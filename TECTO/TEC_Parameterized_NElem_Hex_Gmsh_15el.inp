*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_Gmsh_15el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.2, 0.5
4, 0, 0.2, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.2, 0.5
8, 1, 0.2, 0
9, 1, 0.3, 0
10, 0, 0.3, 0
11, 1, 0.3, 0.5
12, 0, 0.3, 0.5
13, 1, 1.1, 0
14, 0, 1.1, 0
15, 1, 1.1, 0.5
16, 0, 1.1, 0.5
17, 1, 1.2, 0
18, 0, 1.2, 0
19, 1, 1.2, 0.5
20, 0, 1.2, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.2, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.2, 0
28, 1.2, 1.4, 0
29, 2.2, 1.2, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.2, 0
32, 2.2, 1.4, 0
33, 1.2, 1.1, 0.5
34, 2.2, 1.1, 0.5
35, 1.2, 1.1, 0
36, 2.2, 1.1, 0
37, 1.2, 0.3, 0.5
38, 2.2, 0.3, 0.5
39, 1.2, 0.3, 0
40, 2.2, 0.3, 0
41, 1.2, 0.2, 0.5
42, 2.2, 0.2, 0.5
43, 1.2, 0.2, 0
44, 2.2, 0.2, 0
45, 1.2, -2.7755575615629e-17, 0.5
46, 2.2, -2.7755575615629e-17, 0.5
47, 1.2, -2.7755575615629e-17, 0
48, 2.2, -2.7755575615629e-17, 0
49, 2.3, 0.2, 0.5
50, 2.3, -2.7755575615629e-17, 0.5
51, 2.3, 0.2, 0
52, 2.3, -2.7755575615629e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.2, 0.5
56, -0.1, 0.2, 0
57, 0, 0, 0.033333333333333
58, 0, 0, 0.066666666666667
59, 0, 0, 0.1
60, 0, 0, 0.13333333333333
61, 0, 0, 0.16666666666667
62, 0, 0, 0.2
63, 0, 0, 0.23333333333333
64, 0, 0, 0.26666666666667
65, 0, 0, 0.3
66, 0, 0, 0.33333333333333
67, 0, 0, 0.36666666666667
68, 0, 0, 0.4
69, 0, 0, 0.43333333333333
70, 0, 0, 0.46666666666667
71, 0, 0.2, 0.033333333333333
72, 0, 0.2, 0.066666666666667
73, 0, 0.2, 0.1
74, 0, 0.2, 0.13333333333333
75, 0, 0.2, 0.16666666666667
76, 0, 0.2, 0.2
77, 0, 0.2, 0.23333333333333
78, 0, 0.2, 0.26666666666667
79, 0, 0.2, 0.3
80, 0, 0.2, 0.33333333333333
81, 0, 0.2, 0.36666666666667
82, 0, 0.2, 0.4
83, 0, 0.2, 0.43333333333333
84, 0, 0.2, 0.46666666666667
85, 1, 0, 0.033333333333333
86, 1, 0, 0.066666666666667
87, 1, 0, 0.1
88, 1, 0, 0.13333333333333
89, 1, 0, 0.16666666666667
90, 1, 0, 0.2
91, 1, 0, 0.23333333333333
92, 1, 0, 0.26666666666667
93, 1, 0, 0.3
94, 1, 0, 0.33333333333333
95, 1, 0, 0.36666666666667
96, 1, 0, 0.4
97, 1, 0, 0.43333333333333
98, 1, 0, 0.46666666666667
99, 1, 0.2, 0.033333333333333
100, 1, 0.2, 0.066666666666667
101, 1, 0.2, 0.1
102, 1, 0.2, 0.13333333333333
103, 1, 0.2, 0.16666666666667
104, 1, 0.2, 0.2
105, 1, 0.2, 0.23333333333333
106, 1, 0.2, 0.26666666666667
107, 1, 0.2, 0.3
108, 1, 0.2, 0.33333333333333
109, 1, 0.2, 0.36666666666667
110, 1, 0.2, 0.4
111, 1, 0.2, 0.43333333333333
112, 1, 0.2, 0.46666666666667
113, 0.066666666666667, 0, 0
114, 0.13333333333333, 0, 0
115, 0.2, 0, 0
116, 0.26666666666667, 0, 0
117, 0.33333333333333, 0, 0
118, 0.4, 0, 0
119, 0.46666666666667, 0, 0
120, 0.53333333333333, 0, 0
121, 0.6, 0, 0
122, 0.66666666666667, 0, 0
123, 0.73333333333333, 0, 0
124, 0.8, 0, 0
125, 0.86666666666667, 0, 0
126, 0.93333333333333, 0, 0
127, 0.066666666666667, 0, 0.5
128, 0.13333333333333, 0, 0.5
129, 0.2, 0, 0.5
130, 0.26666666666667, 0, 0.5
131, 0.33333333333333, 0, 0.5
132, 0.4, 0, 0.5
133, 0.46666666666667, 0, 0.5
134, 0.53333333333333, 0, 0.5
135, 0.6, 0, 0.5
136, 0.66666666666667, 0, 0.5
137, 0.73333333333333, 0, 0.5
138, 0.8, 0, 0.5
139, 0.86666666666667, 0, 0.5
140, 0.93333333333333, 0, 0.5
141, 0.066666666666667, 0.2, 0
142, 0.13333333333333, 0.2, 0
143, 0.2, 0.2, 0
144, 0.26666666666667, 0.2, 0
145, 0.33333333333333, 0.2, 0
146, 0.4, 0.2, 0
147, 0.46666666666667, 0.2, 0
148, 0.53333333333333, 0.2, 0
149, 0.6, 0.2, 0
150, 0.66666666666667, 0.2, 0
151, 0.73333333333333, 0.2, 0
152, 0.8, 0.2, 0
153, 0.86666666666667, 0.2, 0
154, 0.93333333333333, 0.2, 0
155, 0.066666666666667, 0.2, 0.5
156, 0.13333333333333, 0.2, 0.5
157, 0.2, 0.2, 0.5
158, 0.26666666666667, 0.2, 0.5
159, 0.33333333333333, 0.2, 0.5
160, 0.4, 0.2, 0.5
161, 0.46666666666667, 0.2, 0.5
162, 0.53333333333333, 0.2, 0.5
163, 0.6, 0.2, 0.5
164, 0.66666666666667, 0.2, 0.5
165, 0.73333333333333, 0.2, 0.5
166, 0.8, 0.2, 0.5
167, 0.86666666666667, 0.2, 0.5
168, 0.93333333333333, 0.2, 0.5
169, 0.066666666666667, 0.3, 0
170, 0.13333333333333, 0.3, 0
171, 0.2, 0.3, 0
172, 0.26666666666667, 0.3, 0
173, 0.33333333333333, 0.3, 0
174, 0.4, 0.3, 0
175, 0.46666666666667, 0.3, 0
176, 0.53333333333333, 0.3, 0
177, 0.6, 0.3, 0
178, 0.66666666666667, 0.3, 0
179, 0.73333333333333, 0.3, 0
180, 0.8, 0.3, 0
181, 0.86666666666667, 0.3, 0
182, 0.93333333333333, 0.3, 0
183, 1, 0.3, 0.033333333333333
184, 1, 0.3, 0.066666666666667
185, 1, 0.3, 0.1
186, 1, 0.3, 0.13333333333333
187, 1, 0.3, 0.16666666666667
188, 1, 0.3, 0.2
189, 1, 0.3, 0.23333333333333
190, 1, 0.3, 0.26666666666667
191, 1, 0.3, 0.3
192, 1, 0.3, 0.33333333333333
193, 1, 0.3, 0.36666666666667
194, 1, 0.3, 0.4
195, 1, 0.3, 0.43333333333333
196, 1, 0.3, 0.46666666666667
197, 0.066666666666667, 0.3, 0.5
198, 0.13333333333333, 0.3, 0.5
199, 0.2, 0.3, 0.5
200, 0.26666666666667, 0.3, 0.5
201, 0.33333333333333, 0.3, 0.5
202, 0.4, 0.3, 0.5
203, 0.46666666666667, 0.3, 0.5
204, 0.53333333333333, 0.3, 0.5
205, 0.6, 0.3, 0.5
206, 0.66666666666667, 0.3, 0.5
207, 0.73333333333333, 0.3, 0.5
208, 0.8, 0.3, 0.5
209, 0.86666666666667, 0.3, 0.5
210, 0.93333333333333, 0.3, 0.5
211, 0, 0.3, 0.033333333333333
212, 0, 0.3, 0.066666666666667
213, 0, 0.3, 0.1
214, 0, 0.3, 0.13333333333333
215, 0, 0.3, 0.16666666666667
216, 0, 0.3, 0.2
217, 0, 0.3, 0.23333333333333
218, 0, 0.3, 0.26666666666667
219, 0, 0.3, 0.3
220, 0, 0.3, 0.33333333333333
221, 0, 0.3, 0.36666666666667
222, 0, 0.3, 0.4
223, 0, 0.3, 0.43333333333333
224, 0, 0.3, 0.46666666666667
225, 1, 0.35333333333333, 0
226, 1, 0.40666666666667, 0
227, 1, 0.46, 0
228, 1, 0.51333333333333, 0
229, 1, 0.56666666666667, 0
230, 1, 0.62, 0
231, 1, 0.67333333333333, 0
232, 1, 0.72666666666667, 0
233, 1, 0.78, 0
234, 1, 0.83333333333333, 0
235, 1, 0.88666666666667, 0
236, 1, 0.94, 0
237, 1, 0.99333333333333, 0
238, 1, 1.0466666666667, 0
239, 0, 0.35333333333333, 0
240, 0, 0.40666666666667, 0
241, 0, 0.46, 0
242, 0, 0.51333333333333, 0
243, 0, 0.56666666666667, 0
244, 0, 0.62, 0
245, 0, 0.67333333333333, 0
246, 0, 0.72666666666667, 0
247, 0, 0.78, 0
248, 0, 0.83333333333333, 0
249, 0, 0.88666666666667, 0
250, 0, 0.94, 0
251, 0, 0.99333333333333, 0
252, 0, 1.0466666666667, 0
253, 0.066666666666667, 1.1, 0
254, 0.13333333333333, 1.1, 0
255, 0.2, 1.1, 0
256, 0.26666666666667, 1.1, 0
257, 0.33333333333333, 1.1, 0
258, 0.4, 1.1, 0
259, 0.46666666666667, 1.1, 0
260, 0.53333333333333, 1.1, 0
261, 0.6, 1.1, 0
262, 0.66666666666667, 1.1, 0
263, 0.73333333333333, 1.1, 0
264, 0.8, 1.1, 0
265, 0.86666666666667, 1.1, 0
266, 0.93333333333333, 1.1, 0
267, 1, 0.35333333333333, 0.5
268, 1, 0.40666666666667, 0.5
269, 1, 0.46, 0.5
270, 1, 0.51333333333333, 0.5
271, 1, 0.56666666666667, 0.5
272, 1, 0.62, 0.5
273, 1, 0.67333333333333, 0.5
274, 1, 0.72666666666667, 0.5
275, 1, 0.78, 0.5
276, 1, 0.83333333333333, 0.5
277, 1, 0.88666666666667, 0.5
278, 1, 0.94, 0.5
279, 1, 0.99333333333333, 0.5
280, 1, 1.0466666666667, 0.5
281, 1, 1.1, 0.033333333333333
282, 1, 1.1, 0.066666666666667
283, 1, 1.1, 0.1
284, 1, 1.1, 0.13333333333333
285, 1, 1.1, 0.16666666666667
286, 1, 1.1, 0.2
287, 1, 1.1, 0.23333333333333
288, 1, 1.1, 0.26666666666667
289, 1, 1.1, 0.3
290, 1, 1.1, 0.33333333333333
291, 1, 1.1, 0.36666666666667
292, 1, 1.1, 0.4
293, 1, 1.1, 0.43333333333333
294, 1, 1.1, 0.46666666666667
295, 0, 0.35333333333333, 0.5
296, 0, 0.40666666666667, 0.5
297, 0, 0.46, 0.5
298, 0, 0.51333333333333, 0.5
299, 0, 0.56666666666667, 0.5
300, 0, 0.62, 0.5
301, 0, 0.67333333333333, 0.5
302, 0, 0.72666666666667, 0.5
303, 0, 0.78, 0.5
304, 0, 0.83333333333333, 0.5
305, 0, 0.88666666666667, 0.5
306, 0, 0.94, 0.5
307, 0, 0.99333333333333, 0.5
308, 0, 1.0466666666667, 0.5
309, 0.066666666666667, 1.1, 0.5
310, 0.13333333333333, 1.1, 0.5
311, 0.2, 1.1, 0.5
312, 0.26666666666667, 1.1, 0.5
313, 0.33333333333333, 1.1, 0.5
314, 0.4, 1.1, 0.5
315, 0.46666666666667, 1.1, 0.5
316, 0.53333333333333, 1.1, 0.5
317, 0.6, 1.1, 0.5
318, 0.66666666666667, 1.1, 0.5
319, 0.73333333333333, 1.1, 0.5
320, 0.8, 1.1, 0.5
321, 0.86666666666667, 1.1, 0.5
322, 0.93333333333333, 1.1, 0.5
323, 0, 1.1, 0.033333333333333
324, 0, 1.1, 0.066666666666667
325, 0, 1.1, 0.1
326, 0, 1.1, 0.13333333333333
327, 0, 1.1, 0.16666666666667
328, 0, 1.1, 0.2
329, 0, 1.1, 0.23333333333333
330, 0, 1.1, 0.26666666666667
331, 0, 1.1, 0.3
332, 0, 1.1, 0.33333333333333
333, 0, 1.1, 0.36666666666667
334, 0, 1.1, 0.4
335, 0, 1.1, 0.43333333333333
336, 0, 1.1, 0.46666666666667
337, 0.066666666666667, 1.2, 0
338, 0.13333333333333, 1.2, 0
339, 0.2, 1.2, 0
340, 0.26666666666667, 1.2, 0
341, 0.33333333333333, 1.2, 0
342, 0.4, 1.2, 0
343, 0.46666666666667, 1.2, 0
344, 0.53333333333333, 1.2, 0
345, 0.6, 1.2, 0
346, 0.66666666666667, 1.2, 0
347, 0.73333333333333, 1.2, 0
348, 0.8, 1.2, 0
349, 0.86666666666667, 1.2, 0
350, 0.93333333333333, 1.2, 0
351, 1, 1.2, 0.033333333333333
352, 1, 1.2, 0.066666666666667
353, 1, 1.2, 0.1
354, 1, 1.2, 0.13333333333333
355, 1, 1.2, 0.16666666666667
356, 1, 1.2, 0.2
357, 1, 1.2, 0.23333333333333
358, 1, 1.2, 0.26666666666667
359, 1, 1.2, 0.3
360, 1, 1.2, 0.33333333333333
361, 1, 1.2, 0.36666666666667
362, 1, 1.2, 0.4
363, 1, 1.2, 0.43333333333333
364, 1, 1.2, 0.46666666666667
365, 0.066666666666667, 1.2, 0.5
366, 0.13333333333333, 1.2, 0.5
367, 0.2, 1.2, 0.5
368, 0.26666666666667, 1.2, 0.5
369, 0.33333333333333, 1.2, 0.5
370, 0.4, 1.2, 0.5
371, 0.46666666666667, 1.2, 0.5
372, 0.53333333333333, 1.2, 0.5
373, 0.6, 1.2, 0.5
374, 0.66666666666667, 1.2, 0.5
375, 0.73333333333333, 1.2, 0.5
376, 0.8, 1.2, 0.5
377, 0.86666666666667, 1.2, 0.5
378, 0.93333333333333, 1.2, 0.5
379, 0, 1.2, 0.033333333333333
380, 0, 1.2, 0.066666666666667
381, 0, 1.2, 0.1
382, 0, 1.2, 0.13333333333333
383, 0, 1.2, 0.16666666666667
384, 0, 1.2, 0.2
385, 0, 1.2, 0.23333333333333
386, 0, 1.2, 0.26666666666667
387, 0, 1.2, 0.3
388, 0, 1.2, 0.33333333333333
389, 0, 1.2, 0.36666666666667
390, 0, 1.2, 0.4
391, 0, 1.2, 0.43333333333333
392, 0, 1.2, 0.46666666666667
393, 0.066666666666667, 1.4, 0
394, 0.13333333333333, 1.4, 0
395, 0.2, 1.4, 0
396, 0.26666666666667, 1.4, 0
397, 0.33333333333333, 1.4, 0
398, 0.4, 1.4, 0
399, 0.46666666666667, 1.4, 0
400, 0.53333333333333, 1.4, 0
401, 0.6, 1.4, 0
402, 0.66666666666667, 1.4, 0
403, 0.73333333333333, 1.4, 0
404, 0.8, 1.4, 0
405, 0.86666666666667, 1.4, 0
406, 0.93333333333333, 1.4, 0
407, 1, 1.4, 0.033333333333333
408, 1, 1.4, 0.066666666666667
409, 1, 1.4, 0.1
410, 1, 1.4, 0.13333333333333
411, 1, 1.4, 0.16666666666667
412, 1, 1.4, 0.2
413, 1, 1.4, 0.23333333333333
414, 1, 1.4, 0.26666666666667
415, 1, 1.4, 0.3
416, 1, 1.4, 0.33333333333333
417, 1, 1.4, 0.36666666666667
418, 1, 1.4, 0.4
419, 1, 1.4, 0.43333333333333
420, 1, 1.4, 0.46666666666667
421, 0.066666666666667, 1.4, 0.5
422, 0.13333333333333, 1.4, 0.5
423, 0.2, 1.4, 0.5
424, 0.26666666666667, 1.4, 0.5
425, 0.33333333333333, 1.4, 0.5
426, 0.4, 1.4, 0.5
427, 0.46666666666667, 1.4, 0.5
428, 0.53333333333333, 1.4, 0.5
429, 0.6, 1.4, 0.5
430, 0.66666666666667, 1.4, 0.5
431, 0.73333333333333, 1.4, 0.5
432, 0.8, 1.4, 0.5
433, 0.86666666666667, 1.4, 0.5
434, 0.93333333333333, 1.4, 0.5
435, 0, 1.4, 0.033333333333333
436, 0, 1.4, 0.066666666666667
437, 0, 1.4, 0.1
438, 0, 1.4, 0.13333333333333
439, 0, 1.4, 0.16666666666667
440, 0, 1.4, 0.2
441, 0, 1.4, 0.23333333333333
442, 0, 1.4, 0.26666666666667
443, 0, 1.4, 0.3
444, 0, 1.4, 0.33333333333333
445, 0, 1.4, 0.36666666666667
446, 0, 1.4, 0.4
447, 0, 1.4, 0.43333333333333
448, 0, 1.4, 0.46666666666667
449, 1.2, 1.2, 0.033333333333333
450, 1.2, 1.2, 0.066666666666667
451, 1.2, 1.2, 0.1
452, 1.2, 1.2, 0.13333333333333
453, 1.2, 1.2, 0.16666666666667
454, 1.2, 1.2, 0.2
455, 1.2, 1.2, 0.23333333333333
456, 1.2, 1.2, 0.26666666666667
457, 1.2, 1.2, 0.3
458, 1.2, 1.2, 0.33333333333333
459, 1.2, 1.2, 0.36666666666667
460, 1.2, 1.2, 0.4
461, 1.2, 1.2, 0.43333333333333
462, 1.2, 1.2, 0.46666666666667
463, 1.2, 1.4, 0.033333333333333
464, 1.2, 1.4, 0.066666666666667
465, 1.2, 1.4, 0.1
466, 1.2, 1.4, 0.13333333333333
467, 1.2, 1.4, 0.16666666666667
468, 1.2, 1.4, 0.2
469, 1.2, 1.4, 0.23333333333333
470, 1.2, 1.4, 0.26666666666667
471, 1.2, 1.4, 0.3
472, 1.2, 1.4, 0.33333333333333
473, 1.2, 1.4, 0.36666666666667
474, 1.2, 1.4, 0.4
475, 1.2, 1.4, 0.43333333333333
476, 1.2, 1.4, 0.46666666666667
477, 1.2666666666667, 1.2, 0.5
478, 1.3333333333333, 1.2, 0.5
479, 1.4, 1.2, 0.5
480, 1.4666666666667, 1.2, 0.5
481, 1.5333333333333, 1.2, 0.5
482, 1.6, 1.2, 0.5
483, 1.6666666666667, 1.2, 0.5
484, 1.7333333333333, 1.2, 0.5
485, 1.8, 1.2, 0.5
486, 1.8666666666667, 1.2, 0.5
487, 1.9333333333333, 1.2, 0.5
488, 2, 1.2, 0.5
489, 2.0666666666667, 1.2, 0.5
490, 2.1333333333333, 1.2, 0.5
491, 1.2666666666667, 1.4, 0.5
492, 1.3333333333333, 1.4, 0.5
493, 1.4, 1.4, 0.5
494, 1.4666666666667, 1.4, 0.5
495, 1.5333333333333, 1.4, 0.5
496, 1.6, 1.4, 0.5
497, 1.6666666666667, 1.4, 0.5
498, 1.7333333333333, 1.4, 0.5
499, 1.8, 1.4, 0.5
500, 1.8666666666667, 1.4, 0.5
501, 1.9333333333333, 1.4, 0.5
502, 2, 1.4, 0.5
503, 2.0666666666667, 1.4, 0.5
504, 2.1333333333333, 1.4, 0.5
505, 1.2666666666667, 1.2, 0
506, 1.3333333333333, 1.2, 0
507, 1.4, 1.2, 0
508, 1.4666666666667, 1.2, 0
509, 1.5333333333333, 1.2, 0
510, 1.6, 1.2, 0
511, 1.6666666666667, 1.2, 0
512, 1.7333333333333, 1.2, 0
513, 1.8, 1.2, 0
514, 1.8666666666667, 1.2, 0
515, 1.9333333333333, 1.2, 0
516, 2, 1.2, 0
517, 2.0666666666667, 1.2, 0
518, 2.1333333333333, 1.2, 0
519, 1.2666666666667, 1.4, 0
520, 1.3333333333333, 1.4, 0
521, 1.4, 1.4, 0
522, 1.4666666666667, 1.4, 0
523, 1.5333333333333, 1.4, 0
524, 1.6, 1.4, 0
525, 1.6666666666667, 1.4, 0
526, 1.7333333333333, 1.4, 0
527, 1.8, 1.4, 0
528, 1.8666666666667, 1.4, 0
529, 1.9333333333333, 1.4, 0
530, 2, 1.4, 0
531, 2.0666666666667, 1.4, 0
532, 2.1333333333333, 1.4, 0
533, 2.2, 1.2, 0.033333333333333
534, 2.2, 1.2, 0.066666666666667
535, 2.2, 1.2, 0.1
536, 2.2, 1.2, 0.13333333333333
537, 2.2, 1.2, 0.16666666666667
538, 2.2, 1.2, 0.2
539, 2.2, 1.2, 0.23333333333333
540, 2.2, 1.2, 0.26666666666667
541, 2.2, 1.2, 0.3
542, 2.2, 1.2, 0.33333333333333
543, 2.2, 1.2, 0.36666666666667
544, 2.2, 1.2, 0.4
545, 2.2, 1.2, 0.43333333333333
546, 2.2, 1.2, 0.46666666666667
547, 2.2, 1.4, 0.033333333333333
548, 2.2, 1.4, 0.066666666666667
549, 2.2, 1.4, 0.1
550, 2.2, 1.4, 0.13333333333333
551, 2.2, 1.4, 0.16666666666667
552, 2.2, 1.4, 0.2
553, 2.2, 1.4, 0.23333333333333
554, 2.2, 1.4, 0.26666666666667
555, 2.2, 1.4, 0.3
556, 2.2, 1.4, 0.33333333333333
557, 2.2, 1.4, 0.36666666666667
558, 2.2, 1.4, 0.4
559, 2.2, 1.4, 0.43333333333333
560, 2.2, 1.4, 0.46666666666667
561, 1.2666666666667, 1.1, 0.5
562, 1.3333333333333, 1.1, 0.5
563, 1.4, 1.1, 0.5
564, 1.4666666666667, 1.1, 0.5
565, 1.5333333333333, 1.1, 0.5
566, 1.6, 1.1, 0.5
567, 1.6666666666667, 1.1, 0.5
568, 1.7333333333333, 1.1, 0.5
569, 1.8, 1.1, 0.5
570, 1.8666666666667, 1.1, 0.5
571, 1.9333333333333, 1.1, 0.5
572, 2, 1.1, 0.5
573, 2.0666666666667, 1.1, 0.5
574, 2.1333333333333, 1.1, 0.5
575, 1.2666666666667, 1.1, 0
576, 1.3333333333333, 1.1, 0
577, 1.4, 1.1, 0
578, 1.4666666666667, 1.1, 0
579, 1.5333333333333, 1.1, 0
580, 1.6, 1.1, 0
581, 1.6666666666667, 1.1, 0
582, 1.7333333333333, 1.1, 0
583, 1.8, 1.1, 0
584, 1.8666666666667, 1.1, 0
585, 1.9333333333333, 1.1, 0
586, 2, 1.1, 0
587, 2.0666666666667, 1.1, 0
588, 2.1333333333333, 1.1, 0
589, 1.2, 1.1, 0.033333333333333
590, 1.2, 1.1, 0.066666666666667
591, 1.2, 1.1, 0.1
592, 1.2, 1.1, 0.13333333333333
593, 1.2, 1.1, 0.16666666666667
594, 1.2, 1.1, 0.2
595, 1.2, 1.1, 0.23333333333333
596, 1.2, 1.1, 0.26666666666667
597, 1.2, 1.1, 0.3
598, 1.2, 1.1, 0.33333333333333
599, 1.2, 1.1, 0.36666666666667
600, 1.2, 1.1, 0.4
601, 1.2, 1.1, 0.43333333333333
602, 1.2, 1.1, 0.46666666666667
603, 2.2, 1.1, 0.033333333333333
604, 2.2, 1.1, 0.066666666666667
605, 2.2, 1.1, 0.1
606, 2.2, 1.1, 0.13333333333333
607, 2.2, 1.1, 0.16666666666667
608, 2.2, 1.1, 0.2
609, 2.2, 1.1, 0.23333333333333
610, 2.2, 1.1, 0.26666666666667
611, 2.2, 1.1, 0.3
612, 2.2, 1.1, 0.33333333333333
613, 2.2, 1.1, 0.36666666666667
614, 2.2, 1.1, 0.4
615, 2.2, 1.1, 0.43333333333333
616, 2.2, 1.1, 0.46666666666667
617, 1.2, 1.0466666666667, 0.5
618, 1.2, 0.99333333333333, 0.5
619, 1.2, 0.94, 0.5
620, 1.2, 0.88666666666667, 0.5
621, 1.2, 0.83333333333333, 0.5
622, 1.2, 0.78, 0.5
623, 1.2, 0.72666666666667, 0.5
624, 1.2, 0.67333333333333, 0.5
625, 1.2, 0.62, 0.5
626, 1.2, 0.56666666666667, 0.5
627, 1.2, 0.51333333333333, 0.5
628, 1.2, 0.46, 0.5
629, 1.2, 0.40666666666667, 0.5
630, 1.2, 0.35333333333333, 0.5
631, 2.2, 1.0466666666667, 0.5
632, 2.2, 0.99333333333333, 0.5
633, 2.2, 0.94, 0.5
634, 2.2, 0.88666666666667, 0.5
635, 2.2, 0.83333333333333, 0.5
636, 2.2, 0.78, 0.5
637, 2.2, 0.72666666666667, 0.5
638, 2.2, 0.67333333333333, 0.5
639, 2.2, 0.62, 0.5
640, 2.2, 0.56666666666667, 0.5
641, 2.2, 0.51333333333333, 0.5
642, 2.2, 0.46, 0.5
643, 2.2, 0.40666666666667, 0.5
644, 2.2, 0.35333333333333, 0.5
645, 1.2666666666667, 0.3, 0.5
646, 1.3333333333333, 0.3, 0.5
647, 1.4, 0.3, 0.5
648, 1.4666666666667, 0.3, 0.5
649, 1.5333333333333, 0.3, 0.5
650, 1.6, 0.3, 0.5
651, 1.6666666666667, 0.3, 0.5
652, 1.7333333333333, 0.3, 0.5
653, 1.8, 0.3, 0.5
654, 1.8666666666667, 0.3, 0.5
655, 1.9333333333333, 0.3, 0.5
656, 2, 0.3, 0.5
657, 2.0666666666667, 0.3, 0.5
658, 2.1333333333333, 0.3, 0.5
659, 1.2, 1.0466666666667, 0
660, 1.2, 0.99333333333333, 0
661, 1.2, 0.94, 0
662, 1.2, 0.88666666666667, 0
663, 1.2, 0.83333333333333, 0
664, 1.2, 0.78, 0
665, 1.2, 0.72666666666667, 0
666, 1.2, 0.67333333333333, 0
667, 1.2, 0.62, 0
668, 1.2, 0.56666666666667, 0
669, 1.2, 0.51333333333333, 0
670, 1.2, 0.46, 0
671, 1.2, 0.40666666666667, 0
672, 1.2, 0.35333333333333, 0
673, 2.2, 1.0466666666667, 0
674, 2.2, 0.99333333333333, 0
675, 2.2, 0.94, 0
676, 2.2, 0.88666666666667, 0
677, 2.2, 0.83333333333333, 0
678, 2.2, 0.78, 0
679, 2.2, 0.72666666666667, 0
680, 2.2, 0.67333333333333, 0
681, 2.2, 0.62, 0
682, 2.2, 0.56666666666667, 0
683, 2.2, 0.51333333333333, 0
684, 2.2, 0.46, 0
685, 2.2, 0.40666666666667, 0
686, 2.2, 0.35333333333333, 0
687, 1.2666666666667, 0.3, 0
688, 1.3333333333333, 0.3, 0
689, 1.4, 0.3, 0
690, 1.4666666666667, 0.3, 0
691, 1.5333333333333, 0.3, 0
692, 1.6, 0.3, 0
693, 1.6666666666667, 0.3, 0
694, 1.7333333333333, 0.3, 0
695, 1.8, 0.3, 0
696, 1.8666666666667, 0.3, 0
697, 1.9333333333333, 0.3, 0
698, 2, 0.3, 0
699, 2.0666666666667, 0.3, 0
700, 2.1333333333333, 0.3, 0
701, 1.2, 0.3, 0.033333333333333
702, 1.2, 0.3, 0.066666666666667
703, 1.2, 0.3, 0.1
704, 1.2, 0.3, 0.13333333333333
705, 1.2, 0.3, 0.16666666666667
706, 1.2, 0.3, 0.2
707, 1.2, 0.3, 0.23333333333333
708, 1.2, 0.3, 0.26666666666667
709, 1.2, 0.3, 0.3
710, 1.2, 0.3, 0.33333333333333
711, 1.2, 0.3, 0.36666666666667
712, 1.2, 0.3, 0.4
713, 1.2, 0.3, 0.43333333333333
714, 1.2, 0.3, 0.46666666666667
715, 2.2, 0.3, 0.033333333333333
716, 2.2, 0.3, 0.066666666666667
717, 2.2, 0.3, 0.1
718, 2.2, 0.3, 0.13333333333333
719, 2.2, 0.3, 0.16666666666667
720, 2.2, 0.3, 0.2
721, 2.2, 0.3, 0.23333333333333
722, 2.2, 0.3, 0.26666666666667
723, 2.2, 0.3, 0.3
724, 2.2, 0.3, 0.33333333333333
725, 2.2, 0.3, 0.36666666666667
726, 2.2, 0.3, 0.4
727, 2.2, 0.3, 0.43333333333333
728, 2.2, 0.3, 0.46666666666667
729, 1.2666666666667, 0.2, 0.5
730, 1.3333333333333, 0.2, 0.5
731, 1.4, 0.2, 0.5
732, 1.4666666666667, 0.2, 0.5
733, 1.5333333333333, 0.2, 0.5
734, 1.6, 0.2, 0.5
735, 1.6666666666667, 0.2, 0.5
736, 1.7333333333333, 0.2, 0.5
737, 1.8, 0.2, 0.5
738, 1.8666666666667, 0.2, 0.5
739, 1.9333333333333, 0.2, 0.5
740, 2, 0.2, 0.5
741, 2.0666666666667, 0.2, 0.5
742, 2.1333333333333, 0.2, 0.5
743, 1.2666666666667, 0.2, 0
744, 1.3333333333333, 0.2, 0
745, 1.4, 0.2, 0
746, 1.4666666666667, 0.2, 0
747, 1.5333333333333, 0.2, 0
748, 1.6, 0.2, 0
749, 1.6666666666667, 0.2, 0
750, 1.7333333333333, 0.2, 0
751, 1.8, 0.2, 0
752, 1.8666666666667, 0.2, 0
753, 1.9333333333333, 0.2, 0
754, 2, 0.2, 0
755, 2.0666666666667, 0.2, 0
756, 2.1333333333333, 0.2, 0
757, 1.2, 0.2, 0.033333333333333
758, 1.2, 0.2, 0.066666666666667
759, 1.2, 0.2, 0.1
760, 1.2, 0.2, 0.13333333333333
761, 1.2, 0.2, 0.16666666666667
762, 1.2, 0.2, 0.2
763, 1.2, 0.2, 0.23333333333333
764, 1.2, 0.2, 0.26666666666667
765, 1.2, 0.2, 0.3
766, 1.2, 0.2, 0.33333333333333
767, 1.2, 0.2, 0.36666666666667
768, 1.2, 0.2, 0.4
769, 1.2, 0.2, 0.43333333333333
770, 1.2, 0.2, 0.46666666666667
771, 2.2, 0.2, 0.033333333333333
772, 2.2, 0.2, 0.066666666666667
773, 2.2, 0.2, 0.1
774, 2.2, 0.2, 0.13333333333333
775, 2.2, 0.2, 0.16666666666667
776, 2.2, 0.2, 0.2
777, 2.2, 0.2, 0.23333333333333
778, 2.2, 0.2, 0.26666666666667
779, 2.2, 0.2, 0.3
780, 2.2, 0.2, 0.33333333333333
781, 2.2, 0.2, 0.36666666666667
782, 2.2, 0.2, 0.4
783, 2.2, 0.2, 0.43333333333333
784, 2.2, 0.2, 0.46666666666667
785, 1.2666666666667, -1.942890293094e-16, 0.5
786, 1.3333333333333, -1.942890293094e-16, 0.5
787, 1.4, -1.942890293094e-16, 0.5
788, 1.4666666666667, -1.942890293094e-16, 0.5
789, 1.5333333333333, -1.942890293094e-16, 0.5
790, 1.6, -1.942890293094e-16, 0.5
791, 1.6666666666667, -1.942890293094e-16, 0.5
792, 1.7333333333333, -1.942890293094e-16, 0.5
793, 1.8, -1.942890293094e-16, 0.5
794, 1.8666666666667, -1.942890293094e-16, 0.5
795, 1.9333333333333, -1.942890293094e-16, 0.5
796, 2, -1.942890293094e-16, 0.5
797, 2.0666666666667, -1.942890293094e-16, 0.5
798, 2.1333333333333, -1.942890293094e-16, 0.5
799, 1.2666666666667, -1.942890293094e-16, 0
800, 1.3333333333333, -1.942890293094e-16, 0
801, 1.4, -1.942890293094e-16, 0
802, 1.4666666666667, -1.942890293094e-16, 0
803, 1.5333333333333, -1.942890293094e-16, 0
804, 1.6, -1.942890293094e-16, 0
805, 1.6666666666667, -1.942890293094e-16, 0
806, 1.7333333333333, -1.942890293094e-16, 0
807, 1.8, -1.942890293094e-16, 0
808, 1.8666666666667, -1.942890293094e-16, 0
809, 1.9333333333333, -1.942890293094e-16, 0
810, 2, -1.942890293094e-16, 0
811, 2.0666666666667, -1.942890293094e-16, 0
812, 2.1333333333333, -1.942890293094e-16, 0
813, 1.2, 2.7755575615629e-17, 0.033333333333333
814, 1.2, 2.7755575615629e-17, 0.066666666666667
815, 1.2, 2.7755575615629e-17, 0.1
816, 1.2, 2.7755575615629e-17, 0.13333333333333
817, 1.2, 2.7755575615629e-17, 0.16666666666667
818, 1.2, 2.7755575615629e-17, 0.2
819, 1.2, 2.7755575615629e-17, 0.23333333333333
820, 1.2, 2.7755575615629e-17, 0.26666666666667
821, 1.2, 2.7755575615629e-17, 0.3
822, 1.2, 2.7755575615629e-17, 0.33333333333333
823, 1.2, 2.7755575615629e-17, 0.36666666666667
824, 1.2, 2.7755575615629e-17, 0.4
825, 1.2, 2.7755575615629e-17, 0.43333333333333
826, 1.2, 2.7755575615629e-17, 0.46666666666667
827, 2.2, 2.7755575615629e-17, 0.033333333333333
828, 2.2, 2.7755575615629e-17, 0.066666666666667
829, 2.2, 2.7755575615629e-17, 0.1
830, 2.2, 2.7755575615629e-17, 0.13333333333333
831, 2.2, 2.7755575615629e-17, 0.16666666666667
832, 2.2, 2.7755575615629e-17, 0.2
833, 2.2, 2.7755575615629e-17, 0.23333333333333
834, 2.2, 2.7755575615629e-17, 0.26666666666667
835, 2.2, 2.7755575615629e-17, 0.3
836, 2.2, 2.7755575615629e-17, 0.33333333333333
837, 2.2, 2.7755575615629e-17, 0.36666666666667
838, 2.2, 2.7755575615629e-17, 0.4
839, 2.2, 2.7755575615629e-17, 0.43333333333333
840, 2.2, 2.7755575615629e-17, 0.46666666666667
841, 2.3, 0.2, 0.033333333333333
842, 2.3, 0.2, 0.066666666666667
843, 2.3, 0.2, 0.1
844, 2.3, 0.2, 0.13333333333333
845, 2.3, 0.2, 0.16666666666667
846, 2.3, 0.2, 0.2
847, 2.3, 0.2, 0.23333333333333
848, 2.3, 0.2, 0.26666666666667
849, 2.3, 0.2, 0.3
850, 2.3, 0.2, 0.33333333333333
851, 2.3, 0.2, 0.36666666666667
852, 2.3, 0.2, 0.4
853, 2.3, 0.2, 0.43333333333333
854, 2.3, 0.2, 0.46666666666667
855, 2.3, 2.7755575615629e-17, 0.033333333333333
856, 2.3, 2.7755575615629e-17, 0.066666666666667
857, 2.3, 2.7755575615629e-17, 0.1
858, 2.3, 2.7755575615629e-17, 0.13333333333333
859, 2.3, 2.7755575615629e-17, 0.16666666666667
860, 2.3, 2.7755575615629e-17, 0.2
861, 2.3, 2.7755575615629e-17, 0.23333333333333
862, 2.3, 2.7755575615629e-17, 0.26666666666667
863, 2.3, 2.7755575615629e-17, 0.3
864, 2.3, 2.7755575615629e-17, 0.33333333333333
865, 2.3, 2.7755575615629e-17, 0.36666666666667
866, 2.3, 2.7755575615629e-17, 0.4
867, 2.3, 2.7755575615629e-17, 0.43333333333333
868, 2.3, 2.7755575615629e-17, 0.46666666666667
869, -0.1, 0, 0.033333333333333
870, -0.1, 0, 0.066666666666667
871, -0.1, 0, 0.1
872, -0.1, 0, 0.13333333333333
873, -0.1, 0, 0.16666666666667
874, -0.1, 0, 0.2
875, -0.1, 0, 0.23333333333333
876, -0.1, 0, 0.26666666666667
877, -0.1, 0, 0.3
878, -0.1, 0, 0.33333333333333
879, -0.1, 0, 0.36666666666667
880, -0.1, 0, 0.4
881, -0.1, 0, 0.43333333333333
882, -0.1, 0, 0.46666666666667
883, -0.1, 0.2, 0.033333333333333
884, -0.1, 0.2, 0.066666666666667
885, -0.1, 0.2, 0.1
886, -0.1, 0.2, 0.13333333333333
887, -0.1, 0.2, 0.16666666666667
888, -0.1, 0.2, 0.2
889, -0.1, 0.2, 0.23333333333333
890, -0.1, 0.2, 0.26666666666667
891, -0.1, 0.2, 0.3
892, -0.1, 0.2, 0.33333333333333
893, -0.1, 0.2, 0.36666666666667
894, -0.1, 0.2, 0.4
895, -0.1, 0.2, 0.43333333333333
896, -0.1, 0.2, 0.46666666666667
897, 0.066666666666667, 0, 0.033333333333333
898, 0.066666666666667, 0, 0.066666666666667
899, 0.066666666666667, 0, 0.1
900, 0.066666666666667, 0, 0.13333333333333
901, 0.066666666666667, 0, 0.16666666666667
902, 0.066666666666667, 0, 0.2
903, 0.066666666666667, 0, 0.23333333333333
904, 0.066666666666667, 0, 0.26666666666667
905, 0.066666666666667, 0, 0.3
906, 0.066666666666667, 0, 0.33333333333333
907, 0.066666666666667, 0, 0.36666666666667
908, 0.066666666666667, 0, 0.4
909, 0.066666666666667, 0, 0.43333333333333
910, 0.066666666666667, 0, 0.46666666666667
911, 0.13333333333333, 0, 0.033333333333333
912, 0.13333333333333, 0, 0.066666666666667
913, 0.13333333333333, 0, 0.1
914, 0.13333333333333, 0, 0.13333333333333
915, 0.13333333333333, 0, 0.16666666666667
916, 0.13333333333333, 0, 0.2
917, 0.13333333333333, 0, 0.23333333333333
918, 0.13333333333333, 0, 0.26666666666667
919, 0.13333333333333, 0, 0.3
920, 0.13333333333333, 0, 0.33333333333333
921, 0.13333333333333, 0, 0.36666666666667
922, 0.13333333333333, 0, 0.4
923, 0.13333333333333, 0, 0.43333333333333
924, 0.13333333333333, 0, 0.46666666666667
925, 0.2, 0, 0.033333333333333
926, 0.2, 0, 0.066666666666667
927, 0.2, 0, 0.1
928, 0.2, 0, 0.13333333333333
929, 0.2, 0, 0.16666666666667
930, 0.2, 0, 0.2
931, 0.2, 0, 0.23333333333333
932, 0.2, 0, 0.26666666666667
933, 0.2, 0, 0.3
934, 0.2, 0, 0.33333333333333
935, 0.2, 0, 0.36666666666667
936, 0.2, 0, 0.4
937, 0.2, 0, 0.43333333333333
938, 0.2, 0, 0.46666666666667
939, 0.26666666666667, 0, 0.033333333333333
940, 0.26666666666667, 0, 0.066666666666667
941, 0.26666666666667, 0, 0.1
942, 0.26666666666667, 0, 0.13333333333333
943, 0.26666666666667, 0, 0.16666666666667
944, 0.26666666666667, 0, 0.2
945, 0.26666666666667, 0, 0.23333333333333
946, 0.26666666666667, 0, 0.26666666666667
947, 0.26666666666667, 0, 0.3
948, 0.26666666666667, 0, 0.33333333333333
949, 0.26666666666667, 0, 0.36666666666667
950, 0.26666666666667, 0, 0.4
951, 0.26666666666667, 0, 0.43333333333333
952, 0.26666666666667, 0, 0.46666666666667
953, 0.33333333333333, 0, 0.033333333333333
954, 0.33333333333333, 0, 0.066666666666667
955, 0.33333333333333, 0, 0.1
956, 0.33333333333333, 0, 0.13333333333333
957, 0.33333333333333, 0, 0.16666666666667
958, 0.33333333333333, 0, 0.2
959, 0.33333333333333, 0, 0.23333333333333
960, 0.33333333333333, 0, 0.26666666666667
961, 0.33333333333333, 0, 0.3
962, 0.33333333333333, 0, 0.33333333333333
963, 0.33333333333333, 0, 0.36666666666667
964, 0.33333333333333, 0, 0.4
965, 0.33333333333333, 0, 0.43333333333333
966, 0.33333333333333, 0, 0.46666666666667
967, 0.4, 0, 0.033333333333333
968, 0.4, 0, 0.066666666666667
969, 0.4, 0, 0.1
970, 0.4, 0, 0.13333333333333
971, 0.4, 0, 0.16666666666667
972, 0.4, 0, 0.2
973, 0.4, 0, 0.23333333333333
974, 0.4, 0, 0.26666666666667
975, 0.4, 0, 0.3
976, 0.4, 0, 0.33333333333333
977, 0.4, 0, 0.36666666666667
978, 0.4, 0, 0.4
979, 0.4, 0, 0.43333333333333
980, 0.4, 0, 0.46666666666667
981, 0.46666666666667, 0, 0.033333333333333
982, 0.46666666666667, 0, 0.066666666666667
983, 0.46666666666667, 0, 0.1
984, 0.46666666666667, 0, 0.13333333333333
985, 0.46666666666667, 0, 0.16666666666667
986, 0.46666666666667, 0, 0.2
987, 0.46666666666667, 0, 0.23333333333333
988, 0.46666666666667, 0, 0.26666666666667
989, 0.46666666666667, 0, 0.3
990, 0.46666666666667, 0, 0.33333333333333
991, 0.46666666666667, 0, 0.36666666666667
992, 0.46666666666667, 0, 0.4
993, 0.46666666666667, 0, 0.43333333333333
994, 0.46666666666667, 0, 0.46666666666667
995, 0.53333333333333, 0, 0.033333333333333
996, 0.53333333333333, 0, 0.066666666666667
997, 0.53333333333333, 0, 0.1
998, 0.53333333333333, 0, 0.13333333333333
999, 0.53333333333333, 0, 0.16666666666667
1000, 0.53333333333333, 0, 0.2
1001, 0.53333333333333, 0, 0.23333333333333
1002, 0.53333333333333, 0, 0.26666666666667
1003, 0.53333333333333, 0, 0.3
1004, 0.53333333333333, 0, 0.33333333333333
1005, 0.53333333333333, 0, 0.36666666666667
1006, 0.53333333333333, 0, 0.4
1007, 0.53333333333333, 0, 0.43333333333333
1008, 0.53333333333333, 0, 0.46666666666667
1009, 0.6, 0, 0.033333333333333
1010, 0.6, 0, 0.066666666666667
1011, 0.6, 0, 0.1
1012, 0.6, 0, 0.13333333333333
1013, 0.6, 0, 0.16666666666667
1014, 0.6, 0, 0.2
1015, 0.6, 0, 0.23333333333333
1016, 0.6, 0, 0.26666666666667
1017, 0.6, 0, 0.3
1018, 0.6, 0, 0.33333333333333
1019, 0.6, 0, 0.36666666666667
1020, 0.6, 0, 0.4
1021, 0.6, 0, 0.43333333333333
1022, 0.6, 0, 0.46666666666667
1023, 0.66666666666667, 0, 0.033333333333333
1024, 0.66666666666667, 0, 0.066666666666667
1025, 0.66666666666667, 0, 0.1
1026, 0.66666666666667, 0, 0.13333333333333
1027, 0.66666666666667, 0, 0.16666666666667
1028, 0.66666666666667, 0, 0.2
1029, 0.66666666666667, 0, 0.23333333333333
1030, 0.66666666666667, 0, 0.26666666666667
1031, 0.66666666666667, 0, 0.3
1032, 0.66666666666667, 0, 0.33333333333333
1033, 0.66666666666667, 0, 0.36666666666667
1034, 0.66666666666667, 0, 0.4
1035, 0.66666666666667, 0, 0.43333333333333
1036, 0.66666666666667, 0, 0.46666666666667
1037, 0.73333333333333, 0, 0.033333333333333
1038, 0.73333333333333, 0, 0.066666666666667
1039, 0.73333333333333, 0, 0.1
1040, 0.73333333333333, 0, 0.13333333333333
1041, 0.73333333333333, 0, 0.16666666666667
1042, 0.73333333333333, 0, 0.2
1043, 0.73333333333333, 0, 0.23333333333333
1044, 0.73333333333333, 0, 0.26666666666667
1045, 0.73333333333333, 0, 0.3
1046, 0.73333333333333, 0, 0.33333333333333
1047, 0.73333333333333, 0, 0.36666666666667
1048, 0.73333333333333, 0, 0.4
1049, 0.73333333333333, 0, 0.43333333333333
1050, 0.73333333333333, 0, 0.46666666666667
1051, 0.8, 0, 0.033333333333333
1052, 0.8, 0, 0.066666666666667
1053, 0.8, 0, 0.1
1054, 0.8, 0, 0.13333333333333
1055, 0.8, 0, 0.16666666666667
1056, 0.8, 0, 0.2
1057, 0.8, 0, 0.23333333333333
1058, 0.8, 0, 0.26666666666667
1059, 0.8, 0, 0.3
1060, 0.8, 0, 0.33333333333333
1061, 0.8, 0, 0.36666666666667
1062, 0.8, 0, 0.4
1063, 0.8, 0, 0.43333333333333
1064, 0.8, 0, 0.46666666666667
1065, 0.86666666666667, 0, 0.033333333333333
1066, 0.86666666666667, 0, 0.066666666666667
1067, 0.86666666666667, 0, 0.1
1068, 0.86666666666667, 0, 0.13333333333333
1069, 0.86666666666667, 0, 0.16666666666667
1070, 0.86666666666667, 0, 0.2
1071, 0.86666666666667, 0, 0.23333333333333
1072, 0.86666666666667, 0, 0.26666666666667
1073, 0.86666666666667, 0, 0.3
1074, 0.86666666666667, 0, 0.33333333333333
1075, 0.86666666666667, 0, 0.36666666666667
1076, 0.86666666666667, 0, 0.4
1077, 0.86666666666667, 0, 0.43333333333333
1078, 0.86666666666667, 0, 0.46666666666667
1079, 0.93333333333333, 0, 0.033333333333333
1080, 0.93333333333333, 0, 0.066666666666667
1081, 0.93333333333333, 0, 0.1
1082, 0.93333333333333, 0, 0.13333333333333
1083, 0.93333333333333, 0, 0.16666666666667
1084, 0.93333333333333, 0, 0.2
1085, 0.93333333333333, 0, 0.23333333333333
1086, 0.93333333333333, 0, 0.26666666666667
1087, 0.93333333333333, 0, 0.3
1088, 0.93333333333333, 0, 0.33333333333333
1089, 0.93333333333333, 0, 0.36666666666667
1090, 0.93333333333333, 0, 0.4
1091, 0.93333333333333, 0, 0.43333333333333
1092, 0.93333333333333, 0, 0.46666666666667
1093, 0.066666666666667, 0.2, 0.033333333333333
1094, 0.066666666666667, 0.2, 0.066666666666667
1095, 0.066666666666667, 0.2, 0.1
1096, 0.066666666666667, 0.2, 0.13333333333333
1097, 0.066666666666667, 0.2, 0.16666666666667
1098, 0.066666666666667, 0.2, 0.2
1099, 0.066666666666667, 0.2, 0.23333333333333
1100, 0.066666666666667, 0.2, 0.26666666666667
1101, 0.066666666666667, 0.2, 0.3
1102, 0.066666666666667, 0.2, 0.33333333333333
1103, 0.066666666666667, 0.2, 0.36666666666667
1104, 0.066666666666667, 0.2, 0.4
1105, 0.066666666666667, 0.2, 0.43333333333333
1106, 0.066666666666667, 0.2, 0.46666666666667
1107, 0.13333333333333, 0.2, 0.033333333333333
1108, 0.13333333333333, 0.2, 0.066666666666667
1109, 0.13333333333333, 0.2, 0.1
1110, 0.13333333333333, 0.2, 0.13333333333333
1111, 0.13333333333333, 0.2, 0.16666666666667
1112, 0.13333333333333, 0.2, 0.2
1113, 0.13333333333333, 0.2, 0.23333333333333
1114, 0.13333333333333, 0.2, 0.26666666666667
1115, 0.13333333333333, 0.2, 0.3
1116, 0.13333333333333, 0.2, 0.33333333333333
1117, 0.13333333333333, 0.2, 0.36666666666667
1118, 0.13333333333333, 0.2, 0.4
1119, 0.13333333333333, 0.2, 0.43333333333333
1120, 0.13333333333333, 0.2, 0.46666666666667
1121, 0.2, 0.2, 0.033333333333333
1122, 0.2, 0.2, 0.066666666666667
1123, 0.2, 0.2, 0.1
1124, 0.2, 0.2, 0.13333333333333
1125, 0.2, 0.2, 0.16666666666667
1126, 0.2, 0.2, 0.2
1127, 0.2, 0.2, 0.23333333333333
1128, 0.2, 0.2, 0.26666666666667
1129, 0.2, 0.2, 0.3
1130, 0.2, 0.2, 0.33333333333333
1131, 0.2, 0.2, 0.36666666666667
1132, 0.2, 0.2, 0.4
1133, 0.2, 0.2, 0.43333333333333
1134, 0.2, 0.2, 0.46666666666667
1135, 0.26666666666667, 0.2, 0.033333333333333
1136, 0.26666666666667, 0.2, 0.066666666666667
1137, 0.26666666666667, 0.2, 0.1
1138, 0.26666666666667, 0.2, 0.13333333333333
1139, 0.26666666666667, 0.2, 0.16666666666667
1140, 0.26666666666667, 0.2, 0.2
1141, 0.26666666666667, 0.2, 0.23333333333333
1142, 0.26666666666667, 0.2, 0.26666666666667
1143, 0.26666666666667, 0.2, 0.3
1144, 0.26666666666667, 0.2, 0.33333333333333
1145, 0.26666666666667, 0.2, 0.36666666666667
1146, 0.26666666666667, 0.2, 0.4
1147, 0.26666666666667, 0.2, 0.43333333333333
1148, 0.26666666666667, 0.2, 0.46666666666667
1149, 0.33333333333333, 0.2, 0.033333333333333
1150, 0.33333333333333, 0.2, 0.066666666666667
1151, 0.33333333333333, 0.2, 0.1
1152, 0.33333333333333, 0.2, 0.13333333333333
1153, 0.33333333333333, 0.2, 0.16666666666667
1154, 0.33333333333333, 0.2, 0.2
1155, 0.33333333333333, 0.2, 0.23333333333333
1156, 0.33333333333333, 0.2, 0.26666666666667
1157, 0.33333333333333, 0.2, 0.3
1158, 0.33333333333333, 0.2, 0.33333333333333
1159, 0.33333333333333, 0.2, 0.36666666666667
1160, 0.33333333333333, 0.2, 0.4
1161, 0.33333333333333, 0.2, 0.43333333333333
1162, 0.33333333333333, 0.2, 0.46666666666667
1163, 0.4, 0.2, 0.033333333333333
1164, 0.4, 0.2, 0.066666666666667
1165, 0.4, 0.2, 0.1
1166, 0.4, 0.2, 0.13333333333333
1167, 0.4, 0.2, 0.16666666666667
1168, 0.4, 0.2, 0.2
1169, 0.4, 0.2, 0.23333333333333
1170, 0.4, 0.2, 0.26666666666667
1171, 0.4, 0.2, 0.3
1172, 0.4, 0.2, 0.33333333333333
1173, 0.4, 0.2, 0.36666666666667
1174, 0.4, 0.2, 0.4
1175, 0.4, 0.2, 0.43333333333333
1176, 0.4, 0.2, 0.46666666666667
1177, 0.46666666666667, 0.2, 0.033333333333333
1178, 0.46666666666667, 0.2, 0.066666666666667
1179, 0.46666666666667, 0.2, 0.1
1180, 0.46666666666667, 0.2, 0.13333333333333
1181, 0.46666666666667, 0.2, 0.16666666666667
1182, 0.46666666666667, 0.2, 0.2
1183, 0.46666666666667, 0.2, 0.23333333333333
1184, 0.46666666666667, 0.2, 0.26666666666667
1185, 0.46666666666667, 0.2, 0.3
1186, 0.46666666666667, 0.2, 0.33333333333333
1187, 0.46666666666667, 0.2, 0.36666666666667
1188, 0.46666666666667, 0.2, 0.4
1189, 0.46666666666667, 0.2, 0.43333333333333
1190, 0.46666666666667, 0.2, 0.46666666666667
1191, 0.53333333333333, 0.2, 0.033333333333333
1192, 0.53333333333333, 0.2, 0.066666666666667
1193, 0.53333333333333, 0.2, 0.1
1194, 0.53333333333333, 0.2, 0.13333333333333
1195, 0.53333333333333, 0.2, 0.16666666666667
1196, 0.53333333333333, 0.2, 0.2
1197, 0.53333333333333, 0.2, 0.23333333333333
1198, 0.53333333333333, 0.2, 0.26666666666667
1199, 0.53333333333333, 0.2, 0.3
1200, 0.53333333333333, 0.2, 0.33333333333333
1201, 0.53333333333333, 0.2, 0.36666666666667
1202, 0.53333333333333, 0.2, 0.4
1203, 0.53333333333333, 0.2, 0.43333333333333
1204, 0.53333333333333, 0.2, 0.46666666666667
1205, 0.6, 0.2, 0.033333333333333
1206, 0.6, 0.2, 0.066666666666667
1207, 0.6, 0.2, 0.1
1208, 0.6, 0.2, 0.13333333333333
1209, 0.6, 0.2, 0.16666666666667
1210, 0.6, 0.2, 0.2
1211, 0.6, 0.2, 0.23333333333333
1212, 0.6, 0.2, 0.26666666666667
1213, 0.6, 0.2, 0.3
1214, 0.6, 0.2, 0.33333333333333
1215, 0.6, 0.2, 0.36666666666667
1216, 0.6, 0.2, 0.4
1217, 0.6, 0.2, 0.43333333333333
1218, 0.6, 0.2, 0.46666666666667
1219, 0.66666666666667, 0.2, 0.033333333333333
1220, 0.66666666666667, 0.2, 0.066666666666667
1221, 0.66666666666667, 0.2, 0.1
1222, 0.66666666666667, 0.2, 0.13333333333333
1223, 0.66666666666667, 0.2, 0.16666666666667
1224, 0.66666666666667, 0.2, 0.2
1225, 0.66666666666667, 0.2, 0.23333333333333
1226, 0.66666666666667, 0.2, 0.26666666666667
1227, 0.66666666666667, 0.2, 0.3
1228, 0.66666666666667, 0.2, 0.33333333333333
1229, 0.66666666666667, 0.2, 0.36666666666667
1230, 0.66666666666667, 0.2, 0.4
1231, 0.66666666666667, 0.2, 0.43333333333333
1232, 0.66666666666667, 0.2, 0.46666666666667
1233, 0.73333333333333, 0.2, 0.033333333333333
1234, 0.73333333333333, 0.2, 0.066666666666667
1235, 0.73333333333333, 0.2, 0.1
1236, 0.73333333333333, 0.2, 0.13333333333333
1237, 0.73333333333333, 0.2, 0.16666666666667
1238, 0.73333333333333, 0.2, 0.2
1239, 0.73333333333333, 0.2, 0.23333333333333
1240, 0.73333333333333, 0.2, 0.26666666666667
1241, 0.73333333333333, 0.2, 0.3
1242, 0.73333333333333, 0.2, 0.33333333333333
1243, 0.73333333333333, 0.2, 0.36666666666667
1244, 0.73333333333333, 0.2, 0.4
1245, 0.73333333333333, 0.2, 0.43333333333333
1246, 0.73333333333333, 0.2, 0.46666666666667
1247, 0.8, 0.2, 0.033333333333333
1248, 0.8, 0.2, 0.066666666666667
1249, 0.8, 0.2, 0.1
1250, 0.8, 0.2, 0.13333333333333
1251, 0.8, 0.2, 0.16666666666667
1252, 0.8, 0.2, 0.2
1253, 0.8, 0.2, 0.23333333333333
1254, 0.8, 0.2, 0.26666666666667
1255, 0.8, 0.2, 0.3
1256, 0.8, 0.2, 0.33333333333333
1257, 0.8, 0.2, 0.36666666666667
1258, 0.8, 0.2, 0.4
1259, 0.8, 0.2, 0.43333333333333
1260, 0.8, 0.2, 0.46666666666667
1261, 0.86666666666667, 0.2, 0.033333333333333
1262, 0.86666666666667, 0.2, 0.066666666666667
1263, 0.86666666666667, 0.2, 0.1
1264, 0.86666666666667, 0.2, 0.13333333333333
1265, 0.86666666666667, 0.2, 0.16666666666667
1266, 0.86666666666667, 0.2, 0.2
1267, 0.86666666666667, 0.2, 0.23333333333333
1268, 0.86666666666667, 0.2, 0.26666666666667
1269, 0.86666666666667, 0.2, 0.3
1270, 0.86666666666667, 0.2, 0.33333333333333
1271, 0.86666666666667, 0.2, 0.36666666666667
1272, 0.86666666666667, 0.2, 0.4
1273, 0.86666666666667, 0.2, 0.43333333333333
1274, 0.86666666666667, 0.2, 0.46666666666667
1275, 0.93333333333333, 0.2, 0.033333333333333
1276, 0.93333333333333, 0.2, 0.066666666666667
1277, 0.93333333333333, 0.2, 0.1
1278, 0.93333333333333, 0.2, 0.13333333333333
1279, 0.93333333333333, 0.2, 0.16666666666667
1280, 0.93333333333333, 0.2, 0.2
1281, 0.93333333333333, 0.2, 0.23333333333333
1282, 0.93333333333333, 0.2, 0.26666666666667
1283, 0.93333333333333, 0.2, 0.3
1284, 0.93333333333333, 0.2, 0.33333333333333
1285, 0.93333333333333, 0.2, 0.36666666666667
1286, 0.93333333333333, 0.2, 0.4
1287, 0.93333333333333, 0.2, 0.43333333333333
1288, 0.93333333333333, 0.2, 0.46666666666667
1289, 0.066666666666667, 0.3, 0.033333333333333
1290, 0.066666666666667, 0.3, 0.066666666666667
1291, 0.066666666666667, 0.3, 0.1
1292, 0.066666666666667, 0.3, 0.13333333333333
1293, 0.066666666666667, 0.3, 0.16666666666667
1294, 0.066666666666667, 0.3, 0.2
1295, 0.066666666666667, 0.3, 0.23333333333333
1296, 0.066666666666667, 0.3, 0.26666666666667
1297, 0.066666666666667, 0.3, 0.3
1298, 0.066666666666667, 0.3, 0.33333333333333
1299, 0.066666666666667, 0.3, 0.36666666666667
1300, 0.066666666666667, 0.3, 0.4
1301, 0.066666666666667, 0.3, 0.43333333333333
1302, 0.066666666666667, 0.3, 0.46666666666667
1303, 0.13333333333333, 0.3, 0.033333333333333
1304, 0.13333333333333, 0.3, 0.066666666666667
1305, 0.13333333333333, 0.3, 0.1
1306, 0.13333333333333, 0.3, 0.13333333333333
1307, 0.13333333333333, 0.3, 0.16666666666667
1308, 0.13333333333333, 0.3, 0.2
1309, 0.13333333333333, 0.3, 0.23333333333333
1310, 0.13333333333333, 0.3, 0.26666666666667
1311, 0.13333333333333, 0.3, 0.3
1312, 0.13333333333333, 0.3, 0.33333333333333
1313, 0.13333333333333, 0.3, 0.36666666666667
1314, 0.13333333333333, 0.3, 0.4
1315, 0.13333333333333, 0.3, 0.43333333333333
1316, 0.13333333333333, 0.3, 0.46666666666667
1317, 0.2, 0.3, 0.033333333333333
1318, 0.2, 0.3, 0.066666666666667
1319, 0.2, 0.3, 0.1
1320, 0.2, 0.3, 0.13333333333333
1321, 0.2, 0.3, 0.16666666666667
1322, 0.2, 0.3, 0.2
1323, 0.2, 0.3, 0.23333333333333
1324, 0.2, 0.3, 0.26666666666667
1325, 0.2, 0.3, 0.3
1326, 0.2, 0.3, 0.33333333333333
1327, 0.2, 0.3, 0.36666666666667
1328, 0.2, 0.3, 0.4
1329, 0.2, 0.3, 0.43333333333333
1330, 0.2, 0.3, 0.46666666666667
1331, 0.26666666666667, 0.3, 0.033333333333333
1332, 0.26666666666667, 0.3, 0.066666666666667
1333, 0.26666666666667, 0.3, 0.1
1334, 0.26666666666667, 0.3, 0.13333333333333
1335, 0.26666666666667, 0.3, 0.16666666666667
1336, 0.26666666666667, 0.3, 0.2
1337, 0.26666666666667, 0.3, 0.23333333333333
1338, 0.26666666666667, 0.3, 0.26666666666667
1339, 0.26666666666667, 0.3, 0.3
1340, 0.26666666666667, 0.3, 0.33333333333333
1341, 0.26666666666667, 0.3, 0.36666666666667
1342, 0.26666666666667, 0.3, 0.4
1343, 0.26666666666667, 0.3, 0.43333333333333
1344, 0.26666666666667, 0.3, 0.46666666666667
1345, 0.33333333333333, 0.3, 0.033333333333333
1346, 0.33333333333333, 0.3, 0.066666666666667
1347, 0.33333333333333, 0.3, 0.1
1348, 0.33333333333333, 0.3, 0.13333333333333
1349, 0.33333333333333, 0.3, 0.16666666666667
1350, 0.33333333333333, 0.3, 0.2
1351, 0.33333333333333, 0.3, 0.23333333333333
1352, 0.33333333333333, 0.3, 0.26666666666667
1353, 0.33333333333333, 0.3, 0.3
1354, 0.33333333333333, 0.3, 0.33333333333333
1355, 0.33333333333333, 0.3, 0.36666666666667
1356, 0.33333333333333, 0.3, 0.4
1357, 0.33333333333333, 0.3, 0.43333333333333
1358, 0.33333333333333, 0.3, 0.46666666666667
1359, 0.4, 0.3, 0.033333333333333
1360, 0.4, 0.3, 0.066666666666667
1361, 0.4, 0.3, 0.1
1362, 0.4, 0.3, 0.13333333333333
1363, 0.4, 0.3, 0.16666666666667
1364, 0.4, 0.3, 0.2
1365, 0.4, 0.3, 0.23333333333333
1366, 0.4, 0.3, 0.26666666666667
1367, 0.4, 0.3, 0.3
1368, 0.4, 0.3, 0.33333333333333
1369, 0.4, 0.3, 0.36666666666667
1370, 0.4, 0.3, 0.4
1371, 0.4, 0.3, 0.43333333333333
1372, 0.4, 0.3, 0.46666666666667
1373, 0.46666666666667, 0.3, 0.033333333333333
1374, 0.46666666666667, 0.3, 0.066666666666667
1375, 0.46666666666667, 0.3, 0.1
1376, 0.46666666666667, 0.3, 0.13333333333333
1377, 0.46666666666667, 0.3, 0.16666666666667
1378, 0.46666666666667, 0.3, 0.2
1379, 0.46666666666667, 0.3, 0.23333333333333
1380, 0.46666666666667, 0.3, 0.26666666666667
1381, 0.46666666666667, 0.3, 0.3
1382, 0.46666666666667, 0.3, 0.33333333333333
1383, 0.46666666666667, 0.3, 0.36666666666667
1384, 0.46666666666667, 0.3, 0.4
1385, 0.46666666666667, 0.3, 0.43333333333333
1386, 0.46666666666667, 0.3, 0.46666666666667
1387, 0.53333333333333, 0.3, 0.033333333333333
1388, 0.53333333333333, 0.3, 0.066666666666667
1389, 0.53333333333333, 0.3, 0.1
1390, 0.53333333333333, 0.3, 0.13333333333333
1391, 0.53333333333333, 0.3, 0.16666666666667
1392, 0.53333333333333, 0.3, 0.2
1393, 0.53333333333333, 0.3, 0.23333333333333
1394, 0.53333333333333, 0.3, 0.26666666666667
1395, 0.53333333333333, 0.3, 0.3
1396, 0.53333333333333, 0.3, 0.33333333333333
1397, 0.53333333333333, 0.3, 0.36666666666667
1398, 0.53333333333333, 0.3, 0.4
1399, 0.53333333333333, 0.3, 0.43333333333333
1400, 0.53333333333333, 0.3, 0.46666666666667
1401, 0.6, 0.3, 0.033333333333333
1402, 0.6, 0.3, 0.066666666666667
1403, 0.6, 0.3, 0.1
1404, 0.6, 0.3, 0.13333333333333
1405, 0.6, 0.3, 0.16666666666667
1406, 0.6, 0.3, 0.2
1407, 0.6, 0.3, 0.23333333333333
1408, 0.6, 0.3, 0.26666666666667
1409, 0.6, 0.3, 0.3
1410, 0.6, 0.3, 0.33333333333333
1411, 0.6, 0.3, 0.36666666666667
1412, 0.6, 0.3, 0.4
1413, 0.6, 0.3, 0.43333333333333
1414, 0.6, 0.3, 0.46666666666667
1415, 0.66666666666667, 0.3, 0.033333333333333
1416, 0.66666666666667, 0.3, 0.066666666666667
1417, 0.66666666666667, 0.3, 0.1
1418, 0.66666666666667, 0.3, 0.13333333333333
1419, 0.66666666666667, 0.3, 0.16666666666667
1420, 0.66666666666667, 0.3, 0.2
1421, 0.66666666666667, 0.3, 0.23333333333333
1422, 0.66666666666667, 0.3, 0.26666666666667
1423, 0.66666666666667, 0.3, 0.3
1424, 0.66666666666667, 0.3, 0.33333333333333
1425, 0.66666666666667, 0.3, 0.36666666666667
1426, 0.66666666666667, 0.3, 0.4
1427, 0.66666666666667, 0.3, 0.43333333333333
1428, 0.66666666666667, 0.3, 0.46666666666667
1429, 0.73333333333333, 0.3, 0.033333333333333
1430, 0.73333333333333, 0.3, 0.066666666666667
1431, 0.73333333333333, 0.3, 0.1
1432, 0.73333333333333, 0.3, 0.13333333333333
1433, 0.73333333333333, 0.3, 0.16666666666667
1434, 0.73333333333333, 0.3, 0.2
1435, 0.73333333333333, 0.3, 0.23333333333333
1436, 0.73333333333333, 0.3, 0.26666666666667
1437, 0.73333333333333, 0.3, 0.3
1438, 0.73333333333333, 0.3, 0.33333333333333
1439, 0.73333333333333, 0.3, 0.36666666666667
1440, 0.73333333333333, 0.3, 0.4
1441, 0.73333333333333, 0.3, 0.43333333333333
1442, 0.73333333333333, 0.3, 0.46666666666667
1443, 0.8, 0.3, 0.033333333333333
1444, 0.8, 0.3, 0.066666666666667
1445, 0.8, 0.3, 0.1
1446, 0.8, 0.3, 0.13333333333333
1447, 0.8, 0.3, 0.16666666666667
1448, 0.8, 0.3, 0.2
1449, 0.8, 0.3, 0.23333333333333
1450, 0.8, 0.3, 0.26666666666667
1451, 0.8, 0.3, 0.3
1452, 0.8, 0.3, 0.33333333333333
1453, 0.8, 0.3, 0.36666666666667
1454, 0.8, 0.3, 0.4
1455, 0.8, 0.3, 0.43333333333333
1456, 0.8, 0.3, 0.46666666666667
1457, 0.86666666666667, 0.3, 0.033333333333333
1458, 0.86666666666667, 0.3, 0.066666666666667
1459, 0.86666666666667, 0.3, 0.1
1460, 0.86666666666667, 0.3, 0.13333333333333
1461, 0.86666666666667, 0.3, 0.16666666666667
1462, 0.86666666666667, 0.3, 0.2
1463, 0.86666666666667, 0.3, 0.23333333333333
1464, 0.86666666666667, 0.3, 0.26666666666667
1465, 0.86666666666667, 0.3, 0.3
1466, 0.86666666666667, 0.3, 0.33333333333333
1467, 0.86666666666667, 0.3, 0.36666666666667
1468, 0.86666666666667, 0.3, 0.4
1469, 0.86666666666667, 0.3, 0.43333333333333
1470, 0.86666666666667, 0.3, 0.46666666666667
1471, 0.93333333333333, 0.3, 0.033333333333333
1472, 0.93333333333333, 0.3, 0.066666666666667
1473, 0.93333333333333, 0.3, 0.1
1474, 0.93333333333333, 0.3, 0.13333333333333
1475, 0.93333333333333, 0.3, 0.16666666666667
1476, 0.93333333333333, 0.3, 0.2
1477, 0.93333333333333, 0.3, 0.23333333333333
1478, 0.93333333333333, 0.3, 0.26666666666667
1479, 0.93333333333333, 0.3, 0.3
1480, 0.93333333333333, 0.3, 0.33333333333333
1481, 0.93333333333333, 0.3, 0.36666666666667
1482, 0.93333333333333, 0.3, 0.4
1483, 0.93333333333333, 0.3, 0.43333333333333
1484, 0.93333333333333, 0.3, 0.46666666666667
1485, 0.066666666666667, 0.35333333333333, 0
1486, 0.066666666666667, 0.40666666666667, 0
1487, 0.066666666666667, 0.46, 0
1488, 0.066666666666667, 0.51333333333333, 0
1489, 0.066666666666667, 0.56666666666667, 0
1490, 0.066666666666667, 0.62, 0
1491, 0.066666666666667, 0.67333333333333, 0
1492, 0.066666666666667, 0.72666666666667, 0
1493, 0.066666666666667, 0.78, 0
1494, 0.066666666666667, 0.83333333333333, 0
1495, 0.066666666666667, 0.88666666666667, 0
1496, 0.066666666666667, 0.94, 0
1497, 0.066666666666667, 0.99333333333333, 0
1498, 0.066666666666667, 1.0466666666667, 0
1499, 0.13333333333333, 0.35333333333333, 0
1500, 0.13333333333333, 0.40666666666667, 0
1501, 0.13333333333333, 0.46, 0
1502, 0.13333333333333, 0.51333333333333, 0
1503, 0.13333333333333, 0.56666666666667, 0
1504, 0.13333333333333, 0.62, 0
1505, 0.13333333333333, 0.67333333333333, 0
1506, 0.13333333333333, 0.72666666666667, 0
1507, 0.13333333333333, 0.78, 0
1508, 0.13333333333333, 0.83333333333333, 0
1509, 0.13333333333333, 0.88666666666667, 0
1510, 0.13333333333333, 0.94, 0
1511, 0.13333333333333, 0.99333333333333, 0
1512, 0.13333333333333, 1.0466666666667, 0
1513, 0.2, 0.35333333333333, 0
1514, 0.2, 0.40666666666667, 0
1515, 0.2, 0.46, 0
1516, 0.2, 0.51333333333333, 0
1517, 0.2, 0.56666666666667, 0
1518, 0.2, 0.62, 0
1519, 0.2, 0.67333333333333, 0
1520, 0.2, 0.72666666666667, 0
1521, 0.2, 0.78, 0
1522, 0.2, 0.83333333333333, 0
1523, 0.2, 0.88666666666667, 0
1524, 0.2, 0.94, 0
1525, 0.2, 0.99333333333333, 0
1526, 0.2, 1.0466666666667, 0
1527, 0.26666666666667, 0.35333333333333, 0
1528, 0.26666666666667, 0.40666666666667, 0
1529, 0.26666666666667, 0.46, 0
1530, 0.26666666666667, 0.51333333333333, 0
1531, 0.26666666666667, 0.56666666666667, 0
1532, 0.26666666666667, 0.62, 0
1533, 0.26666666666667, 0.67333333333333, 0
1534, 0.26666666666667, 0.72666666666667, 0
1535, 0.26666666666667, 0.78, 0
1536, 0.26666666666667, 0.83333333333333, 0
1537, 0.26666666666667, 0.88666666666667, 0
1538, 0.26666666666667, 0.94, 0
1539, 0.26666666666667, 0.99333333333333, 0
1540, 0.26666666666667, 1.0466666666667, 0
1541, 0.33333333333333, 0.35333333333333, 0
1542, 0.33333333333333, 0.40666666666667, 0
1543, 0.33333333333333, 0.46, 0
1544, 0.33333333333333, 0.51333333333333, 0
1545, 0.33333333333333, 0.56666666666667, 0
1546, 0.33333333333333, 0.62, 0
1547, 0.33333333333333, 0.67333333333333, 0
1548, 0.33333333333333, 0.72666666666667, 0
1549, 0.33333333333333, 0.78, 0
1550, 0.33333333333333, 0.83333333333333, 0
1551, 0.33333333333333, 0.88666666666667, 0
1552, 0.33333333333333, 0.94, 0
1553, 0.33333333333333, 0.99333333333333, 0
1554, 0.33333333333333, 1.0466666666667, 0
1555, 0.4, 0.35333333333333, 0
1556, 0.4, 0.40666666666667, 0
1557, 0.4, 0.46, 0
1558, 0.4, 0.51333333333333, 0
1559, 0.4, 0.56666666666667, 0
1560, 0.4, 0.62, 0
1561, 0.4, 0.67333333333333, 0
1562, 0.4, 0.72666666666667, 0
1563, 0.4, 0.78, 0
1564, 0.4, 0.83333333333333, 0
1565, 0.4, 0.88666666666667, 0
1566, 0.4, 0.94, 0
1567, 0.4, 0.99333333333333, 0
1568, 0.4, 1.0466666666667, 0
1569, 0.46666666666667, 0.35333333333333, 0
1570, 0.46666666666667, 0.40666666666667, 0
1571, 0.46666666666667, 0.46, 0
1572, 0.46666666666667, 0.51333333333333, 0
1573, 0.46666666666667, 0.56666666666667, 0
1574, 0.46666666666667, 0.62, 0
1575, 0.46666666666667, 0.67333333333333, 0
1576, 0.46666666666667, 0.72666666666667, 0
1577, 0.46666666666667, 0.78, 0
1578, 0.46666666666667, 0.83333333333333, 0
1579, 0.46666666666667, 0.88666666666667, 0
1580, 0.46666666666667, 0.94, 0
1581, 0.46666666666667, 0.99333333333333, 0
1582, 0.46666666666667, 1.0466666666667, 0
1583, 0.53333333333333, 0.35333333333333, 0
1584, 0.53333333333333, 0.40666666666667, 0
1585, 0.53333333333333, 0.46, 0
1586, 0.53333333333333, 0.51333333333333, 0
1587, 0.53333333333333, 0.56666666666667, 0
1588, 0.53333333333333, 0.62, 0
1589, 0.53333333333333, 0.67333333333333, 0
1590, 0.53333333333333, 0.72666666666667, 0
1591, 0.53333333333333, 0.78, 0
1592, 0.53333333333333, 0.83333333333333, 0
1593, 0.53333333333333, 0.88666666666667, 0
1594, 0.53333333333333, 0.94, 0
1595, 0.53333333333333, 0.99333333333333, 0
1596, 0.53333333333333, 1.0466666666667, 0
1597, 0.6, 0.35333333333333, 0
1598, 0.6, 0.40666666666667, 0
1599, 0.6, 0.46, 0
1600, 0.6, 0.51333333333333, 0
1601, 0.6, 0.56666666666667, 0
1602, 0.6, 0.62, 0
1603, 0.6, 0.67333333333333, 0
1604, 0.6, 0.72666666666667, 0
1605, 0.6, 0.78, 0
1606, 0.6, 0.83333333333333, 0
1607, 0.6, 0.88666666666667, 0
1608, 0.6, 0.94, 0
1609, 0.6, 0.99333333333333, 0
1610, 0.6, 1.0466666666667, 0
1611, 0.66666666666667, 0.35333333333333, 0
1612, 0.66666666666667, 0.40666666666667, 0
1613, 0.66666666666667, 0.46, 0
1614, 0.66666666666667, 0.51333333333333, 0
1615, 0.66666666666667, 0.56666666666667, 0
1616, 0.66666666666667, 0.62, 0
1617, 0.66666666666667, 0.67333333333333, 0
1618, 0.66666666666667, 0.72666666666667, 0
1619, 0.66666666666667, 0.78, 0
1620, 0.66666666666667, 0.83333333333333, 0
1621, 0.66666666666667, 0.88666666666667, 0
1622, 0.66666666666667, 0.94, 0
1623, 0.66666666666667, 0.99333333333333, 0
1624, 0.66666666666667, 1.0466666666667, 0
1625, 0.73333333333333, 0.35333333333333, 0
1626, 0.73333333333333, 0.40666666666667, 0
1627, 0.73333333333333, 0.46, 0
1628, 0.73333333333333, 0.51333333333333, 0
1629, 0.73333333333333, 0.56666666666667, 0
1630, 0.73333333333333, 0.62, 0
1631, 0.73333333333333, 0.67333333333333, 0
1632, 0.73333333333333, 0.72666666666667, 0
1633, 0.73333333333333, 0.78, 0
1634, 0.73333333333333, 0.83333333333333, 0
1635, 0.73333333333333, 0.88666666666667, 0
1636, 0.73333333333333, 0.94, 0
1637, 0.73333333333333, 0.99333333333333, 0
1638, 0.73333333333333, 1.0466666666667, 0
1639, 0.8, 0.35333333333333, 0
1640, 0.8, 0.40666666666667, 0
1641, 0.8, 0.46, 0
1642, 0.8, 0.51333333333333, 0
1643, 0.8, 0.56666666666667, 0
1644, 0.8, 0.62, 0
1645, 0.8, 0.67333333333333, 0
1646, 0.8, 0.72666666666667, 0
1647, 0.8, 0.78, 0
1648, 0.8, 0.83333333333333, 0
1649, 0.8, 0.88666666666667, 0
1650, 0.8, 0.94, 0
1651, 0.8, 0.99333333333333, 0
1652, 0.8, 1.0466666666667, 0
1653, 0.86666666666667, 0.35333333333333, 0
1654, 0.86666666666667, 0.40666666666667, 0
1655, 0.86666666666667, 0.46, 0
1656, 0.86666666666667, 0.51333333333333, 0
1657, 0.86666666666667, 0.56666666666667, 0
1658, 0.86666666666667, 0.62, 0
1659, 0.86666666666667, 0.67333333333333, 0
1660, 0.86666666666667, 0.72666666666667, 0
1661, 0.86666666666667, 0.78, 0
1662, 0.86666666666667, 0.83333333333333, 0
1663, 0.86666666666667, 0.88666666666667, 0
1664, 0.86666666666667, 0.94, 0
1665, 0.86666666666667, 0.99333333333333, 0
1666, 0.86666666666667, 1.0466666666667, 0
1667, 0.93333333333333, 0.35333333333333, 0
1668, 0.93333333333333, 0.40666666666667, 0
1669, 0.93333333333333, 0.46, 0
1670, 0.93333333333333, 0.51333333333333, 0
1671, 0.93333333333333, 0.56666666666667, 0
1672, 0.93333333333333, 0.62, 0
1673, 0.93333333333333, 0.67333333333333, 0
1674, 0.93333333333333, 0.72666666666667, 0
1675, 0.93333333333333, 0.78, 0
1676, 0.93333333333333, 0.83333333333333, 0
1677, 0.93333333333333, 0.88666666666667, 0
1678, 0.93333333333333, 0.94, 0
1679, 0.93333333333333, 0.99333333333333, 0
1680, 0.93333333333333, 1.0466666666667, 0
1681, 1, 0.35333333333333, 0.033333333333333
1682, 1, 0.40666666666667, 0.033333333333333
1683, 1, 0.46, 0.033333333333333
1684, 1, 0.51333333333333, 0.033333333333333
1685, 1, 0.56666666666667, 0.033333333333333
1686, 1, 0.62, 0.033333333333333
1687, 1, 0.67333333333333, 0.033333333333333
1688, 1, 0.72666666666667, 0.033333333333333
1689, 1, 0.78, 0.033333333333333
1690, 1, 0.83333333333333, 0.033333333333333
1691, 1, 0.88666666666667, 0.033333333333333
1692, 1, 0.94, 0.033333333333333
1693, 1, 0.99333333333333, 0.033333333333333
1694, 1, 1.0466666666667, 0.033333333333333
1695, 1, 0.35333333333333, 0.066666666666667
1696, 1, 0.40666666666667, 0.066666666666667
1697, 1, 0.46, 0.066666666666667
1698, 1, 0.51333333333333, 0.066666666666667
1699, 1, 0.56666666666667, 0.066666666666667
1700, 1, 0.62, 0.066666666666667
1701, 1, 0.67333333333333, 0.066666666666667
1702, 1, 0.72666666666667, 0.066666666666667
1703, 1, 0.78, 0.066666666666667
1704, 1, 0.83333333333333, 0.066666666666667
1705, 1, 0.88666666666667, 0.066666666666667
1706, 1, 0.94, 0.066666666666667
1707, 1, 0.99333333333333, 0.066666666666667
1708, 1, 1.0466666666667, 0.066666666666667
1709, 1, 0.35333333333333, 0.1
1710, 1, 0.40666666666667, 0.1
1711, 1, 0.46, 0.1
1712, 1, 0.51333333333333, 0.1
1713, 1, 0.56666666666667, 0.1
1714, 1, 0.62, 0.1
1715, 1, 0.67333333333333, 0.1
1716, 1, 0.72666666666667, 0.1
1717, 1, 0.78, 0.1
1718, 1, 0.83333333333333, 0.1
1719, 1, 0.88666666666667, 0.1
1720, 1, 0.94, 0.1
1721, 1, 0.99333333333333, 0.1
1722, 1, 1.0466666666667, 0.1
1723, 1, 0.35333333333333, 0.13333333333333
1724, 1, 0.40666666666667, 0.13333333333333
1725, 1, 0.46, 0.13333333333333
1726, 1, 0.51333333333333, 0.13333333333333
1727, 1, 0.56666666666667, 0.13333333333333
1728, 1, 0.62, 0.13333333333333
1729, 1, 0.67333333333333, 0.13333333333333
1730, 1, 0.72666666666667, 0.13333333333333
1731, 1, 0.78, 0.13333333333333
1732, 1, 0.83333333333333, 0.13333333333333
1733, 1, 0.88666666666667, 0.13333333333333
1734, 1, 0.94, 0.13333333333333
1735, 1, 0.99333333333333, 0.13333333333333
1736, 1, 1.0466666666667, 0.13333333333333
1737, 1, 0.35333333333333, 0.16666666666667
1738, 1, 0.40666666666667, 0.16666666666667
1739, 1, 0.46, 0.16666666666667
1740, 1, 0.51333333333333, 0.16666666666667
1741, 1, 0.56666666666667, 0.16666666666667
1742, 1, 0.62, 0.16666666666667
1743, 1, 0.67333333333333, 0.16666666666667
1744, 1, 0.72666666666667, 0.16666666666667
1745, 1, 0.78, 0.16666666666667
1746, 1, 0.83333333333333, 0.16666666666667
1747, 1, 0.88666666666667, 0.16666666666667
1748, 1, 0.94, 0.16666666666667
1749, 1, 0.99333333333333, 0.16666666666667
1750, 1, 1.0466666666667, 0.16666666666667
1751, 1, 0.35333333333333, 0.2
1752, 1, 0.40666666666667, 0.2
1753, 1, 0.46, 0.2
1754, 1, 0.51333333333333, 0.2
1755, 1, 0.56666666666667, 0.2
1756, 1, 0.62, 0.2
1757, 1, 0.67333333333333, 0.2
1758, 1, 0.72666666666667, 0.2
1759, 1, 0.78, 0.2
1760, 1, 0.83333333333333, 0.2
1761, 1, 0.88666666666667, 0.2
1762, 1, 0.94, 0.2
1763, 1, 0.99333333333333, 0.2
1764, 1, 1.0466666666667, 0.2
1765, 1, 0.35333333333333, 0.23333333333333
1766, 1, 0.40666666666667, 0.23333333333333
1767, 1, 0.46, 0.23333333333333
1768, 1, 0.51333333333333, 0.23333333333333
1769, 1, 0.56666666666667, 0.23333333333333
1770, 1, 0.62, 0.23333333333333
1771, 1, 0.67333333333333, 0.23333333333333
1772, 1, 0.72666666666667, 0.23333333333333
1773, 1, 0.78, 0.23333333333333
1774, 1, 0.83333333333333, 0.23333333333333
1775, 1, 0.88666666666667, 0.23333333333333
1776, 1, 0.94, 0.23333333333333
1777, 1, 0.99333333333333, 0.23333333333333
1778, 1, 1.0466666666667, 0.23333333333333
1779, 1, 0.35333333333333, 0.26666666666667
1780, 1, 0.40666666666667, 0.26666666666667
1781, 1, 0.46, 0.26666666666667
1782, 1, 0.51333333333333, 0.26666666666667
1783, 1, 0.56666666666667, 0.26666666666667
1784, 1, 0.62, 0.26666666666667
1785, 1, 0.67333333333333, 0.26666666666667
1786, 1, 0.72666666666667, 0.26666666666667
1787, 1, 0.78, 0.26666666666667
1788, 1, 0.83333333333333, 0.26666666666667
1789, 1, 0.88666666666667, 0.26666666666667
1790, 1, 0.94, 0.26666666666667
1791, 1, 0.99333333333333, 0.26666666666667
1792, 1, 1.0466666666667, 0.26666666666667
1793, 1, 0.35333333333333, 0.3
1794, 1, 0.40666666666667, 0.3
1795, 1, 0.46, 0.3
1796, 1, 0.51333333333333, 0.3
1797, 1, 0.56666666666667, 0.3
1798, 1, 0.62, 0.3
1799, 1, 0.67333333333333, 0.3
1800, 1, 0.72666666666667, 0.3
1801, 1, 0.78, 0.3
1802, 1, 0.83333333333333, 0.3
1803, 1, 0.88666666666667, 0.3
1804, 1, 0.94, 0.3
1805, 1, 0.99333333333333, 0.3
1806, 1, 1.0466666666667, 0.3
1807, 1, 0.35333333333333, 0.33333333333333
1808, 1, 0.40666666666667, 0.33333333333333
1809, 1, 0.46, 0.33333333333333
1810, 1, 0.51333333333333, 0.33333333333333
1811, 1, 0.56666666666667, 0.33333333333333
1812, 1, 0.62, 0.33333333333333
1813, 1, 0.67333333333333, 0.33333333333333
1814, 1, 0.72666666666667, 0.33333333333333
1815, 1, 0.78, 0.33333333333333
1816, 1, 0.83333333333333, 0.33333333333333
1817, 1, 0.88666666666667, 0.33333333333333
1818, 1, 0.94, 0.33333333333333
1819, 1, 0.99333333333333, 0.33333333333333
1820, 1, 1.0466666666667, 0.33333333333333
1821, 1, 0.35333333333333, 0.36666666666667
1822, 1, 0.40666666666667, 0.36666666666667
1823, 1, 0.46, 0.36666666666667
1824, 1, 0.51333333333333, 0.36666666666667
1825, 1, 0.56666666666667, 0.36666666666667
1826, 1, 0.62, 0.36666666666667
1827, 1, 0.67333333333333, 0.36666666666667
1828, 1, 0.72666666666667, 0.36666666666667
1829, 1, 0.78, 0.36666666666667
1830, 1, 0.83333333333333, 0.36666666666667
1831, 1, 0.88666666666667, 0.36666666666667
1832, 1, 0.94, 0.36666666666667
1833, 1, 0.99333333333333, 0.36666666666667
1834, 1, 1.0466666666667, 0.36666666666667
1835, 1, 0.35333333333333, 0.4
1836, 1, 0.40666666666667, 0.4
1837, 1, 0.46, 0.4
1838, 1, 0.51333333333333, 0.4
1839, 1, 0.56666666666667, 0.4
1840, 1, 0.62, 0.4
1841, 1, 0.67333333333333, 0.4
1842, 1, 0.72666666666667, 0.4
1843, 1, 0.78, 0.4
1844, 1, 0.83333333333333, 0.4
1845, 1, 0.88666666666667, 0.4
1846, 1, 0.94, 0.4
1847, 1, 0.99333333333333, 0.4
1848, 1, 1.0466666666667, 0.4
1849, 1, 0.35333333333333, 0.43333333333333
1850, 1, 0.40666666666667, 0.43333333333333
1851, 1, 0.46, 0.43333333333333
1852, 1, 0.51333333333333, 0.43333333333333
1853, 1, 0.56666666666667, 0.43333333333333
1854, 1, 0.62, 0.43333333333333
1855, 1, 0.67333333333333, 0.43333333333333
1856, 1, 0.72666666666667, 0.43333333333333
1857, 1, 0.78, 0.43333333333333
1858, 1, 0.83333333333333, 0.43333333333333
1859, 1, 0.88666666666667, 0.43333333333333
1860, 1, 0.94, 0.43333333333333
1861, 1, 0.99333333333333, 0.43333333333333
1862, 1, 1.0466666666667, 0.43333333333333
1863, 1, 0.35333333333333, 0.46666666666667
1864, 1, 0.40666666666667, 0.46666666666667
1865, 1, 0.46, 0.46666666666667
1866, 1, 0.51333333333333, 0.46666666666667
1867, 1, 0.56666666666667, 0.46666666666667
1868, 1, 0.62, 0.46666666666667
1869, 1, 0.67333333333333, 0.46666666666667
1870, 1, 0.72666666666667, 0.46666666666667
1871, 1, 0.78, 0.46666666666667
1872, 1, 0.83333333333333, 0.46666666666667
1873, 1, 0.88666666666667, 0.46666666666667
1874, 1, 0.94, 0.46666666666667
1875, 1, 0.99333333333333, 0.46666666666667
1876, 1, 1.0466666666667, 0.46666666666667
1877, 0.066666666666667, 0.35333333333333, 0.5
1878, 0.066666666666667, 0.40666666666667, 0.5
1879, 0.066666666666667, 0.46, 0.5
1880, 0.066666666666667, 0.51333333333333, 0.5
1881, 0.066666666666667, 0.56666666666667, 0.5
1882, 0.066666666666667, 0.62, 0.5
1883, 0.066666666666667, 0.67333333333333, 0.5
1884, 0.066666666666667, 0.72666666666667, 0.5
1885, 0.066666666666667, 0.78, 0.5
1886, 0.066666666666667, 0.83333333333333, 0.5
1887, 0.066666666666667, 0.88666666666667, 0.5
1888, 0.066666666666667, 0.94, 0.5
1889, 0.066666666666667, 0.99333333333333, 0.5
1890, 0.066666666666667, 1.0466666666667, 0.5
1891, 0.13333333333333, 0.35333333333333, 0.5
1892, 0.13333333333333, 0.40666666666667, 0.5
1893, 0.13333333333333, 0.46, 0.5
1894, 0.13333333333333, 0.51333333333333, 0.5
1895, 0.13333333333333, 0.56666666666667, 0.5
1896, 0.13333333333333, 0.62, 0.5
1897, 0.13333333333333, 0.67333333333333, 0.5
1898, 0.13333333333333, 0.72666666666667, 0.5
1899, 0.13333333333333, 0.78, 0.5
1900, 0.13333333333333, 0.83333333333333, 0.5
1901, 0.13333333333333, 0.88666666666667, 0.5
1902, 0.13333333333333, 0.94, 0.5
1903, 0.13333333333333, 0.99333333333333, 0.5
1904, 0.13333333333333, 1.0466666666667, 0.5
1905, 0.2, 0.35333333333333, 0.5
1906, 0.2, 0.40666666666667, 0.5
1907, 0.2, 0.46, 0.5
1908, 0.2, 0.51333333333333, 0.5
1909, 0.2, 0.56666666666667, 0.5
1910, 0.2, 0.62, 0.5
1911, 0.2, 0.67333333333333, 0.5
1912, 0.2, 0.72666666666667, 0.5
1913, 0.2, 0.78, 0.5
1914, 0.2, 0.83333333333333, 0.5
1915, 0.2, 0.88666666666667, 0.5
1916, 0.2, 0.94, 0.5
1917, 0.2, 0.99333333333333, 0.5
1918, 0.2, 1.0466666666667, 0.5
1919, 0.26666666666667, 0.35333333333333, 0.5
1920, 0.26666666666667, 0.40666666666667, 0.5
1921, 0.26666666666667, 0.46, 0.5
1922, 0.26666666666667, 0.51333333333333, 0.5
1923, 0.26666666666667, 0.56666666666667, 0.5
1924, 0.26666666666667, 0.62, 0.5
1925, 0.26666666666667, 0.67333333333333, 0.5
1926, 0.26666666666667, 0.72666666666667, 0.5
1927, 0.26666666666667, 0.78, 0.5
1928, 0.26666666666667, 0.83333333333333, 0.5
1929, 0.26666666666667, 0.88666666666667, 0.5
1930, 0.26666666666667, 0.94, 0.5
1931, 0.26666666666667, 0.99333333333333, 0.5
1932, 0.26666666666667, 1.0466666666667, 0.5
1933, 0.33333333333333, 0.35333333333333, 0.5
1934, 0.33333333333333, 0.40666666666667, 0.5
1935, 0.33333333333333, 0.46, 0.5
1936, 0.33333333333333, 0.51333333333333, 0.5
1937, 0.33333333333333, 0.56666666666667, 0.5
1938, 0.33333333333333, 0.62, 0.5
1939, 0.33333333333333, 0.67333333333333, 0.5
1940, 0.33333333333333, 0.72666666666667, 0.5
1941, 0.33333333333333, 0.78, 0.5
1942, 0.33333333333333, 0.83333333333333, 0.5
1943, 0.33333333333333, 0.88666666666667, 0.5
1944, 0.33333333333333, 0.94, 0.5
1945, 0.33333333333333, 0.99333333333333, 0.5
1946, 0.33333333333333, 1.0466666666667, 0.5
1947, 0.4, 0.35333333333333, 0.5
1948, 0.4, 0.40666666666667, 0.5
1949, 0.4, 0.46, 0.5
1950, 0.4, 0.51333333333333, 0.5
1951, 0.4, 0.56666666666667, 0.5
1952, 0.4, 0.62, 0.5
1953, 0.4, 0.67333333333333, 0.5
1954, 0.4, 0.72666666666667, 0.5
1955, 0.4, 0.78, 0.5
1956, 0.4, 0.83333333333333, 0.5
1957, 0.4, 0.88666666666667, 0.5
1958, 0.4, 0.94, 0.5
1959, 0.4, 0.99333333333333, 0.5
1960, 0.4, 1.0466666666667, 0.5
1961, 0.46666666666667, 0.35333333333333, 0.5
1962, 0.46666666666667, 0.40666666666667, 0.5
1963, 0.46666666666667, 0.46, 0.5
1964, 0.46666666666667, 0.51333333333333, 0.5
1965, 0.46666666666667, 0.56666666666667, 0.5
1966, 0.46666666666667, 0.62, 0.5
1967, 0.46666666666667, 0.67333333333333, 0.5
1968, 0.46666666666667, 0.72666666666667, 0.5
1969, 0.46666666666667, 0.78, 0.5
1970, 0.46666666666667, 0.83333333333333, 0.5
1971, 0.46666666666667, 0.88666666666667, 0.5
1972, 0.46666666666667, 0.94, 0.5
1973, 0.46666666666667, 0.99333333333333, 0.5
1974, 0.46666666666667, 1.0466666666667, 0.5
1975, 0.53333333333333, 0.35333333333333, 0.5
1976, 0.53333333333333, 0.40666666666667, 0.5
1977, 0.53333333333333, 0.46, 0.5
1978, 0.53333333333333, 0.51333333333333, 0.5
1979, 0.53333333333333, 0.56666666666667, 0.5
1980, 0.53333333333333, 0.62, 0.5
1981, 0.53333333333333, 0.67333333333333, 0.5
1982, 0.53333333333333, 0.72666666666667, 0.5
1983, 0.53333333333333, 0.78, 0.5
1984, 0.53333333333333, 0.83333333333333, 0.5
1985, 0.53333333333333, 0.88666666666667, 0.5
1986, 0.53333333333333, 0.94, 0.5
1987, 0.53333333333333, 0.99333333333333, 0.5
1988, 0.53333333333333, 1.0466666666667, 0.5
1989, 0.6, 0.35333333333333, 0.5
1990, 0.6, 0.40666666666667, 0.5
1991, 0.6, 0.46, 0.5
1992, 0.6, 0.51333333333333, 0.5
1993, 0.6, 0.56666666666667, 0.5
1994, 0.6, 0.62, 0.5
1995, 0.6, 0.67333333333333, 0.5
1996, 0.6, 0.72666666666667, 0.5
1997, 0.6, 0.78, 0.5
1998, 0.6, 0.83333333333333, 0.5
1999, 0.6, 0.88666666666667, 0.5
2000, 0.6, 0.94, 0.5
2001, 0.6, 0.99333333333333, 0.5
2002, 0.6, 1.0466666666667, 0.5
2003, 0.66666666666667, 0.35333333333333, 0.5
2004, 0.66666666666667, 0.40666666666667, 0.5
2005, 0.66666666666667, 0.46, 0.5
2006, 0.66666666666667, 0.51333333333333, 0.5
2007, 0.66666666666667, 0.56666666666667, 0.5
2008, 0.66666666666667, 0.62, 0.5
2009, 0.66666666666667, 0.67333333333333, 0.5
2010, 0.66666666666667, 0.72666666666667, 0.5
2011, 0.66666666666667, 0.78, 0.5
2012, 0.66666666666667, 0.83333333333333, 0.5
2013, 0.66666666666667, 0.88666666666667, 0.5
2014, 0.66666666666667, 0.94, 0.5
2015, 0.66666666666667, 0.99333333333333, 0.5
2016, 0.66666666666667, 1.0466666666667, 0.5
2017, 0.73333333333333, 0.35333333333333, 0.5
2018, 0.73333333333333, 0.40666666666667, 0.5
2019, 0.73333333333333, 0.46, 0.5
2020, 0.73333333333333, 0.51333333333333, 0.5
2021, 0.73333333333333, 0.56666666666667, 0.5
2022, 0.73333333333333, 0.62, 0.5
2023, 0.73333333333333, 0.67333333333333, 0.5
2024, 0.73333333333333, 0.72666666666667, 0.5
2025, 0.73333333333333, 0.78, 0.5
2026, 0.73333333333333, 0.83333333333333, 0.5
2027, 0.73333333333333, 0.88666666666667, 0.5
2028, 0.73333333333333, 0.94, 0.5
2029, 0.73333333333333, 0.99333333333333, 0.5
2030, 0.73333333333333, 1.0466666666667, 0.5
2031, 0.8, 0.35333333333333, 0.5
2032, 0.8, 0.40666666666667, 0.5
2033, 0.8, 0.46, 0.5
2034, 0.8, 0.51333333333333, 0.5
2035, 0.8, 0.56666666666667, 0.5
2036, 0.8, 0.62, 0.5
2037, 0.8, 0.67333333333333, 0.5
2038, 0.8, 0.72666666666667, 0.5
2039, 0.8, 0.78, 0.5
2040, 0.8, 0.83333333333333, 0.5
2041, 0.8, 0.88666666666667, 0.5
2042, 0.8, 0.94, 0.5
2043, 0.8, 0.99333333333333, 0.5
2044, 0.8, 1.0466666666667, 0.5
2045, 0.86666666666667, 0.35333333333333, 0.5
2046, 0.86666666666667, 0.40666666666667, 0.5
2047, 0.86666666666667, 0.46, 0.5
2048, 0.86666666666667, 0.51333333333333, 0.5
2049, 0.86666666666667, 0.56666666666667, 0.5
2050, 0.86666666666667, 0.62, 0.5
2051, 0.86666666666667, 0.67333333333333, 0.5
2052, 0.86666666666667, 0.72666666666667, 0.5
2053, 0.86666666666667, 0.78, 0.5
2054, 0.86666666666667, 0.83333333333333, 0.5
2055, 0.86666666666667, 0.88666666666667, 0.5
2056, 0.86666666666667, 0.94, 0.5
2057, 0.86666666666667, 0.99333333333333, 0.5
2058, 0.86666666666667, 1.0466666666667, 0.5
2059, 0.93333333333333, 0.35333333333333, 0.5
2060, 0.93333333333333, 0.40666666666667, 0.5
2061, 0.93333333333333, 0.46, 0.5
2062, 0.93333333333333, 0.51333333333333, 0.5
2063, 0.93333333333333, 0.56666666666667, 0.5
2064, 0.93333333333333, 0.62, 0.5
2065, 0.93333333333333, 0.67333333333333, 0.5
2066, 0.93333333333333, 0.72666666666667, 0.5
2067, 0.93333333333333, 0.78, 0.5
2068, 0.93333333333333, 0.83333333333333, 0.5
2069, 0.93333333333333, 0.88666666666667, 0.5
2070, 0.93333333333333, 0.94, 0.5
2071, 0.93333333333333, 0.99333333333333, 0.5
2072, 0.93333333333333, 1.0466666666667, 0.5
2073, 0, 0.35333333333333, 0.033333333333333
2074, 0, 0.40666666666667, 0.033333333333333
2075, 0, 0.46, 0.033333333333333
2076, 0, 0.51333333333333, 0.033333333333333
2077, 0, 0.56666666666667, 0.033333333333333
2078, 0, 0.62, 0.033333333333333
2079, 0, 0.67333333333333, 0.033333333333333
2080, 0, 0.72666666666667, 0.033333333333333
2081, 0, 0.78, 0.033333333333333
2082, 0, 0.83333333333333, 0.033333333333333
2083, 0, 0.88666666666667, 0.033333333333333
2084, 0, 0.94, 0.033333333333333
2085, 0, 0.99333333333333, 0.033333333333333
2086, 0, 1.0466666666667, 0.033333333333333
2087, 0, 0.35333333333333, 0.066666666666667
2088, 0, 0.40666666666667, 0.066666666666667
2089, 0, 0.46, 0.066666666666667
2090, 0, 0.51333333333333, 0.066666666666667
2091, 0, 0.56666666666667, 0.066666666666667
2092, 0, 0.62, 0.066666666666667
2093, 0, 0.67333333333333, 0.066666666666667
2094, 0, 0.72666666666667, 0.066666666666667
2095, 0, 0.78, 0.066666666666667
2096, 0, 0.83333333333333, 0.066666666666667
2097, 0, 0.88666666666667, 0.066666666666667
2098, 0, 0.94, 0.066666666666667
2099, 0, 0.99333333333333, 0.066666666666667
2100, 0, 1.0466666666667, 0.066666666666667
2101, 0, 0.35333333333333, 0.1
2102, 0, 0.40666666666667, 0.1
2103, 0, 0.46, 0.1
2104, 0, 0.51333333333333, 0.1
2105, 0, 0.56666666666667, 0.1
2106, 0, 0.62, 0.1
2107, 0, 0.67333333333333, 0.1
2108, 0, 0.72666666666667, 0.1
2109, 0, 0.78, 0.1
2110, 0, 0.83333333333333, 0.1
2111, 0, 0.88666666666667, 0.1
2112, 0, 0.94, 0.1
2113, 0, 0.99333333333333, 0.1
2114, 0, 1.0466666666667, 0.1
2115, 0, 0.35333333333333, 0.13333333333333
2116, 0, 0.40666666666667, 0.13333333333333
2117, 0, 0.46, 0.13333333333333
2118, 0, 0.51333333333333, 0.13333333333333
2119, 0, 0.56666666666667, 0.13333333333333
2120, 0, 0.62, 0.13333333333333
2121, 0, 0.67333333333333, 0.13333333333333
2122, 0, 0.72666666666667, 0.13333333333333
2123, 0, 0.78, 0.13333333333333
2124, 0, 0.83333333333333, 0.13333333333333
2125, 0, 0.88666666666667, 0.13333333333333
2126, 0, 0.94, 0.13333333333333
2127, 0, 0.99333333333333, 0.13333333333333
2128, 0, 1.0466666666667, 0.13333333333333
2129, 0, 0.35333333333333, 0.16666666666667
2130, 0, 0.40666666666667, 0.16666666666667
2131, 0, 0.46, 0.16666666666667
2132, 0, 0.51333333333333, 0.16666666666667
2133, 0, 0.56666666666667, 0.16666666666667
2134, 0, 0.62, 0.16666666666667
2135, 0, 0.67333333333333, 0.16666666666667
2136, 0, 0.72666666666667, 0.16666666666667
2137, 0, 0.78, 0.16666666666667
2138, 0, 0.83333333333333, 0.16666666666667
2139, 0, 0.88666666666667, 0.16666666666667
2140, 0, 0.94, 0.16666666666667
2141, 0, 0.99333333333333, 0.16666666666667
2142, 0, 1.0466666666667, 0.16666666666667
2143, 0, 0.35333333333333, 0.2
2144, 0, 0.40666666666667, 0.2
2145, 0, 0.46, 0.2
2146, 0, 0.51333333333333, 0.2
2147, 0, 0.56666666666667, 0.2
2148, 0, 0.62, 0.2
2149, 0, 0.67333333333333, 0.2
2150, 0, 0.72666666666667, 0.2
2151, 0, 0.78, 0.2
2152, 0, 0.83333333333333, 0.2
2153, 0, 0.88666666666667, 0.2
2154, 0, 0.94, 0.2
2155, 0, 0.99333333333333, 0.2
2156, 0, 1.0466666666667, 0.2
2157, 0, 0.35333333333333, 0.23333333333333
2158, 0, 0.40666666666667, 0.23333333333333
2159, 0, 0.46, 0.23333333333333
2160, 0, 0.51333333333333, 0.23333333333333
2161, 0, 0.56666666666667, 0.23333333333333
2162, 0, 0.62, 0.23333333333333
2163, 0, 0.67333333333333, 0.23333333333333
2164, 0, 0.72666666666667, 0.23333333333333
2165, 0, 0.78, 0.23333333333333
2166, 0, 0.83333333333333, 0.23333333333333
2167, 0, 0.88666666666667, 0.23333333333333
2168, 0, 0.94, 0.23333333333333
2169, 0, 0.99333333333333, 0.23333333333333
2170, 0, 1.0466666666667, 0.23333333333333
2171, 0, 0.35333333333333, 0.26666666666667
2172, 0, 0.40666666666667, 0.26666666666667
2173, 0, 0.46, 0.26666666666667
2174, 0, 0.51333333333333, 0.26666666666667
2175, 0, 0.56666666666667, 0.26666666666667
2176, 0, 0.62, 0.26666666666667
2177, 0, 0.67333333333333, 0.26666666666667
2178, 0, 0.72666666666667, 0.26666666666667
2179, 0, 0.78, 0.26666666666667
2180, 0, 0.83333333333333, 0.26666666666667
2181, 0, 0.88666666666667, 0.26666666666667
2182, 0, 0.94, 0.26666666666667
2183, 0, 0.99333333333333, 0.26666666666667
2184, 0, 1.0466666666667, 0.26666666666667
2185, 0, 0.35333333333333, 0.3
2186, 0, 0.40666666666667, 0.3
2187, 0, 0.46, 0.3
2188, 0, 0.51333333333333, 0.3
2189, 0, 0.56666666666667, 0.3
2190, 0, 0.62, 0.3
2191, 0, 0.67333333333333, 0.3
2192, 0, 0.72666666666667, 0.3
2193, 0, 0.78, 0.3
2194, 0, 0.83333333333333, 0.3
2195, 0, 0.88666666666667, 0.3
2196, 0, 0.94, 0.3
2197, 0, 0.99333333333333, 0.3
2198, 0, 1.0466666666667, 0.3
2199, 0, 0.35333333333333, 0.33333333333333
2200, 0, 0.40666666666667, 0.33333333333333
2201, 0, 0.46, 0.33333333333333
2202, 0, 0.51333333333333, 0.33333333333333
2203, 0, 0.56666666666667, 0.33333333333333
2204, 0, 0.62, 0.33333333333333
2205, 0, 0.67333333333333, 0.33333333333333
2206, 0, 0.72666666666667, 0.33333333333333
2207, 0, 0.78, 0.33333333333333
2208, 0, 0.83333333333333, 0.33333333333333
2209, 0, 0.88666666666667, 0.33333333333333
2210, 0, 0.94, 0.33333333333333
2211, 0, 0.99333333333333, 0.33333333333333
2212, 0, 1.0466666666667, 0.33333333333333
2213, 0, 0.35333333333333, 0.36666666666667
2214, 0, 0.40666666666667, 0.36666666666667
2215, 0, 0.46, 0.36666666666667
2216, 0, 0.51333333333333, 0.36666666666667
2217, 0, 0.56666666666667, 0.36666666666667
2218, 0, 0.62, 0.36666666666667
2219, 0, 0.67333333333333, 0.36666666666667
2220, 0, 0.72666666666667, 0.36666666666667
2221, 0, 0.78, 0.36666666666667
2222, 0, 0.83333333333333, 0.36666666666667
2223, 0, 0.88666666666667, 0.36666666666667
2224, 0, 0.94, 0.36666666666667
2225, 0, 0.99333333333333, 0.36666666666667
2226, 0, 1.0466666666667, 0.36666666666667
2227, 0, 0.35333333333333, 0.4
2228, 0, 0.40666666666667, 0.4
2229, 0, 0.46, 0.4
2230, 0, 0.51333333333333, 0.4
2231, 0, 0.56666666666667, 0.4
2232, 0, 0.62, 0.4
2233, 0, 0.67333333333333, 0.4
2234, 0, 0.72666666666667, 0.4
2235, 0, 0.78, 0.4
2236, 0, 0.83333333333333, 0.4
2237, 0, 0.88666666666667, 0.4
2238, 0, 0.94, 0.4
2239, 0, 0.99333333333333, 0.4
2240, 0, 1.0466666666667, 0.4
2241, 0, 0.35333333333333, 0.43333333333333
2242, 0, 0.40666666666667, 0.43333333333333
2243, 0, 0.46, 0.43333333333333
2244, 0, 0.51333333333333, 0.43333333333333
2245, 0, 0.56666666666667, 0.43333333333333
2246, 0, 0.62, 0.43333333333333
2247, 0, 0.67333333333333, 0.43333333333333
2248, 0, 0.72666666666667, 0.43333333333333
2249, 0, 0.78, 0.43333333333333
2250, 0, 0.83333333333333, 0.43333333333333
2251, 0, 0.88666666666667, 0.43333333333333
2252, 0, 0.94, 0.43333333333333
2253, 0, 0.99333333333333, 0.43333333333333
2254, 0, 1.0466666666667, 0.43333333333333
2255, 0, 0.35333333333333, 0.46666666666667
2256, 0, 0.40666666666667, 0.46666666666667
2257, 0, 0.46, 0.46666666666667
2258, 0, 0.51333333333333, 0.46666666666667
2259, 0, 0.56666666666667, 0.46666666666667
2260, 0, 0.62, 0.46666666666667
2261, 0, 0.67333333333333, 0.46666666666667
2262, 0, 0.72666666666667, 0.46666666666667
2263, 0, 0.78, 0.46666666666667
2264, 0, 0.83333333333333, 0.46666666666667
2265, 0, 0.88666666666667, 0.46666666666667
2266, 0, 0.94, 0.46666666666667
2267, 0, 0.99333333333333, 0.46666666666667
2268, 0, 1.0466666666667, 0.46666666666667
2269, 0.066666666666667, 1.1, 0.033333333333333
2270, 0.066666666666667, 1.1, 0.066666666666667
2271, 0.066666666666667, 1.1, 0.1
2272, 0.066666666666667, 1.1, 0.13333333333333
2273, 0.066666666666667, 1.1, 0.16666666666667
2274, 0.066666666666667, 1.1, 0.2
2275, 0.066666666666667, 1.1, 0.23333333333333
2276, 0.066666666666667, 1.1, 0.26666666666667
2277, 0.066666666666667, 1.1, 0.3
2278, 0.066666666666667, 1.1, 0.33333333333333
2279, 0.066666666666667, 1.1, 0.36666666666667
2280, 0.066666666666667, 1.1, 0.4
2281, 0.066666666666667, 1.1, 0.43333333333333
2282, 0.066666666666667, 1.1, 0.46666666666667
2283, 0.13333333333333, 1.1, 0.033333333333333
2284, 0.13333333333333, 1.1, 0.066666666666667
2285, 0.13333333333333, 1.1, 0.1
2286, 0.13333333333333, 1.1, 0.13333333333333
2287, 0.13333333333333, 1.1, 0.16666666666667
2288, 0.13333333333333, 1.1, 0.2
2289, 0.13333333333333, 1.1, 0.23333333333333
2290, 0.13333333333333, 1.1, 0.26666666666667
2291, 0.13333333333333, 1.1, 0.3
2292, 0.13333333333333, 1.1, 0.33333333333333
2293, 0.13333333333333, 1.1, 0.36666666666667
2294, 0.13333333333333, 1.1, 0.4
2295, 0.13333333333333, 1.1, 0.43333333333333
2296, 0.13333333333333, 1.1, 0.46666666666667
2297, 0.2, 1.1, 0.033333333333333
2298, 0.2, 1.1, 0.066666666666667
2299, 0.2, 1.1, 0.1
2300, 0.2, 1.1, 0.13333333333333
2301, 0.2, 1.1, 0.16666666666667
2302, 0.2, 1.1, 0.2
2303, 0.2, 1.1, 0.23333333333333
2304, 0.2, 1.1, 0.26666666666667
2305, 0.2, 1.1, 0.3
2306, 0.2, 1.1, 0.33333333333333
2307, 0.2, 1.1, 0.36666666666667
2308, 0.2, 1.1, 0.4
2309, 0.2, 1.1, 0.43333333333333
2310, 0.2, 1.1, 0.46666666666667
2311, 0.26666666666667, 1.1, 0.033333333333333
2312, 0.26666666666667, 1.1, 0.066666666666667
2313, 0.26666666666667, 1.1, 0.1
2314, 0.26666666666667, 1.1, 0.13333333333333
2315, 0.26666666666667, 1.1, 0.16666666666667
2316, 0.26666666666667, 1.1, 0.2
2317, 0.26666666666667, 1.1, 0.23333333333333
2318, 0.26666666666667, 1.1, 0.26666666666667
2319, 0.26666666666667, 1.1, 0.3
2320, 0.26666666666667, 1.1, 0.33333333333333
2321, 0.26666666666667, 1.1, 0.36666666666667
2322, 0.26666666666667, 1.1, 0.4
2323, 0.26666666666667, 1.1, 0.43333333333333
2324, 0.26666666666667, 1.1, 0.46666666666667
2325, 0.33333333333333, 1.1, 0.033333333333333
2326, 0.33333333333333, 1.1, 0.066666666666667
2327, 0.33333333333333, 1.1, 0.1
2328, 0.33333333333333, 1.1, 0.13333333333333
2329, 0.33333333333333, 1.1, 0.16666666666667
2330, 0.33333333333333, 1.1, 0.2
2331, 0.33333333333333, 1.1, 0.23333333333333
2332, 0.33333333333333, 1.1, 0.26666666666667
2333, 0.33333333333333, 1.1, 0.3
2334, 0.33333333333333, 1.1, 0.33333333333333
2335, 0.33333333333333, 1.1, 0.36666666666667
2336, 0.33333333333333, 1.1, 0.4
2337, 0.33333333333333, 1.1, 0.43333333333333
2338, 0.33333333333333, 1.1, 0.46666666666667
2339, 0.4, 1.1, 0.033333333333333
2340, 0.4, 1.1, 0.066666666666667
2341, 0.4, 1.1, 0.1
2342, 0.4, 1.1, 0.13333333333333
2343, 0.4, 1.1, 0.16666666666667
2344, 0.4, 1.1, 0.2
2345, 0.4, 1.1, 0.23333333333333
2346, 0.4, 1.1, 0.26666666666667
2347, 0.4, 1.1, 0.3
2348, 0.4, 1.1, 0.33333333333333
2349, 0.4, 1.1, 0.36666666666667
2350, 0.4, 1.1, 0.4
2351, 0.4, 1.1, 0.43333333333333
2352, 0.4, 1.1, 0.46666666666667
2353, 0.46666666666667, 1.1, 0.033333333333333
2354, 0.46666666666667, 1.1, 0.066666666666667
2355, 0.46666666666667, 1.1, 0.1
2356, 0.46666666666667, 1.1, 0.13333333333333
2357, 0.46666666666667, 1.1, 0.16666666666667
2358, 0.46666666666667, 1.1, 0.2
2359, 0.46666666666667, 1.1, 0.23333333333333
2360, 0.46666666666667, 1.1, 0.26666666666667
2361, 0.46666666666667, 1.1, 0.3
2362, 0.46666666666667, 1.1, 0.33333333333333
2363, 0.46666666666667, 1.1, 0.36666666666667
2364, 0.46666666666667, 1.1, 0.4
2365, 0.46666666666667, 1.1, 0.43333333333333
2366, 0.46666666666667, 1.1, 0.46666666666667
2367, 0.53333333333333, 1.1, 0.033333333333333
2368, 0.53333333333333, 1.1, 0.066666666666667
2369, 0.53333333333333, 1.1, 0.1
2370, 0.53333333333333, 1.1, 0.13333333333333
2371, 0.53333333333333, 1.1, 0.16666666666667
2372, 0.53333333333333, 1.1, 0.2
2373, 0.53333333333333, 1.1, 0.23333333333333
2374, 0.53333333333333, 1.1, 0.26666666666667
2375, 0.53333333333333, 1.1, 0.3
2376, 0.53333333333333, 1.1, 0.33333333333333
2377, 0.53333333333333, 1.1, 0.36666666666667
2378, 0.53333333333333, 1.1, 0.4
2379, 0.53333333333333, 1.1, 0.43333333333333
2380, 0.53333333333333, 1.1, 0.46666666666667
2381, 0.6, 1.1, 0.033333333333333
2382, 0.6, 1.1, 0.066666666666667
2383, 0.6, 1.1, 0.1
2384, 0.6, 1.1, 0.13333333333333
2385, 0.6, 1.1, 0.16666666666667
2386, 0.6, 1.1, 0.2
2387, 0.6, 1.1, 0.23333333333333
2388, 0.6, 1.1, 0.26666666666667
2389, 0.6, 1.1, 0.3
2390, 0.6, 1.1, 0.33333333333333
2391, 0.6, 1.1, 0.36666666666667
2392, 0.6, 1.1, 0.4
2393, 0.6, 1.1, 0.43333333333333
2394, 0.6, 1.1, 0.46666666666667
2395, 0.66666666666667, 1.1, 0.033333333333333
2396, 0.66666666666667, 1.1, 0.066666666666667
2397, 0.66666666666667, 1.1, 0.1
2398, 0.66666666666667, 1.1, 0.13333333333333
2399, 0.66666666666667, 1.1, 0.16666666666667
2400, 0.66666666666667, 1.1, 0.2
2401, 0.66666666666667, 1.1, 0.23333333333333
2402, 0.66666666666667, 1.1, 0.26666666666667
2403, 0.66666666666667, 1.1, 0.3
2404, 0.66666666666667, 1.1, 0.33333333333333
2405, 0.66666666666667, 1.1, 0.36666666666667
2406, 0.66666666666667, 1.1, 0.4
2407, 0.66666666666667, 1.1, 0.43333333333333
2408, 0.66666666666667, 1.1, 0.46666666666667
2409, 0.73333333333333, 1.1, 0.033333333333333
2410, 0.73333333333333, 1.1, 0.066666666666667
2411, 0.73333333333333, 1.1, 0.1
2412, 0.73333333333333, 1.1, 0.13333333333333
2413, 0.73333333333333, 1.1, 0.16666666666667
2414, 0.73333333333333, 1.1, 0.2
2415, 0.73333333333333, 1.1, 0.23333333333333
2416, 0.73333333333333, 1.1, 0.26666666666667
2417, 0.73333333333333, 1.1, 0.3
2418, 0.73333333333333, 1.1, 0.33333333333333
2419, 0.73333333333333, 1.1, 0.36666666666667
2420, 0.73333333333333, 1.1, 0.4
2421, 0.73333333333333, 1.1, 0.43333333333333
2422, 0.73333333333333, 1.1, 0.46666666666667
2423, 0.8, 1.1, 0.033333333333333
2424, 0.8, 1.1, 0.066666666666667
2425, 0.8, 1.1, 0.1
2426, 0.8, 1.1, 0.13333333333333
2427, 0.8, 1.1, 0.16666666666667
2428, 0.8, 1.1, 0.2
2429, 0.8, 1.1, 0.23333333333333
2430, 0.8, 1.1, 0.26666666666667
2431, 0.8, 1.1, 0.3
2432, 0.8, 1.1, 0.33333333333333
2433, 0.8, 1.1, 0.36666666666667
2434, 0.8, 1.1, 0.4
2435, 0.8, 1.1, 0.43333333333333
2436, 0.8, 1.1, 0.46666666666667
2437, 0.86666666666667, 1.1, 0.033333333333333
2438, 0.86666666666667, 1.1, 0.066666666666667
2439, 0.86666666666667, 1.1, 0.1
2440, 0.86666666666667, 1.1, 0.13333333333333
2441, 0.86666666666667, 1.1, 0.16666666666667
2442, 0.86666666666667, 1.1, 0.2
2443, 0.86666666666667, 1.1, 0.23333333333333
2444, 0.86666666666667, 1.1, 0.26666666666667
2445, 0.86666666666667, 1.1, 0.3
2446, 0.86666666666667, 1.1, 0.33333333333333
2447, 0.86666666666667, 1.1, 0.36666666666667
2448, 0.86666666666667, 1.1, 0.4
2449, 0.86666666666667, 1.1, 0.43333333333333
2450, 0.86666666666667, 1.1, 0.46666666666667
2451, 0.93333333333333, 1.1, 0.033333333333333
2452, 0.93333333333333, 1.1, 0.066666666666667
2453, 0.93333333333333, 1.1, 0.1
2454, 0.93333333333333, 1.1, 0.13333333333333
2455, 0.93333333333333, 1.1, 0.16666666666667
2456, 0.93333333333333, 1.1, 0.2
2457, 0.93333333333333, 1.1, 0.23333333333333
2458, 0.93333333333333, 1.1, 0.26666666666667
2459, 0.93333333333333, 1.1, 0.3
2460, 0.93333333333333, 1.1, 0.33333333333333
2461, 0.93333333333333, 1.1, 0.36666666666667
2462, 0.93333333333333, 1.1, 0.4
2463, 0.93333333333333, 1.1, 0.43333333333333
2464, 0.93333333333333, 1.1, 0.46666666666667
2465, 0.066666666666667, 1.2, 0.033333333333333
2466, 0.066666666666667, 1.2, 0.066666666666667
2467, 0.066666666666667, 1.2, 0.1
2468, 0.066666666666667, 1.2, 0.13333333333333
2469, 0.066666666666667, 1.2, 0.16666666666667
2470, 0.066666666666667, 1.2, 0.2
2471, 0.066666666666667, 1.2, 0.23333333333333
2472, 0.066666666666667, 1.2, 0.26666666666667
2473, 0.066666666666667, 1.2, 0.3
2474, 0.066666666666667, 1.2, 0.33333333333333
2475, 0.066666666666667, 1.2, 0.36666666666667
2476, 0.066666666666667, 1.2, 0.4
2477, 0.066666666666667, 1.2, 0.43333333333333
2478, 0.066666666666667, 1.2, 0.46666666666667
2479, 0.13333333333333, 1.2, 0.033333333333333
2480, 0.13333333333333, 1.2, 0.066666666666667
2481, 0.13333333333333, 1.2, 0.1
2482, 0.13333333333333, 1.2, 0.13333333333333
2483, 0.13333333333333, 1.2, 0.16666666666667
2484, 0.13333333333333, 1.2, 0.2
2485, 0.13333333333333, 1.2, 0.23333333333333
2486, 0.13333333333333, 1.2, 0.26666666666667
2487, 0.13333333333333, 1.2, 0.3
2488, 0.13333333333333, 1.2, 0.33333333333333
2489, 0.13333333333333, 1.2, 0.36666666666667
2490, 0.13333333333333, 1.2, 0.4
2491, 0.13333333333333, 1.2, 0.43333333333333
2492, 0.13333333333333, 1.2, 0.46666666666667
2493, 0.2, 1.2, 0.033333333333333
2494, 0.2, 1.2, 0.066666666666667
2495, 0.2, 1.2, 0.1
2496, 0.2, 1.2, 0.13333333333333
2497, 0.2, 1.2, 0.16666666666667
2498, 0.2, 1.2, 0.2
2499, 0.2, 1.2, 0.23333333333333
2500, 0.2, 1.2, 0.26666666666667
2501, 0.2, 1.2, 0.3
2502, 0.2, 1.2, 0.33333333333333
2503, 0.2, 1.2, 0.36666666666667
2504, 0.2, 1.2, 0.4
2505, 0.2, 1.2, 0.43333333333333
2506, 0.2, 1.2, 0.46666666666667
2507, 0.26666666666667, 1.2, 0.033333333333333
2508, 0.26666666666667, 1.2, 0.066666666666667
2509, 0.26666666666667, 1.2, 0.1
2510, 0.26666666666667, 1.2, 0.13333333333333
2511, 0.26666666666667, 1.2, 0.16666666666667
2512, 0.26666666666667, 1.2, 0.2
2513, 0.26666666666667, 1.2, 0.23333333333333
2514, 0.26666666666667, 1.2, 0.26666666666667
2515, 0.26666666666667, 1.2, 0.3
2516, 0.26666666666667, 1.2, 0.33333333333333
2517, 0.26666666666667, 1.2, 0.36666666666667
2518, 0.26666666666667, 1.2, 0.4
2519, 0.26666666666667, 1.2, 0.43333333333333
2520, 0.26666666666667, 1.2, 0.46666666666667
2521, 0.33333333333333, 1.2, 0.033333333333333
2522, 0.33333333333333, 1.2, 0.066666666666667
2523, 0.33333333333333, 1.2, 0.1
2524, 0.33333333333333, 1.2, 0.13333333333333
2525, 0.33333333333333, 1.2, 0.16666666666667
2526, 0.33333333333333, 1.2, 0.2
2527, 0.33333333333333, 1.2, 0.23333333333333
2528, 0.33333333333333, 1.2, 0.26666666666667
2529, 0.33333333333333, 1.2, 0.3
2530, 0.33333333333333, 1.2, 0.33333333333333
2531, 0.33333333333333, 1.2, 0.36666666666667
2532, 0.33333333333333, 1.2, 0.4
2533, 0.33333333333333, 1.2, 0.43333333333333
2534, 0.33333333333333, 1.2, 0.46666666666667
2535, 0.4, 1.2, 0.033333333333333
2536, 0.4, 1.2, 0.066666666666667
2537, 0.4, 1.2, 0.1
2538, 0.4, 1.2, 0.13333333333333
2539, 0.4, 1.2, 0.16666666666667
2540, 0.4, 1.2, 0.2
2541, 0.4, 1.2, 0.23333333333333
2542, 0.4, 1.2, 0.26666666666667
2543, 0.4, 1.2, 0.3
2544, 0.4, 1.2, 0.33333333333333
2545, 0.4, 1.2, 0.36666666666667
2546, 0.4, 1.2, 0.4
2547, 0.4, 1.2, 0.43333333333333
2548, 0.4, 1.2, 0.46666666666667
2549, 0.46666666666667, 1.2, 0.033333333333333
2550, 0.46666666666667, 1.2, 0.066666666666667
2551, 0.46666666666667, 1.2, 0.1
2552, 0.46666666666667, 1.2, 0.13333333333333
2553, 0.46666666666667, 1.2, 0.16666666666667
2554, 0.46666666666667, 1.2, 0.2
2555, 0.46666666666667, 1.2, 0.23333333333333
2556, 0.46666666666667, 1.2, 0.26666666666667
2557, 0.46666666666667, 1.2, 0.3
2558, 0.46666666666667, 1.2, 0.33333333333333
2559, 0.46666666666667, 1.2, 0.36666666666667
2560, 0.46666666666667, 1.2, 0.4
2561, 0.46666666666667, 1.2, 0.43333333333333
2562, 0.46666666666667, 1.2, 0.46666666666667
2563, 0.53333333333333, 1.2, 0.033333333333333
2564, 0.53333333333333, 1.2, 0.066666666666667
2565, 0.53333333333333, 1.2, 0.1
2566, 0.53333333333333, 1.2, 0.13333333333333
2567, 0.53333333333333, 1.2, 0.16666666666667
2568, 0.53333333333333, 1.2, 0.2
2569, 0.53333333333333, 1.2, 0.23333333333333
2570, 0.53333333333333, 1.2, 0.26666666666667
2571, 0.53333333333333, 1.2, 0.3
2572, 0.53333333333333, 1.2, 0.33333333333333
2573, 0.53333333333333, 1.2, 0.36666666666667
2574, 0.53333333333333, 1.2, 0.4
2575, 0.53333333333333, 1.2, 0.43333333333333
2576, 0.53333333333333, 1.2, 0.46666666666667
2577, 0.6, 1.2, 0.033333333333333
2578, 0.6, 1.2, 0.066666666666667
2579, 0.6, 1.2, 0.1
2580, 0.6, 1.2, 0.13333333333333
2581, 0.6, 1.2, 0.16666666666667
2582, 0.6, 1.2, 0.2
2583, 0.6, 1.2, 0.23333333333333
2584, 0.6, 1.2, 0.26666666666667
2585, 0.6, 1.2, 0.3
2586, 0.6, 1.2, 0.33333333333333
2587, 0.6, 1.2, 0.36666666666667
2588, 0.6, 1.2, 0.4
2589, 0.6, 1.2, 0.43333333333333
2590, 0.6, 1.2, 0.46666666666667
2591, 0.66666666666667, 1.2, 0.033333333333333
2592, 0.66666666666667, 1.2, 0.066666666666667
2593, 0.66666666666667, 1.2, 0.1
2594, 0.66666666666667, 1.2, 0.13333333333333
2595, 0.66666666666667, 1.2, 0.16666666666667
2596, 0.66666666666667, 1.2, 0.2
2597, 0.66666666666667, 1.2, 0.23333333333333
2598, 0.66666666666667, 1.2, 0.26666666666667
2599, 0.66666666666667, 1.2, 0.3
2600, 0.66666666666667, 1.2, 0.33333333333333
2601, 0.66666666666667, 1.2, 0.36666666666667
2602, 0.66666666666667, 1.2, 0.4
2603, 0.66666666666667, 1.2, 0.43333333333333
2604, 0.66666666666667, 1.2, 0.46666666666667
2605, 0.73333333333333, 1.2, 0.033333333333333
2606, 0.73333333333333, 1.2, 0.066666666666667
2607, 0.73333333333333, 1.2, 0.1
2608, 0.73333333333333, 1.2, 0.13333333333333
2609, 0.73333333333333, 1.2, 0.16666666666667
2610, 0.73333333333333, 1.2, 0.2
2611, 0.73333333333333, 1.2, 0.23333333333333
2612, 0.73333333333333, 1.2, 0.26666666666667
2613, 0.73333333333333, 1.2, 0.3
2614, 0.73333333333333, 1.2, 0.33333333333333
2615, 0.73333333333333, 1.2, 0.36666666666667
2616, 0.73333333333333, 1.2, 0.4
2617, 0.73333333333333, 1.2, 0.43333333333333
2618, 0.73333333333333, 1.2, 0.46666666666667
2619, 0.8, 1.2, 0.033333333333333
2620, 0.8, 1.2, 0.066666666666667
2621, 0.8, 1.2, 0.1
2622, 0.8, 1.2, 0.13333333333333
2623, 0.8, 1.2, 0.16666666666667
2624, 0.8, 1.2, 0.2
2625, 0.8, 1.2, 0.23333333333333
2626, 0.8, 1.2, 0.26666666666667
2627, 0.8, 1.2, 0.3
2628, 0.8, 1.2, 0.33333333333333
2629, 0.8, 1.2, 0.36666666666667
2630, 0.8, 1.2, 0.4
2631, 0.8, 1.2, 0.43333333333333
2632, 0.8, 1.2, 0.46666666666667
2633, 0.86666666666667, 1.2, 0.033333333333333
2634, 0.86666666666667, 1.2, 0.066666666666667
2635, 0.86666666666667, 1.2, 0.1
2636, 0.86666666666667, 1.2, 0.13333333333333
2637, 0.86666666666667, 1.2, 0.16666666666667
2638, 0.86666666666667, 1.2, 0.2
2639, 0.86666666666667, 1.2, 0.23333333333333
2640, 0.86666666666667, 1.2, 0.26666666666667
2641, 0.86666666666667, 1.2, 0.3
2642, 0.86666666666667, 1.2, 0.33333333333333
2643, 0.86666666666667, 1.2, 0.36666666666667
2644, 0.86666666666667, 1.2, 0.4
2645, 0.86666666666667, 1.2, 0.43333333333333
2646, 0.86666666666667, 1.2, 0.46666666666667
2647, 0.93333333333333, 1.2, 0.033333333333333
2648, 0.93333333333333, 1.2, 0.066666666666667
2649, 0.93333333333333, 1.2, 0.1
2650, 0.93333333333333, 1.2, 0.13333333333333
2651, 0.93333333333333, 1.2, 0.16666666666667
2652, 0.93333333333333, 1.2, 0.2
2653, 0.93333333333333, 1.2, 0.23333333333333
2654, 0.93333333333333, 1.2, 0.26666666666667
2655, 0.93333333333333, 1.2, 0.3
2656, 0.93333333333333, 1.2, 0.33333333333333
2657, 0.93333333333333, 1.2, 0.36666666666667
2658, 0.93333333333333, 1.2, 0.4
2659, 0.93333333333333, 1.2, 0.43333333333333
2660, 0.93333333333333, 1.2, 0.46666666666667
2661, 0.066666666666667, 1.4, 0.033333333333333
2662, 0.066666666666667, 1.4, 0.066666666666667
2663, 0.066666666666667, 1.4, 0.1
2664, 0.066666666666667, 1.4, 0.13333333333333
2665, 0.066666666666667, 1.4, 0.16666666666667
2666, 0.066666666666667, 1.4, 0.2
2667, 0.066666666666667, 1.4, 0.23333333333333
2668, 0.066666666666667, 1.4, 0.26666666666667
2669, 0.066666666666667, 1.4, 0.3
2670, 0.066666666666667, 1.4, 0.33333333333333
2671, 0.066666666666667, 1.4, 0.36666666666667
2672, 0.066666666666667, 1.4, 0.4
2673, 0.066666666666667, 1.4, 0.43333333333333
2674, 0.066666666666667, 1.4, 0.46666666666667
2675, 0.13333333333333, 1.4, 0.033333333333333
2676, 0.13333333333333, 1.4, 0.066666666666667
2677, 0.13333333333333, 1.4, 0.1
2678, 0.13333333333333, 1.4, 0.13333333333333
2679, 0.13333333333333, 1.4, 0.16666666666667
2680, 0.13333333333333, 1.4, 0.2
2681, 0.13333333333333, 1.4, 0.23333333333333
2682, 0.13333333333333, 1.4, 0.26666666666667
2683, 0.13333333333333, 1.4, 0.3
2684, 0.13333333333333, 1.4, 0.33333333333333
2685, 0.13333333333333, 1.4, 0.36666666666667
2686, 0.13333333333333, 1.4, 0.4
2687, 0.13333333333333, 1.4, 0.43333333333333
2688, 0.13333333333333, 1.4, 0.46666666666667
2689, 0.2, 1.4, 0.033333333333333
2690, 0.2, 1.4, 0.066666666666667
2691, 0.2, 1.4, 0.1
2692, 0.2, 1.4, 0.13333333333333
2693, 0.2, 1.4, 0.16666666666667
2694, 0.2, 1.4, 0.2
2695, 0.2, 1.4, 0.23333333333333
2696, 0.2, 1.4, 0.26666666666667
2697, 0.2, 1.4, 0.3
2698, 0.2, 1.4, 0.33333333333333
2699, 0.2, 1.4, 0.36666666666667
2700, 0.2, 1.4, 0.4
2701, 0.2, 1.4, 0.43333333333333
2702, 0.2, 1.4, 0.46666666666667
2703, 0.26666666666667, 1.4, 0.033333333333333
2704, 0.26666666666667, 1.4, 0.066666666666667
2705, 0.26666666666667, 1.4, 0.1
2706, 0.26666666666667, 1.4, 0.13333333333333
2707, 0.26666666666667, 1.4, 0.16666666666667
2708, 0.26666666666667, 1.4, 0.2
2709, 0.26666666666667, 1.4, 0.23333333333333
2710, 0.26666666666667, 1.4, 0.26666666666667
2711, 0.26666666666667, 1.4, 0.3
2712, 0.26666666666667, 1.4, 0.33333333333333
2713, 0.26666666666667, 1.4, 0.36666666666667
2714, 0.26666666666667, 1.4, 0.4
2715, 0.26666666666667, 1.4, 0.43333333333333
2716, 0.26666666666667, 1.4, 0.46666666666667
2717, 0.33333333333333, 1.4, 0.033333333333333
2718, 0.33333333333333, 1.4, 0.066666666666667
2719, 0.33333333333333, 1.4, 0.1
2720, 0.33333333333333, 1.4, 0.13333333333333
2721, 0.33333333333333, 1.4, 0.16666666666667
2722, 0.33333333333333, 1.4, 0.2
2723, 0.33333333333333, 1.4, 0.23333333333333
2724, 0.33333333333333, 1.4, 0.26666666666667
2725, 0.33333333333333, 1.4, 0.3
2726, 0.33333333333333, 1.4, 0.33333333333333
2727, 0.33333333333333, 1.4, 0.36666666666667
2728, 0.33333333333333, 1.4, 0.4
2729, 0.33333333333333, 1.4, 0.43333333333333
2730, 0.33333333333333, 1.4, 0.46666666666667
2731, 0.4, 1.4, 0.033333333333333
2732, 0.4, 1.4, 0.066666666666667
2733, 0.4, 1.4, 0.1
2734, 0.4, 1.4, 0.13333333333333
2735, 0.4, 1.4, 0.16666666666667
2736, 0.4, 1.4, 0.2
2737, 0.4, 1.4, 0.23333333333333
2738, 0.4, 1.4, 0.26666666666667
2739, 0.4, 1.4, 0.3
2740, 0.4, 1.4, 0.33333333333333
2741, 0.4, 1.4, 0.36666666666667
2742, 0.4, 1.4, 0.4
2743, 0.4, 1.4, 0.43333333333333
2744, 0.4, 1.4, 0.46666666666667
2745, 0.46666666666667, 1.4, 0.033333333333333
2746, 0.46666666666667, 1.4, 0.066666666666667
2747, 0.46666666666667, 1.4, 0.1
2748, 0.46666666666667, 1.4, 0.13333333333333
2749, 0.46666666666667, 1.4, 0.16666666666667
2750, 0.46666666666667, 1.4, 0.2
2751, 0.46666666666667, 1.4, 0.23333333333333
2752, 0.46666666666667, 1.4, 0.26666666666667
2753, 0.46666666666667, 1.4, 0.3
2754, 0.46666666666667, 1.4, 0.33333333333333
2755, 0.46666666666667, 1.4, 0.36666666666667
2756, 0.46666666666667, 1.4, 0.4
2757, 0.46666666666667, 1.4, 0.43333333333333
2758, 0.46666666666667, 1.4, 0.46666666666667
2759, 0.53333333333333, 1.4, 0.033333333333333
2760, 0.53333333333333, 1.4, 0.066666666666667
2761, 0.53333333333333, 1.4, 0.1
2762, 0.53333333333333, 1.4, 0.13333333333333
2763, 0.53333333333333, 1.4, 0.16666666666667
2764, 0.53333333333333, 1.4, 0.2
2765, 0.53333333333333, 1.4, 0.23333333333333
2766, 0.53333333333333, 1.4, 0.26666666666667
2767, 0.53333333333333, 1.4, 0.3
2768, 0.53333333333333, 1.4, 0.33333333333333
2769, 0.53333333333333, 1.4, 0.36666666666667
2770, 0.53333333333333, 1.4, 0.4
2771, 0.53333333333333, 1.4, 0.43333333333333
2772, 0.53333333333333, 1.4, 0.46666666666667
2773, 0.6, 1.4, 0.033333333333333
2774, 0.6, 1.4, 0.066666666666667
2775, 0.6, 1.4, 0.1
2776, 0.6, 1.4, 0.13333333333333
2777, 0.6, 1.4, 0.16666666666667
2778, 0.6, 1.4, 0.2
2779, 0.6, 1.4, 0.23333333333333
2780, 0.6, 1.4, 0.26666666666667
2781, 0.6, 1.4, 0.3
2782, 0.6, 1.4, 0.33333333333333
2783, 0.6, 1.4, 0.36666666666667
2784, 0.6, 1.4, 0.4
2785, 0.6, 1.4, 0.43333333333333
2786, 0.6, 1.4, 0.46666666666667
2787, 0.66666666666667, 1.4, 0.033333333333333
2788, 0.66666666666667, 1.4, 0.066666666666667
2789, 0.66666666666667, 1.4, 0.1
2790, 0.66666666666667, 1.4, 0.13333333333333
2791, 0.66666666666667, 1.4, 0.16666666666667
2792, 0.66666666666667, 1.4, 0.2
2793, 0.66666666666667, 1.4, 0.23333333333333
2794, 0.66666666666667, 1.4, 0.26666666666667
2795, 0.66666666666667, 1.4, 0.3
2796, 0.66666666666667, 1.4, 0.33333333333333
2797, 0.66666666666667, 1.4, 0.36666666666667
2798, 0.66666666666667, 1.4, 0.4
2799, 0.66666666666667, 1.4, 0.43333333333333
2800, 0.66666666666667, 1.4, 0.46666666666667
2801, 0.73333333333333, 1.4, 0.033333333333333
2802, 0.73333333333333, 1.4, 0.066666666666667
2803, 0.73333333333333, 1.4, 0.1
2804, 0.73333333333333, 1.4, 0.13333333333333
2805, 0.73333333333333, 1.4, 0.16666666666667
2806, 0.73333333333333, 1.4, 0.2
2807, 0.73333333333333, 1.4, 0.23333333333333
2808, 0.73333333333333, 1.4, 0.26666666666667
2809, 0.73333333333333, 1.4, 0.3
2810, 0.73333333333333, 1.4, 0.33333333333333
2811, 0.73333333333333, 1.4, 0.36666666666667
2812, 0.73333333333333, 1.4, 0.4
2813, 0.73333333333333, 1.4, 0.43333333333333
2814, 0.73333333333333, 1.4, 0.46666666666667
2815, 0.8, 1.4, 0.033333333333333
2816, 0.8, 1.4, 0.066666666666667
2817, 0.8, 1.4, 0.1
2818, 0.8, 1.4, 0.13333333333333
2819, 0.8, 1.4, 0.16666666666667
2820, 0.8, 1.4, 0.2
2821, 0.8, 1.4, 0.23333333333333
2822, 0.8, 1.4, 0.26666666666667
2823, 0.8, 1.4, 0.3
2824, 0.8, 1.4, 0.33333333333333
2825, 0.8, 1.4, 0.36666666666667
2826, 0.8, 1.4, 0.4
2827, 0.8, 1.4, 0.43333333333333
2828, 0.8, 1.4, 0.46666666666667
2829, 0.86666666666667, 1.4, 0.033333333333333
2830, 0.86666666666667, 1.4, 0.066666666666667
2831, 0.86666666666667, 1.4, 0.1
2832, 0.86666666666667, 1.4, 0.13333333333333
2833, 0.86666666666667, 1.4, 0.16666666666667
2834, 0.86666666666667, 1.4, 0.2
2835, 0.86666666666667, 1.4, 0.23333333333333
2836, 0.86666666666667, 1.4, 0.26666666666667
2837, 0.86666666666667, 1.4, 0.3
2838, 0.86666666666667, 1.4, 0.33333333333333
2839, 0.86666666666667, 1.4, 0.36666666666667
2840, 0.86666666666667, 1.4, 0.4
2841, 0.86666666666667, 1.4, 0.43333333333333
2842, 0.86666666666667, 1.4, 0.46666666666667
2843, 0.93333333333333, 1.4, 0.033333333333333
2844, 0.93333333333333, 1.4, 0.066666666666667
2845, 0.93333333333333, 1.4, 0.1
2846, 0.93333333333333, 1.4, 0.13333333333333
2847, 0.93333333333333, 1.4, 0.16666666666667
2848, 0.93333333333333, 1.4, 0.2
2849, 0.93333333333333, 1.4, 0.23333333333333
2850, 0.93333333333333, 1.4, 0.26666666666667
2851, 0.93333333333333, 1.4, 0.3
2852, 0.93333333333333, 1.4, 0.33333333333333
2853, 0.93333333333333, 1.4, 0.36666666666667
2854, 0.93333333333333, 1.4, 0.4
2855, 0.93333333333333, 1.4, 0.43333333333333
2856, 0.93333333333333, 1.4, 0.46666666666667
2857, 1.2666666666667, 1.2, 0.033333333333333
2858, 1.3333333333333, 1.2, 0.033333333333333
2859, 1.4, 1.2, 0.033333333333333
2860, 1.4666666666667, 1.2, 0.033333333333333
2861, 1.5333333333333, 1.2, 0.033333333333333
2862, 1.6, 1.2, 0.033333333333333
2863, 1.6666666666667, 1.2, 0.033333333333333
2864, 1.7333333333333, 1.2, 0.033333333333333
2865, 1.8, 1.2, 0.033333333333333
2866, 1.8666666666667, 1.2, 0.033333333333333
2867, 1.9333333333333, 1.2, 0.033333333333333
2868, 2, 1.2, 0.033333333333333
2869, 2.0666666666667, 1.2, 0.033333333333333
2870, 2.1333333333333, 1.2, 0.033333333333333
2871, 1.2666666666667, 1.2, 0.066666666666667
2872, 1.3333333333333, 1.2, 0.066666666666667
