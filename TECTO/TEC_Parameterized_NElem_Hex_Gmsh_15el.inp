9486, 2, 0.67333333333333, 0.33333333333333
9487, 2, 0.62, 0.33333333333333
9488, 2, 0.56666666666667, 0.33333333333333
9489, 2, 0.51333333333333, 0.33333333333333
9490, 2, 0.46, 0.33333333333333
9491, 2, 0.40666666666667, 0.33333333333333
9492, 2, 0.35333333333333, 0.33333333333333
9493, 2.0666666666667, 1.0466666666667, 0.33333333333333
9494, 2.0666666666667, 0.99333333333333, 0.33333333333333
9495, 2.0666666666667, 0.94, 0.33333333333333
9496, 2.0666666666667, 0.88666666666667, 0.33333333333333
9497, 2.0666666666667, 0.83333333333333, 0.33333333333333
9498, 2.0666666666667, 0.78, 0.33333333333333
9499, 2.0666666666667, 0.72666666666667, 0.33333333333333
9500, 2.0666666666667, 0.67333333333333, 0.33333333333333
9501, 2.0666666666667, 0.62, 0.33333333333333
9502, 2.0666666666667, 0.56666666666667, 0.33333333333333
9503, 2.0666666666667, 0.51333333333333, 0.33333333333333
9504, 2.0666666666667, 0.46, 0.33333333333333
9505, 2.0666666666667, 0.40666666666667, 0.33333333333333
9506, 2.0666666666667, 0.35333333333333, 0.33333333333333
9507, 2.1333333333333, 1.0466666666667, 0.33333333333333
9508, 2.1333333333333, 0.99333333333333, 0.33333333333333
9509, 2.1333333333333, 0.94, 0.33333333333333
9510, 2.1333333333333, 0.88666666666667, 0.33333333333333
9511, 2.1333333333333, 0.83333333333333, 0.33333333333333
9512, 2.1333333333333, 0.78, 0.33333333333333
9513, 2.1333333333333, 0.72666666666667, 0.33333333333333
9514, 2.1333333333333, 0.67333333333333, 0.33333333333333
9515, 2.1333333333333, 0.62, 0.33333333333333
9516, 2.1333333333333, 0.56666666666667, 0.33333333333333
9517, 2.1333333333333, 0.51333333333333, 0.33333333333333
9518, 2.1333333333333, 0.46, 0.33333333333333
9519, 2.1333333333333, 0.40666666666667, 0.33333333333333
9520, 2.1333333333333, 0.35333333333333, 0.33333333333333
9521, 1.2666666666667, 1.0466666666667, 0.36666666666667
9522, 1.2666666666667, 0.99333333333333, 0.36666666666667
9523, 1.2666666666667, 0.94, 0.36666666666667
9524, 1.2666666666667, 0.88666666666667, 0.36666666666667
9525, 1.2666666666667, 0.83333333333333, 0.36666666666667
9526, 1.2666666666667, 0.78, 0.36666666666667
9527, 1.2666666666667, 0.72666666666667, 0.36666666666667
9528, 1.2666666666667, 0.67333333333333, 0.36666666666667
9529, 1.2666666666667, 0.62, 0.36666666666667
9530, 1.2666666666667, 0.56666666666667, 0.36666666666667
9531, 1.2666666666667, 0.51333333333333, 0.36666666666667
9532, 1.2666666666667, 0.46, 0.36666666666667
9533, 1.2666666666667, 0.40666666666667, 0.36666666666667
9534, 1.2666666666667, 0.35333333333333, 0.36666666666667
9535, 1.3333333333333, 1.0466666666667, 0.36666666666667
9536, 1.3333333333333, 0.99333333333333, 0.36666666666667
9537, 1.3333333333333, 0.94, 0.36666666666667
9538, 1.3333333333333, 0.88666666666667, 0.36666666666667
9539, 1.3333333333333, 0.83333333333333, 0.36666666666667
9540, 1.3333333333333, 0.78, 0.36666666666667
9541, 1.3333333333333, 0.72666666666667, 0.36666666666667
9542, 1.3333333333333, 0.67333333333333, 0.36666666666667
9543, 1.3333333333333, 0.62, 0.36666666666667
9544, 1.3333333333333, 0.56666666666667, 0.36666666666667
9545, 1.3333333333333, 0.51333333333333, 0.36666666666667
9546, 1.3333333333333, 0.46, 0.36666666666667
9547, 1.3333333333333, 0.40666666666667, 0.36666666666667
9548, 1.3333333333333, 0.35333333333333, 0.36666666666667
9549, 1.4, 1.0466666666667, 0.36666666666667
9550, 1.4, 0.99333333333333, 0.36666666666667
9551, 1.4, 0.94, 0.36666666666667
9552, 1.4, 0.88666666666667, 0.36666666666667
9553, 1.4, 0.83333333333333, 0.36666666666667
9554, 1.4, 0.78, 0.36666666666667
9555, 1.4, 0.72666666666667, 0.36666666666667
9556, 1.4, 0.67333333333333, 0.36666666666667
9557, 1.4, 0.62, 0.36666666666667
9558, 1.4, 0.56666666666667, 0.36666666666667
9559, 1.4, 0.51333333333333, 0.36666666666667
9560, 1.4, 0.46, 0.36666666666667
9561, 1.4, 0.40666666666667, 0.36666666666667
9562, 1.4, 0.35333333333333, 0.36666666666667
9563, 1.4666666666667, 1.0466666666667, 0.36666666666667
9564, 1.4666666666667, 0.99333333333333, 0.36666666666667
9565, 1.4666666666667, 0.94, 0.36666666666667
9566, 1.4666666666667, 0.88666666666667, 0.36666666666667
9567, 1.4666666666667, 0.83333333333333, 0.36666666666667
9568, 1.4666666666667, 0.78, 0.36666666666667
9569, 1.4666666666667, 0.72666666666667, 0.36666666666667
9570, 1.4666666666667, 0.67333333333333, 0.36666666666667
9571, 1.4666666666667, 0.62, 0.36666666666667
9572, 1.4666666666667, 0.56666666666667, 0.36666666666667
9573, 1.4666666666667, 0.51333333333333, 0.36666666666667
9574, 1.4666666666667, 0.46, 0.36666666666667
9575, 1.4666666666667, 0.40666666666667, 0.36666666666667
9576, 1.4666666666667, 0.35333333333333, 0.36666666666667
9577, 1.5333333333333, 1.0466666666667, 0.36666666666667
9578, 1.5333333333333, 0.99333333333333, 0.36666666666667
9579, 1.5333333333333, 0.94, 0.36666666666667
9580, 1.5333333333333, 0.88666666666667, 0.36666666666667
9581, 1.5333333333333, 0.83333333333333, 0.36666666666667
9582, 1.5333333333333, 0.78, 0.36666666666667
9583, 1.5333333333333, 0.72666666666667, 0.36666666666667
9584, 1.5333333333333, 0.67333333333333, 0.36666666666667
9585, 1.5333333333333, 0.62, 0.36666666666667
9586, 1.5333333333333, 0.56666666666667, 0.36666666666667
9587, 1.5333333333333, 0.51333333333333, 0.36666666666667
9588, 1.5333333333333, 0.46, 0.36666666666667
9589, 1.5333333333333, 0.40666666666667, 0.36666666666667
9590, 1.5333333333333, 0.35333333333333, 0.36666666666667
9591, 1.6, 1.0466666666667, 0.36666666666667
9592, 1.6, 0.99333333333333, 0.36666666666667
9593, 1.6, 0.94, 0.36666666666667
9594, 1.6, 0.88666666666667, 0.36666666666667
9595, 1.6, 0.83333333333333, 0.36666666666667
9596, 1.6, 0.78, 0.36666666666667
9597, 1.6, 0.72666666666667, 0.36666666666667
9598, 1.6, 0.67333333333333, 0.36666666666667
9599, 1.6, 0.62, 0.36666666666667
9600, 1.6, 0.56666666666667, 0.36666666666667
9601, 1.6, 0.51333333333333, 0.36666666666667
9602, 1.6, 0.46, 0.36666666666667
9603, 1.6, 0.40666666666667, 0.36666666666667
9604, 1.6, 0.35333333333333, 0.36666666666667
9605, 1.6666666666667, 1.0466666666667, 0.36666666666667
9606, 1.6666666666667, 0.99333333333333, 0.36666666666667
9607, 1.6666666666667, 0.94, 0.36666666666667
9608, 1.6666666666667, 0.88666666666667, 0.36666666666667
9609, 1.6666666666667, 0.83333333333333, 0.36666666666667
9610, 1.6666666666667, 0.78, 0.36666666666667
9611, 1.6666666666667, 0.72666666666667, 0.36666666666667
9612, 1.6666666666667, 0.67333333333333, 0.36666666666667
9613, 1.6666666666667, 0.62, 0.36666666666667
9614, 1.6666666666667, 0.56666666666667, 0.36666666666667
9615, 1.6666666666667, 0.51333333333333, 0.36666666666667
9616, 1.6666666666667, 0.46, 0.36666666666667
9617, 1.6666666666667, 0.40666666666667, 0.36666666666667
9618, 1.6666666666667, 0.35333333333333, 0.36666666666667
9619, 1.7333333333333, 1.0466666666667, 0.36666666666667
9620, 1.7333333333333, 0.99333333333333, 0.36666666666667
9621, 1.7333333333333, 0.94, 0.36666666666667
9622, 1.7333333333333, 0.88666666666667, 0.36666666666667
9623, 1.7333333333333, 0.83333333333333, 0.36666666666667
9624, 1.7333333333333, 0.78, 0.36666666666667
9625, 1.7333333333333, 0.72666666666667, 0.36666666666667
9626, 1.7333333333333, 0.67333333333333, 0.36666666666667
9627, 1.7333333333333, 0.62, 0.36666666666667
9628, 1.7333333333333, 0.56666666666667, 0.36666666666667
9629, 1.7333333333333, 0.51333333333333, 0.36666666666667
9630, 1.7333333333333, 0.46, 0.36666666666667
9631, 1.7333333333333, 0.40666666666667, 0.36666666666667
9632, 1.7333333333333, 0.35333333333333, 0.36666666666667
9633, 1.8, 1.0466666666667, 0.36666666666667
9634, 1.8, 0.99333333333333, 0.36666666666667
9635, 1.8, 0.94, 0.36666666666667
9636, 1.8, 0.88666666666667, 0.36666666666667
9637, 1.8, 0.83333333333333, 0.36666666666667
9638, 1.8, 0.78, 0.36666666666667
9639, 1.8, 0.72666666666667, 0.36666666666667
9640, 1.8, 0.67333333333333, 0.36666666666667
9641, 1.8, 0.62, 0.36666666666667
9642, 1.8, 0.56666666666667, 0.36666666666667
9643, 1.8, 0.51333333333333, 0.36666666666667
9644, 1.8, 0.46, 0.36666666666667
9645, 1.8, 0.40666666666667, 0.36666666666667
9646, 1.8, 0.35333333333333, 0.36666666666667
9647, 1.8666666666667, 1.0466666666667, 0.36666666666667
9648, 1.8666666666667, 0.99333333333333, 0.36666666666667
9649, 1.8666666666667, 0.94, 0.36666666666667
9650, 1.8666666666667, 0.88666666666667, 0.36666666666667
9651, 1.8666666666667, 0.83333333333333, 0.36666666666667
9652, 1.8666666666667, 0.78, 0.36666666666667
9653, 1.8666666666667, 0.72666666666667, 0.36666666666667
9654, 1.8666666666667, 0.67333333333333, 0.36666666666667
9655, 1.8666666666667, 0.62, 0.36666666666667
9656, 1.8666666666667, 0.56666666666667, 0.36666666666667
9657, 1.8666666666667, 0.51333333333333, 0.36666666666667
9658, 1.8666666666667, 0.46, 0.36666666666667
9659, 1.8666666666667, 0.40666666666667, 0.36666666666667
9660, 1.8666666666667, 0.35333333333333, 0.36666666666667
9661, 1.9333333333333, 1.0466666666667, 0.36666666666667
9662, 1.9333333333333, 0.99333333333333, 0.36666666666667
9663, 1.9333333333333, 0.94, 0.36666666666667
9664, 1.9333333333333, 0.88666666666667, 0.36666666666667
9665, 1.9333333333333, 0.83333333333333, 0.36666666666667
9666, 1.9333333333333, 0.78, 0.36666666666667
9667, 1.9333333333333, 0.72666666666667, 0.36666666666667
9668, 1.9333333333333, 0.67333333333333, 0.36666666666667
9669, 1.9333333333333, 0.62, 0.36666666666667
9670, 1.9333333333333, 0.56666666666667, 0.36666666666667
9671, 1.9333333333333, 0.51333333333333, 0.36666666666667
9672, 1.9333333333333, 0.46, 0.36666666666667
9673, 1.9333333333333, 0.40666666666667, 0.36666666666667
9674, 1.9333333333333, 0.35333333333333, 0.36666666666667
9675, 2, 1.0466666666667, 0.36666666666667
9676, 2, 0.99333333333333, 0.36666666666667
9677, 2, 0.94, 0.36666666666667
9678, 2, 0.88666666666667, 0.36666666666667
9679, 2, 0.83333333333333, 0.36666666666667
9680, 2, 0.78, 0.36666666666667
9681, 2, 0.72666666666667, 0.36666666666667
9682, 2, 0.67333333333333, 0.36666666666667
9683, 2, 0.62, 0.36666666666667
9684, 2, 0.56666666666667, 0.36666666666667
9685, 2, 0.51333333333333, 0.36666666666667
9686, 2, 0.46, 0.36666666666667
9687, 2, 0.40666666666667, 0.36666666666667
9688, 2, 0.35333333333333, 0.36666666666667
9689, 2.0666666666667, 1.0466666666667, 0.36666666666667
9690, 2.0666666666667, 0.99333333333333, 0.36666666666667
9691, 2.0666666666667, 0.94, 0.36666666666667
9692, 2.0666666666667, 0.88666666666667, 0.36666666666667
9693, 2.0666666666667, 0.83333333333333, 0.36666666666667
9694, 2.0666666666667, 0.78, 0.36666666666667
9695, 2.0666666666667, 0.72666666666667, 0.36666666666667
9696, 2.0666666666667, 0.67333333333333, 0.36666666666667
9697, 2.0666666666667, 0.62, 0.36666666666667
9698, 2.0666666666667, 0.56666666666667, 0.36666666666667
9699, 2.0666666666667, 0.51333333333333, 0.36666666666667
9700, 2.0666666666667, 0.46, 0.36666666666667
9701, 2.0666666666667, 0.40666666666667, 0.36666666666667
9702, 2.0666666666667, 0.35333333333333, 0.36666666666667
9703, 2.1333333333333, 1.0466666666667, 0.36666666666667
9704, 2.1333333333333, 0.99333333333333, 0.36666666666667
9705, 2.1333333333333, 0.94, 0.36666666666667
9706, 2.1333333333333, 0.88666666666667, 0.36666666666667
9707, 2.1333333333333, 0.83333333333333, 0.36666666666667
9708, 2.1333333333333, 0.78, 0.36666666666667
9709, 2.1333333333333, 0.72666666666667, 0.36666666666667
9710, 2.1333333333333, 0.67333333333333, 0.36666666666667
9711, 2.1333333333333, 0.62, 0.36666666666667
9712, 2.1333333333333, 0.56666666666667, 0.36666666666667
9713, 2.1333333333333, 0.51333333333333, 0.36666666666667
9714, 2.1333333333333, 0.46, 0.36666666666667
9715, 2.1333333333333, 0.40666666666667, 0.36666666666667
9716, 2.1333333333333, 0.35333333333333, 0.36666666666667
9717, 1.2666666666667, 1.0466666666667, 0.4
9718, 1.2666666666667, 0.99333333333333, 0.4
9719, 1.2666666666667, 0.94, 0.4
9720, 1.2666666666667, 0.88666666666667, 0.4
9721, 1.2666666666667, 0.83333333333333, 0.4
9722, 1.2666666666667, 0.78, 0.4
9723, 1.2666666666667, 0.72666666666667, 0.4
9724, 1.2666666666667, 0.67333333333333, 0.4
9725, 1.2666666666667, 0.62, 0.4
9726, 1.2666666666667, 0.56666666666667, 0.4
9727, 1.2666666666667, 0.51333333333333, 0.4
9728, 1.2666666666667, 0.46, 0.4
9729, 1.2666666666667, 0.40666666666667, 0.4
9730, 1.2666666666667, 0.35333333333333, 0.4
9731, 1.3333333333333, 1.0466666666667, 0.4
9732, 1.3333333333333, 0.99333333333333, 0.4
9733, 1.3333333333333, 0.94, 0.4
9734, 1.3333333333333, 0.88666666666667, 0.4
9735, 1.3333333333333, 0.83333333333333, 0.4
9736, 1.3333333333333, 0.78, 0.4
9737, 1.3333333333333, 0.72666666666667, 0.4
9738, 1.3333333333333, 0.67333333333333, 0.4
9739, 1.3333333333333, 0.62, 0.4
9740, 1.3333333333333, 0.56666666666667, 0.4
9741, 1.3333333333333, 0.51333333333333, 0.4
9742, 1.3333333333333, 0.46, 0.4
9743, 1.3333333333333, 0.40666666666667, 0.4
9744, 1.3333333333333, 0.35333333333333, 0.4
9745, 1.4, 1.0466666666667, 0.4
9746, 1.4, 0.99333333333333, 0.4
9747, 1.4, 0.94, 0.4
9748, 1.4, 0.88666666666667, 0.4
9749, 1.4, 0.83333333333333, 0.4
9750, 1.4, 0.78, 0.4
9751, 1.4, 0.72666666666667, 0.4
9752, 1.4, 0.67333333333333, 0.4
9753, 1.4, 0.62, 0.4
9754, 1.4, 0.56666666666667, 0.4
9755, 1.4, 0.51333333333333, 0.4
9756, 1.4, 0.46, 0.4
9757, 1.4, 0.40666666666667, 0.4
9758, 1.4, 0.35333333333333, 0.4
9759, 1.4666666666667, 1.0466666666667, 0.4
9760, 1.4666666666667, 0.99333333333333, 0.4
9761, 1.4666666666667, 0.94, 0.4
9762, 1.4666666666667, 0.88666666666667, 0.4
9763, 1.4666666666667, 0.83333333333333, 0.4
9764, 1.4666666666667, 0.78, 0.4
9765, 1.4666666666667, 0.72666666666667, 0.4
9766, 1.4666666666667, 0.67333333333333, 0.4
9767, 1.4666666666667, 0.62, 0.4
9768, 1.4666666666667, 0.56666666666667, 0.4
9769, 1.4666666666667, 0.51333333333333, 0.4
9770, 1.4666666666667, 0.46, 0.4
9771, 1.4666666666667, 0.40666666666667, 0.4
9772, 1.4666666666667, 0.35333333333333, 0.4
9773, 1.5333333333333, 1.0466666666667, 0.4
9774, 1.5333333333333, 0.99333333333333, 0.4
9775, 1.5333333333333, 0.94, 0.4
9776, 1.5333333333333, 0.88666666666667, 0.4
9777, 1.5333333333333, 0.83333333333333, 0.4
9778, 1.5333333333333, 0.78, 0.4
9779, 1.5333333333333, 0.72666666666667, 0.4
9780, 1.5333333333333, 0.67333333333333, 0.4
9781, 1.5333333333333, 0.62, 0.4
9782, 1.5333333333333, 0.56666666666667, 0.4
9783, 1.5333333333333, 0.51333333333333, 0.4
9784, 1.5333333333333, 0.46, 0.4
9785, 1.5333333333333, 0.40666666666667, 0.4
9786, 1.5333333333333, 0.35333333333333, 0.4
9787, 1.6, 1.0466666666667, 0.4
9788, 1.6, 0.99333333333333, 0.4
9789, 1.6, 0.94, 0.4
9790, 1.6, 0.88666666666667, 0.4
9791, 1.6, 0.83333333333333, 0.4
9792, 1.6, 0.78, 0.4
9793, 1.6, 0.72666666666667, 0.4
9794, 1.6, 0.67333333333333, 0.4
9795, 1.6, 0.62, 0.4
9796, 1.6, 0.56666666666667, 0.4
9797, 1.6, 0.51333333333333, 0.4
9798, 1.6, 0.46, 0.4
9799, 1.6, 0.40666666666667, 0.4
9800, 1.6, 0.35333333333333, 0.4
9801, 1.6666666666667, 1.0466666666667, 0.4
9802, 1.6666666666667, 0.99333333333333, 0.4
9803, 1.6666666666667, 0.94, 0.4
9804, 1.6666666666667, 0.88666666666667, 0.4
9805, 1.6666666666667, 0.83333333333333, 0.4
9806, 1.6666666666667, 0.78, 0.4
9807, 1.6666666666667, 0.72666666666667, 0.4
9808, 1.6666666666667, 0.67333333333333, 0.4
9809, 1.6666666666667, 0.62, 0.4
9810, 1.6666666666667, 0.56666666666667, 0.4
9811, 1.6666666666667, 0.51333333333333, 0.4
9812, 1.6666666666667, 0.46, 0.4
9813, 1.6666666666667, 0.40666666666667, 0.4
9814, 1.6666666666667, 0.35333333333333, 0.4
9815, 1.7333333333333, 1.0466666666667, 0.4
9816, 1.7333333333333, 0.99333333333333, 0.4
9817, 1.7333333333333, 0.94, 0.4
9818, 1.7333333333333, 0.88666666666667, 0.4
9819, 1.7333333333333, 0.83333333333333, 0.4
9820, 1.7333333333333, 0.78, 0.4
9821, 1.7333333333333, 0.72666666666667, 0.4
9822, 1.7333333333333, 0.67333333333333, 0.4
9823, 1.7333333333333, 0.62, 0.4
9824, 1.7333333333333, 0.56666666666667, 0.4
9825, 1.7333333333333, 0.51333333333333, 0.4
9826, 1.7333333333333, 0.46, 0.4
9827, 1.7333333333333, 0.40666666666667, 0.4
9828, 1.7333333333333, 0.35333333333333, 0.4
9829, 1.8, 1.0466666666667, 0.4
9830, 1.8, 0.99333333333333, 0.4
9831, 1.8, 0.94, 0.4
9832, 1.8, 0.88666666666667, 0.4
9833, 1.8, 0.83333333333333, 0.4
9834, 1.8, 0.78, 0.4
9835, 1.8, 0.72666666666667, 0.4
9836, 1.8, 0.67333333333333, 0.4
9837, 1.8, 0.62, 0.4
9838, 1.8, 0.56666666666667, 0.4
9839, 1.8, 0.51333333333333, 0.4
9840, 1.8, 0.46, 0.4
9841, 1.8, 0.40666666666667, 0.4
9842, 1.8, 0.35333333333333, 0.4
9843, 1.8666666666667, 1.0466666666667, 0.4
9844, 1.8666666666667, 0.99333333333333, 0.4
9845, 1.8666666666667, 0.94, 0.4
9846, 1.8666666666667, 0.88666666666667, 0.4
9847, 1.8666666666667, 0.83333333333333, 0.4
9848, 1.8666666666667, 0.78, 0.4
9849, 1.8666666666667, 0.72666666666667, 0.4
9850, 1.8666666666667, 0.67333333333333, 0.4
9851, 1.8666666666667, 0.62, 0.4
9852, 1.8666666666667, 0.56666666666667, 0.4
9853, 1.8666666666667, 0.51333333333333, 0.4
9854, 1.8666666666667, 0.46, 0.4
9855, 1.8666666666667, 0.40666666666667, 0.4
9856, 1.8666666666667, 0.35333333333333, 0.4
9857, 1.9333333333333, 1.0466666666667, 0.4
9858, 1.9333333333333, 0.99333333333333, 0.4
9859, 1.9333333333333, 0.94, 0.4
9860, 1.9333333333333, 0.88666666666667, 0.4
9861, 1.9333333333333, 0.83333333333333, 0.4
9862, 1.9333333333333, 0.78, 0.4
9863, 1.9333333333333, 0.72666666666667, 0.4
9864, 1.9333333333333, 0.67333333333333, 0.4
9865, 1.9333333333333, 0.62, 0.4
9866, 1.9333333333333, 0.56666666666667, 0.4
9867, 1.9333333333333, 0.51333333333333, 0.4
9868, 1.9333333333333, 0.46, 0.4
9869, 1.9333333333333, 0.40666666666667, 0.4
9870, 1.9333333333333, 0.35333333333333, 0.4
9871, 2, 1.0466666666667, 0.4
9872, 2, 0.99333333333333, 0.4
9873, 2, 0.94, 0.4
9874, 2, 0.88666666666667, 0.4
9875, 2, 0.83333333333333, 0.4
9876, 2, 0.78, 0.4
9877, 2, 0.72666666666667, 0.4
9878, 2, 0.67333333333333, 0.4
9879, 2, 0.62, 0.4
9880, 2, 0.56666666666667, 0.4
9881, 2, 0.51333333333333, 0.4
9882, 2, 0.46, 0.4
9883, 2, 0.40666666666667, 0.4
9884, 2, 0.35333333333333, 0.4
9885, 2.0666666666667, 1.0466666666667, 0.4
9886, 2.0666666666667, 0.99333333333333, 0.4
9887, 2.0666666666667, 0.94, 0.4
9888, 2.0666666666667, 0.88666666666667, 0.4
9889, 2.0666666666667, 0.83333333333333, 0.4
9890, 2.0666666666667, 0.78, 0.4
9891, 2.0666666666667, 0.72666666666667, 0.4
9892, 2.0666666666667, 0.67333333333333, 0.4
9893, 2.0666666666667, 0.62, 0.4
9894, 2.0666666666667, 0.56666666666667, 0.4
9895, 2.0666666666667, 0.51333333333333, 0.4
9896, 2.0666666666667, 0.46, 0.4
9897, 2.0666666666667, 0.40666666666667, 0.4
9898, 2.0666666666667, 0.35333333333333, 0.4
9899, 2.1333333333333, 1.0466666666667, 0.4
9900, 2.1333333333333, 0.99333333333333, 0.4
9901, 2.1333333333333, 0.94, 0.4
9902, 2.1333333333333, 0.88666666666667, 0.4
9903, 2.1333333333333, 0.83333333333333, 0.4
9904, 2.1333333333333, 0.78, 0.4
9905, 2.1333333333333, 0.72666666666667, 0.4
9906, 2.1333333333333, 0.67333333333333, 0.4
9907, 2.1333333333333, 0.62, 0.4
9908, 2.1333333333333, 0.56666666666667, 0.4
9909, 2.1333333333333, 0.51333333333333, 0.4
9910, 2.1333333333333, 0.46, 0.4
9911, 2.1333333333333, 0.40666666666667, 0.4
9912, 2.1333333333333, 0.35333333333333, 0.4
9913, 1.2666666666667, 1.0466666666667, 0.43333333333333
9914, 1.2666666666667, 0.99333333333333, 0.43333333333333
9915, 1.2666666666667, 0.94, 0.43333333333333
9916, 1.2666666666667, 0.88666666666667, 0.43333333333333
9917, 1.2666666666667, 0.83333333333333, 0.43333333333333
9918, 1.2666666666667, 0.78, 0.43333333333333
9919, 1.2666666666667, 0.72666666666667, 0.43333333333333
9920, 1.2666666666667, 0.67333333333333, 0.43333333333333
9921, 1.2666666666667, 0.62, 0.43333333333333
9922, 1.2666666666667, 0.56666666666667, 0.43333333333333
9923, 1.2666666666667, 0.51333333333333, 0.43333333333333
9924, 1.2666666666667, 0.46, 0.43333333333333
9925, 1.2666666666667, 0.40666666666667, 0.43333333333333
9926, 1.2666666666667, 0.35333333333333, 0.43333333333333
9927, 1.3333333333333, 1.0466666666667, 0.43333333333333
9928, 1.3333333333333, 0.99333333333333, 0.43333333333333
9929, 1.3333333333333, 0.94, 0.43333333333333
9930, 1.3333333333333, 0.88666666666667, 0.43333333333333
9931, 1.3333333333333, 0.83333333333333, 0.43333333333333
9932, 1.3333333333333, 0.78, 0.43333333333333
9933, 1.3333333333333, 0.72666666666667, 0.43333333333333
9934, 1.3333333333333, 0.67333333333333, 0.43333333333333
9935, 1.3333333333333, 0.62, 0.43333333333333
9936, 1.3333333333333, 0.56666666666667, 0.43333333333333
9937, 1.3333333333333, 0.51333333333333, 0.43333333333333
9938, 1.3333333333333, 0.46, 0.43333333333333
9939, 1.3333333333333, 0.40666666666667, 0.43333333333333
9940, 1.3333333333333, 0.35333333333333, 0.43333333333333
9941, 1.4, 1.0466666666667, 0.43333333333333
9942, 1.4, 0.99333333333333, 0.43333333333333
9943, 1.4, 0.94, 0.43333333333333
9944, 1.4, 0.88666666666667, 0.43333333333333
9945, 1.4, 0.83333333333333, 0.43333333333333
9946, 1.4, 0.78, 0.43333333333333
9947, 1.4, 0.72666666666667, 0.43333333333333
9948, 1.4, 0.67333333333333, 0.43333333333333
9949, 1.4, 0.62, 0.43333333333333
9950, 1.4, 0.56666666666667, 0.43333333333333
9951, 1.4, 0.51333333333333, 0.43333333333333
9952, 1.4, 0.46, 0.43333333333333
9953, 1.4, 0.40666666666667, 0.43333333333333
9954, 1.4, 0.35333333333333, 0.43333333333333
9955, 1.4666666666667, 1.0466666666667, 0.43333333333333
9956, 1.4666666666667, 0.99333333333333, 0.43333333333333
9957, 1.4666666666667, 0.94, 0.43333333333333
9958, 1.4666666666667, 0.88666666666667, 0.43333333333333
9959, 1.4666666666667, 0.83333333333333, 0.43333333333333
9960, 1.4666666666667, 0.78, 0.43333333333333
9961, 1.4666666666667, 0.72666666666667, 0.43333333333333
9962, 1.4666666666667, 0.67333333333333, 0.43333333333333
9963, 1.4666666666667, 0.62, 0.43333333333333
9964, 1.4666666666667, 0.56666666666667, 0.43333333333333
9965, 1.4666666666667, 0.51333333333333, 0.43333333333333
9966, 1.4666666666667, 0.46, 0.43333333333333
9967, 1.4666666666667, 0.40666666666667, 0.43333333333333
9968, 1.4666666666667, 0.35333333333333, 0.43333333333333
9969, 1.5333333333333, 1.0466666666667, 0.43333333333333
9970, 1.5333333333333, 0.99333333333333, 0.43333333333333
9971, 1.5333333333333, 0.94, 0.43333333333333
9972, 1.5333333333333, 0.88666666666667, 0.43333333333333
9973, 1.5333333333333, 0.83333333333333, 0.43333333333333
9974, 1.5333333333333, 0.78, 0.43333333333333
9975, 1.5333333333333, 0.72666666666667, 0.43333333333333
9976, 1.5333333333333, 0.67333333333333, 0.43333333333333
9977, 1.5333333333333, 0.62, 0.43333333333333
9978, 1.5333333333333, 0.56666666666667, 0.43333333333333
9979, 1.5333333333333, 0.51333333333333, 0.43333333333333
9980, 1.5333333333333, 0.46, 0.43333333333333
9981, 1.5333333333333, 0.40666666666667, 0.43333333333333
9982, 1.5333333333333, 0.35333333333333, 0.43333333333333
9983, 1.6, 1.0466666666667, 0.43333333333333
9984, 1.6, 0.99333333333333, 0.43333333333333
9985, 1.6, 0.94, 0.43333333333333
9986, 1.6, 0.88666666666667, 0.43333333333333
9987, 1.6, 0.83333333333333, 0.43333333333333
9988, 1.6, 0.78, 0.43333333333333
9989, 1.6, 0.72666666666667, 0.43333333333333
9990, 1.6, 0.67333333333333, 0.43333333333333
9991, 1.6, 0.62, 0.43333333333333
9992, 1.6, 0.56666666666667, 0.43333333333333
9993, 1.6, 0.51333333333333, 0.43333333333333
9994, 1.6, 0.46, 0.43333333333333
9995, 1.6, 0.40666666666667, 0.43333333333333
9996, 1.6, 0.35333333333333, 0.43333333333333
9997, 1.6666666666667, 1.0466666666667, 0.43333333333333
9998, 1.6666666666667, 0.99333333333333, 0.43333333333333
9999, 1.6666666666667, 0.94, 0.43333333333333
10000, 1.6666666666667, 0.88666666666667, 0.43333333333333
10001, 1.6666666666667, 0.83333333333333, 0.43333333333333
10002, 1.6666666666667, 0.78, 0.43333333333333
10003, 1.6666666666667, 0.72666666666667, 0.43333333333333
10004, 1.6666666666667, 0.67333333333333, 0.43333333333333
10005, 1.6666666666667, 0.62, 0.43333333333333
10006, 1.6666666666667, 0.56666666666667, 0.43333333333333
10007, 1.6666666666667, 0.51333333333333, 0.43333333333333
10008, 1.6666666666667, 0.46, 0.43333333333333
10009, 1.6666666666667, 0.40666666666667, 0.43333333333333
10010, 1.6666666666667, 0.35333333333333, 0.43333333333333
10011, 1.7333333333333, 1.0466666666667, 0.43333333333333
10012, 1.7333333333333, 0.99333333333333, 0.43333333333333
10013, 1.7333333333333, 0.94, 0.43333333333333
10014, 1.7333333333333, 0.88666666666667, 0.43333333333333
10015, 1.7333333333333, 0.83333333333333, 0.43333333333333
10016, 1.7333333333333, 0.78, 0.43333333333333
10017, 1.7333333333333, 0.72666666666667, 0.43333333333333
10018, 1.7333333333333, 0.67333333333333, 0.43333333333333
10019, 1.7333333333333, 0.62, 0.43333333333333
10020, 1.7333333333333, 0.56666666666667, 0.43333333333333
10021, 1.7333333333333, 0.51333333333333, 0.43333333333333
10022, 1.7333333333333, 0.46, 0.43333333333333
10023, 1.7333333333333, 0.40666666666667, 0.43333333333333
10024, 1.7333333333333, 0.35333333333333, 0.43333333333333
10025, 1.8, 1.0466666666667, 0.43333333333333
10026, 1.8, 0.99333333333333, 0.43333333333333
10027, 1.8, 0.94, 0.43333333333333
10028, 1.8, 0.88666666666667, 0.43333333333333
10029, 1.8, 0.83333333333333, 0.43333333333333
10030, 1.8, 0.78, 0.43333333333333
10031, 1.8, 0.72666666666667, 0.43333333333333
10032, 1.8, 0.67333333333333, 0.43333333333333
10033, 1.8, 0.62, 0.43333333333333
10034, 1.8, 0.56666666666667, 0.43333333333333
10035, 1.8, 0.51333333333333, 0.43333333333333
10036, 1.8, 0.46, 0.43333333333333
10037, 1.8, 0.40666666666667, 0.43333333333333
10038, 1.8, 0.35333333333333, 0.43333333333333
10039, 1.8666666666667, 1.0466666666667, 0.43333333333333
10040, 1.8666666666667, 0.99333333333333, 0.43333333333333
10041, 1.8666666666667, 0.94, 0.43333333333333
10042, 1.8666666666667, 0.88666666666667, 0.43333333333333
10043, 1.8666666666667, 0.83333333333333, 0.43333333333333
10044, 1.8666666666667, 0.78, 0.43333333333333
10045, 1.8666666666667, 0.72666666666667, 0.43333333333333
10046, 1.8666666666667, 0.67333333333333, 0.43333333333333
10047, 1.8666666666667, 0.62, 0.43333333333333
10048, 1.8666666666667, 0.56666666666667, 0.43333333333333
10049, 1.8666666666667, 0.51333333333333, 0.43333333333333
10050, 1.8666666666667, 0.46, 0.43333333333333
10051, 1.8666666666667, 0.40666666666667, 0.43333333333333
10052, 1.8666666666667, 0.35333333333333, 0.43333333333333
10053, 1.9333333333333, 1.0466666666667, 0.43333333333333
10054, 1.9333333333333, 0.99333333333333, 0.43333333333333
10055, 1.9333333333333, 0.94, 0.43333333333333
10056, 1.9333333333333, 0.88666666666667, 0.43333333333333
10057, 1.9333333333333, 0.83333333333333, 0.43333333333333
10058, 1.9333333333333, 0.78, 0.43333333333333
10059, 1.9333333333333, 0.72666666666667, 0.43333333333333
10060, 1.9333333333333, 0.67333333333333, 0.43333333333333
10061, 1.9333333333333, 0.62, 0.43333333333333
10062, 1.9333333333333, 0.56666666666667, 0.43333333333333
10063, 1.9333333333333, 0.51333333333333, 0.43333333333333
10064, 1.9333333333333, 0.46, 0.43333333333333
10065, 1.9333333333333, 0.40666666666667, 0.43333333333333
10066, 1.9333333333333, 0.35333333333333, 0.43333333333333
10067, 2, 1.0466666666667, 0.43333333333333
10068, 2, 0.99333333333333, 0.43333333333333
10069, 2, 0.94, 0.43333333333333
10070, 2, 0.88666666666667, 0.43333333333333
10071, 2, 0.83333333333333, 0.43333333333333
10072, 2, 0.78, 0.43333333333333
10073, 2, 0.72666666666667, 0.43333333333333
10074, 2, 0.67333333333333, 0.43333333333333
10075, 2, 0.62, 0.43333333333333
10076, 2, 0.56666666666667, 0.43333333333333
10077, 2, 0.51333333333333, 0.43333333333333
10078, 2, 0.46, 0.43333333333333
10079, 2, 0.40666666666667, 0.43333333333333
10080, 2, 0.35333333333333, 0.43333333333333
10081, 2.0666666666667, 1.0466666666667, 0.43333333333333
10082, 2.0666666666667, 0.99333333333333, 0.43333333333333
10083, 2.0666666666667, 0.94, 0.43333333333333
10084, 2.0666666666667, 0.88666666666667, 0.43333333333333
10085, 2.0666666666667, 0.83333333333333, 0.43333333333333
10086, 2.0666666666667, 0.78, 0.43333333333333
10087, 2.0666666666667, 0.72666666666667, 0.43333333333333
10088, 2.0666666666667, 0.67333333333333, 0.43333333333333
10089, 2.0666666666667, 0.62, 0.43333333333333
10090, 2.0666666666667, 0.56666666666667, 0.43333333333333
10091, 2.0666666666667, 0.51333333333333, 0.43333333333333
10092, 2.0666666666667, 0.46, 0.43333333333333
10093, 2.0666666666667, 0.40666666666667, 0.43333333333333
10094, 2.0666666666667, 0.35333333333333, 0.43333333333333
10095, 2.1333333333333, 1.0466666666667, 0.43333333333333
10096, 2.1333333333333, 0.99333333333333, 0.43333333333333
10097, 2.1333333333333, 0.94, 0.43333333333333
10098, 2.1333333333333, 0.88666666666667, 0.43333333333333
10099, 2.1333333333333, 0.83333333333333, 0.43333333333333
10100, 2.1333333333333, 0.78, 0.43333333333333
10101, 2.1333333333333, 0.72666666666667, 0.43333333333333
10102, 2.1333333333333, 0.67333333333333, 0.43333333333333
10103, 2.1333333333333, 0.62, 0.43333333333333
10104, 2.1333333333333, 0.56666666666667, 0.43333333333333
10105, 2.1333333333333, 0.51333333333333, 0.43333333333333
10106, 2.1333333333333, 0.46, 0.43333333333333
10107, 2.1333333333333, 0.40666666666667, 0.43333333333333
10108, 2.1333333333333, 0.35333333333333, 0.43333333333333
10109, 1.2666666666667, 1.0466666666667, 0.46666666666667
10110, 1.2666666666667, 0.99333333333333, 0.46666666666667
10111, 1.2666666666667, 0.94, 0.46666666666667
10112, 1.2666666666667, 0.88666666666667, 0.46666666666667
10113, 1.2666666666667, 0.83333333333333, 0.46666666666667
10114, 1.2666666666667, 0.78, 0.46666666666667
10115, 1.2666666666667, 0.72666666666667, 0.46666666666667
10116, 1.2666666666667, 0.67333333333333, 0.46666666666667
10117, 1.2666666666667, 0.62, 0.46666666666667
10118, 1.2666666666667, 0.56666666666667, 0.46666666666667
10119, 1.2666666666667, 0.51333333333333, 0.46666666666667
10120, 1.2666666666667, 0.46, 0.46666666666667
10121, 1.2666666666667, 0.40666666666667, 0.46666666666667
10122, 1.2666666666667, 0.35333333333333, 0.46666666666667
10123, 1.3333333333333, 1.0466666666667, 0.46666666666667
10124, 1.3333333333333, 0.99333333333333, 0.46666666666667
10125, 1.3333333333333, 0.94, 0.46666666666667
10126, 1.3333333333333, 0.88666666666667, 0.46666666666667
10127, 1.3333333333333, 0.83333333333333, 0.46666666666667
10128, 1.3333333333333, 0.78, 0.46666666666667
10129, 1.3333333333333, 0.72666666666667, 0.46666666666667
10130, 1.3333333333333, 0.67333333333333, 0.46666666666667
10131, 1.3333333333333, 0.62, 0.46666666666667
10132, 1.3333333333333, 0.56666666666667, 0.46666666666667
10133, 1.3333333333333, 0.51333333333333, 0.46666666666667
10134, 1.3333333333333, 0.46, 0.46666666666667
10135, 1.3333333333333, 0.40666666666667, 0.46666666666667
10136, 1.3333333333333, 0.35333333333333, 0.46666666666667
10137, 1.4, 1.0466666666667, 0.46666666666667
10138, 1.4, 0.99333333333333, 0.46666666666667
10139, 1.4, 0.94, 0.46666666666667
10140, 1.4, 0.88666666666667, 0.46666666666667
10141, 1.4, 0.83333333333333, 0.46666666666667
10142, 1.4, 0.78, 0.46666666666667
10143, 1.4, 0.72666666666667, 0.46666666666667
10144, 1.4, 0.67333333333333, 0.46666666666667
10145, 1.4, 0.62, 0.46666666666667
10146, 1.4, 0.56666666666667, 0.46666666666667
10147, 1.4, 0.51333333333333, 0.46666666666667
10148, 1.4, 0.46, 0.46666666666667
10149, 1.4, 0.40666666666667, 0.46666666666667
10150, 1.4, 0.35333333333333, 0.46666666666667
10151, 1.4666666666667, 1.0466666666667, 0.46666666666667
10152, 1.4666666666667, 0.99333333333333, 0.46666666666667
10153, 1.4666666666667, 0.94, 0.46666666666667
10154, 1.4666666666667, 0.88666666666667, 0.46666666666667
10155, 1.4666666666667, 0.83333333333333, 0.46666666666667
10156, 1.4666666666667, 0.78, 0.46666666666667
10157, 1.4666666666667, 0.72666666666667, 0.46666666666667
10158, 1.4666666666667, 0.67333333333333, 0.46666666666667
10159, 1.4666666666667, 0.62, 0.46666666666667
10160, 1.4666666666667, 0.56666666666667, 0.46666666666667
10161, 1.4666666666667, 0.51333333333333, 0.46666666666667
10162, 1.4666666666667, 0.46, 0.46666666666667
10163, 1.4666666666667, 0.40666666666667, 0.46666666666667
10164, 1.4666666666667, 0.35333333333333, 0.46666666666667
10165, 1.5333333333333, 1.0466666666667, 0.46666666666667
10166, 1.5333333333333, 0.99333333333333, 0.46666666666667
10167, 1.5333333333333, 0.94, 0.46666666666667
10168, 1.5333333333333, 0.88666666666667, 0.46666666666667
10169, 1.5333333333333, 0.83333333333333, 0.46666666666667
10170, 1.5333333333333, 0.78, 0.46666666666667
10171, 1.5333333333333, 0.72666666666667, 0.46666666666667
10172, 1.5333333333333, 0.67333333333333, 0.46666666666667
10173, 1.5333333333333, 0.62, 0.46666666666667
10174, 1.5333333333333, 0.56666666666667, 0.46666666666667
10175, 1.5333333333333, 0.51333333333333, 0.46666666666667
10176, 1.5333333333333, 0.46, 0.46666666666667
10177, 1.5333333333333, 0.40666666666667, 0.46666666666667
10178, 1.5333333333333, 0.35333333333333, 0.46666666666667
10179, 1.6, 1.0466666666667, 0.46666666666667
10180, 1.6, 0.99333333333333, 0.46666666666667
10181, 1.6, 0.94, 0.46666666666667
10182, 1.6, 0.88666666666667, 0.46666666666667
10183, 1.6, 0.83333333333333, 0.46666666666667
10184, 1.6, 0.78, 0.46666666666667
10185, 1.6, 0.72666666666667, 0.46666666666667
10186, 1.6, 0.67333333333333, 0.46666666666667
10187, 1.6, 0.62, 0.46666666666667
10188, 1.6, 0.56666666666667, 0.46666666666667
10189, 1.6, 0.51333333333333, 0.46666666666667
10190, 1.6, 0.46, 0.46666666666667
10191, 1.6, 0.40666666666667, 0.46666666666667
10192, 1.6, 0.35333333333333, 0.46666666666667
10193, 1.6666666666667, 1.0466666666667, 0.46666666666667
10194, 1.6666666666667, 0.99333333333333, 0.46666666666667
10195, 1.6666666666667, 0.94, 0.46666666666667
10196, 1.6666666666667, 0.88666666666667, 0.46666666666667
10197, 1.6666666666667, 0.83333333333333, 0.46666666666667
10198, 1.6666666666667, 0.78, 0.46666666666667
10199, 1.6666666666667, 0.72666666666667, 0.46666666666667
10200, 1.6666666666667, 0.67333333333333, 0.46666666666667
10201, 1.6666666666667, 0.62, 0.46666666666667
10202, 1.6666666666667, 0.56666666666667, 0.46666666666667
10203, 1.6666666666667, 0.51333333333333, 0.46666666666667
10204, 1.6666666666667, 0.46, 0.46666666666667
10205, 1.6666666666667, 0.40666666666667, 0.46666666666667
10206, 1.6666666666667, 0.35333333333333, 0.46666666666667
10207, 1.7333333333333, 1.0466666666667, 0.46666666666667
10208, 1.7333333333333, 0.99333333333333, 0.46666666666667
10209, 1.7333333333333, 0.94, 0.46666666666667
10210, 1.7333333333333, 0.88666666666667, 0.46666666666667
10211, 1.7333333333333, 0.83333333333333, 0.46666666666667
10212, 1.7333333333333, 0.78, 0.46666666666667
10213, 1.7333333333333, 0.72666666666667, 0.46666666666667
10214, 1.7333333333333, 0.67333333333333, 0.46666666666667
10215, 1.7333333333333, 0.62, 0.46666666666667
10216, 1.7333333333333, 0.56666666666667, 0.46666666666667
10217, 1.7333333333333, 0.51333333333333, 0.46666666666667
10218, 1.7333333333333, 0.46, 0.46666666666667
10219, 1.7333333333333, 0.40666666666667, 0.46666666666667
10220, 1.7333333333333, 0.35333333333333, 0.46666666666667
10221, 1.8, 1.0466666666667, 0.46666666666667
10222, 1.8, 0.99333333333333, 0.46666666666667
10223, 1.8, 0.94, 0.46666666666667
10224, 1.8, 0.88666666666667, 0.46666666666667
10225, 1.8, 0.83333333333333, 0.46666666666667
10226, 1.8, 0.78, 0.46666666666667
10227, 1.8, 0.72666666666667, 0.46666666666667
10228, 1.8, 0.67333333333333, 0.46666666666667
10229, 1.8, 0.62, 0.46666666666667
10230, 1.8, 0.56666666666667, 0.46666666666667
10231, 1.8, 0.51333333333333, 0.46666666666667
10232, 1.8, 0.46, 0.46666666666667
10233, 1.8, 0.40666666666667, 0.46666666666667
10234, 1.8, 0.35333333333333, 0.46666666666667
10235, 1.8666666666667, 1.0466666666667, 0.46666666666667
10236, 1.8666666666667, 0.99333333333333, 0.46666666666667
10237, 1.8666666666667, 0.94, 0.46666666666667
10238, 1.8666666666667, 0.88666666666667, 0.46666666666667
10239, 1.8666666666667, 0.83333333333333, 0.46666666666667
10240, 1.8666666666667, 0.78, 0.46666666666667
10241, 1.8666666666667, 0.72666666666667, 0.46666666666667
10242, 1.8666666666667, 0.67333333333333, 0.46666666666667
10243, 1.8666666666667, 0.62, 0.46666666666667
10244, 1.8666666666667, 0.56666666666667, 0.46666666666667
10245, 1.8666666666667, 0.51333333333333, 0.46666666666667
10246, 1.8666666666667, 0.46, 0.46666666666667
10247, 1.8666666666667, 0.40666666666667, 0.46666666666667
10248, 1.8666666666667, 0.35333333333333, 0.46666666666667
10249, 1.9333333333333, 1.0466666666667, 0.46666666666667
10250, 1.9333333333333, 0.99333333333333, 0.46666666666667
10251, 1.9333333333333, 0.94, 0.46666666666667
10252, 1.9333333333333, 0.88666666666667, 0.46666666666667
10253, 1.9333333333333, 0.83333333333333, 0.46666666666667
10254, 1.9333333333333, 0.78, 0.46666666666667
10255, 1.9333333333333, 0.72666666666667, 0.46666666666667
10256, 1.9333333333333, 0.67333333333333, 0.46666666666667
10257, 1.9333333333333, 0.62, 0.46666666666667
10258, 1.9333333333333, 0.56666666666667, 0.46666666666667
10259, 1.9333333333333, 0.51333333333333, 0.46666666666667
10260, 1.9333333333333, 0.46, 0.46666666666667
10261, 1.9333333333333, 0.40666666666667, 0.46666666666667
10262, 1.9333333333333, 0.35333333333333, 0.46666666666667
10263, 2, 1.0466666666667, 0.46666666666667
10264, 2, 0.99333333333333, 0.46666666666667
10265, 2, 0.94, 0.46666666666667
10266, 2, 0.88666666666667, 0.46666666666667
10267, 2, 0.83333333333333, 0.46666666666667
10268, 2, 0.78, 0.46666666666667
10269, 2, 0.72666666666667, 0.46666666666667
10270, 2, 0.67333333333333, 0.46666666666667
10271, 2, 0.62, 0.46666666666667
10272, 2, 0.56666666666667, 0.46666666666667
10273, 2, 0.51333333333333, 0.46666666666667
10274, 2, 0.46, 0.46666666666667
10275, 2, 0.40666666666667, 0.46666666666667
10276, 2, 0.35333333333333, 0.46666666666667
10277, 2.0666666666667, 1.0466666666667, 0.46666666666667
10278, 2.0666666666667, 0.99333333333333, 0.46666666666667
10279, 2.0666666666667, 0.94, 0.46666666666667
10280, 2.0666666666667, 0.88666666666667, 0.46666666666667
10281, 2.0666666666667, 0.83333333333333, 0.46666666666667
10282, 2.0666666666667, 0.78, 0.46666666666667
10283, 2.0666666666667, 0.72666666666667, 0.46666666666667
10284, 2.0666666666667, 0.67333333333333, 0.46666666666667
10285, 2.0666666666667, 0.62, 0.46666666666667
10286, 2.0666666666667, 0.56666666666667, 0.46666666666667
10287, 2.0666666666667, 0.51333333333333, 0.46666666666667
10288, 2.0666666666667, 0.46, 0.46666666666667
10289, 2.0666666666667, 0.40666666666667, 0.46666666666667
10290, 2.0666666666667, 0.35333333333333, 0.46666666666667
10291, 2.1333333333333, 1.0466666666667, 0.46666666666667
10292, 2.1333333333333, 0.99333333333333, 0.46666666666667
10293, 2.1333333333333, 0.94, 0.46666666666667
10294, 2.1333333333333, 0.88666666666667, 0.46666666666667
10295, 2.1333333333333, 0.83333333333333, 0.46666666666667
10296, 2.1333333333333, 0.78, 0.46666666666667
10297, 2.1333333333333, 0.72666666666667, 0.46666666666667
10298, 2.1333333333333, 0.67333333333333, 0.46666666666667
10299, 2.1333333333333, 0.62, 0.46666666666667
10300, 2.1333333333333, 0.56666666666667, 0.46666666666667
10301, 2.1333333333333, 0.51333333333333, 0.46666666666667
10302, 2.1333333333333, 0.46, 0.46666666666667
10303, 2.1333333333333, 0.40666666666667, 0.46666666666667
10304, 2.1333333333333, 0.35333333333333, 0.46666666666667
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
9612, 2, 57
9613, 57, 58
9614, 58, 59
9615, 59, 60
9616, 60, 61
9617, 61, 62
9618, 62, 63
9619, 63, 64
9620, 64, 65
9621, 65, 66
9622, 66, 67
9623, 67, 68
9624, 68, 69
9625, 69, 70
9626, 70, 1
*ELEMENT, type=T3D2, ELSET=Line2
9627, 1, 3
*ELEMENT, type=T3D2, ELSET=Line3
9628, 4, 71
9629, 71, 72
9630, 72, 73
9631, 73, 74
9632, 74, 75
9633, 75, 76
9634, 76, 77
9635, 77, 78
9636, 78, 79
9637, 79, 80
9638, 80, 81
9639, 81, 82
9640, 82, 83
9641, 83, 84
9642, 84, 3
*ELEMENT, type=T3D2, ELSET=Line4
9643, 2, 4
*ELEMENT, type=T3D2, ELSET=Line5
9644, 6, 85
9645, 85, 86
9646, 86, 87
9647, 87, 88
9648, 88, 89
9649, 89, 90
9650, 90, 91
9651, 91, 92
9652, 92, 93
9653, 93, 94
9654, 94, 95
9655, 95, 96
9656, 96, 97
9657, 97, 98
9658, 98, 5
*ELEMENT, type=T3D2, ELSET=Line6
9659, 5, 7
*ELEMENT, type=T3D2, ELSET=Line7
9660, 8, 99
9661, 99, 100
9662, 100, 101
9663, 101, 102
9664, 102, 103
9665, 103, 104
9666, 104, 105
9667, 105, 106
9668, 106, 107
9669, 107, 108
9670, 108, 109
9671, 109, 110
9672, 110, 111
9673, 111, 112
9674, 112, 7
*ELEMENT, type=T3D2, ELSET=Line8
9675, 6, 8
*ELEMENT, type=T3D2, ELSET=Line9
9676, 2, 113
9677, 113, 114
9678, 114, 115
9679, 115, 116
9680, 116, 117
9681, 117, 118
9682, 118, 119
9683, 119, 120
9684, 120, 121
9685, 121, 122
9686, 122, 123
9687, 123, 124
9688, 124, 125
9689, 125, 126
9690, 126, 6
*ELEMENT, type=T3D2, ELSET=Line10
9691, 1, 127
9692, 127, 128
9693, 128, 129
9694, 129, 130
9695, 130, 131
9696, 131, 132
9697, 132, 133
9698, 133, 134
9699, 134, 135
9700, 135, 136
9701, 136, 137
9702, 137, 138
9703, 138, 139
9704, 139, 140
9705, 140, 5
*ELEMENT, type=T3D2, ELSET=Line11
9706, 4, 141
9707, 141, 142
9708, 142, 143
9709, 143, 144
9710, 144, 145
9711, 145, 146
9712, 146, 147
9713, 147, 148
9714, 148, 149
9715, 149, 150
9716, 150, 151
9717, 151, 152
9718, 152, 153
9719, 153, 154
9720, 154, 8
*ELEMENT, type=T3D2, ELSET=Line12
9721, 3, 155
9722, 155, 156
9723, 156, 157
9724, 157, 158
9725, 158, 159
9726, 159, 160
9727, 160, 161
9728, 161, 162
9729, 162, 163
9730, 163, 164
9731, 164, 165
9732, 165, 166
9733, 166, 167
9734, 167, 168
9735, 168, 7
*ELEMENT, type=T3D2, ELSET=Line13
9736, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
9737, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
9738, 10, 169
9739, 169, 170
9740, 170, 171
9741, 171, 172
9742, 172, 173
9743, 173, 174
9744, 174, 175
9745, 175, 176
9746, 176, 177
9747, 177, 178
9748, 178, 179
9749, 179, 180
9750, 180, 181
9751, 181, 182
9752, 182, 9
*ELEMENT, type=T3D2, ELSET=Line16
9753, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
9754, 9, 183
9755, 183, 184
9756, 184, 185
9757, 185, 186
9758, 186, 187
9759, 187, 188
9760, 188, 189
9761, 189, 190
9762, 190, 191
9763, 191, 192
9764, 192, 193
9765, 193, 194
9766, 194, 195
9767, 195, 196
9768, 196, 11
*ELEMENT, type=T3D2, ELSET=Line18
9769, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
9770, 12, 197
9771, 197, 198
9772, 198, 199
9773, 199, 200
9774, 200, 201
9775, 201, 202
9776, 202, 203
9777, 203, 204
9778, 204, 205
9779, 205, 206
9780, 206, 207
9781, 207, 208
9782, 208, 209
9783, 209, 210
9784, 210, 11
*ELEMENT, type=T3D2, ELSET=Line20
9785, 10, 211
9786, 211, 212
9787, 212, 213
9788, 213, 214
9789, 214, 215
9790, 215, 216
9791, 216, 217
9792, 217, 218
9793, 218, 219
9794, 219, 220
9795, 220, 221
9796, 221, 222
9797, 222, 223
9798, 223, 224
9799, 224, 12
*ELEMENT, type=T3D2, ELSET=Line21
9800, 9, 225
9801, 225, 226
9802, 226, 227
9803, 227, 228
9804, 228, 229
9805, 229, 230
9806, 230, 231
9807, 231, 232
9808, 232, 233
9809, 233, 234
9810, 234, 235
9811, 235, 236
9812, 236, 237
9813, 237, 238
9814, 238, 13
*ELEMENT, type=T3D2, ELSET=Line22
9815, 10, 239
9816, 239, 240
9817, 240, 241
9818, 241, 242
9819, 242, 243
9820, 243, 244
9821, 244, 245
9822, 245, 246
9823, 246, 247
9824, 247, 248
9825, 248, 249
9826, 249, 250
9827, 250, 251
9828, 251, 252
9829, 252, 14
*ELEMENT, type=T3D2, ELSET=Line23
9830, 14, 253
9831, 253, 254
9832, 254, 255
9833, 255, 256
9834, 256, 257
9835, 257, 258
9836, 258, 259
9837, 259, 260
9838, 260, 261
9839, 261, 262
9840, 262, 263
9841, 263, 264
9842, 264, 265
9843, 265, 266
9844, 266, 13
*ELEMENT, type=T3D2, ELSET=Line24
9845, 11, 267
9846, 267, 268
9847, 268, 269
9848, 269, 270
9849, 270, 271
9850, 271, 272
9851, 272, 273
9852, 273, 274
9853, 274, 275
9854, 275, 276
9855, 276, 277
9856, 277, 278
9857, 278, 279
9858, 279, 280
9859, 280, 15
*ELEMENT, type=T3D2, ELSET=Line25
9860, 13, 281
9861, 281, 282
9862, 282, 283
9863, 283, 284
9864, 284, 285
9865, 285, 286
9866, 286, 287
9867, 287, 288
9868, 288, 289
9869, 289, 290
9870, 290, 291
9871, 291, 292
9872, 292, 293
9873, 293, 294
9874, 294, 15
*ELEMENT, type=T3D2, ELSET=Line26
9875, 12, 295
9876, 295, 296
9877, 296, 297
9878, 297, 298
9879, 298, 299
9880, 299, 300
9881, 300, 301
9882, 301, 302
9883, 302, 303
9884, 303, 304
9885, 304, 305
9886, 305, 306
9887, 306, 307
9888, 307, 308
9889, 308, 16
*ELEMENT, type=T3D2, ELSET=Line27
9890, 16, 309
9891, 309, 310
9892, 310, 311
9893, 311, 312
9894, 312, 313
9895, 313, 314
9896, 314, 315
9897, 315, 316
9898, 316, 317
9899, 317, 318
9900, 318, 319
9901, 319, 320
9902, 320, 321
9903, 321, 322
9904, 322, 15
*ELEMENT, type=T3D2, ELSET=Line28
9905, 14, 323
9906, 323, 324
9907, 324, 325
9908, 325, 326
9909, 326, 327
9910, 327, 328
9911, 328, 329
9912, 329, 330
9913, 330, 331
9914, 331, 332
9915, 332, 333
9916, 333, 334
9917, 334, 335
9918, 335, 336
9919, 336, 16
*ELEMENT, type=T3D2, ELSET=Line29
9920, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
9921, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
9922, 18, 337
9923, 337, 338
9924, 338, 339
9925, 339, 340
9926, 340, 341
9927, 341, 342
9928, 342, 343
9929, 343, 344
9930, 344, 345
9931, 345, 346
9932, 346, 347
9933, 347, 348
9934, 348, 349
9935, 349, 350
9936, 350, 17
*ELEMENT, type=T3D2, ELSET=Line32
9937, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
9938, 17, 351
9939, 351, 352
9940, 352, 353
9941, 353, 354
9942, 354, 355
9943, 355, 356
9944, 356, 357
9945, 357, 358
9946, 358, 359
9947, 359, 360
9948, 360, 361
9949, 361, 362
9950, 362, 363
9951, 363, 364
9952, 364, 19
*ELEMENT, type=T3D2, ELSET=Line34
9953, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
9954, 20, 365
9955, 365, 366
9956, 366, 367
9957, 367, 368
9958, 368, 369
9959, 369, 370
9960, 370, 371
9961, 371, 372
9962, 372, 373
9963, 373, 374
9964, 374, 375
9965, 375, 376
9966, 376, 377
9967, 377, 378
9968, 378, 19
*ELEMENT, type=T3D2, ELSET=Line36
9969, 18, 379
9970, 379, 380
9971, 380, 381
9972, 381, 382
9973, 382, 383
9974, 383, 384
9975, 384, 385
9976, 385, 386
9977, 386, 387
9978, 387, 388
9979, 388, 389
9980, 389, 390
9981, 390, 391
9982, 391, 392
9983, 392, 20
*ELEMENT, type=T3D2, ELSET=Line37
9984, 17, 21
*ELEMENT, type=T3D2, ELSET=Line38
9985, 18, 22
*ELEMENT, type=T3D2, ELSET=Line39
9986, 22, 393
9987, 393, 394
9988, 394, 395
9989, 395, 396
9990, 396, 397
9991, 397, 398
9992, 398, 399
9993, 399, 400
9994, 400, 401
9995, 401, 402
9996, 402, 403
9997, 403, 404
9998, 404, 405
9999, 405, 406
10000, 406, 21
*ELEMENT, type=T3D2, ELSET=Line40
10001, 19, 23
*ELEMENT, type=T3D2, ELSET=Line41
10002, 21, 407
10003, 407, 408
10004, 408, 409
10005, 409, 410
10006, 410, 411
10007, 411, 412
10008, 412, 413
10009, 413, 414
10010, 414, 415
10011, 415, 416
10012, 416, 417
10013, 417, 418
10014, 418, 419
10015, 419, 420
10016, 420, 23
*ELEMENT, type=T3D2, ELSET=Line42
10017, 20, 24
*ELEMENT, type=T3D2, ELSET=Line43
10018, 24, 421
10019, 421, 422
10020, 422, 423
10021, 423, 424
10022, 424, 425
10023, 425, 426
10024, 426, 427
10025, 427, 428
10026, 428, 429
10027, 429, 430
10028, 430, 431
10029, 431, 432
10030, 432, 433
10031, 433, 434
10032, 434, 23
*ELEMENT, type=T3D2, ELSET=Line44
10033, 22, 435
10034, 435, 436
10035, 436, 437
10036, 437, 438
10037, 438, 439
10038, 439, 440
10039, 440, 441
10040, 441, 442
10041, 442, 443
10042, 443, 444
10043, 444, 445
10044, 445, 446
10045, 446, 447
10046, 447, 448
10047, 448, 24
*ELEMENT, type=T3D2, ELSET=Line45
10048, 19, 25
*ELEMENT, type=T3D2, ELSET=Line46
10049, 23, 26
*ELEMENT, type=T3D2, ELSET=Line47
10050, 25, 26
*ELEMENT, type=T3D2, ELSET=Line48
10051, 17, 27
*ELEMENT, type=T3D2, ELSET=Line49
10052, 21, 28
*ELEMENT, type=T3D2, ELSET=Line50
10053, 27, 28
*ELEMENT, type=T3D2, ELSET=Line51
10054, 27, 449
10055, 449, 450
10056, 450, 451
10057, 451, 452
10058, 452, 453
10059, 453, 454
10060, 454, 455
10061, 455, 456
10062, 456, 457
10063, 457, 458
10064, 458, 459
10065, 459, 460
10066, 460, 461
10067, 461, 462
10068, 462, 25
*ELEMENT, type=T3D2, ELSET=Line52
10069, 28, 463
10070, 463, 464
10071, 464, 465
10072, 465, 466
10073, 466, 467
10074, 467, 468
10075, 468, 469
10076, 469, 470
10077, 470, 471
10078, 471, 472
10079, 472, 473
10080, 473, 474
10081, 474, 475
10082, 475, 476
10083, 476, 26
*ELEMENT, type=T3D2, ELSET=Line53
10084, 25, 477
10085, 477, 478
10086, 478, 479
10087, 479, 480
10088, 480, 481
10089, 481, 482
10090, 482, 483
10091, 483, 484
10092, 484, 485
10093, 485, 486
10094, 486, 487
10095, 487, 488
10096, 488, 489
10097, 489, 490
10098, 490, 29
*ELEMENT, type=T3D2, ELSET=Line54
10099, 26, 491
10100, 491, 492
10101, 492, 493
10102, 493, 494
10103, 494, 495
10104, 495, 496
10105, 496, 497
10106, 497, 498
10107, 498, 499
10108, 499, 500
10109, 500, 501
10110, 501, 502
10111, 502, 503
10112, 503, 504
10113, 504, 30
*ELEMENT, type=T3D2, ELSET=Line55
10114, 29, 30
*ELEMENT, type=T3D2, ELSET=Line56
10115, 27, 505
10116, 505, 506
10117, 506, 507
10118, 507, 508
10119, 508, 509
10120, 509, 510
10121, 510, 511
10122, 511, 512
10123, 512, 513
10124, 513, 514
10125, 514, 515
10126, 515, 516
10127, 516, 517
10128, 517, 518
10129, 518, 31
*ELEMENT, type=T3D2, ELSET=Line57
10130, 28, 519
10131, 519, 520
10132, 520, 521
10133, 521, 522
10134, 522, 523
10135, 523, 524
10136, 524, 525
10137, 525, 526
10138, 526, 527
10139, 527, 528
10140, 528, 529
10141, 529, 530
10142, 530, 531
10143, 531, 532
10144, 532, 32
*ELEMENT, type=T3D2, ELSET=Line58
10145, 31, 32
*ELEMENT, type=T3D2, ELSET=Line59
10146, 31, 533
10147, 533, 534
10148, 534, 535
10149, 535, 536
10150, 536, 537
10151, 537, 538
10152, 538, 539
10153, 539, 540
10154, 540, 541
10155, 541, 542
10156, 542, 543
10157, 543, 544
10158, 544, 545
10159, 545, 546
10160, 546, 29
*ELEMENT, type=T3D2, ELSET=Line60
10161, 32, 547
10162, 547, 548
10163, 548, 549
10164, 549, 550
10165, 550, 551
10166, 551, 552
10167, 552, 553
10168, 553, 554
10169, 554, 555
10170, 555, 556
10171, 556, 557
10172, 557, 558
10173, 558, 559
10174, 559, 560
10175, 560, 30
*ELEMENT, type=T3D2, ELSET=Line61
10176, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
10177, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
10178, 33, 561
10179, 561, 562
10180, 562, 563
10181, 563, 564
10182, 564, 565
10183, 565, 566
10184, 566, 567
10185, 567, 568
10186, 568, 569
10187, 569, 570
10188, 570, 571
10189, 571, 572
10190, 572, 573
10191, 573, 574
10192, 574, 34
*ELEMENT, type=T3D2, ELSET=Line64
10193, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
10194, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
10195, 35, 575
10196, 575, 576
10197, 576, 577
10198, 577, 578
10199, 578, 579
10200, 579, 580
10201, 580, 581
10202, 581, 582
10203, 582, 583
10204, 583, 584
10205, 584, 585
10206, 585, 586
10207, 586, 587
10208, 587, 588
10209, 588, 36
*ELEMENT, type=T3D2, ELSET=Line67
10210, 35, 589
10211, 589, 590
10212, 590, 591
10213, 591, 592
10214, 592, 593
10215, 593, 594
10216, 594, 595
10217, 595, 596
10218, 596, 597
10219, 597, 598
10220, 598, 599
10221, 599, 600
10222, 600, 601
10223, 601, 602
10224, 602, 33
*ELEMENT, type=T3D2, ELSET=Line68
10225, 36, 603
10226, 603, 604
10227, 604, 605
10228, 605, 606
10229, 606, 607
10230, 607, 608
10231, 608, 609
10232, 609, 610
10233, 610, 611
10234, 611, 612
10235, 612, 613
10236, 613, 614
10237, 614, 615
10238, 615, 616
10239, 616, 34
*ELEMENT, type=T3D2, ELSET=Line69
10240, 33, 617
10241, 617, 618
10242, 618, 619
10243, 619, 620
10244, 620, 621
10245, 621, 622
10246, 622, 623
10247, 623, 624
10248, 624, 625
10249, 625, 626
10250, 626, 627
10251, 627, 628
10252, 628, 629
10253, 629, 630
10254, 630, 37
*ELEMENT, type=T3D2, ELSET=Line70
10255, 34, 631
10256, 631, 632
10257, 632, 633
10258, 633, 634
10259, 634, 635
10260, 635, 636
10261, 636, 637
10262, 637, 638
10263, 638, 639
10264, 639, 640
10265, 640, 641
10266, 641, 642
10267, 642, 643
10268, 643, 644
10269, 644, 38
*ELEMENT, type=T3D2, ELSET=Line71
10270, 37, 645
10271, 645, 646
10272, 646, 647
10273, 647, 648
10274, 648, 649
10275, 649, 650
10276, 650, 651
10277, 651, 652
10278, 652, 653
10279, 653, 654
10280, 654, 655
10281, 655, 656
10282, 656, 657
10283, 657, 658
10284, 658, 38
*ELEMENT, type=T3D2, ELSET=Line72
10285, 35, 659
10286, 659, 660
10287, 660, 661
10288, 661, 662
10289, 662, 663
10290, 663, 664
10291, 664, 665
10292, 665, 666
10293, 666, 667
10294, 667, 668
10295, 668, 669
10296, 669, 670
10297, 670, 671
10298, 671, 672
10299, 672, 39
*ELEMENT, type=T3D2, ELSET=Line73
10300, 36, 673
10301, 673, 674
10302, 674, 675
10303, 675, 676
10304, 676, 677
10305, 677, 678
10306, 678, 679
10307, 679, 680
10308, 680, 681
10309, 681, 682
10310, 682, 683
10311, 683, 684
10312, 684, 685
10313, 685, 686
10314, 686, 40
*ELEMENT, type=T3D2, ELSET=Line74
10315, 39, 687
10316, 687, 688
10317, 688, 689
10318, 689, 690
10319, 690, 691
10320, 691, 692
10321, 692, 693
10322, 693, 694
10323, 694, 695
10324, 695, 696
10325, 696, 697
10326, 697, 698
10327, 698, 699
10328, 699, 700
10329, 700, 40
*ELEMENT, type=T3D2, ELSET=Line75
10330, 39, 701
10331, 701, 702
10332, 702, 703
10333, 703, 704
10334, 704, 705
10335, 705, 706
10336, 706, 707
10337, 707, 708
10338, 708, 709
10339, 709, 710
10340, 710, 711
10341, 711, 712
10342, 712, 713
10343, 713, 714
10344, 714, 37
*ELEMENT, type=T3D2, ELSET=Line76
10345, 40, 715
10346, 715, 716
10347, 716, 717
10348, 717, 718
10349, 718, 719
10350, 719, 720
10351, 720, 721
10352, 721, 722
10353, 722, 723
10354, 723, 724
10355, 724, 725
10356, 725, 726
10357, 726, 727
10358, 727, 728
10359, 728, 38
*ELEMENT, type=T3D2, ELSET=Line77
10360, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
10361, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
10362, 41, 729
10363, 729, 730
10364, 730, 731
10365, 731, 732
10366, 732, 733
10367, 733, 734
10368, 734, 735
10369, 735, 736
10370, 736, 737
10371, 737, 738
10372, 738, 739
10373, 739, 740
10374, 740, 741
10375, 741, 742
10376, 742, 42
*ELEMENT, type=T3D2, ELSET=Line80
10377, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
10378, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
10379, 43, 743
10380, 743, 744
10381, 744, 745
10382, 745, 746
10383, 746, 747
10384, 747, 748
10385, 748, 749
10386, 749, 750
10387, 750, 751
10388, 751, 752
10389, 752, 753
10390, 753, 754
10391, 754, 755
10392, 755, 756
10393, 756, 44
*ELEMENT, type=T3D2, ELSET=Line83
10394, 43, 757
10395, 757, 758
10396, 758, 759
10397, 759, 760
10398, 760, 761
10399, 761, 762
10400, 762, 763
10401, 763, 764
10402, 764, 765
10403, 765, 766
10404, 766, 767
10405, 767, 768
10406, 768, 769
10407, 769, 770
10408, 770, 41
*ELEMENT, type=T3D2, ELSET=Line84
10409, 44, 771
10410, 771, 772
10411, 772, 773
10412, 773, 774
10413, 774, 775
10414, 775, 776
10415, 776, 777
10416, 777, 778
10417, 778, 779
10418, 779, 780
10419, 780, 781
10420, 781, 782
10421, 782, 783
10422, 783, 784
10423, 784, 42
*ELEMENT, type=T3D2, ELSET=Line85
10424, 41, 45
*ELEMENT, type=T3D2, ELSET=Line86
10425, 42, 46
*ELEMENT, type=T3D2, ELSET=Line87
10426, 45, 785
10427, 785, 786
10428, 786, 787
10429, 787, 788
10430, 788, 789
10431, 789, 790
10432, 790, 791
10433, 791, 792
10434, 792, 793
10435, 793, 794
10436, 794, 795
10437, 795, 796
10438, 796, 797
10439, 797, 798
10440, 798, 46
*ELEMENT, type=T3D2, ELSET=Line88
10441, 43, 47
*ELEMENT, type=T3D2, ELSET=Line89
10442, 44, 48
*ELEMENT, type=T3D2, ELSET=Line90
10443, 47, 799
10444, 799, 800
10445, 800, 801
10446, 801, 802
10447, 802, 803
10448, 803, 804
10449, 804, 805
10450, 805, 806
10451, 806, 807
10452, 807, 808
10453, 808, 809
10454, 809, 810
10455, 810, 811
10456, 811, 812
10457, 812, 48
*ELEMENT, type=T3D2, ELSET=Line91
10458, 47, 813
10459, 813, 814
10460, 814, 815
10461, 815, 816
10462, 816, 817
10463, 817, 818
10464, 818, 819
10465, 819, 820
10466, 820, 821
10467, 821, 822
10468, 822, 823
10469, 823, 824
10470, 824, 825
10471, 825, 826
10472, 826, 45
*ELEMENT, type=T3D2, ELSET=Line92
10473, 48, 827
10474, 827, 828
10475, 828, 829
10476, 829, 830
10477, 830, 831
10478, 831, 832
10479, 832, 833
10480, 833, 834
10481, 834, 835
10482, 835, 836
10483, 836, 837
10484, 837, 838
10485, 838, 839
10486, 839, 840
10487, 840, 46
*ELEMENT, type=T3D2, ELSET=Line93
10488, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
10489, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
10490, 49, 50
*ELEMENT, type=T3D2, ELSET=Line96
10491, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
10492, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
10493, 51, 52
*ELEMENT, type=T3D2, ELSET=Line99
10494, 51, 841
10495, 841, 842
10496, 842, 843
10497, 843, 844
10498, 844, 845
10499, 845, 846
10500, 846, 847
10501, 847, 848
10502, 848, 849
10503, 849, 850
10504, 850, 851
10505, 851, 852
10506, 852, 853
10507, 853, 854
10508, 854, 49
*ELEMENT, type=T3D2, ELSET=Line100
10509, 52, 855
10510, 855, 856
10511, 856, 857
10512, 857, 858
10513, 858, 859
10514, 859, 860
10515, 860, 861
10516, 861, 862
10517, 862, 863
10518, 863, 864
10519, 864, 865
10520, 865, 866
10521, 866, 867
10522, 867, 868
10523, 868, 50
*ELEMENT, type=T3D2, ELSET=Line101
10524, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
10525, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
10526, 54, 869
10527, 869, 870
10528, 870, 871
10529, 871, 872
10530, 872, 873
10531, 873, 874
10532, 874, 875
10533, 875, 876
10534, 876, 877
10535, 877, 878
10536, 878, 879
10537, 879, 880
10538, 880, 881
10539, 881, 882
10540, 882, 53
*ELEMENT, type=T3D2, ELSET=Line104
10541, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
10542, 53, 55
*ELEMENT, type=T3D2, ELSET=Line106
10543, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
10544, 56, 883
10545, 883, 884
10546, 884, 885
10547, 885, 886
10548, 886, 887
10549, 887, 888
10550, 888, 889
10551, 889, 890
10552, 890, 891
10553, 891, 892
10554, 892, 893
10555, 893, 894
10556, 894, 895
10557, 895, 896
10558, 896, 55
*ELEMENT, type=T3D2, ELSET=Line108
10559, 54, 56
*ELEMENT, type=CPS4, ELSET=Surface1
10560, 2, 57, 71, 4
10561, 57, 58, 72, 71
10562, 58, 59, 73, 72
10563, 59, 60, 74, 73
10564, 60, 61, 75, 74
10565, 61, 62, 76, 75
10566, 62, 63, 77, 76
10567, 63, 64, 78, 77
10568, 64, 65, 79, 78
10569, 65, 66, 80, 79
10570, 66, 67, 81, 80
10571, 67, 68, 82, 81
10572, 68, 69, 83, 82
10573, 69, 70, 84, 83
10574, 70, 1, 3, 84
*ELEMENT, type=CPS4, ELSET=Surface2
10575, 6, 8, 99, 85
10576, 85, 99, 100, 86
10577, 86, 100, 101, 87
10578, 87, 101, 102, 88
10579, 88, 102, 103, 89
10580, 89, 103, 104, 90
10581, 90, 104, 105, 91
10582, 91, 105, 106, 92
10583, 92, 106, 107, 93
10584, 93, 107, 108, 94
10585, 94, 108, 109, 95
10586, 95, 109, 110, 96
10587, 96, 110, 111, 97
10588, 97, 111, 112, 98
10589, 98, 112, 7, 5
*ELEMENT, type=CPS4, ELSET=Surface3
1, 2, 113, 897, 57
2, 57, 897, 898, 58
3, 58, 898, 899, 59
4, 59, 899, 900, 60
5, 60, 900, 901, 61
6, 61, 901, 902, 62
7, 62, 902, 903, 63
8, 63, 903, 904, 64
9, 64, 904, 905, 65
10, 65, 905, 906, 66
11, 66, 906, 907, 67
12, 67, 907, 908, 68
13, 68, 908, 909, 69
14, 69, 909, 910, 70
15, 70, 910, 127, 1
16, 113, 114, 911, 897
17, 897, 911, 912, 898
18, 898, 912, 913, 899
19, 899, 913, 914, 900
20, 900, 914, 915, 901
21, 901, 915, 916, 902
22, 902, 916, 917, 903
23, 903, 917, 918, 904
24, 904, 918, 919, 905
25, 905, 919, 920, 906
26, 906, 920, 921, 907
27, 907, 921, 922, 908
28, 908, 922, 923, 909
29, 909, 923, 924, 910
30, 910, 924, 128, 127
31, 114, 115, 925, 911
32, 911, 925, 926, 912
33, 912, 926, 927, 913
34, 913, 927, 928, 914
35, 914, 928, 929, 915
36, 915, 929, 930, 916
37, 916, 930, 931, 917
38, 917, 931, 932, 918
39, 918, 932, 933, 919
40, 919, 933, 934, 920
41, 920, 934, 935, 921
42, 921, 935, 936, 922
43, 922, 936, 937, 923
44, 923, 937, 938, 924
45, 924, 938, 129, 128
46, 115, 116, 939, 925
47, 925, 939, 940, 926
48, 926, 940, 941, 927
49, 927, 941, 942, 928
50, 928, 942, 943, 929
51, 929, 943, 944, 930
52, 930, 944, 945, 931
53, 931, 945, 946, 932
54, 932, 946, 947, 933
55, 933, 947, 948, 934
56, 934, 948, 949, 935
57, 935, 949, 950, 936
58, 936, 950, 951, 937
59, 937, 951, 952, 938
60, 938, 952, 130, 129
61, 116, 117, 953, 939
62, 939, 953, 954, 940
63, 940, 954, 955, 941
64, 941, 955, 956, 942
65, 942, 956, 957, 943
66, 943, 957, 958, 944
67, 944, 958, 959, 945
68, 945, 959, 960, 946
69, 946, 960, 961, 947
70, 947, 961, 962, 948
71, 948, 962, 963, 949
72, 949, 963, 964, 950
73, 950, 964, 965, 951
74, 951, 965, 966, 952
75, 952, 966, 131, 130
76, 117, 118, 967, 953
77, 953, 967, 968, 954
78, 954, 968, 969, 955
79, 955, 969, 970, 956
80, 956, 970, 971, 957
81, 957, 971, 972, 958
82, 958, 972, 973, 959
83, 959, 973, 974, 960
84, 960, 974, 975, 961
85, 961, 975, 976, 962
86, 962, 976, 977, 963
87, 963, 977, 978, 964
88, 964, 978, 979, 965
89, 965, 979, 980, 966
90, 966, 980, 132, 131
91, 118, 119, 981, 967
92, 967, 981, 982, 968
93, 968, 982, 983, 969
94, 969, 983, 984, 970
95, 970, 984, 985, 971
96, 971, 985, 986, 972
97, 972, 986, 987, 973
98, 973, 987, 988, 974
99, 974, 988, 989, 975
100, 975, 989, 990, 976
101, 976, 990, 991, 977
102, 977, 991, 992, 978
103, 978, 992, 993, 979
104, 979, 993, 994, 980
105, 980, 994, 133, 132
106, 119, 120, 995, 981
107, 981, 995, 996, 982
108, 982, 996, 997, 983
109, 983, 997, 998, 984
110, 984, 998, 999, 985
111, 985, 999, 1000, 986
112, 986, 1000, 1001, 987
113, 987, 1001, 1002, 988
114, 988, 1002, 1003, 989
115, 989, 1003, 1004, 990
116, 990, 1004, 1005, 991
117, 991, 1005, 1006, 992
118, 992, 1006, 1007, 993
119, 993, 1007, 1008, 994
120, 994, 1008, 134, 133
121, 120, 121, 1009, 995
122, 995, 1009, 1010, 996
123, 996, 1010, 1011, 997
124, 997, 1011, 1012, 998
125, 998, 1012, 1013, 999
126, 999, 1013, 1014, 1000
127, 1000, 1014, 1015, 1001
128, 1001, 1015, 1016, 1002
129, 1002, 1016, 1017, 1003
130, 1003, 1017, 1018, 1004
131, 1004, 1018, 1019, 1005
132, 1005, 1019, 1020, 1006
133, 1006, 1020, 1021, 1007
134, 1007, 1021, 1022, 1008
135, 1008, 1022, 135, 134
136, 121, 122, 1023, 1009
137, 1009, 1023, 1024, 1010
138, 1010, 1024, 1025, 1011
139, 1011, 1025, 1026, 1012
140, 1012, 1026, 1027, 1013
141, 1013, 1027, 1028, 1014
142, 1014, 1028, 1029, 1015
143, 1015, 1029, 1030, 1016
144, 1016, 1030, 1031, 1017
145, 1017, 1031, 1032, 1018
146, 1018, 1032, 1033, 1019
147, 1019, 1033, 1034, 1020
148, 1020, 1034, 1035, 1021
149, 1021, 1035, 1036, 1022
150, 1022, 1036, 136, 135
151, 122, 123, 1037, 1023
152, 1023, 1037, 1038, 1024
153, 1024, 1038, 1039, 1025
154, 1025, 1039, 1040, 1026
155, 1026, 1040, 1041, 1027
156, 1027, 1041, 1042, 1028
157, 1028, 1042, 1043, 1029
158, 1029, 1043, 1044, 1030
159, 1030, 1044, 1045, 1031
160, 1031, 1045, 1046, 1032
161, 1032, 1046, 1047, 1033
162, 1033, 1047, 1048, 1034
163, 1034, 1048, 1049, 1035
164, 1035, 1049, 1050, 1036
165, 1036, 1050, 137, 136
166, 123, 124, 1051, 1037
167, 1037, 1051, 1052, 1038
168, 1038, 1052, 1053, 1039
169, 1039, 1053, 1054, 1040
170, 1040, 1054, 1055, 1041
171, 1041, 1055, 1056, 1042
172, 1042, 1056, 1057, 1043
173, 1043, 1057, 1058, 1044
174, 1044, 1058, 1059, 1045
175, 1045, 1059, 1060, 1046
176, 1046, 1060, 1061, 1047
177, 1047, 1061, 1062, 1048
178, 1048, 1062, 1063, 1049
179, 1049, 1063, 1064, 1050
180, 1050, 1064, 138, 137
181, 124, 125, 1065, 1051
182, 1051, 1065, 1066, 1052
183, 1052, 1066, 1067, 1053
184, 1053, 1067, 1068, 1054
185, 1054, 1068, 1069, 1055
186, 1055, 1069, 1070, 1056
187, 1056, 1070, 1071, 1057
188, 1057, 1071, 1072, 1058
189, 1058, 1072, 1073, 1059
190, 1059, 1073, 1074, 1060
191, 1060, 1074, 1075, 1061
192, 1061, 1075, 1076, 1062
193, 1062, 1076, 1077, 1063
194, 1063, 1077, 1078, 1064
195, 1064, 1078, 139, 138
196, 125, 126, 1079, 1065
197, 1065, 1079, 1080, 1066
198, 1066, 1080, 1081, 1067
199, 1067, 1081, 1082, 1068
200, 1068, 1082, 1083, 1069
201, 1069, 1083, 1084, 1070
202, 1070, 1084, 1085, 1071
203, 1071, 1085, 1086, 1072
204, 1072, 1086, 1087, 1073
205, 1073, 1087, 1088, 1074
206, 1074, 1088, 1089, 1075
207, 1075, 1089, 1090, 1076
208, 1076, 1090, 1091, 1077
209, 1077, 1091, 1092, 1078
210, 1078, 1092, 140, 139
211, 126, 6, 85, 1079
212, 1079, 85, 86, 1080
213, 1080, 86, 87, 1081
214, 1081, 87, 88, 1082
215, 1082, 88, 89, 1083
216, 1083, 89, 90, 1084
217, 1084, 90, 91, 1085
218, 1085, 91, 92, 1086
219, 1086, 92, 93, 1087
220, 1087, 93, 94, 1088
221, 1088, 94, 95, 1089
222, 1089, 95, 96, 1090
223, 1090, 96, 97, 1091
224, 1091, 97, 98, 1092
225, 1092, 98, 5, 140
*ELEMENT, type=CPS4, ELSET=Surface4
10590, 4, 71, 1093, 141
10591, 71, 72, 1094, 1093
10592, 72, 73, 1095, 1094
10593, 73, 74, 1096, 1095
10594, 74, 75, 1097, 1096
10595, 75, 76, 1098, 1097
10596, 76, 77, 1099, 1098
10597, 77, 78, 1100, 1099
10598, 78, 79, 1101, 1100
10599, 79, 80, 1102, 1101
10600, 80, 81, 1103, 1102
10601, 81, 82, 1104, 1103
10602, 82, 83, 1105, 1104
10603, 83, 84, 1106, 1105
10604, 84, 3, 155, 1106
10605, 141, 1093, 1107, 142
10606, 1093, 1094, 1108, 1107
10607, 1094, 1095, 1109, 1108
10608, 1095, 1096, 1110, 1109
10609, 1096, 1097, 1111, 1110
10610, 1097, 1098, 1112, 1111
10611, 1098, 1099, 1113, 1112
10612, 1099, 1100, 1114, 1113
10613, 1100, 1101, 1115, 1114
10614, 1101, 1102, 1116, 1115
10615, 1102, 1103, 1117, 1116
10616, 1103, 1104, 1118, 1117
10617, 1104, 1105, 1119, 1118
10618, 1105, 1106, 1120, 1119
10619, 1106, 155, 156, 1120
10620, 142, 1107, 1121, 143
10621, 1107, 1108, 1122, 1121
10622, 1108, 1109, 1123, 1122
10623, 1109, 1110, 1124, 1123
10624, 1110, 1111, 1125, 1124
10625, 1111, 1112, 1126, 1125
10626, 1112, 1113, 1127, 1126
10627, 1113, 1114, 1128, 1127
10628, 1114, 1115, 1129, 1128
10629, 1115, 1116, 1130, 1129
10630, 1116, 1117, 1131, 1130
10631, 1117, 1118, 1132, 1131
10632, 1118, 1119, 1133, 1132
10633, 1119, 1120, 1134, 1133
10634, 1120, 156, 157, 1134
10635, 143, 1121, 1135, 144
10636, 1121, 1122, 1136, 1135
10637, 1122, 1123, 1137, 1136
10638, 1123, 1124, 1138, 1137
10639, 1124, 1125, 1139, 1138
10640, 1125, 1126, 1140, 1139
10641, 1126, 1127, 1141, 1140
10642, 1127, 1128, 1142, 1141
10643, 1128, 1129, 1143, 1142
10644, 1129, 1130, 1144, 1143
10645, 1130, 1131, 1145, 1144
10646, 1131, 1132, 1146, 1145
10647, 1132, 1133, 1147, 1146
10648, 1133, 1134, 1148, 1147
10649, 1134, 157, 158, 1148
10650, 144, 1135, 1149, 145
10651, 1135, 1136, 1150, 1149
10652, 1136, 1137, 1151, 1150
10653, 1137, 1138, 1152, 1151
10654, 1138, 1139, 1153, 1152
10655, 1139, 1140, 1154, 1153
10656, 1140, 1141, 1155, 1154
10657, 1141, 1142, 1156, 1155
10658, 1142, 1143, 1157, 1156
10659, 1143, 1144, 1158, 1157
10660, 1144, 1145, 1159, 1158
10661, 1145, 1146, 1160, 1159
10662, 1146, 1147, 1161, 1160
10663, 1147, 1148, 1162, 1161
10664, 1148, 158, 159, 1162
10665, 145, 1149, 1163, 146
10666, 1149, 1150, 1164, 1163
10667, 1150, 1151, 1165, 1164
10668, 1151, 1152, 1166, 1165
10669, 1152, 1153, 1167, 1166
10670, 1153, 1154, 1168, 1167
10671, 1154, 1155, 1169, 1168
10672, 1155, 1156, 1170, 1169
10673, 1156, 1157, 1171, 1170
10674, 1157, 1158, 1172, 1171
10675, 1158, 1159, 1173, 1172
10676, 1159, 1160, 1174, 1173
10677, 1160, 1161, 1175, 1174
10678, 1161, 1162, 1176, 1175
10679, 1162, 159, 160, 1176
10680, 146, 1163, 1177, 147
10681, 1163, 1164, 1178, 1177
10682, 1164, 1165, 1179, 1178
10683, 1165, 1166, 1180, 1179
10684, 1166, 1167, 1181, 1180
10685, 1167, 1168, 1182, 1181
10686, 1168, 1169, 1183, 1182
10687, 1169, 1170, 1184, 1183
10688, 1170, 1171, 1185, 1184
10689, 1171, 1172, 1186, 1185
10690, 1172, 1173, 1187, 1186
10691, 1173, 1174, 1188, 1187
10692, 1174, 1175, 1189, 1188
10693, 1175, 1176, 1190, 1189
10694, 1176, 160, 161, 1190
10695, 147, 1177, 1191, 148
10696, 1177, 1178, 1192, 1191
10697, 1178, 1179, 1193, 1192
10698, 1179, 1180, 1194, 1193
10699, 1180, 1181, 1195, 1194
10700, 1181, 1182, 1196, 1195
10701, 1182, 1183, 1197, 1196
10702, 1183, 1184, 1198, 1197
10703, 1184, 1185, 1199, 1198
10704, 1185, 1186, 1200, 1199
10705, 1186, 1187, 1201, 1200
10706, 1187, 1188, 1202, 1201
10707, 1188, 1189, 1203, 1202
10708, 1189, 1190, 1204, 1203
10709, 1190, 161, 162, 1204
10710, 148, 1191, 1205, 149
10711, 1191, 1192, 1206, 1205
10712, 1192, 1193, 1207, 1206
10713, 1193, 1194, 1208, 1207
10714, 1194, 1195, 1209, 1208
10715, 1195, 1196, 1210, 1209
10716, 1196, 1197, 1211, 1210
10717, 1197, 1198, 1212, 1211
10718, 1198, 1199, 1213, 1212
10719, 1199, 1200, 1214, 1213
10720, 1200, 1201, 1215, 1214
10721, 1201, 1202, 1216, 1215
10722, 1202, 1203, 1217, 1216
10723, 1203, 1204, 1218, 1217
10724, 1204, 162, 163, 1218
10725, 149, 1205, 1219, 150
10726, 1205, 1206, 1220, 1219
10727, 1206, 1207, 1221, 1220
10728, 1207, 1208, 1222, 1221
10729, 1208, 1209, 1223, 1222
10730, 1209, 1210, 1224, 1223
10731, 1210, 1211, 1225, 1224
10732, 1211, 1212, 1226, 1225
10733, 1212, 1213, 1227, 1226
10734, 1213, 1214, 1228, 1227
10735, 1214, 1215, 1229, 1228
10736, 1215, 1216, 1230, 1229
10737, 1216, 1217, 1231, 1230
10738, 1217, 1218, 1232, 1231
10739, 1218, 163, 164, 1232
10740, 150, 1219, 1233, 151
10741, 1219, 1220, 1234, 1233
10742, 1220, 1221, 1235, 1234
10743, 1221, 1222, 1236, 1235
10744, 1222, 1223, 1237, 1236
10745, 1223, 1224, 1238, 1237
10746, 1224, 1225, 1239, 1238
10747, 1225, 1226, 1240, 1239
10748, 1226, 1227, 1241, 1240
10749, 1227, 1228, 1242, 1241
10750, 1228, 1229, 1243, 1242
10751, 1229, 1230, 1244, 1243
10752, 1230, 1231, 1245, 1244
10753, 1231, 1232, 1246, 1245
10754, 1232, 164, 165, 1246
10755, 151, 1233, 1247, 152
10756, 1233, 1234, 1248, 1247
10757, 1234, 1235, 1249, 1248
10758, 1235, 1236, 1250, 1249
10759, 1236, 1237, 1251, 1250
10760, 1237, 1238, 1252, 1251
10761, 1238, 1239, 1253, 1252
10762, 1239, 1240, 1254, 1253
10763, 1240, 1241, 1255, 1254
10764, 1241, 1242, 1256, 1255
10765, 1242, 1243, 1257, 1256
10766, 1243, 1244, 1258, 1257
10767, 1244, 1245, 1259, 1258
10768, 1245, 1246, 1260, 1259
10769, 1246, 165, 166, 1260
10770, 152, 1247, 1261, 153
10771, 1247, 1248, 1262, 1261
10772, 1248, 1249, 1263, 1262
10773, 1249, 1250, 1264, 1263
10774, 1250, 1251, 1265, 1264
10775, 1251, 1252, 1266, 1265
10776, 1252, 1253, 1267, 1266
10777, 1253, 1254, 1268, 1267
10778, 1254, 1255, 1269, 1268
10779, 1255, 1256, 1270, 1269
10780, 1256, 1257, 1271, 1270
10781, 1257, 1258, 1272, 1271
10782, 1258, 1259, 1273, 1272
10783, 1259, 1260, 1274, 1273
10784, 1260, 166, 167, 1274
10785, 153, 1261, 1275, 154
10786, 1261, 1262, 1276, 1275
10787, 1262, 1263, 1277, 1276
10788, 1263, 1264, 1278, 1277
10789, 1264, 1265, 1279, 1278
10790, 1265, 1266, 1280, 1279
10791, 1266, 1267, 1281, 1280
10792, 1267, 1268, 1282, 1281
10793, 1268, 1269, 1283, 1282
10794, 1269, 1270, 1284, 1283
10795, 1270, 1271, 1285, 1284
10796, 1271, 1272, 1286, 1285
10797, 1272, 1273, 1287, 1286
10798, 1273, 1274, 1288, 1287
10799, 1274, 167, 168, 1288
10800, 154, 1275, 99, 8
10801, 1275, 1276, 100, 99
10802, 1276, 1277, 101, 100
10803, 1277, 1278, 102, 101
10804, 1278, 1279, 103, 102
10805, 1279, 1280, 104, 103
10806, 1280, 1281, 105, 104
10807, 1281, 1282, 106, 105
10808, 1282, 1283, 107, 106
10809, 1283, 1284, 108, 107
10810, 1284, 1285, 109, 108
10811, 1285, 1286, 110, 109
10812, 1286, 1287, 111, 110
10813, 1287, 1288, 112, 111
10814, 1288, 168, 7, 112
*ELEMENT, type=CPS4, ELSET=Surface5
10815, 2, 4, 141, 113
10816, 113, 141, 142, 114
10817, 114, 142, 143, 115
10818, 115, 143, 144, 116
10819, 116, 144, 145, 117
10820, 117, 145, 146, 118
10821, 118, 146, 147, 119
10822, 119, 147, 148, 120
10823, 120, 148, 149, 121
10824, 121, 149, 150, 122
10825, 122, 150, 151, 123
10826, 123, 151, 152, 124
10827, 124, 152, 153, 125
10828, 125, 153, 154, 126
10829, 126, 154, 8, 6
*ELEMENT, type=CPS4, ELSET=Surface6
10830, 1, 127, 155, 3
10831, 127, 128, 156, 155
10832, 128, 129, 157, 156
10833, 129, 130, 158, 157
10834, 130, 131, 159, 158
10835, 131, 132, 160, 159
10836, 132, 133, 161, 160
10837, 133, 134, 162, 161
10838, 134, 135, 163, 162
10839, 135, 136, 164, 163
10840, 136, 137, 165, 164
10841, 137, 138, 166, 165
10842, 138, 139, 167, 166
10843, 139, 140, 168, 167
10844, 140, 5, 7, 168
*ELEMENT, type=CPS4, ELSET=Surface7
10845, 4, 10, 169, 141
10846, 141, 169, 170, 142
10847, 142, 170, 171, 143
10848, 143, 171, 172, 144
10849, 144, 172, 173, 145
10850, 145, 173, 174, 146
10851, 146, 174, 175, 147
10852, 147, 175, 176, 148
10853, 148, 176, 177, 149
10854, 149, 177, 178, 150
10855, 150, 178, 179, 151
10856, 151, 179, 180, 152
10857, 152, 180, 181, 153
10858, 153, 181, 182, 154
10859, 154, 182, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
10860, 8, 9, 183, 99
10861, 99, 183, 184, 100
10862, 100, 184, 185, 101
10863, 101, 185, 186, 102
10864, 102, 186, 187, 103
10865, 103, 187, 188, 104
10866, 104, 188, 189, 105
10867, 105, 189, 190, 106
10868, 106, 190, 191, 107
10869, 107, 191, 192, 108
10870, 108, 192, 193, 109
10871, 109, 193, 194, 110
10872, 110, 194, 195, 111
10873, 111, 195, 196, 112
10874, 112, 196, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
10875, 3, 155, 197, 12
10876, 155, 156, 198, 197
10877, 156, 157, 199, 198
10878, 157, 158, 200, 199
10879, 158, 159, 201, 200
10880, 159, 160, 202, 201
10881, 160, 161, 203, 202
10882, 161, 162, 204, 203
10883, 162, 163, 205, 204
10884, 163, 164, 206, 205
10885, 164, 165, 207, 206
10886, 165, 166, 208, 207
10887, 166, 167, 209, 208
10888, 167, 168, 210, 209
10889, 168, 7, 11, 210
*ELEMENT, type=CPS4, ELSET=Surface10
10890, 4, 71, 211, 10
10891, 71, 72, 212, 211
10892, 72, 73, 213, 212
10893, 73, 74, 214, 213
10894, 74, 75, 215, 214
10895, 75, 76, 216, 215
10896, 76, 77, 217, 216
10897, 77, 78, 218, 217
10898, 78, 79, 219, 218
10899, 79, 80, 220, 219
10900, 80, 81, 221, 220
10901, 81, 82, 222, 221
10902, 82, 83, 223, 222
10903, 83, 84, 224, 223
10904, 84, 3, 12, 224
*ELEMENT, type=CPS4, ELSET=Surface11
10905, 10, 211, 1289, 169
10906, 211, 212, 1290, 1289
10907, 212, 213, 1291, 1290
10908, 213, 214, 1292, 1291
10909, 214, 215, 1293, 1292
10910, 215, 216, 1294, 1293
10911, 216, 217, 1295, 1294
10912, 217, 218, 1296, 1295
10913, 218, 219, 1297, 1296
10914, 219, 220, 1298, 1297
10915, 220, 221, 1299, 1298
10916, 221, 222, 1300, 1299
10917, 222, 223, 1301, 1300
10918, 223, 224, 1302, 1301
10919, 224, 12, 197, 1302
10920, 169, 1289, 1303, 170
10921, 1289, 1290, 1304, 1303
10922, 1290, 1291, 1305, 1304
10923, 1291, 1292, 1306, 1305
10924, 1292, 1293, 1307, 1306
10925, 1293, 1294, 1308, 1307
10926, 1294, 1295, 1309, 1308
10927, 1295, 1296, 1310, 1309
10928, 1296, 1297, 1311, 1310
10929, 1297, 1298, 1312, 1311
10930, 1298, 1299, 1313, 1312
10931, 1299, 1300, 1314, 1313
10932, 1300, 1301, 1315, 1314
10933, 1301, 1302, 1316, 1315
10934, 1302, 197, 198, 1316
10935, 170, 1303, 1317, 171
10936, 1303, 1304, 1318, 1317
10937, 1304, 1305, 1319, 1318
10938, 1305, 1306, 1320, 1319
10939, 1306, 1307, 1321, 1320
10940, 1307, 1308, 1322, 1321
10941, 1308, 1309, 1323, 1322
10942, 1309, 1310, 1324, 1323
10943, 1310, 1311, 1325, 1324
10944, 1311, 1312, 1326, 1325
10945, 1312, 1313, 1327, 1326
10946, 1313, 1314, 1328, 1327
10947, 1314, 1315, 1329, 1328
10948, 1315, 1316, 1330, 1329
10949, 1316, 198, 199, 1330
10950, 171, 1317, 1331, 172
10951, 1317, 1318, 1332, 1331
10952, 1318, 1319, 1333, 1332
10953, 1319, 1320, 1334, 1333
10954, 1320, 1321, 1335, 1334
10955, 1321, 1322, 1336, 1335
10956, 1322, 1323, 1337, 1336
10957, 1323, 1324, 1338, 1337
10958, 1324, 1325, 1339, 1338
10959, 1325, 1326, 1340, 1339
10960, 1326, 1327, 1341, 1340
10961, 1327, 1328, 1342, 1341
10962, 1328, 1329, 1343, 1342
10963, 1329, 1330, 1344, 1343
10964, 1330, 199, 200, 1344
10965, 172, 1331, 1345, 173
10966, 1331, 1332, 1346, 1345
10967, 1332, 1333, 1347, 1346
10968, 1333, 1334, 1348, 1347
10969, 1334, 1335, 1349, 1348
10970, 1335, 1336, 1350, 1349
10971, 1336, 1337, 1351, 1350
10972, 1337, 1338, 1352, 1351
10973, 1338, 1339, 1353, 1352
10974, 1339, 1340, 1354, 1353
10975, 1340, 1341, 1355, 1354
10976, 1341, 1342, 1356, 1355
10977, 1342, 1343, 1357, 1356
10978, 1343, 1344, 1358, 1357
10979, 1344, 200, 201, 1358
10980, 173, 1345, 1359, 174
10981, 1345, 1346, 1360, 1359
10982, 1346, 1347, 1361, 1360
10983, 1347, 1348, 1362, 1361
10984, 1348, 1349, 1363, 1362
10985, 1349, 1350, 1364, 1363
10986, 1350, 1351, 1365, 1364
10987, 1351, 1352, 1366, 1365
10988, 1352, 1353, 1367, 1366
10989, 1353, 1354, 1368, 1367
10990, 1354, 1355, 1369, 1368
10991, 1355, 1356, 1370, 1369
10992, 1356, 1357, 1371, 1370
10993, 1357, 1358, 1372, 1371
10994, 1358, 201, 202, 1372
10995, 174, 1359, 1373, 175
10996, 1359, 1360, 1374, 1373
10997, 1360, 1361, 1375, 1374
10998, 1361, 1362, 1376, 1375
10999, 1362, 1363, 1377, 1376
11000, 1363, 1364, 1378, 1377
11001, 1364, 1365, 1379, 1378
11002, 1365, 1366, 1380, 1379
11003, 1366, 1367, 1381, 1380
11004, 1367, 1368, 1382, 1381
11005, 1368, 1369, 1383, 1382
11006, 1369, 1370, 1384, 1383
11007, 1370, 1371, 1385, 1384
11008, 1371, 1372, 1386, 1385
11009, 1372, 202, 203, 1386
11010, 175, 1373, 1387, 176
11011, 1373, 1374, 1388, 1387
11012, 1374, 1375, 1389, 1388
11013, 1375, 1376, 1390, 1389
11014, 1376, 1377, 1391, 1390
11015, 1377, 1378, 1392, 1391
11016, 1378, 1379, 1393, 1392
11017, 1379, 1380, 1394, 1393
11018, 1380, 1381, 1395, 1394
11019, 1381, 1382, 1396, 1395
11020, 1382, 1383, 1397, 1396
11021, 1383, 1384, 1398, 1397
11022, 1384, 1385, 1399, 1398
11023, 1385, 1386, 1400, 1399
11024, 1386, 203, 204, 1400
11025, 176, 1387, 1401, 177
11026, 1387, 1388, 1402, 1401
11027, 1388, 1389, 1403, 1402
11028, 1389, 1390, 1404, 1403
11029, 1390, 1391, 1405, 1404
11030, 1391, 1392, 1406, 1405
11031, 1392, 1393, 1407, 1406
11032, 1393, 1394, 1408, 1407
11033, 1394, 1395, 1409, 1408
11034, 1395, 1396, 1410, 1409
11035, 1396, 1397, 1411, 1410
11036, 1397, 1398, 1412, 1411
11037, 1398, 1399, 1413, 1412
11038, 1399, 1400, 1414, 1413
11039, 1400, 204, 205, 1414
11040, 177, 1401, 1415, 178
11041, 1401, 1402, 1416, 1415
11042, 1402, 1403, 1417, 1416
11043, 1403, 1404, 1418, 1417
11044, 1404, 1405, 1419, 1418
11045, 1405, 1406, 1420, 1419
11046, 1406, 1407, 1421, 1420
11047, 1407, 1408, 1422, 1421
11048, 1408, 1409, 1423, 1422
11049, 1409, 1410, 1424, 1423
11050, 1410, 1411, 1425, 1424
11051, 1411, 1412, 1426, 1425
11052, 1412, 1413, 1427, 1426
11053, 1413, 1414, 1428, 1427
11054, 1414, 205, 206, 1428
11055, 178, 1415, 1429, 179
11056, 1415, 1416, 1430, 1429
11057, 1416, 1417, 1431, 1430
11058, 1417, 1418, 1432, 1431
11059, 1418, 1419, 1433, 1432
11060, 1419, 1420, 1434, 1433
11061, 1420, 1421, 1435, 1434
11062, 1421, 1422, 1436, 1435
11063, 1422, 1423, 1437, 1436
11064, 1423, 1424, 1438, 1437
11065, 1424, 1425, 1439, 1438
11066, 1425, 1426, 1440, 1439
11067, 1426, 1427, 1441, 1440
11068, 1427, 1428, 1442, 1441
11069, 1428, 206, 207, 1442
11070, 179, 1429, 1443, 180
11071, 1429, 1430, 1444, 1443
11072, 1430, 1431, 1445, 1444
11073, 1431, 1432, 1446, 1445
11074, 1432, 1433, 1447, 1446
11075, 1433, 1434, 1448, 1447
11076, 1434, 1435, 1449, 1448
11077, 1435, 1436, 1450, 1449
11078, 1436, 1437, 1451, 1450
11079, 1437, 1438, 1452, 1451
11080, 1438, 1439, 1453, 1452
11081, 1439, 1440, 1454, 1453
11082, 1440, 1441, 1455, 1454
11083, 1441, 1442, 1456, 1455
11084, 1442, 207, 208, 1456
11085, 180, 1443, 1457, 181
11086, 1443, 1444, 1458, 1457
11087, 1444, 1445, 1459, 1458
11088, 1445, 1446, 1460, 1459
11089, 1446, 1447, 1461, 1460
11090, 1447, 1448, 1462, 1461
11091, 1448, 1449, 1463, 1462
11092, 1449, 1450, 1464, 1463
11093, 1450, 1451, 1465, 1464
11094, 1451, 1452, 1466, 1465
11095, 1452, 1453, 1467, 1466
11096, 1453, 1454, 1468, 1467
11097, 1454, 1455, 1469, 1468
11098, 1455, 1456, 1470, 1469
11099, 1456, 208, 209, 1470
11100, 181, 1457, 1471, 182
11101, 1457, 1458, 1472, 1471
11102, 1458, 1459, 1473, 1472
11103, 1459, 1460, 1474, 1473
11104, 1460, 1461, 1475, 1474
11105, 1461, 1462, 1476, 1475
11106, 1462, 1463, 1477, 1476
11107, 1463, 1464, 1478, 1477
11108, 1464, 1465, 1479, 1478
11109, 1465, 1466, 1480, 1479
11110, 1466, 1467, 1481, 1480
11111, 1467, 1468, 1482, 1481
11112, 1468, 1469, 1483, 1482
11113, 1469, 1470, 1484, 1483
11114, 1470, 209, 210, 1484
11115, 182, 1471, 183, 9
11116, 1471, 1472, 184, 183
11117, 1472, 1473, 185, 184
11118, 1473, 1474, 186, 185
11119, 1474, 1475, 187, 186
11120, 1475, 1476, 188, 187
11121, 1476, 1477, 189, 188
11122, 1477, 1478, 190, 189
11123, 1478, 1479, 191, 190
11124, 1479, 1480, 192, 191
11125, 1480, 1481, 193, 192
11126, 1481, 1482, 194, 193
11127, 1482, 1483, 195, 194
11128, 1483, 1484, 196, 195
11129, 1484, 210, 11, 196
*ELEMENT, type=CPS4, ELSET=Surface12
11130, 10, 239, 1485, 169
11131, 239, 240, 1486, 1485
11132, 240, 241, 1487, 1486
11133, 241, 242, 1488, 1487
11134, 242, 243, 1489, 1488
11135, 243, 244, 1490, 1489
11136, 244, 245, 1491, 1490
11137, 245, 246, 1492, 1491
11138, 246, 247, 1493, 1492
11139, 247, 248, 1494, 1493
11140, 248, 249, 1495, 1494
11141, 249, 250, 1496, 1495
11142, 250, 251, 1497, 1496
11143, 251, 252, 1498, 1497
11144, 252, 14, 253, 1498
11145, 169, 1485, 1499, 170
11146, 1485, 1486, 1500, 1499
11147, 1486, 1487, 1501, 1500
11148, 1487, 1488, 1502, 1501
11149, 1488, 1489, 1503, 1502
11150, 1489, 1490, 1504, 1503
11151, 1490, 1491, 1505, 1504
11152, 1491, 1492, 1506, 1505
11153, 1492, 1493, 1507, 1506
11154, 1493, 1494, 1508, 1507
11155, 1494, 1495, 1509, 1508
11156, 1495, 1496, 1510, 1509
11157, 1496, 1497, 1511, 1510
11158, 1497, 1498, 1512, 1511
11159, 1498, 253, 254, 1512
11160, 170, 1499, 1513, 171
11161, 1499, 1500, 1514, 1513
11162, 1500, 1501, 1515, 1514
11163, 1501, 1502, 1516, 1515
11164, 1502, 1503, 1517, 1516
11165, 1503, 1504, 1518, 1517
11166, 1504, 1505, 1519, 1518
11167, 1505, 1506, 1520, 1519
11168, 1506, 1507, 1521, 1520
11169, 1507, 1508, 1522, 1521
11170, 1508, 1509, 1523, 1522
11171, 1509, 1510, 1524, 1523
11172, 1510, 1511, 1525, 1524
11173, 1511, 1512, 1526, 1525
11174, 1512, 254, 255, 1526
11175, 171, 1513, 1527, 172
11176, 1513, 1514, 1528, 1527
11177, 1514, 1515, 1529, 1528
11178, 1515, 1516, 1530, 1529
11179, 1516, 1517, 1531, 1530
11180, 1517, 1518, 1532, 1531
11181, 1518, 1519, 1533, 1532
11182, 1519, 1520, 1534, 1533
11183, 1520, 1521, 1535, 1534
11184, 1521, 1522, 1536, 1535
11185, 1522, 1523, 1537, 1536
11186, 1523, 1524, 1538, 1537
11187, 1524, 1525, 1539, 1538
11188, 1525, 1526, 1540, 1539
11189, 1526, 255, 256, 1540
11190, 172, 1527, 1541, 173
11191, 1527, 1528, 1542, 1541
11192, 1528, 1529, 1543, 1542
11193, 1529, 1530, 1544, 1543
11194, 1530, 1531, 1545, 1544
11195, 1531, 1532, 1546, 1545
11196, 1532, 1533, 1547, 1546
11197, 1533, 1534, 1548, 1547
11198, 1534, 1535, 1549, 1548
11199, 1535, 1536, 1550, 1549
11200, 1536, 1537, 1551, 1550
11201, 1537, 1538, 1552, 1551
11202, 1538, 1539, 1553, 1552
11203, 1539, 1540, 1554, 1553
11204, 1540, 256, 257, 1554
11205, 173, 1541, 1555, 174
11206, 1541, 1542, 1556, 1555
11207, 1542, 1543, 1557, 1556
11208, 1543, 1544, 1558, 1557
11209, 1544, 1545, 1559, 1558
11210, 1545, 1546, 1560, 1559
11211, 1546, 1547, 1561, 1560
11212, 1547, 1548, 1562, 1561
11213, 1548, 1549, 1563, 1562
11214, 1549, 1550, 1564, 1563
11215, 1550, 1551, 1565, 1564
11216, 1551, 1552, 1566, 1565
11217, 1552, 1553, 1567, 1566
11218, 1553, 1554, 1568, 1567
11219, 1554, 257, 258, 1568
11220, 174, 1555, 1569, 175
11221, 1555, 1556, 1570, 1569
11222, 1556, 1557, 1571, 1570
11223, 1557, 1558, 1572, 1571
11224, 1558, 1559, 1573, 1572
11225, 1559, 1560, 1574, 1573
11226, 1560, 1561, 1575, 1574
11227, 1561, 1562, 1576, 1575
11228, 1562, 1563, 1577, 1576
11229, 1563, 1564, 1578, 1577
11230, 1564, 1565, 1579, 1578
11231, 1565, 1566, 1580, 1579
11232, 1566, 1567, 1581, 1580
11233, 1567, 1568, 1582, 1581
11234, 1568, 258, 259, 1582
11235, 175, 1569, 1583, 176
11236, 1569, 1570, 1584, 1583
11237, 1570, 1571, 1585, 1584
11238, 1571, 1572, 1586, 1585
11239, 1572, 1573, 1587, 1586
11240, 1573, 1574, 1588, 1587
11241, 1574, 1575, 1589, 1588
11242, 1575, 1576, 1590, 1589
11243, 1576, 1577, 1591, 1590
11244, 1577, 1578, 1592, 1591
11245, 1578, 1579, 1593, 1592
11246, 1579, 1580, 1594, 1593
11247, 1580, 1581, 1595, 1594
11248, 1581, 1582, 1596, 1595
11249, 1582, 259, 260, 1596
11250, 176, 1583, 1597, 177
11251, 1583, 1584, 1598, 1597
11252, 1584, 1585, 1599, 1598
11253, 1585, 1586, 1600, 1599
11254, 1586, 1587, 1601, 1600
11255, 1587, 1588, 1602, 1601
11256, 1588, 1589, 1603, 1602
11257, 1589, 1590, 1604, 1603
11258, 1590, 1591, 1605, 1604
11259, 1591, 1592, 1606, 1605
11260, 1592, 1593, 1607, 1606
11261, 1593, 1594, 1608, 1607
11262, 1594, 1595, 1609, 1608
11263, 1595, 1596, 1610, 1609
11264, 1596, 260, 261, 1610
11265, 177, 1597, 1611, 178
11266, 1597, 1598, 1612, 1611
11267, 1598, 1599, 1613, 1612
11268, 1599, 1600, 1614, 1613
11269, 1600, 1601, 1615, 1614
11270, 1601, 1602, 1616, 1615
11271, 1602, 1603, 1617, 1616
11272, 1603, 1604, 1618, 1617
11273, 1604, 1605, 1619, 1618
11274, 1605, 1606, 1620, 1619
11275, 1606, 1607, 1621, 1620
11276, 1607, 1608, 1622, 1621
11277, 1608, 1609, 1623, 1622
11278, 1609, 1610, 1624, 1623
11279, 1610, 261, 262, 1624
11280, 178, 1611, 1625, 179
11281, 1611, 1612, 1626, 1625
11282, 1612, 1613, 1627, 1626
11283, 1613, 1614, 1628, 1627
11284, 1614, 1615, 1629, 1628
11285, 1615, 1616, 1630, 1629
11286, 1616, 1617, 1631, 1630
11287, 1617, 1618, 1632, 1631
11288, 1618, 1619, 1633, 1632
11289, 1619, 1620, 1634, 1633
11290, 1620, 1621, 1635, 1634
11291, 1621, 1622, 1636, 1635
11292, 1622, 1623, 1637, 1636
11293, 1623, 1624, 1638, 1637
11294, 1624, 262, 263, 1638
11295, 179, 1625, 1639, 180
11296, 1625, 1626, 1640, 1639
11297, 1626, 1627, 1641, 1640
11298, 1627, 1628, 1642, 1641
11299, 1628, 1629, 1643, 1642
11300, 1629, 1630, 1644, 1643
11301, 1630, 1631, 1645, 1644
11302, 1631, 1632, 1646, 1645
11303, 1632, 1633, 1647, 1646
11304, 1633, 1634, 1648, 1647
11305, 1634, 1635, 1649, 1648
11306, 1635, 1636, 1650, 1649
11307, 1636, 1637, 1651, 1650
11308, 1637, 1638, 1652, 1651
11309, 1638, 263, 264, 1652
11310, 180, 1639, 1653, 181
11311, 1639, 1640, 1654, 1653
11312, 1640, 1641, 1655, 1654
11313, 1641, 1642, 1656, 1655
11314, 1642, 1643, 1657, 1656
11315, 1643, 1644, 1658, 1657
11316, 1644, 1645, 1659, 1658
11317, 1645, 1646, 1660, 1659
11318, 1646, 1647, 1661, 1660
11319, 1647, 1648, 1662, 1661
11320, 1648, 1649, 1663, 1662
11321, 1649, 1650, 1664, 1663
11322, 1650, 1651, 1665, 1664
11323, 1651, 1652, 1666, 1665
11324, 1652, 264, 265, 1666
11325, 181, 1653, 1667, 182
11326, 1653, 1654, 1668, 1667
11327, 1654, 1655, 1669, 1668
11328, 1655, 1656, 1670, 1669
11329, 1656, 1657, 1671, 1670
11330, 1657, 1658, 1672, 1671
11331, 1658, 1659, 1673, 1672
11332, 1659, 1660, 1674, 1673
11333, 1660, 1661, 1675, 1674
11334, 1661, 1662, 1676, 1675
11335, 1662, 1663, 1677, 1676
11336, 1663, 1664, 1678, 1677
11337, 1664, 1665, 1679, 1678
11338, 1665, 1666, 1680, 1679
11339, 1666, 265, 266, 1680
11340, 182, 1667, 225, 9
11341, 1667, 1668, 226, 225
11342, 1668, 1669, 227, 226
11343, 1669, 1670, 228, 227
11344, 1670, 1671, 229, 228
11345, 1671, 1672, 230, 229
11346, 1672, 1673, 231, 230
11347, 1673, 1674, 232, 231
11348, 1674, 1675, 233, 232
11349, 1675, 1676, 234, 233
11350, 1676, 1677, 235, 234
11351, 1677, 1678, 236, 235
11352, 1678, 1679, 237, 236
11353, 1679, 1680, 238, 237
11354, 1680, 266, 13, 238
*ELEMENT, type=CPS4, ELSET=Surface13
11355, 9, 225, 1681, 183
11356, 225, 226, 1682, 1681
11357, 226, 227, 1683, 1682
11358, 227, 228, 1684, 1683
11359, 228, 229, 1685, 1684
11360, 229, 230, 1686, 1685
11361, 230, 231, 1687, 1686
11362, 231, 232, 1688, 1687
11363, 232, 233, 1689, 1688
11364, 233, 234, 1690, 1689
11365, 234, 235, 1691, 1690
11366, 235, 236, 1692, 1691
11367, 236, 237, 1693, 1692
11368, 237, 238, 1694, 1693
11369, 238, 13, 281, 1694
11370, 183, 1681, 1695, 184
11371, 1681, 1682, 1696, 1695
11372, 1682, 1683, 1697, 1696
11373, 1683, 1684, 1698, 1697
11374, 1684, 1685, 1699, 1698
11375, 1685, 1686, 1700, 1699
11376, 1686, 1687, 1701, 1700
11377, 1687, 1688, 1702, 1701
11378, 1688, 1689, 1703, 1702
11379, 1689, 1690, 1704, 1703
11380, 1690, 1691, 1705, 1704
11381, 1691, 1692, 1706, 1705
11382, 1692, 1693, 1707, 1706
11383, 1693, 1694, 1708, 1707
11384, 1694, 281, 282, 1708
11385, 184, 1695, 1709, 185
11386, 1695, 1696, 1710, 1709
11387, 1696, 1697, 1711, 1710
11388, 1697, 1698, 1712, 1711
11389, 1698, 1699, 1713, 1712
11390, 1699, 1700, 1714, 1713
11391, 1700, 1701, 1715, 1714
11392, 1701, 1702, 1716, 1715
11393, 1702, 1703, 1717, 1716
11394, 1703, 1704, 1718, 1717
11395, 1704, 1705, 1719, 1718
11396, 1705, 1706, 1720, 1719
11397, 1706, 1707, 1721, 1720
11398, 1707, 1708, 1722, 1721
11399, 1708, 282, 283, 1722
11400, 185, 1709, 1723, 186
11401, 1709, 1710, 1724, 1723
11402, 1710, 1711, 1725, 1724
11403, 1711, 1712, 1726, 1725
11404, 1712, 1713, 1727, 1726
11405, 1713, 1714, 1728, 1727
11406, 1714, 1715, 1729, 1728
11407, 1715, 1716, 1730, 1729
11408, 1716, 1717, 1731, 1730
11409, 1717, 1718, 1732, 1731
11410, 1718, 1719, 1733, 1732
11411, 1719, 1720, 1734, 1733
11412, 1720, 1721, 1735, 1734
11413, 1721, 1722, 1736, 1735
11414, 1722, 283, 284, 1736
11415, 186, 1723, 1737, 187
11416, 1723, 1724, 1738, 1737
11417, 1724, 1725, 1739, 1738
11418, 1725, 1726, 1740, 1739
11419, 1726, 1727, 1741, 1740
11420, 1727, 1728, 1742, 1741
11421, 1728, 1729, 1743, 1742
11422, 1729, 1730, 1744, 1743
11423, 1730, 1731, 1745, 1744
11424, 1731, 1732, 1746, 1745
11425, 1732, 1733, 1747, 1746
11426, 1733, 1734, 1748, 1747
11427, 1734, 1735, 1749, 1748
11428, 1735, 1736, 1750, 1749
11429, 1736, 284, 285, 1750
11430, 187, 1737, 1751, 188
11431, 1737, 1738, 1752, 1751
11432, 1738, 1739, 1753, 1752
11433, 1739, 1740, 1754, 1753
11434, 1740, 1741, 1755, 1754
11435, 1741, 1742, 1756, 1755
11436, 1742, 1743, 1757, 1756
11437, 1743, 1744, 1758, 1757
11438, 1744, 1745, 1759, 1758
11439, 1745, 1746, 1760, 1759
11440, 1746, 1747, 1761, 1760
11441, 1747, 1748, 1762, 1761
11442, 1748, 1749, 1763, 1762
11443, 1749, 1750, 1764, 1763
11444, 1750, 285, 286, 1764
11445, 188, 1751, 1765, 189
11446, 1751, 1752, 1766, 1765
11447, 1752, 1753, 1767, 1766
11448, 1753, 1754, 1768, 1767
11449, 1754, 1755, 1769, 1768
11450, 1755, 1756, 1770, 1769
11451, 1756, 1757, 1771, 1770
11452, 1757, 1758, 1772, 1771
11453, 1758, 1759, 1773, 1772
11454, 1759, 1760, 1774, 1773
11455, 1760, 1761, 1775, 1774
11456, 1761, 1762, 1776, 1775
11457, 1762, 1763, 1777, 1776
11458, 1763, 1764, 1778, 1777
11459, 1764, 286, 287, 1778
11460, 189, 1765, 1779, 190
11461, 1765, 1766, 1780, 1779
11462, 1766, 1767, 1781, 1780
11463, 1767, 1768, 1782, 1781
11464, 1768, 1769, 1783, 1782
11465, 1769, 1770, 1784, 1783
11466, 1770, 1771, 1785, 1784
11467, 1771, 1772, 1786, 1785
11468, 1772, 1773, 1787, 1786
11469, 1773, 1774, 1788, 1787
11470, 1774, 1775, 1789, 1788
11471, 1775, 1776, 1790, 1789
11472, 1776, 1777, 1791, 1790
11473, 1777, 1778, 1792, 1791
11474, 1778, 287, 288, 1792
11475, 190, 1779, 1793, 191
11476, 1779, 1780, 1794, 1793
11477, 1780, 1781, 1795, 1794
11478, 1781, 1782, 1796, 1795
11479, 1782, 1783, 1797, 1796
11480, 1783, 1784, 1798, 1797
11481, 1784, 1785, 1799, 1798
11482, 1785, 1786, 1800, 1799
11483, 1786, 1787, 1801, 1800
11484, 1787, 1788, 1802, 1801
11485, 1788, 1789, 1803, 1802
11486, 1789, 1790, 1804, 1803
11487, 1790, 1791, 1805, 1804
11488, 1791, 1792, 1806, 1805
11489, 1792, 288, 289, 1806
11490, 191, 1793, 1807, 192
11491, 1793, 1794, 1808, 1807
11492, 1794, 1795, 1809, 1808
11493, 1795, 1796, 1810, 1809
11494, 1796, 1797, 1811, 1810
11495, 1797, 1798, 1812, 1811
11496, 1798, 1799, 1813, 1812
11497, 1799, 1800, 1814, 1813
11498, 1800, 1801, 1815, 1814
11499, 1801, 1802, 1816, 1815
11500, 1802, 1803, 1817, 1816
11501, 1803, 1804, 1818, 1817
11502, 1804, 1805, 1819, 1818
11503, 1805, 1806, 1820, 1819
11504, 1806, 289, 290, 1820
11505, 192, 1807, 1821, 193
11506, 1807, 1808, 1822, 1821
11507, 1808, 1809, 1823, 1822
11508, 1809, 1810, 1824, 1823
11509, 1810, 1811, 1825, 1824
11510, 1811, 1812, 1826, 1825
11511, 1812, 1813, 1827, 1826
11512, 1813, 1814, 1828, 1827
11513, 1814, 1815, 1829, 1828
11514, 1815, 1816, 1830, 1829
11515, 1816, 1817, 1831, 1830
11516, 1817, 1818, 1832, 1831
11517, 1818, 1819, 1833, 1832
11518, 1819, 1820, 1834, 1833
11519, 1820, 290, 291, 1834
11520, 193, 1821, 1835, 194
11521, 1821, 1822, 1836, 1835
11522, 1822, 1823, 1837, 1836
11523, 1823, 1824, 1838, 1837
11524, 1824, 1825, 1839, 1838
11525, 1825, 1826, 1840, 1839
11526, 1826, 1827, 1841, 1840
11527, 1827, 1828, 1842, 1841
11528, 1828, 1829, 1843, 1842
11529, 1829, 1830, 1844, 1843
11530, 1830, 1831, 1845, 1844
11531, 1831, 1832, 1846, 1845
11532, 1832, 1833, 1847, 1846
11533, 1833, 1834, 1848, 1847
11534, 1834, 291, 292, 1848
11535, 194, 1835, 1849, 195
11536, 1835, 1836, 1850, 1849
11537, 1836, 1837, 1851, 1850
11538, 1837, 1838, 1852, 1851
11539, 1838, 1839, 1853, 1852
11540, 1839, 1840, 1854, 1853
11541, 1840, 1841, 1855, 1854
11542, 1841, 1842, 1856, 1855
11543, 1842, 1843, 1857, 1856
11544, 1843, 1844, 1858, 1857
11545, 1844, 1845, 1859, 1858
11546, 1845, 1846, 1860, 1859
11547, 1846, 1847, 1861, 1860
11548, 1847, 1848, 1862, 1861
11549, 1848, 292, 293, 1862
11550, 195, 1849, 1863, 196
11551, 1849, 1850, 1864, 1863
11552, 1850, 1851, 1865, 1864
11553, 1851, 1852, 1866, 1865
11554, 1852, 1853, 1867, 1866
11555, 1853, 1854, 1868, 1867
11556, 1854, 1855, 1869, 1868
11557, 1855, 1856, 1870, 1869
11558, 1856, 1857, 1871, 1870
11559, 1857, 1858, 1872, 1871
11560, 1858, 1859, 1873, 1872
11561, 1859, 1860, 1874, 1873
11562, 1860, 1861, 1875, 1874
11563, 1861, 1862, 1876, 1875
11564, 1862, 293, 294, 1876
11565, 196, 1863, 267, 11
11566, 1863, 1864, 268, 267
11567, 1864, 1865, 269, 268
11568, 1865, 1866, 270, 269
11569, 1866, 1867, 271, 270
11570, 1867, 1868, 272, 271
11571, 1868, 1869, 273, 272
11572, 1869, 1870, 274, 273
11573, 1870, 1871, 275, 274
11574, 1871, 1872, 276, 275
11575, 1872, 1873, 277, 276
11576, 1873, 1874, 278, 277
11577, 1874, 1875, 279, 278
11578, 1875, 1876, 280, 279
11579, 1876, 294, 15, 280
*ELEMENT, type=CPS4, ELSET=Surface14
11580, 12, 197, 1877, 295
11581, 295, 1877, 1878, 296
11582, 296, 1878, 1879, 297
11583, 297, 1879, 1880, 298
11584, 298, 1880, 1881, 299
11585, 299, 1881, 1882, 300
11586, 300, 1882, 1883, 301
11587, 301, 1883, 1884, 302
11588, 302, 1884, 1885, 303
11589, 303, 1885, 1886, 304
11590, 304, 1886, 1887, 305
11591, 305, 1887, 1888, 306
11592, 306, 1888, 1889, 307
11593, 307, 1889, 1890, 308
11594, 308, 1890, 309, 16
11595, 197, 198, 1891, 1877
11596, 1877, 1891, 1892, 1878
11597, 1878, 1892, 1893, 1879
11598, 1879, 1893, 1894, 1880
11599, 1880, 1894, 1895, 1881
11600, 1881, 1895, 1896, 1882
11601, 1882, 1896, 1897, 1883
11602, 1883, 1897, 1898, 1884
11603, 1884, 1898, 1899, 1885
11604, 1885, 1899, 1900, 1886
11605, 1886, 1900, 1901, 1887
11606, 1887, 1901, 1902, 1888
11607, 1888, 1902, 1903, 1889
11608, 1889, 1903, 1904, 1890
11609, 1890, 1904, 310, 309
11610, 198, 199, 1905, 1891
11611, 1891, 1905, 1906, 1892
11612, 1892, 1906, 1907, 1893
11613, 1893, 1907, 1908, 1894
11614, 1894, 1908, 1909, 1895
11615, 1895, 1909, 1910, 1896
11616, 1896, 1910, 1911, 1897
11617, 1897, 1911, 1912, 1898
11618, 1898, 1912, 1913, 1899
11619, 1899, 1913, 1914, 1900
11620, 1900, 1914, 1915, 1901
11621, 1901, 1915, 1916, 1902
11622, 1902, 1916, 1917, 1903
11623, 1903, 1917, 1918, 1904
11624, 1904, 1918, 311, 310
11625, 199, 200, 1919, 1905
11626, 1905, 1919, 1920, 1906
11627, 1906, 1920, 1921, 1907
11628, 1907, 1921, 1922, 1908
11629, 1908, 1922, 1923, 1909
11630, 1909, 1923, 1924, 1910
11631, 1910, 1924, 1925, 1911
11632, 1911, 1925, 1926, 1912
11633, 1912, 1926, 1927, 1913
11634, 1913, 1927, 1928, 1914
11635, 1914, 1928, 1929, 1915
11636, 1915, 1929, 1930, 1916
11637, 1916, 1930, 1931, 1917
11638, 1917, 1931, 1932, 1918
11639, 1918, 1932, 312, 311
11640, 200, 201, 1933, 1919
11641, 1919, 1933, 1934, 1920
11642, 1920, 1934, 1935, 1921
11643, 1921, 1935, 1936, 1922
11644, 1922, 1936, 1937, 1923
11645, 1923, 1937, 1938, 1924
11646, 1924, 1938, 1939, 1925
11647, 1925, 1939, 1940, 1926
11648, 1926, 1940, 1941, 1927
11649, 1927, 1941, 1942, 1928
11650, 1928, 1942, 1943, 1929
11651, 1929, 1943, 1944, 1930
11652, 1930, 1944, 1945, 1931
11653, 1931, 1945, 1946, 1932
11654, 1932, 1946, 313, 312
11655, 201, 202, 1947, 1933
11656, 1933, 1947, 1948, 1934
11657, 1934, 1948, 1949, 1935
11658, 1935, 1949, 1950, 1936
11659, 1936, 1950, 1951, 1937
11660, 1937, 1951, 1952, 1938
11661, 1938, 1952, 1953, 1939
11662, 1939, 1953, 1954, 1940
11663, 1940, 1954, 1955, 1941
11664, 1941, 1955, 1956, 1942
11665, 1942, 1956, 1957, 1943
11666, 1943, 1957, 1958, 1944
11667, 1944, 1958, 1959, 1945
11668, 1945, 1959, 1960, 1946
11669, 1946, 1960, 314, 313
11670, 202, 203, 1961, 1947
11671, 1947, 1961, 1962, 1948
11672, 1948, 1962, 1963, 1949
11673, 1949, 1963, 1964, 1950
11674, 1950, 1964, 1965, 1951
11675, 1951, 1965, 1966, 1952
11676, 1952, 1966, 1967, 1953
11677, 1953, 1967, 1968, 1954
11678, 1954, 1968, 1969, 1955
11679, 1955, 1969, 1970, 1956
11680, 1956, 1970, 1971, 1957
11681, 1957, 1971, 1972, 1958
11682, 1958, 1972, 1973, 1959
11683, 1959, 1973, 1974, 1960
11684, 1960, 1974, 315, 314
11685, 203, 204, 1975, 1961
11686, 1961, 1975, 1976, 1962
11687, 1962, 1976, 1977, 1963
11688, 1963, 1977, 1978, 1964
11689, 1964, 1978, 1979, 1965
11690, 1965, 1979, 1980, 1966
11691, 1966, 1980, 1981, 1967
11692, 1967, 1981, 1982, 1968
11693, 1968, 1982, 1983, 1969
11694, 1969, 1983, 1984, 1970
11695, 1970, 1984, 1985, 1971
11696, 1971, 1985, 1986, 1972
11697, 1972, 1986, 1987, 1973
11698, 1973, 1987, 1988, 1974
11699, 1974, 1988, 316, 315
11700, 204, 205, 1989, 1975
11701, 1975, 1989, 1990, 1976
11702, 1976, 1990, 1991, 1977
11703, 1977, 1991, 1992, 1978
11704, 1978, 1992, 1993, 1979
11705, 1979, 1993, 1994, 1980
11706, 1980, 1994, 1995, 1981
11707, 1981, 1995, 1996, 1982
11708, 1982, 1996, 1997, 1983
11709, 1983, 1997, 1998, 1984
11710, 1984, 1998, 1999, 1985
11711, 1985, 1999, 2000, 1986
11712, 1986, 2000, 2001, 1987
11713, 1987, 2001, 2002, 1988
11714, 1988, 2002, 317, 316
11715, 205, 206, 2003, 1989
11716, 1989, 2003, 2004, 1990
11717, 1990, 2004, 2005, 1991
11718, 1991, 2005, 2006, 1992
11719, 1992, 2006, 2007, 1993
11720, 1993, 2007, 2008, 1994
11721, 1994, 2008, 2009, 1995
11722, 1995, 2009, 2010, 1996
11723, 1996, 2010, 2011, 1997
11724, 1997, 2011, 2012, 1998
11725, 1998, 2012, 2013, 1999
11726, 1999, 2013, 2014, 2000
11727, 2000, 2014, 2015, 2001
11728, 2001, 2015, 2016, 2002
11729, 2002, 2016, 318, 317
11730, 206, 207, 2017, 2003
11731, 2003, 2017, 2018, 2004
11732, 2004, 2018, 2019, 2005
11733, 2005, 2019, 2020, 2006
11734, 2006, 2020, 2021, 2007
11735, 2007, 2021, 2022, 2008
11736, 2008, 2022, 2023, 2009
11737, 2009, 2023, 2024, 2010
11738, 2010, 2024, 2025, 2011
11739, 2011, 2025, 2026, 2012
11740, 2012, 2026, 2027, 2013
11741, 2013, 2027, 2028, 2014
11742, 2014, 2028, 2029, 2015
11743, 2015, 2029, 2030, 2016
11744, 2016, 2030, 319, 318
11745, 207, 208, 2031, 2017
11746, 2017, 2031, 2032, 2018
11747, 2018, 2032, 2033, 2019
11748, 2019, 2033, 2034, 2020
11749, 2020, 2034, 2035, 2021
11750, 2021, 2035, 2036, 2022
11751, 2022, 2036, 2037, 2023
11752, 2023, 2037, 2038, 2024
11753, 2024, 2038, 2039, 2025
11754, 2025, 2039, 2040, 2026
11755, 2026, 2040, 2041, 2027
11756, 2027, 2041, 2042, 2028
11757, 2028, 2042, 2043, 2029
11758, 2029, 2043, 2044, 2030
11759, 2030, 2044, 320, 319
11760, 208, 209, 2045, 2031
11761, 2031, 2045, 2046, 2032
11762, 2032, 2046, 2047, 2033
11763, 2033, 2047, 2048, 2034
11764, 2034, 2048, 2049, 2035
11765, 2035, 2049, 2050, 2036
11766, 2036, 2050, 2051, 2037
11767, 2037, 2051, 2052, 2038
11768, 2038, 2052, 2053, 2039
11769, 2039, 2053, 2054, 2040
11770, 2040, 2054, 2055, 2041
11771, 2041, 2055, 2056, 2042
11772, 2042, 2056, 2057, 2043
11773, 2043, 2057, 2058, 2044
11774, 2044, 2058, 321, 320
11775, 209, 210, 2059, 2045
11776, 2045, 2059, 2060, 2046
11777, 2046, 2060, 2061, 2047
11778, 2047, 2061, 2062, 2048
11779, 2048, 2062, 2063, 2049
11780, 2049, 2063, 2064, 2050
11781, 2050, 2064, 2065, 2051
11782, 2051, 2065, 2066, 2052
11783, 2052, 2066, 2067, 2053
11784, 2053, 2067, 2068, 2054
11785, 2054, 2068, 2069, 2055
11786, 2055, 2069, 2070, 2056
11787, 2056, 2070, 2071, 2057
11788, 2057, 2071, 2072, 2058
11789, 2058, 2072, 322, 321
11790, 210, 11, 267, 2059
11791, 2059, 267, 268, 2060
11792, 2060, 268, 269, 2061
11793, 2061, 269, 270, 2062
11794, 2062, 270, 271, 2063
11795, 2063, 271, 272, 2064
11796, 2064, 272, 273, 2065
11797, 2065, 273, 274, 2066
11798, 2066, 274, 275, 2067
11799, 2067, 275, 276, 2068
11800, 2068, 276, 277, 2069
11801, 2069, 277, 278, 2070
11802, 2070, 278, 279, 2071
11803, 2071, 279, 280, 2072
11804, 2072, 280, 15, 322
*ELEMENT, type=CPS4, ELSET=Surface15
11805, 10, 211, 2073, 239
11806, 239, 2073, 2074, 240
11807, 240, 2074, 2075, 241
11808, 241, 2075, 2076, 242
11809, 242, 2076, 2077, 243
