11810, 243, 2077, 2078, 244
11811, 244, 2078, 2079, 245
11812, 245, 2079, 2080, 246
11813, 246, 2080, 2081, 247
11814, 247, 2081, 2082, 248
11815, 248, 2082, 2083, 249
11816, 249, 2083, 2084, 250
11817, 250, 2084, 2085, 251
11818, 251, 2085, 2086, 252
11819, 252, 2086, 323, 14
11820, 211, 212, 2087, 2073
11821, 2073, 2087, 2088, 2074
11822, 2074, 2088, 2089, 2075
11823, 2075, 2089, 2090, 2076
11824, 2076, 2090, 2091, 2077
11825, 2077, 2091, 2092, 2078
11826, 2078, 2092, 2093, 2079
11827, 2079, 2093, 2094, 2080
11828, 2080, 2094, 2095, 2081
11829, 2081, 2095, 2096, 2082
11830, 2082, 2096, 2097, 2083
11831, 2083, 2097, 2098, 2084
11832, 2084, 2098, 2099, 2085
11833, 2085, 2099, 2100, 2086
11834, 2086, 2100, 324, 323
11835, 212, 213, 2101, 2087
11836, 2087, 2101, 2102, 2088
11837, 2088, 2102, 2103, 2089
11838, 2089, 2103, 2104, 2090
11839, 2090, 2104, 2105, 2091
11840, 2091, 2105, 2106, 2092
11841, 2092, 2106, 2107, 2093
11842, 2093, 2107, 2108, 2094
11843, 2094, 2108, 2109, 2095
11844, 2095, 2109, 2110, 2096
11845, 2096, 2110, 2111, 2097
11846, 2097, 2111, 2112, 2098
11847, 2098, 2112, 2113, 2099
11848, 2099, 2113, 2114, 2100
11849, 2100, 2114, 325, 324
11850, 213, 214, 2115, 2101
11851, 2101, 2115, 2116, 2102
11852, 2102, 2116, 2117, 2103
11853, 2103, 2117, 2118, 2104
11854, 2104, 2118, 2119, 2105
11855, 2105, 2119, 2120, 2106
11856, 2106, 2120, 2121, 2107
11857, 2107, 2121, 2122, 2108
11858, 2108, 2122, 2123, 2109
11859, 2109, 2123, 2124, 2110
11860, 2110, 2124, 2125, 2111
11861, 2111, 2125, 2126, 2112
11862, 2112, 2126, 2127, 2113
11863, 2113, 2127, 2128, 2114
11864, 2114, 2128, 326, 325
11865, 214, 215, 2129, 2115
11866, 2115, 2129, 2130, 2116
11867, 2116, 2130, 2131, 2117
11868, 2117, 2131, 2132, 2118
11869, 2118, 2132, 2133, 2119
11870, 2119, 2133, 2134, 2120
11871, 2120, 2134, 2135, 2121
11872, 2121, 2135, 2136, 2122
11873, 2122, 2136, 2137, 2123
11874, 2123, 2137, 2138, 2124
11875, 2124, 2138, 2139, 2125
11876, 2125, 2139, 2140, 2126
11877, 2126, 2140, 2141, 2127
11878, 2127, 2141, 2142, 2128
11879, 2128, 2142, 327, 326
11880, 215, 216, 2143, 2129
11881, 2129, 2143, 2144, 2130
11882, 2130, 2144, 2145, 2131
11883, 2131, 2145, 2146, 2132
11884, 2132, 2146, 2147, 2133
11885, 2133, 2147, 2148, 2134
11886, 2134, 2148, 2149, 2135
11887, 2135, 2149, 2150, 2136
11888, 2136, 2150, 2151, 2137
11889, 2137, 2151, 2152, 2138
11890, 2138, 2152, 2153, 2139
11891, 2139, 2153, 2154, 2140
11892, 2140, 2154, 2155, 2141
11893, 2141, 2155, 2156, 2142
11894, 2142, 2156, 328, 327
11895, 216, 217, 2157, 2143
11896, 2143, 2157, 2158, 2144
11897, 2144, 2158, 2159, 2145
11898, 2145, 2159, 2160, 2146
11899, 2146, 2160, 2161, 2147
11900, 2147, 2161, 2162, 2148
11901, 2148, 2162, 2163, 2149
11902, 2149, 2163, 2164, 2150
11903, 2150, 2164, 2165, 2151
11904, 2151, 2165, 2166, 2152
11905, 2152, 2166, 2167, 2153
11906, 2153, 2167, 2168, 2154
11907, 2154, 2168, 2169, 2155
11908, 2155, 2169, 2170, 2156
11909, 2156, 2170, 329, 328
11910, 217, 218, 2171, 2157
11911, 2157, 2171, 2172, 2158
11912, 2158, 2172, 2173, 2159
11913, 2159, 2173, 2174, 2160
11914, 2160, 2174, 2175, 2161
11915, 2161, 2175, 2176, 2162
11916, 2162, 2176, 2177, 2163
11917, 2163, 2177, 2178, 2164
11918, 2164, 2178, 2179, 2165
11919, 2165, 2179, 2180, 2166
11920, 2166, 2180, 2181, 2167
11921, 2167, 2181, 2182, 2168
11922, 2168, 2182, 2183, 2169
11923, 2169, 2183, 2184, 2170
11924, 2170, 2184, 330, 329
11925, 218, 219, 2185, 2171
11926, 2171, 2185, 2186, 2172
11927, 2172, 2186, 2187, 2173
11928, 2173, 2187, 2188, 2174
11929, 2174, 2188, 2189, 2175
11930, 2175, 2189, 2190, 2176
11931, 2176, 2190, 2191, 2177
11932, 2177, 2191, 2192, 2178
11933, 2178, 2192, 2193, 2179
11934, 2179, 2193, 2194, 2180
11935, 2180, 2194, 2195, 2181
11936, 2181, 2195, 2196, 2182
11937, 2182, 2196, 2197, 2183
11938, 2183, 2197, 2198, 2184
11939, 2184, 2198, 331, 330
11940, 219, 220, 2199, 2185
11941, 2185, 2199, 2200, 2186
11942, 2186, 2200, 2201, 2187
11943, 2187, 2201, 2202, 2188
11944, 2188, 2202, 2203, 2189
11945, 2189, 2203, 2204, 2190
11946, 2190, 2204, 2205, 2191
11947, 2191, 2205, 2206, 2192
11948, 2192, 2206, 2207, 2193
11949, 2193, 2207, 2208, 2194
11950, 2194, 2208, 2209, 2195
11951, 2195, 2209, 2210, 2196
11952, 2196, 2210, 2211, 2197
11953, 2197, 2211, 2212, 2198
11954, 2198, 2212, 332, 331
11955, 220, 221, 2213, 2199
11956, 2199, 2213, 2214, 2200
11957, 2200, 2214, 2215, 2201
11958, 2201, 2215, 2216, 2202
11959, 2202, 2216, 2217, 2203
11960, 2203, 2217, 2218, 2204
11961, 2204, 2218, 2219, 2205
11962, 2205, 2219, 2220, 2206
11963, 2206, 2220, 2221, 2207
11964, 2207, 2221, 2222, 2208
11965, 2208, 2222, 2223, 2209
11966, 2209, 2223, 2224, 2210
11967, 2210, 2224, 2225, 2211
11968, 2211, 2225, 2226, 2212
11969, 2212, 2226, 333, 332
11970, 221, 222, 2227, 2213
11971, 2213, 2227, 2228, 2214
11972, 2214, 2228, 2229, 2215
11973, 2215, 2229, 2230, 2216
11974, 2216, 2230, 2231, 2217
11975, 2217, 2231, 2232, 2218
11976, 2218, 2232, 2233, 2219
11977, 2219, 2233, 2234, 2220
11978, 2220, 2234, 2235, 2221
11979, 2221, 2235, 2236, 2222
11980, 2222, 2236, 2237, 2223
11981, 2223, 2237, 2238, 2224
11982, 2224, 2238, 2239, 2225
11983, 2225, 2239, 2240, 2226
11984, 2226, 2240, 334, 333
11985, 222, 223, 2241, 2227
11986, 2227, 2241, 2242, 2228
11987, 2228, 2242, 2243, 2229
11988, 2229, 2243, 2244, 2230
11989, 2230, 2244, 2245, 2231
11990, 2231, 2245, 2246, 2232
11991, 2232, 2246, 2247, 2233
11992, 2233, 2247, 2248, 2234
11993, 2234, 2248, 2249, 2235
11994, 2235, 2249, 2250, 2236
11995, 2236, 2250, 2251, 2237
11996, 2237, 2251, 2252, 2238
11997, 2238, 2252, 2253, 2239
11998, 2239, 2253, 2254, 2240
11999, 2240, 2254, 335, 334
12000, 223, 224, 2255, 2241
12001, 2241, 2255, 2256, 2242
12002, 2242, 2256, 2257, 2243
12003, 2243, 2257, 2258, 2244
12004, 2244, 2258, 2259, 2245
12005, 2245, 2259, 2260, 2246
12006, 2246, 2260, 2261, 2247
12007, 2247, 2261, 2262, 2248
12008, 2248, 2262, 2263, 2249
12009, 2249, 2263, 2264, 2250
12010, 2250, 2264, 2265, 2251
12011, 2251, 2265, 2266, 2252
12012, 2252, 2266, 2267, 2253
12013, 2253, 2267, 2268, 2254
12014, 2254, 2268, 336, 335
12015, 224, 12, 295, 2255
12016, 2255, 295, 296, 2256
12017, 2256, 296, 297, 2257
12018, 2257, 297, 298, 2258
12019, 2258, 298, 299, 2259
12020, 2259, 299, 300, 2260
12021, 2260, 300, 301, 2261
12022, 2261, 301, 302, 2262
12023, 2262, 302, 303, 2263
12024, 2263, 303, 304, 2264
12025, 2264, 304, 305, 2265
12026, 2265, 305, 306, 2266
12027, 2266, 306, 307, 2267
12028, 2267, 307, 308, 2268
12029, 2268, 308, 16, 336
*ELEMENT, type=CPS4, ELSET=Surface16
12030, 14, 323, 2269, 253
12031, 323, 324, 2270, 2269
12032, 324, 325, 2271, 2270
12033, 325, 326, 2272, 2271
12034, 326, 327, 2273, 2272
12035, 327, 328, 2274, 2273
12036, 328, 329, 2275, 2274
12037, 329, 330, 2276, 2275
12038, 330, 331, 2277, 2276
12039, 331, 332, 2278, 2277
12040, 332, 333, 2279, 2278
12041, 333, 334, 2280, 2279
12042, 334, 335, 2281, 2280
12043, 335, 336, 2282, 2281
12044, 336, 16, 309, 2282
12045, 253, 2269, 2283, 254
12046, 2269, 2270, 2284, 2283
12047, 2270, 2271, 2285, 2284
12048, 2271, 2272, 2286, 2285
12049, 2272, 2273, 2287, 2286
12050, 2273, 2274, 2288, 2287
12051, 2274, 2275, 2289, 2288
12052, 2275, 2276, 2290, 2289
12053, 2276, 2277, 2291, 2290
12054, 2277, 2278, 2292, 2291
12055, 2278, 2279, 2293, 2292
12056, 2279, 2280, 2294, 2293
12057, 2280, 2281, 2295, 2294
12058, 2281, 2282, 2296, 2295
12059, 2282, 309, 310, 2296
12060, 254, 2283, 2297, 255
12061, 2283, 2284, 2298, 2297
12062, 2284, 2285, 2299, 2298
12063, 2285, 2286, 2300, 2299
12064, 2286, 2287, 2301, 2300
12065, 2287, 2288, 2302, 2301
12066, 2288, 2289, 2303, 2302
12067, 2289, 2290, 2304, 2303
12068, 2290, 2291, 2305, 2304
12069, 2291, 2292, 2306, 2305
12070, 2292, 2293, 2307, 2306
12071, 2293, 2294, 2308, 2307
12072, 2294, 2295, 2309, 2308
12073, 2295, 2296, 2310, 2309
12074, 2296, 310, 311, 2310
12075, 255, 2297, 2311, 256
12076, 2297, 2298, 2312, 2311
12077, 2298, 2299, 2313, 2312
12078, 2299, 2300, 2314, 2313
12079, 2300, 2301, 2315, 2314
12080, 2301, 2302, 2316, 2315
12081, 2302, 2303, 2317, 2316
12082, 2303, 2304, 2318, 2317
12083, 2304, 2305, 2319, 2318
12084, 2305, 2306, 2320, 2319
12085, 2306, 2307, 2321, 2320
12086, 2307, 2308, 2322, 2321
12087, 2308, 2309, 2323, 2322
12088, 2309, 2310, 2324, 2323
12089, 2310, 311, 312, 2324
12090, 256, 2311, 2325, 257
12091, 2311, 2312, 2326, 2325
12092, 2312, 2313, 2327, 2326
12093, 2313, 2314, 2328, 2327
12094, 2314, 2315, 2329, 2328
12095, 2315, 2316, 2330, 2329
12096, 2316, 2317, 2331, 2330
12097, 2317, 2318, 2332, 2331
12098, 2318, 2319, 2333, 2332
12099, 2319, 2320, 2334, 2333
12100, 2320, 2321, 2335, 2334
12101, 2321, 2322, 2336, 2335
12102, 2322, 2323, 2337, 2336
12103, 2323, 2324, 2338, 2337
12104, 2324, 312, 313, 2338
12105, 257, 2325, 2339, 258
12106, 2325, 2326, 2340, 2339
12107, 2326, 2327, 2341, 2340
12108, 2327, 2328, 2342, 2341
12109, 2328, 2329, 2343, 2342
12110, 2329, 2330, 2344, 2343
12111, 2330, 2331, 2345, 2344
12112, 2331, 2332, 2346, 2345
12113, 2332, 2333, 2347, 2346
12114, 2333, 2334, 2348, 2347
12115, 2334, 2335, 2349, 2348
12116, 2335, 2336, 2350, 2349
12117, 2336, 2337, 2351, 2350
12118, 2337, 2338, 2352, 2351
12119, 2338, 313, 314, 2352
12120, 258, 2339, 2353, 259
12121, 2339, 2340, 2354, 2353
12122, 2340, 2341, 2355, 2354
12123, 2341, 2342, 2356, 2355
12124, 2342, 2343, 2357, 2356
12125, 2343, 2344, 2358, 2357
12126, 2344, 2345, 2359, 2358
12127, 2345, 2346, 2360, 2359
12128, 2346, 2347, 2361, 2360
12129, 2347, 2348, 2362, 2361
12130, 2348, 2349, 2363, 2362
12131, 2349, 2350, 2364, 2363
12132, 2350, 2351, 2365, 2364
12133, 2351, 2352, 2366, 2365
12134, 2352, 314, 315, 2366
12135, 259, 2353, 2367, 260
12136, 2353, 2354, 2368, 2367
12137, 2354, 2355, 2369, 2368
12138, 2355, 2356, 2370, 2369
12139, 2356, 2357, 2371, 2370
12140, 2357, 2358, 2372, 2371
12141, 2358, 2359, 2373, 2372
12142, 2359, 2360, 2374, 2373
12143, 2360, 2361, 2375, 2374
12144, 2361, 2362, 2376, 2375
12145, 2362, 2363, 2377, 2376
12146, 2363, 2364, 2378, 2377
12147, 2364, 2365, 2379, 2378
12148, 2365, 2366, 2380, 2379
12149, 2366, 315, 316, 2380
12150, 260, 2367, 2381, 261
12151, 2367, 2368, 2382, 2381
12152, 2368, 2369, 2383, 2382
12153, 2369, 2370, 2384, 2383
12154, 2370, 2371, 2385, 2384
12155, 2371, 2372, 2386, 2385
12156, 2372, 2373, 2387, 2386
12157, 2373, 2374, 2388, 2387
12158, 2374, 2375, 2389, 2388
12159, 2375, 2376, 2390, 2389
12160, 2376, 2377, 2391, 2390
12161, 2377, 2378, 2392, 2391
12162, 2378, 2379, 2393, 2392
12163, 2379, 2380, 2394, 2393
12164, 2380, 316, 317, 2394
12165, 261, 2381, 2395, 262
12166, 2381, 2382, 2396, 2395
12167, 2382, 2383, 2397, 2396
12168, 2383, 2384, 2398, 2397
12169, 2384, 2385, 2399, 2398
12170, 2385, 2386, 2400, 2399
12171, 2386, 2387, 2401, 2400
12172, 2387, 2388, 2402, 2401
12173, 2388, 2389, 2403, 2402
12174, 2389, 2390, 2404, 2403
12175, 2390, 2391, 2405, 2404
12176, 2391, 2392, 2406, 2405
12177, 2392, 2393, 2407, 2406
12178, 2393, 2394, 2408, 2407
12179, 2394, 317, 318, 2408
12180, 262, 2395, 2409, 263
12181, 2395, 2396, 2410, 2409
12182, 2396, 2397, 2411, 2410
12183, 2397, 2398, 2412, 2411
12184, 2398, 2399, 2413, 2412
12185, 2399, 2400, 2414, 2413
12186, 2400, 2401, 2415, 2414
12187, 2401, 2402, 2416, 2415
12188, 2402, 2403, 2417, 2416
12189, 2403, 2404, 2418, 2417
12190, 2404, 2405, 2419, 2418
12191, 2405, 2406, 2420, 2419
12192, 2406, 2407, 2421, 2420
12193, 2407, 2408, 2422, 2421
12194, 2408, 318, 319, 2422
12195, 263, 2409, 2423, 264
12196, 2409, 2410, 2424, 2423
12197, 2410, 2411, 2425, 2424
12198, 2411, 2412, 2426, 2425
12199, 2412, 2413, 2427, 2426
12200, 2413, 2414, 2428, 2427
12201, 2414, 2415, 2429, 2428
12202, 2415, 2416, 2430, 2429
12203, 2416, 2417, 2431, 2430
12204, 2417, 2418, 2432, 2431
12205, 2418, 2419, 2433, 2432
12206, 2419, 2420, 2434, 2433
12207, 2420, 2421, 2435, 2434
12208, 2421, 2422, 2436, 2435
12209, 2422, 319, 320, 2436
12210, 264, 2423, 2437, 265
12211, 2423, 2424, 2438, 2437
12212, 2424, 2425, 2439, 2438
12213, 2425, 2426, 2440, 2439
12214, 2426, 2427, 2441, 2440
12215, 2427, 2428, 2442, 2441
12216, 2428, 2429, 2443, 2442
12217, 2429, 2430, 2444, 2443
12218, 2430, 2431, 2445, 2444
12219, 2431, 2432, 2446, 2445
12220, 2432, 2433, 2447, 2446
12221, 2433, 2434, 2448, 2447
12222, 2434, 2435, 2449, 2448
12223, 2435, 2436, 2450, 2449
12224, 2436, 320, 321, 2450
12225, 265, 2437, 2451, 266
12226, 2437, 2438, 2452, 2451
12227, 2438, 2439, 2453, 2452
12228, 2439, 2440, 2454, 2453
12229, 2440, 2441, 2455, 2454
12230, 2441, 2442, 2456, 2455
12231, 2442, 2443, 2457, 2456
12232, 2443, 2444, 2458, 2457
12233, 2444, 2445, 2459, 2458
12234, 2445, 2446, 2460, 2459
12235, 2446, 2447, 2461, 2460
12236, 2447, 2448, 2462, 2461
12237, 2448, 2449, 2463, 2462
12238, 2449, 2450, 2464, 2463
12239, 2450, 321, 322, 2464
12240, 266, 2451, 281, 13
12241, 2451, 2452, 282, 281
12242, 2452, 2453, 283, 282
12243, 2453, 2454, 284, 283
12244, 2454, 2455, 285, 284
12245, 2455, 2456, 286, 285
12246, 2456, 2457, 287, 286
12247, 2457, 2458, 288, 287
12248, 2458, 2459, 289, 288
12249, 2459, 2460, 290, 289
12250, 2460, 2461, 291, 290
12251, 2461, 2462, 292, 291
12252, 2462, 2463, 293, 292
12253, 2463, 2464, 294, 293
12254, 2464, 322, 15, 294
*ELEMENT, type=CPS4, ELSET=Surface17
12255, 14, 18, 337, 253
12256, 253, 337, 338, 254
12257, 254, 338, 339, 255
12258, 255, 339, 340, 256
12259, 256, 340, 341, 257
12260, 257, 341, 342, 258
12261, 258, 342, 343, 259
12262, 259, 343, 344, 260
12263, 260, 344, 345, 261
12264, 261, 345, 346, 262
12265, 262, 346, 347, 263
12266, 263, 347, 348, 264
12267, 264, 348, 349, 265
12268, 265, 349, 350, 266
12269, 266, 350, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
12270, 13, 17, 351, 281
12271, 281, 351, 352, 282
12272, 282, 352, 353, 283
12273, 283, 353, 354, 284
12274, 284, 354, 355, 285
12275, 285, 355, 356, 286
12276, 286, 356, 357, 287
12277, 287, 357, 358, 288
12278, 288, 358, 359, 289
12279, 289, 359, 360, 290
12280, 290, 360, 361, 291
12281, 291, 361, 362, 292
12282, 292, 362, 363, 293
12283, 293, 363, 364, 294
12284, 294, 364, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
12285, 16, 309, 365, 20
12286, 309, 310, 366, 365
12287, 310, 311, 367, 366
12288, 311, 312, 368, 367
12289, 312, 313, 369, 368
12290, 313, 314, 370, 369
12291, 314, 315, 371, 370
12292, 315, 316, 372, 371
12293, 316, 317, 373, 372
12294, 317, 318, 374, 373
12295, 318, 319, 375, 374
12296, 319, 320, 376, 375
12297, 320, 321, 377, 376
12298, 321, 322, 378, 377
12299, 322, 15, 19, 378
*ELEMENT, type=CPS4, ELSET=Surface20
12300, 14, 323, 379, 18
12301, 323, 324, 380, 379
12302, 324, 325, 381, 380
12303, 325, 326, 382, 381
12304, 326, 327, 383, 382
12305, 327, 328, 384, 383
12306, 328, 329, 385, 384
12307, 329, 330, 386, 385
12308, 330, 331, 387, 386
12309, 331, 332, 388, 387
12310, 332, 333, 389, 388
12311, 333, 334, 390, 389
12312, 334, 335, 391, 390
12313, 335, 336, 392, 391
12314, 336, 16, 20, 392
*ELEMENT, type=CPS4, ELSET=Surface21
12315, 18, 379, 2465, 337
12316, 379, 380, 2466, 2465
12317, 380, 381, 2467, 2466
12318, 381, 382, 2468, 2467
12319, 382, 383, 2469, 2468
12320, 383, 384, 2470, 2469
12321, 384, 385, 2471, 2470
12322, 385, 386, 2472, 2471
12323, 386, 387, 2473, 2472
12324, 387, 388, 2474, 2473
12325, 388, 389, 2475, 2474
12326, 389, 390, 2476, 2475
12327, 390, 391, 2477, 2476
12328, 391, 392, 2478, 2477
12329, 392, 20, 365, 2478
12330, 337, 2465, 2479, 338
12331, 2465, 2466, 2480, 2479
12332, 2466, 2467, 2481, 2480
12333, 2467, 2468, 2482, 2481
12334, 2468, 2469, 2483, 2482
12335, 2469, 2470, 2484, 2483
12336, 2470, 2471, 2485, 2484
12337, 2471, 2472, 2486, 2485
12338, 2472, 2473, 2487, 2486
12339, 2473, 2474, 2488, 2487
12340, 2474, 2475, 2489, 2488
12341, 2475, 2476, 2490, 2489
12342, 2476, 2477, 2491, 2490
12343, 2477, 2478, 2492, 2491
12344, 2478, 365, 366, 2492
12345, 338, 2479, 2493, 339
12346, 2479, 2480, 2494, 2493
12347, 2480, 2481, 2495, 2494
12348, 2481, 2482, 2496, 2495
12349, 2482, 2483, 2497, 2496
12350, 2483, 2484, 2498, 2497
12351, 2484, 2485, 2499, 2498
12352, 2485, 2486, 2500, 2499
12353, 2486, 2487, 2501, 2500
12354, 2487, 2488, 2502, 2501
12355, 2488, 2489, 2503, 2502
12356, 2489, 2490, 2504, 2503
12357, 2490, 2491, 2505, 2504
12358, 2491, 2492, 2506, 2505
12359, 2492, 366, 367, 2506
12360, 339, 2493, 2507, 340
12361, 2493, 2494, 2508, 2507
12362, 2494, 2495, 2509, 2508
12363, 2495, 2496, 2510, 2509
12364, 2496, 2497, 2511, 2510
12365, 2497, 2498, 2512, 2511
12366, 2498, 2499, 2513, 2512
12367, 2499, 2500, 2514, 2513
12368, 2500, 2501, 2515, 2514
12369, 2501, 2502, 2516, 2515
12370, 2502, 2503, 2517, 2516
12371, 2503, 2504, 2518, 2517
12372, 2504, 2505, 2519, 2518
12373, 2505, 2506, 2520, 2519
12374, 2506, 367, 368, 2520
12375, 340, 2507, 2521, 341
12376, 2507, 2508, 2522, 2521
12377, 2508, 2509, 2523, 2522
12378, 2509, 2510, 2524, 2523
12379, 2510, 2511, 2525, 2524
12380, 2511, 2512, 2526, 2525
12381, 2512, 2513, 2527, 2526
12382, 2513, 2514, 2528, 2527
12383, 2514, 2515, 2529, 2528
12384, 2515, 2516, 2530, 2529
12385, 2516, 2517, 2531, 2530
12386, 2517, 2518, 2532, 2531
12387, 2518, 2519, 2533, 2532
12388, 2519, 2520, 2534, 2533
12389, 2520, 368, 369, 2534
12390, 341, 2521, 2535, 342
12391, 2521, 2522, 2536, 2535
12392, 2522, 2523, 2537, 2536
12393, 2523, 2524, 2538, 2537
12394, 2524, 2525, 2539, 2538
12395, 2525, 2526, 2540, 2539
12396, 2526, 2527, 2541, 2540
12397, 2527, 2528, 2542, 2541
12398, 2528, 2529, 2543, 2542
12399, 2529, 2530, 2544, 2543
12400, 2530, 2531, 2545, 2544
12401, 2531, 2532, 2546, 2545
12402, 2532, 2533, 2547, 2546
12403, 2533, 2534, 2548, 2547
12404, 2534, 369, 370, 2548
12405, 342, 2535, 2549, 343
12406, 2535, 2536, 2550, 2549
12407, 2536, 2537, 2551, 2550
12408, 2537, 2538, 2552, 2551
12409, 2538, 2539, 2553, 2552
12410, 2539, 2540, 2554, 2553
12411, 2540, 2541, 2555, 2554
12412, 2541, 2542, 2556, 2555
12413, 2542, 2543, 2557, 2556
12414, 2543, 2544, 2558, 2557
12415, 2544, 2545, 2559, 2558
12416, 2545, 2546, 2560, 2559
12417, 2546, 2547, 2561, 2560
12418, 2547, 2548, 2562, 2561
12419, 2548, 370, 371, 2562
12420, 343, 2549, 2563, 344
12421, 2549, 2550, 2564, 2563
12422, 2550, 2551, 2565, 2564
12423, 2551, 2552, 2566, 2565
12424, 2552, 2553, 2567, 2566
12425, 2553, 2554, 2568, 2567
12426, 2554, 2555, 2569, 2568
12427, 2555, 2556, 2570, 2569
12428, 2556, 2557, 2571, 2570
12429, 2557, 2558, 2572, 2571
12430, 2558, 2559, 2573, 2572
12431, 2559, 2560, 2574, 2573
12432, 2560, 2561, 2575, 2574
12433, 2561, 2562, 2576, 2575
12434, 2562, 371, 372, 2576
12435, 344, 2563, 2577, 345
12436, 2563, 2564, 2578, 2577
12437, 2564, 2565, 2579, 2578
12438, 2565, 2566, 2580, 2579
12439, 2566, 2567, 2581, 2580
12440, 2567, 2568, 2582, 2581
12441, 2568, 2569, 2583, 2582
12442, 2569, 2570, 2584, 2583
12443, 2570, 2571, 2585, 2584
12444, 2571, 2572, 2586, 2585
12445, 2572, 2573, 2587, 2586
12446, 2573, 2574, 2588, 2587
12447, 2574, 2575, 2589, 2588
12448, 2575, 2576, 2590, 2589
12449, 2576, 372, 373, 2590
12450, 345, 2577, 2591, 346
12451, 2577, 2578, 2592, 2591
12452, 2578, 2579, 2593, 2592
12453, 2579, 2580, 2594, 2593
12454, 2580, 2581, 2595, 2594
12455, 2581, 2582, 2596, 2595
12456, 2582, 2583, 2597, 2596
12457, 2583, 2584, 2598, 2597
12458, 2584, 2585, 2599, 2598
12459, 2585, 2586, 2600, 2599
12460, 2586, 2587, 2601, 2600
12461, 2587, 2588, 2602, 2601
12462, 2588, 2589, 2603, 2602
12463, 2589, 2590, 2604, 2603
12464, 2590, 373, 374, 2604
12465, 346, 2591, 2605, 347
12466, 2591, 2592, 2606, 2605
12467, 2592, 2593, 2607, 2606
12468, 2593, 2594, 2608, 2607
12469, 2594, 2595, 2609, 2608
12470, 2595, 2596, 2610, 2609
12471, 2596, 2597, 2611, 2610
12472, 2597, 2598, 2612, 2611
12473, 2598, 2599, 2613, 2612
12474, 2599, 2600, 2614, 2613
12475, 2600, 2601, 2615, 2614
12476, 2601, 2602, 2616, 2615
12477, 2602, 2603, 2617, 2616
12478, 2603, 2604, 2618, 2617
12479, 2604, 374, 375, 2618
12480, 347, 2605, 2619, 348
12481, 2605, 2606, 2620, 2619
12482, 2606, 2607, 2621, 2620
12483, 2607, 2608, 2622, 2621
12484, 2608, 2609, 2623, 2622
12485, 2609, 2610, 2624, 2623
12486, 2610, 2611, 2625, 2624
12487, 2611, 2612, 2626, 2625
12488, 2612, 2613, 2627, 2626
12489, 2613, 2614, 2628, 2627
12490, 2614, 2615, 2629, 2628
12491, 2615, 2616, 2630, 2629
12492, 2616, 2617, 2631, 2630
12493, 2617, 2618, 2632, 2631
12494, 2618, 375, 376, 2632
12495, 348, 2619, 2633, 349
12496, 2619, 2620, 2634, 2633
12497, 2620, 2621, 2635, 2634
12498, 2621, 2622, 2636, 2635
12499, 2622, 2623, 2637, 2636
12500, 2623, 2624, 2638, 2637
12501, 2624, 2625, 2639, 2638
12502, 2625, 2626, 2640, 2639
12503, 2626, 2627, 2641, 2640
12504, 2627, 2628, 2642, 2641
12505, 2628, 2629, 2643, 2642
12506, 2629, 2630, 2644, 2643
12507, 2630, 2631, 2645, 2644
12508, 2631, 2632, 2646, 2645
12509, 2632, 376, 377, 2646
12510, 349, 2633, 2647, 350
12511, 2633, 2634, 2648, 2647
12512, 2634, 2635, 2649, 2648
12513, 2635, 2636, 2650, 2649
12514, 2636, 2637, 2651, 2650
12515, 2637, 2638, 2652, 2651
12516, 2638, 2639, 2653, 2652
12517, 2639, 2640, 2654, 2653
12518, 2640, 2641, 2655, 2654
12519, 2641, 2642, 2656, 2655
12520, 2642, 2643, 2657, 2656
12521, 2643, 2644, 2658, 2657
12522, 2644, 2645, 2659, 2658
12523, 2645, 2646, 2660, 2659
12524, 2646, 377, 378, 2660
12525, 350, 2647, 351, 17
12526, 2647, 2648, 352, 351
12527, 2648, 2649, 353, 352
12528, 2649, 2650, 354, 353
12529, 2650, 2651, 355, 354
12530, 2651, 2652, 356, 355
12531, 2652, 2653, 357, 356
12532, 2653, 2654, 358, 357
12533, 2654, 2655, 359, 358
12534, 2655, 2656, 360, 359
12535, 2656, 2657, 361, 360
12536, 2657, 2658, 362, 361
12537, 2658, 2659, 363, 362
12538, 2659, 2660, 364, 363
12539, 2660, 378, 19, 364
*ELEMENT, type=CPS4, ELSET=Surface22
12540, 18, 22, 393, 337
12541, 337, 393, 394, 338
12542, 338, 394, 395, 339
12543, 339, 395, 396, 340
12544, 340, 396, 397, 341
12545, 341, 397, 398, 342
12546, 342, 398, 399, 343
12547, 343, 399, 400, 344
12548, 344, 400, 401, 345
12549, 345, 401, 402, 346
12550, 346, 402, 403, 347
12551, 347, 403, 404, 348
12552, 348, 404, 405, 349
12553, 349, 405, 406, 350
12554, 350, 406, 21, 17
*ELEMENT, type=CPS4, ELSET=Surface23
12555, 17, 21, 407, 351
12556, 351, 407, 408, 352
12557, 352, 408, 409, 353
12558, 353, 409, 410, 354
12559, 354, 410, 411, 355
12560, 355, 411, 412, 356
12561, 356, 412, 413, 357
12562, 357, 413, 414, 358
12563, 358, 414, 415, 359
12564, 359, 415, 416, 360
12565, 360, 416, 417, 361
12566, 361, 417, 418, 362
12567, 362, 418, 419, 363
12568, 363, 419, 420, 364
12569, 364, 420, 23, 19
*ELEMENT, type=CPS4, ELSET=Surface24
12570, 20, 365, 421, 24
12571, 365, 366, 422, 421
12572, 366, 367, 423, 422
12573, 367, 368, 424, 423
12574, 368, 369, 425, 424
12575, 369, 370, 426, 425
12576, 370, 371, 427, 426
12577, 371, 372, 428, 427
12578, 372, 373, 429, 428
12579, 373, 374, 430, 429
12580, 374, 375, 431, 430
12581, 375, 376, 432, 431
12582, 376, 377, 433, 432
12583, 377, 378, 434, 433
12584, 378, 19, 23, 434
*ELEMENT, type=CPS4, ELSET=Surface25
226, 18, 379, 435, 22
227, 379, 380, 436, 435
228, 380, 381, 437, 436
229, 381, 382, 438, 437
230, 382, 383, 439, 438
231, 383, 384, 440, 439
232, 384, 385, 441, 440
233, 385, 386, 442, 441
234, 386, 387, 443, 442
235, 387, 388, 444, 443
236, 388, 389, 445, 444
237, 389, 390, 446, 445
238, 390, 391, 447, 446
239, 391, 392, 448, 447
240, 392, 20, 24, 448
*ELEMENT, type=CPS4, ELSET=Surface26
241, 22, 435, 2661, 393
242, 435, 436, 2662, 2661
243, 436, 437, 2663, 2662
244, 437, 438, 2664, 2663
245, 438, 439, 2665, 2664
246, 439, 440, 2666, 2665
247, 440, 441, 2667, 2666
248, 441, 442, 2668, 2667
249, 442, 443, 2669, 2668
250, 443, 444, 2670, 2669
251, 444, 445, 2671, 2670
252, 445, 446, 2672, 2671
253, 446, 447, 2673, 2672
254, 447, 448, 2674, 2673
255, 448, 24, 421, 2674
256, 393, 2661, 2675, 394
257, 2661, 2662, 2676, 2675
258, 2662, 2663, 2677, 2676
259, 2663, 2664, 2678, 2677
260, 2664, 2665, 2679, 2678
261, 2665, 2666, 2680, 2679
262, 2666, 2667, 2681, 2680
263, 2667, 2668, 2682, 2681
264, 2668, 2669, 2683, 2682
265, 2669, 2670, 2684, 2683
266, 2670, 2671, 2685, 2684
267, 2671, 2672, 2686, 2685
268, 2672, 2673, 2687, 2686
269, 2673, 2674, 2688, 2687
270, 2674, 421, 422, 2688
271, 394, 2675, 2689, 395
272, 2675, 2676, 2690, 2689
273, 2676, 2677, 2691, 2690
274, 2677, 2678, 2692, 2691
275, 2678, 2679, 2693, 2692
276, 2679, 2680, 2694, 2693
277, 2680, 2681, 2695, 2694
278, 2681, 2682, 2696, 2695
279, 2682, 2683, 2697, 2696
280, 2683, 2684, 2698, 2697
281, 2684, 2685, 2699, 2698
282, 2685, 2686, 2700, 2699
283, 2686, 2687, 2701, 2700
284, 2687, 2688, 2702, 2701
285, 2688, 422, 423, 2702
286, 395, 2689, 2703, 396
287, 2689, 2690, 2704, 2703
288, 2690, 2691, 2705, 2704
289, 2691, 2692, 2706, 2705
290, 2692, 2693, 2707, 2706
291, 2693, 2694, 2708, 2707
292, 2694, 2695, 2709, 2708
293, 2695, 2696, 2710, 2709
294, 2696, 2697, 2711, 2710
295, 2697, 2698, 2712, 2711
296, 2698, 2699, 2713, 2712
297, 2699, 2700, 2714, 2713
298, 2700, 2701, 2715, 2714
299, 2701, 2702, 2716, 2715
300, 2702, 423, 424, 2716
301, 396, 2703, 2717, 397
302, 2703, 2704, 2718, 2717
303, 2704, 2705, 2719, 2718
304, 2705, 2706, 2720, 2719
305, 2706, 2707, 2721, 2720
306, 2707, 2708, 2722, 2721
307, 2708, 2709, 2723, 2722
308, 2709, 2710, 2724, 2723
309, 2710, 2711, 2725, 2724
310, 2711, 2712, 2726, 2725
311, 2712, 2713, 2727, 2726
312, 2713, 2714, 2728, 2727
313, 2714, 2715, 2729, 2728
314, 2715, 2716, 2730, 2729
315, 2716, 424, 425, 2730
316, 397, 2717, 2731, 398
317, 2717, 2718, 2732, 2731
318, 2718, 2719, 2733, 2732
319, 2719, 2720, 2734, 2733
320, 2720, 2721, 2735, 2734
321, 2721, 2722, 2736, 2735
322, 2722, 2723, 2737, 2736
323, 2723, 2724, 2738, 2737
324, 2724, 2725, 2739, 2738
325, 2725, 2726, 2740, 2739
326, 2726, 2727, 2741, 2740
327, 2727, 2728, 2742, 2741
328, 2728, 2729, 2743, 2742
329, 2729, 2730, 2744, 2743
330, 2730, 425, 426, 2744
331, 398, 2731, 2745, 399
332, 2731, 2732, 2746, 2745
333, 2732, 2733, 2747, 2746
334, 2733, 2734, 2748, 2747
335, 2734, 2735, 2749, 2748
336, 2735, 2736, 2750, 2749
337, 2736, 2737, 2751, 2750
338, 2737, 2738, 2752, 2751
339, 2738, 2739, 2753, 2752
340, 2739, 2740, 2754, 2753
341, 2740, 2741, 2755, 2754
342, 2741, 2742, 2756, 2755
343, 2742, 2743, 2757, 2756
344, 2743, 2744, 2758, 2757
345, 2744, 426, 427, 2758
346, 399, 2745, 2759, 400
347, 2745, 2746, 2760, 2759
348, 2746, 2747, 2761, 2760
349, 2747, 2748, 2762, 2761
350, 2748, 2749, 2763, 2762
351, 2749, 2750, 2764, 2763
352, 2750, 2751, 2765, 2764
353, 2751, 2752, 2766, 2765
354, 2752, 2753, 2767, 2766
355, 2753, 2754, 2768, 2767
356, 2754, 2755, 2769, 2768
357, 2755, 2756, 2770, 2769
358, 2756, 2757, 2771, 2770
359, 2757, 2758, 2772, 2771
360, 2758, 427, 428, 2772
361, 400, 2759, 2773, 401
362, 2759, 2760, 2774, 2773
363, 2760, 2761, 2775, 2774
364, 2761, 2762, 2776, 2775
365, 2762, 2763, 2777, 2776
366, 2763, 2764, 2778, 2777
367, 2764, 2765, 2779, 2778
368, 2765, 2766, 2780, 2779
369, 2766, 2767, 2781, 2780
370, 2767, 2768, 2782, 2781
371, 2768, 2769, 2783, 2782
372, 2769, 2770, 2784, 2783
373, 2770, 2771, 2785, 2784
374, 2771, 2772, 2786, 2785
375, 2772, 428, 429, 2786
376, 401, 2773, 2787, 402
377, 2773, 2774, 2788, 2787
378, 2774, 2775, 2789, 2788
379, 2775, 2776, 2790, 2789
380, 2776, 2777, 2791, 2790
381, 2777, 2778, 2792, 2791
382, 2778, 2779, 2793, 2792
383, 2779, 2780, 2794, 2793
384, 2780, 2781, 2795, 2794
385, 2781, 2782, 2796, 2795
386, 2782, 2783, 2797, 2796
387, 2783, 2784, 2798, 2797
388, 2784, 2785, 2799, 2798
389, 2785, 2786, 2800, 2799
390, 2786, 429, 430, 2800
391, 402, 2787, 2801, 403
392, 2787, 2788, 2802, 2801
393, 2788, 2789, 2803, 2802
394, 2789, 2790, 2804, 2803
395, 2790, 2791, 2805, 2804
396, 2791, 2792, 2806, 2805
397, 2792, 2793, 2807, 2806
398, 2793, 2794, 2808, 2807
399, 2794, 2795, 2809, 2808
400, 2795, 2796, 2810, 2809
401, 2796, 2797, 2811, 2810
402, 2797, 2798, 2812, 2811
403, 2798, 2799, 2813, 2812
404, 2799, 2800, 2814, 2813
405, 2800, 430, 431, 2814
406, 403, 2801, 2815, 404
407, 2801, 2802, 2816, 2815
408, 2802, 2803, 2817, 2816
409, 2803, 2804, 2818, 2817
410, 2804, 2805, 2819, 2818
411, 2805, 2806, 2820, 2819
412, 2806, 2807, 2821, 2820
413, 2807, 2808, 2822, 2821
414, 2808, 2809, 2823, 2822
415, 2809, 2810, 2824, 2823
416, 2810, 2811, 2825, 2824
417, 2811, 2812, 2826, 2825
418, 2812, 2813, 2827, 2826
419, 2813, 2814, 2828, 2827
420, 2814, 431, 432, 2828
421, 404, 2815, 2829, 405
422, 2815, 2816, 2830, 2829
423, 2816, 2817, 2831, 2830
424, 2817, 2818, 2832, 2831
425, 2818, 2819, 2833, 2832
426, 2819, 2820, 2834, 2833
427, 2820, 2821, 2835, 2834
428, 2821, 2822, 2836, 2835
429, 2822, 2823, 2837, 2836
430, 2823, 2824, 2838, 2837
431, 2824, 2825, 2839, 2838
432, 2825, 2826, 2840, 2839
433, 2826, 2827, 2841, 2840
434, 2827, 2828, 2842, 2841
435, 2828, 432, 433, 2842
436, 405, 2829, 2843, 406
437, 2829, 2830, 2844, 2843
438, 2830, 2831, 2845, 2844
439, 2831, 2832, 2846, 2845
440, 2832, 2833, 2847, 2846
441, 2833, 2834, 2848, 2847
442, 2834, 2835, 2849, 2848
443, 2835, 2836, 2850, 2849
444, 2836, 2837, 2851, 2850
445, 2837, 2838, 2852, 2851
446, 2838, 2839, 2853, 2852
447, 2839, 2840, 2854, 2853
448, 2840, 2841, 2855, 2854
449, 2841, 2842, 2856, 2855
450, 2842, 433, 434, 2856
451, 406, 2843, 407, 21
452, 2843, 2844, 408, 407
453, 2844, 2845, 409, 408
454, 2845, 2846, 410, 409
455, 2846, 2847, 411, 410
456, 2847, 2848, 412, 411
457, 2848, 2849, 413, 412
458, 2849, 2850, 414, 413
459, 2850, 2851, 415, 414
460, 2851, 2852, 416, 415
461, 2852, 2853, 417, 416
462, 2853, 2854, 418, 417
463, 2854, 2855, 419, 418
464, 2855, 2856, 420, 419
465, 2856, 434, 23, 420
*ELEMENT, type=CPS4, ELSET=Surface27
12585, 19, 25, 26, 23
*ELEMENT, type=CPS4, ELSET=Surface28
12586, 17, 21, 28, 27
*ELEMENT, type=CPS4, ELSET=Surface29
12587, 17, 27, 449, 351
12588, 351, 449, 450, 352
12589, 352, 450, 451, 353
12590, 353, 451, 452, 354
12591, 354, 452, 453, 355
12592, 355, 453, 454, 356
12593, 356, 454, 455, 357
12594, 357, 455, 456, 358
12595, 358, 456, 457, 359
12596, 359, 457, 458, 360
12597, 360, 458, 459, 361
12598, 361, 459, 460, 362
12599, 362, 460, 461, 363
12600, 363, 461, 462, 364
12601, 364, 462, 25, 19
*ELEMENT, type=CPS4, ELSET=Surface30
466, 21, 407, 463, 28
467, 407, 408, 464, 463
468, 408, 409, 465, 464
469, 409, 410, 466, 465
470, 410, 411, 467, 466
471, 411, 412, 468, 467
472, 412, 413, 469, 468
473, 413, 414, 470, 469
474, 414, 415, 471, 470
475, 415, 416, 472, 471
476, 416, 417, 473, 472
477, 417, 418, 474, 473
478, 418, 419, 475, 474
479, 419, 420, 476, 475
480, 420, 23, 26, 476
*ELEMENT, type=CPS4, ELSET=Surface31
12602, 27, 28, 463, 449
12603, 449, 463, 464, 450
12604, 450, 464, 465, 451
12605, 451, 465, 466, 452
12606, 452, 466, 467, 453
12607, 453, 467, 468, 454
12608, 454, 468, 469, 455
12609, 455, 469, 470, 456
12610, 456, 470, 471, 457
12611, 457, 471, 472, 458
12612, 458, 472, 473, 459
12613, 459, 473, 474, 460
12614, 460, 474, 475, 461
12615, 461, 475, 476, 462
12616, 462, 476, 26, 25
*ELEMENT, type=CPS4, ELSET=Surface32
12617, 25, 477, 491, 26
12618, 477, 478, 492, 491
12619, 478, 479, 493, 492
12620, 479, 480, 494, 493
12621, 480, 481, 495, 494
12622, 481, 482, 496, 495
12623, 482, 483, 497, 496
12624, 483, 484, 498, 497
12625, 484, 485, 499, 498
12626, 485, 486, 500, 499
12627, 486, 487, 501, 500
12628, 487, 488, 502, 501
12629, 488, 489, 503, 502
12630, 489, 490, 504, 503
12631, 490, 29, 30, 504
*ELEMENT, type=CPS4, ELSET=Surface33
12632, 27, 28, 519, 505
12633, 505, 519, 520, 506
12634, 506, 520, 521, 507
12635, 507, 521, 522, 508
12636, 508, 522, 523, 509
12637, 509, 523, 524, 510
12638, 510, 524, 525, 511
12639, 511, 525, 526, 512
12640, 512, 526, 527, 513
12641, 513, 527, 528, 514
12642, 514, 528, 529, 515
12643, 515, 529, 530, 516
12644, 516, 530, 531, 517
12645, 517, 531, 532, 518
12646, 518, 532, 32, 31
*ELEMENT, type=CPS4, ELSET=Surface34
12647, 27, 505, 2857, 449
12648, 505, 506, 2858, 2857
12649, 506, 507, 2859, 2858
12650, 507, 508, 2860, 2859
12651, 508, 509, 2861, 2860
12652, 509, 510, 2862, 2861
12653, 510, 511, 2863, 2862
12654, 511, 512, 2864, 2863
12655, 512, 513, 2865, 2864
12656, 513, 514, 2866, 2865
12657, 514, 515, 2867, 2866
12658, 515, 516, 2868, 2867
12659, 516, 517, 2869, 2868
12660, 517, 518, 2870, 2869
12661, 518, 31, 533, 2870
12662, 449, 2857, 2871, 450
12663, 2857, 2858, 2872, 2871
12664, 2858, 2859, 2873, 2872
12665, 2859, 2860, 2874, 2873
12666, 2860, 2861, 2875, 2874
12667, 2861, 2862, 2876, 2875
12668, 2862, 2863, 2877, 2876
12669, 2863, 2864, 2878, 2877
12670, 2864, 2865, 2879, 2878
12671, 2865, 2866, 2880, 2879
12672, 2866, 2867, 2881, 2880
12673, 2867, 2868, 2882, 2881
12674, 2868, 2869, 2883, 2882
12675, 2869, 2870, 2884, 2883
12676, 2870, 533, 534, 2884
12677, 450, 2871, 2885, 451
12678, 2871, 2872, 2886, 2885
12679, 2872, 2873, 2887, 2886
12680, 2873, 2874, 2888, 2887
12681, 2874, 2875, 2889, 2888
12682, 2875, 2876, 2890, 2889
12683, 2876, 2877, 2891, 2890
12684, 2877, 2878, 2892, 2891
12685, 2878, 2879, 2893, 2892
12686, 2879, 2880, 2894, 2893
12687, 2880, 2881, 2895, 2894
12688, 2881, 2882, 2896, 2895
12689, 2882, 2883, 2897, 2896
12690, 2883, 2884, 2898, 2897
12691, 2884, 534, 535, 2898
12692, 451, 2885, 2899, 452
12693, 2885, 2886, 2900, 2899
12694, 2886, 2887, 2901, 2900
12695, 2887, 2888, 2902, 2901
12696, 2888, 2889, 2903, 2902
12697, 2889, 2890, 2904, 2903
12698, 2890, 2891, 2905, 2904
12699, 2891, 2892, 2906, 2905
12700, 2892, 2893, 2907, 2906
12701, 2893, 2894, 2908, 2907
12702, 2894, 2895, 2909, 2908
12703, 2895, 2896, 2910, 2909
12704, 2896, 2897, 2911, 2910
12705, 2897, 2898, 2912, 2911
12706, 2898, 535, 536, 2912
12707, 452, 2899, 2913, 453
12708, 2899, 2900, 2914, 2913
12709, 2900, 2901, 2915, 2914
12710, 2901, 2902, 2916, 2915
12711, 2902, 2903, 2917, 2916
12712, 2903, 2904, 2918, 2917
12713, 2904, 2905, 2919, 2918
12714, 2905, 2906, 2920, 2919
12715, 2906, 2907, 2921, 2920
12716, 2907, 2908, 2922, 2921
12717, 2908, 2909, 2923, 2922
12718, 2909, 2910, 2924, 2923
12719, 2910, 2911, 2925, 2924
12720, 2911, 2912, 2926, 2925
12721, 2912, 536, 537, 2926
12722, 453, 2913, 2927, 454
12723, 2913, 2914, 2928, 2927
12724, 2914, 2915, 2929, 2928
12725, 2915, 2916, 2930, 2929
12726, 2916, 2917, 2931, 2930
12727, 2917, 2918, 2932, 2931
12728, 2918, 2919, 2933, 2932
12729, 2919, 2920, 2934, 2933
12730, 2920, 2921, 2935, 2934
12731, 2921, 2922, 2936, 2935
12732, 2922, 2923, 2937, 2936
12733, 2923, 2924, 2938, 2937
12734, 2924, 2925, 2939, 2938
12735, 2925, 2926, 2940, 2939
12736, 2926, 537, 538, 2940
12737, 454, 2927, 2941, 455
12738, 2927, 2928, 2942, 2941
12739, 2928, 2929, 2943, 2942
12740, 2929, 2930, 2944, 2943
12741, 2930, 2931, 2945, 2944
12742, 2931, 2932, 2946, 2945
12743, 2932, 2933, 2947, 2946
12744, 2933, 2934, 2948, 2947
12745, 2934, 2935, 2949, 2948
12746, 2935, 2936, 2950, 2949
12747, 2936, 2937, 2951, 2950
12748, 2937, 2938, 2952, 2951
12749, 2938, 2939, 2953, 2952
12750, 2939, 2940, 2954, 2953
12751, 2940, 538, 539, 2954
12752, 455, 2941, 2955, 456
12753, 2941, 2942, 2956, 2955
12754, 2942, 2943, 2957, 2956
12755, 2943, 2944, 2958, 2957
12756, 2944, 2945, 2959, 2958
12757, 2945, 2946, 2960, 2959
12758, 2946, 2947, 2961, 2960
12759, 2947, 2948, 2962, 2961
12760, 2948, 2949, 2963, 2962
12761, 2949, 2950, 2964, 2963
12762, 2950, 2951, 2965, 2964
12763, 2951, 2952, 2966, 2965
12764, 2952, 2953, 2967, 2966
12765, 2953, 2954, 2968, 2967
12766, 2954, 539, 540, 2968
12767, 456, 2955, 2969, 457
12768, 2955, 2956, 2970, 2969
12769, 2956, 2957, 2971, 2970
12770, 2957, 2958, 2972, 2971
12771, 2958, 2959, 2973, 2972
12772, 2959, 2960, 2974, 2973
12773, 2960, 2961, 2975, 2974
12774, 2961, 2962, 2976, 2975
12775, 2962, 2963, 2977, 2976
12776, 2963, 2964, 2978, 2977
12777, 2964, 2965, 2979, 2978
12778, 2965, 2966, 2980, 2979
12779, 2966, 2967, 2981, 2980
12780, 2967, 2968, 2982, 2981
12781, 2968, 540, 541, 2982
12782, 457, 2969, 2983, 458
12783, 2969, 2970, 2984, 2983
12784, 2970, 2971, 2985, 2984
12785, 2971, 2972, 2986, 2985
12786, 2972, 2973, 2987, 2986
12787, 2973, 2974, 2988, 2987
12788, 2974, 2975, 2989, 2988
12789, 2975, 2976, 2990, 2989
12790, 2976, 2977, 2991, 2990
12791, 2977, 2978, 2992, 2991
12792, 2978, 2979, 2993, 2992
12793, 2979, 2980, 2994, 2993
12794, 2980, 2981, 2995, 2994
12795, 2981, 2982, 2996, 2995
12796, 2982, 541, 542, 2996
12797, 458, 2983, 2997, 459
12798, 2983, 2984, 2998, 2997
12799, 2984, 2985, 2999, 2998
12800, 2985, 2986, 3000, 2999
12801, 2986, 2987, 3001, 3000
12802, 2987, 2988, 3002, 3001
12803, 2988, 2989, 3003, 3002
12804, 2989, 2990, 3004, 3003
12805, 2990, 2991, 3005, 3004
12806, 2991, 2992, 3006, 3005
12807, 2992, 2993, 3007, 3006
12808, 2993, 2994, 3008, 3007
12809, 2994, 2995, 3009, 3008
12810, 2995, 2996, 3010, 3009
12811, 2996, 542, 543, 3010
12812, 459, 2997, 3011, 460
12813, 2997, 2998, 3012, 3011
12814, 2998, 2999, 3013, 3012
12815, 2999, 3000, 3014, 3013
12816, 3000, 3001, 3015, 3014
12817, 3001, 3002, 3016, 3015
12818, 3002, 3003, 3017, 3016
12819, 3003, 3004, 3018, 3017
12820, 3004, 3005, 3019, 3018
12821, 3005, 3006, 3020, 3019
12822, 3006, 3007, 3021, 3020
12823, 3007, 3008, 3022, 3021
12824, 3008, 3009, 3023, 3022
12825, 3009, 3010, 3024, 3023
12826, 3010, 543, 544, 3024
12827, 460, 3011, 3025, 461
12828, 3011, 3012, 3026, 3025
12829, 3012, 3013, 3027, 3026
12830, 3013, 3014, 3028, 3027
12831, 3014, 3015, 3029, 3028
12832, 3015, 3016, 3030, 3029
12833, 3016, 3017, 3031, 3030
12834, 3017, 3018, 3032, 3031
12835, 3018, 3019, 3033, 3032
12836, 3019, 3020, 3034, 3033
12837, 3020, 3021, 3035, 3034
12838, 3021, 3022, 3036, 3035
12839, 3022, 3023, 3037, 3036
12840, 3023, 3024, 3038, 3037
12841, 3024, 544, 545, 3038
12842, 461, 3025, 3039, 462
12843, 3025, 3026, 3040, 3039
12844, 3026, 3027, 3041, 3040
12845, 3027, 3028, 3042, 3041
12846, 3028, 3029, 3043, 3042
12847, 3029, 3030, 3044, 3043
12848, 3030, 3031, 3045, 3044
12849, 3031, 3032, 3046, 3045
12850, 3032, 3033, 3047, 3046
12851, 3033, 3034, 3048, 3047
12852, 3034, 3035, 3049, 3048
12853, 3035, 3036, 3050, 3049
12854, 3036, 3037, 3051, 3050
12855, 3037, 3038, 3052, 3051
12856, 3038, 545, 546, 3052
12857, 462, 3039, 477, 25
12858, 3039, 3040, 478, 477
12859, 3040, 3041, 479, 478
12860, 3041, 3042, 480, 479
12861, 3042, 3043, 481, 480
12862, 3043, 3044, 482, 481
12863, 3044, 3045, 483, 482
12864, 3045, 3046, 484, 483
12865, 3046, 3047, 485, 484
12866, 3047, 3048, 486, 485
12867, 3048, 3049, 487, 486
12868, 3049, 3050, 488, 487
12869, 3050, 3051, 489, 488
12870, 3051, 3052, 490, 489
12871, 3052, 546, 29, 490
*ELEMENT, type=CPS4, ELSET=Surface35
481, 28, 463, 3053, 519
482, 519, 3053, 3054, 520
483, 520, 3054, 3055, 521
484, 521, 3055, 3056, 522
485, 522, 3056, 3057, 523
486, 523, 3057, 3058, 524
487, 524, 3058, 3059, 525
488, 525, 3059, 3060, 526
489, 526, 3060, 3061, 527
490, 527, 3061, 3062, 528
491, 528, 3062, 3063, 529
492, 529, 3063, 3064, 530
493, 530, 3064, 3065, 531
494, 531, 3065, 3066, 532
495, 532, 3066, 547, 32
496, 463, 464, 3067, 3053
497, 3053, 3067, 3068, 3054
498, 3054, 3068, 3069, 3055
499, 3055, 3069, 3070, 3056
500, 3056, 3070, 3071, 3057
501, 3057, 3071, 3072, 3058
502, 3058, 3072, 3073, 3059
503, 3059, 3073, 3074, 3060
504, 3060, 3074, 3075, 3061
505, 3061, 3075, 3076, 3062
506, 3062, 3076, 3077, 3063
507, 3063, 3077, 3078, 3064
508, 3064, 3078, 3079, 3065
509, 3065, 3079, 3080, 3066
510, 3066, 3080, 548, 547
511, 464, 465, 3081, 3067
512, 3067, 3081, 3082, 3068
513, 3068, 3082, 3083, 3069
514, 3069, 3083, 3084, 3070
515, 3070, 3084, 3085, 3071
516, 3071, 3085, 3086, 3072
517, 3072, 3086, 3087, 3073
518, 3073, 3087, 3088, 3074
519, 3074, 3088, 3089, 3075
520, 3075, 3089, 3090, 3076
521, 3076, 3090, 3091, 3077
522, 3077, 3091, 3092, 3078
523, 3078, 3092, 3093, 3079
524, 3079, 3093, 3094, 3080
525, 3080, 3094, 549, 548
526, 465, 466, 3095, 3081
527, 3081, 3095, 3096, 3082
528, 3082, 3096, 3097, 3083
529, 3083, 3097, 3098, 3084
530, 3084, 3098, 3099, 3085
531, 3085, 3099, 3100, 3086
532, 3086, 3100, 3101, 3087
533, 3087, 3101, 3102, 3088
534, 3088, 3102, 3103, 3089
535, 3089, 3103, 3104, 3090
536, 3090, 3104, 3105, 3091
537, 3091, 3105, 3106, 3092
538, 3092, 3106, 3107, 3093
539, 3093, 3107, 3108, 3094
540, 3094, 3108, 550, 549
541, 466, 467, 3109, 3095
542, 3095, 3109, 3110, 3096
543, 3096, 3110, 3111, 3097
544, 3097, 3111, 3112, 3098
545, 3098, 3112, 3113, 3099
546, 3099, 3113, 3114, 3100
547, 3100, 3114, 3115, 3101
548, 3101, 3115, 3116, 3102
549, 3102, 3116, 3117, 3103
550, 3103, 3117, 3118, 3104
551, 3104, 3118, 3119, 3105
552, 3105, 3119, 3120, 3106
553, 3106, 3120, 3121, 3107
554, 3107, 3121, 3122, 3108
555, 3108, 3122, 551, 550
556, 467, 468, 3123, 3109
557, 3109, 3123, 3124, 3110
558, 3110, 3124, 3125, 3111
559, 3111, 3125, 3126, 3112
560, 3112, 3126, 3127, 3113
561, 3113, 3127, 3128, 3114
562, 3114, 3128, 3129, 3115
563, 3115, 3129, 3130, 3116
564, 3116, 3130, 3131, 3117
565, 3117, 3131, 3132, 3118
566, 3118, 3132, 3133, 3119
567, 3119, 3133, 3134, 3120
568, 3120, 3134, 3135, 3121
569, 3121, 3135, 3136, 3122
570, 3122, 3136, 552, 551
571, 468, 469, 3137, 3123
572, 3123, 3137, 3138, 3124
573, 3124, 3138, 3139, 3125
574, 3125, 3139, 3140, 3126
575, 3126, 3140, 3141, 3127
576, 3127, 3141, 3142, 3128
577, 3128, 3142, 3143, 3129
578, 3129, 3143, 3144, 3130
579, 3130, 3144, 3145, 3131
580, 3131, 3145, 3146, 3132
581, 3132, 3146, 3147, 3133
582, 3133, 3147, 3148, 3134
583, 3134, 3148, 3149, 3135
584, 3135, 3149, 3150, 3136
585, 3136, 3150, 553, 552
586, 469, 470, 3151, 3137
587, 3137, 3151, 3152, 3138
588, 3138, 3152, 3153, 3139
589, 3139, 3153, 3154, 3140
590, 3140, 3154, 3155, 3141
591, 3141, 3155, 3156, 3142
592, 3142, 3156, 3157, 3143
593, 3143, 3157, 3158, 3144
594, 3144, 3158, 3159, 3145
595, 3145, 3159, 3160, 3146
596, 3146, 3160, 3161, 3147
597, 3147, 3161, 3162, 3148
598, 3148, 3162, 3163, 3149
599, 3149, 3163, 3164, 3150
600, 3150, 3164, 554, 553
601, 470, 471, 3165, 3151
602, 3151, 3165, 3166, 3152
603, 3152, 3166, 3167, 3153
604, 3153, 3167, 3168, 3154
605, 3154, 3168, 3169, 3155
606, 3155, 3169, 3170, 3156
607, 3156, 3170, 3171, 3157
608, 3157, 3171, 3172, 3158
609, 3158, 3172, 3173, 3159
610, 3159, 3173, 3174, 3160
611, 3160, 3174, 3175, 3161
612, 3161, 3175, 3176, 3162
613, 3162, 3176, 3177, 3163
614, 3163, 3177, 3178, 3164
615, 3164, 3178, 555, 554
616, 471, 472, 3179, 3165
617, 3165, 3179, 3180, 3166
618, 3166, 3180, 3181, 3167
619, 3167, 3181, 3182, 3168
620, 3168, 3182, 3183, 3169
621, 3169, 3183, 3184, 3170
622, 3170, 3184, 3185, 3171
623, 3171, 3185, 3186, 3172
624, 3172, 3186, 3187, 3173
625, 3173, 3187, 3188, 3174
626, 3174, 3188, 3189, 3175
627, 3175, 3189, 3190, 3176
628, 3176, 3190, 3191, 3177
629, 3177, 3191, 3192, 3178
630, 3178, 3192, 556, 555
631, 472, 473, 3193, 3179
632, 3179, 3193, 3194, 3180
633, 3180, 3194, 3195, 3181
634, 3181, 3195, 3196, 3182
635, 3182, 3196, 3197, 3183
636, 3183, 3197, 3198, 3184
637, 3184, 3198, 3199, 3185
638, 3185, 3199, 3200, 3186
639, 3186, 3200, 3201, 3187
640, 3187, 3201, 3202, 3188
641, 3188, 3202, 3203, 3189
642, 3189, 3203, 3204, 3190
643, 3190, 3204, 3205, 3191
644, 3191, 3205, 3206, 3192
645, 3192, 3206, 557, 556
646, 473, 474, 3207, 3193
647, 3193, 3207, 3208, 3194
648, 3194, 3208, 3209, 3195
649, 3195, 3209, 3210, 3196
650, 3196, 3210, 3211, 3197
651, 3197, 3211, 3212, 3198
652, 3198, 3212, 3213, 3199
653, 3199, 3213, 3214, 3200
654, 3200, 3214, 3215, 3201
655, 3201, 3215, 3216, 3202
656, 3202, 3216, 3217, 3203
657, 3203, 3217, 3218, 3204
658, 3204, 3218, 3219, 3205
659, 3205, 3219, 3220, 3206
660, 3206, 3220, 558, 557
661, 474, 475, 3221, 3207
662, 3207, 3221, 3222, 3208
663, 3208, 3222, 3223, 3209
664, 3209, 3223, 3224, 3210
665, 3210, 3224, 3225, 3211
666, 3211, 3225, 3226, 3212
667, 3212, 3226, 3227, 3213
668, 3213, 3227, 3228, 3214
669, 3214, 3228, 3229, 3215
670, 3215, 3229, 3230, 3216
671, 3216, 3230, 3231, 3217
672, 3217, 3231, 3232, 3218
673, 3218, 3232, 3233, 3219
674, 3219, 3233, 3234, 3220
675, 3220, 3234, 559, 558
676, 475, 476, 3235, 3221
677, 3221, 3235, 3236, 3222
678, 3222, 3236, 3237, 3223
679, 3223, 3237, 3238, 3224
680, 3224, 3238, 3239, 3225
681, 3225, 3239, 3240, 3226
682, 3226, 3240, 3241, 3227
683, 3227, 3241, 3242, 3228
684, 3228, 3242, 3243, 3229
685, 3229, 3243, 3244, 3230
686, 3230, 3244, 3245, 3231
687, 3231, 3245, 3246, 3232
688, 3232, 3246, 3247, 3233
689, 3233, 3247, 3248, 3234
690, 3234, 3248, 560, 559
691, 476, 26, 491, 3235
692, 3235, 491, 492, 3236
693, 3236, 492, 493, 3237
694, 3237, 493, 494, 3238
695, 3238, 494, 495, 3239
696, 3239, 495, 496, 3240
697, 3240, 496, 497, 3241
698, 3241, 497, 498, 3242
699, 3242, 498, 499, 3243
700, 3243, 499, 500, 3244
701, 3244, 500, 501, 3245
702, 3245, 501, 502, 3246
703, 3246, 502, 503, 3247
704, 3247, 503, 504, 3248
705, 3248, 504, 30, 560
*ELEMENT, type=CPS4, ELSET=Surface36
12872, 31, 32, 547, 533
12873, 533, 547, 548, 534
12874, 534, 548, 549, 535
12875, 535, 549, 550, 536
12876, 536, 550, 551, 537
12877, 537, 551, 552, 538
12878, 538, 552, 553, 539
12879, 539, 553, 554, 540
12880, 540, 554, 555, 541
12881, 541, 555, 556, 542
12882, 542, 556, 557, 543
12883, 543, 557, 558, 544
12884, 544, 558, 559, 545
12885, 545, 559, 560, 546
12886, 546, 560, 30, 29
*ELEMENT, type=CPS4, ELSET=Surface37
12887, 25, 33, 561, 477
12888, 477, 561, 562, 478
12889, 478, 562, 563, 479
12890, 479, 563, 564, 480
12891, 480, 564, 565, 481
12892, 481, 565, 566, 482
12893, 482, 566, 567, 483
12894, 483, 567, 568, 484
12895, 484, 568, 569, 485
12896, 485, 569, 570, 486
12897, 486, 570, 571, 487
12898, 487, 571, 572, 488
12899, 488, 572, 573, 489
12900, 489, 573, 574, 490
12901, 490, 574, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
12902, 27, 505, 575, 35
12903, 505, 506, 576, 575
12904, 506, 507, 577, 576
12905, 507, 508, 578, 577
12906, 508, 509, 579, 578
12907, 509, 510, 580, 579
12908, 510, 511, 581, 580
12909, 511, 512, 582, 581
12910, 512, 513, 583, 582
12911, 513, 514, 584, 583
12912, 514, 515, 585, 584
12913, 515, 516, 586, 585
12914, 516, 517, 587, 586
12915, 517, 518, 588, 587
12916, 518, 31, 36, 588
*ELEMENT, type=CPS4, ELSET=Surface39
12917, 27, 35, 589, 449
12918, 449, 589, 590, 450
12919, 450, 590, 591, 451
12920, 451, 591, 592, 452
12921, 452, 592, 593, 453
12922, 453, 593, 594, 454
12923, 454, 594, 595, 455
12924, 455, 595, 596, 456
12925, 456, 596, 597, 457
12926, 457, 597, 598, 458
12927, 458, 598, 599, 459
12928, 459, 599, 600, 460
12929, 460, 600, 601, 461
12930, 461, 601, 602, 462
12931, 462, 602, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
12932, 31, 533, 603, 36
12933, 533, 534, 604, 603
12934, 534, 535, 605, 604
12935, 535, 536, 606, 605
12936, 536, 537, 607, 606
12937, 537, 538, 608, 607
12938, 538, 539, 609, 608
12939, 539, 540, 610, 609
12940, 540, 541, 611, 610
12941, 541, 542, 612, 611
12942, 542, 543, 613, 612
12943, 543, 544, 614, 613
12944, 544, 545, 615, 614
12945, 545, 546, 616, 615
12946, 546, 29, 34, 616
*ELEMENT, type=CPS4, ELSET=Surface41
12947, 35, 575, 3249, 589
12948, 575, 576, 3250, 3249
12949, 576, 577, 3251, 3250
12950, 577, 578, 3252, 3251
12951, 578, 579, 3253, 3252
12952, 579, 580, 3254, 3253
12953, 580, 581, 3255, 3254
12954, 581, 582, 3256, 3255
12955, 582, 583, 3257, 3256
12956, 583, 584, 3258, 3257
12957, 584, 585, 3259, 3258
12958, 585, 586, 3260, 3259
12959, 586, 587, 3261, 3260
12960, 587, 588, 3262, 3261
12961, 588, 36, 603, 3262
12962, 589, 3249, 3263, 590
12963, 3249, 3250, 3264, 3263
12964, 3250, 3251, 3265, 3264
12965, 3251, 3252, 3266, 3265
12966, 3252, 3253, 3267, 3266
12967, 3253, 3254, 3268, 3267
12968, 3254, 3255, 3269, 3268
12969, 3255, 3256, 3270, 3269
12970, 3256, 3257, 3271, 3270
12971, 3257, 3258, 3272, 3271
12972, 3258, 3259, 3273, 3272
12973, 3259, 3260, 3274, 3273
12974, 3260, 3261, 3275, 3274
12975, 3261, 3262, 3276, 3275
12976, 3262, 603, 604, 3276
12977, 590, 3263, 3277, 591
12978, 3263, 3264, 3278, 3277
12979, 3264, 3265, 3279, 3278
12980, 3265, 3266, 3280, 3279
12981, 3266, 3267, 3281, 3280
12982, 3267, 3268, 3282, 3281
12983, 3268, 3269, 3283, 3282
12984, 3269, 3270, 3284, 3283
12985, 3270, 3271, 3285, 3284
12986, 3271, 3272, 3286, 3285
12987, 3272, 3273, 3287, 3286
12988, 3273, 3274, 3288, 3287
12989, 3274, 3275, 3289, 3288
12990, 3275, 3276, 3290, 3289
12991, 3276, 604, 605, 3290
12992, 591, 3277, 3291, 592
12993, 3277, 3278, 3292, 3291
12994, 3278, 3279, 3293, 3292
12995, 3279, 3280, 3294, 3293
12996, 3280, 3281, 3295, 3294
12997, 3281, 3282, 3296, 3295
12998, 3282, 3283, 3297, 3296
12999, 3283, 3284, 3298, 3297
13000, 3284, 3285, 3299, 3298
13001, 3285, 3286, 3300, 3299
13002, 3286, 3287, 3301, 3300
13003, 3287, 3288, 3302, 3301
13004, 3288, 3289, 3303, 3302
13005, 3289, 3290, 3304, 3303
13006, 3290, 605, 606, 3304
13007, 592, 3291, 3305, 593
13008, 3291, 3292, 3306, 3305
13009, 3292, 3293, 3307, 3306
13010, 3293, 3294, 3308, 3307
13011, 3294, 3295, 3309, 3308
13012, 3295, 3296, 3310, 3309
13013, 3296, 3297, 3311, 3310
13014, 3297, 3298, 3312, 3311
13015, 3298, 3299, 3313, 3312
13016, 3299, 3300, 3314, 3313
13017, 3300, 3301, 3315, 3314
13018, 3301, 3302, 3316, 3315
13019, 3302, 3303, 3317, 3316
13020, 3303, 3304, 3318, 3317
13021, 3304, 606, 607, 3318
13022, 593, 3305, 3319, 594
13023, 3305, 3306, 3320, 3319
13024, 3306, 3307, 3321, 3320
13025, 3307, 3308, 3322, 3321
13026, 3308, 3309, 3323, 3322
13027, 3309, 3310, 3324, 3323
13028, 3310, 3311, 3325, 3324
13029, 3311, 3312, 3326, 3325
13030, 3312, 3313, 3327, 3326
13031, 3313, 3314, 3328, 3327
13032, 3314, 3315, 3329, 3328
13033, 3315, 3316, 3330, 3329
13034, 3316, 3317, 3331, 3330
13035, 3317, 3318, 3332, 3331
13036, 3318, 607, 608, 3332
13037, 594, 3319, 3333, 595
13038, 3319, 3320, 3334, 3333
13039, 3320, 3321, 3335, 3334
13040, 3321, 3322, 3336, 3335
13041, 3322, 3323, 3337, 3336
13042, 3323, 3324, 3338, 3337
13043, 3324, 3325, 3339, 3338
13044, 3325, 3326, 3340, 3339
13045, 3326, 3327, 3341, 3340
13046, 3327, 3328, 3342, 3341
13047, 3328, 3329, 3343, 3342
13048, 3329, 3330, 3344, 3343
13049, 3330, 3331, 3345, 3344
13050, 3331, 3332, 3346, 3345
13051, 3332, 608, 609, 3346
13052, 595, 3333, 3347, 596
13053, 3333, 3334, 3348, 3347
13054, 3334, 3335, 3349, 3348
13055, 3335, 3336, 3350, 3349
13056, 3336, 3337, 3351, 3350
13057, 3337, 3338, 3352, 3351
13058, 3338, 3339, 3353, 3352
13059, 3339, 3340, 3354, 3353
13060, 3340, 3341, 3355, 3354
13061, 3341, 3342, 3356, 3355
13062, 3342, 3343, 3357, 3356
13063, 3343, 3344, 3358, 3357
13064, 3344, 3345, 3359, 3358
13065, 3345, 3346, 3360, 3359
13066, 3346, 609, 610, 3360
13067, 596, 3347, 3361, 597
13068, 3347, 3348, 3362, 3361
13069, 3348, 3349, 3363, 3362
13070, 3349, 3350, 3364, 3363
13071, 3350, 3351, 3365, 3364
13072, 3351, 3352, 3366, 3365
13073, 3352, 3353, 3367, 3366
13074, 3353, 3354, 3368, 3367
13075, 3354, 3355, 3369, 3368
13076, 3355, 3356, 3370, 3369
13077, 3356, 3357, 3371, 3370
13078, 3357, 3358, 3372, 3371
13079, 3358, 3359, 3373, 3372
13080, 3359, 3360, 3374, 3373
13081, 3360, 610, 611, 3374
13082, 597, 3361, 3375, 598
13083, 3361, 3362, 3376, 3375
13084, 3362, 3363, 3377, 3376
13085, 3363, 3364, 3378, 3377
13086, 3364, 3365, 3379, 3378
13087, 3365, 3366, 3380, 3379
13088, 3366, 3367, 3381, 3380
13089, 3367, 3368, 3382, 3381
13090, 3368, 3369, 3383, 3382
13091, 3369, 3370, 3384, 3383
13092, 3370, 3371, 3385, 3384
13093, 3371, 3372, 3386, 3385
13094, 3372, 3373, 3387, 3386
13095, 3373, 3374, 3388, 3387
13096, 3374, 611, 612, 3388
13097, 598, 3375, 3389, 599
13098, 3375, 3376, 3390, 3389
13099, 3376, 3377, 3391, 3390
13100, 3377, 3378, 3392, 3391
13101, 3378, 3379, 3393, 3392
13102, 3379, 3380, 3394, 3393
13103, 3380, 3381, 3395, 3394
13104, 3381, 3382, 3396, 3395
13105, 3382, 3383, 3397, 3396
13106, 3383, 3384, 3398, 3397
13107, 3384, 3385, 3399, 3398
13108, 3385, 3386, 3400, 3399
13109, 3386, 3387, 3401, 3400
13110, 3387, 3388, 3402, 3401
13111, 3388, 612, 613, 3402
13112, 599, 3389, 3403, 600
13113, 3389, 3390, 3404, 3403
13114, 3390, 3391, 3405, 3404
13115, 3391, 3392, 3406, 3405
13116, 3392, 3393, 3407, 3406
13117, 3393, 3394, 3408, 3407
13118, 3394, 3395, 3409, 3408
13119, 3395, 3396, 3410, 3409
13120, 3396, 3397, 3411, 3410
13121, 3397, 3398, 3412, 3411
13122, 3398, 3399, 3413, 3412
13123, 3399, 3400, 3414, 3413
13124, 3400, 3401, 3415, 3414
13125, 3401, 3402, 3416, 3415
13126, 3402, 613, 614, 3416
13127, 600, 3403, 3417, 601
13128, 3403, 3404, 3418, 3417
13129, 3404, 3405, 3419, 3418
13130, 3405, 3406, 3420, 3419
13131, 3406, 3407, 3421, 3420
13132, 3407, 3408, 3422, 3421
13133, 3408, 3409, 3423, 3422
13134, 3409, 3410, 3424, 3423
13135, 3410, 3411, 3425, 3424
13136, 3411, 3412, 3426, 3425
13137, 3412, 3413, 3427, 3426
13138, 3413, 3414, 3428, 3427
13139, 3414, 3415, 3429, 3428
13140, 3415, 3416, 3430, 3429
13141, 3416, 614, 615, 3430
13142, 601, 3417, 3431, 602
13143, 3417, 3418, 3432, 3431
13144, 3418, 3419, 3433, 3432
13145, 3419, 3420, 3434, 3433
13146, 3420, 3421, 3435, 3434
13147, 3421, 3422, 3436, 3435
13148, 3422, 3423, 3437, 3436
13149, 3423, 3424, 3438, 3437
13150, 3424, 3425, 3439, 3438
13151, 3425, 3426, 3440, 3439
13152, 3426, 3427, 3441, 3440
13153, 3427, 3428, 3442, 3441
13154, 3428, 3429, 3443, 3442
13155, 3429, 3430, 3444, 3443
13156, 3430, 615, 616, 3444
13157, 602, 3431, 561, 33
13158, 3431, 3432, 562, 561
13159, 3432, 3433, 563, 562
13160, 3433, 3434, 564, 563
13161, 3434, 3435, 565, 564
13162, 3435, 3436, 566, 565
13163, 3436, 3437, 567, 566
13164, 3437, 3438, 568, 567
13165, 3438, 3439, 569, 568
13166, 3439, 3440, 570, 569
13167, 3440, 3441, 571, 570
13168, 3441, 3442, 572, 571
13169, 3442, 3443, 573, 572
13170, 3443, 3444, 574, 573
13171, 3444, 616, 34, 574
*ELEMENT, type=CPS4, ELSET=Surface42
13172, 33, 617, 3445, 561
13173, 617, 618, 3446, 3445
13174, 618, 619, 3447, 3446
13175, 619, 620, 3448, 3447
13176, 620, 621, 3449, 3448
13177, 621, 622, 3450, 3449
13178, 622, 623, 3451, 3450
13179, 623, 624, 3452, 3451
13180, 624, 625, 3453, 3452
13181, 625, 626, 3454, 3453
13182, 626, 627, 3455, 3454
13183, 627, 628, 3456, 3455
13184, 628, 629, 3457, 3456
13185, 629, 630, 3458, 3457
13186, 630, 37, 645, 3458
13187, 561, 3445, 3459, 562
13188, 3445, 3446, 3460, 3459
13189, 3446, 3447, 3461, 3460
13190, 3447, 3448, 3462, 3461
13191, 3448, 3449, 3463, 3462
13192, 3449, 3450, 3464, 3463
13193, 3450, 3451, 3465, 3464
13194, 3451, 3452, 3466, 3465
13195, 3452, 3453, 3467, 3466
13196, 3453, 3454, 3468, 3467
13197, 3454, 3455, 3469, 3468
13198, 3455, 3456, 3470, 3469
13199, 3456, 3457, 3471, 3470
13200, 3457, 3458, 3472, 3471
13201, 3458, 645, 646, 3472
13202, 562, 3459, 3473, 563
13203, 3459, 3460, 3474, 3473
13204, 3460, 3461, 3475, 3474
13205, 3461, 3462, 3476, 3475
13206, 3462, 3463, 3477, 3476
13207, 3463, 3464, 3478, 3477
13208, 3464, 3465, 3479, 3478
13209, 3465, 3466, 3480, 3479
13210, 3466, 3467, 3481, 3480
13211, 3467, 3468, 3482, 3481
13212, 3468, 3469, 3483, 3482
13213, 3469, 3470, 3484, 3483
13214, 3470, 3471, 3485, 3484
13215, 3471, 3472, 3486, 3485
13216, 3472, 646, 647, 3486
13217, 563, 3473, 3487, 564
13218, 3473, 3474, 3488, 3487
13219, 3474, 3475, 3489, 3488
13220, 3475, 3476, 3490, 3489
13221, 3476, 3477, 3491, 3490
13222, 3477, 3478, 3492, 3491
13223, 3478, 3479, 3493, 3492
13224, 3479, 3480, 3494, 3493
13225, 3480, 3481, 3495, 3494
13226, 3481, 3482, 3496, 3495
13227, 3482, 3483, 3497, 3496
13228, 3483, 3484, 3498, 3497
13229, 3484, 3485, 3499, 3498
13230, 3485, 3486, 3500, 3499
13231, 3486, 647, 648, 3500
13232, 564, 3487, 3501, 565
13233, 3487, 3488, 3502, 3501
13234, 3488, 3489, 3503, 3502
13235, 3489, 3490, 3504, 3503
13236, 3490, 3491, 3505, 3504
13237, 3491, 3492, 3506, 3505
13238, 3492, 3493, 3507, 3506
13239, 3493, 3494, 3508, 3507
13240, 3494, 3495, 3509, 3508
13241, 3495, 3496, 3510, 3509
13242, 3496, 3497, 3511, 3510
13243, 3497, 3498, 3512, 3511
13244, 3498, 3499, 3513, 3512
13245, 3499, 3500, 3514, 3513
13246, 3500, 648, 649, 3514
13247, 565, 3501, 3515, 566
13248, 3501, 3502, 3516, 3515
13249, 3502, 3503, 3517, 3516
13250, 3503, 3504, 3518, 3517
13251, 3504, 3505, 3519, 3518
13252, 3505, 3506, 3520, 3519
13253, 3506, 3507, 3521, 3520
13254, 3507, 3508, 3522, 3521
13255, 3508, 3509, 3523, 3522
13256, 3509, 3510, 3524, 3523
13257, 3510, 3511, 3525, 3524
13258, 3511, 3512, 3526, 3525
13259, 3512, 3513, 3527, 3526
13260, 3513, 3514, 3528, 3527
13261, 3514, 649, 650, 3528
13262, 566, 3515, 3529, 567
13263, 3515, 3516, 3530, 3529
13264, 3516, 3517, 3531, 3530
13265, 3517, 3518, 3532, 3531
13266, 3518, 3519, 3533, 3532
13267, 3519, 3520, 3534, 3533
13268, 3520, 3521, 3535, 3534
13269, 3521, 3522, 3536, 3535
13270, 3522, 3523, 3537, 3536
13271, 3523, 3524, 3538, 3537
13272, 3524, 3525, 3539, 3538
13273, 3525, 3526, 3540, 3539
13274, 3526, 3527, 3541, 3540
13275, 3527, 3528, 3542, 3541
13276, 3528, 650, 651, 3542
13277, 567, 3529, 3543, 568
13278, 3529, 3530, 3544, 3543
13279, 3530, 3531, 3545, 3544
13280, 3531, 3532, 3546, 3545
13281, 3532, 3533, 3547, 3546
13282, 3533, 3534, 3548, 3547
13283, 3534, 3535, 3549, 3548
13284, 3535, 3536, 3550, 3549
13285, 3536, 3537, 3551, 3550
13286, 3537, 3538, 3552, 3551
13287, 3538, 3539, 3553, 3552
13288, 3539, 3540, 3554, 3553
13289, 3540, 3541, 3555, 3554
13290, 3541, 3542, 3556, 3555
13291, 3542, 651, 652, 3556
13292, 568, 3543, 3557, 569
13293, 3543, 3544, 3558, 3557
13294, 3544, 3545, 3559, 3558
13295, 3545, 3546, 3560, 3559
13296, 3546, 3547, 3561, 3560
13297, 3547, 3548, 3562, 3561
13298, 3548, 3549, 3563, 3562
13299, 3549, 3550, 3564, 3563
13300, 3550, 3551, 3565, 3564
13301, 3551, 3552, 3566, 3565
13302, 3552, 3553, 3567, 3566
13303, 3553, 3554, 3568, 3567
13304, 3554, 3555, 3569, 3568
13305, 3555, 3556, 3570, 3569
13306, 3556, 652, 653, 3570
13307, 569, 3557, 3571, 570
13308, 3557, 3558, 3572, 3571
13309, 3558, 3559, 3573, 3572
13310, 3559, 3560, 3574, 3573
13311, 3560, 3561, 3575, 3574
13312, 3561, 3562, 3576, 3575
13313, 3562, 3563, 3577, 3576
13314, 3563, 3564, 3578, 3577
13315, 3564, 3565, 3579, 3578
13316, 3565, 3566, 3580, 3579
13317, 3566, 3567, 3581, 3580
13318, 3567, 3568, 3582, 3581
13319, 3568, 3569, 3583, 3582
13320, 3569, 3570, 3584, 3583
13321, 3570, 653, 654, 3584
13322, 570, 3571, 3585, 571
13323, 3571, 3572, 3586, 3585
13324, 3572, 3573, 3587, 3586
13325, 3573, 3574, 3588, 3587
13326, 3574, 3575, 3589, 3588
13327, 3575, 3576, 3590, 3589
13328, 3576, 3577, 3591, 3590
13329, 3577, 3578, 3592, 3591
13330, 3578, 3579, 3593, 3592
13331, 3579, 3580, 3594, 3593
13332, 3580, 3581, 3595, 3594
13333, 3581, 3582, 3596, 3595
13334, 3582, 3583, 3597, 3596
13335, 3583, 3584, 3598, 3597
13336, 3584, 654, 655, 3598
13337, 571, 3585, 3599, 572
13338, 3585, 3586, 3600, 3599
13339, 3586, 3587, 3601, 3600
13340, 3587, 3588, 3602, 3601
13341, 3588, 3589, 3603, 3602
13342, 3589, 3590, 3604, 3603
13343, 3590, 3591, 3605, 3604
13344, 3591, 3592, 3606, 3605
13345, 3592, 3593, 3607, 3606
13346, 3593, 3594, 3608, 3607
13347, 3594, 3595, 3609, 3608
13348, 3595, 3596, 3610, 3609
13349, 3596, 3597, 3611, 3610
13350, 3597, 3598, 3612, 3611
13351, 3598, 655, 656, 3612
13352, 572, 3599, 3613, 573
13353, 3599, 3600, 3614, 3613
13354, 3600, 3601, 3615, 3614
13355, 3601, 3602, 3616, 3615
13356, 3602, 3603, 3617, 3616
13357, 3603, 3604, 3618, 3617
13358, 3604, 3605, 3619, 3618
13359, 3605, 3606, 3620, 3619
13360, 3606, 3607, 3621, 3620
13361, 3607, 3608, 3622, 3621
13362, 3608, 3609, 3623, 3622
13363, 3609, 3610, 3624, 3623
13364, 3610, 3611, 3625, 3624
13365, 3611, 3612, 3626, 3625
13366, 3612, 656, 657, 3626
13367, 573, 3613, 3627, 574
13368, 3613, 3614, 3628, 3627
13369, 3614, 3615, 3629, 3628
13370, 3615, 3616, 3630, 3629
13371, 3616, 3617, 3631, 3630
13372, 3617, 3618, 3632, 3631
13373, 3618, 3619, 3633, 3632
13374, 3619, 3620, 3634, 3633
13375, 3620, 3621, 3635, 3634
13376, 3621, 3622, 3636, 3635
13377, 3622, 3623, 3637, 3636
13378, 3623, 3624, 3638, 3637
13379, 3624, 3625, 3639, 3638
13380, 3625, 3626, 3640, 3639
13381, 3626, 657, 658, 3640
13382, 574, 3627, 631, 34
13383, 3627, 3628, 632, 631
13384, 3628, 3629, 633, 632
13385, 3629, 3630, 634, 633
13386, 3630, 3631, 635, 634
13387, 3631, 3632, 636, 635
13388, 3632, 3633, 637, 636
13389, 3633, 3634, 638, 637
13390, 3634, 3635, 639, 638
13391, 3635, 3636, 640, 639
13392, 3636, 3637, 641, 640
13393, 3637, 3638, 642, 641
13394, 3638, 3639, 643, 642
13395, 3639, 3640, 644, 643
13396, 3640, 658, 38, 644
*ELEMENT, type=CPS4, ELSET=Surface43
13397, 35, 575, 3641, 659
13398, 659, 3641, 3642, 660
13399, 660, 3642, 3643, 661
13400, 661, 3643, 3644, 662
13401, 662, 3644, 3645, 663
13402, 663, 3645, 3646, 664
13403, 664, 3646, 3647, 665
13404, 665, 3647, 3648, 666
13405, 666, 3648, 3649, 667
13406, 667, 3649, 3650, 668
13407, 668, 3650, 3651, 669
13408, 669, 3651, 3652, 670
13409, 670, 3652, 3653, 671
13410, 671, 3653, 3654, 672
13411, 672, 3654, 687, 39
13412, 575, 576, 3655, 3641
13413, 3641, 3655, 3656, 3642
13414, 3642, 3656, 3657, 3643
13415, 3643, 3657, 3658, 3644
13416, 3644, 3658, 3659, 3645
13417, 3645, 3659, 3660, 3646
13418, 3646, 3660, 3661, 3647
13419, 3647, 3661, 3662, 3648
13420, 3648, 3662, 3663, 3649
13421, 3649, 3663, 3664, 3650
13422, 3650, 3664, 3665, 3651
13423, 3651, 3665, 3666, 3652
13424, 3652, 3666, 3667, 3653
13425, 3653, 3667, 3668, 3654
13426, 3654, 3668, 688, 687
13427, 576, 577, 3669, 3655
13428, 3655, 3669, 3670, 3656
13429, 3656, 3670, 3671, 3657
13430, 3657, 3671, 3672, 3658
13431, 3658, 3672, 3673, 3659
13432, 3659, 3673, 3674, 3660
13433, 3660, 3674, 3675, 3661
13434, 3661, 3675, 3676, 3662
13435, 3662, 3676, 3677, 3663
13436, 3663, 3677, 3678, 3664
13437, 3664, 3678, 3679, 3665
13438, 3665, 3679, 3680, 3666
13439, 3666, 3680, 3681, 3667
13440, 3667, 3681, 3682, 3668
13441, 3668, 3682, 689, 688
13442, 577, 578, 3683, 3669
13443, 3669, 3683, 3684, 3670
13444, 3670, 3684, 3685, 3671
13445, 3671, 3685, 3686, 3672
13446, 3672, 3686, 3687, 3673
13447, 3673, 3687, 3688, 3674
13448, 3674, 3688, 3689, 3675
13449, 3675, 3689, 3690, 3676
13450, 3676, 3690, 3691, 3677
13451, 3677, 3691, 3692, 3678
13452, 3678, 3692, 3693, 3679
13453, 3679, 3693, 3694, 3680
13454, 3680, 3694, 3695, 3681
13455, 3681, 3695, 3696, 3682
13456, 3682, 3696, 690, 689
13457, 578, 579, 3697, 3683
13458, 3683, 3697, 3698, 3684
13459, 3684, 3698, 3699, 3685
13460, 3685, 3699, 3700, 3686
13461, 3686, 3700, 3701, 3687
13462, 3687, 3701, 3702, 3688
13463, 3688, 3702, 3703, 3689
13464, 3689, 3703, 3704, 3690
13465, 3690, 3704, 3705, 3691
13466, 3691, 3705, 3706, 3692
13467, 3692, 3706, 3707, 3693
13468, 3693, 3707, 3708, 3694
13469, 3694, 3708, 3709, 3695
13470, 3695, 3709, 3710, 3696
13471, 3696, 3710, 691, 690
13472, 579, 580, 3711, 3697
13473, 3697, 3711, 3712, 3698
13474, 3698, 3712, 3713, 3699
13475, 3699, 3713, 3714, 3700
13476, 3700, 3714, 3715, 3701
13477, 3701, 3715, 3716, 3702
13478, 3702, 3716, 3717, 3703
13479, 3703, 3717, 3718, 3704
13480, 3704, 3718, 3719, 3705
13481, 3705, 3719, 3720, 3706
13482, 3706, 3720, 3721, 3707
13483, 3707, 3721, 3722, 3708
13484, 3708, 3722, 3723, 3709
13485, 3709, 3723, 3724, 3710
13486, 3710, 3724, 692, 691
13487, 580, 581, 3725, 3711
13488, 3711, 3725, 3726, 3712
13489, 3712, 3726, 3727, 3713
13490, 3713, 3727, 3728, 3714
13491, 3714, 3728, 3729, 3715
13492, 3715, 3729, 3730, 3716
13493, 3716, 3730, 3731, 3717
13494, 3717, 3731, 3732, 3718
13495, 3718, 3732, 3733, 3719
13496, 3719, 3733, 3734, 3720
13497, 3720, 3734, 3735, 3721
13498, 3721, 3735, 3736, 3722
13499, 3722, 3736, 3737, 3723
13500, 3723, 3737, 3738, 3724
13501, 3724, 3738, 693, 692
13502, 581, 582, 3739, 3725
13503, 3725, 3739, 3740, 3726
13504, 3726, 3740, 3741, 3727
13505, 3727, 3741, 3742, 3728
13506, 3728, 3742, 3743, 3729
13507, 3729, 3743, 3744, 3730
13508, 3730, 3744, 3745, 3731
13509, 3731, 3745, 3746, 3732
13510, 3732, 3746, 3747, 3733
13511, 3733, 3747, 3748, 3734
13512, 3734, 3748, 3749, 3735
13513, 3735, 3749, 3750, 3736
13514, 3736, 3750, 3751, 3737
13515, 3737, 3751, 3752, 3738
13516, 3738, 3752, 694, 693
13517, 582, 583, 3753, 3739
13518, 3739, 3753, 3754, 3740
13519, 3740, 3754, 3755, 3741
13520, 3741, 3755, 3756, 3742
13521, 3742, 3756, 3757, 3743
13522, 3743, 3757, 3758, 3744
13523, 3744, 3758, 3759, 3745
13524, 3745, 3759, 3760, 3746
13525, 3746, 3760, 3761, 3747
13526, 3747, 3761, 3762, 3748
13527, 3748, 3762, 3763, 3749
13528, 3749, 3763, 3764, 3750
13529, 3750, 3764, 3765, 3751
13530, 3751, 3765, 3766, 3752
13531, 3752, 3766, 695, 694
13532, 583, 584, 3767, 3753
13533, 3753, 3767, 3768, 3754
13534, 3754, 3768, 3769, 3755
13535, 3755, 3769, 3770, 3756
13536, 3756, 3770, 3771, 3757
13537, 3757, 3771, 3772, 3758
13538, 3758, 3772, 3773, 3759
13539, 3759, 3773, 3774, 3760
13540, 3760, 3774, 3775, 3761
13541, 3761, 3775, 3776, 3762
13542, 3762, 3776, 3777, 3763
13543, 3763, 3777, 3778, 3764
13544, 3764, 3778, 3779, 3765
13545, 3765, 3779, 3780, 3766
13546, 3766, 3780, 696, 695
13547, 584, 585, 3781, 3767
13548, 3767, 3781, 3782, 3768
13549, 3768, 3782, 3783, 3769
13550, 3769, 3783, 3784, 3770
13551, 3770, 3784, 3785, 3771
13552, 3771, 3785, 3786, 3772
13553, 3772, 3786, 3787, 3773
13554, 3773, 3787, 3788, 3774
13555, 3774, 3788, 3789, 3775
13556, 3775, 3789, 3790, 3776
13557, 3776, 3790, 3791, 3777
13558, 3777, 3791, 3792, 3778
13559, 3778, 3792, 3793, 3779
13560, 3779, 3793, 3794, 3780
13561, 3780, 3794, 697, 696
13562, 585, 586, 3795, 3781
13563, 3781, 3795, 3796, 3782
13564, 3782, 3796, 3797, 3783
13565, 3783, 3797, 3798, 3784
13566, 3784, 3798, 3799, 3785
13567, 3785, 3799, 3800, 3786
13568, 3786, 3800, 3801, 3787
13569, 3787, 3801, 3802, 3788
13570, 3788, 3802, 3803, 3789
13571, 3789, 3803, 3804, 3790
13572, 3790, 3804, 3805, 3791
13573, 3791, 3805, 3806, 3792
13574, 3792, 3806, 3807, 3793
13575, 3793, 3807, 3808, 3794
13576, 3794, 3808, 698, 697
13577, 586, 587, 3809, 3795
13578, 3795, 3809, 3810, 3796
13579, 3796, 3810, 3811, 3797
13580, 3797, 3811, 3812, 3798
13581, 3798, 3812, 3813, 3799
13582, 3799, 3813, 3814, 3800
13583, 3800, 3814, 3815, 3801
13584, 3801, 3815, 3816, 3802
13585, 3802, 3816, 3817, 3803
13586, 3803, 3817, 3818, 3804
13587, 3804, 3818, 3819, 3805
13588, 3805, 3819, 3820, 3806
13589, 3806, 3820, 3821, 3807
13590, 3807, 3821, 3822, 3808
13591, 3808, 3822, 699, 698
13592, 587, 588, 3823, 3809
13593, 3809, 3823, 3824, 3810
13594, 3810, 3824, 3825, 3811
13595, 3811, 3825, 3826, 3812
13596, 3812, 3826, 3827, 3813
13597, 3813, 3827, 3828, 3814
13598, 3814, 3828, 3829, 3815
13599, 3815, 3829, 3830, 3816
13600, 3816, 3830, 3831, 3817
13601, 3817, 3831, 3832, 3818
13602, 3818, 3832, 3833, 3819
13603, 3819, 3833, 3834, 3820
13604, 3820, 3834, 3835, 3821
13605, 3821, 3835, 3836, 3822
13606, 3822, 3836, 700, 699
13607, 588, 36, 673, 3823
13608, 3823, 673, 674, 3824
13609, 3824, 674, 675, 3825
13610, 3825, 675, 676, 3826
13611, 3826, 676, 677, 3827
13612, 3827, 677, 678, 3828
13613, 3828, 678, 679, 3829
13614, 3829, 679, 680, 3830
13615, 3830, 680, 681, 3831
13616, 3831, 681, 682, 3832
13617, 3832, 682, 683, 3833
13618, 3833, 683, 684, 3834
13619, 3834, 684, 685, 3835
13620, 3835, 685, 686, 3836
13621, 3836, 686, 40, 700
*ELEMENT, type=CPS4, ELSET=Surface44
13622, 35, 659, 3837, 589
13623, 659, 660, 3838, 3837
13624, 660, 661, 3839, 3838
13625, 661, 662, 3840, 3839
13626, 662, 663, 3841, 3840
13627, 663, 664, 3842, 3841
13628, 664, 665, 3843, 3842
13629, 665, 666, 3844, 3843
13630, 666, 667, 3845, 3844
13631, 667, 668, 3846, 3845
13632, 668, 669, 3847, 3846
13633, 669, 670, 3848, 3847
13634, 670, 671, 3849, 3848
13635, 671, 672, 3850, 3849
13636, 672, 39, 701, 3850
13637, 589, 3837, 3851, 590
13638, 3837, 3838, 3852, 3851
13639, 3838, 3839, 3853, 3852
13640, 3839, 3840, 3854, 3853
13641, 3840, 3841, 3855, 3854
13642, 3841, 3842, 3856, 3855
13643, 3842, 3843, 3857, 3856
13644, 3843, 3844, 3858, 3857
13645, 3844, 3845, 3859, 3858
13646, 3845, 3846, 3860, 3859
13647, 3846, 3847, 3861, 3860
13648, 3847, 3848, 3862, 3861
13649, 3848, 3849, 3863, 3862
13650, 3849, 3850, 3864, 3863
13651, 3850, 701, 702, 3864
13652, 590, 3851, 3865, 591
13653, 3851, 3852, 3866, 3865
13654, 3852, 3853, 3867, 3866
13655, 3853, 3854, 3868, 3867
13656, 3854, 3855, 3869, 3868
13657, 3855, 3856, 3870, 3869
13658, 3856, 3857, 3871, 3870
13659, 3857, 3858, 3872, 3871
13660, 3858, 3859, 3873, 3872
13661, 3859, 3860, 3874, 3873
13662, 3860, 3861, 3875, 3874
13663, 3861, 3862, 3876, 3875
13664, 3862, 3863, 3877, 3876
13665, 3863, 3864, 3878, 3877
13666, 3864, 702, 703, 3878
13667, 591, 3865, 3879, 592
13668, 3865, 3866, 3880, 3879
13669, 3866, 3867, 3881, 3880
13670, 3867, 3868, 3882, 3881
13671, 3868, 3869, 3883, 3882
13672, 3869, 3870, 3884, 3883
13673, 3870, 3871, 3885, 3884
13674, 3871, 3872, 3886, 3885
13675, 3872, 3873, 3887, 3886
13676, 3873, 3874, 3888, 3887
13677, 3874, 3875, 3889, 3888
13678, 3875, 3876, 3890, 3889
13679, 3876, 3877, 3891, 3890
13680, 3877, 3878, 3892, 3891
13681, 3878, 703, 704, 3892
13682, 592, 3879, 3893, 593
13683, 3879, 3880, 3894, 3893
13684, 3880, 3881, 3895, 3894
13685, 3881, 3882, 3896, 3895
13686, 3882, 3883, 3897, 3896
13687, 3883, 3884, 3898, 3897
13688, 3884, 3885, 3899, 3898
13689, 3885, 3886, 3900, 3899
13690, 3886, 3887, 3901, 3900
13691, 3887, 3888, 3902, 3901
13692, 3888, 3889, 3903, 3902
13693, 3889, 3890, 3904, 3903
13694, 3890, 3891, 3905, 3904
13695, 3891, 3892, 3906, 3905
13696, 3892, 704, 705, 3906
13697, 593, 3893, 3907, 594
13698, 3893, 3894, 3908, 3907
13699, 3894, 3895, 3909, 3908
13700, 3895, 3896, 3910, 3909
13701, 3896, 3897, 3911, 3910
13702, 3897, 3898, 3912, 3911
13703, 3898, 3899, 3913, 3912
13704, 3899, 3900, 3914, 3913
13705, 3900, 3901, 3915, 3914
13706, 3901, 3902, 3916, 3915
13707, 3902, 3903, 3917, 3916
13708, 3903, 3904, 3918, 3917
13709, 3904, 3905, 3919, 3918
13710, 3905, 3906, 3920, 3919
13711, 3906, 705, 706, 3920
13712, 594, 3907, 3921, 595
13713, 3907, 3908, 3922, 3921
13714, 3908, 3909, 3923, 3922
13715, 3909, 3910, 3924, 3923
13716, 3910, 3911, 3925, 3924
13717, 3911, 3912, 3926, 3925
13718, 3912, 3913, 3927, 3926
13719, 3913, 3914, 3928, 3927
13720, 3914, 3915, 3929, 3928
13721, 3915, 3916, 3930, 3929
13722, 3916, 3917, 3931, 3930
13723, 3917, 3918, 3932, 3931
13724, 3918, 3919, 3933, 3932
13725, 3919, 3920, 3934, 3933
13726, 3920, 706, 707, 3934
13727, 595, 3921, 3935, 596
13728, 3921, 3922, 3936, 3935
13729, 3922, 3923, 3937, 3936
13730, 3923, 3924, 3938, 3937
13731, 3924, 3925, 3939, 3938
13732, 3925, 3926, 3940, 3939
13733, 3926, 3927, 3941, 3940
13734, 3927, 3928, 3942, 3941
13735, 3928, 3929, 3943, 3942
13736, 3929, 3930, 3944, 3943
13737, 3930, 3931, 3945, 3944
13738, 3931, 3932, 3946, 3945
13739, 3932, 3933, 3947, 3946
13740, 3933, 3934, 3948, 3947
13741, 3934, 707, 708, 3948
13742, 596, 3935, 3949, 597
13743, 3935, 3936, 3950, 3949
13744, 3936, 3937, 3951, 3950
13745, 3937, 3938, 3952, 3951
13746, 3938, 3939, 3953, 3952
13747, 3939, 3940, 3954, 3953
13748, 3940, 3941, 3955, 3954
13749, 3941, 3942, 3956, 3955
13750, 3942, 3943, 3957, 3956
13751, 3943, 3944, 3958, 3957
13752, 3944, 3945, 3959, 3958
13753, 3945, 3946, 3960, 3959
13754, 3946, 3947, 3961, 3960
13755, 3947, 3948, 3962, 3961
13756, 3948, 708, 709, 3962
13757, 597, 3949, 3963, 598
13758, 3949, 3950, 3964, 3963
13759, 3950, 3951, 3965, 3964
13760, 3951, 3952, 3966, 3965
13761, 3952, 3953, 3967, 3966
13762, 3953, 3954, 3968, 3967
13763, 3954, 3955, 3969, 3968
13764, 3955, 3956, 3970, 3969
13765, 3956, 3957, 3971, 3970
13766, 3957, 3958, 3972, 3971
13767, 3958, 3959, 3973, 3972
13768, 3959, 3960, 3974, 3973
13769, 3960, 3961, 3975, 3974
13770, 3961, 3962, 3976, 3975
13771, 3962, 709, 710, 3976
13772, 598, 3963, 3977, 599
13773, 3963, 3964, 3978, 3977
13774, 3964, 3965, 3979, 3978
13775, 3965, 3966, 3980, 3979
13776, 3966, 3967, 3981, 3980
13777, 3967, 3968, 3982, 3981
13778, 3968, 3969, 3983, 3982
13779, 3969, 3970, 3984, 3983
13780, 3970, 3971, 3985, 3984
13781, 3971, 3972, 3986, 3985
13782, 3972, 3973, 3987, 3986
13783, 3973, 3974, 3988, 3987
13784, 3974, 3975, 3989, 3988
13785, 3975, 3976, 3990, 3989
13786, 3976, 710, 711, 3990
13787, 599, 3977, 3991, 600
13788, 3977, 3978, 3992, 3991
13789, 3978, 3979, 3993, 3992
13790, 3979, 3980, 3994, 3993
13791, 3980, 3981, 3995, 3994
13792, 3981, 3982, 3996, 3995
13793, 3982, 3983, 3997, 3996
13794, 3983, 3984, 3998, 3997
13795, 3984, 3985, 3999, 3998
13796, 3985, 3986, 4000, 3999
13797, 3986, 3987, 4001, 4000
13798, 3987, 3988, 4002, 4001
13799, 3988, 3989, 4003, 4002
13800, 3989, 3990, 4004, 4003
13801, 3990, 711, 712, 4004
13802, 600, 3991, 4005, 601
13803, 3991, 3992, 4006, 4005
13804, 3992, 3993, 4007, 4006
13805, 3993, 3994, 4008, 4007
13806, 3994, 3995, 4009, 4008
13807, 3995, 3996, 4010, 4009
13808, 3996, 3997, 4011, 4010
13809, 3997, 3998, 4012, 4011
13810, 3998, 3999, 4013, 4012
13811, 3999, 4000, 4014, 4013
13812, 4000, 4001, 4015, 4014
13813, 4001, 4002, 4016, 4015
13814, 4002, 4003, 4017, 4016
13815, 4003, 4004, 4018, 4017
13816, 4004, 712, 713, 4018
13817, 601, 4005, 4019, 602
13818, 4005, 4006, 4020, 4019
13819, 4006, 4007, 4021, 4020
13820, 4007, 4008, 4022, 4021
13821, 4008, 4009, 4023, 4022
13822, 4009, 4010, 4024, 4023
13823, 4010, 4011, 4025, 4024
13824, 4011, 4012, 4026, 4025
13825, 4012, 4013, 4027, 4026
13826, 4013, 4014, 4028, 4027
13827, 4014, 4015, 4029, 4028
13828, 4015, 4016, 4030, 4029
13829, 4016, 4017, 4031, 4030
13830, 4017, 4018, 4032, 4031
13831, 4018, 713, 714, 4032
13832, 602, 4019, 617, 33
13833, 4019, 4020, 618, 617
13834, 4020, 4021, 619, 618
13835, 4021, 4022, 620, 619
13836, 4022, 4023, 621, 620
13837, 4023, 4024, 622, 621
13838, 4024, 4025, 623, 622
13839, 4025, 4026, 624, 623
13840, 4026, 4027, 625, 624
13841, 4027, 4028, 626, 625
13842, 4028, 4029, 627, 626
13843, 4029, 4030, 628, 627
13844, 4030, 4031, 629, 628
13845, 4031, 4032, 630, 629
13846, 4032, 714, 37, 630
*ELEMENT, type=CPS4, ELSET=Surface45
13847, 36, 603, 4033, 673
13848, 673, 4033, 4034, 674
13849, 674, 4034, 4035, 675
13850, 675, 4035, 4036, 676
13851, 676, 4036, 4037, 677
13852, 677, 4037, 4038, 678
13853, 678, 4038, 4039, 679
13854, 679, 4039, 4040, 680
13855, 680, 4040, 4041, 681
13856, 681, 4041, 4042, 682
13857, 682, 4042, 4043, 683
13858, 683, 4043, 4044, 684
13859, 684, 4044, 4045, 685
13860, 685, 4045, 4046, 686
13861, 686, 4046, 715, 40
13862, 603, 604, 4047, 4033
13863, 4033, 4047, 4048, 4034
13864, 4034, 4048, 4049, 4035
13865, 4035, 4049, 4050, 4036
13866, 4036, 4050, 4051, 4037
13867, 4037, 4051, 4052, 4038
13868, 4038, 4052, 4053, 4039
13869, 4039, 4053, 4054, 4040
13870, 4040, 4054, 4055, 4041
13871, 4041, 4055, 4056, 4042
13872, 4042, 4056, 4057, 4043
13873, 4043, 4057, 4058, 4044
13874, 4044, 4058, 4059, 4045
13875, 4045, 4059, 4060, 4046
13876, 4046, 4060, 716, 715
13877, 604, 605, 4061, 4047
13878, 4047, 4061, 4062, 4048
13879, 4048, 4062, 4063, 4049
13880, 4049, 4063, 4064, 4050
13881, 4050, 4064, 4065, 4051
13882, 4051, 4065, 4066, 4052
13883, 4052, 4066, 4067, 4053
13884, 4053, 4067, 4068, 4054
13885, 4054, 4068, 4069, 4055
13886, 4055, 4069, 4070, 4056
13887, 4056, 4070, 4071, 4057
13888, 4057, 4071, 4072, 4058
13889, 4058, 4072, 4073, 4059
13890, 4059, 4073, 4074, 4060
13891, 4060, 4074, 717, 716
13892, 605, 606, 4075, 4061
13893, 4061, 4075, 4076, 4062
13894, 4062, 4076, 4077, 4063
13895, 4063, 4077, 4078, 4064
13896, 4064, 4078, 4079, 4065
13897, 4065, 4079, 4080, 4066
13898, 4066, 4080, 4081, 4067
13899, 4067, 4081, 4082, 4068
13900, 4068, 4082, 4083, 4069
13901, 4069, 4083, 4084, 4070
13902, 4070, 4084, 4085, 4071
13903, 4071, 4085, 4086, 4072
13904, 4072, 4086, 4087, 4073
13905, 4073, 4087, 4088, 4074
13906, 4074, 4088, 718, 717
13907, 606, 607, 4089, 4075
13908, 4075, 4089, 4090, 4076
13909, 4076, 4090, 4091, 4077
13910, 4077, 4091, 4092, 4078
13911, 4078, 4092, 4093, 4079
13912, 4079, 4093, 4094, 4080
13913, 4080, 4094, 4095, 4081
13914, 4081, 4095, 4096, 4082
13915, 4082, 4096, 4097, 4083
13916, 4083, 4097, 4098, 4084
13917, 4084, 4098, 4099, 4085
13918, 4085, 4099, 4100, 4086
13919, 4086, 4100, 4101, 4087
13920, 4087, 4101, 4102, 4088
13921, 4088, 4102, 719, 718
13922, 607, 608, 4103, 4089
13923, 4089, 4103, 4104, 4090
13924, 4090, 4104, 4105, 4091
13925, 4091, 4105, 4106, 4092
13926, 4092, 4106, 4107, 4093
13927, 4093, 4107, 4108, 4094
13928, 4094, 4108, 4109, 4095
13929, 4095, 4109, 4110, 4096
13930, 4096, 4110, 4111, 4097
13931, 4097, 4111, 4112, 4098
13932, 4098, 4112, 4113, 4099
13933, 4099, 4113, 4114, 4100
13934, 4100, 4114, 4115, 4101
13935, 4101, 4115, 4116, 4102
13936, 4102, 4116, 720, 719
13937, 608, 609, 4117, 4103
13938, 4103, 4117, 4118, 4104
13939, 4104, 4118, 4119, 4105
13940, 4105, 4119, 4120, 4106
13941, 4106, 4120, 4121, 4107
13942, 4107, 4121, 4122, 4108
13943, 4108, 4122, 4123, 4109
13944, 4109, 4123, 4124, 4110
13945, 4110, 4124, 4125, 4111
13946, 4111, 4125, 4126, 4112
13947, 4112, 4126, 4127, 4113
13948, 4113, 4127, 4128, 4114
13949, 4114, 4128, 4129, 4115
13950, 4115, 4129, 4130, 4116
13951, 4116, 4130, 721, 720
13952, 609, 610, 4131, 4117
13953, 4117, 4131, 4132, 4118
13954, 4118, 4132, 4133, 4119
13955, 4119, 4133, 4134, 4120
13956, 4120, 4134, 4135, 4121
13957, 4121, 4135, 4136, 4122
13958, 4122, 4136, 4137, 4123
13959, 4123, 4137, 4138, 4124
13960, 4124, 4138, 4139, 4125
13961, 4125, 4139, 4140, 4126
13962, 4126, 4140, 4141, 4127
13963, 4127, 4141, 4142, 4128
13964, 4128, 4142, 4143, 4129
13965, 4129, 4143, 4144, 4130
13966, 4130, 4144, 722, 721
13967, 610, 611, 4145, 4131
13968, 4131, 4145, 4146, 4132
13969, 4132, 4146, 4147, 4133
13970, 4133, 4147, 4148, 4134
13971, 4134, 4148, 4149, 4135
13972, 4135, 4149, 4150, 4136
13973, 4136, 4150, 4151, 4137
13974, 4137, 4151, 4152, 4138
13975, 4138, 4152, 4153, 4139
13976, 4139, 4153, 4154, 4140
13977, 4140, 4154, 4155, 4141
13978, 4141, 4155, 4156, 4142
13979, 4142, 4156, 4157, 4143
13980, 4143, 4157, 4158, 4144
13981, 4144, 4158, 723, 722
13982, 611, 612, 4159, 4145
13983, 4145, 4159, 4160, 4146
13984, 4146, 4160, 4161, 4147
13985, 4147, 4161, 4162, 4148
13986, 4148, 4162, 4163, 4149
13987, 4149, 4163, 4164, 4150
13988, 4150, 4164, 4165, 4151
13989, 4151, 4165, 4166, 4152
13990, 4152, 4166, 4167, 4153
13991, 4153, 4167, 4168, 4154
13992, 4154, 4168, 4169, 4155
13993, 4155, 4169, 4170, 4156
13994, 4156, 4170, 4171, 4157
13995, 4157, 4171, 4172, 4158
13996, 4158, 4172, 724, 723
13997, 612, 613, 4173, 4159
13998, 4159, 4173, 4174, 4160
13999, 4160, 4174, 4175, 4161
14000, 4161, 4175, 4176, 4162
14001, 4162, 4176, 4177, 4163
14002, 4163, 4177, 4178, 4164
14003, 4164, 4178, 4179, 4165
14004, 4165, 4179, 4180, 4166
14005, 4166, 4180, 4181, 4167
14006, 4167, 4181, 4182, 4168
14007, 4168, 4182, 4183, 4169
14008, 4169, 4183, 4184, 4170
14009, 4170, 4184, 4185, 4171
14010, 4171, 4185, 4186, 4172
14011, 4172, 4186, 725, 724
14012, 613, 614, 4187, 4173
14013, 4173, 4187, 4188, 4174
14014, 4174, 4188, 4189, 4175
14015, 4175, 4189, 4190, 4176
14016, 4176, 4190, 4191, 4177
14017, 4177, 4191, 4192, 4178
14018, 4178, 4192, 4193, 4179
14019, 4179, 4193, 4194, 4180
14020, 4180, 4194, 4195, 4181
14021, 4181, 4195, 4196, 4182
14022, 4182, 4196, 4197, 4183
14023, 4183, 4197, 4198, 4184
14024, 4184, 4198, 4199, 4185
14025, 4185, 4199, 4200, 4186
14026, 4186, 4200, 726, 725
14027, 614, 615, 4201, 4187
14028, 4187, 4201, 4202, 4188
14029, 4188, 4202, 4203, 4189
14030, 4189, 4203, 4204, 4190
14031, 4190, 4204, 4205, 4191
14032, 4191, 4205, 4206, 4192
14033, 4192, 4206, 4207, 4193
14034, 4193, 4207, 4208, 4194
14035, 4194, 4208, 4209, 4195
14036, 4195, 4209, 4210, 4196
14037, 4196, 4210, 4211, 4197
14038, 4197, 4211, 4212, 4198
14039, 4198, 4212, 4213, 4199
14040, 4199, 4213, 4214, 4200
14041, 4200, 4214, 727, 726
14042, 615, 616, 4215, 4201
14043, 4201, 4215, 4216, 4202
14044, 4202, 4216, 4217, 4203
14045, 4203, 4217, 4218, 4204
14046, 4204, 4218, 4219, 4205
14047, 4205, 4219, 4220, 4206
14048, 4206, 4220, 4221, 4207
14049, 4207, 4221, 4222, 4208
14050, 4208, 4222, 4223, 4209
14051, 4209, 4223, 4224, 4210
14052, 4210, 4224, 4225, 4211
14053, 4211, 4225, 4226, 4212
14054, 4212, 4226, 4227, 4213
14055, 4213, 4227, 4228, 4214
14056, 4214, 4228, 728, 727
14057, 616, 34, 631, 4215
14058, 4215, 631, 632, 4216
14059, 4216, 632, 633, 4217
14060, 4217, 633, 634, 4218
14061, 4218, 634, 635, 4219
14062, 4219, 635, 636, 4220
14063, 4220, 636, 637, 4221
14064, 4221, 637, 638, 4222
14065, 4222, 638, 639, 4223
14066, 4223, 639, 640, 4224
14067, 4224, 640, 641, 4225
14068, 4225, 641, 642, 4226
14069, 4226, 642, 643, 4227
14070, 4227, 643, 644, 4228
14071, 4228, 644, 38, 728
*ELEMENT, type=CPS4, ELSET=Surface46
14072, 39, 687, 4229, 701
14073, 687, 688, 4230, 4229
14074, 688, 689, 4231, 4230
14075, 689, 690, 4232, 4231
14076, 690, 691, 4233, 4232
14077, 691, 692, 4234, 4233
14078, 692, 693, 4235, 4234
14079, 693, 694, 4236, 4235
14080, 694, 695, 4237, 4236
14081, 695, 696, 4238, 4237
14082, 696, 697, 4239, 4238
14083, 697, 698, 4240, 4239
14084, 698, 699, 4241, 4240
14085, 699, 700, 4242, 4241
14086, 700, 40, 715, 4242
14087, 701, 4229, 4243, 702
14088, 4229, 4230, 4244, 4243
14089, 4230, 4231, 4245, 4244
14090, 4231, 4232, 4246, 4245
14091, 4232, 4233, 4247, 4246
14092, 4233, 4234, 4248, 4247
14093, 4234, 4235, 4249, 4248
14094, 4235, 4236, 4250, 4249
14095, 4236, 4237, 4251, 4250
14096, 4237, 4238, 4252, 4251
14097, 4238, 4239, 4253, 4252
14098, 4239, 4240, 4254, 4253
14099, 4240, 4241, 4255, 4254
14100, 4241, 4242, 4256, 4255
14101, 4242, 715, 716, 4256
14102, 702, 4243, 4257, 703
14103, 4243, 4244, 4258, 4257
14104, 4244, 4245, 4259, 4258
14105, 4245, 4246, 4260, 4259
14106, 4246, 4247, 4261, 4260
14107, 4247, 4248, 4262, 4261
14108, 4248, 4249, 4263, 4262
14109, 4249, 4250, 4264, 4263
14110, 4250, 4251, 4265, 4264
14111, 4251, 4252, 4266, 4265
14112, 4252, 4253, 4267, 4266
14113, 4253, 4254, 4268, 4267
14114, 4254, 4255, 4269, 4268
14115, 4255, 4256, 4270, 4269
14116, 4256, 716, 717, 4270
14117, 703, 4257, 4271, 704
14118, 4257, 4258, 4272, 4271
14119, 4258, 4259, 4273, 4272
14120, 4259, 4260, 4274, 4273
14121, 4260, 4261, 4275, 4274
14122, 4261, 4262, 4276, 4275
14123, 4262, 4263, 4277, 4276
14124, 4263, 4264, 4278, 4277
14125, 4264, 4265, 4279, 4278
14126, 4265, 4266, 4280, 4279
14127, 4266, 4267, 4281, 4280
14128, 4267, 4268, 4282, 4281
14129, 4268, 4269, 4283, 4282
14130, 4269, 4270, 4284, 4283
14131, 4270, 717, 718, 4284
14132, 704, 4271, 4285, 705
14133, 4271, 4272, 4286, 4285
14134, 4272, 4273, 4287, 4286
14135, 4273, 4274, 4288, 4287
14136, 4274, 4275, 4289, 4288
14137, 4275, 4276, 4290, 4289
14138, 4276, 4277, 4291, 4290
14139, 4277, 4278, 4292, 4291
14140, 4278, 4279, 4293, 4292
14141, 4279, 4280, 4294, 4293
14142, 4280, 4281, 4295, 4294
14143, 4281, 4282, 4296, 4295
14144, 4282, 4283, 4297, 4296
14145, 4283, 4284, 4298, 4297
14146, 4284, 718, 719, 4298
14147, 705, 4285, 4299, 706
14148, 4285, 4286, 4300, 4299
14149, 4286, 4287, 4301, 4300
14150, 4287, 4288, 4302, 4301
14151, 4288, 4289, 4303, 4302
14152, 4289, 4290, 4304, 4303
14153, 4290, 4291, 4305, 4304
14154, 4291, 4292, 4306, 4305
14155, 4292, 4293, 4307, 4306
14156, 4293, 4294, 4308, 4307
14157, 4294, 4295, 4309, 4308
14158, 4295, 4296, 4310, 4309
14159, 4296, 4297, 4311, 4310
14160, 4297, 4298, 4312, 4311
14161, 4298, 719, 720, 4312
14162, 706, 4299, 4313, 707
14163, 4299, 4300, 4314, 4313
14164, 4300, 4301, 4315, 4314
14165, 4301, 4302, 4316, 4315
14166, 4302, 4303, 4317, 4316
14167, 4303, 4304, 4318, 4317
14168, 4304, 4305, 4319, 4318
14169, 4305, 4306, 4320, 4319
14170, 4306, 4307, 4321, 4320
14171, 4307, 4308, 4322, 4321
14172, 4308, 4309, 4323, 4322
14173, 4309, 4310, 4324, 4323
14174, 4310, 4311, 4325, 4324
14175, 4311, 4312, 4326, 4325
14176, 4312, 720, 721, 4326
14177, 707, 4313, 4327, 708
14178, 4313, 4314, 4328, 4327
14179, 4314, 4315, 4329, 4328
14180, 4315, 4316, 4330, 4329
14181, 4316, 4317, 4331, 4330
14182, 4317, 4318, 4332, 4331
14183, 4318, 4319, 4333, 4332
14184, 4319, 4320, 4334, 4333
14185, 4320, 4321, 4335, 4334
14186, 4321, 4322, 4336, 4335
14187, 4322, 4323, 4337, 4336
14188, 4323, 4324, 4338, 4337
14189, 4324, 4325, 4339, 4338
14190, 4325, 4326, 4340, 4339
14191, 4326, 721, 722, 4340
14192, 708, 4327, 4341, 709
14193, 4327, 4328, 4342, 4341
14194, 4328, 4329, 4343, 4342
14195, 4329, 4330, 4344, 4343
14196, 4330, 4331, 4345, 4344
14197, 4331, 4332, 4346, 4345
14198, 4332, 4333, 4347, 4346
14199, 4333, 4334, 4348, 4347
14200, 4334, 4335, 4349, 4348
14201, 4335, 4336, 4350, 4349
14202, 4336, 4337, 4351, 4350
14203, 4337, 4338, 4352, 4351
14204, 4338, 4339, 4353, 4352
14205, 4339, 4340, 4354, 4353
14206, 4340, 722, 723, 4354
14207, 709, 4341, 4355, 710
14208, 4341, 4342, 4356, 4355
14209, 4342, 4343, 4357, 4356
14210, 4343, 4344, 4358, 4357
14211, 4344, 4345, 4359, 4358
14212, 4345, 4346, 4360, 4359
14213, 4346, 4347, 4361, 4360
14214, 4347, 4348, 4362, 4361
14215, 4348, 4349, 4363, 4362
14216, 4349, 4350, 4364, 4363
14217, 4350, 4351, 4365, 4364
14218, 4351, 4352, 4366, 4365
14219, 4352, 4353, 4367, 4366
14220, 4353, 4354, 4368, 4367
14221, 4354, 723, 724, 4368
14222, 710, 4355, 4369, 711
14223, 4355, 4356, 4370, 4369
14224, 4356, 4357, 4371, 4370
14225, 4357, 4358, 4372, 4371
14226, 4358, 4359, 4373, 4372
14227, 4359, 4360, 4374, 4373
14228, 4360, 4361, 4375, 4374
14229, 4361, 4362, 4376, 4375
14230, 4362, 4363, 4377, 4376
14231, 4363, 4364, 4378, 4377
14232, 4364, 4365, 4379, 4378
14233, 4365, 4366, 4380, 4379
14234, 4366, 4367, 4381, 4380
14235, 4367, 4368, 4382, 4381
14236, 4368, 724, 725, 4382
14237, 711, 4369, 4383, 712
14238, 4369, 4370, 4384, 4383
14239, 4370, 4371, 4385, 4384
14240, 4371, 4372, 4386, 4385
14241, 4372, 4373, 4387, 4386
14242, 4373, 4374, 4388, 4387
14243, 4374, 4375, 4389, 4388
14244, 4375, 4376, 4390, 4389
14245, 4376, 4377, 4391, 4390
14246, 4377, 4378, 4392, 4391
14247, 4378, 4379, 4393, 4392
14248, 4379, 4380, 4394, 4393
14249, 4380, 4381, 4395, 4394
14250, 4381, 4382, 4396, 4395
14251, 4382, 725, 726, 4396
14252, 712, 4383, 4397, 713
14253, 4383, 4384, 4398, 4397
14254, 4384, 4385, 4399, 4398
14255, 4385, 4386, 4400, 4399
14256, 4386, 4387, 4401, 4400
14257, 4387, 4388, 4402, 4401
14258, 4388, 4389, 4403, 4402
14259, 4389, 4390, 4404, 4403
14260, 4390, 4391, 4405, 4404
14261, 4391, 4392, 4406, 4405
14262, 4392, 4393, 4407, 4406
14263, 4393, 4394, 4408, 4407
14264, 4394, 4395, 4409, 4408
14265, 4395, 4396, 4410, 4409
14266, 4396, 726, 727, 4410
14267, 713, 4397, 4411, 714
14268, 4397, 4398, 4412, 4411
14269, 4398, 4399, 4413, 4412
14270, 4399, 4400, 4414, 4413
14271, 4400, 4401, 4415, 4414
14272, 4401, 4402, 4416, 4415
14273, 4402, 4403, 4417, 4416
14274, 4403, 4404, 4418, 4417
14275, 4404, 4405, 4419, 4418
14276, 4405, 4406, 4420, 4419
14277, 4406, 4407, 4421, 4420
14278, 4407, 4408, 4422, 4421
14279, 4408, 4409, 4423, 4422
14280, 4409, 4410, 4424, 4423
14281, 4410, 727, 728, 4424
14282, 714, 4411, 645, 37
14283, 4411, 4412, 646, 645
14284, 4412, 4413, 647, 646
14285, 4413, 4414, 648, 647
14286, 4414, 4415, 649, 648
14287, 4415, 4416, 650, 649
14288, 4416, 4417, 651, 650
14289, 4417, 4418, 652, 651
14290, 4418, 4419, 653, 652
14291, 4419, 4420, 654, 653
14292, 4420, 4421, 655, 654
14293, 4421, 4422, 656, 655
14294, 4422, 4423, 657, 656
14295, 4423, 4424, 658, 657
14296, 4424, 728, 38, 658
*ELEMENT, type=CPS4, ELSET=Surface47
14297, 37, 41, 729, 645
14298, 645, 729, 730, 646
14299, 646, 730, 731, 647
14300, 647, 731, 732, 648
14301, 648, 732, 733, 649
14302, 649, 733, 734, 650
14303, 650, 734, 735, 651
14304, 651, 735, 736, 652
14305, 652, 736, 737, 653
14306, 653, 737, 738, 654
14307, 654, 738, 739, 655
14308, 655, 739, 740, 656
14309, 656, 740, 741, 657
14310, 657, 741, 742, 658
14311, 658, 742, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
14312, 39, 687, 743, 43
14313, 687, 688, 744, 743
14314, 688, 689, 745, 744
14315, 689, 690, 746, 745
14316, 690, 691, 747, 746
14317, 691, 692, 748, 747
14318, 692, 693, 749, 748
14319, 693, 694, 750, 749
14320, 694, 695, 751, 750
14321, 695, 696, 752, 751
14322, 696, 697, 753, 752
14323, 697, 698, 754, 753
14324, 698, 699, 755, 754
14325, 699, 700, 756, 755
14326, 700, 40, 44, 756
*ELEMENT, type=CPS4, ELSET=Surface49
14327, 39, 43, 757, 701
14328, 701, 757, 758, 702
14329, 702, 758, 759, 703
14330, 703, 759, 760, 704
14331, 704, 760, 761, 705
14332, 705, 761, 762, 706
14333, 706, 762, 763, 707
14334, 707, 763, 764, 708
14335, 708, 764, 765, 709
14336, 709, 765, 766, 710
14337, 710, 766, 767, 711
14338, 711, 767, 768, 712
14339, 712, 768, 769, 713
14340, 713, 769, 770, 714
14341, 714, 770, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
14342, 40, 715, 771, 44
14343, 715, 716, 772, 771
14344, 716, 717, 773, 772
14345, 717, 718, 774, 773
14346, 718, 719, 775, 774
14347, 719, 720, 776, 775
14348, 720, 721, 777, 776
14349, 721, 722, 778, 777
14350, 722, 723, 779, 778
14351, 723, 724, 780, 779
14352, 724, 725, 781, 780
14353, 725, 726, 782, 781
14354, 726, 727, 783, 782
14355, 727, 728, 784, 783
14356, 728, 38, 42, 784
*ELEMENT, type=CPS4, ELSET=Surface51
14357, 43, 743, 4425, 757
14358, 743, 744, 4426, 4425
14359, 744, 745, 4427, 4426
14360, 745, 746, 4428, 4427
14361, 746, 747, 4429, 4428
14362, 747, 748, 4430, 4429
14363, 748, 749, 4431, 4430
14364, 749, 750, 4432, 4431
14365, 750, 751, 4433, 4432
14366, 751, 752, 4434, 4433
14367, 752, 753, 4435, 4434
14368, 753, 754, 4436, 4435
14369, 754, 755, 4437, 4436
14370, 755, 756, 4438, 4437
14371, 756, 44, 771, 4438
14372, 757, 4425, 4439, 758
14373, 4425, 4426, 4440, 4439
14374, 4426, 4427, 4441, 4440
14375, 4427, 4428, 4442, 4441
14376, 4428, 4429, 4443, 4442
14377, 4429, 4430, 4444, 4443
14378, 4430, 4431, 4445, 4444
14379, 4431, 4432, 4446, 4445
14380, 4432, 4433, 4447, 4446
14381, 4433, 4434, 4448, 4447
14382, 4434, 4435, 4449, 4448
14383, 4435, 4436, 4450, 4449
14384, 4436, 4437, 4451, 4450
14385, 4437, 4438, 4452, 4451
14386, 4438, 771, 772, 4452
14387, 758, 4439, 4453, 759
14388, 4439, 4440, 4454, 4453
14389, 4440, 4441, 4455, 4454
14390, 4441, 4442, 4456, 4455
14391, 4442, 4443, 4457, 4456
14392, 4443, 4444, 4458, 4457
14393, 4444, 4445, 4459, 4458
14394, 4445, 4446, 4460, 4459
14395, 4446, 4447, 4461, 4460
14396, 4447, 4448, 4462, 4461
14397, 4448, 4449, 4463, 4462
14398, 4449, 4450, 4464, 4463
14399, 4450, 4451, 4465, 4464
14400, 4451, 4452, 4466, 4465
14401, 4452, 772, 773, 4466
14402, 759, 4453, 4467, 760
14403, 4453, 4454, 4468, 4467
14404, 4454, 4455, 4469, 4468
14405, 4455, 4456, 4470, 4469
14406, 4456, 4457, 4471, 4470
14407, 4457, 4458, 4472, 4471
14408, 4458, 4459, 4473, 4472
14409, 4459, 4460, 4474, 4473
14410, 4460, 4461, 4475, 4474
14411, 4461, 4462, 4476, 4475
14412, 4462, 4463, 4477, 4476
14413, 4463, 4464, 4478, 4477
14414, 4464, 4465, 4479, 4478
14415, 4465, 4466, 4480, 4479
14416, 4466, 773, 774, 4480
14417, 760, 4467, 4481, 761
14418, 4467, 4468, 4482, 4481
14419, 4468, 4469, 4483, 4482
14420, 4469, 4470, 4484, 4483
14421, 4470, 4471, 4485, 4484
14422, 4471, 4472, 4486, 4485
14423, 4472, 4473, 4487, 4486
14424, 4473, 4474, 4488, 4487
14425, 4474, 4475, 4489, 4488
14426, 4475, 4476, 4490, 4489
14427, 4476, 4477, 4491, 4490
14428, 4477, 4478, 4492, 4491
14429, 4478, 4479, 4493, 4492
14430, 4479, 4480, 4494, 4493
14431, 4480, 774, 775, 4494
14432, 761, 4481, 4495, 762
14433, 4481, 4482, 4496, 4495
14434, 4482, 4483, 4497, 4496
14435, 4483, 4484, 4498, 4497
14436, 4484, 4485, 4499, 4498
14437, 4485, 4486, 4500, 4499
14438, 4486, 4487, 4501, 4500
14439, 4487, 4488, 4502, 4501
14440, 4488, 4489, 4503, 4502
14441, 4489, 4490, 4504, 4503
14442, 4490, 4491, 4505, 4504
14443, 4491, 4492, 4506, 4505
14444, 4492, 4493, 4507, 4506
14445, 4493, 4494, 4508, 4507
14446, 4494, 775, 776, 4508
14447, 762, 4495, 4509, 763
14448, 4495, 4496, 4510, 4509
14449, 4496, 4497, 4511, 4510
14450, 4497, 4498, 4512, 4511
14451, 4498, 4499, 4513, 4512
14452, 4499, 4500, 4514, 4513
14453, 4500, 4501, 4515, 4514
14454, 4501, 4502, 4516, 4515
14455, 4502, 4503, 4517, 4516
14456, 4503, 4504, 4518, 4517
14457, 4504, 4505, 4519, 4518
14458, 4505, 4506, 4520, 4519
14459, 4506, 4507, 4521, 4520
14460, 4507, 4508, 4522, 4521
14461, 4508, 776, 777, 4522
14462, 763, 4509, 4523, 764
14463, 4509, 4510, 4524, 4523
14464, 4510, 4511, 4525, 4524
14465, 4511, 4512, 4526, 4525
14466, 4512, 4513, 4527, 4526
14467, 4513, 4514, 4528, 4527
14468, 4514, 4515, 4529, 4528
14469, 4515, 4516, 4530, 4529
14470, 4516, 4517, 4531, 4530
14471, 4517, 4518, 4532, 4531
14472, 4518, 4519, 4533, 4532
14473, 4519, 4520, 4534, 4533
14474, 4520, 4521, 4535, 4534
14475, 4521, 4522, 4536, 4535
14476, 4522, 777, 778, 4536
14477, 764, 4523, 4537, 765
14478, 4523, 4524, 4538, 4537
14479, 4524, 4525, 4539, 4538
14480, 4525, 4526, 4540, 4539
14481, 4526, 4527, 4541, 4540
14482, 4527, 4528, 4542, 4541
14483, 4528, 4529, 4543, 4542
14484, 4529, 4530, 4544, 4543
14485, 4530, 4531, 4545, 4544
14486, 4531, 4532, 4546, 4545
14487, 4532, 4533, 4547, 4546
14488, 4533, 4534, 4548, 4547
14489, 4534, 4535, 4549, 4548
14490, 4535, 4536, 4550, 4549
14491, 4536, 778, 779, 4550
14492, 765, 4537, 4551, 766
14493, 4537, 4538, 4552, 4551
14494, 4538, 4539, 4553, 4552
14495, 4539, 4540, 4554, 4553
14496, 4540, 4541, 4555, 4554
14497, 4541, 4542, 4556, 4555
14498, 4542, 4543, 4557, 4556
14499, 4543, 4544, 4558, 4557
14500, 4544, 4545, 4559, 4558
14501, 4545, 4546, 4560, 4559
14502, 4546, 4547, 4561, 4560
14503, 4547, 4548, 4562, 4561
14504, 4548, 4549, 4563, 4562
14505, 4549, 4550, 4564, 4563
14506, 4550, 779, 780, 4564
14507, 766, 4551, 4565, 767
14508, 4551, 4552, 4566, 4565
14509, 4552, 4553, 4567, 4566
14510, 4553, 4554, 4568, 4567
14511, 4554, 4555, 4569, 4568
14512, 4555, 4556, 4570, 4569
14513, 4556, 4557, 4571, 4570
14514, 4557, 4558, 4572, 4571
14515, 4558, 4559, 4573, 4572
14516, 4559, 4560, 4574, 4573
14517, 4560, 4561, 4575, 4574
14518, 4561, 4562, 4576, 4575
14519, 4562, 4563, 4577, 4576
14520, 4563, 4564, 4578, 4577
14521, 4564, 780, 781, 4578
14522, 767, 4565, 4579, 768
14523, 4565, 4566, 4580, 4579
14524, 4566, 4567, 4581, 4580
14525, 4567, 4568, 4582, 4581
14526, 4568, 4569, 4583, 4582
14527, 4569, 4570, 4584, 4583
14528, 4570, 4571, 4585, 4584
14529, 4571, 4572, 4586, 4585
14530, 4572, 4573, 4587, 4586
14531, 4573, 4574, 4588, 4587
14532, 4574, 4575, 4589, 4588
14533, 4575, 4576, 4590, 4589
14534, 4576, 4577, 4591, 4590
14535, 4577, 4578, 4592, 4591
14536, 4578, 781, 782, 4592
14537, 768, 4579, 4593, 769
14538, 4579, 4580, 4594, 4593
14539, 4580, 4581, 4595, 4594
14540, 4581, 4582, 4596, 4595
14541, 4582, 4583, 4597, 4596
14542, 4583, 4584, 4598, 4597
14543, 4584, 4585, 4599, 4598
14544, 4585, 4586, 4600, 4599
14545, 4586, 4587, 4601, 4600
14546, 4587, 4588, 4602, 4601
14547, 4588, 4589, 4603, 4602
14548, 4589, 4590, 4604, 4603
14549, 4590, 4591, 4605, 4604
14550, 4591, 4592, 4606, 4605
14551, 4592, 782, 783, 4606
14552, 769, 4593, 4607, 770
14553, 4593, 4594, 4608, 4607
14554, 4594, 4595, 4609, 4608
14555, 4595, 4596, 4610, 4609
14556, 4596, 4597, 4611, 4610
14557, 4597, 4598, 4612, 4611
14558, 4598, 4599, 4613, 4612
14559, 4599, 4600, 4614, 4613
14560, 4600, 4601, 4615, 4614
14561, 4601, 4602, 4616, 4615
14562, 4602, 4603, 4617, 4616
14563, 4603, 4604, 4618, 4617
14564, 4604, 4605, 4619, 4618
14565, 4605, 4606, 4620, 4619
14566, 4606, 783, 784, 4620
14567, 770, 4607, 729, 41
14568, 4607, 4608, 730, 729
14569, 4608, 4609, 731, 730
14570, 4609, 4610, 732, 731
14571, 4610, 4611, 733, 732
14572, 4611, 4612, 734, 733
14573, 4612, 4613, 735, 734
14574, 4613, 4614, 736, 735
14575, 4614, 4615, 737, 736
14576, 4615, 4616, 738, 737
14577, 4616, 4617, 739, 738
14578, 4617, 4618, 740, 739
14579, 4618, 4619, 741, 740
14580, 4619, 4620, 742, 741
14581, 4620, 784, 42, 742
*ELEMENT, type=CPS4, ELSET=Surface52
14582, 41, 45, 785, 729
14583, 729, 785, 786, 730
14584, 730, 786, 787, 731
14585, 731, 787, 788, 732
14586, 732, 788, 789, 733
14587, 733, 789, 790, 734
14588, 734, 790, 791, 735
14589, 735, 791, 792, 736
14590, 736, 792, 793, 737
14591, 737, 793, 794, 738
14592, 738, 794, 795, 739
14593, 739, 795, 796, 740
14594, 740, 796, 797, 741
14595, 741, 797, 798, 742
14596, 742, 798, 46, 42
*ELEMENT, type=CPS4, ELSET=Surface53
14597, 43, 743, 799, 47
14598, 743, 744, 800, 799
14599, 744, 745, 801, 800
14600, 745, 746, 802, 801
14601, 746, 747, 803, 802
14602, 747, 748, 804, 803
14603, 748, 749, 805, 804
14604, 749, 750, 806, 805
14605, 750, 751, 807, 806
14606, 751, 752, 808, 807
14607, 752, 753, 809, 808
14608, 753, 754, 810, 809
14609, 754, 755, 811, 810
14610, 755, 756, 812, 811
14611, 756, 44, 48, 812
*ELEMENT, type=CPS4, ELSET=Surface54
14612, 43, 47, 813, 757
14613, 757, 813, 814, 758
14614, 758, 814, 815, 759
14615, 759, 815, 816, 760
14616, 760, 816, 817, 761
14617, 761, 817, 818, 762
14618, 762, 818, 819, 763
14619, 763, 819, 820, 764
14620, 764, 820, 821, 765
14621, 765, 821, 822, 766
14622, 766, 822, 823, 767
14623, 767, 823, 824, 768
14624, 768, 824, 825, 769
14625, 769, 825, 826, 770
14626, 770, 826, 45, 41
*ELEMENT, type=CPS4, ELSET=Surface55
14627, 44, 771, 827, 48
14628, 771, 772, 828, 827
14629, 772, 773, 829, 828
14630, 773, 774, 830, 829
14631, 774, 775, 831, 830
14632, 775, 776, 832, 831
14633, 776, 777, 833, 832
14634, 777, 778, 834, 833
14635, 778, 779, 835, 834
14636, 779, 780, 836, 835
14637, 780, 781, 837, 836
14638, 781, 782, 838, 837
14639, 782, 783, 839, 838
14640, 783, 784, 840, 839
14641, 784, 42, 46, 840
*ELEMENT, type=CPS4, ELSET=Surface56
706, 47, 799, 4621, 813
707, 799, 800, 4622, 4621
708, 800, 801, 4623, 4622
709, 801, 802, 4624, 4623
710, 802, 803, 4625, 4624
711, 803, 804, 4626, 4625
712, 804, 805, 4627, 4626
713, 805, 806, 4628, 4627
714, 806, 807, 4629, 4628
715, 807, 808, 4630, 4629
716, 808, 809, 4631, 4630
717, 809, 810, 4632, 4631
718, 810, 811, 4633, 4632
719, 811, 812, 4634, 4633
720, 812, 48, 827, 4634
721, 813, 4621, 4635, 814
722, 4621, 4622, 4636, 4635
723, 4622, 4623, 4637, 4636
724, 4623, 4624, 4638, 4637
725, 4624, 4625, 4639, 4638
726, 4625, 4626, 4640, 4639
727, 4626, 4627, 4641, 4640
728, 4627, 4628, 4642, 4641
729, 4628, 4629, 4643, 4642
730, 4629, 4630, 4644, 4643
731, 4630, 4631, 4645, 4644
732, 4631, 4632, 4646, 4645
733, 4632, 4633, 4647, 4646
734, 4633, 4634, 4648, 4647
735, 4634, 827, 828, 4648
736, 814, 4635, 4649, 815
737, 4635, 4636, 4650, 4649
738, 4636, 4637, 4651, 4650
739, 4637, 4638, 4652, 4651
740, 4638, 4639, 4653, 4652
741, 4639, 4640, 4654, 4653
742, 4640, 4641, 4655, 4654
743, 4641, 4642, 4656, 4655
744, 4642, 4643, 4657, 4656
745, 4643, 4644, 4658, 4657
746, 4644, 4645, 4659, 4658
747, 4645, 4646, 4660, 4659
748, 4646, 4647, 4661, 4660
749, 4647, 4648, 4662, 4661
750, 4648, 828, 829, 4662
751, 815, 4649, 4663, 816
752, 4649, 4650, 4664, 4663
753, 4650, 4651, 4665, 4664
754, 4651, 4652, 4666, 4665
755, 4652, 4653, 4667, 4666
756, 4653, 4654, 4668, 4667
757, 4654, 4655, 4669, 4668
758, 4655, 4656, 4670, 4669
759, 4656, 4657, 4671, 4670
760, 4657, 4658, 4672, 4671
761, 4658, 4659, 4673, 4672
762, 4659, 4660, 4674, 4673
763, 4660, 4661, 4675, 4674
764, 4661, 4662, 4676, 4675
765, 4662, 829, 830, 4676
766, 816, 4663, 4677, 817
767, 4663, 4664, 4678, 4677
768, 4664, 4665, 4679, 4678
769, 4665, 4666, 4680, 4679
770, 4666, 4667, 4681, 4680
771, 4667, 4668, 4682, 4681
772, 4668, 4669, 4683, 4682
773, 4669, 4670, 4684, 4683
774, 4670, 4671, 4685, 4684
775, 4671, 4672, 4686, 4685
776, 4672, 4673, 4687, 4686
777, 4673, 4674, 4688, 4687
778, 4674, 4675, 4689, 4688
779, 4675, 4676, 4690, 4689
780, 4676, 830, 831, 4690
781, 817, 4677, 4691, 818
782, 4677, 4678, 4692, 4691
783, 4678, 4679, 4693, 4692
784, 4679, 4680, 4694, 4693
785, 4680, 4681, 4695, 4694
786, 4681, 4682, 4696, 4695
787, 4682, 4683, 4697, 4696
788, 4683, 4684, 4698, 4697
789, 4684, 4685, 4699, 4698
790, 4685, 4686, 4700, 4699
791, 4686, 4687, 4701, 4700
792, 4687, 4688, 4702, 4701
793, 4688, 4689, 4703, 4702
794, 4689, 4690, 4704, 4703
795, 4690, 831, 832, 4704
796, 818, 4691, 4705, 819
797, 4691, 4692, 4706, 4705
798, 4692, 4693, 4707, 4706
799, 4693, 4694, 4708, 4707
800, 4694, 4695, 4709, 4708
801, 4695, 4696, 4710, 4709
802, 4696, 4697, 4711, 4710
803, 4697, 4698, 4712, 4711
804, 4698, 4699, 4713, 4712
805, 4699, 4700, 4714, 4713
806, 4700, 4701, 4715, 4714
807, 4701, 4702, 4716, 4715
808, 4702, 4703, 4717, 4716
809, 4703, 4704, 4718, 4717
810, 4704, 832, 833, 4718
811, 819, 4705, 4719, 820
812, 4705, 4706, 4720, 4719
813, 4706, 4707, 4721, 4720
814, 4707, 4708, 4722, 4721
815, 4708, 4709, 4723, 4722
816, 4709, 4710, 4724, 4723
817, 4710, 4711, 4725, 4724
818, 4711, 4712, 4726, 4725
819, 4712, 4713, 4727, 4726
820, 4713, 4714, 4728, 4727
821, 4714, 4715, 4729, 4728
822, 4715, 4716, 4730, 4729
823, 4716, 4717, 4731, 4730
824, 4717, 4718, 4732, 4731
825, 4718, 833, 834, 4732
