2873, 1.4, 1.2, 0.066666666666667
2874, 1.4666666666667, 1.2, 0.066666666666667
2875, 1.5333333333333, 1.2, 0.066666666666667
2876, 1.6, 1.2, 0.066666666666667
2877, 1.6666666666667, 1.2, 0.066666666666667
2878, 1.7333333333333, 1.2, 0.066666666666667
2879, 1.8, 1.2, 0.066666666666667
2880, 1.8666666666667, 1.2, 0.066666666666667
2881, 1.9333333333333, 1.2, 0.066666666666667
2882, 2, 1.2, 0.066666666666667
2883, 2.0666666666667, 1.2, 0.066666666666667
2884, 2.1333333333333, 1.2, 0.066666666666667
2885, 1.2666666666667, 1.2, 0.1
2886, 1.3333333333333, 1.2, 0.1
2887, 1.4, 1.2, 0.1
2888, 1.4666666666667, 1.2, 0.1
2889, 1.5333333333333, 1.2, 0.1
2890, 1.6, 1.2, 0.1
2891, 1.6666666666667, 1.2, 0.1
2892, 1.7333333333333, 1.2, 0.1
2893, 1.8, 1.2, 0.1
2894, 1.8666666666667, 1.2, 0.1
2895, 1.9333333333333, 1.2, 0.1
2896, 2, 1.2, 0.1
2897, 2.0666666666667, 1.2, 0.1
2898, 2.1333333333333, 1.2, 0.1
2899, 1.2666666666667, 1.2, 0.13333333333333
2900, 1.3333333333333, 1.2, 0.13333333333333
2901, 1.4, 1.2, 0.13333333333333
2902, 1.4666666666667, 1.2, 0.13333333333333
2903, 1.5333333333333, 1.2, 0.13333333333333
2904, 1.6, 1.2, 0.13333333333333
2905, 1.6666666666667, 1.2, 0.13333333333333
2906, 1.7333333333333, 1.2, 0.13333333333333
2907, 1.8, 1.2, 0.13333333333333
2908, 1.8666666666667, 1.2, 0.13333333333333
2909, 1.9333333333333, 1.2, 0.13333333333333
2910, 2, 1.2, 0.13333333333333
2911, 2.0666666666667, 1.2, 0.13333333333333
2912, 2.1333333333333, 1.2, 0.13333333333333
2913, 1.2666666666667, 1.2, 0.16666666666667
2914, 1.3333333333333, 1.2, 0.16666666666667
2915, 1.4, 1.2, 0.16666666666667
2916, 1.4666666666667, 1.2, 0.16666666666667
2917, 1.5333333333333, 1.2, 0.16666666666667
2918, 1.6, 1.2, 0.16666666666667
2919, 1.6666666666667, 1.2, 0.16666666666667
2920, 1.7333333333333, 1.2, 0.16666666666667
2921, 1.8, 1.2, 0.16666666666667
2922, 1.8666666666667, 1.2, 0.16666666666667
2923, 1.9333333333333, 1.2, 0.16666666666667
2924, 2, 1.2, 0.16666666666667
2925, 2.0666666666667, 1.2, 0.16666666666667
2926, 2.1333333333333, 1.2, 0.16666666666667
2927, 1.2666666666667, 1.2, 0.2
2928, 1.3333333333333, 1.2, 0.2
2929, 1.4, 1.2, 0.2
2930, 1.4666666666667, 1.2, 0.2
2931, 1.5333333333333, 1.2, 0.2
2932, 1.6, 1.2, 0.2
2933, 1.6666666666667, 1.2, 0.2
2934, 1.7333333333333, 1.2, 0.2
2935, 1.8, 1.2, 0.2
2936, 1.8666666666667, 1.2, 0.2
2937, 1.9333333333333, 1.2, 0.2
2938, 2, 1.2, 0.2
2939, 2.0666666666667, 1.2, 0.2
2940, 2.1333333333333, 1.2, 0.2
2941, 1.2666666666667, 1.2, 0.23333333333333
2942, 1.3333333333333, 1.2, 0.23333333333333
2943, 1.4, 1.2, 0.23333333333333
2944, 1.4666666666667, 1.2, 0.23333333333333
2945, 1.5333333333333, 1.2, 0.23333333333333
2946, 1.6, 1.2, 0.23333333333333
2947, 1.6666666666667, 1.2, 0.23333333333333
2948, 1.7333333333333, 1.2, 0.23333333333333
2949, 1.8, 1.2, 0.23333333333333
2950, 1.8666666666667, 1.2, 0.23333333333333
2951, 1.9333333333333, 1.2, 0.23333333333333
2952, 2, 1.2, 0.23333333333333
2953, 2.0666666666667, 1.2, 0.23333333333333
2954, 2.1333333333333, 1.2, 0.23333333333333
2955, 1.2666666666667, 1.2, 0.26666666666667
2956, 1.3333333333333, 1.2, 0.26666666666667
2957, 1.4, 1.2, 0.26666666666667
2958, 1.4666666666667, 1.2, 0.26666666666667
2959, 1.5333333333333, 1.2, 0.26666666666667
2960, 1.6, 1.2, 0.26666666666667
2961, 1.6666666666667, 1.2, 0.26666666666667
2962, 1.7333333333333, 1.2, 0.26666666666667
2963, 1.8, 1.2, 0.26666666666667
2964, 1.8666666666667, 1.2, 0.26666666666667
2965, 1.9333333333333, 1.2, 0.26666666666667
2966, 2, 1.2, 0.26666666666667
2967, 2.0666666666667, 1.2, 0.26666666666667
2968, 2.1333333333333, 1.2, 0.26666666666667
2969, 1.2666666666667, 1.2, 0.3
2970, 1.3333333333333, 1.2, 0.3
2971, 1.4, 1.2, 0.3
2972, 1.4666666666667, 1.2, 0.3
2973, 1.5333333333333, 1.2, 0.3
2974, 1.6, 1.2, 0.3
2975, 1.6666666666667, 1.2, 0.3
2976, 1.7333333333333, 1.2, 0.3
2977, 1.8, 1.2, 0.3
2978, 1.8666666666667, 1.2, 0.3
2979, 1.9333333333333, 1.2, 0.3
2980, 2, 1.2, 0.3
2981, 2.0666666666667, 1.2, 0.3
2982, 2.1333333333333, 1.2, 0.3
2983, 1.2666666666667, 1.2, 0.33333333333333
2984, 1.3333333333333, 1.2, 0.33333333333333
2985, 1.4, 1.2, 0.33333333333333
2986, 1.4666666666667, 1.2, 0.33333333333333
2987, 1.5333333333333, 1.2, 0.33333333333333
2988, 1.6, 1.2, 0.33333333333333
2989, 1.6666666666667, 1.2, 0.33333333333333
2990, 1.7333333333333, 1.2, 0.33333333333333
2991, 1.8, 1.2, 0.33333333333333
2992, 1.8666666666667, 1.2, 0.33333333333333
2993, 1.9333333333333, 1.2, 0.33333333333333
2994, 2, 1.2, 0.33333333333333
2995, 2.0666666666667, 1.2, 0.33333333333333
2996, 2.1333333333333, 1.2, 0.33333333333333
2997, 1.2666666666667, 1.2, 0.36666666666667
2998, 1.3333333333333, 1.2, 0.36666666666667
2999, 1.4, 1.2, 0.36666666666667
3000, 1.4666666666667, 1.2, 0.36666666666667
3001, 1.5333333333333, 1.2, 0.36666666666667
3002, 1.6, 1.2, 0.36666666666667
3003, 1.6666666666667, 1.2, 0.36666666666667
3004, 1.7333333333333, 1.2, 0.36666666666667
3005, 1.8, 1.2, 0.36666666666667
3006, 1.8666666666667, 1.2, 0.36666666666667
3007, 1.9333333333333, 1.2, 0.36666666666667
3008, 2, 1.2, 0.36666666666667
3009, 2.0666666666667, 1.2, 0.36666666666667
3010, 2.1333333333333, 1.2, 0.36666666666667
3011, 1.2666666666667, 1.2, 0.4
3012, 1.3333333333333, 1.2, 0.4
3013, 1.4, 1.2, 0.4
3014, 1.4666666666667, 1.2, 0.4
3015, 1.5333333333333, 1.2, 0.4
3016, 1.6, 1.2, 0.4
3017, 1.6666666666667, 1.2, 0.4
3018, 1.7333333333333, 1.2, 0.4
3019, 1.8, 1.2, 0.4
3020, 1.8666666666667, 1.2, 0.4
3021, 1.9333333333333, 1.2, 0.4
3022, 2, 1.2, 0.4
3023, 2.0666666666667, 1.2, 0.4
3024, 2.1333333333333, 1.2, 0.4
3025, 1.2666666666667, 1.2, 0.43333333333333
3026, 1.3333333333333, 1.2, 0.43333333333333
3027, 1.4, 1.2, 0.43333333333333
3028, 1.4666666666667, 1.2, 0.43333333333333
3029, 1.5333333333333, 1.2, 0.43333333333333
3030, 1.6, 1.2, 0.43333333333333
3031, 1.6666666666667, 1.2, 0.43333333333333
3032, 1.7333333333333, 1.2, 0.43333333333333
3033, 1.8, 1.2, 0.43333333333333
3034, 1.8666666666667, 1.2, 0.43333333333333
3035, 1.9333333333333, 1.2, 0.43333333333333
3036, 2, 1.2, 0.43333333333333
3037, 2.0666666666667, 1.2, 0.43333333333333
3038, 2.1333333333333, 1.2, 0.43333333333333
3039, 1.2666666666667, 1.2, 0.46666666666667
3040, 1.3333333333333, 1.2, 0.46666666666667
3041, 1.4, 1.2, 0.46666666666667
3042, 1.4666666666667, 1.2, 0.46666666666667
3043, 1.5333333333333, 1.2, 0.46666666666667
3044, 1.6, 1.2, 0.46666666666667
3045, 1.6666666666667, 1.2, 0.46666666666667
3046, 1.7333333333333, 1.2, 0.46666666666667
3047, 1.8, 1.2, 0.46666666666667
3048, 1.8666666666667, 1.2, 0.46666666666667
3049, 1.9333333333333, 1.2, 0.46666666666667
3050, 2, 1.2, 0.46666666666667
3051, 2.0666666666667, 1.2, 0.46666666666667
3052, 2.1333333333333, 1.2, 0.46666666666667
3053, 1.2666666666667, 1.4, 0.033333333333333
3054, 1.3333333333333, 1.4, 0.033333333333333
3055, 1.4, 1.4, 0.033333333333333
3056, 1.4666666666667, 1.4, 0.033333333333333
3057, 1.5333333333333, 1.4, 0.033333333333333
3058, 1.6, 1.4, 0.033333333333333
3059, 1.6666666666667, 1.4, 0.033333333333333
3060, 1.7333333333333, 1.4, 0.033333333333333
3061, 1.8, 1.4, 0.033333333333333
3062, 1.8666666666667, 1.4, 0.033333333333333
3063, 1.9333333333333, 1.4, 0.033333333333333
3064, 2, 1.4, 0.033333333333333
3065, 2.0666666666667, 1.4, 0.033333333333333
3066, 2.1333333333333, 1.4, 0.033333333333333
3067, 1.2666666666667, 1.4, 0.066666666666667
3068, 1.3333333333333, 1.4, 0.066666666666667
3069, 1.4, 1.4, 0.066666666666667
3070, 1.4666666666667, 1.4, 0.066666666666667
3071, 1.5333333333333, 1.4, 0.066666666666667
3072, 1.6, 1.4, 0.066666666666667
3073, 1.6666666666667, 1.4, 0.066666666666667
3074, 1.7333333333333, 1.4, 0.066666666666667
3075, 1.8, 1.4, 0.066666666666667
3076, 1.8666666666667, 1.4, 0.066666666666667
3077, 1.9333333333333, 1.4, 0.066666666666667
3078, 2, 1.4, 0.066666666666667
3079, 2.0666666666667, 1.4, 0.066666666666667
3080, 2.1333333333333, 1.4, 0.066666666666667
3081, 1.2666666666667, 1.4, 0.1
3082, 1.3333333333333, 1.4, 0.1
3083, 1.4, 1.4, 0.1
3084, 1.4666666666667, 1.4, 0.1
3085, 1.5333333333333, 1.4, 0.1
3086, 1.6, 1.4, 0.1
3087, 1.6666666666667, 1.4, 0.1
3088, 1.7333333333333, 1.4, 0.1
3089, 1.8, 1.4, 0.1
3090, 1.8666666666667, 1.4, 0.1
3091, 1.9333333333333, 1.4, 0.1
3092, 2, 1.4, 0.1
3093, 2.0666666666667, 1.4, 0.1
3094, 2.1333333333333, 1.4, 0.1
3095, 1.2666666666667, 1.4, 0.13333333333333
3096, 1.3333333333333, 1.4, 0.13333333333333
3097, 1.4, 1.4, 0.13333333333333
3098, 1.4666666666667, 1.4, 0.13333333333333
3099, 1.5333333333333, 1.4, 0.13333333333333
3100, 1.6, 1.4, 0.13333333333333
3101, 1.6666666666667, 1.4, 0.13333333333333
3102, 1.7333333333333, 1.4, 0.13333333333333
3103, 1.8, 1.4, 0.13333333333333
3104, 1.8666666666667, 1.4, 0.13333333333333
3105, 1.9333333333333, 1.4, 0.13333333333333
3106, 2, 1.4, 0.13333333333333
3107, 2.0666666666667, 1.4, 0.13333333333333
3108, 2.1333333333333, 1.4, 0.13333333333333
3109, 1.2666666666667, 1.4, 0.16666666666667
3110, 1.3333333333333, 1.4, 0.16666666666667
3111, 1.4, 1.4, 0.16666666666667
3112, 1.4666666666667, 1.4, 0.16666666666667
3113, 1.5333333333333, 1.4, 0.16666666666667
3114, 1.6, 1.4, 0.16666666666667
3115, 1.6666666666667, 1.4, 0.16666666666667
3116, 1.7333333333333, 1.4, 0.16666666666667
3117, 1.8, 1.4, 0.16666666666667
3118, 1.8666666666667, 1.4, 0.16666666666667
3119, 1.9333333333333, 1.4, 0.16666666666667
3120, 2, 1.4, 0.16666666666667
3121, 2.0666666666667, 1.4, 0.16666666666667
3122, 2.1333333333333, 1.4, 0.16666666666667
3123, 1.2666666666667, 1.4, 0.2
3124, 1.3333333333333, 1.4, 0.2
3125, 1.4, 1.4, 0.2
3126, 1.4666666666667, 1.4, 0.2
3127, 1.5333333333333, 1.4, 0.2
3128, 1.6, 1.4, 0.2
3129, 1.6666666666667, 1.4, 0.2
3130, 1.7333333333333, 1.4, 0.2
3131, 1.8, 1.4, 0.2
3132, 1.8666666666667, 1.4, 0.2
3133, 1.9333333333333, 1.4, 0.2
3134, 2, 1.4, 0.2
3135, 2.0666666666667, 1.4, 0.2
3136, 2.1333333333333, 1.4, 0.2
3137, 1.2666666666667, 1.4, 0.23333333333333
3138, 1.3333333333333, 1.4, 0.23333333333333
3139, 1.4, 1.4, 0.23333333333333
3140, 1.4666666666667, 1.4, 0.23333333333333
3141, 1.5333333333333, 1.4, 0.23333333333333
3142, 1.6, 1.4, 0.23333333333333
3143, 1.6666666666667, 1.4, 0.23333333333333
3144, 1.7333333333333, 1.4, 0.23333333333333
3145, 1.8, 1.4, 0.23333333333333
3146, 1.8666666666667, 1.4, 0.23333333333333
3147, 1.9333333333333, 1.4, 0.23333333333333
3148, 2, 1.4, 0.23333333333333
3149, 2.0666666666667, 1.4, 0.23333333333333
3150, 2.1333333333333, 1.4, 0.23333333333333
3151, 1.2666666666667, 1.4, 0.26666666666667
3152, 1.3333333333333, 1.4, 0.26666666666667
3153, 1.4, 1.4, 0.26666666666667
3154, 1.4666666666667, 1.4, 0.26666666666667
3155, 1.5333333333333, 1.4, 0.26666666666667
3156, 1.6, 1.4, 0.26666666666667
3157, 1.6666666666667, 1.4, 0.26666666666667
3158, 1.7333333333333, 1.4, 0.26666666666667
3159, 1.8, 1.4, 0.26666666666667
3160, 1.8666666666667, 1.4, 0.26666666666667
3161, 1.9333333333333, 1.4, 0.26666666666667
3162, 2, 1.4, 0.26666666666667
3163, 2.0666666666667, 1.4, 0.26666666666667
3164, 2.1333333333333, 1.4, 0.26666666666667
3165, 1.2666666666667, 1.4, 0.3
3166, 1.3333333333333, 1.4, 0.3
3167, 1.4, 1.4, 0.3
3168, 1.4666666666667, 1.4, 0.3
3169, 1.5333333333333, 1.4, 0.3
3170, 1.6, 1.4, 0.3
3171, 1.6666666666667, 1.4, 0.3
3172, 1.7333333333333, 1.4, 0.3
3173, 1.8, 1.4, 0.3
3174, 1.8666666666667, 1.4, 0.3
3175, 1.9333333333333, 1.4, 0.3
3176, 2, 1.4, 0.3
3177, 2.0666666666667, 1.4, 0.3
3178, 2.1333333333333, 1.4, 0.3
3179, 1.2666666666667, 1.4, 0.33333333333333
3180, 1.3333333333333, 1.4, 0.33333333333333
3181, 1.4, 1.4, 0.33333333333333
3182, 1.4666666666667, 1.4, 0.33333333333333
3183, 1.5333333333333, 1.4, 0.33333333333333
3184, 1.6, 1.4, 0.33333333333333
3185, 1.6666666666667, 1.4, 0.33333333333333
3186, 1.7333333333333, 1.4, 0.33333333333333
3187, 1.8, 1.4, 0.33333333333333
3188, 1.8666666666667, 1.4, 0.33333333333333
3189, 1.9333333333333, 1.4, 0.33333333333333
3190, 2, 1.4, 0.33333333333333
3191, 2.0666666666667, 1.4, 0.33333333333333
3192, 2.1333333333333, 1.4, 0.33333333333333
3193, 1.2666666666667, 1.4, 0.36666666666667
3194, 1.3333333333333, 1.4, 0.36666666666667
3195, 1.4, 1.4, 0.36666666666667
3196, 1.4666666666667, 1.4, 0.36666666666667
3197, 1.5333333333333, 1.4, 0.36666666666667
3198, 1.6, 1.4, 0.36666666666667
3199, 1.6666666666667, 1.4, 0.36666666666667
3200, 1.7333333333333, 1.4, 0.36666666666667
3201, 1.8, 1.4, 0.36666666666667
3202, 1.8666666666667, 1.4, 0.36666666666667
3203, 1.9333333333333, 1.4, 0.36666666666667
3204, 2, 1.4, 0.36666666666667
3205, 2.0666666666667, 1.4, 0.36666666666667
3206, 2.1333333333333, 1.4, 0.36666666666667
3207, 1.2666666666667, 1.4, 0.4
3208, 1.3333333333333, 1.4, 0.4
3209, 1.4, 1.4, 0.4
3210, 1.4666666666667, 1.4, 0.4
3211, 1.5333333333333, 1.4, 0.4
3212, 1.6, 1.4, 0.4
3213, 1.6666666666667, 1.4, 0.4
3214, 1.7333333333333, 1.4, 0.4
3215, 1.8, 1.4, 0.4
3216, 1.8666666666667, 1.4, 0.4
3217, 1.9333333333333, 1.4, 0.4
3218, 2, 1.4, 0.4
3219, 2.0666666666667, 1.4, 0.4
3220, 2.1333333333333, 1.4, 0.4
3221, 1.2666666666667, 1.4, 0.43333333333333
3222, 1.3333333333333, 1.4, 0.43333333333333
3223, 1.4, 1.4, 0.43333333333333
3224, 1.4666666666667, 1.4, 0.43333333333333
3225, 1.5333333333333, 1.4, 0.43333333333333
3226, 1.6, 1.4, 0.43333333333333
3227, 1.6666666666667, 1.4, 0.43333333333333
3228, 1.7333333333333, 1.4, 0.43333333333333
3229, 1.8, 1.4, 0.43333333333333
3230, 1.8666666666667, 1.4, 0.43333333333333
3231, 1.9333333333333, 1.4, 0.43333333333333
3232, 2, 1.4, 0.43333333333333
3233, 2.0666666666667, 1.4, 0.43333333333333
3234, 2.1333333333333, 1.4, 0.43333333333333
3235, 1.2666666666667, 1.4, 0.46666666666667
3236, 1.3333333333333, 1.4, 0.46666666666667
3237, 1.4, 1.4, 0.46666666666667
3238, 1.4666666666667, 1.4, 0.46666666666667
3239, 1.5333333333333, 1.4, 0.46666666666667
3240, 1.6, 1.4, 0.46666666666667
3241, 1.6666666666667, 1.4, 0.46666666666667
3242, 1.7333333333333, 1.4, 0.46666666666667
3243, 1.8, 1.4, 0.46666666666667
3244, 1.8666666666667, 1.4, 0.46666666666667
3245, 1.9333333333333, 1.4, 0.46666666666667
3246, 2, 1.4, 0.46666666666667
3247, 2.0666666666667, 1.4, 0.46666666666667
3248, 2.1333333333333, 1.4, 0.46666666666667
3249, 1.2666666666667, 1.1, 0.033333333333333
3250, 1.3333333333333, 1.1, 0.033333333333333
3251, 1.4, 1.1, 0.033333333333333
3252, 1.4666666666667, 1.1, 0.033333333333333
3253, 1.5333333333333, 1.1, 0.033333333333333
3254, 1.6, 1.1, 0.033333333333333
3255, 1.6666666666667, 1.1, 0.033333333333333
3256, 1.7333333333333, 1.1, 0.033333333333333
3257, 1.8, 1.1, 0.033333333333333
3258, 1.8666666666667, 1.1, 0.033333333333333
3259, 1.9333333333333, 1.1, 0.033333333333333
3260, 2, 1.1, 0.033333333333333
3261, 2.0666666666667, 1.1, 0.033333333333333
3262, 2.1333333333333, 1.1, 0.033333333333333
3263, 1.2666666666667, 1.1, 0.066666666666667
3264, 1.3333333333333, 1.1, 0.066666666666667
3265, 1.4, 1.1, 0.066666666666667
3266, 1.4666666666667, 1.1, 0.066666666666667
3267, 1.5333333333333, 1.1, 0.066666666666667
3268, 1.6, 1.1, 0.066666666666667
3269, 1.6666666666667, 1.1, 0.066666666666667
3270, 1.7333333333333, 1.1, 0.066666666666667
3271, 1.8, 1.1, 0.066666666666667
3272, 1.8666666666667, 1.1, 0.066666666666667
3273, 1.9333333333333, 1.1, 0.066666666666667
3274, 2, 1.1, 0.066666666666667
3275, 2.0666666666667, 1.1, 0.066666666666667
3276, 2.1333333333333, 1.1, 0.066666666666667
3277, 1.2666666666667, 1.1, 0.1
3278, 1.3333333333333, 1.1, 0.1
3279, 1.4, 1.1, 0.1
3280, 1.4666666666667, 1.1, 0.1
3281, 1.5333333333333, 1.1, 0.1
3282, 1.6, 1.1, 0.1
3283, 1.6666666666667, 1.1, 0.1
3284, 1.7333333333333, 1.1, 0.1
3285, 1.8, 1.1, 0.1
3286, 1.8666666666667, 1.1, 0.1
3287, 1.9333333333333, 1.1, 0.1
3288, 2, 1.1, 0.1
3289, 2.0666666666667, 1.1, 0.1
3290, 2.1333333333333, 1.1, 0.1
3291, 1.2666666666667, 1.1, 0.13333333333333
3292, 1.3333333333333, 1.1, 0.13333333333333
3293, 1.4, 1.1, 0.13333333333333
3294, 1.4666666666667, 1.1, 0.13333333333333
3295, 1.5333333333333, 1.1, 0.13333333333333
3296, 1.6, 1.1, 0.13333333333333
3297, 1.6666666666667, 1.1, 0.13333333333333
3298, 1.7333333333333, 1.1, 0.13333333333333
3299, 1.8, 1.1, 0.13333333333333
3300, 1.8666666666667, 1.1, 0.13333333333333
3301, 1.9333333333333, 1.1, 0.13333333333333
3302, 2, 1.1, 0.13333333333333
3303, 2.0666666666667, 1.1, 0.13333333333333
3304, 2.1333333333333, 1.1, 0.13333333333333
3305, 1.2666666666667, 1.1, 0.16666666666667
3306, 1.3333333333333, 1.1, 0.16666666666667
3307, 1.4, 1.1, 0.16666666666667
3308, 1.4666666666667, 1.1, 0.16666666666667
3309, 1.5333333333333, 1.1, 0.16666666666667
3310, 1.6, 1.1, 0.16666666666667
3311, 1.6666666666667, 1.1, 0.16666666666667
3312, 1.7333333333333, 1.1, 0.16666666666667
3313, 1.8, 1.1, 0.16666666666667
3314, 1.8666666666667, 1.1, 0.16666666666667
3315, 1.9333333333333, 1.1, 0.16666666666667
3316, 2, 1.1, 0.16666666666667
3317, 2.0666666666667, 1.1, 0.16666666666667
3318, 2.1333333333333, 1.1, 0.16666666666667
3319, 1.2666666666667, 1.1, 0.2
3320, 1.3333333333333, 1.1, 0.2
3321, 1.4, 1.1, 0.2
3322, 1.4666666666667, 1.1, 0.2
3323, 1.5333333333333, 1.1, 0.2
3324, 1.6, 1.1, 0.2
3325, 1.6666666666667, 1.1, 0.2
3326, 1.7333333333333, 1.1, 0.2
3327, 1.8, 1.1, 0.2
3328, 1.8666666666667, 1.1, 0.2
3329, 1.9333333333333, 1.1, 0.2
3330, 2, 1.1, 0.2
3331, 2.0666666666667, 1.1, 0.2
3332, 2.1333333333333, 1.1, 0.2
3333, 1.2666666666667, 1.1, 0.23333333333333
3334, 1.3333333333333, 1.1, 0.23333333333333
3335, 1.4, 1.1, 0.23333333333333
3336, 1.4666666666667, 1.1, 0.23333333333333
3337, 1.5333333333333, 1.1, 0.23333333333333
3338, 1.6, 1.1, 0.23333333333333
3339, 1.6666666666667, 1.1, 0.23333333333333
3340, 1.7333333333333, 1.1, 0.23333333333333
3341, 1.8, 1.1, 0.23333333333333
3342, 1.8666666666667, 1.1, 0.23333333333333
3343, 1.9333333333333, 1.1, 0.23333333333333
3344, 2, 1.1, 0.23333333333333
3345, 2.0666666666667, 1.1, 0.23333333333333
3346, 2.1333333333333, 1.1, 0.23333333333333
3347, 1.2666666666667, 1.1, 0.26666666666667
3348, 1.3333333333333, 1.1, 0.26666666666667
3349, 1.4, 1.1, 0.26666666666667
3350, 1.4666666666667, 1.1, 0.26666666666667
3351, 1.5333333333333, 1.1, 0.26666666666667
3352, 1.6, 1.1, 0.26666666666667
3353, 1.6666666666667, 1.1, 0.26666666666667
3354, 1.7333333333333, 1.1, 0.26666666666667
3355, 1.8, 1.1, 0.26666666666667
3356, 1.8666666666667, 1.1, 0.26666666666667
3357, 1.9333333333333, 1.1, 0.26666666666667
3358, 2, 1.1, 0.26666666666667
3359, 2.0666666666667, 1.1, 0.26666666666667
3360, 2.1333333333333, 1.1, 0.26666666666667
3361, 1.2666666666667, 1.1, 0.3
3362, 1.3333333333333, 1.1, 0.3
3363, 1.4, 1.1, 0.3
3364, 1.4666666666667, 1.1, 0.3
3365, 1.5333333333333, 1.1, 0.3
3366, 1.6, 1.1, 0.3
3367, 1.6666666666667, 1.1, 0.3
3368, 1.7333333333333, 1.1, 0.3
3369, 1.8, 1.1, 0.3
3370, 1.8666666666667, 1.1, 0.3
3371, 1.9333333333333, 1.1, 0.3
3372, 2, 1.1, 0.3
3373, 2.0666666666667, 1.1, 0.3
3374, 2.1333333333333, 1.1, 0.3
3375, 1.2666666666667, 1.1, 0.33333333333333
3376, 1.3333333333333, 1.1, 0.33333333333333
3377, 1.4, 1.1, 0.33333333333333
3378, 1.4666666666667, 1.1, 0.33333333333333
3379, 1.5333333333333, 1.1, 0.33333333333333
3380, 1.6, 1.1, 0.33333333333333
3381, 1.6666666666667, 1.1, 0.33333333333333
3382, 1.7333333333333, 1.1, 0.33333333333333
3383, 1.8, 1.1, 0.33333333333333
3384, 1.8666666666667, 1.1, 0.33333333333333
3385, 1.9333333333333, 1.1, 0.33333333333333
3386, 2, 1.1, 0.33333333333333
3387, 2.0666666666667, 1.1, 0.33333333333333
3388, 2.1333333333333, 1.1, 0.33333333333333
3389, 1.2666666666667, 1.1, 0.36666666666667
3390, 1.3333333333333, 1.1, 0.36666666666667
3391, 1.4, 1.1, 0.36666666666667
3392, 1.4666666666667, 1.1, 0.36666666666667
3393, 1.5333333333333, 1.1, 0.36666666666667
3394, 1.6, 1.1, 0.36666666666667
3395, 1.6666666666667, 1.1, 0.36666666666667
3396, 1.7333333333333, 1.1, 0.36666666666667
3397, 1.8, 1.1, 0.36666666666667
3398, 1.8666666666667, 1.1, 0.36666666666667
3399, 1.9333333333333, 1.1, 0.36666666666667
3400, 2, 1.1, 0.36666666666667
3401, 2.0666666666667, 1.1, 0.36666666666667
3402, 2.1333333333333, 1.1, 0.36666666666667
3403, 1.2666666666667, 1.1, 0.4
3404, 1.3333333333333, 1.1, 0.4
3405, 1.4, 1.1, 0.4
3406, 1.4666666666667, 1.1, 0.4
3407, 1.5333333333333, 1.1, 0.4
3408, 1.6, 1.1, 0.4
3409, 1.6666666666667, 1.1, 0.4
3410, 1.7333333333333, 1.1, 0.4
3411, 1.8, 1.1, 0.4
3412, 1.8666666666667, 1.1, 0.4
3413, 1.9333333333333, 1.1, 0.4
3414, 2, 1.1, 0.4
3415, 2.0666666666667, 1.1, 0.4
3416, 2.1333333333333, 1.1, 0.4
3417, 1.2666666666667, 1.1, 0.43333333333333
3418, 1.3333333333333, 1.1, 0.43333333333333
3419, 1.4, 1.1, 0.43333333333333
3420, 1.4666666666667, 1.1, 0.43333333333333
3421, 1.5333333333333, 1.1, 0.43333333333333
3422, 1.6, 1.1, 0.43333333333333
3423, 1.6666666666667, 1.1, 0.43333333333333
3424, 1.7333333333333, 1.1, 0.43333333333333
3425, 1.8, 1.1, 0.43333333333333
3426, 1.8666666666667, 1.1, 0.43333333333333
3427, 1.9333333333333, 1.1, 0.43333333333333
3428, 2, 1.1, 0.43333333333333
3429, 2.0666666666667, 1.1, 0.43333333333333
3430, 2.1333333333333, 1.1, 0.43333333333333
3431, 1.2666666666667, 1.1, 0.46666666666667
3432, 1.3333333333333, 1.1, 0.46666666666667
3433, 1.4, 1.1, 0.46666666666667
3434, 1.4666666666667, 1.1, 0.46666666666667
3435, 1.5333333333333, 1.1, 0.46666666666667
3436, 1.6, 1.1, 0.46666666666667
3437, 1.6666666666667, 1.1, 0.46666666666667
3438, 1.7333333333333, 1.1, 0.46666666666667
3439, 1.8, 1.1, 0.46666666666667
3440, 1.8666666666667, 1.1, 0.46666666666667
3441, 1.9333333333333, 1.1, 0.46666666666667
3442, 2, 1.1, 0.46666666666667
3443, 2.0666666666667, 1.1, 0.46666666666667
3444, 2.1333333333333, 1.1, 0.46666666666667
3445, 1.2666666666667, 1.0466666666667, 0.5
3446, 1.2666666666667, 0.99333333333333, 0.5
3447, 1.2666666666667, 0.94, 0.5
3448, 1.2666666666667, 0.88666666666667, 0.5
3449, 1.2666666666667, 0.83333333333333, 0.5
3450, 1.2666666666667, 0.78, 0.5
3451, 1.2666666666667, 0.72666666666667, 0.5
3452, 1.2666666666667, 0.67333333333333, 0.5
3453, 1.2666666666667, 0.62, 0.5
3454, 1.2666666666667, 0.56666666666667, 0.5
3455, 1.2666666666667, 0.51333333333333, 0.5
3456, 1.2666666666667, 0.46, 0.5
3457, 1.2666666666667, 0.40666666666667, 0.5
3458, 1.2666666666667, 0.35333333333333, 0.5
3459, 1.3333333333333, 1.0466666666667, 0.5
3460, 1.3333333333333, 0.99333333333333, 0.5
3461, 1.3333333333333, 0.94, 0.5
3462, 1.3333333333333, 0.88666666666667, 0.5
3463, 1.3333333333333, 0.83333333333333, 0.5
3464, 1.3333333333333, 0.78, 0.5
3465, 1.3333333333333, 0.72666666666667, 0.5
3466, 1.3333333333333, 0.67333333333333, 0.5
3467, 1.3333333333333, 0.62, 0.5
3468, 1.3333333333333, 0.56666666666667, 0.5
3469, 1.3333333333333, 0.51333333333333, 0.5
3470, 1.3333333333333, 0.46, 0.5
3471, 1.3333333333333, 0.40666666666667, 0.5
3472, 1.3333333333333, 0.35333333333333, 0.5
3473, 1.4, 1.0466666666667, 0.5
3474, 1.4, 0.99333333333333, 0.5
3475, 1.4, 0.94, 0.5
3476, 1.4, 0.88666666666667, 0.5
3477, 1.4, 0.83333333333333, 0.5
3478, 1.4, 0.78, 0.5
3479, 1.4, 0.72666666666667, 0.5
3480, 1.4, 0.67333333333333, 0.5
3481, 1.4, 0.62, 0.5
3482, 1.4, 0.56666666666667, 0.5
3483, 1.4, 0.51333333333333, 0.5
3484, 1.4, 0.46, 0.5
3485, 1.4, 0.40666666666667, 0.5
3486, 1.4, 0.35333333333333, 0.5
3487, 1.4666666666667, 1.0466666666667, 0.5
3488, 1.4666666666667, 0.99333333333333, 0.5
3489, 1.4666666666667, 0.94, 0.5
3490, 1.4666666666667, 0.88666666666667, 0.5
3491, 1.4666666666667, 0.83333333333333, 0.5
3492, 1.4666666666667, 0.78, 0.5
3493, 1.4666666666667, 0.72666666666667, 0.5
3494, 1.4666666666667, 0.67333333333333, 0.5
3495, 1.4666666666667, 0.62, 0.5
3496, 1.4666666666667, 0.56666666666667, 0.5
3497, 1.4666666666667, 0.51333333333333, 0.5
3498, 1.4666666666667, 0.46, 0.5
3499, 1.4666666666667, 0.40666666666667, 0.5
3500, 1.4666666666667, 0.35333333333333, 0.5
3501, 1.5333333333333, 1.0466666666667, 0.5
3502, 1.5333333333333, 0.99333333333333, 0.5
3503, 1.5333333333333, 0.94, 0.5
3504, 1.5333333333333, 0.88666666666667, 0.5
3505, 1.5333333333333, 0.83333333333333, 0.5
3506, 1.5333333333333, 0.78, 0.5
3507, 1.5333333333333, 0.72666666666667, 0.5
3508, 1.5333333333333, 0.67333333333333, 0.5
3509, 1.5333333333333, 0.62, 0.5
3510, 1.5333333333333, 0.56666666666667, 0.5
3511, 1.5333333333333, 0.51333333333333, 0.5
3512, 1.5333333333333, 0.46, 0.5
3513, 1.5333333333333, 0.40666666666667, 0.5
3514, 1.5333333333333, 0.35333333333333, 0.5
3515, 1.6, 1.0466666666667, 0.5
3516, 1.6, 0.99333333333333, 0.5
3517, 1.6, 0.94, 0.5
3518, 1.6, 0.88666666666667, 0.5
3519, 1.6, 0.83333333333333, 0.5
3520, 1.6, 0.78, 0.5
3521, 1.6, 0.72666666666667, 0.5
3522, 1.6, 0.67333333333333, 0.5
3523, 1.6, 0.62, 0.5
3524, 1.6, 0.56666666666667, 0.5
3525, 1.6, 0.51333333333333, 0.5
3526, 1.6, 0.46, 0.5
3527, 1.6, 0.40666666666667, 0.5
3528, 1.6, 0.35333333333333, 0.5
3529, 1.6666666666667, 1.0466666666667, 0.5
3530, 1.6666666666667, 0.99333333333333, 0.5
3531, 1.6666666666667, 0.94, 0.5
3532, 1.6666666666667, 0.88666666666667, 0.5
3533, 1.6666666666667, 0.83333333333333, 0.5
3534, 1.6666666666667, 0.78, 0.5
3535, 1.6666666666667, 0.72666666666667, 0.5
3536, 1.6666666666667, 0.67333333333333, 0.5
3537, 1.6666666666667, 0.62, 0.5
3538, 1.6666666666667, 0.56666666666667, 0.5
3539, 1.6666666666667, 0.51333333333333, 0.5
3540, 1.6666666666667, 0.46, 0.5
3541, 1.6666666666667, 0.40666666666667, 0.5
3542, 1.6666666666667, 0.35333333333333, 0.5
3543, 1.7333333333333, 1.0466666666667, 0.5
3544, 1.7333333333333, 0.99333333333333, 0.5
3545, 1.7333333333333, 0.94, 0.5
3546, 1.7333333333333, 0.88666666666667, 0.5
3547, 1.7333333333333, 0.83333333333333, 0.5
3548, 1.7333333333333, 0.78, 0.5
3549, 1.7333333333333, 0.72666666666667, 0.5
3550, 1.7333333333333, 0.67333333333333, 0.5
3551, 1.7333333333333, 0.62, 0.5
3552, 1.7333333333333, 0.56666666666667, 0.5
3553, 1.7333333333333, 0.51333333333333, 0.5
3554, 1.7333333333333, 0.46, 0.5
3555, 1.7333333333333, 0.40666666666667, 0.5
3556, 1.7333333333333, 0.35333333333333, 0.5
3557, 1.8, 1.0466666666667, 0.5
3558, 1.8, 0.99333333333333, 0.5
3559, 1.8, 0.94, 0.5
3560, 1.8, 0.88666666666667, 0.5
3561, 1.8, 0.83333333333333, 0.5
3562, 1.8, 0.78, 0.5
3563, 1.8, 0.72666666666667, 0.5
3564, 1.8, 0.67333333333333, 0.5
3565, 1.8, 0.62, 0.5
3566, 1.8, 0.56666666666667, 0.5
3567, 1.8, 0.51333333333333, 0.5
3568, 1.8, 0.46, 0.5
3569, 1.8, 0.40666666666667, 0.5
3570, 1.8, 0.35333333333333, 0.5
3571, 1.8666666666667, 1.0466666666667, 0.5
3572, 1.8666666666667, 0.99333333333333, 0.5
3573, 1.8666666666667, 0.94, 0.5
3574, 1.8666666666667, 0.88666666666667, 0.5
3575, 1.8666666666667, 0.83333333333333, 0.5
3576, 1.8666666666667, 0.78, 0.5
3577, 1.8666666666667, 0.72666666666667, 0.5
3578, 1.8666666666667, 0.67333333333333, 0.5
3579, 1.8666666666667, 0.62, 0.5
3580, 1.8666666666667, 0.56666666666667, 0.5
3581, 1.8666666666667, 0.51333333333333, 0.5
3582, 1.8666666666667, 0.46, 0.5
3583, 1.8666666666667, 0.40666666666667, 0.5
3584, 1.8666666666667, 0.35333333333333, 0.5
3585, 1.9333333333333, 1.0466666666667, 0.5
3586, 1.9333333333333, 0.99333333333333, 0.5
3587, 1.9333333333333, 0.94, 0.5
3588, 1.9333333333333, 0.88666666666667, 0.5
3589, 1.9333333333333, 0.83333333333333, 0.5
3590, 1.9333333333333, 0.78, 0.5
3591, 1.9333333333333, 0.72666666666667, 0.5
3592, 1.9333333333333, 0.67333333333333, 0.5
3593, 1.9333333333333, 0.62, 0.5
3594, 1.9333333333333, 0.56666666666667, 0.5
3595, 1.9333333333333, 0.51333333333333, 0.5
3596, 1.9333333333333, 0.46, 0.5
3597, 1.9333333333333, 0.40666666666667, 0.5
3598, 1.9333333333333, 0.35333333333333, 0.5
3599, 2, 1.0466666666667, 0.5
3600, 2, 0.99333333333333, 0.5
3601, 2, 0.94, 0.5
3602, 2, 0.88666666666667, 0.5
3603, 2, 0.83333333333333, 0.5
3604, 2, 0.78, 0.5
3605, 2, 0.72666666666667, 0.5
3606, 2, 0.67333333333333, 0.5
3607, 2, 0.62, 0.5
3608, 2, 0.56666666666667, 0.5
3609, 2, 0.51333333333333, 0.5
3610, 2, 0.46, 0.5
3611, 2, 0.40666666666667, 0.5
3612, 2, 0.35333333333333, 0.5
3613, 2.0666666666667, 1.0466666666667, 0.5
3614, 2.0666666666667, 0.99333333333333, 0.5
3615, 2.0666666666667, 0.94, 0.5
3616, 2.0666666666667, 0.88666666666667, 0.5
3617, 2.0666666666667, 0.83333333333333, 0.5
3618, 2.0666666666667, 0.78, 0.5
3619, 2.0666666666667, 0.72666666666667, 0.5
3620, 2.0666666666667, 0.67333333333333, 0.5
3621, 2.0666666666667, 0.62, 0.5
3622, 2.0666666666667, 0.56666666666667, 0.5
3623, 2.0666666666667, 0.51333333333333, 0.5
3624, 2.0666666666667, 0.46, 0.5
3625, 2.0666666666667, 0.40666666666667, 0.5
3626, 2.0666666666667, 0.35333333333333, 0.5
3627, 2.1333333333333, 1.0466666666667, 0.5
3628, 2.1333333333333, 0.99333333333333, 0.5
3629, 2.1333333333333, 0.94, 0.5
3630, 2.1333333333333, 0.88666666666667, 0.5
3631, 2.1333333333333, 0.83333333333333, 0.5
3632, 2.1333333333333, 0.78, 0.5
3633, 2.1333333333333, 0.72666666666667, 0.5
3634, 2.1333333333333, 0.67333333333333, 0.5
3635, 2.1333333333333, 0.62, 0.5
3636, 2.1333333333333, 0.56666666666667, 0.5
3637, 2.1333333333333, 0.51333333333333, 0.5
3638, 2.1333333333333, 0.46, 0.5
3639, 2.1333333333333, 0.40666666666667, 0.5
3640, 2.1333333333333, 0.35333333333333, 0.5
3641, 1.2666666666667, 1.0466666666667, 0
3642, 1.2666666666667, 0.99333333333333, 0
3643, 1.2666666666667, 0.94, 0
3644, 1.2666666666667, 0.88666666666667, 0
3645, 1.2666666666667, 0.83333333333333, 0
3646, 1.2666666666667, 0.78, 0
3647, 1.2666666666667, 0.72666666666667, 0
3648, 1.2666666666667, 0.67333333333333, 0
3649, 1.2666666666667, 0.62, 0
3650, 1.2666666666667, 0.56666666666667, 0
3651, 1.2666666666667, 0.51333333333333, 0
3652, 1.2666666666667, 0.46, 0
3653, 1.2666666666667, 0.40666666666667, 0
3654, 1.2666666666667, 0.35333333333333, 0
3655, 1.3333333333333, 1.0466666666667, 0
3656, 1.3333333333333, 0.99333333333333, 0
3657, 1.3333333333333, 0.94, 0
3658, 1.3333333333333, 0.88666666666667, 0
3659, 1.3333333333333, 0.83333333333333, 0
3660, 1.3333333333333, 0.78, 0
3661, 1.3333333333333, 0.72666666666667, 0
3662, 1.3333333333333, 0.67333333333333, 0
3663, 1.3333333333333, 0.62, 0
3664, 1.3333333333333, 0.56666666666667, 0
3665, 1.3333333333333, 0.51333333333333, 0
3666, 1.3333333333333, 0.46, 0
3667, 1.3333333333333, 0.40666666666667, 0
3668, 1.3333333333333, 0.35333333333333, 0
3669, 1.4, 1.0466666666667, 0
3670, 1.4, 0.99333333333333, 0
3671, 1.4, 0.94, 0
3672, 1.4, 0.88666666666667, 0
3673, 1.4, 0.83333333333333, 0
3674, 1.4, 0.78, 0
3675, 1.4, 0.72666666666667, 0
3676, 1.4, 0.67333333333333, 0
3677, 1.4, 0.62, 0
3678, 1.4, 0.56666666666667, 0
3679, 1.4, 0.51333333333333, 0
3680, 1.4, 0.46, 0
3681, 1.4, 0.40666666666667, 0
3682, 1.4, 0.35333333333333, 0
3683, 1.4666666666667, 1.0466666666667, 0
3684, 1.4666666666667, 0.99333333333333, 0
3685, 1.4666666666667, 0.94, 0
3686, 1.4666666666667, 0.88666666666667, 0
3687, 1.4666666666667, 0.83333333333333, 0
3688, 1.4666666666667, 0.78, 0
3689, 1.4666666666667, 0.72666666666667, 0
3690, 1.4666666666667, 0.67333333333333, 0
3691, 1.4666666666667, 0.62, 0
3692, 1.4666666666667, 0.56666666666667, 0
3693, 1.4666666666667, 0.51333333333333, 0
3694, 1.4666666666667, 0.46, 0
3695, 1.4666666666667, 0.40666666666667, 0
3696, 1.4666666666667, 0.35333333333333, 0
3697, 1.5333333333333, 1.0466666666667, 0
3698, 1.5333333333333, 0.99333333333333, 0
3699, 1.5333333333333, 0.94, 0
3700, 1.5333333333333, 0.88666666666667, 0
3701, 1.5333333333333, 0.83333333333333, 0
3702, 1.5333333333333, 0.78, 0
3703, 1.5333333333333, 0.72666666666667, 0
3704, 1.5333333333333, 0.67333333333333, 0
3705, 1.5333333333333, 0.62, 0
3706, 1.5333333333333, 0.56666666666667, 0
3707, 1.5333333333333, 0.51333333333333, 0
3708, 1.5333333333333, 0.46, 0
3709, 1.5333333333333, 0.40666666666667, 0
3710, 1.5333333333333, 0.35333333333333, 0
3711, 1.6, 1.0466666666667, 0
3712, 1.6, 0.99333333333333, 0
3713, 1.6, 0.94, 0
3714, 1.6, 0.88666666666667, 0
3715, 1.6, 0.83333333333333, 0
3716, 1.6, 0.78, 0
3717, 1.6, 0.72666666666667, 0
3718, 1.6, 0.67333333333333, 0
3719, 1.6, 0.62, 0
3720, 1.6, 0.56666666666667, 0
3721, 1.6, 0.51333333333333, 0
3722, 1.6, 0.46, 0
3723, 1.6, 0.40666666666667, 0
3724, 1.6, 0.35333333333333, 0
3725, 1.6666666666667, 1.0466666666667, 0
3726, 1.6666666666667, 0.99333333333333, 0
3727, 1.6666666666667, 0.94, 0
3728, 1.6666666666667, 0.88666666666667, 0
3729, 1.6666666666667, 0.83333333333333, 0
3730, 1.6666666666667, 0.78, 0
3731, 1.6666666666667, 0.72666666666667, 0
3732, 1.6666666666667, 0.67333333333333, 0
3733, 1.6666666666667, 0.62, 0
3734, 1.6666666666667, 0.56666666666667, 0
3735, 1.6666666666667, 0.51333333333333, 0
3736, 1.6666666666667, 0.46, 0
3737, 1.6666666666667, 0.40666666666667, 0
3738, 1.6666666666667, 0.35333333333333, 0
3739, 1.7333333333333, 1.0466666666667, 0
3740, 1.7333333333333, 0.99333333333333, 0
3741, 1.7333333333333, 0.94, 0
3742, 1.7333333333333, 0.88666666666667, 0
3743, 1.7333333333333, 0.83333333333333, 0
3744, 1.7333333333333, 0.78, 0
3745, 1.7333333333333, 0.72666666666667, 0
3746, 1.7333333333333, 0.67333333333333, 0
3747, 1.7333333333333, 0.62, 0
3748, 1.7333333333333, 0.56666666666667, 0
3749, 1.7333333333333, 0.51333333333333, 0
3750, 1.7333333333333, 0.46, 0
3751, 1.7333333333333, 0.40666666666667, 0
3752, 1.7333333333333, 0.35333333333333, 0
3753, 1.8, 1.0466666666667, 0
3754, 1.8, 0.99333333333333, 0
3755, 1.8, 0.94, 0
3756, 1.8, 0.88666666666667, 0
3757, 1.8, 0.83333333333333, 0
3758, 1.8, 0.78, 0
3759, 1.8, 0.72666666666667, 0
3760, 1.8, 0.67333333333333, 0
3761, 1.8, 0.62, 0
3762, 1.8, 0.56666666666667, 0
3763, 1.8, 0.51333333333333, 0
3764, 1.8, 0.46, 0
3765, 1.8, 0.40666666666667, 0
3766, 1.8, 0.35333333333333, 0
3767, 1.8666666666667, 1.0466666666667, 0
3768, 1.8666666666667, 0.99333333333333, 0
3769, 1.8666666666667, 0.94, 0
3770, 1.8666666666667, 0.88666666666667, 0
3771, 1.8666666666667, 0.83333333333333, 0
3772, 1.8666666666667, 0.78, 0
3773, 1.8666666666667, 0.72666666666667, 0
3774, 1.8666666666667, 0.67333333333333, 0
3775, 1.8666666666667, 0.62, 0
3776, 1.8666666666667, 0.56666666666667, 0
3777, 1.8666666666667, 0.51333333333333, 0
3778, 1.8666666666667, 0.46, 0
3779, 1.8666666666667, 0.40666666666667, 0
3780, 1.8666666666667, 0.35333333333333, 0
3781, 1.9333333333333, 1.0466666666667, 0
3782, 1.9333333333333, 0.99333333333333, 0
3783, 1.9333333333333, 0.94, 0
3784, 1.9333333333333, 0.88666666666667, 0
3785, 1.9333333333333, 0.83333333333333, 0
3786, 1.9333333333333, 0.78, 0
3787, 1.9333333333333, 0.72666666666667, 0
3788, 1.9333333333333, 0.67333333333333, 0
3789, 1.9333333333333, 0.62, 0
3790, 1.9333333333333, 0.56666666666667, 0
3791, 1.9333333333333, 0.51333333333333, 0
3792, 1.9333333333333, 0.46, 0
3793, 1.9333333333333, 0.40666666666667, 0
3794, 1.9333333333333, 0.35333333333333, 0
3795, 2, 1.0466666666667, 0
3796, 2, 0.99333333333333, 0
3797, 2, 0.94, 0
3798, 2, 0.88666666666667, 0
3799, 2, 0.83333333333333, 0
3800, 2, 0.78, 0
3801, 2, 0.72666666666667, 0
3802, 2, 0.67333333333333, 0
3803, 2, 0.62, 0
3804, 2, 0.56666666666667, 0
3805, 2, 0.51333333333333, 0
3806, 2, 0.46, 0
3807, 2, 0.40666666666667, 0
3808, 2, 0.35333333333333, 0
3809, 2.0666666666667, 1.0466666666667, 0
3810, 2.0666666666667, 0.99333333333333, 0
3811, 2.0666666666667, 0.94, 0
3812, 2.0666666666667, 0.88666666666667, 0
3813, 2.0666666666667, 0.83333333333333, 0
3814, 2.0666666666667, 0.78, 0
3815, 2.0666666666667, 0.72666666666667, 0
3816, 2.0666666666667, 0.67333333333333, 0
3817, 2.0666666666667, 0.62, 0
3818, 2.0666666666667, 0.56666666666667, 0
3819, 2.0666666666667, 0.51333333333333, 0
3820, 2.0666666666667, 0.46, 0
3821, 2.0666666666667, 0.40666666666667, 0
3822, 2.0666666666667, 0.35333333333333, 0
3823, 2.1333333333333, 1.0466666666667, 0
3824, 2.1333333333333, 0.99333333333333, 0
3825, 2.1333333333333, 0.94, 0
3826, 2.1333333333333, 0.88666666666667, 0
3827, 2.1333333333333, 0.83333333333333, 0
3828, 2.1333333333333, 0.78, 0
3829, 2.1333333333333, 0.72666666666667, 0
3830, 2.1333333333333, 0.67333333333333, 0
3831, 2.1333333333333, 0.62, 0
3832, 2.1333333333333, 0.56666666666667, 0
3833, 2.1333333333333, 0.51333333333333, 0
3834, 2.1333333333333, 0.46, 0
3835, 2.1333333333333, 0.40666666666667, 0
3836, 2.1333333333333, 0.35333333333333, 0
3837, 1.2, 1.0466666666667, 0.033333333333333
3838, 1.2, 0.99333333333333, 0.033333333333333
3839, 1.2, 0.94, 0.033333333333333
3840, 1.2, 0.88666666666667, 0.033333333333333
3841, 1.2, 0.83333333333333, 0.033333333333333
3842, 1.2, 0.78, 0.033333333333333
3843, 1.2, 0.72666666666667, 0.033333333333333
3844, 1.2, 0.67333333333333, 0.033333333333333
3845, 1.2, 0.62, 0.033333333333333
3846, 1.2, 0.56666666666667, 0.033333333333333
3847, 1.2, 0.51333333333333, 0.033333333333333
3848, 1.2, 0.46, 0.033333333333333
3849, 1.2, 0.40666666666667, 0.033333333333333
3850, 1.2, 0.35333333333333, 0.033333333333333
3851, 1.2, 1.0466666666667, 0.066666666666667
3852, 1.2, 0.99333333333333, 0.066666666666667
3853, 1.2, 0.94, 0.066666666666667
3854, 1.2, 0.88666666666667, 0.066666666666667
3855, 1.2, 0.83333333333333, 0.066666666666667
3856, 1.2, 0.78, 0.066666666666667
3857, 1.2, 0.72666666666667, 0.066666666666667
3858, 1.2, 0.67333333333333, 0.066666666666667
3859, 1.2, 0.62, 0.066666666666667
3860, 1.2, 0.56666666666667, 0.066666666666667
3861, 1.2, 0.51333333333333, 0.066666666666667
3862, 1.2, 0.46, 0.066666666666667
3863, 1.2, 0.40666666666667, 0.066666666666667
3864, 1.2, 0.35333333333333, 0.066666666666667
3865, 1.2, 1.0466666666667, 0.1
3866, 1.2, 0.99333333333333, 0.1
3867, 1.2, 0.94, 0.1
3868, 1.2, 0.88666666666667, 0.1
3869, 1.2, 0.83333333333333, 0.1
3870, 1.2, 0.78, 0.1
3871, 1.2, 0.72666666666667, 0.1
3872, 1.2, 0.67333333333333, 0.1
3873, 1.2, 0.62, 0.1
3874, 1.2, 0.56666666666667, 0.1
3875, 1.2, 0.51333333333333, 0.1
3876, 1.2, 0.46, 0.1
3877, 1.2, 0.40666666666667, 0.1
3878, 1.2, 0.35333333333333, 0.1
3879, 1.2, 1.0466666666667, 0.13333333333333
3880, 1.2, 0.99333333333333, 0.13333333333333
3881, 1.2, 0.94, 0.13333333333333
3882, 1.2, 0.88666666666667, 0.13333333333333
3883, 1.2, 0.83333333333333, 0.13333333333333
3884, 1.2, 0.78, 0.13333333333333
3885, 1.2, 0.72666666666667, 0.13333333333333
3886, 1.2, 0.67333333333333, 0.13333333333333
3887, 1.2, 0.62, 0.13333333333333
3888, 1.2, 0.56666666666667, 0.13333333333333
3889, 1.2, 0.51333333333333, 0.13333333333333
3890, 1.2, 0.46, 0.13333333333333
3891, 1.2, 0.40666666666667, 0.13333333333333
3892, 1.2, 0.35333333333333, 0.13333333333333
3893, 1.2, 1.0466666666667, 0.16666666666667
3894, 1.2, 0.99333333333333, 0.16666666666667
3895, 1.2, 0.94, 0.16666666666667
3896, 1.2, 0.88666666666667, 0.16666666666667
3897, 1.2, 0.83333333333333, 0.16666666666667
3898, 1.2, 0.78, 0.16666666666667
3899, 1.2, 0.72666666666667, 0.16666666666667
3900, 1.2, 0.67333333333333, 0.16666666666667
3901, 1.2, 0.62, 0.16666666666667
3902, 1.2, 0.56666666666667, 0.16666666666667
3903, 1.2, 0.51333333333333, 0.16666666666667
3904, 1.2, 0.46, 0.16666666666667
3905, 1.2, 0.40666666666667, 0.16666666666667
3906, 1.2, 0.35333333333333, 0.16666666666667
3907, 1.2, 1.0466666666667, 0.2
3908, 1.2, 0.99333333333333, 0.2
3909, 1.2, 0.94, 0.2
3910, 1.2, 0.88666666666667, 0.2
3911, 1.2, 0.83333333333333, 0.2
3912, 1.2, 0.78, 0.2
3913, 1.2, 0.72666666666667, 0.2
3914, 1.2, 0.67333333333333, 0.2
3915, 1.2, 0.62, 0.2
3916, 1.2, 0.56666666666667, 0.2
3917, 1.2, 0.51333333333333, 0.2
3918, 1.2, 0.46, 0.2
3919, 1.2, 0.40666666666667, 0.2
3920, 1.2, 0.35333333333333, 0.2
3921, 1.2, 1.0466666666667, 0.23333333333333
3922, 1.2, 0.99333333333333, 0.23333333333333
3923, 1.2, 0.94, 0.23333333333333
3924, 1.2, 0.88666666666667, 0.23333333333333
3925, 1.2, 0.83333333333333, 0.23333333333333
3926, 1.2, 0.78, 0.23333333333333
3927, 1.2, 0.72666666666667, 0.23333333333333
3928, 1.2, 0.67333333333333, 0.23333333333333
3929, 1.2, 0.62, 0.23333333333333
3930, 1.2, 0.56666666666667, 0.23333333333333
3931, 1.2, 0.51333333333333, 0.23333333333333
3932, 1.2, 0.46, 0.23333333333333
3933, 1.2, 0.40666666666667, 0.23333333333333
3934, 1.2, 0.35333333333333, 0.23333333333333
3935, 1.2, 1.0466666666667, 0.26666666666667
3936, 1.2, 0.99333333333333, 0.26666666666667
3937, 1.2, 0.94, 0.26666666666667
3938, 1.2, 0.88666666666667, 0.26666666666667
3939, 1.2, 0.83333333333333, 0.26666666666667
3940, 1.2, 0.78, 0.26666666666667
3941, 1.2, 0.72666666666667, 0.26666666666667
3942, 1.2, 0.67333333333333, 0.26666666666667
3943, 1.2, 0.62, 0.26666666666667
3944, 1.2, 0.56666666666667, 0.26666666666667
3945, 1.2, 0.51333333333333, 0.26666666666667
3946, 1.2, 0.46, 0.26666666666667
3947, 1.2, 0.40666666666667, 0.26666666666667
3948, 1.2, 0.35333333333333, 0.26666666666667
3949, 1.2, 1.0466666666667, 0.3
3950, 1.2, 0.99333333333333, 0.3
3951, 1.2, 0.94, 0.3
3952, 1.2, 0.88666666666667, 0.3
3953, 1.2, 0.83333333333333, 0.3
3954, 1.2, 0.78, 0.3
3955, 1.2, 0.72666666666667, 0.3
3956, 1.2, 0.67333333333333, 0.3
3957, 1.2, 0.62, 0.3
3958, 1.2, 0.56666666666667, 0.3
3959, 1.2, 0.51333333333333, 0.3
3960, 1.2, 0.46, 0.3
3961, 1.2, 0.40666666666667, 0.3
3962, 1.2, 0.35333333333333, 0.3
3963, 1.2, 1.0466666666667, 0.33333333333333
3964, 1.2, 0.99333333333333, 0.33333333333333
3965, 1.2, 0.94, 0.33333333333333
3966, 1.2, 0.88666666666667, 0.33333333333333
3967, 1.2, 0.83333333333333, 0.33333333333333
3968, 1.2, 0.78, 0.33333333333333
3969, 1.2, 0.72666666666667, 0.33333333333333
3970, 1.2, 0.67333333333333, 0.33333333333333
3971, 1.2, 0.62, 0.33333333333333
3972, 1.2, 0.56666666666667, 0.33333333333333
3973, 1.2, 0.51333333333333, 0.33333333333333
3974, 1.2, 0.46, 0.33333333333333
3975, 1.2, 0.40666666666667, 0.33333333333333
3976, 1.2, 0.35333333333333, 0.33333333333333
3977, 1.2, 1.0466666666667, 0.36666666666667
3978, 1.2, 0.99333333333333, 0.36666666666667
3979, 1.2, 0.94, 0.36666666666667
3980, 1.2, 0.88666666666667, 0.36666666666667
3981, 1.2, 0.83333333333333, 0.36666666666667
3982, 1.2, 0.78, 0.36666666666667
3983, 1.2, 0.72666666666667, 0.36666666666667
3984, 1.2, 0.67333333333333, 0.36666666666667
3985, 1.2, 0.62, 0.36666666666667
3986, 1.2, 0.56666666666667, 0.36666666666667
3987, 1.2, 0.51333333333333, 0.36666666666667
3988, 1.2, 0.46, 0.36666666666667
3989, 1.2, 0.40666666666667, 0.36666666666667
3990, 1.2, 0.35333333333333, 0.36666666666667
3991, 1.2, 1.0466666666667, 0.4
3992, 1.2, 0.99333333333333, 0.4
3993, 1.2, 0.94, 0.4
3994, 1.2, 0.88666666666667, 0.4
3995, 1.2, 0.83333333333333, 0.4
3996, 1.2, 0.78, 0.4
3997, 1.2, 0.72666666666667, 0.4
3998, 1.2, 0.67333333333333, 0.4
3999, 1.2, 0.62, 0.4
4000, 1.2, 0.56666666666667, 0.4
4001, 1.2, 0.51333333333333, 0.4
4002, 1.2, 0.46, 0.4
4003, 1.2, 0.40666666666667, 0.4
4004, 1.2, 0.35333333333333, 0.4
4005, 1.2, 1.0466666666667, 0.43333333333333
4006, 1.2, 0.99333333333333, 0.43333333333333
4007, 1.2, 0.94, 0.43333333333333
4008, 1.2, 0.88666666666667, 0.43333333333333
4009, 1.2, 0.83333333333333, 0.43333333333333
4010, 1.2, 0.78, 0.43333333333333
4011, 1.2, 0.72666666666667, 0.43333333333333
4012, 1.2, 0.67333333333333, 0.43333333333333
4013, 1.2, 0.62, 0.43333333333333
4014, 1.2, 0.56666666666667, 0.43333333333333
4015, 1.2, 0.51333333333333, 0.43333333333333
4016, 1.2, 0.46, 0.43333333333333
4017, 1.2, 0.40666666666667, 0.43333333333333
4018, 1.2, 0.35333333333333, 0.43333333333333
4019, 1.2, 1.0466666666667, 0.46666666666667
4020, 1.2, 0.99333333333333, 0.46666666666667
4021, 1.2, 0.94, 0.46666666666667
4022, 1.2, 0.88666666666667, 0.46666666666667
4023, 1.2, 0.83333333333333, 0.46666666666667
4024, 1.2, 0.78, 0.46666666666667
4025, 1.2, 0.72666666666667, 0.46666666666667
4026, 1.2, 0.67333333333333, 0.46666666666667
4027, 1.2, 0.62, 0.46666666666667
4028, 1.2, 0.56666666666667, 0.46666666666667
4029, 1.2, 0.51333333333333, 0.46666666666667
4030, 1.2, 0.46, 0.46666666666667
4031, 1.2, 0.40666666666667, 0.46666666666667
4032, 1.2, 0.35333333333333, 0.46666666666667
4033, 2.2, 1.0466666666667, 0.033333333333333
4034, 2.2, 0.99333333333333, 0.033333333333333
4035, 2.2, 0.94, 0.033333333333333
4036, 2.2, 0.88666666666667, 0.033333333333333
4037, 2.2, 0.83333333333333, 0.033333333333333
4038, 2.2, 0.78, 0.033333333333333
4039, 2.2, 0.72666666666667, 0.033333333333333
4040, 2.2, 0.67333333333333, 0.033333333333333
4041, 2.2, 0.62, 0.033333333333333
4042, 2.2, 0.56666666666667, 0.033333333333333
4043, 2.2, 0.51333333333333, 0.033333333333333
4044, 2.2, 0.46, 0.033333333333333
4045, 2.2, 0.40666666666667, 0.033333333333333
4046, 2.2, 0.35333333333333, 0.033333333333333
4047, 2.2, 1.0466666666667, 0.066666666666667
4048, 2.2, 0.99333333333333, 0.066666666666667
4049, 2.2, 0.94, 0.066666666666667
4050, 2.2, 0.88666666666667, 0.066666666666667
4051, 2.2, 0.83333333333333, 0.066666666666667
4052, 2.2, 0.78, 0.066666666666667
4053, 2.2, 0.72666666666667, 0.066666666666667
4054, 2.2, 0.67333333333333, 0.066666666666667
4055, 2.2, 0.62, 0.066666666666667
4056, 2.2, 0.56666666666667, 0.066666666666667
4057, 2.2, 0.51333333333333, 0.066666666666667
4058, 2.2, 0.46, 0.066666666666667
4059, 2.2, 0.40666666666667, 0.066666666666667
4060, 2.2, 0.35333333333333, 0.066666666666667
4061, 2.2, 1.0466666666667, 0.1
4062, 2.2, 0.99333333333333, 0.1
4063, 2.2, 0.94, 0.1
4064, 2.2, 0.88666666666667, 0.1
4065, 2.2, 0.83333333333333, 0.1
4066, 2.2, 0.78, 0.1
4067, 2.2, 0.72666666666667, 0.1
4068, 2.2, 0.67333333333333, 0.1
4069, 2.2, 0.62, 0.1
4070, 2.2, 0.56666666666667, 0.1
4071, 2.2, 0.51333333333333, 0.1
4072, 2.2, 0.46, 0.1
4073, 2.2, 0.40666666666667, 0.1
4074, 2.2, 0.35333333333333, 0.1
4075, 2.2, 1.0466666666667, 0.13333333333333
4076, 2.2, 0.99333333333333, 0.13333333333333
4077, 2.2, 0.94, 0.13333333333333
4078, 2.2, 0.88666666666667, 0.13333333333333
4079, 2.2, 0.83333333333333, 0.13333333333333
4080, 2.2, 0.78, 0.13333333333333
4081, 2.2, 0.72666666666667, 0.13333333333333
4082, 2.2, 0.67333333333333, 0.13333333333333
4083, 2.2, 0.62, 0.13333333333333
4084, 2.2, 0.56666666666667, 0.13333333333333
4085, 2.2, 0.51333333333333, 0.13333333333333
4086, 2.2, 0.46, 0.13333333333333
4087, 2.2, 0.40666666666667, 0.13333333333333
4088, 2.2, 0.35333333333333, 0.13333333333333
4089, 2.2, 1.0466666666667, 0.16666666666667
4090, 2.2, 0.99333333333333, 0.16666666666667
4091, 2.2, 0.94, 0.16666666666667
4092, 2.2, 0.88666666666667, 0.16666666666667
4093, 2.2, 0.83333333333333, 0.16666666666667
4094, 2.2, 0.78, 0.16666666666667
4095, 2.2, 0.72666666666667, 0.16666666666667
4096, 2.2, 0.67333333333333, 0.16666666666667
4097, 2.2, 0.62, 0.16666666666667
4098, 2.2, 0.56666666666667, 0.16666666666667
4099, 2.2, 0.51333333333333, 0.16666666666667
4100, 2.2, 0.46, 0.16666666666667
4101, 2.2, 0.40666666666667, 0.16666666666667
4102, 2.2, 0.35333333333333, 0.16666666666667
4103, 2.2, 1.0466666666667, 0.2
4104, 2.2, 0.99333333333333, 0.2
4105, 2.2, 0.94, 0.2
4106, 2.2, 0.88666666666667, 0.2
4107, 2.2, 0.83333333333333, 0.2
4108, 2.2, 0.78, 0.2
4109, 2.2, 0.72666666666667, 0.2
4110, 2.2, 0.67333333333333, 0.2
4111, 2.2, 0.62, 0.2
4112, 2.2, 0.56666666666667, 0.2
4113, 2.2, 0.51333333333333, 0.2
4114, 2.2, 0.46, 0.2
4115, 2.2, 0.40666666666667, 0.2
4116, 2.2, 0.35333333333333, 0.2
4117, 2.2, 1.0466666666667, 0.23333333333333
4118, 2.2, 0.99333333333333, 0.23333333333333
4119, 2.2, 0.94, 0.23333333333333
4120, 2.2, 0.88666666666667, 0.23333333333333
4121, 2.2, 0.83333333333333, 0.23333333333333
4122, 2.2, 0.78, 0.23333333333333
4123, 2.2, 0.72666666666667, 0.23333333333333
4124, 2.2, 0.67333333333333, 0.23333333333333
4125, 2.2, 0.62, 0.23333333333333
4126, 2.2, 0.56666666666667, 0.23333333333333
4127, 2.2, 0.51333333333333, 0.23333333333333
4128, 2.2, 0.46, 0.23333333333333
4129, 2.2, 0.40666666666667, 0.23333333333333
4130, 2.2, 0.35333333333333, 0.23333333333333
4131, 2.2, 1.0466666666667, 0.26666666666667
4132, 2.2, 0.99333333333333, 0.26666666666667
4133, 2.2, 0.94, 0.26666666666667
4134, 2.2, 0.88666666666667, 0.26666666666667
4135, 2.2, 0.83333333333333, 0.26666666666667
4136, 2.2, 0.78, 0.26666666666667
4137, 2.2, 0.72666666666667, 0.26666666666667
4138, 2.2, 0.67333333333333, 0.26666666666667
4139, 2.2, 0.62, 0.26666666666667
4140, 2.2, 0.56666666666667, 0.26666666666667
4141, 2.2, 0.51333333333333, 0.26666666666667
4142, 2.2, 0.46, 0.26666666666667
4143, 2.2, 0.40666666666667, 0.26666666666667
4144, 2.2, 0.35333333333333, 0.26666666666667
4145, 2.2, 1.0466666666667, 0.3
4146, 2.2, 0.99333333333333, 0.3
4147, 2.2, 0.94, 0.3
4148, 2.2, 0.88666666666667, 0.3
4149, 2.2, 0.83333333333333, 0.3
4150, 2.2, 0.78, 0.3
4151, 2.2, 0.72666666666667, 0.3
4152, 2.2, 0.67333333333333, 0.3
4153, 2.2, 0.62, 0.3
4154, 2.2, 0.56666666666667, 0.3
4155, 2.2, 0.51333333333333, 0.3
4156, 2.2, 0.46, 0.3
4157, 2.2, 0.40666666666667, 0.3
4158, 2.2, 0.35333333333333, 0.3
4159, 2.2, 1.0466666666667, 0.33333333333333
4160, 2.2, 0.99333333333333, 0.33333333333333
4161, 2.2, 0.94, 0.33333333333333
4162, 2.2, 0.88666666666667, 0.33333333333333
4163, 2.2, 0.83333333333333, 0.33333333333333
4164, 2.2, 0.78, 0.33333333333333
4165, 2.2, 0.72666666666667, 0.33333333333333
4166, 2.2, 0.67333333333333, 0.33333333333333
4167, 2.2, 0.62, 0.33333333333333
4168, 2.2, 0.56666666666667, 0.33333333333333
4169, 2.2, 0.51333333333333, 0.33333333333333
4170, 2.2, 0.46, 0.33333333333333
4171, 2.2, 0.40666666666667, 0.33333333333333
4172, 2.2, 0.35333333333333, 0.33333333333333
4173, 2.2, 1.0466666666667, 0.36666666666667
4174, 2.2, 0.99333333333333, 0.36666666666667
4175, 2.2, 0.94, 0.36666666666667
4176, 2.2, 0.88666666666667, 0.36666666666667
4177, 2.2, 0.83333333333333, 0.36666666666667
4178, 2.2, 0.78, 0.36666666666667
4179, 2.2, 0.72666666666667, 0.36666666666667
4180, 2.2, 0.67333333333333, 0.36666666666667
4181, 2.2, 0.62, 0.36666666666667
4182, 2.2, 0.56666666666667, 0.36666666666667
4183, 2.2, 0.51333333333333, 0.36666666666667
4184, 2.2, 0.46, 0.36666666666667
4185, 2.2, 0.40666666666667, 0.36666666666667
4186, 2.2, 0.35333333333333, 0.36666666666667
4187, 2.2, 1.0466666666667, 0.4
4188, 2.2, 0.99333333333333, 0.4
4189, 2.2, 0.94, 0.4
4190, 2.2, 0.88666666666667, 0.4
4191, 2.2, 0.83333333333333, 0.4
4192, 2.2, 0.78, 0.4
4193, 2.2, 0.72666666666667, 0.4
4194, 2.2, 0.67333333333333, 0.4
4195, 2.2, 0.62, 0.4
4196, 2.2, 0.56666666666667, 0.4
4197, 2.2, 0.51333333333333, 0.4
4198, 2.2, 0.46, 0.4
4199, 2.2, 0.40666666666667, 0.4
4200, 2.2, 0.35333333333333, 0.4
4201, 2.2, 1.0466666666667, 0.43333333333333
4202, 2.2, 0.99333333333333, 0.43333333333333
4203, 2.2, 0.94, 0.43333333333333
4204, 2.2, 0.88666666666667, 0.43333333333333
4205, 2.2, 0.83333333333333, 0.43333333333333
4206, 2.2, 0.78, 0.43333333333333
4207, 2.2, 0.72666666666667, 0.43333333333333
4208, 2.2, 0.67333333333333, 0.43333333333333
4209, 2.2, 0.62, 0.43333333333333
4210, 2.2, 0.56666666666667, 0.43333333333333
4211, 2.2, 0.51333333333333, 0.43333333333333
4212, 2.2, 0.46, 0.43333333333333
4213, 2.2, 0.40666666666667, 0.43333333333333
4214, 2.2, 0.35333333333333, 0.43333333333333
4215, 2.2, 1.0466666666667, 0.46666666666667
4216, 2.2, 0.99333333333333, 0.46666666666667
4217, 2.2, 0.94, 0.46666666666667
4218, 2.2, 0.88666666666667, 0.46666666666667
4219, 2.2, 0.83333333333333, 0.46666666666667
4220, 2.2, 0.78, 0.46666666666667
4221, 2.2, 0.72666666666667, 0.46666666666667
4222, 2.2, 0.67333333333333, 0.46666666666667
4223, 2.2, 0.62, 0.46666666666667
4224, 2.2, 0.56666666666667, 0.46666666666667
4225, 2.2, 0.51333333333333, 0.46666666666667
4226, 2.2, 0.46, 0.46666666666667
4227, 2.2, 0.40666666666667, 0.46666666666667
4228, 2.2, 0.35333333333333, 0.46666666666667
4229, 1.2666666666667, 0.3, 0.033333333333333
4230, 1.3333333333333, 0.3, 0.033333333333333
4231, 1.4, 0.3, 0.033333333333333
4232, 1.4666666666667, 0.3, 0.033333333333333
4233, 1.5333333333333, 0.3, 0.033333333333333
4234, 1.6, 0.3, 0.033333333333333
4235, 1.6666666666667, 0.3, 0.033333333333333
4236, 1.7333333333333, 0.3, 0.033333333333333
4237, 1.8, 0.3, 0.033333333333333
4238, 1.8666666666667, 0.3, 0.033333333333333
4239, 1.9333333333333, 0.3, 0.033333333333333
4240, 2, 0.3, 0.033333333333333
4241, 2.0666666666667, 0.3, 0.033333333333333
4242, 2.1333333333333, 0.3, 0.033333333333333
4243, 1.2666666666667, 0.3, 0.066666666666667
4244, 1.3333333333333, 0.3, 0.066666666666667
4245, 1.4, 0.3, 0.066666666666667
4246, 1.4666666666667, 0.3, 0.066666666666667
4247, 1.5333333333333, 0.3, 0.066666666666667
4248, 1.6, 0.3, 0.066666666666667
4249, 1.6666666666667, 0.3, 0.066666666666667
4250, 1.7333333333333, 0.3, 0.066666666666667
4251, 1.8, 0.3, 0.066666666666667
4252, 1.8666666666667, 0.3, 0.066666666666667
4253, 1.9333333333333, 0.3, 0.066666666666667
4254, 2, 0.3, 0.066666666666667
4255, 2.0666666666667, 0.3, 0.066666666666667
4256, 2.1333333333333, 0.3, 0.066666666666667
4257, 1.2666666666667, 0.3, 0.1
4258, 1.3333333333333, 0.3, 0.1
4259, 1.4, 0.3, 0.1
4260, 1.4666666666667, 0.3, 0.1
4261, 1.5333333333333, 0.3, 0.1
4262, 1.6, 0.3, 0.1
4263, 1.6666666666667, 0.3, 0.1
4264, 1.7333333333333, 0.3, 0.1
4265, 1.8, 0.3, 0.1
4266, 1.8666666666667, 0.3, 0.1
4267, 1.9333333333333, 0.3, 0.1
4268, 2, 0.3, 0.1
4269, 2.0666666666667, 0.3, 0.1
4270, 2.1333333333333, 0.3, 0.1
4271, 1.2666666666667, 0.3, 0.13333333333333
4272, 1.3333333333333, 0.3, 0.13333333333333
4273, 1.4, 0.3, 0.13333333333333
4274, 1.4666666666667, 0.3, 0.13333333333333
4275, 1.5333333333333, 0.3, 0.13333333333333
4276, 1.6, 0.3, 0.13333333333333
4277, 1.6666666666667, 0.3, 0.13333333333333
4278, 1.7333333333333, 0.3, 0.13333333333333
4279, 1.8, 0.3, 0.13333333333333
4280, 1.8666666666667, 0.3, 0.13333333333333
4281, 1.9333333333333, 0.3, 0.13333333333333
4282, 2, 0.3, 0.13333333333333
4283, 2.0666666666667, 0.3, 0.13333333333333
4284, 2.1333333333333, 0.3, 0.13333333333333
4285, 1.2666666666667, 0.3, 0.16666666666667
4286, 1.3333333333333, 0.3, 0.16666666666667
4287, 1.4, 0.3, 0.16666666666667
4288, 1.4666666666667, 0.3, 0.16666666666667
4289, 1.5333333333333, 0.3, 0.16666666666667
4290, 1.6, 0.3, 0.16666666666667
4291, 1.6666666666667, 0.3, 0.16666666666667
4292, 1.7333333333333, 0.3, 0.16666666666667
4293, 1.8, 0.3, 0.16666666666667
4294, 1.8666666666667, 0.3, 0.16666666666667
4295, 1.9333333333333, 0.3, 0.16666666666667
4296, 2, 0.3, 0.16666666666667
4297, 2.0666666666667, 0.3, 0.16666666666667
4298, 2.1333333333333, 0.3, 0.16666666666667
4299, 1.2666666666667, 0.3, 0.2
4300, 1.3333333333333, 0.3, 0.2
4301, 1.4, 0.3, 0.2
4302, 1.4666666666667, 0.3, 0.2
4303, 1.5333333333333, 0.3, 0.2
4304, 1.6, 0.3, 0.2
4305, 1.6666666666667, 0.3, 0.2
4306, 1.7333333333333, 0.3, 0.2
4307, 1.8, 0.3, 0.2
4308, 1.8666666666667, 0.3, 0.2
4309, 1.9333333333333, 0.3, 0.2
4310, 2, 0.3, 0.2
4311, 2.0666666666667, 0.3, 0.2
4312, 2.1333333333333, 0.3, 0.2
4313, 1.2666666666667, 0.3, 0.23333333333333
4314, 1.3333333333333, 0.3, 0.23333333333333
4315, 1.4, 0.3, 0.23333333333333
4316, 1.4666666666667, 0.3, 0.23333333333333
4317, 1.5333333333333, 0.3, 0.23333333333333
4318, 1.6, 0.3, 0.23333333333333
4319, 1.6666666666667, 0.3, 0.23333333333333
4320, 1.7333333333333, 0.3, 0.23333333333333
4321, 1.8, 0.3, 0.23333333333333
4322, 1.8666666666667, 0.3, 0.23333333333333
4323, 1.9333333333333, 0.3, 0.23333333333333
4324, 2, 0.3, 0.23333333333333
4325, 2.0666666666667, 0.3, 0.23333333333333
4326, 2.1333333333333, 0.3, 0.23333333333333
4327, 1.2666666666667, 0.3, 0.26666666666667
4328, 1.3333333333333, 0.3, 0.26666666666667
4329, 1.4, 0.3, 0.26666666666667
4330, 1.4666666666667, 0.3, 0.26666666666667
4331, 1.5333333333333, 0.3, 0.26666666666667
4332, 1.6, 0.3, 0.26666666666667
4333, 1.6666666666667, 0.3, 0.26666666666667
4334, 1.7333333333333, 0.3, 0.26666666666667
4335, 1.8, 0.3, 0.26666666666667
4336, 1.8666666666667, 0.3, 0.26666666666667
4337, 1.9333333333333, 0.3, 0.26666666666667
4338, 2, 0.3, 0.26666666666667
4339, 2.0666666666667, 0.3, 0.26666666666667
4340, 2.1333333333333, 0.3, 0.26666666666667
4341, 1.2666666666667, 0.3, 0.3
4342, 1.3333333333333, 0.3, 0.3
4343, 1.4, 0.3, 0.3
4344, 1.4666666666667, 0.3, 0.3
4345, 1.5333333333333, 0.3, 0.3
4346, 1.6, 0.3, 0.3
4347, 1.6666666666667, 0.3, 0.3
4348, 1.7333333333333, 0.3, 0.3
4349, 1.8, 0.3, 0.3
4350, 1.8666666666667, 0.3, 0.3
4351, 1.9333333333333, 0.3, 0.3
4352, 2, 0.3, 0.3
4353, 2.0666666666667, 0.3, 0.3
4354, 2.1333333333333, 0.3, 0.3
4355, 1.2666666666667, 0.3, 0.33333333333333
4356, 1.3333333333333, 0.3, 0.33333333333333
4357, 1.4, 0.3, 0.33333333333333
4358, 1.4666666666667, 0.3, 0.33333333333333
4359, 1.5333333333333, 0.3, 0.33333333333333
4360, 1.6, 0.3, 0.33333333333333
4361, 1.6666666666667, 0.3, 0.33333333333333
4362, 1.7333333333333, 0.3, 0.33333333333333
4363, 1.8, 0.3, 0.33333333333333
4364, 1.8666666666667, 0.3, 0.33333333333333
4365, 1.9333333333333, 0.3, 0.33333333333333
4366, 2, 0.3, 0.33333333333333
4367, 2.0666666666667, 0.3, 0.33333333333333
4368, 2.1333333333333, 0.3, 0.33333333333333
4369, 1.2666666666667, 0.3, 0.36666666666667
4370, 1.3333333333333, 0.3, 0.36666666666667
4371, 1.4, 0.3, 0.36666666666667
4372, 1.4666666666667, 0.3, 0.36666666666667
4373, 1.5333333333333, 0.3, 0.36666666666667
4374, 1.6, 0.3, 0.36666666666667
4375, 1.6666666666667, 0.3, 0.36666666666667
4376, 1.7333333333333, 0.3, 0.36666666666667
4377, 1.8, 0.3, 0.36666666666667
4378, 1.8666666666667, 0.3, 0.36666666666667
4379, 1.9333333333333, 0.3, 0.36666666666667
4380, 2, 0.3, 0.36666666666667
4381, 2.0666666666667, 0.3, 0.36666666666667
4382, 2.1333333333333, 0.3, 0.36666666666667
4383, 1.2666666666667, 0.3, 0.4
4384, 1.3333333333333, 0.3, 0.4
4385, 1.4, 0.3, 0.4
4386, 1.4666666666667, 0.3, 0.4
4387, 1.5333333333333, 0.3, 0.4
4388, 1.6, 0.3, 0.4
4389, 1.6666666666667, 0.3, 0.4
4390, 1.7333333333333, 0.3, 0.4
4391, 1.8, 0.3, 0.4
4392, 1.8666666666667, 0.3, 0.4
4393, 1.9333333333333, 0.3, 0.4
4394, 2, 0.3, 0.4
4395, 2.0666666666667, 0.3, 0.4
4396, 2.1333333333333, 0.3, 0.4
4397, 1.2666666666667, 0.3, 0.43333333333333
4398, 1.3333333333333, 0.3, 0.43333333333333
4399, 1.4, 0.3, 0.43333333333333
4400, 1.4666666666667, 0.3, 0.43333333333333
4401, 1.5333333333333, 0.3, 0.43333333333333
4402, 1.6, 0.3, 0.43333333333333
4403, 1.6666666666667, 0.3, 0.43333333333333
4404, 1.7333333333333, 0.3, 0.43333333333333
4405, 1.8, 0.3, 0.43333333333333
4406, 1.8666666666667, 0.3, 0.43333333333333
4407, 1.9333333333333, 0.3, 0.43333333333333
4408, 2, 0.3, 0.43333333333333
4409, 2.0666666666667, 0.3, 0.43333333333333
4410, 2.1333333333333, 0.3, 0.43333333333333
4411, 1.2666666666667, 0.3, 0.46666666666667
4412, 1.3333333333333, 0.3, 0.46666666666667
4413, 1.4, 0.3, 0.46666666666667
4414, 1.4666666666667, 0.3, 0.46666666666667
4415, 1.5333333333333, 0.3, 0.46666666666667
4416, 1.6, 0.3, 0.46666666666667
4417, 1.6666666666667, 0.3, 0.46666666666667
4418, 1.7333333333333, 0.3, 0.46666666666667
4419, 1.8, 0.3, 0.46666666666667
4420, 1.8666666666667, 0.3, 0.46666666666667
4421, 1.9333333333333, 0.3, 0.46666666666667
4422, 2, 0.3, 0.46666666666667
4423, 2.0666666666667, 0.3, 0.46666666666667
4424, 2.1333333333333, 0.3, 0.46666666666667
4425, 1.2666666666667, 0.2, 0.033333333333333
4426, 1.3333333333333, 0.2, 0.033333333333333
4427, 1.4, 0.2, 0.033333333333333
4428, 1.4666666666667, 0.2, 0.033333333333333
4429, 1.5333333333333, 0.2, 0.033333333333333
4430, 1.6, 0.2, 0.033333333333333
4431, 1.6666666666667, 0.2, 0.033333333333333
4432, 1.7333333333333, 0.2, 0.033333333333333
4433, 1.8, 0.2, 0.033333333333333
4434, 1.8666666666667, 0.2, 0.033333333333333
4435, 1.9333333333333, 0.2, 0.033333333333333
4436, 2, 0.2, 0.033333333333333
4437, 2.0666666666667, 0.2, 0.033333333333333
4438, 2.1333333333333, 0.2, 0.033333333333333
4439, 1.2666666666667, 0.2, 0.066666666666667
4440, 1.3333333333333, 0.2, 0.066666666666667
4441, 1.4, 0.2, 0.066666666666667
4442, 1.4666666666667, 0.2, 0.066666666666667
4443, 1.5333333333333, 0.2, 0.066666666666667
4444, 1.6, 0.2, 0.066666666666667
4445, 1.6666666666667, 0.2, 0.066666666666667
4446, 1.7333333333333, 0.2, 0.066666666666667
4447, 1.8, 0.2, 0.066666666666667
4448, 1.8666666666667, 0.2, 0.066666666666667
4449, 1.9333333333333, 0.2, 0.066666666666667
4450, 2, 0.2, 0.066666666666667
4451, 2.0666666666667, 0.2, 0.066666666666667
4452, 2.1333333333333, 0.2, 0.066666666666667
4453, 1.2666666666667, 0.2, 0.1
4454, 1.3333333333333, 0.2, 0.1
4455, 1.4, 0.2, 0.1
4456, 1.4666666666667, 0.2, 0.1
4457, 1.5333333333333, 0.2, 0.1
4458, 1.6, 0.2, 0.1
4459, 1.6666666666667, 0.2, 0.1
4460, 1.7333333333333, 0.2, 0.1
4461, 1.8, 0.2, 0.1
4462, 1.8666666666667, 0.2, 0.1
4463, 1.9333333333333, 0.2, 0.1
4464, 2, 0.2, 0.1
4465, 2.0666666666667, 0.2, 0.1
4466, 2.1333333333333, 0.2, 0.1
4467, 1.2666666666667, 0.2, 0.13333333333333
4468, 1.3333333333333, 0.2, 0.13333333333333
4469, 1.4, 0.2, 0.13333333333333
4470, 1.4666666666667, 0.2, 0.13333333333333
4471, 1.5333333333333, 0.2, 0.13333333333333
4472, 1.6, 0.2, 0.13333333333333
4473, 1.6666666666667, 0.2, 0.13333333333333
4474, 1.7333333333333, 0.2, 0.13333333333333
4475, 1.8, 0.2, 0.13333333333333
4476, 1.8666666666667, 0.2, 0.13333333333333
4477, 1.9333333333333, 0.2, 0.13333333333333
4478, 2, 0.2, 0.13333333333333
4479, 2.0666666666667, 0.2, 0.13333333333333
4480, 2.1333333333333, 0.2, 0.13333333333333
4481, 1.2666666666667, 0.2, 0.16666666666667
4482, 1.3333333333333, 0.2, 0.16666666666667
4483, 1.4, 0.2, 0.16666666666667
4484, 1.4666666666667, 0.2, 0.16666666666667
4485, 1.5333333333333, 0.2, 0.16666666666667
4486, 1.6, 0.2, 0.16666666666667
4487, 1.6666666666667, 0.2, 0.16666666666667
4488, 1.7333333333333, 0.2, 0.16666666666667
4489, 1.8, 0.2, 0.16666666666667
4490, 1.8666666666667, 0.2, 0.16666666666667
4491, 1.9333333333333, 0.2, 0.16666666666667
4492, 2, 0.2, 0.16666666666667
4493, 2.0666666666667, 0.2, 0.16666666666667
4494, 2.1333333333333, 0.2, 0.16666666666667
4495, 1.2666666666667, 0.2, 0.2
4496, 1.3333333333333, 0.2, 0.2
4497, 1.4, 0.2, 0.2
4498, 1.4666666666667, 0.2, 0.2
4499, 1.5333333333333, 0.2, 0.2
4500, 1.6, 0.2, 0.2
4501, 1.6666666666667, 0.2, 0.2
4502, 1.7333333333333, 0.2, 0.2
4503, 1.8, 0.2, 0.2
4504, 1.8666666666667, 0.2, 0.2
4505, 1.9333333333333, 0.2, 0.2
4506, 2, 0.2, 0.2
4507, 2.0666666666667, 0.2, 0.2
4508, 2.1333333333333, 0.2, 0.2
4509, 1.2666666666667, 0.2, 0.23333333333333
4510, 1.3333333333333, 0.2, 0.23333333333333
4511, 1.4, 0.2, 0.23333333333333
4512, 1.4666666666667, 0.2, 0.23333333333333
4513, 1.5333333333333, 0.2, 0.23333333333333
4514, 1.6, 0.2, 0.23333333333333
4515, 1.6666666666667, 0.2, 0.23333333333333
4516, 1.7333333333333, 0.2, 0.23333333333333
4517, 1.8, 0.2, 0.23333333333333
4518, 1.8666666666667, 0.2, 0.23333333333333
4519, 1.9333333333333, 0.2, 0.23333333333333
4520, 2, 0.2, 0.23333333333333
4521, 2.0666666666667, 0.2, 0.23333333333333
4522, 2.1333333333333, 0.2, 0.23333333333333
4523, 1.2666666666667, 0.2, 0.26666666666667
4524, 1.3333333333333, 0.2, 0.26666666666667
4525, 1.4, 0.2, 0.26666666666667
4526, 1.4666666666667, 0.2, 0.26666666666667
4527, 1.5333333333333, 0.2, 0.26666666666667
4528, 1.6, 0.2, 0.26666666666667
4529, 1.6666666666667, 0.2, 0.26666666666667
4530, 1.7333333333333, 0.2, 0.26666666666667
4531, 1.8, 0.2, 0.26666666666667
4532, 1.8666666666667, 0.2, 0.26666666666667
4533, 1.9333333333333, 0.2, 0.26666666666667
4534, 2, 0.2, 0.26666666666667
4535, 2.0666666666667, 0.2, 0.26666666666667
4536, 2.1333333333333, 0.2, 0.26666666666667
4537, 1.2666666666667, 0.2, 0.3
4538, 1.3333333333333, 0.2, 0.3
4539, 1.4, 0.2, 0.3
4540, 1.4666666666667, 0.2, 0.3
4541, 1.5333333333333, 0.2, 0.3
4542, 1.6, 0.2, 0.3
4543, 1.6666666666667, 0.2, 0.3
4544, 1.7333333333333, 0.2, 0.3
4545, 1.8, 0.2, 0.3
4546, 1.8666666666667, 0.2, 0.3
4547, 1.9333333333333, 0.2, 0.3
4548, 2, 0.2, 0.3
4549, 2.0666666666667, 0.2, 0.3
4550, 2.1333333333333, 0.2, 0.3
4551, 1.2666666666667, 0.2, 0.33333333333333
4552, 1.3333333333333, 0.2, 0.33333333333333
4553, 1.4, 0.2, 0.33333333333333
4554, 1.4666666666667, 0.2, 0.33333333333333
4555, 1.5333333333333, 0.2, 0.33333333333333
4556, 1.6, 0.2, 0.33333333333333
4557, 1.6666666666667, 0.2, 0.33333333333333
4558, 1.7333333333333, 0.2, 0.33333333333333
4559, 1.8, 0.2, 0.33333333333333
4560, 1.8666666666667, 0.2, 0.33333333333333
4561, 1.9333333333333, 0.2, 0.33333333333333
4562, 2, 0.2, 0.33333333333333
4563, 2.0666666666667, 0.2, 0.33333333333333
4564, 2.1333333333333, 0.2, 0.33333333333333
4565, 1.2666666666667, 0.2, 0.36666666666667
4566, 1.3333333333333, 0.2, 0.36666666666667
4567, 1.4, 0.2, 0.36666666666667
4568, 1.4666666666667, 0.2, 0.36666666666667
4569, 1.5333333333333, 0.2, 0.36666666666667
4570, 1.6, 0.2, 0.36666666666667
4571, 1.6666666666667, 0.2, 0.36666666666667
4572, 1.7333333333333, 0.2, 0.36666666666667
4573, 1.8, 0.2, 0.36666666666667
4574, 1.8666666666667, 0.2, 0.36666666666667
4575, 1.9333333333333, 0.2, 0.36666666666667
4576, 2, 0.2, 0.36666666666667
4577, 2.0666666666667, 0.2, 0.36666666666667
4578, 2.1333333333333, 0.2, 0.36666666666667
4579, 1.2666666666667, 0.2, 0.4
4580, 1.3333333333333, 0.2, 0.4
4581, 1.4, 0.2, 0.4
4582, 1.4666666666667, 0.2, 0.4
4583, 1.5333333333333, 0.2, 0.4
4584, 1.6, 0.2, 0.4
4585, 1.6666666666667, 0.2, 0.4
4586, 1.7333333333333, 0.2, 0.4
4587, 1.8, 0.2, 0.4
4588, 1.8666666666667, 0.2, 0.4
4589, 1.9333333333333, 0.2, 0.4
4590, 2, 0.2, 0.4
4591, 2.0666666666667, 0.2, 0.4
4592, 2.1333333333333, 0.2, 0.4
4593, 1.2666666666667, 0.2, 0.43333333333333
4594, 1.3333333333333, 0.2, 0.43333333333333
4595, 1.4, 0.2, 0.43333333333333
4596, 1.4666666666667, 0.2, 0.43333333333333
4597, 1.5333333333333, 0.2, 0.43333333333333
4598, 1.6, 0.2, 0.43333333333333
4599, 1.6666666666667, 0.2, 0.43333333333333
4600, 1.7333333333333, 0.2, 0.43333333333333
4601, 1.8, 0.2, 0.43333333333333
4602, 1.8666666666667, 0.2, 0.43333333333333
4603, 1.9333333333333, 0.2, 0.43333333333333
4604, 2, 0.2, 0.43333333333333
4605, 2.0666666666667, 0.2, 0.43333333333333
4606, 2.1333333333333, 0.2, 0.43333333333333
4607, 1.2666666666667, 0.2, 0.46666666666667
4608, 1.3333333333333, 0.2, 0.46666666666667
4609, 1.4, 0.2, 0.46666666666667
4610, 1.4666666666667, 0.2, 0.46666666666667
4611, 1.5333333333333, 0.2, 0.46666666666667
4612, 1.6, 0.2, 0.46666666666667
4613, 1.6666666666667, 0.2, 0.46666666666667
4614, 1.7333333333333, 0.2, 0.46666666666667
4615, 1.8, 0.2, 0.46666666666667
4616, 1.8666666666667, 0.2, 0.46666666666667
4617, 1.9333333333333, 0.2, 0.46666666666667
4618, 2, 0.2, 0.46666666666667
4619, 2.0666666666667, 0.2, 0.46666666666667
4620, 2.1333333333333, 0.2, 0.46666666666667
4621, 1.2666666666667, 2.7755575615629e-17, 0.033333333333333
4622, 1.3333333333333, 2.7755575615629e-17, 0.033333333333333
4623, 1.4, 2.7755575615629e-17, 0.033333333333333
4624, 1.4666666666667, 2.7755575615629e-17, 0.033333333333333
4625, 1.5333333333333, 2.7755575615629e-17, 0.033333333333333
4626, 1.6, 2.7755575615629e-17, 0.033333333333333
4627, 1.6666666666667, 2.7755575615629e-17, 0.033333333333333
4628, 1.7333333333333, 2.7755575615629e-17, 0.033333333333333
4629, 1.8, 2.7755575615629e-17, 0.033333333333333
4630, 1.8666666666667, 2.7755575615629e-17, 0.033333333333333
4631, 1.9333333333333, 2.7755575615629e-17, 0.033333333333333
4632, 2, 2.7755575615629e-17, 0.033333333333333
4633, 2.0666666666667, 2.7755575615629e-17, 0.033333333333333
4634, 2.1333333333333, 2.7755575615629e-17, 0.033333333333333
4635, 1.2666666666667, 2.7755575615629e-17, 0.066666666666667
4636, 1.3333333333333, 2.7755575615629e-17, 0.066666666666667
4637, 1.4, 2.7755575615629e-17, 0.066666666666667
4638, 1.4666666666667, 2.7755575615629e-17, 0.066666666666667
4639, 1.5333333333333, 2.7755575615629e-17, 0.066666666666667
4640, 1.6, 2.7755575615629e-17, 0.066666666666667
4641, 1.6666666666667, 2.7755575615629e-17, 0.066666666666667
4642, 1.7333333333333, 2.7755575615629e-17, 0.066666666666667
4643, 1.8, 2.7755575615629e-17, 0.066666666666667
4644, 1.8666666666667, 2.7755575615629e-17, 0.066666666666667
4645, 1.9333333333333, 2.7755575615629e-17, 0.066666666666667
4646, 2, 2.7755575615629e-17, 0.066666666666667
4647, 2.0666666666667, 2.7755575615629e-17, 0.066666666666667
4648, 2.1333333333333, 2.7755575615629e-17, 0.066666666666667
4649, 1.2666666666667, 2.7755575615629e-17, 0.1
4650, 1.3333333333333, 2.7755575615629e-17, 0.1
4651, 1.4, 2.7755575615629e-17, 0.1
4652, 1.4666666666667, 2.7755575615629e-17, 0.1
4653, 1.5333333333333, 2.7755575615629e-17, 0.1
4654, 1.6, 2.7755575615629e-17, 0.1
4655, 1.6666666666667, 2.7755575615629e-17, 0.1
4656, 1.7333333333333, 2.7755575615629e-17, 0.1
4657, 1.8, 2.7755575615629e-17, 0.1
4658, 1.8666666666667, 2.7755575615629e-17, 0.1
4659, 1.9333333333333, 2.7755575615629e-17, 0.1
4660, 2, 2.7755575615629e-17, 0.1
4661, 2.0666666666667, 2.7755575615629e-17, 0.1
4662, 2.1333333333333, 2.7755575615629e-17, 0.1
4663, 1.2666666666667, 2.7755575615629e-17, 0.13333333333333
4664, 1.3333333333333, 2.7755575615629e-17, 0.13333333333333
4665, 1.4, 2.7755575615629e-17, 0.13333333333333
4666, 1.4666666666667, 2.7755575615629e-17, 0.13333333333333
4667, 1.5333333333333, 2.7755575615629e-17, 0.13333333333333
4668, 1.6, 2.7755575615629e-17, 0.13333333333333
4669, 1.6666666666667, 2.7755575615629e-17, 0.13333333333333
4670, 1.7333333333333, 2.7755575615629e-17, 0.13333333333333
4671, 1.8, 2.7755575615629e-17, 0.13333333333333
4672, 1.8666666666667, 2.7755575615629e-17, 0.13333333333333
4673, 1.9333333333333, 2.7755575615629e-17, 0.13333333333333
4674, 2, 2.7755575615629e-17, 0.13333333333333
4675, 2.0666666666667, 2.7755575615629e-17, 0.13333333333333
4676, 2.1333333333333, 2.7755575615629e-17, 0.13333333333333
4677, 1.2666666666667, 2.7755575615629e-17, 0.16666666666667
4678, 1.3333333333333, 2.7755575615629e-17, 0.16666666666667
4679, 1.4, 2.7755575615629e-17, 0.16666666666667
4680, 1.4666666666667, 2.7755575615629e-17, 0.16666666666667
4681, 1.5333333333333, 2.7755575615629e-17, 0.16666666666667
4682, 1.6, 2.7755575615629e-17, 0.16666666666667
4683, 1.6666666666667, 2.7755575615629e-17, 0.16666666666667
4684, 1.7333333333333, 2.7755575615629e-17, 0.16666666666667
4685, 1.8, 2.7755575615629e-17, 0.16666666666667
4686, 1.8666666666667, 2.7755575615629e-17, 0.16666666666667
4687, 1.9333333333333, 2.7755575615629e-17, 0.16666666666667
4688, 2, 2.7755575615629e-17, 0.16666666666667
4689, 2.0666666666667, 2.7755575615629e-17, 0.16666666666667
4690, 2.1333333333333, 2.7755575615629e-17, 0.16666666666667
4691, 1.2666666666667, 2.7755575615629e-17, 0.2
4692, 1.3333333333333, 2.7755575615629e-17, 0.2
4693, 1.4, 2.7755575615629e-17, 0.2
4694, 1.4666666666667, 2.7755575615629e-17, 0.2
4695, 1.5333333333333, 2.7755575615629e-17, 0.2
4696, 1.6, 2.7755575615629e-17, 0.2
4697, 1.6666666666667, 2.7755575615629e-17, 0.2
4698, 1.7333333333333, 2.7755575615629e-17, 0.2
4699, 1.8, 2.7755575615629e-17, 0.2
4700, 1.8666666666667, 2.7755575615629e-17, 0.2
4701, 1.9333333333333, 2.7755575615629e-17, 0.2
4702, 2, 2.7755575615629e-17, 0.2
4703, 2.0666666666667, 2.7755575615629e-17, 0.2
4704, 2.1333333333333, 2.7755575615629e-17, 0.2
4705, 1.2666666666667, 2.7755575615629e-17, 0.23333333333333
4706, 1.3333333333333, 2.7755575615629e-17, 0.23333333333333
4707, 1.4, 2.7755575615629e-17, 0.23333333333333
4708, 1.4666666666667, 2.7755575615629e-17, 0.23333333333333
4709, 1.5333333333333, 2.7755575615629e-17, 0.23333333333333
4710, 1.6, 2.7755575615629e-17, 0.23333333333333
4711, 1.6666666666667, 2.7755575615629e-17, 0.23333333333333
4712, 1.7333333333333, 2.7755575615629e-17, 0.23333333333333
4713, 1.8, 2.7755575615629e-17, 0.23333333333333
4714, 1.8666666666667, 2.7755575615629e-17, 0.23333333333333
4715, 1.9333333333333, 2.7755575615629e-17, 0.23333333333333
4716, 2, 2.7755575615629e-17, 0.23333333333333
4717, 2.0666666666667, 2.7755575615629e-17, 0.23333333333333
4718, 2.1333333333333, 2.7755575615629e-17, 0.23333333333333
4719, 1.2666666666667, 2.7755575615629e-17, 0.26666666666667
4720, 1.3333333333333, 2.7755575615629e-17, 0.26666666666667
4721, 1.4, 2.7755575615629e-17, 0.26666666666667
4722, 1.4666666666667, 2.7755575615629e-17, 0.26666666666667
4723, 1.5333333333333, 2.7755575615629e-17, 0.26666666666667
4724, 1.6, 2.7755575615629e-17, 0.26666666666667
4725, 1.6666666666667, 2.7755575615629e-17, 0.26666666666667
4726, 1.7333333333333, 2.7755575615629e-17, 0.26666666666667
4727, 1.8, 2.7755575615629e-17, 0.26666666666667
4728, 1.8666666666667, 2.7755575615629e-17, 0.26666666666667
4729, 1.9333333333333, 2.7755575615629e-17, 0.26666666666667
4730, 2, 2.7755575615629e-17, 0.26666666666667
4731, 2.0666666666667, 2.7755575615629e-17, 0.26666666666667
4732, 2.1333333333333, 2.7755575615629e-17, 0.26666666666667
4733, 1.2666666666667, 2.7755575615629e-17, 0.3
4734, 1.3333333333333, 2.7755575615629e-17, 0.3
4735, 1.4, 2.7755575615629e-17, 0.3
4736, 1.4666666666667, 2.7755575615629e-17, 0.3
4737, 1.5333333333333, 2.7755575615629e-17, 0.3
4738, 1.6, 2.7755575615629e-17, 0.3
4739, 1.6666666666667, 2.7755575615629e-17, 0.3
4740, 1.7333333333333, 2.7755575615629e-17, 0.3
4741, 1.8, 2.7755575615629e-17, 0.3
4742, 1.8666666666667, 2.7755575615629e-17, 0.3
4743, 1.9333333333333, 2.7755575615629e-17, 0.3
4744, 2, 2.7755575615629e-17, 0.3
4745, 2.0666666666667, 2.7755575615629e-17, 0.3
4746, 2.1333333333333, 2.7755575615629e-17, 0.3
4747, 1.2666666666667, 2.7755575615629e-17, 0.33333333333333
4748, 1.3333333333333, 2.7755575615629e-17, 0.33333333333333
4749, 1.4, 2.7755575615629e-17, 0.33333333333333
4750, 1.4666666666667, 2.7755575615629e-17, 0.33333333333333
4751, 1.5333333333333, 2.7755575615629e-17, 0.33333333333333
4752, 1.6, 2.7755575615629e-17, 0.33333333333333
4753, 1.6666666666667, 2.7755575615629e-17, 0.33333333333333
4754, 1.7333333333333, 2.7755575615629e-17, 0.33333333333333
4755, 1.8, 2.7755575615629e-17, 0.33333333333333
4756, 1.8666666666667, 2.7755575615629e-17, 0.33333333333333
4757, 1.9333333333333, 2.7755575615629e-17, 0.33333333333333
4758, 2, 2.7755575615629e-17, 0.33333333333333
4759, 2.0666666666667, 2.7755575615629e-17, 0.33333333333333
4760, 2.1333333333333, 2.7755575615629e-17, 0.33333333333333
4761, 1.2666666666667, 2.7755575615629e-17, 0.36666666666667
4762, 1.3333333333333, 2.7755575615629e-17, 0.36666666666667
4763, 1.4, 2.7755575615629e-17, 0.36666666666667
4764, 1.4666666666667, 2.7755575615629e-17, 0.36666666666667
4765, 1.5333333333333, 2.7755575615629e-17, 0.36666666666667
4766, 1.6, 2.7755575615629e-17, 0.36666666666667
4767, 1.6666666666667, 2.7755575615629e-17, 0.36666666666667
4768, 1.7333333333333, 2.7755575615629e-17, 0.36666666666667
4769, 1.8, 2.7755575615629e-17, 0.36666666666667
4770, 1.8666666666667, 2.7755575615629e-17, 0.36666666666667
4771, 1.9333333333333, 2.7755575615629e-17, 0.36666666666667
4772, 2, 2.7755575615629e-17, 0.36666666666667
4773, 2.0666666666667, 2.7755575615629e-17, 0.36666666666667
4774, 2.1333333333333, 2.7755575615629e-17, 0.36666666666667
4775, 1.2666666666667, 2.7755575615629e-17, 0.4
4776, 1.3333333333333, 2.7755575615629e-17, 0.4
4777, 1.4, 2.7755575615629e-17, 0.4
4778, 1.4666666666667, 2.7755575615629e-17, 0.4
4779, 1.5333333333333, 2.7755575615629e-17, 0.4
4780, 1.6, 2.7755575615629e-17, 0.4
4781, 1.6666666666667, 2.7755575615629e-17, 0.4
4782, 1.7333333333333, 2.7755575615629e-17, 0.4
4783, 1.8, 2.7755575615629e-17, 0.4
4784, 1.8666666666667, 2.7755575615629e-17, 0.4
4785, 1.9333333333333, 2.7755575615629e-17, 0.4
4786, 2, 2.7755575615629e-17, 0.4
4787, 2.0666666666667, 2.7755575615629e-17, 0.4
4788, 2.1333333333333, 2.7755575615629e-17, 0.4
4789, 1.2666666666667, 2.7755575615629e-17, 0.43333333333333
4790, 1.3333333333333, 2.7755575615629e-17, 0.43333333333333
4791, 1.4, 2.7755575615629e-17, 0.43333333333333
4792, 1.4666666666667, 2.7755575615629e-17, 0.43333333333333
4793, 1.5333333333333, 2.7755575615629e-17, 0.43333333333333
4794, 1.6, 2.7755575615629e-17, 0.43333333333333
4795, 1.6666666666667, 2.7755575615629e-17, 0.43333333333333
4796, 1.7333333333333, 2.7755575615629e-17, 0.43333333333333
4797, 1.8, 2.7755575615629e-17, 0.43333333333333
4798, 1.8666666666667, 2.7755575615629e-17, 0.43333333333333
4799, 1.9333333333333, 2.7755575615629e-17, 0.43333333333333
4800, 2, 2.7755575615629e-17, 0.43333333333333
4801, 2.0666666666667, 2.7755575615629e-17, 0.43333333333333
4802, 2.1333333333333, 2.7755575615629e-17, 0.43333333333333
4803, 1.2666666666667, 2.7755575615629e-17, 0.46666666666667
4804, 1.3333333333333, 2.7755575615629e-17, 0.46666666666667
4805, 1.4, 2.7755575615629e-17, 0.46666666666667
4806, 1.4666666666667, 2.7755575615629e-17, 0.46666666666667
4807, 1.5333333333333, 2.7755575615629e-17, 0.46666666666667
4808, 1.6, 2.7755575615629e-17, 0.46666666666667
4809, 1.6666666666667, 2.7755575615629e-17, 0.46666666666667
4810, 1.7333333333333, 2.7755575615629e-17, 0.46666666666667
4811, 1.8, 2.7755575615629e-17, 0.46666666666667
4812, 1.8666666666667, 2.7755575615629e-17, 0.46666666666667
4813, 1.9333333333333, 2.7755575615629e-17, 0.46666666666667
4814, 2, 2.7755575615629e-17, 0.46666666666667
4815, 2.0666666666667, 2.7755575615629e-17, 0.46666666666667
4816, 2.1333333333333, 2.7755575615629e-17, 0.46666666666667
4817, 0.066666666666667, 0.35333333333333, 0.033333333333333
4818, 0.066666666666667, 0.40666666666667, 0.033333333333333
4819, 0.066666666666667, 0.46, 0.033333333333333
4820, 0.066666666666667, 0.51333333333333, 0.033333333333333
4821, 0.066666666666667, 0.56666666666667, 0.033333333333333
4822, 0.066666666666667, 0.62, 0.033333333333333
4823, 0.066666666666667, 0.67333333333333, 0.033333333333333
4824, 0.066666666666667, 0.72666666666667, 0.033333333333333
4825, 0.066666666666667, 0.78, 0.033333333333333
4826, 0.066666666666667, 0.83333333333333, 0.033333333333333
4827, 0.066666666666667, 0.88666666666667, 0.033333333333333
4828, 0.066666666666667, 0.94, 0.033333333333333
4829, 0.066666666666667, 0.99333333333333, 0.033333333333333
4830, 0.066666666666667, 1.0466666666667, 0.033333333333333
4831, 0.066666666666667, 0.35333333333333, 0.066666666666667
4832, 0.066666666666667, 0.40666666666667, 0.066666666666667
4833, 0.066666666666667, 0.46, 0.066666666666667
4834, 0.066666666666667, 0.51333333333333, 0.066666666666667
4835, 0.066666666666667, 0.56666666666667, 0.066666666666667
4836, 0.066666666666667, 0.62, 0.066666666666667
4837, 0.066666666666667, 0.67333333333333, 0.066666666666667
4838, 0.066666666666667, 0.72666666666667, 0.066666666666667
4839, 0.066666666666667, 0.78, 0.066666666666667
4840, 0.066666666666667, 0.83333333333333, 0.066666666666667
4841, 0.066666666666667, 0.88666666666667, 0.066666666666667
4842, 0.066666666666667, 0.94, 0.066666666666667
4843, 0.066666666666667, 0.99333333333333, 0.066666666666667
4844, 0.066666666666667, 1.0466666666667, 0.066666666666667
4845, 0.066666666666667, 0.35333333333333, 0.1
4846, 0.066666666666667, 0.40666666666667, 0.1
4847, 0.066666666666667, 0.46, 0.1
4848, 0.066666666666667, 0.51333333333333, 0.1
4849, 0.066666666666667, 0.56666666666667, 0.1
4850, 0.066666666666667, 0.62, 0.1
4851, 0.066666666666667, 0.67333333333333, 0.1
4852, 0.066666666666667, 0.72666666666667, 0.1
4853, 0.066666666666667, 0.78, 0.1
4854, 0.066666666666667, 0.83333333333333, 0.1
4855, 0.066666666666667, 0.88666666666667, 0.1
4856, 0.066666666666667, 0.94, 0.1
4857, 0.066666666666667, 0.99333333333333, 0.1
4858, 0.066666666666667, 1.0466666666667, 0.1
4859, 0.066666666666667, 0.35333333333333, 0.13333333333333
4860, 0.066666666666667, 0.40666666666667, 0.13333333333333
4861, 0.066666666666667, 0.46, 0.13333333333333
4862, 0.066666666666667, 0.51333333333333, 0.13333333333333
4863, 0.066666666666667, 0.56666666666667, 0.13333333333333
4864, 0.066666666666667, 0.62, 0.13333333333333
4865, 0.066666666666667, 0.67333333333333, 0.13333333333333
4866, 0.066666666666667, 0.72666666666667, 0.13333333333333
4867, 0.066666666666667, 0.78, 0.13333333333333
4868, 0.066666666666667, 0.83333333333333, 0.13333333333333
4869, 0.066666666666667, 0.88666666666667, 0.13333333333333
4870, 0.066666666666667, 0.94, 0.13333333333333
4871, 0.066666666666667, 0.99333333333333, 0.13333333333333
4872, 0.066666666666667, 1.0466666666667, 0.13333333333333
4873, 0.066666666666667, 0.35333333333333, 0.16666666666667
4874, 0.066666666666667, 0.40666666666667, 0.16666666666667
4875, 0.066666666666667, 0.46, 0.16666666666667
4876, 0.066666666666667, 0.51333333333333, 0.16666666666667
4877, 0.066666666666667, 0.56666666666667, 0.16666666666667
4878, 0.066666666666667, 0.62, 0.16666666666667
4879, 0.066666666666667, 0.67333333333333, 0.16666666666667
4880, 0.066666666666667, 0.72666666666667, 0.16666666666667
4881, 0.066666666666667, 0.78, 0.16666666666667
4882, 0.066666666666667, 0.83333333333333, 0.16666666666667
4883, 0.066666666666667, 0.88666666666667, 0.16666666666667
4884, 0.066666666666667, 0.94, 0.16666666666667
4885, 0.066666666666667, 0.99333333333333, 0.16666666666667
4886, 0.066666666666667, 1.0466666666667, 0.16666666666667
4887, 0.066666666666667, 0.35333333333333, 0.2
4888, 0.066666666666667, 0.40666666666667, 0.2
4889, 0.066666666666667, 0.46, 0.2
4890, 0.066666666666667, 0.51333333333333, 0.2
4891, 0.066666666666667, 0.56666666666667, 0.2
4892, 0.066666666666667, 0.62, 0.2
4893, 0.066666666666667, 0.67333333333333, 0.2
4894, 0.066666666666667, 0.72666666666667, 0.2
4895, 0.066666666666667, 0.78, 0.2
4896, 0.066666666666667, 0.83333333333333, 0.2
4897, 0.066666666666667, 0.88666666666667, 0.2
4898, 0.066666666666667, 0.94, 0.2
4899, 0.066666666666667, 0.99333333333333, 0.2
4900, 0.066666666666667, 1.0466666666667, 0.2
4901, 0.066666666666667, 0.35333333333333, 0.23333333333333
4902, 0.066666666666667, 0.40666666666667, 0.23333333333333
4903, 0.066666666666667, 0.46, 0.23333333333333
4904, 0.066666666666667, 0.51333333333333, 0.23333333333333
4905, 0.066666666666667, 0.56666666666667, 0.23333333333333
4906, 0.066666666666667, 0.62, 0.23333333333333
4907, 0.066666666666667, 0.67333333333333, 0.23333333333333
4908, 0.066666666666667, 0.72666666666667, 0.23333333333333
4909, 0.066666666666667, 0.78, 0.23333333333333
4910, 0.066666666666667, 0.83333333333333, 0.23333333333333
4911, 0.066666666666667, 0.88666666666667, 0.23333333333333
4912, 0.066666666666667, 0.94, 0.23333333333333
4913, 0.066666666666667, 0.99333333333333, 0.23333333333333
4914, 0.066666666666667, 1.0466666666667, 0.23333333333333
4915, 0.066666666666667, 0.35333333333333, 0.26666666666667
4916, 0.066666666666667, 0.40666666666667, 0.26666666666667
4917, 0.066666666666667, 0.46, 0.26666666666667
4918, 0.066666666666667, 0.51333333333333, 0.26666666666667
4919, 0.066666666666667, 0.56666666666667, 0.26666666666667
4920, 0.066666666666667, 0.62, 0.26666666666667
4921, 0.066666666666667, 0.67333333333333, 0.26666666666667
4922, 0.066666666666667, 0.72666666666667, 0.26666666666667
4923, 0.066666666666667, 0.78, 0.26666666666667
4924, 0.066666666666667, 0.83333333333333, 0.26666666666667
4925, 0.066666666666667, 0.88666666666667, 0.26666666666667
4926, 0.066666666666667, 0.94, 0.26666666666667
4927, 0.066666666666667, 0.99333333333333, 0.26666666666667
4928, 0.066666666666667, 1.0466666666667, 0.26666666666667
4929, 0.066666666666667, 0.35333333333333, 0.3
4930, 0.066666666666667, 0.40666666666667, 0.3
4931, 0.066666666666667, 0.46, 0.3
4932, 0.066666666666667, 0.51333333333333, 0.3
4933, 0.066666666666667, 0.56666666666667, 0.3
4934, 0.066666666666667, 0.62, 0.3
4935, 0.066666666666667, 0.67333333333333, 0.3
4936, 0.066666666666667, 0.72666666666667, 0.3
4937, 0.066666666666667, 0.78, 0.3
4938, 0.066666666666667, 0.83333333333333, 0.3
4939, 0.066666666666667, 0.88666666666667, 0.3
4940, 0.066666666666667, 0.94, 0.3
4941, 0.066666666666667, 0.99333333333333, 0.3
4942, 0.066666666666667, 1.0466666666667, 0.3
4943, 0.066666666666667, 0.35333333333333, 0.33333333333333
4944, 0.066666666666667, 0.40666666666667, 0.33333333333333
4945, 0.066666666666667, 0.46, 0.33333333333333
4946, 0.066666666666667, 0.51333333333333, 0.33333333333333
4947, 0.066666666666667, 0.56666666666667, 0.33333333333333
4948, 0.066666666666667, 0.62, 0.33333333333333
4949, 0.066666666666667, 0.67333333333333, 0.33333333333333
4950, 0.066666666666667, 0.72666666666667, 0.33333333333333
4951, 0.066666666666667, 0.78, 0.33333333333333
4952, 0.066666666666667, 0.83333333333333, 0.33333333333333
4953, 0.066666666666667, 0.88666666666667, 0.33333333333333
4954, 0.066666666666667, 0.94, 0.33333333333333
4955, 0.066666666666667, 0.99333333333333, 0.33333333333333
4956, 0.066666666666667, 1.0466666666667, 0.33333333333333
4957, 0.066666666666667, 0.35333333333333, 0.36666666666667
4958, 0.066666666666667, 0.40666666666667, 0.36666666666667
4959, 0.066666666666667, 0.46, 0.36666666666667
4960, 0.066666666666667, 0.51333333333333, 0.36666666666667
4961, 0.066666666666667, 0.56666666666667, 0.36666666666667
4962, 0.066666666666667, 0.62, 0.36666666666667
4963, 0.066666666666667, 0.67333333333333, 0.36666666666667
4964, 0.066666666666667, 0.72666666666667, 0.36666666666667
4965, 0.066666666666667, 0.78, 0.36666666666667
4966, 0.066666666666667, 0.83333333333333, 0.36666666666667
4967, 0.066666666666667, 0.88666666666667, 0.36666666666667
4968, 0.066666666666667, 0.94, 0.36666666666667
4969, 0.066666666666667, 0.99333333333333, 0.36666666666667
4970, 0.066666666666667, 1.0466666666667, 0.36666666666667
4971, 0.066666666666667, 0.35333333333333, 0.4
4972, 0.066666666666667, 0.40666666666667, 0.4
4973, 0.066666666666667, 0.46, 0.4
4974, 0.066666666666667, 0.51333333333333, 0.4
4975, 0.066666666666667, 0.56666666666667, 0.4
4976, 0.066666666666667, 0.62, 0.4
4977, 0.066666666666667, 0.67333333333333, 0.4
4978, 0.066666666666667, 0.72666666666667, 0.4
4979, 0.066666666666667, 0.78, 0.4
4980, 0.066666666666667, 0.83333333333333, 0.4
4981, 0.066666666666667, 0.88666666666667, 0.4
4982, 0.066666666666667, 0.94, 0.4
4983, 0.066666666666667, 0.99333333333333, 0.4
4984, 0.066666666666667, 1.0466666666667, 0.4
4985, 0.066666666666667, 0.35333333333333, 0.43333333333333
4986, 0.066666666666667, 0.40666666666667, 0.43333333333333
4987, 0.066666666666667, 0.46, 0.43333333333333
4988, 0.066666666666667, 0.51333333333333, 0.43333333333333
4989, 0.066666666666667, 0.56666666666667, 0.43333333333333
4990, 0.066666666666667, 0.62, 0.43333333333333
4991, 0.066666666666667, 0.67333333333333, 0.43333333333333
4992, 0.066666666666667, 0.72666666666667, 0.43333333333333
4993, 0.066666666666667, 0.78, 0.43333333333333
4994, 0.066666666666667, 0.83333333333333, 0.43333333333333
4995, 0.066666666666667, 0.88666666666667, 0.43333333333333
4996, 0.066666666666667, 0.94, 0.43333333333333
4997, 0.066666666666667, 0.99333333333333, 0.43333333333333
4998, 0.066666666666667, 1.0466666666667, 0.43333333333333
4999, 0.066666666666667, 0.35333333333333, 0.46666666666667
5000, 0.066666666666667, 0.40666666666667, 0.46666666666667
5001, 0.066666666666667, 0.46, 0.46666666666667
5002, 0.066666666666667, 0.51333333333333, 0.46666666666667
5003, 0.066666666666667, 0.56666666666667, 0.46666666666667
5004, 0.066666666666667, 0.62, 0.46666666666667
5005, 0.066666666666667, 0.67333333333333, 0.46666666666667
5006, 0.066666666666667, 0.72666666666667, 0.46666666666667
5007, 0.066666666666667, 0.78, 0.46666666666667
5008, 0.066666666666667, 0.83333333333333, 0.46666666666667
5009, 0.066666666666667, 0.88666666666667, 0.46666666666667
5010, 0.066666666666667, 0.94, 0.46666666666667
5011, 0.066666666666667, 0.99333333333333, 0.46666666666667
5012, 0.066666666666667, 1.0466666666667, 0.46666666666667
5013, 0.13333333333333, 0.35333333333333, 0.033333333333333
5014, 0.13333333333333, 0.40666666666667, 0.033333333333333
5015, 0.13333333333333, 0.46, 0.033333333333333
5016, 0.13333333333333, 0.51333333333333, 0.033333333333333
5017, 0.13333333333333, 0.56666666666667, 0.033333333333333
5018, 0.13333333333333, 0.62, 0.033333333333333
5019, 0.13333333333333, 0.67333333333333, 0.033333333333333
5020, 0.13333333333333, 0.72666666666667, 0.033333333333333
5021, 0.13333333333333, 0.78, 0.033333333333333
5022, 0.13333333333333, 0.83333333333333, 0.033333333333333
5023, 0.13333333333333, 0.88666666666667, 0.033333333333333
5024, 0.13333333333333, 0.94, 0.033333333333333
5025, 0.13333333333333, 0.99333333333333, 0.033333333333333
5026, 0.13333333333333, 1.0466666666667, 0.033333333333333
5027, 0.13333333333333, 0.35333333333333, 0.066666666666667
5028, 0.13333333333333, 0.40666666666667, 0.066666666666667
5029, 0.13333333333333, 0.46, 0.066666666666667
5030, 0.13333333333333, 0.51333333333333, 0.066666666666667
5031, 0.13333333333333, 0.56666666666667, 0.066666666666667
5032, 0.13333333333333, 0.62, 0.066666666666667
5033, 0.13333333333333, 0.67333333333333, 0.066666666666667
5034, 0.13333333333333, 0.72666666666667, 0.066666666666667
5035, 0.13333333333333, 0.78, 0.066666666666667
5036, 0.13333333333333, 0.83333333333333, 0.066666666666667
5037, 0.13333333333333, 0.88666666666667, 0.066666666666667
5038, 0.13333333333333, 0.94, 0.066666666666667
5039, 0.13333333333333, 0.99333333333333, 0.066666666666667
5040, 0.13333333333333, 1.0466666666667, 0.066666666666667
5041, 0.13333333333333, 0.35333333333333, 0.1
5042, 0.13333333333333, 0.40666666666667, 0.1
5043, 0.13333333333333, 0.46, 0.1
5044, 0.13333333333333, 0.51333333333333, 0.1
5045, 0.13333333333333, 0.56666666666667, 0.1
5046, 0.13333333333333, 0.62, 0.1
5047, 0.13333333333333, 0.67333333333333, 0.1
5048, 0.13333333333333, 0.72666666666667, 0.1
5049, 0.13333333333333, 0.78, 0.1
5050, 0.13333333333333, 0.83333333333333, 0.1
5051, 0.13333333333333, 0.88666666666667, 0.1
5052, 0.13333333333333, 0.94, 0.1
5053, 0.13333333333333, 0.99333333333333, 0.1
5054, 0.13333333333333, 1.0466666666667, 0.1
5055, 0.13333333333333, 0.35333333333333, 0.13333333333333
5056, 0.13333333333333, 0.40666666666667, 0.13333333333333
5057, 0.13333333333333, 0.46, 0.13333333333333
5058, 0.13333333333333, 0.51333333333333, 0.13333333333333
5059, 0.13333333333333, 0.56666666666667, 0.13333333333333
5060, 0.13333333333333, 0.62, 0.13333333333333
5061, 0.13333333333333, 0.67333333333333, 0.13333333333333
5062, 0.13333333333333, 0.72666666666667, 0.13333333333333
5063, 0.13333333333333, 0.78, 0.13333333333333
5064, 0.13333333333333, 0.83333333333333, 0.13333333333333
5065, 0.13333333333333, 0.88666666666667, 0.13333333333333
5066, 0.13333333333333, 0.94, 0.13333333333333
5067, 0.13333333333333, 0.99333333333333, 0.13333333333333
5068, 0.13333333333333, 1.0466666666667, 0.13333333333333
5069, 0.13333333333333, 0.35333333333333, 0.16666666666667
5070, 0.13333333333333, 0.40666666666667, 0.16666666666667
5071, 0.13333333333333, 0.46, 0.16666666666667
5072, 0.13333333333333, 0.51333333333333, 0.16666666666667
5073, 0.13333333333333, 0.56666666666667, 0.16666666666667
5074, 0.13333333333333, 0.62, 0.16666666666667
5075, 0.13333333333333, 0.67333333333333, 0.16666666666667
5076, 0.13333333333333, 0.72666666666667, 0.16666666666667
5077, 0.13333333333333, 0.78, 0.16666666666667
5078, 0.13333333333333, 0.83333333333333, 0.16666666666667
5079, 0.13333333333333, 0.88666666666667, 0.16666666666667
5080, 0.13333333333333, 0.94, 0.16666666666667
5081, 0.13333333333333, 0.99333333333333, 0.16666666666667
5082, 0.13333333333333, 1.0466666666667, 0.16666666666667
5083, 0.13333333333333, 0.35333333333333, 0.2
5084, 0.13333333333333, 0.40666666666667, 0.2
5085, 0.13333333333333, 0.46, 0.2
5086, 0.13333333333333, 0.51333333333333, 0.2
5087, 0.13333333333333, 0.56666666666667, 0.2
5088, 0.13333333333333, 0.62, 0.2
5089, 0.13333333333333, 0.67333333333333, 0.2
5090, 0.13333333333333, 0.72666666666667, 0.2
5091, 0.13333333333333, 0.78, 0.2
5092, 0.13333333333333, 0.83333333333333, 0.2
5093, 0.13333333333333, 0.88666666666667, 0.2
5094, 0.13333333333333, 0.94, 0.2
5095, 0.13333333333333, 0.99333333333333, 0.2
5096, 0.13333333333333, 1.0466666666667, 0.2
5097, 0.13333333333333, 0.35333333333333, 0.23333333333333
5098, 0.13333333333333, 0.40666666666667, 0.23333333333333
5099, 0.13333333333333, 0.46, 0.23333333333333
5100, 0.13333333333333, 0.51333333333333, 0.23333333333333
5101, 0.13333333333333, 0.56666666666667, 0.23333333333333
5102, 0.13333333333333, 0.62, 0.23333333333333
5103, 0.13333333333333, 0.67333333333333, 0.23333333333333
5104, 0.13333333333333, 0.72666666666667, 0.23333333333333
5105, 0.13333333333333, 0.78, 0.23333333333333
5106, 0.13333333333333, 0.83333333333333, 0.23333333333333
5107, 0.13333333333333, 0.88666666666667, 0.23333333333333
5108, 0.13333333333333, 0.94, 0.23333333333333
5109, 0.13333333333333, 0.99333333333333, 0.23333333333333
5110, 0.13333333333333, 1.0466666666667, 0.23333333333333
5111, 0.13333333333333, 0.35333333333333, 0.26666666666667
5112, 0.13333333333333, 0.40666666666667, 0.26666666666667
5113, 0.13333333333333, 0.46, 0.26666666666667
5114, 0.13333333333333, 0.51333333333333, 0.26666666666667
5115, 0.13333333333333, 0.56666666666667, 0.26666666666667
5116, 0.13333333333333, 0.62, 0.26666666666667
5117, 0.13333333333333, 0.67333333333333, 0.26666666666667
5118, 0.13333333333333, 0.72666666666667, 0.26666666666667
5119, 0.13333333333333, 0.78, 0.26666666666667
5120, 0.13333333333333, 0.83333333333333, 0.26666666666667
5121, 0.13333333333333, 0.88666666666667, 0.26666666666667
5122, 0.13333333333333, 0.94, 0.26666666666667
5123, 0.13333333333333, 0.99333333333333, 0.26666666666667
5124, 0.13333333333333, 1.0466666666667, 0.26666666666667
5125, 0.13333333333333, 0.35333333333333, 0.3
5126, 0.13333333333333, 0.40666666666667, 0.3
5127, 0.13333333333333, 0.46, 0.3
5128, 0.13333333333333, 0.51333333333333, 0.3
5129, 0.13333333333333, 0.56666666666667, 0.3
5130, 0.13333333333333, 0.62, 0.3
5131, 0.13333333333333, 0.67333333333333, 0.3
5132, 0.13333333333333, 0.72666666666667, 0.3
5133, 0.13333333333333, 0.78, 0.3
5134, 0.13333333333333, 0.83333333333333, 0.3
5135, 0.13333333333333, 0.88666666666667, 0.3
5136, 0.13333333333333, 0.94, 0.3
5137, 0.13333333333333, 0.99333333333333, 0.3
5138, 0.13333333333333, 1.0466666666667, 0.3
5139, 0.13333333333333, 0.35333333333333, 0.33333333333333
5140, 0.13333333333333, 0.40666666666667, 0.33333333333333
5141, 0.13333333333333, 0.46, 0.33333333333333
5142, 0.13333333333333, 0.51333333333333, 0.33333333333333
5143, 0.13333333333333, 0.56666666666667, 0.33333333333333
5144, 0.13333333333333, 0.62, 0.33333333333333
5145, 0.13333333333333, 0.67333333333333, 0.33333333333333
5146, 0.13333333333333, 0.72666666666667, 0.33333333333333
5147, 0.13333333333333, 0.78, 0.33333333333333
5148, 0.13333333333333, 0.83333333333333, 0.33333333333333
5149, 0.13333333333333, 0.88666666666667, 0.33333333333333
5150, 0.13333333333333, 0.94, 0.33333333333333
5151, 0.13333333333333, 0.99333333333333, 0.33333333333333
5152, 0.13333333333333, 1.0466666666667, 0.33333333333333
5153, 0.13333333333333, 0.35333333333333, 0.36666666666667
5154, 0.13333333333333, 0.40666666666667, 0.36666666666667
5155, 0.13333333333333, 0.46, 0.36666666666667
5156, 0.13333333333333, 0.51333333333333, 0.36666666666667
5157, 0.13333333333333, 0.56666666666667, 0.36666666666667
5158, 0.13333333333333, 0.62, 0.36666666666667
5159, 0.13333333333333, 0.67333333333333, 0.36666666666667
5160, 0.13333333333333, 0.72666666666667, 0.36666666666667
5161, 0.13333333333333, 0.78, 0.36666666666667
5162, 0.13333333333333, 0.83333333333333, 0.36666666666667
5163, 0.13333333333333, 0.88666666666667, 0.36666666666667
5164, 0.13333333333333, 0.94, 0.36666666666667
5165, 0.13333333333333, 0.99333333333333, 0.36666666666667
5166, 0.13333333333333, 1.0466666666667, 0.36666666666667
5167, 0.13333333333333, 0.35333333333333, 0.4
5168, 0.13333333333333, 0.40666666666667, 0.4
5169, 0.13333333333333, 0.46, 0.4
5170, 0.13333333333333, 0.51333333333333, 0.4
5171, 0.13333333333333, 0.56666666666667, 0.4
5172, 0.13333333333333, 0.62, 0.4
5173, 0.13333333333333, 0.67333333333333, 0.4
5174, 0.13333333333333, 0.72666666666667, 0.4
5175, 0.13333333333333, 0.78, 0.4
5176, 0.13333333333333, 0.83333333333333, 0.4
5177, 0.13333333333333, 0.88666666666667, 0.4
5178, 0.13333333333333, 0.94, 0.4
5179, 0.13333333333333, 0.99333333333333, 0.4
5180, 0.13333333333333, 1.0466666666667, 0.4
5181, 0.13333333333333, 0.35333333333333, 0.43333333333333
5182, 0.13333333333333, 0.40666666666667, 0.43333333333333
5183, 0.13333333333333, 0.46, 0.43333333333333
5184, 0.13333333333333, 0.51333333333333, 0.43333333333333
5185, 0.13333333333333, 0.56666666666667, 0.43333333333333
5186, 0.13333333333333, 0.62, 0.43333333333333
5187, 0.13333333333333, 0.67333333333333, 0.43333333333333
5188, 0.13333333333333, 0.72666666666667, 0.43333333333333
5189, 0.13333333333333, 0.78, 0.43333333333333
5190, 0.13333333333333, 0.83333333333333, 0.43333333333333
5191, 0.13333333333333, 0.88666666666667, 0.43333333333333
5192, 0.13333333333333, 0.94, 0.43333333333333
5193, 0.13333333333333, 0.99333333333333, 0.43333333333333
5194, 0.13333333333333, 1.0466666666667, 0.43333333333333
5195, 0.13333333333333, 0.35333333333333, 0.46666666666667
5196, 0.13333333333333, 0.40666666666667, 0.46666666666667
5197, 0.13333333333333, 0.46, 0.46666666666667
5198, 0.13333333333333, 0.51333333333333, 0.46666666666667
5199, 0.13333333333333, 0.56666666666667, 0.46666666666667
5200, 0.13333333333333, 0.62, 0.46666666666667
5201, 0.13333333333333, 0.67333333333333, 0.46666666666667
5202, 0.13333333333333, 0.72666666666667, 0.46666666666667
5203, 0.13333333333333, 0.78, 0.46666666666667
5204, 0.13333333333333, 0.83333333333333, 0.46666666666667
5205, 0.13333333333333, 0.88666666666667, 0.46666666666667
5206, 0.13333333333333, 0.94, 0.46666666666667
5207, 0.13333333333333, 0.99333333333333, 0.46666666666667
5208, 0.13333333333333, 1.0466666666667, 0.46666666666667
5209, 0.2, 0.35333333333333, 0.033333333333333
5210, 0.2, 0.40666666666667, 0.033333333333333
5211, 0.2, 0.46, 0.033333333333333
5212, 0.2, 0.51333333333333, 0.033333333333333
5213, 0.2, 0.56666666666667, 0.033333333333333
5214, 0.2, 0.62, 0.033333333333333
5215, 0.2, 0.67333333333333, 0.033333333333333
5216, 0.2, 0.72666666666667, 0.033333333333333
5217, 0.2, 0.78, 0.033333333333333
5218, 0.2, 0.83333333333333, 0.033333333333333
5219, 0.2, 0.88666666666667, 0.033333333333333
5220, 0.2, 0.94, 0.033333333333333
5221, 0.2, 0.99333333333333, 0.033333333333333
5222, 0.2, 1.0466666666667, 0.033333333333333
5223, 0.2, 0.35333333333333, 0.066666666666667
5224, 0.2, 0.40666666666667, 0.066666666666667
5225, 0.2, 0.46, 0.066666666666667
5226, 0.2, 0.51333333333333, 0.066666666666667
5227, 0.2, 0.56666666666667, 0.066666666666667
5228, 0.2, 0.62, 0.066666666666667
5229, 0.2, 0.67333333333333, 0.066666666666667
5230, 0.2, 0.72666666666667, 0.066666666666667
5231, 0.2, 0.78, 0.066666666666667
5232, 0.2, 0.83333333333333, 0.066666666666667
5233, 0.2, 0.88666666666667, 0.066666666666667
5234, 0.2, 0.94, 0.066666666666667
5235, 0.2, 0.99333333333333, 0.066666666666667
5236, 0.2, 1.0466666666667, 0.066666666666667
5237, 0.2, 0.35333333333333, 0.1
5238, 0.2, 0.40666666666667, 0.1
5239, 0.2, 0.46, 0.1
5240, 0.2, 0.51333333333333, 0.1
5241, 0.2, 0.56666666666667, 0.1
5242, 0.2, 0.62, 0.1
5243, 0.2, 0.67333333333333, 0.1
5244, 0.2, 0.72666666666667, 0.1
5245, 0.2, 0.78, 0.1
5246, 0.2, 0.83333333333333, 0.1
5247, 0.2, 0.88666666666667, 0.1
5248, 0.2, 0.94, 0.1
5249, 0.2, 0.99333333333333, 0.1
5250, 0.2, 1.0466666666667, 0.1
5251, 0.2, 0.35333333333333, 0.13333333333333
5252, 0.2, 0.40666666666667, 0.13333333333333
5253, 0.2, 0.46, 0.13333333333333
5254, 0.2, 0.51333333333333, 0.13333333333333
5255, 0.2, 0.56666666666667, 0.13333333333333
5256, 0.2, 0.62, 0.13333333333333
5257, 0.2, 0.67333333333333, 0.13333333333333
5258, 0.2, 0.72666666666667, 0.13333333333333
5259, 0.2, 0.78, 0.13333333333333
5260, 0.2, 0.83333333333333, 0.13333333333333
5261, 0.2, 0.88666666666667, 0.13333333333333
5262, 0.2, 0.94, 0.13333333333333
5263, 0.2, 0.99333333333333, 0.13333333333333
5264, 0.2, 1.0466666666667, 0.13333333333333
5265, 0.2, 0.35333333333333, 0.16666666666667
5266, 0.2, 0.40666666666667, 0.16666666666667
5267, 0.2, 0.46, 0.16666666666667
5268, 0.2, 0.51333333333333, 0.16666666666667
5269, 0.2, 0.56666666666667, 0.16666666666667
5270, 0.2, 0.62, 0.16666666666667
5271, 0.2, 0.67333333333333, 0.16666666666667
5272, 0.2, 0.72666666666667, 0.16666666666667
5273, 0.2, 0.78, 0.16666666666667
5274, 0.2, 0.83333333333333, 0.16666666666667
5275, 0.2, 0.88666666666667, 0.16666666666667
5276, 0.2, 0.94, 0.16666666666667
