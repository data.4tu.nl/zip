8448, 9746, 9760, 9956, 9942, 9747, 9761, 9957, 9943
8449, 9747, 9761, 9957, 9943, 9748, 9762, 9958, 9944
8450, 9748, 9762, 9958, 9944, 9749, 9763, 9959, 9945
8451, 9749, 9763, 9959, 9945, 9750, 9764, 9960, 9946
8452, 9750, 9764, 9960, 9946, 9751, 9765, 9961, 9947
8453, 9751, 9765, 9961, 9947, 9752, 9766, 9962, 9948
8454, 9752, 9766, 9962, 9948, 9753, 9767, 9963, 9949
8455, 9753, 9767, 9963, 9949, 9754, 9768, 9964, 9950
8456, 9754, 9768, 9964, 9950, 9755, 9769, 9965, 9951
8457, 9755, 9769, 9965, 9951, 9756, 9770, 9966, 9952
8458, 9756, 9770, 9966, 9952, 9757, 9771, 9967, 9953
8459, 9757, 9771, 9967, 9953, 9758, 9772, 9968, 9954
8460, 9758, 9772, 9968, 9954, 4385, 4386, 4400, 4399
8461, 3406, 3407, 3421, 3420, 9759, 9773, 9969, 9955
8462, 9759, 9773, 9969, 9955, 9760, 9774, 9970, 9956
8463, 9760, 9774, 9970, 9956, 9761, 9775, 9971, 9957
8464, 9761, 9775, 9971, 9957, 9762, 9776, 9972, 9958
8465, 9762, 9776, 9972, 9958, 9763, 9777, 9973, 9959
8466, 9763, 9777, 9973, 9959, 9764, 9778, 9974, 9960
8467, 9764, 9778, 9974, 9960, 9765, 9779, 9975, 9961
8468, 9765, 9779, 9975, 9961, 9766, 9780, 9976, 9962
8469, 9766, 9780, 9976, 9962, 9767, 9781, 9977, 9963
8470, 9767, 9781, 9977, 9963, 9768, 9782, 9978, 9964
8471, 9768, 9782, 9978, 9964, 9769, 9783, 9979, 9965
8472, 9769, 9783, 9979, 9965, 9770, 9784, 9980, 9966
8473, 9770, 9784, 9980, 9966, 9771, 9785, 9981, 9967
8474, 9771, 9785, 9981, 9967, 9772, 9786, 9982, 9968
8475, 9772, 9786, 9982, 9968, 4386, 4387, 4401, 4400
8476, 3407, 3408, 3422, 3421, 9773, 9787, 9983, 9969
8477, 9773, 9787, 9983, 9969, 9774, 9788, 9984, 9970
8478, 9774, 9788, 9984, 9970, 9775, 9789, 9985, 9971
8479, 9775, 9789, 9985, 9971, 9776, 9790, 9986, 9972
8480, 9776, 9790, 9986, 9972, 9777, 9791, 9987, 9973
8481, 9777, 9791, 9987, 9973, 9778, 9792, 9988, 9974
8482, 9778, 9792, 9988, 9974, 9779, 9793, 9989, 9975
8483, 9779, 9793, 9989, 9975, 9780, 9794, 9990, 9976
8484, 9780, 9794, 9990, 9976, 9781, 9795, 9991, 9977
8485, 9781, 9795, 9991, 9977, 9782, 9796, 9992, 9978
8486, 9782, 9796, 9992, 9978, 9783, 9797, 9993, 9979
8487, 9783, 9797, 9993, 9979, 9784, 9798, 9994, 9980
8488, 9784, 9798, 9994, 9980, 9785, 9799, 9995, 9981
8489, 9785, 9799, 9995, 9981, 9786, 9800, 9996, 9982
8490, 9786, 9800, 9996, 9982, 4387, 4388, 4402, 4401
8491, 3408, 3409, 3423, 3422, 9787, 9801, 9997, 9983
8492, 9787, 9801, 9997, 9983, 9788, 9802, 9998, 9984
8493, 9788, 9802, 9998, 9984, 9789, 9803, 9999, 9985
8494, 9789, 9803, 9999, 9985, 9790, 9804, 10000, 9986
8495, 9790, 9804, 10000, 9986, 9791, 9805, 10001, 9987
8496, 9791, 9805, 10001, 9987, 9792, 9806, 10002, 9988
8497, 9792, 9806, 10002, 9988, 9793, 9807, 10003, 9989
8498, 9793, 9807, 10003, 9989, 9794, 9808, 10004, 9990
8499, 9794, 9808, 10004, 9990, 9795, 9809, 10005, 9991
8500, 9795, 9809, 10005, 9991, 9796, 9810, 10006, 9992
8501, 9796, 9810, 10006, 9992, 9797, 9811, 10007, 9993
8502, 9797, 9811, 10007, 9993, 9798, 9812, 10008, 9994
8503, 9798, 9812, 10008, 9994, 9799, 9813, 10009, 9995
8504, 9799, 9813, 10009, 9995, 9800, 9814, 10010, 9996
8505, 9800, 9814, 10010, 9996, 4388, 4389, 4403, 4402
8506, 3409, 3410, 3424, 3423, 9801, 9815, 10011, 9997
8507, 9801, 9815, 10011, 9997, 9802, 9816, 10012, 9998
8508, 9802, 9816, 10012, 9998, 9803, 9817, 10013, 9999
8509, 9803, 9817, 10013, 9999, 9804, 9818, 10014, 10000
8510, 9804, 9818, 10014, 10000, 9805, 9819, 10015, 10001
8511, 9805, 9819, 10015, 10001, 9806, 9820, 10016, 10002
8512, 9806, 9820, 10016, 10002, 9807, 9821, 10017, 10003
8513, 9807, 9821, 10017, 10003, 9808, 9822, 10018, 10004
8514, 9808, 9822, 10018, 10004, 9809, 9823, 10019, 10005
8515, 9809, 9823, 10019, 10005, 9810, 9824, 10020, 10006
8516, 9810, 9824, 10020, 10006, 9811, 9825, 10021, 10007
8517, 9811, 9825, 10021, 10007, 9812, 9826, 10022, 10008
8518, 9812, 9826, 10022, 10008, 9813, 9827, 10023, 10009
8519, 9813, 9827, 10023, 10009, 9814, 9828, 10024, 10010
8520, 9814, 9828, 10024, 10010, 4389, 4390, 4404, 4403
8521, 3410, 3411, 3425, 3424, 9815, 9829, 10025, 10011
8522, 9815, 9829, 10025, 10011, 9816, 9830, 10026, 10012
8523, 9816, 9830, 10026, 10012, 9817, 9831, 10027, 10013
8524, 9817, 9831, 10027, 10013, 9818, 9832, 10028, 10014
8525, 9818, 9832, 10028, 10014, 9819, 9833, 10029, 10015
8526, 9819, 9833, 10029, 10015, 9820, 9834, 10030, 10016
8527, 9820, 9834, 10030, 10016, 9821, 9835, 10031, 10017
8528, 9821, 9835, 10031, 10017, 9822, 9836, 10032, 10018
8529, 9822, 9836, 10032, 10018, 9823, 9837, 10033, 10019
8530, 9823, 9837, 10033, 10019, 9824, 9838, 10034, 10020
8531, 9824, 9838, 10034, 10020, 9825, 9839, 10035, 10021
8532, 9825, 9839, 10035, 10021, 9826, 9840, 10036, 10022
8533, 9826, 9840, 10036, 10022, 9827, 9841, 10037, 10023
8534, 9827, 9841, 10037, 10023, 9828, 9842, 10038, 10024
8535, 9828, 9842, 10038, 10024, 4390, 4391, 4405, 4404
8536, 3411, 3412, 3426, 3425, 9829, 9843, 10039, 10025
8537, 9829, 9843, 10039, 10025, 9830, 9844, 10040, 10026
8538, 9830, 9844, 10040, 10026, 9831, 9845, 10041, 10027
8539, 9831, 9845, 10041, 10027, 9832, 9846, 10042, 10028
8540, 9832, 9846, 10042, 10028, 9833, 9847, 10043, 10029
8541, 9833, 9847, 10043, 10029, 9834, 9848, 10044, 10030
8542, 9834, 9848, 10044, 10030, 9835, 9849, 10045, 10031
8543, 9835, 9849, 10045, 10031, 9836, 9850, 10046, 10032
8544, 9836, 9850, 10046, 10032, 9837, 9851, 10047, 10033
8545, 9837, 9851, 10047, 10033, 9838, 9852, 10048, 10034
8546, 9838, 9852, 10048, 10034, 9839, 9853, 10049, 10035
8547, 9839, 9853, 10049, 10035, 9840, 9854, 10050, 10036
8548, 9840, 9854, 10050, 10036, 9841, 9855, 10051, 10037
8549, 9841, 9855, 10051, 10037, 9842, 9856, 10052, 10038
8550, 9842, 9856, 10052, 10038, 4391, 4392, 4406, 4405
8551, 3412, 3413, 3427, 3426, 9843, 9857, 10053, 10039
8552, 9843, 9857, 10053, 10039, 9844, 9858, 10054, 10040
8553, 9844, 9858, 10054, 10040, 9845, 9859, 10055, 10041
8554, 9845, 9859, 10055, 10041, 9846, 9860, 10056, 10042
8555, 9846, 9860, 10056, 10042, 9847, 9861, 10057, 10043
8556, 9847, 9861, 10057, 10043, 9848, 9862, 10058, 10044
8557, 9848, 9862, 10058, 10044, 9849, 9863, 10059, 10045
8558, 9849, 9863, 10059, 10045, 9850, 9864, 10060, 10046
8559, 9850, 9864, 10060, 10046, 9851, 9865, 10061, 10047
8560, 9851, 9865, 10061, 10047, 9852, 9866, 10062, 10048
8561, 9852, 9866, 10062, 10048, 9853, 9867, 10063, 10049
8562, 9853, 9867, 10063, 10049, 9854, 9868, 10064, 10050
8563, 9854, 9868, 10064, 10050, 9855, 9869, 10065, 10051
8564, 9855, 9869, 10065, 10051, 9856, 9870, 10066, 10052
8565, 9856, 9870, 10066, 10052, 4392, 4393, 4407, 4406
8566, 3413, 3414, 3428, 3427, 9857, 9871, 10067, 10053
8567, 9857, 9871, 10067, 10053, 9858, 9872, 10068, 10054
8568, 9858, 9872, 10068, 10054, 9859, 9873, 10069, 10055
8569, 9859, 9873, 10069, 10055, 9860, 9874, 10070, 10056
8570, 9860, 9874, 10070, 10056, 9861, 9875, 10071, 10057
8571, 9861, 9875, 10071, 10057, 9862, 9876, 10072, 10058
8572, 9862, 9876, 10072, 10058, 9863, 9877, 10073, 10059
8573, 9863, 9877, 10073, 10059, 9864, 9878, 10074, 10060
8574, 9864, 9878, 10074, 10060, 9865, 9879, 10075, 10061
8575, 9865, 9879, 10075, 10061, 9866, 9880, 10076, 10062
8576, 9866, 9880, 10076, 10062, 9867, 9881, 10077, 10063
8577, 9867, 9881, 10077, 10063, 9868, 9882, 10078, 10064
8578, 9868, 9882, 10078, 10064, 9869, 9883, 10079, 10065
8579, 9869, 9883, 10079, 10065, 9870, 9884, 10080, 10066
8580, 9870, 9884, 10080, 10066, 4393, 4394, 4408, 4407
8581, 3414, 3415, 3429, 3428, 9871, 9885, 10081, 10067
8582, 9871, 9885, 10081, 10067, 9872, 9886, 10082, 10068
8583, 9872, 9886, 10082, 10068, 9873, 9887, 10083, 10069
8584, 9873, 9887, 10083, 10069, 9874, 9888, 10084, 10070
8585, 9874, 9888, 10084, 10070, 9875, 9889, 10085, 10071
8586, 9875, 9889, 10085, 10071, 9876, 9890, 10086, 10072
8587, 9876, 9890, 10086, 10072, 9877, 9891, 10087, 10073
8588, 9877, 9891, 10087, 10073, 9878, 9892, 10088, 10074
8589, 9878, 9892, 10088, 10074, 9879, 9893, 10089, 10075
8590, 9879, 9893, 10089, 10075, 9880, 9894, 10090, 10076
8591, 9880, 9894, 10090, 10076, 9881, 9895, 10091, 10077
8592, 9881, 9895, 10091, 10077, 9882, 9896, 10092, 10078
8593, 9882, 9896, 10092, 10078, 9883, 9897, 10093, 10079
8594, 9883, 9897, 10093, 10079, 9884, 9898, 10094, 10080
8595, 9884, 9898, 10094, 10080, 4394, 4395, 4409, 4408
8596, 3415, 3416, 3430, 3429, 9885, 9899, 10095, 10081
8597, 9885, 9899, 10095, 10081, 9886, 9900, 10096, 10082
8598, 9886, 9900, 10096, 10082, 9887, 9901, 10097, 10083
8599, 9887, 9901, 10097, 10083, 9888, 9902, 10098, 10084
8600, 9888, 9902, 10098, 10084, 9889, 9903, 10099, 10085
8601, 9889, 9903, 10099, 10085, 9890, 9904, 10100, 10086
8602, 9890, 9904, 10100, 10086, 9891, 9905, 10101, 10087
8603, 9891, 9905, 10101, 10087, 9892, 9906, 10102, 10088
8604, 9892, 9906, 10102, 10088, 9893, 9907, 10103, 10089
8605, 9893, 9907, 10103, 10089, 9894, 9908, 10104, 10090
8606, 9894, 9908, 10104, 10090, 9895, 9909, 10105, 10091
8607, 9895, 9909, 10105, 10091, 9896, 9910, 10106, 10092
8608, 9896, 9910, 10106, 10092, 9897, 9911, 10107, 10093
8609, 9897, 9911, 10107, 10093, 9898, 9912, 10108, 10094
8610, 9898, 9912, 10108, 10094, 4395, 4396, 4410, 4409
8611, 3416, 614, 615, 3430, 9899, 4187, 4201, 10095
8612, 9899, 4187, 4201, 10095, 9900, 4188, 4202, 10096
8613, 9900, 4188, 4202, 10096, 9901, 4189, 4203, 10097
8614, 9901, 4189, 4203, 10097, 9902, 4190, 4204, 10098
8615, 9902, 4190, 4204, 10098, 9903, 4191, 4205, 10099
8616, 9903, 4191, 4205, 10099, 9904, 4192, 4206, 10100
8617, 9904, 4192, 4206, 10100, 9905, 4193, 4207, 10101
8618, 9905, 4193, 4207, 10101, 9906, 4194, 4208, 10102
8619, 9906, 4194, 4208, 10102, 9907, 4195, 4209, 10103
8620, 9907, 4195, 4209, 10103, 9908, 4196, 4210, 10104
8621, 9908, 4196, 4210, 10104, 9909, 4197, 4211, 10105
8622, 9909, 4197, 4211, 10105, 9910, 4198, 4212, 10106
8623, 9910, 4198, 4212, 10106, 9911, 4199, 4213, 10107
8624, 9911, 4199, 4213, 10107, 9912, 4200, 4214, 10108
8625, 9912, 4200, 4214, 10108, 4396, 726, 727, 4410
8626, 601, 3417, 3431, 602, 4005, 9913, 10109, 4019
8627, 4005, 9913, 10109, 4019, 4006, 9914, 10110, 4020
8628, 4006, 9914, 10110, 4020, 4007, 9915, 10111, 4021
8629, 4007, 9915, 10111, 4021, 4008, 9916, 10112, 4022
8630, 4008, 9916, 10112, 4022, 4009, 9917, 10113, 4023
8631, 4009, 9917, 10113, 4023, 4010, 9918, 10114, 4024
8632, 4010, 9918, 10114, 4024, 4011, 9919, 10115, 4025
8633, 4011, 9919, 10115, 4025, 4012, 9920, 10116, 4026
8634, 4012, 9920, 10116, 4026, 4013, 9921, 10117, 4027
8635, 4013, 9921, 10117, 4027, 4014, 9922, 10118, 4028
8636, 4014, 9922, 10118, 4028, 4015, 9923, 10119, 4029
8637, 4015, 9923, 10119, 4029, 4016, 9924, 10120, 4030
8638, 4016, 9924, 10120, 4030, 4017, 9925, 10121, 4031
8639, 4017, 9925, 10121, 4031, 4018, 9926, 10122, 4032
8640, 4018, 9926, 10122, 4032, 713, 4397, 4411, 714
8641, 3417, 3418, 3432, 3431, 9913, 9927, 10123, 10109
8642, 9913, 9927, 10123, 10109, 9914, 9928, 10124, 10110
8643, 9914, 9928, 10124, 10110, 9915, 9929, 10125, 10111
8644, 9915, 9929, 10125, 10111, 9916, 9930, 10126, 10112
8645, 9916, 9930, 10126, 10112, 9917, 9931, 10127, 10113
8646, 9917, 9931, 10127, 10113, 9918, 9932, 10128, 10114
8647, 9918, 9932, 10128, 10114, 9919, 9933, 10129, 10115
8648, 9919, 9933, 10129, 10115, 9920, 9934, 10130, 10116
8649, 9920, 9934, 10130, 10116, 9921, 9935, 10131, 10117
8650, 9921, 9935, 10131, 10117, 9922, 9936, 10132, 10118
8651, 9922, 9936, 10132, 10118, 9923, 9937, 10133, 10119
8652, 9923, 9937, 10133, 10119, 9924, 9938, 10134, 10120
8653, 9924, 9938, 10134, 10120, 9925, 9939, 10135, 10121
8654, 9925, 9939, 10135, 10121, 9926, 9940, 10136, 10122
8655, 9926, 9940, 10136, 10122, 4397, 4398, 4412, 4411
8656, 3418, 3419, 3433, 3432, 9927, 9941, 10137, 10123
8657, 9927, 9941, 10137, 10123, 9928, 9942, 10138, 10124
8658, 9928, 9942, 10138, 10124, 9929, 9943, 10139, 10125
8659, 9929, 9943, 10139, 10125, 9930, 9944, 10140, 10126
8660, 9930, 9944, 10140, 10126, 9931, 9945, 10141, 10127
8661, 9931, 9945, 10141, 10127, 9932, 9946, 10142, 10128
8662, 9932, 9946, 10142, 10128, 9933, 9947, 10143, 10129
8663, 9933, 9947, 10143, 10129, 9934, 9948, 10144, 10130
8664, 9934, 9948, 10144, 10130, 9935, 9949, 10145, 10131
8665, 9935, 9949, 10145, 10131, 9936, 9950, 10146, 10132
8666, 9936, 9950, 10146, 10132, 9937, 9951, 10147, 10133
8667, 9937, 9951, 10147, 10133, 9938, 9952, 10148, 10134
8668, 9938, 9952, 10148, 10134, 9939, 9953, 10149, 10135
8669, 9939, 9953, 10149, 10135, 9940, 9954, 10150, 10136
8670, 9940, 9954, 10150, 10136, 4398, 4399, 4413, 4412
8671, 3419, 3420, 3434, 3433, 9941, 9955, 10151, 10137
8672, 9941, 9955, 10151, 10137, 9942, 9956, 10152, 10138
8673, 9942, 9956, 10152, 10138, 9943, 9957, 10153, 10139
8674, 9943, 9957, 10153, 10139, 9944, 9958, 10154, 10140
8675, 9944, 9958, 10154, 10140, 9945, 9959, 10155, 10141
8676, 9945, 9959, 10155, 10141, 9946, 9960, 10156, 10142
8677, 9946, 9960, 10156, 10142, 9947, 9961, 10157, 10143
8678, 9947, 9961, 10157, 10143, 9948, 9962, 10158, 10144
8679, 9948, 9962, 10158, 10144, 9949, 9963, 10159, 10145
8680, 9949, 9963, 10159, 10145, 9950, 9964, 10160, 10146
8681, 9950, 9964, 10160, 10146, 9951, 9965, 10161, 10147
8682, 9951, 9965, 10161, 10147, 9952, 9966, 10162, 10148
8683, 9952, 9966, 10162, 10148, 9953, 9967, 10163, 10149
8684, 9953, 9967, 10163, 10149, 9954, 9968, 10164, 10150
8685, 9954, 9968, 10164, 10150, 4399, 4400, 4414, 4413
8686, 3420, 3421, 3435, 3434, 9955, 9969, 10165, 10151
8687, 9955, 9969, 10165, 10151, 9956, 9970, 10166, 10152
8688, 9956, 9970, 10166, 10152, 9957, 9971, 10167, 10153
8689, 9957, 9971, 10167, 10153, 9958, 9972, 10168, 10154
8690, 9958, 9972, 10168, 10154, 9959, 9973, 10169, 10155
8691, 9959, 9973, 10169, 10155, 9960, 9974, 10170, 10156
8692, 9960, 9974, 10170, 10156, 9961, 9975, 10171, 10157
8693, 9961, 9975, 10171, 10157, 9962, 9976, 10172, 10158
8694, 9962, 9976, 10172, 10158, 9963, 9977, 10173, 10159
8695, 9963, 9977, 10173, 10159, 9964, 9978, 10174, 10160
8696, 9964, 9978, 10174, 10160, 9965, 9979, 10175, 10161
8697, 9965, 9979, 10175, 10161, 9966, 9980, 10176, 10162
8698, 9966, 9980, 10176, 10162, 9967, 9981, 10177, 10163
8699, 9967, 9981, 10177, 10163, 9968, 9982, 10178, 10164
8700, 9968, 9982, 10178, 10164, 4400, 4401, 4415, 4414
8701, 3421, 3422, 3436, 3435, 9969, 9983, 10179, 10165
8702, 9969, 9983, 10179, 10165, 9970, 9984, 10180, 10166
8703, 9970, 9984, 10180, 10166, 9971, 9985, 10181, 10167
8704, 9971, 9985, 10181, 10167, 9972, 9986, 10182, 10168
8705, 9972, 9986, 10182, 10168, 9973, 9987, 10183, 10169
8706, 9973, 9987, 10183, 10169, 9974, 9988, 10184, 10170
8707, 9974, 9988, 10184, 10170, 9975, 9989, 10185, 10171
8708, 9975, 9989, 10185, 10171, 9976, 9990, 10186, 10172
8709, 9976, 9990, 10186, 10172, 9977, 9991, 10187, 10173
8710, 9977, 9991, 10187, 10173, 9978, 9992, 10188, 10174
8711, 9978, 9992, 10188, 10174, 9979, 9993, 10189, 10175
8712, 9979, 9993, 10189, 10175, 9980, 9994, 10190, 10176
8713, 9980, 9994, 10190, 10176, 9981, 9995, 10191, 10177
8714, 9981, 9995, 10191, 10177, 9982, 9996, 10192, 10178
8715, 9982, 9996, 10192, 10178, 4401, 4402, 4416, 4415
8716, 3422, 3423, 3437, 3436, 9983, 9997, 10193, 10179
8717, 9983, 9997, 10193, 10179, 9984, 9998, 10194, 10180
8718, 9984, 9998, 10194, 10180, 9985, 9999, 10195, 10181
8719, 9985, 9999, 10195, 10181, 9986, 10000, 10196, 10182
8720, 9986, 10000, 10196, 10182, 9987, 10001, 10197, 10183
8721, 9987, 10001, 10197, 10183, 9988, 10002, 10198, 10184
8722, 9988, 10002, 10198, 10184, 9989, 10003, 10199, 10185
8723, 9989, 10003, 10199, 10185, 9990, 10004, 10200, 10186
8724, 9990, 10004, 10200, 10186, 9991, 10005, 10201, 10187
8725, 9991, 10005, 10201, 10187, 9992, 10006, 10202, 10188
8726, 9992, 10006, 10202, 10188, 9993, 10007, 10203, 10189
8727, 9993, 10007, 10203, 10189, 9994, 10008, 10204, 10190
8728, 9994, 10008, 10204, 10190, 9995, 10009, 10205, 10191
8729, 9995, 10009, 10205, 10191, 9996, 10010, 10206, 10192
8730, 9996, 10010, 10206, 10192, 4402, 4403, 4417, 4416
8731, 3423, 3424, 3438, 3437, 9997, 10011, 10207, 10193
8732, 9997, 10011, 10207, 10193, 9998, 10012, 10208, 10194
8733, 9998, 10012, 10208, 10194, 9999, 10013, 10209, 10195
8734, 9999, 10013, 10209, 10195, 10000, 10014, 10210, 10196
8735, 10000, 10014, 10210, 10196, 10001, 10015, 10211, 10197
8736, 10001, 10015, 10211, 10197, 10002, 10016, 10212, 10198
8737, 10002, 10016, 10212, 10198, 10003, 10017, 10213, 10199
8738, 10003, 10017, 10213, 10199, 10004, 10018, 10214, 10200
8739, 10004, 10018, 10214, 10200, 10005, 10019, 10215, 10201
8740, 10005, 10019, 10215, 10201, 10006, 10020, 10216, 10202
8741, 10006, 10020, 10216, 10202, 10007, 10021, 10217, 10203
8742, 10007, 10021, 10217, 10203, 10008, 10022, 10218, 10204
8743, 10008, 10022, 10218, 10204, 10009, 10023, 10219, 10205
8744, 10009, 10023, 10219, 10205, 10010, 10024, 10220, 10206
8745, 10010, 10024, 10220, 10206, 4403, 4404, 4418, 4417
8746, 3424, 3425, 3439, 3438, 10011, 10025, 10221, 10207
8747, 10011, 10025, 10221, 10207, 10012, 10026, 10222, 10208
8748, 10012, 10026, 10222, 10208, 10013, 10027, 10223, 10209
8749, 10013, 10027, 10223, 10209, 10014, 10028, 10224, 10210
8750, 10014, 10028, 10224, 10210, 10015, 10029, 10225, 10211
8751, 10015, 10029, 10225, 10211, 10016, 10030, 10226, 10212
8752, 10016, 10030, 10226, 10212, 10017, 10031, 10227, 10213
8753, 10017, 10031, 10227, 10213, 10018, 10032, 10228, 10214
8754, 10018, 10032, 10228, 10214, 10019, 10033, 10229, 10215
8755, 10019, 10033, 10229, 10215, 10020, 10034, 10230, 10216
8756, 10020, 10034, 10230, 10216, 10021, 10035, 10231, 10217
8757, 10021, 10035, 10231, 10217, 10022, 10036, 10232, 10218
8758, 10022, 10036, 10232, 10218, 10023, 10037, 10233, 10219
8759, 10023, 10037, 10233, 10219, 10024, 10038, 10234, 10220
8760, 10024, 10038, 10234, 10220, 4404, 4405, 4419, 4418
8761, 3425, 3426, 3440, 3439, 10025, 10039, 10235, 10221
8762, 10025, 10039, 10235, 10221, 10026, 10040, 10236, 10222
8763, 10026, 10040, 10236, 10222, 10027, 10041, 10237, 10223
8764, 10027, 10041, 10237, 10223, 10028, 10042, 10238, 10224
8765, 10028, 10042, 10238, 10224, 10029, 10043, 10239, 10225
8766, 10029, 10043, 10239, 10225, 10030, 10044, 10240, 10226
8767, 10030, 10044, 10240, 10226, 10031, 10045, 10241, 10227
8768, 10031, 10045, 10241, 10227, 10032, 10046, 10242, 10228
8769, 10032, 10046, 10242, 10228, 10033, 10047, 10243, 10229
8770, 10033, 10047, 10243, 10229, 10034, 10048, 10244, 10230
8771, 10034, 10048, 10244, 10230, 10035, 10049, 10245, 10231
8772, 10035, 10049, 10245, 10231, 10036, 10050, 10246, 10232
8773, 10036, 10050, 10246, 10232, 10037, 10051, 10247, 10233
8774, 10037, 10051, 10247, 10233, 10038, 10052, 10248, 10234
8775, 10038, 10052, 10248, 10234, 4405, 4406, 4420, 4419
8776, 3426, 3427, 3441, 3440, 10039, 10053, 10249, 10235
8777, 10039, 10053, 10249, 10235, 10040, 10054, 10250, 10236
8778, 10040, 10054, 10250, 10236, 10041, 10055, 10251, 10237
8779, 10041, 10055, 10251, 10237, 10042, 10056, 10252, 10238
8780, 10042, 10056, 10252, 10238, 10043, 10057, 10253, 10239
8781, 10043, 10057, 10253, 10239, 10044, 10058, 10254, 10240
8782, 10044, 10058, 10254, 10240, 10045, 10059, 10255, 10241
8783, 10045, 10059, 10255, 10241, 10046, 10060, 10256, 10242
8784, 10046, 10060, 10256, 10242, 10047, 10061, 10257, 10243
8785, 10047, 10061, 10257, 10243, 10048, 10062, 10258, 10244
8786, 10048, 10062, 10258, 10244, 10049, 10063, 10259, 10245
8787, 10049, 10063, 10259, 10245, 10050, 10064, 10260, 10246
8788, 10050, 10064, 10260, 10246, 10051, 10065, 10261, 10247
8789, 10051, 10065, 10261, 10247, 10052, 10066, 10262, 10248
8790, 10052, 10066, 10262, 10248, 4406, 4407, 4421, 4420
8791, 3427, 3428, 3442, 3441, 10053, 10067, 10263, 10249
8792, 10053, 10067, 10263, 10249, 10054, 10068, 10264, 10250
8793, 10054, 10068, 10264, 10250, 10055, 10069, 10265, 10251
8794, 10055, 10069, 10265, 10251, 10056, 10070, 10266, 10252
8795, 10056, 10070, 10266, 10252, 10057, 10071, 10267, 10253
8796, 10057, 10071, 10267, 10253, 10058, 10072, 10268, 10254
8797, 10058, 10072, 10268, 10254, 10059, 10073, 10269, 10255
8798, 10059, 10073, 10269, 10255, 10060, 10074, 10270, 10256
8799, 10060, 10074, 10270, 10256, 10061, 10075, 10271, 10257
8800, 10061, 10075, 10271, 10257, 10062, 10076, 10272, 10258
8801, 10062, 10076, 10272, 10258, 10063, 10077, 10273, 10259
8802, 10063, 10077, 10273, 10259, 10064, 10078, 10274, 10260
8803, 10064, 10078, 10274, 10260, 10065, 10079, 10275, 10261
8804, 10065, 10079, 10275, 10261, 10066, 10080, 10276, 10262
8805, 10066, 10080, 10276, 10262, 4407, 4408, 4422, 4421
8806, 3428, 3429, 3443, 3442, 10067, 10081, 10277, 10263
8807, 10067, 10081, 10277, 10263, 10068, 10082, 10278, 10264
8808, 10068, 10082, 10278, 10264, 10069, 10083, 10279, 10265
8809, 10069, 10083, 10279, 10265, 10070, 10084, 10280, 10266
8810, 10070, 10084, 10280, 10266, 10071, 10085, 10281, 10267
8811, 10071, 10085, 10281, 10267, 10072, 10086, 10282, 10268
8812, 10072, 10086, 10282, 10268, 10073, 10087, 10283, 10269
8813, 10073, 10087, 10283, 10269, 10074, 10088, 10284, 10270
8814, 10074, 10088, 10284, 10270, 10075, 10089, 10285, 10271
8815, 10075, 10089, 10285, 10271, 10076, 10090, 10286, 10272
8816, 10076, 10090, 10286, 10272, 10077, 10091, 10287, 10273
8817, 10077, 10091, 10287, 10273, 10078, 10092, 10288, 10274
8818, 10078, 10092, 10288, 10274, 10079, 10093, 10289, 10275
8819, 10079, 10093, 10289, 10275, 10080, 10094, 10290, 10276
8820, 10080, 10094, 10290, 10276, 4408, 4409, 4423, 4422
8821, 3429, 3430, 3444, 3443, 10081, 10095, 10291, 10277
8822, 10081, 10095, 10291, 10277, 10082, 10096, 10292, 10278
8823, 10082, 10096, 10292, 10278, 10083, 10097, 10293, 10279
8824, 10083, 10097, 10293, 10279, 10084, 10098, 10294, 10280
8825, 10084, 10098, 10294, 10280, 10085, 10099, 10295, 10281
8826, 10085, 10099, 10295, 10281, 10086, 10100, 10296, 10282
8827, 10086, 10100, 10296, 10282, 10087, 10101, 10297, 10283
8828, 10087, 10101, 10297, 10283, 10088, 10102, 10298, 10284
8829, 10088, 10102, 10298, 10284, 10089, 10103, 10299, 10285
8830, 10089, 10103, 10299, 10285, 10090, 10104, 10300, 10286
8831, 10090, 10104, 10300, 10286, 10091, 10105, 10301, 10287
8832, 10091, 10105, 10301, 10287, 10092, 10106, 10302, 10288
8833, 10092, 10106, 10302, 10288, 10093, 10107, 10303, 10289
8834, 10093, 10107, 10303, 10289, 10094, 10108, 10304, 10290
8835, 10094, 10108, 10304, 10290, 4409, 4410, 4424, 4423
8836, 3430, 615, 616, 3444, 10095, 4201, 4215, 10291
8837, 10095, 4201, 4215, 10291, 10096, 4202, 4216, 10292
8838, 10096, 4202, 4216, 10292, 10097, 4203, 4217, 10293
8839, 10097, 4203, 4217, 10293, 10098, 4204, 4218, 10294
8840, 10098, 4204, 4218, 10294, 10099, 4205, 4219, 10295
8841, 10099, 4205, 4219, 10295, 10100, 4206, 4220, 10296
8842, 10100, 4206, 4220, 10296, 10101, 4207, 4221, 10297
8843, 10101, 4207, 4221, 10297, 10102, 4208, 4222, 10298
8844, 10102, 4208, 4222, 10298, 10103, 4209, 4223, 10299
8845, 10103, 4209, 4223, 10299, 10104, 4210, 4224, 10300
8846, 10104, 4210, 4224, 10300, 10105, 4211, 4225, 10301
8847, 10105, 4211, 4225, 10301, 10106, 4212, 4226, 10302
8848, 10106, 4212, 4226, 10302, 10107, 4213, 4227, 10303
8849, 10107, 4213, 4227, 10303, 10108, 4214, 4228, 10304
8850, 10108, 4214, 4228, 10304, 4410, 727, 728, 4424
8851, 602, 3431, 561, 33, 4019, 10109, 3445, 617
8852, 4019, 10109, 3445, 617, 4020, 10110, 3446, 618
8853, 4020, 10110, 3446, 618, 4021, 10111, 3447, 619
8854, 4021, 10111, 3447, 619, 4022, 10112, 3448, 620
8855, 4022, 10112, 3448, 620, 4023, 10113, 3449, 621
8856, 4023, 10113, 3449, 621, 4024, 10114, 3450, 622
8857, 4024, 10114, 3450, 622, 4025, 10115, 3451, 623
8858, 4025, 10115, 3451, 623, 4026, 10116, 3452, 624
8859, 4026, 10116, 3452, 624, 4027, 10117, 3453, 625
8860, 4027, 10117, 3453, 625, 4028, 10118, 3454, 626
8861, 4028, 10118, 3454, 626, 4029, 10119, 3455, 627
8862, 4029, 10119, 3455, 627, 4030, 10120, 3456, 628
8863, 4030, 10120, 3456, 628, 4031, 10121, 3457, 629
8864, 4031, 10121, 3457, 629, 4032, 10122, 3458, 630
8865, 4032, 10122, 3458, 630, 714, 4411, 645, 37
8866, 3431, 3432, 562, 561, 10109, 10123, 3459, 3445
8867, 10109, 10123, 3459, 3445, 10110, 10124, 3460, 3446
8868, 10110, 10124, 3460, 3446, 10111, 10125, 3461, 3447
8869, 10111, 10125, 3461, 3447, 10112, 10126, 3462, 3448
8870, 10112, 10126, 3462, 3448, 10113, 10127, 3463, 3449
8871, 10113, 10127, 3463, 3449, 10114, 10128, 3464, 3450
8872, 10114, 10128, 3464, 3450, 10115, 10129, 3465, 3451
8873, 10115, 10129, 3465, 3451, 10116, 10130, 3466, 3452
8874, 10116, 10130, 3466, 3452, 10117, 10131, 3467, 3453
8875, 10117, 10131, 3467, 3453, 10118, 10132, 3468, 3454
8876, 10118, 10132, 3468, 3454, 10119, 10133, 3469, 3455
8877, 10119, 10133, 3469, 3455, 10120, 10134, 3470, 3456
8878, 10120, 10134, 3470, 3456, 10121, 10135, 3471, 3457
8879, 10121, 10135, 3471, 3457, 10122, 10136, 3472, 3458
8880, 10122, 10136, 3472, 3458, 4411, 4412, 646, 645
8881, 3432, 3433, 563, 562, 10123, 10137, 3473, 3459
8882, 10123, 10137, 3473, 3459, 10124, 10138, 3474, 3460
8883, 10124, 10138, 3474, 3460, 10125, 10139, 3475, 3461
8884, 10125, 10139, 3475, 3461, 10126, 10140, 3476, 3462
8885, 10126, 10140, 3476, 3462, 10127, 10141, 3477, 3463
8886, 10127, 10141, 3477, 3463, 10128, 10142, 3478, 3464
8887, 10128, 10142, 3478, 3464, 10129, 10143, 3479, 3465
8888, 10129, 10143, 3479, 3465, 10130, 10144, 3480, 3466
8889, 10130, 10144, 3480, 3466, 10131, 10145, 3481, 3467
8890, 10131, 10145, 3481, 3467, 10132, 10146, 3482, 3468
8891, 10132, 10146, 3482, 3468, 10133, 10147, 3483, 3469
8892, 10133, 10147, 3483, 3469, 10134, 10148, 3484, 3470
8893, 10134, 10148, 3484, 3470, 10135, 10149, 3485, 3471
8894, 10135, 10149, 3485, 3471, 10136, 10150, 3486, 3472
8895, 10136, 10150, 3486, 3472, 4412, 4413, 647, 646
8896, 3433, 3434, 564, 563, 10137, 10151, 3487, 3473
8897, 10137, 10151, 3487, 3473, 10138, 10152, 3488, 3474
8898, 10138, 10152, 3488, 3474, 10139, 10153, 3489, 3475
8899, 10139, 10153, 3489, 3475, 10140, 10154, 3490, 3476
8900, 10140, 10154, 3490, 3476, 10141, 10155, 3491, 3477
8901, 10141, 10155, 3491, 3477, 10142, 10156, 3492, 3478
8902, 10142, 10156, 3492, 3478, 10143, 10157, 3493, 3479
8903, 10143, 10157, 3493, 3479, 10144, 10158, 3494, 3480
8904, 10144, 10158, 3494, 3480, 10145, 10159, 3495, 3481
8905, 10145, 10159, 3495, 3481, 10146, 10160, 3496, 3482
8906, 10146, 10160, 3496, 3482, 10147, 10161, 3497, 3483
8907, 10147, 10161, 3497, 3483, 10148, 10162, 3498, 3484
8908, 10148, 10162, 3498, 3484, 10149, 10163, 3499, 3485
8909, 10149, 10163, 3499, 3485, 10150, 10164, 3500, 3486
8910, 10150, 10164, 3500, 3486, 4413, 4414, 648, 647
8911, 3434, 3435, 565, 564, 10151, 10165, 3501, 3487
8912, 10151, 10165, 3501, 3487, 10152, 10166, 3502, 3488
8913, 10152, 10166, 3502, 3488, 10153, 10167, 3503, 3489
8914, 10153, 10167, 3503, 3489, 10154, 10168, 3504, 3490
8915, 10154, 10168, 3504, 3490, 10155, 10169, 3505, 3491
8916, 10155, 10169, 3505, 3491, 10156, 10170, 3506, 3492
8917, 10156, 10170, 3506, 3492, 10157, 10171, 3507, 3493
8918, 10157, 10171, 3507, 3493, 10158, 10172, 3508, 3494
8919, 10158, 10172, 3508, 3494, 10159, 10173, 3509, 3495
8920, 10159, 10173, 3509, 3495, 10160, 10174, 3510, 3496
8921, 10160, 10174, 3510, 3496, 10161, 10175, 3511, 3497
8922, 10161, 10175, 3511, 3497, 10162, 10176, 3512, 3498
8923, 10162, 10176, 3512, 3498, 10163, 10177, 3513, 3499
8924, 10163, 10177, 3513, 3499, 10164, 10178, 3514, 3500
8925, 10164, 10178, 3514, 3500, 4414, 4415, 649, 648
8926, 3435, 3436, 566, 565, 10165, 10179, 3515, 3501
8927, 10165, 10179, 3515, 3501, 10166, 10180, 3516, 3502
8928, 10166, 10180, 3516, 3502, 10167, 10181, 3517, 3503
8929, 10167, 10181, 3517, 3503, 10168, 10182, 3518, 3504
8930, 10168, 10182, 3518, 3504, 10169, 10183, 3519, 3505
8931, 10169, 10183, 3519, 3505, 10170, 10184, 3520, 3506
8932, 10170, 10184, 3520, 3506, 10171, 10185, 3521, 3507
8933, 10171, 10185, 3521, 3507, 10172, 10186, 3522, 3508
8934, 10172, 10186, 3522, 3508, 10173, 10187, 3523, 3509
8935, 10173, 10187, 3523, 3509, 10174, 10188, 3524, 3510
8936, 10174, 10188, 3524, 3510, 10175, 10189, 3525, 3511
8937, 10175, 10189, 3525, 3511, 10176, 10190, 3526, 3512
8938, 10176, 10190, 3526, 3512, 10177, 10191, 3527, 3513
8939, 10177, 10191, 3527, 3513, 10178, 10192, 3528, 3514
8940, 10178, 10192, 3528, 3514, 4415, 4416, 650, 649
8941, 3436, 3437, 567, 566, 10179, 10193, 3529, 3515
8942, 10179, 10193, 3529, 3515, 10180, 10194, 3530, 3516
8943, 10180, 10194, 3530, 3516, 10181, 10195, 3531, 3517
8944, 10181, 10195, 3531, 3517, 10182, 10196, 3532, 3518
8945, 10182, 10196, 3532, 3518, 10183, 10197, 3533, 3519
8946, 10183, 10197, 3533, 3519, 10184, 10198, 3534, 3520
8947, 10184, 10198, 3534, 3520, 10185, 10199, 3535, 3521
8948, 10185, 10199, 3535, 3521, 10186, 10200, 3536, 3522
8949, 10186, 10200, 3536, 3522, 10187, 10201, 3537, 3523
8950, 10187, 10201, 3537, 3523, 10188, 10202, 3538, 3524
8951, 10188, 10202, 3538, 3524, 10189, 10203, 3539, 3525
8952, 10189, 10203, 3539, 3525, 10190, 10204, 3540, 3526
8953, 10190, 10204, 3540, 3526, 10191, 10205, 3541, 3527
8954, 10191, 10205, 3541, 3527, 10192, 10206, 3542, 3528
8955, 10192, 10206, 3542, 3528, 4416, 4417, 651, 650
8956, 3437, 3438, 568, 567, 10193, 10207, 3543, 3529
8957, 10193, 10207, 3543, 3529, 10194, 10208, 3544, 3530
8958, 10194, 10208, 3544, 3530, 10195, 10209, 3545, 3531
8959, 10195, 10209, 3545, 3531, 10196, 10210, 3546, 3532
8960, 10196, 10210, 3546, 3532, 10197, 10211, 3547, 3533
8961, 10197, 10211, 3547, 3533, 10198, 10212, 3548, 3534
8962, 10198, 10212, 3548, 3534, 10199, 10213, 3549, 3535
8963, 10199, 10213, 3549, 3535, 10200, 10214, 3550, 3536
8964, 10200, 10214, 3550, 3536, 10201, 10215, 3551, 3537
8965, 10201, 10215, 3551, 3537, 10202, 10216, 3552, 3538
8966, 10202, 10216, 3552, 3538, 10203, 10217, 3553, 3539
8967, 10203, 10217, 3553, 3539, 10204, 10218, 3554, 3540
8968, 10204, 10218, 3554, 3540, 10205, 10219, 3555, 3541
8969, 10205, 10219, 3555, 3541, 10206, 10220, 3556, 3542
8970, 10206, 10220, 3556, 3542, 4417, 4418, 652, 651
8971, 3438, 3439, 569, 568, 10207, 10221, 3557, 3543
8972, 10207, 10221, 3557, 3543, 10208, 10222, 3558, 3544
8973, 10208, 10222, 3558, 3544, 10209, 10223, 3559, 3545
8974, 10209, 10223, 3559, 3545, 10210, 10224, 3560, 3546
8975, 10210, 10224, 3560, 3546, 10211, 10225, 3561, 3547
8976, 10211, 10225, 3561, 3547, 10212, 10226, 3562, 3548
8977, 10212, 10226, 3562, 3548, 10213, 10227, 3563, 3549
8978, 10213, 10227, 3563, 3549, 10214, 10228, 3564, 3550
8979, 10214, 10228, 3564, 3550, 10215, 10229, 3565, 3551
8980, 10215, 10229, 3565, 3551, 10216, 10230, 3566, 3552
8981, 10216, 10230, 3566, 3552, 10217, 10231, 3567, 3553
8982, 10217, 10231, 3567, 3553, 10218, 10232, 3568, 3554
8983, 10218, 10232, 3568, 3554, 10219, 10233, 3569, 3555
8984, 10219, 10233, 3569, 3555, 10220, 10234, 3570, 3556
8985, 10220, 10234, 3570, 3556, 4418, 4419, 653, 652
8986, 3439, 3440, 570, 569, 10221, 10235, 3571, 3557
8987, 10221, 10235, 3571, 3557, 10222, 10236, 3572, 3558
8988, 10222, 10236, 3572, 3558, 10223, 10237, 3573, 3559
8989, 10223, 10237, 3573, 3559, 10224, 10238, 3574, 3560
8990, 10224, 10238, 3574, 3560, 10225, 10239, 3575, 3561
8991, 10225, 10239, 3575, 3561, 10226, 10240, 3576, 3562
8992, 10226, 10240, 3576, 3562, 10227, 10241, 3577, 3563
8993, 10227, 10241, 3577, 3563, 10228, 10242, 3578, 3564
8994, 10228, 10242, 3578, 3564, 10229, 10243, 3579, 3565
8995, 10229, 10243, 3579, 3565, 10230, 10244, 3580, 3566
8996, 10230, 10244, 3580, 3566, 10231, 10245, 3581, 3567
8997, 10231, 10245, 3581, 3567, 10232, 10246, 3582, 3568
8998, 10232, 10246, 3582, 3568, 10233, 10247, 3583, 3569
8999, 10233, 10247, 3583, 3569, 10234, 10248, 3584, 3570
9000, 10234, 10248, 3584, 3570, 4419, 4420, 654, 653
9001, 3440, 3441, 571, 570, 10235, 10249, 3585, 3571
9002, 10235, 10249, 3585, 3571, 10236, 10250, 3586, 3572
9003, 10236, 10250, 3586, 3572, 10237, 10251, 3587, 3573
9004, 10237, 10251, 3587, 3573, 10238, 10252, 3588, 3574
9005, 10238, 10252, 3588, 3574, 10239, 10253, 3589, 3575
9006, 10239, 10253, 3589, 3575, 10240, 10254, 3590, 3576
9007, 10240, 10254, 3590, 3576, 10241, 10255, 3591, 3577
9008, 10241, 10255, 3591, 3577, 10242, 10256, 3592, 3578
9009, 10242, 10256, 3592, 3578, 10243, 10257, 3593, 3579
9010, 10243, 10257, 3593, 3579, 10244, 10258, 3594, 3580
9011, 10244, 10258, 3594, 3580, 10245, 10259, 3595, 3581
9012, 10245, 10259, 3595, 3581, 10246, 10260, 3596, 3582
9013, 10246, 10260, 3596, 3582, 10247, 10261, 3597, 3583
9014, 10247, 10261, 3597, 3583, 10248, 10262, 3598, 3584
9015, 10248, 10262, 3598, 3584, 4420, 4421, 655, 654
9016, 3441, 3442, 572, 571, 10249, 10263, 3599, 3585
9017, 10249, 10263, 3599, 3585, 10250, 10264, 3600, 3586
9018, 10250, 10264, 3600, 3586, 10251, 10265, 3601, 3587
9019, 10251, 10265, 3601, 3587, 10252, 10266, 3602, 3588
9020, 10252, 10266, 3602, 3588, 10253, 10267, 3603, 3589
9021, 10253, 10267, 3603, 3589, 10254, 10268, 3604, 3590
9022, 10254, 10268, 3604, 3590, 10255, 10269, 3605, 3591
9023, 10255, 10269, 3605, 3591, 10256, 10270, 3606, 3592
9024, 10256, 10270, 3606, 3592, 10257, 10271, 3607, 3593
9025, 10257, 10271, 3607, 3593, 10258, 10272, 3608, 3594
9026, 10258, 10272, 3608, 3594, 10259, 10273, 3609, 3595
9027, 10259, 10273, 3609, 3595, 10260, 10274, 3610, 3596
9028, 10260, 10274, 3610, 3596, 10261, 10275, 3611, 3597
9029, 10261, 10275, 3611, 3597, 10262, 10276, 3612, 3598
9030, 10262, 10276, 3612, 3598, 4421, 4422, 656, 655
9031, 3442, 3443, 573, 572, 10263, 10277, 3613, 3599
9032, 10263, 10277, 3613, 3599, 10264, 10278, 3614, 3600
9033, 10264, 10278, 3614, 3600, 10265, 10279, 3615, 3601
9034, 10265, 10279, 3615, 3601, 10266, 10280, 3616, 3602
9035, 10266, 10280, 3616, 3602, 10267, 10281, 3617, 3603
9036, 10267, 10281, 3617, 3603, 10268, 10282, 3618, 3604
9037, 10268, 10282, 3618, 3604, 10269, 10283, 3619, 3605
9038, 10269, 10283, 3619, 3605, 10270, 10284, 3620, 3606
9039, 10270, 10284, 3620, 3606, 10271, 10285, 3621, 3607
9040, 10271, 10285, 3621, 3607, 10272, 10286, 3622, 3608
9041, 10272, 10286, 3622, 3608, 10273, 10287, 3623, 3609
9042, 10273, 10287, 3623, 3609, 10274, 10288, 3624, 3610
9043, 10274, 10288, 3624, 3610, 10275, 10289, 3625, 3611
9044, 10275, 10289, 3625, 3611, 10276, 10290, 3626, 3612
9045, 10276, 10290, 3626, 3612, 4422, 4423, 657, 656
9046, 3443, 3444, 574, 573, 10277, 10291, 3627, 3613
9047, 10277, 10291, 3627, 3613, 10278, 10292, 3628, 3614
9048, 10278, 10292, 3628, 3614, 10279, 10293, 3629, 3615
9049, 10279, 10293, 3629, 3615, 10280, 10294, 3630, 3616
9050, 10280, 10294, 3630, 3616, 10281, 10295, 3631, 3617
9051, 10281, 10295, 3631, 3617, 10282, 10296, 3632, 3618
9052, 10282, 10296, 3632, 3618, 10283, 10297, 3633, 3619
9053, 10283, 10297, 3633, 3619, 10284, 10298, 3634, 3620
9054, 10284, 10298, 3634, 3620, 10285, 10299, 3635, 3621
9055, 10285, 10299, 3635, 3621, 10286, 10300, 3636, 3622
9056, 10286, 10300, 3636, 3622, 10287, 10301, 3637, 3623
9057, 10287, 10301, 3637, 3623, 10288, 10302, 3638, 3624
9058, 10288, 10302, 3638, 3624, 10289, 10303, 3639, 3625
9059, 10289, 10303, 3639, 3625, 10290, 10304, 3640, 3626
9060, 10290, 10304, 3640, 3626, 4423, 4424, 658, 657
9061, 3444, 616, 34, 574, 10291, 4215, 631, 3627
9062, 10291, 4215, 631, 3627, 10292, 4216, 632, 3628
9063, 10292, 4216, 632, 3628, 10293, 4217, 633, 3629
9064, 10293, 4217, 633, 3629, 10294, 4218, 634, 3630
9065, 10294, 4218, 634, 3630, 10295, 4219, 635, 3631
9066, 10295, 4219, 635, 3631, 10296, 4220, 636, 3632
9067, 10296, 4220, 636, 3632, 10297, 4221, 637, 3633
9068, 10297, 4221, 637, 3633, 10298, 4222, 638, 3634
9069, 10298, 4222, 638, 3634, 10299, 4223, 639, 3635
9070, 10299, 4223, 639, 3635, 10300, 4224, 640, 3636
9071, 10300, 4224, 640, 3636, 10301, 4225, 641, 3637
9072, 10301, 4225, 641, 3637, 10302, 4226, 642, 3638
9073, 10302, 4226, 642, 3638, 10303, 4227, 643, 3639
9074, 10303, 4227, 643, 3639, 10304, 4228, 644, 3640
9075, 10304, 4228, 644, 3640, 4424, 728, 38, 658
*ELEMENT, type=C3D8, ELSET=Volume10
9076, 39, 687, 4229, 701, 43, 743, 4425, 757
9077, 687, 688, 4230, 4229, 743, 744, 4426, 4425
9078, 688, 689, 4231, 4230, 744, 745, 4427, 4426
9079, 689, 690, 4232, 4231, 745, 746, 4428, 4427
9080, 690, 691, 4233, 4232, 746, 747, 4429, 4428
9081, 691, 692, 4234, 4233, 747, 748, 4430, 4429
9082, 692, 693, 4235, 4234, 748, 749, 4431, 4430
9083, 693, 694, 4236, 4235, 749, 750, 4432, 4431
9084, 694, 695, 4237, 4236, 750, 751, 4433, 4432
9085, 695, 696, 4238, 4237, 751, 752, 4434, 4433
9086, 696, 697, 4239, 4238, 752, 753, 4435, 4434
9087, 697, 698, 4240, 4239, 753, 754, 4436, 4435
9088, 698, 699, 4241, 4240, 754, 755, 4437, 4436
9089, 699, 700, 4242, 4241, 755, 756, 4438, 4437
9090, 700, 40, 715, 4242, 756, 44, 771, 4438
9091, 701, 4229, 4243, 702, 757, 4425, 4439, 758
9092, 4229, 4230, 4244, 4243, 4425, 4426, 4440, 4439
9093, 4230, 4231, 4245, 4244, 4426, 4427, 4441, 4440
9094, 4231, 4232, 4246, 4245, 4427, 4428, 4442, 4441
9095, 4232, 4233, 4247, 4246, 4428, 4429, 4443, 4442
9096, 4233, 4234, 4248, 4247, 4429, 4430, 4444, 4443
9097, 4234, 4235, 4249, 4248, 4430, 4431, 4445, 4444
9098, 4235, 4236, 4250, 4249, 4431, 4432, 4446, 4445
9099, 4236, 4237, 4251, 4250, 4432, 4433, 4447, 4446
9100, 4237, 4238, 4252, 4251, 4433, 4434, 4448, 4447
9101, 4238, 4239, 4253, 4252, 4434, 4435, 4449, 4448
9102, 4239, 4240, 4254, 4253, 4435, 4436, 4450, 4449
9103, 4240, 4241, 4255, 4254, 4436, 4437, 4451, 4450
9104, 4241, 4242, 4256, 4255, 4437, 4438, 4452, 4451
9105, 4242, 715, 716, 4256, 4438, 771, 772, 4452
9106, 702, 4243, 4257, 703, 758, 4439, 4453, 759
9107, 4243, 4244, 4258, 4257, 4439, 4440, 4454, 4453
9108, 4244, 4245, 4259, 4258, 4440, 4441, 4455, 4454
9109, 4245, 4246, 4260, 4259, 4441, 4442, 4456, 4455
9110, 4246, 4247, 4261, 4260, 4442, 4443, 4457, 4456
9111, 4247, 4248, 4262, 4261, 4443, 4444, 4458, 4457
9112, 4248, 4249, 4263, 4262, 4444, 4445, 4459, 4458
9113, 4249, 4250, 4264, 4263, 4445, 4446, 4460, 4459
9114, 4250, 4251, 4265, 4264, 4446, 4447, 4461, 4460
9115, 4251, 4252, 4266, 4265, 4447, 4448, 4462, 4461
9116, 4252, 4253, 4267, 4266, 4448, 4449, 4463, 4462
9117, 4253, 4254, 4268, 4267, 4449, 4450, 4464, 4463
9118, 4254, 4255, 4269, 4268, 4450, 4451, 4465, 4464
9119, 4255, 4256, 4270, 4269, 4451, 4452, 4466, 4465
9120, 4256, 716, 717, 4270, 4452, 772, 773, 4466
9121, 703, 4257, 4271, 704, 759, 4453, 4467, 760
9122, 4257, 4258, 4272, 4271, 4453, 4454, 4468, 4467
9123, 4258, 4259, 4273, 4272, 4454, 4455, 4469, 4468
9124, 4259, 4260, 4274, 4273, 4455, 4456, 4470, 4469
9125, 4260, 4261, 4275, 4274, 4456, 4457, 4471, 4470
9126, 4261, 4262, 4276, 4275, 4457, 4458, 4472, 4471
9127, 4262, 4263, 4277, 4276, 4458, 4459, 4473, 4472
9128, 4263, 4264, 4278, 4277, 4459, 4460, 4474, 4473
9129, 4264, 4265, 4279, 4278, 4460, 4461, 4475, 4474
9130, 4265, 4266, 4280, 4279, 4461, 4462, 4476, 4475
9131, 4266, 4267, 4281, 4280, 4462, 4463, 4477, 4476
9132, 4267, 4268, 4282, 4281, 4463, 4464, 4478, 4477
9133, 4268, 4269, 4283, 4282, 4464, 4465, 4479, 4478
9134, 4269, 4270, 4284, 4283, 4465, 4466, 4480, 4479
9135, 4270, 717, 718, 4284, 4466, 773, 774, 4480
9136, 704, 4271, 4285, 705, 760, 4467, 4481, 761
9137, 4271, 4272, 4286, 4285, 4467, 4468, 4482, 4481
9138, 4272, 4273, 4287, 4286, 4468, 4469, 4483, 4482
9139, 4273, 4274, 4288, 4287, 4469, 4470, 4484, 4483
9140, 4274, 4275, 4289, 4288, 4470, 4471, 4485, 4484
9141, 4275, 4276, 4290, 4289, 4471, 4472, 4486, 4485
9142, 4276, 4277, 4291, 4290, 4472, 4473, 4487, 4486
9143, 4277, 4278, 4292, 4291, 4473, 4474, 4488, 4487
9144, 4278, 4279, 4293, 4292, 4474, 4475, 4489, 4488
9145, 4279, 4280, 4294, 4293, 4475, 4476, 4490, 4489
9146, 4280, 4281, 4295, 4294, 4476, 4477, 4491, 4490
9147, 4281, 4282, 4296, 4295, 4477, 4478, 4492, 4491
9148, 4282, 4283, 4297, 4296, 4478, 4479, 4493, 4492
9149, 4283, 4284, 4298, 4297, 4479, 4480, 4494, 4493
9150, 4284, 718, 719, 4298, 4480, 774, 775, 4494
9151, 705, 4285, 4299, 706, 761, 4481, 4495, 762
9152, 4285, 4286, 4300, 4299, 4481, 4482, 4496, 4495
9153, 4286, 4287, 4301, 4300, 4482, 4483, 4497, 4496
9154, 4287, 4288, 4302, 4301, 4483, 4484, 4498, 4497
9155, 4288, 4289, 4303, 4302, 4484, 4485, 4499, 4498
9156, 4289, 4290, 4304, 4303, 4485, 4486, 4500, 4499
9157, 4290, 4291, 4305, 4304, 4486, 4487, 4501, 4500
9158, 4291, 4292, 4306, 4305, 4487, 4488, 4502, 4501
9159, 4292, 4293, 4307, 4306, 4488, 4489, 4503, 4502
9160, 4293, 4294, 4308, 4307, 4489, 4490, 4504, 4503
9161, 4294, 4295, 4309, 4308, 4490, 4491, 4505, 4504
9162, 4295, 4296, 4310, 4309, 4491, 4492, 4506, 4505
9163, 4296, 4297, 4311, 4310, 4492, 4493, 4507, 4506
9164, 4297, 4298, 4312, 4311, 4493, 4494, 4508, 4507
9165, 4298, 719, 720, 4312, 4494, 775, 776, 4508
9166, 706, 4299, 4313, 707, 762, 4495, 4509, 763
9167, 4299, 4300, 4314, 4313, 4495, 4496, 4510, 4509
9168, 4300, 4301, 4315, 4314, 4496, 4497, 4511, 4510
9169, 4301, 4302, 4316, 4315, 4497, 4498, 4512, 4511
9170, 4302, 4303, 4317, 4316, 4498, 4499, 4513, 4512
9171, 4303, 4304, 4318, 4317, 4499, 4500, 4514, 4513
9172, 4304, 4305, 4319, 4318, 4500, 4501, 4515, 4514
9173, 4305, 4306, 4320, 4319, 4501, 4502, 4516, 4515
9174, 4306, 4307, 4321, 4320, 4502, 4503, 4517, 4516
9175, 4307, 4308, 4322, 4321, 4503, 4504, 4518, 4517
9176, 4308, 4309, 4323, 4322, 4504, 4505, 4519, 4518
9177, 4309, 4310, 4324, 4323, 4505, 4506, 4520, 4519
9178, 4310, 4311, 4325, 4324, 4506, 4507, 4521, 4520
9179, 4311, 4312, 4326, 4325, 4507, 4508, 4522, 4521
9180, 4312, 720, 721, 4326, 4508, 776, 777, 4522
9181, 707, 4313, 4327, 708, 763, 4509, 4523, 764
9182, 4313, 4314, 4328, 4327, 4509, 4510, 4524, 4523
9183, 4314, 4315, 4329, 4328, 4510, 4511, 4525, 4524
9184, 4315, 4316, 4330, 4329, 4511, 4512, 4526, 4525
9185, 4316, 4317, 4331, 4330, 4512, 4513, 4527, 4526
9186, 4317, 4318, 4332, 4331, 4513, 4514, 4528, 4527
9187, 4318, 4319, 4333, 4332, 4514, 4515, 4529, 4528
9188, 4319, 4320, 4334, 4333, 4515, 4516, 4530, 4529
9189, 4320, 4321, 4335, 4334, 4516, 4517, 4531, 4530
9190, 4321, 4322, 4336, 4335, 4517, 4518, 4532, 4531
9191, 4322, 4323, 4337, 4336, 4518, 4519, 4533, 4532
9192, 4323, 4324, 4338, 4337, 4519, 4520, 4534, 4533
9193, 4324, 4325, 4339, 4338, 4520, 4521, 4535, 4534
9194, 4325, 4326, 4340, 4339, 4521, 4522, 4536, 4535
9195, 4326, 721, 722, 4340, 4522, 777, 778, 4536
9196, 708, 4327, 4341, 709, 764, 4523, 4537, 765
9197, 4327, 4328, 4342, 4341, 4523, 4524, 4538, 4537
9198, 4328, 4329, 4343, 4342, 4524, 4525, 4539, 4538
9199, 4329, 4330, 4344, 4343, 4525, 4526, 4540, 4539
9200, 4330, 4331, 4345, 4344, 4526, 4527, 4541, 4540
9201, 4331, 4332, 4346, 4345, 4527, 4528, 4542, 4541
9202, 4332, 4333, 4347, 4346, 4528, 4529, 4543, 4542
9203, 4333, 4334, 4348, 4347, 4529, 4530, 4544, 4543
9204, 4334, 4335, 4349, 4348, 4530, 4531, 4545, 4544
9205, 4335, 4336, 4350, 4349, 4531, 4532, 4546, 4545
9206, 4336, 4337, 4351, 4350, 4532, 4533, 4547, 4546
9207, 4337, 4338, 4352, 4351, 4533, 4534, 4548, 4547
9208, 4338, 4339, 4353, 4352, 4534, 4535, 4549, 4548
9209, 4339, 4340, 4354, 4353, 4535, 4536, 4550, 4549
9210, 4340, 722, 723, 4354, 4536, 778, 779, 4550
9211, 709, 4341, 4355, 710, 765, 4537, 4551, 766
9212, 4341, 4342, 4356, 4355, 4537, 4538, 4552, 4551
9213, 4342, 4343, 4357, 4356, 4538, 4539, 4553, 4552
9214, 4343, 4344, 4358, 4357, 4539, 4540, 4554, 4553
9215, 4344, 4345, 4359, 4358, 4540, 4541, 4555, 4554
9216, 4345, 4346, 4360, 4359, 4541, 4542, 4556, 4555
9217, 4346, 4347, 4361, 4360, 4542, 4543, 4557, 4556
9218, 4347, 4348, 4362, 4361, 4543, 4544, 4558, 4557
9219, 4348, 4349, 4363, 4362, 4544, 4545, 4559, 4558
9220, 4349, 4350, 4364, 4363, 4545, 4546, 4560, 4559
9221, 4350, 4351, 4365, 4364, 4546, 4547, 4561, 4560
9222, 4351, 4352, 4366, 4365, 4547, 4548, 4562, 4561
9223, 4352, 4353, 4367, 4366, 4548, 4549, 4563, 4562
9224, 4353, 4354, 4368, 4367, 4549, 4550, 4564, 4563
9225, 4354, 723, 724, 4368, 4550, 779, 780, 4564
9226, 710, 4355, 4369, 711, 766, 4551, 4565, 767
9227, 4355, 4356, 4370, 4369, 4551, 4552, 4566, 4565
9228, 4356, 4357, 4371, 4370, 4552, 4553, 4567, 4566
9229, 4357, 4358, 4372, 4371, 4553, 4554, 4568, 4567
9230, 4358, 4359, 4373, 4372, 4554, 4555, 4569, 4568
9231, 4359, 4360, 4374, 4373, 4555, 4556, 4570, 4569
9232, 4360, 4361, 4375, 4374, 4556, 4557, 4571, 4570
9233, 4361, 4362, 4376, 4375, 4557, 4558, 4572, 4571
9234, 4362, 4363, 4377, 4376, 4558, 4559, 4573, 4572
9235, 4363, 4364, 4378, 4377, 4559, 4560, 4574, 4573
9236, 4364, 4365, 4379, 4378, 4560, 4561, 4575, 4574
9237, 4365, 4366, 4380, 4379, 4561, 4562, 4576, 4575
9238, 4366, 4367, 4381, 4380, 4562, 4563, 4577, 4576
9239, 4367, 4368, 4382, 4381, 4563, 4564, 4578, 4577
9240, 4368, 724, 725, 4382, 4564, 780, 781, 4578
9241, 711, 4369, 4383, 712, 767, 4565, 4579, 768
9242, 4369, 4370, 4384, 4383, 4565, 4566, 4580, 4579
9243, 4370, 4371, 4385, 4384, 4566, 4567, 4581, 4580
9244, 4371, 4372, 4386, 4385, 4567, 4568, 4582, 4581
9245, 4372, 4373, 4387, 4386, 4568, 4569, 4583, 4582
9246, 4373, 4374, 4388, 4387, 4569, 4570, 4584, 4583
9247, 4374, 4375, 4389, 4388, 4570, 4571, 4585, 4584
9248, 4375, 4376, 4390, 4389, 4571, 4572, 4586, 4585
9249, 4376, 4377, 4391, 4390, 4572, 4573, 4587, 4586
9250, 4377, 4378, 4392, 4391, 4573, 4574, 4588, 4587
9251, 4378, 4379, 4393, 4392, 4574, 4575, 4589, 4588
9252, 4379, 4380, 4394, 4393, 4575, 4576, 4590, 4589
9253, 4380, 4381, 4395, 4394, 4576, 4577, 4591, 4590
9254, 4381, 4382, 4396, 4395, 4577, 4578, 4592, 4591
9255, 4382, 725, 726, 4396, 4578, 781, 782, 4592
9256, 712, 4383, 4397, 713, 768, 4579, 4593, 769
9257, 4383, 4384, 4398, 4397, 4579, 4580, 4594, 4593
9258, 4384, 4385, 4399, 4398, 4580, 4581, 4595, 4594
9259, 4385, 4386, 4400, 4399, 4581, 4582, 4596, 4595
9260, 4386, 4387, 4401, 4400, 4582, 4583, 4597, 4596
9261, 4387, 4388, 4402, 4401, 4583, 4584, 4598, 4597
9262, 4388, 4389, 4403, 4402, 4584, 4585, 4599, 4598
9263, 4389, 4390, 4404, 4403, 4585, 4586, 4600, 4599
9264, 4390, 4391, 4405, 4404, 4586, 4587, 4601, 4600
9265, 4391, 4392, 4406, 4405, 4587, 4588, 4602, 4601
9266, 4392, 4393, 4407, 4406, 4588, 4589, 4603, 4602
9267, 4393, 4394, 4408, 4407, 4589, 4590, 4604, 4603
9268, 4394, 4395, 4409, 4408, 4590, 4591, 4605, 4604
9269, 4395, 4396, 4410, 4409, 4591, 4592, 4606, 4605
9270, 4396, 726, 727, 4410, 4592, 782, 783, 4606
9271, 713, 4397, 4411, 714, 769, 4593, 4607, 770
9272, 4397, 4398, 4412, 4411, 4593, 4594, 4608, 4607
9273, 4398, 4399, 4413, 4412, 4594, 4595, 4609, 4608
9274, 4399, 4400, 4414, 4413, 4595, 4596, 4610, 4609
9275, 4400, 4401, 4415, 4414, 4596, 4597, 4611, 4610
9276, 4401, 4402, 4416, 4415, 4597, 4598, 4612, 4611
9277, 4402, 4403, 4417, 4416, 4598, 4599, 4613, 4612
9278, 4403, 4404, 4418, 4417, 4599, 4600, 4614, 4613
9279, 4404, 4405, 4419, 4418, 4600, 4601, 4615, 4614
9280, 4405, 4406, 4420, 4419, 4601, 4602, 4616, 4615
9281, 4406, 4407, 4421, 4420, 4602, 4603, 4617, 4616
9282, 4407, 4408, 4422, 4421, 4603, 4604, 4618, 4617
9283, 4408, 4409, 4423, 4422, 4604, 4605, 4619, 4618
9284, 4409, 4410, 4424, 4423, 4605, 4606, 4620, 4619
9285, 4410, 727, 728, 4424, 4606, 783, 784, 4620
9286, 714, 4411, 645, 37, 770, 4607, 729, 41
9287, 4411, 4412, 646, 645, 4607, 4608, 730, 729
9288, 4412, 4413, 647, 646, 4608, 4609, 731, 730
9289, 4413, 4414, 648, 647, 4609, 4610, 732, 731
9290, 4414, 4415, 649, 648, 4610, 4611, 733, 732
9291, 4415, 4416, 650, 649, 4611, 4612, 734, 733
9292, 4416, 4417, 651, 650, 4612, 4613, 735, 734
9293, 4417, 4418, 652, 651, 4613, 4614, 736, 735
9294, 4418, 4419, 653, 652, 4614, 4615, 737, 736
9295, 4419, 4420, 654, 653, 4615, 4616, 738, 737
9296, 4420, 4421, 655, 654, 4616, 4617, 739, 738
9297, 4421, 4422, 656, 655, 4617, 4618, 740, 739
9298, 4422, 4423, 657, 656, 4618, 4619, 741, 740
9299, 4423, 4424, 658, 657, 4619, 4620, 742, 741
9300, 4424, 728, 38, 658, 4620, 784, 42, 742
*ELEMENT, type=C3D8, ELSET=Volume11
9301, 43, 743, 4425, 757, 47, 799, 4621, 813
9302, 743, 744, 4426, 4425, 799, 800, 4622, 4621
9303, 744, 745, 4427, 4426, 800, 801, 4623, 4622
9304, 745, 746, 4428, 4427, 801, 802, 4624, 4623
9305, 746, 747, 4429, 4428, 802, 803, 4625, 4624
9306, 747, 748, 4430, 4429, 803, 804, 4626, 4625
9307, 748, 749, 4431, 4430, 804, 805, 4627, 4626
9308, 749, 750, 4432, 4431, 805, 806, 4628, 4627
9309, 750, 751, 4433, 4432, 806, 807, 4629, 4628
9310, 751, 752, 4434, 4433, 807, 808, 4630, 4629
9311, 752, 753, 4435, 4434, 808, 809, 4631, 4630
9312, 753, 754, 4436, 4435, 809, 810, 4632, 4631
9313, 754, 755, 4437, 4436, 810, 811, 4633, 4632
9314, 755, 756, 4438, 4437, 811, 812, 4634, 4633
9315, 756, 44, 771, 4438, 812, 48, 827, 4634
9316, 757, 4425, 4439, 758, 813, 4621, 4635, 814
9317, 4425, 4426, 4440, 4439, 4621, 4622, 4636, 4635
9318, 4426, 4427, 4441, 4440, 4622, 4623, 4637, 4636
9319, 4427, 4428, 4442, 4441, 4623, 4624, 4638, 4637
9320, 4428, 4429, 4443, 4442, 4624, 4625, 4639, 4638
9321, 4429, 4430, 4444, 4443, 4625, 4626, 4640, 4639
9322, 4430, 4431, 4445, 4444, 4626, 4627, 4641, 4640
9323, 4431, 4432, 4446, 4445, 4627, 4628, 4642, 4641
9324, 4432, 4433, 4447, 4446, 4628, 4629, 4643, 4642
9325, 4433, 4434, 4448, 4447, 4629, 4630, 4644, 4643
9326, 4434, 4435, 4449, 4448, 4630, 4631, 4645, 4644
9327, 4435, 4436, 4450, 4449, 4631, 4632, 4646, 4645
9328, 4436, 4437, 4451, 4450, 4632, 4633, 4647, 4646
9329, 4437, 4438, 4452, 4451, 4633, 4634, 4648, 4647
9330, 4438, 771, 772, 4452, 4634, 827, 828, 4648
9331, 758, 4439, 4453, 759, 814, 4635, 4649, 815
9332, 4439, 4440, 4454, 4453, 4635, 4636, 4650, 4649
9333, 4440, 4441, 4455, 4454, 4636, 4637, 4651, 4650
9334, 4441, 4442, 4456, 4455, 4637, 4638, 4652, 4651
9335, 4442, 4443, 4457, 4456, 4638, 4639, 4653, 4652
9336, 4443, 4444, 4458, 4457, 4639, 4640, 4654, 4653
9337, 4444, 4445, 4459, 4458, 4640, 4641, 4655, 4654
9338, 4445, 4446, 4460, 4459, 4641, 4642, 4656, 4655
9339, 4446, 4447, 4461, 4460, 4642, 4643, 4657, 4656
9340, 4447, 4448, 4462, 4461, 4643, 4644, 4658, 4657
9341, 4448, 4449, 4463, 4462, 4644, 4645, 4659, 4658
9342, 4449, 4450, 4464, 4463, 4645, 4646, 4660, 4659
9343, 4450, 4451, 4465, 4464, 4646, 4647, 4661, 4660
9344, 4451, 4452, 4466, 4465, 4647, 4648, 4662, 4661
9345, 4452, 772, 773, 4466, 4648, 828, 829, 4662
9346, 759, 4453, 4467, 760, 815, 4649, 4663, 816
9347, 4453, 4454, 4468, 4467, 4649, 4650, 4664, 4663
9348, 4454, 4455, 4469, 4468, 4650, 4651, 4665, 4664
9349, 4455, 4456, 4470, 4469, 4651, 4652, 4666, 4665
9350, 4456, 4457, 4471, 4470, 4652, 4653, 4667, 4666
9351, 4457, 4458, 4472, 4471, 4653, 4654, 4668, 4667
9352, 4458, 4459, 4473, 4472, 4654, 4655, 4669, 4668
9353, 4459, 4460, 4474, 4473, 4655, 4656, 4670, 4669
9354, 4460, 4461, 4475, 4474, 4656, 4657, 4671, 4670
9355, 4461, 4462, 4476, 4475, 4657, 4658, 4672, 4671
9356, 4462, 4463, 4477, 4476, 4658, 4659, 4673, 4672
9357, 4463, 4464, 4478, 4477, 4659, 4660, 4674, 4673
9358, 4464, 4465, 4479, 4478, 4660, 4661, 4675, 4674
9359, 4465, 4466, 4480, 4479, 4661, 4662, 4676, 4675
9360, 4466, 773, 774, 4480, 4662, 829, 830, 4676
9361, 760, 4467, 4481, 761, 816, 4663, 4677, 817
9362, 4467, 4468, 4482, 4481, 4663, 4664, 4678, 4677
9363, 4468, 4469, 4483, 4482, 4664, 4665, 4679, 4678
9364, 4469, 4470, 4484, 4483, 4665, 4666, 4680, 4679
9365, 4470, 4471, 4485, 4484, 4666, 4667, 4681, 4680
9366, 4471, 4472, 4486, 4485, 4667, 4668, 4682, 4681
9367, 4472, 4473, 4487, 4486, 4668, 4669, 4683, 4682
9368, 4473, 4474, 4488, 4487, 4669, 4670, 4684, 4683
9369, 4474, 4475, 4489, 4488, 4670, 4671, 4685, 4684
9370, 4475, 4476, 4490, 4489, 4671, 4672, 4686, 4685
9371, 4476, 4477, 4491, 4490, 4672, 4673, 4687, 4686
9372, 4477, 4478, 4492, 4491, 4673, 4674, 4688, 4687
9373, 4478, 4479, 4493, 4492, 4674, 4675, 4689, 4688
9374, 4479, 4480, 4494, 4493, 4675, 4676, 4690, 4689
9375, 4480, 774, 775, 4494, 4676, 830, 831, 4690
9376, 761, 4481, 4495, 762, 817, 4677, 4691, 818
9377, 4481, 4482, 4496, 4495, 4677, 4678, 4692, 4691
9378, 4482, 4483, 4497, 4496, 4678, 4679, 4693, 4692
9379, 4483, 4484, 4498, 4497, 4679, 4680, 4694, 4693
9380, 4484, 4485, 4499, 4498, 4680, 4681, 4695, 4694
9381, 4485, 4486, 4500, 4499, 4681, 4682, 4696, 4695
9382, 4486, 4487, 4501, 4500, 4682, 4683, 4697, 4696
9383, 4487, 4488, 4502, 4501, 4683, 4684, 4698, 4697
9384, 4488, 4489, 4503, 4502, 4684, 4685, 4699, 4698
9385, 4489, 4490, 4504, 4503, 4685, 4686, 4700, 4699
9386, 4490, 4491, 4505, 4504, 4686, 4687, 4701, 4700
9387, 4491, 4492, 4506, 4505, 4687, 4688, 4702, 4701
9388, 4492, 4493, 4507, 4506, 4688, 4689, 4703, 4702
9389, 4493, 4494, 4508, 4507, 4689, 4690, 4704, 4703
9390, 4494, 775, 776, 4508, 4690, 831, 832, 4704
9391, 762, 4495, 4509, 763, 818, 4691, 4705, 819
9392, 4495, 4496, 4510, 4509, 4691, 4692, 4706, 4705
9393, 4496, 4497, 4511, 4510, 4692, 4693, 4707, 4706
9394, 4497, 4498, 4512, 4511, 4693, 4694, 4708, 4707
9395, 4498, 4499, 4513, 4512, 4694, 4695, 4709, 4708
9396, 4499, 4500, 4514, 4513, 4695, 4696, 4710, 4709
9397, 4500, 4501, 4515, 4514, 4696, 4697, 4711, 4710
9398, 4501, 4502, 4516, 4515, 4697, 4698, 4712, 4711
9399, 4502, 4503, 4517, 4516, 4698, 4699, 4713, 4712
9400, 4503, 4504, 4518, 4517, 4699, 4700, 4714, 4713
9401, 4504, 4505, 4519, 4518, 4700, 4701, 4715, 4714
9402, 4505, 4506, 4520, 4519, 4701, 4702, 4716, 4715
9403, 4506, 4507, 4521, 4520, 4702, 4703, 4717, 4716
9404, 4507, 4508, 4522, 4521, 4703, 4704, 4718, 4717
9405, 4508, 776, 777, 4522, 4704, 832, 833, 4718
9406, 763, 4509, 4523, 764, 819, 4705, 4719, 820
9407, 4509, 4510, 4524, 4523, 4705, 4706, 4720, 4719
9408, 4510, 4511, 4525, 4524, 4706, 4707, 4721, 4720
9409, 4511, 4512, 4526, 4525, 4707, 4708, 4722, 4721
9410, 4512, 4513, 4527, 4526, 4708, 4709, 4723, 4722
9411, 4513, 4514, 4528, 4527, 4709, 4710, 4724, 4723
9412, 4514, 4515, 4529, 4528, 4710, 4711, 4725, 4724
9413, 4515, 4516, 4530, 4529, 4711, 4712, 4726, 4725
9414, 4516, 4517, 4531, 4530, 4712, 4713, 4727, 4726
9415, 4517, 4518, 4532, 4531, 4713, 4714, 4728, 4727
9416, 4518, 4519, 4533, 4532, 4714, 4715, 4729, 4728
9417, 4519, 4520, 4534, 4533, 4715, 4716, 4730, 4729
9418, 4520, 4521, 4535, 4534, 4716, 4717, 4731, 4730
9419, 4521, 4522, 4536, 4535, 4717, 4718, 4732, 4731
9420, 4522, 777, 778, 4536, 4718, 833, 834, 4732
9421, 764, 4523, 4537, 765, 820, 4719, 4733, 821
9422, 4523, 4524, 4538, 4537, 4719, 4720, 4734, 4733
9423, 4524, 4525, 4539, 4538, 4720, 4721, 4735, 4734
9424, 4525, 4526, 4540, 4539, 4721, 4722, 4736, 4735
9425, 4526, 4527, 4541, 4540, 4722, 4723, 4737, 4736
9426, 4527, 4528, 4542, 4541, 4723, 4724, 4738, 4737
9427, 4528, 4529, 4543, 4542, 4724, 4725, 4739, 4738
9428, 4529, 4530, 4544, 4543, 4725, 4726, 4740, 4739
9429, 4530, 4531, 4545, 4544, 4726, 4727, 4741, 4740
9430, 4531, 4532, 4546, 4545, 4727, 4728, 4742, 4741
9431, 4532, 4533, 4547, 4546, 4728, 4729, 4743, 4742
9432, 4533, 4534, 4548, 4547, 4729, 4730, 4744, 4743
9433, 4534, 4535, 4549, 4548, 4730, 4731, 4745, 4744
9434, 4535, 4536, 4550, 4549, 4731, 4732, 4746, 4745
9435, 4536, 778, 779, 4550, 4732, 834, 835, 4746
9436, 765, 4537, 4551, 766, 821, 4733, 4747, 822
9437, 4537, 4538, 4552, 4551, 4733, 4734, 4748, 4747
9438, 4538, 4539, 4553, 4552, 4734, 4735, 4749, 4748
9439, 4539, 4540, 4554, 4553, 4735, 4736, 4750, 4749
9440, 4540, 4541, 4555, 4554, 4736, 4737, 4751, 4750
9441, 4541, 4542, 4556, 4555, 4737, 4738, 4752, 4751
9442, 4542, 4543, 4557, 4556, 4738, 4739, 4753, 4752
9443, 4543, 4544, 4558, 4557, 4739, 4740, 4754, 4753
9444, 4544, 4545, 4559, 4558, 4740, 4741, 4755, 4754
9445, 4545, 4546, 4560, 4559, 4741, 4742, 4756, 4755
9446, 4546, 4547, 4561, 4560, 4742, 4743, 4757, 4756
9447, 4547, 4548, 4562, 4561, 4743, 4744, 4758, 4757
9448, 4548, 4549, 4563, 4562, 4744, 4745, 4759, 4758
9449, 4549, 4550, 4564, 4563, 4745, 4746, 4760, 4759
9450, 4550, 779, 780, 4564, 4746, 835, 836, 4760
9451, 766, 4551, 4565, 767, 822, 4747, 4761, 823
9452, 4551, 4552, 4566, 4565, 4747, 4748, 4762, 4761
9453, 4552, 4553, 4567, 4566, 4748, 4749, 4763, 4762
9454, 4553, 4554, 4568, 4567, 4749, 4750, 4764, 4763
9455, 4554, 4555, 4569, 4568, 4750, 4751, 4765, 4764
9456, 4555, 4556, 4570, 4569, 4751, 4752, 4766, 4765
9457, 4556, 4557, 4571, 4570, 4752, 4753, 4767, 4766
9458, 4557, 4558, 4572, 4571, 4753, 4754, 4768, 4767
9459, 4558, 4559, 4573, 4572, 4754, 4755, 4769, 4768
9460, 4559, 4560, 4574, 4573, 4755, 4756, 4770, 4769
9461, 4560, 4561, 4575, 4574, 4756, 4757, 4771, 4770
9462, 4561, 4562, 4576, 4575, 4757, 4758, 4772, 4771
9463, 4562, 4563, 4577, 4576, 4758, 4759, 4773, 4772
9464, 4563, 4564, 4578, 4577, 4759, 4760, 4774, 4773
9465, 4564, 780, 781, 4578, 4760, 836, 837, 4774
9466, 767, 4565, 4579, 768, 823, 4761, 4775, 824
9467, 4565, 4566, 4580, 4579, 4761, 4762, 4776, 4775
9468, 4566, 4567, 4581, 4580, 4762, 4763, 4777, 4776
9469, 4567, 4568, 4582, 4581, 4763, 4764, 4778, 4777
9470, 4568, 4569, 4583, 4582, 4764, 4765, 4779, 4778
9471, 4569, 4570, 4584, 4583, 4765, 4766, 4780, 4779
9472, 4570, 4571, 4585, 4584, 4766, 4767, 4781, 4780
9473, 4571, 4572, 4586, 4585, 4767, 4768, 4782, 4781
9474, 4572, 4573, 4587, 4586, 4768, 4769, 4783, 4782
9475, 4573, 4574, 4588, 4587, 4769, 4770, 4784, 4783
9476, 4574, 4575, 4589, 4588, 4770, 4771, 4785, 4784
9477, 4575, 4576, 4590, 4589, 4771, 4772, 4786, 4785
9478, 4576, 4577, 4591, 4590, 4772, 4773, 4787, 4786
9479, 4577, 4578, 4592, 4591, 4773, 4774, 4788, 4787
9480, 4578, 781, 782, 4592, 4774, 837, 838, 4788
9481, 768, 4579, 4593, 769, 824, 4775, 4789, 825
9482, 4579, 4580, 4594, 4593, 4775, 4776, 4790, 4789
9483, 4580, 4581, 4595, 4594, 4776, 4777, 4791, 4790
9484, 4581, 4582, 4596, 4595, 4777, 4778, 4792, 4791
9485, 4582, 4583, 4597, 4596, 4778, 4779, 4793, 4792
9486, 4583, 4584, 4598, 4597, 4779, 4780, 4794, 4793
9487, 4584, 4585, 4599, 4598, 4780, 4781, 4795, 4794
9488, 4585, 4586, 4600, 4599, 4781, 4782, 4796, 4795
9489, 4586, 4587, 4601, 4600, 4782, 4783, 4797, 4796
9490, 4587, 4588, 4602, 4601, 4783, 4784, 4798, 4797
9491, 4588, 4589, 4603, 4602, 4784, 4785, 4799, 4798
9492, 4589, 4590, 4604, 4603, 4785, 4786, 4800, 4799
9493, 4590, 4591, 4605, 4604, 4786, 4787, 4801, 4800
9494, 4591, 4592, 4606, 4605, 4787, 4788, 4802, 4801
9495, 4592, 782, 783, 4606, 4788, 838, 839, 4802
9496, 769, 4593, 4607, 770, 825, 4789, 4803, 826
9497, 4593, 4594, 4608, 4607, 4789, 4790, 4804, 4803
9498, 4594, 4595, 4609, 4608, 4790, 4791, 4805, 4804
9499, 4595, 4596, 4610, 4609, 4791, 4792, 4806, 4805
9500, 4596, 4597, 4611, 4610, 4792, 4793, 4807, 4806
9501, 4597, 4598, 4612, 4611, 4793, 4794, 4808, 4807
9502, 4598, 4599, 4613, 4612, 4794, 4795, 4809, 4808
9503, 4599, 4600, 4614, 4613, 4795, 4796, 4810, 4809
9504, 4600, 4601, 4615, 4614, 4796, 4797, 4811, 4810
9505, 4601, 4602, 4616, 4615, 4797, 4798, 4812, 4811
9506, 4602, 4603, 4617, 4616, 4798, 4799, 4813, 4812
9507, 4603, 4604, 4618, 4617, 4799, 4800, 4814, 4813
9508, 4604, 4605, 4619, 4618, 4800, 4801, 4815, 4814
9509, 4605, 4606, 4620, 4619, 4801, 4802, 4816, 4815
9510, 4606, 783, 784, 4620, 4802, 839, 840, 4816
9511, 770, 4607, 729, 41, 826, 4803, 785, 45
9512, 4607, 4608, 730, 729, 4803, 4804, 786, 785
9513, 4608, 4609, 731, 730, 4804, 4805, 787, 786
9514, 4609, 4610, 732, 731, 4805, 4806, 788, 787
9515, 4610, 4611, 733, 732, 4806, 4807, 789, 788
9516, 4611, 4612, 734, 733, 4807, 4808, 790, 789
9517, 4612, 4613, 735, 734, 4808, 4809, 791, 790
9518, 4613, 4614, 736, 735, 4809, 4810, 792, 791
9519, 4614, 4615, 737, 736, 4810, 4811, 793, 792
9520, 4615, 4616, 738, 737, 4811, 4812, 794, 793
9521, 4616, 4617, 739, 738, 4812, 4813, 795, 794
9522, 4617, 4618, 740, 739, 4813, 4814, 796, 795
9523, 4618, 4619, 741, 740, 4814, 4815, 797, 796
9524, 4619, 4620, 742, 741, 4815, 4816, 798, 797
9525, 4620, 784, 42, 742, 4816, 840, 46, 798
*ELEMENT, type=C3D8, ELSET=Volume12
9526, 44, 771, 827, 48, 51, 841, 855, 52
9527, 771, 772, 828, 827, 841, 842, 856, 855
9528, 772, 773, 829, 828, 842, 843, 857, 856
9529, 773, 774, 830, 829, 843, 844, 858, 857
9530, 774, 775, 831, 830, 844, 845, 859, 858
9531, 775, 776, 832, 831, 845, 846, 860, 859
9532, 776, 777, 833, 832, 846, 847, 861, 860
9533, 777, 778, 834, 833, 847, 848, 862, 861
9534, 778, 779, 835, 834, 848, 849, 863, 862
9535, 779, 780, 836, 835, 849, 850, 864, 863
9536, 780, 781, 837, 836, 850, 851, 865, 864
9537, 781, 782, 838, 837, 851, 852, 866, 865
9538, 782, 783, 839, 838, 852, 853, 867, 866
9539, 783, 784, 840, 839, 853, 854, 868, 867
9540, 784, 42, 46, 840, 854, 49, 50, 868
*ELEMENT, type=C3D8, ELSET=Volume13
9541, 2, 57, 71, 4, 54, 869, 883, 56
9542, 57, 58, 72, 71, 869, 870, 884, 883
9543, 58, 59, 73, 72, 870, 871, 885, 884
9544, 59, 60, 74, 73, 871, 872, 886, 885
9545, 60, 61, 75, 74, 872, 873, 887, 886
9546, 61, 62, 76, 75, 873, 874, 888, 887
9547, 62, 63, 77, 76, 874, 875, 889, 888
9548, 63, 64, 78, 77, 875, 876, 890, 889
9549, 64, 65, 79, 78, 876, 877, 891, 890
9550, 65, 66, 80, 79, 877, 878, 892, 891
9551, 66, 67, 81, 80, 878, 879, 893, 892
9552, 67, 68, 82, 81, 879, 880, 894, 893
9553, 68, 69, 83, 82, 880, 881, 895, 894
9554, 69, 70, 84, 83, 881, 882, 896, 895
9555, 70, 1, 3, 84, 882, 53, 55, 896
*ELSET,ELSET=Qin
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 592, 593, 594, 595, 596, 597, 598, 599, 600, 
601, 602, 603, 604, 605, 606, 607, 608, 609, 610, 
611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 
621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 
631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 704, 705, 
*ELSET,ELSET=HeatSink
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 706, 707, 708, 709, 710, 
711, 712, 713, 714, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 724, 725, 726, 727, 728, 729, 730, 
731, 732, 733, 734, 735, 736, 737, 738, 739, 740, 
741, 742, 743, 744, 745, 746, 747, 748, 749, 750, 
751, 752, 753, 754, 755, 756, 757, 758, 759, 760, 
761, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 773, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 796, 797, 798, 799, 800, 
801, 802, 803, 804, 805, 806, 807, 808, 809, 810, 
811, 812, 813, 814, 815, 816, 817, 818, 819, 820, 
821, 822, 823, 824, 825, 826, 827, 828, 829, 830, 
831, 832, 833, 834, 835, 836, 837, 838, 839, 840, 
841, 842, 843, 844, 845, 846, 847, 848, 849, 850, 
851, 852, 853, 854, 855, 856, 857, 858, 859, 860, 
861, 862, 863, 864, 865, 866, 867, 868, 869, 870, 
871, 872, 873, 874, 875, 876, 877, 878, 879, 880, 
881, 882, 883, 884, 885, 886, 887, 888, 889, 890, 
891, 892, 893, 894, 895, 896, 897, 898, 899, 900, 
901, 902, 903, 904, 905, 906, 907, 908, 909, 910, 
911, 912, 913, 914, 915, 916, 917, 918, 919, 920, 
921, 922, 923, 924, 925, 926, 927, 928, 929, 930, 
*ELSET,ELSET=ElectrodeMaxX
931, 932, 933, 934, 935, 936, 937, 938, 939, 940, 
941, 942, 943, 944, 945, 
*ELSET,ELSET=ElectrodeMinX
946, 947, 948, 949, 950, 951, 952, 953, 954, 955, 
956, 957, 958, 959, 960, 
*ELSET,ELSET=Force
226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 
236, 237, 238, 239, 240, 
*ELSET,ELSET=Copper
961, 962, 963, 964, 965, 966, 967, 968, 969, 970, 
971, 972, 973, 974, 975, 976, 977, 978, 979, 980, 
981, 982, 983, 984, 985, 986, 987, 988, 989, 990, 
991, 992, 993, 994, 995, 996, 997, 998, 999, 1000, 
1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 
1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 
1021, 1022, 1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 
1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 
1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 
1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 
1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 
1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 
1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 
1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 
1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 
1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 
1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 
1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 
1141, 1142, 1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 
1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 
1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 
1171, 1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 
1181, 1182, 1183, 1184, 1185, 5011, 5012, 5013, 5014, 5015, 
5016, 5017, 5018, 5019, 5020, 5021, 5022, 5023, 5024, 5025, 
5026, 5027, 5028, 5029, 5030, 5031, 5032, 5033, 5034, 5035, 
5036, 5037, 5038, 5039, 5040, 5041, 5042, 5043, 5044, 5045, 
5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 5054, 5055, 
5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 5064, 5065, 
5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 5074, 5075, 
5076, 5077, 5078, 5079, 5080, 5081, 5082, 5083, 5084, 5085, 
5086, 5087, 5088, 5089, 5090, 5091, 5092, 5093, 5094, 5095, 
5096, 5097, 5098, 5099, 5100, 5101, 5102, 5103, 5104, 5105, 
5106, 5107, 5108, 5109, 5110, 5111, 5112, 5113, 5114, 5115, 
5116, 5117, 5118, 5119, 5120, 5121, 5122, 5123, 5124, 5125, 
5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 5134, 5135, 
5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 5144, 5145, 
5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 5154, 5155, 
5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 5164, 5165, 
5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 5174, 5175, 
5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 5184, 5185, 
5186, 5187, 5188, 5189, 5190, 5191, 5192, 5193, 5194, 5195, 
5196, 5197, 5198, 5199, 5200, 5201, 5202, 5203, 5204, 5205, 
5206, 5207, 5208, 5209, 5210, 5211, 5212, 5213, 5214, 5215, 
5216, 5217, 5218, 5219, 5220, 5221, 5222, 5223, 5224, 5225, 
5226, 5227, 5228, 5229, 5230, 5231, 5232, 5233, 5234, 5235, 
5236, 5237, 5238, 5239, 5240, 5241, 5242, 5243, 5244, 5245, 
5246, 5247, 5248, 5249, 5250, 5251, 5252, 5253, 5254, 5255, 
5256, 5257, 5258, 5259, 5260, 5261, 5262, 5263, 5264, 5265, 
5266, 5267, 5268, 5269, 5270, 5271, 5272, 5273, 5274, 5275, 
5276, 5277, 5278, 5279, 5280, 5281, 5282, 5283, 5284, 5285, 
5286, 5287, 5288, 5289, 5290, 5291, 5292, 5293, 5294, 5295, 
5296, 5297, 5298, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 
5306, 5307, 5308, 5309, 5310, 5311, 5312, 5313, 5314, 5315, 
5316, 5317, 5318, 5319, 5320, 5321, 5322, 5323, 5324, 5325, 
5326, 5327, 5328, 5329, 5330, 5331, 5332, 5333, 5334, 5335, 
5336, 5337, 5338, 5339, 5340, 5341, 5342, 5343, 5344, 5345, 
5346, 5347, 5348, 5349, 5350, 5351, 5352, 5353, 5354, 5355, 
5356, 5357, 5358, 5359, 5360, 5361, 5362, 5363, 5364, 5365, 
5366, 5367, 5368, 5369, 5370, 5371, 5372, 5373, 5374, 5375, 
5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 5384, 5385, 
5386, 5387, 5388, 5389, 5390, 5391, 5392, 5393, 5394, 5395, 
5396, 5397, 5398, 5399, 5400, 5401, 5402, 5403, 5404, 5405, 
5406, 5407, 5408, 5409, 5410, 5411, 5412, 5413, 5414, 5415, 
5416, 5417, 5418, 5419, 5420, 5421, 5422, 5423, 5424, 5425, 
5426, 5427, 5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 
5436, 5437, 5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 
5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 
5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 
5466, 5467, 5468, 5469, 5470, 5471, 5472, 5473, 5474, 5475, 
9301, 9302, 9303, 9304, 9305, 9306, 9307, 9308, 9309, 9310, 
9311, 9312, 9313, 9314, 9315, 9316, 9317, 9318, 9319, 9320, 
9321, 9322, 9323, 9324, 9325, 9326, 9327, 9328, 9329, 9330, 
9331, 9332, 9333, 9334, 9335, 9336, 9337, 9338, 9339, 9340, 
9341, 9342, 9343, 9344, 9345, 9346, 9347, 9348, 9349, 9350, 
9351, 9352, 9353, 9354, 9355, 9356, 9357, 9358, 9359, 9360, 
9361, 9362, 9363, 9364, 9365, 9366, 9367, 9368, 9369, 9370, 
9371, 9372, 9373, 9374, 9375, 9376, 9377, 9378, 9379, 9380, 
9381, 9382, 9383, 9384, 9385, 9386, 9387, 9388, 9389, 9390, 
9391, 9392, 9393, 9394, 9395, 9396, 9397, 9398, 9399, 9400, 
9401, 9402, 9403, 9404, 9405, 9406, 9407, 9408, 9409, 9410, 
9411, 9412, 9413, 9414, 9415, 9416, 9417, 9418, 9419, 9420, 
9421, 9422, 9423, 9424, 9425, 9426, 9427, 9428, 9429, 9430, 
9431, 9432, 9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 
9441, 9442, 9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 
9451, 9452, 9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 
9461, 9462, 9463, 9464, 9465, 9466, 9467, 9468, 9469, 9470, 
9471, 9472, 9473, 9474, 9475, 9476, 9477, 9478, 9479, 9480, 
9481, 9482, 9483, 9484, 9485, 9486, 9487, 9488, 9489, 9490, 
9491, 9492, 9493, 9494, 9495, 9496, 9497, 9498, 9499, 9500, 
9501, 9502, 9503, 9504, 9505, 9506, 9507, 9508, 9509, 9510, 
9511, 9512, 9513, 9514, 9515, 9516, 9517, 9518, 9519, 9520, 
9521, 9522, 9523, 9524, 9525, 9526, 9527, 9528, 9529, 9530, 
9531, 9532, 9533, 9534, 9535, 9536, 9537, 9538, 9539, 9540, 
9541, 9542, 9543, 9544, 9545, 9546, 9547, 9548, 9549, 9550, 
9551, 9552, 9553, 9554, 9555, 
*ELSET,ELSET=SemiconductorN-
1411, 1412, 1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 
1421, 1422, 1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 
1431, 1432, 1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 
1441, 1442, 1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 
1451, 1452, 1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 
1461, 1462, 1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 
1471, 1472, 1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 
1481, 1482, 1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 
1491, 1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 
1501, 1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 
1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 
1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 
1531, 1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 
1541, 1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 
1551, 1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 
1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 
1571, 1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 
1581, 1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 
1591, 1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 
1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 
1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 
1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 
1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 
1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 
1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 
1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 
1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 
1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 
1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 
1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 
1811, 1812, 1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 
1821, 1822, 1823, 1824, 1825, 1826, 1827, 1828, 1829, 1830, 
1831, 1832, 1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 
1841, 1842, 1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 
1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 
1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 1869, 1870, 
1871, 1872, 1873, 1874, 1875, 1876, 1877, 1878, 1879, 1880, 
1881, 1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 
1891, 1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 
1901, 1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 
1911, 1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 
1921, 1922, 1923, 1924, 1925, 1926, 1927, 1928, 1929, 1930, 
1931, 1932, 1933, 1934, 1935, 1936, 1937, 1938, 1939, 1940, 
1941, 1942, 1943, 1944, 1945, 1946, 1947, 1948, 1949, 1950, 
1951, 1952, 1953, 1954, 1955, 1956, 1957, 1958, 1959, 1960, 
1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 
1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 
1981, 1982, 1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 
1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 
2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 
2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 
2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 
2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 
2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 
2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 
2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 
2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 
2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 
2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 
2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 2189, 2190, 
2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 2199, 2200, 
2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 2209, 2210, 
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 2499, 2500, 
2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 2509, 2510, 
2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 2519, 2520, 
2521, 2522, 2523, 2524, 2525, 2526, 2527, 2528, 2529, 2530, 
2531, 2532, 2533, 2534, 2535, 2536, 2537, 2538, 2539, 2540, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 2587, 2588, 2589, 2590, 
2591, 2592, 2593, 2594, 2595, 2596, 2597, 2598, 2599, 2600, 
2601, 2602, 2603, 2604, 2605, 2606, 2607, 2608, 2609, 2610, 
2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 2619, 2620, 
2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 2629, 2630, 
2631, 2632, 2633, 2634, 2635, 2636, 2637, 2638, 2639, 2640, 
2641, 2642, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 2650, 
2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 2660, 
2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 2670, 
2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 2680, 
2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 2690, 
2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 2700, 
2701, 2702, 2703, 2704, 2705, 2706, 2707, 2708, 2709, 2710, 
2711, 2712, 2713, 2714, 2715, 2716, 2717, 2718, 2719, 2720, 
2721, 2722, 2723, 2724, 2725, 2726, 2727, 2728, 2729, 2730, 
2731, 2732, 2733, 2734, 2735, 2736, 2737, 2738, 2739, 2740, 
2741, 2742, 2743, 2744, 2745, 2746, 2747, 2748, 2749, 2750, 
2751, 2752, 2753, 2754, 2755, 2756, 2757, 2758, 2759, 2760, 
2761, 2762, 2763, 2764, 2765, 2766, 2767, 2768, 2769, 2770, 
2771, 2772, 2773, 2774, 2775, 2776, 2777, 2778, 2779, 2780, 
2781, 2782, 2783, 2784, 2785, 2786, 2787, 2788, 2789, 2790, 
2791, 2792, 2793, 2794, 2795, 2796, 2797, 2798, 2799, 2800, 
2801, 2802, 2803, 2804, 2805, 2806, 2807, 2808, 2809, 2810, 
2811, 2812, 2813, 2814, 2815, 2816, 2817, 2818, 2819, 2820, 
2821, 2822, 2823, 2824, 2825, 2826, 2827, 2828, 2829, 2830, 
2831, 2832, 2833, 2834, 2835, 2836, 2837, 2838, 2839, 2840, 
2841, 2842, 2843, 2844, 2845, 2846, 2847, 2848, 2849, 2850, 
2851, 2852, 2853, 2854, 2855, 2856, 2857, 2858, 2859, 2860, 
2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 2869, 2870, 
2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 2879, 2880, 
2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 2889, 2890, 
2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 2899, 2900, 
2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 2909, 2910, 
2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 2919, 2920, 
2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 2929, 2930, 
2931, 2932, 2933, 2934, 2935, 2936, 2937, 2938, 2939, 2940, 
2941, 2942, 2943, 2944, 2945, 2946, 2947, 2948, 2949, 2950, 
2951, 2952, 2953, 2954, 2955, 2956, 2957, 2958, 2959, 2960, 
2961, 2962, 2963, 2964, 2965, 2966, 2967, 2968, 2969, 2970, 
2971, 2972, 2973, 2974, 2975, 2976, 2977, 2978, 2979, 2980, 
2981, 2982, 2983, 2984, 2985, 2986, 2987, 2988, 2989, 2990, 
2991, 2992, 2993, 2994, 2995, 2996, 2997, 2998, 2999, 3000, 
3001, 3002, 3003, 3004, 3005, 3006, 3007, 3008, 3009, 3010, 
3011, 3012, 3013, 3014, 3015, 3016, 3017, 3018, 3019, 3020, 
3021, 3022, 3023, 3024, 3025, 3026, 3027, 3028, 3029, 3030, 
3031, 3032, 3033, 3034, 3035, 3036, 3037, 3038, 3039, 3040, 
3041, 3042, 3043, 3044, 3045, 3046, 3047, 3048, 3049, 3050, 
3051, 3052, 3053, 3054, 3055, 3056, 3057, 3058, 3059, 3060, 
3061, 3062, 3063, 3064, 3065, 3066, 3067, 3068, 3069, 3070, 
3071, 3072, 3073, 3074, 3075, 3076, 3077, 3078, 3079, 3080, 
3081, 3082, 3083, 3084, 3085, 3086, 3087, 3088, 3089, 3090, 
3091, 3092, 3093, 3094, 3095, 3096, 3097, 3098, 3099, 3100, 
3101, 3102, 3103, 3104, 3105, 3106, 3107, 3108, 3109, 3110, 
3111, 3112, 3113, 3114, 3115, 3116, 3117, 3118, 3119, 3120, 
3121, 3122, 3123, 3124, 3125, 3126, 3127, 3128, 3129, 3130, 
3131, 3132, 3133, 3134, 3135, 3136, 3137, 3138, 3139, 3140, 
3141, 3142, 3143, 3144, 3145, 3146, 3147, 3148, 3149, 3150, 
3151, 3152, 3153, 3154, 3155, 3156, 3157, 3158, 3159, 3160, 
3161, 3162, 3163, 3164, 3165, 3166, 3167, 3168, 3169, 3170, 
3171, 3172, 3173, 3174, 3175, 3176, 3177, 3178, 3179, 3180, 
3181, 3182, 3183, 3184, 3185, 3186, 3187, 3188, 3189, 3190, 
3191, 3192, 3193, 3194, 3195, 3196, 3197, 3198, 3199, 3200, 
3201, 3202, 3203, 3204, 3205, 3206, 3207, 3208, 3209, 3210, 
3211, 3212, 3213, 3214, 3215, 3216, 3217, 3218, 3219, 3220, 
3221, 3222, 3223, 3224, 3225, 3226, 3227, 3228, 3229, 3230, 
3231, 3232, 3233, 3234, 3235, 3236, 3237, 3238, 3239, 3240, 
3241, 3242, 3243, 3244, 3245, 3246, 3247, 3248, 3249, 3250, 
3251, 3252, 3253, 3254, 3255, 3256, 3257, 3258, 3259, 3260, 
3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 3269, 3270, 
3271, 3272, 3273, 3274, 3275, 3276, 3277, 3278, 3279, 3280, 
3281, 3282, 3283, 3284, 3285, 3286, 3287, 3288, 3289, 3290, 
3291, 3292, 3293, 3294, 3295, 3296, 3297, 3298, 3299, 3300, 
3301, 3302, 3303, 3304, 3305, 3306, 3307, 3308, 3309, 3310, 
3311, 3312, 3313, 3314, 3315, 3316, 3317, 3318, 3319, 3320, 
3321, 3322, 3323, 3324, 3325, 3326, 3327, 3328, 3329, 3330, 
3331, 3332, 3333, 3334, 3335, 3336, 3337, 3338, 3339, 3340, 
3341, 3342, 3343, 3344, 3345, 3346, 3347, 3348, 3349, 3350, 
3351, 3352, 3353, 3354, 3355, 3356, 3357, 3358, 3359, 3360, 
3361, 3362, 3363, 3364, 3365, 3366, 3367, 3368, 3369, 3370, 
3371, 3372, 3373, 3374, 3375, 3376, 3377, 3378, 3379, 3380, 
3381, 3382, 3383, 3384, 3385, 3386, 3387, 3388, 3389, 3390, 
3391, 3392, 3393, 3394, 3395, 3396, 3397, 3398, 3399, 3400, 
3401, 3402, 3403, 3404, 3405, 3406, 3407, 3408, 3409, 3410, 
3411, 3412, 3413, 3414, 3415, 3416, 3417, 3418, 3419, 3420, 
3421, 3422, 3423, 3424, 3425, 3426, 3427, 3428, 3429, 3430, 
3431, 3432, 3433, 3434, 3435, 3436, 3437, 3438, 3439, 3440, 
3441, 3442, 3443, 3444, 3445, 3446, 3447, 3448, 3449, 3450, 
3451, 3452, 3453, 3454, 3455, 3456, 3457, 3458, 3459, 3460, 
3461, 3462, 3463, 3464, 3465, 3466, 3467, 3468, 3469, 3470, 
3471, 3472, 3473, 3474, 3475, 3476, 3477, 3478, 3479, 3480, 
3481, 3482, 3483, 3484, 3485, 3486, 3487, 3488, 3489, 3490, 
3491, 3492, 3493, 3494, 3495, 3496, 3497, 3498, 3499, 3500, 
3501, 3502, 3503, 3504, 3505, 3506, 3507, 3508, 3509, 3510, 
3511, 3512, 3513, 3514, 3515, 3516, 3517, 3518, 3519, 3520, 
3521, 3522, 3523, 3524, 3525, 3526, 3527, 3528, 3529, 3530, 
3531, 3532, 3533, 3534, 3535, 3536, 3537, 3538, 3539, 3540, 
3541, 3542, 3543, 3544, 3545, 3546, 3547, 3548, 3549, 3550, 
3551, 3552, 3553, 3554, 3555, 3556, 3557, 3558, 3559, 3560, 
3561, 3562, 3563, 3564, 3565, 3566, 3567, 3568, 3569, 3570, 
3571, 3572, 3573, 3574, 3575, 3576, 3577, 3578, 3579, 3580, 
3581, 3582, 3583, 3584, 3585, 3586, 3587, 3588, 3589, 3590, 
3591, 3592, 3593, 3594, 3595, 3596, 3597, 3598, 3599, 3600, 
3601, 3602, 3603, 3604, 3605, 3606, 3607, 3608, 3609, 3610, 
3611, 3612, 3613, 3614, 3615, 3616, 3617, 3618, 3619, 3620, 
3621, 3622, 3623, 3624, 3625, 3626, 3627, 3628, 3629, 3630, 
3631, 3632, 3633, 3634, 3635, 3636, 3637, 3638, 3639, 3640, 
3641, 3642, 3643, 3644, 3645, 3646, 3647, 3648, 3649, 3650, 
3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 3659, 3660, 
3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 3669, 3670, 
3671, 3672, 3673, 3674, 3675, 3676, 3677, 3678, 3679, 3680, 
3681, 3682, 3683, 3684, 3685, 3686, 3687, 3688, 3689, 3690, 
3691, 3692, 3693, 3694, 3695, 3696, 3697, 3698, 3699, 3700, 
3701, 3702, 3703, 3704, 3705, 3706, 3707, 3708, 3709, 3710, 
3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 3719, 3720, 
3721, 3722, 3723, 3724, 3725, 3726, 3727, 3728, 3729, 3730, 
3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 3739, 3740, 
3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 3749, 3750, 
3751, 3752, 3753, 3754, 3755, 3756, 3757, 3758, 3759, 3760, 
3761, 3762, 3763, 3764, 3765, 3766, 3767, 3768, 3769, 3770, 
3771, 3772, 3773, 3774, 3775, 3776, 3777, 3778, 3779, 3780, 
3781, 3782, 3783, 3784, 3785, 3786, 3787, 3788, 3789, 3790, 
3791, 3792, 3793, 3794, 3795, 3796, 3797, 3798, 3799, 3800, 
3801, 3802, 3803, 3804, 3805, 3806, 3807, 3808, 3809, 3810, 
3811, 3812, 3813, 3814, 3815, 3816, 3817, 3818, 3819, 3820, 
3821, 3822, 3823, 3824, 3825, 3826, 3827, 3828, 3829, 3830, 
3831, 3832, 3833, 3834, 3835, 3836, 3837, 3838, 3839, 3840, 
3841, 3842, 3843, 3844, 3845, 3846, 3847, 3848, 3849, 3850, 
3851, 3852, 3853, 3854, 3855, 3856, 3857, 3858, 3859, 3860, 
3861, 3862, 3863, 3864, 3865, 3866, 3867, 3868, 3869, 3870, 
3871, 3872, 3873, 3874, 3875, 3876, 3877, 3878, 3879, 3880, 
3881, 3882, 3883, 3884, 3885, 3886, 3887, 3888, 3889, 3890, 
3891, 3892, 3893, 3894, 3895, 3896, 3897, 3898, 3899, 3900, 
3901, 3902, 3903, 3904, 3905, 3906, 3907, 3908, 3909, 3910, 
3911, 3912, 3913, 3914, 3915, 3916, 3917, 3918, 3919, 3920, 
3921, 3922, 3923, 3924, 3925, 3926, 3927, 3928, 3929, 3930, 
3931, 3932, 3933, 3934, 3935, 3936, 3937, 3938, 3939, 3940, 
3941, 3942, 3943, 3944, 3945, 3946, 3947, 3948, 3949, 3950, 
3951, 3952, 3953, 3954, 3955, 3956, 3957, 3958, 3959, 3960, 
3961, 3962, 3963, 3964, 3965, 3966, 3967, 3968, 3969, 3970, 
3971, 3972, 3973, 3974, 3975, 3976, 3977, 3978, 3979, 3980, 
3981, 3982, 3983, 3984, 3985, 3986, 3987, 3988, 3989, 3990, 
3991, 3992, 3993, 3994, 3995, 3996, 3997, 3998, 3999, 4000, 
4001, 4002, 4003, 4004, 4005, 4006, 4007, 4008, 4009, 4010, 
4011, 4012, 4013, 4014, 4015, 4016, 4017, 4018, 4019, 4020, 
4021, 4022, 4023, 4024, 4025, 4026, 4027, 4028, 4029, 4030, 
4031, 4032, 4033, 4034, 4035, 4036, 4037, 4038, 4039, 4040, 
4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 
4051, 4052, 4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 
4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068, 4069, 4070, 
4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 4080, 
4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 4090, 
4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 4100, 
4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 4110, 
4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 4120, 
4121, 4122, 4123, 4124, 4125, 4126, 4127, 4128, 4129, 4130, 
4131, 4132, 4133, 4134, 4135, 4136, 4137, 4138, 4139, 4140, 
4141, 4142, 4143, 4144, 4145, 4146, 4147, 4148, 4149, 4150, 
4151, 4152, 4153, 4154, 4155, 4156, 4157, 4158, 4159, 4160, 
4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 4169, 4170, 
4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 4179, 4180, 
4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 4189, 4190, 
4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 4199, 4200, 
4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 4209, 4210, 
4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 4219, 4220, 
4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 4229, 4230, 
4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 4239, 4240, 
4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 4249, 4250, 
4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 4259, 4260, 
4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 4269, 4270, 
4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 4279, 4280, 
4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 4289, 4290, 
4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 4299, 4300, 
4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 4309, 4310, 
4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 4319, 4320, 
4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 4329, 4330, 
4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 4339, 4340, 
4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 4349, 4350, 
4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 4359, 4360, 
4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 4369, 4370, 
4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 4379, 4380, 
4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 4389, 4390, 
4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 4399, 4400, 
4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 4409, 4410, 
4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 4420, 
4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 4430, 
4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 4440, 
4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 4450, 
4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 4460, 
4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 4470, 
4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 4480, 
4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 4490, 
4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 4500, 
4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 4510, 
4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 4520, 
4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 4530, 
4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 4539, 4540, 
4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 4549, 4550, 
4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 4559, 4560, 
4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 4569, 4570, 
4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 4579, 4580, 
4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 4589, 4590, 
4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 4599, 4600, 
4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 4609, 4610, 
4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 4619, 4620, 
4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 4629, 4630, 
4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 4639, 4640, 
4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 4649, 4650, 
4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 4659, 4660, 
4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 4669, 4670, 
4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 4679, 4680, 
4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 4689, 4690, 
4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 4699, 4700, 
4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 4709, 4710, 
4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 4719, 4720, 
4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 4729, 4730, 
4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 4739, 4740, 
4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 4749, 4750, 
4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 4759, 4760, 
4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 4769, 4770, 
4771, 4772, 4773, 4774, 4775, 4776, 4777, 4778, 4779, 4780, 
4781, 4782, 4783, 4784, 4785, 
*ELSET,ELSET=SemiconductorP+
5701, 5702, 5703, 5704, 5705, 5706, 5707, 5708, 5709, 5710, 
5711, 5712, 5713, 5714, 5715, 5716, 5717, 5718, 5719, 5720, 
5721, 5722, 5723, 5724, 5725, 5726, 5727, 5728, 5729, 5730, 
5731, 5732, 5733, 5734, 5735, 5736, 5737, 5738, 5739, 5740, 
5741, 5742, 5743, 5744, 5745, 5746, 5747, 5748, 5749, 5750, 
5751, 5752, 5753, 5754, 5755, 5756, 5757, 5758, 5759, 5760, 
5761, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 
6031, 6032, 6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 
6041, 6042, 6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 
6051, 6052, 6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 
6061, 6062, 6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 
6071, 6072, 6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 
6081, 6082, 6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 
6091, 6092, 6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 
6101, 6102, 6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 
6111, 6112, 6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 
6121, 6122, 6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 
6131, 6132, 6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 
6141, 6142, 6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 
6151, 6152, 6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 
6161, 6162, 6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 
6171, 6172, 6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 
6181, 6182, 6183, 6184, 6185, 6186, 6187, 6188, 6189, 6190, 
6191, 6192, 6193, 6194, 6195, 6196, 6197, 6198, 6199, 6200, 
6201, 6202, 6203, 6204, 6205, 6206, 6207, 6208, 6209, 6210, 
6211, 6212, 6213, 6214, 6215, 6216, 6217, 6218, 6219, 6220, 
6221, 6222, 6223, 6224, 6225, 6226, 6227, 6228, 6229, 6230, 
6231, 6232, 6233, 6234, 6235, 6236, 6237, 6238, 6239, 6240, 
6241, 6242, 6243, 6244, 6245, 6246, 6247, 6248, 6249, 6250, 
6251, 6252, 6253, 6254, 6255, 6256, 6257, 6258, 6259, 6260, 
6261, 6262, 6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 
6271, 6272, 6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 
6281, 6282, 6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 
6291, 6292, 6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 
6301, 6302, 6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 
6311, 6312, 6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 
6321, 6322, 6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 
6331, 6332, 6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 
6341, 6342, 6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 
6351, 6352, 6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 
6361, 6362, 6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 
6371, 6372, 6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 
6381, 6382, 6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 
6391, 6392, 6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 
6401, 6402, 6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 
6411, 6412, 6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 
6421, 6422, 6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 
6431, 6432, 6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 
6441, 6442, 6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 
6451, 6452, 6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 
6461, 6462, 6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 
6471, 6472, 6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 
6481, 6482, 6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 
6491, 6492, 6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 
6501, 6502, 6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 
6511, 6512, 6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 
6521, 6522, 6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 
6531, 6532, 6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 
6541, 6542, 6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 
6551, 6552, 6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 
6561, 6562, 6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 
6571, 6572, 6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 
6581, 6582, 6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 
6591, 6592, 6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 
6601, 6602, 6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 
6611, 6612, 6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 
6621, 6622, 6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 
6631, 6632, 6633, 6634, 6635, 6636, 6637, 6638, 6639, 6640, 
6641, 6642, 6643, 6644, 6645, 6646, 6647, 6648, 6649, 6650, 
6651, 6652, 6653, 6654, 6655, 6656, 6657, 6658, 6659, 6660, 
6661, 6662, 6663, 6664, 6665, 6666, 6667, 6668, 6669, 6670, 
6671, 6672, 6673, 6674, 6675, 6676, 6677, 6678, 6679, 6680, 
6681, 6682, 6683, 6684, 6685, 6686, 6687, 6688, 6689, 6690, 
6691, 6692, 6693, 6694, 6695, 6696, 6697, 6698, 6699, 6700, 
6701, 6702, 6703, 6704, 6705, 6706, 6707, 6708, 6709, 6710, 
6711, 6712, 6713, 6714, 6715, 6716, 6717, 6718, 6719, 6720, 
6721, 6722, 6723, 6724, 6725, 6726, 6727, 6728, 6729, 6730, 
6731, 6732, 6733, 6734, 6735, 6736, 6737, 6738, 6739, 6740, 
6741, 6742, 6743, 6744, 6745, 6746, 6747, 6748, 6749, 6750, 
6751, 6752, 6753, 6754, 6755, 6756, 6757, 6758, 6759, 6760, 
6761, 6762, 6763, 6764, 6765, 6766, 6767, 6768, 6769, 6770, 
6771, 6772, 6773, 6774, 6775, 6776, 6777, 6778, 6779, 6780, 
6781, 6782, 6783, 6784, 6785, 6786, 6787, 6788, 6789, 6790, 
6791, 6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 
6801, 6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 
6811, 6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 
6821, 6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 
6831, 6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 
6841, 6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 
6851, 6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 
6861, 6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 
6871, 6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 
6881, 6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 
6891, 6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 
6901, 6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 
6911, 6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 
6921, 6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 
6931, 6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 
6941, 6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 
6951, 6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 
6961, 6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 
6971, 6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 
6981, 6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 
6991, 6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 
7001, 7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 
7011, 7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 
7021, 7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 
7031, 7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 
7041, 7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 
7051, 7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 
