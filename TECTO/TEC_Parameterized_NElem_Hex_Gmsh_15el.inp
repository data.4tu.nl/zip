826, 820, 4719, 4733, 821
827, 4719, 4720, 4734, 4733
828, 4720, 4721, 4735, 4734
829, 4721, 4722, 4736, 4735
830, 4722, 4723, 4737, 4736
831, 4723, 4724, 4738, 4737
832, 4724, 4725, 4739, 4738
833, 4725, 4726, 4740, 4739
834, 4726, 4727, 4741, 4740
835, 4727, 4728, 4742, 4741
836, 4728, 4729, 4743, 4742
837, 4729, 4730, 4744, 4743
838, 4730, 4731, 4745, 4744
839, 4731, 4732, 4746, 4745
840, 4732, 834, 835, 4746
841, 821, 4733, 4747, 822
842, 4733, 4734, 4748, 4747
843, 4734, 4735, 4749, 4748
844, 4735, 4736, 4750, 4749
845, 4736, 4737, 4751, 4750
846, 4737, 4738, 4752, 4751
847, 4738, 4739, 4753, 4752
848, 4739, 4740, 4754, 4753
849, 4740, 4741, 4755, 4754
850, 4741, 4742, 4756, 4755
851, 4742, 4743, 4757, 4756
852, 4743, 4744, 4758, 4757
853, 4744, 4745, 4759, 4758
854, 4745, 4746, 4760, 4759
855, 4746, 835, 836, 4760
856, 822, 4747, 4761, 823
857, 4747, 4748, 4762, 4761
858, 4748, 4749, 4763, 4762
859, 4749, 4750, 4764, 4763
860, 4750, 4751, 4765, 4764
861, 4751, 4752, 4766, 4765
862, 4752, 4753, 4767, 4766
863, 4753, 4754, 4768, 4767
864, 4754, 4755, 4769, 4768
865, 4755, 4756, 4770, 4769
866, 4756, 4757, 4771, 4770
867, 4757, 4758, 4772, 4771
868, 4758, 4759, 4773, 4772
869, 4759, 4760, 4774, 4773
870, 4760, 836, 837, 4774
871, 823, 4761, 4775, 824
872, 4761, 4762, 4776, 4775
873, 4762, 4763, 4777, 4776
874, 4763, 4764, 4778, 4777
875, 4764, 4765, 4779, 4778
876, 4765, 4766, 4780, 4779
877, 4766, 4767, 4781, 4780
878, 4767, 4768, 4782, 4781
879, 4768, 4769, 4783, 4782
880, 4769, 4770, 4784, 4783
881, 4770, 4771, 4785, 4784
882, 4771, 4772, 4786, 4785
883, 4772, 4773, 4787, 4786
884, 4773, 4774, 4788, 4787
885, 4774, 837, 838, 4788
886, 824, 4775, 4789, 825
887, 4775, 4776, 4790, 4789
888, 4776, 4777, 4791, 4790
889, 4777, 4778, 4792, 4791
890, 4778, 4779, 4793, 4792
891, 4779, 4780, 4794, 4793
892, 4780, 4781, 4795, 4794
893, 4781, 4782, 4796, 4795
894, 4782, 4783, 4797, 4796
895, 4783, 4784, 4798, 4797
896, 4784, 4785, 4799, 4798
897, 4785, 4786, 4800, 4799
898, 4786, 4787, 4801, 4800
899, 4787, 4788, 4802, 4801
900, 4788, 838, 839, 4802
901, 825, 4789, 4803, 826
902, 4789, 4790, 4804, 4803
903, 4790, 4791, 4805, 4804
904, 4791, 4792, 4806, 4805
905, 4792, 4793, 4807, 4806
906, 4793, 4794, 4808, 4807
907, 4794, 4795, 4809, 4808
908, 4795, 4796, 4810, 4809
909, 4796, 4797, 4811, 4810
910, 4797, 4798, 4812, 4811
911, 4798, 4799, 4813, 4812
912, 4799, 4800, 4814, 4813
913, 4800, 4801, 4815, 4814
914, 4801, 4802, 4816, 4815
915, 4802, 839, 840, 4816
916, 826, 4803, 785, 45
917, 4803, 4804, 786, 785
918, 4804, 4805, 787, 786
919, 4805, 4806, 788, 787
920, 4806, 4807, 789, 788
921, 4807, 4808, 790, 789
922, 4808, 4809, 791, 790
923, 4809, 4810, 792, 791
924, 4810, 4811, 793, 792
925, 4811, 4812, 794, 793
926, 4812, 4813, 795, 794
927, 4813, 4814, 796, 795
928, 4814, 4815, 797, 796
929, 4815, 4816, 798, 797
930, 4816, 840, 46, 798
*ELEMENT, type=CPS4, ELSET=Surface57
14642, 42, 46, 50, 49
*ELEMENT, type=CPS4, ELSET=Surface58
14643, 44, 51, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
14644, 44, 771, 841, 51
14645, 771, 772, 842, 841
14646, 772, 773, 843, 842
14647, 773, 774, 844, 843
14648, 774, 775, 845, 844
14649, 775, 776, 846, 845
14650, 776, 777, 847, 846
14651, 777, 778, 848, 847
14652, 778, 779, 849, 848
14653, 779, 780, 850, 849
14654, 780, 781, 851, 850
14655, 781, 782, 852, 851
14656, 782, 783, 853, 852
14657, 783, 784, 854, 853
14658, 784, 42, 49, 854
*ELEMENT, type=CPS4, ELSET=Surface60
14659, 48, 52, 855, 827
14660, 827, 855, 856, 828
14661, 828, 856, 857, 829
14662, 829, 857, 858, 830
14663, 830, 858, 859, 831
14664, 831, 859, 860, 832
14665, 832, 860, 861, 833
14666, 833, 861, 862, 834
14667, 834, 862, 863, 835
14668, 835, 863, 864, 836
14669, 836, 864, 865, 837
14670, 837, 865, 866, 838
14671, 838, 866, 867, 839
14672, 839, 867, 868, 840
14673, 840, 868, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
931, 51, 841, 855, 52
932, 841, 842, 856, 855
933, 842, 843, 857, 856
934, 843, 844, 858, 857
935, 844, 845, 859, 858
936, 845, 846, 860, 859
937, 846, 847, 861, 860
938, 847, 848, 862, 861
939, 848, 849, 863, 862
940, 849, 850, 864, 863
941, 850, 851, 865, 864
942, 851, 852, 866, 865
943, 852, 853, 867, 866
944, 853, 854, 868, 867
945, 854, 49, 50, 868
*ELEMENT, type=CPS4, ELSET=Surface62
14674, 2, 57, 869, 54
14675, 57, 58, 870, 869
14676, 58, 59, 871, 870
14677, 59, 60, 872, 871
14678, 60, 61, 873, 872
14679, 61, 62, 874, 873
14680, 62, 63, 875, 874
14681, 63, 64, 876, 875
14682, 64, 65, 877, 876
14683, 65, 66, 878, 877
14684, 66, 67, 879, 878
14685, 67, 68, 880, 879
14686, 68, 69, 881, 880
14687, 69, 70, 882, 881
14688, 70, 1, 53, 882
*ELEMENT, type=CPS4, ELSET=Surface63
14689, 1, 3, 55, 53
*ELEMENT, type=CPS4, ELSET=Surface64
14690, 4, 56, 883, 71
14691, 71, 883, 884, 72
14692, 72, 884, 885, 73
14693, 73, 885, 886, 74
14694, 74, 886, 887, 75
14695, 75, 887, 888, 76
14696, 76, 888, 889, 77
14697, 77, 889, 890, 78
14698, 78, 890, 891, 79
14699, 79, 891, 892, 80
14700, 80, 892, 893, 81
14701, 81, 893, 894, 82
14702, 82, 894, 895, 83
14703, 83, 895, 896, 84
14704, 84, 896, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
14705, 2, 54, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
946, 54, 869, 883, 56
947, 869, 870, 884, 883
948, 870, 871, 885, 884
949, 871, 872, 886, 885
950, 872, 873, 887, 886
951, 873, 874, 888, 887
952, 874, 875, 889, 888
953, 875, 876, 890, 889
954, 876, 877, 891, 890
955, 877, 878, 892, 891
956, 878, 879, 893, 892
957, 879, 880, 894, 893
958, 880, 881, 895, 894
959, 881, 882, 896, 895
960, 882, 53, 55, 896
*ELEMENT, type=C3D8, ELSET=Volume1
961, 71, 57, 2, 4, 1093, 897, 113, 141
962, 1093, 897, 113, 141, 1107, 911, 114, 142
963, 1107, 911, 114, 142, 1121, 925, 115, 143
964, 1121, 925, 115, 143, 1135, 939, 116, 144
965, 1135, 939, 116, 144, 1149, 953, 117, 145
966, 1149, 953, 117, 145, 1163, 967, 118, 146
967, 1163, 967, 118, 146, 1177, 981, 119, 147
968, 1177, 981, 119, 147, 1191, 995, 120, 148
969, 1191, 995, 120, 148, 1205, 1009, 121, 149
970, 1205, 1009, 121, 149, 1219, 1023, 122, 150
971, 1219, 1023, 122, 150, 1233, 1037, 123, 151
972, 1233, 1037, 123, 151, 1247, 1051, 124, 152
973, 1247, 1051, 124, 152, 1261, 1065, 125, 153
974, 1261, 1065, 125, 153, 1275, 1079, 126, 154
975, 1275, 1079, 126, 154, 99, 85, 6, 8
976, 72, 58, 57, 71, 1094, 898, 897, 1093
977, 1094, 898, 897, 1093, 1108, 912, 911, 1107
978, 1108, 912, 911, 1107, 1122, 926, 925, 1121
979, 1122, 926, 925, 1121, 1136, 940, 939, 1135
980, 1136, 940, 939, 1135, 1150, 954, 953, 1149
981, 1150, 954, 953, 1149, 1164, 968, 967, 1163
982, 1164, 968, 967, 1163, 1178, 982, 981, 1177
983, 1178, 982, 981, 1177, 1192, 996, 995, 1191
984, 1192, 996, 995, 1191, 1206, 1010, 1009, 1205
985, 1206, 1010, 1009, 1205, 1220, 1024, 1023, 1219
986, 1220, 1024, 1023, 1219, 1234, 1038, 1037, 1233
987, 1234, 1038, 1037, 1233, 1248, 1052, 1051, 1247
988, 1248, 1052, 1051, 1247, 1262, 1066, 1065, 1261
989, 1262, 1066, 1065, 1261, 1276, 1080, 1079, 1275
990, 1276, 1080, 1079, 1275, 100, 86, 85, 99
991, 73, 59, 58, 72, 1095, 899, 898, 1094
992, 1095, 899, 898, 1094, 1109, 913, 912, 1108
993, 1109, 913, 912, 1108, 1123, 927, 926, 1122
994, 1123, 927, 926, 1122, 1137, 941, 940, 1136
995, 1137, 941, 940, 1136, 1151, 955, 954, 1150
996, 1151, 955, 954, 1150, 1165, 969, 968, 1164
997, 1165, 969, 968, 1164, 1179, 983, 982, 1178
998, 1179, 983, 982, 1178, 1193, 997, 996, 1192
999, 1193, 997, 996, 1192, 1207, 1011, 1010, 1206
1000, 1207, 1011, 1010, 1206, 1221, 1025, 1024, 1220
1001, 1221, 1025, 1024, 1220, 1235, 1039, 1038, 1234
1002, 1235, 1039, 1038, 1234, 1249, 1053, 1052, 1248
1003, 1249, 1053, 1052, 1248, 1263, 1067, 1066, 1262
1004, 1263, 1067, 1066, 1262, 1277, 1081, 1080, 1276
1005, 1277, 1081, 1080, 1276, 101, 87, 86, 100
1006, 74, 60, 59, 73, 1096, 900, 899, 1095
1007, 1096, 900, 899, 1095, 1110, 914, 913, 1109
1008, 1110, 914, 913, 1109, 1124, 928, 927, 1123
1009, 1124, 928, 927, 1123, 1138, 942, 941, 1137
1010, 1138, 942, 941, 1137, 1152, 956, 955, 1151
1011, 1152, 956, 955, 1151, 1166, 970, 969, 1165
1012, 1166, 970, 969, 1165, 1180, 984, 983, 1179
1013, 1180, 984, 983, 1179, 1194, 998, 997, 1193
1014, 1194, 998, 997, 1193, 1208, 1012, 1011, 1207
1015, 1208, 1012, 1011, 1207, 1222, 1026, 1025, 1221
1016, 1222, 1026, 1025, 1221, 1236, 1040, 1039, 1235
1017, 1236, 1040, 1039, 1235, 1250, 1054, 1053, 1249
1018, 1250, 1054, 1053, 1249, 1264, 1068, 1067, 1263
1019, 1264, 1068, 1067, 1263, 1278, 1082, 1081, 1277
1020, 1278, 1082, 1081, 1277, 102, 88, 87, 101
1021, 75, 61, 60, 74, 1097, 901, 900, 1096
1022, 1097, 901, 900, 1096, 1111, 915, 914, 1110
1023, 1111, 915, 914, 1110, 1125, 929, 928, 1124
1024, 1125, 929, 928, 1124, 1139, 943, 942, 1138
1025, 1139, 943, 942, 1138, 1153, 957, 956, 1152
1026, 1153, 957, 956, 1152, 1167, 971, 970, 1166
1027, 1167, 971, 970, 1166, 1181, 985, 984, 1180
1028, 1181, 985, 984, 1180, 1195, 999, 998, 1194
1029, 1195, 999, 998, 1194, 1209, 1013, 1012, 1208
1030, 1209, 1013, 1012, 1208, 1223, 1027, 1026, 1222
1031, 1223, 1027, 1026, 1222, 1237, 1041, 1040, 1236
1032, 1237, 1041, 1040, 1236, 1251, 1055, 1054, 1250
1033, 1251, 1055, 1054, 1250, 1265, 1069, 1068, 1264
1034, 1265, 1069, 1068, 1264, 1279, 1083, 1082, 1278
1035, 1279, 1083, 1082, 1278, 103, 89, 88, 102
1036, 76, 62, 61, 75, 1098, 902, 901, 1097
1037, 1098, 902, 901, 1097, 1112, 916, 915, 1111
1038, 1112, 916, 915, 1111, 1126, 930, 929, 1125
1039, 1126, 930, 929, 1125, 1140, 944, 943, 1139
1040, 1140, 944, 943, 1139, 1154, 958, 957, 1153
1041, 1154, 958, 957, 1153, 1168, 972, 971, 1167
1042, 1168, 972, 971, 1167, 1182, 986, 985, 1181
1043, 1182, 986, 985, 1181, 1196, 1000, 999, 1195
1044, 1196, 1000, 999, 1195, 1210, 1014, 1013, 1209
1045, 1210, 1014, 1013, 1209, 1224, 1028, 1027, 1223
1046, 1224, 1028, 1027, 1223, 1238, 1042, 1041, 1237
1047, 1238, 1042, 1041, 1237, 1252, 1056, 1055, 1251
1048, 1252, 1056, 1055, 1251, 1266, 1070, 1069, 1265
1049, 1266, 1070, 1069, 1265, 1280, 1084, 1083, 1279
1050, 1280, 1084, 1083, 1279, 104, 90, 89, 103
1051, 77, 63, 62, 76, 1099, 903, 902, 1098
1052, 1099, 903, 902, 1098, 1113, 917, 916, 1112
1053, 1113, 917, 916, 1112, 1127, 931, 930, 1126
1054, 1127, 931, 930, 1126, 1141, 945, 944, 1140
1055, 1141, 945, 944, 1140, 1155, 959, 958, 1154
1056, 1155, 959, 958, 1154, 1169, 973, 972, 1168
1057, 1169, 973, 972, 1168, 1183, 987, 986, 1182
1058, 1183, 987, 986, 1182, 1197, 1001, 1000, 1196
1059, 1197, 1001, 1000, 1196, 1211, 1015, 1014, 1210
1060, 1211, 1015, 1014, 1210, 1225, 1029, 1028, 1224
1061, 1225, 1029, 1028, 1224, 1239, 1043, 1042, 1238
1062, 1239, 1043, 1042, 1238, 1253, 1057, 1056, 1252
1063, 1253, 1057, 1056, 1252, 1267, 1071, 1070, 1266
1064, 1267, 1071, 1070, 1266, 1281, 1085, 1084, 1280
1065, 1281, 1085, 1084, 1280, 105, 91, 90, 104
1066, 78, 64, 63, 77, 1100, 904, 903, 1099
1067, 1100, 904, 903, 1099, 1114, 918, 917, 1113
1068, 1114, 918, 917, 1113, 1128, 932, 931, 1127
1069, 1128, 932, 931, 1127, 1142, 946, 945, 1141
1070, 1142, 946, 945, 1141, 1156, 960, 959, 1155
1071, 1156, 960, 959, 1155, 1170, 974, 973, 1169
1072, 1170, 974, 973, 1169, 1184, 988, 987, 1183
1073, 1184, 988, 987, 1183, 1198, 1002, 1001, 1197
1074, 1198, 1002, 1001, 1197, 1212, 1016, 1015, 1211
1075, 1212, 1016, 1015, 1211, 1226, 1030, 1029, 1225
1076, 1226, 1030, 1029, 1225, 1240, 1044, 1043, 1239
1077, 1240, 1044, 1043, 1239, 1254, 1058, 1057, 1253
1078, 1254, 1058, 1057, 1253, 1268, 1072, 1071, 1267
1079, 1268, 1072, 1071, 1267, 1282, 1086, 1085, 1281
1080, 1282, 1086, 1085, 1281, 106, 92, 91, 105
1081, 79, 65, 64, 78, 1101, 905, 904, 1100
1082, 1101, 905, 904, 1100, 1115, 919, 918, 1114
1083, 1115, 919, 918, 1114, 1129, 933, 932, 1128
1084, 1129, 933, 932, 1128, 1143, 947, 946, 1142
1085, 1143, 947, 946, 1142, 1157, 961, 960, 1156
1086, 1157, 961, 960, 1156, 1171, 975, 974, 1170
1087, 1171, 975, 974, 1170, 1185, 989, 988, 1184
1088, 1185, 989, 988, 1184, 1199, 1003, 1002, 1198
1089, 1199, 1003, 1002, 1198, 1213, 1017, 1016, 1212
1090, 1213, 1017, 1016, 1212, 1227, 1031, 1030, 1226
1091, 1227, 1031, 1030, 1226, 1241, 1045, 1044, 1240
1092, 1241, 1045, 1044, 1240, 1255, 1059, 1058, 1254
1093, 1255, 1059, 1058, 1254, 1269, 1073, 1072, 1268
1094, 1269, 1073, 1072, 1268, 1283, 1087, 1086, 1282
1095, 1283, 1087, 1086, 1282, 107, 93, 92, 106
1096, 80, 66, 65, 79, 1102, 906, 905, 1101
1097, 1102, 906, 905, 1101, 1116, 920, 919, 1115
1098, 1116, 920, 919, 1115, 1130, 934, 933, 1129
1099, 1130, 934, 933, 1129, 1144, 948, 947, 1143
1100, 1144, 948, 947, 1143, 1158, 962, 961, 1157
1101, 1158, 962, 961, 1157, 1172, 976, 975, 1171
1102, 1172, 976, 975, 1171, 1186, 990, 989, 1185
1103, 1186, 990, 989, 1185, 1200, 1004, 1003, 1199
1104, 1200, 1004, 1003, 1199, 1214, 1018, 1017, 1213
1105, 1214, 1018, 1017, 1213, 1228, 1032, 1031, 1227
1106, 1228, 1032, 1031, 1227, 1242, 1046, 1045, 1241
1107, 1242, 1046, 1045, 1241, 1256, 1060, 1059, 1255
1108, 1256, 1060, 1059, 1255, 1270, 1074, 1073, 1269
1109, 1270, 1074, 1073, 1269, 1284, 1088, 1087, 1283
1110, 1284, 1088, 1087, 1283, 108, 94, 93, 107
1111, 81, 67, 66, 80, 1103, 907, 906, 1102
1112, 1103, 907, 906, 1102, 1117, 921, 920, 1116
1113, 1117, 921, 920, 1116, 1131, 935, 934, 1130
1114, 1131, 935, 934, 1130, 1145, 949, 948, 1144
1115, 1145, 949, 948, 1144, 1159, 963, 962, 1158
1116, 1159, 963, 962, 1158, 1173, 977, 976, 1172
1117, 1173, 977, 976, 1172, 1187, 991, 990, 1186
1118, 1187, 991, 990, 1186, 1201, 1005, 1004, 1200
1119, 1201, 1005, 1004, 1200, 1215, 1019, 1018, 1214
1120, 1215, 1019, 1018, 1214, 1229, 1033, 1032, 1228
1121, 1229, 1033, 1032, 1228, 1243, 1047, 1046, 1242
1122, 1243, 1047, 1046, 1242, 1257, 1061, 1060, 1256
1123, 1257, 1061, 1060, 1256, 1271, 1075, 1074, 1270
1124, 1271, 1075, 1074, 1270, 1285, 1089, 1088, 1284
1125, 1285, 1089, 1088, 1284, 109, 95, 94, 108
1126, 82, 68, 67, 81, 1104, 908, 907, 1103
1127, 1104, 908, 907, 1103, 1118, 922, 921, 1117
1128, 1118, 922, 921, 1117, 1132, 936, 935, 1131
1129, 1132, 936, 935, 1131, 1146, 950, 949, 1145
1130, 1146, 950, 949, 1145, 1160, 964, 963, 1159
1131, 1160, 964, 963, 1159, 1174, 978, 977, 1173
1132, 1174, 978, 977, 1173, 1188, 992, 991, 1187
1133, 1188, 992, 991, 1187, 1202, 1006, 1005, 1201
1134, 1202, 1006, 1005, 1201, 1216, 1020, 1019, 1215
1135, 1216, 1020, 1019, 1215, 1230, 1034, 1033, 1229
1136, 1230, 1034, 1033, 1229, 1244, 1048, 1047, 1243
1137, 1244, 1048, 1047, 1243, 1258, 1062, 1061, 1257
1138, 1258, 1062, 1061, 1257, 1272, 1076, 1075, 1271
1139, 1272, 1076, 1075, 1271, 1286, 1090, 1089, 1285
1140, 1286, 1090, 1089, 1285, 110, 96, 95, 109
1141, 83, 69, 68, 82, 1105, 909, 908, 1104
1142, 1105, 909, 908, 1104, 1119, 923, 922, 1118
1143, 1119, 923, 922, 1118, 1133, 937, 936, 1132
1144, 1133, 937, 936, 1132, 1147, 951, 950, 1146
1145, 1147, 951, 950, 1146, 1161, 965, 964, 1160
1146, 1161, 965, 964, 1160, 1175, 979, 978, 1174
1147, 1175, 979, 978, 1174, 1189, 993, 992, 1188
1148, 1189, 993, 992, 1188, 1203, 1007, 1006, 1202
1149, 1203, 1007, 1006, 1202, 1217, 1021, 1020, 1216
1150, 1217, 1021, 1020, 1216, 1231, 1035, 1034, 1230
1151, 1231, 1035, 1034, 1230, 1245, 1049, 1048, 1244
1152, 1245, 1049, 1048, 1244, 1259, 1063, 1062, 1258
1153, 1259, 1063, 1062, 1258, 1273, 1077, 1076, 1272
1154, 1273, 1077, 1076, 1272, 1287, 1091, 1090, 1286
1155, 1287, 1091, 1090, 1286, 111, 97, 96, 110
1156, 84, 70, 69, 83, 1106, 910, 909, 1105
1157, 1106, 910, 909, 1105, 1120, 924, 923, 1119
1158, 1120, 924, 923, 1119, 1134, 938, 937, 1133
1159, 1134, 938, 937, 1133, 1148, 952, 951, 1147
1160, 1148, 952, 951, 1147, 1162, 966, 965, 1161
1161, 1162, 966, 965, 1161, 1176, 980, 979, 1175
1162, 1176, 980, 979, 1175, 1190, 994, 993, 1189
1163, 1190, 994, 993, 1189, 1204, 1008, 1007, 1203
1164, 1204, 1008, 1007, 1203, 1218, 1022, 1021, 1217
1165, 1218, 1022, 1021, 1217, 1232, 1036, 1035, 1231
1166, 1232, 1036, 1035, 1231, 1246, 1050, 1049, 1245
1167, 1246, 1050, 1049, 1245, 1260, 1064, 1063, 1259
1168, 1260, 1064, 1063, 1259, 1274, 1078, 1077, 1273
1169, 1274, 1078, 1077, 1273, 1288, 1092, 1091, 1287
1170, 1288, 1092, 1091, 1287, 112, 98, 97, 111
1171, 3, 1, 70, 84, 155, 127, 910, 1106
1172, 155, 127, 910, 1106, 156, 128, 924, 1120
1173, 156, 128, 924, 1120, 157, 129, 938, 1134
1174, 157, 129, 938, 1134, 158, 130, 952, 1148
1175, 158, 130, 952, 1148, 159, 131, 966, 1162
1176, 159, 131, 966, 1162, 160, 132, 980, 1176
1177, 160, 132, 980, 1176, 161, 133, 994, 1190
1178, 161, 133, 994, 1190, 162, 134, 1008, 1204
1179, 162, 134, 1008, 1204, 163, 135, 1022, 1218
1180, 163, 135, 1022, 1218, 164, 136, 1036, 1232
1181, 164, 136, 1036, 1232, 165, 137, 1050, 1246
1182, 165, 137, 1050, 1246, 166, 138, 1064, 1260
1183, 166, 138, 1064, 1260, 167, 139, 1078, 1274
1184, 167, 139, 1078, 1274, 168, 140, 1092, 1288
1185, 168, 140, 1092, 1288, 7, 5, 98, 112
*ELEMENT, type=C3D8, ELSET=Volume2
1186, 4, 71, 1093, 141, 10, 211, 1289, 169
1187, 71, 72, 1094, 1093, 211, 212, 1290, 1289
1188, 72, 73, 1095, 1094, 212, 213, 1291, 1290
1189, 73, 74, 1096, 1095, 213, 214, 1292, 1291
1190, 74, 75, 1097, 1096, 214, 215, 1293, 1292
1191, 75, 76, 1098, 1097, 215, 216, 1294, 1293
1192, 76, 77, 1099, 1098, 216, 217, 1295, 1294
1193, 77, 78, 1100, 1099, 217, 218, 1296, 1295
1194, 78, 79, 1101, 1100, 218, 219, 1297, 1296
1195, 79, 80, 1102, 1101, 219, 220, 1298, 1297
1196, 80, 81, 1103, 1102, 220, 221, 1299, 1298
1197, 81, 82, 1104, 1103, 221, 222, 1300, 1299
1198, 82, 83, 1105, 1104, 222, 223, 1301, 1300
1199, 83, 84, 1106, 1105, 223, 224, 1302, 1301
1200, 84, 3, 155, 1106, 224, 12, 197, 1302
1201, 141, 1093, 1107, 142, 169, 1289, 1303, 170
1202, 1093, 1094, 1108, 1107, 1289, 1290, 1304, 1303
1203, 1094, 1095, 1109, 1108, 1290, 1291, 1305, 1304
1204, 1095, 1096, 1110, 1109, 1291, 1292, 1306, 1305
1205, 1096, 1097, 1111, 1110, 1292, 1293, 1307, 1306
1206, 1097, 1098, 1112, 1111, 1293, 1294, 1308, 1307
1207, 1098, 1099, 1113, 1112, 1294, 1295, 1309, 1308
1208, 1099, 1100, 1114, 1113, 1295, 1296, 1310, 1309
1209, 1100, 1101, 1115, 1114, 1296, 1297, 1311, 1310
1210, 1101, 1102, 1116, 1115, 1297, 1298, 1312, 1311
1211, 1102, 1103, 1117, 1116, 1298, 1299, 1313, 1312
1212, 1103, 1104, 1118, 1117, 1299, 1300, 1314, 1313
1213, 1104, 1105, 1119, 1118, 1300, 1301, 1315, 1314
1214, 1105, 1106, 1120, 1119, 1301, 1302, 1316, 1315
1215, 1106, 155, 156, 1120, 1302, 197, 198, 1316
1216, 142, 1107, 1121, 143, 170, 1303, 1317, 171
1217, 1107, 1108, 1122, 1121, 1303, 1304, 1318, 1317
1218, 1108, 1109, 1123, 1122, 1304, 1305, 1319, 1318
1219, 1109, 1110, 1124, 1123, 1305, 1306, 1320, 1319
1220, 1110, 1111, 1125, 1124, 1306, 1307, 1321, 1320
1221, 1111, 1112, 1126, 1125, 1307, 1308, 1322, 1321
1222, 1112, 1113, 1127, 1126, 1308, 1309, 1323, 1322
1223, 1113, 1114, 1128, 1127, 1309, 1310, 1324, 1323
1224, 1114, 1115, 1129, 1128, 1310, 1311, 1325, 1324
1225, 1115, 1116, 1130, 1129, 1311, 1312, 1326, 1325
1226, 1116, 1117, 1131, 1130, 1312, 1313, 1327, 1326
1227, 1117, 1118, 1132, 1131, 1313, 1314, 1328, 1327
1228, 1118, 1119, 1133, 1132, 1314, 1315, 1329, 1328
1229, 1119, 1120, 1134, 1133, 1315, 1316, 1330, 1329
1230, 1120, 156, 157, 1134, 1316, 198, 199, 1330
1231, 143, 1121, 1135, 144, 171, 1317, 1331, 172
1232, 1121, 1122, 1136, 1135, 1317, 1318, 1332, 1331
1233, 1122, 1123, 1137, 1136, 1318, 1319, 1333, 1332
1234, 1123, 1124, 1138, 1137, 1319, 1320, 1334, 1333
1235, 1124, 1125, 1139, 1138, 1320, 1321, 1335, 1334
1236, 1125, 1126, 1140, 1139, 1321, 1322, 1336, 1335
1237, 1126, 1127, 1141, 1140, 1322, 1323, 1337, 1336
1238, 1127, 1128, 1142, 1141, 1323, 1324, 1338, 1337
1239, 1128, 1129, 1143, 1142, 1324, 1325, 1339, 1338
1240, 1129, 1130, 1144, 1143, 1325, 1326, 1340, 1339
1241, 1130, 1131, 1145, 1144, 1326, 1327, 1341, 1340
1242, 1131, 1132, 1146, 1145, 1327, 1328, 1342, 1341
1243, 1132, 1133, 1147, 1146, 1328, 1329, 1343, 1342
1244, 1133, 1134, 1148, 1147, 1329, 1330, 1344, 1343
1245, 1134, 157, 158, 1148, 1330, 199, 200, 1344
1246, 144, 1135, 1149, 145, 172, 1331, 1345, 173
1247, 1135, 1136, 1150, 1149, 1331, 1332, 1346, 1345
1248, 1136, 1137, 1151, 1150, 1332, 1333, 1347, 1346
1249, 1137, 1138, 1152, 1151, 1333, 1334, 1348, 1347
1250, 1138, 1139, 1153, 1152, 1334, 1335, 1349, 1348
1251, 1139, 1140, 1154, 1153, 1335, 1336, 1350, 1349
1252, 1140, 1141, 1155, 1154, 1336, 1337, 1351, 1350
1253, 1141, 1142, 1156, 1155, 1337, 1338, 1352, 1351
1254, 1142, 1143, 1157, 1156, 1338, 1339, 1353, 1352
1255, 1143, 1144, 1158, 1157, 1339, 1340, 1354, 1353
1256, 1144, 1145, 1159, 1158, 1340, 1341, 1355, 1354
1257, 1145, 1146, 1160, 1159, 1341, 1342, 1356, 1355
1258, 1146, 1147, 1161, 1160, 1342, 1343, 1357, 1356
1259, 1147, 1148, 1162, 1161, 1343, 1344, 1358, 1357
1260, 1148, 158, 159, 1162, 1344, 200, 201, 1358
1261, 145, 1149, 1163, 146, 173, 1345, 1359, 174
1262, 1149, 1150, 1164, 1163, 1345, 1346, 1360, 1359
1263, 1150, 1151, 1165, 1164, 1346, 1347, 1361, 1360
1264, 1151, 1152, 1166, 1165, 1347, 1348, 1362, 1361
1265, 1152, 1153, 1167, 1166, 1348, 1349, 1363, 1362
1266, 1153, 1154, 1168, 1167, 1349, 1350, 1364, 1363
1267, 1154, 1155, 1169, 1168, 1350, 1351, 1365, 1364
1268, 1155, 1156, 1170, 1169, 1351, 1352, 1366, 1365
1269, 1156, 1157, 1171, 1170, 1352, 1353, 1367, 1366
1270, 1157, 1158, 1172, 1171, 1353, 1354, 1368, 1367
1271, 1158, 1159, 1173, 1172, 1354, 1355, 1369, 1368
1272, 1159, 1160, 1174, 1173, 1355, 1356, 1370, 1369
1273, 1160, 1161, 1175, 1174, 1356, 1357, 1371, 1370
1274, 1161, 1162, 1176, 1175, 1357, 1358, 1372, 1371
1275, 1162, 159, 160, 1176, 1358, 201, 202, 1372
1276, 146, 1163, 1177, 147, 174, 1359, 1373, 175
1277, 1163, 1164, 1178, 1177, 1359, 1360, 1374, 1373
1278, 1164, 1165, 1179, 1178, 1360, 1361, 1375, 1374
1279, 1165, 1166, 1180, 1179, 1361, 1362, 1376, 1375
1280, 1166, 1167, 1181, 1180, 1362, 1363, 1377, 1376
1281, 1167, 1168, 1182, 1181, 1363, 1364, 1378, 1377
1282, 1168, 1169, 1183, 1182, 1364, 1365, 1379, 1378
1283, 1169, 1170, 1184, 1183, 1365, 1366, 1380, 1379
1284, 1170, 1171, 1185, 1184, 1366, 1367, 1381, 1380
1285, 1171, 1172, 1186, 1185, 1367, 1368, 1382, 1381
1286, 1172, 1173, 1187, 1186, 1368, 1369, 1383, 1382
1287, 1173, 1174, 1188, 1187, 1369, 1370, 1384, 1383
1288, 1174, 1175, 1189, 1188, 1370, 1371, 1385, 1384
1289, 1175, 1176, 1190, 1189, 1371, 1372, 1386, 1385
1290, 1176, 160, 161, 1190, 1372, 202, 203, 1386
1291, 147, 1177, 1191, 148, 175, 1373, 1387, 176
1292, 1177, 1178, 1192, 1191, 1373, 1374, 1388, 1387
1293, 1178, 1179, 1193, 1192, 1374, 1375, 1389, 1388
1294, 1179, 1180, 1194, 1193, 1375, 1376, 1390, 1389
1295, 1180, 1181, 1195, 1194, 1376, 1377, 1391, 1390
1296, 1181, 1182, 1196, 1195, 1377, 1378, 1392, 1391
1297, 1182, 1183, 1197, 1196, 1378, 1379, 1393, 1392
1298, 1183, 1184, 1198, 1197, 1379, 1380, 1394, 1393
1299, 1184, 1185, 1199, 1198, 1380, 1381, 1395, 1394
1300, 1185, 1186, 1200, 1199, 1381, 1382, 1396, 1395
1301, 1186, 1187, 1201, 1200, 1382, 1383, 1397, 1396
1302, 1187, 1188, 1202, 1201, 1383, 1384, 1398, 1397
1303, 1188, 1189, 1203, 1202, 1384, 1385, 1399, 1398
1304, 1189, 1190, 1204, 1203, 1385, 1386, 1400, 1399
1305, 1190, 161, 162, 1204, 1386, 203, 204, 1400
1306, 148, 1191, 1205, 149, 176, 1387, 1401, 177
1307, 1191, 1192, 1206, 1205, 1387, 1388, 1402, 1401
1308, 1192, 1193, 1207, 1206, 1388, 1389, 1403, 1402
1309, 1193, 1194, 1208, 1207, 1389, 1390, 1404, 1403
1310, 1194, 1195, 1209, 1208, 1390, 1391, 1405, 1404
1311, 1195, 1196, 1210, 1209, 1391, 1392, 1406, 1405
1312, 1196, 1197, 1211, 1210, 1392, 1393, 1407, 1406
1313, 1197, 1198, 1212, 1211, 1393, 1394, 1408, 1407
1314, 1198, 1199, 1213, 1212, 1394, 1395, 1409, 1408
1315, 1199, 1200, 1214, 1213, 1395, 1396, 1410, 1409
1316, 1200, 1201, 1215, 1214, 1396, 1397, 1411, 1410
1317, 1201, 1202, 1216, 1215, 1397, 1398, 1412, 1411
1318, 1202, 1203, 1217, 1216, 1398, 1399, 1413, 1412
1319, 1203, 1204, 1218, 1217, 1399, 1400, 1414, 1413
1320, 1204, 162, 163, 1218, 1400, 204, 205, 1414
1321, 149, 1205, 1219, 150, 177, 1401, 1415, 178
1322, 1205, 1206, 1220, 1219, 1401, 1402, 1416, 1415
1323, 1206, 1207, 1221, 1220, 1402, 1403, 1417, 1416
1324, 1207, 1208, 1222, 1221, 1403, 1404, 1418, 1417
1325, 1208, 1209, 1223, 1222, 1404, 1405, 1419, 1418
1326, 1209, 1210, 1224, 1223, 1405, 1406, 1420, 1419
1327, 1210, 1211, 1225, 1224, 1406, 1407, 1421, 1420
1328, 1211, 1212, 1226, 1225, 1407, 1408, 1422, 1421
1329, 1212, 1213, 1227, 1226, 1408, 1409, 1423, 1422
1330, 1213, 1214, 1228, 1227, 1409, 1410, 1424, 1423
1331, 1214, 1215, 1229, 1228, 1410, 1411, 1425, 1424
1332, 1215, 1216, 1230, 1229, 1411, 1412, 1426, 1425
1333, 1216, 1217, 1231, 1230, 1412, 1413, 1427, 1426
1334, 1217, 1218, 1232, 1231, 1413, 1414, 1428, 1427
1335, 1218, 163, 164, 1232, 1414, 205, 206, 1428
1336, 150, 1219, 1233, 151, 178, 1415, 1429, 179
1337, 1219, 1220, 1234, 1233, 1415, 1416, 1430, 1429
1338, 1220, 1221, 1235, 1234, 1416, 1417, 1431, 1430
1339, 1221, 1222, 1236, 1235, 1417, 1418, 1432, 1431
1340, 1222, 1223, 1237, 1236, 1418, 1419, 1433, 1432
1341, 1223, 1224, 1238, 1237, 1419, 1420, 1434, 1433
1342, 1224, 1225, 1239, 1238, 1420, 1421, 1435, 1434
1343, 1225, 1226, 1240, 1239, 1421, 1422, 1436, 1435
1344, 1226, 1227, 1241, 1240, 1422, 1423, 1437, 1436
1345, 1227, 1228, 1242, 1241, 1423, 1424, 1438, 1437
1346, 1228, 1229, 1243, 1242, 1424, 1425, 1439, 1438
1347, 1229, 1230, 1244, 1243, 1425, 1426, 1440, 1439
1348, 1230, 1231, 1245, 1244, 1426, 1427, 1441, 1440
1349, 1231, 1232, 1246, 1245, 1427, 1428, 1442, 1441
1350, 1232, 164, 165, 1246, 1428, 206, 207, 1442
1351, 151, 1233, 1247, 152, 179, 1429, 1443, 180
1352, 1233, 1234, 1248, 1247, 1429, 1430, 1444, 1443
1353, 1234, 1235, 1249, 1248, 1430, 1431, 1445, 1444
1354, 1235, 1236, 1250, 1249, 1431, 1432, 1446, 1445
1355, 1236, 1237, 1251, 1250, 1432, 1433, 1447, 1446
1356, 1237, 1238, 1252, 1251, 1433, 1434, 1448, 1447
1357, 1238, 1239, 1253, 1252, 1434, 1435, 1449, 1448
1358, 1239, 1240, 1254, 1253, 1435, 1436, 1450, 1449
1359, 1240, 1241, 1255, 1254, 1436, 1437, 1451, 1450
1360, 1241, 1242, 1256, 1255, 1437, 1438, 1452, 1451
1361, 1242, 1243, 1257, 1256, 1438, 1439, 1453, 1452
1362, 1243, 1244, 1258, 1257, 1439, 1440, 1454, 1453
1363, 1244, 1245, 1259, 1258, 1440, 1441, 1455, 1454
1364, 1245, 1246, 1260, 1259, 1441, 1442, 1456, 1455
1365, 1246, 165, 166, 1260, 1442, 207, 208, 1456
1366, 152, 1247, 1261, 153, 180, 1443, 1457, 181
1367, 1247, 1248, 1262, 1261, 1443, 1444, 1458, 1457
1368, 1248, 1249, 1263, 1262, 1444, 1445, 1459, 1458
1369, 1249, 1250, 1264, 1263, 1445, 1446, 1460, 1459
1370, 1250, 1251, 1265, 1264, 1446, 1447, 1461, 1460
1371, 1251, 1252, 1266, 1265, 1447, 1448, 1462, 1461
1372, 1252, 1253, 1267, 1266, 1448, 1449, 1463, 1462
1373, 1253, 1254, 1268, 1267, 1449, 1450, 1464, 1463
1374, 1254, 1255, 1269, 1268, 1450, 1451, 1465, 1464
1375, 1255, 1256, 1270, 1269, 1451, 1452, 1466, 1465
1376, 1256, 1257, 1271, 1270, 1452, 1453, 1467, 1466
1377, 1257, 1258, 1272, 1271, 1453, 1454, 1468, 1467
1378, 1258, 1259, 1273, 1272, 1454, 1455, 1469, 1468
1379, 1259, 1260, 1274, 1273, 1455, 1456, 1470, 1469
1380, 1260, 166, 167, 1274, 1456, 208, 209, 1470
1381, 153, 1261, 1275, 154, 181, 1457, 1471, 182
1382, 1261, 1262, 1276, 1275, 1457, 1458, 1472, 1471
1383, 1262, 1263, 1277, 1276, 1458, 1459, 1473, 1472
1384, 1263, 1264, 1278, 1277, 1459, 1460, 1474, 1473
1385, 1264, 1265, 1279, 1278, 1460, 1461, 1475, 1474
1386, 1265, 1266, 1280, 1279, 1461, 1462, 1476, 1475
1387, 1266, 1267, 1281, 1280, 1462, 1463, 1477, 1476
1388, 1267, 1268, 1282, 1281, 1463, 1464, 1478, 1477
1389, 1268, 1269, 1283, 1282, 1464, 1465, 1479, 1478
1390, 1269, 1270, 1284, 1283, 1465, 1466, 1480, 1479
1391, 1270, 1271, 1285, 1284, 1466, 1467, 1481, 1480
1392, 1271, 1272, 1286, 1285, 1467, 1468, 1482, 1481
1393, 1272, 1273, 1287, 1286, 1468, 1469, 1483, 1482
1394, 1273, 1274, 1288, 1287, 1469, 1470, 1484, 1483
1395, 1274, 167, 168, 1288, 1470, 209, 210, 1484
1396, 154, 1275, 99, 8, 182, 1471, 183, 9
1397, 1275, 1276, 100, 99, 1471, 1472, 184, 183
1398, 1276, 1277, 101, 100, 1472, 1473, 185, 184
1399, 1277, 1278, 102, 101, 1473, 1474, 186, 185
1400, 1278, 1279, 103, 102, 1474, 1475, 187, 186
1401, 1279, 1280, 104, 103, 1475, 1476, 188, 187
1402, 1280, 1281, 105, 104, 1476, 1477, 189, 188
1403, 1281, 1282, 106, 105, 1477, 1478, 190, 189
1404, 1282, 1283, 107, 106, 1478, 1479, 191, 190
1405, 1283, 1284, 108, 107, 1479, 1480, 192, 191
1406, 1284, 1285, 109, 108, 1480, 1481, 193, 192
1407, 1285, 1286, 110, 109, 1481, 1482, 194, 193
1408, 1286, 1287, 111, 110, 1482, 1483, 195, 194
1409, 1287, 1288, 112, 111, 1483, 1484, 196, 195
1410, 1288, 168, 7, 112, 1484, 210, 11, 196
*ELEMENT, type=C3D8, ELSET=Volume3
1411, 10, 211, 1289, 169, 239, 2073, 4817, 1485
1412, 239, 2073, 4817, 1485, 240, 2074, 4818, 1486
1413, 240, 2074, 4818, 1486, 241, 2075, 4819, 1487
1414, 241, 2075, 4819, 1487, 242, 2076, 4820, 1488
1415, 242, 2076, 4820, 1488, 243, 2077, 4821, 1489
1416, 243, 2077, 4821, 1489, 244, 2078, 4822, 1490
1417, 244, 2078, 4822, 1490, 245, 2079, 4823, 1491
1418, 245, 2079, 4823, 1491, 246, 2080, 4824, 1492
1419, 246, 2080, 4824, 1492, 247, 2081, 4825, 1493
1420, 247, 2081, 4825, 1493, 248, 2082, 4826, 1494
1421, 248, 2082, 4826, 1494, 249, 2083, 4827, 1495
1422, 249, 2083, 4827, 1495, 250, 2084, 4828, 1496
1423, 250, 2084, 4828, 1496, 251, 2085, 4829, 1497
1424, 251, 2085, 4829, 1497, 252, 2086, 4830, 1498
1425, 252, 2086, 4830, 1498, 14, 323, 2269, 253
1426, 211, 212, 1290, 1289, 2073, 2087, 4831, 4817
1427, 2073, 2087, 4831, 4817, 2074, 2088, 4832, 4818
1428, 2074, 2088, 4832, 4818, 2075, 2089, 4833, 4819
1429, 2075, 2089, 4833, 4819, 2076, 2090, 4834, 4820
1430, 2076, 2090, 4834, 4820, 2077, 2091, 4835, 4821
1431, 2077, 2091, 4835, 4821, 2078, 2092, 4836, 4822
1432, 2078, 2092, 4836, 4822, 2079, 2093, 4837, 4823
1433, 2079, 2093, 4837, 4823, 2080, 2094, 4838, 4824
1434, 2080, 2094, 4838, 4824, 2081, 2095, 4839, 4825
1435, 2081, 2095, 4839, 4825, 2082, 2096, 4840, 4826
1436, 2082, 2096, 4840, 4826, 2083, 2097, 4841, 4827
1437, 2083, 2097, 4841, 4827, 2084, 2098, 4842, 4828
1438, 2084, 2098, 4842, 4828, 2085, 2099, 4843, 4829
1439, 2085, 2099, 4843, 4829, 2086, 2100, 4844, 4830
1440, 2086, 2100, 4844, 4830, 323, 324, 2270, 2269
1441, 212, 213, 1291, 1290, 2087, 2101, 4845, 4831
1442, 2087, 2101, 4845, 4831, 2088, 2102, 4846, 4832
1443, 2088, 2102, 4846, 4832, 2089, 2103, 4847, 4833
1444, 2089, 2103, 4847, 4833, 2090, 2104, 4848, 4834
1445, 2090, 2104, 4848, 4834, 2091, 2105, 4849, 4835
1446, 2091, 2105, 4849, 4835, 2092, 2106, 4850, 4836
1447, 2092, 2106, 4850, 4836, 2093, 2107, 4851, 4837
1448, 2093, 2107, 4851, 4837, 2094, 2108, 4852, 4838
1449, 2094, 2108, 4852, 4838, 2095, 2109, 4853, 4839
1450, 2095, 2109, 4853, 4839, 2096, 2110, 4854, 4840
1451, 2096, 2110, 4854, 4840, 2097, 2111, 4855, 4841
1452, 2097, 2111, 4855, 4841, 2098, 2112, 4856, 4842
1453, 2098, 2112, 4856, 4842, 2099, 2113, 4857, 4843
1454, 2099, 2113, 4857, 4843, 2100, 2114, 4858, 4844
1455, 2100, 2114, 4858, 4844, 324, 325, 2271, 2270
1456, 213, 214, 1292, 1291, 2101, 2115, 4859, 4845
1457, 2101, 2115, 4859, 4845, 2102, 2116, 4860, 4846
1458, 2102, 2116, 4860, 4846, 2103, 2117, 4861, 4847
1459, 2103, 2117, 4861, 4847, 2104, 2118, 4862, 4848
1460, 2104, 2118, 4862, 4848, 2105, 2119, 4863, 4849
1461, 2105, 2119, 4863, 4849, 2106, 2120, 4864, 4850
1462, 2106, 2120, 4864, 4850, 2107, 2121, 4865, 4851
1463, 2107, 2121, 4865, 4851, 2108, 2122, 4866, 4852
1464, 2108, 2122, 4866, 4852, 2109, 2123, 4867, 4853
1465, 2109, 2123, 4867, 4853, 2110, 2124, 4868, 4854
1466, 2110, 2124, 4868, 4854, 2111, 2125, 4869, 4855
1467, 2111, 2125, 4869, 4855, 2112, 2126, 4870, 4856
1468, 2112, 2126, 4870, 4856, 2113, 2127, 4871, 4857
1469, 2113, 2127, 4871, 4857, 2114, 2128, 4872, 4858
1470, 2114, 2128, 4872, 4858, 325, 326, 2272, 2271
1471, 214, 215, 1293, 1292, 2115, 2129, 4873, 4859
1472, 2115, 2129, 4873, 4859, 2116, 2130, 4874, 4860
1473, 2116, 2130, 4874, 4860, 2117, 2131, 4875, 4861
1474, 2117, 2131, 4875, 4861, 2118, 2132, 4876, 4862
1475, 2118, 2132, 4876, 4862, 2119, 2133, 4877, 4863
1476, 2119, 2133, 4877, 4863, 2120, 2134, 4878, 4864
1477, 2120, 2134, 4878, 4864, 2121, 2135, 4879, 4865
1478, 2121, 2135, 4879, 4865, 2122, 2136, 4880, 4866
1479, 2122, 2136, 4880, 4866, 2123, 2137, 4881, 4867
1480, 2123, 2137, 4881, 4867, 2124, 2138, 4882, 4868
1481, 2124, 2138, 4882, 4868, 2125, 2139, 4883, 4869
1482, 2125, 2139, 4883, 4869, 2126, 2140, 4884, 4870
1483, 2126, 2140, 4884, 4870, 2127, 2141, 4885, 4871
1484, 2127, 2141, 4885, 4871, 2128, 2142, 4886, 4872
1485, 2128, 2142, 4886, 4872, 326, 327, 2273, 2272
1486, 215, 216, 1294, 1293, 2129, 2143, 4887, 4873
1487, 2129, 2143, 4887, 4873, 2130, 2144, 4888, 4874
1488, 2130, 2144, 4888, 4874, 2131, 2145, 4889, 4875
1489, 2131, 2145, 4889, 4875, 2132, 2146, 4890, 4876
1490, 2132, 2146, 4890, 4876, 2133, 2147, 4891, 4877
1491, 2133, 2147, 4891, 4877, 2134, 2148, 4892, 4878
1492, 2134, 2148, 4892, 4878, 2135, 2149, 4893, 4879
1493, 2135, 2149, 4893, 4879, 2136, 2150, 4894, 4880
1494, 2136, 2150, 4894, 4880, 2137, 2151, 4895, 4881
1495, 2137, 2151, 4895, 4881, 2138, 2152, 4896, 4882
1496, 2138, 2152, 4896, 4882, 2139, 2153, 4897, 4883
1497, 2139, 2153, 4897, 4883, 2140, 2154, 4898, 4884
1498, 2140, 2154, 4898, 4884, 2141, 2155, 4899, 4885
1499, 2141, 2155, 4899, 4885, 2142, 2156, 4900, 4886
1500, 2142, 2156, 4900, 4886, 327, 328, 2274, 2273
1501, 216, 217, 1295, 1294, 2143, 2157, 4901, 4887
1502, 2143, 2157, 4901, 4887, 2144, 2158, 4902, 4888
1503, 2144, 2158, 4902, 4888, 2145, 2159, 4903, 4889
1504, 2145, 2159, 4903, 4889, 2146, 2160, 4904, 4890
1505, 2146, 2160, 4904, 4890, 2147, 2161, 4905, 4891
1506, 2147, 2161, 4905, 4891, 2148, 2162, 4906, 4892
1507, 2148, 2162, 4906, 4892, 2149, 2163, 4907, 4893
1508, 2149, 2163, 4907, 4893, 2150, 2164, 4908, 4894
1509, 2150, 2164, 4908, 4894, 2151, 2165, 4909, 4895
1510, 2151, 2165, 4909, 4895, 2152, 2166, 4910, 4896
1511, 2152, 2166, 4910, 4896, 2153, 2167, 4911, 4897
1512, 2153, 2167, 4911, 4897, 2154, 2168, 4912, 4898
1513, 2154, 2168, 4912, 4898, 2155, 2169, 4913, 4899
1514, 2155, 2169, 4913, 4899, 2156, 2170, 4914, 4900
1515, 2156, 2170, 4914, 4900, 328, 329, 2275, 2274
1516, 217, 218, 1296, 1295, 2157, 2171, 4915, 4901
1517, 2157, 2171, 4915, 4901, 2158, 2172, 4916, 4902
1518, 2158, 2172, 4916, 4902, 2159, 2173, 4917, 4903
1519, 2159, 2173, 4917, 4903, 2160, 2174, 4918, 4904
1520, 2160, 2174, 4918, 4904, 2161, 2175, 4919, 4905
1521, 2161, 2175, 4919, 4905, 2162, 2176, 4920, 4906
1522, 2162, 2176, 4920, 4906, 2163, 2177, 4921, 4907
1523, 2163, 2177, 4921, 4907, 2164, 2178, 4922, 4908
1524, 2164, 2178, 4922, 4908, 2165, 2179, 4923, 4909
1525, 2165, 2179, 4923, 4909, 2166, 2180, 4924, 4910
1526, 2166, 2180, 4924, 4910, 2167, 2181, 4925, 4911
1527, 2167, 2181, 4925, 4911, 2168, 2182, 4926, 4912
1528, 2168, 2182, 4926, 4912, 2169, 2183, 4927, 4913
1529, 2169, 2183, 4927, 4913, 2170, 2184, 4928, 4914
1530, 2170, 2184, 4928, 4914, 329, 330, 2276, 2275
1531, 218, 219, 1297, 1296, 2171, 2185, 4929, 4915
1532, 2171, 2185, 4929, 4915, 2172, 2186, 4930, 4916
1533, 2172, 2186, 4930, 4916, 2173, 2187, 4931, 4917
1534, 2173, 2187, 4931, 4917, 2174, 2188, 4932, 4918
1535, 2174, 2188, 4932, 4918, 2175, 2189, 4933, 4919
1536, 2175, 2189, 4933, 4919, 2176, 2190, 4934, 4920
1537, 2176, 2190, 4934, 4920, 2177, 2191, 4935, 4921
1538, 2177, 2191, 4935, 4921, 2178, 2192, 4936, 4922
1539, 2178, 2192, 4936, 4922, 2179, 2193, 4937, 4923
1540, 2179, 2193, 4937, 4923, 2180, 2194, 4938, 4924
1541, 2180, 2194, 4938, 4924, 2181, 2195, 4939, 4925
1542, 2181, 2195, 4939, 4925, 2182, 2196, 4940, 4926
1543, 2182, 2196, 4940, 4926, 2183, 2197, 4941, 4927
1544, 2183, 2197, 4941, 4927, 2184, 2198, 4942, 4928
1545, 2184, 2198, 4942, 4928, 330, 331, 2277, 2276
1546, 219, 220, 1298, 1297, 2185, 2199, 4943, 4929
1547, 2185, 2199, 4943, 4929, 2186, 2200, 4944, 4930
1548, 2186, 2200, 4944, 4930, 2187, 2201, 4945, 4931
1549, 2187, 2201, 4945, 4931, 2188, 2202, 4946, 4932
1550, 2188, 2202, 4946, 4932, 2189, 2203, 4947, 4933
1551, 2189, 2203, 4947, 4933, 2190, 2204, 4948, 4934
1552, 2190, 2204, 4948, 4934, 2191, 2205, 4949, 4935
1553, 2191, 2205, 4949, 4935, 2192, 2206, 4950, 4936
1554, 2192, 2206, 4950, 4936, 2193, 2207, 4951, 4937
1555, 2193, 2207, 4951, 4937, 2194, 2208, 4952, 4938
1556, 2194, 2208, 4952, 4938, 2195, 2209, 4953, 4939
1557, 2195, 2209, 4953, 4939, 2196, 2210, 4954, 4940
1558, 2196, 2210, 4954, 4940, 2197, 2211, 4955, 4941
1559, 2197, 2211, 4955, 4941, 2198, 2212, 4956, 4942
1560, 2198, 2212, 4956, 4942, 331, 332, 2278, 2277
1561, 220, 221, 1299, 1298, 2199, 2213, 4957, 4943
1562, 2199, 2213, 4957, 4943, 2200, 2214, 4958, 4944
1563, 2200, 2214, 4958, 4944, 2201, 2215, 4959, 4945
1564, 2201, 2215, 4959, 4945, 2202, 2216, 4960, 4946
1565, 2202, 2216, 4960, 4946, 2203, 2217, 4961, 4947
1566, 2203, 2217, 4961, 4947, 2204, 2218, 4962, 4948
1567, 2204, 2218, 4962, 4948, 2205, 2219, 4963, 4949
1568, 2205, 2219, 4963, 4949, 2206, 2220, 4964, 4950
1569, 2206, 2220, 4964, 4950, 2207, 2221, 4965, 4951
1570, 2207, 2221, 4965, 4951, 2208, 2222, 4966, 4952
1571, 2208, 2222, 4966, 4952, 2209, 2223, 4967, 4953
1572, 2209, 2223, 4967, 4953, 2210, 2224, 4968, 4954
1573, 2210, 2224, 4968, 4954, 2211, 2225, 4969, 4955
1574, 2211, 2225, 4969, 4955, 2212, 2226, 4970, 4956
1575, 2212, 2226, 4970, 4956, 332, 333, 2279, 2278
1576, 221, 222, 1300, 1299, 2213, 2227, 4971, 4957
1577, 2213, 2227, 4971, 4957, 2214, 2228, 4972, 4958
1578, 2214, 2228, 4972, 4958, 2215, 2229, 4973, 4959
1579, 2215, 2229, 4973, 4959, 2216, 2230, 4974, 4960
1580, 2216, 2230, 4974, 4960, 2217, 2231, 4975, 4961
1581, 2217, 2231, 4975, 4961, 2218, 2232, 4976, 4962
1582, 2218, 2232, 4976, 4962, 2219, 2233, 4977, 4963
1583, 2219, 2233, 4977, 4963, 2220, 2234, 4978, 4964
1584, 2220, 2234, 4978, 4964, 2221, 2235, 4979, 4965
1585, 2221, 2235, 4979, 4965, 2222, 2236, 4980, 4966
1586, 2222, 2236, 4980, 4966, 2223, 2237, 4981, 4967
1587, 2223, 2237, 4981, 4967, 2224, 2238, 4982, 4968
1588, 2224, 2238, 4982, 4968, 2225, 2239, 4983, 4969
1589, 2225, 2239, 4983, 4969, 2226, 2240, 4984, 4970
1590, 2226, 2240, 4984, 4970, 333, 334, 2280, 2279
1591, 222, 223, 1301, 1300, 2227, 2241, 4985, 4971
1592, 2227, 2241, 4985, 4971, 2228, 2242, 4986, 4972
1593, 2228, 2242, 4986, 4972, 2229, 2243, 4987, 4973
1594, 2229, 2243, 4987, 4973, 2230, 2244, 4988, 4974
1595, 2230, 2244, 4988, 4974, 2231, 2245, 4989, 4975
1596, 2231, 2245, 4989, 4975, 2232, 2246, 4990, 4976
1597, 2232, 2246, 4990, 4976, 2233, 2247, 4991, 4977
1598, 2233, 2247, 4991, 4977, 2234, 2248, 4992, 4978
1599, 2234, 2248, 4992, 4978, 2235, 2249, 4993, 4979
1600, 2235, 2249, 4993, 4979, 2236, 2250, 4994, 4980
1601, 2236, 2250, 4994, 4980, 2237, 2251, 4995, 4981
1602, 2237, 2251, 4995, 4981, 2238, 2252, 4996, 4982
1603, 2238, 2252, 4996, 4982, 2239, 2253, 4997, 4983
1604, 2239, 2253, 4997, 4983, 2240, 2254, 4998, 4984
1605, 2240, 2254, 4998, 4984, 334, 335, 2281, 2280
1606, 223, 224, 1302, 1301, 2241, 2255, 4999, 4985
1607, 2241, 2255, 4999, 4985, 2242, 2256, 5000, 4986
1608, 2242, 2256, 5000, 4986, 2243, 2257, 5001, 4987
1609, 2243, 2257, 5001, 4987, 2244, 2258, 5002, 4988
1610, 2244, 2258, 5002, 4988, 2245, 2259, 5003, 4989
1611, 2245, 2259, 5003, 4989, 2246, 2260, 5004, 4990
1612, 2246, 2260, 5004, 4990, 2247, 2261, 5005, 4991
1613, 2247, 2261, 5005, 4991, 2248, 2262, 5006, 4992
1614, 2248, 2262, 5006, 4992, 2249, 2263, 5007, 4993
1615, 2249, 2263, 5007, 4993, 2250, 2264, 5008, 4994
1616, 2250, 2264, 5008, 4994, 2251, 2265, 5009, 4995
1617, 2251, 2265, 5009, 4995, 2252, 2266, 5010, 4996
1618, 2252, 2266, 5010, 4996, 2253, 2267, 5011, 4997
1619, 2253, 2267, 5011, 4997, 2254, 2268, 5012, 4998
1620, 2254, 2268, 5012, 4998, 335, 336, 2282, 2281
1621, 224, 12, 197, 1302, 2255, 295, 1877, 4999
1622, 2255, 295, 1877, 4999, 2256, 296, 1878, 5000
1623, 2256, 296, 1878, 5000, 2257, 297, 1879, 5001
1624, 2257, 297, 1879, 5001, 2258, 298, 1880, 5002
1625, 2258, 298, 1880, 5002, 2259, 299, 1881, 5003
1626, 2259, 299, 1881, 5003, 2260, 300, 1882, 5004
1627, 2260, 300, 1882, 5004, 2261, 301, 1883, 5005
1628, 2261, 301, 1883, 5005, 2262, 302, 1884, 5006
1629, 2262, 302, 1884, 5006, 2263, 303, 1885, 5007
1630, 2263, 303, 1885, 5007, 2264, 304, 1886, 5008
1631, 2264, 304, 1886, 5008, 2265, 305, 1887, 5009
1632, 2265, 305, 1887, 5009, 2266, 306, 1888, 5010
1633, 2266, 306, 1888, 5010, 2267, 307, 1889, 5011
1634, 2267, 307, 1889, 5011, 2268, 308, 1890, 5012
1635, 2268, 308, 1890, 5012, 336, 16, 309, 2282
1636, 169, 1289, 1303, 170, 1485, 4817, 5013, 1499
1637, 1485, 4817, 5013, 1499, 1486, 4818, 5014, 1500
1638, 1486, 4818, 5014, 1500, 1487, 4819, 5015, 1501
1639, 1487, 4819, 5015, 1501, 1488, 4820, 5016, 1502
1640, 1488, 4820, 5016, 1502, 1489, 4821, 5017, 1503
1641, 1489, 4821, 5017, 1503, 1490, 4822, 5018, 1504
1642, 1490, 4822, 5018, 1504, 1491, 4823, 5019, 1505
1643, 1491, 4823, 5019, 1505, 1492, 4824, 5020, 1506
1644, 1492, 4824, 5020, 1506, 1493, 4825, 5021, 1507
1645, 1493, 4825, 5021, 1507, 1494, 4826, 5022, 1508
1646, 1494, 4826, 5022, 1508, 1495, 4827, 5023, 1509
1647, 1495, 4827, 5023, 1509, 1496, 4828, 5024, 1510
1648, 1496, 4828, 5024, 1510, 1497, 4829, 5025, 1511
1649, 1497, 4829, 5025, 1511, 1498, 4830, 5026, 1512
1650, 1498, 4830, 5026, 1512, 253, 2269, 2283, 254
1651, 1289, 1290, 1304, 1303, 4817, 4831, 5027, 5013
1652, 4817, 4831, 5027, 5013, 4818, 4832, 5028, 5014
1653, 4818, 4832, 5028, 5014, 4819, 4833, 5029, 5015
1654, 4819, 4833, 5029, 5015, 4820, 4834, 5030, 5016
1655, 4820, 4834, 5030, 5016, 4821, 4835, 5031, 5017
1656, 4821, 4835, 5031, 5017, 4822, 4836, 5032, 5018
1657, 4822, 4836, 5032, 5018, 4823, 4837, 5033, 5019
1658, 4823, 4837, 5033, 5019, 4824, 4838, 5034, 5020
1659, 4824, 4838, 5034, 5020, 4825, 4839, 5035, 5021
1660, 4825, 4839, 5035, 5021, 4826, 4840, 5036, 5022
1661, 4826, 4840, 5036, 5022, 4827, 4841, 5037, 5023
1662, 4827, 4841, 5037, 5023, 4828, 4842, 5038, 5024
1663, 4828, 4842, 5038, 5024, 4829, 4843, 5039, 5025
1664, 4829, 4843, 5039, 5025, 4830, 4844, 5040, 5026
1665, 4830, 4844, 5040, 5026, 2269, 2270, 2284, 2283
1666, 1290, 1291, 1305, 1304, 4831, 4845, 5041, 5027
1667, 4831, 4845, 5041, 5027, 4832, 4846, 5042, 5028
1668, 4832, 4846, 5042, 5028, 4833, 4847, 5043, 5029
1669, 4833, 4847, 5043, 5029, 4834, 4848, 5044, 5030
1670, 4834, 4848, 5044, 5030, 4835, 4849, 5045, 5031
1671, 4835, 4849, 5045, 5031, 4836, 4850, 5046, 5032
1672, 4836, 4850, 5046, 5032, 4837, 4851, 5047, 5033
1673, 4837, 4851, 5047, 5033, 4838, 4852, 5048, 5034
1674, 4838, 4852, 5048, 5034, 4839, 4853, 5049, 5035
1675, 4839, 4853, 5049, 5035, 4840, 4854, 5050, 5036
1676, 4840, 4854, 5050, 5036, 4841, 4855, 5051, 5037
1677, 4841, 4855, 5051, 5037, 4842, 4856, 5052, 5038
1678, 4842, 4856, 5052, 5038, 4843, 4857, 5053, 5039
1679, 4843, 4857, 5053, 5039, 4844, 4858, 5054, 5040
1680, 4844, 4858, 5054, 5040, 2270, 2271, 2285, 2284
1681, 1291, 1292, 1306, 1305, 4845, 4859, 5055, 5041
1682, 4845, 4859, 5055, 5041, 4846, 4860, 5056, 5042
1683, 4846, 4860, 5056, 5042, 4847, 4861, 5057, 5043
1684, 4847, 4861, 5057, 5043, 4848, 4862, 5058, 5044
1685, 4848, 4862, 5058, 5044, 4849, 4863, 5059, 5045
1686, 4849, 4863, 5059, 5045, 4850, 4864, 5060, 5046
1687, 4850, 4864, 5060, 5046, 4851, 4865, 5061, 5047
1688, 4851, 4865, 5061, 5047, 4852, 4866, 5062, 5048
1689, 4852, 4866, 5062, 5048, 4853, 4867, 5063, 5049
1690, 4853, 4867, 5063, 5049, 4854, 4868, 5064, 5050
1691, 4854, 4868, 5064, 5050, 4855, 4869, 5065, 5051
1692, 4855, 4869, 5065, 5051, 4856, 4870, 5066, 5052
1693, 4856, 4870, 5066, 5052, 4857, 4871, 5067, 5053
1694, 4857, 4871, 5067, 5053, 4858, 4872, 5068, 5054
1695, 4858, 4872, 5068, 5054, 2271, 2272, 2286, 2285
1696, 1292, 1293, 1307, 1306, 4859, 4873, 5069, 5055
1697, 4859, 4873, 5069, 5055, 4860, 4874, 5070, 5056
1698, 4860, 4874, 5070, 5056, 4861, 4875, 5071, 5057
1699, 4861, 4875, 5071, 5057, 4862, 4876, 5072, 5058
1700, 4862, 4876, 5072, 5058, 4863, 4877, 5073, 5059
1701, 4863, 4877, 5073, 5059, 4864, 4878, 5074, 5060
1702, 4864, 4878, 5074, 5060, 4865, 4879, 5075, 5061
1703, 4865, 4879, 5075, 5061, 4866, 4880, 5076, 5062
1704, 4866, 4880, 5076, 5062, 4867, 4881, 5077, 5063
1705, 4867, 4881, 5077, 5063, 4868, 4882, 5078, 5064
1706, 4868, 4882, 5078, 5064, 4869, 4883, 5079, 5065
1707, 4869, 4883, 5079, 5065, 4870, 4884, 5080, 5066
1708, 4870, 4884, 5080, 5066, 4871, 4885, 5081, 5067
1709, 4871, 4885, 5081, 5067, 4872, 4886, 5082, 5068
1710, 4872, 4886, 5082, 5068, 2272, 2273, 2287, 2286
1711, 1293, 1294, 1308, 1307, 4873, 4887, 5083, 5069
1712, 4873, 4887, 5083, 5069, 4874, 4888, 5084, 5070
1713, 4874, 4888, 5084, 5070, 4875, 4889, 5085, 5071
1714, 4875, 4889, 5085, 5071, 4876, 4890, 5086, 5072
1715, 4876, 4890, 5086, 5072, 4877, 4891, 5087, 5073
1716, 4877, 4891, 5087, 5073, 4878, 4892, 5088, 5074
1717, 4878, 4892, 5088, 5074, 4879, 4893, 5089, 5075
1718, 4879, 4893, 5089, 5075, 4880, 4894, 5090, 5076
1719, 4880, 4894, 5090, 5076, 4881, 4895, 5091, 5077
1720, 4881, 4895, 5091, 5077, 4882, 4896, 5092, 5078
1721, 4882, 4896, 5092, 5078, 4883, 4897, 5093, 5079
1722, 4883, 4897, 5093, 5079, 4884, 4898, 5094, 5080
1723, 4884, 4898, 5094, 5080, 4885, 4899, 5095, 5081
1724, 4885, 4899, 5095, 5081, 4886, 4900, 5096, 5082
1725, 4886, 4900, 5096, 5082, 2273, 2274, 2288, 2287
1726, 1294, 1295, 1309, 1308, 4887, 4901, 5097, 5083
1727, 4887, 4901, 5097, 5083, 4888, 4902, 5098, 5084
1728, 4888, 4902, 5098, 5084, 4889, 4903, 5099, 5085
1729, 4889, 4903, 5099, 5085, 4890, 4904, 5100, 5086
1730, 4890, 4904, 5100, 5086, 4891, 4905, 5101, 5087
1731, 4891, 4905, 5101, 5087, 4892, 4906, 5102, 5088
1732, 4892, 4906, 5102, 5088, 4893, 4907, 5103, 5089
1733, 4893, 4907, 5103, 5089, 4894, 4908, 5104, 5090
1734, 4894, 4908, 5104, 5090, 4895, 4909, 5105, 5091
1735, 4895, 4909, 5105, 5091, 4896, 4910, 5106, 5092
1736, 4896, 4910, 5106, 5092, 4897, 4911, 5107, 5093
1737, 4897, 4911, 5107, 5093, 4898, 4912, 5108, 5094
1738, 4898, 4912, 5108, 5094, 4899, 4913, 5109, 5095
1739, 4899, 4913, 5109, 5095, 4900, 4914, 5110, 5096
1740, 4900, 4914, 5110, 5096, 2274, 2275, 2289, 2288
1741, 1295, 1296, 1310, 1309, 4901, 4915, 5111, 5097
1742, 4901, 4915, 5111, 5097, 4902, 4916, 5112, 5098
1743, 4902, 4916, 5112, 5098, 4903, 4917, 5113, 5099
1744, 4903, 4917, 5113, 5099, 4904, 4918, 5114, 5100
1745, 4904, 4918, 5114, 5100, 4905, 4919, 5115, 5101
1746, 4905, 4919, 5115, 5101, 4906, 4920, 5116, 5102
1747, 4906, 4920, 5116, 5102, 4907, 4921, 5117, 5103
1748, 4907, 4921, 5117, 5103, 4908, 4922, 5118, 5104
1749, 4908, 4922, 5118, 5104, 4909, 4923, 5119, 5105
1750, 4909, 4923, 5119, 5105, 4910, 4924, 5120, 5106
1751, 4910, 4924, 5120, 5106, 4911, 4925, 5121, 5107
1752, 4911, 4925, 5121, 5107, 4912, 4926, 5122, 5108
1753, 4912, 4926, 5122, 5108, 4913, 4927, 5123, 5109
1754, 4913, 4927, 5123, 5109, 4914, 4928, 5124, 5110
1755, 4914, 4928, 5124, 5110, 2275, 2276, 2290, 2289
1756, 1296, 1297, 1311, 1310, 4915, 4929, 5125, 5111
1757, 4915, 4929, 5125, 5111, 4916, 4930, 5126, 5112
1758, 4916, 4930, 5126, 5112, 4917, 4931, 5127, 5113
1759, 4917, 4931, 5127, 5113, 4918, 4932, 5128, 5114
1760, 4918, 4932, 5128, 5114, 4919, 4933, 5129, 5115
1761, 4919, 4933, 5129, 5115, 4920, 4934, 5130, 5116
1762, 4920, 4934, 5130, 5116, 4921, 4935, 5131, 5117
1763, 4921, 4935, 5131, 5117, 4922, 4936, 5132, 5118
1764, 4922, 4936, 5132, 5118, 4923, 4937, 5133, 5119
1765, 4923, 4937, 5133, 5119, 4924, 4938, 5134, 5120
1766, 4924, 4938, 5134, 5120, 4925, 4939, 5135, 5121
1767, 4925, 4939, 5135, 5121, 4926, 4940, 5136, 5122
1768, 4926, 4940, 5136, 5122, 4927, 4941, 5137, 5123
1769, 4927, 4941, 5137, 5123, 4928, 4942, 5138, 5124
1770, 4928, 4942, 5138, 5124, 2276, 2277, 2291, 2290
1771, 1297, 1298, 1312, 1311, 4929, 4943, 5139, 5125
1772, 4929, 4943, 5139, 5125, 4930, 4944, 5140, 5126
1773, 4930, 4944, 5140, 5126, 4931, 4945, 5141, 5127
1774, 4931, 4945, 5141, 5127, 4932, 4946, 5142, 5128
1775, 4932, 4946, 5142, 5128, 4933, 4947, 5143, 5129
1776, 4933, 4947, 5143, 5129, 4934, 4948, 5144, 5130
1777, 4934, 4948, 5144, 5130, 4935, 4949, 5145, 5131
1778, 4935, 4949, 5145, 5131, 4936, 4950, 5146, 5132
1779, 4936, 4950, 5146, 5132, 4937, 4951, 5147, 5133
1780, 4937, 4951, 5147, 5133, 4938, 4952, 5148, 5134
1781, 4938, 4952, 5148, 5134, 4939, 4953, 5149, 5135
1782, 4939, 4953, 5149, 5135, 4940, 4954, 5150, 5136
1783, 4940, 4954, 5150, 5136, 4941, 4955, 5151, 5137
1784, 4941, 4955, 5151, 5137, 4942, 4956, 5152, 5138
1785, 4942, 4956, 5152, 5138, 2277, 2278, 2292, 2291
1786, 1298, 1299, 1313, 1312, 4943, 4957, 5153, 5139
1787, 4943, 4957, 5153, 5139, 4944, 4958, 5154, 5140
1788, 4944, 4958, 5154, 5140, 4945, 4959, 5155, 5141
1789, 4945, 4959, 5155, 5141, 4946, 4960, 5156, 5142
1790, 4946, 4960, 5156, 5142, 4947, 4961, 5157, 5143
1791, 4947, 4961, 5157, 5143, 4948, 4962, 5158, 5144
1792, 4948, 4962, 5158, 5144, 4949, 4963, 5159, 5145
1793, 4949, 4963, 5159, 5145, 4950, 4964, 5160, 5146
1794, 4950, 4964, 5160, 5146, 4951, 4965, 5161, 5147
1795, 4951, 4965, 5161, 5147, 4952, 4966, 5162, 5148
1796, 4952, 4966, 5162, 5148, 4953, 4967, 5163, 5149
1797, 4953, 4967, 5163, 5149, 4954, 4968, 5164, 5150
1798, 4954, 4968, 5164, 5150, 4955, 4969, 5165, 5151
1799, 4955, 4969, 5165, 5151, 4956, 4970, 5166, 5152
1800, 4956, 4970, 5166, 5152, 2278, 2279, 2293, 2292
1801, 1299, 1300, 1314, 1313, 4957, 4971, 5167, 5153
1802, 4957, 4971, 5167, 5153, 4958, 4972, 5168, 5154
1803, 4958, 4972, 5168, 5154, 4959, 4973, 5169, 5155
1804, 4959, 4973, 5169, 5155, 4960, 4974, 5170, 5156
1805, 4960, 4974, 5170, 5156, 4961, 4975, 5171, 5157
1806, 4961, 4975, 5171, 5157, 4962, 4976, 5172, 5158
1807, 4962, 4976, 5172, 5158, 4963, 4977, 5173, 5159
1808, 4963, 4977, 5173, 5159, 4964, 4978, 5174, 5160
1809, 4964, 4978, 5174, 5160, 4965, 4979, 5175, 5161
1810, 4965, 4979, 5175, 5161, 4966, 4980, 5176, 5162
1811, 4966, 4980, 5176, 5162, 4967, 4981, 5177, 5163
1812, 4967, 4981, 5177, 5163, 4968, 4982, 5178, 5164
1813, 4968, 4982, 5178, 5164, 4969, 4983, 5179, 5165
1814, 4969, 4983, 5179, 5165, 4970, 4984, 5180, 5166
1815, 4970, 4984, 5180, 5166, 2279, 2280, 2294, 2293
1816, 1300, 1301, 1315, 1314, 4971, 4985, 5181, 5167
1817, 4971, 4985, 5181, 5167, 4972, 4986, 5182, 5168
1818, 4972, 4986, 5182, 5168, 4973, 4987, 5183, 5169
1819, 4973, 4987, 5183, 5169, 4974, 4988, 5184, 5170
1820, 4974, 4988, 5184, 5170, 4975, 4989, 5185, 5171
1821, 4975, 4989, 5185, 5171, 4976, 4990, 5186, 5172
1822, 4976, 4990, 5186, 5172, 4977, 4991, 5187, 5173
1823, 4977, 4991, 5187, 5173, 4978, 4992, 5188, 5174
1824, 4978, 4992, 5188, 5174, 4979, 4993, 5189, 5175
1825, 4979, 4993, 5189, 5175, 4980, 4994, 5190, 5176
1826, 4980, 4994, 5190, 5176, 4981, 4995, 5191, 5177
1827, 4981, 4995, 5191, 5177, 4982, 4996, 5192, 5178
1828, 4982, 4996, 5192, 5178, 4983, 4997, 5193, 5179
1829, 4983, 4997, 5193, 5179, 4984, 4998, 5194, 5180
1830, 4984, 4998, 5194, 5180, 2280, 2281, 2295, 2294
1831, 1301, 1302, 1316, 1315, 4985, 4999, 5195, 5181
1832, 4985, 4999, 5195, 5181, 4986, 5000, 5196, 5182
1833, 4986, 5000, 5196, 5182, 4987, 5001, 5197, 5183
1834, 4987, 5001, 5197, 5183, 4988, 5002, 5198, 5184
1835, 4988, 5002, 5198, 5184, 4989, 5003, 5199, 5185
1836, 4989, 5003, 5199, 5185, 4990, 5004, 5200, 5186
1837, 4990, 5004, 5200, 5186, 4991, 5005, 5201, 5187
1838, 4991, 5005, 5201, 5187, 4992, 5006, 5202, 5188
1839, 4992, 5006, 5202, 5188, 4993, 5007, 5203, 5189
1840, 4993, 5007, 5203, 5189, 4994, 5008, 5204, 5190
1841, 4994, 5008, 5204, 5190, 4995, 5009, 5205, 5191
1842, 4995, 5009, 5205, 5191, 4996, 5010, 5206, 5192
1843, 4996, 5010, 5206, 5192, 4997, 5011, 5207, 5193
1844, 4997, 5011, 5207, 5193, 4998, 5012, 5208, 5194
1845, 4998, 5012, 5208, 5194, 2281, 2282, 2296, 2295
1846, 1302, 197, 198, 1316, 4999, 1877, 1891, 5195
1847, 4999, 1877, 1891, 5195, 5000, 1878, 1892, 5196
1848, 5000, 1878, 1892, 5196, 5001, 1879, 1893, 5197
1849, 5001, 1879, 1893, 5197, 5002, 1880, 1894, 5198
1850, 5002, 1880, 1894, 5198, 5003, 1881, 1895, 5199
1851, 5003, 1881, 1895, 5199, 5004, 1882, 1896, 5200
1852, 5004, 1882, 1896, 5200, 5005, 1883, 1897, 5201
1853, 5005, 1883, 1897, 5201, 5006, 1884, 1898, 5202
1854, 5006, 1884, 1898, 5202, 5007, 1885, 1899, 5203
1855, 5007, 1885, 1899, 5203, 5008, 1886, 1900, 5204
1856, 5008, 1886, 1900, 5204, 5009, 1887, 1901, 5205
1857, 5009, 1887, 1901, 5205, 5010, 1888, 1902, 5206
1858, 5010, 1888, 1902, 5206, 5011, 1889, 1903, 5207
1859, 5011, 1889, 1903, 5207, 5012, 1890, 1904, 5208
1860, 5012, 1890, 1904, 5208, 2282, 309, 310, 2296
1861, 170, 1303, 1317, 171, 1499, 5013, 5209, 1513
1862, 1499, 5013, 5209, 1513, 1500, 5014, 5210, 1514
1863, 1500, 5014, 5210, 1514, 1501, 5015, 5211, 1515
1864, 1501, 5015, 5211, 1515, 1502, 5016, 5212, 1516
1865, 1502, 5016, 5212, 1516, 1503, 5017, 5213, 1517
1866, 1503, 5017, 5213, 1517, 1504, 5018, 5214, 1518
1867, 1504, 5018, 5214, 1518, 1505, 5019, 5215, 1519
1868, 1505, 5019, 5215, 1519, 1506, 5020, 5216, 1520
1869, 1506, 5020, 5216, 1520, 1507, 5021, 5217, 1521
1870, 1507, 5021, 5217, 1521, 1508, 5022, 5218, 1522
1871, 1508, 5022, 5218, 1522, 1509, 5023, 5219, 1523
1872, 1509, 5023, 5219, 1523, 1510, 5024, 5220, 1524
1873, 1510, 5024, 5220, 1524, 1511, 5025, 5221, 1525
1874, 1511, 5025, 5221, 1525, 1512, 5026, 5222, 1526
1875, 1512, 5026, 5222, 1526, 254, 2283, 2297, 255
1876, 1303, 1304, 1318, 1317, 5013, 5027, 5223, 5209
1877, 5013, 5027, 5223, 5209, 5014, 5028, 5224, 5210
1878, 5014, 5028, 5224, 5210, 5015, 5029, 5225, 5211
1879, 5015, 5029, 5225, 5211, 5016, 5030, 5226, 5212
1880, 5016, 5030, 5226, 5212, 5017, 5031, 5227, 5213
1881, 5017, 5031, 5227, 5213, 5018, 5032, 5228, 5214
1882, 5018, 5032, 5228, 5214, 5019, 5033, 5229, 5215
1883, 5019, 5033, 5229, 5215, 5020, 5034, 5230, 5216
1884, 5020, 5034, 5230, 5216, 5021, 5035, 5231, 5217
1885, 5021, 5035, 5231, 5217, 5022, 5036, 5232, 5218
1886, 5022, 5036, 5232, 5218, 5023, 5037, 5233, 5219
1887, 5023, 5037, 5233, 5219, 5024, 5038, 5234, 5220
1888, 5024, 5038, 5234, 5220, 5025, 5039, 5235, 5221
1889, 5025, 5039, 5235, 5221, 5026, 5040, 5236, 5222
1890, 5026, 5040, 5236, 5222, 2283, 2284, 2298, 2297
1891, 1304, 1305, 1319, 1318, 5027, 5041, 5237, 5223
1892, 5027, 5041, 5237, 5223, 5028, 5042, 5238, 5224
1893, 5028, 5042, 5238, 5224, 5029, 5043, 5239, 5225
1894, 5029, 5043, 5239, 5225, 5030, 5044, 5240, 5226
1895, 5030, 5044, 5240, 5226, 5031, 5045, 5241, 5227
1896, 5031, 5045, 5241, 5227, 5032, 5046, 5242, 5228
1897, 5032, 5046, 5242, 5228, 5033, 5047, 5243, 5229
1898, 5033, 5047, 5243, 5229, 5034, 5048, 5244, 5230
1899, 5034, 5048, 5244, 5230, 5035, 5049, 5245, 5231
1900, 5035, 5049, 5245, 5231, 5036, 5050, 5246, 5232
1901, 5036, 5050, 5246, 5232, 5037, 5051, 5247, 5233
1902, 5037, 5051, 5247, 5233, 5038, 5052, 5248, 5234
1903, 5038, 5052, 5248, 5234, 5039, 5053, 5249, 5235
1904, 5039, 5053, 5249, 5235, 5040, 5054, 5250, 5236
1905, 5040, 5054, 5250, 5236, 2284, 2285, 2299, 2298
1906, 1305, 1306, 1320, 1319, 5041, 5055, 5251, 5237
1907, 5041, 5055, 5251, 5237, 5042, 5056, 5252, 5238
1908, 5042, 5056, 5252, 5238, 5043, 5057, 5253, 5239
1909, 5043, 5057, 5253, 5239, 5044, 5058, 5254, 5240
1910, 5044, 5058, 5254, 5240, 5045, 5059, 5255, 5241
1911, 5045, 5059, 5255, 5241, 5046, 5060, 5256, 5242
1912, 5046, 5060, 5256, 5242, 5047, 5061, 5257, 5243
1913, 5047, 5061, 5257, 5243, 5048, 5062, 5258, 5244
1914, 5048, 5062, 5258, 5244, 5049, 5063, 5259, 5245
1915, 5049, 5063, 5259, 5245, 5050, 5064, 5260, 5246
1916, 5050, 5064, 5260, 5246, 5051, 5065, 5261, 5247
1917, 5051, 5065, 5261, 5247, 5052, 5066, 5262, 5248
1918, 5052, 5066, 5262, 5248, 5053, 5067, 5263, 5249
1919, 5053, 5067, 5263, 5249, 5054, 5068, 5264, 5250
1920, 5054, 5068, 5264, 5250, 2285, 2286, 2300, 2299
1921, 1306, 1307, 1321, 1320, 5055, 5069, 5265, 5251
1922, 5055, 5069, 5265, 5251, 5056, 5070, 5266, 5252
1923, 5056, 5070, 5266, 5252, 5057, 5071, 5267, 5253
1924, 5057, 5071, 5267, 5253, 5058, 5072, 5268, 5254
1925, 5058, 5072, 5268, 5254, 5059, 5073, 5269, 5255
1926, 5059, 5073, 5269, 5255, 5060, 5074, 5270, 5256
1927, 5060, 5074, 5270, 5256, 5061, 5075, 5271, 5257
1928, 5061, 5075, 5271, 5257, 5062, 5076, 5272, 5258
1929, 5062, 5076, 5272, 5258, 5063, 5077, 5273, 5259
1930, 5063, 5077, 5273, 5259, 5064, 5078, 5274, 5260
1931, 5064, 5078, 5274, 5260, 5065, 5079, 5275, 5261
1932, 5065, 5079, 5275, 5261, 5066, 5080, 5276, 5262
1933, 5066, 5080, 5276, 5262, 5067, 5081, 5277, 5263
1934, 5067, 5081, 5277, 5263, 5068, 5082, 5278, 5264
1935, 5068, 5082, 5278, 5264, 2286, 2287, 2301, 2300
1936, 1307, 1308, 1322, 1321, 5069, 5083, 5279, 5265
1937, 5069, 5083, 5279, 5265, 5070, 5084, 5280, 5266
1938, 5070, 5084, 5280, 5266, 5071, 5085, 5281, 5267
1939, 5071, 5085, 5281, 5267, 5072, 5086, 5282, 5268
1940, 5072, 5086, 5282, 5268, 5073, 5087, 5283, 5269
1941, 5073, 5087, 5283, 5269, 5074, 5088, 5284, 5270
1942, 5074, 5088, 5284, 5270, 5075, 5089, 5285, 5271
1943, 5075, 5089, 5285, 5271, 5076, 5090, 5286, 5272
1944, 5076, 5090, 5286, 5272, 5077, 5091, 5287, 5273
1945, 5077, 5091, 5287, 5273, 5078, 5092, 5288, 5274
1946, 5078, 5092, 5288, 5274, 5079, 5093, 5289, 5275
1947, 5079, 5093, 5289, 5275, 5080, 5094, 5290, 5276
1948, 5080, 5094, 5290, 5276, 5081, 5095, 5291, 5277
1949, 5081, 5095, 5291, 5277, 5082, 5096, 5292, 5278
1950, 5082, 5096, 5292, 5278, 2287, 2288, 2302, 2301
1951, 1308, 1309, 1323, 1322, 5083, 5097, 5293, 5279
1952, 5083, 5097, 5293, 5279, 5084, 5098, 5294, 5280
1953, 5084, 5098, 5294, 5280, 5085, 5099, 5295, 5281
1954, 5085, 5099, 5295, 5281, 5086, 5100, 5296, 5282
1955, 5086, 5100, 5296, 5282, 5087, 5101, 5297, 5283
1956, 5087, 5101, 5297, 5283, 5088, 5102, 5298, 5284
1957, 5088, 5102, 5298, 5284, 5089, 5103, 5299, 5285
1958, 5089, 5103, 5299, 5285, 5090, 5104, 5300, 5286
1959, 5090, 5104, 5300, 5286, 5091, 5105, 5301, 5287
1960, 5091, 5105, 5301, 5287, 5092, 5106, 5302, 5288
1961, 5092, 5106, 5302, 5288, 5093, 5107, 5303, 5289
1962, 5093, 5107, 5303, 5289, 5094, 5108, 5304, 5290
1963, 5094, 5108, 5304, 5290, 5095, 5109, 5305, 5291
1964, 5095, 5109, 5305, 5291, 5096, 5110, 5306, 5292
1965, 5096, 5110, 5306, 5292, 2288, 2289, 2303, 2302
1966, 1309, 1310, 1324, 1323, 5097, 5111, 5307, 5293
1967, 5097, 5111, 5307, 5293, 5098, 5112, 5308, 5294
1968, 5098, 5112, 5308, 5294, 5099, 5113, 5309, 5295
1969, 5099, 5113, 5309, 5295, 5100, 5114, 5310, 5296
1970, 5100, 5114, 5310, 5296, 5101, 5115, 5311, 5297
1971, 5101, 5115, 5311, 5297, 5102, 5116, 5312, 5298
1972, 5102, 5116, 5312, 5298, 5103, 5117, 5313, 5299
1973, 5103, 5117, 5313, 5299, 5104, 5118, 5314, 5300
1974, 5104, 5118, 5314, 5300, 5105, 5119, 5315, 5301
1975, 5105, 5119, 5315, 5301, 5106, 5120, 5316, 5302
1976, 5106, 5120, 5316, 5302, 5107, 5121, 5317, 5303
1977, 5107, 5121, 5317, 5303, 5108, 5122, 5318, 5304
1978, 5108, 5122, 5318, 5304, 5109, 5123, 5319, 5305
1979, 5109, 5123, 5319, 5305, 5110, 5124, 5320, 5306
1980, 5110, 5124, 5320, 5306, 2289, 2290, 2304, 2303
1981, 1310, 1311, 1325, 1324, 5111, 5125, 5321, 5307
1982, 5111, 5125, 5321, 5307, 5112, 5126, 5322, 5308
1983, 5112, 5126, 5322, 5308, 5113, 5127, 5323, 5309
1984, 5113, 5127, 5323, 5309, 5114, 5128, 5324, 5310
1985, 5114, 5128, 5324, 5310, 5115, 5129, 5325, 5311
1986, 5115, 5129, 5325, 5311, 5116, 5130, 5326, 5312
1987, 5116, 5130, 5326, 5312, 5117, 5131, 5327, 5313
1988, 5117, 5131, 5327, 5313, 5118, 5132, 5328, 5314
1989, 5118, 5132, 5328, 5314, 5119, 5133, 5329, 5315
1990, 5119, 5133, 5329, 5315, 5120, 5134, 5330, 5316
1991, 5120, 5134, 5330, 5316, 5121, 5135, 5331, 5317
1992, 5121, 5135, 5331, 5317, 5122, 5136, 5332, 5318
1993, 5122, 5136, 5332, 5318, 5123, 5137, 5333, 5319
1994, 5123, 5137, 5333, 5319, 5124, 5138, 5334, 5320
1995, 5124, 5138, 5334, 5320, 2290, 2291, 2305, 2304
1996, 1311, 1312, 1326, 1325, 5125, 5139, 5335, 5321
1997, 5125, 5139, 5335, 5321, 5126, 5140, 5336, 5322
1998, 5126, 5140, 5336, 5322, 5127, 5141, 5337, 5323
1999, 5127, 5141, 5337, 5323, 5128, 5142, 5338, 5324
2000, 5128, 5142, 5338, 5324, 5129, 5143, 5339, 5325
2001, 5129, 5143, 5339, 5325, 5130, 5144, 5340, 5326
2002, 5130, 5144, 5340, 5326, 5131, 5145, 5341, 5327
2003, 5131, 5145, 5341, 5327, 5132, 5146, 5342, 5328
2004, 5132, 5146, 5342, 5328, 5133, 5147, 5343, 5329
2005, 5133, 5147, 5343, 5329, 5134, 5148, 5344, 5330
2006, 5134, 5148, 5344, 5330, 5135, 5149, 5345, 5331
2007, 5135, 5149, 5345, 5331, 5136, 5150, 5346, 5332
2008, 5136, 5150, 5346, 5332, 5137, 5151, 5347, 5333
2009, 5137, 5151, 5347, 5333, 5138, 5152, 5348, 5334
2010, 5138, 5152, 5348, 5334, 2291, 2292, 2306, 2305
2011, 1312, 1313, 1327, 1326, 5139, 5153, 5349, 5335
2012, 5139, 5153, 5349, 5335, 5140, 5154, 5350, 5336
2013, 5140, 5154, 5350, 5336, 5141, 5155, 5351, 5337
2014, 5141, 5155, 5351, 5337, 5142, 5156, 5352, 5338
2015, 5142, 5156, 5352, 5338, 5143, 5157, 5353, 5339
2016, 5143, 5157, 5353, 5339, 5144, 5158, 5354, 5340
2017, 5144, 5158, 5354, 5340, 5145, 5159, 5355, 5341
2018, 5145, 5159, 5355, 5341, 5146, 5160, 5356, 5342
2019, 5146, 5160, 5356, 5342, 5147, 5161, 5357, 5343
2020, 5147, 5161, 5357, 5343, 5148, 5162, 5358, 5344
2021, 5148, 5162, 5358, 5344, 5149, 5163, 5359, 5345
2022, 5149, 5163, 5359, 5345, 5150, 5164, 5360, 5346
2023, 5150, 5164, 5360, 5346, 5151, 5165, 5361, 5347
2024, 5151, 5165, 5361, 5347, 5152, 5166, 5362, 5348
2025, 5152, 5166, 5362, 5348, 2292, 2293, 2307, 2306
2026, 1313, 1314, 1328, 1327, 5153, 5167, 5363, 5349
2027, 5153, 5167, 5363, 5349, 5154, 5168, 5364, 5350
2028, 5154, 5168, 5364, 5350, 5155, 5169, 5365, 5351
2029, 5155, 5169, 5365, 5351, 5156, 5170, 5366, 5352
2030, 5156, 5170, 5366, 5352, 5157, 5171, 5367, 5353
2031, 5157, 5171, 5367, 5353, 5158, 5172, 5368, 5354
2032, 5158, 5172, 5368, 5354, 5159, 5173, 5369, 5355
2033, 5159, 5173, 5369, 5355, 5160, 5174, 5370, 5356
2034, 5160, 5174, 5370, 5356, 5161, 5175, 5371, 5357
2035, 5161, 5175, 5371, 5357, 5162, 5176, 5372, 5358
2036, 5162, 5176, 5372, 5358, 5163, 5177, 5373, 5359
2037, 5163, 5177, 5373, 5359, 5164, 5178, 5374, 5360
2038, 5164, 5178, 5374, 5360, 5165, 5179, 5375, 5361
2039, 5165, 5179, 5375, 5361, 5166, 5180, 5376, 5362
2040, 5166, 5180, 5376, 5362, 2293, 2294, 2308, 2307
2041, 1314, 1315, 1329, 1328, 5167, 5181, 5377, 5363
2042, 5167, 5181, 5377, 5363, 5168, 5182, 5378, 5364
2043, 5168, 5182, 5378, 5364, 5169, 5183, 5379, 5365
2044, 5169, 5183, 5379, 5365, 5170, 5184, 5380, 5366
2045, 5170, 5184, 5380, 5366, 5171, 5185, 5381, 5367
2046, 5171, 5185, 5381, 5367, 5172, 5186, 5382, 5368
2047, 5172, 5186, 5382, 5368, 5173, 5187, 5383, 5369
2048, 5173, 5187, 5383, 5369, 5174, 5188, 5384, 5370
2049, 5174, 5188, 5384, 5370, 5175, 5189, 5385, 5371
2050, 5175, 5189, 5385, 5371, 5176, 5190, 5386, 5372
2051, 5176, 5190, 5386, 5372, 5177, 5191, 5387, 5373
2052, 5177, 5191, 5387, 5373, 5178, 5192, 5388, 5374
2053, 5178, 5192, 5388, 5374, 5179, 5193, 5389, 5375
2054, 5179, 5193, 5389, 5375, 5180, 5194, 5390, 5376
2055, 5180, 5194, 5390, 5376, 2294, 2295, 2309, 2308
2056, 1315, 1316, 1330, 1329, 5181, 5195, 5391, 5377
2057, 5181, 5195, 5391, 5377, 5182, 5196, 5392, 5378
2058, 5182, 5196, 5392, 5378, 5183, 5197, 5393, 5379
2059, 5183, 5197, 5393, 5379, 5184, 5198, 5394, 5380
2060, 5184, 5198, 5394, 5380, 5185, 5199, 5395, 5381
2061, 5185, 5199, 5395, 5381, 5186, 5200, 5396, 5382
2062, 5186, 5200, 5396, 5382, 5187, 5201, 5397, 5383
2063, 5187, 5201, 5397, 5383, 5188, 5202, 5398, 5384
2064, 5188, 5202, 5398, 5384, 5189, 5203, 5399, 5385
2065, 5189, 5203, 5399, 5385, 5190, 5204, 5400, 5386
2066, 5190, 5204, 5400, 5386, 5191, 5205, 5401, 5387
2067, 5191, 5205, 5401, 5387, 5192, 5206, 5402, 5388
2068, 5192, 5206, 5402, 5388, 5193, 5207, 5403, 5389
2069, 5193, 5207, 5403, 5389, 5194, 5208, 5404, 5390
2070, 5194, 5208, 5404, 5390, 2295, 2296, 2310, 2309
2071, 1316, 198, 199, 1330, 5195, 1891, 1905, 5391
2072, 5195, 1891, 1905, 5391, 5196, 1892, 1906, 5392
2073, 5196, 1892, 1906, 5392, 5197, 1893, 1907, 5393
2074, 5197, 1893, 1907, 5393, 5198, 1894, 1908, 5394
2075, 5198, 1894, 1908, 5394, 5199, 1895, 1909, 5395
2076, 5199, 1895, 1909, 5395, 5200, 1896, 1910, 5396
2077, 5200, 1896, 1910, 5396, 5201, 1897, 1911, 5397
2078, 5201, 1897, 1911, 5397, 5202, 1898, 1912, 5398
2079, 5202, 1898, 1912, 5398, 5203, 1899, 1913, 5399
2080, 5203, 1899, 1913, 5399, 5204, 1900, 1914, 5400
2081, 5204, 1900, 1914, 5400, 5205, 1901, 1915, 5401
2082, 5205, 1901, 1915, 5401, 5206, 1902, 1916, 5402
2083, 5206, 1902, 1916, 5402, 5207, 1903, 1917, 5403
2084, 5207, 1903, 1917, 5403, 5208, 1904, 1918, 5404
2085, 5208, 1904, 1918, 5404, 2296, 310, 311, 2310
2086, 171, 1317, 1331, 172, 1513, 5209, 5405, 1527
2087, 1513, 5209, 5405, 1527, 1514, 5210, 5406, 1528
2088, 1514, 5210, 5406, 1528, 1515, 5211, 5407, 1529
2089, 1515, 5211, 5407, 1529, 1516, 5212, 5408, 1530
2090, 1516, 5212, 5408, 1530, 1517, 5213, 5409, 1531
2091, 1517, 5213, 5409, 1531, 1518, 5214, 5410, 1532
2092, 1518, 5214, 5410, 1532, 1519, 5215, 5411, 1533
2093, 1519, 5215, 5411, 1533, 1520, 5216, 5412, 1534
2094, 1520, 5216, 5412, 1534, 1521, 5217, 5413, 1535
2095, 1521, 5217, 5413, 1535, 1522, 5218, 5414, 1536
2096, 1522, 5218, 5414, 1536, 1523, 5219, 5415, 1537
2097, 1523, 5219, 5415, 1537, 1524, 5220, 5416, 1538
2098, 1524, 5220, 5416, 1538, 1525, 5221, 5417, 1539
2099, 1525, 5221, 5417, 1539, 1526, 5222, 5418, 1540
2100, 1526, 5222, 5418, 1540, 255, 2297, 2311, 256
2101, 1317, 1318, 1332, 1331, 5209, 5223, 5419, 5405
2102, 5209, 5223, 5419, 5405, 5210, 5224, 5420, 5406
2103, 5210, 5224, 5420, 5406, 5211, 5225, 5421, 5407
2104, 5211, 5225, 5421, 5407, 5212, 5226, 5422, 5408
2105, 5212, 5226, 5422, 5408, 5213, 5227, 5423, 5409
2106, 5213, 5227, 5423, 5409, 5214, 5228, 5424, 5410
2107, 5214, 5228, 5424, 5410, 5215, 5229, 5425, 5411
2108, 5215, 5229, 5425, 5411, 5216, 5230, 5426, 5412
2109, 5216, 5230, 5426, 5412, 5217, 5231, 5427, 5413
2110, 5217, 5231, 5427, 5413, 5218, 5232, 5428, 5414
2111, 5218, 5232, 5428, 5414, 5219, 5233, 5429, 5415
2112, 5219, 5233, 5429, 5415, 5220, 5234, 5430, 5416
2113, 5220, 5234, 5430, 5416, 5221, 5235, 5431, 5417
2114, 5221, 5235, 5431, 5417, 5222, 5236, 5432, 5418
2115, 5222, 5236, 5432, 5418, 2297, 2298, 2312, 2311
2116, 1318, 1319, 1333, 1332, 5223, 5237, 5433, 5419
2117, 5223, 5237, 5433, 5419, 5224, 5238, 5434, 5420
2118, 5224, 5238, 5434, 5420, 5225, 5239, 5435, 5421
2119, 5225, 5239, 5435, 5421, 5226, 5240, 5436, 5422
2120, 5226, 5240, 5436, 5422, 5227, 5241, 5437, 5423
2121, 5227, 5241, 5437, 5423, 5228, 5242, 5438, 5424
2122, 5228, 5242, 5438, 5424, 5229, 5243, 5439, 5425
2123, 5229, 5243, 5439, 5425, 5230, 5244, 5440, 5426
2124, 5230, 5244, 5440, 5426, 5231, 5245, 5441, 5427
2125, 5231, 5245, 5441, 5427, 5232, 5246, 5442, 5428
2126, 5232, 5246, 5442, 5428, 5233, 5247, 5443, 5429
2127, 5233, 5247, 5443, 5429, 5234, 5248, 5444, 5430
2128, 5234, 5248, 5444, 5430, 5235, 5249, 5445, 5431
2129, 5235, 5249, 5445, 5431, 5236, 5250, 5446, 5432
2130, 5236, 5250, 5446, 5432, 2298, 2299, 2313, 2312
2131, 1319, 1320, 1334, 1333, 5237, 5251, 5447, 5433
2132, 5237, 5251, 5447, 5433, 5238, 5252, 5448, 5434
2133, 5238, 5252, 5448, 5434, 5239, 5253, 5449, 5435
2134, 5239, 5253, 5449, 5435, 5240, 5254, 5450, 5436
2135, 5240, 5254, 5450, 5436, 5241, 5255, 5451, 5437
2136, 5241, 5255, 5451, 5437, 5242, 5256, 5452, 5438
2137, 5242, 5256, 5452, 5438, 5243, 5257, 5453, 5439
2138, 5243, 5257, 5453, 5439, 5244, 5258, 5454, 5440
2139, 5244, 5258, 5454, 5440, 5245, 5259, 5455, 5441
2140, 5245, 5259, 5455, 5441, 5246, 5260, 5456, 5442
2141, 5246, 5260, 5456, 5442, 5247, 5261, 5457, 5443
2142, 5247, 5261, 5457, 5443, 5248, 5262, 5458, 5444
2143, 5248, 5262, 5458, 5444, 5249, 5263, 5459, 5445
2144, 5249, 5263, 5459, 5445, 5250, 5264, 5460, 5446
2145, 5250, 5264, 5460, 5446, 2299, 2300, 2314, 2313
2146, 1320, 1321, 1335, 1334, 5251, 5265, 5461, 5447
2147, 5251, 5265, 5461, 5447, 5252, 5266, 5462, 5448
2148, 5252, 5266, 5462, 5448, 5253, 5267, 5463, 5449
2149, 5253, 5267, 5463, 5449, 5254, 5268, 5464, 5450
2150, 5254, 5268, 5464, 5450, 5255, 5269, 5465, 5451
2151, 5255, 5269, 5465, 5451, 5256, 5270, 5466, 5452
2152, 5256, 5270, 5466, 5452, 5257, 5271, 5467, 5453
2153, 5257, 5271, 5467, 5453, 5258, 5272, 5468, 5454
2154, 5258, 5272, 5468, 5454, 5259, 5273, 5469, 5455
2155, 5259, 5273, 5469, 5455, 5260, 5274, 5470, 5456
2156, 5260, 5274, 5470, 5456, 5261, 5275, 5471, 5457
2157, 5261, 5275, 5471, 5457, 5262, 5276, 5472, 5458
2158, 5262, 5276, 5472, 5458, 5263, 5277, 5473, 5459
2159, 5263, 5277, 5473, 5459, 5264, 5278, 5474, 5460
2160, 5264, 5278, 5474, 5460, 2300, 2301, 2315, 2314
2161, 1321, 1322, 1336, 1335, 5265, 5279, 5475, 5461
2162, 5265, 5279, 5475, 5461, 5266, 5280, 5476, 5462
2163, 5266, 5280, 5476, 5462, 5267, 5281, 5477, 5463
2164, 5267, 5281, 5477, 5463, 5268, 5282, 5478, 5464
2165, 5268, 5282, 5478, 5464, 5269, 5283, 5479, 5465
2166, 5269, 5283, 5479, 5465, 5270, 5284, 5480, 5466
2167, 5270, 5284, 5480, 5466, 5271, 5285, 5481, 5467
2168, 5271, 5285, 5481, 5467, 5272, 5286, 5482, 5468
2169, 5272, 5286, 5482, 5468, 5273, 5287, 5483, 5469
2170, 5273, 5287, 5483, 5469, 5274, 5288, 5484, 5470
2171, 5274, 5288, 5484, 5470, 5275, 5289, 5485, 5471
2172, 5275, 5289, 5485, 5471, 5276, 5290, 5486, 5472
2173, 5276, 5290, 5486, 5472, 5277, 5291, 5487, 5473
2174, 5277, 5291, 5487, 5473, 5278, 5292, 5488, 5474
2175, 5278, 5292, 5488, 5474, 2301, 2302, 2316, 2315
2176, 1322, 1323, 1337, 1336, 5279, 5293, 5489, 5475
2177, 5279, 5293, 5489, 5475, 5280, 5294, 5490, 5476
2178, 5280, 5294, 5490, 5476, 5281, 5295, 5491, 5477
2179, 5281, 5295, 5491, 5477, 5282, 5296, 5492, 5478
2180, 5282, 5296, 5492, 5478, 5283, 5297, 5493, 5479
2181, 5283, 5297, 5493, 5479, 5284, 5298, 5494, 5480
2182, 5284, 5298, 5494, 5480, 5285, 5299, 5495, 5481
2183, 5285, 5299, 5495, 5481, 5286, 5300, 5496, 5482
2184, 5286, 5300, 5496, 5482, 5287, 5301, 5497, 5483
2185, 5287, 5301, 5497, 5483, 5288, 5302, 5498, 5484
2186, 5288, 5302, 5498, 5484, 5289, 5303, 5499, 5485
2187, 5289, 5303, 5499, 5485, 5290, 5304, 5500, 5486
2188, 5290, 5304, 5500, 5486, 5291, 5305, 5501, 5487
2189, 5291, 5305, 5501, 5487, 5292, 5306, 5502, 5488
2190, 5292, 5306, 5502, 5488, 2302, 2303, 2317, 2316
2191, 1323, 1324, 1338, 1337, 5293, 5307, 5503, 5489
2192, 5293, 5307, 5503, 5489, 5294, 5308, 5504, 5490
2193, 5294, 5308, 5504, 5490, 5295, 5309, 5505, 5491
2194, 5295, 5309, 5505, 5491, 5296, 5310, 5506, 5492
2195, 5296, 5310, 5506, 5492, 5297, 5311, 5507, 5493
2196, 5297, 5311, 5507, 5493, 5298, 5312, 5508, 5494
2197, 5298, 5312, 5508, 5494, 5299, 5313, 5509, 5495
2198, 5299, 5313, 5509, 5495, 5300, 5314, 5510, 5496
2199, 5300, 5314, 5510, 5496, 5301, 5315, 5511, 5497
2200, 5301, 5315, 5511, 5497, 5302, 5316, 5512, 5498
2201, 5302, 5316, 5512, 5498, 5303, 5317, 5513, 5499
2202, 5303, 5317, 5513, 5499, 5304, 5318, 5514, 5500
2203, 5304, 5318, 5514, 5500, 5305, 5319, 5515, 5501
2204, 5305, 5319, 5515, 5501, 5306, 5320, 5516, 5502
2205, 5306, 5320, 5516, 5502, 2303, 2304, 2318, 2317
2206, 1324, 1325, 1339, 1338, 5307, 5321, 5517, 5503
2207, 5307, 5321, 5517, 5503, 5308, 5322, 5518, 5504
2208, 5308, 5322, 5518, 5504, 5309, 5323, 5519, 5505
2209, 5309, 5323, 5519, 5505, 5310, 5324, 5520, 5506
2210, 5310, 5324, 5520, 5506, 5311, 5325, 5521, 5507
2211, 5311, 5325, 5521, 5507, 5312, 5326, 5522, 5508
2212, 5312, 5326, 5522, 5508, 5313, 5327, 5523, 5509
2213, 5313, 5327, 5523, 5509, 5314, 5328, 5524, 5510
2214, 5314, 5328, 5524, 5510, 5315, 5329, 5525, 5511
2215, 5315, 5329, 5525, 5511, 5316, 5330, 5526, 5512
2216, 5316, 5330, 5526, 5512, 5317, 5331, 5527, 5513
2217, 5317, 5331, 5527, 5513, 5318, 5332, 5528, 5514
2218, 5318, 5332, 5528, 5514, 5319, 5333, 5529, 5515
2219, 5319, 5333, 5529, 5515, 5320, 5334, 5530, 5516
2220, 5320, 5334, 5530, 5516, 2304, 2305, 2319, 2318
2221, 1325, 1326, 1340, 1339, 5321, 5335, 5531, 5517
2222, 5321, 5335, 5531, 5517, 5322, 5336, 5532, 5518
2223, 5322, 5336, 5532, 5518, 5323, 5337, 5533, 5519
2224, 5323, 5337, 5533, 5519, 5324, 5338, 5534, 5520
2225, 5324, 5338, 5534, 5520, 5325, 5339, 5535, 5521
2226, 5325, 5339, 5535, 5521, 5326, 5340, 5536, 5522
2227, 5326, 5340, 5536, 5522, 5327, 5341, 5537, 5523
2228, 5327, 5341, 5537, 5523, 5328, 5342, 5538, 5524
2229, 5328, 5342, 5538, 5524, 5329, 5343, 5539, 5525
2230, 5329, 5343, 5539, 5525, 5330, 5344, 5540, 5526
2231, 5330, 5344, 5540, 5526, 5331, 5345, 5541, 5527
2232, 5331, 5345, 5541, 5527, 5332, 5346, 5542, 5528
2233, 5332, 5346, 5542, 5528, 5333, 5347, 5543, 5529
2234, 5333, 5347, 5543, 5529, 5334, 5348, 5544, 5530
2235, 5334, 5348, 5544, 5530, 2305, 2306, 2320, 2319
2236, 1326, 1327, 1341, 1340, 5335, 5349, 5545, 5531
2237, 5335, 5349, 5545, 5531, 5336, 5350, 5546, 5532
2238, 5336, 5350, 5546, 5532, 5337, 5351, 5547, 5533
2239, 5337, 5351, 5547, 5533, 5338, 5352, 5548, 5534
2240, 5338, 5352, 5548, 5534, 5339, 5353, 5549, 5535
2241, 5339, 5353, 5549, 5535, 5340, 5354, 5550, 5536
2242, 5340, 5354, 5550, 5536, 5341, 5355, 5551, 5537
2243, 5341, 5355, 5551, 5537, 5342, 5356, 5552, 5538
2244, 5342, 5356, 5552, 5538, 5343, 5357, 5553, 5539
2245, 5343, 5357, 5553, 5539, 5344, 5358, 5554, 5540
2246, 5344, 5358, 5554, 5540, 5345, 5359, 5555, 5541
2247, 5345, 5359, 5555, 5541, 5346, 5360, 5556, 5542
2248, 5346, 5360, 5556, 5542, 5347, 5361, 5557, 5543
2249, 5347, 5361, 5557, 5543, 5348, 5362, 5558, 5544
2250, 5348, 5362, 5558, 5544, 2306, 2307, 2321, 2320
2251, 1327, 1328, 1342, 1341, 5349, 5363, 5559, 5545
2252, 5349, 5363, 5559, 5545, 5350, 5364, 5560, 5546
2253, 5350, 5364, 5560, 5546, 5351, 5365, 5561, 5547
2254, 5351, 5365, 5561, 5547, 5352, 5366, 5562, 5548
2255, 5352, 5366, 5562, 5548, 5353, 5367, 5563, 5549
2256, 5353, 5367, 5563, 5549, 5354, 5368, 5564, 5550
2257, 5354, 5368, 5564, 5550, 5355, 5369, 5565, 5551
2258, 5355, 5369, 5565, 5551, 5356, 5370, 5566, 5552
2259, 5356, 5370, 5566, 5552, 5357, 5371, 5567, 5553
2260, 5357, 5371, 5567, 5553, 5358, 5372, 5568, 5554
2261, 5358, 5372, 5568, 5554, 5359, 5373, 5569, 5555
2262, 5359, 5373, 5569, 5555, 5360, 5374, 5570, 5556
2263, 5360, 5374, 5570, 5556, 5361, 5375, 5571, 5557
2264, 5361, 5375, 5571, 5557, 5362, 5376, 5572, 5558
2265, 5362, 5376, 5572, 5558, 2307, 2308, 2322, 2321
2266, 1328, 1329, 1343, 1342, 5363, 5377, 5573, 5559
2267, 5363, 5377, 5573, 5559, 5364, 5378, 5574, 5560
2268, 5364, 5378, 5574, 5560, 5365, 5379, 5575, 5561
2269, 5365, 5379, 5575, 5561, 5366, 5380, 5576, 5562
2270, 5366, 5380, 5576, 5562, 5367, 5381, 5577, 5563
2271, 5367, 5381, 5577, 5563, 5368, 5382, 5578, 5564
2272, 5368, 5382, 5578, 5564, 5369, 5383, 5579, 5565
2273, 5369, 5383, 5579, 5565, 5370, 5384, 5580, 5566
2274, 5370, 5384, 5580, 5566, 5371, 5385, 5581, 5567
2275, 5371, 5385, 5581, 5567, 5372, 5386, 5582, 5568
2276, 5372, 5386, 5582, 5568, 5373, 5387, 5583, 5569
2277, 5373, 5387, 5583, 5569, 5374, 5388, 5584, 5570
2278, 5374, 5388, 5584, 5570, 5375, 5389, 5585, 5571
2279, 5375, 5389, 5585, 5571, 5376, 5390, 5586, 5572
2280, 5376, 5390, 5586, 5572, 2308, 2309, 2323, 2322
2281, 1329, 1330, 1344, 1343, 5377, 5391, 5587, 5573
2282, 5377, 5391, 5587, 5573, 5378, 5392, 5588, 5574
2283, 5378, 5392, 5588, 5574, 5379, 5393, 5589, 5575
2284, 5379, 5393, 5589, 5575, 5380, 5394, 5590, 5576
2285, 5380, 5394, 5590, 5576, 5381, 5395, 5591, 5577
2286, 5381, 5395, 5591, 5577, 5382, 5396, 5592, 5578
2287, 5382, 5396, 5592, 5578, 5383, 5397, 5593, 5579
2288, 5383, 5397, 5593, 5579, 5384, 5398, 5594, 5580
2289, 5384, 5398, 5594, 5580, 5385, 5399, 5595, 5581
2290, 5385, 5399, 5595, 5581, 5386, 5400, 5596, 5582
2291, 5386, 5400, 5596, 5582, 5387, 5401, 5597, 5583
2292, 5387, 5401, 5597, 5583, 5388, 5402, 5598, 5584
2293, 5388, 5402, 5598, 5584, 5389, 5403, 5599, 5585
2294, 5389, 5403, 5599, 5585, 5390, 5404, 5600, 5586
2295, 5390, 5404, 5600, 5586, 2309, 2310, 2324, 2323
2296, 1330, 199, 200, 1344, 5391, 1905, 1919, 5587
2297, 5391, 1905, 1919, 5587, 5392, 1906, 1920, 5588
2298, 5392, 1906, 1920, 5588, 5393, 1907, 1921, 5589
2299, 5393, 1907, 1921, 5589, 5394, 1908, 1922, 5590
2300, 5394, 1908, 1922, 5590, 5395, 1909, 1923, 5591
2301, 5395, 1909, 1923, 5591, 5396, 1910, 1924, 5592
2302, 5396, 1910, 1924, 5592, 5397, 1911, 1925, 5593
2303, 5397, 1911, 1925, 5593, 5398, 1912, 1926, 5594
2304, 5398, 1912, 1926, 5594, 5399, 1913, 1927, 5595
2305, 5399, 1913, 1927, 5595, 5400, 1914, 1928, 5596
2306, 5400, 1914, 1928, 5596, 5401, 1915, 1929, 5597
2307, 5401, 1915, 1929, 5597, 5402, 1916, 1930, 5598
2308, 5402, 1916, 1930, 5598, 5403, 1917, 1931, 5599
2309, 5403, 1917, 1931, 5599, 5404, 1918, 1932, 5600
2310, 5404, 1918, 1932, 5600, 2310, 311, 312, 2324
2311, 172, 1331, 1345, 173, 1527, 5405, 5601, 1541
2312, 1527, 5405, 5601, 1541, 1528, 5406, 5602, 1542
2313, 1528, 5406, 5602, 1542, 1529, 5407, 5603, 1543
2314, 1529, 5407, 5603, 1543, 1530, 5408, 5604, 1544
2315, 1530, 5408, 5604, 1544, 1531, 5409, 5605, 1545
2316, 1531, 5409, 5605, 1545, 1532, 5410, 5606, 1546
2317, 1532, 5410, 5606, 1546, 1533, 5411, 5607, 1547
2318, 1533, 5411, 5607, 1547, 1534, 5412, 5608, 1548
2319, 1534, 5412, 5608, 1548, 1535, 5413, 5609, 1549
2320, 1535, 5413, 5609, 1549, 1536, 5414, 5610, 1550
2321, 1536, 5414, 5610, 1550, 1537, 5415, 5611, 1551
2322, 1537, 5415, 5611, 1551, 1538, 5416, 5612, 1552
2323, 1538, 5416, 5612, 1552, 1539, 5417, 5613, 1553
2324, 1539, 5417, 5613, 1553, 1540, 5418, 5614, 1554
2325, 1540, 5418, 5614, 1554, 256, 2311, 2325, 257
2326, 1331, 1332, 1346, 1345, 5405, 5419, 5615, 5601
2327, 5405, 5419, 5615, 5601, 5406, 5420, 5616, 5602
2328, 5406, 5420, 5616, 5602, 5407, 5421, 5617, 5603
2329, 5407, 5421, 5617, 5603, 5408, 5422, 5618, 5604
2330, 5408, 5422, 5618, 5604, 5409, 5423, 5619, 5605
2331, 5409, 5423, 5619, 5605, 5410, 5424, 5620, 5606
2332, 5410, 5424, 5620, 5606, 5411, 5425, 5621, 5607
2333, 5411, 5425, 5621, 5607, 5412, 5426, 5622, 5608
2334, 5412, 5426, 5622, 5608, 5413, 5427, 5623, 5609
2335, 5413, 5427, 5623, 5609, 5414, 5428, 5624, 5610
2336, 5414, 5428, 5624, 5610, 5415, 5429, 5625, 5611
2337, 5415, 5429, 5625, 5611, 5416, 5430, 5626, 5612
2338, 5416, 5430, 5626, 5612, 5417, 5431, 5627, 5613
2339, 5417, 5431, 5627, 5613, 5418, 5432, 5628, 5614
2340, 5418, 5432, 5628, 5614, 2311, 2312, 2326, 2325
2341, 1332, 1333, 1347, 1346, 5419, 5433, 5629, 5615
2342, 5419, 5433, 5629, 5615, 5420, 5434, 5630, 5616
2343, 5420, 5434, 5630, 5616, 5421, 5435, 5631, 5617
2344, 5421, 5435, 5631, 5617, 5422, 5436, 5632, 5618
2345, 5422, 5436, 5632, 5618, 5423, 5437, 5633, 5619
2346, 5423, 5437, 5633, 5619, 5424, 5438, 5634, 5620
2347, 5424, 5438, 5634, 5620, 5425, 5439, 5635, 5621
2348, 5425, 5439, 5635, 5621, 5426, 5440, 5636, 5622
2349, 5426, 5440, 5636, 5622, 5427, 5441, 5637, 5623
2350, 5427, 5441, 5637, 5623, 5428, 5442, 5638, 5624
2351, 5428, 5442, 5638, 5624, 5429, 5443, 5639, 5625
2352, 5429, 5443, 5639, 5625, 5430, 5444, 5640, 5626
2353, 5430, 5444, 5640, 5626, 5431, 5445, 5641, 5627
2354, 5431, 5445, 5641, 5627, 5432, 5446, 5642, 5628
2355, 5432, 5446, 5642, 5628, 2312, 2313, 2327, 2326
2356, 1333, 1334, 1348, 1347, 5433, 5447, 5643, 5629
2357, 5433, 5447, 5643, 5629, 5434, 5448, 5644, 5630
2358, 5434, 5448, 5644, 5630, 5435, 5449, 5645, 5631
2359, 5435, 5449, 5645, 5631, 5436, 5450, 5646, 5632
2360, 5436, 5450, 5646, 5632, 5437, 5451, 5647, 5633
2361, 5437, 5451, 5647, 5633, 5438, 5452, 5648, 5634
2362, 5438, 5452, 5648, 5634, 5439, 5453, 5649, 5635
2363, 5439, 5453, 5649, 5635, 5440, 5454, 5650, 5636
2364, 5440, 5454, 5650, 5636, 5441, 5455, 5651, 5637
2365, 5441, 5455, 5651, 5637, 5442, 5456, 5652, 5638
2366, 5442, 5456, 5652, 5638, 5443, 5457, 5653, 5639
2367, 5443, 5457, 5653, 5639, 5444, 5458, 5654, 5640
2368, 5444, 5458, 5654, 5640, 5445, 5459, 5655, 5641
2369, 5445, 5459, 5655, 5641, 5446, 5460, 5656, 5642
2370, 5446, 5460, 5656, 5642, 2313, 2314, 2328, 2327
2371, 1334, 1335, 1349, 1348, 5447, 5461, 5657, 5643
2372, 5447, 5461, 5657, 5643, 5448, 5462, 5658, 5644
2373, 5448, 5462, 5658, 5644, 5449, 5463, 5659, 5645
2374, 5449, 5463, 5659, 5645, 5450, 5464, 5660, 5646
2375, 5450, 5464, 5660, 5646, 5451, 5465, 5661, 5647
2376, 5451, 5465, 5661, 5647, 5452, 5466, 5662, 5648
2377, 5452, 5466, 5662, 5648, 5453, 5467, 5663, 5649
2378, 5453, 5467, 5663, 5649, 5454, 5468, 5664, 5650
2379, 5454, 5468, 5664, 5650, 5455, 5469, 5665, 5651
2380, 5455, 5469, 5665, 5651, 5456, 5470, 5666, 5652
2381, 5456, 5470, 5666, 5652, 5457, 5471, 5667, 5653
2382, 5457, 5471, 5667, 5653, 5458, 5472, 5668, 5654
2383, 5458, 5472, 5668, 5654, 5459, 5473, 5669, 5655
2384, 5459, 5473, 5669, 5655, 5460, 5474, 5670, 5656
2385, 5460, 5474, 5670, 5656, 2314, 2315, 2329, 2328
2386, 1335, 1336, 1350, 1349, 5461, 5475, 5671, 5657
2387, 5461, 5475, 5671, 5657, 5462, 5476, 5672, 5658
2388, 5462, 5476, 5672, 5658, 5463, 5477, 5673, 5659
2389, 5463, 5477, 5673, 5659, 5464, 5478, 5674, 5660
2390, 5464, 5478, 5674, 5660, 5465, 5479, 5675, 5661
2391, 5465, 5479, 5675, 5661, 5466, 5480, 5676, 5662
2392, 5466, 5480, 5676, 5662, 5467, 5481, 5677, 5663
2393, 5467, 5481, 5677, 5663, 5468, 5482, 5678, 5664
2394, 5468, 5482, 5678, 5664, 5469, 5483, 5679, 5665
2395, 5469, 5483, 5679, 5665, 5470, 5484, 5680, 5666
2396, 5470, 5484, 5680, 5666, 5471, 5485, 5681, 5667
2397, 5471, 5485, 5681, 5667, 5472, 5486, 5682, 5668
2398, 5472, 5486, 5682, 5668, 5473, 5487, 5683, 5669
2399, 5473, 5487, 5683, 5669, 5474, 5488, 5684, 5670
2400, 5474, 5488, 5684, 5670, 2315, 2316, 2330, 2329
2401, 1336, 1337, 1351, 1350, 5475, 5489, 5685, 5671
2402, 5475, 5489, 5685, 5671, 5476, 5490, 5686, 5672
2403, 5476, 5490, 5686, 5672, 5477, 5491, 5687, 5673
2404, 5477, 5491, 5687, 5673, 5478, 5492, 5688, 5674
2405, 5478, 5492, 5688, 5674, 5479, 5493, 5689, 5675
2406, 5479, 5493, 5689, 5675, 5480, 5494, 5690, 5676
2407, 5480, 5494, 5690, 5676, 5481, 5495, 5691, 5677
2408, 5481, 5495, 5691, 5677, 5482, 5496, 5692, 5678
2409, 5482, 5496, 5692, 5678, 5483, 5497, 5693, 5679
2410, 5483, 5497, 5693, 5679, 5484, 5498, 5694, 5680
2411, 5484, 5498, 5694, 5680, 5485, 5499, 5695, 5681
2412, 5485, 5499, 5695, 5681, 5486, 5500, 5696, 5682
2413, 5486, 5500, 5696, 5682, 5487, 5501, 5697, 5683
2414, 5487, 5501, 5697, 5683, 5488, 5502, 5698, 5684
2415, 5488, 5502, 5698, 5684, 2316, 2317, 2331, 2330
2416, 1337, 1338, 1352, 1351, 5489, 5503, 5699, 5685
2417, 5489, 5503, 5699, 5685, 5490, 5504, 5700, 5686
2418, 5490, 5504, 5700, 5686, 5491, 5505, 5701, 5687
2419, 5491, 5505, 5701, 5687, 5492, 5506, 5702, 5688
2420, 5492, 5506, 5702, 5688, 5493, 5507, 5703, 5689
2421, 5493, 5507, 5703, 5689, 5494, 5508, 5704, 5690
2422, 5494, 5508, 5704, 5690, 5495, 5509, 5705, 5691
2423, 5495, 5509, 5705, 5691, 5496, 5510, 5706, 5692
2424, 5496, 5510, 5706, 5692, 5497, 5511, 5707, 5693
2425, 5497, 5511, 5707, 5693, 5498, 5512, 5708, 5694
2426, 5498, 5512, 5708, 5694, 5499, 5513, 5709, 5695
2427, 5499, 5513, 5709, 5695, 5500, 5514, 5710, 5696
2428, 5500, 5514, 5710, 5696, 5501, 5515, 5711, 5697
2429, 5501, 5515, 5711, 5697, 5502, 5516, 5712, 5698
2430, 5502, 5516, 5712, 5698, 2317, 2318, 2332, 2331
2431, 1338, 1339, 1353, 1352, 5503, 5517, 5713, 5699
2432, 5503, 5517, 5713, 5699, 5504, 5518, 5714, 5700
2433, 5504, 5518, 5714, 5700, 5505, 5519, 5715, 5701
2434, 5505, 5519, 5715, 5701, 5506, 5520, 5716, 5702
2435, 5506, 5520, 5716, 5702, 5507, 5521, 5717, 5703
2436, 5507, 5521, 5717, 5703, 5508, 5522, 5718, 5704
2437, 5508, 5522, 5718, 5704, 5509, 5523, 5719, 5705
2438, 5509, 5523, 5719, 5705, 5510, 5524, 5720, 5706
2439, 5510, 5524, 5720, 5706, 5511, 5525, 5721, 5707
2440, 5511, 5525, 5721, 5707, 5512, 5526, 5722, 5708
2441, 5512, 5526, 5722, 5708, 5513, 5527, 5723, 5709
2442, 5513, 5527, 5723, 5709, 5514, 5528, 5724, 5710
2443, 5514, 5528, 5724, 5710, 5515, 5529, 5725, 5711
2444, 5515, 5529, 5725, 5711, 5516, 5530, 5726, 5712
2445, 5516, 5530, 5726, 5712, 2318, 2319, 2333, 2332
2446, 1339, 1340, 1354, 1353, 5517, 5531, 5727, 5713
2447, 5517, 5531, 5727, 5713, 5518, 5532, 5728, 5714
2448, 5518, 5532, 5728, 5714, 5519, 5533, 5729, 5715
2449, 5519, 5533, 5729, 5715, 5520, 5534, 5730, 5716
2450, 5520, 5534, 5730, 5716, 5521, 5535, 5731, 5717
2451, 5521, 5535, 5731, 5717, 5522, 5536, 5732, 5718
2452, 5522, 5536, 5732, 5718, 5523, 5537, 5733, 5719
2453, 5523, 5537, 5733, 5719, 5524, 5538, 5734, 5720
2454, 5524, 5538, 5734, 5720, 5525, 5539, 5735, 5721
2455, 5525, 5539, 5735, 5721, 5526, 5540, 5736, 5722
2456, 5526, 5540, 5736, 5722, 5527, 5541, 5737, 5723
2457, 5527, 5541, 5737, 5723, 5528, 5542, 5738, 5724
2458, 5528, 5542, 5738, 5724, 5529, 5543, 5739, 5725
2459, 5529, 5543, 5739, 5725, 5530, 5544, 5740, 5726
2460, 5530, 5544, 5740, 5726, 2319, 2320, 2334, 2333
2461, 1340, 1341, 1355, 1354, 5531, 5545, 5741, 5727
2462, 5531, 5545, 5741, 5727, 5532, 5546, 5742, 5728
2463, 5532, 5546, 5742, 5728, 5533, 5547, 5743, 5729
2464, 5533, 5547, 5743, 5729, 5534, 5548, 5744, 5730
2465, 5534, 5548, 5744, 5730, 5535, 5549, 5745, 5731
2466, 5535, 5549, 5745, 5731, 5536, 5550, 5746, 5732
2467, 5536, 5550, 5746, 5732, 5537, 5551, 5747, 5733
2468, 5537, 5551, 5747, 5733, 5538, 5552, 5748, 5734
2469, 5538, 5552, 5748, 5734, 5539, 5553, 5749, 5735
2470, 5539, 5553, 5749, 5735, 5540, 5554, 5750, 5736
2471, 5540, 5554, 5750, 5736, 5541, 5555, 5751, 5737
2472, 5541, 5555, 5751, 5737, 5542, 5556, 5752, 5738
2473, 5542, 5556, 5752, 5738, 5543, 5557, 5753, 5739
2474, 5543, 5557, 5753, 5739, 5544, 5558, 5754, 5740
2475, 5544, 5558, 5754, 5740, 2320, 2321, 2335, 2334
2476, 1341, 1342, 1356, 1355, 5545, 5559, 5755, 5741
2477, 5545, 5559, 5755, 5741, 5546, 5560, 5756, 5742
2478, 5546, 5560, 5756, 5742, 5547, 5561, 5757, 5743
2479, 5547, 5561, 5757, 5743, 5548, 5562, 5758, 5744
2480, 5548, 5562, 5758, 5744, 5549, 5563, 5759, 5745
2481, 5549, 5563, 5759, 5745, 5550, 5564, 5760, 5746
2482, 5550, 5564, 5760, 5746, 5551, 5565, 5761, 5747
2483, 5551, 5565, 5761, 5747, 5552, 5566, 5762, 5748
2484, 5552, 5566, 5762, 5748, 5553, 5567, 5763, 5749
2485, 5553, 5567, 5763, 5749, 5554, 5568, 5764, 5750
2486, 5554, 5568, 5764, 5750, 5555, 5569, 5765, 5751
2487, 5555, 5569, 5765, 5751, 5556, 5570, 5766, 5752
2488, 5556, 5570, 5766, 5752, 5557, 5571, 5767, 5753
2489, 5557, 5571, 5767, 5753, 5558, 5572, 5768, 5754
2490, 5558, 5572, 5768, 5754, 2321, 2322, 2336, 2335
2491, 1342, 1343, 1357, 1356, 5559, 5573, 5769, 5755
2492, 5559, 5573, 5769, 5755, 5560, 5574, 5770, 5756
2493, 5560, 5574, 5770, 5756, 5561, 5575, 5771, 5757
2494, 5561, 5575, 5771, 5757, 5562, 5576, 5772, 5758
2495, 5562, 5576, 5772, 5758, 5563, 5577, 5773, 5759
2496, 5563, 5577, 5773, 5759, 5564, 5578, 5774, 5760
2497, 5564, 5578, 5774, 5760, 5565, 5579, 5775, 5761
2498, 5565, 5579, 5775, 5761, 5566, 5580, 5776, 5762
2499, 5566, 5580, 5776, 5762, 5567, 5581, 5777, 5763
2500, 5567, 5581, 5777, 5763, 5568, 5582, 5778, 5764
2501, 5568, 5582, 5778, 5764, 5569, 5583, 5779, 5765
2502, 5569, 5583, 5779, 5765, 5570, 5584, 5780, 5766
2503, 5570, 5584, 5780, 5766, 5571, 5585, 5781, 5767
2504, 5571, 5585, 5781, 5767, 5572, 5586, 5782, 5768
2505, 5572, 5586, 5782, 5768, 2322, 2323, 2337, 2336
2506, 1343, 1344, 1358, 1357, 5573, 5587, 5783, 5769
2507, 5573, 5587, 5783, 5769, 5574, 5588, 5784, 5770
2508, 5574, 5588, 5784, 5770, 5575, 5589, 5785, 5771
2509, 5575, 5589, 5785, 5771, 5576, 5590, 5786, 5772
2510, 5576, 5590, 5786, 5772, 5577, 5591, 5787, 5773
2511, 5577, 5591, 5787, 5773, 5578, 5592, 5788, 5774
2512, 5578, 5592, 5788, 5774, 5579, 5593, 5789, 5775
2513, 5579, 5593, 5789, 5775, 5580, 5594, 5790, 5776
2514, 5580, 5594, 5790, 5776, 5581, 5595, 5791, 5777
2515, 5581, 5595, 5791, 5777, 5582, 5596, 5792, 5778
2516, 5582, 5596, 5792, 5778, 5583, 5597, 5793, 5779
2517, 5583, 5597, 5793, 5779, 5584, 5598, 5794, 5780
2518, 5584, 5598, 5794, 5780, 5585, 5599, 5795, 5781
2519, 5585, 5599, 5795, 5781, 5586, 5600, 5796, 5782
2520, 5586, 5600, 5796, 5782, 2323, 2324, 2338, 2337
2521, 1344, 200, 201, 1358, 5587, 1919, 1933, 5783
2522, 5587, 1919, 1933, 5783, 5588, 1920, 1934, 5784
2523, 5588, 1920, 1934, 5784, 5589, 1921, 1935, 5785
2524, 5589, 1921, 1935, 5785, 5590, 1922, 1936, 5786
2525, 5590, 1922, 1936, 5786, 5591, 1923, 1937, 5787
2526, 5591, 1923, 1937, 5787, 5592, 1924, 1938, 5788
2527, 5592, 1924, 1938, 5788, 5593, 1925, 1939, 5789
2528, 5593, 1925, 1939, 5789, 5594, 1926, 1940, 5790
2529, 5594, 1926, 1940, 5790, 5595, 1927, 1941, 5791
2530, 5595, 1927, 1941, 5791, 5596, 1928, 1942, 5792
2531, 5596, 1928, 1942, 5792, 5597, 1929, 1943, 5793
2532, 5597, 1929, 1943, 5793, 5598, 1930, 1944, 5794
2533, 5598, 1930, 1944, 5794, 5599, 1931, 1945, 5795
2534, 5599, 1931, 1945, 5795, 5600, 1932, 1946, 5796
2535, 5600, 1932, 1946, 5796, 2324, 312, 313, 2338
2536, 173, 1345, 1359, 174, 1541, 5601, 5797, 1555
2537, 1541, 5601, 5797, 1555, 1542, 5602, 5798, 1556
2538, 1542, 5602, 5798, 1556, 1543, 5603, 5799, 1557
2539, 1543, 5603, 5799, 1557, 1544, 5604, 5800, 1558
2540, 1544, 5604, 5800, 1558, 1545, 5605, 5801, 1559
2541, 1545, 5605, 5801, 1559, 1546, 5606, 5802, 1560
2542, 1546, 5606, 5802, 1560, 1547, 5607, 5803, 1561
2543, 1547, 5607, 5803, 1561, 1548, 5608, 5804, 1562
2544, 1548, 5608, 5804, 1562, 1549, 5609, 5805, 1563
2545, 1549, 5609, 5805, 1563, 1550, 5610, 5806, 1564
2546, 1550, 5610, 5806, 1564, 1551, 5611, 5807, 1565
2547, 1551, 5611, 5807, 1565, 1552, 5612, 5808, 1566
2548, 1552, 5612, 5808, 1566, 1553, 5613, 5809, 1567
2549, 1553, 5613, 5809, 1567, 1554, 5614, 5810, 1568
2550, 1554, 5614, 5810, 1568, 257, 2325, 2339, 258
2551, 1345, 1346, 1360, 1359, 5601, 5615, 5811, 5797
2552, 5601, 5615, 5811, 5797, 5602, 5616, 5812, 5798
2553, 5602, 5616, 5812, 5798, 5603, 5617, 5813, 5799
2554, 5603, 5617, 5813, 5799, 5604, 5618, 5814, 5800
2555, 5604, 5618, 5814, 5800, 5605, 5619, 5815, 5801
2556, 5605, 5619, 5815, 5801, 5606, 5620, 5816, 5802
2557, 5606, 5620, 5816, 5802, 5607, 5621, 5817, 5803
2558, 5607, 5621, 5817, 5803, 5608, 5622, 5818, 5804
2559, 5608, 5622, 5818, 5804, 5609, 5623, 5819, 5805
2560, 5609, 5623, 5819, 5805, 5610, 5624, 5820, 5806
2561, 5610, 5624, 5820, 5806, 5611, 5625, 5821, 5807
2562, 5611, 5625, 5821, 5807, 5612, 5626, 5822, 5808
2563, 5612, 5626, 5822, 5808, 5613, 5627, 5823, 5809
2564, 5613, 5627, 5823, 5809, 5614, 5628, 5824, 5810
2565, 5614, 5628, 5824, 5810, 2325, 2326, 2340, 2339
2566, 1346, 1347, 1361, 1360, 5615, 5629, 5825, 5811
2567, 5615, 5629, 5825, 5811, 5616, 5630, 5826, 5812
2568, 5616, 5630, 5826, 5812, 5617, 5631, 5827, 5813
2569, 5617, 5631, 5827, 5813, 5618, 5632, 5828, 5814
2570, 5618, 5632, 5828, 5814, 5619, 5633, 5829, 5815
2571, 5619, 5633, 5829, 5815, 5620, 5634, 5830, 5816
2572, 5620, 5634, 5830, 5816, 5621, 5635, 5831, 5817
2573, 5621, 5635, 5831, 5817, 5622, 5636, 5832, 5818
2574, 5622, 5636, 5832, 5818, 5623, 5637, 5833, 5819
2575, 5623, 5637, 5833, 5819, 5624, 5638, 5834, 5820
2576, 5624, 5638, 5834, 5820, 5625, 5639, 5835, 5821
2577, 5625, 5639, 5835, 5821, 5626, 5640, 5836, 5822
2578, 5626, 5640, 5836, 5822, 5627, 5641, 5837, 5823
2579, 5627, 5641, 5837, 5823, 5628, 5642, 5838, 5824
2580, 5628, 5642, 5838, 5824, 2326, 2327, 2341, 2340
2581, 1347, 1348, 1362, 1361, 5629, 5643, 5839, 5825
2582, 5629, 5643, 5839, 5825, 5630, 5644, 5840, 5826
2583, 5630, 5644, 5840, 5826, 5631, 5645, 5841, 5827
2584, 5631, 5645, 5841, 5827, 5632, 5646, 5842, 5828
2585, 5632, 5646, 5842, 5828, 5633, 5647, 5843, 5829
2586, 5633, 5647, 5843, 5829, 5634, 5648, 5844, 5830
2587, 5634, 5648, 5844, 5830, 5635, 5649, 5845, 5831
2588, 5635, 5649, 5845, 5831, 5636, 5650, 5846, 5832
2589, 5636, 5650, 5846, 5832, 5637, 5651, 5847, 5833
2590, 5637, 5651, 5847, 5833, 5638, 5652, 5848, 5834
2591, 5638, 5652, 5848, 5834, 5639, 5653, 5849, 5835
2592, 5639, 5653, 5849, 5835, 5640, 5654, 5850, 5836
2593, 5640, 5654, 5850, 5836, 5641, 5655, 5851, 5837
2594, 5641, 5655, 5851, 5837, 5642, 5656, 5852, 5838
2595, 5642, 5656, 5852, 5838, 2327, 2328, 2342, 2341
2596, 1348, 1349, 1363, 1362, 5643, 5657, 5853, 5839
2597, 5643, 5657, 5853, 5839, 5644, 5658, 5854, 5840
2598, 5644, 5658, 5854, 5840, 5645, 5659, 5855, 5841
2599, 5645, 5659, 5855, 5841, 5646, 5660, 5856, 5842
2600, 5646, 5660, 5856, 5842, 5647, 5661, 5857, 5843
2601, 5647, 5661, 5857, 5843, 5648, 5662, 5858, 5844
2602, 5648, 5662, 5858, 5844, 5649, 5663, 5859, 5845
2603, 5649, 5663, 5859, 5845, 5650, 5664, 5860, 5846
2604, 5650, 5664, 5860, 5846, 5651, 5665, 5861, 5847
2605, 5651, 5665, 5861, 5847, 5652, 5666, 5862, 5848
2606, 5652, 5666, 5862, 5848, 5653, 5667, 5863, 5849
2607, 5653, 5667, 5863, 5849, 5654, 5668, 5864, 5850
2608, 5654, 5668, 5864, 5850, 5655, 5669, 5865, 5851
2609, 5655, 5669, 5865, 5851, 5656, 5670, 5866, 5852
2610, 5656, 5670, 5866, 5852, 2328, 2329, 2343, 2342
2611, 1349, 1350, 1364, 1363, 5657, 5671, 5867, 5853
2612, 5657, 5671, 5867, 5853, 5658, 5672, 5868, 5854
2613, 5658, 5672, 5868, 5854, 5659, 5673, 5869, 5855
2614, 5659, 5673, 5869, 5855, 5660, 5674, 5870, 5856
2615, 5660, 5674, 5870, 5856, 5661, 5675, 5871, 5857
2616, 5661, 5675, 5871, 5857, 5662, 5676, 5872, 5858
2617, 5662, 5676, 5872, 5858, 5663, 5677, 5873, 5859
2618, 5663, 5677, 5873, 5859, 5664, 5678, 5874, 5860
2619, 5664, 5678, 5874, 5860, 5665, 5679, 5875, 5861
2620, 5665, 5679, 5875, 5861, 5666, 5680, 5876, 5862
2621, 5666, 5680, 5876, 5862, 5667, 5681, 5877, 5863
2622, 5667, 5681, 5877, 5863, 5668, 5682, 5878, 5864
2623, 5668, 5682, 5878, 5864, 5669, 5683, 5879, 5865
2624, 5669, 5683, 5879, 5865, 5670, 5684, 5880, 5866
2625, 5670, 5684, 5880, 5866, 2329, 2330, 2344, 2343
2626, 1350, 1351, 1365, 1364, 5671, 5685, 5881, 5867
2627, 5671, 5685, 5881, 5867, 5672, 5686, 5882, 5868
2628, 5672, 5686, 5882, 5868, 5673, 5687, 5883, 5869
2629, 5673, 5687, 5883, 5869, 5674, 5688, 5884, 5870
2630, 5674, 5688, 5884, 5870, 5675, 5689, 5885, 5871
2631, 5675, 5689, 5885, 5871, 5676, 5690, 5886, 5872
2632, 5676, 5690, 5886, 5872, 5677, 5691, 5887, 5873
2633, 5677, 5691, 5887, 5873, 5678, 5692, 5888, 5874
2634, 5678, 5692, 5888, 5874, 5679, 5693, 5889, 5875
2635, 5679, 5693, 5889, 5875, 5680, 5694, 5890, 5876
2636, 5680, 5694, 5890, 5876, 5681, 5695, 5891, 5877
2637, 5681, 5695, 5891, 5877, 5682, 5696, 5892, 5878
2638, 5682, 5696, 5892, 5878, 5683, 5697, 5893, 5879
2639, 5683, 5697, 5893, 5879, 5684, 5698, 5894, 5880
2640, 5684, 5698, 5894, 5880, 2330, 2331, 2345, 2344
2641, 1351, 1352, 1366, 1365, 5685, 5699, 5895, 5881
2642, 5685, 5699, 5895, 5881, 5686, 5700, 5896, 5882
2643, 5686, 5700, 5896, 5882, 5687, 5701, 5897, 5883
2644, 5687, 5701, 5897, 5883, 5688, 5702, 5898, 5884
2645, 5688, 5702, 5898, 5884, 5689, 5703, 5899, 5885
2646, 5689, 5703, 5899, 5885, 5690, 5704, 5900, 5886
2647, 5690, 5704, 5900, 5886, 5691, 5705, 5901, 5887
2648, 5691, 5705, 5901, 5887, 5692, 5706, 5902, 5888
2649, 5692, 5706, 5902, 5888, 5693, 5707, 5903, 5889
2650, 5693, 5707, 5903, 5889, 5694, 5708, 5904, 5890
2651, 5694, 5708, 5904, 5890, 5695, 5709, 5905, 5891
2652, 5695, 5709, 5905, 5891, 5696, 5710, 5906, 5892
2653, 5696, 5710, 5906, 5892, 5697, 5711, 5907, 5893
2654, 5697, 5711, 5907, 5893, 5698, 5712, 5908, 5894
2655, 5698, 5712, 5908, 5894, 2331, 2332, 2346, 2345
2656, 1352, 1353, 1367, 1366, 5699, 5713, 5909, 5895
2657, 5699, 5713, 5909, 5895, 5700, 5714, 5910, 5896
2658, 5700, 5714, 5910, 5896, 5701, 5715, 5911, 5897
2659, 5701, 5715, 5911, 5897, 5702, 5716, 5912, 5898
2660, 5702, 5716, 5912, 5898, 5703, 5717, 5913, 5899
2661, 5703, 5717, 5913, 5899, 5704, 5718, 5914, 5900
2662, 5704, 5718, 5914, 5900, 5705, 5719, 5915, 5901
2663, 5705, 5719, 5915, 5901, 5706, 5720, 5916, 5902
2664, 5706, 5720, 5916, 5902, 5707, 5721, 5917, 5903
2665, 5707, 5721, 5917, 5903, 5708, 5722, 5918, 5904
2666, 5708, 5722, 5918, 5904, 5709, 5723, 5919, 5905
2667, 5709, 5723, 5919, 5905, 5710, 5724, 5920, 5906
2668, 5710, 5724, 5920, 5906, 5711, 5725, 5921, 5907
2669, 5711, 5725, 5921, 5907, 5712, 5726, 5922, 5908
2670, 5712, 5726, 5922, 5908, 2332, 2333, 2347, 2346
2671, 1353, 1354, 1368, 1367, 5713, 5727, 5923, 5909
2672, 5713, 5727, 5923, 5909, 5714, 5728, 5924, 5910
2673, 5714, 5728, 5924, 5910, 5715, 5729, 5925, 5911
2674, 5715, 5729, 5925, 5911, 5716, 5730, 5926, 5912
2675, 5716, 5730, 5926, 5912, 5717, 5731, 5927, 5913
2676, 5717, 5731, 5927, 5913, 5718, 5732, 5928, 5914
2677, 5718, 5732, 5928, 5914, 5719, 5733, 5929, 5915
2678, 5719, 5733, 5929, 5915, 5720, 5734, 5930, 5916
2679, 5720, 5734, 5930, 5916, 5721, 5735, 5931, 5917
2680, 5721, 5735, 5931, 5917, 5722, 5736, 5932, 5918
2681, 5722, 5736, 5932, 5918, 5723, 5737, 5933, 5919
2682, 5723, 5737, 5933, 5919, 5724, 5738, 5934, 5920
2683, 5724, 5738, 5934, 5920, 5725, 5739, 5935, 5921
2684, 5725, 5739, 5935, 5921, 5726, 5740, 5936, 5922
2685, 5726, 5740, 5936, 5922, 2333, 2334, 2348, 2347
2686, 1354, 1355, 1369, 1368, 5727, 5741, 5937, 5923
2687, 5727, 5741, 5937, 5923, 5728, 5742, 5938, 5924
2688, 5728, 5742, 5938, 5924, 5729, 5743, 5939, 5925
2689, 5729, 5743, 5939, 5925, 5730, 5744, 5940, 5926
2690, 5730, 5744, 5940, 5926, 5731, 5745, 5941, 5927
2691, 5731, 5745, 5941, 5927, 5732, 5746, 5942, 5928
2692, 5732, 5746, 5942, 5928, 5733, 5747, 5943, 5929
2693, 5733, 5747, 5943, 5929, 5734, 5748, 5944, 5930
2694, 5734, 5748, 5944, 5930, 5735, 5749, 5945, 5931
2695, 5735, 5749, 5945, 5931, 5736, 5750, 5946, 5932
2696, 5736, 5750, 5946, 5932, 5737, 5751, 5947, 5933
2697, 5737, 5751, 5947, 5933, 5738, 5752, 5948, 5934
2698, 5738, 5752, 5948, 5934, 5739, 5753, 5949, 5935
2699, 5739, 5753, 5949, 5935, 5740, 5754, 5950, 5936
2700, 5740, 5754, 5950, 5936, 2334, 2335, 2349, 2348
2701, 1355, 1356, 1370, 1369, 5741, 5755, 5951, 5937
2702, 5741, 5755, 5951, 5937, 5742, 5756, 5952, 5938
2703, 5742, 5756, 5952, 5938, 5743, 5757, 5953, 5939
2704, 5743, 5757, 5953, 5939, 5744, 5758, 5954, 5940
2705, 5744, 5758, 5954, 5940, 5745, 5759, 5955, 5941
2706, 5745, 5759, 5955, 5941, 5746, 5760, 5956, 5942
2707, 5746, 5760, 5956, 5942, 5747, 5761, 5957, 5943
2708, 5747, 5761, 5957, 5943, 5748, 5762, 5958, 5944
2709, 5748, 5762, 5958, 5944, 5749, 5763, 5959, 5945
2710, 5749, 5763, 5959, 5945, 5750, 5764, 5960, 5946
2711, 5750, 5764, 5960, 5946, 5751, 5765, 5961, 5947
2712, 5751, 5765, 5961, 5947, 5752, 5766, 5962, 5948
2713, 5752, 5766, 5962, 5948, 5753, 5767, 5963, 5949
2714, 5753, 5767, 5963, 5949, 5754, 5768, 5964, 5950
2715, 5754, 5768, 5964, 5950, 2335, 2336, 2350, 2349
2716, 1356, 1357, 1371, 1370, 5755, 5769, 5965, 5951
2717, 5755, 5769, 5965, 5951, 5756, 5770, 5966, 5952
2718, 5756, 5770, 5966, 5952, 5757, 5771, 5967, 5953
2719, 5757, 5771, 5967, 5953, 5758, 5772, 5968, 5954
2720, 5758, 5772, 5968, 5954, 5759, 5773, 5969, 5955
2721, 5759, 5773, 5969, 5955, 5760, 5774, 5970, 5956
2722, 5760, 5774, 5970, 5956, 5761, 5775, 5971, 5957
2723, 5761, 5775, 5971, 5957, 5762, 5776, 5972, 5958
2724, 5762, 5776, 5972, 5958, 5763, 5777, 5973, 5959
2725, 5763, 5777, 5973, 5959, 5764, 5778, 5974, 5960
2726, 5764, 5778, 5974, 5960, 5765, 5779, 5975, 5961
2727, 5765, 5779, 5975, 5961, 5766, 5780, 5976, 5962
2728, 5766, 5780, 5976, 5962, 5767, 5781, 5977, 5963
2729, 5767, 5781, 5977, 5963, 5768, 5782, 5978, 5964
2730, 5768, 5782, 5978, 5964, 2336, 2337, 2351, 2350
2731, 1357, 1358, 1372, 1371, 5769, 5783, 5979, 5965
2732, 5769, 5783, 5979, 5965, 5770, 5784, 5980, 5966
2733, 5770, 5784, 5980, 5966, 5771, 5785, 5981, 5967
2734, 5771, 5785, 5981, 5967, 5772, 5786, 5982, 5968
2735, 5772, 5786, 5982, 5968, 5773, 5787, 5983, 5969
2736, 5773, 5787, 5983, 5969, 5774, 5788, 5984, 5970
2737, 5774, 5788, 5984, 5970, 5775, 5789, 5985, 5971
2738, 5775, 5789, 5985, 5971, 5776, 5790, 5986, 5972
2739, 5776, 5790, 5986, 5972, 5777, 5791, 5987, 5973
2740, 5777, 5791, 5987, 5973, 5778, 5792, 5988, 5974
2741, 5778, 5792, 5988, 5974, 5779, 5793, 5989, 5975
2742, 5779, 5793, 5989, 5975, 5780, 5794, 5990, 5976
2743, 5780, 5794, 5990, 5976, 5781, 5795, 5991, 5977
2744, 5781, 5795, 5991, 5977, 5782, 5796, 5992, 5978
2745, 5782, 5796, 5992, 5978, 2337, 2338, 2352, 2351
2746, 1358, 201, 202, 1372, 5783, 1933, 1947, 5979
2747, 5783, 1933, 1947, 5979, 5784, 1934, 1948, 5980
2748, 5784, 1934, 1948, 5980, 5785, 1935, 1949, 5981
2749, 5785, 1935, 1949, 5981, 5786, 1936, 1950, 5982
2750, 5786, 1936, 1950, 5982, 5787, 1937, 1951, 5983
2751, 5787, 1937, 1951, 5983, 5788, 1938, 1952, 5984
2752, 5788, 1938, 1952, 5984, 5789, 1939, 1953, 5985
2753, 5789, 1939, 1953, 5985, 5790, 1940, 1954, 5986
2754, 5790, 1940, 1954, 5986, 5791, 1941, 1955, 5987
2755, 5791, 1941, 1955, 5987, 5792, 1942, 1956, 5988
2756, 5792, 1942, 1956, 5988, 5793, 1943, 1957, 5989
2757, 5793, 1943, 1957, 5989, 5794, 1944, 1958, 5990
2758, 5794, 1944, 1958, 5990, 5795, 1945, 1959, 5991
2759, 5795, 1945, 1959, 5991, 5796, 1946, 1960, 5992
2760, 5796, 1946, 1960, 5992, 2338, 313, 314, 2352
2761, 174, 1359, 1373, 175, 1555, 5797, 5993, 1569
2762, 1555, 5797, 5993, 1569, 1556, 5798, 5994, 1570
2763, 1556, 5798, 5994, 1570, 1557, 5799, 5995, 1571
