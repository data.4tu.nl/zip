5277, 0.2, 0.99333333333333, 0.16666666666667
5278, 0.2, 1.0466666666667, 0.16666666666667
5279, 0.2, 0.35333333333333, 0.2
5280, 0.2, 0.40666666666667, 0.2
5281, 0.2, 0.46, 0.2
5282, 0.2, 0.51333333333333, 0.2
5283, 0.2, 0.56666666666667, 0.2
5284, 0.2, 0.62, 0.2
5285, 0.2, 0.67333333333333, 0.2
5286, 0.2, 0.72666666666667, 0.2
5287, 0.2, 0.78, 0.2
5288, 0.2, 0.83333333333333, 0.2
5289, 0.2, 0.88666666666667, 0.2
5290, 0.2, 0.94, 0.2
5291, 0.2, 0.99333333333333, 0.2
5292, 0.2, 1.0466666666667, 0.2
5293, 0.2, 0.35333333333333, 0.23333333333333
5294, 0.2, 0.40666666666667, 0.23333333333333
5295, 0.2, 0.46, 0.23333333333333
5296, 0.2, 0.51333333333333, 0.23333333333333
5297, 0.2, 0.56666666666667, 0.23333333333333
5298, 0.2, 0.62, 0.23333333333333
5299, 0.2, 0.67333333333333, 0.23333333333333
5300, 0.2, 0.72666666666667, 0.23333333333333
5301, 0.2, 0.78, 0.23333333333333
5302, 0.2, 0.83333333333333, 0.23333333333333
5303, 0.2, 0.88666666666667, 0.23333333333333
5304, 0.2, 0.94, 0.23333333333333
5305, 0.2, 0.99333333333333, 0.23333333333333
5306, 0.2, 1.0466666666667, 0.23333333333333
5307, 0.2, 0.35333333333333, 0.26666666666667
5308, 0.2, 0.40666666666667, 0.26666666666667
5309, 0.2, 0.46, 0.26666666666667
5310, 0.2, 0.51333333333333, 0.26666666666667
5311, 0.2, 0.56666666666667, 0.26666666666667
5312, 0.2, 0.62, 0.26666666666667
5313, 0.2, 0.67333333333333, 0.26666666666667
5314, 0.2, 0.72666666666667, 0.26666666666667
5315, 0.2, 0.78, 0.26666666666667
5316, 0.2, 0.83333333333333, 0.26666666666667
5317, 0.2, 0.88666666666667, 0.26666666666667
5318, 0.2, 0.94, 0.26666666666667
5319, 0.2, 0.99333333333333, 0.26666666666667
5320, 0.2, 1.0466666666667, 0.26666666666667
5321, 0.2, 0.35333333333333, 0.3
5322, 0.2, 0.40666666666667, 0.3
5323, 0.2, 0.46, 0.3
5324, 0.2, 0.51333333333333, 0.3
5325, 0.2, 0.56666666666667, 0.3
5326, 0.2, 0.62, 0.3
5327, 0.2, 0.67333333333333, 0.3
5328, 0.2, 0.72666666666667, 0.3
5329, 0.2, 0.78, 0.3
5330, 0.2, 0.83333333333333, 0.3
5331, 0.2, 0.88666666666667, 0.3
5332, 0.2, 0.94, 0.3
5333, 0.2, 0.99333333333333, 0.3
5334, 0.2, 1.0466666666667, 0.3
5335, 0.2, 0.35333333333333, 0.33333333333333
5336, 0.2, 0.40666666666667, 0.33333333333333
5337, 0.2, 0.46, 0.33333333333333
5338, 0.2, 0.51333333333333, 0.33333333333333
5339, 0.2, 0.56666666666667, 0.33333333333333
5340, 0.2, 0.62, 0.33333333333333
5341, 0.2, 0.67333333333333, 0.33333333333333
5342, 0.2, 0.72666666666667, 0.33333333333333
5343, 0.2, 0.78, 0.33333333333333
5344, 0.2, 0.83333333333333, 0.33333333333333
5345, 0.2, 0.88666666666667, 0.33333333333333
5346, 0.2, 0.94, 0.33333333333333
5347, 0.2, 0.99333333333333, 0.33333333333333
5348, 0.2, 1.0466666666667, 0.33333333333333
5349, 0.2, 0.35333333333333, 0.36666666666667
5350, 0.2, 0.40666666666667, 0.36666666666667
5351, 0.2, 0.46, 0.36666666666667
5352, 0.2, 0.51333333333333, 0.36666666666667
5353, 0.2, 0.56666666666667, 0.36666666666667
5354, 0.2, 0.62, 0.36666666666667
5355, 0.2, 0.67333333333333, 0.36666666666667
5356, 0.2, 0.72666666666667, 0.36666666666667
5357, 0.2, 0.78, 0.36666666666667
5358, 0.2, 0.83333333333333, 0.36666666666667
5359, 0.2, 0.88666666666667, 0.36666666666667
5360, 0.2, 0.94, 0.36666666666667
5361, 0.2, 0.99333333333333, 0.36666666666667
5362, 0.2, 1.0466666666667, 0.36666666666667
5363, 0.2, 0.35333333333333, 0.4
5364, 0.2, 0.40666666666667, 0.4
5365, 0.2, 0.46, 0.4
5366, 0.2, 0.51333333333333, 0.4
5367, 0.2, 0.56666666666667, 0.4
5368, 0.2, 0.62, 0.4
5369, 0.2, 0.67333333333333, 0.4
5370, 0.2, 0.72666666666667, 0.4
5371, 0.2, 0.78, 0.4
5372, 0.2, 0.83333333333333, 0.4
5373, 0.2, 0.88666666666667, 0.4
5374, 0.2, 0.94, 0.4
5375, 0.2, 0.99333333333333, 0.4
5376, 0.2, 1.0466666666667, 0.4
5377, 0.2, 0.35333333333333, 0.43333333333333
5378, 0.2, 0.40666666666667, 0.43333333333333
5379, 0.2, 0.46, 0.43333333333333
5380, 0.2, 0.51333333333333, 0.43333333333333
5381, 0.2, 0.56666666666667, 0.43333333333333
5382, 0.2, 0.62, 0.43333333333333
5383, 0.2, 0.67333333333333, 0.43333333333333
5384, 0.2, 0.72666666666667, 0.43333333333333
5385, 0.2, 0.78, 0.43333333333333
5386, 0.2, 0.83333333333333, 0.43333333333333
5387, 0.2, 0.88666666666667, 0.43333333333333
5388, 0.2, 0.94, 0.43333333333333
5389, 0.2, 0.99333333333333, 0.43333333333333
5390, 0.2, 1.0466666666667, 0.43333333333333
5391, 0.2, 0.35333333333333, 0.46666666666667
5392, 0.2, 0.40666666666667, 0.46666666666667
5393, 0.2, 0.46, 0.46666666666667
5394, 0.2, 0.51333333333333, 0.46666666666667
5395, 0.2, 0.56666666666667, 0.46666666666667
5396, 0.2, 0.62, 0.46666666666667
5397, 0.2, 0.67333333333333, 0.46666666666667
5398, 0.2, 0.72666666666667, 0.46666666666667
5399, 0.2, 0.78, 0.46666666666667
5400, 0.2, 0.83333333333333, 0.46666666666667
5401, 0.2, 0.88666666666667, 0.46666666666667
5402, 0.2, 0.94, 0.46666666666667
5403, 0.2, 0.99333333333333, 0.46666666666667
5404, 0.2, 1.0466666666667, 0.46666666666667
5405, 0.26666666666667, 0.35333333333333, 0.033333333333333
5406, 0.26666666666667, 0.40666666666667, 0.033333333333333
5407, 0.26666666666667, 0.46, 0.033333333333333
5408, 0.26666666666667, 0.51333333333333, 0.033333333333333
5409, 0.26666666666667, 0.56666666666667, 0.033333333333333
5410, 0.26666666666667, 0.62, 0.033333333333333
5411, 0.26666666666667, 0.67333333333333, 0.033333333333333
5412, 0.26666666666667, 0.72666666666667, 0.033333333333333
5413, 0.26666666666667, 0.78, 0.033333333333333
5414, 0.26666666666667, 0.83333333333333, 0.033333333333333
5415, 0.26666666666667, 0.88666666666667, 0.033333333333333
5416, 0.26666666666667, 0.94, 0.033333333333333
5417, 0.26666666666667, 0.99333333333333, 0.033333333333333
5418, 0.26666666666667, 1.0466666666667, 0.033333333333333
5419, 0.26666666666667, 0.35333333333333, 0.066666666666667
5420, 0.26666666666667, 0.40666666666667, 0.066666666666667
5421, 0.26666666666667, 0.46, 0.066666666666667
5422, 0.26666666666667, 0.51333333333333, 0.066666666666667
5423, 0.26666666666667, 0.56666666666667, 0.066666666666667
5424, 0.26666666666667, 0.62, 0.066666666666667
5425, 0.26666666666667, 0.67333333333333, 0.066666666666667
5426, 0.26666666666667, 0.72666666666667, 0.066666666666667
5427, 0.26666666666667, 0.78, 0.066666666666667
5428, 0.26666666666667, 0.83333333333333, 0.066666666666667
5429, 0.26666666666667, 0.88666666666667, 0.066666666666667
5430, 0.26666666666667, 0.94, 0.066666666666667
5431, 0.26666666666667, 0.99333333333333, 0.066666666666667
5432, 0.26666666666667, 1.0466666666667, 0.066666666666667
5433, 0.26666666666667, 0.35333333333333, 0.1
5434, 0.26666666666667, 0.40666666666667, 0.1
5435, 0.26666666666667, 0.46, 0.1
5436, 0.26666666666667, 0.51333333333333, 0.1
5437, 0.26666666666667, 0.56666666666667, 0.1
5438, 0.26666666666667, 0.62, 0.1
5439, 0.26666666666667, 0.67333333333333, 0.1
5440, 0.26666666666667, 0.72666666666667, 0.1
5441, 0.26666666666667, 0.78, 0.1
5442, 0.26666666666667, 0.83333333333333, 0.1
5443, 0.26666666666667, 0.88666666666667, 0.1
5444, 0.26666666666667, 0.94, 0.1
5445, 0.26666666666667, 0.99333333333333, 0.1
5446, 0.26666666666667, 1.0466666666667, 0.1
5447, 0.26666666666667, 0.35333333333333, 0.13333333333333
5448, 0.26666666666667, 0.40666666666667, 0.13333333333333
5449, 0.26666666666667, 0.46, 0.13333333333333
5450, 0.26666666666667, 0.51333333333333, 0.13333333333333
5451, 0.26666666666667, 0.56666666666667, 0.13333333333333
5452, 0.26666666666667, 0.62, 0.13333333333333
5453, 0.26666666666667, 0.67333333333333, 0.13333333333333
5454, 0.26666666666667, 0.72666666666667, 0.13333333333333
5455, 0.26666666666667, 0.78, 0.13333333333333
5456, 0.26666666666667, 0.83333333333333, 0.13333333333333
5457, 0.26666666666667, 0.88666666666667, 0.13333333333333
5458, 0.26666666666667, 0.94, 0.13333333333333
5459, 0.26666666666667, 0.99333333333333, 0.13333333333333
5460, 0.26666666666667, 1.0466666666667, 0.13333333333333
5461, 0.26666666666667, 0.35333333333333, 0.16666666666667
5462, 0.26666666666667, 0.40666666666667, 0.16666666666667
5463, 0.26666666666667, 0.46, 0.16666666666667
5464, 0.26666666666667, 0.51333333333333, 0.16666666666667
5465, 0.26666666666667, 0.56666666666667, 0.16666666666667
5466, 0.26666666666667, 0.62, 0.16666666666667
5467, 0.26666666666667, 0.67333333333333, 0.16666666666667
5468, 0.26666666666667, 0.72666666666667, 0.16666666666667
5469, 0.26666666666667, 0.78, 0.16666666666667
5470, 0.26666666666667, 0.83333333333333, 0.16666666666667
5471, 0.26666666666667, 0.88666666666667, 0.16666666666667
5472, 0.26666666666667, 0.94, 0.16666666666667
5473, 0.26666666666667, 0.99333333333333, 0.16666666666667
5474, 0.26666666666667, 1.0466666666667, 0.16666666666667
5475, 0.26666666666667, 0.35333333333333, 0.2
5476, 0.26666666666667, 0.40666666666667, 0.2
5477, 0.26666666666667, 0.46, 0.2
5478, 0.26666666666667, 0.51333333333333, 0.2
5479, 0.26666666666667, 0.56666666666667, 0.2
5480, 0.26666666666667, 0.62, 0.2
5481, 0.26666666666667, 0.67333333333333, 0.2
5482, 0.26666666666667, 0.72666666666667, 0.2
5483, 0.26666666666667, 0.78, 0.2
5484, 0.26666666666667, 0.83333333333333, 0.2
5485, 0.26666666666667, 0.88666666666667, 0.2
5486, 0.26666666666667, 0.94, 0.2
5487, 0.26666666666667, 0.99333333333333, 0.2
5488, 0.26666666666667, 1.0466666666667, 0.2
5489, 0.26666666666667, 0.35333333333333, 0.23333333333333
5490, 0.26666666666667, 0.40666666666667, 0.23333333333333
5491, 0.26666666666667, 0.46, 0.23333333333333
5492, 0.26666666666667, 0.51333333333333, 0.23333333333333
5493, 0.26666666666667, 0.56666666666667, 0.23333333333333
5494, 0.26666666666667, 0.62, 0.23333333333333
5495, 0.26666666666667, 0.67333333333333, 0.23333333333333
5496, 0.26666666666667, 0.72666666666667, 0.23333333333333
5497, 0.26666666666667, 0.78, 0.23333333333333
5498, 0.26666666666667, 0.83333333333333, 0.23333333333333
5499, 0.26666666666667, 0.88666666666667, 0.23333333333333
5500, 0.26666666666667, 0.94, 0.23333333333333
5501, 0.26666666666667, 0.99333333333333, 0.23333333333333
5502, 0.26666666666667, 1.0466666666667, 0.23333333333333
5503, 0.26666666666667, 0.35333333333333, 0.26666666666667
5504, 0.26666666666667, 0.40666666666667, 0.26666666666667
5505, 0.26666666666667, 0.46, 0.26666666666667
5506, 0.26666666666667, 0.51333333333333, 0.26666666666667
5507, 0.26666666666667, 0.56666666666667, 0.26666666666667
5508, 0.26666666666667, 0.62, 0.26666666666667
5509, 0.26666666666667, 0.67333333333333, 0.26666666666667
5510, 0.26666666666667, 0.72666666666667, 0.26666666666667
5511, 0.26666666666667, 0.78, 0.26666666666667
5512, 0.26666666666667, 0.83333333333333, 0.26666666666667
5513, 0.26666666666667, 0.88666666666667, 0.26666666666667
5514, 0.26666666666667, 0.94, 0.26666666666667
5515, 0.26666666666667, 0.99333333333333, 0.26666666666667
5516, 0.26666666666667, 1.0466666666667, 0.26666666666667
5517, 0.26666666666667, 0.35333333333333, 0.3
5518, 0.26666666666667, 0.40666666666667, 0.3
5519, 0.26666666666667, 0.46, 0.3
5520, 0.26666666666667, 0.51333333333333, 0.3
5521, 0.26666666666667, 0.56666666666667, 0.3
5522, 0.26666666666667, 0.62, 0.3
5523, 0.26666666666667, 0.67333333333333, 0.3
5524, 0.26666666666667, 0.72666666666667, 0.3
5525, 0.26666666666667, 0.78, 0.3
5526, 0.26666666666667, 0.83333333333333, 0.3
5527, 0.26666666666667, 0.88666666666667, 0.3
5528, 0.26666666666667, 0.94, 0.3
5529, 0.26666666666667, 0.99333333333333, 0.3
5530, 0.26666666666667, 1.0466666666667, 0.3
5531, 0.26666666666667, 0.35333333333333, 0.33333333333333
5532, 0.26666666666667, 0.40666666666667, 0.33333333333333
5533, 0.26666666666667, 0.46, 0.33333333333333
5534, 0.26666666666667, 0.51333333333333, 0.33333333333333
5535, 0.26666666666667, 0.56666666666667, 0.33333333333333
5536, 0.26666666666667, 0.62, 0.33333333333333
5537, 0.26666666666667, 0.67333333333333, 0.33333333333333
5538, 0.26666666666667, 0.72666666666667, 0.33333333333333
5539, 0.26666666666667, 0.78, 0.33333333333333
5540, 0.26666666666667, 0.83333333333333, 0.33333333333333
5541, 0.26666666666667, 0.88666666666667, 0.33333333333333
5542, 0.26666666666667, 0.94, 0.33333333333333
5543, 0.26666666666667, 0.99333333333333, 0.33333333333333
5544, 0.26666666666667, 1.0466666666667, 0.33333333333333
5545, 0.26666666666667, 0.35333333333333, 0.36666666666667
5546, 0.26666666666667, 0.40666666666667, 0.36666666666667
5547, 0.26666666666667, 0.46, 0.36666666666667
5548, 0.26666666666667, 0.51333333333333, 0.36666666666667
5549, 0.26666666666667, 0.56666666666667, 0.36666666666667
5550, 0.26666666666667, 0.62, 0.36666666666667
5551, 0.26666666666667, 0.67333333333333, 0.36666666666667
5552, 0.26666666666667, 0.72666666666667, 0.36666666666667
5553, 0.26666666666667, 0.78, 0.36666666666667
5554, 0.26666666666667, 0.83333333333333, 0.36666666666667
5555, 0.26666666666667, 0.88666666666667, 0.36666666666667
5556, 0.26666666666667, 0.94, 0.36666666666667
5557, 0.26666666666667, 0.99333333333333, 0.36666666666667
5558, 0.26666666666667, 1.0466666666667, 0.36666666666667
5559, 0.26666666666667, 0.35333333333333, 0.4
5560, 0.26666666666667, 0.40666666666667, 0.4
5561, 0.26666666666667, 0.46, 0.4
5562, 0.26666666666667, 0.51333333333333, 0.4
5563, 0.26666666666667, 0.56666666666667, 0.4
5564, 0.26666666666667, 0.62, 0.4
5565, 0.26666666666667, 0.67333333333333, 0.4
5566, 0.26666666666667, 0.72666666666667, 0.4
5567, 0.26666666666667, 0.78, 0.4
5568, 0.26666666666667, 0.83333333333333, 0.4
5569, 0.26666666666667, 0.88666666666667, 0.4
5570, 0.26666666666667, 0.94, 0.4
5571, 0.26666666666667, 0.99333333333333, 0.4
5572, 0.26666666666667, 1.0466666666667, 0.4
5573, 0.26666666666667, 0.35333333333333, 0.43333333333333
5574, 0.26666666666667, 0.40666666666667, 0.43333333333333
5575, 0.26666666666667, 0.46, 0.43333333333333
5576, 0.26666666666667, 0.51333333333333, 0.43333333333333
5577, 0.26666666666667, 0.56666666666667, 0.43333333333333
5578, 0.26666666666667, 0.62, 0.43333333333333
5579, 0.26666666666667, 0.67333333333333, 0.43333333333333
5580, 0.26666666666667, 0.72666666666667, 0.43333333333333
5581, 0.26666666666667, 0.78, 0.43333333333333
5582, 0.26666666666667, 0.83333333333333, 0.43333333333333
5583, 0.26666666666667, 0.88666666666667, 0.43333333333333
5584, 0.26666666666667, 0.94, 0.43333333333333
5585, 0.26666666666667, 0.99333333333333, 0.43333333333333
5586, 0.26666666666667, 1.0466666666667, 0.43333333333333
5587, 0.26666666666667, 0.35333333333333, 0.46666666666667
5588, 0.26666666666667, 0.40666666666667, 0.46666666666667
5589, 0.26666666666667, 0.46, 0.46666666666667
5590, 0.26666666666667, 0.51333333333333, 0.46666666666667
5591, 0.26666666666667, 0.56666666666667, 0.46666666666667
5592, 0.26666666666667, 0.62, 0.46666666666667
5593, 0.26666666666667, 0.67333333333333, 0.46666666666667
5594, 0.26666666666667, 0.72666666666667, 0.46666666666667
5595, 0.26666666666667, 0.78, 0.46666666666667
5596, 0.26666666666667, 0.83333333333333, 0.46666666666667
5597, 0.26666666666667, 0.88666666666667, 0.46666666666667
5598, 0.26666666666667, 0.94, 0.46666666666667
5599, 0.26666666666667, 0.99333333333333, 0.46666666666667
5600, 0.26666666666667, 1.0466666666667, 0.46666666666667
5601, 0.33333333333333, 0.35333333333333, 0.033333333333333
5602, 0.33333333333333, 0.40666666666667, 0.033333333333333
5603, 0.33333333333333, 0.46, 0.033333333333333
5604, 0.33333333333333, 0.51333333333333, 0.033333333333333
5605, 0.33333333333333, 0.56666666666667, 0.033333333333333
5606, 0.33333333333333, 0.62, 0.033333333333333
5607, 0.33333333333333, 0.67333333333333, 0.033333333333333
5608, 0.33333333333333, 0.72666666666667, 0.033333333333333
5609, 0.33333333333333, 0.78, 0.033333333333333
5610, 0.33333333333333, 0.83333333333333, 0.033333333333333
5611, 0.33333333333333, 0.88666666666667, 0.033333333333333
5612, 0.33333333333333, 0.94, 0.033333333333333
5613, 0.33333333333333, 0.99333333333333, 0.033333333333333
5614, 0.33333333333333, 1.0466666666667, 0.033333333333333
5615, 0.33333333333333, 0.35333333333333, 0.066666666666667
5616, 0.33333333333333, 0.40666666666667, 0.066666666666667
5617, 0.33333333333333, 0.46, 0.066666666666667
5618, 0.33333333333333, 0.51333333333333, 0.066666666666667
5619, 0.33333333333333, 0.56666666666667, 0.066666666666667
5620, 0.33333333333333, 0.62, 0.066666666666667
5621, 0.33333333333333, 0.67333333333333, 0.066666666666667
5622, 0.33333333333333, 0.72666666666667, 0.066666666666667
5623, 0.33333333333333, 0.78, 0.066666666666667
5624, 0.33333333333333, 0.83333333333333, 0.066666666666667
5625, 0.33333333333333, 0.88666666666667, 0.066666666666667
5626, 0.33333333333333, 0.94, 0.066666666666667
5627, 0.33333333333333, 0.99333333333333, 0.066666666666667
5628, 0.33333333333333, 1.0466666666667, 0.066666666666667
5629, 0.33333333333333, 0.35333333333333, 0.1
5630, 0.33333333333333, 0.40666666666667, 0.1
5631, 0.33333333333333, 0.46, 0.1
5632, 0.33333333333333, 0.51333333333333, 0.1
5633, 0.33333333333333, 0.56666666666667, 0.1
5634, 0.33333333333333, 0.62, 0.1
5635, 0.33333333333333, 0.67333333333333, 0.1
5636, 0.33333333333333, 0.72666666666667, 0.1
5637, 0.33333333333333, 0.78, 0.1
5638, 0.33333333333333, 0.83333333333333, 0.1
5639, 0.33333333333333, 0.88666666666667, 0.1
5640, 0.33333333333333, 0.94, 0.1
5641, 0.33333333333333, 0.99333333333333, 0.1
5642, 0.33333333333333, 1.0466666666667, 0.1
5643, 0.33333333333333, 0.35333333333333, 0.13333333333333
5644, 0.33333333333333, 0.40666666666667, 0.13333333333333
5645, 0.33333333333333, 0.46, 0.13333333333333
5646, 0.33333333333333, 0.51333333333333, 0.13333333333333
5647, 0.33333333333333, 0.56666666666667, 0.13333333333333
5648, 0.33333333333333, 0.62, 0.13333333333333
5649, 0.33333333333333, 0.67333333333333, 0.13333333333333
5650, 0.33333333333333, 0.72666666666667, 0.13333333333333
5651, 0.33333333333333, 0.78, 0.13333333333333
5652, 0.33333333333333, 0.83333333333333, 0.13333333333333
5653, 0.33333333333333, 0.88666666666667, 0.13333333333333
5654, 0.33333333333333, 0.94, 0.13333333333333
5655, 0.33333333333333, 0.99333333333333, 0.13333333333333
5656, 0.33333333333333, 1.0466666666667, 0.13333333333333
5657, 0.33333333333333, 0.35333333333333, 0.16666666666667
5658, 0.33333333333333, 0.40666666666667, 0.16666666666667
5659, 0.33333333333333, 0.46, 0.16666666666667
5660, 0.33333333333333, 0.51333333333333, 0.16666666666667
5661, 0.33333333333333, 0.56666666666667, 0.16666666666667
5662, 0.33333333333333, 0.62, 0.16666666666667
5663, 0.33333333333333, 0.67333333333333, 0.16666666666667
5664, 0.33333333333333, 0.72666666666667, 0.16666666666667
5665, 0.33333333333333, 0.78, 0.16666666666667
5666, 0.33333333333333, 0.83333333333333, 0.16666666666667
5667, 0.33333333333333, 0.88666666666667, 0.16666666666667
5668, 0.33333333333333, 0.94, 0.16666666666667
5669, 0.33333333333333, 0.99333333333333, 0.16666666666667
5670, 0.33333333333333, 1.0466666666667, 0.16666666666667
5671, 0.33333333333333, 0.35333333333333, 0.2
5672, 0.33333333333333, 0.40666666666667, 0.2
5673, 0.33333333333333, 0.46, 0.2
5674, 0.33333333333333, 0.51333333333333, 0.2
5675, 0.33333333333333, 0.56666666666667, 0.2
5676, 0.33333333333333, 0.62, 0.2
5677, 0.33333333333333, 0.67333333333333, 0.2
5678, 0.33333333333333, 0.72666666666667, 0.2
5679, 0.33333333333333, 0.78, 0.2
5680, 0.33333333333333, 0.83333333333333, 0.2
5681, 0.33333333333333, 0.88666666666667, 0.2
5682, 0.33333333333333, 0.94, 0.2
5683, 0.33333333333333, 0.99333333333333, 0.2
5684, 0.33333333333333, 1.0466666666667, 0.2
5685, 0.33333333333333, 0.35333333333333, 0.23333333333333
5686, 0.33333333333333, 0.40666666666667, 0.23333333333333
5687, 0.33333333333333, 0.46, 0.23333333333333
5688, 0.33333333333333, 0.51333333333333, 0.23333333333333
5689, 0.33333333333333, 0.56666666666667, 0.23333333333333
5690, 0.33333333333333, 0.62, 0.23333333333333
5691, 0.33333333333333, 0.67333333333333, 0.23333333333333
5692, 0.33333333333333, 0.72666666666667, 0.23333333333333
5693, 0.33333333333333, 0.78, 0.23333333333333
5694, 0.33333333333333, 0.83333333333333, 0.23333333333333
5695, 0.33333333333333, 0.88666666666667, 0.23333333333333
5696, 0.33333333333333, 0.94, 0.23333333333333
5697, 0.33333333333333, 0.99333333333333, 0.23333333333333
5698, 0.33333333333333, 1.0466666666667, 0.23333333333333
5699, 0.33333333333333, 0.35333333333333, 0.26666666666667
5700, 0.33333333333333, 0.40666666666667, 0.26666666666667
5701, 0.33333333333333, 0.46, 0.26666666666667
5702, 0.33333333333333, 0.51333333333333, 0.26666666666667
5703, 0.33333333333333, 0.56666666666667, 0.26666666666667
5704, 0.33333333333333, 0.62, 0.26666666666667
5705, 0.33333333333333, 0.67333333333333, 0.26666666666667
5706, 0.33333333333333, 0.72666666666667, 0.26666666666667
5707, 0.33333333333333, 0.78, 0.26666666666667
5708, 0.33333333333333, 0.83333333333333, 0.26666666666667
5709, 0.33333333333333, 0.88666666666667, 0.26666666666667
5710, 0.33333333333333, 0.94, 0.26666666666667
5711, 0.33333333333333, 0.99333333333333, 0.26666666666667
5712, 0.33333333333333, 1.0466666666667, 0.26666666666667
5713, 0.33333333333333, 0.35333333333333, 0.3
5714, 0.33333333333333, 0.40666666666667, 0.3
5715, 0.33333333333333, 0.46, 0.3
5716, 0.33333333333333, 0.51333333333333, 0.3
5717, 0.33333333333333, 0.56666666666667, 0.3
5718, 0.33333333333333, 0.62, 0.3
5719, 0.33333333333333, 0.67333333333333, 0.3
5720, 0.33333333333333, 0.72666666666667, 0.3
5721, 0.33333333333333, 0.78, 0.3
5722, 0.33333333333333, 0.83333333333333, 0.3
5723, 0.33333333333333, 0.88666666666667, 0.3
5724, 0.33333333333333, 0.94, 0.3
5725, 0.33333333333333, 0.99333333333333, 0.3
5726, 0.33333333333333, 1.0466666666667, 0.3
5727, 0.33333333333333, 0.35333333333333, 0.33333333333333
5728, 0.33333333333333, 0.40666666666667, 0.33333333333333
5729, 0.33333333333333, 0.46, 0.33333333333333
5730, 0.33333333333333, 0.51333333333333, 0.33333333333333
5731, 0.33333333333333, 0.56666666666667, 0.33333333333333
5732, 0.33333333333333, 0.62, 0.33333333333333
5733, 0.33333333333333, 0.67333333333333, 0.33333333333333
5734, 0.33333333333333, 0.72666666666667, 0.33333333333333
5735, 0.33333333333333, 0.78, 0.33333333333333
5736, 0.33333333333333, 0.83333333333333, 0.33333333333333
5737, 0.33333333333333, 0.88666666666667, 0.33333333333333
5738, 0.33333333333333, 0.94, 0.33333333333333
5739, 0.33333333333333, 0.99333333333333, 0.33333333333333
5740, 0.33333333333333, 1.0466666666667, 0.33333333333333
5741, 0.33333333333333, 0.35333333333333, 0.36666666666667
5742, 0.33333333333333, 0.40666666666667, 0.36666666666667
5743, 0.33333333333333, 0.46, 0.36666666666667
5744, 0.33333333333333, 0.51333333333333, 0.36666666666667
5745, 0.33333333333333, 0.56666666666667, 0.36666666666667
5746, 0.33333333333333, 0.62, 0.36666666666667
5747, 0.33333333333333, 0.67333333333333, 0.36666666666667
5748, 0.33333333333333, 0.72666666666667, 0.36666666666667
5749, 0.33333333333333, 0.78, 0.36666666666667
5750, 0.33333333333333, 0.83333333333333, 0.36666666666667
5751, 0.33333333333333, 0.88666666666667, 0.36666666666667
5752, 0.33333333333333, 0.94, 0.36666666666667
5753, 0.33333333333333, 0.99333333333333, 0.36666666666667
5754, 0.33333333333333, 1.0466666666667, 0.36666666666667
5755, 0.33333333333333, 0.35333333333333, 0.4
5756, 0.33333333333333, 0.40666666666667, 0.4
5757, 0.33333333333333, 0.46, 0.4
5758, 0.33333333333333, 0.51333333333333, 0.4
5759, 0.33333333333333, 0.56666666666667, 0.4
5760, 0.33333333333333, 0.62, 0.4
5761, 0.33333333333333, 0.67333333333333, 0.4
5762, 0.33333333333333, 0.72666666666667, 0.4
5763, 0.33333333333333, 0.78, 0.4
5764, 0.33333333333333, 0.83333333333333, 0.4
5765, 0.33333333333333, 0.88666666666667, 0.4
5766, 0.33333333333333, 0.94, 0.4
5767, 0.33333333333333, 0.99333333333333, 0.4
5768, 0.33333333333333, 1.0466666666667, 0.4
5769, 0.33333333333333, 0.35333333333333, 0.43333333333333
5770, 0.33333333333333, 0.40666666666667, 0.43333333333333
5771, 0.33333333333333, 0.46, 0.43333333333333
5772, 0.33333333333333, 0.51333333333333, 0.43333333333333
5773, 0.33333333333333, 0.56666666666667, 0.43333333333333
5774, 0.33333333333333, 0.62, 0.43333333333333
5775, 0.33333333333333, 0.67333333333333, 0.43333333333333
5776, 0.33333333333333, 0.72666666666667, 0.43333333333333
5777, 0.33333333333333, 0.78, 0.43333333333333
5778, 0.33333333333333, 0.83333333333333, 0.43333333333333
5779, 0.33333333333333, 0.88666666666667, 0.43333333333333
5780, 0.33333333333333, 0.94, 0.43333333333333
5781, 0.33333333333333, 0.99333333333333, 0.43333333333333
5782, 0.33333333333333, 1.0466666666667, 0.43333333333333
5783, 0.33333333333333, 0.35333333333333, 0.46666666666667
5784, 0.33333333333333, 0.40666666666667, 0.46666666666667
5785, 0.33333333333333, 0.46, 0.46666666666667
5786, 0.33333333333333, 0.51333333333333, 0.46666666666667
5787, 0.33333333333333, 0.56666666666667, 0.46666666666667
5788, 0.33333333333333, 0.62, 0.46666666666667
5789, 0.33333333333333, 0.67333333333333, 0.46666666666667
5790, 0.33333333333333, 0.72666666666667, 0.46666666666667
5791, 0.33333333333333, 0.78, 0.46666666666667
5792, 0.33333333333333, 0.83333333333333, 0.46666666666667
5793, 0.33333333333333, 0.88666666666667, 0.46666666666667
5794, 0.33333333333333, 0.94, 0.46666666666667
5795, 0.33333333333333, 0.99333333333333, 0.46666666666667
5796, 0.33333333333333, 1.0466666666667, 0.46666666666667
5797, 0.4, 0.35333333333333, 0.033333333333333
5798, 0.4, 0.40666666666667, 0.033333333333333
5799, 0.4, 0.46, 0.033333333333333
5800, 0.4, 0.51333333333333, 0.033333333333333
5801, 0.4, 0.56666666666667, 0.033333333333333
5802, 0.4, 0.62, 0.033333333333333
5803, 0.4, 0.67333333333333, 0.033333333333333
5804, 0.4, 0.72666666666667, 0.033333333333333
5805, 0.4, 0.78, 0.033333333333333
5806, 0.4, 0.83333333333333, 0.033333333333333
5807, 0.4, 0.88666666666667, 0.033333333333333
5808, 0.4, 0.94, 0.033333333333333
5809, 0.4, 0.99333333333333, 0.033333333333333
5810, 0.4, 1.0466666666667, 0.033333333333333
5811, 0.4, 0.35333333333333, 0.066666666666667
5812, 0.4, 0.40666666666667, 0.066666666666667
5813, 0.4, 0.46, 0.066666666666667
5814, 0.4, 0.51333333333333, 0.066666666666667
5815, 0.4, 0.56666666666667, 0.066666666666667
5816, 0.4, 0.62, 0.066666666666667
5817, 0.4, 0.67333333333333, 0.066666666666667
5818, 0.4, 0.72666666666667, 0.066666666666667
5819, 0.4, 0.78, 0.066666666666667
5820, 0.4, 0.83333333333333, 0.066666666666667
5821, 0.4, 0.88666666666667, 0.066666666666667
5822, 0.4, 0.94, 0.066666666666667
5823, 0.4, 0.99333333333333, 0.066666666666667
5824, 0.4, 1.0466666666667, 0.066666666666667
5825, 0.4, 0.35333333333333, 0.1
5826, 0.4, 0.40666666666667, 0.1
5827, 0.4, 0.46, 0.1
5828, 0.4, 0.51333333333333, 0.1
5829, 0.4, 0.56666666666667, 0.1
5830, 0.4, 0.62, 0.1
5831, 0.4, 0.67333333333333, 0.1
5832, 0.4, 0.72666666666667, 0.1
5833, 0.4, 0.78, 0.1
5834, 0.4, 0.83333333333333, 0.1
5835, 0.4, 0.88666666666667, 0.1
5836, 0.4, 0.94, 0.1
5837, 0.4, 0.99333333333333, 0.1
5838, 0.4, 1.0466666666667, 0.1
5839, 0.4, 0.35333333333333, 0.13333333333333
5840, 0.4, 0.40666666666667, 0.13333333333333
5841, 0.4, 0.46, 0.13333333333333
5842, 0.4, 0.51333333333333, 0.13333333333333
5843, 0.4, 0.56666666666667, 0.13333333333333
5844, 0.4, 0.62, 0.13333333333333
5845, 0.4, 0.67333333333333, 0.13333333333333
5846, 0.4, 0.72666666666667, 0.13333333333333
5847, 0.4, 0.78, 0.13333333333333
5848, 0.4, 0.83333333333333, 0.13333333333333
5849, 0.4, 0.88666666666667, 0.13333333333333
5850, 0.4, 0.94, 0.13333333333333
5851, 0.4, 0.99333333333333, 0.13333333333333
5852, 0.4, 1.0466666666667, 0.13333333333333
5853, 0.4, 0.35333333333333, 0.16666666666667
5854, 0.4, 0.40666666666667, 0.16666666666667
5855, 0.4, 0.46, 0.16666666666667
5856, 0.4, 0.51333333333333, 0.16666666666667
5857, 0.4, 0.56666666666667, 0.16666666666667
5858, 0.4, 0.62, 0.16666666666667
5859, 0.4, 0.67333333333333, 0.16666666666667
5860, 0.4, 0.72666666666667, 0.16666666666667
5861, 0.4, 0.78, 0.16666666666667
5862, 0.4, 0.83333333333333, 0.16666666666667
5863, 0.4, 0.88666666666667, 0.16666666666667
5864, 0.4, 0.94, 0.16666666666667
5865, 0.4, 0.99333333333333, 0.16666666666667
5866, 0.4, 1.0466666666667, 0.16666666666667
5867, 0.4, 0.35333333333333, 0.2
5868, 0.4, 0.40666666666667, 0.2
5869, 0.4, 0.46, 0.2
5870, 0.4, 0.51333333333333, 0.2
5871, 0.4, 0.56666666666667, 0.2
5872, 0.4, 0.62, 0.2
5873, 0.4, 0.67333333333333, 0.2
5874, 0.4, 0.72666666666667, 0.2
5875, 0.4, 0.78, 0.2
5876, 0.4, 0.83333333333333, 0.2
5877, 0.4, 0.88666666666667, 0.2
5878, 0.4, 0.94, 0.2
5879, 0.4, 0.99333333333333, 0.2
5880, 0.4, 1.0466666666667, 0.2
5881, 0.4, 0.35333333333333, 0.23333333333333
5882, 0.4, 0.40666666666667, 0.23333333333333
5883, 0.4, 0.46, 0.23333333333333
5884, 0.4, 0.51333333333333, 0.23333333333333
5885, 0.4, 0.56666666666667, 0.23333333333333
5886, 0.4, 0.62, 0.23333333333333
5887, 0.4, 0.67333333333333, 0.23333333333333
5888, 0.4, 0.72666666666667, 0.23333333333333
5889, 0.4, 0.78, 0.23333333333333
5890, 0.4, 0.83333333333333, 0.23333333333333
5891, 0.4, 0.88666666666667, 0.23333333333333
5892, 0.4, 0.94, 0.23333333333333
5893, 0.4, 0.99333333333333, 0.23333333333333
5894, 0.4, 1.0466666666667, 0.23333333333333
5895, 0.4, 0.35333333333333, 0.26666666666667
5896, 0.4, 0.40666666666667, 0.26666666666667
5897, 0.4, 0.46, 0.26666666666667
5898, 0.4, 0.51333333333333, 0.26666666666667
5899, 0.4, 0.56666666666667, 0.26666666666667
5900, 0.4, 0.62, 0.26666666666667
5901, 0.4, 0.67333333333333, 0.26666666666667
5902, 0.4, 0.72666666666667, 0.26666666666667
5903, 0.4, 0.78, 0.26666666666667
5904, 0.4, 0.83333333333333, 0.26666666666667
5905, 0.4, 0.88666666666667, 0.26666666666667
5906, 0.4, 0.94, 0.26666666666667
5907, 0.4, 0.99333333333333, 0.26666666666667
5908, 0.4, 1.0466666666667, 0.26666666666667
5909, 0.4, 0.35333333333333, 0.3
5910, 0.4, 0.40666666666667, 0.3
5911, 0.4, 0.46, 0.3
5912, 0.4, 0.51333333333333, 0.3
5913, 0.4, 0.56666666666667, 0.3
5914, 0.4, 0.62, 0.3
5915, 0.4, 0.67333333333333, 0.3
5916, 0.4, 0.72666666666667, 0.3
5917, 0.4, 0.78, 0.3
5918, 0.4, 0.83333333333333, 0.3
5919, 0.4, 0.88666666666667, 0.3
5920, 0.4, 0.94, 0.3
5921, 0.4, 0.99333333333333, 0.3
5922, 0.4, 1.0466666666667, 0.3
5923, 0.4, 0.35333333333333, 0.33333333333333
5924, 0.4, 0.40666666666667, 0.33333333333333
5925, 0.4, 0.46, 0.33333333333333
5926, 0.4, 0.51333333333333, 0.33333333333333
5927, 0.4, 0.56666666666667, 0.33333333333333
5928, 0.4, 0.62, 0.33333333333333
5929, 0.4, 0.67333333333333, 0.33333333333333
5930, 0.4, 0.72666666666667, 0.33333333333333
5931, 0.4, 0.78, 0.33333333333333
5932, 0.4, 0.83333333333333, 0.33333333333333
5933, 0.4, 0.88666666666667, 0.33333333333333
5934, 0.4, 0.94, 0.33333333333333
5935, 0.4, 0.99333333333333, 0.33333333333333
5936, 0.4, 1.0466666666667, 0.33333333333333
5937, 0.4, 0.35333333333333, 0.36666666666667
5938, 0.4, 0.40666666666667, 0.36666666666667
5939, 0.4, 0.46, 0.36666666666667
5940, 0.4, 0.51333333333333, 0.36666666666667
5941, 0.4, 0.56666666666667, 0.36666666666667
5942, 0.4, 0.62, 0.36666666666667
5943, 0.4, 0.67333333333333, 0.36666666666667
5944, 0.4, 0.72666666666667, 0.36666666666667
5945, 0.4, 0.78, 0.36666666666667
5946, 0.4, 0.83333333333333, 0.36666666666667
5947, 0.4, 0.88666666666667, 0.36666666666667
5948, 0.4, 0.94, 0.36666666666667
5949, 0.4, 0.99333333333333, 0.36666666666667
5950, 0.4, 1.0466666666667, 0.36666666666667
5951, 0.4, 0.35333333333333, 0.4
5952, 0.4, 0.40666666666667, 0.4
5953, 0.4, 0.46, 0.4
5954, 0.4, 0.51333333333333, 0.4
5955, 0.4, 0.56666666666667, 0.4
5956, 0.4, 0.62, 0.4
5957, 0.4, 0.67333333333333, 0.4
5958, 0.4, 0.72666666666667, 0.4
5959, 0.4, 0.78, 0.4
5960, 0.4, 0.83333333333333, 0.4
5961, 0.4, 0.88666666666667, 0.4
5962, 0.4, 0.94, 0.4
5963, 0.4, 0.99333333333333, 0.4
5964, 0.4, 1.0466666666667, 0.4
5965, 0.4, 0.35333333333333, 0.43333333333333
5966, 0.4, 0.40666666666667, 0.43333333333333
5967, 0.4, 0.46, 0.43333333333333
5968, 0.4, 0.51333333333333, 0.43333333333333
5969, 0.4, 0.56666666666667, 0.43333333333333
5970, 0.4, 0.62, 0.43333333333333
5971, 0.4, 0.67333333333333, 0.43333333333333
5972, 0.4, 0.72666666666667, 0.43333333333333
5973, 0.4, 0.78, 0.43333333333333
5974, 0.4, 0.83333333333333, 0.43333333333333
5975, 0.4, 0.88666666666667, 0.43333333333333
5976, 0.4, 0.94, 0.43333333333333
5977, 0.4, 0.99333333333333, 0.43333333333333
5978, 0.4, 1.0466666666667, 0.43333333333333
5979, 0.4, 0.35333333333333, 0.46666666666667
5980, 0.4, 0.40666666666667, 0.46666666666667
5981, 0.4, 0.46, 0.46666666666667
5982, 0.4, 0.51333333333333, 0.46666666666667
5983, 0.4, 0.56666666666667, 0.46666666666667
5984, 0.4, 0.62, 0.46666666666667
5985, 0.4, 0.67333333333333, 0.46666666666667
5986, 0.4, 0.72666666666667, 0.46666666666667
5987, 0.4, 0.78, 0.46666666666667
5988, 0.4, 0.83333333333333, 0.46666666666667
5989, 0.4, 0.88666666666667, 0.46666666666667
5990, 0.4, 0.94, 0.46666666666667
5991, 0.4, 0.99333333333333, 0.46666666666667
5992, 0.4, 1.0466666666667, 0.46666666666667
5993, 0.46666666666667, 0.35333333333333, 0.033333333333333
5994, 0.46666666666667, 0.40666666666667, 0.033333333333333
5995, 0.46666666666667, 0.46, 0.033333333333333
5996, 0.46666666666667, 0.51333333333333, 0.033333333333333
5997, 0.46666666666667, 0.56666666666667, 0.033333333333333
5998, 0.46666666666667, 0.62, 0.033333333333333
5999, 0.46666666666667, 0.67333333333333, 0.033333333333333
6000, 0.46666666666667, 0.72666666666667, 0.033333333333333
6001, 0.46666666666667, 0.78, 0.033333333333333
6002, 0.46666666666667, 0.83333333333333, 0.033333333333333
6003, 0.46666666666667, 0.88666666666667, 0.033333333333333
6004, 0.46666666666667, 0.94, 0.033333333333333
6005, 0.46666666666667, 0.99333333333333, 0.033333333333333
6006, 0.46666666666667, 1.0466666666667, 0.033333333333333
6007, 0.46666666666667, 0.35333333333333, 0.066666666666667
6008, 0.46666666666667, 0.40666666666667, 0.066666666666667
6009, 0.46666666666667, 0.46, 0.066666666666667
6010, 0.46666666666667, 0.51333333333333, 0.066666666666667
6011, 0.46666666666667, 0.56666666666667, 0.066666666666667
6012, 0.46666666666667, 0.62, 0.066666666666667
6013, 0.46666666666667, 0.67333333333333, 0.066666666666667
6014, 0.46666666666667, 0.72666666666667, 0.066666666666667
6015, 0.46666666666667, 0.78, 0.066666666666667
6016, 0.46666666666667, 0.83333333333333, 0.066666666666667
6017, 0.46666666666667, 0.88666666666667, 0.066666666666667
6018, 0.46666666666667, 0.94, 0.066666666666667
6019, 0.46666666666667, 0.99333333333333, 0.066666666666667
6020, 0.46666666666667, 1.0466666666667, 0.066666666666667
6021, 0.46666666666667, 0.35333333333333, 0.1
6022, 0.46666666666667, 0.40666666666667, 0.1
6023, 0.46666666666667, 0.46, 0.1
6024, 0.46666666666667, 0.51333333333333, 0.1
6025, 0.46666666666667, 0.56666666666667, 0.1
6026, 0.46666666666667, 0.62, 0.1
6027, 0.46666666666667, 0.67333333333333, 0.1
6028, 0.46666666666667, 0.72666666666667, 0.1
6029, 0.46666666666667, 0.78, 0.1
6030, 0.46666666666667, 0.83333333333333, 0.1
6031, 0.46666666666667, 0.88666666666667, 0.1
6032, 0.46666666666667, 0.94, 0.1
6033, 0.46666666666667, 0.99333333333333, 0.1
6034, 0.46666666666667, 1.0466666666667, 0.1
6035, 0.46666666666667, 0.35333333333333, 0.13333333333333
6036, 0.46666666666667, 0.40666666666667, 0.13333333333333
6037, 0.46666666666667, 0.46, 0.13333333333333
6038, 0.46666666666667, 0.51333333333333, 0.13333333333333
6039, 0.46666666666667, 0.56666666666667, 0.13333333333333
6040, 0.46666666666667, 0.62, 0.13333333333333
6041, 0.46666666666667, 0.67333333333333, 0.13333333333333
6042, 0.46666666666667, 0.72666666666667, 0.13333333333333
6043, 0.46666666666667, 0.78, 0.13333333333333
6044, 0.46666666666667, 0.83333333333333, 0.13333333333333
6045, 0.46666666666667, 0.88666666666667, 0.13333333333333
6046, 0.46666666666667, 0.94, 0.13333333333333
6047, 0.46666666666667, 0.99333333333333, 0.13333333333333
6048, 0.46666666666667, 1.0466666666667, 0.13333333333333
6049, 0.46666666666667, 0.35333333333333, 0.16666666666667
6050, 0.46666666666667, 0.40666666666667, 0.16666666666667
6051, 0.46666666666667, 0.46, 0.16666666666667
6052, 0.46666666666667, 0.51333333333333, 0.16666666666667
6053, 0.46666666666667, 0.56666666666667, 0.16666666666667
6054, 0.46666666666667, 0.62, 0.16666666666667
6055, 0.46666666666667, 0.67333333333333, 0.16666666666667
6056, 0.46666666666667, 0.72666666666667, 0.16666666666667
6057, 0.46666666666667, 0.78, 0.16666666666667
6058, 0.46666666666667, 0.83333333333333, 0.16666666666667
6059, 0.46666666666667, 0.88666666666667, 0.16666666666667
6060, 0.46666666666667, 0.94, 0.16666666666667
6061, 0.46666666666667, 0.99333333333333, 0.16666666666667
6062, 0.46666666666667, 1.0466666666667, 0.16666666666667
6063, 0.46666666666667, 0.35333333333333, 0.2
6064, 0.46666666666667, 0.40666666666667, 0.2
6065, 0.46666666666667, 0.46, 0.2
6066, 0.46666666666667, 0.51333333333333, 0.2
6067, 0.46666666666667, 0.56666666666667, 0.2
6068, 0.46666666666667, 0.62, 0.2
6069, 0.46666666666667, 0.67333333333333, 0.2
6070, 0.46666666666667, 0.72666666666667, 0.2
6071, 0.46666666666667, 0.78, 0.2
6072, 0.46666666666667, 0.83333333333333, 0.2
6073, 0.46666666666667, 0.88666666666667, 0.2
6074, 0.46666666666667, 0.94, 0.2
6075, 0.46666666666667, 0.99333333333333, 0.2
6076, 0.46666666666667, 1.0466666666667, 0.2
6077, 0.46666666666667, 0.35333333333333, 0.23333333333333
6078, 0.46666666666667, 0.40666666666667, 0.23333333333333
6079, 0.46666666666667, 0.46, 0.23333333333333
6080, 0.46666666666667, 0.51333333333333, 0.23333333333333
6081, 0.46666666666667, 0.56666666666667, 0.23333333333333
6082, 0.46666666666667, 0.62, 0.23333333333333
6083, 0.46666666666667, 0.67333333333333, 0.23333333333333
6084, 0.46666666666667, 0.72666666666667, 0.23333333333333
6085, 0.46666666666667, 0.78, 0.23333333333333
6086, 0.46666666666667, 0.83333333333333, 0.23333333333333
6087, 0.46666666666667, 0.88666666666667, 0.23333333333333
6088, 0.46666666666667, 0.94, 0.23333333333333
6089, 0.46666666666667, 0.99333333333333, 0.23333333333333
6090, 0.46666666666667, 1.0466666666667, 0.23333333333333
6091, 0.46666666666667, 0.35333333333333, 0.26666666666667
6092, 0.46666666666667, 0.40666666666667, 0.26666666666667
6093, 0.46666666666667, 0.46, 0.26666666666667
6094, 0.46666666666667, 0.51333333333333, 0.26666666666667
6095, 0.46666666666667, 0.56666666666667, 0.26666666666667
6096, 0.46666666666667, 0.62, 0.26666666666667
6097, 0.46666666666667, 0.67333333333333, 0.26666666666667
6098, 0.46666666666667, 0.72666666666667, 0.26666666666667
6099, 0.46666666666667, 0.78, 0.26666666666667
6100, 0.46666666666667, 0.83333333333333, 0.26666666666667
6101, 0.46666666666667, 0.88666666666667, 0.26666666666667
6102, 0.46666666666667, 0.94, 0.26666666666667
6103, 0.46666666666667, 0.99333333333333, 0.26666666666667
6104, 0.46666666666667, 1.0466666666667, 0.26666666666667
6105, 0.46666666666667, 0.35333333333333, 0.3
6106, 0.46666666666667, 0.40666666666667, 0.3
6107, 0.46666666666667, 0.46, 0.3
6108, 0.46666666666667, 0.51333333333333, 0.3
6109, 0.46666666666667, 0.56666666666667, 0.3
6110, 0.46666666666667, 0.62, 0.3
6111, 0.46666666666667, 0.67333333333333, 0.3
6112, 0.46666666666667, 0.72666666666667, 0.3
6113, 0.46666666666667, 0.78, 0.3
6114, 0.46666666666667, 0.83333333333333, 0.3
6115, 0.46666666666667, 0.88666666666667, 0.3
6116, 0.46666666666667, 0.94, 0.3
6117, 0.46666666666667, 0.99333333333333, 0.3
6118, 0.46666666666667, 1.0466666666667, 0.3
6119, 0.46666666666667, 0.35333333333333, 0.33333333333333
6120, 0.46666666666667, 0.40666666666667, 0.33333333333333
6121, 0.46666666666667, 0.46, 0.33333333333333
6122, 0.46666666666667, 0.51333333333333, 0.33333333333333
6123, 0.46666666666667, 0.56666666666667, 0.33333333333333
6124, 0.46666666666667, 0.62, 0.33333333333333
6125, 0.46666666666667, 0.67333333333333, 0.33333333333333
6126, 0.46666666666667, 0.72666666666667, 0.33333333333333
6127, 0.46666666666667, 0.78, 0.33333333333333
6128, 0.46666666666667, 0.83333333333333, 0.33333333333333
6129, 0.46666666666667, 0.88666666666667, 0.33333333333333
6130, 0.46666666666667, 0.94, 0.33333333333333
6131, 0.46666666666667, 0.99333333333333, 0.33333333333333
6132, 0.46666666666667, 1.0466666666667, 0.33333333333333
6133, 0.46666666666667, 0.35333333333333, 0.36666666666667
6134, 0.46666666666667, 0.40666666666667, 0.36666666666667
6135, 0.46666666666667, 0.46, 0.36666666666667
6136, 0.46666666666667, 0.51333333333333, 0.36666666666667
6137, 0.46666666666667, 0.56666666666667, 0.36666666666667
6138, 0.46666666666667, 0.62, 0.36666666666667
6139, 0.46666666666667, 0.67333333333333, 0.36666666666667
6140, 0.46666666666667, 0.72666666666667, 0.36666666666667
6141, 0.46666666666667, 0.78, 0.36666666666667
6142, 0.46666666666667, 0.83333333333333, 0.36666666666667
6143, 0.46666666666667, 0.88666666666667, 0.36666666666667
6144, 0.46666666666667, 0.94, 0.36666666666667
6145, 0.46666666666667, 0.99333333333333, 0.36666666666667
6146, 0.46666666666667, 1.0466666666667, 0.36666666666667
6147, 0.46666666666667, 0.35333333333333, 0.4
6148, 0.46666666666667, 0.40666666666667, 0.4
6149, 0.46666666666667, 0.46, 0.4
6150, 0.46666666666667, 0.51333333333333, 0.4
6151, 0.46666666666667, 0.56666666666667, 0.4
6152, 0.46666666666667, 0.62, 0.4
6153, 0.46666666666667, 0.67333333333333, 0.4
6154, 0.46666666666667, 0.72666666666667, 0.4
6155, 0.46666666666667, 0.78, 0.4
6156, 0.46666666666667, 0.83333333333333, 0.4
6157, 0.46666666666667, 0.88666666666667, 0.4
6158, 0.46666666666667, 0.94, 0.4
6159, 0.46666666666667, 0.99333333333333, 0.4
6160, 0.46666666666667, 1.0466666666667, 0.4
6161, 0.46666666666667, 0.35333333333333, 0.43333333333333
6162, 0.46666666666667, 0.40666666666667, 0.43333333333333
6163, 0.46666666666667, 0.46, 0.43333333333333
6164, 0.46666666666667, 0.51333333333333, 0.43333333333333
6165, 0.46666666666667, 0.56666666666667, 0.43333333333333
6166, 0.46666666666667, 0.62, 0.43333333333333
6167, 0.46666666666667, 0.67333333333333, 0.43333333333333
6168, 0.46666666666667, 0.72666666666667, 0.43333333333333
6169, 0.46666666666667, 0.78, 0.43333333333333
6170, 0.46666666666667, 0.83333333333333, 0.43333333333333
6171, 0.46666666666667, 0.88666666666667, 0.43333333333333
6172, 0.46666666666667, 0.94, 0.43333333333333
6173, 0.46666666666667, 0.99333333333333, 0.43333333333333
6174, 0.46666666666667, 1.0466666666667, 0.43333333333333
6175, 0.46666666666667, 0.35333333333333, 0.46666666666667
6176, 0.46666666666667, 0.40666666666667, 0.46666666666667
6177, 0.46666666666667, 0.46, 0.46666666666667
6178, 0.46666666666667, 0.51333333333333, 0.46666666666667
6179, 0.46666666666667, 0.56666666666667, 0.46666666666667
6180, 0.46666666666667, 0.62, 0.46666666666667
6181, 0.46666666666667, 0.67333333333333, 0.46666666666667
6182, 0.46666666666667, 0.72666666666667, 0.46666666666667
6183, 0.46666666666667, 0.78, 0.46666666666667
6184, 0.46666666666667, 0.83333333333333, 0.46666666666667
6185, 0.46666666666667, 0.88666666666667, 0.46666666666667
6186, 0.46666666666667, 0.94, 0.46666666666667
6187, 0.46666666666667, 0.99333333333333, 0.46666666666667
6188, 0.46666666666667, 1.0466666666667, 0.46666666666667
6189, 0.53333333333333, 0.35333333333333, 0.033333333333333
6190, 0.53333333333333, 0.40666666666667, 0.033333333333333
6191, 0.53333333333333, 0.46, 0.033333333333333
6192, 0.53333333333333, 0.51333333333333, 0.033333333333333
6193, 0.53333333333333, 0.56666666666667, 0.033333333333333
6194, 0.53333333333333, 0.62, 0.033333333333333
6195, 0.53333333333333, 0.67333333333333, 0.033333333333333
6196, 0.53333333333333, 0.72666666666667, 0.033333333333333
6197, 0.53333333333333, 0.78, 0.033333333333333
6198, 0.53333333333333, 0.83333333333333, 0.033333333333333
6199, 0.53333333333333, 0.88666666666667, 0.033333333333333
6200, 0.53333333333333, 0.94, 0.033333333333333
6201, 0.53333333333333, 0.99333333333333, 0.033333333333333
6202, 0.53333333333333, 1.0466666666667, 0.033333333333333
6203, 0.53333333333333, 0.35333333333333, 0.066666666666667
6204, 0.53333333333333, 0.40666666666667, 0.066666666666667
6205, 0.53333333333333, 0.46, 0.066666666666667
6206, 0.53333333333333, 0.51333333333333, 0.066666666666667
6207, 0.53333333333333, 0.56666666666667, 0.066666666666667
6208, 0.53333333333333, 0.62, 0.066666666666667
6209, 0.53333333333333, 0.67333333333333, 0.066666666666667
6210, 0.53333333333333, 0.72666666666667, 0.066666666666667
6211, 0.53333333333333, 0.78, 0.066666666666667
6212, 0.53333333333333, 0.83333333333333, 0.066666666666667
6213, 0.53333333333333, 0.88666666666667, 0.066666666666667
6214, 0.53333333333333, 0.94, 0.066666666666667
6215, 0.53333333333333, 0.99333333333333, 0.066666666666667
6216, 0.53333333333333, 1.0466666666667, 0.066666666666667
6217, 0.53333333333333, 0.35333333333333, 0.1
6218, 0.53333333333333, 0.40666666666667, 0.1
6219, 0.53333333333333, 0.46, 0.1
6220, 0.53333333333333, 0.51333333333333, 0.1
6221, 0.53333333333333, 0.56666666666667, 0.1
6222, 0.53333333333333, 0.62, 0.1
6223, 0.53333333333333, 0.67333333333333, 0.1
6224, 0.53333333333333, 0.72666666666667, 0.1
6225, 0.53333333333333, 0.78, 0.1
6226, 0.53333333333333, 0.83333333333333, 0.1
6227, 0.53333333333333, 0.88666666666667, 0.1
6228, 0.53333333333333, 0.94, 0.1
6229, 0.53333333333333, 0.99333333333333, 0.1
6230, 0.53333333333333, 1.0466666666667, 0.1
6231, 0.53333333333333, 0.35333333333333, 0.13333333333333
6232, 0.53333333333333, 0.40666666666667, 0.13333333333333
6233, 0.53333333333333, 0.46, 0.13333333333333
6234, 0.53333333333333, 0.51333333333333, 0.13333333333333
6235, 0.53333333333333, 0.56666666666667, 0.13333333333333
6236, 0.53333333333333, 0.62, 0.13333333333333
6237, 0.53333333333333, 0.67333333333333, 0.13333333333333
6238, 0.53333333333333, 0.72666666666667, 0.13333333333333
6239, 0.53333333333333, 0.78, 0.13333333333333
6240, 0.53333333333333, 0.83333333333333, 0.13333333333333
6241, 0.53333333333333, 0.88666666666667, 0.13333333333333
6242, 0.53333333333333, 0.94, 0.13333333333333
6243, 0.53333333333333, 0.99333333333333, 0.13333333333333
6244, 0.53333333333333, 1.0466666666667, 0.13333333333333
6245, 0.53333333333333, 0.35333333333333, 0.16666666666667
6246, 0.53333333333333, 0.40666666666667, 0.16666666666667
6247, 0.53333333333333, 0.46, 0.16666666666667
6248, 0.53333333333333, 0.51333333333333, 0.16666666666667
6249, 0.53333333333333, 0.56666666666667, 0.16666666666667
6250, 0.53333333333333, 0.62, 0.16666666666667
6251, 0.53333333333333, 0.67333333333333, 0.16666666666667
6252, 0.53333333333333, 0.72666666666667, 0.16666666666667
6253, 0.53333333333333, 0.78, 0.16666666666667
6254, 0.53333333333333, 0.83333333333333, 0.16666666666667
6255, 0.53333333333333, 0.88666666666667, 0.16666666666667
6256, 0.53333333333333, 0.94, 0.16666666666667
6257, 0.53333333333333, 0.99333333333333, 0.16666666666667
6258, 0.53333333333333, 1.0466666666667, 0.16666666666667
6259, 0.53333333333333, 0.35333333333333, 0.2
6260, 0.53333333333333, 0.40666666666667, 0.2
6261, 0.53333333333333, 0.46, 0.2
6262, 0.53333333333333, 0.51333333333333, 0.2
6263, 0.53333333333333, 0.56666666666667, 0.2
6264, 0.53333333333333, 0.62, 0.2
6265, 0.53333333333333, 0.67333333333333, 0.2
6266, 0.53333333333333, 0.72666666666667, 0.2
6267, 0.53333333333333, 0.78, 0.2
6268, 0.53333333333333, 0.83333333333333, 0.2
6269, 0.53333333333333, 0.88666666666667, 0.2
6270, 0.53333333333333, 0.94, 0.2
6271, 0.53333333333333, 0.99333333333333, 0.2
6272, 0.53333333333333, 1.0466666666667, 0.2
6273, 0.53333333333333, 0.35333333333333, 0.23333333333333
6274, 0.53333333333333, 0.40666666666667, 0.23333333333333
6275, 0.53333333333333, 0.46, 0.23333333333333
6276, 0.53333333333333, 0.51333333333333, 0.23333333333333
6277, 0.53333333333333, 0.56666666666667, 0.23333333333333
6278, 0.53333333333333, 0.62, 0.23333333333333
6279, 0.53333333333333, 0.67333333333333, 0.23333333333333
6280, 0.53333333333333, 0.72666666666667, 0.23333333333333
6281, 0.53333333333333, 0.78, 0.23333333333333
6282, 0.53333333333333, 0.83333333333333, 0.23333333333333
6283, 0.53333333333333, 0.88666666666667, 0.23333333333333
6284, 0.53333333333333, 0.94, 0.23333333333333
6285, 0.53333333333333, 0.99333333333333, 0.23333333333333
6286, 0.53333333333333, 1.0466666666667, 0.23333333333333
6287, 0.53333333333333, 0.35333333333333, 0.26666666666667
6288, 0.53333333333333, 0.40666666666667, 0.26666666666667
6289, 0.53333333333333, 0.46, 0.26666666666667
6290, 0.53333333333333, 0.51333333333333, 0.26666666666667
6291, 0.53333333333333, 0.56666666666667, 0.26666666666667
6292, 0.53333333333333, 0.62, 0.26666666666667
6293, 0.53333333333333, 0.67333333333333, 0.26666666666667
6294, 0.53333333333333, 0.72666666666667, 0.26666666666667
6295, 0.53333333333333, 0.78, 0.26666666666667
6296, 0.53333333333333, 0.83333333333333, 0.26666666666667
6297, 0.53333333333333, 0.88666666666667, 0.26666666666667
6298, 0.53333333333333, 0.94, 0.26666666666667
6299, 0.53333333333333, 0.99333333333333, 0.26666666666667
6300, 0.53333333333333, 1.0466666666667, 0.26666666666667
6301, 0.53333333333333, 0.35333333333333, 0.3
6302, 0.53333333333333, 0.40666666666667, 0.3
6303, 0.53333333333333, 0.46, 0.3
6304, 0.53333333333333, 0.51333333333333, 0.3
6305, 0.53333333333333, 0.56666666666667, 0.3
6306, 0.53333333333333, 0.62, 0.3
6307, 0.53333333333333, 0.67333333333333, 0.3
6308, 0.53333333333333, 0.72666666666667, 0.3
6309, 0.53333333333333, 0.78, 0.3
6310, 0.53333333333333, 0.83333333333333, 0.3
6311, 0.53333333333333, 0.88666666666667, 0.3
6312, 0.53333333333333, 0.94, 0.3
6313, 0.53333333333333, 0.99333333333333, 0.3
6314, 0.53333333333333, 1.0466666666667, 0.3
6315, 0.53333333333333, 0.35333333333333, 0.33333333333333
6316, 0.53333333333333, 0.40666666666667, 0.33333333333333
6317, 0.53333333333333, 0.46, 0.33333333333333
6318, 0.53333333333333, 0.51333333333333, 0.33333333333333
6319, 0.53333333333333, 0.56666666666667, 0.33333333333333
6320, 0.53333333333333, 0.62, 0.33333333333333
6321, 0.53333333333333, 0.67333333333333, 0.33333333333333
6322, 0.53333333333333, 0.72666666666667, 0.33333333333333
6323, 0.53333333333333, 0.78, 0.33333333333333
6324, 0.53333333333333, 0.83333333333333, 0.33333333333333
6325, 0.53333333333333, 0.88666666666667, 0.33333333333333
6326, 0.53333333333333, 0.94, 0.33333333333333
6327, 0.53333333333333, 0.99333333333333, 0.33333333333333
6328, 0.53333333333333, 1.0466666666667, 0.33333333333333
6329, 0.53333333333333, 0.35333333333333, 0.36666666666667
6330, 0.53333333333333, 0.40666666666667, 0.36666666666667
6331, 0.53333333333333, 0.46, 0.36666666666667
6332, 0.53333333333333, 0.51333333333333, 0.36666666666667
6333, 0.53333333333333, 0.56666666666667, 0.36666666666667
6334, 0.53333333333333, 0.62, 0.36666666666667
6335, 0.53333333333333, 0.67333333333333, 0.36666666666667
6336, 0.53333333333333, 0.72666666666667, 0.36666666666667
6337, 0.53333333333333, 0.78, 0.36666666666667
6338, 0.53333333333333, 0.83333333333333, 0.36666666666667
6339, 0.53333333333333, 0.88666666666667, 0.36666666666667
6340, 0.53333333333333, 0.94, 0.36666666666667
6341, 0.53333333333333, 0.99333333333333, 0.36666666666667
6342, 0.53333333333333, 1.0466666666667, 0.36666666666667
6343, 0.53333333333333, 0.35333333333333, 0.4
6344, 0.53333333333333, 0.40666666666667, 0.4
6345, 0.53333333333333, 0.46, 0.4
6346, 0.53333333333333, 0.51333333333333, 0.4
6347, 0.53333333333333, 0.56666666666667, 0.4
6348, 0.53333333333333, 0.62, 0.4
6349, 0.53333333333333, 0.67333333333333, 0.4
6350, 0.53333333333333, 0.72666666666667, 0.4
6351, 0.53333333333333, 0.78, 0.4
6352, 0.53333333333333, 0.83333333333333, 0.4
6353, 0.53333333333333, 0.88666666666667, 0.4
6354, 0.53333333333333, 0.94, 0.4
6355, 0.53333333333333, 0.99333333333333, 0.4
6356, 0.53333333333333, 1.0466666666667, 0.4
6357, 0.53333333333333, 0.35333333333333, 0.43333333333333
6358, 0.53333333333333, 0.40666666666667, 0.43333333333333
6359, 0.53333333333333, 0.46, 0.43333333333333
6360, 0.53333333333333, 0.51333333333333, 0.43333333333333
6361, 0.53333333333333, 0.56666666666667, 0.43333333333333
6362, 0.53333333333333, 0.62, 0.43333333333333
6363, 0.53333333333333, 0.67333333333333, 0.43333333333333
6364, 0.53333333333333, 0.72666666666667, 0.43333333333333
6365, 0.53333333333333, 0.78, 0.43333333333333
6366, 0.53333333333333, 0.83333333333333, 0.43333333333333
6367, 0.53333333333333, 0.88666666666667, 0.43333333333333
6368, 0.53333333333333, 0.94, 0.43333333333333
6369, 0.53333333333333, 0.99333333333333, 0.43333333333333
6370, 0.53333333333333, 1.0466666666667, 0.43333333333333
6371, 0.53333333333333, 0.35333333333333, 0.46666666666667
6372, 0.53333333333333, 0.40666666666667, 0.46666666666667
6373, 0.53333333333333, 0.46, 0.46666666666667
6374, 0.53333333333333, 0.51333333333333, 0.46666666666667
6375, 0.53333333333333, 0.56666666666667, 0.46666666666667
6376, 0.53333333333333, 0.62, 0.46666666666667
6377, 0.53333333333333, 0.67333333333333, 0.46666666666667
6378, 0.53333333333333, 0.72666666666667, 0.46666666666667
6379, 0.53333333333333, 0.78, 0.46666666666667
6380, 0.53333333333333, 0.83333333333333, 0.46666666666667
6381, 0.53333333333333, 0.88666666666667, 0.46666666666667
6382, 0.53333333333333, 0.94, 0.46666666666667
6383, 0.53333333333333, 0.99333333333333, 0.46666666666667
6384, 0.53333333333333, 1.0466666666667, 0.46666666666667
6385, 0.6, 0.35333333333333, 0.033333333333333
6386, 0.6, 0.40666666666667, 0.033333333333333
6387, 0.6, 0.46, 0.033333333333333
6388, 0.6, 0.51333333333333, 0.033333333333333
6389, 0.6, 0.56666666666667, 0.033333333333333
6390, 0.6, 0.62, 0.033333333333333
6391, 0.6, 0.67333333333333, 0.033333333333333
6392, 0.6, 0.72666666666667, 0.033333333333333
6393, 0.6, 0.78, 0.033333333333333
6394, 0.6, 0.83333333333333, 0.033333333333333
6395, 0.6, 0.88666666666667, 0.033333333333333
6396, 0.6, 0.94, 0.033333333333333
6397, 0.6, 0.99333333333333, 0.033333333333333
6398, 0.6, 1.0466666666667, 0.033333333333333
6399, 0.6, 0.35333333333333, 0.066666666666667
6400, 0.6, 0.40666666666667, 0.066666666666667
6401, 0.6, 0.46, 0.066666666666667
6402, 0.6, 0.51333333333333, 0.066666666666667
6403, 0.6, 0.56666666666667, 0.066666666666667
6404, 0.6, 0.62, 0.066666666666667
6405, 0.6, 0.67333333333333, 0.066666666666667
6406, 0.6, 0.72666666666667, 0.066666666666667
6407, 0.6, 0.78, 0.066666666666667
6408, 0.6, 0.83333333333333, 0.066666666666667
6409, 0.6, 0.88666666666667, 0.066666666666667
6410, 0.6, 0.94, 0.066666666666667
6411, 0.6, 0.99333333333333, 0.066666666666667
6412, 0.6, 1.0466666666667, 0.066666666666667
6413, 0.6, 0.35333333333333, 0.1
6414, 0.6, 0.40666666666667, 0.1
6415, 0.6, 0.46, 0.1
6416, 0.6, 0.51333333333333, 0.1
6417, 0.6, 0.56666666666667, 0.1
6418, 0.6, 0.62, 0.1
6419, 0.6, 0.67333333333333, 0.1
6420, 0.6, 0.72666666666667, 0.1
6421, 0.6, 0.78, 0.1
6422, 0.6, 0.83333333333333, 0.1
6423, 0.6, 0.88666666666667, 0.1
6424, 0.6, 0.94, 0.1
6425, 0.6, 0.99333333333333, 0.1
6426, 0.6, 1.0466666666667, 0.1
6427, 0.6, 0.35333333333333, 0.13333333333333
6428, 0.6, 0.40666666666667, 0.13333333333333
6429, 0.6, 0.46, 0.13333333333333
6430, 0.6, 0.51333333333333, 0.13333333333333
6431, 0.6, 0.56666666666667, 0.13333333333333
6432, 0.6, 0.62, 0.13333333333333
6433, 0.6, 0.67333333333333, 0.13333333333333
6434, 0.6, 0.72666666666667, 0.13333333333333
6435, 0.6, 0.78, 0.13333333333333
6436, 0.6, 0.83333333333333, 0.13333333333333
6437, 0.6, 0.88666666666667, 0.13333333333333
6438, 0.6, 0.94, 0.13333333333333
6439, 0.6, 0.99333333333333, 0.13333333333333
6440, 0.6, 1.0466666666667, 0.13333333333333
6441, 0.6, 0.35333333333333, 0.16666666666667
6442, 0.6, 0.40666666666667, 0.16666666666667
6443, 0.6, 0.46, 0.16666666666667
6444, 0.6, 0.51333333333333, 0.16666666666667
6445, 0.6, 0.56666666666667, 0.16666666666667
6446, 0.6, 0.62, 0.16666666666667
6447, 0.6, 0.67333333333333, 0.16666666666667
6448, 0.6, 0.72666666666667, 0.16666666666667
6449, 0.6, 0.78, 0.16666666666667
6450, 0.6, 0.83333333333333, 0.16666666666667
6451, 0.6, 0.88666666666667, 0.16666666666667
6452, 0.6, 0.94, 0.16666666666667
6453, 0.6, 0.99333333333333, 0.16666666666667
6454, 0.6, 1.0466666666667, 0.16666666666667
6455, 0.6, 0.35333333333333, 0.2
6456, 0.6, 0.40666666666667, 0.2
6457, 0.6, 0.46, 0.2
6458, 0.6, 0.51333333333333, 0.2
6459, 0.6, 0.56666666666667, 0.2
6460, 0.6, 0.62, 0.2
6461, 0.6, 0.67333333333333, 0.2
6462, 0.6, 0.72666666666667, 0.2
6463, 0.6, 0.78, 0.2
6464, 0.6, 0.83333333333333, 0.2
6465, 0.6, 0.88666666666667, 0.2
6466, 0.6, 0.94, 0.2
6467, 0.6, 0.99333333333333, 0.2
6468, 0.6, 1.0466666666667, 0.2
6469, 0.6, 0.35333333333333, 0.23333333333333
6470, 0.6, 0.40666666666667, 0.23333333333333
6471, 0.6, 0.46, 0.23333333333333
6472, 0.6, 0.51333333333333, 0.23333333333333
6473, 0.6, 0.56666666666667, 0.23333333333333
6474, 0.6, 0.62, 0.23333333333333
6475, 0.6, 0.67333333333333, 0.23333333333333
6476, 0.6, 0.72666666666667, 0.23333333333333
6477, 0.6, 0.78, 0.23333333333333
6478, 0.6, 0.83333333333333, 0.23333333333333
6479, 0.6, 0.88666666666667, 0.23333333333333
6480, 0.6, 0.94, 0.23333333333333
6481, 0.6, 0.99333333333333, 0.23333333333333
6482, 0.6, 1.0466666666667, 0.23333333333333
6483, 0.6, 0.35333333333333, 0.26666666666667
6484, 0.6, 0.40666666666667, 0.26666666666667
6485, 0.6, 0.46, 0.26666666666667
6486, 0.6, 0.51333333333333, 0.26666666666667
6487, 0.6, 0.56666666666667, 0.26666666666667
6488, 0.6, 0.62, 0.26666666666667
6489, 0.6, 0.67333333333333, 0.26666666666667
6490, 0.6, 0.72666666666667, 0.26666666666667
6491, 0.6, 0.78, 0.26666666666667
6492, 0.6, 0.83333333333333, 0.26666666666667
6493, 0.6, 0.88666666666667, 0.26666666666667
6494, 0.6, 0.94, 0.26666666666667
6495, 0.6, 0.99333333333333, 0.26666666666667
6496, 0.6, 1.0466666666667, 0.26666666666667
6497, 0.6, 0.35333333333333, 0.3
6498, 0.6, 0.40666666666667, 0.3
6499, 0.6, 0.46, 0.3
6500, 0.6, 0.51333333333333, 0.3
6501, 0.6, 0.56666666666667, 0.3
6502, 0.6, 0.62, 0.3
6503, 0.6, 0.67333333333333, 0.3
6504, 0.6, 0.72666666666667, 0.3
6505, 0.6, 0.78, 0.3
6506, 0.6, 0.83333333333333, 0.3
6507, 0.6, 0.88666666666667, 0.3
6508, 0.6, 0.94, 0.3
6509, 0.6, 0.99333333333333, 0.3
6510, 0.6, 1.0466666666667, 0.3
6511, 0.6, 0.35333333333333, 0.33333333333333
6512, 0.6, 0.40666666666667, 0.33333333333333
6513, 0.6, 0.46, 0.33333333333333
6514, 0.6, 0.51333333333333, 0.33333333333333
6515, 0.6, 0.56666666666667, 0.33333333333333
6516, 0.6, 0.62, 0.33333333333333
6517, 0.6, 0.67333333333333, 0.33333333333333
6518, 0.6, 0.72666666666667, 0.33333333333333
6519, 0.6, 0.78, 0.33333333333333
6520, 0.6, 0.83333333333333, 0.33333333333333
6521, 0.6, 0.88666666666667, 0.33333333333333
6522, 0.6, 0.94, 0.33333333333333
6523, 0.6, 0.99333333333333, 0.33333333333333
6524, 0.6, 1.0466666666667, 0.33333333333333
6525, 0.6, 0.35333333333333, 0.36666666666667
6526, 0.6, 0.40666666666667, 0.36666666666667
6527, 0.6, 0.46, 0.36666666666667
6528, 0.6, 0.51333333333333, 0.36666666666667
6529, 0.6, 0.56666666666667, 0.36666666666667
6530, 0.6, 0.62, 0.36666666666667
6531, 0.6, 0.67333333333333, 0.36666666666667
6532, 0.6, 0.72666666666667, 0.36666666666667
6533, 0.6, 0.78, 0.36666666666667
6534, 0.6, 0.83333333333333, 0.36666666666667
6535, 0.6, 0.88666666666667, 0.36666666666667
6536, 0.6, 0.94, 0.36666666666667
6537, 0.6, 0.99333333333333, 0.36666666666667
6538, 0.6, 1.0466666666667, 0.36666666666667
6539, 0.6, 0.35333333333333, 0.4
6540, 0.6, 0.40666666666667, 0.4
6541, 0.6, 0.46, 0.4
6542, 0.6, 0.51333333333333, 0.4
6543, 0.6, 0.56666666666667, 0.4
6544, 0.6, 0.62, 0.4
6545, 0.6, 0.67333333333333, 0.4
6546, 0.6, 0.72666666666667, 0.4
6547, 0.6, 0.78, 0.4
6548, 0.6, 0.83333333333333, 0.4
6549, 0.6, 0.88666666666667, 0.4
6550, 0.6, 0.94, 0.4
6551, 0.6, 0.99333333333333, 0.4
6552, 0.6, 1.0466666666667, 0.4
6553, 0.6, 0.35333333333333, 0.43333333333333
6554, 0.6, 0.40666666666667, 0.43333333333333
6555, 0.6, 0.46, 0.43333333333333
6556, 0.6, 0.51333333333333, 0.43333333333333
6557, 0.6, 0.56666666666667, 0.43333333333333
6558, 0.6, 0.62, 0.43333333333333
6559, 0.6, 0.67333333333333, 0.43333333333333
6560, 0.6, 0.72666666666667, 0.43333333333333
6561, 0.6, 0.78, 0.43333333333333
6562, 0.6, 0.83333333333333, 0.43333333333333
6563, 0.6, 0.88666666666667, 0.43333333333333
6564, 0.6, 0.94, 0.43333333333333
6565, 0.6, 0.99333333333333, 0.43333333333333
6566, 0.6, 1.0466666666667, 0.43333333333333
6567, 0.6, 0.35333333333333, 0.46666666666667
6568, 0.6, 0.40666666666667, 0.46666666666667
6569, 0.6, 0.46, 0.46666666666667
6570, 0.6, 0.51333333333333, 0.46666666666667
6571, 0.6, 0.56666666666667, 0.46666666666667
6572, 0.6, 0.62, 0.46666666666667
6573, 0.6, 0.67333333333333, 0.46666666666667
6574, 0.6, 0.72666666666667, 0.46666666666667
6575, 0.6, 0.78, 0.46666666666667
6576, 0.6, 0.83333333333333, 0.46666666666667
6577, 0.6, 0.88666666666667, 0.46666666666667
6578, 0.6, 0.94, 0.46666666666667
6579, 0.6, 0.99333333333333, 0.46666666666667
6580, 0.6, 1.0466666666667, 0.46666666666667
6581, 0.66666666666667, 0.35333333333333, 0.033333333333333
6582, 0.66666666666667, 0.40666666666667, 0.033333333333333
6583, 0.66666666666667, 0.46, 0.033333333333333
6584, 0.66666666666667, 0.51333333333333, 0.033333333333333
6585, 0.66666666666667, 0.56666666666667, 0.033333333333333
6586, 0.66666666666667, 0.62, 0.033333333333333
6587, 0.66666666666667, 0.67333333333333, 0.033333333333333
6588, 0.66666666666667, 0.72666666666667, 0.033333333333333
6589, 0.66666666666667, 0.78, 0.033333333333333
6590, 0.66666666666667, 0.83333333333333, 0.033333333333333
6591, 0.66666666666667, 0.88666666666667, 0.033333333333333
6592, 0.66666666666667, 0.94, 0.033333333333333
6593, 0.66666666666667, 0.99333333333333, 0.033333333333333
6594, 0.66666666666667, 1.0466666666667, 0.033333333333333
6595, 0.66666666666667, 0.35333333333333, 0.066666666666667
6596, 0.66666666666667, 0.40666666666667, 0.066666666666667
6597, 0.66666666666667, 0.46, 0.066666666666667
6598, 0.66666666666667, 0.51333333333333, 0.066666666666667
6599, 0.66666666666667, 0.56666666666667, 0.066666666666667
6600, 0.66666666666667, 0.62, 0.066666666666667
6601, 0.66666666666667, 0.67333333333333, 0.066666666666667
6602, 0.66666666666667, 0.72666666666667, 0.066666666666667
6603, 0.66666666666667, 0.78, 0.066666666666667
6604, 0.66666666666667, 0.83333333333333, 0.066666666666667
6605, 0.66666666666667, 0.88666666666667, 0.066666666666667
6606, 0.66666666666667, 0.94, 0.066666666666667
6607, 0.66666666666667, 0.99333333333333, 0.066666666666667
6608, 0.66666666666667, 1.0466666666667, 0.066666666666667
6609, 0.66666666666667, 0.35333333333333, 0.1
6610, 0.66666666666667, 0.40666666666667, 0.1
6611, 0.66666666666667, 0.46, 0.1
6612, 0.66666666666667, 0.51333333333333, 0.1
6613, 0.66666666666667, 0.56666666666667, 0.1
6614, 0.66666666666667, 0.62, 0.1
6615, 0.66666666666667, 0.67333333333333, 0.1
6616, 0.66666666666667, 0.72666666666667, 0.1
6617, 0.66666666666667, 0.78, 0.1
6618, 0.66666666666667, 0.83333333333333, 0.1
6619, 0.66666666666667, 0.88666666666667, 0.1
6620, 0.66666666666667, 0.94, 0.1
6621, 0.66666666666667, 0.99333333333333, 0.1
6622, 0.66666666666667, 1.0466666666667, 0.1
6623, 0.66666666666667, 0.35333333333333, 0.13333333333333
6624, 0.66666666666667, 0.40666666666667, 0.13333333333333
6625, 0.66666666666667, 0.46, 0.13333333333333
6626, 0.66666666666667, 0.51333333333333, 0.13333333333333
6627, 0.66666666666667, 0.56666666666667, 0.13333333333333
6628, 0.66666666666667, 0.62, 0.13333333333333
6629, 0.66666666666667, 0.67333333333333, 0.13333333333333
6630, 0.66666666666667, 0.72666666666667, 0.13333333333333
6631, 0.66666666666667, 0.78, 0.13333333333333
6632, 0.66666666666667, 0.83333333333333, 0.13333333333333
6633, 0.66666666666667, 0.88666666666667, 0.13333333333333
6634, 0.66666666666667, 0.94, 0.13333333333333
6635, 0.66666666666667, 0.99333333333333, 0.13333333333333
6636, 0.66666666666667, 1.0466666666667, 0.13333333333333
6637, 0.66666666666667, 0.35333333333333, 0.16666666666667
6638, 0.66666666666667, 0.40666666666667, 0.16666666666667
6639, 0.66666666666667, 0.46, 0.16666666666667
6640, 0.66666666666667, 0.51333333333333, 0.16666666666667
6641, 0.66666666666667, 0.56666666666667, 0.16666666666667
6642, 0.66666666666667, 0.62, 0.16666666666667
6643, 0.66666666666667, 0.67333333333333, 0.16666666666667
6644, 0.66666666666667, 0.72666666666667, 0.16666666666667
6645, 0.66666666666667, 0.78, 0.16666666666667
6646, 0.66666666666667, 0.83333333333333, 0.16666666666667
6647, 0.66666666666667, 0.88666666666667, 0.16666666666667
6648, 0.66666666666667, 0.94, 0.16666666666667
6649, 0.66666666666667, 0.99333333333333, 0.16666666666667
6650, 0.66666666666667, 1.0466666666667, 0.16666666666667
6651, 0.66666666666667, 0.35333333333333, 0.2
6652, 0.66666666666667, 0.40666666666667, 0.2
6653, 0.66666666666667, 0.46, 0.2
6654, 0.66666666666667, 0.51333333333333, 0.2
6655, 0.66666666666667, 0.56666666666667, 0.2
6656, 0.66666666666667, 0.62, 0.2
6657, 0.66666666666667, 0.67333333333333, 0.2
6658, 0.66666666666667, 0.72666666666667, 0.2
6659, 0.66666666666667, 0.78, 0.2
6660, 0.66666666666667, 0.83333333333333, 0.2
6661, 0.66666666666667, 0.88666666666667, 0.2
6662, 0.66666666666667, 0.94, 0.2
6663, 0.66666666666667, 0.99333333333333, 0.2
6664, 0.66666666666667, 1.0466666666667, 0.2
6665, 0.66666666666667, 0.35333333333333, 0.23333333333333
6666, 0.66666666666667, 0.40666666666667, 0.23333333333333
6667, 0.66666666666667, 0.46, 0.23333333333333
6668, 0.66666666666667, 0.51333333333333, 0.23333333333333
6669, 0.66666666666667, 0.56666666666667, 0.23333333333333
6670, 0.66666666666667, 0.62, 0.23333333333333
6671, 0.66666666666667, 0.67333333333333, 0.23333333333333
6672, 0.66666666666667, 0.72666666666667, 0.23333333333333
6673, 0.66666666666667, 0.78, 0.23333333333333
6674, 0.66666666666667, 0.83333333333333, 0.23333333333333
6675, 0.66666666666667, 0.88666666666667, 0.23333333333333
6676, 0.66666666666667, 0.94, 0.23333333333333
6677, 0.66666666666667, 0.99333333333333, 0.23333333333333
6678, 0.66666666666667, 1.0466666666667, 0.23333333333333
6679, 0.66666666666667, 0.35333333333333, 0.26666666666667
6680, 0.66666666666667, 0.40666666666667, 0.26666666666667
6681, 0.66666666666667, 0.46, 0.26666666666667
6682, 0.66666666666667, 0.51333333333333, 0.26666666666667
6683, 0.66666666666667, 0.56666666666667, 0.26666666666667
6684, 0.66666666666667, 0.62, 0.26666666666667
6685, 0.66666666666667, 0.67333333333333, 0.26666666666667
6686, 0.66666666666667, 0.72666666666667, 0.26666666666667
6687, 0.66666666666667, 0.78, 0.26666666666667
6688, 0.66666666666667, 0.83333333333333, 0.26666666666667
6689, 0.66666666666667, 0.88666666666667, 0.26666666666667
6690, 0.66666666666667, 0.94, 0.26666666666667
6691, 0.66666666666667, 0.99333333333333, 0.26666666666667
6692, 0.66666666666667, 1.0466666666667, 0.26666666666667
6693, 0.66666666666667, 0.35333333333333, 0.3
6694, 0.66666666666667, 0.40666666666667, 0.3
6695, 0.66666666666667, 0.46, 0.3
6696, 0.66666666666667, 0.51333333333333, 0.3
6697, 0.66666666666667, 0.56666666666667, 0.3
6698, 0.66666666666667, 0.62, 0.3
6699, 0.66666666666667, 0.67333333333333, 0.3
6700, 0.66666666666667, 0.72666666666667, 0.3
6701, 0.66666666666667, 0.78, 0.3
6702, 0.66666666666667, 0.83333333333333, 0.3
6703, 0.66666666666667, 0.88666666666667, 0.3
6704, 0.66666666666667, 0.94, 0.3
6705, 0.66666666666667, 0.99333333333333, 0.3
6706, 0.66666666666667, 1.0466666666667, 0.3
6707, 0.66666666666667, 0.35333333333333, 0.33333333333333
6708, 0.66666666666667, 0.40666666666667, 0.33333333333333
6709, 0.66666666666667, 0.46, 0.33333333333333
6710, 0.66666666666667, 0.51333333333333, 0.33333333333333
6711, 0.66666666666667, 0.56666666666667, 0.33333333333333
6712, 0.66666666666667, 0.62, 0.33333333333333
6713, 0.66666666666667, 0.67333333333333, 0.33333333333333
6714, 0.66666666666667, 0.72666666666667, 0.33333333333333
6715, 0.66666666666667, 0.78, 0.33333333333333
6716, 0.66666666666667, 0.83333333333333, 0.33333333333333
6717, 0.66666666666667, 0.88666666666667, 0.33333333333333
6718, 0.66666666666667, 0.94, 0.33333333333333
6719, 0.66666666666667, 0.99333333333333, 0.33333333333333
6720, 0.66666666666667, 1.0466666666667, 0.33333333333333
6721, 0.66666666666667, 0.35333333333333, 0.36666666666667
6722, 0.66666666666667, 0.40666666666667, 0.36666666666667
6723, 0.66666666666667, 0.46, 0.36666666666667
6724, 0.66666666666667, 0.51333333333333, 0.36666666666667
6725, 0.66666666666667, 0.56666666666667, 0.36666666666667
6726, 0.66666666666667, 0.62, 0.36666666666667
6727, 0.66666666666667, 0.67333333333333, 0.36666666666667
6728, 0.66666666666667, 0.72666666666667, 0.36666666666667
6729, 0.66666666666667, 0.78, 0.36666666666667
6730, 0.66666666666667, 0.83333333333333, 0.36666666666667
6731, 0.66666666666667, 0.88666666666667, 0.36666666666667
6732, 0.66666666666667, 0.94, 0.36666666666667
6733, 0.66666666666667, 0.99333333333333, 0.36666666666667
6734, 0.66666666666667, 1.0466666666667, 0.36666666666667
6735, 0.66666666666667, 0.35333333333333, 0.4
6736, 0.66666666666667, 0.40666666666667, 0.4
6737, 0.66666666666667, 0.46, 0.4
6738, 0.66666666666667, 0.51333333333333, 0.4
6739, 0.66666666666667, 0.56666666666667, 0.4
6740, 0.66666666666667, 0.62, 0.4
6741, 0.66666666666667, 0.67333333333333, 0.4
6742, 0.66666666666667, 0.72666666666667, 0.4
6743, 0.66666666666667, 0.78, 0.4
6744, 0.66666666666667, 0.83333333333333, 0.4
6745, 0.66666666666667, 0.88666666666667, 0.4
6746, 0.66666666666667, 0.94, 0.4
6747, 0.66666666666667, 0.99333333333333, 0.4
6748, 0.66666666666667, 1.0466666666667, 0.4
6749, 0.66666666666667, 0.35333333333333, 0.43333333333333
6750, 0.66666666666667, 0.40666666666667, 0.43333333333333
6751, 0.66666666666667, 0.46, 0.43333333333333
6752, 0.66666666666667, 0.51333333333333, 0.43333333333333
6753, 0.66666666666667, 0.56666666666667, 0.43333333333333
6754, 0.66666666666667, 0.62, 0.43333333333333
6755, 0.66666666666667, 0.67333333333333, 0.43333333333333
6756, 0.66666666666667, 0.72666666666667, 0.43333333333333
6757, 0.66666666666667, 0.78, 0.43333333333333
6758, 0.66666666666667, 0.83333333333333, 0.43333333333333
6759, 0.66666666666667, 0.88666666666667, 0.43333333333333
6760, 0.66666666666667, 0.94, 0.43333333333333
6761, 0.66666666666667, 0.99333333333333, 0.43333333333333
6762, 0.66666666666667, 1.0466666666667, 0.43333333333333
6763, 0.66666666666667, 0.35333333333333, 0.46666666666667
6764, 0.66666666666667, 0.40666666666667, 0.46666666666667
6765, 0.66666666666667, 0.46, 0.46666666666667
6766, 0.66666666666667, 0.51333333333333, 0.46666666666667
6767, 0.66666666666667, 0.56666666666667, 0.46666666666667
6768, 0.66666666666667, 0.62, 0.46666666666667
6769, 0.66666666666667, 0.67333333333333, 0.46666666666667
6770, 0.66666666666667, 0.72666666666667, 0.46666666666667
6771, 0.66666666666667, 0.78, 0.46666666666667
6772, 0.66666666666667, 0.83333333333333, 0.46666666666667
6773, 0.66666666666667, 0.88666666666667, 0.46666666666667
6774, 0.66666666666667, 0.94, 0.46666666666667
6775, 0.66666666666667, 0.99333333333333, 0.46666666666667
6776, 0.66666666666667, 1.0466666666667, 0.46666666666667
6777, 0.73333333333333, 0.35333333333333, 0.033333333333333
6778, 0.73333333333333, 0.40666666666667, 0.033333333333333
6779, 0.73333333333333, 0.46, 0.033333333333333
6780, 0.73333333333333, 0.51333333333333, 0.033333333333333
6781, 0.73333333333333, 0.56666666666667, 0.033333333333333
6782, 0.73333333333333, 0.62, 0.033333333333333
6783, 0.73333333333333, 0.67333333333333, 0.033333333333333
6784, 0.73333333333333, 0.72666666666667, 0.033333333333333
6785, 0.73333333333333, 0.78, 0.033333333333333
6786, 0.73333333333333, 0.83333333333333, 0.033333333333333
6787, 0.73333333333333, 0.88666666666667, 0.033333333333333
6788, 0.73333333333333, 0.94, 0.033333333333333
6789, 0.73333333333333, 0.99333333333333, 0.033333333333333
6790, 0.73333333333333, 1.0466666666667, 0.033333333333333
6791, 0.73333333333333, 0.35333333333333, 0.066666666666667
6792, 0.73333333333333, 0.40666666666667, 0.066666666666667
6793, 0.73333333333333, 0.46, 0.066666666666667
6794, 0.73333333333333, 0.51333333333333, 0.066666666666667
6795, 0.73333333333333, 0.56666666666667, 0.066666666666667
6796, 0.73333333333333, 0.62, 0.066666666666667
6797, 0.73333333333333, 0.67333333333333, 0.066666666666667
6798, 0.73333333333333, 0.72666666666667, 0.066666666666667
6799, 0.73333333333333, 0.78, 0.066666666666667
6800, 0.73333333333333, 0.83333333333333, 0.066666666666667
6801, 0.73333333333333, 0.88666666666667, 0.066666666666667
6802, 0.73333333333333, 0.94, 0.066666666666667
6803, 0.73333333333333, 0.99333333333333, 0.066666666666667
6804, 0.73333333333333, 1.0466666666667, 0.066666666666667
6805, 0.73333333333333, 0.35333333333333, 0.1
6806, 0.73333333333333, 0.40666666666667, 0.1
6807, 0.73333333333333, 0.46, 0.1
6808, 0.73333333333333, 0.51333333333333, 0.1
6809, 0.73333333333333, 0.56666666666667, 0.1
6810, 0.73333333333333, 0.62, 0.1
6811, 0.73333333333333, 0.67333333333333, 0.1
6812, 0.73333333333333, 0.72666666666667, 0.1
6813, 0.73333333333333, 0.78, 0.1
6814, 0.73333333333333, 0.83333333333333, 0.1
6815, 0.73333333333333, 0.88666666666667, 0.1
6816, 0.73333333333333, 0.94, 0.1
6817, 0.73333333333333, 0.99333333333333, 0.1
6818, 0.73333333333333, 1.0466666666667, 0.1
6819, 0.73333333333333, 0.35333333333333, 0.13333333333333
6820, 0.73333333333333, 0.40666666666667, 0.13333333333333
6821, 0.73333333333333, 0.46, 0.13333333333333
6822, 0.73333333333333, 0.51333333333333, 0.13333333333333
6823, 0.73333333333333, 0.56666666666667, 0.13333333333333
6824, 0.73333333333333, 0.62, 0.13333333333333
6825, 0.73333333333333, 0.67333333333333, 0.13333333333333
6826, 0.73333333333333, 0.72666666666667, 0.13333333333333
6827, 0.73333333333333, 0.78, 0.13333333333333
6828, 0.73333333333333, 0.83333333333333, 0.13333333333333
6829, 0.73333333333333, 0.88666666666667, 0.13333333333333
6830, 0.73333333333333, 0.94, 0.13333333333333
6831, 0.73333333333333, 0.99333333333333, 0.13333333333333
6832, 0.73333333333333, 1.0466666666667, 0.13333333333333
6833, 0.73333333333333, 0.35333333333333, 0.16666666666667
6834, 0.73333333333333, 0.40666666666667, 0.16666666666667
6835, 0.73333333333333, 0.46, 0.16666666666667
6836, 0.73333333333333, 0.51333333333333, 0.16666666666667
6837, 0.73333333333333, 0.56666666666667, 0.16666666666667
6838, 0.73333333333333, 0.62, 0.16666666666667
6839, 0.73333333333333, 0.67333333333333, 0.16666666666667
6840, 0.73333333333333, 0.72666666666667, 0.16666666666667
6841, 0.73333333333333, 0.78, 0.16666666666667
6842, 0.73333333333333, 0.83333333333333, 0.16666666666667
6843, 0.73333333333333, 0.88666666666667, 0.16666666666667
6844, 0.73333333333333, 0.94, 0.16666666666667
6845, 0.73333333333333, 0.99333333333333, 0.16666666666667
6846, 0.73333333333333, 1.0466666666667, 0.16666666666667
6847, 0.73333333333333, 0.35333333333333, 0.2
6848, 0.73333333333333, 0.40666666666667, 0.2
6849, 0.73333333333333, 0.46, 0.2
6850, 0.73333333333333, 0.51333333333333, 0.2
6851, 0.73333333333333, 0.56666666666667, 0.2
6852, 0.73333333333333, 0.62, 0.2
6853, 0.73333333333333, 0.67333333333333, 0.2
6854, 0.73333333333333, 0.72666666666667, 0.2
6855, 0.73333333333333, 0.78, 0.2
6856, 0.73333333333333, 0.83333333333333, 0.2
6857, 0.73333333333333, 0.88666666666667, 0.2
6858, 0.73333333333333, 0.94, 0.2
6859, 0.73333333333333, 0.99333333333333, 0.2
6860, 0.73333333333333, 1.0466666666667, 0.2
6861, 0.73333333333333, 0.35333333333333, 0.23333333333333
6862, 0.73333333333333, 0.40666666666667, 0.23333333333333
6863, 0.73333333333333, 0.46, 0.23333333333333
6864, 0.73333333333333, 0.51333333333333, 0.23333333333333
6865, 0.73333333333333, 0.56666666666667, 0.23333333333333
6866, 0.73333333333333, 0.62, 0.23333333333333
6867, 0.73333333333333, 0.67333333333333, 0.23333333333333
6868, 0.73333333333333, 0.72666666666667, 0.23333333333333
6869, 0.73333333333333, 0.78, 0.23333333333333
6870, 0.73333333333333, 0.83333333333333, 0.23333333333333
6871, 0.73333333333333, 0.88666666666667, 0.23333333333333
6872, 0.73333333333333, 0.94, 0.23333333333333
6873, 0.73333333333333, 0.99333333333333, 0.23333333333333
6874, 0.73333333333333, 1.0466666666667, 0.23333333333333
6875, 0.73333333333333, 0.35333333333333, 0.26666666666667
6876, 0.73333333333333, 0.40666666666667, 0.26666666666667
6877, 0.73333333333333, 0.46, 0.26666666666667
6878, 0.73333333333333, 0.51333333333333, 0.26666666666667
6879, 0.73333333333333, 0.56666666666667, 0.26666666666667
6880, 0.73333333333333, 0.62, 0.26666666666667
6881, 0.73333333333333, 0.67333333333333, 0.26666666666667
6882, 0.73333333333333, 0.72666666666667, 0.26666666666667
6883, 0.73333333333333, 0.78, 0.26666666666667
6884, 0.73333333333333, 0.83333333333333, 0.26666666666667
6885, 0.73333333333333, 0.88666666666667, 0.26666666666667
6886, 0.73333333333333, 0.94, 0.26666666666667
6887, 0.73333333333333, 0.99333333333333, 0.26666666666667
6888, 0.73333333333333, 1.0466666666667, 0.26666666666667
6889, 0.73333333333333, 0.35333333333333, 0.3
6890, 0.73333333333333, 0.40666666666667, 0.3
6891, 0.73333333333333, 0.46, 0.3
6892, 0.73333333333333, 0.51333333333333, 0.3
6893, 0.73333333333333, 0.56666666666667, 0.3
6894, 0.73333333333333, 0.62, 0.3
6895, 0.73333333333333, 0.67333333333333, 0.3
6896, 0.73333333333333, 0.72666666666667, 0.3
6897, 0.73333333333333, 0.78, 0.3
6898, 0.73333333333333, 0.83333333333333, 0.3
6899, 0.73333333333333, 0.88666666666667, 0.3
6900, 0.73333333333333, 0.94, 0.3
6901, 0.73333333333333, 0.99333333333333, 0.3
6902, 0.73333333333333, 1.0466666666667, 0.3
6903, 0.73333333333333, 0.35333333333333, 0.33333333333333
6904, 0.73333333333333, 0.40666666666667, 0.33333333333333
6905, 0.73333333333333, 0.46, 0.33333333333333
6906, 0.73333333333333, 0.51333333333333, 0.33333333333333
6907, 0.73333333333333, 0.56666666666667, 0.33333333333333
6908, 0.73333333333333, 0.62, 0.33333333333333
6909, 0.73333333333333, 0.67333333333333, 0.33333333333333
6910, 0.73333333333333, 0.72666666666667, 0.33333333333333
6911, 0.73333333333333, 0.78, 0.33333333333333
6912, 0.73333333333333, 0.83333333333333, 0.33333333333333
6913, 0.73333333333333, 0.88666666666667, 0.33333333333333
6914, 0.73333333333333, 0.94, 0.33333333333333
6915, 0.73333333333333, 0.99333333333333, 0.33333333333333
6916, 0.73333333333333, 1.0466666666667, 0.33333333333333
6917, 0.73333333333333, 0.35333333333333, 0.36666666666667
6918, 0.73333333333333, 0.40666666666667, 0.36666666666667
6919, 0.73333333333333, 0.46, 0.36666666666667
6920, 0.73333333333333, 0.51333333333333, 0.36666666666667
6921, 0.73333333333333, 0.56666666666667, 0.36666666666667
6922, 0.73333333333333, 0.62, 0.36666666666667
6923, 0.73333333333333, 0.67333333333333, 0.36666666666667
6924, 0.73333333333333, 0.72666666666667, 0.36666666666667
6925, 0.73333333333333, 0.78, 0.36666666666667
6926, 0.73333333333333, 0.83333333333333, 0.36666666666667
6927, 0.73333333333333, 0.88666666666667, 0.36666666666667
6928, 0.73333333333333, 0.94, 0.36666666666667
6929, 0.73333333333333, 0.99333333333333, 0.36666666666667
6930, 0.73333333333333, 1.0466666666667, 0.36666666666667
6931, 0.73333333333333, 0.35333333333333, 0.4
6932, 0.73333333333333, 0.40666666666667, 0.4
6933, 0.73333333333333, 0.46, 0.4
6934, 0.73333333333333, 0.51333333333333, 0.4
6935, 0.73333333333333, 0.56666666666667, 0.4
6936, 0.73333333333333, 0.62, 0.4
6937, 0.73333333333333, 0.67333333333333, 0.4
6938, 0.73333333333333, 0.72666666666667, 0.4
6939, 0.73333333333333, 0.78, 0.4
6940, 0.73333333333333, 0.83333333333333, 0.4
6941, 0.73333333333333, 0.88666666666667, 0.4
6942, 0.73333333333333, 0.94, 0.4
6943, 0.73333333333333, 0.99333333333333, 0.4
6944, 0.73333333333333, 1.0466666666667, 0.4
6945, 0.73333333333333, 0.35333333333333, 0.43333333333333
6946, 0.73333333333333, 0.40666666666667, 0.43333333333333
6947, 0.73333333333333, 0.46, 0.43333333333333
6948, 0.73333333333333, 0.51333333333333, 0.43333333333333
6949, 0.73333333333333, 0.56666666666667, 0.43333333333333
6950, 0.73333333333333, 0.62, 0.43333333333333
6951, 0.73333333333333, 0.67333333333333, 0.43333333333333
6952, 0.73333333333333, 0.72666666666667, 0.43333333333333
6953, 0.73333333333333, 0.78, 0.43333333333333
6954, 0.73333333333333, 0.83333333333333, 0.43333333333333
6955, 0.73333333333333, 0.88666666666667, 0.43333333333333
6956, 0.73333333333333, 0.94, 0.43333333333333
6957, 0.73333333333333, 0.99333333333333, 0.43333333333333
6958, 0.73333333333333, 1.0466666666667, 0.43333333333333
6959, 0.73333333333333, 0.35333333333333, 0.46666666666667
6960, 0.73333333333333, 0.40666666666667, 0.46666666666667
6961, 0.73333333333333, 0.46, 0.46666666666667
6962, 0.73333333333333, 0.51333333333333, 0.46666666666667
6963, 0.73333333333333, 0.56666666666667, 0.46666666666667
6964, 0.73333333333333, 0.62, 0.46666666666667
6965, 0.73333333333333, 0.67333333333333, 0.46666666666667
6966, 0.73333333333333, 0.72666666666667, 0.46666666666667
6967, 0.73333333333333, 0.78, 0.46666666666667
6968, 0.73333333333333, 0.83333333333333, 0.46666666666667
6969, 0.73333333333333, 0.88666666666667, 0.46666666666667
6970, 0.73333333333333, 0.94, 0.46666666666667
6971, 0.73333333333333, 0.99333333333333, 0.46666666666667
6972, 0.73333333333333, 1.0466666666667, 0.46666666666667
6973, 0.8, 0.35333333333333, 0.033333333333333
6974, 0.8, 0.40666666666667, 0.033333333333333
6975, 0.8, 0.46, 0.033333333333333
6976, 0.8, 0.51333333333333, 0.033333333333333
6977, 0.8, 0.56666666666667, 0.033333333333333
6978, 0.8, 0.62, 0.033333333333333
6979, 0.8, 0.67333333333333, 0.033333333333333
6980, 0.8, 0.72666666666667, 0.033333333333333
6981, 0.8, 0.78, 0.033333333333333
6982, 0.8, 0.83333333333333, 0.033333333333333
6983, 0.8, 0.88666666666667, 0.033333333333333
6984, 0.8, 0.94, 0.033333333333333
6985, 0.8, 0.99333333333333, 0.033333333333333
6986, 0.8, 1.0466666666667, 0.033333333333333
6987, 0.8, 0.35333333333333, 0.066666666666667
6988, 0.8, 0.40666666666667, 0.066666666666667
6989, 0.8, 0.46, 0.066666666666667
6990, 0.8, 0.51333333333333, 0.066666666666667
6991, 0.8, 0.56666666666667, 0.066666666666667
6992, 0.8, 0.62, 0.066666666666667
6993, 0.8, 0.67333333333333, 0.066666666666667
6994, 0.8, 0.72666666666667, 0.066666666666667
6995, 0.8, 0.78, 0.066666666666667
6996, 0.8, 0.83333333333333, 0.066666666666667
6997, 0.8, 0.88666666666667, 0.066666666666667
6998, 0.8, 0.94, 0.066666666666667
6999, 0.8, 0.99333333333333, 0.066666666666667
7000, 0.8, 1.0466666666667, 0.066666666666667
7001, 0.8, 0.35333333333333, 0.1
7002, 0.8, 0.40666666666667, 0.1
7003, 0.8, 0.46, 0.1
7004, 0.8, 0.51333333333333, 0.1
7005, 0.8, 0.56666666666667, 0.1
7006, 0.8, 0.62, 0.1
7007, 0.8, 0.67333333333333, 0.1
7008, 0.8, 0.72666666666667, 0.1
7009, 0.8, 0.78, 0.1
7010, 0.8, 0.83333333333333, 0.1
7011, 0.8, 0.88666666666667, 0.1
7012, 0.8, 0.94, 0.1
7013, 0.8, 0.99333333333333, 0.1
7014, 0.8, 1.0466666666667, 0.1
7015, 0.8, 0.35333333333333, 0.13333333333333
7016, 0.8, 0.40666666666667, 0.13333333333333
7017, 0.8, 0.46, 0.13333333333333
7018, 0.8, 0.51333333333333, 0.13333333333333
7019, 0.8, 0.56666666666667, 0.13333333333333
7020, 0.8, 0.62, 0.13333333333333
7021, 0.8, 0.67333333333333, 0.13333333333333
7022, 0.8, 0.72666666666667, 0.13333333333333
7023, 0.8, 0.78, 0.13333333333333
7024, 0.8, 0.83333333333333, 0.13333333333333
7025, 0.8, 0.88666666666667, 0.13333333333333
7026, 0.8, 0.94, 0.13333333333333
7027, 0.8, 0.99333333333333, 0.13333333333333
7028, 0.8, 1.0466666666667, 0.13333333333333
7029, 0.8, 0.35333333333333, 0.16666666666667
7030, 0.8, 0.40666666666667, 0.16666666666667
7031, 0.8, 0.46, 0.16666666666667
7032, 0.8, 0.51333333333333, 0.16666666666667
7033, 0.8, 0.56666666666667, 0.16666666666667
7034, 0.8, 0.62, 0.16666666666667
7035, 0.8, 0.67333333333333, 0.16666666666667
7036, 0.8, 0.72666666666667, 0.16666666666667
7037, 0.8, 0.78, 0.16666666666667
7038, 0.8, 0.83333333333333, 0.16666666666667
7039, 0.8, 0.88666666666667, 0.16666666666667
7040, 0.8, 0.94, 0.16666666666667
7041, 0.8, 0.99333333333333, 0.16666666666667
7042, 0.8, 1.0466666666667, 0.16666666666667
7043, 0.8, 0.35333333333333, 0.2
7044, 0.8, 0.40666666666667, 0.2
7045, 0.8, 0.46, 0.2
7046, 0.8, 0.51333333333333, 0.2
7047, 0.8, 0.56666666666667, 0.2
7048, 0.8, 0.62, 0.2
7049, 0.8, 0.67333333333333, 0.2
7050, 0.8, 0.72666666666667, 0.2
7051, 0.8, 0.78, 0.2
7052, 0.8, 0.83333333333333, 0.2
7053, 0.8, 0.88666666666667, 0.2
7054, 0.8, 0.94, 0.2
7055, 0.8, 0.99333333333333, 0.2
7056, 0.8, 1.0466666666667, 0.2
7057, 0.8, 0.35333333333333, 0.23333333333333
7058, 0.8, 0.40666666666667, 0.23333333333333
7059, 0.8, 0.46, 0.23333333333333
7060, 0.8, 0.51333333333333, 0.23333333333333
7061, 0.8, 0.56666666666667, 0.23333333333333
7062, 0.8, 0.62, 0.23333333333333
7063, 0.8, 0.67333333333333, 0.23333333333333
7064, 0.8, 0.72666666666667, 0.23333333333333
7065, 0.8, 0.78, 0.23333333333333
7066, 0.8, 0.83333333333333, 0.23333333333333
7067, 0.8, 0.88666666666667, 0.23333333333333
7068, 0.8, 0.94, 0.23333333333333
7069, 0.8, 0.99333333333333, 0.23333333333333
7070, 0.8, 1.0466666666667, 0.23333333333333
7071, 0.8, 0.35333333333333, 0.26666666666667
7072, 0.8, 0.40666666666667, 0.26666666666667
7073, 0.8, 0.46, 0.26666666666667
7074, 0.8, 0.51333333333333, 0.26666666666667
7075, 0.8, 0.56666666666667, 0.26666666666667
7076, 0.8, 0.62, 0.26666666666667
7077, 0.8, 0.67333333333333, 0.26666666666667
7078, 0.8, 0.72666666666667, 0.26666666666667
7079, 0.8, 0.78, 0.26666666666667
7080, 0.8, 0.83333333333333, 0.26666666666667
7081, 0.8, 0.88666666666667, 0.26666666666667
7082, 0.8, 0.94, 0.26666666666667
7083, 0.8, 0.99333333333333, 0.26666666666667
7084, 0.8, 1.0466666666667, 0.26666666666667
7085, 0.8, 0.35333333333333, 0.3
7086, 0.8, 0.40666666666667, 0.3
7087, 0.8, 0.46, 0.3
7088, 0.8, 0.51333333333333, 0.3
7089, 0.8, 0.56666666666667, 0.3
7090, 0.8, 0.62, 0.3
7091, 0.8, 0.67333333333333, 0.3
7092, 0.8, 0.72666666666667, 0.3
7093, 0.8, 0.78, 0.3
7094, 0.8, 0.83333333333333, 0.3
7095, 0.8, 0.88666666666667, 0.3
7096, 0.8, 0.94, 0.3
7097, 0.8, 0.99333333333333, 0.3
7098, 0.8, 1.0466666666667, 0.3
7099, 0.8, 0.35333333333333, 0.33333333333333
7100, 0.8, 0.40666666666667, 0.33333333333333
7101, 0.8, 0.46, 0.33333333333333
7102, 0.8, 0.51333333333333, 0.33333333333333
7103, 0.8, 0.56666666666667, 0.33333333333333
7104, 0.8, 0.62, 0.33333333333333
7105, 0.8, 0.67333333333333, 0.33333333333333
7106, 0.8, 0.72666666666667, 0.33333333333333
7107, 0.8, 0.78, 0.33333333333333
7108, 0.8, 0.83333333333333, 0.33333333333333
7109, 0.8, 0.88666666666667, 0.33333333333333
7110, 0.8, 0.94, 0.33333333333333
7111, 0.8, 0.99333333333333, 0.33333333333333
7112, 0.8, 1.0466666666667, 0.33333333333333
7113, 0.8, 0.35333333333333, 0.36666666666667
7114, 0.8, 0.40666666666667, 0.36666666666667
7115, 0.8, 0.46, 0.36666666666667
7116, 0.8, 0.51333333333333, 0.36666666666667
7117, 0.8, 0.56666666666667, 0.36666666666667
7118, 0.8, 0.62, 0.36666666666667
7119, 0.8, 0.67333333333333, 0.36666666666667
7120, 0.8, 0.72666666666667, 0.36666666666667
7121, 0.8, 0.78, 0.36666666666667
7122, 0.8, 0.83333333333333, 0.36666666666667
7123, 0.8, 0.88666666666667, 0.36666666666667
7124, 0.8, 0.94, 0.36666666666667
7125, 0.8, 0.99333333333333, 0.36666666666667
7126, 0.8, 1.0466666666667, 0.36666666666667
7127, 0.8, 0.35333333333333, 0.4
7128, 0.8, 0.40666666666667, 0.4
7129, 0.8, 0.46, 0.4
7130, 0.8, 0.51333333333333, 0.4
7131, 0.8, 0.56666666666667, 0.4
7132, 0.8, 0.62, 0.4
7133, 0.8, 0.67333333333333, 0.4
7134, 0.8, 0.72666666666667, 0.4
7135, 0.8, 0.78, 0.4
7136, 0.8, 0.83333333333333, 0.4
7137, 0.8, 0.88666666666667, 0.4
7138, 0.8, 0.94, 0.4
7139, 0.8, 0.99333333333333, 0.4
7140, 0.8, 1.0466666666667, 0.4
7141, 0.8, 0.35333333333333, 0.43333333333333
7142, 0.8, 0.40666666666667, 0.43333333333333
7143, 0.8, 0.46, 0.43333333333333
7144, 0.8, 0.51333333333333, 0.43333333333333
7145, 0.8, 0.56666666666667, 0.43333333333333
7146, 0.8, 0.62, 0.43333333333333
7147, 0.8, 0.67333333333333, 0.43333333333333
7148, 0.8, 0.72666666666667, 0.43333333333333
7149, 0.8, 0.78, 0.43333333333333
7150, 0.8, 0.83333333333333, 0.43333333333333
7151, 0.8, 0.88666666666667, 0.43333333333333
7152, 0.8, 0.94, 0.43333333333333
7153, 0.8, 0.99333333333333, 0.43333333333333
7154, 0.8, 1.0466666666667, 0.43333333333333
7155, 0.8, 0.35333333333333, 0.46666666666667
7156, 0.8, 0.40666666666667, 0.46666666666667
7157, 0.8, 0.46, 0.46666666666667
7158, 0.8, 0.51333333333333, 0.46666666666667
7159, 0.8, 0.56666666666667, 0.46666666666667
7160, 0.8, 0.62, 0.46666666666667
7161, 0.8, 0.67333333333333, 0.46666666666667
7162, 0.8, 0.72666666666667, 0.46666666666667
7163, 0.8, 0.78, 0.46666666666667
7164, 0.8, 0.83333333333333, 0.46666666666667
7165, 0.8, 0.88666666666667, 0.46666666666667
7166, 0.8, 0.94, 0.46666666666667
7167, 0.8, 0.99333333333333, 0.46666666666667
7168, 0.8, 1.0466666666667, 0.46666666666667
7169, 0.86666666666667, 0.35333333333333, 0.033333333333333
7170, 0.86666666666667, 0.40666666666667, 0.033333333333333
7171, 0.86666666666667, 0.46, 0.033333333333333
7172, 0.86666666666667, 0.51333333333333, 0.033333333333333
7173, 0.86666666666667, 0.56666666666667, 0.033333333333333
7174, 0.86666666666667, 0.62, 0.033333333333333
7175, 0.86666666666667, 0.67333333333333, 0.033333333333333
7176, 0.86666666666667, 0.72666666666667, 0.033333333333333
7177, 0.86666666666667, 0.78, 0.033333333333333
7178, 0.86666666666667, 0.83333333333333, 0.033333333333333
7179, 0.86666666666667, 0.88666666666667, 0.033333333333333
7180, 0.86666666666667, 0.94, 0.033333333333333
7181, 0.86666666666667, 0.99333333333333, 0.033333333333333
7182, 0.86666666666667, 1.0466666666667, 0.033333333333333
7183, 0.86666666666667, 0.35333333333333, 0.066666666666667
7184, 0.86666666666667, 0.40666666666667, 0.066666666666667
7185, 0.86666666666667, 0.46, 0.066666666666667
7186, 0.86666666666667, 0.51333333333333, 0.066666666666667
7187, 0.86666666666667, 0.56666666666667, 0.066666666666667
7188, 0.86666666666667, 0.62, 0.066666666666667
7189, 0.86666666666667, 0.67333333333333, 0.066666666666667
7190, 0.86666666666667, 0.72666666666667, 0.066666666666667
7191, 0.86666666666667, 0.78, 0.066666666666667
7192, 0.86666666666667, 0.83333333333333, 0.066666666666667
7193, 0.86666666666667, 0.88666666666667, 0.066666666666667
7194, 0.86666666666667, 0.94, 0.066666666666667
7195, 0.86666666666667, 0.99333333333333, 0.066666666666667
7196, 0.86666666666667, 1.0466666666667, 0.066666666666667
7197, 0.86666666666667, 0.35333333333333, 0.1
7198, 0.86666666666667, 0.40666666666667, 0.1
7199, 0.86666666666667, 0.46, 0.1
7200, 0.86666666666667, 0.51333333333333, 0.1
7201, 0.86666666666667, 0.56666666666667, 0.1
7202, 0.86666666666667, 0.62, 0.1
7203, 0.86666666666667, 0.67333333333333, 0.1
7204, 0.86666666666667, 0.72666666666667, 0.1
7205, 0.86666666666667, 0.78, 0.1
7206, 0.86666666666667, 0.83333333333333, 0.1
7207, 0.86666666666667, 0.88666666666667, 0.1
7208, 0.86666666666667, 0.94, 0.1
7209, 0.86666666666667, 0.99333333333333, 0.1
7210, 0.86666666666667, 1.0466666666667, 0.1
7211, 0.86666666666667, 0.35333333333333, 0.13333333333333
7212, 0.86666666666667, 0.40666666666667, 0.13333333333333
7213, 0.86666666666667, 0.46, 0.13333333333333
7214, 0.86666666666667, 0.51333333333333, 0.13333333333333
7215, 0.86666666666667, 0.56666666666667, 0.13333333333333
7216, 0.86666666666667, 0.62, 0.13333333333333
7217, 0.86666666666667, 0.67333333333333, 0.13333333333333
7218, 0.86666666666667, 0.72666666666667, 0.13333333333333
7219, 0.86666666666667, 0.78, 0.13333333333333
7220, 0.86666666666667, 0.83333333333333, 0.13333333333333
7221, 0.86666666666667, 0.88666666666667, 0.13333333333333
7222, 0.86666666666667, 0.94, 0.13333333333333
7223, 0.86666666666667, 0.99333333333333, 0.13333333333333
7224, 0.86666666666667, 1.0466666666667, 0.13333333333333
7225, 0.86666666666667, 0.35333333333333, 0.16666666666667
7226, 0.86666666666667, 0.40666666666667, 0.16666666666667
7227, 0.86666666666667, 0.46, 0.16666666666667
7228, 0.86666666666667, 0.51333333333333, 0.16666666666667
7229, 0.86666666666667, 0.56666666666667, 0.16666666666667
7230, 0.86666666666667, 0.62, 0.16666666666667
7231, 0.86666666666667, 0.67333333333333, 0.16666666666667
7232, 0.86666666666667, 0.72666666666667, 0.16666666666667
7233, 0.86666666666667, 0.78, 0.16666666666667
7234, 0.86666666666667, 0.83333333333333, 0.16666666666667
7235, 0.86666666666667, 0.88666666666667, 0.16666666666667
7236, 0.86666666666667, 0.94, 0.16666666666667
7237, 0.86666666666667, 0.99333333333333, 0.16666666666667
7238, 0.86666666666667, 1.0466666666667, 0.16666666666667
7239, 0.86666666666667, 0.35333333333333, 0.2
7240, 0.86666666666667, 0.40666666666667, 0.2
7241, 0.86666666666667, 0.46, 0.2
7242, 0.86666666666667, 0.51333333333333, 0.2
7243, 0.86666666666667, 0.56666666666667, 0.2
7244, 0.86666666666667, 0.62, 0.2
7245, 0.86666666666667, 0.67333333333333, 0.2
7246, 0.86666666666667, 0.72666666666667, 0.2
7247, 0.86666666666667, 0.78, 0.2
7248, 0.86666666666667, 0.83333333333333, 0.2
7249, 0.86666666666667, 0.88666666666667, 0.2
7250, 0.86666666666667, 0.94, 0.2
7251, 0.86666666666667, 0.99333333333333, 0.2
7252, 0.86666666666667, 1.0466666666667, 0.2
7253, 0.86666666666667, 0.35333333333333, 0.23333333333333
7254, 0.86666666666667, 0.40666666666667, 0.23333333333333
7255, 0.86666666666667, 0.46, 0.23333333333333
7256, 0.86666666666667, 0.51333333333333, 0.23333333333333
7257, 0.86666666666667, 0.56666666666667, 0.23333333333333
7258, 0.86666666666667, 0.62, 0.23333333333333
7259, 0.86666666666667, 0.67333333333333, 0.23333333333333
7260, 0.86666666666667, 0.72666666666667, 0.23333333333333
7261, 0.86666666666667, 0.78, 0.23333333333333
7262, 0.86666666666667, 0.83333333333333, 0.23333333333333
7263, 0.86666666666667, 0.88666666666667, 0.23333333333333
7264, 0.86666666666667, 0.94, 0.23333333333333
7265, 0.86666666666667, 0.99333333333333, 0.23333333333333
7266, 0.86666666666667, 1.0466666666667, 0.23333333333333
7267, 0.86666666666667, 0.35333333333333, 0.26666666666667
7268, 0.86666666666667, 0.40666666666667, 0.26666666666667
7269, 0.86666666666667, 0.46, 0.26666666666667
7270, 0.86666666666667, 0.51333333333333, 0.26666666666667
7271, 0.86666666666667, 0.56666666666667, 0.26666666666667
7272, 0.86666666666667, 0.62, 0.26666666666667
7273, 0.86666666666667, 0.67333333333333, 0.26666666666667
7274, 0.86666666666667, 0.72666666666667, 0.26666666666667
7275, 0.86666666666667, 0.78, 0.26666666666667
7276, 0.86666666666667, 0.83333333333333, 0.26666666666667
7277, 0.86666666666667, 0.88666666666667, 0.26666666666667
7278, 0.86666666666667, 0.94, 0.26666666666667
7279, 0.86666666666667, 0.99333333333333, 0.26666666666667
7280, 0.86666666666667, 1.0466666666667, 0.26666666666667
7281, 0.86666666666667, 0.35333333333333, 0.3
7282, 0.86666666666667, 0.40666666666667, 0.3
7283, 0.86666666666667, 0.46, 0.3
7284, 0.86666666666667, 0.51333333333333, 0.3
7285, 0.86666666666667, 0.56666666666667, 0.3
7286, 0.86666666666667, 0.62, 0.3
7287, 0.86666666666667, 0.67333333333333, 0.3
7288, 0.86666666666667, 0.72666666666667, 0.3
7289, 0.86666666666667, 0.78, 0.3
7290, 0.86666666666667, 0.83333333333333, 0.3
7291, 0.86666666666667, 0.88666666666667, 0.3
7292, 0.86666666666667, 0.94, 0.3
7293, 0.86666666666667, 0.99333333333333, 0.3
7294, 0.86666666666667, 1.0466666666667, 0.3
7295, 0.86666666666667, 0.35333333333333, 0.33333333333333
7296, 0.86666666666667, 0.40666666666667, 0.33333333333333
7297, 0.86666666666667, 0.46, 0.33333333333333
7298, 0.86666666666667, 0.51333333333333, 0.33333333333333
7299, 0.86666666666667, 0.56666666666667, 0.33333333333333
7300, 0.86666666666667, 0.62, 0.33333333333333
7301, 0.86666666666667, 0.67333333333333, 0.33333333333333
7302, 0.86666666666667, 0.72666666666667, 0.33333333333333
7303, 0.86666666666667, 0.78, 0.33333333333333
7304, 0.86666666666667, 0.83333333333333, 0.33333333333333
7305, 0.86666666666667, 0.88666666666667, 0.33333333333333
7306, 0.86666666666667, 0.94, 0.33333333333333
7307, 0.86666666666667, 0.99333333333333, 0.33333333333333
7308, 0.86666666666667, 1.0466666666667, 0.33333333333333
7309, 0.86666666666667, 0.35333333333333, 0.36666666666667
7310, 0.86666666666667, 0.40666666666667, 0.36666666666667
7311, 0.86666666666667, 0.46, 0.36666666666667
7312, 0.86666666666667, 0.51333333333333, 0.36666666666667
7313, 0.86666666666667, 0.56666666666667, 0.36666666666667
7314, 0.86666666666667, 0.62, 0.36666666666667
7315, 0.86666666666667, 0.67333333333333, 0.36666666666667
7316, 0.86666666666667, 0.72666666666667, 0.36666666666667
7317, 0.86666666666667, 0.78, 0.36666666666667
7318, 0.86666666666667, 0.83333333333333, 0.36666666666667
7319, 0.86666666666667, 0.88666666666667, 0.36666666666667
7320, 0.86666666666667, 0.94, 0.36666666666667
7321, 0.86666666666667, 0.99333333333333, 0.36666666666667
7322, 0.86666666666667, 1.0466666666667, 0.36666666666667
7323, 0.86666666666667, 0.35333333333333, 0.4
7324, 0.86666666666667, 0.40666666666667, 0.4
7325, 0.86666666666667, 0.46, 0.4
7326, 0.86666666666667, 0.51333333333333, 0.4
7327, 0.86666666666667, 0.56666666666667, 0.4
7328, 0.86666666666667, 0.62, 0.4
7329, 0.86666666666667, 0.67333333333333, 0.4
7330, 0.86666666666667, 0.72666666666667, 0.4
7331, 0.86666666666667, 0.78, 0.4
7332, 0.86666666666667, 0.83333333333333, 0.4
7333, 0.86666666666667, 0.88666666666667, 0.4
7334, 0.86666666666667, 0.94, 0.4
7335, 0.86666666666667, 0.99333333333333, 0.4
7336, 0.86666666666667, 1.0466666666667, 0.4
7337, 0.86666666666667, 0.35333333333333, 0.43333333333333
7338, 0.86666666666667, 0.40666666666667, 0.43333333333333
7339, 0.86666666666667, 0.46, 0.43333333333333
7340, 0.86666666666667, 0.51333333333333, 0.43333333333333
7341, 0.86666666666667, 0.56666666666667, 0.43333333333333
7342, 0.86666666666667, 0.62, 0.43333333333333
7343, 0.86666666666667, 0.67333333333333, 0.43333333333333
7344, 0.86666666666667, 0.72666666666667, 0.43333333333333
7345, 0.86666666666667, 0.78, 0.43333333333333
7346, 0.86666666666667, 0.83333333333333, 0.43333333333333
7347, 0.86666666666667, 0.88666666666667, 0.43333333333333
7348, 0.86666666666667, 0.94, 0.43333333333333
7349, 0.86666666666667, 0.99333333333333, 0.43333333333333
7350, 0.86666666666667, 1.0466666666667, 0.43333333333333
7351, 0.86666666666667, 0.35333333333333, 0.46666666666667
7352, 0.86666666666667, 0.40666666666667, 0.46666666666667
7353, 0.86666666666667, 0.46, 0.46666666666667
7354, 0.86666666666667, 0.51333333333333, 0.46666666666667
7355, 0.86666666666667, 0.56666666666667, 0.46666666666667
7356, 0.86666666666667, 0.62, 0.46666666666667
7357, 0.86666666666667, 0.67333333333333, 0.46666666666667
7358, 0.86666666666667, 0.72666666666667, 0.46666666666667
7359, 0.86666666666667, 0.78, 0.46666666666667
7360, 0.86666666666667, 0.83333333333333, 0.46666666666667
7361, 0.86666666666667, 0.88666666666667, 0.46666666666667
7362, 0.86666666666667, 0.94, 0.46666666666667
7363, 0.86666666666667, 0.99333333333333, 0.46666666666667
7364, 0.86666666666667, 1.0466666666667, 0.46666666666667
7365, 0.93333333333333, 0.35333333333333, 0.033333333333333
7366, 0.93333333333333, 0.40666666666667, 0.033333333333333
7367, 0.93333333333333, 0.46, 0.033333333333333
7368, 0.93333333333333, 0.51333333333333, 0.033333333333333
7369, 0.93333333333333, 0.56666666666667, 0.033333333333333
7370, 0.93333333333333, 0.62, 0.033333333333333
7371, 0.93333333333333, 0.67333333333333, 0.033333333333333
7372, 0.93333333333333, 0.72666666666667, 0.033333333333333
7373, 0.93333333333333, 0.78, 0.033333333333333
7374, 0.93333333333333, 0.83333333333333, 0.033333333333333
7375, 0.93333333333333, 0.88666666666667, 0.033333333333333
7376, 0.93333333333333, 0.94, 0.033333333333333
7377, 0.93333333333333, 0.99333333333333, 0.033333333333333
7378, 0.93333333333333, 1.0466666666667, 0.033333333333333
7379, 0.93333333333333, 0.35333333333333, 0.066666666666667
7380, 0.93333333333333, 0.40666666666667, 0.066666666666667
7381, 0.93333333333333, 0.46, 0.066666666666667
