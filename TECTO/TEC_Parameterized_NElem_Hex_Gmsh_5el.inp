*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_Gmsh_5el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.2, 0.5
4, 0, 0.2, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.2, 0.5
8, 1, 0.2, 0
9, 1, 0.3, 0
10, 0, 0.3, 0
11, 1, 0.3, 0.5
12, 0, 0.3, 0.5
13, 1, 1.1, 0
14, 0, 1.1, 0
15, 1, 1.1, 0.5
16, 0, 1.1, 0.5
17, 1, 1.2, 0
18, 0, 1.2, 0
19, 1, 1.2, 0.5
20, 0, 1.2, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.2, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.2, 0
28, 1.2, 1.4, 0
29, 2.2, 1.2, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.2, 0
32, 2.2, 1.4, 0
33, 1.2, 1.1, 0.5
34, 2.2, 1.1, 0.5
35, 1.2, 1.1, 0
36, 2.2, 1.1, 0
37, 1.2, 0.3, 0.5
38, 2.2, 0.3, 0.5
39, 1.2, 0.3, 0
40, 2.2, 0.3, 0
41, 1.2, 0.2, 0.5
42, 2.2, 0.2, 0.5
43, 1.2, 0.2, 0
44, 2.2, 0.2, 0
45, 1.2, -2.7755575615629e-17, 0.5
46, 2.2, -2.7755575615629e-17, 0.5
47, 1.2, -2.7755575615629e-17, 0
48, 2.2, -2.7755575615629e-17, 0
49, 2.3, 0.2, 0.5
50, 2.3, -2.7755575615629e-17, 0.5
51, 2.3, 0.2, 0
52, 2.3, -2.7755575615629e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.2, 0.5
56, -0.1, 0.2, 0
57, 0, 0, 0.1
58, 0, 0, 0.2
59, 0, 0, 0.3
60, 0, 0, 0.4
61, 0, 0.2, 0.1
62, 0, 0.2, 0.2
63, 0, 0.2, 0.3
64, 0, 0.2, 0.4
65, 1, 0, 0.1
66, 1, 0, 0.2
67, 1, 0, 0.3
68, 1, 0, 0.4
69, 1, 0.2, 0.1
70, 1, 0.2, 0.2
71, 1, 0.2, 0.3
72, 1, 0.2, 0.4
73, 0.2, 0, 0
74, 0.4, 0, 0
75, 0.6, 0, 0
76, 0.8, 0, 0
77, 0.2, 0, 0.5
78, 0.4, 0, 0.5
79, 0.6, 0, 0.5
80, 0.8, 0, 0.5
81, 0.2, 0.2, 0
82, 0.4, 0.2, 0
83, 0.6, 0.2, 0
84, 0.8, 0.2, 0
85, 0.2, 0.2, 0.5
86, 0.4, 0.2, 0.5
87, 0.6, 0.2, 0.5
88, 0.8, 0.2, 0.5
89, 0.2, 0.3, 0
90, 0.4, 0.3, 0
91, 0.6, 0.3, 0
92, 0.8, 0.3, 0
93, 1, 0.3, 0.1
94, 1, 0.3, 0.2
95, 1, 0.3, 0.3
96, 1, 0.3, 0.4
97, 0.2, 0.3, 0.5
98, 0.4, 0.3, 0.5
99, 0.6, 0.3, 0.5
100, 0.8, 0.3, 0.5
101, 0, 0.3, 0.1
102, 0, 0.3, 0.2
103, 0, 0.3, 0.3
104, 0, 0.3, 0.4
105, 1, 0.46, 0
106, 1, 0.62, 0
107, 1, 0.78, 0
108, 1, 0.94, 0
109, 0, 0.46, 0
110, 0, 0.62, 0
111, 0, 0.78, 0
112, 0, 0.94, 0
113, 0.2, 1.1, 0
114, 0.4, 1.1, 0
115, 0.6, 1.1, 0
116, 0.8, 1.1, 0
117, 1, 0.46, 0.5
118, 1, 0.62, 0.5
119, 1, 0.78, 0.5
120, 1, 0.94, 0.5
121, 1, 1.1, 0.1
122, 1, 1.1, 0.2
123, 1, 1.1, 0.3
124, 1, 1.1, 0.4
125, 0, 0.46, 0.5
126, 0, 0.62, 0.5
127, 0, 0.78, 0.5
128, 0, 0.94, 0.5
129, 0.2, 1.1, 0.5
130, 0.4, 1.1, 0.5
131, 0.6, 1.1, 0.5
132, 0.8, 1.1, 0.5
133, 0, 1.1, 0.1
134, 0, 1.1, 0.2
135, 0, 1.1, 0.3
136, 0, 1.1, 0.4
137, 0.2, 1.2, 0
138, 0.4, 1.2, 0
139, 0.6, 1.2, 0
140, 0.8, 1.2, 0
141, 1, 1.2, 0.1
142, 1, 1.2, 0.2
143, 1, 1.2, 0.3
144, 1, 1.2, 0.4
145, 0.2, 1.2, 0.5
146, 0.4, 1.2, 0.5
147, 0.6, 1.2, 0.5
148, 0.8, 1.2, 0.5
149, 0, 1.2, 0.1
150, 0, 1.2, 0.2
151, 0, 1.2, 0.3
152, 0, 1.2, 0.4
153, 0.2, 1.4, 0
154, 0.4, 1.4, 0
155, 0.6, 1.4, 0
156, 0.8, 1.4, 0
157, 1, 1.4, 0.1
158, 1, 1.4, 0.2
159, 1, 1.4, 0.3
160, 1, 1.4, 0.4
161, 0.2, 1.4, 0.5
162, 0.4, 1.4, 0.5
163, 0.6, 1.4, 0.5
164, 0.8, 1.4, 0.5
165, 0, 1.4, 0.1
166, 0, 1.4, 0.2
167, 0, 1.4, 0.3
168, 0, 1.4, 0.4
169, 1.2, 1.2, 0.1
170, 1.2, 1.2, 0.2
171, 1.2, 1.2, 0.3
172, 1.2, 1.2, 0.4
173, 1.2, 1.4, 0.1
174, 1.2, 1.4, 0.2
175, 1.2, 1.4, 0.3
176, 1.2, 1.4, 0.4
177, 1.4, 1.2, 0.5
178, 1.6, 1.2, 0.5
179, 1.8, 1.2, 0.5
180, 2, 1.2, 0.5
181, 1.4, 1.4, 0.5
182, 1.6, 1.4, 0.5
183, 1.8, 1.4, 0.5
184, 2, 1.4, 0.5
185, 1.4, 1.2, 0
186, 1.6, 1.2, 0
187, 1.8, 1.2, 0
188, 2, 1.2, 0
189, 1.4, 1.4, 0
190, 1.6, 1.4, 0
191, 1.8, 1.4, 0
192, 2, 1.4, 0
193, 2.2, 1.2, 0.1
194, 2.2, 1.2, 0.2
195, 2.2, 1.2, 0.3
196, 2.2, 1.2, 0.4
197, 2.2, 1.4, 0.1
198, 2.2, 1.4, 0.2
199, 2.2, 1.4, 0.3
200, 2.2, 1.4, 0.4
201, 1.4, 1.1, 0.5
202, 1.6, 1.1, 0.5
203, 1.8, 1.1, 0.5
204, 2, 1.1, 0.5
205, 1.4, 1.1, 0
206, 1.6, 1.1, 0
207, 1.8, 1.1, 0
208, 2, 1.1, 0
209, 1.2, 1.1, 0.1
210, 1.2, 1.1, 0.2
211, 1.2, 1.1, 0.3
212, 1.2, 1.1, 0.4
213, 2.2, 1.1, 0.1
214, 2.2, 1.1, 0.2
215, 2.2, 1.1, 0.3
216, 2.2, 1.1, 0.4
217, 1.2, 0.94, 0.5
218, 1.2, 0.78, 0.5
219, 1.2, 0.62, 0.5
220, 1.2, 0.46, 0.5
221, 2.2, 0.94, 0.5
222, 2.2, 0.78, 0.5
223, 2.2, 0.62, 0.5
224, 2.2, 0.46, 0.5
225, 1.4, 0.3, 0.5
226, 1.6, 0.3, 0.5
227, 1.8, 0.3, 0.5
228, 2, 0.3, 0.5
229, 1.2, 0.94, 0
230, 1.2, 0.78, 0
231, 1.2, 0.62, 0
232, 1.2, 0.46, 0
233, 2.2, 0.94, 0
234, 2.2, 0.78, 0
235, 2.2, 0.62, 0
236, 2.2, 0.46, 0
237, 1.4, 0.3, 0
238, 1.6, 0.3, 0
239, 1.8, 0.3, 0
240, 2, 0.3, 0
241, 1.2, 0.3, 0.1
242, 1.2, 0.3, 0.2
243, 1.2, 0.3, 0.3
244, 1.2, 0.3, 0.4
245, 2.2, 0.3, 0.1
246, 2.2, 0.3, 0.2
247, 2.2, 0.3, 0.3
248, 2.2, 0.3, 0.4
249, 1.4, 0.2, 0.5
250, 1.6, 0.2, 0.5
251, 1.8, 0.2, 0.5
252, 2, 0.2, 0.5
253, 1.4, 0.2, 0
254, 1.6, 0.2, 0
255, 1.8, 0.2, 0
256, 2, 0.2, 0
257, 1.2, 0.2, 0.1
258, 1.2, 0.2, 0.2
259, 1.2, 0.2, 0.3
260, 1.2, 0.2, 0.4
261, 2.2, 0.2, 0.1
262, 2.2, 0.2, 0.2
263, 2.2, 0.2, 0.3
264, 2.2, 0.2, 0.4
265, 1.4, -1.942890293094e-16, 0.5
266, 1.6, -1.942890293094e-16, 0.5
267, 1.8, -1.942890293094e-16, 0.5
268, 2, -1.942890293094e-16, 0.5
269, 1.4, -1.942890293094e-16, 0
270, 1.6, -1.942890293094e-16, 0
271, 1.8, -1.942890293094e-16, 0
272, 2, -1.942890293094e-16, 0
273, 1.2, 2.7755575615629e-17, 0.1
274, 1.2, 2.7755575615629e-17, 0.2
275, 1.2, 2.7755575615629e-17, 0.3
276, 1.2, 2.7755575615629e-17, 0.4
277, 2.2, 2.7755575615629e-17, 0.1
278, 2.2, 2.7755575615629e-17, 0.2
279, 2.2, 2.7755575615629e-17, 0.3
280, 2.2, 2.7755575615629e-17, 0.4
281, 2.3, 0.2, 0.1
282, 2.3, 0.2, 0.2
283, 2.3, 0.2, 0.3
284, 2.3, 0.2, 0.4
285, 2.3, 2.7755575615629e-17, 0.1
286, 2.3, 2.7755575615629e-17, 0.2
287, 2.3, 2.7755575615629e-17, 0.3
288, 2.3, 2.7755575615629e-17, 0.4
289, -0.1, 0, 0.1
290, -0.1, 0, 0.2
291, -0.1, 0, 0.3
292, -0.1, 0, 0.4
293, -0.1, 0.2, 0.1
294, -0.1, 0.2, 0.2
295, -0.1, 0.2, 0.3
296, -0.1, 0.2, 0.4
297, 0.2, 0, 0.1
298, 0.2, 0, 0.2
299, 0.2, 0, 0.3
300, 0.2, 0, 0.4
301, 0.4, 0, 0.1
302, 0.4, 0, 0.2
303, 0.4, 0, 0.3
304, 0.4, 0, 0.4
305, 0.6, 0, 0.1
306, 0.6, 0, 0.2
307, 0.6, 0, 0.3
308, 0.6, 0, 0.4
309, 0.8, 0, 0.1
310, 0.8, 0, 0.2
311, 0.8, 0, 0.3
312, 0.8, 0, 0.4
313, 0.2, 0.2, 0.1
314, 0.2, 0.2, 0.2
315, 0.2, 0.2, 0.3
316, 0.2, 0.2, 0.4
317, 0.4, 0.2, 0.1
318, 0.4, 0.2, 0.2
319, 0.4, 0.2, 0.3
320, 0.4, 0.2, 0.4
321, 0.6, 0.2, 0.1
322, 0.6, 0.2, 0.2
323, 0.6, 0.2, 0.3
324, 0.6, 0.2, 0.4
325, 0.8, 0.2, 0.1
326, 0.8, 0.2, 0.2
327, 0.8, 0.2, 0.3
328, 0.8, 0.2, 0.4
329, 0.2, 0.3, 0.1
330, 0.2, 0.3, 0.2
331, 0.2, 0.3, 0.3
332, 0.2, 0.3, 0.4
333, 0.4, 0.3, 0.1
334, 0.4, 0.3, 0.2
335, 0.4, 0.3, 0.3
336, 0.4, 0.3, 0.4
337, 0.6, 0.3, 0.1
338, 0.6, 0.3, 0.2
339, 0.6, 0.3, 0.3
340, 0.6, 0.3, 0.4
341, 0.8, 0.3, 0.1
342, 0.8, 0.3, 0.2
343, 0.8, 0.3, 0.3
344, 0.8, 0.3, 0.4
345, 0.2, 0.46, 0
346, 0.2, 0.62, 0
347, 0.2, 0.78, 0
348, 0.2, 0.94, 0
349, 0.4, 0.46, 0
350, 0.4, 0.62, 0
351, 0.4, 0.78, 0
352, 0.4, 0.94, 0
353, 0.6, 0.46, 0
354, 0.6, 0.62, 0
355, 0.6, 0.78, 0
356, 0.6, 0.94, 0
357, 0.8, 0.46, 0
358, 0.8, 0.62, 0
359, 0.8, 0.78, 0
360, 0.8, 0.94, 0
361, 1, 0.46, 0.1
362, 1, 0.62, 0.1
363, 1, 0.78, 0.1
364, 1, 0.94, 0.1
365, 1, 0.46, 0.2
366, 1, 0.62, 0.2
367, 1, 0.78, 0.2
368, 1, 0.94, 0.2
369, 1, 0.46, 0.3
370, 1, 0.62, 0.3
371, 1, 0.78, 0.3
372, 1, 0.94, 0.3
373, 1, 0.46, 0.4
374, 1, 0.62, 0.4
375, 1, 0.78, 0.4
376, 1, 0.94, 0.4
377, 0.2, 0.46, 0.5
378, 0.2, 0.62, 0.5
379, 0.2, 0.78, 0.5
380, 0.2, 0.94, 0.5
381, 0.4, 0.46, 0.5
382, 0.4, 0.62, 0.5
383, 0.4, 0.78, 0.5
384, 0.4, 0.94, 0.5
385, 0.6, 0.46, 0.5
386, 0.6, 0.62, 0.5
387, 0.6, 0.78, 0.5
388, 0.6, 0.94, 0.5
389, 0.8, 0.46, 0.5
390, 0.8, 0.62, 0.5
391, 0.8, 0.78, 0.5
392, 0.8, 0.94, 0.5
393, 0, 0.46, 0.1
394, 0, 0.62, 0.1
395, 0, 0.78, 0.1
396, 0, 0.94, 0.1
397, 0, 0.46, 0.2
398, 0, 0.62, 0.2
399, 0, 0.78, 0.2
400, 0, 0.94, 0.2
401, 0, 0.46, 0.3
402, 0, 0.62, 0.3
403, 0, 0.78, 0.3
404, 0, 0.94, 0.3
405, 0, 0.46, 0.4
406, 0, 0.62, 0.4
407, 0, 0.78, 0.4
408, 0, 0.94, 0.4
409, 0.2, 1.1, 0.1
410, 0.2, 1.1, 0.2
411, 0.2, 1.1, 0.3
412, 0.2, 1.1, 0.4
413, 0.4, 1.1, 0.1
414, 0.4, 1.1, 0.2
415, 0.4, 1.1, 0.3
416, 0.4, 1.1, 0.4
417, 0.6, 1.1, 0.1
418, 0.6, 1.1, 0.2
419, 0.6, 1.1, 0.3
420, 0.6, 1.1, 0.4
421, 0.8, 1.1, 0.1
422, 0.8, 1.1, 0.2
423, 0.8, 1.1, 0.3
424, 0.8, 1.1, 0.4
425, 0.2, 1.2, 0.1
426, 0.2, 1.2, 0.2
427, 0.2, 1.2, 0.3
428, 0.2, 1.2, 0.4
429, 0.4, 1.2, 0.1
430, 0.4, 1.2, 0.2
431, 0.4, 1.2, 0.3
432, 0.4, 1.2, 0.4
433, 0.6, 1.2, 0.1
434, 0.6, 1.2, 0.2
435, 0.6, 1.2, 0.3
436, 0.6, 1.2, 0.4
437, 0.8, 1.2, 0.1
438, 0.8, 1.2, 0.2
439, 0.8, 1.2, 0.3
440, 0.8, 1.2, 0.4
441, 0.2, 1.4, 0.1
442, 0.2, 1.4, 0.2
443, 0.2, 1.4, 0.3
444, 0.2, 1.4, 0.4
445, 0.4, 1.4, 0.1
446, 0.4, 1.4, 0.2
447, 0.4, 1.4, 0.3
448, 0.4, 1.4, 0.4
449, 0.6, 1.4, 0.1
450, 0.6, 1.4, 0.2
451, 0.6, 1.4, 0.3
452, 0.6, 1.4, 0.4
453, 0.8, 1.4, 0.1
454, 0.8, 1.4, 0.2
455, 0.8, 1.4, 0.3
456, 0.8, 1.4, 0.4
457, 1.4, 1.2, 0.1
458, 1.6, 1.2, 0.1
459, 1.8, 1.2, 0.1
460, 2, 1.2, 0.1
461, 1.4, 1.2, 0.2
462, 1.6, 1.2, 0.2
463, 1.8, 1.2, 0.2
464, 2, 1.2, 0.2
465, 1.4, 1.2, 0.3
466, 1.6, 1.2, 0.3
467, 1.8, 1.2, 0.3
468, 2, 1.2, 0.3
469, 1.4, 1.2, 0.4
470, 1.6, 1.2, 0.4
471, 1.8, 1.2, 0.4
472, 2, 1.2, 0.4
473, 1.4, 1.4, 0.1
474, 1.6, 1.4, 0.1
475, 1.8, 1.4, 0.1
476, 2, 1.4, 0.1
477, 1.4, 1.4, 0.2
478, 1.6, 1.4, 0.2
479, 1.8, 1.4, 0.2
480, 2, 1.4, 0.2
481, 1.4, 1.4, 0.3
482, 1.6, 1.4, 0.3
483, 1.8, 1.4, 0.3
484, 2, 1.4, 0.3
485, 1.4, 1.4, 0.4
486, 1.6, 1.4, 0.4
487, 1.8, 1.4, 0.4
488, 2, 1.4, 0.4
489, 1.4, 1.1, 0.1
490, 1.6, 1.1, 0.1
491, 1.8, 1.1, 0.1
492, 2, 1.1, 0.1
493, 1.4, 1.1, 0.2
494, 1.6, 1.1, 0.2
495, 1.8, 1.1, 0.2
496, 2, 1.1, 0.2
497, 1.4, 1.1, 0.3
498, 1.6, 1.1, 0.3
499, 1.8, 1.1, 0.3
500, 2, 1.1, 0.3
501, 1.4, 1.1, 0.4
502, 1.6, 1.1, 0.4
503, 1.8, 1.1, 0.4
504, 2, 1.1, 0.4
505, 1.4, 0.94, 0.5
506, 1.4, 0.78, 0.5
507, 1.4, 0.62, 0.5
508, 1.4, 0.46, 0.5
509, 1.6, 0.94, 0.5
510, 1.6, 0.78, 0.5
511, 1.6, 0.62, 0.5
512, 1.6, 0.46, 0.5
513, 1.8, 0.94, 0.5
514, 1.8, 0.78, 0.5
515, 1.8, 0.62, 0.5
516, 1.8, 0.46, 0.5
517, 2, 0.94, 0.5
518, 2, 0.78, 0.5
519, 2, 0.62, 0.5
520, 2, 0.46, 0.5
521, 1.4, 0.94, 0
522, 1.4, 0.78, 0
523, 1.4, 0.62, 0
524, 1.4, 0.46, 0
525, 1.6, 0.94, 0
526, 1.6, 0.78, 0
527, 1.6, 0.62, 0
528, 1.6, 0.46, 0
529, 1.8, 0.94, 0
530, 1.8, 0.78, 0
531, 1.8, 0.62, 0
532, 1.8, 0.46, 0
533, 2, 0.94, 0
534, 2, 0.78, 0
535, 2, 0.62, 0
536, 2, 0.46, 0
537, 1.2, 0.94, 0.1
538, 1.2, 0.78, 0.1
539, 1.2, 0.62, 0.1
540, 1.2, 0.46, 0.1
541, 1.2, 0.94, 0.2
542, 1.2, 0.78, 0.2
543, 1.2, 0.62, 0.2
544, 1.2, 0.46, 0.2
545, 1.2, 0.94, 0.3
546, 1.2, 0.78, 0.3
547, 1.2, 0.62, 0.3
548, 1.2, 0.46, 0.3
549, 1.2, 0.94, 0.4
550, 1.2, 0.78, 0.4
551, 1.2, 0.62, 0.4
552, 1.2, 0.46, 0.4
553, 2.2, 0.94, 0.1
554, 2.2, 0.78, 0.1
555, 2.2, 0.62, 0.1
556, 2.2, 0.46, 0.1
557, 2.2, 0.94, 0.2
558, 2.2, 0.78, 0.2
559, 2.2, 0.62, 0.2
560, 2.2, 0.46, 0.2
561, 2.2, 0.94, 0.3
562, 2.2, 0.78, 0.3
563, 2.2, 0.62, 0.3
564, 2.2, 0.46, 0.3
565, 2.2, 0.94, 0.4
566, 2.2, 0.78, 0.4
567, 2.2, 0.62, 0.4
568, 2.2, 0.46, 0.4
569, 1.4, 0.3, 0.1
570, 1.6, 0.3, 0.1
571, 1.8, 0.3, 0.1
572, 2, 0.3, 0.1
573, 1.4, 0.3, 0.2
574, 1.6, 0.3, 0.2
575, 1.8, 0.3, 0.2
576, 2, 0.3, 0.2
577, 1.4, 0.3, 0.3
578, 1.6, 0.3, 0.3
579, 1.8, 0.3, 0.3
580, 2, 0.3, 0.3
581, 1.4, 0.3, 0.4
582, 1.6, 0.3, 0.4
583, 1.8, 0.3, 0.4
584, 2, 0.3, 0.4
585, 1.4, 0.2, 0.1
586, 1.6, 0.2, 0.1
587, 1.8, 0.2, 0.1
588, 2, 0.2, 0.1
589, 1.4, 0.2, 0.2
590, 1.6, 0.2, 0.2
591, 1.8, 0.2, 0.2
592, 2, 0.2, 0.2
593, 1.4, 0.2, 0.3
594, 1.6, 0.2, 0.3
595, 1.8, 0.2, 0.3
596, 2, 0.2, 0.3
597, 1.4, 0.2, 0.4
598, 1.6, 0.2, 0.4
599, 1.8, 0.2, 0.4
600, 2, 0.2, 0.4
601, 1.4, 2.7755575615629e-17, 0.1
602, 1.6, 2.7755575615629e-17, 0.1
603, 1.8, 2.7755575615629e-17, 0.1
604, 2, 2.7755575615629e-17, 0.1
605, 1.4, 2.7755575615629e-17, 0.2
606, 1.6, 2.7755575615629e-17, 0.2
607, 1.8, 2.7755575615629e-17, 0.2
608, 2, 2.7755575615629e-17, 0.2
609, 1.4, 2.7755575615629e-17, 0.3
610, 1.6, 2.7755575615629e-17, 0.3
611, 1.8, 2.7755575615629e-17, 0.3
612, 2, 2.7755575615629e-17, 0.3
613, 1.4, 2.7755575615629e-17, 0.4
614, 1.6, 2.7755575615629e-17, 0.4
615, 1.8, 2.7755575615629e-17, 0.4
616, 2, 2.7755575615629e-17, 0.4
617, 0.2, 0.46, 0.1
618, 0.2, 0.62, 0.1
619, 0.2, 0.78, 0.1
620, 0.2, 0.94, 0.1
621, 0.2, 0.46, 0.2
622, 0.2, 0.62, 0.2
623, 0.2, 0.78, 0.2
624, 0.2, 0.94, 0.2
625, 0.2, 0.46, 0.3
626, 0.2, 0.62, 0.3
627, 0.2, 0.78, 0.3
628, 0.2, 0.94, 0.3
629, 0.2, 0.46, 0.4
630, 0.2, 0.62, 0.4
631, 0.2, 0.78, 0.4
632, 0.2, 0.94, 0.4
633, 0.4, 0.46, 0.1
634, 0.4, 0.62, 0.1
635, 0.4, 0.78, 0.1
636, 0.4, 0.94, 0.1
637, 0.4, 0.46, 0.2
638, 0.4, 0.62, 0.2
639, 0.4, 0.78, 0.2
640, 0.4, 0.94, 0.2
641, 0.4, 0.46, 0.3
642, 0.4, 0.62, 0.3
643, 0.4, 0.78, 0.3
644, 0.4, 0.94, 0.3
645, 0.4, 0.46, 0.4
646, 0.4, 0.62, 0.4
647, 0.4, 0.78, 0.4
648, 0.4, 0.94, 0.4
649, 0.6, 0.46, 0.1
650, 0.6, 0.62, 0.1
651, 0.6, 0.78, 0.1
652, 0.6, 0.94, 0.1
653, 0.6, 0.46, 0.2
654, 0.6, 0.62, 0.2
655, 0.6, 0.78, 0.2
656, 0.6, 0.94, 0.2
657, 0.6, 0.46, 0.3
658, 0.6, 0.62, 0.3
659, 0.6, 0.78, 0.3
660, 0.6, 0.94, 0.3
661, 0.6, 0.46, 0.4
662, 0.6, 0.62, 0.4
663, 0.6, 0.78, 0.4
664, 0.6, 0.94, 0.4
665, 0.8, 0.46, 0.1
666, 0.8, 0.62, 0.1
667, 0.8, 0.78, 0.1
668, 0.8, 0.94, 0.1
669, 0.8, 0.46, 0.2
670, 0.8, 0.62, 0.2
671, 0.8, 0.78, 0.2
672, 0.8, 0.94, 0.2
673, 0.8, 0.46, 0.3
674, 0.8, 0.62, 0.3
675, 0.8, 0.78, 0.3
676, 0.8, 0.94, 0.3
677, 0.8, 0.46, 0.4
678, 0.8, 0.62, 0.4
679, 0.8, 0.78, 0.4
680, 0.8, 0.94, 0.4
681, 1.4, 0.94, 0.1
682, 1.4, 0.78, 0.1
683, 1.4, 0.62, 0.1
684, 1.4, 0.46, 0.1
685, 1.6, 0.94, 0.1
686, 1.6, 0.78, 0.1
687, 1.6, 0.62, 0.1
688, 1.6, 0.46, 0.1
689, 1.8, 0.94, 0.1
690, 1.8, 0.78, 0.1
691, 1.8, 0.62, 0.1
692, 1.8, 0.46, 0.1
693, 2, 0.94, 0.1
694, 2, 0.78, 0.1
695, 2, 0.62, 0.1
696, 2, 0.46, 0.1
697, 1.4, 0.94, 0.2
698, 1.4, 0.78, 0.2
699, 1.4, 0.62, 0.2
700, 1.4, 0.46, 0.2
701, 1.6, 0.94, 0.2
702, 1.6, 0.78, 0.2
703, 1.6, 0.62, 0.2
704, 1.6, 0.46, 0.2
705, 1.8, 0.94, 0.2
706, 1.8, 0.78, 0.2
707, 1.8, 0.62, 0.2
708, 1.8, 0.46, 0.2
709, 2, 0.94, 0.2
710, 2, 0.78, 0.2
711, 2, 0.62, 0.2
712, 2, 0.46, 0.2
713, 1.4, 0.94, 0.3
714, 1.4, 0.78, 0.3
715, 1.4, 0.62, 0.3
716, 1.4, 0.46, 0.3
717, 1.6, 0.94, 0.3
718, 1.6, 0.78, 0.3
719, 1.6, 0.62, 0.3
720, 1.6, 0.46, 0.3
721, 1.8, 0.94, 0.3
722, 1.8, 0.78, 0.3
723, 1.8, 0.62, 0.3
724, 1.8, 0.46, 0.3
725, 2, 0.94, 0.3
726, 2, 0.78, 0.3
727, 2, 0.62, 0.3
728, 2, 0.46, 0.3
729, 1.4, 0.94, 0.4
730, 1.4, 0.78, 0.4
731, 1.4, 0.62, 0.4
732, 1.4, 0.46, 0.4
733, 1.6, 0.94, 0.4
734, 1.6, 0.78, 0.4
735, 1.6, 0.62, 0.4
736, 1.6, 0.46, 0.4
737, 1.8, 0.94, 0.4
738, 1.8, 0.78, 0.4
739, 1.8, 0.62, 0.4
740, 1.8, 0.46, 0.4
741, 2, 0.94, 0.4
742, 2, 0.78, 0.4
743, 2, 0.62, 0.4
744, 2, 0.46, 0.4
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
642, 2, 57
643, 57, 58
644, 58, 59
645, 59, 60
646, 60, 1
*ELEMENT, type=T3D2, ELSET=Line2
647, 1, 3
*ELEMENT, type=T3D2, ELSET=Line3
648, 4, 61
649, 61, 62
650, 62, 63
651, 63, 64
652, 64, 3
*ELEMENT, type=T3D2, ELSET=Line4
653, 2, 4
*ELEMENT, type=T3D2, ELSET=Line5
654, 6, 65
655, 65, 66
656, 66, 67
657, 67, 68
658, 68, 5
*ELEMENT, type=T3D2, ELSET=Line6
659, 5, 7
*ELEMENT, type=T3D2, ELSET=Line7
660, 8, 69
661, 69, 70
662, 70, 71
663, 71, 72
664, 72, 7
*ELEMENT, type=T3D2, ELSET=Line8
665, 6, 8
*ELEMENT, type=T3D2, ELSET=Line9
666, 2, 73
667, 73, 74
668, 74, 75
669, 75, 76
670, 76, 6
*ELEMENT, type=T3D2, ELSET=Line10
671, 1, 77
672, 77, 78
673, 78, 79
674, 79, 80
675, 80, 5
*ELEMENT, type=T3D2, ELSET=Line11
676, 4, 81
677, 81, 82
678, 82, 83
679, 83, 84
680, 84, 8
*ELEMENT, type=T3D2, ELSET=Line12
681, 3, 85
682, 85, 86
683, 86, 87
684, 87, 88
685, 88, 7
*ELEMENT, type=T3D2, ELSET=Line13
686, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
687, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
688, 10, 89
689, 89, 90
690, 90, 91
691, 91, 92
692, 92, 9
*ELEMENT, type=T3D2, ELSET=Line16
693, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
694, 9, 93
695, 93, 94
696, 94, 95
697, 95, 96
698, 96, 11
*ELEMENT, type=T3D2, ELSET=Line18
699, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
700, 12, 97
701, 97, 98
702, 98, 99
703, 99, 100
704, 100, 11
*ELEMENT, type=T3D2, ELSET=Line20
705, 10, 101
706, 101, 102
707, 102, 103
708, 103, 104
709, 104, 12
*ELEMENT, type=T3D2, ELSET=Line21
710, 9, 105
711, 105, 106
712, 106, 107
713, 107, 108
714, 108, 13
*ELEMENT, type=T3D2, ELSET=Line22
715, 10, 109
716, 109, 110
717, 110, 111
718, 111, 112
719, 112, 14
*ELEMENT, type=T3D2, ELSET=Line23
720, 14, 113
721, 113, 114
722, 114, 115
723, 115, 116
724, 116, 13
*ELEMENT, type=T3D2, ELSET=Line24
725, 11, 117
726, 117, 118
727, 118, 119
728, 119, 120
729, 120, 15
*ELEMENT, type=T3D2, ELSET=Line25
730, 13, 121
731, 121, 122
732, 122, 123
733, 123, 124
734, 124, 15
*ELEMENT, type=T3D2, ELSET=Line26
735, 12, 125
736, 125, 126
737, 126, 127
738, 127, 128
739, 128, 16
*ELEMENT, type=T3D2, ELSET=Line27
740, 16, 129
741, 129, 130
742, 130, 131
743, 131, 132
744, 132, 15
*ELEMENT, type=T3D2, ELSET=Line28
745, 14, 133
746, 133, 134
747, 134, 135
748, 135, 136
749, 136, 16
*ELEMENT, type=T3D2, ELSET=Line29
750, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
751, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
752, 18, 137
753, 137, 138
754, 138, 139
755, 139, 140
756, 140, 17
*ELEMENT, type=T3D2, ELSET=Line32
757, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
758, 17, 141
759, 141, 142
760, 142, 143
761, 143, 144
762, 144, 19
*ELEMENT, type=T3D2, ELSET=Line34
763, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
764, 20, 145
765, 145, 146
766, 146, 147
767, 147, 148
768, 148, 19
*ELEMENT, type=T3D2, ELSET=Line36
769, 18, 149
770, 149, 150
771, 150, 151
772, 151, 152
773, 152, 20
*ELEMENT, type=T3D2, ELSET=Line37
774, 17, 21
*ELEMENT, type=T3D2, ELSET=Line38
775, 18, 22
*ELEMENT, type=T3D2, ELSET=Line39
776, 22, 153
777, 153, 154
778, 154, 155
779, 155, 156
780, 156, 21
*ELEMENT, type=T3D2, ELSET=Line40
781, 19, 23
*ELEMENT, type=T3D2, ELSET=Line41
782, 21, 157
783, 157, 158
784, 158, 159
785, 159, 160
786, 160, 23
*ELEMENT, type=T3D2, ELSET=Line42
787, 20, 24
*ELEMENT, type=T3D2, ELSET=Line43
788, 24, 161
789, 161, 162
790, 162, 163
791, 163, 164
792, 164, 23
*ELEMENT, type=T3D2, ELSET=Line44
793, 22, 165
794, 165, 166
795, 166, 167
796, 167, 168
797, 168, 24
*ELEMENT, type=T3D2, ELSET=Line45
798, 19, 25
*ELEMENT, type=T3D2, ELSET=Line46
799, 23, 26
*ELEMENT, type=T3D2, ELSET=Line47
800, 25, 26
*ELEMENT, type=T3D2, ELSET=Line48
801, 17, 27
*ELEMENT, type=T3D2, ELSET=Line49
802, 21, 28
*ELEMENT, type=T3D2, ELSET=Line50
803, 27, 28
*ELEMENT, type=T3D2, ELSET=Line51
804, 27, 169
805, 169, 170
806, 170, 171
807, 171, 172
808, 172, 25
*ELEMENT, type=T3D2, ELSET=Line52
809, 28, 173
810, 173, 174
811, 174, 175
812, 175, 176
813, 176, 26
*ELEMENT, type=T3D2, ELSET=Line53
814, 25, 177
815, 177, 178
816, 178, 179
817, 179, 180
818, 180, 29
*ELEMENT, type=T3D2, ELSET=Line54
819, 26, 181
820, 181, 182
821, 182, 183
822, 183, 184
823, 184, 30
*ELEMENT, type=T3D2, ELSET=Line55
824, 29, 30
*ELEMENT, type=T3D2, ELSET=Line56
825, 27, 185
826, 185, 186
827, 186, 187
828, 187, 188
829, 188, 31
*ELEMENT, type=T3D2, ELSET=Line57
830, 28, 189
831, 189, 190
832, 190, 191
833, 191, 192
834, 192, 32
*ELEMENT, type=T3D2, ELSET=Line58
835, 31, 32
*ELEMENT, type=T3D2, ELSET=Line59
836, 31, 193
837, 193, 194
838, 194, 195
839, 195, 196
840, 196, 29
*ELEMENT, type=T3D2, ELSET=Line60
841, 32, 197
842, 197, 198
843, 198, 199
844, 199, 200
845, 200, 30
*ELEMENT, type=T3D2, ELSET=Line61
846, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
847, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
848, 33, 201
849, 201, 202
850, 202, 203
851, 203, 204
852, 204, 34
*ELEMENT, type=T3D2, ELSET=Line64
853, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
854, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
855, 35, 205
856, 205, 206
857, 206, 207
858, 207, 208
859, 208, 36
*ELEMENT, type=T3D2, ELSET=Line67
860, 35, 209
861, 209, 210
862, 210, 211
863, 211, 212
864, 212, 33
*ELEMENT, type=T3D2, ELSET=Line68
865, 36, 213
866, 213, 214
867, 214, 215
868, 215, 216
869, 216, 34
*ELEMENT, type=T3D2, ELSET=Line69
870, 33, 217
871, 217, 218
872, 218, 219
873, 219, 220
874, 220, 37
*ELEMENT, type=T3D2, ELSET=Line70
875, 34, 221
876, 221, 222
877, 222, 223
878, 223, 224
879, 224, 38
*ELEMENT, type=T3D2, ELSET=Line71
880, 37, 225
881, 225, 226
882, 226, 227
883, 227, 228
884, 228, 38
*ELEMENT, type=T3D2, ELSET=Line72
885, 35, 229
886, 229, 230
887, 230, 231
888, 231, 232
889, 232, 39
*ELEMENT, type=T3D2, ELSET=Line73
890, 36, 233
891, 233, 234
892, 234, 235
893, 235, 236
894, 236, 40
*ELEMENT, type=T3D2, ELSET=Line74
895, 39, 237
896, 237, 238
897, 238, 239
898, 239, 240
899, 240, 40
*ELEMENT, type=T3D2, ELSET=Line75
900, 39, 241
901, 241, 242
902, 242, 243
903, 243, 244
904, 244, 37
*ELEMENT, type=T3D2, ELSET=Line76
905, 40, 245
906, 245, 246
907, 246, 247
908, 247, 248
909, 248, 38
*ELEMENT, type=T3D2, ELSET=Line77
910, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
911, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
912, 41, 249
913, 249, 250
914, 250, 251
915, 251, 252
916, 252, 42
*ELEMENT, type=T3D2, ELSET=Line80
917, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
918, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
919, 43, 253
920, 253, 254
921, 254, 255
922, 255, 256
923, 256, 44
*ELEMENT, type=T3D2, ELSET=Line83
924, 43, 257
925, 257, 258
926, 258, 259
927, 259, 260
928, 260, 41
*ELEMENT, type=T3D2, ELSET=Line84
929, 44, 261
930, 261, 262
931, 262, 263
932, 263, 264
933, 264, 42
*ELEMENT, type=T3D2, ELSET=Line85
934, 41, 45
*ELEMENT, type=T3D2, ELSET=Line86
935, 42, 46
*ELEMENT, type=T3D2, ELSET=Line87
936, 45, 265
937, 265, 266
938, 266, 267
939, 267, 268
940, 268, 46
*ELEMENT, type=T3D2, ELSET=Line88
941, 43, 47
*ELEMENT, type=T3D2, ELSET=Line89
942, 44, 48
*ELEMENT, type=T3D2, ELSET=Line90
943, 47, 269
944, 269, 270
945, 270, 271
946, 271, 272
947, 272, 48
*ELEMENT, type=T3D2, ELSET=Line91
948, 47, 273
949, 273, 274
950, 274, 275
951, 275, 276
952, 276, 45
*ELEMENT, type=T3D2, ELSET=Line92
953, 48, 277
954, 277, 278
955, 278, 279
956, 279, 280
957, 280, 46
*ELEMENT, type=T3D2, ELSET=Line93
958, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
959, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
960, 49, 50
*ELEMENT, type=T3D2, ELSET=Line96
961, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
962, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
963, 51, 52
*ELEMENT, type=T3D2, ELSET=Line99
964, 51, 281
965, 281, 282
966, 282, 283
967, 283, 284
968, 284, 49
*ELEMENT, type=T3D2, ELSET=Line100
969, 52, 285
970, 285, 286
971, 286, 287
972, 287, 288
973, 288, 50
*ELEMENT, type=T3D2, ELSET=Line101
974, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
975, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
976, 54, 289
977, 289, 290
978, 290, 291
979, 291, 292
980, 292, 53
*ELEMENT, type=T3D2, ELSET=Line104
981, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
982, 53, 55
*ELEMENT, type=T3D2, ELSET=Line106
983, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
984, 56, 293
985, 293, 294
986, 294, 295
987, 295, 296
988, 296, 55
*ELEMENT, type=T3D2, ELSET=Line108
989, 54, 56
*ELEMENT, type=CPS4, ELSET=Surface1
990, 2, 57, 61, 4
991, 57, 58, 62, 61
992, 58, 59, 63, 62
993, 59, 60, 64, 63
994, 60, 1, 3, 64
*ELEMENT, type=CPS4, ELSET=Surface2
995, 6, 8, 69, 65
996, 65, 69, 70, 66
997, 66, 70, 71, 67
998, 67, 71, 72, 68
999, 68, 72, 7, 5
*ELEMENT, type=CPS4, ELSET=Surface3
1, 2, 73, 297, 57
2, 57, 297, 298, 58
3, 58, 298, 299, 59
4, 59, 299, 300, 60
5, 60, 300, 77, 1
6, 73, 74, 301, 297
7, 297, 301, 302, 298
8, 298, 302, 303, 299
9, 299, 303, 304, 300
10, 300, 304, 78, 77
11, 74, 75, 305, 301
12, 301, 305, 306, 302
13, 302, 306, 307, 303
14, 303, 307, 308, 304
15, 304, 308, 79, 78
16, 75, 76, 309, 305
17, 305, 309, 310, 306
18, 306, 310, 311, 307
19, 307, 311, 312, 308
20, 308, 312, 80, 79
21, 76, 6, 65, 309
22, 309, 65, 66, 310
23, 310, 66, 67, 311
24, 311, 67, 68, 312
25, 312, 68, 5, 80
*ELEMENT, type=CPS4, ELSET=Surface4
1000, 4, 61, 313, 81
1001, 61, 62, 314, 313
1002, 62, 63, 315, 314
1003, 63, 64, 316, 315
1004, 64, 3, 85, 316
1005, 81, 313, 317, 82
1006, 313, 314, 318, 317
1007, 314, 315, 319, 318
1008, 315, 316, 320, 319
1009, 316, 85, 86, 320
1010, 82, 317, 321, 83
1011, 317, 318, 322, 321
1012, 318, 319, 323, 322
1013, 319, 320, 324, 323
1014, 320, 86, 87, 324
1015, 83, 321, 325, 84
1016, 321, 322, 326, 325
1017, 322, 323, 327, 326
1018, 323, 324, 328, 327
1019, 324, 87, 88, 328
1020, 84, 325, 69, 8
1021, 325, 326, 70, 69
1022, 326, 327, 71, 70
1023, 327, 328, 72, 71
1024, 328, 88, 7, 72
*ELEMENT, type=CPS4, ELSET=Surface5
1025, 2, 4, 81, 73
1026, 73, 81, 82, 74
1027, 74, 82, 83, 75
1028, 75, 83, 84, 76
1029, 76, 84, 8, 6
*ELEMENT, type=CPS4, ELSET=Surface6
1030, 1, 77, 85, 3
1031, 77, 78, 86, 85
1032, 78, 79, 87, 86
1033, 79, 80, 88, 87
1034, 80, 5, 7, 88
*ELEMENT, type=CPS4, ELSET=Surface7
1035, 4, 10, 89, 81
1036, 81, 89, 90, 82
1037, 82, 90, 91, 83
1038, 83, 91, 92, 84
1039, 84, 92, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
1040, 8, 9, 93, 69
1041, 69, 93, 94, 70
1042, 70, 94, 95, 71
1043, 71, 95, 96, 72
1044, 72, 96, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
1045, 3, 85, 97, 12
1046, 85, 86, 98, 97
1047, 86, 87, 99, 98
1048, 87, 88, 100, 99
1049, 88, 7, 11, 100
*ELEMENT, type=CPS4, ELSET=Surface10
1050, 4, 61, 101, 10
1051, 61, 62, 102, 101
1052, 62, 63, 103, 102
1053, 63, 64, 104, 103
1054, 64, 3, 12, 104
*ELEMENT, type=CPS4, ELSET=Surface11
1055, 10, 101, 329, 89
1056, 101, 102, 330, 329
1057, 102, 103, 331, 330
1058, 103, 104, 332, 331
1059, 104, 12, 97, 332
1060, 89, 329, 333, 90
1061, 329, 330, 334, 333
1062, 330, 331, 335, 334
1063, 331, 332, 336, 335
1064, 332, 97, 98, 336
1065, 90, 333, 337, 91
1066, 333, 334, 338, 337
1067, 334, 335, 339, 338
1068, 335, 336, 340, 339
1069, 336, 98, 99, 340
1070, 91, 337, 341, 92
1071, 337, 338, 342, 341
1072, 338, 339, 343, 342
1073, 339, 340, 344, 343
1074, 340, 99, 100, 344
1075, 92, 341, 93, 9
1076, 341, 342, 94, 93
1077, 342, 343, 95, 94
1078, 343, 344, 96, 95
1079, 344, 100, 11, 96
*ELEMENT, type=CPS4, ELSET=Surface12
1080, 10, 109, 345, 89
1081, 109, 110, 346, 345
1082, 110, 111, 347, 346
1083, 111, 112, 348, 347
1084, 112, 14, 113, 348
1085, 89, 345, 349, 90
1086, 345, 346, 350, 349
1087, 346, 347, 351, 350
1088, 347, 348, 352, 351
1089, 348, 113, 114, 352
1090, 90, 349, 353, 91
1091, 349, 350, 354, 353
1092, 350, 351, 355, 354
1093, 351, 352, 356, 355
1094, 352, 114, 115, 356
1095, 91, 353, 357, 92
1096, 353, 354, 358, 357
1097, 354, 355, 359, 358
1098, 355, 356, 360, 359
1099, 356, 115, 116, 360
1100, 92, 357, 105, 9
1101, 357, 358, 106, 105
1102, 358, 359, 107, 106
1103, 359, 360, 108, 107
1104, 360, 116, 13, 108
*ELEMENT, type=CPS4, ELSET=Surface13
1105, 9, 105, 361, 93
1106, 105, 106, 362, 361
1107, 106, 107, 363, 362
1108, 107, 108, 364, 363
1109, 108, 13, 121, 364
1110, 93, 361, 365, 94
1111, 361, 362, 366, 365
1112, 362, 363, 367, 366
1113, 363, 364, 368, 367
1114, 364, 121, 122, 368
1115, 94, 365, 369, 95
1116, 365, 366, 370, 369
1117, 366, 367, 371, 370
1118, 367, 368, 372, 371
1119, 368, 122, 123, 372
1120, 95, 369, 373, 96
1121, 369, 370, 374, 373
1122, 370, 371, 375, 374
1123, 371, 372, 376, 375
1124, 372, 123, 124, 376
1125, 96, 373, 117, 11
1126, 373, 374, 118, 117
1127, 374, 375, 119, 118
1128, 375, 376, 120, 119
1129, 376, 124, 15, 120
*ELEMENT, type=CPS4, ELSET=Surface14
1130, 12, 97, 377, 125
1131, 125, 377, 378, 126
1132, 126, 378, 379, 127
1133, 127, 379, 380, 128
1134, 128, 380, 129, 16
1135, 97, 98, 381, 377
1136, 377, 381, 382, 378
1137, 378, 382, 383, 379
1138, 379, 383, 384, 380
1139, 380, 384, 130, 129
1140, 98, 99, 385, 381
1141, 381, 385, 386, 382
1142, 382, 386, 387, 383
1143, 383, 387, 388, 384
1144, 384, 388, 131, 130
1145, 99, 100, 389, 385
1146, 385, 389, 390, 386
1147, 386, 390, 391, 387
1148, 387, 391, 392, 388
1149, 388, 392, 132, 131
1150, 100, 11, 117, 389
1151, 389, 117, 118, 390
1152, 390, 118, 119, 391
1153, 391, 119, 120, 392
1154, 392, 120, 15, 132
*ELEMENT, type=CPS4, ELSET=Surface15
1155, 10, 101, 393, 109
1156, 109, 393, 394, 110
1157, 110, 394, 395, 111
1158, 111, 395, 396, 112
1159, 112, 396, 133, 14
1160, 101, 102, 397, 393
1161, 393, 397, 398, 394
1162, 394, 398, 399, 395
1163, 395, 399, 400, 396
1164, 396, 400, 134, 133
1165, 102, 103, 401, 397
1166, 397, 401, 402, 398
1167, 398, 402, 403, 399
1168, 399, 403, 404, 400
1169, 400, 404, 135, 134
1170, 103, 104, 405, 401
1171, 401, 405, 406, 402
1172, 402, 406, 407, 403
1173, 403, 407, 408, 404
1174, 404, 408, 136, 135
1175, 104, 12, 125, 405
1176, 405, 125, 126, 406
1177, 406, 126, 127, 407
1178, 407, 127, 128, 408
1179, 408, 128, 16, 136
*ELEMENT, type=CPS4, ELSET=Surface16
1180, 14, 133, 409, 113
1181, 133, 134, 410, 409
1182, 134, 135, 411, 410
1183, 135, 136, 412, 411
1184, 136, 16, 129, 412
1185, 113, 409, 413, 114
1186, 409, 410, 414, 413
1187, 410, 411, 415, 414
1188, 411, 412, 416, 415
1189, 412, 129, 130, 416
1190, 114, 413, 417, 115
1191, 413, 414, 418, 417
1192, 414, 415, 419, 418
1193, 415, 416, 420, 419
1194, 416, 130, 131, 420
1195, 115, 417, 421, 116
1196, 417, 418, 422, 421
1197, 418, 419, 423, 422
1198, 419, 420, 424, 423
1199, 420, 131, 132, 424
1200, 116, 421, 121, 13
1201, 421, 422, 122, 121
1202, 422, 423, 123, 122
1203, 423, 424, 124, 123
1204, 424, 132, 15, 124
*ELEMENT, type=CPS4, ELSET=Surface17
1205, 14, 18, 137, 113
1206, 113, 137, 138, 114
1207, 114, 138, 139, 115
1208, 115, 139, 140, 116
1209, 116, 140, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
1210, 13, 17, 141, 121
1211, 121, 141, 142, 122
1212, 122, 142, 143, 123
1213, 123, 143, 144, 124
1214, 124, 144, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
1215, 16, 129, 145, 20
1216, 129, 130, 146, 145
1217, 130, 131, 147, 146
1218, 131, 132, 148, 147
1219, 132, 15, 19, 148
*ELEMENT, type=CPS4, ELSET=Surface20
1220, 14, 133, 149, 18
1221, 133, 134, 150, 149
1222, 134, 135, 151, 150
1223, 135, 136, 152, 151
1224, 136, 16, 20, 152
*ELEMENT, type=CPS4, ELSET=Surface21
1225, 18, 149, 425, 137
1226, 149, 150, 426, 425
1227, 150, 151, 427, 426
1228, 151, 152, 428, 427
1229, 152, 20, 145, 428
1230, 137, 425, 429, 138
1231, 425, 426, 430, 429
1232, 426, 427, 431, 430
1233, 427, 428, 432, 431
1234, 428, 145, 146, 432
1235, 138, 429, 433, 139
1236, 429, 430, 434, 433
1237, 430, 431, 435, 434
1238, 431, 432, 436, 435
1239, 432, 146, 147, 436
1240, 139, 433, 437, 140
1241, 433, 434, 438, 437
1242, 434, 435, 439, 438
1243, 435, 436, 440, 439
1244, 436, 147, 148, 440
1245, 140, 437, 141, 17
1246, 437, 438, 142, 141
1247, 438, 439, 143, 142
1248, 439, 440, 144, 143
1249, 440, 148, 19, 144
*ELEMENT, type=CPS4, ELSET=Surface22
1250, 18, 22, 153, 137
1251, 137, 153, 154, 138
1252, 138, 154, 155, 139
1253, 139, 155, 156, 140
1254, 140, 156, 21, 17
*ELEMENT, type=CPS4, ELSET=Surface23
1255, 17, 21, 157, 141
1256, 141, 157, 158, 142
1257, 142, 158, 159, 143
1258, 143, 159, 160, 144
1259, 144, 160, 23, 19
*ELEMENT, type=CPS4, ELSET=Surface24
1260, 20, 145, 161, 24
1261, 145, 146, 162, 161
1262, 146, 147, 163, 162
1263, 147, 148, 164, 163
1264, 148, 19, 23, 164
*ELEMENT, type=CPS4, ELSET=Surface25
26, 18, 149, 165, 22
27, 149, 150, 166, 165
28, 150, 151, 167, 166
29, 151, 152, 168, 167
30, 152, 20, 24, 168
*ELEMENT, type=CPS4, ELSET=Surface26
31, 22, 165, 441, 153
32, 165, 166, 442, 441
33, 166, 167, 443, 442
34, 167, 168, 444, 443
35, 168, 24, 161, 444
36, 153, 441, 445, 154
37, 441, 442, 446, 445
38, 442, 443, 447, 446
39, 443, 444, 448, 447
40, 444, 161, 162, 448
41, 154, 445, 449, 155
42, 445, 446, 450, 449
43, 446, 447, 451, 450
44, 447, 448, 452, 451
45, 448, 162, 163, 452
46, 155, 449, 453, 156
47, 449, 450, 454, 453
48, 450, 451, 455, 454
49, 451, 452, 456, 455
50, 452, 163, 164, 456
51, 156, 453, 157, 21
52, 453, 454, 158, 157
53, 454, 455, 159, 158
54, 455, 456, 160, 159
55, 456, 164, 23, 160
*ELEMENT, type=CPS4, ELSET=Surface27
1265, 19, 25, 26, 23
*ELEMENT, type=CPS4, ELSET=Surface28
1266, 17, 21, 28, 27
*ELEMENT, type=CPS4, ELSET=Surface29
1267, 17, 27, 169, 141
1268, 141, 169, 170, 142
1269, 142, 170, 171, 143
1270, 143, 171, 172, 144
1271, 144, 172, 25, 19
*ELEMENT, type=CPS4, ELSET=Surface30
56, 21, 157, 173, 28
57, 157, 158, 174, 173
58, 158, 159, 175, 174
59, 159, 160, 176, 175
60, 160, 23, 26, 176
*ELEMENT, type=CPS4, ELSET=Surface31
1272, 27, 28, 173, 169
1273, 169, 173, 174, 170
1274, 170, 174, 175, 171
1275, 171, 175, 176, 172
1276, 172, 176, 26, 25
*ELEMENT, type=CPS4, ELSET=Surface32
1277, 25, 177, 181, 26
1278, 177, 178, 182, 181
1279, 178, 179, 183, 182
1280, 179, 180, 184, 183
1281, 180, 29, 30, 184
*ELEMENT, type=CPS4, ELSET=Surface33
1282, 27, 28, 189, 185
1283, 185, 189, 190, 186
1284, 186, 190, 191, 187
1285, 187, 191, 192, 188
1286, 188, 192, 32, 31
*ELEMENT, type=CPS4, ELSET=Surface34
1287, 27, 185, 457, 169
1288, 185, 186, 458, 457
1289, 186, 187, 459, 458
1290, 187, 188, 460, 459
1291, 188, 31, 193, 460
1292, 169, 457, 461, 170
1293, 457, 458, 462, 461
1294, 458, 459, 463, 462
1295, 459, 460, 464, 463
1296, 460, 193, 194, 464
1297, 170, 461, 465, 171
1298, 461, 462, 466, 465
1299, 462, 463, 467, 466
1300, 463, 464, 468, 467
1301, 464, 194, 195, 468
1302, 171, 465, 469, 172
1303, 465, 466, 470, 469
1304, 466, 467, 471, 470
1305, 467, 468, 472, 471
1306, 468, 195, 196, 472
1307, 172, 469, 177, 25
1308, 469, 470, 178, 177
1309, 470, 471, 179, 178
1310, 471, 472, 180, 179
1311, 472, 196, 29, 180
*ELEMENT, type=CPS4, ELSET=Surface35
61, 28, 173, 473, 189
62, 189, 473, 474, 190
63, 190, 474, 475, 191
64, 191, 475, 476, 192
65, 192, 476, 197, 32
66, 173, 174, 477, 473
67, 473, 477, 478, 474
68, 474, 478, 479, 475
69, 475, 479, 480, 476
70, 476, 480, 198, 197
71, 174, 175, 481, 477
72, 477, 481, 482, 478
73, 478, 482, 483, 479
74, 479, 483, 484, 480
75, 480, 484, 199, 198
76, 175, 176, 485, 481
77, 481, 485, 486, 482
78, 482, 486, 487, 483
79, 483, 487, 488, 484
80, 484, 488, 200, 199
81, 176, 26, 181, 485
82, 485, 181, 182, 486
83, 486, 182, 183, 487
84, 487, 183, 184, 488
85, 488, 184, 30, 200
*ELEMENT, type=CPS4, ELSET=Surface36
1312, 31, 32, 197, 193
1313, 193, 197, 198, 194
1314, 194, 198, 199, 195
1315, 195, 199, 200, 196
1316, 196, 200, 30, 29
*ELEMENT, type=CPS4, ELSET=Surface37
1317, 25, 33, 201, 177
1318, 177, 201, 202, 178
1319, 178, 202, 203, 179
1320, 179, 203, 204, 180
1321, 180, 204, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
1322, 27, 185, 205, 35
1323, 185, 186, 206, 205
1324, 186, 187, 207, 206
1325, 187, 188, 208, 207
1326, 188, 31, 36, 208
*ELEMENT, type=CPS4, ELSET=Surface39
1327, 27, 35, 209, 169
1328, 169, 209, 210, 170
1329, 170, 210, 211, 171
1330, 171, 211, 212, 172
1331, 172, 212, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
1332, 31, 193, 213, 36
1333, 193, 194, 214, 213
1334, 194, 195, 215, 214
1335, 195, 196, 216, 215
1336, 196, 29, 34, 216
*ELEMENT, type=CPS4, ELSET=Surface41
1337, 35, 205, 489, 209
1338, 205, 206, 490, 489
1339, 206, 207, 491, 490
1340, 207, 208, 492, 491
1341, 208, 36, 213, 492
1342, 209, 489, 493, 210
1343, 489, 490, 494, 493
1344, 490, 491, 495, 494
1345, 491, 492, 496, 495
1346, 492, 213, 214, 496
1347, 210, 493, 497, 211
1348, 493, 494, 498, 497
1349, 494, 495, 499, 498
1350, 495, 496, 500, 499
1351, 496, 214, 215, 500
1352, 211, 497, 501, 212
1353, 497, 498, 502, 501
1354, 498, 499, 503, 502
1355, 499, 500, 504, 503
1356, 500, 215, 216, 504
1357, 212, 501, 201, 33
1358, 501, 502, 202, 201
1359, 502, 503, 203, 202
1360, 503, 504, 204, 203
1361, 504, 216, 34, 204
*ELEMENT, type=CPS4, ELSET=Surface42
1362, 33, 217, 505, 201
1363, 217, 218, 506, 505
1364, 218, 219, 507, 506
1365, 219, 220, 508, 507
1366, 220, 37, 225, 508
1367, 201, 505, 509, 202
1368, 505, 506, 510, 509
1369, 506, 507, 511, 510
1370, 507, 508, 512, 511
1371, 508, 225, 226, 512
1372, 202, 509, 513, 203
1373, 509, 510, 514, 513
1374, 510, 511, 515, 514
1375, 511, 512, 516, 515
1376, 512, 226, 227, 516
1377, 203, 513, 517, 204
1378, 513, 514, 518, 517
1379, 514, 515, 519, 518
1380, 515, 516, 520, 519
1381, 516, 227, 228, 520
1382, 204, 517, 221, 34
1383, 517, 518, 222, 221
1384, 518, 519, 223, 222
1385, 519, 520, 224, 223
1386, 520, 228, 38, 224
*ELEMENT, type=CPS4, ELSET=Surface43
1387, 35, 205, 521, 229
1388, 229, 521, 522, 230
1389, 230, 522, 523, 231
1390, 231, 523, 524, 232
1391, 232, 524, 237, 39
1392, 205, 206, 525, 521
1393, 521, 525, 526, 522
1394, 522, 526, 527, 523
1395, 523, 527, 528, 524
1396, 524, 528, 238, 237
1397, 206, 207, 529, 525
1398, 525, 529, 530, 526
1399, 526, 530, 531, 527
1400, 527, 531, 532, 528
1401, 528, 532, 239, 238
1402, 207, 208, 533, 529
1403, 529, 533, 534, 530
1404, 530, 534, 535, 531
1405, 531, 535, 536, 532
1406, 532, 536, 240, 239
1407, 208, 36, 233, 533
1408, 533, 233, 234, 534
1409, 534, 234, 235, 535
1410, 535, 235, 236, 536
1411, 536, 236, 40, 240
*ELEMENT, type=CPS4, ELSET=Surface44
1412, 35, 229, 537, 209
1413, 229, 230, 538, 537
1414, 230, 231, 539, 538
1415, 231, 232, 540, 539
1416, 232, 39, 241, 540
1417, 209, 537, 541, 210
1418, 537, 538, 542, 541
1419, 538, 539, 543, 542
1420, 539, 540, 544, 543
1421, 540, 241, 242, 544
1422, 210, 541, 545, 211
1423, 541, 542, 546, 545
1424, 542, 543, 547, 546
1425, 543, 544, 548, 547
1426, 544, 242, 243, 548
1427, 211, 545, 549, 212
1428, 545, 546, 550, 549
1429, 546, 547, 551, 550
1430, 547, 548, 552, 551
1431, 548, 243, 244, 552
1432, 212, 549, 217, 33
1433, 549, 550, 218, 217
1434, 550, 551, 219, 218
1435, 551, 552, 220, 219
1436, 552, 244, 37, 220
*ELEMENT, type=CPS4, ELSET=Surface45
1437, 36, 213, 553, 233
1438, 233, 553, 554, 234
1439, 234, 554, 555, 235
1440, 235, 555, 556, 236
1441, 236, 556, 245, 40
1442, 213, 214, 557, 553
1443, 553, 557, 558, 554
1444, 554, 558, 559, 555
1445, 555, 559, 560, 556
1446, 556, 560, 246, 245
1447, 214, 215, 561, 557
1448, 557, 561, 562, 558
1449, 558, 562, 563, 559
1450, 559, 563, 564, 560
1451, 560, 564, 247, 246
1452, 215, 216, 565, 561
1453, 561, 565, 566, 562
1454, 562, 566, 567, 563
1455, 563, 567, 568, 564
1456, 564, 568, 248, 247
1457, 216, 34, 221, 565
1458, 565, 221, 222, 566
1459, 566, 222, 223, 567
1460, 567, 223, 224, 568
1461, 568, 224, 38, 248
*ELEMENT, type=CPS4, ELSET=Surface46
1462, 39, 237, 569, 241
1463, 237, 238, 570, 569
1464, 238, 239, 571, 570
1465, 239, 240, 572, 571
1466, 240, 40, 245, 572
1467, 241, 569, 573, 242
1468, 569, 570, 574, 573
1469, 570, 571, 575, 574
1470, 571, 572, 576, 575
1471, 572, 245, 246, 576
1472, 242, 573, 577, 243
1473, 573, 574, 578, 577
1474, 574, 575, 579, 578
1475, 575, 576, 580, 579
1476, 576, 246, 247, 580
1477, 243, 577, 581, 244
1478, 577, 578, 582, 581
1479, 578, 579, 583, 582
1480, 579, 580, 584, 583
1481, 580, 247, 248, 584
1482, 244, 581, 225, 37
1483, 581, 582, 226, 225
1484, 582, 583, 227, 226
1485, 583, 584, 228, 227
1486, 584, 248, 38, 228
*ELEMENT, type=CPS4, ELSET=Surface47
1487, 37, 41, 249, 225
1488, 225, 249, 250, 226
1489, 226, 250, 251, 227
1490, 227, 251, 252, 228
1491, 228, 252, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
1492, 39, 237, 253, 43
1493, 237, 238, 254, 253
1494, 238, 239, 255, 254
1495, 239, 240, 256, 255
1496, 240, 40, 44, 256
*ELEMENT, type=CPS4, ELSET=Surface49
1497, 39, 43, 257, 241
1498, 241, 257, 258, 242
1499, 242, 258, 259, 243
1500, 243, 259, 260, 244
1501, 244, 260, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
1502, 40, 245, 261, 44
1503, 245, 246, 262, 261
1504, 246, 247, 263, 262
1505, 247, 248, 264, 263
1506, 248, 38, 42, 264
*ELEMENT, type=CPS4, ELSET=Surface51
1507, 43, 253, 585, 257
1508, 253, 254, 586, 585
1509, 254, 255, 587, 586
1510, 255, 256, 588, 587
1511, 256, 44, 261, 588
1512, 257, 585, 589, 258
1513, 585, 586, 590, 589
1514, 586, 587, 591, 590
1515, 587, 588, 592, 591
1516, 588, 261, 262, 592
1517, 258, 589, 593, 259
1518, 589, 590, 594, 593
1519, 590, 591, 595, 594
1520, 591, 592, 596, 595
1521, 592, 262, 263, 596
1522, 259, 593, 597, 260
1523, 593, 594, 598, 597
1524, 594, 595, 599, 598
1525, 595, 596, 600, 599
1526, 596, 263, 264, 600
1527, 260, 597, 249, 41
1528, 597, 598, 250, 249
1529, 598, 599, 251, 250
1530, 599, 600, 252, 251
1531, 600, 264, 42, 252
*ELEMENT, type=CPS4, ELSET=Surface52
1532, 41, 45, 265, 249
1533, 249, 265, 266, 250
1534, 250, 266, 267, 251
1535, 251, 267, 268, 252
1536, 252, 268, 46, 42
*ELEMENT, type=CPS4, ELSET=Surface53
1537, 43, 253, 269, 47
1538, 253, 254, 270, 269
1539, 254, 255, 271, 270
1540, 255, 256, 272, 271
1541, 256, 44, 48, 272
*ELEMENT, type=CPS4, ELSET=Surface54
1542, 43, 47, 273, 257
1543, 257, 273, 274, 258
1544, 258, 274, 275, 259
1545, 259, 275, 276, 260
1546, 260, 276, 45, 41
*ELEMENT, type=CPS4, ELSET=Surface55
1547, 44, 261, 277, 48
1548, 261, 262, 278, 277
1549, 262, 263, 279, 278
1550, 263, 264, 280, 279
1551, 264, 42, 46, 280
*ELEMENT, type=CPS4, ELSET=Surface56
86, 47, 269, 601, 273
87, 269, 270, 602, 601
88, 270, 271, 603, 602
89, 271, 272, 604, 603
90, 272, 48, 277, 604
91, 273, 601, 605, 274
92, 601, 602, 606, 605
93, 602, 603, 607, 606
94, 603, 604, 608, 607
95, 604, 277, 278, 608
96, 274, 605, 609, 275
97, 605, 606, 610, 609
98, 606, 607, 611, 610
99, 607, 608, 612, 611
100, 608, 278, 279, 612
101, 275, 609, 613, 276
102, 609, 610, 614, 613
103, 610, 611, 615, 614
104, 611, 612, 616, 615
105, 612, 279, 280, 616
106, 276, 613, 265, 45
107, 613, 614, 266, 265
108, 614, 615, 267, 266
109, 615, 616, 268, 267
110, 616, 280, 46, 268
*ELEMENT, type=CPS4, ELSET=Surface57
1552, 42, 46, 50, 49
*ELEMENT, type=CPS4, ELSET=Surface58
1553, 44, 51, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
1554, 44, 261, 281, 51
1555, 261, 262, 282, 281
1556, 262, 263, 283, 282
1557, 263, 264, 284, 283
1558, 264, 42, 49, 284
*ELEMENT, type=CPS4, ELSET=Surface60
1559, 48, 52, 285, 277
1560, 277, 285, 286, 278
1561, 278, 286, 287, 279
1562, 279, 287, 288, 280
1563, 280, 288, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
111, 51, 281, 285, 52
112, 281, 282, 286, 285
113, 282, 283, 287, 286
114, 283, 284, 288, 287
115, 284, 49, 50, 288
*ELEMENT, type=CPS4, ELSET=Surface62
1564, 2, 57, 289, 54
1565, 57, 58, 290, 289
1566, 58, 59, 291, 290
1567, 59, 60, 292, 291
1568, 60, 1, 53, 292
*ELEMENT, type=CPS4, ELSET=Surface63
1569, 1, 3, 55, 53
*ELEMENT, type=CPS4, ELSET=Surface64
1570, 4, 56, 293, 61
1571, 61, 293, 294, 62
1572, 62, 294, 295, 63
1573, 63, 295, 296, 64
1574, 64, 296, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
1575, 2, 54, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
116, 54, 289, 293, 56
117, 289, 290, 294, 293
118, 290, 291, 295, 294
119, 291, 292, 296, 295
120, 292, 53, 55, 296
*ELEMENT, type=C3D8, ELSET=Volume1
121, 61, 57, 2, 4, 313, 297, 73, 81
122, 313, 297, 73, 81, 317, 301, 74, 82
123, 317, 301, 74, 82, 321, 305, 75, 83
124, 321, 305, 75, 83, 325, 309, 76, 84
125, 325, 309, 76, 84, 69, 65, 6, 8
126, 62, 58, 57, 61, 314, 298, 297, 313
127, 314, 298, 297, 313, 318, 302, 301, 317
128, 318, 302, 301, 317, 322, 306, 305, 321
129, 322, 306, 305, 321, 326, 310, 309, 325
130, 326, 310, 309, 325, 70, 66, 65, 69
131, 63, 59, 58, 62, 315, 299, 298, 314
132, 315, 299, 298, 314, 319, 303, 302, 318
133, 319, 303, 302, 318, 323, 307, 306, 322
134, 323, 307, 306, 322, 327, 311, 310, 326
135, 327, 311, 310, 326, 71, 67, 66, 70
136, 64, 60, 59, 63, 316, 300, 299, 315
137, 316, 300, 299, 315, 320, 304, 303, 319
138, 320, 304, 303, 319, 324, 308, 307, 323
139, 324, 308, 307, 323, 328, 312, 311, 327
140, 328, 312, 311, 327, 72, 68, 67, 71
141, 3, 1, 60, 64, 85, 77, 300, 316
142, 85, 77, 300, 316, 86, 78, 304, 320
143, 86, 78, 304, 320, 87, 79, 308, 324
144, 87, 79, 308, 324, 88, 80, 312, 328
145, 88, 80, 312, 328, 7, 5, 68, 72
*ELEMENT, type=C3D8, ELSET=Volume2
146, 4, 61, 313, 81, 10, 101, 329, 89
147, 61, 62, 314, 313, 101, 102, 330, 329
148, 62, 63, 315, 314, 102, 103, 331, 330
149, 63, 64, 316, 315, 103, 104, 332, 331
150, 64, 3, 85, 316, 104, 12, 97, 332
151, 81, 313, 317, 82, 89, 329, 333, 90
152, 313, 314, 318, 317, 329, 330, 334, 333
153, 314, 315, 319, 318, 330, 331, 335, 334
154, 315, 316, 320, 319, 331, 332, 336, 335
155, 316, 85, 86, 320, 332, 97, 98, 336
156, 82, 317, 321, 83, 90, 333, 337, 91
157, 317, 318, 322, 321, 333, 334, 338, 337
158, 318, 319, 323, 322, 334, 335, 339, 338
159, 319, 320, 324, 323, 335, 336, 340, 339
160, 320, 86, 87, 324, 336, 98, 99, 340
161, 83, 321, 325, 84, 91, 337, 341, 92
162, 321, 322, 326, 325, 337, 338, 342, 341
163, 322, 323, 327, 326, 338, 339, 343, 342
164, 323, 324, 328, 327, 339, 340, 344, 343
165, 324, 87, 88, 328, 340, 99, 100, 344
166, 84, 325, 69, 8, 92, 341, 93, 9
167, 325, 326, 70, 69, 341, 342, 94, 93
168, 326, 327, 71, 70, 342, 343, 95, 94
169, 327, 328, 72, 71, 343, 344, 96, 95
170, 328, 88, 7, 72, 344, 100, 11, 96
*ELEMENT, type=C3D8, ELSET=Volume3
171, 10, 101, 329, 89, 109, 393, 617, 345
172, 109, 393, 617, 345, 110, 394, 618, 346
173, 110, 394, 618, 346, 111, 395, 619, 347
174, 111, 395, 619, 347, 112, 396, 620, 348
175, 112, 396, 620, 348, 14, 133, 409, 113
176, 101, 102, 330, 329, 393, 397, 621, 617
177, 393, 397, 621, 617, 394, 398, 622, 618
178, 394, 398, 622, 618, 395, 399, 623, 619
179, 395, 399, 623, 619, 396, 400, 624, 620
180, 396, 400, 624, 620, 133, 134, 410, 409
181, 102, 103, 331, 330, 397, 401, 625, 621
182, 397, 401, 625, 621, 398, 402, 626, 622
183, 398, 402, 626, 622, 399, 403, 627, 623
184, 399, 403, 627, 623, 400, 404, 628, 624
185, 400, 404, 628, 624, 134, 135, 411, 410
186, 103, 104, 332, 331, 401, 405, 629, 625
187, 401, 405, 629, 625, 402, 406, 630, 626
188, 402, 406, 630, 626, 403, 407, 631, 627
189, 403, 407, 631, 627, 404, 408, 632, 628
190, 404, 408, 632, 628, 135, 136, 412, 411
191, 104, 12, 97, 332, 405, 125, 377, 629
192, 405, 125, 377, 629, 406, 126, 378, 630
193, 406, 126, 378, 630, 407, 127, 379, 631
194, 407, 127, 379, 631, 408, 128, 380, 632
195, 408, 128, 380, 632, 136, 16, 129, 412
196, 89, 329, 333, 90, 345, 617, 633, 349
197, 345, 617, 633, 349, 346, 618, 634, 350
198, 346, 618, 634, 350, 347, 619, 635, 351
199, 347, 619, 635, 351, 348, 620, 636, 352
200, 348, 620, 636, 352, 113, 409, 413, 114
201, 329, 330, 334, 333, 617, 621, 637, 633
202, 617, 621, 637, 633, 618, 622, 638, 634
203, 618, 622, 638, 634, 619, 623, 639, 635
204, 619, 623, 639, 635, 620, 624, 640, 636
205, 620, 624, 640, 636, 409, 410, 414, 413
206, 330, 331, 335, 334, 621, 625, 641, 637
207, 621, 625, 641, 637, 622, 626, 642, 638
208, 622, 626, 642, 638, 623, 627, 643, 639
209, 623, 627, 643, 639, 624, 628, 644, 640
210, 624, 628, 644, 640, 410, 411, 415, 414
211, 331, 332, 336, 335, 625, 629, 645, 641
212, 625, 629, 645, 641, 626, 630, 646, 642
213, 626, 630, 646, 642, 627, 631, 647, 643
214, 627, 631, 647, 643, 628, 632, 648, 644
215, 628, 632, 648, 644, 411, 412, 416, 415
216, 332, 97, 98, 336, 629, 377, 381, 645
217, 629, 377, 381, 645, 630, 378, 382, 646
218, 630, 378, 382, 646, 631, 379, 383, 647
219, 631, 379, 383, 647, 632, 380, 384, 648
220, 632, 380, 384, 648, 412, 129, 130, 416
221, 90, 333, 337, 91, 349, 633, 649, 353
222, 349, 633, 649, 353, 350, 634, 650, 354
223, 350, 634, 650, 354, 351, 635, 651, 355
224, 351, 635, 651, 355, 352, 636, 652, 356
225, 352, 636, 652, 356, 114, 413, 417, 115
226, 333, 334, 338, 337, 633, 637, 653, 649
227, 633, 637, 653, 649, 634, 638, 654, 650
228, 634, 638, 654, 650, 635, 639, 655, 651
229, 635, 639, 655, 651, 636, 640, 656, 652
230, 636, 640, 656, 652, 413, 414, 418, 417
231, 334, 335, 339, 338, 637, 641, 657, 653
232, 637, 641, 657, 653, 638, 642, 658, 654
233, 638, 642, 658, 654, 639, 643, 659, 655
234, 639, 643, 659, 655, 640, 644, 660, 656
235, 640, 644, 660, 656, 414, 415, 419, 418
236, 335, 336, 340, 339, 641, 645, 661, 657
237, 641, 645, 661, 657, 642, 646, 662, 658
238, 642, 646, 662, 658, 643, 647, 663, 659
239, 643, 647, 663, 659, 644, 648, 664, 660
240, 644, 648, 664, 660, 415, 416, 420, 419
241, 336, 98, 99, 340, 645, 381, 385, 661
242, 645, 381, 385, 661, 646, 382, 386, 662
243, 646, 382, 386, 662, 647, 383, 387, 663
244, 647, 383, 387, 663, 648, 384, 388, 664
245, 648, 384, 388, 664, 416, 130, 131, 420
246, 91, 337, 341, 92, 353, 649, 665, 357
247, 353, 649, 665, 357, 354, 650, 666, 358
248, 354, 650, 666, 358, 355, 651, 667, 359
249, 355, 651, 667, 359, 356, 652, 668, 360
250, 356, 652, 668, 360, 115, 417, 421, 116
251, 337, 338, 342, 341, 649, 653, 669, 665
252, 649, 653, 669, 665, 650, 654, 670, 666
253, 650, 654, 670, 666, 651, 655, 671, 667
254, 651, 655, 671, 667, 652, 656, 672, 668
255, 652, 656, 672, 668, 417, 418, 422, 421
256, 338, 339, 343, 342, 653, 657, 673, 669
257, 653, 657, 673, 669, 654, 658, 674, 670
258, 654, 658, 674, 670, 655, 659, 675, 671
259, 655, 659, 675, 671, 656, 660, 676, 672
260, 656, 660, 676, 672, 418, 419, 423, 422
261, 339, 340, 344, 343, 657, 661, 677, 673
262, 657, 661, 677, 673, 658, 662, 678, 674
263, 658, 662, 678, 674, 659, 663, 679, 675
264, 659, 663, 679, 675, 660, 664, 680, 676
265, 660, 664, 680, 676, 419, 420, 424, 423
266, 340, 99, 100, 344, 661, 385, 389, 677
267, 661, 385, 389, 677, 662, 386, 390, 678
268, 662, 386, 390, 678, 663, 387, 391, 679
269, 663, 387, 391, 679, 664, 388, 392, 680
270, 664, 388, 392, 680, 420, 131, 132, 424
271, 92, 341, 93, 9, 357, 665, 361, 105
272, 357, 665, 361, 105, 358, 666, 362, 106
273, 358, 666, 362, 106, 359, 667, 363, 107
274, 359, 667, 363, 107, 360, 668, 364, 108
275, 360, 668, 364, 108, 116, 421, 121, 13
276, 341, 342, 94, 93, 665, 669, 365, 361
277, 665, 669, 365, 361, 666, 670, 366, 362
278, 666, 670, 366, 362, 667, 671, 367, 363
279, 667, 671, 367, 363, 668, 672, 368, 364
280, 668, 672, 368, 364, 421, 422, 122, 121
281, 342, 343, 95, 94, 669, 673, 369, 365
282, 669, 673, 369, 365, 670, 674, 370, 366
283, 670, 674, 370, 366, 671, 675, 371, 367
284, 671, 675, 371, 367, 672, 676, 372, 368
285, 672, 676, 372, 368, 422, 423, 123, 122
286, 343, 344, 96, 95, 673, 677, 373, 369
287, 673, 677, 373, 369, 674, 678, 374, 370
288, 674, 678, 374, 370, 675, 679, 375, 371
289, 675, 679, 375, 371, 676, 680, 376, 372
290, 676, 680, 376, 372, 423, 424, 124, 123
291, 344, 100, 11, 96, 677, 389, 117, 373
292, 677, 389, 117, 373, 678, 390, 118, 374
293, 678, 390, 118, 374, 679, 391, 119, 375
294, 679, 391, 119, 375, 680, 392, 120, 376
295, 680, 392, 120, 376, 424, 132, 15, 124
*ELEMENT, type=C3D8, ELSET=Volume4
296, 14, 133, 409, 113, 18, 149, 425, 137
297, 133, 134, 410, 409, 149, 150, 426, 425
298, 134, 135, 411, 410, 150, 151, 427, 426
299, 135, 136, 412, 411, 151, 152, 428, 427
300, 136, 16, 129, 412, 152, 20, 145, 428
301, 113, 409, 413, 114, 137, 425, 429, 138
302, 409, 410, 414, 413, 425, 426, 430, 429
303, 410, 411, 415, 414, 426, 427, 431, 430
304, 411, 412, 416, 415, 427, 428, 432, 431
305, 412, 129, 130, 416, 428, 145, 146, 432
306, 114, 413, 417, 115, 138, 429, 433, 139
307, 413, 414, 418, 417, 429, 430, 434, 433
308, 414, 415, 419, 418, 430, 431, 435, 434
309, 415, 416, 420, 419, 431, 432, 436, 435
310, 416, 130, 131, 420, 432, 146, 147, 436
311, 115, 417, 421, 116, 139, 433, 437, 140
312, 417, 418, 422, 421, 433, 434, 438, 437
313, 418, 419, 423, 422, 434, 435, 439, 438
314, 419, 420, 424, 423, 435, 436, 440, 439
315, 420, 131, 132, 424, 436, 147, 148, 440
316, 116, 421, 121, 13, 140, 437, 141, 17
317, 421, 422, 122, 121, 437, 438, 142, 141
318, 422, 423, 123, 122, 438, 439, 143, 142
319, 423, 424, 124, 123, 439, 440, 144, 143
320, 424, 132, 15, 124, 440, 148, 19, 144
*ELEMENT, type=C3D8, ELSET=Volume5
321, 18, 149, 425, 137, 22, 165, 441, 153
322, 149, 150, 426, 425, 165, 166, 442, 441
323, 150, 151, 427, 426, 166, 167, 443, 442
324, 151, 152, 428, 427, 167, 168, 444, 443
325, 152, 20, 145, 428, 168, 24, 161, 444
326, 137, 425, 429, 138, 153, 441, 445, 154
327, 425, 426, 430, 429, 441, 442, 446, 445
328, 426, 427, 431, 430, 442, 443, 447, 446
329, 427, 428, 432, 431, 443, 444, 448, 447
330, 428, 145, 146, 432, 444, 161, 162, 448
331, 138, 429, 433, 139, 154, 445, 449, 155
332, 429, 430, 434, 433, 445, 446, 450, 449
333, 430, 431, 435, 434, 446, 447, 451, 450
334, 431, 432, 436, 435, 447, 448, 452, 451
335, 432, 146, 147, 436, 448, 162, 163, 452
336, 139, 433, 437, 140, 155, 449, 453, 156
337, 433, 434, 438, 437, 449, 450, 454, 453
338, 434, 435, 439, 438, 450, 451, 455, 454
339, 435, 436, 440, 439, 451, 452, 456, 455
340, 436, 147, 148, 440, 452, 163, 164, 456
341, 140, 437, 141, 17, 156, 453, 157, 21
342, 437, 438, 142, 141, 453, 454, 158, 157
343, 438, 439, 143, 142, 454, 455, 159, 158
344, 439, 440, 144, 143, 455, 456, 160, 159
345, 440, 148, 19, 144, 456, 164, 23, 160
*ELEMENT, type=C3D8, ELSET=Volume6
346, 17, 21, 157, 141, 27, 28, 173, 169
347, 141, 157, 158, 142, 169, 173, 174, 170
348, 142, 158, 159, 143, 170, 174, 175, 171
349, 143, 159, 160, 144, 171, 175, 176, 172
350, 144, 160, 23, 19, 172, 176, 26, 25
*ELEMENT, type=C3D8, ELSET=Volume7
351, 27, 28, 173, 169, 185, 189, 473, 457
352, 185, 189, 473, 457, 186, 190, 474, 458
353, 186, 190, 474, 458, 187, 191, 475, 459
354, 187, 191, 475, 459, 188, 192, 476, 460
355, 188, 192, 476, 460, 31, 32, 197, 193
356, 169, 173, 174, 170, 457, 473, 477, 461
357, 457, 473, 477, 461, 458, 474, 478, 462
358, 458, 474, 478, 462, 459, 475, 479, 463
359, 459, 475, 479, 463, 460, 476, 480, 464
360, 460, 476, 480, 464, 193, 197, 198, 194
361, 170, 174, 175, 171, 461, 477, 481, 465
362, 461, 477, 481, 465, 462, 478, 482, 466
363, 462, 478, 482, 466, 463, 479, 483, 467
364, 463, 479, 483, 467, 464, 480, 484, 468
365, 464, 480, 484, 468, 194, 198, 199, 195
366, 171, 175, 176, 172, 465, 481, 485, 469
367, 465, 481, 485, 469, 466, 482, 486, 470
368, 466, 482, 486, 470, 467, 483, 487, 471
369, 467, 483, 487, 471, 468, 484, 488, 472
370, 468, 484, 488, 472, 195, 199, 200, 196
371, 172, 176, 26, 25, 469, 485, 181, 177
372, 469, 485, 181, 177, 470, 486, 182, 178
373, 470, 486, 182, 178, 471, 487, 183, 179
374, 471, 487, 183, 179, 472, 488, 184, 180
375, 472, 488, 184, 180, 196, 200, 30, 29
*ELEMENT, type=C3D8, ELSET=Volume8
376, 27, 185, 457, 169, 35, 205, 489, 209
377, 185, 186, 458, 457, 205, 206, 490, 489
378, 186, 187, 459, 458, 206, 207, 491, 490
379, 187, 188, 460, 459, 207, 208, 492, 491
380, 188, 31, 193, 460, 208, 36, 213, 492
381, 169, 457, 461, 170, 209, 489, 493, 210
382, 457, 458, 462, 461, 489, 490, 494, 493
383, 458, 459, 463, 462, 490, 491, 495, 494
384, 459, 460, 464, 463, 491, 492, 496, 495
385, 460, 193, 194, 464, 492, 213, 214, 496
386, 170, 461, 465, 171, 210, 493, 497, 211
387, 461, 462, 466, 465, 493, 494, 498, 497
388, 462, 463, 467, 466, 494, 495, 499, 498
389, 463, 464, 468, 467, 495, 496, 500, 499
390, 464, 194, 195, 468, 496, 214, 215, 500
391, 171, 465, 469, 172, 211, 497, 501, 212
392, 465, 466, 470, 469, 497, 498, 502, 501
393, 466, 467, 471, 470, 498, 499, 503, 502
394, 467, 468, 472, 471, 499, 500, 504, 503
395, 468, 195, 196, 472, 500, 215, 216, 504
396, 172, 469, 177, 25, 212, 501, 201, 33
397, 469, 470, 178, 177, 501, 502, 202, 201
398, 470, 471, 179, 178, 502, 503, 203, 202
399, 471, 472, 180, 179, 503, 504, 204, 203
400, 472, 196, 29, 180, 504, 216, 34, 204
*ELEMENT, type=C3D8, ELSET=Volume9
401, 35, 205, 489, 209, 229, 521, 681, 537
402, 229, 521, 681, 537, 230, 522, 682, 538
403, 230, 522, 682, 538, 231, 523, 683, 539
404, 231, 523, 683, 539, 232, 524, 684, 540
405, 232, 524, 684, 540, 39, 237, 569, 241
406, 205, 206, 490, 489, 521, 525, 685, 681
407, 521, 525, 685, 681, 522, 526, 686, 682
408, 522, 526, 686, 682, 523, 527, 687, 683
409, 523, 527, 687, 683, 524, 528, 688, 684
410, 524, 528, 688, 684, 237, 238, 570, 569
411, 206, 207, 491, 490, 525, 529, 689, 685
412, 525, 529, 689, 685, 526, 530, 690, 686
413, 526, 530, 690, 686, 527, 531, 691, 687
414, 527, 531, 691, 687, 528, 532, 692, 688
415, 528, 532, 692, 688, 238, 239, 571, 570
416, 207, 208, 492, 491, 529, 533, 693, 689
417, 529, 533, 693, 689, 530, 534, 694, 690
418, 530, 534, 694, 690, 531, 535, 695, 691
419, 531, 535, 695, 691, 532, 536, 696, 692
420, 532, 536, 696, 692, 239, 240, 572, 571
421, 208, 36, 213, 492, 533, 233, 553, 693
422, 533, 233, 553, 693, 534, 234, 554, 694
423, 534, 234, 554, 694, 535, 235, 555, 695
424, 535, 235, 555, 695, 536, 236, 556, 696
425, 536, 236, 556, 696, 240, 40, 245, 572
426, 209, 489, 493, 210, 537, 681, 697, 541
427, 537, 681, 697, 541, 538, 682, 698, 542
428, 538, 682, 698, 542, 539, 683, 699, 543
429, 539, 683, 699, 543, 540, 684, 700, 544
430, 540, 684, 700, 544, 241, 569, 573, 242
431, 489, 490, 494, 493, 681, 685, 701, 697
432, 681, 685, 701, 697, 682, 686, 702, 698
433, 682, 686, 702, 698, 683, 687, 703, 699
434, 683, 687, 703, 699, 684, 688, 704, 700
435, 684, 688, 704, 700, 569, 570, 574, 573
436, 490, 491, 495, 494, 685, 689, 705, 701
437, 685, 689, 705, 701, 686, 690, 706, 702
438, 686, 690, 706, 702, 687, 691, 707, 703
439, 687, 691, 707, 703, 688, 692, 708, 704
440, 688, 692, 708, 704, 570, 571, 575, 574
441, 491, 492, 496, 495, 689, 693, 709, 705
442, 689, 693, 709, 705, 690, 694, 710, 706
443, 690, 694, 710, 706, 691, 695, 711, 707
444, 691, 695, 711, 707, 692, 696, 712, 708
445, 692, 696, 712, 708, 571, 572, 576, 575
446, 492, 213, 214, 496, 693, 553, 557, 709
447, 693, 553, 557, 709, 694, 554, 558, 710
448, 694, 554, 558, 710, 695, 555, 559, 711
449, 695, 555, 559, 711, 696, 556, 560, 712
450, 696, 556, 560, 712, 572, 245, 246, 576
451, 210, 493, 497, 211, 541, 697, 713, 545
452, 541, 697, 713, 545, 542, 698, 714, 546
453, 542, 698, 714, 546, 543, 699, 715, 547
454, 543, 699, 715, 547, 544, 700, 716, 548
455, 544, 700, 716, 548, 242, 573, 577, 243
456, 493, 494, 498, 497, 697, 701, 717, 713
457, 697, 701, 717, 713, 698, 702, 718, 714
458, 698, 702, 718, 714, 699, 703, 719, 715
459, 699, 703, 719, 715, 700, 704, 720, 716
460, 700, 704, 720, 716, 573, 574, 578, 577
461, 494, 495, 499, 498, 701, 705, 721, 717
462, 701, 705, 721, 717, 702, 706, 722, 718
463, 702, 706, 722, 718, 703, 707, 723, 719
464, 703, 707, 723, 719, 704, 708, 724, 720
465, 704, 708, 724, 720, 574, 575, 579, 578
466, 495, 496, 500, 499, 705, 709, 725, 721
467, 705, 709, 725, 721, 706, 710, 726, 722
468, 706, 710, 726, 722, 707, 711, 727, 723
469, 707, 711, 727, 723, 708, 712, 728, 724
470, 708, 712, 728, 724, 575, 576, 580, 579
471, 496, 214, 215, 500, 709, 557, 561, 725
472, 709, 557, 561, 725, 710, 558, 562, 726
473, 710, 558, 562, 726, 711, 559, 563, 727
474, 711, 559, 563, 727, 712, 560, 564, 728
475, 712, 560, 564, 728, 576, 246, 247, 580
476, 211, 497, 501, 212, 545, 713, 729, 549
477, 545, 713, 729, 549, 546, 714, 730, 550
478, 546, 714, 730, 550, 547, 715, 731, 551
479, 547, 715, 731, 551, 548, 716, 732, 552
480, 548, 716, 732, 552, 243, 577, 581, 244
481, 497, 498, 502, 501, 713, 717, 733, 729
482, 713, 717, 733, 729, 714, 718, 734, 730
483, 714, 718, 734, 730, 715, 719, 735, 731
484, 715, 719, 735, 731, 716, 720, 736, 732
485, 716, 720, 736, 732, 577, 578, 582, 581
486, 498, 499, 503, 502, 717, 721, 737, 733
487, 717, 721, 737, 733, 718, 722, 738, 734
488, 718, 722, 738, 734, 719, 723, 739, 735
489, 719, 723, 739, 735, 720, 724, 740, 736
490, 720, 724, 740, 736, 578, 579, 583, 582
491, 499, 500, 504, 503, 721, 725, 741, 737
492, 721, 725, 741, 737, 722, 726, 742, 738
493, 722, 726, 742, 738, 723, 727, 743, 739
494, 723, 727, 743, 739, 724, 728, 744, 740
495, 724, 728, 744, 740, 579, 580, 584, 583
496, 500, 215, 216, 504, 725, 561, 565, 741
497, 725, 561, 565, 741, 726, 562, 566, 742
498, 726, 562, 566, 742, 727, 563, 567, 743
499, 727, 563, 567, 743, 728, 564, 568, 744
500, 728, 564, 568, 744, 580, 247, 248, 584
501, 212, 501, 201, 33, 549, 729, 505, 217
502, 549, 729, 505, 217, 550, 730, 506, 218
503, 550, 730, 506, 218, 551, 731, 507, 219
504, 551, 731, 507, 219, 552, 732, 508, 220
505, 552, 732, 508, 220, 244, 581, 225, 37
506, 501, 502, 202, 201, 729, 733, 509, 505
507, 729, 733, 509, 505, 730, 734, 510, 506
508, 730, 734, 510, 506, 731, 735, 511, 507
509, 731, 735, 511, 507, 732, 736, 512, 508
510, 732, 736, 512, 508, 581, 582, 226, 225
511, 502, 503, 203, 202, 733, 737, 513, 509
512, 733, 737, 513, 509, 734, 738, 514, 510
513, 734, 738, 514, 510, 735, 739, 515, 511
514, 735, 739, 515, 511, 736, 740, 516, 512
515, 736, 740, 516, 512, 582, 583, 227, 226
516, 503, 504, 204, 203, 737, 741, 517, 513
517, 737, 741, 517, 513, 738, 742, 518, 514
518, 738, 742, 518, 514, 739, 743, 519, 515
519, 739, 743, 519, 515, 740, 744, 520, 516
520, 740, 744, 520, 516, 583, 584, 228, 227
521, 504, 216, 34, 204, 741, 565, 221, 517
522, 741, 565, 221, 517, 742, 566, 222, 518
523, 742, 566, 222, 518, 743, 567, 223, 519
524, 743, 567, 223, 519, 744, 568, 224, 520
525, 744, 568, 224, 520, 584, 248, 38, 228
*ELEMENT, type=C3D8, ELSET=Volume10
526, 39, 237, 569, 241, 43, 253, 585, 257
527, 237, 238, 570, 569, 253, 254, 586, 585
528, 238, 239, 571, 570, 254, 255, 587, 586
529, 239, 240, 572, 571, 255, 256, 588, 587
530, 240, 40, 245, 572, 256, 44, 261, 588
531, 241, 569, 573, 242, 257, 585, 589, 258
532, 569, 570, 574, 573, 585, 586, 590, 589
533, 570, 571, 575, 574, 586, 587, 591, 590
534, 571, 572, 576, 575, 587, 588, 592, 591
535, 572, 245, 246, 576, 588, 261, 262, 592
536, 242, 573, 577, 243, 258, 589, 593, 259
537, 573, 574, 578, 577, 589, 590, 594, 593
538, 574, 575, 579, 578, 590, 591, 595, 594
539, 575, 576, 580, 579, 591, 592, 596, 595
540, 576, 246, 247, 580, 592, 262, 263, 596
541, 243, 577, 581, 244, 259, 593, 597, 260
542, 577, 578, 582, 581, 593, 594, 598, 597
543, 578, 579, 583, 582, 594, 595, 599, 598
544, 579, 580, 584, 583, 595, 596, 600, 599
545, 580, 247, 248, 584, 596, 263, 264, 600
546, 244, 581, 225, 37, 260, 597, 249, 41
547, 581, 582, 226, 225, 597, 598, 250, 249
548, 582, 583, 227, 226, 598, 599, 251, 250
549, 583, 584, 228, 227, 599, 600, 252, 251
550, 584, 248, 38, 228, 600, 264, 42, 252
*ELEMENT, type=C3D8, ELSET=Volume11
551, 43, 253, 585, 257, 47, 269, 601, 273
552, 253, 254, 586, 585, 269, 270, 602, 601
553, 254, 255, 587, 586, 270, 271, 603, 602
554, 255, 256, 588, 587, 271, 272, 604, 603
555, 256, 44, 261, 588, 272, 48, 277, 604
556, 257, 585, 589, 258, 273, 601, 605, 274
557, 585, 586, 590, 589, 601, 602, 606, 605
558, 586, 587, 591, 590, 602, 603, 607, 606
559, 587, 588, 592, 591, 603, 604, 608, 607
560, 588, 261, 262, 592, 604, 277, 278, 608
561, 258, 589, 593, 259, 274, 605, 609, 275
562, 589, 590, 594, 593, 605, 606, 610, 609
563, 590, 591, 595, 594, 606, 607, 611, 610
564, 591, 592, 596, 595, 607, 608, 612, 611
565, 592, 262, 263, 596, 608, 278, 279, 612
566, 259, 593, 597, 260, 275, 609, 613, 276
567, 593, 594, 598, 597, 609, 610, 614, 613
568, 594, 595, 599, 598, 610, 611, 615, 614
569, 595, 596, 600, 599, 611, 612, 616, 615
570, 596, 263, 264, 600, 612, 279, 280, 616
571, 260, 597, 249, 41, 276, 613, 265, 45
572, 597, 598, 250, 249, 613, 614, 266, 265
573, 598, 599, 251, 250, 614, 615, 267, 266
574, 599, 600, 252, 251, 615, 616, 268, 267
575, 600, 264, 42, 252, 616, 280, 46, 268
*ELEMENT, type=C3D8, ELSET=Volume12
576, 44, 261, 277, 48, 51, 281, 285, 52
577, 261, 262, 278, 277, 281, 282, 286, 285
578, 262, 263, 279, 278, 282, 283, 287, 286
579, 263, 264, 280, 279, 283, 284, 288, 287
580, 264, 42, 46, 280, 284, 49, 50, 288
*ELEMENT, type=C3D8, ELSET=Volume13
581, 2, 57, 61, 4, 54, 289, 293, 56
582, 57, 58, 62, 61, 289, 290, 294, 293
583, 58, 59, 63, 62, 290, 291, 295, 294
584, 59, 60, 64, 63, 291, 292, 296, 295
585, 60, 1, 3, 64, 292, 53, 55, 296
*ELSET,ELSET=Qin
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 
*ELSET,ELSET=HeatSink
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
*ELSET,ELSET=ElectrodeMaxX
111, 112, 113, 114, 115, 
*ELSET,ELSET=ElectrodeMinX
116, 117, 118, 119, 120, 
*ELSET,ELSET=Force
26, 27, 28, 29, 30, 
*ELSET,ELSET=Copper
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 321, 322, 323, 324, 325, 
326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 
336, 337, 338, 339, 340, 341, 342, 343, 344, 345, 
346, 347, 348, 349, 350, 351, 352, 353, 354, 355, 
356, 357, 358, 359, 360, 361, 362, 363, 364, 365, 
366, 367, 368, 369, 370, 371, 372, 373, 374, 375, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 
*ELSET,ELSET=SemiconductorN-
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 
*ELSET,ELSET=SemiconductorP+
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 
*ELSET,ELSET=Solder
146, 147, 148, 149, 150, 151, 152, 153, 154, 155, 
156, 157, 158, 159, 160, 161, 162, 163, 164, 165, 
166, 167, 168, 169, 170, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
376, 377, 378, 379, 380, 381, 382, 383, 384, 385, 
386, 387, 388, 389, 390, 391, 392, 393, 394, 395, 
396, 397, 398, 399, 400, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
*ELSET,ELSET=Volume
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 
*ELSET,ELSET=TO
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 401, 402, 403, 404, 405, 
406, 407, 408, 409, 410, 411, 412, 413, 414, 415, 
416, 417, 418, 419, 420, 421, 422, 423, 424, 425, 
426, 427, 428, 429, 430, 431, 432, 433, 434, 435, 
436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 
446, 447, 448, 449, 450, 451, 452, 453, 454, 455, 
456, 457, 458, 459, 460, 461, 462, 463, 464, 465, 
466, 467, 468, 469, 470, 471, 472, 473, 474, 475, 
476, 477, 478, 479, 480, 481, 482, 483, 484, 485, 
486, 487, 488, 489, 490, 491, 492, 493, 494, 495, 
496, 497, 498, 499, 500, 501, 502, 503, 504, 505, 
506, 507, 508, 509, 510, 511, 512, 513, 514, 515, 
516, 517, 518, 519, 520, 521, 522, 523, 524, 525, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 153, 154, 
155, 156, 157, 158, 159, 160, 161, 162, 163, 164, 
165, 166, 167, 168, 173, 174, 175, 176, 181, 182, 
183, 184, 189, 190, 191, 192, 197, 198, 199, 200, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 473, 474, 475, 476, 
477, 478, 479, 480, 481, 482, 483, 484, 485, 486, 
487, 488, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 57, 58, 
59, 60, 65, 66, 67, 68, 73, 74, 75, 76, 
77, 78, 79, 80, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
297, 298, 299, 300, 301, 302, 303, 304, 305, 306, 
307, 308, 309, 310, 311, 312, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 
615, 616, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 281, 282, 283, 284, 285, 286, 
287, 288, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 289, 290, 291, 292, 293, 294, 
295, 296, 
*NSET,NSET=Force
18, 20, 22, 24, 149, 150, 151, 152, 165, 166, 
167, 168, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 
67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 
77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 
87, 88, 137, 138, 139, 140, 141, 142, 143, 144, 
145, 146, 147, 148, 149, 150, 151, 152, 153, 154, 
155, 156, 157, 158, 159, 160, 161, 162, 163, 164, 
165, 166, 167, 168, 169, 170, 171, 172, 173, 174, 
175, 176, 177, 178, 179, 180, 181, 182, 183, 184, 
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 249, 250, 251, 252, 
253, 254, 255, 256, 257, 258, 259, 260, 261, 262, 
263, 264, 265, 266, 267, 268, 269, 270, 271, 272, 
273, 274, 275, 276, 277, 278, 279, 280, 281, 282, 
283, 284, 285, 286, 287, 288, 289, 290, 291, 292, 
293, 294, 295, 296, 297, 298, 299, 300, 301, 302, 
303, 304, 305, 306, 307, 308, 309, 310, 311, 312, 
313, 314, 315, 316, 317, 318, 319, 320, 321, 322, 
323, 324, 325, 326, 327, 328, 425, 426, 427, 428, 
429, 430, 431, 432, 433, 434, 435, 436, 437, 438, 
439, 440, 441, 442, 443, 444, 445, 446, 447, 448, 
449, 450, 451, 452, 453, 454, 455, 456, 457, 458, 
459, 460, 461, 462, 463, 464, 465, 466, 467, 468, 
469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 
479, 480, 481, 482, 483, 484, 485, 486, 487, 488, 
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 
615, 616, 
*NSET,NSET=SemiconductorN-
9, 10, 11, 12, 13, 14, 15, 16, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 329, 330, 331, 332, 
333, 334, 335, 336, 337, 338, 339, 340, 341, 342, 
343, 344, 345, 346, 347, 348, 349, 350, 351, 352, 
353, 354, 355, 356, 357, 358, 359, 360, 361, 362, 
363, 364, 365, 366, 367, 368, 369, 370, 371, 372, 
373, 374, 375, 376, 377, 378, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 401, 402, 
403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 
413, 414, 415, 416, 417, 418, 419, 420, 421, 422, 
423, 424, 617, 618, 619, 620, 621, 622, 623, 624, 
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 
645, 646, 647, 648, 649, 650, 651, 652, 653, 654, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 
*NSET,NSET=SemiconductorP+
33, 34, 35, 36, 37, 38, 39, 40, 201, 202, 
203, 204, 205, 206, 207, 208, 209, 210, 211, 212, 
213, 214, 215, 216, 217, 218, 219, 220, 221, 222, 
223, 224, 225, 226, 227, 228, 229, 230, 231, 232, 
233, 234, 235, 236, 237, 238, 239, 240, 241, 242, 
243, 244, 245, 246, 247, 248, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 527, 528, 529, 530, 531, 532, 
533, 534, 535, 536, 537, 538, 539, 540, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 564, 565, 566, 567, 568, 569, 570, 571, 572, 
573, 574, 575, 576, 577, 578, 579, 580, 581, 582, 
583, 584, 681, 682, 683, 684, 685, 686, 687, 688, 
689, 690, 691, 692, 693, 694, 695, 696, 697, 698, 
699, 700, 701, 702, 703, 704, 705, 706, 707, 708, 
709, 710, 711, 712, 713, 714, 715, 716, 717, 718, 
719, 720, 721, 722, 723, 724, 725, 726, 727, 728, 
729, 730, 731, 732, 733, 734, 735, 736, 737, 738, 
739, 740, 741, 742, 743, 744, 
*NSET,NSET=Solder
3, 4, 7, 8, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 25, 27, 29, 31, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 61, 62, 63, 64, 69, 70, 71, 72, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 113, 114, 115, 116, 121, 122, 
123, 124, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 169, 170, 171, 172, 
177, 178, 179, 180, 185, 186, 187, 188, 193, 194, 
195, 196, 201, 202, 203, 204, 205, 206, 207, 208, 
209, 210, 211, 212, 213, 214, 215, 216, 225, 226, 
227, 228, 237, 238, 239, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
313, 314, 315, 316, 317, 318, 319, 320, 321, 322, 
323, 324, 325, 326, 327, 328, 329, 330, 331, 332, 
333, 334, 335, 336, 337, 338, 339, 340, 341, 342, 
343, 344, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 429, 430, 431, 432, 433, 434, 435, 436, 
437, 438, 439, 440, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 471, 472, 
489, 490, 491, 492, 493, 494, 495, 496, 497, 498, 
499, 500, 501, 502, 503, 504, 569, 570, 571, 572, 
573, 574, 575, 576, 577, 578, 579, 580, 581, 582, 
583, 584, 585, 586, 587, 588, 589, 590, 591, 592, 
593, 594, 595, 596, 597, 598, 599, 600, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 592, 593, 594, 595, 596, 597, 598, 599, 600, 
601, 602, 603, 604, 605, 606, 607, 608, 609, 610, 
611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 
621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 
631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 704, 705, 706, 707, 708, 709, 710, 
711, 712, 713, 714, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 724, 725, 726, 727, 728, 729, 730, 
731, 732, 733, 734, 735, 736, 737, 738, 739, 740, 
741, 742, 743, 744, 
*NSET,NSET=TO
9, 10, 11, 12, 13, 14, 15, 16, 33, 34, 
35, 36, 37, 38, 39, 40, 89, 90, 91, 92, 
93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 
103, 104, 105, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 
123, 124, 125, 126, 127, 128, 129, 130, 131, 132, 
133, 134, 135, 136, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 
247, 248, 329, 330, 331, 332, 333, 334, 335, 336, 
337, 338, 339, 340, 341, 342, 343, 344, 345, 346, 
347, 348, 349, 350, 351, 352, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 401, 402, 403, 404, 405, 406, 
407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 617, 618, 619, 620, 621, 622, 
623, 624, 625, 626, 627, 628, 629, 630, 631, 632, 
633, 634, 635, 636, 637, 638, 639, 640, 641, 642, 
643, 644, 645, 646, 647, 648, 649, 650, 651, 652, 
653, 654, 655, 656, 657, 658, 659, 660, 661, 662, 
663, 664, 665, 666, 667, 668, 669, 670, 671, 672, 
673, 674, 675, 676, 677, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 701, 702, 
703, 704, 705, 706, 707, 708, 709, 710, 711, 712, 
713, 714, 715, 716, 717, 718, 719, 720, 721, 722, 
723, 724, 725, 726, 727, 728, 729, 730, 731, 732, 
733, 734, 735, 736, 737, 738, 739, 740, 741, 742, 
743, 744, 
