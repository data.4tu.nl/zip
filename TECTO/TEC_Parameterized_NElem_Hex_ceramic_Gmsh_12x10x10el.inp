7045, 1.2833333333333, 1.3625, 0.1
7046, 1.3666666666667, 1.3625, 0.1
7047, 1.45, 1.3625, 0.1
7048, 1.5333333333333, 1.3625, 0.1
7049, 1.6166666666667, 1.3625, 0.1
7050, 1.7, 1.3625, 0.1
7051, 1.7833333333333, 1.3625, 0.1
7052, 1.8666666666667, 1.3625, 0.1
7053, 1.95, 1.3625, 0.1
7054, 2.0333333333333, 1.3625, 0.1
7055, 2.1166666666667, 1.3625, 0.1
7056, 1.2833333333333, 1.375, 0.1
7057, 1.3666666666667, 1.375, 0.1
7058, 1.45, 1.375, 0.1
7059, 1.5333333333333, 1.375, 0.1
7060, 1.6166666666667, 1.375, 0.1
7061, 1.7, 1.375, 0.1
7062, 1.7833333333333, 1.375, 0.1
7063, 1.8666666666667, 1.375, 0.1
7064, 1.95, 1.375, 0.1
7065, 2.0333333333333, 1.375, 0.1
7066, 2.1166666666667, 1.375, 0.1
7067, 1.2833333333333, 1.3875, 0.1
7068, 1.3666666666667, 1.3875, 0.1
7069, 1.45, 1.3875, 0.1
7070, 1.5333333333333, 1.3875, 0.1
7071, 1.6166666666667, 1.3875, 0.1
7072, 1.7, 1.3875, 0.1
7073, 1.7833333333333, 1.3875, 0.1
7074, 1.8666666666667, 1.3875, 0.1
7075, 1.95, 1.3875, 0.1
7076, 2.0333333333333, 1.3875, 0.1
7077, 2.1166666666667, 1.3875, 0.1
7078, 1.2833333333333, 1.3625, 0.15
7079, 1.3666666666667, 1.3625, 0.15
7080, 1.45, 1.3625, 0.15
7081, 1.5333333333333, 1.3625, 0.15
7082, 1.6166666666667, 1.3625, 0.15
7083, 1.7, 1.3625, 0.15
7084, 1.7833333333333, 1.3625, 0.15
7085, 1.8666666666667, 1.3625, 0.15
7086, 1.95, 1.3625, 0.15
7087, 2.0333333333333, 1.3625, 0.15
7088, 2.1166666666667, 1.3625, 0.15
7089, 1.2833333333333, 1.375, 0.15
7090, 1.3666666666667, 1.375, 0.15
7091, 1.45, 1.375, 0.15
7092, 1.5333333333333, 1.375, 0.15
7093, 1.6166666666667, 1.375, 0.15
7094, 1.7, 1.375, 0.15
7095, 1.7833333333333, 1.375, 0.15
7096, 1.8666666666667, 1.375, 0.15
7097, 1.95, 1.375, 0.15
7098, 2.0333333333333, 1.375, 0.15
7099, 2.1166666666667, 1.375, 0.15
7100, 1.2833333333333, 1.3875, 0.15
7101, 1.3666666666667, 1.3875, 0.15
7102, 1.45, 1.3875, 0.15
7103, 1.5333333333333, 1.3875, 0.15
7104, 1.6166666666667, 1.3875, 0.15
7105, 1.7, 1.3875, 0.15
7106, 1.7833333333333, 1.3875, 0.15
7107, 1.8666666666667, 1.3875, 0.15
7108, 1.95, 1.3875, 0.15
7109, 2.0333333333333, 1.3875, 0.15
7110, 2.1166666666667, 1.3875, 0.15
7111, 1.2833333333333, 1.3625, 0.2
7112, 1.3666666666667, 1.3625, 0.2
7113, 1.45, 1.3625, 0.2
7114, 1.5333333333333, 1.3625, 0.2
7115, 1.6166666666667, 1.3625, 0.2
7116, 1.7, 1.3625, 0.2
7117, 1.7833333333333, 1.3625, 0.2
7118, 1.8666666666667, 1.3625, 0.2
7119, 1.95, 1.3625, 0.2
7120, 2.0333333333333, 1.3625, 0.2
7121, 2.1166666666667, 1.3625, 0.2
7122, 1.2833333333333, 1.375, 0.2
7123, 1.3666666666667, 1.375, 0.2
7124, 1.45, 1.375, 0.2
7125, 1.5333333333333, 1.375, 0.2
7126, 1.6166666666667, 1.375, 0.2
7127, 1.7, 1.375, 0.2
7128, 1.7833333333333, 1.375, 0.2
7129, 1.8666666666667, 1.375, 0.2
7130, 1.95, 1.375, 0.2
7131, 2.0333333333333, 1.375, 0.2
7132, 2.1166666666667, 1.375, 0.2
7133, 1.2833333333333, 1.3875, 0.2
7134, 1.3666666666667, 1.3875, 0.2
7135, 1.45, 1.3875, 0.2
7136, 1.5333333333333, 1.3875, 0.2
7137, 1.6166666666667, 1.3875, 0.2
7138, 1.7, 1.3875, 0.2
7139, 1.7833333333333, 1.3875, 0.2
7140, 1.8666666666667, 1.3875, 0.2
7141, 1.95, 1.3875, 0.2
7142, 2.0333333333333, 1.3875, 0.2
7143, 2.1166666666667, 1.3875, 0.2
7144, 1.2833333333333, 1.3625, 0.25
7145, 1.3666666666667, 1.3625, 0.25
7146, 1.45, 1.3625, 0.25
7147, 1.5333333333333, 1.3625, 0.25
7148, 1.6166666666667, 1.3625, 0.25
7149, 1.7, 1.3625, 0.25
7150, 1.7833333333333, 1.3625, 0.25
7151, 1.8666666666667, 1.3625, 0.25
7152, 1.95, 1.3625, 0.25
7153, 2.0333333333333, 1.3625, 0.25
7154, 2.1166666666667, 1.3625, 0.25
7155, 1.2833333333333, 1.375, 0.25
7156, 1.3666666666667, 1.375, 0.25
7157, 1.45, 1.375, 0.25
7158, 1.5333333333333, 1.375, 0.25
7159, 1.6166666666667, 1.375, 0.25
7160, 1.7, 1.375, 0.25
7161, 1.7833333333333, 1.375, 0.25
7162, 1.8666666666667, 1.375, 0.25
7163, 1.95, 1.375, 0.25
7164, 2.0333333333333, 1.375, 0.25
7165, 2.1166666666667, 1.375, 0.25
7166, 1.2833333333333, 1.3875, 0.25
7167, 1.3666666666667, 1.3875, 0.25
7168, 1.45, 1.3875, 0.25
7169, 1.5333333333333, 1.3875, 0.25
7170, 1.6166666666667, 1.3875, 0.25
7171, 1.7, 1.3875, 0.25
7172, 1.7833333333333, 1.3875, 0.25
7173, 1.8666666666667, 1.3875, 0.25
7174, 1.95, 1.3875, 0.25
7175, 2.0333333333333, 1.3875, 0.25
7176, 2.1166666666667, 1.3875, 0.25
7177, 1.2833333333333, 1.3625, 0.3
7178, 1.3666666666667, 1.3625, 0.3
7179, 1.45, 1.3625, 0.3
7180, 1.5333333333333, 1.3625, 0.3
7181, 1.6166666666667, 1.3625, 0.3
7182, 1.7, 1.3625, 0.3
7183, 1.7833333333333, 1.3625, 0.3
7184, 1.8666666666667, 1.3625, 0.3
7185, 1.95, 1.3625, 0.3
7186, 2.0333333333333, 1.3625, 0.3
7187, 2.1166666666667, 1.3625, 0.3
7188, 1.2833333333333, 1.375, 0.3
7189, 1.3666666666667, 1.375, 0.3
7190, 1.45, 1.375, 0.3
7191, 1.5333333333333, 1.375, 0.3
7192, 1.6166666666667, 1.375, 0.3
7193, 1.7, 1.375, 0.3
7194, 1.7833333333333, 1.375, 0.3
7195, 1.8666666666667, 1.375, 0.3
7196, 1.95, 1.375, 0.3
7197, 2.0333333333333, 1.375, 0.3
7198, 2.1166666666667, 1.375, 0.3
7199, 1.2833333333333, 1.3875, 0.3
7200, 1.3666666666667, 1.3875, 0.3
7201, 1.45, 1.3875, 0.3
7202, 1.5333333333333, 1.3875, 0.3
7203, 1.6166666666667, 1.3875, 0.3
7204, 1.7, 1.3875, 0.3
7205, 1.7833333333333, 1.3875, 0.3
7206, 1.8666666666667, 1.3875, 0.3
7207, 1.95, 1.3875, 0.3
7208, 2.0333333333333, 1.3875, 0.3
7209, 2.1166666666667, 1.3875, 0.3
7210, 1.2833333333333, 1.3625, 0.35
7211, 1.3666666666667, 1.3625, 0.35
7212, 1.45, 1.3625, 0.35
7213, 1.5333333333333, 1.3625, 0.35
7214, 1.6166666666667, 1.3625, 0.35
7215, 1.7, 1.3625, 0.35
7216, 1.7833333333333, 1.3625, 0.35
7217, 1.8666666666667, 1.3625, 0.35
7218, 1.95, 1.3625, 0.35
7219, 2.0333333333333, 1.3625, 0.35
7220, 2.1166666666667, 1.3625, 0.35
7221, 1.2833333333333, 1.375, 0.35
7222, 1.3666666666667, 1.375, 0.35
7223, 1.45, 1.375, 0.35
7224, 1.5333333333333, 1.375, 0.35
7225, 1.6166666666667, 1.375, 0.35
7226, 1.7, 1.375, 0.35
7227, 1.7833333333333, 1.375, 0.35
7228, 1.8666666666667, 1.375, 0.35
7229, 1.95, 1.375, 0.35
7230, 2.0333333333333, 1.375, 0.35
7231, 2.1166666666667, 1.375, 0.35
7232, 1.2833333333333, 1.3875, 0.35
7233, 1.3666666666667, 1.3875, 0.35
7234, 1.45, 1.3875, 0.35
7235, 1.5333333333333, 1.3875, 0.35
7236, 1.6166666666667, 1.3875, 0.35
7237, 1.7, 1.3875, 0.35
7238, 1.7833333333333, 1.3875, 0.35
7239, 1.8666666666667, 1.3875, 0.35
7240, 1.95, 1.3875, 0.35
7241, 2.0333333333333, 1.3875, 0.35
7242, 2.1166666666667, 1.3875, 0.35
7243, 1.2833333333333, 1.3625, 0.4
7244, 1.3666666666667, 1.3625, 0.4
7245, 1.45, 1.3625, 0.4
7246, 1.5333333333333, 1.3625, 0.4
7247, 1.6166666666667, 1.3625, 0.4
7248, 1.7, 1.3625, 0.4
7249, 1.7833333333333, 1.3625, 0.4
7250, 1.8666666666667, 1.3625, 0.4
7251, 1.95, 1.3625, 0.4
7252, 2.0333333333333, 1.3625, 0.4
7253, 2.1166666666667, 1.3625, 0.4
7254, 1.2833333333333, 1.375, 0.4
7255, 1.3666666666667, 1.375, 0.4
7256, 1.45, 1.375, 0.4
7257, 1.5333333333333, 1.375, 0.4
7258, 1.6166666666667, 1.375, 0.4
7259, 1.7, 1.375, 0.4
7260, 1.7833333333333, 1.375, 0.4
7261, 1.8666666666667, 1.375, 0.4
7262, 1.95, 1.375, 0.4
7263, 2.0333333333333, 1.375, 0.4
7264, 2.1166666666667, 1.375, 0.4
7265, 1.2833333333333, 1.3875, 0.4
7266, 1.3666666666667, 1.3875, 0.4
7267, 1.45, 1.3875, 0.4
7268, 1.5333333333333, 1.3875, 0.4
7269, 1.6166666666667, 1.3875, 0.4
7270, 1.7, 1.3875, 0.4
7271, 1.7833333333333, 1.3875, 0.4
7272, 1.8666666666667, 1.3875, 0.4
7273, 1.95, 1.3875, 0.4
7274, 2.0333333333333, 1.3875, 0.4
7275, 2.1166666666667, 1.3875, 0.4
7276, 1.2833333333333, 1.3625, 0.45
7277, 1.3666666666667, 1.3625, 0.45
7278, 1.45, 1.3625, 0.45
7279, 1.5333333333333, 1.3625, 0.45
7280, 1.6166666666667, 1.3625, 0.45
7281, 1.7, 1.3625, 0.45
7282, 1.7833333333333, 1.3625, 0.45
7283, 1.8666666666667, 1.3625, 0.45
7284, 1.95, 1.3625, 0.45
7285, 2.0333333333333, 1.3625, 0.45
7286, 2.1166666666667, 1.3625, 0.45
7287, 1.2833333333333, 1.375, 0.45
7288, 1.3666666666667, 1.375, 0.45
7289, 1.45, 1.375, 0.45
7290, 1.5333333333333, 1.375, 0.45
7291, 1.6166666666667, 1.375, 0.45
7292, 1.7, 1.375, 0.45
7293, 1.7833333333333, 1.375, 0.45
7294, 1.8666666666667, 1.375, 0.45
7295, 1.95, 1.375, 0.45
7296, 2.0333333333333, 1.375, 0.45
7297, 2.1166666666667, 1.375, 0.45
7298, 1.2833333333333, 1.3875, 0.45
7299, 1.3666666666667, 1.3875, 0.45
7300, 1.45, 1.3875, 0.45
7301, 1.5333333333333, 1.3875, 0.45
7302, 1.6166666666667, 1.3875, 0.45
7303, 1.7, 1.3875, 0.45
7304, 1.7833333333333, 1.3875, 0.45
7305, 1.8666666666667, 1.3875, 0.45
7306, 1.95, 1.3875, 0.45
7307, 2.0333333333333, 1.3875, 0.45
7308, 2.1166666666667, 1.3875, 0.45
7309, 1.2833333333333, 1.18, 0.05
7310, 1.2833333333333, 1.06, 0.05
7311, 1.2833333333333, 0.94, 0.05
7312, 1.2833333333333, 0.82, 0.05
7313, 1.2833333333333, 0.7, 0.05
7314, 1.2833333333333, 0.58, 0.05
7315, 1.2833333333333, 0.46, 0.05
7316, 1.2833333333333, 0.34, 0.05
7317, 1.2833333333333, 0.22, 0.05
7318, 1.3666666666667, 1.18, 0.05
7319, 1.3666666666667, 1.06, 0.05
7320, 1.3666666666667, 0.94, 0.05
7321, 1.3666666666667, 0.82, 0.05
7322, 1.3666666666667, 0.7, 0.05
7323, 1.3666666666667, 0.58, 0.05
7324, 1.3666666666667, 0.46, 0.05
7325, 1.3666666666667, 0.34, 0.05
7326, 1.3666666666667, 0.22, 0.05
7327, 1.45, 1.18, 0.05
7328, 1.45, 1.06, 0.05
7329, 1.45, 0.94, 0.05
7330, 1.45, 0.82, 0.05
7331, 1.45, 0.7, 0.05
7332, 1.45, 0.58, 0.05
7333, 1.45, 0.46, 0.05
7334, 1.45, 0.34, 0.05
7335, 1.45, 0.22, 0.05
7336, 1.5333333333333, 1.18, 0.05
7337, 1.5333333333333, 1.06, 0.05
7338, 1.5333333333333, 0.94, 0.05
7339, 1.5333333333333, 0.82, 0.05
7340, 1.5333333333333, 0.7, 0.05
7341, 1.5333333333333, 0.58, 0.05
7342, 1.5333333333333, 0.46, 0.05
7343, 1.5333333333333, 0.34, 0.05
7344, 1.5333333333333, 0.22, 0.05
7345, 1.6166666666667, 1.18, 0.05
7346, 1.6166666666667, 1.06, 0.05
7347, 1.6166666666667, 0.94, 0.05
7348, 1.6166666666667, 0.82, 0.05
7349, 1.6166666666667, 0.7, 0.05
7350, 1.6166666666667, 0.58, 0.05
7351, 1.6166666666667, 0.46, 0.05
7352, 1.6166666666667, 0.34, 0.05
7353, 1.6166666666667, 0.22, 0.05
7354, 1.7, 1.18, 0.05
7355, 1.7, 1.06, 0.05
7356, 1.7, 0.94, 0.05
7357, 1.7, 0.82, 0.05
7358, 1.7, 0.7, 0.05
7359, 1.7, 0.58, 0.05
7360, 1.7, 0.46, 0.05
7361, 1.7, 0.34, 0.05
7362, 1.7, 0.22, 0.05
7363, 1.7833333333333, 1.18, 0.05
7364, 1.7833333333333, 1.06, 0.05
7365, 1.7833333333333, 0.94, 0.05
7366, 1.7833333333333, 0.82, 0.05
7367, 1.7833333333333, 0.7, 0.05
7368, 1.7833333333333, 0.58, 0.05
7369, 1.7833333333333, 0.46, 0.05
7370, 1.7833333333333, 0.34, 0.05
7371, 1.7833333333333, 0.22, 0.05
7372, 1.8666666666667, 1.18, 0.05
7373, 1.8666666666667, 1.06, 0.05
7374, 1.8666666666667, 0.94, 0.05
7375, 1.8666666666667, 0.82, 0.05
7376, 1.8666666666667, 0.7, 0.05
7377, 1.8666666666667, 0.58, 0.05
7378, 1.8666666666667, 0.46, 0.05
7379, 1.8666666666667, 0.34, 0.05
7380, 1.8666666666667, 0.22, 0.05
7381, 1.95, 1.18, 0.05
7382, 1.95, 1.06, 0.05
7383, 1.95, 0.94, 0.05
7384, 1.95, 0.82, 0.05
7385, 1.95, 0.7, 0.05
7386, 1.95, 0.58, 0.05
7387, 1.95, 0.46, 0.05
7388, 1.95, 0.34, 0.05
7389, 1.95, 0.22, 0.05
7390, 2.0333333333333, 1.18, 0.05
7391, 2.0333333333333, 1.06, 0.05
7392, 2.0333333333333, 0.94, 0.05
7393, 2.0333333333333, 0.82, 0.05
7394, 2.0333333333333, 0.7, 0.05
7395, 2.0333333333333, 0.58, 0.05
7396, 2.0333333333333, 0.46, 0.05
7397, 2.0333333333333, 0.34, 0.05
7398, 2.0333333333333, 0.22, 0.05
7399, 2.1166666666667, 1.18, 0.05
7400, 2.1166666666667, 1.06, 0.05
7401, 2.1166666666667, 0.94, 0.05
7402, 2.1166666666667, 0.82, 0.05
7403, 2.1166666666667, 0.7, 0.05
7404, 2.1166666666667, 0.58, 0.05
7405, 2.1166666666667, 0.46, 0.05
7406, 2.1166666666667, 0.34, 0.05
7407, 2.1166666666667, 0.22, 0.05
7408, 1.2833333333333, 1.18, 0.1
7409, 1.2833333333333, 1.06, 0.1
7410, 1.2833333333333, 0.94, 0.1
7411, 1.2833333333333, 0.82, 0.1
7412, 1.2833333333333, 0.7, 0.1
7413, 1.2833333333333, 0.58, 0.1
7414, 1.2833333333333, 0.46, 0.1
7415, 1.2833333333333, 0.34, 0.1
7416, 1.2833333333333, 0.22, 0.1
7417, 1.3666666666667, 1.18, 0.1
7418, 1.3666666666667, 1.06, 0.1
7419, 1.3666666666667, 0.94, 0.1
7420, 1.3666666666667, 0.82, 0.1
7421, 1.3666666666667, 0.7, 0.1
7422, 1.3666666666667, 0.58, 0.1
7423, 1.3666666666667, 0.46, 0.1
7424, 1.3666666666667, 0.34, 0.1
7425, 1.3666666666667, 0.22, 0.1
7426, 1.45, 1.18, 0.1
7427, 1.45, 1.06, 0.1
7428, 1.45, 0.94, 0.1
7429, 1.45, 0.82, 0.1
7430, 1.45, 0.7, 0.1
7431, 1.45, 0.58, 0.1
7432, 1.45, 0.46, 0.1
7433, 1.45, 0.34, 0.1
7434, 1.45, 0.22, 0.1
7435, 1.5333333333333, 1.18, 0.1
7436, 1.5333333333333, 1.06, 0.1
7437, 1.5333333333333, 0.94, 0.1
7438, 1.5333333333333, 0.82, 0.1
7439, 1.5333333333333, 0.7, 0.1
7440, 1.5333333333333, 0.58, 0.1
7441, 1.5333333333333, 0.46, 0.1
7442, 1.5333333333333, 0.34, 0.1
7443, 1.5333333333333, 0.22, 0.1
7444, 1.6166666666667, 1.18, 0.1
7445, 1.6166666666667, 1.06, 0.1
7446, 1.6166666666667, 0.94, 0.1
7447, 1.6166666666667, 0.82, 0.1
7448, 1.6166666666667, 0.7, 0.1
7449, 1.6166666666667, 0.58, 0.1
7450, 1.6166666666667, 0.46, 0.1
7451, 1.6166666666667, 0.34, 0.1
7452, 1.6166666666667, 0.22, 0.1
7453, 1.7, 1.18, 0.1
7454, 1.7, 1.06, 0.1
7455, 1.7, 0.94, 0.1
7456, 1.7, 0.82, 0.1
7457, 1.7, 0.7, 0.1
7458, 1.7, 0.58, 0.1
7459, 1.7, 0.46, 0.1
7460, 1.7, 0.34, 0.1
7461, 1.7, 0.22, 0.1
7462, 1.7833333333333, 1.18, 0.1
7463, 1.7833333333333, 1.06, 0.1
7464, 1.7833333333333, 0.94, 0.1
7465, 1.7833333333333, 0.82, 0.1
7466, 1.7833333333333, 0.7, 0.1
7467, 1.7833333333333, 0.58, 0.1
7468, 1.7833333333333, 0.46, 0.1
7469, 1.7833333333333, 0.34, 0.1
7470, 1.7833333333333, 0.22, 0.1
7471, 1.8666666666667, 1.18, 0.1
7472, 1.8666666666667, 1.06, 0.1
7473, 1.8666666666667, 0.94, 0.1
7474, 1.8666666666667, 0.82, 0.1
7475, 1.8666666666667, 0.7, 0.1
7476, 1.8666666666667, 0.58, 0.1
7477, 1.8666666666667, 0.46, 0.1
7478, 1.8666666666667, 0.34, 0.1
7479, 1.8666666666667, 0.22, 0.1
7480, 1.95, 1.18, 0.1
7481, 1.95, 1.06, 0.1
7482, 1.95, 0.94, 0.1
7483, 1.95, 0.82, 0.1
7484, 1.95, 0.7, 0.1
7485, 1.95, 0.58, 0.1
7486, 1.95, 0.46, 0.1
7487, 1.95, 0.34, 0.1
7488, 1.95, 0.22, 0.1
7489, 2.0333333333333, 1.18, 0.1
7490, 2.0333333333333, 1.06, 0.1
7491, 2.0333333333333, 0.94, 0.1
7492, 2.0333333333333, 0.82, 0.1
7493, 2.0333333333333, 0.7, 0.1
7494, 2.0333333333333, 0.58, 0.1
7495, 2.0333333333333, 0.46, 0.1
7496, 2.0333333333333, 0.34, 0.1
7497, 2.0333333333333, 0.22, 0.1
7498, 2.1166666666667, 1.18, 0.1
7499, 2.1166666666667, 1.06, 0.1
7500, 2.1166666666667, 0.94, 0.1
7501, 2.1166666666667, 0.82, 0.1
7502, 2.1166666666667, 0.7, 0.1
7503, 2.1166666666667, 0.58, 0.1
7504, 2.1166666666667, 0.46, 0.1
7505, 2.1166666666667, 0.34, 0.1
7506, 2.1166666666667, 0.22, 0.1
7507, 1.2833333333333, 1.18, 0.15
7508, 1.2833333333333, 1.06, 0.15
7509, 1.2833333333333, 0.94, 0.15
7510, 1.2833333333333, 0.82, 0.15
7511, 1.2833333333333, 0.7, 0.15
7512, 1.2833333333333, 0.58, 0.15
7513, 1.2833333333333, 0.46, 0.15
7514, 1.2833333333333, 0.34, 0.15
7515, 1.2833333333333, 0.22, 0.15
7516, 1.3666666666667, 1.18, 0.15
7517, 1.3666666666667, 1.06, 0.15
7518, 1.3666666666667, 0.94, 0.15
7519, 1.3666666666667, 0.82, 0.15
7520, 1.3666666666667, 0.7, 0.15
7521, 1.3666666666667, 0.58, 0.15
7522, 1.3666666666667, 0.46, 0.15
7523, 1.3666666666667, 0.34, 0.15
7524, 1.3666666666667, 0.22, 0.15
7525, 1.45, 1.18, 0.15
7526, 1.45, 1.06, 0.15
7527, 1.45, 0.94, 0.15
7528, 1.45, 0.82, 0.15
7529, 1.45, 0.7, 0.15
7530, 1.45, 0.58, 0.15
7531, 1.45, 0.46, 0.15
7532, 1.45, 0.34, 0.15
7533, 1.45, 0.22, 0.15
7534, 1.5333333333333, 1.18, 0.15
7535, 1.5333333333333, 1.06, 0.15
7536, 1.5333333333333, 0.94, 0.15
7537, 1.5333333333333, 0.82, 0.15
7538, 1.5333333333333, 0.7, 0.15
7539, 1.5333333333333, 0.58, 0.15
7540, 1.5333333333333, 0.46, 0.15
7541, 1.5333333333333, 0.34, 0.15
7542, 1.5333333333333, 0.22, 0.15
7543, 1.6166666666667, 1.18, 0.15
7544, 1.6166666666667, 1.06, 0.15
7545, 1.6166666666667, 0.94, 0.15
7546, 1.6166666666667, 0.82, 0.15
7547, 1.6166666666667, 0.7, 0.15
7548, 1.6166666666667, 0.58, 0.15
7549, 1.6166666666667, 0.46, 0.15
7550, 1.6166666666667, 0.34, 0.15
7551, 1.6166666666667, 0.22, 0.15
7552, 1.7, 1.18, 0.15
7553, 1.7, 1.06, 0.15
7554, 1.7, 0.94, 0.15
7555, 1.7, 0.82, 0.15
7556, 1.7, 0.7, 0.15
7557, 1.7, 0.58, 0.15
7558, 1.7, 0.46, 0.15
7559, 1.7, 0.34, 0.15
7560, 1.7, 0.22, 0.15
7561, 1.7833333333333, 1.18, 0.15
7562, 1.7833333333333, 1.06, 0.15
7563, 1.7833333333333, 0.94, 0.15
7564, 1.7833333333333, 0.82, 0.15
7565, 1.7833333333333, 0.7, 0.15
7566, 1.7833333333333, 0.58, 0.15
7567, 1.7833333333333, 0.46, 0.15
7568, 1.7833333333333, 0.34, 0.15
7569, 1.7833333333333, 0.22, 0.15
7570, 1.8666666666667, 1.18, 0.15
7571, 1.8666666666667, 1.06, 0.15
7572, 1.8666666666667, 0.94, 0.15
7573, 1.8666666666667, 0.82, 0.15
7574, 1.8666666666667, 0.7, 0.15
7575, 1.8666666666667, 0.58, 0.15
7576, 1.8666666666667, 0.46, 0.15
7577, 1.8666666666667, 0.34, 0.15
7578, 1.8666666666667, 0.22, 0.15
7579, 1.95, 1.18, 0.15
7580, 1.95, 1.06, 0.15
7581, 1.95, 0.94, 0.15
7582, 1.95, 0.82, 0.15
7583, 1.95, 0.7, 0.15
7584, 1.95, 0.58, 0.15
7585, 1.95, 0.46, 0.15
7586, 1.95, 0.34, 0.15
7587, 1.95, 0.22, 0.15
7588, 2.0333333333333, 1.18, 0.15
7589, 2.0333333333333, 1.06, 0.15
7590, 2.0333333333333, 0.94, 0.15
7591, 2.0333333333333, 0.82, 0.15
7592, 2.0333333333333, 0.7, 0.15
7593, 2.0333333333333, 0.58, 0.15
7594, 2.0333333333333, 0.46, 0.15
7595, 2.0333333333333, 0.34, 0.15
7596, 2.0333333333333, 0.22, 0.15
7597, 2.1166666666667, 1.18, 0.15
7598, 2.1166666666667, 1.06, 0.15
7599, 2.1166666666667, 0.94, 0.15
7600, 2.1166666666667, 0.82, 0.15
7601, 2.1166666666667, 0.7, 0.15
7602, 2.1166666666667, 0.58, 0.15
7603, 2.1166666666667, 0.46, 0.15
7604, 2.1166666666667, 0.34, 0.15
7605, 2.1166666666667, 0.22, 0.15
7606, 1.2833333333333, 1.18, 0.2
7607, 1.2833333333333, 1.06, 0.2
7608, 1.2833333333333, 0.94, 0.2
7609, 1.2833333333333, 0.82, 0.2
7610, 1.2833333333333, 0.7, 0.2
7611, 1.2833333333333, 0.58, 0.2
7612, 1.2833333333333, 0.46, 0.2
7613, 1.2833333333333, 0.34, 0.2
7614, 1.2833333333333, 0.22, 0.2
7615, 1.3666666666667, 1.18, 0.2
7616, 1.3666666666667, 1.06, 0.2
7617, 1.3666666666667, 0.94, 0.2
7618, 1.3666666666667, 0.82, 0.2
7619, 1.3666666666667, 0.7, 0.2
7620, 1.3666666666667, 0.58, 0.2
7621, 1.3666666666667, 0.46, 0.2
7622, 1.3666666666667, 0.34, 0.2
7623, 1.3666666666667, 0.22, 0.2
7624, 1.45, 1.18, 0.2
7625, 1.45, 1.06, 0.2
7626, 1.45, 0.94, 0.2
7627, 1.45, 0.82, 0.2
7628, 1.45, 0.7, 0.2
7629, 1.45, 0.58, 0.2
7630, 1.45, 0.46, 0.2
7631, 1.45, 0.34, 0.2
7632, 1.45, 0.22, 0.2
7633, 1.5333333333333, 1.18, 0.2
7634, 1.5333333333333, 1.06, 0.2
7635, 1.5333333333333, 0.94, 0.2
7636, 1.5333333333333, 0.82, 0.2
7637, 1.5333333333333, 0.7, 0.2
7638, 1.5333333333333, 0.58, 0.2
7639, 1.5333333333333, 0.46, 0.2
7640, 1.5333333333333, 0.34, 0.2
7641, 1.5333333333333, 0.22, 0.2
7642, 1.6166666666667, 1.18, 0.2
7643, 1.6166666666667, 1.06, 0.2
7644, 1.6166666666667, 0.94, 0.2
7645, 1.6166666666667, 0.82, 0.2
7646, 1.6166666666667, 0.7, 0.2
7647, 1.6166666666667, 0.58, 0.2
7648, 1.6166666666667, 0.46, 0.2
7649, 1.6166666666667, 0.34, 0.2
7650, 1.6166666666667, 0.22, 0.2
7651, 1.7, 1.18, 0.2
7652, 1.7, 1.06, 0.2
7653, 1.7, 0.94, 0.2
7654, 1.7, 0.82, 0.2
7655, 1.7, 0.7, 0.2
7656, 1.7, 0.58, 0.2
7657, 1.7, 0.46, 0.2
7658, 1.7, 0.34, 0.2
7659, 1.7, 0.22, 0.2
7660, 1.7833333333333, 1.18, 0.2
7661, 1.7833333333333, 1.06, 0.2
7662, 1.7833333333333, 0.94, 0.2
7663, 1.7833333333333, 0.82, 0.2
7664, 1.7833333333333, 0.7, 0.2
7665, 1.7833333333333, 0.58, 0.2
7666, 1.7833333333333, 0.46, 0.2
7667, 1.7833333333333, 0.34, 0.2
7668, 1.7833333333333, 0.22, 0.2
7669, 1.8666666666667, 1.18, 0.2
7670, 1.8666666666667, 1.06, 0.2
7671, 1.8666666666667, 0.94, 0.2
7672, 1.8666666666667, 0.82, 0.2
7673, 1.8666666666667, 0.7, 0.2
7674, 1.8666666666667, 0.58, 0.2
7675, 1.8666666666667, 0.46, 0.2
7676, 1.8666666666667, 0.34, 0.2
7677, 1.8666666666667, 0.22, 0.2
7678, 1.95, 1.18, 0.2
7679, 1.95, 1.06, 0.2
7680, 1.95, 0.94, 0.2
7681, 1.95, 0.82, 0.2
7682, 1.95, 0.7, 0.2
7683, 1.95, 0.58, 0.2
7684, 1.95, 0.46, 0.2
7685, 1.95, 0.34, 0.2
7686, 1.95, 0.22, 0.2
7687, 2.0333333333333, 1.18, 0.2
7688, 2.0333333333333, 1.06, 0.2
7689, 2.0333333333333, 0.94, 0.2
7690, 2.0333333333333, 0.82, 0.2
7691, 2.0333333333333, 0.7, 0.2
7692, 2.0333333333333, 0.58, 0.2
7693, 2.0333333333333, 0.46, 0.2
7694, 2.0333333333333, 0.34, 0.2
7695, 2.0333333333333, 0.22, 0.2
7696, 2.1166666666667, 1.18, 0.2
7697, 2.1166666666667, 1.06, 0.2
7698, 2.1166666666667, 0.94, 0.2
7699, 2.1166666666667, 0.82, 0.2
7700, 2.1166666666667, 0.7, 0.2
7701, 2.1166666666667, 0.58, 0.2
7702, 2.1166666666667, 0.46, 0.2
7703, 2.1166666666667, 0.34, 0.2
7704, 2.1166666666667, 0.22, 0.2
7705, 1.2833333333333, 1.18, 0.25
7706, 1.2833333333333, 1.06, 0.25
7707, 1.2833333333333, 0.94, 0.25
7708, 1.2833333333333, 0.82, 0.25
7709, 1.2833333333333, 0.7, 0.25
7710, 1.2833333333333, 0.58, 0.25
7711, 1.2833333333333, 0.46, 0.25
7712, 1.2833333333333, 0.34, 0.25
7713, 1.2833333333333, 0.22, 0.25
7714, 1.3666666666667, 1.18, 0.25
7715, 1.3666666666667, 1.06, 0.25
7716, 1.3666666666667, 0.94, 0.25
7717, 1.3666666666667, 0.82, 0.25
7718, 1.3666666666667, 0.7, 0.25
7719, 1.3666666666667, 0.58, 0.25
7720, 1.3666666666667, 0.46, 0.25
7721, 1.3666666666667, 0.34, 0.25
7722, 1.3666666666667, 0.22, 0.25
7723, 1.45, 1.18, 0.25
7724, 1.45, 1.06, 0.25
7725, 1.45, 0.94, 0.25
7726, 1.45, 0.82, 0.25
7727, 1.45, 0.7, 0.25
7728, 1.45, 0.58, 0.25
7729, 1.45, 0.46, 0.25
7730, 1.45, 0.34, 0.25
7731, 1.45, 0.22, 0.25
7732, 1.5333333333333, 1.18, 0.25
7733, 1.5333333333333, 1.06, 0.25
7734, 1.5333333333333, 0.94, 0.25
7735, 1.5333333333333, 0.82, 0.25
7736, 1.5333333333333, 0.7, 0.25
7737, 1.5333333333333, 0.58, 0.25
7738, 1.5333333333333, 0.46, 0.25
7739, 1.5333333333333, 0.34, 0.25
7740, 1.5333333333333, 0.22, 0.25
7741, 1.6166666666667, 1.18, 0.25
7742, 1.6166666666667, 1.06, 0.25
7743, 1.6166666666667, 0.94, 0.25
7744, 1.6166666666667, 0.82, 0.25
7745, 1.6166666666667, 0.7, 0.25
7746, 1.6166666666667, 0.58, 0.25
7747, 1.6166666666667, 0.46, 0.25
7748, 1.6166666666667, 0.34, 0.25
7749, 1.6166666666667, 0.22, 0.25
7750, 1.7, 1.18, 0.25
7751, 1.7, 1.06, 0.25
7752, 1.7, 0.94, 0.25
7753, 1.7, 0.82, 0.25
7754, 1.7, 0.7, 0.25
7755, 1.7, 0.58, 0.25
7756, 1.7, 0.46, 0.25
7757, 1.7, 0.34, 0.25
7758, 1.7, 0.22, 0.25
7759, 1.7833333333333, 1.18, 0.25
7760, 1.7833333333333, 1.06, 0.25
7761, 1.7833333333333, 0.94, 0.25
7762, 1.7833333333333, 0.82, 0.25
7763, 1.7833333333333, 0.7, 0.25
7764, 1.7833333333333, 0.58, 0.25
7765, 1.7833333333333, 0.46, 0.25
7766, 1.7833333333333, 0.34, 0.25
7767, 1.7833333333333, 0.22, 0.25
7768, 1.8666666666667, 1.18, 0.25
7769, 1.8666666666667, 1.06, 0.25
7770, 1.8666666666667, 0.94, 0.25
7771, 1.8666666666667, 0.82, 0.25
7772, 1.8666666666667, 0.7, 0.25
7773, 1.8666666666667, 0.58, 0.25
7774, 1.8666666666667, 0.46, 0.25
7775, 1.8666666666667, 0.34, 0.25
7776, 1.8666666666667, 0.22, 0.25
7777, 1.95, 1.18, 0.25
7778, 1.95, 1.06, 0.25
7779, 1.95, 0.94, 0.25
7780, 1.95, 0.82, 0.25
7781, 1.95, 0.7, 0.25
7782, 1.95, 0.58, 0.25
7783, 1.95, 0.46, 0.25
7784, 1.95, 0.34, 0.25
7785, 1.95, 0.22, 0.25
7786, 2.0333333333333, 1.18, 0.25
7787, 2.0333333333333, 1.06, 0.25
7788, 2.0333333333333, 0.94, 0.25
7789, 2.0333333333333, 0.82, 0.25
7790, 2.0333333333333, 0.7, 0.25
7791, 2.0333333333333, 0.58, 0.25
7792, 2.0333333333333, 0.46, 0.25
7793, 2.0333333333333, 0.34, 0.25
7794, 2.0333333333333, 0.22, 0.25
7795, 2.1166666666667, 1.18, 0.25
7796, 2.1166666666667, 1.06, 0.25
7797, 2.1166666666667, 0.94, 0.25
7798, 2.1166666666667, 0.82, 0.25
7799, 2.1166666666667, 0.7, 0.25
7800, 2.1166666666667, 0.58, 0.25
7801, 2.1166666666667, 0.46, 0.25
7802, 2.1166666666667, 0.34, 0.25
7803, 2.1166666666667, 0.22, 0.25
7804, 1.2833333333333, 1.18, 0.3
7805, 1.2833333333333, 1.06, 0.3
7806, 1.2833333333333, 0.94, 0.3
7807, 1.2833333333333, 0.82, 0.3
7808, 1.2833333333333, 0.7, 0.3
7809, 1.2833333333333, 0.58, 0.3
7810, 1.2833333333333, 0.46, 0.3
7811, 1.2833333333333, 0.34, 0.3
7812, 1.2833333333333, 0.22, 0.3
7813, 1.3666666666667, 1.18, 0.3
7814, 1.3666666666667, 1.06, 0.3
7815, 1.3666666666667, 0.94, 0.3
7816, 1.3666666666667, 0.82, 0.3
7817, 1.3666666666667, 0.7, 0.3
7818, 1.3666666666667, 0.58, 0.3
7819, 1.3666666666667, 0.46, 0.3
7820, 1.3666666666667, 0.34, 0.3
7821, 1.3666666666667, 0.22, 0.3
7822, 1.45, 1.18, 0.3
7823, 1.45, 1.06, 0.3
7824, 1.45, 0.94, 0.3
7825, 1.45, 0.82, 0.3
7826, 1.45, 0.7, 0.3
7827, 1.45, 0.58, 0.3
7828, 1.45, 0.46, 0.3
7829, 1.45, 0.34, 0.3
7830, 1.45, 0.22, 0.3
7831, 1.5333333333333, 1.18, 0.3
7832, 1.5333333333333, 1.06, 0.3
7833, 1.5333333333333, 0.94, 0.3
7834, 1.5333333333333, 0.82, 0.3
7835, 1.5333333333333, 0.7, 0.3
7836, 1.5333333333333, 0.58, 0.3
7837, 1.5333333333333, 0.46, 0.3
7838, 1.5333333333333, 0.34, 0.3
7839, 1.5333333333333, 0.22, 0.3
7840, 1.6166666666667, 1.18, 0.3
7841, 1.6166666666667, 1.06, 0.3
7842, 1.6166666666667, 0.94, 0.3
7843, 1.6166666666667, 0.82, 0.3
7844, 1.6166666666667, 0.7, 0.3
7845, 1.6166666666667, 0.58, 0.3
7846, 1.6166666666667, 0.46, 0.3
7847, 1.6166666666667, 0.34, 0.3
7848, 1.6166666666667, 0.22, 0.3
7849, 1.7, 1.18, 0.3
7850, 1.7, 1.06, 0.3
7851, 1.7, 0.94, 0.3
7852, 1.7, 0.82, 0.3
7853, 1.7, 0.7, 0.3
7854, 1.7, 0.58, 0.3
7855, 1.7, 0.46, 0.3
7856, 1.7, 0.34, 0.3
7857, 1.7, 0.22, 0.3
7858, 1.7833333333333, 1.18, 0.3
7859, 1.7833333333333, 1.06, 0.3
7860, 1.7833333333333, 0.94, 0.3
7861, 1.7833333333333, 0.82, 0.3
7862, 1.7833333333333, 0.7, 0.3
7863, 1.7833333333333, 0.58, 0.3
7864, 1.7833333333333, 0.46, 0.3
7865, 1.7833333333333, 0.34, 0.3
7866, 1.7833333333333, 0.22, 0.3
7867, 1.8666666666667, 1.18, 0.3
7868, 1.8666666666667, 1.06, 0.3
7869, 1.8666666666667, 0.94, 0.3
7870, 1.8666666666667, 0.82, 0.3
7871, 1.8666666666667, 0.7, 0.3
7872, 1.8666666666667, 0.58, 0.3
7873, 1.8666666666667, 0.46, 0.3
7874, 1.8666666666667, 0.34, 0.3
7875, 1.8666666666667, 0.22, 0.3
7876, 1.95, 1.18, 0.3
7877, 1.95, 1.06, 0.3
7878, 1.95, 0.94, 0.3
7879, 1.95, 0.82, 0.3
7880, 1.95, 0.7, 0.3
7881, 1.95, 0.58, 0.3
7882, 1.95, 0.46, 0.3
7883, 1.95, 0.34, 0.3
7884, 1.95, 0.22, 0.3
7885, 2.0333333333333, 1.18, 0.3
7886, 2.0333333333333, 1.06, 0.3
7887, 2.0333333333333, 0.94, 0.3
7888, 2.0333333333333, 0.82, 0.3
7889, 2.0333333333333, 0.7, 0.3
7890, 2.0333333333333, 0.58, 0.3
7891, 2.0333333333333, 0.46, 0.3
7892, 2.0333333333333, 0.34, 0.3
7893, 2.0333333333333, 0.22, 0.3
7894, 2.1166666666667, 1.18, 0.3
7895, 2.1166666666667, 1.06, 0.3
7896, 2.1166666666667, 0.94, 0.3
7897, 2.1166666666667, 0.82, 0.3
7898, 2.1166666666667, 0.7, 0.3
7899, 2.1166666666667, 0.58, 0.3
7900, 2.1166666666667, 0.46, 0.3
7901, 2.1166666666667, 0.34, 0.3
7902, 2.1166666666667, 0.22, 0.3
7903, 1.2833333333333, 1.18, 0.35
7904, 1.2833333333333, 1.06, 0.35
7905, 1.2833333333333, 0.94, 0.35
7906, 1.2833333333333, 0.82, 0.35
7907, 1.2833333333333, 0.7, 0.35
7908, 1.2833333333333, 0.58, 0.35
7909, 1.2833333333333, 0.46, 0.35
7910, 1.2833333333333, 0.34, 0.35
7911, 1.2833333333333, 0.22, 0.35
7912, 1.3666666666667, 1.18, 0.35
7913, 1.3666666666667, 1.06, 0.35
7914, 1.3666666666667, 0.94, 0.35
7915, 1.3666666666667, 0.82, 0.35
7916, 1.3666666666667, 0.7, 0.35
7917, 1.3666666666667, 0.58, 0.35
7918, 1.3666666666667, 0.46, 0.35
7919, 1.3666666666667, 0.34, 0.35
7920, 1.3666666666667, 0.22, 0.35
7921, 1.45, 1.18, 0.35
7922, 1.45, 1.06, 0.35
7923, 1.45, 0.94, 0.35
7924, 1.45, 0.82, 0.35
7925, 1.45, 0.7, 0.35
7926, 1.45, 0.58, 0.35
7927, 1.45, 0.46, 0.35
7928, 1.45, 0.34, 0.35
7929, 1.45, 0.22, 0.35
7930, 1.5333333333333, 1.18, 0.35
7931, 1.5333333333333, 1.06, 0.35
7932, 1.5333333333333, 0.94, 0.35
7933, 1.5333333333333, 0.82, 0.35
7934, 1.5333333333333, 0.7, 0.35
7935, 1.5333333333333, 0.58, 0.35
7936, 1.5333333333333, 0.46, 0.35
7937, 1.5333333333333, 0.34, 0.35
7938, 1.5333333333333, 0.22, 0.35
7939, 1.6166666666667, 1.18, 0.35
7940, 1.6166666666667, 1.06, 0.35
7941, 1.6166666666667, 0.94, 0.35
7942, 1.6166666666667, 0.82, 0.35
7943, 1.6166666666667, 0.7, 0.35
7944, 1.6166666666667, 0.58, 0.35
7945, 1.6166666666667, 0.46, 0.35
7946, 1.6166666666667, 0.34, 0.35
7947, 1.6166666666667, 0.22, 0.35
7948, 1.7, 1.18, 0.35
7949, 1.7, 1.06, 0.35
7950, 1.7, 0.94, 0.35
7951, 1.7, 0.82, 0.35
7952, 1.7, 0.7, 0.35
7953, 1.7, 0.58, 0.35
7954, 1.7, 0.46, 0.35
7955, 1.7, 0.34, 0.35
7956, 1.7, 0.22, 0.35
7957, 1.7833333333333, 1.18, 0.35
7958, 1.7833333333333, 1.06, 0.35
7959, 1.7833333333333, 0.94, 0.35
7960, 1.7833333333333, 0.82, 0.35
7961, 1.7833333333333, 0.7, 0.35
7962, 1.7833333333333, 0.58, 0.35
7963, 1.7833333333333, 0.46, 0.35
7964, 1.7833333333333, 0.34, 0.35
7965, 1.7833333333333, 0.22, 0.35
7966, 1.8666666666667, 1.18, 0.35
7967, 1.8666666666667, 1.06, 0.35
7968, 1.8666666666667, 0.94, 0.35
7969, 1.8666666666667, 0.82, 0.35
7970, 1.8666666666667, 0.7, 0.35
7971, 1.8666666666667, 0.58, 0.35
7972, 1.8666666666667, 0.46, 0.35
7973, 1.8666666666667, 0.34, 0.35
7974, 1.8666666666667, 0.22, 0.35
7975, 1.95, 1.18, 0.35
7976, 1.95, 1.06, 0.35
7977, 1.95, 0.94, 0.35
7978, 1.95, 0.82, 0.35
7979, 1.95, 0.7, 0.35
7980, 1.95, 0.58, 0.35
7981, 1.95, 0.46, 0.35
7982, 1.95, 0.34, 0.35
7983, 1.95, 0.22, 0.35
7984, 2.0333333333333, 1.18, 0.35
7985, 2.0333333333333, 1.06, 0.35
7986, 2.0333333333333, 0.94, 0.35
7987, 2.0333333333333, 0.82, 0.35
7988, 2.0333333333333, 0.7, 0.35
7989, 2.0333333333333, 0.58, 0.35
7990, 2.0333333333333, 0.46, 0.35
7991, 2.0333333333333, 0.34, 0.35
7992, 2.0333333333333, 0.22, 0.35
7993, 2.1166666666667, 1.18, 0.35
7994, 2.1166666666667, 1.06, 0.35
7995, 2.1166666666667, 0.94, 0.35
7996, 2.1166666666667, 0.82, 0.35
7997, 2.1166666666667, 0.7, 0.35
7998, 2.1166666666667, 0.58, 0.35
7999, 2.1166666666667, 0.46, 0.35
8000, 2.1166666666667, 0.34, 0.35
8001, 2.1166666666667, 0.22, 0.35
8002, 1.2833333333333, 1.18, 0.4
8003, 1.2833333333333, 1.06, 0.4
8004, 1.2833333333333, 0.94, 0.4
8005, 1.2833333333333, 0.82, 0.4
8006, 1.2833333333333, 0.7, 0.4
8007, 1.2833333333333, 0.58, 0.4
8008, 1.2833333333333, 0.46, 0.4
8009, 1.2833333333333, 0.34, 0.4
8010, 1.2833333333333, 0.22, 0.4
8011, 1.3666666666667, 1.18, 0.4
8012, 1.3666666666667, 1.06, 0.4
8013, 1.3666666666667, 0.94, 0.4
8014, 1.3666666666667, 0.82, 0.4
8015, 1.3666666666667, 0.7, 0.4
8016, 1.3666666666667, 0.58, 0.4
8017, 1.3666666666667, 0.46, 0.4
8018, 1.3666666666667, 0.34, 0.4
8019, 1.3666666666667, 0.22, 0.4
8020, 1.45, 1.18, 0.4
8021, 1.45, 1.06, 0.4
8022, 1.45, 0.94, 0.4
8023, 1.45, 0.82, 0.4
8024, 1.45, 0.7, 0.4
8025, 1.45, 0.58, 0.4
8026, 1.45, 0.46, 0.4
8027, 1.45, 0.34, 0.4
8028, 1.45, 0.22, 0.4
8029, 1.5333333333333, 1.18, 0.4
8030, 1.5333333333333, 1.06, 0.4
8031, 1.5333333333333, 0.94, 0.4
8032, 1.5333333333333, 0.82, 0.4
8033, 1.5333333333333, 0.7, 0.4
8034, 1.5333333333333, 0.58, 0.4
8035, 1.5333333333333, 0.46, 0.4
8036, 1.5333333333333, 0.34, 0.4
8037, 1.5333333333333, 0.22, 0.4
8038, 1.6166666666667, 1.18, 0.4
8039, 1.6166666666667, 1.06, 0.4
8040, 1.6166666666667, 0.94, 0.4
8041, 1.6166666666667, 0.82, 0.4
8042, 1.6166666666667, 0.7, 0.4
8043, 1.6166666666667, 0.58, 0.4
8044, 1.6166666666667, 0.46, 0.4
8045, 1.6166666666667, 0.34, 0.4
8046, 1.6166666666667, 0.22, 0.4
8047, 1.7, 1.18, 0.4
8048, 1.7, 1.06, 0.4
8049, 1.7, 0.94, 0.4
8050, 1.7, 0.82, 0.4
8051, 1.7, 0.7, 0.4
8052, 1.7, 0.58, 0.4
8053, 1.7, 0.46, 0.4
8054, 1.7, 0.34, 0.4
8055, 1.7, 0.22, 0.4
8056, 1.7833333333333, 1.18, 0.4
8057, 1.7833333333333, 1.06, 0.4
8058, 1.7833333333333, 0.94, 0.4
8059, 1.7833333333333, 0.82, 0.4
8060, 1.7833333333333, 0.7, 0.4
8061, 1.7833333333333, 0.58, 0.4
8062, 1.7833333333333, 0.46, 0.4
8063, 1.7833333333333, 0.34, 0.4
8064, 1.7833333333333, 0.22, 0.4
8065, 1.8666666666667, 1.18, 0.4
8066, 1.8666666666667, 1.06, 0.4
8067, 1.8666666666667, 0.94, 0.4
8068, 1.8666666666667, 0.82, 0.4
8069, 1.8666666666667, 0.7, 0.4
8070, 1.8666666666667, 0.58, 0.4
8071, 1.8666666666667, 0.46, 0.4
8072, 1.8666666666667, 0.34, 0.4
8073, 1.8666666666667, 0.22, 0.4
8074, 1.95, 1.18, 0.4
8075, 1.95, 1.06, 0.4
8076, 1.95, 0.94, 0.4
8077, 1.95, 0.82, 0.4
8078, 1.95, 0.7, 0.4
8079, 1.95, 0.58, 0.4
8080, 1.95, 0.46, 0.4
8081, 1.95, 0.34, 0.4
8082, 1.95, 0.22, 0.4
8083, 2.0333333333333, 1.18, 0.4
8084, 2.0333333333333, 1.06, 0.4
8085, 2.0333333333333, 0.94, 0.4
8086, 2.0333333333333, 0.82, 0.4
8087, 2.0333333333333, 0.7, 0.4
8088, 2.0333333333333, 0.58, 0.4
8089, 2.0333333333333, 0.46, 0.4
8090, 2.0333333333333, 0.34, 0.4
8091, 2.0333333333333, 0.22, 0.4
8092, 2.1166666666667, 1.18, 0.4
8093, 2.1166666666667, 1.06, 0.4
8094, 2.1166666666667, 0.94, 0.4
8095, 2.1166666666667, 0.82, 0.4
8096, 2.1166666666667, 0.7, 0.4
8097, 2.1166666666667, 0.58, 0.4
8098, 2.1166666666667, 0.46, 0.4
8099, 2.1166666666667, 0.34, 0.4
8100, 2.1166666666667, 0.22, 0.4
8101, 1.2833333333333, 1.18, 0.45
8102, 1.2833333333333, 1.06, 0.45
8103, 1.2833333333333, 0.94, 0.45
8104, 1.2833333333333, 0.82, 0.45
8105, 1.2833333333333, 0.7, 0.45
8106, 1.2833333333333, 0.58, 0.45
8107, 1.2833333333333, 0.46, 0.45
8108, 1.2833333333333, 0.34, 0.45
8109, 1.2833333333333, 0.22, 0.45
8110, 1.3666666666667, 1.18, 0.45
8111, 1.3666666666667, 1.06, 0.45
8112, 1.3666666666667, 0.94, 0.45
8113, 1.3666666666667, 0.82, 0.45
8114, 1.3666666666667, 0.7, 0.45
8115, 1.3666666666667, 0.58, 0.45
8116, 1.3666666666667, 0.46, 0.45
8117, 1.3666666666667, 0.34, 0.45
8118, 1.3666666666667, 0.22, 0.45
8119, 1.45, 1.18, 0.45
8120, 1.45, 1.06, 0.45
8121, 1.45, 0.94, 0.45
8122, 1.45, 0.82, 0.45
8123, 1.45, 0.7, 0.45
8124, 1.45, 0.58, 0.45
8125, 1.45, 0.46, 0.45
8126, 1.45, 0.34, 0.45
8127, 1.45, 0.22, 0.45
8128, 1.5333333333333, 1.18, 0.45
8129, 1.5333333333333, 1.06, 0.45
8130, 1.5333333333333, 0.94, 0.45
8131, 1.5333333333333, 0.82, 0.45
8132, 1.5333333333333, 0.7, 0.45
8133, 1.5333333333333, 0.58, 0.45
8134, 1.5333333333333, 0.46, 0.45
8135, 1.5333333333333, 0.34, 0.45
8136, 1.5333333333333, 0.22, 0.45
8137, 1.6166666666667, 1.18, 0.45
8138, 1.6166666666667, 1.06, 0.45
8139, 1.6166666666667, 0.94, 0.45
8140, 1.6166666666667, 0.82, 0.45
8141, 1.6166666666667, 0.7, 0.45
8142, 1.6166666666667, 0.58, 0.45
8143, 1.6166666666667, 0.46, 0.45
8144, 1.6166666666667, 0.34, 0.45
8145, 1.6166666666667, 0.22, 0.45
8146, 1.7, 1.18, 0.45
8147, 1.7, 1.06, 0.45
8148, 1.7, 0.94, 0.45
8149, 1.7, 0.82, 0.45
8150, 1.7, 0.7, 0.45
8151, 1.7, 0.58, 0.45
8152, 1.7, 0.46, 0.45
8153, 1.7, 0.34, 0.45
8154, 1.7, 0.22, 0.45
8155, 1.7833333333333, 1.18, 0.45
8156, 1.7833333333333, 1.06, 0.45
8157, 1.7833333333333, 0.94, 0.45
8158, 1.7833333333333, 0.82, 0.45
8159, 1.7833333333333, 0.7, 0.45
8160, 1.7833333333333, 0.58, 0.45
8161, 1.7833333333333, 0.46, 0.45
8162, 1.7833333333333, 0.34, 0.45
8163, 1.7833333333333, 0.22, 0.45
8164, 1.8666666666667, 1.18, 0.45
8165, 1.8666666666667, 1.06, 0.45
8166, 1.8666666666667, 0.94, 0.45
8167, 1.8666666666667, 0.82, 0.45
8168, 1.8666666666667, 0.7, 0.45
8169, 1.8666666666667, 0.58, 0.45
8170, 1.8666666666667, 0.46, 0.45
8171, 1.8666666666667, 0.34, 0.45
8172, 1.8666666666667, 0.22, 0.45
8173, 1.95, 1.18, 0.45
8174, 1.95, 1.06, 0.45
8175, 1.95, 0.94, 0.45
8176, 1.95, 0.82, 0.45
8177, 1.95, 0.7, 0.45
8178, 1.95, 0.58, 0.45
8179, 1.95, 0.46, 0.45
8180, 1.95, 0.34, 0.45
8181, 1.95, 0.22, 0.45
8182, 2.0333333333333, 1.18, 0.45
8183, 2.0333333333333, 1.06, 0.45
8184, 2.0333333333333, 0.94, 0.45
8185, 2.0333333333333, 0.82, 0.45
8186, 2.0333333333333, 0.7, 0.45
8187, 2.0333333333333, 0.58, 0.45
8188, 2.0333333333333, 0.46, 0.45
8189, 2.0333333333333, 0.34, 0.45
8190, 2.0333333333333, 0.22, 0.45
8191, 2.1166666666667, 1.18, 0.45
8192, 2.1166666666667, 1.06, 0.45
8193, 2.1166666666667, 0.94, 0.45
8194, 2.1166666666667, 0.82, 0.45
8195, 2.1166666666667, 0.7, 0.45
8196, 2.1166666666667, 0.58, 0.45
8197, 2.1166666666667, 0.46, 0.45
8198, 2.1166666666667, 0.34, 0.45
8199, 2.1166666666667, 0.22, 0.45
8200, 1.2833333333333, 0.0375, 0.05
8201, 1.2833333333333, 0.025, 0.05
8202, 1.2833333333333, 0.0125, 0.05
8203, 1.3666666666667, 0.0375, 0.05
8204, 1.3666666666667, 0.025, 0.05
8205, 1.3666666666667, 0.0125, 0.05
8206, 1.45, 0.0375, 0.05
8207, 1.45, 0.025, 0.05
8208, 1.45, 0.0125, 0.05
8209, 1.5333333333333, 0.0375, 0.05
8210, 1.5333333333333, 0.025, 0.05
8211, 1.5333333333333, 0.0125, 0.05
8212, 1.6166666666667, 0.0375, 0.05
8213, 1.6166666666667, 0.025, 0.05
8214, 1.6166666666667, 0.0125, 0.05
8215, 1.7, 0.0375, 0.05
8216, 1.7, 0.025, 0.05
8217, 1.7, 0.0125, 0.05
8218, 1.7833333333333, 0.0375, 0.05
8219, 1.7833333333333, 0.025, 0.05
8220, 1.7833333333333, 0.0125, 0.05
8221, 1.8666666666667, 0.0375, 0.05
8222, 1.8666666666667, 0.025, 0.05
8223, 1.8666666666667, 0.0125, 0.05
8224, 1.95, 0.0375, 0.05
8225, 1.95, 0.025, 0.05
8226, 1.95, 0.0125, 0.05
8227, 2.0333333333333, 0.0375, 0.05
8228, 2.0333333333333, 0.025, 0.05
8229, 2.0333333333333, 0.0125, 0.05
8230, 2.1166666666667, 0.0375, 0.05
8231, 2.1166666666667, 0.025, 0.05
8232, 2.1166666666667, 0.0125, 0.05
8233, 1.2833333333333, 0.0375, 0.1
8234, 1.2833333333333, 0.025, 0.1
8235, 1.2833333333333, 0.0125, 0.1
8236, 1.3666666666667, 0.0375, 0.1
8237, 1.3666666666667, 0.025, 0.1
8238, 1.3666666666667, 0.0125, 0.1
8239, 1.45, 0.0375, 0.1
8240, 1.45, 0.025, 0.1
8241, 1.45, 0.0125, 0.1
8242, 1.5333333333333, 0.0375, 0.1
8243, 1.5333333333333, 0.025, 0.1
8244, 1.5333333333333, 0.0125, 0.1
8245, 1.6166666666667, 0.0375, 0.1
8246, 1.6166666666667, 0.025, 0.1
8247, 1.6166666666667, 0.0125, 0.1
8248, 1.7, 0.0375, 0.1
8249, 1.7, 0.025, 0.1
8250, 1.7, 0.0125, 0.1
8251, 1.7833333333333, 0.0375, 0.1
8252, 1.7833333333333, 0.025, 0.1
8253, 1.7833333333333, 0.0125, 0.1
8254, 1.8666666666667, 0.0375, 0.1
8255, 1.8666666666667, 0.025, 0.1
8256, 1.8666666666667, 0.0125, 0.1
8257, 1.95, 0.0375, 0.1
8258, 1.95, 0.025, 0.1
8259, 1.95, 0.0125, 0.1
8260, 2.0333333333333, 0.0375, 0.1
8261, 2.0333333333333, 0.025, 0.1
8262, 2.0333333333333, 0.0125, 0.1
8263, 2.1166666666667, 0.0375, 0.1
8264, 2.1166666666667, 0.025, 0.1
8265, 2.1166666666667, 0.0125, 0.1
8266, 1.2833333333333, 0.0375, 0.15
8267, 1.2833333333333, 0.025, 0.15
8268, 1.2833333333333, 0.0125, 0.15
8269, 1.3666666666667, 0.0375, 0.15
8270, 1.3666666666667, 0.025, 0.15
8271, 1.3666666666667, 0.0125, 0.15
8272, 1.45, 0.0375, 0.15
8273, 1.45, 0.025, 0.15
8274, 1.45, 0.0125, 0.15
8275, 1.5333333333333, 0.0375, 0.15
8276, 1.5333333333333, 0.025, 0.15
8277, 1.5333333333333, 0.0125, 0.15
8278, 1.6166666666667, 0.0375, 0.15
8279, 1.6166666666667, 0.025, 0.15
8280, 1.6166666666667, 0.0125, 0.15
8281, 1.7, 0.0375, 0.15
8282, 1.7, 0.025, 0.15
8283, 1.7, 0.0125, 0.15
8284, 1.7833333333333, 0.0375, 0.15
8285, 1.7833333333333, 0.025, 0.15
8286, 1.7833333333333, 0.0125, 0.15
8287, 1.8666666666667, 0.0375, 0.15
8288, 1.8666666666667, 0.025, 0.15
8289, 1.8666666666667, 0.0125, 0.15
8290, 1.95, 0.0375, 0.15
8291, 1.95, 0.025, 0.15
8292, 1.95, 0.0125, 0.15
8293, 2.0333333333333, 0.0375, 0.15
8294, 2.0333333333333, 0.025, 0.15
8295, 2.0333333333333, 0.0125, 0.15
8296, 2.1166666666667, 0.0375, 0.15
8297, 2.1166666666667, 0.025, 0.15
8298, 2.1166666666667, 0.0125, 0.15
8299, 1.2833333333333, 0.0375, 0.2
8300, 1.2833333333333, 0.025, 0.2
8301, 1.2833333333333, 0.0125, 0.2
8302, 1.3666666666667, 0.0375, 0.2
8303, 1.3666666666667, 0.025, 0.2
8304, 1.3666666666667, 0.0125, 0.2
8305, 1.45, 0.0375, 0.2
8306, 1.45, 0.025, 0.2
8307, 1.45, 0.0125, 0.2
8308, 1.5333333333333, 0.0375, 0.2
8309, 1.5333333333333, 0.025, 0.2
8310, 1.5333333333333, 0.0125, 0.2
8311, 1.6166666666667, 0.0375, 0.2
8312, 1.6166666666667, 0.025, 0.2
8313, 1.6166666666667, 0.0125, 0.2
8314, 1.7, 0.0375, 0.2
8315, 1.7, 0.025, 0.2
8316, 1.7, 0.0125, 0.2
8317, 1.7833333333333, 0.0375, 0.2
8318, 1.7833333333333, 0.025, 0.2
8319, 1.7833333333333, 0.0125, 0.2
8320, 1.8666666666667, 0.0375, 0.2
8321, 1.8666666666667, 0.025, 0.2
8322, 1.8666666666667, 0.0125, 0.2
8323, 1.95, 0.0375, 0.2
8324, 1.95, 0.025, 0.2
8325, 1.95, 0.0125, 0.2
8326, 2.0333333333333, 0.0375, 0.2
8327, 2.0333333333333, 0.025, 0.2
8328, 2.0333333333333, 0.0125, 0.2
8329, 2.1166666666667, 0.0375, 0.2
8330, 2.1166666666667, 0.025, 0.2
8331, 2.1166666666667, 0.0125, 0.2
8332, 1.2833333333333, 0.0375, 0.25
8333, 1.2833333333333, 0.025, 0.25
8334, 1.2833333333333, 0.0125, 0.25
8335, 1.3666666666667, 0.0375, 0.25
8336, 1.3666666666667, 0.025, 0.25
8337, 1.3666666666667, 0.0125, 0.25
8338, 1.45, 0.0375, 0.25
8339, 1.45, 0.025, 0.25
8340, 1.45, 0.0125, 0.25
8341, 1.5333333333333, 0.0375, 0.25
8342, 1.5333333333333, 0.025, 0.25
8343, 1.5333333333333, 0.0125, 0.25
8344, 1.6166666666667, 0.0375, 0.25
8345, 1.6166666666667, 0.025, 0.25
8346, 1.6166666666667, 0.0125, 0.25
8347, 1.7, 0.0375, 0.25
8348, 1.7, 0.025, 0.25
8349, 1.7, 0.0125, 0.25
8350, 1.7833333333333, 0.0375, 0.25
8351, 1.7833333333333, 0.025, 0.25
8352, 1.7833333333333, 0.0125, 0.25
8353, 1.8666666666667, 0.0375, 0.25
8354, 1.8666666666667, 0.025, 0.25
8355, 1.8666666666667, 0.0125, 0.25
8356, 1.95, 0.0375, 0.25
8357, 1.95, 0.025, 0.25
8358, 1.95, 0.0125, 0.25
8359, 2.0333333333333, 0.0375, 0.25
8360, 2.0333333333333, 0.025, 0.25
8361, 2.0333333333333, 0.0125, 0.25
8362, 2.1166666666667, 0.0375, 0.25
8363, 2.1166666666667, 0.025, 0.25
8364, 2.1166666666667, 0.0125, 0.25
8365, 1.2833333333333, 0.0375, 0.3
8366, 1.2833333333333, 0.025, 0.3
8367, 1.2833333333333, 0.0125, 0.3
8368, 1.3666666666667, 0.0375, 0.3
8369, 1.3666666666667, 0.025, 0.3
8370, 1.3666666666667, 0.0125, 0.3
8371, 1.45, 0.0375, 0.3
8372, 1.45, 0.025, 0.3
8373, 1.45, 0.0125, 0.3
8374, 1.5333333333333, 0.0375, 0.3
8375, 1.5333333333333, 0.025, 0.3
8376, 1.5333333333333, 0.0125, 0.3
8377, 1.6166666666667, 0.0375, 0.3
8378, 1.6166666666667, 0.025, 0.3
8379, 1.6166666666667, 0.0125, 0.3
8380, 1.7, 0.0375, 0.3
8381, 1.7, 0.025, 0.3
8382, 1.7, 0.0125, 0.3
8383, 1.7833333333333, 0.0375, 0.3
8384, 1.7833333333333, 0.025, 0.3
8385, 1.7833333333333, 0.0125, 0.3
8386, 1.8666666666667, 0.0375, 0.3
8387, 1.8666666666667, 0.025, 0.3
8388, 1.8666666666667, 0.0125, 0.3
8389, 1.95, 0.0375, 0.3
8390, 1.95, 0.025, 0.3
8391, 1.95, 0.0125, 0.3
8392, 2.0333333333333, 0.0375, 0.3
8393, 2.0333333333333, 0.025, 0.3
8394, 2.0333333333333, 0.0125, 0.3
8395, 2.1166666666667, 0.0375, 0.3
8396, 2.1166666666667, 0.025, 0.3
8397, 2.1166666666667, 0.0125, 0.3
8398, 1.2833333333333, 0.0375, 0.35
8399, 1.2833333333333, 0.025, 0.35
8400, 1.2833333333333, 0.0125, 0.35
8401, 1.3666666666667, 0.0375, 0.35
8402, 1.3666666666667, 0.025, 0.35
8403, 1.3666666666667, 0.0125, 0.35
8404, 1.45, 0.0375, 0.35
8405, 1.45, 0.025, 0.35
8406, 1.45, 0.0125, 0.35
8407, 1.5333333333333, 0.0375, 0.35
8408, 1.5333333333333, 0.025, 0.35
8409, 1.5333333333333, 0.0125, 0.35
8410, 1.6166666666667, 0.0375, 0.35
8411, 1.6166666666667, 0.025, 0.35
8412, 1.6166666666667, 0.0125, 0.35
8413, 1.7, 0.0375, 0.35
8414, 1.7, 0.025, 0.35
8415, 1.7, 0.0125, 0.35
8416, 1.7833333333333, 0.0375, 0.35
8417, 1.7833333333333, 0.025, 0.35
8418, 1.7833333333333, 0.0125, 0.35
8419, 1.8666666666667, 0.0375, 0.35
8420, 1.8666666666667, 0.025, 0.35
8421, 1.8666666666667, 0.0125, 0.35
8422, 1.95, 0.0375, 0.35
8423, 1.95, 0.025, 0.35
8424, 1.95, 0.0125, 0.35
8425, 2.0333333333333, 0.0375, 0.35
8426, 2.0333333333333, 0.025, 0.35
8427, 2.0333333333333, 0.0125, 0.35
8428, 2.1166666666667, 0.0375, 0.35
8429, 2.1166666666667, 0.025, 0.35
8430, 2.1166666666667, 0.0125, 0.35
8431, 1.2833333333333, 0.0375, 0.4
8432, 1.2833333333333, 0.025, 0.4
8433, 1.2833333333333, 0.0125, 0.4
8434, 1.3666666666667, 0.0375, 0.4
8435, 1.3666666666667, 0.025, 0.4
8436, 1.3666666666667, 0.0125, 0.4
8437, 1.45, 0.0375, 0.4
8438, 1.45, 0.025, 0.4
8439, 1.45, 0.0125, 0.4
8440, 1.5333333333333, 0.0375, 0.4
8441, 1.5333333333333, 0.025, 0.4
8442, 1.5333333333333, 0.0125, 0.4
8443, 1.6166666666667, 0.0375, 0.4
8444, 1.6166666666667, 0.025, 0.4
8445, 1.6166666666667, 0.0125, 0.4
8446, 1.7, 0.0375, 0.4
8447, 1.7, 0.025, 0.4
8448, 1.7, 0.0125, 0.4
8449, 1.7833333333333, 0.0375, 0.4
8450, 1.7833333333333, 0.025, 0.4
8451, 1.7833333333333, 0.0125, 0.4
8452, 1.8666666666667, 0.0375, 0.4
8453, 1.8666666666667, 0.025, 0.4
8454, 1.8666666666667, 0.0125, 0.4
8455, 1.95, 0.0375, 0.4
8456, 1.95, 0.025, 0.4
8457, 1.95, 0.0125, 0.4
8458, 2.0333333333333, 0.0375, 0.4
8459, 2.0333333333333, 0.025, 0.4
8460, 2.0333333333333, 0.0125, 0.4
8461, 2.1166666666667, 0.0375, 0.4
8462, 2.1166666666667, 0.025, 0.4
8463, 2.1166666666667, 0.0125, 0.4
8464, 1.2833333333333, 0.0375, 0.45
8465, 1.2833333333333, 0.025, 0.45
8466, 1.2833333333333, 0.0125, 0.45
8467, 1.3666666666667, 0.0375, 0.45
8468, 1.3666666666667, 0.025, 0.45
8469, 1.3666666666667, 0.0125, 0.45
8470, 1.45, 0.0375, 0.45
8471, 1.45, 0.025, 0.45
8472, 1.45, 0.0125, 0.45
8473, 1.5333333333333, 0.0375, 0.45
8474, 1.5333333333333, 0.025, 0.45
8475, 1.5333333333333, 0.0125, 0.45
8476, 1.6166666666667, 0.0375, 0.45
8477, 1.6166666666667, 0.025, 0.45
8478, 1.6166666666667, 0.0125, 0.45
8479, 1.7, 0.0375, 0.45
8480, 1.7, 0.025, 0.45
8481, 1.7, 0.0125, 0.45
8482, 1.7833333333333, 0.0375, 0.45
8483, 1.7833333333333, 0.025, 0.45
8484, 1.7833333333333, 0.0125, 0.45
8485, 1.8666666666667, 0.0375, 0.45
8486, 1.8666666666667, 0.025, 0.45
8487, 1.8666666666667, 0.0125, 0.45
8488, 1.95, 0.0375, 0.45
8489, 1.95, 0.025, 0.45
8490, 1.95, 0.0125, 0.45
8491, 2.0333333333333, 0.0375, 0.45
8492, 2.0333333333333, 0.025, 0.45
8493, 2.0333333333333, 0.0125, 0.45
8494, 2.1166666666667, 0.0375, 0.45
8495, 2.1166666666667, 0.025, 0.45
8496, 2.1166666666667, 0.0125, 0.45
8497, 0.083333333333333, 1.44, 0.05
8498, 0.083333333333333, 1.48, 0.05
8499, 0.083333333333333, 1.52, 0.05
8500, 0.083333333333333, 1.56, 0.05
8501, 0.083333333333333, 1.44, 0.1
8502, 0.083333333333333, 1.48, 0.1
8503, 0.083333333333333, 1.52, 0.1
8504, 0.083333333333333, 1.56, 0.1
8505, 0.083333333333333, 1.44, 0.15
8506, 0.083333333333333, 1.48, 0.15
8507, 0.083333333333333, 1.52, 0.15
8508, 0.083333333333333, 1.56, 0.15
8509, 0.083333333333333, 1.44, 0.2
8510, 0.083333333333333, 1.48, 0.2
8511, 0.083333333333333, 1.52, 0.2
8512, 0.083333333333333, 1.56, 0.2
8513, 0.083333333333333, 1.44, 0.25
8514, 0.083333333333333, 1.48, 0.25
8515, 0.083333333333333, 1.52, 0.25
8516, 0.083333333333333, 1.56, 0.25
8517, 0.083333333333333, 1.44, 0.3
8518, 0.083333333333333, 1.48, 0.3
8519, 0.083333333333333, 1.52, 0.3
8520, 0.083333333333333, 1.56, 0.3
8521, 0.083333333333333, 1.44, 0.35
8522, 0.083333333333333, 1.48, 0.35
8523, 0.083333333333333, 1.52, 0.35
8524, 0.083333333333333, 1.56, 0.35
8525, 0.083333333333333, 1.44, 0.4
8526, 0.083333333333333, 1.48, 0.4
8527, 0.083333333333333, 1.52, 0.4
8528, 0.083333333333333, 1.56, 0.4
8529, 0.083333333333333, 1.44, 0.45
8530, 0.083333333333333, 1.48, 0.45
8531, 0.083333333333333, 1.52, 0.45
8532, 0.083333333333333, 1.56, 0.45
8533, 0.16666666666667, 1.44, 0.05
8534, 0.16666666666667, 1.48, 0.05
8535, 0.16666666666667, 1.52, 0.05
8536, 0.16666666666667, 1.56, 0.05
8537, 0.16666666666667, 1.44, 0.1
8538, 0.16666666666667, 1.48, 0.1
8539, 0.16666666666667, 1.52, 0.1
8540, 0.16666666666667, 1.56, 0.1
8541, 0.16666666666667, 1.44, 0.15
8542, 0.16666666666667, 1.48, 0.15
8543, 0.16666666666667, 1.52, 0.15
8544, 0.16666666666667, 1.56, 0.15
8545, 0.16666666666667, 1.44, 0.2
8546, 0.16666666666667, 1.48, 0.2
8547, 0.16666666666667, 1.52, 0.2
8548, 0.16666666666667, 1.56, 0.2
8549, 0.16666666666667, 1.44, 0.25
8550, 0.16666666666667, 1.48, 0.25
8551, 0.16666666666667, 1.52, 0.25
8552, 0.16666666666667, 1.56, 0.25
8553, 0.16666666666667, 1.44, 0.3
8554, 0.16666666666667, 1.48, 0.3
8555, 0.16666666666667, 1.52, 0.3
8556, 0.16666666666667, 1.56, 0.3
8557, 0.16666666666667, 1.44, 0.35
8558, 0.16666666666667, 1.48, 0.35
8559, 0.16666666666667, 1.52, 0.35
8560, 0.16666666666667, 1.56, 0.35
8561, 0.16666666666667, 1.44, 0.4
8562, 0.16666666666667, 1.48, 0.4
8563, 0.16666666666667, 1.52, 0.4
8564, 0.16666666666667, 1.56, 0.4
8565, 0.16666666666667, 1.44, 0.45
8566, 0.16666666666667, 1.48, 0.45
8567, 0.16666666666667, 1.52, 0.45
8568, 0.16666666666667, 1.56, 0.45
8569, 0.25, 1.44, 0.05
8570, 0.25, 1.48, 0.05
8571, 0.25, 1.52, 0.05
8572, 0.25, 1.56, 0.05
8573, 0.25, 1.44, 0.1
8574, 0.25, 1.48, 0.1
8575, 0.25, 1.52, 0.1
8576, 0.25, 1.56, 0.1
8577, 0.25, 1.44, 0.15
8578, 0.25, 1.48, 0.15
8579, 0.25, 1.52, 0.15
8580, 0.25, 1.56, 0.15
8581, 0.25, 1.44, 0.2
8582, 0.25, 1.48, 0.2
8583, 0.25, 1.52, 0.2
8584, 0.25, 1.56, 0.2
8585, 0.25, 1.44, 0.25
8586, 0.25, 1.48, 0.25
8587, 0.25, 1.52, 0.25
8588, 0.25, 1.56, 0.25
8589, 0.25, 1.44, 0.3
8590, 0.25, 1.48, 0.3
8591, 0.25, 1.52, 0.3
8592, 0.25, 1.56, 0.3
8593, 0.25, 1.44, 0.35
8594, 0.25, 1.48, 0.35
8595, 0.25, 1.52, 0.35
8596, 0.25, 1.56, 0.35
8597, 0.25, 1.44, 0.4
8598, 0.25, 1.48, 0.4
8599, 0.25, 1.52, 0.4
8600, 0.25, 1.56, 0.4
8601, 0.25, 1.44, 0.45
8602, 0.25, 1.48, 0.45
8603, 0.25, 1.52, 0.45
8604, 0.25, 1.56, 0.45
8605, 0.33333333333333, 1.44, 0.05
8606, 0.33333333333333, 1.48, 0.05
8607, 0.33333333333333, 1.52, 0.05
8608, 0.33333333333333, 1.56, 0.05
8609, 0.33333333333333, 1.44, 0.1
8610, 0.33333333333333, 1.48, 0.1
8611, 0.33333333333333, 1.52, 0.1
8612, 0.33333333333333, 1.56, 0.1
8613, 0.33333333333333, 1.44, 0.15
8614, 0.33333333333333, 1.48, 0.15
8615, 0.33333333333333, 1.52, 0.15
8616, 0.33333333333333, 1.56, 0.15
8617, 0.33333333333333, 1.44, 0.2
8618, 0.33333333333333, 1.48, 0.2
8619, 0.33333333333333, 1.52, 0.2
8620, 0.33333333333333, 1.56, 0.2
8621, 0.33333333333333, 1.44, 0.25
8622, 0.33333333333333, 1.48, 0.25
8623, 0.33333333333333, 1.52, 0.25
8624, 0.33333333333333, 1.56, 0.25
8625, 0.33333333333333, 1.44, 0.3
8626, 0.33333333333333, 1.48, 0.3
8627, 0.33333333333333, 1.52, 0.3
8628, 0.33333333333333, 1.56, 0.3
8629, 0.33333333333333, 1.44, 0.35
8630, 0.33333333333333, 1.48, 0.35
8631, 0.33333333333333, 1.52, 0.35
8632, 0.33333333333333, 1.56, 0.35
8633, 0.33333333333333, 1.44, 0.4
8634, 0.33333333333333, 1.48, 0.4
8635, 0.33333333333333, 1.52, 0.4
8636, 0.33333333333333, 1.56, 0.4
8637, 0.33333333333333, 1.44, 0.45
8638, 0.33333333333333, 1.48, 0.45
8639, 0.33333333333333, 1.52, 0.45
8640, 0.33333333333333, 1.56, 0.45
8641, 0.41666666666667, 1.44, 0.05
8642, 0.41666666666667, 1.48, 0.05
8643, 0.41666666666667, 1.52, 0.05
8644, 0.41666666666667, 1.56, 0.05
8645, 0.41666666666667, 1.44, 0.1
8646, 0.41666666666667, 1.48, 0.1
8647, 0.41666666666667, 1.52, 0.1
8648, 0.41666666666667, 1.56, 0.1
8649, 0.41666666666667, 1.44, 0.15
8650, 0.41666666666667, 1.48, 0.15
8651, 0.41666666666667, 1.52, 0.15
8652, 0.41666666666667, 1.56, 0.15
8653, 0.41666666666667, 1.44, 0.2
8654, 0.41666666666667, 1.48, 0.2
8655, 0.41666666666667, 1.52, 0.2
8656, 0.41666666666667, 1.56, 0.2
8657, 0.41666666666667, 1.44, 0.25
8658, 0.41666666666667, 1.48, 0.25
8659, 0.41666666666667, 1.52, 0.25
8660, 0.41666666666667, 1.56, 0.25
8661, 0.41666666666667, 1.44, 0.3
8662, 0.41666666666667, 1.48, 0.3
8663, 0.41666666666667, 1.52, 0.3
8664, 0.41666666666667, 1.56, 0.3
8665, 0.41666666666667, 1.44, 0.35
8666, 0.41666666666667, 1.48, 0.35
8667, 0.41666666666667, 1.52, 0.35
8668, 0.41666666666667, 1.56, 0.35
8669, 0.41666666666667, 1.44, 0.4
8670, 0.41666666666667, 1.48, 0.4
8671, 0.41666666666667, 1.52, 0.4
8672, 0.41666666666667, 1.56, 0.4
8673, 0.41666666666667, 1.44, 0.45
8674, 0.41666666666667, 1.48, 0.45
8675, 0.41666666666667, 1.52, 0.45
8676, 0.41666666666667, 1.56, 0.45
8677, 0.5, 1.44, 0.05
8678, 0.5, 1.48, 0.05
8679, 0.5, 1.52, 0.05
8680, 0.5, 1.56, 0.05
8681, 0.5, 1.44, 0.1
8682, 0.5, 1.48, 0.1
8683, 0.5, 1.52, 0.1
8684, 0.5, 1.56, 0.1
8685, 0.5, 1.44, 0.15
8686, 0.5, 1.48, 0.15
8687, 0.5, 1.52, 0.15
8688, 0.5, 1.56, 0.15
8689, 0.5, 1.44, 0.2
8690, 0.5, 1.48, 0.2
8691, 0.5, 1.52, 0.2
8692, 0.5, 1.56, 0.2
8693, 0.5, 1.44, 0.25
8694, 0.5, 1.48, 0.25
8695, 0.5, 1.52, 0.25
8696, 0.5, 1.56, 0.25
8697, 0.5, 1.44, 0.3
8698, 0.5, 1.48, 0.3
8699, 0.5, 1.52, 0.3
8700, 0.5, 1.56, 0.3
8701, 0.5, 1.44, 0.35
8702, 0.5, 1.48, 0.35
8703, 0.5, 1.52, 0.35
8704, 0.5, 1.56, 0.35
8705, 0.5, 1.44, 0.4
8706, 0.5, 1.48, 0.4
8707, 0.5, 1.52, 0.4
8708, 0.5, 1.56, 0.4
8709, 0.5, 1.44, 0.45
8710, 0.5, 1.48, 0.45
8711, 0.5, 1.52, 0.45
8712, 0.5, 1.56, 0.45
8713, 0.58333333333333, 1.44, 0.05
8714, 0.58333333333333, 1.48, 0.05
8715, 0.58333333333333, 1.52, 0.05
8716, 0.58333333333333, 1.56, 0.05
8717, 0.58333333333333, 1.44, 0.1
8718, 0.58333333333333, 1.48, 0.1
8719, 0.58333333333333, 1.52, 0.1
8720, 0.58333333333333, 1.56, 0.1
8721, 0.58333333333333, 1.44, 0.15
8722, 0.58333333333333, 1.48, 0.15
8723, 0.58333333333333, 1.52, 0.15
8724, 0.58333333333333, 1.56, 0.15
8725, 0.58333333333333, 1.44, 0.2
8726, 0.58333333333333, 1.48, 0.2
8727, 0.58333333333333, 1.52, 0.2
8728, 0.58333333333333, 1.56, 0.2
8729, 0.58333333333333, 1.44, 0.25
8730, 0.58333333333333, 1.48, 0.25
8731, 0.58333333333333, 1.52, 0.25
8732, 0.58333333333333, 1.56, 0.25
8733, 0.58333333333333, 1.44, 0.3
8734, 0.58333333333333, 1.48, 0.3
8735, 0.58333333333333, 1.52, 0.3
8736, 0.58333333333333, 1.56, 0.3
8737, 0.58333333333333, 1.44, 0.35
8738, 0.58333333333333, 1.48, 0.35
8739, 0.58333333333333, 1.52, 0.35
8740, 0.58333333333333, 1.56, 0.35
8741, 0.58333333333333, 1.44, 0.4
8742, 0.58333333333333, 1.48, 0.4
8743, 0.58333333333333, 1.52, 0.4
8744, 0.58333333333333, 1.56, 0.4
8745, 0.58333333333333, 1.44, 0.45
8746, 0.58333333333333, 1.48, 0.45
8747, 0.58333333333333, 1.52, 0.45
8748, 0.58333333333333, 1.56, 0.45
8749, 0.66666666666667, 1.44, 0.05
8750, 0.66666666666667, 1.48, 0.05
8751, 0.66666666666667, 1.52, 0.05
8752, 0.66666666666667, 1.56, 0.05
8753, 0.66666666666667, 1.44, 0.1
8754, 0.66666666666667, 1.48, 0.1
8755, 0.66666666666667, 1.52, 0.1
8756, 0.66666666666667, 1.56, 0.1
8757, 0.66666666666667, 1.44, 0.15
8758, 0.66666666666667, 1.48, 0.15
8759, 0.66666666666667, 1.52, 0.15
8760, 0.66666666666667, 1.56, 0.15
8761, 0.66666666666667, 1.44, 0.2
8762, 0.66666666666667, 1.48, 0.2
8763, 0.66666666666667, 1.52, 0.2
8764, 0.66666666666667, 1.56, 0.2
8765, 0.66666666666667, 1.44, 0.25
8766, 0.66666666666667, 1.48, 0.25
8767, 0.66666666666667, 1.52, 0.25
8768, 0.66666666666667, 1.56, 0.25
8769, 0.66666666666667, 1.44, 0.3
8770, 0.66666666666667, 1.48, 0.3
8771, 0.66666666666667, 1.52, 0.3
8772, 0.66666666666667, 1.56, 0.3
8773, 0.66666666666667, 1.44, 0.35
8774, 0.66666666666667, 1.48, 0.35
8775, 0.66666666666667, 1.52, 0.35
8776, 0.66666666666667, 1.56, 0.35
8777, 0.66666666666667, 1.44, 0.4
8778, 0.66666666666667, 1.48, 0.4
8779, 0.66666666666667, 1.52, 0.4
8780, 0.66666666666667, 1.56, 0.4
8781, 0.66666666666667, 1.44, 0.45
8782, 0.66666666666667, 1.48, 0.45
8783, 0.66666666666667, 1.52, 0.45
8784, 0.66666666666667, 1.56, 0.45
8785, 0.75, 1.44, 0.05
8786, 0.75, 1.48, 0.05
8787, 0.75, 1.52, 0.05
8788, 0.75, 1.56, 0.05
8789, 0.75, 1.44, 0.1
8790, 0.75, 1.48, 0.1
8791, 0.75, 1.52, 0.1
8792, 0.75, 1.56, 0.1
8793, 0.75, 1.44, 0.15
8794, 0.75, 1.48, 0.15
8795, 0.75, 1.52, 0.15
8796, 0.75, 1.56, 0.15
8797, 0.75, 1.44, 0.2
8798, 0.75, 1.48, 0.2
8799, 0.75, 1.52, 0.2
8800, 0.75, 1.56, 0.2
8801, 0.75, 1.44, 0.25
8802, 0.75, 1.48, 0.25
8803, 0.75, 1.52, 0.25
8804, 0.75, 1.56, 0.25
8805, 0.75, 1.44, 0.3
8806, 0.75, 1.48, 0.3
8807, 0.75, 1.52, 0.3
8808, 0.75, 1.56, 0.3
8809, 0.75, 1.44, 0.35
8810, 0.75, 1.48, 0.35
8811, 0.75, 1.52, 0.35
8812, 0.75, 1.56, 0.35
8813, 0.75, 1.44, 0.4
8814, 0.75, 1.48, 0.4
8815, 0.75, 1.52, 0.4
8816, 0.75, 1.56, 0.4
8817, 0.75, 1.44, 0.45
8818, 0.75, 1.48, 0.45
8819, 0.75, 1.52, 0.45
8820, 0.75, 1.56, 0.45
8821, 0.83333333333333, 1.44, 0.05
8822, 0.83333333333333, 1.48, 0.05
8823, 0.83333333333333, 1.52, 0.05
8824, 0.83333333333333, 1.56, 0.05
8825, 0.83333333333333, 1.44, 0.1
8826, 0.83333333333333, 1.48, 0.1
8827, 0.83333333333333, 1.52, 0.1
8828, 0.83333333333333, 1.56, 0.1
8829, 0.83333333333333, 1.44, 0.15
8830, 0.83333333333333, 1.48, 0.15
8831, 0.83333333333333, 1.52, 0.15
8832, 0.83333333333333, 1.56, 0.15
8833, 0.83333333333333, 1.44, 0.2
8834, 0.83333333333333, 1.48, 0.2
8835, 0.83333333333333, 1.52, 0.2
8836, 0.83333333333333, 1.56, 0.2
8837, 0.83333333333333, 1.44, 0.25
8838, 0.83333333333333, 1.48, 0.25
8839, 0.83333333333333, 1.52, 0.25
8840, 0.83333333333333, 1.56, 0.25
8841, 0.83333333333333, 1.44, 0.3
8842, 0.83333333333333, 1.48, 0.3
8843, 0.83333333333333, 1.52, 0.3
8844, 0.83333333333333, 1.56, 0.3
8845, 0.83333333333333, 1.44, 0.35
8846, 0.83333333333333, 1.48, 0.35
8847, 0.83333333333333, 1.52, 0.35
8848, 0.83333333333333, 1.56, 0.35
8849, 0.83333333333333, 1.44, 0.4
8850, 0.83333333333333, 1.48, 0.4
8851, 0.83333333333333, 1.52, 0.4
8852, 0.83333333333333, 1.56, 0.4
8853, 0.83333333333333, 1.44, 0.45
8854, 0.83333333333333, 1.48, 0.45
8855, 0.83333333333333, 1.52, 0.45
8856, 0.83333333333333, 1.56, 0.45
8857, 0.91666666666667, 1.44, 0.05
8858, 0.91666666666667, 1.48, 0.05
8859, 0.91666666666667, 1.52, 0.05
8860, 0.91666666666667, 1.56, 0.05
8861, 0.91666666666667, 1.44, 0.1
8862, 0.91666666666667, 1.48, 0.1
8863, 0.91666666666667, 1.52, 0.1
8864, 0.91666666666667, 1.56, 0.1
8865, 0.91666666666667, 1.44, 0.15
8866, 0.91666666666667, 1.48, 0.15
8867, 0.91666666666667, 1.52, 0.15
8868, 0.91666666666667, 1.56, 0.15
8869, 0.91666666666667, 1.44, 0.2
8870, 0.91666666666667, 1.48, 0.2
8871, 0.91666666666667, 1.52, 0.2
8872, 0.91666666666667, 1.56, 0.2
8873, 0.91666666666667, 1.44, 0.25
8874, 0.91666666666667, 1.48, 0.25
8875, 0.91666666666667, 1.52, 0.25
8876, 0.91666666666667, 1.56, 0.25
8877, 0.91666666666667, 1.44, 0.3
8878, 0.91666666666667, 1.48, 0.3
8879, 0.91666666666667, 1.52, 0.3
8880, 0.91666666666667, 1.56, 0.3
8881, 0.91666666666667, 1.44, 0.35
8882, 0.91666666666667, 1.48, 0.35
8883, 0.91666666666667, 1.52, 0.35
8884, 0.91666666666667, 1.56, 0.35
8885, 0.91666666666667, 1.44, 0.4
8886, 0.91666666666667, 1.48, 0.4
8887, 0.91666666666667, 1.52, 0.4
8888, 0.91666666666667, 1.56, 0.4
8889, 0.91666666666667, 1.44, 0.45
8890, 0.91666666666667, 1.48, 0.45
8891, 0.91666666666667, 1.52, 0.45
8892, 0.91666666666667, 1.56, 0.45
8893, 1.0285714285714, 1.44, 0.05
8894, 1.0285714285714, 1.48, 0.05
8895, 1.0285714285714, 1.52, 0.05
8896, 1.0285714285714, 1.56, 0.05
8897, 1.0571428571429, 1.44, 0.05
8898, 1.0571428571429, 1.48, 0.05
8899, 1.0571428571429, 1.52, 0.05
8900, 1.0571428571429, 1.56, 0.05
8901, 1.0857142857143, 1.44, 0.05
8902, 1.0857142857143, 1.48, 0.05
8903, 1.0857142857143, 1.52, 0.05
8904, 1.0857142857143, 1.56, 0.05
8905, 1.1142857142857, 1.44, 0.05
8906, 1.1142857142857, 1.48, 0.05
8907, 1.1142857142857, 1.52, 0.05
8908, 1.1142857142857, 1.56, 0.05
8909, 1.1428571428571, 1.44, 0.05
8910, 1.1428571428571, 1.48, 0.05
8911, 1.1428571428571, 1.52, 0.05
8912, 1.1428571428571, 1.56, 0.05
8913, 1.1714285714286, 1.44, 0.05
8914, 1.1714285714286, 1.48, 0.05
8915, 1.1714285714286, 1.52, 0.05
8916, 1.1714285714286, 1.56, 0.05
8917, 1.0285714285714, 1.44, 0.1
8918, 1.0285714285714, 1.48, 0.1
8919, 1.0285714285714, 1.52, 0.1
8920, 1.0285714285714, 1.56, 0.1
8921, 1.0571428571429, 1.44, 0.1
8922, 1.0571428571429, 1.48, 0.1
8923, 1.0571428571429, 1.52, 0.1
8924, 1.0571428571429, 1.56, 0.1
8925, 1.0857142857143, 1.44, 0.1
8926, 1.0857142857143, 1.48, 0.1
8927, 1.0857142857143, 1.52, 0.1
8928, 1.0857142857143, 1.56, 0.1
8929, 1.1142857142857, 1.44, 0.1
8930, 1.1142857142857, 1.48, 0.1
8931, 1.1142857142857, 1.52, 0.1
8932, 1.1142857142857, 1.56, 0.1
8933, 1.1428571428571, 1.44, 0.1
8934, 1.1428571428571, 1.48, 0.1
8935, 1.1428571428571, 1.52, 0.1
8936, 1.1428571428571, 1.56, 0.1
8937, 1.1714285714286, 1.44, 0.1
8938, 1.1714285714286, 1.48, 0.1
8939, 1.1714285714286, 1.52, 0.1
8940, 1.1714285714286, 1.56, 0.1
8941, 1.0285714285714, 1.44, 0.15
8942, 1.0285714285714, 1.48, 0.15
8943, 1.0285714285714, 1.52, 0.15
8944, 1.0285714285714, 1.56, 0.15
8945, 1.0571428571429, 1.44, 0.15
8946, 1.0571428571429, 1.48, 0.15
8947, 1.0571428571429, 1.52, 0.15
8948, 1.0571428571429, 1.56, 0.15
8949, 1.0857142857143, 1.44, 0.15
8950, 1.0857142857143, 1.48, 0.15
8951, 1.0857142857143, 1.52, 0.15
8952, 1.0857142857143, 1.56, 0.15
8953, 1.1142857142857, 1.44, 0.15
8954, 1.1142857142857, 1.48, 0.15
8955, 1.1142857142857, 1.52, 0.15
8956, 1.1142857142857, 1.56, 0.15
8957, 1.1428571428571, 1.44, 0.15
8958, 1.1428571428571, 1.48, 0.15
8959, 1.1428571428571, 1.52, 0.15
8960, 1.1428571428571, 1.56, 0.15
8961, 1.1714285714286, 1.44, 0.15
8962, 1.1714285714286, 1.48, 0.15
8963, 1.1714285714286, 1.52, 0.15
8964, 1.1714285714286, 1.56, 0.15
8965, 1.0285714285714, 1.44, 0.2
8966, 1.0285714285714, 1.48, 0.2
8967, 1.0285714285714, 1.52, 0.2
8968, 1.0285714285714, 1.56, 0.2
8969, 1.0571428571429, 1.44, 0.2
8970, 1.0571428571429, 1.48, 0.2
8971, 1.0571428571429, 1.52, 0.2
8972, 1.0571428571429, 1.56, 0.2
8973, 1.0857142857143, 1.44, 0.2
8974, 1.0857142857143, 1.48, 0.2
8975, 1.0857142857143, 1.52, 0.2
8976, 1.0857142857143, 1.56, 0.2
8977, 1.1142857142857, 1.44, 0.2
8978, 1.1142857142857, 1.48, 0.2
8979, 1.1142857142857, 1.52, 0.2
8980, 1.1142857142857, 1.56, 0.2
8981, 1.1428571428571, 1.44, 0.2
8982, 1.1428571428571, 1.48, 0.2
8983, 1.1428571428571, 1.52, 0.2
8984, 1.1428571428571, 1.56, 0.2
8985, 1.1714285714286, 1.44, 0.2
8986, 1.1714285714286, 1.48, 0.2
8987, 1.1714285714286, 1.52, 0.2
8988, 1.1714285714286, 1.56, 0.2
8989, 1.0285714285714, 1.44, 0.25
8990, 1.0285714285714, 1.48, 0.25
8991, 1.0285714285714, 1.52, 0.25
8992, 1.0285714285714, 1.56, 0.25
8993, 1.0571428571429, 1.44, 0.25
8994, 1.0571428571429, 1.48, 0.25
8995, 1.0571428571429, 1.52, 0.25
8996, 1.0571428571429, 1.56, 0.25
8997, 1.0857142857143, 1.44, 0.25
8998, 1.0857142857143, 1.48, 0.25
8999, 1.0857142857143, 1.52, 0.25
9000, 1.0857142857143, 1.56, 0.25
9001, 1.1142857142857, 1.44, 0.25
9002, 1.1142857142857, 1.48, 0.25
9003, 1.1142857142857, 1.52, 0.25
9004, 1.1142857142857, 1.56, 0.25
9005, 1.1428571428571, 1.44, 0.25
9006, 1.1428571428571, 1.48, 0.25
9007, 1.1428571428571, 1.52, 0.25
9008, 1.1428571428571, 1.56, 0.25
9009, 1.1714285714286, 1.44, 0.25
9010, 1.1714285714286, 1.48, 0.25
9011, 1.1714285714286, 1.52, 0.25
9012, 1.1714285714286, 1.56, 0.25
9013, 1.0285714285714, 1.44, 0.3
9014, 1.0285714285714, 1.48, 0.3
9015, 1.0285714285714, 1.52, 0.3
9016, 1.0285714285714, 1.56, 0.3
9017, 1.0571428571429, 1.44, 0.3
9018, 1.0571428571429, 1.48, 0.3
9019, 1.0571428571429, 1.52, 0.3
9020, 1.0571428571429, 1.56, 0.3
9021, 1.0857142857143, 1.44, 0.3
9022, 1.0857142857143, 1.48, 0.3
9023, 1.0857142857143, 1.52, 0.3
9024, 1.0857142857143, 1.56, 0.3
9025, 1.1142857142857, 1.44, 0.3
9026, 1.1142857142857, 1.48, 0.3
9027, 1.1142857142857, 1.52, 0.3
9028, 1.1142857142857, 1.56, 0.3
9029, 1.1428571428571, 1.44, 0.3
9030, 1.1428571428571, 1.48, 0.3
9031, 1.1428571428571, 1.52, 0.3
9032, 1.1428571428571, 1.56, 0.3
9033, 1.1714285714286, 1.44, 0.3
9034, 1.1714285714286, 1.48, 0.3
9035, 1.1714285714286, 1.52, 0.3
9036, 1.1714285714286, 1.56, 0.3
9037, 1.0285714285714, 1.44, 0.35
9038, 1.0285714285714, 1.48, 0.35
9039, 1.0285714285714, 1.52, 0.35
9040, 1.0285714285714, 1.56, 0.35
9041, 1.0571428571429, 1.44, 0.35
9042, 1.0571428571429, 1.48, 0.35
9043, 1.0571428571429, 1.52, 0.35
9044, 1.0571428571429, 1.56, 0.35
9045, 1.0857142857143, 1.44, 0.35
9046, 1.0857142857143, 1.48, 0.35
9047, 1.0857142857143, 1.52, 0.35
9048, 1.0857142857143, 1.56, 0.35
9049, 1.1142857142857, 1.44, 0.35
9050, 1.1142857142857, 1.48, 0.35
9051, 1.1142857142857, 1.52, 0.35
9052, 1.1142857142857, 1.56, 0.35
9053, 1.1428571428571, 1.44, 0.35
9054, 1.1428571428571, 1.48, 0.35
9055, 1.1428571428571, 1.52, 0.35
9056, 1.1428571428571, 1.56, 0.35
9057, 1.1714285714286, 1.44, 0.35
9058, 1.1714285714286, 1.48, 0.35
9059, 1.1714285714286, 1.52, 0.35
9060, 1.1714285714286, 1.56, 0.35
9061, 1.0285714285714, 1.44, 0.4
9062, 1.0285714285714, 1.48, 0.4
9063, 1.0285714285714, 1.52, 0.4
9064, 1.0285714285714, 1.56, 0.4
9065, 1.0571428571429, 1.44, 0.4
9066, 1.0571428571429, 1.48, 0.4
9067, 1.0571428571429, 1.52, 0.4
9068, 1.0571428571429, 1.56, 0.4
9069, 1.0857142857143, 1.44, 0.4
9070, 1.0857142857143, 1.48, 0.4
9071, 1.0857142857143, 1.52, 0.4
9072, 1.0857142857143, 1.56, 0.4
9073, 1.1142857142857, 1.44, 0.4
9074, 1.1142857142857, 1.48, 0.4
9075, 1.1142857142857, 1.52, 0.4
9076, 1.1142857142857, 1.56, 0.4
9077, 1.1428571428571, 1.44, 0.4
9078, 1.1428571428571, 1.48, 0.4
9079, 1.1428571428571, 1.52, 0.4
9080, 1.1428571428571, 1.56, 0.4
9081, 1.1714285714286, 1.44, 0.4
9082, 1.1714285714286, 1.48, 0.4
9083, 1.1714285714286, 1.52, 0.4
9084, 1.1714285714286, 1.56, 0.4
9085, 1.0285714285714, 1.44, 0.45
9086, 1.0285714285714, 1.48, 0.45
9087, 1.0285714285714, 1.52, 0.45
9088, 1.0285714285714, 1.56, 0.45
9089, 1.0571428571429, 1.44, 0.45
9090, 1.0571428571429, 1.48, 0.45
9091, 1.0571428571429, 1.52, 0.45
9092, 1.0571428571429, 1.56, 0.45
9093, 1.0857142857143, 1.44, 0.45
9094, 1.0857142857143, 1.48, 0.45
9095, 1.0857142857143, 1.52, 0.45
9096, 1.0857142857143, 1.56, 0.45
9097, 1.1142857142857, 1.44, 0.45
9098, 1.1142857142857, 1.48, 0.45
9099, 1.1142857142857, 1.52, 0.45
9100, 1.1142857142857, 1.56, 0.45
9101, 1.1428571428571, 1.44, 0.45
9102, 1.1428571428571, 1.48, 0.45
9103, 1.1428571428571, 1.52, 0.45
9104, 1.1428571428571, 1.56, 0.45
9105, 1.1714285714286, 1.44, 0.45
9106, 1.1714285714286, 1.48, 0.45
9107, 1.1714285714286, 1.52, 0.45
9108, 1.1714285714286, 1.56, 0.45
9109, 1.2833333333333, 1.44, 0.05
9110, 1.2833333333333, 1.48, 0.05
9111, 1.2833333333333, 1.52, 0.05
9112, 1.2833333333333, 1.56, 0.05
9113, 1.3666666666667, 1.44, 0.05
9114, 1.3666666666667, 1.48, 0.05
9115, 1.3666666666667, 1.52, 0.05
9116, 1.3666666666667, 1.56, 0.05
9117, 1.45, 1.44, 0.05
9118, 1.45, 1.48, 0.05
9119, 1.45, 1.52, 0.05
9120, 1.45, 1.56, 0.05
9121, 1.5333333333333, 1.44, 0.05
9122, 1.5333333333333, 1.48, 0.05
9123, 1.5333333333333, 1.52, 0.05
9124, 1.5333333333333, 1.56, 0.05
9125, 1.6166666666667, 1.44, 0.05
9126, 1.6166666666667, 1.48, 0.05
9127, 1.6166666666667, 1.52, 0.05
9128, 1.6166666666667, 1.56, 0.05
9129, 1.7, 1.44, 0.05
9130, 1.7, 1.48, 0.05
9131, 1.7, 1.52, 0.05
9132, 1.7, 1.56, 0.05
9133, 1.7833333333333, 1.44, 0.05
9134, 1.7833333333333, 1.48, 0.05
9135, 1.7833333333333, 1.52, 0.05
9136, 1.7833333333333, 1.56, 0.05
9137, 1.8666666666667, 1.44, 0.05
9138, 1.8666666666667, 1.48, 0.05
9139, 1.8666666666667, 1.52, 0.05
9140, 1.8666666666667, 1.56, 0.05
9141, 1.95, 1.44, 0.05
9142, 1.95, 1.48, 0.05
9143, 1.95, 1.52, 0.05
9144, 1.95, 1.56, 0.05
9145, 2.0333333333333, 1.44, 0.05
9146, 2.0333333333333, 1.48, 0.05
9147, 2.0333333333333, 1.52, 0.05
9148, 2.0333333333333, 1.56, 0.05
9149, 2.1166666666667, 1.44, 0.05
9150, 2.1166666666667, 1.48, 0.05
9151, 2.1166666666667, 1.52, 0.05
9152, 2.1166666666667, 1.56, 0.05
9153, 1.2833333333333, 1.44, 0.1
9154, 1.2833333333333, 1.48, 0.1
9155, 1.2833333333333, 1.52, 0.1
9156, 1.2833333333333, 1.56, 0.1
9157, 1.3666666666667, 1.44, 0.1
9158, 1.3666666666667, 1.48, 0.1
9159, 1.3666666666667, 1.52, 0.1
9160, 1.3666666666667, 1.56, 0.1
9161, 1.45, 1.44, 0.1
9162, 1.45, 1.48, 0.1
9163, 1.45, 1.52, 0.1
9164, 1.45, 1.56, 0.1
9165, 1.5333333333333, 1.44, 0.1
9166, 1.5333333333333, 1.48, 0.1
9167, 1.5333333333333, 1.52, 0.1
9168, 1.5333333333333, 1.56, 0.1
9169, 1.6166666666667, 1.44, 0.1
9170, 1.6166666666667, 1.48, 0.1
9171, 1.6166666666667, 1.52, 0.1
9172, 1.6166666666667, 1.56, 0.1
9173, 1.7, 1.44, 0.1
9174, 1.7, 1.48, 0.1
9175, 1.7, 1.52, 0.1
9176, 1.7, 1.56, 0.1
9177, 1.7833333333333, 1.44, 0.1
9178, 1.7833333333333, 1.48, 0.1
9179, 1.7833333333333, 1.52, 0.1
9180, 1.7833333333333, 1.56, 0.1
9181, 1.8666666666667, 1.44, 0.1
9182, 1.8666666666667, 1.48, 0.1
9183, 1.8666666666667, 1.52, 0.1
9184, 1.8666666666667, 1.56, 0.1
9185, 1.95, 1.44, 0.1
9186, 1.95, 1.48, 0.1
9187, 1.95, 1.52, 0.1
9188, 1.95, 1.56, 0.1
9189, 2.0333333333333, 1.44, 0.1
9190, 2.0333333333333, 1.48, 0.1
9191, 2.0333333333333, 1.52, 0.1
9192, 2.0333333333333, 1.56, 0.1
9193, 2.1166666666667, 1.44, 0.1
9194, 2.1166666666667, 1.48, 0.1
9195, 2.1166666666667, 1.52, 0.1
9196, 2.1166666666667, 1.56, 0.1
9197, 1.2833333333333, 1.44, 0.15
9198, 1.2833333333333, 1.48, 0.15
9199, 1.2833333333333, 1.52, 0.15
9200, 1.2833333333333, 1.56, 0.15
9201, 1.3666666666667, 1.44, 0.15
9202, 1.3666666666667, 1.48, 0.15
9203, 1.3666666666667, 1.52, 0.15
9204, 1.3666666666667, 1.56, 0.15
9205, 1.45, 1.44, 0.15
9206, 1.45, 1.48, 0.15
9207, 1.45, 1.52, 0.15
9208, 1.45, 1.56, 0.15
9209, 1.5333333333333, 1.44, 0.15
9210, 1.5333333333333, 1.48, 0.15
9211, 1.5333333333333, 1.52, 0.15
9212, 1.5333333333333, 1.56, 0.15
9213, 1.6166666666667, 1.44, 0.15
9214, 1.6166666666667, 1.48, 0.15
9215, 1.6166666666667, 1.52, 0.15
9216, 1.6166666666667, 1.56, 0.15
9217, 1.7, 1.44, 0.15
9218, 1.7, 1.48, 0.15
9219, 1.7, 1.52, 0.15
9220, 1.7, 1.56, 0.15
9221, 1.7833333333333, 1.44, 0.15
9222, 1.7833333333333, 1.48, 0.15
9223, 1.7833333333333, 1.52, 0.15
9224, 1.7833333333333, 1.56, 0.15
9225, 1.8666666666667, 1.44, 0.15
9226, 1.8666666666667, 1.48, 0.15
9227, 1.8666666666667, 1.52, 0.15
9228, 1.8666666666667, 1.56, 0.15
9229, 1.95, 1.44, 0.15
9230, 1.95, 1.48, 0.15
9231, 1.95, 1.52, 0.15
9232, 1.95, 1.56, 0.15
9233, 2.0333333333333, 1.44, 0.15
9234, 2.0333333333333, 1.48, 0.15
9235, 2.0333333333333, 1.52, 0.15
9236, 2.0333333333333, 1.56, 0.15
9237, 2.1166666666667, 1.44, 0.15
9238, 2.1166666666667, 1.48, 0.15
9239, 2.1166666666667, 1.52, 0.15
9240, 2.1166666666667, 1.56, 0.15
9241, 1.2833333333333, 1.44, 0.2
9242, 1.2833333333333, 1.48, 0.2
9243, 1.2833333333333, 1.52, 0.2
9244, 1.2833333333333, 1.56, 0.2
9245, 1.3666666666667, 1.44, 0.2
9246, 1.3666666666667, 1.48, 0.2
9247, 1.3666666666667, 1.52, 0.2
9248, 1.3666666666667, 1.56, 0.2
9249, 1.45, 1.44, 0.2
9250, 1.45, 1.48, 0.2
9251, 1.45, 1.52, 0.2
9252, 1.45, 1.56, 0.2
9253, 1.5333333333333, 1.44, 0.2
9254, 1.5333333333333, 1.48, 0.2
9255, 1.5333333333333, 1.52, 0.2
9256, 1.5333333333333, 1.56, 0.2
9257, 1.6166666666667, 1.44, 0.2
9258, 1.6166666666667, 1.48, 0.2
9259, 1.6166666666667, 1.52, 0.2
9260, 1.6166666666667, 1.56, 0.2
9261, 1.7, 1.44, 0.2
9262, 1.7, 1.48, 0.2
9263, 1.7, 1.52, 0.2
9264, 1.7, 1.56, 0.2
9265, 1.7833333333333, 1.44, 0.2
9266, 1.7833333333333, 1.48, 0.2
9267, 1.7833333333333, 1.52, 0.2
9268, 1.7833333333333, 1.56, 0.2
9269, 1.8666666666667, 1.44, 0.2
9270, 1.8666666666667, 1.48, 0.2
9271, 1.8666666666667, 1.52, 0.2
9272, 1.8666666666667, 1.56, 0.2
9273, 1.95, 1.44, 0.2
9274, 1.95, 1.48, 0.2
9275, 1.95, 1.52, 0.2
9276, 1.95, 1.56, 0.2
9277, 2.0333333333333, 1.44, 0.2
9278, 2.0333333333333, 1.48, 0.2
9279, 2.0333333333333, 1.52, 0.2
9280, 2.0333333333333, 1.56, 0.2
9281, 2.1166666666667, 1.44, 0.2
9282, 2.1166666666667, 1.48, 0.2
9283, 2.1166666666667, 1.52, 0.2
9284, 2.1166666666667, 1.56, 0.2
9285, 1.2833333333333, 1.44, 0.25
9286, 1.2833333333333, 1.48, 0.25
9287, 1.2833333333333, 1.52, 0.25
9288, 1.2833333333333, 1.56, 0.25
9289, 1.3666666666667, 1.44, 0.25
9290, 1.3666666666667, 1.48, 0.25
9291, 1.3666666666667, 1.52, 0.25
9292, 1.3666666666667, 1.56, 0.25
9293, 1.45, 1.44, 0.25
9294, 1.45, 1.48, 0.25
9295, 1.45, 1.52, 0.25
9296, 1.45, 1.56, 0.25
9297, 1.5333333333333, 1.44, 0.25
9298, 1.5333333333333, 1.48, 0.25
9299, 1.5333333333333, 1.52, 0.25
9300, 1.5333333333333, 1.56, 0.25
9301, 1.6166666666667, 1.44, 0.25
9302, 1.6166666666667, 1.48, 0.25
9303, 1.6166666666667, 1.52, 0.25
9304, 1.6166666666667, 1.56, 0.25
9305, 1.7, 1.44, 0.25
9306, 1.7, 1.48, 0.25
9307, 1.7, 1.52, 0.25
9308, 1.7, 1.56, 0.25
9309, 1.7833333333333, 1.44, 0.25
9310, 1.7833333333333, 1.48, 0.25
9311, 1.7833333333333, 1.52, 0.25
9312, 1.7833333333333, 1.56, 0.25
9313, 1.8666666666667, 1.44, 0.25
9314, 1.8666666666667, 1.48, 0.25
9315, 1.8666666666667, 1.52, 0.25
9316, 1.8666666666667, 1.56, 0.25
9317, 1.95, 1.44, 0.25
9318, 1.95, 1.48, 0.25
9319, 1.95, 1.52, 0.25
9320, 1.95, 1.56, 0.25
9321, 2.0333333333333, 1.44, 0.25
9322, 2.0333333333333, 1.48, 0.25
9323, 2.0333333333333, 1.52, 0.25
9324, 2.0333333333333, 1.56, 0.25
9325, 2.1166666666667, 1.44, 0.25
9326, 2.1166666666667, 1.48, 0.25
9327, 2.1166666666667, 1.52, 0.25
9328, 2.1166666666667, 1.56, 0.25
9329, 1.2833333333333, 1.44, 0.3
9330, 1.2833333333333, 1.48, 0.3
9331, 1.2833333333333, 1.52, 0.3
9332, 1.2833333333333, 1.56, 0.3
9333, 1.3666666666667, 1.44, 0.3
9334, 1.3666666666667, 1.48, 0.3
9335, 1.3666666666667, 1.52, 0.3
9336, 1.3666666666667, 1.56, 0.3
9337, 1.45, 1.44, 0.3
9338, 1.45, 1.48, 0.3
9339, 1.45, 1.52, 0.3
9340, 1.45, 1.56, 0.3
9341, 1.5333333333333, 1.44, 0.3
9342, 1.5333333333333, 1.48, 0.3
9343, 1.5333333333333, 1.52, 0.3
9344, 1.5333333333333, 1.56, 0.3
9345, 1.6166666666667, 1.44, 0.3
9346, 1.6166666666667, 1.48, 0.3
9347, 1.6166666666667, 1.52, 0.3
9348, 1.6166666666667, 1.56, 0.3
9349, 1.7, 1.44, 0.3
9350, 1.7, 1.48, 0.3
9351, 1.7, 1.52, 0.3
9352, 1.7, 1.56, 0.3
9353, 1.7833333333333, 1.44, 0.3
9354, 1.7833333333333, 1.48, 0.3
9355, 1.7833333333333, 1.52, 0.3
9356, 1.7833333333333, 1.56, 0.3
9357, 1.8666666666667, 1.44, 0.3
9358, 1.8666666666667, 1.48, 0.3
9359, 1.8666666666667, 1.52, 0.3
9360, 1.8666666666667, 1.56, 0.3
9361, 1.95, 1.44, 0.3
9362, 1.95, 1.48, 0.3
9363, 1.95, 1.52, 0.3
9364, 1.95, 1.56, 0.3
9365, 2.0333333333333, 1.44, 0.3
9366, 2.0333333333333, 1.48, 0.3
9367, 2.0333333333333, 1.52, 0.3
9368, 2.0333333333333, 1.56, 0.3
9369, 2.1166666666667, 1.44, 0.3
9370, 2.1166666666667, 1.48, 0.3
9371, 2.1166666666667, 1.52, 0.3
9372, 2.1166666666667, 1.56, 0.3
9373, 1.2833333333333, 1.44, 0.35
9374, 1.2833333333333, 1.48, 0.35
9375, 1.2833333333333, 1.52, 0.35
9376, 1.2833333333333, 1.56, 0.35
9377, 1.3666666666667, 1.44, 0.35
9378, 1.3666666666667, 1.48, 0.35
9379, 1.3666666666667, 1.52, 0.35
9380, 1.3666666666667, 1.56, 0.35
9381, 1.45, 1.44, 0.35
9382, 1.45, 1.48, 0.35
9383, 1.45, 1.52, 0.35
9384, 1.45, 1.56, 0.35
9385, 1.5333333333333, 1.44, 0.35
9386, 1.5333333333333, 1.48, 0.35
9387, 1.5333333333333, 1.52, 0.35
9388, 1.5333333333333, 1.56, 0.35
9389, 1.6166666666667, 1.44, 0.35
9390, 1.6166666666667, 1.48, 0.35
9391, 1.6166666666667, 1.52, 0.35
9392, 1.6166666666667, 1.56, 0.35
9393, 1.7, 1.44, 0.35
9394, 1.7, 1.48, 0.35
9395, 1.7, 1.52, 0.35
9396, 1.7, 1.56, 0.35
9397, 1.7833333333333, 1.44, 0.35
9398, 1.7833333333333, 1.48, 0.35
9399, 1.7833333333333, 1.52, 0.35
9400, 1.7833333333333, 1.56, 0.35
9401, 1.8666666666667, 1.44, 0.35
9402, 1.8666666666667, 1.48, 0.35
9403, 1.8666666666667, 1.52, 0.35
9404, 1.8666666666667, 1.56, 0.35
9405, 1.95, 1.44, 0.35
9406, 1.95, 1.48, 0.35
9407, 1.95, 1.52, 0.35
9408, 1.95, 1.56, 0.35
9409, 2.0333333333333, 1.44, 0.35
9410, 2.0333333333333, 1.48, 0.35
9411, 2.0333333333333, 1.52, 0.35
9412, 2.0333333333333, 1.56, 0.35
9413, 2.1166666666667, 1.44, 0.35
9414, 2.1166666666667, 1.48, 0.35
9415, 2.1166666666667, 1.52, 0.35
9416, 2.1166666666667, 1.56, 0.35
9417, 1.2833333333333, 1.44, 0.4
9418, 1.2833333333333, 1.48, 0.4
9419, 1.2833333333333, 1.52, 0.4
9420, 1.2833333333333, 1.56, 0.4
9421, 1.3666666666667, 1.44, 0.4
9422, 1.3666666666667, 1.48, 0.4
9423, 1.3666666666667, 1.52, 0.4
9424, 1.3666666666667, 1.56, 0.4
9425, 1.45, 1.44, 0.4
9426, 1.45, 1.48, 0.4
9427, 1.45, 1.52, 0.4
9428, 1.45, 1.56, 0.4
9429, 1.5333333333333, 1.44, 0.4
9430, 1.5333333333333, 1.48, 0.4
9431, 1.5333333333333, 1.52, 0.4
9432, 1.5333333333333, 1.56, 0.4
9433, 1.6166666666667, 1.44, 0.4
9434, 1.6166666666667, 1.48, 0.4
9435, 1.6166666666667, 1.52, 0.4
9436, 1.6166666666667, 1.56, 0.4
9437, 1.7, 1.44, 0.4
9438, 1.7, 1.48, 0.4
9439, 1.7, 1.52, 0.4
9440, 1.7, 1.56, 0.4
9441, 1.7833333333333, 1.44, 0.4
9442, 1.7833333333333, 1.48, 0.4
9443, 1.7833333333333, 1.52, 0.4
9444, 1.7833333333333, 1.56, 0.4
9445, 1.8666666666667, 1.44, 0.4
9446, 1.8666666666667, 1.48, 0.4
9447, 1.8666666666667, 1.52, 0.4
9448, 1.8666666666667, 1.56, 0.4
9449, 1.95, 1.44, 0.4
9450, 1.95, 1.48, 0.4
9451, 1.95, 1.52, 0.4
9452, 1.95, 1.56, 0.4
9453, 2.0333333333333, 1.44, 0.4
9454, 2.0333333333333, 1.48, 0.4
9455, 2.0333333333333, 1.52, 0.4
9456, 2.0333333333333, 1.56, 0.4
9457, 2.1166666666667, 1.44, 0.4
9458, 2.1166666666667, 1.48, 0.4
9459, 2.1166666666667, 1.52, 0.4
9460, 2.1166666666667, 1.56, 0.4
9461, 1.2833333333333, 1.44, 0.45
9462, 1.2833333333333, 1.48, 0.45
9463, 1.2833333333333, 1.52, 0.45
9464, 1.2833333333333, 1.56, 0.45
9465, 1.3666666666667, 1.44, 0.45
9466, 1.3666666666667, 1.48, 0.45
9467, 1.3666666666667, 1.52, 0.45
9468, 1.3666666666667, 1.56, 0.45
9469, 1.45, 1.44, 0.45
9470, 1.45, 1.48, 0.45
9471, 1.45, 1.52, 0.45
9472, 1.45, 1.56, 0.45
9473, 1.5333333333333, 1.44, 0.45
9474, 1.5333333333333, 1.48, 0.45
9475, 1.5333333333333, 1.52, 0.45
9476, 1.5333333333333, 1.56, 0.45
9477, 1.6166666666667, 1.44, 0.45
9478, 1.6166666666667, 1.48, 0.45
9479, 1.6166666666667, 1.52, 0.45
9480, 1.6166666666667, 1.56, 0.45
9481, 1.7, 1.44, 0.45
9482, 1.7, 1.48, 0.45
9483, 1.7, 1.52, 0.45
9484, 1.7, 1.56, 0.45
9485, 1.7833333333333, 1.44, 0.45
9486, 1.7833333333333, 1.48, 0.45
9487, 1.7833333333333, 1.52, 0.45
9488, 1.7833333333333, 1.56, 0.45
9489, 1.8666666666667, 1.44, 0.45
9490, 1.8666666666667, 1.48, 0.45
9491, 1.8666666666667, 1.52, 0.45
9492, 1.8666666666667, 1.56, 0.45
9493, 1.95, 1.44, 0.45
9494, 1.95, 1.48, 0.45
9495, 1.95, 1.52, 0.45
9496, 1.95, 1.56, 0.45
9497, 2.0333333333333, 1.44, 0.45
9498, 2.0333333333333, 1.48, 0.45
9499, 2.0333333333333, 1.52, 0.45
9500, 2.0333333333333, 1.56, 0.45
9501, 2.1166666666667, 1.44, 0.45
9502, 2.1166666666667, 1.48, 0.45
9503, 2.1166666666667, 1.52, 0.45
9504, 2.1166666666667, 1.56, 0.45
9505, 0.083333333333333, -0.04, 0.05
9506, 0.083333333333333, -0.08, 0.05
9507, 0.083333333333333, -0.12, 0.05
9508, 0.083333333333333, -0.16, 0.05
9509, 0.083333333333333, -0.04, 0.1
9510, 0.083333333333333, -0.08, 0.1
9511, 0.083333333333333, -0.12, 0.1
9512, 0.083333333333333, -0.16, 0.1
9513, 0.083333333333333, -0.04, 0.15
9514, 0.083333333333333, -0.08, 0.15
9515, 0.083333333333333, -0.12, 0.15
9516, 0.083333333333333, -0.16, 0.15
9517, 0.083333333333333, -0.04, 0.2
9518, 0.083333333333333, -0.08, 0.2
9519, 0.083333333333333, -0.12, 0.2
9520, 0.083333333333333, -0.16, 0.2
9521, 0.083333333333333, -0.04, 0.25
9522, 0.083333333333333, -0.08, 0.25
9523, 0.083333333333333, -0.12, 0.25
9524, 0.083333333333333, -0.16, 0.25
9525, 0.083333333333333, -0.04, 0.3
9526, 0.083333333333333, -0.08, 0.3
9527, 0.083333333333333, -0.12, 0.3
9528, 0.083333333333333, -0.16, 0.3
9529, 0.083333333333333, -0.04, 0.35
9530, 0.083333333333333, -0.08, 0.35
9531, 0.083333333333333, -0.12, 0.35
9532, 0.083333333333333, -0.16, 0.35
9533, 0.083333333333333, -0.04, 0.4
9534, 0.083333333333333, -0.08, 0.4
9535, 0.083333333333333, -0.12, 0.4
9536, 0.083333333333333, -0.16, 0.4
9537, 0.083333333333333, -0.04, 0.45
9538, 0.083333333333333, -0.08, 0.45
9539, 0.083333333333333, -0.12, 0.45
9540, 0.083333333333333, -0.16, 0.45
9541, 0.16666666666667, -0.04, 0.05
9542, 0.16666666666667, -0.08, 0.05
9543, 0.16666666666667, -0.12, 0.05
9544, 0.16666666666667, -0.16, 0.05
9545, 0.16666666666667, -0.04, 0.1
9546, 0.16666666666667, -0.08, 0.1
9547, 0.16666666666667, -0.12, 0.1
9548, 0.16666666666667, -0.16, 0.1
9549, 0.16666666666667, -0.04, 0.15
9550, 0.16666666666667, -0.08, 0.15
9551, 0.16666666666667, -0.12, 0.15
9552, 0.16666666666667, -0.16, 0.15
9553, 0.16666666666667, -0.04, 0.2
9554, 0.16666666666667, -0.08, 0.2
9555, 0.16666666666667, -0.12, 0.2
9556, 0.16666666666667, -0.16, 0.2
9557, 0.16666666666667, -0.04, 0.25
9558, 0.16666666666667, -0.08, 0.25
9559, 0.16666666666667, -0.12, 0.25
9560, 0.16666666666667, -0.16, 0.25
9561, 0.16666666666667, -0.04, 0.3
9562, 0.16666666666667, -0.08, 0.3
9563, 0.16666666666667, -0.12, 0.3
9564, 0.16666666666667, -0.16, 0.3
9565, 0.16666666666667, -0.04, 0.35
9566, 0.16666666666667, -0.08, 0.35
9567, 0.16666666666667, -0.12, 0.35
9568, 0.16666666666667, -0.16, 0.35
9569, 0.16666666666667, -0.04, 0.4
9570, 0.16666666666667, -0.08, 0.4
9571, 0.16666666666667, -0.12, 0.4
9572, 0.16666666666667, -0.16, 0.4
9573, 0.16666666666667, -0.04, 0.45
9574, 0.16666666666667, -0.08, 0.45
9575, 0.16666666666667, -0.12, 0.45
9576, 0.16666666666667, -0.16, 0.45
9577, 0.25, -0.04, 0.05
9578, 0.25, -0.08, 0.05
9579, 0.25, -0.12, 0.05
9580, 0.25, -0.16, 0.05
9581, 0.25, -0.04, 0.1
9582, 0.25, -0.08, 0.1
9583, 0.25, -0.12, 0.1
9584, 0.25, -0.16, 0.1
9585, 0.25, -0.04, 0.15
9586, 0.25, -0.08, 0.15
9587, 0.25, -0.12, 0.15
9588, 0.25, -0.16, 0.15
9589, 0.25, -0.04, 0.2
9590, 0.25, -0.08, 0.2
9591, 0.25, -0.12, 0.2
9592, 0.25, -0.16, 0.2
9593, 0.25, -0.04, 0.25
9594, 0.25, -0.08, 0.25
9595, 0.25, -0.12, 0.25
9596, 0.25, -0.16, 0.25
9597, 0.25, -0.04, 0.3
9598, 0.25, -0.08, 0.3
9599, 0.25, -0.12, 0.3
9600, 0.25, -0.16, 0.3
9601, 0.25, -0.04, 0.35
9602, 0.25, -0.08, 0.35
9603, 0.25, -0.12, 0.35
9604, 0.25, -0.16, 0.35
9605, 0.25, -0.04, 0.4
9606, 0.25, -0.08, 0.4
9607, 0.25, -0.12, 0.4
9608, 0.25, -0.16, 0.4
9609, 0.25, -0.04, 0.45
9610, 0.25, -0.08, 0.45
9611, 0.25, -0.12, 0.45
9612, 0.25, -0.16, 0.45
9613, 0.33333333333333, -0.04, 0.05
9614, 0.33333333333333, -0.08, 0.05
9615, 0.33333333333333, -0.12, 0.05
9616, 0.33333333333333, -0.16, 0.05
9617, 0.33333333333333, -0.04, 0.1
9618, 0.33333333333333, -0.08, 0.1
9619, 0.33333333333333, -0.12, 0.1
9620, 0.33333333333333, -0.16, 0.1
9621, 0.33333333333333, -0.04, 0.15
9622, 0.33333333333333, -0.08, 0.15
9623, 0.33333333333333, -0.12, 0.15
9624, 0.33333333333333, -0.16, 0.15
9625, 0.33333333333333, -0.04, 0.2
9626, 0.33333333333333, -0.08, 0.2
9627, 0.33333333333333, -0.12, 0.2
9628, 0.33333333333333, -0.16, 0.2
9629, 0.33333333333333, -0.04, 0.25
9630, 0.33333333333333, -0.08, 0.25
9631, 0.33333333333333, -0.12, 0.25
9632, 0.33333333333333, -0.16, 0.25
9633, 0.33333333333333, -0.04, 0.3
9634, 0.33333333333333, -0.08, 0.3
9635, 0.33333333333333, -0.12, 0.3
9636, 0.33333333333333, -0.16, 0.3
9637, 0.33333333333333, -0.04, 0.35
9638, 0.33333333333333, -0.08, 0.35
9639, 0.33333333333333, -0.12, 0.35
9640, 0.33333333333333, -0.16, 0.35
9641, 0.33333333333333, -0.04, 0.4
9642, 0.33333333333333, -0.08, 0.4
9643, 0.33333333333333, -0.12, 0.4
9644, 0.33333333333333, -0.16, 0.4
9645, 0.33333333333333, -0.04, 0.45
9646, 0.33333333333333, -0.08, 0.45
9647, 0.33333333333333, -0.12, 0.45
9648, 0.33333333333333, -0.16, 0.45
9649, 0.41666666666667, -0.04, 0.05
9650, 0.41666666666667, -0.08, 0.05
9651, 0.41666666666667, -0.12, 0.05
9652, 0.41666666666667, -0.16, 0.05
9653, 0.41666666666667, -0.04, 0.1
9654, 0.41666666666667, -0.08, 0.1
9655, 0.41666666666667, -0.12, 0.1
9656, 0.41666666666667, -0.16, 0.1
9657, 0.41666666666667, -0.04, 0.15
9658, 0.41666666666667, -0.08, 0.15
9659, 0.41666666666667, -0.12, 0.15
9660, 0.41666666666667, -0.16, 0.15
9661, 0.41666666666667, -0.04, 0.2
9662, 0.41666666666667, -0.08, 0.2
9663, 0.41666666666667, -0.12, 0.2
9664, 0.41666666666667, -0.16, 0.2
9665, 0.41666666666667, -0.04, 0.25
9666, 0.41666666666667, -0.08, 0.25
9667, 0.41666666666667, -0.12, 0.25
9668, 0.41666666666667, -0.16, 0.25
9669, 0.41666666666667, -0.04, 0.3
9670, 0.41666666666667, -0.08, 0.3
9671, 0.41666666666667, -0.12, 0.3
9672, 0.41666666666667, -0.16, 0.3
9673, 0.41666666666667, -0.04, 0.35
9674, 0.41666666666667, -0.08, 0.35
9675, 0.41666666666667, -0.12, 0.35
9676, 0.41666666666667, -0.16, 0.35
9677, 0.41666666666667, -0.04, 0.4
9678, 0.41666666666667, -0.08, 0.4
9679, 0.41666666666667, -0.12, 0.4
9680, 0.41666666666667, -0.16, 0.4
9681, 0.41666666666667, -0.04, 0.45
9682, 0.41666666666667, -0.08, 0.45
9683, 0.41666666666667, -0.12, 0.45
9684, 0.41666666666667, -0.16, 0.45
9685, 0.5, -0.04, 0.05
9686, 0.5, -0.08, 0.05
9687, 0.5, -0.12, 0.05
9688, 0.5, -0.16, 0.05
9689, 0.5, -0.04, 0.1
9690, 0.5, -0.08, 0.1
9691, 0.5, -0.12, 0.1
9692, 0.5, -0.16, 0.1
9693, 0.5, -0.04, 0.15
9694, 0.5, -0.08, 0.15
9695, 0.5, -0.12, 0.15
9696, 0.5, -0.16, 0.15
9697, 0.5, -0.04, 0.2
9698, 0.5, -0.08, 0.2
9699, 0.5, -0.12, 0.2
9700, 0.5, -0.16, 0.2
9701, 0.5, -0.04, 0.25
9702, 0.5, -0.08, 0.25
9703, 0.5, -0.12, 0.25
9704, 0.5, -0.16, 0.25
9705, 0.5, -0.04, 0.3
9706, 0.5, -0.08, 0.3
9707, 0.5, -0.12, 0.3
9708, 0.5, -0.16, 0.3
9709, 0.5, -0.04, 0.35
9710, 0.5, -0.08, 0.35
9711, 0.5, -0.12, 0.35
9712, 0.5, -0.16, 0.35
9713, 0.5, -0.04, 0.4
9714, 0.5, -0.08, 0.4
9715, 0.5, -0.12, 0.4
9716, 0.5, -0.16, 0.4
9717, 0.5, -0.04, 0.45
9718, 0.5, -0.08, 0.45
9719, 0.5, -0.12, 0.45
9720, 0.5, -0.16, 0.45
9721, 0.58333333333333, -0.04, 0.05
9722, 0.58333333333333, -0.08, 0.05
9723, 0.58333333333333, -0.12, 0.05
9724, 0.58333333333333, -0.16, 0.05
9725, 0.58333333333333, -0.04, 0.1
9726, 0.58333333333333, -0.08, 0.1
9727, 0.58333333333333, -0.12, 0.1
9728, 0.58333333333333, -0.16, 0.1
9729, 0.58333333333333, -0.04, 0.15
9730, 0.58333333333333, -0.08, 0.15
9731, 0.58333333333333, -0.12, 0.15
9732, 0.58333333333333, -0.16, 0.15
9733, 0.58333333333333, -0.04, 0.2
9734, 0.58333333333333, -0.08, 0.2
9735, 0.58333333333333, -0.12, 0.2
9736, 0.58333333333333, -0.16, 0.2
9737, 0.58333333333333, -0.04, 0.25
9738, 0.58333333333333, -0.08, 0.25
9739, 0.58333333333333, -0.12, 0.25
9740, 0.58333333333333, -0.16, 0.25
9741, 0.58333333333333, -0.04, 0.3
9742, 0.58333333333333, -0.08, 0.3
9743, 0.58333333333333, -0.12, 0.3
9744, 0.58333333333333, -0.16, 0.3
9745, 0.58333333333333, -0.04, 0.35
9746, 0.58333333333333, -0.08, 0.35
9747, 0.58333333333333, -0.12, 0.35
9748, 0.58333333333333, -0.16, 0.35
9749, 0.58333333333333, -0.04, 0.4
9750, 0.58333333333333, -0.08, 0.4
9751, 0.58333333333333, -0.12, 0.4
9752, 0.58333333333333, -0.16, 0.4
9753, 0.58333333333333, -0.04, 0.45
9754, 0.58333333333333, -0.08, 0.45
9755, 0.58333333333333, -0.12, 0.45
9756, 0.58333333333333, -0.16, 0.45
9757, 0.66666666666667, -0.04, 0.05
9758, 0.66666666666667, -0.08, 0.05
9759, 0.66666666666667, -0.12, 0.05
9760, 0.66666666666667, -0.16, 0.05
9761, 0.66666666666667, -0.04, 0.1
9762, 0.66666666666667, -0.08, 0.1
9763, 0.66666666666667, -0.12, 0.1
9764, 0.66666666666667, -0.16, 0.1
9765, 0.66666666666667, -0.04, 0.15
9766, 0.66666666666667, -0.08, 0.15
9767, 0.66666666666667, -0.12, 0.15
9768, 0.66666666666667, -0.16, 0.15
9769, 0.66666666666667, -0.04, 0.2
9770, 0.66666666666667, -0.08, 0.2
9771, 0.66666666666667, -0.12, 0.2
9772, 0.66666666666667, -0.16, 0.2
9773, 0.66666666666667, -0.04, 0.25
9774, 0.66666666666667, -0.08, 0.25
9775, 0.66666666666667, -0.12, 0.25
9776, 0.66666666666667, -0.16, 0.25
9777, 0.66666666666667, -0.04, 0.3
9778, 0.66666666666667, -0.08, 0.3
9779, 0.66666666666667, -0.12, 0.3
9780, 0.66666666666667, -0.16, 0.3
9781, 0.66666666666667, -0.04, 0.35
9782, 0.66666666666667, -0.08, 0.35
9783, 0.66666666666667, -0.12, 0.35
9784, 0.66666666666667, -0.16, 0.35
9785, 0.66666666666667, -0.04, 0.4
9786, 0.66666666666667, -0.08, 0.4
9787, 0.66666666666667, -0.12, 0.4
9788, 0.66666666666667, -0.16, 0.4
9789, 0.66666666666667, -0.04, 0.45
9790, 0.66666666666667, -0.08, 0.45
9791, 0.66666666666667, -0.12, 0.45
9792, 0.66666666666667, -0.16, 0.45
9793, 0.75, -0.04, 0.05
9794, 0.75, -0.08, 0.05
9795, 0.75, -0.12, 0.05
9796, 0.75, -0.16, 0.05
9797, 0.75, -0.04, 0.1
9798, 0.75, -0.08, 0.1
9799, 0.75, -0.12, 0.1
9800, 0.75, -0.16, 0.1
9801, 0.75, -0.04, 0.15
9802, 0.75, -0.08, 0.15
9803, 0.75, -0.12, 0.15
9804, 0.75, -0.16, 0.15
9805, 0.75, -0.04, 0.2
9806, 0.75, -0.08, 0.2
9807, 0.75, -0.12, 0.2
9808, 0.75, -0.16, 0.2
9809, 0.75, -0.04, 0.25
9810, 0.75, -0.08, 0.25
9811, 0.75, -0.12, 0.25
9812, 0.75, -0.16, 0.25
9813, 0.75, -0.04, 0.3
9814, 0.75, -0.08, 0.3
9815, 0.75, -0.12, 0.3
9816, 0.75, -0.16, 0.3
9817, 0.75, -0.04, 0.35
9818, 0.75, -0.08, 0.35
9819, 0.75, -0.12, 0.35
9820, 0.75, -0.16, 0.35
9821, 0.75, -0.04, 0.4
9822, 0.75, -0.08, 0.4
9823, 0.75, -0.12, 0.4
9824, 0.75, -0.16, 0.4
9825, 0.75, -0.04, 0.45
9826, 0.75, -0.08, 0.45
9827, 0.75, -0.12, 0.45
9828, 0.75, -0.16, 0.45
9829, 0.83333333333333, -0.04, 0.05
9830, 0.83333333333333, -0.08, 0.05
9831, 0.83333333333333, -0.12, 0.05
9832, 0.83333333333333, -0.16, 0.05
9833, 0.83333333333333, -0.04, 0.1
9834, 0.83333333333333, -0.08, 0.1
9835, 0.83333333333333, -0.12, 0.1
9836, 0.83333333333333, -0.16, 0.1
9837, 0.83333333333333, -0.04, 0.15
9838, 0.83333333333333, -0.08, 0.15
9839, 0.83333333333333, -0.12, 0.15
9840, 0.83333333333333, -0.16, 0.15
9841, 0.83333333333333, -0.04, 0.2
9842, 0.83333333333333, -0.08, 0.2
9843, 0.83333333333333, -0.12, 0.2
9844, 0.83333333333333, -0.16, 0.2
9845, 0.83333333333333, -0.04, 0.25
9846, 0.83333333333333, -0.08, 0.25
9847, 0.83333333333333, -0.12, 0.25
9848, 0.83333333333333, -0.16, 0.25
9849, 0.83333333333333, -0.04, 0.3
9850, 0.83333333333333, -0.08, 0.3
9851, 0.83333333333333, -0.12, 0.3
9852, 0.83333333333333, -0.16, 0.3
9853, 0.83333333333333, -0.04, 0.35
9854, 0.83333333333333, -0.08, 0.35
9855, 0.83333333333333, -0.12, 0.35
9856, 0.83333333333333, -0.16, 0.35
9857, 0.83333333333333, -0.04, 0.4
9858, 0.83333333333333, -0.08, 0.4
9859, 0.83333333333333, -0.12, 0.4
9860, 0.83333333333333, -0.16, 0.4
9861, 0.83333333333333, -0.04, 0.45
9862, 0.83333333333333, -0.08, 0.45
9863, 0.83333333333333, -0.12, 0.45
9864, 0.83333333333333, -0.16, 0.45
9865, 0.91666666666667, -0.04, 0.05
9866, 0.91666666666667, -0.08, 0.05
9867, 0.91666666666667, -0.12, 0.05
9868, 0.91666666666667, -0.16, 0.05
9869, 0.91666666666667, -0.04, 0.1
9870, 0.91666666666667, -0.08, 0.1
9871, 0.91666666666667, -0.12, 0.1
9872, 0.91666666666667, -0.16, 0.1
9873, 0.91666666666667, -0.04, 0.15
9874, 0.91666666666667, -0.08, 0.15
9875, 0.91666666666667, -0.12, 0.15
9876, 0.91666666666667, -0.16, 0.15
9877, 0.91666666666667, -0.04, 0.2
9878, 0.91666666666667, -0.08, 0.2
9879, 0.91666666666667, -0.12, 0.2
9880, 0.91666666666667, -0.16, 0.2
9881, 0.91666666666667, -0.04, 0.25
9882, 0.91666666666667, -0.08, 0.25
9883, 0.91666666666667, -0.12, 0.25
9884, 0.91666666666667, -0.16, 0.25
9885, 0.91666666666667, -0.04, 0.3
9886, 0.91666666666667, -0.08, 0.3
9887, 0.91666666666667, -0.12, 0.3
9888, 0.91666666666667, -0.16, 0.3
9889, 0.91666666666667, -0.04, 0.35
9890, 0.91666666666667, -0.08, 0.35
9891, 0.91666666666667, -0.12, 0.35
9892, 0.91666666666667, -0.16, 0.35
9893, 0.91666666666667, -0.04, 0.4
9894, 0.91666666666667, -0.08, 0.4
9895, 0.91666666666667, -0.12, 0.4
9896, 0.91666666666667, -0.16, 0.4
9897, 0.91666666666667, -0.04, 0.45
9898, 0.91666666666667, -0.08, 0.45
9899, 0.91666666666667, -0.12, 0.45
9900, 0.91666666666667, -0.16, 0.45
9901, 1.2833333333333, -0.04, 0.05
9902, 1.2833333333333, -0.08, 0.05
9903, 1.2833333333333, -0.12, 0.05
9904, 1.2833333333333, -0.16, 0.05
9905, 1.3666666666667, -0.04, 0.05
9906, 1.3666666666667, -0.08, 0.05
9907, 1.3666666666667, -0.12, 0.05
9908, 1.3666666666667, -0.16, 0.05
9909, 1.45, -0.04, 0.05
9910, 1.45, -0.08, 0.05
9911, 1.45, -0.12, 0.05
9912, 1.45, -0.16, 0.05
9913, 1.5333333333333, -0.04, 0.05
9914, 1.5333333333333, -0.08, 0.05
9915, 1.5333333333333, -0.12, 0.05
9916, 1.5333333333333, -0.16, 0.05
9917, 1.6166666666667, -0.04, 0.05
9918, 1.6166666666667, -0.08, 0.05
9919, 1.6166666666667, -0.12, 0.05
9920, 1.6166666666667, -0.16, 0.05
9921, 1.7, -0.04, 0.05
9922, 1.7, -0.08, 0.05
9923, 1.7, -0.12, 0.05
9924, 1.7, -0.16, 0.05
9925, 1.7833333333333, -0.04, 0.05
9926, 1.7833333333333, -0.08, 0.05
9927, 1.7833333333333, -0.12, 0.05
9928, 1.7833333333333, -0.16, 0.05
9929, 1.8666666666667, -0.04, 0.05
9930, 1.8666666666667, -0.08, 0.05
9931, 1.8666666666667, -0.12, 0.05
9932, 1.8666666666667, -0.16, 0.05
9933, 1.95, -0.04, 0.05
9934, 1.95, -0.08, 0.05
9935, 1.95, -0.12, 0.05
9936, 1.95, -0.16, 0.05
9937, 2.0333333333333, -0.04, 0.05
9938, 2.0333333333333, -0.08, 0.05
9939, 2.0333333333333, -0.12, 0.05
9940, 2.0333333333333, -0.16, 0.05
9941, 2.1166666666667, -0.04, 0.05
9942, 2.1166666666667, -0.08, 0.05
9943, 2.1166666666667, -0.12, 0.05
9944, 2.1166666666667, -0.16, 0.05
9945, 1.2833333333333, -0.04, 0.1
9946, 1.2833333333333, -0.08, 0.1
9947, 1.2833333333333, -0.12, 0.1
9948, 1.2833333333333, -0.16, 0.1
9949, 1.3666666666667, -0.04, 0.1
9950, 1.3666666666667, -0.08, 0.1
9951, 1.3666666666667, -0.12, 0.1
9952, 1.3666666666667, -0.16, 0.1
9953, 1.45, -0.04, 0.1
9954, 1.45, -0.08, 0.1
9955, 1.45, -0.12, 0.1
9956, 1.45, -0.16, 0.1
9957, 1.5333333333333, -0.04, 0.1
9958, 1.5333333333333, -0.08, 0.1
9959, 1.5333333333333, -0.12, 0.1
9960, 1.5333333333333, -0.16, 0.1
9961, 1.6166666666667, -0.04, 0.1
9962, 1.6166666666667, -0.08, 0.1
9963, 1.6166666666667, -0.12, 0.1
9964, 1.6166666666667, -0.16, 0.1
9965, 1.7, -0.04, 0.1
9966, 1.7, -0.08, 0.1
9967, 1.7, -0.12, 0.1
9968, 1.7, -0.16, 0.1
9969, 1.7833333333333, -0.04, 0.1
9970, 1.7833333333333, -0.08, 0.1
9971, 1.7833333333333, -0.12, 0.1
9972, 1.7833333333333, -0.16, 0.1
9973, 1.8666666666667, -0.04, 0.1
9974, 1.8666666666667, -0.08, 0.1
9975, 1.8666666666667, -0.12, 0.1
9976, 1.8666666666667, -0.16, 0.1
9977, 1.95, -0.04, 0.1
9978, 1.95, -0.08, 0.1
9979, 1.95, -0.12, 0.1
9980, 1.95, -0.16, 0.1
9981, 2.0333333333333, -0.04, 0.1
9982, 2.0333333333333, -0.08, 0.1
9983, 2.0333333333333, -0.12, 0.1
9984, 2.0333333333333, -0.16, 0.1
9985, 2.1166666666667, -0.04, 0.1
9986, 2.1166666666667, -0.08, 0.1
9987, 2.1166666666667, -0.12, 0.1
9988, 2.1166666666667, -0.16, 0.1
9989, 1.2833333333333, -0.04, 0.15
9990, 1.2833333333333, -0.08, 0.15
9991, 1.2833333333333, -0.12, 0.15
9992, 1.2833333333333, -0.16, 0.15
9993, 1.3666666666667, -0.04, 0.15
9994, 1.3666666666667, -0.08, 0.15
9995, 1.3666666666667, -0.12, 0.15
9996, 1.3666666666667, -0.16, 0.15
9997, 1.45, -0.04, 0.15
9998, 1.45, -0.08, 0.15
9999, 1.45, -0.12, 0.15
10000, 1.45, -0.16, 0.15
10001, 1.5333333333333, -0.04, 0.15
10002, 1.5333333333333, -0.08, 0.15
10003, 1.5333333333333, -0.12, 0.15
10004, 1.5333333333333, -0.16, 0.15
10005, 1.6166666666667, -0.04, 0.15
10006, 1.6166666666667, -0.08, 0.15
10007, 1.6166666666667, -0.12, 0.15
10008, 1.6166666666667, -0.16, 0.15
10009, 1.7, -0.04, 0.15
10010, 1.7, -0.08, 0.15
10011, 1.7, -0.12, 0.15
10012, 1.7, -0.16, 0.15
10013, 1.7833333333333, -0.04, 0.15
10014, 1.7833333333333, -0.08, 0.15
10015, 1.7833333333333, -0.12, 0.15
10016, 1.7833333333333, -0.16, 0.15
10017, 1.8666666666667, -0.04, 0.15
10018, 1.8666666666667, -0.08, 0.15
10019, 1.8666666666667, -0.12, 0.15
10020, 1.8666666666667, -0.16, 0.15
10021, 1.95, -0.04, 0.15
10022, 1.95, -0.08, 0.15
10023, 1.95, -0.12, 0.15
10024, 1.95, -0.16, 0.15
10025, 2.0333333333333, -0.04, 0.15
10026, 2.0333333333333, -0.08, 0.15
10027, 2.0333333333333, -0.12, 0.15
10028, 2.0333333333333, -0.16, 0.15
10029, 2.1166666666667, -0.04, 0.15
10030, 2.1166666666667, -0.08, 0.15
10031, 2.1166666666667, -0.12, 0.15
10032, 2.1166666666667, -0.16, 0.15
10033, 1.2833333333333, -0.04, 0.2
10034, 1.2833333333333, -0.08, 0.2
10035, 1.2833333333333, -0.12, 0.2
10036, 1.2833333333333, -0.16, 0.2
10037, 1.3666666666667, -0.04, 0.2
10038, 1.3666666666667, -0.08, 0.2
10039, 1.3666666666667, -0.12, 0.2
10040, 1.3666666666667, -0.16, 0.2
10041, 1.45, -0.04, 0.2
10042, 1.45, -0.08, 0.2
10043, 1.45, -0.12, 0.2
10044, 1.45, -0.16, 0.2
10045, 1.5333333333333, -0.04, 0.2
10046, 1.5333333333333, -0.08, 0.2
10047, 1.5333333333333, -0.12, 0.2
10048, 1.5333333333333, -0.16, 0.2
10049, 1.6166666666667, -0.04, 0.2
10050, 1.6166666666667, -0.08, 0.2
10051, 1.6166666666667, -0.12, 0.2
10052, 1.6166666666667, -0.16, 0.2
10053, 1.7, -0.04, 0.2
10054, 1.7, -0.08, 0.2
10055, 1.7, -0.12, 0.2
10056, 1.7, -0.16, 0.2
10057, 1.7833333333333, -0.04, 0.2
10058, 1.7833333333333, -0.08, 0.2
10059, 1.7833333333333, -0.12, 0.2
10060, 1.7833333333333, -0.16, 0.2
10061, 1.8666666666667, -0.04, 0.2
10062, 1.8666666666667, -0.08, 0.2
10063, 1.8666666666667, -0.12, 0.2
10064, 1.8666666666667, -0.16, 0.2
10065, 1.95, -0.04, 0.2
10066, 1.95, -0.08, 0.2
10067, 1.95, -0.12, 0.2
10068, 1.95, -0.16, 0.2
10069, 2.0333333333333, -0.04, 0.2
10070, 2.0333333333333, -0.08, 0.2
10071, 2.0333333333333, -0.12, 0.2
10072, 2.0333333333333, -0.16, 0.2
10073, 2.1166666666667, -0.04, 0.2
10074, 2.1166666666667, -0.08, 0.2
10075, 2.1166666666667, -0.12, 0.2
10076, 2.1166666666667, -0.16, 0.2
10077, 1.2833333333333, -0.04, 0.25
10078, 1.2833333333333, -0.08, 0.25
10079, 1.2833333333333, -0.12, 0.25
10080, 1.2833333333333, -0.16, 0.25
10081, 1.3666666666667, -0.04, 0.25
10082, 1.3666666666667, -0.08, 0.25
10083, 1.3666666666667, -0.12, 0.25
10084, 1.3666666666667, -0.16, 0.25
10085, 1.45, -0.04, 0.25
10086, 1.45, -0.08, 0.25
10087, 1.45, -0.12, 0.25
10088, 1.45, -0.16, 0.25
10089, 1.5333333333333, -0.04, 0.25
10090, 1.5333333333333, -0.08, 0.25
10091, 1.5333333333333, -0.12, 0.25
10092, 1.5333333333333, -0.16, 0.25
10093, 1.6166666666667, -0.04, 0.25
10094, 1.6166666666667, -0.08, 0.25
10095, 1.6166666666667, -0.12, 0.25
10096, 1.6166666666667, -0.16, 0.25
10097, 1.7, -0.04, 0.25
10098, 1.7, -0.08, 0.25
10099, 1.7, -0.12, 0.25
10100, 1.7, -0.16, 0.25
10101, 1.7833333333333, -0.04, 0.25
10102, 1.7833333333333, -0.08, 0.25
10103, 1.7833333333333, -0.12, 0.25
10104, 1.7833333333333, -0.16, 0.25
10105, 1.8666666666667, -0.04, 0.25
10106, 1.8666666666667, -0.08, 0.25
10107, 1.8666666666667, -0.12, 0.25
10108, 1.8666666666667, -0.16, 0.25
10109, 1.95, -0.04, 0.25
10110, 1.95, -0.08, 0.25
10111, 1.95, -0.12, 0.25
10112, 1.95, -0.16, 0.25
10113, 2.0333333333333, -0.04, 0.25
10114, 2.0333333333333, -0.08, 0.25
10115, 2.0333333333333, -0.12, 0.25
10116, 2.0333333333333, -0.16, 0.25
10117, 2.1166666666667, -0.04, 0.25
10118, 2.1166666666667, -0.08, 0.25
10119, 2.1166666666667, -0.12, 0.25
10120, 2.1166666666667, -0.16, 0.25
10121, 1.2833333333333, -0.04, 0.3
10122, 1.2833333333333, -0.08, 0.3
10123, 1.2833333333333, -0.12, 0.3
10124, 1.2833333333333, -0.16, 0.3
10125, 1.3666666666667, -0.04, 0.3
10126, 1.3666666666667, -0.08, 0.3
10127, 1.3666666666667, -0.12, 0.3
10128, 1.3666666666667, -0.16, 0.3
10129, 1.45, -0.04, 0.3
10130, 1.45, -0.08, 0.3
10131, 1.45, -0.12, 0.3
10132, 1.45, -0.16, 0.3
10133, 1.5333333333333, -0.04, 0.3
10134, 1.5333333333333, -0.08, 0.3
10135, 1.5333333333333, -0.12, 0.3
10136, 1.5333333333333, -0.16, 0.3
10137, 1.6166666666667, -0.04, 0.3
10138, 1.6166666666667, -0.08, 0.3
10139, 1.6166666666667, -0.12, 0.3
10140, 1.6166666666667, -0.16, 0.3
10141, 1.7, -0.04, 0.3
10142, 1.7, -0.08, 0.3
10143, 1.7, -0.12, 0.3
10144, 1.7, -0.16, 0.3
10145, 1.7833333333333, -0.04, 0.3
10146, 1.7833333333333, -0.08, 0.3
10147, 1.7833333333333, -0.12, 0.3
10148, 1.7833333333333, -0.16, 0.3
10149, 1.8666666666667, -0.04, 0.3
10150, 1.8666666666667, -0.08, 0.3
10151, 1.8666666666667, -0.12, 0.3
10152, 1.8666666666667, -0.16, 0.3
10153, 1.95, -0.04, 0.3
10154, 1.95, -0.08, 0.3
10155, 1.95, -0.12, 0.3
10156, 1.95, -0.16, 0.3
10157, 2.0333333333333, -0.04, 0.3
10158, 2.0333333333333, -0.08, 0.3
10159, 2.0333333333333, -0.12, 0.3
10160, 2.0333333333333, -0.16, 0.3
10161, 2.1166666666667, -0.04, 0.3
10162, 2.1166666666667, -0.08, 0.3
10163, 2.1166666666667, -0.12, 0.3
10164, 2.1166666666667, -0.16, 0.3
10165, 1.2833333333333, -0.04, 0.35
10166, 1.2833333333333, -0.08, 0.35
10167, 1.2833333333333, -0.12, 0.35
10168, 1.2833333333333, -0.16, 0.35
10169, 1.3666666666667, -0.04, 0.35
10170, 1.3666666666667, -0.08, 0.35
10171, 1.3666666666667, -0.12, 0.35
10172, 1.3666666666667, -0.16, 0.35
10173, 1.45, -0.04, 0.35
10174, 1.45, -0.08, 0.35
10175, 1.45, -0.12, 0.35
10176, 1.45, -0.16, 0.35
10177, 1.5333333333333, -0.04, 0.35
10178, 1.5333333333333, -0.08, 0.35
10179, 1.5333333333333, -0.12, 0.35
10180, 1.5333333333333, -0.16, 0.35
10181, 1.6166666666667, -0.04, 0.35
10182, 1.6166666666667, -0.08, 0.35
10183, 1.6166666666667, -0.12, 0.35
10184, 1.6166666666667, -0.16, 0.35
10185, 1.7, -0.04, 0.35
10186, 1.7, -0.08, 0.35
10187, 1.7, -0.12, 0.35
10188, 1.7, -0.16, 0.35
10189, 1.7833333333333, -0.04, 0.35
10190, 1.7833333333333, -0.08, 0.35
10191, 1.7833333333333, -0.12, 0.35
10192, 1.7833333333333, -0.16, 0.35
10193, 1.8666666666667, -0.04, 0.35
10194, 1.8666666666667, -0.08, 0.35
10195, 1.8666666666667, -0.12, 0.35
10196, 1.8666666666667, -0.16, 0.35
10197, 1.95, -0.04, 0.35
10198, 1.95, -0.08, 0.35
10199, 1.95, -0.12, 0.35
10200, 1.95, -0.16, 0.35
10201, 2.0333333333333, -0.04, 0.35
10202, 2.0333333333333, -0.08, 0.35
10203, 2.0333333333333, -0.12, 0.35
10204, 2.0333333333333, -0.16, 0.35
10205, 2.1166666666667, -0.04, 0.35
10206, 2.1166666666667, -0.08, 0.35
10207, 2.1166666666667, -0.12, 0.35
10208, 2.1166666666667, -0.16, 0.35
10209, 1.2833333333333, -0.04, 0.4
10210, 1.2833333333333, -0.08, 0.4
10211, 1.2833333333333, -0.12, 0.4
10212, 1.2833333333333, -0.16, 0.4
10213, 1.3666666666667, -0.04, 0.4
10214, 1.3666666666667, -0.08, 0.4
10215, 1.3666666666667, -0.12, 0.4
10216, 1.3666666666667, -0.16, 0.4
10217, 1.45, -0.04, 0.4
10218, 1.45, -0.08, 0.4
10219, 1.45, -0.12, 0.4
10220, 1.45, -0.16, 0.4
10221, 1.5333333333333, -0.04, 0.4
10222, 1.5333333333333, -0.08, 0.4
10223, 1.5333333333333, -0.12, 0.4
10224, 1.5333333333333, -0.16, 0.4
10225, 1.6166666666667, -0.04, 0.4
