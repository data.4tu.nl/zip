7323, 1215, 99, 98, 1212, 5431, 1265, 1264, 5398
7324, 5431, 1265, 1264, 5398, 5432, 1274, 1273, 5399
7325, 5432, 1274, 1273, 5399, 5433, 1283, 1282, 5400
7326, 5433, 1283, 1282, 5400, 5434, 1292, 1291, 5401
7327, 5434, 1292, 1291, 5401, 5435, 1301, 1300, 5402
7328, 5435, 1301, 1300, 5402, 5436, 1310, 1309, 5403
7329, 5436, 1310, 1309, 5403, 5437, 1319, 1318, 5404
7330, 5437, 1319, 1318, 5404, 5438, 1328, 1327, 5405
7331, 5438, 1328, 1327, 5405, 5439, 1337, 1336, 5406
7332, 5439, 1337, 1336, 5406, 5440, 1346, 1345, 5407
7333, 5440, 1346, 1345, 5407, 5441, 1355, 1354, 5408
7334, 5441, 1355, 1354, 5408, 1242, 123, 122, 1239
7335, 1216, 1215, 1212, 1213, 5442, 5431, 5398, 5409
7336, 5442, 5431, 5398, 5409, 5443, 5432, 5399, 5410
7337, 5443, 5432, 5399, 5410, 5444, 5433, 5400, 5411
7338, 5444, 5433, 5400, 5411, 5445, 5434, 5401, 5412
7339, 5445, 5434, 5401, 5412, 5446, 5435, 5402, 5413
7340, 5446, 5435, 5402, 5413, 5447, 5436, 5403, 5414
7341, 5447, 5436, 5403, 5414, 5448, 5437, 5404, 5415
7342, 5448, 5437, 5404, 5415, 5449, 5438, 5405, 5416
7343, 5449, 5438, 5405, 5416, 5450, 5439, 5406, 5417
7344, 5450, 5439, 5406, 5417, 5451, 5440, 5407, 5418
7345, 5451, 5440, 5407, 5418, 5452, 5441, 5408, 5419
7346, 5452, 5441, 5408, 5419, 1243, 1242, 1239, 1240
7347, 1217, 1216, 1213, 1214, 5453, 5442, 5409, 5420
7348, 5453, 5442, 5409, 5420, 5454, 5443, 5410, 5421
7349, 5454, 5443, 5410, 5421, 5455, 5444, 5411, 5422
7350, 5455, 5444, 5411, 5422, 5456, 5445, 5412, 5423
7351, 5456, 5445, 5412, 5423, 5457, 5446, 5413, 5424
7352, 5457, 5446, 5413, 5424, 5458, 5447, 5414, 5425
7353, 5458, 5447, 5414, 5425, 5459, 5448, 5415, 5426
7354, 5459, 5448, 5415, 5426, 5460, 5449, 5416, 5427
7355, 5460, 5449, 5416, 5427, 5461, 5450, 5417, 5428
7356, 5461, 5450, 5417, 5428, 5462, 5451, 5418, 5429
7357, 5462, 5451, 5418, 5429, 5463, 5452, 5419, 5430
7358, 5463, 5452, 5419, 5430, 1244, 1243, 1240, 1241
7359, 111, 1217, 1214, 110, 1364, 5453, 5420, 1363
7360, 1364, 5453, 5420, 1363, 1373, 5454, 5421, 1372
7361, 1373, 5454, 5421, 1372, 1382, 5455, 5422, 1381
7362, 1382, 5455, 5422, 1381, 1391, 5456, 5423, 1390
7363, 1391, 5456, 5423, 1390, 1400, 5457, 5424, 1399
7364, 1400, 5457, 5424, 1399, 1409, 5458, 5425, 1408
7365, 1409, 5458, 5425, 1408, 1418, 5459, 5426, 1417
7366, 1418, 5459, 5426, 1417, 1427, 5460, 5427, 1426
7367, 1427, 5460, 5427, 1426, 1436, 5461, 5428, 1435
7368, 1436, 5461, 5428, 1435, 1445, 5462, 5429, 1444
7369, 1445, 5462, 5429, 1444, 1454, 5463, 5430, 1453
7370, 1454, 5463, 5430, 1453, 135, 1244, 1241, 134
7371, 1218, 100, 99, 1215, 5464, 1266, 1265, 5431
7372, 5464, 1266, 1265, 5431, 5465, 1275, 1274, 5432
7373, 5465, 1275, 1274, 5432, 5466, 1284, 1283, 5433
7374, 5466, 1284, 1283, 5433, 5467, 1293, 1292, 5434
7375, 5467, 1293, 1292, 5434, 5468, 1302, 1301, 5435
7376, 5468, 1302, 1301, 5435, 5469, 1311, 1310, 5436
7377, 5469, 1311, 1310, 5436, 5470, 1320, 1319, 5437
7378, 5470, 1320, 1319, 5437, 5471, 1329, 1328, 5438
7379, 5471, 1329, 1328, 5438, 5472, 1338, 1337, 5439
7380, 5472, 1338, 1337, 5439, 5473, 1347, 1346, 5440
7381, 5473, 1347, 1346, 5440, 5474, 1356, 1355, 5441
7382, 5474, 1356, 1355, 5441, 1245, 124, 123, 1242
7383, 1219, 1218, 1215, 1216, 5475, 5464, 5431, 5442
7384, 5475, 5464, 5431, 5442, 5476, 5465, 5432, 5443
7385, 5476, 5465, 5432, 5443, 5477, 5466, 5433, 5444
7386, 5477, 5466, 5433, 5444, 5478, 5467, 5434, 5445
7387, 5478, 5467, 5434, 5445, 5479, 5468, 5435, 5446
7388, 5479, 5468, 5435, 5446, 5480, 5469, 5436, 5447
7389, 5480, 5469, 5436, 5447, 5481, 5470, 5437, 5448
7390, 5481, 5470, 5437, 5448, 5482, 5471, 5438, 5449
7391, 5482, 5471, 5438, 5449, 5483, 5472, 5439, 5450
7392, 5483, 5472, 5439, 5450, 5484, 5473, 5440, 5451
7393, 5484, 5473, 5440, 5451, 5485, 5474, 5441, 5452
7394, 5485, 5474, 5441, 5452, 1246, 1245, 1242, 1243
7395, 1220, 1219, 1216, 1217, 5486, 5475, 5442, 5453
7396, 5486, 5475, 5442, 5453, 5487, 5476, 5443, 5454
7397, 5487, 5476, 5443, 5454, 5488, 5477, 5444, 5455
7398, 5488, 5477, 5444, 5455, 5489, 5478, 5445, 5456
7399, 5489, 5478, 5445, 5456, 5490, 5479, 5446, 5457
7400, 5490, 5479, 5446, 5457, 5491, 5480, 5447, 5458
7401, 5491, 5480, 5447, 5458, 5492, 5481, 5448, 5459
7402, 5492, 5481, 5448, 5459, 5493, 5482, 5449, 5460
7403, 5493, 5482, 5449, 5460, 5494, 5483, 5450, 5461
7404, 5494, 5483, 5450, 5461, 5495, 5484, 5451, 5462
7405, 5495, 5484, 5451, 5462, 5496, 5485, 5452, 5463
7406, 5496, 5485, 5452, 5463, 1247, 1246, 1243, 1244
7407, 112, 1220, 1217, 111, 1365, 5486, 5453, 1364
7408, 1365, 5486, 5453, 1364, 1374, 5487, 5454, 1373
7409, 1374, 5487, 5454, 1373, 1383, 5488, 5455, 1382
7410, 1383, 5488, 5455, 1382, 1392, 5489, 5456, 1391
7411, 1392, 5489, 5456, 1391, 1401, 5490, 5457, 1400
7412, 1401, 5490, 5457, 1400, 1410, 5491, 5458, 1409
7413, 1410, 5491, 5458, 1409, 1419, 5492, 5459, 1418
7414, 1419, 5492, 5459, 1418, 1428, 5493, 5460, 1427
7415, 1428, 5493, 5460, 1427, 1437, 5494, 5461, 1436
7416, 1437, 5494, 5461, 1436, 1446, 5495, 5462, 1445
7417, 1446, 5495, 5462, 1445, 1455, 5496, 5463, 1454
7418, 1455, 5496, 5463, 1454, 136, 1247, 1244, 135
7419, 1221, 101, 100, 1218, 5497, 1267, 1266, 5464
7420, 5497, 1267, 1266, 5464, 5498, 1276, 1275, 5465
7421, 5498, 1276, 1275, 5465, 5499, 1285, 1284, 5466
7422, 5499, 1285, 1284, 5466, 5500, 1294, 1293, 5467
7423, 5500, 1294, 1293, 5467, 5501, 1303, 1302, 5468
7424, 5501, 1303, 1302, 5468, 5502, 1312, 1311, 5469
7425, 5502, 1312, 1311, 5469, 5503, 1321, 1320, 5470
7426, 5503, 1321, 1320, 5470, 5504, 1330, 1329, 5471
7427, 5504, 1330, 1329, 5471, 5505, 1339, 1338, 5472
7428, 5505, 1339, 1338, 5472, 5506, 1348, 1347, 5473
7429, 5506, 1348, 1347, 5473, 5507, 1357, 1356, 5474
7430, 5507, 1357, 1356, 5474, 1248, 125, 124, 1245
7431, 1222, 1221, 1218, 1219, 5508, 5497, 5464, 5475
7432, 5508, 5497, 5464, 5475, 5509, 5498, 5465, 5476
7433, 5509, 5498, 5465, 5476, 5510, 5499, 5466, 5477
7434, 5510, 5499, 5466, 5477, 5511, 5500, 5467, 5478
7435, 5511, 5500, 5467, 5478, 5512, 5501, 5468, 5479
7436, 5512, 5501, 5468, 5479, 5513, 5502, 5469, 5480
7437, 5513, 5502, 5469, 5480, 5514, 5503, 5470, 5481
7438, 5514, 5503, 5470, 5481, 5515, 5504, 5471, 5482
7439, 5515, 5504, 5471, 5482, 5516, 5505, 5472, 5483
7440, 5516, 5505, 5472, 5483, 5517, 5506, 5473, 5484
7441, 5517, 5506, 5473, 5484, 5518, 5507, 5474, 5485
7442, 5518, 5507, 5474, 5485, 1249, 1248, 1245, 1246
7443, 1223, 1222, 1219, 1220, 5519, 5508, 5475, 5486
7444, 5519, 5508, 5475, 5486, 5520, 5509, 5476, 5487
7445, 5520, 5509, 5476, 5487, 5521, 5510, 5477, 5488
7446, 5521, 5510, 5477, 5488, 5522, 5511, 5478, 5489
7447, 5522, 5511, 5478, 5489, 5523, 5512, 5479, 5490
7448, 5523, 5512, 5479, 5490, 5524, 5513, 5480, 5491
7449, 5524, 5513, 5480, 5491, 5525, 5514, 5481, 5492
7450, 5525, 5514, 5481, 5492, 5526, 5515, 5482, 5493
7451, 5526, 5515, 5482, 5493, 5527, 5516, 5483, 5494
7452, 5527, 5516, 5483, 5494, 5528, 5517, 5484, 5495
7453, 5528, 5517, 5484, 5495, 5529, 5518, 5485, 5496
7454, 5529, 5518, 5485, 5496, 1250, 1249, 1246, 1247
7455, 113, 1223, 1220, 112, 1366, 5519, 5486, 1365
7456, 1366, 5519, 5486, 1365, 1375, 5520, 5487, 1374
7457, 1375, 5520, 5487, 1374, 1384, 5521, 5488, 1383
7458, 1384, 5521, 5488, 1383, 1393, 5522, 5489, 1392
7459, 1393, 5522, 5489, 1392, 1402, 5523, 5490, 1401
7460, 1402, 5523, 5490, 1401, 1411, 5524, 5491, 1410
7461, 1411, 5524, 5491, 1410, 1420, 5525, 5492, 1419
7462, 1420, 5525, 5492, 1419, 1429, 5526, 5493, 1428
7463, 1429, 5526, 5493, 1428, 1438, 5527, 5494, 1437
7464, 1438, 5527, 5494, 1437, 1447, 5528, 5495, 1446
7465, 1447, 5528, 5495, 1446, 1456, 5529, 5496, 1455
7466, 1456, 5529, 5496, 1455, 137, 1250, 1247, 136
7467, 1224, 102, 101, 1221, 5530, 1268, 1267, 5497
7468, 5530, 1268, 1267, 5497, 5531, 1277, 1276, 5498
7469, 5531, 1277, 1276, 5498, 5532, 1286, 1285, 5499
7470, 5532, 1286, 1285, 5499, 5533, 1295, 1294, 5500
7471, 5533, 1295, 1294, 5500, 5534, 1304, 1303, 5501
7472, 5534, 1304, 1303, 5501, 5535, 1313, 1312, 5502
7473, 5535, 1313, 1312, 5502, 5536, 1322, 1321, 5503
7474, 5536, 1322, 1321, 5503, 5537, 1331, 1330, 5504
7475, 5537, 1331, 1330, 5504, 5538, 1340, 1339, 5505
7476, 5538, 1340, 1339, 5505, 5539, 1349, 1348, 5506
7477, 5539, 1349, 1348, 5506, 5540, 1358, 1357, 5507
7478, 5540, 1358, 1357, 5507, 1251, 126, 125, 1248
7479, 1225, 1224, 1221, 1222, 5541, 5530, 5497, 5508
7480, 5541, 5530, 5497, 5508, 5542, 5531, 5498, 5509
7481, 5542, 5531, 5498, 5509, 5543, 5532, 5499, 5510
7482, 5543, 5532, 5499, 5510, 5544, 5533, 5500, 5511
7483, 5544, 5533, 5500, 5511, 5545, 5534, 5501, 5512
7484, 5545, 5534, 5501, 5512, 5546, 5535, 5502, 5513
7485, 5546, 5535, 5502, 5513, 5547, 5536, 5503, 5514
7486, 5547, 5536, 5503, 5514, 5548, 5537, 5504, 5515
7487, 5548, 5537, 5504, 5515, 5549, 5538, 5505, 5516
7488, 5549, 5538, 5505, 5516, 5550, 5539, 5506, 5517
7489, 5550, 5539, 5506, 5517, 5551, 5540, 5507, 5518
7490, 5551, 5540, 5507, 5518, 1252, 1251, 1248, 1249
7491, 1226, 1225, 1222, 1223, 5552, 5541, 5508, 5519
7492, 5552, 5541, 5508, 5519, 5553, 5542, 5509, 5520
7493, 5553, 5542, 5509, 5520, 5554, 5543, 5510, 5521
7494, 5554, 5543, 5510, 5521, 5555, 5544, 5511, 5522
7495, 5555, 5544, 5511, 5522, 5556, 5545, 5512, 5523
7496, 5556, 5545, 5512, 5523, 5557, 5546, 5513, 5524
7497, 5557, 5546, 5513, 5524, 5558, 5547, 5514, 5525
7498, 5558, 5547, 5514, 5525, 5559, 5548, 5515, 5526
7499, 5559, 5548, 5515, 5526, 5560, 5549, 5516, 5527
7500, 5560, 5549, 5516, 5527, 5561, 5550, 5517, 5528
7501, 5561, 5550, 5517, 5528, 5562, 5551, 5518, 5529
7502, 5562, 5551, 5518, 5529, 1253, 1252, 1249, 1250
7503, 114, 1226, 1223, 113, 1367, 5552, 5519, 1366
7504, 1367, 5552, 5519, 1366, 1376, 5553, 5520, 1375
7505, 1376, 5553, 5520, 1375, 1385, 5554, 5521, 1384
7506, 1385, 5554, 5521, 1384, 1394, 5555, 5522, 1393
7507, 1394, 5555, 5522, 1393, 1403, 5556, 5523, 1402
7508, 1403, 5556, 5523, 1402, 1412, 5557, 5524, 1411
7509, 1412, 5557, 5524, 1411, 1421, 5558, 5525, 1420
7510, 1421, 5558, 5525, 1420, 1430, 5559, 5526, 1429
7511, 1430, 5559, 5526, 1429, 1439, 5560, 5527, 1438
7512, 1439, 5560, 5527, 1438, 1448, 5561, 5528, 1447
7513, 1448, 5561, 5528, 1447, 1457, 5562, 5529, 1456
7514, 1457, 5562, 5529, 1456, 138, 1253, 1250, 137
7515, 1227, 103, 102, 1224, 5563, 1269, 1268, 5530
7516, 5563, 1269, 1268, 5530, 5564, 1278, 1277, 5531
7517, 5564, 1278, 1277, 5531, 5565, 1287, 1286, 5532
7518, 5565, 1287, 1286, 5532, 5566, 1296, 1295, 5533
7519, 5566, 1296, 1295, 5533, 5567, 1305, 1304, 5534
7520, 5567, 1305, 1304, 5534, 5568, 1314, 1313, 5535
7521, 5568, 1314, 1313, 5535, 5569, 1323, 1322, 5536
7522, 5569, 1323, 1322, 5536, 5570, 1332, 1331, 5537
7523, 5570, 1332, 1331, 5537, 5571, 1341, 1340, 5538
7524, 5571, 1341, 1340, 5538, 5572, 1350, 1349, 5539
7525, 5572, 1350, 1349, 5539, 5573, 1359, 1358, 5540
7526, 5573, 1359, 1358, 5540, 1254, 127, 126, 1251
7527, 1228, 1227, 1224, 1225, 5574, 5563, 5530, 5541
7528, 5574, 5563, 5530, 5541, 5575, 5564, 5531, 5542
7529, 5575, 5564, 5531, 5542, 5576, 5565, 5532, 5543
7530, 5576, 5565, 5532, 5543, 5577, 5566, 5533, 5544
7531, 5577, 5566, 5533, 5544, 5578, 5567, 5534, 5545
7532, 5578, 5567, 5534, 5545, 5579, 5568, 5535, 5546
7533, 5579, 5568, 5535, 5546, 5580, 5569, 5536, 5547
7534, 5580, 5569, 5536, 5547, 5581, 5570, 5537, 5548
7535, 5581, 5570, 5537, 5548, 5582, 5571, 5538, 5549
7536, 5582, 5571, 5538, 5549, 5583, 5572, 5539, 5550
7537, 5583, 5572, 5539, 5550, 5584, 5573, 5540, 5551
7538, 5584, 5573, 5540, 5551, 1255, 1254, 1251, 1252
7539, 1229, 1228, 1225, 1226, 5585, 5574, 5541, 5552
7540, 5585, 5574, 5541, 5552, 5586, 5575, 5542, 5553
7541, 5586, 5575, 5542, 5553, 5587, 5576, 5543, 5554
7542, 5587, 5576, 5543, 5554, 5588, 5577, 5544, 5555
7543, 5588, 5577, 5544, 5555, 5589, 5578, 5545, 5556
7544, 5589, 5578, 5545, 5556, 5590, 5579, 5546, 5557
7545, 5590, 5579, 5546, 5557, 5591, 5580, 5547, 5558
7546, 5591, 5580, 5547, 5558, 5592, 5581, 5548, 5559
7547, 5592, 5581, 5548, 5559, 5593, 5582, 5549, 5560
7548, 5593, 5582, 5549, 5560, 5594, 5583, 5550, 5561
7549, 5594, 5583, 5550, 5561, 5595, 5584, 5551, 5562
7550, 5595, 5584, 5551, 5562, 1256, 1255, 1252, 1253
7551, 115, 1229, 1226, 114, 1368, 5585, 5552, 1367
7552, 1368, 5585, 5552, 1367, 1377, 5586, 5553, 1376
7553, 1377, 5586, 5553, 1376, 1386, 5587, 5554, 1385
7554, 1386, 5587, 5554, 1385, 1395, 5588, 5555, 1394
7555, 1395, 5588, 5555, 1394, 1404, 5589, 5556, 1403
7556, 1404, 5589, 5556, 1403, 1413, 5590, 5557, 1412
7557, 1413, 5590, 5557, 1412, 1422, 5591, 5558, 1421
7558, 1422, 5591, 5558, 1421, 1431, 5592, 5559, 1430
7559, 1431, 5592, 5559, 1430, 1440, 5593, 5560, 1439
7560, 1440, 5593, 5560, 1439, 1449, 5594, 5561, 1448
7561, 1449, 5594, 5561, 1448, 1458, 5595, 5562, 1457
7562, 1458, 5595, 5562, 1457, 139, 1256, 1253, 138
7563, 1230, 104, 103, 1227, 5596, 1270, 1269, 5563
7564, 5596, 1270, 1269, 5563, 5597, 1279, 1278, 5564
7565, 5597, 1279, 1278, 5564, 5598, 1288, 1287, 5565
7566, 5598, 1288, 1287, 5565, 5599, 1297, 1296, 5566
7567, 5599, 1297, 1296, 5566, 5600, 1306, 1305, 5567
7568, 5600, 1306, 1305, 5567, 5601, 1315, 1314, 5568
7569, 5601, 1315, 1314, 5568, 5602, 1324, 1323, 5569
7570, 5602, 1324, 1323, 5569, 5603, 1333, 1332, 5570
7571, 5603, 1333, 1332, 5570, 5604, 1342, 1341, 5571
7572, 5604, 1342, 1341, 5571, 5605, 1351, 1350, 5572
7573, 5605, 1351, 1350, 5572, 5606, 1360, 1359, 5573
7574, 5606, 1360, 1359, 5573, 1257, 128, 127, 1254
7575, 1231, 1230, 1227, 1228, 5607, 5596, 5563, 5574
7576, 5607, 5596, 5563, 5574, 5608, 5597, 5564, 5575
7577, 5608, 5597, 5564, 5575, 5609, 5598, 5565, 5576
7578, 5609, 5598, 5565, 5576, 5610, 5599, 5566, 5577
7579, 5610, 5599, 5566, 5577, 5611, 5600, 5567, 5578
7580, 5611, 5600, 5567, 5578, 5612, 5601, 5568, 5579
7581, 5612, 5601, 5568, 5579, 5613, 5602, 5569, 5580
7582, 5613, 5602, 5569, 5580, 5614, 5603, 5570, 5581
7583, 5614, 5603, 5570, 5581, 5615, 5604, 5571, 5582
7584, 5615, 5604, 5571, 5582, 5616, 5605, 5572, 5583
7585, 5616, 5605, 5572, 5583, 5617, 5606, 5573, 5584
7586, 5617, 5606, 5573, 5584, 1258, 1257, 1254, 1255
7587, 1232, 1231, 1228, 1229, 5618, 5607, 5574, 5585
7588, 5618, 5607, 5574, 5585, 5619, 5608, 5575, 5586
7589, 5619, 5608, 5575, 5586, 5620, 5609, 5576, 5587
7590, 5620, 5609, 5576, 5587, 5621, 5610, 5577, 5588
7591, 5621, 5610, 5577, 5588, 5622, 5611, 5578, 5589
7592, 5622, 5611, 5578, 5589, 5623, 5612, 5579, 5590
7593, 5623, 5612, 5579, 5590, 5624, 5613, 5580, 5591
7594, 5624, 5613, 5580, 5591, 5625, 5614, 5581, 5592
7595, 5625, 5614, 5581, 5592, 5626, 5615, 5582, 5593
7596, 5626, 5615, 5582, 5593, 5627, 5616, 5583, 5594
7597, 5627, 5616, 5583, 5594, 5628, 5617, 5584, 5595
7598, 5628, 5617, 5584, 5595, 1259, 1258, 1255, 1256
7599, 116, 1232, 1229, 115, 1369, 5618, 5585, 1368
7600, 1369, 5618, 5585, 1368, 1378, 5619, 5586, 1377
7601, 1378, 5619, 5586, 1377, 1387, 5620, 5587, 1386
7602, 1387, 5620, 5587, 1386, 1396, 5621, 5588, 1395
7603, 1396, 5621, 5588, 1395, 1405, 5622, 5589, 1404
7604, 1405, 5622, 5589, 1404, 1414, 5623, 5590, 1413
7605, 1414, 5623, 5590, 1413, 1423, 5624, 5591, 1422
7606, 1423, 5624, 5591, 1422, 1432, 5625, 5592, 1431
7607, 1432, 5625, 5592, 1431, 1441, 5626, 5593, 1440
7608, 1441, 5626, 5593, 1440, 1450, 5627, 5594, 1449
7609, 1450, 5627, 5594, 1449, 1459, 5628, 5595, 1458
7610, 1459, 5628, 5595, 1458, 140, 1259, 1256, 139
7611, 1233, 105, 104, 1230, 5629, 1271, 1270, 5596
7612, 5629, 1271, 1270, 5596, 5630, 1280, 1279, 5597
7613, 5630, 1280, 1279, 5597, 5631, 1289, 1288, 5598
7614, 5631, 1289, 1288, 5598, 5632, 1298, 1297, 5599
7615, 5632, 1298, 1297, 5599, 5633, 1307, 1306, 5600
7616, 5633, 1307, 1306, 5600, 5634, 1316, 1315, 5601
7617, 5634, 1316, 1315, 5601, 5635, 1325, 1324, 5602
7618, 5635, 1325, 1324, 5602, 5636, 1334, 1333, 5603
7619, 5636, 1334, 1333, 5603, 5637, 1343, 1342, 5604
7620, 5637, 1343, 1342, 5604, 5638, 1352, 1351, 5605
7621, 5638, 1352, 1351, 5605, 5639, 1361, 1360, 5606
7622, 5639, 1361, 1360, 5606, 1260, 129, 128, 1257
7623, 1234, 1233, 1230, 1231, 5640, 5629, 5596, 5607
7624, 5640, 5629, 5596, 5607, 5641, 5630, 5597, 5608
7625, 5641, 5630, 5597, 5608, 5642, 5631, 5598, 5609
7626, 5642, 5631, 5598, 5609, 5643, 5632, 5599, 5610
7627, 5643, 5632, 5599, 5610, 5644, 5633, 5600, 5611
7628, 5644, 5633, 5600, 5611, 5645, 5634, 5601, 5612
7629, 5645, 5634, 5601, 5612, 5646, 5635, 5602, 5613
7630, 5646, 5635, 5602, 5613, 5647, 5636, 5603, 5614
7631, 5647, 5636, 5603, 5614, 5648, 5637, 5604, 5615
7632, 5648, 5637, 5604, 5615, 5649, 5638, 5605, 5616
7633, 5649, 5638, 5605, 5616, 5650, 5639, 5606, 5617
7634, 5650, 5639, 5606, 5617, 1261, 1260, 1257, 1258
7635, 1235, 1234, 1231, 1232, 5651, 5640, 5607, 5618
7636, 5651, 5640, 5607, 5618, 5652, 5641, 5608, 5619
7637, 5652, 5641, 5608, 5619, 5653, 5642, 5609, 5620
7638, 5653, 5642, 5609, 5620, 5654, 5643, 5610, 5621
7639, 5654, 5643, 5610, 5621, 5655, 5644, 5611, 5622
7640, 5655, 5644, 5611, 5622, 5656, 5645, 5612, 5623
7641, 5656, 5645, 5612, 5623, 5657, 5646, 5613, 5624
7642, 5657, 5646, 5613, 5624, 5658, 5647, 5614, 5625
7643, 5658, 5647, 5614, 5625, 5659, 5648, 5615, 5626
7644, 5659, 5648, 5615, 5626, 5660, 5649, 5616, 5627
7645, 5660, 5649, 5616, 5627, 5661, 5650, 5617, 5628
7646, 5661, 5650, 5617, 5628, 1262, 1261, 1258, 1259
7647, 117, 1235, 1232, 116, 1370, 5651, 5618, 1369
7648, 1370, 5651, 5618, 1369, 1379, 5652, 5619, 1378
7649, 1379, 5652, 5619, 1378, 1388, 5653, 5620, 1387
7650, 1388, 5653, 5620, 1387, 1397, 5654, 5621, 1396
7651, 1397, 5654, 5621, 1396, 1406, 5655, 5622, 1405
7652, 1406, 5655, 5622, 1405, 1415, 5656, 5623, 1414
7653, 1415, 5656, 5623, 1414, 1424, 5657, 5624, 1423
7654, 1424, 5657, 5624, 1423, 1433, 5658, 5625, 1432
7655, 1433, 5658, 5625, 1432, 1442, 5659, 5626, 1441
7656, 1442, 5659, 5626, 1441, 1451, 5660, 5627, 1450
7657, 1451, 5660, 5627, 1450, 1460, 5661, 5628, 1459
7658, 1460, 5661, 5628, 1459, 141, 1262, 1259, 140
7659, 106, 1, 105, 1233, 1494, 156, 1271, 5629
7660, 1494, 156, 1271, 5629, 1495, 157, 1280, 5630
7661, 1495, 157, 1280, 5630, 1496, 158, 1289, 5631
7662, 1496, 158, 1289, 5631, 1497, 159, 1298, 5632
7663, 1497, 159, 1298, 5632, 1498, 160, 1307, 5633
7664, 1498, 160, 1307, 5633, 1499, 161, 1316, 5634
7665, 1499, 161, 1316, 5634, 1500, 162, 1325, 5635
7666, 1500, 162, 1325, 5635, 1501, 163, 1334, 5636
7667, 1501, 163, 1334, 5636, 1502, 164, 1343, 5637
7668, 1502, 164, 1343, 5637, 1503, 165, 1352, 5638
7669, 1503, 165, 1352, 5638, 1504, 166, 1361, 5639
7670, 1504, 166, 1361, 5639, 130, 5, 129, 1260
7671, 107, 106, 1233, 1234, 1505, 1494, 5629, 5640
7672, 1505, 1494, 5629, 5640, 1506, 1495, 5630, 5641
7673, 1506, 1495, 5630, 5641, 1507, 1496, 5631, 5642
7674, 1507, 1496, 5631, 5642, 1508, 1497, 5632, 5643
7675, 1508, 1497, 5632, 5643, 1509, 1498, 5633, 5644
7676, 1509, 1498, 5633, 5644, 1510, 1499, 5634, 5645
7677, 1510, 1499, 5634, 5645, 1511, 1500, 5635, 5646
7678, 1511, 1500, 5635, 5646, 1512, 1501, 5636, 5647
7679, 1512, 1501, 5636, 5647, 1513, 1502, 5637, 5648
7680, 1513, 1502, 5637, 5648, 1514, 1503, 5638, 5649
7681, 1514, 1503, 5638, 5649, 1515, 1504, 5639, 5650
7682, 1515, 1504, 5639, 5650, 131, 130, 1260, 1261
7683, 108, 107, 1234, 1235, 1516, 1505, 5640, 5651
7684, 1516, 1505, 5640, 5651, 1517, 1506, 5641, 5652
7685, 1517, 1506, 5641, 5652, 1518, 1507, 5642, 5653
7686, 1518, 1507, 5642, 5653, 1519, 1508, 5643, 5654
7687, 1519, 1508, 5643, 5654, 1520, 1509, 5644, 5655
7688, 1520, 1509, 5644, 5655, 1521, 1510, 5645, 5656
7689, 1521, 1510, 5645, 5656, 1522, 1511, 5646, 5657
7690, 1522, 1511, 5646, 5657, 1523, 1512, 5647, 5658
7691, 1523, 1512, 5647, 5658, 1524, 1513, 5648, 5659
7692, 1524, 1513, 5648, 5659, 1525, 1514, 5649, 5660
7693, 1525, 1514, 5649, 5660, 1526, 1515, 5650, 5661
7694, 1526, 1515, 5650, 5661, 132, 131, 1261, 1262
7695, 3, 108, 1235, 117, 178, 1516, 5651, 1370
7696, 178, 1516, 5651, 1370, 179, 1517, 5652, 1379
7697, 179, 1517, 5652, 1379, 180, 1518, 5653, 1388
7698, 180, 1518, 5653, 1388, 181, 1519, 5654, 1397
7699, 181, 1519, 5654, 1397, 182, 1520, 5655, 1406
7700, 182, 1520, 5655, 1406, 183, 1521, 5656, 1415
7701, 183, 1521, 5656, 1415, 184, 1522, 5657, 1424
7702, 184, 1522, 5657, 1424, 185, 1523, 5658, 1433
7703, 185, 1523, 5658, 1433, 186, 1524, 5659, 1442
7704, 186, 1524, 5659, 1442, 187, 1525, 5660, 1451
7705, 187, 1525, 5660, 1451, 188, 1526, 5661, 1460
7706, 188, 1526, 5661, 1460, 7, 132, 1262, 141
*ELEMENT, type=C3D8, ELSET=Volume2
7707, 4, 109, 1362, 167, 10, 220, 1527, 189
7708, 109, 110, 1363, 1362, 220, 221, 1528, 1527
7709, 110, 111, 1364, 1363, 221, 222, 1529, 1528
7710, 111, 112, 1365, 1364, 222, 223, 1530, 1529
7711, 112, 113, 1366, 1365, 223, 224, 1531, 1530
7712, 113, 114, 1367, 1366, 224, 225, 1532, 1531
7713, 114, 115, 1368, 1367, 225, 226, 1533, 1532
7714, 115, 116, 1369, 1368, 226, 227, 1534, 1533
7715, 116, 117, 1370, 1369, 227, 228, 1535, 1534
7716, 117, 3, 178, 1370, 228, 12, 209, 1535
7717, 167, 1362, 1371, 168, 189, 1527, 1536, 190
7718, 1362, 1363, 1372, 1371, 1527, 1528, 1537, 1536
7719, 1363, 1364, 1373, 1372, 1528, 1529, 1538, 1537
7720, 1364, 1365, 1374, 1373, 1529, 1530, 1539, 1538
7721, 1365, 1366, 1375, 1374, 1530, 1531, 1540, 1539
7722, 1366, 1367, 1376, 1375, 1531, 1532, 1541, 1540
7723, 1367, 1368, 1377, 1376, 1532, 1533, 1542, 1541
7724, 1368, 1369, 1378, 1377, 1533, 1534, 1543, 1542
7725, 1369, 1370, 1379, 1378, 1534, 1535, 1544, 1543
7726, 1370, 178, 179, 1379, 1535, 209, 210, 1544
7727, 168, 1371, 1380, 169, 190, 1536, 1545, 191
7728, 1371, 1372, 1381, 1380, 1536, 1537, 1546, 1545
7729, 1372, 1373, 1382, 1381, 1537, 1538, 1547, 1546
7730, 1373, 1374, 1383, 1382, 1538, 1539, 1548, 1547
7731, 1374, 1375, 1384, 1383, 1539, 1540, 1549, 1548
7732, 1375, 1376, 1385, 1384, 1540, 1541, 1550, 1549
7733, 1376, 1377, 1386, 1385, 1541, 1542, 1551, 1550
7734, 1377, 1378, 1387, 1386, 1542, 1543, 1552, 1551
7735, 1378, 1379, 1388, 1387, 1543, 1544, 1553, 1552
7736, 1379, 179, 180, 1388, 1544, 210, 211, 1553
7737, 169, 1380, 1389, 170, 191, 1545, 1554, 192
7738, 1380, 1381, 1390, 1389, 1545, 1546, 1555, 1554
7739, 1381, 1382, 1391, 1390, 1546, 1547, 1556, 1555
7740, 1382, 1383, 1392, 1391, 1547, 1548, 1557, 1556
7741, 1383, 1384, 1393, 1392, 1548, 1549, 1558, 1557
7742, 1384, 1385, 1394, 1393, 1549, 1550, 1559, 1558
7743, 1385, 1386, 1395, 1394, 1550, 1551, 1560, 1559
7744, 1386, 1387, 1396, 1395, 1551, 1552, 1561, 1560
7745, 1387, 1388, 1397, 1396, 1552, 1553, 1562, 1561
7746, 1388, 180, 181, 1397, 1553, 211, 212, 1562
7747, 170, 1389, 1398, 171, 192, 1554, 1563, 193
7748, 1389, 1390, 1399, 1398, 1554, 1555, 1564, 1563
7749, 1390, 1391, 1400, 1399, 1555, 1556, 1565, 1564
7750, 1391, 1392, 1401, 1400, 1556, 1557, 1566, 1565
7751, 1392, 1393, 1402, 1401, 1557, 1558, 1567, 1566
7752, 1393, 1394, 1403, 1402, 1558, 1559, 1568, 1567
7753, 1394, 1395, 1404, 1403, 1559, 1560, 1569, 1568
7754, 1395, 1396, 1405, 1404, 1560, 1561, 1570, 1569
7755, 1396, 1397, 1406, 1405, 1561, 1562, 1571, 1570
7756, 1397, 181, 182, 1406, 1562, 212, 213, 1571
7757, 171, 1398, 1407, 172, 193, 1563, 1572, 194
7758, 1398, 1399, 1408, 1407, 1563, 1564, 1573, 1572
7759, 1399, 1400, 1409, 1408, 1564, 1565, 1574, 1573
7760, 1400, 1401, 1410, 1409, 1565, 1566, 1575, 1574
7761, 1401, 1402, 1411, 1410, 1566, 1567, 1576, 1575
7762, 1402, 1403, 1412, 1411, 1567, 1568, 1577, 1576
7763, 1403, 1404, 1413, 1412, 1568, 1569, 1578, 1577
7764, 1404, 1405, 1414, 1413, 1569, 1570, 1579, 1578
7765, 1405, 1406, 1415, 1414, 1570, 1571, 1580, 1579
7766, 1406, 182, 183, 1415, 1571, 213, 214, 1580
7767, 172, 1407, 1416, 173, 194, 1572, 1581, 195
7768, 1407, 1408, 1417, 1416, 1572, 1573, 1582, 1581
7769, 1408, 1409, 1418, 1417, 1573, 1574, 1583, 1582
7770, 1409, 1410, 1419, 1418, 1574, 1575, 1584, 1583
7771, 1410, 1411, 1420, 1419, 1575, 1576, 1585, 1584
7772, 1411, 1412, 1421, 1420, 1576, 1577, 1586, 1585
7773, 1412, 1413, 1422, 1421, 1577, 1578, 1587, 1586
7774, 1413, 1414, 1423, 1422, 1578, 1579, 1588, 1587
7775, 1414, 1415, 1424, 1423, 1579, 1580, 1589, 1588
7776, 1415, 183, 184, 1424, 1580, 214, 215, 1589
7777, 173, 1416, 1425, 174, 195, 1581, 1590, 196
7778, 1416, 1417, 1426, 1425, 1581, 1582, 1591, 1590
7779, 1417, 1418, 1427, 1426, 1582, 1583, 1592, 1591
7780, 1418, 1419, 1428, 1427, 1583, 1584, 1593, 1592
7781, 1419, 1420, 1429, 1428, 1584, 1585, 1594, 1593
7782, 1420, 1421, 1430, 1429, 1585, 1586, 1595, 1594
7783, 1421, 1422, 1431, 1430, 1586, 1587, 1596, 1595
7784, 1422, 1423, 1432, 1431, 1587, 1588, 1597, 1596
7785, 1423, 1424, 1433, 1432, 1588, 1589, 1598, 1597
7786, 1424, 184, 185, 1433, 1589, 215, 216, 1598
7787, 174, 1425, 1434, 175, 196, 1590, 1599, 197
7788, 1425, 1426, 1435, 1434, 1590, 1591, 1600, 1599
7789, 1426, 1427, 1436, 1435, 1591, 1592, 1601, 1600
7790, 1427, 1428, 1437, 1436, 1592, 1593, 1602, 1601
7791, 1428, 1429, 1438, 1437, 1593, 1594, 1603, 1602
7792, 1429, 1430, 1439, 1438, 1594, 1595, 1604, 1603
7793, 1430, 1431, 1440, 1439, 1595, 1596, 1605, 1604
7794, 1431, 1432, 1441, 1440, 1596, 1597, 1606, 1605
7795, 1432, 1433, 1442, 1441, 1597, 1598, 1607, 1606
7796, 1433, 185, 186, 1442, 1598, 216, 217, 1607
7797, 175, 1434, 1443, 176, 197, 1599, 1608, 198
7798, 1434, 1435, 1444, 1443, 1599, 1600, 1609, 1608
7799, 1435, 1436, 1445, 1444, 1600, 1601, 1610, 1609
7800, 1436, 1437, 1446, 1445, 1601, 1602, 1611, 1610
7801, 1437, 1438, 1447, 1446, 1602, 1603, 1612, 1611
7802, 1438, 1439, 1448, 1447, 1603, 1604, 1613, 1612
7803, 1439, 1440, 1449, 1448, 1604, 1605, 1614, 1613
7804, 1440, 1441, 1450, 1449, 1605, 1606, 1615, 1614
7805, 1441, 1442, 1451, 1450, 1606, 1607, 1616, 1615
7806, 1442, 186, 187, 1451, 1607, 217, 218, 1616
7807, 176, 1443, 1452, 177, 198, 1608, 1617, 199
7808, 1443, 1444, 1453, 1452, 1608, 1609, 1618, 1617
7809, 1444, 1445, 1454, 1453, 1609, 1610, 1619, 1618
7810, 1445, 1446, 1455, 1454, 1610, 1611, 1620, 1619
7811, 1446, 1447, 1456, 1455, 1611, 1612, 1621, 1620
7812, 1447, 1448, 1457, 1456, 1612, 1613, 1622, 1621
7813, 1448, 1449, 1458, 1457, 1613, 1614, 1623, 1622
7814, 1449, 1450, 1459, 1458, 1614, 1615, 1624, 1623
7815, 1450, 1451, 1460, 1459, 1615, 1616, 1625, 1624
7816, 1451, 187, 188, 1460, 1616, 218, 219, 1625
7817, 177, 1452, 133, 8, 199, 1617, 200, 9
7818, 1452, 1453, 134, 133, 1617, 1618, 201, 200
7819, 1453, 1454, 135, 134, 1618, 1619, 202, 201
7820, 1454, 1455, 136, 135, 1619, 1620, 203, 202
7821, 1455, 1456, 137, 136, 1620, 1621, 204, 203
7822, 1456, 1457, 138, 137, 1621, 1622, 205, 204
7823, 1457, 1458, 139, 138, 1622, 1623, 206, 205
7824, 1458, 1459, 140, 139, 1623, 1624, 207, 206
7825, 1459, 1460, 141, 140, 1624, 1625, 208, 207
7826, 1460, 188, 7, 141, 1625, 219, 11, 208
*ELEMENT, type=C3D8, ELSET=Volume3
7827, 10, 220, 1527, 189, 238, 1905, 5662, 1626
7828, 238, 1905, 5662, 1626, 239, 1906, 5663, 1627
7829, 239, 1906, 5663, 1627, 240, 1907, 5664, 1628
7830, 240, 1907, 5664, 1628, 241, 1908, 5665, 1629
7831, 241, 1908, 5665, 1629, 242, 1909, 5666, 1630
7832, 242, 1909, 5666, 1630, 243, 1910, 5667, 1631
7833, 243, 1910, 5667, 1631, 244, 1911, 5668, 1632
7834, 244, 1911, 5668, 1632, 245, 1912, 5669, 1633
7835, 245, 1912, 5669, 1633, 246, 1913, 5670, 1634
7836, 246, 1913, 5670, 1634, 14, 296, 1986, 247
7837, 220, 221, 1528, 1527, 1905, 1914, 5671, 5662
7838, 1905, 1914, 5671, 5662, 1906, 1915, 5672, 5663
7839, 1906, 1915, 5672, 5663, 1907, 1916, 5673, 5664
7840, 1907, 1916, 5673, 5664, 1908, 1917, 5674, 5665
7841, 1908, 1917, 5674, 5665, 1909, 1918, 5675, 5666
7842, 1909, 1918, 5675, 5666, 1910, 1919, 5676, 5667
7843, 1910, 1919, 5676, 5667, 1911, 1920, 5677, 5668
7844, 1911, 1920, 5677, 5668, 1912, 1921, 5678, 5669
7845, 1912, 1921, 5678, 5669, 1913, 1922, 5679, 5670
7846, 1913, 1922, 5679, 5670, 296, 297, 1987, 1986
7847, 221, 222, 1529, 1528, 1914, 1923, 5680, 5671
7848, 1914, 1923, 5680, 5671, 1915, 1924, 5681, 5672
7849, 1915, 1924, 5681, 5672, 1916, 1925, 5682, 5673
7850, 1916, 1925, 5682, 5673, 1917, 1926, 5683, 5674
7851, 1917, 1926, 5683, 5674, 1918, 1927, 5684, 5675
7852, 1918, 1927, 5684, 5675, 1919, 1928, 5685, 5676
7853, 1919, 1928, 5685, 5676, 1920, 1929, 5686, 5677
7854, 1920, 1929, 5686, 5677, 1921, 1930, 5687, 5678
7855, 1921, 1930, 5687, 5678, 1922, 1931, 5688, 5679
7856, 1922, 1931, 5688, 5679, 297, 298, 1988, 1987
7857, 222, 223, 1530, 1529, 1923, 1932, 5689, 5680
7858, 1923, 1932, 5689, 5680, 1924, 1933, 5690, 5681
7859, 1924, 1933, 5690, 5681, 1925, 1934, 5691, 5682
7860, 1925, 1934, 5691, 5682, 1926, 1935, 5692, 5683
7861, 1926, 1935, 5692, 5683, 1927, 1936, 5693, 5684
7862, 1927, 1936, 5693, 5684, 1928, 1937, 5694, 5685
7863, 1928, 1937, 5694, 5685, 1929, 1938, 5695, 5686
7864, 1929, 1938, 5695, 5686, 1930, 1939, 5696, 5687
7865, 1930, 1939, 5696, 5687, 1931, 1940, 5697, 5688
7866, 1931, 1940, 5697, 5688, 298, 299, 1989, 1988
7867, 223, 224, 1531, 1530, 1932, 1941, 5698, 5689
7868, 1932, 1941, 5698, 5689, 1933, 1942, 5699, 5690
7869, 1933, 1942, 5699, 5690, 1934, 1943, 5700, 5691
7870, 1934, 1943, 5700, 5691, 1935, 1944, 5701, 5692
7871, 1935, 1944, 5701, 5692, 1936, 1945, 5702, 5693
7872, 1936, 1945, 5702, 5693, 1937, 1946, 5703, 5694
7873, 1937, 1946, 5703, 5694, 1938, 1947, 5704, 5695
7874, 1938, 1947, 5704, 5695, 1939, 1948, 5705, 5696
7875, 1939, 1948, 5705, 5696, 1940, 1949, 5706, 5697
7876, 1940, 1949, 5706, 5697, 299, 300, 1990, 1989
7877, 224, 225, 1532, 1531, 1941, 1950, 5707, 5698
7878, 1941, 1950, 5707, 5698, 1942, 1951, 5708, 5699
7879, 1942, 1951, 5708, 5699, 1943, 1952, 5709, 5700
7880, 1943, 1952, 5709, 5700, 1944, 1953, 5710, 5701
7881, 1944, 1953, 5710, 5701, 1945, 1954, 5711, 5702
7882, 1945, 1954, 5711, 5702, 1946, 1955, 5712, 5703
7883, 1946, 1955, 5712, 5703, 1947, 1956, 5713, 5704
7884, 1947, 1956, 5713, 5704, 1948, 1957, 5714, 5705
7885, 1948, 1957, 5714, 5705, 1949, 1958, 5715, 5706
7886, 1949, 1958, 5715, 5706, 300, 301, 1991, 1990
7887, 225, 226, 1533, 1532, 1950, 1959, 5716, 5707
7888, 1950, 1959, 5716, 5707, 1951, 1960, 5717, 5708
7889, 1951, 1960, 5717, 5708, 1952, 1961, 5718, 5709
7890, 1952, 1961, 5718, 5709, 1953, 1962, 5719, 5710
7891, 1953, 1962, 5719, 5710, 1954, 1963, 5720, 5711
7892, 1954, 1963, 5720, 5711, 1955, 1964, 5721, 5712
7893, 1955, 1964, 5721, 5712, 1956, 1965, 5722, 5713
7894, 1956, 1965, 5722, 5713, 1957, 1966, 5723, 5714
7895, 1957, 1966, 5723, 5714, 1958, 1967, 5724, 5715
7896, 1958, 1967, 5724, 5715, 301, 302, 1992, 1991
7897, 226, 227, 1534, 1533, 1959, 1968, 5725, 5716
7898, 1959, 1968, 5725, 5716, 1960, 1969, 5726, 5717
7899, 1960, 1969, 5726, 5717, 1961, 1970, 5727, 5718
7900, 1961, 1970, 5727, 5718, 1962, 1971, 5728, 5719
7901, 1962, 1971, 5728, 5719, 1963, 1972, 5729, 5720
7902, 1963, 1972, 5729, 5720, 1964, 1973, 5730, 5721
7903, 1964, 1973, 5730, 5721, 1965, 1974, 5731, 5722
7904, 1965, 1974, 5731, 5722, 1966, 1975, 5732, 5723
7905, 1966, 1975, 5732, 5723, 1967, 1976, 5733, 5724
7906, 1967, 1976, 5733, 5724, 302, 303, 1993, 1992
7907, 227, 228, 1535, 1534, 1968, 1977, 5734, 5725
7908, 1968, 1977, 5734, 5725, 1969, 1978, 5735, 5726
7909, 1969, 1978, 5735, 5726, 1970, 1979, 5736, 5727
7910, 1970, 1979, 5736, 5727, 1971, 1980, 5737, 5728
7911, 1971, 1980, 5737, 5728, 1972, 1981, 5738, 5729
7912, 1972, 1981, 5738, 5729, 1973, 1982, 5739, 5730
7913, 1973, 1982, 5739, 5730, 1974, 1983, 5740, 5731
7914, 1974, 1983, 5740, 5731, 1975, 1984, 5741, 5732
7915, 1975, 1984, 5741, 5732, 1976, 1985, 5742, 5733
7916, 1976, 1985, 5742, 5733, 303, 304, 1994, 1993
7917, 228, 12, 209, 1535, 1977, 276, 1806, 5734
7918, 1977, 276, 1806, 5734, 1978, 277, 1807, 5735
7919, 1978, 277, 1807, 5735, 1979, 278, 1808, 5736
7920, 1979, 278, 1808, 5736, 1980, 279, 1809, 5737
7921, 1980, 279, 1809, 5737, 1981, 280, 1810, 5738
7922, 1981, 280, 1810, 5738, 1982, 281, 1811, 5739
7923, 1982, 281, 1811, 5739, 1983, 282, 1812, 5740
7924, 1983, 282, 1812, 5740, 1984, 283, 1813, 5741
7925, 1984, 283, 1813, 5741, 1985, 284, 1814, 5742
7926, 1985, 284, 1814, 5742, 304, 16, 285, 1994
7927, 189, 1527, 1536, 190, 1626, 5662, 5743, 1635
7928, 1626, 5662, 5743, 1635, 1627, 5663, 5744, 1636
7929, 1627, 5663, 5744, 1636, 1628, 5664, 5745, 1637
7930, 1628, 5664, 5745, 1637, 1629, 5665, 5746, 1638
7931, 1629, 5665, 5746, 1638, 1630, 5666, 5747, 1639
7932, 1630, 5666, 5747, 1639, 1631, 5667, 5748, 1640
7933, 1631, 5667, 5748, 1640, 1632, 5668, 5749, 1641
7934, 1632, 5668, 5749, 1641, 1633, 5669, 5750, 1642
7935, 1633, 5669, 5750, 1642, 1634, 5670, 5751, 1643
7936, 1634, 5670, 5751, 1643, 247, 1986, 1995, 248
7937, 1527, 1528, 1537, 1536, 5662, 5671, 5752, 5743
7938, 5662, 5671, 5752, 5743, 5663, 5672, 5753, 5744
7939, 5663, 5672, 5753, 5744, 5664, 5673, 5754, 5745
7940, 5664, 5673, 5754, 5745, 5665, 5674, 5755, 5746
7941, 5665, 5674, 5755, 5746, 5666, 5675, 5756, 5747
7942, 5666, 5675, 5756, 5747, 5667, 5676, 5757, 5748
7943, 5667, 5676, 5757, 5748, 5668, 5677, 5758, 5749
7944, 5668, 5677, 5758, 5749, 5669, 5678, 5759, 5750
7945, 5669, 5678, 5759, 5750, 5670, 5679, 5760, 5751
7946, 5670, 5679, 5760, 5751, 1986, 1987, 1996, 1995
7947, 1528, 1529, 1538, 1537, 5671, 5680, 5761, 5752
7948, 5671, 5680, 5761, 5752, 5672, 5681, 5762, 5753
7949, 5672, 5681, 5762, 5753, 5673, 5682, 5763, 5754
7950, 5673, 5682, 5763, 5754, 5674, 5683, 5764, 5755
7951, 5674, 5683, 5764, 5755, 5675, 5684, 5765, 5756
7952, 5675, 5684, 5765, 5756, 5676, 5685, 5766, 5757
7953, 5676, 5685, 5766, 5757, 5677, 5686, 5767, 5758
7954, 5677, 5686, 5767, 5758, 5678, 5687, 5768, 5759
7955, 5678, 5687, 5768, 5759, 5679, 5688, 5769, 5760
7956, 5679, 5688, 5769, 5760, 1987, 1988, 1997, 1996
7957, 1529, 1530, 1539, 1538, 5680, 5689, 5770, 5761
7958, 5680, 5689, 5770, 5761, 5681, 5690, 5771, 5762
7959, 5681, 5690, 5771, 5762, 5682, 5691, 5772, 5763
7960, 5682, 5691, 5772, 5763, 5683, 5692, 5773, 5764
7961, 5683, 5692, 5773, 5764, 5684, 5693, 5774, 5765
7962, 5684, 5693, 5774, 5765, 5685, 5694, 5775, 5766
7963, 5685, 5694, 5775, 5766, 5686, 5695, 5776, 5767
7964, 5686, 5695, 5776, 5767, 5687, 5696, 5777, 5768
7965, 5687, 5696, 5777, 5768, 5688, 5697, 5778, 5769
7966, 5688, 5697, 5778, 5769, 1988, 1989, 1998, 1997
7967, 1530, 1531, 1540, 1539, 5689, 5698, 5779, 5770
7968, 5689, 5698, 5779, 5770, 5690, 5699, 5780, 5771
7969, 5690, 5699, 5780, 5771, 5691, 5700, 5781, 5772
7970, 5691, 5700, 5781, 5772, 5692, 5701, 5782, 5773
7971, 5692, 5701, 5782, 5773, 5693, 5702, 5783, 5774
7972, 5693, 5702, 5783, 5774, 5694, 5703, 5784, 5775
7973, 5694, 5703, 5784, 5775, 5695, 5704, 5785, 5776
7974, 5695, 5704, 5785, 5776, 5696, 5705, 5786, 5777
7975, 5696, 5705, 5786, 5777, 5697, 5706, 5787, 5778
7976, 5697, 5706, 5787, 5778, 1989, 1990, 1999, 1998
7977, 1531, 1532, 1541, 1540, 5698, 5707, 5788, 5779
7978, 5698, 5707, 5788, 5779, 5699, 5708, 5789, 5780
7979, 5699, 5708, 5789, 5780, 5700, 5709, 5790, 5781
7980, 5700, 5709, 5790, 5781, 5701, 5710, 5791, 5782
7981, 5701, 5710, 5791, 5782, 5702, 5711, 5792, 5783
7982, 5702, 5711, 5792, 5783, 5703, 5712, 5793, 5784
7983, 5703, 5712, 5793, 5784, 5704, 5713, 5794, 5785
7984, 5704, 5713, 5794, 5785, 5705, 5714, 5795, 5786
7985, 5705, 5714, 5795, 5786, 5706, 5715, 5796, 5787
7986, 5706, 5715, 5796, 5787, 1990, 1991, 2000, 1999
7987, 1532, 1533, 1542, 1541, 5707, 5716, 5797, 5788
7988, 5707, 5716, 5797, 5788, 5708, 5717, 5798, 5789
7989, 5708, 5717, 5798, 5789, 5709, 5718, 5799, 5790
7990, 5709, 5718, 5799, 5790, 5710, 5719, 5800, 5791
7991, 5710, 5719, 5800, 5791, 5711, 5720, 5801, 5792
7992, 5711, 5720, 5801, 5792, 5712, 5721, 5802, 5793
7993, 5712, 5721, 5802, 5793, 5713, 5722, 5803, 5794
7994, 5713, 5722, 5803, 5794, 5714, 5723, 5804, 5795
7995, 5714, 5723, 5804, 5795, 5715, 5724, 5805, 5796
7996, 5715, 5724, 5805, 5796, 1991, 1992, 2001, 2000
7997, 1533, 1534, 1543, 1542, 5716, 5725, 5806, 5797
7998, 5716, 5725, 5806, 5797, 5717, 5726, 5807, 5798
7999, 5717, 5726, 5807, 5798, 5718, 5727, 5808, 5799
8000, 5718, 5727, 5808, 5799, 5719, 5728, 5809, 5800
8001, 5719, 5728, 5809, 5800, 5720, 5729, 5810, 5801
8002, 5720, 5729, 5810, 5801, 5721, 5730, 5811, 5802
8003, 5721, 5730, 5811, 5802, 5722, 5731, 5812, 5803
8004, 5722, 5731, 5812, 5803, 5723, 5732, 5813, 5804
8005, 5723, 5732, 5813, 5804, 5724, 5733, 5814, 5805
8006, 5724, 5733, 5814, 5805, 1992, 1993, 2002, 2001
8007, 1534, 1535, 1544, 1543, 5725, 5734, 5815, 5806
8008, 5725, 5734, 5815, 5806, 5726, 5735, 5816, 5807
8009, 5726, 5735, 5816, 5807, 5727, 5736, 5817, 5808
8010, 5727, 5736, 5817, 5808, 5728, 5737, 5818, 5809
8011, 5728, 5737, 5818, 5809, 5729, 5738, 5819, 5810
8012, 5729, 5738, 5819, 5810, 5730, 5739, 5820, 5811
8013, 5730, 5739, 5820, 5811, 5731, 5740, 5821, 5812
8014, 5731, 5740, 5821, 5812, 5732, 5741, 5822, 5813
8015, 5732, 5741, 5822, 5813, 5733, 5742, 5823, 5814
8016, 5733, 5742, 5823, 5814, 1993, 1994, 2003, 2002
8017, 1535, 209, 210, 1544, 5734, 1806, 1815, 5815
8018, 5734, 1806, 1815, 5815, 5735, 1807, 1816, 5816
8019, 5735, 1807, 1816, 5816, 5736, 1808, 1817, 5817
8020, 5736, 1808, 1817, 5817, 5737, 1809, 1818, 5818
8021, 5737, 1809, 1818, 5818, 5738, 1810, 1819, 5819
8022, 5738, 1810, 1819, 5819, 5739, 1811, 1820, 5820
8023, 5739, 1811, 1820, 5820, 5740, 1812, 1821, 5821
8024, 5740, 1812, 1821, 5821, 5741, 1813, 1822, 5822
8025, 5741, 1813, 1822, 5822, 5742, 1814, 1823, 5823
8026, 5742, 1814, 1823, 5823, 1994, 285, 286, 2003
8027, 190, 1536, 1545, 191, 1635, 5743, 5824, 1644
8028, 1635, 5743, 5824, 1644, 1636, 5744, 5825, 1645
8029, 1636, 5744, 5825, 1645, 1637, 5745, 5826, 1646
8030, 1637, 5745, 5826, 1646, 1638, 5746, 5827, 1647
8031, 1638, 5746, 5827, 1647, 1639, 5747, 5828, 1648
8032, 1639, 5747, 5828, 1648, 1640, 5748, 5829, 1649
8033, 1640, 5748, 5829, 1649, 1641, 5749, 5830, 1650
8034, 1641, 5749, 5830, 1650, 1642, 5750, 5831, 1651
8035, 1642, 5750, 5831, 1651, 1643, 5751, 5832, 1652
8036, 1643, 5751, 5832, 1652, 248, 1995, 2004, 249
8037, 1536, 1537, 1546, 1545, 5743, 5752, 5833, 5824
8038, 5743, 5752, 5833, 5824, 5744, 5753, 5834, 5825
8039, 5744, 5753, 5834, 5825, 5745, 5754, 5835, 5826
8040, 5745, 5754, 5835, 5826, 5746, 5755, 5836, 5827
8041, 5746, 5755, 5836, 5827, 5747, 5756, 5837, 5828
8042, 5747, 5756, 5837, 5828, 5748, 5757, 5838, 5829
8043, 5748, 5757, 5838, 5829, 5749, 5758, 5839, 5830
8044, 5749, 5758, 5839, 5830, 5750, 5759, 5840, 5831
8045, 5750, 5759, 5840, 5831, 5751, 5760, 5841, 5832
8046, 5751, 5760, 5841, 5832, 1995, 1996, 2005, 2004
8047, 1537, 1538, 1547, 1546, 5752, 5761, 5842, 5833
8048, 5752, 5761, 5842, 5833, 5753, 5762, 5843, 5834
8049, 5753, 5762, 5843, 5834, 5754, 5763, 5844, 5835
8050, 5754, 5763, 5844, 5835, 5755, 5764, 5845, 5836
8051, 5755, 5764, 5845, 5836, 5756, 5765, 5846, 5837
8052, 5756, 5765, 5846, 5837, 5757, 5766, 5847, 5838
8053, 5757, 5766, 5847, 5838, 5758, 5767, 5848, 5839
8054, 5758, 5767, 5848, 5839, 5759, 5768, 5849, 5840
8055, 5759, 5768, 5849, 5840, 5760, 5769, 5850, 5841
8056, 5760, 5769, 5850, 5841, 1996, 1997, 2006, 2005
8057, 1538, 1539, 1548, 1547, 5761, 5770, 5851, 5842
8058, 5761, 5770, 5851, 5842, 5762, 5771, 5852, 5843
8059, 5762, 5771, 5852, 5843, 5763, 5772, 5853, 5844
8060, 5763, 5772, 5853, 5844, 5764, 5773, 5854, 5845
8061, 5764, 5773, 5854, 5845, 5765, 5774, 5855, 5846
8062, 5765, 5774, 5855, 5846, 5766, 5775, 5856, 5847
8063, 5766, 5775, 5856, 5847, 5767, 5776, 5857, 5848
8064, 5767, 5776, 5857, 5848, 5768, 5777, 5858, 5849
8065, 5768, 5777, 5858, 5849, 5769, 5778, 5859, 5850
8066, 5769, 5778, 5859, 5850, 1997, 1998, 2007, 2006
8067, 1539, 1540, 1549, 1548, 5770, 5779, 5860, 5851
8068, 5770, 5779, 5860, 5851, 5771, 5780, 5861, 5852
8069, 5771, 5780, 5861, 5852, 5772, 5781, 5862, 5853
8070, 5772, 5781, 5862, 5853, 5773, 5782, 5863, 5854
8071, 5773, 5782, 5863, 5854, 5774, 5783, 5864, 5855
8072, 5774, 5783, 5864, 5855, 5775, 5784, 5865, 5856
8073, 5775, 5784, 5865, 5856, 5776, 5785, 5866, 5857
8074, 5776, 5785, 5866, 5857, 5777, 5786, 5867, 5858
8075, 5777, 5786, 5867, 5858, 5778, 5787, 5868, 5859
8076, 5778, 5787, 5868, 5859, 1998, 1999, 2008, 2007
8077, 1540, 1541, 1550, 1549, 5779, 5788, 5869, 5860
8078, 5779, 5788, 5869, 5860, 5780, 5789, 5870, 5861
8079, 5780, 5789, 5870, 5861, 5781, 5790, 5871, 5862
8080, 5781, 5790, 5871, 5862, 5782, 5791, 5872, 5863
8081, 5782, 5791, 5872, 5863, 5783, 5792, 5873, 5864
8082, 5783, 5792, 5873, 5864, 5784, 5793, 5874, 5865
8083, 5784, 5793, 5874, 5865, 5785, 5794, 5875, 5866
8084, 5785, 5794, 5875, 5866, 5786, 5795, 5876, 5867
8085, 5786, 5795, 5876, 5867, 5787, 5796, 5877, 5868
8086, 5787, 5796, 5877, 5868, 1999, 2000, 2009, 2008
8087, 1541, 1542, 1551, 1550, 5788, 5797, 5878, 5869
8088, 5788, 5797, 5878, 5869, 5789, 5798, 5879, 5870
8089, 5789, 5798, 5879, 5870, 5790, 5799, 5880, 5871
8090, 5790, 5799, 5880, 5871, 5791, 5800, 5881, 5872
8091, 5791, 5800, 5881, 5872, 5792, 5801, 5882, 5873
8092, 5792, 5801, 5882, 5873, 5793, 5802, 5883, 5874
8093, 5793, 5802, 5883, 5874, 5794, 5803, 5884, 5875
8094, 5794, 5803, 5884, 5875, 5795, 5804, 5885, 5876
8095, 5795, 5804, 5885, 5876, 5796, 5805, 5886, 5877
8096, 5796, 5805, 5886, 5877, 2000, 2001, 2010, 2009
8097, 1542, 1543, 1552, 1551, 5797, 5806, 5887, 5878
8098, 5797, 5806, 5887, 5878, 5798, 5807, 5888, 5879
8099, 5798, 5807, 5888, 5879, 5799, 5808, 5889, 5880
8100, 5799, 5808, 5889, 5880, 5800, 5809, 5890, 5881
8101, 5800, 5809, 5890, 5881, 5801, 5810, 5891, 5882
8102, 5801, 5810, 5891, 5882, 5802, 5811, 5892, 5883
8103, 5802, 5811, 5892, 5883, 5803, 5812, 5893, 5884
8104, 5803, 5812, 5893, 5884, 5804, 5813, 5894, 5885
8105, 5804, 5813, 5894, 5885, 5805, 5814, 5895, 5886
8106, 5805, 5814, 5895, 5886, 2001, 2002, 2011, 2010
8107, 1543, 1544, 1553, 1552, 5806, 5815, 5896, 5887
8108, 5806, 5815, 5896, 5887, 5807, 5816, 5897, 5888
8109, 5807, 5816, 5897, 5888, 5808, 5817, 5898, 5889
8110, 5808, 5817, 5898, 5889, 5809, 5818, 5899, 5890
8111, 5809, 5818, 5899, 5890, 5810, 5819, 5900, 5891
8112, 5810, 5819, 5900, 5891, 5811, 5820, 5901, 5892
8113, 5811, 5820, 5901, 5892, 5812, 5821, 5902, 5893
8114, 5812, 5821, 5902, 5893, 5813, 5822, 5903, 5894
8115, 5813, 5822, 5903, 5894, 5814, 5823, 5904, 5895
8116, 5814, 5823, 5904, 5895, 2002, 2003, 2012, 2011
8117, 1544, 210, 211, 1553, 5815, 1815, 1824, 5896
8118, 5815, 1815, 1824, 5896, 5816, 1816, 1825, 5897
8119, 5816, 1816, 1825, 5897, 5817, 1817, 1826, 5898
8120, 5817, 1817, 1826, 5898, 5818, 1818, 1827, 5899
8121, 5818, 1818, 1827, 5899, 5819, 1819, 1828, 5900
8122, 5819, 1819, 1828, 5900, 5820, 1820, 1829, 5901
8123, 5820, 1820, 1829, 5901, 5821, 1821, 1830, 5902
8124, 5821, 1821, 1830, 5902, 5822, 1822, 1831, 5903
8125, 5822, 1822, 1831, 5903, 5823, 1823, 1832, 5904
8126, 5823, 1823, 1832, 5904, 2003, 286, 287, 2012
8127, 191, 1545, 1554, 192, 1644, 5824, 5905, 1653
8128, 1644, 5824, 5905, 1653, 1645, 5825, 5906, 1654
8129, 1645, 5825, 5906, 1654, 1646, 5826, 5907, 1655
8130, 1646, 5826, 5907, 1655, 1647, 5827, 5908, 1656
8131, 1647, 5827, 5908, 1656, 1648, 5828, 5909, 1657
8132, 1648, 5828, 5909, 1657, 1649, 5829, 5910, 1658
8133, 1649, 5829, 5910, 1658, 1650, 5830, 5911, 1659
8134, 1650, 5830, 5911, 1659, 1651, 5831, 5912, 1660
8135, 1651, 5831, 5912, 1660, 1652, 5832, 5913, 1661
8136, 1652, 5832, 5913, 1661, 249, 2004, 2013, 250
8137, 1545, 1546, 1555, 1554, 5824, 5833, 5914, 5905
8138, 5824, 5833, 5914, 5905, 5825, 5834, 5915, 5906
8139, 5825, 5834, 5915, 5906, 5826, 5835, 5916, 5907
8140, 5826, 5835, 5916, 5907, 5827, 5836, 5917, 5908
8141, 5827, 5836, 5917, 5908, 5828, 5837, 5918, 5909
8142, 5828, 5837, 5918, 5909, 5829, 5838, 5919, 5910
8143, 5829, 5838, 5919, 5910, 5830, 5839, 5920, 5911
8144, 5830, 5839, 5920, 5911, 5831, 5840, 5921, 5912
8145, 5831, 5840, 5921, 5912, 5832, 5841, 5922, 5913
8146, 5832, 5841, 5922, 5913, 2004, 2005, 2014, 2013
8147, 1546, 1547, 1556, 1555, 5833, 5842, 5923, 5914
8148, 5833, 5842, 5923, 5914, 5834, 5843, 5924, 5915
8149, 5834, 5843, 5924, 5915, 5835, 5844, 5925, 5916
8150, 5835, 5844, 5925, 5916, 5836, 5845, 5926, 5917
8151, 5836, 5845, 5926, 5917, 5837, 5846, 5927, 5918
8152, 5837, 5846, 5927, 5918, 5838, 5847, 5928, 5919
8153, 5838, 5847, 5928, 5919, 5839, 5848, 5929, 5920
8154, 5839, 5848, 5929, 5920, 5840, 5849, 5930, 5921
8155, 5840, 5849, 5930, 5921, 5841, 5850, 5931, 5922
8156, 5841, 5850, 5931, 5922, 2005, 2006, 2015, 2014
8157, 1547, 1548, 1557, 1556, 5842, 5851, 5932, 5923
8158, 5842, 5851, 5932, 5923, 5843, 5852, 5933, 5924
8159, 5843, 5852, 5933, 5924, 5844, 5853, 5934, 5925
8160, 5844, 5853, 5934, 5925, 5845, 5854, 5935, 5926
8161, 5845, 5854, 5935, 5926, 5846, 5855, 5936, 5927
8162, 5846, 5855, 5936, 5927, 5847, 5856, 5937, 5928
8163, 5847, 5856, 5937, 5928, 5848, 5857, 5938, 5929
8164, 5848, 5857, 5938, 5929, 5849, 5858, 5939, 5930
8165, 5849, 5858, 5939, 5930, 5850, 5859, 5940, 5931
8166, 5850, 5859, 5940, 5931, 2006, 2007, 2016, 2015
8167, 1548, 1549, 1558, 1557, 5851, 5860, 5941, 5932
8168, 5851, 5860, 5941, 5932, 5852, 5861, 5942, 5933
8169, 5852, 5861, 5942, 5933, 5853, 5862, 5943, 5934
8170, 5853, 5862, 5943, 5934, 5854, 5863, 5944, 5935
8171, 5854, 5863, 5944, 5935, 5855, 5864, 5945, 5936
8172, 5855, 5864, 5945, 5936, 5856, 5865, 5946, 5937
8173, 5856, 5865, 5946, 5937, 5857, 5866, 5947, 5938
8174, 5857, 5866, 5947, 5938, 5858, 5867, 5948, 5939
8175, 5858, 5867, 5948, 5939, 5859, 5868, 5949, 5940
8176, 5859, 5868, 5949, 5940, 2007, 2008, 2017, 2016
8177, 1549, 1550, 1559, 1558, 5860, 5869, 5950, 5941
8178, 5860, 5869, 5950, 5941, 5861, 5870, 5951, 5942
8179, 5861, 5870, 5951, 5942, 5862, 5871, 5952, 5943
8180, 5862, 5871, 5952, 5943, 5863, 5872, 5953, 5944
8181, 5863, 5872, 5953, 5944, 5864, 5873, 5954, 5945
8182, 5864, 5873, 5954, 5945, 5865, 5874, 5955, 5946
8183, 5865, 5874, 5955, 5946, 5866, 5875, 5956, 5947
8184, 5866, 5875, 5956, 5947, 5867, 5876, 5957, 5948
8185, 5867, 5876, 5957, 5948, 5868, 5877, 5958, 5949
8186, 5868, 5877, 5958, 5949, 2008, 2009, 2018, 2017
8187, 1550, 1551, 1560, 1559, 5869, 5878, 5959, 5950
8188, 5869, 5878, 5959, 5950, 5870, 5879, 5960, 5951
8189, 5870, 5879, 5960, 5951, 5871, 5880, 5961, 5952
8190, 5871, 5880, 5961, 5952, 5872, 5881, 5962, 5953
8191, 5872, 5881, 5962, 5953, 5873, 5882, 5963, 5954
8192, 5873, 5882, 5963, 5954, 5874, 5883, 5964, 5955
8193, 5874, 5883, 5964, 5955, 5875, 5884, 5965, 5956
8194, 5875, 5884, 5965, 5956, 5876, 5885, 5966, 5957
8195, 5876, 5885, 5966, 5957, 5877, 5886, 5967, 5958
8196, 5877, 5886, 5967, 5958, 2009, 2010, 2019, 2018
8197, 1551, 1552, 1561, 1560, 5878, 5887, 5968, 5959
8198, 5878, 5887, 5968, 5959, 5879, 5888, 5969, 5960
8199, 5879, 5888, 5969, 5960, 5880, 5889, 5970, 5961
8200, 5880, 5889, 5970, 5961, 5881, 5890, 5971, 5962
8201, 5881, 5890, 5971, 5962, 5882, 5891, 5972, 5963
8202, 5882, 5891, 5972, 5963, 5883, 5892, 5973, 5964
8203, 5883, 5892, 5973, 5964, 5884, 5893, 5974, 5965
8204, 5884, 5893, 5974, 5965, 5885, 5894, 5975, 5966
8205, 5885, 5894, 5975, 5966, 5886, 5895, 5976, 5967
8206, 5886, 5895, 5976, 5967, 2010, 2011, 2020, 2019
8207, 1552, 1553, 1562, 1561, 5887, 5896, 5977, 5968
8208, 5887, 5896, 5977, 5968, 5888, 5897, 5978, 5969
8209, 5888, 5897, 5978, 5969, 5889, 5898, 5979, 5970
8210, 5889, 5898, 5979, 5970, 5890, 5899, 5980, 5971
8211, 5890, 5899, 5980, 5971, 5891, 5900, 5981, 5972
8212, 5891, 5900, 5981, 5972, 5892, 5901, 5982, 5973
8213, 5892, 5901, 5982, 5973, 5893, 5902, 5983, 5974
8214, 5893, 5902, 5983, 5974, 5894, 5903, 5984, 5975
8215, 5894, 5903, 5984, 5975, 5895, 5904, 5985, 5976
8216, 5895, 5904, 5985, 5976, 2011, 2012, 2021, 2020
8217, 1553, 211, 212, 1562, 5896, 1824, 1833, 5977
8218, 5896, 1824, 1833, 5977, 5897, 1825, 1834, 5978
8219, 5897, 1825, 1834, 5978, 5898, 1826, 1835, 5979
8220, 5898, 1826, 1835, 5979, 5899, 1827, 1836, 5980
8221, 5899, 1827, 1836, 5980, 5900, 1828, 1837, 5981
8222, 5900, 1828, 1837, 5981, 5901, 1829, 1838, 5982
8223, 5901, 1829, 1838, 5982, 5902, 1830, 1839, 5983
8224, 5902, 1830, 1839, 5983, 5903, 1831, 1840, 5984
8225, 5903, 1831, 1840, 5984, 5904, 1832, 1841, 5985
8226, 5904, 1832, 1841, 5985, 2012, 287, 288, 2021
8227, 192, 1554, 1563, 193, 1653, 5905, 5986, 1662
8228, 1653, 5905, 5986, 1662, 1654, 5906, 5987, 1663
8229, 1654, 5906, 5987, 1663, 1655, 5907, 5988, 1664
8230, 1655, 5907, 5988, 1664, 1656, 5908, 5989, 1665
8231, 1656, 5908, 5989, 1665, 1657, 5909, 5990, 1666
8232, 1657, 5909, 5990, 1666, 1658, 5910, 5991, 1667
8233, 1658, 5910, 5991, 1667, 1659, 5911, 5992, 1668
8234, 1659, 5911, 5992, 1668, 1660, 5912, 5993, 1669
8235, 1660, 5912, 5993, 1669, 1661, 5913, 5994, 1670
8236, 1661, 5913, 5994, 1670, 250, 2013, 2022, 251
8237, 1554, 1555, 1564, 1563, 5905, 5914, 5995, 5986
8238, 5905, 5914, 5995, 5986, 5906, 5915, 5996, 5987
8239, 5906, 5915, 5996, 5987, 5907, 5916, 5997, 5988
8240, 5907, 5916, 5997, 5988, 5908, 5917, 5998, 5989
8241, 5908, 5917, 5998, 5989, 5909, 5918, 5999, 5990
8242, 5909, 5918, 5999, 5990, 5910, 5919, 6000, 5991
8243, 5910, 5919, 6000, 5991, 5911, 5920, 6001, 5992
8244, 5911, 5920, 6001, 5992, 5912, 5921, 6002, 5993
8245, 5912, 5921, 6002, 5993, 5913, 5922, 6003, 5994
8246, 5913, 5922, 6003, 5994, 2013, 2014, 2023, 2022
8247, 1555, 1556, 1565, 1564, 5914, 5923, 6004, 5995
8248, 5914, 5923, 6004, 5995, 5915, 5924, 6005, 5996
8249, 5915, 5924, 6005, 5996, 5916, 5925, 6006, 5997
8250, 5916, 5925, 6006, 5997, 5917, 5926, 6007, 5998
8251, 5917, 5926, 6007, 5998, 5918, 5927, 6008, 5999
8252, 5918, 5927, 6008, 5999, 5919, 5928, 6009, 6000
8253, 5919, 5928, 6009, 6000, 5920, 5929, 6010, 6001
8254, 5920, 5929, 6010, 6001, 5921, 5930, 6011, 6002
8255, 5921, 5930, 6011, 6002, 5922, 5931, 6012, 6003
8256, 5922, 5931, 6012, 6003, 2014, 2015, 2024, 2023
8257, 1556, 1557, 1566, 1565, 5923, 5932, 6013, 6004
8258, 5923, 5932, 6013, 6004, 5924, 5933, 6014, 6005
8259, 5924, 5933, 6014, 6005, 5925, 5934, 6015, 6006
8260, 5925, 5934, 6015, 6006, 5926, 5935, 6016, 6007
8261, 5926, 5935, 6016, 6007, 5927, 5936, 6017, 6008
8262, 5927, 5936, 6017, 6008, 5928, 5937, 6018, 6009
8263, 5928, 5937, 6018, 6009, 5929, 5938, 6019, 6010
8264, 5929, 5938, 6019, 6010, 5930, 5939, 6020, 6011
8265, 5930, 5939, 6020, 6011, 5931, 5940, 6021, 6012
8266, 5931, 5940, 6021, 6012, 2015, 2016, 2025, 2024
8267, 1557, 1558, 1567, 1566, 5932, 5941, 6022, 6013
8268, 5932, 5941, 6022, 6013, 5933, 5942, 6023, 6014
8269, 5933, 5942, 6023, 6014, 5934, 5943, 6024, 6015
8270, 5934, 5943, 6024, 6015, 5935, 5944, 6025, 6016
8271, 5935, 5944, 6025, 6016, 5936, 5945, 6026, 6017
8272, 5936, 5945, 6026, 6017, 5937, 5946, 6027, 6018
8273, 5937, 5946, 6027, 6018, 5938, 5947, 6028, 6019
8274, 5938, 5947, 6028, 6019, 5939, 5948, 6029, 6020
8275, 5939, 5948, 6029, 6020, 5940, 5949, 6030, 6021
8276, 5940, 5949, 6030, 6021, 2016, 2017, 2026, 2025
8277, 1558, 1559, 1568, 1567, 5941, 5950, 6031, 6022
8278, 5941, 5950, 6031, 6022, 5942, 5951, 6032, 6023
8279, 5942, 5951, 6032, 6023, 5943, 5952, 6033, 6024
8280, 5943, 5952, 6033, 6024, 5944, 5953, 6034, 6025
8281, 5944, 5953, 6034, 6025, 5945, 5954, 6035, 6026
8282, 5945, 5954, 6035, 6026, 5946, 5955, 6036, 6027
8283, 5946, 5955, 6036, 6027, 5947, 5956, 6037, 6028
8284, 5947, 5956, 6037, 6028, 5948, 5957, 6038, 6029
8285, 5948, 5957, 6038, 6029, 5949, 5958, 6039, 6030
8286, 5949, 5958, 6039, 6030, 2017, 2018, 2027, 2026
8287, 1559, 1560, 1569, 1568, 5950, 5959, 6040, 6031
8288, 5950, 5959, 6040, 6031, 5951, 5960, 6041, 6032
8289, 5951, 5960, 6041, 6032, 5952, 5961, 6042, 6033
8290, 5952, 5961, 6042, 6033, 5953, 5962, 6043, 6034
8291, 5953, 5962, 6043, 6034, 5954, 5963, 6044, 6035
8292, 5954, 5963, 6044, 6035, 5955, 5964, 6045, 6036
8293, 5955, 5964, 6045, 6036, 5956, 5965, 6046, 6037
8294, 5956, 5965, 6046, 6037, 5957, 5966, 6047, 6038
8295, 5957, 5966, 6047, 6038, 5958, 5967, 6048, 6039
8296, 5958, 5967, 6048, 6039, 2018, 2019, 2028, 2027
8297, 1560, 1561, 1570, 1569, 5959, 5968, 6049, 6040
8298, 5959, 5968, 6049, 6040, 5960, 5969, 6050, 6041
8299, 5960, 5969, 6050, 6041, 5961, 5970, 6051, 6042
8300, 5961, 5970, 6051, 6042, 5962, 5971, 6052, 6043
8301, 5962, 5971, 6052, 6043, 5963, 5972, 6053, 6044
8302, 5963, 5972, 6053, 6044, 5964, 5973, 6054, 6045
8303, 5964, 5973, 6054, 6045, 5965, 5974, 6055, 6046
8304, 5965, 5974, 6055, 6046, 5966, 5975, 6056, 6047
8305, 5966, 5975, 6056, 6047, 5967, 5976, 6057, 6048
8306, 5967, 5976, 6057, 6048, 2019, 2020, 2029, 2028
8307, 1561, 1562, 1571, 1570, 5968, 5977, 6058, 6049
8308, 5968, 5977, 6058, 6049, 5969, 5978, 6059, 6050
8309, 5969, 5978, 6059, 6050, 5970, 5979, 6060, 6051
8310, 5970, 5979, 6060, 6051, 5971, 5980, 6061, 6052
8311, 5971, 5980, 6061, 6052, 5972, 5981, 6062, 6053
8312, 5972, 5981, 6062, 6053, 5973, 5982, 6063, 6054
8313, 5973, 5982, 6063, 6054, 5974, 5983, 6064, 6055
8314, 5974, 5983, 6064, 6055, 5975, 5984, 6065, 6056
8315, 5975, 5984, 6065, 6056, 5976, 5985, 6066, 6057
8316, 5976, 5985, 6066, 6057, 2020, 2021, 2030, 2029
8317, 1562, 212, 213, 1571, 5977, 1833, 1842, 6058
8318, 5977, 1833, 1842, 6058, 5978, 1834, 1843, 6059
8319, 5978, 1834, 1843, 6059, 5979, 1835, 1844, 6060
8320, 5979, 1835, 1844, 6060, 5980, 1836, 1845, 6061
8321, 5980, 1836, 1845, 6061, 5981, 1837, 1846, 6062
8322, 5981, 1837, 1846, 6062, 5982, 1838, 1847, 6063
8323, 5982, 1838, 1847, 6063, 5983, 1839, 1848, 6064
8324, 5983, 1839, 1848, 6064, 5984, 1840, 1849, 6065
8325, 5984, 1840, 1849, 6065, 5985, 1841, 1850, 6066
8326, 5985, 1841, 1850, 6066, 2021, 288, 289, 2030
8327, 193, 1563, 1572, 194, 1662, 5986, 6067, 1671
8328, 1662, 5986, 6067, 1671, 1663, 5987, 6068, 1672
8329, 1663, 5987, 6068, 1672, 1664, 5988, 6069, 1673
8330, 1664, 5988, 6069, 1673, 1665, 5989, 6070, 1674
8331, 1665, 5989, 6070, 1674, 1666, 5990, 6071, 1675
8332, 1666, 5990, 6071, 1675, 1667, 5991, 6072, 1676
8333, 1667, 5991, 6072, 1676, 1668, 5992, 6073, 1677
8334, 1668, 5992, 6073, 1677, 1669, 5993, 6074, 1678
8335, 1669, 5993, 6074, 1678, 1670, 5994, 6075, 1679
8336, 1670, 5994, 6075, 1679, 251, 2022, 2031, 252
8337, 1563, 1564, 1573, 1572, 5986, 5995, 6076, 6067
8338, 5986, 5995, 6076, 6067, 5987, 5996, 6077, 6068
8339, 5987, 5996, 6077, 6068, 5988, 5997, 6078, 6069
8340, 5988, 5997, 6078, 6069, 5989, 5998, 6079, 6070
8341, 5989, 5998, 6079, 6070, 5990, 5999, 6080, 6071
8342, 5990, 5999, 6080, 6071, 5991, 6000, 6081, 6072
8343, 5991, 6000, 6081, 6072, 5992, 6001, 6082, 6073
8344, 5992, 6001, 6082, 6073, 5993, 6002, 6083, 6074
8345, 5993, 6002, 6083, 6074, 5994, 6003, 6084, 6075
8346, 5994, 6003, 6084, 6075, 2022, 2023, 2032, 2031
8347, 1564, 1565, 1574, 1573, 5995, 6004, 6085, 6076
8348, 5995, 6004, 6085, 6076, 5996, 6005, 6086, 6077
8349, 5996, 6005, 6086, 6077, 5997, 6006, 6087, 6078
8350, 5997, 6006, 6087, 6078, 5998, 6007, 6088, 6079
8351, 5998, 6007, 6088, 6079, 5999, 6008, 6089, 6080
8352, 5999, 6008, 6089, 6080, 6000, 6009, 6090, 6081
8353, 6000, 6009, 6090, 6081, 6001, 6010, 6091, 6082
8354, 6001, 6010, 6091, 6082, 6002, 6011, 6092, 6083
8355, 6002, 6011, 6092, 6083, 6003, 6012, 6093, 6084
8356, 6003, 6012, 6093, 6084, 2023, 2024, 2033, 2032
8357, 1565, 1566, 1575, 1574, 6004, 6013, 6094, 6085
8358, 6004, 6013, 6094, 6085, 6005, 6014, 6095, 6086
8359, 6005, 6014, 6095, 6086, 6006, 6015, 6096, 6087
8360, 6006, 6015, 6096, 6087, 6007, 6016, 6097, 6088
8361, 6007, 6016, 6097, 6088, 6008, 6017, 6098, 6089
8362, 6008, 6017, 6098, 6089, 6009, 6018, 6099, 6090
8363, 6009, 6018, 6099, 6090, 6010, 6019, 6100, 6091
8364, 6010, 6019, 6100, 6091, 6011, 6020, 6101, 6092
8365, 6011, 6020, 6101, 6092, 6012, 6021, 6102, 6093
8366, 6012, 6021, 6102, 6093, 2024, 2025, 2034, 2033
8367, 1566, 1567, 1576, 1575, 6013, 6022, 6103, 6094
8368, 6013, 6022, 6103, 6094, 6014, 6023, 6104, 6095
8369, 6014, 6023, 6104, 6095, 6015, 6024, 6105, 6096
8370, 6015, 6024, 6105, 6096, 6016, 6025, 6106, 6097
8371, 6016, 6025, 6106, 6097, 6017, 6026, 6107, 6098
8372, 6017, 6026, 6107, 6098, 6018, 6027, 6108, 6099
8373, 6018, 6027, 6108, 6099, 6019, 6028, 6109, 6100
8374, 6019, 6028, 6109, 6100, 6020, 6029, 6110, 6101
8375, 6020, 6029, 6110, 6101, 6021, 6030, 6111, 6102
8376, 6021, 6030, 6111, 6102, 2025, 2026, 2035, 2034
8377, 1567, 1568, 1577, 1576, 6022, 6031, 6112, 6103
8378, 6022, 6031, 6112, 6103, 6023, 6032, 6113, 6104
8379, 6023, 6032, 6113, 6104, 6024, 6033, 6114, 6105
8380, 6024, 6033, 6114, 6105, 6025, 6034, 6115, 6106
8381, 6025, 6034, 6115, 6106, 6026, 6035, 6116, 6107
8382, 6026, 6035, 6116, 6107, 6027, 6036, 6117, 6108
8383, 6027, 6036, 6117, 6108, 6028, 6037, 6118, 6109
8384, 6028, 6037, 6118, 6109, 6029, 6038, 6119, 6110
8385, 6029, 6038, 6119, 6110, 6030, 6039, 6120, 6111
8386, 6030, 6039, 6120, 6111, 2026, 2027, 2036, 2035
8387, 1568, 1569, 1578, 1577, 6031, 6040, 6121, 6112
8388, 6031, 6040, 6121, 6112, 6032, 6041, 6122, 6113
8389, 6032, 6041, 6122, 6113, 6033, 6042, 6123, 6114
8390, 6033, 6042, 6123, 6114, 6034, 6043, 6124, 6115
8391, 6034, 6043, 6124, 6115, 6035, 6044, 6125, 6116
8392, 6035, 6044, 6125, 6116, 6036, 6045, 6126, 6117
8393, 6036, 6045, 6126, 6117, 6037, 6046, 6127, 6118
8394, 6037, 6046, 6127, 6118, 6038, 6047, 6128, 6119
8395, 6038, 6047, 6128, 6119, 6039, 6048, 6129, 6120
8396, 6039, 6048, 6129, 6120, 2027, 2028, 2037, 2036
8397, 1569, 1570, 1579, 1578, 6040, 6049, 6130, 6121
8398, 6040, 6049, 6130, 6121, 6041, 6050, 6131, 6122
8399, 6041, 6050, 6131, 6122, 6042, 6051, 6132, 6123
8400, 6042, 6051, 6132, 6123, 6043, 6052, 6133, 6124
8401, 6043, 6052, 6133, 6124, 6044, 6053, 6134, 6125
8402, 6044, 6053, 6134, 6125, 6045, 6054, 6135, 6126
8403, 6045, 6054, 6135, 6126, 6046, 6055, 6136, 6127
8404, 6046, 6055, 6136, 6127, 6047, 6056, 6137, 6128
8405, 6047, 6056, 6137, 6128, 6048, 6057, 6138, 6129
8406, 6048, 6057, 6138, 6129, 2028, 2029, 2038, 2037
8407, 1570, 1571, 1580, 1579, 6049, 6058, 6139, 6130
8408, 6049, 6058, 6139, 6130, 6050, 6059, 6140, 6131
8409, 6050, 6059, 6140, 6131, 6051, 6060, 6141, 6132
8410, 6051, 6060, 6141, 6132, 6052, 6061, 6142, 6133
8411, 6052, 6061, 6142, 6133, 6053, 6062, 6143, 6134
8412, 6053, 6062, 6143, 6134, 6054, 6063, 6144, 6135
8413, 6054, 6063, 6144, 6135, 6055, 6064, 6145, 6136
8414, 6055, 6064, 6145, 6136, 6056, 6065, 6146, 6137
8415, 6056, 6065, 6146, 6137, 6057, 6066, 6147, 6138
8416, 6057, 6066, 6147, 6138, 2029, 2030, 2039, 2038
8417, 1571, 213, 214, 1580, 6058, 1842, 1851, 6139
8418, 6058, 1842, 1851, 6139, 6059, 1843, 1852, 6140
8419, 6059, 1843, 1852, 6140, 6060, 1844, 1853, 6141
8420, 6060, 1844, 1853, 6141, 6061, 1845, 1854, 6142
8421, 6061, 1845, 1854, 6142, 6062, 1846, 1855, 6143
8422, 6062, 1846, 1855, 6143, 6063, 1847, 1856, 6144
8423, 6063, 1847, 1856, 6144, 6064, 1848, 1857, 6145
8424, 6064, 1848, 1857, 6145, 6065, 1849, 1858, 6146
8425, 6065, 1849, 1858, 6146, 6066, 1850, 1859, 6147
8426, 6066, 1850, 1859, 6147, 2030, 289, 290, 2039
8427, 194, 1572, 1581, 195, 1671, 6067, 6148, 1680
8428, 1671, 6067, 6148, 1680, 1672, 6068, 6149, 1681
8429, 1672, 6068, 6149, 1681, 1673, 6069, 6150, 1682
8430, 1673, 6069, 6150, 1682, 1674, 6070, 6151, 1683
8431, 1674, 6070, 6151, 1683, 1675, 6071, 6152, 1684
8432, 1675, 6071, 6152, 1684, 1676, 6072, 6153, 1685
8433, 1676, 6072, 6153, 1685, 1677, 6073, 6154, 1686
8434, 1677, 6073, 6154, 1686, 1678, 6074, 6155, 1687
8435, 1678, 6074, 6155, 1687, 1679, 6075, 6156, 1688
8436, 1679, 6075, 6156, 1688, 252, 2031, 2040, 253
8437, 1572, 1573, 1582, 1581, 6067, 6076, 6157, 6148
8438, 6067, 6076, 6157, 6148, 6068, 6077, 6158, 6149
8439, 6068, 6077, 6158, 6149, 6069, 6078, 6159, 6150
8440, 6069, 6078, 6159, 6150, 6070, 6079, 6160, 6151
8441, 6070, 6079, 6160, 6151, 6071, 6080, 6161, 6152
8442, 6071, 6080, 6161, 6152, 6072, 6081, 6162, 6153
8443, 6072, 6081, 6162, 6153, 6073, 6082, 6163, 6154
8444, 6073, 6082, 6163, 6154, 6074, 6083, 6164, 6155
8445, 6074, 6083, 6164, 6155, 6075, 6084, 6165, 6156
8446, 6075, 6084, 6165, 6156, 2031, 2032, 2041, 2040
8447, 1573, 1574, 1583, 1582, 6076, 6085, 6166, 6157
8448, 6076, 6085, 6166, 6157, 6077, 6086, 6167, 6158
8449, 6077, 6086, 6167, 6158, 6078, 6087, 6168, 6159
8450, 6078, 6087, 6168, 6159, 6079, 6088, 6169, 6160
8451, 6079, 6088, 6169, 6160, 6080, 6089, 6170, 6161
8452, 6080, 6089, 6170, 6161, 6081, 6090, 6171, 6162
8453, 6081, 6090, 6171, 6162, 6082, 6091, 6172, 6163
8454, 6082, 6091, 6172, 6163, 6083, 6092, 6173, 6164
8455, 6083, 6092, 6173, 6164, 6084, 6093, 6174, 6165
8456, 6084, 6093, 6174, 6165, 2032, 2033, 2042, 2041
8457, 1574, 1575, 1584, 1583, 6085, 6094, 6175, 6166
8458, 6085, 6094, 6175, 6166, 6086, 6095, 6176, 6167
8459, 6086, 6095, 6176, 6167, 6087, 6096, 6177, 6168
8460, 6087, 6096, 6177, 6168, 6088, 6097, 6178, 6169
8461, 6088, 6097, 6178, 6169, 6089, 6098, 6179, 6170
8462, 6089, 6098, 6179, 6170, 6090, 6099, 6180, 6171
8463, 6090, 6099, 6180, 6171, 6091, 6100, 6181, 6172
8464, 6091, 6100, 6181, 6172, 6092, 6101, 6182, 6173
8465, 6092, 6101, 6182, 6173, 6093, 6102, 6183, 6174
8466, 6093, 6102, 6183, 6174, 2033, 2034, 2043, 2042
8467, 1575, 1576, 1585, 1584, 6094, 6103, 6184, 6175
8468, 6094, 6103, 6184, 6175, 6095, 6104, 6185, 6176
8469, 6095, 6104, 6185, 6176, 6096, 6105, 6186, 6177
8470, 6096, 6105, 6186, 6177, 6097, 6106, 6187, 6178
8471, 6097, 6106, 6187, 6178, 6098, 6107, 6188, 6179
8472, 6098, 6107, 6188, 6179, 6099, 6108, 6189, 6180
8473, 6099, 6108, 6189, 6180, 6100, 6109, 6190, 6181
8474, 6100, 6109, 6190, 6181, 6101, 6110, 6191, 6182
8475, 6101, 6110, 6191, 6182, 6102, 6111, 6192, 6183
8476, 6102, 6111, 6192, 6183, 2034, 2035, 2044, 2043
8477, 1576, 1577, 1586, 1585, 6103, 6112, 6193, 6184
8478, 6103, 6112, 6193, 6184, 6104, 6113, 6194, 6185
8479, 6104, 6113, 6194, 6185, 6105, 6114, 6195, 6186
8480, 6105, 6114, 6195, 6186, 6106, 6115, 6196, 6187
8481, 6106, 6115, 6196, 6187, 6107, 6116, 6197, 6188
8482, 6107, 6116, 6197, 6188, 6108, 6117, 6198, 6189
8483, 6108, 6117, 6198, 6189, 6109, 6118, 6199, 6190
8484, 6109, 6118, 6199, 6190, 6110, 6119, 6200, 6191
8485, 6110, 6119, 6200, 6191, 6111, 6120, 6201, 6192
8486, 6111, 6120, 6201, 6192, 2035, 2036, 2045, 2044
8487, 1577, 1578, 1587, 1586, 6112, 6121, 6202, 6193
8488, 6112, 6121, 6202, 6193, 6113, 6122, 6203, 6194
8489, 6113, 6122, 6203, 6194, 6114, 6123, 6204, 6195
8490, 6114, 6123, 6204, 6195, 6115, 6124, 6205, 6196
8491, 6115, 6124, 6205, 6196, 6116, 6125, 6206, 6197
8492, 6116, 6125, 6206, 6197, 6117, 6126, 6207, 6198
8493, 6117, 6126, 6207, 6198, 6118, 6127, 6208, 6199
8494, 6118, 6127, 6208, 6199, 6119, 6128, 6209, 6200
8495, 6119, 6128, 6209, 6200, 6120, 6129, 6210, 6201
8496, 6120, 6129, 6210, 6201, 2036, 2037, 2046, 2045
8497, 1578, 1579, 1588, 1587, 6121, 6130, 6211, 6202
8498, 6121, 6130, 6211, 6202, 6122, 6131, 6212, 6203
8499, 6122, 6131, 6212, 6203, 6123, 6132, 6213, 6204
8500, 6123, 6132, 6213, 6204, 6124, 6133, 6214, 6205
8501, 6124, 6133, 6214, 6205, 6125, 6134, 6215, 6206
8502, 6125, 6134, 6215, 6206, 6126, 6135, 6216, 6207
8503, 6126, 6135, 6216, 6207, 6127, 6136, 6217, 6208
8504, 6127, 6136, 6217, 6208, 6128, 6137, 6218, 6209
8505, 6128, 6137, 6218, 6209, 6129, 6138, 6219, 6210
8506, 6129, 6138, 6219, 6210, 2037, 2038, 2047, 2046
8507, 1579, 1580, 1589, 1588, 6130, 6139, 6220, 6211
8508, 6130, 6139, 6220, 6211, 6131, 6140, 6221, 6212
8509, 6131, 6140, 6221, 6212, 6132, 6141, 6222, 6213
8510, 6132, 6141, 6222, 6213, 6133, 6142, 6223, 6214
8511, 6133, 6142, 6223, 6214, 6134, 6143, 6224, 6215
8512, 6134, 6143, 6224, 6215, 6135, 6144, 6225, 6216
8513, 6135, 6144, 6225, 6216, 6136, 6145, 6226, 6217
8514, 6136, 6145, 6226, 6217, 6137, 6146, 6227, 6218
8515, 6137, 6146, 6227, 6218, 6138, 6147, 6228, 6219
8516, 6138, 6147, 6228, 6219, 2038, 2039, 2048, 2047
8517, 1580, 214, 215, 1589, 6139, 1851, 1860, 6220
8518, 6139, 1851, 1860, 6220, 6140, 1852, 1861, 6221
8519, 6140, 1852, 1861, 6221, 6141, 1853, 1862, 6222
8520, 6141, 1853, 1862, 6222, 6142, 1854, 1863, 6223
8521, 6142, 1854, 1863, 6223, 6143, 1855, 1864, 6224
8522, 6143, 1855, 1864, 6224, 6144, 1856, 1865, 6225
8523, 6144, 1856, 1865, 6225, 6145, 1857, 1866, 6226
8524, 6145, 1857, 1866, 6226, 6146, 1858, 1867, 6227
8525, 6146, 1858, 1867, 6227, 6147, 1859, 1868, 6228
8526, 6147, 1859, 1868, 6228, 2039, 290, 291, 2048
8527, 195, 1581, 1590, 196, 1680, 6148, 6229, 1689
8528, 1680, 6148, 6229, 1689, 1681, 6149, 6230, 1690
8529, 1681, 6149, 6230, 1690, 1682, 6150, 6231, 1691
8530, 1682, 6150, 6231, 1691, 1683, 6151, 6232, 1692
8531, 1683, 6151, 6232, 1692, 1684, 6152, 6233, 1693
8532, 1684, 6152, 6233, 1693, 1685, 6153, 6234, 1694
8533, 1685, 6153, 6234, 1694, 1686, 6154, 6235, 1695
8534, 1686, 6154, 6235, 1695, 1687, 6155, 6236, 1696
8535, 1687, 6155, 6236, 1696, 1688, 6156, 6237, 1697
8536, 1688, 6156, 6237, 1697, 253, 2040, 2049, 254
8537, 1581, 1582, 1591, 1590, 6148, 6157, 6238, 6229
8538, 6148, 6157, 6238, 6229, 6149, 6158, 6239, 6230
8539, 6149, 6158, 6239, 6230, 6150, 6159, 6240, 6231
8540, 6150, 6159, 6240, 6231, 6151, 6160, 6241, 6232
8541, 6151, 6160, 6241, 6232, 6152, 6161, 6242, 6233
8542, 6152, 6161, 6242, 6233, 6153, 6162, 6243, 6234
8543, 6153, 6162, 6243, 6234, 6154, 6163, 6244, 6235
8544, 6154, 6163, 6244, 6235, 6155, 6164, 6245, 6236
8545, 6155, 6164, 6245, 6236, 6156, 6165, 6246, 6237
8546, 6156, 6165, 6246, 6237, 2040, 2041, 2050, 2049
8547, 1582, 1583, 1592, 1591, 6157, 6166, 6247, 6238
8548, 6157, 6166, 6247, 6238, 6158, 6167, 6248, 6239
8549, 6158, 6167, 6248, 6239, 6159, 6168, 6249, 6240
8550, 6159, 6168, 6249, 6240, 6160, 6169, 6250, 6241
8551, 6160, 6169, 6250, 6241, 6161, 6170, 6251, 6242
8552, 6161, 6170, 6251, 6242, 6162, 6171, 6252, 6243
8553, 6162, 6171, 6252, 6243, 6163, 6172, 6253, 6244
8554, 6163, 6172, 6253, 6244, 6164, 6173, 6254, 6245
8555, 6164, 6173, 6254, 6245, 6165, 6174, 6255, 6246
8556, 6165, 6174, 6255, 6246, 2041, 2042, 2051, 2050
8557, 1583, 1584, 1593, 1592, 6166, 6175, 6256, 6247
8558, 6166, 6175, 6256, 6247, 6167, 6176, 6257, 6248
8559, 6167, 6176, 6257, 6248, 6168, 6177, 6258, 6249
8560, 6168, 6177, 6258, 6249, 6169, 6178, 6259, 6250
8561, 6169, 6178, 6259, 6250, 6170, 6179, 6260, 6251
8562, 6170, 6179, 6260, 6251, 6171, 6180, 6261, 6252
8563, 6171, 6180, 6261, 6252, 6172, 6181, 6262, 6253
8564, 6172, 6181, 6262, 6253, 6173, 6182, 6263, 6254
8565, 6173, 6182, 6263, 6254, 6174, 6183, 6264, 6255
8566, 6174, 6183, 6264, 6255, 2042, 2043, 2052, 2051
8567, 1584, 1585, 1594, 1593, 6175, 6184, 6265, 6256
8568, 6175, 6184, 6265, 6256, 6176, 6185, 6266, 6257
8569, 6176, 6185, 6266, 6257, 6177, 6186, 6267, 6258
8570, 6177, 6186, 6267, 6258, 6178, 6187, 6268, 6259
8571, 6178, 6187, 6268, 6259, 6179, 6188, 6269, 6260
8572, 6179, 6188, 6269, 6260, 6180, 6189, 6270, 6261
8573, 6180, 6189, 6270, 6261, 6181, 6190, 6271, 6262
8574, 6181, 6190, 6271, 6262, 6182, 6191, 6272, 6263
8575, 6182, 6191, 6272, 6263, 6183, 6192, 6273, 6264
8576, 6183, 6192, 6273, 6264, 2043, 2044, 2053, 2052
8577, 1585, 1586, 1595, 1594, 6184, 6193, 6274, 6265
8578, 6184, 6193, 6274, 6265, 6185, 6194, 6275, 6266
8579, 6185, 6194, 6275, 6266, 6186, 6195, 6276, 6267
8580, 6186, 6195, 6276, 6267, 6187, 6196, 6277, 6268
8581, 6187, 6196, 6277, 6268, 6188, 6197, 6278, 6269
8582, 6188, 6197, 6278, 6269, 6189, 6198, 6279, 6270
8583, 6189, 6198, 6279, 6270, 6190, 6199, 6280, 6271
8584, 6190, 6199, 6280, 6271, 6191, 6200, 6281, 6272
8585, 6191, 6200, 6281, 6272, 6192, 6201, 6282, 6273
8586, 6192, 6201, 6282, 6273, 2044, 2045, 2054, 2053
8587, 1586, 1587, 1596, 1595, 6193, 6202, 6283, 6274
8588, 6193, 6202, 6283, 6274, 6194, 6203, 6284, 6275
8589, 6194, 6203, 6284, 6275, 6195, 6204, 6285, 6276
8590, 6195, 6204, 6285, 6276, 6196, 6205, 6286, 6277
8591, 6196, 6205, 6286, 6277, 6197, 6206, 6287, 6278
8592, 6197, 6206, 6287, 6278, 6198, 6207, 6288, 6279
8593, 6198, 6207, 6288, 6279, 6199, 6208, 6289, 6280
8594, 6199, 6208, 6289, 6280, 6200, 6209, 6290, 6281
8595, 6200, 6209, 6290, 6281, 6201, 6210, 6291, 6282
8596, 6201, 6210, 6291, 6282, 2045, 2046, 2055, 2054
8597, 1587, 1588, 1597, 1596, 6202, 6211, 6292, 6283
8598, 6202, 6211, 6292, 6283, 6203, 6212, 6293, 6284
8599, 6203, 6212, 6293, 6284, 6204, 6213, 6294, 6285
8600, 6204, 6213, 6294, 6285, 6205, 6214, 6295, 6286
8601, 6205, 6214, 6295, 6286, 6206, 6215, 6296, 6287
8602, 6206, 6215, 6296, 6287, 6207, 6216, 6297, 6288
8603, 6207, 6216, 6297, 6288, 6208, 6217, 6298, 6289
8604, 6208, 6217, 6298, 6289, 6209, 6218, 6299, 6290
8605, 6209, 6218, 6299, 6290, 6210, 6219, 6300, 6291
8606, 6210, 6219, 6300, 6291, 2046, 2047, 2056, 2055
8607, 1588, 1589, 1598, 1597, 6211, 6220, 6301, 6292
8608, 6211, 6220, 6301, 6292, 6212, 6221, 6302, 6293
8609, 6212, 6221, 6302, 6293, 6213, 6222, 6303, 6294
8610, 6213, 6222, 6303, 6294, 6214, 6223, 6304, 6295
8611, 6214, 6223, 6304, 6295, 6215, 6224, 6305, 6296
8612, 6215, 6224, 6305, 6296, 6216, 6225, 6306, 6297
8613, 6216, 6225, 6306, 6297, 6217, 6226, 6307, 6298
8614, 6217, 6226, 6307, 6298, 6218, 6227, 6308, 6299
8615, 6218, 6227, 6308, 6299, 6219, 6228, 6309, 6300
8616, 6219, 6228, 6309, 6300, 2047, 2048, 2057, 2056
8617, 1589, 215, 216, 1598, 6220, 1860, 1869, 6301
8618, 6220, 1860, 1869, 6301, 6221, 1861, 1870, 6302
8619, 6221, 1861, 1870, 6302, 6222, 1862, 1871, 6303
8620, 6222, 1862, 1871, 6303, 6223, 1863, 1872, 6304
8621, 6223, 1863, 1872, 6304, 6224, 1864, 1873, 6305
8622, 6224, 1864, 1873, 6305, 6225, 1865, 1874, 6306
8623, 6225, 1865, 1874, 6306, 6226, 1866, 1875, 6307
8624, 6226, 1866, 1875, 6307, 6227, 1867, 1876, 6308
8625, 6227, 1867, 1876, 6308, 6228, 1868, 1877, 6309
8626, 6228, 1868, 1877, 6309, 2048, 291, 292, 2057
8627, 196, 1590, 1599, 197, 1689, 6229, 6310, 1698
8628, 1689, 6229, 6310, 1698, 1690, 6230, 6311, 1699
8629, 1690, 6230, 6311, 1699, 1691, 6231, 6312, 1700
8630, 1691, 6231, 6312, 1700, 1692, 6232, 6313, 1701
8631, 1692, 6232, 6313, 1701, 1693, 6233, 6314, 1702
8632, 1693, 6233, 6314, 1702, 1694, 6234, 6315, 1703
8633, 1694, 6234, 6315, 1703, 1695, 6235, 6316, 1704
8634, 1695, 6235, 6316, 1704, 1696, 6236, 6317, 1705
8635, 1696, 6236, 6317, 1705, 1697, 6237, 6318, 1706
8636, 1697, 6237, 6318, 1706, 254, 2049, 2058, 255
8637, 1590, 1591, 1600, 1599, 6229, 6238, 6319, 6310
8638, 6229, 6238, 6319, 6310, 6230, 6239, 6320, 6311
8639, 6230, 6239, 6320, 6311, 6231, 6240, 6321, 6312
8640, 6231, 6240, 6321, 6312, 6232, 6241, 6322, 6313
8641, 6232, 6241, 6322, 6313, 6233, 6242, 6323, 6314
8642, 6233, 6242, 6323, 6314, 6234, 6243, 6324, 6315
8643, 6234, 6243, 6324, 6315, 6235, 6244, 6325, 6316
8644, 6235, 6244, 6325, 6316, 6236, 6245, 6326, 6317
8645, 6236, 6245, 6326, 6317, 6237, 6246, 6327, 6318
8646, 6237, 6246, 6327, 6318, 2049, 2050, 2059, 2058
8647, 1591, 1592, 1601, 1600, 6238, 6247, 6328, 6319
8648, 6238, 6247, 6328, 6319, 6239, 6248, 6329, 6320
8649, 6239, 6248, 6329, 6320, 6240, 6249, 6330, 6321
8650, 6240, 6249, 6330, 6321, 6241, 6250, 6331, 6322
8651, 6241, 6250, 6331, 6322, 6242, 6251, 6332, 6323
8652, 6242, 6251, 6332, 6323, 6243, 6252, 6333, 6324
8653, 6243, 6252, 6333, 6324, 6244, 6253, 6334, 6325
8654, 6244, 6253, 6334, 6325, 6245, 6254, 6335, 6326
8655, 6245, 6254, 6335, 6326, 6246, 6255, 6336, 6327
8656, 6246, 6255, 6336, 6327, 2050, 2051, 2060, 2059
8657, 1592, 1593, 1602, 1601, 6247, 6256, 6337, 6328
8658, 6247, 6256, 6337, 6328, 6248, 6257, 6338, 6329
8659, 6248, 6257, 6338, 6329, 6249, 6258, 6339, 6330
8660, 6249, 6258, 6339, 6330, 6250, 6259, 6340, 6331
8661, 6250, 6259, 6340, 6331, 6251, 6260, 6341, 6332
8662, 6251, 6260, 6341, 6332, 6252, 6261, 6342, 6333
8663, 6252, 6261, 6342, 6333, 6253, 6262, 6343, 6334
8664, 6253, 6262, 6343, 6334, 6254, 6263, 6344, 6335
8665, 6254, 6263, 6344, 6335, 6255, 6264, 6345, 6336
8666, 6255, 6264, 6345, 6336, 2051, 2052, 2061, 2060
8667, 1593, 1594, 1603, 1602, 6256, 6265, 6346, 6337
8668, 6256, 6265, 6346, 6337, 6257, 6266, 6347, 6338
8669, 6257, 6266, 6347, 6338, 6258, 6267, 6348, 6339
8670, 6258, 6267, 6348, 6339, 6259, 6268, 6349, 6340
8671, 6259, 6268, 6349, 6340, 6260, 6269, 6350, 6341
8672, 6260, 6269, 6350, 6341, 6261, 6270, 6351, 6342
8673, 6261, 6270, 6351, 6342, 6262, 6271, 6352, 6343
8674, 6262, 6271, 6352, 6343, 6263, 6272, 6353, 6344
8675, 6263, 6272, 6353, 6344, 6264, 6273, 6354, 6345
8676, 6264, 6273, 6354, 6345, 2052, 2053, 2062, 2061
8677, 1594, 1595, 1604, 1603, 6265, 6274, 6355, 6346
8678, 6265, 6274, 6355, 6346, 6266, 6275, 6356, 6347
8679, 6266, 6275, 6356, 6347, 6267, 6276, 6357, 6348
8680, 6267, 6276, 6357, 6348, 6268, 6277, 6358, 6349
8681, 6268, 6277, 6358, 6349, 6269, 6278, 6359, 6350
8682, 6269, 6278, 6359, 6350, 6270, 6279, 6360, 6351
8683, 6270, 6279, 6360, 6351, 6271, 6280, 6361, 6352
8684, 6271, 6280, 6361, 6352, 6272, 6281, 6362, 6353
8685, 6272, 6281, 6362, 6353, 6273, 6282, 6363, 6354
8686, 6273, 6282, 6363, 6354, 2053, 2054, 2063, 2062
8687, 1595, 1596, 1605, 1604, 6274, 6283, 6364, 6355
8688, 6274, 6283, 6364, 6355, 6275, 6284, 6365, 6356
8689, 6275, 6284, 6365, 6356, 6276, 6285, 6366, 6357
8690, 6276, 6285, 6366, 6357, 6277, 6286, 6367, 6358
8691, 6277, 6286, 6367, 6358, 6278, 6287, 6368, 6359
8692, 6278, 6287, 6368, 6359, 6279, 6288, 6369, 6360
8693, 6279, 6288, 6369, 6360, 6280, 6289, 6370, 6361
8694, 6280, 6289, 6370, 6361, 6281, 6290, 6371, 6362
8695, 6281, 6290, 6371, 6362, 6282, 6291, 6372, 6363
8696, 6282, 6291, 6372, 6363, 2054, 2055, 2064, 2063
8697, 1596, 1597, 1606, 1605, 6283, 6292, 6373, 6364
8698, 6283, 6292, 6373, 6364, 6284, 6293, 6374, 6365
8699, 6284, 6293, 6374, 6365, 6285, 6294, 6375, 6366
8700, 6285, 6294, 6375, 6366, 6286, 6295, 6376, 6367
8701, 6286, 6295, 6376, 6367, 6287, 6296, 6377, 6368
8702, 6287, 6296, 6377, 6368, 6288, 6297, 6378, 6369
8703, 6288, 6297, 6378, 6369, 6289, 6298, 6379, 6370
8704, 6289, 6298, 6379, 6370, 6290, 6299, 6380, 6371
8705, 6290, 6299, 6380, 6371, 6291, 6300, 6381, 6372
8706, 6291, 6300, 6381, 6372, 2055, 2056, 2065, 2064
8707, 1597, 1598, 1607, 1606, 6292, 6301, 6382, 6373
8708, 6292, 6301, 6382, 6373, 6293, 6302, 6383, 6374
8709, 6293, 6302, 6383, 6374, 6294, 6303, 6384, 6375
8710, 6294, 6303, 6384, 6375, 6295, 6304, 6385, 6376
8711, 6295, 6304, 6385, 6376, 6296, 6305, 6386, 6377
8712, 6296, 6305, 6386, 6377, 6297, 6306, 6387, 6378
8713, 6297, 6306, 6387, 6378, 6298, 6307, 6388, 6379
8714, 6298, 6307, 6388, 6379, 6299, 6308, 6389, 6380
8715, 6299, 6308, 6389, 6380, 6300, 6309, 6390, 6381
8716, 6300, 6309, 6390, 6381, 2056, 2057, 2066, 2065
8717, 1598, 216, 217, 1607, 6301, 1869, 1878, 6382
8718, 6301, 1869, 1878, 6382, 6302, 1870, 1879, 6383
8719, 6302, 1870, 1879, 6383, 6303, 1871, 1880, 6384
8720, 6303, 1871, 1880, 6384, 6304, 1872, 1881, 6385
8721, 6304, 1872, 1881, 6385, 6305, 1873, 1882, 6386
8722, 6305, 1873, 1882, 6386, 6306, 1874, 1883, 6387
8723, 6306, 1874, 1883, 6387, 6307, 1875, 1884, 6388
8724, 6307, 1875, 1884, 6388, 6308, 1876, 1885, 6389
8725, 6308, 1876, 1885, 6389, 6309, 1877, 1886, 6390
8726, 6309, 1877, 1886, 6390, 2057, 292, 293, 2066
8727, 197, 1599, 1608, 198, 1698, 6310, 6391, 1707
8728, 1698, 6310, 6391, 1707, 1699, 6311, 6392, 1708
8729, 1699, 6311, 6392, 1708, 1700, 6312, 6393, 1709
8730, 1700, 6312, 6393, 1709, 1701, 6313, 6394, 1710
8731, 1701, 6313, 6394, 1710, 1702, 6314, 6395, 1711
8732, 1702, 6314, 6395, 1711, 1703, 6315, 6396, 1712
8733, 1703, 6315, 6396, 1712, 1704, 6316, 6397, 1713
8734, 1704, 6316, 6397, 1713, 1705, 6317, 6398, 1714
8735, 1705, 6317, 6398, 1714, 1706, 6318, 6399, 1715
8736, 1706, 6318, 6399, 1715, 255, 2058, 2067, 256
8737, 1599, 1600, 1609, 1608, 6310, 6319, 6400, 6391
8738, 6310, 6319, 6400, 6391, 6311, 6320, 6401, 6392
8739, 6311, 6320, 6401, 6392, 6312, 6321, 6402, 6393
8740, 6312, 6321, 6402, 6393, 6313, 6322, 6403, 6394
8741, 6313, 6322, 6403, 6394, 6314, 6323, 6404, 6395
8742, 6314, 6323, 6404, 6395, 6315, 6324, 6405, 6396
8743, 6315, 6324, 6405, 6396, 6316, 6325, 6406, 6397
8744, 6316, 6325, 6406, 6397, 6317, 6326, 6407, 6398
8745, 6317, 6326, 6407, 6398, 6318, 6327, 6408, 6399
8746, 6318, 6327, 6408, 6399, 2058, 2059, 2068, 2067
8747, 1600, 1601, 1610, 1609, 6319, 6328, 6409, 6400
8748, 6319, 6328, 6409, 6400, 6320, 6329, 6410, 6401
8749, 6320, 6329, 6410, 6401, 6321, 6330, 6411, 6402
8750, 6321, 6330, 6411, 6402, 6322, 6331, 6412, 6403
8751, 6322, 6331, 6412, 6403, 6323, 6332, 6413, 6404
8752, 6323, 6332, 6413, 6404, 6324, 6333, 6414, 6405
8753, 6324, 6333, 6414, 6405, 6325, 6334, 6415, 6406
8754, 6325, 6334, 6415, 6406, 6326, 6335, 6416, 6407
8755, 6326, 6335, 6416, 6407, 6327, 6336, 6417, 6408
8756, 6327, 6336, 6417, 6408, 2059, 2060, 2069, 2068
8757, 1601, 1602, 1611, 1610, 6328, 6337, 6418, 6409
8758, 6328, 6337, 6418, 6409, 6329, 6338, 6419, 6410
8759, 6329, 6338, 6419, 6410, 6330, 6339, 6420, 6411
8760, 6330, 6339, 6420, 6411, 6331, 6340, 6421, 6412
8761, 6331, 6340, 6421, 6412, 6332, 6341, 6422, 6413
8762, 6332, 6341, 6422, 6413, 6333, 6342, 6423, 6414
8763, 6333, 6342, 6423, 6414, 6334, 6343, 6424, 6415
8764, 6334, 6343, 6424, 6415, 6335, 6344, 6425, 6416
8765, 6335, 6344, 6425, 6416, 6336, 6345, 6426, 6417
8766, 6336, 6345, 6426, 6417, 2060, 2061, 2070, 2069
8767, 1602, 1603, 1612, 1611, 6337, 6346, 6427, 6418
8768, 6337, 6346, 6427, 6418, 6338, 6347, 6428, 6419
8769, 6338, 6347, 6428, 6419, 6339, 6348, 6429, 6420
8770, 6339, 6348, 6429, 6420, 6340, 6349, 6430, 6421
8771, 6340, 6349, 6430, 6421, 6341, 6350, 6431, 6422
8772, 6341, 6350, 6431, 6422, 6342, 6351, 6432, 6423
8773, 6342, 6351, 6432, 6423, 6343, 6352, 6433, 6424
8774, 6343, 6352, 6433, 6424, 6344, 6353, 6434, 6425
8775, 6344, 6353, 6434, 6425, 6345, 6354, 6435, 6426
8776, 6345, 6354, 6435, 6426, 2061, 2062, 2071, 2070
8777, 1603, 1604, 1613, 1612, 6346, 6355, 6436, 6427
8778, 6346, 6355, 6436, 6427, 6347, 6356, 6437, 6428
8779, 6347, 6356, 6437, 6428, 6348, 6357, 6438, 6429
8780, 6348, 6357, 6438, 6429, 6349, 6358, 6439, 6430
8781, 6349, 6358, 6439, 6430, 6350, 6359, 6440, 6431
8782, 6350, 6359, 6440, 6431, 6351, 6360, 6441, 6432
8783, 6351, 6360, 6441, 6432, 6352, 6361, 6442, 6433
8784, 6352, 6361, 6442, 6433, 6353, 6362, 6443, 6434
8785, 6353, 6362, 6443, 6434, 6354, 6363, 6444, 6435
8786, 6354, 6363, 6444, 6435, 2062, 2063, 2072, 2071
8787, 1604, 1605, 1614, 1613, 6355, 6364, 6445, 6436
8788, 6355, 6364, 6445, 6436, 6356, 6365, 6446, 6437
8789, 6356, 6365, 6446, 6437, 6357, 6366, 6447, 6438
8790, 6357, 6366, 6447, 6438, 6358, 6367, 6448, 6439
8791, 6358, 6367, 6448, 6439, 6359, 6368, 6449, 6440
8792, 6359, 6368, 6449, 6440, 6360, 6369, 6450, 6441
8793, 6360, 6369, 6450, 6441, 6361, 6370, 6451, 6442
8794, 6361, 6370, 6451, 6442, 6362, 6371, 6452, 6443
8795, 6362, 6371, 6452, 6443, 6363, 6372, 6453, 6444
8796, 6363, 6372, 6453, 6444, 2063, 2064, 2073, 2072
8797, 1605, 1606, 1615, 1614, 6364, 6373, 6454, 6445
8798, 6364, 6373, 6454, 6445, 6365, 6374, 6455, 6446
8799, 6365, 6374, 6455, 6446, 6366, 6375, 6456, 6447
8800, 6366, 6375, 6456, 6447, 6367, 6376, 6457, 6448
8801, 6367, 6376, 6457, 6448, 6368, 6377, 6458, 6449
8802, 6368, 6377, 6458, 6449, 6369, 6378, 6459, 6450
8803, 6369, 6378, 6459, 6450, 6370, 6379, 6460, 6451
8804, 6370, 6379, 6460, 6451, 6371, 6380, 6461, 6452
8805, 6371, 6380, 6461, 6452, 6372, 6381, 6462, 6453
8806, 6372, 6381, 6462, 6453, 2064, 2065, 2074, 2073
8807, 1606, 1607, 1616, 1615, 6373, 6382, 6463, 6454
8808, 6373, 6382, 6463, 6454, 6374, 6383, 6464, 6455
8809, 6374, 6383, 6464, 6455, 6375, 6384, 6465, 6456
8810, 6375, 6384, 6465, 6456, 6376, 6385, 6466, 6457
8811, 6376, 6385, 6466, 6457, 6377, 6386, 6467, 6458
8812, 6377, 6386, 6467, 6458, 6378, 6387, 6468, 6459
8813, 6378, 6387, 6468, 6459, 6379, 6388, 6469, 6460
8814, 6379, 6388, 6469, 6460, 6380, 6389, 6470, 6461
8815, 6380, 6389, 6470, 6461, 6381, 6390, 6471, 6462
8816, 6381, 6390, 6471, 6462, 2065, 2066, 2075, 2074
8817, 1607, 217, 218, 1616, 6382, 1878, 1887, 6463
8818, 6382, 1878, 1887, 6463, 6383, 1879, 1888, 6464
8819, 6383, 1879, 1888, 6464, 6384, 1880, 1889, 6465
8820, 6384, 1880, 1889, 6465, 6385, 1881, 1890, 6466
8821, 6385, 1881, 1890, 6466, 6386, 1882, 1891, 6467
8822, 6386, 1882, 1891, 6467, 6387, 1883, 1892, 6468
8823, 6387, 1883, 1892, 6468, 6388, 1884, 1893, 6469
8824, 6388, 1884, 1893, 6469, 6389, 1885, 1894, 6470
8825, 6389, 1885, 1894, 6470, 6390, 1886, 1895, 6471
8826, 6390, 1886, 1895, 6471, 2066, 293, 294, 2075
8827, 198, 1608, 1617, 199, 1707, 6391, 6472, 1716
8828, 1707, 6391, 6472, 1716, 1708, 6392, 6473, 1717
8829, 1708, 6392, 6473, 1717, 1709, 6393, 6474, 1718
8830, 1709, 6393, 6474, 1718, 1710, 6394, 6475, 1719
8831, 1710, 6394, 6475, 1719, 1711, 6395, 6476, 1720
8832, 1711, 6395, 6476, 1720, 1712, 6396, 6477, 1721
8833, 1712, 6396, 6477, 1721, 1713, 6397, 6478, 1722
8834, 1713, 6397, 6478, 1722, 1714, 6398, 6479, 1723
8835, 1714, 6398, 6479, 1723, 1715, 6399, 6480, 1724
8836, 1715, 6399, 6480, 1724, 256, 2067, 2076, 257
8837, 1608, 1609, 1618, 1617, 6391, 6400, 6481, 6472
8838, 6391, 6400, 6481, 6472, 6392, 6401, 6482, 6473
8839, 6392, 6401, 6482, 6473, 6393, 6402, 6483, 6474
8840, 6393, 6402, 6483, 6474, 6394, 6403, 6484, 6475
8841, 6394, 6403, 6484, 6475, 6395, 6404, 6485, 6476
8842, 6395, 6404, 6485, 6476, 6396, 6405, 6486, 6477
8843, 6396, 6405, 6486, 6477, 6397, 6406, 6487, 6478
8844, 6397, 6406, 6487, 6478, 6398, 6407, 6488, 6479
8845, 6398, 6407, 6488, 6479, 6399, 6408, 6489, 6480
8846, 6399, 6408, 6489, 6480, 2067, 2068, 2077, 2076
8847, 1609, 1610, 1619, 1618, 6400, 6409, 6490, 6481
8848, 6400, 6409, 6490, 6481, 6401, 6410, 6491, 6482
8849, 6401, 6410, 6491, 6482, 6402, 6411, 6492, 6483
8850, 6402, 6411, 6492, 6483, 6403, 6412, 6493, 6484
8851, 6403, 6412, 6493, 6484, 6404, 6413, 6494, 6485
8852, 6404, 6413, 6494, 6485, 6405, 6414, 6495, 6486
8853, 6405, 6414, 6495, 6486, 6406, 6415, 6496, 6487
8854, 6406, 6415, 6496, 6487, 6407, 6416, 6497, 6488
8855, 6407, 6416, 6497, 6488, 6408, 6417, 6498, 6489
8856, 6408, 6417, 6498, 6489, 2068, 2069, 2078, 2077
8857, 1610, 1611, 1620, 1619, 6409, 6418, 6499, 6490
8858, 6409, 6418, 6499, 6490, 6410, 6419, 6500, 6491
8859, 6410, 6419, 6500, 6491, 6411, 6420, 6501, 6492
8860, 6411, 6420, 6501, 6492, 6412, 6421, 6502, 6493
8861, 6412, 6421, 6502, 6493, 6413, 6422, 6503, 6494
8862, 6413, 6422, 6503, 6494, 6414, 6423, 6504, 6495
8863, 6414, 6423, 6504, 6495, 6415, 6424, 6505, 6496
8864, 6415, 6424, 6505, 6496, 6416, 6425, 6506, 6497
8865, 6416, 6425, 6506, 6497, 6417, 6426, 6507, 6498
8866, 6417, 6426, 6507, 6498, 2069, 2070, 2079, 2078
8867, 1611, 1612, 1621, 1620, 6418, 6427, 6508, 6499
8868, 6418, 6427, 6508, 6499, 6419, 6428, 6509, 6500
8869, 6419, 6428, 6509, 6500, 6420, 6429, 6510, 6501
8870, 6420, 6429, 6510, 6501, 6421, 6430, 6511, 6502
8871, 6421, 6430, 6511, 6502, 6422, 6431, 6512, 6503
8872, 6422, 6431, 6512, 6503, 6423, 6432, 6513, 6504
8873, 6423, 6432, 6513, 6504, 6424, 6433, 6514, 6505
8874, 6424, 6433, 6514, 6505, 6425, 6434, 6515, 6506
8875, 6425, 6434, 6515, 6506, 6426, 6435, 6516, 6507
8876, 6426, 6435, 6516, 6507, 2070, 2071, 2080, 2079
8877, 1612, 1613, 1622, 1621, 6427, 6436, 6517, 6508
8878, 6427, 6436, 6517, 6508, 6428, 6437, 6518, 6509
8879, 6428, 6437, 6518, 6509, 6429, 6438, 6519, 6510
8880, 6429, 6438, 6519, 6510, 6430, 6439, 6520, 6511
8881, 6430, 6439, 6520, 6511, 6431, 6440, 6521, 6512
8882, 6431, 6440, 6521, 6512, 6432, 6441, 6522, 6513
8883, 6432, 6441, 6522, 6513, 6433, 6442, 6523, 6514
8884, 6433, 6442, 6523, 6514, 6434, 6443, 6524, 6515
8885, 6434, 6443, 6524, 6515, 6435, 6444, 6525, 6516
8886, 6435, 6444, 6525, 6516, 2071, 2072, 2081, 2080
8887, 1613, 1614, 1623, 1622, 6436, 6445, 6526, 6517
8888, 6436, 6445, 6526, 6517, 6437, 6446, 6527, 6518
8889, 6437, 6446, 6527, 6518, 6438, 6447, 6528, 6519
8890, 6438, 6447, 6528, 6519, 6439, 6448, 6529, 6520
8891, 6439, 6448, 6529, 6520, 6440, 6449, 6530, 6521
8892, 6440, 6449, 6530, 6521, 6441, 6450, 6531, 6522
8893, 6441, 6450, 6531, 6522, 6442, 6451, 6532, 6523
8894, 6442, 6451, 6532, 6523, 6443, 6452, 6533, 6524
8895, 6443, 6452, 6533, 6524, 6444, 6453, 6534, 6525
8896, 6444, 6453, 6534, 6525, 2072, 2073, 2082, 2081
8897, 1614, 1615, 1624, 1623, 6445, 6454, 6535, 6526
8898, 6445, 6454, 6535, 6526, 6446, 6455, 6536, 6527
8899, 6446, 6455, 6536, 6527, 6447, 6456, 6537, 6528
8900, 6447, 6456, 6537, 6528, 6448, 6457, 6538, 6529
8901, 6448, 6457, 6538, 6529, 6449, 6458, 6539, 6530
8902, 6449, 6458, 6539, 6530, 6450, 6459, 6540, 6531
8903, 6450, 6459, 6540, 6531, 6451, 6460, 6541, 6532
8904, 6451, 6460, 6541, 6532, 6452, 6461, 6542, 6533
8905, 6452, 6461, 6542, 6533, 6453, 6462, 6543, 6534
8906, 6453, 6462, 6543, 6534, 2073, 2074, 2083, 2082
8907, 1615, 1616, 1625, 1624, 6454, 6463, 6544, 6535
8908, 6454, 6463, 6544, 6535, 6455, 6464, 6545, 6536
8909, 6455, 6464, 6545, 6536, 6456, 6465, 6546, 6537
8910, 6456, 6465, 6546, 6537, 6457, 6466, 6547, 6538
8911, 6457, 6466, 6547, 6538, 6458, 6467, 6548, 6539
8912, 6458, 6467, 6548, 6539, 6459, 6468, 6549, 6540
8913, 6459, 6468, 6549, 6540, 6460, 6469, 6550, 6541
8914, 6460, 6469, 6550, 6541, 6461, 6470, 6551, 6542
8915, 6461, 6470, 6551, 6542, 6462, 6471, 6552, 6543
8916, 6462, 6471, 6552, 6543, 2074, 2075, 2084, 2083
8917, 1616, 218, 219, 1625, 6463, 1887, 1896, 6544
8918, 6463, 1887, 1896, 6544, 6464, 1888, 1897, 6545
8919, 6464, 1888, 1897, 6545, 6465, 1889, 1898, 6546
8920, 6465, 1889, 1898, 6546, 6466, 1890, 1899, 6547
8921, 6466, 1890, 1899, 6547, 6467, 1891, 1900, 6548
8922, 6467, 1891, 1900, 6548, 6468, 1892, 1901, 6549
8923, 6468, 1892, 1901, 6549, 6469, 1893, 1902, 6550
8924, 6469, 1893, 1902, 6550, 6470, 1894, 1903, 6551
8925, 6470, 1894, 1903, 6551, 6471, 1895, 1904, 6552
8926, 6471, 1895, 1904, 6552, 2075, 294, 295, 2084
8927, 199, 1617, 200, 9, 1716, 6472, 1725, 229
8928, 1716, 6472, 1725, 229, 1717, 6473, 1726, 230
8929, 1717, 6473, 1726, 230, 1718, 6474, 1727, 231
8930, 1718, 6474, 1727, 231, 1719, 6475, 1728, 232
8931, 1719, 6475, 1728, 232, 1720, 6476, 1729, 233
8932, 1720, 6476, 1729, 233, 1721, 6477, 1730, 234
8933, 1721, 6477, 1730, 234, 1722, 6478, 1731, 235
8934, 1722, 6478, 1731, 235, 1723, 6479, 1732, 236
8935, 1723, 6479, 1732, 236, 1724, 6480, 1733, 237
8936, 1724, 6480, 1733, 237, 257, 2076, 267, 13
8937, 1617, 1618, 201, 200, 6472, 6481, 1734, 1725
8938, 6472, 6481, 1734, 1725, 6473, 6482, 1735, 1726
8939, 6473, 6482, 1735, 1726, 6474, 6483, 1736, 1727
8940, 6474, 6483, 1736, 1727, 6475, 6484, 1737, 1728
8941, 6475, 6484, 1737, 1728, 6476, 6485, 1738, 1729
8942, 6476, 6485, 1738, 1729, 6477, 6486, 1739, 1730
8943, 6477, 6486, 1739, 1730, 6478, 6487, 1740, 1731
8944, 6478, 6487, 1740, 1731, 6479, 6488, 1741, 1732
8945, 6479, 6488, 1741, 1732, 6480, 6489, 1742, 1733
8946, 6480, 6489, 1742, 1733, 2076, 2077, 268, 267
8947, 1618, 1619, 202, 201, 6481, 6490, 1743, 1734
8948, 6481, 6490, 1743, 1734, 6482, 6491, 1744, 1735
8949, 6482, 6491, 1744, 1735, 6483, 6492, 1745, 1736
8950, 6483, 6492, 1745, 1736, 6484, 6493, 1746, 1737
8951, 6484, 6493, 1746, 1737, 6485, 6494, 1747, 1738
8952, 6485, 6494, 1747, 1738, 6486, 6495, 1748, 1739
8953, 6486, 6495, 1748, 1739, 6487, 6496, 1749, 1740
8954, 6487, 6496, 1749, 1740, 6488, 6497, 1750, 1741
8955, 6488, 6497, 1750, 1741, 6489, 6498, 1751, 1742
8956, 6489, 6498, 1751, 1742, 2077, 2078, 269, 268
8957, 1619, 1620, 203, 202, 6490, 6499, 1752, 1743
8958, 6490, 6499, 1752, 1743, 6491, 6500, 1753, 1744
8959, 6491, 6500, 1753, 1744, 6492, 6501, 1754, 1745
8960, 6492, 6501, 1754, 1745, 6493, 6502, 1755, 1746
8961, 6493, 6502, 1755, 1746, 6494, 6503, 1756, 1747
8962, 6494, 6503, 1756, 1747, 6495, 6504, 1757, 1748
8963, 6495, 6504, 1757, 1748, 6496, 6505, 1758, 1749
8964, 6496, 6505, 1758, 1749, 6497, 6506, 1759, 1750
8965, 6497, 6506, 1759, 1750, 6498, 6507, 1760, 1751
8966, 6498, 6507, 1760, 1751, 2078, 2079, 270, 269
8967, 1620, 1621, 204, 203, 6499, 6508, 1761, 1752
8968, 6499, 6508, 1761, 1752, 6500, 6509, 1762, 1753
8969, 6500, 6509, 1762, 1753, 6501, 6510, 1763, 1754
8970, 6501, 6510, 1763, 1754, 6502, 6511, 1764, 1755
8971, 6502, 6511, 1764, 1755, 6503, 6512, 1765, 1756
8972, 6503, 6512, 1765, 1756, 6504, 6513, 1766, 1757
8973, 6504, 6513, 1766, 1757, 6505, 6514, 1767, 1758
8974, 6505, 6514, 1767, 1758, 6506, 6515, 1768, 1759
8975, 6506, 6515, 1768, 1759, 6507, 6516, 1769, 1760
8976, 6507, 6516, 1769, 1760, 2079, 2080, 271, 270
8977, 1621, 1622, 205, 204, 6508, 6517, 1770, 1761
8978, 6508, 6517, 1770, 1761, 6509, 6518, 1771, 1762
8979, 6509, 6518, 1771, 1762, 6510, 6519, 1772, 1763
8980, 6510, 6519, 1772, 1763, 6511, 6520, 1773, 1764
8981, 6511, 6520, 1773, 1764, 6512, 6521, 1774, 1765
8982, 6512, 6521, 1774, 1765, 6513, 6522, 1775, 1766
8983, 6513, 6522, 1775, 1766, 6514, 6523, 1776, 1767
8984, 6514, 6523, 1776, 1767, 6515, 6524, 1777, 1768
8985, 6515, 6524, 1777, 1768, 6516, 6525, 1778, 1769
8986, 6516, 6525, 1778, 1769, 2080, 2081, 272, 271
8987, 1622, 1623, 206, 205, 6517, 6526, 1779, 1770
8988, 6517, 6526, 1779, 1770, 6518, 6527, 1780, 1771
8989, 6518, 6527, 1780, 1771, 6519, 6528, 1781, 1772
8990, 6519, 6528, 1781, 1772, 6520, 6529, 1782, 1773
8991, 6520, 6529, 1782, 1773, 6521, 6530, 1783, 1774
8992, 6521, 6530, 1783, 1774, 6522, 6531, 1784, 1775
8993, 6522, 6531, 1784, 1775, 6523, 6532, 1785, 1776
8994, 6523, 6532, 1785, 1776, 6524, 6533, 1786, 1777
8995, 6524, 6533, 1786, 1777, 6525, 6534, 1787, 1778
8996, 6525, 6534, 1787, 1778, 2081, 2082, 273, 272
8997, 1623, 1624, 207, 206, 6526, 6535, 1788, 1779
8998, 6526, 6535, 1788, 1779, 6527, 6536, 1789, 1780
8999, 6527, 6536, 1789, 1780, 6528, 6537, 1790, 1781
9000, 6528, 6537, 1790, 1781, 6529, 6538, 1791, 1782
9001, 6529, 6538, 1791, 1782, 6530, 6539, 1792, 1783
9002, 6530, 6539, 1792, 1783, 6531, 6540, 1793, 1784
9003, 6531, 6540, 1793, 1784, 6532, 6541, 1794, 1785
9004, 6532, 6541, 1794, 1785, 6533, 6542, 1795, 1786
9005, 6533, 6542, 1795, 1786, 6534, 6543, 1796, 1787
9006, 6534, 6543, 1796, 1787, 2082, 2083, 274, 273
9007, 1624, 1625, 208, 207, 6535, 6544, 1797, 1788
9008, 6535, 6544, 1797, 1788, 6536, 6545, 1798, 1789
9009, 6536, 6545, 1798, 1789, 6537, 6546, 1799, 1790
9010, 6537, 6546, 1799, 1790, 6538, 6547, 1800, 1791
9011, 6538, 6547, 1800, 1791, 6539, 6548, 1801, 1792
9012, 6539, 6548, 1801, 1792, 6540, 6549, 1802, 1793
9013, 6540, 6549, 1802, 1793, 6541, 6550, 1803, 1794
9014, 6541, 6550, 1803, 1794, 6542, 6551, 1804, 1795
9015, 6542, 6551, 1804, 1795, 6543, 6552, 1805, 1796
9016, 6543, 6552, 1805, 1796, 2083, 2084, 275, 274
9017, 1625, 219, 11, 208, 6544, 1896, 258, 1797
9018, 6544, 1896, 258, 1797, 6545, 1897, 259, 1798
9019, 6545, 1897, 259, 1798, 6546, 1898, 260, 1799
9020, 6546, 1898, 260, 1799, 6547, 1899, 261, 1800
9021, 6547, 1899, 261, 1800, 6548, 1900, 262, 1801
9022, 6548, 1900, 262, 1801, 6549, 1901, 263, 1802
9023, 6549, 1901, 263, 1802, 6550, 1902, 264, 1803
9024, 6550, 1902, 264, 1803, 6551, 1903, 265, 1804
9025, 6551, 1903, 265, 1804, 6552, 1904, 266, 1805
9026, 6552, 1904, 266, 1805, 2084, 295, 15, 275
*ELEMENT, type=C3D8, ELSET=Volume4
9027, 14, 296, 1986, 247, 18, 336, 2085, 305
9028, 296, 297, 1987, 1986, 336, 337, 2086, 2085
9029, 297, 298, 1988, 1987, 337, 338, 2087, 2086
9030, 298, 299, 1989, 1988, 338, 339, 2088, 2087
9031, 299, 300, 1990, 1989, 339, 340, 2089, 2088
9032, 300, 301, 1991, 1990, 340, 341, 2090, 2089
9033, 301, 302, 1992, 1991, 341, 342, 2091, 2090
9034, 302, 303, 1993, 1992, 342, 343, 2092, 2091
9035, 303, 304, 1994, 1993, 343, 344, 2093, 2092
9036, 304, 16, 285, 1994, 344, 20, 325, 2093
9037, 247, 1986, 1995, 248, 305, 2085, 2094, 306
9038, 1986, 1987, 1996, 1995, 2085, 2086, 2095, 2094
9039, 1987, 1988, 1997, 1996, 2086, 2087, 2096, 2095
9040, 1988, 1989, 1998, 1997, 2087, 2088, 2097, 2096
9041, 1989, 1990, 1999, 1998, 2088, 2089, 2098, 2097
9042, 1990, 1991, 2000, 1999, 2089, 2090, 2099, 2098
9043, 1991, 1992, 2001, 2000, 2090, 2091, 2100, 2099
9044, 1992, 1993, 2002, 2001, 2091, 2092, 2101, 2100
9045, 1993, 1994, 2003, 2002, 2092, 2093, 2102, 2101
9046, 1994, 285, 286, 2003, 2093, 325, 326, 2102
9047, 248, 1995, 2004, 249, 306, 2094, 2103, 307
9048, 1995, 1996, 2005, 2004, 2094, 2095, 2104, 2103
9049, 1996, 1997, 2006, 2005, 2095, 2096, 2105, 2104
9050, 1997, 1998, 2007, 2006, 2096, 2097, 2106, 2105
9051, 1998, 1999, 2008, 2007, 2097, 2098, 2107, 2106
9052, 1999, 2000, 2009, 2008, 2098, 2099, 2108, 2107
9053, 2000, 2001, 2010, 2009, 2099, 2100, 2109, 2108
9054, 2001, 2002, 2011, 2010, 2100, 2101, 2110, 2109
9055, 2002, 2003, 2012, 2011, 2101, 2102, 2111, 2110
9056, 2003, 286, 287, 2012, 2102, 326, 327, 2111
9057, 249, 2004, 2013, 250, 307, 2103, 2112, 308
9058, 2004, 2005, 2014, 2013, 2103, 2104, 2113, 2112
9059, 2005, 2006, 2015, 2014, 2104, 2105, 2114, 2113
9060, 2006, 2007, 2016, 2015, 2105, 2106, 2115, 2114
9061, 2007, 2008, 2017, 2016, 2106, 2107, 2116, 2115
9062, 2008, 2009, 2018, 2017, 2107, 2108, 2117, 2116
9063, 2009, 2010, 2019, 2018, 2108, 2109, 2118, 2117
9064, 2010, 2011, 2020, 2019, 2109, 2110, 2119, 2118
9065, 2011, 2012, 2021, 2020, 2110, 2111, 2120, 2119
9066, 2012, 287, 288, 2021, 2111, 327, 328, 2120
9067, 250, 2013, 2022, 251, 308, 2112, 2121, 309
9068, 2013, 2014, 2023, 2022, 2112, 2113, 2122, 2121
9069, 2014, 2015, 2024, 2023, 2113, 2114, 2123, 2122
9070, 2015, 2016, 2025, 2024, 2114, 2115, 2124, 2123
9071, 2016, 2017, 2026, 2025, 2115, 2116, 2125, 2124
9072, 2017, 2018, 2027, 2026, 2116, 2117, 2126, 2125
9073, 2018, 2019, 2028, 2027, 2117, 2118, 2127, 2126
9074, 2019, 2020, 2029, 2028, 2118, 2119, 2128, 2127
9075, 2020, 2021, 2030, 2029, 2119, 2120, 2129, 2128
9076, 2021, 288, 289, 2030, 2120, 328, 329, 2129
9077, 251, 2022, 2031, 252, 309, 2121, 2130, 310
9078, 2022, 2023, 2032, 2031, 2121, 2122, 2131, 2130
9079, 2023, 2024, 2033, 2032, 2122, 2123, 2132, 2131
9080, 2024, 2025, 2034, 2033, 2123, 2124, 2133, 2132
9081, 2025, 2026, 2035, 2034, 2124, 2125, 2134, 2133
9082, 2026, 2027, 2036, 2035, 2125, 2126, 2135, 2134
9083, 2027, 2028, 2037, 2036, 2126, 2127, 2136, 2135
9084, 2028, 2029, 2038, 2037, 2127, 2128, 2137, 2136
9085, 2029, 2030, 2039, 2038, 2128, 2129, 2138, 2137
9086, 2030, 289, 290, 2039, 2129, 329, 330, 2138
9087, 252, 2031, 2040, 253, 310, 2130, 2139, 311
9088, 2031, 2032, 2041, 2040, 2130, 2131, 2140, 2139
9089, 2032, 2033, 2042, 2041, 2131, 2132, 2141, 2140
9090, 2033, 2034, 2043, 2042, 2132, 2133, 2142, 2141
9091, 2034, 2035, 2044, 2043, 2133, 2134, 2143, 2142
9092, 2035, 2036, 2045, 2044, 2134, 2135, 2144, 2143
9093, 2036, 2037, 2046, 2045, 2135, 2136, 2145, 2144
9094, 2037, 2038, 2047, 2046, 2136, 2137, 2146, 2145
9095, 2038, 2039, 2048, 2047, 2137, 2138, 2147, 2146
9096, 2039, 290, 291, 2048, 2138, 330, 331, 2147
9097, 253, 2040, 2049, 254, 311, 2139, 2148, 312
9098, 2040, 2041, 2050, 2049, 2139, 2140, 2149, 2148
9099, 2041, 2042, 2051, 2050, 2140, 2141, 2150, 2149
9100, 2042, 2043, 2052, 2051, 2141, 2142, 2151, 2150
9101, 2043, 2044, 2053, 2052, 2142, 2143, 2152, 2151
9102, 2044, 2045, 2054, 2053, 2143, 2144, 2153, 2152
9103, 2045, 2046, 2055, 2054, 2144, 2145, 2154, 2153
9104, 2046, 2047, 2056, 2055, 2145, 2146, 2155, 2154
9105, 2047, 2048, 2057, 2056, 2146, 2147, 2156, 2155
9106, 2048, 291, 292, 2057, 2147, 331, 332, 2156
9107, 254, 2049, 2058, 255, 312, 2148, 2157, 313
9108, 2049, 2050, 2059, 2058, 2148, 2149, 2158, 2157
9109, 2050, 2051, 2060, 2059, 2149, 2150, 2159, 2158
9110, 2051, 2052, 2061, 2060, 2150, 2151, 2160, 2159
9111, 2052, 2053, 2062, 2061, 2151, 2152, 2161, 2160
9112, 2053, 2054, 2063, 2062, 2152, 2153, 2162, 2161
9113, 2054, 2055, 2064, 2063, 2153, 2154, 2163, 2162
9114, 2055, 2056, 2065, 2064, 2154, 2155, 2164, 2163
9115, 2056, 2057, 2066, 2065, 2155, 2156, 2165, 2164
9116, 2057, 292, 293, 2066, 2156, 332, 333, 2165
9117, 255, 2058, 2067, 256, 313, 2157, 2166, 314
9118, 2058, 2059, 2068, 2067, 2157, 2158, 2167, 2166
9119, 2059, 2060, 2069, 2068, 2158, 2159, 2168, 2167
9120, 2060, 2061, 2070, 2069, 2159, 2160, 2169, 2168
9121, 2061, 2062, 2071, 2070, 2160, 2161, 2170, 2169
9122, 2062, 2063, 2072, 2071, 2161, 2162, 2171, 2170
9123, 2063, 2064, 2073, 2072, 2162, 2163, 2172, 2171
9124, 2064, 2065, 2074, 2073, 2163, 2164, 2173, 2172
9125, 2065, 2066, 2075, 2074, 2164, 2165, 2174, 2173
9126, 2066, 293, 294, 2075, 2165, 333, 334, 2174
9127, 256, 2067, 2076, 257, 314, 2166, 2175, 315
9128, 2067, 2068, 2077, 2076, 2166, 2167, 2176, 2175
9129, 2068, 2069, 2078, 2077, 2167, 2168, 2177, 2176
9130, 2069, 2070, 2079, 2078, 2168, 2169, 2178, 2177
9131, 2070, 2071, 2080, 2079, 2169, 2170, 2179, 2178
9132, 2071, 2072, 2081, 2080, 2170, 2171, 2180, 2179
9133, 2072, 2073, 2082, 2081, 2171, 2172, 2181, 2180
9134, 2073, 2074, 2083, 2082, 2172, 2173, 2182, 2181
9135, 2074, 2075, 2084, 2083, 2173, 2174, 2183, 2182
9136, 2075, 294, 295, 2084, 2174, 334, 335, 2183
9137, 257, 2076, 267, 13, 315, 2175, 316, 17
9138, 2076, 2077, 268, 267, 2175, 2176, 317, 316
9139, 2077, 2078, 269, 268, 2176, 2177, 318, 317
9140, 2078, 2079, 270, 269, 2177, 2178, 319, 318
9141, 2079, 2080, 271, 270, 2178, 2179, 320, 319
9142, 2080, 2081, 272, 271, 2179, 2180, 321, 320
9143, 2081, 2082, 273, 272, 2180, 2181, 322, 321
9144, 2082, 2083, 274, 273, 2181, 2182, 323, 322
9145, 2083, 2084, 275, 274, 2182, 2183, 324, 323
9146, 2084, 295, 15, 275, 2183, 335, 19, 324
*ELEMENT, type=C3D8, ELSET=Volume5
9147, 18, 336, 2085, 305, 348, 2277, 6553, 2184
9148, 348, 2277, 6553, 2184, 349, 2278, 6554, 2185
9149, 349, 2278, 6554, 2185, 350, 2279, 6555, 2186
9150, 350, 2279, 6555, 2186, 22, 388, 2304, 351
9151, 336, 337, 2086, 2085, 2277, 2280, 6556, 6553
9152, 2277, 2280, 6556, 6553, 2278, 2281, 6557, 6554
9153, 2278, 2281, 6557, 6554, 2279, 2282, 6558, 6555
9154, 2279, 2282, 6558, 6555, 388, 389, 2305, 2304
9155, 337, 338, 2087, 2086, 2280, 2283, 6559, 6556
9156, 2280, 2283, 6559, 6556, 2281, 2284, 6560, 6557
9157, 2281, 2284, 6560, 6557, 2282, 2285, 6561, 6558
9158, 2282, 2285, 6561, 6558, 389, 390, 2306, 2305
9159, 338, 339, 2088, 2087, 2283, 2286, 6562, 6559
9160, 2283, 2286, 6562, 6559, 2284, 2287, 6563, 6560
9161, 2284, 2287, 6563, 6560, 2285, 2288, 6564, 6561
9162, 2285, 2288, 6564, 6561, 390, 391, 2307, 2306
9163, 339, 340, 2089, 2088, 2286, 2289, 6565, 6562
9164, 2286, 2289, 6565, 6562, 2287, 2290, 6566, 6563
9165, 2287, 2290, 6566, 6563, 2288, 2291, 6567, 6564
9166, 2288, 2291, 6567, 6564, 391, 392, 2308, 2307
9167, 340, 341, 2090, 2089, 2289, 2292, 6568, 6565
9168, 2289, 2292, 6568, 6565, 2290, 2293, 6569, 6566
9169, 2290, 2293, 6569, 6566, 2291, 2294, 6570, 6567
9170, 2291, 2294, 6570, 6567, 392, 393, 2309, 2308
9171, 341, 342, 2091, 2090, 2292, 2295, 6571, 6568
9172, 2292, 2295, 6571, 6568, 2293, 2296, 6572, 6569
9173, 2293, 2296, 6572, 6569, 2294, 2297, 6573, 6570
9174, 2294, 2297, 6573, 6570, 393, 394, 2310, 2309
9175, 342, 343, 2092, 2091, 2295, 2298, 6574, 6571
9176, 2295, 2298, 6574, 6571, 2296, 2299, 6575, 6572
9177, 2296, 2299, 6575, 6572, 2297, 2300, 6576, 6573
9178, 2297, 2300, 6576, 6573, 394, 395, 2311, 2310
9179, 343, 344, 2093, 2092, 2298, 2301, 6577, 6574
9180, 2298, 2301, 6577, 6574, 2299, 2302, 6578, 6575
9181, 2299, 2302, 6578, 6575, 2300, 2303, 6579, 6576
9182, 2300, 2303, 6579, 6576, 395, 396, 2312, 2311
9183, 344, 20, 325, 2093, 2301, 374, 2244, 6577
9184, 2301, 374, 2244, 6577, 2302, 375, 2245, 6578
9185, 2302, 375, 2245, 6578, 2303, 376, 2246, 6579
9186, 2303, 376, 2246, 6579, 396, 24, 377, 2312
9187, 305, 2085, 2094, 306, 2184, 6553, 6580, 2187
9188, 2184, 6553, 6580, 2187, 2185, 6554, 6581, 2188
9189, 2185, 6554, 6581, 2188, 2186, 6555, 6582, 2189
9190, 2186, 6555, 6582, 2189, 351, 2304, 2313, 352
9191, 2085, 2086, 2095, 2094, 6553, 6556, 6583, 6580
9192, 6553, 6556, 6583, 6580, 6554, 6557, 6584, 6581
9193, 6554, 6557, 6584, 6581, 6555, 6558, 6585, 6582
9194, 6555, 6558, 6585, 6582, 2304, 2305, 2314, 2313
9195, 2086, 2087, 2096, 2095, 6556, 6559, 6586, 6583
9196, 6556, 6559, 6586, 6583, 6557, 6560, 6587, 6584
9197, 6557, 6560, 6587, 6584, 6558, 6561, 6588, 6585
9198, 6558, 6561, 6588, 6585, 2305, 2306, 2315, 2314
9199, 2087, 2088, 2097, 2096, 6559, 6562, 6589, 6586
9200, 6559, 6562, 6589, 6586, 6560, 6563, 6590, 6587
9201, 6560, 6563, 6590, 6587, 6561, 6564, 6591, 6588
9202, 6561, 6564, 6591, 6588, 2306, 2307, 2316, 2315
9203, 2088, 2089, 2098, 2097, 6562, 6565, 6592, 6589
9204, 6562, 6565, 6592, 6589, 6563, 6566, 6593, 6590
9205, 6563, 6566, 6593, 6590, 6564, 6567, 6594, 6591
9206, 6564, 6567, 6594, 6591, 2307, 2308, 2317, 2316
9207, 2089, 2090, 2099, 2098, 6565, 6568, 6595, 6592
9208, 6565, 6568, 6595, 6592, 6566, 6569, 6596, 6593
9209, 6566, 6569, 6596, 6593, 6567, 6570, 6597, 6594
9210, 6567, 6570, 6597, 6594, 2308, 2309, 2318, 2317
9211, 2090, 2091, 2100, 2099, 6568, 6571, 6598, 6595
9212, 6568, 6571, 6598, 6595, 6569, 6572, 6599, 6596
9213, 6569, 6572, 6599, 6596, 6570, 6573, 6600, 6597
9214, 6570, 6573, 6600, 6597, 2309, 2310, 2319, 2318
9215, 2091, 2092, 2101, 2100, 6571, 6574, 6601, 6598
9216, 6571, 6574, 6601, 6598, 6572, 6575, 6602, 6599
9217, 6572, 6575, 6602, 6599, 6573, 6576, 6603, 6600
9218, 6573, 6576, 6603, 6600, 2310, 2311, 2320, 2319
9219, 2092, 2093, 2102, 2101, 6574, 6577, 6604, 6601
9220, 6574, 6577, 6604, 6601, 6575, 6578, 6605, 6602
9221, 6575, 6578, 6605, 6602, 6576, 6579, 6606, 6603
