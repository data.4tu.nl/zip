12975, 8551, 8555, 8591, 8587, 8552, 8556, 8592, 8588
12976, 8552, 8556, 8592, 8588, 4328, 4329, 4338, 4337
12977, 2318, 2319, 2328, 2327, 8553, 8557, 8593, 8589
12978, 8553, 8557, 8593, 8589, 8554, 8558, 8594, 8590
12979, 8554, 8558, 8594, 8590, 8555, 8559, 8595, 8591
12980, 8555, 8559, 8595, 8591, 8556, 8560, 8596, 8592
12981, 8556, 8560, 8596, 8592, 4329, 4330, 4339, 4338
12982, 2319, 2320, 2329, 2328, 8557, 8561, 8597, 8593
12983, 8557, 8561, 8597, 8593, 8558, 8562, 8598, 8594
12984, 8558, 8562, 8598, 8594, 8559, 8563, 8599, 8595
12985, 8559, 8563, 8599, 8595, 8560, 8564, 8600, 8596
12986, 8560, 8564, 8600, 8596, 4330, 4331, 4340, 4339
12987, 2320, 2321, 2330, 2329, 8561, 8565, 8601, 8597
12988, 8561, 8565, 8601, 8597, 8562, 8566, 8602, 8598
12989, 8562, 8566, 8602, 8598, 8563, 8567, 8603, 8599
12990, 8563, 8567, 8603, 8599, 8564, 8568, 8604, 8600
12991, 8564, 8568, 8604, 8600, 4331, 4332, 4341, 4340
12992, 2321, 378, 379, 2330, 8565, 4239, 4243, 8601
12993, 8565, 4239, 4243, 8601, 8566, 4240, 4244, 8602
12994, 8566, 4240, 4244, 8602, 8567, 4241, 4245, 8603
12995, 8567, 4241, 4245, 8603, 8568, 4242, 4246, 8604
12996, 8568, 4242, 4246, 8604, 4332, 976, 977, 4341
12997, 353, 2322, 2331, 354, 4163, 8569, 8605, 4167
12998, 4163, 8569, 8605, 4167, 4164, 8570, 8606, 4168
12999, 4164, 8570, 8606, 4168, 4165, 8571, 8607, 4169
13000, 4165, 8571, 8607, 4169, 4166, 8572, 8608, 4170
13001, 4166, 8572, 8608, 4170, 949, 4333, 4342, 950
13002, 2322, 2323, 2332, 2331, 8569, 8573, 8609, 8605
13003, 8569, 8573, 8609, 8605, 8570, 8574, 8610, 8606
13004, 8570, 8574, 8610, 8606, 8571, 8575, 8611, 8607
13005, 8571, 8575, 8611, 8607, 8572, 8576, 8612, 8608
13006, 8572, 8576, 8612, 8608, 4333, 4334, 4343, 4342
13007, 2323, 2324, 2333, 2332, 8573, 8577, 8613, 8609
13008, 8573, 8577, 8613, 8609, 8574, 8578, 8614, 8610
13009, 8574, 8578, 8614, 8610, 8575, 8579, 8615, 8611
13010, 8575, 8579, 8615, 8611, 8576, 8580, 8616, 8612
13011, 8576, 8580, 8616, 8612, 4334, 4335, 4344, 4343
13012, 2324, 2325, 2334, 2333, 8577, 8581, 8617, 8613
13013, 8577, 8581, 8617, 8613, 8578, 8582, 8618, 8614
13014, 8578, 8582, 8618, 8614, 8579, 8583, 8619, 8615
13015, 8579, 8583, 8619, 8615, 8580, 8584, 8620, 8616
13016, 8580, 8584, 8620, 8616, 4335, 4336, 4345, 4344
13017, 2325, 2326, 2335, 2334, 8581, 8585, 8621, 8617
13018, 8581, 8585, 8621, 8617, 8582, 8586, 8622, 8618
13019, 8582, 8586, 8622, 8618, 8583, 8587, 8623, 8619
13020, 8583, 8587, 8623, 8619, 8584, 8588, 8624, 8620
13021, 8584, 8588, 8624, 8620, 4336, 4337, 4346, 4345
13022, 2326, 2327, 2336, 2335, 8585, 8589, 8625, 8621
13023, 8585, 8589, 8625, 8621, 8586, 8590, 8626, 8622
13024, 8586, 8590, 8626, 8622, 8587, 8591, 8627, 8623
13025, 8587, 8591, 8627, 8623, 8588, 8592, 8628, 8624
13026, 8588, 8592, 8628, 8624, 4337, 4338, 4347, 4346
13027, 2327, 2328, 2337, 2336, 8589, 8593, 8629, 8625
13028, 8589, 8593, 8629, 8625, 8590, 8594, 8630, 8626
13029, 8590, 8594, 8630, 8626, 8591, 8595, 8631, 8627
13030, 8591, 8595, 8631, 8627, 8592, 8596, 8632, 8628
13031, 8592, 8596, 8632, 8628, 4338, 4339, 4348, 4347
13032, 2328, 2329, 2338, 2337, 8593, 8597, 8633, 8629
13033, 8593, 8597, 8633, 8629, 8594, 8598, 8634, 8630
13034, 8594, 8598, 8634, 8630, 8595, 8599, 8635, 8631
13035, 8595, 8599, 8635, 8631, 8596, 8600, 8636, 8632
13036, 8596, 8600, 8636, 8632, 4339, 4340, 4349, 4348
13037, 2329, 2330, 2339, 2338, 8597, 8601, 8637, 8633
13038, 8597, 8601, 8637, 8633, 8598, 8602, 8638, 8634
13039, 8598, 8602, 8638, 8634, 8599, 8603, 8639, 8635
13040, 8599, 8603, 8639, 8635, 8600, 8604, 8640, 8636
13041, 8600, 8604, 8640, 8636, 4340, 4341, 4350, 4349
13042, 2330, 379, 380, 2339, 8601, 4243, 4247, 8637
13043, 8601, 4243, 4247, 8637, 8602, 4244, 4248, 8638
13044, 8602, 4244, 4248, 8638, 8603, 4245, 4249, 8639
13045, 8603, 4245, 4249, 8639, 8604, 4246, 4250, 8640
13046, 8604, 4246, 4250, 8640, 4341, 977, 978, 4350
13047, 354, 2331, 2340, 355, 4167, 8605, 8641, 4171
13048, 4167, 8605, 8641, 4171, 4168, 8606, 8642, 4172
13049, 4168, 8606, 8642, 4172, 4169, 8607, 8643, 4173
13050, 4169, 8607, 8643, 4173, 4170, 8608, 8644, 4174
13051, 4170, 8608, 8644, 4174, 950, 4342, 4351, 951
13052, 2331, 2332, 2341, 2340, 8605, 8609, 8645, 8641
13053, 8605, 8609, 8645, 8641, 8606, 8610, 8646, 8642
13054, 8606, 8610, 8646, 8642, 8607, 8611, 8647, 8643
13055, 8607, 8611, 8647, 8643, 8608, 8612, 8648, 8644
13056, 8608, 8612, 8648, 8644, 4342, 4343, 4352, 4351
13057, 2332, 2333, 2342, 2341, 8609, 8613, 8649, 8645
13058, 8609, 8613, 8649, 8645, 8610, 8614, 8650, 8646
13059, 8610, 8614, 8650, 8646, 8611, 8615, 8651, 8647
13060, 8611, 8615, 8651, 8647, 8612, 8616, 8652, 8648
13061, 8612, 8616, 8652, 8648, 4343, 4344, 4353, 4352
13062, 2333, 2334, 2343, 2342, 8613, 8617, 8653, 8649
13063, 8613, 8617, 8653, 8649, 8614, 8618, 8654, 8650
13064, 8614, 8618, 8654, 8650, 8615, 8619, 8655, 8651
13065, 8615, 8619, 8655, 8651, 8616, 8620, 8656, 8652
13066, 8616, 8620, 8656, 8652, 4344, 4345, 4354, 4353
13067, 2334, 2335, 2344, 2343, 8617, 8621, 8657, 8653
13068, 8617, 8621, 8657, 8653, 8618, 8622, 8658, 8654
13069, 8618, 8622, 8658, 8654, 8619, 8623, 8659, 8655
13070, 8619, 8623, 8659, 8655, 8620, 8624, 8660, 8656
13071, 8620, 8624, 8660, 8656, 4345, 4346, 4355, 4354
13072, 2335, 2336, 2345, 2344, 8621, 8625, 8661, 8657
13073, 8621, 8625, 8661, 8657, 8622, 8626, 8662, 8658
13074, 8622, 8626, 8662, 8658, 8623, 8627, 8663, 8659
13075, 8623, 8627, 8663, 8659, 8624, 8628, 8664, 8660
13076, 8624, 8628, 8664, 8660, 4346, 4347, 4356, 4355
13077, 2336, 2337, 2346, 2345, 8625, 8629, 8665, 8661
13078, 8625, 8629, 8665, 8661, 8626, 8630, 8666, 8662
13079, 8626, 8630, 8666, 8662, 8627, 8631, 8667, 8663
13080, 8627, 8631, 8667, 8663, 8628, 8632, 8668, 8664
13081, 8628, 8632, 8668, 8664, 4347, 4348, 4357, 4356
13082, 2337, 2338, 2347, 2346, 8629, 8633, 8669, 8665
13083, 8629, 8633, 8669, 8665, 8630, 8634, 8670, 8666
13084, 8630, 8634, 8670, 8666, 8631, 8635, 8671, 8667
13085, 8631, 8635, 8671, 8667, 8632, 8636, 8672, 8668
13086, 8632, 8636, 8672, 8668, 4348, 4349, 4358, 4357
13087, 2338, 2339, 2348, 2347, 8633, 8637, 8673, 8669
13088, 8633, 8637, 8673, 8669, 8634, 8638, 8674, 8670
13089, 8634, 8638, 8674, 8670, 8635, 8639, 8675, 8671
13090, 8635, 8639, 8675, 8671, 8636, 8640, 8676, 8672
13091, 8636, 8640, 8676, 8672, 4349, 4350, 4359, 4358
13092, 2339, 380, 381, 2348, 8637, 4247, 4251, 8673
13093, 8637, 4247, 4251, 8673, 8638, 4248, 4252, 8674
13094, 8638, 4248, 4252, 8674, 8639, 4249, 4253, 8675
13095, 8639, 4249, 4253, 8675, 8640, 4250, 4254, 8676
13096, 8640, 4250, 4254, 8676, 4350, 978, 979, 4359
13097, 355, 2340, 2349, 356, 4171, 8641, 8677, 4175
13098, 4171, 8641, 8677, 4175, 4172, 8642, 8678, 4176
13099, 4172, 8642, 8678, 4176, 4173, 8643, 8679, 4177
13100, 4173, 8643, 8679, 4177, 4174, 8644, 8680, 4178
13101, 4174, 8644, 8680, 4178, 951, 4351, 4360, 952
13102, 2340, 2341, 2350, 2349, 8641, 8645, 8681, 8677
13103, 8641, 8645, 8681, 8677, 8642, 8646, 8682, 8678
13104, 8642, 8646, 8682, 8678, 8643, 8647, 8683, 8679
13105, 8643, 8647, 8683, 8679, 8644, 8648, 8684, 8680
13106, 8644, 8648, 8684, 8680, 4351, 4352, 4361, 4360
13107, 2341, 2342, 2351, 2350, 8645, 8649, 8685, 8681
13108, 8645, 8649, 8685, 8681, 8646, 8650, 8686, 8682
13109, 8646, 8650, 8686, 8682, 8647, 8651, 8687, 8683
13110, 8647, 8651, 8687, 8683, 8648, 8652, 8688, 8684
13111, 8648, 8652, 8688, 8684, 4352, 4353, 4362, 4361
13112, 2342, 2343, 2352, 2351, 8649, 8653, 8689, 8685
13113, 8649, 8653, 8689, 8685, 8650, 8654, 8690, 8686
13114, 8650, 8654, 8690, 8686, 8651, 8655, 8691, 8687
13115, 8651, 8655, 8691, 8687, 8652, 8656, 8692, 8688
13116, 8652, 8656, 8692, 8688, 4353, 4354, 4363, 4362
13117, 2343, 2344, 2353, 2352, 8653, 8657, 8693, 8689
13118, 8653, 8657, 8693, 8689, 8654, 8658, 8694, 8690
13119, 8654, 8658, 8694, 8690, 8655, 8659, 8695, 8691
13120, 8655, 8659, 8695, 8691, 8656, 8660, 8696, 8692
13121, 8656, 8660, 8696, 8692, 4354, 4355, 4364, 4363
13122, 2344, 2345, 2354, 2353, 8657, 8661, 8697, 8693
13123, 8657, 8661, 8697, 8693, 8658, 8662, 8698, 8694
13124, 8658, 8662, 8698, 8694, 8659, 8663, 8699, 8695
13125, 8659, 8663, 8699, 8695, 8660, 8664, 8700, 8696
13126, 8660, 8664, 8700, 8696, 4355, 4356, 4365, 4364
13127, 2345, 2346, 2355, 2354, 8661, 8665, 8701, 8697
13128, 8661, 8665, 8701, 8697, 8662, 8666, 8702, 8698
13129, 8662, 8666, 8702, 8698, 8663, 8667, 8703, 8699
13130, 8663, 8667, 8703, 8699, 8664, 8668, 8704, 8700
13131, 8664, 8668, 8704, 8700, 4356, 4357, 4366, 4365
13132, 2346, 2347, 2356, 2355, 8665, 8669, 8705, 8701
13133, 8665, 8669, 8705, 8701, 8666, 8670, 8706, 8702
13134, 8666, 8670, 8706, 8702, 8667, 8671, 8707, 8703
13135, 8667, 8671, 8707, 8703, 8668, 8672, 8708, 8704
13136, 8668, 8672, 8708, 8704, 4357, 4358, 4367, 4366
13137, 2347, 2348, 2357, 2356, 8669, 8673, 8709, 8705
13138, 8669, 8673, 8709, 8705, 8670, 8674, 8710, 8706
13139, 8670, 8674, 8710, 8706, 8671, 8675, 8711, 8707
13140, 8671, 8675, 8711, 8707, 8672, 8676, 8712, 8708
13141, 8672, 8676, 8712, 8708, 4358, 4359, 4368, 4367
13142, 2348, 381, 382, 2357, 8673, 4251, 4255, 8709
13143, 8673, 4251, 4255, 8709, 8674, 4252, 4256, 8710
13144, 8674, 4252, 4256, 8710, 8675, 4253, 4257, 8711
13145, 8675, 4253, 4257, 8711, 8676, 4254, 4258, 8712
13146, 8676, 4254, 4258, 8712, 4359, 979, 980, 4368
13147, 356, 2349, 2358, 357, 4175, 8677, 8713, 4179
13148, 4175, 8677, 8713, 4179, 4176, 8678, 8714, 4180
13149, 4176, 8678, 8714, 4180, 4177, 8679, 8715, 4181
13150, 4177, 8679, 8715, 4181, 4178, 8680, 8716, 4182
13151, 4178, 8680, 8716, 4182, 952, 4360, 4369, 953
13152, 2349, 2350, 2359, 2358, 8677, 8681, 8717, 8713
13153, 8677, 8681, 8717, 8713, 8678, 8682, 8718, 8714
13154, 8678, 8682, 8718, 8714, 8679, 8683, 8719, 8715
13155, 8679, 8683, 8719, 8715, 8680, 8684, 8720, 8716
13156, 8680, 8684, 8720, 8716, 4360, 4361, 4370, 4369
13157, 2350, 2351, 2360, 2359, 8681, 8685, 8721, 8717
13158, 8681, 8685, 8721, 8717, 8682, 8686, 8722, 8718
13159, 8682, 8686, 8722, 8718, 8683, 8687, 8723, 8719
13160, 8683, 8687, 8723, 8719, 8684, 8688, 8724, 8720
13161, 8684, 8688, 8724, 8720, 4361, 4362, 4371, 4370
13162, 2351, 2352, 2361, 2360, 8685, 8689, 8725, 8721
13163, 8685, 8689, 8725, 8721, 8686, 8690, 8726, 8722
13164, 8686, 8690, 8726, 8722, 8687, 8691, 8727, 8723
13165, 8687, 8691, 8727, 8723, 8688, 8692, 8728, 8724
13166, 8688, 8692, 8728, 8724, 4362, 4363, 4372, 4371
13167, 2352, 2353, 2362, 2361, 8689, 8693, 8729, 8725
13168, 8689, 8693, 8729, 8725, 8690, 8694, 8730, 8726
13169, 8690, 8694, 8730, 8726, 8691, 8695, 8731, 8727
13170, 8691, 8695, 8731, 8727, 8692, 8696, 8732, 8728
13171, 8692, 8696, 8732, 8728, 4363, 4364, 4373, 4372
13172, 2353, 2354, 2363, 2362, 8693, 8697, 8733, 8729
13173, 8693, 8697, 8733, 8729, 8694, 8698, 8734, 8730
13174, 8694, 8698, 8734, 8730, 8695, 8699, 8735, 8731
13175, 8695, 8699, 8735, 8731, 8696, 8700, 8736, 8732
13176, 8696, 8700, 8736, 8732, 4364, 4365, 4374, 4373
13177, 2354, 2355, 2364, 2363, 8697, 8701, 8737, 8733
13178, 8697, 8701, 8737, 8733, 8698, 8702, 8738, 8734
13179, 8698, 8702, 8738, 8734, 8699, 8703, 8739, 8735
13180, 8699, 8703, 8739, 8735, 8700, 8704, 8740, 8736
13181, 8700, 8704, 8740, 8736, 4365, 4366, 4375, 4374
13182, 2355, 2356, 2365, 2364, 8701, 8705, 8741, 8737
13183, 8701, 8705, 8741, 8737, 8702, 8706, 8742, 8738
13184, 8702, 8706, 8742, 8738, 8703, 8707, 8743, 8739
13185, 8703, 8707, 8743, 8739, 8704, 8708, 8744, 8740
13186, 8704, 8708, 8744, 8740, 4366, 4367, 4376, 4375
13187, 2356, 2357, 2366, 2365, 8705, 8709, 8745, 8741
13188, 8705, 8709, 8745, 8741, 8706, 8710, 8746, 8742
13189, 8706, 8710, 8746, 8742, 8707, 8711, 8747, 8743
13190, 8707, 8711, 8747, 8743, 8708, 8712, 8748, 8744
13191, 8708, 8712, 8748, 8744, 4367, 4368, 4377, 4376
13192, 2357, 382, 383, 2366, 8709, 4255, 4259, 8745
13193, 8709, 4255, 4259, 8745, 8710, 4256, 4260, 8746
13194, 8710, 4256, 4260, 8746, 8711, 4257, 4261, 8747
13195, 8711, 4257, 4261, 8747, 8712, 4258, 4262, 8748
13196, 8712, 4258, 4262, 8748, 4368, 980, 981, 4377
13197, 357, 2358, 2367, 358, 4179, 8713, 8749, 4183
13198, 4179, 8713, 8749, 4183, 4180, 8714, 8750, 4184
13199, 4180, 8714, 8750, 4184, 4181, 8715, 8751, 4185
13200, 4181, 8715, 8751, 4185, 4182, 8716, 8752, 4186
13201, 4182, 8716, 8752, 4186, 953, 4369, 4378, 954
13202, 2358, 2359, 2368, 2367, 8713, 8717, 8753, 8749
13203, 8713, 8717, 8753, 8749, 8714, 8718, 8754, 8750
13204, 8714, 8718, 8754, 8750, 8715, 8719, 8755, 8751
13205, 8715, 8719, 8755, 8751, 8716, 8720, 8756, 8752
13206, 8716, 8720, 8756, 8752, 4369, 4370, 4379, 4378
13207, 2359, 2360, 2369, 2368, 8717, 8721, 8757, 8753
13208, 8717, 8721, 8757, 8753, 8718, 8722, 8758, 8754
13209, 8718, 8722, 8758, 8754, 8719, 8723, 8759, 8755
13210, 8719, 8723, 8759, 8755, 8720, 8724, 8760, 8756
13211, 8720, 8724, 8760, 8756, 4370, 4371, 4380, 4379
13212, 2360, 2361, 2370, 2369, 8721, 8725, 8761, 8757
13213, 8721, 8725, 8761, 8757, 8722, 8726, 8762, 8758
13214, 8722, 8726, 8762, 8758, 8723, 8727, 8763, 8759
13215, 8723, 8727, 8763, 8759, 8724, 8728, 8764, 8760
13216, 8724, 8728, 8764, 8760, 4371, 4372, 4381, 4380
13217, 2361, 2362, 2371, 2370, 8725, 8729, 8765, 8761
13218, 8725, 8729, 8765, 8761, 8726, 8730, 8766, 8762
13219, 8726, 8730, 8766, 8762, 8727, 8731, 8767, 8763
13220, 8727, 8731, 8767, 8763, 8728, 8732, 8768, 8764
13221, 8728, 8732, 8768, 8764, 4372, 4373, 4382, 4381
13222, 2362, 2363, 2372, 2371, 8729, 8733, 8769, 8765
13223, 8729, 8733, 8769, 8765, 8730, 8734, 8770, 8766
13224, 8730, 8734, 8770, 8766, 8731, 8735, 8771, 8767
13225, 8731, 8735, 8771, 8767, 8732, 8736, 8772, 8768
13226, 8732, 8736, 8772, 8768, 4373, 4374, 4383, 4382
13227, 2363, 2364, 2373, 2372, 8733, 8737, 8773, 8769
13228, 8733, 8737, 8773, 8769, 8734, 8738, 8774, 8770
13229, 8734, 8738, 8774, 8770, 8735, 8739, 8775, 8771
13230, 8735, 8739, 8775, 8771, 8736, 8740, 8776, 8772
13231, 8736, 8740, 8776, 8772, 4374, 4375, 4384, 4383
13232, 2364, 2365, 2374, 2373, 8737, 8741, 8777, 8773
13233, 8737, 8741, 8777, 8773, 8738, 8742, 8778, 8774
13234, 8738, 8742, 8778, 8774, 8739, 8743, 8779, 8775
13235, 8739, 8743, 8779, 8775, 8740, 8744, 8780, 8776
13236, 8740, 8744, 8780, 8776, 4375, 4376, 4385, 4384
13237, 2365, 2366, 2375, 2374, 8741, 8745, 8781, 8777
13238, 8741, 8745, 8781, 8777, 8742, 8746, 8782, 8778
13239, 8742, 8746, 8782, 8778, 8743, 8747, 8783, 8779
13240, 8743, 8747, 8783, 8779, 8744, 8748, 8784, 8780
13241, 8744, 8748, 8784, 8780, 4376, 4377, 4386, 4385
13242, 2366, 383, 384, 2375, 8745, 4259, 4263, 8781
13243, 8745, 4259, 4263, 8781, 8746, 4260, 4264, 8782
13244, 8746, 4260, 4264, 8782, 8747, 4261, 4265, 8783
13245, 8747, 4261, 4265, 8783, 8748, 4262, 4266, 8784
13246, 8748, 4262, 4266, 8784, 4377, 981, 982, 4386
13247, 358, 2367, 2376, 359, 4183, 8749, 8785, 4187
13248, 4183, 8749, 8785, 4187, 4184, 8750, 8786, 4188
13249, 4184, 8750, 8786, 4188, 4185, 8751, 8787, 4189
13250, 4185, 8751, 8787, 4189, 4186, 8752, 8788, 4190
13251, 4186, 8752, 8788, 4190, 954, 4378, 4387, 955
13252, 2367, 2368, 2377, 2376, 8749, 8753, 8789, 8785
13253, 8749, 8753, 8789, 8785, 8750, 8754, 8790, 8786
13254, 8750, 8754, 8790, 8786, 8751, 8755, 8791, 8787
13255, 8751, 8755, 8791, 8787, 8752, 8756, 8792, 8788
13256, 8752, 8756, 8792, 8788, 4378, 4379, 4388, 4387
13257, 2368, 2369, 2378, 2377, 8753, 8757, 8793, 8789
13258, 8753, 8757, 8793, 8789, 8754, 8758, 8794, 8790
13259, 8754, 8758, 8794, 8790, 8755, 8759, 8795, 8791
13260, 8755, 8759, 8795, 8791, 8756, 8760, 8796, 8792
13261, 8756, 8760, 8796, 8792, 4379, 4380, 4389, 4388
13262, 2369, 2370, 2379, 2378, 8757, 8761, 8797, 8793
13263, 8757, 8761, 8797, 8793, 8758, 8762, 8798, 8794
13264, 8758, 8762, 8798, 8794, 8759, 8763, 8799, 8795
13265, 8759, 8763, 8799, 8795, 8760, 8764, 8800, 8796
13266, 8760, 8764, 8800, 8796, 4380, 4381, 4390, 4389
13267, 2370, 2371, 2380, 2379, 8761, 8765, 8801, 8797
13268, 8761, 8765, 8801, 8797, 8762, 8766, 8802, 8798
13269, 8762, 8766, 8802, 8798, 8763, 8767, 8803, 8799
13270, 8763, 8767, 8803, 8799, 8764, 8768, 8804, 8800
13271, 8764, 8768, 8804, 8800, 4381, 4382, 4391, 4390
13272, 2371, 2372, 2381, 2380, 8765, 8769, 8805, 8801
13273, 8765, 8769, 8805, 8801, 8766, 8770, 8806, 8802
13274, 8766, 8770, 8806, 8802, 8767, 8771, 8807, 8803
13275, 8767, 8771, 8807, 8803, 8768, 8772, 8808, 8804
13276, 8768, 8772, 8808, 8804, 4382, 4383, 4392, 4391
13277, 2372, 2373, 2382, 2381, 8769, 8773, 8809, 8805
13278, 8769, 8773, 8809, 8805, 8770, 8774, 8810, 8806
13279, 8770, 8774, 8810, 8806, 8771, 8775, 8811, 8807
13280, 8771, 8775, 8811, 8807, 8772, 8776, 8812, 8808
13281, 8772, 8776, 8812, 8808, 4383, 4384, 4393, 4392
13282, 2373, 2374, 2383, 2382, 8773, 8777, 8813, 8809
13283, 8773, 8777, 8813, 8809, 8774, 8778, 8814, 8810
13284, 8774, 8778, 8814, 8810, 8775, 8779, 8815, 8811
13285, 8775, 8779, 8815, 8811, 8776, 8780, 8816, 8812
13286, 8776, 8780, 8816, 8812, 4384, 4385, 4394, 4393
13287, 2374, 2375, 2384, 2383, 8777, 8781, 8817, 8813
13288, 8777, 8781, 8817, 8813, 8778, 8782, 8818, 8814
13289, 8778, 8782, 8818, 8814, 8779, 8783, 8819, 8815
13290, 8779, 8783, 8819, 8815, 8780, 8784, 8820, 8816
13291, 8780, 8784, 8820, 8816, 4385, 4386, 4395, 4394
13292, 2375, 384, 385, 2384, 8781, 4263, 4267, 8817
13293, 8781, 4263, 4267, 8817, 8782, 4264, 4268, 8818
13294, 8782, 4264, 4268, 8818, 8783, 4265, 4269, 8819
13295, 8783, 4265, 4269, 8819, 8784, 4266, 4270, 8820
13296, 8784, 4266, 4270, 8820, 4386, 982, 983, 4395
13297, 359, 2376, 2385, 360, 4187, 8785, 8821, 4191
13298, 4187, 8785, 8821, 4191, 4188, 8786, 8822, 4192
13299, 4188, 8786, 8822, 4192, 4189, 8787, 8823, 4193
13300, 4189, 8787, 8823, 4193, 4190, 8788, 8824, 4194
13301, 4190, 8788, 8824, 4194, 955, 4387, 4396, 956
13302, 2376, 2377, 2386, 2385, 8785, 8789, 8825, 8821
13303, 8785, 8789, 8825, 8821, 8786, 8790, 8826, 8822
13304, 8786, 8790, 8826, 8822, 8787, 8791, 8827, 8823
13305, 8787, 8791, 8827, 8823, 8788, 8792, 8828, 8824
13306, 8788, 8792, 8828, 8824, 4387, 4388, 4397, 4396
13307, 2377, 2378, 2387, 2386, 8789, 8793, 8829, 8825
13308, 8789, 8793, 8829, 8825, 8790, 8794, 8830, 8826
13309, 8790, 8794, 8830, 8826, 8791, 8795, 8831, 8827
13310, 8791, 8795, 8831, 8827, 8792, 8796, 8832, 8828
13311, 8792, 8796, 8832, 8828, 4388, 4389, 4398, 4397
13312, 2378, 2379, 2388, 2387, 8793, 8797, 8833, 8829
13313, 8793, 8797, 8833, 8829, 8794, 8798, 8834, 8830
13314, 8794, 8798, 8834, 8830, 8795, 8799, 8835, 8831
13315, 8795, 8799, 8835, 8831, 8796, 8800, 8836, 8832
13316, 8796, 8800, 8836, 8832, 4389, 4390, 4399, 4398
13317, 2379, 2380, 2389, 2388, 8797, 8801, 8837, 8833
13318, 8797, 8801, 8837, 8833, 8798, 8802, 8838, 8834
13319, 8798, 8802, 8838, 8834, 8799, 8803, 8839, 8835
13320, 8799, 8803, 8839, 8835, 8800, 8804, 8840, 8836
13321, 8800, 8804, 8840, 8836, 4390, 4391, 4400, 4399
13322, 2380, 2381, 2390, 2389, 8801, 8805, 8841, 8837
13323, 8801, 8805, 8841, 8837, 8802, 8806, 8842, 8838
13324, 8802, 8806, 8842, 8838, 8803, 8807, 8843, 8839
13325, 8803, 8807, 8843, 8839, 8804, 8808, 8844, 8840
13326, 8804, 8808, 8844, 8840, 4391, 4392, 4401, 4400
13327, 2381, 2382, 2391, 2390, 8805, 8809, 8845, 8841
13328, 8805, 8809, 8845, 8841, 8806, 8810, 8846, 8842
13329, 8806, 8810, 8846, 8842, 8807, 8811, 8847, 8843
13330, 8807, 8811, 8847, 8843, 8808, 8812, 8848, 8844
13331, 8808, 8812, 8848, 8844, 4392, 4393, 4402, 4401
13332, 2382, 2383, 2392, 2391, 8809, 8813, 8849, 8845
13333, 8809, 8813, 8849, 8845, 8810, 8814, 8850, 8846
13334, 8810, 8814, 8850, 8846, 8811, 8815, 8851, 8847
13335, 8811, 8815, 8851, 8847, 8812, 8816, 8852, 8848
13336, 8812, 8816, 8852, 8848, 4393, 4394, 4403, 4402
13337, 2383, 2384, 2393, 2392, 8813, 8817, 8853, 8849
13338, 8813, 8817, 8853, 8849, 8814, 8818, 8854, 8850
13339, 8814, 8818, 8854, 8850, 8815, 8819, 8855, 8851
13340, 8815, 8819, 8855, 8851, 8816, 8820, 8856, 8852
13341, 8816, 8820, 8856, 8852, 4394, 4395, 4404, 4403
13342, 2384, 385, 386, 2393, 8817, 4267, 4271, 8853
13343, 8817, 4267, 4271, 8853, 8818, 4268, 4272, 8854
13344, 8818, 4268, 4272, 8854, 8819, 4269, 4273, 8855
13345, 8819, 4269, 4273, 8855, 8820, 4270, 4274, 8856
13346, 8820, 4270, 4274, 8856, 4395, 983, 984, 4404
13347, 360, 2385, 2394, 361, 4191, 8821, 8857, 4195
13348, 4191, 8821, 8857, 4195, 4192, 8822, 8858, 4196
13349, 4192, 8822, 8858, 4196, 4193, 8823, 8859, 4197
13350, 4193, 8823, 8859, 4197, 4194, 8824, 8860, 4198
13351, 4194, 8824, 8860, 4198, 956, 4396, 4405, 957
13352, 2385, 2386, 2395, 2394, 8821, 8825, 8861, 8857
13353, 8821, 8825, 8861, 8857, 8822, 8826, 8862, 8858
13354, 8822, 8826, 8862, 8858, 8823, 8827, 8863, 8859
13355, 8823, 8827, 8863, 8859, 8824, 8828, 8864, 8860
13356, 8824, 8828, 8864, 8860, 4396, 4397, 4406, 4405
13357, 2386, 2387, 2396, 2395, 8825, 8829, 8865, 8861
13358, 8825, 8829, 8865, 8861, 8826, 8830, 8866, 8862
13359, 8826, 8830, 8866, 8862, 8827, 8831, 8867, 8863
13360, 8827, 8831, 8867, 8863, 8828, 8832, 8868, 8864
13361, 8828, 8832, 8868, 8864, 4397, 4398, 4407, 4406
13362, 2387, 2388, 2397, 2396, 8829, 8833, 8869, 8865
13363, 8829, 8833, 8869, 8865, 8830, 8834, 8870, 8866
13364, 8830, 8834, 8870, 8866, 8831, 8835, 8871, 8867
13365, 8831, 8835, 8871, 8867, 8832, 8836, 8872, 8868
13366, 8832, 8836, 8872, 8868, 4398, 4399, 4408, 4407
13367, 2388, 2389, 2398, 2397, 8833, 8837, 8873, 8869
13368, 8833, 8837, 8873, 8869, 8834, 8838, 8874, 8870
13369, 8834, 8838, 8874, 8870, 8835, 8839, 8875, 8871
13370, 8835, 8839, 8875, 8871, 8836, 8840, 8876, 8872
13371, 8836, 8840, 8876, 8872, 4399, 4400, 4409, 4408
13372, 2389, 2390, 2399, 2398, 8837, 8841, 8877, 8873
13373, 8837, 8841, 8877, 8873, 8838, 8842, 8878, 8874
13374, 8838, 8842, 8878, 8874, 8839, 8843, 8879, 8875
13375, 8839, 8843, 8879, 8875, 8840, 8844, 8880, 8876
13376, 8840, 8844, 8880, 8876, 4400, 4401, 4410, 4409
13377, 2390, 2391, 2400, 2399, 8841, 8845, 8881, 8877
13378, 8841, 8845, 8881, 8877, 8842, 8846, 8882, 8878
13379, 8842, 8846, 8882, 8878, 8843, 8847, 8883, 8879
13380, 8843, 8847, 8883, 8879, 8844, 8848, 8884, 8880
13381, 8844, 8848, 8884, 8880, 4401, 4402, 4411, 4410
13382, 2391, 2392, 2401, 2400, 8845, 8849, 8885, 8881
13383, 8845, 8849, 8885, 8881, 8846, 8850, 8886, 8882
13384, 8846, 8850, 8886, 8882, 8847, 8851, 8887, 8883
13385, 8847, 8851, 8887, 8883, 8848, 8852, 8888, 8884
13386, 8848, 8852, 8888, 8884, 4402, 4403, 4412, 4411
13387, 2392, 2393, 2402, 2401, 8849, 8853, 8889, 8885
13388, 8849, 8853, 8889, 8885, 8850, 8854, 8890, 8886
13389, 8850, 8854, 8890, 8886, 8851, 8855, 8891, 8887
13390, 8851, 8855, 8891, 8887, 8852, 8856, 8892, 8888
13391, 8852, 8856, 8892, 8888, 4403, 4404, 4413, 4412
13392, 2393, 386, 387, 2402, 8853, 4271, 4275, 8889
13393, 8853, 4271, 4275, 8889, 8854, 4272, 4276, 8890
13394, 8854, 4272, 4276, 8890, 8855, 4273, 4277, 8891
13395, 8855, 4273, 4277, 8891, 8856, 4274, 4278, 8892
13396, 8856, 4274, 4278, 8892, 4404, 984, 985, 4413
13397, 361, 2394, 365, 21, 4195, 8857, 4199, 939
13398, 4195, 8857, 4199, 939, 4196, 8858, 4200, 940
13399, 4196, 8858, 4200, 940, 4197, 8859, 4201, 941
13400, 4197, 8859, 4201, 941, 4198, 8860, 4202, 942
13401, 4198, 8860, 4202, 942, 957, 4405, 962, 77
13402, 2394, 2395, 366, 365, 8857, 8861, 4203, 4199
13403, 8857, 8861, 4203, 4199, 8858, 8862, 4204, 4200
13404, 8858, 8862, 4204, 4200, 8859, 8863, 4205, 4201
13405, 8859, 8863, 4205, 4201, 8860, 8864, 4206, 4202
13406, 8860, 8864, 4206, 4202, 4405, 4406, 963, 962
13407, 2395, 2396, 367, 366, 8861, 8865, 4207, 4203
13408, 8861, 8865, 4207, 4203, 8862, 8866, 4208, 4204
13409, 8862, 8866, 4208, 4204, 8863, 8867, 4209, 4205
13410, 8863, 8867, 4209, 4205, 8864, 8868, 4210, 4206
13411, 8864, 8868, 4210, 4206, 4406, 4407, 964, 963
13412, 2396, 2397, 368, 367, 8865, 8869, 4211, 4207
13413, 8865, 8869, 4211, 4207, 8866, 8870, 4212, 4208
13414, 8866, 8870, 4212, 4208, 8867, 8871, 4213, 4209
13415, 8867, 8871, 4213, 4209, 8868, 8872, 4214, 4210
13416, 8868, 8872, 4214, 4210, 4407, 4408, 965, 964
13417, 2397, 2398, 369, 368, 8869, 8873, 4215, 4211
13418, 8869, 8873, 4215, 4211, 8870, 8874, 4216, 4212
13419, 8870, 8874, 4216, 4212, 8871, 8875, 4217, 4213
13420, 8871, 8875, 4217, 4213, 8872, 8876, 4218, 4214
13421, 8872, 8876, 4218, 4214, 4408, 4409, 966, 965
13422, 2398, 2399, 370, 369, 8873, 8877, 4219, 4215
13423, 8873, 8877, 4219, 4215, 8874, 8878, 4220, 4216
13424, 8874, 8878, 4220, 4216, 8875, 8879, 4221, 4217
13425, 8875, 8879, 4221, 4217, 8876, 8880, 4222, 4218
13426, 8876, 8880, 4222, 4218, 4409, 4410, 967, 966
13427, 2399, 2400, 371, 370, 8877, 8881, 4223, 4219
13428, 8877, 8881, 4223, 4219, 8878, 8882, 4224, 4220
13429, 8878, 8882, 4224, 4220, 8879, 8883, 4225, 4221
13430, 8879, 8883, 4225, 4221, 8880, 8884, 4226, 4222
13431, 8880, 8884, 4226, 4222, 4410, 4411, 968, 967
13432, 2400, 2401, 372, 371, 8881, 8885, 4227, 4223
13433, 8881, 8885, 4227, 4223, 8882, 8886, 4228, 4224
13434, 8882, 8886, 4228, 4224, 8883, 8887, 4229, 4225
13435, 8883, 8887, 4229, 4225, 8884, 8888, 4230, 4226
13436, 8884, 8888, 4230, 4226, 4411, 4412, 969, 968
13437, 2401, 2402, 373, 372, 8885, 8889, 4231, 4227
13438, 8885, 8889, 4231, 4227, 8886, 8890, 4232, 4228
13439, 8886, 8890, 4232, 4228, 8887, 8891, 4233, 4229
13440, 8887, 8891, 4233, 4229, 8888, 8892, 4234, 4230
13441, 8888, 8892, 4234, 4230, 4412, 4413, 970, 969
13442, 2402, 387, 23, 373, 8889, 4275, 958, 4231
13443, 8889, 4275, 958, 4231, 8890, 4276, 959, 4232
13444, 8890, 4276, 959, 4232, 8891, 4277, 960, 4233
13445, 8891, 4277, 960, 4233, 8892, 4278, 961, 4234
13446, 8892, 4278, 961, 4234, 4413, 985, 79, 970
*ELEMENT, type=C3D8, ELSET=Volume21
13447, 21, 365, 2493, 418, 939, 4199, 8893, 4438
13448, 939, 4199, 8893, 4438, 940, 4200, 8894, 4439
13449, 940, 4200, 8894, 4439, 941, 4201, 8895, 4440
13450, 941, 4201, 8895, 4440, 942, 4202, 8896, 4441
13451, 942, 4202, 8896, 4441, 77, 962, 4498, 1009
13452, 418, 2493, 2494, 419, 4438, 8893, 8897, 4442
13453, 4438, 8893, 8897, 4442, 4439, 8894, 8898, 4443
13454, 4439, 8894, 8898, 4443, 4440, 8895, 8899, 4444
13455, 4440, 8895, 8899, 4444, 4441, 8896, 8900, 4445
13456, 4441, 8896, 8900, 4445, 1009, 4498, 4499, 1010
13457, 419, 2494, 2495, 420, 4442, 8897, 8901, 4446
13458, 4442, 8897, 8901, 4446, 4443, 8898, 8902, 4447
13459, 4443, 8898, 8902, 4447, 4444, 8899, 8903, 4448
13460, 4444, 8899, 8903, 4448, 4445, 8900, 8904, 4449
13461, 4445, 8900, 8904, 4449, 1010, 4499, 4500, 1011
13462, 420, 2495, 2496, 421, 4446, 8901, 8905, 4450
13463, 4446, 8901, 8905, 4450, 4447, 8902, 8906, 4451
13464, 4447, 8902, 8906, 4451, 4448, 8903, 8907, 4452
13465, 4448, 8903, 8907, 4452, 4449, 8904, 8908, 4453
13466, 4449, 8904, 8908, 4453, 1011, 4500, 4501, 1012
13467, 421, 2496, 2497, 422, 4450, 8905, 8909, 4454
13468, 4450, 8905, 8909, 4454, 4451, 8906, 8910, 4455
13469, 4451, 8906, 8910, 4455, 4452, 8907, 8911, 4456
13470, 4452, 8907, 8911, 4456, 4453, 8908, 8912, 4457
13471, 4453, 8908, 8912, 4457, 1012, 4501, 4502, 1013
13472, 422, 2497, 2498, 423, 4454, 8909, 8913, 4458
13473, 4454, 8909, 8913, 4458, 4455, 8910, 8914, 4459
13474, 4455, 8910, 8914, 4459, 4456, 8911, 8915, 4460
13475, 4456, 8911, 8915, 4460, 4457, 8912, 8916, 4461
13476, 4457, 8912, 8916, 4461, 1013, 4502, 4503, 1014
13477, 423, 2498, 436, 28, 4458, 8913, 4462, 1005
13478, 4458, 8913, 4462, 1005, 4459, 8914, 4463, 1006
13479, 4459, 8914, 4463, 1006, 4460, 8915, 4464, 1007
13480, 4460, 8915, 4464, 1007, 4461, 8916, 4465, 1008
13481, 4461, 8916, 4465, 1008, 1014, 4503, 1015, 82
13482, 365, 366, 2499, 2493, 4199, 4203, 8917, 8893
13483, 4199, 4203, 8917, 8893, 4200, 4204, 8918, 8894
13484, 4200, 4204, 8918, 8894, 4201, 4205, 8919, 8895
13485, 4201, 4205, 8919, 8895, 4202, 4206, 8920, 8896
13486, 4202, 4206, 8920, 8896, 962, 963, 4504, 4498
13487, 2493, 2499, 2500, 2494, 8893, 8917, 8921, 8897
13488, 8893, 8917, 8921, 8897, 8894, 8918, 8922, 8898
13489, 8894, 8918, 8922, 8898, 8895, 8919, 8923, 8899
13490, 8895, 8919, 8923, 8899, 8896, 8920, 8924, 8900
13491, 8896, 8920, 8924, 8900, 4498, 4504, 4505, 4499
13492, 2494, 2500, 2501, 2495, 8897, 8921, 8925, 8901
13493, 8897, 8921, 8925, 8901, 8898, 8922, 8926, 8902
13494, 8898, 8922, 8926, 8902, 8899, 8923, 8927, 8903
13495, 8899, 8923, 8927, 8903, 8900, 8924, 8928, 8904
13496, 8900, 8924, 8928, 8904, 4499, 4505, 4506, 4500
13497, 2495, 2501, 2502, 2496, 8901, 8925, 8929, 8905
13498, 8901, 8925, 8929, 8905, 8902, 8926, 8930, 8906
13499, 8902, 8926, 8930, 8906, 8903, 8927, 8931, 8907
13500, 8903, 8927, 8931, 8907, 8904, 8928, 8932, 8908
13501, 8904, 8928, 8932, 8908, 4500, 4506, 4507, 4501
13502, 2496, 2502, 2503, 2497, 8905, 8929, 8933, 8909
13503, 8905, 8929, 8933, 8909, 8906, 8930, 8934, 8910
13504, 8906, 8930, 8934, 8910, 8907, 8931, 8935, 8911
13505, 8907, 8931, 8935, 8911, 8908, 8932, 8936, 8912
13506, 8908, 8932, 8936, 8912, 4501, 4507, 4508, 4502
13507, 2497, 2503, 2504, 2498, 8909, 8933, 8937, 8913
13508, 8909, 8933, 8937, 8913, 8910, 8934, 8938, 8914
13509, 8910, 8934, 8938, 8914, 8911, 8935, 8939, 8915
13510, 8911, 8935, 8939, 8915, 8912, 8936, 8940, 8916
13511, 8912, 8936, 8940, 8916, 4502, 4508, 4509, 4503
13512, 2498, 2504, 437, 436, 8913, 8937, 4466, 4462
13513, 8913, 8937, 4466, 4462, 8914, 8938, 4467, 4463
13514, 8914, 8938, 4467, 4463, 8915, 8939, 4468, 4464
13515, 8915, 8939, 4468, 4464, 8916, 8940, 4469, 4465
13516, 8916, 8940, 4469, 4465, 4503, 4509, 1016, 1015
13517, 366, 367, 2505, 2499, 4203, 4207, 8941, 8917
13518, 4203, 4207, 8941, 8917, 4204, 4208, 8942, 8918
13519, 4204, 4208, 8942, 8918, 4205, 4209, 8943, 8919
13520, 4205, 4209, 8943, 8919, 4206, 4210, 8944, 8920
13521, 4206, 4210, 8944, 8920, 963, 964, 4510, 4504
13522, 2499, 2505, 2506, 2500, 8917, 8941, 8945, 8921
13523, 8917, 8941, 8945, 8921, 8918, 8942, 8946, 8922
13524, 8918, 8942, 8946, 8922, 8919, 8943, 8947, 8923
13525, 8919, 8943, 8947, 8923, 8920, 8944, 8948, 8924
13526, 8920, 8944, 8948, 8924, 4504, 4510, 4511, 4505
13527, 2500, 2506, 2507, 2501, 8921, 8945, 8949, 8925
13528, 8921, 8945, 8949, 8925, 8922, 8946, 8950, 8926
13529, 8922, 8946, 8950, 8926, 8923, 8947, 8951, 8927
13530, 8923, 8947, 8951, 8927, 8924, 8948, 8952, 8928
13531, 8924, 8948, 8952, 8928, 4505, 4511, 4512, 4506
13532, 2501, 2507, 2508, 2502, 8925, 8949, 8953, 8929
13533, 8925, 8949, 8953, 8929, 8926, 8950, 8954, 8930
13534, 8926, 8950, 8954, 8930, 8927, 8951, 8955, 8931
13535, 8927, 8951, 8955, 8931, 8928, 8952, 8956, 8932
13536, 8928, 8952, 8956, 8932, 4506, 4512, 4513, 4507
13537, 2502, 2508, 2509, 2503, 8929, 8953, 8957, 8933
13538, 8929, 8953, 8957, 8933, 8930, 8954, 8958, 8934
13539, 8930, 8954, 8958, 8934, 8931, 8955, 8959, 8935
13540, 8931, 8955, 8959, 8935, 8932, 8956, 8960, 8936
13541, 8932, 8956, 8960, 8936, 4507, 4513, 4514, 4508
13542, 2503, 2509, 2510, 2504, 8933, 8957, 8961, 8937
13543, 8933, 8957, 8961, 8937, 8934, 8958, 8962, 8938
13544, 8934, 8958, 8962, 8938, 8935, 8959, 8963, 8939
13545, 8935, 8959, 8963, 8939, 8936, 8960, 8964, 8940
13546, 8936, 8960, 8964, 8940, 4508, 4514, 4515, 4509
13547, 2504, 2510, 438, 437, 8937, 8961, 4470, 4466
13548, 8937, 8961, 4470, 4466, 8938, 8962, 4471, 4467
13549, 8938, 8962, 4471, 4467, 8939, 8963, 4472, 4468
13550, 8939, 8963, 4472, 4468, 8940, 8964, 4473, 4469
13551, 8940, 8964, 4473, 4469, 4509, 4515, 1017, 1016
13552, 367, 368, 2511, 2505, 4207, 4211, 8965, 8941
13553, 4207, 4211, 8965, 8941, 4208, 4212, 8966, 8942
13554, 4208, 4212, 8966, 8942, 4209, 4213, 8967, 8943
13555, 4209, 4213, 8967, 8943, 4210, 4214, 8968, 8944
13556, 4210, 4214, 8968, 8944, 964, 965, 4516, 4510
13557, 2505, 2511, 2512, 2506, 8941, 8965, 8969, 8945
13558, 8941, 8965, 8969, 8945, 8942, 8966, 8970, 8946
13559, 8942, 8966, 8970, 8946, 8943, 8967, 8971, 8947
13560, 8943, 8967, 8971, 8947, 8944, 8968, 8972, 8948
13561, 8944, 8968, 8972, 8948, 4510, 4516, 4517, 4511
13562, 2506, 2512, 2513, 2507, 8945, 8969, 8973, 8949
13563, 8945, 8969, 8973, 8949, 8946, 8970, 8974, 8950
13564, 8946, 8970, 8974, 8950, 8947, 8971, 8975, 8951
13565, 8947, 8971, 8975, 8951, 8948, 8972, 8976, 8952
13566, 8948, 8972, 8976, 8952, 4511, 4517, 4518, 4512
13567, 2507, 2513, 2514, 2508, 8949, 8973, 8977, 8953
13568, 8949, 8973, 8977, 8953, 8950, 8974, 8978, 8954
13569, 8950, 8974, 8978, 8954, 8951, 8975, 8979, 8955
13570, 8951, 8975, 8979, 8955, 8952, 8976, 8980, 8956
13571, 8952, 8976, 8980, 8956, 4512, 4518, 4519, 4513
13572, 2508, 2514, 2515, 2509, 8953, 8977, 8981, 8957
13573, 8953, 8977, 8981, 8957, 8954, 8978, 8982, 8958
13574, 8954, 8978, 8982, 8958, 8955, 8979, 8983, 8959
13575, 8955, 8979, 8983, 8959, 8956, 8980, 8984, 8960
13576, 8956, 8980, 8984, 8960, 4513, 4519, 4520, 4514
13577, 2509, 2515, 2516, 2510, 8957, 8981, 8985, 8961
13578, 8957, 8981, 8985, 8961, 8958, 8982, 8986, 8962
13579, 8958, 8982, 8986, 8962, 8959, 8983, 8987, 8963
13580, 8959, 8983, 8987, 8963, 8960, 8984, 8988, 8964
13581, 8960, 8984, 8988, 8964, 4514, 4520, 4521, 4515
13582, 2510, 2516, 439, 438, 8961, 8985, 4474, 4470
13583, 8961, 8985, 4474, 4470, 8962, 8986, 4475, 4471
13584, 8962, 8986, 4475, 4471, 8963, 8987, 4476, 4472
13585, 8963, 8987, 4476, 4472, 8964, 8988, 4477, 4473
13586, 8964, 8988, 4477, 4473, 4515, 4521, 1018, 1017
13587, 368, 369, 2517, 2511, 4211, 4215, 8989, 8965
13588, 4211, 4215, 8989, 8965, 4212, 4216, 8990, 8966
13589, 4212, 4216, 8990, 8966, 4213, 4217, 8991, 8967
13590, 4213, 4217, 8991, 8967, 4214, 4218, 8992, 8968
13591, 4214, 4218, 8992, 8968, 965, 966, 4522, 4516
13592, 2511, 2517, 2518, 2512, 8965, 8989, 8993, 8969
13593, 8965, 8989, 8993, 8969, 8966, 8990, 8994, 8970
13594, 8966, 8990, 8994, 8970, 8967, 8991, 8995, 8971
13595, 8967, 8991, 8995, 8971, 8968, 8992, 8996, 8972
13596, 8968, 8992, 8996, 8972, 4516, 4522, 4523, 4517
13597, 2512, 2518, 2519, 2513, 8969, 8993, 8997, 8973
13598, 8969, 8993, 8997, 8973, 8970, 8994, 8998, 8974
13599, 8970, 8994, 8998, 8974, 8971, 8995, 8999, 8975
13600, 8971, 8995, 8999, 8975, 8972, 8996, 9000, 8976
13601, 8972, 8996, 9000, 8976, 4517, 4523, 4524, 4518
13602, 2513, 2519, 2520, 2514, 8973, 8997, 9001, 8977
13603, 8973, 8997, 9001, 8977, 8974, 8998, 9002, 8978
13604, 8974, 8998, 9002, 8978, 8975, 8999, 9003, 8979
13605, 8975, 8999, 9003, 8979, 8976, 9000, 9004, 8980
13606, 8976, 9000, 9004, 8980, 4518, 4524, 4525, 4519
13607, 2514, 2520, 2521, 2515, 8977, 9001, 9005, 8981
13608, 8977, 9001, 9005, 8981, 8978, 9002, 9006, 8982
13609, 8978, 9002, 9006, 8982, 8979, 9003, 9007, 8983
13610, 8979, 9003, 9007, 8983, 8980, 9004, 9008, 8984
13611, 8980, 9004, 9008, 8984, 4519, 4525, 4526, 4520
13612, 2515, 2521, 2522, 2516, 8981, 9005, 9009, 8985
13613, 8981, 9005, 9009, 8985, 8982, 9006, 9010, 8986
13614, 8982, 9006, 9010, 8986, 8983, 9007, 9011, 8987
13615, 8983, 9007, 9011, 8987, 8984, 9008, 9012, 8988
13616, 8984, 9008, 9012, 8988, 4520, 4526, 4527, 4521
13617, 2516, 2522, 440, 439, 8985, 9009, 4478, 4474
13618, 8985, 9009, 4478, 4474, 8986, 9010, 4479, 4475
13619, 8986, 9010, 4479, 4475, 8987, 9011, 4480, 4476
13620, 8987, 9011, 4480, 4476, 8988, 9012, 4481, 4477
13621, 8988, 9012, 4481, 4477, 4521, 4527, 1019, 1018
13622, 369, 370, 2523, 2517, 4215, 4219, 9013, 8989
13623, 4215, 4219, 9013, 8989, 4216, 4220, 9014, 8990
13624, 4216, 4220, 9014, 8990, 4217, 4221, 9015, 8991
13625, 4217, 4221, 9015, 8991, 4218, 4222, 9016, 8992
13626, 4218, 4222, 9016, 8992, 966, 967, 4528, 4522
13627, 2517, 2523, 2524, 2518, 8989, 9013, 9017, 8993
13628, 8989, 9013, 9017, 8993, 8990, 9014, 9018, 8994
13629, 8990, 9014, 9018, 8994, 8991, 9015, 9019, 8995
13630, 8991, 9015, 9019, 8995, 8992, 9016, 9020, 8996
13631, 8992, 9016, 9020, 8996, 4522, 4528, 4529, 4523
13632, 2518, 2524, 2525, 2519, 8993, 9017, 9021, 8997
13633, 8993, 9017, 9021, 8997, 8994, 9018, 9022, 8998
13634, 8994, 9018, 9022, 8998, 8995, 9019, 9023, 8999
13635, 8995, 9019, 9023, 8999, 8996, 9020, 9024, 9000
13636, 8996, 9020, 9024, 9000, 4523, 4529, 4530, 4524
13637, 2519, 2525, 2526, 2520, 8997, 9021, 9025, 9001
13638, 8997, 9021, 9025, 9001, 8998, 9022, 9026, 9002
13639, 8998, 9022, 9026, 9002, 8999, 9023, 9027, 9003
13640, 8999, 9023, 9027, 9003, 9000, 9024, 9028, 9004
13641, 9000, 9024, 9028, 9004, 4524, 4530, 4531, 4525
13642, 2520, 2526, 2527, 2521, 9001, 9025, 9029, 9005
13643, 9001, 9025, 9029, 9005, 9002, 9026, 9030, 9006
13644, 9002, 9026, 9030, 9006, 9003, 9027, 9031, 9007
13645, 9003, 9027, 9031, 9007, 9004, 9028, 9032, 9008
13646, 9004, 9028, 9032, 9008, 4525, 4531, 4532, 4526
13647, 2521, 2527, 2528, 2522, 9005, 9029, 9033, 9009
13648, 9005, 9029, 9033, 9009, 9006, 9030, 9034, 9010
13649, 9006, 9030, 9034, 9010, 9007, 9031, 9035, 9011
13650, 9007, 9031, 9035, 9011, 9008, 9032, 9036, 9012
13651, 9008, 9032, 9036, 9012, 4526, 4532, 4533, 4527
13652, 2522, 2528, 441, 440, 9009, 9033, 4482, 4478
13653, 9009, 9033, 4482, 4478, 9010, 9034, 4483, 4479
13654, 9010, 9034, 4483, 4479, 9011, 9035, 4484, 4480
13655, 9011, 9035, 4484, 4480, 9012, 9036, 4485, 4481
13656, 9012, 9036, 4485, 4481, 4527, 4533, 1020, 1019
13657, 370, 371, 2529, 2523, 4219, 4223, 9037, 9013
13658, 4219, 4223, 9037, 9013, 4220, 4224, 9038, 9014
13659, 4220, 4224, 9038, 9014, 4221, 4225, 9039, 9015
13660, 4221, 4225, 9039, 9015, 4222, 4226, 9040, 9016
13661, 4222, 4226, 9040, 9016, 967, 968, 4534, 4528
13662, 2523, 2529, 2530, 2524, 9013, 9037, 9041, 9017
13663, 9013, 9037, 9041, 9017, 9014, 9038, 9042, 9018
13664, 9014, 9038, 9042, 9018, 9015, 9039, 9043, 9019
13665, 9015, 9039, 9043, 9019, 9016, 9040, 9044, 9020
13666, 9016, 9040, 9044, 9020, 4528, 4534, 4535, 4529
13667, 2524, 2530, 2531, 2525, 9017, 9041, 9045, 9021
13668, 9017, 9041, 9045, 9021, 9018, 9042, 9046, 9022
13669, 9018, 9042, 9046, 9022, 9019, 9043, 9047, 9023
13670, 9019, 9043, 9047, 9023, 9020, 9044, 9048, 9024
13671, 9020, 9044, 9048, 9024, 4529, 4535, 4536, 4530
13672, 2525, 2531, 2532, 2526, 9021, 9045, 9049, 9025
13673, 9021, 9045, 9049, 9025, 9022, 9046, 9050, 9026
13674, 9022, 9046, 9050, 9026, 9023, 9047, 9051, 9027
13675, 9023, 9047, 9051, 9027, 9024, 9048, 9052, 9028
13676, 9024, 9048, 9052, 9028, 4530, 4536, 4537, 4531
13677, 2526, 2532, 2533, 2527, 9025, 9049, 9053, 9029
13678, 9025, 9049, 9053, 9029, 9026, 9050, 9054, 9030
13679, 9026, 9050, 9054, 9030, 9027, 9051, 9055, 9031
13680, 9027, 9051, 9055, 9031, 9028, 9052, 9056, 9032
13681, 9028, 9052, 9056, 9032, 4531, 4537, 4538, 4532
13682, 2527, 2533, 2534, 2528, 9029, 9053, 9057, 9033
13683, 9029, 9053, 9057, 9033, 9030, 9054, 9058, 9034
13684, 9030, 9054, 9058, 9034, 9031, 9055, 9059, 9035
13685, 9031, 9055, 9059, 9035, 9032, 9056, 9060, 9036
13686, 9032, 9056, 9060, 9036, 4532, 4538, 4539, 4533
13687, 2528, 2534, 442, 441, 9033, 9057, 4486, 4482
13688, 9033, 9057, 4486, 4482, 9034, 9058, 4487, 4483
13689, 9034, 9058, 4487, 4483, 9035, 9059, 4488, 4484
13690, 9035, 9059, 4488, 4484, 9036, 9060, 4489, 4485
13691, 9036, 9060, 4489, 4485, 4533, 4539, 1021, 1020
13692, 371, 372, 2535, 2529, 4223, 4227, 9061, 9037
13693, 4223, 4227, 9061, 9037, 4224, 4228, 9062, 9038
13694, 4224, 4228, 9062, 9038, 4225, 4229, 9063, 9039
13695, 4225, 4229, 9063, 9039, 4226, 4230, 9064, 9040
13696, 4226, 4230, 9064, 9040, 968, 969, 4540, 4534
13697, 2529, 2535, 2536, 2530, 9037, 9061, 9065, 9041
13698, 9037, 9061, 9065, 9041, 9038, 9062, 9066, 9042
13699, 9038, 9062, 9066, 9042, 9039, 9063, 9067, 9043
13700, 9039, 9063, 9067, 9043, 9040, 9064, 9068, 9044
13701, 9040, 9064, 9068, 9044, 4534, 4540, 4541, 4535
13702, 2530, 2536, 2537, 2531, 9041, 9065, 9069, 9045
13703, 9041, 9065, 9069, 9045, 9042, 9066, 9070, 9046
13704, 9042, 9066, 9070, 9046, 9043, 9067, 9071, 9047
13705, 9043, 9067, 9071, 9047, 9044, 9068, 9072, 9048
13706, 9044, 9068, 9072, 9048, 4535, 4541, 4542, 4536
13707, 2531, 2537, 2538, 2532, 9045, 9069, 9073, 9049
13708, 9045, 9069, 9073, 9049, 9046, 9070, 9074, 9050
13709, 9046, 9070, 9074, 9050, 9047, 9071, 9075, 9051
13710, 9047, 9071, 9075, 9051, 9048, 9072, 9076, 9052
13711, 9048, 9072, 9076, 9052, 4536, 4542, 4543, 4537
13712, 2532, 2538, 2539, 2533, 9049, 9073, 9077, 9053
13713, 9049, 9073, 9077, 9053, 9050, 9074, 9078, 9054
13714, 9050, 9074, 9078, 9054, 9051, 9075, 9079, 9055
13715, 9051, 9075, 9079, 9055, 9052, 9076, 9080, 9056
13716, 9052, 9076, 9080, 9056, 4537, 4543, 4544, 4538
13717, 2533, 2539, 2540, 2534, 9053, 9077, 9081, 9057
13718, 9053, 9077, 9081, 9057, 9054, 9078, 9082, 9058
13719, 9054, 9078, 9082, 9058, 9055, 9079, 9083, 9059
13720, 9055, 9079, 9083, 9059, 9056, 9080, 9084, 9060
13721, 9056, 9080, 9084, 9060, 4538, 4544, 4545, 4539
13722, 2534, 2540, 443, 442, 9057, 9081, 4490, 4486
13723, 9057, 9081, 4490, 4486, 9058, 9082, 4491, 4487
13724, 9058, 9082, 4491, 4487, 9059, 9083, 4492, 4488
13725, 9059, 9083, 4492, 4488, 9060, 9084, 4493, 4489
13726, 9060, 9084, 4493, 4489, 4539, 4545, 1022, 1021
13727, 372, 373, 2541, 2535, 4227, 4231, 9085, 9061
13728, 4227, 4231, 9085, 9061, 4228, 4232, 9086, 9062
13729, 4228, 4232, 9086, 9062, 4229, 4233, 9087, 9063
13730, 4229, 4233, 9087, 9063, 4230, 4234, 9088, 9064
13731, 4230, 4234, 9088, 9064, 969, 970, 4546, 4540
13732, 2535, 2541, 2542, 2536, 9061, 9085, 9089, 9065
13733, 9061, 9085, 9089, 9065, 9062, 9086, 9090, 9066
13734, 9062, 9086, 9090, 9066, 9063, 9087, 9091, 9067
13735, 9063, 9087, 9091, 9067, 9064, 9088, 9092, 9068
13736, 9064, 9088, 9092, 9068, 4540, 4546, 4547, 4541
13737, 2536, 2542, 2543, 2537, 9065, 9089, 9093, 9069
13738, 9065, 9089, 9093, 9069, 9066, 9090, 9094, 9070
13739, 9066, 9090, 9094, 9070, 9067, 9091, 9095, 9071
13740, 9067, 9091, 9095, 9071, 9068, 9092, 9096, 9072
13741, 9068, 9092, 9096, 9072, 4541, 4547, 4548, 4542
13742, 2537, 2543, 2544, 2538, 9069, 9093, 9097, 9073
13743, 9069, 9093, 9097, 9073, 9070, 9094, 9098, 9074
13744, 9070, 9094, 9098, 9074, 9071, 9095, 9099, 9075
13745, 9071, 9095, 9099, 9075, 9072, 9096, 9100, 9076
13746, 9072, 9096, 9100, 9076, 4542, 4548, 4549, 4543
13747, 2538, 2544, 2545, 2539, 9073, 9097, 9101, 9077
13748, 9073, 9097, 9101, 9077, 9074, 9098, 9102, 9078
13749, 9074, 9098, 9102, 9078, 9075, 9099, 9103, 9079
13750, 9075, 9099, 9103, 9079, 9076, 9100, 9104, 9080
13751, 9076, 9100, 9104, 9080, 4543, 4549, 4550, 4544
13752, 2539, 2545, 2546, 2540, 9077, 9101, 9105, 9081
13753, 9077, 9101, 9105, 9081, 9078, 9102, 9106, 9082
13754, 9078, 9102, 9106, 9082, 9079, 9103, 9107, 9083
13755, 9079, 9103, 9107, 9083, 9080, 9104, 9108, 9084
13756, 9080, 9104, 9108, 9084, 4544, 4550, 4551, 4545
13757, 2540, 2546, 444, 443, 9081, 9105, 4494, 4490
13758, 9081, 9105, 4494, 4490, 9082, 9106, 4495, 4491
13759, 9082, 9106, 4495, 4491, 9083, 9107, 4496, 4492
13760, 9083, 9107, 4496, 4492, 9084, 9108, 4497, 4493
13761, 9084, 9108, 4497, 4493, 4545, 4551, 1023, 1022
13762, 373, 23, 403, 2541, 4231, 958, 4414, 9085
13763, 4231, 958, 4414, 9085, 4232, 959, 4415, 9086
13764, 4232, 959, 4415, 9086, 4233, 960, 4416, 9087
13765, 4233, 960, 4416, 9087, 4234, 961, 4417, 9088
13766, 4234, 961, 4417, 9088, 970, 79, 999, 4546
13767, 2541, 403, 404, 2542, 9085, 4414, 4418, 9089
13768, 9085, 4414, 4418, 9089, 9086, 4415, 4419, 9090
13769, 9086, 4415, 4419, 9090, 9087, 4416, 4420, 9091
13770, 9087, 4416, 4420, 9091, 9088, 4417, 4421, 9092
13771, 9088, 4417, 4421, 9092, 4546, 999, 1000, 4547
13772, 2542, 404, 405, 2543, 9089, 4418, 4422, 9093
13773, 9089, 4418, 4422, 9093, 9090, 4419, 4423, 9094
13774, 9090, 4419, 4423, 9094, 9091, 4420, 4424, 9095
13775, 9091, 4420, 4424, 9095, 9092, 4421, 4425, 9096
13776, 9092, 4421, 4425, 9096, 4547, 1000, 1001, 4548
13777, 2543, 405, 406, 2544, 9093, 4422, 4426, 9097
13778, 9093, 4422, 4426, 9097, 9094, 4423, 4427, 9098
13779, 9094, 4423, 4427, 9098, 9095, 4424, 4428, 9099
13780, 9095, 4424, 4428, 9099, 9096, 4425, 4429, 9100
13781, 9096, 4425, 4429, 9100, 4548, 1001, 1002, 4549
13782, 2544, 406, 407, 2545, 9097, 4426, 4430, 9101
13783, 9097, 4426, 4430, 9101, 9098, 4427, 4431, 9102
13784, 9098, 4427, 4431, 9102, 9099, 4428, 4432, 9103
13785, 9099, 4428, 4432, 9103, 9100, 4429, 4433, 9104
13786, 9100, 4429, 4433, 9104, 4549, 1002, 1003, 4550
13787, 2545, 407, 408, 2546, 9101, 4430, 4434, 9105
13788, 9101, 4430, 4434, 9105, 9102, 4431, 4435, 9106
13789, 9102, 4431, 4435, 9106, 9103, 4432, 4436, 9107
13790, 9103, 4432, 4436, 9107, 9104, 4433, 4437, 9108
13791, 9104, 4433, 4437, 9108, 4550, 1003, 1004, 4551
13792, 2546, 408, 26, 444, 9105, 4434, 995, 4494
13793, 9105, 4434, 995, 4494, 9106, 4435, 996, 4495
13794, 9106, 4435, 996, 4495, 9107, 4436, 997, 4496
13795, 9107, 4436, 997, 4496, 9108, 4437, 998, 4497
13796, 9108, 4437, 998, 4497, 4551, 1004, 81, 1023
*ELEMENT, type=C3D8, ELSET=Volume22
13797, 28, 436, 2739, 481, 1005, 4462, 9109, 4596
13798, 1005, 4462, 9109, 4596, 1006, 4463, 9110, 4597
13799, 1006, 4463, 9110, 4597, 1007, 4464, 9111, 4598
13800, 1007, 4464, 9111, 4598, 1008, 4465, 9112, 4599
13801, 1008, 4465, 9112, 4599, 82, 1015, 4676, 1043
13802, 481, 2739, 2740, 482, 4596, 9109, 9113, 4600
13803, 4596, 9109, 9113, 4600, 4597, 9110, 9114, 4601
13804, 4597, 9110, 9114, 4601, 4598, 9111, 9115, 4602
13805, 4598, 9111, 9115, 4602, 4599, 9112, 9116, 4603
13806, 4599, 9112, 9116, 4603, 1043, 4676, 4677, 1044
13807, 482, 2740, 2741, 483, 4600, 9113, 9117, 4604
13808, 4600, 9113, 9117, 4604, 4601, 9114, 9118, 4605
13809, 4601, 9114, 9118, 4605, 4602, 9115, 9119, 4606
13810, 4602, 9115, 9119, 4606, 4603, 9116, 9120, 4607
13811, 4603, 9116, 9120, 4607, 1044, 4677, 4678, 1045
13812, 483, 2741, 2742, 484, 4604, 9117, 9121, 4608
13813, 4604, 9117, 9121, 4608, 4605, 9118, 9122, 4609
13814, 4605, 9118, 9122, 4609, 4606, 9119, 9123, 4610
13815, 4606, 9119, 9123, 4610, 4607, 9120, 9124, 4611
13816, 4607, 9120, 9124, 4611, 1045, 4678, 4679, 1046
13817, 484, 2742, 2743, 485, 4608, 9121, 9125, 4612
13818, 4608, 9121, 9125, 4612, 4609, 9122, 9126, 4613
13819, 4609, 9122, 9126, 4613, 4610, 9123, 9127, 4614
13820, 4610, 9123, 9127, 4614, 4611, 9124, 9128, 4615
13821, 4611, 9124, 9128, 4615, 1046, 4679, 4680, 1047
13822, 485, 2743, 2744, 486, 4612, 9125, 9129, 4616
13823, 4612, 9125, 9129, 4616, 4613, 9126, 9130, 4617
13824, 4613, 9126, 9130, 4617, 4614, 9127, 9131, 4618
13825, 4614, 9127, 9131, 4618, 4615, 9128, 9132, 4619
13826, 4615, 9128, 9132, 4619, 1047, 4680, 4681, 1048
13827, 486, 2744, 2745, 487, 4616, 9129, 9133, 4620
13828, 4616, 9129, 9133, 4620, 4617, 9130, 9134, 4621
13829, 4617, 9130, 9134, 4621, 4618, 9131, 9135, 4622
13830, 4618, 9131, 9135, 4622, 4619, 9132, 9136, 4623
13831, 4619, 9132, 9136, 4623, 1048, 4681, 4682, 1049
13832, 487, 2745, 2746, 488, 4620, 9133, 9137, 4624
13833, 4620, 9133, 9137, 4624, 4621, 9134, 9138, 4625
13834, 4621, 9134, 9138, 4625, 4622, 9135, 9139, 4626
13835, 4622, 9135, 9139, 4626, 4623, 9136, 9140, 4627
13836, 4623, 9136, 9140, 4627, 1049, 4682, 4683, 1050
13837, 488, 2746, 2747, 489, 4624, 9137, 9141, 4628
13838, 4624, 9137, 9141, 4628, 4625, 9138, 9142, 4629
13839, 4625, 9138, 9142, 4629, 4626, 9139, 9143, 4630
13840, 4626, 9139, 9143, 4630, 4627, 9140, 9144, 4631
13841, 4627, 9140, 9144, 4631, 1050, 4683, 4684, 1051
13842, 489, 2747, 2748, 490, 4628, 9141, 9145, 4632
13843, 4628, 9141, 9145, 4632, 4629, 9142, 9146, 4633
13844, 4629, 9142, 9146, 4633, 4630, 9143, 9147, 4634
13845, 4630, 9143, 9147, 4634, 4631, 9144, 9148, 4635
13846, 4631, 9144, 9148, 4635, 1051, 4684, 4685, 1052
13847, 490, 2748, 2749, 491, 4632, 9145, 9149, 4636
13848, 4632, 9145, 9149, 4636, 4633, 9146, 9150, 4637
13849, 4633, 9146, 9150, 4637, 4634, 9147, 9151, 4638
13850, 4634, 9147, 9151, 4638, 4635, 9148, 9152, 4639
13851, 4635, 9148, 9152, 4639, 1052, 4685, 4686, 1053
13852, 491, 2749, 504, 32, 4636, 9149, 4640, 1039
13853, 4636, 9149, 4640, 1039, 4637, 9150, 4641, 1040
13854, 4637, 9150, 4641, 1040, 4638, 9151, 4642, 1041
13855, 4638, 9151, 4642, 1041, 4639, 9152, 4643, 1042
13856, 4639, 9152, 4643, 1042, 1053, 4686, 1054, 84
13857, 436, 437, 2750, 2739, 4462, 4466, 9153, 9109
13858, 4462, 4466, 9153, 9109, 4463, 4467, 9154, 9110
13859, 4463, 4467, 9154, 9110, 4464, 4468, 9155, 9111
13860, 4464, 4468, 9155, 9111, 4465, 4469, 9156, 9112
13861, 4465, 4469, 9156, 9112, 1015, 1016, 4687, 4676
13862, 2739, 2750, 2751, 2740, 9109, 9153, 9157, 9113
13863, 9109, 9153, 9157, 9113, 9110, 9154, 9158, 9114
13864, 9110, 9154, 9158, 9114, 9111, 9155, 9159, 9115
13865, 9111, 9155, 9159, 9115, 9112, 9156, 9160, 9116
13866, 9112, 9156, 9160, 9116, 4676, 4687, 4688, 4677
13867, 2740, 2751, 2752, 2741, 9113, 9157, 9161, 9117
13868, 9113, 9157, 9161, 9117, 9114, 9158, 9162, 9118
13869, 9114, 9158, 9162, 9118, 9115, 9159, 9163, 9119
13870, 9115, 9159, 9163, 9119, 9116, 9160, 9164, 9120
13871, 9116, 9160, 9164, 9120, 4677, 4688, 4689, 4678
13872, 2741, 2752, 2753, 2742, 9117, 9161, 9165, 9121
13873, 9117, 9161, 9165, 9121, 9118, 9162, 9166, 9122
13874, 9118, 9162, 9166, 9122, 9119, 9163, 9167, 9123
13875, 9119, 9163, 9167, 9123, 9120, 9164, 9168, 9124
13876, 9120, 9164, 9168, 9124, 4678, 4689, 4690, 4679
13877, 2742, 2753, 2754, 2743, 9121, 9165, 9169, 9125
13878, 9121, 9165, 9169, 9125, 9122, 9166, 9170, 9126
13879, 9122, 9166, 9170, 9126, 9123, 9167, 9171, 9127
13880, 9123, 9167, 9171, 9127, 9124, 9168, 9172, 9128
13881, 9124, 9168, 9172, 9128, 4679, 4690, 4691, 4680
13882, 2743, 2754, 2755, 2744, 9125, 9169, 9173, 9129
13883, 9125, 9169, 9173, 9129, 9126, 9170, 9174, 9130
13884, 9126, 9170, 9174, 9130, 9127, 9171, 9175, 9131
13885, 9127, 9171, 9175, 9131, 9128, 9172, 9176, 9132
13886, 9128, 9172, 9176, 9132, 4680, 4691, 4692, 4681
13887, 2744, 2755, 2756, 2745, 9129, 9173, 9177, 9133
13888, 9129, 9173, 9177, 9133, 9130, 9174, 9178, 9134
13889, 9130, 9174, 9178, 9134, 9131, 9175, 9179, 9135
13890, 9131, 9175, 9179, 9135, 9132, 9176, 9180, 9136
13891, 9132, 9176, 9180, 9136, 4681, 4692, 4693, 4682
13892, 2745, 2756, 2757, 2746, 9133, 9177, 9181, 9137
13893, 9133, 9177, 9181, 9137, 9134, 9178, 9182, 9138
13894, 9134, 9178, 9182, 9138, 9135, 9179, 9183, 9139
13895, 9135, 9179, 9183, 9139, 9136, 9180, 9184, 9140
13896, 9136, 9180, 9184, 9140, 4682, 4693, 4694, 4683
13897, 2746, 2757, 2758, 2747, 9137, 9181, 9185, 9141
13898, 9137, 9181, 9185, 9141, 9138, 9182, 9186, 9142
13899, 9138, 9182, 9186, 9142, 9139, 9183, 9187, 9143
13900, 9139, 9183, 9187, 9143, 9140, 9184, 9188, 9144
13901, 9140, 9184, 9188, 9144, 4683, 4694, 4695, 4684
13902, 2747, 2758, 2759, 2748, 9141, 9185, 9189, 9145
13903, 9141, 9185, 9189, 9145, 9142, 9186, 9190, 9146
13904, 9142, 9186, 9190, 9146, 9143, 9187, 9191, 9147
13905, 9143, 9187, 9191, 9147, 9144, 9188, 9192, 9148
13906, 9144, 9188, 9192, 9148, 4684, 4695, 4696, 4685
13907, 2748, 2759, 2760, 2749, 9145, 9189, 9193, 9149
13908, 9145, 9189, 9193, 9149, 9146, 9190, 9194, 9150
13909, 9146, 9190, 9194, 9150, 9147, 9191, 9195, 9151
13910, 9147, 9191, 9195, 9151, 9148, 9192, 9196, 9152
13911, 9148, 9192, 9196, 9152, 4685, 4696, 4697, 4686
13912, 2749, 2760, 505, 504, 9149, 9193, 4644, 4640
13913, 9149, 9193, 4644, 4640, 9150, 9194, 4645, 4641
13914, 9150, 9194, 4645, 4641, 9151, 9195, 4646, 4642
13915, 9151, 9195, 4646, 4642, 9152, 9196, 4647, 4643
13916, 9152, 9196, 4647, 4643, 4686, 4697, 1055, 1054
13917, 437, 438, 2761, 2750, 4466, 4470, 9197, 9153
13918, 4466, 4470, 9197, 9153, 4467, 4471, 9198, 9154
13919, 4467, 4471, 9198, 9154, 4468, 4472, 9199, 9155
13920, 4468, 4472, 9199, 9155, 4469, 4473, 9200, 9156
13921, 4469, 4473, 9200, 9156, 1016, 1017, 4698, 4687
13922, 2750, 2761, 2762, 2751, 9153, 9197, 9201, 9157
13923, 9153, 9197, 9201, 9157, 9154, 9198, 9202, 9158
13924, 9154, 9198, 9202, 9158, 9155, 9199, 9203, 9159
13925, 9155, 9199, 9203, 9159, 9156, 9200, 9204, 9160
13926, 9156, 9200, 9204, 9160, 4687, 4698, 4699, 4688
13927, 2751, 2762, 2763, 2752, 9157, 9201, 9205, 9161
13928, 9157, 9201, 9205, 9161, 9158, 9202, 9206, 9162
13929, 9158, 9202, 9206, 9162, 9159, 9203, 9207, 9163
13930, 9159, 9203, 9207, 9163, 9160, 9204, 9208, 9164
13931, 9160, 9204, 9208, 9164, 4688, 4699, 4700, 4689
13932, 2752, 2763, 2764, 2753, 9161, 9205, 9209, 9165
13933, 9161, 9205, 9209, 9165, 9162, 9206, 9210, 9166
13934, 9162, 9206, 9210, 9166, 9163, 9207, 9211, 9167
13935, 9163, 9207, 9211, 9167, 9164, 9208, 9212, 9168
13936, 9164, 9208, 9212, 9168, 4689, 4700, 4701, 4690
13937, 2753, 2764, 2765, 2754, 9165, 9209, 9213, 9169
13938, 9165, 9209, 9213, 9169, 9166, 9210, 9214, 9170
13939, 9166, 9210, 9214, 9170, 9167, 9211, 9215, 9171
13940, 9167, 9211, 9215, 9171, 9168, 9212, 9216, 9172
13941, 9168, 9212, 9216, 9172, 4690, 4701, 4702, 4691
13942, 2754, 2765, 2766, 2755, 9169, 9213, 9217, 9173
13943, 9169, 9213, 9217, 9173, 9170, 9214, 9218, 9174
13944, 9170, 9214, 9218, 9174, 9171, 9215, 9219, 9175
13945, 9171, 9215, 9219, 9175, 9172, 9216, 9220, 9176
13946, 9172, 9216, 9220, 9176, 4691, 4702, 4703, 4692
13947, 2755, 2766, 2767, 2756, 9173, 9217, 9221, 9177
13948, 9173, 9217, 9221, 9177, 9174, 9218, 9222, 9178
13949, 9174, 9218, 9222, 9178, 9175, 9219, 9223, 9179
13950, 9175, 9219, 9223, 9179, 9176, 9220, 9224, 9180
13951, 9176, 9220, 9224, 9180, 4692, 4703, 4704, 4693
13952, 2756, 2767, 2768, 2757, 9177, 9221, 9225, 9181
13953, 9177, 9221, 9225, 9181, 9178, 9222, 9226, 9182
13954, 9178, 9222, 9226, 9182, 9179, 9223, 9227, 9183
13955, 9179, 9223, 9227, 9183, 9180, 9224, 9228, 9184
13956, 9180, 9224, 9228, 9184, 4693, 4704, 4705, 4694
13957, 2757, 2768, 2769, 2758, 9181, 9225, 9229, 9185
13958, 9181, 9225, 9229, 9185, 9182, 9226, 9230, 9186
13959, 9182, 9226, 9230, 9186, 9183, 9227, 9231, 9187
13960, 9183, 9227, 9231, 9187, 9184, 9228, 9232, 9188
13961, 9184, 9228, 9232, 9188, 4694, 4705, 4706, 4695
13962, 2758, 2769, 2770, 2759, 9185, 9229, 9233, 9189
13963, 9185, 9229, 9233, 9189, 9186, 9230, 9234, 9190
13964, 9186, 9230, 9234, 9190, 9187, 9231, 9235, 9191
13965, 9187, 9231, 9235, 9191, 9188, 9232, 9236, 9192
13966, 9188, 9232, 9236, 9192, 4695, 4706, 4707, 4696
13967, 2759, 2770, 2771, 2760, 9189, 9233, 9237, 9193
13968, 9189, 9233, 9237, 9193, 9190, 9234, 9238, 9194
13969, 9190, 9234, 9238, 9194, 9191, 9235, 9239, 9195
13970, 9191, 9235, 9239, 9195, 9192, 9236, 9240, 9196
13971, 9192, 9236, 9240, 9196, 4696, 4707, 4708, 4697
13972, 2760, 2771, 506, 505, 9193, 9237, 4648, 4644
13973, 9193, 9237, 4648, 4644, 9194, 9238, 4649, 4645
13974, 9194, 9238, 4649, 4645, 9195, 9239, 4650, 4646
13975, 9195, 9239, 4650, 4646, 9196, 9240, 4651, 4647
13976, 9196, 9240, 4651, 4647, 4697, 4708, 1056, 1055
13977, 438, 439, 2772, 2761, 4470, 4474, 9241, 9197
13978, 4470, 4474, 9241, 9197, 4471, 4475, 9242, 9198
13979, 4471, 4475, 9242, 9198, 4472, 4476, 9243, 9199
13980, 4472, 4476, 9243, 9199, 4473, 4477, 9244, 9200
13981, 4473, 4477, 9244, 9200, 1017, 1018, 4709, 4698
13982, 2761, 2772, 2773, 2762, 9197, 9241, 9245, 9201
13983, 9197, 9241, 9245, 9201, 9198, 9242, 9246, 9202
13984, 9198, 9242, 9246, 9202, 9199, 9243, 9247, 9203
13985, 9199, 9243, 9247, 9203, 9200, 9244, 9248, 9204
13986, 9200, 9244, 9248, 9204, 4698, 4709, 4710, 4699
13987, 2762, 2773, 2774, 2763, 9201, 9245, 9249, 9205
13988, 9201, 9245, 9249, 9205, 9202, 9246, 9250, 9206
13989, 9202, 9246, 9250, 9206, 9203, 9247, 9251, 9207
13990, 9203, 9247, 9251, 9207, 9204, 9248, 9252, 9208
13991, 9204, 9248, 9252, 9208, 4699, 4710, 4711, 4700
13992, 2763, 2774, 2775, 2764, 9205, 9249, 9253, 9209
13993, 9205, 9249, 9253, 9209, 9206, 9250, 9254, 9210
13994, 9206, 9250, 9254, 9210, 9207, 9251, 9255, 9211
13995, 9207, 9251, 9255, 9211, 9208, 9252, 9256, 9212
13996, 9208, 9252, 9256, 9212, 4700, 4711, 4712, 4701
13997, 2764, 2775, 2776, 2765, 9209, 9253, 9257, 9213
13998, 9209, 9253, 9257, 9213, 9210, 9254, 9258, 9214
13999, 9210, 9254, 9258, 9214, 9211, 9255, 9259, 9215
14000, 9211, 9255, 9259, 9215, 9212, 9256, 9260, 9216
14001, 9212, 9256, 9260, 9216, 4701, 4712, 4713, 4702
14002, 2765, 2776, 2777, 2766, 9213, 9257, 9261, 9217
14003, 9213, 9257, 9261, 9217, 9214, 9258, 9262, 9218
14004, 9214, 9258, 9262, 9218, 9215, 9259, 9263, 9219
14005, 9215, 9259, 9263, 9219, 9216, 9260, 9264, 9220
14006, 9216, 9260, 9264, 9220, 4702, 4713, 4714, 4703
14007, 2766, 2777, 2778, 2767, 9217, 9261, 9265, 9221
14008, 9217, 9261, 9265, 9221, 9218, 9262, 9266, 9222
14009, 9218, 9262, 9266, 9222, 9219, 9263, 9267, 9223
14010, 9219, 9263, 9267, 9223, 9220, 9264, 9268, 9224
14011, 9220, 9264, 9268, 9224, 4703, 4714, 4715, 4704
14012, 2767, 2778, 2779, 2768, 9221, 9265, 9269, 9225
14013, 9221, 9265, 9269, 9225, 9222, 9266, 9270, 9226
14014, 9222, 9266, 9270, 9226, 9223, 9267, 9271, 9227
14015, 9223, 9267, 9271, 9227, 9224, 9268, 9272, 9228
14016, 9224, 9268, 9272, 9228, 4704, 4715, 4716, 4705
14017, 2768, 2779, 2780, 2769, 9225, 9269, 9273, 9229
14018, 9225, 9269, 9273, 9229, 9226, 9270, 9274, 9230
14019, 9226, 9270, 9274, 9230, 9227, 9271, 9275, 9231
14020, 9227, 9271, 9275, 9231, 9228, 9272, 9276, 9232
14021, 9228, 9272, 9276, 9232, 4705, 4716, 4717, 4706
14022, 2769, 2780, 2781, 2770, 9229, 9273, 9277, 9233
14023, 9229, 9273, 9277, 9233, 9230, 9274, 9278, 9234
14024, 9230, 9274, 9278, 9234, 9231, 9275, 9279, 9235
14025, 9231, 9275, 9279, 9235, 9232, 9276, 9280, 9236
14026, 9232, 9276, 9280, 9236, 4706, 4717, 4718, 4707
14027, 2770, 2781, 2782, 2771, 9233, 9277, 9281, 9237
14028, 9233, 9277, 9281, 9237, 9234, 9278, 9282, 9238
14029, 9234, 9278, 9282, 9238, 9235, 9279, 9283, 9239
14030, 9235, 9279, 9283, 9239, 9236, 9280, 9284, 9240
14031, 9236, 9280, 9284, 9240, 4707, 4718, 4719, 4708
14032, 2771, 2782, 507, 506, 9237, 9281, 4652, 4648
14033, 9237, 9281, 4652, 4648, 9238, 9282, 4653, 4649
14034, 9238, 9282, 4653, 4649, 9239, 9283, 4654, 4650
14035, 9239, 9283, 4654, 4650, 9240, 9284, 4655, 4651
14036, 9240, 9284, 4655, 4651, 4708, 4719, 1057, 1056
14037, 439, 440, 2783, 2772, 4474, 4478, 9285, 9241
14038, 4474, 4478, 9285, 9241, 4475, 4479, 9286, 9242
14039, 4475, 4479, 9286, 9242, 4476, 4480, 9287, 9243
14040, 4476, 4480, 9287, 9243, 4477, 4481, 9288, 9244
14041, 4477, 4481, 9288, 9244, 1018, 1019, 4720, 4709
14042, 2772, 2783, 2784, 2773, 9241, 9285, 9289, 9245
14043, 9241, 9285, 9289, 9245, 9242, 9286, 9290, 9246
14044, 9242, 9286, 9290, 9246, 9243, 9287, 9291, 9247
14045, 9243, 9287, 9291, 9247, 9244, 9288, 9292, 9248
14046, 9244, 9288, 9292, 9248, 4709, 4720, 4721, 4710
14047, 2773, 2784, 2785, 2774, 9245, 9289, 9293, 9249
14048, 9245, 9289, 9293, 9249, 9246, 9290, 9294, 9250
14049, 9246, 9290, 9294, 9250, 9247, 9291, 9295, 9251
14050, 9247, 9291, 9295, 9251, 9248, 9292, 9296, 9252
14051, 9248, 9292, 9296, 9252, 4710, 4721, 4722, 4711
14052, 2774, 2785, 2786, 2775, 9249, 9293, 9297, 9253
14053, 9249, 9293, 9297, 9253, 9250, 9294, 9298, 9254
14054, 9250, 9294, 9298, 9254, 9251, 9295, 9299, 9255
14055, 9251, 9295, 9299, 9255, 9252, 9296, 9300, 9256
14056, 9252, 9296, 9300, 9256, 4711, 4722, 4723, 4712
14057, 2775, 2786, 2787, 2776, 9253, 9297, 9301, 9257
14058, 9253, 9297, 9301, 9257, 9254, 9298, 9302, 9258
14059, 9254, 9298, 9302, 9258, 9255, 9299, 9303, 9259
14060, 9255, 9299, 9303, 9259, 9256, 9300, 9304, 9260
14061, 9256, 9300, 9304, 9260, 4712, 4723, 4724, 4713
14062, 2776, 2787, 2788, 2777, 9257, 9301, 9305, 9261
14063, 9257, 9301, 9305, 9261, 9258, 9302, 9306, 9262
14064, 9258, 9302, 9306, 9262, 9259, 9303, 9307, 9263
14065, 9259, 9303, 9307, 9263, 9260, 9304, 9308, 9264
14066, 9260, 9304, 9308, 9264, 4713, 4724, 4725, 4714
14067, 2777, 2788, 2789, 2778, 9261, 9305, 9309, 9265
14068, 9261, 9305, 9309, 9265, 9262, 9306, 9310, 9266
14069, 9262, 9306, 9310, 9266, 9263, 9307, 9311, 9267
14070, 9263, 9307, 9311, 9267, 9264, 9308, 9312, 9268
14071, 9264, 9308, 9312, 9268, 4714, 4725, 4726, 4715
14072, 2778, 2789, 2790, 2779, 9265, 9309, 9313, 9269
14073, 9265, 9309, 9313, 9269, 9266, 9310, 9314, 9270
14074, 9266, 9310, 9314, 9270, 9267, 9311, 9315, 9271
14075, 9267, 9311, 9315, 9271, 9268, 9312, 9316, 9272
14076, 9268, 9312, 9316, 9272, 4715, 4726, 4727, 4716
14077, 2779, 2790, 2791, 2780, 9269, 9313, 9317, 9273
14078, 9269, 9313, 9317, 9273, 9270, 9314, 9318, 9274
14079, 9270, 9314, 9318, 9274, 9271, 9315, 9319, 9275
14080, 9271, 9315, 9319, 9275, 9272, 9316, 9320, 9276
14081, 9272, 9316, 9320, 9276, 4716, 4727, 4728, 4717
14082, 2780, 2791, 2792, 2781, 9273, 9317, 9321, 9277
14083, 9273, 9317, 9321, 9277, 9274, 9318, 9322, 9278
14084, 9274, 9318, 9322, 9278, 9275, 9319, 9323, 9279
14085, 9275, 9319, 9323, 9279, 9276, 9320, 9324, 9280
14086, 9276, 9320, 9324, 9280, 4717, 4728, 4729, 4718
14087, 2781, 2792, 2793, 2782, 9277, 9321, 9325, 9281
14088, 9277, 9321, 9325, 9281, 9278, 9322, 9326, 9282
14089, 9278, 9322, 9326, 9282, 9279, 9323, 9327, 9283
14090, 9279, 9323, 9327, 9283, 9280, 9324, 9328, 9284
14091, 9280, 9324, 9328, 9284, 4718, 4729, 4730, 4719
14092, 2782, 2793, 508, 507, 9281, 9325, 4656, 4652
14093, 9281, 9325, 4656, 4652, 9282, 9326, 4657, 4653
14094, 9282, 9326, 4657, 4653, 9283, 9327, 4658, 4654
14095, 9283, 9327, 4658, 4654, 9284, 9328, 4659, 4655
14096, 9284, 9328, 4659, 4655, 4719, 4730, 1058, 1057
14097, 440, 441, 2794, 2783, 4478, 4482, 9329, 9285
14098, 4478, 4482, 9329, 9285, 4479, 4483, 9330, 9286
14099, 4479, 4483, 9330, 9286, 4480, 4484, 9331, 9287
14100, 4480, 4484, 9331, 9287, 4481, 4485, 9332, 9288
14101, 4481, 4485, 9332, 9288, 1019, 1020, 4731, 4720
14102, 2783, 2794, 2795, 2784, 9285, 9329, 9333, 9289
14103, 9285, 9329, 9333, 9289, 9286, 9330, 9334, 9290
14104, 9286, 9330, 9334, 9290, 9287, 9331, 9335, 9291
14105, 9287, 9331, 9335, 9291, 9288, 9332, 9336, 9292
14106, 9288, 9332, 9336, 9292, 4720, 4731, 4732, 4721
14107, 2784, 2795, 2796, 2785, 9289, 9333, 9337, 9293
14108, 9289, 9333, 9337, 9293, 9290, 9334, 9338, 9294
14109, 9290, 9334, 9338, 9294, 9291, 9335, 9339, 9295
14110, 9291, 9335, 9339, 9295, 9292, 9336, 9340, 9296
14111, 9292, 9336, 9340, 9296, 4721, 4732, 4733, 4722
14112, 2785, 2796, 2797, 2786, 9293, 9337, 9341, 9297
14113, 9293, 9337, 9341, 9297, 9294, 9338, 9342, 9298
14114, 9294, 9338, 9342, 9298, 9295, 9339, 9343, 9299
14115, 9295, 9339, 9343, 9299, 9296, 9340, 9344, 9300
14116, 9296, 9340, 9344, 9300, 4722, 4733, 4734, 4723
14117, 2786, 2797, 2798, 2787, 9297, 9341, 9345, 9301
14118, 9297, 9341, 9345, 9301, 9298, 9342, 9346, 9302
14119, 9298, 9342, 9346, 9302, 9299, 9343, 9347, 9303
14120, 9299, 9343, 9347, 9303, 9300, 9344, 9348, 9304
14121, 9300, 9344, 9348, 9304, 4723, 4734, 4735, 4724
14122, 2787, 2798, 2799, 2788, 9301, 9345, 9349, 9305
14123, 9301, 9345, 9349, 9305, 9302, 9346, 9350, 9306
14124, 9302, 9346, 9350, 9306, 9303, 9347, 9351, 9307
14125, 9303, 9347, 9351, 9307, 9304, 9348, 9352, 9308
14126, 9304, 9348, 9352, 9308, 4724, 4735, 4736, 4725
14127, 2788, 2799, 2800, 2789, 9305, 9349, 9353, 9309
14128, 9305, 9349, 9353, 9309, 9306, 9350, 9354, 9310
14129, 9306, 9350, 9354, 9310, 9307, 9351, 9355, 9311
14130, 9307, 9351, 9355, 9311, 9308, 9352, 9356, 9312
14131, 9308, 9352, 9356, 9312, 4725, 4736, 4737, 4726
14132, 2789, 2800, 2801, 2790, 9309, 9353, 9357, 9313
14133, 9309, 9353, 9357, 9313, 9310, 9354, 9358, 9314
14134, 9310, 9354, 9358, 9314, 9311, 9355, 9359, 9315
14135, 9311, 9355, 9359, 9315, 9312, 9356, 9360, 9316
14136, 9312, 9356, 9360, 9316, 4726, 4737, 4738, 4727
14137, 2790, 2801, 2802, 2791, 9313, 9357, 9361, 9317
14138, 9313, 9357, 9361, 9317, 9314, 9358, 9362, 9318
14139, 9314, 9358, 9362, 9318, 9315, 9359, 9363, 9319
14140, 9315, 9359, 9363, 9319, 9316, 9360, 9364, 9320
14141, 9316, 9360, 9364, 9320, 4727, 4738, 4739, 4728
14142, 2791, 2802, 2803, 2792, 9317, 9361, 9365, 9321
14143, 9317, 9361, 9365, 9321, 9318, 9362, 9366, 9322
14144, 9318, 9362, 9366, 9322, 9319, 9363, 9367, 9323
14145, 9319, 9363, 9367, 9323, 9320, 9364, 9368, 9324
14146, 9320, 9364, 9368, 9324, 4728, 4739, 4740, 4729
14147, 2792, 2803, 2804, 2793, 9321, 9365, 9369, 9325
14148, 9321, 9365, 9369, 9325, 9322, 9366, 9370, 9326
14149, 9322, 9366, 9370, 9326, 9323, 9367, 9371, 9327
14150, 9323, 9367, 9371, 9327, 9324, 9368, 9372, 9328
14151, 9324, 9368, 9372, 9328, 4729, 4740, 4741, 4730
14152, 2793, 2804, 509, 508, 9325, 9369, 4660, 4656
14153, 9325, 9369, 4660, 4656, 9326, 9370, 4661, 4657
14154, 9326, 9370, 4661, 4657, 9327, 9371, 4662, 4658
14155, 9327, 9371, 4662, 4658, 9328, 9372, 4663, 4659
14156, 9328, 9372, 4663, 4659, 4730, 4741, 1059, 1058
14157, 441, 442, 2805, 2794, 4482, 4486, 9373, 9329
14158, 4482, 4486, 9373, 9329, 4483, 4487, 9374, 9330
14159, 4483, 4487, 9374, 9330, 4484, 4488, 9375, 9331
14160, 4484, 4488, 9375, 9331, 4485, 4489, 9376, 9332
14161, 4485, 4489, 9376, 9332, 1020, 1021, 4742, 4731
14162, 2794, 2805, 2806, 2795, 9329, 9373, 9377, 9333
14163, 9329, 9373, 9377, 9333, 9330, 9374, 9378, 9334
14164, 9330, 9374, 9378, 9334, 9331, 9375, 9379, 9335
14165, 9331, 9375, 9379, 9335, 9332, 9376, 9380, 9336
14166, 9332, 9376, 9380, 9336, 4731, 4742, 4743, 4732
14167, 2795, 2806, 2807, 2796, 9333, 9377, 9381, 9337
14168, 9333, 9377, 9381, 9337, 9334, 9378, 9382, 9338
14169, 9334, 9378, 9382, 9338, 9335, 9379, 9383, 9339
14170, 9335, 9379, 9383, 9339, 9336, 9380, 9384, 9340
14171, 9336, 9380, 9384, 9340, 4732, 4743, 4744, 4733
14172, 2796, 2807, 2808, 2797, 9337, 9381, 9385, 9341
14173, 9337, 9381, 9385, 9341, 9338, 9382, 9386, 9342
14174, 9338, 9382, 9386, 9342, 9339, 9383, 9387, 9343
14175, 9339, 9383, 9387, 9343, 9340, 9384, 9388, 9344
14176, 9340, 9384, 9388, 9344, 4733, 4744, 4745, 4734
14177, 2797, 2808, 2809, 2798, 9341, 9385, 9389, 9345
14178, 9341, 9385, 9389, 9345, 9342, 9386, 9390, 9346
14179, 9342, 9386, 9390, 9346, 9343, 9387, 9391, 9347
14180, 9343, 9387, 9391, 9347, 9344, 9388, 9392, 9348
14181, 9344, 9388, 9392, 9348, 4734, 4745, 4746, 4735
14182, 2798, 2809, 2810, 2799, 9345, 9389, 9393, 9349
14183, 9345, 9389, 9393, 9349, 9346, 9390, 9394, 9350
14184, 9346, 9390, 9394, 9350, 9347, 9391, 9395, 9351
14185, 9347, 9391, 9395, 9351, 9348, 9392, 9396, 9352
14186, 9348, 9392, 9396, 9352, 4735, 4746, 4747, 4736
14187, 2799, 2810, 2811, 2800, 9349, 9393, 9397, 9353
14188, 9349, 9393, 9397, 9353, 9350, 9394, 9398, 9354
14189, 9350, 9394, 9398, 9354, 9351, 9395, 9399, 9355
14190, 9351, 9395, 9399, 9355, 9352, 9396, 9400, 9356
14191, 9352, 9396, 9400, 9356, 4736, 4747, 4748, 4737
14192, 2800, 2811, 2812, 2801, 9353, 9397, 9401, 9357
14193, 9353, 9397, 9401, 9357, 9354, 9398, 9402, 9358
14194, 9354, 9398, 9402, 9358, 9355, 9399, 9403, 9359
14195, 9355, 9399, 9403, 9359, 9356, 9400, 9404, 9360
14196, 9356, 9400, 9404, 9360, 4737, 4748, 4749, 4738
14197, 2801, 2812, 2813, 2802, 9357, 9401, 9405, 9361
14198, 9357, 9401, 9405, 9361, 9358, 9402, 9406, 9362
14199, 9358, 9402, 9406, 9362, 9359, 9403, 9407, 9363
14200, 9359, 9403, 9407, 9363, 9360, 9404, 9408, 9364
14201, 9360, 9404, 9408, 9364, 4738, 4749, 4750, 4739
14202, 2802, 2813, 2814, 2803, 9361, 9405, 9409, 9365
14203, 9361, 9405, 9409, 9365, 9362, 9406, 9410, 9366
14204, 9362, 9406, 9410, 9366, 9363, 9407, 9411, 9367
14205, 9363, 9407, 9411, 9367, 9364, 9408, 9412, 9368
14206, 9364, 9408, 9412, 9368, 4739, 4750, 4751, 4740
14207, 2803, 2814, 2815, 2804, 9365, 9409, 9413, 9369
14208, 9365, 9409, 9413, 9369, 9366, 9410, 9414, 9370
14209, 9366, 9410, 9414, 9370, 9367, 9411, 9415, 9371
14210, 9367, 9411, 9415, 9371, 9368, 9412, 9416, 9372
14211, 9368, 9412, 9416, 9372, 4740, 4751, 4752, 4741
14212, 2804, 2815, 510, 509, 9369, 9413, 4664, 4660
14213, 9369, 9413, 4664, 4660, 9370, 9414, 4665, 4661
14214, 9370, 9414, 4665, 4661, 9371, 9415, 4666, 4662
14215, 9371, 9415, 4666, 4662, 9372, 9416, 4667, 4663
14216, 9372, 9416, 4667, 4663, 4741, 4752, 1060, 1059
14217, 442, 443, 2816, 2805, 4486, 4490, 9417, 9373
14218, 4486, 4490, 9417, 9373, 4487, 4491, 9418, 9374
14219, 4487, 4491, 9418, 9374, 4488, 4492, 9419, 9375
14220, 4488, 4492, 9419, 9375, 4489, 4493, 9420, 9376
14221, 4489, 4493, 9420, 9376, 1021, 1022, 4753, 4742
14222, 2805, 2816, 2817, 2806, 9373, 9417, 9421, 9377
14223, 9373, 9417, 9421, 9377, 9374, 9418, 9422, 9378
14224, 9374, 9418, 9422, 9378, 9375, 9419, 9423, 9379
14225, 9375, 9419, 9423, 9379, 9376, 9420, 9424, 9380
14226, 9376, 9420, 9424, 9380, 4742, 4753, 4754, 4743
14227, 2806, 2817, 2818, 2807, 9377, 9421, 9425, 9381
14228, 9377, 9421, 9425, 9381, 9378, 9422, 9426, 9382
14229, 9378, 9422, 9426, 9382, 9379, 9423, 9427, 9383
14230, 9379, 9423, 9427, 9383, 9380, 9424, 9428, 9384
14231, 9380, 9424, 9428, 9384, 4743, 4754, 4755, 4744
14232, 2807, 2818, 2819, 2808, 9381, 9425, 9429, 9385
14233, 9381, 9425, 9429, 9385, 9382, 9426, 9430, 9386
14234, 9382, 9426, 9430, 9386, 9383, 9427, 9431, 9387
14235, 9383, 9427, 9431, 9387, 9384, 9428, 9432, 9388
14236, 9384, 9428, 9432, 9388, 4744, 4755, 4756, 4745
14237, 2808, 2819, 2820, 2809, 9385, 9429, 9433, 9389
14238, 9385, 9429, 9433, 9389, 9386, 9430, 9434, 9390
14239, 9386, 9430, 9434, 9390, 9387, 9431, 9435, 9391
14240, 9387, 9431, 9435, 9391, 9388, 9432, 9436, 9392
14241, 9388, 9432, 9436, 9392, 4745, 4756, 4757, 4746
14242, 2809, 2820, 2821, 2810, 9389, 9433, 9437, 9393
14243, 9389, 9433, 9437, 9393, 9390, 9434, 9438, 9394
14244, 9390, 9434, 9438, 9394, 9391, 9435, 9439, 9395
14245, 9391, 9435, 9439, 9395, 9392, 9436, 9440, 9396
14246, 9392, 9436, 9440, 9396, 4746, 4757, 4758, 4747
14247, 2810, 2821, 2822, 2811, 9393, 9437, 9441, 9397
14248, 9393, 9437, 9441, 9397, 9394, 9438, 9442, 9398
14249, 9394, 9438, 9442, 9398, 9395, 9439, 9443, 9399
14250, 9395, 9439, 9443, 9399, 9396, 9440, 9444, 9400
14251, 9396, 9440, 9444, 9400, 4747, 4758, 4759, 4748
14252, 2811, 2822, 2823, 2812, 9397, 9441, 9445, 9401
14253, 9397, 9441, 9445, 9401, 9398, 9442, 9446, 9402
14254, 9398, 9442, 9446, 9402, 9399, 9443, 9447, 9403
14255, 9399, 9443, 9447, 9403, 9400, 9444, 9448, 9404
14256, 9400, 9444, 9448, 9404, 4748, 4759, 4760, 4749
14257, 2812, 2823, 2824, 2813, 9401, 9445, 9449, 9405
14258, 9401, 9445, 9449, 9405, 9402, 9446, 9450, 9406
14259, 9402, 9446, 9450, 9406, 9403, 9447, 9451, 9407
14260, 9403, 9447, 9451, 9407, 9404, 9448, 9452, 9408
14261, 9404, 9448, 9452, 9408, 4749, 4760, 4761, 4750
14262, 2813, 2824, 2825, 2814, 9405, 9449, 9453, 9409
14263, 9405, 9449, 9453, 9409, 9406, 9450, 9454, 9410
14264, 9406, 9450, 9454, 9410, 9407, 9451, 9455, 9411
14265, 9407, 9451, 9455, 9411, 9408, 9452, 9456, 9412
14266, 9408, 9452, 9456, 9412, 4750, 4761, 4762, 4751
14267, 2814, 2825, 2826, 2815, 9409, 9453, 9457, 9413
14268, 9409, 9453, 9457, 9413, 9410, 9454, 9458, 9414
14269, 9410, 9454, 9458, 9414, 9411, 9455, 9459, 9415
14270, 9411, 9455, 9459, 9415, 9412, 9456, 9460, 9416
14271, 9412, 9456, 9460, 9416, 4751, 4762, 4763, 4752
14272, 2815, 2826, 511, 510, 9413, 9457, 4668, 4664
14273, 9413, 9457, 4668, 4664, 9414, 9458, 4669, 4665
14274, 9414, 9458, 4669, 4665, 9415, 9459, 4670, 4666
14275, 9415, 9459, 4670, 4666, 9416, 9460, 4671, 4667
14276, 9416, 9460, 4671, 4667, 4752, 4763, 1061, 1060
14277, 443, 444, 2827, 2816, 4490, 4494, 9461, 9417
14278, 4490, 4494, 9461, 9417, 4491, 4495, 9462, 9418
14279, 4491, 4495, 9462, 9418, 4492, 4496, 9463, 9419
14280, 4492, 4496, 9463, 9419, 4493, 4497, 9464, 9420
14281, 4493, 4497, 9464, 9420, 1022, 1023, 4764, 4753
14282, 2816, 2827, 2828, 2817, 9417, 9461, 9465, 9421
14283, 9417, 9461, 9465, 9421, 9418, 9462, 9466, 9422
14284, 9418, 9462, 9466, 9422, 9419, 9463, 9467, 9423
14285, 9419, 9463, 9467, 9423, 9420, 9464, 9468, 9424
14286, 9420, 9464, 9468, 9424, 4753, 4764, 4765, 4754
14287, 2817, 2828, 2829, 2818, 9421, 9465, 9469, 9425
14288, 9421, 9465, 9469, 9425, 9422, 9466, 9470, 9426
14289, 9422, 9466, 9470, 9426, 9423, 9467, 9471, 9427
14290, 9423, 9467, 9471, 9427, 9424, 9468, 9472, 9428
14291, 9424, 9468, 9472, 9428, 4754, 4765, 4766, 4755
14292, 2818, 2829, 2830, 2819, 9425, 9469, 9473, 9429
14293, 9425, 9469, 9473, 9429, 9426, 9470, 9474, 9430
14294, 9426, 9470, 9474, 9430, 9427, 9471, 9475, 9431
14295, 9427, 9471, 9475, 9431, 9428, 9472, 9476, 9432
14296, 9428, 9472, 9476, 9432, 4755, 4766, 4767, 4756
14297, 2819, 2830, 2831, 2820, 9429, 9473, 9477, 9433
14298, 9429, 9473, 9477, 9433, 9430, 9474, 9478, 9434
14299, 9430, 9474, 9478, 9434, 9431, 9475, 9479, 9435
14300, 9431, 9475, 9479, 9435, 9432, 9476, 9480, 9436
14301, 9432, 9476, 9480, 9436, 4756, 4767, 4768, 4757
14302, 2820, 2831, 2832, 2821, 9433, 9477, 9481, 9437
14303, 9433, 9477, 9481, 9437, 9434, 9478, 9482, 9438
14304, 9434, 9478, 9482, 9438, 9435, 9479, 9483, 9439
14305, 9435, 9479, 9483, 9439, 9436, 9480, 9484, 9440
14306, 9436, 9480, 9484, 9440, 4757, 4768, 4769, 4758
14307, 2821, 2832, 2833, 2822, 9437, 9481, 9485, 9441
14308, 9437, 9481, 9485, 9441, 9438, 9482, 9486, 9442
14309, 9438, 9482, 9486, 9442, 9439, 9483, 9487, 9443
14310, 9439, 9483, 9487, 9443, 9440, 9484, 9488, 9444
14311, 9440, 9484, 9488, 9444, 4758, 4769, 4770, 4759
14312, 2822, 2833, 2834, 2823, 9441, 9485, 9489, 9445
14313, 9441, 9485, 9489, 9445, 9442, 9486, 9490, 9446
14314, 9442, 9486, 9490, 9446, 9443, 9487, 9491, 9447
14315, 9443, 9487, 9491, 9447, 9444, 9488, 9492, 9448
14316, 9444, 9488, 9492, 9448, 4759, 4770, 4771, 4760
14317, 2823, 2834, 2835, 2824, 9445, 9489, 9493, 9449
14318, 9445, 9489, 9493, 9449, 9446, 9490, 9494, 9450
14319, 9446, 9490, 9494, 9450, 9447, 9491, 9495, 9451
14320, 9447, 9491, 9495, 9451, 9448, 9492, 9496, 9452
14321, 9448, 9492, 9496, 9452, 4760, 4771, 4772, 4761
14322, 2824, 2835, 2836, 2825, 9449, 9493, 9497, 9453
14323, 9449, 9493, 9497, 9453, 9450, 9494, 9498, 9454
14324, 9450, 9494, 9498, 9454, 9451, 9495, 9499, 9455
14325, 9451, 9495, 9499, 9455, 9452, 9496, 9500, 9456
14326, 9452, 9496, 9500, 9456, 4761, 4772, 4773, 4762
14327, 2825, 2836, 2837, 2826, 9453, 9497, 9501, 9457
14328, 9453, 9497, 9501, 9457, 9454, 9498, 9502, 9458
14329, 9454, 9498, 9502, 9458, 9455, 9499, 9503, 9459
14330, 9455, 9499, 9503, 9459, 9456, 9500, 9504, 9460
14331, 9456, 9500, 9504, 9460, 4762, 4773, 4774, 4763
14332, 2826, 2837, 512, 511, 9457, 9501, 4672, 4668
14333, 9457, 9501, 4672, 4668, 9458, 9502, 4673, 4669
14334, 9458, 9502, 4673, 4669, 9459, 9503, 4674, 4670
14335, 9459, 9503, 4674, 4670, 9460, 9504, 4675, 4671
14336, 9460, 9504, 4675, 4671, 4763, 4774, 1062, 1061
14337, 444, 26, 456, 2827, 4494, 995, 4552, 9461
14338, 4494, 995, 4552, 9461, 4495, 996, 4553, 9462
14339, 4495, 996, 4553, 9462, 4496, 997, 4554, 9463
14340, 4496, 997, 4554, 9463, 4497, 998, 4555, 9464
14341, 4497, 998, 4555, 9464, 1023, 81, 1028, 4764
14342, 2827, 456, 457, 2828, 9461, 4552, 4556, 9465
14343, 9461, 4552, 4556, 9465, 9462, 4553, 4557, 9466
14344, 9462, 4553, 4557, 9466, 9463, 4554, 4558, 9467
14345, 9463, 4554, 4558, 9467, 9464, 4555, 4559, 9468
14346, 9464, 4555, 4559, 9468, 4764, 1028, 1029, 4765
14347, 2828, 457, 458, 2829, 9465, 4556, 4560, 9469
14348, 9465, 4556, 4560, 9469, 9466, 4557, 4561, 9470
14349, 9466, 4557, 4561, 9470, 9467, 4558, 4562, 9471
14350, 9467, 4558, 4562, 9471, 9468, 4559, 4563, 9472
14351, 9468, 4559, 4563, 9472, 4765, 1029, 1030, 4766
14352, 2829, 458, 459, 2830, 9469, 4560, 4564, 9473
14353, 9469, 4560, 4564, 9473, 9470, 4561, 4565, 9474
14354, 9470, 4561, 4565, 9474, 9471, 4562, 4566, 9475
14355, 9471, 4562, 4566, 9475, 9472, 4563, 4567, 9476
14356, 9472, 4563, 4567, 9476, 4766, 1030, 1031, 4767
14357, 2830, 459, 460, 2831, 9473, 4564, 4568, 9477
14358, 9473, 4564, 4568, 9477, 9474, 4565, 4569, 9478
14359, 9474, 4565, 4569, 9478, 9475, 4566, 4570, 9479
14360, 9475, 4566, 4570, 9479, 9476, 4567, 4571, 9480
14361, 9476, 4567, 4571, 9480, 4767, 1031, 1032, 4768
14362, 2831, 460, 461, 2832, 9477, 4568, 4572, 9481
14363, 9477, 4568, 4572, 9481, 9478, 4569, 4573, 9482
14364, 9478, 4569, 4573, 9482, 9479, 4570, 4574, 9483
14365, 9479, 4570, 4574, 9483, 9480, 4571, 4575, 9484
14366, 9480, 4571, 4575, 9484, 4768, 1032, 1033, 4769
14367, 2832, 461, 462, 2833, 9481, 4572, 4576, 9485
14368, 9481, 4572, 4576, 9485, 9482, 4573, 4577, 9486
14369, 9482, 4573, 4577, 9486, 9483, 4574, 4578, 9487
14370, 9483, 4574, 4578, 9487, 9484, 4575, 4579, 9488
14371, 9484, 4575, 4579, 9488, 4769, 1033, 1034, 4770
14372, 2833, 462, 463, 2834, 9485, 4576, 4580, 9489
14373, 9485, 4576, 4580, 9489, 9486, 4577, 4581, 9490
14374, 9486, 4577, 4581, 9490, 9487, 4578, 4582, 9491
14375, 9487, 4578, 4582, 9491, 9488, 4579, 4583, 9492
14376, 9488, 4579, 4583, 9492, 4770, 1034, 1035, 4771
14377, 2834, 463, 464, 2835, 9489, 4580, 4584, 9493
14378, 9489, 4580, 4584, 9493, 9490, 4581, 4585, 9494
14379, 9490, 4581, 4585, 9494, 9491, 4582, 4586, 9495
14380, 9491, 4582, 4586, 9495, 9492, 4583, 4587, 9496
14381, 9492, 4583, 4587, 9496, 4771, 1035, 1036, 4772
14382, 2835, 464, 465, 2836, 9493, 4584, 4588, 9497
14383, 9493, 4584, 4588, 9497, 9494, 4585, 4589, 9498
14384, 9494, 4585, 4589, 9498, 9495, 4586, 4590, 9499
14385, 9495, 4586, 4590, 9499, 9496, 4587, 4591, 9500
14386, 9496, 4587, 4591, 9500, 4772, 1036, 1037, 4773
14387, 2836, 465, 466, 2837, 9497, 4588, 4592, 9501
14388, 9497, 4588, 4592, 9501, 9498, 4589, 4593, 9502
14389, 9498, 4589, 4593, 9502, 9499, 4590, 4594, 9503
14390, 9499, 4590, 4594, 9503, 9500, 4591, 4595, 9504
14391, 9500, 4591, 4595, 9504, 4773, 1037, 1038, 4774
14392, 2837, 466, 30, 512, 9501, 4592, 1024, 4672
14393, 9501, 4592, 1024, 4672, 9502, 4593, 1025, 4673
14394, 9502, 4593, 1025, 4673, 9503, 4594, 1026, 4674
14395, 9503, 4594, 1026, 4674, 9504, 4595, 1027, 4675
14396, 9504, 4595, 1027, 4675, 4774, 1038, 83, 1062
*ELEMENT, type=C3D8, ELSET=Volume23
14397, 2, 145, 1263, 97, 1067, 4775, 9505, 4899
14398, 1067, 4775, 9505, 4899, 1068, 4776, 9506, 4900
14399, 1068, 4776, 9506, 4900, 1069, 4777, 9507, 4901
14400, 1069, 4777, 9507, 4901, 1070, 4778, 9508, 4902
14401, 1070, 4778, 9508, 4902, 86, 1071, 4935, 1110
14402, 97, 1263, 1264, 98, 4899, 9505, 9509, 4903
14403, 4899, 9505, 9509, 4903, 4900, 9506, 9510, 4904
14404, 4900, 9506, 9510, 4904, 4901, 9507, 9511, 4905
14405, 4901, 9507, 9511, 4905, 4902, 9508, 9512, 4906
14406, 4902, 9508, 9512, 4906, 1110, 4935, 4936, 1111
14407, 98, 1264, 1265, 99, 4903, 9509, 9513, 4907
14408, 4903, 9509, 9513, 4907, 4904, 9510, 9514, 4908
14409, 4904, 9510, 9514, 4908, 4905, 9511, 9515, 4909
14410, 4905, 9511, 9515, 4909, 4906, 9512, 9516, 4910
14411, 4906, 9512, 9516, 4910, 1111, 4936, 4937, 1112
14412, 99, 1265, 1266, 100, 4907, 9513, 9517, 4911
14413, 4907, 9513, 9517, 4911, 4908, 9514, 9518, 4912
14414, 4908, 9514, 9518, 4912, 4909, 9515, 9519, 4913
14415, 4909, 9515, 9519, 4913, 4910, 9516, 9520, 4914
14416, 4910, 9516, 9520, 4914, 1112, 4937, 4938, 1113
14417, 100, 1266, 1267, 101, 4911, 9517, 9521, 4915
14418, 4911, 9517, 9521, 4915, 4912, 9518, 9522, 4916
14419, 4912, 9518, 9522, 4916, 4913, 9519, 9523, 4917
14420, 4913, 9519, 9523, 4917, 4914, 9520, 9524, 4918
14421, 4914, 9520, 9524, 4918, 1113, 4938, 4939, 1114
14422, 101, 1267, 1268, 102, 4915, 9521, 9525, 4919
14423, 4915, 9521, 9525, 4919, 4916, 9522, 9526, 4920
14424, 4916, 9522, 9526, 4920, 4917, 9523, 9527, 4921
14425, 4917, 9523, 9527, 4921, 4918, 9524, 9528, 4922
14426, 4918, 9524, 9528, 4922, 1114, 4939, 4940, 1115
14427, 102, 1268, 1269, 103, 4919, 9525, 9529, 4923
14428, 4919, 9525, 9529, 4923, 4920, 9526, 9530, 4924
14429, 4920, 9526, 9530, 4924, 4921, 9527, 9531, 4925
14430, 4921, 9527, 9531, 4925, 4922, 9528, 9532, 4926
14431, 4922, 9528, 9532, 4926, 1115, 4940, 4941, 1116
14432, 103, 1269, 1270, 104, 4923, 9529, 9533, 4927
14433, 4923, 9529, 9533, 4927, 4924, 9530, 9534, 4928
14434, 4924, 9530, 9534, 4928, 4925, 9531, 9535, 4929
14435, 4925, 9531, 9535, 4929, 4926, 9532, 9536, 4930
14436, 4926, 9532, 9536, 4930, 1116, 4941, 4942, 1117
14437, 104, 1270, 1271, 105, 4927, 9533, 9537, 4931
14438, 4927, 9533, 9537, 4931, 4928, 9534, 9538, 4932
14439, 4928, 9534, 9538, 4932, 4929, 9535, 9539, 4933
14440, 4929, 9535, 9539, 4933, 4930, 9536, 9540, 4934
14441, 4930, 9536, 9540, 4934, 1117, 4942, 4943, 1118
14442, 105, 1271, 156, 1, 4931, 9537, 4855, 1095
14443, 4931, 9537, 4855, 1095, 4932, 9538, 4856, 1096
14444, 4932, 9538, 4856, 1096, 4933, 9539, 4857, 1097
14445, 4933, 9539, 4857, 1097, 4934, 9540, 4858, 1098
14446, 4934, 9540, 4858, 1098, 1118, 4943, 1099, 88
14447, 145, 146, 1272, 1263, 4775, 4779, 9541, 9505
14448, 4775, 4779, 9541, 9505, 4776, 4780, 9542, 9506
14449, 4776, 4780, 9542, 9506, 4777, 4781, 9543, 9507
14450, 4777, 4781, 9543, 9507, 4778, 4782, 9544, 9508
14451, 4778, 4782, 9544, 9508, 1071, 1072, 4944, 4935
14452, 1263, 1272, 1273, 1264, 9505, 9541, 9545, 9509
14453, 9505, 9541, 9545, 9509, 9506, 9542, 9546, 9510
14454, 9506, 9542, 9546, 9510, 9507, 9543, 9547, 9511
14455, 9507, 9543, 9547, 9511, 9508, 9544, 9548, 9512
14456, 9508, 9544, 9548, 9512, 4935, 4944, 4945, 4936
14457, 1264, 1273, 1274, 1265, 9509, 9545, 9549, 9513
14458, 9509, 9545, 9549, 9513, 9510, 9546, 9550, 9514
14459, 9510, 9546, 9550, 9514, 9511, 9547, 9551, 9515
14460, 9511, 9547, 9551, 9515, 9512, 9548, 9552, 9516
14461, 9512, 9548, 9552, 9516, 4936, 4945, 4946, 4937
14462, 1265, 1274, 1275, 1266, 9513, 9549, 9553, 9517
14463, 9513, 9549, 9553, 9517, 9514, 9550, 9554, 9518
14464, 9514, 9550, 9554, 9518, 9515, 9551, 9555, 9519
14465, 9515, 9551, 9555, 9519, 9516, 9552, 9556, 9520
14466, 9516, 9552, 9556, 9520, 4937, 4946, 4947, 4938
14467, 1266, 1275, 1276, 1267, 9517, 9553, 9557, 9521
14468, 9517, 9553, 9557, 9521, 9518, 9554, 9558, 9522
14469, 9518, 9554, 9558, 9522, 9519, 9555, 9559, 9523
14470, 9519, 9555, 9559, 9523, 9520, 9556, 9560, 9524
14471, 9520, 9556, 9560, 9524, 4938, 4947, 4948, 4939
14472, 1267, 1276, 1277, 1268, 9521, 9557, 9561, 9525
14473, 9521, 9557, 9561, 9525, 9522, 9558, 9562, 9526
14474, 9522, 9558, 9562, 9526, 9523, 9559, 9563, 9527
14475, 9523, 9559, 9563, 9527, 9524, 9560, 9564, 9528
14476, 9524, 9560, 9564, 9528, 4939, 4948, 4949, 4940
14477, 1268, 1277, 1278, 1269, 9525, 9561, 9565, 9529
14478, 9525, 9561, 9565, 9529, 9526, 9562, 9566, 9530
14479, 9526, 9562, 9566, 9530, 9527, 9563, 9567, 9531
14480, 9527, 9563, 9567, 9531, 9528, 9564, 9568, 9532
14481, 9528, 9564, 9568, 9532, 4940, 4949, 4950, 4941
14482, 1269, 1278, 1279, 1270, 9529, 9565, 9569, 9533
14483, 9529, 9565, 9569, 9533, 9530, 9566, 9570, 9534
14484, 9530, 9566, 9570, 9534, 9531, 9567, 9571, 9535
14485, 9531, 9567, 9571, 9535, 9532, 9568, 9572, 9536
14486, 9532, 9568, 9572, 9536, 4941, 4950, 4951, 4942
14487, 1270, 1279, 1280, 1271, 9533, 9569, 9573, 9537
14488, 9533, 9569, 9573, 9537, 9534, 9570, 9574, 9538
14489, 9534, 9570, 9574, 9538, 9535, 9571, 9575, 9539
14490, 9535, 9571, 9575, 9539, 9536, 9572, 9576, 9540
14491, 9536, 9572, 9576, 9540, 4942, 4951, 4952, 4943
14492, 1271, 1280, 157, 156, 9537, 9573, 4859, 4855
14493, 9537, 9573, 4859, 4855, 9538, 9574, 4860, 4856
14494, 9538, 9574, 4860, 4856, 9539, 9575, 4861, 4857
14495, 9539, 9575, 4861, 4857, 9540, 9576, 4862, 4858
14496, 9540, 9576, 4862, 4858, 4943, 4952, 1100, 1099
14497, 146, 147, 1281, 1272, 4779, 4783, 9577, 9541
14498, 4779, 4783, 9577, 9541, 4780, 4784, 9578, 9542
14499, 4780, 4784, 9578, 9542, 4781, 4785, 9579, 9543
14500, 4781, 4785, 9579, 9543, 4782, 4786, 9580, 9544
14501, 4782, 4786, 9580, 9544, 1072, 1073, 4953, 4944
14502, 1272, 1281, 1282, 1273, 9541, 9577, 9581, 9545
14503, 9541, 9577, 9581, 9545, 9542, 9578, 9582, 9546
14504, 9542, 9578, 9582, 9546, 9543, 9579, 9583, 9547
14505, 9543, 9579, 9583, 9547, 9544, 9580, 9584, 9548
14506, 9544, 9580, 9584, 9548, 4944, 4953, 4954, 4945
14507, 1273, 1282, 1283, 1274, 9545, 9581, 9585, 9549
14508, 9545, 9581, 9585, 9549, 9546, 9582, 9586, 9550
14509, 9546, 9582, 9586, 9550, 9547, 9583, 9587, 9551
14510, 9547, 9583, 9587, 9551, 9548, 9584, 9588, 9552
14511, 9548, 9584, 9588, 9552, 4945, 4954, 4955, 4946
14512, 1274, 1283, 1284, 1275, 9549, 9585, 9589, 9553
14513, 9549, 9585, 9589, 9553, 9550, 9586, 9590, 9554
14514, 9550, 9586, 9590, 9554, 9551, 9587, 9591, 9555
14515, 9551, 9587, 9591, 9555, 9552, 9588, 9592, 9556
14516, 9552, 9588, 9592, 9556, 4946, 4955, 4956, 4947
14517, 1275, 1284, 1285, 1276, 9553, 9589, 9593, 9557
14518, 9553, 9589, 9593, 9557, 9554, 9590, 9594, 9558
14519, 9554, 9590, 9594, 9558, 9555, 9591, 9595, 9559
14520, 9555, 9591, 9595, 9559, 9556, 9592, 9596, 9560
14521, 9556, 9592, 9596, 9560, 4947, 4956, 4957, 4948
14522, 1276, 1285, 1286, 1277, 9557, 9593, 9597, 9561
14523, 9557, 9593, 9597, 9561, 9558, 9594, 9598, 9562
14524, 9558, 9594, 9598, 9562, 9559, 9595, 9599, 9563
14525, 9559, 9595, 9599, 9563, 9560, 9596, 9600, 9564
14526, 9560, 9596, 9600, 9564, 4948, 4957, 4958, 4949
14527, 1277, 1286, 1287, 1278, 9561, 9597, 9601, 9565
14528, 9561, 9597, 9601, 9565, 9562, 9598, 9602, 9566
14529, 9562, 9598, 9602, 9566, 9563, 9599, 9603, 9567
14530, 9563, 9599, 9603, 9567, 9564, 9600, 9604, 9568
14531, 9564, 9600, 9604, 9568, 4949, 4958, 4959, 4950
14532, 1278, 1287, 1288, 1279, 9565, 9601, 9605, 9569
14533, 9565, 9601, 9605, 9569, 9566, 9602, 9606, 9570
14534, 9566, 9602, 9606, 9570, 9567, 9603, 9607, 9571
14535, 9567, 9603, 9607, 9571, 9568, 9604, 9608, 9572
14536, 9568, 9604, 9608, 9572, 4950, 4959, 4960, 4951
14537, 1279, 1288, 1289, 1280, 9569, 9605, 9609, 9573
14538, 9569, 9605, 9609, 9573, 9570, 9606, 9610, 9574
14539, 9570, 9606, 9610, 9574, 9571, 9607, 9611, 9575
14540, 9571, 9607, 9611, 9575, 9572, 9608, 9612, 9576
14541, 9572, 9608, 9612, 9576, 4951, 4960, 4961, 4952
14542, 1280, 1289, 158, 157, 9573, 9609, 4863, 4859
14543, 9573, 9609, 4863, 4859, 9574, 9610, 4864, 4860
14544, 9574, 9610, 4864, 4860, 9575, 9611, 4865, 4861
14545, 9575, 9611, 4865, 4861, 9576, 9612, 4866, 4862
14546, 9576, 9612, 4866, 4862, 4952, 4961, 1101, 1100
14547, 147, 148, 1290, 1281, 4783, 4787, 9613, 9577
14548, 4783, 4787, 9613, 9577, 4784, 4788, 9614, 9578
14549, 4784, 4788, 9614, 9578, 4785, 4789, 9615, 9579
14550, 4785, 4789, 9615, 9579, 4786, 4790, 9616, 9580
14551, 4786, 4790, 9616, 9580, 1073, 1074, 4962, 4953
14552, 1281, 1290, 1291, 1282, 9577, 9613, 9617, 9581
14553, 9577, 9613, 9617, 9581, 9578, 9614, 9618, 9582
14554, 9578, 9614, 9618, 9582, 9579, 9615, 9619, 9583
14555, 9579, 9615, 9619, 9583, 9580, 9616, 9620, 9584
14556, 9580, 9616, 9620, 9584, 4953, 4962, 4963, 4954
14557, 1282, 1291, 1292, 1283, 9581, 9617, 9621, 9585
14558, 9581, 9617, 9621, 9585, 9582, 9618, 9622, 9586
14559, 9582, 9618, 9622, 9586, 9583, 9619, 9623, 9587
14560, 9583, 9619, 9623, 9587, 9584, 9620, 9624, 9588
14561, 9584, 9620, 9624, 9588, 4954, 4963, 4964, 4955
14562, 1283, 1292, 1293, 1284, 9585, 9621, 9625, 9589
14563, 9585, 9621, 9625, 9589, 9586, 9622, 9626, 9590
14564, 9586, 9622, 9626, 9590, 9587, 9623, 9627, 9591
14565, 9587, 9623, 9627, 9591, 9588, 9624, 9628, 9592
14566, 9588, 9624, 9628, 9592, 4955, 4964, 4965, 4956
14567, 1284, 1293, 1294, 1285, 9589, 9625, 9629, 9593
14568, 9589, 9625, 9629, 9593, 9590, 9626, 9630, 9594
14569, 9590, 9626, 9630, 9594, 9591, 9627, 9631, 9595
14570, 9591, 9627, 9631, 9595, 9592, 9628, 9632, 9596
14571, 9592, 9628, 9632, 9596, 4956, 4965, 4966, 4957
14572, 1285, 1294, 1295, 1286, 9593, 9629, 9633, 9597
14573, 9593, 9629, 9633, 9597, 9594, 9630, 9634, 9598
14574, 9594, 9630, 9634, 9598, 9595, 9631, 9635, 9599
14575, 9595, 9631, 9635, 9599, 9596, 9632, 9636, 9600
14576, 9596, 9632, 9636, 9600, 4957, 4966, 4967, 4958
14577, 1286, 1295, 1296, 1287, 9597, 9633, 9637, 9601
14578, 9597, 9633, 9637, 9601, 9598, 9634, 9638, 9602
14579, 9598, 9634, 9638, 9602, 9599, 9635, 9639, 9603
14580, 9599, 9635, 9639, 9603, 9600, 9636, 9640, 9604
14581, 9600, 9636, 9640, 9604, 4958, 4967, 4968, 4959
14582, 1287, 1296, 1297, 1288, 9601, 9637, 9641, 9605
14583, 9601, 9637, 9641, 9605, 9602, 9638, 9642, 9606
14584, 9602, 9638, 9642, 9606, 9603, 9639, 9643, 9607
14585, 9603, 9639, 9643, 9607, 9604, 9640, 9644, 9608
14586, 9604, 9640, 9644, 9608, 4959, 4968, 4969, 4960
14587, 1288, 1297, 1298, 1289, 9605, 9641, 9645, 9609
14588, 9605, 9641, 9645, 9609, 9606, 9642, 9646, 9610
14589, 9606, 9642, 9646, 9610, 9607, 9643, 9647, 9611
14590, 9607, 9643, 9647, 9611, 9608, 9644, 9648, 9612
14591, 9608, 9644, 9648, 9612, 4960, 4969, 4970, 4961
14592, 1289, 1298, 159, 158, 9609, 9645, 4867, 4863
14593, 9609, 9645, 4867, 4863, 9610, 9646, 4868, 4864
14594, 9610, 9646, 4868, 4864, 9611, 9647, 4869, 4865
14595, 9611, 9647, 4869, 4865, 9612, 9648, 4870, 4866
14596, 9612, 9648, 4870, 4866, 4961, 4970, 1102, 1101
14597, 148, 149, 1299, 1290, 4787, 4791, 9649, 9613
14598, 4787, 4791, 9649, 9613, 4788, 4792, 9650, 9614
14599, 4788, 4792, 9650, 9614, 4789, 4793, 9651, 9615
14600, 4789, 4793, 9651, 9615, 4790, 4794, 9652, 9616
14601, 4790, 4794, 9652, 9616, 1074, 1075, 4971, 4962
14602, 1290, 1299, 1300, 1291, 9613, 9649, 9653, 9617
14603, 9613, 9649, 9653, 9617, 9614, 9650, 9654, 9618
14604, 9614, 9650, 9654, 9618, 9615, 9651, 9655, 9619
14605, 9615, 9651, 9655, 9619, 9616, 9652, 9656, 9620
14606, 9616, 9652, 9656, 9620, 4962, 4971, 4972, 4963
14607, 1291, 1300, 1301, 1292, 9617, 9653, 9657, 9621
14608, 9617, 9653, 9657, 9621, 9618, 9654, 9658, 9622
14609, 9618, 9654, 9658, 9622, 9619, 9655, 9659, 9623
14610, 9619, 9655, 9659, 9623, 9620, 9656, 9660, 9624
14611, 9620, 9656, 9660, 9624, 4963, 4972, 4973, 4964
14612, 1292, 1301, 1302, 1293, 9621, 9657, 9661, 9625
14613, 9621, 9657, 9661, 9625, 9622, 9658, 9662, 9626
14614, 9622, 9658, 9662, 9626, 9623, 9659, 9663, 9627
14615, 9623, 9659, 9663, 9627, 9624, 9660, 9664, 9628
14616, 9624, 9660, 9664, 9628, 4964, 4973, 4974, 4965
14617, 1293, 1302, 1303, 1294, 9625, 9661, 9665, 9629
14618, 9625, 9661, 9665, 9629, 9626, 9662, 9666, 9630
14619, 9626, 9662, 9666, 9630, 9627, 9663, 9667, 9631
14620, 9627, 9663, 9667, 9631, 9628, 9664, 9668, 9632
14621, 9628, 9664, 9668, 9632, 4965, 4974, 4975, 4966
14622, 1294, 1303, 1304, 1295, 9629, 9665, 9669, 9633
14623, 9629, 9665, 9669, 9633, 9630, 9666, 9670, 9634
14624, 9630, 9666, 9670, 9634, 9631, 9667, 9671, 9635
14625, 9631, 9667, 9671, 9635, 9632, 9668, 9672, 9636
14626, 9632, 9668, 9672, 9636, 4966, 4975, 4976, 4967
14627, 1295, 1304, 1305, 1296, 9633, 9669, 9673, 9637
14628, 9633, 9669, 9673, 9637, 9634, 9670, 9674, 9638
14629, 9634, 9670, 9674, 9638, 9635, 9671, 9675, 9639
14630, 9635, 9671, 9675, 9639, 9636, 9672, 9676, 9640
14631, 9636, 9672, 9676, 9640, 4967, 4976, 4977, 4968
14632, 1296, 1305, 1306, 1297, 9637, 9673, 9677, 9641
14633, 9637, 9673, 9677, 9641, 9638, 9674, 9678, 9642
14634, 9638, 9674, 9678, 9642, 9639, 9675, 9679, 9643
14635, 9639, 9675, 9679, 9643, 9640, 9676, 9680, 9644
14636, 9640, 9676, 9680, 9644, 4968, 4977, 4978, 4969
14637, 1297, 1306, 1307, 1298, 9641, 9677, 9681, 9645
14638, 9641, 9677, 9681, 9645, 9642, 9678, 9682, 9646
14639, 9642, 9678, 9682, 9646, 9643, 9679, 9683, 9647
14640, 9643, 9679, 9683, 9647, 9644, 9680, 9684, 9648
14641, 9644, 9680, 9684, 9648, 4969, 4978, 4979, 4970
14642, 1298, 1307, 160, 159, 9645, 9681, 4871, 4867
14643, 9645, 9681, 4871, 4867, 9646, 9682, 4872, 4868
14644, 9646, 9682, 4872, 4868, 9647, 9683, 4873, 4869
14645, 9647, 9683, 4873, 4869, 9648, 9684, 4874, 4870
14646, 9648, 9684, 4874, 4870, 4970, 4979, 1103, 1102
14647, 149, 150, 1308, 1299, 4791, 4795, 9685, 9649
14648, 4791, 4795, 9685, 9649, 4792, 4796, 9686, 9650
14649, 4792, 4796, 9686, 9650, 4793, 4797, 9687, 9651
14650, 4793, 4797, 9687, 9651, 4794, 4798, 9688, 9652
14651, 4794, 4798, 9688, 9652, 1075, 1076, 4980, 4971
14652, 1299, 1308, 1309, 1300, 9649, 9685, 9689, 9653
14653, 9649, 9685, 9689, 9653, 9650, 9686, 9690, 9654
14654, 9650, 9686, 9690, 9654, 9651, 9687, 9691, 9655
14655, 9651, 9687, 9691, 9655, 9652, 9688, 9692, 9656
14656, 9652, 9688, 9692, 9656, 4971, 4980, 4981, 4972
14657, 1300, 1309, 1310, 1301, 9653, 9689, 9693, 9657
14658, 9653, 9689, 9693, 9657, 9654, 9690, 9694, 9658
14659, 9654, 9690, 9694, 9658, 9655, 9691, 9695, 9659
14660, 9655, 9691, 9695, 9659, 9656, 9692, 9696, 9660
14661, 9656, 9692, 9696, 9660, 4972, 4981, 4982, 4973
14662, 1301, 1310, 1311, 1302, 9657, 9693, 9697, 9661
14663, 9657, 9693, 9697, 9661, 9658, 9694, 9698, 9662
14664, 9658, 9694, 9698, 9662, 9659, 9695, 9699, 9663
14665, 9659, 9695, 9699, 9663, 9660, 9696, 9700, 9664
14666, 9660, 9696, 9700, 9664, 4973, 4982, 4983, 4974
14667, 1302, 1311, 1312, 1303, 9661, 9697, 9701, 9665
14668, 9661, 9697, 9701, 9665, 9662, 9698, 9702, 9666
14669, 9662, 9698, 9702, 9666, 9663, 9699, 9703, 9667
14670, 9663, 9699, 9703, 9667, 9664, 9700, 9704, 9668
14671, 9664, 9700, 9704, 9668, 4974, 4983, 4984, 4975
14672, 1303, 1312, 1313, 1304, 9665, 9701, 9705, 9669
14673, 9665, 9701, 9705, 9669, 9666, 9702, 9706, 9670
14674, 9666, 9702, 9706, 9670, 9667, 9703, 9707, 9671
14675, 9667, 9703, 9707, 9671, 9668, 9704, 9708, 9672
14676, 9668, 9704, 9708, 9672, 4975, 4984, 4985, 4976
14677, 1304, 1313, 1314, 1305, 9669, 9705, 9709, 9673
14678, 9669, 9705, 9709, 9673, 9670, 9706, 9710, 9674
14679, 9670, 9706, 9710, 9674, 9671, 9707, 9711, 9675
14680, 9671, 9707, 9711, 9675, 9672, 9708, 9712, 9676
14681, 9672, 9708, 9712, 9676, 4976, 4985, 4986, 4977
14682, 1305, 1314, 1315, 1306, 9673, 9709, 9713, 9677
14683, 9673, 9709, 9713, 9677, 9674, 9710, 9714, 9678
14684, 9674, 9710, 9714, 9678, 9675, 9711, 9715, 9679
14685, 9675, 9711, 9715, 9679, 9676, 9712, 9716, 9680
14686, 9676, 9712, 9716, 9680, 4977, 4986, 4987, 4978
14687, 1306, 1315, 1316, 1307, 9677, 9713, 9717, 9681
14688, 9677, 9713, 9717, 9681, 9678, 9714, 9718, 9682
14689, 9678, 9714, 9718, 9682, 9679, 9715, 9719, 9683
14690, 9679, 9715, 9719, 9683, 9680, 9716, 9720, 9684
14691, 9680, 9716, 9720, 9684, 4978, 4987, 4988, 4979
14692, 1307, 1316, 161, 160, 9681, 9717, 4875, 4871
14693, 9681, 9717, 4875, 4871, 9682, 9718, 4876, 4872
14694, 9682, 9718, 4876, 4872, 9683, 9719, 4877, 4873
14695, 9683, 9719, 4877, 4873, 9684, 9720, 4878, 4874
14696, 9684, 9720, 4878, 4874, 4979, 4988, 1104, 1103
14697, 150, 151, 1317, 1308, 4795, 4799, 9721, 9685
14698, 4795, 4799, 9721, 9685, 4796, 4800, 9722, 9686
14699, 4796, 4800, 9722, 9686, 4797, 4801, 9723, 9687
14700, 4797, 4801, 9723, 9687, 4798, 4802, 9724, 9688
14701, 4798, 4802, 9724, 9688, 1076, 1077, 4989, 4980
14702, 1308, 1317, 1318, 1309, 9685, 9721, 9725, 9689
14703, 9685, 9721, 9725, 9689, 9686, 9722, 9726, 9690
14704, 9686, 9722, 9726, 9690, 9687, 9723, 9727, 9691
14705, 9687, 9723, 9727, 9691, 9688, 9724, 9728, 9692
14706, 9688, 9724, 9728, 9692, 4980, 4989, 4990, 4981
14707, 1309, 1318, 1319, 1310, 9689, 9725, 9729, 9693
14708, 9689, 9725, 9729, 9693, 9690, 9726, 9730, 9694
14709, 9690, 9726, 9730, 9694, 9691, 9727, 9731, 9695
14710, 9691, 9727, 9731, 9695, 9692, 9728, 9732, 9696
14711, 9692, 9728, 9732, 9696, 4981, 4990, 4991, 4982
14712, 1310, 1319, 1320, 1311, 9693, 9729, 9733, 9697
14713, 9693, 9729, 9733, 9697, 9694, 9730, 9734, 9698
14714, 9694, 9730, 9734, 9698, 9695, 9731, 9735, 9699
14715, 9695, 9731, 9735, 9699, 9696, 9732, 9736, 9700
14716, 9696, 9732, 9736, 9700, 4982, 4991, 4992, 4983
14717, 1311, 1320, 1321, 1312, 9697, 9733, 9737, 9701
14718, 9697, 9733, 9737, 9701, 9698, 9734, 9738, 9702
14719, 9698, 9734, 9738, 9702, 9699, 9735, 9739, 9703
14720, 9699, 9735, 9739, 9703, 9700, 9736, 9740, 9704
14721, 9700, 9736, 9740, 9704, 4983, 4992, 4993, 4984
14722, 1312, 1321, 1322, 1313, 9701, 9737, 9741, 9705
14723, 9701, 9737, 9741, 9705, 9702, 9738, 9742, 9706
14724, 9702, 9738, 9742, 9706, 9703, 9739, 9743, 9707
14725, 9703, 9739, 9743, 9707, 9704, 9740, 9744, 9708
14726, 9704, 9740, 9744, 9708, 4984, 4993, 4994, 4985
14727, 1313, 1322, 1323, 1314, 9705, 9741, 9745, 9709
14728, 9705, 9741, 9745, 9709, 9706, 9742, 9746, 9710
14729, 9706, 9742, 9746, 9710, 9707, 9743, 9747, 9711
14730, 9707, 9743, 9747, 9711, 9708, 9744, 9748, 9712
14731, 9708, 9744, 9748, 9712, 4985, 4994, 4995, 4986
14732, 1314, 1323, 1324, 1315, 9709, 9745, 9749, 9713
14733, 9709, 9745, 9749, 9713, 9710, 9746, 9750, 9714
14734, 9710, 9746, 9750, 9714, 9711, 9747, 9751, 9715
14735, 9711, 9747, 9751, 9715, 9712, 9748, 9752, 9716
14736, 9712, 9748, 9752, 9716, 4986, 4995, 4996, 4987
14737, 1315, 1324, 1325, 1316, 9713, 9749, 9753, 9717
14738, 9713, 9749, 9753, 9717, 9714, 9750, 9754, 9718
14739, 9714, 9750, 9754, 9718, 9715, 9751, 9755, 9719
14740, 9715, 9751, 9755, 9719, 9716, 9752, 9756, 9720
14741, 9716, 9752, 9756, 9720, 4987, 4996, 4997, 4988
14742, 1316, 1325, 162, 161, 9717, 9753, 4879, 4875
14743, 9717, 9753, 4879, 4875, 9718, 9754, 4880, 4876
14744, 9718, 9754, 4880, 4876, 9719, 9755, 4881, 4877
14745, 9719, 9755, 4881, 4877, 9720, 9756, 4882, 4878
14746, 9720, 9756, 4882, 4878, 4988, 4997, 1105, 1104
14747, 151, 152, 1326, 1317, 4799, 4803, 9757, 9721
14748, 4799, 4803, 9757, 9721, 4800, 4804, 9758, 9722
14749, 4800, 4804, 9758, 9722, 4801, 4805, 9759, 9723
14750, 4801, 4805, 9759, 9723, 4802, 4806, 9760, 9724
14751, 4802, 4806, 9760, 9724, 1077, 1078, 4998, 4989
14752, 1317, 1326, 1327, 1318, 9721, 9757, 9761, 9725
14753, 9721, 9757, 9761, 9725, 9722, 9758, 9762, 9726
14754, 9722, 9758, 9762, 9726, 9723, 9759, 9763, 9727
14755, 9723, 9759, 9763, 9727, 9724, 9760, 9764, 9728
14756, 9724, 9760, 9764, 9728, 4989, 4998, 4999, 4990
14757, 1318, 1327, 1328, 1319, 9725, 9761, 9765, 9729
14758, 9725, 9761, 9765, 9729, 9726, 9762, 9766, 9730
14759, 9726, 9762, 9766, 9730, 9727, 9763, 9767, 9731
14760, 9727, 9763, 9767, 9731, 9728, 9764, 9768, 9732
14761, 9728, 9764, 9768, 9732, 4990, 4999, 5000, 4991
14762, 1319, 1328, 1329, 1320, 9729, 9765, 9769, 9733
14763, 9729, 9765, 9769, 9733, 9730, 9766, 9770, 9734
14764, 9730, 9766, 9770, 9734, 9731, 9767, 9771, 9735
14765, 9731, 9767, 9771, 9735, 9732, 9768, 9772, 9736
14766, 9732, 9768, 9772, 9736, 4991, 5000, 5001, 4992
14767, 1320, 1329, 1330, 1321, 9733, 9769, 9773, 9737
14768, 9733, 9769, 9773, 9737, 9734, 9770, 9774, 9738
14769, 9734, 9770, 9774, 9738, 9735, 9771, 9775, 9739
14770, 9735, 9771, 9775, 9739, 9736, 9772, 9776, 9740
14771, 9736, 9772, 9776, 9740, 4992, 5001, 5002, 4993
14772, 1321, 1330, 1331, 1322, 9737, 9773, 9777, 9741
14773, 9737, 9773, 9777, 9741, 9738, 9774, 9778, 9742
14774, 9738, 9774, 9778, 9742, 9739, 9775, 9779, 9743
14775, 9739, 9775, 9779, 9743, 9740, 9776, 9780, 9744
14776, 9740, 9776, 9780, 9744, 4993, 5002, 5003, 4994
14777, 1322, 1331, 1332, 1323, 9741, 9777, 9781, 9745
14778, 9741, 9777, 9781, 9745, 9742, 9778, 9782, 9746
14779, 9742, 9778, 9782, 9746, 9743, 9779, 9783, 9747
14780, 9743, 9779, 9783, 9747, 9744, 9780, 9784, 9748
14781, 9744, 9780, 9784, 9748, 4994, 5003, 5004, 4995
14782, 1323, 1332, 1333, 1324, 9745, 9781, 9785, 9749
14783, 9745, 9781, 9785, 9749, 9746, 9782, 9786, 9750
14784, 9746, 9782, 9786, 9750, 9747, 9783, 9787, 9751
14785, 9747, 9783, 9787, 9751, 9748, 9784, 9788, 9752
14786, 9748, 9784, 9788, 9752, 4995, 5004, 5005, 4996
14787, 1324, 1333, 1334, 1325, 9749, 9785, 9789, 9753
14788, 9749, 9785, 9789, 9753, 9750, 9786, 9790, 9754
14789, 9750, 9786, 9790, 9754, 9751, 9787, 9791, 9755
14790, 9751, 9787, 9791, 9755, 9752, 9788, 9792, 9756
14791, 9752, 9788, 9792, 9756, 4996, 5005, 5006, 4997
14792, 1325, 1334, 163, 162, 9753, 9789, 4883, 4879
14793, 9753, 9789, 4883, 4879, 9754, 9790, 4884, 4880
14794, 9754, 9790, 4884, 4880, 9755, 9791, 4885, 4881
14795, 9755, 9791, 4885, 4881, 9756, 9792, 4886, 4882
14796, 9756, 9792, 4886, 4882, 4997, 5006, 1106, 1105
14797, 152, 153, 1335, 1326, 4803, 4807, 9793, 9757
14798, 4803, 4807, 9793, 9757, 4804, 4808, 9794, 9758
14799, 4804, 4808, 9794, 9758, 4805, 4809, 9795, 9759
14800, 4805, 4809, 9795, 9759, 4806, 4810, 9796, 9760
14801, 4806, 4810, 9796, 9760, 1078, 1079, 5007, 4998
14802, 1326, 1335, 1336, 1327, 9757, 9793, 9797, 9761
14803, 9757, 9793, 9797, 9761, 9758, 9794, 9798, 9762
14804, 9758, 9794, 9798, 9762, 9759, 9795, 9799, 9763
14805, 9759, 9795, 9799, 9763, 9760, 9796, 9800, 9764
14806, 9760, 9796, 9800, 9764, 4998, 5007, 5008, 4999
14807, 1327, 1336, 1337, 1328, 9761, 9797, 9801, 9765
14808, 9761, 9797, 9801, 9765, 9762, 9798, 9802, 9766
14809, 9762, 9798, 9802, 9766, 9763, 9799, 9803, 9767
14810, 9763, 9799, 9803, 9767, 9764, 9800, 9804, 9768
14811, 9764, 9800, 9804, 9768, 4999, 5008, 5009, 5000
14812, 1328, 1337, 1338, 1329, 9765, 9801, 9805, 9769
14813, 9765, 9801, 9805, 9769, 9766, 9802, 9806, 9770
14814, 9766, 9802, 9806, 9770, 9767, 9803, 9807, 9771
14815, 9767, 9803, 9807, 9771, 9768, 9804, 9808, 9772
14816, 9768, 9804, 9808, 9772, 5000, 5009, 5010, 5001
14817, 1329, 1338, 1339, 1330, 9769, 9805, 9809, 9773
14818, 9769, 9805, 9809, 9773, 9770, 9806, 9810, 9774
14819, 9770, 9806, 9810, 9774, 9771, 9807, 9811, 9775
14820, 9771, 9807, 9811, 9775, 9772, 9808, 9812, 9776
14821, 9772, 9808, 9812, 9776, 5001, 5010, 5011, 5002
14822, 1330, 1339, 1340, 1331, 9773, 9809, 9813, 9777
14823, 9773, 9809, 9813, 9777, 9774, 9810, 9814, 9778
14824, 9774, 9810, 9814, 9778, 9775, 9811, 9815, 9779
14825, 9775, 9811, 9815, 9779, 9776, 9812, 9816, 9780
14826, 9776, 9812, 9816, 9780, 5002, 5011, 5012, 5003
14827, 1331, 1340, 1341, 1332, 9777, 9813, 9817, 9781
14828, 9777, 9813, 9817, 9781, 9778, 9814, 9818, 9782
14829, 9778, 9814, 9818, 9782, 9779, 9815, 9819, 9783
14830, 9779, 9815, 9819, 9783, 9780, 9816, 9820, 9784
14831, 9780, 9816, 9820, 9784, 5003, 5012, 5013, 5004
