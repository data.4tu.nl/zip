3714, 1.7833333333333, 8.3266726846887e-17, 0.35
3715, 1.8666666666667, 8.3266726846887e-17, 0.35
3716, 1.95, 8.3266726846887e-17, 0.35
3717, 2.0333333333333, 8.3266726846887e-17, 0.35
3718, 2.1166666666667, 8.3266726846887e-17, 0.35
3719, 1.2833333333333, 8.3266726846887e-17, 0.4
3720, 1.3666666666667, 8.3266726846887e-17, 0.4
3721, 1.45, 8.3266726846887e-17, 0.4
3722, 1.5333333333333, 8.3266726846887e-17, 0.4
3723, 1.6166666666667, 8.3266726846887e-17, 0.4
3724, 1.7, 8.3266726846887e-17, 0.4
3725, 1.7833333333333, 8.3266726846887e-17, 0.4
3726, 1.8666666666667, 8.3266726846887e-17, 0.4
3727, 1.95, 8.3266726846887e-17, 0.4
3728, 2.0333333333333, 8.3266726846887e-17, 0.4
3729, 2.1166666666667, 8.3266726846887e-17, 0.4
3730, 1.2833333333333, 8.3266726846887e-17, 0.45
3731, 1.3666666666667, 8.3266726846887e-17, 0.45
3732, 1.45, 8.3266726846887e-17, 0.45
3733, 1.5333333333333, 8.3266726846887e-17, 0.45
3734, 1.6166666666667, 8.3266726846887e-17, 0.45
3735, 1.7, 8.3266726846887e-17, 0.45
3736, 1.7833333333333, 8.3266726846887e-17, 0.45
3737, 1.8666666666667, 8.3266726846887e-17, 0.45
3738, 1.95, 8.3266726846887e-17, 0.45
3739, 2.0333333333333, 8.3266726846887e-17, 0.45
3740, 2.1166666666667, 8.3266726846887e-17, 0.45
3741, 2.3, 0.0375, 0.05
3742, 2.3, 0.025, 0.05
3743, 2.3, 0.0125, 0.05
3744, 2.3, 0.0375, 0.1
3745, 2.3, 0.025, 0.1
3746, 2.3, 0.0125, 0.1
3747, 2.3, 0.0375, 0.15
3748, 2.3, 0.025, 0.15
3749, 2.3, 0.0125, 0.15
3750, 2.3, 0.0375, 0.2
3751, 2.3, 0.025, 0.2
3752, 2.3, 0.0125, 0.2
3753, 2.3, 0.0375, 0.25
3754, 2.3, 0.025, 0.25
3755, 2.3, 0.0125, 0.25
3756, 2.3, 0.0375, 0.3
3757, 2.3, 0.025, 0.3
3758, 2.3, 0.0125, 0.3
3759, 2.3, 0.0375, 0.35
3760, 2.3, 0.025, 0.35
3761, 2.3, 0.0125, 0.35
3762, 2.3, 0.0375, 0.4
3763, 2.3, 0.025, 0.4
3764, 2.3, 0.0125, 0.4
3765, 2.3, 0.0375, 0.45
3766, 2.3, 0.025, 0.45
3767, 2.3, 0.0125, 0.45
3768, -0.1, 0.0125, 0.05
3769, -0.1, 0.025, 0.05
3770, -0.1, 0.0375, 0.05
3771, -0.1, 0.0125, 0.1
3772, -0.1, 0.025, 0.1
3773, -0.1, 0.0375, 0.1
3774, -0.1, 0.0125, 0.15
3775, -0.1, 0.025, 0.15
3776, -0.1, 0.0375, 0.15
3777, -0.1, 0.0125, 0.2
3778, -0.1, 0.025, 0.2
3779, -0.1, 0.0375, 0.2
3780, -0.1, 0.0125, 0.25
3781, -0.1, 0.025, 0.25
3782, -0.1, 0.0375, 0.25
3783, -0.1, 0.0125, 0.3
3784, -0.1, 0.025, 0.3
3785, -0.1, 0.0375, 0.3
3786, -0.1, 0.0125, 0.35
3787, -0.1, 0.025, 0.35
3788, -0.1, 0.0375, 0.35
3789, -0.1, 0.0125, 0.4
3790, -0.1, 0.025, 0.4
3791, -0.1, 0.0375, 0.4
3792, -0.1, 0.0125, 0.45
3793, -0.1, 0.025, 0.45
3794, -0.1, 0.0375, 0.45
3795, 1.05, 0.22, 0.05
3796, 1.05, 0.34, 0.05
3797, 1.05, 0.46, 0.05
3798, 1.05, 0.58, 0.05
3799, 1.05, 0.7, 0.05
3800, 1.05, 0.82, 0.05
3801, 1.05, 0.94, 0.05
3802, 1.05, 1.06, 0.05
3803, 1.05, 1.18, 0.05
3804, 1.05, 0.22, 0.1
3805, 1.05, 0.34, 0.1
3806, 1.05, 0.46, 0.1
3807, 1.05, 0.58, 0.1
3808, 1.05, 0.7, 0.1
3809, 1.05, 0.82, 0.1
3810, 1.05, 0.94, 0.1
3811, 1.05, 1.06, 0.1
3812, 1.05, 1.18, 0.1
3813, 1.05, 0.22, 0.15
3814, 1.05, 0.34, 0.15
3815, 1.05, 0.46, 0.15
3816, 1.05, 0.58, 0.15
3817, 1.05, 0.7, 0.15
3818, 1.05, 0.82, 0.15
3819, 1.05, 0.94, 0.15
3820, 1.05, 1.06, 0.15
3821, 1.05, 1.18, 0.15
3822, 1.05, 0.22, 0.2
3823, 1.05, 0.34, 0.2
3824, 1.05, 0.46, 0.2
3825, 1.05, 0.58, 0.2
3826, 1.05, 0.7, 0.2
3827, 1.05, 0.82, 0.2
3828, 1.05, 0.94, 0.2
3829, 1.05, 1.06, 0.2
3830, 1.05, 1.18, 0.2
3831, 1.05, 0.22, 0.25
3832, 1.05, 0.34, 0.25
3833, 1.05, 0.46, 0.25
3834, 1.05, 0.58, 0.25
3835, 1.05, 0.7, 0.25
3836, 1.05, 0.82, 0.25
3837, 1.05, 0.94, 0.25
3838, 1.05, 1.06, 0.25
3839, 1.05, 1.18, 0.25
3840, 1.05, 0.22, 0.3
3841, 1.05, 0.34, 0.3
3842, 1.05, 0.46, 0.3
3843, 1.05, 0.58, 0.3
3844, 1.05, 0.7, 0.3
3845, 1.05, 0.82, 0.3
3846, 1.05, 0.94, 0.3
3847, 1.05, 1.06, 0.3
3848, 1.05, 1.18, 0.3
3849, 1.05, 0.22, 0.35
3850, 1.05, 0.34, 0.35
3851, 1.05, 0.46, 0.35
3852, 1.05, 0.58, 0.35
3853, 1.05, 0.7, 0.35
3854, 1.05, 0.82, 0.35
3855, 1.05, 0.94, 0.35
3856, 1.05, 1.06, 0.35
3857, 1.05, 1.18, 0.35
3858, 1.05, 0.22, 0.4
3859, 1.05, 0.34, 0.4
3860, 1.05, 0.46, 0.4
3861, 1.05, 0.58, 0.4
3862, 1.05, 0.7, 0.4
3863, 1.05, 0.82, 0.4
3864, 1.05, 0.94, 0.4
3865, 1.05, 1.06, 0.4
3866, 1.05, 1.18, 0.4
3867, 1.05, 0.22, 0.45
3868, 1.05, 0.34, 0.45
3869, 1.05, 0.46, 0.45
3870, 1.05, 0.58, 0.45
3871, 1.05, 0.7, 0.45
3872, 1.05, 0.82, 0.45
3873, 1.05, 0.94, 0.45
3874, 1.05, 1.06, 0.45
3875, 1.05, 1.18, 0.45
3876, 1.15, 1.18, 0.05
3877, 1.15, 1.06, 0.05
3878, 1.15, 0.94, 0.05
3879, 1.15, 0.82, 0.05
3880, 1.15, 0.7, 0.05
3881, 1.15, 0.58, 0.05
3882, 1.15, 0.46, 0.05
3883, 1.15, 0.34, 0.05
3884, 1.15, 0.22, 0.05
3885, 1.15, 1.18, 0.1
3886, 1.15, 1.06, 0.1
3887, 1.15, 0.94, 0.1
3888, 1.15, 0.82, 0.1
3889, 1.15, 0.7, 0.1
3890, 1.15, 0.58, 0.1
3891, 1.15, 0.46, 0.1
3892, 1.15, 0.34, 0.1
3893, 1.15, 0.22, 0.1
3894, 1.15, 1.18, 0.15
3895, 1.15, 1.06, 0.15
3896, 1.15, 0.94, 0.15
3897, 1.15, 0.82, 0.15
3898, 1.15, 0.7, 0.15
3899, 1.15, 0.58, 0.15
3900, 1.15, 0.46, 0.15
3901, 1.15, 0.34, 0.15
3902, 1.15, 0.22, 0.15
3903, 1.15, 1.18, 0.2
3904, 1.15, 1.06, 0.2
3905, 1.15, 0.94, 0.2
3906, 1.15, 0.82, 0.2
3907, 1.15, 0.7, 0.2
3908, 1.15, 0.58, 0.2
3909, 1.15, 0.46, 0.2
3910, 1.15, 0.34, 0.2
3911, 1.15, 0.22, 0.2
3912, 1.15, 1.18, 0.25
3913, 1.15, 1.06, 0.25
3914, 1.15, 0.94, 0.25
3915, 1.15, 0.82, 0.25
3916, 1.15, 0.7, 0.25
3917, 1.15, 0.58, 0.25
3918, 1.15, 0.46, 0.25
3919, 1.15, 0.34, 0.25
3920, 1.15, 0.22, 0.25
3921, 1.15, 1.18, 0.3
3922, 1.15, 1.06, 0.3
3923, 1.15, 0.94, 0.3
3924, 1.15, 0.82, 0.3
3925, 1.15, 0.7, 0.3
3926, 1.15, 0.58, 0.3
3927, 1.15, 0.46, 0.3
3928, 1.15, 0.34, 0.3
3929, 1.15, 0.22, 0.3
3930, 1.15, 1.18, 0.35
3931, 1.15, 1.06, 0.35
3932, 1.15, 0.94, 0.35
3933, 1.15, 0.82, 0.35
3934, 1.15, 0.7, 0.35
3935, 1.15, 0.58, 0.35
3936, 1.15, 0.46, 0.35
3937, 1.15, 0.34, 0.35
3938, 1.15, 0.22, 0.35
3939, 1.15, 1.18, 0.4
3940, 1.15, 1.06, 0.4
3941, 1.15, 0.94, 0.4
3942, 1.15, 0.82, 0.4
3943, 1.15, 0.7, 0.4
3944, 1.15, 0.58, 0.4
3945, 1.15, 0.46, 0.4
3946, 1.15, 0.34, 0.4
3947, 1.15, 0.22, 0.4
3948, 1.15, 1.18, 0.45
3949, 1.15, 1.06, 0.45
3950, 1.15, 0.94, 0.45
3951, 1.15, 0.82, 0.45
3952, 1.15, 0.7, 0.45
3953, 1.15, 0.58, 0.45
3954, 1.15, 0.46, 0.45
3955, 1.15, 0.34, 0.45
3956, 1.15, 0.22, 0.45
3957, 0.083333333333333, 0.22, -0.1
3958, 0.083333333333333, 0.34, -0.1
3959, 0.083333333333333, 0.46, -0.1
3960, 0.083333333333333, 0.58, -0.1
3961, 0.083333333333333, 0.7, -0.1
3962, 0.083333333333333, 0.82, -0.1
3963, 0.083333333333333, 0.94, -0.1
3964, 0.083333333333333, 1.06, -0.1
3965, 0.083333333333333, 1.18, -0.1
3966, 0.16666666666667, 0.22, -0.1
3967, 0.16666666666667, 0.34, -0.1
3968, 0.16666666666667, 0.46, -0.1
3969, 0.16666666666667, 0.58, -0.1
3970, 0.16666666666667, 0.7, -0.1
3971, 0.16666666666667, 0.82, -0.1
3972, 0.16666666666667, 0.94, -0.1
3973, 0.16666666666667, 1.06, -0.1
3974, 0.16666666666667, 1.18, -0.1
3975, 0.25, 0.22, -0.1
3976, 0.25, 0.34, -0.1
3977, 0.25, 0.46, -0.1
3978, 0.25, 0.58, -0.1
3979, 0.25, 0.7, -0.1
3980, 0.25, 0.82, -0.1
3981, 0.25, 0.94, -0.1
3982, 0.25, 1.06, -0.1
3983, 0.25, 1.18, -0.1
3984, 0.33333333333333, 0.22, -0.1
3985, 0.33333333333333, 0.34, -0.1
3986, 0.33333333333333, 0.46, -0.1
3987, 0.33333333333333, 0.58, -0.1
3988, 0.33333333333333, 0.7, -0.1
3989, 0.33333333333333, 0.82, -0.1
3990, 0.33333333333333, 0.94, -0.1
3991, 0.33333333333333, 1.06, -0.1
3992, 0.33333333333333, 1.18, -0.1
3993, 0.41666666666667, 0.22, -0.1
3994, 0.41666666666667, 0.34, -0.1
3995, 0.41666666666667, 0.46, -0.1
3996, 0.41666666666667, 0.58, -0.1
3997, 0.41666666666667, 0.7, -0.1
3998, 0.41666666666667, 0.82, -0.1
3999, 0.41666666666667, 0.94, -0.1
4000, 0.41666666666667, 1.06, -0.1
4001, 0.41666666666667, 1.18, -0.1
4002, 0.5, 0.22, -0.1
4003, 0.5, 0.34, -0.1
4004, 0.5, 0.46, -0.1
4005, 0.5, 0.58, -0.1
4006, 0.5, 0.7, -0.1
4007, 0.5, 0.82, -0.1
4008, 0.5, 0.94, -0.1
4009, 0.5, 1.06, -0.1
4010, 0.5, 1.18, -0.1
4011, 0.58333333333333, 0.22, -0.1
4012, 0.58333333333333, 0.34, -0.1
4013, 0.58333333333333, 0.46, -0.1
4014, 0.58333333333333, 0.58, -0.1
4015, 0.58333333333333, 0.7, -0.1
4016, 0.58333333333333, 0.82, -0.1
4017, 0.58333333333333, 0.94, -0.1
4018, 0.58333333333333, 1.06, -0.1
4019, 0.58333333333333, 1.18, -0.1
4020, 0.66666666666667, 0.22, -0.1
4021, 0.66666666666667, 0.34, -0.1
4022, 0.66666666666667, 0.46, -0.1
4023, 0.66666666666667, 0.58, -0.1
4024, 0.66666666666667, 0.7, -0.1
4025, 0.66666666666667, 0.82, -0.1
4026, 0.66666666666667, 0.94, -0.1
4027, 0.66666666666667, 1.06, -0.1
4028, 0.66666666666667, 1.18, -0.1
4029, 0.75, 0.22, -0.1
4030, 0.75, 0.34, -0.1
4031, 0.75, 0.46, -0.1
4032, 0.75, 0.58, -0.1
4033, 0.75, 0.7, -0.1
4034, 0.75, 0.82, -0.1
4035, 0.75, 0.94, -0.1
4036, 0.75, 1.06, -0.1
4037, 0.75, 1.18, -0.1
4038, 0.83333333333333, 0.22, -0.1
4039, 0.83333333333333, 0.34, -0.1
4040, 0.83333333333333, 0.46, -0.1
4041, 0.83333333333333, 0.58, -0.1
4042, 0.83333333333333, 0.7, -0.1
4043, 0.83333333333333, 0.82, -0.1
4044, 0.83333333333333, 0.94, -0.1
4045, 0.83333333333333, 1.06, -0.1
4046, 0.83333333333333, 1.18, -0.1
4047, 0.91666666666667, 0.22, -0.1
4048, 0.91666666666667, 0.34, -0.1
4049, 0.91666666666667, 0.46, -0.1
4050, 0.91666666666667, 0.58, -0.1
4051, 0.91666666666667, 0.7, -0.1
4052, 0.91666666666667, 0.82, -0.1
4053, 0.91666666666667, 0.94, -0.1
4054, 0.91666666666667, 1.06, -0.1
4055, 0.91666666666667, 1.18, -0.1
4056, 1.2833333333333, 1.18, -0.1
4057, 1.2833333333333, 1.06, -0.1
4058, 1.2833333333333, 0.94, -0.1
4059, 1.2833333333333, 0.82, -0.1
4060, 1.2833333333333, 0.7, -0.1
4061, 1.2833333333333, 0.58, -0.1
4062, 1.2833333333333, 0.46, -0.1
4063, 1.2833333333333, 0.34, -0.1
4064, 1.2833333333333, 0.22, -0.1
4065, 1.3666666666667, 1.18, -0.1
4066, 1.3666666666667, 1.06, -0.1
4067, 1.3666666666667, 0.94, -0.1
4068, 1.3666666666667, 0.82, -0.1
4069, 1.3666666666667, 0.7, -0.1
4070, 1.3666666666667, 0.58, -0.1
4071, 1.3666666666667, 0.46, -0.1
4072, 1.3666666666667, 0.34, -0.1
4073, 1.3666666666667, 0.22, -0.1
4074, 1.45, 1.18, -0.1
4075, 1.45, 1.06, -0.1
4076, 1.45, 0.94, -0.1
4077, 1.45, 0.82, -0.1
4078, 1.45, 0.7, -0.1
4079, 1.45, 0.58, -0.1
4080, 1.45, 0.46, -0.1
4081, 1.45, 0.34, -0.1
4082, 1.45, 0.22, -0.1
4083, 1.5333333333333, 1.18, -0.1
4084, 1.5333333333333, 1.06, -0.1
4085, 1.5333333333333, 0.94, -0.1
4086, 1.5333333333333, 0.82, -0.1
4087, 1.5333333333333, 0.7, -0.1
4088, 1.5333333333333, 0.58, -0.1
4089, 1.5333333333333, 0.46, -0.1
4090, 1.5333333333333, 0.34, -0.1
4091, 1.5333333333333, 0.22, -0.1
4092, 1.6166666666667, 1.18, -0.1
4093, 1.6166666666667, 1.06, -0.1
4094, 1.6166666666667, 0.94, -0.1
4095, 1.6166666666667, 0.82, -0.1
4096, 1.6166666666667, 0.7, -0.1
4097, 1.6166666666667, 0.58, -0.1
4098, 1.6166666666667, 0.46, -0.1
4099, 1.6166666666667, 0.34, -0.1
4100, 1.6166666666667, 0.22, -0.1
4101, 1.7, 1.18, -0.1
4102, 1.7, 1.06, -0.1
4103, 1.7, 0.94, -0.1
4104, 1.7, 0.82, -0.1
4105, 1.7, 0.7, -0.1
4106, 1.7, 0.58, -0.1
4107, 1.7, 0.46, -0.1
4108, 1.7, 0.34, -0.1
4109, 1.7, 0.22, -0.1
4110, 1.7833333333333, 1.18, -0.1
4111, 1.7833333333333, 1.06, -0.1
4112, 1.7833333333333, 0.94, -0.1
4113, 1.7833333333333, 0.82, -0.1
4114, 1.7833333333333, 0.7, -0.1
4115, 1.7833333333333, 0.58, -0.1
4116, 1.7833333333333, 0.46, -0.1
4117, 1.7833333333333, 0.34, -0.1
4118, 1.7833333333333, 0.22, -0.1
4119, 1.8666666666667, 1.18, -0.1
4120, 1.8666666666667, 1.06, -0.1
4121, 1.8666666666667, 0.94, -0.1
4122, 1.8666666666667, 0.82, -0.1
4123, 1.8666666666667, 0.7, -0.1
4124, 1.8666666666667, 0.58, -0.1
4125, 1.8666666666667, 0.46, -0.1
4126, 1.8666666666667, 0.34, -0.1
4127, 1.8666666666667, 0.22, -0.1
4128, 1.95, 1.18, -0.1
4129, 1.95, 1.06, -0.1
4130, 1.95, 0.94, -0.1
4131, 1.95, 0.82, -0.1
4132, 1.95, 0.7, -0.1
4133, 1.95, 0.58, -0.1
4134, 1.95, 0.46, -0.1
4135, 1.95, 0.34, -0.1
4136, 1.95, 0.22, -0.1
4137, 2.0333333333333, 1.18, -0.1
4138, 2.0333333333333, 1.06, -0.1
4139, 2.0333333333333, 0.94, -0.1
4140, 2.0333333333333, 0.82, -0.1
4141, 2.0333333333333, 0.7, -0.1
4142, 2.0333333333333, 0.58, -0.1
4143, 2.0333333333333, 0.46, -0.1
4144, 2.0333333333333, 0.34, -0.1
4145, 2.0333333333333, 0.22, -0.1
4146, 2.1166666666667, 1.18, -0.1
4147, 2.1166666666667, 1.06, -0.1
4148, 2.1166666666667, 0.94, -0.1
4149, 2.1166666666667, 0.82, -0.1
4150, 2.1166666666667, 0.7, -0.1
4151, 2.1166666666667, 0.58, -0.1
4152, 2.1166666666667, 0.46, -0.1
4153, 2.1166666666667, 0.34, -0.1
4154, 2.1166666666667, 0.22, -0.1
4155, 0.083333333333333, 1.44, 0
4156, 0.083333333333333, 1.48, 0
4157, 0.083333333333333, 1.52, 0
4158, 0.083333333333333, 1.56, 0
4159, 0.16666666666667, 1.44, 0
4160, 0.16666666666667, 1.48, 0
4161, 0.16666666666667, 1.52, 0
4162, 0.16666666666667, 1.56, 0
4163, 0.25, 1.44, 0
4164, 0.25, 1.48, 0
4165, 0.25, 1.52, 0
4166, 0.25, 1.56, 0
4167, 0.33333333333333, 1.44, 0
4168, 0.33333333333333, 1.48, 0
4169, 0.33333333333333, 1.52, 0
4170, 0.33333333333333, 1.56, 0
4171, 0.41666666666667, 1.44, 0
4172, 0.41666666666667, 1.48, 0
4173, 0.41666666666667, 1.52, 0
4174, 0.41666666666667, 1.56, 0
4175, 0.5, 1.44, 0
4176, 0.5, 1.48, 0
4177, 0.5, 1.52, 0
4178, 0.5, 1.56, 0
4179, 0.58333333333333, 1.44, 0
4180, 0.58333333333333, 1.48, 0
4181, 0.58333333333333, 1.52, 0
4182, 0.58333333333333, 1.56, 0
4183, 0.66666666666667, 1.44, 0
4184, 0.66666666666667, 1.48, 0
4185, 0.66666666666667, 1.52, 0
4186, 0.66666666666667, 1.56, 0
4187, 0.75, 1.44, 0
4188, 0.75, 1.48, 0
4189, 0.75, 1.52, 0
4190, 0.75, 1.56, 0
4191, 0.83333333333333, 1.44, 0
4192, 0.83333333333333, 1.48, 0
4193, 0.83333333333333, 1.52, 0
4194, 0.83333333333333, 1.56, 0
4195, 0.91666666666667, 1.44, 0
4196, 0.91666666666667, 1.48, 0
4197, 0.91666666666667, 1.52, 0
4198, 0.91666666666667, 1.56, 0
4199, 1, 1.44, 0.05
4200, 1, 1.48, 0.05
4201, 1, 1.52, 0.05
4202, 1, 1.56, 0.05
4203, 1, 1.44, 0.1
4204, 1, 1.48, 0.1
4205, 1, 1.52, 0.1
4206, 1, 1.56, 0.1
4207, 1, 1.44, 0.15
4208, 1, 1.48, 0.15
4209, 1, 1.52, 0.15
4210, 1, 1.56, 0.15
4211, 1, 1.44, 0.2
4212, 1, 1.48, 0.2
4213, 1, 1.52, 0.2
4214, 1, 1.56, 0.2
4215, 1, 1.44, 0.25
4216, 1, 1.48, 0.25
4217, 1, 1.52, 0.25
4218, 1, 1.56, 0.25
4219, 1, 1.44, 0.3
4220, 1, 1.48, 0.3
4221, 1, 1.52, 0.3
4222, 1, 1.56, 0.3
4223, 1, 1.44, 0.35
4224, 1, 1.48, 0.35
4225, 1, 1.52, 0.35
4226, 1, 1.56, 0.35
4227, 1, 1.44, 0.4
4228, 1, 1.48, 0.4
4229, 1, 1.52, 0.4
4230, 1, 1.56, 0.4
4231, 1, 1.44, 0.45
4232, 1, 1.48, 0.45
4233, 1, 1.52, 0.45
4234, 1, 1.56, 0.45
4235, 0.083333333333333, 1.44, 0.5
4236, 0.083333333333333, 1.48, 0.5
4237, 0.083333333333333, 1.52, 0.5
4238, 0.083333333333333, 1.56, 0.5
4239, 0.16666666666667, 1.44, 0.5
4240, 0.16666666666667, 1.48, 0.5
4241, 0.16666666666667, 1.52, 0.5
4242, 0.16666666666667, 1.56, 0.5
4243, 0.25, 1.44, 0.5
4244, 0.25, 1.48, 0.5
4245, 0.25, 1.52, 0.5
4246, 0.25, 1.56, 0.5
4247, 0.33333333333333, 1.44, 0.5
4248, 0.33333333333333, 1.48, 0.5
4249, 0.33333333333333, 1.52, 0.5
4250, 0.33333333333333, 1.56, 0.5
4251, 0.41666666666667, 1.44, 0.5
4252, 0.41666666666667, 1.48, 0.5
4253, 0.41666666666667, 1.52, 0.5
4254, 0.41666666666667, 1.56, 0.5
4255, 0.5, 1.44, 0.5
4256, 0.5, 1.48, 0.5
4257, 0.5, 1.52, 0.5
4258, 0.5, 1.56, 0.5
4259, 0.58333333333333, 1.44, 0.5
4260, 0.58333333333333, 1.48, 0.5
4261, 0.58333333333333, 1.52, 0.5
4262, 0.58333333333333, 1.56, 0.5
4263, 0.66666666666667, 1.44, 0.5
4264, 0.66666666666667, 1.48, 0.5
4265, 0.66666666666667, 1.52, 0.5
4266, 0.66666666666667, 1.56, 0.5
4267, 0.75, 1.44, 0.5
4268, 0.75, 1.48, 0.5
4269, 0.75, 1.52, 0.5
4270, 0.75, 1.56, 0.5
4271, 0.83333333333333, 1.44, 0.5
4272, 0.83333333333333, 1.48, 0.5
4273, 0.83333333333333, 1.52, 0.5
4274, 0.83333333333333, 1.56, 0.5
4275, 0.91666666666667, 1.44, 0.5
4276, 0.91666666666667, 1.48, 0.5
4277, 0.91666666666667, 1.52, 0.5
4278, 0.91666666666667, 1.56, 0.5
4279, 0, 1.44, 0.05
4280, 0, 1.48, 0.05
4281, 0, 1.52, 0.05
4282, 0, 1.56, 0.05
4283, 0, 1.44, 0.1
4284, 0, 1.48, 0.1
4285, 0, 1.52, 0.1
4286, 0, 1.56, 0.1
4287, 0, 1.44, 0.15
4288, 0, 1.48, 0.15
4289, 0, 1.52, 0.15
4290, 0, 1.56, 0.15
4291, 0, 1.44, 0.2
4292, 0, 1.48, 0.2
4293, 0, 1.52, 0.2
4294, 0, 1.56, 0.2
4295, 0, 1.44, 0.25
4296, 0, 1.48, 0.25
4297, 0, 1.52, 0.25
4298, 0, 1.56, 0.25
4299, 0, 1.44, 0.3
4300, 0, 1.48, 0.3
4301, 0, 1.52, 0.3
4302, 0, 1.56, 0.3
4303, 0, 1.44, 0.35
4304, 0, 1.48, 0.35
4305, 0, 1.52, 0.35
4306, 0, 1.56, 0.35
4307, 0, 1.44, 0.4
4308, 0, 1.48, 0.4
4309, 0, 1.52, 0.4
4310, 0, 1.56, 0.4
4311, 0, 1.44, 0.45
4312, 0, 1.48, 0.45
4313, 0, 1.52, 0.45
4314, 0, 1.56, 0.45
4315, 0.083333333333333, 1.6, 0.05
4316, 0.083333333333333, 1.6, 0.1
4317, 0.083333333333333, 1.6, 0.15
4318, 0.083333333333333, 1.6, 0.2
4319, 0.083333333333333, 1.6, 0.25
4320, 0.083333333333333, 1.6, 0.3
4321, 0.083333333333333, 1.6, 0.35
4322, 0.083333333333333, 1.6, 0.4
4323, 0.083333333333333, 1.6, 0.45
4324, 0.16666666666667, 1.6, 0.05
4325, 0.16666666666667, 1.6, 0.1
4326, 0.16666666666667, 1.6, 0.15
4327, 0.16666666666667, 1.6, 0.2
4328, 0.16666666666667, 1.6, 0.25
4329, 0.16666666666667, 1.6, 0.3
4330, 0.16666666666667, 1.6, 0.35
4331, 0.16666666666667, 1.6, 0.4
4332, 0.16666666666667, 1.6, 0.45
4333, 0.25, 1.6, 0.05
4334, 0.25, 1.6, 0.1
4335, 0.25, 1.6, 0.15
4336, 0.25, 1.6, 0.2
4337, 0.25, 1.6, 0.25
4338, 0.25, 1.6, 0.3
4339, 0.25, 1.6, 0.35
4340, 0.25, 1.6, 0.4
4341, 0.25, 1.6, 0.45
4342, 0.33333333333333, 1.6, 0.05
4343, 0.33333333333333, 1.6, 0.1
4344, 0.33333333333333, 1.6, 0.15
4345, 0.33333333333333, 1.6, 0.2
4346, 0.33333333333333, 1.6, 0.25
4347, 0.33333333333333, 1.6, 0.3
4348, 0.33333333333333, 1.6, 0.35
4349, 0.33333333333333, 1.6, 0.4
4350, 0.33333333333333, 1.6, 0.45
4351, 0.41666666666667, 1.6, 0.05
4352, 0.41666666666667, 1.6, 0.1
4353, 0.41666666666667, 1.6, 0.15
4354, 0.41666666666667, 1.6, 0.2
4355, 0.41666666666667, 1.6, 0.25
4356, 0.41666666666667, 1.6, 0.3
4357, 0.41666666666667, 1.6, 0.35
4358, 0.41666666666667, 1.6, 0.4
4359, 0.41666666666667, 1.6, 0.45
4360, 0.5, 1.6, 0.05
4361, 0.5, 1.6, 0.1
4362, 0.5, 1.6, 0.15
4363, 0.5, 1.6, 0.2
4364, 0.5, 1.6, 0.25
4365, 0.5, 1.6, 0.3
4366, 0.5, 1.6, 0.35
4367, 0.5, 1.6, 0.4
4368, 0.5, 1.6, 0.45
4369, 0.58333333333333, 1.6, 0.05
4370, 0.58333333333333, 1.6, 0.1
4371, 0.58333333333333, 1.6, 0.15
4372, 0.58333333333333, 1.6, 0.2
4373, 0.58333333333333, 1.6, 0.25
4374, 0.58333333333333, 1.6, 0.3
4375, 0.58333333333333, 1.6, 0.35
4376, 0.58333333333333, 1.6, 0.4
4377, 0.58333333333333, 1.6, 0.45
4378, 0.66666666666667, 1.6, 0.05
4379, 0.66666666666667, 1.6, 0.1
4380, 0.66666666666667, 1.6, 0.15
4381, 0.66666666666667, 1.6, 0.2
4382, 0.66666666666667, 1.6, 0.25
4383, 0.66666666666667, 1.6, 0.3
4384, 0.66666666666667, 1.6, 0.35
4385, 0.66666666666667, 1.6, 0.4
4386, 0.66666666666667, 1.6, 0.45
4387, 0.75, 1.6, 0.05
4388, 0.75, 1.6, 0.1
4389, 0.75, 1.6, 0.15
4390, 0.75, 1.6, 0.2
4391, 0.75, 1.6, 0.25
4392, 0.75, 1.6, 0.3
4393, 0.75, 1.6, 0.35
4394, 0.75, 1.6, 0.4
4395, 0.75, 1.6, 0.45
4396, 0.83333333333333, 1.6, 0.05
4397, 0.83333333333333, 1.6, 0.1
4398, 0.83333333333333, 1.6, 0.15
4399, 0.83333333333333, 1.6, 0.2
4400, 0.83333333333333, 1.6, 0.25
4401, 0.83333333333333, 1.6, 0.3
4402, 0.83333333333333, 1.6, 0.35
4403, 0.83333333333333, 1.6, 0.4
4404, 0.83333333333333, 1.6, 0.45
4405, 0.91666666666667, 1.6, 0.05
4406, 0.91666666666667, 1.6, 0.1
4407, 0.91666666666667, 1.6, 0.15
4408, 0.91666666666667, 1.6, 0.2
4409, 0.91666666666667, 1.6, 0.25
4410, 0.91666666666667, 1.6, 0.3
4411, 0.91666666666667, 1.6, 0.35
4412, 0.91666666666667, 1.6, 0.4
4413, 0.91666666666667, 1.6, 0.45
4414, 1.0285714285714, 1.44, 0.5
4415, 1.0285714285714, 1.48, 0.5
4416, 1.0285714285714, 1.52, 0.5
4417, 1.0285714285714, 1.56, 0.5
4418, 1.0571428571429, 1.44, 0.5
4419, 1.0571428571429, 1.48, 0.5
4420, 1.0571428571429, 1.52, 0.5
4421, 1.0571428571429, 1.56, 0.5
4422, 1.0857142857143, 1.44, 0.5
4423, 1.0857142857143, 1.48, 0.5
4424, 1.0857142857143, 1.52, 0.5
4425, 1.0857142857143, 1.56, 0.5
4426, 1.1142857142857, 1.44, 0.5
4427, 1.1142857142857, 1.48, 0.5
4428, 1.1142857142857, 1.52, 0.5
4429, 1.1142857142857, 1.56, 0.5
4430, 1.1428571428571, 1.44, 0.5
4431, 1.1428571428571, 1.48, 0.5
4432, 1.1428571428571, 1.52, 0.5
4433, 1.1428571428571, 1.56, 0.5
4434, 1.1714285714286, 1.44, 0.5
4435, 1.1714285714286, 1.48, 0.5
4436, 1.1714285714286, 1.52, 0.5
4437, 1.1714285714286, 1.56, 0.5
4438, 1.0285714285714, 1.44, 0
4439, 1.0285714285714, 1.48, 0
4440, 1.0285714285714, 1.52, 0
4441, 1.0285714285714, 1.56, 0
4442, 1.0571428571429, 1.44, 0
4443, 1.0571428571429, 1.48, 0
4444, 1.0571428571429, 1.52, 0
4445, 1.0571428571429, 1.56, 0
4446, 1.0857142857143, 1.44, 0
4447, 1.0857142857143, 1.48, 0
4448, 1.0857142857143, 1.52, 0
4449, 1.0857142857143, 1.56, 0
4450, 1.1142857142857, 1.44, 0
4451, 1.1142857142857, 1.48, 0
4452, 1.1142857142857, 1.52, 0
4453, 1.1142857142857, 1.56, 0
4454, 1.1428571428571, 1.44, 0
4455, 1.1428571428571, 1.48, 0
4456, 1.1428571428571, 1.52, 0
4457, 1.1428571428571, 1.56, 0
4458, 1.1714285714286, 1.44, 0
4459, 1.1714285714286, 1.48, 0
4460, 1.1714285714286, 1.52, 0
4461, 1.1714285714286, 1.56, 0
4462, 1.2, 1.44, 0.05
4463, 1.2, 1.48, 0.05
4464, 1.2, 1.52, 0.05
4465, 1.2, 1.56, 0.05
4466, 1.2, 1.44, 0.1
4467, 1.2, 1.48, 0.1
4468, 1.2, 1.52, 0.1
4469, 1.2, 1.56, 0.1
4470, 1.2, 1.44, 0.15
4471, 1.2, 1.48, 0.15
4472, 1.2, 1.52, 0.15
4473, 1.2, 1.56, 0.15
4474, 1.2, 1.44, 0.2
4475, 1.2, 1.48, 0.2
4476, 1.2, 1.52, 0.2
4477, 1.2, 1.56, 0.2
4478, 1.2, 1.44, 0.25
4479, 1.2, 1.48, 0.25
4480, 1.2, 1.52, 0.25
4481, 1.2, 1.56, 0.25
4482, 1.2, 1.44, 0.3
4483, 1.2, 1.48, 0.3
4484, 1.2, 1.52, 0.3
4485, 1.2, 1.56, 0.3
4486, 1.2, 1.44, 0.35
4487, 1.2, 1.48, 0.35
4488, 1.2, 1.52, 0.35
4489, 1.2, 1.56, 0.35
4490, 1.2, 1.44, 0.4
4491, 1.2, 1.48, 0.4
4492, 1.2, 1.52, 0.4
4493, 1.2, 1.56, 0.4
4494, 1.2, 1.44, 0.45
4495, 1.2, 1.48, 0.45
4496, 1.2, 1.52, 0.45
4497, 1.2, 1.56, 0.45
4498, 1.0285714285714, 1.6, 0.05
4499, 1.0571428571429, 1.6, 0.05
4500, 1.0857142857143, 1.6, 0.05
4501, 1.1142857142857, 1.6, 0.05
4502, 1.1428571428571, 1.6, 0.05
4503, 1.1714285714286, 1.6, 0.05
4504, 1.0285714285714, 1.6, 0.1
4505, 1.0571428571429, 1.6, 0.1
4506, 1.0857142857143, 1.6, 0.1
4507, 1.1142857142857, 1.6, 0.1
4508, 1.1428571428571, 1.6, 0.1
4509, 1.1714285714286, 1.6, 0.1
4510, 1.0285714285714, 1.6, 0.15
4511, 1.0571428571429, 1.6, 0.15
4512, 1.0857142857143, 1.6, 0.15
4513, 1.1142857142857, 1.6, 0.15
4514, 1.1428571428571, 1.6, 0.15
4515, 1.1714285714286, 1.6, 0.15
4516, 1.0285714285714, 1.6, 0.2
4517, 1.0571428571429, 1.6, 0.2
4518, 1.0857142857143, 1.6, 0.2
4519, 1.1142857142857, 1.6, 0.2
4520, 1.1428571428571, 1.6, 0.2
4521, 1.1714285714286, 1.6, 0.2
4522, 1.0285714285714, 1.6, 0.25
4523, 1.0571428571429, 1.6, 0.25
4524, 1.0857142857143, 1.6, 0.25
4525, 1.1142857142857, 1.6, 0.25
4526, 1.1428571428571, 1.6, 0.25
4527, 1.1714285714286, 1.6, 0.25
4528, 1.0285714285714, 1.6, 0.3
4529, 1.0571428571429, 1.6, 0.3
4530, 1.0857142857143, 1.6, 0.3
4531, 1.1142857142857, 1.6, 0.3
4532, 1.1428571428571, 1.6, 0.3
4533, 1.1714285714286, 1.6, 0.3
4534, 1.0285714285714, 1.6, 0.35
4535, 1.0571428571429, 1.6, 0.35
4536, 1.0857142857143, 1.6, 0.35
4537, 1.1142857142857, 1.6, 0.35
4538, 1.1428571428571, 1.6, 0.35
4539, 1.1714285714286, 1.6, 0.35
4540, 1.0285714285714, 1.6, 0.4
4541, 1.0571428571429, 1.6, 0.4
4542, 1.0857142857143, 1.6, 0.4
4543, 1.1142857142857, 1.6, 0.4
4544, 1.1428571428571, 1.6, 0.4
4545, 1.1714285714286, 1.6, 0.4
4546, 1.0285714285714, 1.6, 0.45
4547, 1.0571428571429, 1.6, 0.45
4548, 1.0857142857143, 1.6, 0.45
4549, 1.1142857142857, 1.6, 0.45
4550, 1.1428571428571, 1.6, 0.45
4551, 1.1714285714286, 1.6, 0.45
4552, 1.2833333333333, 1.44, 0.5
4553, 1.2833333333333, 1.48, 0.5
4554, 1.2833333333333, 1.52, 0.5
4555, 1.2833333333333, 1.56, 0.5
4556, 1.3666666666667, 1.44, 0.5
4557, 1.3666666666667, 1.48, 0.5
4558, 1.3666666666667, 1.52, 0.5
4559, 1.3666666666667, 1.56, 0.5
4560, 1.45, 1.44, 0.5
4561, 1.45, 1.48, 0.5
4562, 1.45, 1.52, 0.5
4563, 1.45, 1.56, 0.5
4564, 1.5333333333333, 1.44, 0.5
4565, 1.5333333333333, 1.48, 0.5
4566, 1.5333333333333, 1.52, 0.5
4567, 1.5333333333333, 1.56, 0.5
4568, 1.6166666666667, 1.44, 0.5
4569, 1.6166666666667, 1.48, 0.5
4570, 1.6166666666667, 1.52, 0.5
4571, 1.6166666666667, 1.56, 0.5
4572, 1.7, 1.44, 0.5
4573, 1.7, 1.48, 0.5
4574, 1.7, 1.52, 0.5
4575, 1.7, 1.56, 0.5
4576, 1.7833333333333, 1.44, 0.5
4577, 1.7833333333333, 1.48, 0.5
4578, 1.7833333333333, 1.52, 0.5
4579, 1.7833333333333, 1.56, 0.5
4580, 1.8666666666667, 1.44, 0.5
4581, 1.8666666666667, 1.48, 0.5
4582, 1.8666666666667, 1.52, 0.5
4583, 1.8666666666667, 1.56, 0.5
4584, 1.95, 1.44, 0.5
4585, 1.95, 1.48, 0.5
4586, 1.95, 1.52, 0.5
4587, 1.95, 1.56, 0.5
4588, 2.0333333333333, 1.44, 0.5
4589, 2.0333333333333, 1.48, 0.5
4590, 2.0333333333333, 1.52, 0.5
4591, 2.0333333333333, 1.56, 0.5
4592, 2.1166666666667, 1.44, 0.5
4593, 2.1166666666667, 1.48, 0.5
4594, 2.1166666666667, 1.52, 0.5
4595, 2.1166666666667, 1.56, 0.5
4596, 1.2833333333333, 1.44, 0
4597, 1.2833333333333, 1.48, 0
4598, 1.2833333333333, 1.52, 0
4599, 1.2833333333333, 1.56, 0
4600, 1.3666666666667, 1.44, 0
4601, 1.3666666666667, 1.48, 0
4602, 1.3666666666667, 1.52, 0
4603, 1.3666666666667, 1.56, 0
4604, 1.45, 1.44, 0
4605, 1.45, 1.48, 0
4606, 1.45, 1.52, 0
4607, 1.45, 1.56, 0
4608, 1.5333333333333, 1.44, 0
4609, 1.5333333333333, 1.48, 0
4610, 1.5333333333333, 1.52, 0
4611, 1.5333333333333, 1.56, 0
4612, 1.6166666666667, 1.44, 0
4613, 1.6166666666667, 1.48, 0
4614, 1.6166666666667, 1.52, 0
4615, 1.6166666666667, 1.56, 0
4616, 1.7, 1.44, 0
4617, 1.7, 1.48, 0
4618, 1.7, 1.52, 0
4619, 1.7, 1.56, 0
4620, 1.7833333333333, 1.44, 0
4621, 1.7833333333333, 1.48, 0
4622, 1.7833333333333, 1.52, 0
4623, 1.7833333333333, 1.56, 0
4624, 1.8666666666667, 1.44, 0
4625, 1.8666666666667, 1.48, 0
4626, 1.8666666666667, 1.52, 0
4627, 1.8666666666667, 1.56, 0
4628, 1.95, 1.44, 0
4629, 1.95, 1.48, 0
4630, 1.95, 1.52, 0
4631, 1.95, 1.56, 0
4632, 2.0333333333333, 1.44, 0
4633, 2.0333333333333, 1.48, 0
4634, 2.0333333333333, 1.52, 0
4635, 2.0333333333333, 1.56, 0
4636, 2.1166666666667, 1.44, 0
4637, 2.1166666666667, 1.48, 0
4638, 2.1166666666667, 1.52, 0
4639, 2.1166666666667, 1.56, 0
4640, 2.2, 1.44, 0.05
4641, 2.2, 1.48, 0.05
4642, 2.2, 1.52, 0.05
4643, 2.2, 1.56, 0.05
4644, 2.2, 1.44, 0.1
4645, 2.2, 1.48, 0.1
4646, 2.2, 1.52, 0.1
4647, 2.2, 1.56, 0.1
4648, 2.2, 1.44, 0.15
4649, 2.2, 1.48, 0.15
4650, 2.2, 1.52, 0.15
4651, 2.2, 1.56, 0.15
4652, 2.2, 1.44, 0.2
4653, 2.2, 1.48, 0.2
4654, 2.2, 1.52, 0.2
4655, 2.2, 1.56, 0.2
4656, 2.2, 1.44, 0.25
4657, 2.2, 1.48, 0.25
4658, 2.2, 1.52, 0.25
4659, 2.2, 1.56, 0.25
4660, 2.2, 1.44, 0.3
4661, 2.2, 1.48, 0.3
4662, 2.2, 1.52, 0.3
4663, 2.2, 1.56, 0.3
4664, 2.2, 1.44, 0.35
4665, 2.2, 1.48, 0.35
4666, 2.2, 1.52, 0.35
4667, 2.2, 1.56, 0.35
4668, 2.2, 1.44, 0.4
4669, 2.2, 1.48, 0.4
4670, 2.2, 1.52, 0.4
4671, 2.2, 1.56, 0.4
4672, 2.2, 1.44, 0.45
4673, 2.2, 1.48, 0.45
4674, 2.2, 1.52, 0.45
4675, 2.2, 1.56, 0.45
4676, 1.2833333333333, 1.6, 0.05
4677, 1.3666666666667, 1.6, 0.05
4678, 1.45, 1.6, 0.05
4679, 1.5333333333333, 1.6, 0.05
4680, 1.6166666666667, 1.6, 0.05
4681, 1.7, 1.6, 0.05
4682, 1.7833333333333, 1.6, 0.05
4683, 1.8666666666667, 1.6, 0.05
4684, 1.95, 1.6, 0.05
4685, 2.0333333333333, 1.6, 0.05
4686, 2.1166666666667, 1.6, 0.05
4687, 1.2833333333333, 1.6, 0.1
4688, 1.3666666666667, 1.6, 0.1
4689, 1.45, 1.6, 0.1
4690, 1.5333333333333, 1.6, 0.1
4691, 1.6166666666667, 1.6, 0.1
4692, 1.7, 1.6, 0.1
4693, 1.7833333333333, 1.6, 0.1
4694, 1.8666666666667, 1.6, 0.1
4695, 1.95, 1.6, 0.1
4696, 2.0333333333333, 1.6, 0.1
4697, 2.1166666666667, 1.6, 0.1
4698, 1.2833333333333, 1.6, 0.15
4699, 1.3666666666667, 1.6, 0.15
4700, 1.45, 1.6, 0.15
4701, 1.5333333333333, 1.6, 0.15
4702, 1.6166666666667, 1.6, 0.15
4703, 1.7, 1.6, 0.15
4704, 1.7833333333333, 1.6, 0.15
4705, 1.8666666666667, 1.6, 0.15
4706, 1.95, 1.6, 0.15
4707, 2.0333333333333, 1.6, 0.15
4708, 2.1166666666667, 1.6, 0.15
4709, 1.2833333333333, 1.6, 0.2
4710, 1.3666666666667, 1.6, 0.2
4711, 1.45, 1.6, 0.2
4712, 1.5333333333333, 1.6, 0.2
4713, 1.6166666666667, 1.6, 0.2
4714, 1.7, 1.6, 0.2
4715, 1.7833333333333, 1.6, 0.2
4716, 1.8666666666667, 1.6, 0.2
4717, 1.95, 1.6, 0.2
4718, 2.0333333333333, 1.6, 0.2
4719, 2.1166666666667, 1.6, 0.2
4720, 1.2833333333333, 1.6, 0.25
4721, 1.3666666666667, 1.6, 0.25
4722, 1.45, 1.6, 0.25
4723, 1.5333333333333, 1.6, 0.25
4724, 1.6166666666667, 1.6, 0.25
4725, 1.7, 1.6, 0.25
4726, 1.7833333333333, 1.6, 0.25
4727, 1.8666666666667, 1.6, 0.25
4728, 1.95, 1.6, 0.25
4729, 2.0333333333333, 1.6, 0.25
4730, 2.1166666666667, 1.6, 0.25
4731, 1.2833333333333, 1.6, 0.3
4732, 1.3666666666667, 1.6, 0.3
4733, 1.45, 1.6, 0.3
4734, 1.5333333333333, 1.6, 0.3
4735, 1.6166666666667, 1.6, 0.3
4736, 1.7, 1.6, 0.3
4737, 1.7833333333333, 1.6, 0.3
4738, 1.8666666666667, 1.6, 0.3
4739, 1.95, 1.6, 0.3
4740, 2.0333333333333, 1.6, 0.3
4741, 2.1166666666667, 1.6, 0.3
4742, 1.2833333333333, 1.6, 0.35
4743, 1.3666666666667, 1.6, 0.35
4744, 1.45, 1.6, 0.35
4745, 1.5333333333333, 1.6, 0.35
4746, 1.6166666666667, 1.6, 0.35
4747, 1.7, 1.6, 0.35
4748, 1.7833333333333, 1.6, 0.35
4749, 1.8666666666667, 1.6, 0.35
4750, 1.95, 1.6, 0.35
4751, 2.0333333333333, 1.6, 0.35
4752, 2.1166666666667, 1.6, 0.35
4753, 1.2833333333333, 1.6, 0.4
4754, 1.3666666666667, 1.6, 0.4
4755, 1.45, 1.6, 0.4
4756, 1.5333333333333, 1.6, 0.4
4757, 1.6166666666667, 1.6, 0.4
4758, 1.7, 1.6, 0.4
4759, 1.7833333333333, 1.6, 0.4
4760, 1.8666666666667, 1.6, 0.4
4761, 1.95, 1.6, 0.4
4762, 2.0333333333333, 1.6, 0.4
4763, 2.1166666666667, 1.6, 0.4
4764, 1.2833333333333, 1.6, 0.45
4765, 1.3666666666667, 1.6, 0.45
4766, 1.45, 1.6, 0.45
4767, 1.5333333333333, 1.6, 0.45
4768, 1.6166666666667, 1.6, 0.45
4769, 1.7, 1.6, 0.45
4770, 1.7833333333333, 1.6, 0.45
4771, 1.8666666666667, 1.6, 0.45
4772, 1.95, 1.6, 0.45
4773, 2.0333333333333, 1.6, 0.45
4774, 2.1166666666667, 1.6, 0.45
4775, 0.083333333333333, -0.04, 0
4776, 0.083333333333333, -0.08, 0
4777, 0.083333333333333, -0.12, 0
4778, 0.083333333333333, -0.16, 0
4779, 0.16666666666667, -0.04, 0
4780, 0.16666666666667, -0.08, 0
4781, 0.16666666666667, -0.12, 0
4782, 0.16666666666667, -0.16, 0
4783, 0.25, -0.04, 0
4784, 0.25, -0.08, 0
4785, 0.25, -0.12, 0
4786, 0.25, -0.16, 0
4787, 0.33333333333333, -0.04, 0
4788, 0.33333333333333, -0.08, 0
4789, 0.33333333333333, -0.12, 0
4790, 0.33333333333333, -0.16, 0
4791, 0.41666666666667, -0.04, 0
4792, 0.41666666666667, -0.08, 0
4793, 0.41666666666667, -0.12, 0
4794, 0.41666666666667, -0.16, 0
4795, 0.5, -0.04, 0
4796, 0.5, -0.08, 0
4797, 0.5, -0.12, 0
4798, 0.5, -0.16, 0
4799, 0.58333333333333, -0.04, 0
4800, 0.58333333333333, -0.08, 0
4801, 0.58333333333333, -0.12, 0
4802, 0.58333333333333, -0.16, 0
4803, 0.66666666666667, -0.04, 0
4804, 0.66666666666667, -0.08, 0
4805, 0.66666666666667, -0.12, 0
4806, 0.66666666666667, -0.16, 0
4807, 0.75, -0.04, 0
4808, 0.75, -0.08, 0
4809, 0.75, -0.12, 0
4810, 0.75, -0.16, 0
4811, 0.83333333333333, -0.04, 0
4812, 0.83333333333333, -0.08, 0
4813, 0.83333333333333, -0.12, 0
4814, 0.83333333333333, -0.16, 0
4815, 0.91666666666667, -0.04, 0
4816, 0.91666666666667, -0.08, 0
4817, 0.91666666666667, -0.12, 0
4818, 0.91666666666667, -0.16, 0
4819, 1, -0.04, 0.05
4820, 1, -0.08, 0.05
4821, 1, -0.12, 0.05
4822, 1, -0.16, 0.05
4823, 1, -0.04, 0.1
4824, 1, -0.08, 0.1
4825, 1, -0.12, 0.1
4826, 1, -0.16, 0.1
4827, 1, -0.04, 0.15
4828, 1, -0.08, 0.15
4829, 1, -0.12, 0.15
4830, 1, -0.16, 0.15
4831, 1, -0.04, 0.2
4832, 1, -0.08, 0.2
4833, 1, -0.12, 0.2
4834, 1, -0.16, 0.2
4835, 1, -0.04, 0.25
4836, 1, -0.08, 0.25
4837, 1, -0.12, 0.25
4838, 1, -0.16, 0.25
4839, 1, -0.04, 0.3
4840, 1, -0.08, 0.3
4841, 1, -0.12, 0.3
4842, 1, -0.16, 0.3
4843, 1, -0.04, 0.35
4844, 1, -0.08, 0.35
4845, 1, -0.12, 0.35
4846, 1, -0.16, 0.35
4847, 1, -0.04, 0.4
4848, 1, -0.08, 0.4
4849, 1, -0.12, 0.4
4850, 1, -0.16, 0.4
4851, 1, -0.04, 0.45
4852, 1, -0.08, 0.45
4853, 1, -0.12, 0.45
4854, 1, -0.16, 0.45
4855, 0.083333333333333, -0.04, 0.5
4856, 0.083333333333333, -0.08, 0.5
4857, 0.083333333333333, -0.12, 0.5
4858, 0.083333333333333, -0.16, 0.5
4859, 0.16666666666667, -0.04, 0.5
4860, 0.16666666666667, -0.08, 0.5
4861, 0.16666666666667, -0.12, 0.5
4862, 0.16666666666667, -0.16, 0.5
4863, 0.25, -0.04, 0.5
4864, 0.25, -0.08, 0.5
4865, 0.25, -0.12, 0.5
4866, 0.25, -0.16, 0.5
4867, 0.33333333333333, -0.04, 0.5
4868, 0.33333333333333, -0.08, 0.5
4869, 0.33333333333333, -0.12, 0.5
4870, 0.33333333333333, -0.16, 0.5
4871, 0.41666666666667, -0.04, 0.5
4872, 0.41666666666667, -0.08, 0.5
4873, 0.41666666666667, -0.12, 0.5
4874, 0.41666666666667, -0.16, 0.5
4875, 0.5, -0.04, 0.5
4876, 0.5, -0.08, 0.5
4877, 0.5, -0.12, 0.5
4878, 0.5, -0.16, 0.5
4879, 0.58333333333333, -0.04, 0.5
4880, 0.58333333333333, -0.08, 0.5
4881, 0.58333333333333, -0.12, 0.5
4882, 0.58333333333333, -0.16, 0.5
4883, 0.66666666666667, -0.04, 0.5
4884, 0.66666666666667, -0.08, 0.5
4885, 0.66666666666667, -0.12, 0.5
4886, 0.66666666666667, -0.16, 0.5
4887, 0.75, -0.04, 0.5
4888, 0.75, -0.08, 0.5
4889, 0.75, -0.12, 0.5
4890, 0.75, -0.16, 0.5
4891, 0.83333333333333, -0.04, 0.5
4892, 0.83333333333333, -0.08, 0.5
4893, 0.83333333333333, -0.12, 0.5
4894, 0.83333333333333, -0.16, 0.5
4895, 0.91666666666667, -0.04, 0.5
4896, 0.91666666666667, -0.08, 0.5
4897, 0.91666666666667, -0.12, 0.5
4898, 0.91666666666667, -0.16, 0.5
4899, 0, -0.04, 0.05
4900, 0, -0.08, 0.05
4901, 0, -0.12, 0.05
4902, 0, -0.16, 0.05
4903, 0, -0.04, 0.1
4904, 0, -0.08, 0.1
4905, 0, -0.12, 0.1
4906, 0, -0.16, 0.1
4907, 0, -0.04, 0.15
4908, 0, -0.08, 0.15
4909, 0, -0.12, 0.15
4910, 0, -0.16, 0.15
4911, 0, -0.04, 0.2
4912, 0, -0.08, 0.2
4913, 0, -0.12, 0.2
4914, 0, -0.16, 0.2
4915, 0, -0.04, 0.25
4916, 0, -0.08, 0.25
4917, 0, -0.12, 0.25
4918, 0, -0.16, 0.25
4919, 0, -0.04, 0.3
4920, 0, -0.08, 0.3
4921, 0, -0.12, 0.3
4922, 0, -0.16, 0.3
4923, 0, -0.04, 0.35
4924, 0, -0.08, 0.35
4925, 0, -0.12, 0.35
4926, 0, -0.16, 0.35
4927, 0, -0.04, 0.4
4928, 0, -0.08, 0.4
4929, 0, -0.12, 0.4
4930, 0, -0.16, 0.4
4931, 0, -0.04, 0.45
4932, 0, -0.08, 0.45
4933, 0, -0.12, 0.45
4934, 0, -0.16, 0.45
4935, 0.083333333333333, -0.2, 0.05
4936, 0.083333333333333, -0.2, 0.1
4937, 0.083333333333333, -0.2, 0.15
4938, 0.083333333333333, -0.2, 0.2
4939, 0.083333333333333, -0.2, 0.25
4940, 0.083333333333333, -0.2, 0.3
4941, 0.083333333333333, -0.2, 0.35
4942, 0.083333333333333, -0.2, 0.4
4943, 0.083333333333333, -0.2, 0.45
4944, 0.16666666666667, -0.2, 0.05
4945, 0.16666666666667, -0.2, 0.1
4946, 0.16666666666667, -0.2, 0.15
4947, 0.16666666666667, -0.2, 0.2
4948, 0.16666666666667, -0.2, 0.25
4949, 0.16666666666667, -0.2, 0.3
4950, 0.16666666666667, -0.2, 0.35
4951, 0.16666666666667, -0.2, 0.4
4952, 0.16666666666667, -0.2, 0.45
4953, 0.25, -0.2, 0.05
4954, 0.25, -0.2, 0.1
4955, 0.25, -0.2, 0.15
4956, 0.25, -0.2, 0.2
4957, 0.25, -0.2, 0.25
4958, 0.25, -0.2, 0.3
4959, 0.25, -0.2, 0.35
4960, 0.25, -0.2, 0.4
4961, 0.25, -0.2, 0.45
4962, 0.33333333333333, -0.2, 0.05
4963, 0.33333333333333, -0.2, 0.1
4964, 0.33333333333333, -0.2, 0.15
4965, 0.33333333333333, -0.2, 0.2
4966, 0.33333333333333, -0.2, 0.25
4967, 0.33333333333333, -0.2, 0.3
4968, 0.33333333333333, -0.2, 0.35
4969, 0.33333333333333, -0.2, 0.4
4970, 0.33333333333333, -0.2, 0.45
4971, 0.41666666666667, -0.2, 0.05
4972, 0.41666666666667, -0.2, 0.1
4973, 0.41666666666667, -0.2, 0.15
4974, 0.41666666666667, -0.2, 0.2
4975, 0.41666666666667, -0.2, 0.25
4976, 0.41666666666667, -0.2, 0.3
4977, 0.41666666666667, -0.2, 0.35
4978, 0.41666666666667, -0.2, 0.4
4979, 0.41666666666667, -0.2, 0.45
4980, 0.5, -0.2, 0.05
4981, 0.5, -0.2, 0.1
4982, 0.5, -0.2, 0.15
4983, 0.5, -0.2, 0.2
4984, 0.5, -0.2, 0.25
4985, 0.5, -0.2, 0.3
4986, 0.5, -0.2, 0.35
4987, 0.5, -0.2, 0.4
4988, 0.5, -0.2, 0.45
4989, 0.58333333333333, -0.2, 0.05
4990, 0.58333333333333, -0.2, 0.1
4991, 0.58333333333333, -0.2, 0.15
4992, 0.58333333333333, -0.2, 0.2
4993, 0.58333333333333, -0.2, 0.25
4994, 0.58333333333333, -0.2, 0.3
4995, 0.58333333333333, -0.2, 0.35
4996, 0.58333333333333, -0.2, 0.4
4997, 0.58333333333333, -0.2, 0.45
4998, 0.66666666666667, -0.2, 0.05
4999, 0.66666666666667, -0.2, 0.1
5000, 0.66666666666667, -0.2, 0.15
5001, 0.66666666666667, -0.2, 0.2
5002, 0.66666666666667, -0.2, 0.25
5003, 0.66666666666667, -0.2, 0.3
5004, 0.66666666666667, -0.2, 0.35
5005, 0.66666666666667, -0.2, 0.4
5006, 0.66666666666667, -0.2, 0.45
5007, 0.75, -0.2, 0.05
5008, 0.75, -0.2, 0.1
5009, 0.75, -0.2, 0.15
5010, 0.75, -0.2, 0.2
5011, 0.75, -0.2, 0.25
5012, 0.75, -0.2, 0.3
5013, 0.75, -0.2, 0.35
5014, 0.75, -0.2, 0.4
5015, 0.75, -0.2, 0.45
5016, 0.83333333333333, -0.2, 0.05
5017, 0.83333333333333, -0.2, 0.1
5018, 0.83333333333333, -0.2, 0.15
5019, 0.83333333333333, -0.2, 0.2
5020, 0.83333333333333, -0.2, 0.25
5021, 0.83333333333333, -0.2, 0.3
5022, 0.83333333333333, -0.2, 0.35
5023, 0.83333333333333, -0.2, 0.4
5024, 0.83333333333333, -0.2, 0.45
5025, 0.91666666666667, -0.2, 0.05
5026, 0.91666666666667, -0.2, 0.1
5027, 0.91666666666667, -0.2, 0.15
5028, 0.91666666666667, -0.2, 0.2
5029, 0.91666666666667, -0.2, 0.25
5030, 0.91666666666667, -0.2, 0.3
5031, 0.91666666666667, -0.2, 0.35
5032, 0.91666666666667, -0.2, 0.4
5033, 0.91666666666667, -0.2, 0.45
5034, -0.1, -0.04, 0.05
5035, -0.1, -0.08, 0.05
5036, -0.1, -0.12, 0.05
5037, -0.1, -0.16, 0.05
5038, -0.1, -0.04, 0.1
5039, -0.1, -0.08, 0.1
5040, -0.1, -0.12, 0.1
5041, -0.1, -0.16, 0.1
5042, -0.1, -0.04, 0.15
5043, -0.1, -0.08, 0.15
5044, -0.1, -0.12, 0.15
5045, -0.1, -0.16, 0.15
5046, -0.1, -0.04, 0.2
5047, -0.1, -0.08, 0.2
5048, -0.1, -0.12, 0.2
5049, -0.1, -0.16, 0.2
5050, -0.1, -0.04, 0.25
5051, -0.1, -0.08, 0.25
5052, -0.1, -0.12, 0.25
5053, -0.1, -0.16, 0.25
5054, -0.1, -0.04, 0.3
5055, -0.1, -0.08, 0.3
5056, -0.1, -0.12, 0.3
5057, -0.1, -0.16, 0.3
5058, -0.1, -0.04, 0.35
5059, -0.1, -0.08, 0.35
5060, -0.1, -0.12, 0.35
5061, -0.1, -0.16, 0.35
5062, -0.1, -0.04, 0.4
5063, -0.1, -0.08, 0.4
5064, -0.1, -0.12, 0.4
5065, -0.1, -0.16, 0.4
5066, -0.1, -0.04, 0.45
5067, -0.1, -0.08, 0.45
5068, -0.1, -0.12, 0.45
5069, -0.1, -0.16, 0.45
5070, 1.2833333333333, -0.04, 0.5
5071, 1.2833333333333, -0.08, 0.5
5072, 1.2833333333333, -0.12, 0.5
5073, 1.2833333333333, -0.16, 0.5
5074, 1.3666666666667, -0.04, 0.5
5075, 1.3666666666667, -0.08, 0.5
5076, 1.3666666666667, -0.12, 0.5
5077, 1.3666666666667, -0.16, 0.5
5078, 1.45, -0.04, 0.5
5079, 1.45, -0.08, 0.5
5080, 1.45, -0.12, 0.5
5081, 1.45, -0.16, 0.5
5082, 1.5333333333333, -0.04, 0.5
5083, 1.5333333333333, -0.08, 0.5
5084, 1.5333333333333, -0.12, 0.5
5085, 1.5333333333333, -0.16, 0.5
5086, 1.6166666666667, -0.04, 0.5
5087, 1.6166666666667, -0.08, 0.5
5088, 1.6166666666667, -0.12, 0.5
5089, 1.6166666666667, -0.16, 0.5
5090, 1.7, -0.04, 0.5
5091, 1.7, -0.08, 0.5
5092, 1.7, -0.12, 0.5
5093, 1.7, -0.16, 0.5
5094, 1.7833333333333, -0.04, 0.5
5095, 1.7833333333333, -0.08, 0.5
5096, 1.7833333333333, -0.12, 0.5
5097, 1.7833333333333, -0.16, 0.5
5098, 1.8666666666667, -0.04, 0.5
5099, 1.8666666666667, -0.08, 0.5
5100, 1.8666666666667, -0.12, 0.5
5101, 1.8666666666667, -0.16, 0.5
5102, 1.95, -0.04, 0.5
5103, 1.95, -0.08, 0.5
5104, 1.95, -0.12, 0.5
5105, 1.95, -0.16, 0.5
5106, 2.0333333333333, -0.04, 0.5
5107, 2.0333333333333, -0.08, 0.5
5108, 2.0333333333333, -0.12, 0.5
5109, 2.0333333333333, -0.16, 0.5
5110, 2.1166666666667, -0.04, 0.5
5111, 2.1166666666667, -0.08, 0.5
5112, 2.1166666666667, -0.12, 0.5
5113, 2.1166666666667, -0.16, 0.5
5114, 1.2833333333333, -0.04, 0
5115, 1.2833333333333, -0.08, 0
5116, 1.2833333333333, -0.12, 0
5117, 1.2833333333333, -0.16, 0
5118, 1.3666666666667, -0.04, 0
5119, 1.3666666666667, -0.08, 0
5120, 1.3666666666667, -0.12, 0
5121, 1.3666666666667, -0.16, 0
5122, 1.45, -0.04, 0
5123, 1.45, -0.08, 0
5124, 1.45, -0.12, 0
5125, 1.45, -0.16, 0
5126, 1.5333333333333, -0.04, 0
5127, 1.5333333333333, -0.08, 0
5128, 1.5333333333333, -0.12, 0
5129, 1.5333333333333, -0.16, 0
5130, 1.6166666666667, -0.04, 0
5131, 1.6166666666667, -0.08, 0
5132, 1.6166666666667, -0.12, 0
5133, 1.6166666666667, -0.16, 0
5134, 1.7, -0.04, 0
5135, 1.7, -0.08, 0
5136, 1.7, -0.12, 0
5137, 1.7, -0.16, 0
5138, 1.7833333333333, -0.04, 0
5139, 1.7833333333333, -0.08, 0
5140, 1.7833333333333, -0.12, 0
5141, 1.7833333333333, -0.16, 0
5142, 1.8666666666667, -0.04, 0
5143, 1.8666666666667, -0.08, 0
5144, 1.8666666666667, -0.12, 0
5145, 1.8666666666667, -0.16, 0
5146, 1.95, -0.04, 0
5147, 1.95, -0.08, 0
5148, 1.95, -0.12, 0
5149, 1.95, -0.16, 0
5150, 2.0333333333333, -0.04, 0
5151, 2.0333333333333, -0.08, 0
5152, 2.0333333333333, -0.12, 0
5153, 2.0333333333333, -0.16, 0
5154, 2.1166666666667, -0.04, 0
5155, 2.1166666666667, -0.08, 0
5156, 2.1166666666667, -0.12, 0
5157, 2.1166666666667, -0.16, 0
5158, 1.2, -0.04, 0.05
5159, 1.2, -0.08, 0.05
5160, 1.2, -0.12, 0.05
5161, 1.2, -0.16, 0.05
5162, 1.2, -0.04, 0.1
5163, 1.2, -0.08, 0.1
5164, 1.2, -0.12, 0.1
5165, 1.2, -0.16, 0.1
5166, 1.2, -0.04, 0.15
5167, 1.2, -0.08, 0.15
5168, 1.2, -0.12, 0.15
5169, 1.2, -0.16, 0.15
5170, 1.2, -0.04, 0.2
5171, 1.2, -0.08, 0.2
5172, 1.2, -0.12, 0.2
5173, 1.2, -0.16, 0.2
5174, 1.2, -0.04, 0.25
5175, 1.2, -0.08, 0.25
5176, 1.2, -0.12, 0.25
5177, 1.2, -0.16, 0.25
5178, 1.2, -0.04, 0.3
5179, 1.2, -0.08, 0.3
5180, 1.2, -0.12, 0.3
5181, 1.2, -0.16, 0.3
5182, 1.2, -0.04, 0.35
5183, 1.2, -0.08, 0.35
5184, 1.2, -0.12, 0.35
5185, 1.2, -0.16, 0.35
5186, 1.2, -0.04, 0.4
5187, 1.2, -0.08, 0.4
5188, 1.2, -0.12, 0.4
5189, 1.2, -0.16, 0.4
5190, 1.2, -0.04, 0.45
5191, 1.2, -0.08, 0.45
5192, 1.2, -0.12, 0.45
5193, 1.2, -0.16, 0.45
5194, 2.2, -0.04, 0.05
5195, 2.2, -0.08, 0.05
5196, 2.2, -0.12, 0.05
5197, 2.2, -0.16, 0.05
5198, 2.2, -0.04, 0.1
5199, 2.2, -0.08, 0.1
5200, 2.2, -0.12, 0.1
5201, 2.2, -0.16, 0.1
5202, 2.2, -0.04, 0.15
5203, 2.2, -0.08, 0.15
5204, 2.2, -0.12, 0.15
5205, 2.2, -0.16, 0.15
5206, 2.2, -0.04, 0.2
5207, 2.2, -0.08, 0.2
5208, 2.2, -0.12, 0.2
5209, 2.2, -0.16, 0.2
5210, 2.2, -0.04, 0.25
5211, 2.2, -0.08, 0.25
5212, 2.2, -0.12, 0.25
5213, 2.2, -0.16, 0.25
5214, 2.2, -0.04, 0.3
5215, 2.2, -0.08, 0.3
5216, 2.2, -0.12, 0.3
5217, 2.2, -0.16, 0.3
5218, 2.2, -0.04, 0.35
5219, 2.2, -0.08, 0.35
5220, 2.2, -0.12, 0.35
5221, 2.2, -0.16, 0.35
5222, 2.2, -0.04, 0.4
5223, 2.2, -0.08, 0.4
5224, 2.2, -0.12, 0.4
5225, 2.2, -0.16, 0.4
5226, 2.2, -0.04, 0.45
5227, 2.2, -0.08, 0.45
5228, 2.2, -0.12, 0.45
5229, 2.2, -0.16, 0.45
5230, 1.2833333333333, -0.2, 0.05
5231, 1.3666666666667, -0.2, 0.05
5232, 1.45, -0.2, 0.05
5233, 1.5333333333333, -0.2, 0.05
5234, 1.6166666666667, -0.2, 0.05
5235, 1.7, -0.2, 0.05
5236, 1.7833333333333, -0.2, 0.05
5237, 1.8666666666667, -0.2, 0.05
5238, 1.95, -0.2, 0.05
5239, 2.0333333333333, -0.2, 0.05
5240, 2.1166666666667, -0.2, 0.05
5241, 1.2833333333333, -0.2, 0.1
5242, 1.3666666666667, -0.2, 0.1
5243, 1.45, -0.2, 0.1
5244, 1.5333333333333, -0.2, 0.1
5245, 1.6166666666667, -0.2, 0.1
5246, 1.7, -0.2, 0.1
5247, 1.7833333333333, -0.2, 0.1
5248, 1.8666666666667, -0.2, 0.1
5249, 1.95, -0.2, 0.1
5250, 2.0333333333333, -0.2, 0.1
5251, 2.1166666666667, -0.2, 0.1
5252, 1.2833333333333, -0.2, 0.15
5253, 1.3666666666667, -0.2, 0.15
5254, 1.45, -0.2, 0.15
5255, 1.5333333333333, -0.2, 0.15
5256, 1.6166666666667, -0.2, 0.15
5257, 1.7, -0.2, 0.15
5258, 1.7833333333333, -0.2, 0.15
5259, 1.8666666666667, -0.2, 0.15
5260, 1.95, -0.2, 0.15
5261, 2.0333333333333, -0.2, 0.15
5262, 2.1166666666667, -0.2, 0.15
5263, 1.2833333333333, -0.2, 0.2
5264, 1.3666666666667, -0.2, 0.2
5265, 1.45, -0.2, 0.2
5266, 1.5333333333333, -0.2, 0.2
5267, 1.6166666666667, -0.2, 0.2
5268, 1.7, -0.2, 0.2
5269, 1.7833333333333, -0.2, 0.2
5270, 1.8666666666667, -0.2, 0.2
5271, 1.95, -0.2, 0.2
5272, 2.0333333333333, -0.2, 0.2
5273, 2.1166666666667, -0.2, 0.2
5274, 1.2833333333333, -0.2, 0.25
5275, 1.3666666666667, -0.2, 0.25
5276, 1.45, -0.2, 0.25
5277, 1.5333333333333, -0.2, 0.25
5278, 1.6166666666667, -0.2, 0.25
5279, 1.7, -0.2, 0.25
5280, 1.7833333333333, -0.2, 0.25
5281, 1.8666666666667, -0.2, 0.25
5282, 1.95, -0.2, 0.25
5283, 2.0333333333333, -0.2, 0.25
5284, 2.1166666666667, -0.2, 0.25
5285, 1.2833333333333, -0.2, 0.3
5286, 1.3666666666667, -0.2, 0.3
5287, 1.45, -0.2, 0.3
5288, 1.5333333333333, -0.2, 0.3
5289, 1.6166666666667, -0.2, 0.3
5290, 1.7, -0.2, 0.3
5291, 1.7833333333333, -0.2, 0.3
5292, 1.8666666666667, -0.2, 0.3
5293, 1.95, -0.2, 0.3
5294, 2.0333333333333, -0.2, 0.3
5295, 2.1166666666667, -0.2, 0.3
5296, 1.2833333333333, -0.2, 0.35
5297, 1.3666666666667, -0.2, 0.35
5298, 1.45, -0.2, 0.35
5299, 1.5333333333333, -0.2, 0.35
5300, 1.6166666666667, -0.2, 0.35
5301, 1.7, -0.2, 0.35
5302, 1.7833333333333, -0.2, 0.35
5303, 1.8666666666667, -0.2, 0.35
5304, 1.95, -0.2, 0.35
5305, 2.0333333333333, -0.2, 0.35
5306, 2.1166666666667, -0.2, 0.35
5307, 1.2833333333333, -0.2, 0.4
5308, 1.3666666666667, -0.2, 0.4
5309, 1.45, -0.2, 0.4
5310, 1.5333333333333, -0.2, 0.4
5311, 1.6166666666667, -0.2, 0.4
5312, 1.7, -0.2, 0.4
5313, 1.7833333333333, -0.2, 0.4
5314, 1.8666666666667, -0.2, 0.4
5315, 1.95, -0.2, 0.4
5316, 2.0333333333333, -0.2, 0.4
5317, 2.1166666666667, -0.2, 0.4
5318, 1.2833333333333, -0.2, 0.45
5319, 1.3666666666667, -0.2, 0.45
5320, 1.45, -0.2, 0.45
5321, 1.5333333333333, -0.2, 0.45
5322, 1.6166666666667, -0.2, 0.45
5323, 1.7, -0.2, 0.45
5324, 1.7833333333333, -0.2, 0.45
5325, 1.8666666666667, -0.2, 0.45
5326, 1.95, -0.2, 0.45
5327, 2.0333333333333, -0.2, 0.45
5328, 2.1166666666667, -0.2, 0.45
5329, 2.3, -0.04, 0.05
5330, 2.3, -0.08, 0.05
5331, 2.3, -0.12, 0.05
5332, 2.3, -0.16, 0.05
5333, 2.3, -0.04, 0.1
5334, 2.3, -0.08, 0.1
5335, 2.3, -0.12, 0.1
5336, 2.3, -0.16, 0.1
5337, 2.3, -0.04, 0.15
5338, 2.3, -0.08, 0.15
5339, 2.3, -0.12, 0.15
5340, 2.3, -0.16, 0.15
5341, 2.3, -0.04, 0.2
5342, 2.3, -0.08, 0.2
5343, 2.3, -0.12, 0.2
5344, 2.3, -0.16, 0.2
5345, 2.3, -0.04, 0.25
5346, 2.3, -0.08, 0.25
5347, 2.3, -0.12, 0.25
5348, 2.3, -0.16, 0.25
5349, 2.3, -0.04, 0.3
5350, 2.3, -0.08, 0.3
5351, 2.3, -0.12, 0.3
5352, 2.3, -0.16, 0.3
5353, 2.3, -0.04, 0.35
5354, 2.3, -0.08, 0.35
5355, 2.3, -0.12, 0.35
5356, 2.3, -0.16, 0.35
5357, 2.3, -0.04, 0.4
5358, 2.3, -0.08, 0.4
5359, 2.3, -0.12, 0.4
5360, 2.3, -0.16, 0.4
5361, 2.3, -0.04, 0.45
5362, 2.3, -0.08, 0.45
5363, 2.3, -0.12, 0.45
5364, 2.3, -0.16, 0.45
5365, 0.083333333333333, 0.0125, 0.05
5366, 0.16666666666667, 0.0125, 0.05
5367, 0.25, 0.0125, 0.05
5368, 0.33333333333333, 0.0125, 0.05
5369, 0.41666666666667, 0.0125, 0.05
5370, 0.5, 0.0125, 0.05
5371, 0.58333333333333, 0.0125, 0.05
5372, 0.66666666666667, 0.0125, 0.05
5373, 0.75, 0.0125, 0.05
5374, 0.83333333333333, 0.0125, 0.05
5375, 0.91666666666667, 0.0125, 0.05
5376, 0.083333333333333, 0.025, 0.05
5377, 0.16666666666667, 0.025, 0.05
5378, 0.25, 0.025, 0.05
5379, 0.33333333333333, 0.025, 0.05
5380, 0.41666666666667, 0.025, 0.05
5381, 0.5, 0.025, 0.05
5382, 0.58333333333333, 0.025, 0.05
5383, 0.66666666666667, 0.025, 0.05
5384, 0.75, 0.025, 0.05
5385, 0.83333333333333, 0.025, 0.05
5386, 0.91666666666667, 0.025, 0.05
5387, 0.083333333333333, 0.0375, 0.05
5388, 0.16666666666667, 0.0375, 0.05
5389, 0.25, 0.0375, 0.05
5390, 0.33333333333333, 0.0375, 0.05
5391, 0.41666666666667, 0.0375, 0.05
5392, 0.5, 0.0375, 0.05
5393, 0.58333333333333, 0.0375, 0.05
5394, 0.66666666666667, 0.0375, 0.05
5395, 0.75, 0.0375, 0.05
5396, 0.83333333333333, 0.0375, 0.05
5397, 0.91666666666667, 0.0375, 0.05
5398, 0.083333333333333, 0.0125, 0.1
5399, 0.16666666666667, 0.0125, 0.1
5400, 0.25, 0.0125, 0.1
5401, 0.33333333333333, 0.0125, 0.1
5402, 0.41666666666667, 0.0125, 0.1
5403, 0.5, 0.0125, 0.1
5404, 0.58333333333333, 0.0125, 0.1
5405, 0.66666666666667, 0.0125, 0.1
5406, 0.75, 0.0125, 0.1
5407, 0.83333333333333, 0.0125, 0.1
5408, 0.91666666666667, 0.0125, 0.1
5409, 0.083333333333333, 0.025, 0.1
5410, 0.16666666666667, 0.025, 0.1
5411, 0.25, 0.025, 0.1
5412, 0.33333333333333, 0.025, 0.1
5413, 0.41666666666667, 0.025, 0.1
5414, 0.5, 0.025, 0.1
5415, 0.58333333333333, 0.025, 0.1
5416, 0.66666666666667, 0.025, 0.1
5417, 0.75, 0.025, 0.1
5418, 0.83333333333333, 0.025, 0.1
5419, 0.91666666666667, 0.025, 0.1
5420, 0.083333333333333, 0.0375, 0.1
5421, 0.16666666666667, 0.0375, 0.1
5422, 0.25, 0.0375, 0.1
5423, 0.33333333333333, 0.0375, 0.1
5424, 0.41666666666667, 0.0375, 0.1
5425, 0.5, 0.0375, 0.1
5426, 0.58333333333333, 0.0375, 0.1
5427, 0.66666666666667, 0.0375, 0.1
5428, 0.75, 0.0375, 0.1
5429, 0.83333333333333, 0.0375, 0.1
5430, 0.91666666666667, 0.0375, 0.1
5431, 0.083333333333333, 0.0125, 0.15
5432, 0.16666666666667, 0.0125, 0.15
5433, 0.25, 0.0125, 0.15
5434, 0.33333333333333, 0.0125, 0.15
5435, 0.41666666666667, 0.0125, 0.15
5436, 0.5, 0.0125, 0.15
5437, 0.58333333333333, 0.0125, 0.15
5438, 0.66666666666667, 0.0125, 0.15
5439, 0.75, 0.0125, 0.15
5440, 0.83333333333333, 0.0125, 0.15
5441, 0.91666666666667, 0.0125, 0.15
5442, 0.083333333333333, 0.025, 0.15
5443, 0.16666666666667, 0.025, 0.15
5444, 0.25, 0.025, 0.15
5445, 0.33333333333333, 0.025, 0.15
5446, 0.41666666666667, 0.025, 0.15
5447, 0.5, 0.025, 0.15
5448, 0.58333333333333, 0.025, 0.15
5449, 0.66666666666667, 0.025, 0.15
5450, 0.75, 0.025, 0.15
5451, 0.83333333333333, 0.025, 0.15
5452, 0.91666666666667, 0.025, 0.15
5453, 0.083333333333333, 0.0375, 0.15
5454, 0.16666666666667, 0.0375, 0.15
5455, 0.25, 0.0375, 0.15
5456, 0.33333333333333, 0.0375, 0.15
5457, 0.41666666666667, 0.0375, 0.15
5458, 0.5, 0.0375, 0.15
5459, 0.58333333333333, 0.0375, 0.15
5460, 0.66666666666667, 0.0375, 0.15
5461, 0.75, 0.0375, 0.15
5462, 0.83333333333333, 0.0375, 0.15
5463, 0.91666666666667, 0.0375, 0.15
5464, 0.083333333333333, 0.0125, 0.2
5465, 0.16666666666667, 0.0125, 0.2
5466, 0.25, 0.0125, 0.2
5467, 0.33333333333333, 0.0125, 0.2
5468, 0.41666666666667, 0.0125, 0.2
5469, 0.5, 0.0125, 0.2
5470, 0.58333333333333, 0.0125, 0.2
5471, 0.66666666666667, 0.0125, 0.2
5472, 0.75, 0.0125, 0.2
5473, 0.83333333333333, 0.0125, 0.2
5474, 0.91666666666667, 0.0125, 0.2
5475, 0.083333333333333, 0.025, 0.2
5476, 0.16666666666667, 0.025, 0.2
5477, 0.25, 0.025, 0.2
5478, 0.33333333333333, 0.025, 0.2
5479, 0.41666666666667, 0.025, 0.2
5480, 0.5, 0.025, 0.2
5481, 0.58333333333333, 0.025, 0.2
5482, 0.66666666666667, 0.025, 0.2
5483, 0.75, 0.025, 0.2
5484, 0.83333333333333, 0.025, 0.2
5485, 0.91666666666667, 0.025, 0.2
5486, 0.083333333333333, 0.0375, 0.2
5487, 0.16666666666667, 0.0375, 0.2
5488, 0.25, 0.0375, 0.2
5489, 0.33333333333333, 0.0375, 0.2
5490, 0.41666666666667, 0.0375, 0.2
5491, 0.5, 0.0375, 0.2
5492, 0.58333333333333, 0.0375, 0.2
5493, 0.66666666666667, 0.0375, 0.2
5494, 0.75, 0.0375, 0.2
5495, 0.83333333333333, 0.0375, 0.2
5496, 0.91666666666667, 0.0375, 0.2
5497, 0.083333333333333, 0.0125, 0.25
5498, 0.16666666666667, 0.0125, 0.25
5499, 0.25, 0.0125, 0.25
5500, 0.33333333333333, 0.0125, 0.25
5501, 0.41666666666667, 0.0125, 0.25
5502, 0.5, 0.0125, 0.25
5503, 0.58333333333333, 0.0125, 0.25
5504, 0.66666666666667, 0.0125, 0.25
5505, 0.75, 0.0125, 0.25
5506, 0.83333333333333, 0.0125, 0.25
5507, 0.91666666666667, 0.0125, 0.25
5508, 0.083333333333333, 0.025, 0.25
5509, 0.16666666666667, 0.025, 0.25
5510, 0.25, 0.025, 0.25
5511, 0.33333333333333, 0.025, 0.25
5512, 0.41666666666667, 0.025, 0.25
5513, 0.5, 0.025, 0.25
5514, 0.58333333333333, 0.025, 0.25
5515, 0.66666666666667, 0.025, 0.25
5516, 0.75, 0.025, 0.25
5517, 0.83333333333333, 0.025, 0.25
5518, 0.91666666666667, 0.025, 0.25
5519, 0.083333333333333, 0.0375, 0.25
5520, 0.16666666666667, 0.0375, 0.25
5521, 0.25, 0.0375, 0.25
5522, 0.33333333333333, 0.0375, 0.25
5523, 0.41666666666667, 0.0375, 0.25
5524, 0.5, 0.0375, 0.25
5525, 0.58333333333333, 0.0375, 0.25
5526, 0.66666666666667, 0.0375, 0.25
5527, 0.75, 0.0375, 0.25
5528, 0.83333333333333, 0.0375, 0.25
5529, 0.91666666666667, 0.0375, 0.25
5530, 0.083333333333333, 0.0125, 0.3
5531, 0.16666666666667, 0.0125, 0.3
5532, 0.25, 0.0125, 0.3
5533, 0.33333333333333, 0.0125, 0.3
5534, 0.41666666666667, 0.0125, 0.3
5535, 0.5, 0.0125, 0.3
5536, 0.58333333333333, 0.0125, 0.3
5537, 0.66666666666667, 0.0125, 0.3
5538, 0.75, 0.0125, 0.3
5539, 0.83333333333333, 0.0125, 0.3
5540, 0.91666666666667, 0.0125, 0.3
5541, 0.083333333333333, 0.025, 0.3
5542, 0.16666666666667, 0.025, 0.3
5543, 0.25, 0.025, 0.3
5544, 0.33333333333333, 0.025, 0.3
5545, 0.41666666666667, 0.025, 0.3
5546, 0.5, 0.025, 0.3
5547, 0.58333333333333, 0.025, 0.3
5548, 0.66666666666667, 0.025, 0.3
5549, 0.75, 0.025, 0.3
5550, 0.83333333333333, 0.025, 0.3
5551, 0.91666666666667, 0.025, 0.3
5552, 0.083333333333333, 0.0375, 0.3
5553, 0.16666666666667, 0.0375, 0.3
5554, 0.25, 0.0375, 0.3
5555, 0.33333333333333, 0.0375, 0.3
5556, 0.41666666666667, 0.0375, 0.3
5557, 0.5, 0.0375, 0.3
5558, 0.58333333333333, 0.0375, 0.3
5559, 0.66666666666667, 0.0375, 0.3
5560, 0.75, 0.0375, 0.3
5561, 0.83333333333333, 0.0375, 0.3
5562, 0.91666666666667, 0.0375, 0.3
5563, 0.083333333333333, 0.0125, 0.35
5564, 0.16666666666667, 0.0125, 0.35
5565, 0.25, 0.0125, 0.35
5566, 0.33333333333333, 0.0125, 0.35
5567, 0.41666666666667, 0.0125, 0.35
5568, 0.5, 0.0125, 0.35
5569, 0.58333333333333, 0.0125, 0.35
5570, 0.66666666666667, 0.0125, 0.35
5571, 0.75, 0.0125, 0.35
5572, 0.83333333333333, 0.0125, 0.35
5573, 0.91666666666667, 0.0125, 0.35
5574, 0.083333333333333, 0.025, 0.35
5575, 0.16666666666667, 0.025, 0.35
5576, 0.25, 0.025, 0.35
5577, 0.33333333333333, 0.025, 0.35
5578, 0.41666666666667, 0.025, 0.35
5579, 0.5, 0.025, 0.35
5580, 0.58333333333333, 0.025, 0.35
5581, 0.66666666666667, 0.025, 0.35
5582, 0.75, 0.025, 0.35
5583, 0.83333333333333, 0.025, 0.35
5584, 0.91666666666667, 0.025, 0.35
5585, 0.083333333333333, 0.0375, 0.35
5586, 0.16666666666667, 0.0375, 0.35
5587, 0.25, 0.0375, 0.35
5588, 0.33333333333333, 0.0375, 0.35
5589, 0.41666666666667, 0.0375, 0.35
5590, 0.5, 0.0375, 0.35
5591, 0.58333333333333, 0.0375, 0.35
5592, 0.66666666666667, 0.0375, 0.35
5593, 0.75, 0.0375, 0.35
5594, 0.83333333333333, 0.0375, 0.35
5595, 0.91666666666667, 0.0375, 0.35
5596, 0.083333333333333, 0.0125, 0.4
5597, 0.16666666666667, 0.0125, 0.4
5598, 0.25, 0.0125, 0.4
5599, 0.33333333333333, 0.0125, 0.4
5600, 0.41666666666667, 0.0125, 0.4
5601, 0.5, 0.0125, 0.4
5602, 0.58333333333333, 0.0125, 0.4
5603, 0.66666666666667, 0.0125, 0.4
5604, 0.75, 0.0125, 0.4
5605, 0.83333333333333, 0.0125, 0.4
5606, 0.91666666666667, 0.0125, 0.4
5607, 0.083333333333333, 0.025, 0.4
5608, 0.16666666666667, 0.025, 0.4
5609, 0.25, 0.025, 0.4
5610, 0.33333333333333, 0.025, 0.4
5611, 0.41666666666667, 0.025, 0.4
5612, 0.5, 0.025, 0.4
5613, 0.58333333333333, 0.025, 0.4
5614, 0.66666666666667, 0.025, 0.4
5615, 0.75, 0.025, 0.4
5616, 0.83333333333333, 0.025, 0.4
5617, 0.91666666666667, 0.025, 0.4
5618, 0.083333333333333, 0.0375, 0.4
5619, 0.16666666666667, 0.0375, 0.4
5620, 0.25, 0.0375, 0.4
5621, 0.33333333333333, 0.0375, 0.4
5622, 0.41666666666667, 0.0375, 0.4
5623, 0.5, 0.0375, 0.4
5624, 0.58333333333333, 0.0375, 0.4
5625, 0.66666666666667, 0.0375, 0.4
5626, 0.75, 0.0375, 0.4
5627, 0.83333333333333, 0.0375, 0.4
5628, 0.91666666666667, 0.0375, 0.4
5629, 0.083333333333333, 0.0125, 0.45
5630, 0.16666666666667, 0.0125, 0.45
5631, 0.25, 0.0125, 0.45
5632, 0.33333333333333, 0.0125, 0.45
5633, 0.41666666666667, 0.0125, 0.45
5634, 0.5, 0.0125, 0.45
5635, 0.58333333333333, 0.0125, 0.45
5636, 0.66666666666667, 0.0125, 0.45
5637, 0.75, 0.0125, 0.45
5638, 0.83333333333333, 0.0125, 0.45
5639, 0.91666666666667, 0.0125, 0.45
5640, 0.083333333333333, 0.025, 0.45
5641, 0.16666666666667, 0.025, 0.45
5642, 0.25, 0.025, 0.45
5643, 0.33333333333333, 0.025, 0.45
5644, 0.41666666666667, 0.025, 0.45
5645, 0.5, 0.025, 0.45
5646, 0.58333333333333, 0.025, 0.45
5647, 0.66666666666667, 0.025, 0.45
5648, 0.75, 0.025, 0.45
5649, 0.83333333333333, 0.025, 0.45
5650, 0.91666666666667, 0.025, 0.45
5651, 0.083333333333333, 0.0375, 0.45
5652, 0.16666666666667, 0.0375, 0.45
5653, 0.25, 0.0375, 0.45
5654, 0.33333333333333, 0.0375, 0.45
5655, 0.41666666666667, 0.0375, 0.45
5656, 0.5, 0.0375, 0.45
5657, 0.58333333333333, 0.0375, 0.45
5658, 0.66666666666667, 0.0375, 0.45
5659, 0.75, 0.0375, 0.45
5660, 0.83333333333333, 0.0375, 0.45
5661, 0.91666666666667, 0.0375, 0.45
5662, 0.083333333333333, 0.22, 0.05
5663, 0.083333333333333, 0.34, 0.05
5664, 0.083333333333333, 0.46, 0.05
5665, 0.083333333333333, 0.58, 0.05
5666, 0.083333333333333, 0.7, 0.05
5667, 0.083333333333333, 0.82, 0.05
5668, 0.083333333333333, 0.94, 0.05
5669, 0.083333333333333, 1.06, 0.05
5670, 0.083333333333333, 1.18, 0.05
5671, 0.083333333333333, 0.22, 0.1
5672, 0.083333333333333, 0.34, 0.1
5673, 0.083333333333333, 0.46, 0.1
5674, 0.083333333333333, 0.58, 0.1
5675, 0.083333333333333, 0.7, 0.1
5676, 0.083333333333333, 0.82, 0.1
5677, 0.083333333333333, 0.94, 0.1
5678, 0.083333333333333, 1.06, 0.1
5679, 0.083333333333333, 1.18, 0.1
5680, 0.083333333333333, 0.22, 0.15
5681, 0.083333333333333, 0.34, 0.15
5682, 0.083333333333333, 0.46, 0.15
5683, 0.083333333333333, 0.58, 0.15
5684, 0.083333333333333, 0.7, 0.15
5685, 0.083333333333333, 0.82, 0.15
5686, 0.083333333333333, 0.94, 0.15
5687, 0.083333333333333, 1.06, 0.15
5688, 0.083333333333333, 1.18, 0.15
5689, 0.083333333333333, 0.22, 0.2
5690, 0.083333333333333, 0.34, 0.2
5691, 0.083333333333333, 0.46, 0.2
5692, 0.083333333333333, 0.58, 0.2
5693, 0.083333333333333, 0.7, 0.2
5694, 0.083333333333333, 0.82, 0.2
5695, 0.083333333333333, 0.94, 0.2
5696, 0.083333333333333, 1.06, 0.2
5697, 0.083333333333333, 1.18, 0.2
5698, 0.083333333333333, 0.22, 0.25
5699, 0.083333333333333, 0.34, 0.25
5700, 0.083333333333333, 0.46, 0.25
5701, 0.083333333333333, 0.58, 0.25
5702, 0.083333333333333, 0.7, 0.25
5703, 0.083333333333333, 0.82, 0.25
5704, 0.083333333333333, 0.94, 0.25
5705, 0.083333333333333, 1.06, 0.25
5706, 0.083333333333333, 1.18, 0.25
5707, 0.083333333333333, 0.22, 0.3
5708, 0.083333333333333, 0.34, 0.3
5709, 0.083333333333333, 0.46, 0.3
5710, 0.083333333333333, 0.58, 0.3
5711, 0.083333333333333, 0.7, 0.3
5712, 0.083333333333333, 0.82, 0.3
5713, 0.083333333333333, 0.94, 0.3
5714, 0.083333333333333, 1.06, 0.3
5715, 0.083333333333333, 1.18, 0.3
5716, 0.083333333333333, 0.22, 0.35
5717, 0.083333333333333, 0.34, 0.35
5718, 0.083333333333333, 0.46, 0.35
5719, 0.083333333333333, 0.58, 0.35
5720, 0.083333333333333, 0.7, 0.35
5721, 0.083333333333333, 0.82, 0.35
5722, 0.083333333333333, 0.94, 0.35
5723, 0.083333333333333, 1.06, 0.35
5724, 0.083333333333333, 1.18, 0.35
5725, 0.083333333333333, 0.22, 0.4
5726, 0.083333333333333, 0.34, 0.4
5727, 0.083333333333333, 0.46, 0.4
5728, 0.083333333333333, 0.58, 0.4
5729, 0.083333333333333, 0.7, 0.4
5730, 0.083333333333333, 0.82, 0.4
5731, 0.083333333333333, 0.94, 0.4
5732, 0.083333333333333, 1.06, 0.4
5733, 0.083333333333333, 1.18, 0.4
5734, 0.083333333333333, 0.22, 0.45
5735, 0.083333333333333, 0.34, 0.45
5736, 0.083333333333333, 0.46, 0.45
5737, 0.083333333333333, 0.58, 0.45
5738, 0.083333333333333, 0.7, 0.45
5739, 0.083333333333333, 0.82, 0.45
5740, 0.083333333333333, 0.94, 0.45
5741, 0.083333333333333, 1.06, 0.45
5742, 0.083333333333333, 1.18, 0.45
5743, 0.16666666666667, 0.22, 0.05
5744, 0.16666666666667, 0.34, 0.05
5745, 0.16666666666667, 0.46, 0.05
5746, 0.16666666666667, 0.58, 0.05
5747, 0.16666666666667, 0.7, 0.05
5748, 0.16666666666667, 0.82, 0.05
5749, 0.16666666666667, 0.94, 0.05
5750, 0.16666666666667, 1.06, 0.05
5751, 0.16666666666667, 1.18, 0.05
5752, 0.16666666666667, 0.22, 0.1
5753, 0.16666666666667, 0.34, 0.1
5754, 0.16666666666667, 0.46, 0.1
5755, 0.16666666666667, 0.58, 0.1
5756, 0.16666666666667, 0.7, 0.1
5757, 0.16666666666667, 0.82, 0.1
5758, 0.16666666666667, 0.94, 0.1
5759, 0.16666666666667, 1.06, 0.1
5760, 0.16666666666667, 1.18, 0.1
5761, 0.16666666666667, 0.22, 0.15
5762, 0.16666666666667, 0.34, 0.15
5763, 0.16666666666667, 0.46, 0.15
5764, 0.16666666666667, 0.58, 0.15
5765, 0.16666666666667, 0.7, 0.15
5766, 0.16666666666667, 0.82, 0.15
5767, 0.16666666666667, 0.94, 0.15
5768, 0.16666666666667, 1.06, 0.15
5769, 0.16666666666667, 1.18, 0.15
5770, 0.16666666666667, 0.22, 0.2
5771, 0.16666666666667, 0.34, 0.2
5772, 0.16666666666667, 0.46, 0.2
5773, 0.16666666666667, 0.58, 0.2
5774, 0.16666666666667, 0.7, 0.2
5775, 0.16666666666667, 0.82, 0.2
5776, 0.16666666666667, 0.94, 0.2
5777, 0.16666666666667, 1.06, 0.2
5778, 0.16666666666667, 1.18, 0.2
5779, 0.16666666666667, 0.22, 0.25
5780, 0.16666666666667, 0.34, 0.25
5781, 0.16666666666667, 0.46, 0.25
5782, 0.16666666666667, 0.58, 0.25
5783, 0.16666666666667, 0.7, 0.25
5784, 0.16666666666667, 0.82, 0.25
5785, 0.16666666666667, 0.94, 0.25
5786, 0.16666666666667, 1.06, 0.25
5787, 0.16666666666667, 1.18, 0.25
5788, 0.16666666666667, 0.22, 0.3
5789, 0.16666666666667, 0.34, 0.3
5790, 0.16666666666667, 0.46, 0.3
5791, 0.16666666666667, 0.58, 0.3
5792, 0.16666666666667, 0.7, 0.3
5793, 0.16666666666667, 0.82, 0.3
5794, 0.16666666666667, 0.94, 0.3
5795, 0.16666666666667, 1.06, 0.3
5796, 0.16666666666667, 1.18, 0.3
5797, 0.16666666666667, 0.22, 0.35
5798, 0.16666666666667, 0.34, 0.35
5799, 0.16666666666667, 0.46, 0.35
5800, 0.16666666666667, 0.58, 0.35
5801, 0.16666666666667, 0.7, 0.35
5802, 0.16666666666667, 0.82, 0.35
5803, 0.16666666666667, 0.94, 0.35
5804, 0.16666666666667, 1.06, 0.35
5805, 0.16666666666667, 1.18, 0.35
5806, 0.16666666666667, 0.22, 0.4
5807, 0.16666666666667, 0.34, 0.4
5808, 0.16666666666667, 0.46, 0.4
5809, 0.16666666666667, 0.58, 0.4
5810, 0.16666666666667, 0.7, 0.4
5811, 0.16666666666667, 0.82, 0.4
5812, 0.16666666666667, 0.94, 0.4
5813, 0.16666666666667, 1.06, 0.4
5814, 0.16666666666667, 1.18, 0.4
5815, 0.16666666666667, 0.22, 0.45
5816, 0.16666666666667, 0.34, 0.45
5817, 0.16666666666667, 0.46, 0.45
5818, 0.16666666666667, 0.58, 0.45
5819, 0.16666666666667, 0.7, 0.45
5820, 0.16666666666667, 0.82, 0.45
5821, 0.16666666666667, 0.94, 0.45
5822, 0.16666666666667, 1.06, 0.45
5823, 0.16666666666667, 1.18, 0.45
5824, 0.25, 0.22, 0.05
5825, 0.25, 0.34, 0.05
5826, 0.25, 0.46, 0.05
5827, 0.25, 0.58, 0.05
5828, 0.25, 0.7, 0.05
5829, 0.25, 0.82, 0.05
5830, 0.25, 0.94, 0.05
5831, 0.25, 1.06, 0.05
5832, 0.25, 1.18, 0.05
5833, 0.25, 0.22, 0.1
5834, 0.25, 0.34, 0.1
5835, 0.25, 0.46, 0.1
5836, 0.25, 0.58, 0.1
5837, 0.25, 0.7, 0.1
5838, 0.25, 0.82, 0.1
5839, 0.25, 0.94, 0.1
5840, 0.25, 1.06, 0.1
5841, 0.25, 1.18, 0.1
5842, 0.25, 0.22, 0.15
5843, 0.25, 0.34, 0.15
5844, 0.25, 0.46, 0.15
5845, 0.25, 0.58, 0.15
5846, 0.25, 0.7, 0.15
5847, 0.25, 0.82, 0.15
5848, 0.25, 0.94, 0.15
5849, 0.25, 1.06, 0.15
5850, 0.25, 1.18, 0.15
5851, 0.25, 0.22, 0.2
5852, 0.25, 0.34, 0.2
5853, 0.25, 0.46, 0.2
5854, 0.25, 0.58, 0.2
5855, 0.25, 0.7, 0.2
5856, 0.25, 0.82, 0.2
5857, 0.25, 0.94, 0.2
5858, 0.25, 1.06, 0.2
5859, 0.25, 1.18, 0.2
5860, 0.25, 0.22, 0.25
5861, 0.25, 0.34, 0.25
5862, 0.25, 0.46, 0.25
5863, 0.25, 0.58, 0.25
5864, 0.25, 0.7, 0.25
5865, 0.25, 0.82, 0.25
5866, 0.25, 0.94, 0.25
5867, 0.25, 1.06, 0.25
5868, 0.25, 1.18, 0.25
5869, 0.25, 0.22, 0.3
5870, 0.25, 0.34, 0.3
5871, 0.25, 0.46, 0.3
5872, 0.25, 0.58, 0.3
5873, 0.25, 0.7, 0.3
5874, 0.25, 0.82, 0.3
5875, 0.25, 0.94, 0.3
5876, 0.25, 1.06, 0.3
5877, 0.25, 1.18, 0.3
5878, 0.25, 0.22, 0.35
5879, 0.25, 0.34, 0.35
5880, 0.25, 0.46, 0.35
5881, 0.25, 0.58, 0.35
5882, 0.25, 0.7, 0.35
5883, 0.25, 0.82, 0.35
5884, 0.25, 0.94, 0.35
5885, 0.25, 1.06, 0.35
5886, 0.25, 1.18, 0.35
5887, 0.25, 0.22, 0.4
5888, 0.25, 0.34, 0.4
5889, 0.25, 0.46, 0.4
5890, 0.25, 0.58, 0.4
5891, 0.25, 0.7, 0.4
5892, 0.25, 0.82, 0.4
5893, 0.25, 0.94, 0.4
5894, 0.25, 1.06, 0.4
5895, 0.25, 1.18, 0.4
5896, 0.25, 0.22, 0.45
5897, 0.25, 0.34, 0.45
5898, 0.25, 0.46, 0.45
5899, 0.25, 0.58, 0.45
5900, 0.25, 0.7, 0.45
5901, 0.25, 0.82, 0.45
5902, 0.25, 0.94, 0.45
5903, 0.25, 1.06, 0.45
5904, 0.25, 1.18, 0.45
5905, 0.33333333333333, 0.22, 0.05
5906, 0.33333333333333, 0.34, 0.05
5907, 0.33333333333333, 0.46, 0.05
5908, 0.33333333333333, 0.58, 0.05
5909, 0.33333333333333, 0.7, 0.05
5910, 0.33333333333333, 0.82, 0.05
5911, 0.33333333333333, 0.94, 0.05
5912, 0.33333333333333, 1.06, 0.05
5913, 0.33333333333333, 1.18, 0.05
5914, 0.33333333333333, 0.22, 0.1
5915, 0.33333333333333, 0.34, 0.1
5916, 0.33333333333333, 0.46, 0.1
5917, 0.33333333333333, 0.58, 0.1
5918, 0.33333333333333, 0.7, 0.1
5919, 0.33333333333333, 0.82, 0.1
5920, 0.33333333333333, 0.94, 0.1
5921, 0.33333333333333, 1.06, 0.1
5922, 0.33333333333333, 1.18, 0.1
5923, 0.33333333333333, 0.22, 0.15
5924, 0.33333333333333, 0.34, 0.15
5925, 0.33333333333333, 0.46, 0.15
5926, 0.33333333333333, 0.58, 0.15
5927, 0.33333333333333, 0.7, 0.15
5928, 0.33333333333333, 0.82, 0.15
5929, 0.33333333333333, 0.94, 0.15
5930, 0.33333333333333, 1.06, 0.15
5931, 0.33333333333333, 1.18, 0.15
5932, 0.33333333333333, 0.22, 0.2
5933, 0.33333333333333, 0.34, 0.2
5934, 0.33333333333333, 0.46, 0.2
5935, 0.33333333333333, 0.58, 0.2
5936, 0.33333333333333, 0.7, 0.2
5937, 0.33333333333333, 0.82, 0.2
5938, 0.33333333333333, 0.94, 0.2
5939, 0.33333333333333, 1.06, 0.2
5940, 0.33333333333333, 1.18, 0.2
5941, 0.33333333333333, 0.22, 0.25
5942, 0.33333333333333, 0.34, 0.25
5943, 0.33333333333333, 0.46, 0.25
5944, 0.33333333333333, 0.58, 0.25
5945, 0.33333333333333, 0.7, 0.25
5946, 0.33333333333333, 0.82, 0.25
5947, 0.33333333333333, 0.94, 0.25
5948, 0.33333333333333, 1.06, 0.25
5949, 0.33333333333333, 1.18, 0.25
5950, 0.33333333333333, 0.22, 0.3
5951, 0.33333333333333, 0.34, 0.3
5952, 0.33333333333333, 0.46, 0.3
5953, 0.33333333333333, 0.58, 0.3
5954, 0.33333333333333, 0.7, 0.3
5955, 0.33333333333333, 0.82, 0.3
5956, 0.33333333333333, 0.94, 0.3
5957, 0.33333333333333, 1.06, 0.3
5958, 0.33333333333333, 1.18, 0.3
5959, 0.33333333333333, 0.22, 0.35
5960, 0.33333333333333, 0.34, 0.35
5961, 0.33333333333333, 0.46, 0.35
5962, 0.33333333333333, 0.58, 0.35
5963, 0.33333333333333, 0.7, 0.35
5964, 0.33333333333333, 0.82, 0.35
5965, 0.33333333333333, 0.94, 0.35
5966, 0.33333333333333, 1.06, 0.35
5967, 0.33333333333333, 1.18, 0.35
5968, 0.33333333333333, 0.22, 0.4
5969, 0.33333333333333, 0.34, 0.4
5970, 0.33333333333333, 0.46, 0.4
5971, 0.33333333333333, 0.58, 0.4
5972, 0.33333333333333, 0.7, 0.4
5973, 0.33333333333333, 0.82, 0.4
5974, 0.33333333333333, 0.94, 0.4
5975, 0.33333333333333, 1.06, 0.4
5976, 0.33333333333333, 1.18, 0.4
5977, 0.33333333333333, 0.22, 0.45
5978, 0.33333333333333, 0.34, 0.45
5979, 0.33333333333333, 0.46, 0.45
5980, 0.33333333333333, 0.58, 0.45
5981, 0.33333333333333, 0.7, 0.45
5982, 0.33333333333333, 0.82, 0.45
5983, 0.33333333333333, 0.94, 0.45
5984, 0.33333333333333, 1.06, 0.45
5985, 0.33333333333333, 1.18, 0.45
5986, 0.41666666666667, 0.22, 0.05
5987, 0.41666666666667, 0.34, 0.05
5988, 0.41666666666667, 0.46, 0.05
5989, 0.41666666666667, 0.58, 0.05
5990, 0.41666666666667, 0.7, 0.05
5991, 0.41666666666667, 0.82, 0.05
5992, 0.41666666666667, 0.94, 0.05
5993, 0.41666666666667, 1.06, 0.05
5994, 0.41666666666667, 1.18, 0.05
5995, 0.41666666666667, 0.22, 0.1
5996, 0.41666666666667, 0.34, 0.1
5997, 0.41666666666667, 0.46, 0.1
5998, 0.41666666666667, 0.58, 0.1
5999, 0.41666666666667, 0.7, 0.1
6000, 0.41666666666667, 0.82, 0.1
6001, 0.41666666666667, 0.94, 0.1
6002, 0.41666666666667, 1.06, 0.1
6003, 0.41666666666667, 1.18, 0.1
6004, 0.41666666666667, 0.22, 0.15
6005, 0.41666666666667, 0.34, 0.15
6006, 0.41666666666667, 0.46, 0.15
6007, 0.41666666666667, 0.58, 0.15
6008, 0.41666666666667, 0.7, 0.15
6009, 0.41666666666667, 0.82, 0.15
6010, 0.41666666666667, 0.94, 0.15
6011, 0.41666666666667, 1.06, 0.15
6012, 0.41666666666667, 1.18, 0.15
6013, 0.41666666666667, 0.22, 0.2
6014, 0.41666666666667, 0.34, 0.2
6015, 0.41666666666667, 0.46, 0.2
6016, 0.41666666666667, 0.58, 0.2
6017, 0.41666666666667, 0.7, 0.2
6018, 0.41666666666667, 0.82, 0.2
6019, 0.41666666666667, 0.94, 0.2
6020, 0.41666666666667, 1.06, 0.2
6021, 0.41666666666667, 1.18, 0.2
6022, 0.41666666666667, 0.22, 0.25
6023, 0.41666666666667, 0.34, 0.25
6024, 0.41666666666667, 0.46, 0.25
6025, 0.41666666666667, 0.58, 0.25
6026, 0.41666666666667, 0.7, 0.25
6027, 0.41666666666667, 0.82, 0.25
6028, 0.41666666666667, 0.94, 0.25
6029, 0.41666666666667, 1.06, 0.25
6030, 0.41666666666667, 1.18, 0.25
6031, 0.41666666666667, 0.22, 0.3
6032, 0.41666666666667, 0.34, 0.3
6033, 0.41666666666667, 0.46, 0.3
6034, 0.41666666666667, 0.58, 0.3
6035, 0.41666666666667, 0.7, 0.3
6036, 0.41666666666667, 0.82, 0.3
6037, 0.41666666666667, 0.94, 0.3
6038, 0.41666666666667, 1.06, 0.3
6039, 0.41666666666667, 1.18, 0.3
6040, 0.41666666666667, 0.22, 0.35
6041, 0.41666666666667, 0.34, 0.35
6042, 0.41666666666667, 0.46, 0.35
6043, 0.41666666666667, 0.58, 0.35
6044, 0.41666666666667, 0.7, 0.35
6045, 0.41666666666667, 0.82, 0.35
6046, 0.41666666666667, 0.94, 0.35
6047, 0.41666666666667, 1.06, 0.35
6048, 0.41666666666667, 1.18, 0.35
6049, 0.41666666666667, 0.22, 0.4
6050, 0.41666666666667, 0.34, 0.4
6051, 0.41666666666667, 0.46, 0.4
6052, 0.41666666666667, 0.58, 0.4
6053, 0.41666666666667, 0.7, 0.4
6054, 0.41666666666667, 0.82, 0.4
6055, 0.41666666666667, 0.94, 0.4
6056, 0.41666666666667, 1.06, 0.4
6057, 0.41666666666667, 1.18, 0.4
6058, 0.41666666666667, 0.22, 0.45
6059, 0.41666666666667, 0.34, 0.45
6060, 0.41666666666667, 0.46, 0.45
6061, 0.41666666666667, 0.58, 0.45
6062, 0.41666666666667, 0.7, 0.45
6063, 0.41666666666667, 0.82, 0.45
6064, 0.41666666666667, 0.94, 0.45
6065, 0.41666666666667, 1.06, 0.45
6066, 0.41666666666667, 1.18, 0.45
6067, 0.5, 0.22, 0.05
6068, 0.5, 0.34, 0.05
6069, 0.5, 0.46, 0.05
6070, 0.5, 0.58, 0.05
6071, 0.5, 0.7, 0.05
6072, 0.5, 0.82, 0.05
6073, 0.5, 0.94, 0.05
6074, 0.5, 1.06, 0.05
6075, 0.5, 1.18, 0.05
6076, 0.5, 0.22, 0.1
6077, 0.5, 0.34, 0.1
6078, 0.5, 0.46, 0.1
6079, 0.5, 0.58, 0.1
6080, 0.5, 0.7, 0.1
6081, 0.5, 0.82, 0.1
6082, 0.5, 0.94, 0.1
6083, 0.5, 1.06, 0.1
6084, 0.5, 1.18, 0.1
6085, 0.5, 0.22, 0.15
6086, 0.5, 0.34, 0.15
6087, 0.5, 0.46, 0.15
6088, 0.5, 0.58, 0.15
6089, 0.5, 0.7, 0.15
6090, 0.5, 0.82, 0.15
6091, 0.5, 0.94, 0.15
6092, 0.5, 1.06, 0.15
6093, 0.5, 1.18, 0.15
6094, 0.5, 0.22, 0.2
6095, 0.5, 0.34, 0.2
6096, 0.5, 0.46, 0.2
6097, 0.5, 0.58, 0.2
6098, 0.5, 0.7, 0.2
6099, 0.5, 0.82, 0.2
6100, 0.5, 0.94, 0.2
6101, 0.5, 1.06, 0.2
6102, 0.5, 1.18, 0.2
6103, 0.5, 0.22, 0.25
6104, 0.5, 0.34, 0.25
6105, 0.5, 0.46, 0.25
6106, 0.5, 0.58, 0.25
6107, 0.5, 0.7, 0.25
6108, 0.5, 0.82, 0.25
6109, 0.5, 0.94, 0.25
6110, 0.5, 1.06, 0.25
6111, 0.5, 1.18, 0.25
6112, 0.5, 0.22, 0.3
6113, 0.5, 0.34, 0.3
6114, 0.5, 0.46, 0.3
6115, 0.5, 0.58, 0.3
6116, 0.5, 0.7, 0.3
6117, 0.5, 0.82, 0.3
6118, 0.5, 0.94, 0.3
6119, 0.5, 1.06, 0.3
6120, 0.5, 1.18, 0.3
6121, 0.5, 0.22, 0.35
6122, 0.5, 0.34, 0.35
6123, 0.5, 0.46, 0.35
6124, 0.5, 0.58, 0.35
6125, 0.5, 0.7, 0.35
6126, 0.5, 0.82, 0.35
6127, 0.5, 0.94, 0.35
6128, 0.5, 1.06, 0.35
6129, 0.5, 1.18, 0.35
6130, 0.5, 0.22, 0.4
6131, 0.5, 0.34, 0.4
6132, 0.5, 0.46, 0.4
6133, 0.5, 0.58, 0.4
6134, 0.5, 0.7, 0.4
6135, 0.5, 0.82, 0.4
6136, 0.5, 0.94, 0.4
6137, 0.5, 1.06, 0.4
6138, 0.5, 1.18, 0.4
6139, 0.5, 0.22, 0.45
6140, 0.5, 0.34, 0.45
6141, 0.5, 0.46, 0.45
6142, 0.5, 0.58, 0.45
6143, 0.5, 0.7, 0.45
6144, 0.5, 0.82, 0.45
6145, 0.5, 0.94, 0.45
6146, 0.5, 1.06, 0.45
6147, 0.5, 1.18, 0.45
6148, 0.58333333333333, 0.22, 0.05
6149, 0.58333333333333, 0.34, 0.05
6150, 0.58333333333333, 0.46, 0.05
6151, 0.58333333333333, 0.58, 0.05
6152, 0.58333333333333, 0.7, 0.05
6153, 0.58333333333333, 0.82, 0.05
6154, 0.58333333333333, 0.94, 0.05
6155, 0.58333333333333, 1.06, 0.05
6156, 0.58333333333333, 1.18, 0.05
6157, 0.58333333333333, 0.22, 0.1
6158, 0.58333333333333, 0.34, 0.1
6159, 0.58333333333333, 0.46, 0.1
6160, 0.58333333333333, 0.58, 0.1
6161, 0.58333333333333, 0.7, 0.1
6162, 0.58333333333333, 0.82, 0.1
6163, 0.58333333333333, 0.94, 0.1
6164, 0.58333333333333, 1.06, 0.1
6165, 0.58333333333333, 1.18, 0.1
6166, 0.58333333333333, 0.22, 0.15
6167, 0.58333333333333, 0.34, 0.15
6168, 0.58333333333333, 0.46, 0.15
6169, 0.58333333333333, 0.58, 0.15
6170, 0.58333333333333, 0.7, 0.15
6171, 0.58333333333333, 0.82, 0.15
6172, 0.58333333333333, 0.94, 0.15
6173, 0.58333333333333, 1.06, 0.15
6174, 0.58333333333333, 1.18, 0.15
6175, 0.58333333333333, 0.22, 0.2
6176, 0.58333333333333, 0.34, 0.2
6177, 0.58333333333333, 0.46, 0.2
6178, 0.58333333333333, 0.58, 0.2
6179, 0.58333333333333, 0.7, 0.2
6180, 0.58333333333333, 0.82, 0.2
6181, 0.58333333333333, 0.94, 0.2
6182, 0.58333333333333, 1.06, 0.2
6183, 0.58333333333333, 1.18, 0.2
6184, 0.58333333333333, 0.22, 0.25
6185, 0.58333333333333, 0.34, 0.25
6186, 0.58333333333333, 0.46, 0.25
6187, 0.58333333333333, 0.58, 0.25
6188, 0.58333333333333, 0.7, 0.25
6189, 0.58333333333333, 0.82, 0.25
6190, 0.58333333333333, 0.94, 0.25
6191, 0.58333333333333, 1.06, 0.25
6192, 0.58333333333333, 1.18, 0.25
6193, 0.58333333333333, 0.22, 0.3
6194, 0.58333333333333, 0.34, 0.3
6195, 0.58333333333333, 0.46, 0.3
6196, 0.58333333333333, 0.58, 0.3
6197, 0.58333333333333, 0.7, 0.3
6198, 0.58333333333333, 0.82, 0.3
6199, 0.58333333333333, 0.94, 0.3
6200, 0.58333333333333, 1.06, 0.3
6201, 0.58333333333333, 1.18, 0.3
6202, 0.58333333333333, 0.22, 0.35
6203, 0.58333333333333, 0.34, 0.35
6204, 0.58333333333333, 0.46, 0.35
6205, 0.58333333333333, 0.58, 0.35
6206, 0.58333333333333, 0.7, 0.35
6207, 0.58333333333333, 0.82, 0.35
6208, 0.58333333333333, 0.94, 0.35
6209, 0.58333333333333, 1.06, 0.35
6210, 0.58333333333333, 1.18, 0.35
6211, 0.58333333333333, 0.22, 0.4
6212, 0.58333333333333, 0.34, 0.4
6213, 0.58333333333333, 0.46, 0.4
6214, 0.58333333333333, 0.58, 0.4
6215, 0.58333333333333, 0.7, 0.4
6216, 0.58333333333333, 0.82, 0.4
6217, 0.58333333333333, 0.94, 0.4
6218, 0.58333333333333, 1.06, 0.4
6219, 0.58333333333333, 1.18, 0.4
6220, 0.58333333333333, 0.22, 0.45
6221, 0.58333333333333, 0.34, 0.45
6222, 0.58333333333333, 0.46, 0.45
6223, 0.58333333333333, 0.58, 0.45
6224, 0.58333333333333, 0.7, 0.45
6225, 0.58333333333333, 0.82, 0.45
6226, 0.58333333333333, 0.94, 0.45
6227, 0.58333333333333, 1.06, 0.45
6228, 0.58333333333333, 1.18, 0.45
6229, 0.66666666666667, 0.22, 0.05
6230, 0.66666666666667, 0.34, 0.05
6231, 0.66666666666667, 0.46, 0.05
6232, 0.66666666666667, 0.58, 0.05
6233, 0.66666666666667, 0.7, 0.05
6234, 0.66666666666667, 0.82, 0.05
6235, 0.66666666666667, 0.94, 0.05
6236, 0.66666666666667, 1.06, 0.05
6237, 0.66666666666667, 1.18, 0.05
6238, 0.66666666666667, 0.22, 0.1
6239, 0.66666666666667, 0.34, 0.1
6240, 0.66666666666667, 0.46, 0.1
6241, 0.66666666666667, 0.58, 0.1
6242, 0.66666666666667, 0.7, 0.1
6243, 0.66666666666667, 0.82, 0.1
6244, 0.66666666666667, 0.94, 0.1
6245, 0.66666666666667, 1.06, 0.1
6246, 0.66666666666667, 1.18, 0.1
6247, 0.66666666666667, 0.22, 0.15
6248, 0.66666666666667, 0.34, 0.15
6249, 0.66666666666667, 0.46, 0.15
6250, 0.66666666666667, 0.58, 0.15
6251, 0.66666666666667, 0.7, 0.15
6252, 0.66666666666667, 0.82, 0.15
6253, 0.66666666666667, 0.94, 0.15
6254, 0.66666666666667, 1.06, 0.15
6255, 0.66666666666667, 1.18, 0.15
6256, 0.66666666666667, 0.22, 0.2
6257, 0.66666666666667, 0.34, 0.2
6258, 0.66666666666667, 0.46, 0.2
6259, 0.66666666666667, 0.58, 0.2
6260, 0.66666666666667, 0.7, 0.2
6261, 0.66666666666667, 0.82, 0.2
6262, 0.66666666666667, 0.94, 0.2
6263, 0.66666666666667, 1.06, 0.2
6264, 0.66666666666667, 1.18, 0.2
6265, 0.66666666666667, 0.22, 0.25
6266, 0.66666666666667, 0.34, 0.25
6267, 0.66666666666667, 0.46, 0.25
6268, 0.66666666666667, 0.58, 0.25
6269, 0.66666666666667, 0.7, 0.25
6270, 0.66666666666667, 0.82, 0.25
6271, 0.66666666666667, 0.94, 0.25
6272, 0.66666666666667, 1.06, 0.25
6273, 0.66666666666667, 1.18, 0.25
6274, 0.66666666666667, 0.22, 0.3
6275, 0.66666666666667, 0.34, 0.3
6276, 0.66666666666667, 0.46, 0.3
6277, 0.66666666666667, 0.58, 0.3
6278, 0.66666666666667, 0.7, 0.3
6279, 0.66666666666667, 0.82, 0.3
6280, 0.66666666666667, 0.94, 0.3
6281, 0.66666666666667, 1.06, 0.3
6282, 0.66666666666667, 1.18, 0.3
6283, 0.66666666666667, 0.22, 0.35
6284, 0.66666666666667, 0.34, 0.35
6285, 0.66666666666667, 0.46, 0.35
6286, 0.66666666666667, 0.58, 0.35
6287, 0.66666666666667, 0.7, 0.35
6288, 0.66666666666667, 0.82, 0.35
6289, 0.66666666666667, 0.94, 0.35
6290, 0.66666666666667, 1.06, 0.35
6291, 0.66666666666667, 1.18, 0.35
6292, 0.66666666666667, 0.22, 0.4
6293, 0.66666666666667, 0.34, 0.4
6294, 0.66666666666667, 0.46, 0.4
6295, 0.66666666666667, 0.58, 0.4
6296, 0.66666666666667, 0.7, 0.4
6297, 0.66666666666667, 0.82, 0.4
6298, 0.66666666666667, 0.94, 0.4
6299, 0.66666666666667, 1.06, 0.4
6300, 0.66666666666667, 1.18, 0.4
6301, 0.66666666666667, 0.22, 0.45
6302, 0.66666666666667, 0.34, 0.45
6303, 0.66666666666667, 0.46, 0.45
6304, 0.66666666666667, 0.58, 0.45
6305, 0.66666666666667, 0.7, 0.45
6306, 0.66666666666667, 0.82, 0.45
6307, 0.66666666666667, 0.94, 0.45
6308, 0.66666666666667, 1.06, 0.45
6309, 0.66666666666667, 1.18, 0.45
6310, 0.75, 0.22, 0.05
6311, 0.75, 0.34, 0.05
6312, 0.75, 0.46, 0.05
6313, 0.75, 0.58, 0.05
6314, 0.75, 0.7, 0.05
6315, 0.75, 0.82, 0.05
6316, 0.75, 0.94, 0.05
6317, 0.75, 1.06, 0.05
6318, 0.75, 1.18, 0.05
6319, 0.75, 0.22, 0.1
6320, 0.75, 0.34, 0.1
6321, 0.75, 0.46, 0.1
6322, 0.75, 0.58, 0.1
6323, 0.75, 0.7, 0.1
6324, 0.75, 0.82, 0.1
6325, 0.75, 0.94, 0.1
6326, 0.75, 1.06, 0.1
6327, 0.75, 1.18, 0.1
6328, 0.75, 0.22, 0.15
6329, 0.75, 0.34, 0.15
6330, 0.75, 0.46, 0.15
6331, 0.75, 0.58, 0.15
6332, 0.75, 0.7, 0.15
6333, 0.75, 0.82, 0.15
6334, 0.75, 0.94, 0.15
6335, 0.75, 1.06, 0.15
6336, 0.75, 1.18, 0.15
6337, 0.75, 0.22, 0.2
6338, 0.75, 0.34, 0.2
6339, 0.75, 0.46, 0.2
6340, 0.75, 0.58, 0.2
6341, 0.75, 0.7, 0.2
6342, 0.75, 0.82, 0.2
6343, 0.75, 0.94, 0.2
6344, 0.75, 1.06, 0.2
6345, 0.75, 1.18, 0.2
6346, 0.75, 0.22, 0.25
6347, 0.75, 0.34, 0.25
6348, 0.75, 0.46, 0.25
6349, 0.75, 0.58, 0.25
6350, 0.75, 0.7, 0.25
6351, 0.75, 0.82, 0.25
6352, 0.75, 0.94, 0.25
6353, 0.75, 1.06, 0.25
6354, 0.75, 1.18, 0.25
6355, 0.75, 0.22, 0.3
6356, 0.75, 0.34, 0.3
6357, 0.75, 0.46, 0.3
6358, 0.75, 0.58, 0.3
6359, 0.75, 0.7, 0.3
6360, 0.75, 0.82, 0.3
6361, 0.75, 0.94, 0.3
6362, 0.75, 1.06, 0.3
6363, 0.75, 1.18, 0.3
6364, 0.75, 0.22, 0.35
6365, 0.75, 0.34, 0.35
6366, 0.75, 0.46, 0.35
6367, 0.75, 0.58, 0.35
6368, 0.75, 0.7, 0.35
6369, 0.75, 0.82, 0.35
6370, 0.75, 0.94, 0.35
6371, 0.75, 1.06, 0.35
6372, 0.75, 1.18, 0.35
6373, 0.75, 0.22, 0.4
6374, 0.75, 0.34, 0.4
6375, 0.75, 0.46, 0.4
6376, 0.75, 0.58, 0.4
6377, 0.75, 0.7, 0.4
6378, 0.75, 0.82, 0.4
6379, 0.75, 0.94, 0.4
6380, 0.75, 1.06, 0.4
6381, 0.75, 1.18, 0.4
6382, 0.75, 0.22, 0.45
6383, 0.75, 0.34, 0.45
6384, 0.75, 0.46, 0.45
6385, 0.75, 0.58, 0.45
6386, 0.75, 0.7, 0.45
6387, 0.75, 0.82, 0.45
6388, 0.75, 0.94, 0.45
6389, 0.75, 1.06, 0.45
6390, 0.75, 1.18, 0.45
6391, 0.83333333333333, 0.22, 0.05
6392, 0.83333333333333, 0.34, 0.05
6393, 0.83333333333333, 0.46, 0.05
6394, 0.83333333333333, 0.58, 0.05
6395, 0.83333333333333, 0.7, 0.05
6396, 0.83333333333333, 0.82, 0.05
6397, 0.83333333333333, 0.94, 0.05
6398, 0.83333333333333, 1.06, 0.05
6399, 0.83333333333333, 1.18, 0.05
6400, 0.83333333333333, 0.22, 0.1
6401, 0.83333333333333, 0.34, 0.1
6402, 0.83333333333333, 0.46, 0.1
6403, 0.83333333333333, 0.58, 0.1
6404, 0.83333333333333, 0.7, 0.1
6405, 0.83333333333333, 0.82, 0.1
6406, 0.83333333333333, 0.94, 0.1
6407, 0.83333333333333, 1.06, 0.1
6408, 0.83333333333333, 1.18, 0.1
6409, 0.83333333333333, 0.22, 0.15
6410, 0.83333333333333, 0.34, 0.15
6411, 0.83333333333333, 0.46, 0.15
6412, 0.83333333333333, 0.58, 0.15
6413, 0.83333333333333, 0.7, 0.15
6414, 0.83333333333333, 0.82, 0.15
6415, 0.83333333333333, 0.94, 0.15
6416, 0.83333333333333, 1.06, 0.15
6417, 0.83333333333333, 1.18, 0.15
6418, 0.83333333333333, 0.22, 0.2
6419, 0.83333333333333, 0.34, 0.2
6420, 0.83333333333333, 0.46, 0.2
6421, 0.83333333333333, 0.58, 0.2
6422, 0.83333333333333, 0.7, 0.2
6423, 0.83333333333333, 0.82, 0.2
6424, 0.83333333333333, 0.94, 0.2
6425, 0.83333333333333, 1.06, 0.2
6426, 0.83333333333333, 1.18, 0.2
6427, 0.83333333333333, 0.22, 0.25
6428, 0.83333333333333, 0.34, 0.25
6429, 0.83333333333333, 0.46, 0.25
6430, 0.83333333333333, 0.58, 0.25
6431, 0.83333333333333, 0.7, 0.25
6432, 0.83333333333333, 0.82, 0.25
6433, 0.83333333333333, 0.94, 0.25
6434, 0.83333333333333, 1.06, 0.25
6435, 0.83333333333333, 1.18, 0.25
6436, 0.83333333333333, 0.22, 0.3
6437, 0.83333333333333, 0.34, 0.3
6438, 0.83333333333333, 0.46, 0.3
6439, 0.83333333333333, 0.58, 0.3
6440, 0.83333333333333, 0.7, 0.3
6441, 0.83333333333333, 0.82, 0.3
6442, 0.83333333333333, 0.94, 0.3
6443, 0.83333333333333, 1.06, 0.3
6444, 0.83333333333333, 1.18, 0.3
6445, 0.83333333333333, 0.22, 0.35
6446, 0.83333333333333, 0.34, 0.35
6447, 0.83333333333333, 0.46, 0.35
6448, 0.83333333333333, 0.58, 0.35
6449, 0.83333333333333, 0.7, 0.35
6450, 0.83333333333333, 0.82, 0.35
6451, 0.83333333333333, 0.94, 0.35
6452, 0.83333333333333, 1.06, 0.35
6453, 0.83333333333333, 1.18, 0.35
6454, 0.83333333333333, 0.22, 0.4
6455, 0.83333333333333, 0.34, 0.4
6456, 0.83333333333333, 0.46, 0.4
6457, 0.83333333333333, 0.58, 0.4
6458, 0.83333333333333, 0.7, 0.4
6459, 0.83333333333333, 0.82, 0.4
6460, 0.83333333333333, 0.94, 0.4
6461, 0.83333333333333, 1.06, 0.4
6462, 0.83333333333333, 1.18, 0.4
6463, 0.83333333333333, 0.22, 0.45
6464, 0.83333333333333, 0.34, 0.45
6465, 0.83333333333333, 0.46, 0.45
6466, 0.83333333333333, 0.58, 0.45
6467, 0.83333333333333, 0.7, 0.45
6468, 0.83333333333333, 0.82, 0.45
6469, 0.83333333333333, 0.94, 0.45
6470, 0.83333333333333, 1.06, 0.45
6471, 0.83333333333333, 1.18, 0.45
6472, 0.91666666666667, 0.22, 0.05
6473, 0.91666666666667, 0.34, 0.05
6474, 0.91666666666667, 0.46, 0.05
6475, 0.91666666666667, 0.58, 0.05
6476, 0.91666666666667, 0.7, 0.05
6477, 0.91666666666667, 0.82, 0.05
6478, 0.91666666666667, 0.94, 0.05
6479, 0.91666666666667, 1.06, 0.05
6480, 0.91666666666667, 1.18, 0.05
6481, 0.91666666666667, 0.22, 0.1
6482, 0.91666666666667, 0.34, 0.1
6483, 0.91666666666667, 0.46, 0.1
6484, 0.91666666666667, 0.58, 0.1
6485, 0.91666666666667, 0.7, 0.1
6486, 0.91666666666667, 0.82, 0.1
6487, 0.91666666666667, 0.94, 0.1
6488, 0.91666666666667, 1.06, 0.1
6489, 0.91666666666667, 1.18, 0.1
6490, 0.91666666666667, 0.22, 0.15
6491, 0.91666666666667, 0.34, 0.15
6492, 0.91666666666667, 0.46, 0.15
6493, 0.91666666666667, 0.58, 0.15
6494, 0.91666666666667, 0.7, 0.15
6495, 0.91666666666667, 0.82, 0.15
6496, 0.91666666666667, 0.94, 0.15
6497, 0.91666666666667, 1.06, 0.15
6498, 0.91666666666667, 1.18, 0.15
6499, 0.91666666666667, 0.22, 0.2
6500, 0.91666666666667, 0.34, 0.2
6501, 0.91666666666667, 0.46, 0.2
6502, 0.91666666666667, 0.58, 0.2
6503, 0.91666666666667, 0.7, 0.2
6504, 0.91666666666667, 0.82, 0.2
6505, 0.91666666666667, 0.94, 0.2
6506, 0.91666666666667, 1.06, 0.2
6507, 0.91666666666667, 1.18, 0.2
6508, 0.91666666666667, 0.22, 0.25
6509, 0.91666666666667, 0.34, 0.25
6510, 0.91666666666667, 0.46, 0.25
6511, 0.91666666666667, 0.58, 0.25
6512, 0.91666666666667, 0.7, 0.25
6513, 0.91666666666667, 0.82, 0.25
6514, 0.91666666666667, 0.94, 0.25
6515, 0.91666666666667, 1.06, 0.25
6516, 0.91666666666667, 1.18, 0.25
6517, 0.91666666666667, 0.22, 0.3
6518, 0.91666666666667, 0.34, 0.3
6519, 0.91666666666667, 0.46, 0.3
6520, 0.91666666666667, 0.58, 0.3
6521, 0.91666666666667, 0.7, 0.3
6522, 0.91666666666667, 0.82, 0.3
6523, 0.91666666666667, 0.94, 0.3
6524, 0.91666666666667, 1.06, 0.3
6525, 0.91666666666667, 1.18, 0.3
6526, 0.91666666666667, 0.22, 0.35
6527, 0.91666666666667, 0.34, 0.35
6528, 0.91666666666667, 0.46, 0.35
6529, 0.91666666666667, 0.58, 0.35
6530, 0.91666666666667, 0.7, 0.35
6531, 0.91666666666667, 0.82, 0.35
6532, 0.91666666666667, 0.94, 0.35
6533, 0.91666666666667, 1.06, 0.35
6534, 0.91666666666667, 1.18, 0.35
6535, 0.91666666666667, 0.22, 0.4
6536, 0.91666666666667, 0.34, 0.4
6537, 0.91666666666667, 0.46, 0.4
6538, 0.91666666666667, 0.58, 0.4
6539, 0.91666666666667, 0.7, 0.4
6540, 0.91666666666667, 0.82, 0.4
6541, 0.91666666666667, 0.94, 0.4
6542, 0.91666666666667, 1.06, 0.4
6543, 0.91666666666667, 1.18, 0.4
6544, 0.91666666666667, 0.22, 0.45
6545, 0.91666666666667, 0.34, 0.45
6546, 0.91666666666667, 0.46, 0.45
6547, 0.91666666666667, 0.58, 0.45
6548, 0.91666666666667, 0.7, 0.45
6549, 0.91666666666667, 0.82, 0.45
6550, 0.91666666666667, 0.94, 0.45
6551, 0.91666666666667, 1.06, 0.45
6552, 0.91666666666667, 1.18, 0.45
6553, 0.083333333333333, 1.3625, 0.05
6554, 0.083333333333333, 1.375, 0.05
6555, 0.083333333333333, 1.3875, 0.05
6556, 0.083333333333333, 1.3625, 0.1
6557, 0.083333333333333, 1.375, 0.1
6558, 0.083333333333333, 1.3875, 0.1
6559, 0.083333333333333, 1.3625, 0.15
6560, 0.083333333333333, 1.375, 0.15
6561, 0.083333333333333, 1.3875, 0.15
6562, 0.083333333333333, 1.3625, 0.2
6563, 0.083333333333333, 1.375, 0.2
6564, 0.083333333333333, 1.3875, 0.2
6565, 0.083333333333333, 1.3625, 0.25
6566, 0.083333333333333, 1.375, 0.25
6567, 0.083333333333333, 1.3875, 0.25
6568, 0.083333333333333, 1.3625, 0.3
6569, 0.083333333333333, 1.375, 0.3
6570, 0.083333333333333, 1.3875, 0.3
6571, 0.083333333333333, 1.3625, 0.35
6572, 0.083333333333333, 1.375, 0.35
6573, 0.083333333333333, 1.3875, 0.35
6574, 0.083333333333333, 1.3625, 0.4
6575, 0.083333333333333, 1.375, 0.4
6576, 0.083333333333333, 1.3875, 0.4
6577, 0.083333333333333, 1.3625, 0.45
6578, 0.083333333333333, 1.375, 0.45
6579, 0.083333333333333, 1.3875, 0.45
6580, 0.16666666666667, 1.3625, 0.05
6581, 0.16666666666667, 1.375, 0.05
6582, 0.16666666666667, 1.3875, 0.05
6583, 0.16666666666667, 1.3625, 0.1
6584, 0.16666666666667, 1.375, 0.1
6585, 0.16666666666667, 1.3875, 0.1
6586, 0.16666666666667, 1.3625, 0.15
6587, 0.16666666666667, 1.375, 0.15
6588, 0.16666666666667, 1.3875, 0.15
6589, 0.16666666666667, 1.3625, 0.2
6590, 0.16666666666667, 1.375, 0.2
6591, 0.16666666666667, 1.3875, 0.2
6592, 0.16666666666667, 1.3625, 0.25
6593, 0.16666666666667, 1.375, 0.25
6594, 0.16666666666667, 1.3875, 0.25
6595, 0.16666666666667, 1.3625, 0.3
6596, 0.16666666666667, 1.375, 0.3
6597, 0.16666666666667, 1.3875, 0.3
6598, 0.16666666666667, 1.3625, 0.35
6599, 0.16666666666667, 1.375, 0.35
6600, 0.16666666666667, 1.3875, 0.35
6601, 0.16666666666667, 1.3625, 0.4
6602, 0.16666666666667, 1.375, 0.4
6603, 0.16666666666667, 1.3875, 0.4
6604, 0.16666666666667, 1.3625, 0.45
6605, 0.16666666666667, 1.375, 0.45
6606, 0.16666666666667, 1.3875, 0.45
6607, 0.25, 1.3625, 0.05
6608, 0.25, 1.375, 0.05
6609, 0.25, 1.3875, 0.05
6610, 0.25, 1.3625, 0.1
6611, 0.25, 1.375, 0.1
6612, 0.25, 1.3875, 0.1
6613, 0.25, 1.3625, 0.15
6614, 0.25, 1.375, 0.15
6615, 0.25, 1.3875, 0.15
6616, 0.25, 1.3625, 0.2
6617, 0.25, 1.375, 0.2
6618, 0.25, 1.3875, 0.2
6619, 0.25, 1.3625, 0.25
6620, 0.25, 1.375, 0.25
6621, 0.25, 1.3875, 0.25
6622, 0.25, 1.3625, 0.3
6623, 0.25, 1.375, 0.3
6624, 0.25, 1.3875, 0.3
6625, 0.25, 1.3625, 0.35
6626, 0.25, 1.375, 0.35
6627, 0.25, 1.3875, 0.35
6628, 0.25, 1.3625, 0.4
6629, 0.25, 1.375, 0.4
6630, 0.25, 1.3875, 0.4
6631, 0.25, 1.3625, 0.45
6632, 0.25, 1.375, 0.45
6633, 0.25, 1.3875, 0.45
6634, 0.33333333333333, 1.3625, 0.05
6635, 0.33333333333333, 1.375, 0.05
6636, 0.33333333333333, 1.3875, 0.05
6637, 0.33333333333333, 1.3625, 0.1
6638, 0.33333333333333, 1.375, 0.1
6639, 0.33333333333333, 1.3875, 0.1
6640, 0.33333333333333, 1.3625, 0.15
6641, 0.33333333333333, 1.375, 0.15
6642, 0.33333333333333, 1.3875, 0.15
6643, 0.33333333333333, 1.3625, 0.2
6644, 0.33333333333333, 1.375, 0.2
6645, 0.33333333333333, 1.3875, 0.2
6646, 0.33333333333333, 1.3625, 0.25
6647, 0.33333333333333, 1.375, 0.25
6648, 0.33333333333333, 1.3875, 0.25
6649, 0.33333333333333, 1.3625, 0.3
6650, 0.33333333333333, 1.375, 0.3
6651, 0.33333333333333, 1.3875, 0.3
6652, 0.33333333333333, 1.3625, 0.35
6653, 0.33333333333333, 1.375, 0.35
6654, 0.33333333333333, 1.3875, 0.35
6655, 0.33333333333333, 1.3625, 0.4
6656, 0.33333333333333, 1.375, 0.4
6657, 0.33333333333333, 1.3875, 0.4
6658, 0.33333333333333, 1.3625, 0.45
6659, 0.33333333333333, 1.375, 0.45
6660, 0.33333333333333, 1.3875, 0.45
6661, 0.41666666666667, 1.3625, 0.05
6662, 0.41666666666667, 1.375, 0.05
6663, 0.41666666666667, 1.3875, 0.05
6664, 0.41666666666667, 1.3625, 0.1
6665, 0.41666666666667, 1.375, 0.1
6666, 0.41666666666667, 1.3875, 0.1
6667, 0.41666666666667, 1.3625, 0.15
6668, 0.41666666666667, 1.375, 0.15
6669, 0.41666666666667, 1.3875, 0.15
6670, 0.41666666666667, 1.3625, 0.2
6671, 0.41666666666667, 1.375, 0.2
6672, 0.41666666666667, 1.3875, 0.2
6673, 0.41666666666667, 1.3625, 0.25
6674, 0.41666666666667, 1.375, 0.25
6675, 0.41666666666667, 1.3875, 0.25
6676, 0.41666666666667, 1.3625, 0.3
6677, 0.41666666666667, 1.375, 0.3
6678, 0.41666666666667, 1.3875, 0.3
6679, 0.41666666666667, 1.3625, 0.35
6680, 0.41666666666667, 1.375, 0.35
6681, 0.41666666666667, 1.3875, 0.35
6682, 0.41666666666667, 1.3625, 0.4
6683, 0.41666666666667, 1.375, 0.4
6684, 0.41666666666667, 1.3875, 0.4
6685, 0.41666666666667, 1.3625, 0.45
6686, 0.41666666666667, 1.375, 0.45
6687, 0.41666666666667, 1.3875, 0.45
6688, 0.5, 1.3625, 0.05
6689, 0.5, 1.375, 0.05
6690, 0.5, 1.3875, 0.05
6691, 0.5, 1.3625, 0.1
6692, 0.5, 1.375, 0.1
6693, 0.5, 1.3875, 0.1
6694, 0.5, 1.3625, 0.15
6695, 0.5, 1.375, 0.15
6696, 0.5, 1.3875, 0.15
6697, 0.5, 1.3625, 0.2
6698, 0.5, 1.375, 0.2
6699, 0.5, 1.3875, 0.2
6700, 0.5, 1.3625, 0.25
6701, 0.5, 1.375, 0.25
6702, 0.5, 1.3875, 0.25
6703, 0.5, 1.3625, 0.3
6704, 0.5, 1.375, 0.3
6705, 0.5, 1.3875, 0.3
6706, 0.5, 1.3625, 0.35
6707, 0.5, 1.375, 0.35
6708, 0.5, 1.3875, 0.35
6709, 0.5, 1.3625, 0.4
6710, 0.5, 1.375, 0.4
6711, 0.5, 1.3875, 0.4
6712, 0.5, 1.3625, 0.45
6713, 0.5, 1.375, 0.45
6714, 0.5, 1.3875, 0.45
6715, 0.58333333333333, 1.3625, 0.05
6716, 0.58333333333333, 1.375, 0.05
6717, 0.58333333333333, 1.3875, 0.05
6718, 0.58333333333333, 1.3625, 0.1
6719, 0.58333333333333, 1.375, 0.1
6720, 0.58333333333333, 1.3875, 0.1
6721, 0.58333333333333, 1.3625, 0.15
6722, 0.58333333333333, 1.375, 0.15
6723, 0.58333333333333, 1.3875, 0.15
6724, 0.58333333333333, 1.3625, 0.2
6725, 0.58333333333333, 1.375, 0.2
6726, 0.58333333333333, 1.3875, 0.2
6727, 0.58333333333333, 1.3625, 0.25
6728, 0.58333333333333, 1.375, 0.25
6729, 0.58333333333333, 1.3875, 0.25
6730, 0.58333333333333, 1.3625, 0.3
6731, 0.58333333333333, 1.375, 0.3
6732, 0.58333333333333, 1.3875, 0.3
6733, 0.58333333333333, 1.3625, 0.35
6734, 0.58333333333333, 1.375, 0.35
6735, 0.58333333333333, 1.3875, 0.35
6736, 0.58333333333333, 1.3625, 0.4
6737, 0.58333333333333, 1.375, 0.4
6738, 0.58333333333333, 1.3875, 0.4
6739, 0.58333333333333, 1.3625, 0.45
6740, 0.58333333333333, 1.375, 0.45
6741, 0.58333333333333, 1.3875, 0.45
6742, 0.66666666666667, 1.3625, 0.05
6743, 0.66666666666667, 1.375, 0.05
6744, 0.66666666666667, 1.3875, 0.05
6745, 0.66666666666667, 1.3625, 0.1
6746, 0.66666666666667, 1.375, 0.1
6747, 0.66666666666667, 1.3875, 0.1
6748, 0.66666666666667, 1.3625, 0.15
6749, 0.66666666666667, 1.375, 0.15
6750, 0.66666666666667, 1.3875, 0.15
6751, 0.66666666666667, 1.3625, 0.2
6752, 0.66666666666667, 1.375, 0.2
6753, 0.66666666666667, 1.3875, 0.2
6754, 0.66666666666667, 1.3625, 0.25
6755, 0.66666666666667, 1.375, 0.25
6756, 0.66666666666667, 1.3875, 0.25
6757, 0.66666666666667, 1.3625, 0.3
6758, 0.66666666666667, 1.375, 0.3
6759, 0.66666666666667, 1.3875, 0.3
6760, 0.66666666666667, 1.3625, 0.35
6761, 0.66666666666667, 1.375, 0.35
6762, 0.66666666666667, 1.3875, 0.35
6763, 0.66666666666667, 1.3625, 0.4
6764, 0.66666666666667, 1.375, 0.4
6765, 0.66666666666667, 1.3875, 0.4
6766, 0.66666666666667, 1.3625, 0.45
6767, 0.66666666666667, 1.375, 0.45
6768, 0.66666666666667, 1.3875, 0.45
6769, 0.75, 1.3625, 0.05
6770, 0.75, 1.375, 0.05
6771, 0.75, 1.3875, 0.05
6772, 0.75, 1.3625, 0.1
6773, 0.75, 1.375, 0.1
6774, 0.75, 1.3875, 0.1
6775, 0.75, 1.3625, 0.15
6776, 0.75, 1.375, 0.15
6777, 0.75, 1.3875, 0.15
6778, 0.75, 1.3625, 0.2
6779, 0.75, 1.375, 0.2
6780, 0.75, 1.3875, 0.2
6781, 0.75, 1.3625, 0.25
6782, 0.75, 1.375, 0.25
6783, 0.75, 1.3875, 0.25
6784, 0.75, 1.3625, 0.3
6785, 0.75, 1.375, 0.3
6786, 0.75, 1.3875, 0.3
6787, 0.75, 1.3625, 0.35
6788, 0.75, 1.375, 0.35
6789, 0.75, 1.3875, 0.35
6790, 0.75, 1.3625, 0.4
6791, 0.75, 1.375, 0.4
6792, 0.75, 1.3875, 0.4
6793, 0.75, 1.3625, 0.45
6794, 0.75, 1.375, 0.45
6795, 0.75, 1.3875, 0.45
6796, 0.83333333333333, 1.3625, 0.05
6797, 0.83333333333333, 1.375, 0.05
6798, 0.83333333333333, 1.3875, 0.05
6799, 0.83333333333333, 1.3625, 0.1
6800, 0.83333333333333, 1.375, 0.1
6801, 0.83333333333333, 1.3875, 0.1
6802, 0.83333333333333, 1.3625, 0.15
6803, 0.83333333333333, 1.375, 0.15
6804, 0.83333333333333, 1.3875, 0.15
6805, 0.83333333333333, 1.3625, 0.2
6806, 0.83333333333333, 1.375, 0.2
6807, 0.83333333333333, 1.3875, 0.2
6808, 0.83333333333333, 1.3625, 0.25
6809, 0.83333333333333, 1.375, 0.25
6810, 0.83333333333333, 1.3875, 0.25
6811, 0.83333333333333, 1.3625, 0.3
6812, 0.83333333333333, 1.375, 0.3
6813, 0.83333333333333, 1.3875, 0.3
6814, 0.83333333333333, 1.3625, 0.35
6815, 0.83333333333333, 1.375, 0.35
6816, 0.83333333333333, 1.3875, 0.35
6817, 0.83333333333333, 1.3625, 0.4
6818, 0.83333333333333, 1.375, 0.4
6819, 0.83333333333333, 1.3875, 0.4
6820, 0.83333333333333, 1.3625, 0.45
6821, 0.83333333333333, 1.375, 0.45
6822, 0.83333333333333, 1.3875, 0.45
6823, 0.91666666666667, 1.3625, 0.05
6824, 0.91666666666667, 1.375, 0.05
6825, 0.91666666666667, 1.3875, 0.05
6826, 0.91666666666667, 1.3625, 0.1
6827, 0.91666666666667, 1.375, 0.1
6828, 0.91666666666667, 1.3875, 0.1
6829, 0.91666666666667, 1.3625, 0.15
6830, 0.91666666666667, 1.375, 0.15
6831, 0.91666666666667, 1.3875, 0.15
6832, 0.91666666666667, 1.3625, 0.2
6833, 0.91666666666667, 1.375, 0.2
6834, 0.91666666666667, 1.3875, 0.2
6835, 0.91666666666667, 1.3625, 0.25
6836, 0.91666666666667, 1.375, 0.25
6837, 0.91666666666667, 1.3875, 0.25
6838, 0.91666666666667, 1.3625, 0.3
6839, 0.91666666666667, 1.375, 0.3
6840, 0.91666666666667, 1.3875, 0.3
6841, 0.91666666666667, 1.3625, 0.35
6842, 0.91666666666667, 1.375, 0.35
6843, 0.91666666666667, 1.3875, 0.35
6844, 0.91666666666667, 1.3625, 0.4
6845, 0.91666666666667, 1.375, 0.4
6846, 0.91666666666667, 1.3875, 0.4
6847, 0.91666666666667, 1.3625, 0.45
6848, 0.91666666666667, 1.375, 0.45
6849, 0.91666666666667, 1.3875, 0.45
6850, 1.0285714285714, 1.3625, 0.05
6851, 1.0571428571429, 1.3625, 0.05
6852, 1.0857142857143, 1.3625, 0.05
6853, 1.1142857142857, 1.3625, 0.05
6854, 1.1428571428571, 1.3625, 0.05
6855, 1.1714285714286, 1.3625, 0.05
6856, 1.0285714285714, 1.375, 0.05
6857, 1.0571428571429, 1.375, 0.05
6858, 1.0857142857143, 1.375, 0.05
6859, 1.1142857142857, 1.375, 0.05
6860, 1.1428571428571, 1.375, 0.05
6861, 1.1714285714286, 1.375, 0.05
6862, 1.0285714285714, 1.3875, 0.05
6863, 1.0571428571429, 1.3875, 0.05
6864, 1.0857142857143, 1.3875, 0.05
6865, 1.1142857142857, 1.3875, 0.05
6866, 1.1428571428571, 1.3875, 0.05
6867, 1.1714285714286, 1.3875, 0.05
6868, 1.0285714285714, 1.3625, 0.1
6869, 1.0571428571429, 1.3625, 0.1
6870, 1.0857142857143, 1.3625, 0.1
6871, 1.1142857142857, 1.3625, 0.1
6872, 1.1428571428571, 1.3625, 0.1
6873, 1.1714285714286, 1.3625, 0.1
6874, 1.0285714285714, 1.375, 0.1
6875, 1.0571428571429, 1.375, 0.1
6876, 1.0857142857143, 1.375, 0.1
6877, 1.1142857142857, 1.375, 0.1
6878, 1.1428571428571, 1.375, 0.1
6879, 1.1714285714286, 1.375, 0.1
6880, 1.0285714285714, 1.3875, 0.1
6881, 1.0571428571429, 1.3875, 0.1
6882, 1.0857142857143, 1.3875, 0.1
6883, 1.1142857142857, 1.3875, 0.1
6884, 1.1428571428571, 1.3875, 0.1
6885, 1.1714285714286, 1.3875, 0.1
6886, 1.0285714285714, 1.3625, 0.15
6887, 1.0571428571429, 1.3625, 0.15
6888, 1.0857142857143, 1.3625, 0.15
6889, 1.1142857142857, 1.3625, 0.15
6890, 1.1428571428571, 1.3625, 0.15
6891, 1.1714285714286, 1.3625, 0.15
6892, 1.0285714285714, 1.375, 0.15
6893, 1.0571428571429, 1.375, 0.15
6894, 1.0857142857143, 1.375, 0.15
6895, 1.1142857142857, 1.375, 0.15
6896, 1.1428571428571, 1.375, 0.15
6897, 1.1714285714286, 1.375, 0.15
6898, 1.0285714285714, 1.3875, 0.15
6899, 1.0571428571429, 1.3875, 0.15
6900, 1.0857142857143, 1.3875, 0.15
6901, 1.1142857142857, 1.3875, 0.15
6902, 1.1428571428571, 1.3875, 0.15
6903, 1.1714285714286, 1.3875, 0.15
6904, 1.0285714285714, 1.3625, 0.2
6905, 1.0571428571429, 1.3625, 0.2
6906, 1.0857142857143, 1.3625, 0.2
6907, 1.1142857142857, 1.3625, 0.2
6908, 1.1428571428571, 1.3625, 0.2
6909, 1.1714285714286, 1.3625, 0.2
6910, 1.0285714285714, 1.375, 0.2
6911, 1.0571428571429, 1.375, 0.2
6912, 1.0857142857143, 1.375, 0.2
6913, 1.1142857142857, 1.375, 0.2
6914, 1.1428571428571, 1.375, 0.2
6915, 1.1714285714286, 1.375, 0.2
6916, 1.0285714285714, 1.3875, 0.2
6917, 1.0571428571429, 1.3875, 0.2
6918, 1.0857142857143, 1.3875, 0.2
6919, 1.1142857142857, 1.3875, 0.2
6920, 1.1428571428571, 1.3875, 0.2
6921, 1.1714285714286, 1.3875, 0.2
6922, 1.0285714285714, 1.3625, 0.25
6923, 1.0571428571429, 1.3625, 0.25
6924, 1.0857142857143, 1.3625, 0.25
6925, 1.1142857142857, 1.3625, 0.25
6926, 1.1428571428571, 1.3625, 0.25
6927, 1.1714285714286, 1.3625, 0.25
6928, 1.0285714285714, 1.375, 0.25
6929, 1.0571428571429, 1.375, 0.25
6930, 1.0857142857143, 1.375, 0.25
6931, 1.1142857142857, 1.375, 0.25
6932, 1.1428571428571, 1.375, 0.25
6933, 1.1714285714286, 1.375, 0.25
6934, 1.0285714285714, 1.3875, 0.25
6935, 1.0571428571429, 1.3875, 0.25
6936, 1.0857142857143, 1.3875, 0.25
6937, 1.1142857142857, 1.3875, 0.25
6938, 1.1428571428571, 1.3875, 0.25
6939, 1.1714285714286, 1.3875, 0.25
6940, 1.0285714285714, 1.3625, 0.3
6941, 1.0571428571429, 1.3625, 0.3
6942, 1.0857142857143, 1.3625, 0.3
6943, 1.1142857142857, 1.3625, 0.3
6944, 1.1428571428571, 1.3625, 0.3
6945, 1.1714285714286, 1.3625, 0.3
6946, 1.0285714285714, 1.375, 0.3
6947, 1.0571428571429, 1.375, 0.3
6948, 1.0857142857143, 1.375, 0.3
6949, 1.1142857142857, 1.375, 0.3
6950, 1.1428571428571, 1.375, 0.3
6951, 1.1714285714286, 1.375, 0.3
6952, 1.0285714285714, 1.3875, 0.3
6953, 1.0571428571429, 1.3875, 0.3
6954, 1.0857142857143, 1.3875, 0.3
6955, 1.1142857142857, 1.3875, 0.3
6956, 1.1428571428571, 1.3875, 0.3
6957, 1.1714285714286, 1.3875, 0.3
6958, 1.0285714285714, 1.3625, 0.35
6959, 1.0571428571429, 1.3625, 0.35
6960, 1.0857142857143, 1.3625, 0.35
6961, 1.1142857142857, 1.3625, 0.35
6962, 1.1428571428571, 1.3625, 0.35
6963, 1.1714285714286, 1.3625, 0.35
6964, 1.0285714285714, 1.375, 0.35
6965, 1.0571428571429, 1.375, 0.35
6966, 1.0857142857143, 1.375, 0.35
6967, 1.1142857142857, 1.375, 0.35
6968, 1.1428571428571, 1.375, 0.35
6969, 1.1714285714286, 1.375, 0.35
6970, 1.0285714285714, 1.3875, 0.35
6971, 1.0571428571429, 1.3875, 0.35
6972, 1.0857142857143, 1.3875, 0.35
6973, 1.1142857142857, 1.3875, 0.35
6974, 1.1428571428571, 1.3875, 0.35
6975, 1.1714285714286, 1.3875, 0.35
6976, 1.0285714285714, 1.3625, 0.4
6977, 1.0571428571429, 1.3625, 0.4
6978, 1.0857142857143, 1.3625, 0.4
6979, 1.1142857142857, 1.3625, 0.4
6980, 1.1428571428571, 1.3625, 0.4
6981, 1.1714285714286, 1.3625, 0.4
6982, 1.0285714285714, 1.375, 0.4
6983, 1.0571428571429, 1.375, 0.4
6984, 1.0857142857143, 1.375, 0.4
6985, 1.1142857142857, 1.375, 0.4
6986, 1.1428571428571, 1.375, 0.4
6987, 1.1714285714286, 1.375, 0.4
6988, 1.0285714285714, 1.3875, 0.4
6989, 1.0571428571429, 1.3875, 0.4
6990, 1.0857142857143, 1.3875, 0.4
6991, 1.1142857142857, 1.3875, 0.4
6992, 1.1428571428571, 1.3875, 0.4
6993, 1.1714285714286, 1.3875, 0.4
6994, 1.0285714285714, 1.3625, 0.45
6995, 1.0571428571429, 1.3625, 0.45
6996, 1.0857142857143, 1.3625, 0.45
6997, 1.1142857142857, 1.3625, 0.45
6998, 1.1428571428571, 1.3625, 0.45
6999, 1.1714285714286, 1.3625, 0.45
7000, 1.0285714285714, 1.375, 0.45
7001, 1.0571428571429, 1.375, 0.45
7002, 1.0857142857143, 1.375, 0.45
7003, 1.1142857142857, 1.375, 0.45
7004, 1.1428571428571, 1.375, 0.45
7005, 1.1714285714286, 1.375, 0.45
7006, 1.0285714285714, 1.3875, 0.45
7007, 1.0571428571429, 1.3875, 0.45
7008, 1.0857142857143, 1.3875, 0.45
7009, 1.1142857142857, 1.3875, 0.45
7010, 1.1428571428571, 1.3875, 0.45
7011, 1.1714285714286, 1.3875, 0.45
7012, 1.2833333333333, 1.3625, 0.05
7013, 1.3666666666667, 1.3625, 0.05
7014, 1.45, 1.3625, 0.05
7015, 1.5333333333333, 1.3625, 0.05
7016, 1.6166666666667, 1.3625, 0.05
7017, 1.7, 1.3625, 0.05
7018, 1.7833333333333, 1.3625, 0.05
7019, 1.8666666666667, 1.3625, 0.05
7020, 1.95, 1.3625, 0.05
7021, 2.0333333333333, 1.3625, 0.05
7022, 2.1166666666667, 1.3625, 0.05
7023, 1.2833333333333, 1.375, 0.05
7024, 1.3666666666667, 1.375, 0.05
7025, 1.45, 1.375, 0.05
7026, 1.5333333333333, 1.375, 0.05
7027, 1.6166666666667, 1.375, 0.05
7028, 1.7, 1.375, 0.05
7029, 1.7833333333333, 1.375, 0.05
7030, 1.8666666666667, 1.375, 0.05
7031, 1.95, 1.375, 0.05
7032, 2.0333333333333, 1.375, 0.05
7033, 2.1166666666667, 1.375, 0.05
7034, 1.2833333333333, 1.3875, 0.05
7035, 1.3666666666667, 1.3875, 0.05
7036, 1.45, 1.3875, 0.05
7037, 1.5333333333333, 1.3875, 0.05
7038, 1.6166666666667, 1.3875, 0.05
7039, 1.7, 1.3875, 0.05
7040, 1.7833333333333, 1.3875, 0.05
7041, 1.8666666666667, 1.3875, 0.05
7042, 1.95, 1.3875, 0.05
7043, 2.0333333333333, 1.3875, 0.05
7044, 2.1166666666667, 1.3875, 0.05
