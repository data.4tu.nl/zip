3939, 527, 528, 3099, 3090
3940, 3090, 3099, 3100, 3091
3941, 3091, 3100, 3101, 3092
3942, 3092, 3101, 3102, 3093
3943, 3093, 3102, 3103, 3094
3944, 3094, 3103, 3104, 3095
3945, 3095, 3104, 3105, 3096
3946, 3096, 3105, 3106, 3097
3947, 3097, 3106, 3107, 3098
3948, 3098, 3107, 604, 603
3949, 528, 529, 3108, 3099
3950, 3099, 3108, 3109, 3100
3951, 3100, 3109, 3110, 3101
3952, 3101, 3110, 3111, 3102
3953, 3102, 3111, 3112, 3103
3954, 3103, 3112, 3113, 3104
3955, 3104, 3113, 3114, 3105
3956, 3105, 3114, 3115, 3106
3957, 3106, 3115, 3116, 3107
3958, 3107, 3116, 605, 604
3959, 529, 530, 3117, 3108
3960, 3108, 3117, 3118, 3109
3961, 3109, 3118, 3119, 3110
3962, 3110, 3119, 3120, 3111
3963, 3111, 3120, 3121, 3112
3964, 3112, 3121, 3122, 3113
3965, 3113, 3122, 3123, 3114
3966, 3114, 3123, 3124, 3115
3967, 3115, 3124, 3125, 3116
3968, 3116, 3125, 606, 605
3969, 530, 531, 3126, 3117
3970, 3117, 3126, 3127, 3118
3971, 3118, 3127, 3128, 3119
3972, 3119, 3128, 3129, 3120
3973, 3120, 3129, 3130, 3121
3974, 3121, 3130, 3131, 3122
3975, 3122, 3131, 3132, 3123
3976, 3123, 3132, 3133, 3124
3977, 3124, 3133, 3134, 3125
3978, 3125, 3134, 607, 606
3979, 531, 532, 3135, 3126
3980, 3126, 3135, 3136, 3127
3981, 3127, 3136, 3137, 3128
3982, 3128, 3137, 3138, 3129
3983, 3129, 3138, 3139, 3130
3984, 3130, 3139, 3140, 3131
3985, 3131, 3140, 3141, 3132
3986, 3132, 3141, 3142, 3133
3987, 3133, 3142, 3143, 3134
3988, 3134, 3143, 608, 607
3989, 532, 533, 3144, 3135
3990, 3135, 3144, 3145, 3136
3991, 3136, 3145, 3146, 3137
3992, 3137, 3146, 3147, 3138
3993, 3138, 3147, 3148, 3139
3994, 3139, 3148, 3149, 3140
3995, 3140, 3149, 3150, 3141
3996, 3141, 3150, 3151, 3142
3997, 3142, 3151, 3152, 3143
3998, 3143, 3152, 609, 608
3999, 533, 534, 3153, 3144
4000, 3144, 3153, 3154, 3145
4001, 3145, 3154, 3155, 3146
4002, 3146, 3155, 3156, 3147
4003, 3147, 3156, 3157, 3148
4004, 3148, 3157, 3158, 3149
4005, 3149, 3158, 3159, 3150
4006, 3150, 3159, 3160, 3151
4007, 3151, 3160, 3161, 3152
4008, 3152, 3161, 610, 609
4009, 534, 36, 591, 3153
4010, 3153, 591, 592, 3154
4011, 3154, 592, 593, 3155
4012, 3155, 593, 594, 3156
4013, 3156, 594, 595, 3157
4014, 3157, 595, 596, 3158
4015, 3158, 596, 597, 3159
4016, 3159, 597, 598, 3160
4017, 3160, 598, 599, 3161
4018, 3161, 599, 40, 610
*ELEMENT, type=CPS4, ELSET=Surface44
4019, 35, 582, 3162, 535
4020, 582, 583, 3163, 3162
4021, 583, 584, 3164, 3163
4022, 584, 585, 3165, 3164
4023, 585, 586, 3166, 3165
4024, 586, 587, 3167, 3166
4025, 587, 588, 3168, 3167
4026, 588, 589, 3169, 3168
4027, 589, 590, 3170, 3169
4028, 590, 39, 611, 3170
4029, 535, 3162, 3171, 536
4030, 3162, 3163, 3172, 3171
4031, 3163, 3164, 3173, 3172
4032, 3164, 3165, 3174, 3173
4033, 3165, 3166, 3175, 3174
4034, 3166, 3167, 3176, 3175
4035, 3167, 3168, 3177, 3176
4036, 3168, 3169, 3178, 3177
4037, 3169, 3170, 3179, 3178
4038, 3170, 611, 612, 3179
4039, 536, 3171, 3180, 537
4040, 3171, 3172, 3181, 3180
4041, 3172, 3173, 3182, 3181
4042, 3173, 3174, 3183, 3182
4043, 3174, 3175, 3184, 3183
4044, 3175, 3176, 3185, 3184
4045, 3176, 3177, 3186, 3185
4046, 3177, 3178, 3187, 3186
4047, 3178, 3179, 3188, 3187
4048, 3179, 612, 613, 3188
4049, 537, 3180, 3189, 538
4050, 3180, 3181, 3190, 3189
4051, 3181, 3182, 3191, 3190
4052, 3182, 3183, 3192, 3191
4053, 3183, 3184, 3193, 3192
4054, 3184, 3185, 3194, 3193
4055, 3185, 3186, 3195, 3194
4056, 3186, 3187, 3196, 3195
4057, 3187, 3188, 3197, 3196
4058, 3188, 613, 614, 3197
4059, 538, 3189, 3198, 539
4060, 3189, 3190, 3199, 3198
4061, 3190, 3191, 3200, 3199
4062, 3191, 3192, 3201, 3200
4063, 3192, 3193, 3202, 3201
4064, 3193, 3194, 3203, 3202
4065, 3194, 3195, 3204, 3203
4066, 3195, 3196, 3205, 3204
4067, 3196, 3197, 3206, 3205
4068, 3197, 614, 615, 3206
4069, 539, 3198, 3207, 540
4070, 3198, 3199, 3208, 3207
4071, 3199, 3200, 3209, 3208
4072, 3200, 3201, 3210, 3209
4073, 3201, 3202, 3211, 3210
4074, 3202, 3203, 3212, 3211
4075, 3203, 3204, 3213, 3212
4076, 3204, 3205, 3214, 3213
4077, 3205, 3206, 3215, 3214
4078, 3206, 615, 616, 3215
4079, 540, 3207, 3216, 541
4080, 3207, 3208, 3217, 3216
4081, 3208, 3209, 3218, 3217
4082, 3209, 3210, 3219, 3218
4083, 3210, 3211, 3220, 3219
4084, 3211, 3212, 3221, 3220
4085, 3212, 3213, 3222, 3221
4086, 3213, 3214, 3223, 3222
4087, 3214, 3215, 3224, 3223
4088, 3215, 616, 617, 3224
4089, 541, 3216, 3225, 542
4090, 3216, 3217, 3226, 3225
4091, 3217, 3218, 3227, 3226
4092, 3218, 3219, 3228, 3227
4093, 3219, 3220, 3229, 3228
4094, 3220, 3221, 3230, 3229
4095, 3221, 3222, 3231, 3230
4096, 3222, 3223, 3232, 3231
4097, 3223, 3224, 3233, 3232
4098, 3224, 617, 618, 3233
4099, 542, 3225, 3234, 543
4100, 3225, 3226, 3235, 3234
4101, 3226, 3227, 3236, 3235
4102, 3227, 3228, 3237, 3236
4103, 3228, 3229, 3238, 3237
4104, 3229, 3230, 3239, 3238
4105, 3230, 3231, 3240, 3239
4106, 3231, 3232, 3241, 3240
4107, 3232, 3233, 3242, 3241
4108, 3233, 618, 619, 3242
4109, 543, 3234, 553, 33
4110, 3234, 3235, 554, 553
4111, 3235, 3236, 555, 554
4112, 3236, 3237, 556, 555
4113, 3237, 3238, 557, 556
4114, 3238, 3239, 558, 557
4115, 3239, 3240, 559, 558
4116, 3240, 3241, 560, 559
4117, 3241, 3242, 561, 560
4118, 3242, 619, 37, 561
*ELEMENT, type=CPS4, ELSET=Surface45
4119, 36, 544, 3243, 591
4120, 591, 3243, 3244, 592
4121, 592, 3244, 3245, 593
4122, 593, 3245, 3246, 594
4123, 594, 3246, 3247, 595
4124, 595, 3247, 3248, 596
4125, 596, 3248, 3249, 597
4126, 597, 3249, 3250, 598
4127, 598, 3250, 3251, 599
4128, 599, 3251, 620, 40
4129, 544, 545, 3252, 3243
4130, 3243, 3252, 3253, 3244
4131, 3244, 3253, 3254, 3245
4132, 3245, 3254, 3255, 3246
4133, 3246, 3255, 3256, 3247
4134, 3247, 3256, 3257, 3248
4135, 3248, 3257, 3258, 3249
4136, 3249, 3258, 3259, 3250
4137, 3250, 3259, 3260, 3251
4138, 3251, 3260, 621, 620
4139, 545, 546, 3261, 3252
4140, 3252, 3261, 3262, 3253
4141, 3253, 3262, 3263, 3254
4142, 3254, 3263, 3264, 3255
4143, 3255, 3264, 3265, 3256
4144, 3256, 3265, 3266, 3257
4145, 3257, 3266, 3267, 3258
4146, 3258, 3267, 3268, 3259
4147, 3259, 3268, 3269, 3260
4148, 3260, 3269, 622, 621
4149, 546, 547, 3270, 3261
4150, 3261, 3270, 3271, 3262
4151, 3262, 3271, 3272, 3263
4152, 3263, 3272, 3273, 3264
4153, 3264, 3273, 3274, 3265
4154, 3265, 3274, 3275, 3266
4155, 3266, 3275, 3276, 3267
4156, 3267, 3276, 3277, 3268
4157, 3268, 3277, 3278, 3269
4158, 3269, 3278, 623, 622
4159, 547, 548, 3279, 3270
4160, 3270, 3279, 3280, 3271
4161, 3271, 3280, 3281, 3272
4162, 3272, 3281, 3282, 3273
4163, 3273, 3282, 3283, 3274
4164, 3274, 3283, 3284, 3275
4165, 3275, 3284, 3285, 3276
4166, 3276, 3285, 3286, 3277
4167, 3277, 3286, 3287, 3278
4168, 3278, 3287, 624, 623
4169, 548, 549, 3288, 3279
4170, 3279, 3288, 3289, 3280
4171, 3280, 3289, 3290, 3281
4172, 3281, 3290, 3291, 3282
4173, 3282, 3291, 3292, 3283
4174, 3283, 3292, 3293, 3284
4175, 3284, 3293, 3294, 3285
4176, 3285, 3294, 3295, 3286
4177, 3286, 3295, 3296, 3287
4178, 3287, 3296, 625, 624
4179, 549, 550, 3297, 3288
4180, 3288, 3297, 3298, 3289
4181, 3289, 3298, 3299, 3290
4182, 3290, 3299, 3300, 3291
4183, 3291, 3300, 3301, 3292
4184, 3292, 3301, 3302, 3293
4185, 3293, 3302, 3303, 3294
4186, 3294, 3303, 3304, 3295
4187, 3295, 3304, 3305, 3296
4188, 3296, 3305, 626, 625
4189, 550, 551, 3306, 3297
4190, 3297, 3306, 3307, 3298
4191, 3298, 3307, 3308, 3299
4192, 3299, 3308, 3309, 3300
4193, 3300, 3309, 3310, 3301
4194, 3301, 3310, 3311, 3302
4195, 3302, 3311, 3312, 3303
4196, 3303, 3312, 3313, 3304
4197, 3304, 3313, 3314, 3305
4198, 3305, 3314, 627, 626
4199, 551, 552, 3315, 3306
4200, 3306, 3315, 3316, 3307
4201, 3307, 3316, 3317, 3308
4202, 3308, 3317, 3318, 3309
4203, 3309, 3318, 3319, 3310
4204, 3310, 3319, 3320, 3311
4205, 3311, 3320, 3321, 3312
4206, 3312, 3321, 3322, 3313
4207, 3313, 3322, 3323, 3314
4208, 3314, 3323, 628, 627
4209, 552, 34, 562, 3315
4210, 3315, 562, 563, 3316
4211, 3316, 563, 564, 3317
4212, 3317, 564, 565, 3318
4213, 3318, 565, 566, 3319
4214, 3319, 566, 567, 3320
4215, 3320, 567, 568, 3321
4216, 3321, 568, 569, 3322
4217, 3322, 569, 570, 3323
4218, 3323, 570, 38, 628
*ELEMENT, type=CPS4, ELSET=Surface46
4219, 39, 600, 3324, 611
4220, 600, 601, 3325, 3324
4221, 601, 602, 3326, 3325
4222, 602, 603, 3327, 3326
4223, 603, 604, 3328, 3327
4224, 604, 605, 3329, 3328
4225, 605, 606, 3330, 3329
4226, 606, 607, 3331, 3330
4227, 607, 608, 3332, 3331
4228, 608, 609, 3333, 3332
4229, 609, 610, 3334, 3333
4230, 610, 40, 620, 3334
4231, 611, 3324, 3335, 612
4232, 3324, 3325, 3336, 3335
4233, 3325, 3326, 3337, 3336
4234, 3326, 3327, 3338, 3337
4235, 3327, 3328, 3339, 3338
4236, 3328, 3329, 3340, 3339
4237, 3329, 3330, 3341, 3340
4238, 3330, 3331, 3342, 3341
4239, 3331, 3332, 3343, 3342
4240, 3332, 3333, 3344, 3343
4241, 3333, 3334, 3345, 3344
4242, 3334, 620, 621, 3345
4243, 612, 3335, 3346, 613
4244, 3335, 3336, 3347, 3346
4245, 3336, 3337, 3348, 3347
4246, 3337, 3338, 3349, 3348
4247, 3338, 3339, 3350, 3349
4248, 3339, 3340, 3351, 3350
4249, 3340, 3341, 3352, 3351
4250, 3341, 3342, 3353, 3352
4251, 3342, 3343, 3354, 3353
4252, 3343, 3344, 3355, 3354
4253, 3344, 3345, 3356, 3355
4254, 3345, 621, 622, 3356
4255, 613, 3346, 3357, 614
4256, 3346, 3347, 3358, 3357
4257, 3347, 3348, 3359, 3358
4258, 3348, 3349, 3360, 3359
4259, 3349, 3350, 3361, 3360
4260, 3350, 3351, 3362, 3361
4261, 3351, 3352, 3363, 3362
4262, 3352, 3353, 3364, 3363
4263, 3353, 3354, 3365, 3364
4264, 3354, 3355, 3366, 3365
4265, 3355, 3356, 3367, 3366
4266, 3356, 622, 623, 3367
4267, 614, 3357, 3368, 615
4268, 3357, 3358, 3369, 3368
4269, 3358, 3359, 3370, 3369
4270, 3359, 3360, 3371, 3370
4271, 3360, 3361, 3372, 3371
4272, 3361, 3362, 3373, 3372
4273, 3362, 3363, 3374, 3373
4274, 3363, 3364, 3375, 3374
4275, 3364, 3365, 3376, 3375
4276, 3365, 3366, 3377, 3376
4277, 3366, 3367, 3378, 3377
4278, 3367, 623, 624, 3378
4279, 615, 3368, 3379, 616
4280, 3368, 3369, 3380, 3379
4281, 3369, 3370, 3381, 3380
4282, 3370, 3371, 3382, 3381
4283, 3371, 3372, 3383, 3382
4284, 3372, 3373, 3384, 3383
4285, 3373, 3374, 3385, 3384
4286, 3374, 3375, 3386, 3385
4287, 3375, 3376, 3387, 3386
4288, 3376, 3377, 3388, 3387
4289, 3377, 3378, 3389, 3388
4290, 3378, 624, 625, 3389
4291, 616, 3379, 3390, 617
4292, 3379, 3380, 3391, 3390
4293, 3380, 3381, 3392, 3391
4294, 3381, 3382, 3393, 3392
4295, 3382, 3383, 3394, 3393
4296, 3383, 3384, 3395, 3394
4297, 3384, 3385, 3396, 3395
4298, 3385, 3386, 3397, 3396
4299, 3386, 3387, 3398, 3397
4300, 3387, 3388, 3399, 3398
4301, 3388, 3389, 3400, 3399
4302, 3389, 625, 626, 3400
4303, 617, 3390, 3401, 618
4304, 3390, 3391, 3402, 3401
4305, 3391, 3392, 3403, 3402
4306, 3392, 3393, 3404, 3403
4307, 3393, 3394, 3405, 3404
4308, 3394, 3395, 3406, 3405
4309, 3395, 3396, 3407, 3406
4310, 3396, 3397, 3408, 3407
4311, 3397, 3398, 3409, 3408
4312, 3398, 3399, 3410, 3409
4313, 3399, 3400, 3411, 3410
4314, 3400, 626, 627, 3411
4315, 618, 3401, 3412, 619
4316, 3401, 3402, 3413, 3412
4317, 3402, 3403, 3414, 3413
4318, 3403, 3404, 3415, 3414
4319, 3404, 3405, 3416, 3415
4320, 3405, 3406, 3417, 3416
4321, 3406, 3407, 3418, 3417
4322, 3407, 3408, 3419, 3418
4323, 3408, 3409, 3420, 3419
4324, 3409, 3410, 3421, 3420
4325, 3410, 3411, 3422, 3421
4326, 3411, 627, 628, 3422
4327, 619, 3412, 571, 37
4328, 3412, 3413, 572, 571
4329, 3413, 3414, 573, 572
4330, 3414, 3415, 574, 573
4331, 3415, 3416, 575, 574
4332, 3416, 3417, 576, 575
4333, 3417, 3418, 577, 576
4334, 3418, 3419, 578, 577
4335, 3419, 3420, 579, 578
4336, 3420, 3421, 580, 579
4337, 3421, 3422, 581, 580
4338, 3422, 628, 38, 581
*ELEMENT, type=CPS4, ELSET=Surface47
4339, 37, 41, 629, 571
4340, 571, 629, 630, 572
4341, 572, 630, 631, 573
4342, 573, 631, 632, 574
4343, 574, 632, 633, 575
4344, 575, 633, 634, 576
4345, 576, 634, 635, 577
4346, 577, 635, 636, 578
4347, 578, 636, 637, 579
4348, 579, 637, 638, 580
4349, 580, 638, 639, 581
4350, 581, 639, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
4351, 39, 600, 640, 43
4352, 600, 601, 641, 640
4353, 601, 602, 642, 641
4354, 602, 603, 643, 642
4355, 603, 604, 644, 643
4356, 604, 605, 645, 644
4357, 605, 606, 646, 645
4358, 606, 607, 647, 646
4359, 607, 608, 648, 647
4360, 608, 609, 649, 648
4361, 609, 610, 650, 649
4362, 610, 40, 44, 650
*ELEMENT, type=CPS4, ELSET=Surface49
4363, 39, 43, 651, 611
4364, 611, 651, 652, 612
4365, 612, 652, 653, 613
4366, 613, 653, 654, 614
4367, 614, 654, 655, 615
4368, 615, 655, 656, 616
4369, 616, 656, 657, 617
4370, 617, 657, 658, 618
4371, 618, 658, 659, 619
4372, 619, 659, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
4373, 40, 620, 660, 44
4374, 620, 621, 661, 660
4375, 621, 622, 662, 661
4376, 622, 623, 663, 662
4377, 623, 624, 664, 663
4378, 624, 625, 665, 664
4379, 625, 626, 666, 665
4380, 626, 627, 667, 666
4381, 627, 628, 668, 667
4382, 628, 38, 42, 668
*ELEMENT, type=CPS4, ELSET=Surface51
4383, 43, 640, 3423, 651
4384, 640, 641, 3424, 3423
4385, 641, 642, 3425, 3424
4386, 642, 643, 3426, 3425
4387, 643, 644, 3427, 3426
4388, 644, 645, 3428, 3427
4389, 645, 646, 3429, 3428
4390, 646, 647, 3430, 3429
4391, 647, 648, 3431, 3430
4392, 648, 649, 3432, 3431
4393, 649, 650, 3433, 3432
4394, 650, 44, 660, 3433
4395, 651, 3423, 3434, 652
4396, 3423, 3424, 3435, 3434
4397, 3424, 3425, 3436, 3435
4398, 3425, 3426, 3437, 3436
4399, 3426, 3427, 3438, 3437
4400, 3427, 3428, 3439, 3438
4401, 3428, 3429, 3440, 3439
4402, 3429, 3430, 3441, 3440
4403, 3430, 3431, 3442, 3441
4404, 3431, 3432, 3443, 3442
4405, 3432, 3433, 3444, 3443
4406, 3433, 660, 661, 3444
4407, 652, 3434, 3445, 653
4408, 3434, 3435, 3446, 3445
4409, 3435, 3436, 3447, 3446
4410, 3436, 3437, 3448, 3447
4411, 3437, 3438, 3449, 3448
4412, 3438, 3439, 3450, 3449
4413, 3439, 3440, 3451, 3450
4414, 3440, 3441, 3452, 3451
4415, 3441, 3442, 3453, 3452
4416, 3442, 3443, 3454, 3453
4417, 3443, 3444, 3455, 3454
4418, 3444, 661, 662, 3455
4419, 653, 3445, 3456, 654
4420, 3445, 3446, 3457, 3456
4421, 3446, 3447, 3458, 3457
4422, 3447, 3448, 3459, 3458
4423, 3448, 3449, 3460, 3459
4424, 3449, 3450, 3461, 3460
4425, 3450, 3451, 3462, 3461
4426, 3451, 3452, 3463, 3462
4427, 3452, 3453, 3464, 3463
4428, 3453, 3454, 3465, 3464
4429, 3454, 3455, 3466, 3465
4430, 3455, 662, 663, 3466
4431, 654, 3456, 3467, 655
4432, 3456, 3457, 3468, 3467
4433, 3457, 3458, 3469, 3468
4434, 3458, 3459, 3470, 3469
4435, 3459, 3460, 3471, 3470
4436, 3460, 3461, 3472, 3471
4437, 3461, 3462, 3473, 3472
4438, 3462, 3463, 3474, 3473
4439, 3463, 3464, 3475, 3474
4440, 3464, 3465, 3476, 3475
4441, 3465, 3466, 3477, 3476
4442, 3466, 663, 664, 3477
4443, 655, 3467, 3478, 656
4444, 3467, 3468, 3479, 3478
4445, 3468, 3469, 3480, 3479
4446, 3469, 3470, 3481, 3480
4447, 3470, 3471, 3482, 3481
4448, 3471, 3472, 3483, 3482
4449, 3472, 3473, 3484, 3483
4450, 3473, 3474, 3485, 3484
4451, 3474, 3475, 3486, 3485
4452, 3475, 3476, 3487, 3486
4453, 3476, 3477, 3488, 3487
4454, 3477, 664, 665, 3488
4455, 656, 3478, 3489, 657
4456, 3478, 3479, 3490, 3489
4457, 3479, 3480, 3491, 3490
4458, 3480, 3481, 3492, 3491
4459, 3481, 3482, 3493, 3492
4460, 3482, 3483, 3494, 3493
4461, 3483, 3484, 3495, 3494
4462, 3484, 3485, 3496, 3495
4463, 3485, 3486, 3497, 3496
4464, 3486, 3487, 3498, 3497
4465, 3487, 3488, 3499, 3498
4466, 3488, 665, 666, 3499
4467, 657, 3489, 3500, 658
4468, 3489, 3490, 3501, 3500
4469, 3490, 3491, 3502, 3501
4470, 3491, 3492, 3503, 3502
4471, 3492, 3493, 3504, 3503
4472, 3493, 3494, 3505, 3504
4473, 3494, 3495, 3506, 3505
4474, 3495, 3496, 3507, 3506
4475, 3496, 3497, 3508, 3507
4476, 3497, 3498, 3509, 3508
4477, 3498, 3499, 3510, 3509
4478, 3499, 666, 667, 3510
4479, 658, 3500, 3511, 659
4480, 3500, 3501, 3512, 3511
4481, 3501, 3502, 3513, 3512
4482, 3502, 3503, 3514, 3513
4483, 3503, 3504, 3515, 3514
4484, 3504, 3505, 3516, 3515
4485, 3505, 3506, 3517, 3516
4486, 3506, 3507, 3518, 3517
4487, 3507, 3508, 3519, 3518
4488, 3508, 3509, 3520, 3519
4489, 3509, 3510, 3521, 3520
4490, 3510, 667, 668, 3521
4491, 659, 3511, 629, 41
4492, 3511, 3512, 630, 629
4493, 3512, 3513, 631, 630
4494, 3513, 3514, 632, 631
4495, 3514, 3515, 633, 632
4496, 3515, 3516, 634, 633
4497, 3516, 3517, 635, 634
4498, 3517, 3518, 636, 635
4499, 3518, 3519, 637, 636
4500, 3519, 3520, 638, 637
4501, 3520, 3521, 639, 638
4502, 3521, 668, 42, 639
*ELEMENT, type=CPS4, ELSET=Surface52
4503, 41, 669, 3522, 629
4504, 669, 670, 3523, 3522
4505, 670, 671, 3524, 3523
4506, 671, 45, 675, 3524
4507, 629, 3522, 3525, 630
4508, 3522, 3523, 3526, 3525
4509, 3523, 3524, 3527, 3526
4510, 3524, 675, 676, 3527
4511, 630, 3525, 3528, 631
4512, 3525, 3526, 3529, 3528
4513, 3526, 3527, 3530, 3529
4514, 3527, 676, 677, 3530
4515, 631, 3528, 3531, 632
4516, 3528, 3529, 3532, 3531
4517, 3529, 3530, 3533, 3532
4518, 3530, 677, 678, 3533
4519, 632, 3531, 3534, 633
4520, 3531, 3532, 3535, 3534
4521, 3532, 3533, 3536, 3535
4522, 3533, 678, 679, 3536
4523, 633, 3534, 3537, 634
4524, 3534, 3535, 3538, 3537
4525, 3535, 3536, 3539, 3538
4526, 3536, 679, 680, 3539
4527, 634, 3537, 3540, 635
4528, 3537, 3538, 3541, 3540
4529, 3538, 3539, 3542, 3541
4530, 3539, 680, 681, 3542
4531, 635, 3540, 3543, 636
4532, 3540, 3541, 3544, 3543
4533, 3541, 3542, 3545, 3544
4534, 3542, 681, 682, 3545
4535, 636, 3543, 3546, 637
4536, 3543, 3544, 3547, 3546
4537, 3544, 3545, 3548, 3547
4538, 3545, 682, 683, 3548
4539, 637, 3546, 3549, 638
4540, 3546, 3547, 3550, 3549
4541, 3547, 3548, 3551, 3550
4542, 3548, 683, 684, 3551
4543, 638, 3549, 3552, 639
4544, 3549, 3550, 3553, 3552
4545, 3550, 3551, 3554, 3553
4546, 3551, 684, 685, 3554
4547, 639, 3552, 672, 42
4548, 3552, 3553, 673, 672
4549, 3553, 3554, 674, 673
4550, 3554, 685, 46, 674
*ELEMENT, type=CPS4, ELSET=Surface53
4551, 43, 640, 3555, 686
4552, 686, 3555, 3556, 687
4553, 687, 3556, 3557, 688
4554, 688, 3557, 692, 47
4555, 640, 641, 3558, 3555
4556, 3555, 3558, 3559, 3556
4557, 3556, 3559, 3560, 3557
4558, 3557, 3560, 693, 692
4559, 641, 642, 3561, 3558
4560, 3558, 3561, 3562, 3559
4561, 3559, 3562, 3563, 3560
4562, 3560, 3563, 694, 693
4563, 642, 643, 3564, 3561
4564, 3561, 3564, 3565, 3562
4565, 3562, 3565, 3566, 3563
4566, 3563, 3566, 695, 694
4567, 643, 644, 3567, 3564
4568, 3564, 3567, 3568, 3565
4569, 3565, 3568, 3569, 3566
4570, 3566, 3569, 696, 695
4571, 644, 645, 3570, 3567
4572, 3567, 3570, 3571, 3568
4573, 3568, 3571, 3572, 3569
4574, 3569, 3572, 697, 696
4575, 645, 646, 3573, 3570
4576, 3570, 3573, 3574, 3571
4577, 3571, 3574, 3575, 3572
4578, 3572, 3575, 698, 697
4579, 646, 647, 3576, 3573
4580, 3573, 3576, 3577, 3574
4581, 3574, 3577, 3578, 3575
4582, 3575, 3578, 699, 698
4583, 647, 648, 3579, 3576
4584, 3576, 3579, 3580, 3577
4585, 3577, 3580, 3581, 3578
4586, 3578, 3581, 700, 699
4587, 648, 649, 3582, 3579
4588, 3579, 3582, 3583, 3580
4589, 3580, 3583, 3584, 3581
4590, 3581, 3584, 701, 700
4591, 649, 650, 3585, 3582
4592, 3582, 3585, 3586, 3583
4593, 3583, 3586, 3587, 3584
4594, 3584, 3587, 702, 701
4595, 650, 44, 689, 3585
4596, 3585, 689, 690, 3586
4597, 3586, 690, 691, 3587
4598, 3587, 691, 48, 702
*ELEMENT, type=CPS4, ELSET=Surface54
4599, 43, 686, 3588, 651
4600, 686, 687, 3589, 3588
4601, 687, 688, 3590, 3589
4602, 688, 47, 703, 3590
4603, 651, 3588, 3591, 652
4604, 3588, 3589, 3592, 3591
4605, 3589, 3590, 3593, 3592
4606, 3590, 703, 704, 3593
4607, 652, 3591, 3594, 653
4608, 3591, 3592, 3595, 3594
4609, 3592, 3593, 3596, 3595
4610, 3593, 704, 705, 3596
4611, 653, 3594, 3597, 654
4612, 3594, 3595, 3598, 3597
4613, 3595, 3596, 3599, 3598
4614, 3596, 705, 706, 3599
4615, 654, 3597, 3600, 655
4616, 3597, 3598, 3601, 3600
4617, 3598, 3599, 3602, 3601
4618, 3599, 706, 707, 3602
4619, 655, 3600, 3603, 656
4620, 3600, 3601, 3604, 3603
4621, 3601, 3602, 3605, 3604
4622, 3602, 707, 708, 3605
4623, 656, 3603, 3606, 657
4624, 3603, 3604, 3607, 3606
4625, 3604, 3605, 3608, 3607
4626, 3605, 708, 709, 3608
4627, 657, 3606, 3609, 658
4628, 3606, 3607, 3610, 3609
4629, 3607, 3608, 3611, 3610
4630, 3608, 709, 710, 3611
4631, 658, 3609, 3612, 659
4632, 3609, 3610, 3613, 3612
4633, 3610, 3611, 3614, 3613
4634, 3611, 710, 711, 3614
4635, 659, 3612, 669, 41
4636, 3612, 3613, 670, 669
4637, 3613, 3614, 671, 670
4638, 3614, 711, 45, 671
*ELEMENT, type=CPS4, ELSET=Surface55
4639, 44, 660, 3615, 689
4640, 689, 3615, 3616, 690
4641, 690, 3616, 3617, 691
4642, 691, 3617, 712, 48
4643, 660, 661, 3618, 3615
4644, 3615, 3618, 3619, 3616
4645, 3616, 3619, 3620, 3617
4646, 3617, 3620, 713, 712
4647, 661, 662, 3621, 3618
4648, 3618, 3621, 3622, 3619
4649, 3619, 3622, 3623, 3620
4650, 3620, 3623, 714, 713
4651, 662, 663, 3624, 3621
4652, 3621, 3624, 3625, 3622
4653, 3622, 3625, 3626, 3623
4654, 3623, 3626, 715, 714
4655, 663, 664, 3627, 3624
4656, 3624, 3627, 3628, 3625
4657, 3625, 3628, 3629, 3626
4658, 3626, 3629, 716, 715
4659, 664, 665, 3630, 3627
4660, 3627, 3630, 3631, 3628
4661, 3628, 3631, 3632, 3629
4662, 3629, 3632, 717, 716
4663, 665, 666, 3633, 3630
4664, 3630, 3633, 3634, 3631
4665, 3631, 3634, 3635, 3632
4666, 3632, 3635, 718, 717
4667, 666, 667, 3636, 3633
4668, 3633, 3636, 3637, 3634
4669, 3634, 3637, 3638, 3635
4670, 3635, 3638, 719, 718
4671, 667, 668, 3639, 3636
4672, 3636, 3639, 3640, 3637
4673, 3637, 3640, 3641, 3638
4674, 3638, 3641, 720, 719
4675, 668, 42, 672, 3639
4676, 3639, 672, 673, 3640
4677, 3640, 673, 674, 3641
4678, 3641, 674, 46, 720
*ELEMENT, type=CPS4, ELSET=Surface56
4679, 47, 692, 3642, 703
4680, 692, 693, 3643, 3642
4681, 693, 694, 3644, 3643
4682, 694, 695, 3645, 3644
4683, 695, 696, 3646, 3645
4684, 696, 697, 3647, 3646
4685, 697, 698, 3648, 3647
4686, 698, 699, 3649, 3648
4687, 699, 700, 3650, 3649
4688, 700, 701, 3651, 3650
4689, 701, 702, 3652, 3651
4690, 702, 48, 712, 3652
4691, 703, 3642, 3653, 704
4692, 3642, 3643, 3654, 3653
4693, 3643, 3644, 3655, 3654
4694, 3644, 3645, 3656, 3655
4695, 3645, 3646, 3657, 3656
4696, 3646, 3647, 3658, 3657
4697, 3647, 3648, 3659, 3658
4698, 3648, 3649, 3660, 3659
4699, 3649, 3650, 3661, 3660
4700, 3650, 3651, 3662, 3661
4701, 3651, 3652, 3663, 3662
4702, 3652, 712, 713, 3663
4703, 704, 3653, 3664, 705
4704, 3653, 3654, 3665, 3664
4705, 3654, 3655, 3666, 3665
4706, 3655, 3656, 3667, 3666
4707, 3656, 3657, 3668, 3667
4708, 3657, 3658, 3669, 3668
4709, 3658, 3659, 3670, 3669
4710, 3659, 3660, 3671, 3670
4711, 3660, 3661, 3672, 3671
4712, 3661, 3662, 3673, 3672
4713, 3662, 3663, 3674, 3673
4714, 3663, 713, 714, 3674
4715, 705, 3664, 3675, 706
4716, 3664, 3665, 3676, 3675
4717, 3665, 3666, 3677, 3676
4718, 3666, 3667, 3678, 3677
4719, 3667, 3668, 3679, 3678
4720, 3668, 3669, 3680, 3679
4721, 3669, 3670, 3681, 3680
4722, 3670, 3671, 3682, 3681
4723, 3671, 3672, 3683, 3682
4724, 3672, 3673, 3684, 3683
4725, 3673, 3674, 3685, 3684
4726, 3674, 714, 715, 3685
4727, 706, 3675, 3686, 707
4728, 3675, 3676, 3687, 3686
4729, 3676, 3677, 3688, 3687
4730, 3677, 3678, 3689, 3688
4731, 3678, 3679, 3690, 3689
4732, 3679, 3680, 3691, 3690
4733, 3680, 3681, 3692, 3691
4734, 3681, 3682, 3693, 3692
4735, 3682, 3683, 3694, 3693
4736, 3683, 3684, 3695, 3694
4737, 3684, 3685, 3696, 3695
4738, 3685, 715, 716, 3696
4739, 707, 3686, 3697, 708
4740, 3686, 3687, 3698, 3697
4741, 3687, 3688, 3699, 3698
4742, 3688, 3689, 3700, 3699
4743, 3689, 3690, 3701, 3700
4744, 3690, 3691, 3702, 3701
4745, 3691, 3692, 3703, 3702
4746, 3692, 3693, 3704, 3703
4747, 3693, 3694, 3705, 3704
4748, 3694, 3695, 3706, 3705
4749, 3695, 3696, 3707, 3706
4750, 3696, 716, 717, 3707
4751, 708, 3697, 3708, 709
4752, 3697, 3698, 3709, 3708
4753, 3698, 3699, 3710, 3709
4754, 3699, 3700, 3711, 3710
4755, 3700, 3701, 3712, 3711
4756, 3701, 3702, 3713, 3712
4757, 3702, 3703, 3714, 3713
4758, 3703, 3704, 3715, 3714
4759, 3704, 3705, 3716, 3715
4760, 3705, 3706, 3717, 3716
4761, 3706, 3707, 3718, 3717
4762, 3707, 717, 718, 3718
4763, 709, 3708, 3719, 710
4764, 3708, 3709, 3720, 3719
4765, 3709, 3710, 3721, 3720
4766, 3710, 3711, 3722, 3721
4767, 3711, 3712, 3723, 3722
4768, 3712, 3713, 3724, 3723
4769, 3713, 3714, 3725, 3724
4770, 3714, 3715, 3726, 3725
4771, 3715, 3716, 3727, 3726
4772, 3716, 3717, 3728, 3727
4773, 3717, 3718, 3729, 3728
4774, 3718, 718, 719, 3729
4775, 710, 3719, 3730, 711
4776, 3719, 3720, 3731, 3730
4777, 3720, 3721, 3732, 3731
4778, 3721, 3722, 3733, 3732
4779, 3722, 3723, 3734, 3733
4780, 3723, 3724, 3735, 3734
4781, 3724, 3725, 3736, 3735
4782, 3725, 3726, 3737, 3736
4783, 3726, 3727, 3738, 3737
4784, 3727, 3728, 3739, 3738
4785, 3728, 3729, 3740, 3739
4786, 3729, 719, 720, 3740
4787, 711, 3730, 675, 45
4788, 3730, 3731, 676, 675
4789, 3731, 3732, 677, 676
4790, 3732, 3733, 678, 677
4791, 3733, 3734, 679, 678
4792, 3734, 3735, 680, 679
4793, 3735, 3736, 681, 680
4794, 3736, 3737, 682, 681
4795, 3737, 3738, 683, 682
4796, 3738, 3739, 684, 683
4797, 3739, 3740, 685, 684
4798, 3740, 720, 46, 685
*ELEMENT, type=CPS4, ELSET=Surface57
4799, 42, 672, 721, 49
4800, 672, 673, 722, 721
4801, 673, 674, 723, 722
4802, 674, 46, 50, 723
*ELEMENT, type=CPS4, ELSET=Surface58
4803, 44, 51, 724, 689
4804, 689, 724, 725, 690
4805, 690, 725, 726, 691
4806, 691, 726, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
4807, 44, 660, 727, 51
4808, 660, 661, 728, 727
4809, 661, 662, 729, 728
4810, 662, 663, 730, 729
4811, 663, 664, 731, 730
4812, 664, 665, 732, 731
4813, 665, 666, 733, 732
4814, 666, 667, 734, 733
4815, 667, 668, 735, 734
4816, 668, 42, 49, 735
*ELEMENT, type=CPS4, ELSET=Surface60
4817, 48, 52, 736, 712
4818, 712, 736, 737, 713
4819, 713, 737, 738, 714
4820, 714, 738, 739, 715
4821, 715, 739, 740, 716
4822, 716, 740, 741, 717
4823, 717, 741, 742, 718
4824, 718, 742, 743, 719
4825, 719, 743, 744, 720
4826, 720, 744, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
4827, 51, 727, 3741, 724
4828, 724, 3741, 3742, 725
4829, 725, 3742, 3743, 726
4830, 726, 3743, 736, 52
4831, 727, 728, 3744, 3741
4832, 3741, 3744, 3745, 3742
4833, 3742, 3745, 3746, 3743
4834, 3743, 3746, 737, 736
4835, 728, 729, 3747, 3744
4836, 3744, 3747, 3748, 3745
4837, 3745, 3748, 3749, 3746
4838, 3746, 3749, 738, 737
4839, 729, 730, 3750, 3747
4840, 3747, 3750, 3751, 3748
4841, 3748, 3751, 3752, 3749
4842, 3749, 3752, 739, 738
4843, 730, 731, 3753, 3750
4844, 3750, 3753, 3754, 3751
4845, 3751, 3754, 3755, 3752
4846, 3752, 3755, 740, 739
4847, 731, 732, 3756, 3753
4848, 3753, 3756, 3757, 3754
4849, 3754, 3757, 3758, 3755
4850, 3755, 3758, 741, 740
4851, 732, 733, 3759, 3756
4852, 3756, 3759, 3760, 3757
4853, 3757, 3760, 3761, 3758
4854, 3758, 3761, 742, 741
4855, 733, 734, 3762, 3759
4856, 3759, 3762, 3763, 3760
4857, 3760, 3763, 3764, 3761
4858, 3761, 3764, 743, 742
4859, 734, 735, 3765, 3762
4860, 3762, 3765, 3766, 3763
4861, 3763, 3766, 3767, 3764
4862, 3764, 3767, 744, 743
4863, 735, 49, 721, 3765
4864, 3765, 721, 722, 3766
4865, 3766, 722, 723, 3767
4866, 3767, 723, 50, 744
*ELEMENT, type=CPS4, ELSET=Surface62
4867, 2, 97, 745, 54
4868, 97, 98, 746, 745
4869, 98, 99, 747, 746
4870, 99, 100, 748, 747
4871, 100, 101, 749, 748
4872, 101, 102, 750, 749
4873, 102, 103, 751, 750
4874, 103, 104, 752, 751
4875, 104, 105, 753, 752
4876, 105, 1, 53, 753
*ELEMENT, type=CPS4, ELSET=Surface63
4877, 1, 106, 754, 53
4878, 106, 107, 755, 754
4879, 107, 108, 756, 755
4880, 108, 3, 55, 756
*ELEMENT, type=CPS4, ELSET=Surface64
4881, 4, 56, 757, 109
4882, 109, 757, 758, 110
4883, 110, 758, 759, 111
4884, 111, 759, 760, 112
4885, 112, 760, 761, 113
4886, 113, 761, 762, 114
4887, 114, 762, 763, 115
4888, 115, 763, 764, 116
4889, 116, 764, 765, 117
4890, 117, 765, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
4891, 2, 54, 766, 118
4892, 118, 766, 767, 119
4893, 119, 767, 768, 120
4894, 120, 768, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
4895, 54, 745, 3768, 766
4896, 766, 3768, 3769, 767
4897, 767, 3769, 3770, 768
4898, 768, 3770, 757, 56
4899, 745, 746, 3771, 3768
4900, 3768, 3771, 3772, 3769
4901, 3769, 3772, 3773, 3770
4902, 3770, 3773, 758, 757
4903, 746, 747, 3774, 3771
4904, 3771, 3774, 3775, 3772
4905, 3772, 3775, 3776, 3773
4906, 3773, 3776, 759, 758
4907, 747, 748, 3777, 3774
4908, 3774, 3777, 3778, 3775
4909, 3775, 3778, 3779, 3776
4910, 3776, 3779, 760, 759
4911, 748, 749, 3780, 3777
4912, 3777, 3780, 3781, 3778
4913, 3778, 3781, 3782, 3779
4914, 3779, 3782, 761, 760
4915, 749, 750, 3783, 3780
4916, 3780, 3783, 3784, 3781
4917, 3781, 3784, 3785, 3782
4918, 3782, 3785, 762, 761
4919, 750, 751, 3786, 3783
4920, 3783, 3786, 3787, 3784
4921, 3784, 3787, 3788, 3785
4922, 3785, 3788, 763, 762
4923, 751, 752, 3789, 3786
4924, 3786, 3789, 3790, 3787
4925, 3787, 3790, 3791, 3788
4926, 3788, 3791, 764, 763
4927, 752, 753, 3792, 3789
4928, 3789, 3792, 3793, 3790
4929, 3790, 3793, 3794, 3791
4930, 3791, 3794, 765, 764
4931, 753, 53, 754, 3792
4932, 3792, 754, 755, 3793
4933, 3793, 755, 756, 3794
4934, 3794, 756, 55, 765
*ELEMENT, type=CPS4, ELSET=Surface77
4935, 11, 57, 769, 258
4936, 258, 769, 770, 259
4937, 259, 770, 771, 260
4938, 260, 771, 772, 261
4939, 261, 772, 773, 262
4940, 262, 773, 774, 263
4941, 263, 774, 775, 264
4942, 264, 775, 776, 265
4943, 265, 776, 777, 266
4944, 266, 777, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
4945, 9, 229, 778, 59
4946, 229, 230, 779, 778
4947, 230, 231, 780, 779
4948, 231, 232, 781, 780
4949, 232, 233, 782, 781
4950, 233, 234, 783, 782
4951, 234, 235, 784, 783
4952, 235, 236, 785, 784
4953, 236, 237, 786, 785
4954, 237, 13, 60, 786
*ELEMENT, type=CPS4, ELSET=Surface79
4955, 9, 59, 787, 200
4956, 200, 787, 788, 201
4957, 201, 788, 789, 202
4958, 202, 789, 790, 203
4959, 203, 790, 791, 204
4960, 204, 791, 792, 205
4961, 205, 792, 793, 206
4962, 206, 793, 794, 207
4963, 207, 794, 795, 208
4964, 208, 795, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
4965, 13, 267, 796, 60
4966, 267, 268, 797, 796
4967, 268, 269, 798, 797
4968, 269, 270, 799, 798
4969, 270, 271, 800, 799
4970, 271, 272, 801, 800
4971, 272, 273, 802, 801
4972, 273, 274, 803, 802
4973, 274, 275, 804, 803
4974, 275, 15, 58, 804
*ELEMENT, type=CPS4, ELSET=Surface81
4975, 59, 778, 3795, 787
4976, 778, 779, 3796, 3795
4977, 779, 780, 3797, 3796
4978, 780, 781, 3798, 3797
4979, 781, 782, 3799, 3798
4980, 782, 783, 3800, 3799
4981, 783, 784, 3801, 3800
4982, 784, 785, 3802, 3801
4983, 785, 786, 3803, 3802
4984, 786, 60, 796, 3803
4985, 787, 3795, 3804, 788
4986, 3795, 3796, 3805, 3804
4987, 3796, 3797, 3806, 3805
4988, 3797, 3798, 3807, 3806
4989, 3798, 3799, 3808, 3807
4990, 3799, 3800, 3809, 3808
4991, 3800, 3801, 3810, 3809
4992, 3801, 3802, 3811, 3810
4993, 3802, 3803, 3812, 3811
4994, 3803, 796, 797, 3812
4995, 788, 3804, 3813, 789
4996, 3804, 3805, 3814, 3813
4997, 3805, 3806, 3815, 3814
4998, 3806, 3807, 3816, 3815
4999, 3807, 3808, 3817, 3816
5000, 3808, 3809, 3818, 3817
5001, 3809, 3810, 3819, 3818
5002, 3810, 3811, 3820, 3819
5003, 3811, 3812, 3821, 3820
5004, 3812, 797, 798, 3821
5005, 789, 3813, 3822, 790
5006, 3813, 3814, 3823, 3822
5007, 3814, 3815, 3824, 3823
5008, 3815, 3816, 3825, 3824
5009, 3816, 3817, 3826, 3825
5010, 3817, 3818, 3827, 3826
5011, 3818, 3819, 3828, 3827
5012, 3819, 3820, 3829, 3828
5013, 3820, 3821, 3830, 3829
5014, 3821, 798, 799, 3830
5015, 790, 3822, 3831, 791
5016, 3822, 3823, 3832, 3831
5017, 3823, 3824, 3833, 3832
5018, 3824, 3825, 3834, 3833
5019, 3825, 3826, 3835, 3834
5020, 3826, 3827, 3836, 3835
5021, 3827, 3828, 3837, 3836
5022, 3828, 3829, 3838, 3837
5023, 3829, 3830, 3839, 3838
5024, 3830, 799, 800, 3839
5025, 791, 3831, 3840, 792
5026, 3831, 3832, 3841, 3840
5027, 3832, 3833, 3842, 3841
5028, 3833, 3834, 3843, 3842
5029, 3834, 3835, 3844, 3843
5030, 3835, 3836, 3845, 3844
5031, 3836, 3837, 3846, 3845
5032, 3837, 3838, 3847, 3846
5033, 3838, 3839, 3848, 3847
5034, 3839, 800, 801, 3848
5035, 792, 3840, 3849, 793
5036, 3840, 3841, 3850, 3849
5037, 3841, 3842, 3851, 3850
5038, 3842, 3843, 3852, 3851
5039, 3843, 3844, 3853, 3852
5040, 3844, 3845, 3854, 3853
5041, 3845, 3846, 3855, 3854
5042, 3846, 3847, 3856, 3855
5043, 3847, 3848, 3857, 3856
5044, 3848, 801, 802, 3857
5045, 793, 3849, 3858, 794
5046, 3849, 3850, 3859, 3858
5047, 3850, 3851, 3860, 3859
5048, 3851, 3852, 3861, 3860
5049, 3852, 3853, 3862, 3861
5050, 3853, 3854, 3863, 3862
5051, 3854, 3855, 3864, 3863
5052, 3855, 3856, 3865, 3864
5053, 3856, 3857, 3866, 3865
5054, 3857, 802, 803, 3866
5055, 794, 3858, 3867, 795
5056, 3858, 3859, 3868, 3867
5057, 3859, 3860, 3869, 3868
5058, 3860, 3861, 3870, 3869
5059, 3861, 3862, 3871, 3870
5060, 3862, 3863, 3872, 3871
5061, 3863, 3864, 3873, 3872
5062, 3864, 3865, 3874, 3873
5063, 3865, 3866, 3875, 3874
5064, 3866, 803, 804, 3875
5065, 795, 3867, 769, 57
5066, 3867, 3868, 770, 769
5067, 3868, 3869, 771, 770
5068, 3869, 3870, 772, 771
5069, 3870, 3871, 773, 772
5070, 3871, 3872, 774, 773
5071, 3872, 3873, 775, 774
5072, 3873, 3874, 776, 775
5073, 3874, 3875, 777, 776
5074, 3875, 804, 58, 777
*ELEMENT, type=CPS4, ELSET=Surface82
5075, 33, 61, 805, 553
5076, 553, 805, 806, 554
5077, 554, 806, 807, 555
5078, 555, 807, 808, 556
5079, 556, 808, 809, 557
5080, 557, 809, 810, 558
5081, 558, 810, 811, 559
5082, 559, 811, 812, 560
5083, 560, 812, 813, 561
5084, 561, 813, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
5085, 35, 582, 814, 63
5086, 582, 583, 815, 814
5087, 583, 584, 816, 815
5088, 584, 585, 817, 816
5089, 585, 586, 818, 817
5090, 586, 587, 819, 818
5091, 587, 588, 820, 819
5092, 588, 589, 821, 820
5093, 589, 590, 822, 821
5094, 590, 39, 64, 822
*ELEMENT, type=CPS4, ELSET=Surface84
5095, 35, 63, 823, 535
5096, 535, 823, 824, 536
5097, 536, 824, 825, 537
5098, 537, 825, 826, 538
5099, 538, 826, 827, 539
5100, 539, 827, 828, 540
5101, 540, 828, 829, 541
5102, 541, 829, 830, 542
5103, 542, 830, 831, 543
5104, 543, 831, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
5105, 39, 611, 832, 64
5106, 611, 612, 833, 832
5107, 612, 613, 834, 833
5108, 613, 614, 835, 834
5109, 614, 615, 836, 835
5110, 615, 616, 837, 836
5111, 616, 617, 838, 837
5112, 617, 618, 839, 838
5113, 618, 619, 840, 839
5114, 619, 37, 62, 840
*ELEMENT, type=CPS4, ELSET=Surface86
5115, 63, 814, 3876, 823
5116, 814, 815, 3877, 3876
5117, 815, 816, 3878, 3877
5118, 816, 817, 3879, 3878
5119, 817, 818, 3880, 3879
5120, 818, 819, 3881, 3880
5121, 819, 820, 3882, 3881
5122, 820, 821, 3883, 3882
5123, 821, 822, 3884, 3883
5124, 822, 64, 832, 3884
5125, 823, 3876, 3885, 824
5126, 3876, 3877, 3886, 3885
5127, 3877, 3878, 3887, 3886
5128, 3878, 3879, 3888, 3887
5129, 3879, 3880, 3889, 3888
5130, 3880, 3881, 3890, 3889
5131, 3881, 3882, 3891, 3890
5132, 3882, 3883, 3892, 3891
5133, 3883, 3884, 3893, 3892
5134, 3884, 832, 833, 3893
5135, 824, 3885, 3894, 825
5136, 3885, 3886, 3895, 3894
5137, 3886, 3887, 3896, 3895
5138, 3887, 3888, 3897, 3896
5139, 3888, 3889, 3898, 3897
5140, 3889, 3890, 3899, 3898
5141, 3890, 3891, 3900, 3899
5142, 3891, 3892, 3901, 3900
5143, 3892, 3893, 3902, 3901
5144, 3893, 833, 834, 3902
5145, 825, 3894, 3903, 826
5146, 3894, 3895, 3904, 3903
5147, 3895, 3896, 3905, 3904
5148, 3896, 3897, 3906, 3905
5149, 3897, 3898, 3907, 3906
5150, 3898, 3899, 3908, 3907
5151, 3899, 3900, 3909, 3908
5152, 3900, 3901, 3910, 3909
5153, 3901, 3902, 3911, 3910
5154, 3902, 834, 835, 3911
5155, 826, 3903, 3912, 827
5156, 3903, 3904, 3913, 3912
5157, 3904, 3905, 3914, 3913
5158, 3905, 3906, 3915, 3914
5159, 3906, 3907, 3916, 3915
5160, 3907, 3908, 3917, 3916
5161, 3908, 3909, 3918, 3917
5162, 3909, 3910, 3919, 3918
5163, 3910, 3911, 3920, 3919
5164, 3911, 835, 836, 3920
5165, 827, 3912, 3921, 828
5166, 3912, 3913, 3922, 3921
5167, 3913, 3914, 3923, 3922
5168, 3914, 3915, 3924, 3923
5169, 3915, 3916, 3925, 3924
5170, 3916, 3917, 3926, 3925
5171, 3917, 3918, 3927, 3926
5172, 3918, 3919, 3928, 3927
5173, 3919, 3920, 3929, 3928
5174, 3920, 836, 837, 3929
5175, 828, 3921, 3930, 829
5176, 3921, 3922, 3931, 3930
5177, 3922, 3923, 3932, 3931
5178, 3923, 3924, 3933, 3932
5179, 3924, 3925, 3934, 3933
5180, 3925, 3926, 3935, 3934
5181, 3926, 3927, 3936, 3935
5182, 3927, 3928, 3937, 3936
5183, 3928, 3929, 3938, 3937
5184, 3929, 837, 838, 3938
5185, 829, 3930, 3939, 830
5186, 3930, 3931, 3940, 3939
5187, 3931, 3932, 3941, 3940
5188, 3932, 3933, 3942, 3941
5189, 3933, 3934, 3943, 3942
5190, 3934, 3935, 3944, 3943
5191, 3935, 3936, 3945, 3944
5192, 3936, 3937, 3946, 3945
5193, 3937, 3938, 3947, 3946
5194, 3938, 838, 839, 3947
5195, 830, 3939, 3948, 831
5196, 3939, 3940, 3949, 3948
5197, 3940, 3941, 3950, 3949
5198, 3941, 3942, 3951, 3950
5199, 3942, 3943, 3952, 3951
5200, 3943, 3944, 3953, 3952
5201, 3944, 3945, 3954, 3953
5202, 3945, 3946, 3955, 3954
5203, 3946, 3947, 3956, 3955
5204, 3947, 839, 840, 3956
5205, 831, 3948, 805, 61
5206, 3948, 3949, 806, 805
5207, 3949, 3950, 807, 806
5208, 3950, 3951, 808, 807
5209, 3951, 3952, 809, 808
5210, 3952, 3953, 810, 809
5211, 3953, 3954, 811, 810
5212, 3954, 3955, 812, 811
5213, 3955, 3956, 813, 812
5214, 3956, 840, 62, 813
*ELEMENT, type=CPS4, ELSET=Surface87
5215, 9, 65, 841, 229
5216, 229, 841, 842, 230
5217, 230, 842, 843, 231
5218, 231, 843, 844, 232
5219, 232, 844, 845, 233
5220, 233, 845, 846, 234
5221, 234, 846, 847, 235
5222, 235, 847, 848, 236
5223, 236, 848, 849, 237
5224, 237, 849, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
5225, 10, 238, 850, 67
5226, 238, 239, 851, 850
5227, 239, 240, 852, 851
5228, 240, 241, 853, 852
5229, 241, 242, 854, 853
5230, 242, 243, 855, 854
5231, 243, 244, 856, 855
5232, 244, 245, 857, 856
5233, 245, 246, 858, 857
5234, 246, 14, 68, 858
*ELEMENT, type=CPS4, ELSET=Surface89
5235, 10, 67, 859, 189
5236, 189, 859, 860, 190
5237, 190, 860, 861, 191
5238, 191, 861, 862, 192
5239, 192, 862, 863, 193
5240, 193, 863, 864, 194
5241, 194, 864, 865, 195
5242, 195, 865, 866, 196
5243, 196, 866, 867, 197
5244, 197, 867, 868, 198
5245, 198, 868, 869, 199
5246, 199, 869, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
5247, 14, 247, 870, 68
5248, 247, 248, 871, 870
5249, 248, 249, 872, 871
5250, 249, 250, 873, 872
5251, 250, 251, 874, 873
5252, 251, 252, 875, 874
5253, 252, 253, 876, 875
5254, 253, 254, 877, 876
5255, 254, 255, 878, 877
5256, 255, 256, 879, 878
5257, 256, 257, 880, 879
5258, 257, 13, 66, 880
*ELEMENT, type=CPS4, ELSET=Surface91
5259, 67, 850, 3957, 859
5260, 850, 851, 3958, 3957
5261, 851, 852, 3959, 3958
5262, 852, 853, 3960, 3959
5263, 853, 854, 3961, 3960
5264, 854, 855, 3962, 3961
5265, 855, 856, 3963, 3962
5266, 856, 857, 3964, 3963
5267, 857, 858, 3965, 3964
5268, 858, 68, 870, 3965
5269, 859, 3957, 3966, 860
5270, 3957, 3958, 3967, 3966
5271, 3958, 3959, 3968, 3967
5272, 3959, 3960, 3969, 3968
5273, 3960, 3961, 3970, 3969
5274, 3961, 3962, 3971, 3970
5275, 3962, 3963, 3972, 3971
5276, 3963, 3964, 3973, 3972
5277, 3964, 3965, 3974, 3973
5278, 3965, 870, 871, 3974
5279, 860, 3966, 3975, 861
5280, 3966, 3967, 3976, 3975
5281, 3967, 3968, 3977, 3976
5282, 3968, 3969, 3978, 3977
5283, 3969, 3970, 3979, 3978
5284, 3970, 3971, 3980, 3979
5285, 3971, 3972, 3981, 3980
5286, 3972, 3973, 3982, 3981
5287, 3973, 3974, 3983, 3982
5288, 3974, 871, 872, 3983
5289, 861, 3975, 3984, 862
5290, 3975, 3976, 3985, 3984
5291, 3976, 3977, 3986, 3985
5292, 3977, 3978, 3987, 3986
5293, 3978, 3979, 3988, 3987
5294, 3979, 3980, 3989, 3988
5295, 3980, 3981, 3990, 3989
5296, 3981, 3982, 3991, 3990
5297, 3982, 3983, 3992, 3991
5298, 3983, 872, 873, 3992
5299, 862, 3984, 3993, 863
5300, 3984, 3985, 3994, 3993
5301, 3985, 3986, 3995, 3994
5302, 3986, 3987, 3996, 3995
5303, 3987, 3988, 3997, 3996
5304, 3988, 3989, 3998, 3997
5305, 3989, 3990, 3999, 3998
5306, 3990, 3991, 4000, 3999
5307, 3991, 3992, 4001, 4000
5308, 3992, 873, 874, 4001
5309, 863, 3993, 4002, 864
5310, 3993, 3994, 4003, 4002
5311, 3994, 3995, 4004, 4003
5312, 3995, 3996, 4005, 4004
5313, 3996, 3997, 4006, 4005
5314, 3997, 3998, 4007, 4006
5315, 3998, 3999, 4008, 4007
5316, 3999, 4000, 4009, 4008
5317, 4000, 4001, 4010, 4009
5318, 4001, 874, 875, 4010
5319, 864, 4002, 4011, 865
5320, 4002, 4003, 4012, 4011
5321, 4003, 4004, 4013, 4012
5322, 4004, 4005, 4014, 4013
5323, 4005, 4006, 4015, 4014
5324, 4006, 4007, 4016, 4015
5325, 4007, 4008, 4017, 4016
5326, 4008, 4009, 4018, 4017
5327, 4009, 4010, 4019, 4018
5328, 4010, 875, 876, 4019
5329, 865, 4011, 4020, 866
5330, 4011, 4012, 4021, 4020
5331, 4012, 4013, 4022, 4021
5332, 4013, 4014, 4023, 4022
5333, 4014, 4015, 4024, 4023
5334, 4015, 4016, 4025, 4024
5335, 4016, 4017, 4026, 4025
5336, 4017, 4018, 4027, 4026
5337, 4018, 4019, 4028, 4027
5338, 4019, 876, 877, 4028
5339, 866, 4020, 4029, 867
5340, 4020, 4021, 4030, 4029
5341, 4021, 4022, 4031, 4030
5342, 4022, 4023, 4032, 4031
5343, 4023, 4024, 4033, 4032
5344, 4024, 4025, 4034, 4033
5345, 4025, 4026, 4035, 4034
5346, 4026, 4027, 4036, 4035
5347, 4027, 4028, 4037, 4036
5348, 4028, 877, 878, 4037
5349, 867, 4029, 4038, 868
5350, 4029, 4030, 4039, 4038
5351, 4030, 4031, 4040, 4039
5352, 4031, 4032, 4041, 4040
5353, 4032, 4033, 4042, 4041
5354, 4033, 4034, 4043, 4042
5355, 4034, 4035, 4044, 4043
5356, 4035, 4036, 4045, 4044
5357, 4036, 4037, 4046, 4045
5358, 4037, 878, 879, 4046
5359, 868, 4038, 4047, 869
5360, 4038, 4039, 4048, 4047
5361, 4039, 4040, 4049, 4048
5362, 4040, 4041, 4050, 4049
5363, 4041, 4042, 4051, 4050
5364, 4042, 4043, 4052, 4051
5365, 4043, 4044, 4053, 4052
5366, 4044, 4045, 4054, 4053
5367, 4045, 4046, 4055, 4054
5368, 4046, 879, 880, 4055
5369, 869, 4047, 841, 65
5370, 4047, 4048, 842, 841
5371, 4048, 4049, 843, 842
5372, 4049, 4050, 844, 843
5373, 4050, 4051, 845, 844
5374, 4051, 4052, 846, 845
5375, 4052, 4053, 847, 846
5376, 4053, 4054, 848, 847
5377, 4054, 4055, 849, 848
5378, 4055, 880, 66, 849
*ELEMENT, type=CPS4, ELSET=Surface92
5379, 35, 69, 881, 582
5380, 582, 881, 882, 583
5381, 583, 882, 883, 584
5382, 584, 883, 884, 585
5383, 585, 884, 885, 586
5384, 586, 885, 886, 587
5385, 587, 886, 887, 588
5386, 588, 887, 888, 589
5387, 589, 888, 889, 590
5388, 590, 889, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
5389, 36, 591, 890, 71
5390, 591, 592, 891, 890
5391, 592, 593, 892, 891
5392, 593, 594, 893, 892
5393, 594, 595, 894, 893
5394, 595, 596, 895, 894
5395, 596, 597, 896, 895
5396, 597, 598, 897, 896
5397, 598, 599, 898, 897
5398, 599, 40, 72, 898
*ELEMENT, type=CPS4, ELSET=Surface94
5399, 35, 524, 899, 69
5400, 524, 525, 900, 899
5401, 525, 526, 901, 900
5402, 526, 527, 902, 901
5403, 527, 528, 903, 902
5404, 528, 529, 904, 903
5405, 529, 530, 905, 904
5406, 530, 531, 906, 905
5407, 531, 532, 907, 906
5408, 532, 533, 908, 907
5409, 533, 534, 909, 908
5410, 534, 36, 71, 909
*ELEMENT, type=CPS4, ELSET=Surface95
5411, 39, 70, 910, 600
5412, 600, 910, 911, 601
5413, 601, 911, 912, 602
5414, 602, 912, 913, 603
5415, 603, 913, 914, 604
5416, 604, 914, 915, 605
5417, 605, 915, 916, 606
5418, 606, 916, 917, 607
5419, 607, 917, 918, 608
5420, 608, 918, 919, 609
5421, 609, 919, 920, 610
5422, 610, 920, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
5423, 69, 899, 4056, 881
5424, 881, 4056, 4057, 882
5425, 882, 4057, 4058, 883
5426, 883, 4058, 4059, 884
5427, 884, 4059, 4060, 885
5428, 885, 4060, 4061, 886
5429, 886, 4061, 4062, 887
5430, 887, 4062, 4063, 888
5431, 888, 4063, 4064, 889
5432, 889, 4064, 910, 70
5433, 899, 900, 4065, 4056
5434, 4056, 4065, 4066, 4057
5435, 4057, 4066, 4067, 4058
5436, 4058, 4067, 4068, 4059
5437, 4059, 4068, 4069, 4060
5438, 4060, 4069, 4070, 4061
5439, 4061, 4070, 4071, 4062
5440, 4062, 4071, 4072, 4063
5441, 4063, 4072, 4073, 4064
5442, 4064, 4073, 911, 910
5443, 900, 901, 4074, 4065
5444, 4065, 4074, 4075, 4066
5445, 4066, 4075, 4076, 4067
5446, 4067, 4076, 4077, 4068
5447, 4068, 4077, 4078, 4069
5448, 4069, 4078, 4079, 4070
5449, 4070, 4079, 4080, 4071
5450, 4071, 4080, 4081, 4072
5451, 4072, 4081, 4082, 4073
5452, 4073, 4082, 912, 911
5453, 901, 902, 4083, 4074
5454, 4074, 4083, 4084, 4075
5455, 4075, 4084, 4085, 4076
5456, 4076, 4085, 4086, 4077
5457, 4077, 4086, 4087, 4078
5458, 4078, 4087, 4088, 4079
5459, 4079, 4088, 4089, 4080
5460, 4080, 4089, 4090, 4081
5461, 4081, 4090, 4091, 4082
5462, 4082, 4091, 913, 912
5463, 902, 903, 4092, 4083
5464, 4083, 4092, 4093, 4084
5465, 4084, 4093, 4094, 4085
5466, 4085, 4094, 4095, 4086
5467, 4086, 4095, 4096, 4087
5468, 4087, 4096, 4097, 4088
5469, 4088, 4097, 4098, 4089
5470, 4089, 4098, 4099, 4090
5471, 4090, 4099, 4100, 4091
5472, 4091, 4100, 914, 913
5473, 903, 904, 4101, 4092
5474, 4092, 4101, 4102, 4093
5475, 4093, 4102, 4103, 4094
5476, 4094, 4103, 4104, 4095
5477, 4095, 4104, 4105, 4096
5478, 4096, 4105, 4106, 4097
5479, 4097, 4106, 4107, 4098
5480, 4098, 4107, 4108, 4099
5481, 4099, 4108, 4109, 4100
5482, 4100, 4109, 915, 914
5483, 904, 905, 4110, 4101
5484, 4101, 4110, 4111, 4102
5485, 4102, 4111, 4112, 4103
5486, 4103, 4112, 4113, 4104
5487, 4104, 4113, 4114, 4105
5488, 4105, 4114, 4115, 4106
5489, 4106, 4115, 4116, 4107
5490, 4107, 4116, 4117, 4108
5491, 4108, 4117, 4118, 4109
5492, 4109, 4118, 916, 915
5493, 905, 906, 4119, 4110
5494, 4110, 4119, 4120, 4111
5495, 4111, 4120, 4121, 4112
5496, 4112, 4121, 4122, 4113
5497, 4113, 4122, 4123, 4114
5498, 4114, 4123, 4124, 4115
5499, 4115, 4124, 4125, 4116
5500, 4116, 4125, 4126, 4117
5501, 4117, 4126, 4127, 4118
5502, 4118, 4127, 917, 916
5503, 906, 907, 4128, 4119
5504, 4119, 4128, 4129, 4120
5505, 4120, 4129, 4130, 4121
5506, 4121, 4130, 4131, 4122
5507, 4122, 4131, 4132, 4123
5508, 4123, 4132, 4133, 4124
5509, 4124, 4133, 4134, 4125
5510, 4125, 4134, 4135, 4126
5511, 4126, 4135, 4136, 4127
5512, 4127, 4136, 918, 917
5513, 907, 908, 4137, 4128
5514, 4128, 4137, 4138, 4129
5515, 4129, 4138, 4139, 4130
5516, 4130, 4139, 4140, 4131
5517, 4131, 4140, 4141, 4132
5518, 4132, 4141, 4142, 4133
5519, 4133, 4142, 4143, 4134
5520, 4134, 4143, 4144, 4135
5521, 4135, 4144, 4145, 4136
5522, 4136, 4145, 919, 918
5523, 908, 909, 4146, 4137
5524, 4137, 4146, 4147, 4138
5525, 4138, 4147, 4148, 4139
5526, 4139, 4148, 4149, 4140
5527, 4140, 4149, 4150, 4141
5528, 4141, 4150, 4151, 4142
5529, 4142, 4151, 4152, 4143
5530, 4143, 4152, 4153, 4144
5531, 4144, 4153, 4154, 4145
5532, 4145, 4154, 920, 919
5533, 909, 71, 890, 4146
5534, 4146, 890, 891, 4147
5535, 4147, 891, 892, 4148
5536, 4148, 892, 893, 4149
5537, 4149, 893, 894, 4150
5538, 4150, 894, 895, 4151
5539, 4151, 895, 896, 4152
5540, 4152, 896, 897, 4153
5541, 4153, 897, 898, 4154
5542, 4154, 898, 72, 920
*ELEMENT, type=CPS4, ELSET=Surface97
5543, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
5544, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
5545, 63, 73, 921, 814
5546, 814, 921, 922, 815
5547, 815, 922, 923, 816
5548, 816, 923, 924, 817
5549, 817, 924, 925, 818
5550, 818, 925, 926, 819
5551, 819, 926, 927, 820
5552, 820, 927, 928, 821
5553, 821, 928, 929, 822
5554, 822, 929, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
5555, 69, 881, 921, 73
5556, 881, 882, 922, 921
5557, 882, 883, 923, 922
5558, 883, 884, 924, 923
5559, 884, 885, 925, 924
5560, 885, 886, 926, 925
5561, 886, 887, 927, 926
5562, 887, 888, 928, 927
5563, 888, 889, 929, 928
5564, 889, 70, 74, 929
*ELEMENT, type=CPS4, ELSET=Surface101
5565, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
5566, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
5567, 59, 75, 930, 778
5568, 778, 930, 931, 779
5569, 779, 931, 932, 780
5570, 780, 932, 933, 781
5571, 781, 933, 934, 782
5572, 782, 934, 935, 783
5573, 783, 935, 936, 784
5574, 784, 936, 937, 785
5575, 785, 937, 938, 786
5576, 786, 938, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
5577, 65, 841, 930, 75
5578, 841, 842, 931, 930
5579, 842, 843, 932, 931
5580, 843, 844, 933, 932
5581, 844, 845, 934, 933
5582, 845, 846, 935, 934
5583, 846, 847, 936, 935
5584, 847, 848, 937, 936
5585, 848, 849, 938, 937
5586, 849, 66, 76, 938
*ELEMENT, type=CPS4, ELSET=Surface105
5587, 22, 943, 4155, 351
5588, 943, 944, 4156, 4155
5589, 944, 945, 4157, 4156
5590, 945, 946, 4158, 4157
5591, 946, 78, 947, 4158
5592, 351, 4155, 4159, 352
5593, 4155, 4156, 4160, 4159
5594, 4156, 4157, 4161, 4160
5595, 4157, 4158, 4162, 4161
5596, 4158, 947, 948, 4162
5597, 352, 4159, 4163, 353
5598, 4159, 4160, 4164, 4163
5599, 4160, 4161, 4165, 4164
5600, 4161, 4162, 4166, 4165
5601, 4162, 948, 949, 4166
5602, 353, 4163, 4167, 354
5603, 4163, 4164, 4168, 4167
5604, 4164, 4165, 4169, 4168
5605, 4165, 4166, 4170, 4169
5606, 4166, 949, 950, 4170
5607, 354, 4167, 4171, 355
5608, 4167, 4168, 4172, 4171
5609, 4168, 4169, 4173, 4172
5610, 4169, 4170, 4174, 4173
5611, 4170, 950, 951, 4174
5612, 355, 4171, 4175, 356
5613, 4171, 4172, 4176, 4175
5614, 4172, 4173, 4177, 4176
5615, 4173, 4174, 4178, 4177
5616, 4174, 951, 952, 4178
5617, 356, 4175, 4179, 357
5618, 4175, 4176, 4180, 4179
5619, 4176, 4177, 4181, 4180
5620, 4177, 4178, 4182, 4181
5621, 4178, 952, 953, 4182
5622, 357, 4179, 4183, 358
5623, 4179, 4180, 4184, 4183
5624, 4180, 4181, 4185, 4184
5625, 4181, 4182, 4186, 4185
5626, 4182, 953, 954, 4186
5627, 358, 4183, 4187, 359
5628, 4183, 4184, 4188, 4187
5629, 4184, 4185, 4189, 4188
5630, 4185, 4186, 4190, 4189
5631, 4186, 954, 955, 4190
5632, 359, 4187, 4191, 360
5633, 4187, 4188, 4192, 4191
5634, 4188, 4189, 4193, 4192
5635, 4189, 4190, 4194, 4193
5636, 4190, 955, 956, 4194
5637, 360, 4191, 4195, 361
5638, 4191, 4192, 4196, 4195
5639, 4192, 4193, 4197, 4196
5640, 4193, 4194, 4198, 4197
5641, 4194, 956, 957, 4198
5642, 361, 4195, 939, 21
5643, 4195, 4196, 940, 939
5644, 4196, 4197, 941, 940
5645, 4197, 4198, 942, 941
5646, 4198, 957, 77, 942
*ELEMENT, type=CPS4, ELSET=Surface106
5647, 21, 939, 4199, 365
5648, 939, 940, 4200, 4199
5649, 940, 941, 4201, 4200
5650, 941, 942, 4202, 4201
5651, 942, 77, 962, 4202
5652, 365, 4199, 4203, 366
5653, 4199, 4200, 4204, 4203
5654, 4200, 4201, 4205, 4204
5655, 4201, 4202, 4206, 4205
5656, 4202, 962, 963, 4206
5657, 366, 4203, 4207, 367
5658, 4203, 4204, 4208, 4207
5659, 4204, 4205, 4209, 4208
5660, 4205, 4206, 4210, 4209
5661, 4206, 963, 964, 4210
5662, 367, 4207, 4211, 368
5663, 4207, 4208, 4212, 4211
5664, 4208, 4209, 4213, 4212
5665, 4209, 4210, 4214, 4213
5666, 4210, 964, 965, 4214
5667, 368, 4211, 4215, 369
5668, 4211, 4212, 4216, 4215
5669, 4212, 4213, 4217, 4216
5670, 4213, 4214, 4218, 4217
5671, 4214, 965, 966, 4218
5672, 369, 4215, 4219, 370
5673, 4215, 4216, 4220, 4219
5674, 4216, 4217, 4221, 4220
5675, 4217, 4218, 4222, 4221
5676, 4218, 966, 967, 4222
5677, 370, 4219, 4223, 371
5678, 4219, 4220, 4224, 4223
5679, 4220, 4221, 4225, 4224
5680, 4221, 4222, 4226, 4225
5681, 4222, 967, 968, 4226
5682, 371, 4223, 4227, 372
5683, 4223, 4224, 4228, 4227
5684, 4224, 4225, 4229, 4228
5685, 4225, 4226, 4230, 4229
5686, 4226, 968, 969, 4230
5687, 372, 4227, 4231, 373
5688, 4227, 4228, 4232, 4231
5689, 4228, 4229, 4233, 4232
5690, 4229, 4230, 4234, 4233
5691, 4230, 969, 970, 4234
5692, 373, 4231, 958, 23
5693, 4231, 4232, 959, 958
5694, 4232, 4233, 960, 959
5695, 4233, 4234, 961, 960
5696, 4234, 970, 79, 961
*ELEMENT, type=CPS4, ELSET=Surface107
5697, 24, 377, 4235, 971
5698, 971, 4235, 4236, 972
5699, 972, 4236, 4237, 973
5700, 973, 4237, 4238, 974
5701, 974, 4238, 975, 80
5702, 377, 378, 4239, 4235
5703, 4235, 4239, 4240, 4236
5704, 4236, 4240, 4241, 4237
5705, 4237, 4241, 4242, 4238
5706, 4238, 4242, 976, 975
5707, 378, 379, 4243, 4239
5708, 4239, 4243, 4244, 4240
5709, 4240, 4244, 4245, 4241
5710, 4241, 4245, 4246, 4242
5711, 4242, 4246, 977, 976
5712, 379, 380, 4247, 4243
5713, 4243, 4247, 4248, 4244
5714, 4244, 4248, 4249, 4245
5715, 4245, 4249, 4250, 4246
5716, 4246, 4250, 978, 977
5717, 380, 381, 4251, 4247
5718, 4247, 4251, 4252, 4248
5719, 4248, 4252, 4253, 4249
5720, 4249, 4253, 4254, 4250
5721, 4250, 4254, 979, 978
5722, 381, 382, 4255, 4251
5723, 4251, 4255, 4256, 4252
5724, 4252, 4256, 4257, 4253
5725, 4253, 4257, 4258, 4254
5726, 4254, 4258, 980, 979
5727, 382, 383, 4259, 4255
5728, 4255, 4259, 4260, 4256
5729, 4256, 4260, 4261, 4257
5730, 4257, 4261, 4262, 4258
5731, 4258, 4262, 981, 980
5732, 383, 384, 4263, 4259
5733, 4259, 4263, 4264, 4260
5734, 4260, 4264, 4265, 4261
5735, 4261, 4265, 4266, 4262
5736, 4262, 4266, 982, 981
5737, 384, 385, 4267, 4263
5738, 4263, 4267, 4268, 4264
5739, 4264, 4268, 4269, 4265
5740, 4265, 4269, 4270, 4266
5741, 4266, 4270, 983, 982
5742, 385, 386, 4271, 4267
5743, 4267, 4271, 4272, 4268
5744, 4268, 4272, 4273, 4269
5745, 4269, 4273, 4274, 4270
5746, 4270, 4274, 984, 983
5747, 386, 387, 4275, 4271
5748, 4271, 4275, 4276, 4272
5749, 4272, 4276, 4277, 4273
5750, 4273, 4277, 4278, 4274
5751, 4274, 4278, 985, 984
5752, 387, 23, 958, 4275
5753, 4275, 958, 959, 4276
5754, 4276, 959, 960, 4277
5755, 4277, 960, 961, 4278
5756, 4278, 961, 79, 985
*ELEMENT, type=CPS4, ELSET=Surface108
5757, 22, 388, 4279, 943
5758, 943, 4279, 4280, 944
5759, 944, 4280, 4281, 945
5760, 945, 4281, 4282, 946
5761, 946, 4282, 986, 78
5762, 388, 389, 4283, 4279
5763, 4279, 4283, 4284, 4280
5764, 4280, 4284, 4285, 4281
5765, 4281, 4285, 4286, 4282
5766, 4282, 4286, 987, 986
5767, 389, 390, 4287, 4283
5768, 4283, 4287, 4288, 4284
5769, 4284, 4288, 4289, 4285
5770, 4285, 4289, 4290, 4286
5771, 4286, 4290, 988, 987
5772, 390, 391, 4291, 4287
5773, 4287, 4291, 4292, 4288
5774, 4288, 4292, 4293, 4289
5775, 4289, 4293, 4294, 4290
5776, 4290, 4294, 989, 988
5777, 391, 392, 4295, 4291
5778, 4291, 4295, 4296, 4292
5779, 4292, 4296, 4297, 4293
5780, 4293, 4297, 4298, 4294
5781, 4294, 4298, 990, 989
5782, 392, 393, 4299, 4295
5783, 4295, 4299, 4300, 4296
5784, 4296, 4300, 4301, 4297
5785, 4297, 4301, 4302, 4298
5786, 4298, 4302, 991, 990
5787, 393, 394, 4303, 4299
5788, 4299, 4303, 4304, 4300
5789, 4300, 4304, 4305, 4301
5790, 4301, 4305, 4306, 4302
5791, 4302, 4306, 992, 991
5792, 394, 395, 4307, 4303
5793, 4303, 4307, 4308, 4304
5794, 4304, 4308, 4309, 4305
5795, 4305, 4309, 4310, 4306
5796, 4306, 4310, 993, 992
5797, 395, 396, 4311, 4307
5798, 4307, 4311, 4312, 4308
5799, 4308, 4312, 4313, 4309
5800, 4309, 4313, 4314, 4310
5801, 4310, 4314, 994, 993
5802, 396, 24, 971, 4311
5803, 4311, 971, 972, 4312
5804, 4312, 972, 973, 4313
5805, 4313, 973, 974, 4314
5806, 4314, 974, 80, 994
*ELEMENT, type=CPS4, ELSET=Surface109
5807, 78, 986, 4315, 947
5808, 986, 987, 4316, 4315
5809, 987, 988, 4317, 4316
5810, 988, 989, 4318, 4317
5811, 989, 990, 4319, 4318
5812, 990, 991, 4320, 4319
5813, 991, 992, 4321, 4320
5814, 992, 993, 4322, 4321
5815, 993, 994, 4323, 4322
5816, 994, 80, 975, 4323
5817, 947, 4315, 4324, 948
5818, 4315, 4316, 4325, 4324
5819, 4316, 4317, 4326, 4325
5820, 4317, 4318, 4327, 4326
5821, 4318, 4319, 4328, 4327
5822, 4319, 4320, 4329, 4328
5823, 4320, 4321, 4330, 4329
5824, 4321, 4322, 4331, 4330
5825, 4322, 4323, 4332, 4331
5826, 4323, 975, 976, 4332
5827, 948, 4324, 4333, 949
5828, 4324, 4325, 4334, 4333
5829, 4325, 4326, 4335, 4334
5830, 4326, 4327, 4336, 4335
5831, 4327, 4328, 4337, 4336
5832, 4328, 4329, 4338, 4337
5833, 4329, 4330, 4339, 4338
5834, 4330, 4331, 4340, 4339
5835, 4331, 4332, 4341, 4340
5836, 4332, 976, 977, 4341
5837, 949, 4333, 4342, 950
5838, 4333, 4334, 4343, 4342
5839, 4334, 4335, 4344, 4343
5840, 4335, 4336, 4345, 4344
5841, 4336, 4337, 4346, 4345
5842, 4337, 4338, 4347, 4346
5843, 4338, 4339, 4348, 4347
5844, 4339, 4340, 4349, 4348
5845, 4340, 4341, 4350, 4349
5846, 4341, 977, 978, 4350
5847, 950, 4342, 4351, 951
5848, 4342, 4343, 4352, 4351
5849, 4343, 4344, 4353, 4352
5850, 4344, 4345, 4354, 4353
5851, 4345, 4346, 4355, 4354
5852, 4346, 4347, 4356, 4355
5853, 4347, 4348, 4357, 4356
5854, 4348, 4349, 4358, 4357
5855, 4349, 4350, 4359, 4358
5856, 4350, 978, 979, 4359
5857, 951, 4351, 4360, 952
5858, 4351, 4352, 4361, 4360
5859, 4352, 4353, 4362, 4361
5860, 4353, 4354, 4363, 4362
5861, 4354, 4355, 4364, 4363
5862, 4355, 4356, 4365, 4364
5863, 4356, 4357, 4366, 4365
5864, 4357, 4358, 4367, 4366
5865, 4358, 4359, 4368, 4367
5866, 4359, 979, 980, 4368
5867, 952, 4360, 4369, 953
5868, 4360, 4361, 4370, 4369
5869, 4361, 4362, 4371, 4370
5870, 4362, 4363, 4372, 4371
5871, 4363, 4364, 4373, 4372
5872, 4364, 4365, 4374, 4373
5873, 4365, 4366, 4375, 4374
5874, 4366, 4367, 4376, 4375
5875, 4367, 4368, 4377, 4376
5876, 4368, 980, 981, 4377
5877, 953, 4369, 4378, 954
5878, 4369, 4370, 4379, 4378
5879, 4370, 4371, 4380, 4379
5880, 4371, 4372, 4381, 4380
5881, 4372, 4373, 4382, 4381
5882, 4373, 4374, 4383, 4382
5883, 4374, 4375, 4384, 4383
5884, 4375, 4376, 4385, 4384
5885, 4376, 4377, 4386, 4385
5886, 4377, 981, 982, 4386
5887, 954, 4378, 4387, 955
5888, 4378, 4379, 4388, 4387
5889, 4379, 4380, 4389, 4388
5890, 4380, 4381, 4390, 4389
5891, 4381, 4382, 4391, 4390
5892, 4382, 4383, 4392, 4391
5893, 4383, 4384, 4393, 4392
5894, 4384, 4385, 4394, 4393
5895, 4385, 4386, 4395, 4394
5896, 4386, 982, 983, 4395
5897, 955, 4387, 4396, 956
5898, 4387, 4388, 4397, 4396
5899, 4388, 4389, 4398, 4397
5900, 4389, 4390, 4399, 4398
5901, 4390, 4391, 4400, 4399
5902, 4391, 4392, 4401, 4400
5903, 4392, 4393, 4402, 4401
5904, 4393, 4394, 4403, 4402
5905, 4394, 4395, 4404, 4403
5906, 4395, 983, 984, 4404
5907, 956, 4396, 4405, 957
5908, 4396, 4397, 4406, 4405
5909, 4397, 4398, 4407, 4406
5910, 4398, 4399, 4408, 4407
5911, 4399, 4400, 4409, 4408
5912, 4400, 4401, 4410, 4409
5913, 4401, 4402, 4411, 4410
5914, 4402, 4403, 4412, 4411
5915, 4403, 4404, 4413, 4412
5916, 4404, 984, 985, 4413
5917, 957, 4405, 962, 77
5918, 4405, 4406, 963, 962
5919, 4406, 4407, 964, 963
5920, 4407, 4408, 965, 964
5921, 4408, 4409, 966, 965
5922, 4409, 4410, 967, 966
5923, 4410, 4411, 968, 967
5924, 4411, 4412, 969, 968
5925, 4412, 4413, 970, 969
5926, 4413, 985, 79, 970
*ELEMENT, type=CPS4, ELSET=Surface110
5927, 23, 403, 4414, 958
5928, 958, 4414, 4415, 959
5929, 959, 4415, 4416, 960
5930, 960, 4416, 4417, 961
5931, 961, 4417, 999, 79
5932, 403, 404, 4418, 4414
5933, 4414, 4418, 4419, 4415
5934, 4415, 4419, 4420, 4416
5935, 4416, 4420, 4421, 4417
5936, 4417, 4421, 1000, 999
5937, 404, 405, 4422, 4418
5938, 4418, 4422, 4423, 4419
5939, 4419, 4423, 4424, 4420
5940, 4420, 4424, 4425, 4421
5941, 4421, 4425, 1001, 1000
5942, 405, 406, 4426, 4422
5943, 4422, 4426, 4427, 4423
5944, 4423, 4427, 4428, 4424
5945, 4424, 4428, 4429, 4425
5946, 4425, 4429, 1002, 1001
5947, 406, 407, 4430, 4426
5948, 4426, 4430, 4431, 4427
5949, 4427, 4431, 4432, 4428
5950, 4428, 4432, 4433, 4429
5951, 4429, 4433, 1003, 1002
5952, 407, 408, 4434, 4430
5953, 4430, 4434, 4435, 4431
5954, 4431, 4435, 4436, 4432
5955, 4432, 4436, 4437, 4433
5956, 4433, 4437, 1004, 1003
5957, 408, 26, 995, 4434
5958, 4434, 995, 996, 4435
5959, 4435, 996, 997, 4436
5960, 4436, 997, 998, 4437
5961, 4437, 998, 81, 1004
*ELEMENT, type=CPS4, ELSET=Surface111
5962, 21, 939, 4438, 418
5963, 939, 940, 4439, 4438
5964, 940, 941, 4440, 4439
5965, 941, 942, 4441, 4440
5966, 942, 77, 1009, 4441
5967, 418, 4438, 4442, 419
5968, 4438, 4439, 4443, 4442
5969, 4439, 4440, 4444, 4443
5970, 4440, 4441, 4445, 4444
5971, 4441, 1009, 1010, 4445
5972, 419, 4442, 4446, 420
5973, 4442, 4443, 4447, 4446
5974, 4443, 4444, 4448, 4447
5975, 4444, 4445, 4449, 4448
5976, 4445, 1010, 1011, 4449
5977, 420, 4446, 4450, 421
5978, 4446, 4447, 4451, 4450
5979, 4447, 4448, 4452, 4451
5980, 4448, 4449, 4453, 4452
5981, 4449, 1011, 1012, 4453
5982, 421, 4450, 4454, 422
5983, 4450, 4451, 4455, 4454
5984, 4451, 4452, 4456, 4455
5985, 4452, 4453, 4457, 4456
5986, 4453, 1012, 1013, 4457
5987, 422, 4454, 4458, 423
5988, 4454, 4455, 4459, 4458
5989, 4455, 4456, 4460, 4459
5990, 4456, 4457, 4461, 4460
5991, 4457, 1013, 1014, 4461
5992, 423, 4458, 1005, 28
5993, 4458, 4459, 1006, 1005
5994, 4459, 4460, 1007, 1006
5995, 4460, 4461, 1008, 1007
5996, 4461, 1014, 82, 1008
*ELEMENT, type=CPS4, ELSET=Surface112
5997, 28, 1005, 4462, 436
5998, 1005, 1006, 4463, 4462
5999, 1006, 1007, 4464, 4463
6000, 1007, 1008, 4465, 4464
6001, 1008, 82, 1015, 4465
6002, 436, 4462, 4466, 437
6003, 4462, 4463, 4467, 4466
6004, 4463, 4464, 4468, 4467
6005, 4464, 4465, 4469, 4468
6006, 4465, 1015, 1016, 4469
6007, 437, 4466, 4470, 438
6008, 4466, 4467, 4471, 4470
6009, 4467, 4468, 4472, 4471
6010, 4468, 4469, 4473, 4472
6011, 4469, 1016, 1017, 4473
6012, 438, 4470, 4474, 439
6013, 4470, 4471, 4475, 4474
6014, 4471, 4472, 4476, 4475
6015, 4472, 4473, 4477, 4476
6016, 4473, 1017, 1018, 4477
6017, 439, 4474, 4478, 440
6018, 4474, 4475, 4479, 4478
6019, 4475, 4476, 4480, 4479
6020, 4476, 4477, 4481, 4480
6021, 4477, 1018, 1019, 4481
6022, 440, 4478, 4482, 441
6023, 4478, 4479, 4483, 4482
6024, 4479, 4480, 4484, 4483
6025, 4480, 4481, 4485, 4484
6026, 4481, 1019, 1020, 4485
6027, 441, 4482, 4486, 442
6028, 4482, 4483, 4487, 4486
6029, 4483, 4484, 4488, 4487
6030, 4484, 4485, 4489, 4488
6031, 4485, 1020, 1021, 4489
6032, 442, 4486, 4490, 443
6033, 4486, 4487, 4491, 4490
6034, 4487, 4488, 4492, 4491
6035, 4488, 4489, 4493, 4492
6036, 4489, 1021, 1022, 4493
6037, 443, 4490, 4494, 444
6038, 4490, 4491, 4495, 4494
6039, 4491, 4492, 4496, 4495
6040, 4492, 4493, 4497, 4496
6041, 4493, 1022, 1023, 4497
6042, 444, 4494, 995, 26
6043, 4494, 4495, 996, 995
6044, 4495, 4496, 997, 996
6045, 4496, 4497, 998, 997
6046, 4497, 1023, 81, 998
*ELEMENT, type=CPS4, ELSET=Surface113
6047, 77, 962, 4498, 1009
6048, 1009, 4498, 4499, 1010
6049, 1010, 4499, 4500, 1011
6050, 1011, 4500, 4501, 1012
6051, 1012, 4501, 4502, 1013
6052, 1013, 4502, 4503, 1014
6053, 1014, 4503, 1015, 82
6054, 962, 963, 4504, 4498
6055, 4498, 4504, 4505, 4499
6056, 4499, 4505, 4506, 4500
6057, 4500, 4506, 4507, 4501
6058, 4501, 4507, 4508, 4502
6059, 4502, 4508, 4509, 4503
6060, 4503, 4509, 1016, 1015
6061, 963, 964, 4510, 4504
6062, 4504, 4510, 4511, 4505
6063, 4505, 4511, 4512, 4506
6064, 4506, 4512, 4513, 4507
6065, 4507, 4513, 4514, 4508
6066, 4508, 4514, 4515, 4509
6067, 4509, 4515, 1017, 1016
6068, 964, 965, 4516, 4510
6069, 4510, 4516, 4517, 4511
6070, 4511, 4517, 4518, 4512
6071, 4512, 4518, 4519, 4513
6072, 4513, 4519, 4520, 4514
6073, 4514, 4520, 4521, 4515
6074, 4515, 4521, 1018, 1017
6075, 965, 966, 4522, 4516
6076, 4516, 4522, 4523, 4517
6077, 4517, 4523, 4524, 4518
6078, 4518, 4524, 4525, 4519
6079, 4519, 4525, 4526, 4520
6080, 4520, 4526, 4527, 4521
6081, 4521, 4527, 1019, 1018
6082, 966, 967, 4528, 4522
6083, 4522, 4528, 4529, 4523
6084, 4523, 4529, 4530, 4524
6085, 4524, 4530, 4531, 4525
6086, 4525, 4531, 4532, 4526
6087, 4526, 4532, 4533, 4527
6088, 4527, 4533, 1020, 1019
6089, 967, 968, 4534, 4528
6090, 4528, 4534, 4535, 4529
6091, 4529, 4535, 4536, 4530
6092, 4530, 4536, 4537, 4531
6093, 4531, 4537, 4538, 4532
6094, 4532, 4538, 4539, 4533
6095, 4533, 4539, 1021, 1020
6096, 968, 969, 4540, 4534
6097, 4534, 4540, 4541, 4535
6098, 4535, 4541, 4542, 4536
6099, 4536, 4542, 4543, 4537
6100, 4537, 4543, 4544, 4538
6101, 4538, 4544, 4545, 4539
6102, 4539, 4545, 1022, 1021
6103, 969, 970, 4546, 4540
6104, 4540, 4546, 4547, 4541
6105, 4541, 4547, 4548, 4542
6106, 4542, 4548, 4549, 4543
6107, 4543, 4549, 4550, 4544
6108, 4544, 4550, 4551, 4545
6109, 4545, 4551, 1023, 1022
6110, 970, 79, 999, 4546
6111, 4546, 999, 1000, 4547
6112, 4547, 1000, 1001, 4548
6113, 4548, 1001, 1002, 4549
6114, 4549, 1002, 1003, 4550
6115, 4550, 1003, 1004, 4551
6116, 4551, 1004, 81, 1023
*ELEMENT, type=CPS4, ELSET=Surface114
6117, 26, 456, 4552, 995
6118, 995, 4552, 4553, 996
6119, 996, 4553, 4554, 997
6120, 997, 4554, 4555, 998
6121, 998, 4555, 1028, 81
6122, 456, 457, 4556, 4552
6123, 4552, 4556, 4557, 4553
6124, 4553, 4557, 4558, 4554
6125, 4554, 4558, 4559, 4555
6126, 4555, 4559, 1029, 1028
6127, 457, 458, 4560, 4556
6128, 4556, 4560, 4561, 4557
6129, 4557, 4561, 4562, 4558
6130, 4558, 4562, 4563, 4559
6131, 4559, 4563, 1030, 1029
6132, 458, 459, 4564, 4560
6133, 4560, 4564, 4565, 4561
6134, 4561, 4565, 4566, 4562
6135, 4562, 4566, 4567, 4563
6136, 4563, 4567, 1031, 1030
6137, 459, 460, 4568, 4564
6138, 4564, 4568, 4569, 4565
6139, 4565, 4569, 4570, 4566
6140, 4566, 4570, 4571, 4567
6141, 4567, 4571, 1032, 1031
6142, 460, 461, 4572, 4568
6143, 4568, 4572, 4573, 4569
6144, 4569, 4573, 4574, 4570
6145, 4570, 4574, 4575, 4571
6146, 4571, 4575, 1033, 1032
6147, 461, 462, 4576, 4572
6148, 4572, 4576, 4577, 4573
6149, 4573, 4577, 4578, 4574
6150, 4574, 4578, 4579, 4575
6151, 4575, 4579, 1034, 1033
6152, 462, 463, 4580, 4576
6153, 4576, 4580, 4581, 4577
6154, 4577, 4581, 4582, 4578
6155, 4578, 4582, 4583, 4579
6156, 4579, 4583, 1035, 1034
6157, 463, 464, 4584, 4580
6158, 4580, 4584, 4585, 4581
6159, 4581, 4585, 4586, 4582
6160, 4582, 4586, 4587, 4583
6161, 4583, 4587, 1036, 1035
6162, 464, 465, 4588, 4584
6163, 4584, 4588, 4589, 4585
6164, 4585, 4589, 4590, 4586
6165, 4586, 4590, 4591, 4587
6166, 4587, 4591, 1037, 1036
6167, 465, 466, 4592, 4588
6168, 4588, 4592, 4593, 4589
6169, 4589, 4593, 4594, 4590
6170, 4590, 4594, 4595, 4591
6171, 4591, 4595, 1038, 1037
6172, 466, 30, 1024, 4592
6173, 4592, 1024, 1025, 4593
6174, 4593, 1025, 1026, 4594
6175, 4594, 1026, 1027, 4595
6176, 4595, 1027, 83, 1038
*ELEMENT, type=CPS4, ELSET=Surface115
6177, 28, 1005, 4596, 481
6178, 1005, 1006, 4597, 4596
6179, 1006, 1007, 4598, 4597
6180, 1007, 1008, 4599, 4598
6181, 1008, 82, 1043, 4599
6182, 481, 4596, 4600, 482
6183, 4596, 4597, 4601, 4600
6184, 4597, 4598, 4602, 4601
6185, 4598, 4599, 4603, 4602
6186, 4599, 1043, 1044, 4603
6187, 482, 4600, 4604, 483
6188, 4600, 4601, 4605, 4604
6189, 4601, 4602, 4606, 4605
6190, 4602, 4603, 4607, 4606
6191, 4603, 1044, 1045, 4607
6192, 483, 4604, 4608, 484
6193, 4604, 4605, 4609, 4608
6194, 4605, 4606, 4610, 4609
6195, 4606, 4607, 4611, 4610
6196, 4607, 1045, 1046, 4611
6197, 484, 4608, 4612, 485
6198, 4608, 4609, 4613, 4612
6199, 4609, 4610, 4614, 4613
6200, 4610, 4611, 4615, 4614
6201, 4611, 1046, 1047, 4615
6202, 485, 4612, 4616, 486
6203, 4612, 4613, 4617, 4616
6204, 4613, 4614, 4618, 4617
6205, 4614, 4615, 4619, 4618
6206, 4615, 1047, 1048, 4619
6207, 486, 4616, 4620, 487
6208, 4616, 4617, 4621, 4620
6209, 4617, 4618, 4622, 4621
6210, 4618, 4619, 4623, 4622
6211, 4619, 1048, 1049, 4623
6212, 487, 4620, 4624, 488
6213, 4620, 4621, 4625, 4624
6214, 4621, 4622, 4626, 4625
6215, 4622, 4623, 4627, 4626
6216, 4623, 1049, 1050, 4627
6217, 488, 4624, 4628, 489
6218, 4624, 4625, 4629, 4628
6219, 4625, 4626, 4630, 4629
6220, 4626, 4627, 4631, 4630
6221, 4627, 1050, 1051, 4631
6222, 489, 4628, 4632, 490
6223, 4628, 4629, 4633, 4632
6224, 4629, 4630, 4634, 4633
6225, 4630, 4631, 4635, 4634
6226, 4631, 1051, 1052, 4635
6227, 490, 4632, 4636, 491
6228, 4632, 4633, 4637, 4636
6229, 4633, 4634, 4638, 4637
6230, 4634, 4635, 4639, 4638
6231, 4635, 1052, 1053, 4639
6232, 491, 4636, 1039, 32
6233, 4636, 4637, 1040, 1039
6234, 4637, 4638, 1041, 1040
6235, 4638, 4639, 1042, 1041
6236, 4639, 1053, 84, 1042
*ELEMENT, type=CPS4, ELSET=Surface116
6237, 32, 1039, 4640, 504
6238, 1039, 1040, 4641, 4640
6239, 1040, 1041, 4642, 4641
6240, 1041, 1042, 4643, 4642
6241, 1042, 84, 1054, 4643
6242, 504, 4640, 4644, 505
6243, 4640, 4641, 4645, 4644
6244, 4641, 4642, 4646, 4645
6245, 4642, 4643, 4647, 4646
6246, 4643, 1054, 1055, 4647
6247, 505, 4644, 4648, 506
6248, 4644, 4645, 4649, 4648
6249, 4645, 4646, 4650, 4649
6250, 4646, 4647, 4651, 4650
6251, 4647, 1055, 1056, 4651
6252, 506, 4648, 4652, 507
6253, 4648, 4649, 4653, 4652
6254, 4649, 4650, 4654, 4653
6255, 4650, 4651, 4655, 4654
6256, 4651, 1056, 1057, 4655
6257, 507, 4652, 4656, 508
6258, 4652, 4653, 4657, 4656
6259, 4653, 4654, 4658, 4657
6260, 4654, 4655, 4659, 4658
6261, 4655, 1057, 1058, 4659
6262, 508, 4656, 4660, 509
6263, 4656, 4657, 4661, 4660
6264, 4657, 4658, 4662, 4661
6265, 4658, 4659, 4663, 4662
6266, 4659, 1058, 1059, 4663
6267, 509, 4660, 4664, 510
6268, 4660, 4661, 4665, 4664
6269, 4661, 4662, 4666, 4665
6270, 4662, 4663, 4667, 4666
6271, 4663, 1059, 1060, 4667
6272, 510, 4664, 4668, 511
6273, 4664, 4665, 4669, 4668
6274, 4665, 4666, 4670, 4669
6275, 4666, 4667, 4671, 4670
6276, 4667, 1060, 1061, 4671
6277, 511, 4668, 4672, 512
6278, 4668, 4669, 4673, 4672
6279, 4669, 4670, 4674, 4673
6280, 4670, 4671, 4675, 4674
6281, 4671, 1061, 1062, 4675
6282, 512, 4672, 1024, 30
6283, 4672, 4673, 1025, 1024
6284, 4673, 4674, 1026, 1025
6285, 4674, 4675, 1027, 1026
6286, 4675, 1062, 83, 1027
*ELEMENT, type=CPS4, ELSET=Surface117
6287, 82, 1015, 4676, 1043
6288, 1043, 4676, 4677, 1044
6289, 1044, 4677, 4678, 1045
6290, 1045, 4678, 4679, 1046
6291, 1046, 4679, 4680, 1047
6292, 1047, 4680, 4681, 1048
6293, 1048, 4681, 4682, 1049
6294, 1049, 4682, 4683, 1050
6295, 1050, 4683, 4684, 1051
6296, 1051, 4684, 4685, 1052
6297, 1052, 4685, 4686, 1053
6298, 1053, 4686, 1054, 84
6299, 1015, 1016, 4687, 4676
6300, 4676, 4687, 4688, 4677
6301, 4677, 4688, 4689, 4678
6302, 4678, 4689, 4690, 4679
6303, 4679, 4690, 4691, 4680
6304, 4680, 4691, 4692, 4681
6305, 4681, 4692, 4693, 4682
6306, 4682, 4693, 4694, 4683
6307, 4683, 4694, 4695, 4684
6308, 4684, 4695, 4696, 4685
6309, 4685, 4696, 4697, 4686
6310, 4686, 4697, 1055, 1054
6311, 1016, 1017, 4698, 4687
6312, 4687, 4698, 4699, 4688
6313, 4688, 4699, 4700, 4689
6314, 4689, 4700, 4701, 4690
6315, 4690, 4701, 4702, 4691
6316, 4691, 4702, 4703, 4692
6317, 4692, 4703, 4704, 4693
6318, 4693, 4704, 4705, 4694
6319, 4694, 4705, 4706, 4695
6320, 4695, 4706, 4707, 4696
6321, 4696, 4707, 4708, 4697
6322, 4697, 4708, 1056, 1055
6323, 1017, 1018, 4709, 4698
6324, 4698, 4709, 4710, 4699
6325, 4699, 4710, 4711, 4700
6326, 4700, 4711, 4712, 4701
6327, 4701, 4712, 4713, 4702
6328, 4702, 4713, 4714, 4703
6329, 4703, 4714, 4715, 4704
6330, 4704, 4715, 4716, 4705
6331, 4705, 4716, 4717, 4706
6332, 4706, 4717, 4718, 4707
6333, 4707, 4718, 4719, 4708
6334, 4708, 4719, 1057, 1056
6335, 1018, 1019, 4720, 4709
6336, 4709, 4720, 4721, 4710
6337, 4710, 4721, 4722, 4711
6338, 4711, 4722, 4723, 4712
6339, 4712, 4723, 4724, 4713
6340, 4713, 4724, 4725, 4714
6341, 4714, 4725, 4726, 4715
6342, 4715, 4726, 4727, 4716
6343, 4716, 4727, 4728, 4717
6344, 4717, 4728, 4729, 4718
6345, 4718, 4729, 4730, 4719
6346, 4719, 4730, 1058, 1057
6347, 1019, 1020, 4731, 4720
6348, 4720, 4731, 4732, 4721
6349, 4721, 4732, 4733, 4722
6350, 4722, 4733, 4734, 4723
6351, 4723, 4734, 4735, 4724
6352, 4724, 4735, 4736, 4725
6353, 4725, 4736, 4737, 4726
6354, 4726, 4737, 4738, 4727
6355, 4727, 4738, 4739, 4728
6356, 4728, 4739, 4740, 4729
6357, 4729, 4740, 4741, 4730
6358, 4730, 4741, 1059, 1058
6359, 1020, 1021, 4742, 4731
6360, 4731, 4742, 4743, 4732
6361, 4732, 4743, 4744, 4733
6362, 4733, 4744, 4745, 4734
6363, 4734, 4745, 4746, 4735
6364, 4735, 4746, 4747, 4736
6365, 4736, 4747, 4748, 4737
6366, 4737, 4748, 4749, 4738
6367, 4738, 4749, 4750, 4739
6368, 4739, 4750, 4751, 4740
6369, 4740, 4751, 4752, 4741
6370, 4741, 4752, 1060, 1059
6371, 1021, 1022, 4753, 4742
6372, 4742, 4753, 4754, 4743
6373, 4743, 4754, 4755, 4744
6374, 4744, 4755, 4756, 4745
6375, 4745, 4756, 4757, 4746
6376, 4746, 4757, 4758, 4747
6377, 4747, 4758, 4759, 4748
6378, 4748, 4759, 4760, 4749
6379, 4749, 4760, 4761, 4750
6380, 4750, 4761, 4762, 4751
6381, 4751, 4762, 4763, 4752
6382, 4752, 4763, 1061, 1060
6383, 1022, 1023, 4764, 4753
6384, 4753, 4764, 4765, 4754
6385, 4754, 4765, 4766, 4755
6386, 4755, 4766, 4767, 4756
6387, 4756, 4767, 4768, 4757
6388, 4757, 4768, 4769, 4758
6389, 4758, 4769, 4770, 4759
6390, 4759, 4770, 4771, 4760
6391, 4760, 4771, 4772, 4761
6392, 4761, 4772, 4773, 4762
6393, 4762, 4773, 4774, 4763
6394, 4763, 4774, 1062, 1061
6395, 1023, 81, 1028, 4764
6396, 4764, 1028, 1029, 4765
6397, 4765, 1029, 1030, 4766
6398, 4766, 1030, 1031, 4767
6399, 4767, 1031, 1032, 4768
6400, 4768, 1032, 1033, 4769
6401, 4769, 1033, 1034, 4770
6402, 4770, 1034, 1035, 4771
6403, 4771, 1035, 1036, 4772
6404, 4772, 1036, 1037, 4773
6405, 4773, 1037, 1038, 4774
6406, 4774, 1038, 83, 1062
*ELEMENT, type=CPS4, ELSET=Surface118
6407, 2, 145, 4775, 1067
6408, 1067, 4775, 4776, 1068
6409, 1068, 4776, 4777, 1069
6410, 1069, 4777, 4778, 1070
6411, 1070, 4778, 1071, 86
6412, 145, 146, 4779, 4775
6413, 4775, 4779, 4780, 4776
6414, 4776, 4780, 4781, 4777
6415, 4777, 4781, 4782, 4778
6416, 4778, 4782, 1072, 1071
6417, 146, 147, 4783, 4779
6418, 4779, 4783, 4784, 4780
6419, 4780, 4784, 4785, 4781
6420, 4781, 4785, 4786, 4782
6421, 4782, 4786, 1073, 1072
6422, 147, 148, 4787, 4783
6423, 4783, 4787, 4788, 4784
6424, 4784, 4788, 4789, 4785
6425, 4785, 4789, 4790, 4786
6426, 4786, 4790, 1074, 1073
6427, 148, 149, 4791, 4787
6428, 4787, 4791, 4792, 4788
6429, 4788, 4792, 4793, 4789
6430, 4789, 4793, 4794, 4790
6431, 4790, 4794, 1075, 1074
6432, 149, 150, 4795, 4791
6433, 4791, 4795, 4796, 4792
6434, 4792, 4796, 4797, 4793
6435, 4793, 4797, 4798, 4794
6436, 4794, 4798, 1076, 1075
6437, 150, 151, 4799, 4795
6438, 4795, 4799, 4800, 4796
6439, 4796, 4800, 4801, 4797
6440, 4797, 4801, 4802, 4798
6441, 4798, 4802, 1077, 1076
6442, 151, 152, 4803, 4799
6443, 4799, 4803, 4804, 4800
6444, 4800, 4804, 4805, 4801
6445, 4801, 4805, 4806, 4802
6446, 4802, 4806, 1078, 1077
6447, 152, 153, 4807, 4803
6448, 4803, 4807, 4808, 4804
6449, 4804, 4808, 4809, 4805
6450, 4805, 4809, 4810, 4806
6451, 4806, 4810, 1079, 1078
6452, 153, 154, 4811, 4807
6453, 4807, 4811, 4812, 4808
6454, 4808, 4812, 4813, 4809
6455, 4809, 4813, 4814, 4810
6456, 4810, 4814, 1080, 1079
6457, 154, 155, 4815, 4811
6458, 4811, 4815, 4816, 4812
6459, 4812, 4816, 4817, 4813
6460, 4813, 4817, 4818, 4814
6461, 4814, 4818, 1081, 1080
6462, 155, 6, 1063, 4815
6463, 4815, 1063, 1064, 4816
6464, 4816, 1064, 1065, 4817
6465, 4817, 1065, 1066, 4818
6466, 4818, 1066, 85, 1081
*ELEMENT, type=CPS4, ELSET=Surface119
6467, 6, 121, 4819, 1063
6468, 1063, 4819, 4820, 1064
6469, 1064, 4820, 4821, 1065
6470, 1065, 4821, 4822, 1066
6471, 1066, 4822, 1086, 85
6472, 121, 122, 4823, 4819
6473, 4819, 4823, 4824, 4820
6474, 4820, 4824, 4825, 4821
6475, 4821, 4825, 4826, 4822
6476, 4822, 4826, 1087, 1086
6477, 122, 123, 4827, 4823
6478, 4823, 4827, 4828, 4824
6479, 4824, 4828, 4829, 4825
6480, 4825, 4829, 4830, 4826
6481, 4826, 4830, 1088, 1087
6482, 123, 124, 4831, 4827
6483, 4827, 4831, 4832, 4828
6484, 4828, 4832, 4833, 4829
6485, 4829, 4833, 4834, 4830
6486, 4830, 4834, 1089, 1088
6487, 124, 125, 4835, 4831
6488, 4831, 4835, 4836, 4832
6489, 4832, 4836, 4837, 4833
6490, 4833, 4837, 4838, 4834
6491, 4834, 4838, 1090, 1089
6492, 125, 126, 4839, 4835
6493, 4835, 4839, 4840, 4836
6494, 4836, 4840, 4841, 4837
6495, 4837, 4841, 4842, 4838
6496, 4838, 4842, 1091, 1090
6497, 126, 127, 4843, 4839
6498, 4839, 4843, 4844, 4840
6499, 4840, 4844, 4845, 4841
6500, 4841, 4845, 4846, 4842
6501, 4842, 4846, 1092, 1091
6502, 127, 128, 4847, 4843
6503, 4843, 4847, 4848, 4844
6504, 4844, 4848, 4849, 4845
6505, 4845, 4849, 4850, 4846
6506, 4846, 4850, 1093, 1092
6507, 128, 129, 4851, 4847
6508, 4847, 4851, 4852, 4848
6509, 4848, 4852, 4853, 4849
6510, 4849, 4853, 4854, 4850
6511, 4850, 4854, 1094, 1093
6512, 129, 5, 1082, 4851
6513, 4851, 1082, 1083, 4852
6514, 4852, 1083, 1084, 4853
6515, 4853, 1084, 1085, 4854
6516, 4854, 1085, 87, 1094
*ELEMENT, type=CPS4, ELSET=Surface120
6517, 1, 1095, 4855, 156
6518, 1095, 1096, 4856, 4855
6519, 1096, 1097, 4857, 4856
6520, 1097, 1098, 4858, 4857
6521, 1098, 88, 1099, 4858
6522, 156, 4855, 4859, 157
6523, 4855, 4856, 4860, 4859
6524, 4856, 4857, 4861, 4860
6525, 4857, 4858, 4862, 4861
6526, 4858, 1099, 1100, 4862
6527, 157, 4859, 4863, 158
6528, 4859, 4860, 4864, 4863
6529, 4860, 4861, 4865, 4864
6530, 4861, 4862, 4866, 4865
6531, 4862, 1100, 1101, 4866
6532, 158, 4863, 4867, 159
6533, 4863, 4864, 4868, 4867
6534, 4864, 4865, 4869, 4868
6535, 4865, 4866, 4870, 4869
6536, 4866, 1101, 1102, 4870
6537, 159, 4867, 4871, 160
6538, 4867, 4868, 4872, 4871
6539, 4868, 4869, 4873, 4872
6540, 4869, 4870, 4874, 4873
6541, 4870, 1102, 1103, 4874
6542, 160, 4871, 4875, 161
6543, 4871, 4872, 4876, 4875
6544, 4872, 4873, 4877, 4876
6545, 4873, 4874, 4878, 4877
6546, 4874, 1103, 1104, 4878
6547, 161, 4875, 4879, 162
6548, 4875, 4876, 4880, 4879
6549, 4876, 4877, 4881, 4880
6550, 4877, 4878, 4882, 4881
6551, 4878, 1104, 1105, 4882
6552, 162, 4879, 4883, 163
6553, 4879, 4880, 4884, 4883
6554, 4880, 4881, 4885, 4884
6555, 4881, 4882, 4886, 4885
6556, 4882, 1105, 1106, 4886
6557, 163, 4883, 4887, 164
6558, 4883, 4884, 4888, 4887
6559, 4884, 4885, 4889, 4888
6560, 4885, 4886, 4890, 4889
6561, 4886, 1106, 1107, 4890
6562, 164, 4887, 4891, 165
6563, 4887, 4888, 4892, 4891
6564, 4888, 4889, 4893, 4892
6565, 4889, 4890, 4894, 4893
6566, 4890, 1107, 1108, 4894
6567, 165, 4891, 4895, 166
6568, 4891, 4892, 4896, 4895
6569, 4892, 4893, 4897, 4896
6570, 4893, 4894, 4898, 4897
6571, 4894, 1108, 1109, 4898
6572, 166, 4895, 1082, 5
6573, 4895, 4896, 1083, 1082
6574, 4896, 4897, 1084, 1083
6575, 4897, 4898, 1085, 1084
6576, 4898, 1109, 87, 1085
*ELEMENT, type=CPS4, ELSET=Surface121
6577, 2, 1067, 4899, 97
6578, 1067, 1068, 4900, 4899
6579, 1068, 1069, 4901, 4900
6580, 1069, 1070, 4902, 4901
6581, 1070, 86, 1110, 4902
6582, 97, 4899, 4903, 98
6583, 4899, 4900, 4904, 4903
6584, 4900, 4901, 4905, 4904
6585, 4901, 4902, 4906, 4905
6586, 4902, 1110, 1111, 4906
6587, 98, 4903, 4907, 99
6588, 4903, 4904, 4908, 4907
6589, 4904, 4905, 4909, 4908
6590, 4905, 4906, 4910, 4909
6591, 4906, 1111, 1112, 4910
6592, 99, 4907, 4911, 100
6593, 4907, 4908, 4912, 4911
6594, 4908, 4909, 4913, 4912
6595, 4909, 4910, 4914, 4913
6596, 4910, 1112, 1113, 4914
6597, 100, 4911, 4915, 101
6598, 4911, 4912, 4916, 4915
6599, 4912, 4913, 4917, 4916
6600, 4913, 4914, 4918, 4917
6601, 4914, 1113, 1114, 4918
6602, 101, 4915, 4919, 102
6603, 4915, 4916, 4920, 4919
6604, 4916, 4917, 4921, 4920
6605, 4917, 4918, 4922, 4921
6606, 4918, 1114, 1115, 4922
6607, 102, 4919, 4923, 103
6608, 4919, 4920, 4924, 4923
6609, 4920, 4921, 4925, 4924
6610, 4921, 4922, 4926, 4925
6611, 4922, 1115, 1116, 4926
6612, 103, 4923, 4927, 104
6613, 4923, 4924, 4928, 4927
6614, 4924, 4925, 4929, 4928
6615, 4925, 4926, 4930, 4929
6616, 4926, 1116, 1117, 4930
6617, 104, 4927, 4931, 105
6618, 4927, 4928, 4932, 4931
6619, 4928, 4929, 4933, 4932
6620, 4929, 4930, 4934, 4933
6621, 4930, 1117, 1118, 4934
6622, 105, 4931, 1095, 1
6623, 4931, 4932, 1096, 1095
6624, 4932, 4933, 1097, 1096
6625, 4933, 4934, 1098, 1097
6626, 4934, 1118, 88, 1098
*ELEMENT, type=CPS4, ELSET=Surface122
6627, 86, 1071, 4935, 1110
6628, 1110, 4935, 4936, 1111
6629, 1111, 4936, 4937, 1112
6630, 1112, 4937, 4938, 1113
6631, 1113, 4938, 4939, 1114
6632, 1114, 4939, 4940, 1115
6633, 1115, 4940, 4941, 1116
6634, 1116, 4941, 4942, 1117
6635, 1117, 4942, 4943, 1118
6636, 1118, 4943, 1099, 88
6637, 1071, 1072, 4944, 4935
6638, 4935, 4944, 4945, 4936
6639, 4936, 4945, 4946, 4937
6640, 4937, 4946, 4947, 4938
6641, 4938, 4947, 4948, 4939
6642, 4939, 4948, 4949, 4940
6643, 4940, 4949, 4950, 4941
6644, 4941, 4950, 4951, 4942
6645, 4942, 4951, 4952, 4943
6646, 4943, 4952, 1100, 1099
6647, 1072, 1073, 4953, 4944
6648, 4944, 4953, 4954, 4945
6649, 4945, 4954, 4955, 4946
6650, 4946, 4955, 4956, 4947
6651, 4947, 4956, 4957, 4948
6652, 4948, 4957, 4958, 4949
6653, 4949, 4958, 4959, 4950
6654, 4950, 4959, 4960, 4951
6655, 4951, 4960, 4961, 4952
6656, 4952, 4961, 1101, 1100
6657, 1073, 1074, 4962, 4953
6658, 4953, 4962, 4963, 4954
6659, 4954, 4963, 4964, 4955
6660, 4955, 4964, 4965, 4956
6661, 4956, 4965, 4966, 4957
6662, 4957, 4966, 4967, 4958
6663, 4958, 4967, 4968, 4959
6664, 4959, 4968, 4969, 4960
6665, 4960, 4969, 4970, 4961
6666, 4961, 4970, 1102, 1101
6667, 1074, 1075, 4971, 4962
6668, 4962, 4971, 4972, 4963
6669, 4963, 4972, 4973, 4964
6670, 4964, 4973, 4974, 4965
6671, 4965, 4974, 4975, 4966
6672, 4966, 4975, 4976, 4967
6673, 4967, 4976, 4977, 4968
6674, 4968, 4977, 4978, 4969
6675, 4969, 4978, 4979, 4970
6676, 4970, 4979, 1103, 1102
6677, 1075, 1076, 4980, 4971
6678, 4971, 4980, 4981, 4972
6679, 4972, 4981, 4982, 4973
6680, 4973, 4982, 4983, 4974
6681, 4974, 4983, 4984, 4975
6682, 4975, 4984, 4985, 4976
6683, 4976, 4985, 4986, 4977
6684, 4977, 4986, 4987, 4978
6685, 4978, 4987, 4988, 4979
6686, 4979, 4988, 1104, 1103
6687, 1076, 1077, 4989, 4980
6688, 4980, 4989, 4990, 4981
6689, 4981, 4990, 4991, 4982
6690, 4982, 4991, 4992, 4983
6691, 4983, 4992, 4993, 4984
6692, 4984, 4993, 4994, 4985
6693, 4985, 4994, 4995, 4986
6694, 4986, 4995, 4996, 4987
6695, 4987, 4996, 4997, 4988
6696, 4988, 4997, 1105, 1104
6697, 1077, 1078, 4998, 4989
6698, 4989, 4998, 4999, 4990
6699, 4990, 4999, 5000, 4991
6700, 4991, 5000, 5001, 4992
6701, 4992, 5001, 5002, 4993
6702, 4993, 5002, 5003, 4994
6703, 4994, 5003, 5004, 4995
6704, 4995, 5004, 5005, 4996
6705, 4996, 5005, 5006, 4997
6706, 4997, 5006, 1106, 1105
6707, 1078, 1079, 5007, 4998
6708, 4998, 5007, 5008, 4999
6709, 4999, 5008, 5009, 5000
6710, 5000, 5009, 5010, 5001
6711, 5001, 5010, 5011, 5002
6712, 5002, 5011, 5012, 5003
6713, 5003, 5012, 5013, 5004
6714, 5004, 5013, 5014, 5005
6715, 5005, 5014, 5015, 5006
6716, 5006, 5015, 1107, 1106
6717, 1079, 1080, 5016, 5007
6718, 5007, 5016, 5017, 5008
6719, 5008, 5017, 5018, 5009
6720, 5009, 5018, 5019, 5010
6721, 5010, 5019, 5020, 5011
6722, 5011, 5020, 5021, 5012
6723, 5012, 5021, 5022, 5013
6724, 5013, 5022, 5023, 5014
6725, 5014, 5023, 5024, 5015
6726, 5015, 5024, 1108, 1107
6727, 1080, 1081, 5025, 5016
6728, 5016, 5025, 5026, 5017
6729, 5017, 5026, 5027, 5018
6730, 5018, 5027, 5028, 5019
6731, 5019, 5028, 5029, 5020
6732, 5020, 5029, 5030, 5021
6733, 5021, 5030, 5031, 5022
6734, 5022, 5031, 5032, 5023
6735, 5023, 5032, 5033, 5024
6736, 5024, 5033, 1109, 1108
6737, 1081, 85, 1086, 5025
6738, 5025, 1086, 1087, 5026
6739, 5026, 1087, 1088, 5027
6740, 5027, 1088, 1089, 5028
6741, 5028, 1089, 1090, 5029
6742, 5029, 1090, 1091, 5030
6743, 5030, 1091, 1092, 5031
6744, 5031, 1092, 1093, 5032
6745, 5032, 1093, 1094, 5033
6746, 5033, 1094, 87, 1109
*ELEMENT, type=CPS4, ELSET=Surface123
6747, 1, 53, 1119, 1095
6748, 1095, 1119, 1120, 1096
6749, 1096, 1120, 1121, 1097
6750, 1097, 1121, 1122, 1098
6751, 1098, 1122, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
6752, 2, 1067, 1123, 54
6753, 1067, 1068, 1124, 1123
6754, 1068, 1069, 1125, 1124
6755, 1069, 1070, 1126, 1125
6756, 1070, 86, 90, 1126
*ELEMENT, type=CPS4, ELSET=Surface125
6757, 54, 1123, 5034, 745
6758, 1123, 1124, 5035, 5034
6759, 1124, 1125, 5036, 5035
6760, 1125, 1126, 5037, 5036
6761, 1126, 90, 1127, 5037
6762, 745, 5034, 5038, 746
6763, 5034, 5035, 5039, 5038
6764, 5035, 5036, 5040, 5039
6765, 5036, 5037, 5041, 5040
6766, 5037, 1127, 1128, 5041
6767, 746, 5038, 5042, 747
6768, 5038, 5039, 5043, 5042
6769, 5039, 5040, 5044, 5043
6770, 5040, 5041, 5045, 5044
6771, 5041, 1128, 1129, 5045
6772, 747, 5042, 5046, 748
6773, 5042, 5043, 5047, 5046
6774, 5043, 5044, 5048, 5047
6775, 5044, 5045, 5049, 5048
6776, 5045, 1129, 1130, 5049
6777, 748, 5046, 5050, 749
6778, 5046, 5047, 5051, 5050
6779, 5047, 5048, 5052, 5051
6780, 5048, 5049, 5053, 5052
6781, 5049, 1130, 1131, 5053
6782, 749, 5050, 5054, 750
6783, 5050, 5051, 5055, 5054
6784, 5051, 5052, 5056, 5055
6785, 5052, 5053, 5057, 5056
6786, 5053, 1131, 1132, 5057
6787, 750, 5054, 5058, 751
6788, 5054, 5055, 5059, 5058
6789, 5055, 5056, 5060, 5059
6790, 5056, 5057, 5061, 5060
6791, 5057, 1132, 1133, 5061
6792, 751, 5058, 5062, 752
6793, 5058, 5059, 5063, 5062
6794, 5059, 5060, 5064, 5063
6795, 5060, 5061, 5065, 5064
6796, 5061, 1133, 1134, 5065
6797, 752, 5062, 5066, 753
6798, 5062, 5063, 5067, 5066
6799, 5063, 5064, 5068, 5067
6800, 5064, 5065, 5069, 5068
6801, 5065, 1134, 1135, 5069
6802, 753, 5066, 1119, 53
6803, 5066, 5067, 1120, 1119
6804, 5067, 5068, 1121, 1120
6805, 5068, 5069, 1122, 1121
6806, 5069, 1135, 89, 1122
*ELEMENT, type=CPS4, ELSET=Surface126
6807, 86, 1110, 1127, 90
6808, 1110, 1111, 1128, 1127
6809, 1111, 1112, 1129, 1128
6810, 1112, 1113, 1130, 1129
6811, 1113, 1114, 1131, 1130
6812, 1114, 1115, 1132, 1131
6813, 1115, 1116, 1133, 1132
6814, 1116, 1117, 1134, 1133
6815, 1117, 1118, 1135, 1134
6816, 1118, 88, 89, 1135
*ELEMENT, type=CPS4, ELSET=Surface127
6817, 45, 1136, 5070, 675
6818, 1136, 1137, 5071, 5070
6819, 1137, 1138, 5072, 5071
6820, 1138, 1139, 5073, 5072
6821, 1139, 91, 1144, 5073
6822, 675, 5070, 5074, 676
6823, 5070, 5071, 5075, 5074
6824, 5071, 5072, 5076, 5075
6825, 5072, 5073, 5077, 5076
6826, 5073, 1144, 1145, 5077
6827, 676, 5074, 5078, 677
6828, 5074, 5075, 5079, 5078
6829, 5075, 5076, 5080, 5079
6830, 5076, 5077, 5081, 5080
6831, 5077, 1145, 1146, 5081
6832, 677, 5078, 5082, 678
6833, 5078, 5079, 5083, 5082
6834, 5079, 5080, 5084, 5083
6835, 5080, 5081, 5085, 5084
6836, 5081, 1146, 1147, 5085
6837, 678, 5082, 5086, 679
6838, 5082, 5083, 5087, 5086
6839, 5083, 5084, 5088, 5087
6840, 5084, 5085, 5089, 5088
6841, 5085, 1147, 1148, 5089
6842, 679, 5086, 5090, 680
6843, 5086, 5087, 5091, 5090
6844, 5087, 5088, 5092, 5091
6845, 5088, 5089, 5093, 5092
6846, 5089, 1148, 1149, 5093
6847, 680, 5090, 5094, 681
6848, 5090, 5091, 5095, 5094
6849, 5091, 5092, 5096, 5095
6850, 5092, 5093, 5097, 5096
6851, 5093, 1149, 1150, 5097
6852, 681, 5094, 5098, 682
6853, 5094, 5095, 5099, 5098
6854, 5095, 5096, 5100, 5099
6855, 5096, 5097, 5101, 5100
6856, 5097, 1150, 1151, 5101
6857, 682, 5098, 5102, 683
6858, 5098, 5099, 5103, 5102
6859, 5099, 5100, 5104, 5103
6860, 5100, 5101, 5105, 5104
6861, 5101, 1151, 1152, 5105
6862, 683, 5102, 5106, 684
6863, 5102, 5103, 5107, 5106
6864, 5103, 5104, 5108, 5107
6865, 5104, 5105, 5109, 5108
6866, 5105, 1152, 1153, 5109
6867, 684, 5106, 5110, 685
6868, 5106, 5107, 5111, 5110
6869, 5107, 5108, 5112, 5111
6870, 5108, 5109, 5113, 5112
6871, 5109, 1153, 1154, 5113
6872, 685, 5110, 1140, 46
6873, 5110, 5111, 1141, 1140
6874, 5111, 5112, 1142, 1141
6875, 5112, 5113, 1143, 1142
6876, 5113, 1154, 92, 1143
*ELEMENT, type=CPS4, ELSET=Surface128
6877, 47, 692, 5114, 1155
6878, 1155, 5114, 5115, 1156
6879, 1156, 5115, 5116, 1157
6880, 1157, 5116, 5117, 1158
6881, 1158, 5117, 1163, 93
6882, 692, 693, 5118, 5114
6883, 5114, 5118, 5119, 5115
6884, 5115, 5119, 5120, 5116
6885, 5116, 5120, 5121, 5117
6886, 5117, 5121, 1164, 1163
6887, 693, 694, 5122, 5118
6888, 5118, 5122, 5123, 5119
6889, 5119, 5123, 5124, 5120
6890, 5120, 5124, 5125, 5121
6891, 5121, 5125, 1165, 1164
6892, 694, 695, 5126, 5122
6893, 5122, 5126, 5127, 5123
6894, 5123, 5127, 5128, 5124
6895, 5124, 5128, 5129, 5125
6896, 5125, 5129, 1166, 1165
6897, 695, 696, 5130, 5126
6898, 5126, 5130, 5131, 5127
6899, 5127, 5131, 5132, 5128
6900, 5128, 5132, 5133, 5129
6901, 5129, 5133, 1167, 1166
6902, 696, 697, 5134, 5130
6903, 5130, 5134, 5135, 5131
6904, 5131, 5135, 5136, 5132
6905, 5132, 5136, 5137, 5133
6906, 5133, 5137, 1168, 1167
6907, 697, 698, 5138, 5134
6908, 5134, 5138, 5139, 5135
6909, 5135, 5139, 5140, 5136
6910, 5136, 5140, 5141, 5137
6911, 5137, 5141, 1169, 1168
6912, 698, 699, 5142, 5138
6913, 5138, 5142, 5143, 5139
6914, 5139, 5143, 5144, 5140
6915, 5140, 5144, 5145, 5141
6916, 5141, 5145, 1170, 1169
6917, 699, 700, 5146, 5142
6918, 5142, 5146, 5147, 5143
6919, 5143, 5147, 5148, 5144
6920, 5144, 5148, 5149, 5145
6921, 5145, 5149, 1171, 1170
6922, 700, 701, 5150, 5146
6923, 5146, 5150, 5151, 5147
6924, 5147, 5151, 5152, 5148
6925, 5148, 5152, 5153, 5149
6926, 5149, 5153, 1172, 1171
6927, 701, 702, 5154, 5150
6928, 5150, 5154, 5155, 5151
6929, 5151, 5155, 5156, 5152
6930, 5152, 5156, 5157, 5153
6931, 5153, 5157, 1173, 1172
6932, 702, 48, 1159, 5154
6933, 5154, 1159, 1160, 5155
6934, 5155, 1160, 1161, 5156
6935, 5156, 1161, 1162, 5157
6936, 5157, 1162, 94, 1173
*ELEMENT, type=CPS4, ELSET=Surface129
6937, 47, 1155, 5158, 703
6938, 1155, 1156, 5159, 5158
6939, 1156, 1157, 5160, 5159
6940, 1157, 1158, 5161, 5160
6941, 1158, 93, 1174, 5161
6942, 703, 5158, 5162, 704
6943, 5158, 5159, 5163, 5162
6944, 5159, 5160, 5164, 5163
6945, 5160, 5161, 5165, 5164
6946, 5161, 1174, 1175, 5165
6947, 704, 5162, 5166, 705
6948, 5162, 5163, 5167, 5166
6949, 5163, 5164, 5168, 5167
6950, 5164, 5165, 5169, 5168
6951, 5165, 1175, 1176, 5169
6952, 705, 5166, 5170, 706
6953, 5166, 5167, 5171, 5170
6954, 5167, 5168, 5172, 5171
6955, 5168, 5169, 5173, 5172
6956, 5169, 1176, 1177, 5173
6957, 706, 5170, 5174, 707
6958, 5170, 5171, 5175, 5174
6959, 5171, 5172, 5176, 5175
6960, 5172, 5173, 5177, 5176
6961, 5173, 1177, 1178, 5177
6962, 707, 5174, 5178, 708
6963, 5174, 5175, 5179, 5178
6964, 5175, 5176, 5180, 5179
6965, 5176, 5177, 5181, 5180
6966, 5177, 1178, 1179, 5181
6967, 708, 5178, 5182, 709
6968, 5178, 5179, 5183, 5182
6969, 5179, 5180, 5184, 5183
6970, 5180, 5181, 5185, 5184
6971, 5181, 1179, 1180, 5185
6972, 709, 5182, 5186, 710
6973, 5182, 5183, 5187, 5186
6974, 5183, 5184, 5188, 5187
6975, 5184, 5185, 5189, 5188
6976, 5185, 1180, 1181, 5189
6977, 710, 5186, 5190, 711
6978, 5186, 5187, 5191, 5190
6979, 5187, 5188, 5192, 5191
6980, 5188, 5189, 5193, 5192
6981, 5189, 1181, 1182, 5193
6982, 711, 5190, 1136, 45
6983, 5190, 5191, 1137, 1136
6984, 5191, 5192, 1138, 1137
6985, 5192, 5193, 1139, 1138
6986, 5193, 1182, 91, 1139
*ELEMENT, type=CPS4, ELSET=Surface130
6987, 48, 712, 5194, 1159
6988, 1159, 5194, 5195, 1160
6989, 1160, 5195, 5196, 1161
6990, 1161, 5196, 5197, 1162
6991, 1162, 5197, 1183, 94
6992, 712, 713, 5198, 5194
6993, 5194, 5198, 5199, 5195
6994, 5195, 5199, 5200, 5196
6995, 5196, 5200, 5201, 5197
6996, 5197, 5201, 1184, 1183
6997, 713, 714, 5202, 5198
6998, 5198, 5202, 5203, 5199
6999, 5199, 5203, 5204, 5200
7000, 5200, 5204, 5205, 5201
7001, 5201, 5205, 1185, 1184
7002, 714, 715, 5206, 5202
7003, 5202, 5206, 5207, 5203
7004, 5203, 5207, 5208, 5204
7005, 5204, 5208, 5209, 5205
7006, 5205, 5209, 1186, 1185
7007, 715, 716, 5210, 5206
7008, 5206, 5210, 5211, 5207
7009, 5207, 5211, 5212, 5208
7010, 5208, 5212, 5213, 5209
7011, 5209, 5213, 1187, 1186
7012, 716, 717, 5214, 5210
7013, 5210, 5214, 5215, 5211
7014, 5211, 5215, 5216, 5212
7015, 5212, 5216, 5217, 5213
7016, 5213, 5217, 1188, 1187
7017, 717, 718, 5218, 5214
7018, 5214, 5218, 5219, 5215
7019, 5215, 5219, 5220, 5216
7020, 5216, 5220, 5221, 5217
7021, 5217, 5221, 1189, 1188
7022, 718, 719, 5222, 5218
7023, 5218, 5222, 5223, 5219
7024, 5219, 5223, 5224, 5220
7025, 5220, 5224, 5225, 5221
7026, 5221, 5225, 1190, 1189
7027, 719, 720, 5226, 5222
7028, 5222, 5226, 5227, 5223
7029, 5223, 5227, 5228, 5224
7030, 5224, 5228, 5229, 5225
7031, 5225, 5229, 1191, 1190
7032, 720, 46, 1140, 5226
7033, 5226, 1140, 1141, 5227
7034, 5227, 1141, 1142, 5228
7035, 5228, 1142, 1143, 5229
7036, 5229, 1143, 92, 1191
*ELEMENT, type=CPS4, ELSET=Surface131
7037, 93, 1163, 5230, 1174
7038, 1163, 1164, 5231, 5230
7039, 1164, 1165, 5232, 5231
7040, 1165, 1166, 5233, 5232
7041, 1166, 1167, 5234, 5233
7042, 1167, 1168, 5235, 5234
7043, 1168, 1169, 5236, 5235
7044, 1169, 1170, 5237, 5236
7045, 1170, 1171, 5238, 5237
7046, 1171, 1172, 5239, 5238
7047, 1172, 1173, 5240, 5239
7048, 1173, 94, 1183, 5240
7049, 1174, 5230, 5241, 1175
7050, 5230, 5231, 5242, 5241
7051, 5231, 5232, 5243, 5242
7052, 5232, 5233, 5244, 5243
7053, 5233, 5234, 5245, 5244
7054, 5234, 5235, 5246, 5245
7055, 5235, 5236, 5247, 5246
7056, 5236, 5237, 5248, 5247
7057, 5237, 5238, 5249, 5248
7058, 5238, 5239, 5250, 5249
7059, 5239, 5240, 5251, 5250
7060, 5240, 1183, 1184, 5251
7061, 1175, 5241, 5252, 1176
7062, 5241, 5242, 5253, 5252
7063, 5242, 5243, 5254, 5253
7064, 5243, 5244, 5255, 5254
7065, 5244, 5245, 5256, 5255
7066, 5245, 5246, 5257, 5256
7067, 5246, 5247, 5258, 5257
7068, 5247, 5248, 5259, 5258
7069, 5248, 5249, 5260, 5259
7070, 5249, 5250, 5261, 5260
7071, 5250, 5251, 5262, 5261
7072, 5251, 1184, 1185, 5262
7073, 1176, 5252, 5263, 1177
7074, 5252, 5253, 5264, 5263
7075, 5253, 5254, 5265, 5264
7076, 5254, 5255, 5266, 5265
7077, 5255, 5256, 5267, 5266
7078, 5256, 5257, 5268, 5267
7079, 5257, 5258, 5269, 5268
7080, 5258, 5259, 5270, 5269
7081, 5259, 5260, 5271, 5270
7082, 5260, 5261, 5272, 5271
7083, 5261, 5262, 5273, 5272
7084, 5262, 1185, 1186, 5273
7085, 1177, 5263, 5274, 1178
7086, 5263, 5264, 5275, 5274
7087, 5264, 5265, 5276, 5275
7088, 5265, 5266, 5277, 5276
7089, 5266, 5267, 5278, 5277
7090, 5267, 5268, 5279, 5278
7091, 5268, 5269, 5280, 5279
7092, 5269, 5270, 5281, 5280
7093, 5270, 5271, 5282, 5281
7094, 5271, 5272, 5283, 5282
7095, 5272, 5273, 5284, 5283
7096, 5273, 1186, 1187, 5284
7097, 1178, 5274, 5285, 1179
7098, 5274, 5275, 5286, 5285
7099, 5275, 5276, 5287, 5286
7100, 5276, 5277, 5288, 5287
7101, 5277, 5278, 5289, 5288
7102, 5278, 5279, 5290, 5289
7103, 5279, 5280, 5291, 5290
7104, 5280, 5281, 5292, 5291
7105, 5281, 5282, 5293, 5292
7106, 5282, 5283, 5294, 5293
7107, 5283, 5284, 5295, 5294
7108, 5284, 1187, 1188, 5295
7109, 1179, 5285, 5296, 1180
7110, 5285, 5286, 5297, 5296
7111, 5286, 5287, 5298, 5297
7112, 5287, 5288, 5299, 5298
7113, 5288, 5289, 5300, 5299
7114, 5289, 5290, 5301, 5300
7115, 5290, 5291, 5302, 5301
7116, 5291, 5292, 5303, 5302
7117, 5292, 5293, 5304, 5303
7118, 5293, 5294, 5305, 5304
7119, 5294, 5295, 5306, 5305
7120, 5295, 1188, 1189, 5306
7121, 1180, 5296, 5307, 1181
7122, 5296, 5297, 5308, 5307
7123, 5297, 5298, 5309, 5308
7124, 5298, 5299, 5310, 5309
7125, 5299, 5300, 5311, 5310
7126, 5300, 5301, 5312, 5311
7127, 5301, 5302, 5313, 5312
7128, 5302, 5303, 5314, 5313
7129, 5303, 5304, 5315, 5314
7130, 5304, 5305, 5316, 5315
7131, 5305, 5306, 5317, 5316
7132, 5306, 1189, 1190, 5317
7133, 1181, 5307, 5318, 1182
7134, 5307, 5308, 5319, 5318
7135, 5308, 5309, 5320, 5319
7136, 5309, 5310, 5321, 5320
7137, 5310, 5311, 5322, 5321
7138, 5311, 5312, 5323, 5322
7139, 5312, 5313, 5324, 5323
7140, 5313, 5314, 5325, 5324
7141, 5314, 5315, 5326, 5325
7142, 5315, 5316, 5327, 5326
7143, 5316, 5317, 5328, 5327
7144, 5317, 1190, 1191, 5328
7145, 1182, 5318, 1144, 91
7146, 5318, 5319, 1145, 1144
7147, 5319, 5320, 1146, 1145
7148, 5320, 5321, 1147, 1146
7149, 5321, 5322, 1148, 1147
7150, 5322, 5323, 1149, 1148
7151, 5323, 5324, 1150, 1149
7152, 5324, 5325, 1151, 1150
7153, 5325, 5326, 1152, 1151
7154, 5326, 5327, 1153, 1152
7155, 5327, 5328, 1154, 1153
7156, 5328, 1191, 92, 1154
*ELEMENT, type=CPS4, ELSET=Surface132
7157, 46, 1140, 1192, 50
7158, 1140, 1141, 1193, 1192
7159, 1141, 1142, 1194, 1193
7160, 1142, 1143, 1195, 1194
7161, 1143, 92, 95, 1195
*ELEMENT, type=CPS4, ELSET=Surface133
7162, 48, 52, 1196, 1159
7163, 1159, 1196, 1197, 1160
7164, 1160, 1197, 1198, 1161
7165, 1161, 1198, 1199, 1162
7166, 1162, 1199, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
7167, 52, 736, 5329, 1196
7168, 1196, 5329, 5330, 1197
7169, 1197, 5330, 5331, 1198
7170, 1198, 5331, 5332, 1199
7171, 1199, 5332, 1200, 96
7172, 736, 737, 5333, 5329
7173, 5329, 5333, 5334, 5330
7174, 5330, 5334, 5335, 5331
7175, 5331, 5335, 5336, 5332
7176, 5332, 5336, 1201, 1200
7177, 737, 738, 5337, 5333
7178, 5333, 5337, 5338, 5334
7179, 5334, 5338, 5339, 5335
7180, 5335, 5339, 5340, 5336
7181, 5336, 5340, 1202, 1201
7182, 738, 739, 5341, 5337
7183, 5337, 5341, 5342, 5338
7184, 5338, 5342, 5343, 5339
7185, 5339, 5343, 5344, 5340
7186, 5340, 5344, 1203, 1202
7187, 739, 740, 5345, 5341
7188, 5341, 5345, 5346, 5342
7189, 5342, 5346, 5347, 5343
7190, 5343, 5347, 5348, 5344
7191, 5344, 5348, 1204, 1203
7192, 740, 741, 5349, 5345
7193, 5345, 5349, 5350, 5346
7194, 5346, 5350, 5351, 5347
7195, 5347, 5351, 5352, 5348
7196, 5348, 5352, 1205, 1204
7197, 741, 742, 5353, 5349
7198, 5349, 5353, 5354, 5350
7199, 5350, 5354, 5355, 5351
7200, 5351, 5355, 5356, 5352
7201, 5352, 5356, 1206, 1205
7202, 742, 743, 5357, 5353
7203, 5353, 5357, 5358, 5354
7204, 5354, 5358, 5359, 5355
7205, 5355, 5359, 5360, 5356
7206, 5356, 5360, 1207, 1206
7207, 743, 744, 5361, 5357
7208, 5357, 5361, 5362, 5358
7209, 5358, 5362, 5363, 5359
7210, 5359, 5363, 5364, 5360
7211, 5360, 5364, 1208, 1207
7212, 744, 50, 1192, 5361
7213, 5361, 1192, 1193, 5362
7214, 5362, 1193, 1194, 5363
7215, 5363, 1194, 1195, 5364
7216, 5364, 1195, 95, 1208
*ELEMENT, type=CPS4, ELSET=Surface135
7217, 94, 96, 1200, 1183
7218, 1183, 1200, 1201, 1184
7219, 1184, 1201, 1202, 1185
7220, 1185, 1202, 1203, 1186
7221, 1186, 1203, 1204, 1187
7222, 1187, 1204, 1205, 1188
7223, 1188, 1205, 1206, 1189
7224, 1189, 1206, 1207, 1190
7225, 1190, 1207, 1208, 1191
7226, 1191, 1208, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
7227, 1209, 97, 2, 118, 5365, 1263, 145, 1461
7228, 5365, 1263, 145, 1461, 5366, 1272, 146, 1462
7229, 5366, 1272, 146, 1462, 5367, 1281, 147, 1463
7230, 5367, 1281, 147, 1463, 5368, 1290, 148, 1464
7231, 5368, 1290, 148, 1464, 5369, 1299, 149, 1465
7232, 5369, 1299, 149, 1465, 5370, 1308, 150, 1466
7233, 5370, 1308, 150, 1466, 5371, 1317, 151, 1467
7234, 5371, 1317, 151, 1467, 5372, 1326, 152, 1468
7235, 5372, 1326, 152, 1468, 5373, 1335, 153, 1469
7236, 5373, 1335, 153, 1469, 5374, 1344, 154, 1470
7237, 5374, 1344, 154, 1470, 5375, 1353, 155, 1471
7238, 5375, 1353, 155, 1471, 1236, 121, 6, 142
7239, 1210, 1209, 118, 119, 5376, 5365, 1461, 1472
7240, 5376, 5365, 1461, 1472, 5377, 5366, 1462, 1473
7241, 5377, 5366, 1462, 1473, 5378, 5367, 1463, 1474
7242, 5378, 5367, 1463, 1474, 5379, 5368, 1464, 1475
7243, 5379, 5368, 1464, 1475, 5380, 5369, 1465, 1476
7244, 5380, 5369, 1465, 1476, 5381, 5370, 1466, 1477
7245, 5381, 5370, 1466, 1477, 5382, 5371, 1467, 1478
7246, 5382, 5371, 1467, 1478, 5383, 5372, 1468, 1479
7247, 5383, 5372, 1468, 1479, 5384, 5373, 1469, 1480
7248, 5384, 5373, 1469, 1480, 5385, 5374, 1470, 1481
7249, 5385, 5374, 1470, 1481, 5386, 5375, 1471, 1482
7250, 5386, 5375, 1471, 1482, 1237, 1236, 142, 143
7251, 1211, 1210, 119, 120, 5387, 5376, 1472, 1483
7252, 5387, 5376, 1472, 1483, 5388, 5377, 1473, 1484
7253, 5388, 5377, 1473, 1484, 5389, 5378, 1474, 1485
7254, 5389, 5378, 1474, 1485, 5390, 5379, 1475, 1486
7255, 5390, 5379, 1475, 1486, 5391, 5380, 1476, 1487
7256, 5391, 5380, 1476, 1487, 5392, 5381, 1477, 1488
7257, 5392, 5381, 1477, 1488, 5393, 5382, 1478, 1489
7258, 5393, 5382, 1478, 1489, 5394, 5383, 1479, 1490
7259, 5394, 5383, 1479, 1490, 5395, 5384, 1480, 1491
7260, 5395, 5384, 1480, 1491, 5396, 5385, 1481, 1492
7261, 5396, 5385, 1481, 1492, 5397, 5386, 1482, 1493
7262, 5397, 5386, 1482, 1493, 1238, 1237, 143, 144
7263, 109, 1211, 120, 4, 1362, 5387, 1483, 167
7264, 1362, 5387, 1483, 167, 1371, 5388, 1484, 168
7265, 1371, 5388, 1484, 168, 1380, 5389, 1485, 169
7266, 1380, 5389, 1485, 169, 1389, 5390, 1486, 170
7267, 1389, 5390, 1486, 170, 1398, 5391, 1487, 171
7268, 1398, 5391, 1487, 171, 1407, 5392, 1488, 172
7269, 1407, 5392, 1488, 172, 1416, 5393, 1489, 173
7270, 1416, 5393, 1489, 173, 1425, 5394, 1490, 174
7271, 1425, 5394, 1490, 174, 1434, 5395, 1491, 175
7272, 1434, 5395, 1491, 175, 1443, 5396, 1492, 176
7273, 1443, 5396, 1492, 176, 1452, 5397, 1493, 177
7274, 1452, 5397, 1493, 177, 133, 1238, 144, 8
7275, 1212, 98, 97, 1209, 5398, 1264, 1263, 5365
7276, 5398, 1264, 1263, 5365, 5399, 1273, 1272, 5366
7277, 5399, 1273, 1272, 5366, 5400, 1282, 1281, 5367
7278, 5400, 1282, 1281, 5367, 5401, 1291, 1290, 5368
7279, 5401, 1291, 1290, 5368, 5402, 1300, 1299, 5369
7280, 5402, 1300, 1299, 5369, 5403, 1309, 1308, 5370
7281, 5403, 1309, 1308, 5370, 5404, 1318, 1317, 5371
7282, 5404, 1318, 1317, 5371, 5405, 1327, 1326, 5372
7283, 5405, 1327, 1326, 5372, 5406, 1336, 1335, 5373
7284, 5406, 1336, 1335, 5373, 5407, 1345, 1344, 5374
7285, 5407, 1345, 1344, 5374, 5408, 1354, 1353, 5375
7286, 5408, 1354, 1353, 5375, 1239, 122, 121, 1236
7287, 1213, 1212, 1209, 1210, 5409, 5398, 5365, 5376
7288, 5409, 5398, 5365, 5376, 5410, 5399, 5366, 5377
7289, 5410, 5399, 5366, 5377, 5411, 5400, 5367, 5378
7290, 5411, 5400, 5367, 5378, 5412, 5401, 5368, 5379
7291, 5412, 5401, 5368, 5379, 5413, 5402, 5369, 5380
7292, 5413, 5402, 5369, 5380, 5414, 5403, 5370, 5381
7293, 5414, 5403, 5370, 5381, 5415, 5404, 5371, 5382
7294, 5415, 5404, 5371, 5382, 5416, 5405, 5372, 5383
7295, 5416, 5405, 5372, 5383, 5417, 5406, 5373, 5384
7296, 5417, 5406, 5373, 5384, 5418, 5407, 5374, 5385
7297, 5418, 5407, 5374, 5385, 5419, 5408, 5375, 5386
7298, 5419, 5408, 5375, 5386, 1240, 1239, 1236, 1237
7299, 1214, 1213, 1210, 1211, 5420, 5409, 5376, 5387
7300, 5420, 5409, 5376, 5387, 5421, 5410, 5377, 5388
7301, 5421, 5410, 5377, 5388, 5422, 5411, 5378, 5389
7302, 5422, 5411, 5378, 5389, 5423, 5412, 5379, 5390
7303, 5423, 5412, 5379, 5390, 5424, 5413, 5380, 5391
7304, 5424, 5413, 5380, 5391, 5425, 5414, 5381, 5392
7305, 5425, 5414, 5381, 5392, 5426, 5415, 5382, 5393
7306, 5426, 5415, 5382, 5393, 5427, 5416, 5383, 5394
7307, 5427, 5416, 5383, 5394, 5428, 5417, 5384, 5395
7308, 5428, 5417, 5384, 5395, 5429, 5418, 5385, 5396
7309, 5429, 5418, 5385, 5396, 5430, 5419, 5386, 5397
7310, 5430, 5419, 5386, 5397, 1241, 1240, 1237, 1238
7311, 110, 1214, 1211, 109, 1363, 5420, 5387, 1362
7312, 1363, 5420, 5387, 1362, 1372, 5421, 5388, 1371
7313, 1372, 5421, 5388, 1371, 1381, 5422, 5389, 1380
7314, 1381, 5422, 5389, 1380, 1390, 5423, 5390, 1389
7315, 1390, 5423, 5390, 1389, 1399, 5424, 5391, 1398
7316, 1399, 5424, 5391, 1398, 1408, 5425, 5392, 1407
7317, 1408, 5425, 5392, 1407, 1417, 5426, 5393, 1416
7318, 1417, 5426, 5393, 1416, 1426, 5427, 5394, 1425
7319, 1426, 5427, 5394, 1425, 1435, 5428, 5395, 1434
7320, 1435, 5428, 5395, 1434, 1444, 5429, 5396, 1443
7321, 1444, 5429, 5396, 1443, 1453, 5430, 5397, 1452
7322, 1453, 5430, 5397, 1452, 134, 1241, 1238, 133
