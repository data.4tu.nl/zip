*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_12x10x10el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 1, 1.6, 0
78, 0, 1.6, 0
79, 1, 1.6, 0.5
80, 0, 1.6, 0.5
81, 1.2, 1.6, 0.5
82, 1.2, 1.6, 0
83, 2.2, 1.6, 0.5
84, 2.2, 1.6, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.05
98, 0, 0, 0.1
99, 0, 0, 0.15
100, 0, 0, 0.2
101, 0, 0, 0.25
102, 0, 0, 0.3
103, 0, 0, 0.35
104, 0, 0, 0.4
105, 0, 0, 0.45
106, 0, 0.0125, 0.5
107, 0, 0.025, 0.5
108, 0, 0.0375, 0.5
109, 0, 0.05, 0.05
110, 0, 0.05, 0.1
111, 0, 0.05, 0.15
112, 0, 0.05, 0.2
113, 0, 0.05, 0.25
114, 0, 0.05, 0.3
115, 0, 0.05, 0.35
116, 0, 0.05, 0.4
117, 0, 0.05, 0.45
118, 0, 0.0125, 0
119, 0, 0.025, 0
120, 0, 0.0375, 0
121, 1, 0, 0.05
122, 1, 0, 0.1
123, 1, 0, 0.15
124, 1, 0, 0.2
125, 1, 0, 0.25
126, 1, 0, 0.3
127, 1, 0, 0.35
128, 1, 0, 0.4
129, 1, 0, 0.45
130, 1, 0.0125, 0.5
131, 1, 0.025, 0.5
132, 1, 0.0375, 0.5
133, 1, 0.05, 0.05
134, 1, 0.05, 0.1
135, 1, 0.05, 0.15
136, 1, 0.05, 0.2
137, 1, 0.05, 0.25
138, 1, 0.05, 0.3
139, 1, 0.05, 0.35
140, 1, 0.05, 0.4
141, 1, 0.05, 0.45
142, 1, 0.0125, 0
143, 1, 0.025, 0
144, 1, 0.0375, 0
145, 0.083333333333333, 0, 0
146, 0.16666666666667, 0, 0
147, 0.25, 0, 0
148, 0.33333333333333, 0, 0
149, 0.41666666666667, 0, 0
150, 0.5, 0, 0
151, 0.58333333333333, 0, 0
152, 0.66666666666667, 0, 0
153, 0.75, 0, 0
154, 0.83333333333333, 0, 0
155, 0.91666666666667, 0, 0
156, 0.083333333333333, 0, 0.5
157, 0.16666666666667, 0, 0.5
158, 0.25, 0, 0.5
159, 0.33333333333333, 0, 0.5
160, 0.41666666666667, 0, 0.5
161, 0.5, 0, 0.5
162, 0.58333333333333, 0, 0.5
163, 0.66666666666667, 0, 0.5
164, 0.75, 0, 0.5
165, 0.83333333333333, 0, 0.5
166, 0.91666666666667, 0, 0.5
167, 0.083333333333333, 0.05, 0
168, 0.16666666666667, 0.05, 0
169, 0.25, 0.05, 0
170, 0.33333333333333, 0.05, 0
171, 0.41666666666667, 0.05, 0
172, 0.5, 0.05, 0
173, 0.58333333333333, 0.05, 0
174, 0.66666666666667, 0.05, 0
175, 0.75, 0.05, 0
176, 0.83333333333333, 0.05, 0
177, 0.91666666666667, 0.05, 0
178, 0.083333333333333, 0.05, 0.5
179, 0.16666666666667, 0.05, 0.5
180, 0.25, 0.05, 0.5
181, 0.33333333333333, 0.05, 0.5
182, 0.41666666666667, 0.05, 0.5
183, 0.5, 0.05, 0.5
184, 0.58333333333333, 0.05, 0.5
185, 0.66666666666667, 0.05, 0.5
186, 0.75, 0.05, 0.5
187, 0.83333333333333, 0.05, 0.5
188, 0.91666666666667, 0.05, 0.5
189, 0.083333333333333, 0.1, 0
190, 0.16666666666667, 0.1, 0
191, 0.25, 0.1, 0
192, 0.33333333333333, 0.1, 0
193, 0.41666666666667, 0.1, 0
194, 0.5, 0.1, 0
195, 0.58333333333333, 0.1, 0
196, 0.66666666666667, 0.1, 0
197, 0.75, 0.1, 0
198, 0.83333333333333, 0.1, 0
199, 0.91666666666667, 0.1, 0
200, 1, 0.1, 0.05
201, 1, 0.1, 0.1
202, 1, 0.1, 0.15
203, 1, 0.1, 0.2
204, 1, 0.1, 0.25
205, 1, 0.1, 0.3
206, 1, 0.1, 0.35
207, 1, 0.1, 0.4
208, 1, 0.1, 0.45
209, 0.083333333333333, 0.1, 0.5
210, 0.16666666666667, 0.1, 0.5
211, 0.25, 0.1, 0.5
212, 0.33333333333333, 0.1, 0.5
213, 0.41666666666667, 0.1, 0.5
214, 0.5, 0.1, 0.5
215, 0.58333333333333, 0.1, 0.5
216, 0.66666666666667, 0.1, 0.5
217, 0.75, 0.1, 0.5
218, 0.83333333333333, 0.1, 0.5
219, 0.91666666666667, 0.1, 0.5
220, 0, 0.1, 0.05
221, 0, 0.1, 0.1
222, 0, 0.1, 0.15
223, 0, 0.1, 0.2
224, 0, 0.1, 0.25
225, 0, 0.1, 0.3
226, 0, 0.1, 0.35
227, 0, 0.1, 0.4
228, 0, 0.1, 0.45
229, 1, 0.22, 0
230, 1, 0.34, 0
231, 1, 0.46, 0
232, 1, 0.58, 0
233, 1, 0.7, 0
234, 1, 0.82, 0
235, 1, 0.94, 0
236, 1, 1.06, 0
237, 1, 1.18, 0
238, 0, 0.22, 0
239, 0, 0.34, 0
240, 0, 0.46, 0
241, 0, 0.58, 0
242, 0, 0.7, 0
243, 0, 0.82, 0
244, 0, 0.94, 0
245, 0, 1.06, 0
246, 0, 1.18, 0
247, 0.083333333333333, 1.3, 0
248, 0.16666666666667, 1.3, 0
249, 0.25, 1.3, 0
250, 0.33333333333333, 1.3, 0
251, 0.41666666666667, 1.3, 0
252, 0.5, 1.3, 0
253, 0.58333333333333, 1.3, 0
254, 0.66666666666667, 1.3, 0
255, 0.75, 1.3, 0
256, 0.83333333333333, 1.3, 0
257, 0.91666666666667, 1.3, 0
258, 1, 0.22, 0.5
259, 1, 0.34, 0.5
260, 1, 0.46, 0.5
261, 1, 0.58, 0.5
262, 1, 0.7, 0.5
263, 1, 0.82, 0.5
264, 1, 0.94, 0.5
265, 1, 1.06, 0.5
266, 1, 1.18, 0.5
267, 1, 1.3, 0.05
268, 1, 1.3, 0.1
269, 1, 1.3, 0.15
270, 1, 1.3, 0.2
271, 1, 1.3, 0.25
272, 1, 1.3, 0.3
273, 1, 1.3, 0.35
274, 1, 1.3, 0.4
275, 1, 1.3, 0.45
276, 0, 0.22, 0.5
277, 0, 0.34, 0.5
278, 0, 0.46, 0.5
279, 0, 0.58, 0.5
280, 0, 0.7, 0.5
281, 0, 0.82, 0.5
282, 0, 0.94, 0.5
283, 0, 1.06, 0.5
284, 0, 1.18, 0.5
285, 0.083333333333333, 1.3, 0.5
286, 0.16666666666667, 1.3, 0.5
287, 0.25, 1.3, 0.5
288, 0.33333333333333, 1.3, 0.5
289, 0.41666666666667, 1.3, 0.5
290, 0.5, 1.3, 0.5
291, 0.58333333333333, 1.3, 0.5
292, 0.66666666666667, 1.3, 0.5
293, 0.75, 1.3, 0.5
294, 0.83333333333333, 1.3, 0.5
295, 0.91666666666667, 1.3, 0.5
296, 0, 1.3, 0.05
297, 0, 1.3, 0.1
298, 0, 1.3, 0.15
299, 0, 1.3, 0.2
300, 0, 1.3, 0.25
301, 0, 1.3, 0.3
302, 0, 1.3, 0.35
303, 0, 1.3, 0.4
304, 0, 1.3, 0.45
305, 0.083333333333333, 1.35, 0
306, 0.16666666666667, 1.35, 0
307, 0.25, 1.35, 0
308, 0.33333333333333, 1.35, 0
309, 0.41666666666667, 1.35, 0
310, 0.5, 1.35, 0
311, 0.58333333333333, 1.35, 0
312, 0.66666666666667, 1.35, 0
313, 0.75, 1.35, 0
314, 0.83333333333333, 1.35, 0
315, 0.91666666666667, 1.35, 0
316, 1, 1.35, 0.05
317, 1, 1.35, 0.1
318, 1, 1.35, 0.15
319, 1, 1.35, 0.2
320, 1, 1.35, 0.25
321, 1, 1.35, 0.3
322, 1, 1.35, 0.35
323, 1, 1.35, 0.4
324, 1, 1.35, 0.45
325, 0.083333333333333, 1.35, 0.5
326, 0.16666666666667, 1.35, 0.5
327, 0.25, 1.35, 0.5
328, 0.33333333333333, 1.35, 0.5
329, 0.41666666666667, 1.35, 0.5
330, 0.5, 1.35, 0.5
331, 0.58333333333333, 1.35, 0.5
332, 0.66666666666667, 1.35, 0.5
333, 0.75, 1.35, 0.5
334, 0.83333333333333, 1.35, 0.5
335, 0.91666666666667, 1.35, 0.5
336, 0, 1.35, 0.05
337, 0, 1.35, 0.1
338, 0, 1.35, 0.15
339, 0, 1.35, 0.2
340, 0, 1.35, 0.25
341, 0, 1.35, 0.3
342, 0, 1.35, 0.35
343, 0, 1.35, 0.4
344, 0, 1.35, 0.45
345, 1, 1.3625, 0
346, 1, 1.375, 0
347, 1, 1.3875, 0
348, 0, 1.3625, 0
349, 0, 1.375, 0
350, 0, 1.3875, 0
351, 0.083333333333333, 1.4, 0
352, 0.16666666666667, 1.4, 0
353, 0.25, 1.4, 0
354, 0.33333333333333, 1.4, 0
355, 0.41666666666667, 1.4, 0
356, 0.5, 1.4, 0
357, 0.58333333333333, 1.4, 0
358, 0.66666666666667, 1.4, 0
359, 0.75, 1.4, 0
360, 0.83333333333333, 1.4, 0
361, 0.91666666666667, 1.4, 0
362, 1, 1.3625, 0.5
363, 1, 1.375, 0.5
364, 1, 1.3875, 0.5
365, 1, 1.4, 0.05
366, 1, 1.4, 0.1
367, 1, 1.4, 0.15
368, 1, 1.4, 0.2
369, 1, 1.4, 0.25
370, 1, 1.4, 0.3
371, 1, 1.4, 0.35
372, 1, 1.4, 0.4
373, 1, 1.4, 0.45
374, 0, 1.3625, 0.5
375, 0, 1.375, 0.5
376, 0, 1.3875, 0.5
377, 0.083333333333333, 1.4, 0.5
378, 0.16666666666667, 1.4, 0.5
379, 0.25, 1.4, 0.5
380, 0.33333333333333, 1.4, 0.5
381, 0.41666666666667, 1.4, 0.5
382, 0.5, 1.4, 0.5
383, 0.58333333333333, 1.4, 0.5
384, 0.66666666666667, 1.4, 0.5
385, 0.75, 1.4, 0.5
386, 0.83333333333333, 1.4, 0.5
387, 0.91666666666667, 1.4, 0.5
388, 0, 1.4, 0.05
389, 0, 1.4, 0.1
390, 0, 1.4, 0.15
391, 0, 1.4, 0.2
392, 0, 1.4, 0.25
393, 0, 1.4, 0.3
394, 0, 1.4, 0.35
395, 0, 1.4, 0.4
396, 0, 1.4, 0.45
397, 1.0285714285714, 1.35, 0.5
398, 1.0571428571429, 1.35, 0.5
399, 1.0857142857143, 1.35, 0.5
400, 1.1142857142857, 1.35, 0.5
401, 1.1428571428571, 1.35, 0.5
402, 1.1714285714286, 1.35, 0.5
403, 1.0285714285714, 1.4, 0.5
404, 1.0571428571429, 1.4, 0.5
405, 1.0857142857143, 1.4, 0.5
406, 1.1142857142857, 1.4, 0.5
407, 1.1428571428571, 1.4, 0.5
408, 1.1714285714286, 1.4, 0.5
409, 1.2, 1.3625, 0.5
410, 1.2, 1.375, 0.5
411, 1.2, 1.3875, 0.5
412, 1.0285714285714, 1.35, 0
413, 1.0571428571429, 1.35, 0
414, 1.0857142857143, 1.35, 0
415, 1.1142857142857, 1.35, 0
416, 1.1428571428571, 1.35, 0
417, 1.1714285714286, 1.35, 0
418, 1.0285714285714, 1.4, 0
419, 1.0571428571429, 1.4, 0
420, 1.0857142857143, 1.4, 0
421, 1.1142857142857, 1.4, 0
422, 1.1428571428571, 1.4, 0
423, 1.1714285714286, 1.4, 0
424, 1.2, 1.3625, 0
425, 1.2, 1.375, 0
426, 1.2, 1.3875, 0
427, 1.2, 1.35, 0.05
428, 1.2, 1.35, 0.1
429, 1.2, 1.35, 0.15
430, 1.2, 1.35, 0.2
431, 1.2, 1.35, 0.25
432, 1.2, 1.35, 0.3
433, 1.2, 1.35, 0.35
434, 1.2, 1.35, 0.4
435, 1.2, 1.35, 0.45
436, 1.2, 1.4, 0.05
437, 1.2, 1.4, 0.1
438, 1.2, 1.4, 0.15
439, 1.2, 1.4, 0.2
440, 1.2, 1.4, 0.25
441, 1.2, 1.4, 0.3
442, 1.2, 1.4, 0.35
443, 1.2, 1.4, 0.4
444, 1.2, 1.4, 0.45
445, 1.2833333333333, 1.35, 0.5
446, 1.3666666666667, 1.35, 0.5
447, 1.45, 1.35, 0.5
448, 1.5333333333333, 1.35, 0.5
449, 1.6166666666667, 1.35, 0.5
450, 1.7, 1.35, 0.5
451, 1.7833333333333, 1.35, 0.5
452, 1.8666666666667, 1.35, 0.5
453, 1.95, 1.35, 0.5
454, 2.0333333333333, 1.35, 0.5
455, 2.1166666666667, 1.35, 0.5
456, 1.2833333333333, 1.4, 0.5
457, 1.3666666666667, 1.4, 0.5
458, 1.45, 1.4, 0.5
459, 1.5333333333333, 1.4, 0.5
460, 1.6166666666667, 1.4, 0.5
461, 1.7, 1.4, 0.5
462, 1.7833333333333, 1.4, 0.5
463, 1.8666666666667, 1.4, 0.5
464, 1.95, 1.4, 0.5
465, 2.0333333333333, 1.4, 0.5
466, 2.1166666666667, 1.4, 0.5
467, 2.2, 1.3625, 0.5
468, 2.2, 1.375, 0.5
469, 2.2, 1.3875, 0.5
470, 1.2833333333333, 1.35, 0
471, 1.3666666666667, 1.35, 0
472, 1.45, 1.35, 0
473, 1.5333333333333, 1.35, 0
474, 1.6166666666667, 1.35, 0
475, 1.7, 1.35, 0
476, 1.7833333333333, 1.35, 0
477, 1.8666666666667, 1.35, 0
478, 1.95, 1.35, 0
479, 2.0333333333333, 1.35, 0
480, 2.1166666666667, 1.35, 0
481, 1.2833333333333, 1.4, 0
482, 1.3666666666667, 1.4, 0
483, 1.45, 1.4, 0
484, 1.5333333333333, 1.4, 0
485, 1.6166666666667, 1.4, 0
486, 1.7, 1.4, 0
487, 1.7833333333333, 1.4, 0
488, 1.8666666666667, 1.4, 0
489, 1.95, 1.4, 0
490, 2.0333333333333, 1.4, 0
491, 2.1166666666667, 1.4, 0
492, 2.2, 1.3625, 0
493, 2.2, 1.375, 0
494, 2.2, 1.3875, 0
495, 2.2, 1.35, 0.05
496, 2.2, 1.35, 0.1
497, 2.2, 1.35, 0.15
498, 2.2, 1.35, 0.2
499, 2.2, 1.35, 0.25
500, 2.2, 1.35, 0.3
501, 2.2, 1.35, 0.35
502, 2.2, 1.35, 0.4
503, 2.2, 1.35, 0.45
504, 2.2, 1.4, 0.05
505, 2.2, 1.4, 0.1
506, 2.2, 1.4, 0.15
507, 2.2, 1.4, 0.2
508, 2.2, 1.4, 0.25
509, 2.2, 1.4, 0.3
510, 2.2, 1.4, 0.35
511, 2.2, 1.4, 0.4
512, 2.2, 1.4, 0.45
513, 1.2833333333333, 1.3, 0.5
514, 1.3666666666667, 1.3, 0.5
515, 1.45, 1.3, 0.5
516, 1.5333333333333, 1.3, 0.5
517, 1.6166666666667, 1.3, 0.5
518, 1.7, 1.3, 0.5
519, 1.7833333333333, 1.3, 0.5
520, 1.8666666666667, 1.3, 0.5
521, 1.95, 1.3, 0.5
522, 2.0333333333333, 1.3, 0.5
523, 2.1166666666667, 1.3, 0.5
524, 1.2833333333333, 1.3, 0
525, 1.3666666666667, 1.3, 0
526, 1.45, 1.3, 0
527, 1.5333333333333, 1.3, 0
528, 1.6166666666667, 1.3, 0
529, 1.7, 1.3, 0
530, 1.7833333333333, 1.3, 0
531, 1.8666666666667, 1.3, 0
532, 1.95, 1.3, 0
533, 2.0333333333333, 1.3, 0
534, 2.1166666666667, 1.3, 0
535, 1.2, 1.3, 0.05
536, 1.2, 1.3, 0.1
537, 1.2, 1.3, 0.15
538, 1.2, 1.3, 0.2
539, 1.2, 1.3, 0.25
540, 1.2, 1.3, 0.3
541, 1.2, 1.3, 0.35
542, 1.2, 1.3, 0.4
543, 1.2, 1.3, 0.45
544, 2.2, 1.3, 0.05
545, 2.2, 1.3, 0.1
546, 2.2, 1.3, 0.15
547, 2.2, 1.3, 0.2
548, 2.2, 1.3, 0.25
549, 2.2, 1.3, 0.3
550, 2.2, 1.3, 0.35
551, 2.2, 1.3, 0.4
552, 2.2, 1.3, 0.45
553, 1.2, 1.18, 0.5
554, 1.2, 1.06, 0.5
555, 1.2, 0.94, 0.5
556, 1.2, 0.82, 0.5
557, 1.2, 0.7, 0.5
558, 1.2, 0.58, 0.5
559, 1.2, 0.46, 0.5
560, 1.2, 0.34, 0.5
561, 1.2, 0.22, 0.5
562, 2.2, 1.18, 0.5
563, 2.2, 1.06, 0.5
564, 2.2, 0.94, 0.5
565, 2.2, 0.82, 0.5
566, 2.2, 0.7, 0.5
567, 2.2, 0.58, 0.5
568, 2.2, 0.46, 0.5
569, 2.2, 0.34, 0.5
570, 2.2, 0.22, 0.5
571, 1.2833333333333, 0.1, 0.5
572, 1.3666666666667, 0.1, 0.5
573, 1.45, 0.1, 0.5
574, 1.5333333333333, 0.1, 0.5
575, 1.6166666666667, 0.1, 0.5
576, 1.7, 0.1, 0.5
577, 1.7833333333333, 0.1, 0.5
578, 1.8666666666667, 0.1, 0.5
579, 1.95, 0.1, 0.5
580, 2.0333333333333, 0.1, 0.5
581, 2.1166666666667, 0.1, 0.5
582, 1.2, 1.18, 0
583, 1.2, 1.06, 0
584, 1.2, 0.94, 0
585, 1.2, 0.82, 0
586, 1.2, 0.7, 0
587, 1.2, 0.58, 0
588, 1.2, 0.46, 0
589, 1.2, 0.34, 0
590, 1.2, 0.22, 0
591, 2.2, 1.18, 0
592, 2.2, 1.06, 0
593, 2.2, 0.94, 0
594, 2.2, 0.82, 0
595, 2.2, 0.7, 0
596, 2.2, 0.58, 0
597, 2.2, 0.46, 0
598, 2.2, 0.34, 0
599, 2.2, 0.22, 0
600, 1.2833333333333, 0.1, 0
601, 1.3666666666667, 0.1, 0
602, 1.45, 0.1, 0
603, 1.5333333333333, 0.1, 0
604, 1.6166666666667, 0.1, 0
605, 1.7, 0.1, 0
606, 1.7833333333333, 0.1, 0
607, 1.8666666666667, 0.1, 0
608, 1.95, 0.1, 0
609, 2.0333333333333, 0.1, 0
610, 2.1166666666667, 0.1, 0
611, 1.2, 0.1, 0.05
612, 1.2, 0.1, 0.1
613, 1.2, 0.1, 0.15
614, 1.2, 0.1, 0.2
615, 1.2, 0.1, 0.25
616, 1.2, 0.1, 0.3
617, 1.2, 0.1, 0.35
618, 1.2, 0.1, 0.4
619, 1.2, 0.1, 0.45
620, 2.2, 0.1, 0.05
621, 2.2, 0.1, 0.1
622, 2.2, 0.1, 0.15
623, 2.2, 0.1, 0.2
624, 2.2, 0.1, 0.25
625, 2.2, 0.1, 0.3
626, 2.2, 0.1, 0.35
627, 2.2, 0.1, 0.4
628, 2.2, 0.1, 0.45
629, 1.2833333333333, 0.05, 0.5
630, 1.3666666666667, 0.05, 0.5
631, 1.45, 0.05, 0.5
632, 1.5333333333333, 0.05, 0.5
633, 1.6166666666667, 0.05, 0.5
634, 1.7, 0.05, 0.5
635, 1.7833333333333, 0.05, 0.5
636, 1.8666666666667, 0.05, 0.5
637, 1.95, 0.05, 0.5
638, 2.0333333333333, 0.05, 0.5
639, 2.1166666666667, 0.05, 0.5
640, 1.2833333333333, 0.05, 0
641, 1.3666666666667, 0.05, 0
642, 1.45, 0.05, 0
643, 1.5333333333333, 0.05, 0
644, 1.6166666666667, 0.05, 0
645, 1.7, 0.05, 0
646, 1.7833333333333, 0.05, 0
647, 1.8666666666667, 0.05, 0
648, 1.95, 0.05, 0
649, 2.0333333333333, 0.05, 0
650, 2.1166666666667, 0.05, 0
651, 1.2, 0.05, 0.05
652, 1.2, 0.05, 0.1
653, 1.2, 0.05, 0.15
654, 1.2, 0.05, 0.2
655, 1.2, 0.05, 0.25
656, 1.2, 0.05, 0.3
657, 1.2, 0.05, 0.35
658, 1.2, 0.05, 0.4
659, 1.2, 0.05, 0.45
660, 2.2, 0.05, 0.05
661, 2.2, 0.05, 0.1
662, 2.2, 0.05, 0.15
663, 2.2, 0.05, 0.2
664, 2.2, 0.05, 0.25
665, 2.2, 0.05, 0.3
666, 2.2, 0.05, 0.35
667, 2.2, 0.05, 0.4
668, 2.2, 0.05, 0.45
669, 1.2, 0.0375, 0.5
670, 1.2, 0.025, 0.5
671, 1.2, 0.0125, 0.5
672, 2.2, 0.0375, 0.5
673, 2.2, 0.025, 0.5
674, 2.2, 0.0125, 0.5
675, 1.2833333333333, 8.3266726846887e-17, 0.5
676, 1.3666666666667, 8.3266726846887e-17, 0.5
677, 1.45, 8.3266726846887e-17, 0.5
678, 1.5333333333333, 8.3266726846887e-17, 0.5
679, 1.6166666666667, 8.3266726846887e-17, 0.5
680, 1.7, 8.3266726846887e-17, 0.5
681, 1.7833333333333, 8.3266726846887e-17, 0.5
682, 1.8666666666667, 8.3266726846887e-17, 0.5
683, 1.95, 8.3266726846887e-17, 0.5
684, 2.0333333333333, 8.3266726846887e-17, 0.5
685, 2.1166666666667, 8.3266726846887e-17, 0.5
686, 1.2, 0.0375, 0
687, 1.2, 0.025, 0
688, 1.2, 0.0125, 0
689, 2.2, 0.0375, 0
690, 2.2, 0.025, 0
691, 2.2, 0.0125, 0
692, 1.2833333333333, 8.3266726846887e-17, 0
693, 1.3666666666667, 8.3266726846887e-17, 0
694, 1.45, 8.3266726846887e-17, 0
695, 1.5333333333333, 8.3266726846887e-17, 0
696, 1.6166666666667, 8.3266726846887e-17, 0
697, 1.7, 8.3266726846887e-17, 0
698, 1.7833333333333, 8.3266726846887e-17, 0
699, 1.8666666666667, 8.3266726846887e-17, 0
700, 1.95, 8.3266726846887e-17, 0
701, 2.0333333333333, 8.3266726846887e-17, 0
702, 2.1166666666667, 8.3266726846887e-17, 0
703, 1.2, 8.3266726846887e-17, 0.05
704, 1.2, 8.3266726846887e-17, 0.1
705, 1.2, 8.3266726846887e-17, 0.15
706, 1.2, 8.3266726846887e-17, 0.2
707, 1.2, 8.3266726846887e-17, 0.25
708, 1.2, 8.3266726846887e-17, 0.3
709, 1.2, 8.3266726846887e-17, 0.35
710, 1.2, 8.3266726846887e-17, 0.4
711, 1.2, 8.3266726846887e-17, 0.45
712, 2.2, 8.3266726846887e-17, 0.05
713, 2.2, 8.3266726846887e-17, 0.1
714, 2.2, 8.3266726846887e-17, 0.15
715, 2.2, 8.3266726846887e-17, 0.2
716, 2.2, 8.3266726846887e-17, 0.25
717, 2.2, 8.3266726846887e-17, 0.3
718, 2.2, 8.3266726846887e-17, 0.35
719, 2.2, 8.3266726846887e-17, 0.4
720, 2.2, 8.3266726846887e-17, 0.45
721, 2.3, 0.0375, 0.5
722, 2.3, 0.025, 0.5
723, 2.3, 0.0125, 0.5
724, 2.3, 0.0375, 0
725, 2.3, 0.025, 0
726, 2.3, 0.0125, 0
727, 2.3, 0.05, 0.05
728, 2.3, 0.05, 0.1
729, 2.3, 0.05, 0.15
730, 2.3, 0.05, 0.2
731, 2.3, 0.05, 0.25
732, 2.3, 0.05, 0.3
733, 2.3, 0.05, 0.35
734, 2.3, 0.05, 0.4
735, 2.3, 0.05, 0.45
736, 2.3, 8.3266726846887e-17, 0.05
737, 2.3, 8.3266726846887e-17, 0.1
738, 2.3, 8.3266726846887e-17, 0.15
739, 2.3, 8.3266726846887e-17, 0.2
740, 2.3, 8.3266726846887e-17, 0.25
741, 2.3, 8.3266726846887e-17, 0.3
742, 2.3, 8.3266726846887e-17, 0.35
743, 2.3, 8.3266726846887e-17, 0.4
744, 2.3, 8.3266726846887e-17, 0.45
745, -0.1, 0, 0.05
746, -0.1, 0, 0.1
747, -0.1, 0, 0.15
748, -0.1, 0, 0.2
749, -0.1, 0, 0.25
750, -0.1, 0, 0.3
751, -0.1, 0, 0.35
752, -0.1, 0, 0.4
753, -0.1, 0, 0.45
754, -0.1, 0.0125, 0.5
755, -0.1, 0.025, 0.5
756, -0.1, 0.0375, 0.5
757, -0.1, 0.05, 0.05
758, -0.1, 0.05, 0.1
759, -0.1, 0.05, 0.15
760, -0.1, 0.05, 0.2
761, -0.1, 0.05, 0.25
762, -0.1, 0.05, 0.3
763, -0.1, 0.05, 0.35
764, -0.1, 0.05, 0.4
765, -0.1, 0.05, 0.45
766, -0.1, 0.0125, 0
767, -0.1, 0.025, 0
768, -0.1, 0.0375, 0
769, 1.05, 0.22, 0.5
770, 1.05, 0.34, 0.5
771, 1.05, 0.46, 0.5
772, 1.05, 0.58, 0.5
773, 1.05, 0.7, 0.5
774, 1.05, 0.82, 0.5
775, 1.05, 0.94, 0.5
776, 1.05, 1.06, 0.5
777, 1.05, 1.18, 0.5
778, 1.05, 0.22, 0
779, 1.05, 0.34, 0
780, 1.05, 0.46, 0
781, 1.05, 0.58, 0
782, 1.05, 0.7, 0
783, 1.05, 0.82, 0
784, 1.05, 0.94, 0
785, 1.05, 1.06, 0
786, 1.05, 1.18, 0
787, 1.05, 0.1, 0.05
788, 1.05, 0.1, 0.1
789, 1.05, 0.1, 0.15
790, 1.05, 0.1, 0.2
791, 1.05, 0.1, 0.25
792, 1.05, 0.1, 0.3
793, 1.05, 0.1, 0.35
794, 1.05, 0.1, 0.4
795, 1.05, 0.1, 0.45
796, 1.05, 1.3, 0.05
797, 1.05, 1.3, 0.1
798, 1.05, 1.3, 0.15
799, 1.05, 1.3, 0.2
800, 1.05, 1.3, 0.25
801, 1.05, 1.3, 0.3
802, 1.05, 1.3, 0.35
803, 1.05, 1.3, 0.4
804, 1.05, 1.3, 0.45
805, 1.15, 1.18, 0.5
806, 1.15, 1.06, 0.5
807, 1.15, 0.94, 0.5
808, 1.15, 0.82, 0.5
809, 1.15, 0.7, 0.5
810, 1.15, 0.58, 0.5
811, 1.15, 0.46, 0.5
812, 1.15, 0.34, 0.5
813, 1.15, 0.22, 0.5
814, 1.15, 1.18, 0
815, 1.15, 1.06, 0
816, 1.15, 0.94, 0
817, 1.15, 0.82, 0
818, 1.15, 0.7, 0
819, 1.15, 0.58, 0
820, 1.15, 0.46, 0
821, 1.15, 0.34, 0
822, 1.15, 0.22, 0
823, 1.15, 1.3, 0.05
824, 1.15, 1.3, 0.1
825, 1.15, 1.3, 0.15
826, 1.15, 1.3, 0.2
827, 1.15, 1.3, 0.25
828, 1.15, 1.3, 0.3
829, 1.15, 1.3, 0.35
830, 1.15, 1.3, 0.4
831, 1.15, 1.3, 0.45
832, 1.15, 0.1, 0.05
833, 1.15, 0.1, 0.1
834, 1.15, 0.1, 0.15
835, 1.15, 0.1, 0.2
836, 1.15, 0.1, 0.25
837, 1.15, 0.1, 0.3
838, 1.15, 0.1, 0.35
839, 1.15, 0.1, 0.4
840, 1.15, 0.1, 0.45
841, 1, 0.22, -0.1
842, 1, 0.34, -0.1
843, 1, 0.46, -0.1
844, 1, 0.58, -0.1
845, 1, 0.7, -0.1
846, 1, 0.82, -0.1
847, 1, 0.94, -0.1
848, 1, 1.06, -0.1
849, 1, 1.18, -0.1
850, 0, 0.22, -0.1
851, 0, 0.34, -0.1
852, 0, 0.46, -0.1
853, 0, 0.58, -0.1
854, 0, 0.7, -0.1
855, 0, 0.82, -0.1
856, 0, 0.94, -0.1
857, 0, 1.06, -0.1
858, 0, 1.18, -0.1
859, 0.083333333333333, 0.1, -0.1
860, 0.16666666666667, 0.1, -0.1
861, 0.25, 0.1, -0.1
862, 0.33333333333333, 0.1, -0.1
863, 0.41666666666667, 0.1, -0.1
864, 0.5, 0.1, -0.1
865, 0.58333333333333, 0.1, -0.1
866, 0.66666666666667, 0.1, -0.1
867, 0.75, 0.1, -0.1
868, 0.83333333333333, 0.1, -0.1
869, 0.91666666666667, 0.1, -0.1
870, 0.083333333333333, 1.3, -0.1
871, 0.16666666666667, 1.3, -0.1
872, 0.25, 1.3, -0.1
873, 0.33333333333333, 1.3, -0.1
874, 0.41666666666667, 1.3, -0.1
875, 0.5, 1.3, -0.1
876, 0.58333333333333, 1.3, -0.1
877, 0.66666666666667, 1.3, -0.1
878, 0.75, 1.3, -0.1
879, 0.83333333333333, 1.3, -0.1
880, 0.91666666666667, 1.3, -0.1
881, 1.2, 1.18, -0.1
882, 1.2, 1.06, -0.1
883, 1.2, 0.94, -0.1
884, 1.2, 0.82, -0.1
885, 1.2, 0.7, -0.1
886, 1.2, 0.58, -0.1
887, 1.2, 0.46, -0.1
888, 1.2, 0.34, -0.1
889, 1.2, 0.22, -0.1
890, 2.2, 1.18, -0.1
891, 2.2, 1.06, -0.1
892, 2.2, 0.94, -0.1
893, 2.2, 0.82, -0.1
894, 2.2, 0.7, -0.1
895, 2.2, 0.58, -0.1
896, 2.2, 0.46, -0.1
897, 2.2, 0.34, -0.1
898, 2.2, 0.22, -0.1
899, 1.2833333333333, 1.3, -0.1
900, 1.3666666666667, 1.3, -0.1
901, 1.45, 1.3, -0.1
902, 1.5333333333333, 1.3, -0.1
903, 1.6166666666667, 1.3, -0.1
904, 1.7, 1.3, -0.1
905, 1.7833333333333, 1.3, -0.1
906, 1.8666666666667, 1.3, -0.1
907, 1.95, 1.3, -0.1
908, 2.0333333333333, 1.3, -0.1
909, 2.1166666666667, 1.3, -0.1
910, 1.2833333333333, 0.1, -0.1
911, 1.3666666666667, 0.1, -0.1
912, 1.45, 0.1, -0.1
913, 1.5333333333333, 0.1, -0.1
914, 1.6166666666667, 0.1, -0.1
915, 1.7, 0.1, -0.1
916, 1.7833333333333, 0.1, -0.1
917, 1.8666666666667, 0.1, -0.1
918, 1.95, 0.1, -0.1
919, 2.0333333333333, 0.1, -0.1
920, 2.1166666666667, 0.1, -0.1
921, 1.15, 1.18, -0.1
922, 1.15, 1.06, -0.1
923, 1.15, 0.94, -0.1
924, 1.15, 0.82, -0.1
925, 1.15, 0.7, -0.1
926, 1.15, 0.58, -0.1
927, 1.15, 0.46, -0.1
928, 1.15, 0.34, -0.1
929, 1.15, 0.22, -0.1
930, 1.05, 0.22, -0.1
931, 1.05, 0.34, -0.1
932, 1.05, 0.46, -0.1
933, 1.05, 0.58, -0.1
934, 1.05, 0.7, -0.1
935, 1.05, 0.82, -0.1
936, 1.05, 0.94, -0.1
937, 1.05, 1.06, -0.1
938, 1.05, 1.18, -0.1
939, 1, 1.44, 0
940, 1, 1.48, 0
941, 1, 1.52, 0
942, 1, 1.56, 0
943, 0, 1.44, 0
944, 0, 1.48, 0
945, 0, 1.52, 0
946, 0, 1.56, 0
947, 0.083333333333333, 1.6, 0
948, 0.16666666666667, 1.6, 0
949, 0.25, 1.6, 0
950, 0.33333333333333, 1.6, 0
951, 0.41666666666667, 1.6, 0
952, 0.5, 1.6, 0
953, 0.58333333333333, 1.6, 0
954, 0.66666666666667, 1.6, 0
955, 0.75, 1.6, 0
956, 0.83333333333333, 1.6, 0
957, 0.91666666666667, 1.6, 0
958, 1, 1.44, 0.5
959, 1, 1.48, 0.5
960, 1, 1.52, 0.5
961, 1, 1.56, 0.5
962, 1, 1.6, 0.05
963, 1, 1.6, 0.1
964, 1, 1.6, 0.15
965, 1, 1.6, 0.2
966, 1, 1.6, 0.25
967, 1, 1.6, 0.3
968, 1, 1.6, 0.35
969, 1, 1.6, 0.4
970, 1, 1.6, 0.45
971, 0, 1.44, 0.5
972, 0, 1.48, 0.5
973, 0, 1.52, 0.5
974, 0, 1.56, 0.5
975, 0.083333333333333, 1.6, 0.5
976, 0.16666666666667, 1.6, 0.5
977, 0.25, 1.6, 0.5
978, 0.33333333333333, 1.6, 0.5
979, 0.41666666666667, 1.6, 0.5
980, 0.5, 1.6, 0.5
981, 0.58333333333333, 1.6, 0.5
982, 0.66666666666667, 1.6, 0.5
983, 0.75, 1.6, 0.5
984, 0.83333333333333, 1.6, 0.5
985, 0.91666666666667, 1.6, 0.5
986, 0, 1.6, 0.05
987, 0, 1.6, 0.1
988, 0, 1.6, 0.15
989, 0, 1.6, 0.2
990, 0, 1.6, 0.25
991, 0, 1.6, 0.3
992, 0, 1.6, 0.35
993, 0, 1.6, 0.4
994, 0, 1.6, 0.45
995, 1.2, 1.44, 0.5
996, 1.2, 1.48, 0.5
997, 1.2, 1.52, 0.5
998, 1.2, 1.56, 0.5
999, 1.0285714285714, 1.6, 0.5
1000, 1.0571428571429, 1.6, 0.5
1001, 1.0857142857143, 1.6, 0.5
1002, 1.1142857142857, 1.6, 0.5
1003, 1.1428571428571, 1.6, 0.5
1004, 1.1714285714286, 1.6, 0.5
1005, 1.2, 1.44, 0
1006, 1.2, 1.48, 0
1007, 1.2, 1.52, 0
1008, 1.2, 1.56, 0
1009, 1.0285714285714, 1.6, 0
1010, 1.0571428571429, 1.6, 0
1011, 1.0857142857143, 1.6, 0
1012, 1.1142857142857, 1.6, 0
1013, 1.1428571428571, 1.6, 0
1014, 1.1714285714286, 1.6, 0
1015, 1.2, 1.6, 0.05
1016, 1.2, 1.6, 0.1
1017, 1.2, 1.6, 0.15
1018, 1.2, 1.6, 0.2
1019, 1.2, 1.6, 0.25
1020, 1.2, 1.6, 0.3
1021, 1.2, 1.6, 0.35
1022, 1.2, 1.6, 0.4
1023, 1.2, 1.6, 0.45
1024, 2.2, 1.44, 0.5
1025, 2.2, 1.48, 0.5
1026, 2.2, 1.52, 0.5
1027, 2.2, 1.56, 0.5
1028, 1.2833333333333, 1.6, 0.5
1029, 1.3666666666667, 1.6, 0.5
1030, 1.45, 1.6, 0.5
1031, 1.5333333333333, 1.6, 0.5
1032, 1.6166666666667, 1.6, 0.5
1033, 1.7, 1.6, 0.5
1034, 1.7833333333333, 1.6, 0.5
1035, 1.8666666666667, 1.6, 0.5
1036, 1.95, 1.6, 0.5
1037, 2.0333333333333, 1.6, 0.5
1038, 2.1166666666667, 1.6, 0.5
1039, 2.2, 1.44, 0
1040, 2.2, 1.48, 0
1041, 2.2, 1.52, 0
1042, 2.2, 1.56, 0
1043, 1.2833333333333, 1.6, 0
1044, 1.3666666666667, 1.6, 0
1045, 1.45, 1.6, 0
1046, 1.5333333333333, 1.6, 0
1047, 1.6166666666667, 1.6, 0
1048, 1.7, 1.6, 0
1049, 1.7833333333333, 1.6, 0
1050, 1.8666666666667, 1.6, 0
1051, 1.95, 1.6, 0
1052, 2.0333333333333, 1.6, 0
1053, 2.1166666666667, 1.6, 0
1054, 2.2, 1.6, 0.05
1055, 2.2, 1.6, 0.1
1056, 2.2, 1.6, 0.15
1057, 2.2, 1.6, 0.2
1058, 2.2, 1.6, 0.25
1059, 2.2, 1.6, 0.3
1060, 2.2, 1.6, 0.35
1061, 2.2, 1.6, 0.4
1062, 2.2, 1.6, 0.45
1063, 1, -0.04, 0
1064, 1, -0.08, 0
1065, 1, -0.12, 0
1066, 1, -0.16, 0
1067, 0, -0.04, 0
1068, 0, -0.08, 0
1069, 0, -0.12, 0
1070, 0, -0.16, 0
1071, 0.083333333333333, -0.2, 0
1072, 0.16666666666667, -0.2, 0
1073, 0.25, -0.2, 0
1074, 0.33333333333333, -0.2, 0
1075, 0.41666666666667, -0.2, 0
1076, 0.5, -0.2, 0
1077, 0.58333333333333, -0.2, 0
1078, 0.66666666666667, -0.2, 0
1079, 0.75, -0.2, 0
1080, 0.83333333333333, -0.2, 0
1081, 0.91666666666667, -0.2, 0
1082, 1, -0.04, 0.5
1083, 1, -0.08, 0.5
1084, 1, -0.12, 0.5
1085, 1, -0.16, 0.5
1086, 1, -0.2, 0.05
1087, 1, -0.2, 0.1
1088, 1, -0.2, 0.15
1089, 1, -0.2, 0.2
1090, 1, -0.2, 0.25
1091, 1, -0.2, 0.3
1092, 1, -0.2, 0.35
1093, 1, -0.2, 0.4
1094, 1, -0.2, 0.45
1095, 0, -0.04, 0.5
1096, 0, -0.08, 0.5
1097, 0, -0.12, 0.5
1098, 0, -0.16, 0.5
1099, 0.083333333333333, -0.2, 0.5
1100, 0.16666666666667, -0.2, 0.5
1101, 0.25, -0.2, 0.5
1102, 0.33333333333333, -0.2, 0.5
1103, 0.41666666666667, -0.2, 0.5
1104, 0.5, -0.2, 0.5
1105, 0.58333333333333, -0.2, 0.5
1106, 0.66666666666667, -0.2, 0.5
1107, 0.75, -0.2, 0.5
1108, 0.83333333333333, -0.2, 0.5
1109, 0.91666666666667, -0.2, 0.5
1110, 0, -0.2, 0.05
1111, 0, -0.2, 0.1
1112, 0, -0.2, 0.15
1113, 0, -0.2, 0.2
1114, 0, -0.2, 0.25
1115, 0, -0.2, 0.3
1116, 0, -0.2, 0.35
1117, 0, -0.2, 0.4
1118, 0, -0.2, 0.45
1119, -0.1, -0.04, 0.5
1120, -0.1, -0.08, 0.5
1121, -0.1, -0.12, 0.5
1122, -0.1, -0.16, 0.5
1123, -0.1, -0.04, 0
1124, -0.1, -0.08, 0
1125, -0.1, -0.12, 0
1126, -0.1, -0.16, 0
1127, -0.1, -0.2, 0.05
1128, -0.1, -0.2, 0.1
1129, -0.1, -0.2, 0.15
1130, -0.1, -0.2, 0.2
1131, -0.1, -0.2, 0.25
1132, -0.1, -0.2, 0.3
1133, -0.1, -0.2, 0.35
1134, -0.1, -0.2, 0.4
1135, -0.1, -0.2, 0.45
1136, 1.2, -0.04, 0.5
1137, 1.2, -0.08, 0.5
1138, 1.2, -0.12, 0.5
1139, 1.2, -0.16, 0.5
1140, 2.2, -0.04, 0.5
1141, 2.2, -0.08, 0.5
1142, 2.2, -0.12, 0.5
1143, 2.2, -0.16, 0.5
1144, 1.2833333333333, -0.2, 0.5
1145, 1.3666666666667, -0.2, 0.5
1146, 1.45, -0.2, 0.5
1147, 1.5333333333333, -0.2, 0.5
1148, 1.6166666666667, -0.2, 0.5
1149, 1.7, -0.2, 0.5
1150, 1.7833333333333, -0.2, 0.5
1151, 1.8666666666667, -0.2, 0.5
1152, 1.95, -0.2, 0.5
1153, 2.0333333333333, -0.2, 0.5
1154, 2.1166666666667, -0.2, 0.5
1155, 1.2, -0.04, 0
1156, 1.2, -0.08, 0
1157, 1.2, -0.12, 0
1158, 1.2, -0.16, 0
1159, 2.2, -0.04, 0
1160, 2.2, -0.08, 0
1161, 2.2, -0.12, 0
1162, 2.2, -0.16, 0
1163, 1.2833333333333, -0.2, 0
1164, 1.3666666666667, -0.2, 0
1165, 1.45, -0.2, 0
1166, 1.5333333333333, -0.2, 0
1167, 1.6166666666667, -0.2, 0
1168, 1.7, -0.2, 0
1169, 1.7833333333333, -0.2, 0
1170, 1.8666666666667, -0.2, 0
1171, 1.95, -0.2, 0
1172, 2.0333333333333, -0.2, 0
1173, 2.1166666666667, -0.2, 0
1174, 1.2, -0.2, 0.05
1175, 1.2, -0.2, 0.1
1176, 1.2, -0.2, 0.15
1177, 1.2, -0.2, 0.2
1178, 1.2, -0.2, 0.25
1179, 1.2, -0.2, 0.3
1180, 1.2, -0.2, 0.35
1181, 1.2, -0.2, 0.4
1182, 1.2, -0.2, 0.45
1183, 2.2, -0.2, 0.05
1184, 2.2, -0.2, 0.1
1185, 2.2, -0.2, 0.15
1186, 2.2, -0.2, 0.2
1187, 2.2, -0.2, 0.25
1188, 2.2, -0.2, 0.3
1189, 2.2, -0.2, 0.35
1190, 2.2, -0.2, 0.4
1191, 2.2, -0.2, 0.45
1192, 2.3, -0.04, 0.5
1193, 2.3, -0.08, 0.5
1194, 2.3, -0.12, 0.5
1195, 2.3, -0.16, 0.5
1196, 2.3, -0.04, 0
1197, 2.3, -0.08, 0
1198, 2.3, -0.12, 0
1199, 2.3, -0.16, 0
1200, 2.3, -0.2, 0.05
1201, 2.3, -0.2, 0.1
1202, 2.3, -0.2, 0.15
1203, 2.3, -0.2, 0.2
1204, 2.3, -0.2, 0.25
1205, 2.3, -0.2, 0.3
1206, 2.3, -0.2, 0.35
1207, 2.3, -0.2, 0.4
1208, 2.3, -0.2, 0.45
1209, 0, 0.0125, 0.05
1210, 0, 0.025, 0.05
1211, 0, 0.0375, 0.05
1212, 0, 0.0125, 0.1
1213, 0, 0.025, 0.1
1214, 0, 0.0375, 0.1
1215, 0, 0.0125, 0.15
1216, 0, 0.025, 0.15
1217, 0, 0.0375, 0.15
1218, 0, 0.0125, 0.2
1219, 0, 0.025, 0.2
1220, 0, 0.0375, 0.2
1221, 0, 0.0125, 0.25
1222, 0, 0.025, 0.25
1223, 0, 0.0375, 0.25
1224, 0, 0.0125, 0.3
1225, 0, 0.025, 0.3
1226, 0, 0.0375, 0.3
1227, 0, 0.0125, 0.35
1228, 0, 0.025, 0.35
1229, 0, 0.0375, 0.35
1230, 0, 0.0125, 0.4
1231, 0, 0.025, 0.4
1232, 0, 0.0375, 0.4
1233, 0, 0.0125, 0.45
1234, 0, 0.025, 0.45
1235, 0, 0.0375, 0.45
1236, 1, 0.0125, 0.05
1237, 1, 0.025, 0.05
1238, 1, 0.0375, 0.05
1239, 1, 0.0125, 0.1
1240, 1, 0.025, 0.1
1241, 1, 0.0375, 0.1
1242, 1, 0.0125, 0.15
1243, 1, 0.025, 0.15
1244, 1, 0.0375, 0.15
1245, 1, 0.0125, 0.2
1246, 1, 0.025, 0.2
1247, 1, 0.0375, 0.2
1248, 1, 0.0125, 0.25
1249, 1, 0.025, 0.25
1250, 1, 0.0375, 0.25
1251, 1, 0.0125, 0.3
1252, 1, 0.025, 0.3
1253, 1, 0.0375, 0.3
1254, 1, 0.0125, 0.35
1255, 1, 0.025, 0.35
1256, 1, 0.0375, 0.35
1257, 1, 0.0125, 0.4
1258, 1, 0.025, 0.4
1259, 1, 0.0375, 0.4
1260, 1, 0.0125, 0.45
1261, 1, 0.025, 0.45
1262, 1, 0.0375, 0.45
1263, 0.083333333333333, 0, 0.05
1264, 0.083333333333333, 0, 0.1
1265, 0.083333333333333, 0, 0.15
1266, 0.083333333333333, 0, 0.2
1267, 0.083333333333333, 0, 0.25
1268, 0.083333333333333, 0, 0.3
1269, 0.083333333333333, 0, 0.35
1270, 0.083333333333333, 0, 0.4
1271, 0.083333333333333, 0, 0.45
1272, 0.16666666666667, 0, 0.05
1273, 0.16666666666667, 0, 0.1
1274, 0.16666666666667, 0, 0.15
1275, 0.16666666666667, 0, 0.2
1276, 0.16666666666667, 0, 0.25
1277, 0.16666666666667, 0, 0.3
1278, 0.16666666666667, 0, 0.35
1279, 0.16666666666667, 0, 0.4
1280, 0.16666666666667, 0, 0.45
1281, 0.25, 0, 0.05
1282, 0.25, 0, 0.1
1283, 0.25, 0, 0.15
1284, 0.25, 0, 0.2
1285, 0.25, 0, 0.25
1286, 0.25, 0, 0.3
1287, 0.25, 0, 0.35
1288, 0.25, 0, 0.4
1289, 0.25, 0, 0.45
1290, 0.33333333333333, 0, 0.05
1291, 0.33333333333333, 0, 0.1
1292, 0.33333333333333, 0, 0.15
1293, 0.33333333333333, 0, 0.2
1294, 0.33333333333333, 0, 0.25
1295, 0.33333333333333, 0, 0.3
1296, 0.33333333333333, 0, 0.35
1297, 0.33333333333333, 0, 0.4
1298, 0.33333333333333, 0, 0.45
1299, 0.41666666666667, 0, 0.05
1300, 0.41666666666667, 0, 0.1
1301, 0.41666666666667, 0, 0.15
1302, 0.41666666666667, 0, 0.2
1303, 0.41666666666667, 0, 0.25
1304, 0.41666666666667, 0, 0.3
1305, 0.41666666666667, 0, 0.35
1306, 0.41666666666667, 0, 0.4
1307, 0.41666666666667, 0, 0.45
1308, 0.5, 0, 0.05
1309, 0.5, 0, 0.1
1310, 0.5, 0, 0.15
1311, 0.5, 0, 0.2
1312, 0.5, 0, 0.25
1313, 0.5, 0, 0.3
1314, 0.5, 0, 0.35
1315, 0.5, 0, 0.4
1316, 0.5, 0, 0.45
1317, 0.58333333333333, 0, 0.05
1318, 0.58333333333333, 0, 0.1
1319, 0.58333333333333, 0, 0.15
1320, 0.58333333333333, 0, 0.2
1321, 0.58333333333333, 0, 0.25
1322, 0.58333333333333, 0, 0.3
1323, 0.58333333333333, 0, 0.35
1324, 0.58333333333333, 0, 0.4
1325, 0.58333333333333, 0, 0.45
1326, 0.66666666666667, 0, 0.05
1327, 0.66666666666667, 0, 0.1
1328, 0.66666666666667, 0, 0.15
1329, 0.66666666666667, 0, 0.2
1330, 0.66666666666667, 0, 0.25
1331, 0.66666666666667, 0, 0.3
1332, 0.66666666666667, 0, 0.35
1333, 0.66666666666667, 0, 0.4
1334, 0.66666666666667, 0, 0.45
1335, 0.75, 0, 0.05
1336, 0.75, 0, 0.1
1337, 0.75, 0, 0.15
1338, 0.75, 0, 0.2
1339, 0.75, 0, 0.25
1340, 0.75, 0, 0.3
1341, 0.75, 0, 0.35
1342, 0.75, 0, 0.4
1343, 0.75, 0, 0.45
1344, 0.83333333333333, 0, 0.05
1345, 0.83333333333333, 0, 0.1
1346, 0.83333333333333, 0, 0.15
1347, 0.83333333333333, 0, 0.2
1348, 0.83333333333333, 0, 0.25
1349, 0.83333333333333, 0, 0.3
1350, 0.83333333333333, 0, 0.35
1351, 0.83333333333333, 0, 0.4
1352, 0.83333333333333, 0, 0.45
1353, 0.91666666666667, 0, 0.05
1354, 0.91666666666667, 0, 0.1
1355, 0.91666666666667, 0, 0.15
1356, 0.91666666666667, 0, 0.2
1357, 0.91666666666667, 0, 0.25
1358, 0.91666666666667, 0, 0.3
1359, 0.91666666666667, 0, 0.35
1360, 0.91666666666667, 0, 0.4
1361, 0.91666666666667, 0, 0.45
1362, 0.083333333333333, 0.05, 0.05
1363, 0.083333333333333, 0.05, 0.1
1364, 0.083333333333333, 0.05, 0.15
1365, 0.083333333333333, 0.05, 0.2
1366, 0.083333333333333, 0.05, 0.25
1367, 0.083333333333333, 0.05, 0.3
1368, 0.083333333333333, 0.05, 0.35
1369, 0.083333333333333, 0.05, 0.4
1370, 0.083333333333333, 0.05, 0.45
1371, 0.16666666666667, 0.05, 0.05
1372, 0.16666666666667, 0.05, 0.1
1373, 0.16666666666667, 0.05, 0.15
1374, 0.16666666666667, 0.05, 0.2
1375, 0.16666666666667, 0.05, 0.25
1376, 0.16666666666667, 0.05, 0.3
1377, 0.16666666666667, 0.05, 0.35
1378, 0.16666666666667, 0.05, 0.4
1379, 0.16666666666667, 0.05, 0.45
1380, 0.25, 0.05, 0.05
1381, 0.25, 0.05, 0.1
1382, 0.25, 0.05, 0.15
1383, 0.25, 0.05, 0.2
1384, 0.25, 0.05, 0.25
1385, 0.25, 0.05, 0.3
1386, 0.25, 0.05, 0.35
1387, 0.25, 0.05, 0.4
1388, 0.25, 0.05, 0.45
1389, 0.33333333333333, 0.05, 0.05
1390, 0.33333333333333, 0.05, 0.1
1391, 0.33333333333333, 0.05, 0.15
1392, 0.33333333333333, 0.05, 0.2
1393, 0.33333333333333, 0.05, 0.25
1394, 0.33333333333333, 0.05, 0.3
1395, 0.33333333333333, 0.05, 0.35
1396, 0.33333333333333, 0.05, 0.4
1397, 0.33333333333333, 0.05, 0.45
1398, 0.41666666666667, 0.05, 0.05
1399, 0.41666666666667, 0.05, 0.1
1400, 0.41666666666667, 0.05, 0.15
1401, 0.41666666666667, 0.05, 0.2
1402, 0.41666666666667, 0.05, 0.25
1403, 0.41666666666667, 0.05, 0.3
1404, 0.41666666666667, 0.05, 0.35
1405, 0.41666666666667, 0.05, 0.4
1406, 0.41666666666667, 0.05, 0.45
1407, 0.5, 0.05, 0.05
1408, 0.5, 0.05, 0.1
1409, 0.5, 0.05, 0.15
1410, 0.5, 0.05, 0.2
1411, 0.5, 0.05, 0.25
1412, 0.5, 0.05, 0.3
1413, 0.5, 0.05, 0.35
1414, 0.5, 0.05, 0.4
1415, 0.5, 0.05, 0.45
1416, 0.58333333333333, 0.05, 0.05
1417, 0.58333333333333, 0.05, 0.1
1418, 0.58333333333333, 0.05, 0.15
1419, 0.58333333333333, 0.05, 0.2
1420, 0.58333333333333, 0.05, 0.25
1421, 0.58333333333333, 0.05, 0.3
1422, 0.58333333333333, 0.05, 0.35
1423, 0.58333333333333, 0.05, 0.4
1424, 0.58333333333333, 0.05, 0.45
1425, 0.66666666666667, 0.05, 0.05
1426, 0.66666666666667, 0.05, 0.1
1427, 0.66666666666667, 0.05, 0.15
1428, 0.66666666666667, 0.05, 0.2
1429, 0.66666666666667, 0.05, 0.25
1430, 0.66666666666667, 0.05, 0.3
1431, 0.66666666666667, 0.05, 0.35
1432, 0.66666666666667, 0.05, 0.4
1433, 0.66666666666667, 0.05, 0.45
1434, 0.75, 0.05, 0.05
1435, 0.75, 0.05, 0.1
1436, 0.75, 0.05, 0.15
1437, 0.75, 0.05, 0.2
1438, 0.75, 0.05, 0.25
1439, 0.75, 0.05, 0.3
1440, 0.75, 0.05, 0.35
1441, 0.75, 0.05, 0.4
1442, 0.75, 0.05, 0.45
1443, 0.83333333333333, 0.05, 0.05
1444, 0.83333333333333, 0.05, 0.1
1445, 0.83333333333333, 0.05, 0.15
1446, 0.83333333333333, 0.05, 0.2
1447, 0.83333333333333, 0.05, 0.25
1448, 0.83333333333333, 0.05, 0.3
1449, 0.83333333333333, 0.05, 0.35
1450, 0.83333333333333, 0.05, 0.4
1451, 0.83333333333333, 0.05, 0.45
1452, 0.91666666666667, 0.05, 0.05
1453, 0.91666666666667, 0.05, 0.1
1454, 0.91666666666667, 0.05, 0.15
1455, 0.91666666666667, 0.05, 0.2
1456, 0.91666666666667, 0.05, 0.25
1457, 0.91666666666667, 0.05, 0.3
1458, 0.91666666666667, 0.05, 0.35
1459, 0.91666666666667, 0.05, 0.4
1460, 0.91666666666667, 0.05, 0.45
1461, 0.083333333333333, 0.0125, 0
1462, 0.16666666666667, 0.0125, 0
1463, 0.25, 0.0125, 0
1464, 0.33333333333333, 0.0125, 0
1465, 0.41666666666667, 0.0125, 0
1466, 0.5, 0.0125, 0
1467, 0.58333333333333, 0.0125, 0
1468, 0.66666666666667, 0.0125, 0
1469, 0.75, 0.0125, 0
1470, 0.83333333333333, 0.0125, 0
1471, 0.91666666666667, 0.0125, 0
1472, 0.083333333333333, 0.025, 0
1473, 0.16666666666667, 0.025, 0
1474, 0.25, 0.025, 0
1475, 0.33333333333333, 0.025, 0
1476, 0.41666666666667, 0.025, 0
1477, 0.5, 0.025, 0
1478, 0.58333333333333, 0.025, 0
1479, 0.66666666666667, 0.025, 0
1480, 0.75, 0.025, 0
1481, 0.83333333333333, 0.025, 0
1482, 0.91666666666667, 0.025, 0
1483, 0.083333333333333, 0.0375, 0
1484, 0.16666666666667, 0.0375, 0
1485, 0.25, 0.0375, 0
1486, 0.33333333333333, 0.0375, 0
1487, 0.41666666666667, 0.0375, 0
1488, 0.5, 0.0375, 0
1489, 0.58333333333333, 0.0375, 0
1490, 0.66666666666667, 0.0375, 0
1491, 0.75, 0.0375, 0
1492, 0.83333333333333, 0.0375, 0
1493, 0.91666666666667, 0.0375, 0
1494, 0.083333333333333, 0.0125, 0.5
1495, 0.16666666666667, 0.0125, 0.5
1496, 0.25, 0.0125, 0.5
1497, 0.33333333333333, 0.0125, 0.5
1498, 0.41666666666667, 0.0125, 0.5
1499, 0.5, 0.0125, 0.5
1500, 0.58333333333333, 0.0125, 0.5
1501, 0.66666666666667, 0.0125, 0.5
1502, 0.75, 0.0125, 0.5
1503, 0.83333333333333, 0.0125, 0.5
1504, 0.91666666666667, 0.0125, 0.5
1505, 0.083333333333333, 0.025, 0.5
1506, 0.16666666666667, 0.025, 0.5
1507, 0.25, 0.025, 0.5
1508, 0.33333333333333, 0.025, 0.5
1509, 0.41666666666667, 0.025, 0.5
1510, 0.5, 0.025, 0.5
1511, 0.58333333333333, 0.025, 0.5
1512, 0.66666666666667, 0.025, 0.5
1513, 0.75, 0.025, 0.5
1514, 0.83333333333333, 0.025, 0.5
1515, 0.91666666666667, 0.025, 0.5
1516, 0.083333333333333, 0.0375, 0.5
1517, 0.16666666666667, 0.0375, 0.5
1518, 0.25, 0.0375, 0.5
1519, 0.33333333333333, 0.0375, 0.5
1520, 0.41666666666667, 0.0375, 0.5
1521, 0.5, 0.0375, 0.5
1522, 0.58333333333333, 0.0375, 0.5
1523, 0.66666666666667, 0.0375, 0.5
1524, 0.75, 0.0375, 0.5
1525, 0.83333333333333, 0.0375, 0.5
1526, 0.91666666666667, 0.0375, 0.5
1527, 0.083333333333333, 0.1, 0.05
1528, 0.083333333333333, 0.1, 0.1
1529, 0.083333333333333, 0.1, 0.15
1530, 0.083333333333333, 0.1, 0.2
1531, 0.083333333333333, 0.1, 0.25
1532, 0.083333333333333, 0.1, 0.3
1533, 0.083333333333333, 0.1, 0.35
1534, 0.083333333333333, 0.1, 0.4
1535, 0.083333333333333, 0.1, 0.45
1536, 0.16666666666667, 0.1, 0.05
1537, 0.16666666666667, 0.1, 0.1
1538, 0.16666666666667, 0.1, 0.15
1539, 0.16666666666667, 0.1, 0.2
1540, 0.16666666666667, 0.1, 0.25
1541, 0.16666666666667, 0.1, 0.3
1542, 0.16666666666667, 0.1, 0.35
1543, 0.16666666666667, 0.1, 0.4
1544, 0.16666666666667, 0.1, 0.45
1545, 0.25, 0.1, 0.05
1546, 0.25, 0.1, 0.1
1547, 0.25, 0.1, 0.15
1548, 0.25, 0.1, 0.2
1549, 0.25, 0.1, 0.25
1550, 0.25, 0.1, 0.3
1551, 0.25, 0.1, 0.35
1552, 0.25, 0.1, 0.4
1553, 0.25, 0.1, 0.45
1554, 0.33333333333333, 0.1, 0.05
1555, 0.33333333333333, 0.1, 0.1
1556, 0.33333333333333, 0.1, 0.15
1557, 0.33333333333333, 0.1, 0.2
1558, 0.33333333333333, 0.1, 0.25
1559, 0.33333333333333, 0.1, 0.3
1560, 0.33333333333333, 0.1, 0.35
1561, 0.33333333333333, 0.1, 0.4
1562, 0.33333333333333, 0.1, 0.45
1563, 0.41666666666667, 0.1, 0.05
1564, 0.41666666666667, 0.1, 0.1
1565, 0.41666666666667, 0.1, 0.15
1566, 0.41666666666667, 0.1, 0.2
1567, 0.41666666666667, 0.1, 0.25
1568, 0.41666666666667, 0.1, 0.3
1569, 0.41666666666667, 0.1, 0.35
1570, 0.41666666666667, 0.1, 0.4
1571, 0.41666666666667, 0.1, 0.45
1572, 0.5, 0.1, 0.05
1573, 0.5, 0.1, 0.1
1574, 0.5, 0.1, 0.15
1575, 0.5, 0.1, 0.2
1576, 0.5, 0.1, 0.25
1577, 0.5, 0.1, 0.3
1578, 0.5, 0.1, 0.35
1579, 0.5, 0.1, 0.4
1580, 0.5, 0.1, 0.45
1581, 0.58333333333333, 0.1, 0.05
1582, 0.58333333333333, 0.1, 0.1
1583, 0.58333333333333, 0.1, 0.15
1584, 0.58333333333333, 0.1, 0.2
1585, 0.58333333333333, 0.1, 0.25
1586, 0.58333333333333, 0.1, 0.3
1587, 0.58333333333333, 0.1, 0.35
1588, 0.58333333333333, 0.1, 0.4
1589, 0.58333333333333, 0.1, 0.45
1590, 0.66666666666667, 0.1, 0.05
1591, 0.66666666666667, 0.1, 0.1
1592, 0.66666666666667, 0.1, 0.15
1593, 0.66666666666667, 0.1, 0.2
1594, 0.66666666666667, 0.1, 0.25
1595, 0.66666666666667, 0.1, 0.3
1596, 0.66666666666667, 0.1, 0.35
1597, 0.66666666666667, 0.1, 0.4
1598, 0.66666666666667, 0.1, 0.45
1599, 0.75, 0.1, 0.05
1600, 0.75, 0.1, 0.1
1601, 0.75, 0.1, 0.15
1602, 0.75, 0.1, 0.2
1603, 0.75, 0.1, 0.25
1604, 0.75, 0.1, 0.3
1605, 0.75, 0.1, 0.35
1606, 0.75, 0.1, 0.4
1607, 0.75, 0.1, 0.45
1608, 0.83333333333333, 0.1, 0.05
1609, 0.83333333333333, 0.1, 0.1
1610, 0.83333333333333, 0.1, 0.15
1611, 0.83333333333333, 0.1, 0.2
1612, 0.83333333333333, 0.1, 0.25
1613, 0.83333333333333, 0.1, 0.3
1614, 0.83333333333333, 0.1, 0.35
1615, 0.83333333333333, 0.1, 0.4
1616, 0.83333333333333, 0.1, 0.45
1617, 0.91666666666667, 0.1, 0.05
1618, 0.91666666666667, 0.1, 0.1
1619, 0.91666666666667, 0.1, 0.15
1620, 0.91666666666667, 0.1, 0.2
1621, 0.91666666666667, 0.1, 0.25
1622, 0.91666666666667, 0.1, 0.3
1623, 0.91666666666667, 0.1, 0.35
1624, 0.91666666666667, 0.1, 0.4
1625, 0.91666666666667, 0.1, 0.45
1626, 0.083333333333333, 0.22, 0
1627, 0.083333333333333, 0.34, 0
1628, 0.083333333333333, 0.46, 0
1629, 0.083333333333333, 0.58, 0
1630, 0.083333333333333, 0.7, 0
1631, 0.083333333333333, 0.82, 0
1632, 0.083333333333333, 0.94, 0
1633, 0.083333333333333, 1.06, 0
1634, 0.083333333333333, 1.18, 0
1635, 0.16666666666667, 0.22, 0
1636, 0.16666666666667, 0.34, 0
1637, 0.16666666666667, 0.46, 0
1638, 0.16666666666667, 0.58, 0
1639, 0.16666666666667, 0.7, 0
1640, 0.16666666666667, 0.82, 0
1641, 0.16666666666667, 0.94, 0
1642, 0.16666666666667, 1.06, 0
1643, 0.16666666666667, 1.18, 0
1644, 0.25, 0.22, 0
1645, 0.25, 0.34, 0
1646, 0.25, 0.46, 0
1647, 0.25, 0.58, 0
1648, 0.25, 0.7, 0
1649, 0.25, 0.82, 0
1650, 0.25, 0.94, 0
1651, 0.25, 1.06, 0
1652, 0.25, 1.18, 0
1653, 0.33333333333333, 0.22, 0
1654, 0.33333333333333, 0.34, 0
1655, 0.33333333333333, 0.46, 0
1656, 0.33333333333333, 0.58, 0
1657, 0.33333333333333, 0.7, 0
1658, 0.33333333333333, 0.82, 0
1659, 0.33333333333333, 0.94, 0
1660, 0.33333333333333, 1.06, 0
1661, 0.33333333333333, 1.18, 0
1662, 0.41666666666667, 0.22, 0
1663, 0.41666666666667, 0.34, 0
1664, 0.41666666666667, 0.46, 0
1665, 0.41666666666667, 0.58, 0
1666, 0.41666666666667, 0.7, 0
1667, 0.41666666666667, 0.82, 0
1668, 0.41666666666667, 0.94, 0
1669, 0.41666666666667, 1.06, 0
1670, 0.41666666666667, 1.18, 0
1671, 0.5, 0.22, 0
1672, 0.5, 0.34, 0
1673, 0.5, 0.46, 0
1674, 0.5, 0.58, 0
1675, 0.5, 0.7, 0
1676, 0.5, 0.82, 0
1677, 0.5, 0.94, 0
1678, 0.5, 1.06, 0
1679, 0.5, 1.18, 0
1680, 0.58333333333333, 0.22, 0
1681, 0.58333333333333, 0.34, 0
1682, 0.58333333333333, 0.46, 0
1683, 0.58333333333333, 0.58, 0
1684, 0.58333333333333, 0.7, 0
1685, 0.58333333333333, 0.82, 0
1686, 0.58333333333333, 0.94, 0
1687, 0.58333333333333, 1.06, 0
1688, 0.58333333333333, 1.18, 0
1689, 0.66666666666667, 0.22, 0
1690, 0.66666666666667, 0.34, 0
1691, 0.66666666666667, 0.46, 0
1692, 0.66666666666667, 0.58, 0
1693, 0.66666666666667, 0.7, 0
1694, 0.66666666666667, 0.82, 0
1695, 0.66666666666667, 0.94, 0
1696, 0.66666666666667, 1.06, 0
1697, 0.66666666666667, 1.18, 0
1698, 0.75, 0.22, 0
1699, 0.75, 0.34, 0
1700, 0.75, 0.46, 0
1701, 0.75, 0.58, 0
1702, 0.75, 0.7, 0
1703, 0.75, 0.82, 0
1704, 0.75, 0.94, 0
1705, 0.75, 1.06, 0
1706, 0.75, 1.18, 0
1707, 0.83333333333333, 0.22, 0
1708, 0.83333333333333, 0.34, 0
1709, 0.83333333333333, 0.46, 0
1710, 0.83333333333333, 0.58, 0
1711, 0.83333333333333, 0.7, 0
1712, 0.83333333333333, 0.82, 0
1713, 0.83333333333333, 0.94, 0
1714, 0.83333333333333, 1.06, 0
1715, 0.83333333333333, 1.18, 0
1716, 0.91666666666667, 0.22, 0
1717, 0.91666666666667, 0.34, 0
1718, 0.91666666666667, 0.46, 0
1719, 0.91666666666667, 0.58, 0
1720, 0.91666666666667, 0.7, 0
1721, 0.91666666666667, 0.82, 0
1722, 0.91666666666667, 0.94, 0
1723, 0.91666666666667, 1.06, 0
1724, 0.91666666666667, 1.18, 0
1725, 1, 0.22, 0.05
1726, 1, 0.34, 0.05
1727, 1, 0.46, 0.05
1728, 1, 0.58, 0.05
1729, 1, 0.7, 0.05
1730, 1, 0.82, 0.05
1731, 1, 0.94, 0.05
1732, 1, 1.06, 0.05
1733, 1, 1.18, 0.05
1734, 1, 0.22, 0.1
1735, 1, 0.34, 0.1
1736, 1, 0.46, 0.1
1737, 1, 0.58, 0.1
1738, 1, 0.7, 0.1
1739, 1, 0.82, 0.1
1740, 1, 0.94, 0.1
1741, 1, 1.06, 0.1
1742, 1, 1.18, 0.1
1743, 1, 0.22, 0.15
1744, 1, 0.34, 0.15
1745, 1, 0.46, 0.15
1746, 1, 0.58, 0.15
1747, 1, 0.7, 0.15
1748, 1, 0.82, 0.15
1749, 1, 0.94, 0.15
1750, 1, 1.06, 0.15
1751, 1, 1.18, 0.15
1752, 1, 0.22, 0.2
1753, 1, 0.34, 0.2
1754, 1, 0.46, 0.2
1755, 1, 0.58, 0.2
1756, 1, 0.7, 0.2
1757, 1, 0.82, 0.2
1758, 1, 0.94, 0.2
1759, 1, 1.06, 0.2
1760, 1, 1.18, 0.2
1761, 1, 0.22, 0.25
1762, 1, 0.34, 0.25
1763, 1, 0.46, 0.25
1764, 1, 0.58, 0.25
1765, 1, 0.7, 0.25
1766, 1, 0.82, 0.25
1767, 1, 0.94, 0.25
1768, 1, 1.06, 0.25
1769, 1, 1.18, 0.25
1770, 1, 0.22, 0.3
1771, 1, 0.34, 0.3
1772, 1, 0.46, 0.3
1773, 1, 0.58, 0.3
1774, 1, 0.7, 0.3
1775, 1, 0.82, 0.3
1776, 1, 0.94, 0.3
1777, 1, 1.06, 0.3
1778, 1, 1.18, 0.3
1779, 1, 0.22, 0.35
1780, 1, 0.34, 0.35
1781, 1, 0.46, 0.35
1782, 1, 0.58, 0.35
1783, 1, 0.7, 0.35
1784, 1, 0.82, 0.35
1785, 1, 0.94, 0.35
1786, 1, 1.06, 0.35
1787, 1, 1.18, 0.35
1788, 1, 0.22, 0.4
1789, 1, 0.34, 0.4
1790, 1, 0.46, 0.4
1791, 1, 0.58, 0.4
1792, 1, 0.7, 0.4
1793, 1, 0.82, 0.4
1794, 1, 0.94, 0.4
1795, 1, 1.06, 0.4
1796, 1, 1.18, 0.4
1797, 1, 0.22, 0.45
1798, 1, 0.34, 0.45
1799, 1, 0.46, 0.45
1800, 1, 0.58, 0.45
1801, 1, 0.7, 0.45
1802, 1, 0.82, 0.45
1803, 1, 0.94, 0.45
1804, 1, 1.06, 0.45
1805, 1, 1.18, 0.45
1806, 0.083333333333333, 0.22, 0.5
1807, 0.083333333333333, 0.34, 0.5
1808, 0.083333333333333, 0.46, 0.5
1809, 0.083333333333333, 0.58, 0.5
1810, 0.083333333333333, 0.7, 0.5
1811, 0.083333333333333, 0.82, 0.5
1812, 0.083333333333333, 0.94, 0.5
1813, 0.083333333333333, 1.06, 0.5
1814, 0.083333333333333, 1.18, 0.5
1815, 0.16666666666667, 0.22, 0.5
1816, 0.16666666666667, 0.34, 0.5
1817, 0.16666666666667, 0.46, 0.5
1818, 0.16666666666667, 0.58, 0.5
1819, 0.16666666666667, 0.7, 0.5
1820, 0.16666666666667, 0.82, 0.5
1821, 0.16666666666667, 0.94, 0.5
1822, 0.16666666666667, 1.06, 0.5
1823, 0.16666666666667, 1.18, 0.5
1824, 0.25, 0.22, 0.5
1825, 0.25, 0.34, 0.5
1826, 0.25, 0.46, 0.5
1827, 0.25, 0.58, 0.5
1828, 0.25, 0.7, 0.5
1829, 0.25, 0.82, 0.5
1830, 0.25, 0.94, 0.5
1831, 0.25, 1.06, 0.5
1832, 0.25, 1.18, 0.5
1833, 0.33333333333333, 0.22, 0.5
1834, 0.33333333333333, 0.34, 0.5
1835, 0.33333333333333, 0.46, 0.5
1836, 0.33333333333333, 0.58, 0.5
1837, 0.33333333333333, 0.7, 0.5
1838, 0.33333333333333, 0.82, 0.5
1839, 0.33333333333333, 0.94, 0.5
1840, 0.33333333333333, 1.06, 0.5
1841, 0.33333333333333, 1.18, 0.5
1842, 0.41666666666667, 0.22, 0.5
1843, 0.41666666666667, 0.34, 0.5
1844, 0.41666666666667, 0.46, 0.5
1845, 0.41666666666667, 0.58, 0.5
1846, 0.41666666666667, 0.7, 0.5
1847, 0.41666666666667, 0.82, 0.5
1848, 0.41666666666667, 0.94, 0.5
1849, 0.41666666666667, 1.06, 0.5
1850, 0.41666666666667, 1.18, 0.5
1851, 0.5, 0.22, 0.5
1852, 0.5, 0.34, 0.5
1853, 0.5, 0.46, 0.5
1854, 0.5, 0.58, 0.5
1855, 0.5, 0.7, 0.5
1856, 0.5, 0.82, 0.5
1857, 0.5, 0.94, 0.5
1858, 0.5, 1.06, 0.5
1859, 0.5, 1.18, 0.5
1860, 0.58333333333333, 0.22, 0.5
1861, 0.58333333333333, 0.34, 0.5
1862, 0.58333333333333, 0.46, 0.5
1863, 0.58333333333333, 0.58, 0.5
1864, 0.58333333333333, 0.7, 0.5
1865, 0.58333333333333, 0.82, 0.5
1866, 0.58333333333333, 0.94, 0.5
1867, 0.58333333333333, 1.06, 0.5
1868, 0.58333333333333, 1.18, 0.5
1869, 0.66666666666667, 0.22, 0.5
1870, 0.66666666666667, 0.34, 0.5
1871, 0.66666666666667, 0.46, 0.5
1872, 0.66666666666667, 0.58, 0.5
1873, 0.66666666666667, 0.7, 0.5
1874, 0.66666666666667, 0.82, 0.5
1875, 0.66666666666667, 0.94, 0.5
1876, 0.66666666666667, 1.06, 0.5
1877, 0.66666666666667, 1.18, 0.5
1878, 0.75, 0.22, 0.5
1879, 0.75, 0.34, 0.5
1880, 0.75, 0.46, 0.5
1881, 0.75, 0.58, 0.5
1882, 0.75, 0.7, 0.5
1883, 0.75, 0.82, 0.5
1884, 0.75, 0.94, 0.5
1885, 0.75, 1.06, 0.5
1886, 0.75, 1.18, 0.5
1887, 0.83333333333333, 0.22, 0.5
1888, 0.83333333333333, 0.34, 0.5
1889, 0.83333333333333, 0.46, 0.5
1890, 0.83333333333333, 0.58, 0.5
1891, 0.83333333333333, 0.7, 0.5
1892, 0.83333333333333, 0.82, 0.5
1893, 0.83333333333333, 0.94, 0.5
1894, 0.83333333333333, 1.06, 0.5
1895, 0.83333333333333, 1.18, 0.5
1896, 0.91666666666667, 0.22, 0.5
1897, 0.91666666666667, 0.34, 0.5
1898, 0.91666666666667, 0.46, 0.5
1899, 0.91666666666667, 0.58, 0.5
1900, 0.91666666666667, 0.7, 0.5
1901, 0.91666666666667, 0.82, 0.5
1902, 0.91666666666667, 0.94, 0.5
1903, 0.91666666666667, 1.06, 0.5
1904, 0.91666666666667, 1.18, 0.5
1905, 0, 0.22, 0.05
1906, 0, 0.34, 0.05
1907, 0, 0.46, 0.05
1908, 0, 0.58, 0.05
1909, 0, 0.7, 0.05
1910, 0, 0.82, 0.05
1911, 0, 0.94, 0.05
1912, 0, 1.06, 0.05
1913, 0, 1.18, 0.05
1914, 0, 0.22, 0.1
1915, 0, 0.34, 0.1
1916, 0, 0.46, 0.1
1917, 0, 0.58, 0.1
1918, 0, 0.7, 0.1
1919, 0, 0.82, 0.1
1920, 0, 0.94, 0.1
1921, 0, 1.06, 0.1
1922, 0, 1.18, 0.1
1923, 0, 0.22, 0.15
1924, 0, 0.34, 0.15
1925, 0, 0.46, 0.15
1926, 0, 0.58, 0.15
1927, 0, 0.7, 0.15
1928, 0, 0.82, 0.15
1929, 0, 0.94, 0.15
1930, 0, 1.06, 0.15
1931, 0, 1.18, 0.15
1932, 0, 0.22, 0.2
1933, 0, 0.34, 0.2
1934, 0, 0.46, 0.2
1935, 0, 0.58, 0.2
1936, 0, 0.7, 0.2
1937, 0, 0.82, 0.2
1938, 0, 0.94, 0.2
1939, 0, 1.06, 0.2
1940, 0, 1.18, 0.2
1941, 0, 0.22, 0.25
1942, 0, 0.34, 0.25
1943, 0, 0.46, 0.25
1944, 0, 0.58, 0.25
1945, 0, 0.7, 0.25
1946, 0, 0.82, 0.25
1947, 0, 0.94, 0.25
1948, 0, 1.06, 0.25
1949, 0, 1.18, 0.25
1950, 0, 0.22, 0.3
1951, 0, 0.34, 0.3
1952, 0, 0.46, 0.3
1953, 0, 0.58, 0.3
1954, 0, 0.7, 0.3
1955, 0, 0.82, 0.3
1956, 0, 0.94, 0.3
1957, 0, 1.06, 0.3
1958, 0, 1.18, 0.3
1959, 0, 0.22, 0.35
1960, 0, 0.34, 0.35
1961, 0, 0.46, 0.35
1962, 0, 0.58, 0.35
1963, 0, 0.7, 0.35
1964, 0, 0.82, 0.35
1965, 0, 0.94, 0.35
1966, 0, 1.06, 0.35
1967, 0, 1.18, 0.35
1968, 0, 0.22, 0.4
1969, 0, 0.34, 0.4
1970, 0, 0.46, 0.4
1971, 0, 0.58, 0.4
1972, 0, 0.7, 0.4
1973, 0, 0.82, 0.4
1974, 0, 0.94, 0.4
1975, 0, 1.06, 0.4
1976, 0, 1.18, 0.4
1977, 0, 0.22, 0.45
1978, 0, 0.34, 0.45
1979, 0, 0.46, 0.45
1980, 0, 0.58, 0.45
1981, 0, 0.7, 0.45
1982, 0, 0.82, 0.45
1983, 0, 0.94, 0.45
1984, 0, 1.06, 0.45
1985, 0, 1.18, 0.45
1986, 0.083333333333333, 1.3, 0.05
1987, 0.083333333333333, 1.3, 0.1
1988, 0.083333333333333, 1.3, 0.15
1989, 0.083333333333333, 1.3, 0.2
1990, 0.083333333333333, 1.3, 0.25
1991, 0.083333333333333, 1.3, 0.3
1992, 0.083333333333333, 1.3, 0.35
1993, 0.083333333333333, 1.3, 0.4
1994, 0.083333333333333, 1.3, 0.45
1995, 0.16666666666667, 1.3, 0.05
1996, 0.16666666666667, 1.3, 0.1
1997, 0.16666666666667, 1.3, 0.15
1998, 0.16666666666667, 1.3, 0.2
1999, 0.16666666666667, 1.3, 0.25
2000, 0.16666666666667, 1.3, 0.3
2001, 0.16666666666667, 1.3, 0.35
2002, 0.16666666666667, 1.3, 0.4
2003, 0.16666666666667, 1.3, 0.45
2004, 0.25, 1.3, 0.05
2005, 0.25, 1.3, 0.1
2006, 0.25, 1.3, 0.15
2007, 0.25, 1.3, 0.2
2008, 0.25, 1.3, 0.25
2009, 0.25, 1.3, 0.3
2010, 0.25, 1.3, 0.35
2011, 0.25, 1.3, 0.4
2012, 0.25, 1.3, 0.45
2013, 0.33333333333333, 1.3, 0.05
2014, 0.33333333333333, 1.3, 0.1
2015, 0.33333333333333, 1.3, 0.15
2016, 0.33333333333333, 1.3, 0.2
2017, 0.33333333333333, 1.3, 0.25
2018, 0.33333333333333, 1.3, 0.3
2019, 0.33333333333333, 1.3, 0.35
2020, 0.33333333333333, 1.3, 0.4
2021, 0.33333333333333, 1.3, 0.45
2022, 0.41666666666667, 1.3, 0.05
2023, 0.41666666666667, 1.3, 0.1
2024, 0.41666666666667, 1.3, 0.15
2025, 0.41666666666667, 1.3, 0.2
2026, 0.41666666666667, 1.3, 0.25
2027, 0.41666666666667, 1.3, 0.3
2028, 0.41666666666667, 1.3, 0.35
2029, 0.41666666666667, 1.3, 0.4
2030, 0.41666666666667, 1.3, 0.45
2031, 0.5, 1.3, 0.05
2032, 0.5, 1.3, 0.1
2033, 0.5, 1.3, 0.15
2034, 0.5, 1.3, 0.2
2035, 0.5, 1.3, 0.25
2036, 0.5, 1.3, 0.3
2037, 0.5, 1.3, 0.35
2038, 0.5, 1.3, 0.4
2039, 0.5, 1.3, 0.45
2040, 0.58333333333333, 1.3, 0.05
2041, 0.58333333333333, 1.3, 0.1
2042, 0.58333333333333, 1.3, 0.15
2043, 0.58333333333333, 1.3, 0.2
2044, 0.58333333333333, 1.3, 0.25
2045, 0.58333333333333, 1.3, 0.3
2046, 0.58333333333333, 1.3, 0.35
2047, 0.58333333333333, 1.3, 0.4
2048, 0.58333333333333, 1.3, 0.45
2049, 0.66666666666667, 1.3, 0.05
2050, 0.66666666666667, 1.3, 0.1
2051, 0.66666666666667, 1.3, 0.15
2052, 0.66666666666667, 1.3, 0.2
2053, 0.66666666666667, 1.3, 0.25
2054, 0.66666666666667, 1.3, 0.3
2055, 0.66666666666667, 1.3, 0.35
2056, 0.66666666666667, 1.3, 0.4
2057, 0.66666666666667, 1.3, 0.45
2058, 0.75, 1.3, 0.05
2059, 0.75, 1.3, 0.1
2060, 0.75, 1.3, 0.15
2061, 0.75, 1.3, 0.2
2062, 0.75, 1.3, 0.25
2063, 0.75, 1.3, 0.3
2064, 0.75, 1.3, 0.35
2065, 0.75, 1.3, 0.4
2066, 0.75, 1.3, 0.45
2067, 0.83333333333333, 1.3, 0.05
2068, 0.83333333333333, 1.3, 0.1
2069, 0.83333333333333, 1.3, 0.15
2070, 0.83333333333333, 1.3, 0.2
2071, 0.83333333333333, 1.3, 0.25
2072, 0.83333333333333, 1.3, 0.3
2073, 0.83333333333333, 1.3, 0.35
2074, 0.83333333333333, 1.3, 0.4
2075, 0.83333333333333, 1.3, 0.45
2076, 0.91666666666667, 1.3, 0.05
2077, 0.91666666666667, 1.3, 0.1
2078, 0.91666666666667, 1.3, 0.15
2079, 0.91666666666667, 1.3, 0.2
2080, 0.91666666666667, 1.3, 0.25
2081, 0.91666666666667, 1.3, 0.3
2082, 0.91666666666667, 1.3, 0.35
2083, 0.91666666666667, 1.3, 0.4
2084, 0.91666666666667, 1.3, 0.45
2085, 0.083333333333333, 1.35, 0.05
2086, 0.083333333333333, 1.35, 0.1
2087, 0.083333333333333, 1.35, 0.15
2088, 0.083333333333333, 1.35, 0.2
2089, 0.083333333333333, 1.35, 0.25
2090, 0.083333333333333, 1.35, 0.3
2091, 0.083333333333333, 1.35, 0.35
2092, 0.083333333333333, 1.35, 0.4
2093, 0.083333333333333, 1.35, 0.45
2094, 0.16666666666667, 1.35, 0.05
2095, 0.16666666666667, 1.35, 0.1
2096, 0.16666666666667, 1.35, 0.15
2097, 0.16666666666667, 1.35, 0.2
2098, 0.16666666666667, 1.35, 0.25
2099, 0.16666666666667, 1.35, 0.3
2100, 0.16666666666667, 1.35, 0.35
2101, 0.16666666666667, 1.35, 0.4
2102, 0.16666666666667, 1.35, 0.45
2103, 0.25, 1.35, 0.05
2104, 0.25, 1.35, 0.1
2105, 0.25, 1.35, 0.15
2106, 0.25, 1.35, 0.2
2107, 0.25, 1.35, 0.25
2108, 0.25, 1.35, 0.3
2109, 0.25, 1.35, 0.35
2110, 0.25, 1.35, 0.4
2111, 0.25, 1.35, 0.45
2112, 0.33333333333333, 1.35, 0.05
2113, 0.33333333333333, 1.35, 0.1
2114, 0.33333333333333, 1.35, 0.15
2115, 0.33333333333333, 1.35, 0.2
2116, 0.33333333333333, 1.35, 0.25
2117, 0.33333333333333, 1.35, 0.3
2118, 0.33333333333333, 1.35, 0.35
2119, 0.33333333333333, 1.35, 0.4
2120, 0.33333333333333, 1.35, 0.45
2121, 0.41666666666667, 1.35, 0.05
2122, 0.41666666666667, 1.35, 0.1
2123, 0.41666666666667, 1.35, 0.15
2124, 0.41666666666667, 1.35, 0.2
2125, 0.41666666666667, 1.35, 0.25
2126, 0.41666666666667, 1.35, 0.3
2127, 0.41666666666667, 1.35, 0.35
2128, 0.41666666666667, 1.35, 0.4
2129, 0.41666666666667, 1.35, 0.45
2130, 0.5, 1.35, 0.05
2131, 0.5, 1.35, 0.1
2132, 0.5, 1.35, 0.15
2133, 0.5, 1.35, 0.2
2134, 0.5, 1.35, 0.25
2135, 0.5, 1.35, 0.3
2136, 0.5, 1.35, 0.35
2137, 0.5, 1.35, 0.4
2138, 0.5, 1.35, 0.45
2139, 0.58333333333333, 1.35, 0.05
2140, 0.58333333333333, 1.35, 0.1
2141, 0.58333333333333, 1.35, 0.15
2142, 0.58333333333333, 1.35, 0.2
2143, 0.58333333333333, 1.35, 0.25
2144, 0.58333333333333, 1.35, 0.3
2145, 0.58333333333333, 1.35, 0.35
2146, 0.58333333333333, 1.35, 0.4
2147, 0.58333333333333, 1.35, 0.45
2148, 0.66666666666667, 1.35, 0.05
2149, 0.66666666666667, 1.35, 0.1
2150, 0.66666666666667, 1.35, 0.15
2151, 0.66666666666667, 1.35, 0.2
2152, 0.66666666666667, 1.35, 0.25
2153, 0.66666666666667, 1.35, 0.3
2154, 0.66666666666667, 1.35, 0.35
2155, 0.66666666666667, 1.35, 0.4
2156, 0.66666666666667, 1.35, 0.45
2157, 0.75, 1.35, 0.05
2158, 0.75, 1.35, 0.1
2159, 0.75, 1.35, 0.15
2160, 0.75, 1.35, 0.2
2161, 0.75, 1.35, 0.25
2162, 0.75, 1.35, 0.3
2163, 0.75, 1.35, 0.35
2164, 0.75, 1.35, 0.4
2165, 0.75, 1.35, 0.45
2166, 0.83333333333333, 1.35, 0.05
2167, 0.83333333333333, 1.35, 0.1
2168, 0.83333333333333, 1.35, 0.15
2169, 0.83333333333333, 1.35, 0.2
2170, 0.83333333333333, 1.35, 0.25
2171, 0.83333333333333, 1.35, 0.3
2172, 0.83333333333333, 1.35, 0.35
2173, 0.83333333333333, 1.35, 0.4
2174, 0.83333333333333, 1.35, 0.45
2175, 0.91666666666667, 1.35, 0.05
2176, 0.91666666666667, 1.35, 0.1
2177, 0.91666666666667, 1.35, 0.15
2178, 0.91666666666667, 1.35, 0.2
2179, 0.91666666666667, 1.35, 0.25
2180, 0.91666666666667, 1.35, 0.3
2181, 0.91666666666667, 1.35, 0.35
2182, 0.91666666666667, 1.35, 0.4
2183, 0.91666666666667, 1.35, 0.45
2184, 0.083333333333333, 1.3625, 0
2185, 0.083333333333333, 1.375, 0
2186, 0.083333333333333, 1.3875, 0
2187, 0.16666666666667, 1.3625, 0
2188, 0.16666666666667, 1.375, 0
2189, 0.16666666666667, 1.3875, 0
2190, 0.25, 1.3625, 0
2191, 0.25, 1.375, 0
2192, 0.25, 1.3875, 0
2193, 0.33333333333333, 1.3625, 0
2194, 0.33333333333333, 1.375, 0
2195, 0.33333333333333, 1.3875, 0
2196, 0.41666666666667, 1.3625, 0
2197, 0.41666666666667, 1.375, 0
2198, 0.41666666666667, 1.3875, 0
2199, 0.5, 1.3625, 0
2200, 0.5, 1.375, 0
2201, 0.5, 1.3875, 0
2202, 0.58333333333333, 1.3625, 0
2203, 0.58333333333333, 1.375, 0
2204, 0.58333333333333, 1.3875, 0
2205, 0.66666666666667, 1.3625, 0
2206, 0.66666666666667, 1.375, 0
2207, 0.66666666666667, 1.3875, 0
2208, 0.75, 1.3625, 0
2209, 0.75, 1.375, 0
2210, 0.75, 1.3875, 0
2211, 0.83333333333333, 1.3625, 0
2212, 0.83333333333333, 1.375, 0
2213, 0.83333333333333, 1.3875, 0
2214, 0.91666666666667, 1.3625, 0
2215, 0.91666666666667, 1.375, 0
2216, 0.91666666666667, 1.3875, 0
2217, 1, 1.3625, 0.05
2218, 1, 1.375, 0.05
2219, 1, 1.3875, 0.05
2220, 1, 1.3625, 0.1
2221, 1, 1.375, 0.1
2222, 1, 1.3875, 0.1
2223, 1, 1.3625, 0.15
2224, 1, 1.375, 0.15
2225, 1, 1.3875, 0.15
2226, 1, 1.3625, 0.2
2227, 1, 1.375, 0.2
2228, 1, 1.3875, 0.2
2229, 1, 1.3625, 0.25
2230, 1, 1.375, 0.25
2231, 1, 1.3875, 0.25
2232, 1, 1.3625, 0.3
2233, 1, 1.375, 0.3
2234, 1, 1.3875, 0.3
2235, 1, 1.3625, 0.35
2236, 1, 1.375, 0.35
2237, 1, 1.3875, 0.35
2238, 1, 1.3625, 0.4
2239, 1, 1.375, 0.4
2240, 1, 1.3875, 0.4
2241, 1, 1.3625, 0.45
2242, 1, 1.375, 0.45
2243, 1, 1.3875, 0.45
2244, 0.083333333333333, 1.3625, 0.5
2245, 0.083333333333333, 1.375, 0.5
2246, 0.083333333333333, 1.3875, 0.5
2247, 0.16666666666667, 1.3625, 0.5
2248, 0.16666666666667, 1.375, 0.5
2249, 0.16666666666667, 1.3875, 0.5
2250, 0.25, 1.3625, 0.5
2251, 0.25, 1.375, 0.5
2252, 0.25, 1.3875, 0.5
2253, 0.33333333333333, 1.3625, 0.5
2254, 0.33333333333333, 1.375, 0.5
2255, 0.33333333333333, 1.3875, 0.5
2256, 0.41666666666667, 1.3625, 0.5
2257, 0.41666666666667, 1.375, 0.5
2258, 0.41666666666667, 1.3875, 0.5
2259, 0.5, 1.3625, 0.5
2260, 0.5, 1.375, 0.5
2261, 0.5, 1.3875, 0.5
2262, 0.58333333333333, 1.3625, 0.5
2263, 0.58333333333333, 1.375, 0.5
2264, 0.58333333333333, 1.3875, 0.5
2265, 0.66666666666667, 1.3625, 0.5
2266, 0.66666666666667, 1.375, 0.5
2267, 0.66666666666667, 1.3875, 0.5
2268, 0.75, 1.3625, 0.5
2269, 0.75, 1.375, 0.5
2270, 0.75, 1.3875, 0.5
2271, 0.83333333333333, 1.3625, 0.5
2272, 0.83333333333333, 1.375, 0.5
2273, 0.83333333333333, 1.3875, 0.5
2274, 0.91666666666667, 1.3625, 0.5
2275, 0.91666666666667, 1.375, 0.5
2276, 0.91666666666667, 1.3875, 0.5
2277, 0, 1.3625, 0.05
2278, 0, 1.375, 0.05
2279, 0, 1.3875, 0.05
2280, 0, 1.3625, 0.1
2281, 0, 1.375, 0.1
2282, 0, 1.3875, 0.1
2283, 0, 1.3625, 0.15
2284, 0, 1.375, 0.15
2285, 0, 1.3875, 0.15
2286, 0, 1.3625, 0.2
2287, 0, 1.375, 0.2
2288, 0, 1.3875, 0.2
2289, 0, 1.3625, 0.25
2290, 0, 1.375, 0.25
2291, 0, 1.3875, 0.25
2292, 0, 1.3625, 0.3
2293, 0, 1.375, 0.3
2294, 0, 1.3875, 0.3
2295, 0, 1.3625, 0.35
2296, 0, 1.375, 0.35
2297, 0, 1.3875, 0.35
2298, 0, 1.3625, 0.4
2299, 0, 1.375, 0.4
2300, 0, 1.3875, 0.4
2301, 0, 1.3625, 0.45
2302, 0, 1.375, 0.45
2303, 0, 1.3875, 0.45
2304, 0.083333333333333, 1.4, 0.05
2305, 0.083333333333333, 1.4, 0.1
2306, 0.083333333333333, 1.4, 0.15
2307, 0.083333333333333, 1.4, 0.2
2308, 0.083333333333333, 1.4, 0.25
2309, 0.083333333333333, 1.4, 0.3
2310, 0.083333333333333, 1.4, 0.35
2311, 0.083333333333333, 1.4, 0.4
2312, 0.083333333333333, 1.4, 0.45
2313, 0.16666666666667, 1.4, 0.05
2314, 0.16666666666667, 1.4, 0.1
2315, 0.16666666666667, 1.4, 0.15
2316, 0.16666666666667, 1.4, 0.2
2317, 0.16666666666667, 1.4, 0.25
2318, 0.16666666666667, 1.4, 0.3
2319, 0.16666666666667, 1.4, 0.35
2320, 0.16666666666667, 1.4, 0.4
2321, 0.16666666666667, 1.4, 0.45
2322, 0.25, 1.4, 0.05
2323, 0.25, 1.4, 0.1
2324, 0.25, 1.4, 0.15
2325, 0.25, 1.4, 0.2
2326, 0.25, 1.4, 0.25
2327, 0.25, 1.4, 0.3
2328, 0.25, 1.4, 0.35
2329, 0.25, 1.4, 0.4
2330, 0.25, 1.4, 0.45
2331, 0.33333333333333, 1.4, 0.05
2332, 0.33333333333333, 1.4, 0.1
2333, 0.33333333333333, 1.4, 0.15
2334, 0.33333333333333, 1.4, 0.2
2335, 0.33333333333333, 1.4, 0.25
2336, 0.33333333333333, 1.4, 0.3
2337, 0.33333333333333, 1.4, 0.35
2338, 0.33333333333333, 1.4, 0.4
2339, 0.33333333333333, 1.4, 0.45
2340, 0.41666666666667, 1.4, 0.05
2341, 0.41666666666667, 1.4, 0.1
2342, 0.41666666666667, 1.4, 0.15
2343, 0.41666666666667, 1.4, 0.2
2344, 0.41666666666667, 1.4, 0.25
2345, 0.41666666666667, 1.4, 0.3
2346, 0.41666666666667, 1.4, 0.35
2347, 0.41666666666667, 1.4, 0.4
2348, 0.41666666666667, 1.4, 0.45
2349, 0.5, 1.4, 0.05
2350, 0.5, 1.4, 0.1
2351, 0.5, 1.4, 0.15
2352, 0.5, 1.4, 0.2
2353, 0.5, 1.4, 0.25
2354, 0.5, 1.4, 0.3
2355, 0.5, 1.4, 0.35
2356, 0.5, 1.4, 0.4
2357, 0.5, 1.4, 0.45
2358, 0.58333333333333, 1.4, 0.05
2359, 0.58333333333333, 1.4, 0.1
2360, 0.58333333333333, 1.4, 0.15
2361, 0.58333333333333, 1.4, 0.2
2362, 0.58333333333333, 1.4, 0.25
2363, 0.58333333333333, 1.4, 0.3
2364, 0.58333333333333, 1.4, 0.35
2365, 0.58333333333333, 1.4, 0.4
2366, 0.58333333333333, 1.4, 0.45
2367, 0.66666666666667, 1.4, 0.05
2368, 0.66666666666667, 1.4, 0.1
2369, 0.66666666666667, 1.4, 0.15
2370, 0.66666666666667, 1.4, 0.2
2371, 0.66666666666667, 1.4, 0.25
2372, 0.66666666666667, 1.4, 0.3
2373, 0.66666666666667, 1.4, 0.35
2374, 0.66666666666667, 1.4, 0.4
2375, 0.66666666666667, 1.4, 0.45
2376, 0.75, 1.4, 0.05
2377, 0.75, 1.4, 0.1
2378, 0.75, 1.4, 0.15
2379, 0.75, 1.4, 0.2
2380, 0.75, 1.4, 0.25
2381, 0.75, 1.4, 0.3
2382, 0.75, 1.4, 0.35
2383, 0.75, 1.4, 0.4
2384, 0.75, 1.4, 0.45
2385, 0.83333333333333, 1.4, 0.05
2386, 0.83333333333333, 1.4, 0.1
2387, 0.83333333333333, 1.4, 0.15
2388, 0.83333333333333, 1.4, 0.2
2389, 0.83333333333333, 1.4, 0.25
2390, 0.83333333333333, 1.4, 0.3
2391, 0.83333333333333, 1.4, 0.35
2392, 0.83333333333333, 1.4, 0.4
2393, 0.83333333333333, 1.4, 0.45
2394, 0.91666666666667, 1.4, 0.05
2395, 0.91666666666667, 1.4, 0.1
2396, 0.91666666666667, 1.4, 0.15
2397, 0.91666666666667, 1.4, 0.2
2398, 0.91666666666667, 1.4, 0.25
2399, 0.91666666666667, 1.4, 0.3
2400, 0.91666666666667, 1.4, 0.35
2401, 0.91666666666667, 1.4, 0.4
2402, 0.91666666666667, 1.4, 0.45
2403, 1.0285714285714, 1.3625, 0.5
2404, 1.0571428571429, 1.3625, 0.5
2405, 1.0857142857143, 1.3625, 0.5
2406, 1.1142857142857, 1.3625, 0.5
2407, 1.1428571428571, 1.3625, 0.5
2408, 1.1714285714286, 1.3625, 0.5
2409, 1.0285714285714, 1.375, 0.5
2410, 1.0571428571429, 1.375, 0.5
2411, 1.0857142857143, 1.375, 0.5
2412, 1.1142857142857, 1.375, 0.5
2413, 1.1428571428571, 1.375, 0.5
2414, 1.1714285714286, 1.375, 0.5
2415, 1.0285714285714, 1.3875, 0.5
2416, 1.0571428571429, 1.3875, 0.5
2417, 1.0857142857143, 1.3875, 0.5
2418, 1.1142857142857, 1.3875, 0.5
2419, 1.1428571428571, 1.3875, 0.5
2420, 1.1714285714286, 1.3875, 0.5
2421, 1.0285714285714, 1.3625, 0
2422, 1.0571428571429, 1.3625, 0
2423, 1.0857142857143, 1.3625, 0
2424, 1.1142857142857, 1.3625, 0
2425, 1.1428571428571, 1.3625, 0
2426, 1.1714285714286, 1.3625, 0
2427, 1.0285714285714, 1.375, 0
2428, 1.0571428571429, 1.375, 0
2429, 1.0857142857143, 1.375, 0
2430, 1.1142857142857, 1.375, 0
2431, 1.1428571428571, 1.375, 0
2432, 1.1714285714286, 1.375, 0
2433, 1.0285714285714, 1.3875, 0
2434, 1.0571428571429, 1.3875, 0
2435, 1.0857142857143, 1.3875, 0
2436, 1.1142857142857, 1.3875, 0
2437, 1.1428571428571, 1.3875, 0
2438, 1.1714285714286, 1.3875, 0
2439, 1.0285714285714, 1.35, 0.05
2440, 1.0571428571429, 1.35, 0.05
2441, 1.0857142857143, 1.35, 0.05
2442, 1.1142857142857, 1.35, 0.05
2443, 1.1428571428571, 1.35, 0.05
2444, 1.1714285714286, 1.35, 0.05
2445, 1.0285714285714, 1.35, 0.1
2446, 1.0571428571429, 1.35, 0.1
2447, 1.0857142857143, 1.35, 0.1
2448, 1.1142857142857, 1.35, 0.1
2449, 1.1428571428571, 1.35, 0.1
2450, 1.1714285714286, 1.35, 0.1
2451, 1.0285714285714, 1.35, 0.15
2452, 1.0571428571429, 1.35, 0.15
2453, 1.0857142857143, 1.35, 0.15
2454, 1.1142857142857, 1.35, 0.15
2455, 1.1428571428571, 1.35, 0.15
2456, 1.1714285714286, 1.35, 0.15
2457, 1.0285714285714, 1.35, 0.2
2458, 1.0571428571429, 1.35, 0.2
2459, 1.0857142857143, 1.35, 0.2
2460, 1.1142857142857, 1.35, 0.2
2461, 1.1428571428571, 1.35, 0.2
2462, 1.1714285714286, 1.35, 0.2
2463, 1.0285714285714, 1.35, 0.25
2464, 1.0571428571429, 1.35, 0.25
2465, 1.0857142857143, 1.35, 0.25
2466, 1.1142857142857, 1.35, 0.25
2467, 1.1428571428571, 1.35, 0.25
2468, 1.1714285714286, 1.35, 0.25
2469, 1.0285714285714, 1.35, 0.3
2470, 1.0571428571429, 1.35, 0.3
2471, 1.0857142857143, 1.35, 0.3
2472, 1.1142857142857, 1.35, 0.3
2473, 1.1428571428571, 1.35, 0.3
2474, 1.1714285714286, 1.35, 0.3
2475, 1.0285714285714, 1.35, 0.35
2476, 1.0571428571429, 1.35, 0.35
2477, 1.0857142857143, 1.35, 0.35
2478, 1.1142857142857, 1.35, 0.35
2479, 1.1428571428571, 1.35, 0.35
2480, 1.1714285714286, 1.35, 0.35
2481, 1.0285714285714, 1.35, 0.4
2482, 1.0571428571429, 1.35, 0.4
2483, 1.0857142857143, 1.35, 0.4
2484, 1.1142857142857, 1.35, 0.4
2485, 1.1428571428571, 1.35, 0.4
2486, 1.1714285714286, 1.35, 0.4
2487, 1.0285714285714, 1.35, 0.45
2488, 1.0571428571429, 1.35, 0.45
2489, 1.0857142857143, 1.35, 0.45
2490, 1.1142857142857, 1.35, 0.45
2491, 1.1428571428571, 1.35, 0.45
2492, 1.1714285714286, 1.35, 0.45
2493, 1.0285714285714, 1.4, 0.05
2494, 1.0571428571429, 1.4, 0.05
2495, 1.0857142857143, 1.4, 0.05
2496, 1.1142857142857, 1.4, 0.05
2497, 1.1428571428571, 1.4, 0.05
2498, 1.1714285714286, 1.4, 0.05
2499, 1.0285714285714, 1.4, 0.1
2500, 1.0571428571429, 1.4, 0.1
2501, 1.0857142857143, 1.4, 0.1
2502, 1.1142857142857, 1.4, 0.1
2503, 1.1428571428571, 1.4, 0.1
2504, 1.1714285714286, 1.4, 0.1
2505, 1.0285714285714, 1.4, 0.15
2506, 1.0571428571429, 1.4, 0.15
2507, 1.0857142857143, 1.4, 0.15
2508, 1.1142857142857, 1.4, 0.15
2509, 1.1428571428571, 1.4, 0.15
2510, 1.1714285714286, 1.4, 0.15
2511, 1.0285714285714, 1.4, 0.2
2512, 1.0571428571429, 1.4, 0.2
2513, 1.0857142857143, 1.4, 0.2
2514, 1.1142857142857, 1.4, 0.2
2515, 1.1428571428571, 1.4, 0.2
2516, 1.1714285714286, 1.4, 0.2
2517, 1.0285714285714, 1.4, 0.25
2518, 1.0571428571429, 1.4, 0.25
2519, 1.0857142857143, 1.4, 0.25
2520, 1.1142857142857, 1.4, 0.25
2521, 1.1428571428571, 1.4, 0.25
2522, 1.1714285714286, 1.4, 0.25
2523, 1.0285714285714, 1.4, 0.3
2524, 1.0571428571429, 1.4, 0.3
2525, 1.0857142857143, 1.4, 0.3
2526, 1.1142857142857, 1.4, 0.3
2527, 1.1428571428571, 1.4, 0.3
2528, 1.1714285714286, 1.4, 0.3
2529, 1.0285714285714, 1.4, 0.35
2530, 1.0571428571429, 1.4, 0.35
2531, 1.0857142857143, 1.4, 0.35
2532, 1.1142857142857, 1.4, 0.35
2533, 1.1428571428571, 1.4, 0.35
2534, 1.1714285714286, 1.4, 0.35
2535, 1.0285714285714, 1.4, 0.4
2536, 1.0571428571429, 1.4, 0.4
2537, 1.0857142857143, 1.4, 0.4
2538, 1.1142857142857, 1.4, 0.4
2539, 1.1428571428571, 1.4, 0.4
2540, 1.1714285714286, 1.4, 0.4
2541, 1.0285714285714, 1.4, 0.45
2542, 1.0571428571429, 1.4, 0.45
2543, 1.0857142857143, 1.4, 0.45
2544, 1.1142857142857, 1.4, 0.45
2545, 1.1428571428571, 1.4, 0.45
2546, 1.1714285714286, 1.4, 0.45
2547, 1.2, 1.3625, 0.05
2548, 1.2, 1.375, 0.05
2549, 1.2, 1.3875, 0.05
2550, 1.2, 1.3625, 0.1
2551, 1.2, 1.375, 0.1
2552, 1.2, 1.3875, 0.1
2553, 1.2, 1.3625, 0.15
2554, 1.2, 1.375, 0.15
2555, 1.2, 1.3875, 0.15
2556, 1.2, 1.3625, 0.2
2557, 1.2, 1.375, 0.2
2558, 1.2, 1.3875, 0.2
2559, 1.2, 1.3625, 0.25
2560, 1.2, 1.375, 0.25
2561, 1.2, 1.3875, 0.25
2562, 1.2, 1.3625, 0.3
2563, 1.2, 1.375, 0.3
2564, 1.2, 1.3875, 0.3
2565, 1.2, 1.3625, 0.35
2566, 1.2, 1.375, 0.35
2567, 1.2, 1.3875, 0.35
2568, 1.2, 1.3625, 0.4
2569, 1.2, 1.375, 0.4
2570, 1.2, 1.3875, 0.4
2571, 1.2, 1.3625, 0.45
2572, 1.2, 1.375, 0.45
2573, 1.2, 1.3875, 0.45
2574, 1.2833333333333, 1.3625, 0.5
2575, 1.3666666666667, 1.3625, 0.5
2576, 1.45, 1.3625, 0.5
2577, 1.5333333333333, 1.3625, 0.5
2578, 1.6166666666667, 1.3625, 0.5
2579, 1.7, 1.3625, 0.5
2580, 1.7833333333333, 1.3625, 0.5
2581, 1.8666666666667, 1.3625, 0.5
2582, 1.95, 1.3625, 0.5
2583, 2.0333333333333, 1.3625, 0.5
2584, 2.1166666666667, 1.3625, 0.5
2585, 1.2833333333333, 1.375, 0.5
2586, 1.3666666666667, 1.375, 0.5
2587, 1.45, 1.375, 0.5
2588, 1.5333333333333, 1.375, 0.5
2589, 1.6166666666667, 1.375, 0.5
2590, 1.7, 1.375, 0.5
2591, 1.7833333333333, 1.375, 0.5
2592, 1.8666666666667, 1.375, 0.5
2593, 1.95, 1.375, 0.5
2594, 2.0333333333333, 1.375, 0.5
2595, 2.1166666666667, 1.375, 0.5
2596, 1.2833333333333, 1.3875, 0.5
2597, 1.3666666666667, 1.3875, 0.5
2598, 1.45, 1.3875, 0.5
2599, 1.5333333333333, 1.3875, 0.5
2600, 1.6166666666667, 1.3875, 0.5
2601, 1.7, 1.3875, 0.5
2602, 1.7833333333333, 1.3875, 0.5
2603, 1.8666666666667, 1.3875, 0.5
2604, 1.95, 1.3875, 0.5
2605, 2.0333333333333, 1.3875, 0.5
2606, 2.1166666666667, 1.3875, 0.5
2607, 1.2833333333333, 1.3625, 0
2608, 1.3666666666667, 1.3625, 0
2609, 1.45, 1.3625, 0
2610, 1.5333333333333, 1.3625, 0
2611, 1.6166666666667, 1.3625, 0
2612, 1.7, 1.3625, 0
2613, 1.7833333333333, 1.3625, 0
2614, 1.8666666666667, 1.3625, 0
2615, 1.95, 1.3625, 0
2616, 2.0333333333333, 1.3625, 0
2617, 2.1166666666667, 1.3625, 0
2618, 1.2833333333333, 1.375, 0
2619, 1.3666666666667, 1.375, 0
2620, 1.45, 1.375, 0
2621, 1.5333333333333, 1.375, 0
2622, 1.6166666666667, 1.375, 0
2623, 1.7, 1.375, 0
2624, 1.7833333333333, 1.375, 0
2625, 1.8666666666667, 1.375, 0
2626, 1.95, 1.375, 0
2627, 2.0333333333333, 1.375, 0
2628, 2.1166666666667, 1.375, 0
2629, 1.2833333333333, 1.3875, 0
2630, 1.3666666666667, 1.3875, 0
2631, 1.45, 1.3875, 0
2632, 1.5333333333333, 1.3875, 0
2633, 1.6166666666667, 1.3875, 0
2634, 1.7, 1.3875, 0
2635, 1.7833333333333, 1.3875, 0
2636, 1.8666666666667, 1.3875, 0
2637, 1.95, 1.3875, 0
2638, 2.0333333333333, 1.3875, 0
2639, 2.1166666666667, 1.3875, 0
2640, 1.2833333333333, 1.35, 0.05
2641, 1.3666666666667, 1.35, 0.05
2642, 1.45, 1.35, 0.05
2643, 1.5333333333333, 1.35, 0.05
2644, 1.6166666666667, 1.35, 0.05
2645, 1.7, 1.35, 0.05
2646, 1.7833333333333, 1.35, 0.05
2647, 1.8666666666667, 1.35, 0.05
2648, 1.95, 1.35, 0.05
2649, 2.0333333333333, 1.35, 0.05
2650, 2.1166666666667, 1.35, 0.05
2651, 1.2833333333333, 1.35, 0.1
2652, 1.3666666666667, 1.35, 0.1
2653, 1.45, 1.35, 0.1
2654, 1.5333333333333, 1.35, 0.1
2655, 1.6166666666667, 1.35, 0.1
2656, 1.7, 1.35, 0.1
2657, 1.7833333333333, 1.35, 0.1
2658, 1.8666666666667, 1.35, 0.1
2659, 1.95, 1.35, 0.1
2660, 2.0333333333333, 1.35, 0.1
2661, 2.1166666666667, 1.35, 0.1
2662, 1.2833333333333, 1.35, 0.15
2663, 1.3666666666667, 1.35, 0.15
2664, 1.45, 1.35, 0.15
2665, 1.5333333333333, 1.35, 0.15
2666, 1.6166666666667, 1.35, 0.15
2667, 1.7, 1.35, 0.15
2668, 1.7833333333333, 1.35, 0.15
2669, 1.8666666666667, 1.35, 0.15
2670, 1.95, 1.35, 0.15
2671, 2.0333333333333, 1.35, 0.15
2672, 2.1166666666667, 1.35, 0.15
2673, 1.2833333333333, 1.35, 0.2
2674, 1.3666666666667, 1.35, 0.2
2675, 1.45, 1.35, 0.2
2676, 1.5333333333333, 1.35, 0.2
2677, 1.6166666666667, 1.35, 0.2
2678, 1.7, 1.35, 0.2
2679, 1.7833333333333, 1.35, 0.2
2680, 1.8666666666667, 1.35, 0.2
2681, 1.95, 1.35, 0.2
2682, 2.0333333333333, 1.35, 0.2
2683, 2.1166666666667, 1.35, 0.2
2684, 1.2833333333333, 1.35, 0.25
2685, 1.3666666666667, 1.35, 0.25
2686, 1.45, 1.35, 0.25
2687, 1.5333333333333, 1.35, 0.25
2688, 1.6166666666667, 1.35, 0.25
2689, 1.7, 1.35, 0.25
2690, 1.7833333333333, 1.35, 0.25
2691, 1.8666666666667, 1.35, 0.25
2692, 1.95, 1.35, 0.25
2693, 2.0333333333333, 1.35, 0.25
2694, 2.1166666666667, 1.35, 0.25
2695, 1.2833333333333, 1.35, 0.3
2696, 1.3666666666667, 1.35, 0.3
2697, 1.45, 1.35, 0.3
2698, 1.5333333333333, 1.35, 0.3
2699, 1.6166666666667, 1.35, 0.3
2700, 1.7, 1.35, 0.3
2701, 1.7833333333333, 1.35, 0.3
2702, 1.8666666666667, 1.35, 0.3
2703, 1.95, 1.35, 0.3
2704, 2.0333333333333, 1.35, 0.3
2705, 2.1166666666667, 1.35, 0.3
2706, 1.2833333333333, 1.35, 0.35
2707, 1.3666666666667, 1.35, 0.35
2708, 1.45, 1.35, 0.35
2709, 1.5333333333333, 1.35, 0.35
2710, 1.6166666666667, 1.35, 0.35
2711, 1.7, 1.35, 0.35
2712, 1.7833333333333, 1.35, 0.35
2713, 1.8666666666667, 1.35, 0.35
2714, 1.95, 1.35, 0.35
2715, 2.0333333333333, 1.35, 0.35
2716, 2.1166666666667, 1.35, 0.35
2717, 1.2833333333333, 1.35, 0.4
2718, 1.3666666666667, 1.35, 0.4
2719, 1.45, 1.35, 0.4
2720, 1.5333333333333, 1.35, 0.4
2721, 1.6166666666667, 1.35, 0.4
2722, 1.7, 1.35, 0.4
2723, 1.7833333333333, 1.35, 0.4
2724, 1.8666666666667, 1.35, 0.4
2725, 1.95, 1.35, 0.4
2726, 2.0333333333333, 1.35, 0.4
2727, 2.1166666666667, 1.35, 0.4
2728, 1.2833333333333, 1.35, 0.45
2729, 1.3666666666667, 1.35, 0.45
2730, 1.45, 1.35, 0.45
2731, 1.5333333333333, 1.35, 0.45
2732, 1.6166666666667, 1.35, 0.45
2733, 1.7, 1.35, 0.45
2734, 1.7833333333333, 1.35, 0.45
2735, 1.8666666666667, 1.35, 0.45
2736, 1.95, 1.35, 0.45
2737, 2.0333333333333, 1.35, 0.45
2738, 2.1166666666667, 1.35, 0.45
2739, 1.2833333333333, 1.4, 0.05
2740, 1.3666666666667, 1.4, 0.05
2741, 1.45, 1.4, 0.05
2742, 1.5333333333333, 1.4, 0.05
2743, 1.6166666666667, 1.4, 0.05
2744, 1.7, 1.4, 0.05
2745, 1.7833333333333, 1.4, 0.05
2746, 1.8666666666667, 1.4, 0.05
2747, 1.95, 1.4, 0.05
2748, 2.0333333333333, 1.4, 0.05
2749, 2.1166666666667, 1.4, 0.05
2750, 1.2833333333333, 1.4, 0.1
2751, 1.3666666666667, 1.4, 0.1
2752, 1.45, 1.4, 0.1
2753, 1.5333333333333, 1.4, 0.1
2754, 1.6166666666667, 1.4, 0.1
2755, 1.7, 1.4, 0.1
2756, 1.7833333333333, 1.4, 0.1
2757, 1.8666666666667, 1.4, 0.1
2758, 1.95, 1.4, 0.1
2759, 2.0333333333333, 1.4, 0.1
2760, 2.1166666666667, 1.4, 0.1
2761, 1.2833333333333, 1.4, 0.15
2762, 1.3666666666667, 1.4, 0.15
2763, 1.45, 1.4, 0.15
2764, 1.5333333333333, 1.4, 0.15
2765, 1.6166666666667, 1.4, 0.15
2766, 1.7, 1.4, 0.15
2767, 1.7833333333333, 1.4, 0.15
2768, 1.8666666666667, 1.4, 0.15
2769, 1.95, 1.4, 0.15
2770, 2.0333333333333, 1.4, 0.15
2771, 2.1166666666667, 1.4, 0.15
2772, 1.2833333333333, 1.4, 0.2
2773, 1.3666666666667, 1.4, 0.2
2774, 1.45, 1.4, 0.2
2775, 1.5333333333333, 1.4, 0.2
2776, 1.6166666666667, 1.4, 0.2
2777, 1.7, 1.4, 0.2
2778, 1.7833333333333, 1.4, 0.2
2779, 1.8666666666667, 1.4, 0.2
2780, 1.95, 1.4, 0.2
2781, 2.0333333333333, 1.4, 0.2
2782, 2.1166666666667, 1.4, 0.2
2783, 1.2833333333333, 1.4, 0.25
2784, 1.3666666666667, 1.4, 0.25
2785, 1.45, 1.4, 0.25
2786, 1.5333333333333, 1.4, 0.25
2787, 1.6166666666667, 1.4, 0.25
2788, 1.7, 1.4, 0.25
2789, 1.7833333333333, 1.4, 0.25
2790, 1.8666666666667, 1.4, 0.25
2791, 1.95, 1.4, 0.25
2792, 2.0333333333333, 1.4, 0.25
2793, 2.1166666666667, 1.4, 0.25
2794, 1.2833333333333, 1.4, 0.3
2795, 1.3666666666667, 1.4, 0.3
2796, 1.45, 1.4, 0.3
2797, 1.5333333333333, 1.4, 0.3
2798, 1.6166666666667, 1.4, 0.3
2799, 1.7, 1.4, 0.3
2800, 1.7833333333333, 1.4, 0.3
2801, 1.8666666666667, 1.4, 0.3
2802, 1.95, 1.4, 0.3
2803, 2.0333333333333, 1.4, 0.3
2804, 2.1166666666667, 1.4, 0.3
2805, 1.2833333333333, 1.4, 0.35
2806, 1.3666666666667, 1.4, 0.35
2807, 1.45, 1.4, 0.35
2808, 1.5333333333333, 1.4, 0.35
2809, 1.6166666666667, 1.4, 0.35
2810, 1.7, 1.4, 0.35
2811, 1.7833333333333, 1.4, 0.35
2812, 1.8666666666667, 1.4, 0.35
2813, 1.95, 1.4, 0.35
2814, 2.0333333333333, 1.4, 0.35
2815, 2.1166666666667, 1.4, 0.35
2816, 1.2833333333333, 1.4, 0.4
2817, 1.3666666666667, 1.4, 0.4
2818, 1.45, 1.4, 0.4
2819, 1.5333333333333, 1.4, 0.4
2820, 1.6166666666667, 1.4, 0.4
2821, 1.7, 1.4, 0.4
2822, 1.7833333333333, 1.4, 0.4
2823, 1.8666666666667, 1.4, 0.4
2824, 1.95, 1.4, 0.4
2825, 2.0333333333333, 1.4, 0.4
2826, 2.1166666666667, 1.4, 0.4
2827, 1.2833333333333, 1.4, 0.45
2828, 1.3666666666667, 1.4, 0.45
2829, 1.45, 1.4, 0.45
2830, 1.5333333333333, 1.4, 0.45
2831, 1.6166666666667, 1.4, 0.45
2832, 1.7, 1.4, 0.45
2833, 1.7833333333333, 1.4, 0.45
2834, 1.8666666666667, 1.4, 0.45
2835, 1.95, 1.4, 0.45
2836, 2.0333333333333, 1.4, 0.45
2837, 2.1166666666667, 1.4, 0.45
2838, 2.2, 1.3625, 0.05
2839, 2.2, 1.375, 0.05
2840, 2.2, 1.3875, 0.05
2841, 2.2, 1.3625, 0.1
2842, 2.2, 1.375, 0.1
2843, 2.2, 1.3875, 0.1
2844, 2.2, 1.3625, 0.15
2845, 2.2, 1.375, 0.15
2846, 2.2, 1.3875, 0.15
2847, 2.2, 1.3625, 0.2
2848, 2.2, 1.375, 0.2
2849, 2.2, 1.3875, 0.2
2850, 2.2, 1.3625, 0.25
2851, 2.2, 1.375, 0.25
2852, 2.2, 1.3875, 0.25
2853, 2.2, 1.3625, 0.3
2854, 2.2, 1.375, 0.3
2855, 2.2, 1.3875, 0.3
2856, 2.2, 1.3625, 0.35
2857, 2.2, 1.375, 0.35
2858, 2.2, 1.3875, 0.35
2859, 2.2, 1.3625, 0.4
2860, 2.2, 1.375, 0.4
2861, 2.2, 1.3875, 0.4
2862, 2.2, 1.3625, 0.45
2863, 2.2, 1.375, 0.45
2864, 2.2, 1.3875, 0.45
2865, 1.2833333333333, 1.3, 0.05
2866, 1.3666666666667, 1.3, 0.05
2867, 1.45, 1.3, 0.05
2868, 1.5333333333333, 1.3, 0.05
2869, 1.6166666666667, 1.3, 0.05
2870, 1.7, 1.3, 0.05
2871, 1.7833333333333, 1.3, 0.05
2872, 1.8666666666667, 1.3, 0.05
2873, 1.95, 1.3, 0.05
2874, 2.0333333333333, 1.3, 0.05
2875, 2.1166666666667, 1.3, 0.05
2876, 1.2833333333333, 1.3, 0.1
2877, 1.3666666666667, 1.3, 0.1
2878, 1.45, 1.3, 0.1
2879, 1.5333333333333, 1.3, 0.1
2880, 1.6166666666667, 1.3, 0.1
2881, 1.7, 1.3, 0.1
2882, 1.7833333333333, 1.3, 0.1
2883, 1.8666666666667, 1.3, 0.1
2884, 1.95, 1.3, 0.1
2885, 2.0333333333333, 1.3, 0.1
2886, 2.1166666666667, 1.3, 0.1
2887, 1.2833333333333, 1.3, 0.15
2888, 1.3666666666667, 1.3, 0.15
2889, 1.45, 1.3, 0.15
2890, 1.5333333333333, 1.3, 0.15
2891, 1.6166666666667, 1.3, 0.15
2892, 1.7, 1.3, 0.15
2893, 1.7833333333333, 1.3, 0.15
2894, 1.8666666666667, 1.3, 0.15
2895, 1.95, 1.3, 0.15
2896, 2.0333333333333, 1.3, 0.15
2897, 2.1166666666667, 1.3, 0.15
2898, 1.2833333333333, 1.3, 0.2
2899, 1.3666666666667, 1.3, 0.2
2900, 1.45, 1.3, 0.2
2901, 1.5333333333333, 1.3, 0.2
2902, 1.6166666666667, 1.3, 0.2
2903, 1.7, 1.3, 0.2
2904, 1.7833333333333, 1.3, 0.2
2905, 1.8666666666667, 1.3, 0.2
2906, 1.95, 1.3, 0.2
2907, 2.0333333333333, 1.3, 0.2
2908, 2.1166666666667, 1.3, 0.2
2909, 1.2833333333333, 1.3, 0.25
2910, 1.3666666666667, 1.3, 0.25
2911, 1.45, 1.3, 0.25
2912, 1.5333333333333, 1.3, 0.25
2913, 1.6166666666667, 1.3, 0.25
2914, 1.7, 1.3, 0.25
2915, 1.7833333333333, 1.3, 0.25
2916, 1.8666666666667, 1.3, 0.25
2917, 1.95, 1.3, 0.25
2918, 2.0333333333333, 1.3, 0.25
2919, 2.1166666666667, 1.3, 0.25
2920, 1.2833333333333, 1.3, 0.3
2921, 1.3666666666667, 1.3, 0.3
2922, 1.45, 1.3, 0.3
2923, 1.5333333333333, 1.3, 0.3
2924, 1.6166666666667, 1.3, 0.3
2925, 1.7, 1.3, 0.3
2926, 1.7833333333333, 1.3, 0.3
2927, 1.8666666666667, 1.3, 0.3
2928, 1.95, 1.3, 0.3
2929, 2.0333333333333, 1.3, 0.3
2930, 2.1166666666667, 1.3, 0.3
2931, 1.2833333333333, 1.3, 0.35
2932, 1.3666666666667, 1.3, 0.35
2933, 1.45, 1.3, 0.35
2934, 1.5333333333333, 1.3, 0.35
2935, 1.6166666666667, 1.3, 0.35
2936, 1.7, 1.3, 0.35
2937, 1.7833333333333, 1.3, 0.35
2938, 1.8666666666667, 1.3, 0.35
2939, 1.95, 1.3, 0.35
2940, 2.0333333333333, 1.3, 0.35
2941, 2.1166666666667, 1.3, 0.35
2942, 1.2833333333333, 1.3, 0.4
2943, 1.3666666666667, 1.3, 0.4
2944, 1.45, 1.3, 0.4
2945, 1.5333333333333, 1.3, 0.4
2946, 1.6166666666667, 1.3, 0.4
2947, 1.7, 1.3, 0.4
2948, 1.7833333333333, 1.3, 0.4
2949, 1.8666666666667, 1.3, 0.4
2950, 1.95, 1.3, 0.4
2951, 2.0333333333333, 1.3, 0.4
2952, 2.1166666666667, 1.3, 0.4
2953, 1.2833333333333, 1.3, 0.45
2954, 1.3666666666667, 1.3, 0.45
2955, 1.45, 1.3, 0.45
2956, 1.5333333333333, 1.3, 0.45
2957, 1.6166666666667, 1.3, 0.45
2958, 1.7, 1.3, 0.45
2959, 1.7833333333333, 1.3, 0.45
2960, 1.8666666666667, 1.3, 0.45
2961, 1.95, 1.3, 0.45
2962, 2.0333333333333, 1.3, 0.45
2963, 2.1166666666667, 1.3, 0.45
2964, 1.2833333333333, 1.18, 0.5
2965, 1.2833333333333, 1.06, 0.5
2966, 1.2833333333333, 0.94, 0.5
2967, 1.2833333333333, 0.82, 0.5
2968, 1.2833333333333, 0.7, 0.5
2969, 1.2833333333333, 0.58, 0.5
2970, 1.2833333333333, 0.46, 0.5
2971, 1.2833333333333, 0.34, 0.5
2972, 1.2833333333333, 0.22, 0.5
2973, 1.3666666666667, 1.18, 0.5
2974, 1.3666666666667, 1.06, 0.5
2975, 1.3666666666667, 0.94, 0.5
2976, 1.3666666666667, 0.82, 0.5
2977, 1.3666666666667, 0.7, 0.5
2978, 1.3666666666667, 0.58, 0.5
2979, 1.3666666666667, 0.46, 0.5
2980, 1.3666666666667, 0.34, 0.5
2981, 1.3666666666667, 0.22, 0.5
2982, 1.45, 1.18, 0.5
2983, 1.45, 1.06, 0.5
2984, 1.45, 0.94, 0.5
2985, 1.45, 0.82, 0.5
2986, 1.45, 0.7, 0.5
2987, 1.45, 0.58, 0.5
2988, 1.45, 0.46, 0.5
2989, 1.45, 0.34, 0.5
2990, 1.45, 0.22, 0.5
2991, 1.5333333333333, 1.18, 0.5
2992, 1.5333333333333, 1.06, 0.5
2993, 1.5333333333333, 0.94, 0.5
2994, 1.5333333333333, 0.82, 0.5
2995, 1.5333333333333, 0.7, 0.5
2996, 1.5333333333333, 0.58, 0.5
2997, 1.5333333333333, 0.46, 0.5
2998, 1.5333333333333, 0.34, 0.5
2999, 1.5333333333333, 0.22, 0.5
3000, 1.6166666666667, 1.18, 0.5
3001, 1.6166666666667, 1.06, 0.5
3002, 1.6166666666667, 0.94, 0.5
3003, 1.6166666666667, 0.82, 0.5
3004, 1.6166666666667, 0.7, 0.5
3005, 1.6166666666667, 0.58, 0.5
3006, 1.6166666666667, 0.46, 0.5
3007, 1.6166666666667, 0.34, 0.5
3008, 1.6166666666667, 0.22, 0.5
3009, 1.7, 1.18, 0.5
3010, 1.7, 1.06, 0.5
3011, 1.7, 0.94, 0.5
3012, 1.7, 0.82, 0.5
3013, 1.7, 0.7, 0.5
3014, 1.7, 0.58, 0.5
3015, 1.7, 0.46, 0.5
3016, 1.7, 0.34, 0.5
3017, 1.7, 0.22, 0.5
3018, 1.7833333333333, 1.18, 0.5
3019, 1.7833333333333, 1.06, 0.5
3020, 1.7833333333333, 0.94, 0.5
3021, 1.7833333333333, 0.82, 0.5
3022, 1.7833333333333, 0.7, 0.5
3023, 1.7833333333333, 0.58, 0.5
3024, 1.7833333333333, 0.46, 0.5
3025, 1.7833333333333, 0.34, 0.5
3026, 1.7833333333333, 0.22, 0.5
3027, 1.8666666666667, 1.18, 0.5
3028, 1.8666666666667, 1.06, 0.5
3029, 1.8666666666667, 0.94, 0.5
3030, 1.8666666666667, 0.82, 0.5
3031, 1.8666666666667, 0.7, 0.5
3032, 1.8666666666667, 0.58, 0.5
3033, 1.8666666666667, 0.46, 0.5
3034, 1.8666666666667, 0.34, 0.5
3035, 1.8666666666667, 0.22, 0.5
3036, 1.95, 1.18, 0.5
3037, 1.95, 1.06, 0.5
3038, 1.95, 0.94, 0.5
3039, 1.95, 0.82, 0.5
3040, 1.95, 0.7, 0.5
3041, 1.95, 0.58, 0.5
3042, 1.95, 0.46, 0.5
3043, 1.95, 0.34, 0.5
3044, 1.95, 0.22, 0.5
3045, 2.0333333333333, 1.18, 0.5
3046, 2.0333333333333, 1.06, 0.5
3047, 2.0333333333333, 0.94, 0.5
3048, 2.0333333333333, 0.82, 0.5
3049, 2.0333333333333, 0.7, 0.5
3050, 2.0333333333333, 0.58, 0.5
3051, 2.0333333333333, 0.46, 0.5
3052, 2.0333333333333, 0.34, 0.5
3053, 2.0333333333333, 0.22, 0.5
3054, 2.1166666666667, 1.18, 0.5
3055, 2.1166666666667, 1.06, 0.5
3056, 2.1166666666667, 0.94, 0.5
3057, 2.1166666666667, 0.82, 0.5
3058, 2.1166666666667, 0.7, 0.5
3059, 2.1166666666667, 0.58, 0.5
3060, 2.1166666666667, 0.46, 0.5
3061, 2.1166666666667, 0.34, 0.5
3062, 2.1166666666667, 0.22, 0.5
3063, 1.2833333333333, 1.18, 0
3064, 1.2833333333333, 1.06, 0
3065, 1.2833333333333, 0.94, 0
3066, 1.2833333333333, 0.82, 0
3067, 1.2833333333333, 0.7, 0
3068, 1.2833333333333, 0.58, 0
3069, 1.2833333333333, 0.46, 0
3070, 1.2833333333333, 0.34, 0
3071, 1.2833333333333, 0.22, 0
3072, 1.3666666666667, 1.18, 0
3073, 1.3666666666667, 1.06, 0
3074, 1.3666666666667, 0.94, 0
3075, 1.3666666666667, 0.82, 0
3076, 1.3666666666667, 0.7, 0
3077, 1.3666666666667, 0.58, 0
3078, 1.3666666666667, 0.46, 0
3079, 1.3666666666667, 0.34, 0
3080, 1.3666666666667, 0.22, 0
3081, 1.45, 1.18, 0
3082, 1.45, 1.06, 0
3083, 1.45, 0.94, 0
3084, 1.45, 0.82, 0
3085, 1.45, 0.7, 0
3086, 1.45, 0.58, 0
3087, 1.45, 0.46, 0
3088, 1.45, 0.34, 0
3089, 1.45, 0.22, 0
3090, 1.5333333333333, 1.18, 0
3091, 1.5333333333333, 1.06, 0
3092, 1.5333333333333, 0.94, 0
3093, 1.5333333333333, 0.82, 0
3094, 1.5333333333333, 0.7, 0
3095, 1.5333333333333, 0.58, 0
3096, 1.5333333333333, 0.46, 0
3097, 1.5333333333333, 0.34, 0
3098, 1.5333333333333, 0.22, 0
3099, 1.6166666666667, 1.18, 0
3100, 1.6166666666667, 1.06, 0
3101, 1.6166666666667, 0.94, 0
3102, 1.6166666666667, 0.82, 0
3103, 1.6166666666667, 0.7, 0
3104, 1.6166666666667, 0.58, 0
3105, 1.6166666666667, 0.46, 0
3106, 1.6166666666667, 0.34, 0
3107, 1.6166666666667, 0.22, 0
3108, 1.7, 1.18, 0
3109, 1.7, 1.06, 0
3110, 1.7, 0.94, 0
3111, 1.7, 0.82, 0
3112, 1.7, 0.7, 0
3113, 1.7, 0.58, 0
3114, 1.7, 0.46, 0
3115, 1.7, 0.34, 0
3116, 1.7, 0.22, 0
3117, 1.7833333333333, 1.18, 0
3118, 1.7833333333333, 1.06, 0
3119, 1.7833333333333, 0.94, 0
3120, 1.7833333333333, 0.82, 0
3121, 1.7833333333333, 0.7, 0
3122, 1.7833333333333, 0.58, 0
3123, 1.7833333333333, 0.46, 0
3124, 1.7833333333333, 0.34, 0
3125, 1.7833333333333, 0.22, 0
3126, 1.8666666666667, 1.18, 0
3127, 1.8666666666667, 1.06, 0
3128, 1.8666666666667, 0.94, 0
3129, 1.8666666666667, 0.82, 0
3130, 1.8666666666667, 0.7, 0
3131, 1.8666666666667, 0.58, 0
3132, 1.8666666666667, 0.46, 0
3133, 1.8666666666667, 0.34, 0
3134, 1.8666666666667, 0.22, 0
3135, 1.95, 1.18, 0
3136, 1.95, 1.06, 0
3137, 1.95, 0.94, 0
3138, 1.95, 0.82, 0
3139, 1.95, 0.7, 0
3140, 1.95, 0.58, 0
3141, 1.95, 0.46, 0
3142, 1.95, 0.34, 0
3143, 1.95, 0.22, 0
3144, 2.0333333333333, 1.18, 0
3145, 2.0333333333333, 1.06, 0
3146, 2.0333333333333, 0.94, 0
3147, 2.0333333333333, 0.82, 0
3148, 2.0333333333333, 0.7, 0
3149, 2.0333333333333, 0.58, 0
3150, 2.0333333333333, 0.46, 0
3151, 2.0333333333333, 0.34, 0
3152, 2.0333333333333, 0.22, 0
3153, 2.1166666666667, 1.18, 0
3154, 2.1166666666667, 1.06, 0
3155, 2.1166666666667, 0.94, 0
3156, 2.1166666666667, 0.82, 0
3157, 2.1166666666667, 0.7, 0
3158, 2.1166666666667, 0.58, 0
3159, 2.1166666666667, 0.46, 0
3160, 2.1166666666667, 0.34, 0
3161, 2.1166666666667, 0.22, 0
3162, 1.2, 1.18, 0.05
3163, 1.2, 1.06, 0.05
3164, 1.2, 0.94, 0.05
3165, 1.2, 0.82, 0.05
3166, 1.2, 0.7, 0.05
3167, 1.2, 0.58, 0.05
3168, 1.2, 0.46, 0.05
3169, 1.2, 0.34, 0.05
3170, 1.2, 0.22, 0.05
3171, 1.2, 1.18, 0.1
3172, 1.2, 1.06, 0.1
3173, 1.2, 0.94, 0.1
3174, 1.2, 0.82, 0.1
3175, 1.2, 0.7, 0.1
3176, 1.2, 0.58, 0.1
3177, 1.2, 0.46, 0.1
3178, 1.2, 0.34, 0.1
3179, 1.2, 0.22, 0.1
3180, 1.2, 1.18, 0.15
3181, 1.2, 1.06, 0.15
3182, 1.2, 0.94, 0.15
3183, 1.2, 0.82, 0.15
3184, 1.2, 0.7, 0.15
3185, 1.2, 0.58, 0.15
3186, 1.2, 0.46, 0.15
3187, 1.2, 0.34, 0.15
3188, 1.2, 0.22, 0.15
3189, 1.2, 1.18, 0.2
3190, 1.2, 1.06, 0.2
3191, 1.2, 0.94, 0.2
3192, 1.2, 0.82, 0.2
3193, 1.2, 0.7, 0.2
3194, 1.2, 0.58, 0.2
3195, 1.2, 0.46, 0.2
3196, 1.2, 0.34, 0.2
3197, 1.2, 0.22, 0.2
3198, 1.2, 1.18, 0.25
3199, 1.2, 1.06, 0.25
3200, 1.2, 0.94, 0.25
3201, 1.2, 0.82, 0.25
3202, 1.2, 0.7, 0.25
3203, 1.2, 0.58, 0.25
3204, 1.2, 0.46, 0.25
3205, 1.2, 0.34, 0.25
3206, 1.2, 0.22, 0.25
3207, 1.2, 1.18, 0.3
3208, 1.2, 1.06, 0.3
3209, 1.2, 0.94, 0.3
3210, 1.2, 0.82, 0.3
3211, 1.2, 0.7, 0.3
3212, 1.2, 0.58, 0.3
3213, 1.2, 0.46, 0.3
3214, 1.2, 0.34, 0.3
3215, 1.2, 0.22, 0.3
3216, 1.2, 1.18, 0.35
3217, 1.2, 1.06, 0.35
3218, 1.2, 0.94, 0.35
3219, 1.2, 0.82, 0.35
3220, 1.2, 0.7, 0.35
3221, 1.2, 0.58, 0.35
3222, 1.2, 0.46, 0.35
3223, 1.2, 0.34, 0.35
3224, 1.2, 0.22, 0.35
3225, 1.2, 1.18, 0.4
3226, 1.2, 1.06, 0.4
3227, 1.2, 0.94, 0.4
3228, 1.2, 0.82, 0.4
3229, 1.2, 0.7, 0.4
3230, 1.2, 0.58, 0.4
3231, 1.2, 0.46, 0.4
3232, 1.2, 0.34, 0.4
3233, 1.2, 0.22, 0.4
3234, 1.2, 1.18, 0.45
3235, 1.2, 1.06, 0.45
3236, 1.2, 0.94, 0.45
3237, 1.2, 0.82, 0.45
3238, 1.2, 0.7, 0.45
3239, 1.2, 0.58, 0.45
3240, 1.2, 0.46, 0.45
3241, 1.2, 0.34, 0.45
3242, 1.2, 0.22, 0.45
3243, 2.2, 1.18, 0.05
3244, 2.2, 1.06, 0.05
3245, 2.2, 0.94, 0.05
3246, 2.2, 0.82, 0.05
3247, 2.2, 0.7, 0.05
3248, 2.2, 0.58, 0.05
3249, 2.2, 0.46, 0.05
3250, 2.2, 0.34, 0.05
3251, 2.2, 0.22, 0.05
3252, 2.2, 1.18, 0.1
3253, 2.2, 1.06, 0.1
3254, 2.2, 0.94, 0.1
3255, 2.2, 0.82, 0.1
3256, 2.2, 0.7, 0.1
3257, 2.2, 0.58, 0.1
3258, 2.2, 0.46, 0.1
3259, 2.2, 0.34, 0.1
3260, 2.2, 0.22, 0.1
3261, 2.2, 1.18, 0.15
3262, 2.2, 1.06, 0.15
3263, 2.2, 0.94, 0.15
3264, 2.2, 0.82, 0.15
3265, 2.2, 0.7, 0.15
3266, 2.2, 0.58, 0.15
3267, 2.2, 0.46, 0.15
3268, 2.2, 0.34, 0.15
3269, 2.2, 0.22, 0.15
3270, 2.2, 1.18, 0.2
3271, 2.2, 1.06, 0.2
3272, 2.2, 0.94, 0.2
3273, 2.2, 0.82, 0.2
3274, 2.2, 0.7, 0.2
3275, 2.2, 0.58, 0.2
3276, 2.2, 0.46, 0.2
3277, 2.2, 0.34, 0.2
3278, 2.2, 0.22, 0.2
3279, 2.2, 1.18, 0.25
3280, 2.2, 1.06, 0.25
3281, 2.2, 0.94, 0.25
3282, 2.2, 0.82, 0.25
3283, 2.2, 0.7, 0.25
3284, 2.2, 0.58, 0.25
3285, 2.2, 0.46, 0.25
3286, 2.2, 0.34, 0.25
3287, 2.2, 0.22, 0.25
3288, 2.2, 1.18, 0.3
3289, 2.2, 1.06, 0.3
3290, 2.2, 0.94, 0.3
3291, 2.2, 0.82, 0.3
3292, 2.2, 0.7, 0.3
3293, 2.2, 0.58, 0.3
3294, 2.2, 0.46, 0.3
3295, 2.2, 0.34, 0.3
3296, 2.2, 0.22, 0.3
3297, 2.2, 1.18, 0.35
3298, 2.2, 1.06, 0.35
3299, 2.2, 0.94, 0.35
3300, 2.2, 0.82, 0.35
3301, 2.2, 0.7, 0.35
3302, 2.2, 0.58, 0.35
3303, 2.2, 0.46, 0.35
3304, 2.2, 0.34, 0.35
3305, 2.2, 0.22, 0.35
3306, 2.2, 1.18, 0.4
3307, 2.2, 1.06, 0.4
3308, 2.2, 0.94, 0.4
3309, 2.2, 0.82, 0.4
3310, 2.2, 0.7, 0.4
3311, 2.2, 0.58, 0.4
3312, 2.2, 0.46, 0.4
3313, 2.2, 0.34, 0.4
3314, 2.2, 0.22, 0.4
3315, 2.2, 1.18, 0.45
3316, 2.2, 1.06, 0.45
3317, 2.2, 0.94, 0.45
3318, 2.2, 0.82, 0.45
3319, 2.2, 0.7, 0.45
3320, 2.2, 0.58, 0.45
3321, 2.2, 0.46, 0.45
3322, 2.2, 0.34, 0.45
3323, 2.2, 0.22, 0.45
3324, 1.2833333333333, 0.1, 0.05
3325, 1.3666666666667, 0.1, 0.05
3326, 1.45, 0.1, 0.05
3327, 1.5333333333333, 0.1, 0.05
3328, 1.6166666666667, 0.1, 0.05
3329, 1.7, 0.1, 0.05
3330, 1.7833333333333, 0.1, 0.05
3331, 1.8666666666667, 0.1, 0.05
3332, 1.95, 0.1, 0.05
3333, 2.0333333333333, 0.1, 0.05
3334, 2.1166666666667, 0.1, 0.05
3335, 1.2833333333333, 0.1, 0.1
3336, 1.3666666666667, 0.1, 0.1
3337, 1.45, 0.1, 0.1
3338, 1.5333333333333, 0.1, 0.1
3339, 1.6166666666667, 0.1, 0.1
3340, 1.7, 0.1, 0.1
3341, 1.7833333333333, 0.1, 0.1
3342, 1.8666666666667, 0.1, 0.1
3343, 1.95, 0.1, 0.1
3344, 2.0333333333333, 0.1, 0.1
3345, 2.1166666666667, 0.1, 0.1
3346, 1.2833333333333, 0.1, 0.15
3347, 1.3666666666667, 0.1, 0.15
3348, 1.45, 0.1, 0.15
3349, 1.5333333333333, 0.1, 0.15
3350, 1.6166666666667, 0.1, 0.15
3351, 1.7, 0.1, 0.15
3352, 1.7833333333333, 0.1, 0.15
3353, 1.8666666666667, 0.1, 0.15
3354, 1.95, 0.1, 0.15
3355, 2.0333333333333, 0.1, 0.15
3356, 2.1166666666667, 0.1, 0.15
3357, 1.2833333333333, 0.1, 0.2
3358, 1.3666666666667, 0.1, 0.2
3359, 1.45, 0.1, 0.2
3360, 1.5333333333333, 0.1, 0.2
3361, 1.6166666666667, 0.1, 0.2
3362, 1.7, 0.1, 0.2
3363, 1.7833333333333, 0.1, 0.2
3364, 1.8666666666667, 0.1, 0.2
3365, 1.95, 0.1, 0.2
3366, 2.0333333333333, 0.1, 0.2
3367, 2.1166666666667, 0.1, 0.2
3368, 1.2833333333333, 0.1, 0.25
3369, 1.3666666666667, 0.1, 0.25
3370, 1.45, 0.1, 0.25
3371, 1.5333333333333, 0.1, 0.25
3372, 1.6166666666667, 0.1, 0.25
3373, 1.7, 0.1, 0.25
3374, 1.7833333333333, 0.1, 0.25
3375, 1.8666666666667, 0.1, 0.25
3376, 1.95, 0.1, 0.25
3377, 2.0333333333333, 0.1, 0.25
3378, 2.1166666666667, 0.1, 0.25
3379, 1.2833333333333, 0.1, 0.3
3380, 1.3666666666667, 0.1, 0.3
3381, 1.45, 0.1, 0.3
3382, 1.5333333333333, 0.1, 0.3
3383, 1.6166666666667, 0.1, 0.3
3384, 1.7, 0.1, 0.3
3385, 1.7833333333333, 0.1, 0.3
3386, 1.8666666666667, 0.1, 0.3
3387, 1.95, 0.1, 0.3
3388, 2.0333333333333, 0.1, 0.3
3389, 2.1166666666667, 0.1, 0.3
3390, 1.2833333333333, 0.1, 0.35
3391, 1.3666666666667, 0.1, 0.35
3392, 1.45, 0.1, 0.35
3393, 1.5333333333333, 0.1, 0.35
3394, 1.6166666666667, 0.1, 0.35
3395, 1.7, 0.1, 0.35
3396, 1.7833333333333, 0.1, 0.35
3397, 1.8666666666667, 0.1, 0.35
3398, 1.95, 0.1, 0.35
3399, 2.0333333333333, 0.1, 0.35
3400, 2.1166666666667, 0.1, 0.35
3401, 1.2833333333333, 0.1, 0.4
3402, 1.3666666666667, 0.1, 0.4
3403, 1.45, 0.1, 0.4
3404, 1.5333333333333, 0.1, 0.4
3405, 1.6166666666667, 0.1, 0.4
3406, 1.7, 0.1, 0.4
3407, 1.7833333333333, 0.1, 0.4
3408, 1.8666666666667, 0.1, 0.4
3409, 1.95, 0.1, 0.4
3410, 2.0333333333333, 0.1, 0.4
3411, 2.1166666666667, 0.1, 0.4
3412, 1.2833333333333, 0.1, 0.45
3413, 1.3666666666667, 0.1, 0.45
3414, 1.45, 0.1, 0.45
3415, 1.5333333333333, 0.1, 0.45
3416, 1.6166666666667, 0.1, 0.45
3417, 1.7, 0.1, 0.45
3418, 1.7833333333333, 0.1, 0.45
3419, 1.8666666666667, 0.1, 0.45
3420, 1.95, 0.1, 0.45
3421, 2.0333333333333, 0.1, 0.45
3422, 2.1166666666667, 0.1, 0.45
3423, 1.2833333333333, 0.05, 0.05
3424, 1.3666666666667, 0.05, 0.05
3425, 1.45, 0.05, 0.05
3426, 1.5333333333333, 0.05, 0.05
3427, 1.6166666666667, 0.05, 0.05
3428, 1.7, 0.05, 0.05
3429, 1.7833333333333, 0.05, 0.05
3430, 1.8666666666667, 0.05, 0.05
3431, 1.95, 0.05, 0.05
3432, 2.0333333333333, 0.05, 0.05
3433, 2.1166666666667, 0.05, 0.05
3434, 1.2833333333333, 0.05, 0.1
3435, 1.3666666666667, 0.05, 0.1
3436, 1.45, 0.05, 0.1
3437, 1.5333333333333, 0.05, 0.1
3438, 1.6166666666667, 0.05, 0.1
3439, 1.7, 0.05, 0.1
3440, 1.7833333333333, 0.05, 0.1
3441, 1.8666666666667, 0.05, 0.1
3442, 1.95, 0.05, 0.1
3443, 2.0333333333333, 0.05, 0.1
3444, 2.1166666666667, 0.05, 0.1
3445, 1.2833333333333, 0.05, 0.15
3446, 1.3666666666667, 0.05, 0.15
3447, 1.45, 0.05, 0.15
3448, 1.5333333333333, 0.05, 0.15
3449, 1.6166666666667, 0.05, 0.15
3450, 1.7, 0.05, 0.15
3451, 1.7833333333333, 0.05, 0.15
3452, 1.8666666666667, 0.05, 0.15
3453, 1.95, 0.05, 0.15
3454, 2.0333333333333, 0.05, 0.15
3455, 2.1166666666667, 0.05, 0.15
3456, 1.2833333333333, 0.05, 0.2
3457, 1.3666666666667, 0.05, 0.2
3458, 1.45, 0.05, 0.2
3459, 1.5333333333333, 0.05, 0.2
3460, 1.6166666666667, 0.05, 0.2
3461, 1.7, 0.05, 0.2
3462, 1.7833333333333, 0.05, 0.2
3463, 1.8666666666667, 0.05, 0.2
3464, 1.95, 0.05, 0.2
3465, 2.0333333333333, 0.05, 0.2
3466, 2.1166666666667, 0.05, 0.2
3467, 1.2833333333333, 0.05, 0.25
3468, 1.3666666666667, 0.05, 0.25
3469, 1.45, 0.05, 0.25
3470, 1.5333333333333, 0.05, 0.25
3471, 1.6166666666667, 0.05, 0.25
3472, 1.7, 0.05, 0.25
3473, 1.7833333333333, 0.05, 0.25
3474, 1.8666666666667, 0.05, 0.25
3475, 1.95, 0.05, 0.25
3476, 2.0333333333333, 0.05, 0.25
3477, 2.1166666666667, 0.05, 0.25
3478, 1.2833333333333, 0.05, 0.3
3479, 1.3666666666667, 0.05, 0.3
3480, 1.45, 0.05, 0.3
3481, 1.5333333333333, 0.05, 0.3
3482, 1.6166666666667, 0.05, 0.3
3483, 1.7, 0.05, 0.3
3484, 1.7833333333333, 0.05, 0.3
3485, 1.8666666666667, 0.05, 0.3
3486, 1.95, 0.05, 0.3
3487, 2.0333333333333, 0.05, 0.3
3488, 2.1166666666667, 0.05, 0.3
3489, 1.2833333333333, 0.05, 0.35
3490, 1.3666666666667, 0.05, 0.35
3491, 1.45, 0.05, 0.35
3492, 1.5333333333333, 0.05, 0.35
3493, 1.6166666666667, 0.05, 0.35
3494, 1.7, 0.05, 0.35
3495, 1.7833333333333, 0.05, 0.35
3496, 1.8666666666667, 0.05, 0.35
3497, 1.95, 0.05, 0.35
3498, 2.0333333333333, 0.05, 0.35
3499, 2.1166666666667, 0.05, 0.35
3500, 1.2833333333333, 0.05, 0.4
3501, 1.3666666666667, 0.05, 0.4
3502, 1.45, 0.05, 0.4
3503, 1.5333333333333, 0.05, 0.4
3504, 1.6166666666667, 0.05, 0.4
3505, 1.7, 0.05, 0.4
3506, 1.7833333333333, 0.05, 0.4
3507, 1.8666666666667, 0.05, 0.4
3508, 1.95, 0.05, 0.4
3509, 2.0333333333333, 0.05, 0.4
3510, 2.1166666666667, 0.05, 0.4
3511, 1.2833333333333, 0.05, 0.45
3512, 1.3666666666667, 0.05, 0.45
3513, 1.45, 0.05, 0.45
3514, 1.5333333333333, 0.05, 0.45
3515, 1.6166666666667, 0.05, 0.45
3516, 1.7, 0.05, 0.45
3517, 1.7833333333333, 0.05, 0.45
3518, 1.8666666666667, 0.05, 0.45
3519, 1.95, 0.05, 0.45
3520, 2.0333333333333, 0.05, 0.45
3521, 2.1166666666667, 0.05, 0.45
3522, 1.2833333333333, 0.0375, 0.5
3523, 1.2833333333333, 0.025, 0.5
3524, 1.2833333333333, 0.0125, 0.5
3525, 1.3666666666667, 0.0375, 0.5
3526, 1.3666666666667, 0.025, 0.5
3527, 1.3666666666667, 0.0125, 0.5
3528, 1.45, 0.0375, 0.5
3529, 1.45, 0.025, 0.5
3530, 1.45, 0.0125, 0.5
3531, 1.5333333333333, 0.0375, 0.5
3532, 1.5333333333333, 0.025, 0.5
3533, 1.5333333333333, 0.0125, 0.5
3534, 1.6166666666667, 0.0375, 0.5
3535, 1.6166666666667, 0.025, 0.5
3536, 1.6166666666667, 0.0125, 0.5
3537, 1.7, 0.0375, 0.5
3538, 1.7, 0.025, 0.5
3539, 1.7, 0.0125, 0.5
3540, 1.7833333333333, 0.0375, 0.5
3541, 1.7833333333333, 0.025, 0.5
3542, 1.7833333333333, 0.0125, 0.5
3543, 1.8666666666667, 0.0375, 0.5
3544, 1.8666666666667, 0.025, 0.5
3545, 1.8666666666667, 0.0125, 0.5
3546, 1.95, 0.0375, 0.5
3547, 1.95, 0.025, 0.5
3548, 1.95, 0.0125, 0.5
3549, 2.0333333333333, 0.0375, 0.5
3550, 2.0333333333333, 0.025, 0.5
3551, 2.0333333333333, 0.0125, 0.5
3552, 2.1166666666667, 0.0375, 0.5
3553, 2.1166666666667, 0.025, 0.5
3554, 2.1166666666667, 0.0125, 0.5
3555, 1.2833333333333, 0.0375, 0
3556, 1.2833333333333, 0.025, 0
3557, 1.2833333333333, 0.0125, 0
3558, 1.3666666666667, 0.0375, 0
3559, 1.3666666666667, 0.025, 0
3560, 1.3666666666667, 0.0125, 0
3561, 1.45, 0.0375, 0
3562, 1.45, 0.025, 0
3563, 1.45, 0.0125, 0
3564, 1.5333333333333, 0.0375, 0
3565, 1.5333333333333, 0.025, 0
3566, 1.5333333333333, 0.0125, 0
3567, 1.6166666666667, 0.0375, 0
3568, 1.6166666666667, 0.025, 0
3569, 1.6166666666667, 0.0125, 0
3570, 1.7, 0.0375, 0
3571, 1.7, 0.025, 0
3572, 1.7, 0.0125, 0
3573, 1.7833333333333, 0.0375, 0
3574, 1.7833333333333, 0.025, 0
3575, 1.7833333333333, 0.0125, 0
3576, 1.8666666666667, 0.0375, 0
3577, 1.8666666666667, 0.025, 0
3578, 1.8666666666667, 0.0125, 0
3579, 1.95, 0.0375, 0
3580, 1.95, 0.025, 0
3581, 1.95, 0.0125, 0
3582, 2.0333333333333, 0.0375, 0
3583, 2.0333333333333, 0.025, 0
3584, 2.0333333333333, 0.0125, 0
3585, 2.1166666666667, 0.0375, 0
3586, 2.1166666666667, 0.025, 0
3587, 2.1166666666667, 0.0125, 0
3588, 1.2, 0.0375, 0.05
3589, 1.2, 0.025, 0.05
3590, 1.2, 0.0125, 0.05
3591, 1.2, 0.0375, 0.1
3592, 1.2, 0.025, 0.1
3593, 1.2, 0.0125, 0.1
3594, 1.2, 0.0375, 0.15
3595, 1.2, 0.025, 0.15
3596, 1.2, 0.0125, 0.15
3597, 1.2, 0.0375, 0.2
3598, 1.2, 0.025, 0.2
3599, 1.2, 0.0125, 0.2
3600, 1.2, 0.0375, 0.25
3601, 1.2, 0.025, 0.25
3602, 1.2, 0.0125, 0.25
3603, 1.2, 0.0375, 0.3
3604, 1.2, 0.025, 0.3
3605, 1.2, 0.0125, 0.3
3606, 1.2, 0.0375, 0.35
3607, 1.2, 0.025, 0.35
3608, 1.2, 0.0125, 0.35
3609, 1.2, 0.0375, 0.4
3610, 1.2, 0.025, 0.4
3611, 1.2, 0.0125, 0.4
3612, 1.2, 0.0375, 0.45
3613, 1.2, 0.025, 0.45
3614, 1.2, 0.0125, 0.45
3615, 2.2, 0.0375, 0.05
3616, 2.2, 0.025, 0.05
3617, 2.2, 0.0125, 0.05
3618, 2.2, 0.0375, 0.1
3619, 2.2, 0.025, 0.1
3620, 2.2, 0.0125, 0.1
3621, 2.2, 0.0375, 0.15
3622, 2.2, 0.025, 0.15
3623, 2.2, 0.0125, 0.15
3624, 2.2, 0.0375, 0.2
3625, 2.2, 0.025, 0.2
3626, 2.2, 0.0125, 0.2
3627, 2.2, 0.0375, 0.25
3628, 2.2, 0.025, 0.25
3629, 2.2, 0.0125, 0.25
3630, 2.2, 0.0375, 0.3
3631, 2.2, 0.025, 0.3
3632, 2.2, 0.0125, 0.3
3633, 2.2, 0.0375, 0.35
3634, 2.2, 0.025, 0.35
3635, 2.2, 0.0125, 0.35
3636, 2.2, 0.0375, 0.4
3637, 2.2, 0.025, 0.4
3638, 2.2, 0.0125, 0.4
3639, 2.2, 0.0375, 0.45
3640, 2.2, 0.025, 0.45
3641, 2.2, 0.0125, 0.45
3642, 1.2833333333333, 8.3266726846887e-17, 0.05
3643, 1.3666666666667, 8.3266726846887e-17, 0.05
3644, 1.45, 8.3266726846887e-17, 0.05
3645, 1.5333333333333, 8.3266726846887e-17, 0.05
3646, 1.6166666666667, 8.3266726846887e-17, 0.05
3647, 1.7, 8.3266726846887e-17, 0.05
3648, 1.7833333333333, 8.3266726846887e-17, 0.05
3649, 1.8666666666667, 8.3266726846887e-17, 0.05
3650, 1.95, 8.3266726846887e-17, 0.05
3651, 2.0333333333333, 8.3266726846887e-17, 0.05
3652, 2.1166666666667, 8.3266726846887e-17, 0.05
3653, 1.2833333333333, 8.3266726846887e-17, 0.1
3654, 1.3666666666667, 8.3266726846887e-17, 0.1
3655, 1.45, 8.3266726846887e-17, 0.1
3656, 1.5333333333333, 8.3266726846887e-17, 0.1
3657, 1.6166666666667, 8.3266726846887e-17, 0.1
3658, 1.7, 8.3266726846887e-17, 0.1
3659, 1.7833333333333, 8.3266726846887e-17, 0.1
3660, 1.8666666666667, 8.3266726846887e-17, 0.1
3661, 1.95, 8.3266726846887e-17, 0.1
3662, 2.0333333333333, 8.3266726846887e-17, 0.1
3663, 2.1166666666667, 8.3266726846887e-17, 0.1
3664, 1.2833333333333, 8.3266726846887e-17, 0.15
3665, 1.3666666666667, 8.3266726846887e-17, 0.15
3666, 1.45, 8.3266726846887e-17, 0.15
3667, 1.5333333333333, 8.3266726846887e-17, 0.15
3668, 1.6166666666667, 8.3266726846887e-17, 0.15
3669, 1.7, 8.3266726846887e-17, 0.15
3670, 1.7833333333333, 8.3266726846887e-17, 0.15
3671, 1.8666666666667, 8.3266726846887e-17, 0.15
3672, 1.95, 8.3266726846887e-17, 0.15
3673, 2.0333333333333, 8.3266726846887e-17, 0.15
3674, 2.1166666666667, 8.3266726846887e-17, 0.15
3675, 1.2833333333333, 8.3266726846887e-17, 0.2
3676, 1.3666666666667, 8.3266726846887e-17, 0.2
3677, 1.45, 8.3266726846887e-17, 0.2
3678, 1.5333333333333, 8.3266726846887e-17, 0.2
3679, 1.6166666666667, 8.3266726846887e-17, 0.2
3680, 1.7, 8.3266726846887e-17, 0.2
3681, 1.7833333333333, 8.3266726846887e-17, 0.2
3682, 1.8666666666667, 8.3266726846887e-17, 0.2
3683, 1.95, 8.3266726846887e-17, 0.2
3684, 2.0333333333333, 8.3266726846887e-17, 0.2
3685, 2.1166666666667, 8.3266726846887e-17, 0.2
3686, 1.2833333333333, 8.3266726846887e-17, 0.25
3687, 1.3666666666667, 8.3266726846887e-17, 0.25
3688, 1.45, 8.3266726846887e-17, 0.25
3689, 1.5333333333333, 8.3266726846887e-17, 0.25
3690, 1.6166666666667, 8.3266726846887e-17, 0.25
3691, 1.7, 8.3266726846887e-17, 0.25
3692, 1.7833333333333, 8.3266726846887e-17, 0.25
3693, 1.8666666666667, 8.3266726846887e-17, 0.25
3694, 1.95, 8.3266726846887e-17, 0.25
3695, 2.0333333333333, 8.3266726846887e-17, 0.25
3696, 2.1166666666667, 8.3266726846887e-17, 0.25
3697, 1.2833333333333, 8.3266726846887e-17, 0.3
3698, 1.3666666666667, 8.3266726846887e-17, 0.3
3699, 1.45, 8.3266726846887e-17, 0.3
3700, 1.5333333333333, 8.3266726846887e-17, 0.3
3701, 1.6166666666667, 8.3266726846887e-17, 0.3
3702, 1.7, 8.3266726846887e-17, 0.3
3703, 1.7833333333333, 8.3266726846887e-17, 0.3
3704, 1.8666666666667, 8.3266726846887e-17, 0.3
3705, 1.95, 8.3266726846887e-17, 0.3
3706, 2.0333333333333, 8.3266726846887e-17, 0.3
3707, 2.1166666666667, 8.3266726846887e-17, 0.3
3708, 1.2833333333333, 8.3266726846887e-17, 0.35
3709, 1.3666666666667, 8.3266726846887e-17, 0.35
3710, 1.45, 8.3266726846887e-17, 0.35
3711, 1.5333333333333, 8.3266726846887e-17, 0.35
3712, 1.6166666666667, 8.3266726846887e-17, 0.35
3713, 1.7, 8.3266726846887e-17, 0.35
