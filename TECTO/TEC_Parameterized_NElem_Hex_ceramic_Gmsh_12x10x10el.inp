11100, 7698, 3272, 3281, 7797, 7699, 3273, 3282, 7798
11101, 7699, 3273, 3282, 7798, 7700, 3274, 3283, 7799
11102, 7700, 3274, 3283, 7799, 7701, 3275, 3284, 7800
11103, 7701, 3275, 3284, 7800, 7702, 3276, 3285, 7801
11104, 7702, 3276, 3285, 7801, 7703, 3277, 3286, 7802
11105, 7703, 3277, 3286, 7802, 7704, 3278, 3287, 7803
11106, 7704, 3278, 3287, 7803, 3367, 623, 624, 3378
11107, 539, 2909, 2920, 540, 3198, 7705, 7804, 3207
11108, 3198, 7705, 7804, 3207, 3199, 7706, 7805, 3208
11109, 3199, 7706, 7805, 3208, 3200, 7707, 7806, 3209
11110, 3200, 7707, 7806, 3209, 3201, 7708, 7807, 3210
11111, 3201, 7708, 7807, 3210, 3202, 7709, 7808, 3211
11112, 3202, 7709, 7808, 3211, 3203, 7710, 7809, 3212
11113, 3203, 7710, 7809, 3212, 3204, 7711, 7810, 3213
11114, 3204, 7711, 7810, 3213, 3205, 7712, 7811, 3214
11115, 3205, 7712, 7811, 3214, 3206, 7713, 7812, 3215
11116, 3206, 7713, 7812, 3215, 615, 3368, 3379, 616
11117, 2909, 2910, 2921, 2920, 7705, 7714, 7813, 7804
11118, 7705, 7714, 7813, 7804, 7706, 7715, 7814, 7805
11119, 7706, 7715, 7814, 7805, 7707, 7716, 7815, 7806
11120, 7707, 7716, 7815, 7806, 7708, 7717, 7816, 7807
11121, 7708, 7717, 7816, 7807, 7709, 7718, 7817, 7808
11122, 7709, 7718, 7817, 7808, 7710, 7719, 7818, 7809
11123, 7710, 7719, 7818, 7809, 7711, 7720, 7819, 7810
11124, 7711, 7720, 7819, 7810, 7712, 7721, 7820, 7811
11125, 7712, 7721, 7820, 7811, 7713, 7722, 7821, 7812
11126, 7713, 7722, 7821, 7812, 3368, 3369, 3380, 3379
11127, 2910, 2911, 2922, 2921, 7714, 7723, 7822, 7813
11128, 7714, 7723, 7822, 7813, 7715, 7724, 7823, 7814
11129, 7715, 7724, 7823, 7814, 7716, 7725, 7824, 7815
11130, 7716, 7725, 7824, 7815, 7717, 7726, 7825, 7816
11131, 7717, 7726, 7825, 7816, 7718, 7727, 7826, 7817
11132, 7718, 7727, 7826, 7817, 7719, 7728, 7827, 7818
11133, 7719, 7728, 7827, 7818, 7720, 7729, 7828, 7819
11134, 7720, 7729, 7828, 7819, 7721, 7730, 7829, 7820
11135, 7721, 7730, 7829, 7820, 7722, 7731, 7830, 7821
11136, 7722, 7731, 7830, 7821, 3369, 3370, 3381, 3380
11137, 2911, 2912, 2923, 2922, 7723, 7732, 7831, 7822
11138, 7723, 7732, 7831, 7822, 7724, 7733, 7832, 7823
11139, 7724, 7733, 7832, 7823, 7725, 7734, 7833, 7824
11140, 7725, 7734, 7833, 7824, 7726, 7735, 7834, 7825
11141, 7726, 7735, 7834, 7825, 7727, 7736, 7835, 7826
11142, 7727, 7736, 7835, 7826, 7728, 7737, 7836, 7827
11143, 7728, 7737, 7836, 7827, 7729, 7738, 7837, 7828
11144, 7729, 7738, 7837, 7828, 7730, 7739, 7838, 7829
11145, 7730, 7739, 7838, 7829, 7731, 7740, 7839, 7830
11146, 7731, 7740, 7839, 7830, 3370, 3371, 3382, 3381
11147, 2912, 2913, 2924, 2923, 7732, 7741, 7840, 7831
11148, 7732, 7741, 7840, 7831, 7733, 7742, 7841, 7832
11149, 7733, 7742, 7841, 7832, 7734, 7743, 7842, 7833
11150, 7734, 7743, 7842, 7833, 7735, 7744, 7843, 7834
11151, 7735, 7744, 7843, 7834, 7736, 7745, 7844, 7835
11152, 7736, 7745, 7844, 7835, 7737, 7746, 7845, 7836
11153, 7737, 7746, 7845, 7836, 7738, 7747, 7846, 7837
11154, 7738, 7747, 7846, 7837, 7739, 7748, 7847, 7838
11155, 7739, 7748, 7847, 7838, 7740, 7749, 7848, 7839
11156, 7740, 7749, 7848, 7839, 3371, 3372, 3383, 3382
11157, 2913, 2914, 2925, 2924, 7741, 7750, 7849, 7840
11158, 7741, 7750, 7849, 7840, 7742, 7751, 7850, 7841
11159, 7742, 7751, 7850, 7841, 7743, 7752, 7851, 7842
11160, 7743, 7752, 7851, 7842, 7744, 7753, 7852, 7843
11161, 7744, 7753, 7852, 7843, 7745, 7754, 7853, 7844
11162, 7745, 7754, 7853, 7844, 7746, 7755, 7854, 7845
11163, 7746, 7755, 7854, 7845, 7747, 7756, 7855, 7846
11164, 7747, 7756, 7855, 7846, 7748, 7757, 7856, 7847
11165, 7748, 7757, 7856, 7847, 7749, 7758, 7857, 7848
11166, 7749, 7758, 7857, 7848, 3372, 3373, 3384, 3383
11167, 2914, 2915, 2926, 2925, 7750, 7759, 7858, 7849
11168, 7750, 7759, 7858, 7849, 7751, 7760, 7859, 7850
11169, 7751, 7760, 7859, 7850, 7752, 7761, 7860, 7851
11170, 7752, 7761, 7860, 7851, 7753, 7762, 7861, 7852
11171, 7753, 7762, 7861, 7852, 7754, 7763, 7862, 7853
11172, 7754, 7763, 7862, 7853, 7755, 7764, 7863, 7854
11173, 7755, 7764, 7863, 7854, 7756, 7765, 7864, 7855
11174, 7756, 7765, 7864, 7855, 7757, 7766, 7865, 7856
11175, 7757, 7766, 7865, 7856, 7758, 7767, 7866, 7857
11176, 7758, 7767, 7866, 7857, 3373, 3374, 3385, 3384
11177, 2915, 2916, 2927, 2926, 7759, 7768, 7867, 7858
11178, 7759, 7768, 7867, 7858, 7760, 7769, 7868, 7859
11179, 7760, 7769, 7868, 7859, 7761, 7770, 7869, 7860
11180, 7761, 7770, 7869, 7860, 7762, 7771, 7870, 7861
11181, 7762, 7771, 7870, 7861, 7763, 7772, 7871, 7862
11182, 7763, 7772, 7871, 7862, 7764, 7773, 7872, 7863
11183, 7764, 7773, 7872, 7863, 7765, 7774, 7873, 7864
11184, 7765, 7774, 7873, 7864, 7766, 7775, 7874, 7865
11185, 7766, 7775, 7874, 7865, 7767, 7776, 7875, 7866
11186, 7767, 7776, 7875, 7866, 3374, 3375, 3386, 3385
11187, 2916, 2917, 2928, 2927, 7768, 7777, 7876, 7867
11188, 7768, 7777, 7876, 7867, 7769, 7778, 7877, 7868
11189, 7769, 7778, 7877, 7868, 7770, 7779, 7878, 7869
11190, 7770, 7779, 7878, 7869, 7771, 7780, 7879, 7870
11191, 7771, 7780, 7879, 7870, 7772, 7781, 7880, 7871
11192, 7772, 7781, 7880, 7871, 7773, 7782, 7881, 7872
11193, 7773, 7782, 7881, 7872, 7774, 7783, 7882, 7873
11194, 7774, 7783, 7882, 7873, 7775, 7784, 7883, 7874
11195, 7775, 7784, 7883, 7874, 7776, 7785, 7884, 7875
11196, 7776, 7785, 7884, 7875, 3375, 3376, 3387, 3386
11197, 2917, 2918, 2929, 2928, 7777, 7786, 7885, 7876
11198, 7777, 7786, 7885, 7876, 7778, 7787, 7886, 7877
11199, 7778, 7787, 7886, 7877, 7779, 7788, 7887, 7878
11200, 7779, 7788, 7887, 7878, 7780, 7789, 7888, 7879
11201, 7780, 7789, 7888, 7879, 7781, 7790, 7889, 7880
11202, 7781, 7790, 7889, 7880, 7782, 7791, 7890, 7881
11203, 7782, 7791, 7890, 7881, 7783, 7792, 7891, 7882
11204, 7783, 7792, 7891, 7882, 7784, 7793, 7892, 7883
11205, 7784, 7793, 7892, 7883, 7785, 7794, 7893, 7884
11206, 7785, 7794, 7893, 7884, 3376, 3377, 3388, 3387
11207, 2918, 2919, 2930, 2929, 7786, 7795, 7894, 7885
11208, 7786, 7795, 7894, 7885, 7787, 7796, 7895, 7886
11209, 7787, 7796, 7895, 7886, 7788, 7797, 7896, 7887
11210, 7788, 7797, 7896, 7887, 7789, 7798, 7897, 7888
11211, 7789, 7798, 7897, 7888, 7790, 7799, 7898, 7889
11212, 7790, 7799, 7898, 7889, 7791, 7800, 7899, 7890
11213, 7791, 7800, 7899, 7890, 7792, 7801, 7900, 7891
11214, 7792, 7801, 7900, 7891, 7793, 7802, 7901, 7892
11215, 7793, 7802, 7901, 7892, 7794, 7803, 7902, 7893
11216, 7794, 7803, 7902, 7893, 3377, 3378, 3389, 3388
11217, 2919, 548, 549, 2930, 7795, 3279, 3288, 7894
11218, 7795, 3279, 3288, 7894, 7796, 3280, 3289, 7895
11219, 7796, 3280, 3289, 7895, 7797, 3281, 3290, 7896
11220, 7797, 3281, 3290, 7896, 7798, 3282, 3291, 7897
11221, 7798, 3282, 3291, 7897, 7799, 3283, 3292, 7898
11222, 7799, 3283, 3292, 7898, 7800, 3284, 3293, 7899
11223, 7800, 3284, 3293, 7899, 7801, 3285, 3294, 7900
11224, 7801, 3285, 3294, 7900, 7802, 3286, 3295, 7901
11225, 7802, 3286, 3295, 7901, 7803, 3287, 3296, 7902
11226, 7803, 3287, 3296, 7902, 3378, 624, 625, 3389
11227, 540, 2920, 2931, 541, 3207, 7804, 7903, 3216
11228, 3207, 7804, 7903, 3216, 3208, 7805, 7904, 3217
11229, 3208, 7805, 7904, 3217, 3209, 7806, 7905, 3218
11230, 3209, 7806, 7905, 3218, 3210, 7807, 7906, 3219
11231, 3210, 7807, 7906, 3219, 3211, 7808, 7907, 3220
11232, 3211, 7808, 7907, 3220, 3212, 7809, 7908, 3221
11233, 3212, 7809, 7908, 3221, 3213, 7810, 7909, 3222
11234, 3213, 7810, 7909, 3222, 3214, 7811, 7910, 3223
11235, 3214, 7811, 7910, 3223, 3215, 7812, 7911, 3224
11236, 3215, 7812, 7911, 3224, 616, 3379, 3390, 617
11237, 2920, 2921, 2932, 2931, 7804, 7813, 7912, 7903
11238, 7804, 7813, 7912, 7903, 7805, 7814, 7913, 7904
11239, 7805, 7814, 7913, 7904, 7806, 7815, 7914, 7905
11240, 7806, 7815, 7914, 7905, 7807, 7816, 7915, 7906
11241, 7807, 7816, 7915, 7906, 7808, 7817, 7916, 7907
11242, 7808, 7817, 7916, 7907, 7809, 7818, 7917, 7908
11243, 7809, 7818, 7917, 7908, 7810, 7819, 7918, 7909
11244, 7810, 7819, 7918, 7909, 7811, 7820, 7919, 7910
11245, 7811, 7820, 7919, 7910, 7812, 7821, 7920, 7911
11246, 7812, 7821, 7920, 7911, 3379, 3380, 3391, 3390
11247, 2921, 2922, 2933, 2932, 7813, 7822, 7921, 7912
11248, 7813, 7822, 7921, 7912, 7814, 7823, 7922, 7913
11249, 7814, 7823, 7922, 7913, 7815, 7824, 7923, 7914
11250, 7815, 7824, 7923, 7914, 7816, 7825, 7924, 7915
11251, 7816, 7825, 7924, 7915, 7817, 7826, 7925, 7916
11252, 7817, 7826, 7925, 7916, 7818, 7827, 7926, 7917
11253, 7818, 7827, 7926, 7917, 7819, 7828, 7927, 7918
11254, 7819, 7828, 7927, 7918, 7820, 7829, 7928, 7919
11255, 7820, 7829, 7928, 7919, 7821, 7830, 7929, 7920
11256, 7821, 7830, 7929, 7920, 3380, 3381, 3392, 3391
11257, 2922, 2923, 2934, 2933, 7822, 7831, 7930, 7921
11258, 7822, 7831, 7930, 7921, 7823, 7832, 7931, 7922
11259, 7823, 7832, 7931, 7922, 7824, 7833, 7932, 7923
11260, 7824, 7833, 7932, 7923, 7825, 7834, 7933, 7924
11261, 7825, 7834, 7933, 7924, 7826, 7835, 7934, 7925
11262, 7826, 7835, 7934, 7925, 7827, 7836, 7935, 7926
11263, 7827, 7836, 7935, 7926, 7828, 7837, 7936, 7927
11264, 7828, 7837, 7936, 7927, 7829, 7838, 7937, 7928
11265, 7829, 7838, 7937, 7928, 7830, 7839, 7938, 7929
11266, 7830, 7839, 7938, 7929, 3381, 3382, 3393, 3392
11267, 2923, 2924, 2935, 2934, 7831, 7840, 7939, 7930
11268, 7831, 7840, 7939, 7930, 7832, 7841, 7940, 7931
11269, 7832, 7841, 7940, 7931, 7833, 7842, 7941, 7932
11270, 7833, 7842, 7941, 7932, 7834, 7843, 7942, 7933
11271, 7834, 7843, 7942, 7933, 7835, 7844, 7943, 7934
11272, 7835, 7844, 7943, 7934, 7836, 7845, 7944, 7935
11273, 7836, 7845, 7944, 7935, 7837, 7846, 7945, 7936
11274, 7837, 7846, 7945, 7936, 7838, 7847, 7946, 7937
11275, 7838, 7847, 7946, 7937, 7839, 7848, 7947, 7938
11276, 7839, 7848, 7947, 7938, 3382, 3383, 3394, 3393
11277, 2924, 2925, 2936, 2935, 7840, 7849, 7948, 7939
11278, 7840, 7849, 7948, 7939, 7841, 7850, 7949, 7940
11279, 7841, 7850, 7949, 7940, 7842, 7851, 7950, 7941
11280, 7842, 7851, 7950, 7941, 7843, 7852, 7951, 7942
11281, 7843, 7852, 7951, 7942, 7844, 7853, 7952, 7943
11282, 7844, 7853, 7952, 7943, 7845, 7854, 7953, 7944
11283, 7845, 7854, 7953, 7944, 7846, 7855, 7954, 7945
11284, 7846, 7855, 7954, 7945, 7847, 7856, 7955, 7946
11285, 7847, 7856, 7955, 7946, 7848, 7857, 7956, 7947
11286, 7848, 7857, 7956, 7947, 3383, 3384, 3395, 3394
11287, 2925, 2926, 2937, 2936, 7849, 7858, 7957, 7948
11288, 7849, 7858, 7957, 7948, 7850, 7859, 7958, 7949
11289, 7850, 7859, 7958, 7949, 7851, 7860, 7959, 7950
11290, 7851, 7860, 7959, 7950, 7852, 7861, 7960, 7951
11291, 7852, 7861, 7960, 7951, 7853, 7862, 7961, 7952
11292, 7853, 7862, 7961, 7952, 7854, 7863, 7962, 7953
11293, 7854, 7863, 7962, 7953, 7855, 7864, 7963, 7954
11294, 7855, 7864, 7963, 7954, 7856, 7865, 7964, 7955
11295, 7856, 7865, 7964, 7955, 7857, 7866, 7965, 7956
11296, 7857, 7866, 7965, 7956, 3384, 3385, 3396, 3395
11297, 2926, 2927, 2938, 2937, 7858, 7867, 7966, 7957
11298, 7858, 7867, 7966, 7957, 7859, 7868, 7967, 7958
11299, 7859, 7868, 7967, 7958, 7860, 7869, 7968, 7959
11300, 7860, 7869, 7968, 7959, 7861, 7870, 7969, 7960
11301, 7861, 7870, 7969, 7960, 7862, 7871, 7970, 7961
11302, 7862, 7871, 7970, 7961, 7863, 7872, 7971, 7962
11303, 7863, 7872, 7971, 7962, 7864, 7873, 7972, 7963
11304, 7864, 7873, 7972, 7963, 7865, 7874, 7973, 7964
11305, 7865, 7874, 7973, 7964, 7866, 7875, 7974, 7965
11306, 7866, 7875, 7974, 7965, 3385, 3386, 3397, 3396
11307, 2927, 2928, 2939, 2938, 7867, 7876, 7975, 7966
11308, 7867, 7876, 7975, 7966, 7868, 7877, 7976, 7967
11309, 7868, 7877, 7976, 7967, 7869, 7878, 7977, 7968
11310, 7869, 7878, 7977, 7968, 7870, 7879, 7978, 7969
11311, 7870, 7879, 7978, 7969, 7871, 7880, 7979, 7970
11312, 7871, 7880, 7979, 7970, 7872, 7881, 7980, 7971
11313, 7872, 7881, 7980, 7971, 7873, 7882, 7981, 7972
11314, 7873, 7882, 7981, 7972, 7874, 7883, 7982, 7973
11315, 7874, 7883, 7982, 7973, 7875, 7884, 7983, 7974
11316, 7875, 7884, 7983, 7974, 3386, 3387, 3398, 3397
11317, 2928, 2929, 2940, 2939, 7876, 7885, 7984, 7975
11318, 7876, 7885, 7984, 7975, 7877, 7886, 7985, 7976
11319, 7877, 7886, 7985, 7976, 7878, 7887, 7986, 7977
11320, 7878, 7887, 7986, 7977, 7879, 7888, 7987, 7978
11321, 7879, 7888, 7987, 7978, 7880, 7889, 7988, 7979
11322, 7880, 7889, 7988, 7979, 7881, 7890, 7989, 7980
11323, 7881, 7890, 7989, 7980, 7882, 7891, 7990, 7981
11324, 7882, 7891, 7990, 7981, 7883, 7892, 7991, 7982
11325, 7883, 7892, 7991, 7982, 7884, 7893, 7992, 7983
11326, 7884, 7893, 7992, 7983, 3387, 3388, 3399, 3398
11327, 2929, 2930, 2941, 2940, 7885, 7894, 7993, 7984
11328, 7885, 7894, 7993, 7984, 7886, 7895, 7994, 7985
11329, 7886, 7895, 7994, 7985, 7887, 7896, 7995, 7986
11330, 7887, 7896, 7995, 7986, 7888, 7897, 7996, 7987
11331, 7888, 7897, 7996, 7987, 7889, 7898, 7997, 7988
11332, 7889, 7898, 7997, 7988, 7890, 7899, 7998, 7989
11333, 7890, 7899, 7998, 7989, 7891, 7900, 7999, 7990
11334, 7891, 7900, 7999, 7990, 7892, 7901, 8000, 7991
11335, 7892, 7901, 8000, 7991, 7893, 7902, 8001, 7992
11336, 7893, 7902, 8001, 7992, 3388, 3389, 3400, 3399
11337, 2930, 549, 550, 2941, 7894, 3288, 3297, 7993
11338, 7894, 3288, 3297, 7993, 7895, 3289, 3298, 7994
11339, 7895, 3289, 3298, 7994, 7896, 3290, 3299, 7995
11340, 7896, 3290, 3299, 7995, 7897, 3291, 3300, 7996
11341, 7897, 3291, 3300, 7996, 7898, 3292, 3301, 7997
11342, 7898, 3292, 3301, 7997, 7899, 3293, 3302, 7998
11343, 7899, 3293, 3302, 7998, 7900, 3294, 3303, 7999
11344, 7900, 3294, 3303, 7999, 7901, 3295, 3304, 8000
11345, 7901, 3295, 3304, 8000, 7902, 3296, 3305, 8001
11346, 7902, 3296, 3305, 8001, 3389, 625, 626, 3400
11347, 541, 2931, 2942, 542, 3216, 7903, 8002, 3225
11348, 3216, 7903, 8002, 3225, 3217, 7904, 8003, 3226
11349, 3217, 7904, 8003, 3226, 3218, 7905, 8004, 3227
11350, 3218, 7905, 8004, 3227, 3219, 7906, 8005, 3228
11351, 3219, 7906, 8005, 3228, 3220, 7907, 8006, 3229
11352, 3220, 7907, 8006, 3229, 3221, 7908, 8007, 3230
11353, 3221, 7908, 8007, 3230, 3222, 7909, 8008, 3231
11354, 3222, 7909, 8008, 3231, 3223, 7910, 8009, 3232
11355, 3223, 7910, 8009, 3232, 3224, 7911, 8010, 3233
11356, 3224, 7911, 8010, 3233, 617, 3390, 3401, 618
11357, 2931, 2932, 2943, 2942, 7903, 7912, 8011, 8002
11358, 7903, 7912, 8011, 8002, 7904, 7913, 8012, 8003
11359, 7904, 7913, 8012, 8003, 7905, 7914, 8013, 8004
11360, 7905, 7914, 8013, 8004, 7906, 7915, 8014, 8005
11361, 7906, 7915, 8014, 8005, 7907, 7916, 8015, 8006
11362, 7907, 7916, 8015, 8006, 7908, 7917, 8016, 8007
11363, 7908, 7917, 8016, 8007, 7909, 7918, 8017, 8008
11364, 7909, 7918, 8017, 8008, 7910, 7919, 8018, 8009
11365, 7910, 7919, 8018, 8009, 7911, 7920, 8019, 8010
11366, 7911, 7920, 8019, 8010, 3390, 3391, 3402, 3401
11367, 2932, 2933, 2944, 2943, 7912, 7921, 8020, 8011
11368, 7912, 7921, 8020, 8011, 7913, 7922, 8021, 8012
11369, 7913, 7922, 8021, 8012, 7914, 7923, 8022, 8013
11370, 7914, 7923, 8022, 8013, 7915, 7924, 8023, 8014
11371, 7915, 7924, 8023, 8014, 7916, 7925, 8024, 8015
11372, 7916, 7925, 8024, 8015, 7917, 7926, 8025, 8016
11373, 7917, 7926, 8025, 8016, 7918, 7927, 8026, 8017
11374, 7918, 7927, 8026, 8017, 7919, 7928, 8027, 8018
11375, 7919, 7928, 8027, 8018, 7920, 7929, 8028, 8019
11376, 7920, 7929, 8028, 8019, 3391, 3392, 3403, 3402
11377, 2933, 2934, 2945, 2944, 7921, 7930, 8029, 8020
11378, 7921, 7930, 8029, 8020, 7922, 7931, 8030, 8021
11379, 7922, 7931, 8030, 8021, 7923, 7932, 8031, 8022
11380, 7923, 7932, 8031, 8022, 7924, 7933, 8032, 8023
11381, 7924, 7933, 8032, 8023, 7925, 7934, 8033, 8024
11382, 7925, 7934, 8033, 8024, 7926, 7935, 8034, 8025
11383, 7926, 7935, 8034, 8025, 7927, 7936, 8035, 8026
11384, 7927, 7936, 8035, 8026, 7928, 7937, 8036, 8027
11385, 7928, 7937, 8036, 8027, 7929, 7938, 8037, 8028
11386, 7929, 7938, 8037, 8028, 3392, 3393, 3404, 3403
11387, 2934, 2935, 2946, 2945, 7930, 7939, 8038, 8029
11388, 7930, 7939, 8038, 8029, 7931, 7940, 8039, 8030
11389, 7931, 7940, 8039, 8030, 7932, 7941, 8040, 8031
11390, 7932, 7941, 8040, 8031, 7933, 7942, 8041, 8032
11391, 7933, 7942, 8041, 8032, 7934, 7943, 8042, 8033
11392, 7934, 7943, 8042, 8033, 7935, 7944, 8043, 8034
11393, 7935, 7944, 8043, 8034, 7936, 7945, 8044, 8035
11394, 7936, 7945, 8044, 8035, 7937, 7946, 8045, 8036
11395, 7937, 7946, 8045, 8036, 7938, 7947, 8046, 8037
11396, 7938, 7947, 8046, 8037, 3393, 3394, 3405, 3404
11397, 2935, 2936, 2947, 2946, 7939, 7948, 8047, 8038
11398, 7939, 7948, 8047, 8038, 7940, 7949, 8048, 8039
11399, 7940, 7949, 8048, 8039, 7941, 7950, 8049, 8040
11400, 7941, 7950, 8049, 8040, 7942, 7951, 8050, 8041
11401, 7942, 7951, 8050, 8041, 7943, 7952, 8051, 8042
11402, 7943, 7952, 8051, 8042, 7944, 7953, 8052, 8043
11403, 7944, 7953, 8052, 8043, 7945, 7954, 8053, 8044
11404, 7945, 7954, 8053, 8044, 7946, 7955, 8054, 8045
11405, 7946, 7955, 8054, 8045, 7947, 7956, 8055, 8046
11406, 7947, 7956, 8055, 8046, 3394, 3395, 3406, 3405
11407, 2936, 2937, 2948, 2947, 7948, 7957, 8056, 8047
11408, 7948, 7957, 8056, 8047, 7949, 7958, 8057, 8048
11409, 7949, 7958, 8057, 8048, 7950, 7959, 8058, 8049
11410, 7950, 7959, 8058, 8049, 7951, 7960, 8059, 8050
11411, 7951, 7960, 8059, 8050, 7952, 7961, 8060, 8051
11412, 7952, 7961, 8060, 8051, 7953, 7962, 8061, 8052
11413, 7953, 7962, 8061, 8052, 7954, 7963, 8062, 8053
11414, 7954, 7963, 8062, 8053, 7955, 7964, 8063, 8054
11415, 7955, 7964, 8063, 8054, 7956, 7965, 8064, 8055
11416, 7956, 7965, 8064, 8055, 3395, 3396, 3407, 3406
11417, 2937, 2938, 2949, 2948, 7957, 7966, 8065, 8056
11418, 7957, 7966, 8065, 8056, 7958, 7967, 8066, 8057
11419, 7958, 7967, 8066, 8057, 7959, 7968, 8067, 8058
11420, 7959, 7968, 8067, 8058, 7960, 7969, 8068, 8059
11421, 7960, 7969, 8068, 8059, 7961, 7970, 8069, 8060
11422, 7961, 7970, 8069, 8060, 7962, 7971, 8070, 8061
11423, 7962, 7971, 8070, 8061, 7963, 7972, 8071, 8062
11424, 7963, 7972, 8071, 8062, 7964, 7973, 8072, 8063
11425, 7964, 7973, 8072, 8063, 7965, 7974, 8073, 8064
11426, 7965, 7974, 8073, 8064, 3396, 3397, 3408, 3407
11427, 2938, 2939, 2950, 2949, 7966, 7975, 8074, 8065
11428, 7966, 7975, 8074, 8065, 7967, 7976, 8075, 8066
11429, 7967, 7976, 8075, 8066, 7968, 7977, 8076, 8067
11430, 7968, 7977, 8076, 8067, 7969, 7978, 8077, 8068
11431, 7969, 7978, 8077, 8068, 7970, 7979, 8078, 8069
11432, 7970, 7979, 8078, 8069, 7971, 7980, 8079, 8070
11433, 7971, 7980, 8079, 8070, 7972, 7981, 8080, 8071
11434, 7972, 7981, 8080, 8071, 7973, 7982, 8081, 8072
11435, 7973, 7982, 8081, 8072, 7974, 7983, 8082, 8073
11436, 7974, 7983, 8082, 8073, 3397, 3398, 3409, 3408
11437, 2939, 2940, 2951, 2950, 7975, 7984, 8083, 8074
11438, 7975, 7984, 8083, 8074, 7976, 7985, 8084, 8075
11439, 7976, 7985, 8084, 8075, 7977, 7986, 8085, 8076
11440, 7977, 7986, 8085, 8076, 7978, 7987, 8086, 8077
11441, 7978, 7987, 8086, 8077, 7979, 7988, 8087, 8078
11442, 7979, 7988, 8087, 8078, 7980, 7989, 8088, 8079
11443, 7980, 7989, 8088, 8079, 7981, 7990, 8089, 8080
11444, 7981, 7990, 8089, 8080, 7982, 7991, 8090, 8081
11445, 7982, 7991, 8090, 8081, 7983, 7992, 8091, 8082
11446, 7983, 7992, 8091, 8082, 3398, 3399, 3410, 3409
11447, 2940, 2941, 2952, 2951, 7984, 7993, 8092, 8083
11448, 7984, 7993, 8092, 8083, 7985, 7994, 8093, 8084
11449, 7985, 7994, 8093, 8084, 7986, 7995, 8094, 8085
11450, 7986, 7995, 8094, 8085, 7987, 7996, 8095, 8086
11451, 7987, 7996, 8095, 8086, 7988, 7997, 8096, 8087
11452, 7988, 7997, 8096, 8087, 7989, 7998, 8097, 8088
11453, 7989, 7998, 8097, 8088, 7990, 7999, 8098, 8089
11454, 7990, 7999, 8098, 8089, 7991, 8000, 8099, 8090
11455, 7991, 8000, 8099, 8090, 7992, 8001, 8100, 8091
11456, 7992, 8001, 8100, 8091, 3399, 3400, 3411, 3410
11457, 2941, 550, 551, 2952, 7993, 3297, 3306, 8092
11458, 7993, 3297, 3306, 8092, 7994, 3298, 3307, 8093
11459, 7994, 3298, 3307, 8093, 7995, 3299, 3308, 8094
11460, 7995, 3299, 3308, 8094, 7996, 3300, 3309, 8095
11461, 7996, 3300, 3309, 8095, 7997, 3301, 3310, 8096
11462, 7997, 3301, 3310, 8096, 7998, 3302, 3311, 8097
11463, 7998, 3302, 3311, 8097, 7999, 3303, 3312, 8098
11464, 7999, 3303, 3312, 8098, 8000, 3304, 3313, 8099
11465, 8000, 3304, 3313, 8099, 8001, 3305, 3314, 8100
11466, 8001, 3305, 3314, 8100, 3400, 626, 627, 3411
11467, 542, 2942, 2953, 543, 3225, 8002, 8101, 3234
11468, 3225, 8002, 8101, 3234, 3226, 8003, 8102, 3235
11469, 3226, 8003, 8102, 3235, 3227, 8004, 8103, 3236
11470, 3227, 8004, 8103, 3236, 3228, 8005, 8104, 3237
11471, 3228, 8005, 8104, 3237, 3229, 8006, 8105, 3238
11472, 3229, 8006, 8105, 3238, 3230, 8007, 8106, 3239
11473, 3230, 8007, 8106, 3239, 3231, 8008, 8107, 3240
11474, 3231, 8008, 8107, 3240, 3232, 8009, 8108, 3241
11475, 3232, 8009, 8108, 3241, 3233, 8010, 8109, 3242
11476, 3233, 8010, 8109, 3242, 618, 3401, 3412, 619
11477, 2942, 2943, 2954, 2953, 8002, 8011, 8110, 8101
11478, 8002, 8011, 8110, 8101, 8003, 8012, 8111, 8102
11479, 8003, 8012, 8111, 8102, 8004, 8013, 8112, 8103
11480, 8004, 8013, 8112, 8103, 8005, 8014, 8113, 8104
11481, 8005, 8014, 8113, 8104, 8006, 8015, 8114, 8105
11482, 8006, 8015, 8114, 8105, 8007, 8016, 8115, 8106
11483, 8007, 8016, 8115, 8106, 8008, 8017, 8116, 8107
11484, 8008, 8017, 8116, 8107, 8009, 8018, 8117, 8108
11485, 8009, 8018, 8117, 8108, 8010, 8019, 8118, 8109
11486, 8010, 8019, 8118, 8109, 3401, 3402, 3413, 3412
11487, 2943, 2944, 2955, 2954, 8011, 8020, 8119, 8110
11488, 8011, 8020, 8119, 8110, 8012, 8021, 8120, 8111
11489, 8012, 8021, 8120, 8111, 8013, 8022, 8121, 8112
11490, 8013, 8022, 8121, 8112, 8014, 8023, 8122, 8113
11491, 8014, 8023, 8122, 8113, 8015, 8024, 8123, 8114
11492, 8015, 8024, 8123, 8114, 8016, 8025, 8124, 8115
11493, 8016, 8025, 8124, 8115, 8017, 8026, 8125, 8116
11494, 8017, 8026, 8125, 8116, 8018, 8027, 8126, 8117
11495, 8018, 8027, 8126, 8117, 8019, 8028, 8127, 8118
11496, 8019, 8028, 8127, 8118, 3402, 3403, 3414, 3413
11497, 2944, 2945, 2956, 2955, 8020, 8029, 8128, 8119
11498, 8020, 8029, 8128, 8119, 8021, 8030, 8129, 8120
11499, 8021, 8030, 8129, 8120, 8022, 8031, 8130, 8121
11500, 8022, 8031, 8130, 8121, 8023, 8032, 8131, 8122
11501, 8023, 8032, 8131, 8122, 8024, 8033, 8132, 8123
11502, 8024, 8033, 8132, 8123, 8025, 8034, 8133, 8124
11503, 8025, 8034, 8133, 8124, 8026, 8035, 8134, 8125
11504, 8026, 8035, 8134, 8125, 8027, 8036, 8135, 8126
11505, 8027, 8036, 8135, 8126, 8028, 8037, 8136, 8127
11506, 8028, 8037, 8136, 8127, 3403, 3404, 3415, 3414
11507, 2945, 2946, 2957, 2956, 8029, 8038, 8137, 8128
11508, 8029, 8038, 8137, 8128, 8030, 8039, 8138, 8129
11509, 8030, 8039, 8138, 8129, 8031, 8040, 8139, 8130
11510, 8031, 8040, 8139, 8130, 8032, 8041, 8140, 8131
11511, 8032, 8041, 8140, 8131, 8033, 8042, 8141, 8132
11512, 8033, 8042, 8141, 8132, 8034, 8043, 8142, 8133
11513, 8034, 8043, 8142, 8133, 8035, 8044, 8143, 8134
11514, 8035, 8044, 8143, 8134, 8036, 8045, 8144, 8135
11515, 8036, 8045, 8144, 8135, 8037, 8046, 8145, 8136
11516, 8037, 8046, 8145, 8136, 3404, 3405, 3416, 3415
11517, 2946, 2947, 2958, 2957, 8038, 8047, 8146, 8137
11518, 8038, 8047, 8146, 8137, 8039, 8048, 8147, 8138
11519, 8039, 8048, 8147, 8138, 8040, 8049, 8148, 8139
11520, 8040, 8049, 8148, 8139, 8041, 8050, 8149, 8140
11521, 8041, 8050, 8149, 8140, 8042, 8051, 8150, 8141
11522, 8042, 8051, 8150, 8141, 8043, 8052, 8151, 8142
11523, 8043, 8052, 8151, 8142, 8044, 8053, 8152, 8143
11524, 8044, 8053, 8152, 8143, 8045, 8054, 8153, 8144
11525, 8045, 8054, 8153, 8144, 8046, 8055, 8154, 8145
11526, 8046, 8055, 8154, 8145, 3405, 3406, 3417, 3416
11527, 2947, 2948, 2959, 2958, 8047, 8056, 8155, 8146
11528, 8047, 8056, 8155, 8146, 8048, 8057, 8156, 8147
11529, 8048, 8057, 8156, 8147, 8049, 8058, 8157, 8148
11530, 8049, 8058, 8157, 8148, 8050, 8059, 8158, 8149
11531, 8050, 8059, 8158, 8149, 8051, 8060, 8159, 8150
11532, 8051, 8060, 8159, 8150, 8052, 8061, 8160, 8151
11533, 8052, 8061, 8160, 8151, 8053, 8062, 8161, 8152
11534, 8053, 8062, 8161, 8152, 8054, 8063, 8162, 8153
11535, 8054, 8063, 8162, 8153, 8055, 8064, 8163, 8154
11536, 8055, 8064, 8163, 8154, 3406, 3407, 3418, 3417
11537, 2948, 2949, 2960, 2959, 8056, 8065, 8164, 8155
11538, 8056, 8065, 8164, 8155, 8057, 8066, 8165, 8156
11539, 8057, 8066, 8165, 8156, 8058, 8067, 8166, 8157
11540, 8058, 8067, 8166, 8157, 8059, 8068, 8167, 8158
11541, 8059, 8068, 8167, 8158, 8060, 8069, 8168, 8159
11542, 8060, 8069, 8168, 8159, 8061, 8070, 8169, 8160
11543, 8061, 8070, 8169, 8160, 8062, 8071, 8170, 8161
11544, 8062, 8071, 8170, 8161, 8063, 8072, 8171, 8162
11545, 8063, 8072, 8171, 8162, 8064, 8073, 8172, 8163
11546, 8064, 8073, 8172, 8163, 3407, 3408, 3419, 3418
11547, 2949, 2950, 2961, 2960, 8065, 8074, 8173, 8164
11548, 8065, 8074, 8173, 8164, 8066, 8075, 8174, 8165
11549, 8066, 8075, 8174, 8165, 8067, 8076, 8175, 8166
11550, 8067, 8076, 8175, 8166, 8068, 8077, 8176, 8167
11551, 8068, 8077, 8176, 8167, 8069, 8078, 8177, 8168
11552, 8069, 8078, 8177, 8168, 8070, 8079, 8178, 8169
11553, 8070, 8079, 8178, 8169, 8071, 8080, 8179, 8170
11554, 8071, 8080, 8179, 8170, 8072, 8081, 8180, 8171
11555, 8072, 8081, 8180, 8171, 8073, 8082, 8181, 8172
11556, 8073, 8082, 8181, 8172, 3408, 3409, 3420, 3419
11557, 2950, 2951, 2962, 2961, 8074, 8083, 8182, 8173
11558, 8074, 8083, 8182, 8173, 8075, 8084, 8183, 8174
11559, 8075, 8084, 8183, 8174, 8076, 8085, 8184, 8175
11560, 8076, 8085, 8184, 8175, 8077, 8086, 8185, 8176
11561, 8077, 8086, 8185, 8176, 8078, 8087, 8186, 8177
11562, 8078, 8087, 8186, 8177, 8079, 8088, 8187, 8178
11563, 8079, 8088, 8187, 8178, 8080, 8089, 8188, 8179
11564, 8080, 8089, 8188, 8179, 8081, 8090, 8189, 8180
11565, 8081, 8090, 8189, 8180, 8082, 8091, 8190, 8181
11566, 8082, 8091, 8190, 8181, 3409, 3410, 3421, 3420
11567, 2951, 2952, 2963, 2962, 8083, 8092, 8191, 8182
11568, 8083, 8092, 8191, 8182, 8084, 8093, 8192, 8183
11569, 8084, 8093, 8192, 8183, 8085, 8094, 8193, 8184
11570, 8085, 8094, 8193, 8184, 8086, 8095, 8194, 8185
11571, 8086, 8095, 8194, 8185, 8087, 8096, 8195, 8186
11572, 8087, 8096, 8195, 8186, 8088, 8097, 8196, 8187
11573, 8088, 8097, 8196, 8187, 8089, 8098, 8197, 8188
11574, 8089, 8098, 8197, 8188, 8090, 8099, 8198, 8189
11575, 8090, 8099, 8198, 8189, 8091, 8100, 8199, 8190
11576, 8091, 8100, 8199, 8190, 3410, 3411, 3422, 3421
11577, 2952, 551, 552, 2963, 8092, 3306, 3315, 8191
11578, 8092, 3306, 3315, 8191, 8093, 3307, 3316, 8192
11579, 8093, 3307, 3316, 8192, 8094, 3308, 3317, 8193
11580, 8094, 3308, 3317, 8193, 8095, 3309, 3318, 8194
11581, 8095, 3309, 3318, 8194, 8096, 3310, 3319, 8195
11582, 8096, 3310, 3319, 8195, 8097, 3311, 3320, 8196
11583, 8097, 3311, 3320, 8196, 8098, 3312, 3321, 8197
11584, 8098, 3312, 3321, 8197, 8099, 3313, 3322, 8198
11585, 8099, 3313, 3322, 8198, 8100, 3314, 3323, 8199
11586, 8100, 3314, 3323, 8199, 3411, 627, 628, 3422
11587, 543, 2953, 513, 33, 3234, 8101, 2964, 553
11588, 3234, 8101, 2964, 553, 3235, 8102, 2965, 554
11589, 3235, 8102, 2965, 554, 3236, 8103, 2966, 555
11590, 3236, 8103, 2966, 555, 3237, 8104, 2967, 556
11591, 3237, 8104, 2967, 556, 3238, 8105, 2968, 557
11592, 3238, 8105, 2968, 557, 3239, 8106, 2969, 558
11593, 3239, 8106, 2969, 558, 3240, 8107, 2970, 559
11594, 3240, 8107, 2970, 559, 3241, 8108, 2971, 560
11595, 3241, 8108, 2971, 560, 3242, 8109, 2972, 561
11596, 3242, 8109, 2972, 561, 619, 3412, 571, 37
11597, 2953, 2954, 514, 513, 8101, 8110, 2973, 2964
11598, 8101, 8110, 2973, 2964, 8102, 8111, 2974, 2965
11599, 8102, 8111, 2974, 2965, 8103, 8112, 2975, 2966
11600, 8103, 8112, 2975, 2966, 8104, 8113, 2976, 2967
11601, 8104, 8113, 2976, 2967, 8105, 8114, 2977, 2968
11602, 8105, 8114, 2977, 2968, 8106, 8115, 2978, 2969
11603, 8106, 8115, 2978, 2969, 8107, 8116, 2979, 2970
11604, 8107, 8116, 2979, 2970, 8108, 8117, 2980, 2971
11605, 8108, 8117, 2980, 2971, 8109, 8118, 2981, 2972
11606, 8109, 8118, 2981, 2972, 3412, 3413, 572, 571
11607, 2954, 2955, 515, 514, 8110, 8119, 2982, 2973
11608, 8110, 8119, 2982, 2973, 8111, 8120, 2983, 2974
11609, 8111, 8120, 2983, 2974, 8112, 8121, 2984, 2975
11610, 8112, 8121, 2984, 2975, 8113, 8122, 2985, 2976
11611, 8113, 8122, 2985, 2976, 8114, 8123, 2986, 2977
11612, 8114, 8123, 2986, 2977, 8115, 8124, 2987, 2978
11613, 8115, 8124, 2987, 2978, 8116, 8125, 2988, 2979
11614, 8116, 8125, 2988, 2979, 8117, 8126, 2989, 2980
11615, 8117, 8126, 2989, 2980, 8118, 8127, 2990, 2981
11616, 8118, 8127, 2990, 2981, 3413, 3414, 573, 572
11617, 2955, 2956, 516, 515, 8119, 8128, 2991, 2982
11618, 8119, 8128, 2991, 2982, 8120, 8129, 2992, 2983
11619, 8120, 8129, 2992, 2983, 8121, 8130, 2993, 2984
11620, 8121, 8130, 2993, 2984, 8122, 8131, 2994, 2985
11621, 8122, 8131, 2994, 2985, 8123, 8132, 2995, 2986
11622, 8123, 8132, 2995, 2986, 8124, 8133, 2996, 2987
11623, 8124, 8133, 2996, 2987, 8125, 8134, 2997, 2988
11624, 8125, 8134, 2997, 2988, 8126, 8135, 2998, 2989
11625, 8126, 8135, 2998, 2989, 8127, 8136, 2999, 2990
11626, 8127, 8136, 2999, 2990, 3414, 3415, 574, 573
11627, 2956, 2957, 517, 516, 8128, 8137, 3000, 2991
11628, 8128, 8137, 3000, 2991, 8129, 8138, 3001, 2992
11629, 8129, 8138, 3001, 2992, 8130, 8139, 3002, 2993
11630, 8130, 8139, 3002, 2993, 8131, 8140, 3003, 2994
11631, 8131, 8140, 3003, 2994, 8132, 8141, 3004, 2995
11632, 8132, 8141, 3004, 2995, 8133, 8142, 3005, 2996
11633, 8133, 8142, 3005, 2996, 8134, 8143, 3006, 2997
11634, 8134, 8143, 3006, 2997, 8135, 8144, 3007, 2998
11635, 8135, 8144, 3007, 2998, 8136, 8145, 3008, 2999
11636, 8136, 8145, 3008, 2999, 3415, 3416, 575, 574
11637, 2957, 2958, 518, 517, 8137, 8146, 3009, 3000
11638, 8137, 8146, 3009, 3000, 8138, 8147, 3010, 3001
11639, 8138, 8147, 3010, 3001, 8139, 8148, 3011, 3002
11640, 8139, 8148, 3011, 3002, 8140, 8149, 3012, 3003
11641, 8140, 8149, 3012, 3003, 8141, 8150, 3013, 3004
11642, 8141, 8150, 3013, 3004, 8142, 8151, 3014, 3005
11643, 8142, 8151, 3014, 3005, 8143, 8152, 3015, 3006
11644, 8143, 8152, 3015, 3006, 8144, 8153, 3016, 3007
11645, 8144, 8153, 3016, 3007, 8145, 8154, 3017, 3008
11646, 8145, 8154, 3017, 3008, 3416, 3417, 576, 575
11647, 2958, 2959, 519, 518, 8146, 8155, 3018, 3009
11648, 8146, 8155, 3018, 3009, 8147, 8156, 3019, 3010
11649, 8147, 8156, 3019, 3010, 8148, 8157, 3020, 3011
11650, 8148, 8157, 3020, 3011, 8149, 8158, 3021, 3012
11651, 8149, 8158, 3021, 3012, 8150, 8159, 3022, 3013
11652, 8150, 8159, 3022, 3013, 8151, 8160, 3023, 3014
11653, 8151, 8160, 3023, 3014, 8152, 8161, 3024, 3015
11654, 8152, 8161, 3024, 3015, 8153, 8162, 3025, 3016
11655, 8153, 8162, 3025, 3016, 8154, 8163, 3026, 3017
11656, 8154, 8163, 3026, 3017, 3417, 3418, 577, 576
11657, 2959, 2960, 520, 519, 8155, 8164, 3027, 3018
11658, 8155, 8164, 3027, 3018, 8156, 8165, 3028, 3019
11659, 8156, 8165, 3028, 3019, 8157, 8166, 3029, 3020
11660, 8157, 8166, 3029, 3020, 8158, 8167, 3030, 3021
11661, 8158, 8167, 3030, 3021, 8159, 8168, 3031, 3022
11662, 8159, 8168, 3031, 3022, 8160, 8169, 3032, 3023
11663, 8160, 8169, 3032, 3023, 8161, 8170, 3033, 3024
11664, 8161, 8170, 3033, 3024, 8162, 8171, 3034, 3025
11665, 8162, 8171, 3034, 3025, 8163, 8172, 3035, 3026
11666, 8163, 8172, 3035, 3026, 3418, 3419, 578, 577
11667, 2960, 2961, 521, 520, 8164, 8173, 3036, 3027
11668, 8164, 8173, 3036, 3027, 8165, 8174, 3037, 3028
11669, 8165, 8174, 3037, 3028, 8166, 8175, 3038, 3029
11670, 8166, 8175, 3038, 3029, 8167, 8176, 3039, 3030
11671, 8167, 8176, 3039, 3030, 8168, 8177, 3040, 3031
11672, 8168, 8177, 3040, 3031, 8169, 8178, 3041, 3032
11673, 8169, 8178, 3041, 3032, 8170, 8179, 3042, 3033
11674, 8170, 8179, 3042, 3033, 8171, 8180, 3043, 3034
11675, 8171, 8180, 3043, 3034, 8172, 8181, 3044, 3035
11676, 8172, 8181, 3044, 3035, 3419, 3420, 579, 578
11677, 2961, 2962, 522, 521, 8173, 8182, 3045, 3036
11678, 8173, 8182, 3045, 3036, 8174, 8183, 3046, 3037
11679, 8174, 8183, 3046, 3037, 8175, 8184, 3047, 3038
11680, 8175, 8184, 3047, 3038, 8176, 8185, 3048, 3039
11681, 8176, 8185, 3048, 3039, 8177, 8186, 3049, 3040
11682, 8177, 8186, 3049, 3040, 8178, 8187, 3050, 3041
11683, 8178, 8187, 3050, 3041, 8179, 8188, 3051, 3042
11684, 8179, 8188, 3051, 3042, 8180, 8189, 3052, 3043
11685, 8180, 8189, 3052, 3043, 8181, 8190, 3053, 3044
11686, 8181, 8190, 3053, 3044, 3420, 3421, 580, 579
11687, 2962, 2963, 523, 522, 8182, 8191, 3054, 3045
11688, 8182, 8191, 3054, 3045, 8183, 8192, 3055, 3046
11689, 8183, 8192, 3055, 3046, 8184, 8193, 3056, 3047
11690, 8184, 8193, 3056, 3047, 8185, 8194, 3057, 3048
11691, 8185, 8194, 3057, 3048, 8186, 8195, 3058, 3049
11692, 8186, 8195, 3058, 3049, 8187, 8196, 3059, 3050
11693, 8187, 8196, 3059, 3050, 8188, 8197, 3060, 3051
11694, 8188, 8197, 3060, 3051, 8189, 8198, 3061, 3052
11695, 8189, 8198, 3061, 3052, 8190, 8199, 3062, 3053
11696, 8190, 8199, 3062, 3053, 3421, 3422, 581, 580
11697, 2963, 552, 34, 523, 8191, 3315, 562, 3054
11698, 8191, 3315, 562, 3054, 8192, 3316, 563, 3055
11699, 8192, 3316, 563, 3055, 8193, 3317, 564, 3056
11700, 8193, 3317, 564, 3056, 8194, 3318, 565, 3057
11701, 8194, 3318, 565, 3057, 8195, 3319, 566, 3058
11702, 8195, 3319, 566, 3058, 8196, 3320, 567, 3059
11703, 8196, 3320, 567, 3059, 8197, 3321, 568, 3060
11704, 8197, 3321, 568, 3060, 8198, 3322, 569, 3061
11705, 8198, 3322, 569, 3061, 8199, 3323, 570, 3062
11706, 8199, 3323, 570, 3062, 3422, 628, 38, 581
*ELEMENT, type=C3D8, ELSET=Volume10
11707, 39, 600, 3324, 611, 43, 640, 3423, 651
11708, 600, 601, 3325, 3324, 640, 641, 3424, 3423
11709, 601, 602, 3326, 3325, 641, 642, 3425, 3424
11710, 602, 603, 3327, 3326, 642, 643, 3426, 3425
11711, 603, 604, 3328, 3327, 643, 644, 3427, 3426
11712, 604, 605, 3329, 3328, 644, 645, 3428, 3427
11713, 605, 606, 3330, 3329, 645, 646, 3429, 3428
11714, 606, 607, 3331, 3330, 646, 647, 3430, 3429
11715, 607, 608, 3332, 3331, 647, 648, 3431, 3430
11716, 608, 609, 3333, 3332, 648, 649, 3432, 3431
11717, 609, 610, 3334, 3333, 649, 650, 3433, 3432
11718, 610, 40, 620, 3334, 650, 44, 660, 3433
11719, 611, 3324, 3335, 612, 651, 3423, 3434, 652
11720, 3324, 3325, 3336, 3335, 3423, 3424, 3435, 3434
11721, 3325, 3326, 3337, 3336, 3424, 3425, 3436, 3435
11722, 3326, 3327, 3338, 3337, 3425, 3426, 3437, 3436
11723, 3327, 3328, 3339, 3338, 3426, 3427, 3438, 3437
11724, 3328, 3329, 3340, 3339, 3427, 3428, 3439, 3438
11725, 3329, 3330, 3341, 3340, 3428, 3429, 3440, 3439
11726, 3330, 3331, 3342, 3341, 3429, 3430, 3441, 3440
11727, 3331, 3332, 3343, 3342, 3430, 3431, 3442, 3441
11728, 3332, 3333, 3344, 3343, 3431, 3432, 3443, 3442
11729, 3333, 3334, 3345, 3344, 3432, 3433, 3444, 3443
11730, 3334, 620, 621, 3345, 3433, 660, 661, 3444
11731, 612, 3335, 3346, 613, 652, 3434, 3445, 653
11732, 3335, 3336, 3347, 3346, 3434, 3435, 3446, 3445
11733, 3336, 3337, 3348, 3347, 3435, 3436, 3447, 3446
11734, 3337, 3338, 3349, 3348, 3436, 3437, 3448, 3447
11735, 3338, 3339, 3350, 3349, 3437, 3438, 3449, 3448
11736, 3339, 3340, 3351, 3350, 3438, 3439, 3450, 3449
11737, 3340, 3341, 3352, 3351, 3439, 3440, 3451, 3450
11738, 3341, 3342, 3353, 3352, 3440, 3441, 3452, 3451
11739, 3342, 3343, 3354, 3353, 3441, 3442, 3453, 3452
11740, 3343, 3344, 3355, 3354, 3442, 3443, 3454, 3453
11741, 3344, 3345, 3356, 3355, 3443, 3444, 3455, 3454
11742, 3345, 621, 622, 3356, 3444, 661, 662, 3455
11743, 613, 3346, 3357, 614, 653, 3445, 3456, 654
11744, 3346, 3347, 3358, 3357, 3445, 3446, 3457, 3456
11745, 3347, 3348, 3359, 3358, 3446, 3447, 3458, 3457
11746, 3348, 3349, 3360, 3359, 3447, 3448, 3459, 3458
11747, 3349, 3350, 3361, 3360, 3448, 3449, 3460, 3459
11748, 3350, 3351, 3362, 3361, 3449, 3450, 3461, 3460
11749, 3351, 3352, 3363, 3362, 3450, 3451, 3462, 3461
11750, 3352, 3353, 3364, 3363, 3451, 3452, 3463, 3462
11751, 3353, 3354, 3365, 3364, 3452, 3453, 3464, 3463
11752, 3354, 3355, 3366, 3365, 3453, 3454, 3465, 3464
11753, 3355, 3356, 3367, 3366, 3454, 3455, 3466, 3465
11754, 3356, 622, 623, 3367, 3455, 662, 663, 3466
11755, 614, 3357, 3368, 615, 654, 3456, 3467, 655
11756, 3357, 3358, 3369, 3368, 3456, 3457, 3468, 3467
11757, 3358, 3359, 3370, 3369, 3457, 3458, 3469, 3468
11758, 3359, 3360, 3371, 3370, 3458, 3459, 3470, 3469
11759, 3360, 3361, 3372, 3371, 3459, 3460, 3471, 3470
11760, 3361, 3362, 3373, 3372, 3460, 3461, 3472, 3471
11761, 3362, 3363, 3374, 3373, 3461, 3462, 3473, 3472
11762, 3363, 3364, 3375, 3374, 3462, 3463, 3474, 3473
11763, 3364, 3365, 3376, 3375, 3463, 3464, 3475, 3474
11764, 3365, 3366, 3377, 3376, 3464, 3465, 3476, 3475
11765, 3366, 3367, 3378, 3377, 3465, 3466, 3477, 3476
11766, 3367, 623, 624, 3378, 3466, 663, 664, 3477
11767, 615, 3368, 3379, 616, 655, 3467, 3478, 656
11768, 3368, 3369, 3380, 3379, 3467, 3468, 3479, 3478
11769, 3369, 3370, 3381, 3380, 3468, 3469, 3480, 3479
11770, 3370, 3371, 3382, 3381, 3469, 3470, 3481, 3480
11771, 3371, 3372, 3383, 3382, 3470, 3471, 3482, 3481
11772, 3372, 3373, 3384, 3383, 3471, 3472, 3483, 3482
11773, 3373, 3374, 3385, 3384, 3472, 3473, 3484, 3483
11774, 3374, 3375, 3386, 3385, 3473, 3474, 3485, 3484
11775, 3375, 3376, 3387, 3386, 3474, 3475, 3486, 3485
11776, 3376, 3377, 3388, 3387, 3475, 3476, 3487, 3486
11777, 3377, 3378, 3389, 3388, 3476, 3477, 3488, 3487
11778, 3378, 624, 625, 3389, 3477, 664, 665, 3488
11779, 616, 3379, 3390, 617, 656, 3478, 3489, 657
11780, 3379, 3380, 3391, 3390, 3478, 3479, 3490, 3489
11781, 3380, 3381, 3392, 3391, 3479, 3480, 3491, 3490
11782, 3381, 3382, 3393, 3392, 3480, 3481, 3492, 3491
11783, 3382, 3383, 3394, 3393, 3481, 3482, 3493, 3492
11784, 3383, 3384, 3395, 3394, 3482, 3483, 3494, 3493
11785, 3384, 3385, 3396, 3395, 3483, 3484, 3495, 3494
11786, 3385, 3386, 3397, 3396, 3484, 3485, 3496, 3495
11787, 3386, 3387, 3398, 3397, 3485, 3486, 3497, 3496
11788, 3387, 3388, 3399, 3398, 3486, 3487, 3498, 3497
11789, 3388, 3389, 3400, 3399, 3487, 3488, 3499, 3498
11790, 3389, 625, 626, 3400, 3488, 665, 666, 3499
11791, 617, 3390, 3401, 618, 657, 3489, 3500, 658
11792, 3390, 3391, 3402, 3401, 3489, 3490, 3501, 3500
11793, 3391, 3392, 3403, 3402, 3490, 3491, 3502, 3501
11794, 3392, 3393, 3404, 3403, 3491, 3492, 3503, 3502
11795, 3393, 3394, 3405, 3404, 3492, 3493, 3504, 3503
11796, 3394, 3395, 3406, 3405, 3493, 3494, 3505, 3504
11797, 3395, 3396, 3407, 3406, 3494, 3495, 3506, 3505
11798, 3396, 3397, 3408, 3407, 3495, 3496, 3507, 3506
11799, 3397, 3398, 3409, 3408, 3496, 3497, 3508, 3507
11800, 3398, 3399, 3410, 3409, 3497, 3498, 3509, 3508
11801, 3399, 3400, 3411, 3410, 3498, 3499, 3510, 3509
11802, 3400, 626, 627, 3411, 3499, 666, 667, 3510
11803, 618, 3401, 3412, 619, 658, 3500, 3511, 659
11804, 3401, 3402, 3413, 3412, 3500, 3501, 3512, 3511
11805, 3402, 3403, 3414, 3413, 3501, 3502, 3513, 3512
11806, 3403, 3404, 3415, 3414, 3502, 3503, 3514, 3513
11807, 3404, 3405, 3416, 3415, 3503, 3504, 3515, 3514
11808, 3405, 3406, 3417, 3416, 3504, 3505, 3516, 3515
11809, 3406, 3407, 3418, 3417, 3505, 3506, 3517, 3516
11810, 3407, 3408, 3419, 3418, 3506, 3507, 3518, 3517
11811, 3408, 3409, 3420, 3419, 3507, 3508, 3519, 3518
11812, 3409, 3410, 3421, 3420, 3508, 3509, 3520, 3519
11813, 3410, 3411, 3422, 3421, 3509, 3510, 3521, 3520
11814, 3411, 627, 628, 3422, 3510, 667, 668, 3521
11815, 619, 3412, 571, 37, 659, 3511, 629, 41
11816, 3412, 3413, 572, 571, 3511, 3512, 630, 629
11817, 3413, 3414, 573, 572, 3512, 3513, 631, 630
11818, 3414, 3415, 574, 573, 3513, 3514, 632, 631
11819, 3415, 3416, 575, 574, 3514, 3515, 633, 632
11820, 3416, 3417, 576, 575, 3515, 3516, 634, 633
11821, 3417, 3418, 577, 576, 3516, 3517, 635, 634
11822, 3418, 3419, 578, 577, 3517, 3518, 636, 635
11823, 3419, 3420, 579, 578, 3518, 3519, 637, 636
11824, 3420, 3421, 580, 579, 3519, 3520, 638, 637
11825, 3421, 3422, 581, 580, 3520, 3521, 639, 638
11826, 3422, 628, 38, 581, 3521, 668, 42, 639
*ELEMENT, type=C3D8, ELSET=Volume11
11827, 43, 640, 3423, 651, 686, 3555, 8200, 3588
11828, 686, 3555, 8200, 3588, 687, 3556, 8201, 3589
11829, 687, 3556, 8201, 3589, 688, 3557, 8202, 3590
11830, 688, 3557, 8202, 3590, 47, 692, 3642, 703
11831, 640, 641, 3424, 3423, 3555, 3558, 8203, 8200
11832, 3555, 3558, 8203, 8200, 3556, 3559, 8204, 8201
11833, 3556, 3559, 8204, 8201, 3557, 3560, 8205, 8202
11834, 3557, 3560, 8205, 8202, 692, 693, 3643, 3642
11835, 641, 642, 3425, 3424, 3558, 3561, 8206, 8203
11836, 3558, 3561, 8206, 8203, 3559, 3562, 8207, 8204
11837, 3559, 3562, 8207, 8204, 3560, 3563, 8208, 8205
11838, 3560, 3563, 8208, 8205, 693, 694, 3644, 3643
11839, 642, 643, 3426, 3425, 3561, 3564, 8209, 8206
11840, 3561, 3564, 8209, 8206, 3562, 3565, 8210, 8207
11841, 3562, 3565, 8210, 8207, 3563, 3566, 8211, 8208
11842, 3563, 3566, 8211, 8208, 694, 695, 3645, 3644
11843, 643, 644, 3427, 3426, 3564, 3567, 8212, 8209
11844, 3564, 3567, 8212, 8209, 3565, 3568, 8213, 8210
11845, 3565, 3568, 8213, 8210, 3566, 3569, 8214, 8211
11846, 3566, 3569, 8214, 8211, 695, 696, 3646, 3645
11847, 644, 645, 3428, 3427, 3567, 3570, 8215, 8212
11848, 3567, 3570, 8215, 8212, 3568, 3571, 8216, 8213
11849, 3568, 3571, 8216, 8213, 3569, 3572, 8217, 8214
11850, 3569, 3572, 8217, 8214, 696, 697, 3647, 3646
11851, 645, 646, 3429, 3428, 3570, 3573, 8218, 8215
11852, 3570, 3573, 8218, 8215, 3571, 3574, 8219, 8216
11853, 3571, 3574, 8219, 8216, 3572, 3575, 8220, 8217
11854, 3572, 3575, 8220, 8217, 697, 698, 3648, 3647
11855, 646, 647, 3430, 3429, 3573, 3576, 8221, 8218
11856, 3573, 3576, 8221, 8218, 3574, 3577, 8222, 8219
11857, 3574, 3577, 8222, 8219, 3575, 3578, 8223, 8220
11858, 3575, 3578, 8223, 8220, 698, 699, 3649, 3648
11859, 647, 648, 3431, 3430, 3576, 3579, 8224, 8221
11860, 3576, 3579, 8224, 8221, 3577, 3580, 8225, 8222
11861, 3577, 3580, 8225, 8222, 3578, 3581, 8226, 8223
11862, 3578, 3581, 8226, 8223, 699, 700, 3650, 3649
11863, 648, 649, 3432, 3431, 3579, 3582, 8227, 8224
11864, 3579, 3582, 8227, 8224, 3580, 3583, 8228, 8225
11865, 3580, 3583, 8228, 8225, 3581, 3584, 8229, 8226
11866, 3581, 3584, 8229, 8226, 700, 701, 3651, 3650
11867, 649, 650, 3433, 3432, 3582, 3585, 8230, 8227
11868, 3582, 3585, 8230, 8227, 3583, 3586, 8231, 8228
11869, 3583, 3586, 8231, 8228, 3584, 3587, 8232, 8229
11870, 3584, 3587, 8232, 8229, 701, 702, 3652, 3651
11871, 650, 44, 660, 3433, 3585, 689, 3615, 8230
11872, 3585, 689, 3615, 8230, 3586, 690, 3616, 8231
11873, 3586, 690, 3616, 8231, 3587, 691, 3617, 8232
11874, 3587, 691, 3617, 8232, 702, 48, 712, 3652
11875, 651, 3423, 3434, 652, 3588, 8200, 8233, 3591
11876, 3588, 8200, 8233, 3591, 3589, 8201, 8234, 3592
11877, 3589, 8201, 8234, 3592, 3590, 8202, 8235, 3593
11878, 3590, 8202, 8235, 3593, 703, 3642, 3653, 704
11879, 3423, 3424, 3435, 3434, 8200, 8203, 8236, 8233
11880, 8200, 8203, 8236, 8233, 8201, 8204, 8237, 8234
11881, 8201, 8204, 8237, 8234, 8202, 8205, 8238, 8235
11882, 8202, 8205, 8238, 8235, 3642, 3643, 3654, 3653
11883, 3424, 3425, 3436, 3435, 8203, 8206, 8239, 8236
11884, 8203, 8206, 8239, 8236, 8204, 8207, 8240, 8237
11885, 8204, 8207, 8240, 8237, 8205, 8208, 8241, 8238
11886, 8205, 8208, 8241, 8238, 3643, 3644, 3655, 3654
11887, 3425, 3426, 3437, 3436, 8206, 8209, 8242, 8239
11888, 8206, 8209, 8242, 8239, 8207, 8210, 8243, 8240
11889, 8207, 8210, 8243, 8240, 8208, 8211, 8244, 8241
11890, 8208, 8211, 8244, 8241, 3644, 3645, 3656, 3655
11891, 3426, 3427, 3438, 3437, 8209, 8212, 8245, 8242
11892, 8209, 8212, 8245, 8242, 8210, 8213, 8246, 8243
11893, 8210, 8213, 8246, 8243, 8211, 8214, 8247, 8244
11894, 8211, 8214, 8247, 8244, 3645, 3646, 3657, 3656
11895, 3427, 3428, 3439, 3438, 8212, 8215, 8248, 8245
11896, 8212, 8215, 8248, 8245, 8213, 8216, 8249, 8246
11897, 8213, 8216, 8249, 8246, 8214, 8217, 8250, 8247
11898, 8214, 8217, 8250, 8247, 3646, 3647, 3658, 3657
11899, 3428, 3429, 3440, 3439, 8215, 8218, 8251, 8248
11900, 8215, 8218, 8251, 8248, 8216, 8219, 8252, 8249
11901, 8216, 8219, 8252, 8249, 8217, 8220, 8253, 8250
11902, 8217, 8220, 8253, 8250, 3647, 3648, 3659, 3658
11903, 3429, 3430, 3441, 3440, 8218, 8221, 8254, 8251
11904, 8218, 8221, 8254, 8251, 8219, 8222, 8255, 8252
11905, 8219, 8222, 8255, 8252, 8220, 8223, 8256, 8253
11906, 8220, 8223, 8256, 8253, 3648, 3649, 3660, 3659
11907, 3430, 3431, 3442, 3441, 8221, 8224, 8257, 8254
11908, 8221, 8224, 8257, 8254, 8222, 8225, 8258, 8255
11909, 8222, 8225, 8258, 8255, 8223, 8226, 8259, 8256
11910, 8223, 8226, 8259, 8256, 3649, 3650, 3661, 3660
11911, 3431, 3432, 3443, 3442, 8224, 8227, 8260, 8257
11912, 8224, 8227, 8260, 8257, 8225, 8228, 8261, 8258
11913, 8225, 8228, 8261, 8258, 8226, 8229, 8262, 8259
11914, 8226, 8229, 8262, 8259, 3650, 3651, 3662, 3661
11915, 3432, 3433, 3444, 3443, 8227, 8230, 8263, 8260
11916, 8227, 8230, 8263, 8260, 8228, 8231, 8264, 8261
11917, 8228, 8231, 8264, 8261, 8229, 8232, 8265, 8262
11918, 8229, 8232, 8265, 8262, 3651, 3652, 3663, 3662
11919, 3433, 660, 661, 3444, 8230, 3615, 3618, 8263
11920, 8230, 3615, 3618, 8263, 8231, 3616, 3619, 8264
11921, 8231, 3616, 3619, 8264, 8232, 3617, 3620, 8265
11922, 8232, 3617, 3620, 8265, 3652, 712, 713, 3663
11923, 652, 3434, 3445, 653, 3591, 8233, 8266, 3594
11924, 3591, 8233, 8266, 3594, 3592, 8234, 8267, 3595
11925, 3592, 8234, 8267, 3595, 3593, 8235, 8268, 3596
11926, 3593, 8235, 8268, 3596, 704, 3653, 3664, 705
11927, 3434, 3435, 3446, 3445, 8233, 8236, 8269, 8266
11928, 8233, 8236, 8269, 8266, 8234, 8237, 8270, 8267
11929, 8234, 8237, 8270, 8267, 8235, 8238, 8271, 8268
11930, 8235, 8238, 8271, 8268, 3653, 3654, 3665, 3664
11931, 3435, 3436, 3447, 3446, 8236, 8239, 8272, 8269
11932, 8236, 8239, 8272, 8269, 8237, 8240, 8273, 8270
11933, 8237, 8240, 8273, 8270, 8238, 8241, 8274, 8271
11934, 8238, 8241, 8274, 8271, 3654, 3655, 3666, 3665
11935, 3436, 3437, 3448, 3447, 8239, 8242, 8275, 8272
11936, 8239, 8242, 8275, 8272, 8240, 8243, 8276, 8273
11937, 8240, 8243, 8276, 8273, 8241, 8244, 8277, 8274
11938, 8241, 8244, 8277, 8274, 3655, 3656, 3667, 3666
11939, 3437, 3438, 3449, 3448, 8242, 8245, 8278, 8275
11940, 8242, 8245, 8278, 8275, 8243, 8246, 8279, 8276
11941, 8243, 8246, 8279, 8276, 8244, 8247, 8280, 8277
11942, 8244, 8247, 8280, 8277, 3656, 3657, 3668, 3667
11943, 3438, 3439, 3450, 3449, 8245, 8248, 8281, 8278
11944, 8245, 8248, 8281, 8278, 8246, 8249, 8282, 8279
11945, 8246, 8249, 8282, 8279, 8247, 8250, 8283, 8280
11946, 8247, 8250, 8283, 8280, 3657, 3658, 3669, 3668
11947, 3439, 3440, 3451, 3450, 8248, 8251, 8284, 8281
11948, 8248, 8251, 8284, 8281, 8249, 8252, 8285, 8282
11949, 8249, 8252, 8285, 8282, 8250, 8253, 8286, 8283
11950, 8250, 8253, 8286, 8283, 3658, 3659, 3670, 3669
11951, 3440, 3441, 3452, 3451, 8251, 8254, 8287, 8284
11952, 8251, 8254, 8287, 8284, 8252, 8255, 8288, 8285
11953, 8252, 8255, 8288, 8285, 8253, 8256, 8289, 8286
11954, 8253, 8256, 8289, 8286, 3659, 3660, 3671, 3670
11955, 3441, 3442, 3453, 3452, 8254, 8257, 8290, 8287
11956, 8254, 8257, 8290, 8287, 8255, 8258, 8291, 8288
11957, 8255, 8258, 8291, 8288, 8256, 8259, 8292, 8289
11958, 8256, 8259, 8292, 8289, 3660, 3661, 3672, 3671
11959, 3442, 3443, 3454, 3453, 8257, 8260, 8293, 8290
11960, 8257, 8260, 8293, 8290, 8258, 8261, 8294, 8291
11961, 8258, 8261, 8294, 8291, 8259, 8262, 8295, 8292
11962, 8259, 8262, 8295, 8292, 3661, 3662, 3673, 3672
11963, 3443, 3444, 3455, 3454, 8260, 8263, 8296, 8293
11964, 8260, 8263, 8296, 8293, 8261, 8264, 8297, 8294
11965, 8261, 8264, 8297, 8294, 8262, 8265, 8298, 8295
11966, 8262, 8265, 8298, 8295, 3662, 3663, 3674, 3673
11967, 3444, 661, 662, 3455, 8263, 3618, 3621, 8296
11968, 8263, 3618, 3621, 8296, 8264, 3619, 3622, 8297
11969, 8264, 3619, 3622, 8297, 8265, 3620, 3623, 8298
11970, 8265, 3620, 3623, 8298, 3663, 713, 714, 3674
11971, 653, 3445, 3456, 654, 3594, 8266, 8299, 3597
11972, 3594, 8266, 8299, 3597, 3595, 8267, 8300, 3598
11973, 3595, 8267, 8300, 3598, 3596, 8268, 8301, 3599
11974, 3596, 8268, 8301, 3599, 705, 3664, 3675, 706
11975, 3445, 3446, 3457, 3456, 8266, 8269, 8302, 8299
11976, 8266, 8269, 8302, 8299, 8267, 8270, 8303, 8300
11977, 8267, 8270, 8303, 8300, 8268, 8271, 8304, 8301
11978, 8268, 8271, 8304, 8301, 3664, 3665, 3676, 3675
11979, 3446, 3447, 3458, 3457, 8269, 8272, 8305, 8302
11980, 8269, 8272, 8305, 8302, 8270, 8273, 8306, 8303
11981, 8270, 8273, 8306, 8303, 8271, 8274, 8307, 8304
11982, 8271, 8274, 8307, 8304, 3665, 3666, 3677, 3676
11983, 3447, 3448, 3459, 3458, 8272, 8275, 8308, 8305
11984, 8272, 8275, 8308, 8305, 8273, 8276, 8309, 8306
11985, 8273, 8276, 8309, 8306, 8274, 8277, 8310, 8307
11986, 8274, 8277, 8310, 8307, 3666, 3667, 3678, 3677
11987, 3448, 3449, 3460, 3459, 8275, 8278, 8311, 8308
11988, 8275, 8278, 8311, 8308, 8276, 8279, 8312, 8309
11989, 8276, 8279, 8312, 8309, 8277, 8280, 8313, 8310
11990, 8277, 8280, 8313, 8310, 3667, 3668, 3679, 3678
11991, 3449, 3450, 3461, 3460, 8278, 8281, 8314, 8311
11992, 8278, 8281, 8314, 8311, 8279, 8282, 8315, 8312
11993, 8279, 8282, 8315, 8312, 8280, 8283, 8316, 8313
11994, 8280, 8283, 8316, 8313, 3668, 3669, 3680, 3679
11995, 3450, 3451, 3462, 3461, 8281, 8284, 8317, 8314
11996, 8281, 8284, 8317, 8314, 8282, 8285, 8318, 8315
11997, 8282, 8285, 8318, 8315, 8283, 8286, 8319, 8316
11998, 8283, 8286, 8319, 8316, 3669, 3670, 3681, 3680
11999, 3451, 3452, 3463, 3462, 8284, 8287, 8320, 8317
12000, 8284, 8287, 8320, 8317, 8285, 8288, 8321, 8318
12001, 8285, 8288, 8321, 8318, 8286, 8289, 8322, 8319
12002, 8286, 8289, 8322, 8319, 3670, 3671, 3682, 3681
12003, 3452, 3453, 3464, 3463, 8287, 8290, 8323, 8320
12004, 8287, 8290, 8323, 8320, 8288, 8291, 8324, 8321
12005, 8288, 8291, 8324, 8321, 8289, 8292, 8325, 8322
12006, 8289, 8292, 8325, 8322, 3671, 3672, 3683, 3682
12007, 3453, 3454, 3465, 3464, 8290, 8293, 8326, 8323
12008, 8290, 8293, 8326, 8323, 8291, 8294, 8327, 8324
12009, 8291, 8294, 8327, 8324, 8292, 8295, 8328, 8325
12010, 8292, 8295, 8328, 8325, 3672, 3673, 3684, 3683
12011, 3454, 3455, 3466, 3465, 8293, 8296, 8329, 8326
12012, 8293, 8296, 8329, 8326, 8294, 8297, 8330, 8327
12013, 8294, 8297, 8330, 8327, 8295, 8298, 8331, 8328
12014, 8295, 8298, 8331, 8328, 3673, 3674, 3685, 3684
12015, 3455, 662, 663, 3466, 8296, 3621, 3624, 8329
12016, 8296, 3621, 3624, 8329, 8297, 3622, 3625, 8330
12017, 8297, 3622, 3625, 8330, 8298, 3623, 3626, 8331
12018, 8298, 3623, 3626, 8331, 3674, 714, 715, 3685
12019, 654, 3456, 3467, 655, 3597, 8299, 8332, 3600
12020, 3597, 8299, 8332, 3600, 3598, 8300, 8333, 3601
12021, 3598, 8300, 8333, 3601, 3599, 8301, 8334, 3602
12022, 3599, 8301, 8334, 3602, 706, 3675, 3686, 707
12023, 3456, 3457, 3468, 3467, 8299, 8302, 8335, 8332
12024, 8299, 8302, 8335, 8332, 8300, 8303, 8336, 8333
12025, 8300, 8303, 8336, 8333, 8301, 8304, 8337, 8334
12026, 8301, 8304, 8337, 8334, 3675, 3676, 3687, 3686
12027, 3457, 3458, 3469, 3468, 8302, 8305, 8338, 8335
12028, 8302, 8305, 8338, 8335, 8303, 8306, 8339, 8336
12029, 8303, 8306, 8339, 8336, 8304, 8307, 8340, 8337
12030, 8304, 8307, 8340, 8337, 3676, 3677, 3688, 3687
12031, 3458, 3459, 3470, 3469, 8305, 8308, 8341, 8338
12032, 8305, 8308, 8341, 8338, 8306, 8309, 8342, 8339
12033, 8306, 8309, 8342, 8339, 8307, 8310, 8343, 8340
12034, 8307, 8310, 8343, 8340, 3677, 3678, 3689, 3688
12035, 3459, 3460, 3471, 3470, 8308, 8311, 8344, 8341
12036, 8308, 8311, 8344, 8341, 8309, 8312, 8345, 8342
12037, 8309, 8312, 8345, 8342, 8310, 8313, 8346, 8343
12038, 8310, 8313, 8346, 8343, 3678, 3679, 3690, 3689
12039, 3460, 3461, 3472, 3471, 8311, 8314, 8347, 8344
12040, 8311, 8314, 8347, 8344, 8312, 8315, 8348, 8345
12041, 8312, 8315, 8348, 8345, 8313, 8316, 8349, 8346
12042, 8313, 8316, 8349, 8346, 3679, 3680, 3691, 3690
12043, 3461, 3462, 3473, 3472, 8314, 8317, 8350, 8347
12044, 8314, 8317, 8350, 8347, 8315, 8318, 8351, 8348
12045, 8315, 8318, 8351, 8348, 8316, 8319, 8352, 8349
12046, 8316, 8319, 8352, 8349, 3680, 3681, 3692, 3691
12047, 3462, 3463, 3474, 3473, 8317, 8320, 8353, 8350
12048, 8317, 8320, 8353, 8350, 8318, 8321, 8354, 8351
12049, 8318, 8321, 8354, 8351, 8319, 8322, 8355, 8352
12050, 8319, 8322, 8355, 8352, 3681, 3682, 3693, 3692
12051, 3463, 3464, 3475, 3474, 8320, 8323, 8356, 8353
12052, 8320, 8323, 8356, 8353, 8321, 8324, 8357, 8354
12053, 8321, 8324, 8357, 8354, 8322, 8325, 8358, 8355
12054, 8322, 8325, 8358, 8355, 3682, 3683, 3694, 3693
12055, 3464, 3465, 3476, 3475, 8323, 8326, 8359, 8356
12056, 8323, 8326, 8359, 8356, 8324, 8327, 8360, 8357
12057, 8324, 8327, 8360, 8357, 8325, 8328, 8361, 8358
12058, 8325, 8328, 8361, 8358, 3683, 3684, 3695, 3694
12059, 3465, 3466, 3477, 3476, 8326, 8329, 8362, 8359
12060, 8326, 8329, 8362, 8359, 8327, 8330, 8363, 8360
12061, 8327, 8330, 8363, 8360, 8328, 8331, 8364, 8361
12062, 8328, 8331, 8364, 8361, 3684, 3685, 3696, 3695
12063, 3466, 663, 664, 3477, 8329, 3624, 3627, 8362
12064, 8329, 3624, 3627, 8362, 8330, 3625, 3628, 8363
12065, 8330, 3625, 3628, 8363, 8331, 3626, 3629, 8364
12066, 8331, 3626, 3629, 8364, 3685, 715, 716, 3696
12067, 655, 3467, 3478, 656, 3600, 8332, 8365, 3603
12068, 3600, 8332, 8365, 3603, 3601, 8333, 8366, 3604
12069, 3601, 8333, 8366, 3604, 3602, 8334, 8367, 3605
12070, 3602, 8334, 8367, 3605, 707, 3686, 3697, 708
12071, 3467, 3468, 3479, 3478, 8332, 8335, 8368, 8365
12072, 8332, 8335, 8368, 8365, 8333, 8336, 8369, 8366
12073, 8333, 8336, 8369, 8366, 8334, 8337, 8370, 8367
12074, 8334, 8337, 8370, 8367, 3686, 3687, 3698, 3697
12075, 3468, 3469, 3480, 3479, 8335, 8338, 8371, 8368
12076, 8335, 8338, 8371, 8368, 8336, 8339, 8372, 8369
12077, 8336, 8339, 8372, 8369, 8337, 8340, 8373, 8370
12078, 8337, 8340, 8373, 8370, 3687, 3688, 3699, 3698
12079, 3469, 3470, 3481, 3480, 8338, 8341, 8374, 8371
12080, 8338, 8341, 8374, 8371, 8339, 8342, 8375, 8372
12081, 8339, 8342, 8375, 8372, 8340, 8343, 8376, 8373
12082, 8340, 8343, 8376, 8373, 3688, 3689, 3700, 3699
12083, 3470, 3471, 3482, 3481, 8341, 8344, 8377, 8374
12084, 8341, 8344, 8377, 8374, 8342, 8345, 8378, 8375
12085, 8342, 8345, 8378, 8375, 8343, 8346, 8379, 8376
12086, 8343, 8346, 8379, 8376, 3689, 3690, 3701, 3700
12087, 3471, 3472, 3483, 3482, 8344, 8347, 8380, 8377
12088, 8344, 8347, 8380, 8377, 8345, 8348, 8381, 8378
12089, 8345, 8348, 8381, 8378, 8346, 8349, 8382, 8379
12090, 8346, 8349, 8382, 8379, 3690, 3691, 3702, 3701
12091, 3472, 3473, 3484, 3483, 8347, 8350, 8383, 8380
12092, 8347, 8350, 8383, 8380, 8348, 8351, 8384, 8381
12093, 8348, 8351, 8384, 8381, 8349, 8352, 8385, 8382
12094, 8349, 8352, 8385, 8382, 3691, 3692, 3703, 3702
12095, 3473, 3474, 3485, 3484, 8350, 8353, 8386, 8383
12096, 8350, 8353, 8386, 8383, 8351, 8354, 8387, 8384
12097, 8351, 8354, 8387, 8384, 8352, 8355, 8388, 8385
12098, 8352, 8355, 8388, 8385, 3692, 3693, 3704, 3703
12099, 3474, 3475, 3486, 3485, 8353, 8356, 8389, 8386
12100, 8353, 8356, 8389, 8386, 8354, 8357, 8390, 8387
12101, 8354, 8357, 8390, 8387, 8355, 8358, 8391, 8388
12102, 8355, 8358, 8391, 8388, 3693, 3694, 3705, 3704
12103, 3475, 3476, 3487, 3486, 8356, 8359, 8392, 8389
12104, 8356, 8359, 8392, 8389, 8357, 8360, 8393, 8390
12105, 8357, 8360, 8393, 8390, 8358, 8361, 8394, 8391
12106, 8358, 8361, 8394, 8391, 3694, 3695, 3706, 3705
12107, 3476, 3477, 3488, 3487, 8359, 8362, 8395, 8392
12108, 8359, 8362, 8395, 8392, 8360, 8363, 8396, 8393
12109, 8360, 8363, 8396, 8393, 8361, 8364, 8397, 8394
12110, 8361, 8364, 8397, 8394, 3695, 3696, 3707, 3706
12111, 3477, 664, 665, 3488, 8362, 3627, 3630, 8395
12112, 8362, 3627, 3630, 8395, 8363, 3628, 3631, 8396
12113, 8363, 3628, 3631, 8396, 8364, 3629, 3632, 8397
12114, 8364, 3629, 3632, 8397, 3696, 716, 717, 3707
12115, 656, 3478, 3489, 657, 3603, 8365, 8398, 3606
12116, 3603, 8365, 8398, 3606, 3604, 8366, 8399, 3607
12117, 3604, 8366, 8399, 3607, 3605, 8367, 8400, 3608
12118, 3605, 8367, 8400, 3608, 708, 3697, 3708, 709
12119, 3478, 3479, 3490, 3489, 8365, 8368, 8401, 8398
12120, 8365, 8368, 8401, 8398, 8366, 8369, 8402, 8399
12121, 8366, 8369, 8402, 8399, 8367, 8370, 8403, 8400
12122, 8367, 8370, 8403, 8400, 3697, 3698, 3709, 3708
12123, 3479, 3480, 3491, 3490, 8368, 8371, 8404, 8401
12124, 8368, 8371, 8404, 8401, 8369, 8372, 8405, 8402
12125, 8369, 8372, 8405, 8402, 8370, 8373, 8406, 8403
12126, 8370, 8373, 8406, 8403, 3698, 3699, 3710, 3709
12127, 3480, 3481, 3492, 3491, 8371, 8374, 8407, 8404
12128, 8371, 8374, 8407, 8404, 8372, 8375, 8408, 8405
12129, 8372, 8375, 8408, 8405, 8373, 8376, 8409, 8406
12130, 8373, 8376, 8409, 8406, 3699, 3700, 3711, 3710
12131, 3481, 3482, 3493, 3492, 8374, 8377, 8410, 8407
12132, 8374, 8377, 8410, 8407, 8375, 8378, 8411, 8408
12133, 8375, 8378, 8411, 8408, 8376, 8379, 8412, 8409
12134, 8376, 8379, 8412, 8409, 3700, 3701, 3712, 3711
12135, 3482, 3483, 3494, 3493, 8377, 8380, 8413, 8410
12136, 8377, 8380, 8413, 8410, 8378, 8381, 8414, 8411
12137, 8378, 8381, 8414, 8411, 8379, 8382, 8415, 8412
12138, 8379, 8382, 8415, 8412, 3701, 3702, 3713, 3712
12139, 3483, 3484, 3495, 3494, 8380, 8383, 8416, 8413
12140, 8380, 8383, 8416, 8413, 8381, 8384, 8417, 8414
12141, 8381, 8384, 8417, 8414, 8382, 8385, 8418, 8415
12142, 8382, 8385, 8418, 8415, 3702, 3703, 3714, 3713
12143, 3484, 3485, 3496, 3495, 8383, 8386, 8419, 8416
12144, 8383, 8386, 8419, 8416, 8384, 8387, 8420, 8417
12145, 8384, 8387, 8420, 8417, 8385, 8388, 8421, 8418
12146, 8385, 8388, 8421, 8418, 3703, 3704, 3715, 3714
12147, 3485, 3486, 3497, 3496, 8386, 8389, 8422, 8419
12148, 8386, 8389, 8422, 8419, 8387, 8390, 8423, 8420
12149, 8387, 8390, 8423, 8420, 8388, 8391, 8424, 8421
12150, 8388, 8391, 8424, 8421, 3704, 3705, 3716, 3715
12151, 3486, 3487, 3498, 3497, 8389, 8392, 8425, 8422
12152, 8389, 8392, 8425, 8422, 8390, 8393, 8426, 8423
12153, 8390, 8393, 8426, 8423, 8391, 8394, 8427, 8424
12154, 8391, 8394, 8427, 8424, 3705, 3706, 3717, 3716
12155, 3487, 3488, 3499, 3498, 8392, 8395, 8428, 8425
12156, 8392, 8395, 8428, 8425, 8393, 8396, 8429, 8426
12157, 8393, 8396, 8429, 8426, 8394, 8397, 8430, 8427
12158, 8394, 8397, 8430, 8427, 3706, 3707, 3718, 3717
12159, 3488, 665, 666, 3499, 8395, 3630, 3633, 8428
12160, 8395, 3630, 3633, 8428, 8396, 3631, 3634, 8429
12161, 8396, 3631, 3634, 8429, 8397, 3632, 3635, 8430
12162, 8397, 3632, 3635, 8430, 3707, 717, 718, 3718
12163, 657, 3489, 3500, 658, 3606, 8398, 8431, 3609
12164, 3606, 8398, 8431, 3609, 3607, 8399, 8432, 3610
12165, 3607, 8399, 8432, 3610, 3608, 8400, 8433, 3611
12166, 3608, 8400, 8433, 3611, 709, 3708, 3719, 710
12167, 3489, 3490, 3501, 3500, 8398, 8401, 8434, 8431
12168, 8398, 8401, 8434, 8431, 8399, 8402, 8435, 8432
12169, 8399, 8402, 8435, 8432, 8400, 8403, 8436, 8433
12170, 8400, 8403, 8436, 8433, 3708, 3709, 3720, 3719
12171, 3490, 3491, 3502, 3501, 8401, 8404, 8437, 8434
12172, 8401, 8404, 8437, 8434, 8402, 8405, 8438, 8435
12173, 8402, 8405, 8438, 8435, 8403, 8406, 8439, 8436
12174, 8403, 8406, 8439, 8436, 3709, 3710, 3721, 3720
12175, 3491, 3492, 3503, 3502, 8404, 8407, 8440, 8437
12176, 8404, 8407, 8440, 8437, 8405, 8408, 8441, 8438
12177, 8405, 8408, 8441, 8438, 8406, 8409, 8442, 8439
12178, 8406, 8409, 8442, 8439, 3710, 3711, 3722, 3721
12179, 3492, 3493, 3504, 3503, 8407, 8410, 8443, 8440
12180, 8407, 8410, 8443, 8440, 8408, 8411, 8444, 8441
12181, 8408, 8411, 8444, 8441, 8409, 8412, 8445, 8442
12182, 8409, 8412, 8445, 8442, 3711, 3712, 3723, 3722
12183, 3493, 3494, 3505, 3504, 8410, 8413, 8446, 8443
12184, 8410, 8413, 8446, 8443, 8411, 8414, 8447, 8444
12185, 8411, 8414, 8447, 8444, 8412, 8415, 8448, 8445
12186, 8412, 8415, 8448, 8445, 3712, 3713, 3724, 3723
12187, 3494, 3495, 3506, 3505, 8413, 8416, 8449, 8446
12188, 8413, 8416, 8449, 8446, 8414, 8417, 8450, 8447
12189, 8414, 8417, 8450, 8447, 8415, 8418, 8451, 8448
12190, 8415, 8418, 8451, 8448, 3713, 3714, 3725, 3724
12191, 3495, 3496, 3507, 3506, 8416, 8419, 8452, 8449
12192, 8416, 8419, 8452, 8449, 8417, 8420, 8453, 8450
12193, 8417, 8420, 8453, 8450, 8418, 8421, 8454, 8451
12194, 8418, 8421, 8454, 8451, 3714, 3715, 3726, 3725
12195, 3496, 3497, 3508, 3507, 8419, 8422, 8455, 8452
12196, 8419, 8422, 8455, 8452, 8420, 8423, 8456, 8453
12197, 8420, 8423, 8456, 8453, 8421, 8424, 8457, 8454
12198, 8421, 8424, 8457, 8454, 3715, 3716, 3727, 3726
12199, 3497, 3498, 3509, 3508, 8422, 8425, 8458, 8455
12200, 8422, 8425, 8458, 8455, 8423, 8426, 8459, 8456
12201, 8423, 8426, 8459, 8456, 8424, 8427, 8460, 8457
12202, 8424, 8427, 8460, 8457, 3716, 3717, 3728, 3727
12203, 3498, 3499, 3510, 3509, 8425, 8428, 8461, 8458
12204, 8425, 8428, 8461, 8458, 8426, 8429, 8462, 8459
12205, 8426, 8429, 8462, 8459, 8427, 8430, 8463, 8460
12206, 8427, 8430, 8463, 8460, 3717, 3718, 3729, 3728
12207, 3499, 666, 667, 3510, 8428, 3633, 3636, 8461
12208, 8428, 3633, 3636, 8461, 8429, 3634, 3637, 8462
12209, 8429, 3634, 3637, 8462, 8430, 3635, 3638, 8463
12210, 8430, 3635, 3638, 8463, 3718, 718, 719, 3729
12211, 658, 3500, 3511, 659, 3609, 8431, 8464, 3612
12212, 3609, 8431, 8464, 3612, 3610, 8432, 8465, 3613
12213, 3610, 8432, 8465, 3613, 3611, 8433, 8466, 3614
12214, 3611, 8433, 8466, 3614, 710, 3719, 3730, 711
12215, 3500, 3501, 3512, 3511, 8431, 8434, 8467, 8464
12216, 8431, 8434, 8467, 8464, 8432, 8435, 8468, 8465
12217, 8432, 8435, 8468, 8465, 8433, 8436, 8469, 8466
12218, 8433, 8436, 8469, 8466, 3719, 3720, 3731, 3730
12219, 3501, 3502, 3513, 3512, 8434, 8437, 8470, 8467
12220, 8434, 8437, 8470, 8467, 8435, 8438, 8471, 8468
12221, 8435, 8438, 8471, 8468, 8436, 8439, 8472, 8469
12222, 8436, 8439, 8472, 8469, 3720, 3721, 3732, 3731
12223, 3502, 3503, 3514, 3513, 8437, 8440, 8473, 8470
12224, 8437, 8440, 8473, 8470, 8438, 8441, 8474, 8471
12225, 8438, 8441, 8474, 8471, 8439, 8442, 8475, 8472
12226, 8439, 8442, 8475, 8472, 3721, 3722, 3733, 3732
12227, 3503, 3504, 3515, 3514, 8440, 8443, 8476, 8473
12228, 8440, 8443, 8476, 8473, 8441, 8444, 8477, 8474
12229, 8441, 8444, 8477, 8474, 8442, 8445, 8478, 8475
12230, 8442, 8445, 8478, 8475, 3722, 3723, 3734, 3733
12231, 3504, 3505, 3516, 3515, 8443, 8446, 8479, 8476
12232, 8443, 8446, 8479, 8476, 8444, 8447, 8480, 8477
12233, 8444, 8447, 8480, 8477, 8445, 8448, 8481, 8478
12234, 8445, 8448, 8481, 8478, 3723, 3724, 3735, 3734
12235, 3505, 3506, 3517, 3516, 8446, 8449, 8482, 8479
12236, 8446, 8449, 8482, 8479, 8447, 8450, 8483, 8480
12237, 8447, 8450, 8483, 8480, 8448, 8451, 8484, 8481
12238, 8448, 8451, 8484, 8481, 3724, 3725, 3736, 3735
12239, 3506, 3507, 3518, 3517, 8449, 8452, 8485, 8482
12240, 8449, 8452, 8485, 8482, 8450, 8453, 8486, 8483
12241, 8450, 8453, 8486, 8483, 8451, 8454, 8487, 8484
12242, 8451, 8454, 8487, 8484, 3725, 3726, 3737, 3736
12243, 3507, 3508, 3519, 3518, 8452, 8455, 8488, 8485
12244, 8452, 8455, 8488, 8485, 8453, 8456, 8489, 8486
12245, 8453, 8456, 8489, 8486, 8454, 8457, 8490, 8487
12246, 8454, 8457, 8490, 8487, 3726, 3727, 3738, 3737
12247, 3508, 3509, 3520, 3519, 8455, 8458, 8491, 8488
12248, 8455, 8458, 8491, 8488, 8456, 8459, 8492, 8489
12249, 8456, 8459, 8492, 8489, 8457, 8460, 8493, 8490
12250, 8457, 8460, 8493, 8490, 3727, 3728, 3739, 3738
12251, 3509, 3510, 3521, 3520, 8458, 8461, 8494, 8491
12252, 8458, 8461, 8494, 8491, 8459, 8462, 8495, 8492
12253, 8459, 8462, 8495, 8492, 8460, 8463, 8496, 8493
12254, 8460, 8463, 8496, 8493, 3728, 3729, 3740, 3739
12255, 3510, 667, 668, 3521, 8461, 3636, 3639, 8494
12256, 8461, 3636, 3639, 8494, 8462, 3637, 3640, 8495
12257, 8462, 3637, 3640, 8495, 8463, 3638, 3641, 8496
12258, 8463, 3638, 3641, 8496, 3729, 719, 720, 3740
12259, 659, 3511, 629, 41, 3612, 8464, 3522, 669
12260, 3612, 8464, 3522, 669, 3613, 8465, 3523, 670
12261, 3613, 8465, 3523, 670, 3614, 8466, 3524, 671
12262, 3614, 8466, 3524, 671, 711, 3730, 675, 45
12263, 3511, 3512, 630, 629, 8464, 8467, 3525, 3522
12264, 8464, 8467, 3525, 3522, 8465, 8468, 3526, 3523
12265, 8465, 8468, 3526, 3523, 8466, 8469, 3527, 3524
12266, 8466, 8469, 3527, 3524, 3730, 3731, 676, 675
12267, 3512, 3513, 631, 630, 8467, 8470, 3528, 3525
12268, 8467, 8470, 3528, 3525, 8468, 8471, 3529, 3526
12269, 8468, 8471, 3529, 3526, 8469, 8472, 3530, 3527
12270, 8469, 8472, 3530, 3527, 3731, 3732, 677, 676
12271, 3513, 3514, 632, 631, 8470, 8473, 3531, 3528
12272, 8470, 8473, 3531, 3528, 8471, 8474, 3532, 3529
12273, 8471, 8474, 3532, 3529, 8472, 8475, 3533, 3530
12274, 8472, 8475, 3533, 3530, 3732, 3733, 678, 677
12275, 3514, 3515, 633, 632, 8473, 8476, 3534, 3531
12276, 8473, 8476, 3534, 3531, 8474, 8477, 3535, 3532
12277, 8474, 8477, 3535, 3532, 8475, 8478, 3536, 3533
12278, 8475, 8478, 3536, 3533, 3733, 3734, 679, 678
12279, 3515, 3516, 634, 633, 8476, 8479, 3537, 3534
12280, 8476, 8479, 3537, 3534, 8477, 8480, 3538, 3535
12281, 8477, 8480, 3538, 3535, 8478, 8481, 3539, 3536
12282, 8478, 8481, 3539, 3536, 3734, 3735, 680, 679
12283, 3516, 3517, 635, 634, 8479, 8482, 3540, 3537
12284, 8479, 8482, 3540, 3537, 8480, 8483, 3541, 3538
12285, 8480, 8483, 3541, 3538, 8481, 8484, 3542, 3539
12286, 8481, 8484, 3542, 3539, 3735, 3736, 681, 680
12287, 3517, 3518, 636, 635, 8482, 8485, 3543, 3540
12288, 8482, 8485, 3543, 3540, 8483, 8486, 3544, 3541
12289, 8483, 8486, 3544, 3541, 8484, 8487, 3545, 3542
12290, 8484, 8487, 3545, 3542, 3736, 3737, 682, 681
12291, 3518, 3519, 637, 636, 8485, 8488, 3546, 3543
12292, 8485, 8488, 3546, 3543, 8486, 8489, 3547, 3544
12293, 8486, 8489, 3547, 3544, 8487, 8490, 3548, 3545
12294, 8487, 8490, 3548, 3545, 3737, 3738, 683, 682
12295, 3519, 3520, 638, 637, 8488, 8491, 3549, 3546
12296, 8488, 8491, 3549, 3546, 8489, 8492, 3550, 3547
12297, 8489, 8492, 3550, 3547, 8490, 8493, 3551, 3548
12298, 8490, 8493, 3551, 3548, 3738, 3739, 684, 683
12299, 3520, 3521, 639, 638, 8491, 8494, 3552, 3549
12300, 8491, 8494, 3552, 3549, 8492, 8495, 3553, 3550
12301, 8492, 8495, 3553, 3550, 8493, 8496, 3554, 3551
12302, 8493, 8496, 3554, 3551, 3739, 3740, 685, 684
12303, 3521, 668, 42, 639, 8494, 3639, 672, 3552
12304, 8494, 3639, 672, 3552, 8495, 3640, 673, 3553
12305, 8495, 3640, 673, 3553, 8496, 3641, 674, 3554
12306, 8496, 3641, 674, 3554, 3740, 720, 46, 685
*ELEMENT, type=C3D8, ELSET=Volume12
12307, 44, 660, 3615, 689, 51, 727, 3741, 724
12308, 689, 3615, 3616, 690, 724, 3741, 3742, 725
12309, 690, 3616, 3617, 691, 725, 3742, 3743, 726
12310, 691, 3617, 712, 48, 726, 3743, 736, 52
12311, 660, 661, 3618, 3615, 727, 728, 3744, 3741
12312, 3615, 3618, 3619, 3616, 3741, 3744, 3745, 3742
12313, 3616, 3619, 3620, 3617, 3742, 3745, 3746, 3743
12314, 3617, 3620, 713, 712, 3743, 3746, 737, 736
12315, 661, 662, 3621, 3618, 728, 729, 3747, 3744
12316, 3618, 3621, 3622, 3619, 3744, 3747, 3748, 3745
12317, 3619, 3622, 3623, 3620, 3745, 3748, 3749, 3746
12318, 3620, 3623, 714, 713, 3746, 3749, 738, 737
12319, 662, 663, 3624, 3621, 729, 730, 3750, 3747
12320, 3621, 3624, 3625, 3622, 3747, 3750, 3751, 3748
12321, 3622, 3625, 3626, 3623, 3748, 3751, 3752, 3749
12322, 3623, 3626, 715, 714, 3749, 3752, 739, 738
12323, 663, 664, 3627, 3624, 730, 731, 3753, 3750
12324, 3624, 3627, 3628, 3625, 3750, 3753, 3754, 3751
12325, 3625, 3628, 3629, 3626, 3751, 3754, 3755, 3752
12326, 3626, 3629, 716, 715, 3752, 3755, 740, 739
12327, 664, 665, 3630, 3627, 731, 732, 3756, 3753
12328, 3627, 3630, 3631, 3628, 3753, 3756, 3757, 3754
12329, 3628, 3631, 3632, 3629, 3754, 3757, 3758, 3755
12330, 3629, 3632, 717, 716, 3755, 3758, 741, 740
12331, 665, 666, 3633, 3630, 732, 733, 3759, 3756
12332, 3630, 3633, 3634, 3631, 3756, 3759, 3760, 3757
12333, 3631, 3634, 3635, 3632, 3757, 3760, 3761, 3758
12334, 3632, 3635, 718, 717, 3758, 3761, 742, 741
12335, 666, 667, 3636, 3633, 733, 734, 3762, 3759
12336, 3633, 3636, 3637, 3634, 3759, 3762, 3763, 3760
12337, 3634, 3637, 3638, 3635, 3760, 3763, 3764, 3761
12338, 3635, 3638, 719, 718, 3761, 3764, 743, 742
12339, 667, 668, 3639, 3636, 734, 735, 3765, 3762
12340, 3636, 3639, 3640, 3637, 3762, 3765, 3766, 3763
12341, 3637, 3640, 3641, 3638, 3763, 3766, 3767, 3764
12342, 3638, 3641, 720, 719, 3764, 3767, 744, 743
12343, 668, 42, 672, 3639, 735, 49, 721, 3765
12344, 3639, 672, 673, 3640, 3765, 721, 722, 3766
12345, 3640, 673, 674, 3641, 3766, 722, 723, 3767
12346, 3641, 674, 46, 720, 3767, 723, 50, 744
*ELEMENT, type=C3D8, ELSET=Volume13
12347, 2, 97, 1209, 118, 54, 745, 3768, 766
12348, 118, 1209, 1210, 119, 766, 3768, 3769, 767
12349, 119, 1210, 1211, 120, 767, 3769, 3770, 768
12350, 120, 1211, 109, 4, 768, 3770, 757, 56
12351, 97, 98, 1212, 1209, 745, 746, 3771, 3768
12352, 1209, 1212, 1213, 1210, 3768, 3771, 3772, 3769
12353, 1210, 1213, 1214, 1211, 3769, 3772, 3773, 3770
12354, 1211, 1214, 110, 109, 3770, 3773, 758, 757
12355, 98, 99, 1215, 1212, 746, 747, 3774, 3771
12356, 1212, 1215, 1216, 1213, 3771, 3774, 3775, 3772
12357, 1213, 1216, 1217, 1214, 3772, 3775, 3776, 3773
12358, 1214, 1217, 111, 110, 3773, 3776, 759, 758
12359, 99, 100, 1218, 1215, 747, 748, 3777, 3774
12360, 1215, 1218, 1219, 1216, 3774, 3777, 3778, 3775
12361, 1216, 1219, 1220, 1217, 3775, 3778, 3779, 3776
12362, 1217, 1220, 112, 111, 3776, 3779, 760, 759
12363, 100, 101, 1221, 1218, 748, 749, 3780, 3777
12364, 1218, 1221, 1222, 1219, 3777, 3780, 3781, 3778
12365, 1219, 1222, 1223, 1220, 3778, 3781, 3782, 3779
12366, 1220, 1223, 113, 112, 3779, 3782, 761, 760
12367, 101, 102, 1224, 1221, 749, 750, 3783, 3780
12368, 1221, 1224, 1225, 1222, 3780, 3783, 3784, 3781
12369, 1222, 1225, 1226, 1223, 3781, 3784, 3785, 3782
12370, 1223, 1226, 114, 113, 3782, 3785, 762, 761
12371, 102, 103, 1227, 1224, 750, 751, 3786, 3783
12372, 1224, 1227, 1228, 1225, 3783, 3786, 3787, 3784
12373, 1225, 1228, 1229, 1226, 3784, 3787, 3788, 3785
12374, 1226, 1229, 115, 114, 3785, 3788, 763, 762
12375, 103, 104, 1230, 1227, 751, 752, 3789, 3786
12376, 1227, 1230, 1231, 1228, 3786, 3789, 3790, 3787
12377, 1228, 1231, 1232, 1229, 3787, 3790, 3791, 3788
12378, 1229, 1232, 116, 115, 3788, 3791, 764, 763
12379, 104, 105, 1233, 1230, 752, 753, 3792, 3789
12380, 1230, 1233, 1234, 1231, 3789, 3792, 3793, 3790
12381, 1231, 1234, 1235, 1232, 3790, 3793, 3794, 3791
12382, 1232, 1235, 117, 116, 3791, 3794, 765, 764
12383, 105, 1, 106, 1233, 753, 53, 754, 3792
12384, 1233, 106, 107, 1234, 3792, 754, 755, 3793
12385, 1234, 107, 108, 1235, 3793, 755, 756, 3794
12386, 1235, 108, 3, 117, 3794, 756, 55, 765
*ELEMENT, type=C3D8, ELSET=Volume14
12387, 10, 238, 1626, 189, 67, 850, 3957, 859
12388, 238, 239, 1627, 1626, 850, 851, 3958, 3957
12389, 239, 240, 1628, 1627, 851, 852, 3959, 3958
12390, 240, 241, 1629, 1628, 852, 853, 3960, 3959
12391, 241, 242, 1630, 1629, 853, 854, 3961, 3960
12392, 242, 243, 1631, 1630, 854, 855, 3962, 3961
12393, 243, 244, 1632, 1631, 855, 856, 3963, 3962
12394, 244, 245, 1633, 1632, 856, 857, 3964, 3963
12395, 245, 246, 1634, 1633, 857, 858, 3965, 3964
12396, 246, 14, 247, 1634, 858, 68, 870, 3965
12397, 189, 1626, 1635, 190, 859, 3957, 3966, 860
12398, 1626, 1627, 1636, 1635, 3957, 3958, 3967, 3966
12399, 1627, 1628, 1637, 1636, 3958, 3959, 3968, 3967
12400, 1628, 1629, 1638, 1637, 3959, 3960, 3969, 3968
12401, 1629, 1630, 1639, 1638, 3960, 3961, 3970, 3969
12402, 1630, 1631, 1640, 1639, 3961, 3962, 3971, 3970
12403, 1631, 1632, 1641, 1640, 3962, 3963, 3972, 3971
12404, 1632, 1633, 1642, 1641, 3963, 3964, 3973, 3972
12405, 1633, 1634, 1643, 1642, 3964, 3965, 3974, 3973
12406, 1634, 247, 248, 1643, 3965, 870, 871, 3974
12407, 190, 1635, 1644, 191, 860, 3966, 3975, 861
12408, 1635, 1636, 1645, 1644, 3966, 3967, 3976, 3975
12409, 1636, 1637, 1646, 1645, 3967, 3968, 3977, 3976
12410, 1637, 1638, 1647, 1646, 3968, 3969, 3978, 3977
12411, 1638, 1639, 1648, 1647, 3969, 3970, 3979, 3978
12412, 1639, 1640, 1649, 1648, 3970, 3971, 3980, 3979
12413, 1640, 1641, 1650, 1649, 3971, 3972, 3981, 3980
12414, 1641, 1642, 1651, 1650, 3972, 3973, 3982, 3981
12415, 1642, 1643, 1652, 1651, 3973, 3974, 3983, 3982
12416, 1643, 248, 249, 1652, 3974, 871, 872, 3983
12417, 191, 1644, 1653, 192, 861, 3975, 3984, 862
12418, 1644, 1645, 1654, 1653, 3975, 3976, 3985, 3984
12419, 1645, 1646, 1655, 1654, 3976, 3977, 3986, 3985
12420, 1646, 1647, 1656, 1655, 3977, 3978, 3987, 3986
12421, 1647, 1648, 1657, 1656, 3978, 3979, 3988, 3987
12422, 1648, 1649, 1658, 1657, 3979, 3980, 3989, 3988
12423, 1649, 1650, 1659, 1658, 3980, 3981, 3990, 3989
12424, 1650, 1651, 1660, 1659, 3981, 3982, 3991, 3990
12425, 1651, 1652, 1661, 1660, 3982, 3983, 3992, 3991
12426, 1652, 249, 250, 1661, 3983, 872, 873, 3992
12427, 192, 1653, 1662, 193, 862, 3984, 3993, 863
12428, 1653, 1654, 1663, 1662, 3984, 3985, 3994, 3993
12429, 1654, 1655, 1664, 1663, 3985, 3986, 3995, 3994
12430, 1655, 1656, 1665, 1664, 3986, 3987, 3996, 3995
12431, 1656, 1657, 1666, 1665, 3987, 3988, 3997, 3996
12432, 1657, 1658, 1667, 1666, 3988, 3989, 3998, 3997
12433, 1658, 1659, 1668, 1667, 3989, 3990, 3999, 3998
12434, 1659, 1660, 1669, 1668, 3990, 3991, 4000, 3999
12435, 1660, 1661, 1670, 1669, 3991, 3992, 4001, 4000
12436, 1661, 250, 251, 1670, 3992, 873, 874, 4001
12437, 193, 1662, 1671, 194, 863, 3993, 4002, 864
12438, 1662, 1663, 1672, 1671, 3993, 3994, 4003, 4002
12439, 1663, 1664, 1673, 1672, 3994, 3995, 4004, 4003
12440, 1664, 1665, 1674, 1673, 3995, 3996, 4005, 4004
12441, 1665, 1666, 1675, 1674, 3996, 3997, 4006, 4005
12442, 1666, 1667, 1676, 1675, 3997, 3998, 4007, 4006
12443, 1667, 1668, 1677, 1676, 3998, 3999, 4008, 4007
12444, 1668, 1669, 1678, 1677, 3999, 4000, 4009, 4008
12445, 1669, 1670, 1679, 1678, 4000, 4001, 4010, 4009
12446, 1670, 251, 252, 1679, 4001, 874, 875, 4010
12447, 194, 1671, 1680, 195, 864, 4002, 4011, 865
12448, 1671, 1672, 1681, 1680, 4002, 4003, 4012, 4011
12449, 1672, 1673, 1682, 1681, 4003, 4004, 4013, 4012
12450, 1673, 1674, 1683, 1682, 4004, 4005, 4014, 4013
12451, 1674, 1675, 1684, 1683, 4005, 4006, 4015, 4014
12452, 1675, 1676, 1685, 1684, 4006, 4007, 4016, 4015
12453, 1676, 1677, 1686, 1685, 4007, 4008, 4017, 4016
12454, 1677, 1678, 1687, 1686, 4008, 4009, 4018, 4017
12455, 1678, 1679, 1688, 1687, 4009, 4010, 4019, 4018
12456, 1679, 252, 253, 1688, 4010, 875, 876, 4019
12457, 195, 1680, 1689, 196, 865, 4011, 4020, 866
12458, 1680, 1681, 1690, 1689, 4011, 4012, 4021, 4020
12459, 1681, 1682, 1691, 1690, 4012, 4013, 4022, 4021
12460, 1682, 1683, 1692, 1691, 4013, 4014, 4023, 4022
12461, 1683, 1684, 1693, 1692, 4014, 4015, 4024, 4023
12462, 1684, 1685, 1694, 1693, 4015, 4016, 4025, 4024
12463, 1685, 1686, 1695, 1694, 4016, 4017, 4026, 4025
12464, 1686, 1687, 1696, 1695, 4017, 4018, 4027, 4026
12465, 1687, 1688, 1697, 1696, 4018, 4019, 4028, 4027
12466, 1688, 253, 254, 1697, 4019, 876, 877, 4028
12467, 196, 1689, 1698, 197, 866, 4020, 4029, 867
12468, 1689, 1690, 1699, 1698, 4020, 4021, 4030, 4029
12469, 1690, 1691, 1700, 1699, 4021, 4022, 4031, 4030
12470, 1691, 1692, 1701, 1700, 4022, 4023, 4032, 4031
12471, 1692, 1693, 1702, 1701, 4023, 4024, 4033, 4032
12472, 1693, 1694, 1703, 1702, 4024, 4025, 4034, 4033
12473, 1694, 1695, 1704, 1703, 4025, 4026, 4035, 4034
12474, 1695, 1696, 1705, 1704, 4026, 4027, 4036, 4035
12475, 1696, 1697, 1706, 1705, 4027, 4028, 4037, 4036
12476, 1697, 254, 255, 1706, 4028, 877, 878, 4037
12477, 197, 1698, 1707, 198, 867, 4029, 4038, 868
12478, 1698, 1699, 1708, 1707, 4029, 4030, 4039, 4038
12479, 1699, 1700, 1709, 1708, 4030, 4031, 4040, 4039
12480, 1700, 1701, 1710, 1709, 4031, 4032, 4041, 4040
12481, 1701, 1702, 1711, 1710, 4032, 4033, 4042, 4041
12482, 1702, 1703, 1712, 1711, 4033, 4034, 4043, 4042
12483, 1703, 1704, 1713, 1712, 4034, 4035, 4044, 4043
12484, 1704, 1705, 1714, 1713, 4035, 4036, 4045, 4044
12485, 1705, 1706, 1715, 1714, 4036, 4037, 4046, 4045
12486, 1706, 255, 256, 1715, 4037, 878, 879, 4046
12487, 198, 1707, 1716, 199, 868, 4038, 4047, 869
12488, 1707, 1708, 1717, 1716, 4038, 4039, 4048, 4047
12489, 1708, 1709, 1718, 1717, 4039, 4040, 4049, 4048
12490, 1709, 1710, 1719, 1718, 4040, 4041, 4050, 4049
12491, 1710, 1711, 1720, 1719, 4041, 4042, 4051, 4050
12492, 1711, 1712, 1721, 1720, 4042, 4043, 4052, 4051
12493, 1712, 1713, 1722, 1721, 4043, 4044, 4053, 4052
12494, 1713, 1714, 1723, 1722, 4044, 4045, 4054, 4053
12495, 1714, 1715, 1724, 1723, 4045, 4046, 4055, 4054
12496, 1715, 256, 257, 1724, 4046, 879, 880, 4055
12497, 199, 1716, 229, 9, 869, 4047, 841, 65
12498, 1716, 1717, 230, 229, 4047, 4048, 842, 841
12499, 1717, 1718, 231, 230, 4048, 4049, 843, 842
12500, 1718, 1719, 232, 231, 4049, 4050, 844, 843
12501, 1719, 1720, 233, 232, 4050, 4051, 845, 844
12502, 1720, 1721, 234, 233, 4051, 4052, 846, 845
12503, 1721, 1722, 235, 234, 4052, 4053, 847, 846
12504, 1722, 1723, 236, 235, 4053, 4054, 848, 847
12505, 1723, 1724, 237, 236, 4054, 4055, 849, 848
12506, 1724, 257, 13, 237, 4055, 880, 66, 849
*ELEMENT, type=C3D8, ELSET=Volume15
12507, 35, 524, 3063, 582, 69, 899, 4056, 881
12508, 582, 3063, 3064, 583, 881, 4056, 4057, 882
12509, 583, 3064, 3065, 584, 882, 4057, 4058, 883
12510, 584, 3065, 3066, 585, 883, 4058, 4059, 884
12511, 585, 3066, 3067, 586, 884, 4059, 4060, 885
12512, 586, 3067, 3068, 587, 885, 4060, 4061, 886
12513, 587, 3068, 3069, 588, 886, 4061, 4062, 887
12514, 588, 3069, 3070, 589, 887, 4062, 4063, 888
12515, 589, 3070, 3071, 590, 888, 4063, 4064, 889
12516, 590, 3071, 600, 39, 889, 4064, 910, 70
12517, 524, 525, 3072, 3063, 899, 900, 4065, 4056
12518, 3063, 3072, 3073, 3064, 4056, 4065, 4066, 4057
12519, 3064, 3073, 3074, 3065, 4057, 4066, 4067, 4058
12520, 3065, 3074, 3075, 3066, 4058, 4067, 4068, 4059
12521, 3066, 3075, 3076, 3067, 4059, 4068, 4069, 4060
12522, 3067, 3076, 3077, 3068, 4060, 4069, 4070, 4061
12523, 3068, 3077, 3078, 3069, 4061, 4070, 4071, 4062
12524, 3069, 3078, 3079, 3070, 4062, 4071, 4072, 4063
12525, 3070, 3079, 3080, 3071, 4063, 4072, 4073, 4064
12526, 3071, 3080, 601, 600, 4064, 4073, 911, 910
12527, 525, 526, 3081, 3072, 900, 901, 4074, 4065
12528, 3072, 3081, 3082, 3073, 4065, 4074, 4075, 4066
12529, 3073, 3082, 3083, 3074, 4066, 4075, 4076, 4067
12530, 3074, 3083, 3084, 3075, 4067, 4076, 4077, 4068
12531, 3075, 3084, 3085, 3076, 4068, 4077, 4078, 4069
12532, 3076, 3085, 3086, 3077, 4069, 4078, 4079, 4070
12533, 3077, 3086, 3087, 3078, 4070, 4079, 4080, 4071
12534, 3078, 3087, 3088, 3079, 4071, 4080, 4081, 4072
12535, 3079, 3088, 3089, 3080, 4072, 4081, 4082, 4073
12536, 3080, 3089, 602, 601, 4073, 4082, 912, 911
12537, 526, 527, 3090, 3081, 901, 902, 4083, 4074
12538, 3081, 3090, 3091, 3082, 4074, 4083, 4084, 4075
12539, 3082, 3091, 3092, 3083, 4075, 4084, 4085, 4076
12540, 3083, 3092, 3093, 3084, 4076, 4085, 4086, 4077
12541, 3084, 3093, 3094, 3085, 4077, 4086, 4087, 4078
12542, 3085, 3094, 3095, 3086, 4078, 4087, 4088, 4079
12543, 3086, 3095, 3096, 3087, 4079, 4088, 4089, 4080
12544, 3087, 3096, 3097, 3088, 4080, 4089, 4090, 4081
12545, 3088, 3097, 3098, 3089, 4081, 4090, 4091, 4082
12546, 3089, 3098, 603, 602, 4082, 4091, 913, 912
12547, 527, 528, 3099, 3090, 902, 903, 4092, 4083
12548, 3090, 3099, 3100, 3091, 4083, 4092, 4093, 4084
12549, 3091, 3100, 3101, 3092, 4084, 4093, 4094, 4085
12550, 3092, 3101, 3102, 3093, 4085, 4094, 4095, 4086
12551, 3093, 3102, 3103, 3094, 4086, 4095, 4096, 4087
12552, 3094, 3103, 3104, 3095, 4087, 4096, 4097, 4088
12553, 3095, 3104, 3105, 3096, 4088, 4097, 4098, 4089
12554, 3096, 3105, 3106, 3097, 4089, 4098, 4099, 4090
12555, 3097, 3106, 3107, 3098, 4090, 4099, 4100, 4091
12556, 3098, 3107, 604, 603, 4091, 4100, 914, 913
12557, 528, 529, 3108, 3099, 903, 904, 4101, 4092
12558, 3099, 3108, 3109, 3100, 4092, 4101, 4102, 4093
12559, 3100, 3109, 3110, 3101, 4093, 4102, 4103, 4094
12560, 3101, 3110, 3111, 3102, 4094, 4103, 4104, 4095
12561, 3102, 3111, 3112, 3103, 4095, 4104, 4105, 4096
12562, 3103, 3112, 3113, 3104, 4096, 4105, 4106, 4097
12563, 3104, 3113, 3114, 3105, 4097, 4106, 4107, 4098
12564, 3105, 3114, 3115, 3106, 4098, 4107, 4108, 4099
12565, 3106, 3115, 3116, 3107, 4099, 4108, 4109, 4100
12566, 3107, 3116, 605, 604, 4100, 4109, 915, 914
12567, 529, 530, 3117, 3108, 904, 905, 4110, 4101
12568, 3108, 3117, 3118, 3109, 4101, 4110, 4111, 4102
12569, 3109, 3118, 3119, 3110, 4102, 4111, 4112, 4103
12570, 3110, 3119, 3120, 3111, 4103, 4112, 4113, 4104
12571, 3111, 3120, 3121, 3112, 4104, 4113, 4114, 4105
12572, 3112, 3121, 3122, 3113, 4105, 4114, 4115, 4106
12573, 3113, 3122, 3123, 3114, 4106, 4115, 4116, 4107
12574, 3114, 3123, 3124, 3115, 4107, 4116, 4117, 4108
12575, 3115, 3124, 3125, 3116, 4108, 4117, 4118, 4109
12576, 3116, 3125, 606, 605, 4109, 4118, 916, 915
12577, 530, 531, 3126, 3117, 905, 906, 4119, 4110
12578, 3117, 3126, 3127, 3118, 4110, 4119, 4120, 4111
12579, 3118, 3127, 3128, 3119, 4111, 4120, 4121, 4112
12580, 3119, 3128, 3129, 3120, 4112, 4121, 4122, 4113
12581, 3120, 3129, 3130, 3121, 4113, 4122, 4123, 4114
12582, 3121, 3130, 3131, 3122, 4114, 4123, 4124, 4115
12583, 3122, 3131, 3132, 3123, 4115, 4124, 4125, 4116
12584, 3123, 3132, 3133, 3124, 4116, 4125, 4126, 4117
12585, 3124, 3133, 3134, 3125, 4117, 4126, 4127, 4118
12586, 3125, 3134, 607, 606, 4118, 4127, 917, 916
12587, 531, 532, 3135, 3126, 906, 907, 4128, 4119
12588, 3126, 3135, 3136, 3127, 4119, 4128, 4129, 4120
12589, 3127, 3136, 3137, 3128, 4120, 4129, 4130, 4121
12590, 3128, 3137, 3138, 3129, 4121, 4130, 4131, 4122
12591, 3129, 3138, 3139, 3130, 4122, 4131, 4132, 4123
12592, 3130, 3139, 3140, 3131, 4123, 4132, 4133, 4124
12593, 3131, 3140, 3141, 3132, 4124, 4133, 4134, 4125
12594, 3132, 3141, 3142, 3133, 4125, 4134, 4135, 4126
12595, 3133, 3142, 3143, 3134, 4126, 4135, 4136, 4127
12596, 3134, 3143, 608, 607, 4127, 4136, 918, 917
12597, 532, 533, 3144, 3135, 907, 908, 4137, 4128
12598, 3135, 3144, 3145, 3136, 4128, 4137, 4138, 4129
12599, 3136, 3145, 3146, 3137, 4129, 4138, 4139, 4130
12600, 3137, 3146, 3147, 3138, 4130, 4139, 4140, 4131
12601, 3138, 3147, 3148, 3139, 4131, 4140, 4141, 4132
12602, 3139, 3148, 3149, 3140, 4132, 4141, 4142, 4133
12603, 3140, 3149, 3150, 3141, 4133, 4142, 4143, 4134
12604, 3141, 3150, 3151, 3142, 4134, 4143, 4144, 4135
12605, 3142, 3151, 3152, 3143, 4135, 4144, 4145, 4136
12606, 3143, 3152, 609, 608, 4136, 4145, 919, 918
12607, 533, 534, 3153, 3144, 908, 909, 4146, 4137
12608, 3144, 3153, 3154, 3145, 4137, 4146, 4147, 4138
12609, 3145, 3154, 3155, 3146, 4138, 4147, 4148, 4139
12610, 3146, 3155, 3156, 3147, 4139, 4148, 4149, 4140
12611, 3147, 3156, 3157, 3148, 4140, 4149, 4150, 4141
12612, 3148, 3157, 3158, 3149, 4141, 4150, 4151, 4142
12613, 3149, 3158, 3159, 3150, 4142, 4151, 4152, 4143
12614, 3150, 3159, 3160, 3151, 4143, 4152, 4153, 4144
12615, 3151, 3160, 3161, 3152, 4144, 4153, 4154, 4145
12616, 3152, 3161, 610, 609, 4145, 4154, 920, 919
12617, 534, 36, 591, 3153, 909, 71, 890, 4146
12618, 3153, 591, 592, 3154, 4146, 890, 891, 4147
12619, 3154, 592, 593, 3155, 4147, 891, 892, 4148
12620, 3155, 593, 594, 3156, 4148, 892, 893, 4149
12621, 3156, 594, 595, 3157, 4149, 893, 894, 4150
12622, 3157, 595, 596, 3158, 4150, 894, 895, 4151
12623, 3158, 596, 597, 3159, 4151, 895, 896, 4152
12624, 3159, 597, 598, 3160, 4152, 896, 897, 4153
12625, 3160, 598, 599, 3161, 4153, 897, 898, 4154
12626, 3161, 599, 40, 610, 4154, 898, 72, 920
*ELEMENT, type=C3D8, ELSET=Volume16
12627, 9, 229, 1725, 200, 59, 778, 3795, 787
12628, 229, 230, 1726, 1725, 778, 779, 3796, 3795
12629, 230, 231, 1727, 1726, 779, 780, 3797, 3796
12630, 231, 232, 1728, 1727, 780, 781, 3798, 3797
12631, 232, 233, 1729, 1728, 781, 782, 3799, 3798
12632, 233, 234, 1730, 1729, 782, 783, 3800, 3799
12633, 234, 235, 1731, 1730, 783, 784, 3801, 3800
12634, 235, 236, 1732, 1731, 784, 785, 3802, 3801
12635, 236, 237, 1733, 1732, 785, 786, 3803, 3802
12636, 237, 13, 267, 1733, 786, 60, 796, 3803
12637, 200, 1725, 1734, 201, 787, 3795, 3804, 788
12638, 1725, 1726, 1735, 1734, 3795, 3796, 3805, 3804
12639, 1726, 1727, 1736, 1735, 3796, 3797, 3806, 3805
12640, 1727, 1728, 1737, 1736, 3797, 3798, 3807, 3806
12641, 1728, 1729, 1738, 1737, 3798, 3799, 3808, 3807
12642, 1729, 1730, 1739, 1738, 3799, 3800, 3809, 3808
12643, 1730, 1731, 1740, 1739, 3800, 3801, 3810, 3809
12644, 1731, 1732, 1741, 1740, 3801, 3802, 3811, 3810
12645, 1732, 1733, 1742, 1741, 3802, 3803, 3812, 3811
12646, 1733, 267, 268, 1742, 3803, 796, 797, 3812
12647, 201, 1734, 1743, 202, 788, 3804, 3813, 789
12648, 1734, 1735, 1744, 1743, 3804, 3805, 3814, 3813
12649, 1735, 1736, 1745, 1744, 3805, 3806, 3815, 3814
12650, 1736, 1737, 1746, 1745, 3806, 3807, 3816, 3815
12651, 1737, 1738, 1747, 1746, 3807, 3808, 3817, 3816
12652, 1738, 1739, 1748, 1747, 3808, 3809, 3818, 3817
12653, 1739, 1740, 1749, 1748, 3809, 3810, 3819, 3818
12654, 1740, 1741, 1750, 1749, 3810, 3811, 3820, 3819
12655, 1741, 1742, 1751, 1750, 3811, 3812, 3821, 3820
12656, 1742, 268, 269, 1751, 3812, 797, 798, 3821
12657, 202, 1743, 1752, 203, 789, 3813, 3822, 790
12658, 1743, 1744, 1753, 1752, 3813, 3814, 3823, 3822
12659, 1744, 1745, 1754, 1753, 3814, 3815, 3824, 3823
12660, 1745, 1746, 1755, 1754, 3815, 3816, 3825, 3824
12661, 1746, 1747, 1756, 1755, 3816, 3817, 3826, 3825
12662, 1747, 1748, 1757, 1756, 3817, 3818, 3827, 3826
12663, 1748, 1749, 1758, 1757, 3818, 3819, 3828, 3827
12664, 1749, 1750, 1759, 1758, 3819, 3820, 3829, 3828
12665, 1750, 1751, 1760, 1759, 3820, 3821, 3830, 3829
12666, 1751, 269, 270, 1760, 3821, 798, 799, 3830
12667, 203, 1752, 1761, 204, 790, 3822, 3831, 791
12668, 1752, 1753, 1762, 1761, 3822, 3823, 3832, 3831
12669, 1753, 1754, 1763, 1762, 3823, 3824, 3833, 3832
12670, 1754, 1755, 1764, 1763, 3824, 3825, 3834, 3833
12671, 1755, 1756, 1765, 1764, 3825, 3826, 3835, 3834
12672, 1756, 1757, 1766, 1765, 3826, 3827, 3836, 3835
12673, 1757, 1758, 1767, 1766, 3827, 3828, 3837, 3836
12674, 1758, 1759, 1768, 1767, 3828, 3829, 3838, 3837
12675, 1759, 1760, 1769, 1768, 3829, 3830, 3839, 3838
12676, 1760, 270, 271, 1769, 3830, 799, 800, 3839
12677, 204, 1761, 1770, 205, 791, 3831, 3840, 792
12678, 1761, 1762, 1771, 1770, 3831, 3832, 3841, 3840
12679, 1762, 1763, 1772, 1771, 3832, 3833, 3842, 3841
12680, 1763, 1764, 1773, 1772, 3833, 3834, 3843, 3842
12681, 1764, 1765, 1774, 1773, 3834, 3835, 3844, 3843
12682, 1765, 1766, 1775, 1774, 3835, 3836, 3845, 3844
12683, 1766, 1767, 1776, 1775, 3836, 3837, 3846, 3845
12684, 1767, 1768, 1777, 1776, 3837, 3838, 3847, 3846
12685, 1768, 1769, 1778, 1777, 3838, 3839, 3848, 3847
12686, 1769, 271, 272, 1778, 3839, 800, 801, 3848
12687, 205, 1770, 1779, 206, 792, 3840, 3849, 793
12688, 1770, 1771, 1780, 1779, 3840, 3841, 3850, 3849
12689, 1771, 1772, 1781, 1780, 3841, 3842, 3851, 3850
12690, 1772, 1773, 1782, 1781, 3842, 3843, 3852, 3851
12691, 1773, 1774, 1783, 1782, 3843, 3844, 3853, 3852
12692, 1774, 1775, 1784, 1783, 3844, 3845, 3854, 3853
12693, 1775, 1776, 1785, 1784, 3845, 3846, 3855, 3854
12694, 1776, 1777, 1786, 1785, 3846, 3847, 3856, 3855
12695, 1777, 1778, 1787, 1786, 3847, 3848, 3857, 3856
12696, 1778, 272, 273, 1787, 3848, 801, 802, 3857
12697, 206, 1779, 1788, 207, 793, 3849, 3858, 794
12698, 1779, 1780, 1789, 1788, 3849, 3850, 3859, 3858
12699, 1780, 1781, 1790, 1789, 3850, 3851, 3860, 3859
12700, 1781, 1782, 1791, 1790, 3851, 3852, 3861, 3860
12701, 1782, 1783, 1792, 1791, 3852, 3853, 3862, 3861
12702, 1783, 1784, 1793, 1792, 3853, 3854, 3863, 3862
12703, 1784, 1785, 1794, 1793, 3854, 3855, 3864, 3863
12704, 1785, 1786, 1795, 1794, 3855, 3856, 3865, 3864
12705, 1786, 1787, 1796, 1795, 3856, 3857, 3866, 3865
12706, 1787, 273, 274, 1796, 3857, 802, 803, 3866
12707, 207, 1788, 1797, 208, 794, 3858, 3867, 795
12708, 1788, 1789, 1798, 1797, 3858, 3859, 3868, 3867
12709, 1789, 1790, 1799, 1798, 3859, 3860, 3869, 3868
12710, 1790, 1791, 1800, 1799, 3860, 3861, 3870, 3869
12711, 1791, 1792, 1801, 1800, 3861, 3862, 3871, 3870
12712, 1792, 1793, 1802, 1801, 3862, 3863, 3872, 3871
12713, 1793, 1794, 1803, 1802, 3863, 3864, 3873, 3872
12714, 1794, 1795, 1804, 1803, 3864, 3865, 3874, 3873
12715, 1795, 1796, 1805, 1804, 3865, 3866, 3875, 3874
12716, 1796, 274, 275, 1805, 3866, 803, 804, 3875
12717, 208, 1797, 258, 11, 795, 3867, 769, 57
12718, 1797, 1798, 259, 258, 3867, 3868, 770, 769
12719, 1798, 1799, 260, 259, 3868, 3869, 771, 770
12720, 1799, 1800, 261, 260, 3869, 3870, 772, 771
12721, 1800, 1801, 262, 261, 3870, 3871, 773, 772
12722, 1801, 1802, 263, 262, 3871, 3872, 774, 773
12723, 1802, 1803, 264, 263, 3872, 3873, 775, 774
12724, 1803, 1804, 265, 264, 3873, 3874, 776, 775
12725, 1804, 1805, 266, 265, 3874, 3875, 777, 776
12726, 1805, 275, 15, 266, 3875, 804, 58, 777
*ELEMENT, type=C3D8, ELSET=Volume17
12727, 35, 582, 3162, 535, 63, 814, 3876, 823
12728, 582, 583, 3163, 3162, 814, 815, 3877, 3876
12729, 583, 584, 3164, 3163, 815, 816, 3878, 3877
12730, 584, 585, 3165, 3164, 816, 817, 3879, 3878
12731, 585, 586, 3166, 3165, 817, 818, 3880, 3879
12732, 586, 587, 3167, 3166, 818, 819, 3881, 3880
12733, 587, 588, 3168, 3167, 819, 820, 3882, 3881
12734, 588, 589, 3169, 3168, 820, 821, 3883, 3882
12735, 589, 590, 3170, 3169, 821, 822, 3884, 3883
12736, 590, 39, 611, 3170, 822, 64, 832, 3884
12737, 535, 3162, 3171, 536, 823, 3876, 3885, 824
12738, 3162, 3163, 3172, 3171, 3876, 3877, 3886, 3885
12739, 3163, 3164, 3173, 3172, 3877, 3878, 3887, 3886
12740, 3164, 3165, 3174, 3173, 3878, 3879, 3888, 3887
12741, 3165, 3166, 3175, 3174, 3879, 3880, 3889, 3888
12742, 3166, 3167, 3176, 3175, 3880, 3881, 3890, 3889
12743, 3167, 3168, 3177, 3176, 3881, 3882, 3891, 3890
12744, 3168, 3169, 3178, 3177, 3882, 3883, 3892, 3891
12745, 3169, 3170, 3179, 3178, 3883, 3884, 3893, 3892
12746, 3170, 611, 612, 3179, 3884, 832, 833, 3893
12747, 536, 3171, 3180, 537, 824, 3885, 3894, 825
12748, 3171, 3172, 3181, 3180, 3885, 3886, 3895, 3894
12749, 3172, 3173, 3182, 3181, 3886, 3887, 3896, 3895
12750, 3173, 3174, 3183, 3182, 3887, 3888, 3897, 3896
12751, 3174, 3175, 3184, 3183, 3888, 3889, 3898, 3897
12752, 3175, 3176, 3185, 3184, 3889, 3890, 3899, 3898
12753, 3176, 3177, 3186, 3185, 3890, 3891, 3900, 3899
12754, 3177, 3178, 3187, 3186, 3891, 3892, 3901, 3900
12755, 3178, 3179, 3188, 3187, 3892, 3893, 3902, 3901
12756, 3179, 612, 613, 3188, 3893, 833, 834, 3902
12757, 537, 3180, 3189, 538, 825, 3894, 3903, 826
12758, 3180, 3181, 3190, 3189, 3894, 3895, 3904, 3903
12759, 3181, 3182, 3191, 3190, 3895, 3896, 3905, 3904
12760, 3182, 3183, 3192, 3191, 3896, 3897, 3906, 3905
12761, 3183, 3184, 3193, 3192, 3897, 3898, 3907, 3906
12762, 3184, 3185, 3194, 3193, 3898, 3899, 3908, 3907
12763, 3185, 3186, 3195, 3194, 3899, 3900, 3909, 3908
12764, 3186, 3187, 3196, 3195, 3900, 3901, 3910, 3909
12765, 3187, 3188, 3197, 3196, 3901, 3902, 3911, 3910
12766, 3188, 613, 614, 3197, 3902, 834, 835, 3911
12767, 538, 3189, 3198, 539, 826, 3903, 3912, 827
12768, 3189, 3190, 3199, 3198, 3903, 3904, 3913, 3912
12769, 3190, 3191, 3200, 3199, 3904, 3905, 3914, 3913
12770, 3191, 3192, 3201, 3200, 3905, 3906, 3915, 3914
12771, 3192, 3193, 3202, 3201, 3906, 3907, 3916, 3915
12772, 3193, 3194, 3203, 3202, 3907, 3908, 3917, 3916
12773, 3194, 3195, 3204, 3203, 3908, 3909, 3918, 3917
12774, 3195, 3196, 3205, 3204, 3909, 3910, 3919, 3918
12775, 3196, 3197, 3206, 3205, 3910, 3911, 3920, 3919
12776, 3197, 614, 615, 3206, 3911, 835, 836, 3920
12777, 539, 3198, 3207, 540, 827, 3912, 3921, 828
12778, 3198, 3199, 3208, 3207, 3912, 3913, 3922, 3921
12779, 3199, 3200, 3209, 3208, 3913, 3914, 3923, 3922
12780, 3200, 3201, 3210, 3209, 3914, 3915, 3924, 3923
12781, 3201, 3202, 3211, 3210, 3915, 3916, 3925, 3924
12782, 3202, 3203, 3212, 3211, 3916, 3917, 3926, 3925
12783, 3203, 3204, 3213, 3212, 3917, 3918, 3927, 3926
12784, 3204, 3205, 3214, 3213, 3918, 3919, 3928, 3927
12785, 3205, 3206, 3215, 3214, 3919, 3920, 3929, 3928
12786, 3206, 615, 616, 3215, 3920, 836, 837, 3929
12787, 540, 3207, 3216, 541, 828, 3921, 3930, 829
12788, 3207, 3208, 3217, 3216, 3921, 3922, 3931, 3930
12789, 3208, 3209, 3218, 3217, 3922, 3923, 3932, 3931
12790, 3209, 3210, 3219, 3218, 3923, 3924, 3933, 3932
12791, 3210, 3211, 3220, 3219, 3924, 3925, 3934, 3933
12792, 3211, 3212, 3221, 3220, 3925, 3926, 3935, 3934
12793, 3212, 3213, 3222, 3221, 3926, 3927, 3936, 3935
12794, 3213, 3214, 3223, 3222, 3927, 3928, 3937, 3936
12795, 3214, 3215, 3224, 3223, 3928, 3929, 3938, 3937
12796, 3215, 616, 617, 3224, 3929, 837, 838, 3938
12797, 541, 3216, 3225, 542, 829, 3930, 3939, 830
12798, 3216, 3217, 3226, 3225, 3930, 3931, 3940, 3939
12799, 3217, 3218, 3227, 3226, 3931, 3932, 3941, 3940
12800, 3218, 3219, 3228, 3227, 3932, 3933, 3942, 3941
12801, 3219, 3220, 3229, 3228, 3933, 3934, 3943, 3942
12802, 3220, 3221, 3230, 3229, 3934, 3935, 3944, 3943
12803, 3221, 3222, 3231, 3230, 3935, 3936, 3945, 3944
12804, 3222, 3223, 3232, 3231, 3936, 3937, 3946, 3945
12805, 3223, 3224, 3233, 3232, 3937, 3938, 3947, 3946
12806, 3224, 617, 618, 3233, 3938, 838, 839, 3947
12807, 542, 3225, 3234, 543, 830, 3939, 3948, 831
12808, 3225, 3226, 3235, 3234, 3939, 3940, 3949, 3948
12809, 3226, 3227, 3236, 3235, 3940, 3941, 3950, 3949
12810, 3227, 3228, 3237, 3236, 3941, 3942, 3951, 3950
12811, 3228, 3229, 3238, 3237, 3942, 3943, 3952, 3951
12812, 3229, 3230, 3239, 3238, 3943, 3944, 3953, 3952
12813, 3230, 3231, 3240, 3239, 3944, 3945, 3954, 3953
12814, 3231, 3232, 3241, 3240, 3945, 3946, 3955, 3954
12815, 3232, 3233, 3242, 3241, 3946, 3947, 3956, 3955
12816, 3233, 618, 619, 3242, 3947, 839, 840, 3956
12817, 543, 3234, 553, 33, 831, 3948, 805, 61
12818, 3234, 3235, 554, 553, 3948, 3949, 806, 805
12819, 3235, 3236, 555, 554, 3949, 3950, 807, 806
12820, 3236, 3237, 556, 555, 3950, 3951, 808, 807
12821, 3237, 3238, 557, 556, 3951, 3952, 809, 808
12822, 3238, 3239, 558, 557, 3952, 3953, 810, 809
12823, 3239, 3240, 559, 558, 3953, 3954, 811, 810
12824, 3240, 3241, 560, 559, 3954, 3955, 812, 811
12825, 3241, 3242, 561, 560, 3955, 3956, 813, 812
12826, 3242, 619, 37, 561, 3956, 840, 62, 813
*ELEMENT, type=C3D8, ELSET=Volume18
12827, 35, 582, 814, 63, 69, 881, 921, 73
12828, 582, 583, 815, 814, 881, 882, 922, 921
12829, 583, 584, 816, 815, 882, 883, 923, 922
12830, 584, 585, 817, 816, 883, 884, 924, 923
12831, 585, 586, 818, 817, 884, 885, 925, 924
12832, 586, 587, 819, 818, 885, 886, 926, 925
12833, 587, 588, 820, 819, 886, 887, 927, 926
12834, 588, 589, 821, 820, 887, 888, 928, 927
12835, 589, 590, 822, 821, 888, 889, 929, 928
12836, 590, 39, 64, 822, 889, 70, 74, 929
*ELEMENT, type=C3D8, ELSET=Volume19
12837, 9, 229, 778, 59, 65, 841, 930, 75
12838, 229, 230, 779, 778, 841, 842, 931, 930
12839, 230, 231, 780, 779, 842, 843, 932, 931
12840, 231, 232, 781, 780, 843, 844, 933, 932
12841, 232, 233, 782, 781, 844, 845, 934, 933
12842, 233, 234, 783, 782, 845, 846, 935, 934
12843, 234, 235, 784, 783, 846, 847, 936, 935
12844, 235, 236, 785, 784, 847, 848, 937, 936
12845, 236, 237, 786, 785, 848, 849, 938, 937
12846, 237, 13, 60, 786, 849, 66, 76, 938
*ELEMENT, type=C3D8, ELSET=Volume20
12847, 22, 388, 2304, 351, 943, 4279, 8497, 4155
12848, 943, 4279, 8497, 4155, 944, 4280, 8498, 4156
12849, 944, 4280, 8498, 4156, 945, 4281, 8499, 4157
12850, 945, 4281, 8499, 4157, 946, 4282, 8500, 4158
12851, 946, 4282, 8500, 4158, 78, 986, 4315, 947
12852, 388, 389, 2305, 2304, 4279, 4283, 8501, 8497
12853, 4279, 4283, 8501, 8497, 4280, 4284, 8502, 8498
12854, 4280, 4284, 8502, 8498, 4281, 4285, 8503, 8499
12855, 4281, 4285, 8503, 8499, 4282, 4286, 8504, 8500
12856, 4282, 4286, 8504, 8500, 986, 987, 4316, 4315
12857, 389, 390, 2306, 2305, 4283, 4287, 8505, 8501
12858, 4283, 4287, 8505, 8501, 4284, 4288, 8506, 8502
12859, 4284, 4288, 8506, 8502, 4285, 4289, 8507, 8503
12860, 4285, 4289, 8507, 8503, 4286, 4290, 8508, 8504
12861, 4286, 4290, 8508, 8504, 987, 988, 4317, 4316
12862, 390, 391, 2307, 2306, 4287, 4291, 8509, 8505
12863, 4287, 4291, 8509, 8505, 4288, 4292, 8510, 8506
12864, 4288, 4292, 8510, 8506, 4289, 4293, 8511, 8507
12865, 4289, 4293, 8511, 8507, 4290, 4294, 8512, 8508
12866, 4290, 4294, 8512, 8508, 988, 989, 4318, 4317
12867, 391, 392, 2308, 2307, 4291, 4295, 8513, 8509
12868, 4291, 4295, 8513, 8509, 4292, 4296, 8514, 8510
12869, 4292, 4296, 8514, 8510, 4293, 4297, 8515, 8511
12870, 4293, 4297, 8515, 8511, 4294, 4298, 8516, 8512
12871, 4294, 4298, 8516, 8512, 989, 990, 4319, 4318
12872, 392, 393, 2309, 2308, 4295, 4299, 8517, 8513
12873, 4295, 4299, 8517, 8513, 4296, 4300, 8518, 8514
12874, 4296, 4300, 8518, 8514, 4297, 4301, 8519, 8515
12875, 4297, 4301, 8519, 8515, 4298, 4302, 8520, 8516
12876, 4298, 4302, 8520, 8516, 990, 991, 4320, 4319
12877, 393, 394, 2310, 2309, 4299, 4303, 8521, 8517
12878, 4299, 4303, 8521, 8517, 4300, 4304, 8522, 8518
12879, 4300, 4304, 8522, 8518, 4301, 4305, 8523, 8519
12880, 4301, 4305, 8523, 8519, 4302, 4306, 8524, 8520
12881, 4302, 4306, 8524, 8520, 991, 992, 4321, 4320
12882, 394, 395, 2311, 2310, 4303, 4307, 8525, 8521
12883, 4303, 4307, 8525, 8521, 4304, 4308, 8526, 8522
12884, 4304, 4308, 8526, 8522, 4305, 4309, 8527, 8523
12885, 4305, 4309, 8527, 8523, 4306, 4310, 8528, 8524
12886, 4306, 4310, 8528, 8524, 992, 993, 4322, 4321
12887, 395, 396, 2312, 2311, 4307, 4311, 8529, 8525
12888, 4307, 4311, 8529, 8525, 4308, 4312, 8530, 8526
12889, 4308, 4312, 8530, 8526, 4309, 4313, 8531, 8527
12890, 4309, 4313, 8531, 8527, 4310, 4314, 8532, 8528
12891, 4310, 4314, 8532, 8528, 993, 994, 4323, 4322
12892, 396, 24, 377, 2312, 4311, 971, 4235, 8529
12893, 4311, 971, 4235, 8529, 4312, 972, 4236, 8530
12894, 4312, 972, 4236, 8530, 4313, 973, 4237, 8531
12895, 4313, 973, 4237, 8531, 4314, 974, 4238, 8532
12896, 4314, 974, 4238, 8532, 994, 80, 975, 4323
12897, 351, 2304, 2313, 352, 4155, 8497, 8533, 4159
12898, 4155, 8497, 8533, 4159, 4156, 8498, 8534, 4160
12899, 4156, 8498, 8534, 4160, 4157, 8499, 8535, 4161
12900, 4157, 8499, 8535, 4161, 4158, 8500, 8536, 4162
12901, 4158, 8500, 8536, 4162, 947, 4315, 4324, 948
12902, 2304, 2305, 2314, 2313, 8497, 8501, 8537, 8533
12903, 8497, 8501, 8537, 8533, 8498, 8502, 8538, 8534
12904, 8498, 8502, 8538, 8534, 8499, 8503, 8539, 8535
12905, 8499, 8503, 8539, 8535, 8500, 8504, 8540, 8536
12906, 8500, 8504, 8540, 8536, 4315, 4316, 4325, 4324
12907, 2305, 2306, 2315, 2314, 8501, 8505, 8541, 8537
12908, 8501, 8505, 8541, 8537, 8502, 8506, 8542, 8538
12909, 8502, 8506, 8542, 8538, 8503, 8507, 8543, 8539
12910, 8503, 8507, 8543, 8539, 8504, 8508, 8544, 8540
12911, 8504, 8508, 8544, 8540, 4316, 4317, 4326, 4325
12912, 2306, 2307, 2316, 2315, 8505, 8509, 8545, 8541
12913, 8505, 8509, 8545, 8541, 8506, 8510, 8546, 8542
12914, 8506, 8510, 8546, 8542, 8507, 8511, 8547, 8543
12915, 8507, 8511, 8547, 8543, 8508, 8512, 8548, 8544
12916, 8508, 8512, 8548, 8544, 4317, 4318, 4327, 4326
12917, 2307, 2308, 2317, 2316, 8509, 8513, 8549, 8545
12918, 8509, 8513, 8549, 8545, 8510, 8514, 8550, 8546
12919, 8510, 8514, 8550, 8546, 8511, 8515, 8551, 8547
12920, 8511, 8515, 8551, 8547, 8512, 8516, 8552, 8548
12921, 8512, 8516, 8552, 8548, 4318, 4319, 4328, 4327
12922, 2308, 2309, 2318, 2317, 8513, 8517, 8553, 8549
12923, 8513, 8517, 8553, 8549, 8514, 8518, 8554, 8550
12924, 8514, 8518, 8554, 8550, 8515, 8519, 8555, 8551
12925, 8515, 8519, 8555, 8551, 8516, 8520, 8556, 8552
12926, 8516, 8520, 8556, 8552, 4319, 4320, 4329, 4328
12927, 2309, 2310, 2319, 2318, 8517, 8521, 8557, 8553
12928, 8517, 8521, 8557, 8553, 8518, 8522, 8558, 8554
12929, 8518, 8522, 8558, 8554, 8519, 8523, 8559, 8555
12930, 8519, 8523, 8559, 8555, 8520, 8524, 8560, 8556
12931, 8520, 8524, 8560, 8556, 4320, 4321, 4330, 4329
12932, 2310, 2311, 2320, 2319, 8521, 8525, 8561, 8557
12933, 8521, 8525, 8561, 8557, 8522, 8526, 8562, 8558
12934, 8522, 8526, 8562, 8558, 8523, 8527, 8563, 8559
12935, 8523, 8527, 8563, 8559, 8524, 8528, 8564, 8560
12936, 8524, 8528, 8564, 8560, 4321, 4322, 4331, 4330
12937, 2311, 2312, 2321, 2320, 8525, 8529, 8565, 8561
12938, 8525, 8529, 8565, 8561, 8526, 8530, 8566, 8562
12939, 8526, 8530, 8566, 8562, 8527, 8531, 8567, 8563
12940, 8527, 8531, 8567, 8563, 8528, 8532, 8568, 8564
12941, 8528, 8532, 8568, 8564, 4322, 4323, 4332, 4331
12942, 2312, 377, 378, 2321, 8529, 4235, 4239, 8565
12943, 8529, 4235, 4239, 8565, 8530, 4236, 4240, 8566
12944, 8530, 4236, 4240, 8566, 8531, 4237, 4241, 8567
12945, 8531, 4237, 4241, 8567, 8532, 4238, 4242, 8568
12946, 8532, 4238, 4242, 8568, 4323, 975, 976, 4332
12947, 352, 2313, 2322, 353, 4159, 8533, 8569, 4163
12948, 4159, 8533, 8569, 4163, 4160, 8534, 8570, 4164
12949, 4160, 8534, 8570, 4164, 4161, 8535, 8571, 4165
12950, 4161, 8535, 8571, 4165, 4162, 8536, 8572, 4166
12951, 4162, 8536, 8572, 4166, 948, 4324, 4333, 949
12952, 2313, 2314, 2323, 2322, 8533, 8537, 8573, 8569
12953, 8533, 8537, 8573, 8569, 8534, 8538, 8574, 8570
12954, 8534, 8538, 8574, 8570, 8535, 8539, 8575, 8571
12955, 8535, 8539, 8575, 8571, 8536, 8540, 8576, 8572
12956, 8536, 8540, 8576, 8572, 4324, 4325, 4334, 4333
12957, 2314, 2315, 2324, 2323, 8537, 8541, 8577, 8573
12958, 8537, 8541, 8577, 8573, 8538, 8542, 8578, 8574
12959, 8538, 8542, 8578, 8574, 8539, 8543, 8579, 8575
12960, 8539, 8543, 8579, 8575, 8540, 8544, 8580, 8576
12961, 8540, 8544, 8580, 8576, 4325, 4326, 4335, 4334
12962, 2315, 2316, 2325, 2324, 8541, 8545, 8581, 8577
12963, 8541, 8545, 8581, 8577, 8542, 8546, 8582, 8578
12964, 8542, 8546, 8582, 8578, 8543, 8547, 8583, 8579
12965, 8543, 8547, 8583, 8579, 8544, 8548, 8584, 8580
12966, 8544, 8548, 8584, 8580, 4326, 4327, 4336, 4335
12967, 2316, 2317, 2326, 2325, 8545, 8549, 8585, 8581
12968, 8545, 8549, 8585, 8581, 8546, 8550, 8586, 8582
12969, 8546, 8550, 8586, 8582, 8547, 8551, 8587, 8583
12970, 8547, 8551, 8587, 8583, 8548, 8552, 8588, 8584
12971, 8548, 8552, 8588, 8584, 4327, 4328, 4337, 4336
12972, 2317, 2318, 2327, 2326, 8549, 8553, 8589, 8585
12973, 8549, 8553, 8589, 8585, 8550, 8554, 8590, 8586
12974, 8550, 8554, 8590, 8586, 8551, 8555, 8591, 8587
