10226, 1.6166666666667, -0.08, 0.4
10227, 1.6166666666667, -0.12, 0.4
10228, 1.6166666666667, -0.16, 0.4
10229, 1.7, -0.04, 0.4
10230, 1.7, -0.08, 0.4
10231, 1.7, -0.12, 0.4
10232, 1.7, -0.16, 0.4
10233, 1.7833333333333, -0.04, 0.4
10234, 1.7833333333333, -0.08, 0.4
10235, 1.7833333333333, -0.12, 0.4
10236, 1.7833333333333, -0.16, 0.4
10237, 1.8666666666667, -0.04, 0.4
10238, 1.8666666666667, -0.08, 0.4
10239, 1.8666666666667, -0.12, 0.4
10240, 1.8666666666667, -0.16, 0.4
10241, 1.95, -0.04, 0.4
10242, 1.95, -0.08, 0.4
10243, 1.95, -0.12, 0.4
10244, 1.95, -0.16, 0.4
10245, 2.0333333333333, -0.04, 0.4
10246, 2.0333333333333, -0.08, 0.4
10247, 2.0333333333333, -0.12, 0.4
10248, 2.0333333333333, -0.16, 0.4
10249, 2.1166666666667, -0.04, 0.4
10250, 2.1166666666667, -0.08, 0.4
10251, 2.1166666666667, -0.12, 0.4
10252, 2.1166666666667, -0.16, 0.4
10253, 1.2833333333333, -0.04, 0.45
10254, 1.2833333333333, -0.08, 0.45
10255, 1.2833333333333, -0.12, 0.45
10256, 1.2833333333333, -0.16, 0.45
10257, 1.3666666666667, -0.04, 0.45
10258, 1.3666666666667, -0.08, 0.45
10259, 1.3666666666667, -0.12, 0.45
10260, 1.3666666666667, -0.16, 0.45
10261, 1.45, -0.04, 0.45
10262, 1.45, -0.08, 0.45
10263, 1.45, -0.12, 0.45
10264, 1.45, -0.16, 0.45
10265, 1.5333333333333, -0.04, 0.45
10266, 1.5333333333333, -0.08, 0.45
10267, 1.5333333333333, -0.12, 0.45
10268, 1.5333333333333, -0.16, 0.45
10269, 1.6166666666667, -0.04, 0.45
10270, 1.6166666666667, -0.08, 0.45
10271, 1.6166666666667, -0.12, 0.45
10272, 1.6166666666667, -0.16, 0.45
10273, 1.7, -0.04, 0.45
10274, 1.7, -0.08, 0.45
10275, 1.7, -0.12, 0.45
10276, 1.7, -0.16, 0.45
10277, 1.7833333333333, -0.04, 0.45
10278, 1.7833333333333, -0.08, 0.45
10279, 1.7833333333333, -0.12, 0.45
10280, 1.7833333333333, -0.16, 0.45
10281, 1.8666666666667, -0.04, 0.45
10282, 1.8666666666667, -0.08, 0.45
10283, 1.8666666666667, -0.12, 0.45
10284, 1.8666666666667, -0.16, 0.45
10285, 1.95, -0.04, 0.45
10286, 1.95, -0.08, 0.45
10287, 1.95, -0.12, 0.45
10288, 1.95, -0.16, 0.45
10289, 2.0333333333333, -0.04, 0.45
10290, 2.0333333333333, -0.08, 0.45
10291, 2.0333333333333, -0.12, 0.45
10292, 2.0333333333333, -0.16, 0.45
10293, 2.1166666666667, -0.04, 0.45
10294, 2.1166666666667, -0.08, 0.45
10295, 2.1166666666667, -0.12, 0.45
10296, 2.1166666666667, -0.16, 0.45
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 99
100, 99, 100
101, 100, 101
102, 101, 102
103, 102, 103
104, 103, 104
105, 104, 105
106, 105, 1
*ELEMENT, type=T3D2, ELSET=Line2
107, 1, 106
108, 106, 107
109, 107, 108
110, 108, 3
*ELEMENT, type=T3D2, ELSET=Line3
111, 4, 109
112, 109, 110
113, 110, 111
114, 111, 112
115, 112, 113
116, 113, 114
117, 114, 115
118, 115, 116
119, 116, 117
120, 117, 3
*ELEMENT, type=T3D2, ELSET=Line4
121, 2, 118
122, 118, 119
123, 119, 120
124, 120, 4
*ELEMENT, type=T3D2, ELSET=Line5
125, 6, 121
126, 121, 122
127, 122, 123
128, 123, 124
129, 124, 125
130, 125, 126
131, 126, 127
132, 127, 128
133, 128, 129
134, 129, 5
*ELEMENT, type=T3D2, ELSET=Line6
135, 5, 130
136, 130, 131
137, 131, 132
138, 132, 7
*ELEMENT, type=T3D2, ELSET=Line7
139, 8, 133
140, 133, 134
141, 134, 135
142, 135, 136
143, 136, 137
144, 137, 138
145, 138, 139
146, 139, 140
147, 140, 141
148, 141, 7
*ELEMENT, type=T3D2, ELSET=Line8
149, 6, 142
150, 142, 143
151, 143, 144
152, 144, 8
*ELEMENT, type=T3D2, ELSET=Line9
153, 2, 145
154, 145, 146
155, 146, 147
156, 147, 148
157, 148, 149
158, 149, 150
159, 150, 151
160, 151, 152
161, 152, 153
162, 153, 154
163, 154, 155
164, 155, 6
*ELEMENT, type=T3D2, ELSET=Line10
165, 1, 156
166, 156, 157
167, 157, 158
168, 158, 159
169, 159, 160
170, 160, 161
171, 161, 162
172, 162, 163
173, 163, 164
174, 164, 165
175, 165, 166
176, 166, 5
*ELEMENT, type=T3D2, ELSET=Line11
177, 4, 167
178, 167, 168
179, 168, 169
180, 169, 170
181, 170, 171
182, 171, 172
183, 172, 173
184, 173, 174
185, 174, 175
186, 175, 176
187, 176, 177
188, 177, 8
*ELEMENT, type=T3D2, ELSET=Line12
189, 3, 178
190, 178, 179
191, 179, 180
192, 180, 181
193, 181, 182
194, 182, 183
195, 183, 184
196, 184, 185
197, 185, 186
198, 186, 187
199, 187, 188
200, 188, 7
*ELEMENT, type=T3D2, ELSET=Line13
201, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
202, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
203, 10, 189
204, 189, 190
205, 190, 191
206, 191, 192
207, 192, 193
208, 193, 194
209, 194, 195
210, 195, 196
211, 196, 197
212, 197, 198
213, 198, 199
214, 199, 9
*ELEMENT, type=T3D2, ELSET=Line16
215, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
216, 9, 200
217, 200, 201
218, 201, 202
219, 202, 203
220, 203, 204
221, 204, 205
222, 205, 206
223, 206, 207
224, 207, 208
225, 208, 11
*ELEMENT, type=T3D2, ELSET=Line18
226, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
227, 12, 209
228, 209, 210
229, 210, 211
230, 211, 212
231, 212, 213
232, 213, 214
233, 214, 215
234, 215, 216
235, 216, 217
236, 217, 218
237, 218, 219
238, 219, 11
*ELEMENT, type=T3D2, ELSET=Line20
239, 10, 220
240, 220, 221
241, 221, 222
242, 222, 223
243, 223, 224
244, 224, 225
245, 225, 226
246, 226, 227
247, 227, 228
248, 228, 12
*ELEMENT, type=T3D2, ELSET=Line21
249, 9, 229
250, 229, 230
251, 230, 231
252, 231, 232
253, 232, 233
254, 233, 234
255, 234, 235
256, 235, 236
257, 236, 237
258, 237, 13
*ELEMENT, type=T3D2, ELSET=Line22
259, 10, 238
260, 238, 239
261, 239, 240
262, 240, 241
263, 241, 242
264, 242, 243
265, 243, 244
266, 244, 245
267, 245, 246
268, 246, 14
*ELEMENT, type=T3D2, ELSET=Line23
269, 14, 247
270, 247, 248
271, 248, 249
272, 249, 250
273, 250, 251
274, 251, 252
275, 252, 253
276, 253, 254
277, 254, 255
278, 255, 256
279, 256, 257
280, 257, 13
*ELEMENT, type=T3D2, ELSET=Line24
281, 11, 258
282, 258, 259
283, 259, 260
284, 260, 261
285, 261, 262
286, 262, 263
287, 263, 264
288, 264, 265
289, 265, 266
290, 266, 15
*ELEMENT, type=T3D2, ELSET=Line25
291, 13, 267
292, 267, 268
293, 268, 269
294, 269, 270
295, 270, 271
296, 271, 272
297, 272, 273
298, 273, 274
299, 274, 275
300, 275, 15
*ELEMENT, type=T3D2, ELSET=Line26
301, 12, 276
302, 276, 277
303, 277, 278
304, 278, 279
305, 279, 280
306, 280, 281
307, 281, 282
308, 282, 283
309, 283, 284
310, 284, 16
*ELEMENT, type=T3D2, ELSET=Line27
311, 16, 285
312, 285, 286
313, 286, 287
314, 287, 288
315, 288, 289
316, 289, 290
317, 290, 291
318, 291, 292
319, 292, 293
320, 293, 294
321, 294, 295
322, 295, 15
*ELEMENT, type=T3D2, ELSET=Line28
323, 14, 296
324, 296, 297
325, 297, 298
326, 298, 299
327, 299, 300
328, 300, 301
329, 301, 302
330, 302, 303
331, 303, 304
332, 304, 16
*ELEMENT, type=T3D2, ELSET=Line29
333, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
334, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
335, 18, 305
336, 305, 306
337, 306, 307
338, 307, 308
339, 308, 309
340, 309, 310
341, 310, 311
342, 311, 312
343, 312, 313
344, 313, 314
345, 314, 315
346, 315, 17
*ELEMENT, type=T3D2, ELSET=Line32
347, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
348, 17, 316
349, 316, 317
350, 317, 318
351, 318, 319
352, 319, 320
353, 320, 321
354, 321, 322
355, 322, 323
356, 323, 324
357, 324, 19
*ELEMENT, type=T3D2, ELSET=Line34
358, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
359, 20, 325
360, 325, 326
361, 326, 327
362, 327, 328
363, 328, 329
364, 329, 330
365, 330, 331
366, 331, 332
367, 332, 333
368, 333, 334
369, 334, 335
370, 335, 19
*ELEMENT, type=T3D2, ELSET=Line36
371, 18, 336
372, 336, 337
373, 337, 338
374, 338, 339
375, 339, 340
376, 340, 341
377, 341, 342
378, 342, 343
379, 343, 344
380, 344, 20
*ELEMENT, type=T3D2, ELSET=Line37
381, 17, 345
382, 345, 346
383, 346, 347
384, 347, 21
*ELEMENT, type=T3D2, ELSET=Line38
385, 18, 348
386, 348, 349
387, 349, 350
388, 350, 22
*ELEMENT, type=T3D2, ELSET=Line39
389, 22, 351
390, 351, 352
391, 352, 353
392, 353, 354
393, 354, 355
394, 355, 356
395, 356, 357
396, 357, 358
397, 358, 359
398, 359, 360
399, 360, 361
400, 361, 21
*ELEMENT, type=T3D2, ELSET=Line40
401, 19, 362
402, 362, 363
403, 363, 364
404, 364, 23
*ELEMENT, type=T3D2, ELSET=Line41
405, 21, 365
406, 365, 366
407, 366, 367
408, 367, 368
409, 368, 369
410, 369, 370
411, 370, 371
412, 371, 372
413, 372, 373
414, 373, 23
*ELEMENT, type=T3D2, ELSET=Line42
415, 20, 374
416, 374, 375
417, 375, 376
418, 376, 24
*ELEMENT, type=T3D2, ELSET=Line43
419, 24, 377
420, 377, 378
421, 378, 379
422, 379, 380
423, 380, 381
424, 381, 382
425, 382, 383
426, 383, 384
427, 384, 385
428, 385, 386
429, 386, 387
430, 387, 23
*ELEMENT, type=T3D2, ELSET=Line44
431, 22, 388
432, 388, 389
433, 389, 390
434, 390, 391
435, 391, 392
436, 392, 393
437, 393, 394
438, 394, 395
439, 395, 396
440, 396, 24
*ELEMENT, type=T3D2, ELSET=Line45
441, 19, 397
442, 397, 398
443, 398, 399
444, 399, 400
445, 400, 401
446, 401, 402
447, 402, 25
*ELEMENT, type=T3D2, ELSET=Line46
448, 23, 403
449, 403, 404
450, 404, 405
451, 405, 406
452, 406, 407
453, 407, 408
454, 408, 26
*ELEMENT, type=T3D2, ELSET=Line47
455, 25, 409
456, 409, 410
457, 410, 411
458, 411, 26
*ELEMENT, type=T3D2, ELSET=Line48
459, 17, 412
460, 412, 413
461, 413, 414
462, 414, 415
463, 415, 416
464, 416, 417
465, 417, 27
*ELEMENT, type=T3D2, ELSET=Line49
466, 21, 418
467, 418, 419
468, 419, 420
469, 420, 421
470, 421, 422
471, 422, 423
472, 423, 28
*ELEMENT, type=T3D2, ELSET=Line50
473, 27, 424
474, 424, 425
475, 425, 426
476, 426, 28
*ELEMENT, type=T3D2, ELSET=Line51
477, 27, 427
478, 427, 428
479, 428, 429
480, 429, 430
481, 430, 431
482, 431, 432
483, 432, 433
484, 433, 434
485, 434, 435
486, 435, 25
*ELEMENT, type=T3D2, ELSET=Line52
487, 28, 436
488, 436, 437
489, 437, 438
490, 438, 439
491, 439, 440
492, 440, 441
493, 441, 442
494, 442, 443
495, 443, 444
496, 444, 26
*ELEMENT, type=T3D2, ELSET=Line53
497, 25, 445
498, 445, 446
499, 446, 447
500, 447, 448
501, 448, 449
502, 449, 450
503, 450, 451
504, 451, 452
505, 452, 453
506, 453, 454
507, 454, 455
508, 455, 29
*ELEMENT, type=T3D2, ELSET=Line54
509, 26, 456
510, 456, 457
511, 457, 458
512, 458, 459
513, 459, 460
514, 460, 461
515, 461, 462
516, 462, 463
517, 463, 464
518, 464, 465
519, 465, 466
520, 466, 30
*ELEMENT, type=T3D2, ELSET=Line55
521, 29, 467
522, 467, 468
523, 468, 469
524, 469, 30
*ELEMENT, type=T3D2, ELSET=Line56
525, 27, 470
526, 470, 471
527, 471, 472
528, 472, 473
529, 473, 474
530, 474, 475
531, 475, 476
532, 476, 477
533, 477, 478
534, 478, 479
535, 479, 480
536, 480, 31
*ELEMENT, type=T3D2, ELSET=Line57
537, 28, 481
538, 481, 482
539, 482, 483
540, 483, 484
541, 484, 485
542, 485, 486
543, 486, 487
544, 487, 488
545, 488, 489
546, 489, 490
547, 490, 491
548, 491, 32
*ELEMENT, type=T3D2, ELSET=Line58
549, 31, 492
550, 492, 493
551, 493, 494
552, 494, 32
*ELEMENT, type=T3D2, ELSET=Line59
553, 31, 495
554, 495, 496
555, 496, 497
556, 497, 498
557, 498, 499
558, 499, 500
559, 500, 501
560, 501, 502
561, 502, 503
562, 503, 29
*ELEMENT, type=T3D2, ELSET=Line60
563, 32, 504
564, 504, 505
565, 505, 506
566, 506, 507
567, 507, 508
568, 508, 509
569, 509, 510
570, 510, 511
571, 511, 512
572, 512, 30
*ELEMENT, type=T3D2, ELSET=Line61
573, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
574, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
575, 33, 513
576, 513, 514
577, 514, 515
578, 515, 516
579, 516, 517
580, 517, 518
581, 518, 519
582, 519, 520
583, 520, 521
584, 521, 522
585, 522, 523
586, 523, 34
*ELEMENT, type=T3D2, ELSET=Line64
587, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
588, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
589, 35, 524
590, 524, 525
591, 525, 526
592, 526, 527
593, 527, 528
594, 528, 529
595, 529, 530
596, 530, 531
597, 531, 532
598, 532, 533
599, 533, 534
600, 534, 36
*ELEMENT, type=T3D2, ELSET=Line67
601, 35, 535
602, 535, 536
603, 536, 537
604, 537, 538
605, 538, 539
606, 539, 540
607, 540, 541
608, 541, 542
609, 542, 543
610, 543, 33
*ELEMENT, type=T3D2, ELSET=Line68
611, 36, 544
612, 544, 545
613, 545, 546
614, 546, 547
615, 547, 548
616, 548, 549
617, 549, 550
618, 550, 551
619, 551, 552
620, 552, 34
*ELEMENT, type=T3D2, ELSET=Line69
621, 33, 553
622, 553, 554
623, 554, 555
624, 555, 556
625, 556, 557
626, 557, 558
627, 558, 559
628, 559, 560
629, 560, 561
630, 561, 37
*ELEMENT, type=T3D2, ELSET=Line70
631, 34, 562
632, 562, 563
633, 563, 564
634, 564, 565
635, 565, 566
636, 566, 567
637, 567, 568
638, 568, 569
639, 569, 570
640, 570, 38
*ELEMENT, type=T3D2, ELSET=Line71
641, 37, 571
642, 571, 572
643, 572, 573
644, 573, 574
645, 574, 575
646, 575, 576
647, 576, 577
648, 577, 578
649, 578, 579
650, 579, 580
651, 580, 581
652, 581, 38
*ELEMENT, type=T3D2, ELSET=Line72
653, 35, 582
654, 582, 583
655, 583, 584
656, 584, 585
657, 585, 586
658, 586, 587
659, 587, 588
660, 588, 589
661, 589, 590
662, 590, 39
*ELEMENT, type=T3D2, ELSET=Line73
663, 36, 591
664, 591, 592
665, 592, 593
666, 593, 594
667, 594, 595
668, 595, 596
669, 596, 597
670, 597, 598
671, 598, 599
672, 599, 40
*ELEMENT, type=T3D2, ELSET=Line74
673, 39, 600
674, 600, 601
675, 601, 602
676, 602, 603
677, 603, 604
678, 604, 605
679, 605, 606
680, 606, 607
681, 607, 608
682, 608, 609
683, 609, 610
684, 610, 40
*ELEMENT, type=T3D2, ELSET=Line75
685, 39, 611
686, 611, 612
687, 612, 613
688, 613, 614
689, 614, 615
690, 615, 616
691, 616, 617
692, 617, 618
693, 618, 619
694, 619, 37
*ELEMENT, type=T3D2, ELSET=Line76
695, 40, 620
696, 620, 621
697, 621, 622
698, 622, 623
699, 623, 624
700, 624, 625
701, 625, 626
702, 626, 627
703, 627, 628
704, 628, 38
*ELEMENT, type=T3D2, ELSET=Line77
705, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
706, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
707, 41, 629
708, 629, 630
709, 630, 631
710, 631, 632
711, 632, 633
712, 633, 634
713, 634, 635
714, 635, 636
715, 636, 637
716, 637, 638
717, 638, 639
718, 639, 42
*ELEMENT, type=T3D2, ELSET=Line80
719, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
720, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
721, 43, 640
722, 640, 641
723, 641, 642
724, 642, 643
725, 643, 644
726, 644, 645
727, 645, 646
728, 646, 647
729, 647, 648
730, 648, 649
731, 649, 650
732, 650, 44
*ELEMENT, type=T3D2, ELSET=Line83
733, 43, 651
734, 651, 652
735, 652, 653
736, 653, 654
737, 654, 655
738, 655, 656
739, 656, 657
740, 657, 658
741, 658, 659
742, 659, 41
*ELEMENT, type=T3D2, ELSET=Line84
743, 44, 660
744, 660, 661
745, 661, 662
746, 662, 663
747, 663, 664
748, 664, 665
749, 665, 666
750, 666, 667
751, 667, 668
752, 668, 42
*ELEMENT, type=T3D2, ELSET=Line85
753, 41, 669
754, 669, 670
755, 670, 671
756, 671, 45
*ELEMENT, type=T3D2, ELSET=Line86
757, 42, 672
758, 672, 673
759, 673, 674
760, 674, 46
*ELEMENT, type=T3D2, ELSET=Line87
761, 45, 675
762, 675, 676
763, 676, 677
764, 677, 678
765, 678, 679
766, 679, 680
767, 680, 681
768, 681, 682
769, 682, 683
770, 683, 684
771, 684, 685
772, 685, 46
*ELEMENT, type=T3D2, ELSET=Line88
773, 43, 686
774, 686, 687
775, 687, 688
776, 688, 47
*ELEMENT, type=T3D2, ELSET=Line89
777, 44, 689
778, 689, 690
779, 690, 691
780, 691, 48
*ELEMENT, type=T3D2, ELSET=Line90
781, 47, 692
782, 692, 693
783, 693, 694
784, 694, 695
785, 695, 696
786, 696, 697
787, 697, 698
788, 698, 699
789, 699, 700
790, 700, 701
791, 701, 702
792, 702, 48
*ELEMENT, type=T3D2, ELSET=Line91
793, 47, 703
794, 703, 704
795, 704, 705
796, 705, 706
797, 706, 707
798, 707, 708
799, 708, 709
800, 709, 710
801, 710, 711
802, 711, 45
*ELEMENT, type=T3D2, ELSET=Line92
803, 48, 712
804, 712, 713
805, 713, 714
806, 714, 715
807, 715, 716
808, 716, 717
809, 717, 718
810, 718, 719
811, 719, 720
812, 720, 46
*ELEMENT, type=T3D2, ELSET=Line93
813, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
814, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
815, 49, 721
816, 721, 722
817, 722, 723
818, 723, 50
*ELEMENT, type=T3D2, ELSET=Line96
819, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
820, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
821, 51, 724
822, 724, 725
823, 725, 726
824, 726, 52
*ELEMENT, type=T3D2, ELSET=Line99
825, 51, 727
826, 727, 728
827, 728, 729
828, 729, 730
829, 730, 731
830, 731, 732
831, 732, 733
832, 733, 734
833, 734, 735
834, 735, 49
*ELEMENT, type=T3D2, ELSET=Line100
835, 52, 736
836, 736, 737
837, 737, 738
838, 738, 739
839, 739, 740
840, 740, 741
841, 741, 742
842, 742, 743
843, 743, 744
844, 744, 50
*ELEMENT, type=T3D2, ELSET=Line101
845, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
846, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
847, 54, 745
848, 745, 746
849, 746, 747
850, 747, 748
851, 748, 749
852, 749, 750
853, 750, 751
854, 751, 752
855, 752, 753
856, 753, 53
*ELEMENT, type=T3D2, ELSET=Line104
857, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
858, 53, 754
859, 754, 755
860, 755, 756
861, 756, 55
*ELEMENT, type=T3D2, ELSET=Line106
862, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
863, 56, 757
864, 757, 758
865, 758, 759
866, 759, 760
867, 760, 761
868, 761, 762
869, 762, 763
870, 763, 764
871, 764, 765
872, 765, 55
*ELEMENT, type=T3D2, ELSET=Line108
873, 54, 766
874, 766, 767
875, 767, 768
876, 768, 56
*ELEMENT, type=T3D2, ELSET=Line125
877, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
878, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
879, 57, 769
880, 769, 770
881, 770, 771
882, 771, 772
883, 772, 773
884, 773, 774
885, 774, 775
886, 775, 776
887, 776, 777
888, 777, 58
*ELEMENT, type=T3D2, ELSET=Line128
889, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
890, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
891, 59, 778
892, 778, 779
893, 779, 780
894, 780, 781
895, 781, 782
896, 782, 783
897, 783, 784
898, 784, 785
899, 785, 786
900, 786, 60
*ELEMENT, type=T3D2, ELSET=Line131
901, 59, 787
902, 787, 788
903, 788, 789
904, 789, 790
905, 790, 791
906, 791, 792
907, 792, 793
908, 793, 794
909, 794, 795
910, 795, 57
*ELEMENT, type=T3D2, ELSET=Line132
911, 60, 796
912, 796, 797
913, 797, 798
914, 798, 799
915, 799, 800
916, 800, 801
917, 801, 802
918, 802, 803
919, 803, 804
920, 804, 58
*ELEMENT, type=T3D2, ELSET=Line133
921, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
922, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
923, 61, 805
924, 805, 806
925, 806, 807
926, 807, 808
927, 808, 809
928, 809, 810
929, 810, 811
930, 811, 812
931, 812, 813
932, 813, 62
*ELEMENT, type=T3D2, ELSET=Line136
933, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
934, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
935, 63, 814
936, 814, 815
937, 815, 816
938, 816, 817
939, 817, 818
940, 818, 819
941, 819, 820
942, 820, 821
943, 821, 822
944, 822, 64
*ELEMENT, type=T3D2, ELSET=Line139
945, 63, 823
946, 823, 824
947, 824, 825
948, 825, 826
949, 826, 827
950, 827, 828
951, 828, 829
952, 829, 830
953, 830, 831
954, 831, 61
*ELEMENT, type=T3D2, ELSET=Line140
955, 64, 832
956, 832, 833
957, 833, 834
958, 834, 835
959, 835, 836
960, 836, 837
961, 837, 838
962, 838, 839
963, 839, 840
964, 840, 62
*ELEMENT, type=T3D2, ELSET=Line141
965, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
966, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
967, 65, 841
968, 841, 842
969, 842, 843
970, 843, 844
971, 844, 845
972, 845, 846
973, 846, 847
974, 847, 848
975, 848, 849
976, 849, 66
*ELEMENT, type=T3D2, ELSET=Line144
977, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
978, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
979, 67, 850
980, 850, 851
981, 851, 852
982, 852, 853
983, 853, 854
984, 854, 855
985, 855, 856
986, 856, 857
987, 857, 858
988, 858, 68
*ELEMENT, type=T3D2, ELSET=Line147
989, 67, 859
990, 859, 860
991, 860, 861
992, 861, 862
993, 862, 863
994, 863, 864
995, 864, 865
996, 865, 866
997, 866, 867
998, 867, 868
999, 868, 869
1000, 869, 65
*ELEMENT, type=T3D2, ELSET=Line148
1001, 68, 870
1002, 870, 871
1003, 871, 872
1004, 872, 873
1005, 873, 874
1006, 874, 875
1007, 875, 876
1008, 876, 877
1009, 877, 878
1010, 878, 879
1011, 879, 880
1012, 880, 66
*ELEMENT, type=T3D2, ELSET=Line149
1013, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
1014, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
1015, 69, 881
1016, 881, 882
1017, 882, 883
1018, 883, 884
1019, 884, 885
1020, 885, 886
1021, 886, 887
1022, 887, 888
1023, 888, 889
1024, 889, 70
*ELEMENT, type=T3D2, ELSET=Line152
1025, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
1026, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
1027, 71, 890
1028, 890, 891
1029, 891, 892
1030, 892, 893
1031, 893, 894
1032, 894, 895
1033, 895, 896
1034, 896, 897
1035, 897, 898
1036, 898, 72
*ELEMENT, type=T3D2, ELSET=Line155
1037, 69, 899
1038, 899, 900
1039, 900, 901
1040, 901, 902
1041, 902, 903
1042, 903, 904
1043, 904, 905
1044, 905, 906
1045, 906, 907
1046, 907, 908
1047, 908, 909
1048, 909, 71
*ELEMENT, type=T3D2, ELSET=Line156
1049, 70, 910
1050, 910, 911
1051, 911, 912
1052, 912, 913
1053, 913, 914
1054, 914, 915
1055, 915, 916
1056, 916, 917
1057, 917, 918
1058, 918, 919
1059, 919, 920
1060, 920, 72
*ELEMENT, type=T3D2, ELSET=Line157
1061, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
1062, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
1063, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
1064, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
1065, 73, 921
1066, 921, 922
1067, 922, 923
1068, 923, 924
1069, 924, 925
1070, 925, 926
1071, 926, 927
1072, 927, 928
1073, 928, 929
1074, 929, 74
*ELEMENT, type=T3D2, ELSET=Line162
1075, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
1076, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
1077, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
1078, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
1079, 75, 930
1080, 930, 931
1081, 931, 932
1082, 932, 933
1083, 933, 934
1084, 934, 935
1085, 935, 936
1086, 936, 937
1087, 937, 938
1088, 938, 76
*ELEMENT, type=T3D2, ELSET=Line167
1089, 21, 939
1090, 939, 940
1091, 940, 941
1092, 941, 942
1093, 942, 77
*ELEMENT, type=T3D2, ELSET=Line168
1094, 22, 943
1095, 943, 944
1096, 944, 945
1097, 945, 946
1098, 946, 78
*ELEMENT, type=T3D2, ELSET=Line169
1099, 78, 947
1100, 947, 948
1101, 948, 949
1102, 949, 950
1103, 950, 951
1104, 951, 952
1105, 952, 953
1106, 953, 954
1107, 954, 955
1108, 955, 956
1109, 956, 957
1110, 957, 77
*ELEMENT, type=T3D2, ELSET=Line170
1111, 23, 958
1112, 958, 959
1113, 959, 960
1114, 960, 961
1115, 961, 79
*ELEMENT, type=T3D2, ELSET=Line171
1116, 77, 962
1117, 962, 963
1118, 963, 964
1119, 964, 965
1120, 965, 966
1121, 966, 967
1122, 967, 968
1123, 968, 969
1124, 969, 970
1125, 970, 79
*ELEMENT, type=T3D2, ELSET=Line172
1126, 24, 971
1127, 971, 972
1128, 972, 973
1129, 973, 974
1130, 974, 80
*ELEMENT, type=T3D2, ELSET=Line173
1131, 80, 975
1132, 975, 976
1133, 976, 977
1134, 977, 978
1135, 978, 979
1136, 979, 980
1137, 980, 981
1138, 981, 982
1139, 982, 983
1140, 983, 984
1141, 984, 985
1142, 985, 79
*ELEMENT, type=T3D2, ELSET=Line174
1143, 78, 986
1144, 986, 987
1145, 987, 988
1146, 988, 989
1147, 989, 990
1148, 990, 991
1149, 991, 992
1150, 992, 993
1151, 993, 994
1152, 994, 80
*ELEMENT, type=T3D2, ELSET=Line175
1153, 26, 995
1154, 995, 996
1155, 996, 997
1156, 997, 998
1157, 998, 81
*ELEMENT, type=T3D2, ELSET=Line176
1158, 79, 999
1159, 999, 1000
1160, 1000, 1001
1161, 1001, 1002
1162, 1002, 1003
1163, 1003, 1004
1164, 1004, 81
*ELEMENT, type=T3D2, ELSET=Line177
1165, 28, 1005
1166, 1005, 1006
1167, 1006, 1007
1168, 1007, 1008
1169, 1008, 82
*ELEMENT, type=T3D2, ELSET=Line178
1170, 77, 1009
1171, 1009, 1010
1172, 1010, 1011
1173, 1011, 1012
1174, 1012, 1013
1175, 1013, 1014
1176, 1014, 82
*ELEMENT, type=T3D2, ELSET=Line179
1177, 82, 1015
1178, 1015, 1016
1179, 1016, 1017
1180, 1017, 1018
1181, 1018, 1019
1182, 1019, 1020
1183, 1020, 1021
1184, 1021, 1022
1185, 1022, 1023
1186, 1023, 81
*ELEMENT, type=T3D2, ELSET=Line180
1187, 30, 1024
1188, 1024, 1025
1189, 1025, 1026
1190, 1026, 1027
1191, 1027, 83
*ELEMENT, type=T3D2, ELSET=Line181
1192, 81, 1028
1193, 1028, 1029
1194, 1029, 1030
1195, 1030, 1031
1196, 1031, 1032
1197, 1032, 1033
1198, 1033, 1034
1199, 1034, 1035
1200, 1035, 1036
1201, 1036, 1037
1202, 1037, 1038
1203, 1038, 83
*ELEMENT, type=T3D2, ELSET=Line182
1204, 32, 1039
1205, 1039, 1040
1206, 1040, 1041
1207, 1041, 1042
1208, 1042, 84
*ELEMENT, type=T3D2, ELSET=Line183
1209, 82, 1043
1210, 1043, 1044
1211, 1044, 1045
1212, 1045, 1046
1213, 1046, 1047
1214, 1047, 1048
1215, 1048, 1049
1216, 1049, 1050
1217, 1050, 1051
1218, 1051, 1052
1219, 1052, 1053
1220, 1053, 84
*ELEMENT, type=T3D2, ELSET=Line184
1221, 84, 1054
1222, 1054, 1055
1223, 1055, 1056
1224, 1056, 1057
1225, 1057, 1058
1226, 1058, 1059
1227, 1059, 1060
1228, 1060, 1061
1229, 1061, 1062
1230, 1062, 83
*ELEMENT, type=T3D2, ELSET=Line185
1231, 6, 1063
1232, 1063, 1064
1233, 1064, 1065
1234, 1065, 1066
1235, 1066, 85
*ELEMENT, type=T3D2, ELSET=Line186
1236, 2, 1067
1237, 1067, 1068
1238, 1068, 1069
1239, 1069, 1070
1240, 1070, 86
*ELEMENT, type=T3D2, ELSET=Line187
1241, 86, 1071
1242, 1071, 1072
1243, 1072, 1073
1244, 1073, 1074
1245, 1074, 1075
1246, 1075, 1076
1247, 1076, 1077
1248, 1077, 1078
1249, 1078, 1079
1250, 1079, 1080
1251, 1080, 1081
1252, 1081, 85
*ELEMENT, type=T3D2, ELSET=Line188
1253, 5, 1082
1254, 1082, 1083
1255, 1083, 1084
1256, 1084, 1085
1257, 1085, 87
*ELEMENT, type=T3D2, ELSET=Line189
1258, 85, 1086
1259, 1086, 1087
1260, 1087, 1088
1261, 1088, 1089
1262, 1089, 1090
1263, 1090, 1091
1264, 1091, 1092
1265, 1092, 1093
1266, 1093, 1094
1267, 1094, 87
*ELEMENT, type=T3D2, ELSET=Line190
1268, 1, 1095
1269, 1095, 1096
1270, 1096, 1097
1271, 1097, 1098
1272, 1098, 88
*ELEMENT, type=T3D2, ELSET=Line191
1273, 88, 1099
1274, 1099, 1100
1275, 1100, 1101
1276, 1101, 1102
1277, 1102, 1103
1278, 1103, 1104
1279, 1104, 1105
1280, 1105, 1106
1281, 1106, 1107
1282, 1107, 1108
1283, 1108, 1109
1284, 1109, 87
*ELEMENT, type=T3D2, ELSET=Line192
1285, 86, 1110
1286, 1110, 1111
1287, 1111, 1112
1288, 1112, 1113
1289, 1113, 1114
1290, 1114, 1115
1291, 1115, 1116
1292, 1116, 1117
1293, 1117, 1118
1294, 1118, 88
*ELEMENT, type=T3D2, ELSET=Line193
1295, 53, 1119
1296, 1119, 1120
1297, 1120, 1121
1298, 1121, 1122
1299, 1122, 89
*ELEMENT, type=T3D2, ELSET=Line194
1300, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
1301, 54, 1123
1302, 1123, 1124
1303, 1124, 1125
1304, 1125, 1126
1305, 1126, 90
*ELEMENT, type=T3D2, ELSET=Line196
1306, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
1307, 90, 1127
1308, 1127, 1128
1309, 1128, 1129
1310, 1129, 1130
1311, 1130, 1131
1312, 1131, 1132
1313, 1132, 1133
1314, 1133, 1134
1315, 1134, 1135
1316, 1135, 89
*ELEMENT, type=T3D2, ELSET=Line198
1317, 45, 1136
1318, 1136, 1137
1319, 1137, 1138
1320, 1138, 1139
1321, 1139, 91
*ELEMENT, type=T3D2, ELSET=Line199
1322, 46, 1140
1323, 1140, 1141
1324, 1141, 1142
1325, 1142, 1143
1326, 1143, 92
*ELEMENT, type=T3D2, ELSET=Line200
1327, 91, 1144
1328, 1144, 1145
1329, 1145, 1146
1330, 1146, 1147
1331, 1147, 1148
1332, 1148, 1149
1333, 1149, 1150
1334, 1150, 1151
1335, 1151, 1152
1336, 1152, 1153
1337, 1153, 1154
1338, 1154, 92
*ELEMENT, type=T3D2, ELSET=Line201
1339, 47, 1155
1340, 1155, 1156
1341, 1156, 1157
1342, 1157, 1158
1343, 1158, 93
*ELEMENT, type=T3D2, ELSET=Line202
1344, 48, 1159
1345, 1159, 1160
1346, 1160, 1161
1347, 1161, 1162
1348, 1162, 94
*ELEMENT, type=T3D2, ELSET=Line203
1349, 93, 1163
1350, 1163, 1164
1351, 1164, 1165
1352, 1165, 1166
1353, 1166, 1167
1354, 1167, 1168
1355, 1168, 1169
1356, 1169, 1170
1357, 1170, 1171
1358, 1171, 1172
1359, 1172, 1173
1360, 1173, 94
*ELEMENT, type=T3D2, ELSET=Line204
1361, 93, 1174
1362, 1174, 1175
1363, 1175, 1176
1364, 1176, 1177
1365, 1177, 1178
1366, 1178, 1179
1367, 1179, 1180
1368, 1180, 1181
1369, 1181, 1182
1370, 1182, 91
*ELEMENT, type=T3D2, ELSET=Line205
1371, 94, 1183
1372, 1183, 1184
1373, 1184, 1185
1374, 1185, 1186
1375, 1186, 1187
1376, 1187, 1188
1377, 1188, 1189
1378, 1189, 1190
1379, 1190, 1191
1380, 1191, 92
*ELEMENT, type=T3D2, ELSET=Line206
1381, 50, 1192
1382, 1192, 1193
1383, 1193, 1194
1384, 1194, 1195
1385, 1195, 95
*ELEMENT, type=T3D2, ELSET=Line207
1386, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
1387, 52, 1196
1388, 1196, 1197
1389, 1197, 1198
1390, 1198, 1199
1391, 1199, 96
*ELEMENT, type=T3D2, ELSET=Line209
1392, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
1393, 96, 1200
1394, 1200, 1201
1395, 1201, 1202
1396, 1202, 1203
1397, 1203, 1204
1398, 1204, 1205
1399, 1205, 1206
1400, 1206, 1207
1401, 1207, 1208
1402, 1208, 95
*ELEMENT, type=CPS4, ELSET=Surface1
1403, 2, 97, 1209, 118
1404, 118, 1209, 1210, 119
1405, 119, 1210, 1211, 120
1406, 120, 1211, 109, 4
1407, 97, 98, 1212, 1209
1408, 1209, 1212, 1213, 1210
1409, 1210, 1213, 1214, 1211
1410, 1211, 1214, 110, 109
1411, 98, 99, 1215, 1212
1412, 1212, 1215, 1216, 1213
1413, 1213, 1216, 1217, 1214
1414, 1214, 1217, 111, 110
1415, 99, 100, 1218, 1215
1416, 1215, 1218, 1219, 1216
1417, 1216, 1219, 1220, 1217
1418, 1217, 1220, 112, 111
1419, 100, 101, 1221, 1218
1420, 1218, 1221, 1222, 1219
1421, 1219, 1222, 1223, 1220
1422, 1220, 1223, 113, 112
1423, 101, 102, 1224, 1221
1424, 1221, 1224, 1225, 1222
1425, 1222, 1225, 1226, 1223
1426, 1223, 1226, 114, 113
1427, 102, 103, 1227, 1224
1428, 1224, 1227, 1228, 1225
1429, 1225, 1228, 1229, 1226
1430, 1226, 1229, 115, 114
1431, 103, 104, 1230, 1227
1432, 1227, 1230, 1231, 1228
1433, 1228, 1231, 1232, 1229
1434, 1229, 1232, 116, 115
1435, 104, 105, 1233, 1230
1436, 1230, 1233, 1234, 1231
1437, 1231, 1234, 1235, 1232
1438, 1232, 1235, 117, 116
1439, 105, 1, 106, 1233
1440, 1233, 106, 107, 1234
1441, 1234, 107, 108, 1235
1442, 1235, 108, 3, 117
*ELEMENT, type=CPS4, ELSET=Surface2
1443, 6, 142, 1236, 121
1444, 142, 143, 1237, 1236
1445, 143, 144, 1238, 1237
1446, 144, 8, 133, 1238
1447, 121, 1236, 1239, 122
1448, 1236, 1237, 1240, 1239
1449, 1237, 1238, 1241, 1240
1450, 1238, 133, 134, 1241
1451, 122, 1239, 1242, 123
1452, 1239, 1240, 1243, 1242
1453, 1240, 1241, 1244, 1243
1454, 1241, 134, 135, 1244
1455, 123, 1242, 1245, 124
1456, 1242, 1243, 1246, 1245
1457, 1243, 1244, 1247, 1246
1458, 1244, 135, 136, 1247
1459, 124, 1245, 1248, 125
1460, 1245, 1246, 1249, 1248
1461, 1246, 1247, 1250, 1249
1462, 1247, 136, 137, 1250
1463, 125, 1248, 1251, 126
1464, 1248, 1249, 1252, 1251
1465, 1249, 1250, 1253, 1252
1466, 1250, 137, 138, 1253
1467, 126, 1251, 1254, 127
1468, 1251, 1252, 1255, 1254
1469, 1252, 1253, 1256, 1255
1470, 1253, 138, 139, 1256
1471, 127, 1254, 1257, 128
1472, 1254, 1255, 1258, 1257
1473, 1255, 1256, 1259, 1258
1474, 1256, 139, 140, 1259
1475, 128, 1257, 1260, 129
1476, 1257, 1258, 1261, 1260
1477, 1258, 1259, 1262, 1261
1478, 1259, 140, 141, 1262
1479, 129, 1260, 130, 5
1480, 1260, 1261, 131, 130
1481, 1261, 1262, 132, 131
1482, 1262, 141, 7, 132
*ELEMENT, type=CPS4, ELSET=Surface3
1483, 2, 145, 1263, 97
1484, 97, 1263, 1264, 98
1485, 98, 1264, 1265, 99
1486, 99, 1265, 1266, 100
1487, 100, 1266, 1267, 101
1488, 101, 1267, 1268, 102
1489, 102, 1268, 1269, 103
1490, 103, 1269, 1270, 104
1491, 104, 1270, 1271, 105
1492, 105, 1271, 156, 1
1493, 145, 146, 1272, 1263
1494, 1263, 1272, 1273, 1264
1495, 1264, 1273, 1274, 1265
1496, 1265, 1274, 1275, 1266
1497, 1266, 1275, 1276, 1267
1498, 1267, 1276, 1277, 1268
1499, 1268, 1277, 1278, 1269
1500, 1269, 1278, 1279, 1270
1501, 1270, 1279, 1280, 1271
1502, 1271, 1280, 157, 156
1503, 146, 147, 1281, 1272
1504, 1272, 1281, 1282, 1273
1505, 1273, 1282, 1283, 1274
1506, 1274, 1283, 1284, 1275
1507, 1275, 1284, 1285, 1276
1508, 1276, 1285, 1286, 1277
1509, 1277, 1286, 1287, 1278
1510, 1278, 1287, 1288, 1279
1511, 1279, 1288, 1289, 1280
1512, 1280, 1289, 158, 157
1513, 147, 148, 1290, 1281
1514, 1281, 1290, 1291, 1282
1515, 1282, 1291, 1292, 1283
1516, 1283, 1292, 1293, 1284
1517, 1284, 1293, 1294, 1285
1518, 1285, 1294, 1295, 1286
1519, 1286, 1295, 1296, 1287
1520, 1287, 1296, 1297, 1288
1521, 1288, 1297, 1298, 1289
1522, 1289, 1298, 159, 158
1523, 148, 149, 1299, 1290
1524, 1290, 1299, 1300, 1291
1525, 1291, 1300, 1301, 1292
1526, 1292, 1301, 1302, 1293
1527, 1293, 1302, 1303, 1294
1528, 1294, 1303, 1304, 1295
1529, 1295, 1304, 1305, 1296
1530, 1296, 1305, 1306, 1297
1531, 1297, 1306, 1307, 1298
1532, 1298, 1307, 160, 159
1533, 149, 150, 1308, 1299
1534, 1299, 1308, 1309, 1300
1535, 1300, 1309, 1310, 1301
1536, 1301, 1310, 1311, 1302
1537, 1302, 1311, 1312, 1303
1538, 1303, 1312, 1313, 1304
1539, 1304, 1313, 1314, 1305
1540, 1305, 1314, 1315, 1306
1541, 1306, 1315, 1316, 1307
1542, 1307, 1316, 161, 160
1543, 150, 151, 1317, 1308
1544, 1308, 1317, 1318, 1309
1545, 1309, 1318, 1319, 1310
1546, 1310, 1319, 1320, 1311
1547, 1311, 1320, 1321, 1312
1548, 1312, 1321, 1322, 1313
1549, 1313, 1322, 1323, 1314
1550, 1314, 1323, 1324, 1315
1551, 1315, 1324, 1325, 1316
1552, 1316, 1325, 162, 161
1553, 151, 152, 1326, 1317
1554, 1317, 1326, 1327, 1318
1555, 1318, 1327, 1328, 1319
1556, 1319, 1328, 1329, 1320
1557, 1320, 1329, 1330, 1321
1558, 1321, 1330, 1331, 1322
1559, 1322, 1331, 1332, 1323
1560, 1323, 1332, 1333, 1324
1561, 1324, 1333, 1334, 1325
1562, 1325, 1334, 163, 162
1563, 152, 153, 1335, 1326
1564, 1326, 1335, 1336, 1327
1565, 1327, 1336, 1337, 1328
1566, 1328, 1337, 1338, 1329
1567, 1329, 1338, 1339, 1330
1568, 1330, 1339, 1340, 1331
1569, 1331, 1340, 1341, 1332
1570, 1332, 1341, 1342, 1333
1571, 1333, 1342, 1343, 1334
1572, 1334, 1343, 164, 163
1573, 153, 154, 1344, 1335
1574, 1335, 1344, 1345, 1336
1575, 1336, 1345, 1346, 1337
1576, 1337, 1346, 1347, 1338
1577, 1338, 1347, 1348, 1339
1578, 1339, 1348, 1349, 1340
1579, 1340, 1349, 1350, 1341
1580, 1341, 1350, 1351, 1342
1581, 1342, 1351, 1352, 1343
1582, 1343, 1352, 165, 164
1583, 154, 155, 1353, 1344
1584, 1344, 1353, 1354, 1345
1585, 1345, 1354, 1355, 1346
1586, 1346, 1355, 1356, 1347
1587, 1347, 1356, 1357, 1348
1588, 1348, 1357, 1358, 1349
1589, 1349, 1358, 1359, 1350
1590, 1350, 1359, 1360, 1351
1591, 1351, 1360, 1361, 1352
1592, 1352, 1361, 166, 165
1593, 155, 6, 121, 1353
1594, 1353, 121, 122, 1354
1595, 1354, 122, 123, 1355
1596, 1355, 123, 124, 1356
1597, 1356, 124, 125, 1357
1598, 1357, 125, 126, 1358
1599, 1358, 126, 127, 1359
1600, 1359, 127, 128, 1360
1601, 1360, 128, 129, 1361
1602, 1361, 129, 5, 166
*ELEMENT, type=CPS4, ELSET=Surface4
1603, 4, 109, 1362, 167
1604, 109, 110, 1363, 1362
1605, 110, 111, 1364, 1363
1606, 111, 112, 1365, 1364
1607, 112, 113, 1366, 1365
1608, 113, 114, 1367, 1366
1609, 114, 115, 1368, 1367
1610, 115, 116, 1369, 1368
1611, 116, 117, 1370, 1369
1612, 117, 3, 178, 1370
1613, 167, 1362, 1371, 168
1614, 1362, 1363, 1372, 1371
1615, 1363, 1364, 1373, 1372
1616, 1364, 1365, 1374, 1373
1617, 1365, 1366, 1375, 1374
1618, 1366, 1367, 1376, 1375
1619, 1367, 1368, 1377, 1376
1620, 1368, 1369, 1378, 1377
1621, 1369, 1370, 1379, 1378
1622, 1370, 178, 179, 1379
1623, 168, 1371, 1380, 169
1624, 1371, 1372, 1381, 1380
1625, 1372, 1373, 1382, 1381
1626, 1373, 1374, 1383, 1382
1627, 1374, 1375, 1384, 1383
1628, 1375, 1376, 1385, 1384
1629, 1376, 1377, 1386, 1385
1630, 1377, 1378, 1387, 1386
1631, 1378, 1379, 1388, 1387
1632, 1379, 179, 180, 1388
1633, 169, 1380, 1389, 170
1634, 1380, 1381, 1390, 1389
1635, 1381, 1382, 1391, 1390
1636, 1382, 1383, 1392, 1391
1637, 1383, 1384, 1393, 1392
1638, 1384, 1385, 1394, 1393
1639, 1385, 1386, 1395, 1394
1640, 1386, 1387, 1396, 1395
1641, 1387, 1388, 1397, 1396
1642, 1388, 180, 181, 1397
1643, 170, 1389, 1398, 171
1644, 1389, 1390, 1399, 1398
1645, 1390, 1391, 1400, 1399
1646, 1391, 1392, 1401, 1400
1647, 1392, 1393, 1402, 1401
1648, 1393, 1394, 1403, 1402
1649, 1394, 1395, 1404, 1403
1650, 1395, 1396, 1405, 1404
1651, 1396, 1397, 1406, 1405
1652, 1397, 181, 182, 1406
1653, 171, 1398, 1407, 172
1654, 1398, 1399, 1408, 1407
1655, 1399, 1400, 1409, 1408
1656, 1400, 1401, 1410, 1409
1657, 1401, 1402, 1411, 1410
1658, 1402, 1403, 1412, 1411
1659, 1403, 1404, 1413, 1412
1660, 1404, 1405, 1414, 1413
1661, 1405, 1406, 1415, 1414
1662, 1406, 182, 183, 1415
1663, 172, 1407, 1416, 173
1664, 1407, 1408, 1417, 1416
1665, 1408, 1409, 1418, 1417
1666, 1409, 1410, 1419, 1418
1667, 1410, 1411, 1420, 1419
1668, 1411, 1412, 1421, 1420
1669, 1412, 1413, 1422, 1421
1670, 1413, 1414, 1423, 1422
1671, 1414, 1415, 1424, 1423
1672, 1415, 183, 184, 1424
1673, 173, 1416, 1425, 174
1674, 1416, 1417, 1426, 1425
1675, 1417, 1418, 1427, 1426
1676, 1418, 1419, 1428, 1427
1677, 1419, 1420, 1429, 1428
1678, 1420, 1421, 1430, 1429
1679, 1421, 1422, 1431, 1430
1680, 1422, 1423, 1432, 1431
1681, 1423, 1424, 1433, 1432
1682, 1424, 184, 185, 1433
1683, 174, 1425, 1434, 175
1684, 1425, 1426, 1435, 1434
1685, 1426, 1427, 1436, 1435
1686, 1427, 1428, 1437, 1436
1687, 1428, 1429, 1438, 1437
1688, 1429, 1430, 1439, 1438
1689, 1430, 1431, 1440, 1439
1690, 1431, 1432, 1441, 1440
1691, 1432, 1433, 1442, 1441
1692, 1433, 185, 186, 1442
1693, 175, 1434, 1443, 176
1694, 1434, 1435, 1444, 1443
1695, 1435, 1436, 1445, 1444
1696, 1436, 1437, 1446, 1445
1697, 1437, 1438, 1447, 1446
1698, 1438, 1439, 1448, 1447
1699, 1439, 1440, 1449, 1448
1700, 1440, 1441, 1450, 1449
1701, 1441, 1442, 1451, 1450
1702, 1442, 186, 187, 1451
1703, 176, 1443, 1452, 177
1704, 1443, 1444, 1453, 1452
1705, 1444, 1445, 1454, 1453
1706, 1445, 1446, 1455, 1454
1707, 1446, 1447, 1456, 1455
1708, 1447, 1448, 1457, 1456
1709, 1448, 1449, 1458, 1457
1710, 1449, 1450, 1459, 1458
1711, 1450, 1451, 1460, 1459
1712, 1451, 187, 188, 1460
1713, 177, 1452, 133, 8
1714, 1452, 1453, 134, 133
1715, 1453, 1454, 135, 134
1716, 1454, 1455, 136, 135
1717, 1455, 1456, 137, 136
1718, 1456, 1457, 138, 137
1719, 1457, 1458, 139, 138
1720, 1458, 1459, 140, 139
1721, 1459, 1460, 141, 140
1722, 1460, 188, 7, 141
*ELEMENT, type=CPS4, ELSET=Surface5
1723, 2, 118, 1461, 145
1724, 145, 1461, 1462, 146
1725, 146, 1462, 1463, 147
1726, 147, 1463, 1464, 148
1727, 148, 1464, 1465, 149
1728, 149, 1465, 1466, 150
1729, 150, 1466, 1467, 151
1730, 151, 1467, 1468, 152
1731, 152, 1468, 1469, 153
1732, 153, 1469, 1470, 154
1733, 154, 1470, 1471, 155
1734, 155, 1471, 142, 6
1735, 118, 119, 1472, 1461
1736, 1461, 1472, 1473, 1462
1737, 1462, 1473, 1474, 1463
1738, 1463, 1474, 1475, 1464
1739, 1464, 1475, 1476, 1465
1740, 1465, 1476, 1477, 1466
1741, 1466, 1477, 1478, 1467
1742, 1467, 1478, 1479, 1468
1743, 1468, 1479, 1480, 1469
1744, 1469, 1480, 1481, 1470
1745, 1470, 1481, 1482, 1471
1746, 1471, 1482, 143, 142
1747, 119, 120, 1483, 1472
1748, 1472, 1483, 1484, 1473
1749, 1473, 1484, 1485, 1474
1750, 1474, 1485, 1486, 1475
1751, 1475, 1486, 1487, 1476
1752, 1476, 1487, 1488, 1477
1753, 1477, 1488, 1489, 1478
1754, 1478, 1489, 1490, 1479
1755, 1479, 1490, 1491, 1480
1756, 1480, 1491, 1492, 1481
1757, 1481, 1492, 1493, 1482
1758, 1482, 1493, 144, 143
1759, 120, 4, 167, 1483
1760, 1483, 167, 168, 1484
1761, 1484, 168, 169, 1485
1762, 1485, 169, 170, 1486
1763, 1486, 170, 171, 1487
1764, 1487, 171, 172, 1488
1765, 1488, 172, 173, 1489
1766, 1489, 173, 174, 1490
1767, 1490, 174, 175, 1491
1768, 1491, 175, 176, 1492
1769, 1492, 176, 177, 1493
1770, 1493, 177, 8, 144
*ELEMENT, type=CPS4, ELSET=Surface6
1771, 1, 156, 1494, 106
1772, 156, 157, 1495, 1494
1773, 157, 158, 1496, 1495
1774, 158, 159, 1497, 1496
1775, 159, 160, 1498, 1497
1776, 160, 161, 1499, 1498
1777, 161, 162, 1500, 1499
1778, 162, 163, 1501, 1500
1779, 163, 164, 1502, 1501
1780, 164, 165, 1503, 1502
1781, 165, 166, 1504, 1503
1782, 166, 5, 130, 1504
1783, 106, 1494, 1505, 107
1784, 1494, 1495, 1506, 1505
1785, 1495, 1496, 1507, 1506
1786, 1496, 1497, 1508, 1507
1787, 1497, 1498, 1509, 1508
1788, 1498, 1499, 1510, 1509
1789, 1499, 1500, 1511, 1510
1790, 1500, 1501, 1512, 1511
1791, 1501, 1502, 1513, 1512
1792, 1502, 1503, 1514, 1513
1793, 1503, 1504, 1515, 1514
1794, 1504, 130, 131, 1515
1795, 107, 1505, 1516, 108
1796, 1505, 1506, 1517, 1516
1797, 1506, 1507, 1518, 1517
1798, 1507, 1508, 1519, 1518
1799, 1508, 1509, 1520, 1519
1800, 1509, 1510, 1521, 1520
1801, 1510, 1511, 1522, 1521
1802, 1511, 1512, 1523, 1522
1803, 1512, 1513, 1524, 1523
1804, 1513, 1514, 1525, 1524
1805, 1514, 1515, 1526, 1525
1806, 1515, 131, 132, 1526
1807, 108, 1516, 178, 3
1808, 1516, 1517, 179, 178
1809, 1517, 1518, 180, 179
1810, 1518, 1519, 181, 180
1811, 1519, 1520, 182, 181
1812, 1520, 1521, 183, 182
1813, 1521, 1522, 184, 183
1814, 1522, 1523, 185, 184
1815, 1523, 1524, 186, 185
1816, 1524, 1525, 187, 186
1817, 1525, 1526, 188, 187
1818, 1526, 132, 7, 188
*ELEMENT, type=CPS4, ELSET=Surface7
1819, 4, 10, 189, 167
1820, 167, 189, 190, 168
1821, 168, 190, 191, 169
1822, 169, 191, 192, 170
1823, 170, 192, 193, 171
1824, 171, 193, 194, 172
1825, 172, 194, 195, 173
1826, 173, 195, 196, 174
1827, 174, 196, 197, 175
1828, 175, 197, 198, 176
1829, 176, 198, 199, 177
1830, 177, 199, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
1831, 8, 9, 200, 133
1832, 133, 200, 201, 134
1833, 134, 201, 202, 135
1834, 135, 202, 203, 136
1835, 136, 203, 204, 137
1836, 137, 204, 205, 138
1837, 138, 205, 206, 139
1838, 139, 206, 207, 140
1839, 140, 207, 208, 141
1840, 141, 208, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
1841, 3, 178, 209, 12
1842, 178, 179, 210, 209
1843, 179, 180, 211, 210
1844, 180, 181, 212, 211
1845, 181, 182, 213, 212
1846, 182, 183, 214, 213
1847, 183, 184, 215, 214
1848, 184, 185, 216, 215
1849, 185, 186, 217, 216
1850, 186, 187, 218, 217
1851, 187, 188, 219, 218
1852, 188, 7, 11, 219
*ELEMENT, type=CPS4, ELSET=Surface10
1853, 4, 109, 220, 10
1854, 109, 110, 221, 220
1855, 110, 111, 222, 221
1856, 111, 112, 223, 222
1857, 112, 113, 224, 223
1858, 113, 114, 225, 224
1859, 114, 115, 226, 225
1860, 115, 116, 227, 226
1861, 116, 117, 228, 227
1862, 117, 3, 12, 228
*ELEMENT, type=CPS4, ELSET=Surface11
1863, 10, 220, 1527, 189
1864, 220, 221, 1528, 1527
1865, 221, 222, 1529, 1528
1866, 222, 223, 1530, 1529
1867, 223, 224, 1531, 1530
1868, 224, 225, 1532, 1531
1869, 225, 226, 1533, 1532
1870, 226, 227, 1534, 1533
1871, 227, 228, 1535, 1534
1872, 228, 12, 209, 1535
1873, 189, 1527, 1536, 190
1874, 1527, 1528, 1537, 1536
1875, 1528, 1529, 1538, 1537
1876, 1529, 1530, 1539, 1538
1877, 1530, 1531, 1540, 1539
1878, 1531, 1532, 1541, 1540
1879, 1532, 1533, 1542, 1541
1880, 1533, 1534, 1543, 1542
1881, 1534, 1535, 1544, 1543
1882, 1535, 209, 210, 1544
1883, 190, 1536, 1545, 191
1884, 1536, 1537, 1546, 1545
1885, 1537, 1538, 1547, 1546
1886, 1538, 1539, 1548, 1547
1887, 1539, 1540, 1549, 1548
1888, 1540, 1541, 1550, 1549
1889, 1541, 1542, 1551, 1550
1890, 1542, 1543, 1552, 1551
1891, 1543, 1544, 1553, 1552
1892, 1544, 210, 211, 1553
1893, 191, 1545, 1554, 192
1894, 1545, 1546, 1555, 1554
1895, 1546, 1547, 1556, 1555
1896, 1547, 1548, 1557, 1556
1897, 1548, 1549, 1558, 1557
1898, 1549, 1550, 1559, 1558
1899, 1550, 1551, 1560, 1559
1900, 1551, 1552, 1561, 1560
1901, 1552, 1553, 1562, 1561
1902, 1553, 211, 212, 1562
1903, 192, 1554, 1563, 193
1904, 1554, 1555, 1564, 1563
1905, 1555, 1556, 1565, 1564
1906, 1556, 1557, 1566, 1565
1907, 1557, 1558, 1567, 1566
1908, 1558, 1559, 1568, 1567
1909, 1559, 1560, 1569, 1568
1910, 1560, 1561, 1570, 1569
1911, 1561, 1562, 1571, 1570
1912, 1562, 212, 213, 1571
1913, 193, 1563, 1572, 194
1914, 1563, 1564, 1573, 1572
1915, 1564, 1565, 1574, 1573
1916, 1565, 1566, 1575, 1574
1917, 1566, 1567, 1576, 1575
1918, 1567, 1568, 1577, 1576
1919, 1568, 1569, 1578, 1577
1920, 1569, 1570, 1579, 1578
1921, 1570, 1571, 1580, 1579
1922, 1571, 213, 214, 1580
1923, 194, 1572, 1581, 195
1924, 1572, 1573, 1582, 1581
1925, 1573, 1574, 1583, 1582
1926, 1574, 1575, 1584, 1583
1927, 1575, 1576, 1585, 1584
1928, 1576, 1577, 1586, 1585
1929, 1577, 1578, 1587, 1586
1930, 1578, 1579, 1588, 1587
1931, 1579, 1580, 1589, 1588
1932, 1580, 214, 215, 1589
1933, 195, 1581, 1590, 196
1934, 1581, 1582, 1591, 1590
1935, 1582, 1583, 1592, 1591
1936, 1583, 1584, 1593, 1592
1937, 1584, 1585, 1594, 1593
1938, 1585, 1586, 1595, 1594
1939, 1586, 1587, 1596, 1595
1940, 1587, 1588, 1597, 1596
1941, 1588, 1589, 1598, 1597
1942, 1589, 215, 216, 1598
1943, 196, 1590, 1599, 197
1944, 1590, 1591, 1600, 1599
1945, 1591, 1592, 1601, 1600
1946, 1592, 1593, 1602, 1601
1947, 1593, 1594, 1603, 1602
1948, 1594, 1595, 1604, 1603
1949, 1595, 1596, 1605, 1604
1950, 1596, 1597, 1606, 1605
1951, 1597, 1598, 1607, 1606
1952, 1598, 216, 217, 1607
1953, 197, 1599, 1608, 198
1954, 1599, 1600, 1609, 1608
1955, 1600, 1601, 1610, 1609
1956, 1601, 1602, 1611, 1610
1957, 1602, 1603, 1612, 1611
1958, 1603, 1604, 1613, 1612
1959, 1604, 1605, 1614, 1613
1960, 1605, 1606, 1615, 1614
1961, 1606, 1607, 1616, 1615
1962, 1607, 217, 218, 1616
1963, 198, 1608, 1617, 199
1964, 1608, 1609, 1618, 1617
1965, 1609, 1610, 1619, 1618
1966, 1610, 1611, 1620, 1619
1967, 1611, 1612, 1621, 1620
1968, 1612, 1613, 1622, 1621
1969, 1613, 1614, 1623, 1622
1970, 1614, 1615, 1624, 1623
1971, 1615, 1616, 1625, 1624
1972, 1616, 218, 219, 1625
1973, 199, 1617, 200, 9
1974, 1617, 1618, 201, 200
1975, 1618, 1619, 202, 201
1976, 1619, 1620, 203, 202
1977, 1620, 1621, 204, 203
1978, 1621, 1622, 205, 204
1979, 1622, 1623, 206, 205
1980, 1623, 1624, 207, 206
1981, 1624, 1625, 208, 207
1982, 1625, 219, 11, 208
*ELEMENT, type=CPS4, ELSET=Surface12
1983, 10, 238, 1626, 189
1984, 238, 239, 1627, 1626
1985, 239, 240, 1628, 1627
1986, 240, 241, 1629, 1628
1987, 241, 242, 1630, 1629
1988, 242, 243, 1631, 1630
1989, 243, 244, 1632, 1631
1990, 244, 245, 1633, 1632
1991, 245, 246, 1634, 1633
1992, 246, 14, 247, 1634
1993, 189, 1626, 1635, 190
1994, 1626, 1627, 1636, 1635
1995, 1627, 1628, 1637, 1636
1996, 1628, 1629, 1638, 1637
1997, 1629, 1630, 1639, 1638
1998, 1630, 1631, 1640, 1639
1999, 1631, 1632, 1641, 1640
2000, 1632, 1633, 1642, 1641
2001, 1633, 1634, 1643, 1642
2002, 1634, 247, 248, 1643
2003, 190, 1635, 1644, 191
2004, 1635, 1636, 1645, 1644
2005, 1636, 1637, 1646, 1645
2006, 1637, 1638, 1647, 1646
2007, 1638, 1639, 1648, 1647
2008, 1639, 1640, 1649, 1648
2009, 1640, 1641, 1650, 1649
2010, 1641, 1642, 1651, 1650
2011, 1642, 1643, 1652, 1651
2012, 1643, 248, 249, 1652
2013, 191, 1644, 1653, 192
2014, 1644, 1645, 1654, 1653
2015, 1645, 1646, 1655, 1654
2016, 1646, 1647, 1656, 1655
2017, 1647, 1648, 1657, 1656
2018, 1648, 1649, 1658, 1657
2019, 1649, 1650, 1659, 1658
2020, 1650, 1651, 1660, 1659
2021, 1651, 1652, 1661, 1660
2022, 1652, 249, 250, 1661
2023, 192, 1653, 1662, 193
2024, 1653, 1654, 1663, 1662
2025, 1654, 1655, 1664, 1663
2026, 1655, 1656, 1665, 1664
2027, 1656, 1657, 1666, 1665
2028, 1657, 1658, 1667, 1666
2029, 1658, 1659, 1668, 1667
2030, 1659, 1660, 1669, 1668
2031, 1660, 1661, 1670, 1669
2032, 1661, 250, 251, 1670
2033, 193, 1662, 1671, 194
2034, 1662, 1663, 1672, 1671
2035, 1663, 1664, 1673, 1672
2036, 1664, 1665, 1674, 1673
2037, 1665, 1666, 1675, 1674
2038, 1666, 1667, 1676, 1675
2039, 1667, 1668, 1677, 1676
2040, 1668, 1669, 1678, 1677
2041, 1669, 1670, 1679, 1678
2042, 1670, 251, 252, 1679
2043, 194, 1671, 1680, 195
2044, 1671, 1672, 1681, 1680
2045, 1672, 1673, 1682, 1681
2046, 1673, 1674, 1683, 1682
2047, 1674, 1675, 1684, 1683
2048, 1675, 1676, 1685, 1684
2049, 1676, 1677, 1686, 1685
2050, 1677, 1678, 1687, 1686
2051, 1678, 1679, 1688, 1687
2052, 1679, 252, 253, 1688
2053, 195, 1680, 1689, 196
2054, 1680, 1681, 1690, 1689
2055, 1681, 1682, 1691, 1690
2056, 1682, 1683, 1692, 1691
2057, 1683, 1684, 1693, 1692
2058, 1684, 1685, 1694, 1693
2059, 1685, 1686, 1695, 1694
2060, 1686, 1687, 1696, 1695
2061, 1687, 1688, 1697, 1696
2062, 1688, 253, 254, 1697
2063, 196, 1689, 1698, 197
2064, 1689, 1690, 1699, 1698
2065, 1690, 1691, 1700, 1699
2066, 1691, 1692, 1701, 1700
2067, 1692, 1693, 1702, 1701
2068, 1693, 1694, 1703, 1702
2069, 1694, 1695, 1704, 1703
2070, 1695, 1696, 1705, 1704
2071, 1696, 1697, 1706, 1705
2072, 1697, 254, 255, 1706
2073, 197, 1698, 1707, 198
2074, 1698, 1699, 1708, 1707
2075, 1699, 1700, 1709, 1708
2076, 1700, 1701, 1710, 1709
2077, 1701, 1702, 1711, 1710
2078, 1702, 1703, 1712, 1711
2079, 1703, 1704, 1713, 1712
2080, 1704, 1705, 1714, 1713
2081, 1705, 1706, 1715, 1714
2082, 1706, 255, 256, 1715
2083, 198, 1707, 1716, 199
2084, 1707, 1708, 1717, 1716
2085, 1708, 1709, 1718, 1717
2086, 1709, 1710, 1719, 1718
2087, 1710, 1711, 1720, 1719
2088, 1711, 1712, 1721, 1720
2089, 1712, 1713, 1722, 1721
2090, 1713, 1714, 1723, 1722
2091, 1714, 1715, 1724, 1723
2092, 1715, 256, 257, 1724
2093, 199, 1716, 229, 9
2094, 1716, 1717, 230, 229
2095, 1717, 1718, 231, 230
2096, 1718, 1719, 232, 231
2097, 1719, 1720, 233, 232
2098, 1720, 1721, 234, 233
2099, 1721, 1722, 235, 234
2100, 1722, 1723, 236, 235
2101, 1723, 1724, 237, 236
2102, 1724, 257, 13, 237
*ELEMENT, type=CPS4, ELSET=Surface13
2103, 9, 229, 1725, 200
2104, 229, 230, 1726, 1725
2105, 230, 231, 1727, 1726
2106, 231, 232, 1728, 1727
2107, 232, 233, 1729, 1728
2108, 233, 234, 1730, 1729
2109, 234, 235, 1731, 1730
2110, 235, 236, 1732, 1731
2111, 236, 237, 1733, 1732
2112, 237, 13, 267, 1733
2113, 200, 1725, 1734, 201
2114, 1725, 1726, 1735, 1734
2115, 1726, 1727, 1736, 1735
2116, 1727, 1728, 1737, 1736
2117, 1728, 1729, 1738, 1737
2118, 1729, 1730, 1739, 1738
2119, 1730, 1731, 1740, 1739
2120, 1731, 1732, 1741, 1740
2121, 1732, 1733, 1742, 1741
2122, 1733, 267, 268, 1742
2123, 201, 1734, 1743, 202
2124, 1734, 1735, 1744, 1743
2125, 1735, 1736, 1745, 1744
2126, 1736, 1737, 1746, 1745
2127, 1737, 1738, 1747, 1746
2128, 1738, 1739, 1748, 1747
2129, 1739, 1740, 1749, 1748
2130, 1740, 1741, 1750, 1749
2131, 1741, 1742, 1751, 1750
2132, 1742, 268, 269, 1751
2133, 202, 1743, 1752, 203
2134, 1743, 1744, 1753, 1752
2135, 1744, 1745, 1754, 1753
2136, 1745, 1746, 1755, 1754
2137, 1746, 1747, 1756, 1755
2138, 1747, 1748, 1757, 1756
2139, 1748, 1749, 1758, 1757
2140, 1749, 1750, 1759, 1758
2141, 1750, 1751, 1760, 1759
2142, 1751, 269, 270, 1760
2143, 203, 1752, 1761, 204
2144, 1752, 1753, 1762, 1761
2145, 1753, 1754, 1763, 1762
2146, 1754, 1755, 1764, 1763
2147, 1755, 1756, 1765, 1764
2148, 1756, 1757, 1766, 1765
2149, 1757, 1758, 1767, 1766
2150, 1758, 1759, 1768, 1767
2151, 1759, 1760, 1769, 1768
2152, 1760, 270, 271, 1769
2153, 204, 1761, 1770, 205
2154, 1761, 1762, 1771, 1770
2155, 1762, 1763, 1772, 1771
2156, 1763, 1764, 1773, 1772
2157, 1764, 1765, 1774, 1773
2158, 1765, 1766, 1775, 1774
2159, 1766, 1767, 1776, 1775
2160, 1767, 1768, 1777, 1776
2161, 1768, 1769, 1778, 1777
2162, 1769, 271, 272, 1778
2163, 205, 1770, 1779, 206
2164, 1770, 1771, 1780, 1779
2165, 1771, 1772, 1781, 1780
2166, 1772, 1773, 1782, 1781
2167, 1773, 1774, 1783, 1782
2168, 1774, 1775, 1784, 1783
2169, 1775, 1776, 1785, 1784
2170, 1776, 1777, 1786, 1785
2171, 1777, 1778, 1787, 1786
2172, 1778, 272, 273, 1787
2173, 206, 1779, 1788, 207
2174, 1779, 1780, 1789, 1788
2175, 1780, 1781, 1790, 1789
2176, 1781, 1782, 1791, 1790
2177, 1782, 1783, 1792, 1791
2178, 1783, 1784, 1793, 1792
2179, 1784, 1785, 1794, 1793
2180, 1785, 1786, 1795, 1794
2181, 1786, 1787, 1796, 1795
2182, 1787, 273, 274, 1796
2183, 207, 1788, 1797, 208
2184, 1788, 1789, 1798, 1797
2185, 1789, 1790, 1799, 1798
2186, 1790, 1791, 1800, 1799
2187, 1791, 1792, 1801, 1800
2188, 1792, 1793, 1802, 1801
2189, 1793, 1794, 1803, 1802
2190, 1794, 1795, 1804, 1803
2191, 1795, 1796, 1805, 1804
2192, 1796, 274, 275, 1805
2193, 208, 1797, 258, 11
2194, 1797, 1798, 259, 258
2195, 1798, 1799, 260, 259
2196, 1799, 1800, 261, 260
2197, 1800, 1801, 262, 261
2198, 1801, 1802, 263, 262
2199, 1802, 1803, 264, 263
2200, 1803, 1804, 265, 264
2201, 1804, 1805, 266, 265
2202, 1805, 275, 15, 266
*ELEMENT, type=CPS4, ELSET=Surface14
2203, 12, 209, 1806, 276
2204, 276, 1806, 1807, 277
2205, 277, 1807, 1808, 278
2206, 278, 1808, 1809, 279
2207, 279, 1809, 1810, 280
2208, 280, 1810, 1811, 281
2209, 281, 1811, 1812, 282
2210, 282, 1812, 1813, 283
2211, 283, 1813, 1814, 284
2212, 284, 1814, 285, 16
2213, 209, 210, 1815, 1806
2214, 1806, 1815, 1816, 1807
2215, 1807, 1816, 1817, 1808
2216, 1808, 1817, 1818, 1809
2217, 1809, 1818, 1819, 1810
2218, 1810, 1819, 1820, 1811
2219, 1811, 1820, 1821, 1812
2220, 1812, 1821, 1822, 1813
2221, 1813, 1822, 1823, 1814
2222, 1814, 1823, 286, 285
2223, 210, 211, 1824, 1815
2224, 1815, 1824, 1825, 1816
2225, 1816, 1825, 1826, 1817
2226, 1817, 1826, 1827, 1818
2227, 1818, 1827, 1828, 1819
2228, 1819, 1828, 1829, 1820
2229, 1820, 1829, 1830, 1821
2230, 1821, 1830, 1831, 1822
2231, 1822, 1831, 1832, 1823
2232, 1823, 1832, 287, 286
2233, 211, 212, 1833, 1824
2234, 1824, 1833, 1834, 1825
2235, 1825, 1834, 1835, 1826
2236, 1826, 1835, 1836, 1827
2237, 1827, 1836, 1837, 1828
2238, 1828, 1837, 1838, 1829
2239, 1829, 1838, 1839, 1830
2240, 1830, 1839, 1840, 1831
2241, 1831, 1840, 1841, 1832
2242, 1832, 1841, 288, 287
2243, 212, 213, 1842, 1833
2244, 1833, 1842, 1843, 1834
2245, 1834, 1843, 1844, 1835
2246, 1835, 1844, 1845, 1836
2247, 1836, 1845, 1846, 1837
2248, 1837, 1846, 1847, 1838
2249, 1838, 1847, 1848, 1839
2250, 1839, 1848, 1849, 1840
2251, 1840, 1849, 1850, 1841
2252, 1841, 1850, 289, 288
2253, 213, 214, 1851, 1842
2254, 1842, 1851, 1852, 1843
2255, 1843, 1852, 1853, 1844
2256, 1844, 1853, 1854, 1845
2257, 1845, 1854, 1855, 1846
2258, 1846, 1855, 1856, 1847
2259, 1847, 1856, 1857, 1848
2260, 1848, 1857, 1858, 1849
2261, 1849, 1858, 1859, 1850
2262, 1850, 1859, 290, 289
2263, 214, 215, 1860, 1851
2264, 1851, 1860, 1861, 1852
2265, 1852, 1861, 1862, 1853
2266, 1853, 1862, 1863, 1854
2267, 1854, 1863, 1864, 1855
2268, 1855, 1864, 1865, 1856
2269, 1856, 1865, 1866, 1857
2270, 1857, 1866, 1867, 1858
2271, 1858, 1867, 1868, 1859
2272, 1859, 1868, 291, 290
2273, 215, 216, 1869, 1860
2274, 1860, 1869, 1870, 1861
2275, 1861, 1870, 1871, 1862
2276, 1862, 1871, 1872, 1863
2277, 1863, 1872, 1873, 1864
2278, 1864, 1873, 1874, 1865
2279, 1865, 1874, 1875, 1866
2280, 1866, 1875, 1876, 1867
2281, 1867, 1876, 1877, 1868
2282, 1868, 1877, 292, 291
2283, 216, 217, 1878, 1869
2284, 1869, 1878, 1879, 1870
2285, 1870, 1879, 1880, 1871
2286, 1871, 1880, 1881, 1872
2287, 1872, 1881, 1882, 1873
2288, 1873, 1882, 1883, 1874
2289, 1874, 1883, 1884, 1875
2290, 1875, 1884, 1885, 1876
2291, 1876, 1885, 1886, 1877
2292, 1877, 1886, 293, 292
2293, 217, 218, 1887, 1878
2294, 1878, 1887, 1888, 1879
2295, 1879, 1888, 1889, 1880
2296, 1880, 1889, 1890, 1881
2297, 1881, 1890, 1891, 1882
2298, 1882, 1891, 1892, 1883
2299, 1883, 1892, 1893, 1884
2300, 1884, 1893, 1894, 1885
2301, 1885, 1894, 1895, 1886
2302, 1886, 1895, 294, 293
2303, 218, 219, 1896, 1887
2304, 1887, 1896, 1897, 1888
2305, 1888, 1897, 1898, 1889
2306, 1889, 1898, 1899, 1890
2307, 1890, 1899, 1900, 1891
2308, 1891, 1900, 1901, 1892
2309, 1892, 1901, 1902, 1893
2310, 1893, 1902, 1903, 1894
2311, 1894, 1903, 1904, 1895
2312, 1895, 1904, 295, 294
2313, 219, 11, 258, 1896
2314, 1896, 258, 259, 1897
2315, 1897, 259, 260, 1898
2316, 1898, 260, 261, 1899
2317, 1899, 261, 262, 1900
2318, 1900, 262, 263, 1901
2319, 1901, 263, 264, 1902
2320, 1902, 264, 265, 1903
2321, 1903, 265, 266, 1904
2322, 1904, 266, 15, 295
*ELEMENT, type=CPS4, ELSET=Surface15
2323, 10, 220, 1905, 238
2324, 238, 1905, 1906, 239
2325, 239, 1906, 1907, 240
2326, 240, 1907, 1908, 241
2327, 241, 1908, 1909, 242
2328, 242, 1909, 1910, 243
2329, 243, 1910, 1911, 244
2330, 244, 1911, 1912, 245
2331, 245, 1912, 1913, 246
2332, 246, 1913, 296, 14
2333, 220, 221, 1914, 1905
2334, 1905, 1914, 1915, 1906
2335, 1906, 1915, 1916, 1907
2336, 1907, 1916, 1917, 1908
2337, 1908, 1917, 1918, 1909
2338, 1909, 1918, 1919, 1910
2339, 1910, 1919, 1920, 1911
2340, 1911, 1920, 1921, 1912
2341, 1912, 1921, 1922, 1913
2342, 1913, 1922, 297, 296
2343, 221, 222, 1923, 1914
2344, 1914, 1923, 1924, 1915
2345, 1915, 1924, 1925, 1916
2346, 1916, 1925, 1926, 1917
2347, 1917, 1926, 1927, 1918
2348, 1918, 1927, 1928, 1919
2349, 1919, 1928, 1929, 1920
2350, 1920, 1929, 1930, 1921
2351, 1921, 1930, 1931, 1922
2352, 1922, 1931, 298, 297
2353, 222, 223, 1932, 1923
2354, 1923, 1932, 1933, 1924
2355, 1924, 1933, 1934, 1925
2356, 1925, 1934, 1935, 1926
2357, 1926, 1935, 1936, 1927
2358, 1927, 1936, 1937, 1928
2359, 1928, 1937, 1938, 1929
2360, 1929, 1938, 1939, 1930
2361, 1930, 1939, 1940, 1931
2362, 1931, 1940, 299, 298
2363, 223, 224, 1941, 1932
2364, 1932, 1941, 1942, 1933
2365, 1933, 1942, 1943, 1934
2366, 1934, 1943, 1944, 1935
2367, 1935, 1944, 1945, 1936
2368, 1936, 1945, 1946, 1937
2369, 1937, 1946, 1947, 1938
2370, 1938, 1947, 1948, 1939
2371, 1939, 1948, 1949, 1940
2372, 1940, 1949, 300, 299
2373, 224, 225, 1950, 1941
2374, 1941, 1950, 1951, 1942
2375, 1942, 1951, 1952, 1943
2376, 1943, 1952, 1953, 1944
2377, 1944, 1953, 1954, 1945
2378, 1945, 1954, 1955, 1946
2379, 1946, 1955, 1956, 1947
2380, 1947, 1956, 1957, 1948
2381, 1948, 1957, 1958, 1949
2382, 1949, 1958, 301, 300
2383, 225, 226, 1959, 1950
2384, 1950, 1959, 1960, 1951
2385, 1951, 1960, 1961, 1952
2386, 1952, 1961, 1962, 1953
2387, 1953, 1962, 1963, 1954
2388, 1954, 1963, 1964, 1955
2389, 1955, 1964, 1965, 1956
2390, 1956, 1965, 1966, 1957
2391, 1957, 1966, 1967, 1958
2392, 1958, 1967, 302, 301
2393, 226, 227, 1968, 1959
2394, 1959, 1968, 1969, 1960
2395, 1960, 1969, 1970, 1961
2396, 1961, 1970, 1971, 1962
2397, 1962, 1971, 1972, 1963
2398, 1963, 1972, 1973, 1964
2399, 1964, 1973, 1974, 1965
2400, 1965, 1974, 1975, 1966
2401, 1966, 1975, 1976, 1967
2402, 1967, 1976, 303, 302
2403, 227, 228, 1977, 1968
2404, 1968, 1977, 1978, 1969
2405, 1969, 1978, 1979, 1970
2406, 1970, 1979, 1980, 1971
2407, 1971, 1980, 1981, 1972
2408, 1972, 1981, 1982, 1973
2409, 1973, 1982, 1983, 1974
2410, 1974, 1983, 1984, 1975
2411, 1975, 1984, 1985, 1976
2412, 1976, 1985, 304, 303
2413, 228, 12, 276, 1977
2414, 1977, 276, 277, 1978
2415, 1978, 277, 278, 1979
2416, 1979, 278, 279, 1980
2417, 1980, 279, 280, 1981
2418, 1981, 280, 281, 1982
2419, 1982, 281, 282, 1983
2420, 1983, 282, 283, 1984
2421, 1984, 283, 284, 1985
2422, 1985, 284, 16, 304
*ELEMENT, type=CPS4, ELSET=Surface16
2423, 14, 296, 1986, 247
2424, 296, 297, 1987, 1986
2425, 297, 298, 1988, 1987
2426, 298, 299, 1989, 1988
2427, 299, 300, 1990, 1989
2428, 300, 301, 1991, 1990
2429, 301, 302, 1992, 1991
2430, 302, 303, 1993, 1992
2431, 303, 304, 1994, 1993
2432, 304, 16, 285, 1994
2433, 247, 1986, 1995, 248
2434, 1986, 1987, 1996, 1995
2435, 1987, 1988, 1997, 1996
2436, 1988, 1989, 1998, 1997
2437, 1989, 1990, 1999, 1998
2438, 1990, 1991, 2000, 1999
2439, 1991, 1992, 2001, 2000
2440, 1992, 1993, 2002, 2001
2441, 1993, 1994, 2003, 2002
2442, 1994, 285, 286, 2003
2443, 248, 1995, 2004, 249
2444, 1995, 1996, 2005, 2004
2445, 1996, 1997, 2006, 2005
2446, 1997, 1998, 2007, 2006
2447, 1998, 1999, 2008, 2007
2448, 1999, 2000, 2009, 2008
2449, 2000, 2001, 2010, 2009
2450, 2001, 2002, 2011, 2010
2451, 2002, 2003, 2012, 2011
2452, 2003, 286, 287, 2012
2453, 249, 2004, 2013, 250
2454, 2004, 2005, 2014, 2013
2455, 2005, 2006, 2015, 2014
2456, 2006, 2007, 2016, 2015
2457, 2007, 2008, 2017, 2016
2458, 2008, 2009, 2018, 2017
2459, 2009, 2010, 2019, 2018
2460, 2010, 2011, 2020, 2019
2461, 2011, 2012, 2021, 2020
2462, 2012, 287, 288, 2021
2463, 250, 2013, 2022, 251
2464, 2013, 2014, 2023, 2022
2465, 2014, 2015, 2024, 2023
2466, 2015, 2016, 2025, 2024
2467, 2016, 2017, 2026, 2025
2468, 2017, 2018, 2027, 2026
2469, 2018, 2019, 2028, 2027
2470, 2019, 2020, 2029, 2028
2471, 2020, 2021, 2030, 2029
2472, 2021, 288, 289, 2030
2473, 251, 2022, 2031, 252
2474, 2022, 2023, 2032, 2031
2475, 2023, 2024, 2033, 2032
2476, 2024, 2025, 2034, 2033
2477, 2025, 2026, 2035, 2034
2478, 2026, 2027, 2036, 2035
2479, 2027, 2028, 2037, 2036
2480, 2028, 2029, 2038, 2037
2481, 2029, 2030, 2039, 2038
2482, 2030, 289, 290, 2039
2483, 252, 2031, 2040, 253
2484, 2031, 2032, 2041, 2040
2485, 2032, 2033, 2042, 2041
2486, 2033, 2034, 2043, 2042
2487, 2034, 2035, 2044, 2043
2488, 2035, 2036, 2045, 2044
2489, 2036, 2037, 2046, 2045
2490, 2037, 2038, 2047, 2046
2491, 2038, 2039, 2048, 2047
2492, 2039, 290, 291, 2048
2493, 253, 2040, 2049, 254
2494, 2040, 2041, 2050, 2049
2495, 2041, 2042, 2051, 2050
2496, 2042, 2043, 2052, 2051
2497, 2043, 2044, 2053, 2052
2498, 2044, 2045, 2054, 2053
2499, 2045, 2046, 2055, 2054
2500, 2046, 2047, 2056, 2055
2501, 2047, 2048, 2057, 2056
2502, 2048, 291, 292, 2057
2503, 254, 2049, 2058, 255
2504, 2049, 2050, 2059, 2058
2505, 2050, 2051, 2060, 2059
2506, 2051, 2052, 2061, 2060
2507, 2052, 2053, 2062, 2061
2508, 2053, 2054, 2063, 2062
2509, 2054, 2055, 2064, 2063
2510, 2055, 2056, 2065, 2064
2511, 2056, 2057, 2066, 2065
2512, 2057, 292, 293, 2066
2513, 255, 2058, 2067, 256
2514, 2058, 2059, 2068, 2067
2515, 2059, 2060, 2069, 2068
2516, 2060, 2061, 2070, 2069
2517, 2061, 2062, 2071, 2070
2518, 2062, 2063, 2072, 2071
2519, 2063, 2064, 2073, 2072
2520, 2064, 2065, 2074, 2073
2521, 2065, 2066, 2075, 2074
2522, 2066, 293, 294, 2075
2523, 256, 2067, 2076, 257
2524, 2067, 2068, 2077, 2076
2525, 2068, 2069, 2078, 2077
2526, 2069, 2070, 2079, 2078
2527, 2070, 2071, 2080, 2079
2528, 2071, 2072, 2081, 2080
2529, 2072, 2073, 2082, 2081
2530, 2073, 2074, 2083, 2082
2531, 2074, 2075, 2084, 2083
2532, 2075, 294, 295, 2084
2533, 257, 2076, 267, 13
2534, 2076, 2077, 268, 267
2535, 2077, 2078, 269, 268
2536, 2078, 2079, 270, 269
2537, 2079, 2080, 271, 270
2538, 2080, 2081, 272, 271
2539, 2081, 2082, 273, 272
2540, 2082, 2083, 274, 273
2541, 2083, 2084, 275, 274
2542, 2084, 295, 15, 275
*ELEMENT, type=CPS4, ELSET=Surface17
2543, 14, 18, 305, 247
2544, 247, 305, 306, 248
2545, 248, 306, 307, 249
2546, 249, 307, 308, 250
2547, 250, 308, 309, 251
2548, 251, 309, 310, 252
2549, 252, 310, 311, 253
2550, 253, 311, 312, 254
2551, 254, 312, 313, 255
2552, 255, 313, 314, 256
2553, 256, 314, 315, 257
2554, 257, 315, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
2555, 13, 17, 316, 267
2556, 267, 316, 317, 268
2557, 268, 317, 318, 269
2558, 269, 318, 319, 270
2559, 270, 319, 320, 271
2560, 271, 320, 321, 272
2561, 272, 321, 322, 273
2562, 273, 322, 323, 274
2563, 274, 323, 324, 275
2564, 275, 324, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
2565, 16, 285, 325, 20
2566, 285, 286, 326, 325
2567, 286, 287, 327, 326
2568, 287, 288, 328, 327
2569, 288, 289, 329, 328
2570, 289, 290, 330, 329
2571, 290, 291, 331, 330
2572, 291, 292, 332, 331
2573, 292, 293, 333, 332
2574, 293, 294, 334, 333
2575, 294, 295, 335, 334
2576, 295, 15, 19, 335
*ELEMENT, type=CPS4, ELSET=Surface20
2577, 14, 296, 336, 18
2578, 296, 297, 337, 336
2579, 297, 298, 338, 337
2580, 298, 299, 339, 338
2581, 299, 300, 340, 339
2582, 300, 301, 341, 340
2583, 301, 302, 342, 341
2584, 302, 303, 343, 342
2585, 303, 304, 344, 343
2586, 304, 16, 20, 344
*ELEMENT, type=CPS4, ELSET=Surface21
2587, 18, 336, 2085, 305
2588, 336, 337, 2086, 2085
2589, 337, 338, 2087, 2086
2590, 338, 339, 2088, 2087
2591, 339, 340, 2089, 2088
2592, 340, 341, 2090, 2089
2593, 341, 342, 2091, 2090
2594, 342, 343, 2092, 2091
2595, 343, 344, 2093, 2092
2596, 344, 20, 325, 2093
2597, 305, 2085, 2094, 306
2598, 2085, 2086, 2095, 2094
2599, 2086, 2087, 2096, 2095
2600, 2087, 2088, 2097, 2096
2601, 2088, 2089, 2098, 2097
2602, 2089, 2090, 2099, 2098
2603, 2090, 2091, 2100, 2099
2604, 2091, 2092, 2101, 2100
2605, 2092, 2093, 2102, 2101
2606, 2093, 325, 326, 2102
2607, 306, 2094, 2103, 307
2608, 2094, 2095, 2104, 2103
2609, 2095, 2096, 2105, 2104
2610, 2096, 2097, 2106, 2105
2611, 2097, 2098, 2107, 2106
2612, 2098, 2099, 2108, 2107
2613, 2099, 2100, 2109, 2108
2614, 2100, 2101, 2110, 2109
2615, 2101, 2102, 2111, 2110
2616, 2102, 326, 327, 2111
2617, 307, 2103, 2112, 308
2618, 2103, 2104, 2113, 2112
2619, 2104, 2105, 2114, 2113
2620, 2105, 2106, 2115, 2114
2621, 2106, 2107, 2116, 2115
2622, 2107, 2108, 2117, 2116
2623, 2108, 2109, 2118, 2117
2624, 2109, 2110, 2119, 2118
2625, 2110, 2111, 2120, 2119
2626, 2111, 327, 328, 2120
2627, 308, 2112, 2121, 309
2628, 2112, 2113, 2122, 2121
2629, 2113, 2114, 2123, 2122
2630, 2114, 2115, 2124, 2123
2631, 2115, 2116, 2125, 2124
2632, 2116, 2117, 2126, 2125
2633, 2117, 2118, 2127, 2126
2634, 2118, 2119, 2128, 2127
2635, 2119, 2120, 2129, 2128
2636, 2120, 328, 329, 2129
2637, 309, 2121, 2130, 310
2638, 2121, 2122, 2131, 2130
2639, 2122, 2123, 2132, 2131
2640, 2123, 2124, 2133, 2132
2641, 2124, 2125, 2134, 2133
2642, 2125, 2126, 2135, 2134
2643, 2126, 2127, 2136, 2135
2644, 2127, 2128, 2137, 2136
2645, 2128, 2129, 2138, 2137
2646, 2129, 329, 330, 2138
2647, 310, 2130, 2139, 311
2648, 2130, 2131, 2140, 2139
2649, 2131, 2132, 2141, 2140
2650, 2132, 2133, 2142, 2141
2651, 2133, 2134, 2143, 2142
2652, 2134, 2135, 2144, 2143
2653, 2135, 2136, 2145, 2144
2654, 2136, 2137, 2146, 2145
2655, 2137, 2138, 2147, 2146
2656, 2138, 330, 331, 2147
2657, 311, 2139, 2148, 312
2658, 2139, 2140, 2149, 2148
2659, 2140, 2141, 2150, 2149
2660, 2141, 2142, 2151, 2150
2661, 2142, 2143, 2152, 2151
2662, 2143, 2144, 2153, 2152
2663, 2144, 2145, 2154, 2153
2664, 2145, 2146, 2155, 2154
2665, 2146, 2147, 2156, 2155
2666, 2147, 331, 332, 2156
2667, 312, 2148, 2157, 313
2668, 2148, 2149, 2158, 2157
2669, 2149, 2150, 2159, 2158
2670, 2150, 2151, 2160, 2159
2671, 2151, 2152, 2161, 2160
2672, 2152, 2153, 2162, 2161
2673, 2153, 2154, 2163, 2162
2674, 2154, 2155, 2164, 2163
2675, 2155, 2156, 2165, 2164
2676, 2156, 332, 333, 2165
2677, 313, 2157, 2166, 314
2678, 2157, 2158, 2167, 2166
2679, 2158, 2159, 2168, 2167
2680, 2159, 2160, 2169, 2168
2681, 2160, 2161, 2170, 2169
2682, 2161, 2162, 2171, 2170
2683, 2162, 2163, 2172, 2171
2684, 2163, 2164, 2173, 2172
2685, 2164, 2165, 2174, 2173
2686, 2165, 333, 334, 2174
2687, 314, 2166, 2175, 315
2688, 2166, 2167, 2176, 2175
2689, 2167, 2168, 2177, 2176
2690, 2168, 2169, 2178, 2177
2691, 2169, 2170, 2179, 2178
2692, 2170, 2171, 2180, 2179
2693, 2171, 2172, 2181, 2180
2694, 2172, 2173, 2182, 2181
2695, 2173, 2174, 2183, 2182
2696, 2174, 334, 335, 2183
2697, 315, 2175, 316, 17
2698, 2175, 2176, 317, 316
2699, 2176, 2177, 318, 317
2700, 2177, 2178, 319, 318
2701, 2178, 2179, 320, 319
2702, 2179, 2180, 321, 320
2703, 2180, 2181, 322, 321
2704, 2181, 2182, 323, 322
2705, 2182, 2183, 324, 323
2706, 2183, 335, 19, 324
*ELEMENT, type=CPS4, ELSET=Surface22
2707, 18, 348, 2184, 305
2708, 348, 349, 2185, 2184
2709, 349, 350, 2186, 2185
2710, 350, 22, 351, 2186
2711, 305, 2184, 2187, 306
2712, 2184, 2185, 2188, 2187
2713, 2185, 2186, 2189, 2188
2714, 2186, 351, 352, 2189
2715, 306, 2187, 2190, 307
2716, 2187, 2188, 2191, 2190
2717, 2188, 2189, 2192, 2191
2718, 2189, 352, 353, 2192
2719, 307, 2190, 2193, 308
2720, 2190, 2191, 2194, 2193
2721, 2191, 2192, 2195, 2194
2722, 2192, 353, 354, 2195
2723, 308, 2193, 2196, 309
2724, 2193, 2194, 2197, 2196
2725, 2194, 2195, 2198, 2197
2726, 2195, 354, 355, 2198
2727, 309, 2196, 2199, 310
2728, 2196, 2197, 2200, 2199
2729, 2197, 2198, 2201, 2200
2730, 2198, 355, 356, 2201
2731, 310, 2199, 2202, 311
2732, 2199, 2200, 2203, 2202
2733, 2200, 2201, 2204, 2203
2734, 2201, 356, 357, 2204
2735, 311, 2202, 2205, 312
2736, 2202, 2203, 2206, 2205
2737, 2203, 2204, 2207, 2206
2738, 2204, 357, 358, 2207
2739, 312, 2205, 2208, 313
2740, 2205, 2206, 2209, 2208
2741, 2206, 2207, 2210, 2209
2742, 2207, 358, 359, 2210
2743, 313, 2208, 2211, 314
2744, 2208, 2209, 2212, 2211
2745, 2209, 2210, 2213, 2212
2746, 2210, 359, 360, 2213
2747, 314, 2211, 2214, 315
2748, 2211, 2212, 2215, 2214
2749, 2212, 2213, 2216, 2215
2750, 2213, 360, 361, 2216
2751, 315, 2214, 345, 17
2752, 2214, 2215, 346, 345
2753, 2215, 2216, 347, 346
2754, 2216, 361, 21, 347
*ELEMENT, type=CPS4, ELSET=Surface23
2755, 17, 345, 2217, 316
2756, 345, 346, 2218, 2217
2757, 346, 347, 2219, 2218
2758, 347, 21, 365, 2219
2759, 316, 2217, 2220, 317
2760, 2217, 2218, 2221, 2220
2761, 2218, 2219, 2222, 2221
2762, 2219, 365, 366, 2222
2763, 317, 2220, 2223, 318
2764, 2220, 2221, 2224, 2223
2765, 2221, 2222, 2225, 2224
2766, 2222, 366, 367, 2225
2767, 318, 2223, 2226, 319
2768, 2223, 2224, 2227, 2226
2769, 2224, 2225, 2228, 2227
2770, 2225, 367, 368, 2228
2771, 319, 2226, 2229, 320
2772, 2226, 2227, 2230, 2229
2773, 2227, 2228, 2231, 2230
2774, 2228, 368, 369, 2231
2775, 320, 2229, 2232, 321
2776, 2229, 2230, 2233, 2232
2777, 2230, 2231, 2234, 2233
2778, 2231, 369, 370, 2234
2779, 321, 2232, 2235, 322
2780, 2232, 2233, 2236, 2235
2781, 2233, 2234, 2237, 2236
2782, 2234, 370, 371, 2237
2783, 322, 2235, 2238, 323
2784, 2235, 2236, 2239, 2238
2785, 2236, 2237, 2240, 2239
2786, 2237, 371, 372, 2240
2787, 323, 2238, 2241, 324
2788, 2238, 2239, 2242, 2241
2789, 2239, 2240, 2243, 2242
2790, 2240, 372, 373, 2243
2791, 324, 2241, 362, 19
2792, 2241, 2242, 363, 362
2793, 2242, 2243, 364, 363
2794, 2243, 373, 23, 364
*ELEMENT, type=CPS4, ELSET=Surface24
2795, 20, 325, 2244, 374
2796, 374, 2244, 2245, 375
2797, 375, 2245, 2246, 376
2798, 376, 2246, 377, 24
2799, 325, 326, 2247, 2244
2800, 2244, 2247, 2248, 2245
2801, 2245, 2248, 2249, 2246
2802, 2246, 2249, 378, 377
2803, 326, 327, 2250, 2247
2804, 2247, 2250, 2251, 2248
2805, 2248, 2251, 2252, 2249
2806, 2249, 2252, 379, 378
2807, 327, 328, 2253, 2250
2808, 2250, 2253, 2254, 2251
2809, 2251, 2254, 2255, 2252
2810, 2252, 2255, 380, 379
2811, 328, 329, 2256, 2253
2812, 2253, 2256, 2257, 2254
2813, 2254, 2257, 2258, 2255
2814, 2255, 2258, 381, 380
2815, 329, 330, 2259, 2256
2816, 2256, 2259, 2260, 2257
2817, 2257, 2260, 2261, 2258
2818, 2258, 2261, 382, 381
2819, 330, 331, 2262, 2259
2820, 2259, 2262, 2263, 2260
2821, 2260, 2263, 2264, 2261
2822, 2261, 2264, 383, 382
2823, 331, 332, 2265, 2262
2824, 2262, 2265, 2266, 2263
2825, 2263, 2266, 2267, 2264
2826, 2264, 2267, 384, 383
2827, 332, 333, 2268, 2265
2828, 2265, 2268, 2269, 2266
2829, 2266, 2269, 2270, 2267
2830, 2267, 2270, 385, 384
2831, 333, 334, 2271, 2268
2832, 2268, 2271, 2272, 2269
2833, 2269, 2272, 2273, 2270
2834, 2270, 2273, 386, 385
2835, 334, 335, 2274, 2271
2836, 2271, 2274, 2275, 2272
2837, 2272, 2275, 2276, 2273
2838, 2273, 2276, 387, 386
2839, 335, 19, 362, 2274
2840, 2274, 362, 363, 2275
2841, 2275, 363, 364, 2276
2842, 2276, 364, 23, 387
*ELEMENT, type=CPS4, ELSET=Surface25
2843, 18, 336, 2277, 348
2844, 348, 2277, 2278, 349
2845, 349, 2278, 2279, 350
2846, 350, 2279, 388, 22
2847, 336, 337, 2280, 2277
2848, 2277, 2280, 2281, 2278
2849, 2278, 2281, 2282, 2279
2850, 2279, 2282, 389, 388
2851, 337, 338, 2283, 2280
2852, 2280, 2283, 2284, 2281
2853, 2281, 2284, 2285, 2282
2854, 2282, 2285, 390, 389
2855, 338, 339, 2286, 2283
2856, 2283, 2286, 2287, 2284
2857, 2284, 2287, 2288, 2285
2858, 2285, 2288, 391, 390
2859, 339, 340, 2289, 2286
2860, 2286, 2289, 2290, 2287
2861, 2287, 2290, 2291, 2288
2862, 2288, 2291, 392, 391
2863, 340, 341, 2292, 2289
2864, 2289, 2292, 2293, 2290
2865, 2290, 2293, 2294, 2291
2866, 2291, 2294, 393, 392
2867, 341, 342, 2295, 2292
2868, 2292, 2295, 2296, 2293
2869, 2293, 2296, 2297, 2294
2870, 2294, 2297, 394, 393
2871, 342, 343, 2298, 2295
2872, 2295, 2298, 2299, 2296
2873, 2296, 2299, 2300, 2297
2874, 2297, 2300, 395, 394
2875, 343, 344, 2301, 2298
2876, 2298, 2301, 2302, 2299
2877, 2299, 2302, 2303, 2300
2878, 2300, 2303, 396, 395
2879, 344, 20, 374, 2301
2880, 2301, 374, 375, 2302
2881, 2302, 375, 376, 2303
2882, 2303, 376, 24, 396
*ELEMENT, type=CPS4, ELSET=Surface26
2883, 22, 388, 2304, 351
2884, 388, 389, 2305, 2304
2885, 389, 390, 2306, 2305
2886, 390, 391, 2307, 2306
2887, 391, 392, 2308, 2307
2888, 392, 393, 2309, 2308
2889, 393, 394, 2310, 2309
2890, 394, 395, 2311, 2310
2891, 395, 396, 2312, 2311
2892, 396, 24, 377, 2312
2893, 351, 2304, 2313, 352
2894, 2304, 2305, 2314, 2313
2895, 2305, 2306, 2315, 2314
2896, 2306, 2307, 2316, 2315
2897, 2307, 2308, 2317, 2316
2898, 2308, 2309, 2318, 2317
2899, 2309, 2310, 2319, 2318
2900, 2310, 2311, 2320, 2319
2901, 2311, 2312, 2321, 2320
2902, 2312, 377, 378, 2321
2903, 352, 2313, 2322, 353
2904, 2313, 2314, 2323, 2322
2905, 2314, 2315, 2324, 2323
2906, 2315, 2316, 2325, 2324
2907, 2316, 2317, 2326, 2325
2908, 2317, 2318, 2327, 2326
2909, 2318, 2319, 2328, 2327
2910, 2319, 2320, 2329, 2328
2911, 2320, 2321, 2330, 2329
2912, 2321, 378, 379, 2330
2913, 353, 2322, 2331, 354
2914, 2322, 2323, 2332, 2331
2915, 2323, 2324, 2333, 2332
2916, 2324, 2325, 2334, 2333
2917, 2325, 2326, 2335, 2334
2918, 2326, 2327, 2336, 2335
2919, 2327, 2328, 2337, 2336
2920, 2328, 2329, 2338, 2337
2921, 2329, 2330, 2339, 2338
2922, 2330, 379, 380, 2339
2923, 354, 2331, 2340, 355
2924, 2331, 2332, 2341, 2340
2925, 2332, 2333, 2342, 2341
2926, 2333, 2334, 2343, 2342
2927, 2334, 2335, 2344, 2343
2928, 2335, 2336, 2345, 2344
2929, 2336, 2337, 2346, 2345
2930, 2337, 2338, 2347, 2346
2931, 2338, 2339, 2348, 2347
2932, 2339, 380, 381, 2348
2933, 355, 2340, 2349, 356
2934, 2340, 2341, 2350, 2349
2935, 2341, 2342, 2351, 2350
2936, 2342, 2343, 2352, 2351
2937, 2343, 2344, 2353, 2352
2938, 2344, 2345, 2354, 2353
2939, 2345, 2346, 2355, 2354
2940, 2346, 2347, 2356, 2355
2941, 2347, 2348, 2357, 2356
2942, 2348, 381, 382, 2357
2943, 356, 2349, 2358, 357
2944, 2349, 2350, 2359, 2358
2945, 2350, 2351, 2360, 2359
2946, 2351, 2352, 2361, 2360
2947, 2352, 2353, 2362, 2361
2948, 2353, 2354, 2363, 2362
2949, 2354, 2355, 2364, 2363
2950, 2355, 2356, 2365, 2364
2951, 2356, 2357, 2366, 2365
2952, 2357, 382, 383, 2366
2953, 357, 2358, 2367, 358
2954, 2358, 2359, 2368, 2367
2955, 2359, 2360, 2369, 2368
2956, 2360, 2361, 2370, 2369
2957, 2361, 2362, 2371, 2370
2958, 2362, 2363, 2372, 2371
2959, 2363, 2364, 2373, 2372
2960, 2364, 2365, 2374, 2373
2961, 2365, 2366, 2375, 2374
2962, 2366, 383, 384, 2375
2963, 358, 2367, 2376, 359
2964, 2367, 2368, 2377, 2376
2965, 2368, 2369, 2378, 2377
2966, 2369, 2370, 2379, 2378
2967, 2370, 2371, 2380, 2379
2968, 2371, 2372, 2381, 2380
2969, 2372, 2373, 2382, 2381
2970, 2373, 2374, 2383, 2382
2971, 2374, 2375, 2384, 2383
2972, 2375, 384, 385, 2384
2973, 359, 2376, 2385, 360
2974, 2376, 2377, 2386, 2385
2975, 2377, 2378, 2387, 2386
2976, 2378, 2379, 2388, 2387
2977, 2379, 2380, 2389, 2388
2978, 2380, 2381, 2390, 2389
2979, 2381, 2382, 2391, 2390
2980, 2382, 2383, 2392, 2391
2981, 2383, 2384, 2393, 2392
2982, 2384, 385, 386, 2393
2983, 360, 2385, 2394, 361
2984, 2385, 2386, 2395, 2394
2985, 2386, 2387, 2396, 2395
2986, 2387, 2388, 2397, 2396
2987, 2388, 2389, 2398, 2397
2988, 2389, 2390, 2399, 2398
2989, 2390, 2391, 2400, 2399
2990, 2391, 2392, 2401, 2400
2991, 2392, 2393, 2402, 2401
2992, 2393, 386, 387, 2402
2993, 361, 2394, 365, 21
2994, 2394, 2395, 366, 365
2995, 2395, 2396, 367, 366
2996, 2396, 2397, 368, 367
2997, 2397, 2398, 369, 368
2998, 2398, 2399, 370, 369
2999, 2399, 2400, 371, 370
3000, 2400, 2401, 372, 371
3001, 2401, 2402, 373, 372
3002, 2402, 387, 23, 373
*ELEMENT, type=CPS4, ELSET=Surface27
3003, 19, 397, 2403, 362
3004, 397, 398, 2404, 2403
3005, 398, 399, 2405, 2404
3006, 399, 400, 2406, 2405
3007, 400, 401, 2407, 2406
3008, 401, 402, 2408, 2407
3009, 402, 25, 409, 2408
3010, 362, 2403, 2409, 363
3011, 2403, 2404, 2410, 2409
3012, 2404, 2405, 2411, 2410
3013, 2405, 2406, 2412, 2411
3014, 2406, 2407, 2413, 2412
3015, 2407, 2408, 2414, 2413
3016, 2408, 409, 410, 2414
3017, 363, 2409, 2415, 364
3018, 2409, 2410, 2416, 2415
3019, 2410, 2411, 2417, 2416
3020, 2411, 2412, 2418, 2417
3021, 2412, 2413, 2419, 2418
3022, 2413, 2414, 2420, 2419
3023, 2414, 410, 411, 2420
3024, 364, 2415, 403, 23
3025, 2415, 2416, 404, 403
3026, 2416, 2417, 405, 404
3027, 2417, 2418, 406, 405
3028, 2418, 2419, 407, 406
3029, 2419, 2420, 408, 407
3030, 2420, 411, 26, 408
*ELEMENT, type=CPS4, ELSET=Surface28
3031, 17, 345, 2421, 412
3032, 412, 2421, 2422, 413
3033, 413, 2422, 2423, 414
3034, 414, 2423, 2424, 415
3035, 415, 2424, 2425, 416
3036, 416, 2425, 2426, 417
3037, 417, 2426, 424, 27
3038, 345, 346, 2427, 2421
3039, 2421, 2427, 2428, 2422
3040, 2422, 2428, 2429, 2423
3041, 2423, 2429, 2430, 2424
3042, 2424, 2430, 2431, 2425
3043, 2425, 2431, 2432, 2426
3044, 2426, 2432, 425, 424
3045, 346, 347, 2433, 2427
3046, 2427, 2433, 2434, 2428
3047, 2428, 2434, 2435, 2429
3048, 2429, 2435, 2436, 2430
3049, 2430, 2436, 2437, 2431
3050, 2431, 2437, 2438, 2432
3051, 2432, 2438, 426, 425
3052, 347, 21, 418, 2433
3053, 2433, 418, 419, 2434
3054, 2434, 419, 420, 2435
3055, 2435, 420, 421, 2436
3056, 2436, 421, 422, 2437
3057, 2437, 422, 423, 2438
3058, 2438, 423, 28, 426
*ELEMENT, type=CPS4, ELSET=Surface29
3059, 17, 412, 2439, 316
3060, 412, 413, 2440, 2439
3061, 413, 414, 2441, 2440
3062, 414, 415, 2442, 2441
3063, 415, 416, 2443, 2442
3064, 416, 417, 2444, 2443
3065, 417, 27, 427, 2444
3066, 316, 2439, 2445, 317
3067, 2439, 2440, 2446, 2445
3068, 2440, 2441, 2447, 2446
3069, 2441, 2442, 2448, 2447
3070, 2442, 2443, 2449, 2448
3071, 2443, 2444, 2450, 2449
3072, 2444, 427, 428, 2450
3073, 317, 2445, 2451, 318
3074, 2445, 2446, 2452, 2451
3075, 2446, 2447, 2453, 2452
3076, 2447, 2448, 2454, 2453
3077, 2448, 2449, 2455, 2454
3078, 2449, 2450, 2456, 2455
3079, 2450, 428, 429, 2456
3080, 318, 2451, 2457, 319
3081, 2451, 2452, 2458, 2457
3082, 2452, 2453, 2459, 2458
3083, 2453, 2454, 2460, 2459
3084, 2454, 2455, 2461, 2460
3085, 2455, 2456, 2462, 2461
3086, 2456, 429, 430, 2462
3087, 319, 2457, 2463, 320
3088, 2457, 2458, 2464, 2463
3089, 2458, 2459, 2465, 2464
3090, 2459, 2460, 2466, 2465
3091, 2460, 2461, 2467, 2466
3092, 2461, 2462, 2468, 2467
3093, 2462, 430, 431, 2468
3094, 320, 2463, 2469, 321
3095, 2463, 2464, 2470, 2469
3096, 2464, 2465, 2471, 2470
3097, 2465, 2466, 2472, 2471
3098, 2466, 2467, 2473, 2472
3099, 2467, 2468, 2474, 2473
3100, 2468, 431, 432, 2474
3101, 321, 2469, 2475, 322
3102, 2469, 2470, 2476, 2475
3103, 2470, 2471, 2477, 2476
3104, 2471, 2472, 2478, 2477
3105, 2472, 2473, 2479, 2478
3106, 2473, 2474, 2480, 2479
3107, 2474, 432, 433, 2480
3108, 322, 2475, 2481, 323
3109, 2475, 2476, 2482, 2481
3110, 2476, 2477, 2483, 2482
3111, 2477, 2478, 2484, 2483
3112, 2478, 2479, 2485, 2484
3113, 2479, 2480, 2486, 2485
3114, 2480, 433, 434, 2486
3115, 323, 2481, 2487, 324
3116, 2481, 2482, 2488, 2487
3117, 2482, 2483, 2489, 2488
3118, 2483, 2484, 2490, 2489
3119, 2484, 2485, 2491, 2490
3120, 2485, 2486, 2492, 2491
3121, 2486, 434, 435, 2492
3122, 324, 2487, 397, 19
3123, 2487, 2488, 398, 397
3124, 2488, 2489, 399, 398
3125, 2489, 2490, 400, 399
3126, 2490, 2491, 401, 400
3127, 2491, 2492, 402, 401
3128, 2492, 435, 25, 402
*ELEMENT, type=CPS4, ELSET=Surface30
3129, 21, 365, 2493, 418
3130, 418, 2493, 2494, 419
3131, 419, 2494, 2495, 420
3132, 420, 2495, 2496, 421
3133, 421, 2496, 2497, 422
3134, 422, 2497, 2498, 423
3135, 423, 2498, 436, 28
3136, 365, 366, 2499, 2493
3137, 2493, 2499, 2500, 2494
3138, 2494, 2500, 2501, 2495
3139, 2495, 2501, 2502, 2496
3140, 2496, 2502, 2503, 2497
3141, 2497, 2503, 2504, 2498
3142, 2498, 2504, 437, 436
3143, 366, 367, 2505, 2499
3144, 2499, 2505, 2506, 2500
3145, 2500, 2506, 2507, 2501
3146, 2501, 2507, 2508, 2502
3147, 2502, 2508, 2509, 2503
3148, 2503, 2509, 2510, 2504
3149, 2504, 2510, 438, 437
3150, 367, 368, 2511, 2505
3151, 2505, 2511, 2512, 2506
3152, 2506, 2512, 2513, 2507
3153, 2507, 2513, 2514, 2508
3154, 2508, 2514, 2515, 2509
3155, 2509, 2515, 2516, 2510
3156, 2510, 2516, 439, 438
3157, 368, 369, 2517, 2511
3158, 2511, 2517, 2518, 2512
3159, 2512, 2518, 2519, 2513
3160, 2513, 2519, 2520, 2514
3161, 2514, 2520, 2521, 2515
3162, 2515, 2521, 2522, 2516
3163, 2516, 2522, 440, 439
3164, 369, 370, 2523, 2517
3165, 2517, 2523, 2524, 2518
3166, 2518, 2524, 2525, 2519
3167, 2519, 2525, 2526, 2520
3168, 2520, 2526, 2527, 2521
3169, 2521, 2527, 2528, 2522
3170, 2522, 2528, 441, 440
3171, 370, 371, 2529, 2523
3172, 2523, 2529, 2530, 2524
3173, 2524, 2530, 2531, 2525
3174, 2525, 2531, 2532, 2526
3175, 2526, 2532, 2533, 2527
3176, 2527, 2533, 2534, 2528
3177, 2528, 2534, 442, 441
3178, 371, 372, 2535, 2529
3179, 2529, 2535, 2536, 2530
3180, 2530, 2536, 2537, 2531
3181, 2531, 2537, 2538, 2532
3182, 2532, 2538, 2539, 2533
3183, 2533, 2539, 2540, 2534
3184, 2534, 2540, 443, 442
3185, 372, 373, 2541, 2535
3186, 2535, 2541, 2542, 2536
3187, 2536, 2542, 2543, 2537
3188, 2537, 2543, 2544, 2538
3189, 2538, 2544, 2545, 2539
3190, 2539, 2545, 2546, 2540
3191, 2540, 2546, 444, 443
3192, 373, 23, 403, 2541
3193, 2541, 403, 404, 2542
3194, 2542, 404, 405, 2543
3195, 2543, 405, 406, 2544
3196, 2544, 406, 407, 2545
3197, 2545, 407, 408, 2546
3198, 2546, 408, 26, 444
*ELEMENT, type=CPS4, ELSET=Surface31
3199, 27, 424, 2547, 427
3200, 424, 425, 2548, 2547
3201, 425, 426, 2549, 2548
3202, 426, 28, 436, 2549
3203, 427, 2547, 2550, 428
3204, 2547, 2548, 2551, 2550
3205, 2548, 2549, 2552, 2551
3206, 2549, 436, 437, 2552
3207, 428, 2550, 2553, 429
3208, 2550, 2551, 2554, 2553
3209, 2551, 2552, 2555, 2554
3210, 2552, 437, 438, 2555
3211, 429, 2553, 2556, 430
3212, 2553, 2554, 2557, 2556
3213, 2554, 2555, 2558, 2557
3214, 2555, 438, 439, 2558
3215, 430, 2556, 2559, 431
3216, 2556, 2557, 2560, 2559
3217, 2557, 2558, 2561, 2560
3218, 2558, 439, 440, 2561
3219, 431, 2559, 2562, 432
3220, 2559, 2560, 2563, 2562
3221, 2560, 2561, 2564, 2563
3222, 2561, 440, 441, 2564
3223, 432, 2562, 2565, 433
3224, 2562, 2563, 2566, 2565
3225, 2563, 2564, 2567, 2566
3226, 2564, 441, 442, 2567
3227, 433, 2565, 2568, 434
3228, 2565, 2566, 2569, 2568
3229, 2566, 2567, 2570, 2569
3230, 2567, 442, 443, 2570
3231, 434, 2568, 2571, 435
3232, 2568, 2569, 2572, 2571
3233, 2569, 2570, 2573, 2572
3234, 2570, 443, 444, 2573
3235, 435, 2571, 409, 25
3236, 2571, 2572, 410, 409
3237, 2572, 2573, 411, 410
3238, 2573, 444, 26, 411
*ELEMENT, type=CPS4, ELSET=Surface32
3239, 25, 445, 2574, 409
3240, 445, 446, 2575, 2574
3241, 446, 447, 2576, 2575
3242, 447, 448, 2577, 2576
3243, 448, 449, 2578, 2577
3244, 449, 450, 2579, 2578
3245, 450, 451, 2580, 2579
3246, 451, 452, 2581, 2580
3247, 452, 453, 2582, 2581
3248, 453, 454, 2583, 2582
3249, 454, 455, 2584, 2583
3250, 455, 29, 467, 2584
3251, 409, 2574, 2585, 410
3252, 2574, 2575, 2586, 2585
3253, 2575, 2576, 2587, 2586
3254, 2576, 2577, 2588, 2587
3255, 2577, 2578, 2589, 2588
3256, 2578, 2579, 2590, 2589
3257, 2579, 2580, 2591, 2590
3258, 2580, 2581, 2592, 2591
3259, 2581, 2582, 2593, 2592
3260, 2582, 2583, 2594, 2593
3261, 2583, 2584, 2595, 2594
3262, 2584, 467, 468, 2595
3263, 410, 2585, 2596, 411
3264, 2585, 2586, 2597, 2596
3265, 2586, 2587, 2598, 2597
3266, 2587, 2588, 2599, 2598
3267, 2588, 2589, 2600, 2599
3268, 2589, 2590, 2601, 2600
3269, 2590, 2591, 2602, 2601
3270, 2591, 2592, 2603, 2602
3271, 2592, 2593, 2604, 2603
3272, 2593, 2594, 2605, 2604
3273, 2594, 2595, 2606, 2605
3274, 2595, 468, 469, 2606
3275, 411, 2596, 456, 26
3276, 2596, 2597, 457, 456
3277, 2597, 2598, 458, 457
3278, 2598, 2599, 459, 458
3279, 2599, 2600, 460, 459
3280, 2600, 2601, 461, 460
3281, 2601, 2602, 462, 461
3282, 2602, 2603, 463, 462
3283, 2603, 2604, 464, 463
3284, 2604, 2605, 465, 464
3285, 2605, 2606, 466, 465
3286, 2606, 469, 30, 466
*ELEMENT, type=CPS4, ELSET=Surface33
3287, 27, 424, 2607, 470
3288, 470, 2607, 2608, 471
3289, 471, 2608, 2609, 472
3290, 472, 2609, 2610, 473
3291, 473, 2610, 2611, 474
3292, 474, 2611, 2612, 475
3293, 475, 2612, 2613, 476
3294, 476, 2613, 2614, 477
3295, 477, 2614, 2615, 478
3296, 478, 2615, 2616, 479
3297, 479, 2616, 2617, 480
3298, 480, 2617, 492, 31
3299, 424, 425, 2618, 2607
3300, 2607, 2618, 2619, 2608
3301, 2608, 2619, 2620, 2609
3302, 2609, 2620, 2621, 2610
3303, 2610, 2621, 2622, 2611
3304, 2611, 2622, 2623, 2612
3305, 2612, 2623, 2624, 2613
3306, 2613, 2624, 2625, 2614
3307, 2614, 2625, 2626, 2615
3308, 2615, 2626, 2627, 2616
3309, 2616, 2627, 2628, 2617
3310, 2617, 2628, 493, 492
3311, 425, 426, 2629, 2618
3312, 2618, 2629, 2630, 2619
3313, 2619, 2630, 2631, 2620
3314, 2620, 2631, 2632, 2621
3315, 2621, 2632, 2633, 2622
3316, 2622, 2633, 2634, 2623
3317, 2623, 2634, 2635, 2624
3318, 2624, 2635, 2636, 2625
3319, 2625, 2636, 2637, 2626
3320, 2626, 2637, 2638, 2627
3321, 2627, 2638, 2639, 2628
3322, 2628, 2639, 494, 493
3323, 426, 28, 481, 2629
3324, 2629, 481, 482, 2630
3325, 2630, 482, 483, 2631
3326, 2631, 483, 484, 2632
3327, 2632, 484, 485, 2633
3328, 2633, 485, 486, 2634
3329, 2634, 486, 487, 2635
3330, 2635, 487, 488, 2636
3331, 2636, 488, 489, 2637
3332, 2637, 489, 490, 2638
3333, 2638, 490, 491, 2639
3334, 2639, 491, 32, 494
*ELEMENT, type=CPS4, ELSET=Surface34
3335, 27, 470, 2640, 427
3336, 470, 471, 2641, 2640
3337, 471, 472, 2642, 2641
3338, 472, 473, 2643, 2642
3339, 473, 474, 2644, 2643
3340, 474, 475, 2645, 2644
3341, 475, 476, 2646, 2645
3342, 476, 477, 2647, 2646
3343, 477, 478, 2648, 2647
3344, 478, 479, 2649, 2648
3345, 479, 480, 2650, 2649
3346, 480, 31, 495, 2650
3347, 427, 2640, 2651, 428
3348, 2640, 2641, 2652, 2651
3349, 2641, 2642, 2653, 2652
3350, 2642, 2643, 2654, 2653
3351, 2643, 2644, 2655, 2654
3352, 2644, 2645, 2656, 2655
3353, 2645, 2646, 2657, 2656
3354, 2646, 2647, 2658, 2657
3355, 2647, 2648, 2659, 2658
3356, 2648, 2649, 2660, 2659
3357, 2649, 2650, 2661, 2660
3358, 2650, 495, 496, 2661
3359, 428, 2651, 2662, 429
3360, 2651, 2652, 2663, 2662
3361, 2652, 2653, 2664, 2663
3362, 2653, 2654, 2665, 2664
3363, 2654, 2655, 2666, 2665
3364, 2655, 2656, 2667, 2666
3365, 2656, 2657, 2668, 2667
3366, 2657, 2658, 2669, 2668
3367, 2658, 2659, 2670, 2669
3368, 2659, 2660, 2671, 2670
3369, 2660, 2661, 2672, 2671
3370, 2661, 496, 497, 2672
3371, 429, 2662, 2673, 430
3372, 2662, 2663, 2674, 2673
3373, 2663, 2664, 2675, 2674
3374, 2664, 2665, 2676, 2675
3375, 2665, 2666, 2677, 2676
3376, 2666, 2667, 2678, 2677
3377, 2667, 2668, 2679, 2678
3378, 2668, 2669, 2680, 2679
3379, 2669, 2670, 2681, 2680
3380, 2670, 2671, 2682, 2681
3381, 2671, 2672, 2683, 2682
3382, 2672, 497, 498, 2683
3383, 430, 2673, 2684, 431
3384, 2673, 2674, 2685, 2684
3385, 2674, 2675, 2686, 2685
3386, 2675, 2676, 2687, 2686
3387, 2676, 2677, 2688, 2687
3388, 2677, 2678, 2689, 2688
3389, 2678, 2679, 2690, 2689
3390, 2679, 2680, 2691, 2690
3391, 2680, 2681, 2692, 2691
3392, 2681, 2682, 2693, 2692
3393, 2682, 2683, 2694, 2693
3394, 2683, 498, 499, 2694
3395, 431, 2684, 2695, 432
3396, 2684, 2685, 2696, 2695
3397, 2685, 2686, 2697, 2696
3398, 2686, 2687, 2698, 2697
3399, 2687, 2688, 2699, 2698
3400, 2688, 2689, 2700, 2699
3401, 2689, 2690, 2701, 2700
3402, 2690, 2691, 2702, 2701
3403, 2691, 2692, 2703, 2702
3404, 2692, 2693, 2704, 2703
3405, 2693, 2694, 2705, 2704
3406, 2694, 499, 500, 2705
3407, 432, 2695, 2706, 433
3408, 2695, 2696, 2707, 2706
3409, 2696, 2697, 2708, 2707
3410, 2697, 2698, 2709, 2708
3411, 2698, 2699, 2710, 2709
3412, 2699, 2700, 2711, 2710
3413, 2700, 2701, 2712, 2711
3414, 2701, 2702, 2713, 2712
3415, 2702, 2703, 2714, 2713
3416, 2703, 2704, 2715, 2714
3417, 2704, 2705, 2716, 2715
3418, 2705, 500, 501, 2716
3419, 433, 2706, 2717, 434
3420, 2706, 2707, 2718, 2717
3421, 2707, 2708, 2719, 2718
3422, 2708, 2709, 2720, 2719
3423, 2709, 2710, 2721, 2720
3424, 2710, 2711, 2722, 2721
3425, 2711, 2712, 2723, 2722
3426, 2712, 2713, 2724, 2723
3427, 2713, 2714, 2725, 2724
3428, 2714, 2715, 2726, 2725
3429, 2715, 2716, 2727, 2726
3430, 2716, 501, 502, 2727
3431, 434, 2717, 2728, 435
3432, 2717, 2718, 2729, 2728
3433, 2718, 2719, 2730, 2729
3434, 2719, 2720, 2731, 2730
3435, 2720, 2721, 2732, 2731
3436, 2721, 2722, 2733, 2732
3437, 2722, 2723, 2734, 2733
3438, 2723, 2724, 2735, 2734
3439, 2724, 2725, 2736, 2735
3440, 2725, 2726, 2737, 2736
3441, 2726, 2727, 2738, 2737
3442, 2727, 502, 503, 2738
3443, 435, 2728, 445, 25
3444, 2728, 2729, 446, 445
3445, 2729, 2730, 447, 446
3446, 2730, 2731, 448, 447
3447, 2731, 2732, 449, 448
3448, 2732, 2733, 450, 449
3449, 2733, 2734, 451, 450
3450, 2734, 2735, 452, 451
3451, 2735, 2736, 453, 452
3452, 2736, 2737, 454, 453
3453, 2737, 2738, 455, 454
3454, 2738, 503, 29, 455
*ELEMENT, type=CPS4, ELSET=Surface35
3455, 28, 436, 2739, 481
3456, 481, 2739, 2740, 482
3457, 482, 2740, 2741, 483
3458, 483, 2741, 2742, 484
3459, 484, 2742, 2743, 485
3460, 485, 2743, 2744, 486
3461, 486, 2744, 2745, 487
3462, 487, 2745, 2746, 488
3463, 488, 2746, 2747, 489
3464, 489, 2747, 2748, 490
3465, 490, 2748, 2749, 491
3466, 491, 2749, 504, 32
3467, 436, 437, 2750, 2739
3468, 2739, 2750, 2751, 2740
3469, 2740, 2751, 2752, 2741
3470, 2741, 2752, 2753, 2742
3471, 2742, 2753, 2754, 2743
3472, 2743, 2754, 2755, 2744
3473, 2744, 2755, 2756, 2745
3474, 2745, 2756, 2757, 2746
3475, 2746, 2757, 2758, 2747
3476, 2747, 2758, 2759, 2748
3477, 2748, 2759, 2760, 2749
3478, 2749, 2760, 505, 504
3479, 437, 438, 2761, 2750
3480, 2750, 2761, 2762, 2751
3481, 2751, 2762, 2763, 2752
3482, 2752, 2763, 2764, 2753
3483, 2753, 2764, 2765, 2754
3484, 2754, 2765, 2766, 2755
3485, 2755, 2766, 2767, 2756
3486, 2756, 2767, 2768, 2757
3487, 2757, 2768, 2769, 2758
3488, 2758, 2769, 2770, 2759
3489, 2759, 2770, 2771, 2760
3490, 2760, 2771, 506, 505
3491, 438, 439, 2772, 2761
3492, 2761, 2772, 2773, 2762
3493, 2762, 2773, 2774, 2763
3494, 2763, 2774, 2775, 2764
3495, 2764, 2775, 2776, 2765
3496, 2765, 2776, 2777, 2766
3497, 2766, 2777, 2778, 2767
3498, 2767, 2778, 2779, 2768
3499, 2768, 2779, 2780, 2769
3500, 2769, 2780, 2781, 2770
3501, 2770, 2781, 2782, 2771
3502, 2771, 2782, 507, 506
3503, 439, 440, 2783, 2772
3504, 2772, 2783, 2784, 2773
3505, 2773, 2784, 2785, 2774
3506, 2774, 2785, 2786, 2775
3507, 2775, 2786, 2787, 2776
3508, 2776, 2787, 2788, 2777
3509, 2777, 2788, 2789, 2778
3510, 2778, 2789, 2790, 2779
3511, 2779, 2790, 2791, 2780
3512, 2780, 2791, 2792, 2781
3513, 2781, 2792, 2793, 2782
3514, 2782, 2793, 508, 507
3515, 440, 441, 2794, 2783
3516, 2783, 2794, 2795, 2784
3517, 2784, 2795, 2796, 2785
3518, 2785, 2796, 2797, 2786
3519, 2786, 2797, 2798, 2787
3520, 2787, 2798, 2799, 2788
3521, 2788, 2799, 2800, 2789
3522, 2789, 2800, 2801, 2790
3523, 2790, 2801, 2802, 2791
3524, 2791, 2802, 2803, 2792
3525, 2792, 2803, 2804, 2793
3526, 2793, 2804, 509, 508
3527, 441, 442, 2805, 2794
3528, 2794, 2805, 2806, 2795
3529, 2795, 2806, 2807, 2796
3530, 2796, 2807, 2808, 2797
3531, 2797, 2808, 2809, 2798
3532, 2798, 2809, 2810, 2799
3533, 2799, 2810, 2811, 2800
3534, 2800, 2811, 2812, 2801
3535, 2801, 2812, 2813, 2802
3536, 2802, 2813, 2814, 2803
3537, 2803, 2814, 2815, 2804
3538, 2804, 2815, 510, 509
3539, 442, 443, 2816, 2805
3540, 2805, 2816, 2817, 2806
3541, 2806, 2817, 2818, 2807
3542, 2807, 2818, 2819, 2808
3543, 2808, 2819, 2820, 2809
3544, 2809, 2820, 2821, 2810
3545, 2810, 2821, 2822, 2811
3546, 2811, 2822, 2823, 2812
3547, 2812, 2823, 2824, 2813
3548, 2813, 2824, 2825, 2814
3549, 2814, 2825, 2826, 2815
3550, 2815, 2826, 511, 510
3551, 443, 444, 2827, 2816
3552, 2816, 2827, 2828, 2817
3553, 2817, 2828, 2829, 2818
3554, 2818, 2829, 2830, 2819
3555, 2819, 2830, 2831, 2820
3556, 2820, 2831, 2832, 2821
3557, 2821, 2832, 2833, 2822
3558, 2822, 2833, 2834, 2823
3559, 2823, 2834, 2835, 2824
3560, 2824, 2835, 2836, 2825
3561, 2825, 2836, 2837, 2826
3562, 2826, 2837, 512, 511
3563, 444, 26, 456, 2827
3564, 2827, 456, 457, 2828
3565, 2828, 457, 458, 2829
3566, 2829, 458, 459, 2830
3567, 2830, 459, 460, 2831
3568, 2831, 460, 461, 2832
3569, 2832, 461, 462, 2833
3570, 2833, 462, 463, 2834
3571, 2834, 463, 464, 2835
3572, 2835, 464, 465, 2836
3573, 2836, 465, 466, 2837
3574, 2837, 466, 30, 512
*ELEMENT, type=CPS4, ELSET=Surface36
3575, 31, 492, 2838, 495
3576, 492, 493, 2839, 2838
3577, 493, 494, 2840, 2839
3578, 494, 32, 504, 2840
3579, 495, 2838, 2841, 496
3580, 2838, 2839, 2842, 2841
3581, 2839, 2840, 2843, 2842
3582, 2840, 504, 505, 2843
3583, 496, 2841, 2844, 497
3584, 2841, 2842, 2845, 2844
3585, 2842, 2843, 2846, 2845
3586, 2843, 505, 506, 2846
3587, 497, 2844, 2847, 498
3588, 2844, 2845, 2848, 2847
3589, 2845, 2846, 2849, 2848
3590, 2846, 506, 507, 2849
3591, 498, 2847, 2850, 499
3592, 2847, 2848, 2851, 2850
3593, 2848, 2849, 2852, 2851
3594, 2849, 507, 508, 2852
3595, 499, 2850, 2853, 500
3596, 2850, 2851, 2854, 2853
3597, 2851, 2852, 2855, 2854
3598, 2852, 508, 509, 2855
3599, 500, 2853, 2856, 501
3600, 2853, 2854, 2857, 2856
3601, 2854, 2855, 2858, 2857
3602, 2855, 509, 510, 2858
3603, 501, 2856, 2859, 502
3604, 2856, 2857, 2860, 2859
3605, 2857, 2858, 2861, 2860
3606, 2858, 510, 511, 2861
3607, 502, 2859, 2862, 503
3608, 2859, 2860, 2863, 2862
3609, 2860, 2861, 2864, 2863
3610, 2861, 511, 512, 2864
3611, 503, 2862, 467, 29
3612, 2862, 2863, 468, 467
3613, 2863, 2864, 469, 468
3614, 2864, 512, 30, 469
*ELEMENT, type=CPS4, ELSET=Surface37
3615, 25, 33, 513, 445
3616, 445, 513, 514, 446
3617, 446, 514, 515, 447
3618, 447, 515, 516, 448
3619, 448, 516, 517, 449
3620, 449, 517, 518, 450
3621, 450, 518, 519, 451
3622, 451, 519, 520, 452
3623, 452, 520, 521, 453
3624, 453, 521, 522, 454
3625, 454, 522, 523, 455
3626, 455, 523, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
3627, 27, 470, 524, 35
3628, 470, 471, 525, 524
3629, 471, 472, 526, 525
3630, 472, 473, 527, 526
3631, 473, 474, 528, 527
3632, 474, 475, 529, 528
3633, 475, 476, 530, 529
3634, 476, 477, 531, 530
3635, 477, 478, 532, 531
3636, 478, 479, 533, 532
3637, 479, 480, 534, 533
3638, 480, 31, 36, 534
*ELEMENT, type=CPS4, ELSET=Surface39
3639, 27, 35, 535, 427
3640, 427, 535, 536, 428
3641, 428, 536, 537, 429
3642, 429, 537, 538, 430
3643, 430, 538, 539, 431
3644, 431, 539, 540, 432
3645, 432, 540, 541, 433
3646, 433, 541, 542, 434
3647, 434, 542, 543, 435
3648, 435, 543, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
3649, 31, 495, 544, 36
3650, 495, 496, 545, 544
3651, 496, 497, 546, 545
3652, 497, 498, 547, 546
3653, 498, 499, 548, 547
3654, 499, 500, 549, 548
3655, 500, 501, 550, 549
3656, 501, 502, 551, 550
3657, 502, 503, 552, 551
3658, 503, 29, 34, 552
*ELEMENT, type=CPS4, ELSET=Surface41
3659, 35, 524, 2865, 535
3660, 524, 525, 2866, 2865
3661, 525, 526, 2867, 2866
3662, 526, 527, 2868, 2867
3663, 527, 528, 2869, 2868
3664, 528, 529, 2870, 2869
3665, 529, 530, 2871, 2870
3666, 530, 531, 2872, 2871
3667, 531, 532, 2873, 2872
3668, 532, 533, 2874, 2873
3669, 533, 534, 2875, 2874
3670, 534, 36, 544, 2875
3671, 535, 2865, 2876, 536
3672, 2865, 2866, 2877, 2876
3673, 2866, 2867, 2878, 2877
3674, 2867, 2868, 2879, 2878
3675, 2868, 2869, 2880, 2879
3676, 2869, 2870, 2881, 2880
3677, 2870, 2871, 2882, 2881
3678, 2871, 2872, 2883, 2882
3679, 2872, 2873, 2884, 2883
3680, 2873, 2874, 2885, 2884
3681, 2874, 2875, 2886, 2885
3682, 2875, 544, 545, 2886
3683, 536, 2876, 2887, 537
3684, 2876, 2877, 2888, 2887
3685, 2877, 2878, 2889, 2888
3686, 2878, 2879, 2890, 2889
3687, 2879, 2880, 2891, 2890
3688, 2880, 2881, 2892, 2891
3689, 2881, 2882, 2893, 2892
3690, 2882, 2883, 2894, 2893
3691, 2883, 2884, 2895, 2894
3692, 2884, 2885, 2896, 2895
3693, 2885, 2886, 2897, 2896
3694, 2886, 545, 546, 2897
3695, 537, 2887, 2898, 538
3696, 2887, 2888, 2899, 2898
3697, 2888, 2889, 2900, 2899
3698, 2889, 2890, 2901, 2900
3699, 2890, 2891, 2902, 2901
3700, 2891, 2892, 2903, 2902
3701, 2892, 2893, 2904, 2903
3702, 2893, 2894, 2905, 2904
3703, 2894, 2895, 2906, 2905
3704, 2895, 2896, 2907, 2906
3705, 2896, 2897, 2908, 2907
3706, 2897, 546, 547, 2908
3707, 538, 2898, 2909, 539
3708, 2898, 2899, 2910, 2909
3709, 2899, 2900, 2911, 2910
3710, 2900, 2901, 2912, 2911
3711, 2901, 2902, 2913, 2912
3712, 2902, 2903, 2914, 2913
3713, 2903, 2904, 2915, 2914
3714, 2904, 2905, 2916, 2915
3715, 2905, 2906, 2917, 2916
3716, 2906, 2907, 2918, 2917
3717, 2907, 2908, 2919, 2918
3718, 2908, 547, 548, 2919
3719, 539, 2909, 2920, 540
3720, 2909, 2910, 2921, 2920
3721, 2910, 2911, 2922, 2921
3722, 2911, 2912, 2923, 2922
3723, 2912, 2913, 2924, 2923
3724, 2913, 2914, 2925, 2924
3725, 2914, 2915, 2926, 2925
3726, 2915, 2916, 2927, 2926
3727, 2916, 2917, 2928, 2927
3728, 2917, 2918, 2929, 2928
3729, 2918, 2919, 2930, 2929
3730, 2919, 548, 549, 2930
3731, 540, 2920, 2931, 541
3732, 2920, 2921, 2932, 2931
3733, 2921, 2922, 2933, 2932
3734, 2922, 2923, 2934, 2933
3735, 2923, 2924, 2935, 2934
3736, 2924, 2925, 2936, 2935
3737, 2925, 2926, 2937, 2936
3738, 2926, 2927, 2938, 2937
3739, 2927, 2928, 2939, 2938
3740, 2928, 2929, 2940, 2939
3741, 2929, 2930, 2941, 2940
3742, 2930, 549, 550, 2941
3743, 541, 2931, 2942, 542
3744, 2931, 2932, 2943, 2942
3745, 2932, 2933, 2944, 2943
3746, 2933, 2934, 2945, 2944
3747, 2934, 2935, 2946, 2945
3748, 2935, 2936, 2947, 2946
3749, 2936, 2937, 2948, 2947
3750, 2937, 2938, 2949, 2948
3751, 2938, 2939, 2950, 2949
3752, 2939, 2940, 2951, 2950
3753, 2940, 2941, 2952, 2951
3754, 2941, 550, 551, 2952
3755, 542, 2942, 2953, 543
3756, 2942, 2943, 2954, 2953
3757, 2943, 2944, 2955, 2954
3758, 2944, 2945, 2956, 2955
3759, 2945, 2946, 2957, 2956
3760, 2946, 2947, 2958, 2957
3761, 2947, 2948, 2959, 2958
3762, 2948, 2949, 2960, 2959
3763, 2949, 2950, 2961, 2960
3764, 2950, 2951, 2962, 2961
3765, 2951, 2952, 2963, 2962
3766, 2952, 551, 552, 2963
3767, 543, 2953, 513, 33
3768, 2953, 2954, 514, 513
3769, 2954, 2955, 515, 514
3770, 2955, 2956, 516, 515
3771, 2956, 2957, 517, 516
3772, 2957, 2958, 518, 517
3773, 2958, 2959, 519, 518
3774, 2959, 2960, 520, 519
3775, 2960, 2961, 521, 520
3776, 2961, 2962, 522, 521
3777, 2962, 2963, 523, 522
3778, 2963, 552, 34, 523
*ELEMENT, type=CPS4, ELSET=Surface42
3779, 33, 553, 2964, 513
3780, 553, 554, 2965, 2964
3781, 554, 555, 2966, 2965
3782, 555, 556, 2967, 2966
3783, 556, 557, 2968, 2967
3784, 557, 558, 2969, 2968
3785, 558, 559, 2970, 2969
3786, 559, 560, 2971, 2970
3787, 560, 561, 2972, 2971
3788, 561, 37, 571, 2972
3789, 513, 2964, 2973, 514
3790, 2964, 2965, 2974, 2973
3791, 2965, 2966, 2975, 2974
3792, 2966, 2967, 2976, 2975
3793, 2967, 2968, 2977, 2976
3794, 2968, 2969, 2978, 2977
3795, 2969, 2970, 2979, 2978
3796, 2970, 2971, 2980, 2979
3797, 2971, 2972, 2981, 2980
3798, 2972, 571, 572, 2981
3799, 514, 2973, 2982, 515
3800, 2973, 2974, 2983, 2982
3801, 2974, 2975, 2984, 2983
3802, 2975, 2976, 2985, 2984
3803, 2976, 2977, 2986, 2985
3804, 2977, 2978, 2987, 2986
3805, 2978, 2979, 2988, 2987
3806, 2979, 2980, 2989, 2988
3807, 2980, 2981, 2990, 2989
3808, 2981, 572, 573, 2990
3809, 515, 2982, 2991, 516
3810, 2982, 2983, 2992, 2991
3811, 2983, 2984, 2993, 2992
3812, 2984, 2985, 2994, 2993
3813, 2985, 2986, 2995, 2994
3814, 2986, 2987, 2996, 2995
3815, 2987, 2988, 2997, 2996
3816, 2988, 2989, 2998, 2997
3817, 2989, 2990, 2999, 2998
3818, 2990, 573, 574, 2999
3819, 516, 2991, 3000, 517
3820, 2991, 2992, 3001, 3000
3821, 2992, 2993, 3002, 3001
3822, 2993, 2994, 3003, 3002
3823, 2994, 2995, 3004, 3003
3824, 2995, 2996, 3005, 3004
3825, 2996, 2997, 3006, 3005
3826, 2997, 2998, 3007, 3006
3827, 2998, 2999, 3008, 3007
3828, 2999, 574, 575, 3008
3829, 517, 3000, 3009, 518
3830, 3000, 3001, 3010, 3009
3831, 3001, 3002, 3011, 3010
3832, 3002, 3003, 3012, 3011
3833, 3003, 3004, 3013, 3012
3834, 3004, 3005, 3014, 3013
3835, 3005, 3006, 3015, 3014
3836, 3006, 3007, 3016, 3015
3837, 3007, 3008, 3017, 3016
3838, 3008, 575, 576, 3017
3839, 518, 3009, 3018, 519
3840, 3009, 3010, 3019, 3018
3841, 3010, 3011, 3020, 3019
3842, 3011, 3012, 3021, 3020
3843, 3012, 3013, 3022, 3021
3844, 3013, 3014, 3023, 3022
3845, 3014, 3015, 3024, 3023
3846, 3015, 3016, 3025, 3024
3847, 3016, 3017, 3026, 3025
3848, 3017, 576, 577, 3026
3849, 519, 3018, 3027, 520
3850, 3018, 3019, 3028, 3027
3851, 3019, 3020, 3029, 3028
3852, 3020, 3021, 3030, 3029
3853, 3021, 3022, 3031, 3030
3854, 3022, 3023, 3032, 3031
3855, 3023, 3024, 3033, 3032
3856, 3024, 3025, 3034, 3033
3857, 3025, 3026, 3035, 3034
3858, 3026, 577, 578, 3035
3859, 520, 3027, 3036, 521
3860, 3027, 3028, 3037, 3036
3861, 3028, 3029, 3038, 3037
3862, 3029, 3030, 3039, 3038
3863, 3030, 3031, 3040, 3039
3864, 3031, 3032, 3041, 3040
3865, 3032, 3033, 3042, 3041
3866, 3033, 3034, 3043, 3042
3867, 3034, 3035, 3044, 3043
3868, 3035, 578, 579, 3044
3869, 521, 3036, 3045, 522
3870, 3036, 3037, 3046, 3045
3871, 3037, 3038, 3047, 3046
3872, 3038, 3039, 3048, 3047
3873, 3039, 3040, 3049, 3048
3874, 3040, 3041, 3050, 3049
3875, 3041, 3042, 3051, 3050
3876, 3042, 3043, 3052, 3051
3877, 3043, 3044, 3053, 3052
3878, 3044, 579, 580, 3053
3879, 522, 3045, 3054, 523
3880, 3045, 3046, 3055, 3054
3881, 3046, 3047, 3056, 3055
3882, 3047, 3048, 3057, 3056
3883, 3048, 3049, 3058, 3057
3884, 3049, 3050, 3059, 3058
3885, 3050, 3051, 3060, 3059
3886, 3051, 3052, 3061, 3060
3887, 3052, 3053, 3062, 3061
3888, 3053, 580, 581, 3062
3889, 523, 3054, 562, 34
3890, 3054, 3055, 563, 562
3891, 3055, 3056, 564, 563
3892, 3056, 3057, 565, 564
3893, 3057, 3058, 566, 565
3894, 3058, 3059, 567, 566
3895, 3059, 3060, 568, 567
3896, 3060, 3061, 569, 568
3897, 3061, 3062, 570, 569
3898, 3062, 581, 38, 570
*ELEMENT, type=CPS4, ELSET=Surface43
3899, 35, 524, 3063, 582
3900, 582, 3063, 3064, 583
3901, 583, 3064, 3065, 584
3902, 584, 3065, 3066, 585
3903, 585, 3066, 3067, 586
3904, 586, 3067, 3068, 587
3905, 587, 3068, 3069, 588
3906, 588, 3069, 3070, 589
3907, 589, 3070, 3071, 590
3908, 590, 3071, 600, 39
3909, 524, 525, 3072, 3063
3910, 3063, 3072, 3073, 3064
3911, 3064, 3073, 3074, 3065
3912, 3065, 3074, 3075, 3066
3913, 3066, 3075, 3076, 3067
3914, 3067, 3076, 3077, 3068
3915, 3068, 3077, 3078, 3069
3916, 3069, 3078, 3079, 3070
3917, 3070, 3079, 3080, 3071
3918, 3071, 3080, 601, 600
3919, 525, 526, 3081, 3072
3920, 3072, 3081, 3082, 3073
3921, 3073, 3082, 3083, 3074
3922, 3074, 3083, 3084, 3075
3923, 3075, 3084, 3085, 3076
3924, 3076, 3085, 3086, 3077
3925, 3077, 3086, 3087, 3078
3926, 3078, 3087, 3088, 3079
3927, 3079, 3088, 3089, 3080
3928, 3080, 3089, 602, 601
3929, 526, 527, 3090, 3081
3930, 3081, 3090, 3091, 3082
3931, 3082, 3091, 3092, 3083
3932, 3083, 3092, 3093, 3084
3933, 3084, 3093, 3094, 3085
3934, 3085, 3094, 3095, 3086
3935, 3086, 3095, 3096, 3087
3936, 3087, 3096, 3097, 3088
3937, 3088, 3097, 3098, 3089
3938, 3089, 3098, 603, 602
