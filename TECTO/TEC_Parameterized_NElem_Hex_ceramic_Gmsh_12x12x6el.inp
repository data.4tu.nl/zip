7692, 5046, 5057, 5178, 5167, 5047, 5058, 5179, 5168
7693, 5047, 5058, 5179, 5168, 5048, 5059, 5180, 5169
7694, 5048, 5059, 5180, 5169, 5049, 5060, 5181, 5170
7695, 5049, 5060, 5181, 5170, 5050, 5061, 5182, 5171
7696, 5050, 5061, 5182, 5171, 5051, 5062, 5183, 5172
7697, 5051, 5062, 5183, 5172, 5052, 5063, 5184, 5173
7698, 5052, 5063, 5184, 5173, 5053, 5064, 5185, 5174
7699, 5053, 5064, 5185, 5174, 5054, 5065, 5186, 5175
7700, 5054, 5065, 5186, 5175, 5055, 5066, 5187, 5176
7701, 5055, 5066, 5187, 5176, 5056, 5067, 5188, 5177
7702, 5056, 5067, 5188, 5177, 2506, 2507, 2518, 2517
7703, 2100, 2101, 2112, 2111, 5057, 5068, 5189, 5178
7704, 5057, 5068, 5189, 5178, 5058, 5069, 5190, 5179
7705, 5058, 5069, 5190, 5179, 5059, 5070, 5191, 5180
7706, 5059, 5070, 5191, 5180, 5060, 5071, 5192, 5181
7707, 5060, 5071, 5192, 5181, 5061, 5072, 5193, 5182
7708, 5061, 5072, 5193, 5182, 5062, 5073, 5194, 5183
7709, 5062, 5073, 5194, 5183, 5063, 5074, 5195, 5184
7710, 5063, 5074, 5195, 5184, 5064, 5075, 5196, 5185
7711, 5064, 5075, 5196, 5185, 5065, 5076, 5197, 5186
7712, 5065, 5076, 5197, 5186, 5066, 5077, 5198, 5187
7713, 5066, 5077, 5198, 5187, 5067, 5078, 5199, 5188
7714, 5067, 5078, 5199, 5188, 2507, 2508, 2519, 2518
7715, 2101, 2102, 2113, 2112, 5068, 5079, 5200, 5189
7716, 5068, 5079, 5200, 5189, 5069, 5080, 5201, 5190
7717, 5069, 5080, 5201, 5190, 5070, 5081, 5202, 5191
7718, 5070, 5081, 5202, 5191, 5071, 5082, 5203, 5192
7719, 5071, 5082, 5203, 5192, 5072, 5083, 5204, 5193
7720, 5072, 5083, 5204, 5193, 5073, 5084, 5205, 5194
7721, 5073, 5084, 5205, 5194, 5074, 5085, 5206, 5195
7722, 5074, 5085, 5206, 5195, 5075, 5086, 5207, 5196
7723, 5075, 5086, 5207, 5196, 5076, 5087, 5208, 5197
7724, 5076, 5087, 5208, 5197, 5077, 5088, 5209, 5198
7725, 5077, 5088, 5209, 5198, 5078, 5089, 5210, 5199
7726, 5078, 5089, 5210, 5199, 2508, 2509, 2520, 2519
7727, 2102, 2103, 2114, 2113, 5079, 5090, 5211, 5200
7728, 5079, 5090, 5211, 5200, 5080, 5091, 5212, 5201
7729, 5080, 5091, 5212, 5201, 5081, 5092, 5213, 5202
7730, 5081, 5092, 5213, 5202, 5082, 5093, 5214, 5203
7731, 5082, 5093, 5214, 5203, 5083, 5094, 5215, 5204
7732, 5083, 5094, 5215, 5204, 5084, 5095, 5216, 5205
7733, 5084, 5095, 5216, 5205, 5085, 5096, 5217, 5206
7734, 5085, 5096, 5217, 5206, 5086, 5097, 5218, 5207
7735, 5086, 5097, 5218, 5207, 5087, 5098, 5219, 5208
7736, 5087, 5098, 5219, 5208, 5088, 5099, 5220, 5209
7737, 5088, 5099, 5220, 5209, 5089, 5100, 5221, 5210
7738, 5089, 5100, 5221, 5210, 2509, 2510, 2521, 2520
7739, 2103, 2104, 2115, 2114, 5090, 5101, 5222, 5211
7740, 5090, 5101, 5222, 5211, 5091, 5102, 5223, 5212
7741, 5091, 5102, 5223, 5212, 5092, 5103, 5224, 5213
7742, 5092, 5103, 5224, 5213, 5093, 5104, 5225, 5214
7743, 5093, 5104, 5225, 5214, 5094, 5105, 5226, 5215
7744, 5094, 5105, 5226, 5215, 5095, 5106, 5227, 5216
7745, 5095, 5106, 5227, 5216, 5096, 5107, 5228, 5217
7746, 5096, 5107, 5228, 5217, 5097, 5108, 5229, 5218
7747, 5097, 5108, 5229, 5218, 5098, 5109, 5230, 5219
7748, 5098, 5109, 5230, 5219, 5099, 5110, 5231, 5220
7749, 5099, 5110, 5231, 5220, 5100, 5111, 5232, 5221
7750, 5100, 5111, 5232, 5221, 2510, 2511, 2522, 2521
7751, 2104, 2105, 2116, 2115, 5101, 5112, 5233, 5222
7752, 5101, 5112, 5233, 5222, 5102, 5113, 5234, 5223
7753, 5102, 5113, 5234, 5223, 5103, 5114, 5235, 5224
7754, 5103, 5114, 5235, 5224, 5104, 5115, 5236, 5225
7755, 5104, 5115, 5236, 5225, 5105, 5116, 5237, 5226
7756, 5105, 5116, 5237, 5226, 5106, 5117, 5238, 5227
7757, 5106, 5117, 5238, 5227, 5107, 5118, 5239, 5228
7758, 5107, 5118, 5239, 5228, 5108, 5119, 5240, 5229
7759, 5108, 5119, 5240, 5229, 5109, 5120, 5241, 5230
7760, 5109, 5120, 5241, 5230, 5110, 5121, 5242, 5231
7761, 5110, 5121, 5242, 5231, 5111, 5122, 5243, 5232
7762, 5111, 5122, 5243, 5232, 2511, 2512, 2523, 2522
7763, 2105, 2106, 2117, 2116, 5112, 5123, 5244, 5233
7764, 5112, 5123, 5244, 5233, 5113, 5124, 5245, 5234
7765, 5113, 5124, 5245, 5234, 5114, 5125, 5246, 5235
7766, 5114, 5125, 5246, 5235, 5115, 5126, 5247, 5236
7767, 5115, 5126, 5247, 5236, 5116, 5127, 5248, 5237
7768, 5116, 5127, 5248, 5237, 5117, 5128, 5249, 5238
7769, 5117, 5128, 5249, 5238, 5118, 5129, 5250, 5239
7770, 5118, 5129, 5250, 5239, 5119, 5130, 5251, 5240
7771, 5119, 5130, 5251, 5240, 5120, 5131, 5252, 5241
7772, 5120, 5131, 5252, 5241, 5121, 5132, 5253, 5242
7773, 5121, 5132, 5253, 5242, 5122, 5133, 5254, 5243
7774, 5122, 5133, 5254, 5243, 2512, 2513, 2524, 2523
7775, 2106, 465, 466, 2117, 5123, 2448, 2459, 5244
7776, 5123, 2448, 2459, 5244, 5124, 2449, 2460, 5245
7777, 5124, 2449, 2460, 5245, 5125, 2450, 2461, 5246
7778, 5125, 2450, 2461, 5246, 5126, 2451, 2462, 5247
7779, 5126, 2451, 2462, 5247, 5127, 2452, 2463, 5248
7780, 5127, 2452, 2463, 5248, 5128, 2453, 2464, 5249
7781, 5128, 2453, 2464, 5249, 5129, 2454, 2465, 5250
7782, 5129, 2454, 2465, 5250, 5130, 2455, 2466, 5251
7783, 5130, 2455, 2466, 5251, 5131, 2456, 2467, 5252
7784, 5131, 2456, 2467, 5252, 5132, 2457, 2468, 5253
7785, 5132, 2457, 2468, 5253, 5133, 2458, 2469, 5254
7786, 5133, 2458, 2469, 5254, 2513, 541, 542, 2524
7787, 461, 2107, 2118, 462, 2404, 5134, 5255, 2415
7788, 2404, 5134, 5255, 2415, 2405, 5135, 5256, 2416
7789, 2405, 5135, 5256, 2416, 2406, 5136, 5257, 2417
7790, 2406, 5136, 5257, 2417, 2407, 5137, 5258, 2418
7791, 2407, 5137, 5258, 2418, 2408, 5138, 5259, 2419
7792, 2408, 5138, 5259, 2419, 2409, 5139, 5260, 2420
7793, 2409, 5139, 5260, 2420, 2410, 5140, 5261, 2421
7794, 2410, 5140, 5261, 2421, 2411, 5141, 5262, 2422
7795, 2411, 5141, 5262, 2422, 2412, 5142, 5263, 2423
7796, 2412, 5142, 5263, 2423, 2413, 5143, 5264, 2424
7797, 2413, 5143, 5264, 2424, 2414, 5144, 5265, 2425
7798, 2414, 5144, 5265, 2425, 537, 2514, 2525, 538
7799, 2107, 2108, 2119, 2118, 5134, 5145, 5266, 5255
7800, 5134, 5145, 5266, 5255, 5135, 5146, 5267, 5256
7801, 5135, 5146, 5267, 5256, 5136, 5147, 5268, 5257
7802, 5136, 5147, 5268, 5257, 5137, 5148, 5269, 5258
7803, 5137, 5148, 5269, 5258, 5138, 5149, 5270, 5259
7804, 5138, 5149, 5270, 5259, 5139, 5150, 5271, 5260
7805, 5139, 5150, 5271, 5260, 5140, 5151, 5272, 5261
7806, 5140, 5151, 5272, 5261, 5141, 5152, 5273, 5262
7807, 5141, 5152, 5273, 5262, 5142, 5153, 5274, 5263
7808, 5142, 5153, 5274, 5263, 5143, 5154, 5275, 5264
7809, 5143, 5154, 5275, 5264, 5144, 5155, 5276, 5265
7810, 5144, 5155, 5276, 5265, 2514, 2515, 2526, 2525
7811, 2108, 2109, 2120, 2119, 5145, 5156, 5277, 5266
7812, 5145, 5156, 5277, 5266, 5146, 5157, 5278, 5267
7813, 5146, 5157, 5278, 5267, 5147, 5158, 5279, 5268
7814, 5147, 5158, 5279, 5268, 5148, 5159, 5280, 5269
7815, 5148, 5159, 5280, 5269, 5149, 5160, 5281, 5270
7816, 5149, 5160, 5281, 5270, 5150, 5161, 5282, 5271
7817, 5150, 5161, 5282, 5271, 5151, 5162, 5283, 5272
7818, 5151, 5162, 5283, 5272, 5152, 5163, 5284, 5273
7819, 5152, 5163, 5284, 5273, 5153, 5164, 5285, 5274
7820, 5153, 5164, 5285, 5274, 5154, 5165, 5286, 5275
7821, 5154, 5165, 5286, 5275, 5155, 5166, 5287, 5276
7822, 5155, 5166, 5287, 5276, 2515, 2516, 2527, 2526
7823, 2109, 2110, 2121, 2120, 5156, 5167, 5288, 5277
7824, 5156, 5167, 5288, 5277, 5157, 5168, 5289, 5278
7825, 5157, 5168, 5289, 5278, 5158, 5169, 5290, 5279
7826, 5158, 5169, 5290, 5279, 5159, 5170, 5291, 5280
7827, 5159, 5170, 5291, 5280, 5160, 5171, 5292, 5281
7828, 5160, 5171, 5292, 5281, 5161, 5172, 5293, 5282
7829, 5161, 5172, 5293, 5282, 5162, 5173, 5294, 5283
7830, 5162, 5173, 5294, 5283, 5163, 5174, 5295, 5284
7831, 5163, 5174, 5295, 5284, 5164, 5175, 5296, 5285
7832, 5164, 5175, 5296, 5285, 5165, 5176, 5297, 5286
7833, 5165, 5176, 5297, 5286, 5166, 5177, 5298, 5287
7834, 5166, 5177, 5298, 5287, 2516, 2517, 2528, 2527
7835, 2110, 2111, 2122, 2121, 5167, 5178, 5299, 5288
7836, 5167, 5178, 5299, 5288, 5168, 5179, 5300, 5289
7837, 5168, 5179, 5300, 5289, 5169, 5180, 5301, 5290
7838, 5169, 5180, 5301, 5290, 5170, 5181, 5302, 5291
7839, 5170, 5181, 5302, 5291, 5171, 5182, 5303, 5292
7840, 5171, 5182, 5303, 5292, 5172, 5183, 5304, 5293
7841, 5172, 5183, 5304, 5293, 5173, 5184, 5305, 5294
7842, 5173, 5184, 5305, 5294, 5174, 5185, 5306, 5295
7843, 5174, 5185, 5306, 5295, 5175, 5186, 5307, 5296
7844, 5175, 5186, 5307, 5296, 5176, 5187, 5308, 5297
7845, 5176, 5187, 5308, 5297, 5177, 5188, 5309, 5298
7846, 5177, 5188, 5309, 5298, 2517, 2518, 2529, 2528
7847, 2111, 2112, 2123, 2122, 5178, 5189, 5310, 5299
7848, 5178, 5189, 5310, 5299, 5179, 5190, 5311, 5300
7849, 5179, 5190, 5311, 5300, 5180, 5191, 5312, 5301
7850, 5180, 5191, 5312, 5301, 5181, 5192, 5313, 5302
7851, 5181, 5192, 5313, 5302, 5182, 5193, 5314, 5303
7852, 5182, 5193, 5314, 5303, 5183, 5194, 5315, 5304
7853, 5183, 5194, 5315, 5304, 5184, 5195, 5316, 5305
7854, 5184, 5195, 5316, 5305, 5185, 5196, 5317, 5306
7855, 5185, 5196, 5317, 5306, 5186, 5197, 5318, 5307
7856, 5186, 5197, 5318, 5307, 5187, 5198, 5319, 5308
7857, 5187, 5198, 5319, 5308, 5188, 5199, 5320, 5309
7858, 5188, 5199, 5320, 5309, 2518, 2519, 2530, 2529
7859, 2112, 2113, 2124, 2123, 5189, 5200, 5321, 5310
7860, 5189, 5200, 5321, 5310, 5190, 5201, 5322, 5311
7861, 5190, 5201, 5322, 5311, 5191, 5202, 5323, 5312
7862, 5191, 5202, 5323, 5312, 5192, 5203, 5324, 5313
7863, 5192, 5203, 5324, 5313, 5193, 5204, 5325, 5314
7864, 5193, 5204, 5325, 5314, 5194, 5205, 5326, 5315
7865, 5194, 5205, 5326, 5315, 5195, 5206, 5327, 5316
7866, 5195, 5206, 5327, 5316, 5196, 5207, 5328, 5317
7867, 5196, 5207, 5328, 5317, 5197, 5208, 5329, 5318
7868, 5197, 5208, 5329, 5318, 5198, 5209, 5330, 5319
7869, 5198, 5209, 5330, 5319, 5199, 5210, 5331, 5320
7870, 5199, 5210, 5331, 5320, 2519, 2520, 2531, 2530
7871, 2113, 2114, 2125, 2124, 5200, 5211, 5332, 5321
7872, 5200, 5211, 5332, 5321, 5201, 5212, 5333, 5322
7873, 5201, 5212, 5333, 5322, 5202, 5213, 5334, 5323
7874, 5202, 5213, 5334, 5323, 5203, 5214, 5335, 5324
7875, 5203, 5214, 5335, 5324, 5204, 5215, 5336, 5325
7876, 5204, 5215, 5336, 5325, 5205, 5216, 5337, 5326
7877, 5205, 5216, 5337, 5326, 5206, 5217, 5338, 5327
7878, 5206, 5217, 5338, 5327, 5207, 5218, 5339, 5328
7879, 5207, 5218, 5339, 5328, 5208, 5219, 5340, 5329
7880, 5208, 5219, 5340, 5329, 5209, 5220, 5341, 5330
7881, 5209, 5220, 5341, 5330, 5210, 5221, 5342, 5331
7882, 5210, 5221, 5342, 5331, 2520, 2521, 2532, 2531
7883, 2114, 2115, 2126, 2125, 5211, 5222, 5343, 5332
7884, 5211, 5222, 5343, 5332, 5212, 5223, 5344, 5333
7885, 5212, 5223, 5344, 5333, 5213, 5224, 5345, 5334
7886, 5213, 5224, 5345, 5334, 5214, 5225, 5346, 5335
7887, 5214, 5225, 5346, 5335, 5215, 5226, 5347, 5336
7888, 5215, 5226, 5347, 5336, 5216, 5227, 5348, 5337
7889, 5216, 5227, 5348, 5337, 5217, 5228, 5349, 5338
7890, 5217, 5228, 5349, 5338, 5218, 5229, 5350, 5339
7891, 5218, 5229, 5350, 5339, 5219, 5230, 5351, 5340
7892, 5219, 5230, 5351, 5340, 5220, 5231, 5352, 5341
7893, 5220, 5231, 5352, 5341, 5221, 5232, 5353, 5342
7894, 5221, 5232, 5353, 5342, 2521, 2522, 2533, 2532
7895, 2115, 2116, 2127, 2126, 5222, 5233, 5354, 5343
7896, 5222, 5233, 5354, 5343, 5223, 5234, 5355, 5344
7897, 5223, 5234, 5355, 5344, 5224, 5235, 5356, 5345
7898, 5224, 5235, 5356, 5345, 5225, 5236, 5357, 5346
7899, 5225, 5236, 5357, 5346, 5226, 5237, 5358, 5347
7900, 5226, 5237, 5358, 5347, 5227, 5238, 5359, 5348
7901, 5227, 5238, 5359, 5348, 5228, 5239, 5360, 5349
7902, 5228, 5239, 5360, 5349, 5229, 5240, 5361, 5350
7903, 5229, 5240, 5361, 5350, 5230, 5241, 5362, 5351
7904, 5230, 5241, 5362, 5351, 5231, 5242, 5363, 5352
7905, 5231, 5242, 5363, 5352, 5232, 5243, 5364, 5353
7906, 5232, 5243, 5364, 5353, 2522, 2523, 2534, 2533
7907, 2116, 2117, 2128, 2127, 5233, 5244, 5365, 5354
7908, 5233, 5244, 5365, 5354, 5234, 5245, 5366, 5355
7909, 5234, 5245, 5366, 5355, 5235, 5246, 5367, 5356
7910, 5235, 5246, 5367, 5356, 5236, 5247, 5368, 5357
7911, 5236, 5247, 5368, 5357, 5237, 5248, 5369, 5358
7912, 5237, 5248, 5369, 5358, 5238, 5249, 5370, 5359
7913, 5238, 5249, 5370, 5359, 5239, 5250, 5371, 5360
7914, 5239, 5250, 5371, 5360, 5240, 5251, 5372, 5361
7915, 5240, 5251, 5372, 5361, 5241, 5252, 5373, 5362
7916, 5241, 5252, 5373, 5362, 5242, 5253, 5374, 5363
7917, 5242, 5253, 5374, 5363, 5243, 5254, 5375, 5364
7918, 5243, 5254, 5375, 5364, 2523, 2524, 2535, 2534
7919, 2117, 466, 467, 2128, 5244, 2459, 2470, 5365
7920, 5244, 2459, 2470, 5365, 5245, 2460, 2471, 5366
7921, 5245, 2460, 2471, 5366, 5246, 2461, 2472, 5367
7922, 5246, 2461, 2472, 5367, 5247, 2462, 2473, 5368
7923, 5247, 2462, 2473, 5368, 5248, 2463, 2474, 5369
7924, 5248, 2463, 2474, 5369, 5249, 2464, 2475, 5370
7925, 5249, 2464, 2475, 5370, 5250, 2465, 2476, 5371
7926, 5250, 2465, 2476, 5371, 5251, 2466, 2477, 5372
7927, 5251, 2466, 2477, 5372, 5252, 2467, 2478, 5373
7928, 5252, 2467, 2478, 5373, 5253, 2468, 2479, 5374
7929, 5253, 2468, 2479, 5374, 5254, 2469, 2480, 5375
7930, 5254, 2469, 2480, 5375, 2524, 542, 543, 2535
7931, 462, 2118, 2129, 463, 2415, 5255, 5376, 2426
7932, 2415, 5255, 5376, 2426, 2416, 5256, 5377, 2427
7933, 2416, 5256, 5377, 2427, 2417, 5257, 5378, 2428
7934, 2417, 5257, 5378, 2428, 2418, 5258, 5379, 2429
7935, 2418, 5258, 5379, 2429, 2419, 5259, 5380, 2430
7936, 2419, 5259, 5380, 2430, 2420, 5260, 5381, 2431
7937, 2420, 5260, 5381, 2431, 2421, 5261, 5382, 2432
7938, 2421, 5261, 5382, 2432, 2422, 5262, 5383, 2433
7939, 2422, 5262, 5383, 2433, 2423, 5263, 5384, 2434
7940, 2423, 5263, 5384, 2434, 2424, 5264, 5385, 2435
7941, 2424, 5264, 5385, 2435, 2425, 5265, 5386, 2436
7942, 2425, 5265, 5386, 2436, 538, 2525, 2536, 539
7943, 2118, 2119, 2130, 2129, 5255, 5266, 5387, 5376
7944, 5255, 5266, 5387, 5376, 5256, 5267, 5388, 5377
7945, 5256, 5267, 5388, 5377, 5257, 5268, 5389, 5378
7946, 5257, 5268, 5389, 5378, 5258, 5269, 5390, 5379
7947, 5258, 5269, 5390, 5379, 5259, 5270, 5391, 5380
7948, 5259, 5270, 5391, 5380, 5260, 5271, 5392, 5381
7949, 5260, 5271, 5392, 5381, 5261, 5272, 5393, 5382
7950, 5261, 5272, 5393, 5382, 5262, 5273, 5394, 5383
7951, 5262, 5273, 5394, 5383, 5263, 5274, 5395, 5384
7952, 5263, 5274, 5395, 5384, 5264, 5275, 5396, 5385
7953, 5264, 5275, 5396, 5385, 5265, 5276, 5397, 5386
7954, 5265, 5276, 5397, 5386, 2525, 2526, 2537, 2536
7955, 2119, 2120, 2131, 2130, 5266, 5277, 5398, 5387
7956, 5266, 5277, 5398, 5387, 5267, 5278, 5399, 5388
7957, 5267, 5278, 5399, 5388, 5268, 5279, 5400, 5389
7958, 5268, 5279, 5400, 5389, 5269, 5280, 5401, 5390
7959, 5269, 5280, 5401, 5390, 5270, 5281, 5402, 5391
7960, 5270, 5281, 5402, 5391, 5271, 5282, 5403, 5392
7961, 5271, 5282, 5403, 5392, 5272, 5283, 5404, 5393
7962, 5272, 5283, 5404, 5393, 5273, 5284, 5405, 5394
7963, 5273, 5284, 5405, 5394, 5274, 5285, 5406, 5395
7964, 5274, 5285, 5406, 5395, 5275, 5286, 5407, 5396
7965, 5275, 5286, 5407, 5396, 5276, 5287, 5408, 5397
7966, 5276, 5287, 5408, 5397, 2526, 2527, 2538, 2537
7967, 2120, 2121, 2132, 2131, 5277, 5288, 5409, 5398
7968, 5277, 5288, 5409, 5398, 5278, 5289, 5410, 5399
7969, 5278, 5289, 5410, 5399, 5279, 5290, 5411, 5400
7970, 5279, 5290, 5411, 5400, 5280, 5291, 5412, 5401
7971, 5280, 5291, 5412, 5401, 5281, 5292, 5413, 5402
7972, 5281, 5292, 5413, 5402, 5282, 5293, 5414, 5403
7973, 5282, 5293, 5414, 5403, 5283, 5294, 5415, 5404
7974, 5283, 5294, 5415, 5404, 5284, 5295, 5416, 5405
7975, 5284, 5295, 5416, 5405, 5285, 5296, 5417, 5406
7976, 5285, 5296, 5417, 5406, 5286, 5297, 5418, 5407
7977, 5286, 5297, 5418, 5407, 5287, 5298, 5419, 5408
7978, 5287, 5298, 5419, 5408, 2527, 2528, 2539, 2538
7979, 2121, 2122, 2133, 2132, 5288, 5299, 5420, 5409
7980, 5288, 5299, 5420, 5409, 5289, 5300, 5421, 5410
7981, 5289, 5300, 5421, 5410, 5290, 5301, 5422, 5411
7982, 5290, 5301, 5422, 5411, 5291, 5302, 5423, 5412
7983, 5291, 5302, 5423, 5412, 5292, 5303, 5424, 5413
7984, 5292, 5303, 5424, 5413, 5293, 5304, 5425, 5414
7985, 5293, 5304, 5425, 5414, 5294, 5305, 5426, 5415
7986, 5294, 5305, 5426, 5415, 5295, 5306, 5427, 5416
7987, 5295, 5306, 5427, 5416, 5296, 5307, 5428, 5417
7988, 5296, 5307, 5428, 5417, 5297, 5308, 5429, 5418
7989, 5297, 5308, 5429, 5418, 5298, 5309, 5430, 5419
7990, 5298, 5309, 5430, 5419, 2528, 2529, 2540, 2539
7991, 2122, 2123, 2134, 2133, 5299, 5310, 5431, 5420
7992, 5299, 5310, 5431, 5420, 5300, 5311, 5432, 5421
7993, 5300, 5311, 5432, 5421, 5301, 5312, 5433, 5422
7994, 5301, 5312, 5433, 5422, 5302, 5313, 5434, 5423
7995, 5302, 5313, 5434, 5423, 5303, 5314, 5435, 5424
7996, 5303, 5314, 5435, 5424, 5304, 5315, 5436, 5425
7997, 5304, 5315, 5436, 5425, 5305, 5316, 5437, 5426
7998, 5305, 5316, 5437, 5426, 5306, 5317, 5438, 5427
7999, 5306, 5317, 5438, 5427, 5307, 5318, 5439, 5428
8000, 5307, 5318, 5439, 5428, 5308, 5319, 5440, 5429
8001, 5308, 5319, 5440, 5429, 5309, 5320, 5441, 5430
8002, 5309, 5320, 5441, 5430, 2529, 2530, 2541, 2540
8003, 2123, 2124, 2135, 2134, 5310, 5321, 5442, 5431
8004, 5310, 5321, 5442, 5431, 5311, 5322, 5443, 5432
8005, 5311, 5322, 5443, 5432, 5312, 5323, 5444, 5433
8006, 5312, 5323, 5444, 5433, 5313, 5324, 5445, 5434
8007, 5313, 5324, 5445, 5434, 5314, 5325, 5446, 5435
8008, 5314, 5325, 5446, 5435, 5315, 5326, 5447, 5436
8009, 5315, 5326, 5447, 5436, 5316, 5327, 5448, 5437
8010, 5316, 5327, 5448, 5437, 5317, 5328, 5449, 5438
8011, 5317, 5328, 5449, 5438, 5318, 5329, 5450, 5439
8012, 5318, 5329, 5450, 5439, 5319, 5330, 5451, 5440
8013, 5319, 5330, 5451, 5440, 5320, 5331, 5452, 5441
8014, 5320, 5331, 5452, 5441, 2530, 2531, 2542, 2541
8015, 2124, 2125, 2136, 2135, 5321, 5332, 5453, 5442
8016, 5321, 5332, 5453, 5442, 5322, 5333, 5454, 5443
8017, 5322, 5333, 5454, 5443, 5323, 5334, 5455, 5444
8018, 5323, 5334, 5455, 5444, 5324, 5335, 5456, 5445
8019, 5324, 5335, 5456, 5445, 5325, 5336, 5457, 5446
8020, 5325, 5336, 5457, 5446, 5326, 5337, 5458, 5447
8021, 5326, 5337, 5458, 5447, 5327, 5338, 5459, 5448
8022, 5327, 5338, 5459, 5448, 5328, 5339, 5460, 5449
8023, 5328, 5339, 5460, 5449, 5329, 5340, 5461, 5450
8024, 5329, 5340, 5461, 5450, 5330, 5341, 5462, 5451
8025, 5330, 5341, 5462, 5451, 5331, 5342, 5463, 5452
8026, 5331, 5342, 5463, 5452, 2531, 2532, 2543, 2542
8027, 2125, 2126, 2137, 2136, 5332, 5343, 5464, 5453
8028, 5332, 5343, 5464, 5453, 5333, 5344, 5465, 5454
8029, 5333, 5344, 5465, 5454, 5334, 5345, 5466, 5455
8030, 5334, 5345, 5466, 5455, 5335, 5346, 5467, 5456
8031, 5335, 5346, 5467, 5456, 5336, 5347, 5468, 5457
8032, 5336, 5347, 5468, 5457, 5337, 5348, 5469, 5458
8033, 5337, 5348, 5469, 5458, 5338, 5349, 5470, 5459
8034, 5338, 5349, 5470, 5459, 5339, 5350, 5471, 5460
8035, 5339, 5350, 5471, 5460, 5340, 5351, 5472, 5461
8036, 5340, 5351, 5472, 5461, 5341, 5352, 5473, 5462
8037, 5341, 5352, 5473, 5462, 5342, 5353, 5474, 5463
8038, 5342, 5353, 5474, 5463, 2532, 2533, 2544, 2543
8039, 2126, 2127, 2138, 2137, 5343, 5354, 5475, 5464
8040, 5343, 5354, 5475, 5464, 5344, 5355, 5476, 5465
8041, 5344, 5355, 5476, 5465, 5345, 5356, 5477, 5466
8042, 5345, 5356, 5477, 5466, 5346, 5357, 5478, 5467
8043, 5346, 5357, 5478, 5467, 5347, 5358, 5479, 5468
8044, 5347, 5358, 5479, 5468, 5348, 5359, 5480, 5469
8045, 5348, 5359, 5480, 5469, 5349, 5360, 5481, 5470
8046, 5349, 5360, 5481, 5470, 5350, 5361, 5482, 5471
8047, 5350, 5361, 5482, 5471, 5351, 5362, 5483, 5472
8048, 5351, 5362, 5483, 5472, 5352, 5363, 5484, 5473
8049, 5352, 5363, 5484, 5473, 5353, 5364, 5485, 5474
8050, 5353, 5364, 5485, 5474, 2533, 2534, 2545, 2544
8051, 2127, 2128, 2139, 2138, 5354, 5365, 5486, 5475
8052, 5354, 5365, 5486, 5475, 5355, 5366, 5487, 5476
8053, 5355, 5366, 5487, 5476, 5356, 5367, 5488, 5477
8054, 5356, 5367, 5488, 5477, 5357, 5368, 5489, 5478
8055, 5357, 5368, 5489, 5478, 5358, 5369, 5490, 5479
8056, 5358, 5369, 5490, 5479, 5359, 5370, 5491, 5480
8057, 5359, 5370, 5491, 5480, 5360, 5371, 5492, 5481
8058, 5360, 5371, 5492, 5481, 5361, 5372, 5493, 5482
8059, 5361, 5372, 5493, 5482, 5362, 5373, 5494, 5483
8060, 5362, 5373, 5494, 5483, 5363, 5374, 5495, 5484
8061, 5363, 5374, 5495, 5484, 5364, 5375, 5496, 5485
8062, 5364, 5375, 5496, 5485, 2534, 2535, 2546, 2545
8063, 2128, 467, 468, 2139, 5365, 2470, 2481, 5486
8064, 5365, 2470, 2481, 5486, 5366, 2471, 2482, 5487
8065, 5366, 2471, 2482, 5487, 5367, 2472, 2483, 5488
8066, 5367, 2472, 2483, 5488, 5368, 2473, 2484, 5489
8067, 5368, 2473, 2484, 5489, 5369, 2474, 2485, 5490
8068, 5369, 2474, 2485, 5490, 5370, 2475, 2486, 5491
8069, 5370, 2475, 2486, 5491, 5371, 2476, 2487, 5492
8070, 5371, 2476, 2487, 5492, 5372, 2477, 2488, 5493
8071, 5372, 2477, 2488, 5493, 5373, 2478, 2489, 5494
8072, 5373, 2478, 2489, 5494, 5374, 2479, 2490, 5495
8073, 5374, 2479, 2490, 5495, 5375, 2480, 2491, 5496
8074, 5375, 2480, 2491, 5496, 2535, 543, 544, 2546
8075, 463, 2129, 437, 33, 2426, 5376, 2140, 469
8076, 2426, 5376, 2140, 469, 2427, 5377, 2141, 470
8077, 2427, 5377, 2141, 470, 2428, 5378, 2142, 471
8078, 2428, 5378, 2142, 471, 2429, 5379, 2143, 472
8079, 2429, 5379, 2143, 472, 2430, 5380, 2144, 473
8080, 2430, 5380, 2144, 473, 2431, 5381, 2145, 474
8081, 2431, 5381, 2145, 474, 2432, 5382, 2146, 475
8082, 2432, 5382, 2146, 475, 2433, 5383, 2147, 476
8083, 2433, 5383, 2147, 476, 2434, 5384, 2148, 477
8084, 2434, 5384, 2148, 477, 2435, 5385, 2149, 478
8085, 2435, 5385, 2149, 478, 2436, 5386, 2150, 479
8086, 2436, 5386, 2150, 479, 539, 2536, 491, 37
8087, 2129, 2130, 438, 437, 5376, 5387, 2151, 2140
8088, 5376, 5387, 2151, 2140, 5377, 5388, 2152, 2141
8089, 5377, 5388, 2152, 2141, 5378, 5389, 2153, 2142
8090, 5378, 5389, 2153, 2142, 5379, 5390, 2154, 2143
8091, 5379, 5390, 2154, 2143, 5380, 5391, 2155, 2144
8092, 5380, 5391, 2155, 2144, 5381, 5392, 2156, 2145
8093, 5381, 5392, 2156, 2145, 5382, 5393, 2157, 2146
8094, 5382, 5393, 2157, 2146, 5383, 5394, 2158, 2147
8095, 5383, 5394, 2158, 2147, 5384, 5395, 2159, 2148
8096, 5384, 5395, 2159, 2148, 5385, 5396, 2160, 2149
8097, 5385, 5396, 2160, 2149, 5386, 5397, 2161, 2150
8098, 5386, 5397, 2161, 2150, 2536, 2537, 492, 491
8099, 2130, 2131, 439, 438, 5387, 5398, 2162, 2151
8100, 5387, 5398, 2162, 2151, 5388, 5399, 2163, 2152
8101, 5388, 5399, 2163, 2152, 5389, 5400, 2164, 2153
8102, 5389, 5400, 2164, 2153, 5390, 5401, 2165, 2154
8103, 5390, 5401, 2165, 2154, 5391, 5402, 2166, 2155
8104, 5391, 5402, 2166, 2155, 5392, 5403, 2167, 2156
8105, 5392, 5403, 2167, 2156, 5393, 5404, 2168, 2157
8106, 5393, 5404, 2168, 2157, 5394, 5405, 2169, 2158
8107, 5394, 5405, 2169, 2158, 5395, 5406, 2170, 2159
8108, 5395, 5406, 2170, 2159, 5396, 5407, 2171, 2160
8109, 5396, 5407, 2171, 2160, 5397, 5408, 2172, 2161
8110, 5397, 5408, 2172, 2161, 2537, 2538, 493, 492
8111, 2131, 2132, 440, 439, 5398, 5409, 2173, 2162
8112, 5398, 5409, 2173, 2162, 5399, 5410, 2174, 2163
8113, 5399, 5410, 2174, 2163, 5400, 5411, 2175, 2164
8114, 5400, 5411, 2175, 2164, 5401, 5412, 2176, 2165
8115, 5401, 5412, 2176, 2165, 5402, 5413, 2177, 2166
8116, 5402, 5413, 2177, 2166, 5403, 5414, 2178, 2167
8117, 5403, 5414, 2178, 2167, 5404, 5415, 2179, 2168
8118, 5404, 5415, 2179, 2168, 5405, 5416, 2180, 2169
8119, 5405, 5416, 2180, 2169, 5406, 5417, 2181, 2170
8120, 5406, 5417, 2181, 2170, 5407, 5418, 2182, 2171
8121, 5407, 5418, 2182, 2171, 5408, 5419, 2183, 2172
8122, 5408, 5419, 2183, 2172, 2538, 2539, 494, 493
8123, 2132, 2133, 441, 440, 5409, 5420, 2184, 2173
8124, 5409, 5420, 2184, 2173, 5410, 5421, 2185, 2174
8125, 5410, 5421, 2185, 2174, 5411, 5422, 2186, 2175
8126, 5411, 5422, 2186, 2175, 5412, 5423, 2187, 2176
8127, 5412, 5423, 2187, 2176, 5413, 5424, 2188, 2177
8128, 5413, 5424, 2188, 2177, 5414, 5425, 2189, 2178
8129, 5414, 5425, 2189, 2178, 5415, 5426, 2190, 2179
8130, 5415, 5426, 2190, 2179, 5416, 5427, 2191, 2180
8131, 5416, 5427, 2191, 2180, 5417, 5428, 2192, 2181
8132, 5417, 5428, 2192, 2181, 5418, 5429, 2193, 2182
8133, 5418, 5429, 2193, 2182, 5419, 5430, 2194, 2183
8134, 5419, 5430, 2194, 2183, 2539, 2540, 495, 494
8135, 2133, 2134, 442, 441, 5420, 5431, 2195, 2184
8136, 5420, 5431, 2195, 2184, 5421, 5432, 2196, 2185
8137, 5421, 5432, 2196, 2185, 5422, 5433, 2197, 2186
8138, 5422, 5433, 2197, 2186, 5423, 5434, 2198, 2187
8139, 5423, 5434, 2198, 2187, 5424, 5435, 2199, 2188
8140, 5424, 5435, 2199, 2188, 5425, 5436, 2200, 2189
8141, 5425, 5436, 2200, 2189, 5426, 5437, 2201, 2190
8142, 5426, 5437, 2201, 2190, 5427, 5438, 2202, 2191
8143, 5427, 5438, 2202, 2191, 5428, 5439, 2203, 2192
8144, 5428, 5439, 2203, 2192, 5429, 5440, 2204, 2193
8145, 5429, 5440, 2204, 2193, 5430, 5441, 2205, 2194
8146, 5430, 5441, 2205, 2194, 2540, 2541, 496, 495
8147, 2134, 2135, 443, 442, 5431, 5442, 2206, 2195
8148, 5431, 5442, 2206, 2195, 5432, 5443, 2207, 2196
8149, 5432, 5443, 2207, 2196, 5433, 5444, 2208, 2197
8150, 5433, 5444, 2208, 2197, 5434, 5445, 2209, 2198
8151, 5434, 5445, 2209, 2198, 5435, 5446, 2210, 2199
8152, 5435, 5446, 2210, 2199, 5436, 5447, 2211, 2200
8153, 5436, 5447, 2211, 2200, 5437, 5448, 2212, 2201
8154, 5437, 5448, 2212, 2201, 5438, 5449, 2213, 2202
8155, 5438, 5449, 2213, 2202, 5439, 5450, 2214, 2203
8156, 5439, 5450, 2214, 2203, 5440, 5451, 2215, 2204
8157, 5440, 5451, 2215, 2204, 5441, 5452, 2216, 2205
8158, 5441, 5452, 2216, 2205, 2541, 2542, 497, 496
8159, 2135, 2136, 444, 443, 5442, 5453, 2217, 2206
8160, 5442, 5453, 2217, 2206, 5443, 5454, 2218, 2207
8161, 5443, 5454, 2218, 2207, 5444, 5455, 2219, 2208
8162, 5444, 5455, 2219, 2208, 5445, 5456, 2220, 2209
8163, 5445, 5456, 2220, 2209, 5446, 5457, 2221, 2210
8164, 5446, 5457, 2221, 2210, 5447, 5458, 2222, 2211
8165, 5447, 5458, 2222, 2211, 5448, 5459, 2223, 2212
8166, 5448, 5459, 2223, 2212, 5449, 5460, 2224, 2213
8167, 5449, 5460, 2224, 2213, 5450, 5461, 2225, 2214
8168, 5450, 5461, 2225, 2214, 5451, 5462, 2226, 2215
8169, 5451, 5462, 2226, 2215, 5452, 5463, 2227, 2216
8170, 5452, 5463, 2227, 2216, 2542, 2543, 498, 497
8171, 2136, 2137, 445, 444, 5453, 5464, 2228, 2217
8172, 5453, 5464, 2228, 2217, 5454, 5465, 2229, 2218
8173, 5454, 5465, 2229, 2218, 5455, 5466, 2230, 2219
8174, 5455, 5466, 2230, 2219, 5456, 5467, 2231, 2220
8175, 5456, 5467, 2231, 2220, 5457, 5468, 2232, 2221
8176, 5457, 5468, 2232, 2221, 5458, 5469, 2233, 2222
8177, 5458, 5469, 2233, 2222, 5459, 5470, 2234, 2223
8178, 5459, 5470, 2234, 2223, 5460, 5471, 2235, 2224
8179, 5460, 5471, 2235, 2224, 5461, 5472, 2236, 2225
8180, 5461, 5472, 2236, 2225, 5462, 5473, 2237, 2226
8181, 5462, 5473, 2237, 2226, 5463, 5474, 2238, 2227
8182, 5463, 5474, 2238, 2227, 2543, 2544, 499, 498
8183, 2137, 2138, 446, 445, 5464, 5475, 2239, 2228
8184, 5464, 5475, 2239, 2228, 5465, 5476, 2240, 2229
8185, 5465, 5476, 2240, 2229, 5466, 5477, 2241, 2230
8186, 5466, 5477, 2241, 2230, 5467, 5478, 2242, 2231
8187, 5467, 5478, 2242, 2231, 5468, 5479, 2243, 2232
8188, 5468, 5479, 2243, 2232, 5469, 5480, 2244, 2233
8189, 5469, 5480, 2244, 2233, 5470, 5481, 2245, 2234
8190, 5470, 5481, 2245, 2234, 5471, 5482, 2246, 2235
8191, 5471, 5482, 2246, 2235, 5472, 5483, 2247, 2236
8192, 5472, 5483, 2247, 2236, 5473, 5484, 2248, 2237
8193, 5473, 5484, 2248, 2237, 5474, 5485, 2249, 2238
8194, 5474, 5485, 2249, 2238, 2544, 2545, 500, 499
8195, 2138, 2139, 447, 446, 5475, 5486, 2250, 2239
8196, 5475, 5486, 2250, 2239, 5476, 5487, 2251, 2240
8197, 5476, 5487, 2251, 2240, 5477, 5488, 2252, 2241
8198, 5477, 5488, 2252, 2241, 5478, 5489, 2253, 2242
8199, 5478, 5489, 2253, 2242, 5479, 5490, 2254, 2243
8200, 5479, 5490, 2254, 2243, 5480, 5491, 2255, 2244
8201, 5480, 5491, 2255, 2244, 5481, 5492, 2256, 2245
8202, 5481, 5492, 2256, 2245, 5482, 5493, 2257, 2246
8203, 5482, 5493, 2257, 2246, 5483, 5494, 2258, 2247
8204, 5483, 5494, 2258, 2247, 5484, 5495, 2259, 2248
8205, 5484, 5495, 2259, 2248, 5485, 5496, 2260, 2249
8206, 5485, 5496, 2260, 2249, 2545, 2546, 501, 500
8207, 2139, 468, 34, 447, 5486, 2481, 480, 2250
8208, 5486, 2481, 480, 2250, 5487, 2482, 481, 2251
8209, 5487, 2482, 481, 2251, 5488, 2483, 482, 2252
8210, 5488, 2483, 482, 2252, 5489, 2484, 483, 2253
8211, 5489, 2484, 483, 2253, 5490, 2485, 484, 2254
8212, 5490, 2485, 484, 2254, 5491, 2486, 485, 2255
8213, 5491, 2486, 485, 2255, 5492, 2487, 486, 2256
8214, 5492, 2487, 486, 2256, 5493, 2488, 487, 2257
8215, 5493, 2488, 487, 2257, 5494, 2489, 488, 2258
8216, 5494, 2489, 488, 2258, 5495, 2490, 489, 2259
8217, 5495, 2490, 489, 2259, 5496, 2491, 490, 2260
8218, 5496, 2491, 490, 2260, 2546, 544, 38, 501
*ELEMENT, type=C3D8, ELSET=Volume10
8219, 39, 524, 2492, 535, 43, 556, 2547, 567
8220, 524, 525, 2493, 2492, 556, 557, 2548, 2547
8221, 525, 526, 2494, 2493, 557, 558, 2549, 2548
8222, 526, 527, 2495, 2494, 558, 559, 2550, 2549
8223, 527, 528, 2496, 2495, 559, 560, 2551, 2550
8224, 528, 529, 2497, 2496, 560, 561, 2552, 2551
8225, 529, 530, 2498, 2497, 561, 562, 2553, 2552
8226, 530, 531, 2499, 2498, 562, 563, 2554, 2553
8227, 531, 532, 2500, 2499, 563, 564, 2555, 2554
8228, 532, 533, 2501, 2500, 564, 565, 2556, 2555
8229, 533, 534, 2502, 2501, 565, 566, 2557, 2556
8230, 534, 40, 540, 2502, 566, 44, 572, 2557
8231, 535, 2492, 2503, 536, 567, 2547, 2558, 568
8232, 2492, 2493, 2504, 2503, 2547, 2548, 2559, 2558
8233, 2493, 2494, 2505, 2504, 2548, 2549, 2560, 2559
8234, 2494, 2495, 2506, 2505, 2549, 2550, 2561, 2560
8235, 2495, 2496, 2507, 2506, 2550, 2551, 2562, 2561
8236, 2496, 2497, 2508, 2507, 2551, 2552, 2563, 2562
8237, 2497, 2498, 2509, 2508, 2552, 2553, 2564, 2563
8238, 2498, 2499, 2510, 2509, 2553, 2554, 2565, 2564
8239, 2499, 2500, 2511, 2510, 2554, 2555, 2566, 2565
8240, 2500, 2501, 2512, 2511, 2555, 2556, 2567, 2566
8241, 2501, 2502, 2513, 2512, 2556, 2557, 2568, 2567
8242, 2502, 540, 541, 2513, 2557, 572, 573, 2568
8243, 536, 2503, 2514, 537, 568, 2558, 2569, 569
8244, 2503, 2504, 2515, 2514, 2558, 2559, 2570, 2569
8245, 2504, 2505, 2516, 2515, 2559, 2560, 2571, 2570
8246, 2505, 2506, 2517, 2516, 2560, 2561, 2572, 2571
8247, 2506, 2507, 2518, 2517, 2561, 2562, 2573, 2572
8248, 2507, 2508, 2519, 2518, 2562, 2563, 2574, 2573
8249, 2508, 2509, 2520, 2519, 2563, 2564, 2575, 2574
8250, 2509, 2510, 2521, 2520, 2564, 2565, 2576, 2575
8251, 2510, 2511, 2522, 2521, 2565, 2566, 2577, 2576
8252, 2511, 2512, 2523, 2522, 2566, 2567, 2578, 2577
8253, 2512, 2513, 2524, 2523, 2567, 2568, 2579, 2578
8254, 2513, 541, 542, 2524, 2568, 573, 574, 2579
8255, 537, 2514, 2525, 538, 569, 2569, 2580, 570
8256, 2514, 2515, 2526, 2525, 2569, 2570, 2581, 2580
8257, 2515, 2516, 2527, 2526, 2570, 2571, 2582, 2581
8258, 2516, 2517, 2528, 2527, 2571, 2572, 2583, 2582
8259, 2517, 2518, 2529, 2528, 2572, 2573, 2584, 2583
8260, 2518, 2519, 2530, 2529, 2573, 2574, 2585, 2584
8261, 2519, 2520, 2531, 2530, 2574, 2575, 2586, 2585
8262, 2520, 2521, 2532, 2531, 2575, 2576, 2587, 2586
8263, 2521, 2522, 2533, 2532, 2576, 2577, 2588, 2587
8264, 2522, 2523, 2534, 2533, 2577, 2578, 2589, 2588
8265, 2523, 2524, 2535, 2534, 2578, 2579, 2590, 2589
8266, 2524, 542, 543, 2535, 2579, 574, 575, 2590
8267, 538, 2525, 2536, 539, 570, 2580, 2591, 571
8268, 2525, 2526, 2537, 2536, 2580, 2581, 2592, 2591
8269, 2526, 2527, 2538, 2537, 2581, 2582, 2593, 2592
8270, 2527, 2528, 2539, 2538, 2582, 2583, 2594, 2593
8271, 2528, 2529, 2540, 2539, 2583, 2584, 2595, 2594
8272, 2529, 2530, 2541, 2540, 2584, 2585, 2596, 2595
8273, 2530, 2531, 2542, 2541, 2585, 2586, 2597, 2596
8274, 2531, 2532, 2543, 2542, 2586, 2587, 2598, 2597
8275, 2532, 2533, 2544, 2543, 2587, 2588, 2599, 2598
8276, 2533, 2534, 2545, 2544, 2588, 2589, 2600, 2599
8277, 2534, 2535, 2546, 2545, 2589, 2590, 2601, 2600
8278, 2535, 543, 544, 2546, 2590, 575, 576, 2601
8279, 539, 2536, 491, 37, 571, 2591, 545, 41
8280, 2536, 2537, 492, 491, 2591, 2592, 546, 545
8281, 2537, 2538, 493, 492, 2592, 2593, 547, 546
8282, 2538, 2539, 494, 493, 2593, 2594, 548, 547
8283, 2539, 2540, 495, 494, 2594, 2595, 549, 548
8284, 2540, 2541, 496, 495, 2595, 2596, 550, 549
8285, 2541, 2542, 497, 496, 2596, 2597, 551, 550
8286, 2542, 2543, 498, 497, 2597, 2598, 552, 551
8287, 2543, 2544, 499, 498, 2598, 2599, 553, 552
8288, 2544, 2545, 500, 499, 2599, 2600, 554, 553
8289, 2545, 2546, 501, 500, 2600, 2601, 555, 554
8290, 2546, 544, 38, 501, 2601, 576, 42, 555
*ELEMENT, type=C3D8, ELSET=Volume11
8291, 43, 556, 2547, 567, 592, 2624, 5497, 2646
8292, 592, 2624, 5497, 2646, 593, 2625, 5498, 2647
8293, 593, 2625, 5498, 2647, 47, 596, 2666, 607
8294, 556, 557, 2548, 2547, 2624, 2626, 5499, 5497
8295, 2624, 2626, 5499, 5497, 2625, 2627, 5500, 5498
8296, 2625, 2627, 5500, 5498, 596, 597, 2667, 2666
8297, 557, 558, 2549, 2548, 2626, 2628, 5501, 5499
8298, 2626, 2628, 5501, 5499, 2627, 2629, 5502, 5500
8299, 2627, 2629, 5502, 5500, 597, 598, 2668, 2667
8300, 558, 559, 2550, 2549, 2628, 2630, 5503, 5501
8301, 2628, 2630, 5503, 5501, 2629, 2631, 5504, 5502
8302, 2629, 2631, 5504, 5502, 598, 599, 2669, 2668
8303, 559, 560, 2551, 2550, 2630, 2632, 5505, 5503
8304, 2630, 2632, 5505, 5503, 2631, 2633, 5506, 5504
8305, 2631, 2633, 5506, 5504, 599, 600, 2670, 2669
8306, 560, 561, 2552, 2551, 2632, 2634, 5507, 5505
8307, 2632, 2634, 5507, 5505, 2633, 2635, 5508, 5506
8308, 2633, 2635, 5508, 5506, 600, 601, 2671, 2670
8309, 561, 562, 2553, 2552, 2634, 2636, 5509, 5507
8310, 2634, 2636, 5509, 5507, 2635, 2637, 5510, 5508
8311, 2635, 2637, 5510, 5508, 601, 602, 2672, 2671
8312, 562, 563, 2554, 2553, 2636, 2638, 5511, 5509
8313, 2636, 2638, 5511, 5509, 2637, 2639, 5512, 5510
8314, 2637, 2639, 5512, 5510, 602, 603, 2673, 2672
8315, 563, 564, 2555, 2554, 2638, 2640, 5513, 5511
8316, 2638, 2640, 5513, 5511, 2639, 2641, 5514, 5512
8317, 2639, 2641, 5514, 5512, 603, 604, 2674, 2673
8318, 564, 565, 2556, 2555, 2640, 2642, 5515, 5513
8319, 2640, 2642, 5515, 5513, 2641, 2643, 5516, 5514
8320, 2641, 2643, 5516, 5514, 604, 605, 2675, 2674
8321, 565, 566, 2557, 2556, 2642, 2644, 5517, 5515
8322, 2642, 2644, 5517, 5515, 2643, 2645, 5518, 5516
8323, 2643, 2645, 5518, 5516, 605, 606, 2676, 2675
8324, 566, 44, 572, 2557, 2644, 594, 2656, 5517
8325, 2644, 594, 2656, 5517, 2645, 595, 2657, 5518
8326, 2645, 595, 2657, 5518, 606, 48, 612, 2676
8327, 567, 2547, 2558, 568, 2646, 5497, 5519, 2648
8328, 2646, 5497, 5519, 2648, 2647, 5498, 5520, 2649
8329, 2647, 5498, 5520, 2649, 607, 2666, 2677, 608
8330, 2547, 2548, 2559, 2558, 5497, 5499, 5521, 5519
8331, 5497, 5499, 5521, 5519, 5498, 5500, 5522, 5520
8332, 5498, 5500, 5522, 5520, 2666, 2667, 2678, 2677
8333, 2548, 2549, 2560, 2559, 5499, 5501, 5523, 5521
8334, 5499, 5501, 5523, 5521, 5500, 5502, 5524, 5522
8335, 5500, 5502, 5524, 5522, 2667, 2668, 2679, 2678
8336, 2549, 2550, 2561, 2560, 5501, 5503, 5525, 5523
8337, 5501, 5503, 5525, 5523, 5502, 5504, 5526, 5524
8338, 5502, 5504, 5526, 5524, 2668, 2669, 2680, 2679
8339, 2550, 2551, 2562, 2561, 5503, 5505, 5527, 5525
8340, 5503, 5505, 5527, 5525, 5504, 5506, 5528, 5526
8341, 5504, 5506, 5528, 5526, 2669, 2670, 2681, 2680
8342, 2551, 2552, 2563, 2562, 5505, 5507, 5529, 5527
8343, 5505, 5507, 5529, 5527, 5506, 5508, 5530, 5528
8344, 5506, 5508, 5530, 5528, 2670, 2671, 2682, 2681
8345, 2552, 2553, 2564, 2563, 5507, 5509, 5531, 5529
8346, 5507, 5509, 5531, 5529, 5508, 5510, 5532, 5530
8347, 5508, 5510, 5532, 5530, 2671, 2672, 2683, 2682
8348, 2553, 2554, 2565, 2564, 5509, 5511, 5533, 5531
8349, 5509, 5511, 5533, 5531, 5510, 5512, 5534, 5532
8350, 5510, 5512, 5534, 5532, 2672, 2673, 2684, 2683
8351, 2554, 2555, 2566, 2565, 5511, 5513, 5535, 5533
8352, 5511, 5513, 5535, 5533, 5512, 5514, 5536, 5534
8353, 5512, 5514, 5536, 5534, 2673, 2674, 2685, 2684
8354, 2555, 2556, 2567, 2566, 5513, 5515, 5537, 5535
8355, 5513, 5515, 5537, 5535, 5514, 5516, 5538, 5536
8356, 5514, 5516, 5538, 5536, 2674, 2675, 2686, 2685
8357, 2556, 2557, 2568, 2567, 5515, 5517, 5539, 5537
8358, 5515, 5517, 5539, 5537, 5516, 5518, 5540, 5538
8359, 5516, 5518, 5540, 5538, 2675, 2676, 2687, 2686
8360, 2557, 572, 573, 2568, 5517, 2656, 2658, 5539
8361, 5517, 2656, 2658, 5539, 5518, 2657, 2659, 5540
8362, 5518, 2657, 2659, 5540, 2676, 612, 613, 2687
8363, 568, 2558, 2569, 569, 2648, 5519, 5541, 2650
8364, 2648, 5519, 5541, 2650, 2649, 5520, 5542, 2651
8365, 2649, 5520, 5542, 2651, 608, 2677, 2688, 609
8366, 2558, 2559, 2570, 2569, 5519, 5521, 5543, 5541
8367, 5519, 5521, 5543, 5541, 5520, 5522, 5544, 5542
8368, 5520, 5522, 5544, 5542, 2677, 2678, 2689, 2688
8369, 2559, 2560, 2571, 2570, 5521, 5523, 5545, 5543
8370, 5521, 5523, 5545, 5543, 5522, 5524, 5546, 5544
8371, 5522, 5524, 5546, 5544, 2678, 2679, 2690, 2689
8372, 2560, 2561, 2572, 2571, 5523, 5525, 5547, 5545
8373, 5523, 5525, 5547, 5545, 5524, 5526, 5548, 5546
8374, 5524, 5526, 5548, 5546, 2679, 2680, 2691, 2690
8375, 2561, 2562, 2573, 2572, 5525, 5527, 5549, 5547
8376, 5525, 5527, 5549, 5547, 5526, 5528, 5550, 5548
8377, 5526, 5528, 5550, 5548, 2680, 2681, 2692, 2691
8378, 2562, 2563, 2574, 2573, 5527, 5529, 5551, 5549
8379, 5527, 5529, 5551, 5549, 5528, 5530, 5552, 5550
8380, 5528, 5530, 5552, 5550, 2681, 2682, 2693, 2692
8381, 2563, 2564, 2575, 2574, 5529, 5531, 5553, 5551
8382, 5529, 5531, 5553, 5551, 5530, 5532, 5554, 5552
8383, 5530, 5532, 5554, 5552, 2682, 2683, 2694, 2693
8384, 2564, 2565, 2576, 2575, 5531, 5533, 5555, 5553
8385, 5531, 5533, 5555, 5553, 5532, 5534, 5556, 5554
8386, 5532, 5534, 5556, 5554, 2683, 2684, 2695, 2694
8387, 2565, 2566, 2577, 2576, 5533, 5535, 5557, 5555
8388, 5533, 5535, 5557, 5555, 5534, 5536, 5558, 5556
8389, 5534, 5536, 5558, 5556, 2684, 2685, 2696, 2695
8390, 2566, 2567, 2578, 2577, 5535, 5537, 5559, 5557
8391, 5535, 5537, 5559, 5557, 5536, 5538, 5560, 5558
8392, 5536, 5538, 5560, 5558, 2685, 2686, 2697, 2696
8393, 2567, 2568, 2579, 2578, 5537, 5539, 5561, 5559
8394, 5537, 5539, 5561, 5559, 5538, 5540, 5562, 5560
8395, 5538, 5540, 5562, 5560, 2686, 2687, 2698, 2697
8396, 2568, 573, 574, 2579, 5539, 2658, 2660, 5561
8397, 5539, 2658, 2660, 5561, 5540, 2659, 2661, 5562
8398, 5540, 2659, 2661, 5562, 2687, 613, 614, 2698
8399, 569, 2569, 2580, 570, 2650, 5541, 5563, 2652
8400, 2650, 5541, 5563, 2652, 2651, 5542, 5564, 2653
8401, 2651, 5542, 5564, 2653, 609, 2688, 2699, 610
8402, 2569, 2570, 2581, 2580, 5541, 5543, 5565, 5563
8403, 5541, 5543, 5565, 5563, 5542, 5544, 5566, 5564
8404, 5542, 5544, 5566, 5564, 2688, 2689, 2700, 2699
8405, 2570, 2571, 2582, 2581, 5543, 5545, 5567, 5565
8406, 5543, 5545, 5567, 5565, 5544, 5546, 5568, 5566
8407, 5544, 5546, 5568, 5566, 2689, 2690, 2701, 2700
8408, 2571, 2572, 2583, 2582, 5545, 5547, 5569, 5567
8409, 5545, 5547, 5569, 5567, 5546, 5548, 5570, 5568
8410, 5546, 5548, 5570, 5568, 2690, 2691, 2702, 2701
8411, 2572, 2573, 2584, 2583, 5547, 5549, 5571, 5569
8412, 5547, 5549, 5571, 5569, 5548, 5550, 5572, 5570
8413, 5548, 5550, 5572, 5570, 2691, 2692, 2703, 2702
8414, 2573, 2574, 2585, 2584, 5549, 5551, 5573, 5571
8415, 5549, 5551, 5573, 5571, 5550, 5552, 5574, 5572
8416, 5550, 5552, 5574, 5572, 2692, 2693, 2704, 2703
8417, 2574, 2575, 2586, 2585, 5551, 5553, 5575, 5573
8418, 5551, 5553, 5575, 5573, 5552, 5554, 5576, 5574
8419, 5552, 5554, 5576, 5574, 2693, 2694, 2705, 2704
8420, 2575, 2576, 2587, 2586, 5553, 5555, 5577, 5575
8421, 5553, 5555, 5577, 5575, 5554, 5556, 5578, 5576
8422, 5554, 5556, 5578, 5576, 2694, 2695, 2706, 2705
8423, 2576, 2577, 2588, 2587, 5555, 5557, 5579, 5577
8424, 5555, 5557, 5579, 5577, 5556, 5558, 5580, 5578
8425, 5556, 5558, 5580, 5578, 2695, 2696, 2707, 2706
8426, 2577, 2578, 2589, 2588, 5557, 5559, 5581, 5579
8427, 5557, 5559, 5581, 5579, 5558, 5560, 5582, 5580
8428, 5558, 5560, 5582, 5580, 2696, 2697, 2708, 2707
8429, 2578, 2579, 2590, 2589, 5559, 5561, 5583, 5581
8430, 5559, 5561, 5583, 5581, 5560, 5562, 5584, 5582
8431, 5560, 5562, 5584, 5582, 2697, 2698, 2709, 2708
8432, 2579, 574, 575, 2590, 5561, 2660, 2662, 5583
8433, 5561, 2660, 2662, 5583, 5562, 2661, 2663, 5584
8434, 5562, 2661, 2663, 5584, 2698, 614, 615, 2709
8435, 570, 2580, 2591, 571, 2652, 5563, 5585, 2654
8436, 2652, 5563, 5585, 2654, 2653, 5564, 5586, 2655
8437, 2653, 5564, 5586, 2655, 610, 2699, 2710, 611
8438, 2580, 2581, 2592, 2591, 5563, 5565, 5587, 5585
8439, 5563, 5565, 5587, 5585, 5564, 5566, 5588, 5586
8440, 5564, 5566, 5588, 5586, 2699, 2700, 2711, 2710
8441, 2581, 2582, 2593, 2592, 5565, 5567, 5589, 5587
8442, 5565, 5567, 5589, 5587, 5566, 5568, 5590, 5588
8443, 5566, 5568, 5590, 5588, 2700, 2701, 2712, 2711
8444, 2582, 2583, 2594, 2593, 5567, 5569, 5591, 5589
8445, 5567, 5569, 5591, 5589, 5568, 5570, 5592, 5590
8446, 5568, 5570, 5592, 5590, 2701, 2702, 2713, 2712
8447, 2583, 2584, 2595, 2594, 5569, 5571, 5593, 5591
8448, 5569, 5571, 5593, 5591, 5570, 5572, 5594, 5592
8449, 5570, 5572, 5594, 5592, 2702, 2703, 2714, 2713
8450, 2584, 2585, 2596, 2595, 5571, 5573, 5595, 5593
8451, 5571, 5573, 5595, 5593, 5572, 5574, 5596, 5594
8452, 5572, 5574, 5596, 5594, 2703, 2704, 2715, 2714
8453, 2585, 2586, 2597, 2596, 5573, 5575, 5597, 5595
8454, 5573, 5575, 5597, 5595, 5574, 5576, 5598, 5596
8455, 5574, 5576, 5598, 5596, 2704, 2705, 2716, 2715
8456, 2586, 2587, 2598, 2597, 5575, 5577, 5599, 5597
8457, 5575, 5577, 5599, 5597, 5576, 5578, 5600, 5598
8458, 5576, 5578, 5600, 5598, 2705, 2706, 2717, 2716
8459, 2587, 2588, 2599, 2598, 5577, 5579, 5601, 5599
8460, 5577, 5579, 5601, 5599, 5578, 5580, 5602, 5600
8461, 5578, 5580, 5602, 5600, 2706, 2707, 2718, 2717
8462, 2588, 2589, 2600, 2599, 5579, 5581, 5603, 5601
8463, 5579, 5581, 5603, 5601, 5580, 5582, 5604, 5602
8464, 5580, 5582, 5604, 5602, 2707, 2708, 2719, 2718
8465, 2589, 2590, 2601, 2600, 5581, 5583, 5605, 5603
8466, 5581, 5583, 5605, 5603, 5582, 5584, 5606, 5604
8467, 5582, 5584, 5606, 5604, 2708, 2709, 2720, 2719
8468, 2590, 575, 576, 2601, 5583, 2662, 2664, 5605
8469, 5583, 2662, 2664, 5605, 5584, 2663, 2665, 5606
8470, 5584, 2663, 2665, 5606, 2709, 615, 616, 2720
8471, 571, 2591, 545, 41, 2654, 5585, 2602, 577
8472, 2654, 5585, 2602, 577, 2655, 5586, 2603, 578
8473, 2655, 5586, 2603, 578, 611, 2710, 581, 45
8474, 2591, 2592, 546, 545, 5585, 5587, 2604, 2602
8475, 5585, 5587, 2604, 2602, 5586, 5588, 2605, 2603
8476, 5586, 5588, 2605, 2603, 2710, 2711, 582, 581
8477, 2592, 2593, 547, 546, 5587, 5589, 2606, 2604
8478, 5587, 5589, 2606, 2604, 5588, 5590, 2607, 2605
8479, 5588, 5590, 2607, 2605, 2711, 2712, 583, 582
8480, 2593, 2594, 548, 547, 5589, 5591, 2608, 2606
8481, 5589, 5591, 2608, 2606, 5590, 5592, 2609, 2607
8482, 5590, 5592, 2609, 2607, 2712, 2713, 584, 583
8483, 2594, 2595, 549, 548, 5591, 5593, 2610, 2608
8484, 5591, 5593, 2610, 2608, 5592, 5594, 2611, 2609
8485, 5592, 5594, 2611, 2609, 2713, 2714, 585, 584
8486, 2595, 2596, 550, 549, 5593, 5595, 2612, 2610
8487, 5593, 5595, 2612, 2610, 5594, 5596, 2613, 2611
8488, 5594, 5596, 2613, 2611, 2714, 2715, 586, 585
8489, 2596, 2597, 551, 550, 5595, 5597, 2614, 2612
8490, 5595, 5597, 2614, 2612, 5596, 5598, 2615, 2613
8491, 5596, 5598, 2615, 2613, 2715, 2716, 587, 586
8492, 2597, 2598, 552, 551, 5597, 5599, 2616, 2614
8493, 5597, 5599, 2616, 2614, 5598, 5600, 2617, 2615
8494, 5598, 5600, 2617, 2615, 2716, 2717, 588, 587
8495, 2598, 2599, 553, 552, 5599, 5601, 2618, 2616
8496, 5599, 5601, 2618, 2616, 5600, 5602, 2619, 2617
8497, 5600, 5602, 2619, 2617, 2717, 2718, 589, 588
8498, 2599, 2600, 554, 553, 5601, 5603, 2620, 2618
8499, 5601, 5603, 2620, 2618, 5602, 5604, 2621, 2619
8500, 5602, 5604, 2621, 2619, 2718, 2719, 590, 589
8501, 2600, 2601, 555, 554, 5603, 5605, 2622, 2620
8502, 5603, 5605, 2622, 2620, 5604, 5606, 2623, 2621
8503, 5604, 5606, 2623, 2621, 2719, 2720, 591, 590
8504, 2601, 576, 42, 555, 5605, 2664, 579, 2622
8505, 5605, 2664, 579, 2622, 5606, 2665, 580, 2623
8506, 5606, 2665, 580, 2623, 2720, 616, 46, 591
*ELEMENT, type=C3D8, ELSET=Volume12
8507, 44, 572, 2656, 594, 51, 621, 2721, 619
8508, 594, 2656, 2657, 595, 619, 2721, 2722, 620
8509, 595, 2657, 612, 48, 620, 2722, 626, 52
8510, 572, 573, 2658, 2656, 621, 622, 2723, 2721
8511, 2656, 2658, 2659, 2657, 2721, 2723, 2724, 2722
8512, 2657, 2659, 613, 612, 2722, 2724, 627, 626
8513, 573, 574, 2660, 2658, 622, 623, 2725, 2723
8514, 2658, 2660, 2661, 2659, 2723, 2725, 2726, 2724
8515, 2659, 2661, 614, 613, 2724, 2726, 628, 627
8516, 574, 575, 2662, 2660, 623, 624, 2727, 2725
8517, 2660, 2662, 2663, 2661, 2725, 2727, 2728, 2726
8518, 2661, 2663, 615, 614, 2726, 2728, 629, 628
8519, 575, 576, 2664, 2662, 624, 625, 2729, 2727
8520, 2662, 2664, 2665, 2663, 2727, 2729, 2730, 2728
8521, 2663, 2665, 616, 615, 2728, 2730, 630, 629
8522, 576, 42, 579, 2664, 625, 49, 617, 2729
8523, 2664, 579, 580, 2665, 2729, 617, 618, 2730
8524, 2665, 580, 46, 616, 2730, 618, 50, 630
*ELEMENT, type=C3D8, ELSET=Volume13
8525, 2, 97, 1045, 109, 54, 631, 2731, 643
8526, 109, 1045, 1046, 110, 643, 2731, 2732, 644
8527, 110, 1046, 104, 4, 644, 2732, 638, 56
8528, 97, 98, 1047, 1045, 631, 632, 2733, 2731
8529, 1045, 1047, 1048, 1046, 2731, 2733, 2734, 2732
8530, 1046, 1048, 105, 104, 2732, 2734, 639, 638
8531, 98, 99, 1049, 1047, 632, 633, 2735, 2733
8532, 1047, 1049, 1050, 1048, 2733, 2735, 2736, 2734
8533, 1048, 1050, 106, 105, 2734, 2736, 640, 639
8534, 99, 100, 1051, 1049, 633, 634, 2737, 2735
8535, 1049, 1051, 1052, 1050, 2735, 2737, 2738, 2736
8536, 1050, 1052, 107, 106, 2736, 2738, 641, 640
8537, 100, 101, 1053, 1051, 634, 635, 2739, 2737
8538, 1051, 1053, 1054, 1052, 2737, 2739, 2740, 2738
8539, 1052, 1054, 108, 107, 2738, 2740, 642, 641
8540, 101, 1, 102, 1053, 635, 53, 636, 2739
8541, 1053, 102, 103, 1054, 2739, 636, 637, 2740
8542, 1054, 103, 3, 108, 2740, 637, 55, 642
*ELEMENT, type=C3D8, ELSET=Volume14
8543, 10, 212, 1274, 169, 67, 720, 2851, 731
8544, 212, 213, 1275, 1274, 720, 721, 2852, 2851
8545, 213, 214, 1276, 1275, 721, 722, 2853, 2852
8546, 214, 215, 1277, 1276, 722, 723, 2854, 2853
8547, 215, 216, 1278, 1277, 723, 724, 2855, 2854
8548, 216, 217, 1279, 1278, 724, 725, 2856, 2855
8549, 217, 218, 1280, 1279, 725, 726, 2857, 2856
8550, 218, 219, 1281, 1280, 726, 727, 2858, 2857
8551, 219, 220, 1282, 1281, 727, 728, 2859, 2858
8552, 220, 221, 1283, 1282, 728, 729, 2860, 2859
8553, 221, 222, 1284, 1283, 729, 730, 2861, 2860
8554, 222, 14, 223, 1284, 730, 68, 742, 2861
8555, 169, 1274, 1285, 170, 731, 2851, 2862, 732
8556, 1274, 1275, 1286, 1285, 2851, 2852, 2863, 2862
8557, 1275, 1276, 1287, 1286, 2852, 2853, 2864, 2863
8558, 1276, 1277, 1288, 1287, 2853, 2854, 2865, 2864
8559, 1277, 1278, 1289, 1288, 2854, 2855, 2866, 2865
8560, 1278, 1279, 1290, 1289, 2855, 2856, 2867, 2866
8561, 1279, 1280, 1291, 1290, 2856, 2857, 2868, 2867
8562, 1280, 1281, 1292, 1291, 2857, 2858, 2869, 2868
8563, 1281, 1282, 1293, 1292, 2858, 2859, 2870, 2869
8564, 1282, 1283, 1294, 1293, 2859, 2860, 2871, 2870
8565, 1283, 1284, 1295, 1294, 2860, 2861, 2872, 2871
8566, 1284, 223, 224, 1295, 2861, 742, 743, 2872
8567, 170, 1285, 1296, 171, 732, 2862, 2873, 733
8568, 1285, 1286, 1297, 1296, 2862, 2863, 2874, 2873
8569, 1286, 1287, 1298, 1297, 2863, 2864, 2875, 2874
8570, 1287, 1288, 1299, 1298, 2864, 2865, 2876, 2875
8571, 1288, 1289, 1300, 1299, 2865, 2866, 2877, 2876
8572, 1289, 1290, 1301, 1300, 2866, 2867, 2878, 2877
8573, 1290, 1291, 1302, 1301, 2867, 2868, 2879, 2878
8574, 1291, 1292, 1303, 1302, 2868, 2869, 2880, 2879
8575, 1292, 1293, 1304, 1303, 2869, 2870, 2881, 2880
8576, 1293, 1294, 1305, 1304, 2870, 2871, 2882, 2881
8577, 1294, 1295, 1306, 1305, 2871, 2872, 2883, 2882
8578, 1295, 224, 225, 1306, 2872, 743, 744, 2883
8579, 171, 1296, 1307, 172, 733, 2873, 2884, 734
8580, 1296, 1297, 1308, 1307, 2873, 2874, 2885, 2884
8581, 1297, 1298, 1309, 1308, 2874, 2875, 2886, 2885
8582, 1298, 1299, 1310, 1309, 2875, 2876, 2887, 2886
8583, 1299, 1300, 1311, 1310, 2876, 2877, 2888, 2887
8584, 1300, 1301, 1312, 1311, 2877, 2878, 2889, 2888
8585, 1301, 1302, 1313, 1312, 2878, 2879, 2890, 2889
8586, 1302, 1303, 1314, 1313, 2879, 2880, 2891, 2890
8587, 1303, 1304, 1315, 1314, 2880, 2881, 2892, 2891
8588, 1304, 1305, 1316, 1315, 2881, 2882, 2893, 2892
8589, 1305, 1306, 1317, 1316, 2882, 2883, 2894, 2893
8590, 1306, 225, 226, 1317, 2883, 744, 745, 2894
8591, 172, 1307, 1318, 173, 734, 2884, 2895, 735
8592, 1307, 1308, 1319, 1318, 2884, 2885, 2896, 2895
8593, 1308, 1309, 1320, 1319, 2885, 2886, 2897, 2896
8594, 1309, 1310, 1321, 1320, 2886, 2887, 2898, 2897
8595, 1310, 1311, 1322, 1321, 2887, 2888, 2899, 2898
8596, 1311, 1312, 1323, 1322, 2888, 2889, 2900, 2899
8597, 1312, 1313, 1324, 1323, 2889, 2890, 2901, 2900
8598, 1313, 1314, 1325, 1324, 2890, 2891, 2902, 2901
8599, 1314, 1315, 1326, 1325, 2891, 2892, 2903, 2902
8600, 1315, 1316, 1327, 1326, 2892, 2893, 2904, 2903
8601, 1316, 1317, 1328, 1327, 2893, 2894, 2905, 2904
8602, 1317, 226, 227, 1328, 2894, 745, 746, 2905
8603, 173, 1318, 1329, 174, 735, 2895, 2906, 736
8604, 1318, 1319, 1330, 1329, 2895, 2896, 2907, 2906
8605, 1319, 1320, 1331, 1330, 2896, 2897, 2908, 2907
8606, 1320, 1321, 1332, 1331, 2897, 2898, 2909, 2908
8607, 1321, 1322, 1333, 1332, 2898, 2899, 2910, 2909
8608, 1322, 1323, 1334, 1333, 2899, 2900, 2911, 2910
8609, 1323, 1324, 1335, 1334, 2900, 2901, 2912, 2911
8610, 1324, 1325, 1336, 1335, 2901, 2902, 2913, 2912
8611, 1325, 1326, 1337, 1336, 2902, 2903, 2914, 2913
8612, 1326, 1327, 1338, 1337, 2903, 2904, 2915, 2914
8613, 1327, 1328, 1339, 1338, 2904, 2905, 2916, 2915
8614, 1328, 227, 228, 1339, 2905, 746, 747, 2916
8615, 174, 1329, 1340, 175, 736, 2906, 2917, 737
8616, 1329, 1330, 1341, 1340, 2906, 2907, 2918, 2917
8617, 1330, 1331, 1342, 1341, 2907, 2908, 2919, 2918
8618, 1331, 1332, 1343, 1342, 2908, 2909, 2920, 2919
8619, 1332, 1333, 1344, 1343, 2909, 2910, 2921, 2920
8620, 1333, 1334, 1345, 1344, 2910, 2911, 2922, 2921
8621, 1334, 1335, 1346, 1345, 2911, 2912, 2923, 2922
8622, 1335, 1336, 1347, 1346, 2912, 2913, 2924, 2923
8623, 1336, 1337, 1348, 1347, 2913, 2914, 2925, 2924
8624, 1337, 1338, 1349, 1348, 2914, 2915, 2926, 2925
8625, 1338, 1339, 1350, 1349, 2915, 2916, 2927, 2926
8626, 1339, 228, 229, 1350, 2916, 747, 748, 2927
8627, 175, 1340, 1351, 176, 737, 2917, 2928, 738
8628, 1340, 1341, 1352, 1351, 2917, 2918, 2929, 2928
8629, 1341, 1342, 1353, 1352, 2918, 2919, 2930, 2929
8630, 1342, 1343, 1354, 1353, 2919, 2920, 2931, 2930
8631, 1343, 1344, 1355, 1354, 2920, 2921, 2932, 2931
8632, 1344, 1345, 1356, 1355, 2921, 2922, 2933, 2932
8633, 1345, 1346, 1357, 1356, 2922, 2923, 2934, 2933
8634, 1346, 1347, 1358, 1357, 2923, 2924, 2935, 2934
8635, 1347, 1348, 1359, 1358, 2924, 2925, 2936, 2935
8636, 1348, 1349, 1360, 1359, 2925, 2926, 2937, 2936
8637, 1349, 1350, 1361, 1360, 2926, 2927, 2938, 2937
8638, 1350, 229, 230, 1361, 2927, 748, 749, 2938
8639, 176, 1351, 1362, 177, 738, 2928, 2939, 739
8640, 1351, 1352, 1363, 1362, 2928, 2929, 2940, 2939
8641, 1352, 1353, 1364, 1363, 2929, 2930, 2941, 2940
8642, 1353, 1354, 1365, 1364, 2930, 2931, 2942, 2941
8643, 1354, 1355, 1366, 1365, 2931, 2932, 2943, 2942
8644, 1355, 1356, 1367, 1366, 2932, 2933, 2944, 2943
8645, 1356, 1357, 1368, 1367, 2933, 2934, 2945, 2944
8646, 1357, 1358, 1369, 1368, 2934, 2935, 2946, 2945
8647, 1358, 1359, 1370, 1369, 2935, 2936, 2947, 2946
8648, 1359, 1360, 1371, 1370, 2936, 2937, 2948, 2947
8649, 1360, 1361, 1372, 1371, 2937, 2938, 2949, 2948
8650, 1361, 230, 231, 1372, 2938, 749, 750, 2949
8651, 177, 1362, 1373, 178, 739, 2939, 2950, 740
8652, 1362, 1363, 1374, 1373, 2939, 2940, 2951, 2950
8653, 1363, 1364, 1375, 1374, 2940, 2941, 2952, 2951
8654, 1364, 1365, 1376, 1375, 2941, 2942, 2953, 2952
8655, 1365, 1366, 1377, 1376, 2942, 2943, 2954, 2953
8656, 1366, 1367, 1378, 1377, 2943, 2944, 2955, 2954
8657, 1367, 1368, 1379, 1378, 2944, 2945, 2956, 2955
8658, 1368, 1369, 1380, 1379, 2945, 2946, 2957, 2956
8659, 1369, 1370, 1381, 1380, 2946, 2947, 2958, 2957
8660, 1370, 1371, 1382, 1381, 2947, 2948, 2959, 2958
8661, 1371, 1372, 1383, 1382, 2948, 2949, 2960, 2959
8662, 1372, 231, 232, 1383, 2949, 750, 751, 2960
8663, 178, 1373, 1384, 179, 740, 2950, 2961, 741
8664, 1373, 1374, 1385, 1384, 2950, 2951, 2962, 2961
8665, 1374, 1375, 1386, 1385, 2951, 2952, 2963, 2962
8666, 1375, 1376, 1387, 1386, 2952, 2953, 2964, 2963
8667, 1376, 1377, 1388, 1387, 2953, 2954, 2965, 2964
8668, 1377, 1378, 1389, 1388, 2954, 2955, 2966, 2965
8669, 1378, 1379, 1390, 1389, 2955, 2956, 2967, 2966
8670, 1379, 1380, 1391, 1390, 2956, 2957, 2968, 2967
8671, 1380, 1381, 1392, 1391, 2957, 2958, 2969, 2968
8672, 1381, 1382, 1393, 1392, 2958, 2959, 2970, 2969
8673, 1382, 1383, 1394, 1393, 2959, 2960, 2971, 2970
8674, 1383, 232, 233, 1394, 2960, 751, 752, 2971
8675, 179, 1384, 201, 9, 741, 2961, 709, 65
8676, 1384, 1385, 202, 201, 2961, 2962, 710, 709
8677, 1385, 1386, 203, 202, 2962, 2963, 711, 710
8678, 1386, 1387, 204, 203, 2963, 2964, 712, 711
8679, 1387, 1388, 205, 204, 2964, 2965, 713, 712
8680, 1388, 1389, 206, 205, 2965, 2966, 714, 713
8681, 1389, 1390, 207, 206, 2966, 2967, 715, 714
8682, 1390, 1391, 208, 207, 2967, 2968, 716, 715
8683, 1391, 1392, 209, 208, 2968, 2969, 717, 716
8684, 1392, 1393, 210, 209, 2969, 2970, 718, 717
8685, 1393, 1394, 211, 210, 2970, 2971, 719, 718
8686, 1394, 233, 13, 211, 2971, 752, 66, 719
*ELEMENT, type=C3D8, ELSET=Volume15
8687, 35, 448, 2261, 502, 69, 775, 2972, 753
8688, 502, 2261, 2262, 503, 753, 2972, 2973, 754
8689, 503, 2262, 2263, 504, 754, 2973, 2974, 755
8690, 504, 2263, 2264, 505, 755, 2974, 2975, 756
8691, 505, 2264, 2265, 506, 756, 2975, 2976, 757
8692, 506, 2265, 2266, 507, 757, 2976, 2977, 758
8693, 507, 2266, 2267, 508, 758, 2977, 2978, 759
8694, 508, 2267, 2268, 509, 759, 2978, 2979, 760
8695, 509, 2268, 2269, 510, 760, 2979, 2980, 761
8696, 510, 2269, 2270, 511, 761, 2980, 2981, 762
8697, 511, 2270, 2271, 512, 762, 2981, 2982, 763
8698, 512, 2271, 524, 39, 763, 2982, 786, 70
8699, 448, 449, 2272, 2261, 775, 776, 2983, 2972
8700, 2261, 2272, 2273, 2262, 2972, 2983, 2984, 2973
8701, 2262, 2273, 2274, 2263, 2973, 2984, 2985, 2974
8702, 2263, 2274, 2275, 2264, 2974, 2985, 2986, 2975
8703, 2264, 2275, 2276, 2265, 2975, 2986, 2987, 2976
8704, 2265, 2276, 2277, 2266, 2976, 2987, 2988, 2977
8705, 2266, 2277, 2278, 2267, 2977, 2988, 2989, 2978
8706, 2267, 2278, 2279, 2268, 2978, 2989, 2990, 2979
8707, 2268, 2279, 2280, 2269, 2979, 2990, 2991, 2980
8708, 2269, 2280, 2281, 2270, 2980, 2991, 2992, 2981
8709, 2270, 2281, 2282, 2271, 2981, 2992, 2993, 2982
8710, 2271, 2282, 525, 524, 2982, 2993, 787, 786
8711, 449, 450, 2283, 2272, 776, 777, 2994, 2983
8712, 2272, 2283, 2284, 2273, 2983, 2994, 2995, 2984
8713, 2273, 2284, 2285, 2274, 2984, 2995, 2996, 2985
8714, 2274, 2285, 2286, 2275, 2985, 2996, 2997, 2986
8715, 2275, 2286, 2287, 2276, 2986, 2997, 2998, 2987
8716, 2276, 2287, 2288, 2277, 2987, 2998, 2999, 2988
8717, 2277, 2288, 2289, 2278, 2988, 2999, 3000, 2989
8718, 2278, 2289, 2290, 2279, 2989, 3000, 3001, 2990
8719, 2279, 2290, 2291, 2280, 2990, 3001, 3002, 2991
8720, 2280, 2291, 2292, 2281, 2991, 3002, 3003, 2992
8721, 2281, 2292, 2293, 2282, 2992, 3003, 3004, 2993
8722, 2282, 2293, 526, 525, 2993, 3004, 788, 787
8723, 450, 451, 2294, 2283, 777, 778, 3005, 2994
8724, 2283, 2294, 2295, 2284, 2994, 3005, 3006, 2995
8725, 2284, 2295, 2296, 2285, 2995, 3006, 3007, 2996
8726, 2285, 2296, 2297, 2286, 2996, 3007, 3008, 2997
8727, 2286, 2297, 2298, 2287, 2997, 3008, 3009, 2998
8728, 2287, 2298, 2299, 2288, 2998, 3009, 3010, 2999
8729, 2288, 2299, 2300, 2289, 2999, 3010, 3011, 3000
8730, 2289, 2300, 2301, 2290, 3000, 3011, 3012, 3001
8731, 2290, 2301, 2302, 2291, 3001, 3012, 3013, 3002
8732, 2291, 2302, 2303, 2292, 3002, 3013, 3014, 3003
8733, 2292, 2303, 2304, 2293, 3003, 3014, 3015, 3004
8734, 2293, 2304, 527, 526, 3004, 3015, 789, 788
8735, 451, 452, 2305, 2294, 778, 779, 3016, 3005
8736, 2294, 2305, 2306, 2295, 3005, 3016, 3017, 3006
8737, 2295, 2306, 2307, 2296, 3006, 3017, 3018, 3007
8738, 2296, 2307, 2308, 2297, 3007, 3018, 3019, 3008
8739, 2297, 2308, 2309, 2298, 3008, 3019, 3020, 3009
8740, 2298, 2309, 2310, 2299, 3009, 3020, 3021, 3010
8741, 2299, 2310, 2311, 2300, 3010, 3021, 3022, 3011
8742, 2300, 2311, 2312, 2301, 3011, 3022, 3023, 3012
8743, 2301, 2312, 2313, 2302, 3012, 3023, 3024, 3013
8744, 2302, 2313, 2314, 2303, 3013, 3024, 3025, 3014
8745, 2303, 2314, 2315, 2304, 3014, 3025, 3026, 3015
8746, 2304, 2315, 528, 527, 3015, 3026, 790, 789
8747, 452, 453, 2316, 2305, 779, 780, 3027, 3016
8748, 2305, 2316, 2317, 2306, 3016, 3027, 3028, 3017
8749, 2306, 2317, 2318, 2307, 3017, 3028, 3029, 3018
8750, 2307, 2318, 2319, 2308, 3018, 3029, 3030, 3019
8751, 2308, 2319, 2320, 2309, 3019, 3030, 3031, 3020
8752, 2309, 2320, 2321, 2310, 3020, 3031, 3032, 3021
8753, 2310, 2321, 2322, 2311, 3021, 3032, 3033, 3022
8754, 2311, 2322, 2323, 2312, 3022, 3033, 3034, 3023
8755, 2312, 2323, 2324, 2313, 3023, 3034, 3035, 3024
8756, 2313, 2324, 2325, 2314, 3024, 3035, 3036, 3025
8757, 2314, 2325, 2326, 2315, 3025, 3036, 3037, 3026
8758, 2315, 2326, 529, 528, 3026, 3037, 791, 790
8759, 453, 454, 2327, 2316, 780, 781, 3038, 3027
8760, 2316, 2327, 2328, 2317, 3027, 3038, 3039, 3028
8761, 2317, 2328, 2329, 2318, 3028, 3039, 3040, 3029
8762, 2318, 2329, 2330, 2319, 3029, 3040, 3041, 3030
8763, 2319, 2330, 2331, 2320, 3030, 3041, 3042, 3031
8764, 2320, 2331, 2332, 2321, 3031, 3042, 3043, 3032
8765, 2321, 2332, 2333, 2322, 3032, 3043, 3044, 3033
8766, 2322, 2333, 2334, 2323, 3033, 3044, 3045, 3034
8767, 2323, 2334, 2335, 2324, 3034, 3045, 3046, 3035
8768, 2324, 2335, 2336, 2325, 3035, 3046, 3047, 3036
8769, 2325, 2336, 2337, 2326, 3036, 3047, 3048, 3037
8770, 2326, 2337, 530, 529, 3037, 3048, 792, 791
8771, 454, 455, 2338, 2327, 781, 782, 3049, 3038
8772, 2327, 2338, 2339, 2328, 3038, 3049, 3050, 3039
8773, 2328, 2339, 2340, 2329, 3039, 3050, 3051, 3040
8774, 2329, 2340, 2341, 2330, 3040, 3051, 3052, 3041
8775, 2330, 2341, 2342, 2331, 3041, 3052, 3053, 3042
8776, 2331, 2342, 2343, 2332, 3042, 3053, 3054, 3043
8777, 2332, 2343, 2344, 2333, 3043, 3054, 3055, 3044
8778, 2333, 2344, 2345, 2334, 3044, 3055, 3056, 3045
8779, 2334, 2345, 2346, 2335, 3045, 3056, 3057, 3046
8780, 2335, 2346, 2347, 2336, 3046, 3057, 3058, 3047
8781, 2336, 2347, 2348, 2337, 3047, 3058, 3059, 3048
8782, 2337, 2348, 531, 530, 3048, 3059, 793, 792
8783, 455, 456, 2349, 2338, 782, 783, 3060, 3049
8784, 2338, 2349, 2350, 2339, 3049, 3060, 3061, 3050
8785, 2339, 2350, 2351, 2340, 3050, 3061, 3062, 3051
8786, 2340, 2351, 2352, 2341, 3051, 3062, 3063, 3052
8787, 2341, 2352, 2353, 2342, 3052, 3063, 3064, 3053
8788, 2342, 2353, 2354, 2343, 3053, 3064, 3065, 3054
8789, 2343, 2354, 2355, 2344, 3054, 3065, 3066, 3055
8790, 2344, 2355, 2356, 2345, 3055, 3066, 3067, 3056
8791, 2345, 2356, 2357, 2346, 3056, 3067, 3068, 3057
8792, 2346, 2357, 2358, 2347, 3057, 3068, 3069, 3058
8793, 2347, 2358, 2359, 2348, 3058, 3069, 3070, 3059
8794, 2348, 2359, 532, 531, 3059, 3070, 794, 793
8795, 456, 457, 2360, 2349, 783, 784, 3071, 3060
8796, 2349, 2360, 2361, 2350, 3060, 3071, 3072, 3061
8797, 2350, 2361, 2362, 2351, 3061, 3072, 3073, 3062
8798, 2351, 2362, 2363, 2352, 3062, 3073, 3074, 3063
8799, 2352, 2363, 2364, 2353, 3063, 3074, 3075, 3064
8800, 2353, 2364, 2365, 2354, 3064, 3075, 3076, 3065
8801, 2354, 2365, 2366, 2355, 3065, 3076, 3077, 3066
8802, 2355, 2366, 2367, 2356, 3066, 3077, 3078, 3067
8803, 2356, 2367, 2368, 2357, 3067, 3078, 3079, 3068
8804, 2357, 2368, 2369, 2358, 3068, 3079, 3080, 3069
8805, 2358, 2369, 2370, 2359, 3069, 3080, 3081, 3070
8806, 2359, 2370, 533, 532, 3070, 3081, 795, 794
8807, 457, 458, 2371, 2360, 784, 785, 3082, 3071
8808, 2360, 2371, 2372, 2361, 3071, 3082, 3083, 3072
8809, 2361, 2372, 2373, 2362, 3072, 3083, 3084, 3073
8810, 2362, 2373, 2374, 2363, 3073, 3084, 3085, 3074
8811, 2363, 2374, 2375, 2364, 3074, 3085, 3086, 3075
8812, 2364, 2375, 2376, 2365, 3075, 3086, 3087, 3076
8813, 2365, 2376, 2377, 2366, 3076, 3087, 3088, 3077
8814, 2366, 2377, 2378, 2367, 3077, 3088, 3089, 3078
8815, 2367, 2378, 2379, 2368, 3078, 3089, 3090, 3079
8816, 2368, 2379, 2380, 2369, 3079, 3090, 3091, 3080
8817, 2369, 2380, 2381, 2370, 3080, 3091, 3092, 3081
8818, 2370, 2381, 534, 533, 3081, 3092, 796, 795
8819, 458, 36, 513, 2371, 785, 71, 764, 3082
8820, 2371, 513, 514, 2372, 3082, 764, 765, 3083
8821, 2372, 514, 515, 2373, 3083, 765, 766, 3084
8822, 2373, 515, 516, 2374, 3084, 766, 767, 3085
8823, 2374, 516, 517, 2375, 3085, 767, 768, 3086
8824, 2375, 517, 518, 2376, 3086, 768, 769, 3087
8825, 2376, 518, 519, 2377, 3087, 769, 770, 3088
8826, 2377, 519, 520, 2378, 3088, 770, 771, 3089
8827, 2378, 520, 521, 2379, 3089, 771, 772, 3090
8828, 2379, 521, 522, 2380, 3090, 772, 773, 3091
8829, 2380, 522, 523, 2381, 3091, 773, 774, 3092
8830, 2381, 523, 40, 534, 3092, 774, 72, 796
*ELEMENT, type=C3D8, ELSET=Volume16
8831, 9, 201, 1395, 180, 59, 656, 2741, 667
8832, 201, 202, 1396, 1395, 656, 657, 2742, 2741
8833, 202, 203, 1397, 1396, 657, 658, 2743, 2742
8834, 203, 204, 1398, 1397, 658, 659, 2744, 2743
8835, 204, 205, 1399, 1398, 659, 660, 2745, 2744
8836, 205, 206, 1400, 1399, 660, 661, 2746, 2745
8837, 206, 207, 1401, 1400, 661, 662, 2747, 2746
8838, 207, 208, 1402, 1401, 662, 663, 2748, 2747
8839, 208, 209, 1403, 1402, 663, 664, 2749, 2748
8840, 209, 210, 1404, 1403, 664, 665, 2750, 2749
8841, 210, 211, 1405, 1404, 665, 666, 2751, 2750
8842, 211, 13, 245, 1405, 666, 60, 672, 2751
8843, 180, 1395, 1406, 181, 667, 2741, 2752, 668
8844, 1395, 1396, 1407, 1406, 2741, 2742, 2753, 2752
8845, 1396, 1397, 1408, 1407, 2742, 2743, 2754, 2753
8846, 1397, 1398, 1409, 1408, 2743, 2744, 2755, 2754
8847, 1398, 1399, 1410, 1409, 2744, 2745, 2756, 2755
8848, 1399, 1400, 1411, 1410, 2745, 2746, 2757, 2756
8849, 1400, 1401, 1412, 1411, 2746, 2747, 2758, 2757
8850, 1401, 1402, 1413, 1412, 2747, 2748, 2759, 2758
8851, 1402, 1403, 1414, 1413, 2748, 2749, 2760, 2759
8852, 1403, 1404, 1415, 1414, 2749, 2750, 2761, 2760
8853, 1404, 1405, 1416, 1415, 2750, 2751, 2762, 2761
8854, 1405, 245, 246, 1416, 2751, 672, 673, 2762
8855, 181, 1406, 1417, 182, 668, 2752, 2763, 669
8856, 1406, 1407, 1418, 1417, 2752, 2753, 2764, 2763
8857, 1407, 1408, 1419, 1418, 2753, 2754, 2765, 2764
8858, 1408, 1409, 1420, 1419, 2754, 2755, 2766, 2765
8859, 1409, 1410, 1421, 1420, 2755, 2756, 2767, 2766
8860, 1410, 1411, 1422, 1421, 2756, 2757, 2768, 2767
8861, 1411, 1412, 1423, 1422, 2757, 2758, 2769, 2768
8862, 1412, 1413, 1424, 1423, 2758, 2759, 2770, 2769
8863, 1413, 1414, 1425, 1424, 2759, 2760, 2771, 2770
8864, 1414, 1415, 1426, 1425, 2760, 2761, 2772, 2771
8865, 1415, 1416, 1427, 1426, 2761, 2762, 2773, 2772
8866, 1416, 246, 247, 1427, 2762, 673, 674, 2773
8867, 182, 1417, 1428, 183, 669, 2763, 2774, 670
8868, 1417, 1418, 1429, 1428, 2763, 2764, 2775, 2774
8869, 1418, 1419, 1430, 1429, 2764, 2765, 2776, 2775
8870, 1419, 1420, 1431, 1430, 2765, 2766, 2777, 2776
8871, 1420, 1421, 1432, 1431, 2766, 2767, 2778, 2777
8872, 1421, 1422, 1433, 1432, 2767, 2768, 2779, 2778
8873, 1422, 1423, 1434, 1433, 2768, 2769, 2780, 2779
8874, 1423, 1424, 1435, 1434, 2769, 2770, 2781, 2780
8875, 1424, 1425, 1436, 1435, 2770, 2771, 2782, 2781
8876, 1425, 1426, 1437, 1436, 2771, 2772, 2783, 2782
8877, 1426, 1427, 1438, 1437, 2772, 2773, 2784, 2783
8878, 1427, 247, 248, 1438, 2773, 674, 675, 2784
8879, 183, 1428, 1439, 184, 670, 2774, 2785, 671
8880, 1428, 1429, 1440, 1439, 2774, 2775, 2786, 2785
8881, 1429, 1430, 1441, 1440, 2775, 2776, 2787, 2786
8882, 1430, 1431, 1442, 1441, 2776, 2777, 2788, 2787
8883, 1431, 1432, 1443, 1442, 2777, 2778, 2789, 2788
8884, 1432, 1433, 1444, 1443, 2778, 2779, 2790, 2789
8885, 1433, 1434, 1445, 1444, 2779, 2780, 2791, 2790
8886, 1434, 1435, 1446, 1445, 2780, 2781, 2792, 2791
8887, 1435, 1436, 1447, 1446, 2781, 2782, 2793, 2792
8888, 1436, 1437, 1448, 1447, 2782, 2783, 2794, 2793
8889, 1437, 1438, 1449, 1448, 2783, 2784, 2795, 2794
8890, 1438, 248, 249, 1449, 2784, 675, 676, 2795
8891, 184, 1439, 234, 11, 671, 2785, 645, 57
8892, 1439, 1440, 235, 234, 2785, 2786, 646, 645
8893, 1440, 1441, 236, 235, 2786, 2787, 647, 646
8894, 1441, 1442, 237, 236, 2787, 2788, 648, 647
8895, 1442, 1443, 238, 237, 2788, 2789, 649, 648
8896, 1443, 1444, 239, 238, 2789, 2790, 650, 649
8897, 1444, 1445, 240, 239, 2790, 2791, 651, 650
8898, 1445, 1446, 241, 240, 2791, 2792, 652, 651
8899, 1446, 1447, 242, 241, 2792, 2793, 653, 652
8900, 1447, 1448, 243, 242, 2793, 2794, 654, 653
8901, 1448, 1449, 244, 243, 2794, 2795, 655, 654
8902, 1449, 249, 15, 244, 2795, 676, 58, 655
*ELEMENT, type=C3D8, ELSET=Volume17
8903, 35, 502, 2382, 459, 63, 688, 2796, 699
8904, 502, 503, 2383, 2382, 688, 689, 2797, 2796
8905, 503, 504, 2384, 2383, 689, 690, 2798, 2797
8906, 504, 505, 2385, 2384, 690, 691, 2799, 2798
8907, 505, 506, 2386, 2385, 691, 692, 2800, 2799
8908, 506, 507, 2387, 2386, 692, 693, 2801, 2800
8909, 507, 508, 2388, 2387, 693, 694, 2802, 2801
8910, 508, 509, 2389, 2388, 694, 695, 2803, 2802
8911, 509, 510, 2390, 2389, 695, 696, 2804, 2803
8912, 510, 511, 2391, 2390, 696, 697, 2805, 2804
8913, 511, 512, 2392, 2391, 697, 698, 2806, 2805
8914, 512, 39, 535, 2392, 698, 64, 704, 2806
8915, 459, 2382, 2393, 460, 699, 2796, 2807, 700
8916, 2382, 2383, 2394, 2393, 2796, 2797, 2808, 2807
8917, 2383, 2384, 2395, 2394, 2797, 2798, 2809, 2808
8918, 2384, 2385, 2396, 2395, 2798, 2799, 2810, 2809
8919, 2385, 2386, 2397, 2396, 2799, 2800, 2811, 2810
8920, 2386, 2387, 2398, 2397, 2800, 2801, 2812, 2811
8921, 2387, 2388, 2399, 2398, 2801, 2802, 2813, 2812
8922, 2388, 2389, 2400, 2399, 2802, 2803, 2814, 2813
8923, 2389, 2390, 2401, 2400, 2803, 2804, 2815, 2814
8924, 2390, 2391, 2402, 2401, 2804, 2805, 2816, 2815
8925, 2391, 2392, 2403, 2402, 2805, 2806, 2817, 2816
8926, 2392, 535, 536, 2403, 2806, 704, 705, 2817
8927, 460, 2393, 2404, 461, 700, 2807, 2818, 701
8928, 2393, 2394, 2405, 2404, 2807, 2808, 2819, 2818
8929, 2394, 2395, 2406, 2405, 2808, 2809, 2820, 2819
8930, 2395, 2396, 2407, 2406, 2809, 2810, 2821, 2820
8931, 2396, 2397, 2408, 2407, 2810, 2811, 2822, 2821
8932, 2397, 2398, 2409, 2408, 2811, 2812, 2823, 2822
8933, 2398, 2399, 2410, 2409, 2812, 2813, 2824, 2823
8934, 2399, 2400, 2411, 2410, 2813, 2814, 2825, 2824
8935, 2400, 2401, 2412, 2411, 2814, 2815, 2826, 2825
8936, 2401, 2402, 2413, 2412, 2815, 2816, 2827, 2826
8937, 2402, 2403, 2414, 2413, 2816, 2817, 2828, 2827
8938, 2403, 536, 537, 2414, 2817, 705, 706, 2828
8939, 461, 2404, 2415, 462, 701, 2818, 2829, 702
8940, 2404, 2405, 2416, 2415, 2818, 2819, 2830, 2829
8941, 2405, 2406, 2417, 2416, 2819, 2820, 2831, 2830
8942, 2406, 2407, 2418, 2417, 2820, 2821, 2832, 2831
8943, 2407, 2408, 2419, 2418, 2821, 2822, 2833, 2832
8944, 2408, 2409, 2420, 2419, 2822, 2823, 2834, 2833
8945, 2409, 2410, 2421, 2420, 2823, 2824, 2835, 2834
8946, 2410, 2411, 2422, 2421, 2824, 2825, 2836, 2835
8947, 2411, 2412, 2423, 2422, 2825, 2826, 2837, 2836
8948, 2412, 2413, 2424, 2423, 2826, 2827, 2838, 2837
8949, 2413, 2414, 2425, 2424, 2827, 2828, 2839, 2838
8950, 2414, 537, 538, 2425, 2828, 706, 707, 2839
8951, 462, 2415, 2426, 463, 702, 2829, 2840, 703
8952, 2415, 2416, 2427, 2426, 2829, 2830, 2841, 2840
8953, 2416, 2417, 2428, 2427, 2830, 2831, 2842, 2841
8954, 2417, 2418, 2429, 2428, 2831, 2832, 2843, 2842
8955, 2418, 2419, 2430, 2429, 2832, 2833, 2844, 2843
8956, 2419, 2420, 2431, 2430, 2833, 2834, 2845, 2844
8957, 2420, 2421, 2432, 2431, 2834, 2835, 2846, 2845
8958, 2421, 2422, 2433, 2432, 2835, 2836, 2847, 2846
8959, 2422, 2423, 2434, 2433, 2836, 2837, 2848, 2847
8960, 2423, 2424, 2435, 2434, 2837, 2838, 2849, 2848
8961, 2424, 2425, 2436, 2435, 2838, 2839, 2850, 2849
8962, 2425, 538, 539, 2436, 2839, 707, 708, 2850
8963, 463, 2426, 469, 33, 703, 2840, 677, 61
8964, 2426, 2427, 470, 469, 2840, 2841, 678, 677
8965, 2427, 2428, 471, 470, 2841, 2842, 679, 678
8966, 2428, 2429, 472, 471, 2842, 2843, 680, 679
8967, 2429, 2430, 473, 472, 2843, 2844, 681, 680
8968, 2430, 2431, 474, 473, 2844, 2845, 682, 681
8969, 2431, 2432, 475, 474, 2845, 2846, 683, 682
8970, 2432, 2433, 476, 475, 2846, 2847, 684, 683
8971, 2433, 2434, 477, 476, 2847, 2848, 685, 684
8972, 2434, 2435, 478, 477, 2848, 2849, 686, 685
8973, 2435, 2436, 479, 478, 2849, 2850, 687, 686
8974, 2436, 539, 37, 479, 2850, 708, 62, 687
*ELEMENT, type=C3D8, ELSET=Volume18
8975, 35, 502, 688, 63, 69, 753, 797, 73
8976, 502, 503, 689, 688, 753, 754, 798, 797
8977, 503, 504, 690, 689, 754, 755, 799, 798
8978, 504, 505, 691, 690, 755, 756, 800, 799
8979, 505, 506, 692, 691, 756, 757, 801, 800
8980, 506, 507, 693, 692, 757, 758, 802, 801
8981, 507, 508, 694, 693, 758, 759, 803, 802
8982, 508, 509, 695, 694, 759, 760, 804, 803
8983, 509, 510, 696, 695, 760, 761, 805, 804
8984, 510, 511, 697, 696, 761, 762, 806, 805
8985, 511, 512, 698, 697, 762, 763, 807, 806
8986, 512, 39, 64, 698, 763, 70, 74, 807
*ELEMENT, type=C3D8, ELSET=Volume19
8987, 9, 201, 656, 59, 65, 709, 808, 75
8988, 201, 202, 657, 656, 709, 710, 809, 808
8989, 202, 203, 658, 657, 710, 711, 810, 809
8990, 203, 204, 659, 658, 711, 712, 811, 810
8991, 204, 205, 660, 659, 712, 713, 812, 811
8992, 205, 206, 661, 660, 713, 714, 813, 812
8993, 206, 207, 662, 661, 714, 715, 814, 813
8994, 207, 208, 663, 662, 715, 716, 815, 814
8995, 208, 209, 664, 663, 716, 717, 816, 815
8996, 209, 210, 665, 664, 717, 718, 817, 816
8997, 210, 211, 666, 665, 718, 719, 818, 817
8998, 211, 13, 60, 666, 719, 66, 76, 818
*ELEMENT, type=C3D8, ELSET=Volume20
8999, 22, 344, 1800, 313, 823, 3201, 5607, 3093
9000, 823, 3201, 5607, 3093, 824, 3202, 5608, 3094
9001, 824, 3202, 5608, 3094, 825, 3203, 5609, 3095
9002, 825, 3203, 5609, 3095, 826, 3204, 5610, 3096
9003, 826, 3204, 5610, 3096, 78, 862, 3221, 827
9004, 344, 345, 1801, 1800, 3201, 3205, 5611, 5607
9005, 3201, 3205, 5611, 5607, 3202, 3206, 5612, 5608
9006, 3202, 3206, 5612, 5608, 3203, 3207, 5613, 5609
9007, 3203, 3207, 5613, 5609, 3204, 3208, 5614, 5610
9008, 3204, 3208, 5614, 5610, 862, 863, 3222, 3221
9009, 345, 346, 1802, 1801, 3205, 3209, 5615, 5611
9010, 3205, 3209, 5615, 5611, 3206, 3210, 5616, 5612
9011, 3206, 3210, 5616, 5612, 3207, 3211, 5617, 5613
9012, 3207, 3211, 5617, 5613, 3208, 3212, 5618, 5614
9013, 3208, 3212, 5618, 5614, 863, 864, 3223, 3222
9014, 346, 347, 1803, 1802, 3209, 3213, 5619, 5615
9015, 3209, 3213, 5619, 5615, 3210, 3214, 5620, 5616
9016, 3210, 3214, 5620, 5616, 3211, 3215, 5621, 5617
9017, 3211, 3215, 5621, 5617, 3212, 3216, 5622, 5618
9018, 3212, 3216, 5622, 5618, 864, 865, 3224, 3223
9019, 347, 348, 1804, 1803, 3213, 3217, 5623, 5619
9020, 3213, 3217, 5623, 5619, 3214, 3218, 5624, 5620
9021, 3214, 3218, 5624, 5620, 3215, 3219, 5625, 5621
9022, 3215, 3219, 5625, 5621, 3216, 3220, 5626, 5622
9023, 3216, 3220, 5626, 5622, 865, 866, 3225, 3224
9024, 348, 24, 333, 1804, 3217, 847, 3157, 5623
9025, 3217, 847, 3157, 5623, 3218, 848, 3158, 5624
9026, 3218, 848, 3158, 5624, 3219, 849, 3159, 5625
9027, 3219, 849, 3159, 5625, 3220, 850, 3160, 5626
9028, 3220, 850, 3160, 5626, 866, 80, 851, 3225
9029, 313, 1800, 1805, 314, 3093, 5607, 5627, 3097
9030, 3093, 5607, 5627, 3097, 3094, 5608, 5628, 3098
9031, 3094, 5608, 5628, 3098, 3095, 5609, 5629, 3099
9032, 3095, 5609, 5629, 3099, 3096, 5610, 5630, 3100
9033, 3096, 5610, 5630, 3100, 827, 3221, 3226, 828
9034, 1800, 1801, 1806, 1805, 5607, 5611, 5631, 5627
9035, 5607, 5611, 5631, 5627, 5608, 5612, 5632, 5628
9036, 5608, 5612, 5632, 5628, 5609, 5613, 5633, 5629
9037, 5609, 5613, 5633, 5629, 5610, 5614, 5634, 5630
9038, 5610, 5614, 5634, 5630, 3221, 3222, 3227, 3226
9039, 1801, 1802, 1807, 1806, 5611, 5615, 5635, 5631
9040, 5611, 5615, 5635, 5631, 5612, 5616, 5636, 5632
9041, 5612, 5616, 5636, 5632, 5613, 5617, 5637, 5633
9042, 5613, 5617, 5637, 5633, 5614, 5618, 5638, 5634
9043, 5614, 5618, 5638, 5634, 3222, 3223, 3228, 3227
9044, 1802, 1803, 1808, 1807, 5615, 5619, 5639, 5635
9045, 5615, 5619, 5639, 5635, 5616, 5620, 5640, 5636
9046, 5616, 5620, 5640, 5636, 5617, 5621, 5641, 5637
9047, 5617, 5621, 5641, 5637, 5618, 5622, 5642, 5638
9048, 5618, 5622, 5642, 5638, 3223, 3224, 3229, 3228
9049, 1803, 1804, 1809, 1808, 5619, 5623, 5643, 5639
9050, 5619, 5623, 5643, 5639, 5620, 5624, 5644, 5640
9051, 5620, 5624, 5644, 5640, 5621, 5625, 5645, 5641
9052, 5621, 5625, 5645, 5641, 5622, 5626, 5646, 5642
9053, 5622, 5626, 5646, 5642, 3224, 3225, 3230, 3229
9054, 1804, 333, 334, 1809, 5623, 3157, 3161, 5643
9055, 5623, 3157, 3161, 5643, 5624, 3158, 3162, 5644
9056, 5624, 3158, 3162, 5644, 5625, 3159, 3163, 5645
9057, 5625, 3159, 3163, 5645, 5626, 3160, 3164, 5646
9058, 5626, 3160, 3164, 5646, 3225, 851, 852, 3230
9059, 314, 1805, 1810, 315, 3097, 5627, 5647, 3101
9060, 3097, 5627, 5647, 3101, 3098, 5628, 5648, 3102
9061, 3098, 5628, 5648, 3102, 3099, 5629, 5649, 3103
9062, 3099, 5629, 5649, 3103, 3100, 5630, 5650, 3104
9063, 3100, 5630, 5650, 3104, 828, 3226, 3231, 829
9064, 1805, 1806, 1811, 1810, 5627, 5631, 5651, 5647
9065, 5627, 5631, 5651, 5647, 5628, 5632, 5652, 5648
9066, 5628, 5632, 5652, 5648, 5629, 5633, 5653, 5649
9067, 5629, 5633, 5653, 5649, 5630, 5634, 5654, 5650
9068, 5630, 5634, 5654, 5650, 3226, 3227, 3232, 3231
9069, 1806, 1807, 1812, 1811, 5631, 5635, 5655, 5651
9070, 5631, 5635, 5655, 5651, 5632, 5636, 5656, 5652
9071, 5632, 5636, 5656, 5652, 5633, 5637, 5657, 5653
9072, 5633, 5637, 5657, 5653, 5634, 5638, 5658, 5654
9073, 5634, 5638, 5658, 5654, 3227, 3228, 3233, 3232
9074, 1807, 1808, 1813, 1812, 5635, 5639, 5659, 5655
9075, 5635, 5639, 5659, 5655, 5636, 5640, 5660, 5656
9076, 5636, 5640, 5660, 5656, 5637, 5641, 5661, 5657
9077, 5637, 5641, 5661, 5657, 5638, 5642, 5662, 5658
9078, 5638, 5642, 5662, 5658, 3228, 3229, 3234, 3233
9079, 1808, 1809, 1814, 1813, 5639, 5643, 5663, 5659
9080, 5639, 5643, 5663, 5659, 5640, 5644, 5664, 5660
9081, 5640, 5644, 5664, 5660, 5641, 5645, 5665, 5661
9082, 5641, 5645, 5665, 5661, 5642, 5646, 5666, 5662
9083, 5642, 5646, 5666, 5662, 3229, 3230, 3235, 3234
9084, 1809, 334, 335, 1814, 5643, 3161, 3165, 5663
9085, 5643, 3161, 3165, 5663, 5644, 3162, 3166, 5664
9086, 5644, 3162, 3166, 5664, 5645, 3163, 3167, 5665
9087, 5645, 3163, 3167, 5665, 5646, 3164, 3168, 5666
9088, 5646, 3164, 3168, 5666, 3230, 852, 853, 3235
9089, 315, 1810, 1815, 316, 3101, 5647, 5667, 3105
9090, 3101, 5647, 5667, 3105, 3102, 5648, 5668, 3106
9091, 3102, 5648, 5668, 3106, 3103, 5649, 5669, 3107
9092, 3103, 5649, 5669, 3107, 3104, 5650, 5670, 3108
9093, 3104, 5650, 5670, 3108, 829, 3231, 3236, 830
9094, 1810, 1811, 1816, 1815, 5647, 5651, 5671, 5667
9095, 5647, 5651, 5671, 5667, 5648, 5652, 5672, 5668
9096, 5648, 5652, 5672, 5668, 5649, 5653, 5673, 5669
9097, 5649, 5653, 5673, 5669, 5650, 5654, 5674, 5670
9098, 5650, 5654, 5674, 5670, 3231, 3232, 3237, 3236
9099, 1811, 1812, 1817, 1816, 5651, 5655, 5675, 5671
9100, 5651, 5655, 5675, 5671, 5652, 5656, 5676, 5672
9101, 5652, 5656, 5676, 5672, 5653, 5657, 5677, 5673
9102, 5653, 5657, 5677, 5673, 5654, 5658, 5678, 5674
9103, 5654, 5658, 5678, 5674, 3232, 3233, 3238, 3237
9104, 1812, 1813, 1818, 1817, 5655, 5659, 5679, 5675
9105, 5655, 5659, 5679, 5675, 5656, 5660, 5680, 5676
9106, 5656, 5660, 5680, 5676, 5657, 5661, 5681, 5677
9107, 5657, 5661, 5681, 5677, 5658, 5662, 5682, 5678
9108, 5658, 5662, 5682, 5678, 3233, 3234, 3239, 3238
9109, 1813, 1814, 1819, 1818, 5659, 5663, 5683, 5679
9110, 5659, 5663, 5683, 5679, 5660, 5664, 5684, 5680
9111, 5660, 5664, 5684, 5680, 5661, 5665, 5685, 5681
9112, 5661, 5665, 5685, 5681, 5662, 5666, 5686, 5682
9113, 5662, 5666, 5686, 5682, 3234, 3235, 3240, 3239
9114, 1814, 335, 336, 1819, 5663, 3165, 3169, 5683
9115, 5663, 3165, 3169, 5683, 5664, 3166, 3170, 5684
9116, 5664, 3166, 3170, 5684, 5665, 3167, 3171, 5685
9117, 5665, 3167, 3171, 5685, 5666, 3168, 3172, 5686
9118, 5666, 3168, 3172, 5686, 3235, 853, 854, 3240
9119, 316, 1815, 1820, 317, 3105, 5667, 5687, 3109
9120, 3105, 5667, 5687, 3109, 3106, 5668, 5688, 3110
9121, 3106, 5668, 5688, 3110, 3107, 5669, 5689, 3111
9122, 3107, 5669, 5689, 3111, 3108, 5670, 5690, 3112
9123, 3108, 5670, 5690, 3112, 830, 3236, 3241, 831
9124, 1815, 1816, 1821, 1820, 5667, 5671, 5691, 5687
9125, 5667, 5671, 5691, 5687, 5668, 5672, 5692, 5688
9126, 5668, 5672, 5692, 5688, 5669, 5673, 5693, 5689
9127, 5669, 5673, 5693, 5689, 5670, 5674, 5694, 5690
9128, 5670, 5674, 5694, 5690, 3236, 3237, 3242, 3241
9129, 1816, 1817, 1822, 1821, 5671, 5675, 5695, 5691
9130, 5671, 5675, 5695, 5691, 5672, 5676, 5696, 5692
9131, 5672, 5676, 5696, 5692, 5673, 5677, 5697, 5693
9132, 5673, 5677, 5697, 5693, 5674, 5678, 5698, 5694
9133, 5674, 5678, 5698, 5694, 3237, 3238, 3243, 3242
9134, 1817, 1818, 1823, 1822, 5675, 5679, 5699, 5695
9135, 5675, 5679, 5699, 5695, 5676, 5680, 5700, 5696
9136, 5676, 5680, 5700, 5696, 5677, 5681, 5701, 5697
9137, 5677, 5681, 5701, 5697, 5678, 5682, 5702, 5698
9138, 5678, 5682, 5702, 5698, 3238, 3239, 3244, 3243
9139, 1818, 1819, 1824, 1823, 5679, 5683, 5703, 5699
9140, 5679, 5683, 5703, 5699, 5680, 5684, 5704, 5700
9141, 5680, 5684, 5704, 5700, 5681, 5685, 5705, 5701
9142, 5681, 5685, 5705, 5701, 5682, 5686, 5706, 5702
9143, 5682, 5686, 5706, 5702, 3239, 3240, 3245, 3244
9144, 1819, 336, 337, 1824, 5683, 3169, 3173, 5703
9145, 5683, 3169, 3173, 5703, 5684, 3170, 3174, 5704
9146, 5684, 3170, 3174, 5704, 5685, 3171, 3175, 5705
9147, 5685, 3171, 3175, 5705, 5686, 3172, 3176, 5706
9148, 5686, 3172, 3176, 5706, 3240, 854, 855, 3245
9149, 317, 1820, 1825, 318, 3109, 5687, 5707, 3113
9150, 3109, 5687, 5707, 3113, 3110, 5688, 5708, 3114
9151, 3110, 5688, 5708, 3114, 3111, 5689, 5709, 3115
9152, 3111, 5689, 5709, 3115, 3112, 5690, 5710, 3116
9153, 3112, 5690, 5710, 3116, 831, 3241, 3246, 832
9154, 1820, 1821, 1826, 1825, 5687, 5691, 5711, 5707
9155, 5687, 5691, 5711, 5707, 5688, 5692, 5712, 5708
9156, 5688, 5692, 5712, 5708, 5689, 5693, 5713, 5709
9157, 5689, 5693, 5713, 5709, 5690, 5694, 5714, 5710
9158, 5690, 5694, 5714, 5710, 3241, 3242, 3247, 3246
9159, 1821, 1822, 1827, 1826, 5691, 5695, 5715, 5711
9160, 5691, 5695, 5715, 5711, 5692, 5696, 5716, 5712
9161, 5692, 5696, 5716, 5712, 5693, 5697, 5717, 5713
9162, 5693, 5697, 5717, 5713, 5694, 5698, 5718, 5714
9163, 5694, 5698, 5718, 5714, 3242, 3243, 3248, 3247
9164, 1822, 1823, 1828, 1827, 5695, 5699, 5719, 5715
9165, 5695, 5699, 5719, 5715, 5696, 5700, 5720, 5716
9166, 5696, 5700, 5720, 5716, 5697, 5701, 5721, 5717
9167, 5697, 5701, 5721, 5717, 5698, 5702, 5722, 5718
9168, 5698, 5702, 5722, 5718, 3243, 3244, 3249, 3248
9169, 1823, 1824, 1829, 1828, 5699, 5703, 5723, 5719
9170, 5699, 5703, 5723, 5719, 5700, 5704, 5724, 5720
9171, 5700, 5704, 5724, 5720, 5701, 5705, 5725, 5721
9172, 5701, 5705, 5725, 5721, 5702, 5706, 5726, 5722
9173, 5702, 5706, 5726, 5722, 3244, 3245, 3250, 3249
9174, 1824, 337, 338, 1829, 5703, 3173, 3177, 5723
9175, 5703, 3173, 3177, 5723, 5704, 3174, 3178, 5724
9176, 5704, 3174, 3178, 5724, 5705, 3175, 3179, 5725
9177, 5705, 3175, 3179, 5725, 5706, 3176, 3180, 5726
9178, 5706, 3176, 3180, 5726, 3245, 855, 856, 3250
9179, 318, 1825, 1830, 319, 3113, 5707, 5727, 3117
9180, 3113, 5707, 5727, 3117, 3114, 5708, 5728, 3118
9181, 3114, 5708, 5728, 3118, 3115, 5709, 5729, 3119
9182, 3115, 5709, 5729, 3119, 3116, 5710, 5730, 3120
9183, 3116, 5710, 5730, 3120, 832, 3246, 3251, 833
9184, 1825, 1826, 1831, 1830, 5707, 5711, 5731, 5727
9185, 5707, 5711, 5731, 5727, 5708, 5712, 5732, 5728
9186, 5708, 5712, 5732, 5728, 5709, 5713, 5733, 5729
9187, 5709, 5713, 5733, 5729, 5710, 5714, 5734, 5730
9188, 5710, 5714, 5734, 5730, 3246, 3247, 3252, 3251
9189, 1826, 1827, 1832, 1831, 5711, 5715, 5735, 5731
9190, 5711, 5715, 5735, 5731, 5712, 5716, 5736, 5732
9191, 5712, 5716, 5736, 5732, 5713, 5717, 5737, 5733
9192, 5713, 5717, 5737, 5733, 5714, 5718, 5738, 5734
9193, 5714, 5718, 5738, 5734, 3247, 3248, 3253, 3252
9194, 1827, 1828, 1833, 1832, 5715, 5719, 5739, 5735
9195, 5715, 5719, 5739, 5735, 5716, 5720, 5740, 5736
9196, 5716, 5720, 5740, 5736, 5717, 5721, 5741, 5737
9197, 5717, 5721, 5741, 5737, 5718, 5722, 5742, 5738
9198, 5718, 5722, 5742, 5738, 3248, 3249, 3254, 3253
9199, 1828, 1829, 1834, 1833, 5719, 5723, 5743, 5739
9200, 5719, 5723, 5743, 5739, 5720, 5724, 5744, 5740
9201, 5720, 5724, 5744, 5740, 5721, 5725, 5745, 5741
9202, 5721, 5725, 5745, 5741, 5722, 5726, 5746, 5742
9203, 5722, 5726, 5746, 5742, 3249, 3250, 3255, 3254
9204, 1829, 338, 339, 1834, 5723, 3177, 3181, 5743
9205, 5723, 3177, 3181, 5743, 5724, 3178, 3182, 5744
9206, 5724, 3178, 3182, 5744, 5725, 3179, 3183, 5745
9207, 5725, 3179, 3183, 5745, 5726, 3180, 3184, 5746
9208, 5726, 3180, 3184, 5746, 3250, 856, 857, 3255
9209, 319, 1830, 1835, 320, 3117, 5727, 5747, 3121
9210, 3117, 5727, 5747, 3121, 3118, 5728, 5748, 3122
9211, 3118, 5728, 5748, 3122, 3119, 5729, 5749, 3123
9212, 3119, 5729, 5749, 3123, 3120, 5730, 5750, 3124
9213, 3120, 5730, 5750, 3124, 833, 3251, 3256, 834
9214, 1830, 1831, 1836, 1835, 5727, 5731, 5751, 5747
9215, 5727, 5731, 5751, 5747, 5728, 5732, 5752, 5748
9216, 5728, 5732, 5752, 5748, 5729, 5733, 5753, 5749
9217, 5729, 5733, 5753, 5749, 5730, 5734, 5754, 5750
9218, 5730, 5734, 5754, 5750, 3251, 3252, 3257, 3256
9219, 1831, 1832, 1837, 1836, 5731, 5735, 5755, 5751
9220, 5731, 5735, 5755, 5751, 5732, 5736, 5756, 5752
9221, 5732, 5736, 5756, 5752, 5733, 5737, 5757, 5753
9222, 5733, 5737, 5757, 5753, 5734, 5738, 5758, 5754
9223, 5734, 5738, 5758, 5754, 3252, 3253, 3258, 3257
9224, 1832, 1833, 1838, 1837, 5735, 5739, 5759, 5755
9225, 5735, 5739, 5759, 5755, 5736, 5740, 5760, 5756
9226, 5736, 5740, 5760, 5756, 5737, 5741, 5761, 5757
9227, 5737, 5741, 5761, 5757, 5738, 5742, 5762, 5758
9228, 5738, 5742, 5762, 5758, 3253, 3254, 3259, 3258
9229, 1833, 1834, 1839, 1838, 5739, 5743, 5763, 5759
9230, 5739, 5743, 5763, 5759, 5740, 5744, 5764, 5760
9231, 5740, 5744, 5764, 5760, 5741, 5745, 5765, 5761
9232, 5741, 5745, 5765, 5761, 5742, 5746, 5766, 5762
9233, 5742, 5746, 5766, 5762, 3254, 3255, 3260, 3259
9234, 1834, 339, 340, 1839, 5743, 3181, 3185, 5763
9235, 5743, 3181, 3185, 5763, 5744, 3182, 3186, 5764
9236, 5744, 3182, 3186, 5764, 5745, 3183, 3187, 5765
9237, 5745, 3183, 3187, 5765, 5746, 3184, 3188, 5766
9238, 5746, 3184, 3188, 5766, 3255, 857, 858, 3260
9239, 320, 1835, 1840, 321, 3121, 5747, 5767, 3125
9240, 3121, 5747, 5767, 3125, 3122, 5748, 5768, 3126
9241, 3122, 5748, 5768, 3126, 3123, 5749, 5769, 3127
9242, 3123, 5749, 5769, 3127, 3124, 5750, 5770, 3128
9243, 3124, 5750, 5770, 3128, 834, 3256, 3261, 835
9244, 1835, 1836, 1841, 1840, 5747, 5751, 5771, 5767
9245, 5747, 5751, 5771, 5767, 5748, 5752, 5772, 5768
9246, 5748, 5752, 5772, 5768, 5749, 5753, 5773, 5769
9247, 5749, 5753, 5773, 5769, 5750, 5754, 5774, 5770
9248, 5750, 5754, 5774, 5770, 3256, 3257, 3262, 3261
9249, 1836, 1837, 1842, 1841, 5751, 5755, 5775, 5771
9250, 5751, 5755, 5775, 5771, 5752, 5756, 5776, 5772
9251, 5752, 5756, 5776, 5772, 5753, 5757, 5777, 5773
9252, 5753, 5757, 5777, 5773, 5754, 5758, 5778, 5774
9253, 5754, 5758, 5778, 5774, 3257, 3258, 3263, 3262
9254, 1837, 1838, 1843, 1842, 5755, 5759, 5779, 5775
9255, 5755, 5759, 5779, 5775, 5756, 5760, 5780, 5776
9256, 5756, 5760, 5780, 5776, 5757, 5761, 5781, 5777
9257, 5757, 5761, 5781, 5777, 5758, 5762, 5782, 5778
9258, 5758, 5762, 5782, 5778, 3258, 3259, 3264, 3263
9259, 1838, 1839, 1844, 1843, 5759, 5763, 5783, 5779
9260, 5759, 5763, 5783, 5779, 5760, 5764, 5784, 5780
9261, 5760, 5764, 5784, 5780, 5761, 5765, 5785, 5781
9262, 5761, 5765, 5785, 5781, 5762, 5766, 5786, 5782
9263, 5762, 5766, 5786, 5782, 3259, 3260, 3265, 3264
9264, 1839, 340, 341, 1844, 5763, 3185, 3189, 5783
9265, 5763, 3185, 3189, 5783, 5764, 3186, 3190, 5784
9266, 5764, 3186, 3190, 5784, 5765, 3187, 3191, 5785
9267, 5765, 3187, 3191, 5785, 5766, 3188, 3192, 5786
9268, 5766, 3188, 3192, 5786, 3260, 858, 859, 3265
9269, 321, 1840, 1845, 322, 3125, 5767, 5787, 3129
9270, 3125, 5767, 5787, 3129, 3126, 5768, 5788, 3130
9271, 3126, 5768, 5788, 3130, 3127, 5769, 5789, 3131
9272, 3127, 5769, 5789, 3131, 3128, 5770, 5790, 3132
9273, 3128, 5770, 5790, 3132, 835, 3261, 3266, 836
9274, 1840, 1841, 1846, 1845, 5767, 5771, 5791, 5787
9275, 5767, 5771, 5791, 5787, 5768, 5772, 5792, 5788
9276, 5768, 5772, 5792, 5788, 5769, 5773, 5793, 5789
9277, 5769, 5773, 5793, 5789, 5770, 5774, 5794, 5790
9278, 5770, 5774, 5794, 5790, 3261, 3262, 3267, 3266
9279, 1841, 1842, 1847, 1846, 5771, 5775, 5795, 5791
9280, 5771, 5775, 5795, 5791, 5772, 5776, 5796, 5792
9281, 5772, 5776, 5796, 5792, 5773, 5777, 5797, 5793
9282, 5773, 5777, 5797, 5793, 5774, 5778, 5798, 5794
9283, 5774, 5778, 5798, 5794, 3262, 3263, 3268, 3267
9284, 1842, 1843, 1848, 1847, 5775, 5779, 5799, 5795
9285, 5775, 5779, 5799, 5795, 5776, 5780, 5800, 5796
9286, 5776, 5780, 5800, 5796, 5777, 5781, 5801, 5797
9287, 5777, 5781, 5801, 5797, 5778, 5782, 5802, 5798
9288, 5778, 5782, 5802, 5798, 3263, 3264, 3269, 3268
9289, 1843, 1844, 1849, 1848, 5779, 5783, 5803, 5799
9290, 5779, 5783, 5803, 5799, 5780, 5784, 5804, 5800
9291, 5780, 5784, 5804, 5800, 5781, 5785, 5805, 5801
9292, 5781, 5785, 5805, 5801, 5782, 5786, 5806, 5802
9293, 5782, 5786, 5806, 5802, 3264, 3265, 3270, 3269
9294, 1844, 341, 342, 1849, 5783, 3189, 3193, 5803
9295, 5783, 3189, 3193, 5803, 5784, 3190, 3194, 5804
9296, 5784, 3190, 3194, 5804, 5785, 3191, 3195, 5805
9297, 5785, 3191, 3195, 5805, 5786, 3192, 3196, 5806
9298, 5786, 3192, 3196, 5806, 3265, 859, 860, 3270
9299, 322, 1845, 1850, 323, 3129, 5787, 5807, 3133
9300, 3129, 5787, 5807, 3133, 3130, 5788, 5808, 3134
9301, 3130, 5788, 5808, 3134, 3131, 5789, 5809, 3135
9302, 3131, 5789, 5809, 3135, 3132, 5790, 5810, 3136
9303, 3132, 5790, 5810, 3136, 836, 3266, 3271, 837
9304, 1845, 1846, 1851, 1850, 5787, 5791, 5811, 5807
9305, 5787, 5791, 5811, 5807, 5788, 5792, 5812, 5808
9306, 5788, 5792, 5812, 5808, 5789, 5793, 5813, 5809
9307, 5789, 5793, 5813, 5809, 5790, 5794, 5814, 5810
9308, 5790, 5794, 5814, 5810, 3266, 3267, 3272, 3271
9309, 1846, 1847, 1852, 1851, 5791, 5795, 5815, 5811
9310, 5791, 5795, 5815, 5811, 5792, 5796, 5816, 5812
9311, 5792, 5796, 5816, 5812, 5793, 5797, 5817, 5813
9312, 5793, 5797, 5817, 5813, 5794, 5798, 5818, 5814
9313, 5794, 5798, 5818, 5814, 3267, 3268, 3273, 3272
9314, 1847, 1848, 1853, 1852, 5795, 5799, 5819, 5815
9315, 5795, 5799, 5819, 5815, 5796, 5800, 5820, 5816
9316, 5796, 5800, 5820, 5816, 5797, 5801, 5821, 5817
9317, 5797, 5801, 5821, 5817, 5798, 5802, 5822, 5818
9318, 5798, 5802, 5822, 5818, 3268, 3269, 3274, 3273
9319, 1848, 1849, 1854, 1853, 5799, 5803, 5823, 5819
9320, 5799, 5803, 5823, 5819, 5800, 5804, 5824, 5820
9321, 5800, 5804, 5824, 5820, 5801, 5805, 5825, 5821
9322, 5801, 5805, 5825, 5821, 5802, 5806, 5826, 5822
9323, 5802, 5806, 5826, 5822, 3269, 3270, 3275, 3274
9324, 1849, 342, 343, 1854, 5803, 3193, 3197, 5823
9325, 5803, 3193, 3197, 5823, 5804, 3194, 3198, 5824
9326, 5804, 3194, 3198, 5824, 5805, 3195, 3199, 5825
9327, 5805, 3195, 3199, 5825, 5806, 3196, 3200, 5826
9328, 5806, 3196, 3200, 5826, 3270, 860, 861, 3275
9329, 323, 1850, 326, 21, 3133, 5807, 3137, 819
9330, 3133, 5807, 3137, 819, 3134, 5808, 3138, 820
9331, 3134, 5808, 3138, 820, 3135, 5809, 3139, 821
9332, 3135, 5809, 3139, 821, 3136, 5810, 3140, 822
9333, 3136, 5810, 3140, 822, 837, 3271, 842, 77
9334, 1850, 1851, 327, 326, 5807, 5811, 3141, 3137
9335, 5807, 5811, 3141, 3137, 5808, 5812, 3142, 3138
9336, 5808, 5812, 3142, 3138, 5809, 5813, 3143, 3139
9337, 5809, 5813, 3143, 3139, 5810, 5814, 3144, 3140
9338, 5810, 5814, 3144, 3140, 3271, 3272, 843, 842
9339, 1851, 1852, 328, 327, 5811, 5815, 3145, 3141
9340, 5811, 5815, 3145, 3141, 5812, 5816, 3146, 3142
9341, 5812, 5816, 3146, 3142, 5813, 5817, 3147, 3143
9342, 5813, 5817, 3147, 3143, 5814, 5818, 3148, 3144
9343, 5814, 5818, 3148, 3144, 3272, 3273, 844, 843
9344, 1852, 1853, 329, 328, 5815, 5819, 3149, 3145
9345, 5815, 5819, 3149, 3145, 5816, 5820, 3150, 3146
9346, 5816, 5820, 3150, 3146, 5817, 5821, 3151, 3147
9347, 5817, 5821, 3151, 3147, 5818, 5822, 3152, 3148
9348, 5818, 5822, 3152, 3148, 3273, 3274, 845, 844
9349, 1853, 1854, 330, 329, 5819, 5823, 3153, 3149
9350, 5819, 5823, 3153, 3149, 5820, 5824, 3154, 3150
9351, 5820, 5824, 3154, 3150, 5821, 5825, 3155, 3151
9352, 5821, 5825, 3155, 3151, 5822, 5826, 3156, 3152
9353, 5822, 5826, 3156, 3152, 3274, 3275, 846, 845
9354, 1854, 343, 23, 330, 5823, 3197, 838, 3153
9355, 5823, 3197, 838, 3153, 5824, 3198, 839, 3154
9356, 5824, 3198, 839, 3154, 5825, 3199, 840, 3155
9357, 5825, 3199, 840, 3155, 5826, 3200, 841, 3156
9358, 5826, 3200, 841, 3156, 3275, 861, 79, 846
*ELEMENT, type=C3D8, ELSET=Volume21
9359, 21, 326, 1891, 363, 819, 3137, 5827, 3292
9360, 819, 3137, 5827, 3292, 820, 3138, 5828, 3293
9361, 820, 3138, 5828, 3293, 821, 3139, 5829, 3294
9362, 821, 3139, 5829, 3294, 822, 3140, 5830, 3295
9363, 822, 3140, 5830, 3295, 77, 842, 3328, 879
9364, 363, 1891, 1892, 364, 3292, 5827, 5831, 3296
9365, 3292, 5827, 5831, 3296, 3293, 5828, 5832, 3297
9366, 3293, 5828, 5832, 3297, 3294, 5829, 5833, 3298
9367, 3294, 5829, 5833, 3298, 3295, 5830, 5834, 3299
9368, 3295, 5830, 5834, 3299, 879, 3328, 3329, 880
9369, 364, 1892, 1893, 365, 3296, 5831, 5835, 3300
9370, 3296, 5831, 5835, 3300, 3297, 5832, 5836, 3301
9371, 3297, 5832, 5836, 3301, 3298, 5833, 5837, 3302
9372, 3298, 5833, 5837, 3302, 3299, 5834, 5838, 3303
9373, 3299, 5834, 5838, 3303, 880, 3329, 3330, 881
9374, 365, 1893, 1894, 366, 3300, 5835, 5839, 3304
9375, 3300, 5835, 5839, 3304, 3301, 5836, 5840, 3305
9376, 3301, 5836, 5840, 3305, 3302, 5837, 5841, 3306
9377, 3302, 5837, 5841, 3306, 3303, 5838, 5842, 3307
9378, 3303, 5838, 5842, 3307, 881, 3330, 3331, 882
9379, 366, 1894, 374, 28, 3304, 5839, 3308, 875
9380, 3304, 5839, 3308, 875, 3305, 5840, 3309, 876
9381, 3305, 5840, 3309, 876, 3306, 5841, 3310, 877
9382, 3306, 5841, 3310, 877, 3307, 5842, 3311, 878
9383, 3307, 5842, 3311, 878, 882, 3331, 883, 82
9384, 326, 327, 1895, 1891, 3137, 3141, 5843, 5827
9385, 3137, 3141, 5843, 5827, 3138, 3142, 5844, 5828
9386, 3138, 3142, 5844, 5828, 3139, 3143, 5845, 5829
9387, 3139, 3143, 5845, 5829, 3140, 3144, 5846, 5830
9388, 3140, 3144, 5846, 5830, 842, 843, 3332, 3328
9389, 1891, 1895, 1896, 1892, 5827, 5843, 5847, 5831
9390, 5827, 5843, 5847, 5831, 5828, 5844, 5848, 5832
9391, 5828, 5844, 5848, 5832, 5829, 5845, 5849, 5833
9392, 5829, 5845, 5849, 5833, 5830, 5846, 5850, 5834
9393, 5830, 5846, 5850, 5834, 3328, 3332, 3333, 3329
9394, 1892, 1896, 1897, 1893, 5831, 5847, 5851, 5835
9395, 5831, 5847, 5851, 5835, 5832, 5848, 5852, 5836
9396, 5832, 5848, 5852, 5836, 5833, 5849, 5853, 5837
9397, 5833, 5849, 5853, 5837, 5834, 5850, 5854, 5838
9398, 5834, 5850, 5854, 5838, 3329, 3333, 3334, 3330
9399, 1893, 1897, 1898, 1894, 5835, 5851, 5855, 5839
9400, 5835, 5851, 5855, 5839, 5836, 5852, 5856, 5840
9401, 5836, 5852, 5856, 5840, 5837, 5853, 5857, 5841
9402, 5837, 5853, 5857, 5841, 5838, 5854, 5858, 5842
9403, 5838, 5854, 5858, 5842, 3330, 3334, 3335, 3331
9404, 1894, 1898, 375, 374, 5839, 5855, 3312, 3308
9405, 5839, 5855, 3312, 3308, 5840, 5856, 3313, 3309
9406, 5840, 5856, 3313, 3309, 5841, 5857, 3314, 3310
9407, 5841, 5857, 3314, 3310, 5842, 5858, 3315, 3311
9408, 5842, 5858, 3315, 3311, 3331, 3335, 884, 883
9409, 327, 328, 1899, 1895, 3141, 3145, 5859, 5843
9410, 3141, 3145, 5859, 5843, 3142, 3146, 5860, 5844
9411, 3142, 3146, 5860, 5844, 3143, 3147, 5861, 5845
9412, 3143, 3147, 5861, 5845, 3144, 3148, 5862, 5846
9413, 3144, 3148, 5862, 5846, 843, 844, 3336, 3332
9414, 1895, 1899, 1900, 1896, 5843, 5859, 5863, 5847
9415, 5843, 5859, 5863, 5847, 5844, 5860, 5864, 5848
9416, 5844, 5860, 5864, 5848, 5845, 5861, 5865, 5849
9417, 5845, 5861, 5865, 5849, 5846, 5862, 5866, 5850
9418, 5846, 5862, 5866, 5850, 3332, 3336, 3337, 3333
9419, 1896, 1900, 1901, 1897, 5847, 5863, 5867, 5851
9420, 5847, 5863, 5867, 5851, 5848, 5864, 5868, 5852
9421, 5848, 5864, 5868, 5852, 5849, 5865, 5869, 5853
9422, 5849, 5865, 5869, 5853, 5850, 5866, 5870, 5854
9423, 5850, 5866, 5870, 5854, 3333, 3337, 3338, 3334
9424, 1897, 1901, 1902, 1898, 5851, 5867, 5871, 5855
9425, 5851, 5867, 5871, 5855, 5852, 5868, 5872, 5856
9426, 5852, 5868, 5872, 5856, 5853, 5869, 5873, 5857
9427, 5853, 5869, 5873, 5857, 5854, 5870, 5874, 5858
9428, 5854, 5870, 5874, 5858, 3334, 3338, 3339, 3335
9429, 1898, 1902, 376, 375, 5855, 5871, 3316, 3312
9430, 5855, 5871, 3316, 3312, 5856, 5872, 3317, 3313
9431, 5856, 5872, 3317, 3313, 5857, 5873, 3318, 3314
9432, 5857, 5873, 3318, 3314, 5858, 5874, 3319, 3315
9433, 5858, 5874, 3319, 3315, 3335, 3339, 885, 884
9434, 328, 329, 1903, 1899, 3145, 3149, 5875, 5859
9435, 3145, 3149, 5875, 5859, 3146, 3150, 5876, 5860
9436, 3146, 3150, 5876, 5860, 3147, 3151, 5877, 5861
9437, 3147, 3151, 5877, 5861, 3148, 3152, 5878, 5862
9438, 3148, 3152, 5878, 5862, 844, 845, 3340, 3336
9439, 1899, 1903, 1904, 1900, 5859, 5875, 5879, 5863
9440, 5859, 5875, 5879, 5863, 5860, 5876, 5880, 5864
9441, 5860, 5876, 5880, 5864, 5861, 5877, 5881, 5865
9442, 5861, 5877, 5881, 5865, 5862, 5878, 5882, 5866
9443, 5862, 5878, 5882, 5866, 3336, 3340, 3341, 3337
9444, 1900, 1904, 1905, 1901, 5863, 5879, 5883, 5867
9445, 5863, 5879, 5883, 5867, 5864, 5880, 5884, 5868
9446, 5864, 5880, 5884, 5868, 5865, 5881, 5885, 5869
9447, 5865, 5881, 5885, 5869, 5866, 5882, 5886, 5870
9448, 5866, 5882, 5886, 5870, 3337, 3341, 3342, 3338
9449, 1901, 1905, 1906, 1902, 5867, 5883, 5887, 5871
9450, 5867, 5883, 5887, 5871, 5868, 5884, 5888, 5872
9451, 5868, 5884, 5888, 5872, 5869, 5885, 5889, 5873
9452, 5869, 5885, 5889, 5873, 5870, 5886, 5890, 5874
9453, 5870, 5886, 5890, 5874, 3338, 3342, 3343, 3339
9454, 1902, 1906, 377, 376, 5871, 5887, 3320, 3316
9455, 5871, 5887, 3320, 3316, 5872, 5888, 3321, 3317
9456, 5872, 5888, 3321, 3317, 5873, 5889, 3322, 3318
9457, 5873, 5889, 3322, 3318, 5874, 5890, 3323, 3319
9458, 5874, 5890, 3323, 3319, 3339, 3343, 886, 885
9459, 329, 330, 1907, 1903, 3149, 3153, 5891, 5875
9460, 3149, 3153, 5891, 5875, 3150, 3154, 5892, 5876
9461, 3150, 3154, 5892, 5876, 3151, 3155, 5893, 5877
9462, 3151, 3155, 5893, 5877, 3152, 3156, 5894, 5878
9463, 3152, 3156, 5894, 5878, 845, 846, 3344, 3340
9464, 1903, 1907, 1908, 1904, 5875, 5891, 5895, 5879
9465, 5875, 5891, 5895, 5879, 5876, 5892, 5896, 5880
9466, 5876, 5892, 5896, 5880, 5877, 5893, 5897, 5881
9467, 5877, 5893, 5897, 5881, 5878, 5894, 5898, 5882
9468, 5878, 5894, 5898, 5882, 3340, 3344, 3345, 3341
9469, 1904, 1908, 1909, 1905, 5879, 5895, 5899, 5883
9470, 5879, 5895, 5899, 5883, 5880, 5896, 5900, 5884
9471, 5880, 5896, 5900, 5884, 5881, 5897, 5901, 5885
9472, 5881, 5897, 5901, 5885, 5882, 5898, 5902, 5886
9473, 5882, 5898, 5902, 5886, 3341, 3345, 3346, 3342
9474, 1905, 1909, 1910, 1906, 5883, 5899, 5903, 5887
9475, 5883, 5899, 5903, 5887, 5884, 5900, 5904, 5888
9476, 5884, 5900, 5904, 5888, 5885, 5901, 5905, 5889
9477, 5885, 5901, 5905, 5889, 5886, 5902, 5906, 5890
9478, 5886, 5902, 5906, 5890, 3342, 3346, 3347, 3343
9479, 1906, 1910, 378, 377, 5887, 5903, 3324, 3320
9480, 5887, 5903, 3324, 3320, 5888, 5904, 3325, 3321
9481, 5888, 5904, 3325, 3321, 5889, 5905, 3326, 3322
9482, 5889, 5905, 3326, 3322, 5890, 5906, 3327, 3323
9483, 5890, 5906, 3327, 3323, 3343, 3347, 887, 886
9484, 330, 23, 353, 1907, 3153, 838, 3276, 5891
9485, 3153, 838, 3276, 5891, 3154, 839, 3277, 5892
9486, 3154, 839, 3277, 5892, 3155, 840, 3278, 5893
9487, 3155, 840, 3278, 5893, 3156, 841, 3279, 5894
9488, 3156, 841, 3279, 5894, 846, 79, 871, 3344
9489, 1907, 353, 354, 1908, 5891, 3276, 3280, 5895
9490, 5891, 3276, 3280, 5895, 5892, 3277, 3281, 5896
9491, 5892, 3277, 3281, 5896, 5893, 3278, 3282, 5897
9492, 5893, 3278, 3282, 5897, 5894, 3279, 3283, 5898
9493, 5894, 3279, 3283, 5898, 3344, 871, 872, 3345
9494, 1908, 354, 355, 1909, 5895, 3280, 3284, 5899
9495, 5895, 3280, 3284, 5899, 5896, 3281, 3285, 5900
9496, 5896, 3281, 3285, 5900, 5897, 3282, 3286, 5901
9497, 5897, 3282, 3286, 5901, 5898, 3283, 3287, 5902
9498, 5898, 3283, 3287, 5902, 3345, 872, 873, 3346
9499, 1909, 355, 356, 1910, 5899, 3284, 3288, 5903
9500, 5899, 3284, 3288, 5903, 5900, 3285, 3289, 5904
9501, 5900, 3285, 3289, 5904, 5901, 3286, 3290, 5905
9502, 5901, 3286, 3290, 5905, 5902, 3287, 3291, 5906
9503, 5902, 3287, 3291, 5906, 3346, 873, 874, 3347
9504, 1910, 356, 26, 378, 5903, 3288, 867, 3324
9505, 5903, 3288, 867, 3324, 5904, 3289, 868, 3325
9506, 5904, 3289, 868, 3325, 5905, 3290, 869, 3326
9507, 5905, 3290, 869, 3326, 5906, 3291, 870, 3327
9508, 5906, 3291, 870, 3327, 3347, 874, 81, 887
*ELEMENT, type=C3D8, ELSET=Volume22
9509, 28, 374, 2020, 414, 875, 3308, 5907, 3392
9510, 875, 3308, 5907, 3392, 876, 3309, 5908, 3393
9511, 876, 3309, 5908, 3393, 877, 3310, 5909, 3394
9512, 877, 3310, 5909, 3394, 878, 3311, 5910, 3395
9513, 878, 3311, 5910, 3395, 82, 883, 3456, 907
9514, 414, 2020, 2021, 415, 3392, 5907, 5911, 3396
9515, 3392, 5907, 5911, 3396, 3393, 5908, 5912, 3397
9516, 3393, 5908, 5912, 3397, 3394, 5909, 5913, 3398
9517, 3394, 5909, 5913, 3398, 3395, 5910, 5914, 3399
9518, 3395, 5910, 5914, 3399, 907, 3456, 3457, 908
9519, 415, 2021, 2022, 416, 3396, 5911, 5915, 3400
9520, 3396, 5911, 5915, 3400, 3397, 5912, 5916, 3401
9521, 3397, 5912, 5916, 3401, 3398, 5913, 5917, 3402
9522, 3398, 5913, 5917, 3402, 3399, 5914, 5918, 3403
9523, 3399, 5914, 5918, 3403, 908, 3457, 3458, 909
9524, 416, 2022, 2023, 417, 3400, 5915, 5919, 3404
9525, 3400, 5915, 5919, 3404, 3401, 5916, 5920, 3405
9526, 3401, 5916, 5920, 3405, 3402, 5917, 5921, 3406
9527, 3402, 5917, 5921, 3406, 3403, 5918, 5922, 3407
9528, 3403, 5918, 5922, 3407, 909, 3458, 3459, 910
9529, 417, 2023, 2024, 418, 3404, 5919, 5923, 3408
9530, 3404, 5919, 5923, 3408, 3405, 5920, 5924, 3409
9531, 3405, 5920, 5924, 3409, 3406, 5921, 5925, 3410
9532, 3406, 5921, 5925, 3410, 3407, 5922, 5926, 3411
9533, 3407, 5922, 5926, 3411, 910, 3459, 3460, 911
9534, 418, 2024, 2025, 419, 3408, 5923, 5927, 3412
9535, 3408, 5923, 5927, 3412, 3409, 5924, 5928, 3413
9536, 3409, 5924, 5928, 3413, 3410, 5925, 5929, 3414
9537, 3410, 5925, 5929, 3414, 3411, 5926, 5930, 3415
9538, 3411, 5926, 5930, 3415, 911, 3460, 3461, 912
9539, 419, 2025, 2026, 420, 3412, 5927, 5931, 3416
9540, 3412, 5927, 5931, 3416, 3413, 5928, 5932, 3417
9541, 3413, 5928, 5932, 3417, 3414, 5929, 5933, 3418
9542, 3414, 5929, 5933, 3418, 3415, 5930, 5934, 3419
9543, 3415, 5930, 5934, 3419, 912, 3461, 3462, 913
9544, 420, 2026, 2027, 421, 3416, 5931, 5935, 3420
9545, 3416, 5931, 5935, 3420, 3417, 5932, 5936, 3421
9546, 3417, 5932, 5936, 3421, 3418, 5933, 5937, 3422
9547, 3418, 5933, 5937, 3422, 3419, 5934, 5938, 3423
9548, 3419, 5934, 5938, 3423, 913, 3462, 3463, 914
9549, 421, 2027, 2028, 422, 3420, 5935, 5939, 3424
9550, 3420, 5935, 5939, 3424, 3421, 5936, 5940, 3425
9551, 3421, 5936, 5940, 3425, 3422, 5937, 5941, 3426
9552, 3422, 5937, 5941, 3426, 3423, 5938, 5942, 3427
9553, 3423, 5938, 5942, 3427, 914, 3463, 3464, 915
9554, 422, 2028, 2029, 423, 3424, 5939, 5943, 3428
9555, 3424, 5939, 5943, 3428, 3425, 5940, 5944, 3429
9556, 3425, 5940, 5944, 3429, 3426, 5941, 5945, 3430
9557, 3426, 5941, 5945, 3430, 3427, 5942, 5946, 3431
9558, 3427, 5942, 5946, 3431, 915, 3464, 3465, 916
9559, 423, 2029, 2030, 424, 3428, 5943, 5947, 3432
9560, 3428, 5943, 5947, 3432, 3429, 5944, 5948, 3433
9561, 3429, 5944, 5948, 3433, 3430, 5945, 5949, 3434
9562, 3430, 5945, 5949, 3434, 3431, 5946, 5950, 3435
9563, 3431, 5946, 5950, 3435, 916, 3465, 3466, 917
9564, 424, 2030, 432, 32, 3432, 5947, 3436, 903
9565, 3432, 5947, 3436, 903, 3433, 5948, 3437, 904
9566, 3433, 5948, 3437, 904, 3434, 5949, 3438, 905
9567, 3434, 5949, 3438, 905, 3435, 5950, 3439, 906
9568, 3435, 5950, 3439, 906, 917, 3466, 918, 84
9569, 374, 375, 2031, 2020, 3308, 3312, 5951, 5907
9570, 3308, 3312, 5951, 5907, 3309, 3313, 5952, 5908
9571, 3309, 3313, 5952, 5908, 3310, 3314, 5953, 5909
9572, 3310, 3314, 5953, 5909, 3311, 3315, 5954, 5910
9573, 3311, 3315, 5954, 5910, 883, 884, 3467, 3456
9574, 2020, 2031, 2032, 2021, 5907, 5951, 5955, 5911
9575, 5907, 5951, 5955, 5911, 5908, 5952, 5956, 5912
9576, 5908, 5952, 5956, 5912, 5909, 5953, 5957, 5913
9577, 5909, 5953, 5957, 5913, 5910, 5954, 5958, 5914
9578, 5910, 5954, 5958, 5914, 3456, 3467, 3468, 3457
9579, 2021, 2032, 2033, 2022, 5911, 5955, 5959, 5915
9580, 5911, 5955, 5959, 5915, 5912, 5956, 5960, 5916
9581, 5912, 5956, 5960, 5916, 5913, 5957, 5961, 5917
9582, 5913, 5957, 5961, 5917, 5914, 5958, 5962, 5918
9583, 5914, 5958, 5962, 5918, 3457, 3468, 3469, 3458
9584, 2022, 2033, 2034, 2023, 5915, 5959, 5963, 5919
9585, 5915, 5959, 5963, 5919, 5916, 5960, 5964, 5920
9586, 5916, 5960, 5964, 5920, 5917, 5961, 5965, 5921
9587, 5917, 5961, 5965, 5921, 5918, 5962, 5966, 5922
9588, 5918, 5962, 5966, 5922, 3458, 3469, 3470, 3459
9589, 2023, 2034, 2035, 2024, 5919, 5963, 5967, 5923
9590, 5919, 5963, 5967, 5923, 5920, 5964, 5968, 5924
9591, 5920, 5964, 5968, 5924, 5921, 5965, 5969, 5925
9592, 5921, 5965, 5969, 5925, 5922, 5966, 5970, 5926
9593, 5922, 5966, 5970, 5926, 3459, 3470, 3471, 3460
9594, 2024, 2035, 2036, 2025, 5923, 5967, 5971, 5927
9595, 5923, 5967, 5971, 5927, 5924, 5968, 5972, 5928
9596, 5924, 5968, 5972, 5928, 5925, 5969, 5973, 5929
9597, 5925, 5969, 5973, 5929, 5926, 5970, 5974, 5930
9598, 5926, 5970, 5974, 5930, 3460, 3471, 3472, 3461
9599, 2025, 2036, 2037, 2026, 5927, 5971, 5975, 5931
9600, 5927, 5971, 5975, 5931, 5928, 5972, 5976, 5932
9601, 5928, 5972, 5976, 5932, 5929, 5973, 5977, 5933
9602, 5929, 5973, 5977, 5933, 5930, 5974, 5978, 5934
9603, 5930, 5974, 5978, 5934, 3461, 3472, 3473, 3462
