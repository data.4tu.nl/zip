2514, 1923, 1924, 1935, 1934
2515, 1924, 1925, 1936, 1935
2516, 1925, 1926, 1937, 1936
2517, 1926, 1927, 1938, 1937
2518, 1927, 1928, 1939, 1938
2519, 1928, 1929, 1940, 1939
2520, 1929, 1930, 1941, 1940
2521, 1930, 1931, 1942, 1941
2522, 1931, 401, 402, 1942
2523, 358, 1932, 390, 26
2524, 1932, 1933, 391, 390
2525, 1933, 1934, 392, 391
2526, 1934, 1935, 393, 392
2527, 1935, 1936, 394, 393
2528, 1936, 1937, 395, 394
2529, 1937, 1938, 396, 395
2530, 1938, 1939, 397, 396
2531, 1939, 1940, 398, 397
2532, 1940, 1941, 399, 398
2533, 1941, 1942, 400, 399
2534, 1942, 402, 30, 400
*ELEMENT, type=CPS4, ELSET=Surface33
2535, 27, 367, 1943, 403
2536, 403, 1943, 1944, 404
2537, 404, 1944, 1945, 405
2538, 405, 1945, 1946, 406
2539, 406, 1946, 1947, 407
2540, 407, 1947, 1948, 408
2541, 408, 1948, 1949, 409
2542, 409, 1949, 1950, 410
2543, 410, 1950, 1951, 411
2544, 411, 1951, 1952, 412
2545, 412, 1952, 1953, 413
2546, 413, 1953, 425, 31
2547, 367, 368, 1954, 1943
2548, 1943, 1954, 1955, 1944
2549, 1944, 1955, 1956, 1945
2550, 1945, 1956, 1957, 1946
2551, 1946, 1957, 1958, 1947
2552, 1947, 1958, 1959, 1948
2553, 1948, 1959, 1960, 1949
2554, 1949, 1960, 1961, 1950
2555, 1950, 1961, 1962, 1951
2556, 1951, 1962, 1963, 1952
2557, 1952, 1963, 1964, 1953
2558, 1953, 1964, 426, 425
2559, 368, 28, 414, 1954
2560, 1954, 414, 415, 1955
2561, 1955, 415, 416, 1956
2562, 1956, 416, 417, 1957
2563, 1957, 417, 418, 1958
2564, 1958, 418, 419, 1959
2565, 1959, 419, 420, 1960
2566, 1960, 420, 421, 1961
2567, 1961, 421, 422, 1962
2568, 1962, 422, 423, 1963
2569, 1963, 423, 424, 1964
2570, 1964, 424, 32, 426
*ELEMENT, type=CPS4, ELSET=Surface34
2571, 27, 403, 1965, 369
2572, 403, 404, 1966, 1965
2573, 404, 405, 1967, 1966
2574, 405, 406, 1968, 1967
2575, 406, 407, 1969, 1968
2576, 407, 408, 1970, 1969
2577, 408, 409, 1971, 1970
2578, 409, 410, 1972, 1971
2579, 410, 411, 1973, 1972
2580, 411, 412, 1974, 1973
2581, 412, 413, 1975, 1974
2582, 413, 31, 427, 1975
2583, 369, 1965, 1976, 370
2584, 1965, 1966, 1977, 1976
2585, 1966, 1967, 1978, 1977
2586, 1967, 1968, 1979, 1978
2587, 1968, 1969, 1980, 1979
2588, 1969, 1970, 1981, 1980
2589, 1970, 1971, 1982, 1981
2590, 1971, 1972, 1983, 1982
2591, 1972, 1973, 1984, 1983
2592, 1973, 1974, 1985, 1984
2593, 1974, 1975, 1986, 1985
2594, 1975, 427, 428, 1986
2595, 370, 1976, 1987, 371
2596, 1976, 1977, 1988, 1987
2597, 1977, 1978, 1989, 1988
2598, 1978, 1979, 1990, 1989
2599, 1979, 1980, 1991, 1990
2600, 1980, 1981, 1992, 1991
2601, 1981, 1982, 1993, 1992
2602, 1982, 1983, 1994, 1993
2603, 1983, 1984, 1995, 1994
2604, 1984, 1985, 1996, 1995
2605, 1985, 1986, 1997, 1996
2606, 1986, 428, 429, 1997
2607, 371, 1987, 1998, 372
2608, 1987, 1988, 1999, 1998
2609, 1988, 1989, 2000, 1999
2610, 1989, 1990, 2001, 2000
2611, 1990, 1991, 2002, 2001
2612, 1991, 1992, 2003, 2002
2613, 1992, 1993, 2004, 2003
2614, 1993, 1994, 2005, 2004
2615, 1994, 1995, 2006, 2005
2616, 1995, 1996, 2007, 2006
2617, 1996, 1997, 2008, 2007
2618, 1997, 429, 430, 2008
2619, 372, 1998, 2009, 373
2620, 1998, 1999, 2010, 2009
2621, 1999, 2000, 2011, 2010
2622, 2000, 2001, 2012, 2011
2623, 2001, 2002, 2013, 2012
2624, 2002, 2003, 2014, 2013
2625, 2003, 2004, 2015, 2014
2626, 2004, 2005, 2016, 2015
2627, 2005, 2006, 2017, 2016
2628, 2006, 2007, 2018, 2017
2629, 2007, 2008, 2019, 2018
2630, 2008, 430, 431, 2019
2631, 373, 2009, 379, 25
2632, 2009, 2010, 380, 379
2633, 2010, 2011, 381, 380
2634, 2011, 2012, 382, 381
2635, 2012, 2013, 383, 382
2636, 2013, 2014, 384, 383
2637, 2014, 2015, 385, 384
2638, 2015, 2016, 386, 385
2639, 2016, 2017, 387, 386
2640, 2017, 2018, 388, 387
2641, 2018, 2019, 389, 388
2642, 2019, 431, 29, 389
*ELEMENT, type=CPS4, ELSET=Surface35
2643, 28, 374, 2020, 414
2644, 414, 2020, 2021, 415
2645, 415, 2021, 2022, 416
2646, 416, 2022, 2023, 417
2647, 417, 2023, 2024, 418
2648, 418, 2024, 2025, 419
2649, 419, 2025, 2026, 420
2650, 420, 2026, 2027, 421
2651, 421, 2027, 2028, 422
2652, 422, 2028, 2029, 423
2653, 423, 2029, 2030, 424
2654, 424, 2030, 432, 32
2655, 374, 375, 2031, 2020
2656, 2020, 2031, 2032, 2021
2657, 2021, 2032, 2033, 2022
2658, 2022, 2033, 2034, 2023
2659, 2023, 2034, 2035, 2024
2660, 2024, 2035, 2036, 2025
2661, 2025, 2036, 2037, 2026
2662, 2026, 2037, 2038, 2027
2663, 2027, 2038, 2039, 2028
2664, 2028, 2039, 2040, 2029
2665, 2029, 2040, 2041, 2030
2666, 2030, 2041, 433, 432
2667, 375, 376, 2042, 2031
2668, 2031, 2042, 2043, 2032
2669, 2032, 2043, 2044, 2033
2670, 2033, 2044, 2045, 2034
2671, 2034, 2045, 2046, 2035
2672, 2035, 2046, 2047, 2036
2673, 2036, 2047, 2048, 2037
2674, 2037, 2048, 2049, 2038
2675, 2038, 2049, 2050, 2039
2676, 2039, 2050, 2051, 2040
2677, 2040, 2051, 2052, 2041
2678, 2041, 2052, 434, 433
2679, 376, 377, 2053, 2042
2680, 2042, 2053, 2054, 2043
2681, 2043, 2054, 2055, 2044
2682, 2044, 2055, 2056, 2045
2683, 2045, 2056, 2057, 2046
2684, 2046, 2057, 2058, 2047
2685, 2047, 2058, 2059, 2048
2686, 2048, 2059, 2060, 2049
2687, 2049, 2060, 2061, 2050
2688, 2050, 2061, 2062, 2051
2689, 2051, 2062, 2063, 2052
2690, 2052, 2063, 435, 434
2691, 377, 378, 2064, 2053
2692, 2053, 2064, 2065, 2054
2693, 2054, 2065, 2066, 2055
2694, 2055, 2066, 2067, 2056
2695, 2056, 2067, 2068, 2057
2696, 2057, 2068, 2069, 2058
2697, 2058, 2069, 2070, 2059
2698, 2059, 2070, 2071, 2060
2699, 2060, 2071, 2072, 2061
2700, 2061, 2072, 2073, 2062
2701, 2062, 2073, 2074, 2063
2702, 2063, 2074, 436, 435
2703, 378, 26, 390, 2064
2704, 2064, 390, 391, 2065
2705, 2065, 391, 392, 2066
2706, 2066, 392, 393, 2067
2707, 2067, 393, 394, 2068
2708, 2068, 394, 395, 2069
2709, 2069, 395, 396, 2070
2710, 2070, 396, 397, 2071
2711, 2071, 397, 398, 2072
2712, 2072, 398, 399, 2073
2713, 2073, 399, 400, 2074
2714, 2074, 400, 30, 436
*ELEMENT, type=CPS4, ELSET=Surface36
2715, 31, 425, 2075, 427
2716, 425, 426, 2076, 2075
2717, 426, 32, 432, 2076
2718, 427, 2075, 2077, 428
2719, 2075, 2076, 2078, 2077
2720, 2076, 432, 433, 2078
2721, 428, 2077, 2079, 429
2722, 2077, 2078, 2080, 2079
2723, 2078, 433, 434, 2080
2724, 429, 2079, 2081, 430
2725, 2079, 2080, 2082, 2081
2726, 2080, 434, 435, 2082
2727, 430, 2081, 2083, 431
2728, 2081, 2082, 2084, 2083
2729, 2082, 435, 436, 2084
2730, 431, 2083, 401, 29
2731, 2083, 2084, 402, 401
2732, 2084, 436, 30, 402
*ELEMENT, type=CPS4, ELSET=Surface37
2733, 25, 33, 437, 379
2734, 379, 437, 438, 380
2735, 380, 438, 439, 381
2736, 381, 439, 440, 382
2737, 382, 440, 441, 383
2738, 383, 441, 442, 384
2739, 384, 442, 443, 385
2740, 385, 443, 444, 386
2741, 386, 444, 445, 387
2742, 387, 445, 446, 388
2743, 388, 446, 447, 389
2744, 389, 447, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
2745, 27, 403, 448, 35
2746, 403, 404, 449, 448
2747, 404, 405, 450, 449
2748, 405, 406, 451, 450
2749, 406, 407, 452, 451
2750, 407, 408, 453, 452
2751, 408, 409, 454, 453
2752, 409, 410, 455, 454
2753, 410, 411, 456, 455
2754, 411, 412, 457, 456
2755, 412, 413, 458, 457
2756, 413, 31, 36, 458
*ELEMENT, type=CPS4, ELSET=Surface39
2757, 27, 35, 459, 369
2758, 369, 459, 460, 370
2759, 370, 460, 461, 371
2760, 371, 461, 462, 372
2761, 372, 462, 463, 373
2762, 373, 463, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
2763, 31, 427, 464, 36
2764, 427, 428, 465, 464
2765, 428, 429, 466, 465
2766, 429, 430, 467, 466
2767, 430, 431, 468, 467
2768, 431, 29, 34, 468
*ELEMENT, type=CPS4, ELSET=Surface41
2769, 35, 448, 2085, 459
2770, 448, 449, 2086, 2085
2771, 449, 450, 2087, 2086
2772, 450, 451, 2088, 2087
2773, 451, 452, 2089, 2088
2774, 452, 453, 2090, 2089
2775, 453, 454, 2091, 2090
2776, 454, 455, 2092, 2091
2777, 455, 456, 2093, 2092
2778, 456, 457, 2094, 2093
2779, 457, 458, 2095, 2094
2780, 458, 36, 464, 2095
2781, 459, 2085, 2096, 460
2782, 2085, 2086, 2097, 2096
2783, 2086, 2087, 2098, 2097
2784, 2087, 2088, 2099, 2098
2785, 2088, 2089, 2100, 2099
2786, 2089, 2090, 2101, 2100
2787, 2090, 2091, 2102, 2101
2788, 2091, 2092, 2103, 2102
2789, 2092, 2093, 2104, 2103
2790, 2093, 2094, 2105, 2104
2791, 2094, 2095, 2106, 2105
2792, 2095, 464, 465, 2106
2793, 460, 2096, 2107, 461
2794, 2096, 2097, 2108, 2107
2795, 2097, 2098, 2109, 2108
2796, 2098, 2099, 2110, 2109
2797, 2099, 2100, 2111, 2110
2798, 2100, 2101, 2112, 2111
2799, 2101, 2102, 2113, 2112
2800, 2102, 2103, 2114, 2113
2801, 2103, 2104, 2115, 2114
2802, 2104, 2105, 2116, 2115
2803, 2105, 2106, 2117, 2116
2804, 2106, 465, 466, 2117
2805, 461, 2107, 2118, 462
2806, 2107, 2108, 2119, 2118
2807, 2108, 2109, 2120, 2119
2808, 2109, 2110, 2121, 2120
2809, 2110, 2111, 2122, 2121
2810, 2111, 2112, 2123, 2122
2811, 2112, 2113, 2124, 2123
2812, 2113, 2114, 2125, 2124
2813, 2114, 2115, 2126, 2125
2814, 2115, 2116, 2127, 2126
2815, 2116, 2117, 2128, 2127
2816, 2117, 466, 467, 2128
2817, 462, 2118, 2129, 463
2818, 2118, 2119, 2130, 2129
2819, 2119, 2120, 2131, 2130
2820, 2120, 2121, 2132, 2131
2821, 2121, 2122, 2133, 2132
2822, 2122, 2123, 2134, 2133
2823, 2123, 2124, 2135, 2134
2824, 2124, 2125, 2136, 2135
2825, 2125, 2126, 2137, 2136
2826, 2126, 2127, 2138, 2137
2827, 2127, 2128, 2139, 2138
2828, 2128, 467, 468, 2139
2829, 463, 2129, 437, 33
2830, 2129, 2130, 438, 437
2831, 2130, 2131, 439, 438
2832, 2131, 2132, 440, 439
2833, 2132, 2133, 441, 440
2834, 2133, 2134, 442, 441
2835, 2134, 2135, 443, 442
2836, 2135, 2136, 444, 443
2837, 2136, 2137, 445, 444
2838, 2137, 2138, 446, 445
2839, 2138, 2139, 447, 446
2840, 2139, 468, 34, 447
*ELEMENT, type=CPS4, ELSET=Surface42
2841, 33, 469, 2140, 437
2842, 469, 470, 2141, 2140
2843, 470, 471, 2142, 2141
2844, 471, 472, 2143, 2142
2845, 472, 473, 2144, 2143
2846, 473, 474, 2145, 2144
2847, 474, 475, 2146, 2145
2848, 475, 476, 2147, 2146
2849, 476, 477, 2148, 2147
2850, 477, 478, 2149, 2148
2851, 478, 479, 2150, 2149
2852, 479, 37, 491, 2150
2853, 437, 2140, 2151, 438
2854, 2140, 2141, 2152, 2151
2855, 2141, 2142, 2153, 2152
2856, 2142, 2143, 2154, 2153
2857, 2143, 2144, 2155, 2154
2858, 2144, 2145, 2156, 2155
2859, 2145, 2146, 2157, 2156
2860, 2146, 2147, 2158, 2157
2861, 2147, 2148, 2159, 2158
2862, 2148, 2149, 2160, 2159
2863, 2149, 2150, 2161, 2160
2864, 2150, 491, 492, 2161
2865, 438, 2151, 2162, 439
2866, 2151, 2152, 2163, 2162
2867, 2152, 2153, 2164, 2163
2868, 2153, 2154, 2165, 2164
2869, 2154, 2155, 2166, 2165
2870, 2155, 2156, 2167, 2166
2871, 2156, 2157, 2168, 2167
2872, 2157, 2158, 2169, 2168
2873, 2158, 2159, 2170, 2169
2874, 2159, 2160, 2171, 2170
2875, 2160, 2161, 2172, 2171
2876, 2161, 492, 493, 2172
2877, 439, 2162, 2173, 440
2878, 2162, 2163, 2174, 2173
2879, 2163, 2164, 2175, 2174
2880, 2164, 2165, 2176, 2175
2881, 2165, 2166, 2177, 2176
2882, 2166, 2167, 2178, 2177
2883, 2167, 2168, 2179, 2178
2884, 2168, 2169, 2180, 2179
2885, 2169, 2170, 2181, 2180
2886, 2170, 2171, 2182, 2181
2887, 2171, 2172, 2183, 2182
2888, 2172, 493, 494, 2183
2889, 440, 2173, 2184, 441
2890, 2173, 2174, 2185, 2184
2891, 2174, 2175, 2186, 2185
2892, 2175, 2176, 2187, 2186
2893, 2176, 2177, 2188, 2187
2894, 2177, 2178, 2189, 2188
2895, 2178, 2179, 2190, 2189
2896, 2179, 2180, 2191, 2190
2897, 2180, 2181, 2192, 2191
2898, 2181, 2182, 2193, 2192
2899, 2182, 2183, 2194, 2193
2900, 2183, 494, 495, 2194
2901, 441, 2184, 2195, 442
2902, 2184, 2185, 2196, 2195
2903, 2185, 2186, 2197, 2196
2904, 2186, 2187, 2198, 2197
2905, 2187, 2188, 2199, 2198
2906, 2188, 2189, 2200, 2199
2907, 2189, 2190, 2201, 2200
2908, 2190, 2191, 2202, 2201
2909, 2191, 2192, 2203, 2202
2910, 2192, 2193, 2204, 2203
2911, 2193, 2194, 2205, 2204
2912, 2194, 495, 496, 2205
2913, 442, 2195, 2206, 443
2914, 2195, 2196, 2207, 2206
2915, 2196, 2197, 2208, 2207
2916, 2197, 2198, 2209, 2208
2917, 2198, 2199, 2210, 2209
2918, 2199, 2200, 2211, 2210
2919, 2200, 2201, 2212, 2211
2920, 2201, 2202, 2213, 2212
2921, 2202, 2203, 2214, 2213
2922, 2203, 2204, 2215, 2214
2923, 2204, 2205, 2216, 2215
2924, 2205, 496, 497, 2216
2925, 443, 2206, 2217, 444
2926, 2206, 2207, 2218, 2217
2927, 2207, 2208, 2219, 2218
2928, 2208, 2209, 2220, 2219
2929, 2209, 2210, 2221, 2220
2930, 2210, 2211, 2222, 2221
2931, 2211, 2212, 2223, 2222
2932, 2212, 2213, 2224, 2223
2933, 2213, 2214, 2225, 2224
2934, 2214, 2215, 2226, 2225
2935, 2215, 2216, 2227, 2226
2936, 2216, 497, 498, 2227
2937, 444, 2217, 2228, 445
2938, 2217, 2218, 2229, 2228
2939, 2218, 2219, 2230, 2229
2940, 2219, 2220, 2231, 2230
2941, 2220, 2221, 2232, 2231
2942, 2221, 2222, 2233, 2232
2943, 2222, 2223, 2234, 2233
2944, 2223, 2224, 2235, 2234
2945, 2224, 2225, 2236, 2235
2946, 2225, 2226, 2237, 2236
2947, 2226, 2227, 2238, 2237
2948, 2227, 498, 499, 2238
2949, 445, 2228, 2239, 446
2950, 2228, 2229, 2240, 2239
2951, 2229, 2230, 2241, 2240
2952, 2230, 2231, 2242, 2241
2953, 2231, 2232, 2243, 2242
2954, 2232, 2233, 2244, 2243
2955, 2233, 2234, 2245, 2244
2956, 2234, 2235, 2246, 2245
2957, 2235, 2236, 2247, 2246
2958, 2236, 2237, 2248, 2247
2959, 2237, 2238, 2249, 2248
2960, 2238, 499, 500, 2249
2961, 446, 2239, 2250, 447
2962, 2239, 2240, 2251, 2250
2963, 2240, 2241, 2252, 2251
2964, 2241, 2242, 2253, 2252
2965, 2242, 2243, 2254, 2253
2966, 2243, 2244, 2255, 2254
2967, 2244, 2245, 2256, 2255
2968, 2245, 2246, 2257, 2256
2969, 2246, 2247, 2258, 2257
2970, 2247, 2248, 2259, 2258
2971, 2248, 2249, 2260, 2259
2972, 2249, 500, 501, 2260
2973, 447, 2250, 480, 34
2974, 2250, 2251, 481, 480
2975, 2251, 2252, 482, 481
2976, 2252, 2253, 483, 482
2977, 2253, 2254, 484, 483
2978, 2254, 2255, 485, 484
2979, 2255, 2256, 486, 485
2980, 2256, 2257, 487, 486
2981, 2257, 2258, 488, 487
2982, 2258, 2259, 489, 488
2983, 2259, 2260, 490, 489
2984, 2260, 501, 38, 490
*ELEMENT, type=CPS4, ELSET=Surface43
2985, 35, 448, 2261, 502
2986, 502, 2261, 2262, 503
2987, 503, 2262, 2263, 504
2988, 504, 2263, 2264, 505
2989, 505, 2264, 2265, 506
2990, 506, 2265, 2266, 507
2991, 507, 2266, 2267, 508
2992, 508, 2267, 2268, 509
2993, 509, 2268, 2269, 510
2994, 510, 2269, 2270, 511
2995, 511, 2270, 2271, 512
2996, 512, 2271, 524, 39
2997, 448, 449, 2272, 2261
2998, 2261, 2272, 2273, 2262
2999, 2262, 2273, 2274, 2263
3000, 2263, 2274, 2275, 2264
3001, 2264, 2275, 2276, 2265
3002, 2265, 2276, 2277, 2266
3003, 2266, 2277, 2278, 2267
3004, 2267, 2278, 2279, 2268
3005, 2268, 2279, 2280, 2269
3006, 2269, 2280, 2281, 2270
3007, 2270, 2281, 2282, 2271
3008, 2271, 2282, 525, 524
3009, 449, 450, 2283, 2272
3010, 2272, 2283, 2284, 2273
3011, 2273, 2284, 2285, 2274
3012, 2274, 2285, 2286, 2275
3013, 2275, 2286, 2287, 2276
3014, 2276, 2287, 2288, 2277
3015, 2277, 2288, 2289, 2278
3016, 2278, 2289, 2290, 2279
3017, 2279, 2290, 2291, 2280
3018, 2280, 2291, 2292, 2281
3019, 2281, 2292, 2293, 2282
3020, 2282, 2293, 526, 525
3021, 450, 451, 2294, 2283
3022, 2283, 2294, 2295, 2284
3023, 2284, 2295, 2296, 2285
3024, 2285, 2296, 2297, 2286
3025, 2286, 2297, 2298, 2287
3026, 2287, 2298, 2299, 2288
3027, 2288, 2299, 2300, 2289
3028, 2289, 2300, 2301, 2290
3029, 2290, 2301, 2302, 2291
3030, 2291, 2302, 2303, 2292
3031, 2292, 2303, 2304, 2293
3032, 2293, 2304, 527, 526
3033, 451, 452, 2305, 2294
3034, 2294, 2305, 2306, 2295
3035, 2295, 2306, 2307, 2296
3036, 2296, 2307, 2308, 2297
3037, 2297, 2308, 2309, 2298
3038, 2298, 2309, 2310, 2299
3039, 2299, 2310, 2311, 2300
3040, 2300, 2311, 2312, 2301
3041, 2301, 2312, 2313, 2302
3042, 2302, 2313, 2314, 2303
3043, 2303, 2314, 2315, 2304
3044, 2304, 2315, 528, 527
3045, 452, 453, 2316, 2305
3046, 2305, 2316, 2317, 2306
3047, 2306, 2317, 2318, 2307
3048, 2307, 2318, 2319, 2308
3049, 2308, 2319, 2320, 2309
3050, 2309, 2320, 2321, 2310
3051, 2310, 2321, 2322, 2311
3052, 2311, 2322, 2323, 2312
3053, 2312, 2323, 2324, 2313
3054, 2313, 2324, 2325, 2314
3055, 2314, 2325, 2326, 2315
3056, 2315, 2326, 529, 528
3057, 453, 454, 2327, 2316
3058, 2316, 2327, 2328, 2317
3059, 2317, 2328, 2329, 2318
3060, 2318, 2329, 2330, 2319
3061, 2319, 2330, 2331, 2320
3062, 2320, 2331, 2332, 2321
3063, 2321, 2332, 2333, 2322
3064, 2322, 2333, 2334, 2323
3065, 2323, 2334, 2335, 2324
3066, 2324, 2335, 2336, 2325
3067, 2325, 2336, 2337, 2326
3068, 2326, 2337, 530, 529
3069, 454, 455, 2338, 2327
3070, 2327, 2338, 2339, 2328
3071, 2328, 2339, 2340, 2329
3072, 2329, 2340, 2341, 2330
3073, 2330, 2341, 2342, 2331
3074, 2331, 2342, 2343, 2332
3075, 2332, 2343, 2344, 2333
3076, 2333, 2344, 2345, 2334
3077, 2334, 2345, 2346, 2335
3078, 2335, 2346, 2347, 2336
3079, 2336, 2347, 2348, 2337
3080, 2337, 2348, 531, 530
3081, 455, 456, 2349, 2338
3082, 2338, 2349, 2350, 2339
3083, 2339, 2350, 2351, 2340
3084, 2340, 2351, 2352, 2341
3085, 2341, 2352, 2353, 2342
3086, 2342, 2353, 2354, 2343
3087, 2343, 2354, 2355, 2344
3088, 2344, 2355, 2356, 2345
3089, 2345, 2356, 2357, 2346
3090, 2346, 2357, 2358, 2347
3091, 2347, 2358, 2359, 2348
3092, 2348, 2359, 532, 531
3093, 456, 457, 2360, 2349
3094, 2349, 2360, 2361, 2350
3095, 2350, 2361, 2362, 2351
3096, 2351, 2362, 2363, 2352
3097, 2352, 2363, 2364, 2353
3098, 2353, 2364, 2365, 2354
3099, 2354, 2365, 2366, 2355
3100, 2355, 2366, 2367, 2356
3101, 2356, 2367, 2368, 2357
3102, 2357, 2368, 2369, 2358
3103, 2358, 2369, 2370, 2359
3104, 2359, 2370, 533, 532
3105, 457, 458, 2371, 2360
3106, 2360, 2371, 2372, 2361
3107, 2361, 2372, 2373, 2362
3108, 2362, 2373, 2374, 2363
3109, 2363, 2374, 2375, 2364
3110, 2364, 2375, 2376, 2365
3111, 2365, 2376, 2377, 2366
3112, 2366, 2377, 2378, 2367
3113, 2367, 2378, 2379, 2368
3114, 2368, 2379, 2380, 2369
3115, 2369, 2380, 2381, 2370
3116, 2370, 2381, 534, 533
3117, 458, 36, 513, 2371
3118, 2371, 513, 514, 2372
3119, 2372, 514, 515, 2373
3120, 2373, 515, 516, 2374
3121, 2374, 516, 517, 2375
3122, 2375, 517, 518, 2376
3123, 2376, 518, 519, 2377
3124, 2377, 519, 520, 2378
3125, 2378, 520, 521, 2379
3126, 2379, 521, 522, 2380
3127, 2380, 522, 523, 2381
3128, 2381, 523, 40, 534
*ELEMENT, type=CPS4, ELSET=Surface44
3129, 35, 502, 2382, 459
3130, 502, 503, 2383, 2382
3131, 503, 504, 2384, 2383
3132, 504, 505, 2385, 2384
3133, 505, 506, 2386, 2385
3134, 506, 507, 2387, 2386
3135, 507, 508, 2388, 2387
3136, 508, 509, 2389, 2388
3137, 509, 510, 2390, 2389
3138, 510, 511, 2391, 2390
3139, 511, 512, 2392, 2391
3140, 512, 39, 535, 2392
3141, 459, 2382, 2393, 460
3142, 2382, 2383, 2394, 2393
3143, 2383, 2384, 2395, 2394
3144, 2384, 2385, 2396, 2395
3145, 2385, 2386, 2397, 2396
3146, 2386, 2387, 2398, 2397
3147, 2387, 2388, 2399, 2398
3148, 2388, 2389, 2400, 2399
3149, 2389, 2390, 2401, 2400
3150, 2390, 2391, 2402, 2401
3151, 2391, 2392, 2403, 2402
3152, 2392, 535, 536, 2403
3153, 460, 2393, 2404, 461
3154, 2393, 2394, 2405, 2404
3155, 2394, 2395, 2406, 2405
3156, 2395, 2396, 2407, 2406
3157, 2396, 2397, 2408, 2407
3158, 2397, 2398, 2409, 2408
3159, 2398, 2399, 2410, 2409
3160, 2399, 2400, 2411, 2410
3161, 2400, 2401, 2412, 2411
3162, 2401, 2402, 2413, 2412
3163, 2402, 2403, 2414, 2413
3164, 2403, 536, 537, 2414
3165, 461, 2404, 2415, 462
3166, 2404, 2405, 2416, 2415
3167, 2405, 2406, 2417, 2416
3168, 2406, 2407, 2418, 2417
3169, 2407, 2408, 2419, 2418
3170, 2408, 2409, 2420, 2419
3171, 2409, 2410, 2421, 2420
3172, 2410, 2411, 2422, 2421
3173, 2411, 2412, 2423, 2422
3174, 2412, 2413, 2424, 2423
3175, 2413, 2414, 2425, 2424
3176, 2414, 537, 538, 2425
3177, 462, 2415, 2426, 463
3178, 2415, 2416, 2427, 2426
3179, 2416, 2417, 2428, 2427
3180, 2417, 2418, 2429, 2428
3181, 2418, 2419, 2430, 2429
3182, 2419, 2420, 2431, 2430
3183, 2420, 2421, 2432, 2431
3184, 2421, 2422, 2433, 2432
3185, 2422, 2423, 2434, 2433
3186, 2423, 2424, 2435, 2434
3187, 2424, 2425, 2436, 2435
3188, 2425, 538, 539, 2436
3189, 463, 2426, 469, 33
3190, 2426, 2427, 470, 469
3191, 2427, 2428, 471, 470
3192, 2428, 2429, 472, 471
3193, 2429, 2430, 473, 472
3194, 2430, 2431, 474, 473
3195, 2431, 2432, 475, 474
3196, 2432, 2433, 476, 475
3197, 2433, 2434, 477, 476
3198, 2434, 2435, 478, 477
3199, 2435, 2436, 479, 478
3200, 2436, 539, 37, 479
*ELEMENT, type=CPS4, ELSET=Surface45
3201, 36, 464, 2437, 513
3202, 513, 2437, 2438, 514
3203, 514, 2438, 2439, 515
3204, 515, 2439, 2440, 516
3205, 516, 2440, 2441, 517
3206, 517, 2441, 2442, 518
3207, 518, 2442, 2443, 519
3208, 519, 2443, 2444, 520
3209, 520, 2444, 2445, 521
3210, 521, 2445, 2446, 522
3211, 522, 2446, 2447, 523
3212, 523, 2447, 540, 40
3213, 464, 465, 2448, 2437
3214, 2437, 2448, 2449, 2438
3215, 2438, 2449, 2450, 2439
3216, 2439, 2450, 2451, 2440
3217, 2440, 2451, 2452, 2441
3218, 2441, 2452, 2453, 2442
3219, 2442, 2453, 2454, 2443
3220, 2443, 2454, 2455, 2444
3221, 2444, 2455, 2456, 2445
3222, 2445, 2456, 2457, 2446
3223, 2446, 2457, 2458, 2447
3224, 2447, 2458, 541, 540
3225, 465, 466, 2459, 2448
3226, 2448, 2459, 2460, 2449
3227, 2449, 2460, 2461, 2450
3228, 2450, 2461, 2462, 2451
3229, 2451, 2462, 2463, 2452
3230, 2452, 2463, 2464, 2453
3231, 2453, 2464, 2465, 2454
3232, 2454, 2465, 2466, 2455
3233, 2455, 2466, 2467, 2456
3234, 2456, 2467, 2468, 2457
3235, 2457, 2468, 2469, 2458
3236, 2458, 2469, 542, 541
3237, 466, 467, 2470, 2459
3238, 2459, 2470, 2471, 2460
3239, 2460, 2471, 2472, 2461
3240, 2461, 2472, 2473, 2462
3241, 2462, 2473, 2474, 2463
3242, 2463, 2474, 2475, 2464
3243, 2464, 2475, 2476, 2465
3244, 2465, 2476, 2477, 2466
3245, 2466, 2477, 2478, 2467
3246, 2467, 2478, 2479, 2468
3247, 2468, 2479, 2480, 2469
3248, 2469, 2480, 543, 542
3249, 467, 468, 2481, 2470
3250, 2470, 2481, 2482, 2471
3251, 2471, 2482, 2483, 2472
3252, 2472, 2483, 2484, 2473
3253, 2473, 2484, 2485, 2474
3254, 2474, 2485, 2486, 2475
3255, 2475, 2486, 2487, 2476
3256, 2476, 2487, 2488, 2477
3257, 2477, 2488, 2489, 2478
3258, 2478, 2489, 2490, 2479
3259, 2479, 2490, 2491, 2480
3260, 2480, 2491, 544, 543
3261, 468, 34, 480, 2481
3262, 2481, 480, 481, 2482
3263, 2482, 481, 482, 2483
3264, 2483, 482, 483, 2484
3265, 2484, 483, 484, 2485
3266, 2485, 484, 485, 2486
3267, 2486, 485, 486, 2487
3268, 2487, 486, 487, 2488
3269, 2488, 487, 488, 2489
3270, 2489, 488, 489, 2490
3271, 2490, 489, 490, 2491
3272, 2491, 490, 38, 544
*ELEMENT, type=CPS4, ELSET=Surface46
3273, 39, 524, 2492, 535
3274, 524, 525, 2493, 2492
3275, 525, 526, 2494, 2493
3276, 526, 527, 2495, 2494
3277, 527, 528, 2496, 2495
3278, 528, 529, 2497, 2496
3279, 529, 530, 2498, 2497
3280, 530, 531, 2499, 2498
3281, 531, 532, 2500, 2499
3282, 532, 533, 2501, 2500
3283, 533, 534, 2502, 2501
3284, 534, 40, 540, 2502
3285, 535, 2492, 2503, 536
3286, 2492, 2493, 2504, 2503
3287, 2493, 2494, 2505, 2504
3288, 2494, 2495, 2506, 2505
3289, 2495, 2496, 2507, 2506
3290, 2496, 2497, 2508, 2507
3291, 2497, 2498, 2509, 2508
3292, 2498, 2499, 2510, 2509
3293, 2499, 2500, 2511, 2510
3294, 2500, 2501, 2512, 2511
3295, 2501, 2502, 2513, 2512
3296, 2502, 540, 541, 2513
3297, 536, 2503, 2514, 537
3298, 2503, 2504, 2515, 2514
3299, 2504, 2505, 2516, 2515
3300, 2505, 2506, 2517, 2516
3301, 2506, 2507, 2518, 2517
3302, 2507, 2508, 2519, 2518
3303, 2508, 2509, 2520, 2519
3304, 2509, 2510, 2521, 2520
3305, 2510, 2511, 2522, 2521
3306, 2511, 2512, 2523, 2522
3307, 2512, 2513, 2524, 2523
3308, 2513, 541, 542, 2524
3309, 537, 2514, 2525, 538
3310, 2514, 2515, 2526, 2525
3311, 2515, 2516, 2527, 2526
3312, 2516, 2517, 2528, 2527
3313, 2517, 2518, 2529, 2528
3314, 2518, 2519, 2530, 2529
3315, 2519, 2520, 2531, 2530
3316, 2520, 2521, 2532, 2531
3317, 2521, 2522, 2533, 2532
3318, 2522, 2523, 2534, 2533
3319, 2523, 2524, 2535, 2534
3320, 2524, 542, 543, 2535
3321, 538, 2525, 2536, 539
3322, 2525, 2526, 2537, 2536
3323, 2526, 2527, 2538, 2537
3324, 2527, 2528, 2539, 2538
3325, 2528, 2529, 2540, 2539
3326, 2529, 2530, 2541, 2540
3327, 2530, 2531, 2542, 2541
3328, 2531, 2532, 2543, 2542
3329, 2532, 2533, 2544, 2543
3330, 2533, 2534, 2545, 2544
3331, 2534, 2535, 2546, 2545
3332, 2535, 543, 544, 2546
3333, 539, 2536, 491, 37
3334, 2536, 2537, 492, 491
3335, 2537, 2538, 493, 492
3336, 2538, 2539, 494, 493
3337, 2539, 2540, 495, 494
3338, 2540, 2541, 496, 495
3339, 2541, 2542, 497, 496
3340, 2542, 2543, 498, 497
3341, 2543, 2544, 499, 498
3342, 2544, 2545, 500, 499
3343, 2545, 2546, 501, 500
3344, 2546, 544, 38, 501
*ELEMENT, type=CPS4, ELSET=Surface47
3345, 37, 41, 545, 491
3346, 491, 545, 546, 492
3347, 492, 546, 547, 493
3348, 493, 547, 548, 494
3349, 494, 548, 549, 495
3350, 495, 549, 550, 496
3351, 496, 550, 551, 497
3352, 497, 551, 552, 498
3353, 498, 552, 553, 499
3354, 499, 553, 554, 500
3355, 500, 554, 555, 501
3356, 501, 555, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
3357, 39, 524, 556, 43
3358, 524, 525, 557, 556
3359, 525, 526, 558, 557
3360, 526, 527, 559, 558
3361, 527, 528, 560, 559
3362, 528, 529, 561, 560
3363, 529, 530, 562, 561
3364, 530, 531, 563, 562
3365, 531, 532, 564, 563
3366, 532, 533, 565, 564
3367, 533, 534, 566, 565
3368, 534, 40, 44, 566
*ELEMENT, type=CPS4, ELSET=Surface49
3369, 39, 43, 567, 535
3370, 535, 567, 568, 536
3371, 536, 568, 569, 537
3372, 537, 569, 570, 538
3373, 538, 570, 571, 539
3374, 539, 571, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
3375, 40, 540, 572, 44
3376, 540, 541, 573, 572
3377, 541, 542, 574, 573
3378, 542, 543, 575, 574
3379, 543, 544, 576, 575
3380, 544, 38, 42, 576
*ELEMENT, type=CPS4, ELSET=Surface51
3381, 43, 556, 2547, 567
3382, 556, 557, 2548, 2547
3383, 557, 558, 2549, 2548
3384, 558, 559, 2550, 2549
3385, 559, 560, 2551, 2550
3386, 560, 561, 2552, 2551
3387, 561, 562, 2553, 2552
3388, 562, 563, 2554, 2553
3389, 563, 564, 2555, 2554
3390, 564, 565, 2556, 2555
3391, 565, 566, 2557, 2556
3392, 566, 44, 572, 2557
3393, 567, 2547, 2558, 568
3394, 2547, 2548, 2559, 2558
3395, 2548, 2549, 2560, 2559
3396, 2549, 2550, 2561, 2560
3397, 2550, 2551, 2562, 2561
3398, 2551, 2552, 2563, 2562
3399, 2552, 2553, 2564, 2563
3400, 2553, 2554, 2565, 2564
3401, 2554, 2555, 2566, 2565
3402, 2555, 2556, 2567, 2566
3403, 2556, 2557, 2568, 2567
3404, 2557, 572, 573, 2568
3405, 568, 2558, 2569, 569
3406, 2558, 2559, 2570, 2569
3407, 2559, 2560, 2571, 2570
3408, 2560, 2561, 2572, 2571
3409, 2561, 2562, 2573, 2572
3410, 2562, 2563, 2574, 2573
3411, 2563, 2564, 2575, 2574
3412, 2564, 2565, 2576, 2575
3413, 2565, 2566, 2577, 2576
3414, 2566, 2567, 2578, 2577
3415, 2567, 2568, 2579, 2578
3416, 2568, 573, 574, 2579
3417, 569, 2569, 2580, 570
3418, 2569, 2570, 2581, 2580
3419, 2570, 2571, 2582, 2581
3420, 2571, 2572, 2583, 2582
3421, 2572, 2573, 2584, 2583
3422, 2573, 2574, 2585, 2584
3423, 2574, 2575, 2586, 2585
3424, 2575, 2576, 2587, 2586
3425, 2576, 2577, 2588, 2587
3426, 2577, 2578, 2589, 2588
3427, 2578, 2579, 2590, 2589
3428, 2579, 574, 575, 2590
3429, 570, 2580, 2591, 571
3430, 2580, 2581, 2592, 2591
3431, 2581, 2582, 2593, 2592
3432, 2582, 2583, 2594, 2593
3433, 2583, 2584, 2595, 2594
3434, 2584, 2585, 2596, 2595
3435, 2585, 2586, 2597, 2596
3436, 2586, 2587, 2598, 2597
3437, 2587, 2588, 2599, 2598
3438, 2588, 2589, 2600, 2599
3439, 2589, 2590, 2601, 2600
3440, 2590, 575, 576, 2601
3441, 571, 2591, 545, 41
3442, 2591, 2592, 546, 545
3443, 2592, 2593, 547, 546
3444, 2593, 2594, 548, 547
3445, 2594, 2595, 549, 548
3446, 2595, 2596, 550, 549
3447, 2596, 2597, 551, 550
3448, 2597, 2598, 552, 551
3449, 2598, 2599, 553, 552
3450, 2599, 2600, 554, 553
3451, 2600, 2601, 555, 554
3452, 2601, 576, 42, 555
*ELEMENT, type=CPS4, ELSET=Surface52
3453, 41, 577, 2602, 545
3454, 577, 578, 2603, 2602
3455, 578, 45, 581, 2603
3456, 545, 2602, 2604, 546
3457, 2602, 2603, 2605, 2604
3458, 2603, 581, 582, 2605
3459, 546, 2604, 2606, 547
3460, 2604, 2605, 2607, 2606
3461, 2605, 582, 583, 2607
3462, 547, 2606, 2608, 548
3463, 2606, 2607, 2609, 2608
3464, 2607, 583, 584, 2609
3465, 548, 2608, 2610, 549
3466, 2608, 2609, 2611, 2610
3467, 2609, 584, 585, 2611
3468, 549, 2610, 2612, 550
3469, 2610, 2611, 2613, 2612
3470, 2611, 585, 586, 2613
3471, 550, 2612, 2614, 551
3472, 2612, 2613, 2615, 2614
3473, 2613, 586, 587, 2615
3474, 551, 2614, 2616, 552
3475, 2614, 2615, 2617, 2616
3476, 2615, 587, 588, 2617
3477, 552, 2616, 2618, 553
3478, 2616, 2617, 2619, 2618
3479, 2617, 588, 589, 2619
3480, 553, 2618, 2620, 554
3481, 2618, 2619, 2621, 2620
3482, 2619, 589, 590, 2621
3483, 554, 2620, 2622, 555
3484, 2620, 2621, 2623, 2622
3485, 2621, 590, 591, 2623
3486, 555, 2622, 579, 42
3487, 2622, 2623, 580, 579
3488, 2623, 591, 46, 580
*ELEMENT, type=CPS4, ELSET=Surface53
3489, 43, 556, 2624, 592
3490, 592, 2624, 2625, 593
3491, 593, 2625, 596, 47
3492, 556, 557, 2626, 2624
3493, 2624, 2626, 2627, 2625
3494, 2625, 2627, 597, 596
3495, 557, 558, 2628, 2626
3496, 2626, 2628, 2629, 2627
3497, 2627, 2629, 598, 597
3498, 558, 559, 2630, 2628
3499, 2628, 2630, 2631, 2629
3500, 2629, 2631, 599, 598
3501, 559, 560, 2632, 2630
3502, 2630, 2632, 2633, 2631
3503, 2631, 2633, 600, 599
3504, 560, 561, 2634, 2632
3505, 2632, 2634, 2635, 2633
3506, 2633, 2635, 601, 600
3507, 561, 562, 2636, 2634
3508, 2634, 2636, 2637, 2635
3509, 2635, 2637, 602, 601
3510, 562, 563, 2638, 2636
3511, 2636, 2638, 2639, 2637
3512, 2637, 2639, 603, 602
3513, 563, 564, 2640, 2638
3514, 2638, 2640, 2641, 2639
3515, 2639, 2641, 604, 603
3516, 564, 565, 2642, 2640
3517, 2640, 2642, 2643, 2641
3518, 2641, 2643, 605, 604
3519, 565, 566, 2644, 2642
3520, 2642, 2644, 2645, 2643
3521, 2643, 2645, 606, 605
3522, 566, 44, 594, 2644
3523, 2644, 594, 595, 2645
3524, 2645, 595, 48, 606
*ELEMENT, type=CPS4, ELSET=Surface54
3525, 43, 592, 2646, 567
3526, 592, 593, 2647, 2646
3527, 593, 47, 607, 2647
3528, 567, 2646, 2648, 568
3529, 2646, 2647, 2649, 2648
3530, 2647, 607, 608, 2649
3531, 568, 2648, 2650, 569
3532, 2648, 2649, 2651, 2650
3533, 2649, 608, 609, 2651
3534, 569, 2650, 2652, 570
3535, 2650, 2651, 2653, 2652
3536, 2651, 609, 610, 2653
3537, 570, 2652, 2654, 571
3538, 2652, 2653, 2655, 2654
3539, 2653, 610, 611, 2655
3540, 571, 2654, 577, 41
3541, 2654, 2655, 578, 577
3542, 2655, 611, 45, 578
*ELEMENT, type=CPS4, ELSET=Surface55
3543, 44, 572, 2656, 594
3544, 594, 2656, 2657, 595
3545, 595, 2657, 612, 48
3546, 572, 573, 2658, 2656
3547, 2656, 2658, 2659, 2657
3548, 2657, 2659, 613, 612
3549, 573, 574, 2660, 2658
3550, 2658, 2660, 2661, 2659
3551, 2659, 2661, 614, 613
3552, 574, 575, 2662, 2660
3553, 2660, 2662, 2663, 2661
3554, 2661, 2663, 615, 614
3555, 575, 576, 2664, 2662
3556, 2662, 2664, 2665, 2663
3557, 2663, 2665, 616, 615
3558, 576, 42, 579, 2664
3559, 2664, 579, 580, 2665
3560, 2665, 580, 46, 616
*ELEMENT, type=CPS4, ELSET=Surface56
3561, 47, 596, 2666, 607
3562, 596, 597, 2667, 2666
3563, 597, 598, 2668, 2667
3564, 598, 599, 2669, 2668
3565, 599, 600, 2670, 2669
3566, 600, 601, 2671, 2670
3567, 601, 602, 2672, 2671
3568, 602, 603, 2673, 2672
3569, 603, 604, 2674, 2673
3570, 604, 605, 2675, 2674
3571, 605, 606, 2676, 2675
3572, 606, 48, 612, 2676
3573, 607, 2666, 2677, 608
3574, 2666, 2667, 2678, 2677
3575, 2667, 2668, 2679, 2678
3576, 2668, 2669, 2680, 2679
3577, 2669, 2670, 2681, 2680
3578, 2670, 2671, 2682, 2681
3579, 2671, 2672, 2683, 2682
3580, 2672, 2673, 2684, 2683
3581, 2673, 2674, 2685, 2684
3582, 2674, 2675, 2686, 2685
3583, 2675, 2676, 2687, 2686
3584, 2676, 612, 613, 2687
3585, 608, 2677, 2688, 609
3586, 2677, 2678, 2689, 2688
3587, 2678, 2679, 2690, 2689
3588, 2679, 2680, 2691, 2690
3589, 2680, 2681, 2692, 2691
3590, 2681, 2682, 2693, 2692
3591, 2682, 2683, 2694, 2693
3592, 2683, 2684, 2695, 2694
3593, 2684, 2685, 2696, 2695
3594, 2685, 2686, 2697, 2696
3595, 2686, 2687, 2698, 2697
3596, 2687, 613, 614, 2698
3597, 609, 2688, 2699, 610
3598, 2688, 2689, 2700, 2699
3599, 2689, 2690, 2701, 2700
3600, 2690, 2691, 2702, 2701
3601, 2691, 2692, 2703, 2702
3602, 2692, 2693, 2704, 2703
3603, 2693, 2694, 2705, 2704
3604, 2694, 2695, 2706, 2705
3605, 2695, 2696, 2707, 2706
3606, 2696, 2697, 2708, 2707
3607, 2697, 2698, 2709, 2708
3608, 2698, 614, 615, 2709
3609, 610, 2699, 2710, 611
3610, 2699, 2700, 2711, 2710
3611, 2700, 2701, 2712, 2711
3612, 2701, 2702, 2713, 2712
3613, 2702, 2703, 2714, 2713
3614, 2703, 2704, 2715, 2714
3615, 2704, 2705, 2716, 2715
3616, 2705, 2706, 2717, 2716
3617, 2706, 2707, 2718, 2717
3618, 2707, 2708, 2719, 2718
3619, 2708, 2709, 2720, 2719
3620, 2709, 615, 616, 2720
3621, 611, 2710, 581, 45
3622, 2710, 2711, 582, 581
3623, 2711, 2712, 583, 582
3624, 2712, 2713, 584, 583
3625, 2713, 2714, 585, 584
3626, 2714, 2715, 586, 585
3627, 2715, 2716, 587, 586
3628, 2716, 2717, 588, 587
3629, 2717, 2718, 589, 588
3630, 2718, 2719, 590, 589
3631, 2719, 2720, 591, 590
3632, 2720, 616, 46, 591
*ELEMENT, type=CPS4, ELSET=Surface57
3633, 42, 579, 617, 49
3634, 579, 580, 618, 617
3635, 580, 46, 50, 618
*ELEMENT, type=CPS4, ELSET=Surface58
3636, 44, 51, 619, 594
3637, 594, 619, 620, 595
3638, 595, 620, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
3639, 44, 572, 621, 51
3640, 572, 573, 622, 621
3641, 573, 574, 623, 622
3642, 574, 575, 624, 623
3643, 575, 576, 625, 624
3644, 576, 42, 49, 625
*ELEMENT, type=CPS4, ELSET=Surface60
3645, 48, 52, 626, 612
3646, 612, 626, 627, 613
3647, 613, 627, 628, 614
3648, 614, 628, 629, 615
3649, 615, 629, 630, 616
3650, 616, 630, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
3651, 51, 621, 2721, 619
3652, 619, 2721, 2722, 620
3653, 620, 2722, 626, 52
3654, 621, 622, 2723, 2721
3655, 2721, 2723, 2724, 2722
3656, 2722, 2724, 627, 626
3657, 622, 623, 2725, 2723
3658, 2723, 2725, 2726, 2724
3659, 2724, 2726, 628, 627
3660, 623, 624, 2727, 2725
3661, 2725, 2727, 2728, 2726
3662, 2726, 2728, 629, 628
3663, 624, 625, 2729, 2727
3664, 2727, 2729, 2730, 2728
3665, 2728, 2730, 630, 629
3666, 625, 49, 617, 2729
3667, 2729, 617, 618, 2730
3668, 2730, 618, 50, 630
*ELEMENT, type=CPS4, ELSET=Surface62
3669, 2, 97, 631, 54
3670, 97, 98, 632, 631
3671, 98, 99, 633, 632
3672, 99, 100, 634, 633
3673, 100, 101, 635, 634
3674, 101, 1, 53, 635
*ELEMENT, type=CPS4, ELSET=Surface63
3675, 1, 102, 636, 53
3676, 102, 103, 637, 636
3677, 103, 3, 55, 637
*ELEMENT, type=CPS4, ELSET=Surface64
3678, 4, 56, 638, 104
3679, 104, 638, 639, 105
3680, 105, 639, 640, 106
3681, 106, 640, 641, 107
3682, 107, 641, 642, 108
3683, 108, 642, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
3684, 2, 54, 643, 109
3685, 109, 643, 644, 110
3686, 110, 644, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
3687, 54, 631, 2731, 643
3688, 643, 2731, 2732, 644
3689, 644, 2732, 638, 56
3690, 631, 632, 2733, 2731
3691, 2731, 2733, 2734, 2732
3692, 2732, 2734, 639, 638
3693, 632, 633, 2735, 2733
3694, 2733, 2735, 2736, 2734
3695, 2734, 2736, 640, 639
3696, 633, 634, 2737, 2735
3697, 2735, 2737, 2738, 2736
3698, 2736, 2738, 641, 640
3699, 634, 635, 2739, 2737
3700, 2737, 2739, 2740, 2738
3701, 2738, 2740, 642, 641
3702, 635, 53, 636, 2739
3703, 2739, 636, 637, 2740
3704, 2740, 637, 55, 642
*ELEMENT, type=CPS4, ELSET=Surface77
3705, 11, 57, 645, 234
3706, 234, 645, 646, 235
3707, 235, 646, 647, 236
3708, 236, 647, 648, 237
3709, 237, 648, 649, 238
3710, 238, 649, 650, 239
3711, 239, 650, 651, 240
3712, 240, 651, 652, 241
3713, 241, 652, 653, 242
3714, 242, 653, 654, 243
3715, 243, 654, 655, 244
3716, 244, 655, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
3717, 9, 201, 656, 59
3718, 201, 202, 657, 656
3719, 202, 203, 658, 657
3720, 203, 204, 659, 658
3721, 204, 205, 660, 659
3722, 205, 206, 661, 660
3723, 206, 207, 662, 661
3724, 207, 208, 663, 662
3725, 208, 209, 664, 663
3726, 209, 210, 665, 664
3727, 210, 211, 666, 665
3728, 211, 13, 60, 666
*ELEMENT, type=CPS4, ELSET=Surface79
3729, 9, 59, 667, 180
3730, 180, 667, 668, 181
3731, 181, 668, 669, 182
3732, 182, 669, 670, 183
3733, 183, 670, 671, 184
3734, 184, 671, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
3735, 13, 245, 672, 60
3736, 245, 246, 673, 672
3737, 246, 247, 674, 673
3738, 247, 248, 675, 674
3739, 248, 249, 676, 675
3740, 249, 15, 58, 676
*ELEMENT, type=CPS4, ELSET=Surface81
3741, 59, 656, 2741, 667
3742, 656, 657, 2742, 2741
3743, 657, 658, 2743, 2742
3744, 658, 659, 2744, 2743
3745, 659, 660, 2745, 2744
3746, 660, 661, 2746, 2745
3747, 661, 662, 2747, 2746
3748, 662, 663, 2748, 2747
3749, 663, 664, 2749, 2748
3750, 664, 665, 2750, 2749
3751, 665, 666, 2751, 2750
3752, 666, 60, 672, 2751
3753, 667, 2741, 2752, 668
3754, 2741, 2742, 2753, 2752
3755, 2742, 2743, 2754, 2753
3756, 2743, 2744, 2755, 2754
3757, 2744, 2745, 2756, 2755
3758, 2745, 2746, 2757, 2756
3759, 2746, 2747, 2758, 2757
3760, 2747, 2748, 2759, 2758
3761, 2748, 2749, 2760, 2759
3762, 2749, 2750, 2761, 2760
3763, 2750, 2751, 2762, 2761
3764, 2751, 672, 673, 2762
3765, 668, 2752, 2763, 669
3766, 2752, 2753, 2764, 2763
3767, 2753, 2754, 2765, 2764
3768, 2754, 2755, 2766, 2765
3769, 2755, 2756, 2767, 2766
3770, 2756, 2757, 2768, 2767
3771, 2757, 2758, 2769, 2768
3772, 2758, 2759, 2770, 2769
3773, 2759, 2760, 2771, 2770
3774, 2760, 2761, 2772, 2771
3775, 2761, 2762, 2773, 2772
3776, 2762, 673, 674, 2773
3777, 669, 2763, 2774, 670
3778, 2763, 2764, 2775, 2774
3779, 2764, 2765, 2776, 2775
3780, 2765, 2766, 2777, 2776
3781, 2766, 2767, 2778, 2777
3782, 2767, 2768, 2779, 2778
3783, 2768, 2769, 2780, 2779
3784, 2769, 2770, 2781, 2780
3785, 2770, 2771, 2782, 2781
3786, 2771, 2772, 2783, 2782
3787, 2772, 2773, 2784, 2783
3788, 2773, 674, 675, 2784
3789, 670, 2774, 2785, 671
3790, 2774, 2775, 2786, 2785
3791, 2775, 2776, 2787, 2786
3792, 2776, 2777, 2788, 2787
3793, 2777, 2778, 2789, 2788
3794, 2778, 2779, 2790, 2789
3795, 2779, 2780, 2791, 2790
3796, 2780, 2781, 2792, 2791
3797, 2781, 2782, 2793, 2792
3798, 2782, 2783, 2794, 2793
3799, 2783, 2784, 2795, 2794
3800, 2784, 675, 676, 2795
3801, 671, 2785, 645, 57
3802, 2785, 2786, 646, 645
3803, 2786, 2787, 647, 646
3804, 2787, 2788, 648, 647
3805, 2788, 2789, 649, 648
3806, 2789, 2790, 650, 649
3807, 2790, 2791, 651, 650
3808, 2791, 2792, 652, 651
3809, 2792, 2793, 653, 652
3810, 2793, 2794, 654, 653
3811, 2794, 2795, 655, 654
3812, 2795, 676, 58, 655
*ELEMENT, type=CPS4, ELSET=Surface82
3813, 33, 61, 677, 469
3814, 469, 677, 678, 470
3815, 470, 678, 679, 471
3816, 471, 679, 680, 472
3817, 472, 680, 681, 473
3818, 473, 681, 682, 474
3819, 474, 682, 683, 475
3820, 475, 683, 684, 476
3821, 476, 684, 685, 477
3822, 477, 685, 686, 478
3823, 478, 686, 687, 479
3824, 479, 687, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
3825, 35, 502, 688, 63
3826, 502, 503, 689, 688
3827, 503, 504, 690, 689
3828, 504, 505, 691, 690
3829, 505, 506, 692, 691
3830, 506, 507, 693, 692
3831, 507, 508, 694, 693
3832, 508, 509, 695, 694
3833, 509, 510, 696, 695
3834, 510, 511, 697, 696
3835, 511, 512, 698, 697
3836, 512, 39, 64, 698
*ELEMENT, type=CPS4, ELSET=Surface84
3837, 35, 63, 699, 459
3838, 459, 699, 700, 460
3839, 460, 700, 701, 461
3840, 461, 701, 702, 462
3841, 462, 702, 703, 463
3842, 463, 703, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
3843, 39, 535, 704, 64
3844, 535, 536, 705, 704
3845, 536, 537, 706, 705
3846, 537, 538, 707, 706
3847, 538, 539, 708, 707
3848, 539, 37, 62, 708
*ELEMENT, type=CPS4, ELSET=Surface86
3849, 63, 688, 2796, 699
3850, 688, 689, 2797, 2796
3851, 689, 690, 2798, 2797
3852, 690, 691, 2799, 2798
3853, 691, 692, 2800, 2799
3854, 692, 693, 2801, 2800
3855, 693, 694, 2802, 2801
3856, 694, 695, 2803, 2802
3857, 695, 696, 2804, 2803
3858, 696, 697, 2805, 2804
3859, 697, 698, 2806, 2805
3860, 698, 64, 704, 2806
3861, 699, 2796, 2807, 700
3862, 2796, 2797, 2808, 2807
3863, 2797, 2798, 2809, 2808
3864, 2798, 2799, 2810, 2809
3865, 2799, 2800, 2811, 2810
3866, 2800, 2801, 2812, 2811
3867, 2801, 2802, 2813, 2812
3868, 2802, 2803, 2814, 2813
3869, 2803, 2804, 2815, 2814
3870, 2804, 2805, 2816, 2815
3871, 2805, 2806, 2817, 2816
3872, 2806, 704, 705, 2817
3873, 700, 2807, 2818, 701
3874, 2807, 2808, 2819, 2818
3875, 2808, 2809, 2820, 2819
3876, 2809, 2810, 2821, 2820
3877, 2810, 2811, 2822, 2821
3878, 2811, 2812, 2823, 2822
3879, 2812, 2813, 2824, 2823
3880, 2813, 2814, 2825, 2824
3881, 2814, 2815, 2826, 2825
3882, 2815, 2816, 2827, 2826
3883, 2816, 2817, 2828, 2827
3884, 2817, 705, 706, 2828
3885, 701, 2818, 2829, 702
3886, 2818, 2819, 2830, 2829
3887, 2819, 2820, 2831, 2830
3888, 2820, 2821, 2832, 2831
3889, 2821, 2822, 2833, 2832
3890, 2822, 2823, 2834, 2833
3891, 2823, 2824, 2835, 2834
3892, 2824, 2825, 2836, 2835
3893, 2825, 2826, 2837, 2836
3894, 2826, 2827, 2838, 2837
3895, 2827, 2828, 2839, 2838
3896, 2828, 706, 707, 2839
3897, 702, 2829, 2840, 703
3898, 2829, 2830, 2841, 2840
3899, 2830, 2831, 2842, 2841
3900, 2831, 2832, 2843, 2842
3901, 2832, 2833, 2844, 2843
3902, 2833, 2834, 2845, 2844
3903, 2834, 2835, 2846, 2845
3904, 2835, 2836, 2847, 2846
3905, 2836, 2837, 2848, 2847
3906, 2837, 2838, 2849, 2848
3907, 2838, 2839, 2850, 2849
3908, 2839, 707, 708, 2850
3909, 703, 2840, 677, 61
3910, 2840, 2841, 678, 677
3911, 2841, 2842, 679, 678
3912, 2842, 2843, 680, 679
3913, 2843, 2844, 681, 680
3914, 2844, 2845, 682, 681
3915, 2845, 2846, 683, 682
3916, 2846, 2847, 684, 683
3917, 2847, 2848, 685, 684
3918, 2848, 2849, 686, 685
3919, 2849, 2850, 687, 686
3920, 2850, 708, 62, 687
*ELEMENT, type=CPS4, ELSET=Surface87
3921, 9, 65, 709, 201
3922, 201, 709, 710, 202
3923, 202, 710, 711, 203
3924, 203, 711, 712, 204
3925, 204, 712, 713, 205
3926, 205, 713, 714, 206
3927, 206, 714, 715, 207
3928, 207, 715, 716, 208
3929, 208, 716, 717, 209
3930, 209, 717, 718, 210
3931, 210, 718, 719, 211
3932, 211, 719, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
3933, 10, 212, 720, 67
3934, 212, 213, 721, 720
3935, 213, 214, 722, 721
3936, 214, 215, 723, 722
3937, 215, 216, 724, 723
3938, 216, 217, 725, 724
3939, 217, 218, 726, 725
3940, 218, 219, 727, 726
3941, 219, 220, 728, 727
3942, 220, 221, 729, 728
3943, 221, 222, 730, 729
3944, 222, 14, 68, 730
*ELEMENT, type=CPS4, ELSET=Surface89
3945, 10, 67, 731, 169
3946, 169, 731, 732, 170
3947, 170, 732, 733, 171
3948, 171, 733, 734, 172
3949, 172, 734, 735, 173
3950, 173, 735, 736, 174
3951, 174, 736, 737, 175
3952, 175, 737, 738, 176
3953, 176, 738, 739, 177
3954, 177, 739, 740, 178
3955, 178, 740, 741, 179
3956, 179, 741, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
3957, 14, 223, 742, 68
3958, 223, 224, 743, 742
3959, 224, 225, 744, 743
3960, 225, 226, 745, 744
3961, 226, 227, 746, 745
3962, 227, 228, 747, 746
3963, 228, 229, 748, 747
3964, 229, 230, 749, 748
3965, 230, 231, 750, 749
3966, 231, 232, 751, 750
3967, 232, 233, 752, 751
3968, 233, 13, 66, 752
*ELEMENT, type=CPS4, ELSET=Surface91
3969, 67, 720, 2851, 731
3970, 720, 721, 2852, 2851
3971, 721, 722, 2853, 2852
3972, 722, 723, 2854, 2853
3973, 723, 724, 2855, 2854
3974, 724, 725, 2856, 2855
3975, 725, 726, 2857, 2856
3976, 726, 727, 2858, 2857
3977, 727, 728, 2859, 2858
3978, 728, 729, 2860, 2859
3979, 729, 730, 2861, 2860
3980, 730, 68, 742, 2861
3981, 731, 2851, 2862, 732
3982, 2851, 2852, 2863, 2862
3983, 2852, 2853, 2864, 2863
3984, 2853, 2854, 2865, 2864
3985, 2854, 2855, 2866, 2865
3986, 2855, 2856, 2867, 2866
3987, 2856, 2857, 2868, 2867
3988, 2857, 2858, 2869, 2868
3989, 2858, 2859, 2870, 2869
3990, 2859, 2860, 2871, 2870
3991, 2860, 2861, 2872, 2871
3992, 2861, 742, 743, 2872
3993, 732, 2862, 2873, 733
3994, 2862, 2863, 2874, 2873
3995, 2863, 2864, 2875, 2874
3996, 2864, 2865, 2876, 2875
3997, 2865, 2866, 2877, 2876
3998, 2866, 2867, 2878, 2877
3999, 2867, 2868, 2879, 2878
4000, 2868, 2869, 2880, 2879
4001, 2869, 2870, 2881, 2880
4002, 2870, 2871, 2882, 2881
4003, 2871, 2872, 2883, 2882
4004, 2872, 743, 744, 2883
4005, 733, 2873, 2884, 734
4006, 2873, 2874, 2885, 2884
4007, 2874, 2875, 2886, 2885
4008, 2875, 2876, 2887, 2886
4009, 2876, 2877, 2888, 2887
4010, 2877, 2878, 2889, 2888
4011, 2878, 2879, 2890, 2889
4012, 2879, 2880, 2891, 2890
4013, 2880, 2881, 2892, 2891
4014, 2881, 2882, 2893, 2892
4015, 2882, 2883, 2894, 2893
4016, 2883, 744, 745, 2894
4017, 734, 2884, 2895, 735
4018, 2884, 2885, 2896, 2895
4019, 2885, 2886, 2897, 2896
4020, 2886, 2887, 2898, 2897
4021, 2887, 2888, 2899, 2898
4022, 2888, 2889, 2900, 2899
4023, 2889, 2890, 2901, 2900
4024, 2890, 2891, 2902, 2901
4025, 2891, 2892, 2903, 2902
4026, 2892, 2893, 2904, 2903
4027, 2893, 2894, 2905, 2904
4028, 2894, 745, 746, 2905
4029, 735, 2895, 2906, 736
4030, 2895, 2896, 2907, 2906
4031, 2896, 2897, 2908, 2907
4032, 2897, 2898, 2909, 2908
4033, 2898, 2899, 2910, 2909
4034, 2899, 2900, 2911, 2910
4035, 2900, 2901, 2912, 2911
4036, 2901, 2902, 2913, 2912
4037, 2902, 2903, 2914, 2913
4038, 2903, 2904, 2915, 2914
4039, 2904, 2905, 2916, 2915
4040, 2905, 746, 747, 2916
4041, 736, 2906, 2917, 737
4042, 2906, 2907, 2918, 2917
4043, 2907, 2908, 2919, 2918
4044, 2908, 2909, 2920, 2919
4045, 2909, 2910, 2921, 2920
4046, 2910, 2911, 2922, 2921
4047, 2911, 2912, 2923, 2922
4048, 2912, 2913, 2924, 2923
4049, 2913, 2914, 2925, 2924
4050, 2914, 2915, 2926, 2925
4051, 2915, 2916, 2927, 2926
4052, 2916, 747, 748, 2927
4053, 737, 2917, 2928, 738
4054, 2917, 2918, 2929, 2928
4055, 2918, 2919, 2930, 2929
4056, 2919, 2920, 2931, 2930
4057, 2920, 2921, 2932, 2931
4058, 2921, 2922, 2933, 2932
4059, 2922, 2923, 2934, 2933
4060, 2923, 2924, 2935, 2934
4061, 2924, 2925, 2936, 2935
4062, 2925, 2926, 2937, 2936
4063, 2926, 2927, 2938, 2937
4064, 2927, 748, 749, 2938
4065, 738, 2928, 2939, 739
4066, 2928, 2929, 2940, 2939
4067, 2929, 2930, 2941, 2940
4068, 2930, 2931, 2942, 2941
4069, 2931, 2932, 2943, 2942
4070, 2932, 2933, 2944, 2943
4071, 2933, 2934, 2945, 2944
4072, 2934, 2935, 2946, 2945
4073, 2935, 2936, 2947, 2946
4074, 2936, 2937, 2948, 2947
4075, 2937, 2938, 2949, 2948
4076, 2938, 749, 750, 2949
4077, 739, 2939, 2950, 740
4078, 2939, 2940, 2951, 2950
4079, 2940, 2941, 2952, 2951
4080, 2941, 2942, 2953, 2952
4081, 2942, 2943, 2954, 2953
4082, 2943, 2944, 2955, 2954
4083, 2944, 2945, 2956, 2955
4084, 2945, 2946, 2957, 2956
4085, 2946, 2947, 2958, 2957
4086, 2947, 2948, 2959, 2958
4087, 2948, 2949, 2960, 2959
4088, 2949, 750, 751, 2960
4089, 740, 2950, 2961, 741
4090, 2950, 2951, 2962, 2961
4091, 2951, 2952, 2963, 2962
4092, 2952, 2953, 2964, 2963
4093, 2953, 2954, 2965, 2964
4094, 2954, 2955, 2966, 2965
4095, 2955, 2956, 2967, 2966
4096, 2956, 2957, 2968, 2967
4097, 2957, 2958, 2969, 2968
4098, 2958, 2959, 2970, 2969
4099, 2959, 2960, 2971, 2970
4100, 2960, 751, 752, 2971
4101, 741, 2961, 709, 65
4102, 2961, 2962, 710, 709
4103, 2962, 2963, 711, 710
4104, 2963, 2964, 712, 711
4105, 2964, 2965, 713, 712
4106, 2965, 2966, 714, 713
4107, 2966, 2967, 715, 714
4108, 2967, 2968, 716, 715
4109, 2968, 2969, 717, 716
4110, 2969, 2970, 718, 717
4111, 2970, 2971, 719, 718
4112, 2971, 752, 66, 719
*ELEMENT, type=CPS4, ELSET=Surface92
4113, 35, 69, 753, 502
4114, 502, 753, 754, 503
4115, 503, 754, 755, 504
4116, 504, 755, 756, 505
4117, 505, 756, 757, 506
4118, 506, 757, 758, 507
4119, 507, 758, 759, 508
4120, 508, 759, 760, 509
4121, 509, 760, 761, 510
4122, 510, 761, 762, 511
4123, 511, 762, 763, 512
4124, 512, 763, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
4125, 36, 513, 764, 71
4126, 513, 514, 765, 764
4127, 514, 515, 766, 765
4128, 515, 516, 767, 766
4129, 516, 517, 768, 767
4130, 517, 518, 769, 768
4131, 518, 519, 770, 769
4132, 519, 520, 771, 770
4133, 520, 521, 772, 771
4134, 521, 522, 773, 772
4135, 522, 523, 774, 773
4136, 523, 40, 72, 774
*ELEMENT, type=CPS4, ELSET=Surface94
4137, 35, 448, 775, 69
4138, 448, 449, 776, 775
4139, 449, 450, 777, 776
4140, 450, 451, 778, 777
4141, 451, 452, 779, 778
4142, 452, 453, 780, 779
4143, 453, 454, 781, 780
4144, 454, 455, 782, 781
4145, 455, 456, 783, 782
4146, 456, 457, 784, 783
4147, 457, 458, 785, 784
4148, 458, 36, 71, 785
*ELEMENT, type=CPS4, ELSET=Surface95
4149, 39, 70, 786, 524
4150, 524, 786, 787, 525
4151, 525, 787, 788, 526
4152, 526, 788, 789, 527
4153, 527, 789, 790, 528
4154, 528, 790, 791, 529
4155, 529, 791, 792, 530
4156, 530, 792, 793, 531
4157, 531, 793, 794, 532
4158, 532, 794, 795, 533
4159, 533, 795, 796, 534
4160, 534, 796, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
4161, 69, 775, 2972, 753
4162, 753, 2972, 2973, 754
4163, 754, 2973, 2974, 755
4164, 755, 2974, 2975, 756
4165, 756, 2975, 2976, 757
4166, 757, 2976, 2977, 758
4167, 758, 2977, 2978, 759
4168, 759, 2978, 2979, 760
4169, 760, 2979, 2980, 761
4170, 761, 2980, 2981, 762
4171, 762, 2981, 2982, 763
4172, 763, 2982, 786, 70
4173, 775, 776, 2983, 2972
4174, 2972, 2983, 2984, 2973
4175, 2973, 2984, 2985, 2974
4176, 2974, 2985, 2986, 2975
4177, 2975, 2986, 2987, 2976
4178, 2976, 2987, 2988, 2977
4179, 2977, 2988, 2989, 2978
4180, 2978, 2989, 2990, 2979
4181, 2979, 2990, 2991, 2980
4182, 2980, 2991, 2992, 2981
4183, 2981, 2992, 2993, 2982
4184, 2982, 2993, 787, 786
4185, 776, 777, 2994, 2983
4186, 2983, 2994, 2995, 2984
4187, 2984, 2995, 2996, 2985
4188, 2985, 2996, 2997, 2986
4189, 2986, 2997, 2998, 2987
4190, 2987, 2998, 2999, 2988
4191, 2988, 2999, 3000, 2989
4192, 2989, 3000, 3001, 2990
4193, 2990, 3001, 3002, 2991
4194, 2991, 3002, 3003, 2992
4195, 2992, 3003, 3004, 2993
4196, 2993, 3004, 788, 787
4197, 777, 778, 3005, 2994
4198, 2994, 3005, 3006, 2995
4199, 2995, 3006, 3007, 2996
4200, 2996, 3007, 3008, 2997
4201, 2997, 3008, 3009, 2998
4202, 2998, 3009, 3010, 2999
4203, 2999, 3010, 3011, 3000
4204, 3000, 3011, 3012, 3001
4205, 3001, 3012, 3013, 3002
4206, 3002, 3013, 3014, 3003
4207, 3003, 3014, 3015, 3004
4208, 3004, 3015, 789, 788
4209, 778, 779, 3016, 3005
4210, 3005, 3016, 3017, 3006
4211, 3006, 3017, 3018, 3007
4212, 3007, 3018, 3019, 3008
4213, 3008, 3019, 3020, 3009
4214, 3009, 3020, 3021, 3010
4215, 3010, 3021, 3022, 3011
4216, 3011, 3022, 3023, 3012
4217, 3012, 3023, 3024, 3013
4218, 3013, 3024, 3025, 3014
4219, 3014, 3025, 3026, 3015
4220, 3015, 3026, 790, 789
4221, 779, 780, 3027, 3016
4222, 3016, 3027, 3028, 3017
4223, 3017, 3028, 3029, 3018
4224, 3018, 3029, 3030, 3019
4225, 3019, 3030, 3031, 3020
4226, 3020, 3031, 3032, 3021
4227, 3021, 3032, 3033, 3022
4228, 3022, 3033, 3034, 3023
4229, 3023, 3034, 3035, 3024
4230, 3024, 3035, 3036, 3025
4231, 3025, 3036, 3037, 3026
4232, 3026, 3037, 791, 790
4233, 780, 781, 3038, 3027
4234, 3027, 3038, 3039, 3028
4235, 3028, 3039, 3040, 3029
4236, 3029, 3040, 3041, 3030
4237, 3030, 3041, 3042, 3031
4238, 3031, 3042, 3043, 3032
4239, 3032, 3043, 3044, 3033
4240, 3033, 3044, 3045, 3034
4241, 3034, 3045, 3046, 3035
4242, 3035, 3046, 3047, 3036
4243, 3036, 3047, 3048, 3037
4244, 3037, 3048, 792, 791
4245, 781, 782, 3049, 3038
4246, 3038, 3049, 3050, 3039
4247, 3039, 3050, 3051, 3040
4248, 3040, 3051, 3052, 3041
4249, 3041, 3052, 3053, 3042
4250, 3042, 3053, 3054, 3043
4251, 3043, 3054, 3055, 3044
4252, 3044, 3055, 3056, 3045
4253, 3045, 3056, 3057, 3046
4254, 3046, 3057, 3058, 3047
4255, 3047, 3058, 3059, 3048
4256, 3048, 3059, 793, 792
4257, 782, 783, 3060, 3049
4258, 3049, 3060, 3061, 3050
4259, 3050, 3061, 3062, 3051
4260, 3051, 3062, 3063, 3052
4261, 3052, 3063, 3064, 3053
4262, 3053, 3064, 3065, 3054
4263, 3054, 3065, 3066, 3055
4264, 3055, 3066, 3067, 3056
4265, 3056, 3067, 3068, 3057
4266, 3057, 3068, 3069, 3058
4267, 3058, 3069, 3070, 3059
4268, 3059, 3070, 794, 793
4269, 783, 784, 3071, 3060
4270, 3060, 3071, 3072, 3061
4271, 3061, 3072, 3073, 3062
4272, 3062, 3073, 3074, 3063
4273, 3063, 3074, 3075, 3064
4274, 3064, 3075, 3076, 3065
4275, 3065, 3076, 3077, 3066
4276, 3066, 3077, 3078, 3067
4277, 3067, 3078, 3079, 3068
4278, 3068, 3079, 3080, 3069
4279, 3069, 3080, 3081, 3070
4280, 3070, 3081, 795, 794
4281, 784, 785, 3082, 3071
4282, 3071, 3082, 3083, 3072
4283, 3072, 3083, 3084, 3073
4284, 3073, 3084, 3085, 3074
4285, 3074, 3085, 3086, 3075
4286, 3075, 3086, 3087, 3076
4287, 3076, 3087, 3088, 3077
4288, 3077, 3088, 3089, 3078
4289, 3078, 3089, 3090, 3079
4290, 3079, 3090, 3091, 3080
4291, 3080, 3091, 3092, 3081
4292, 3081, 3092, 796, 795
4293, 785, 71, 764, 3082
4294, 3082, 764, 765, 3083
4295, 3083, 765, 766, 3084
4296, 3084, 766, 767, 3085
4297, 3085, 767, 768, 3086
4298, 3086, 768, 769, 3087
4299, 3087, 769, 770, 3088
4300, 3088, 770, 771, 3089
4301, 3089, 771, 772, 3090
4302, 3090, 772, 773, 3091
4303, 3091, 773, 774, 3092
4304, 3092, 774, 72, 796
*ELEMENT, type=CPS4, ELSET=Surface97
4305, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
4306, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
4307, 63, 73, 797, 688
4308, 688, 797, 798, 689
4309, 689, 798, 799, 690
4310, 690, 799, 800, 691
4311, 691, 800, 801, 692
4312, 692, 801, 802, 693
4313, 693, 802, 803, 694
4314, 694, 803, 804, 695
4315, 695, 804, 805, 696
4316, 696, 805, 806, 697
4317, 697, 806, 807, 698
4318, 698, 807, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
4319, 69, 753, 797, 73
4320, 753, 754, 798, 797
4321, 754, 755, 799, 798
4322, 755, 756, 800, 799
4323, 756, 757, 801, 800
4324, 757, 758, 802, 801
4325, 758, 759, 803, 802
4326, 759, 760, 804, 803
4327, 760, 761, 805, 804
4328, 761, 762, 806, 805
4329, 762, 763, 807, 806
4330, 763, 70, 74, 807
*ELEMENT, type=CPS4, ELSET=Surface101
4331, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
4332, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
4333, 59, 75, 808, 656
4334, 656, 808, 809, 657
4335, 657, 809, 810, 658
4336, 658, 810, 811, 659
4337, 659, 811, 812, 660
4338, 660, 812, 813, 661
4339, 661, 813, 814, 662
4340, 662, 814, 815, 663
4341, 663, 815, 816, 664
4342, 664, 816, 817, 665
4343, 665, 817, 818, 666
4344, 666, 818, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
4345, 65, 709, 808, 75
4346, 709, 710, 809, 808
4347, 710, 711, 810, 809
4348, 711, 712, 811, 810
4349, 712, 713, 812, 811
4350, 713, 714, 813, 812
4351, 714, 715, 814, 813
4352, 715, 716, 815, 814
4353, 716, 717, 816, 815
4354, 717, 718, 817, 816
4355, 718, 719, 818, 817
4356, 719, 66, 76, 818
*ELEMENT, type=CPS4, ELSET=Surface105
4357, 22, 823, 3093, 313
4358, 823, 824, 3094, 3093
4359, 824, 825, 3095, 3094
4360, 825, 826, 3096, 3095
4361, 826, 78, 827, 3096
4362, 313, 3093, 3097, 314
4363, 3093, 3094, 3098, 3097
4364, 3094, 3095, 3099, 3098
4365, 3095, 3096, 3100, 3099
4366, 3096, 827, 828, 3100
4367, 314, 3097, 3101, 315
4368, 3097, 3098, 3102, 3101
4369, 3098, 3099, 3103, 3102
4370, 3099, 3100, 3104, 3103
4371, 3100, 828, 829, 3104
4372, 315, 3101, 3105, 316
4373, 3101, 3102, 3106, 3105
4374, 3102, 3103, 3107, 3106
4375, 3103, 3104, 3108, 3107
4376, 3104, 829, 830, 3108
4377, 316, 3105, 3109, 317
4378, 3105, 3106, 3110, 3109
4379, 3106, 3107, 3111, 3110
4380, 3107, 3108, 3112, 3111
4381, 3108, 830, 831, 3112
4382, 317, 3109, 3113, 318
4383, 3109, 3110, 3114, 3113
4384, 3110, 3111, 3115, 3114
4385, 3111, 3112, 3116, 3115
4386, 3112, 831, 832, 3116
4387, 318, 3113, 3117, 319
4388, 3113, 3114, 3118, 3117
4389, 3114, 3115, 3119, 3118
4390, 3115, 3116, 3120, 3119
4391, 3116, 832, 833, 3120
4392, 319, 3117, 3121, 320
4393, 3117, 3118, 3122, 3121
4394, 3118, 3119, 3123, 3122
4395, 3119, 3120, 3124, 3123
4396, 3120, 833, 834, 3124
4397, 320, 3121, 3125, 321
4398, 3121, 3122, 3126, 3125
4399, 3122, 3123, 3127, 3126
4400, 3123, 3124, 3128, 3127
4401, 3124, 834, 835, 3128
4402, 321, 3125, 3129, 322
4403, 3125, 3126, 3130, 3129
4404, 3126, 3127, 3131, 3130
4405, 3127, 3128, 3132, 3131
4406, 3128, 835, 836, 3132
4407, 322, 3129, 3133, 323
4408, 3129, 3130, 3134, 3133
4409, 3130, 3131, 3135, 3134
4410, 3131, 3132, 3136, 3135
4411, 3132, 836, 837, 3136
4412, 323, 3133, 819, 21
4413, 3133, 3134, 820, 819
4414, 3134, 3135, 821, 820
4415, 3135, 3136, 822, 821
4416, 3136, 837, 77, 822
*ELEMENT, type=CPS4, ELSET=Surface106
4417, 21, 819, 3137, 326
4418, 819, 820, 3138, 3137
4419, 820, 821, 3139, 3138
4420, 821, 822, 3140, 3139
4421, 822, 77, 842, 3140
4422, 326, 3137, 3141, 327
4423, 3137, 3138, 3142, 3141
4424, 3138, 3139, 3143, 3142
4425, 3139, 3140, 3144, 3143
4426, 3140, 842, 843, 3144
4427, 327, 3141, 3145, 328
4428, 3141, 3142, 3146, 3145
4429, 3142, 3143, 3147, 3146
4430, 3143, 3144, 3148, 3147
4431, 3144, 843, 844, 3148
4432, 328, 3145, 3149, 329
4433, 3145, 3146, 3150, 3149
4434, 3146, 3147, 3151, 3150
4435, 3147, 3148, 3152, 3151
4436, 3148, 844, 845, 3152
4437, 329, 3149, 3153, 330
4438, 3149, 3150, 3154, 3153
4439, 3150, 3151, 3155, 3154
4440, 3151, 3152, 3156, 3155
4441, 3152, 845, 846, 3156
4442, 330, 3153, 838, 23
4443, 3153, 3154, 839, 838
4444, 3154, 3155, 840, 839
4445, 3155, 3156, 841, 840
4446, 3156, 846, 79, 841
*ELEMENT, type=CPS4, ELSET=Surface107
4447, 24, 333, 3157, 847
4448, 847, 3157, 3158, 848
4449, 848, 3158, 3159, 849
4450, 849, 3159, 3160, 850
4451, 850, 3160, 851, 80
4452, 333, 334, 3161, 3157
4453, 3157, 3161, 3162, 3158
4454, 3158, 3162, 3163, 3159
4455, 3159, 3163, 3164, 3160
4456, 3160, 3164, 852, 851
4457, 334, 335, 3165, 3161
4458, 3161, 3165, 3166, 3162
4459, 3162, 3166, 3167, 3163
4460, 3163, 3167, 3168, 3164
4461, 3164, 3168, 853, 852
4462, 335, 336, 3169, 3165
4463, 3165, 3169, 3170, 3166
4464, 3166, 3170, 3171, 3167
4465, 3167, 3171, 3172, 3168
4466, 3168, 3172, 854, 853
4467, 336, 337, 3173, 3169
4468, 3169, 3173, 3174, 3170
4469, 3170, 3174, 3175, 3171
4470, 3171, 3175, 3176, 3172
4471, 3172, 3176, 855, 854
4472, 337, 338, 3177, 3173
4473, 3173, 3177, 3178, 3174
4474, 3174, 3178, 3179, 3175
4475, 3175, 3179, 3180, 3176
4476, 3176, 3180, 856, 855
4477, 338, 339, 3181, 3177
4478, 3177, 3181, 3182, 3178
4479, 3178, 3182, 3183, 3179
4480, 3179, 3183, 3184, 3180
4481, 3180, 3184, 857, 856
4482, 339, 340, 3185, 3181
4483, 3181, 3185, 3186, 3182
4484, 3182, 3186, 3187, 3183
4485, 3183, 3187, 3188, 3184
4486, 3184, 3188, 858, 857
4487, 340, 341, 3189, 3185
4488, 3185, 3189, 3190, 3186
4489, 3186, 3190, 3191, 3187
4490, 3187, 3191, 3192, 3188
4491, 3188, 3192, 859, 858
4492, 341, 342, 3193, 3189
4493, 3189, 3193, 3194, 3190
4494, 3190, 3194, 3195, 3191
4495, 3191, 3195, 3196, 3192
4496, 3192, 3196, 860, 859
4497, 342, 343, 3197, 3193
4498, 3193, 3197, 3198, 3194
4499, 3194, 3198, 3199, 3195
4500, 3195, 3199, 3200, 3196
4501, 3196, 3200, 861, 860
4502, 343, 23, 838, 3197
4503, 3197, 838, 839, 3198
4504, 3198, 839, 840, 3199
4505, 3199, 840, 841, 3200
4506, 3200, 841, 79, 861
*ELEMENT, type=CPS4, ELSET=Surface108
4507, 22, 344, 3201, 823
4508, 823, 3201, 3202, 824
4509, 824, 3202, 3203, 825
4510, 825, 3203, 3204, 826
4511, 826, 3204, 862, 78
4512, 344, 345, 3205, 3201
4513, 3201, 3205, 3206, 3202
4514, 3202, 3206, 3207, 3203
4515, 3203, 3207, 3208, 3204
4516, 3204, 3208, 863, 862
4517, 345, 346, 3209, 3205
4518, 3205, 3209, 3210, 3206
4519, 3206, 3210, 3211, 3207
4520, 3207, 3211, 3212, 3208
4521, 3208, 3212, 864, 863
4522, 346, 347, 3213, 3209
4523, 3209, 3213, 3214, 3210
4524, 3210, 3214, 3215, 3211
4525, 3211, 3215, 3216, 3212
4526, 3212, 3216, 865, 864
4527, 347, 348, 3217, 3213
4528, 3213, 3217, 3218, 3214
4529, 3214, 3218, 3219, 3215
4530, 3215, 3219, 3220, 3216
4531, 3216, 3220, 866, 865
4532, 348, 24, 847, 3217
4533, 3217, 847, 848, 3218
4534, 3218, 848, 849, 3219
4535, 3219, 849, 850, 3220
4536, 3220, 850, 80, 866
*ELEMENT, type=CPS4, ELSET=Surface109
4537, 78, 862, 3221, 827
4538, 862, 863, 3222, 3221
4539, 863, 864, 3223, 3222
4540, 864, 865, 3224, 3223
4541, 865, 866, 3225, 3224
4542, 866, 80, 851, 3225
4543, 827, 3221, 3226, 828
4544, 3221, 3222, 3227, 3226
4545, 3222, 3223, 3228, 3227
4546, 3223, 3224, 3229, 3228
4547, 3224, 3225, 3230, 3229
4548, 3225, 851, 852, 3230
4549, 828, 3226, 3231, 829
4550, 3226, 3227, 3232, 3231
4551, 3227, 3228, 3233, 3232
4552, 3228, 3229, 3234, 3233
4553, 3229, 3230, 3235, 3234
4554, 3230, 852, 853, 3235
4555, 829, 3231, 3236, 830
4556, 3231, 3232, 3237, 3236
4557, 3232, 3233, 3238, 3237
4558, 3233, 3234, 3239, 3238
4559, 3234, 3235, 3240, 3239
4560, 3235, 853, 854, 3240
4561, 830, 3236, 3241, 831
4562, 3236, 3237, 3242, 3241
4563, 3237, 3238, 3243, 3242
4564, 3238, 3239, 3244, 3243
4565, 3239, 3240, 3245, 3244
4566, 3240, 854, 855, 3245
4567, 831, 3241, 3246, 832
4568, 3241, 3242, 3247, 3246
4569, 3242, 3243, 3248, 3247
4570, 3243, 3244, 3249, 3248
4571, 3244, 3245, 3250, 3249
4572, 3245, 855, 856, 3250
4573, 832, 3246, 3251, 833
4574, 3246, 3247, 3252, 3251
4575, 3247, 3248, 3253, 3252
4576, 3248, 3249, 3254, 3253
4577, 3249, 3250, 3255, 3254
4578, 3250, 856, 857, 3255
4579, 833, 3251, 3256, 834
4580, 3251, 3252, 3257, 3256
4581, 3252, 3253, 3258, 3257
4582, 3253, 3254, 3259, 3258
4583, 3254, 3255, 3260, 3259
4584, 3255, 857, 858, 3260
4585, 834, 3256, 3261, 835
4586, 3256, 3257, 3262, 3261
4587, 3257, 3258, 3263, 3262
4588, 3258, 3259, 3264, 3263
4589, 3259, 3260, 3265, 3264
4590, 3260, 858, 859, 3265
4591, 835, 3261, 3266, 836
4592, 3261, 3262, 3267, 3266
4593, 3262, 3263, 3268, 3267
4594, 3263, 3264, 3269, 3268
4595, 3264, 3265, 3270, 3269
4596, 3265, 859, 860, 3270
4597, 836, 3266, 3271, 837
4598, 3266, 3267, 3272, 3271
4599, 3267, 3268, 3273, 3272
4600, 3268, 3269, 3274, 3273
4601, 3269, 3270, 3275, 3274
4602, 3270, 860, 861, 3275
4603, 837, 3271, 842, 77
4604, 3271, 3272, 843, 842
4605, 3272, 3273, 844, 843
4606, 3273, 3274, 845, 844
4607, 3274, 3275, 846, 845
4608, 3275, 861, 79, 846
*ELEMENT, type=CPS4, ELSET=Surface110
4609, 23, 353, 3276, 838
4610, 838, 3276, 3277, 839
4611, 839, 3277, 3278, 840
4612, 840, 3278, 3279, 841
4613, 841, 3279, 871, 79
4614, 353, 354, 3280, 3276
4615, 3276, 3280, 3281, 3277
4616, 3277, 3281, 3282, 3278
4617, 3278, 3282, 3283, 3279
4618, 3279, 3283, 872, 871
4619, 354, 355, 3284, 3280
4620, 3280, 3284, 3285, 3281
4621, 3281, 3285, 3286, 3282
4622, 3282, 3286, 3287, 3283
4623, 3283, 3287, 873, 872
4624, 355, 356, 3288, 3284
4625, 3284, 3288, 3289, 3285
4626, 3285, 3289, 3290, 3286
4627, 3286, 3290, 3291, 3287
4628, 3287, 3291, 874, 873
4629, 356, 26, 867, 3288
4630, 3288, 867, 868, 3289
4631, 3289, 868, 869, 3290
4632, 3290, 869, 870, 3291
4633, 3291, 870, 81, 874
*ELEMENT, type=CPS4, ELSET=Surface111
4634, 21, 819, 3292, 363
4635, 819, 820, 3293, 3292
4636, 820, 821, 3294, 3293
4637, 821, 822, 3295, 3294
4638, 822, 77, 879, 3295
4639, 363, 3292, 3296, 364
4640, 3292, 3293, 3297, 3296
4641, 3293, 3294, 3298, 3297
4642, 3294, 3295, 3299, 3298
4643, 3295, 879, 880, 3299
4644, 364, 3296, 3300, 365
4645, 3296, 3297, 3301, 3300
4646, 3297, 3298, 3302, 3301
4647, 3298, 3299, 3303, 3302
4648, 3299, 880, 881, 3303
4649, 365, 3300, 3304, 366
4650, 3300, 3301, 3305, 3304
4651, 3301, 3302, 3306, 3305
4652, 3302, 3303, 3307, 3306
4653, 3303, 881, 882, 3307
4654, 366, 3304, 875, 28
4655, 3304, 3305, 876, 875
4656, 3305, 3306, 877, 876
4657, 3306, 3307, 878, 877
4658, 3307, 882, 82, 878
*ELEMENT, type=CPS4, ELSET=Surface112
4659, 28, 875, 3308, 374
4660, 875, 876, 3309, 3308
4661, 876, 877, 3310, 3309
4662, 877, 878, 3311, 3310
4663, 878, 82, 883, 3311
4664, 374, 3308, 3312, 375
4665, 3308, 3309, 3313, 3312
4666, 3309, 3310, 3314, 3313
4667, 3310, 3311, 3315, 3314
4668, 3311, 883, 884, 3315
4669, 375, 3312, 3316, 376
4670, 3312, 3313, 3317, 3316
4671, 3313, 3314, 3318, 3317
4672, 3314, 3315, 3319, 3318
4673, 3315, 884, 885, 3319
4674, 376, 3316, 3320, 377
4675, 3316, 3317, 3321, 3320
4676, 3317, 3318, 3322, 3321
4677, 3318, 3319, 3323, 3322
4678, 3319, 885, 886, 3323
4679, 377, 3320, 3324, 378
4680, 3320, 3321, 3325, 3324
4681, 3321, 3322, 3326, 3325
4682, 3322, 3323, 3327, 3326
4683, 3323, 886, 887, 3327
4684, 378, 3324, 867, 26
4685, 3324, 3325, 868, 867
4686, 3325, 3326, 869, 868
4687, 3326, 3327, 870, 869
4688, 3327, 887, 81, 870
*ELEMENT, type=CPS4, ELSET=Surface113
4689, 77, 842, 3328, 879
4690, 879, 3328, 3329, 880
4691, 880, 3329, 3330, 881
4692, 881, 3330, 3331, 882
4693, 882, 3331, 883, 82
4694, 842, 843, 3332, 3328
4695, 3328, 3332, 3333, 3329
4696, 3329, 3333, 3334, 3330
4697, 3330, 3334, 3335, 3331
4698, 3331, 3335, 884, 883
4699, 843, 844, 3336, 3332
4700, 3332, 3336, 3337, 3333
4701, 3333, 3337, 3338, 3334
4702, 3334, 3338, 3339, 3335
4703, 3335, 3339, 885, 884
4704, 844, 845, 3340, 3336
4705, 3336, 3340, 3341, 3337
4706, 3337, 3341, 3342, 3338
4707, 3338, 3342, 3343, 3339
4708, 3339, 3343, 886, 885
4709, 845, 846, 3344, 3340
4710, 3340, 3344, 3345, 3341
4711, 3341, 3345, 3346, 3342
4712, 3342, 3346, 3347, 3343
4713, 3343, 3347, 887, 886
4714, 846, 79, 871, 3344
4715, 3344, 871, 872, 3345
4716, 3345, 872, 873, 3346
4717, 3346, 873, 874, 3347
4718, 3347, 874, 81, 887
*ELEMENT, type=CPS4, ELSET=Surface114
4719, 26, 390, 3348, 867
4720, 867, 3348, 3349, 868
4721, 868, 3349, 3350, 869
4722, 869, 3350, 3351, 870
4723, 870, 3351, 892, 81
4724, 390, 391, 3352, 3348
4725, 3348, 3352, 3353, 3349
4726, 3349, 3353, 3354, 3350
4727, 3350, 3354, 3355, 3351
4728, 3351, 3355, 893, 892
4729, 391, 392, 3356, 3352
4730, 3352, 3356, 3357, 3353
4731, 3353, 3357, 3358, 3354
4732, 3354, 3358, 3359, 3355
4733, 3355, 3359, 894, 893
4734, 392, 393, 3360, 3356
4735, 3356, 3360, 3361, 3357
4736, 3357, 3361, 3362, 3358
4737, 3358, 3362, 3363, 3359
4738, 3359, 3363, 895, 894
4739, 393, 394, 3364, 3360
4740, 3360, 3364, 3365, 3361
4741, 3361, 3365, 3366, 3362
4742, 3362, 3366, 3367, 3363
4743, 3363, 3367, 896, 895
4744, 394, 395, 3368, 3364
4745, 3364, 3368, 3369, 3365
4746, 3365, 3369, 3370, 3366
4747, 3366, 3370, 3371, 3367
4748, 3367, 3371, 897, 896
4749, 395, 396, 3372, 3368
4750, 3368, 3372, 3373, 3369
4751, 3369, 3373, 3374, 3370
4752, 3370, 3374, 3375, 3371
4753, 3371, 3375, 898, 897
4754, 396, 397, 3376, 3372
4755, 3372, 3376, 3377, 3373
4756, 3373, 3377, 3378, 3374
4757, 3374, 3378, 3379, 3375
4758, 3375, 3379, 899, 898
4759, 397, 398, 3380, 3376
4760, 3376, 3380, 3381, 3377
4761, 3377, 3381, 3382, 3378
4762, 3378, 3382, 3383, 3379
4763, 3379, 3383, 900, 899
4764, 398, 399, 3384, 3380
4765, 3380, 3384, 3385, 3381
4766, 3381, 3385, 3386, 3382
4767, 3382, 3386, 3387, 3383
4768, 3383, 3387, 901, 900
4769, 399, 400, 3388, 3384
4770, 3384, 3388, 3389, 3385
4771, 3385, 3389, 3390, 3386
4772, 3386, 3390, 3391, 3387
4773, 3387, 3391, 902, 901
4774, 400, 30, 888, 3388
4775, 3388, 888, 889, 3389
4776, 3389, 889, 890, 3390
4777, 3390, 890, 891, 3391
4778, 3391, 891, 83, 902
*ELEMENT, type=CPS4, ELSET=Surface115
4779, 28, 875, 3392, 414
4780, 875, 876, 3393, 3392
4781, 876, 877, 3394, 3393
4782, 877, 878, 3395, 3394
4783, 878, 82, 907, 3395
4784, 414, 3392, 3396, 415
4785, 3392, 3393, 3397, 3396
4786, 3393, 3394, 3398, 3397
4787, 3394, 3395, 3399, 3398
4788, 3395, 907, 908, 3399
4789, 415, 3396, 3400, 416
4790, 3396, 3397, 3401, 3400
4791, 3397, 3398, 3402, 3401
4792, 3398, 3399, 3403, 3402
4793, 3399, 908, 909, 3403
4794, 416, 3400, 3404, 417
4795, 3400, 3401, 3405, 3404
4796, 3401, 3402, 3406, 3405
4797, 3402, 3403, 3407, 3406
4798, 3403, 909, 910, 3407
4799, 417, 3404, 3408, 418
4800, 3404, 3405, 3409, 3408
4801, 3405, 3406, 3410, 3409
4802, 3406, 3407, 3411, 3410
4803, 3407, 910, 911, 3411
4804, 418, 3408, 3412, 419
4805, 3408, 3409, 3413, 3412
4806, 3409, 3410, 3414, 3413
4807, 3410, 3411, 3415, 3414
4808, 3411, 911, 912, 3415
4809, 419, 3412, 3416, 420
4810, 3412, 3413, 3417, 3416
4811, 3413, 3414, 3418, 3417
4812, 3414, 3415, 3419, 3418
4813, 3415, 912, 913, 3419
4814, 420, 3416, 3420, 421
4815, 3416, 3417, 3421, 3420
4816, 3417, 3418, 3422, 3421
4817, 3418, 3419, 3423, 3422
4818, 3419, 913, 914, 3423
4819, 421, 3420, 3424, 422
4820, 3420, 3421, 3425, 3424
4821, 3421, 3422, 3426, 3425
4822, 3422, 3423, 3427, 3426
4823, 3423, 914, 915, 3427
4824, 422, 3424, 3428, 423
4825, 3424, 3425, 3429, 3428
4826, 3425, 3426, 3430, 3429
4827, 3426, 3427, 3431, 3430
4828, 3427, 915, 916, 3431
4829, 423, 3428, 3432, 424
4830, 3428, 3429, 3433, 3432
4831, 3429, 3430, 3434, 3433
4832, 3430, 3431, 3435, 3434
4833, 3431, 916, 917, 3435
4834, 424, 3432, 903, 32
4835, 3432, 3433, 904, 903
4836, 3433, 3434, 905, 904
4837, 3434, 3435, 906, 905
4838, 3435, 917, 84, 906
*ELEMENT, type=CPS4, ELSET=Surface116
4839, 32, 903, 3436, 432
4840, 903, 904, 3437, 3436
4841, 904, 905, 3438, 3437
4842, 905, 906, 3439, 3438
4843, 906, 84, 918, 3439
4844, 432, 3436, 3440, 433
4845, 3436, 3437, 3441, 3440
4846, 3437, 3438, 3442, 3441
4847, 3438, 3439, 3443, 3442
4848, 3439, 918, 919, 3443
4849, 433, 3440, 3444, 434
4850, 3440, 3441, 3445, 3444
4851, 3441, 3442, 3446, 3445
4852, 3442, 3443, 3447, 3446
4853, 3443, 919, 920, 3447
4854, 434, 3444, 3448, 435
4855, 3444, 3445, 3449, 3448
4856, 3445, 3446, 3450, 3449
4857, 3446, 3447, 3451, 3450
4858, 3447, 920, 921, 3451
4859, 435, 3448, 3452, 436
4860, 3448, 3449, 3453, 3452
4861, 3449, 3450, 3454, 3453
4862, 3450, 3451, 3455, 3454
4863, 3451, 921, 922, 3455
4864, 436, 3452, 888, 30
4865, 3452, 3453, 889, 888
4866, 3453, 3454, 890, 889
4867, 3454, 3455, 891, 890
4868, 3455, 922, 83, 891
*ELEMENT, type=CPS4, ELSET=Surface117
4869, 82, 883, 3456, 907
4870, 907, 3456, 3457, 908
4871, 908, 3457, 3458, 909
4872, 909, 3458, 3459, 910
4873, 910, 3459, 3460, 911
4874, 911, 3460, 3461, 912
4875, 912, 3461, 3462, 913
4876, 913, 3462, 3463, 914
4877, 914, 3463, 3464, 915
4878, 915, 3464, 3465, 916
4879, 916, 3465, 3466, 917
4880, 917, 3466, 918, 84
4881, 883, 884, 3467, 3456
4882, 3456, 3467, 3468, 3457
4883, 3457, 3468, 3469, 3458
4884, 3458, 3469, 3470, 3459
4885, 3459, 3470, 3471, 3460
4886, 3460, 3471, 3472, 3461
4887, 3461, 3472, 3473, 3462
4888, 3462, 3473, 3474, 3463
4889, 3463, 3474, 3475, 3464
4890, 3464, 3475, 3476, 3465
4891, 3465, 3476, 3477, 3466
4892, 3466, 3477, 919, 918
4893, 884, 885, 3478, 3467
4894, 3467, 3478, 3479, 3468
4895, 3468, 3479, 3480, 3469
4896, 3469, 3480, 3481, 3470
4897, 3470, 3481, 3482, 3471
4898, 3471, 3482, 3483, 3472
4899, 3472, 3483, 3484, 3473
4900, 3473, 3484, 3485, 3474
4901, 3474, 3485, 3486, 3475
4902, 3475, 3486, 3487, 3476
4903, 3476, 3487, 3488, 3477
4904, 3477, 3488, 920, 919
4905, 885, 886, 3489, 3478
4906, 3478, 3489, 3490, 3479
4907, 3479, 3490, 3491, 3480
4908, 3480, 3491, 3492, 3481
4909, 3481, 3492, 3493, 3482
4910, 3482, 3493, 3494, 3483
4911, 3483, 3494, 3495, 3484
4912, 3484, 3495, 3496, 3485
4913, 3485, 3496, 3497, 3486
4914, 3486, 3497, 3498, 3487
4915, 3487, 3498, 3499, 3488
4916, 3488, 3499, 921, 920
4917, 886, 887, 3500, 3489
4918, 3489, 3500, 3501, 3490
4919, 3490, 3501, 3502, 3491
4920, 3491, 3502, 3503, 3492
4921, 3492, 3503, 3504, 3493
4922, 3493, 3504, 3505, 3494
4923, 3494, 3505, 3506, 3495
4924, 3495, 3506, 3507, 3496
4925, 3496, 3507, 3508, 3497
4926, 3497, 3508, 3509, 3498
4927, 3498, 3509, 3510, 3499
4928, 3499, 3510, 922, 921
4929, 887, 81, 892, 3500
4930, 3500, 892, 893, 3501
4931, 3501, 893, 894, 3502
4932, 3502, 894, 895, 3503
4933, 3503, 895, 896, 3504
4934, 3504, 896, 897, 3505
4935, 3505, 897, 898, 3506
4936, 3506, 898, 899, 3507
4937, 3507, 899, 900, 3508
4938, 3508, 900, 901, 3509
4939, 3509, 901, 902, 3510
4940, 3510, 902, 83, 922
*ELEMENT, type=CPS4, ELSET=Surface118
4941, 2, 125, 3511, 927
4942, 927, 3511, 3512, 928
4943, 928, 3512, 3513, 929
4944, 929, 3513, 3514, 930
4945, 930, 3514, 931, 86
4946, 125, 126, 3515, 3511
4947, 3511, 3515, 3516, 3512
4948, 3512, 3516, 3517, 3513
4949, 3513, 3517, 3518, 3514
4950, 3514, 3518, 932, 931
4951, 126, 127, 3519, 3515
4952, 3515, 3519, 3520, 3516
4953, 3516, 3520, 3521, 3517
4954, 3517, 3521, 3522, 3518
4955, 3518, 3522, 933, 932
4956, 127, 128, 3523, 3519
4957, 3519, 3523, 3524, 3520
4958, 3520, 3524, 3525, 3521
4959, 3521, 3525, 3526, 3522
4960, 3522, 3526, 934, 933
4961, 128, 129, 3527, 3523
4962, 3523, 3527, 3528, 3524
4963, 3524, 3528, 3529, 3525
4964, 3525, 3529, 3530, 3526
4965, 3526, 3530, 935, 934
4966, 129, 130, 3531, 3527
4967, 3527, 3531, 3532, 3528
4968, 3528, 3532, 3533, 3529
4969, 3529, 3533, 3534, 3530
4970, 3530, 3534, 936, 935
4971, 130, 131, 3535, 3531
4972, 3531, 3535, 3536, 3532
4973, 3532, 3536, 3537, 3533
4974, 3533, 3537, 3538, 3534
4975, 3534, 3538, 937, 936
4976, 131, 132, 3539, 3535
4977, 3535, 3539, 3540, 3536
4978, 3536, 3540, 3541, 3537
4979, 3537, 3541, 3542, 3538
4980, 3538, 3542, 938, 937
4981, 132, 133, 3543, 3539
4982, 3539, 3543, 3544, 3540
4983, 3540, 3544, 3545, 3541
4984, 3541, 3545, 3546, 3542
4985, 3542, 3546, 939, 938
4986, 133, 134, 3547, 3543
4987, 3543, 3547, 3548, 3544
4988, 3544, 3548, 3549, 3545
4989, 3545, 3549, 3550, 3546
4990, 3546, 3550, 940, 939
4991, 134, 135, 3551, 3547
4992, 3547, 3551, 3552, 3548
4993, 3548, 3552, 3553, 3549
4994, 3549, 3553, 3554, 3550
4995, 3550, 3554, 941, 940
4996, 135, 6, 923, 3551
4997, 3551, 923, 924, 3552
4998, 3552, 924, 925, 3553
4999, 3553, 925, 926, 3554
5000, 3554, 926, 85, 941
*ELEMENT, type=CPS4, ELSET=Surface119
5001, 6, 111, 3555, 923
5002, 923, 3555, 3556, 924
5003, 924, 3556, 3557, 925
5004, 925, 3557, 3558, 926
5005, 926, 3558, 946, 85
5006, 111, 112, 3559, 3555
5007, 3555, 3559, 3560, 3556
5008, 3556, 3560, 3561, 3557
5009, 3557, 3561, 3562, 3558
5010, 3558, 3562, 947, 946
5011, 112, 113, 3563, 3559
5012, 3559, 3563, 3564, 3560
5013, 3560, 3564, 3565, 3561
5014, 3561, 3565, 3566, 3562
5015, 3562, 3566, 948, 947
5016, 113, 114, 3567, 3563
5017, 3563, 3567, 3568, 3564
5018, 3564, 3568, 3569, 3565
5019, 3565, 3569, 3570, 3566
5020, 3566, 3570, 949, 948
5021, 114, 115, 3571, 3567
5022, 3567, 3571, 3572, 3568
5023, 3568, 3572, 3573, 3569
5024, 3569, 3573, 3574, 3570
5025, 3570, 3574, 950, 949
5026, 115, 5, 942, 3571
5027, 3571, 942, 943, 3572
5028, 3572, 943, 944, 3573
5029, 3573, 944, 945, 3574
5030, 3574, 945, 87, 950
*ELEMENT, type=CPS4, ELSET=Surface120
5031, 1, 951, 3575, 136
5032, 951, 952, 3576, 3575
5033, 952, 953, 3577, 3576
5034, 953, 954, 3578, 3577
5035, 954, 88, 955, 3578
5036, 136, 3575, 3579, 137
5037, 3575, 3576, 3580, 3579
5038, 3576, 3577, 3581, 3580
5039, 3577, 3578, 3582, 3581
5040, 3578, 955, 956, 3582
5041, 137, 3579, 3583, 138
5042, 3579, 3580, 3584, 3583
5043, 3580, 3581, 3585, 3584
5044, 3581, 3582, 3586, 3585
5045, 3582, 956, 957, 3586
5046, 138, 3583, 3587, 139
5047, 3583, 3584, 3588, 3587
5048, 3584, 3585, 3589, 3588
5049, 3585, 3586, 3590, 3589
5050, 3586, 957, 958, 3590
5051, 139, 3587, 3591, 140
5052, 3587, 3588, 3592, 3591
5053, 3588, 3589, 3593, 3592
5054, 3589, 3590, 3594, 3593
5055, 3590, 958, 959, 3594
5056, 140, 3591, 3595, 141
5057, 3591, 3592, 3596, 3595
5058, 3592, 3593, 3597, 3596
5059, 3593, 3594, 3598, 3597
5060, 3594, 959, 960, 3598
5061, 141, 3595, 3599, 142
5062, 3595, 3596, 3600, 3599
5063, 3596, 3597, 3601, 3600
5064, 3597, 3598, 3602, 3601
5065, 3598, 960, 961, 3602
5066, 142, 3599, 3603, 143
5067, 3599, 3600, 3604, 3603
5068, 3600, 3601, 3605, 3604
5069, 3601, 3602, 3606, 3605
5070, 3602, 961, 962, 3606
5071, 143, 3603, 3607, 144
5072, 3603, 3604, 3608, 3607
5073, 3604, 3605, 3609, 3608
5074, 3605, 3606, 3610, 3609
5075, 3606, 962, 963, 3610
5076, 144, 3607, 3611, 145
5077, 3607, 3608, 3612, 3611
5078, 3608, 3609, 3613, 3612
5079, 3609, 3610, 3614, 3613
5080, 3610, 963, 964, 3614
5081, 145, 3611, 3615, 146
5082, 3611, 3612, 3616, 3615
5083, 3612, 3613, 3617, 3616
5084, 3613, 3614, 3618, 3617
5085, 3614, 964, 965, 3618
5086, 146, 3615, 942, 5
5087, 3615, 3616, 943, 942
5088, 3616, 3617, 944, 943
5089, 3617, 3618, 945, 944
5090, 3618, 965, 87, 945
*ELEMENT, type=CPS4, ELSET=Surface121
5091, 2, 927, 3619, 97
5092, 927, 928, 3620, 3619
5093, 928, 929, 3621, 3620
5094, 929, 930, 3622, 3621
5095, 930, 86, 966, 3622
5096, 97, 3619, 3623, 98
5097, 3619, 3620, 3624, 3623
5098, 3620, 3621, 3625, 3624
5099, 3621, 3622, 3626, 3625
5100, 3622, 966, 967, 3626
5101, 98, 3623, 3627, 99
5102, 3623, 3624, 3628, 3627
5103, 3624, 3625, 3629, 3628
5104, 3625, 3626, 3630, 3629
5105, 3626, 967, 968, 3630
5106, 99, 3627, 3631, 100
5107, 3627, 3628, 3632, 3631
5108, 3628, 3629, 3633, 3632
5109, 3629, 3630, 3634, 3633
5110, 3630, 968, 969, 3634
5111, 100, 3631, 3635, 101
5112, 3631, 3632, 3636, 3635
5113, 3632, 3633, 3637, 3636
5114, 3633, 3634, 3638, 3637
5115, 3634, 969, 970, 3638
5116, 101, 3635, 951, 1
5117, 3635, 3636, 952, 951
5118, 3636, 3637, 953, 952
5119, 3637, 3638, 954, 953
5120, 3638, 970, 88, 954
*ELEMENT, type=CPS4, ELSET=Surface122
5121, 86, 931, 3639, 966
5122, 966, 3639, 3640, 967
5123, 967, 3640, 3641, 968
5124, 968, 3641, 3642, 969
5125, 969, 3642, 3643, 970
5126, 970, 3643, 955, 88
5127, 931, 932, 3644, 3639
5128, 3639, 3644, 3645, 3640
5129, 3640, 3645, 3646, 3641
5130, 3641, 3646, 3647, 3642
5131, 3642, 3647, 3648, 3643
5132, 3643, 3648, 956, 955
5133, 932, 933, 3649, 3644
5134, 3644, 3649, 3650, 3645
5135, 3645, 3650, 3651, 3646
5136, 3646, 3651, 3652, 3647
5137, 3647, 3652, 3653, 3648
5138, 3648, 3653, 957, 956
5139, 933, 934, 3654, 3649
5140, 3649, 3654, 3655, 3650
5141, 3650, 3655, 3656, 3651
5142, 3651, 3656, 3657, 3652
5143, 3652, 3657, 3658, 3653
5144, 3653, 3658, 958, 957
5145, 934, 935, 3659, 3654
5146, 3654, 3659, 3660, 3655
5147, 3655, 3660, 3661, 3656
5148, 3656, 3661, 3662, 3657
5149, 3657, 3662, 3663, 3658
5150, 3658, 3663, 959, 958
5151, 935, 936, 3664, 3659
5152, 3659, 3664, 3665, 3660
5153, 3660, 3665, 3666, 3661
5154, 3661, 3666, 3667, 3662
5155, 3662, 3667, 3668, 3663
5156, 3663, 3668, 960, 959
5157, 936, 937, 3669, 3664
5158, 3664, 3669, 3670, 3665
5159, 3665, 3670, 3671, 3666
5160, 3666, 3671, 3672, 3667
5161, 3667, 3672, 3673, 3668
5162, 3668, 3673, 961, 960
5163, 937, 938, 3674, 3669
5164, 3669, 3674, 3675, 3670
5165, 3670, 3675, 3676, 3671
5166, 3671, 3676, 3677, 3672
5167, 3672, 3677, 3678, 3673
5168, 3673, 3678, 962, 961
5169, 938, 939, 3679, 3674
5170, 3674, 3679, 3680, 3675
5171, 3675, 3680, 3681, 3676
5172, 3676, 3681, 3682, 3677
5173, 3677, 3682, 3683, 3678
5174, 3678, 3683, 963, 962
5175, 939, 940, 3684, 3679
5176, 3679, 3684, 3685, 3680
5177, 3680, 3685, 3686, 3681
5178, 3681, 3686, 3687, 3682
5179, 3682, 3687, 3688, 3683
5180, 3683, 3688, 964, 963
5181, 940, 941, 3689, 3684
5182, 3684, 3689, 3690, 3685
5183, 3685, 3690, 3691, 3686
5184, 3686, 3691, 3692, 3687
5185, 3687, 3692, 3693, 3688
5186, 3688, 3693, 965, 964
5187, 941, 85, 946, 3689
5188, 3689, 946, 947, 3690
5189, 3690, 947, 948, 3691
5190, 3691, 948, 949, 3692
5191, 3692, 949, 950, 3693
5192, 3693, 950, 87, 965
*ELEMENT, type=CPS4, ELSET=Surface123
5193, 1, 53, 971, 951
5194, 951, 971, 972, 952
5195, 952, 972, 973, 953
5196, 953, 973, 974, 954
5197, 954, 974, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
5198, 2, 927, 975, 54
5199, 927, 928, 976, 975
5200, 928, 929, 977, 976
5201, 929, 930, 978, 977
5202, 930, 86, 90, 978
*ELEMENT, type=CPS4, ELSET=Surface125
5203, 54, 975, 3694, 631
5204, 975, 976, 3695, 3694
5205, 976, 977, 3696, 3695
5206, 977, 978, 3697, 3696
5207, 978, 90, 979, 3697
5208, 631, 3694, 3698, 632
5209, 3694, 3695, 3699, 3698
5210, 3695, 3696, 3700, 3699
5211, 3696, 3697, 3701, 3700
5212, 3697, 979, 980, 3701
5213, 632, 3698, 3702, 633
5214, 3698, 3699, 3703, 3702
5215, 3699, 3700, 3704, 3703
5216, 3700, 3701, 3705, 3704
5217, 3701, 980, 981, 3705
5218, 633, 3702, 3706, 634
5219, 3702, 3703, 3707, 3706
5220, 3703, 3704, 3708, 3707
5221, 3704, 3705, 3709, 3708
5222, 3705, 981, 982, 3709
5223, 634, 3706, 3710, 635
5224, 3706, 3707, 3711, 3710
5225, 3707, 3708, 3712, 3711
5226, 3708, 3709, 3713, 3712
5227, 3709, 982, 983, 3713
5228, 635, 3710, 971, 53
5229, 3710, 3711, 972, 971
5230, 3711, 3712, 973, 972
5231, 3712, 3713, 974, 973
5232, 3713, 983, 89, 974
*ELEMENT, type=CPS4, ELSET=Surface126
5233, 86, 966, 979, 90
5234, 966, 967, 980, 979
5235, 967, 968, 981, 980
5236, 968, 969, 982, 981
5237, 969, 970, 983, 982
5238, 970, 88, 89, 983
*ELEMENT, type=CPS4, ELSET=Surface127
5239, 45, 984, 3714, 581
5240, 984, 985, 3715, 3714
5241, 985, 986, 3716, 3715
5242, 986, 987, 3717, 3716
5243, 987, 91, 992, 3717
5244, 581, 3714, 3718, 582
5245, 3714, 3715, 3719, 3718
5246, 3715, 3716, 3720, 3719
5247, 3716, 3717, 3721, 3720
5248, 3717, 992, 993, 3721
5249, 582, 3718, 3722, 583
5250, 3718, 3719, 3723, 3722
5251, 3719, 3720, 3724, 3723
5252, 3720, 3721, 3725, 3724
5253, 3721, 993, 994, 3725
5254, 583, 3722, 3726, 584
5255, 3722, 3723, 3727, 3726
5256, 3723, 3724, 3728, 3727
5257, 3724, 3725, 3729, 3728
5258, 3725, 994, 995, 3729
5259, 584, 3726, 3730, 585
5260, 3726, 3727, 3731, 3730
5261, 3727, 3728, 3732, 3731
5262, 3728, 3729, 3733, 3732
5263, 3729, 995, 996, 3733
5264, 585, 3730, 3734, 586
5265, 3730, 3731, 3735, 3734
5266, 3731, 3732, 3736, 3735
5267, 3732, 3733, 3737, 3736
5268, 3733, 996, 997, 3737
5269, 586, 3734, 3738, 587
5270, 3734, 3735, 3739, 3738
5271, 3735, 3736, 3740, 3739
5272, 3736, 3737, 3741, 3740
5273, 3737, 997, 998, 3741
5274, 587, 3738, 3742, 588
5275, 3738, 3739, 3743, 3742
5276, 3739, 3740, 3744, 3743
5277, 3740, 3741, 3745, 3744
5278, 3741, 998, 999, 3745
5279, 588, 3742, 3746, 589
5280, 3742, 3743, 3747, 3746
5281, 3743, 3744, 3748, 3747
5282, 3744, 3745, 3749, 3748
5283, 3745, 999, 1000, 3749
5284, 589, 3746, 3750, 590
5285, 3746, 3747, 3751, 3750
5286, 3747, 3748, 3752, 3751
5287, 3748, 3749, 3753, 3752
5288, 3749, 1000, 1001, 3753
5289, 590, 3750, 3754, 591
5290, 3750, 3751, 3755, 3754
5291, 3751, 3752, 3756, 3755
5292, 3752, 3753, 3757, 3756
5293, 3753, 1001, 1002, 3757
5294, 591, 3754, 988, 46
5295, 3754, 3755, 989, 988
5296, 3755, 3756, 990, 989
5297, 3756, 3757, 991, 990
5298, 3757, 1002, 92, 991
*ELEMENT, type=CPS4, ELSET=Surface128
5299, 47, 596, 3758, 1003
5300, 1003, 3758, 3759, 1004
5301, 1004, 3759, 3760, 1005
5302, 1005, 3760, 3761, 1006
5303, 1006, 3761, 1011, 93
5304, 596, 597, 3762, 3758
5305, 3758, 3762, 3763, 3759
5306, 3759, 3763, 3764, 3760
5307, 3760, 3764, 3765, 3761
5308, 3761, 3765, 1012, 1011
5309, 597, 598, 3766, 3762
5310, 3762, 3766, 3767, 3763
5311, 3763, 3767, 3768, 3764
5312, 3764, 3768, 3769, 3765
5313, 3765, 3769, 1013, 1012
5314, 598, 599, 3770, 3766
5315, 3766, 3770, 3771, 3767
5316, 3767, 3771, 3772, 3768
5317, 3768, 3772, 3773, 3769
5318, 3769, 3773, 1014, 1013
5319, 599, 600, 3774, 3770
5320, 3770, 3774, 3775, 3771
5321, 3771, 3775, 3776, 3772
5322, 3772, 3776, 3777, 3773
5323, 3773, 3777, 1015, 1014
5324, 600, 601, 3778, 3774
5325, 3774, 3778, 3779, 3775
5326, 3775, 3779, 3780, 3776
5327, 3776, 3780, 3781, 3777
5328, 3777, 3781, 1016, 1015
5329, 601, 602, 3782, 3778
5330, 3778, 3782, 3783, 3779
5331, 3779, 3783, 3784, 3780
5332, 3780, 3784, 3785, 3781
5333, 3781, 3785, 1017, 1016
5334, 602, 603, 3786, 3782
5335, 3782, 3786, 3787, 3783
5336, 3783, 3787, 3788, 3784
5337, 3784, 3788, 3789, 3785
5338, 3785, 3789, 1018, 1017
5339, 603, 604, 3790, 3786
5340, 3786, 3790, 3791, 3787
5341, 3787, 3791, 3792, 3788
5342, 3788, 3792, 3793, 3789
5343, 3789, 3793, 1019, 1018
5344, 604, 605, 3794, 3790
5345, 3790, 3794, 3795, 3791
5346, 3791, 3795, 3796, 3792
5347, 3792, 3796, 3797, 3793
5348, 3793, 3797, 1020, 1019
5349, 605, 606, 3798, 3794
5350, 3794, 3798, 3799, 3795
5351, 3795, 3799, 3800, 3796
5352, 3796, 3800, 3801, 3797
5353, 3797, 3801, 1021, 1020
5354, 606, 48, 1007, 3798
5355, 3798, 1007, 1008, 3799
5356, 3799, 1008, 1009, 3800
5357, 3800, 1009, 1010, 3801
5358, 3801, 1010, 94, 1021
*ELEMENT, type=CPS4, ELSET=Surface129
5359, 47, 1003, 3802, 607
5360, 1003, 1004, 3803, 3802
5361, 1004, 1005, 3804, 3803
5362, 1005, 1006, 3805, 3804
5363, 1006, 93, 1022, 3805
5364, 607, 3802, 3806, 608
5365, 3802, 3803, 3807, 3806
5366, 3803, 3804, 3808, 3807
5367, 3804, 3805, 3809, 3808
5368, 3805, 1022, 1023, 3809
5369, 608, 3806, 3810, 609
5370, 3806, 3807, 3811, 3810
5371, 3807, 3808, 3812, 3811
5372, 3808, 3809, 3813, 3812
5373, 3809, 1023, 1024, 3813
5374, 609, 3810, 3814, 610
5375, 3810, 3811, 3815, 3814
5376, 3811, 3812, 3816, 3815
5377, 3812, 3813, 3817, 3816
5378, 3813, 1024, 1025, 3817
5379, 610, 3814, 3818, 611
5380, 3814, 3815, 3819, 3818
5381, 3815, 3816, 3820, 3819
5382, 3816, 3817, 3821, 3820
5383, 3817, 1025, 1026, 3821
5384, 611, 3818, 984, 45
5385, 3818, 3819, 985, 984
5386, 3819, 3820, 986, 985
5387, 3820, 3821, 987, 986
5388, 3821, 1026, 91, 987
*ELEMENT, type=CPS4, ELSET=Surface130
5389, 48, 612, 3822, 1007
5390, 1007, 3822, 3823, 1008
5391, 1008, 3823, 3824, 1009
5392, 1009, 3824, 3825, 1010
5393, 1010, 3825, 1027, 94
5394, 612, 613, 3826, 3822
5395, 3822, 3826, 3827, 3823
5396, 3823, 3827, 3828, 3824
5397, 3824, 3828, 3829, 3825
5398, 3825, 3829, 1028, 1027
5399, 613, 614, 3830, 3826
5400, 3826, 3830, 3831, 3827
5401, 3827, 3831, 3832, 3828
5402, 3828, 3832, 3833, 3829
5403, 3829, 3833, 1029, 1028
5404, 614, 615, 3834, 3830
5405, 3830, 3834, 3835, 3831
5406, 3831, 3835, 3836, 3832
5407, 3832, 3836, 3837, 3833
5408, 3833, 3837, 1030, 1029
5409, 615, 616, 3838, 3834
5410, 3834, 3838, 3839, 3835
5411, 3835, 3839, 3840, 3836
5412, 3836, 3840, 3841, 3837
5413, 3837, 3841, 1031, 1030
5414, 616, 46, 988, 3838
5415, 3838, 988, 989, 3839
5416, 3839, 989, 990, 3840
5417, 3840, 990, 991, 3841
5418, 3841, 991, 92, 1031
*ELEMENT, type=CPS4, ELSET=Surface131
5419, 93, 1011, 3842, 1022
5420, 1011, 1012, 3843, 3842
5421, 1012, 1013, 3844, 3843
5422, 1013, 1014, 3845, 3844
5423, 1014, 1015, 3846, 3845
5424, 1015, 1016, 3847, 3846
5425, 1016, 1017, 3848, 3847
5426, 1017, 1018, 3849, 3848
5427, 1018, 1019, 3850, 3849
5428, 1019, 1020, 3851, 3850
5429, 1020, 1021, 3852, 3851
5430, 1021, 94, 1027, 3852
5431, 1022, 3842, 3853, 1023
5432, 3842, 3843, 3854, 3853
5433, 3843, 3844, 3855, 3854
5434, 3844, 3845, 3856, 3855
5435, 3845, 3846, 3857, 3856
5436, 3846, 3847, 3858, 3857
5437, 3847, 3848, 3859, 3858
5438, 3848, 3849, 3860, 3859
5439, 3849, 3850, 3861, 3860
5440, 3850, 3851, 3862, 3861
5441, 3851, 3852, 3863, 3862
5442, 3852, 1027, 1028, 3863
5443, 1023, 3853, 3864, 1024
5444, 3853, 3854, 3865, 3864
5445, 3854, 3855, 3866, 3865
5446, 3855, 3856, 3867, 3866
5447, 3856, 3857, 3868, 3867
5448, 3857, 3858, 3869, 3868
5449, 3858, 3859, 3870, 3869
5450, 3859, 3860, 3871, 3870
5451, 3860, 3861, 3872, 3871
5452, 3861, 3862, 3873, 3872
5453, 3862, 3863, 3874, 3873
5454, 3863, 1028, 1029, 3874
5455, 1024, 3864, 3875, 1025
5456, 3864, 3865, 3876, 3875
5457, 3865, 3866, 3877, 3876
5458, 3866, 3867, 3878, 3877
5459, 3867, 3868, 3879, 3878
5460, 3868, 3869, 3880, 3879
5461, 3869, 3870, 3881, 3880
5462, 3870, 3871, 3882, 3881
5463, 3871, 3872, 3883, 3882
5464, 3872, 3873, 3884, 3883
5465, 3873, 3874, 3885, 3884
5466, 3874, 1029, 1030, 3885
5467, 1025, 3875, 3886, 1026
5468, 3875, 3876, 3887, 3886
5469, 3876, 3877, 3888, 3887
5470, 3877, 3878, 3889, 3888
5471, 3878, 3879, 3890, 3889
5472, 3879, 3880, 3891, 3890
5473, 3880, 3881, 3892, 3891
5474, 3881, 3882, 3893, 3892
5475, 3882, 3883, 3894, 3893
5476, 3883, 3884, 3895, 3894
5477, 3884, 3885, 3896, 3895
5478, 3885, 1030, 1031, 3896
5479, 1026, 3886, 992, 91
5480, 3886, 3887, 993, 992
5481, 3887, 3888, 994, 993
5482, 3888, 3889, 995, 994
5483, 3889, 3890, 996, 995
5484, 3890, 3891, 997, 996
5485, 3891, 3892, 998, 997
5486, 3892, 3893, 999, 998
5487, 3893, 3894, 1000, 999
5488, 3894, 3895, 1001, 1000
5489, 3895, 3896, 1002, 1001
5490, 3896, 1031, 92, 1002
*ELEMENT, type=CPS4, ELSET=Surface132
5491, 46, 988, 1032, 50
5492, 988, 989, 1033, 1032
5493, 989, 990, 1034, 1033
5494, 990, 991, 1035, 1034
5495, 991, 92, 95, 1035
*ELEMENT, type=CPS4, ELSET=Surface133
5496, 48, 52, 1036, 1007
5497, 1007, 1036, 1037, 1008
5498, 1008, 1037, 1038, 1009
5499, 1009, 1038, 1039, 1010
5500, 1010, 1039, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
5501, 52, 626, 3897, 1036
5502, 1036, 3897, 3898, 1037
5503, 1037, 3898, 3899, 1038
5504, 1038, 3899, 3900, 1039
5505, 1039, 3900, 1040, 96
5506, 626, 627, 3901, 3897
5507, 3897, 3901, 3902, 3898
5508, 3898, 3902, 3903, 3899
5509, 3899, 3903, 3904, 3900
5510, 3900, 3904, 1041, 1040
5511, 627, 628, 3905, 3901
5512, 3901, 3905, 3906, 3902
5513, 3902, 3906, 3907, 3903
5514, 3903, 3907, 3908, 3904
5515, 3904, 3908, 1042, 1041
5516, 628, 629, 3909, 3905
5517, 3905, 3909, 3910, 3906
5518, 3906, 3910, 3911, 3907
5519, 3907, 3911, 3912, 3908
5520, 3908, 3912, 1043, 1042
5521, 629, 630, 3913, 3909
5522, 3909, 3913, 3914, 3910
5523, 3910, 3914, 3915, 3911
5524, 3911, 3915, 3916, 3912
5525, 3912, 3916, 1044, 1043
5526, 630, 50, 1032, 3913
5527, 3913, 1032, 1033, 3914
5528, 3914, 1033, 1034, 3915
5529, 3915, 1034, 1035, 3916
5530, 3916, 1035, 95, 1044
*ELEMENT, type=CPS4, ELSET=Surface135
5531, 94, 96, 1040, 1027
5532, 1027, 1040, 1041, 1028
5533, 1028, 1041, 1042, 1029
5534, 1029, 1042, 1043, 1030
5535, 1030, 1043, 1044, 1031
5536, 1031, 1044, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
5537, 1045, 97, 2, 109, 3917, 1065, 125, 1175
5538, 3917, 1065, 125, 1175, 3918, 1070, 126, 1176
5539, 3918, 1070, 126, 1176, 3919, 1075, 127, 1177
5540, 3919, 1075, 127, 1177, 3920, 1080, 128, 1178
5541, 3920, 1080, 128, 1178, 3921, 1085, 129, 1179
5542, 3921, 1085, 129, 1179, 3922, 1090, 130, 1180
5543, 3922, 1090, 130, 1180, 3923, 1095, 131, 1181
5544, 3923, 1095, 131, 1181, 3924, 1100, 132, 1182
5545, 3924, 1100, 132, 1182, 3925, 1105, 133, 1183
5546, 3925, 1105, 133, 1183, 3926, 1110, 134, 1184
5547, 3926, 1110, 134, 1184, 3927, 1115, 135, 1185
5548, 3927, 1115, 135, 1185, 1055, 111, 6, 123
5549, 1046, 1045, 109, 110, 3928, 3917, 1175, 1186
5550, 3928, 3917, 1175, 1186, 3929, 3918, 1176, 1187
5551, 3929, 3918, 1176, 1187, 3930, 3919, 1177, 1188
5552, 3930, 3919, 1177, 1188, 3931, 3920, 1178, 1189
5553, 3931, 3920, 1178, 1189, 3932, 3921, 1179, 1190
5554, 3932, 3921, 1179, 1190, 3933, 3922, 1180, 1191
5555, 3933, 3922, 1180, 1191, 3934, 3923, 1181, 1192
5556, 3934, 3923, 1181, 1192, 3935, 3924, 1182, 1193
5557, 3935, 3924, 1182, 1193, 3936, 3925, 1183, 1194
5558, 3936, 3925, 1183, 1194, 3937, 3926, 1184, 1195
5559, 3937, 3926, 1184, 1195, 3938, 3927, 1185, 1196
5560, 3938, 3927, 1185, 1196, 1056, 1055, 123, 124
5561, 104, 1046, 110, 4, 1120, 3928, 1186, 147
5562, 1120, 3928, 1186, 147, 1125, 3929, 1187, 148
5563, 1125, 3929, 1187, 148, 1130, 3930, 1188, 149
5564, 1130, 3930, 1188, 149, 1135, 3931, 1189, 150
5565, 1135, 3931, 1189, 150, 1140, 3932, 1190, 151
5566, 1140, 3932, 1190, 151, 1145, 3933, 1191, 152
5567, 1145, 3933, 1191, 152, 1150, 3934, 1192, 153
5568, 1150, 3934, 1192, 153, 1155, 3935, 1193, 154
5569, 1155, 3935, 1193, 154, 1160, 3936, 1194, 155
5570, 1160, 3936, 1194, 155, 1165, 3937, 1195, 156
5571, 1165, 3937, 1195, 156, 1170, 3938, 1196, 157
5572, 1170, 3938, 1196, 157, 118, 1056, 124, 8
5573, 1047, 98, 97, 1045, 3939, 1066, 1065, 3917
5574, 3939, 1066, 1065, 3917, 3940, 1071, 1070, 3918
5575, 3940, 1071, 1070, 3918, 3941, 1076, 1075, 3919
5576, 3941, 1076, 1075, 3919, 3942, 1081, 1080, 3920
5577, 3942, 1081, 1080, 3920, 3943, 1086, 1085, 3921
5578, 3943, 1086, 1085, 3921, 3944, 1091, 1090, 3922
5579, 3944, 1091, 1090, 3922, 3945, 1096, 1095, 3923
5580, 3945, 1096, 1095, 3923, 3946, 1101, 1100, 3924
5581, 3946, 1101, 1100, 3924, 3947, 1106, 1105, 3925
5582, 3947, 1106, 1105, 3925, 3948, 1111, 1110, 3926
5583, 3948, 1111, 1110, 3926, 3949, 1116, 1115, 3927
5584, 3949, 1116, 1115, 3927, 1057, 112, 111, 1055
5585, 1048, 1047, 1045, 1046, 3950, 3939, 3917, 3928
5586, 3950, 3939, 3917, 3928, 3951, 3940, 3918, 3929
5587, 3951, 3940, 3918, 3929, 3952, 3941, 3919, 3930
5588, 3952, 3941, 3919, 3930, 3953, 3942, 3920, 3931
5589, 3953, 3942, 3920, 3931, 3954, 3943, 3921, 3932
5590, 3954, 3943, 3921, 3932, 3955, 3944, 3922, 3933
5591, 3955, 3944, 3922, 3933, 3956, 3945, 3923, 3934
5592, 3956, 3945, 3923, 3934, 3957, 3946, 3924, 3935
5593, 3957, 3946, 3924, 3935, 3958, 3947, 3925, 3936
5594, 3958, 3947, 3925, 3936, 3959, 3948, 3926, 3937
5595, 3959, 3948, 3926, 3937, 3960, 3949, 3927, 3938
5596, 3960, 3949, 3927, 3938, 1058, 1057, 1055, 1056
5597, 105, 1048, 1046, 104, 1121, 3950, 3928, 1120
5598, 1121, 3950, 3928, 1120, 1126, 3951, 3929, 1125
5599, 1126, 3951, 3929, 1125, 1131, 3952, 3930, 1130
5600, 1131, 3952, 3930, 1130, 1136, 3953, 3931, 1135
5601, 1136, 3953, 3931, 1135, 1141, 3954, 3932, 1140
5602, 1141, 3954, 3932, 1140, 1146, 3955, 3933, 1145
5603, 1146, 3955, 3933, 1145, 1151, 3956, 3934, 1150
5604, 1151, 3956, 3934, 1150, 1156, 3957, 3935, 1155
5605, 1156, 3957, 3935, 1155, 1161, 3958, 3936, 1160
5606, 1161, 3958, 3936, 1160, 1166, 3959, 3937, 1165
5607, 1166, 3959, 3937, 1165, 1171, 3960, 3938, 1170
5608, 1171, 3960, 3938, 1170, 119, 1058, 1056, 118
5609, 1049, 99, 98, 1047, 3961, 1067, 1066, 3939
5610, 3961, 1067, 1066, 3939, 3962, 1072, 1071, 3940
5611, 3962, 1072, 1071, 3940, 3963, 1077, 1076, 3941
5612, 3963, 1077, 1076, 3941, 3964, 1082, 1081, 3942
5613, 3964, 1082, 1081, 3942, 3965, 1087, 1086, 3943
5614, 3965, 1087, 1086, 3943, 3966, 1092, 1091, 3944
5615, 3966, 1092, 1091, 3944, 3967, 1097, 1096, 3945
5616, 3967, 1097, 1096, 3945, 3968, 1102, 1101, 3946
5617, 3968, 1102, 1101, 3946, 3969, 1107, 1106, 3947
5618, 3969, 1107, 1106, 3947, 3970, 1112, 1111, 3948
5619, 3970, 1112, 1111, 3948, 3971, 1117, 1116, 3949
5620, 3971, 1117, 1116, 3949, 1059, 113, 112, 1057
5621, 1050, 1049, 1047, 1048, 3972, 3961, 3939, 3950
5622, 3972, 3961, 3939, 3950, 3973, 3962, 3940, 3951
5623, 3973, 3962, 3940, 3951, 3974, 3963, 3941, 3952
5624, 3974, 3963, 3941, 3952, 3975, 3964, 3942, 3953
5625, 3975, 3964, 3942, 3953, 3976, 3965, 3943, 3954
5626, 3976, 3965, 3943, 3954, 3977, 3966, 3944, 3955
5627, 3977, 3966, 3944, 3955, 3978, 3967, 3945, 3956
5628, 3978, 3967, 3945, 3956, 3979, 3968, 3946, 3957
5629, 3979, 3968, 3946, 3957, 3980, 3969, 3947, 3958
5630, 3980, 3969, 3947, 3958, 3981, 3970, 3948, 3959
5631, 3981, 3970, 3948, 3959, 3982, 3971, 3949, 3960
5632, 3982, 3971, 3949, 3960, 1060, 1059, 1057, 1058
5633, 106, 1050, 1048, 105, 1122, 3972, 3950, 1121
5634, 1122, 3972, 3950, 1121, 1127, 3973, 3951, 1126
5635, 1127, 3973, 3951, 1126, 1132, 3974, 3952, 1131
5636, 1132, 3974, 3952, 1131, 1137, 3975, 3953, 1136
5637, 1137, 3975, 3953, 1136, 1142, 3976, 3954, 1141
5638, 1142, 3976, 3954, 1141, 1147, 3977, 3955, 1146
5639, 1147, 3977, 3955, 1146, 1152, 3978, 3956, 1151
5640, 1152, 3978, 3956, 1151, 1157, 3979, 3957, 1156
5641, 1157, 3979, 3957, 1156, 1162, 3980, 3958, 1161
5642, 1162, 3980, 3958, 1161, 1167, 3981, 3959, 1166
5643, 1167, 3981, 3959, 1166, 1172, 3982, 3960, 1171
5644, 1172, 3982, 3960, 1171, 120, 1060, 1058, 119
5645, 1051, 100, 99, 1049, 3983, 1068, 1067, 3961
5646, 3983, 1068, 1067, 3961, 3984, 1073, 1072, 3962
5647, 3984, 1073, 1072, 3962, 3985, 1078, 1077, 3963
5648, 3985, 1078, 1077, 3963, 3986, 1083, 1082, 3964
5649, 3986, 1083, 1082, 3964, 3987, 1088, 1087, 3965
5650, 3987, 1088, 1087, 3965, 3988, 1093, 1092, 3966
5651, 3988, 1093, 1092, 3966, 3989, 1098, 1097, 3967
5652, 3989, 1098, 1097, 3967, 3990, 1103, 1102, 3968
5653, 3990, 1103, 1102, 3968, 3991, 1108, 1107, 3969
5654, 3991, 1108, 1107, 3969, 3992, 1113, 1112, 3970
5655, 3992, 1113, 1112, 3970, 3993, 1118, 1117, 3971
5656, 3993, 1118, 1117, 3971, 1061, 114, 113, 1059
5657, 1052, 1051, 1049, 1050, 3994, 3983, 3961, 3972
5658, 3994, 3983, 3961, 3972, 3995, 3984, 3962, 3973
5659, 3995, 3984, 3962, 3973, 3996, 3985, 3963, 3974
5660, 3996, 3985, 3963, 3974, 3997, 3986, 3964, 3975
5661, 3997, 3986, 3964, 3975, 3998, 3987, 3965, 3976
5662, 3998, 3987, 3965, 3976, 3999, 3988, 3966, 3977
5663, 3999, 3988, 3966, 3977, 4000, 3989, 3967, 3978
5664, 4000, 3989, 3967, 3978, 4001, 3990, 3968, 3979
5665, 4001, 3990, 3968, 3979, 4002, 3991, 3969, 3980
5666, 4002, 3991, 3969, 3980, 4003, 3992, 3970, 3981
5667, 4003, 3992, 3970, 3981, 4004, 3993, 3971, 3982
5668, 4004, 3993, 3971, 3982, 1062, 1061, 1059, 1060
5669, 107, 1052, 1050, 106, 1123, 3994, 3972, 1122
5670, 1123, 3994, 3972, 1122, 1128, 3995, 3973, 1127
5671, 1128, 3995, 3973, 1127, 1133, 3996, 3974, 1132
5672, 1133, 3996, 3974, 1132, 1138, 3997, 3975, 1137
5673, 1138, 3997, 3975, 1137, 1143, 3998, 3976, 1142
5674, 1143, 3998, 3976, 1142, 1148, 3999, 3977, 1147
5675, 1148, 3999, 3977, 1147, 1153, 4000, 3978, 1152
5676, 1153, 4000, 3978, 1152, 1158, 4001, 3979, 1157
5677, 1158, 4001, 3979, 1157, 1163, 4002, 3980, 1162
5678, 1163, 4002, 3980, 1162, 1168, 4003, 3981, 1167
5679, 1168, 4003, 3981, 1167, 1173, 4004, 3982, 1172
5680, 1173, 4004, 3982, 1172, 121, 1062, 1060, 120
5681, 1053, 101, 100, 1051, 4005, 1069, 1068, 3983
5682, 4005, 1069, 1068, 3983, 4006, 1074, 1073, 3984
5683, 4006, 1074, 1073, 3984, 4007, 1079, 1078, 3985
5684, 4007, 1079, 1078, 3985, 4008, 1084, 1083, 3986
5685, 4008, 1084, 1083, 3986, 4009, 1089, 1088, 3987
5686, 4009, 1089, 1088, 3987, 4010, 1094, 1093, 3988
5687, 4010, 1094, 1093, 3988, 4011, 1099, 1098, 3989
5688, 4011, 1099, 1098, 3989, 4012, 1104, 1103, 3990
5689, 4012, 1104, 1103, 3990, 4013, 1109, 1108, 3991
5690, 4013, 1109, 1108, 3991, 4014, 1114, 1113, 3992
5691, 4014, 1114, 1113, 3992, 4015, 1119, 1118, 3993
5692, 4015, 1119, 1118, 3993, 1063, 115, 114, 1061
5693, 1054, 1053, 1051, 1052, 4016, 4005, 3983, 3994
5694, 4016, 4005, 3983, 3994, 4017, 4006, 3984, 3995
5695, 4017, 4006, 3984, 3995, 4018, 4007, 3985, 3996
5696, 4018, 4007, 3985, 3996, 4019, 4008, 3986, 3997
5697, 4019, 4008, 3986, 3997, 4020, 4009, 3987, 3998
5698, 4020, 4009, 3987, 3998, 4021, 4010, 3988, 3999
5699, 4021, 4010, 3988, 3999, 4022, 4011, 3989, 4000
5700, 4022, 4011, 3989, 4000, 4023, 4012, 3990, 4001
5701, 4023, 4012, 3990, 4001, 4024, 4013, 3991, 4002
5702, 4024, 4013, 3991, 4002, 4025, 4014, 3992, 4003
5703, 4025, 4014, 3992, 4003, 4026, 4015, 3993, 4004
5704, 4026, 4015, 3993, 4004, 1064, 1063, 1061, 1062
5705, 108, 1054, 1052, 107, 1124, 4016, 3994, 1123
5706, 1124, 4016, 3994, 1123, 1129, 4017, 3995, 1128
5707, 1129, 4017, 3995, 1128, 1134, 4018, 3996, 1133
5708, 1134, 4018, 3996, 1133, 1139, 4019, 3997, 1138
5709, 1139, 4019, 3997, 1138, 1144, 4020, 3998, 1143
5710, 1144, 4020, 3998, 1143, 1149, 4021, 3999, 1148
5711, 1149, 4021, 3999, 1148, 1154, 4022, 4000, 1153
5712, 1154, 4022, 4000, 1153, 1159, 4023, 4001, 1158
5713, 1159, 4023, 4001, 1158, 1164, 4024, 4002, 1163
5714, 1164, 4024, 4002, 1163, 1169, 4025, 4003, 1168
5715, 1169, 4025, 4003, 1168, 1174, 4026, 4004, 1173
5716, 1174, 4026, 4004, 1173, 122, 1064, 1062, 121
5717, 102, 1, 101, 1053, 1197, 136, 1069, 4005
5718, 1197, 136, 1069, 4005, 1198, 137, 1074, 4006
5719, 1198, 137, 1074, 4006, 1199, 138, 1079, 4007
5720, 1199, 138, 1079, 4007, 1200, 139, 1084, 4008
5721, 1200, 139, 1084, 4008, 1201, 140, 1089, 4009
5722, 1201, 140, 1089, 4009, 1202, 141, 1094, 4010
5723, 1202, 141, 1094, 4010, 1203, 142, 1099, 4011
5724, 1203, 142, 1099, 4011, 1204, 143, 1104, 4012
5725, 1204, 143, 1104, 4012, 1205, 144, 1109, 4013
5726, 1205, 144, 1109, 4013, 1206, 145, 1114, 4014
5727, 1206, 145, 1114, 4014, 1207, 146, 1119, 4015
5728, 1207, 146, 1119, 4015, 116, 5, 115, 1063
5729, 103, 102, 1053, 1054, 1208, 1197, 4005, 4016
5730, 1208, 1197, 4005, 4016, 1209, 1198, 4006, 4017
5731, 1209, 1198, 4006, 4017, 1210, 1199, 4007, 4018
5732, 1210, 1199, 4007, 4018, 1211, 1200, 4008, 4019
5733, 1211, 1200, 4008, 4019, 1212, 1201, 4009, 4020
5734, 1212, 1201, 4009, 4020, 1213, 1202, 4010, 4021
5735, 1213, 1202, 4010, 4021, 1214, 1203, 4011, 4022
5736, 1214, 1203, 4011, 4022, 1215, 1204, 4012, 4023
5737, 1215, 1204, 4012, 4023, 1216, 1205, 4013, 4024
5738, 1216, 1205, 4013, 4024, 1217, 1206, 4014, 4025
5739, 1217, 1206, 4014, 4025, 1218, 1207, 4015, 4026
5740, 1218, 1207, 4015, 4026, 117, 116, 1063, 1064
5741, 3, 103, 1054, 108, 158, 1208, 4016, 1124
5742, 158, 1208, 4016, 1124, 159, 1209, 4017, 1129
5743, 159, 1209, 4017, 1129, 160, 1210, 4018, 1134
5744, 160, 1210, 4018, 1134, 161, 1211, 4019, 1139
5745, 161, 1211, 4019, 1139, 162, 1212, 4020, 1144
5746, 162, 1212, 4020, 1144, 163, 1213, 4021, 1149
5747, 163, 1213, 4021, 1149, 164, 1214, 4022, 1154
5748, 164, 1214, 4022, 1154, 165, 1215, 4023, 1159
5749, 165, 1215, 4023, 1159, 166, 1216, 4024, 1164
5750, 166, 1216, 4024, 1164, 167, 1217, 4025, 1169
5751, 167, 1217, 4025, 1169, 168, 1218, 4026, 1174
5752, 168, 1218, 4026, 1174, 7, 117, 1064, 122
*ELEMENT, type=C3D8, ELSET=Volume2
5753, 4, 104, 1120, 147, 10, 196, 1219, 169
5754, 104, 105, 1121, 1120, 196, 197, 1220, 1219
5755, 105, 106, 1122, 1121, 197, 198, 1221, 1220
5756, 106, 107, 1123, 1122, 198, 199, 1222, 1221
5757, 107, 108, 1124, 1123, 199, 200, 1223, 1222
5758, 108, 3, 158, 1124, 200, 12, 185, 1223
5759, 147, 1120, 1125, 148, 169, 1219, 1224, 170
5760, 1120, 1121, 1126, 1125, 1219, 1220, 1225, 1224
5761, 1121, 1122, 1127, 1126, 1220, 1221, 1226, 1225
5762, 1122, 1123, 1128, 1127, 1221, 1222, 1227, 1226
5763, 1123, 1124, 1129, 1128, 1222, 1223, 1228, 1227
5764, 1124, 158, 159, 1129, 1223, 185, 186, 1228
5765, 148, 1125, 1130, 149, 170, 1224, 1229, 171
5766, 1125, 1126, 1131, 1130, 1224, 1225, 1230, 1229
5767, 1126, 1127, 1132, 1131, 1225, 1226, 1231, 1230
5768, 1127, 1128, 1133, 1132, 1226, 1227, 1232, 1231
5769, 1128, 1129, 1134, 1133, 1227, 1228, 1233, 1232
5770, 1129, 159, 160, 1134, 1228, 186, 187, 1233
5771, 149, 1130, 1135, 150, 171, 1229, 1234, 172
5772, 1130, 1131, 1136, 1135, 1229, 1230, 1235, 1234
5773, 1131, 1132, 1137, 1136, 1230, 1231, 1236, 1235
5774, 1132, 1133, 1138, 1137, 1231, 1232, 1237, 1236
5775, 1133, 1134, 1139, 1138, 1232, 1233, 1238, 1237
5776, 1134, 160, 161, 1139, 1233, 187, 188, 1238
5777, 150, 1135, 1140, 151, 172, 1234, 1239, 173
5778, 1135, 1136, 1141, 1140, 1234, 1235, 1240, 1239
5779, 1136, 1137, 1142, 1141, 1235, 1236, 1241, 1240
5780, 1137, 1138, 1143, 1142, 1236, 1237, 1242, 1241
5781, 1138, 1139, 1144, 1143, 1237, 1238, 1243, 1242
5782, 1139, 161, 162, 1144, 1238, 188, 189, 1243
5783, 151, 1140, 1145, 152, 173, 1239, 1244, 174
5784, 1140, 1141, 1146, 1145, 1239, 1240, 1245, 1244
5785, 1141, 1142, 1147, 1146, 1240, 1241, 1246, 1245
5786, 1142, 1143, 1148, 1147, 1241, 1242, 1247, 1246
5787, 1143, 1144, 1149, 1148, 1242, 1243, 1248, 1247
5788, 1144, 162, 163, 1149, 1243, 189, 190, 1248
