9604, 2026, 2037, 2038, 2027, 5931, 5975, 5979, 5935
9605, 5931, 5975, 5979, 5935, 5932, 5976, 5980, 5936
9606, 5932, 5976, 5980, 5936, 5933, 5977, 5981, 5937
9607, 5933, 5977, 5981, 5937, 5934, 5978, 5982, 5938
9608, 5934, 5978, 5982, 5938, 3462, 3473, 3474, 3463
9609, 2027, 2038, 2039, 2028, 5935, 5979, 5983, 5939
9610, 5935, 5979, 5983, 5939, 5936, 5980, 5984, 5940
9611, 5936, 5980, 5984, 5940, 5937, 5981, 5985, 5941
9612, 5937, 5981, 5985, 5941, 5938, 5982, 5986, 5942
9613, 5938, 5982, 5986, 5942, 3463, 3474, 3475, 3464
9614, 2028, 2039, 2040, 2029, 5939, 5983, 5987, 5943
9615, 5939, 5983, 5987, 5943, 5940, 5984, 5988, 5944
9616, 5940, 5984, 5988, 5944, 5941, 5985, 5989, 5945
9617, 5941, 5985, 5989, 5945, 5942, 5986, 5990, 5946
9618, 5942, 5986, 5990, 5946, 3464, 3475, 3476, 3465
9619, 2029, 2040, 2041, 2030, 5943, 5987, 5991, 5947
9620, 5943, 5987, 5991, 5947, 5944, 5988, 5992, 5948
9621, 5944, 5988, 5992, 5948, 5945, 5989, 5993, 5949
9622, 5945, 5989, 5993, 5949, 5946, 5990, 5994, 5950
9623, 5946, 5990, 5994, 5950, 3465, 3476, 3477, 3466
9624, 2030, 2041, 433, 432, 5947, 5991, 3440, 3436
9625, 5947, 5991, 3440, 3436, 5948, 5992, 3441, 3437
9626, 5948, 5992, 3441, 3437, 5949, 5993, 3442, 3438
9627, 5949, 5993, 3442, 3438, 5950, 5994, 3443, 3439
9628, 5950, 5994, 3443, 3439, 3466, 3477, 919, 918
9629, 375, 376, 2042, 2031, 3312, 3316, 5995, 5951
9630, 3312, 3316, 5995, 5951, 3313, 3317, 5996, 5952
9631, 3313, 3317, 5996, 5952, 3314, 3318, 5997, 5953
9632, 3314, 3318, 5997, 5953, 3315, 3319, 5998, 5954
9633, 3315, 3319, 5998, 5954, 884, 885, 3478, 3467
9634, 2031, 2042, 2043, 2032, 5951, 5995, 5999, 5955
9635, 5951, 5995, 5999, 5955, 5952, 5996, 6000, 5956
9636, 5952, 5996, 6000, 5956, 5953, 5997, 6001, 5957
9637, 5953, 5997, 6001, 5957, 5954, 5998, 6002, 5958
9638, 5954, 5998, 6002, 5958, 3467, 3478, 3479, 3468
9639, 2032, 2043, 2044, 2033, 5955, 5999, 6003, 5959
9640, 5955, 5999, 6003, 5959, 5956, 6000, 6004, 5960
9641, 5956, 6000, 6004, 5960, 5957, 6001, 6005, 5961
9642, 5957, 6001, 6005, 5961, 5958, 6002, 6006, 5962
9643, 5958, 6002, 6006, 5962, 3468, 3479, 3480, 3469
9644, 2033, 2044, 2045, 2034, 5959, 6003, 6007, 5963
9645, 5959, 6003, 6007, 5963, 5960, 6004, 6008, 5964
9646, 5960, 6004, 6008, 5964, 5961, 6005, 6009, 5965
9647, 5961, 6005, 6009, 5965, 5962, 6006, 6010, 5966
9648, 5962, 6006, 6010, 5966, 3469, 3480, 3481, 3470
9649, 2034, 2045, 2046, 2035, 5963, 6007, 6011, 5967
9650, 5963, 6007, 6011, 5967, 5964, 6008, 6012, 5968
9651, 5964, 6008, 6012, 5968, 5965, 6009, 6013, 5969
9652, 5965, 6009, 6013, 5969, 5966, 6010, 6014, 5970
9653, 5966, 6010, 6014, 5970, 3470, 3481, 3482, 3471
9654, 2035, 2046, 2047, 2036, 5967, 6011, 6015, 5971
9655, 5967, 6011, 6015, 5971, 5968, 6012, 6016, 5972
9656, 5968, 6012, 6016, 5972, 5969, 6013, 6017, 5973
9657, 5969, 6013, 6017, 5973, 5970, 6014, 6018, 5974
9658, 5970, 6014, 6018, 5974, 3471, 3482, 3483, 3472
9659, 2036, 2047, 2048, 2037, 5971, 6015, 6019, 5975
9660, 5971, 6015, 6019, 5975, 5972, 6016, 6020, 5976
9661, 5972, 6016, 6020, 5976, 5973, 6017, 6021, 5977
9662, 5973, 6017, 6021, 5977, 5974, 6018, 6022, 5978
9663, 5974, 6018, 6022, 5978, 3472, 3483, 3484, 3473
9664, 2037, 2048, 2049, 2038, 5975, 6019, 6023, 5979
9665, 5975, 6019, 6023, 5979, 5976, 6020, 6024, 5980
9666, 5976, 6020, 6024, 5980, 5977, 6021, 6025, 5981
9667, 5977, 6021, 6025, 5981, 5978, 6022, 6026, 5982
9668, 5978, 6022, 6026, 5982, 3473, 3484, 3485, 3474
9669, 2038, 2049, 2050, 2039, 5979, 6023, 6027, 5983
9670, 5979, 6023, 6027, 5983, 5980, 6024, 6028, 5984
9671, 5980, 6024, 6028, 5984, 5981, 6025, 6029, 5985
9672, 5981, 6025, 6029, 5985, 5982, 6026, 6030, 5986
9673, 5982, 6026, 6030, 5986, 3474, 3485, 3486, 3475
9674, 2039, 2050, 2051, 2040, 5983, 6027, 6031, 5987
9675, 5983, 6027, 6031, 5987, 5984, 6028, 6032, 5988
9676, 5984, 6028, 6032, 5988, 5985, 6029, 6033, 5989
9677, 5985, 6029, 6033, 5989, 5986, 6030, 6034, 5990
9678, 5986, 6030, 6034, 5990, 3475, 3486, 3487, 3476
9679, 2040, 2051, 2052, 2041, 5987, 6031, 6035, 5991
9680, 5987, 6031, 6035, 5991, 5988, 6032, 6036, 5992
9681, 5988, 6032, 6036, 5992, 5989, 6033, 6037, 5993
9682, 5989, 6033, 6037, 5993, 5990, 6034, 6038, 5994
9683, 5990, 6034, 6038, 5994, 3476, 3487, 3488, 3477
9684, 2041, 2052, 434, 433, 5991, 6035, 3444, 3440
9685, 5991, 6035, 3444, 3440, 5992, 6036, 3445, 3441
9686, 5992, 6036, 3445, 3441, 5993, 6037, 3446, 3442
9687, 5993, 6037, 3446, 3442, 5994, 6038, 3447, 3443
9688, 5994, 6038, 3447, 3443, 3477, 3488, 920, 919
9689, 376, 377, 2053, 2042, 3316, 3320, 6039, 5995
9690, 3316, 3320, 6039, 5995, 3317, 3321, 6040, 5996
9691, 3317, 3321, 6040, 5996, 3318, 3322, 6041, 5997
9692, 3318, 3322, 6041, 5997, 3319, 3323, 6042, 5998
9693, 3319, 3323, 6042, 5998, 885, 886, 3489, 3478
9694, 2042, 2053, 2054, 2043, 5995, 6039, 6043, 5999
9695, 5995, 6039, 6043, 5999, 5996, 6040, 6044, 6000
9696, 5996, 6040, 6044, 6000, 5997, 6041, 6045, 6001
9697, 5997, 6041, 6045, 6001, 5998, 6042, 6046, 6002
9698, 5998, 6042, 6046, 6002, 3478, 3489, 3490, 3479
9699, 2043, 2054, 2055, 2044, 5999, 6043, 6047, 6003
9700, 5999, 6043, 6047, 6003, 6000, 6044, 6048, 6004
9701, 6000, 6044, 6048, 6004, 6001, 6045, 6049, 6005
9702, 6001, 6045, 6049, 6005, 6002, 6046, 6050, 6006
9703, 6002, 6046, 6050, 6006, 3479, 3490, 3491, 3480
9704, 2044, 2055, 2056, 2045, 6003, 6047, 6051, 6007
9705, 6003, 6047, 6051, 6007, 6004, 6048, 6052, 6008
9706, 6004, 6048, 6052, 6008, 6005, 6049, 6053, 6009
9707, 6005, 6049, 6053, 6009, 6006, 6050, 6054, 6010
9708, 6006, 6050, 6054, 6010, 3480, 3491, 3492, 3481
9709, 2045, 2056, 2057, 2046, 6007, 6051, 6055, 6011
9710, 6007, 6051, 6055, 6011, 6008, 6052, 6056, 6012
9711, 6008, 6052, 6056, 6012, 6009, 6053, 6057, 6013
9712, 6009, 6053, 6057, 6013, 6010, 6054, 6058, 6014
9713, 6010, 6054, 6058, 6014, 3481, 3492, 3493, 3482
9714, 2046, 2057, 2058, 2047, 6011, 6055, 6059, 6015
9715, 6011, 6055, 6059, 6015, 6012, 6056, 6060, 6016
9716, 6012, 6056, 6060, 6016, 6013, 6057, 6061, 6017
9717, 6013, 6057, 6061, 6017, 6014, 6058, 6062, 6018
9718, 6014, 6058, 6062, 6018, 3482, 3493, 3494, 3483
9719, 2047, 2058, 2059, 2048, 6015, 6059, 6063, 6019
9720, 6015, 6059, 6063, 6019, 6016, 6060, 6064, 6020
9721, 6016, 6060, 6064, 6020, 6017, 6061, 6065, 6021
9722, 6017, 6061, 6065, 6021, 6018, 6062, 6066, 6022
9723, 6018, 6062, 6066, 6022, 3483, 3494, 3495, 3484
9724, 2048, 2059, 2060, 2049, 6019, 6063, 6067, 6023
9725, 6019, 6063, 6067, 6023, 6020, 6064, 6068, 6024
9726, 6020, 6064, 6068, 6024, 6021, 6065, 6069, 6025
9727, 6021, 6065, 6069, 6025, 6022, 6066, 6070, 6026
9728, 6022, 6066, 6070, 6026, 3484, 3495, 3496, 3485
9729, 2049, 2060, 2061, 2050, 6023, 6067, 6071, 6027
9730, 6023, 6067, 6071, 6027, 6024, 6068, 6072, 6028
9731, 6024, 6068, 6072, 6028, 6025, 6069, 6073, 6029
9732, 6025, 6069, 6073, 6029, 6026, 6070, 6074, 6030
9733, 6026, 6070, 6074, 6030, 3485, 3496, 3497, 3486
9734, 2050, 2061, 2062, 2051, 6027, 6071, 6075, 6031
9735, 6027, 6071, 6075, 6031, 6028, 6072, 6076, 6032
9736, 6028, 6072, 6076, 6032, 6029, 6073, 6077, 6033
9737, 6029, 6073, 6077, 6033, 6030, 6074, 6078, 6034
9738, 6030, 6074, 6078, 6034, 3486, 3497, 3498, 3487
9739, 2051, 2062, 2063, 2052, 6031, 6075, 6079, 6035
9740, 6031, 6075, 6079, 6035, 6032, 6076, 6080, 6036
9741, 6032, 6076, 6080, 6036, 6033, 6077, 6081, 6037
9742, 6033, 6077, 6081, 6037, 6034, 6078, 6082, 6038
9743, 6034, 6078, 6082, 6038, 3487, 3498, 3499, 3488
9744, 2052, 2063, 435, 434, 6035, 6079, 3448, 3444
9745, 6035, 6079, 3448, 3444, 6036, 6080, 3449, 3445
9746, 6036, 6080, 3449, 3445, 6037, 6081, 3450, 3446
9747, 6037, 6081, 3450, 3446, 6038, 6082, 3451, 3447
9748, 6038, 6082, 3451, 3447, 3488, 3499, 921, 920
9749, 377, 378, 2064, 2053, 3320, 3324, 6083, 6039
9750, 3320, 3324, 6083, 6039, 3321, 3325, 6084, 6040
9751, 3321, 3325, 6084, 6040, 3322, 3326, 6085, 6041
9752, 3322, 3326, 6085, 6041, 3323, 3327, 6086, 6042
9753, 3323, 3327, 6086, 6042, 886, 887, 3500, 3489
9754, 2053, 2064, 2065, 2054, 6039, 6083, 6087, 6043
9755, 6039, 6083, 6087, 6043, 6040, 6084, 6088, 6044
9756, 6040, 6084, 6088, 6044, 6041, 6085, 6089, 6045
9757, 6041, 6085, 6089, 6045, 6042, 6086, 6090, 6046
9758, 6042, 6086, 6090, 6046, 3489, 3500, 3501, 3490
9759, 2054, 2065, 2066, 2055, 6043, 6087, 6091, 6047
9760, 6043, 6087, 6091, 6047, 6044, 6088, 6092, 6048
9761, 6044, 6088, 6092, 6048, 6045, 6089, 6093, 6049
9762, 6045, 6089, 6093, 6049, 6046, 6090, 6094, 6050
9763, 6046, 6090, 6094, 6050, 3490, 3501, 3502, 3491
9764, 2055, 2066, 2067, 2056, 6047, 6091, 6095, 6051
9765, 6047, 6091, 6095, 6051, 6048, 6092, 6096, 6052
9766, 6048, 6092, 6096, 6052, 6049, 6093, 6097, 6053
9767, 6049, 6093, 6097, 6053, 6050, 6094, 6098, 6054
9768, 6050, 6094, 6098, 6054, 3491, 3502, 3503, 3492
9769, 2056, 2067, 2068, 2057, 6051, 6095, 6099, 6055
9770, 6051, 6095, 6099, 6055, 6052, 6096, 6100, 6056
9771, 6052, 6096, 6100, 6056, 6053, 6097, 6101, 6057
9772, 6053, 6097, 6101, 6057, 6054, 6098, 6102, 6058
9773, 6054, 6098, 6102, 6058, 3492, 3503, 3504, 3493
9774, 2057, 2068, 2069, 2058, 6055, 6099, 6103, 6059
9775, 6055, 6099, 6103, 6059, 6056, 6100, 6104, 6060
9776, 6056, 6100, 6104, 6060, 6057, 6101, 6105, 6061
9777, 6057, 6101, 6105, 6061, 6058, 6102, 6106, 6062
9778, 6058, 6102, 6106, 6062, 3493, 3504, 3505, 3494
9779, 2058, 2069, 2070, 2059, 6059, 6103, 6107, 6063
9780, 6059, 6103, 6107, 6063, 6060, 6104, 6108, 6064
9781, 6060, 6104, 6108, 6064, 6061, 6105, 6109, 6065
9782, 6061, 6105, 6109, 6065, 6062, 6106, 6110, 6066
9783, 6062, 6106, 6110, 6066, 3494, 3505, 3506, 3495
9784, 2059, 2070, 2071, 2060, 6063, 6107, 6111, 6067
9785, 6063, 6107, 6111, 6067, 6064, 6108, 6112, 6068
9786, 6064, 6108, 6112, 6068, 6065, 6109, 6113, 6069
9787, 6065, 6109, 6113, 6069, 6066, 6110, 6114, 6070
9788, 6066, 6110, 6114, 6070, 3495, 3506, 3507, 3496
9789, 2060, 2071, 2072, 2061, 6067, 6111, 6115, 6071
9790, 6067, 6111, 6115, 6071, 6068, 6112, 6116, 6072
9791, 6068, 6112, 6116, 6072, 6069, 6113, 6117, 6073
9792, 6069, 6113, 6117, 6073, 6070, 6114, 6118, 6074
9793, 6070, 6114, 6118, 6074, 3496, 3507, 3508, 3497
9794, 2061, 2072, 2073, 2062, 6071, 6115, 6119, 6075
9795, 6071, 6115, 6119, 6075, 6072, 6116, 6120, 6076
9796, 6072, 6116, 6120, 6076, 6073, 6117, 6121, 6077
9797, 6073, 6117, 6121, 6077, 6074, 6118, 6122, 6078
9798, 6074, 6118, 6122, 6078, 3497, 3508, 3509, 3498
9799, 2062, 2073, 2074, 2063, 6075, 6119, 6123, 6079
9800, 6075, 6119, 6123, 6079, 6076, 6120, 6124, 6080
9801, 6076, 6120, 6124, 6080, 6077, 6121, 6125, 6081
9802, 6077, 6121, 6125, 6081, 6078, 6122, 6126, 6082
9803, 6078, 6122, 6126, 6082, 3498, 3509, 3510, 3499
9804, 2063, 2074, 436, 435, 6079, 6123, 3452, 3448
9805, 6079, 6123, 3452, 3448, 6080, 6124, 3453, 3449
9806, 6080, 6124, 3453, 3449, 6081, 6125, 3454, 3450
9807, 6081, 6125, 3454, 3450, 6082, 6126, 3455, 3451
9808, 6082, 6126, 3455, 3451, 3499, 3510, 922, 921
9809, 378, 26, 390, 2064, 3324, 867, 3348, 6083
9810, 3324, 867, 3348, 6083, 3325, 868, 3349, 6084
9811, 3325, 868, 3349, 6084, 3326, 869, 3350, 6085
9812, 3326, 869, 3350, 6085, 3327, 870, 3351, 6086
9813, 3327, 870, 3351, 6086, 887, 81, 892, 3500
9814, 2064, 390, 391, 2065, 6083, 3348, 3352, 6087
9815, 6083, 3348, 3352, 6087, 6084, 3349, 3353, 6088
9816, 6084, 3349, 3353, 6088, 6085, 3350, 3354, 6089
9817, 6085, 3350, 3354, 6089, 6086, 3351, 3355, 6090
9818, 6086, 3351, 3355, 6090, 3500, 892, 893, 3501
9819, 2065, 391, 392, 2066, 6087, 3352, 3356, 6091
9820, 6087, 3352, 3356, 6091, 6088, 3353, 3357, 6092
9821, 6088, 3353, 3357, 6092, 6089, 3354, 3358, 6093
9822, 6089, 3354, 3358, 6093, 6090, 3355, 3359, 6094
9823, 6090, 3355, 3359, 6094, 3501, 893, 894, 3502
9824, 2066, 392, 393, 2067, 6091, 3356, 3360, 6095
9825, 6091, 3356, 3360, 6095, 6092, 3357, 3361, 6096
9826, 6092, 3357, 3361, 6096, 6093, 3358, 3362, 6097
9827, 6093, 3358, 3362, 6097, 6094, 3359, 3363, 6098
9828, 6094, 3359, 3363, 6098, 3502, 894, 895, 3503
9829, 2067, 393, 394, 2068, 6095, 3360, 3364, 6099
9830, 6095, 3360, 3364, 6099, 6096, 3361, 3365, 6100
9831, 6096, 3361, 3365, 6100, 6097, 3362, 3366, 6101
9832, 6097, 3362, 3366, 6101, 6098, 3363, 3367, 6102
9833, 6098, 3363, 3367, 6102, 3503, 895, 896, 3504
9834, 2068, 394, 395, 2069, 6099, 3364, 3368, 6103
9835, 6099, 3364, 3368, 6103, 6100, 3365, 3369, 6104
9836, 6100, 3365, 3369, 6104, 6101, 3366, 3370, 6105
9837, 6101, 3366, 3370, 6105, 6102, 3367, 3371, 6106
9838, 6102, 3367, 3371, 6106, 3504, 896, 897, 3505
9839, 2069, 395, 396, 2070, 6103, 3368, 3372, 6107
9840, 6103, 3368, 3372, 6107, 6104, 3369, 3373, 6108
9841, 6104, 3369, 3373, 6108, 6105, 3370, 3374, 6109
9842, 6105, 3370, 3374, 6109, 6106, 3371, 3375, 6110
9843, 6106, 3371, 3375, 6110, 3505, 897, 898, 3506
9844, 2070, 396, 397, 2071, 6107, 3372, 3376, 6111
9845, 6107, 3372, 3376, 6111, 6108, 3373, 3377, 6112
9846, 6108, 3373, 3377, 6112, 6109, 3374, 3378, 6113
9847, 6109, 3374, 3378, 6113, 6110, 3375, 3379, 6114
9848, 6110, 3375, 3379, 6114, 3506, 898, 899, 3507
9849, 2071, 397, 398, 2072, 6111, 3376, 3380, 6115
9850, 6111, 3376, 3380, 6115, 6112, 3377, 3381, 6116
9851, 6112, 3377, 3381, 6116, 6113, 3378, 3382, 6117
9852, 6113, 3378, 3382, 6117, 6114, 3379, 3383, 6118
9853, 6114, 3379, 3383, 6118, 3507, 899, 900, 3508
9854, 2072, 398, 399, 2073, 6115, 3380, 3384, 6119
9855, 6115, 3380, 3384, 6119, 6116, 3381, 3385, 6120
9856, 6116, 3381, 3385, 6120, 6117, 3382, 3386, 6121
9857, 6117, 3382, 3386, 6121, 6118, 3383, 3387, 6122
9858, 6118, 3383, 3387, 6122, 3508, 900, 901, 3509
9859, 2073, 399, 400, 2074, 6119, 3384, 3388, 6123
9860, 6119, 3384, 3388, 6123, 6120, 3385, 3389, 6124
9861, 6120, 3385, 3389, 6124, 6121, 3386, 3390, 6125
9862, 6121, 3386, 3390, 6125, 6122, 3387, 3391, 6126
9863, 6122, 3387, 3391, 6126, 3509, 901, 902, 3510
9864, 2074, 400, 30, 436, 6123, 3388, 888, 3452
9865, 6123, 3388, 888, 3452, 6124, 3389, 889, 3453
9866, 6124, 3389, 889, 3453, 6125, 3390, 890, 3454
9867, 6125, 3390, 890, 3454, 6126, 3391, 891, 3455
9868, 6126, 3391, 891, 3455, 3510, 902, 83, 922
*ELEMENT, type=C3D8, ELSET=Volume23
9869, 2, 125, 1065, 97, 927, 3511, 6127, 3619
9870, 927, 3511, 6127, 3619, 928, 3512, 6128, 3620
9871, 928, 3512, 6128, 3620, 929, 3513, 6129, 3621
9872, 929, 3513, 6129, 3621, 930, 3514, 6130, 3622
9873, 930, 3514, 6130, 3622, 86, 931, 3639, 966
9874, 97, 1065, 1066, 98, 3619, 6127, 6131, 3623
9875, 3619, 6127, 6131, 3623, 3620, 6128, 6132, 3624
9876, 3620, 6128, 6132, 3624, 3621, 6129, 6133, 3625
9877, 3621, 6129, 6133, 3625, 3622, 6130, 6134, 3626
9878, 3622, 6130, 6134, 3626, 966, 3639, 3640, 967
9879, 98, 1066, 1067, 99, 3623, 6131, 6135, 3627
9880, 3623, 6131, 6135, 3627, 3624, 6132, 6136, 3628
9881, 3624, 6132, 6136, 3628, 3625, 6133, 6137, 3629
9882, 3625, 6133, 6137, 3629, 3626, 6134, 6138, 3630
9883, 3626, 6134, 6138, 3630, 967, 3640, 3641, 968
9884, 99, 1067, 1068, 100, 3627, 6135, 6139, 3631
9885, 3627, 6135, 6139, 3631, 3628, 6136, 6140, 3632
9886, 3628, 6136, 6140, 3632, 3629, 6137, 6141, 3633
9887, 3629, 6137, 6141, 3633, 3630, 6138, 6142, 3634
9888, 3630, 6138, 6142, 3634, 968, 3641, 3642, 969
9889, 100, 1068, 1069, 101, 3631, 6139, 6143, 3635
9890, 3631, 6139, 6143, 3635, 3632, 6140, 6144, 3636
9891, 3632, 6140, 6144, 3636, 3633, 6141, 6145, 3637
9892, 3633, 6141, 6145, 3637, 3634, 6142, 6146, 3638
9893, 3634, 6142, 6146, 3638, 969, 3642, 3643, 970
9894, 101, 1069, 136, 1, 3635, 6143, 3575, 951
9895, 3635, 6143, 3575, 951, 3636, 6144, 3576, 952
9896, 3636, 6144, 3576, 952, 3637, 6145, 3577, 953
9897, 3637, 6145, 3577, 953, 3638, 6146, 3578, 954
9898, 3638, 6146, 3578, 954, 970, 3643, 955, 88
9899, 125, 126, 1070, 1065, 3511, 3515, 6147, 6127
9900, 3511, 3515, 6147, 6127, 3512, 3516, 6148, 6128
9901, 3512, 3516, 6148, 6128, 3513, 3517, 6149, 6129
9902, 3513, 3517, 6149, 6129, 3514, 3518, 6150, 6130
9903, 3514, 3518, 6150, 6130, 931, 932, 3644, 3639
9904, 1065, 1070, 1071, 1066, 6127, 6147, 6151, 6131
9905, 6127, 6147, 6151, 6131, 6128, 6148, 6152, 6132
9906, 6128, 6148, 6152, 6132, 6129, 6149, 6153, 6133
9907, 6129, 6149, 6153, 6133, 6130, 6150, 6154, 6134
9908, 6130, 6150, 6154, 6134, 3639, 3644, 3645, 3640
9909, 1066, 1071, 1072, 1067, 6131, 6151, 6155, 6135
9910, 6131, 6151, 6155, 6135, 6132, 6152, 6156, 6136
9911, 6132, 6152, 6156, 6136, 6133, 6153, 6157, 6137
9912, 6133, 6153, 6157, 6137, 6134, 6154, 6158, 6138
9913, 6134, 6154, 6158, 6138, 3640, 3645, 3646, 3641
9914, 1067, 1072, 1073, 1068, 6135, 6155, 6159, 6139
9915, 6135, 6155, 6159, 6139, 6136, 6156, 6160, 6140
9916, 6136, 6156, 6160, 6140, 6137, 6157, 6161, 6141
9917, 6137, 6157, 6161, 6141, 6138, 6158, 6162, 6142
9918, 6138, 6158, 6162, 6142, 3641, 3646, 3647, 3642
9919, 1068, 1073, 1074, 1069, 6139, 6159, 6163, 6143
9920, 6139, 6159, 6163, 6143, 6140, 6160, 6164, 6144
9921, 6140, 6160, 6164, 6144, 6141, 6161, 6165, 6145
9922, 6141, 6161, 6165, 6145, 6142, 6162, 6166, 6146
9923, 6142, 6162, 6166, 6146, 3642, 3647, 3648, 3643
9924, 1069, 1074, 137, 136, 6143, 6163, 3579, 3575
9925, 6143, 6163, 3579, 3575, 6144, 6164, 3580, 3576
9926, 6144, 6164, 3580, 3576, 6145, 6165, 3581, 3577
9927, 6145, 6165, 3581, 3577, 6146, 6166, 3582, 3578
9928, 6146, 6166, 3582, 3578, 3643, 3648, 956, 955
9929, 126, 127, 1075, 1070, 3515, 3519, 6167, 6147
9930, 3515, 3519, 6167, 6147, 3516, 3520, 6168, 6148
9931, 3516, 3520, 6168, 6148, 3517, 3521, 6169, 6149
9932, 3517, 3521, 6169, 6149, 3518, 3522, 6170, 6150
9933, 3518, 3522, 6170, 6150, 932, 933, 3649, 3644
9934, 1070, 1075, 1076, 1071, 6147, 6167, 6171, 6151
9935, 6147, 6167, 6171, 6151, 6148, 6168, 6172, 6152
9936, 6148, 6168, 6172, 6152, 6149, 6169, 6173, 6153
9937, 6149, 6169, 6173, 6153, 6150, 6170, 6174, 6154
9938, 6150, 6170, 6174, 6154, 3644, 3649, 3650, 3645
9939, 1071, 1076, 1077, 1072, 6151, 6171, 6175, 6155
9940, 6151, 6171, 6175, 6155, 6152, 6172, 6176, 6156
9941, 6152, 6172, 6176, 6156, 6153, 6173, 6177, 6157
9942, 6153, 6173, 6177, 6157, 6154, 6174, 6178, 6158
9943, 6154, 6174, 6178, 6158, 3645, 3650, 3651, 3646
9944, 1072, 1077, 1078, 1073, 6155, 6175, 6179, 6159
9945, 6155, 6175, 6179, 6159, 6156, 6176, 6180, 6160
9946, 6156, 6176, 6180, 6160, 6157, 6177, 6181, 6161
9947, 6157, 6177, 6181, 6161, 6158, 6178, 6182, 6162
9948, 6158, 6178, 6182, 6162, 3646, 3651, 3652, 3647
9949, 1073, 1078, 1079, 1074, 6159, 6179, 6183, 6163
9950, 6159, 6179, 6183, 6163, 6160, 6180, 6184, 6164
9951, 6160, 6180, 6184, 6164, 6161, 6181, 6185, 6165
9952, 6161, 6181, 6185, 6165, 6162, 6182, 6186, 6166
9953, 6162, 6182, 6186, 6166, 3647, 3652, 3653, 3648
9954, 1074, 1079, 138, 137, 6163, 6183, 3583, 3579
9955, 6163, 6183, 3583, 3579, 6164, 6184, 3584, 3580
9956, 6164, 6184, 3584, 3580, 6165, 6185, 3585, 3581
9957, 6165, 6185, 3585, 3581, 6166, 6186, 3586, 3582
9958, 6166, 6186, 3586, 3582, 3648, 3653, 957, 956
9959, 127, 128, 1080, 1075, 3519, 3523, 6187, 6167
9960, 3519, 3523, 6187, 6167, 3520, 3524, 6188, 6168
9961, 3520, 3524, 6188, 6168, 3521, 3525, 6189, 6169
9962, 3521, 3525, 6189, 6169, 3522, 3526, 6190, 6170
9963, 3522, 3526, 6190, 6170, 933, 934, 3654, 3649
9964, 1075, 1080, 1081, 1076, 6167, 6187, 6191, 6171
9965, 6167, 6187, 6191, 6171, 6168, 6188, 6192, 6172
9966, 6168, 6188, 6192, 6172, 6169, 6189, 6193, 6173
9967, 6169, 6189, 6193, 6173, 6170, 6190, 6194, 6174
9968, 6170, 6190, 6194, 6174, 3649, 3654, 3655, 3650
9969, 1076, 1081, 1082, 1077, 6171, 6191, 6195, 6175
9970, 6171, 6191, 6195, 6175, 6172, 6192, 6196, 6176
9971, 6172, 6192, 6196, 6176, 6173, 6193, 6197, 6177
9972, 6173, 6193, 6197, 6177, 6174, 6194, 6198, 6178
9973, 6174, 6194, 6198, 6178, 3650, 3655, 3656, 3651
9974, 1077, 1082, 1083, 1078, 6175, 6195, 6199, 6179
9975, 6175, 6195, 6199, 6179, 6176, 6196, 6200, 6180
9976, 6176, 6196, 6200, 6180, 6177, 6197, 6201, 6181
9977, 6177, 6197, 6201, 6181, 6178, 6198, 6202, 6182
9978, 6178, 6198, 6202, 6182, 3651, 3656, 3657, 3652
9979, 1078, 1083, 1084, 1079, 6179, 6199, 6203, 6183
9980, 6179, 6199, 6203, 6183, 6180, 6200, 6204, 6184
9981, 6180, 6200, 6204, 6184, 6181, 6201, 6205, 6185
9982, 6181, 6201, 6205, 6185, 6182, 6202, 6206, 6186
9983, 6182, 6202, 6206, 6186, 3652, 3657, 3658, 3653
9984, 1079, 1084, 139, 138, 6183, 6203, 3587, 3583
9985, 6183, 6203, 3587, 3583, 6184, 6204, 3588, 3584
9986, 6184, 6204, 3588, 3584, 6185, 6205, 3589, 3585
9987, 6185, 6205, 3589, 3585, 6186, 6206, 3590, 3586
9988, 6186, 6206, 3590, 3586, 3653, 3658, 958, 957
9989, 128, 129, 1085, 1080, 3523, 3527, 6207, 6187
9990, 3523, 3527, 6207, 6187, 3524, 3528, 6208, 6188
9991, 3524, 3528, 6208, 6188, 3525, 3529, 6209, 6189
9992, 3525, 3529, 6209, 6189, 3526, 3530, 6210, 6190
9993, 3526, 3530, 6210, 6190, 934, 935, 3659, 3654
9994, 1080, 1085, 1086, 1081, 6187, 6207, 6211, 6191
9995, 6187, 6207, 6211, 6191, 6188, 6208, 6212, 6192
9996, 6188, 6208, 6212, 6192, 6189, 6209, 6213, 6193
9997, 6189, 6209, 6213, 6193, 6190, 6210, 6214, 6194
9998, 6190, 6210, 6214, 6194, 3654, 3659, 3660, 3655
9999, 1081, 1086, 1087, 1082, 6191, 6211, 6215, 6195
10000, 6191, 6211, 6215, 6195, 6192, 6212, 6216, 6196
10001, 6192, 6212, 6216, 6196, 6193, 6213, 6217, 6197
10002, 6193, 6213, 6217, 6197, 6194, 6214, 6218, 6198
10003, 6194, 6214, 6218, 6198, 3655, 3660, 3661, 3656
10004, 1082, 1087, 1088, 1083, 6195, 6215, 6219, 6199
10005, 6195, 6215, 6219, 6199, 6196, 6216, 6220, 6200
10006, 6196, 6216, 6220, 6200, 6197, 6217, 6221, 6201
10007, 6197, 6217, 6221, 6201, 6198, 6218, 6222, 6202
10008, 6198, 6218, 6222, 6202, 3656, 3661, 3662, 3657
10009, 1083, 1088, 1089, 1084, 6199, 6219, 6223, 6203
10010, 6199, 6219, 6223, 6203, 6200, 6220, 6224, 6204
10011, 6200, 6220, 6224, 6204, 6201, 6221, 6225, 6205
10012, 6201, 6221, 6225, 6205, 6202, 6222, 6226, 6206
10013, 6202, 6222, 6226, 6206, 3657, 3662, 3663, 3658
10014, 1084, 1089, 140, 139, 6203, 6223, 3591, 3587
10015, 6203, 6223, 3591, 3587, 6204, 6224, 3592, 3588
10016, 6204, 6224, 3592, 3588, 6205, 6225, 3593, 3589
10017, 6205, 6225, 3593, 3589, 6206, 6226, 3594, 3590
10018, 6206, 6226, 3594, 3590, 3658, 3663, 959, 958
10019, 129, 130, 1090, 1085, 3527, 3531, 6227, 6207
10020, 3527, 3531, 6227, 6207, 3528, 3532, 6228, 6208
10021, 3528, 3532, 6228, 6208, 3529, 3533, 6229, 6209
10022, 3529, 3533, 6229, 6209, 3530, 3534, 6230, 6210
10023, 3530, 3534, 6230, 6210, 935, 936, 3664, 3659
10024, 1085, 1090, 1091, 1086, 6207, 6227, 6231, 6211
10025, 6207, 6227, 6231, 6211, 6208, 6228, 6232, 6212
10026, 6208, 6228, 6232, 6212, 6209, 6229, 6233, 6213
10027, 6209, 6229, 6233, 6213, 6210, 6230, 6234, 6214
10028, 6210, 6230, 6234, 6214, 3659, 3664, 3665, 3660
10029, 1086, 1091, 1092, 1087, 6211, 6231, 6235, 6215
10030, 6211, 6231, 6235, 6215, 6212, 6232, 6236, 6216
10031, 6212, 6232, 6236, 6216, 6213, 6233, 6237, 6217
10032, 6213, 6233, 6237, 6217, 6214, 6234, 6238, 6218
10033, 6214, 6234, 6238, 6218, 3660, 3665, 3666, 3661
10034, 1087, 1092, 1093, 1088, 6215, 6235, 6239, 6219
10035, 6215, 6235, 6239, 6219, 6216, 6236, 6240, 6220
10036, 6216, 6236, 6240, 6220, 6217, 6237, 6241, 6221
10037, 6217, 6237, 6241, 6221, 6218, 6238, 6242, 6222
10038, 6218, 6238, 6242, 6222, 3661, 3666, 3667, 3662
10039, 1088, 1093, 1094, 1089, 6219, 6239, 6243, 6223
10040, 6219, 6239, 6243, 6223, 6220, 6240, 6244, 6224
10041, 6220, 6240, 6244, 6224, 6221, 6241, 6245, 6225
10042, 6221, 6241, 6245, 6225, 6222, 6242, 6246, 6226
10043, 6222, 6242, 6246, 6226, 3662, 3667, 3668, 3663
10044, 1089, 1094, 141, 140, 6223, 6243, 3595, 3591
10045, 6223, 6243, 3595, 3591, 6224, 6244, 3596, 3592
10046, 6224, 6244, 3596, 3592, 6225, 6245, 3597, 3593
10047, 6225, 6245, 3597, 3593, 6226, 6246, 3598, 3594
10048, 6226, 6246, 3598, 3594, 3663, 3668, 960, 959
10049, 130, 131, 1095, 1090, 3531, 3535, 6247, 6227
10050, 3531, 3535, 6247, 6227, 3532, 3536, 6248, 6228
10051, 3532, 3536, 6248, 6228, 3533, 3537, 6249, 6229
10052, 3533, 3537, 6249, 6229, 3534, 3538, 6250, 6230
10053, 3534, 3538, 6250, 6230, 936, 937, 3669, 3664
10054, 1090, 1095, 1096, 1091, 6227, 6247, 6251, 6231
10055, 6227, 6247, 6251, 6231, 6228, 6248, 6252, 6232
10056, 6228, 6248, 6252, 6232, 6229, 6249, 6253, 6233
10057, 6229, 6249, 6253, 6233, 6230, 6250, 6254, 6234
10058, 6230, 6250, 6254, 6234, 3664, 3669, 3670, 3665
10059, 1091, 1096, 1097, 1092, 6231, 6251, 6255, 6235
10060, 6231, 6251, 6255, 6235, 6232, 6252, 6256, 6236
10061, 6232, 6252, 6256, 6236, 6233, 6253, 6257, 6237
10062, 6233, 6253, 6257, 6237, 6234, 6254, 6258, 6238
10063, 6234, 6254, 6258, 6238, 3665, 3670, 3671, 3666
10064, 1092, 1097, 1098, 1093, 6235, 6255, 6259, 6239
10065, 6235, 6255, 6259, 6239, 6236, 6256, 6260, 6240
10066, 6236, 6256, 6260, 6240, 6237, 6257, 6261, 6241
10067, 6237, 6257, 6261, 6241, 6238, 6258, 6262, 6242
10068, 6238, 6258, 6262, 6242, 3666, 3671, 3672, 3667
10069, 1093, 1098, 1099, 1094, 6239, 6259, 6263, 6243
10070, 6239, 6259, 6263, 6243, 6240, 6260, 6264, 6244
10071, 6240, 6260, 6264, 6244, 6241, 6261, 6265, 6245
10072, 6241, 6261, 6265, 6245, 6242, 6262, 6266, 6246
10073, 6242, 6262, 6266, 6246, 3667, 3672, 3673, 3668
10074, 1094, 1099, 142, 141, 6243, 6263, 3599, 3595
10075, 6243, 6263, 3599, 3595, 6244, 6264, 3600, 3596
10076, 6244, 6264, 3600, 3596, 6245, 6265, 3601, 3597
10077, 6245, 6265, 3601, 3597, 6246, 6266, 3602, 3598
10078, 6246, 6266, 3602, 3598, 3668, 3673, 961, 960
10079, 131, 132, 1100, 1095, 3535, 3539, 6267, 6247
10080, 3535, 3539, 6267, 6247, 3536, 3540, 6268, 6248
10081, 3536, 3540, 6268, 6248, 3537, 3541, 6269, 6249
10082, 3537, 3541, 6269, 6249, 3538, 3542, 6270, 6250
10083, 3538, 3542, 6270, 6250, 937, 938, 3674, 3669
10084, 1095, 1100, 1101, 1096, 6247, 6267, 6271, 6251
10085, 6247, 6267, 6271, 6251, 6248, 6268, 6272, 6252
10086, 6248, 6268, 6272, 6252, 6249, 6269, 6273, 6253
10087, 6249, 6269, 6273, 6253, 6250, 6270, 6274, 6254
10088, 6250, 6270, 6274, 6254, 3669, 3674, 3675, 3670
10089, 1096, 1101, 1102, 1097, 6251, 6271, 6275, 6255
10090, 6251, 6271, 6275, 6255, 6252, 6272, 6276, 6256
10091, 6252, 6272, 6276, 6256, 6253, 6273, 6277, 6257
10092, 6253, 6273, 6277, 6257, 6254, 6274, 6278, 6258
10093, 6254, 6274, 6278, 6258, 3670, 3675, 3676, 3671
10094, 1097, 1102, 1103, 1098, 6255, 6275, 6279, 6259
10095, 6255, 6275, 6279, 6259, 6256, 6276, 6280, 6260
10096, 6256, 6276, 6280, 6260, 6257, 6277, 6281, 6261
10097, 6257, 6277, 6281, 6261, 6258, 6278, 6282, 6262
10098, 6258, 6278, 6282, 6262, 3671, 3676, 3677, 3672
10099, 1098, 1103, 1104, 1099, 6259, 6279, 6283, 6263
10100, 6259, 6279, 6283, 6263, 6260, 6280, 6284, 6264
10101, 6260, 6280, 6284, 6264, 6261, 6281, 6285, 6265
10102, 6261, 6281, 6285, 6265, 6262, 6282, 6286, 6266
10103, 6262, 6282, 6286, 6266, 3672, 3677, 3678, 3673
10104, 1099, 1104, 143, 142, 6263, 6283, 3603, 3599
10105, 6263, 6283, 3603, 3599, 6264, 6284, 3604, 3600
10106, 6264, 6284, 3604, 3600, 6265, 6285, 3605, 3601
10107, 6265, 6285, 3605, 3601, 6266, 6286, 3606, 3602
10108, 6266, 6286, 3606, 3602, 3673, 3678, 962, 961
10109, 132, 133, 1105, 1100, 3539, 3543, 6287, 6267
10110, 3539, 3543, 6287, 6267, 3540, 3544, 6288, 6268
10111, 3540, 3544, 6288, 6268, 3541, 3545, 6289, 6269
10112, 3541, 3545, 6289, 6269, 3542, 3546, 6290, 6270
10113, 3542, 3546, 6290, 6270, 938, 939, 3679, 3674
10114, 1100, 1105, 1106, 1101, 6267, 6287, 6291, 6271
10115, 6267, 6287, 6291, 6271, 6268, 6288, 6292, 6272
10116, 6268, 6288, 6292, 6272, 6269, 6289, 6293, 6273
10117, 6269, 6289, 6293, 6273, 6270, 6290, 6294, 6274
10118, 6270, 6290, 6294, 6274, 3674, 3679, 3680, 3675
10119, 1101, 1106, 1107, 1102, 6271, 6291, 6295, 6275
10120, 6271, 6291, 6295, 6275, 6272, 6292, 6296, 6276
10121, 6272, 6292, 6296, 6276, 6273, 6293, 6297, 6277
10122, 6273, 6293, 6297, 6277, 6274, 6294, 6298, 6278
10123, 6274, 6294, 6298, 6278, 3675, 3680, 3681, 3676
10124, 1102, 1107, 1108, 1103, 6275, 6295, 6299, 6279
10125, 6275, 6295, 6299, 6279, 6276, 6296, 6300, 6280
10126, 6276, 6296, 6300, 6280, 6277, 6297, 6301, 6281
10127, 6277, 6297, 6301, 6281, 6278, 6298, 6302, 6282
10128, 6278, 6298, 6302, 6282, 3676, 3681, 3682, 3677
10129, 1103, 1108, 1109, 1104, 6279, 6299, 6303, 6283
10130, 6279, 6299, 6303, 6283, 6280, 6300, 6304, 6284
10131, 6280, 6300, 6304, 6284, 6281, 6301, 6305, 6285
10132, 6281, 6301, 6305, 6285, 6282, 6302, 6306, 6286
10133, 6282, 6302, 6306, 6286, 3677, 3682, 3683, 3678
10134, 1104, 1109, 144, 143, 6283, 6303, 3607, 3603
10135, 6283, 6303, 3607, 3603, 6284, 6304, 3608, 3604
10136, 6284, 6304, 3608, 3604, 6285, 6305, 3609, 3605
10137, 6285, 6305, 3609, 3605, 6286, 6306, 3610, 3606
10138, 6286, 6306, 3610, 3606, 3678, 3683, 963, 962
10139, 133, 134, 1110, 1105, 3543, 3547, 6307, 6287
10140, 3543, 3547, 6307, 6287, 3544, 3548, 6308, 6288
10141, 3544, 3548, 6308, 6288, 3545, 3549, 6309, 6289
10142, 3545, 3549, 6309, 6289, 3546, 3550, 6310, 6290
10143, 3546, 3550, 6310, 6290, 939, 940, 3684, 3679
10144, 1105, 1110, 1111, 1106, 6287, 6307, 6311, 6291
10145, 6287, 6307, 6311, 6291, 6288, 6308, 6312, 6292
10146, 6288, 6308, 6312, 6292, 6289, 6309, 6313, 6293
10147, 6289, 6309, 6313, 6293, 6290, 6310, 6314, 6294
10148, 6290, 6310, 6314, 6294, 3679, 3684, 3685, 3680
10149, 1106, 1111, 1112, 1107, 6291, 6311, 6315, 6295
10150, 6291, 6311, 6315, 6295, 6292, 6312, 6316, 6296
10151, 6292, 6312, 6316, 6296, 6293, 6313, 6317, 6297
10152, 6293, 6313, 6317, 6297, 6294, 6314, 6318, 6298
10153, 6294, 6314, 6318, 6298, 3680, 3685, 3686, 3681
10154, 1107, 1112, 1113, 1108, 6295, 6315, 6319, 6299
10155, 6295, 6315, 6319, 6299, 6296, 6316, 6320, 6300
10156, 6296, 6316, 6320, 6300, 6297, 6317, 6321, 6301
10157, 6297, 6317, 6321, 6301, 6298, 6318, 6322, 6302
10158, 6298, 6318, 6322, 6302, 3681, 3686, 3687, 3682
10159, 1108, 1113, 1114, 1109, 6299, 6319, 6323, 6303
10160, 6299, 6319, 6323, 6303, 6300, 6320, 6324, 6304
10161, 6300, 6320, 6324, 6304, 6301, 6321, 6325, 6305
10162, 6301, 6321, 6325, 6305, 6302, 6322, 6326, 6306
10163, 6302, 6322, 6326, 6306, 3682, 3687, 3688, 3683
10164, 1109, 1114, 145, 144, 6303, 6323, 3611, 3607
10165, 6303, 6323, 3611, 3607, 6304, 6324, 3612, 3608
10166, 6304, 6324, 3612, 3608, 6305, 6325, 3613, 3609
10167, 6305, 6325, 3613, 3609, 6306, 6326, 3614, 3610
10168, 6306, 6326, 3614, 3610, 3683, 3688, 964, 963
10169, 134, 135, 1115, 1110, 3547, 3551, 6327, 6307
10170, 3547, 3551, 6327, 6307, 3548, 3552, 6328, 6308
10171, 3548, 3552, 6328, 6308, 3549, 3553, 6329, 6309
10172, 3549, 3553, 6329, 6309, 3550, 3554, 6330, 6310
10173, 3550, 3554, 6330, 6310, 940, 941, 3689, 3684
10174, 1110, 1115, 1116, 1111, 6307, 6327, 6331, 6311
10175, 6307, 6327, 6331, 6311, 6308, 6328, 6332, 6312
10176, 6308, 6328, 6332, 6312, 6309, 6329, 6333, 6313
10177, 6309, 6329, 6333, 6313, 6310, 6330, 6334, 6314
10178, 6310, 6330, 6334, 6314, 3684, 3689, 3690, 3685
10179, 1111, 1116, 1117, 1112, 6311, 6331, 6335, 6315
10180, 6311, 6331, 6335, 6315, 6312, 6332, 6336, 6316
10181, 6312, 6332, 6336, 6316, 6313, 6333, 6337, 6317
10182, 6313, 6333, 6337, 6317, 6314, 6334, 6338, 6318
10183, 6314, 6334, 6338, 6318, 3685, 3690, 3691, 3686
10184, 1112, 1117, 1118, 1113, 6315, 6335, 6339, 6319
10185, 6315, 6335, 6339, 6319, 6316, 6336, 6340, 6320
10186, 6316, 6336, 6340, 6320, 6317, 6337, 6341, 6321
10187, 6317, 6337, 6341, 6321, 6318, 6338, 6342, 6322
10188, 6318, 6338, 6342, 6322, 3686, 3691, 3692, 3687
10189, 1113, 1118, 1119, 1114, 6319, 6339, 6343, 6323
10190, 6319, 6339, 6343, 6323, 6320, 6340, 6344, 6324
10191, 6320, 6340, 6344, 6324, 6321, 6341, 6345, 6325
10192, 6321, 6341, 6345, 6325, 6322, 6342, 6346, 6326
10193, 6322, 6342, 6346, 6326, 3687, 3692, 3693, 3688
10194, 1114, 1119, 146, 145, 6323, 6343, 3615, 3611
10195, 6323, 6343, 3615, 3611, 6324, 6344, 3616, 3612
10196, 6324, 6344, 3616, 3612, 6325, 6345, 3617, 3613
10197, 6325, 6345, 3617, 3613, 6326, 6346, 3618, 3614
10198, 6326, 6346, 3618, 3614, 3688, 3693, 965, 964
10199, 135, 6, 111, 1115, 3551, 923, 3555, 6327
10200, 3551, 923, 3555, 6327, 3552, 924, 3556, 6328
10201, 3552, 924, 3556, 6328, 3553, 925, 3557, 6329
10202, 3553, 925, 3557, 6329, 3554, 926, 3558, 6330
10203, 3554, 926, 3558, 6330, 941, 85, 946, 3689
10204, 1115, 111, 112, 1116, 6327, 3555, 3559, 6331
10205, 6327, 3555, 3559, 6331, 6328, 3556, 3560, 6332
10206, 6328, 3556, 3560, 6332, 6329, 3557, 3561, 6333
10207, 6329, 3557, 3561, 6333, 6330, 3558, 3562, 6334
10208, 6330, 3558, 3562, 6334, 3689, 946, 947, 3690
10209, 1116, 112, 113, 1117, 6331, 3559, 3563, 6335
10210, 6331, 3559, 3563, 6335, 6332, 3560, 3564, 6336
10211, 6332, 3560, 3564, 6336, 6333, 3561, 3565, 6337
10212, 6333, 3561, 3565, 6337, 6334, 3562, 3566, 6338
10213, 6334, 3562, 3566, 6338, 3690, 947, 948, 3691
10214, 1117, 113, 114, 1118, 6335, 3563, 3567, 6339
10215, 6335, 3563, 3567, 6339, 6336, 3564, 3568, 6340
10216, 6336, 3564, 3568, 6340, 6337, 3565, 3569, 6341
10217, 6337, 3565, 3569, 6341, 6338, 3566, 3570, 6342
10218, 6338, 3566, 3570, 6342, 3691, 948, 949, 3692
10219, 1118, 114, 115, 1119, 6339, 3567, 3571, 6343
10220, 6339, 3567, 3571, 6343, 6340, 3568, 3572, 6344
10221, 6340, 3568, 3572, 6344, 6341, 3569, 3573, 6345
10222, 6341, 3569, 3573, 6345, 6342, 3570, 3574, 6346
10223, 6342, 3570, 3574, 6346, 3692, 949, 950, 3693
10224, 1119, 115, 5, 146, 6343, 3571, 942, 3615
10225, 6343, 3571, 942, 3615, 6344, 3572, 943, 3616
10226, 6344, 3572, 943, 3616, 6345, 3573, 944, 3617
10227, 6345, 3573, 944, 3617, 6346, 3574, 945, 3618
10228, 6346, 3574, 945, 3618, 3693, 950, 87, 965
*ELEMENT, type=C3D8, ELSET=Volume24
10229, 2, 97, 631, 54, 927, 3619, 3694, 975
10230, 927, 3619, 3694, 975, 928, 3620, 3695, 976
10231, 928, 3620, 3695, 976, 929, 3621, 3696, 977
10232, 929, 3621, 3696, 977, 930, 3622, 3697, 978
10233, 930, 3622, 3697, 978, 86, 966, 979, 90
10234, 97, 98, 632, 631, 3619, 3623, 3698, 3694
10235, 3619, 3623, 3698, 3694, 3620, 3624, 3699, 3695
10236, 3620, 3624, 3699, 3695, 3621, 3625, 3700, 3696
10237, 3621, 3625, 3700, 3696, 3622, 3626, 3701, 3697
10238, 3622, 3626, 3701, 3697, 966, 967, 980, 979
10239, 98, 99, 633, 632, 3623, 3627, 3702, 3698
10240, 3623, 3627, 3702, 3698, 3624, 3628, 3703, 3699
10241, 3624, 3628, 3703, 3699, 3625, 3629, 3704, 3700
10242, 3625, 3629, 3704, 3700, 3626, 3630, 3705, 3701
10243, 3626, 3630, 3705, 3701, 967, 968, 981, 980
10244, 99, 100, 634, 633, 3627, 3631, 3706, 3702
10245, 3627, 3631, 3706, 3702, 3628, 3632, 3707, 3703
10246, 3628, 3632, 3707, 3703, 3629, 3633, 3708, 3704
10247, 3629, 3633, 3708, 3704, 3630, 3634, 3709, 3705
10248, 3630, 3634, 3709, 3705, 968, 969, 982, 981
10249, 100, 101, 635, 634, 3631, 3635, 3710, 3706
10250, 3631, 3635, 3710, 3706, 3632, 3636, 3711, 3707
10251, 3632, 3636, 3711, 3707, 3633, 3637, 3712, 3708
10252, 3633, 3637, 3712, 3708, 3634, 3638, 3713, 3709
10253, 3634, 3638, 3713, 3709, 969, 970, 983, 982
10254, 101, 1, 53, 635, 3635, 951, 971, 3710
10255, 3635, 951, 971, 3710, 3636, 952, 972, 3711
10256, 3636, 952, 972, 3711, 3637, 953, 973, 3712
10257, 3637, 953, 973, 3712, 3638, 954, 974, 3713
10258, 3638, 954, 974, 3713, 970, 88, 89, 983
*ELEMENT, type=C3D8, ELSET=Volume25
10259, 47, 596, 2666, 607, 1003, 3758, 6347, 3802
10260, 1003, 3758, 6347, 3802, 1004, 3759, 6348, 3803
10261, 1004, 3759, 6348, 3803, 1005, 3760, 6349, 3804
10262, 1005, 3760, 6349, 3804, 1006, 3761, 6350, 3805
10263, 1006, 3761, 6350, 3805, 93, 1011, 3842, 1022
10264, 596, 597, 2667, 2666, 3758, 3762, 6351, 6347
10265, 3758, 3762, 6351, 6347, 3759, 3763, 6352, 6348
10266, 3759, 3763, 6352, 6348, 3760, 3764, 6353, 6349
10267, 3760, 3764, 6353, 6349, 3761, 3765, 6354, 6350
10268, 3761, 3765, 6354, 6350, 1011, 1012, 3843, 3842
10269, 597, 598, 2668, 2667, 3762, 3766, 6355, 6351
10270, 3762, 3766, 6355, 6351, 3763, 3767, 6356, 6352
10271, 3763, 3767, 6356, 6352, 3764, 3768, 6357, 6353
10272, 3764, 3768, 6357, 6353, 3765, 3769, 6358, 6354
10273, 3765, 3769, 6358, 6354, 1012, 1013, 3844, 3843
10274, 598, 599, 2669, 2668, 3766, 3770, 6359, 6355
10275, 3766, 3770, 6359, 6355, 3767, 3771, 6360, 6356
10276, 3767, 3771, 6360, 6356, 3768, 3772, 6361, 6357
10277, 3768, 3772, 6361, 6357, 3769, 3773, 6362, 6358
10278, 3769, 3773, 6362, 6358, 1013, 1014, 3845, 3844
10279, 599, 600, 2670, 2669, 3770, 3774, 6363, 6359
10280, 3770, 3774, 6363, 6359, 3771, 3775, 6364, 6360
10281, 3771, 3775, 6364, 6360, 3772, 3776, 6365, 6361
10282, 3772, 3776, 6365, 6361, 3773, 3777, 6366, 6362
10283, 3773, 3777, 6366, 6362, 1014, 1015, 3846, 3845
10284, 600, 601, 2671, 2670, 3774, 3778, 6367, 6363
10285, 3774, 3778, 6367, 6363, 3775, 3779, 6368, 6364
10286, 3775, 3779, 6368, 6364, 3776, 3780, 6369, 6365
10287, 3776, 3780, 6369, 6365, 3777, 3781, 6370, 6366
10288, 3777, 3781, 6370, 6366, 1015, 1016, 3847, 3846
10289, 601, 602, 2672, 2671, 3778, 3782, 6371, 6367
10290, 3778, 3782, 6371, 6367, 3779, 3783, 6372, 6368
10291, 3779, 3783, 6372, 6368, 3780, 3784, 6373, 6369
10292, 3780, 3784, 6373, 6369, 3781, 3785, 6374, 6370
10293, 3781, 3785, 6374, 6370, 1016, 1017, 3848, 3847
10294, 602, 603, 2673, 2672, 3782, 3786, 6375, 6371
10295, 3782, 3786, 6375, 6371, 3783, 3787, 6376, 6372
10296, 3783, 3787, 6376, 6372, 3784, 3788, 6377, 6373
10297, 3784, 3788, 6377, 6373, 3785, 3789, 6378, 6374
10298, 3785, 3789, 6378, 6374, 1017, 1018, 3849, 3848
10299, 603, 604, 2674, 2673, 3786, 3790, 6379, 6375
10300, 3786, 3790, 6379, 6375, 3787, 3791, 6380, 6376
10301, 3787, 3791, 6380, 6376, 3788, 3792, 6381, 6377
10302, 3788, 3792, 6381, 6377, 3789, 3793, 6382, 6378
10303, 3789, 3793, 6382, 6378, 1018, 1019, 3850, 3849
10304, 604, 605, 2675, 2674, 3790, 3794, 6383, 6379
10305, 3790, 3794, 6383, 6379, 3791, 3795, 6384, 6380
10306, 3791, 3795, 6384, 6380, 3792, 3796, 6385, 6381
10307, 3792, 3796, 6385, 6381, 3793, 3797, 6386, 6382
10308, 3793, 3797, 6386, 6382, 1019, 1020, 3851, 3850
10309, 605, 606, 2676, 2675, 3794, 3798, 6387, 6383
10310, 3794, 3798, 6387, 6383, 3795, 3799, 6388, 6384
10311, 3795, 3799, 6388, 6384, 3796, 3800, 6389, 6385
10312, 3796, 3800, 6389, 6385, 3797, 3801, 6390, 6386
10313, 3797, 3801, 6390, 6386, 1020, 1021, 3852, 3851
10314, 606, 48, 612, 2676, 3798, 1007, 3822, 6387
10315, 3798, 1007, 3822, 6387, 3799, 1008, 3823, 6388
10316, 3799, 1008, 3823, 6388, 3800, 1009, 3824, 6389
10317, 3800, 1009, 3824, 6389, 3801, 1010, 3825, 6390
10318, 3801, 1010, 3825, 6390, 1021, 94, 1027, 3852
10319, 607, 2666, 2677, 608, 3802, 6347, 6391, 3806
10320, 3802, 6347, 6391, 3806, 3803, 6348, 6392, 3807
10321, 3803, 6348, 6392, 3807, 3804, 6349, 6393, 3808
10322, 3804, 6349, 6393, 3808, 3805, 6350, 6394, 3809
10323, 3805, 6350, 6394, 3809, 1022, 3842, 3853, 1023
10324, 2666, 2667, 2678, 2677, 6347, 6351, 6395, 6391
10325, 6347, 6351, 6395, 6391, 6348, 6352, 6396, 6392
10326, 6348, 6352, 6396, 6392, 6349, 6353, 6397, 6393
10327, 6349, 6353, 6397, 6393, 6350, 6354, 6398, 6394
10328, 6350, 6354, 6398, 6394, 3842, 3843, 3854, 3853
10329, 2667, 2668, 2679, 2678, 6351, 6355, 6399, 6395
10330, 6351, 6355, 6399, 6395, 6352, 6356, 6400, 6396
10331, 6352, 6356, 6400, 6396, 6353, 6357, 6401, 6397
10332, 6353, 6357, 6401, 6397, 6354, 6358, 6402, 6398
10333, 6354, 6358, 6402, 6398, 3843, 3844, 3855, 3854
10334, 2668, 2669, 2680, 2679, 6355, 6359, 6403, 6399
10335, 6355, 6359, 6403, 6399, 6356, 6360, 6404, 6400
10336, 6356, 6360, 6404, 6400, 6357, 6361, 6405, 6401
10337, 6357, 6361, 6405, 6401, 6358, 6362, 6406, 6402
10338, 6358, 6362, 6406, 6402, 3844, 3845, 3856, 3855
10339, 2669, 2670, 2681, 2680, 6359, 6363, 6407, 6403
10340, 6359, 6363, 6407, 6403, 6360, 6364, 6408, 6404
10341, 6360, 6364, 6408, 6404, 6361, 6365, 6409, 6405
10342, 6361, 6365, 6409, 6405, 6362, 6366, 6410, 6406
10343, 6362, 6366, 6410, 6406, 3845, 3846, 3857, 3856
10344, 2670, 2671, 2682, 2681, 6363, 6367, 6411, 6407
10345, 6363, 6367, 6411, 6407, 6364, 6368, 6412, 6408
10346, 6364, 6368, 6412, 6408, 6365, 6369, 6413, 6409
10347, 6365, 6369, 6413, 6409, 6366, 6370, 6414, 6410
10348, 6366, 6370, 6414, 6410, 3846, 3847, 3858, 3857
10349, 2671, 2672, 2683, 2682, 6367, 6371, 6415, 6411
10350, 6367, 6371, 6415, 6411, 6368, 6372, 6416, 6412
10351, 6368, 6372, 6416, 6412, 6369, 6373, 6417, 6413
10352, 6369, 6373, 6417, 6413, 6370, 6374, 6418, 6414
10353, 6370, 6374, 6418, 6414, 3847, 3848, 3859, 3858
10354, 2672, 2673, 2684, 2683, 6371, 6375, 6419, 6415
10355, 6371, 6375, 6419, 6415, 6372, 6376, 6420, 6416
10356, 6372, 6376, 6420, 6416, 6373, 6377, 6421, 6417
10357, 6373, 6377, 6421, 6417, 6374, 6378, 6422, 6418
10358, 6374, 6378, 6422, 6418, 3848, 3849, 3860, 3859
10359, 2673, 2674, 2685, 2684, 6375, 6379, 6423, 6419
10360, 6375, 6379, 6423, 6419, 6376, 6380, 6424, 6420
10361, 6376, 6380, 6424, 6420, 6377, 6381, 6425, 6421
10362, 6377, 6381, 6425, 6421, 6378, 6382, 6426, 6422
10363, 6378, 6382, 6426, 6422, 3849, 3850, 3861, 3860
10364, 2674, 2675, 2686, 2685, 6379, 6383, 6427, 6423
10365, 6379, 6383, 6427, 6423, 6380, 6384, 6428, 6424
10366, 6380, 6384, 6428, 6424, 6381, 6385, 6429, 6425
10367, 6381, 6385, 6429, 6425, 6382, 6386, 6430, 6426
10368, 6382, 6386, 6430, 6426, 3850, 3851, 3862, 3861
10369, 2675, 2676, 2687, 2686, 6383, 6387, 6431, 6427
10370, 6383, 6387, 6431, 6427, 6384, 6388, 6432, 6428
10371, 6384, 6388, 6432, 6428, 6385, 6389, 6433, 6429
10372, 6385, 6389, 6433, 6429, 6386, 6390, 6434, 6430
10373, 6386, 6390, 6434, 6430, 3851, 3852, 3863, 3862
10374, 2676, 612, 613, 2687, 6387, 3822, 3826, 6431
10375, 6387, 3822, 3826, 6431, 6388, 3823, 3827, 6432
10376, 6388, 3823, 3827, 6432, 6389, 3824, 3828, 6433
10377, 6389, 3824, 3828, 6433, 6390, 3825, 3829, 6434
10378, 6390, 3825, 3829, 6434, 3852, 1027, 1028, 3863
10379, 608, 2677, 2688, 609, 3806, 6391, 6435, 3810
10380, 3806, 6391, 6435, 3810, 3807, 6392, 6436, 3811
10381, 3807, 6392, 6436, 3811, 3808, 6393, 6437, 3812
10382, 3808, 6393, 6437, 3812, 3809, 6394, 6438, 3813
10383, 3809, 6394, 6438, 3813, 1023, 3853, 3864, 1024
10384, 2677, 2678, 2689, 2688, 6391, 6395, 6439, 6435
10385, 6391, 6395, 6439, 6435, 6392, 6396, 6440, 6436
10386, 6392, 6396, 6440, 6436, 6393, 6397, 6441, 6437
10387, 6393, 6397, 6441, 6437, 6394, 6398, 6442, 6438
10388, 6394, 6398, 6442, 6438, 3853, 3854, 3865, 3864
10389, 2678, 2679, 2690, 2689, 6395, 6399, 6443, 6439
10390, 6395, 6399, 6443, 6439, 6396, 6400, 6444, 6440
10391, 6396, 6400, 6444, 6440, 6397, 6401, 6445, 6441
10392, 6397, 6401, 6445, 6441, 6398, 6402, 6446, 6442
10393, 6398, 6402, 6446, 6442, 3854, 3855, 3866, 3865
10394, 2679, 2680, 2691, 2690, 6399, 6403, 6447, 6443
10395, 6399, 6403, 6447, 6443, 6400, 6404, 6448, 6444
10396, 6400, 6404, 6448, 6444, 6401, 6405, 6449, 6445
10397, 6401, 6405, 6449, 6445, 6402, 6406, 6450, 6446
10398, 6402, 6406, 6450, 6446, 3855, 3856, 3867, 3866
10399, 2680, 2681, 2692, 2691, 6403, 6407, 6451, 6447
10400, 6403, 6407, 6451, 6447, 6404, 6408, 6452, 6448
10401, 6404, 6408, 6452, 6448, 6405, 6409, 6453, 6449
10402, 6405, 6409, 6453, 6449, 6406, 6410, 6454, 6450
10403, 6406, 6410, 6454, 6450, 3856, 3857, 3868, 3867
10404, 2681, 2682, 2693, 2692, 6407, 6411, 6455, 6451
10405, 6407, 6411, 6455, 6451, 6408, 6412, 6456, 6452
10406, 6408, 6412, 6456, 6452, 6409, 6413, 6457, 6453
10407, 6409, 6413, 6457, 6453, 6410, 6414, 6458, 6454
10408, 6410, 6414, 6458, 6454, 3857, 3858, 3869, 3868
10409, 2682, 2683, 2694, 2693, 6411, 6415, 6459, 6455
10410, 6411, 6415, 6459, 6455, 6412, 6416, 6460, 6456
10411, 6412, 6416, 6460, 6456, 6413, 6417, 6461, 6457
10412, 6413, 6417, 6461, 6457, 6414, 6418, 6462, 6458
10413, 6414, 6418, 6462, 6458, 3858, 3859, 3870, 3869
10414, 2683, 2684, 2695, 2694, 6415, 6419, 6463, 6459
10415, 6415, 6419, 6463, 6459, 6416, 6420, 6464, 6460
10416, 6416, 6420, 6464, 6460, 6417, 6421, 6465, 6461
10417, 6417, 6421, 6465, 6461, 6418, 6422, 6466, 6462
10418, 6418, 6422, 6466, 6462, 3859, 3860, 3871, 3870
10419, 2684, 2685, 2696, 2695, 6419, 6423, 6467, 6463
10420, 6419, 6423, 6467, 6463, 6420, 6424, 6468, 6464
10421, 6420, 6424, 6468, 6464, 6421, 6425, 6469, 6465
10422, 6421, 6425, 6469, 6465, 6422, 6426, 6470, 6466
10423, 6422, 6426, 6470, 6466, 3860, 3861, 3872, 3871
10424, 2685, 2686, 2697, 2696, 6423, 6427, 6471, 6467
10425, 6423, 6427, 6471, 6467, 6424, 6428, 6472, 6468
10426, 6424, 6428, 6472, 6468, 6425, 6429, 6473, 6469
10427, 6425, 6429, 6473, 6469, 6426, 6430, 6474, 6470
10428, 6426, 6430, 6474, 6470, 3861, 3862, 3873, 3872
10429, 2686, 2687, 2698, 2697, 6427, 6431, 6475, 6471
10430, 6427, 6431, 6475, 6471, 6428, 6432, 6476, 6472
10431, 6428, 6432, 6476, 6472, 6429, 6433, 6477, 6473
10432, 6429, 6433, 6477, 6473, 6430, 6434, 6478, 6474
10433, 6430, 6434, 6478, 6474, 3862, 3863, 3874, 3873
10434, 2687, 613, 614, 2698, 6431, 3826, 3830, 6475
10435, 6431, 3826, 3830, 6475, 6432, 3827, 3831, 6476
10436, 6432, 3827, 3831, 6476, 6433, 3828, 3832, 6477
10437, 6433, 3828, 3832, 6477, 6434, 3829, 3833, 6478
10438, 6434, 3829, 3833, 6478, 3863, 1028, 1029, 3874
10439, 609, 2688, 2699, 610, 3810, 6435, 6479, 3814
10440, 3810, 6435, 6479, 3814, 3811, 6436, 6480, 3815
10441, 3811, 6436, 6480, 3815, 3812, 6437, 6481, 3816
10442, 3812, 6437, 6481, 3816, 3813, 6438, 6482, 3817
10443, 3813, 6438, 6482, 3817, 1024, 3864, 3875, 1025
10444, 2688, 2689, 2700, 2699, 6435, 6439, 6483, 6479
10445, 6435, 6439, 6483, 6479, 6436, 6440, 6484, 6480
10446, 6436, 6440, 6484, 6480, 6437, 6441, 6485, 6481
10447, 6437, 6441, 6485, 6481, 6438, 6442, 6486, 6482
10448, 6438, 6442, 6486, 6482, 3864, 3865, 3876, 3875
10449, 2689, 2690, 2701, 2700, 6439, 6443, 6487, 6483
10450, 6439, 6443, 6487, 6483, 6440, 6444, 6488, 6484
10451, 6440, 6444, 6488, 6484, 6441, 6445, 6489, 6485
10452, 6441, 6445, 6489, 6485, 6442, 6446, 6490, 6486
10453, 6442, 6446, 6490, 6486, 3865, 3866, 3877, 3876
10454, 2690, 2691, 2702, 2701, 6443, 6447, 6491, 6487
10455, 6443, 6447, 6491, 6487, 6444, 6448, 6492, 6488
10456, 6444, 6448, 6492, 6488, 6445, 6449, 6493, 6489
10457, 6445, 6449, 6493, 6489, 6446, 6450, 6494, 6490
10458, 6446, 6450, 6494, 6490, 3866, 3867, 3878, 3877
10459, 2691, 2692, 2703, 2702, 6447, 6451, 6495, 6491
10460, 6447, 6451, 6495, 6491, 6448, 6452, 6496, 6492
10461, 6448, 6452, 6496, 6492, 6449, 6453, 6497, 6493
10462, 6449, 6453, 6497, 6493, 6450, 6454, 6498, 6494
10463, 6450, 6454, 6498, 6494, 3867, 3868, 3879, 3878
10464, 2692, 2693, 2704, 2703, 6451, 6455, 6499, 6495
10465, 6451, 6455, 6499, 6495, 6452, 6456, 6500, 6496
10466, 6452, 6456, 6500, 6496, 6453, 6457, 6501, 6497
10467, 6453, 6457, 6501, 6497, 6454, 6458, 6502, 6498
10468, 6454, 6458, 6502, 6498, 3868, 3869, 3880, 3879
10469, 2693, 2694, 2705, 2704, 6455, 6459, 6503, 6499
10470, 6455, 6459, 6503, 6499, 6456, 6460, 6504, 6500
10471, 6456, 6460, 6504, 6500, 6457, 6461, 6505, 6501
10472, 6457, 6461, 6505, 6501, 6458, 6462, 6506, 6502
10473, 6458, 6462, 6506, 6502, 3869, 3870, 3881, 3880
10474, 2694, 2695, 2706, 2705, 6459, 6463, 6507, 6503
10475, 6459, 6463, 6507, 6503, 6460, 6464, 6508, 6504
10476, 6460, 6464, 6508, 6504, 6461, 6465, 6509, 6505
10477, 6461, 6465, 6509, 6505, 6462, 6466, 6510, 6506
10478, 6462, 6466, 6510, 6506, 3870, 3871, 3882, 3881
10479, 2695, 2696, 2707, 2706, 6463, 6467, 6511, 6507
10480, 6463, 6467, 6511, 6507, 6464, 6468, 6512, 6508
10481, 6464, 6468, 6512, 6508, 6465, 6469, 6513, 6509
10482, 6465, 6469, 6513, 6509, 6466, 6470, 6514, 6510
10483, 6466, 6470, 6514, 6510, 3871, 3872, 3883, 3882
10484, 2696, 2697, 2708, 2707, 6467, 6471, 6515, 6511
10485, 6467, 6471, 6515, 6511, 6468, 6472, 6516, 6512
10486, 6468, 6472, 6516, 6512, 6469, 6473, 6517, 6513
10487, 6469, 6473, 6517, 6513, 6470, 6474, 6518, 6514
10488, 6470, 6474, 6518, 6514, 3872, 3873, 3884, 3883
10489, 2697, 2698, 2709, 2708, 6471, 6475, 6519, 6515
10490, 6471, 6475, 6519, 6515, 6472, 6476, 6520, 6516
10491, 6472, 6476, 6520, 6516, 6473, 6477, 6521, 6517
10492, 6473, 6477, 6521, 6517, 6474, 6478, 6522, 6518
10493, 6474, 6478, 6522, 6518, 3873, 3874, 3885, 3884
10494, 2698, 614, 615, 2709, 6475, 3830, 3834, 6519
10495, 6475, 3830, 3834, 6519, 6476, 3831, 3835, 6520
10496, 6476, 3831, 3835, 6520, 6477, 3832, 3836, 6521
10497, 6477, 3832, 3836, 6521, 6478, 3833, 3837, 6522
10498, 6478, 3833, 3837, 6522, 3874, 1029, 1030, 3885
10499, 610, 2699, 2710, 611, 3814, 6479, 6523, 3818
10500, 3814, 6479, 6523, 3818, 3815, 6480, 6524, 3819
10501, 3815, 6480, 6524, 3819, 3816, 6481, 6525, 3820
10502, 3816, 6481, 6525, 3820, 3817, 6482, 6526, 3821
10503, 3817, 6482, 6526, 3821, 1025, 3875, 3886, 1026
10504, 2699, 2700, 2711, 2710, 6479, 6483, 6527, 6523
10505, 6479, 6483, 6527, 6523, 6480, 6484, 6528, 6524
10506, 6480, 6484, 6528, 6524, 6481, 6485, 6529, 6525
10507, 6481, 6485, 6529, 6525, 6482, 6486, 6530, 6526
10508, 6482, 6486, 6530, 6526, 3875, 3876, 3887, 3886
10509, 2700, 2701, 2712, 2711, 6483, 6487, 6531, 6527
10510, 6483, 6487, 6531, 6527, 6484, 6488, 6532, 6528
10511, 6484, 6488, 6532, 6528, 6485, 6489, 6533, 6529
10512, 6485, 6489, 6533, 6529, 6486, 6490, 6534, 6530
10513, 6486, 6490, 6534, 6530, 3876, 3877, 3888, 3887
10514, 2701, 2702, 2713, 2712, 6487, 6491, 6535, 6531
10515, 6487, 6491, 6535, 6531, 6488, 6492, 6536, 6532
10516, 6488, 6492, 6536, 6532, 6489, 6493, 6537, 6533
10517, 6489, 6493, 6537, 6533, 6490, 6494, 6538, 6534
10518, 6490, 6494, 6538, 6534, 3877, 3878, 3889, 3888
10519, 2702, 2703, 2714, 2713, 6491, 6495, 6539, 6535
10520, 6491, 6495, 6539, 6535, 6492, 6496, 6540, 6536
10521, 6492, 6496, 6540, 6536, 6493, 6497, 6541, 6537
10522, 6493, 6497, 6541, 6537, 6494, 6498, 6542, 6538
10523, 6494, 6498, 6542, 6538, 3878, 3879, 3890, 3889
10524, 2703, 2704, 2715, 2714, 6495, 6499, 6543, 6539
10525, 6495, 6499, 6543, 6539, 6496, 6500, 6544, 6540
10526, 6496, 6500, 6544, 6540, 6497, 6501, 6545, 6541
10527, 6497, 6501, 6545, 6541, 6498, 6502, 6546, 6542
10528, 6498, 6502, 6546, 6542, 3879, 3880, 3891, 3890
10529, 2704, 2705, 2716, 2715, 6499, 6503, 6547, 6543
10530, 6499, 6503, 6547, 6543, 6500, 6504, 6548, 6544
10531, 6500, 6504, 6548, 6544, 6501, 6505, 6549, 6545
10532, 6501, 6505, 6549, 6545, 6502, 6506, 6550, 6546
10533, 6502, 6506, 6550, 6546, 3880, 3881, 3892, 3891
10534, 2705, 2706, 2717, 2716, 6503, 6507, 6551, 6547
10535, 6503, 6507, 6551, 6547, 6504, 6508, 6552, 6548
10536, 6504, 6508, 6552, 6548, 6505, 6509, 6553, 6549
10537, 6505, 6509, 6553, 6549, 6506, 6510, 6554, 6550
10538, 6506, 6510, 6554, 6550, 3881, 3882, 3893, 3892
10539, 2706, 2707, 2718, 2717, 6507, 6511, 6555, 6551
10540, 6507, 6511, 6555, 6551, 6508, 6512, 6556, 6552
10541, 6508, 6512, 6556, 6552, 6509, 6513, 6557, 6553
10542, 6509, 6513, 6557, 6553, 6510, 6514, 6558, 6554
10543, 6510, 6514, 6558, 6554, 3882, 3883, 3894, 3893
10544, 2707, 2708, 2719, 2718, 6511, 6515, 6559, 6555
10545, 6511, 6515, 6559, 6555, 6512, 6516, 6560, 6556
10546, 6512, 6516, 6560, 6556, 6513, 6517, 6561, 6557
10547, 6513, 6517, 6561, 6557, 6514, 6518, 6562, 6558
10548, 6514, 6518, 6562, 6558, 3883, 3884, 3895, 3894
10549, 2708, 2709, 2720, 2719, 6515, 6519, 6563, 6559
10550, 6515, 6519, 6563, 6559, 6516, 6520, 6564, 6560
10551, 6516, 6520, 6564, 6560, 6517, 6521, 6565, 6561
10552, 6517, 6521, 6565, 6561, 6518, 6522, 6566, 6562
10553, 6518, 6522, 6566, 6562, 3884, 3885, 3896, 3895
10554, 2709, 615, 616, 2720, 6519, 3834, 3838, 6563
10555, 6519, 3834, 3838, 6563, 6520, 3835, 3839, 6564
10556, 6520, 3835, 3839, 6564, 6521, 3836, 3840, 6565
10557, 6521, 3836, 3840, 6565, 6522, 3837, 3841, 6566
10558, 6522, 3837, 3841, 6566, 3885, 1030, 1031, 3896
10559, 611, 2710, 581, 45, 3818, 6523, 3714, 984
10560, 3818, 6523, 3714, 984, 3819, 6524, 3715, 985
10561, 3819, 6524, 3715, 985, 3820, 6525, 3716, 986
10562, 3820, 6525, 3716, 986, 3821, 6526, 3717, 987
10563, 3821, 6526, 3717, 987, 1026, 3886, 992, 91
10564, 2710, 2711, 582, 581, 6523, 6527, 3718, 3714
10565, 6523, 6527, 3718, 3714, 6524, 6528, 3719, 3715
10566, 6524, 6528, 3719, 3715, 6525, 6529, 3720, 3716
10567, 6525, 6529, 3720, 3716, 6526, 6530, 3721, 3717
10568, 6526, 6530, 3721, 3717, 3886, 3887, 993, 992
10569, 2711, 2712, 583, 582, 6527, 6531, 3722, 3718
10570, 6527, 6531, 3722, 3718, 6528, 6532, 3723, 3719
10571, 6528, 6532, 3723, 3719, 6529, 6533, 3724, 3720
10572, 6529, 6533, 3724, 3720, 6530, 6534, 3725, 3721
10573, 6530, 6534, 3725, 3721, 3887, 3888, 994, 993
10574, 2712, 2713, 584, 583, 6531, 6535, 3726, 3722
10575, 6531, 6535, 3726, 3722, 6532, 6536, 3727, 3723
10576, 6532, 6536, 3727, 3723, 6533, 6537, 3728, 3724
10577, 6533, 6537, 3728, 3724, 6534, 6538, 3729, 3725
10578, 6534, 6538, 3729, 3725, 3888, 3889, 995, 994
10579, 2713, 2714, 585, 584, 6535, 6539, 3730, 3726
10580, 6535, 6539, 3730, 3726, 6536, 6540, 3731, 3727
10581, 6536, 6540, 3731, 3727, 6537, 6541, 3732, 3728
10582, 6537, 6541, 3732, 3728, 6538, 6542, 3733, 3729
10583, 6538, 6542, 3733, 3729, 3889, 3890, 996, 995
10584, 2714, 2715, 586, 585, 6539, 6543, 3734, 3730
10585, 6539, 6543, 3734, 3730, 6540, 6544, 3735, 3731
10586, 6540, 6544, 3735, 3731, 6541, 6545, 3736, 3732
10587, 6541, 6545, 3736, 3732, 6542, 6546, 3737, 3733
10588, 6542, 6546, 3737, 3733, 3890, 3891, 997, 996
10589, 2715, 2716, 587, 586, 6543, 6547, 3738, 3734
10590, 6543, 6547, 3738, 3734, 6544, 6548, 3739, 3735
10591, 6544, 6548, 3739, 3735, 6545, 6549, 3740, 3736
10592, 6545, 6549, 3740, 3736, 6546, 6550, 3741, 3737
10593, 6546, 6550, 3741, 3737, 3891, 3892, 998, 997
10594, 2716, 2717, 588, 587, 6547, 6551, 3742, 3738
10595, 6547, 6551, 3742, 3738, 6548, 6552, 3743, 3739
10596, 6548, 6552, 3743, 3739, 6549, 6553, 3744, 3740
10597, 6549, 6553, 3744, 3740, 6550, 6554, 3745, 3741
10598, 6550, 6554, 3745, 3741, 3892, 3893, 999, 998
10599, 2717, 2718, 589, 588, 6551, 6555, 3746, 3742
10600, 6551, 6555, 3746, 3742, 6552, 6556, 3747, 3743
10601, 6552, 6556, 3747, 3743, 6553, 6557, 3748, 3744
10602, 6553, 6557, 3748, 3744, 6554, 6558, 3749, 3745
10603, 6554, 6558, 3749, 3745, 3893, 3894, 1000, 999
10604, 2718, 2719, 590, 589, 6555, 6559, 3750, 3746
10605, 6555, 6559, 3750, 3746, 6556, 6560, 3751, 3747
10606, 6556, 6560, 3751, 3747, 6557, 6561, 3752, 3748
10607, 6557, 6561, 3752, 3748, 6558, 6562, 3753, 3749
10608, 6558, 6562, 3753, 3749, 3894, 3895, 1001, 1000
10609, 2719, 2720, 591, 590, 6559, 6563, 3754, 3750
10610, 6559, 6563, 3754, 3750, 6560, 6564, 3755, 3751
10611, 6560, 6564, 3755, 3751, 6561, 6565, 3756, 3752
10612, 6561, 6565, 3756, 3752, 6562, 6566, 3757, 3753
10613, 6562, 6566, 3757, 3753, 3895, 3896, 1002, 1001
10614, 2720, 616, 46, 591, 6563, 3838, 988, 3754
10615, 6563, 3838, 988, 3754, 6564, 3839, 989, 3755
10616, 6564, 3839, 989, 3755, 6565, 3840, 990, 3756
10617, 6565, 3840, 990, 3756, 6566, 3841, 991, 3757
10618, 6566, 3841, 991, 3757, 3896, 1031, 92, 1002
*ELEMENT, type=C3D8, ELSET=Volume26
10619, 48, 52, 626, 612, 1007, 1036, 3897, 3822
10620, 1007, 1036, 3897, 3822, 1008, 1037, 3898, 3823
10621, 1008, 1037, 3898, 3823, 1009, 1038, 3899, 3824
10622, 1009, 1038, 3899, 3824, 1010, 1039, 3900, 3825
10623, 1010, 1039, 3900, 3825, 94, 96, 1040, 1027
10624, 612, 626, 627, 613, 3822, 3897, 3901, 3826
10625, 3822, 3897, 3901, 3826, 3823, 3898, 3902, 3827
10626, 3823, 3898, 3902, 3827, 3824, 3899, 3903, 3828
10627, 3824, 3899, 3903, 3828, 3825, 3900, 3904, 3829
10628, 3825, 3900, 3904, 3829, 1027, 1040, 1041, 1028
10629, 613, 627, 628, 614, 3826, 3901, 3905, 3830
10630, 3826, 3901, 3905, 3830, 3827, 3902, 3906, 3831
10631, 3827, 3902, 3906, 3831, 3828, 3903, 3907, 3832
10632, 3828, 3903, 3907, 3832, 3829, 3904, 3908, 3833
10633, 3829, 3904, 3908, 3833, 1028, 1041, 1042, 1029
10634, 614, 628, 629, 615, 3830, 3905, 3909, 3834
10635, 3830, 3905, 3909, 3834, 3831, 3906, 3910, 3835
10636, 3831, 3906, 3910, 3835, 3832, 3907, 3911, 3836
10637, 3832, 3907, 3911, 3836, 3833, 3908, 3912, 3837
10638, 3833, 3908, 3912, 3837, 1029, 1042, 1043, 1030
10639, 615, 629, 630, 616, 3834, 3909, 3913, 3838
10640, 3834, 3909, 3913, 3838, 3835, 3910, 3914, 3839
10641, 3835, 3910, 3914, 3839, 3836, 3911, 3915, 3840
10642, 3836, 3911, 3915, 3840, 3837, 3912, 3916, 3841
10643, 3837, 3912, 3916, 3841, 1030, 1043, 1044, 1031
10644, 616, 630, 50, 46, 3838, 3913, 1032, 988
10645, 3838, 3913, 1032, 988, 3839, 3914, 1033, 989
10646, 3839, 3914, 1033, 989, 3840, 3915, 1034, 990
10647, 3840, 3915, 1034, 990, 3841, 3916, 1035, 991
10648, 3841, 3916, 1035, 991, 1031, 1044, 95, 92
*ELSET,ELSET=Qin
2319, 2320, 2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 
2329, 2330, 2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 
2339, 2340, 2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 
2349, 2350, 2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 
2359, 2360, 2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 
2369, 2370, 2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 
2379, 2380, 2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 
2389, 2390, 2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 
2459, 2460, 2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 
2469, 2470, 2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 
2479, 2480, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 2650, 
2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 2660, 
2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 2670, 
2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 2680, 
2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 2690, 
2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 2700, 
2701, 2702, 2703, 2704, 2705, 2706, 2707, 2708, 2709, 2710, 
2711, 2712, 2713, 2714, 
*ELSET,ELSET=HeatSink
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 3561, 3562, 3563, 3564, 3565, 3566, 3567, 3568, 
3569, 3570, 3571, 3572, 3573, 3574, 3575, 3576, 3577, 3578, 
3579, 3580, 3581, 3582, 3583, 3584, 3585, 3586, 3587, 3588, 
3589, 3590, 3591, 3592, 3593, 3594, 3595, 3596, 3597, 3598, 
3599, 3600, 3601, 3602, 3603, 3604, 3605, 3606, 3607, 3608, 
3609, 3610, 3611, 3612, 3613, 3614, 3615, 3616, 3617, 3618, 
3619, 3620, 3621, 3622, 3623, 3624, 3625, 3626, 3627, 3628, 
3629, 3630, 3631, 3632, 
*ELSET,ELSET=ElectrodeMaxX
3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 3659, 3660, 
3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 
*ELSET,ELSET=ElectrodeMinX
3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 3696, 
3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 
*ELSET,ELSET=Force
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 
*ELSET,ELSET=Ceramic_Top
4537, 4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 
4547, 4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 
4557, 4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 
4567, 4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 
4577, 4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 
4587, 4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 
4597, 4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 
4607, 4608, 4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 
4697, 4698, 4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 
4707, 4708, 4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 
4717, 4718, 4869, 4870, 4871, 4872, 4873, 4874, 4875, 4876, 
4877, 4878, 4879, 4880, 4881, 4882, 4883, 4884, 4885, 4886, 
4887, 4888, 4889, 4890, 4891, 4892, 4893, 4894, 4895, 4896, 
4897, 4898, 4899, 4900, 4901, 4902, 4903, 4904, 4905, 4906, 
4907, 4908, 4909, 4910, 4911, 4912, 4913, 4914, 4915, 4916, 
4917, 4918, 4919, 4920, 4921, 4922, 4923, 4924, 4925, 4926, 
4927, 4928, 4929, 4930, 4931, 4932, 4933, 4934, 4935, 4936, 
4937, 4938, 4939, 4940, 
*ELSET,ELSET=Ceramic_Bottom
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 5121, 5122, 5123, 5124, 5125, 
5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 5134, 5135, 
5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 5144, 5145, 
5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 5154, 5155, 
5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 5164, 5165, 
5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 5174, 5175, 
5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 5184, 5185, 
5186, 5187, 5188, 5189, 5190, 5191, 5192, 5419, 5420, 5421, 
5422, 5423, 5424, 5425, 5426, 5427, 5428, 5429, 5430, 5431, 
5432, 5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 5441, 
5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 5451, 
5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 5461, 
5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 5471, 
5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 5481, 
5482, 5483, 5484, 5485, 5486, 5487, 5488, 5489, 5490, 
*ELSET,ELSET=Top_Semiconductors
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2769, 2770, 2771, 2772, 2773, 2774, 2775, 2776, 
2777, 2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 2786, 
2787, 2788, 2789, 2790, 2791, 2792, 2793, 2794, 2795, 2796, 
2797, 2798, 2799, 2800, 2801, 2802, 2803, 2804, 2805, 2806, 
2807, 2808, 2809, 2810, 2811, 2812, 2813, 2814, 2815, 2816, 
2817, 2818, 2819, 2820, 2821, 2822, 2823, 2824, 2825, 2826, 
2827, 2828, 2829, 2830, 2831, 2832, 2833, 2834, 2835, 2836, 
2837, 2838, 2839, 2840, 
*ELSET,ELSET=top
4537, 4538, 4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 
4547, 4548, 4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 
4557, 4558, 4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 
4567, 4568, 4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 
4577, 4578, 4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 
4587, 4588, 4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 
4597, 4598, 4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 
4607, 4608, 4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 
4697, 4698, 4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 
4707, 4708, 4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 
4717, 4718, 4869, 4870, 4871, 4872, 4873, 4874, 4875, 4876, 
4877, 4878, 4879, 4880, 4881, 4882, 4883, 4884, 4885, 4886, 
4887, 4888, 4889, 4890, 4891, 4892, 4893, 4894, 4895, 4896, 
4897, 4898, 4899, 4900, 4901, 4902, 4903, 4904, 4905, 4906, 
4907, 4908, 4909, 4910, 4911, 4912, 4913, 4914, 4915, 4916, 
4917, 4918, 4919, 4920, 4921, 4922, 4923, 4924, 4925, 4926, 
4927, 4928, 4929, 4930, 4931, 4932, 4933, 4934, 4935, 4936, 
4937, 4938, 4939, 4940, 
*ELSET,ELSET=bottom
5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 5129, 5130, 
5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 5139, 5140, 
5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 5149, 5150, 
5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 5159, 5160, 
5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 5169, 5170, 
5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 5179, 5180, 
5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 5189, 5190, 
5191, 5192, 5233, 5234, 5235, 5236, 5237, 5238, 5419, 5420, 
5421, 5422, 5423, 5424, 5425, 5426, 5427, 5428, 5429, 5430, 
5431, 5432, 5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 
5441, 5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 
5451, 5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 
5461, 5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 
5471, 5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 
5481, 5482, 5483, 5484, 5485, 5486, 5487, 5488, 5489, 5490, 
5531, 5532, 5533, 5534, 5535, 5536, 
*ELSET,ELSET=Copper
5537, 5538, 5539, 5540, 5541, 5542, 5543, 5544, 5545, 5546, 
5547, 5548, 5549, 5550, 5551, 5552, 5553, 5554, 5555, 5556, 
5557, 5558, 5559, 5560, 5561, 5562, 5563, 5564, 5565, 5566, 
5567, 5568, 5569, 5570, 5571, 5572, 5573, 5574, 5575, 5576, 
5577, 5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 5586, 
5587, 5588, 5589, 5590, 5591, 5592, 5593, 5594, 5595, 5596, 
5597, 5598, 5599, 5600, 5601, 5602, 5603, 5604, 5605, 5606, 
5607, 5608, 5609, 5610, 5611, 5612, 5613, 5614, 5615, 5616, 
5617, 5618, 5619, 5620, 5621, 5622, 5623, 5624, 5625, 5626, 
5627, 5628, 5629, 5630, 5631, 5632, 5633, 5634, 5635, 5636, 
5637, 5638, 5639, 5640, 5641, 5642, 5643, 5644, 5645, 5646, 
5647, 5648, 5649, 5650, 5651, 5652, 5653, 5654, 5655, 5656, 
5657, 5658, 5659, 5660, 5661, 5662, 5663, 5664, 5665, 5666, 
5667, 5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 5676, 
5677, 5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 5686, 
5687, 5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 5696, 
5697, 5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 5706, 
5707, 5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 5716, 
5717, 5718, 5719, 5720, 5721, 5722, 5723, 5724, 5725, 5726, 
5727, 5728, 5729, 5730, 5731, 5732, 5733, 5734, 5735, 5736, 
5737, 5738, 5739, 5740, 5741, 5742, 5743, 5744, 5745, 5746, 
5747, 5748, 5749, 5750, 5751, 5752, 6761, 6762, 6763, 6764, 
6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 6773, 6774, 
6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 6783, 6784, 
6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 6793, 6794, 
6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 6803, 6804, 
6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 6813, 6814, 
6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 
6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 
6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 
6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 
6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 
6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 
6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 
6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 
6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 
6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 
6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 
6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 
6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 
6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 
6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 
6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 
6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 
6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 
6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 
7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 
7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 
7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 
7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 
7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 
7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 
7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 
7075, 7076, 7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 
7085, 7086, 7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 
7095, 7096, 7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 
7105, 7106, 7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 
7115, 7116, 7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 
7125, 7126, 7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 
7135, 7136, 7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 
7145, 7146, 7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 
7155, 7156, 7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 
7165, 7166, 7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 
7175, 7176, 7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 
7185, 7186, 7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 
7195, 7196, 7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 
7205, 7206, 7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 
7215, 7216, 7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 
7225, 7226, 7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 
7235, 7236, 7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 
7245, 7246, 7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 
7255, 7256, 7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 
7265, 7266, 7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 
7275, 7276, 7277, 7278, 7279, 7280, 7281, 7282, 8291, 8292, 
8293, 8294, 8295, 8296, 8297, 8298, 8299, 8300, 8301, 8302, 
8303, 8304, 8305, 8306, 8307, 8308, 8309, 8310, 8311, 8312, 
8313, 8314, 8315, 8316, 8317, 8318, 8319, 8320, 8321, 8322, 
8323, 8324, 8325, 8326, 8327, 8328, 8329, 8330, 8331, 8332, 
8333, 8334, 8335, 8336, 8337, 8338, 8339, 8340, 8341, 8342, 
8343, 8344, 8345, 8346, 8347, 8348, 8349, 8350, 8351, 8352, 
8353, 8354, 8355, 8356, 8357, 8358, 8359, 8360, 8361, 8362, 
8363, 8364, 8365, 8366, 8367, 8368, 8369, 8370, 8371, 8372, 
8373, 8374, 8375, 8376, 8377, 8378, 8379, 8380, 8381, 8382, 
8383, 8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 8392, 
8393, 8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 8402, 
8403, 8404, 8405, 8406, 8407, 8408, 8409, 8410, 8411, 8412, 
8413, 8414, 8415, 8416, 8417, 8418, 8419, 8420, 8421, 8422, 
8423, 8424, 8425, 8426, 8427, 8428, 8429, 8430, 8431, 8432, 
8433, 8434, 8435, 8436, 8437, 8438, 8439, 8440, 8441, 8442, 
8443, 8444, 8445, 8446, 8447, 8448, 8449, 8450, 8451, 8452, 
8453, 8454, 8455, 8456, 8457, 8458, 8459, 8460, 8461, 8462, 
8463, 8464, 8465, 8466, 8467, 8468, 8469, 8470, 8471, 8472, 
8473, 8474, 8475, 8476, 8477, 8478, 8479, 8480, 8481, 8482, 
8483, 8484, 8485, 8486, 8487, 8488, 8489, 8490, 8491, 8492, 
8493, 8494, 8495, 8496, 8497, 8498, 8499, 8500, 8501, 8502, 
8503, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 8511, 8512, 
8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 8521, 8522, 
8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 8531, 8532, 
8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 8541, 8542, 
*ELSET,ELSET=SemiconductorN-
5825, 5826, 5827, 5828, 5829, 5830, 5831, 5832, 5833, 5834, 
5835, 5836, 5837, 5838, 5839, 5840, 5841, 5842, 5843, 5844, 
5845, 5846, 5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 
5855, 5856, 5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 
5865, 5866, 5867, 5868, 5869, 5870, 5871, 5872, 5873, 5874, 
5875, 5876, 5877, 5878, 5879, 5880, 5881, 5882, 5883, 5884, 
5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 
5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 
5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 
5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 
5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 5933, 5934, 
5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 5943, 5944, 
5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 5953, 5954, 
5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 5963, 5964, 
5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 5973, 5974, 
5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 5983, 5984, 
5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 5993, 5994, 
5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 6003, 6004, 
6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 6013, 6014, 
6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 6023, 6024, 
6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 6033, 6034, 
6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 6043, 6044, 
6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 6053, 6054, 
6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 6063, 6064, 
6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 6073, 6074, 
6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 6083, 6084, 
6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 6093, 6094, 
6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 6103, 6104, 
6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 6113, 6114, 
6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 6123, 6124, 
6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 6133, 6134, 
6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 6143, 6144, 
6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 6153, 6154, 
6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 6163, 6164, 
6165, 6166, 6167, 6168, 6169, 6170, 6171, 6172, 6173, 6174, 
6175, 6176, 6177, 6178, 6179, 6180, 6181, 6182, 6183, 6184, 
6185, 6186, 6187, 6188, 6189, 6190, 6191, 6192, 6193, 6194, 
6195, 6196, 6197, 6198, 6199, 6200, 6201, 6202, 6203, 6204, 
6205, 6206, 6207, 6208, 6209, 6210, 6211, 6212, 6213, 6214, 
6215, 6216, 6217, 6218, 6219, 6220, 6221, 6222, 6223, 6224, 
6225, 6226, 6227, 6228, 6229, 6230, 6231, 6232, 6233, 6234, 
6235, 6236, 6237, 6238, 6239, 6240, 6241, 6242, 6243, 6244, 
6245, 6246, 6247, 6248, 6249, 6250, 6251, 6252, 6253, 6254, 
6255, 6256, 6257, 6258, 6259, 6260, 6261, 6262, 6263, 6264, 
6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 6273, 6274, 
6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 6283, 6284, 
6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 6293, 6294, 
6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 6303, 6304, 
6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 6313, 6314, 
6315, 6316, 6317, 6318, 6319, 6320, 6321, 6322, 6323, 6324, 
6325, 6326, 6327, 6328, 6329, 6330, 6331, 6332, 6333, 6334, 
6335, 6336, 6337, 6338, 6339, 6340, 6341, 6342, 6343, 6344, 
6345, 6346, 6347, 6348, 6349, 6350, 6351, 6352, 6353, 6354, 
6355, 6356, 6357, 6358, 6359, 6360, 6361, 6362, 6363, 6364, 
6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 6373, 6374, 
6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 6383, 6384, 
6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 6393, 6394, 
6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 6403, 6404, 
6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 6413, 6414, 
6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 6423, 6424, 
6425, 6426, 6427, 6428, 6429, 6430, 6431, 6432, 6433, 6434, 
6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 6443, 6444, 
6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 6453, 6454, 
6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 6463, 6464, 
6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 6473, 6474, 
6475, 6476, 6477, 6478, 6479, 6480, 6481, 6482, 6483, 6484, 
6485, 6486, 6487, 6488, 6489, 6490, 6491, 6492, 6493, 6494, 
6495, 6496, 6497, 6498, 6499, 6500, 6501, 6502, 6503, 6504, 
6505, 6506, 6507, 6508, 6509, 6510, 6511, 6512, 6513, 6514, 
6515, 6516, 6517, 6518, 6519, 6520, 6521, 6522, 6523, 6524, 
6525, 6526, 6527, 6528, 6529, 6530, 6531, 6532, 6533, 6534, 
6535, 6536, 6537, 6538, 6539, 6540, 6541, 6542, 6543, 6544, 
6545, 6546, 6547, 6548, 6549, 6550, 6551, 6552, 6553, 6554, 
6555, 6556, 6557, 6558, 6559, 6560, 6561, 6562, 6563, 6564, 
6565, 6566, 6567, 6568, 6569, 6570, 6571, 6572, 6573, 6574, 
6575, 6576, 6577, 6578, 6579, 6580, 6581, 6582, 6583, 6584, 
6585, 6586, 6587, 6588, 6589, 6590, 6591, 6592, 6593, 6594, 
6595, 6596, 6597, 6598, 6599, 6600, 6601, 6602, 6603, 6604, 
6605, 6606, 6607, 6608, 6609, 6610, 6611, 6612, 6613, 6614, 
6615, 6616, 6617, 6618, 6619, 6620, 6621, 6622, 6623, 6624, 
6625, 6626, 6627, 6628, 6629, 6630, 6631, 6632, 6633, 6634, 
6635, 6636, 6637, 6638, 6639, 6640, 6641, 6642, 6643, 6644, 
6645, 6646, 6647, 6648, 6649, 6650, 6651, 6652, 6653, 6654, 
6655, 6656, 6657, 6658, 6659, 6660, 6661, 6662, 6663, 6664, 
6665, 6666, 6667, 6668, 6669, 6670, 6671, 6672, 6673, 6674, 
6675, 6676, 6677, 6678, 6679, 6680, 6681, 6682, 6683, 6684, 
6685, 6686, 6687, 6688, 8543, 8544, 8545, 8546, 8547, 8548, 
8549, 8550, 8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 
8559, 8560, 8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 
8569, 8570, 8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 
8579, 8580, 8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 
8589, 8590, 8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 
8599, 8600, 8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 
8609, 8610, 8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 
8619, 8620, 8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 
8629, 8630, 8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 
8639, 8640, 8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 
8649, 8650, 8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 
8659, 8660, 8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 
8669, 8670, 8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 
8679, 8680, 8681, 8682, 8683, 8684, 8685, 8686, 8831, 8832, 
8833, 8834, 8835, 8836, 8837, 8838, 8839, 8840, 8841, 8842, 
8843, 8844, 8845, 8846, 8847, 8848, 8849, 8850, 8851, 8852, 
8853, 8854, 8855, 8856, 8857, 8858, 8859, 8860, 8861, 8862, 
8863, 8864, 8865, 8866, 8867, 8868, 8869, 8870, 8871, 8872, 
8873, 8874, 8875, 8876, 8877, 8878, 8879, 8880, 8881, 8882, 
8883, 8884, 8885, 8886, 8887, 8888, 8889, 8890, 8891, 8892, 
8893, 8894, 8895, 8896, 8897, 8898, 8899, 8900, 8901, 8902, 
8987, 8988, 8989, 8990, 8991, 8992, 8993, 8994, 8995, 8996, 
8997, 8998, 
*ELSET,ELSET=SemiconductorP+
7355, 7356, 7357, 7358, 7359, 7360, 7361, 7362, 7363, 7364, 
7365, 7366, 7367, 7368, 7369, 7370, 7371, 7372, 7373, 7374, 
7375, 7376, 7377, 7378, 7379, 7380, 7381, 7382, 7383, 7384, 
7385, 7386, 7387, 7388, 7389, 7390, 7391, 7392, 7393, 7394, 
7395, 7396, 7397, 7398, 7399, 7400, 7401, 7402, 7403, 7404, 
7405, 7406, 7407, 7408, 7409, 7410, 7411, 7412, 7413, 7414, 
7415, 7416, 7417, 7418, 7419, 7420, 7421, 7422, 7423, 7424, 
7425, 7426, 7427, 7428, 7429, 7430, 7431, 7432, 7433, 7434, 
7435, 7436, 7437, 7438, 7439, 7440, 7441, 7442, 7443, 7444, 
7445, 7446, 7447, 7448, 7449, 7450, 7451, 7452, 7453, 7454, 
7455, 7456, 7457, 7458, 7459, 7460, 7461, 7462, 7463, 7464, 
7465, 7466, 7467, 7468, 7469, 7470, 7471, 7472, 7473, 7474, 
7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 7483, 7484, 
7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 7494, 
7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 7503, 7504, 
7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 7513, 7514, 
7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 7524, 
7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 7533, 7534, 
7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 7544, 
7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 7554, 
7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 7563, 7564, 
7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 7574, 
7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 7583, 7584, 
7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 7593, 7594, 
7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 7604, 
7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 7613, 7614, 
7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 7624, 
7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 7634, 
7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 7643, 7644, 
7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 7654, 
7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 7663, 7664, 
7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 7673, 7674, 
7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 7684, 
7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 7693, 7694, 
7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 7704, 
7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 7714, 
7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 7723, 7724, 
7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 7734, 
7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 7743, 7744, 
7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 7753, 7754, 
7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 7764, 
7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 7773, 7774, 
7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 7784, 
7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 7794, 
7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 7803, 7804, 
7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 7814, 
7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 7823, 7824, 
7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 7833, 7834, 
7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 7844, 
7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 7853, 7854, 
7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 7864, 
7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 7874, 
7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 7883, 7884, 
7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 7894, 
7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 7903, 7904, 
7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 7913, 7914, 
7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 7924, 
7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 7933, 7934, 
7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 7944, 
7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 7954, 
7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 7963, 7964, 
7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 7974, 
7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 7983, 7984, 
7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 7993, 7994, 
7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 8004, 
8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 8013, 8014, 
8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 8024, 
8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 8034, 
8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 8043, 8044, 
8045, 8046, 8047, 8048, 8049, 8050, 8051, 8052, 8053, 8054, 
8055, 8056, 8057, 8058, 8059, 8060, 8061, 8062, 8063, 8064, 
8065, 8066, 8067, 8068, 8069, 8070, 8071, 8072, 8073, 8074, 
8075, 8076, 8077, 8078, 8079, 8080, 8081, 8082, 8083, 8084, 
8085, 8086, 8087, 8088, 8089, 8090, 8091, 8092, 8093, 8094, 
8095, 8096, 8097, 8098, 8099, 8100, 8101, 8102, 8103, 8104, 
8105, 8106, 8107, 8108, 8109, 8110, 8111, 8112, 8113, 8114, 
8115, 8116, 8117, 8118, 8119, 8120, 8121, 8122, 8123, 8124, 
8125, 8126, 8127, 8128, 8129, 8130, 8131, 8132, 8133, 8134, 
8135, 8136, 8137, 8138, 8139, 8140, 8141, 8142, 8143, 8144, 
8145, 8146, 8147, 8148, 8149, 8150, 8151, 8152, 8153, 8154, 
8155, 8156, 8157, 8158, 8159, 8160, 8161, 8162, 8163, 8164, 
8165, 8166, 8167, 8168, 8169, 8170, 8171, 8172, 8173, 8174, 
8175, 8176, 8177, 8178, 8179, 8180, 8181, 8182, 8183, 8184, 
8185, 8186, 8187, 8188, 8189, 8190, 8191, 8192, 8193, 8194, 
8195, 8196, 8197, 8198, 8199, 8200, 8201, 8202, 8203, 8204, 
8205, 8206, 8207, 8208, 8209, 8210, 8211, 8212, 8213, 8214, 
8215, 8216, 8217, 8218, 8687, 8688, 8689, 8690, 8691, 8692, 
8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 8701, 8702, 
8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 8711, 8712, 
8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 8721, 8722, 
8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 8731, 8732, 
8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 8741, 8742, 
8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 8751, 8752, 
8753, 8754, 8755, 8756, 8757, 8758, 8759, 8760, 8761, 8762, 
8763, 8764, 8765, 8766, 8767, 8768, 8769, 8770, 8771, 8772, 
8773, 8774, 8775, 8776, 8777, 8778, 8779, 8780, 8781, 8782, 
8783, 8784, 8785, 8786, 8787, 8788, 8789, 8790, 8791, 8792, 
8793, 8794, 8795, 8796, 8797, 8798, 8799, 8800, 8801, 8802, 
8803, 8804, 8805, 8806, 8807, 8808, 8809, 8810, 8811, 8812, 
8813, 8814, 8815, 8816, 8817, 8818, 8819, 8820, 8821, 8822, 
8823, 8824, 8825, 8826, 8827, 8828, 8829, 8830, 8903, 8904, 
8905, 8906, 8907, 8908, 8909, 8910, 8911, 8912, 8913, 8914, 
8915, 8916, 8917, 8918, 8919, 8920, 8921, 8922, 8923, 8924, 
8925, 8926, 8927, 8928, 8929, 8930, 8931, 8932, 8933, 8934, 
8935, 8936, 8937, 8938, 8939, 8940, 8941, 8942, 8943, 8944, 
8945, 8946, 8947, 8948, 8949, 8950, 8951, 8952, 8953, 8954, 
8955, 8956, 8957, 8958, 8959, 8960, 8961, 8962, 8963, 8964, 
8965, 8966, 8967, 8968, 8969, 8970, 8971, 8972, 8973, 8974, 
8975, 8976, 8977, 8978, 8979, 8980, 8981, 8982, 8983, 8984, 
8985, 8986, 
*ELSET,ELSET=Solder
5753, 5754, 5755, 5756, 5757, 5758, 5759, 5760, 5761, 5762, 
5763, 5764, 5765, 5766, 5767, 5768, 5769, 5770, 5771, 5772, 
5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 5781, 5782, 
5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 5791, 5792, 
5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 5801, 5802, 
5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 5811, 5812, 
5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 5821, 5822, 
5823, 5824, 6689, 6690, 6691, 6692, 6693, 6694, 6695, 6696, 
6697, 6698, 6699, 6700, 6701, 6702, 6703, 6704, 6705, 6706, 
6707, 6708, 6709, 6710, 6711, 6712, 6713, 6714, 6715, 6716, 
6717, 6718, 6719, 6720, 6721, 6722, 6723, 6724, 6725, 6726, 
6727, 6728, 6729, 6730, 6731, 6732, 6733, 6734, 6735, 6736, 
6737, 6738, 6739, 6740, 6741, 6742, 6743, 6744, 6745, 6746, 
6747, 6748, 6749, 6750, 6751, 6752, 6753, 6754, 6755, 6756, 
6757, 6758, 6759, 6760, 7283, 7284, 7285, 7286, 7287, 7288, 
7289, 7290, 7291, 7292, 7293, 7294, 7295, 7296, 7297, 7298, 
7299, 7300, 7301, 7302, 7303, 7304, 7305, 7306, 7307, 7308, 
7309, 7310, 7311, 7312, 7313, 7314, 7315, 7316, 7317, 7318, 
7319, 7320, 7321, 7322, 7323, 7324, 7325, 7326, 7327, 7328, 
7329, 7330, 7331, 7332, 7333, 7334, 7335, 7336, 7337, 7338, 
7339, 7340, 7341, 7342, 7343, 7344, 7345, 7346, 7347, 7348, 
7349, 7350, 7351, 7352, 7353, 7354, 8219, 8220, 8221, 8222, 
8223, 8224, 8225, 8226, 8227, 8228, 8229, 8230, 8231, 8232, 
8233, 8234, 8235, 8236, 8237, 8238, 8239, 8240, 8241, 8242, 
8243, 8244, 8245, 8246, 8247, 8248, 8249, 8250, 8251, 8252, 
8253, 8254, 8255, 8256, 8257, 8258, 8259, 8260, 8261, 8262, 
8263, 8264, 8265, 8266, 8267, 8268, 8269, 8270, 8271, 8272, 
8273, 8274, 8275, 8276, 8277, 8278, 8279, 8280, 8281, 8282, 
8283, 8284, 8285, 8286, 8287, 8288, 8289, 8290, 
*ELSET,ELSET=Volume
5537, 5538, 5539, 5540, 5541, 5542, 5543, 5544, 5545, 5546, 
5547, 5548, 5549, 5550, 5551, 5552, 5553, 5554, 5555, 5556, 
5557, 5558, 5559, 5560, 5561, 5562, 5563, 5564, 5565, 5566, 
5567, 5568, 5569, 5570, 5571, 5572, 5573, 5574, 5575, 5576, 
5577, 5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 5586, 
5587, 5588, 5589, 5590, 5591, 5592, 5593, 5594, 5595, 5596, 
5597, 5598, 5599, 5600, 5601, 5602, 5603, 5604, 5605, 5606, 
5607, 5608, 5609, 5610, 5611, 5612, 5613, 5614, 5615, 5616, 
5617, 5618, 5619, 5620, 5621, 5622, 5623, 5624, 5625, 5626, 
5627, 5628, 5629, 5630, 5631, 5632, 5633, 5634, 5635, 5636, 
5637, 5638, 5639, 5640, 5641, 5642, 5643, 5644, 5645, 5646, 
5647, 5648, 5649, 5650, 5651, 5652, 5653, 5654, 5655, 5656, 
5657, 5658, 5659, 5660, 5661, 5662, 5663, 5664, 5665, 5666, 
5667, 5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 5676, 
5677, 5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 5686, 
5687, 5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 5696, 
5697, 5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 5706, 
5707, 5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 5716, 
5717, 5718, 5719, 5720, 5721, 5722, 5723, 5724, 5725, 5726, 
5727, 5728, 5729, 5730, 5731, 5732, 5733, 5734, 5735, 5736, 
5737, 5738, 5739, 5740, 5741, 5742, 5743, 5744, 5745, 5746, 
5747, 5748, 5749, 5750, 5751, 5752, 5753, 5754, 5755, 5756, 
5757, 5758, 5759, 5760, 5761, 5762, 5763, 5764, 5765, 5766, 
5767, 5768, 5769, 5770, 5771, 5772, 5773, 5774, 5775, 5776, 
5777, 5778, 5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 
5787, 5788, 5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 
5797, 5798, 5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 
5807, 5808, 5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 
5817, 5818, 5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 
5827, 5828, 5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 
5837, 5838, 5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 
5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 5856, 
5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 5866, 
5867, 5868, 5869, 5870, 5871, 5872, 5873, 5874, 5875, 5876, 
5877, 5878, 5879, 5880, 5881, 5882, 5883, 5884, 5885, 5886, 
5887, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 5895, 5896, 
5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 5905, 5906, 
5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 5915, 5916, 
5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 5925, 5926, 
5927, 5928, 5929, 5930, 5931, 5932, 5933, 5934, 5935, 5936, 
5937, 5938, 5939, 5940, 5941, 5942, 5943, 5944, 5945, 5946, 
5947, 5948, 5949, 5950, 5951, 5952, 5953, 5954, 5955, 5956, 
5957, 5958, 5959, 5960, 5961, 5962, 5963, 5964, 5965, 5966, 
5967, 5968, 5969, 5970, 5971, 5972, 5973, 5974, 5975, 5976, 
5977, 5978, 5979, 5980, 5981, 5982, 5983, 5984, 5985, 5986, 
5987, 5988, 5989, 5990, 5991, 5992, 5993, 5994, 5995, 5996, 
5997, 5998, 5999, 6000, 6001, 6002, 6003, 6004, 6005, 6006, 
6007, 6008, 6009, 6010, 6011, 6012, 6013, 6014, 6015, 6016, 
6017, 6018, 6019, 6020, 6021, 6022, 6023, 6024, 6025, 6026, 
6027, 6028, 6029, 6030, 6031, 6032, 6033, 6034, 6035, 6036, 
6037, 6038, 6039, 6040, 6041, 6042, 6043, 6044, 6045, 6046, 
6047, 6048, 6049, 6050, 6051, 6052, 6053, 6054, 6055, 6056, 
6057, 6058, 6059, 6060, 6061, 6062, 6063, 6064, 6065, 6066, 
6067, 6068, 6069, 6070, 6071, 6072, 6073, 6074, 6075, 6076, 
6077, 6078, 6079, 6080, 6081, 6082, 6083, 6084, 6085, 6086, 
6087, 6088, 6089, 6090, 6091, 6092, 6093, 6094, 6095, 6096, 
6097, 6098, 6099, 6100, 6101, 6102, 6103, 6104, 6105, 6106, 
6107, 6108, 6109, 6110, 6111, 6112, 6113, 6114, 6115, 6116, 
6117, 6118, 6119, 6120, 6121, 6122, 6123, 6124, 6125, 6126, 
6127, 6128, 6129, 6130, 6131, 6132, 6133, 6134, 6135, 6136, 
6137, 6138, 6139, 6140, 6141, 6142, 6143, 6144, 6145, 6146, 
6147, 6148, 6149, 6150, 6151, 6152, 6153, 6154, 6155, 6156, 
6157, 6158, 6159, 6160, 6161, 6162, 6163, 6164, 6165, 6166, 
6167, 6168, 6169, 6170, 6171, 6172, 6173, 6174, 6175, 6176, 
6177, 6178, 6179, 6180, 6181, 6182, 6183, 6184, 6185, 6186, 
6187, 6188, 6189, 6190, 6191, 6192, 6193, 6194, 6195, 6196, 
6197, 6198, 6199, 6200, 6201, 6202, 6203, 6204, 6205, 6206, 
6207, 6208, 6209, 6210, 6211, 6212, 6213, 6214, 6215, 6216, 
6217, 6218, 6219, 6220, 6221, 6222, 6223, 6224, 6225, 6226, 
6227, 6228, 6229, 6230, 6231, 6232, 6233, 6234, 6235, 6236, 
6237, 6238, 6239, 6240, 6241, 6242, 6243, 6244, 6245, 6246, 
6247, 6248, 6249, 6250, 6251, 6252, 6253, 6254, 6255, 6256, 
6257, 6258, 6259, 6260, 6261, 6262, 6263, 6264, 6265, 6266, 
6267, 6268, 6269, 6270, 6271, 6272, 6273, 6274, 6275, 6276, 
6277, 6278, 6279, 6280, 6281, 6282, 6283, 6284, 6285, 6286, 
6287, 6288, 6289, 6290, 6291, 6292, 6293, 6294, 6295, 6296, 
6297, 6298, 6299, 6300, 6301, 6302, 6303, 6304, 6305, 6306, 
6307, 6308, 6309, 6310, 6311, 6312, 6313, 6314, 6315, 6316, 
6317, 6318, 6319, 6320, 6321, 6322, 6323, 6324, 6325, 6326, 
6327, 6328, 6329, 6330, 6331, 6332, 6333, 6334, 6335, 6336, 
6337, 6338, 6339, 6340, 6341, 6342, 6343, 6344, 6345, 6346, 
6347, 6348, 6349, 6350, 6351, 6352, 6353, 6354, 6355, 6356, 
6357, 6358, 6359, 6360, 6361, 6362, 6363, 6364, 6365, 6366, 
6367, 6368, 6369, 6370, 6371, 6372, 6373, 6374, 6375, 6376, 
6377, 6378, 6379, 6380, 6381, 6382, 6383, 6384, 6385, 6386, 
6387, 6388, 6389, 6390, 6391, 6392, 6393, 6394, 6395, 6396, 
6397, 6398, 6399, 6400, 6401, 6402, 6403, 6404, 6405, 6406, 
6407, 6408, 6409, 6410, 6411, 6412, 6413, 6414, 6415, 6416, 
6417, 6418, 6419, 6420, 6421, 6422, 6423, 6424, 6425, 6426, 
6427, 6428, 6429, 6430, 6431, 6432, 6433, 6434, 6435, 6436, 
6437, 6438, 6439, 6440, 6441, 6442, 6443, 6444, 6445, 6446, 
6447, 6448, 6449, 6450, 6451, 6452, 6453, 6454, 6455, 6456, 
6457, 6458, 6459, 6460, 6461, 6462, 6463, 6464, 6465, 6466, 
6467, 6468, 6469, 6470, 6471, 6472, 6473, 6474, 6475, 6476, 
6477, 6478, 6479, 6480, 6481, 6482, 6483, 6484, 6485, 6486, 
6487, 6488, 6489, 6490, 6491, 6492, 6493, 6494, 6495, 6496, 
6497, 6498, 6499, 6500, 6501, 6502, 6503, 6504, 6505, 6506, 
6507, 6508, 6509, 6510, 6511, 6512, 6513, 6514, 6515, 6516, 
6517, 6518, 6519, 6520, 6521, 6522, 6523, 6524, 6525, 6526, 
6527, 6528, 6529, 6530, 6531, 6532, 6533, 6534, 6535, 6536, 
6537, 6538, 6539, 6540, 6541, 6542, 6543, 6544, 6545, 6546, 
6547, 6548, 6549, 6550, 6551, 6552, 6553, 6554, 6555, 6556, 
6557, 6558, 6559, 6560, 6561, 6562, 6563, 6564, 6565, 6566, 
6567, 6568, 6569, 6570, 6571, 6572, 6573, 6574, 6575, 6576, 
6577, 6578, 6579, 6580, 6581, 6582, 6583, 6584, 6585, 6586, 
6587, 6588, 6589, 6590, 6591, 6592, 6593, 6594, 6595, 6596, 
6597, 6598, 6599, 6600, 6601, 6602, 6603, 6604, 6605, 6606, 
6607, 6608, 6609, 6610, 6611, 6612, 6613, 6614, 6615, 6616, 
6617, 6618, 6619, 6620, 6621, 6622, 6623, 6624, 6625, 6626, 
6627, 6628, 6629, 6630, 6631, 6632, 6633, 6634, 6635, 6636, 
6637, 6638, 6639, 6640, 6641, 6642, 6643, 6644, 6645, 6646, 
6647, 6648, 6649, 6650, 6651, 6652, 6653, 6654, 6655, 6656, 
6657, 6658, 6659, 6660, 6661, 6662, 6663, 6664, 6665, 6666, 
6667, 6668, 6669, 6670, 6671, 6672, 6673, 6674, 6675, 6676, 
6677, 6678, 6679, 6680, 6681, 6682, 6683, 6684, 6685, 6686, 
6687, 6688, 6689, 6690, 6691, 6692, 6693, 6694, 6695, 6696, 
6697, 6698, 6699, 6700, 6701, 6702, 6703, 6704, 6705, 6706, 
6707, 6708, 6709, 6710, 6711, 6712, 6713, 6714, 6715, 6716, 
6717, 6718, 6719, 6720, 6721, 6722, 6723, 6724, 6725, 6726, 
6727, 6728, 6729, 6730, 6731, 6732, 6733, 6734, 6735, 6736, 
6737, 6738, 6739, 6740, 6741, 6742, 6743, 6744, 6745, 6746, 
6747, 6748, 6749, 6750, 6751, 6752, 6753, 6754, 6755, 6756, 
6757, 6758, 6759, 6760, 6761, 6762, 6763, 6764, 6765, 6766, 
6767, 6768, 6769, 6770, 6771, 6772, 6773, 6774, 6775, 6776, 
6777, 6778, 6779, 6780, 6781, 6782, 6783, 6784, 6785, 6786, 
6787, 6788, 6789, 6790, 6791, 6792, 6793, 6794, 6795, 6796, 
6797, 6798, 6799, 6800, 6801, 6802, 6803, 6804, 6805, 6806, 
6807, 6808, 6809, 6810, 6811, 6812, 6813, 6814, 6815, 6816, 
6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 6825, 6826, 
6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 6835, 6836, 
6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 6845, 6846, 
6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 6855, 6856, 
6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 6865, 6866, 
6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 6875, 6876, 
6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 6885, 6886, 
6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 6895, 6896, 
6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 6905, 6906, 
6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 6915, 6916, 
6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 6925, 6926, 
6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 6935, 6936, 
6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 6945, 6946, 
6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 6955, 6956, 
6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 6965, 6966, 
6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 6975, 6976, 
6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 6985, 6986, 
6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 6995, 6996, 
6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 7005, 7006, 
7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 7015, 7016, 
7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 7025, 7026, 
7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 7035, 7036, 
7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 7045, 7046, 
7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 7055, 7056, 
7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 7065, 7066, 
7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 7075, 7076, 
7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 7085, 7086, 
7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 7095, 7096, 
7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 7105, 7106, 
7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 7115, 7116, 
7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 
7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 
7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 7145, 7146, 
7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 7155, 7156, 
7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 7165, 7166, 
7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 7175, 7176, 
7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 7185, 7186, 
7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 7195, 7196, 
7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 7205, 7206, 
7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 7215, 7216, 
7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 7225, 7226, 
7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 7235, 7236, 
7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 7245, 7246, 
7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 7255, 7256, 
7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 7265, 7266, 
7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 7275, 7276, 
7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 7285, 7286, 
7287, 7288, 7289, 7290, 7291, 7292, 7293, 7294, 7295, 7296, 
7297, 7298, 7299, 7300, 7301, 7302, 7303, 7304, 7305, 7306, 
7307, 7308, 7309, 7310, 7311, 7312, 7313, 7314, 7315, 7316, 
7317, 7318, 7319, 7320, 7321, 7322, 7323, 7324, 7325, 7326, 
7327, 7328, 7329, 7330, 7331, 7332, 7333, 7334, 7335, 7336, 
7337, 7338, 7339, 7340, 7341, 7342, 7343, 7344, 7345, 7346, 
7347, 7348, 7349, 7350, 7351, 7352, 7353, 7354, 7355, 7356, 
7357, 7358, 7359, 7360, 7361, 7362, 7363, 7364, 7365, 7366, 
7367, 7368, 7369, 7370, 7371, 7372, 7373, 7374, 7375, 7376, 
7377, 7378, 7379, 7380, 7381, 7382, 7383, 7384, 7385, 7386, 
7387, 7388, 7389, 7390, 7391, 7392, 7393, 7394, 7395, 7396, 
7397, 7398, 7399, 7400, 7401, 7402, 7403, 7404, 7405, 7406, 
7407, 7408, 7409, 7410, 7411, 7412, 7413, 7414, 7415, 7416, 
7417, 7418, 7419, 7420, 7421, 7422, 7423, 7424, 7425, 7426, 
7427, 7428, 7429, 7430, 7431, 7432, 7433, 7434, 7435, 7436, 
7437, 7438, 7439, 7440, 7441, 7442, 7443, 7444, 7445, 7446, 
7447, 7448, 7449, 7450, 7451, 7452, 7453, 7454, 7455, 7456, 
7457, 7458, 7459, 7460, 7461, 7462, 7463, 7464, 7465, 7466, 
7467, 7468, 7469, 7470, 7471, 7472, 7473, 7474, 7475, 7476, 
7477, 7478, 7479, 7480, 7481, 7482, 7483, 7484, 7485, 7486, 
7487, 7488, 7489, 7490, 7491, 7492, 7493, 7494, 7495, 7496, 
7497, 7498, 7499, 7500, 7501, 7502, 7503, 7504, 7505, 7506, 
7507, 7508, 7509, 7510, 7511, 7512, 7513, 7514, 7515, 7516, 
7517, 7518, 7519, 7520, 7521, 7522, 7523, 7524, 7525, 7526, 
7527, 7528, 7529, 7530, 7531, 7532, 7533, 7534, 7535, 7536, 
7537, 7538, 7539, 7540, 7541, 7542, 7543, 7544, 7545, 7546, 
7547, 7548, 7549, 7550, 7551, 7552, 7553, 7554, 7555, 7556, 
7557, 7558, 7559, 7560, 7561, 7562, 7563, 7564, 7565, 7566, 
7567, 7568, 7569, 7570, 7571, 7572, 7573, 7574, 7575, 7576, 
7577, 7578, 7579, 7580, 7581, 7582, 7583, 7584, 7585, 7586, 
7587, 7588, 7589, 7590, 7591, 7592, 7593, 7594, 7595, 7596, 
7597, 7598, 7599, 7600, 7601, 7602, 7603, 7604, 7605, 7606, 
7607, 7608, 7609, 7610, 7611, 7612, 7613, 7614, 7615, 7616, 
7617, 7618, 7619, 7620, 7621, 7622, 7623, 7624, 7625, 7626, 
7627, 7628, 7629, 7630, 7631, 7632, 7633, 7634, 7635, 7636, 
7637, 7638, 7639, 7640, 7641, 7642, 7643, 7644, 7645, 7646, 
7647, 7648, 7649, 7650, 7651, 7652, 7653, 7654, 7655, 7656, 
7657, 7658, 7659, 7660, 7661, 7662, 7663, 7664, 7665, 7666, 
7667, 7668, 7669, 7670, 7671, 7672, 7673, 7674, 7675, 7676, 
7677, 7678, 7679, 7680, 7681, 7682, 7683, 7684, 7685, 7686, 
7687, 7688, 7689, 7690, 7691, 7692, 7693, 7694, 7695, 7696, 
7697, 7698, 7699, 7700, 7701, 7702, 7703, 7704, 7705, 7706, 
7707, 7708, 7709, 7710, 7711, 7712, 7713, 7714, 7715, 7716, 
7717, 7718, 7719, 7720, 7721, 7722, 7723, 7724, 7725, 7726, 
7727, 7728, 7729, 7730, 7731, 7732, 7733, 7734, 7735, 7736, 
7737, 7738, 7739, 7740, 7741, 7742, 7743, 7744, 7745, 7746, 
7747, 7748, 7749, 7750, 7751, 7752, 7753, 7754, 7755, 7756, 
7757, 7758, 7759, 7760, 7761, 7762, 7763, 7764, 7765, 7766, 
7767, 7768, 7769, 7770, 7771, 7772, 7773, 7774, 7775, 7776, 
7777, 7778, 7779, 7780, 7781, 7782, 7783, 7784, 7785, 7786, 
7787, 7788, 7789, 7790, 7791, 7792, 7793, 7794, 7795, 7796, 
7797, 7798, 7799, 7800, 7801, 7802, 7803, 7804, 7805, 7806, 
7807, 7808, 7809, 7810, 7811, 7812, 7813, 7814, 7815, 7816, 
7817, 7818, 7819, 7820, 7821, 7822, 7823, 7824, 7825, 7826, 
7827, 7828, 7829, 7830, 7831, 7832, 7833, 7834, 7835, 7836, 
7837, 7838, 7839, 7840, 7841, 7842, 7843, 7844, 7845, 7846, 
7847, 7848, 7849, 7850, 7851, 7852, 7853, 7854, 7855, 7856, 
7857, 7858, 7859, 7860, 7861, 7862, 7863, 7864, 7865, 7866, 
7867, 7868, 7869, 7870, 7871, 7872, 7873, 7874, 7875, 7876, 
7877, 7878, 7879, 7880, 7881, 7882, 7883, 7884, 7885, 7886, 
7887, 7888, 7889, 7890, 7891, 7892, 7893, 7894, 7895, 7896, 
7897, 7898, 7899, 7900, 7901, 7902, 7903, 7904, 7905, 7906, 
7907, 7908, 7909, 7910, 7911, 7912, 7913, 7914, 7915, 7916, 
7917, 7918, 7919, 7920, 7921, 7922, 7923, 7924, 7925, 7926, 
7927, 7928, 7929, 7930, 7931, 7932, 7933, 7934, 7935, 7936, 
7937, 7938, 7939, 7940, 7941, 7942, 7943, 7944, 7945, 7946, 
7947, 7948, 7949, 7950, 7951, 7952, 7953, 7954, 7955, 7956, 
7957, 7958, 7959, 7960, 7961, 7962, 7963, 7964, 7965, 7966, 
7967, 7968, 7969, 7970, 7971, 7972, 7973, 7974, 7975, 7976, 
7977, 7978, 7979, 7980, 7981, 7982, 7983, 7984, 7985, 7986, 
7987, 7988, 7989, 7990, 7991, 7992, 7993, 7994, 7995, 7996, 
7997, 7998, 7999, 8000, 8001, 8002, 8003, 8004, 8005, 8006, 
8007, 8008, 8009, 8010, 8011, 8012, 8013, 8014, 8015, 8016, 
8017, 8018, 8019, 8020, 8021, 8022, 8023, 8024, 8025, 8026, 
8027, 8028, 8029, 8030, 8031, 8032, 8033, 8034, 8035, 8036, 
8037, 8038, 8039, 8040, 8041, 8042, 8043, 8044, 8045, 8046, 
8047, 8048, 8049, 8050, 8051, 8052, 8053, 8054, 8055, 8056, 
8057, 8058, 8059, 8060, 8061, 8062, 8063, 8064, 8065, 8066, 
8067, 8068, 8069, 8070, 8071, 8072, 8073, 8074, 8075, 8076, 
8077, 8078, 8079, 8080, 8081, 8082, 8083, 8084, 8085, 8086, 
8087, 8088, 8089, 8090, 8091, 8092, 8093, 8094, 8095, 8096, 
