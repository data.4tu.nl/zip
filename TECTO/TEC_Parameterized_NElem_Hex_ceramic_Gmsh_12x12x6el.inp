3101, 0.25, 1.54, 0
3102, 0.25, 1.58, 0
3103, 0.25, 1.62, 0
3104, 0.25, 1.66, 0
3105, 0.33333333333333, 1.54, 0
3106, 0.33333333333333, 1.58, 0
3107, 0.33333333333333, 1.62, 0
3108, 0.33333333333333, 1.66, 0
3109, 0.41666666666667, 1.54, 0
3110, 0.41666666666667, 1.58, 0
3111, 0.41666666666667, 1.62, 0
3112, 0.41666666666667, 1.66, 0
3113, 0.5, 1.54, 0
3114, 0.5, 1.58, 0
3115, 0.5, 1.62, 0
3116, 0.5, 1.66, 0
3117, 0.58333333333333, 1.54, 0
3118, 0.58333333333333, 1.58, 0
3119, 0.58333333333333, 1.62, 0
3120, 0.58333333333333, 1.66, 0
3121, 0.66666666666667, 1.54, 0
3122, 0.66666666666667, 1.58, 0
3123, 0.66666666666667, 1.62, 0
3124, 0.66666666666667, 1.66, 0
3125, 0.75, 1.54, 0
3126, 0.75, 1.58, 0
3127, 0.75, 1.62, 0
3128, 0.75, 1.66, 0
3129, 0.83333333333333, 1.54, 0
3130, 0.83333333333333, 1.58, 0
3131, 0.83333333333333, 1.62, 0
3132, 0.83333333333333, 1.66, 0
3133, 0.91666666666667, 1.54, 0
3134, 0.91666666666667, 1.58, 0
3135, 0.91666666666667, 1.62, 0
3136, 0.91666666666667, 1.66, 0
3137, 1, 1.54, 0.083333333333333
3138, 1, 1.58, 0.083333333333333
3139, 1, 1.62, 0.083333333333333
3140, 1, 1.66, 0.083333333333333
3141, 1, 1.54, 0.16666666666667
3142, 1, 1.58, 0.16666666666667
3143, 1, 1.62, 0.16666666666667
3144, 1, 1.66, 0.16666666666667
3145, 1, 1.54, 0.25
3146, 1, 1.58, 0.25
3147, 1, 1.62, 0.25
3148, 1, 1.66, 0.25
3149, 1, 1.54, 0.33333333333333
3150, 1, 1.58, 0.33333333333333
3151, 1, 1.62, 0.33333333333333
3152, 1, 1.66, 0.33333333333333
3153, 1, 1.54, 0.41666666666667
3154, 1, 1.58, 0.41666666666667
3155, 1, 1.62, 0.41666666666667
3156, 1, 1.66, 0.41666666666667
3157, 0.083333333333333, 1.54, 0.5
3158, 0.083333333333333, 1.58, 0.5
3159, 0.083333333333333, 1.62, 0.5
3160, 0.083333333333333, 1.66, 0.5
3161, 0.16666666666667, 1.54, 0.5
3162, 0.16666666666667, 1.58, 0.5
3163, 0.16666666666667, 1.62, 0.5
3164, 0.16666666666667, 1.66, 0.5
3165, 0.25, 1.54, 0.5
3166, 0.25, 1.58, 0.5
3167, 0.25, 1.62, 0.5
3168, 0.25, 1.66, 0.5
3169, 0.33333333333333, 1.54, 0.5
3170, 0.33333333333333, 1.58, 0.5
3171, 0.33333333333333, 1.62, 0.5
3172, 0.33333333333333, 1.66, 0.5
3173, 0.41666666666667, 1.54, 0.5
3174, 0.41666666666667, 1.58, 0.5
3175, 0.41666666666667, 1.62, 0.5
3176, 0.41666666666667, 1.66, 0.5
3177, 0.5, 1.54, 0.5
3178, 0.5, 1.58, 0.5
3179, 0.5, 1.62, 0.5
3180, 0.5, 1.66, 0.5
3181, 0.58333333333333, 1.54, 0.5
3182, 0.58333333333333, 1.58, 0.5
3183, 0.58333333333333, 1.62, 0.5
3184, 0.58333333333333, 1.66, 0.5
3185, 0.66666666666667, 1.54, 0.5
3186, 0.66666666666667, 1.58, 0.5
3187, 0.66666666666667, 1.62, 0.5
3188, 0.66666666666667, 1.66, 0.5
3189, 0.75, 1.54, 0.5
3190, 0.75, 1.58, 0.5
3191, 0.75, 1.62, 0.5
3192, 0.75, 1.66, 0.5
3193, 0.83333333333333, 1.54, 0.5
3194, 0.83333333333333, 1.58, 0.5
3195, 0.83333333333333, 1.62, 0.5
3196, 0.83333333333333, 1.66, 0.5
3197, 0.91666666666667, 1.54, 0.5
3198, 0.91666666666667, 1.58, 0.5
3199, 0.91666666666667, 1.62, 0.5
3200, 0.91666666666667, 1.66, 0.5
3201, 0, 1.54, 0.083333333333333
3202, 0, 1.58, 0.083333333333333
3203, 0, 1.62, 0.083333333333333
3204, 0, 1.66, 0.083333333333333
3205, 0, 1.54, 0.16666666666667
3206, 0, 1.58, 0.16666666666667
3207, 0, 1.62, 0.16666666666667
3208, 0, 1.66, 0.16666666666667
3209, 0, 1.54, 0.25
3210, 0, 1.58, 0.25
3211, 0, 1.62, 0.25
3212, 0, 1.66, 0.25
3213, 0, 1.54, 0.33333333333333
3214, 0, 1.58, 0.33333333333333
3215, 0, 1.62, 0.33333333333333
3216, 0, 1.66, 0.33333333333333
3217, 0, 1.54, 0.41666666666667
3218, 0, 1.58, 0.41666666666667
3219, 0, 1.62, 0.41666666666667
3220, 0, 1.66, 0.41666666666667
3221, 0.083333333333333, 1.7, 0.083333333333333
3222, 0.083333333333333, 1.7, 0.16666666666667
3223, 0.083333333333333, 1.7, 0.25
3224, 0.083333333333333, 1.7, 0.33333333333333
3225, 0.083333333333333, 1.7, 0.41666666666667
3226, 0.16666666666667, 1.7, 0.083333333333333
3227, 0.16666666666667, 1.7, 0.16666666666667
3228, 0.16666666666667, 1.7, 0.25
3229, 0.16666666666667, 1.7, 0.33333333333333
3230, 0.16666666666667, 1.7, 0.41666666666667
3231, 0.25, 1.7, 0.083333333333333
3232, 0.25, 1.7, 0.16666666666667
3233, 0.25, 1.7, 0.25
3234, 0.25, 1.7, 0.33333333333333
3235, 0.25, 1.7, 0.41666666666667
3236, 0.33333333333333, 1.7, 0.083333333333333
3237, 0.33333333333333, 1.7, 0.16666666666667
3238, 0.33333333333333, 1.7, 0.25
3239, 0.33333333333333, 1.7, 0.33333333333333
3240, 0.33333333333333, 1.7, 0.41666666666667
3241, 0.41666666666667, 1.7, 0.083333333333333
3242, 0.41666666666667, 1.7, 0.16666666666667
3243, 0.41666666666667, 1.7, 0.25
3244, 0.41666666666667, 1.7, 0.33333333333333
3245, 0.41666666666667, 1.7, 0.41666666666667
3246, 0.5, 1.7, 0.083333333333333
3247, 0.5, 1.7, 0.16666666666667
3248, 0.5, 1.7, 0.25
3249, 0.5, 1.7, 0.33333333333333
3250, 0.5, 1.7, 0.41666666666667
3251, 0.58333333333333, 1.7, 0.083333333333333
3252, 0.58333333333333, 1.7, 0.16666666666667
3253, 0.58333333333333, 1.7, 0.25
3254, 0.58333333333333, 1.7, 0.33333333333333
3255, 0.58333333333333, 1.7, 0.41666666666667
3256, 0.66666666666667, 1.7, 0.083333333333333
3257, 0.66666666666667, 1.7, 0.16666666666667
3258, 0.66666666666667, 1.7, 0.25
3259, 0.66666666666667, 1.7, 0.33333333333333
3260, 0.66666666666667, 1.7, 0.41666666666667
3261, 0.75, 1.7, 0.083333333333333
3262, 0.75, 1.7, 0.16666666666667
3263, 0.75, 1.7, 0.25
3264, 0.75, 1.7, 0.33333333333333
3265, 0.75, 1.7, 0.41666666666667
3266, 0.83333333333333, 1.7, 0.083333333333333
3267, 0.83333333333333, 1.7, 0.16666666666667
3268, 0.83333333333333, 1.7, 0.25
3269, 0.83333333333333, 1.7, 0.33333333333333
3270, 0.83333333333333, 1.7, 0.41666666666667
3271, 0.91666666666667, 1.7, 0.083333333333333
3272, 0.91666666666667, 1.7, 0.16666666666667
3273, 0.91666666666667, 1.7, 0.25
3274, 0.91666666666667, 1.7, 0.33333333333333
3275, 0.91666666666667, 1.7, 0.41666666666667
3276, 1.04, 1.54, 0.5
3277, 1.04, 1.58, 0.5
3278, 1.04, 1.62, 0.5
3279, 1.04, 1.66, 0.5
3280, 1.08, 1.54, 0.5
3281, 1.08, 1.58, 0.5
3282, 1.08, 1.62, 0.5
3283, 1.08, 1.66, 0.5
3284, 1.12, 1.54, 0.5
3285, 1.12, 1.58, 0.5
3286, 1.12, 1.62, 0.5
3287, 1.12, 1.66, 0.5
3288, 1.16, 1.54, 0.5
3289, 1.16, 1.58, 0.5
3290, 1.16, 1.62, 0.5
3291, 1.16, 1.66, 0.5
3292, 1.04, 1.54, 0
3293, 1.04, 1.58, 0
3294, 1.04, 1.62, 0
3295, 1.04, 1.66, 0
3296, 1.08, 1.54, 0
3297, 1.08, 1.58, 0
3298, 1.08, 1.62, 0
3299, 1.08, 1.66, 0
3300, 1.12, 1.54, 0
3301, 1.12, 1.58, 0
3302, 1.12, 1.62, 0
3303, 1.12, 1.66, 0
3304, 1.16, 1.54, 0
3305, 1.16, 1.58, 0
3306, 1.16, 1.62, 0
3307, 1.16, 1.66, 0
3308, 1.2, 1.54, 0.083333333333333
3309, 1.2, 1.58, 0.083333333333333
3310, 1.2, 1.62, 0.083333333333333
3311, 1.2, 1.66, 0.083333333333333
3312, 1.2, 1.54, 0.16666666666667
3313, 1.2, 1.58, 0.16666666666667
3314, 1.2, 1.62, 0.16666666666667
3315, 1.2, 1.66, 0.16666666666667
3316, 1.2, 1.54, 0.25
3317, 1.2, 1.58, 0.25
3318, 1.2, 1.62, 0.25
3319, 1.2, 1.66, 0.25
3320, 1.2, 1.54, 0.33333333333333
3321, 1.2, 1.58, 0.33333333333333
3322, 1.2, 1.62, 0.33333333333333
3323, 1.2, 1.66, 0.33333333333333
3324, 1.2, 1.54, 0.41666666666667
3325, 1.2, 1.58, 0.41666666666667
3326, 1.2, 1.62, 0.41666666666667
3327, 1.2, 1.66, 0.41666666666667
3328, 1.04, 1.7, 0.083333333333333
3329, 1.08, 1.7, 0.083333333333333
3330, 1.12, 1.7, 0.083333333333333
3331, 1.16, 1.7, 0.083333333333333
3332, 1.04, 1.7, 0.16666666666667
3333, 1.08, 1.7, 0.16666666666667
3334, 1.12, 1.7, 0.16666666666667
3335, 1.16, 1.7, 0.16666666666667
3336, 1.04, 1.7, 0.25
3337, 1.08, 1.7, 0.25
3338, 1.12, 1.7, 0.25
3339, 1.16, 1.7, 0.25
3340, 1.04, 1.7, 0.33333333333333
3341, 1.08, 1.7, 0.33333333333333
3342, 1.12, 1.7, 0.33333333333333
3343, 1.16, 1.7, 0.33333333333333
3344, 1.04, 1.7, 0.41666666666667
3345, 1.08, 1.7, 0.41666666666667
3346, 1.12, 1.7, 0.41666666666667
3347, 1.16, 1.7, 0.41666666666667
3348, 1.2833333333333, 1.54, 0.5
3349, 1.2833333333333, 1.58, 0.5
3350, 1.2833333333333, 1.62, 0.5
3351, 1.2833333333333, 1.66, 0.5
3352, 1.3666666666667, 1.54, 0.5
3353, 1.3666666666667, 1.58, 0.5
3354, 1.3666666666667, 1.62, 0.5
3355, 1.3666666666667, 1.66, 0.5
3356, 1.45, 1.54, 0.5
3357, 1.45, 1.58, 0.5
3358, 1.45, 1.62, 0.5
3359, 1.45, 1.66, 0.5
3360, 1.5333333333333, 1.54, 0.5
3361, 1.5333333333333, 1.58, 0.5
3362, 1.5333333333333, 1.62, 0.5
3363, 1.5333333333333, 1.66, 0.5
3364, 1.6166666666667, 1.54, 0.5
3365, 1.6166666666667, 1.58, 0.5
3366, 1.6166666666667, 1.62, 0.5
3367, 1.6166666666667, 1.66, 0.5
3368, 1.7, 1.54, 0.5
3369, 1.7, 1.58, 0.5
3370, 1.7, 1.62, 0.5
3371, 1.7, 1.66, 0.5
3372, 1.7833333333333, 1.54, 0.5
3373, 1.7833333333333, 1.58, 0.5
3374, 1.7833333333333, 1.62, 0.5
3375, 1.7833333333333, 1.66, 0.5
3376, 1.8666666666667, 1.54, 0.5
3377, 1.8666666666667, 1.58, 0.5
3378, 1.8666666666667, 1.62, 0.5
3379, 1.8666666666667, 1.66, 0.5
3380, 1.95, 1.54, 0.5
3381, 1.95, 1.58, 0.5
3382, 1.95, 1.62, 0.5
3383, 1.95, 1.66, 0.5
3384, 2.0333333333333, 1.54, 0.5
3385, 2.0333333333333, 1.58, 0.5
3386, 2.0333333333333, 1.62, 0.5
3387, 2.0333333333333, 1.66, 0.5
3388, 2.1166666666667, 1.54, 0.5
3389, 2.1166666666667, 1.58, 0.5
3390, 2.1166666666667, 1.62, 0.5
3391, 2.1166666666667, 1.66, 0.5
3392, 1.2833333333333, 1.54, 0
3393, 1.2833333333333, 1.58, 0
3394, 1.2833333333333, 1.62, 0
3395, 1.2833333333333, 1.66, 0
3396, 1.3666666666667, 1.54, 0
3397, 1.3666666666667, 1.58, 0
3398, 1.3666666666667, 1.62, 0
3399, 1.3666666666667, 1.66, 0
3400, 1.45, 1.54, 0
3401, 1.45, 1.58, 0
3402, 1.45, 1.62, 0
3403, 1.45, 1.66, 0
3404, 1.5333333333333, 1.54, 0
3405, 1.5333333333333, 1.58, 0
3406, 1.5333333333333, 1.62, 0
3407, 1.5333333333333, 1.66, 0
3408, 1.6166666666667, 1.54, 0
3409, 1.6166666666667, 1.58, 0
3410, 1.6166666666667, 1.62, 0
3411, 1.6166666666667, 1.66, 0
3412, 1.7, 1.54, 0
3413, 1.7, 1.58, 0
3414, 1.7, 1.62, 0
3415, 1.7, 1.66, 0
3416, 1.7833333333333, 1.54, 0
3417, 1.7833333333333, 1.58, 0
3418, 1.7833333333333, 1.62, 0
3419, 1.7833333333333, 1.66, 0
3420, 1.8666666666667, 1.54, 0
3421, 1.8666666666667, 1.58, 0
3422, 1.8666666666667, 1.62, 0
3423, 1.8666666666667, 1.66, 0
3424, 1.95, 1.54, 0
3425, 1.95, 1.58, 0
3426, 1.95, 1.62, 0
3427, 1.95, 1.66, 0
3428, 2.0333333333333, 1.54, 0
3429, 2.0333333333333, 1.58, 0
3430, 2.0333333333333, 1.62, 0
3431, 2.0333333333333, 1.66, 0
3432, 2.1166666666667, 1.54, 0
3433, 2.1166666666667, 1.58, 0
3434, 2.1166666666667, 1.62, 0
3435, 2.1166666666667, 1.66, 0
3436, 2.2, 1.54, 0.083333333333333
3437, 2.2, 1.58, 0.083333333333333
3438, 2.2, 1.62, 0.083333333333333
3439, 2.2, 1.66, 0.083333333333333
3440, 2.2, 1.54, 0.16666666666667
3441, 2.2, 1.58, 0.16666666666667
3442, 2.2, 1.62, 0.16666666666667
3443, 2.2, 1.66, 0.16666666666667
3444, 2.2, 1.54, 0.25
3445, 2.2, 1.58, 0.25
3446, 2.2, 1.62, 0.25
3447, 2.2, 1.66, 0.25
3448, 2.2, 1.54, 0.33333333333333
3449, 2.2, 1.58, 0.33333333333333
3450, 2.2, 1.62, 0.33333333333333
3451, 2.2, 1.66, 0.33333333333333
3452, 2.2, 1.54, 0.41666666666667
3453, 2.2, 1.58, 0.41666666666667
3454, 2.2, 1.62, 0.41666666666667
3455, 2.2, 1.66, 0.41666666666667
3456, 1.2833333333333, 1.7, 0.083333333333333
3457, 1.3666666666667, 1.7, 0.083333333333333
3458, 1.45, 1.7, 0.083333333333333
3459, 1.5333333333333, 1.7, 0.083333333333333
3460, 1.6166666666667, 1.7, 0.083333333333333
3461, 1.7, 1.7, 0.083333333333333
3462, 1.7833333333333, 1.7, 0.083333333333333
3463, 1.8666666666667, 1.7, 0.083333333333333
3464, 1.95, 1.7, 0.083333333333333
3465, 2.0333333333333, 1.7, 0.083333333333333
3466, 2.1166666666667, 1.7, 0.083333333333333
3467, 1.2833333333333, 1.7, 0.16666666666667
3468, 1.3666666666667, 1.7, 0.16666666666667
3469, 1.45, 1.7, 0.16666666666667
3470, 1.5333333333333, 1.7, 0.16666666666667
3471, 1.6166666666667, 1.7, 0.16666666666667
3472, 1.7, 1.7, 0.16666666666667
3473, 1.7833333333333, 1.7, 0.16666666666667
3474, 1.8666666666667, 1.7, 0.16666666666667
3475, 1.95, 1.7, 0.16666666666667
3476, 2.0333333333333, 1.7, 0.16666666666667
3477, 2.1166666666667, 1.7, 0.16666666666667
3478, 1.2833333333333, 1.7, 0.25
3479, 1.3666666666667, 1.7, 0.25
3480, 1.45, 1.7, 0.25
3481, 1.5333333333333, 1.7, 0.25
3482, 1.6166666666667, 1.7, 0.25
3483, 1.7, 1.7, 0.25
3484, 1.7833333333333, 1.7, 0.25
3485, 1.8666666666667, 1.7, 0.25
3486, 1.95, 1.7, 0.25
3487, 2.0333333333333, 1.7, 0.25
3488, 2.1166666666667, 1.7, 0.25
3489, 1.2833333333333, 1.7, 0.33333333333333
3490, 1.3666666666667, 1.7, 0.33333333333333
3491, 1.45, 1.7, 0.33333333333333
3492, 1.5333333333333, 1.7, 0.33333333333333
3493, 1.6166666666667, 1.7, 0.33333333333333
3494, 1.7, 1.7, 0.33333333333333
3495, 1.7833333333333, 1.7, 0.33333333333333
3496, 1.8666666666667, 1.7, 0.33333333333333
3497, 1.95, 1.7, 0.33333333333333
3498, 2.0333333333333, 1.7, 0.33333333333333
3499, 2.1166666666667, 1.7, 0.33333333333333
3500, 1.2833333333333, 1.7, 0.41666666666667
3501, 1.3666666666667, 1.7, 0.41666666666667
3502, 1.45, 1.7, 0.41666666666667
3503, 1.5333333333333, 1.7, 0.41666666666667
3504, 1.6166666666667, 1.7, 0.41666666666667
3505, 1.7, 1.7, 0.41666666666667
3506, 1.7833333333333, 1.7, 0.41666666666667
3507, 1.8666666666667, 1.7, 0.41666666666667
3508, 1.95, 1.7, 0.41666666666667
3509, 2.0333333333333, 1.7, 0.41666666666667
3510, 2.1166666666667, 1.7, 0.41666666666667
3511, 0.083333333333333, -0.04, 0
3512, 0.083333333333333, -0.08, 0
3513, 0.083333333333333, -0.12, 0
3514, 0.083333333333333, -0.16, 0
3515, 0.16666666666667, -0.04, 0
3516, 0.16666666666667, -0.08, 0
3517, 0.16666666666667, -0.12, 0
3518, 0.16666666666667, -0.16, 0
3519, 0.25, -0.04, 0
3520, 0.25, -0.08, 0
3521, 0.25, -0.12, 0
3522, 0.25, -0.16, 0
3523, 0.33333333333333, -0.04, 0
3524, 0.33333333333333, -0.08, 0
3525, 0.33333333333333, -0.12, 0
3526, 0.33333333333333, -0.16, 0
3527, 0.41666666666667, -0.04, 0
3528, 0.41666666666667, -0.08, 0
3529, 0.41666666666667, -0.12, 0
3530, 0.41666666666667, -0.16, 0
3531, 0.5, -0.04, 0
3532, 0.5, -0.08, 0
3533, 0.5, -0.12, 0
3534, 0.5, -0.16, 0
3535, 0.58333333333333, -0.04, 0
3536, 0.58333333333333, -0.08, 0
3537, 0.58333333333333, -0.12, 0
3538, 0.58333333333333, -0.16, 0
3539, 0.66666666666667, -0.04, 0
3540, 0.66666666666667, -0.08, 0
3541, 0.66666666666667, -0.12, 0
3542, 0.66666666666667, -0.16, 0
3543, 0.75, -0.04, 0
3544, 0.75, -0.08, 0
3545, 0.75, -0.12, 0
3546, 0.75, -0.16, 0
3547, 0.83333333333333, -0.04, 0
3548, 0.83333333333333, -0.08, 0
3549, 0.83333333333333, -0.12, 0
3550, 0.83333333333333, -0.16, 0
3551, 0.91666666666667, -0.04, 0
3552, 0.91666666666667, -0.08, 0
3553, 0.91666666666667, -0.12, 0
3554, 0.91666666666667, -0.16, 0
3555, 1, -0.04, 0.083333333333333
3556, 1, -0.08, 0.083333333333333
3557, 1, -0.12, 0.083333333333333
3558, 1, -0.16, 0.083333333333333
3559, 1, -0.04, 0.16666666666667
3560, 1, -0.08, 0.16666666666667
3561, 1, -0.12, 0.16666666666667
3562, 1, -0.16, 0.16666666666667
3563, 1, -0.04, 0.25
3564, 1, -0.08, 0.25
3565, 1, -0.12, 0.25
3566, 1, -0.16, 0.25
3567, 1, -0.04, 0.33333333333333
3568, 1, -0.08, 0.33333333333333
3569, 1, -0.12, 0.33333333333333
3570, 1, -0.16, 0.33333333333333
3571, 1, -0.04, 0.41666666666667
3572, 1, -0.08, 0.41666666666667
3573, 1, -0.12, 0.41666666666667
3574, 1, -0.16, 0.41666666666667
3575, 0.083333333333333, -0.04, 0.5
3576, 0.083333333333333, -0.08, 0.5
3577, 0.083333333333333, -0.12, 0.5
3578, 0.083333333333333, -0.16, 0.5
3579, 0.16666666666667, -0.04, 0.5
3580, 0.16666666666667, -0.08, 0.5
3581, 0.16666666666667, -0.12, 0.5
3582, 0.16666666666667, -0.16, 0.5
3583, 0.25, -0.04, 0.5
3584, 0.25, -0.08, 0.5
3585, 0.25, -0.12, 0.5
3586, 0.25, -0.16, 0.5
3587, 0.33333333333333, -0.04, 0.5
3588, 0.33333333333333, -0.08, 0.5
3589, 0.33333333333333, -0.12, 0.5
3590, 0.33333333333333, -0.16, 0.5
3591, 0.41666666666667, -0.04, 0.5
3592, 0.41666666666667, -0.08, 0.5
3593, 0.41666666666667, -0.12, 0.5
3594, 0.41666666666667, -0.16, 0.5
3595, 0.5, -0.04, 0.5
3596, 0.5, -0.08, 0.5
3597, 0.5, -0.12, 0.5
3598, 0.5, -0.16, 0.5
3599, 0.58333333333333, -0.04, 0.5
3600, 0.58333333333333, -0.08, 0.5
3601, 0.58333333333333, -0.12, 0.5
3602, 0.58333333333333, -0.16, 0.5
3603, 0.66666666666667, -0.04, 0.5
3604, 0.66666666666667, -0.08, 0.5
3605, 0.66666666666667, -0.12, 0.5
3606, 0.66666666666667, -0.16, 0.5
3607, 0.75, -0.04, 0.5
3608, 0.75, -0.08, 0.5
3609, 0.75, -0.12, 0.5
3610, 0.75, -0.16, 0.5
3611, 0.83333333333333, -0.04, 0.5
3612, 0.83333333333333, -0.08, 0.5
3613, 0.83333333333333, -0.12, 0.5
3614, 0.83333333333333, -0.16, 0.5
3615, 0.91666666666667, -0.04, 0.5
3616, 0.91666666666667, -0.08, 0.5
3617, 0.91666666666667, -0.12, 0.5
3618, 0.91666666666667, -0.16, 0.5
3619, 0, -0.04, 0.083333333333333
3620, 0, -0.08, 0.083333333333333
3621, 0, -0.12, 0.083333333333333
3622, 0, -0.16, 0.083333333333333
3623, 0, -0.04, 0.16666666666667
3624, 0, -0.08, 0.16666666666667
3625, 0, -0.12, 0.16666666666667
3626, 0, -0.16, 0.16666666666667
3627, 0, -0.04, 0.25
3628, 0, -0.08, 0.25
3629, 0, -0.12, 0.25
3630, 0, -0.16, 0.25
3631, 0, -0.04, 0.33333333333333
3632, 0, -0.08, 0.33333333333333
3633, 0, -0.12, 0.33333333333333
3634, 0, -0.16, 0.33333333333333
3635, 0, -0.04, 0.41666666666667
3636, 0, -0.08, 0.41666666666667
3637, 0, -0.12, 0.41666666666667
3638, 0, -0.16, 0.41666666666667
3639, 0.083333333333333, -0.2, 0.083333333333333
3640, 0.083333333333333, -0.2, 0.16666666666667
3641, 0.083333333333333, -0.2, 0.25
3642, 0.083333333333333, -0.2, 0.33333333333333
3643, 0.083333333333333, -0.2, 0.41666666666667
3644, 0.16666666666667, -0.2, 0.083333333333333
3645, 0.16666666666667, -0.2, 0.16666666666667
3646, 0.16666666666667, -0.2, 0.25
3647, 0.16666666666667, -0.2, 0.33333333333333
3648, 0.16666666666667, -0.2, 0.41666666666667
3649, 0.25, -0.2, 0.083333333333333
3650, 0.25, -0.2, 0.16666666666667
3651, 0.25, -0.2, 0.25
3652, 0.25, -0.2, 0.33333333333333
3653, 0.25, -0.2, 0.41666666666667
3654, 0.33333333333333, -0.2, 0.083333333333333
3655, 0.33333333333333, -0.2, 0.16666666666667
3656, 0.33333333333333, -0.2, 0.25
3657, 0.33333333333333, -0.2, 0.33333333333333
3658, 0.33333333333333, -0.2, 0.41666666666667
3659, 0.41666666666667, -0.2, 0.083333333333333
3660, 0.41666666666667, -0.2, 0.16666666666667
3661, 0.41666666666667, -0.2, 0.25
3662, 0.41666666666667, -0.2, 0.33333333333333
3663, 0.41666666666667, -0.2, 0.41666666666667
3664, 0.5, -0.2, 0.083333333333333
3665, 0.5, -0.2, 0.16666666666667
3666, 0.5, -0.2, 0.25
3667, 0.5, -0.2, 0.33333333333333
3668, 0.5, -0.2, 0.41666666666667
3669, 0.58333333333333, -0.2, 0.083333333333333
3670, 0.58333333333333, -0.2, 0.16666666666667
3671, 0.58333333333333, -0.2, 0.25
3672, 0.58333333333333, -0.2, 0.33333333333333
3673, 0.58333333333333, -0.2, 0.41666666666667
3674, 0.66666666666667, -0.2, 0.083333333333333
3675, 0.66666666666667, -0.2, 0.16666666666667
3676, 0.66666666666667, -0.2, 0.25
3677, 0.66666666666667, -0.2, 0.33333333333333
3678, 0.66666666666667, -0.2, 0.41666666666667
3679, 0.75, -0.2, 0.083333333333333
3680, 0.75, -0.2, 0.16666666666667
3681, 0.75, -0.2, 0.25
3682, 0.75, -0.2, 0.33333333333333
3683, 0.75, -0.2, 0.41666666666667
3684, 0.83333333333333, -0.2, 0.083333333333333
3685, 0.83333333333333, -0.2, 0.16666666666667
3686, 0.83333333333333, -0.2, 0.25
3687, 0.83333333333333, -0.2, 0.33333333333333
3688, 0.83333333333333, -0.2, 0.41666666666667
3689, 0.91666666666667, -0.2, 0.083333333333333
3690, 0.91666666666667, -0.2, 0.16666666666667
3691, 0.91666666666667, -0.2, 0.25
3692, 0.91666666666667, -0.2, 0.33333333333333
3693, 0.91666666666667, -0.2, 0.41666666666667
3694, -0.1, -0.04, 0.083333333333333
3695, -0.1, -0.08, 0.083333333333333
3696, -0.1, -0.12, 0.083333333333333
3697, -0.1, -0.16, 0.083333333333333
3698, -0.1, -0.04, 0.16666666666667
3699, -0.1, -0.08, 0.16666666666667
3700, -0.1, -0.12, 0.16666666666667
3701, -0.1, -0.16, 0.16666666666667
3702, -0.1, -0.04, 0.25
3703, -0.1, -0.08, 0.25
3704, -0.1, -0.12, 0.25
3705, -0.1, -0.16, 0.25
3706, -0.1, -0.04, 0.33333333333333
3707, -0.1, -0.08, 0.33333333333333
3708, -0.1, -0.12, 0.33333333333333
3709, -0.1, -0.16, 0.33333333333333
3710, -0.1, -0.04, 0.41666666666667
3711, -0.1, -0.08, 0.41666666666667
3712, -0.1, -0.12, 0.41666666666667
3713, -0.1, -0.16, 0.41666666666667
3714, 1.2833333333333, -0.04, 0.5
3715, 1.2833333333333, -0.08, 0.5
3716, 1.2833333333333, -0.12, 0.5
3717, 1.2833333333333, -0.16, 0.5
3718, 1.3666666666667, -0.04, 0.5
3719, 1.3666666666667, -0.08, 0.5
3720, 1.3666666666667, -0.12, 0.5
3721, 1.3666666666667, -0.16, 0.5
3722, 1.45, -0.04, 0.5
3723, 1.45, -0.08, 0.5
3724, 1.45, -0.12, 0.5
3725, 1.45, -0.16, 0.5
3726, 1.5333333333333, -0.04, 0.5
3727, 1.5333333333333, -0.08, 0.5
3728, 1.5333333333333, -0.12, 0.5
3729, 1.5333333333333, -0.16, 0.5
3730, 1.6166666666667, -0.04, 0.5
3731, 1.6166666666667, -0.08, 0.5
3732, 1.6166666666667, -0.12, 0.5
3733, 1.6166666666667, -0.16, 0.5
3734, 1.7, -0.04, 0.5
3735, 1.7, -0.08, 0.5
3736, 1.7, -0.12, 0.5
3737, 1.7, -0.16, 0.5
3738, 1.7833333333333, -0.04, 0.5
3739, 1.7833333333333, -0.08, 0.5
3740, 1.7833333333333, -0.12, 0.5
3741, 1.7833333333333, -0.16, 0.5
3742, 1.8666666666667, -0.04, 0.5
3743, 1.8666666666667, -0.08, 0.5
3744, 1.8666666666667, -0.12, 0.5
3745, 1.8666666666667, -0.16, 0.5
3746, 1.95, -0.04, 0.5
3747, 1.95, -0.08, 0.5
3748, 1.95, -0.12, 0.5
3749, 1.95, -0.16, 0.5
3750, 2.0333333333333, -0.04, 0.5
3751, 2.0333333333333, -0.08, 0.5
3752, 2.0333333333333, -0.12, 0.5
3753, 2.0333333333333, -0.16, 0.5
3754, 2.1166666666667, -0.04, 0.5
3755, 2.1166666666667, -0.08, 0.5
3756, 2.1166666666667, -0.12, 0.5
3757, 2.1166666666667, -0.16, 0.5
3758, 1.2833333333333, -0.04, 0
3759, 1.2833333333333, -0.08, 0
3760, 1.2833333333333, -0.12, 0
3761, 1.2833333333333, -0.16, 0
3762, 1.3666666666667, -0.04, 0
3763, 1.3666666666667, -0.08, 0
3764, 1.3666666666667, -0.12, 0
3765, 1.3666666666667, -0.16, 0
3766, 1.45, -0.04, 0
3767, 1.45, -0.08, 0
3768, 1.45, -0.12, 0
3769, 1.45, -0.16, 0
3770, 1.5333333333333, -0.04, 0
3771, 1.5333333333333, -0.08, 0
3772, 1.5333333333333, -0.12, 0
3773, 1.5333333333333, -0.16, 0
3774, 1.6166666666667, -0.04, 0
3775, 1.6166666666667, -0.08, 0
3776, 1.6166666666667, -0.12, 0
3777, 1.6166666666667, -0.16, 0
3778, 1.7, -0.04, 0
3779, 1.7, -0.08, 0
3780, 1.7, -0.12, 0
3781, 1.7, -0.16, 0
3782, 1.7833333333333, -0.04, 0
3783, 1.7833333333333, -0.08, 0
3784, 1.7833333333333, -0.12, 0
3785, 1.7833333333333, -0.16, 0
3786, 1.8666666666667, -0.04, 0
3787, 1.8666666666667, -0.08, 0
3788, 1.8666666666667, -0.12, 0
3789, 1.8666666666667, -0.16, 0
3790, 1.95, -0.04, 0
3791, 1.95, -0.08, 0
3792, 1.95, -0.12, 0
3793, 1.95, -0.16, 0
3794, 2.0333333333333, -0.04, 0
3795, 2.0333333333333, -0.08, 0
3796, 2.0333333333333, -0.12, 0
3797, 2.0333333333333, -0.16, 0
3798, 2.1166666666667, -0.04, 0
3799, 2.1166666666667, -0.08, 0
3800, 2.1166666666667, -0.12, 0
3801, 2.1166666666667, -0.16, 0
3802, 1.2, -0.04, 0.083333333333333
3803, 1.2, -0.08, 0.083333333333333
3804, 1.2, -0.12, 0.083333333333333
3805, 1.2, -0.16, 0.083333333333333
3806, 1.2, -0.04, 0.16666666666667
3807, 1.2, -0.08, 0.16666666666667
3808, 1.2, -0.12, 0.16666666666667
3809, 1.2, -0.16, 0.16666666666667
3810, 1.2, -0.04, 0.25
3811, 1.2, -0.08, 0.25
3812, 1.2, -0.12, 0.25
3813, 1.2, -0.16, 0.25
3814, 1.2, -0.04, 0.33333333333333
3815, 1.2, -0.08, 0.33333333333333
3816, 1.2, -0.12, 0.33333333333333
3817, 1.2, -0.16, 0.33333333333333
3818, 1.2, -0.04, 0.41666666666667
3819, 1.2, -0.08, 0.41666666666667
3820, 1.2, -0.12, 0.41666666666667
3821, 1.2, -0.16, 0.41666666666667
3822, 2.2, -0.04, 0.083333333333333
3823, 2.2, -0.08, 0.083333333333333
3824, 2.2, -0.12, 0.083333333333333
3825, 2.2, -0.16, 0.083333333333333
3826, 2.2, -0.04, 0.16666666666667
3827, 2.2, -0.08, 0.16666666666667
3828, 2.2, -0.12, 0.16666666666667
3829, 2.2, -0.16, 0.16666666666667
3830, 2.2, -0.04, 0.25
3831, 2.2, -0.08, 0.25
3832, 2.2, -0.12, 0.25
3833, 2.2, -0.16, 0.25
3834, 2.2, -0.04, 0.33333333333333
3835, 2.2, -0.08, 0.33333333333333
3836, 2.2, -0.12, 0.33333333333333
3837, 2.2, -0.16, 0.33333333333333
3838, 2.2, -0.04, 0.41666666666667
3839, 2.2, -0.08, 0.41666666666667
3840, 2.2, -0.12, 0.41666666666667
3841, 2.2, -0.16, 0.41666666666667
3842, 1.2833333333333, -0.2, 0.083333333333333
3843, 1.3666666666667, -0.2, 0.083333333333333
3844, 1.45, -0.2, 0.083333333333333
3845, 1.5333333333333, -0.2, 0.083333333333333
3846, 1.6166666666667, -0.2, 0.083333333333333
3847, 1.7, -0.2, 0.083333333333333
3848, 1.7833333333333, -0.2, 0.083333333333333
3849, 1.8666666666667, -0.2, 0.083333333333333
3850, 1.95, -0.2, 0.083333333333333
3851, 2.0333333333333, -0.2, 0.083333333333333
3852, 2.1166666666667, -0.2, 0.083333333333333
3853, 1.2833333333333, -0.2, 0.16666666666667
3854, 1.3666666666667, -0.2, 0.16666666666667
3855, 1.45, -0.2, 0.16666666666667
3856, 1.5333333333333, -0.2, 0.16666666666667
3857, 1.6166666666667, -0.2, 0.16666666666667
3858, 1.7, -0.2, 0.16666666666667
3859, 1.7833333333333, -0.2, 0.16666666666667
3860, 1.8666666666667, -0.2, 0.16666666666667
3861, 1.95, -0.2, 0.16666666666667
3862, 2.0333333333333, -0.2, 0.16666666666667
3863, 2.1166666666667, -0.2, 0.16666666666667
3864, 1.2833333333333, -0.2, 0.25
3865, 1.3666666666667, -0.2, 0.25
3866, 1.45, -0.2, 0.25
3867, 1.5333333333333, -0.2, 0.25
3868, 1.6166666666667, -0.2, 0.25
3869, 1.7, -0.2, 0.25
3870, 1.7833333333333, -0.2, 0.25
3871, 1.8666666666667, -0.2, 0.25
3872, 1.95, -0.2, 0.25
3873, 2.0333333333333, -0.2, 0.25
3874, 2.1166666666667, -0.2, 0.25
3875, 1.2833333333333, -0.2, 0.33333333333333
3876, 1.3666666666667, -0.2, 0.33333333333333
3877, 1.45, -0.2, 0.33333333333333
3878, 1.5333333333333, -0.2, 0.33333333333333
3879, 1.6166666666667, -0.2, 0.33333333333333
3880, 1.7, -0.2, 0.33333333333333
3881, 1.7833333333333, -0.2, 0.33333333333333
3882, 1.8666666666667, -0.2, 0.33333333333333
3883, 1.95, -0.2, 0.33333333333333
3884, 2.0333333333333, -0.2, 0.33333333333333
3885, 2.1166666666667, -0.2, 0.33333333333333
3886, 1.2833333333333, -0.2, 0.41666666666667
3887, 1.3666666666667, -0.2, 0.41666666666667
3888, 1.45, -0.2, 0.41666666666667
3889, 1.5333333333333, -0.2, 0.41666666666667
3890, 1.6166666666667, -0.2, 0.41666666666667
3891, 1.7, -0.2, 0.41666666666667
3892, 1.7833333333333, -0.2, 0.41666666666667
3893, 1.8666666666667, -0.2, 0.41666666666667
3894, 1.95, -0.2, 0.41666666666667
3895, 2.0333333333333, -0.2, 0.41666666666667
3896, 2.1166666666667, -0.2, 0.41666666666667
3897, 2.3, -0.04, 0.083333333333333
3898, 2.3, -0.08, 0.083333333333333
3899, 2.3, -0.12, 0.083333333333333
3900, 2.3, -0.16, 0.083333333333333
3901, 2.3, -0.04, 0.16666666666667
3902, 2.3, -0.08, 0.16666666666667
3903, 2.3, -0.12, 0.16666666666667
3904, 2.3, -0.16, 0.16666666666667
3905, 2.3, -0.04, 0.25
3906, 2.3, -0.08, 0.25
3907, 2.3, -0.12, 0.25
3908, 2.3, -0.16, 0.25
3909, 2.3, -0.04, 0.33333333333333
3910, 2.3, -0.08, 0.33333333333333
3911, 2.3, -0.12, 0.33333333333333
3912, 2.3, -0.16, 0.33333333333333
3913, 2.3, -0.04, 0.41666666666667
3914, 2.3, -0.08, 0.41666666666667
3915, 2.3, -0.12, 0.41666666666667
3916, 2.3, -0.16, 0.41666666666667
3917, 0.083333333333333, 0.033333333333333, 0.083333333333333
3918, 0.16666666666667, 0.033333333333333, 0.083333333333333
3919, 0.25, 0.033333333333333, 0.083333333333333
3920, 0.33333333333333, 0.033333333333333, 0.083333333333333
3921, 0.41666666666667, 0.033333333333333, 0.083333333333333
3922, 0.5, 0.033333333333333, 0.083333333333333
3923, 0.58333333333333, 0.033333333333333, 0.083333333333333
3924, 0.66666666666667, 0.033333333333333, 0.083333333333333
3925, 0.75, 0.033333333333333, 0.083333333333333
3926, 0.83333333333333, 0.033333333333333, 0.083333333333333
3927, 0.91666666666667, 0.033333333333333, 0.083333333333333
3928, 0.083333333333333, 0.066666666666667, 0.083333333333333
3929, 0.16666666666667, 0.066666666666667, 0.083333333333333
3930, 0.25, 0.066666666666667, 0.083333333333333
3931, 0.33333333333333, 0.066666666666667, 0.083333333333333
3932, 0.41666666666667, 0.066666666666667, 0.083333333333333
3933, 0.5, 0.066666666666667, 0.083333333333333
3934, 0.58333333333333, 0.066666666666667, 0.083333333333333
3935, 0.66666666666667, 0.066666666666667, 0.083333333333333
3936, 0.75, 0.066666666666667, 0.083333333333333
3937, 0.83333333333333, 0.066666666666667, 0.083333333333333
3938, 0.91666666666667, 0.066666666666667, 0.083333333333333
3939, 0.083333333333333, 0.033333333333333, 0.16666666666667
3940, 0.16666666666667, 0.033333333333333, 0.16666666666667
3941, 0.25, 0.033333333333333, 0.16666666666667
3942, 0.33333333333333, 0.033333333333333, 0.16666666666667
3943, 0.41666666666667, 0.033333333333333, 0.16666666666667
3944, 0.5, 0.033333333333333, 0.16666666666667
3945, 0.58333333333333, 0.033333333333333, 0.16666666666667
3946, 0.66666666666667, 0.033333333333333, 0.16666666666667
3947, 0.75, 0.033333333333333, 0.16666666666667
3948, 0.83333333333333, 0.033333333333333, 0.16666666666667
3949, 0.91666666666667, 0.033333333333333, 0.16666666666667
3950, 0.083333333333333, 0.066666666666667, 0.16666666666667
3951, 0.16666666666667, 0.066666666666667, 0.16666666666667
3952, 0.25, 0.066666666666667, 0.16666666666667
3953, 0.33333333333333, 0.066666666666667, 0.16666666666667
3954, 0.41666666666667, 0.066666666666667, 0.16666666666667
3955, 0.5, 0.066666666666667, 0.16666666666667
3956, 0.58333333333333, 0.066666666666667, 0.16666666666667
3957, 0.66666666666667, 0.066666666666667, 0.16666666666667
3958, 0.75, 0.066666666666667, 0.16666666666667
3959, 0.83333333333333, 0.066666666666667, 0.16666666666667
3960, 0.91666666666667, 0.066666666666667, 0.16666666666667
3961, 0.083333333333333, 0.033333333333333, 0.25
3962, 0.16666666666667, 0.033333333333333, 0.25
3963, 0.25, 0.033333333333333, 0.25
3964, 0.33333333333333, 0.033333333333333, 0.25
3965, 0.41666666666667, 0.033333333333333, 0.25
3966, 0.5, 0.033333333333333, 0.25
3967, 0.58333333333333, 0.033333333333333, 0.25
3968, 0.66666666666667, 0.033333333333333, 0.25
3969, 0.75, 0.033333333333333, 0.25
3970, 0.83333333333333, 0.033333333333333, 0.25
3971, 0.91666666666667, 0.033333333333333, 0.25
3972, 0.083333333333333, 0.066666666666667, 0.25
3973, 0.16666666666667, 0.066666666666667, 0.25
3974, 0.25, 0.066666666666667, 0.25
3975, 0.33333333333333, 0.066666666666667, 0.25
3976, 0.41666666666667, 0.066666666666667, 0.25
3977, 0.5, 0.066666666666667, 0.25
3978, 0.58333333333333, 0.066666666666667, 0.25
3979, 0.66666666666667, 0.066666666666667, 0.25
3980, 0.75, 0.066666666666667, 0.25
3981, 0.83333333333333, 0.066666666666667, 0.25
3982, 0.91666666666667, 0.066666666666667, 0.25
3983, 0.083333333333333, 0.033333333333333, 0.33333333333333
3984, 0.16666666666667, 0.033333333333333, 0.33333333333333
3985, 0.25, 0.033333333333333, 0.33333333333333
3986, 0.33333333333333, 0.033333333333333, 0.33333333333333
3987, 0.41666666666667, 0.033333333333333, 0.33333333333333
3988, 0.5, 0.033333333333333, 0.33333333333333
3989, 0.58333333333333, 0.033333333333333, 0.33333333333333
3990, 0.66666666666667, 0.033333333333333, 0.33333333333333
3991, 0.75, 0.033333333333333, 0.33333333333333
3992, 0.83333333333333, 0.033333333333333, 0.33333333333333
3993, 0.91666666666667, 0.033333333333333, 0.33333333333333
3994, 0.083333333333333, 0.066666666666667, 0.33333333333333
3995, 0.16666666666667, 0.066666666666667, 0.33333333333333
3996, 0.25, 0.066666666666667, 0.33333333333333
3997, 0.33333333333333, 0.066666666666667, 0.33333333333333
3998, 0.41666666666667, 0.066666666666667, 0.33333333333333
3999, 0.5, 0.066666666666667, 0.33333333333333
4000, 0.58333333333333, 0.066666666666667, 0.33333333333333
4001, 0.66666666666667, 0.066666666666667, 0.33333333333333
4002, 0.75, 0.066666666666667, 0.33333333333333
4003, 0.83333333333333, 0.066666666666667, 0.33333333333333
4004, 0.91666666666667, 0.066666666666667, 0.33333333333333
4005, 0.083333333333333, 0.033333333333333, 0.41666666666667
4006, 0.16666666666667, 0.033333333333333, 0.41666666666667
4007, 0.25, 0.033333333333333, 0.41666666666667
4008, 0.33333333333333, 0.033333333333333, 0.41666666666667
4009, 0.41666666666667, 0.033333333333333, 0.41666666666667
4010, 0.5, 0.033333333333333, 0.41666666666667
4011, 0.58333333333333, 0.033333333333333, 0.41666666666667
4012, 0.66666666666667, 0.033333333333333, 0.41666666666667
4013, 0.75, 0.033333333333333, 0.41666666666667
4014, 0.83333333333333, 0.033333333333333, 0.41666666666667
4015, 0.91666666666667, 0.033333333333333, 0.41666666666667
4016, 0.083333333333333, 0.066666666666667, 0.41666666666667
4017, 0.16666666666667, 0.066666666666667, 0.41666666666667
4018, 0.25, 0.066666666666667, 0.41666666666667
4019, 0.33333333333333, 0.066666666666667, 0.41666666666667
4020, 0.41666666666667, 0.066666666666667, 0.41666666666667
4021, 0.5, 0.066666666666667, 0.41666666666667
4022, 0.58333333333333, 0.066666666666667, 0.41666666666667
4023, 0.66666666666667, 0.066666666666667, 0.41666666666667
4024, 0.75, 0.066666666666667, 0.41666666666667
4025, 0.83333333333333, 0.066666666666667, 0.41666666666667
4026, 0.91666666666667, 0.066666666666667, 0.41666666666667
4027, 0.083333333333333, 0.25, 0.083333333333333
4028, 0.083333333333333, 0.35, 0.083333333333333
4029, 0.083333333333333, 0.45, 0.083333333333333
4030, 0.083333333333333, 0.55, 0.083333333333333
4031, 0.083333333333333, 0.65, 0.083333333333333
4032, 0.083333333333333, 0.75, 0.083333333333333
4033, 0.083333333333333, 0.85, 0.083333333333333
4034, 0.083333333333333, 0.95, 0.083333333333333
4035, 0.083333333333333, 1.05, 0.083333333333333
4036, 0.083333333333333, 1.15, 0.083333333333333
4037, 0.083333333333333, 1.25, 0.083333333333333
4038, 0.083333333333333, 0.25, 0.16666666666667
4039, 0.083333333333333, 0.35, 0.16666666666667
4040, 0.083333333333333, 0.45, 0.16666666666667
4041, 0.083333333333333, 0.55, 0.16666666666667
4042, 0.083333333333333, 0.65, 0.16666666666667
4043, 0.083333333333333, 0.75, 0.16666666666667
4044, 0.083333333333333, 0.85, 0.16666666666667
4045, 0.083333333333333, 0.95, 0.16666666666667
4046, 0.083333333333333, 1.05, 0.16666666666667
4047, 0.083333333333333, 1.15, 0.16666666666667
4048, 0.083333333333333, 1.25, 0.16666666666667
4049, 0.083333333333333, 0.25, 0.25
4050, 0.083333333333333, 0.35, 0.25
4051, 0.083333333333333, 0.45, 0.25
4052, 0.083333333333333, 0.55, 0.25
4053, 0.083333333333333, 0.65, 0.25
4054, 0.083333333333333, 0.75, 0.25
4055, 0.083333333333333, 0.85, 0.25
4056, 0.083333333333333, 0.95, 0.25
4057, 0.083333333333333, 1.05, 0.25
4058, 0.083333333333333, 1.15, 0.25
4059, 0.083333333333333, 1.25, 0.25
4060, 0.083333333333333, 0.25, 0.33333333333333
4061, 0.083333333333333, 0.35, 0.33333333333333
4062, 0.083333333333333, 0.45, 0.33333333333333
4063, 0.083333333333333, 0.55, 0.33333333333333
4064, 0.083333333333333, 0.65, 0.33333333333333
4065, 0.083333333333333, 0.75, 0.33333333333333
4066, 0.083333333333333, 0.85, 0.33333333333333
4067, 0.083333333333333, 0.95, 0.33333333333333
4068, 0.083333333333333, 1.05, 0.33333333333333
4069, 0.083333333333333, 1.15, 0.33333333333333
4070, 0.083333333333333, 1.25, 0.33333333333333
4071, 0.083333333333333, 0.25, 0.41666666666667
4072, 0.083333333333333, 0.35, 0.41666666666667
4073, 0.083333333333333, 0.45, 0.41666666666667
4074, 0.083333333333333, 0.55, 0.41666666666667
4075, 0.083333333333333, 0.65, 0.41666666666667
4076, 0.083333333333333, 0.75, 0.41666666666667
4077, 0.083333333333333, 0.85, 0.41666666666667
4078, 0.083333333333333, 0.95, 0.41666666666667
4079, 0.083333333333333, 1.05, 0.41666666666667
4080, 0.083333333333333, 1.15, 0.41666666666667
4081, 0.083333333333333, 1.25, 0.41666666666667
4082, 0.16666666666667, 0.25, 0.083333333333333
4083, 0.16666666666667, 0.35, 0.083333333333333
4084, 0.16666666666667, 0.45, 0.083333333333333
4085, 0.16666666666667, 0.55, 0.083333333333333
4086, 0.16666666666667, 0.65, 0.083333333333333
4087, 0.16666666666667, 0.75, 0.083333333333333
4088, 0.16666666666667, 0.85, 0.083333333333333
4089, 0.16666666666667, 0.95, 0.083333333333333
4090, 0.16666666666667, 1.05, 0.083333333333333
4091, 0.16666666666667, 1.15, 0.083333333333333
4092, 0.16666666666667, 1.25, 0.083333333333333
4093, 0.16666666666667, 0.25, 0.16666666666667
4094, 0.16666666666667, 0.35, 0.16666666666667
4095, 0.16666666666667, 0.45, 0.16666666666667
4096, 0.16666666666667, 0.55, 0.16666666666667
4097, 0.16666666666667, 0.65, 0.16666666666667
4098, 0.16666666666667, 0.75, 0.16666666666667
4099, 0.16666666666667, 0.85, 0.16666666666667
4100, 0.16666666666667, 0.95, 0.16666666666667
4101, 0.16666666666667, 1.05, 0.16666666666667
4102, 0.16666666666667, 1.15, 0.16666666666667
4103, 0.16666666666667, 1.25, 0.16666666666667
4104, 0.16666666666667, 0.25, 0.25
4105, 0.16666666666667, 0.35, 0.25
4106, 0.16666666666667, 0.45, 0.25
4107, 0.16666666666667, 0.55, 0.25
4108, 0.16666666666667, 0.65, 0.25
4109, 0.16666666666667, 0.75, 0.25
4110, 0.16666666666667, 0.85, 0.25
4111, 0.16666666666667, 0.95, 0.25
4112, 0.16666666666667, 1.05, 0.25
4113, 0.16666666666667, 1.15, 0.25
4114, 0.16666666666667, 1.25, 0.25
4115, 0.16666666666667, 0.25, 0.33333333333333
4116, 0.16666666666667, 0.35, 0.33333333333333
4117, 0.16666666666667, 0.45, 0.33333333333333
4118, 0.16666666666667, 0.55, 0.33333333333333
4119, 0.16666666666667, 0.65, 0.33333333333333
4120, 0.16666666666667, 0.75, 0.33333333333333
4121, 0.16666666666667, 0.85, 0.33333333333333
4122, 0.16666666666667, 0.95, 0.33333333333333
4123, 0.16666666666667, 1.05, 0.33333333333333
4124, 0.16666666666667, 1.15, 0.33333333333333
4125, 0.16666666666667, 1.25, 0.33333333333333
4126, 0.16666666666667, 0.25, 0.41666666666667
4127, 0.16666666666667, 0.35, 0.41666666666667
4128, 0.16666666666667, 0.45, 0.41666666666667
4129, 0.16666666666667, 0.55, 0.41666666666667
4130, 0.16666666666667, 0.65, 0.41666666666667
4131, 0.16666666666667, 0.75, 0.41666666666667
4132, 0.16666666666667, 0.85, 0.41666666666667
4133, 0.16666666666667, 0.95, 0.41666666666667
4134, 0.16666666666667, 1.05, 0.41666666666667
4135, 0.16666666666667, 1.15, 0.41666666666667
4136, 0.16666666666667, 1.25, 0.41666666666667
4137, 0.25, 0.25, 0.083333333333333
4138, 0.25, 0.35, 0.083333333333333
4139, 0.25, 0.45, 0.083333333333333
4140, 0.25, 0.55, 0.083333333333333
4141, 0.25, 0.65, 0.083333333333333
4142, 0.25, 0.75, 0.083333333333333
4143, 0.25, 0.85, 0.083333333333333
4144, 0.25, 0.95, 0.083333333333333
4145, 0.25, 1.05, 0.083333333333333
4146, 0.25, 1.15, 0.083333333333333
4147, 0.25, 1.25, 0.083333333333333
4148, 0.25, 0.25, 0.16666666666667
4149, 0.25, 0.35, 0.16666666666667
4150, 0.25, 0.45, 0.16666666666667
4151, 0.25, 0.55, 0.16666666666667
4152, 0.25, 0.65, 0.16666666666667
4153, 0.25, 0.75, 0.16666666666667
4154, 0.25, 0.85, 0.16666666666667
4155, 0.25, 0.95, 0.16666666666667
4156, 0.25, 1.05, 0.16666666666667
4157, 0.25, 1.15, 0.16666666666667
4158, 0.25, 1.25, 0.16666666666667
4159, 0.25, 0.25, 0.25
4160, 0.25, 0.35, 0.25
4161, 0.25, 0.45, 0.25
4162, 0.25, 0.55, 0.25
4163, 0.25, 0.65, 0.25
4164, 0.25, 0.75, 0.25
4165, 0.25, 0.85, 0.25
4166, 0.25, 0.95, 0.25
4167, 0.25, 1.05, 0.25
4168, 0.25, 1.15, 0.25
4169, 0.25, 1.25, 0.25
4170, 0.25, 0.25, 0.33333333333333
4171, 0.25, 0.35, 0.33333333333333
4172, 0.25, 0.45, 0.33333333333333
4173, 0.25, 0.55, 0.33333333333333
4174, 0.25, 0.65, 0.33333333333333
4175, 0.25, 0.75, 0.33333333333333
4176, 0.25, 0.85, 0.33333333333333
4177, 0.25, 0.95, 0.33333333333333
4178, 0.25, 1.05, 0.33333333333333
4179, 0.25, 1.15, 0.33333333333333
4180, 0.25, 1.25, 0.33333333333333
4181, 0.25, 0.25, 0.41666666666667
4182, 0.25, 0.35, 0.41666666666667
4183, 0.25, 0.45, 0.41666666666667
4184, 0.25, 0.55, 0.41666666666667
4185, 0.25, 0.65, 0.41666666666667
4186, 0.25, 0.75, 0.41666666666667
4187, 0.25, 0.85, 0.41666666666667
4188, 0.25, 0.95, 0.41666666666667
4189, 0.25, 1.05, 0.41666666666667
4190, 0.25, 1.15, 0.41666666666667
4191, 0.25, 1.25, 0.41666666666667
4192, 0.33333333333333, 0.25, 0.083333333333333
4193, 0.33333333333333, 0.35, 0.083333333333333
4194, 0.33333333333333, 0.45, 0.083333333333333
4195, 0.33333333333333, 0.55, 0.083333333333333
4196, 0.33333333333333, 0.65, 0.083333333333333
4197, 0.33333333333333, 0.75, 0.083333333333333
4198, 0.33333333333333, 0.85, 0.083333333333333
4199, 0.33333333333333, 0.95, 0.083333333333333
4200, 0.33333333333333, 1.05, 0.083333333333333
4201, 0.33333333333333, 1.15, 0.083333333333333
4202, 0.33333333333333, 1.25, 0.083333333333333
4203, 0.33333333333333, 0.25, 0.16666666666667
4204, 0.33333333333333, 0.35, 0.16666666666667
4205, 0.33333333333333, 0.45, 0.16666666666667
4206, 0.33333333333333, 0.55, 0.16666666666667
4207, 0.33333333333333, 0.65, 0.16666666666667
4208, 0.33333333333333, 0.75, 0.16666666666667
4209, 0.33333333333333, 0.85, 0.16666666666667
4210, 0.33333333333333, 0.95, 0.16666666666667
4211, 0.33333333333333, 1.05, 0.16666666666667
4212, 0.33333333333333, 1.15, 0.16666666666667
4213, 0.33333333333333, 1.25, 0.16666666666667
4214, 0.33333333333333, 0.25, 0.25
4215, 0.33333333333333, 0.35, 0.25
4216, 0.33333333333333, 0.45, 0.25
4217, 0.33333333333333, 0.55, 0.25
4218, 0.33333333333333, 0.65, 0.25
4219, 0.33333333333333, 0.75, 0.25
4220, 0.33333333333333, 0.85, 0.25
4221, 0.33333333333333, 0.95, 0.25
4222, 0.33333333333333, 1.05, 0.25
4223, 0.33333333333333, 1.15, 0.25
4224, 0.33333333333333, 1.25, 0.25
4225, 0.33333333333333, 0.25, 0.33333333333333
4226, 0.33333333333333, 0.35, 0.33333333333333
4227, 0.33333333333333, 0.45, 0.33333333333333
4228, 0.33333333333333, 0.55, 0.33333333333333
4229, 0.33333333333333, 0.65, 0.33333333333333
4230, 0.33333333333333, 0.75, 0.33333333333333
4231, 0.33333333333333, 0.85, 0.33333333333333
4232, 0.33333333333333, 0.95, 0.33333333333333
4233, 0.33333333333333, 1.05, 0.33333333333333
4234, 0.33333333333333, 1.15, 0.33333333333333
4235, 0.33333333333333, 1.25, 0.33333333333333
4236, 0.33333333333333, 0.25, 0.41666666666667
4237, 0.33333333333333, 0.35, 0.41666666666667
4238, 0.33333333333333, 0.45, 0.41666666666667
4239, 0.33333333333333, 0.55, 0.41666666666667
4240, 0.33333333333333, 0.65, 0.41666666666667
4241, 0.33333333333333, 0.75, 0.41666666666667
4242, 0.33333333333333, 0.85, 0.41666666666667
4243, 0.33333333333333, 0.95, 0.41666666666667
4244, 0.33333333333333, 1.05, 0.41666666666667
4245, 0.33333333333333, 1.15, 0.41666666666667
4246, 0.33333333333333, 1.25, 0.41666666666667
4247, 0.41666666666667, 0.25, 0.083333333333333
4248, 0.41666666666667, 0.35, 0.083333333333333
4249, 0.41666666666667, 0.45, 0.083333333333333
4250, 0.41666666666667, 0.55, 0.083333333333333
4251, 0.41666666666667, 0.65, 0.083333333333333
4252, 0.41666666666667, 0.75, 0.083333333333333
4253, 0.41666666666667, 0.85, 0.083333333333333
4254, 0.41666666666667, 0.95, 0.083333333333333
4255, 0.41666666666667, 1.05, 0.083333333333333
4256, 0.41666666666667, 1.15, 0.083333333333333
4257, 0.41666666666667, 1.25, 0.083333333333333
4258, 0.41666666666667, 0.25, 0.16666666666667
4259, 0.41666666666667, 0.35, 0.16666666666667
4260, 0.41666666666667, 0.45, 0.16666666666667
4261, 0.41666666666667, 0.55, 0.16666666666667
4262, 0.41666666666667, 0.65, 0.16666666666667
4263, 0.41666666666667, 0.75, 0.16666666666667
4264, 0.41666666666667, 0.85, 0.16666666666667
4265, 0.41666666666667, 0.95, 0.16666666666667
4266, 0.41666666666667, 1.05, 0.16666666666667
4267, 0.41666666666667, 1.15, 0.16666666666667
4268, 0.41666666666667, 1.25, 0.16666666666667
4269, 0.41666666666667, 0.25, 0.25
4270, 0.41666666666667, 0.35, 0.25
4271, 0.41666666666667, 0.45, 0.25
4272, 0.41666666666667, 0.55, 0.25
4273, 0.41666666666667, 0.65, 0.25
4274, 0.41666666666667, 0.75, 0.25
4275, 0.41666666666667, 0.85, 0.25
4276, 0.41666666666667, 0.95, 0.25
4277, 0.41666666666667, 1.05, 0.25
4278, 0.41666666666667, 1.15, 0.25
4279, 0.41666666666667, 1.25, 0.25
4280, 0.41666666666667, 0.25, 0.33333333333333
4281, 0.41666666666667, 0.35, 0.33333333333333
4282, 0.41666666666667, 0.45, 0.33333333333333
4283, 0.41666666666667, 0.55, 0.33333333333333
4284, 0.41666666666667, 0.65, 0.33333333333333
4285, 0.41666666666667, 0.75, 0.33333333333333
4286, 0.41666666666667, 0.85, 0.33333333333333
4287, 0.41666666666667, 0.95, 0.33333333333333
4288, 0.41666666666667, 1.05, 0.33333333333333
4289, 0.41666666666667, 1.15, 0.33333333333333
4290, 0.41666666666667, 1.25, 0.33333333333333
4291, 0.41666666666667, 0.25, 0.41666666666667
4292, 0.41666666666667, 0.35, 0.41666666666667
4293, 0.41666666666667, 0.45, 0.41666666666667
4294, 0.41666666666667, 0.55, 0.41666666666667
4295, 0.41666666666667, 0.65, 0.41666666666667
4296, 0.41666666666667, 0.75, 0.41666666666667
4297, 0.41666666666667, 0.85, 0.41666666666667
4298, 0.41666666666667, 0.95, 0.41666666666667
4299, 0.41666666666667, 1.05, 0.41666666666667
4300, 0.41666666666667, 1.15, 0.41666666666667
4301, 0.41666666666667, 1.25, 0.41666666666667
4302, 0.5, 0.25, 0.083333333333333
4303, 0.5, 0.35, 0.083333333333333
4304, 0.5, 0.45, 0.083333333333333
4305, 0.5, 0.55, 0.083333333333333
4306, 0.5, 0.65, 0.083333333333333
4307, 0.5, 0.75, 0.083333333333333
4308, 0.5, 0.85, 0.083333333333333
4309, 0.5, 0.95, 0.083333333333333
4310, 0.5, 1.05, 0.083333333333333
4311, 0.5, 1.15, 0.083333333333333
4312, 0.5, 1.25, 0.083333333333333
4313, 0.5, 0.25, 0.16666666666667
4314, 0.5, 0.35, 0.16666666666667
4315, 0.5, 0.45, 0.16666666666667
4316, 0.5, 0.55, 0.16666666666667
4317, 0.5, 0.65, 0.16666666666667
4318, 0.5, 0.75, 0.16666666666667
4319, 0.5, 0.85, 0.16666666666667
4320, 0.5, 0.95, 0.16666666666667
4321, 0.5, 1.05, 0.16666666666667
4322, 0.5, 1.15, 0.16666666666667
4323, 0.5, 1.25, 0.16666666666667
4324, 0.5, 0.25, 0.25
4325, 0.5, 0.35, 0.25
4326, 0.5, 0.45, 0.25
4327, 0.5, 0.55, 0.25
4328, 0.5, 0.65, 0.25
4329, 0.5, 0.75, 0.25
4330, 0.5, 0.85, 0.25
4331, 0.5, 0.95, 0.25
4332, 0.5, 1.05, 0.25
4333, 0.5, 1.15, 0.25
4334, 0.5, 1.25, 0.25
4335, 0.5, 0.25, 0.33333333333333
4336, 0.5, 0.35, 0.33333333333333
4337, 0.5, 0.45, 0.33333333333333
4338, 0.5, 0.55, 0.33333333333333
4339, 0.5, 0.65, 0.33333333333333
4340, 0.5, 0.75, 0.33333333333333
4341, 0.5, 0.85, 0.33333333333333
4342, 0.5, 0.95, 0.33333333333333
4343, 0.5, 1.05, 0.33333333333333
4344, 0.5, 1.15, 0.33333333333333
4345, 0.5, 1.25, 0.33333333333333
4346, 0.5, 0.25, 0.41666666666667
4347, 0.5, 0.35, 0.41666666666667
4348, 0.5, 0.45, 0.41666666666667
4349, 0.5, 0.55, 0.41666666666667
4350, 0.5, 0.65, 0.41666666666667
4351, 0.5, 0.75, 0.41666666666667
4352, 0.5, 0.85, 0.41666666666667
4353, 0.5, 0.95, 0.41666666666667
4354, 0.5, 1.05, 0.41666666666667
4355, 0.5, 1.15, 0.41666666666667
4356, 0.5, 1.25, 0.41666666666667
4357, 0.58333333333333, 0.25, 0.083333333333333
4358, 0.58333333333333, 0.35, 0.083333333333333
4359, 0.58333333333333, 0.45, 0.083333333333333
4360, 0.58333333333333, 0.55, 0.083333333333333
4361, 0.58333333333333, 0.65, 0.083333333333333
4362, 0.58333333333333, 0.75, 0.083333333333333
4363, 0.58333333333333, 0.85, 0.083333333333333
4364, 0.58333333333333, 0.95, 0.083333333333333
4365, 0.58333333333333, 1.05, 0.083333333333333
4366, 0.58333333333333, 1.15, 0.083333333333333
4367, 0.58333333333333, 1.25, 0.083333333333333
4368, 0.58333333333333, 0.25, 0.16666666666667
4369, 0.58333333333333, 0.35, 0.16666666666667
4370, 0.58333333333333, 0.45, 0.16666666666667
4371, 0.58333333333333, 0.55, 0.16666666666667
4372, 0.58333333333333, 0.65, 0.16666666666667
4373, 0.58333333333333, 0.75, 0.16666666666667
4374, 0.58333333333333, 0.85, 0.16666666666667
4375, 0.58333333333333, 0.95, 0.16666666666667
4376, 0.58333333333333, 1.05, 0.16666666666667
4377, 0.58333333333333, 1.15, 0.16666666666667
4378, 0.58333333333333, 1.25, 0.16666666666667
4379, 0.58333333333333, 0.25, 0.25
4380, 0.58333333333333, 0.35, 0.25
4381, 0.58333333333333, 0.45, 0.25
4382, 0.58333333333333, 0.55, 0.25
4383, 0.58333333333333, 0.65, 0.25
4384, 0.58333333333333, 0.75, 0.25
4385, 0.58333333333333, 0.85, 0.25
4386, 0.58333333333333, 0.95, 0.25
4387, 0.58333333333333, 1.05, 0.25
4388, 0.58333333333333, 1.15, 0.25
4389, 0.58333333333333, 1.25, 0.25
4390, 0.58333333333333, 0.25, 0.33333333333333
4391, 0.58333333333333, 0.35, 0.33333333333333
4392, 0.58333333333333, 0.45, 0.33333333333333
4393, 0.58333333333333, 0.55, 0.33333333333333
4394, 0.58333333333333, 0.65, 0.33333333333333
4395, 0.58333333333333, 0.75, 0.33333333333333
4396, 0.58333333333333, 0.85, 0.33333333333333
4397, 0.58333333333333, 0.95, 0.33333333333333
4398, 0.58333333333333, 1.05, 0.33333333333333
4399, 0.58333333333333, 1.15, 0.33333333333333
4400, 0.58333333333333, 1.25, 0.33333333333333
4401, 0.58333333333333, 0.25, 0.41666666666667
4402, 0.58333333333333, 0.35, 0.41666666666667
4403, 0.58333333333333, 0.45, 0.41666666666667
4404, 0.58333333333333, 0.55, 0.41666666666667
4405, 0.58333333333333, 0.65, 0.41666666666667
4406, 0.58333333333333, 0.75, 0.41666666666667
4407, 0.58333333333333, 0.85, 0.41666666666667
4408, 0.58333333333333, 0.95, 0.41666666666667
4409, 0.58333333333333, 1.05, 0.41666666666667
4410, 0.58333333333333, 1.15, 0.41666666666667
4411, 0.58333333333333, 1.25, 0.41666666666667
4412, 0.66666666666667, 0.25, 0.083333333333333
4413, 0.66666666666667, 0.35, 0.083333333333333
4414, 0.66666666666667, 0.45, 0.083333333333333
4415, 0.66666666666667, 0.55, 0.083333333333333
4416, 0.66666666666667, 0.65, 0.083333333333333
4417, 0.66666666666667, 0.75, 0.083333333333333
4418, 0.66666666666667, 0.85, 0.083333333333333
4419, 0.66666666666667, 0.95, 0.083333333333333
4420, 0.66666666666667, 1.05, 0.083333333333333
4421, 0.66666666666667, 1.15, 0.083333333333333
4422, 0.66666666666667, 1.25, 0.083333333333333
4423, 0.66666666666667, 0.25, 0.16666666666667
4424, 0.66666666666667, 0.35, 0.16666666666667
4425, 0.66666666666667, 0.45, 0.16666666666667
4426, 0.66666666666667, 0.55, 0.16666666666667
4427, 0.66666666666667, 0.65, 0.16666666666667
4428, 0.66666666666667, 0.75, 0.16666666666667
4429, 0.66666666666667, 0.85, 0.16666666666667
4430, 0.66666666666667, 0.95, 0.16666666666667
4431, 0.66666666666667, 1.05, 0.16666666666667
4432, 0.66666666666667, 1.15, 0.16666666666667
4433, 0.66666666666667, 1.25, 0.16666666666667
4434, 0.66666666666667, 0.25, 0.25
4435, 0.66666666666667, 0.35, 0.25
4436, 0.66666666666667, 0.45, 0.25
4437, 0.66666666666667, 0.55, 0.25
4438, 0.66666666666667, 0.65, 0.25
4439, 0.66666666666667, 0.75, 0.25
4440, 0.66666666666667, 0.85, 0.25
4441, 0.66666666666667, 0.95, 0.25
4442, 0.66666666666667, 1.05, 0.25
4443, 0.66666666666667, 1.15, 0.25
4444, 0.66666666666667, 1.25, 0.25
4445, 0.66666666666667, 0.25, 0.33333333333333
4446, 0.66666666666667, 0.35, 0.33333333333333
4447, 0.66666666666667, 0.45, 0.33333333333333
4448, 0.66666666666667, 0.55, 0.33333333333333
4449, 0.66666666666667, 0.65, 0.33333333333333
4450, 0.66666666666667, 0.75, 0.33333333333333
4451, 0.66666666666667, 0.85, 0.33333333333333
4452, 0.66666666666667, 0.95, 0.33333333333333
4453, 0.66666666666667, 1.05, 0.33333333333333
4454, 0.66666666666667, 1.15, 0.33333333333333
4455, 0.66666666666667, 1.25, 0.33333333333333
4456, 0.66666666666667, 0.25, 0.41666666666667
4457, 0.66666666666667, 0.35, 0.41666666666667
4458, 0.66666666666667, 0.45, 0.41666666666667
4459, 0.66666666666667, 0.55, 0.41666666666667
4460, 0.66666666666667, 0.65, 0.41666666666667
4461, 0.66666666666667, 0.75, 0.41666666666667
4462, 0.66666666666667, 0.85, 0.41666666666667
4463, 0.66666666666667, 0.95, 0.41666666666667
4464, 0.66666666666667, 1.05, 0.41666666666667
4465, 0.66666666666667, 1.15, 0.41666666666667
4466, 0.66666666666667, 1.25, 0.41666666666667
4467, 0.75, 0.25, 0.083333333333333
4468, 0.75, 0.35, 0.083333333333333
4469, 0.75, 0.45, 0.083333333333333
4470, 0.75, 0.55, 0.083333333333333
4471, 0.75, 0.65, 0.083333333333333
4472, 0.75, 0.75, 0.083333333333333
4473, 0.75, 0.85, 0.083333333333333
4474, 0.75, 0.95, 0.083333333333333
4475, 0.75, 1.05, 0.083333333333333
4476, 0.75, 1.15, 0.083333333333333
4477, 0.75, 1.25, 0.083333333333333
4478, 0.75, 0.25, 0.16666666666667
4479, 0.75, 0.35, 0.16666666666667
4480, 0.75, 0.45, 0.16666666666667
4481, 0.75, 0.55, 0.16666666666667
4482, 0.75, 0.65, 0.16666666666667
4483, 0.75, 0.75, 0.16666666666667
4484, 0.75, 0.85, 0.16666666666667
4485, 0.75, 0.95, 0.16666666666667
4486, 0.75, 1.05, 0.16666666666667
4487, 0.75, 1.15, 0.16666666666667
4488, 0.75, 1.25, 0.16666666666667
4489, 0.75, 0.25, 0.25
4490, 0.75, 0.35, 0.25
4491, 0.75, 0.45, 0.25
4492, 0.75, 0.55, 0.25
4493, 0.75, 0.65, 0.25
4494, 0.75, 0.75, 0.25
4495, 0.75, 0.85, 0.25
4496, 0.75, 0.95, 0.25
4497, 0.75, 1.05, 0.25
4498, 0.75, 1.15, 0.25
4499, 0.75, 1.25, 0.25
4500, 0.75, 0.25, 0.33333333333333
4501, 0.75, 0.35, 0.33333333333333
4502, 0.75, 0.45, 0.33333333333333
4503, 0.75, 0.55, 0.33333333333333
4504, 0.75, 0.65, 0.33333333333333
4505, 0.75, 0.75, 0.33333333333333
4506, 0.75, 0.85, 0.33333333333333
4507, 0.75, 0.95, 0.33333333333333
4508, 0.75, 1.05, 0.33333333333333
4509, 0.75, 1.15, 0.33333333333333
4510, 0.75, 1.25, 0.33333333333333
4511, 0.75, 0.25, 0.41666666666667
4512, 0.75, 0.35, 0.41666666666667
4513, 0.75, 0.45, 0.41666666666667
4514, 0.75, 0.55, 0.41666666666667
4515, 0.75, 0.65, 0.41666666666667
4516, 0.75, 0.75, 0.41666666666667
4517, 0.75, 0.85, 0.41666666666667
4518, 0.75, 0.95, 0.41666666666667
4519, 0.75, 1.05, 0.41666666666667
4520, 0.75, 1.15, 0.41666666666667
4521, 0.75, 1.25, 0.41666666666667
4522, 0.83333333333333, 0.25, 0.083333333333333
4523, 0.83333333333333, 0.35, 0.083333333333333
4524, 0.83333333333333, 0.45, 0.083333333333333
4525, 0.83333333333333, 0.55, 0.083333333333333
4526, 0.83333333333333, 0.65, 0.083333333333333
4527, 0.83333333333333, 0.75, 0.083333333333333
4528, 0.83333333333333, 0.85, 0.083333333333333
4529, 0.83333333333333, 0.95, 0.083333333333333
4530, 0.83333333333333, 1.05, 0.083333333333333
4531, 0.83333333333333, 1.15, 0.083333333333333
4532, 0.83333333333333, 1.25, 0.083333333333333
4533, 0.83333333333333, 0.25, 0.16666666666667
4534, 0.83333333333333, 0.35, 0.16666666666667
4535, 0.83333333333333, 0.45, 0.16666666666667
4536, 0.83333333333333, 0.55, 0.16666666666667
4537, 0.83333333333333, 0.65, 0.16666666666667
4538, 0.83333333333333, 0.75, 0.16666666666667
4539, 0.83333333333333, 0.85, 0.16666666666667
4540, 0.83333333333333, 0.95, 0.16666666666667
4541, 0.83333333333333, 1.05, 0.16666666666667
4542, 0.83333333333333, 1.15, 0.16666666666667
4543, 0.83333333333333, 1.25, 0.16666666666667
4544, 0.83333333333333, 0.25, 0.25
4545, 0.83333333333333, 0.35, 0.25
4546, 0.83333333333333, 0.45, 0.25
4547, 0.83333333333333, 0.55, 0.25
4548, 0.83333333333333, 0.65, 0.25
4549, 0.83333333333333, 0.75, 0.25
4550, 0.83333333333333, 0.85, 0.25
4551, 0.83333333333333, 0.95, 0.25
4552, 0.83333333333333, 1.05, 0.25
4553, 0.83333333333333, 1.15, 0.25
4554, 0.83333333333333, 1.25, 0.25
4555, 0.83333333333333, 0.25, 0.33333333333333
4556, 0.83333333333333, 0.35, 0.33333333333333
4557, 0.83333333333333, 0.45, 0.33333333333333
4558, 0.83333333333333, 0.55, 0.33333333333333
4559, 0.83333333333333, 0.65, 0.33333333333333
4560, 0.83333333333333, 0.75, 0.33333333333333
4561, 0.83333333333333, 0.85, 0.33333333333333
4562, 0.83333333333333, 0.95, 0.33333333333333
4563, 0.83333333333333, 1.05, 0.33333333333333
4564, 0.83333333333333, 1.15, 0.33333333333333
4565, 0.83333333333333, 1.25, 0.33333333333333
4566, 0.83333333333333, 0.25, 0.41666666666667
4567, 0.83333333333333, 0.35, 0.41666666666667
4568, 0.83333333333333, 0.45, 0.41666666666667
4569, 0.83333333333333, 0.55, 0.41666666666667
4570, 0.83333333333333, 0.65, 0.41666666666667
4571, 0.83333333333333, 0.75, 0.41666666666667
4572, 0.83333333333333, 0.85, 0.41666666666667
4573, 0.83333333333333, 0.95, 0.41666666666667
4574, 0.83333333333333, 1.05, 0.41666666666667
4575, 0.83333333333333, 1.15, 0.41666666666667
4576, 0.83333333333333, 1.25, 0.41666666666667
4577, 0.91666666666667, 0.25, 0.083333333333333
4578, 0.91666666666667, 0.35, 0.083333333333333
4579, 0.91666666666667, 0.45, 0.083333333333333
4580, 0.91666666666667, 0.55, 0.083333333333333
4581, 0.91666666666667, 0.65, 0.083333333333333
4582, 0.91666666666667, 0.75, 0.083333333333333
4583, 0.91666666666667, 0.85, 0.083333333333333
4584, 0.91666666666667, 0.95, 0.083333333333333
4585, 0.91666666666667, 1.05, 0.083333333333333
4586, 0.91666666666667, 1.15, 0.083333333333333
4587, 0.91666666666667, 1.25, 0.083333333333333
4588, 0.91666666666667, 0.25, 0.16666666666667
4589, 0.91666666666667, 0.35, 0.16666666666667
4590, 0.91666666666667, 0.45, 0.16666666666667
4591, 0.91666666666667, 0.55, 0.16666666666667
4592, 0.91666666666667, 0.65, 0.16666666666667
4593, 0.91666666666667, 0.75, 0.16666666666667
4594, 0.91666666666667, 0.85, 0.16666666666667
4595, 0.91666666666667, 0.95, 0.16666666666667
4596, 0.91666666666667, 1.05, 0.16666666666667
4597, 0.91666666666667, 1.15, 0.16666666666667
4598, 0.91666666666667, 1.25, 0.16666666666667
4599, 0.91666666666667, 0.25, 0.25
4600, 0.91666666666667, 0.35, 0.25
4601, 0.91666666666667, 0.45, 0.25
4602, 0.91666666666667, 0.55, 0.25
4603, 0.91666666666667, 0.65, 0.25
4604, 0.91666666666667, 0.75, 0.25
4605, 0.91666666666667, 0.85, 0.25
4606, 0.91666666666667, 0.95, 0.25
4607, 0.91666666666667, 1.05, 0.25
4608, 0.91666666666667, 1.15, 0.25
4609, 0.91666666666667, 1.25, 0.25
4610, 0.91666666666667, 0.25, 0.33333333333333
4611, 0.91666666666667, 0.35, 0.33333333333333
4612, 0.91666666666667, 0.45, 0.33333333333333
4613, 0.91666666666667, 0.55, 0.33333333333333
4614, 0.91666666666667, 0.65, 0.33333333333333
4615, 0.91666666666667, 0.75, 0.33333333333333
4616, 0.91666666666667, 0.85, 0.33333333333333
4617, 0.91666666666667, 0.95, 0.33333333333333
4618, 0.91666666666667, 1.05, 0.33333333333333
4619, 0.91666666666667, 1.15, 0.33333333333333
4620, 0.91666666666667, 1.25, 0.33333333333333
4621, 0.91666666666667, 0.25, 0.41666666666667
4622, 0.91666666666667, 0.35, 0.41666666666667
4623, 0.91666666666667, 0.45, 0.41666666666667
4624, 0.91666666666667, 0.55, 0.41666666666667
4625, 0.91666666666667, 0.65, 0.41666666666667
4626, 0.91666666666667, 0.75, 0.41666666666667
4627, 0.91666666666667, 0.85, 0.41666666666667
4628, 0.91666666666667, 0.95, 0.41666666666667
4629, 0.91666666666667, 1.05, 0.41666666666667
4630, 0.91666666666667, 1.15, 0.41666666666667
4631, 0.91666666666667, 1.25, 0.41666666666667
4632, 0.083333333333333, 1.4333333333333, 0.083333333333333
4633, 0.083333333333333, 1.4666666666667, 0.083333333333333
4634, 0.083333333333333, 1.4333333333333, 0.16666666666667
4635, 0.083333333333333, 1.4666666666667, 0.16666666666667
4636, 0.083333333333333, 1.4333333333333, 0.25
4637, 0.083333333333333, 1.4666666666667, 0.25
4638, 0.083333333333333, 1.4333333333333, 0.33333333333333
4639, 0.083333333333333, 1.4666666666667, 0.33333333333333
4640, 0.083333333333333, 1.4333333333333, 0.41666666666667
4641, 0.083333333333333, 1.4666666666667, 0.41666666666667
4642, 0.16666666666667, 1.4333333333333, 0.083333333333333
4643, 0.16666666666667, 1.4666666666667, 0.083333333333333
4644, 0.16666666666667, 1.4333333333333, 0.16666666666667
4645, 0.16666666666667, 1.4666666666667, 0.16666666666667
4646, 0.16666666666667, 1.4333333333333, 0.25
4647, 0.16666666666667, 1.4666666666667, 0.25
4648, 0.16666666666667, 1.4333333333333, 0.33333333333333
4649, 0.16666666666667, 1.4666666666667, 0.33333333333333
4650, 0.16666666666667, 1.4333333333333, 0.41666666666667
4651, 0.16666666666667, 1.4666666666667, 0.41666666666667
4652, 0.25, 1.4333333333333, 0.083333333333333
4653, 0.25, 1.4666666666667, 0.083333333333333
4654, 0.25, 1.4333333333333, 0.16666666666667
4655, 0.25, 1.4666666666667, 0.16666666666667
4656, 0.25, 1.4333333333333, 0.25
4657, 0.25, 1.4666666666667, 0.25
4658, 0.25, 1.4333333333333, 0.33333333333333
4659, 0.25, 1.4666666666667, 0.33333333333333
4660, 0.25, 1.4333333333333, 0.41666666666667
4661, 0.25, 1.4666666666667, 0.41666666666667
4662, 0.33333333333333, 1.4333333333333, 0.083333333333333
4663, 0.33333333333333, 1.4666666666667, 0.083333333333333
4664, 0.33333333333333, 1.4333333333333, 0.16666666666667
4665, 0.33333333333333, 1.4666666666667, 0.16666666666667
4666, 0.33333333333333, 1.4333333333333, 0.25
4667, 0.33333333333333, 1.4666666666667, 0.25
4668, 0.33333333333333, 1.4333333333333, 0.33333333333333
4669, 0.33333333333333, 1.4666666666667, 0.33333333333333
4670, 0.33333333333333, 1.4333333333333, 0.41666666666667
4671, 0.33333333333333, 1.4666666666667, 0.41666666666667
4672, 0.41666666666667, 1.4333333333333, 0.083333333333333
4673, 0.41666666666667, 1.4666666666667, 0.083333333333333
4674, 0.41666666666667, 1.4333333333333, 0.16666666666667
4675, 0.41666666666667, 1.4666666666667, 0.16666666666667
4676, 0.41666666666667, 1.4333333333333, 0.25
4677, 0.41666666666667, 1.4666666666667, 0.25
4678, 0.41666666666667, 1.4333333333333, 0.33333333333333
4679, 0.41666666666667, 1.4666666666667, 0.33333333333333
4680, 0.41666666666667, 1.4333333333333, 0.41666666666667
4681, 0.41666666666667, 1.4666666666667, 0.41666666666667
4682, 0.5, 1.4333333333333, 0.083333333333333
4683, 0.5, 1.4666666666667, 0.083333333333333
4684, 0.5, 1.4333333333333, 0.16666666666667
4685, 0.5, 1.4666666666667, 0.16666666666667
4686, 0.5, 1.4333333333333, 0.25
4687, 0.5, 1.4666666666667, 0.25
4688, 0.5, 1.4333333333333, 0.33333333333333
4689, 0.5, 1.4666666666667, 0.33333333333333
4690, 0.5, 1.4333333333333, 0.41666666666667
4691, 0.5, 1.4666666666667, 0.41666666666667
4692, 0.58333333333333, 1.4333333333333, 0.083333333333333
4693, 0.58333333333333, 1.4666666666667, 0.083333333333333
4694, 0.58333333333333, 1.4333333333333, 0.16666666666667
4695, 0.58333333333333, 1.4666666666667, 0.16666666666667
4696, 0.58333333333333, 1.4333333333333, 0.25
4697, 0.58333333333333, 1.4666666666667, 0.25
4698, 0.58333333333333, 1.4333333333333, 0.33333333333333
4699, 0.58333333333333, 1.4666666666667, 0.33333333333333
4700, 0.58333333333333, 1.4333333333333, 0.41666666666667
4701, 0.58333333333333, 1.4666666666667, 0.41666666666667
4702, 0.66666666666667, 1.4333333333333, 0.083333333333333
4703, 0.66666666666667, 1.4666666666667, 0.083333333333333
4704, 0.66666666666667, 1.4333333333333, 0.16666666666667
4705, 0.66666666666667, 1.4666666666667, 0.16666666666667
4706, 0.66666666666667, 1.4333333333333, 0.25
4707, 0.66666666666667, 1.4666666666667, 0.25
4708, 0.66666666666667, 1.4333333333333, 0.33333333333333
4709, 0.66666666666667, 1.4666666666667, 0.33333333333333
4710, 0.66666666666667, 1.4333333333333, 0.41666666666667
4711, 0.66666666666667, 1.4666666666667, 0.41666666666667
4712, 0.75, 1.4333333333333, 0.083333333333333
4713, 0.75, 1.4666666666667, 0.083333333333333
4714, 0.75, 1.4333333333333, 0.16666666666667
4715, 0.75, 1.4666666666667, 0.16666666666667
4716, 0.75, 1.4333333333333, 0.25
4717, 0.75, 1.4666666666667, 0.25
4718, 0.75, 1.4333333333333, 0.33333333333333
4719, 0.75, 1.4666666666667, 0.33333333333333
4720, 0.75, 1.4333333333333, 0.41666666666667
4721, 0.75, 1.4666666666667, 0.41666666666667
4722, 0.83333333333333, 1.4333333333333, 0.083333333333333
4723, 0.83333333333333, 1.4666666666667, 0.083333333333333
4724, 0.83333333333333, 1.4333333333333, 0.16666666666667
4725, 0.83333333333333, 1.4666666666667, 0.16666666666667
4726, 0.83333333333333, 1.4333333333333, 0.25
4727, 0.83333333333333, 1.4666666666667, 0.25
4728, 0.83333333333333, 1.4333333333333, 0.33333333333333
4729, 0.83333333333333, 1.4666666666667, 0.33333333333333
4730, 0.83333333333333, 1.4333333333333, 0.41666666666667
4731, 0.83333333333333, 1.4666666666667, 0.41666666666667
4732, 0.91666666666667, 1.4333333333333, 0.083333333333333
4733, 0.91666666666667, 1.4666666666667, 0.083333333333333
4734, 0.91666666666667, 1.4333333333333, 0.16666666666667
4735, 0.91666666666667, 1.4666666666667, 0.16666666666667
4736, 0.91666666666667, 1.4333333333333, 0.25
4737, 0.91666666666667, 1.4666666666667, 0.25
4738, 0.91666666666667, 1.4333333333333, 0.33333333333333
4739, 0.91666666666667, 1.4666666666667, 0.33333333333333
4740, 0.91666666666667, 1.4333333333333, 0.41666666666667
4741, 0.91666666666667, 1.4666666666667, 0.41666666666667
4742, 1.04, 1.4333333333333, 0.083333333333333
4743, 1.08, 1.4333333333333, 0.083333333333333
4744, 1.12, 1.4333333333333, 0.083333333333333
4745, 1.16, 1.4333333333333, 0.083333333333333
4746, 1.04, 1.4666666666667, 0.083333333333333
4747, 1.08, 1.4666666666667, 0.083333333333333
4748, 1.12, 1.4666666666667, 0.083333333333333
4749, 1.16, 1.4666666666667, 0.083333333333333
4750, 1.04, 1.4333333333333, 0.16666666666667
4751, 1.08, 1.4333333333333, 0.16666666666667
4752, 1.12, 1.4333333333333, 0.16666666666667
4753, 1.16, 1.4333333333333, 0.16666666666667
4754, 1.04, 1.4666666666667, 0.16666666666667
4755, 1.08, 1.4666666666667, 0.16666666666667
4756, 1.12, 1.4666666666667, 0.16666666666667
4757, 1.16, 1.4666666666667, 0.16666666666667
4758, 1.04, 1.4333333333333, 0.25
4759, 1.08, 1.4333333333333, 0.25
4760, 1.12, 1.4333333333333, 0.25
4761, 1.16, 1.4333333333333, 0.25
4762, 1.04, 1.4666666666667, 0.25
4763, 1.08, 1.4666666666667, 0.25
4764, 1.12, 1.4666666666667, 0.25
4765, 1.16, 1.4666666666667, 0.25
4766, 1.04, 1.4333333333333, 0.33333333333333
4767, 1.08, 1.4333333333333, 0.33333333333333
4768, 1.12, 1.4333333333333, 0.33333333333333
4769, 1.16, 1.4333333333333, 0.33333333333333
4770, 1.04, 1.4666666666667, 0.33333333333333
4771, 1.08, 1.4666666666667, 0.33333333333333
4772, 1.12, 1.4666666666667, 0.33333333333333
4773, 1.16, 1.4666666666667, 0.33333333333333
4774, 1.04, 1.4333333333333, 0.41666666666667
4775, 1.08, 1.4333333333333, 0.41666666666667
4776, 1.12, 1.4333333333333, 0.41666666666667
4777, 1.16, 1.4333333333333, 0.41666666666667
4778, 1.04, 1.4666666666667, 0.41666666666667
4779, 1.08, 1.4666666666667, 0.41666666666667
4780, 1.12, 1.4666666666667, 0.41666666666667
4781, 1.16, 1.4666666666667, 0.41666666666667
4782, 1.2833333333333, 1.4333333333333, 0.083333333333333
4783, 1.3666666666667, 1.4333333333333, 0.083333333333333
4784, 1.45, 1.4333333333333, 0.083333333333333
4785, 1.5333333333333, 1.4333333333333, 0.083333333333333
4786, 1.6166666666667, 1.4333333333333, 0.083333333333333
4787, 1.7, 1.4333333333333, 0.083333333333333
4788, 1.7833333333333, 1.4333333333333, 0.083333333333333
4789, 1.8666666666667, 1.4333333333333, 0.083333333333333
4790, 1.95, 1.4333333333333, 0.083333333333333
4791, 2.0333333333333, 1.4333333333333, 0.083333333333333
4792, 2.1166666666667, 1.4333333333333, 0.083333333333333
4793, 1.2833333333333, 1.4666666666667, 0.083333333333333
4794, 1.3666666666667, 1.4666666666667, 0.083333333333333
4795, 1.45, 1.4666666666667, 0.083333333333333
4796, 1.5333333333333, 1.4666666666667, 0.083333333333333
4797, 1.6166666666667, 1.4666666666667, 0.083333333333333
4798, 1.7, 1.4666666666667, 0.083333333333333
4799, 1.7833333333333, 1.4666666666667, 0.083333333333333
4800, 1.8666666666667, 1.4666666666667, 0.083333333333333
4801, 1.95, 1.4666666666667, 0.083333333333333
4802, 2.0333333333333, 1.4666666666667, 0.083333333333333
4803, 2.1166666666667, 1.4666666666667, 0.083333333333333
4804, 1.2833333333333, 1.4333333333333, 0.16666666666667
4805, 1.3666666666667, 1.4333333333333, 0.16666666666667
4806, 1.45, 1.4333333333333, 0.16666666666667
4807, 1.5333333333333, 1.4333333333333, 0.16666666666667
4808, 1.6166666666667, 1.4333333333333, 0.16666666666667
4809, 1.7, 1.4333333333333, 0.16666666666667
4810, 1.7833333333333, 1.4333333333333, 0.16666666666667
4811, 1.8666666666667, 1.4333333333333, 0.16666666666667
4812, 1.95, 1.4333333333333, 0.16666666666667
4813, 2.0333333333333, 1.4333333333333, 0.16666666666667
4814, 2.1166666666667, 1.4333333333333, 0.16666666666667
4815, 1.2833333333333, 1.4666666666667, 0.16666666666667
4816, 1.3666666666667, 1.4666666666667, 0.16666666666667
4817, 1.45, 1.4666666666667, 0.16666666666667
4818, 1.5333333333333, 1.4666666666667, 0.16666666666667
4819, 1.6166666666667, 1.4666666666667, 0.16666666666667
4820, 1.7, 1.4666666666667, 0.16666666666667
4821, 1.7833333333333, 1.4666666666667, 0.16666666666667
4822, 1.8666666666667, 1.4666666666667, 0.16666666666667
4823, 1.95, 1.4666666666667, 0.16666666666667
4824, 2.0333333333333, 1.4666666666667, 0.16666666666667
4825, 2.1166666666667, 1.4666666666667, 0.16666666666667
4826, 1.2833333333333, 1.4333333333333, 0.25
4827, 1.3666666666667, 1.4333333333333, 0.25
4828, 1.45, 1.4333333333333, 0.25
4829, 1.5333333333333, 1.4333333333333, 0.25
4830, 1.6166666666667, 1.4333333333333, 0.25
4831, 1.7, 1.4333333333333, 0.25
4832, 1.7833333333333, 1.4333333333333, 0.25
4833, 1.8666666666667, 1.4333333333333, 0.25
4834, 1.95, 1.4333333333333, 0.25
4835, 2.0333333333333, 1.4333333333333, 0.25
4836, 2.1166666666667, 1.4333333333333, 0.25
4837, 1.2833333333333, 1.4666666666667, 0.25
4838, 1.3666666666667, 1.4666666666667, 0.25
4839, 1.45, 1.4666666666667, 0.25
4840, 1.5333333333333, 1.4666666666667, 0.25
4841, 1.6166666666667, 1.4666666666667, 0.25
4842, 1.7, 1.4666666666667, 0.25
4843, 1.7833333333333, 1.4666666666667, 0.25
4844, 1.8666666666667, 1.4666666666667, 0.25
4845, 1.95, 1.4666666666667, 0.25
4846, 2.0333333333333, 1.4666666666667, 0.25
4847, 2.1166666666667, 1.4666666666667, 0.25
4848, 1.2833333333333, 1.4333333333333, 0.33333333333333
4849, 1.3666666666667, 1.4333333333333, 0.33333333333333
4850, 1.45, 1.4333333333333, 0.33333333333333
4851, 1.5333333333333, 1.4333333333333, 0.33333333333333
4852, 1.6166666666667, 1.4333333333333, 0.33333333333333
4853, 1.7, 1.4333333333333, 0.33333333333333
4854, 1.7833333333333, 1.4333333333333, 0.33333333333333
4855, 1.8666666666667, 1.4333333333333, 0.33333333333333
4856, 1.95, 1.4333333333333, 0.33333333333333
4857, 2.0333333333333, 1.4333333333333, 0.33333333333333
4858, 2.1166666666667, 1.4333333333333, 0.33333333333333
4859, 1.2833333333333, 1.4666666666667, 0.33333333333333
4860, 1.3666666666667, 1.4666666666667, 0.33333333333333
4861, 1.45, 1.4666666666667, 0.33333333333333
4862, 1.5333333333333, 1.4666666666667, 0.33333333333333
4863, 1.6166666666667, 1.4666666666667, 0.33333333333333
4864, 1.7, 1.4666666666667, 0.33333333333333
4865, 1.7833333333333, 1.4666666666667, 0.33333333333333
4866, 1.8666666666667, 1.4666666666667, 0.33333333333333
4867, 1.95, 1.4666666666667, 0.33333333333333
4868, 2.0333333333333, 1.4666666666667, 0.33333333333333
4869, 2.1166666666667, 1.4666666666667, 0.33333333333333
4870, 1.2833333333333, 1.4333333333333, 0.41666666666667
4871, 1.3666666666667, 1.4333333333333, 0.41666666666667
4872, 1.45, 1.4333333333333, 0.41666666666667
4873, 1.5333333333333, 1.4333333333333, 0.41666666666667
4874, 1.6166666666667, 1.4333333333333, 0.41666666666667
4875, 1.7, 1.4333333333333, 0.41666666666667
4876, 1.7833333333333, 1.4333333333333, 0.41666666666667
4877, 1.8666666666667, 1.4333333333333, 0.41666666666667
4878, 1.95, 1.4333333333333, 0.41666666666667
4879, 2.0333333333333, 1.4333333333333, 0.41666666666667
4880, 2.1166666666667, 1.4333333333333, 0.41666666666667
4881, 1.2833333333333, 1.4666666666667, 0.41666666666667
4882, 1.3666666666667, 1.4666666666667, 0.41666666666667
4883, 1.45, 1.4666666666667, 0.41666666666667
4884, 1.5333333333333, 1.4666666666667, 0.41666666666667
4885, 1.6166666666667, 1.4666666666667, 0.41666666666667
4886, 1.7, 1.4666666666667, 0.41666666666667
4887, 1.7833333333333, 1.4666666666667, 0.41666666666667
4888, 1.8666666666667, 1.4666666666667, 0.41666666666667
4889, 1.95, 1.4666666666667, 0.41666666666667
4890, 2.0333333333333, 1.4666666666667, 0.41666666666667
4891, 2.1166666666667, 1.4666666666667, 0.41666666666667
4892, 1.2833333333333, 1.25, 0.083333333333333
4893, 1.2833333333333, 1.15, 0.083333333333333
4894, 1.2833333333333, 1.05, 0.083333333333333
4895, 1.2833333333333, 0.95, 0.083333333333333
4896, 1.2833333333333, 0.85, 0.083333333333333
4897, 1.2833333333333, 0.75, 0.083333333333333
4898, 1.2833333333333, 0.65, 0.083333333333333
4899, 1.2833333333333, 0.55, 0.083333333333333
4900, 1.2833333333333, 0.45, 0.083333333333333
4901, 1.2833333333333, 0.35, 0.083333333333333
4902, 1.2833333333333, 0.25, 0.083333333333333
4903, 1.3666666666667, 1.25, 0.083333333333333
4904, 1.3666666666667, 1.15, 0.083333333333333
4905, 1.3666666666667, 1.05, 0.083333333333333
4906, 1.3666666666667, 0.95, 0.083333333333333
4907, 1.3666666666667, 0.85, 0.083333333333333
4908, 1.3666666666667, 0.75, 0.083333333333333
4909, 1.3666666666667, 0.65, 0.083333333333333
4910, 1.3666666666667, 0.55, 0.083333333333333
4911, 1.3666666666667, 0.45, 0.083333333333333
4912, 1.3666666666667, 0.35, 0.083333333333333
4913, 1.3666666666667, 0.25, 0.083333333333333
4914, 1.45, 1.25, 0.083333333333333
4915, 1.45, 1.15, 0.083333333333333
4916, 1.45, 1.05, 0.083333333333333
4917, 1.45, 0.95, 0.083333333333333
4918, 1.45, 0.85, 0.083333333333333
4919, 1.45, 0.75, 0.083333333333333
4920, 1.45, 0.65, 0.083333333333333
4921, 1.45, 0.55, 0.083333333333333
4922, 1.45, 0.45, 0.083333333333333
4923, 1.45, 0.35, 0.083333333333333
4924, 1.45, 0.25, 0.083333333333333
4925, 1.5333333333333, 1.25, 0.083333333333333
4926, 1.5333333333333, 1.15, 0.083333333333333
4927, 1.5333333333333, 1.05, 0.083333333333333
4928, 1.5333333333333, 0.95, 0.083333333333333
4929, 1.5333333333333, 0.85, 0.083333333333333
4930, 1.5333333333333, 0.75, 0.083333333333333
4931, 1.5333333333333, 0.65, 0.083333333333333
4932, 1.5333333333333, 0.55, 0.083333333333333
4933, 1.5333333333333, 0.45, 0.083333333333333
4934, 1.5333333333333, 0.35, 0.083333333333333
4935, 1.5333333333333, 0.25, 0.083333333333333
4936, 1.6166666666667, 1.25, 0.083333333333333
4937, 1.6166666666667, 1.15, 0.083333333333333
4938, 1.6166666666667, 1.05, 0.083333333333333
4939, 1.6166666666667, 0.95, 0.083333333333333
4940, 1.6166666666667, 0.85, 0.083333333333333
4941, 1.6166666666667, 0.75, 0.083333333333333
4942, 1.6166666666667, 0.65, 0.083333333333333
4943, 1.6166666666667, 0.55, 0.083333333333333
4944, 1.6166666666667, 0.45, 0.083333333333333
4945, 1.6166666666667, 0.35, 0.083333333333333
4946, 1.6166666666667, 0.25, 0.083333333333333
4947, 1.7, 1.25, 0.083333333333333
4948, 1.7, 1.15, 0.083333333333333
4949, 1.7, 1.05, 0.083333333333333
4950, 1.7, 0.95, 0.083333333333333
4951, 1.7, 0.85, 0.083333333333333
4952, 1.7, 0.75, 0.083333333333333
4953, 1.7, 0.65, 0.083333333333333
4954, 1.7, 0.55, 0.083333333333333
4955, 1.7, 0.45, 0.083333333333333
4956, 1.7, 0.35, 0.083333333333333
4957, 1.7, 0.25, 0.083333333333333
4958, 1.7833333333333, 1.25, 0.083333333333333
4959, 1.7833333333333, 1.15, 0.083333333333333
4960, 1.7833333333333, 1.05, 0.083333333333333
4961, 1.7833333333333, 0.95, 0.083333333333333
4962, 1.7833333333333, 0.85, 0.083333333333333
4963, 1.7833333333333, 0.75, 0.083333333333333
4964, 1.7833333333333, 0.65, 0.083333333333333
4965, 1.7833333333333, 0.55, 0.083333333333333
4966, 1.7833333333333, 0.45, 0.083333333333333
4967, 1.7833333333333, 0.35, 0.083333333333333
4968, 1.7833333333333, 0.25, 0.083333333333333
4969, 1.8666666666667, 1.25, 0.083333333333333
4970, 1.8666666666667, 1.15, 0.083333333333333
4971, 1.8666666666667, 1.05, 0.083333333333333
4972, 1.8666666666667, 0.95, 0.083333333333333
4973, 1.8666666666667, 0.85, 0.083333333333333
4974, 1.8666666666667, 0.75, 0.083333333333333
4975, 1.8666666666667, 0.65, 0.083333333333333
4976, 1.8666666666667, 0.55, 0.083333333333333
4977, 1.8666666666667, 0.45, 0.083333333333333
4978, 1.8666666666667, 0.35, 0.083333333333333
4979, 1.8666666666667, 0.25, 0.083333333333333
4980, 1.95, 1.25, 0.083333333333333
4981, 1.95, 1.15, 0.083333333333333
4982, 1.95, 1.05, 0.083333333333333
4983, 1.95, 0.95, 0.083333333333333
4984, 1.95, 0.85, 0.083333333333333
4985, 1.95, 0.75, 0.083333333333333
4986, 1.95, 0.65, 0.083333333333333
4987, 1.95, 0.55, 0.083333333333333
4988, 1.95, 0.45, 0.083333333333333
4989, 1.95, 0.35, 0.083333333333333
4990, 1.95, 0.25, 0.083333333333333
4991, 2.0333333333333, 1.25, 0.083333333333333
4992, 2.0333333333333, 1.15, 0.083333333333333
4993, 2.0333333333333, 1.05, 0.083333333333333
4994, 2.0333333333333, 0.95, 0.083333333333333
4995, 2.0333333333333, 0.85, 0.083333333333333
4996, 2.0333333333333, 0.75, 0.083333333333333
4997, 2.0333333333333, 0.65, 0.083333333333333
4998, 2.0333333333333, 0.55, 0.083333333333333
4999, 2.0333333333333, 0.45, 0.083333333333333
5000, 2.0333333333333, 0.35, 0.083333333333333
5001, 2.0333333333333, 0.25, 0.083333333333333
5002, 2.1166666666667, 1.25, 0.083333333333333
5003, 2.1166666666667, 1.15, 0.083333333333333
5004, 2.1166666666667, 1.05, 0.083333333333333
5005, 2.1166666666667, 0.95, 0.083333333333333
5006, 2.1166666666667, 0.85, 0.083333333333333
5007, 2.1166666666667, 0.75, 0.083333333333333
5008, 2.1166666666667, 0.65, 0.083333333333333
5009, 2.1166666666667, 0.55, 0.083333333333333
5010, 2.1166666666667, 0.45, 0.083333333333333
5011, 2.1166666666667, 0.35, 0.083333333333333
5012, 2.1166666666667, 0.25, 0.083333333333333
5013, 1.2833333333333, 1.25, 0.16666666666667
5014, 1.2833333333333, 1.15, 0.16666666666667
5015, 1.2833333333333, 1.05, 0.16666666666667
5016, 1.2833333333333, 0.95, 0.16666666666667
5017, 1.2833333333333, 0.85, 0.16666666666667
5018, 1.2833333333333, 0.75, 0.16666666666667
5019, 1.2833333333333, 0.65, 0.16666666666667
5020, 1.2833333333333, 0.55, 0.16666666666667
5021, 1.2833333333333, 0.45, 0.16666666666667
5022, 1.2833333333333, 0.35, 0.16666666666667
5023, 1.2833333333333, 0.25, 0.16666666666667
5024, 1.3666666666667, 1.25, 0.16666666666667
5025, 1.3666666666667, 1.15, 0.16666666666667
5026, 1.3666666666667, 1.05, 0.16666666666667
5027, 1.3666666666667, 0.95, 0.16666666666667
5028, 1.3666666666667, 0.85, 0.16666666666667
5029, 1.3666666666667, 0.75, 0.16666666666667
5030, 1.3666666666667, 0.65, 0.16666666666667
5031, 1.3666666666667, 0.55, 0.16666666666667
5032, 1.3666666666667, 0.45, 0.16666666666667
5033, 1.3666666666667, 0.35, 0.16666666666667
5034, 1.3666666666667, 0.25, 0.16666666666667
5035, 1.45, 1.25, 0.16666666666667
5036, 1.45, 1.15, 0.16666666666667
5037, 1.45, 1.05, 0.16666666666667
5038, 1.45, 0.95, 0.16666666666667
5039, 1.45, 0.85, 0.16666666666667
5040, 1.45, 0.75, 0.16666666666667
5041, 1.45, 0.65, 0.16666666666667
5042, 1.45, 0.55, 0.16666666666667
5043, 1.45, 0.45, 0.16666666666667
5044, 1.45, 0.35, 0.16666666666667
5045, 1.45, 0.25, 0.16666666666667
5046, 1.5333333333333, 1.25, 0.16666666666667
5047, 1.5333333333333, 1.15, 0.16666666666667
5048, 1.5333333333333, 1.05, 0.16666666666667
5049, 1.5333333333333, 0.95, 0.16666666666667
5050, 1.5333333333333, 0.85, 0.16666666666667
5051, 1.5333333333333, 0.75, 0.16666666666667
5052, 1.5333333333333, 0.65, 0.16666666666667
5053, 1.5333333333333, 0.55, 0.16666666666667
5054, 1.5333333333333, 0.45, 0.16666666666667
5055, 1.5333333333333, 0.35, 0.16666666666667
5056, 1.5333333333333, 0.25, 0.16666666666667
5057, 1.6166666666667, 1.25, 0.16666666666667
5058, 1.6166666666667, 1.15, 0.16666666666667
5059, 1.6166666666667, 1.05, 0.16666666666667
5060, 1.6166666666667, 0.95, 0.16666666666667
5061, 1.6166666666667, 0.85, 0.16666666666667
5062, 1.6166666666667, 0.75, 0.16666666666667
5063, 1.6166666666667, 0.65, 0.16666666666667
5064, 1.6166666666667, 0.55, 0.16666666666667
5065, 1.6166666666667, 0.45, 0.16666666666667
5066, 1.6166666666667, 0.35, 0.16666666666667
5067, 1.6166666666667, 0.25, 0.16666666666667
5068, 1.7, 1.25, 0.16666666666667
5069, 1.7, 1.15, 0.16666666666667
5070, 1.7, 1.05, 0.16666666666667
5071, 1.7, 0.95, 0.16666666666667
5072, 1.7, 0.85, 0.16666666666667
5073, 1.7, 0.75, 0.16666666666667
5074, 1.7, 0.65, 0.16666666666667
5075, 1.7, 0.55, 0.16666666666667
5076, 1.7, 0.45, 0.16666666666667
5077, 1.7, 0.35, 0.16666666666667
5078, 1.7, 0.25, 0.16666666666667
5079, 1.7833333333333, 1.25, 0.16666666666667
5080, 1.7833333333333, 1.15, 0.16666666666667
5081, 1.7833333333333, 1.05, 0.16666666666667
5082, 1.7833333333333, 0.95, 0.16666666666667
5083, 1.7833333333333, 0.85, 0.16666666666667
5084, 1.7833333333333, 0.75, 0.16666666666667
5085, 1.7833333333333, 0.65, 0.16666666666667
5086, 1.7833333333333, 0.55, 0.16666666666667
5087, 1.7833333333333, 0.45, 0.16666666666667
5088, 1.7833333333333, 0.35, 0.16666666666667
5089, 1.7833333333333, 0.25, 0.16666666666667
5090, 1.8666666666667, 1.25, 0.16666666666667
5091, 1.8666666666667, 1.15, 0.16666666666667
5092, 1.8666666666667, 1.05, 0.16666666666667
5093, 1.8666666666667, 0.95, 0.16666666666667
5094, 1.8666666666667, 0.85, 0.16666666666667
5095, 1.8666666666667, 0.75, 0.16666666666667
5096, 1.8666666666667, 0.65, 0.16666666666667
5097, 1.8666666666667, 0.55, 0.16666666666667
5098, 1.8666666666667, 0.45, 0.16666666666667
5099, 1.8666666666667, 0.35, 0.16666666666667
5100, 1.8666666666667, 0.25, 0.16666666666667
5101, 1.95, 1.25, 0.16666666666667
5102, 1.95, 1.15, 0.16666666666667
5103, 1.95, 1.05, 0.16666666666667
5104, 1.95, 0.95, 0.16666666666667
5105, 1.95, 0.85, 0.16666666666667
5106, 1.95, 0.75, 0.16666666666667
5107, 1.95, 0.65, 0.16666666666667
5108, 1.95, 0.55, 0.16666666666667
5109, 1.95, 0.45, 0.16666666666667
5110, 1.95, 0.35, 0.16666666666667
5111, 1.95, 0.25, 0.16666666666667
5112, 2.0333333333333, 1.25, 0.16666666666667
5113, 2.0333333333333, 1.15, 0.16666666666667
5114, 2.0333333333333, 1.05, 0.16666666666667
5115, 2.0333333333333, 0.95, 0.16666666666667
5116, 2.0333333333333, 0.85, 0.16666666666667
5117, 2.0333333333333, 0.75, 0.16666666666667
5118, 2.0333333333333, 0.65, 0.16666666666667
5119, 2.0333333333333, 0.55, 0.16666666666667
5120, 2.0333333333333, 0.45, 0.16666666666667
5121, 2.0333333333333, 0.35, 0.16666666666667
5122, 2.0333333333333, 0.25, 0.16666666666667
5123, 2.1166666666667, 1.25, 0.16666666666667
5124, 2.1166666666667, 1.15, 0.16666666666667
5125, 2.1166666666667, 1.05, 0.16666666666667
5126, 2.1166666666667, 0.95, 0.16666666666667
5127, 2.1166666666667, 0.85, 0.16666666666667
5128, 2.1166666666667, 0.75, 0.16666666666667
5129, 2.1166666666667, 0.65, 0.16666666666667
5130, 2.1166666666667, 0.55, 0.16666666666667
5131, 2.1166666666667, 0.45, 0.16666666666667
5132, 2.1166666666667, 0.35, 0.16666666666667
5133, 2.1166666666667, 0.25, 0.16666666666667
5134, 1.2833333333333, 1.25, 0.25
5135, 1.2833333333333, 1.15, 0.25
5136, 1.2833333333333, 1.05, 0.25
5137, 1.2833333333333, 0.95, 0.25
5138, 1.2833333333333, 0.85, 0.25
5139, 1.2833333333333, 0.75, 0.25
5140, 1.2833333333333, 0.65, 0.25
5141, 1.2833333333333, 0.55, 0.25
5142, 1.2833333333333, 0.45, 0.25
5143, 1.2833333333333, 0.35, 0.25
5144, 1.2833333333333, 0.25, 0.25
5145, 1.3666666666667, 1.25, 0.25
5146, 1.3666666666667, 1.15, 0.25
5147, 1.3666666666667, 1.05, 0.25
5148, 1.3666666666667, 0.95, 0.25
5149, 1.3666666666667, 0.85, 0.25
5150, 1.3666666666667, 0.75, 0.25
5151, 1.3666666666667, 0.65, 0.25
5152, 1.3666666666667, 0.55, 0.25
5153, 1.3666666666667, 0.45, 0.25
5154, 1.3666666666667, 0.35, 0.25
5155, 1.3666666666667, 0.25, 0.25
5156, 1.45, 1.25, 0.25
5157, 1.45, 1.15, 0.25
5158, 1.45, 1.05, 0.25
5159, 1.45, 0.95, 0.25
5160, 1.45, 0.85, 0.25
5161, 1.45, 0.75, 0.25
5162, 1.45, 0.65, 0.25
5163, 1.45, 0.55, 0.25
5164, 1.45, 0.45, 0.25
5165, 1.45, 0.35, 0.25
5166, 1.45, 0.25, 0.25
5167, 1.5333333333333, 1.25, 0.25
5168, 1.5333333333333, 1.15, 0.25
5169, 1.5333333333333, 1.05, 0.25
5170, 1.5333333333333, 0.95, 0.25
5171, 1.5333333333333, 0.85, 0.25
5172, 1.5333333333333, 0.75, 0.25
5173, 1.5333333333333, 0.65, 0.25
5174, 1.5333333333333, 0.55, 0.25
5175, 1.5333333333333, 0.45, 0.25
5176, 1.5333333333333, 0.35, 0.25
5177, 1.5333333333333, 0.25, 0.25
5178, 1.6166666666667, 1.25, 0.25
5179, 1.6166666666667, 1.15, 0.25
5180, 1.6166666666667, 1.05, 0.25
5181, 1.6166666666667, 0.95, 0.25
5182, 1.6166666666667, 0.85, 0.25
5183, 1.6166666666667, 0.75, 0.25
5184, 1.6166666666667, 0.65, 0.25
5185, 1.6166666666667, 0.55, 0.25
5186, 1.6166666666667, 0.45, 0.25
5187, 1.6166666666667, 0.35, 0.25
5188, 1.6166666666667, 0.25, 0.25
5189, 1.7, 1.25, 0.25
5190, 1.7, 1.15, 0.25
5191, 1.7, 1.05, 0.25
5192, 1.7, 0.95, 0.25
5193, 1.7, 0.85, 0.25
5194, 1.7, 0.75, 0.25
5195, 1.7, 0.65, 0.25
5196, 1.7, 0.55, 0.25
5197, 1.7, 0.45, 0.25
5198, 1.7, 0.35, 0.25
5199, 1.7, 0.25, 0.25
5200, 1.7833333333333, 1.25, 0.25
5201, 1.7833333333333, 1.15, 0.25
5202, 1.7833333333333, 1.05, 0.25
5203, 1.7833333333333, 0.95, 0.25
5204, 1.7833333333333, 0.85, 0.25
5205, 1.7833333333333, 0.75, 0.25
5206, 1.7833333333333, 0.65, 0.25
5207, 1.7833333333333, 0.55, 0.25
5208, 1.7833333333333, 0.45, 0.25
5209, 1.7833333333333, 0.35, 0.25
5210, 1.7833333333333, 0.25, 0.25
5211, 1.8666666666667, 1.25, 0.25
5212, 1.8666666666667, 1.15, 0.25
5213, 1.8666666666667, 1.05, 0.25
5214, 1.8666666666667, 0.95, 0.25
5215, 1.8666666666667, 0.85, 0.25
5216, 1.8666666666667, 0.75, 0.25
5217, 1.8666666666667, 0.65, 0.25
5218, 1.8666666666667, 0.55, 0.25
5219, 1.8666666666667, 0.45, 0.25
5220, 1.8666666666667, 0.35, 0.25
5221, 1.8666666666667, 0.25, 0.25
5222, 1.95, 1.25, 0.25
5223, 1.95, 1.15, 0.25
5224, 1.95, 1.05, 0.25
5225, 1.95, 0.95, 0.25
5226, 1.95, 0.85, 0.25
5227, 1.95, 0.75, 0.25
5228, 1.95, 0.65, 0.25
5229, 1.95, 0.55, 0.25
5230, 1.95, 0.45, 0.25
5231, 1.95, 0.35, 0.25
5232, 1.95, 0.25, 0.25
5233, 2.0333333333333, 1.25, 0.25
5234, 2.0333333333333, 1.15, 0.25
5235, 2.0333333333333, 1.05, 0.25
5236, 2.0333333333333, 0.95, 0.25
5237, 2.0333333333333, 0.85, 0.25
5238, 2.0333333333333, 0.75, 0.25
5239, 2.0333333333333, 0.65, 0.25
5240, 2.0333333333333, 0.55, 0.25
5241, 2.0333333333333, 0.45, 0.25
5242, 2.0333333333333, 0.35, 0.25
5243, 2.0333333333333, 0.25, 0.25
5244, 2.1166666666667, 1.25, 0.25
5245, 2.1166666666667, 1.15, 0.25
5246, 2.1166666666667, 1.05, 0.25
5247, 2.1166666666667, 0.95, 0.25
5248, 2.1166666666667, 0.85, 0.25
5249, 2.1166666666667, 0.75, 0.25
5250, 2.1166666666667, 0.65, 0.25
5251, 2.1166666666667, 0.55, 0.25
5252, 2.1166666666667, 0.45, 0.25
5253, 2.1166666666667, 0.35, 0.25
5254, 2.1166666666667, 0.25, 0.25
5255, 1.2833333333333, 1.25, 0.33333333333333
5256, 1.2833333333333, 1.15, 0.33333333333333
5257, 1.2833333333333, 1.05, 0.33333333333333
5258, 1.2833333333333, 0.95, 0.33333333333333
5259, 1.2833333333333, 0.85, 0.33333333333333
5260, 1.2833333333333, 0.75, 0.33333333333333
5261, 1.2833333333333, 0.65, 0.33333333333333
5262, 1.2833333333333, 0.55, 0.33333333333333
5263, 1.2833333333333, 0.45, 0.33333333333333
5264, 1.2833333333333, 0.35, 0.33333333333333
5265, 1.2833333333333, 0.25, 0.33333333333333
5266, 1.3666666666667, 1.25, 0.33333333333333
5267, 1.3666666666667, 1.15, 0.33333333333333
5268, 1.3666666666667, 1.05, 0.33333333333333
5269, 1.3666666666667, 0.95, 0.33333333333333
5270, 1.3666666666667, 0.85, 0.33333333333333
5271, 1.3666666666667, 0.75, 0.33333333333333
5272, 1.3666666666667, 0.65, 0.33333333333333
5273, 1.3666666666667, 0.55, 0.33333333333333
5274, 1.3666666666667, 0.45, 0.33333333333333
5275, 1.3666666666667, 0.35, 0.33333333333333
5276, 1.3666666666667, 0.25, 0.33333333333333
5277, 1.45, 1.25, 0.33333333333333
5278, 1.45, 1.15, 0.33333333333333
5279, 1.45, 1.05, 0.33333333333333
5280, 1.45, 0.95, 0.33333333333333
5281, 1.45, 0.85, 0.33333333333333
5282, 1.45, 0.75, 0.33333333333333
5283, 1.45, 0.65, 0.33333333333333
5284, 1.45, 0.55, 0.33333333333333
5285, 1.45, 0.45, 0.33333333333333
5286, 1.45, 0.35, 0.33333333333333
5287, 1.45, 0.25, 0.33333333333333
5288, 1.5333333333333, 1.25, 0.33333333333333
5289, 1.5333333333333, 1.15, 0.33333333333333
5290, 1.5333333333333, 1.05, 0.33333333333333
5291, 1.5333333333333, 0.95, 0.33333333333333
5292, 1.5333333333333, 0.85, 0.33333333333333
5293, 1.5333333333333, 0.75, 0.33333333333333
5294, 1.5333333333333, 0.65, 0.33333333333333
5295, 1.5333333333333, 0.55, 0.33333333333333
5296, 1.5333333333333, 0.45, 0.33333333333333
5297, 1.5333333333333, 0.35, 0.33333333333333
5298, 1.5333333333333, 0.25, 0.33333333333333
5299, 1.6166666666667, 1.25, 0.33333333333333
5300, 1.6166666666667, 1.15, 0.33333333333333
5301, 1.6166666666667, 1.05, 0.33333333333333
5302, 1.6166666666667, 0.95, 0.33333333333333
5303, 1.6166666666667, 0.85, 0.33333333333333
5304, 1.6166666666667, 0.75, 0.33333333333333
5305, 1.6166666666667, 0.65, 0.33333333333333
5306, 1.6166666666667, 0.55, 0.33333333333333
5307, 1.6166666666667, 0.45, 0.33333333333333
5308, 1.6166666666667, 0.35, 0.33333333333333
5309, 1.6166666666667, 0.25, 0.33333333333333
5310, 1.7, 1.25, 0.33333333333333
5311, 1.7, 1.15, 0.33333333333333
5312, 1.7, 1.05, 0.33333333333333
5313, 1.7, 0.95, 0.33333333333333
5314, 1.7, 0.85, 0.33333333333333
5315, 1.7, 0.75, 0.33333333333333
5316, 1.7, 0.65, 0.33333333333333
5317, 1.7, 0.55, 0.33333333333333
5318, 1.7, 0.45, 0.33333333333333
5319, 1.7, 0.35, 0.33333333333333
5320, 1.7, 0.25, 0.33333333333333
5321, 1.7833333333333, 1.25, 0.33333333333333
5322, 1.7833333333333, 1.15, 0.33333333333333
5323, 1.7833333333333, 1.05, 0.33333333333333
5324, 1.7833333333333, 0.95, 0.33333333333333
5325, 1.7833333333333, 0.85, 0.33333333333333
5326, 1.7833333333333, 0.75, 0.33333333333333
5327, 1.7833333333333, 0.65, 0.33333333333333
5328, 1.7833333333333, 0.55, 0.33333333333333
5329, 1.7833333333333, 0.45, 0.33333333333333
5330, 1.7833333333333, 0.35, 0.33333333333333
5331, 1.7833333333333, 0.25, 0.33333333333333
5332, 1.8666666666667, 1.25, 0.33333333333333
5333, 1.8666666666667, 1.15, 0.33333333333333
5334, 1.8666666666667, 1.05, 0.33333333333333
5335, 1.8666666666667, 0.95, 0.33333333333333
5336, 1.8666666666667, 0.85, 0.33333333333333
5337, 1.8666666666667, 0.75, 0.33333333333333
5338, 1.8666666666667, 0.65, 0.33333333333333
5339, 1.8666666666667, 0.55, 0.33333333333333
5340, 1.8666666666667, 0.45, 0.33333333333333
5341, 1.8666666666667, 0.35, 0.33333333333333
5342, 1.8666666666667, 0.25, 0.33333333333333
5343, 1.95, 1.25, 0.33333333333333
5344, 1.95, 1.15, 0.33333333333333
5345, 1.95, 1.05, 0.33333333333333
5346, 1.95, 0.95, 0.33333333333333
5347, 1.95, 0.85, 0.33333333333333
5348, 1.95, 0.75, 0.33333333333333
5349, 1.95, 0.65, 0.33333333333333
5350, 1.95, 0.55, 0.33333333333333
5351, 1.95, 0.45, 0.33333333333333
5352, 1.95, 0.35, 0.33333333333333
5353, 1.95, 0.25, 0.33333333333333
5354, 2.0333333333333, 1.25, 0.33333333333333
5355, 2.0333333333333, 1.15, 0.33333333333333
5356, 2.0333333333333, 1.05, 0.33333333333333
5357, 2.0333333333333, 0.95, 0.33333333333333
5358, 2.0333333333333, 0.85, 0.33333333333333
5359, 2.0333333333333, 0.75, 0.33333333333333
5360, 2.0333333333333, 0.65, 0.33333333333333
5361, 2.0333333333333, 0.55, 0.33333333333333
5362, 2.0333333333333, 0.45, 0.33333333333333
5363, 2.0333333333333, 0.35, 0.33333333333333
5364, 2.0333333333333, 0.25, 0.33333333333333
5365, 2.1166666666667, 1.25, 0.33333333333333
5366, 2.1166666666667, 1.15, 0.33333333333333
5367, 2.1166666666667, 1.05, 0.33333333333333
5368, 2.1166666666667, 0.95, 0.33333333333333
5369, 2.1166666666667, 0.85, 0.33333333333333
5370, 2.1166666666667, 0.75, 0.33333333333333
5371, 2.1166666666667, 0.65, 0.33333333333333
5372, 2.1166666666667, 0.55, 0.33333333333333
5373, 2.1166666666667, 0.45, 0.33333333333333
5374, 2.1166666666667, 0.35, 0.33333333333333
5375, 2.1166666666667, 0.25, 0.33333333333333
5376, 1.2833333333333, 1.25, 0.41666666666667
5377, 1.2833333333333, 1.15, 0.41666666666667
5378, 1.2833333333333, 1.05, 0.41666666666667
5379, 1.2833333333333, 0.95, 0.41666666666667
5380, 1.2833333333333, 0.85, 0.41666666666667
5381, 1.2833333333333, 0.75, 0.41666666666667
5382, 1.2833333333333, 0.65, 0.41666666666667
5383, 1.2833333333333, 0.55, 0.41666666666667
5384, 1.2833333333333, 0.45, 0.41666666666667
5385, 1.2833333333333, 0.35, 0.41666666666667
5386, 1.2833333333333, 0.25, 0.41666666666667
5387, 1.3666666666667, 1.25, 0.41666666666667
5388, 1.3666666666667, 1.15, 0.41666666666667
5389, 1.3666666666667, 1.05, 0.41666666666667
5390, 1.3666666666667, 0.95, 0.41666666666667
5391, 1.3666666666667, 0.85, 0.41666666666667
5392, 1.3666666666667, 0.75, 0.41666666666667
5393, 1.3666666666667, 0.65, 0.41666666666667
5394, 1.3666666666667, 0.55, 0.41666666666667
5395, 1.3666666666667, 0.45, 0.41666666666667
5396, 1.3666666666667, 0.35, 0.41666666666667
5397, 1.3666666666667, 0.25, 0.41666666666667
5398, 1.45, 1.25, 0.41666666666667
5399, 1.45, 1.15, 0.41666666666667
5400, 1.45, 1.05, 0.41666666666667
5401, 1.45, 0.95, 0.41666666666667
5402, 1.45, 0.85, 0.41666666666667
5403, 1.45, 0.75, 0.41666666666667
5404, 1.45, 0.65, 0.41666666666667
5405, 1.45, 0.55, 0.41666666666667
5406, 1.45, 0.45, 0.41666666666667
5407, 1.45, 0.35, 0.41666666666667
5408, 1.45, 0.25, 0.41666666666667
5409, 1.5333333333333, 1.25, 0.41666666666667
5410, 1.5333333333333, 1.15, 0.41666666666667
5411, 1.5333333333333, 1.05, 0.41666666666667
5412, 1.5333333333333, 0.95, 0.41666666666667
5413, 1.5333333333333, 0.85, 0.41666666666667
5414, 1.5333333333333, 0.75, 0.41666666666667
5415, 1.5333333333333, 0.65, 0.41666666666667
5416, 1.5333333333333, 0.55, 0.41666666666667
5417, 1.5333333333333, 0.45, 0.41666666666667
5418, 1.5333333333333, 0.35, 0.41666666666667
5419, 1.5333333333333, 0.25, 0.41666666666667
5420, 1.6166666666667, 1.25, 0.41666666666667
5421, 1.6166666666667, 1.15, 0.41666666666667
5422, 1.6166666666667, 1.05, 0.41666666666667
5423, 1.6166666666667, 0.95, 0.41666666666667
5424, 1.6166666666667, 0.85, 0.41666666666667
5425, 1.6166666666667, 0.75, 0.41666666666667
5426, 1.6166666666667, 0.65, 0.41666666666667
5427, 1.6166666666667, 0.55, 0.41666666666667
5428, 1.6166666666667, 0.45, 0.41666666666667
5429, 1.6166666666667, 0.35, 0.41666666666667
5430, 1.6166666666667, 0.25, 0.41666666666667
5431, 1.7, 1.25, 0.41666666666667
5432, 1.7, 1.15, 0.41666666666667
5433, 1.7, 1.05, 0.41666666666667
5434, 1.7, 0.95, 0.41666666666667
5435, 1.7, 0.85, 0.41666666666667
5436, 1.7, 0.75, 0.41666666666667
5437, 1.7, 0.65, 0.41666666666667
5438, 1.7, 0.55, 0.41666666666667
5439, 1.7, 0.45, 0.41666666666667
5440, 1.7, 0.35, 0.41666666666667
5441, 1.7, 0.25, 0.41666666666667
5442, 1.7833333333333, 1.25, 0.41666666666667
5443, 1.7833333333333, 1.15, 0.41666666666667
5444, 1.7833333333333, 1.05, 0.41666666666667
5445, 1.7833333333333, 0.95, 0.41666666666667
5446, 1.7833333333333, 0.85, 0.41666666666667
5447, 1.7833333333333, 0.75, 0.41666666666667
5448, 1.7833333333333, 0.65, 0.41666666666667
5449, 1.7833333333333, 0.55, 0.41666666666667
5450, 1.7833333333333, 0.45, 0.41666666666667
5451, 1.7833333333333, 0.35, 0.41666666666667
5452, 1.7833333333333, 0.25, 0.41666666666667
5453, 1.8666666666667, 1.25, 0.41666666666667
5454, 1.8666666666667, 1.15, 0.41666666666667
5455, 1.8666666666667, 1.05, 0.41666666666667
5456, 1.8666666666667, 0.95, 0.41666666666667
5457, 1.8666666666667, 0.85, 0.41666666666667
5458, 1.8666666666667, 0.75, 0.41666666666667
5459, 1.8666666666667, 0.65, 0.41666666666667
5460, 1.8666666666667, 0.55, 0.41666666666667
5461, 1.8666666666667, 0.45, 0.41666666666667
5462, 1.8666666666667, 0.35, 0.41666666666667
5463, 1.8666666666667, 0.25, 0.41666666666667
5464, 1.95, 1.25, 0.41666666666667
5465, 1.95, 1.15, 0.41666666666667
5466, 1.95, 1.05, 0.41666666666667
5467, 1.95, 0.95, 0.41666666666667
5468, 1.95, 0.85, 0.41666666666667
5469, 1.95, 0.75, 0.41666666666667
5470, 1.95, 0.65, 0.41666666666667
5471, 1.95, 0.55, 0.41666666666667
5472, 1.95, 0.45, 0.41666666666667
5473, 1.95, 0.35, 0.41666666666667
5474, 1.95, 0.25, 0.41666666666667
5475, 2.0333333333333, 1.25, 0.41666666666667
5476, 2.0333333333333, 1.15, 0.41666666666667
5477, 2.0333333333333, 1.05, 0.41666666666667
5478, 2.0333333333333, 0.95, 0.41666666666667
5479, 2.0333333333333, 0.85, 0.41666666666667
5480, 2.0333333333333, 0.75, 0.41666666666667
5481, 2.0333333333333, 0.65, 0.41666666666667
5482, 2.0333333333333, 0.55, 0.41666666666667
5483, 2.0333333333333, 0.45, 0.41666666666667
5484, 2.0333333333333, 0.35, 0.41666666666667
5485, 2.0333333333333, 0.25, 0.41666666666667
5486, 2.1166666666667, 1.25, 0.41666666666667
5487, 2.1166666666667, 1.15, 0.41666666666667
5488, 2.1166666666667, 1.05, 0.41666666666667
5489, 2.1166666666667, 0.95, 0.41666666666667
5490, 2.1166666666667, 0.85, 0.41666666666667
5491, 2.1166666666667, 0.75, 0.41666666666667
5492, 2.1166666666667, 0.65, 0.41666666666667
5493, 2.1166666666667, 0.55, 0.41666666666667
5494, 2.1166666666667, 0.45, 0.41666666666667
5495, 2.1166666666667, 0.35, 0.41666666666667
5496, 2.1166666666667, 0.25, 0.41666666666667
5497, 1.2833333333333, 0.066666666666667, 0.083333333333333
5498, 1.2833333333333, 0.033333333333333, 0.083333333333333
5499, 1.3666666666667, 0.066666666666667, 0.083333333333333
5500, 1.3666666666667, 0.033333333333333, 0.083333333333333
5501, 1.45, 0.066666666666667, 0.083333333333333
5502, 1.45, 0.033333333333333, 0.083333333333333
5503, 1.5333333333333, 0.066666666666667, 0.083333333333333
5504, 1.5333333333333, 0.033333333333333, 0.083333333333333
5505, 1.6166666666667, 0.066666666666667, 0.083333333333333
5506, 1.6166666666667, 0.033333333333333, 0.083333333333333
5507, 1.7, 0.066666666666667, 0.083333333333333
5508, 1.7, 0.033333333333333, 0.083333333333333
5509, 1.7833333333333, 0.066666666666667, 0.083333333333333
5510, 1.7833333333333, 0.033333333333333, 0.083333333333333
5511, 1.8666666666667, 0.066666666666667, 0.083333333333333
5512, 1.8666666666667, 0.033333333333333, 0.083333333333333
5513, 1.95, 0.066666666666667, 0.083333333333333
5514, 1.95, 0.033333333333333, 0.083333333333333
5515, 2.0333333333333, 0.066666666666667, 0.083333333333333
5516, 2.0333333333333, 0.033333333333333, 0.083333333333333
5517, 2.1166666666667, 0.066666666666667, 0.083333333333333
5518, 2.1166666666667, 0.033333333333333, 0.083333333333333
5519, 1.2833333333333, 0.066666666666667, 0.16666666666667
5520, 1.2833333333333, 0.033333333333333, 0.16666666666667
5521, 1.3666666666667, 0.066666666666667, 0.16666666666667
5522, 1.3666666666667, 0.033333333333333, 0.16666666666667
5523, 1.45, 0.066666666666667, 0.16666666666667
5524, 1.45, 0.033333333333333, 0.16666666666667
5525, 1.5333333333333, 0.066666666666667, 0.16666666666667
5526, 1.5333333333333, 0.033333333333333, 0.16666666666667
5527, 1.6166666666667, 0.066666666666667, 0.16666666666667
5528, 1.6166666666667, 0.033333333333333, 0.16666666666667
5529, 1.7, 0.066666666666667, 0.16666666666667
5530, 1.7, 0.033333333333333, 0.16666666666667
5531, 1.7833333333333, 0.066666666666667, 0.16666666666667
5532, 1.7833333333333, 0.033333333333333, 0.16666666666667
5533, 1.8666666666667, 0.066666666666667, 0.16666666666667
5534, 1.8666666666667, 0.033333333333333, 0.16666666666667
5535, 1.95, 0.066666666666667, 0.16666666666667
5536, 1.95, 0.033333333333333, 0.16666666666667
5537, 2.0333333333333, 0.066666666666667, 0.16666666666667
5538, 2.0333333333333, 0.033333333333333, 0.16666666666667
5539, 2.1166666666667, 0.066666666666667, 0.16666666666667
5540, 2.1166666666667, 0.033333333333333, 0.16666666666667
5541, 1.2833333333333, 0.066666666666667, 0.25
5542, 1.2833333333333, 0.033333333333333, 0.25
5543, 1.3666666666667, 0.066666666666667, 0.25
5544, 1.3666666666667, 0.033333333333333, 0.25
5545, 1.45, 0.066666666666667, 0.25
5546, 1.45, 0.033333333333333, 0.25
5547, 1.5333333333333, 0.066666666666667, 0.25
5548, 1.5333333333333, 0.033333333333333, 0.25
5549, 1.6166666666667, 0.066666666666667, 0.25
5550, 1.6166666666667, 0.033333333333333, 0.25
5551, 1.7, 0.066666666666667, 0.25
5552, 1.7, 0.033333333333333, 0.25
5553, 1.7833333333333, 0.066666666666667, 0.25
5554, 1.7833333333333, 0.033333333333333, 0.25
5555, 1.8666666666667, 0.066666666666667, 0.25
5556, 1.8666666666667, 0.033333333333333, 0.25
5557, 1.95, 0.066666666666667, 0.25
5558, 1.95, 0.033333333333333, 0.25
5559, 2.0333333333333, 0.066666666666667, 0.25
5560, 2.0333333333333, 0.033333333333333, 0.25
5561, 2.1166666666667, 0.066666666666667, 0.25
5562, 2.1166666666667, 0.033333333333333, 0.25
5563, 1.2833333333333, 0.066666666666667, 0.33333333333333
5564, 1.2833333333333, 0.033333333333333, 0.33333333333333
5565, 1.3666666666667, 0.066666666666667, 0.33333333333333
5566, 1.3666666666667, 0.033333333333333, 0.33333333333333
5567, 1.45, 0.066666666666667, 0.33333333333333
5568, 1.45, 0.033333333333333, 0.33333333333333
5569, 1.5333333333333, 0.066666666666667, 0.33333333333333
5570, 1.5333333333333, 0.033333333333333, 0.33333333333333
5571, 1.6166666666667, 0.066666666666667, 0.33333333333333
5572, 1.6166666666667, 0.033333333333333, 0.33333333333333
5573, 1.7, 0.066666666666667, 0.33333333333333
5574, 1.7, 0.033333333333333, 0.33333333333333
5575, 1.7833333333333, 0.066666666666667, 0.33333333333333
