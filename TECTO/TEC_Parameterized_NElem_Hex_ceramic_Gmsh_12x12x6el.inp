5576, 1.7833333333333, 0.033333333333333, 0.33333333333333
5577, 1.8666666666667, 0.066666666666667, 0.33333333333333
5578, 1.8666666666667, 0.033333333333333, 0.33333333333333
5579, 1.95, 0.066666666666667, 0.33333333333333
5580, 1.95, 0.033333333333333, 0.33333333333333
5581, 2.0333333333333, 0.066666666666667, 0.33333333333333
5582, 2.0333333333333, 0.033333333333333, 0.33333333333333
5583, 2.1166666666667, 0.066666666666667, 0.33333333333333
5584, 2.1166666666667, 0.033333333333333, 0.33333333333333
5585, 1.2833333333333, 0.066666666666667, 0.41666666666667
5586, 1.2833333333333, 0.033333333333333, 0.41666666666667
5587, 1.3666666666667, 0.066666666666667, 0.41666666666667
5588, 1.3666666666667, 0.033333333333333, 0.41666666666667
5589, 1.45, 0.066666666666667, 0.41666666666667
5590, 1.45, 0.033333333333333, 0.41666666666667
5591, 1.5333333333333, 0.066666666666667, 0.41666666666667
5592, 1.5333333333333, 0.033333333333333, 0.41666666666667
5593, 1.6166666666667, 0.066666666666667, 0.41666666666667
5594, 1.6166666666667, 0.033333333333333, 0.41666666666667
5595, 1.7, 0.066666666666667, 0.41666666666667
5596, 1.7, 0.033333333333333, 0.41666666666667
5597, 1.7833333333333, 0.066666666666667, 0.41666666666667
5598, 1.7833333333333, 0.033333333333333, 0.41666666666667
5599, 1.8666666666667, 0.066666666666667, 0.41666666666667
5600, 1.8666666666667, 0.033333333333333, 0.41666666666667
5601, 1.95, 0.066666666666667, 0.41666666666667
5602, 1.95, 0.033333333333333, 0.41666666666667
5603, 2.0333333333333, 0.066666666666667, 0.41666666666667
5604, 2.0333333333333, 0.033333333333333, 0.41666666666667
5605, 2.1166666666667, 0.066666666666667, 0.41666666666667
5606, 2.1166666666667, 0.033333333333333, 0.41666666666667
5607, 0.083333333333333, 1.54, 0.083333333333333
5608, 0.083333333333333, 1.58, 0.083333333333333
5609, 0.083333333333333, 1.62, 0.083333333333333
5610, 0.083333333333333, 1.66, 0.083333333333333
5611, 0.083333333333333, 1.54, 0.16666666666667
5612, 0.083333333333333, 1.58, 0.16666666666667
5613, 0.083333333333333, 1.62, 0.16666666666667
5614, 0.083333333333333, 1.66, 0.16666666666667
5615, 0.083333333333333, 1.54, 0.25
5616, 0.083333333333333, 1.58, 0.25
5617, 0.083333333333333, 1.62, 0.25
5618, 0.083333333333333, 1.66, 0.25
5619, 0.083333333333333, 1.54, 0.33333333333333
5620, 0.083333333333333, 1.58, 0.33333333333333
5621, 0.083333333333333, 1.62, 0.33333333333333
5622, 0.083333333333333, 1.66, 0.33333333333333
5623, 0.083333333333333, 1.54, 0.41666666666667
5624, 0.083333333333333, 1.58, 0.41666666666667
5625, 0.083333333333333, 1.62, 0.41666666666667
5626, 0.083333333333333, 1.66, 0.41666666666667
5627, 0.16666666666667, 1.54, 0.083333333333333
5628, 0.16666666666667, 1.58, 0.083333333333333
5629, 0.16666666666667, 1.62, 0.083333333333333
5630, 0.16666666666667, 1.66, 0.083333333333333
5631, 0.16666666666667, 1.54, 0.16666666666667
5632, 0.16666666666667, 1.58, 0.16666666666667
5633, 0.16666666666667, 1.62, 0.16666666666667
5634, 0.16666666666667, 1.66, 0.16666666666667
5635, 0.16666666666667, 1.54, 0.25
5636, 0.16666666666667, 1.58, 0.25
5637, 0.16666666666667, 1.62, 0.25
5638, 0.16666666666667, 1.66, 0.25
5639, 0.16666666666667, 1.54, 0.33333333333333
5640, 0.16666666666667, 1.58, 0.33333333333333
5641, 0.16666666666667, 1.62, 0.33333333333333
5642, 0.16666666666667, 1.66, 0.33333333333333
5643, 0.16666666666667, 1.54, 0.41666666666667
5644, 0.16666666666667, 1.58, 0.41666666666667
5645, 0.16666666666667, 1.62, 0.41666666666667
5646, 0.16666666666667, 1.66, 0.41666666666667
5647, 0.25, 1.54, 0.083333333333333
5648, 0.25, 1.58, 0.083333333333333
5649, 0.25, 1.62, 0.083333333333333
5650, 0.25, 1.66, 0.083333333333333
5651, 0.25, 1.54, 0.16666666666667
5652, 0.25, 1.58, 0.16666666666667
5653, 0.25, 1.62, 0.16666666666667
5654, 0.25, 1.66, 0.16666666666667
5655, 0.25, 1.54, 0.25
5656, 0.25, 1.58, 0.25
5657, 0.25, 1.62, 0.25
5658, 0.25, 1.66, 0.25
5659, 0.25, 1.54, 0.33333333333333
5660, 0.25, 1.58, 0.33333333333333
5661, 0.25, 1.62, 0.33333333333333
5662, 0.25, 1.66, 0.33333333333333
5663, 0.25, 1.54, 0.41666666666667
5664, 0.25, 1.58, 0.41666666666667
5665, 0.25, 1.62, 0.41666666666667
5666, 0.25, 1.66, 0.41666666666667
5667, 0.33333333333333, 1.54, 0.083333333333333
5668, 0.33333333333333, 1.58, 0.083333333333333
5669, 0.33333333333333, 1.62, 0.083333333333333
5670, 0.33333333333333, 1.66, 0.083333333333333
5671, 0.33333333333333, 1.54, 0.16666666666667
5672, 0.33333333333333, 1.58, 0.16666666666667
5673, 0.33333333333333, 1.62, 0.16666666666667
5674, 0.33333333333333, 1.66, 0.16666666666667
5675, 0.33333333333333, 1.54, 0.25
5676, 0.33333333333333, 1.58, 0.25
5677, 0.33333333333333, 1.62, 0.25
5678, 0.33333333333333, 1.66, 0.25
5679, 0.33333333333333, 1.54, 0.33333333333333
5680, 0.33333333333333, 1.58, 0.33333333333333
5681, 0.33333333333333, 1.62, 0.33333333333333
5682, 0.33333333333333, 1.66, 0.33333333333333
5683, 0.33333333333333, 1.54, 0.41666666666667
5684, 0.33333333333333, 1.58, 0.41666666666667
5685, 0.33333333333333, 1.62, 0.41666666666667
5686, 0.33333333333333, 1.66, 0.41666666666667
5687, 0.41666666666667, 1.54, 0.083333333333333
5688, 0.41666666666667, 1.58, 0.083333333333333
5689, 0.41666666666667, 1.62, 0.083333333333333
5690, 0.41666666666667, 1.66, 0.083333333333333
5691, 0.41666666666667, 1.54, 0.16666666666667
5692, 0.41666666666667, 1.58, 0.16666666666667
5693, 0.41666666666667, 1.62, 0.16666666666667
5694, 0.41666666666667, 1.66, 0.16666666666667
5695, 0.41666666666667, 1.54, 0.25
5696, 0.41666666666667, 1.58, 0.25
5697, 0.41666666666667, 1.62, 0.25
5698, 0.41666666666667, 1.66, 0.25
5699, 0.41666666666667, 1.54, 0.33333333333333
5700, 0.41666666666667, 1.58, 0.33333333333333
5701, 0.41666666666667, 1.62, 0.33333333333333
5702, 0.41666666666667, 1.66, 0.33333333333333
5703, 0.41666666666667, 1.54, 0.41666666666667
5704, 0.41666666666667, 1.58, 0.41666666666667
5705, 0.41666666666667, 1.62, 0.41666666666667
5706, 0.41666666666667, 1.66, 0.41666666666667
5707, 0.5, 1.54, 0.083333333333333
5708, 0.5, 1.58, 0.083333333333333
5709, 0.5, 1.62, 0.083333333333333
5710, 0.5, 1.66, 0.083333333333333
5711, 0.5, 1.54, 0.16666666666667
5712, 0.5, 1.58, 0.16666666666667
5713, 0.5, 1.62, 0.16666666666667
5714, 0.5, 1.66, 0.16666666666667
5715, 0.5, 1.54, 0.25
5716, 0.5, 1.58, 0.25
5717, 0.5, 1.62, 0.25
5718, 0.5, 1.66, 0.25
5719, 0.5, 1.54, 0.33333333333333
5720, 0.5, 1.58, 0.33333333333333
5721, 0.5, 1.62, 0.33333333333333
5722, 0.5, 1.66, 0.33333333333333
5723, 0.5, 1.54, 0.41666666666667
5724, 0.5, 1.58, 0.41666666666667
5725, 0.5, 1.62, 0.41666666666667
5726, 0.5, 1.66, 0.41666666666667
5727, 0.58333333333333, 1.54, 0.083333333333333
5728, 0.58333333333333, 1.58, 0.083333333333333
5729, 0.58333333333333, 1.62, 0.083333333333333
5730, 0.58333333333333, 1.66, 0.083333333333333
5731, 0.58333333333333, 1.54, 0.16666666666667
5732, 0.58333333333333, 1.58, 0.16666666666667
5733, 0.58333333333333, 1.62, 0.16666666666667
5734, 0.58333333333333, 1.66, 0.16666666666667
5735, 0.58333333333333, 1.54, 0.25
5736, 0.58333333333333, 1.58, 0.25
5737, 0.58333333333333, 1.62, 0.25
5738, 0.58333333333333, 1.66, 0.25
5739, 0.58333333333333, 1.54, 0.33333333333333
5740, 0.58333333333333, 1.58, 0.33333333333333
5741, 0.58333333333333, 1.62, 0.33333333333333
5742, 0.58333333333333, 1.66, 0.33333333333333
5743, 0.58333333333333, 1.54, 0.41666666666667
5744, 0.58333333333333, 1.58, 0.41666666666667
5745, 0.58333333333333, 1.62, 0.41666666666667
5746, 0.58333333333333, 1.66, 0.41666666666667
5747, 0.66666666666667, 1.54, 0.083333333333333
5748, 0.66666666666667, 1.58, 0.083333333333333
5749, 0.66666666666667, 1.62, 0.083333333333333
5750, 0.66666666666667, 1.66, 0.083333333333333
5751, 0.66666666666667, 1.54, 0.16666666666667
5752, 0.66666666666667, 1.58, 0.16666666666667
5753, 0.66666666666667, 1.62, 0.16666666666667
5754, 0.66666666666667, 1.66, 0.16666666666667
5755, 0.66666666666667, 1.54, 0.25
5756, 0.66666666666667, 1.58, 0.25
5757, 0.66666666666667, 1.62, 0.25
5758, 0.66666666666667, 1.66, 0.25
5759, 0.66666666666667, 1.54, 0.33333333333333
5760, 0.66666666666667, 1.58, 0.33333333333333
5761, 0.66666666666667, 1.62, 0.33333333333333
5762, 0.66666666666667, 1.66, 0.33333333333333
5763, 0.66666666666667, 1.54, 0.41666666666667
5764, 0.66666666666667, 1.58, 0.41666666666667
5765, 0.66666666666667, 1.62, 0.41666666666667
5766, 0.66666666666667, 1.66, 0.41666666666667
5767, 0.75, 1.54, 0.083333333333333
5768, 0.75, 1.58, 0.083333333333333
5769, 0.75, 1.62, 0.083333333333333
5770, 0.75, 1.66, 0.083333333333333
5771, 0.75, 1.54, 0.16666666666667
5772, 0.75, 1.58, 0.16666666666667
5773, 0.75, 1.62, 0.16666666666667
5774, 0.75, 1.66, 0.16666666666667
5775, 0.75, 1.54, 0.25
5776, 0.75, 1.58, 0.25
5777, 0.75, 1.62, 0.25
5778, 0.75, 1.66, 0.25
5779, 0.75, 1.54, 0.33333333333333
5780, 0.75, 1.58, 0.33333333333333
5781, 0.75, 1.62, 0.33333333333333
5782, 0.75, 1.66, 0.33333333333333
5783, 0.75, 1.54, 0.41666666666667
5784, 0.75, 1.58, 0.41666666666667
5785, 0.75, 1.62, 0.41666666666667
5786, 0.75, 1.66, 0.41666666666667
5787, 0.83333333333333, 1.54, 0.083333333333333
5788, 0.83333333333333, 1.58, 0.083333333333333
5789, 0.83333333333333, 1.62, 0.083333333333333
5790, 0.83333333333333, 1.66, 0.083333333333333
5791, 0.83333333333333, 1.54, 0.16666666666667
5792, 0.83333333333333, 1.58, 0.16666666666667
5793, 0.83333333333333, 1.62, 0.16666666666667
5794, 0.83333333333333, 1.66, 0.16666666666667
5795, 0.83333333333333, 1.54, 0.25
5796, 0.83333333333333, 1.58, 0.25
5797, 0.83333333333333, 1.62, 0.25
5798, 0.83333333333333, 1.66, 0.25
5799, 0.83333333333333, 1.54, 0.33333333333333
5800, 0.83333333333333, 1.58, 0.33333333333333
5801, 0.83333333333333, 1.62, 0.33333333333333
5802, 0.83333333333333, 1.66, 0.33333333333333
5803, 0.83333333333333, 1.54, 0.41666666666667
5804, 0.83333333333333, 1.58, 0.41666666666667
5805, 0.83333333333333, 1.62, 0.41666666666667
5806, 0.83333333333333, 1.66, 0.41666666666667
5807, 0.91666666666667, 1.54, 0.083333333333333
5808, 0.91666666666667, 1.58, 0.083333333333333
5809, 0.91666666666667, 1.62, 0.083333333333333
5810, 0.91666666666667, 1.66, 0.083333333333333
5811, 0.91666666666667, 1.54, 0.16666666666667
5812, 0.91666666666667, 1.58, 0.16666666666667
5813, 0.91666666666667, 1.62, 0.16666666666667
5814, 0.91666666666667, 1.66, 0.16666666666667
5815, 0.91666666666667, 1.54, 0.25
5816, 0.91666666666667, 1.58, 0.25
5817, 0.91666666666667, 1.62, 0.25
5818, 0.91666666666667, 1.66, 0.25
5819, 0.91666666666667, 1.54, 0.33333333333333
5820, 0.91666666666667, 1.58, 0.33333333333333
5821, 0.91666666666667, 1.62, 0.33333333333333
5822, 0.91666666666667, 1.66, 0.33333333333333
5823, 0.91666666666667, 1.54, 0.41666666666667
5824, 0.91666666666667, 1.58, 0.41666666666667
5825, 0.91666666666667, 1.62, 0.41666666666667
5826, 0.91666666666667, 1.66, 0.41666666666667
5827, 1.04, 1.54, 0.083333333333333
5828, 1.04, 1.58, 0.083333333333333
5829, 1.04, 1.62, 0.083333333333333
5830, 1.04, 1.66, 0.083333333333333
5831, 1.08, 1.54, 0.083333333333333
5832, 1.08, 1.58, 0.083333333333333
5833, 1.08, 1.62, 0.083333333333333
5834, 1.08, 1.66, 0.083333333333333
5835, 1.12, 1.54, 0.083333333333333
5836, 1.12, 1.58, 0.083333333333333
5837, 1.12, 1.62, 0.083333333333333
5838, 1.12, 1.66, 0.083333333333333
5839, 1.16, 1.54, 0.083333333333333
5840, 1.16, 1.58, 0.083333333333333
5841, 1.16, 1.62, 0.083333333333333
5842, 1.16, 1.66, 0.083333333333333
5843, 1.04, 1.54, 0.16666666666667
5844, 1.04, 1.58, 0.16666666666667
5845, 1.04, 1.62, 0.16666666666667
5846, 1.04, 1.66, 0.16666666666667
5847, 1.08, 1.54, 0.16666666666667
5848, 1.08, 1.58, 0.16666666666667
5849, 1.08, 1.62, 0.16666666666667
5850, 1.08, 1.66, 0.16666666666667
5851, 1.12, 1.54, 0.16666666666667
5852, 1.12, 1.58, 0.16666666666667
5853, 1.12, 1.62, 0.16666666666667
5854, 1.12, 1.66, 0.16666666666667
5855, 1.16, 1.54, 0.16666666666667
5856, 1.16, 1.58, 0.16666666666667
5857, 1.16, 1.62, 0.16666666666667
5858, 1.16, 1.66, 0.16666666666667
5859, 1.04, 1.54, 0.25
5860, 1.04, 1.58, 0.25
5861, 1.04, 1.62, 0.25
5862, 1.04, 1.66, 0.25
5863, 1.08, 1.54, 0.25
5864, 1.08, 1.58, 0.25
5865, 1.08, 1.62, 0.25
5866, 1.08, 1.66, 0.25
5867, 1.12, 1.54, 0.25
5868, 1.12, 1.58, 0.25
5869, 1.12, 1.62, 0.25
5870, 1.12, 1.66, 0.25
5871, 1.16, 1.54, 0.25
5872, 1.16, 1.58, 0.25
5873, 1.16, 1.62, 0.25
5874, 1.16, 1.66, 0.25
5875, 1.04, 1.54, 0.33333333333333
5876, 1.04, 1.58, 0.33333333333333
5877, 1.04, 1.62, 0.33333333333333
5878, 1.04, 1.66, 0.33333333333333
5879, 1.08, 1.54, 0.33333333333333
5880, 1.08, 1.58, 0.33333333333333
5881, 1.08, 1.62, 0.33333333333333
5882, 1.08, 1.66, 0.33333333333333
5883, 1.12, 1.54, 0.33333333333333
5884, 1.12, 1.58, 0.33333333333333
5885, 1.12, 1.62, 0.33333333333333
5886, 1.12, 1.66, 0.33333333333333
5887, 1.16, 1.54, 0.33333333333333
5888, 1.16, 1.58, 0.33333333333333
5889, 1.16, 1.62, 0.33333333333333
5890, 1.16, 1.66, 0.33333333333333
5891, 1.04, 1.54, 0.41666666666667
5892, 1.04, 1.58, 0.41666666666667
5893, 1.04, 1.62, 0.41666666666667
5894, 1.04, 1.66, 0.41666666666667
5895, 1.08, 1.54, 0.41666666666667
5896, 1.08, 1.58, 0.41666666666667
5897, 1.08, 1.62, 0.41666666666667
5898, 1.08, 1.66, 0.41666666666667
5899, 1.12, 1.54, 0.41666666666667
5900, 1.12, 1.58, 0.41666666666667
5901, 1.12, 1.62, 0.41666666666667
5902, 1.12, 1.66, 0.41666666666667
5903, 1.16, 1.54, 0.41666666666667
5904, 1.16, 1.58, 0.41666666666667
5905, 1.16, 1.62, 0.41666666666667
5906, 1.16, 1.66, 0.41666666666667
5907, 1.2833333333333, 1.54, 0.083333333333333
5908, 1.2833333333333, 1.58, 0.083333333333333
5909, 1.2833333333333, 1.62, 0.083333333333333
5910, 1.2833333333333, 1.66, 0.083333333333333
5911, 1.3666666666667, 1.54, 0.083333333333333
5912, 1.3666666666667, 1.58, 0.083333333333333
5913, 1.3666666666667, 1.62, 0.083333333333333
5914, 1.3666666666667, 1.66, 0.083333333333333
5915, 1.45, 1.54, 0.083333333333333
5916, 1.45, 1.58, 0.083333333333333
5917, 1.45, 1.62, 0.083333333333333
5918, 1.45, 1.66, 0.083333333333333
5919, 1.5333333333333, 1.54, 0.083333333333333
5920, 1.5333333333333, 1.58, 0.083333333333333
5921, 1.5333333333333, 1.62, 0.083333333333333
5922, 1.5333333333333, 1.66, 0.083333333333333
5923, 1.6166666666667, 1.54, 0.083333333333333
5924, 1.6166666666667, 1.58, 0.083333333333333
5925, 1.6166666666667, 1.62, 0.083333333333333
5926, 1.6166666666667, 1.66, 0.083333333333333
5927, 1.7, 1.54, 0.083333333333333
5928, 1.7, 1.58, 0.083333333333333
5929, 1.7, 1.62, 0.083333333333333
5930, 1.7, 1.66, 0.083333333333333
5931, 1.7833333333333, 1.54, 0.083333333333333
5932, 1.7833333333333, 1.58, 0.083333333333333
5933, 1.7833333333333, 1.62, 0.083333333333333
5934, 1.7833333333333, 1.66, 0.083333333333333
5935, 1.8666666666667, 1.54, 0.083333333333333
5936, 1.8666666666667, 1.58, 0.083333333333333
5937, 1.8666666666667, 1.62, 0.083333333333333
5938, 1.8666666666667, 1.66, 0.083333333333333
5939, 1.95, 1.54, 0.083333333333333
5940, 1.95, 1.58, 0.083333333333333
5941, 1.95, 1.62, 0.083333333333333
5942, 1.95, 1.66, 0.083333333333333
5943, 2.0333333333333, 1.54, 0.083333333333333
5944, 2.0333333333333, 1.58, 0.083333333333333
5945, 2.0333333333333, 1.62, 0.083333333333333
5946, 2.0333333333333, 1.66, 0.083333333333333
5947, 2.1166666666667, 1.54, 0.083333333333333
5948, 2.1166666666667, 1.58, 0.083333333333333
5949, 2.1166666666667, 1.62, 0.083333333333333
5950, 2.1166666666667, 1.66, 0.083333333333333
5951, 1.2833333333333, 1.54, 0.16666666666667
5952, 1.2833333333333, 1.58, 0.16666666666667
5953, 1.2833333333333, 1.62, 0.16666666666667
5954, 1.2833333333333, 1.66, 0.16666666666667
5955, 1.3666666666667, 1.54, 0.16666666666667
5956, 1.3666666666667, 1.58, 0.16666666666667
5957, 1.3666666666667, 1.62, 0.16666666666667
5958, 1.3666666666667, 1.66, 0.16666666666667
5959, 1.45, 1.54, 0.16666666666667
5960, 1.45, 1.58, 0.16666666666667
5961, 1.45, 1.62, 0.16666666666667
5962, 1.45, 1.66, 0.16666666666667
5963, 1.5333333333333, 1.54, 0.16666666666667
5964, 1.5333333333333, 1.58, 0.16666666666667
5965, 1.5333333333333, 1.62, 0.16666666666667
5966, 1.5333333333333, 1.66, 0.16666666666667
5967, 1.6166666666667, 1.54, 0.16666666666667
5968, 1.6166666666667, 1.58, 0.16666666666667
5969, 1.6166666666667, 1.62, 0.16666666666667
5970, 1.6166666666667, 1.66, 0.16666666666667
5971, 1.7, 1.54, 0.16666666666667
5972, 1.7, 1.58, 0.16666666666667
5973, 1.7, 1.62, 0.16666666666667
5974, 1.7, 1.66, 0.16666666666667
5975, 1.7833333333333, 1.54, 0.16666666666667
5976, 1.7833333333333, 1.58, 0.16666666666667
5977, 1.7833333333333, 1.62, 0.16666666666667
5978, 1.7833333333333, 1.66, 0.16666666666667
5979, 1.8666666666667, 1.54, 0.16666666666667
5980, 1.8666666666667, 1.58, 0.16666666666667
5981, 1.8666666666667, 1.62, 0.16666666666667
5982, 1.8666666666667, 1.66, 0.16666666666667
5983, 1.95, 1.54, 0.16666666666667
5984, 1.95, 1.58, 0.16666666666667
5985, 1.95, 1.62, 0.16666666666667
5986, 1.95, 1.66, 0.16666666666667
5987, 2.0333333333333, 1.54, 0.16666666666667
5988, 2.0333333333333, 1.58, 0.16666666666667
5989, 2.0333333333333, 1.62, 0.16666666666667
5990, 2.0333333333333, 1.66, 0.16666666666667
5991, 2.1166666666667, 1.54, 0.16666666666667
5992, 2.1166666666667, 1.58, 0.16666666666667
5993, 2.1166666666667, 1.62, 0.16666666666667
5994, 2.1166666666667, 1.66, 0.16666666666667
5995, 1.2833333333333, 1.54, 0.25
5996, 1.2833333333333, 1.58, 0.25
5997, 1.2833333333333, 1.62, 0.25
5998, 1.2833333333333, 1.66, 0.25
5999, 1.3666666666667, 1.54, 0.25
6000, 1.3666666666667, 1.58, 0.25
6001, 1.3666666666667, 1.62, 0.25
6002, 1.3666666666667, 1.66, 0.25
6003, 1.45, 1.54, 0.25
6004, 1.45, 1.58, 0.25
6005, 1.45, 1.62, 0.25
6006, 1.45, 1.66, 0.25
6007, 1.5333333333333, 1.54, 0.25
6008, 1.5333333333333, 1.58, 0.25
6009, 1.5333333333333, 1.62, 0.25
6010, 1.5333333333333, 1.66, 0.25
6011, 1.6166666666667, 1.54, 0.25
6012, 1.6166666666667, 1.58, 0.25
6013, 1.6166666666667, 1.62, 0.25
6014, 1.6166666666667, 1.66, 0.25
6015, 1.7, 1.54, 0.25
6016, 1.7, 1.58, 0.25
6017, 1.7, 1.62, 0.25
6018, 1.7, 1.66, 0.25
6019, 1.7833333333333, 1.54, 0.25
6020, 1.7833333333333, 1.58, 0.25
6021, 1.7833333333333, 1.62, 0.25
6022, 1.7833333333333, 1.66, 0.25
6023, 1.8666666666667, 1.54, 0.25
6024, 1.8666666666667, 1.58, 0.25
6025, 1.8666666666667, 1.62, 0.25
6026, 1.8666666666667, 1.66, 0.25
6027, 1.95, 1.54, 0.25
6028, 1.95, 1.58, 0.25
6029, 1.95, 1.62, 0.25
6030, 1.95, 1.66, 0.25
6031, 2.0333333333333, 1.54, 0.25
6032, 2.0333333333333, 1.58, 0.25
6033, 2.0333333333333, 1.62, 0.25
6034, 2.0333333333333, 1.66, 0.25
6035, 2.1166666666667, 1.54, 0.25
6036, 2.1166666666667, 1.58, 0.25
6037, 2.1166666666667, 1.62, 0.25
6038, 2.1166666666667, 1.66, 0.25
6039, 1.2833333333333, 1.54, 0.33333333333333
6040, 1.2833333333333, 1.58, 0.33333333333333
6041, 1.2833333333333, 1.62, 0.33333333333333
6042, 1.2833333333333, 1.66, 0.33333333333333
6043, 1.3666666666667, 1.54, 0.33333333333333
6044, 1.3666666666667, 1.58, 0.33333333333333
6045, 1.3666666666667, 1.62, 0.33333333333333
6046, 1.3666666666667, 1.66, 0.33333333333333
6047, 1.45, 1.54, 0.33333333333333
6048, 1.45, 1.58, 0.33333333333333
6049, 1.45, 1.62, 0.33333333333333
6050, 1.45, 1.66, 0.33333333333333
6051, 1.5333333333333, 1.54, 0.33333333333333
6052, 1.5333333333333, 1.58, 0.33333333333333
6053, 1.5333333333333, 1.62, 0.33333333333333
6054, 1.5333333333333, 1.66, 0.33333333333333
6055, 1.6166666666667, 1.54, 0.33333333333333
6056, 1.6166666666667, 1.58, 0.33333333333333
6057, 1.6166666666667, 1.62, 0.33333333333333
6058, 1.6166666666667, 1.66, 0.33333333333333
6059, 1.7, 1.54, 0.33333333333333
6060, 1.7, 1.58, 0.33333333333333
6061, 1.7, 1.62, 0.33333333333333
6062, 1.7, 1.66, 0.33333333333333
6063, 1.7833333333333, 1.54, 0.33333333333333
6064, 1.7833333333333, 1.58, 0.33333333333333
6065, 1.7833333333333, 1.62, 0.33333333333333
6066, 1.7833333333333, 1.66, 0.33333333333333
6067, 1.8666666666667, 1.54, 0.33333333333333
6068, 1.8666666666667, 1.58, 0.33333333333333
6069, 1.8666666666667, 1.62, 0.33333333333333
6070, 1.8666666666667, 1.66, 0.33333333333333
6071, 1.95, 1.54, 0.33333333333333
6072, 1.95, 1.58, 0.33333333333333
6073, 1.95, 1.62, 0.33333333333333
6074, 1.95, 1.66, 0.33333333333333
6075, 2.0333333333333, 1.54, 0.33333333333333
6076, 2.0333333333333, 1.58, 0.33333333333333
6077, 2.0333333333333, 1.62, 0.33333333333333
6078, 2.0333333333333, 1.66, 0.33333333333333
6079, 2.1166666666667, 1.54, 0.33333333333333
6080, 2.1166666666667, 1.58, 0.33333333333333
6081, 2.1166666666667, 1.62, 0.33333333333333
6082, 2.1166666666667, 1.66, 0.33333333333333
6083, 1.2833333333333, 1.54, 0.41666666666667
6084, 1.2833333333333, 1.58, 0.41666666666667
6085, 1.2833333333333, 1.62, 0.41666666666667
6086, 1.2833333333333, 1.66, 0.41666666666667
6087, 1.3666666666667, 1.54, 0.41666666666667
6088, 1.3666666666667, 1.58, 0.41666666666667
6089, 1.3666666666667, 1.62, 0.41666666666667
6090, 1.3666666666667, 1.66, 0.41666666666667
6091, 1.45, 1.54, 0.41666666666667
6092, 1.45, 1.58, 0.41666666666667
6093, 1.45, 1.62, 0.41666666666667
6094, 1.45, 1.66, 0.41666666666667
6095, 1.5333333333333, 1.54, 0.41666666666667
6096, 1.5333333333333, 1.58, 0.41666666666667
6097, 1.5333333333333, 1.62, 0.41666666666667
6098, 1.5333333333333, 1.66, 0.41666666666667
6099, 1.6166666666667, 1.54, 0.41666666666667
6100, 1.6166666666667, 1.58, 0.41666666666667
6101, 1.6166666666667, 1.62, 0.41666666666667
6102, 1.6166666666667, 1.66, 0.41666666666667
6103, 1.7, 1.54, 0.41666666666667
6104, 1.7, 1.58, 0.41666666666667
6105, 1.7, 1.62, 0.41666666666667
6106, 1.7, 1.66, 0.41666666666667
6107, 1.7833333333333, 1.54, 0.41666666666667
6108, 1.7833333333333, 1.58, 0.41666666666667
6109, 1.7833333333333, 1.62, 0.41666666666667
6110, 1.7833333333333, 1.66, 0.41666666666667
6111, 1.8666666666667, 1.54, 0.41666666666667
6112, 1.8666666666667, 1.58, 0.41666666666667
6113, 1.8666666666667, 1.62, 0.41666666666667
6114, 1.8666666666667, 1.66, 0.41666666666667
6115, 1.95, 1.54, 0.41666666666667
6116, 1.95, 1.58, 0.41666666666667
6117, 1.95, 1.62, 0.41666666666667
6118, 1.95, 1.66, 0.41666666666667
6119, 2.0333333333333, 1.54, 0.41666666666667
6120, 2.0333333333333, 1.58, 0.41666666666667
6121, 2.0333333333333, 1.62, 0.41666666666667
6122, 2.0333333333333, 1.66, 0.41666666666667
6123, 2.1166666666667, 1.54, 0.41666666666667
6124, 2.1166666666667, 1.58, 0.41666666666667
6125, 2.1166666666667, 1.62, 0.41666666666667
6126, 2.1166666666667, 1.66, 0.41666666666667
6127, 0.083333333333333, -0.04, 0.083333333333333
6128, 0.083333333333333, -0.08, 0.083333333333333
6129, 0.083333333333333, -0.12, 0.083333333333333
6130, 0.083333333333333, -0.16, 0.083333333333333
6131, 0.083333333333333, -0.04, 0.16666666666667
6132, 0.083333333333333, -0.08, 0.16666666666667
6133, 0.083333333333333, -0.12, 0.16666666666667
6134, 0.083333333333333, -0.16, 0.16666666666667
6135, 0.083333333333333, -0.04, 0.25
6136, 0.083333333333333, -0.08, 0.25
6137, 0.083333333333333, -0.12, 0.25
6138, 0.083333333333333, -0.16, 0.25
6139, 0.083333333333333, -0.04, 0.33333333333333
6140, 0.083333333333333, -0.08, 0.33333333333333
6141, 0.083333333333333, -0.12, 0.33333333333333
6142, 0.083333333333333, -0.16, 0.33333333333333
6143, 0.083333333333333, -0.04, 0.41666666666667
6144, 0.083333333333333, -0.08, 0.41666666666667
6145, 0.083333333333333, -0.12, 0.41666666666667
6146, 0.083333333333333, -0.16, 0.41666666666667
6147, 0.16666666666667, -0.04, 0.083333333333333
6148, 0.16666666666667, -0.08, 0.083333333333333
6149, 0.16666666666667, -0.12, 0.083333333333333
6150, 0.16666666666667, -0.16, 0.083333333333333
6151, 0.16666666666667, -0.04, 0.16666666666667
6152, 0.16666666666667, -0.08, 0.16666666666667
6153, 0.16666666666667, -0.12, 0.16666666666667
6154, 0.16666666666667, -0.16, 0.16666666666667
6155, 0.16666666666667, -0.04, 0.25
6156, 0.16666666666667, -0.08, 0.25
6157, 0.16666666666667, -0.12, 0.25
6158, 0.16666666666667, -0.16, 0.25
6159, 0.16666666666667, -0.04, 0.33333333333333
6160, 0.16666666666667, -0.08, 0.33333333333333
6161, 0.16666666666667, -0.12, 0.33333333333333
6162, 0.16666666666667, -0.16, 0.33333333333333
6163, 0.16666666666667, -0.04, 0.41666666666667
6164, 0.16666666666667, -0.08, 0.41666666666667
6165, 0.16666666666667, -0.12, 0.41666666666667
6166, 0.16666666666667, -0.16, 0.41666666666667
6167, 0.25, -0.04, 0.083333333333333
6168, 0.25, -0.08, 0.083333333333333
6169, 0.25, -0.12, 0.083333333333333
6170, 0.25, -0.16, 0.083333333333333
6171, 0.25, -0.04, 0.16666666666667
6172, 0.25, -0.08, 0.16666666666667
6173, 0.25, -0.12, 0.16666666666667
6174, 0.25, -0.16, 0.16666666666667
6175, 0.25, -0.04, 0.25
6176, 0.25, -0.08, 0.25
6177, 0.25, -0.12, 0.25
6178, 0.25, -0.16, 0.25
6179, 0.25, -0.04, 0.33333333333333
6180, 0.25, -0.08, 0.33333333333333
6181, 0.25, -0.12, 0.33333333333333
6182, 0.25, -0.16, 0.33333333333333
6183, 0.25, -0.04, 0.41666666666667
6184, 0.25, -0.08, 0.41666666666667
6185, 0.25, -0.12, 0.41666666666667
6186, 0.25, -0.16, 0.41666666666667
6187, 0.33333333333333, -0.04, 0.083333333333333
6188, 0.33333333333333, -0.08, 0.083333333333333
6189, 0.33333333333333, -0.12, 0.083333333333333
6190, 0.33333333333333, -0.16, 0.083333333333333
6191, 0.33333333333333, -0.04, 0.16666666666667
6192, 0.33333333333333, -0.08, 0.16666666666667
6193, 0.33333333333333, -0.12, 0.16666666666667
6194, 0.33333333333333, -0.16, 0.16666666666667
6195, 0.33333333333333, -0.04, 0.25
6196, 0.33333333333333, -0.08, 0.25
6197, 0.33333333333333, -0.12, 0.25
6198, 0.33333333333333, -0.16, 0.25
6199, 0.33333333333333, -0.04, 0.33333333333333
6200, 0.33333333333333, -0.08, 0.33333333333333
6201, 0.33333333333333, -0.12, 0.33333333333333
6202, 0.33333333333333, -0.16, 0.33333333333333
6203, 0.33333333333333, -0.04, 0.41666666666667
6204, 0.33333333333333, -0.08, 0.41666666666667
6205, 0.33333333333333, -0.12, 0.41666666666667
6206, 0.33333333333333, -0.16, 0.41666666666667
6207, 0.41666666666667, -0.04, 0.083333333333333
6208, 0.41666666666667, -0.08, 0.083333333333333
6209, 0.41666666666667, -0.12, 0.083333333333333
6210, 0.41666666666667, -0.16, 0.083333333333333
6211, 0.41666666666667, -0.04, 0.16666666666667
6212, 0.41666666666667, -0.08, 0.16666666666667
6213, 0.41666666666667, -0.12, 0.16666666666667
6214, 0.41666666666667, -0.16, 0.16666666666667
6215, 0.41666666666667, -0.04, 0.25
6216, 0.41666666666667, -0.08, 0.25
6217, 0.41666666666667, -0.12, 0.25
6218, 0.41666666666667, -0.16, 0.25
6219, 0.41666666666667, -0.04, 0.33333333333333
6220, 0.41666666666667, -0.08, 0.33333333333333
6221, 0.41666666666667, -0.12, 0.33333333333333
6222, 0.41666666666667, -0.16, 0.33333333333333
6223, 0.41666666666667, -0.04, 0.41666666666667
6224, 0.41666666666667, -0.08, 0.41666666666667
6225, 0.41666666666667, -0.12, 0.41666666666667
6226, 0.41666666666667, -0.16, 0.41666666666667
6227, 0.5, -0.04, 0.083333333333333
6228, 0.5, -0.08, 0.083333333333333
6229, 0.5, -0.12, 0.083333333333333
6230, 0.5, -0.16, 0.083333333333333
6231, 0.5, -0.04, 0.16666666666667
6232, 0.5, -0.08, 0.16666666666667
6233, 0.5, -0.12, 0.16666666666667
6234, 0.5, -0.16, 0.16666666666667
6235, 0.5, -0.04, 0.25
6236, 0.5, -0.08, 0.25
6237, 0.5, -0.12, 0.25
6238, 0.5, -0.16, 0.25
6239, 0.5, -0.04, 0.33333333333333
6240, 0.5, -0.08, 0.33333333333333
6241, 0.5, -0.12, 0.33333333333333
6242, 0.5, -0.16, 0.33333333333333
6243, 0.5, -0.04, 0.41666666666667
6244, 0.5, -0.08, 0.41666666666667
6245, 0.5, -0.12, 0.41666666666667
6246, 0.5, -0.16, 0.41666666666667
6247, 0.58333333333333, -0.04, 0.083333333333333
6248, 0.58333333333333, -0.08, 0.083333333333333
6249, 0.58333333333333, -0.12, 0.083333333333333
6250, 0.58333333333333, -0.16, 0.083333333333333
6251, 0.58333333333333, -0.04, 0.16666666666667
6252, 0.58333333333333, -0.08, 0.16666666666667
6253, 0.58333333333333, -0.12, 0.16666666666667
6254, 0.58333333333333, -0.16, 0.16666666666667
6255, 0.58333333333333, -0.04, 0.25
6256, 0.58333333333333, -0.08, 0.25
6257, 0.58333333333333, -0.12, 0.25
6258, 0.58333333333333, -0.16, 0.25
6259, 0.58333333333333, -0.04, 0.33333333333333
6260, 0.58333333333333, -0.08, 0.33333333333333
6261, 0.58333333333333, -0.12, 0.33333333333333
6262, 0.58333333333333, -0.16, 0.33333333333333
6263, 0.58333333333333, -0.04, 0.41666666666667
6264, 0.58333333333333, -0.08, 0.41666666666667
6265, 0.58333333333333, -0.12, 0.41666666666667
6266, 0.58333333333333, -0.16, 0.41666666666667
6267, 0.66666666666667, -0.04, 0.083333333333333
6268, 0.66666666666667, -0.08, 0.083333333333333
6269, 0.66666666666667, -0.12, 0.083333333333333
6270, 0.66666666666667, -0.16, 0.083333333333333
6271, 0.66666666666667, -0.04, 0.16666666666667
6272, 0.66666666666667, -0.08, 0.16666666666667
6273, 0.66666666666667, -0.12, 0.16666666666667
6274, 0.66666666666667, -0.16, 0.16666666666667
6275, 0.66666666666667, -0.04, 0.25
6276, 0.66666666666667, -0.08, 0.25
6277, 0.66666666666667, -0.12, 0.25
6278, 0.66666666666667, -0.16, 0.25
6279, 0.66666666666667, -0.04, 0.33333333333333
6280, 0.66666666666667, -0.08, 0.33333333333333
6281, 0.66666666666667, -0.12, 0.33333333333333
6282, 0.66666666666667, -0.16, 0.33333333333333
6283, 0.66666666666667, -0.04, 0.41666666666667
6284, 0.66666666666667, -0.08, 0.41666666666667
6285, 0.66666666666667, -0.12, 0.41666666666667
6286, 0.66666666666667, -0.16, 0.41666666666667
6287, 0.75, -0.04, 0.083333333333333
6288, 0.75, -0.08, 0.083333333333333
6289, 0.75, -0.12, 0.083333333333333
6290, 0.75, -0.16, 0.083333333333333
6291, 0.75, -0.04, 0.16666666666667
6292, 0.75, -0.08, 0.16666666666667
6293, 0.75, -0.12, 0.16666666666667
6294, 0.75, -0.16, 0.16666666666667
6295, 0.75, -0.04, 0.25
6296, 0.75, -0.08, 0.25
6297, 0.75, -0.12, 0.25
6298, 0.75, -0.16, 0.25
6299, 0.75, -0.04, 0.33333333333333
6300, 0.75, -0.08, 0.33333333333333
6301, 0.75, -0.12, 0.33333333333333
6302, 0.75, -0.16, 0.33333333333333
6303, 0.75, -0.04, 0.41666666666667
6304, 0.75, -0.08, 0.41666666666667
6305, 0.75, -0.12, 0.41666666666667
6306, 0.75, -0.16, 0.41666666666667
6307, 0.83333333333333, -0.04, 0.083333333333333
6308, 0.83333333333333, -0.08, 0.083333333333333
6309, 0.83333333333333, -0.12, 0.083333333333333
6310, 0.83333333333333, -0.16, 0.083333333333333
6311, 0.83333333333333, -0.04, 0.16666666666667
6312, 0.83333333333333, -0.08, 0.16666666666667
6313, 0.83333333333333, -0.12, 0.16666666666667
6314, 0.83333333333333, -0.16, 0.16666666666667
6315, 0.83333333333333, -0.04, 0.25
6316, 0.83333333333333, -0.08, 0.25
6317, 0.83333333333333, -0.12, 0.25
6318, 0.83333333333333, -0.16, 0.25
6319, 0.83333333333333, -0.04, 0.33333333333333
6320, 0.83333333333333, -0.08, 0.33333333333333
6321, 0.83333333333333, -0.12, 0.33333333333333
6322, 0.83333333333333, -0.16, 0.33333333333333
6323, 0.83333333333333, -0.04, 0.41666666666667
6324, 0.83333333333333, -0.08, 0.41666666666667
6325, 0.83333333333333, -0.12, 0.41666666666667
6326, 0.83333333333333, -0.16, 0.41666666666667
6327, 0.91666666666667, -0.04, 0.083333333333333
6328, 0.91666666666667, -0.08, 0.083333333333333
6329, 0.91666666666667, -0.12, 0.083333333333333
6330, 0.91666666666667, -0.16, 0.083333333333333
6331, 0.91666666666667, -0.04, 0.16666666666667
6332, 0.91666666666667, -0.08, 0.16666666666667
6333, 0.91666666666667, -0.12, 0.16666666666667
6334, 0.91666666666667, -0.16, 0.16666666666667
6335, 0.91666666666667, -0.04, 0.25
6336, 0.91666666666667, -0.08, 0.25
6337, 0.91666666666667, -0.12, 0.25
6338, 0.91666666666667, -0.16, 0.25
6339, 0.91666666666667, -0.04, 0.33333333333333
6340, 0.91666666666667, -0.08, 0.33333333333333
6341, 0.91666666666667, -0.12, 0.33333333333333
6342, 0.91666666666667, -0.16, 0.33333333333333
6343, 0.91666666666667, -0.04, 0.41666666666667
6344, 0.91666666666667, -0.08, 0.41666666666667
6345, 0.91666666666667, -0.12, 0.41666666666667
6346, 0.91666666666667, -0.16, 0.41666666666667
6347, 1.2833333333333, -0.04, 0.083333333333333
6348, 1.2833333333333, -0.08, 0.083333333333333
6349, 1.2833333333333, -0.12, 0.083333333333333
6350, 1.2833333333333, -0.16, 0.083333333333333
6351, 1.3666666666667, -0.04, 0.083333333333333
6352, 1.3666666666667, -0.08, 0.083333333333333
6353, 1.3666666666667, -0.12, 0.083333333333333
6354, 1.3666666666667, -0.16, 0.083333333333333
6355, 1.45, -0.04, 0.083333333333333
6356, 1.45, -0.08, 0.083333333333333
6357, 1.45, -0.12, 0.083333333333333
6358, 1.45, -0.16, 0.083333333333333
6359, 1.5333333333333, -0.04, 0.083333333333333
6360, 1.5333333333333, -0.08, 0.083333333333333
6361, 1.5333333333333, -0.12, 0.083333333333333
6362, 1.5333333333333, -0.16, 0.083333333333333
6363, 1.6166666666667, -0.04, 0.083333333333333
6364, 1.6166666666667, -0.08, 0.083333333333333
6365, 1.6166666666667, -0.12, 0.083333333333333
6366, 1.6166666666667, -0.16, 0.083333333333333
6367, 1.7, -0.04, 0.083333333333333
6368, 1.7, -0.08, 0.083333333333333
6369, 1.7, -0.12, 0.083333333333333
6370, 1.7, -0.16, 0.083333333333333
6371, 1.7833333333333, -0.04, 0.083333333333333
6372, 1.7833333333333, -0.08, 0.083333333333333
6373, 1.7833333333333, -0.12, 0.083333333333333
6374, 1.7833333333333, -0.16, 0.083333333333333
6375, 1.8666666666667, -0.04, 0.083333333333333
6376, 1.8666666666667, -0.08, 0.083333333333333
6377, 1.8666666666667, -0.12, 0.083333333333333
6378, 1.8666666666667, -0.16, 0.083333333333333
6379, 1.95, -0.04, 0.083333333333333
6380, 1.95, -0.08, 0.083333333333333
6381, 1.95, -0.12, 0.083333333333333
6382, 1.95, -0.16, 0.083333333333333
6383, 2.0333333333333, -0.04, 0.083333333333333
6384, 2.0333333333333, -0.08, 0.083333333333333
6385, 2.0333333333333, -0.12, 0.083333333333333
6386, 2.0333333333333, -0.16, 0.083333333333333
6387, 2.1166666666667, -0.04, 0.083333333333333
6388, 2.1166666666667, -0.08, 0.083333333333333
6389, 2.1166666666667, -0.12, 0.083333333333333
6390, 2.1166666666667, -0.16, 0.083333333333333
6391, 1.2833333333333, -0.04, 0.16666666666667
6392, 1.2833333333333, -0.08, 0.16666666666667
6393, 1.2833333333333, -0.12, 0.16666666666667
6394, 1.2833333333333, -0.16, 0.16666666666667
6395, 1.3666666666667, -0.04, 0.16666666666667
6396, 1.3666666666667, -0.08, 0.16666666666667
6397, 1.3666666666667, -0.12, 0.16666666666667
6398, 1.3666666666667, -0.16, 0.16666666666667
6399, 1.45, -0.04, 0.16666666666667
6400, 1.45, -0.08, 0.16666666666667
6401, 1.45, -0.12, 0.16666666666667
6402, 1.45, -0.16, 0.16666666666667
6403, 1.5333333333333, -0.04, 0.16666666666667
6404, 1.5333333333333, -0.08, 0.16666666666667
6405, 1.5333333333333, -0.12, 0.16666666666667
6406, 1.5333333333333, -0.16, 0.16666666666667
6407, 1.6166666666667, -0.04, 0.16666666666667
6408, 1.6166666666667, -0.08, 0.16666666666667
6409, 1.6166666666667, -0.12, 0.16666666666667
6410, 1.6166666666667, -0.16, 0.16666666666667
6411, 1.7, -0.04, 0.16666666666667
6412, 1.7, -0.08, 0.16666666666667
6413, 1.7, -0.12, 0.16666666666667
6414, 1.7, -0.16, 0.16666666666667
6415, 1.7833333333333, -0.04, 0.16666666666667
6416, 1.7833333333333, -0.08, 0.16666666666667
6417, 1.7833333333333, -0.12, 0.16666666666667
6418, 1.7833333333333, -0.16, 0.16666666666667
6419, 1.8666666666667, -0.04, 0.16666666666667
6420, 1.8666666666667, -0.08, 0.16666666666667
6421, 1.8666666666667, -0.12, 0.16666666666667
6422, 1.8666666666667, -0.16, 0.16666666666667
6423, 1.95, -0.04, 0.16666666666667
6424, 1.95, -0.08, 0.16666666666667
6425, 1.95, -0.12, 0.16666666666667
6426, 1.95, -0.16, 0.16666666666667
6427, 2.0333333333333, -0.04, 0.16666666666667
6428, 2.0333333333333, -0.08, 0.16666666666667
6429, 2.0333333333333, -0.12, 0.16666666666667
6430, 2.0333333333333, -0.16, 0.16666666666667
6431, 2.1166666666667, -0.04, 0.16666666666667
6432, 2.1166666666667, -0.08, 0.16666666666667
6433, 2.1166666666667, -0.12, 0.16666666666667
6434, 2.1166666666667, -0.16, 0.16666666666667
6435, 1.2833333333333, -0.04, 0.25
6436, 1.2833333333333, -0.08, 0.25
6437, 1.2833333333333, -0.12, 0.25
6438, 1.2833333333333, -0.16, 0.25
6439, 1.3666666666667, -0.04, 0.25
6440, 1.3666666666667, -0.08, 0.25
6441, 1.3666666666667, -0.12, 0.25
6442, 1.3666666666667, -0.16, 0.25
6443, 1.45, -0.04, 0.25
6444, 1.45, -0.08, 0.25
6445, 1.45, -0.12, 0.25
6446, 1.45, -0.16, 0.25
6447, 1.5333333333333, -0.04, 0.25
6448, 1.5333333333333, -0.08, 0.25
6449, 1.5333333333333, -0.12, 0.25
6450, 1.5333333333333, -0.16, 0.25
6451, 1.6166666666667, -0.04, 0.25
6452, 1.6166666666667, -0.08, 0.25
6453, 1.6166666666667, -0.12, 0.25
6454, 1.6166666666667, -0.16, 0.25
6455, 1.7, -0.04, 0.25
6456, 1.7, -0.08, 0.25
6457, 1.7, -0.12, 0.25
6458, 1.7, -0.16, 0.25
6459, 1.7833333333333, -0.04, 0.25
6460, 1.7833333333333, -0.08, 0.25
6461, 1.7833333333333, -0.12, 0.25
6462, 1.7833333333333, -0.16, 0.25
6463, 1.8666666666667, -0.04, 0.25
6464, 1.8666666666667, -0.08, 0.25
6465, 1.8666666666667, -0.12, 0.25
6466, 1.8666666666667, -0.16, 0.25
6467, 1.95, -0.04, 0.25
6468, 1.95, -0.08, 0.25
6469, 1.95, -0.12, 0.25
6470, 1.95, -0.16, 0.25
6471, 2.0333333333333, -0.04, 0.25
6472, 2.0333333333333, -0.08, 0.25
6473, 2.0333333333333, -0.12, 0.25
6474, 2.0333333333333, -0.16, 0.25
6475, 2.1166666666667, -0.04, 0.25
6476, 2.1166666666667, -0.08, 0.25
6477, 2.1166666666667, -0.12, 0.25
6478, 2.1166666666667, -0.16, 0.25
6479, 1.2833333333333, -0.04, 0.33333333333333
6480, 1.2833333333333, -0.08, 0.33333333333333
6481, 1.2833333333333, -0.12, 0.33333333333333
6482, 1.2833333333333, -0.16, 0.33333333333333
6483, 1.3666666666667, -0.04, 0.33333333333333
6484, 1.3666666666667, -0.08, 0.33333333333333
6485, 1.3666666666667, -0.12, 0.33333333333333
6486, 1.3666666666667, -0.16, 0.33333333333333
6487, 1.45, -0.04, 0.33333333333333
6488, 1.45, -0.08, 0.33333333333333
6489, 1.45, -0.12, 0.33333333333333
6490, 1.45, -0.16, 0.33333333333333
6491, 1.5333333333333, -0.04, 0.33333333333333
6492, 1.5333333333333, -0.08, 0.33333333333333
6493, 1.5333333333333, -0.12, 0.33333333333333
6494, 1.5333333333333, -0.16, 0.33333333333333
6495, 1.6166666666667, -0.04, 0.33333333333333
6496, 1.6166666666667, -0.08, 0.33333333333333
6497, 1.6166666666667, -0.12, 0.33333333333333
6498, 1.6166666666667, -0.16, 0.33333333333333
6499, 1.7, -0.04, 0.33333333333333
6500, 1.7, -0.08, 0.33333333333333
6501, 1.7, -0.12, 0.33333333333333
6502, 1.7, -0.16, 0.33333333333333
6503, 1.7833333333333, -0.04, 0.33333333333333
6504, 1.7833333333333, -0.08, 0.33333333333333
6505, 1.7833333333333, -0.12, 0.33333333333333
6506, 1.7833333333333, -0.16, 0.33333333333333
6507, 1.8666666666667, -0.04, 0.33333333333333
6508, 1.8666666666667, -0.08, 0.33333333333333
6509, 1.8666666666667, -0.12, 0.33333333333333
6510, 1.8666666666667, -0.16, 0.33333333333333
6511, 1.95, -0.04, 0.33333333333333
6512, 1.95, -0.08, 0.33333333333333
6513, 1.95, -0.12, 0.33333333333333
6514, 1.95, -0.16, 0.33333333333333
6515, 2.0333333333333, -0.04, 0.33333333333333
6516, 2.0333333333333, -0.08, 0.33333333333333
6517, 2.0333333333333, -0.12, 0.33333333333333
6518, 2.0333333333333, -0.16, 0.33333333333333
6519, 2.1166666666667, -0.04, 0.33333333333333
6520, 2.1166666666667, -0.08, 0.33333333333333
6521, 2.1166666666667, -0.12, 0.33333333333333
6522, 2.1166666666667, -0.16, 0.33333333333333
6523, 1.2833333333333, -0.04, 0.41666666666667
6524, 1.2833333333333, -0.08, 0.41666666666667
6525, 1.2833333333333, -0.12, 0.41666666666667
6526, 1.2833333333333, -0.16, 0.41666666666667
6527, 1.3666666666667, -0.04, 0.41666666666667
6528, 1.3666666666667, -0.08, 0.41666666666667
6529, 1.3666666666667, -0.12, 0.41666666666667
6530, 1.3666666666667, -0.16, 0.41666666666667
6531, 1.45, -0.04, 0.41666666666667
6532, 1.45, -0.08, 0.41666666666667
6533, 1.45, -0.12, 0.41666666666667
6534, 1.45, -0.16, 0.41666666666667
6535, 1.5333333333333, -0.04, 0.41666666666667
6536, 1.5333333333333, -0.08, 0.41666666666667
6537, 1.5333333333333, -0.12, 0.41666666666667
6538, 1.5333333333333, -0.16, 0.41666666666667
6539, 1.6166666666667, -0.04, 0.41666666666667
6540, 1.6166666666667, -0.08, 0.41666666666667
6541, 1.6166666666667, -0.12, 0.41666666666667
6542, 1.6166666666667, -0.16, 0.41666666666667
6543, 1.7, -0.04, 0.41666666666667
6544, 1.7, -0.08, 0.41666666666667
6545, 1.7, -0.12, 0.41666666666667
6546, 1.7, -0.16, 0.41666666666667
6547, 1.7833333333333, -0.04, 0.41666666666667
6548, 1.7833333333333, -0.08, 0.41666666666667
6549, 1.7833333333333, -0.12, 0.41666666666667
6550, 1.7833333333333, -0.16, 0.41666666666667
6551, 1.8666666666667, -0.04, 0.41666666666667
6552, 1.8666666666667, -0.08, 0.41666666666667
6553, 1.8666666666667, -0.12, 0.41666666666667
6554, 1.8666666666667, -0.16, 0.41666666666667
6555, 1.95, -0.04, 0.41666666666667
6556, 1.95, -0.08, 0.41666666666667
6557, 1.95, -0.12, 0.41666666666667
6558, 1.95, -0.16, 0.41666666666667
6559, 2.0333333333333, -0.04, 0.41666666666667
6560, 2.0333333333333, -0.08, 0.41666666666667
6561, 2.0333333333333, -0.12, 0.41666666666667
6562, 2.0333333333333, -0.16, 0.41666666666667
6563, 2.1166666666667, -0.04, 0.41666666666667
6564, 2.1166666666667, -0.08, 0.41666666666667
6565, 2.1166666666667, -0.12, 0.41666666666667
6566, 2.1166666666667, -0.16, 0.41666666666667
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 99
100, 99, 100
101, 100, 101
102, 101, 1
*ELEMENT, type=T3D2, ELSET=Line2
103, 1, 102
104, 102, 103
105, 103, 3
*ELEMENT, type=T3D2, ELSET=Line3
106, 4, 104
107, 104, 105
108, 105, 106
109, 106, 107
110, 107, 108
111, 108, 3
*ELEMENT, type=T3D2, ELSET=Line4
112, 2, 109
113, 109, 110
114, 110, 4
*ELEMENT, type=T3D2, ELSET=Line5
115, 6, 111
116, 111, 112
117, 112, 113
118, 113, 114
119, 114, 115
120, 115, 5
*ELEMENT, type=T3D2, ELSET=Line6
121, 5, 116
122, 116, 117
123, 117, 7
*ELEMENT, type=T3D2, ELSET=Line7
124, 8, 118
125, 118, 119
126, 119, 120
127, 120, 121
128, 121, 122
129, 122, 7
*ELEMENT, type=T3D2, ELSET=Line8
130, 6, 123
131, 123, 124
132, 124, 8
*ELEMENT, type=T3D2, ELSET=Line9
133, 2, 125
134, 125, 126
135, 126, 127
136, 127, 128
137, 128, 129
138, 129, 130
139, 130, 131
140, 131, 132
141, 132, 133
142, 133, 134
143, 134, 135
144, 135, 6
*ELEMENT, type=T3D2, ELSET=Line10
145, 1, 136
146, 136, 137
147, 137, 138
148, 138, 139
149, 139, 140
150, 140, 141
151, 141, 142
152, 142, 143
153, 143, 144
154, 144, 145
155, 145, 146
156, 146, 5
*ELEMENT, type=T3D2, ELSET=Line11
157, 4, 147
158, 147, 148
159, 148, 149
160, 149, 150
161, 150, 151
162, 151, 152
163, 152, 153
164, 153, 154
165, 154, 155
166, 155, 156
167, 156, 157
168, 157, 8
*ELEMENT, type=T3D2, ELSET=Line12
169, 3, 158
170, 158, 159
171, 159, 160
172, 160, 161
173, 161, 162
174, 162, 163
175, 163, 164
176, 164, 165
177, 165, 166
178, 166, 167
179, 167, 168
180, 168, 7
*ELEMENT, type=T3D2, ELSET=Line13
181, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
182, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
183, 10, 169
184, 169, 170
185, 170, 171
186, 171, 172
187, 172, 173
188, 173, 174
189, 174, 175
190, 175, 176
191, 176, 177
192, 177, 178
193, 178, 179
194, 179, 9
*ELEMENT, type=T3D2, ELSET=Line16
195, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
196, 9, 180
197, 180, 181
198, 181, 182
199, 182, 183
200, 183, 184
201, 184, 11
*ELEMENT, type=T3D2, ELSET=Line18
202, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
203, 12, 185
204, 185, 186
205, 186, 187
206, 187, 188
207, 188, 189
208, 189, 190
209, 190, 191
210, 191, 192
211, 192, 193
212, 193, 194
213, 194, 195
214, 195, 11
*ELEMENT, type=T3D2, ELSET=Line20
215, 10, 196
216, 196, 197
217, 197, 198
218, 198, 199
219, 199, 200
220, 200, 12
*ELEMENT, type=T3D2, ELSET=Line21
221, 9, 201
222, 201, 202
223, 202, 203
224, 203, 204
225, 204, 205
226, 205, 206
227, 206, 207
228, 207, 208
229, 208, 209
230, 209, 210
231, 210, 211
232, 211, 13
*ELEMENT, type=T3D2, ELSET=Line22
233, 10, 212
234, 212, 213
235, 213, 214
236, 214, 215
237, 215, 216
238, 216, 217
239, 217, 218
240, 218, 219
241, 219, 220
242, 220, 221
243, 221, 222
244, 222, 14
*ELEMENT, type=T3D2, ELSET=Line23
245, 14, 223
246, 223, 224
247, 224, 225
248, 225, 226
249, 226, 227
250, 227, 228
251, 228, 229
252, 229, 230
253, 230, 231
254, 231, 232
255, 232, 233
256, 233, 13
*ELEMENT, type=T3D2, ELSET=Line24
257, 11, 234
258, 234, 235
259, 235, 236
260, 236, 237
261, 237, 238
262, 238, 239
263, 239, 240
264, 240, 241
265, 241, 242
266, 242, 243
267, 243, 244
268, 244, 15
*ELEMENT, type=T3D2, ELSET=Line25
269, 13, 245
270, 245, 246
271, 246, 247
272, 247, 248
273, 248, 249
274, 249, 15
*ELEMENT, type=T3D2, ELSET=Line26
275, 12, 250
276, 250, 251
277, 251, 252
278, 252, 253
279, 253, 254
280, 254, 255
281, 255, 256
282, 256, 257
283, 257, 258
284, 258, 259
285, 259, 260
286, 260, 16
*ELEMENT, type=T3D2, ELSET=Line27
287, 16, 261
288, 261, 262
289, 262, 263
290, 263, 264
291, 264, 265
292, 265, 266
293, 266, 267
294, 267, 268
295, 268, 269
296, 269, 270
297, 270, 271
298, 271, 15
*ELEMENT, type=T3D2, ELSET=Line28
299, 14, 272
300, 272, 273
301, 273, 274
302, 274, 275
303, 275, 276
304, 276, 16
*ELEMENT, type=T3D2, ELSET=Line29
305, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
306, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
307, 18, 277
308, 277, 278
309, 278, 279
310, 279, 280
311, 280, 281
312, 281, 282
313, 282, 283
314, 283, 284
315, 284, 285
316, 285, 286
317, 286, 287
318, 287, 17
*ELEMENT, type=T3D2, ELSET=Line32
319, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
320, 17, 288
321, 288, 289
322, 289, 290
323, 290, 291
324, 291, 292
325, 292, 19
*ELEMENT, type=T3D2, ELSET=Line34
326, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
327, 20, 293
328, 293, 294
329, 294, 295
330, 295, 296
331, 296, 297
332, 297, 298
333, 298, 299
334, 299, 300
335, 300, 301
336, 301, 302
337, 302, 303
338, 303, 19
*ELEMENT, type=T3D2, ELSET=Line36
339, 18, 304
340, 304, 305
341, 305, 306
342, 306, 307
343, 307, 308
344, 308, 20
*ELEMENT, type=T3D2, ELSET=Line37
345, 17, 309
346, 309, 310
347, 310, 21
*ELEMENT, type=T3D2, ELSET=Line38
348, 18, 311
349, 311, 312
350, 312, 22
*ELEMENT, type=T3D2, ELSET=Line39
351, 22, 313
352, 313, 314
353, 314, 315
354, 315, 316
355, 316, 317
356, 317, 318
357, 318, 319
358, 319, 320
359, 320, 321
360, 321, 322
361, 322, 323
362, 323, 21
*ELEMENT, type=T3D2, ELSET=Line40
363, 19, 324
364, 324, 325
365, 325, 23
*ELEMENT, type=T3D2, ELSET=Line41
366, 21, 326
367, 326, 327
368, 327, 328
369, 328, 329
370, 329, 330
371, 330, 23
*ELEMENT, type=T3D2, ELSET=Line42
372, 20, 331
373, 331, 332
374, 332, 24
*ELEMENT, type=T3D2, ELSET=Line43
375, 24, 333
376, 333, 334
377, 334, 335
378, 335, 336
379, 336, 337
380, 337, 338
381, 338, 339
382, 339, 340
383, 340, 341
384, 341, 342
385, 342, 343
386, 343, 23
*ELEMENT, type=T3D2, ELSET=Line44
387, 22, 344
388, 344, 345
389, 345, 346
390, 346, 347
391, 347, 348
392, 348, 24
*ELEMENT, type=T3D2, ELSET=Line45
393, 19, 349
394, 349, 350
395, 350, 351
396, 351, 352
397, 352, 25
*ELEMENT, type=T3D2, ELSET=Line46
398, 23, 353
399, 353, 354
400, 354, 355
401, 355, 356
402, 356, 26
*ELEMENT, type=T3D2, ELSET=Line47
403, 25, 357
404, 357, 358
405, 358, 26
*ELEMENT, type=T3D2, ELSET=Line48
406, 17, 359
407, 359, 360
408, 360, 361
409, 361, 362
410, 362, 27
*ELEMENT, type=T3D2, ELSET=Line49
411, 21, 363
412, 363, 364
413, 364, 365
414, 365, 366
415, 366, 28
*ELEMENT, type=T3D2, ELSET=Line50
416, 27, 367
417, 367, 368
418, 368, 28
*ELEMENT, type=T3D2, ELSET=Line51
419, 27, 369
420, 369, 370
421, 370, 371
422, 371, 372
423, 372, 373
424, 373, 25
*ELEMENT, type=T3D2, ELSET=Line52
425, 28, 374
426, 374, 375
427, 375, 376
428, 376, 377
429, 377, 378
430, 378, 26
*ELEMENT, type=T3D2, ELSET=Line53
431, 25, 379
432, 379, 380
433, 380, 381
434, 381, 382
435, 382, 383
436, 383, 384
437, 384, 385
438, 385, 386
439, 386, 387
440, 387, 388
441, 388, 389
442, 389, 29
*ELEMENT, type=T3D2, ELSET=Line54
443, 26, 390
444, 390, 391
445, 391, 392
446, 392, 393
447, 393, 394
448, 394, 395
449, 395, 396
450, 396, 397
451, 397, 398
452, 398, 399
453, 399, 400
454, 400, 30
*ELEMENT, type=T3D2, ELSET=Line55
455, 29, 401
456, 401, 402
457, 402, 30
*ELEMENT, type=T3D2, ELSET=Line56
458, 27, 403
459, 403, 404
460, 404, 405
461, 405, 406
462, 406, 407
463, 407, 408
464, 408, 409
465, 409, 410
466, 410, 411
467, 411, 412
468, 412, 413
469, 413, 31
*ELEMENT, type=T3D2, ELSET=Line57
470, 28, 414
471, 414, 415
472, 415, 416
473, 416, 417
474, 417, 418
475, 418, 419
476, 419, 420
477, 420, 421
478, 421, 422
479, 422, 423
480, 423, 424
481, 424, 32
*ELEMENT, type=T3D2, ELSET=Line58
482, 31, 425
483, 425, 426
484, 426, 32
*ELEMENT, type=T3D2, ELSET=Line59
485, 31, 427
486, 427, 428
487, 428, 429
488, 429, 430
489, 430, 431
490, 431, 29
*ELEMENT, type=T3D2, ELSET=Line60
491, 32, 432
492, 432, 433
493, 433, 434
494, 434, 435
495, 435, 436
496, 436, 30
*ELEMENT, type=T3D2, ELSET=Line61
497, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
498, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
499, 33, 437
500, 437, 438
501, 438, 439
502, 439, 440
503, 440, 441
504, 441, 442
505, 442, 443
506, 443, 444
507, 444, 445
508, 445, 446
509, 446, 447
510, 447, 34
*ELEMENT, type=T3D2, ELSET=Line64
511, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
512, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
513, 35, 448
514, 448, 449
515, 449, 450
516, 450, 451
517, 451, 452
518, 452, 453
519, 453, 454
520, 454, 455
521, 455, 456
522, 456, 457
523, 457, 458
524, 458, 36
*ELEMENT, type=T3D2, ELSET=Line67
525, 35, 459
526, 459, 460
527, 460, 461
528, 461, 462
529, 462, 463
530, 463, 33
*ELEMENT, type=T3D2, ELSET=Line68
531, 36, 464
532, 464, 465
533, 465, 466
534, 466, 467
535, 467, 468
536, 468, 34
*ELEMENT, type=T3D2, ELSET=Line69
537, 33, 469
538, 469, 470
539, 470, 471
540, 471, 472
541, 472, 473
542, 473, 474
543, 474, 475
544, 475, 476
545, 476, 477
546, 477, 478
547, 478, 479
548, 479, 37
*ELEMENT, type=T3D2, ELSET=Line70
549, 34, 480
550, 480, 481
551, 481, 482
552, 482, 483
553, 483, 484
554, 484, 485
555, 485, 486
556, 486, 487
557, 487, 488
558, 488, 489
559, 489, 490
560, 490, 38
*ELEMENT, type=T3D2, ELSET=Line71
561, 37, 491
562, 491, 492
563, 492, 493
564, 493, 494
565, 494, 495
566, 495, 496
567, 496, 497
568, 497, 498
569, 498, 499
570, 499, 500
571, 500, 501
572, 501, 38
*ELEMENT, type=T3D2, ELSET=Line72
573, 35, 502
574, 502, 503
575, 503, 504
576, 504, 505
577, 505, 506
578, 506, 507
579, 507, 508
580, 508, 509
581, 509, 510
582, 510, 511
583, 511, 512
584, 512, 39
*ELEMENT, type=T3D2, ELSET=Line73
585, 36, 513
586, 513, 514
587, 514, 515
588, 515, 516
589, 516, 517
590, 517, 518
591, 518, 519
592, 519, 520
593, 520, 521
594, 521, 522
595, 522, 523
596, 523, 40
*ELEMENT, type=T3D2, ELSET=Line74
597, 39, 524
598, 524, 525
599, 525, 526
600, 526, 527
601, 527, 528
602, 528, 529
603, 529, 530
604, 530, 531
605, 531, 532
606, 532, 533
607, 533, 534
608, 534, 40
*ELEMENT, type=T3D2, ELSET=Line75
609, 39, 535
610, 535, 536
611, 536, 537
612, 537, 538
613, 538, 539
614, 539, 37
*ELEMENT, type=T3D2, ELSET=Line76
615, 40, 540
616, 540, 541
617, 541, 542
618, 542, 543
619, 543, 544
620, 544, 38
*ELEMENT, type=T3D2, ELSET=Line77
621, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
622, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
623, 41, 545
624, 545, 546
625, 546, 547
626, 547, 548
627, 548, 549
628, 549, 550
629, 550, 551
630, 551, 552
631, 552, 553
632, 553, 554
633, 554, 555
634, 555, 42
*ELEMENT, type=T3D2, ELSET=Line80
635, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
636, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
637, 43, 556
638, 556, 557
639, 557, 558
640, 558, 559
641, 559, 560
642, 560, 561
643, 561, 562
644, 562, 563
645, 563, 564
646, 564, 565
647, 565, 566
648, 566, 44
*ELEMENT, type=T3D2, ELSET=Line83
649, 43, 567
650, 567, 568
651, 568, 569
652, 569, 570
653, 570, 571
654, 571, 41
*ELEMENT, type=T3D2, ELSET=Line84
655, 44, 572
656, 572, 573
657, 573, 574
658, 574, 575
659, 575, 576
660, 576, 42
*ELEMENT, type=T3D2, ELSET=Line85
661, 41, 577
662, 577, 578
663, 578, 45
*ELEMENT, type=T3D2, ELSET=Line86
664, 42, 579
665, 579, 580
666, 580, 46
*ELEMENT, type=T3D2, ELSET=Line87
667, 45, 581
668, 581, 582
669, 582, 583
670, 583, 584
671, 584, 585
672, 585, 586
673, 586, 587
674, 587, 588
675, 588, 589
676, 589, 590
677, 590, 591
678, 591, 46
*ELEMENT, type=T3D2, ELSET=Line88
679, 43, 592
680, 592, 593
681, 593, 47
*ELEMENT, type=T3D2, ELSET=Line89
682, 44, 594
683, 594, 595
684, 595, 48
*ELEMENT, type=T3D2, ELSET=Line90
685, 47, 596
686, 596, 597
687, 597, 598
688, 598, 599
689, 599, 600
690, 600, 601
691, 601, 602
692, 602, 603
693, 603, 604
694, 604, 605
695, 605, 606
696, 606, 48
*ELEMENT, type=T3D2, ELSET=Line91
697, 47, 607
698, 607, 608
699, 608, 609
700, 609, 610
701, 610, 611
702, 611, 45
*ELEMENT, type=T3D2, ELSET=Line92
703, 48, 612
704, 612, 613
705, 613, 614
706, 614, 615
707, 615, 616
708, 616, 46
*ELEMENT, type=T3D2, ELSET=Line93
709, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
710, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
711, 49, 617
712, 617, 618
713, 618, 50
*ELEMENT, type=T3D2, ELSET=Line96
714, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
715, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
716, 51, 619
717, 619, 620
718, 620, 52
*ELEMENT, type=T3D2, ELSET=Line99
719, 51, 621
720, 621, 622
721, 622, 623
722, 623, 624
723, 624, 625
724, 625, 49
*ELEMENT, type=T3D2, ELSET=Line100
725, 52, 626
726, 626, 627
727, 627, 628
728, 628, 629
729, 629, 630
730, 630, 50
*ELEMENT, type=T3D2, ELSET=Line101
731, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
732, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
733, 54, 631
734, 631, 632
735, 632, 633
736, 633, 634
737, 634, 635
738, 635, 53
*ELEMENT, type=T3D2, ELSET=Line104
739, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
740, 53, 636
741, 636, 637
742, 637, 55
*ELEMENT, type=T3D2, ELSET=Line106
743, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
744, 56, 638
745, 638, 639
746, 639, 640
747, 640, 641
748, 641, 642
749, 642, 55
*ELEMENT, type=T3D2, ELSET=Line108
750, 54, 643
751, 643, 644
752, 644, 56
*ELEMENT, type=T3D2, ELSET=Line125
753, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
754, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
755, 57, 645
756, 645, 646
757, 646, 647
758, 647, 648
759, 648, 649
760, 649, 650
761, 650, 651
762, 651, 652
763, 652, 653
764, 653, 654
765, 654, 655
766, 655, 58
*ELEMENT, type=T3D2, ELSET=Line128
767, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
768, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
769, 59, 656
770, 656, 657
771, 657, 658
772, 658, 659
773, 659, 660
774, 660, 661
775, 661, 662
776, 662, 663
777, 663, 664
778, 664, 665
779, 665, 666
780, 666, 60
*ELEMENT, type=T3D2, ELSET=Line131
781, 59, 667
782, 667, 668
783, 668, 669
784, 669, 670
785, 670, 671
786, 671, 57
*ELEMENT, type=T3D2, ELSET=Line132
787, 60, 672
788, 672, 673
789, 673, 674
790, 674, 675
791, 675, 676
792, 676, 58
*ELEMENT, type=T3D2, ELSET=Line133
793, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
794, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
795, 61, 677
796, 677, 678
797, 678, 679
798, 679, 680
799, 680, 681
800, 681, 682
801, 682, 683
802, 683, 684
803, 684, 685
804, 685, 686
805, 686, 687
806, 687, 62
*ELEMENT, type=T3D2, ELSET=Line136
807, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
808, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
809, 63, 688
810, 688, 689
811, 689, 690
812, 690, 691
813, 691, 692
814, 692, 693
815, 693, 694
816, 694, 695
817, 695, 696
818, 696, 697
819, 697, 698
820, 698, 64
*ELEMENT, type=T3D2, ELSET=Line139
821, 63, 699
822, 699, 700
823, 700, 701
824, 701, 702
825, 702, 703
826, 703, 61
*ELEMENT, type=T3D2, ELSET=Line140
827, 64, 704
828, 704, 705
829, 705, 706
830, 706, 707
831, 707, 708
832, 708, 62
*ELEMENT, type=T3D2, ELSET=Line141
833, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
834, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
835, 65, 709
836, 709, 710
837, 710, 711
838, 711, 712
839, 712, 713
840, 713, 714
841, 714, 715
842, 715, 716
843, 716, 717
844, 717, 718
845, 718, 719
846, 719, 66
*ELEMENT, type=T3D2, ELSET=Line144
847, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
848, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
849, 67, 720
850, 720, 721
851, 721, 722
852, 722, 723
853, 723, 724
854, 724, 725
855, 725, 726
856, 726, 727
857, 727, 728
858, 728, 729
859, 729, 730
860, 730, 68
*ELEMENT, type=T3D2, ELSET=Line147
861, 67, 731
862, 731, 732
863, 732, 733
864, 733, 734
865, 734, 735
866, 735, 736
867, 736, 737
868, 737, 738
869, 738, 739
870, 739, 740
871, 740, 741
872, 741, 65
*ELEMENT, type=T3D2, ELSET=Line148
873, 68, 742
874, 742, 743
875, 743, 744
876, 744, 745
877, 745, 746
878, 746, 747
879, 747, 748
880, 748, 749
881, 749, 750
882, 750, 751
883, 751, 752
884, 752, 66
*ELEMENT, type=T3D2, ELSET=Line149
885, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
886, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
887, 69, 753
888, 753, 754
889, 754, 755
890, 755, 756
891, 756, 757
892, 757, 758
893, 758, 759
894, 759, 760
895, 760, 761
896, 761, 762
897, 762, 763
898, 763, 70
*ELEMENT, type=T3D2, ELSET=Line152
899, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
900, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
901, 71, 764
902, 764, 765
903, 765, 766
904, 766, 767
905, 767, 768
906, 768, 769
907, 769, 770
908, 770, 771
909, 771, 772
910, 772, 773
911, 773, 774
912, 774, 72
*ELEMENT, type=T3D2, ELSET=Line155
913, 69, 775
914, 775, 776
915, 776, 777
916, 777, 778
917, 778, 779
918, 779, 780
919, 780, 781
920, 781, 782
921, 782, 783
922, 783, 784
923, 784, 785
924, 785, 71
*ELEMENT, type=T3D2, ELSET=Line156
925, 70, 786
926, 786, 787
927, 787, 788
928, 788, 789
929, 789, 790
930, 790, 791
931, 791, 792
932, 792, 793
933, 793, 794
934, 794, 795
935, 795, 796
936, 796, 72
*ELEMENT, type=T3D2, ELSET=Line157
937, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
938, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
939, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
940, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
941, 73, 797
942, 797, 798
943, 798, 799
944, 799, 800
945, 800, 801
946, 801, 802
947, 802, 803
948, 803, 804
949, 804, 805
950, 805, 806
951, 806, 807
952, 807, 74
*ELEMENT, type=T3D2, ELSET=Line162
953, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
954, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
955, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
956, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
957, 75, 808
958, 808, 809
959, 809, 810
960, 810, 811
961, 811, 812
962, 812, 813
963, 813, 814
964, 814, 815
965, 815, 816
966, 816, 817
967, 817, 818
968, 818, 76
*ELEMENT, type=T3D2, ELSET=Line167
969, 21, 819
970, 819, 820
971, 820, 821
972, 821, 822
973, 822, 77
*ELEMENT, type=T3D2, ELSET=Line168
974, 22, 823
975, 823, 824
976, 824, 825
977, 825, 826
978, 826, 78
*ELEMENT, type=T3D2, ELSET=Line169
979, 78, 827
980, 827, 828
981, 828, 829
982, 829, 830
983, 830, 831
984, 831, 832
985, 832, 833
986, 833, 834
987, 834, 835
988, 835, 836
989, 836, 837
990, 837, 77
*ELEMENT, type=T3D2, ELSET=Line170
991, 23, 838
992, 838, 839
993, 839, 840
994, 840, 841
995, 841, 79
*ELEMENT, type=T3D2, ELSET=Line171
996, 77, 842
997, 842, 843
998, 843, 844
999, 844, 845
1000, 845, 846
1001, 846, 79
*ELEMENT, type=T3D2, ELSET=Line172
1002, 24, 847
1003, 847, 848
1004, 848, 849
1005, 849, 850
1006, 850, 80
*ELEMENT, type=T3D2, ELSET=Line173
1007, 80, 851
1008, 851, 852
1009, 852, 853
1010, 853, 854
1011, 854, 855
1012, 855, 856
1013, 856, 857
1014, 857, 858
1015, 858, 859
1016, 859, 860
1017, 860, 861
1018, 861, 79
*ELEMENT, type=T3D2, ELSET=Line174
1019, 78, 862
1020, 862, 863
1021, 863, 864
1022, 864, 865
1023, 865, 866
1024, 866, 80
*ELEMENT, type=T3D2, ELSET=Line175
1025, 26, 867
1026, 867, 868
1027, 868, 869
1028, 869, 870
1029, 870, 81
*ELEMENT, type=T3D2, ELSET=Line176
1030, 79, 871
1031, 871, 872
1032, 872, 873
1033, 873, 874
1034, 874, 81
*ELEMENT, type=T3D2, ELSET=Line177
1035, 28, 875
1036, 875, 876
1037, 876, 877
1038, 877, 878
1039, 878, 82
*ELEMENT, type=T3D2, ELSET=Line178
1040, 77, 879
1041, 879, 880
1042, 880, 881
1043, 881, 882
1044, 882, 82
*ELEMENT, type=T3D2, ELSET=Line179
1045, 82, 883
1046, 883, 884
1047, 884, 885
1048, 885, 886
1049, 886, 887
1050, 887, 81
*ELEMENT, type=T3D2, ELSET=Line180
1051, 30, 888
1052, 888, 889
1053, 889, 890
1054, 890, 891
1055, 891, 83
*ELEMENT, type=T3D2, ELSET=Line181
1056, 81, 892
1057, 892, 893
1058, 893, 894
1059, 894, 895
1060, 895, 896
1061, 896, 897
1062, 897, 898
1063, 898, 899
1064, 899, 900
1065, 900, 901
1066, 901, 902
1067, 902, 83
*ELEMENT, type=T3D2, ELSET=Line182
1068, 32, 903
1069, 903, 904
1070, 904, 905
1071, 905, 906
1072, 906, 84
*ELEMENT, type=T3D2, ELSET=Line183
1073, 82, 907
1074, 907, 908
1075, 908, 909
1076, 909, 910
1077, 910, 911
1078, 911, 912
1079, 912, 913
1080, 913, 914
1081, 914, 915
1082, 915, 916
1083, 916, 917
1084, 917, 84
*ELEMENT, type=T3D2, ELSET=Line184
1085, 84, 918
1086, 918, 919
1087, 919, 920
1088, 920, 921
1089, 921, 922
1090, 922, 83
*ELEMENT, type=T3D2, ELSET=Line185
1091, 6, 923
1092, 923, 924
1093, 924, 925
1094, 925, 926
1095, 926, 85
*ELEMENT, type=T3D2, ELSET=Line186
1096, 2, 927
1097, 927, 928
1098, 928, 929
1099, 929, 930
1100, 930, 86
*ELEMENT, type=T3D2, ELSET=Line187
1101, 86, 931
1102, 931, 932
1103, 932, 933
1104, 933, 934
1105, 934, 935
1106, 935, 936
1107, 936, 937
1108, 937, 938
1109, 938, 939
1110, 939, 940
1111, 940, 941
1112, 941, 85
*ELEMENT, type=T3D2, ELSET=Line188
1113, 5, 942
1114, 942, 943
1115, 943, 944
1116, 944, 945
1117, 945, 87
*ELEMENT, type=T3D2, ELSET=Line189
1118, 85, 946
1119, 946, 947
1120, 947, 948
1121, 948, 949
1122, 949, 950
1123, 950, 87
*ELEMENT, type=T3D2, ELSET=Line190
1124, 1, 951
1125, 951, 952
1126, 952, 953
1127, 953, 954
1128, 954, 88
*ELEMENT, type=T3D2, ELSET=Line191
1129, 88, 955
1130, 955, 956
1131, 956, 957
1132, 957, 958
1133, 958, 959
1134, 959, 960
1135, 960, 961
1136, 961, 962
1137, 962, 963
1138, 963, 964
1139, 964, 965
1140, 965, 87
*ELEMENT, type=T3D2, ELSET=Line192
1141, 86, 966
1142, 966, 967
1143, 967, 968
1144, 968, 969
1145, 969, 970
1146, 970, 88
*ELEMENT, type=T3D2, ELSET=Line193
1147, 53, 971
1148, 971, 972
1149, 972, 973
1150, 973, 974
1151, 974, 89
*ELEMENT, type=T3D2, ELSET=Line194
1152, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
1153, 54, 975
1154, 975, 976
1155, 976, 977
1156, 977, 978
1157, 978, 90
*ELEMENT, type=T3D2, ELSET=Line196
1158, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
1159, 90, 979
1160, 979, 980
1161, 980, 981
1162, 981, 982
1163, 982, 983
1164, 983, 89
*ELEMENT, type=T3D2, ELSET=Line198
1165, 45, 984
1166, 984, 985
1167, 985, 986
1168, 986, 987
1169, 987, 91
*ELEMENT, type=T3D2, ELSET=Line199
1170, 46, 988
1171, 988, 989
1172, 989, 990
1173, 990, 991
1174, 991, 92
*ELEMENT, type=T3D2, ELSET=Line200
1175, 91, 992
1176, 992, 993
1177, 993, 994
1178, 994, 995
1179, 995, 996
1180, 996, 997
1181, 997, 998
1182, 998, 999
1183, 999, 1000
1184, 1000, 1001
1185, 1001, 1002
1186, 1002, 92
*ELEMENT, type=T3D2, ELSET=Line201
1187, 47, 1003
1188, 1003, 1004
1189, 1004, 1005
1190, 1005, 1006
1191, 1006, 93
*ELEMENT, type=T3D2, ELSET=Line202
1192, 48, 1007
1193, 1007, 1008
1194, 1008, 1009
1195, 1009, 1010
1196, 1010, 94
*ELEMENT, type=T3D2, ELSET=Line203
1197, 93, 1011
1198, 1011, 1012
1199, 1012, 1013
1200, 1013, 1014
1201, 1014, 1015
1202, 1015, 1016
1203, 1016, 1017
1204, 1017, 1018
1205, 1018, 1019
1206, 1019, 1020
1207, 1020, 1021
1208, 1021, 94
*ELEMENT, type=T3D2, ELSET=Line204
1209, 93, 1022
1210, 1022, 1023
1211, 1023, 1024
1212, 1024, 1025
1213, 1025, 1026
1214, 1026, 91
*ELEMENT, type=T3D2, ELSET=Line205
1215, 94, 1027
1216, 1027, 1028
1217, 1028, 1029
1218, 1029, 1030
1219, 1030, 1031
1220, 1031, 92
*ELEMENT, type=T3D2, ELSET=Line206
1221, 50, 1032
1222, 1032, 1033
1223, 1033, 1034
1224, 1034, 1035
1225, 1035, 95
*ELEMENT, type=T3D2, ELSET=Line207
1226, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
1227, 52, 1036
1228, 1036, 1037
1229, 1037, 1038
1230, 1038, 1039
1231, 1039, 96
*ELEMENT, type=T3D2, ELSET=Line209
1232, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
1233, 96, 1040
1234, 1040, 1041
1235, 1041, 1042
1236, 1042, 1043
1237, 1043, 1044
1238, 1044, 95
*ELEMENT, type=CPS4, ELSET=Surface1
1239, 2, 97, 1045, 109
1240, 109, 1045, 1046, 110
1241, 110, 1046, 104, 4
1242, 97, 98, 1047, 1045
1243, 1045, 1047, 1048, 1046
1244, 1046, 1048, 105, 104
1245, 98, 99, 1049, 1047
1246, 1047, 1049, 1050, 1048
1247, 1048, 1050, 106, 105
1248, 99, 100, 1051, 1049
1249, 1049, 1051, 1052, 1050
1250, 1050, 1052, 107, 106
1251, 100, 101, 1053, 1051
1252, 1051, 1053, 1054, 1052
1253, 1052, 1054, 108, 107
1254, 101, 1, 102, 1053
1255, 1053, 102, 103, 1054
1256, 1054, 103, 3, 108
*ELEMENT, type=CPS4, ELSET=Surface2
1257, 6, 123, 1055, 111
1258, 123, 124, 1056, 1055
1259, 124, 8, 118, 1056
1260, 111, 1055, 1057, 112
1261, 1055, 1056, 1058, 1057
1262, 1056, 118, 119, 1058
1263, 112, 1057, 1059, 113
1264, 1057, 1058, 1060, 1059
1265, 1058, 119, 120, 1060
1266, 113, 1059, 1061, 114
1267, 1059, 1060, 1062, 1061
1268, 1060, 120, 121, 1062
1269, 114, 1061, 1063, 115
1270, 1061, 1062, 1064, 1063
1271, 1062, 121, 122, 1064
1272, 115, 1063, 116, 5
1273, 1063, 1064, 117, 116
1274, 1064, 122, 7, 117
*ELEMENT, type=CPS4, ELSET=Surface3
1275, 2, 125, 1065, 97
1276, 97, 1065, 1066, 98
1277, 98, 1066, 1067, 99
1278, 99, 1067, 1068, 100
1279, 100, 1068, 1069, 101
1280, 101, 1069, 136, 1
1281, 125, 126, 1070, 1065
1282, 1065, 1070, 1071, 1066
1283, 1066, 1071, 1072, 1067
1284, 1067, 1072, 1073, 1068
1285, 1068, 1073, 1074, 1069
1286, 1069, 1074, 137, 136
1287, 126, 127, 1075, 1070
1288, 1070, 1075, 1076, 1071
1289, 1071, 1076, 1077, 1072
1290, 1072, 1077, 1078, 1073
1291, 1073, 1078, 1079, 1074
1292, 1074, 1079, 138, 137
1293, 127, 128, 1080, 1075
1294, 1075, 1080, 1081, 1076
1295, 1076, 1081, 1082, 1077
1296, 1077, 1082, 1083, 1078
1297, 1078, 1083, 1084, 1079
1298, 1079, 1084, 139, 138
1299, 128, 129, 1085, 1080
1300, 1080, 1085, 1086, 1081
1301, 1081, 1086, 1087, 1082
1302, 1082, 1087, 1088, 1083
1303, 1083, 1088, 1089, 1084
1304, 1084, 1089, 140, 139
1305, 129, 130, 1090, 1085
1306, 1085, 1090, 1091, 1086
1307, 1086, 1091, 1092, 1087
1308, 1087, 1092, 1093, 1088
1309, 1088, 1093, 1094, 1089
1310, 1089, 1094, 141, 140
1311, 130, 131, 1095, 1090
1312, 1090, 1095, 1096, 1091
1313, 1091, 1096, 1097, 1092
1314, 1092, 1097, 1098, 1093
1315, 1093, 1098, 1099, 1094
1316, 1094, 1099, 142, 141
1317, 131, 132, 1100, 1095
1318, 1095, 1100, 1101, 1096
1319, 1096, 1101, 1102, 1097
1320, 1097, 1102, 1103, 1098
1321, 1098, 1103, 1104, 1099
1322, 1099, 1104, 143, 142
1323, 132, 133, 1105, 1100
1324, 1100, 1105, 1106, 1101
1325, 1101, 1106, 1107, 1102
1326, 1102, 1107, 1108, 1103
1327, 1103, 1108, 1109, 1104
1328, 1104, 1109, 144, 143
1329, 133, 134, 1110, 1105
1330, 1105, 1110, 1111, 1106
1331, 1106, 1111, 1112, 1107
1332, 1107, 1112, 1113, 1108
1333, 1108, 1113, 1114, 1109
1334, 1109, 1114, 145, 144
1335, 134, 135, 1115, 1110
1336, 1110, 1115, 1116, 1111
1337, 1111, 1116, 1117, 1112
1338, 1112, 1117, 1118, 1113
1339, 1113, 1118, 1119, 1114
1340, 1114, 1119, 146, 145
1341, 135, 6, 111, 1115
1342, 1115, 111, 112, 1116
1343, 1116, 112, 113, 1117
1344, 1117, 113, 114, 1118
1345, 1118, 114, 115, 1119
1346, 1119, 115, 5, 146
*ELEMENT, type=CPS4, ELSET=Surface4
1347, 4, 104, 1120, 147
1348, 104, 105, 1121, 1120
1349, 105, 106, 1122, 1121
1350, 106, 107, 1123, 1122
1351, 107, 108, 1124, 1123
1352, 108, 3, 158, 1124
1353, 147, 1120, 1125, 148
1354, 1120, 1121, 1126, 1125
1355, 1121, 1122, 1127, 1126
1356, 1122, 1123, 1128, 1127
1357, 1123, 1124, 1129, 1128
1358, 1124, 158, 159, 1129
1359, 148, 1125, 1130, 149
1360, 1125, 1126, 1131, 1130
1361, 1126, 1127, 1132, 1131
1362, 1127, 1128, 1133, 1132
1363, 1128, 1129, 1134, 1133
1364, 1129, 159, 160, 1134
1365, 149, 1130, 1135, 150
1366, 1130, 1131, 1136, 1135
1367, 1131, 1132, 1137, 1136
1368, 1132, 1133, 1138, 1137
1369, 1133, 1134, 1139, 1138
1370, 1134, 160, 161, 1139
1371, 150, 1135, 1140, 151
1372, 1135, 1136, 1141, 1140
1373, 1136, 1137, 1142, 1141
1374, 1137, 1138, 1143, 1142
1375, 1138, 1139, 1144, 1143
1376, 1139, 161, 162, 1144
1377, 151, 1140, 1145, 152
1378, 1140, 1141, 1146, 1145
1379, 1141, 1142, 1147, 1146
1380, 1142, 1143, 1148, 1147
1381, 1143, 1144, 1149, 1148
1382, 1144, 162, 163, 1149
1383, 152, 1145, 1150, 153
1384, 1145, 1146, 1151, 1150
1385, 1146, 1147, 1152, 1151
1386, 1147, 1148, 1153, 1152
1387, 1148, 1149, 1154, 1153
1388, 1149, 163, 164, 1154
1389, 153, 1150, 1155, 154
1390, 1150, 1151, 1156, 1155
1391, 1151, 1152, 1157, 1156
1392, 1152, 1153, 1158, 1157
1393, 1153, 1154, 1159, 1158
1394, 1154, 164, 165, 1159
1395, 154, 1155, 1160, 155
1396, 1155, 1156, 1161, 1160
1397, 1156, 1157, 1162, 1161
1398, 1157, 1158, 1163, 1162
1399, 1158, 1159, 1164, 1163
1400, 1159, 165, 166, 1164
1401, 155, 1160, 1165, 156
1402, 1160, 1161, 1166, 1165
1403, 1161, 1162, 1167, 1166
1404, 1162, 1163, 1168, 1167
1405, 1163, 1164, 1169, 1168
1406, 1164, 166, 167, 1169
1407, 156, 1165, 1170, 157
1408, 1165, 1166, 1171, 1170
1409, 1166, 1167, 1172, 1171
1410, 1167, 1168, 1173, 1172
1411, 1168, 1169, 1174, 1173
1412, 1169, 167, 168, 1174
1413, 157, 1170, 118, 8
1414, 1170, 1171, 119, 118
1415, 1171, 1172, 120, 119
1416, 1172, 1173, 121, 120
1417, 1173, 1174, 122, 121
1418, 1174, 168, 7, 122
*ELEMENT, type=CPS4, ELSET=Surface5
1419, 2, 109, 1175, 125
1420, 125, 1175, 1176, 126
1421, 126, 1176, 1177, 127
1422, 127, 1177, 1178, 128
1423, 128, 1178, 1179, 129
1424, 129, 1179, 1180, 130
1425, 130, 1180, 1181, 131
1426, 131, 1181, 1182, 132
1427, 132, 1182, 1183, 133
1428, 133, 1183, 1184, 134
1429, 134, 1184, 1185, 135
1430, 135, 1185, 123, 6
1431, 109, 110, 1186, 1175
1432, 1175, 1186, 1187, 1176
1433, 1176, 1187, 1188, 1177
1434, 1177, 1188, 1189, 1178
1435, 1178, 1189, 1190, 1179
1436, 1179, 1190, 1191, 1180
1437, 1180, 1191, 1192, 1181
1438, 1181, 1192, 1193, 1182
1439, 1182, 1193, 1194, 1183
1440, 1183, 1194, 1195, 1184
1441, 1184, 1195, 1196, 1185
1442, 1185, 1196, 124, 123
1443, 110, 4, 147, 1186
1444, 1186, 147, 148, 1187
1445, 1187, 148, 149, 1188
1446, 1188, 149, 150, 1189
1447, 1189, 150, 151, 1190
1448, 1190, 151, 152, 1191
1449, 1191, 152, 153, 1192
1450, 1192, 153, 154, 1193
1451, 1193, 154, 155, 1194
1452, 1194, 155, 156, 1195
1453, 1195, 156, 157, 1196
1454, 1196, 157, 8, 124
*ELEMENT, type=CPS4, ELSET=Surface6
1455, 1, 136, 1197, 102
1456, 136, 137, 1198, 1197
1457, 137, 138, 1199, 1198
1458, 138, 139, 1200, 1199
1459, 139, 140, 1201, 1200
1460, 140, 141, 1202, 1201
1461, 141, 142, 1203, 1202
1462, 142, 143, 1204, 1203
1463, 143, 144, 1205, 1204
1464, 144, 145, 1206, 1205
1465, 145, 146, 1207, 1206
1466, 146, 5, 116, 1207
1467, 102, 1197, 1208, 103
1468, 1197, 1198, 1209, 1208
1469, 1198, 1199, 1210, 1209
1470, 1199, 1200, 1211, 1210
1471, 1200, 1201, 1212, 1211
1472, 1201, 1202, 1213, 1212
1473, 1202, 1203, 1214, 1213
1474, 1203, 1204, 1215, 1214
1475, 1204, 1205, 1216, 1215
1476, 1205, 1206, 1217, 1216
1477, 1206, 1207, 1218, 1217
1478, 1207, 116, 117, 1218
1479, 103, 1208, 158, 3
1480, 1208, 1209, 159, 158
1481, 1209, 1210, 160, 159
1482, 1210, 1211, 161, 160
1483, 1211, 1212, 162, 161
1484, 1212, 1213, 163, 162
1485, 1213, 1214, 164, 163
1486, 1214, 1215, 165, 164
1487, 1215, 1216, 166, 165
1488, 1216, 1217, 167, 166
1489, 1217, 1218, 168, 167
1490, 1218, 117, 7, 168
*ELEMENT, type=CPS4, ELSET=Surface7
1491, 4, 10, 169, 147
1492, 147, 169, 170, 148
1493, 148, 170, 171, 149
1494, 149, 171, 172, 150
1495, 150, 172, 173, 151
1496, 151, 173, 174, 152
1497, 152, 174, 175, 153
1498, 153, 175, 176, 154
1499, 154, 176, 177, 155
1500, 155, 177, 178, 156
1501, 156, 178, 179, 157
1502, 157, 179, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
1503, 8, 9, 180, 118
1504, 118, 180, 181, 119
1505, 119, 181, 182, 120
1506, 120, 182, 183, 121
1507, 121, 183, 184, 122
1508, 122, 184, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
1509, 3, 158, 185, 12
1510, 158, 159, 186, 185
1511, 159, 160, 187, 186
1512, 160, 161, 188, 187
1513, 161, 162, 189, 188
1514, 162, 163, 190, 189
1515, 163, 164, 191, 190
1516, 164, 165, 192, 191
1517, 165, 166, 193, 192
1518, 166, 167, 194, 193
1519, 167, 168, 195, 194
1520, 168, 7, 11, 195
*ELEMENT, type=CPS4, ELSET=Surface10
1521, 4, 104, 196, 10
1522, 104, 105, 197, 196
1523, 105, 106, 198, 197
1524, 106, 107, 199, 198
1525, 107, 108, 200, 199
1526, 108, 3, 12, 200
*ELEMENT, type=CPS4, ELSET=Surface11
1527, 10, 196, 1219, 169
1528, 196, 197, 1220, 1219
1529, 197, 198, 1221, 1220
1530, 198, 199, 1222, 1221
1531, 199, 200, 1223, 1222
1532, 200, 12, 185, 1223
1533, 169, 1219, 1224, 170
1534, 1219, 1220, 1225, 1224
1535, 1220, 1221, 1226, 1225
1536, 1221, 1222, 1227, 1226
1537, 1222, 1223, 1228, 1227
1538, 1223, 185, 186, 1228
1539, 170, 1224, 1229, 171
1540, 1224, 1225, 1230, 1229
1541, 1225, 1226, 1231, 1230
1542, 1226, 1227, 1232, 1231
1543, 1227, 1228, 1233, 1232
1544, 1228, 186, 187, 1233
1545, 171, 1229, 1234, 172
1546, 1229, 1230, 1235, 1234
1547, 1230, 1231, 1236, 1235
1548, 1231, 1232, 1237, 1236
1549, 1232, 1233, 1238, 1237
1550, 1233, 187, 188, 1238
1551, 172, 1234, 1239, 173
1552, 1234, 1235, 1240, 1239
1553, 1235, 1236, 1241, 1240
1554, 1236, 1237, 1242, 1241
1555, 1237, 1238, 1243, 1242
1556, 1238, 188, 189, 1243
1557, 173, 1239, 1244, 174
1558, 1239, 1240, 1245, 1244
1559, 1240, 1241, 1246, 1245
1560, 1241, 1242, 1247, 1246
1561, 1242, 1243, 1248, 1247
1562, 1243, 189, 190, 1248
1563, 174, 1244, 1249, 175
1564, 1244, 1245, 1250, 1249
1565, 1245, 1246, 1251, 1250
1566, 1246, 1247, 1252, 1251
1567, 1247, 1248, 1253, 1252
1568, 1248, 190, 191, 1253
1569, 175, 1249, 1254, 176
1570, 1249, 1250, 1255, 1254
1571, 1250, 1251, 1256, 1255
1572, 1251, 1252, 1257, 1256
1573, 1252, 1253, 1258, 1257
1574, 1253, 191, 192, 1258
1575, 176, 1254, 1259, 177
1576, 1254, 1255, 1260, 1259
1577, 1255, 1256, 1261, 1260
1578, 1256, 1257, 1262, 1261
1579, 1257, 1258, 1263, 1262
1580, 1258, 192, 193, 1263
1581, 177, 1259, 1264, 178
1582, 1259, 1260, 1265, 1264
1583, 1260, 1261, 1266, 1265
1584, 1261, 1262, 1267, 1266
1585, 1262, 1263, 1268, 1267
1586, 1263, 193, 194, 1268
1587, 178, 1264, 1269, 179
1588, 1264, 1265, 1270, 1269
1589, 1265, 1266, 1271, 1270
1590, 1266, 1267, 1272, 1271
1591, 1267, 1268, 1273, 1272
1592, 1268, 194, 195, 1273
1593, 179, 1269, 180, 9
1594, 1269, 1270, 181, 180
1595, 1270, 1271, 182, 181
1596, 1271, 1272, 183, 182
1597, 1272, 1273, 184, 183
1598, 1273, 195, 11, 184
*ELEMENT, type=CPS4, ELSET=Surface12
1599, 10, 212, 1274, 169
1600, 212, 213, 1275, 1274
1601, 213, 214, 1276, 1275
1602, 214, 215, 1277, 1276
1603, 215, 216, 1278, 1277
1604, 216, 217, 1279, 1278
1605, 217, 218, 1280, 1279
1606, 218, 219, 1281, 1280
1607, 219, 220, 1282, 1281
1608, 220, 221, 1283, 1282
1609, 221, 222, 1284, 1283
1610, 222, 14, 223, 1284
1611, 169, 1274, 1285, 170
1612, 1274, 1275, 1286, 1285
1613, 1275, 1276, 1287, 1286
1614, 1276, 1277, 1288, 1287
1615, 1277, 1278, 1289, 1288
1616, 1278, 1279, 1290, 1289
1617, 1279, 1280, 1291, 1290
1618, 1280, 1281, 1292, 1291
1619, 1281, 1282, 1293, 1292
1620, 1282, 1283, 1294, 1293
1621, 1283, 1284, 1295, 1294
1622, 1284, 223, 224, 1295
1623, 170, 1285, 1296, 171
1624, 1285, 1286, 1297, 1296
1625, 1286, 1287, 1298, 1297
1626, 1287, 1288, 1299, 1298
1627, 1288, 1289, 1300, 1299
1628, 1289, 1290, 1301, 1300
1629, 1290, 1291, 1302, 1301
1630, 1291, 1292, 1303, 1302
1631, 1292, 1293, 1304, 1303
1632, 1293, 1294, 1305, 1304
1633, 1294, 1295, 1306, 1305
1634, 1295, 224, 225, 1306
1635, 171, 1296, 1307, 172
1636, 1296, 1297, 1308, 1307
1637, 1297, 1298, 1309, 1308
1638, 1298, 1299, 1310, 1309
1639, 1299, 1300, 1311, 1310
1640, 1300, 1301, 1312, 1311
1641, 1301, 1302, 1313, 1312
1642, 1302, 1303, 1314, 1313
1643, 1303, 1304, 1315, 1314
1644, 1304, 1305, 1316, 1315
1645, 1305, 1306, 1317, 1316
1646, 1306, 225, 226, 1317
1647, 172, 1307, 1318, 173
1648, 1307, 1308, 1319, 1318
1649, 1308, 1309, 1320, 1319
1650, 1309, 1310, 1321, 1320
1651, 1310, 1311, 1322, 1321
1652, 1311, 1312, 1323, 1322
1653, 1312, 1313, 1324, 1323
1654, 1313, 1314, 1325, 1324
1655, 1314, 1315, 1326, 1325
1656, 1315, 1316, 1327, 1326
1657, 1316, 1317, 1328, 1327
1658, 1317, 226, 227, 1328
1659, 173, 1318, 1329, 174
1660, 1318, 1319, 1330, 1329
1661, 1319, 1320, 1331, 1330
1662, 1320, 1321, 1332, 1331
1663, 1321, 1322, 1333, 1332
1664, 1322, 1323, 1334, 1333
1665, 1323, 1324, 1335, 1334
1666, 1324, 1325, 1336, 1335
1667, 1325, 1326, 1337, 1336
1668, 1326, 1327, 1338, 1337
1669, 1327, 1328, 1339, 1338
1670, 1328, 227, 228, 1339
1671, 174, 1329, 1340, 175
1672, 1329, 1330, 1341, 1340
1673, 1330, 1331, 1342, 1341
1674, 1331, 1332, 1343, 1342
1675, 1332, 1333, 1344, 1343
1676, 1333, 1334, 1345, 1344
1677, 1334, 1335, 1346, 1345
1678, 1335, 1336, 1347, 1346
1679, 1336, 1337, 1348, 1347
1680, 1337, 1338, 1349, 1348
1681, 1338, 1339, 1350, 1349
1682, 1339, 228, 229, 1350
1683, 175, 1340, 1351, 176
1684, 1340, 1341, 1352, 1351
1685, 1341, 1342, 1353, 1352
1686, 1342, 1343, 1354, 1353
1687, 1343, 1344, 1355, 1354
1688, 1344, 1345, 1356, 1355
1689, 1345, 1346, 1357, 1356
1690, 1346, 1347, 1358, 1357
1691, 1347, 1348, 1359, 1358
1692, 1348, 1349, 1360, 1359
1693, 1349, 1350, 1361, 1360
1694, 1350, 229, 230, 1361
1695, 176, 1351, 1362, 177
1696, 1351, 1352, 1363, 1362
1697, 1352, 1353, 1364, 1363
1698, 1353, 1354, 1365, 1364
1699, 1354, 1355, 1366, 1365
1700, 1355, 1356, 1367, 1366
1701, 1356, 1357, 1368, 1367
1702, 1357, 1358, 1369, 1368
1703, 1358, 1359, 1370, 1369
1704, 1359, 1360, 1371, 1370
1705, 1360, 1361, 1372, 1371
1706, 1361, 230, 231, 1372
1707, 177, 1362, 1373, 178
1708, 1362, 1363, 1374, 1373
1709, 1363, 1364, 1375, 1374
1710, 1364, 1365, 1376, 1375
1711, 1365, 1366, 1377, 1376
1712, 1366, 1367, 1378, 1377
1713, 1367, 1368, 1379, 1378
1714, 1368, 1369, 1380, 1379
1715, 1369, 1370, 1381, 1380
1716, 1370, 1371, 1382, 1381
1717, 1371, 1372, 1383, 1382
1718, 1372, 231, 232, 1383
1719, 178, 1373, 1384, 179
1720, 1373, 1374, 1385, 1384
1721, 1374, 1375, 1386, 1385
1722, 1375, 1376, 1387, 1386
1723, 1376, 1377, 1388, 1387
1724, 1377, 1378, 1389, 1388
1725, 1378, 1379, 1390, 1389
1726, 1379, 1380, 1391, 1390
1727, 1380, 1381, 1392, 1391
1728, 1381, 1382, 1393, 1392
1729, 1382, 1383, 1394, 1393
1730, 1383, 232, 233, 1394
1731, 179, 1384, 201, 9
1732, 1384, 1385, 202, 201
1733, 1385, 1386, 203, 202
1734, 1386, 1387, 204, 203
1735, 1387, 1388, 205, 204
1736, 1388, 1389, 206, 205
1737, 1389, 1390, 207, 206
1738, 1390, 1391, 208, 207
1739, 1391, 1392, 209, 208
1740, 1392, 1393, 210, 209
1741, 1393, 1394, 211, 210
1742, 1394, 233, 13, 211
*ELEMENT, type=CPS4, ELSET=Surface13
1743, 9, 201, 1395, 180
1744, 201, 202, 1396, 1395
1745, 202, 203, 1397, 1396
1746, 203, 204, 1398, 1397
1747, 204, 205, 1399, 1398
1748, 205, 206, 1400, 1399
1749, 206, 207, 1401, 1400
1750, 207, 208, 1402, 1401
1751, 208, 209, 1403, 1402
1752, 209, 210, 1404, 1403
1753, 210, 211, 1405, 1404
1754, 211, 13, 245, 1405
1755, 180, 1395, 1406, 181
1756, 1395, 1396, 1407, 1406
1757, 1396, 1397, 1408, 1407
1758, 1397, 1398, 1409, 1408
1759, 1398, 1399, 1410, 1409
1760, 1399, 1400, 1411, 1410
1761, 1400, 1401, 1412, 1411
1762, 1401, 1402, 1413, 1412
1763, 1402, 1403, 1414, 1413
1764, 1403, 1404, 1415, 1414
1765, 1404, 1405, 1416, 1415
1766, 1405, 245, 246, 1416
1767, 181, 1406, 1417, 182
1768, 1406, 1407, 1418, 1417
1769, 1407, 1408, 1419, 1418
1770, 1408, 1409, 1420, 1419
1771, 1409, 1410, 1421, 1420
1772, 1410, 1411, 1422, 1421
1773, 1411, 1412, 1423, 1422
1774, 1412, 1413, 1424, 1423
1775, 1413, 1414, 1425, 1424
1776, 1414, 1415, 1426, 1425
1777, 1415, 1416, 1427, 1426
1778, 1416, 246, 247, 1427
1779, 182, 1417, 1428, 183
1780, 1417, 1418, 1429, 1428
1781, 1418, 1419, 1430, 1429
1782, 1419, 1420, 1431, 1430
1783, 1420, 1421, 1432, 1431
1784, 1421, 1422, 1433, 1432
1785, 1422, 1423, 1434, 1433
1786, 1423, 1424, 1435, 1434
1787, 1424, 1425, 1436, 1435
1788, 1425, 1426, 1437, 1436
1789, 1426, 1427, 1438, 1437
1790, 1427, 247, 248, 1438
1791, 183, 1428, 1439, 184
1792, 1428, 1429, 1440, 1439
1793, 1429, 1430, 1441, 1440
1794, 1430, 1431, 1442, 1441
1795, 1431, 1432, 1443, 1442
1796, 1432, 1433, 1444, 1443
1797, 1433, 1434, 1445, 1444
1798, 1434, 1435, 1446, 1445
1799, 1435, 1436, 1447, 1446
1800, 1436, 1437, 1448, 1447
1801, 1437, 1438, 1449, 1448
1802, 1438, 248, 249, 1449
1803, 184, 1439, 234, 11
1804, 1439, 1440, 235, 234
1805, 1440, 1441, 236, 235
1806, 1441, 1442, 237, 236
1807, 1442, 1443, 238, 237
1808, 1443, 1444, 239, 238
1809, 1444, 1445, 240, 239
1810, 1445, 1446, 241, 240
1811, 1446, 1447, 242, 241
1812, 1447, 1448, 243, 242
1813, 1448, 1449, 244, 243
1814, 1449, 249, 15, 244
*ELEMENT, type=CPS4, ELSET=Surface14
1815, 12, 185, 1450, 250
1816, 250, 1450, 1451, 251
1817, 251, 1451, 1452, 252
1818, 252, 1452, 1453, 253
1819, 253, 1453, 1454, 254
1820, 254, 1454, 1455, 255
1821, 255, 1455, 1456, 256
1822, 256, 1456, 1457, 257
1823, 257, 1457, 1458, 258
1824, 258, 1458, 1459, 259
1825, 259, 1459, 1460, 260
1826, 260, 1460, 261, 16
1827, 185, 186, 1461, 1450
1828, 1450, 1461, 1462, 1451
1829, 1451, 1462, 1463, 1452
1830, 1452, 1463, 1464, 1453
1831, 1453, 1464, 1465, 1454
1832, 1454, 1465, 1466, 1455
1833, 1455, 1466, 1467, 1456
1834, 1456, 1467, 1468, 1457
1835, 1457, 1468, 1469, 1458
1836, 1458, 1469, 1470, 1459
1837, 1459, 1470, 1471, 1460
1838, 1460, 1471, 262, 261
1839, 186, 187, 1472, 1461
1840, 1461, 1472, 1473, 1462
1841, 1462, 1473, 1474, 1463
1842, 1463, 1474, 1475, 1464
1843, 1464, 1475, 1476, 1465
1844, 1465, 1476, 1477, 1466
1845, 1466, 1477, 1478, 1467
1846, 1467, 1478, 1479, 1468
1847, 1468, 1479, 1480, 1469
1848, 1469, 1480, 1481, 1470
1849, 1470, 1481, 1482, 1471
1850, 1471, 1482, 263, 262
1851, 187, 188, 1483, 1472
1852, 1472, 1483, 1484, 1473
1853, 1473, 1484, 1485, 1474
1854, 1474, 1485, 1486, 1475
1855, 1475, 1486, 1487, 1476
1856, 1476, 1487, 1488, 1477
1857, 1477, 1488, 1489, 1478
1858, 1478, 1489, 1490, 1479
1859, 1479, 1490, 1491, 1480
1860, 1480, 1491, 1492, 1481
1861, 1481, 1492, 1493, 1482
1862, 1482, 1493, 264, 263
1863, 188, 189, 1494, 1483
1864, 1483, 1494, 1495, 1484
1865, 1484, 1495, 1496, 1485
1866, 1485, 1496, 1497, 1486
1867, 1486, 1497, 1498, 1487
1868, 1487, 1498, 1499, 1488
1869, 1488, 1499, 1500, 1489
1870, 1489, 1500, 1501, 1490
1871, 1490, 1501, 1502, 1491
1872, 1491, 1502, 1503, 1492
1873, 1492, 1503, 1504, 1493
1874, 1493, 1504, 265, 264
1875, 189, 190, 1505, 1494
1876, 1494, 1505, 1506, 1495
1877, 1495, 1506, 1507, 1496
1878, 1496, 1507, 1508, 1497
1879, 1497, 1508, 1509, 1498
1880, 1498, 1509, 1510, 1499
1881, 1499, 1510, 1511, 1500
1882, 1500, 1511, 1512, 1501
1883, 1501, 1512, 1513, 1502
1884, 1502, 1513, 1514, 1503
1885, 1503, 1514, 1515, 1504
1886, 1504, 1515, 266, 265
1887, 190, 191, 1516, 1505
1888, 1505, 1516, 1517, 1506
1889, 1506, 1517, 1518, 1507
1890, 1507, 1518, 1519, 1508
1891, 1508, 1519, 1520, 1509
1892, 1509, 1520, 1521, 1510
1893, 1510, 1521, 1522, 1511
1894, 1511, 1522, 1523, 1512
1895, 1512, 1523, 1524, 1513
1896, 1513, 1524, 1525, 1514
1897, 1514, 1525, 1526, 1515
1898, 1515, 1526, 267, 266
1899, 191, 192, 1527, 1516
1900, 1516, 1527, 1528, 1517
1901, 1517, 1528, 1529, 1518
1902, 1518, 1529, 1530, 1519
1903, 1519, 1530, 1531, 1520
1904, 1520, 1531, 1532, 1521
1905, 1521, 1532, 1533, 1522
1906, 1522, 1533, 1534, 1523
1907, 1523, 1534, 1535, 1524
1908, 1524, 1535, 1536, 1525
1909, 1525, 1536, 1537, 1526
1910, 1526, 1537, 268, 267
1911, 192, 193, 1538, 1527
1912, 1527, 1538, 1539, 1528
1913, 1528, 1539, 1540, 1529
1914, 1529, 1540, 1541, 1530
1915, 1530, 1541, 1542, 1531
1916, 1531, 1542, 1543, 1532
1917, 1532, 1543, 1544, 1533
1918, 1533, 1544, 1545, 1534
1919, 1534, 1545, 1546, 1535
1920, 1535, 1546, 1547, 1536
1921, 1536, 1547, 1548, 1537
1922, 1537, 1548, 269, 268
1923, 193, 194, 1549, 1538
1924, 1538, 1549, 1550, 1539
1925, 1539, 1550, 1551, 1540
1926, 1540, 1551, 1552, 1541
1927, 1541, 1552, 1553, 1542
1928, 1542, 1553, 1554, 1543
1929, 1543, 1554, 1555, 1544
1930, 1544, 1555, 1556, 1545
1931, 1545, 1556, 1557, 1546
1932, 1546, 1557, 1558, 1547
1933, 1547, 1558, 1559, 1548
1934, 1548, 1559, 270, 269
1935, 194, 195, 1560, 1549
1936, 1549, 1560, 1561, 1550
1937, 1550, 1561, 1562, 1551
1938, 1551, 1562, 1563, 1552
1939, 1552, 1563, 1564, 1553
1940, 1553, 1564, 1565, 1554
1941, 1554, 1565, 1566, 1555
1942, 1555, 1566, 1567, 1556
1943, 1556, 1567, 1568, 1557
1944, 1557, 1568, 1569, 1558
1945, 1558, 1569, 1570, 1559
1946, 1559, 1570, 271, 270
1947, 195, 11, 234, 1560
1948, 1560, 234, 235, 1561
1949, 1561, 235, 236, 1562
1950, 1562, 236, 237, 1563
1951, 1563, 237, 238, 1564
1952, 1564, 238, 239, 1565
1953, 1565, 239, 240, 1566
1954, 1566, 240, 241, 1567
1955, 1567, 241, 242, 1568
1956, 1568, 242, 243, 1569
1957, 1569, 243, 244, 1570
1958, 1570, 244, 15, 271
*ELEMENT, type=CPS4, ELSET=Surface15
1959, 10, 196, 1571, 212
1960, 212, 1571, 1572, 213
1961, 213, 1572, 1573, 214
1962, 214, 1573, 1574, 215
1963, 215, 1574, 1575, 216
1964, 216, 1575, 1576, 217
1965, 217, 1576, 1577, 218
1966, 218, 1577, 1578, 219
1967, 219, 1578, 1579, 220
1968, 220, 1579, 1580, 221
1969, 221, 1580, 1581, 222
1970, 222, 1581, 272, 14
1971, 196, 197, 1582, 1571
1972, 1571, 1582, 1583, 1572
1973, 1572, 1583, 1584, 1573
1974, 1573, 1584, 1585, 1574
1975, 1574, 1585, 1586, 1575
1976, 1575, 1586, 1587, 1576
1977, 1576, 1587, 1588, 1577
1978, 1577, 1588, 1589, 1578
1979, 1578, 1589, 1590, 1579
1980, 1579, 1590, 1591, 1580
1981, 1580, 1591, 1592, 1581
1982, 1581, 1592, 273, 272
1983, 197, 198, 1593, 1582
1984, 1582, 1593, 1594, 1583
1985, 1583, 1594, 1595, 1584
1986, 1584, 1595, 1596, 1585
1987, 1585, 1596, 1597, 1586
1988, 1586, 1597, 1598, 1587
1989, 1587, 1598, 1599, 1588
1990, 1588, 1599, 1600, 1589
1991, 1589, 1600, 1601, 1590
1992, 1590, 1601, 1602, 1591
1993, 1591, 1602, 1603, 1592
1994, 1592, 1603, 274, 273
1995, 198, 199, 1604, 1593
1996, 1593, 1604, 1605, 1594
1997, 1594, 1605, 1606, 1595
1998, 1595, 1606, 1607, 1596
1999, 1596, 1607, 1608, 1597
2000, 1597, 1608, 1609, 1598
2001, 1598, 1609, 1610, 1599
2002, 1599, 1610, 1611, 1600
2003, 1600, 1611, 1612, 1601
2004, 1601, 1612, 1613, 1602
2005, 1602, 1613, 1614, 1603
2006, 1603, 1614, 275, 274
2007, 199, 200, 1615, 1604
2008, 1604, 1615, 1616, 1605
2009, 1605, 1616, 1617, 1606
2010, 1606, 1617, 1618, 1607
2011, 1607, 1618, 1619, 1608
2012, 1608, 1619, 1620, 1609
2013, 1609, 1620, 1621, 1610
2014, 1610, 1621, 1622, 1611
2015, 1611, 1622, 1623, 1612
2016, 1612, 1623, 1624, 1613
2017, 1613, 1624, 1625, 1614
2018, 1614, 1625, 276, 275
2019, 200, 12, 250, 1615
2020, 1615, 250, 251, 1616
2021, 1616, 251, 252, 1617
2022, 1617, 252, 253, 1618
2023, 1618, 253, 254, 1619
2024, 1619, 254, 255, 1620
2025, 1620, 255, 256, 1621
2026, 1621, 256, 257, 1622
2027, 1622, 257, 258, 1623
2028, 1623, 258, 259, 1624
2029, 1624, 259, 260, 1625
2030, 1625, 260, 16, 276
*ELEMENT, type=CPS4, ELSET=Surface16
2031, 14, 272, 1626, 223
2032, 272, 273, 1627, 1626
2033, 273, 274, 1628, 1627
2034, 274, 275, 1629, 1628
2035, 275, 276, 1630, 1629
2036, 276, 16, 261, 1630
2037, 223, 1626, 1631, 224
2038, 1626, 1627, 1632, 1631
2039, 1627, 1628, 1633, 1632
2040, 1628, 1629, 1634, 1633
2041, 1629, 1630, 1635, 1634
2042, 1630, 261, 262, 1635
2043, 224, 1631, 1636, 225
2044, 1631, 1632, 1637, 1636
2045, 1632, 1633, 1638, 1637
2046, 1633, 1634, 1639, 1638
2047, 1634, 1635, 1640, 1639
2048, 1635, 262, 263, 1640
2049, 225, 1636, 1641, 226
2050, 1636, 1637, 1642, 1641
2051, 1637, 1638, 1643, 1642
2052, 1638, 1639, 1644, 1643
2053, 1639, 1640, 1645, 1644
2054, 1640, 263, 264, 1645
2055, 226, 1641, 1646, 227
2056, 1641, 1642, 1647, 1646
2057, 1642, 1643, 1648, 1647
2058, 1643, 1644, 1649, 1648
2059, 1644, 1645, 1650, 1649
2060, 1645, 264, 265, 1650
2061, 227, 1646, 1651, 228
2062, 1646, 1647, 1652, 1651
2063, 1647, 1648, 1653, 1652
2064, 1648, 1649, 1654, 1653
2065, 1649, 1650, 1655, 1654
2066, 1650, 265, 266, 1655
2067, 228, 1651, 1656, 229
2068, 1651, 1652, 1657, 1656
2069, 1652, 1653, 1658, 1657
2070, 1653, 1654, 1659, 1658
2071, 1654, 1655, 1660, 1659
2072, 1655, 266, 267, 1660
2073, 229, 1656, 1661, 230
2074, 1656, 1657, 1662, 1661
2075, 1657, 1658, 1663, 1662
2076, 1658, 1659, 1664, 1663
2077, 1659, 1660, 1665, 1664
2078, 1660, 267, 268, 1665
2079, 230, 1661, 1666, 231
2080, 1661, 1662, 1667, 1666
2081, 1662, 1663, 1668, 1667
2082, 1663, 1664, 1669, 1668
2083, 1664, 1665, 1670, 1669
2084, 1665, 268, 269, 1670
2085, 231, 1666, 1671, 232
2086, 1666, 1667, 1672, 1671
2087, 1667, 1668, 1673, 1672
2088, 1668, 1669, 1674, 1673
2089, 1669, 1670, 1675, 1674
2090, 1670, 269, 270, 1675
2091, 232, 1671, 1676, 233
2092, 1671, 1672, 1677, 1676
2093, 1672, 1673, 1678, 1677
2094, 1673, 1674, 1679, 1678
2095, 1674, 1675, 1680, 1679
2096, 1675, 270, 271, 1680
2097, 233, 1676, 245, 13
2098, 1676, 1677, 246, 245
2099, 1677, 1678, 247, 246
2100, 1678, 1679, 248, 247
2101, 1679, 1680, 249, 248
2102, 1680, 271, 15, 249
*ELEMENT, type=CPS4, ELSET=Surface17
2103, 14, 18, 277, 223
2104, 223, 277, 278, 224
2105, 224, 278, 279, 225
2106, 225, 279, 280, 226
2107, 226, 280, 281, 227
2108, 227, 281, 282, 228
2109, 228, 282, 283, 229
2110, 229, 283, 284, 230
2111, 230, 284, 285, 231
2112, 231, 285, 286, 232
2113, 232, 286, 287, 233
2114, 233, 287, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
2115, 13, 17, 288, 245
2116, 245, 288, 289, 246
2117, 246, 289, 290, 247
2118, 247, 290, 291, 248
2119, 248, 291, 292, 249
2120, 249, 292, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
2121, 16, 261, 293, 20
2122, 261, 262, 294, 293
2123, 262, 263, 295, 294
2124, 263, 264, 296, 295
2125, 264, 265, 297, 296
2126, 265, 266, 298, 297
2127, 266, 267, 299, 298
2128, 267, 268, 300, 299
2129, 268, 269, 301, 300
2130, 269, 270, 302, 301
2131, 270, 271, 303, 302
2132, 271, 15, 19, 303
*ELEMENT, type=CPS4, ELSET=Surface20
2133, 14, 272, 304, 18
2134, 272, 273, 305, 304
2135, 273, 274, 306, 305
2136, 274, 275, 307, 306
2137, 275, 276, 308, 307
2138, 276, 16, 20, 308
*ELEMENT, type=CPS4, ELSET=Surface21
2139, 18, 304, 1681, 277
2140, 304, 305, 1682, 1681
2141, 305, 306, 1683, 1682
2142, 306, 307, 1684, 1683
2143, 307, 308, 1685, 1684
2144, 308, 20, 293, 1685
2145, 277, 1681, 1686, 278
2146, 1681, 1682, 1687, 1686
2147, 1682, 1683, 1688, 1687
2148, 1683, 1684, 1689, 1688
2149, 1684, 1685, 1690, 1689
2150, 1685, 293, 294, 1690
2151, 278, 1686, 1691, 279
2152, 1686, 1687, 1692, 1691
2153, 1687, 1688, 1693, 1692
2154, 1688, 1689, 1694, 1693
2155, 1689, 1690, 1695, 1694
2156, 1690, 294, 295, 1695
2157, 279, 1691, 1696, 280
2158, 1691, 1692, 1697, 1696
2159, 1692, 1693, 1698, 1697
2160, 1693, 1694, 1699, 1698
2161, 1694, 1695, 1700, 1699
2162, 1695, 295, 296, 1700
2163, 280, 1696, 1701, 281
2164, 1696, 1697, 1702, 1701
2165, 1697, 1698, 1703, 1702
2166, 1698, 1699, 1704, 1703
2167, 1699, 1700, 1705, 1704
2168, 1700, 296, 297, 1705
2169, 281, 1701, 1706, 282
2170, 1701, 1702, 1707, 1706
2171, 1702, 1703, 1708, 1707
2172, 1703, 1704, 1709, 1708
2173, 1704, 1705, 1710, 1709
2174, 1705, 297, 298, 1710
2175, 282, 1706, 1711, 283
2176, 1706, 1707, 1712, 1711
2177, 1707, 1708, 1713, 1712
2178, 1708, 1709, 1714, 1713
2179, 1709, 1710, 1715, 1714
2180, 1710, 298, 299, 1715
2181, 283, 1711, 1716, 284
2182, 1711, 1712, 1717, 1716
2183, 1712, 1713, 1718, 1717
2184, 1713, 1714, 1719, 1718
2185, 1714, 1715, 1720, 1719
2186, 1715, 299, 300, 1720
2187, 284, 1716, 1721, 285
2188, 1716, 1717, 1722, 1721
2189, 1717, 1718, 1723, 1722
2190, 1718, 1719, 1724, 1723
2191, 1719, 1720, 1725, 1724
2192, 1720, 300, 301, 1725
2193, 285, 1721, 1726, 286
2194, 1721, 1722, 1727, 1726
2195, 1722, 1723, 1728, 1727
2196, 1723, 1724, 1729, 1728
2197, 1724, 1725, 1730, 1729
2198, 1725, 301, 302, 1730
2199, 286, 1726, 1731, 287
2200, 1726, 1727, 1732, 1731
2201, 1727, 1728, 1733, 1732
2202, 1728, 1729, 1734, 1733
2203, 1729, 1730, 1735, 1734
2204, 1730, 302, 303, 1735
2205, 287, 1731, 288, 17
2206, 1731, 1732, 289, 288
2207, 1732, 1733, 290, 289
2208, 1733, 1734, 291, 290
2209, 1734, 1735, 292, 291
2210, 1735, 303, 19, 292
*ELEMENT, type=CPS4, ELSET=Surface22
2211, 18, 311, 1736, 277
2212, 311, 312, 1737, 1736
2213, 312, 22, 313, 1737
2214, 277, 1736, 1738, 278
2215, 1736, 1737, 1739, 1738
2216, 1737, 313, 314, 1739
2217, 278, 1738, 1740, 279
2218, 1738, 1739, 1741, 1740
2219, 1739, 314, 315, 1741
2220, 279, 1740, 1742, 280
2221, 1740, 1741, 1743, 1742
2222, 1741, 315, 316, 1743
2223, 280, 1742, 1744, 281
2224, 1742, 1743, 1745, 1744
2225, 1743, 316, 317, 1745
2226, 281, 1744, 1746, 282
2227, 1744, 1745, 1747, 1746
2228, 1745, 317, 318, 1747
2229, 282, 1746, 1748, 283
2230, 1746, 1747, 1749, 1748
2231, 1747, 318, 319, 1749
2232, 283, 1748, 1750, 284
2233, 1748, 1749, 1751, 1750
2234, 1749, 319, 320, 1751
2235, 284, 1750, 1752, 285
2236, 1750, 1751, 1753, 1752
2237, 1751, 320, 321, 1753
2238, 285, 1752, 1754, 286
2239, 1752, 1753, 1755, 1754
2240, 1753, 321, 322, 1755
2241, 286, 1754, 1756, 287
2242, 1754, 1755, 1757, 1756
2243, 1755, 322, 323, 1757
2244, 287, 1756, 309, 17
2245, 1756, 1757, 310, 309
2246, 1757, 323, 21, 310
*ELEMENT, type=CPS4, ELSET=Surface23
2247, 17, 309, 1758, 288
2248, 309, 310, 1759, 1758
2249, 310, 21, 326, 1759
2250, 288, 1758, 1760, 289
2251, 1758, 1759, 1761, 1760
2252, 1759, 326, 327, 1761
2253, 289, 1760, 1762, 290
2254, 1760, 1761, 1763, 1762
2255, 1761, 327, 328, 1763
2256, 290, 1762, 1764, 291
2257, 1762, 1763, 1765, 1764
2258, 1763, 328, 329, 1765
2259, 291, 1764, 1766, 292
2260, 1764, 1765, 1767, 1766
2261, 1765, 329, 330, 1767
2262, 292, 1766, 324, 19
2263, 1766, 1767, 325, 324
2264, 1767, 330, 23, 325
*ELEMENT, type=CPS4, ELSET=Surface24
2265, 20, 293, 1768, 331
2266, 331, 1768, 1769, 332
2267, 332, 1769, 333, 24
2268, 293, 294, 1770, 1768
2269, 1768, 1770, 1771, 1769
2270, 1769, 1771, 334, 333
2271, 294, 295, 1772, 1770
2272, 1770, 1772, 1773, 1771
2273, 1771, 1773, 335, 334
2274, 295, 296, 1774, 1772
2275, 1772, 1774, 1775, 1773
2276, 1773, 1775, 336, 335
2277, 296, 297, 1776, 1774
2278, 1774, 1776, 1777, 1775
2279, 1775, 1777, 337, 336
2280, 297, 298, 1778, 1776
2281, 1776, 1778, 1779, 1777
2282, 1777, 1779, 338, 337
2283, 298, 299, 1780, 1778
2284, 1778, 1780, 1781, 1779
2285, 1779, 1781, 339, 338
2286, 299, 300, 1782, 1780
2287, 1780, 1782, 1783, 1781
2288, 1781, 1783, 340, 339
2289, 300, 301, 1784, 1782
2290, 1782, 1784, 1785, 1783
2291, 1783, 1785, 341, 340
2292, 301, 302, 1786, 1784
2293, 1784, 1786, 1787, 1785
2294, 1785, 1787, 342, 341
2295, 302, 303, 1788, 1786
2296, 1786, 1788, 1789, 1787
2297, 1787, 1789, 343, 342
2298, 303, 19, 324, 1788
2299, 1788, 324, 325, 1789
2300, 1789, 325, 23, 343
*ELEMENT, type=CPS4, ELSET=Surface25
2301, 18, 304, 1790, 311
2302, 311, 1790, 1791, 312
2303, 312, 1791, 344, 22
2304, 304, 305, 1792, 1790
2305, 1790, 1792, 1793, 1791
2306, 1791, 1793, 345, 344
2307, 305, 306, 1794, 1792
2308, 1792, 1794, 1795, 1793
2309, 1793, 1795, 346, 345
2310, 306, 307, 1796, 1794
2311, 1794, 1796, 1797, 1795
2312, 1795, 1797, 347, 346
2313, 307, 308, 1798, 1796
2314, 1796, 1798, 1799, 1797
2315, 1797, 1799, 348, 347
2316, 308, 20, 331, 1798
2317, 1798, 331, 332, 1799
2318, 1799, 332, 24, 348
*ELEMENT, type=CPS4, ELSET=Surface26
2319, 22, 344, 1800, 313
2320, 344, 345, 1801, 1800
2321, 345, 346, 1802, 1801
2322, 346, 347, 1803, 1802
2323, 347, 348, 1804, 1803
2324, 348, 24, 333, 1804
2325, 313, 1800, 1805, 314
2326, 1800, 1801, 1806, 1805
2327, 1801, 1802, 1807, 1806
2328, 1802, 1803, 1808, 1807
2329, 1803, 1804, 1809, 1808
2330, 1804, 333, 334, 1809
2331, 314, 1805, 1810, 315
2332, 1805, 1806, 1811, 1810
2333, 1806, 1807, 1812, 1811
2334, 1807, 1808, 1813, 1812
2335, 1808, 1809, 1814, 1813
2336, 1809, 334, 335, 1814
2337, 315, 1810, 1815, 316
2338, 1810, 1811, 1816, 1815
2339, 1811, 1812, 1817, 1816
2340, 1812, 1813, 1818, 1817
2341, 1813, 1814, 1819, 1818
2342, 1814, 335, 336, 1819
2343, 316, 1815, 1820, 317
2344, 1815, 1816, 1821, 1820
2345, 1816, 1817, 1822, 1821
2346, 1817, 1818, 1823, 1822
2347, 1818, 1819, 1824, 1823
2348, 1819, 336, 337, 1824
2349, 317, 1820, 1825, 318
2350, 1820, 1821, 1826, 1825
2351, 1821, 1822, 1827, 1826
2352, 1822, 1823, 1828, 1827
2353, 1823, 1824, 1829, 1828
2354, 1824, 337, 338, 1829
2355, 318, 1825, 1830, 319
2356, 1825, 1826, 1831, 1830
2357, 1826, 1827, 1832, 1831
2358, 1827, 1828, 1833, 1832
2359, 1828, 1829, 1834, 1833
2360, 1829, 338, 339, 1834
2361, 319, 1830, 1835, 320
2362, 1830, 1831, 1836, 1835
2363, 1831, 1832, 1837, 1836
2364, 1832, 1833, 1838, 1837
2365, 1833, 1834, 1839, 1838
2366, 1834, 339, 340, 1839
2367, 320, 1835, 1840, 321
2368, 1835, 1836, 1841, 1840
2369, 1836, 1837, 1842, 1841
2370, 1837, 1838, 1843, 1842
2371, 1838, 1839, 1844, 1843
2372, 1839, 340, 341, 1844
2373, 321, 1840, 1845, 322
2374, 1840, 1841, 1846, 1845
2375, 1841, 1842, 1847, 1846
2376, 1842, 1843, 1848, 1847
2377, 1843, 1844, 1849, 1848
2378, 1844, 341, 342, 1849
2379, 322, 1845, 1850, 323
2380, 1845, 1846, 1851, 1850
2381, 1846, 1847, 1852, 1851
2382, 1847, 1848, 1853, 1852
2383, 1848, 1849, 1854, 1853
2384, 1849, 342, 343, 1854
2385, 323, 1850, 326, 21
2386, 1850, 1851, 327, 326
2387, 1851, 1852, 328, 327
2388, 1852, 1853, 329, 328
2389, 1853, 1854, 330, 329
2390, 1854, 343, 23, 330
*ELEMENT, type=CPS4, ELSET=Surface27
2391, 19, 349, 1855, 324
2392, 349, 350, 1856, 1855
2393, 350, 351, 1857, 1856
2394, 351, 352, 1858, 1857
2395, 352, 25, 357, 1858
2396, 324, 1855, 1859, 325
2397, 1855, 1856, 1860, 1859
2398, 1856, 1857, 1861, 1860
2399, 1857, 1858, 1862, 1861
2400, 1858, 357, 358, 1862
2401, 325, 1859, 353, 23
2402, 1859, 1860, 354, 353
2403, 1860, 1861, 355, 354
2404, 1861, 1862, 356, 355
2405, 1862, 358, 26, 356
*ELEMENT, type=CPS4, ELSET=Surface28
2406, 17, 309, 1863, 359
2407, 359, 1863, 1864, 360
2408, 360, 1864, 1865, 361
2409, 361, 1865, 1866, 362
2410, 362, 1866, 367, 27
2411, 309, 310, 1867, 1863
2412, 1863, 1867, 1868, 1864
2413, 1864, 1868, 1869, 1865
2414, 1865, 1869, 1870, 1866
2415, 1866, 1870, 368, 367
2416, 310, 21, 363, 1867
2417, 1867, 363, 364, 1868
2418, 1868, 364, 365, 1869
2419, 1869, 365, 366, 1870
2420, 1870, 366, 28, 368
*ELEMENT, type=CPS4, ELSET=Surface29
2421, 17, 359, 1871, 288
2422, 359, 360, 1872, 1871
2423, 360, 361, 1873, 1872
2424, 361, 362, 1874, 1873
2425, 362, 27, 369, 1874
2426, 288, 1871, 1875, 289
2427, 1871, 1872, 1876, 1875
2428, 1872, 1873, 1877, 1876
2429, 1873, 1874, 1878, 1877
2430, 1874, 369, 370, 1878
2431, 289, 1875, 1879, 290
2432, 1875, 1876, 1880, 1879
2433, 1876, 1877, 1881, 1880
2434, 1877, 1878, 1882, 1881
2435, 1878, 370, 371, 1882
2436, 290, 1879, 1883, 291
2437, 1879, 1880, 1884, 1883
2438, 1880, 1881, 1885, 1884
2439, 1881, 1882, 1886, 1885
2440, 1882, 371, 372, 1886
2441, 291, 1883, 1887, 292
2442, 1883, 1884, 1888, 1887
2443, 1884, 1885, 1889, 1888
2444, 1885, 1886, 1890, 1889
2445, 1886, 372, 373, 1890
2446, 292, 1887, 349, 19
2447, 1887, 1888, 350, 349
2448, 1888, 1889, 351, 350
2449, 1889, 1890, 352, 351
2450, 1890, 373, 25, 352
*ELEMENT, type=CPS4, ELSET=Surface30
2451, 21, 326, 1891, 363
2452, 363, 1891, 1892, 364
2453, 364, 1892, 1893, 365
2454, 365, 1893, 1894, 366
2455, 366, 1894, 374, 28
2456, 326, 327, 1895, 1891
2457, 1891, 1895, 1896, 1892
2458, 1892, 1896, 1897, 1893
2459, 1893, 1897, 1898, 1894
2460, 1894, 1898, 375, 374
2461, 327, 328, 1899, 1895
2462, 1895, 1899, 1900, 1896
2463, 1896, 1900, 1901, 1897
2464, 1897, 1901, 1902, 1898
2465, 1898, 1902, 376, 375
2466, 328, 329, 1903, 1899
2467, 1899, 1903, 1904, 1900
2468, 1900, 1904, 1905, 1901
2469, 1901, 1905, 1906, 1902
2470, 1902, 1906, 377, 376
2471, 329, 330, 1907, 1903
2472, 1903, 1907, 1908, 1904
2473, 1904, 1908, 1909, 1905
2474, 1905, 1909, 1910, 1906
2475, 1906, 1910, 378, 377
2476, 330, 23, 353, 1907
2477, 1907, 353, 354, 1908
2478, 1908, 354, 355, 1909
2479, 1909, 355, 356, 1910
2480, 1910, 356, 26, 378
*ELEMENT, type=CPS4, ELSET=Surface31
2481, 27, 367, 1911, 369
2482, 367, 368, 1912, 1911
2483, 368, 28, 374, 1912
2484, 369, 1911, 1913, 370
2485, 1911, 1912, 1914, 1913
2486, 1912, 374, 375, 1914
2487, 370, 1913, 1915, 371
2488, 1913, 1914, 1916, 1915
2489, 1914, 375, 376, 1916
2490, 371, 1915, 1917, 372
2491, 1915, 1916, 1918, 1917
2492, 1916, 376, 377, 1918
2493, 372, 1917, 1919, 373
2494, 1917, 1918, 1920, 1919
2495, 1918, 377, 378, 1920
2496, 373, 1919, 357, 25
2497, 1919, 1920, 358, 357
2498, 1920, 378, 26, 358
*ELEMENT, type=CPS4, ELSET=Surface32
2499, 25, 379, 1921, 357
2500, 379, 380, 1922, 1921
2501, 380, 381, 1923, 1922
2502, 381, 382, 1924, 1923
2503, 382, 383, 1925, 1924
2504, 383, 384, 1926, 1925
2505, 384, 385, 1927, 1926
2506, 385, 386, 1928, 1927
2507, 386, 387, 1929, 1928
2508, 387, 388, 1930, 1929
2509, 388, 389, 1931, 1930
2510, 389, 29, 401, 1931
2511, 357, 1921, 1932, 358
2512, 1921, 1922, 1933, 1932
2513, 1922, 1923, 1934, 1933
