*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_12x12x6el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 1.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0.5
47, 1.2, -1.2490009027033e-16, 0
48, 2.2, -1.2490009027033e-16, 0
49, 2.3, 0.1, 0.5
50, 2.3, -1.2490009027033e-16, 0.5
51, 2.3, 0.1, 0
52, 2.3, -1.2490009027033e-16, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.1, 0.5
56, -0.1, 0.1, 0
57, 1.05, 0.15, 0.5
58, 1.05, 1.35, 0.5
59, 1.05, 0.15, 0
60, 1.05, 1.35, 0
61, 1.15, 1.35, 0.5
62, 1.15, 0.15, 0.5
63, 1.15, 1.35, 0
64, 1.15, 0.15, 0
65, 1, 0.15, -0.1
66, 1, 1.35, -0.1
67, 0, 0.15, -0.1
68, 0, 1.35, -0.1
69, 1.2, 1.35, -0.1
70, 1.2, 0.15, -0.1
71, 2.2, 1.35, -0.1
72, 2.2, 0.15, -0.1
73, 1.15, 1.35, -0.1
74, 1.15, 0.15, -0.1
75, 1.05, 0.15, -0.1
76, 1.05, 1.35, -0.1
77, 1, 1.7, 0
78, 0, 1.7, 0
79, 1, 1.7, 0.5
80, 0, 1.7, 0.5
81, 1.2, 1.7, 0.5
82, 1.2, 1.7, 0
83, 2.2, 1.7, 0.5
84, 2.2, 1.7, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.083333333333333
98, 0, 0, 0.16666666666667
99, 0, 0, 0.25
100, 0, 0, 0.33333333333333
101, 0, 0, 0.41666666666667
102, 0, 0.033333333333333, 0.5
103, 0, 0.066666666666667, 0.5
104, 0, 0.1, 0.083333333333333
105, 0, 0.1, 0.16666666666667
106, 0, 0.1, 0.25
107, 0, 0.1, 0.33333333333333
108, 0, 0.1, 0.41666666666667
109, 0, 0.033333333333333, 0
110, 0, 0.066666666666667, 0
111, 1, 0, 0.083333333333333
112, 1, 0, 0.16666666666667
113, 1, 0, 0.25
114, 1, 0, 0.33333333333333
115, 1, 0, 0.41666666666667
116, 1, 0.033333333333333, 0.5
117, 1, 0.066666666666667, 0.5
118, 1, 0.1, 0.083333333333333
119, 1, 0.1, 0.16666666666667
120, 1, 0.1, 0.25
121, 1, 0.1, 0.33333333333333
122, 1, 0.1, 0.41666666666667
123, 1, 0.033333333333333, 0
124, 1, 0.066666666666667, 0
125, 0.083333333333333, 0, 0
126, 0.16666666666667, 0, 0
127, 0.25, 0, 0
128, 0.33333333333333, 0, 0
129, 0.41666666666667, 0, 0
130, 0.5, 0, 0
131, 0.58333333333333, 0, 0
132, 0.66666666666667, 0, 0
133, 0.75, 0, 0
134, 0.83333333333333, 0, 0
135, 0.91666666666667, 0, 0
136, 0.083333333333333, 0, 0.5
137, 0.16666666666667, 0, 0.5
138, 0.25, 0, 0.5
139, 0.33333333333333, 0, 0.5
140, 0.41666666666667, 0, 0.5
141, 0.5, 0, 0.5
142, 0.58333333333333, 0, 0.5
143, 0.66666666666667, 0, 0.5
144, 0.75, 0, 0.5
145, 0.83333333333333, 0, 0.5
146, 0.91666666666667, 0, 0.5
147, 0.083333333333333, 0.1, 0
148, 0.16666666666667, 0.1, 0
149, 0.25, 0.1, 0
150, 0.33333333333333, 0.1, 0
151, 0.41666666666667, 0.1, 0
152, 0.5, 0.1, 0
153, 0.58333333333333, 0.1, 0
154, 0.66666666666667, 0.1, 0
155, 0.75, 0.1, 0
156, 0.83333333333333, 0.1, 0
157, 0.91666666666667, 0.1, 0
158, 0.083333333333333, 0.1, 0.5
159, 0.16666666666667, 0.1, 0.5
160, 0.25, 0.1, 0.5
161, 0.33333333333333, 0.1, 0.5
162, 0.41666666666667, 0.1, 0.5
163, 0.5, 0.1, 0.5
164, 0.58333333333333, 0.1, 0.5
165, 0.66666666666667, 0.1, 0.5
166, 0.75, 0.1, 0.5
167, 0.83333333333333, 0.1, 0.5
168, 0.91666666666667, 0.1, 0.5
169, 0.083333333333333, 0.15, 0
170, 0.16666666666667, 0.15, 0
171, 0.25, 0.15, 0
172, 0.33333333333333, 0.15, 0
173, 0.41666666666667, 0.15, 0
174, 0.5, 0.15, 0
175, 0.58333333333333, 0.15, 0
176, 0.66666666666667, 0.15, 0
177, 0.75, 0.15, 0
178, 0.83333333333333, 0.15, 0
179, 0.91666666666667, 0.15, 0
180, 1, 0.15, 0.083333333333333
181, 1, 0.15, 0.16666666666667
182, 1, 0.15, 0.25
183, 1, 0.15, 0.33333333333333
184, 1, 0.15, 0.41666666666667
185, 0.083333333333333, 0.15, 0.5
186, 0.16666666666667, 0.15, 0.5
187, 0.25, 0.15, 0.5
188, 0.33333333333333, 0.15, 0.5
189, 0.41666666666667, 0.15, 0.5
190, 0.5, 0.15, 0.5
191, 0.58333333333333, 0.15, 0.5
192, 0.66666666666667, 0.15, 0.5
193, 0.75, 0.15, 0.5
194, 0.83333333333333, 0.15, 0.5
195, 0.91666666666667, 0.15, 0.5
196, 0, 0.15, 0.083333333333333
197, 0, 0.15, 0.16666666666667
198, 0, 0.15, 0.25
199, 0, 0.15, 0.33333333333333
200, 0, 0.15, 0.41666666666667
201, 1, 0.25, 0
202, 1, 0.35, 0
203, 1, 0.45, 0
204, 1, 0.55, 0
205, 1, 0.65, 0
206, 1, 0.75, 0
207, 1, 0.85, 0
208, 1, 0.95, 0
209, 1, 1.05, 0
210, 1, 1.15, 0
211, 1, 1.25, 0
212, 0, 0.25, 0
213, 0, 0.35, 0
214, 0, 0.45, 0
215, 0, 0.55, 0
216, 0, 0.65, 0
217, 0, 0.75, 0
218, 0, 0.85, 0
219, 0, 0.95, 0
220, 0, 1.05, 0
221, 0, 1.15, 0
222, 0, 1.25, 0
223, 0.083333333333333, 1.35, 0
224, 0.16666666666667, 1.35, 0
225, 0.25, 1.35, 0
226, 0.33333333333333, 1.35, 0
227, 0.41666666666667, 1.35, 0
228, 0.5, 1.35, 0
229, 0.58333333333333, 1.35, 0
230, 0.66666666666667, 1.35, 0
231, 0.75, 1.35, 0
232, 0.83333333333333, 1.35, 0
233, 0.91666666666667, 1.35, 0
234, 1, 0.25, 0.5
235, 1, 0.35, 0.5
236, 1, 0.45, 0.5
237, 1, 0.55, 0.5
238, 1, 0.65, 0.5
239, 1, 0.75, 0.5
240, 1, 0.85, 0.5
241, 1, 0.95, 0.5
242, 1, 1.05, 0.5
243, 1, 1.15, 0.5
244, 1, 1.25, 0.5
245, 1, 1.35, 0.083333333333333
246, 1, 1.35, 0.16666666666667
247, 1, 1.35, 0.25
248, 1, 1.35, 0.33333333333333
249, 1, 1.35, 0.41666666666667
250, 0, 0.25, 0.5
251, 0, 0.35, 0.5
252, 0, 0.45, 0.5
253, 0, 0.55, 0.5
254, 0, 0.65, 0.5
255, 0, 0.75, 0.5
256, 0, 0.85, 0.5
257, 0, 0.95, 0.5
258, 0, 1.05, 0.5
259, 0, 1.15, 0.5
260, 0, 1.25, 0.5
261, 0.083333333333333, 1.35, 0.5
262, 0.16666666666667, 1.35, 0.5
263, 0.25, 1.35, 0.5
264, 0.33333333333333, 1.35, 0.5
265, 0.41666666666667, 1.35, 0.5
266, 0.5, 1.35, 0.5
267, 0.58333333333333, 1.35, 0.5
268, 0.66666666666667, 1.35, 0.5
269, 0.75, 1.35, 0.5
270, 0.83333333333333, 1.35, 0.5
271, 0.91666666666667, 1.35, 0.5
272, 0, 1.35, 0.083333333333333
273, 0, 1.35, 0.16666666666667
274, 0, 1.35, 0.25
275, 0, 1.35, 0.33333333333333
276, 0, 1.35, 0.41666666666667
277, 0.083333333333333, 1.4, 0
278, 0.16666666666667, 1.4, 0
279, 0.25, 1.4, 0
280, 0.33333333333333, 1.4, 0
281, 0.41666666666667, 1.4, 0
282, 0.5, 1.4, 0
283, 0.58333333333333, 1.4, 0
284, 0.66666666666667, 1.4, 0
285, 0.75, 1.4, 0
286, 0.83333333333333, 1.4, 0
287, 0.91666666666667, 1.4, 0
288, 1, 1.4, 0.083333333333333
289, 1, 1.4, 0.16666666666667
290, 1, 1.4, 0.25
291, 1, 1.4, 0.33333333333333
292, 1, 1.4, 0.41666666666667
293, 0.083333333333333, 1.4, 0.5
294, 0.16666666666667, 1.4, 0.5
295, 0.25, 1.4, 0.5
296, 0.33333333333333, 1.4, 0.5
297, 0.41666666666667, 1.4, 0.5
298, 0.5, 1.4, 0.5
299, 0.58333333333333, 1.4, 0.5
300, 0.66666666666667, 1.4, 0.5
301, 0.75, 1.4, 0.5
302, 0.83333333333333, 1.4, 0.5
303, 0.91666666666667, 1.4, 0.5
304, 0, 1.4, 0.083333333333333
305, 0, 1.4, 0.16666666666667
306, 0, 1.4, 0.25
307, 0, 1.4, 0.33333333333333
308, 0, 1.4, 0.41666666666667
309, 1, 1.4333333333333, 0
310, 1, 1.4666666666667, 0
311, 0, 1.4333333333333, 0
312, 0, 1.4666666666667, 0
313, 0.083333333333333, 1.5, 0
314, 0.16666666666667, 1.5, 0
315, 0.25, 1.5, 0
316, 0.33333333333333, 1.5, 0
317, 0.41666666666667, 1.5, 0
318, 0.5, 1.5, 0
319, 0.58333333333333, 1.5, 0
320, 0.66666666666667, 1.5, 0
321, 0.75, 1.5, 0
322, 0.83333333333333, 1.5, 0
323, 0.91666666666667, 1.5, 0
324, 1, 1.4333333333333, 0.5
325, 1, 1.4666666666667, 0.5
326, 1, 1.5, 0.083333333333333
327, 1, 1.5, 0.16666666666667
328, 1, 1.5, 0.25
329, 1, 1.5, 0.33333333333333
330, 1, 1.5, 0.41666666666667
331, 0, 1.4333333333333, 0.5
332, 0, 1.4666666666667, 0.5
333, 0.083333333333333, 1.5, 0.5
334, 0.16666666666667, 1.5, 0.5
335, 0.25, 1.5, 0.5
336, 0.33333333333333, 1.5, 0.5
337, 0.41666666666667, 1.5, 0.5
338, 0.5, 1.5, 0.5
339, 0.58333333333333, 1.5, 0.5
340, 0.66666666666667, 1.5, 0.5
341, 0.75, 1.5, 0.5
342, 0.83333333333333, 1.5, 0.5
343, 0.91666666666667, 1.5, 0.5
344, 0, 1.5, 0.083333333333333
345, 0, 1.5, 0.16666666666667
346, 0, 1.5, 0.25
347, 0, 1.5, 0.33333333333333
348, 0, 1.5, 0.41666666666667
349, 1.04, 1.4, 0.5
350, 1.08, 1.4, 0.5
351, 1.12, 1.4, 0.5
352, 1.16, 1.4, 0.5
353, 1.04, 1.5, 0.5
354, 1.08, 1.5, 0.5
355, 1.12, 1.5, 0.5
356, 1.16, 1.5, 0.5
357, 1.2, 1.4333333333333, 0.5
358, 1.2, 1.4666666666667, 0.5
359, 1.04, 1.4, 0
360, 1.08, 1.4, 0
361, 1.12, 1.4, 0
362, 1.16, 1.4, 0
363, 1.04, 1.5, 0
364, 1.08, 1.5, 0
365, 1.12, 1.5, 0
366, 1.16, 1.5, 0
367, 1.2, 1.4333333333333, 0
368, 1.2, 1.4666666666667, 0
369, 1.2, 1.4, 0.083333333333333
370, 1.2, 1.4, 0.16666666666667
371, 1.2, 1.4, 0.25
372, 1.2, 1.4, 0.33333333333333
373, 1.2, 1.4, 0.41666666666667
374, 1.2, 1.5, 0.083333333333333
375, 1.2, 1.5, 0.16666666666667
376, 1.2, 1.5, 0.25
377, 1.2, 1.5, 0.33333333333333
378, 1.2, 1.5, 0.41666666666667
379, 1.2833333333333, 1.4, 0.5
380, 1.3666666666667, 1.4, 0.5
381, 1.45, 1.4, 0.5
382, 1.5333333333333, 1.4, 0.5
383, 1.6166666666667, 1.4, 0.5
384, 1.7, 1.4, 0.5
385, 1.7833333333333, 1.4, 0.5
386, 1.8666666666667, 1.4, 0.5
387, 1.95, 1.4, 0.5
388, 2.0333333333333, 1.4, 0.5
389, 2.1166666666667, 1.4, 0.5
390, 1.2833333333333, 1.5, 0.5
391, 1.3666666666667, 1.5, 0.5
392, 1.45, 1.5, 0.5
393, 1.5333333333333, 1.5, 0.5
394, 1.6166666666667, 1.5, 0.5
395, 1.7, 1.5, 0.5
396, 1.7833333333333, 1.5, 0.5
397, 1.8666666666667, 1.5, 0.5
398, 1.95, 1.5, 0.5
399, 2.0333333333333, 1.5, 0.5
400, 2.1166666666667, 1.5, 0.5
401, 2.2, 1.4333333333333, 0.5
402, 2.2, 1.4666666666667, 0.5
403, 1.2833333333333, 1.4, 0
404, 1.3666666666667, 1.4, 0
405, 1.45, 1.4, 0
406, 1.5333333333333, 1.4, 0
407, 1.6166666666667, 1.4, 0
408, 1.7, 1.4, 0
409, 1.7833333333333, 1.4, 0
410, 1.8666666666667, 1.4, 0
411, 1.95, 1.4, 0
412, 2.0333333333333, 1.4, 0
413, 2.1166666666667, 1.4, 0
414, 1.2833333333333, 1.5, 0
415, 1.3666666666667, 1.5, 0
416, 1.45, 1.5, 0
417, 1.5333333333333, 1.5, 0
418, 1.6166666666667, 1.5, 0
419, 1.7, 1.5, 0
420, 1.7833333333333, 1.5, 0
421, 1.8666666666667, 1.5, 0
422, 1.95, 1.5, 0
423, 2.0333333333333, 1.5, 0
424, 2.1166666666667, 1.5, 0
425, 2.2, 1.4333333333333, 0
426, 2.2, 1.4666666666667, 0
427, 2.2, 1.4, 0.083333333333333
428, 2.2, 1.4, 0.16666666666667
429, 2.2, 1.4, 0.25
430, 2.2, 1.4, 0.33333333333333
431, 2.2, 1.4, 0.41666666666667
432, 2.2, 1.5, 0.083333333333333
433, 2.2, 1.5, 0.16666666666667
434, 2.2, 1.5, 0.25
435, 2.2, 1.5, 0.33333333333333
436, 2.2, 1.5, 0.41666666666667
437, 1.2833333333333, 1.35, 0.5
438, 1.3666666666667, 1.35, 0.5
439, 1.45, 1.35, 0.5
440, 1.5333333333333, 1.35, 0.5
441, 1.6166666666667, 1.35, 0.5
442, 1.7, 1.35, 0.5
443, 1.7833333333333, 1.35, 0.5
444, 1.8666666666667, 1.35, 0.5
445, 1.95, 1.35, 0.5
446, 2.0333333333333, 1.35, 0.5
447, 2.1166666666667, 1.35, 0.5
448, 1.2833333333333, 1.35, 0
449, 1.3666666666667, 1.35, 0
450, 1.45, 1.35, 0
451, 1.5333333333333, 1.35, 0
452, 1.6166666666667, 1.35, 0
453, 1.7, 1.35, 0
454, 1.7833333333333, 1.35, 0
455, 1.8666666666667, 1.35, 0
456, 1.95, 1.35, 0
457, 2.0333333333333, 1.35, 0
458, 2.1166666666667, 1.35, 0
459, 1.2, 1.35, 0.083333333333333
460, 1.2, 1.35, 0.16666666666667
461, 1.2, 1.35, 0.25
462, 1.2, 1.35, 0.33333333333333
463, 1.2, 1.35, 0.41666666666667
464, 2.2, 1.35, 0.083333333333333
465, 2.2, 1.35, 0.16666666666667
466, 2.2, 1.35, 0.25
467, 2.2, 1.35, 0.33333333333333
468, 2.2, 1.35, 0.41666666666667
469, 1.2, 1.25, 0.5
470, 1.2, 1.15, 0.5
471, 1.2, 1.05, 0.5
472, 1.2, 0.95, 0.5
473, 1.2, 0.85, 0.5
474, 1.2, 0.75, 0.5
475, 1.2, 0.65, 0.5
476, 1.2, 0.55, 0.5
477, 1.2, 0.45, 0.5
478, 1.2, 0.35, 0.5
479, 1.2, 0.25, 0.5
480, 2.2, 1.25, 0.5
481, 2.2, 1.15, 0.5
482, 2.2, 1.05, 0.5
483, 2.2, 0.95, 0.5
484, 2.2, 0.85, 0.5
485, 2.2, 0.75, 0.5
486, 2.2, 0.65, 0.5
487, 2.2, 0.55, 0.5
488, 2.2, 0.45, 0.5
489, 2.2, 0.35, 0.5
490, 2.2, 0.25, 0.5
491, 1.2833333333333, 0.15, 0.5
492, 1.3666666666667, 0.15, 0.5
493, 1.45, 0.15, 0.5
494, 1.5333333333333, 0.15, 0.5
495, 1.6166666666667, 0.15, 0.5
496, 1.7, 0.15, 0.5
497, 1.7833333333333, 0.15, 0.5
498, 1.8666666666667, 0.15, 0.5
499, 1.95, 0.15, 0.5
500, 2.0333333333333, 0.15, 0.5
501, 2.1166666666667, 0.15, 0.5
502, 1.2, 1.25, 0
503, 1.2, 1.15, 0
504, 1.2, 1.05, 0
505, 1.2, 0.95, 0
506, 1.2, 0.85, 0
507, 1.2, 0.75, 0
508, 1.2, 0.65, 0
509, 1.2, 0.55, 0
510, 1.2, 0.45, 0
511, 1.2, 0.35, 0
512, 1.2, 0.25, 0
513, 2.2, 1.25, 0
514, 2.2, 1.15, 0
515, 2.2, 1.05, 0
516, 2.2, 0.95, 0
517, 2.2, 0.85, 0
518, 2.2, 0.75, 0
519, 2.2, 0.65, 0
520, 2.2, 0.55, 0
521, 2.2, 0.45, 0
522, 2.2, 0.35, 0
523, 2.2, 0.25, 0
524, 1.2833333333333, 0.15, 0
525, 1.3666666666667, 0.15, 0
526, 1.45, 0.15, 0
527, 1.5333333333333, 0.15, 0
528, 1.6166666666667, 0.15, 0
529, 1.7, 0.15, 0
530, 1.7833333333333, 0.15, 0
531, 1.8666666666667, 0.15, 0
532, 1.95, 0.15, 0
533, 2.0333333333333, 0.15, 0
534, 2.1166666666667, 0.15, 0
535, 1.2, 0.15, 0.083333333333333
536, 1.2, 0.15, 0.16666666666667
537, 1.2, 0.15, 0.25
538, 1.2, 0.15, 0.33333333333333
539, 1.2, 0.15, 0.41666666666667
540, 2.2, 0.15, 0.083333333333333
541, 2.2, 0.15, 0.16666666666667
542, 2.2, 0.15, 0.25
543, 2.2, 0.15, 0.33333333333333
544, 2.2, 0.15, 0.41666666666667
545, 1.2833333333333, 0.1, 0.5
546, 1.3666666666667, 0.1, 0.5
547, 1.45, 0.1, 0.5
548, 1.5333333333333, 0.1, 0.5
549, 1.6166666666667, 0.1, 0.5
550, 1.7, 0.1, 0.5
551, 1.7833333333333, 0.1, 0.5
552, 1.8666666666667, 0.1, 0.5
553, 1.95, 0.1, 0.5
554, 2.0333333333333, 0.1, 0.5
555, 2.1166666666667, 0.1, 0.5
556, 1.2833333333333, 0.1, 0
557, 1.3666666666667, 0.1, 0
558, 1.45, 0.1, 0
559, 1.5333333333333, 0.1, 0
560, 1.6166666666667, 0.1, 0
561, 1.7, 0.1, 0
562, 1.7833333333333, 0.1, 0
563, 1.8666666666667, 0.1, 0
564, 1.95, 0.1, 0
565, 2.0333333333333, 0.1, 0
566, 2.1166666666667, 0.1, 0
567, 1.2, 0.1, 0.083333333333333
568, 1.2, 0.1, 0.16666666666667
569, 1.2, 0.1, 0.25
570, 1.2, 0.1, 0.33333333333333
571, 1.2, 0.1, 0.41666666666667
572, 2.2, 0.1, 0.083333333333333
573, 2.2, 0.1, 0.16666666666667
574, 2.2, 0.1, 0.25
575, 2.2, 0.1, 0.33333333333333
576, 2.2, 0.1, 0.41666666666667
577, 1.2, 0.066666666666667, 0.5
578, 1.2, 0.033333333333333, 0.5
579, 2.2, 0.066666666666667, 0.5
580, 2.2, 0.033333333333333, 0.5
581, 1.2833333333333, 1.2490009027033e-16, 0.5
582, 1.3666666666667, 1.2490009027033e-16, 0.5
583, 1.45, 1.2490009027033e-16, 0.5
584, 1.5333333333333, 1.2490009027033e-16, 0.5
585, 1.6166666666667, 1.2490009027033e-16, 0.5
586, 1.7, 1.2490009027033e-16, 0.5
587, 1.7833333333333, 1.2490009027033e-16, 0.5
588, 1.8666666666667, 1.2490009027033e-16, 0.5
589, 1.95, 1.2490009027033e-16, 0.5
590, 2.0333333333333, 1.2490009027033e-16, 0.5
591, 2.1166666666667, 1.2490009027033e-16, 0.5
592, 1.2, 0.066666666666667, 0
593, 1.2, 0.033333333333333, 0
594, 2.2, 0.066666666666667, 0
595, 2.2, 0.033333333333333, 0
596, 1.2833333333333, 1.2490009027033e-16, 0
597, 1.3666666666667, 1.2490009027033e-16, 0
598, 1.45, 1.2490009027033e-16, 0
599, 1.5333333333333, 1.2490009027033e-16, 0
600, 1.6166666666667, 1.2490009027033e-16, 0
601, 1.7, 1.2490009027033e-16, 0
602, 1.7833333333333, 1.2490009027033e-16, 0
603, 1.8666666666667, 1.2490009027033e-16, 0
604, 1.95, 1.2490009027033e-16, 0
605, 2.0333333333333, 1.2490009027033e-16, 0
606, 2.1166666666667, 1.2490009027033e-16, 0
607, 1.2, 1.2490009027033e-16, 0.083333333333333
608, 1.2, 1.2490009027033e-16, 0.16666666666667
609, 1.2, 1.2490009027033e-16, 0.25
610, 1.2, 1.2490009027033e-16, 0.33333333333333
611, 1.2, 1.2490009027033e-16, 0.41666666666667
612, 2.2, 1.2490009027033e-16, 0.083333333333333
613, 2.2, 1.2490009027033e-16, 0.16666666666667
614, 2.2, 1.2490009027033e-16, 0.25
615, 2.2, 1.2490009027033e-16, 0.33333333333333
616, 2.2, 1.2490009027033e-16, 0.41666666666667
617, 2.3, 0.066666666666667, 0.5
618, 2.3, 0.033333333333333, 0.5
619, 2.3, 0.066666666666667, 0
620, 2.3, 0.033333333333333, 0
621, 2.3, 0.1, 0.083333333333333
622, 2.3, 0.1, 0.16666666666667
623, 2.3, 0.1, 0.25
624, 2.3, 0.1, 0.33333333333333
625, 2.3, 0.1, 0.41666666666667
626, 2.3, 1.2490009027033e-16, 0.083333333333333
627, 2.3, 1.2490009027033e-16, 0.16666666666667
628, 2.3, 1.2490009027033e-16, 0.25
629, 2.3, 1.2490009027033e-16, 0.33333333333333
630, 2.3, 1.2490009027033e-16, 0.41666666666667
631, -0.1, 0, 0.083333333333333
632, -0.1, 0, 0.16666666666667
633, -0.1, 0, 0.25
634, -0.1, 0, 0.33333333333333
635, -0.1, 0, 0.41666666666667
636, -0.1, 0.033333333333333, 0.5
637, -0.1, 0.066666666666667, 0.5
638, -0.1, 0.1, 0.083333333333333
639, -0.1, 0.1, 0.16666666666667
640, -0.1, 0.1, 0.25
641, -0.1, 0.1, 0.33333333333333
642, -0.1, 0.1, 0.41666666666667
643, -0.1, 0.033333333333333, 0
644, -0.1, 0.066666666666667, 0
645, 1.05, 0.25, 0.5
646, 1.05, 0.35, 0.5
647, 1.05, 0.45, 0.5
648, 1.05, 0.55, 0.5
649, 1.05, 0.65, 0.5
650, 1.05, 0.75, 0.5
651, 1.05, 0.85, 0.5
652, 1.05, 0.95, 0.5
653, 1.05, 1.05, 0.5
654, 1.05, 1.15, 0.5
655, 1.05, 1.25, 0.5
656, 1.05, 0.25, 0
657, 1.05, 0.35, 0
658, 1.05, 0.45, 0
659, 1.05, 0.55, 0
660, 1.05, 0.65, 0
661, 1.05, 0.75, 0
662, 1.05, 0.85, 0
663, 1.05, 0.95, 0
664, 1.05, 1.05, 0
665, 1.05, 1.15, 0
666, 1.05, 1.25, 0
667, 1.05, 0.15, 0.083333333333333
668, 1.05, 0.15, 0.16666666666667
669, 1.05, 0.15, 0.25
670, 1.05, 0.15, 0.33333333333333
671, 1.05, 0.15, 0.41666666666667
672, 1.05, 1.35, 0.083333333333333
673, 1.05, 1.35, 0.16666666666667
674, 1.05, 1.35, 0.25
675, 1.05, 1.35, 0.33333333333333
676, 1.05, 1.35, 0.41666666666667
677, 1.15, 1.25, 0.5
678, 1.15, 1.15, 0.5
679, 1.15, 1.05, 0.5
680, 1.15, 0.95, 0.5
681, 1.15, 0.85, 0.5
682, 1.15, 0.75, 0.5
683, 1.15, 0.65, 0.5
684, 1.15, 0.55, 0.5
685, 1.15, 0.45, 0.5
686, 1.15, 0.35, 0.5
687, 1.15, 0.25, 0.5
688, 1.15, 1.25, 0
689, 1.15, 1.15, 0
690, 1.15, 1.05, 0
691, 1.15, 0.95, 0
692, 1.15, 0.85, 0
693, 1.15, 0.75, 0
694, 1.15, 0.65, 0
695, 1.15, 0.55, 0
696, 1.15, 0.45, 0
697, 1.15, 0.35, 0
698, 1.15, 0.25, 0
699, 1.15, 1.35, 0.083333333333333
700, 1.15, 1.35, 0.16666666666667
701, 1.15, 1.35, 0.25
702, 1.15, 1.35, 0.33333333333333
703, 1.15, 1.35, 0.41666666666667
704, 1.15, 0.15, 0.083333333333333
705, 1.15, 0.15, 0.16666666666667
706, 1.15, 0.15, 0.25
707, 1.15, 0.15, 0.33333333333333
708, 1.15, 0.15, 0.41666666666667
709, 1, 0.25, -0.1
710, 1, 0.35, -0.1
711, 1, 0.45, -0.1
712, 1, 0.55, -0.1
713, 1, 0.65, -0.1
714, 1, 0.75, -0.1
715, 1, 0.85, -0.1
716, 1, 0.95, -0.1
717, 1, 1.05, -0.1
718, 1, 1.15, -0.1
719, 1, 1.25, -0.1
720, 0, 0.25, -0.1
721, 0, 0.35, -0.1
722, 0, 0.45, -0.1
723, 0, 0.55, -0.1
724, 0, 0.65, -0.1
725, 0, 0.75, -0.1
726, 0, 0.85, -0.1
727, 0, 0.95, -0.1
728, 0, 1.05, -0.1
729, 0, 1.15, -0.1
730, 0, 1.25, -0.1
731, 0.083333333333333, 0.15, -0.1
732, 0.16666666666667, 0.15, -0.1
733, 0.25, 0.15, -0.1
734, 0.33333333333333, 0.15, -0.1
735, 0.41666666666667, 0.15, -0.1
736, 0.5, 0.15, -0.1
737, 0.58333333333333, 0.15, -0.1
738, 0.66666666666667, 0.15, -0.1
739, 0.75, 0.15, -0.1
740, 0.83333333333333, 0.15, -0.1
741, 0.91666666666667, 0.15, -0.1
742, 0.083333333333333, 1.35, -0.1
743, 0.16666666666667, 1.35, -0.1
744, 0.25, 1.35, -0.1
745, 0.33333333333333, 1.35, -0.1
746, 0.41666666666667, 1.35, -0.1
747, 0.5, 1.35, -0.1
748, 0.58333333333333, 1.35, -0.1
749, 0.66666666666667, 1.35, -0.1
750, 0.75, 1.35, -0.1
751, 0.83333333333333, 1.35, -0.1
752, 0.91666666666667, 1.35, -0.1
753, 1.2, 1.25, -0.1
754, 1.2, 1.15, -0.1
755, 1.2, 1.05, -0.1
756, 1.2, 0.95, -0.1
757, 1.2, 0.85, -0.1
758, 1.2, 0.75, -0.1
759, 1.2, 0.65, -0.1
760, 1.2, 0.55, -0.1
761, 1.2, 0.45, -0.1
762, 1.2, 0.35, -0.1
763, 1.2, 0.25, -0.1
764, 2.2, 1.25, -0.1
765, 2.2, 1.15, -0.1
766, 2.2, 1.05, -0.1
767, 2.2, 0.95, -0.1
768, 2.2, 0.85, -0.1
769, 2.2, 0.75, -0.1
770, 2.2, 0.65, -0.1
771, 2.2, 0.55, -0.1
772, 2.2, 0.45, -0.1
773, 2.2, 0.35, -0.1
774, 2.2, 0.25, -0.1
775, 1.2833333333333, 1.35, -0.1
776, 1.3666666666667, 1.35, -0.1
777, 1.45, 1.35, -0.1
778, 1.5333333333333, 1.35, -0.1
779, 1.6166666666667, 1.35, -0.1
780, 1.7, 1.35, -0.1
781, 1.7833333333333, 1.35, -0.1
782, 1.8666666666667, 1.35, -0.1
783, 1.95, 1.35, -0.1
784, 2.0333333333333, 1.35, -0.1
785, 2.1166666666667, 1.35, -0.1
786, 1.2833333333333, 0.15, -0.1
787, 1.3666666666667, 0.15, -0.1
788, 1.45, 0.15, -0.1
789, 1.5333333333333, 0.15, -0.1
790, 1.6166666666667, 0.15, -0.1
791, 1.7, 0.15, -0.1
792, 1.7833333333333, 0.15, -0.1
793, 1.8666666666667, 0.15, -0.1
794, 1.95, 0.15, -0.1
795, 2.0333333333333, 0.15, -0.1
796, 2.1166666666667, 0.15, -0.1
797, 1.15, 1.25, -0.1
798, 1.15, 1.15, -0.1
799, 1.15, 1.05, -0.1
800, 1.15, 0.95, -0.1
801, 1.15, 0.85, -0.1
802, 1.15, 0.75, -0.1
803, 1.15, 0.65, -0.1
804, 1.15, 0.55, -0.1
805, 1.15, 0.45, -0.1
806, 1.15, 0.35, -0.1
807, 1.15, 0.25, -0.1
808, 1.05, 0.25, -0.1
809, 1.05, 0.35, -0.1
810, 1.05, 0.45, -0.1
811, 1.05, 0.55, -0.1
812, 1.05, 0.65, -0.1
813, 1.05, 0.75, -0.1
814, 1.05, 0.85, -0.1
815, 1.05, 0.95, -0.1
816, 1.05, 1.05, -0.1
817, 1.05, 1.15, -0.1
818, 1.05, 1.25, -0.1
819, 1, 1.54, 0
820, 1, 1.58, 0
821, 1, 1.62, 0
822, 1, 1.66, 0
823, 0, 1.54, 0
824, 0, 1.58, 0
825, 0, 1.62, 0
826, 0, 1.66, 0
827, 0.083333333333333, 1.7, 0
828, 0.16666666666667, 1.7, 0
829, 0.25, 1.7, 0
830, 0.33333333333333, 1.7, 0
831, 0.41666666666667, 1.7, 0
832, 0.5, 1.7, 0
833, 0.58333333333333, 1.7, 0
834, 0.66666666666667, 1.7, 0
835, 0.75, 1.7, 0
836, 0.83333333333333, 1.7, 0
837, 0.91666666666667, 1.7, 0
838, 1, 1.54, 0.5
839, 1, 1.58, 0.5
840, 1, 1.62, 0.5
841, 1, 1.66, 0.5
842, 1, 1.7, 0.083333333333333
843, 1, 1.7, 0.16666666666667
844, 1, 1.7, 0.25
845, 1, 1.7, 0.33333333333333
846, 1, 1.7, 0.41666666666667
847, 0, 1.54, 0.5
848, 0, 1.58, 0.5
849, 0, 1.62, 0.5
850, 0, 1.66, 0.5
851, 0.083333333333333, 1.7, 0.5
852, 0.16666666666667, 1.7, 0.5
853, 0.25, 1.7, 0.5
854, 0.33333333333333, 1.7, 0.5
855, 0.41666666666667, 1.7, 0.5
856, 0.5, 1.7, 0.5
857, 0.58333333333333, 1.7, 0.5
858, 0.66666666666667, 1.7, 0.5
859, 0.75, 1.7, 0.5
860, 0.83333333333333, 1.7, 0.5
861, 0.91666666666667, 1.7, 0.5
862, 0, 1.7, 0.083333333333333
863, 0, 1.7, 0.16666666666667
864, 0, 1.7, 0.25
865, 0, 1.7, 0.33333333333333
866, 0, 1.7, 0.41666666666667
867, 1.2, 1.54, 0.5
868, 1.2, 1.58, 0.5
869, 1.2, 1.62, 0.5
870, 1.2, 1.66, 0.5
871, 1.04, 1.7, 0.5
872, 1.08, 1.7, 0.5
873, 1.12, 1.7, 0.5
874, 1.16, 1.7, 0.5
875, 1.2, 1.54, 0
876, 1.2, 1.58, 0
877, 1.2, 1.62, 0
878, 1.2, 1.66, 0
879, 1.04, 1.7, 0
880, 1.08, 1.7, 0
881, 1.12, 1.7, 0
882, 1.16, 1.7, 0
883, 1.2, 1.7, 0.083333333333333
884, 1.2, 1.7, 0.16666666666667
885, 1.2, 1.7, 0.25
886, 1.2, 1.7, 0.33333333333333
887, 1.2, 1.7, 0.41666666666667
888, 2.2, 1.54, 0.5
889, 2.2, 1.58, 0.5
890, 2.2, 1.62, 0.5
891, 2.2, 1.66, 0.5
892, 1.2833333333333, 1.7, 0.5
893, 1.3666666666667, 1.7, 0.5
894, 1.45, 1.7, 0.5
895, 1.5333333333333, 1.7, 0.5
896, 1.6166666666667, 1.7, 0.5
897, 1.7, 1.7, 0.5
898, 1.7833333333333, 1.7, 0.5
899, 1.8666666666667, 1.7, 0.5
900, 1.95, 1.7, 0.5
901, 2.0333333333333, 1.7, 0.5
902, 2.1166666666667, 1.7, 0.5
903, 2.2, 1.54, 0
904, 2.2, 1.58, 0
905, 2.2, 1.62, 0
906, 2.2, 1.66, 0
907, 1.2833333333333, 1.7, 0
908, 1.3666666666667, 1.7, 0
909, 1.45, 1.7, 0
910, 1.5333333333333, 1.7, 0
911, 1.6166666666667, 1.7, 0
912, 1.7, 1.7, 0
913, 1.7833333333333, 1.7, 0
914, 1.8666666666667, 1.7, 0
915, 1.95, 1.7, 0
916, 2.0333333333333, 1.7, 0
917, 2.1166666666667, 1.7, 0
918, 2.2, 1.7, 0.083333333333333
919, 2.2, 1.7, 0.16666666666667
920, 2.2, 1.7, 0.25
921, 2.2, 1.7, 0.33333333333333
922, 2.2, 1.7, 0.41666666666667
923, 1, -0.04, 0
924, 1, -0.08, 0
925, 1, -0.12, 0
926, 1, -0.16, 0
927, 0, -0.04, 0
928, 0, -0.08, 0
929, 0, -0.12, 0
930, 0, -0.16, 0
931, 0.083333333333333, -0.2, 0
932, 0.16666666666667, -0.2, 0
933, 0.25, -0.2, 0
934, 0.33333333333333, -0.2, 0
935, 0.41666666666667, -0.2, 0
936, 0.5, -0.2, 0
937, 0.58333333333333, -0.2, 0
938, 0.66666666666667, -0.2, 0
939, 0.75, -0.2, 0
940, 0.83333333333333, -0.2, 0
941, 0.91666666666667, -0.2, 0
942, 1, -0.04, 0.5
943, 1, -0.08, 0.5
944, 1, -0.12, 0.5
945, 1, -0.16, 0.5
946, 1, -0.2, 0.083333333333333
947, 1, -0.2, 0.16666666666667
948, 1, -0.2, 0.25
949, 1, -0.2, 0.33333333333333
950, 1, -0.2, 0.41666666666667
951, 0, -0.04, 0.5
952, 0, -0.08, 0.5
953, 0, -0.12, 0.5
954, 0, -0.16, 0.5
955, 0.083333333333333, -0.2, 0.5
956, 0.16666666666667, -0.2, 0.5
957, 0.25, -0.2, 0.5
958, 0.33333333333333, -0.2, 0.5
959, 0.41666666666667, -0.2, 0.5
960, 0.5, -0.2, 0.5
961, 0.58333333333333, -0.2, 0.5
962, 0.66666666666667, -0.2, 0.5
963, 0.75, -0.2, 0.5
964, 0.83333333333333, -0.2, 0.5
965, 0.91666666666667, -0.2, 0.5
966, 0, -0.2, 0.083333333333333
967, 0, -0.2, 0.16666666666667
968, 0, -0.2, 0.25
969, 0, -0.2, 0.33333333333333
970, 0, -0.2, 0.41666666666667
971, -0.1, -0.04, 0.5
972, -0.1, -0.08, 0.5
973, -0.1, -0.12, 0.5
974, -0.1, -0.16, 0.5
975, -0.1, -0.04, 0
976, -0.1, -0.08, 0
977, -0.1, -0.12, 0
978, -0.1, -0.16, 0
979, -0.1, -0.2, 0.083333333333333
980, -0.1, -0.2, 0.16666666666667
981, -0.1, -0.2, 0.25
982, -0.1, -0.2, 0.33333333333333
983, -0.1, -0.2, 0.41666666666667
984, 1.2, -0.04, 0.5
985, 1.2, -0.08, 0.5
986, 1.2, -0.12, 0.5
987, 1.2, -0.16, 0.5
988, 2.2, -0.04, 0.5
989, 2.2, -0.08, 0.5
990, 2.2, -0.12, 0.5
991, 2.2, -0.16, 0.5
992, 1.2833333333333, -0.2, 0.5
993, 1.3666666666667, -0.2, 0.5
994, 1.45, -0.2, 0.5
995, 1.5333333333333, -0.2, 0.5
996, 1.6166666666667, -0.2, 0.5
997, 1.7, -0.2, 0.5
998, 1.7833333333333, -0.2, 0.5
999, 1.8666666666667, -0.2, 0.5
1000, 1.95, -0.2, 0.5
1001, 2.0333333333333, -0.2, 0.5
1002, 2.1166666666667, -0.2, 0.5
1003, 1.2, -0.04, 0
1004, 1.2, -0.08, 0
1005, 1.2, -0.12, 0
1006, 1.2, -0.16, 0
1007, 2.2, -0.04, 0
1008, 2.2, -0.08, 0
1009, 2.2, -0.12, 0
1010, 2.2, -0.16, 0
1011, 1.2833333333333, -0.2, 0
1012, 1.3666666666667, -0.2, 0
1013, 1.45, -0.2, 0
1014, 1.5333333333333, -0.2, 0
1015, 1.6166666666667, -0.2, 0
1016, 1.7, -0.2, 0
1017, 1.7833333333333, -0.2, 0
1018, 1.8666666666667, -0.2, 0
1019, 1.95, -0.2, 0
1020, 2.0333333333333, -0.2, 0
1021, 2.1166666666667, -0.2, 0
1022, 1.2, -0.2, 0.083333333333333
1023, 1.2, -0.2, 0.16666666666667
1024, 1.2, -0.2, 0.25
1025, 1.2, -0.2, 0.33333333333333
1026, 1.2, -0.2, 0.41666666666667
1027, 2.2, -0.2, 0.083333333333333
1028, 2.2, -0.2, 0.16666666666667
1029, 2.2, -0.2, 0.25
1030, 2.2, -0.2, 0.33333333333333
1031, 2.2, -0.2, 0.41666666666667
1032, 2.3, -0.04, 0.5
1033, 2.3, -0.08, 0.5
1034, 2.3, -0.12, 0.5
1035, 2.3, -0.16, 0.5
1036, 2.3, -0.04, 0
1037, 2.3, -0.08, 0
1038, 2.3, -0.12, 0
1039, 2.3, -0.16, 0
1040, 2.3, -0.2, 0.083333333333333
1041, 2.3, -0.2, 0.16666666666667
1042, 2.3, -0.2, 0.25
1043, 2.3, -0.2, 0.33333333333333
1044, 2.3, -0.2, 0.41666666666667
1045, 0, 0.033333333333333, 0.083333333333333
1046, 0, 0.066666666666667, 0.083333333333333
1047, 0, 0.033333333333333, 0.16666666666667
1048, 0, 0.066666666666667, 0.16666666666667
1049, 0, 0.033333333333333, 0.25
1050, 0, 0.066666666666667, 0.25
1051, 0, 0.033333333333333, 0.33333333333333
1052, 0, 0.066666666666667, 0.33333333333333
1053, 0, 0.033333333333333, 0.41666666666667
1054, 0, 0.066666666666667, 0.41666666666667
1055, 1, 0.033333333333333, 0.083333333333333
1056, 1, 0.066666666666667, 0.083333333333333
1057, 1, 0.033333333333333, 0.16666666666667
1058, 1, 0.066666666666667, 0.16666666666667
1059, 1, 0.033333333333333, 0.25
1060, 1, 0.066666666666667, 0.25
1061, 1, 0.033333333333333, 0.33333333333333
1062, 1, 0.066666666666667, 0.33333333333333
1063, 1, 0.033333333333333, 0.41666666666667
1064, 1, 0.066666666666667, 0.41666666666667
1065, 0.083333333333333, 0, 0.083333333333333
1066, 0.083333333333333, 0, 0.16666666666667
1067, 0.083333333333333, 0, 0.25
1068, 0.083333333333333, 0, 0.33333333333333
1069, 0.083333333333333, 0, 0.41666666666667
1070, 0.16666666666667, 0, 0.083333333333333
1071, 0.16666666666667, 0, 0.16666666666667
1072, 0.16666666666667, 0, 0.25
1073, 0.16666666666667, 0, 0.33333333333333
1074, 0.16666666666667, 0, 0.41666666666667
1075, 0.25, 0, 0.083333333333333
1076, 0.25, 0, 0.16666666666667
1077, 0.25, 0, 0.25
1078, 0.25, 0, 0.33333333333333
1079, 0.25, 0, 0.41666666666667
1080, 0.33333333333333, 0, 0.083333333333333
1081, 0.33333333333333, 0, 0.16666666666667
1082, 0.33333333333333, 0, 0.25
1083, 0.33333333333333, 0, 0.33333333333333
1084, 0.33333333333333, 0, 0.41666666666667
1085, 0.41666666666667, 0, 0.083333333333333
1086, 0.41666666666667, 0, 0.16666666666667
1087, 0.41666666666667, 0, 0.25
1088, 0.41666666666667, 0, 0.33333333333333
1089, 0.41666666666667, 0, 0.41666666666667
1090, 0.5, 0, 0.083333333333333
1091, 0.5, 0, 0.16666666666667
1092, 0.5, 0, 0.25
1093, 0.5, 0, 0.33333333333333
1094, 0.5, 0, 0.41666666666667
1095, 0.58333333333333, 0, 0.083333333333333
1096, 0.58333333333333, 0, 0.16666666666667
1097, 0.58333333333333, 0, 0.25
1098, 0.58333333333333, 0, 0.33333333333333
1099, 0.58333333333333, 0, 0.41666666666667
1100, 0.66666666666667, 0, 0.083333333333333
1101, 0.66666666666667, 0, 0.16666666666667
1102, 0.66666666666667, 0, 0.25
1103, 0.66666666666667, 0, 0.33333333333333
1104, 0.66666666666667, 0, 0.41666666666667
1105, 0.75, 0, 0.083333333333333
1106, 0.75, 0, 0.16666666666667
1107, 0.75, 0, 0.25
1108, 0.75, 0, 0.33333333333333
1109, 0.75, 0, 0.41666666666667
1110, 0.83333333333333, 0, 0.083333333333333
1111, 0.83333333333333, 0, 0.16666666666667
1112, 0.83333333333333, 0, 0.25
1113, 0.83333333333333, 0, 0.33333333333333
1114, 0.83333333333333, 0, 0.41666666666667
1115, 0.91666666666667, 0, 0.083333333333333
1116, 0.91666666666667, 0, 0.16666666666667
1117, 0.91666666666667, 0, 0.25
1118, 0.91666666666667, 0, 0.33333333333333
1119, 0.91666666666667, 0, 0.41666666666667
1120, 0.083333333333333, 0.1, 0.083333333333333
1121, 0.083333333333333, 0.1, 0.16666666666667
1122, 0.083333333333333, 0.1, 0.25
1123, 0.083333333333333, 0.1, 0.33333333333333
1124, 0.083333333333333, 0.1, 0.41666666666667
1125, 0.16666666666667, 0.1, 0.083333333333333
1126, 0.16666666666667, 0.1, 0.16666666666667
1127, 0.16666666666667, 0.1, 0.25
1128, 0.16666666666667, 0.1, 0.33333333333333
1129, 0.16666666666667, 0.1, 0.41666666666667
1130, 0.25, 0.1, 0.083333333333333
1131, 0.25, 0.1, 0.16666666666667
1132, 0.25, 0.1, 0.25
1133, 0.25, 0.1, 0.33333333333333
1134, 0.25, 0.1, 0.41666666666667
1135, 0.33333333333333, 0.1, 0.083333333333333
1136, 0.33333333333333, 0.1, 0.16666666666667
1137, 0.33333333333333, 0.1, 0.25
1138, 0.33333333333333, 0.1, 0.33333333333333
1139, 0.33333333333333, 0.1, 0.41666666666667
1140, 0.41666666666667, 0.1, 0.083333333333333
1141, 0.41666666666667, 0.1, 0.16666666666667
1142, 0.41666666666667, 0.1, 0.25
1143, 0.41666666666667, 0.1, 0.33333333333333
1144, 0.41666666666667, 0.1, 0.41666666666667
1145, 0.5, 0.1, 0.083333333333333
1146, 0.5, 0.1, 0.16666666666667
1147, 0.5, 0.1, 0.25
1148, 0.5, 0.1, 0.33333333333333
1149, 0.5, 0.1, 0.41666666666667
1150, 0.58333333333333, 0.1, 0.083333333333333
1151, 0.58333333333333, 0.1, 0.16666666666667
1152, 0.58333333333333, 0.1, 0.25
1153, 0.58333333333333, 0.1, 0.33333333333333
1154, 0.58333333333333, 0.1, 0.41666666666667
1155, 0.66666666666667, 0.1, 0.083333333333333
1156, 0.66666666666667, 0.1, 0.16666666666667
1157, 0.66666666666667, 0.1, 0.25
1158, 0.66666666666667, 0.1, 0.33333333333333
1159, 0.66666666666667, 0.1, 0.41666666666667
1160, 0.75, 0.1, 0.083333333333333
1161, 0.75, 0.1, 0.16666666666667
1162, 0.75, 0.1, 0.25
1163, 0.75, 0.1, 0.33333333333333
1164, 0.75, 0.1, 0.41666666666667
1165, 0.83333333333333, 0.1, 0.083333333333333
1166, 0.83333333333333, 0.1, 0.16666666666667
1167, 0.83333333333333, 0.1, 0.25
1168, 0.83333333333333, 0.1, 0.33333333333333
1169, 0.83333333333333, 0.1, 0.41666666666667
1170, 0.91666666666667, 0.1, 0.083333333333333
1171, 0.91666666666667, 0.1, 0.16666666666667
1172, 0.91666666666667, 0.1, 0.25
1173, 0.91666666666667, 0.1, 0.33333333333333
1174, 0.91666666666667, 0.1, 0.41666666666667
1175, 0.083333333333333, 0.033333333333333, 0
1176, 0.16666666666667, 0.033333333333333, 0
1177, 0.25, 0.033333333333333, 0
1178, 0.33333333333333, 0.033333333333333, 0
1179, 0.41666666666667, 0.033333333333333, 0
1180, 0.5, 0.033333333333333, 0
1181, 0.58333333333333, 0.033333333333333, 0
1182, 0.66666666666667, 0.033333333333333, 0
1183, 0.75, 0.033333333333333, 0
1184, 0.83333333333333, 0.033333333333333, 0
1185, 0.91666666666667, 0.033333333333333, 0
1186, 0.083333333333333, 0.066666666666667, 0
1187, 0.16666666666667, 0.066666666666667, 0
1188, 0.25, 0.066666666666667, 0
1189, 0.33333333333333, 0.066666666666667, 0
1190, 0.41666666666667, 0.066666666666667, 0
1191, 0.5, 0.066666666666667, 0
1192, 0.58333333333333, 0.066666666666667, 0
1193, 0.66666666666667, 0.066666666666667, 0
1194, 0.75, 0.066666666666667, 0
1195, 0.83333333333333, 0.066666666666667, 0
1196, 0.91666666666667, 0.066666666666667, 0
1197, 0.083333333333333, 0.033333333333333, 0.5
1198, 0.16666666666667, 0.033333333333333, 0.5
1199, 0.25, 0.033333333333333, 0.5
1200, 0.33333333333333, 0.033333333333333, 0.5
1201, 0.41666666666667, 0.033333333333333, 0.5
1202, 0.5, 0.033333333333333, 0.5
1203, 0.58333333333333, 0.033333333333333, 0.5
1204, 0.66666666666667, 0.033333333333333, 0.5
1205, 0.75, 0.033333333333333, 0.5
1206, 0.83333333333333, 0.033333333333333, 0.5
1207, 0.91666666666667, 0.033333333333333, 0.5
1208, 0.083333333333333, 0.066666666666667, 0.5
1209, 0.16666666666667, 0.066666666666667, 0.5
1210, 0.25, 0.066666666666667, 0.5
1211, 0.33333333333333, 0.066666666666667, 0.5
1212, 0.41666666666667, 0.066666666666667, 0.5
1213, 0.5, 0.066666666666667, 0.5
1214, 0.58333333333333, 0.066666666666667, 0.5
1215, 0.66666666666667, 0.066666666666667, 0.5
1216, 0.75, 0.066666666666667, 0.5
1217, 0.83333333333333, 0.066666666666667, 0.5
1218, 0.91666666666667, 0.066666666666667, 0.5
1219, 0.083333333333333, 0.15, 0.083333333333333
1220, 0.083333333333333, 0.15, 0.16666666666667
1221, 0.083333333333333, 0.15, 0.25
1222, 0.083333333333333, 0.15, 0.33333333333333
1223, 0.083333333333333, 0.15, 0.41666666666667
1224, 0.16666666666667, 0.15, 0.083333333333333
1225, 0.16666666666667, 0.15, 0.16666666666667
1226, 0.16666666666667, 0.15, 0.25
1227, 0.16666666666667, 0.15, 0.33333333333333
1228, 0.16666666666667, 0.15, 0.41666666666667
1229, 0.25, 0.15, 0.083333333333333
1230, 0.25, 0.15, 0.16666666666667
1231, 0.25, 0.15, 0.25
1232, 0.25, 0.15, 0.33333333333333
1233, 0.25, 0.15, 0.41666666666667
1234, 0.33333333333333, 0.15, 0.083333333333333
1235, 0.33333333333333, 0.15, 0.16666666666667
1236, 0.33333333333333, 0.15, 0.25
1237, 0.33333333333333, 0.15, 0.33333333333333
1238, 0.33333333333333, 0.15, 0.41666666666667
1239, 0.41666666666667, 0.15, 0.083333333333333
1240, 0.41666666666667, 0.15, 0.16666666666667
1241, 0.41666666666667, 0.15, 0.25
1242, 0.41666666666667, 0.15, 0.33333333333333
1243, 0.41666666666667, 0.15, 0.41666666666667
1244, 0.5, 0.15, 0.083333333333333
1245, 0.5, 0.15, 0.16666666666667
1246, 0.5, 0.15, 0.25
1247, 0.5, 0.15, 0.33333333333333
1248, 0.5, 0.15, 0.41666666666667
1249, 0.58333333333333, 0.15, 0.083333333333333
1250, 0.58333333333333, 0.15, 0.16666666666667
1251, 0.58333333333333, 0.15, 0.25
1252, 0.58333333333333, 0.15, 0.33333333333333
1253, 0.58333333333333, 0.15, 0.41666666666667
1254, 0.66666666666667, 0.15, 0.083333333333333
1255, 0.66666666666667, 0.15, 0.16666666666667
1256, 0.66666666666667, 0.15, 0.25
1257, 0.66666666666667, 0.15, 0.33333333333333
1258, 0.66666666666667, 0.15, 0.41666666666667
1259, 0.75, 0.15, 0.083333333333333
1260, 0.75, 0.15, 0.16666666666667
1261, 0.75, 0.15, 0.25
1262, 0.75, 0.15, 0.33333333333333
1263, 0.75, 0.15, 0.41666666666667
1264, 0.83333333333333, 0.15, 0.083333333333333
1265, 0.83333333333333, 0.15, 0.16666666666667
1266, 0.83333333333333, 0.15, 0.25
1267, 0.83333333333333, 0.15, 0.33333333333333
1268, 0.83333333333333, 0.15, 0.41666666666667
1269, 0.91666666666667, 0.15, 0.083333333333333
1270, 0.91666666666667, 0.15, 0.16666666666667
1271, 0.91666666666667, 0.15, 0.25
1272, 0.91666666666667, 0.15, 0.33333333333333
1273, 0.91666666666667, 0.15, 0.41666666666667
1274, 0.083333333333333, 0.25, 0
1275, 0.083333333333333, 0.35, 0
1276, 0.083333333333333, 0.45, 0
1277, 0.083333333333333, 0.55, 0
1278, 0.083333333333333, 0.65, 0
1279, 0.083333333333333, 0.75, 0
1280, 0.083333333333333, 0.85, 0
1281, 0.083333333333333, 0.95, 0
1282, 0.083333333333333, 1.05, 0
1283, 0.083333333333333, 1.15, 0
1284, 0.083333333333333, 1.25, 0
1285, 0.16666666666667, 0.25, 0
1286, 0.16666666666667, 0.35, 0
1287, 0.16666666666667, 0.45, 0
1288, 0.16666666666667, 0.55, 0
1289, 0.16666666666667, 0.65, 0
1290, 0.16666666666667, 0.75, 0
1291, 0.16666666666667, 0.85, 0
1292, 0.16666666666667, 0.95, 0
1293, 0.16666666666667, 1.05, 0
1294, 0.16666666666667, 1.15, 0
1295, 0.16666666666667, 1.25, 0
1296, 0.25, 0.25, 0
1297, 0.25, 0.35, 0
1298, 0.25, 0.45, 0
1299, 0.25, 0.55, 0
1300, 0.25, 0.65, 0
1301, 0.25, 0.75, 0
1302, 0.25, 0.85, 0
1303, 0.25, 0.95, 0
1304, 0.25, 1.05, 0
1305, 0.25, 1.15, 0
1306, 0.25, 1.25, 0
1307, 0.33333333333333, 0.25, 0
1308, 0.33333333333333, 0.35, 0
1309, 0.33333333333333, 0.45, 0
1310, 0.33333333333333, 0.55, 0
1311, 0.33333333333333, 0.65, 0
1312, 0.33333333333333, 0.75, 0
1313, 0.33333333333333, 0.85, 0
1314, 0.33333333333333, 0.95, 0
1315, 0.33333333333333, 1.05, 0
1316, 0.33333333333333, 1.15, 0
1317, 0.33333333333333, 1.25, 0
1318, 0.41666666666667, 0.25, 0
1319, 0.41666666666667, 0.35, 0
1320, 0.41666666666667, 0.45, 0
1321, 0.41666666666667, 0.55, 0
1322, 0.41666666666667, 0.65, 0
1323, 0.41666666666667, 0.75, 0
1324, 0.41666666666667, 0.85, 0
1325, 0.41666666666667, 0.95, 0
1326, 0.41666666666667, 1.05, 0
1327, 0.41666666666667, 1.15, 0
1328, 0.41666666666667, 1.25, 0
1329, 0.5, 0.25, 0
1330, 0.5, 0.35, 0
1331, 0.5, 0.45, 0
1332, 0.5, 0.55, 0
1333, 0.5, 0.65, 0
1334, 0.5, 0.75, 0
1335, 0.5, 0.85, 0
1336, 0.5, 0.95, 0
1337, 0.5, 1.05, 0
1338, 0.5, 1.15, 0
1339, 0.5, 1.25, 0
1340, 0.58333333333333, 0.25, 0
1341, 0.58333333333333, 0.35, 0
1342, 0.58333333333333, 0.45, 0
1343, 0.58333333333333, 0.55, 0
1344, 0.58333333333333, 0.65, 0
1345, 0.58333333333333, 0.75, 0
1346, 0.58333333333333, 0.85, 0
1347, 0.58333333333333, 0.95, 0
1348, 0.58333333333333, 1.05, 0
1349, 0.58333333333333, 1.15, 0
1350, 0.58333333333333, 1.25, 0
1351, 0.66666666666667, 0.25, 0
1352, 0.66666666666667, 0.35, 0
1353, 0.66666666666667, 0.45, 0
1354, 0.66666666666667, 0.55, 0
1355, 0.66666666666667, 0.65, 0
1356, 0.66666666666667, 0.75, 0
1357, 0.66666666666667, 0.85, 0
1358, 0.66666666666667, 0.95, 0
1359, 0.66666666666667, 1.05, 0
1360, 0.66666666666667, 1.15, 0
1361, 0.66666666666667, 1.25, 0
1362, 0.75, 0.25, 0
1363, 0.75, 0.35, 0
1364, 0.75, 0.45, 0
1365, 0.75, 0.55, 0
1366, 0.75, 0.65, 0
1367, 0.75, 0.75, 0
1368, 0.75, 0.85, 0
1369, 0.75, 0.95, 0
1370, 0.75, 1.05, 0
1371, 0.75, 1.15, 0
1372, 0.75, 1.25, 0
1373, 0.83333333333333, 0.25, 0
1374, 0.83333333333333, 0.35, 0
1375, 0.83333333333333, 0.45, 0
1376, 0.83333333333333, 0.55, 0
1377, 0.83333333333333, 0.65, 0
1378, 0.83333333333333, 0.75, 0
1379, 0.83333333333333, 0.85, 0
1380, 0.83333333333333, 0.95, 0
1381, 0.83333333333333, 1.05, 0
1382, 0.83333333333333, 1.15, 0
1383, 0.83333333333333, 1.25, 0
1384, 0.91666666666667, 0.25, 0
1385, 0.91666666666667, 0.35, 0
1386, 0.91666666666667, 0.45, 0
1387, 0.91666666666667, 0.55, 0
1388, 0.91666666666667, 0.65, 0
1389, 0.91666666666667, 0.75, 0
1390, 0.91666666666667, 0.85, 0
1391, 0.91666666666667, 0.95, 0
1392, 0.91666666666667, 1.05, 0
1393, 0.91666666666667, 1.15, 0
1394, 0.91666666666667, 1.25, 0
1395, 1, 0.25, 0.083333333333333
1396, 1, 0.35, 0.083333333333333
1397, 1, 0.45, 0.083333333333333
1398, 1, 0.55, 0.083333333333333
1399, 1, 0.65, 0.083333333333333
1400, 1, 0.75, 0.083333333333333
1401, 1, 0.85, 0.083333333333333
1402, 1, 0.95, 0.083333333333333
1403, 1, 1.05, 0.083333333333333
1404, 1, 1.15, 0.083333333333333
1405, 1, 1.25, 0.083333333333333
1406, 1, 0.25, 0.16666666666667
1407, 1, 0.35, 0.16666666666667
1408, 1, 0.45, 0.16666666666667
1409, 1, 0.55, 0.16666666666667
1410, 1, 0.65, 0.16666666666667
1411, 1, 0.75, 0.16666666666667
1412, 1, 0.85, 0.16666666666667
1413, 1, 0.95, 0.16666666666667
1414, 1, 1.05, 0.16666666666667
1415, 1, 1.15, 0.16666666666667
1416, 1, 1.25, 0.16666666666667
1417, 1, 0.25, 0.25
1418, 1, 0.35, 0.25
1419, 1, 0.45, 0.25
1420, 1, 0.55, 0.25
1421, 1, 0.65, 0.25
1422, 1, 0.75, 0.25
1423, 1, 0.85, 0.25
1424, 1, 0.95, 0.25
1425, 1, 1.05, 0.25
1426, 1, 1.15, 0.25
1427, 1, 1.25, 0.25
1428, 1, 0.25, 0.33333333333333
1429, 1, 0.35, 0.33333333333333
1430, 1, 0.45, 0.33333333333333
1431, 1, 0.55, 0.33333333333333
1432, 1, 0.65, 0.33333333333333
1433, 1, 0.75, 0.33333333333333
1434, 1, 0.85, 0.33333333333333
1435, 1, 0.95, 0.33333333333333
1436, 1, 1.05, 0.33333333333333
1437, 1, 1.15, 0.33333333333333
1438, 1, 1.25, 0.33333333333333
1439, 1, 0.25, 0.41666666666667
1440, 1, 0.35, 0.41666666666667
1441, 1, 0.45, 0.41666666666667
1442, 1, 0.55, 0.41666666666667
1443, 1, 0.65, 0.41666666666667
1444, 1, 0.75, 0.41666666666667
1445, 1, 0.85, 0.41666666666667
1446, 1, 0.95, 0.41666666666667
1447, 1, 1.05, 0.41666666666667
1448, 1, 1.15, 0.41666666666667
1449, 1, 1.25, 0.41666666666667
1450, 0.083333333333333, 0.25, 0.5
1451, 0.083333333333333, 0.35, 0.5
1452, 0.083333333333333, 0.45, 0.5
1453, 0.083333333333333, 0.55, 0.5
1454, 0.083333333333333, 0.65, 0.5
1455, 0.083333333333333, 0.75, 0.5
1456, 0.083333333333333, 0.85, 0.5
1457, 0.083333333333333, 0.95, 0.5
1458, 0.083333333333333, 1.05, 0.5
1459, 0.083333333333333, 1.15, 0.5
1460, 0.083333333333333, 1.25, 0.5
1461, 0.16666666666667, 0.25, 0.5
1462, 0.16666666666667, 0.35, 0.5
1463, 0.16666666666667, 0.45, 0.5
1464, 0.16666666666667, 0.55, 0.5
1465, 0.16666666666667, 0.65, 0.5
1466, 0.16666666666667, 0.75, 0.5
1467, 0.16666666666667, 0.85, 0.5
1468, 0.16666666666667, 0.95, 0.5
1469, 0.16666666666667, 1.05, 0.5
1470, 0.16666666666667, 1.15, 0.5
1471, 0.16666666666667, 1.25, 0.5
1472, 0.25, 0.25, 0.5
1473, 0.25, 0.35, 0.5
1474, 0.25, 0.45, 0.5
1475, 0.25, 0.55, 0.5
1476, 0.25, 0.65, 0.5
1477, 0.25, 0.75, 0.5
1478, 0.25, 0.85, 0.5
1479, 0.25, 0.95, 0.5
1480, 0.25, 1.05, 0.5
1481, 0.25, 1.15, 0.5
1482, 0.25, 1.25, 0.5
1483, 0.33333333333333, 0.25, 0.5
1484, 0.33333333333333, 0.35, 0.5
1485, 0.33333333333333, 0.45, 0.5
1486, 0.33333333333333, 0.55, 0.5
1487, 0.33333333333333, 0.65, 0.5
1488, 0.33333333333333, 0.75, 0.5
1489, 0.33333333333333, 0.85, 0.5
1490, 0.33333333333333, 0.95, 0.5
1491, 0.33333333333333, 1.05, 0.5
1492, 0.33333333333333, 1.15, 0.5
1493, 0.33333333333333, 1.25, 0.5
1494, 0.41666666666667, 0.25, 0.5
1495, 0.41666666666667, 0.35, 0.5
1496, 0.41666666666667, 0.45, 0.5
1497, 0.41666666666667, 0.55, 0.5
1498, 0.41666666666667, 0.65, 0.5
1499, 0.41666666666667, 0.75, 0.5
1500, 0.41666666666667, 0.85, 0.5
1501, 0.41666666666667, 0.95, 0.5
1502, 0.41666666666667, 1.05, 0.5
1503, 0.41666666666667, 1.15, 0.5
1504, 0.41666666666667, 1.25, 0.5
1505, 0.5, 0.25, 0.5
1506, 0.5, 0.35, 0.5
1507, 0.5, 0.45, 0.5
1508, 0.5, 0.55, 0.5
1509, 0.5, 0.65, 0.5
1510, 0.5, 0.75, 0.5
1511, 0.5, 0.85, 0.5
1512, 0.5, 0.95, 0.5
1513, 0.5, 1.05, 0.5
1514, 0.5, 1.15, 0.5
1515, 0.5, 1.25, 0.5
1516, 0.58333333333333, 0.25, 0.5
1517, 0.58333333333333, 0.35, 0.5
1518, 0.58333333333333, 0.45, 0.5
1519, 0.58333333333333, 0.55, 0.5
1520, 0.58333333333333, 0.65, 0.5
1521, 0.58333333333333, 0.75, 0.5
1522, 0.58333333333333, 0.85, 0.5
1523, 0.58333333333333, 0.95, 0.5
1524, 0.58333333333333, 1.05, 0.5
1525, 0.58333333333333, 1.15, 0.5
1526, 0.58333333333333, 1.25, 0.5
1527, 0.66666666666667, 0.25, 0.5
1528, 0.66666666666667, 0.35, 0.5
1529, 0.66666666666667, 0.45, 0.5
1530, 0.66666666666667, 0.55, 0.5
1531, 0.66666666666667, 0.65, 0.5
1532, 0.66666666666667, 0.75, 0.5
1533, 0.66666666666667, 0.85, 0.5
1534, 0.66666666666667, 0.95, 0.5
1535, 0.66666666666667, 1.05, 0.5
1536, 0.66666666666667, 1.15, 0.5
1537, 0.66666666666667, 1.25, 0.5
1538, 0.75, 0.25, 0.5
1539, 0.75, 0.35, 0.5
1540, 0.75, 0.45, 0.5
1541, 0.75, 0.55, 0.5
1542, 0.75, 0.65, 0.5
1543, 0.75, 0.75, 0.5
1544, 0.75, 0.85, 0.5
1545, 0.75, 0.95, 0.5
1546, 0.75, 1.05, 0.5
1547, 0.75, 1.15, 0.5
1548, 0.75, 1.25, 0.5
1549, 0.83333333333333, 0.25, 0.5
1550, 0.83333333333333, 0.35, 0.5
1551, 0.83333333333333, 0.45, 0.5
1552, 0.83333333333333, 0.55, 0.5
1553, 0.83333333333333, 0.65, 0.5
1554, 0.83333333333333, 0.75, 0.5
1555, 0.83333333333333, 0.85, 0.5
1556, 0.83333333333333, 0.95, 0.5
1557, 0.83333333333333, 1.05, 0.5
1558, 0.83333333333333, 1.15, 0.5
1559, 0.83333333333333, 1.25, 0.5
1560, 0.91666666666667, 0.25, 0.5
1561, 0.91666666666667, 0.35, 0.5
1562, 0.91666666666667, 0.45, 0.5
1563, 0.91666666666667, 0.55, 0.5
1564, 0.91666666666667, 0.65, 0.5
1565, 0.91666666666667, 0.75, 0.5
1566, 0.91666666666667, 0.85, 0.5
1567, 0.91666666666667, 0.95, 0.5
1568, 0.91666666666667, 1.05, 0.5
1569, 0.91666666666667, 1.15, 0.5
1570, 0.91666666666667, 1.25, 0.5
1571, 0, 0.25, 0.083333333333333
1572, 0, 0.35, 0.083333333333333
1573, 0, 0.45, 0.083333333333333
1574, 0, 0.55, 0.083333333333333
1575, 0, 0.65, 0.083333333333333
1576, 0, 0.75, 0.083333333333333
1577, 0, 0.85, 0.083333333333333
1578, 0, 0.95, 0.083333333333333
1579, 0, 1.05, 0.083333333333333
1580, 0, 1.15, 0.083333333333333
1581, 0, 1.25, 0.083333333333333
1582, 0, 0.25, 0.16666666666667
1583, 0, 0.35, 0.16666666666667
1584, 0, 0.45, 0.16666666666667
1585, 0, 0.55, 0.16666666666667
1586, 0, 0.65, 0.16666666666667
1587, 0, 0.75, 0.16666666666667
1588, 0, 0.85, 0.16666666666667
1589, 0, 0.95, 0.16666666666667
1590, 0, 1.05, 0.16666666666667
1591, 0, 1.15, 0.16666666666667
1592, 0, 1.25, 0.16666666666667
1593, 0, 0.25, 0.25
1594, 0, 0.35, 0.25
1595, 0, 0.45, 0.25
1596, 0, 0.55, 0.25
1597, 0, 0.65, 0.25
1598, 0, 0.75, 0.25
1599, 0, 0.85, 0.25
1600, 0, 0.95, 0.25
1601, 0, 1.05, 0.25
1602, 0, 1.15, 0.25
1603, 0, 1.25, 0.25
1604, 0, 0.25, 0.33333333333333
1605, 0, 0.35, 0.33333333333333
1606, 0, 0.45, 0.33333333333333
1607, 0, 0.55, 0.33333333333333
1608, 0, 0.65, 0.33333333333333
1609, 0, 0.75, 0.33333333333333
1610, 0, 0.85, 0.33333333333333
1611, 0, 0.95, 0.33333333333333
1612, 0, 1.05, 0.33333333333333
1613, 0, 1.15, 0.33333333333333
1614, 0, 1.25, 0.33333333333333
1615, 0, 0.25, 0.41666666666667
1616, 0, 0.35, 0.41666666666667
1617, 0, 0.45, 0.41666666666667
1618, 0, 0.55, 0.41666666666667
1619, 0, 0.65, 0.41666666666667
1620, 0, 0.75, 0.41666666666667
1621, 0, 0.85, 0.41666666666667
1622, 0, 0.95, 0.41666666666667
1623, 0, 1.05, 0.41666666666667
1624, 0, 1.15, 0.41666666666667
1625, 0, 1.25, 0.41666666666667
1626, 0.083333333333333, 1.35, 0.083333333333333
1627, 0.083333333333333, 1.35, 0.16666666666667
1628, 0.083333333333333, 1.35, 0.25
1629, 0.083333333333333, 1.35, 0.33333333333333
1630, 0.083333333333333, 1.35, 0.41666666666667
1631, 0.16666666666667, 1.35, 0.083333333333333
1632, 0.16666666666667, 1.35, 0.16666666666667
1633, 0.16666666666667, 1.35, 0.25
1634, 0.16666666666667, 1.35, 0.33333333333333
1635, 0.16666666666667, 1.35, 0.41666666666667
1636, 0.25, 1.35, 0.083333333333333
1637, 0.25, 1.35, 0.16666666666667
1638, 0.25, 1.35, 0.25
1639, 0.25, 1.35, 0.33333333333333
1640, 0.25, 1.35, 0.41666666666667
1641, 0.33333333333333, 1.35, 0.083333333333333
1642, 0.33333333333333, 1.35, 0.16666666666667
1643, 0.33333333333333, 1.35, 0.25
1644, 0.33333333333333, 1.35, 0.33333333333333
1645, 0.33333333333333, 1.35, 0.41666666666667
1646, 0.41666666666667, 1.35, 0.083333333333333
1647, 0.41666666666667, 1.35, 0.16666666666667
1648, 0.41666666666667, 1.35, 0.25
1649, 0.41666666666667, 1.35, 0.33333333333333
1650, 0.41666666666667, 1.35, 0.41666666666667
1651, 0.5, 1.35, 0.083333333333333
1652, 0.5, 1.35, 0.16666666666667
1653, 0.5, 1.35, 0.25
1654, 0.5, 1.35, 0.33333333333333
1655, 0.5, 1.35, 0.41666666666667
1656, 0.58333333333333, 1.35, 0.083333333333333
1657, 0.58333333333333, 1.35, 0.16666666666667
1658, 0.58333333333333, 1.35, 0.25
1659, 0.58333333333333, 1.35, 0.33333333333333
1660, 0.58333333333333, 1.35, 0.41666666666667
1661, 0.66666666666667, 1.35, 0.083333333333333
1662, 0.66666666666667, 1.35, 0.16666666666667
1663, 0.66666666666667, 1.35, 0.25
1664, 0.66666666666667, 1.35, 0.33333333333333
1665, 0.66666666666667, 1.35, 0.41666666666667
1666, 0.75, 1.35, 0.083333333333333
1667, 0.75, 1.35, 0.16666666666667
1668, 0.75, 1.35, 0.25
1669, 0.75, 1.35, 0.33333333333333
1670, 0.75, 1.35, 0.41666666666667
1671, 0.83333333333333, 1.35, 0.083333333333333
1672, 0.83333333333333, 1.35, 0.16666666666667
1673, 0.83333333333333, 1.35, 0.25
1674, 0.83333333333333, 1.35, 0.33333333333333
1675, 0.83333333333333, 1.35, 0.41666666666667
1676, 0.91666666666667, 1.35, 0.083333333333333
1677, 0.91666666666667, 1.35, 0.16666666666667
1678, 0.91666666666667, 1.35, 0.25
1679, 0.91666666666667, 1.35, 0.33333333333333
1680, 0.91666666666667, 1.35, 0.41666666666667
1681, 0.083333333333333, 1.4, 0.083333333333333
1682, 0.083333333333333, 1.4, 0.16666666666667
1683, 0.083333333333333, 1.4, 0.25
1684, 0.083333333333333, 1.4, 0.33333333333333
1685, 0.083333333333333, 1.4, 0.41666666666667
1686, 0.16666666666667, 1.4, 0.083333333333333
1687, 0.16666666666667, 1.4, 0.16666666666667
1688, 0.16666666666667, 1.4, 0.25
1689, 0.16666666666667, 1.4, 0.33333333333333
1690, 0.16666666666667, 1.4, 0.41666666666667
1691, 0.25, 1.4, 0.083333333333333
1692, 0.25, 1.4, 0.16666666666667
1693, 0.25, 1.4, 0.25
1694, 0.25, 1.4, 0.33333333333333
1695, 0.25, 1.4, 0.41666666666667
1696, 0.33333333333333, 1.4, 0.083333333333333
1697, 0.33333333333333, 1.4, 0.16666666666667
1698, 0.33333333333333, 1.4, 0.25
1699, 0.33333333333333, 1.4, 0.33333333333333
1700, 0.33333333333333, 1.4, 0.41666666666667
1701, 0.41666666666667, 1.4, 0.083333333333333
1702, 0.41666666666667, 1.4, 0.16666666666667
1703, 0.41666666666667, 1.4, 0.25
1704, 0.41666666666667, 1.4, 0.33333333333333
1705, 0.41666666666667, 1.4, 0.41666666666667
1706, 0.5, 1.4, 0.083333333333333
1707, 0.5, 1.4, 0.16666666666667
1708, 0.5, 1.4, 0.25
1709, 0.5, 1.4, 0.33333333333333
1710, 0.5, 1.4, 0.41666666666667
1711, 0.58333333333333, 1.4, 0.083333333333333
1712, 0.58333333333333, 1.4, 0.16666666666667
1713, 0.58333333333333, 1.4, 0.25
1714, 0.58333333333333, 1.4, 0.33333333333333
1715, 0.58333333333333, 1.4, 0.41666666666667
1716, 0.66666666666667, 1.4, 0.083333333333333
1717, 0.66666666666667, 1.4, 0.16666666666667
1718, 0.66666666666667, 1.4, 0.25
1719, 0.66666666666667, 1.4, 0.33333333333333
1720, 0.66666666666667, 1.4, 0.41666666666667
1721, 0.75, 1.4, 0.083333333333333
1722, 0.75, 1.4, 0.16666666666667
1723, 0.75, 1.4, 0.25
1724, 0.75, 1.4, 0.33333333333333
1725, 0.75, 1.4, 0.41666666666667
1726, 0.83333333333333, 1.4, 0.083333333333333
1727, 0.83333333333333, 1.4, 0.16666666666667
1728, 0.83333333333333, 1.4, 0.25
1729, 0.83333333333333, 1.4, 0.33333333333333
1730, 0.83333333333333, 1.4, 0.41666666666667
1731, 0.91666666666667, 1.4, 0.083333333333333
1732, 0.91666666666667, 1.4, 0.16666666666667
1733, 0.91666666666667, 1.4, 0.25
1734, 0.91666666666667, 1.4, 0.33333333333333
1735, 0.91666666666667, 1.4, 0.41666666666667
1736, 0.083333333333333, 1.4333333333333, 0
1737, 0.083333333333333, 1.4666666666667, 0
1738, 0.16666666666667, 1.4333333333333, 0
1739, 0.16666666666667, 1.4666666666667, 0
1740, 0.25, 1.4333333333333, 0
1741, 0.25, 1.4666666666667, 0
1742, 0.33333333333333, 1.4333333333333, 0
1743, 0.33333333333333, 1.4666666666667, 0
1744, 0.41666666666667, 1.4333333333333, 0
1745, 0.41666666666667, 1.4666666666667, 0
1746, 0.5, 1.4333333333333, 0
1747, 0.5, 1.4666666666667, 0
1748, 0.58333333333333, 1.4333333333333, 0
1749, 0.58333333333333, 1.4666666666667, 0
1750, 0.66666666666667, 1.4333333333333, 0
1751, 0.66666666666667, 1.4666666666667, 0
1752, 0.75, 1.4333333333333, 0
1753, 0.75, 1.4666666666667, 0
1754, 0.83333333333333, 1.4333333333333, 0
1755, 0.83333333333333, 1.4666666666667, 0
1756, 0.91666666666667, 1.4333333333333, 0
1757, 0.91666666666667, 1.4666666666667, 0
1758, 1, 1.4333333333333, 0.083333333333333
1759, 1, 1.4666666666667, 0.083333333333333
1760, 1, 1.4333333333333, 0.16666666666667
1761, 1, 1.4666666666667, 0.16666666666667
1762, 1, 1.4333333333333, 0.25
1763, 1, 1.4666666666667, 0.25
1764, 1, 1.4333333333333, 0.33333333333333
1765, 1, 1.4666666666667, 0.33333333333333
1766, 1, 1.4333333333333, 0.41666666666667
1767, 1, 1.4666666666667, 0.41666666666667
1768, 0.083333333333333, 1.4333333333333, 0.5
1769, 0.083333333333333, 1.4666666666667, 0.5
1770, 0.16666666666667, 1.4333333333333, 0.5
1771, 0.16666666666667, 1.4666666666667, 0.5
1772, 0.25, 1.4333333333333, 0.5
1773, 0.25, 1.4666666666667, 0.5
1774, 0.33333333333333, 1.4333333333333, 0.5
1775, 0.33333333333333, 1.4666666666667, 0.5
1776, 0.41666666666667, 1.4333333333333, 0.5
1777, 0.41666666666667, 1.4666666666667, 0.5
1778, 0.5, 1.4333333333333, 0.5
1779, 0.5, 1.4666666666667, 0.5
1780, 0.58333333333333, 1.4333333333333, 0.5
1781, 0.58333333333333, 1.4666666666667, 0.5
1782, 0.66666666666667, 1.4333333333333, 0.5
1783, 0.66666666666667, 1.4666666666667, 0.5
1784, 0.75, 1.4333333333333, 0.5
1785, 0.75, 1.4666666666667, 0.5
1786, 0.83333333333333, 1.4333333333333, 0.5
1787, 0.83333333333333, 1.4666666666667, 0.5
1788, 0.91666666666667, 1.4333333333333, 0.5
1789, 0.91666666666667, 1.4666666666667, 0.5
1790, 0, 1.4333333333333, 0.083333333333333
1791, 0, 1.4666666666667, 0.083333333333333
1792, 0, 1.4333333333333, 0.16666666666667
1793, 0, 1.4666666666667, 0.16666666666667
1794, 0, 1.4333333333333, 0.25
1795, 0, 1.4666666666667, 0.25
1796, 0, 1.4333333333333, 0.33333333333333
1797, 0, 1.4666666666667, 0.33333333333333
1798, 0, 1.4333333333333, 0.41666666666667
1799, 0, 1.4666666666667, 0.41666666666667
1800, 0.083333333333333, 1.5, 0.083333333333333
1801, 0.083333333333333, 1.5, 0.16666666666667
1802, 0.083333333333333, 1.5, 0.25
1803, 0.083333333333333, 1.5, 0.33333333333333
1804, 0.083333333333333, 1.5, 0.41666666666667
1805, 0.16666666666667, 1.5, 0.083333333333333
1806, 0.16666666666667, 1.5, 0.16666666666667
1807, 0.16666666666667, 1.5, 0.25
1808, 0.16666666666667, 1.5, 0.33333333333333
1809, 0.16666666666667, 1.5, 0.41666666666667
1810, 0.25, 1.5, 0.083333333333333
1811, 0.25, 1.5, 0.16666666666667
1812, 0.25, 1.5, 0.25
1813, 0.25, 1.5, 0.33333333333333
1814, 0.25, 1.5, 0.41666666666667
1815, 0.33333333333333, 1.5, 0.083333333333333
1816, 0.33333333333333, 1.5, 0.16666666666667
1817, 0.33333333333333, 1.5, 0.25
1818, 0.33333333333333, 1.5, 0.33333333333333
1819, 0.33333333333333, 1.5, 0.41666666666667
1820, 0.41666666666667, 1.5, 0.083333333333333
1821, 0.41666666666667, 1.5, 0.16666666666667
1822, 0.41666666666667, 1.5, 0.25
1823, 0.41666666666667, 1.5, 0.33333333333333
1824, 0.41666666666667, 1.5, 0.41666666666667
1825, 0.5, 1.5, 0.083333333333333
1826, 0.5, 1.5, 0.16666666666667
1827, 0.5, 1.5, 0.25
1828, 0.5, 1.5, 0.33333333333333
1829, 0.5, 1.5, 0.41666666666667
1830, 0.58333333333333, 1.5, 0.083333333333333
1831, 0.58333333333333, 1.5, 0.16666666666667
1832, 0.58333333333333, 1.5, 0.25
1833, 0.58333333333333, 1.5, 0.33333333333333
1834, 0.58333333333333, 1.5, 0.41666666666667
1835, 0.66666666666667, 1.5, 0.083333333333333
1836, 0.66666666666667, 1.5, 0.16666666666667
1837, 0.66666666666667, 1.5, 0.25
1838, 0.66666666666667, 1.5, 0.33333333333333
1839, 0.66666666666667, 1.5, 0.41666666666667
1840, 0.75, 1.5, 0.083333333333333
1841, 0.75, 1.5, 0.16666666666667
1842, 0.75, 1.5, 0.25
1843, 0.75, 1.5, 0.33333333333333
1844, 0.75, 1.5, 0.41666666666667
1845, 0.83333333333333, 1.5, 0.083333333333333
1846, 0.83333333333333, 1.5, 0.16666666666667
1847, 0.83333333333333, 1.5, 0.25
1848, 0.83333333333333, 1.5, 0.33333333333333
1849, 0.83333333333333, 1.5, 0.41666666666667
1850, 0.91666666666667, 1.5, 0.083333333333333
1851, 0.91666666666667, 1.5, 0.16666666666667
1852, 0.91666666666667, 1.5, 0.25
1853, 0.91666666666667, 1.5, 0.33333333333333
1854, 0.91666666666667, 1.5, 0.41666666666667
1855, 1.04, 1.4333333333333, 0.5
1856, 1.08, 1.4333333333333, 0.5
1857, 1.12, 1.4333333333333, 0.5
1858, 1.16, 1.4333333333333, 0.5
1859, 1.04, 1.4666666666667, 0.5
1860, 1.08, 1.4666666666667, 0.5
1861, 1.12, 1.4666666666667, 0.5
1862, 1.16, 1.4666666666667, 0.5
1863, 1.04, 1.4333333333333, 0
1864, 1.08, 1.4333333333333, 0
1865, 1.12, 1.4333333333333, 0
1866, 1.16, 1.4333333333333, 0
1867, 1.04, 1.4666666666667, 0
1868, 1.08, 1.4666666666667, 0
1869, 1.12, 1.4666666666667, 0
1870, 1.16, 1.4666666666667, 0
1871, 1.04, 1.4, 0.083333333333333
1872, 1.08, 1.4, 0.083333333333333
1873, 1.12, 1.4, 0.083333333333333
1874, 1.16, 1.4, 0.083333333333333
1875, 1.04, 1.4, 0.16666666666667
1876, 1.08, 1.4, 0.16666666666667
1877, 1.12, 1.4, 0.16666666666667
1878, 1.16, 1.4, 0.16666666666667
1879, 1.04, 1.4, 0.25
1880, 1.08, 1.4, 0.25
1881, 1.12, 1.4, 0.25
1882, 1.16, 1.4, 0.25
1883, 1.04, 1.4, 0.33333333333333
1884, 1.08, 1.4, 0.33333333333333
1885, 1.12, 1.4, 0.33333333333333
1886, 1.16, 1.4, 0.33333333333333
1887, 1.04, 1.4, 0.41666666666667
1888, 1.08, 1.4, 0.41666666666667
1889, 1.12, 1.4, 0.41666666666667
1890, 1.16, 1.4, 0.41666666666667
1891, 1.04, 1.5, 0.083333333333333
1892, 1.08, 1.5, 0.083333333333333
1893, 1.12, 1.5, 0.083333333333333
1894, 1.16, 1.5, 0.083333333333333
1895, 1.04, 1.5, 0.16666666666667
1896, 1.08, 1.5, 0.16666666666667
1897, 1.12, 1.5, 0.16666666666667
1898, 1.16, 1.5, 0.16666666666667
1899, 1.04, 1.5, 0.25
1900, 1.08, 1.5, 0.25
1901, 1.12, 1.5, 0.25
1902, 1.16, 1.5, 0.25
1903, 1.04, 1.5, 0.33333333333333
1904, 1.08, 1.5, 0.33333333333333
1905, 1.12, 1.5, 0.33333333333333
1906, 1.16, 1.5, 0.33333333333333
1907, 1.04, 1.5, 0.41666666666667
1908, 1.08, 1.5, 0.41666666666667
1909, 1.12, 1.5, 0.41666666666667
1910, 1.16, 1.5, 0.41666666666667
1911, 1.2, 1.4333333333333, 0.083333333333333
1912, 1.2, 1.4666666666667, 0.083333333333333
1913, 1.2, 1.4333333333333, 0.16666666666667
1914, 1.2, 1.4666666666667, 0.16666666666667
1915, 1.2, 1.4333333333333, 0.25
1916, 1.2, 1.4666666666667, 0.25
1917, 1.2, 1.4333333333333, 0.33333333333333
1918, 1.2, 1.4666666666667, 0.33333333333333
1919, 1.2, 1.4333333333333, 0.41666666666667
1920, 1.2, 1.4666666666667, 0.41666666666667
1921, 1.2833333333333, 1.4333333333333, 0.5
1922, 1.3666666666667, 1.4333333333333, 0.5
1923, 1.45, 1.4333333333333, 0.5
1924, 1.5333333333333, 1.4333333333333, 0.5
1925, 1.6166666666667, 1.4333333333333, 0.5
1926, 1.7, 1.4333333333333, 0.5
1927, 1.7833333333333, 1.4333333333333, 0.5
1928, 1.8666666666667, 1.4333333333333, 0.5
1929, 1.95, 1.4333333333333, 0.5
1930, 2.0333333333333, 1.4333333333333, 0.5
1931, 2.1166666666667, 1.4333333333333, 0.5
1932, 1.2833333333333, 1.4666666666667, 0.5
1933, 1.3666666666667, 1.4666666666667, 0.5
1934, 1.45, 1.4666666666667, 0.5
1935, 1.5333333333333, 1.4666666666667, 0.5
1936, 1.6166666666667, 1.4666666666667, 0.5
1937, 1.7, 1.4666666666667, 0.5
1938, 1.7833333333333, 1.4666666666667, 0.5
1939, 1.8666666666667, 1.4666666666667, 0.5
1940, 1.95, 1.4666666666667, 0.5
1941, 2.0333333333333, 1.4666666666667, 0.5
1942, 2.1166666666667, 1.4666666666667, 0.5
1943, 1.2833333333333, 1.4333333333333, 0
1944, 1.3666666666667, 1.4333333333333, 0
1945, 1.45, 1.4333333333333, 0
1946, 1.5333333333333, 1.4333333333333, 0
1947, 1.6166666666667, 1.4333333333333, 0
1948, 1.7, 1.4333333333333, 0
1949, 1.7833333333333, 1.4333333333333, 0
1950, 1.8666666666667, 1.4333333333333, 0
1951, 1.95, 1.4333333333333, 0
1952, 2.0333333333333, 1.4333333333333, 0
1953, 2.1166666666667, 1.4333333333333, 0
1954, 1.2833333333333, 1.4666666666667, 0
1955, 1.3666666666667, 1.4666666666667, 0
1956, 1.45, 1.4666666666667, 0
1957, 1.5333333333333, 1.4666666666667, 0
1958, 1.6166666666667, 1.4666666666667, 0
1959, 1.7, 1.4666666666667, 0
1960, 1.7833333333333, 1.4666666666667, 0
1961, 1.8666666666667, 1.4666666666667, 0
1962, 1.95, 1.4666666666667, 0
1963, 2.0333333333333, 1.4666666666667, 0
1964, 2.1166666666667, 1.4666666666667, 0
1965, 1.2833333333333, 1.4, 0.083333333333333
1966, 1.3666666666667, 1.4, 0.083333333333333
1967, 1.45, 1.4, 0.083333333333333
1968, 1.5333333333333, 1.4, 0.083333333333333
1969, 1.6166666666667, 1.4, 0.083333333333333
1970, 1.7, 1.4, 0.083333333333333
1971, 1.7833333333333, 1.4, 0.083333333333333
1972, 1.8666666666667, 1.4, 0.083333333333333
1973, 1.95, 1.4, 0.083333333333333
1974, 2.0333333333333, 1.4, 0.083333333333333
1975, 2.1166666666667, 1.4, 0.083333333333333
1976, 1.2833333333333, 1.4, 0.16666666666667
1977, 1.3666666666667, 1.4, 0.16666666666667
1978, 1.45, 1.4, 0.16666666666667
1979, 1.5333333333333, 1.4, 0.16666666666667
1980, 1.6166666666667, 1.4, 0.16666666666667
1981, 1.7, 1.4, 0.16666666666667
1982, 1.7833333333333, 1.4, 0.16666666666667
1983, 1.8666666666667, 1.4, 0.16666666666667
1984, 1.95, 1.4, 0.16666666666667
1985, 2.0333333333333, 1.4, 0.16666666666667
1986, 2.1166666666667, 1.4, 0.16666666666667
1987, 1.2833333333333, 1.4, 0.25
1988, 1.3666666666667, 1.4, 0.25
1989, 1.45, 1.4, 0.25
1990, 1.5333333333333, 1.4, 0.25
1991, 1.6166666666667, 1.4, 0.25
1992, 1.7, 1.4, 0.25
1993, 1.7833333333333, 1.4, 0.25
1994, 1.8666666666667, 1.4, 0.25
1995, 1.95, 1.4, 0.25
1996, 2.0333333333333, 1.4, 0.25
1997, 2.1166666666667, 1.4, 0.25
1998, 1.2833333333333, 1.4, 0.33333333333333
1999, 1.3666666666667, 1.4, 0.33333333333333
2000, 1.45, 1.4, 0.33333333333333
2001, 1.5333333333333, 1.4, 0.33333333333333
2002, 1.6166666666667, 1.4, 0.33333333333333
2003, 1.7, 1.4, 0.33333333333333
2004, 1.7833333333333, 1.4, 0.33333333333333
2005, 1.8666666666667, 1.4, 0.33333333333333
2006, 1.95, 1.4, 0.33333333333333
2007, 2.0333333333333, 1.4, 0.33333333333333
2008, 2.1166666666667, 1.4, 0.33333333333333
2009, 1.2833333333333, 1.4, 0.41666666666667
2010, 1.3666666666667, 1.4, 0.41666666666667
2011, 1.45, 1.4, 0.41666666666667
2012, 1.5333333333333, 1.4, 0.41666666666667
2013, 1.6166666666667, 1.4, 0.41666666666667
2014, 1.7, 1.4, 0.41666666666667
2015, 1.7833333333333, 1.4, 0.41666666666667
2016, 1.8666666666667, 1.4, 0.41666666666667
2017, 1.95, 1.4, 0.41666666666667
2018, 2.0333333333333, 1.4, 0.41666666666667
2019, 2.1166666666667, 1.4, 0.41666666666667
2020, 1.2833333333333, 1.5, 0.083333333333333
2021, 1.3666666666667, 1.5, 0.083333333333333
2022, 1.45, 1.5, 0.083333333333333
2023, 1.5333333333333, 1.5, 0.083333333333333
2024, 1.6166666666667, 1.5, 0.083333333333333
2025, 1.7, 1.5, 0.083333333333333
2026, 1.7833333333333, 1.5, 0.083333333333333
2027, 1.8666666666667, 1.5, 0.083333333333333
2028, 1.95, 1.5, 0.083333333333333
2029, 2.0333333333333, 1.5, 0.083333333333333
2030, 2.1166666666667, 1.5, 0.083333333333333
2031, 1.2833333333333, 1.5, 0.16666666666667
2032, 1.3666666666667, 1.5, 0.16666666666667
2033, 1.45, 1.5, 0.16666666666667
2034, 1.5333333333333, 1.5, 0.16666666666667
2035, 1.6166666666667, 1.5, 0.16666666666667
2036, 1.7, 1.5, 0.16666666666667
2037, 1.7833333333333, 1.5, 0.16666666666667
2038, 1.8666666666667, 1.5, 0.16666666666667
2039, 1.95, 1.5, 0.16666666666667
2040, 2.0333333333333, 1.5, 0.16666666666667
2041, 2.1166666666667, 1.5, 0.16666666666667
2042, 1.2833333333333, 1.5, 0.25
2043, 1.3666666666667, 1.5, 0.25
2044, 1.45, 1.5, 0.25
2045, 1.5333333333333, 1.5, 0.25
2046, 1.6166666666667, 1.5, 0.25
2047, 1.7, 1.5, 0.25
2048, 1.7833333333333, 1.5, 0.25
2049, 1.8666666666667, 1.5, 0.25
2050, 1.95, 1.5, 0.25
2051, 2.0333333333333, 1.5, 0.25
2052, 2.1166666666667, 1.5, 0.25
2053, 1.2833333333333, 1.5, 0.33333333333333
2054, 1.3666666666667, 1.5, 0.33333333333333
2055, 1.45, 1.5, 0.33333333333333
2056, 1.5333333333333, 1.5, 0.33333333333333
2057, 1.6166666666667, 1.5, 0.33333333333333
2058, 1.7, 1.5, 0.33333333333333
2059, 1.7833333333333, 1.5, 0.33333333333333
2060, 1.8666666666667, 1.5, 0.33333333333333
2061, 1.95, 1.5, 0.33333333333333
2062, 2.0333333333333, 1.5, 0.33333333333333
2063, 2.1166666666667, 1.5, 0.33333333333333
2064, 1.2833333333333, 1.5, 0.41666666666667
2065, 1.3666666666667, 1.5, 0.41666666666667
2066, 1.45, 1.5, 0.41666666666667
2067, 1.5333333333333, 1.5, 0.41666666666667
2068, 1.6166666666667, 1.5, 0.41666666666667
2069, 1.7, 1.5, 0.41666666666667
2070, 1.7833333333333, 1.5, 0.41666666666667
2071, 1.8666666666667, 1.5, 0.41666666666667
2072, 1.95, 1.5, 0.41666666666667
2073, 2.0333333333333, 1.5, 0.41666666666667
2074, 2.1166666666667, 1.5, 0.41666666666667
2075, 2.2, 1.4333333333333, 0.083333333333333
2076, 2.2, 1.4666666666667, 0.083333333333333
2077, 2.2, 1.4333333333333, 0.16666666666667
2078, 2.2, 1.4666666666667, 0.16666666666667
2079, 2.2, 1.4333333333333, 0.25
2080, 2.2, 1.4666666666667, 0.25
2081, 2.2, 1.4333333333333, 0.33333333333333
2082, 2.2, 1.4666666666667, 0.33333333333333
2083, 2.2, 1.4333333333333, 0.41666666666667
2084, 2.2, 1.4666666666667, 0.41666666666667
2085, 1.2833333333333, 1.35, 0.083333333333333
2086, 1.3666666666667, 1.35, 0.083333333333333
2087, 1.45, 1.35, 0.083333333333333
2088, 1.5333333333333, 1.35, 0.083333333333333
2089, 1.6166666666667, 1.35, 0.083333333333333
2090, 1.7, 1.35, 0.083333333333333
2091, 1.7833333333333, 1.35, 0.083333333333333
2092, 1.8666666666667, 1.35, 0.083333333333333
2093, 1.95, 1.35, 0.083333333333333
2094, 2.0333333333333, 1.35, 0.083333333333333
2095, 2.1166666666667, 1.35, 0.083333333333333
2096, 1.2833333333333, 1.35, 0.16666666666667
2097, 1.3666666666667, 1.35, 0.16666666666667
2098, 1.45, 1.35, 0.16666666666667
2099, 1.5333333333333, 1.35, 0.16666666666667
2100, 1.6166666666667, 1.35, 0.16666666666667
2101, 1.7, 1.35, 0.16666666666667
2102, 1.7833333333333, 1.35, 0.16666666666667
2103, 1.8666666666667, 1.35, 0.16666666666667
2104, 1.95, 1.35, 0.16666666666667
2105, 2.0333333333333, 1.35, 0.16666666666667
2106, 2.1166666666667, 1.35, 0.16666666666667
2107, 1.2833333333333, 1.35, 0.25
2108, 1.3666666666667, 1.35, 0.25
2109, 1.45, 1.35, 0.25
2110, 1.5333333333333, 1.35, 0.25
2111, 1.6166666666667, 1.35, 0.25
2112, 1.7, 1.35, 0.25
2113, 1.7833333333333, 1.35, 0.25
2114, 1.8666666666667, 1.35, 0.25
2115, 1.95, 1.35, 0.25
2116, 2.0333333333333, 1.35, 0.25
2117, 2.1166666666667, 1.35, 0.25
2118, 1.2833333333333, 1.35, 0.33333333333333
2119, 1.3666666666667, 1.35, 0.33333333333333
2120, 1.45, 1.35, 0.33333333333333
2121, 1.5333333333333, 1.35, 0.33333333333333
2122, 1.6166666666667, 1.35, 0.33333333333333
2123, 1.7, 1.35, 0.33333333333333
2124, 1.7833333333333, 1.35, 0.33333333333333
2125, 1.8666666666667, 1.35, 0.33333333333333
2126, 1.95, 1.35, 0.33333333333333
2127, 2.0333333333333, 1.35, 0.33333333333333
2128, 2.1166666666667, 1.35, 0.33333333333333
2129, 1.2833333333333, 1.35, 0.41666666666667
2130, 1.3666666666667, 1.35, 0.41666666666667
2131, 1.45, 1.35, 0.41666666666667
2132, 1.5333333333333, 1.35, 0.41666666666667
2133, 1.6166666666667, 1.35, 0.41666666666667
2134, 1.7, 1.35, 0.41666666666667
2135, 1.7833333333333, 1.35, 0.41666666666667
2136, 1.8666666666667, 1.35, 0.41666666666667
2137, 1.95, 1.35, 0.41666666666667
2138, 2.0333333333333, 1.35, 0.41666666666667
2139, 2.1166666666667, 1.35, 0.41666666666667
2140, 1.2833333333333, 1.25, 0.5
2141, 1.2833333333333, 1.15, 0.5
2142, 1.2833333333333, 1.05, 0.5
2143, 1.2833333333333, 0.95, 0.5
2144, 1.2833333333333, 0.85, 0.5
2145, 1.2833333333333, 0.75, 0.5
2146, 1.2833333333333, 0.65, 0.5
2147, 1.2833333333333, 0.55, 0.5
2148, 1.2833333333333, 0.45, 0.5
2149, 1.2833333333333, 0.35, 0.5
2150, 1.2833333333333, 0.25, 0.5
2151, 1.3666666666667, 1.25, 0.5
2152, 1.3666666666667, 1.15, 0.5
2153, 1.3666666666667, 1.05, 0.5
2154, 1.3666666666667, 0.95, 0.5
2155, 1.3666666666667, 0.85, 0.5
2156, 1.3666666666667, 0.75, 0.5
2157, 1.3666666666667, 0.65, 0.5
2158, 1.3666666666667, 0.55, 0.5
2159, 1.3666666666667, 0.45, 0.5
2160, 1.3666666666667, 0.35, 0.5
2161, 1.3666666666667, 0.25, 0.5
2162, 1.45, 1.25, 0.5
2163, 1.45, 1.15, 0.5
2164, 1.45, 1.05, 0.5
2165, 1.45, 0.95, 0.5
2166, 1.45, 0.85, 0.5
2167, 1.45, 0.75, 0.5
2168, 1.45, 0.65, 0.5
2169, 1.45, 0.55, 0.5
2170, 1.45, 0.45, 0.5
2171, 1.45, 0.35, 0.5
2172, 1.45, 0.25, 0.5
2173, 1.5333333333333, 1.25, 0.5
2174, 1.5333333333333, 1.15, 0.5
2175, 1.5333333333333, 1.05, 0.5
2176, 1.5333333333333, 0.95, 0.5
2177, 1.5333333333333, 0.85, 0.5
2178, 1.5333333333333, 0.75, 0.5
2179, 1.5333333333333, 0.65, 0.5
2180, 1.5333333333333, 0.55, 0.5
2181, 1.5333333333333, 0.45, 0.5
2182, 1.5333333333333, 0.35, 0.5
2183, 1.5333333333333, 0.25, 0.5
2184, 1.6166666666667, 1.25, 0.5
2185, 1.6166666666667, 1.15, 0.5
2186, 1.6166666666667, 1.05, 0.5
2187, 1.6166666666667, 0.95, 0.5
2188, 1.6166666666667, 0.85, 0.5
2189, 1.6166666666667, 0.75, 0.5
2190, 1.6166666666667, 0.65, 0.5
2191, 1.6166666666667, 0.55, 0.5
2192, 1.6166666666667, 0.45, 0.5
2193, 1.6166666666667, 0.35, 0.5
2194, 1.6166666666667, 0.25, 0.5
2195, 1.7, 1.25, 0.5
2196, 1.7, 1.15, 0.5
2197, 1.7, 1.05, 0.5
2198, 1.7, 0.95, 0.5
2199, 1.7, 0.85, 0.5
2200, 1.7, 0.75, 0.5
2201, 1.7, 0.65, 0.5
2202, 1.7, 0.55, 0.5
2203, 1.7, 0.45, 0.5
2204, 1.7, 0.35, 0.5
2205, 1.7, 0.25, 0.5
2206, 1.7833333333333, 1.25, 0.5
2207, 1.7833333333333, 1.15, 0.5
2208, 1.7833333333333, 1.05, 0.5
2209, 1.7833333333333, 0.95, 0.5
2210, 1.7833333333333, 0.85, 0.5
2211, 1.7833333333333, 0.75, 0.5
2212, 1.7833333333333, 0.65, 0.5
2213, 1.7833333333333, 0.55, 0.5
2214, 1.7833333333333, 0.45, 0.5
2215, 1.7833333333333, 0.35, 0.5
2216, 1.7833333333333, 0.25, 0.5
2217, 1.8666666666667, 1.25, 0.5
2218, 1.8666666666667, 1.15, 0.5
2219, 1.8666666666667, 1.05, 0.5
2220, 1.8666666666667, 0.95, 0.5
2221, 1.8666666666667, 0.85, 0.5
2222, 1.8666666666667, 0.75, 0.5
2223, 1.8666666666667, 0.65, 0.5
2224, 1.8666666666667, 0.55, 0.5
2225, 1.8666666666667, 0.45, 0.5
2226, 1.8666666666667, 0.35, 0.5
2227, 1.8666666666667, 0.25, 0.5
2228, 1.95, 1.25, 0.5
2229, 1.95, 1.15, 0.5
2230, 1.95, 1.05, 0.5
2231, 1.95, 0.95, 0.5
2232, 1.95, 0.85, 0.5
2233, 1.95, 0.75, 0.5
2234, 1.95, 0.65, 0.5
2235, 1.95, 0.55, 0.5
2236, 1.95, 0.45, 0.5
2237, 1.95, 0.35, 0.5
2238, 1.95, 0.25, 0.5
2239, 2.0333333333333, 1.25, 0.5
2240, 2.0333333333333, 1.15, 0.5
2241, 2.0333333333333, 1.05, 0.5
2242, 2.0333333333333, 0.95, 0.5
2243, 2.0333333333333, 0.85, 0.5
2244, 2.0333333333333, 0.75, 0.5
2245, 2.0333333333333, 0.65, 0.5
2246, 2.0333333333333, 0.55, 0.5
2247, 2.0333333333333, 0.45, 0.5
2248, 2.0333333333333, 0.35, 0.5
2249, 2.0333333333333, 0.25, 0.5
2250, 2.1166666666667, 1.25, 0.5
2251, 2.1166666666667, 1.15, 0.5
2252, 2.1166666666667, 1.05, 0.5
2253, 2.1166666666667, 0.95, 0.5
2254, 2.1166666666667, 0.85, 0.5
2255, 2.1166666666667, 0.75, 0.5
2256, 2.1166666666667, 0.65, 0.5
2257, 2.1166666666667, 0.55, 0.5
2258, 2.1166666666667, 0.45, 0.5
2259, 2.1166666666667, 0.35, 0.5
2260, 2.1166666666667, 0.25, 0.5
2261, 1.2833333333333, 1.25, 0
2262, 1.2833333333333, 1.15, 0
2263, 1.2833333333333, 1.05, 0
2264, 1.2833333333333, 0.95, 0
2265, 1.2833333333333, 0.85, 0
2266, 1.2833333333333, 0.75, 0
2267, 1.2833333333333, 0.65, 0
2268, 1.2833333333333, 0.55, 0
2269, 1.2833333333333, 0.45, 0
2270, 1.2833333333333, 0.35, 0
2271, 1.2833333333333, 0.25, 0
2272, 1.3666666666667, 1.25, 0
2273, 1.3666666666667, 1.15, 0
2274, 1.3666666666667, 1.05, 0
2275, 1.3666666666667, 0.95, 0
2276, 1.3666666666667, 0.85, 0
2277, 1.3666666666667, 0.75, 0
2278, 1.3666666666667, 0.65, 0
2279, 1.3666666666667, 0.55, 0
2280, 1.3666666666667, 0.45, 0
2281, 1.3666666666667, 0.35, 0
2282, 1.3666666666667, 0.25, 0
2283, 1.45, 1.25, 0
2284, 1.45, 1.15, 0
2285, 1.45, 1.05, 0
2286, 1.45, 0.95, 0
2287, 1.45, 0.85, 0
2288, 1.45, 0.75, 0
2289, 1.45, 0.65, 0
2290, 1.45, 0.55, 0
2291, 1.45, 0.45, 0
2292, 1.45, 0.35, 0
2293, 1.45, 0.25, 0
2294, 1.5333333333333, 1.25, 0
2295, 1.5333333333333, 1.15, 0
2296, 1.5333333333333, 1.05, 0
2297, 1.5333333333333, 0.95, 0
2298, 1.5333333333333, 0.85, 0
2299, 1.5333333333333, 0.75, 0
2300, 1.5333333333333, 0.65, 0
2301, 1.5333333333333, 0.55, 0
2302, 1.5333333333333, 0.45, 0
2303, 1.5333333333333, 0.35, 0
2304, 1.5333333333333, 0.25, 0
2305, 1.6166666666667, 1.25, 0
2306, 1.6166666666667, 1.15, 0
2307, 1.6166666666667, 1.05, 0
2308, 1.6166666666667, 0.95, 0
2309, 1.6166666666667, 0.85, 0
2310, 1.6166666666667, 0.75, 0
2311, 1.6166666666667, 0.65, 0
2312, 1.6166666666667, 0.55, 0
2313, 1.6166666666667, 0.45, 0
2314, 1.6166666666667, 0.35, 0
2315, 1.6166666666667, 0.25, 0
2316, 1.7, 1.25, 0
2317, 1.7, 1.15, 0
2318, 1.7, 1.05, 0
2319, 1.7, 0.95, 0
2320, 1.7, 0.85, 0
2321, 1.7, 0.75, 0
2322, 1.7, 0.65, 0
2323, 1.7, 0.55, 0
2324, 1.7, 0.45, 0
2325, 1.7, 0.35, 0
2326, 1.7, 0.25, 0
2327, 1.7833333333333, 1.25, 0
2328, 1.7833333333333, 1.15, 0
2329, 1.7833333333333, 1.05, 0
2330, 1.7833333333333, 0.95, 0
2331, 1.7833333333333, 0.85, 0
2332, 1.7833333333333, 0.75, 0
2333, 1.7833333333333, 0.65, 0
2334, 1.7833333333333, 0.55, 0
2335, 1.7833333333333, 0.45, 0
2336, 1.7833333333333, 0.35, 0
2337, 1.7833333333333, 0.25, 0
2338, 1.8666666666667, 1.25, 0
2339, 1.8666666666667, 1.15, 0
2340, 1.8666666666667, 1.05, 0
2341, 1.8666666666667, 0.95, 0
2342, 1.8666666666667, 0.85, 0
2343, 1.8666666666667, 0.75, 0
2344, 1.8666666666667, 0.65, 0
2345, 1.8666666666667, 0.55, 0
2346, 1.8666666666667, 0.45, 0
2347, 1.8666666666667, 0.35, 0
2348, 1.8666666666667, 0.25, 0
2349, 1.95, 1.25, 0
2350, 1.95, 1.15, 0
2351, 1.95, 1.05, 0
2352, 1.95, 0.95, 0
2353, 1.95, 0.85, 0
2354, 1.95, 0.75, 0
2355, 1.95, 0.65, 0
2356, 1.95, 0.55, 0
2357, 1.95, 0.45, 0
2358, 1.95, 0.35, 0
2359, 1.95, 0.25, 0
2360, 2.0333333333333, 1.25, 0
2361, 2.0333333333333, 1.15, 0
2362, 2.0333333333333, 1.05, 0
2363, 2.0333333333333, 0.95, 0
2364, 2.0333333333333, 0.85, 0
2365, 2.0333333333333, 0.75, 0
2366, 2.0333333333333, 0.65, 0
2367, 2.0333333333333, 0.55, 0
2368, 2.0333333333333, 0.45, 0
2369, 2.0333333333333, 0.35, 0
2370, 2.0333333333333, 0.25, 0
2371, 2.1166666666667, 1.25, 0
2372, 2.1166666666667, 1.15, 0
2373, 2.1166666666667, 1.05, 0
2374, 2.1166666666667, 0.95, 0
2375, 2.1166666666667, 0.85, 0
2376, 2.1166666666667, 0.75, 0
2377, 2.1166666666667, 0.65, 0
2378, 2.1166666666667, 0.55, 0
2379, 2.1166666666667, 0.45, 0
2380, 2.1166666666667, 0.35, 0
2381, 2.1166666666667, 0.25, 0
2382, 1.2, 1.25, 0.083333333333333
2383, 1.2, 1.15, 0.083333333333333
2384, 1.2, 1.05, 0.083333333333333
2385, 1.2, 0.95, 0.083333333333333
2386, 1.2, 0.85, 0.083333333333333
2387, 1.2, 0.75, 0.083333333333333
2388, 1.2, 0.65, 0.083333333333333
2389, 1.2, 0.55, 0.083333333333333
2390, 1.2, 0.45, 0.083333333333333
2391, 1.2, 0.35, 0.083333333333333
2392, 1.2, 0.25, 0.083333333333333
2393, 1.2, 1.25, 0.16666666666667
2394, 1.2, 1.15, 0.16666666666667
2395, 1.2, 1.05, 0.16666666666667
2396, 1.2, 0.95, 0.16666666666667
2397, 1.2, 0.85, 0.16666666666667
2398, 1.2, 0.75, 0.16666666666667
2399, 1.2, 0.65, 0.16666666666667
2400, 1.2, 0.55, 0.16666666666667
2401, 1.2, 0.45, 0.16666666666667
2402, 1.2, 0.35, 0.16666666666667
2403, 1.2, 0.25, 0.16666666666667
2404, 1.2, 1.25, 0.25
2405, 1.2, 1.15, 0.25
2406, 1.2, 1.05, 0.25
2407, 1.2, 0.95, 0.25
2408, 1.2, 0.85, 0.25
2409, 1.2, 0.75, 0.25
2410, 1.2, 0.65, 0.25
2411, 1.2, 0.55, 0.25
2412, 1.2, 0.45, 0.25
2413, 1.2, 0.35, 0.25
2414, 1.2, 0.25, 0.25
2415, 1.2, 1.25, 0.33333333333333
2416, 1.2, 1.15, 0.33333333333333
2417, 1.2, 1.05, 0.33333333333333
2418, 1.2, 0.95, 0.33333333333333
2419, 1.2, 0.85, 0.33333333333333
2420, 1.2, 0.75, 0.33333333333333
2421, 1.2, 0.65, 0.33333333333333
2422, 1.2, 0.55, 0.33333333333333
2423, 1.2, 0.45, 0.33333333333333
2424, 1.2, 0.35, 0.33333333333333
2425, 1.2, 0.25, 0.33333333333333
2426, 1.2, 1.25, 0.41666666666667
2427, 1.2, 1.15, 0.41666666666667
2428, 1.2, 1.05, 0.41666666666667
2429, 1.2, 0.95, 0.41666666666667
2430, 1.2, 0.85, 0.41666666666667
2431, 1.2, 0.75, 0.41666666666667
2432, 1.2, 0.65, 0.41666666666667
2433, 1.2, 0.55, 0.41666666666667
2434, 1.2, 0.45, 0.41666666666667
2435, 1.2, 0.35, 0.41666666666667
2436, 1.2, 0.25, 0.41666666666667
2437, 2.2, 1.25, 0.083333333333333
2438, 2.2, 1.15, 0.083333333333333
2439, 2.2, 1.05, 0.083333333333333
2440, 2.2, 0.95, 0.083333333333333
2441, 2.2, 0.85, 0.083333333333333
2442, 2.2, 0.75, 0.083333333333333
2443, 2.2, 0.65, 0.083333333333333
2444, 2.2, 0.55, 0.083333333333333
2445, 2.2, 0.45, 0.083333333333333
2446, 2.2, 0.35, 0.083333333333333
2447, 2.2, 0.25, 0.083333333333333
2448, 2.2, 1.25, 0.16666666666667
2449, 2.2, 1.15, 0.16666666666667
2450, 2.2, 1.05, 0.16666666666667
2451, 2.2, 0.95, 0.16666666666667
2452, 2.2, 0.85, 0.16666666666667
2453, 2.2, 0.75, 0.16666666666667
2454, 2.2, 0.65, 0.16666666666667
2455, 2.2, 0.55, 0.16666666666667
2456, 2.2, 0.45, 0.16666666666667
2457, 2.2, 0.35, 0.16666666666667
2458, 2.2, 0.25, 0.16666666666667
2459, 2.2, 1.25, 0.25
2460, 2.2, 1.15, 0.25
2461, 2.2, 1.05, 0.25
2462, 2.2, 0.95, 0.25
2463, 2.2, 0.85, 0.25
2464, 2.2, 0.75, 0.25
2465, 2.2, 0.65, 0.25
2466, 2.2, 0.55, 0.25
2467, 2.2, 0.45, 0.25
2468, 2.2, 0.35, 0.25
2469, 2.2, 0.25, 0.25
2470, 2.2, 1.25, 0.33333333333333
2471, 2.2, 1.15, 0.33333333333333
2472, 2.2, 1.05, 0.33333333333333
2473, 2.2, 0.95, 0.33333333333333
2474, 2.2, 0.85, 0.33333333333333
2475, 2.2, 0.75, 0.33333333333333
2476, 2.2, 0.65, 0.33333333333333
2477, 2.2, 0.55, 0.33333333333333
2478, 2.2, 0.45, 0.33333333333333
2479, 2.2, 0.35, 0.33333333333333
2480, 2.2, 0.25, 0.33333333333333
2481, 2.2, 1.25, 0.41666666666667
2482, 2.2, 1.15, 0.41666666666667
2483, 2.2, 1.05, 0.41666666666667
2484, 2.2, 0.95, 0.41666666666667
2485, 2.2, 0.85, 0.41666666666667
2486, 2.2, 0.75, 0.41666666666667
2487, 2.2, 0.65, 0.41666666666667
2488, 2.2, 0.55, 0.41666666666667
2489, 2.2, 0.45, 0.41666666666667
2490, 2.2, 0.35, 0.41666666666667
2491, 2.2, 0.25, 0.41666666666667
2492, 1.2833333333333, 0.15, 0.083333333333333
2493, 1.3666666666667, 0.15, 0.083333333333333
2494, 1.45, 0.15, 0.083333333333333
2495, 1.5333333333333, 0.15, 0.083333333333333
2496, 1.6166666666667, 0.15, 0.083333333333333
2497, 1.7, 0.15, 0.083333333333333
2498, 1.7833333333333, 0.15, 0.083333333333333
2499, 1.8666666666667, 0.15, 0.083333333333333
2500, 1.95, 0.15, 0.083333333333333
2501, 2.0333333333333, 0.15, 0.083333333333333
2502, 2.1166666666667, 0.15, 0.083333333333333
2503, 1.2833333333333, 0.15, 0.16666666666667
2504, 1.3666666666667, 0.15, 0.16666666666667
2505, 1.45, 0.15, 0.16666666666667
2506, 1.5333333333333, 0.15, 0.16666666666667
2507, 1.6166666666667, 0.15, 0.16666666666667
2508, 1.7, 0.15, 0.16666666666667
2509, 1.7833333333333, 0.15, 0.16666666666667
2510, 1.8666666666667, 0.15, 0.16666666666667
2511, 1.95, 0.15, 0.16666666666667
2512, 2.0333333333333, 0.15, 0.16666666666667
2513, 2.1166666666667, 0.15, 0.16666666666667
2514, 1.2833333333333, 0.15, 0.25
2515, 1.3666666666667, 0.15, 0.25
2516, 1.45, 0.15, 0.25
2517, 1.5333333333333, 0.15, 0.25
2518, 1.6166666666667, 0.15, 0.25
2519, 1.7, 0.15, 0.25
2520, 1.7833333333333, 0.15, 0.25
2521, 1.8666666666667, 0.15, 0.25
2522, 1.95, 0.15, 0.25
2523, 2.0333333333333, 0.15, 0.25
2524, 2.1166666666667, 0.15, 0.25
2525, 1.2833333333333, 0.15, 0.33333333333333
2526, 1.3666666666667, 0.15, 0.33333333333333
2527, 1.45, 0.15, 0.33333333333333
2528, 1.5333333333333, 0.15, 0.33333333333333
2529, 1.6166666666667, 0.15, 0.33333333333333
2530, 1.7, 0.15, 0.33333333333333
2531, 1.7833333333333, 0.15, 0.33333333333333
2532, 1.8666666666667, 0.15, 0.33333333333333
2533, 1.95, 0.15, 0.33333333333333
2534, 2.0333333333333, 0.15, 0.33333333333333
2535, 2.1166666666667, 0.15, 0.33333333333333
2536, 1.2833333333333, 0.15, 0.41666666666667
2537, 1.3666666666667, 0.15, 0.41666666666667
2538, 1.45, 0.15, 0.41666666666667
2539, 1.5333333333333, 0.15, 0.41666666666667
2540, 1.6166666666667, 0.15, 0.41666666666667
2541, 1.7, 0.15, 0.41666666666667
2542, 1.7833333333333, 0.15, 0.41666666666667
2543, 1.8666666666667, 0.15, 0.41666666666667
2544, 1.95, 0.15, 0.41666666666667
2545, 2.0333333333333, 0.15, 0.41666666666667
2546, 2.1166666666667, 0.15, 0.41666666666667
2547, 1.2833333333333, 0.1, 0.083333333333333
2548, 1.3666666666667, 0.1, 0.083333333333333
2549, 1.45, 0.1, 0.083333333333333
2550, 1.5333333333333, 0.1, 0.083333333333333
2551, 1.6166666666667, 0.1, 0.083333333333333
2552, 1.7, 0.1, 0.083333333333333
2553, 1.7833333333333, 0.1, 0.083333333333333
2554, 1.8666666666667, 0.1, 0.083333333333333
2555, 1.95, 0.1, 0.083333333333333
2556, 2.0333333333333, 0.1, 0.083333333333333
2557, 2.1166666666667, 0.1, 0.083333333333333
2558, 1.2833333333333, 0.1, 0.16666666666667
2559, 1.3666666666667, 0.1, 0.16666666666667
2560, 1.45, 0.1, 0.16666666666667
2561, 1.5333333333333, 0.1, 0.16666666666667
2562, 1.6166666666667, 0.1, 0.16666666666667
2563, 1.7, 0.1, 0.16666666666667
2564, 1.7833333333333, 0.1, 0.16666666666667
2565, 1.8666666666667, 0.1, 0.16666666666667
2566, 1.95, 0.1, 0.16666666666667
2567, 2.0333333333333, 0.1, 0.16666666666667
2568, 2.1166666666667, 0.1, 0.16666666666667
2569, 1.2833333333333, 0.1, 0.25
2570, 1.3666666666667, 0.1, 0.25
2571, 1.45, 0.1, 0.25
2572, 1.5333333333333, 0.1, 0.25
2573, 1.6166666666667, 0.1, 0.25
2574, 1.7, 0.1, 0.25
2575, 1.7833333333333, 0.1, 0.25
2576, 1.8666666666667, 0.1, 0.25
2577, 1.95, 0.1, 0.25
2578, 2.0333333333333, 0.1, 0.25
2579, 2.1166666666667, 0.1, 0.25
2580, 1.2833333333333, 0.1, 0.33333333333333
2581, 1.3666666666667, 0.1, 0.33333333333333
2582, 1.45, 0.1, 0.33333333333333
2583, 1.5333333333333, 0.1, 0.33333333333333
2584, 1.6166666666667, 0.1, 0.33333333333333
2585, 1.7, 0.1, 0.33333333333333
2586, 1.7833333333333, 0.1, 0.33333333333333
2587, 1.8666666666667, 0.1, 0.33333333333333
2588, 1.95, 0.1, 0.33333333333333
2589, 2.0333333333333, 0.1, 0.33333333333333
2590, 2.1166666666667, 0.1, 0.33333333333333
2591, 1.2833333333333, 0.1, 0.41666666666667
2592, 1.3666666666667, 0.1, 0.41666666666667
2593, 1.45, 0.1, 0.41666666666667
2594, 1.5333333333333, 0.1, 0.41666666666667
2595, 1.6166666666667, 0.1, 0.41666666666667
2596, 1.7, 0.1, 0.41666666666667
2597, 1.7833333333333, 0.1, 0.41666666666667
2598, 1.8666666666667, 0.1, 0.41666666666667
2599, 1.95, 0.1, 0.41666666666667
2600, 2.0333333333333, 0.1, 0.41666666666667
2601, 2.1166666666667, 0.1, 0.41666666666667
2602, 1.2833333333333, 0.066666666666667, 0.5
2603, 1.2833333333333, 0.033333333333333, 0.5
2604, 1.3666666666667, 0.066666666666667, 0.5
2605, 1.3666666666667, 0.033333333333333, 0.5
2606, 1.45, 0.066666666666667, 0.5
2607, 1.45, 0.033333333333333, 0.5
2608, 1.5333333333333, 0.066666666666667, 0.5
2609, 1.5333333333333, 0.033333333333333, 0.5
2610, 1.6166666666667, 0.066666666666667, 0.5
2611, 1.6166666666667, 0.033333333333333, 0.5
2612, 1.7, 0.066666666666667, 0.5
2613, 1.7, 0.033333333333333, 0.5
2614, 1.7833333333333, 0.066666666666667, 0.5
2615, 1.7833333333333, 0.033333333333333, 0.5
2616, 1.8666666666667, 0.066666666666667, 0.5
2617, 1.8666666666667, 0.033333333333333, 0.5
2618, 1.95, 0.066666666666667, 0.5
2619, 1.95, 0.033333333333333, 0.5
2620, 2.0333333333333, 0.066666666666667, 0.5
2621, 2.0333333333333, 0.033333333333333, 0.5
2622, 2.1166666666667, 0.066666666666667, 0.5
2623, 2.1166666666667, 0.033333333333333, 0.5
2624, 1.2833333333333, 0.066666666666667, 0
2625, 1.2833333333333, 0.033333333333333, 0
2626, 1.3666666666667, 0.066666666666667, 0
2627, 1.3666666666667, 0.033333333333333, 0
2628, 1.45, 0.066666666666667, 0
2629, 1.45, 0.033333333333333, 0
2630, 1.5333333333333, 0.066666666666667, 0
2631, 1.5333333333333, 0.033333333333333, 0
2632, 1.6166666666667, 0.066666666666667, 0
2633, 1.6166666666667, 0.033333333333333, 0
2634, 1.7, 0.066666666666667, 0
2635, 1.7, 0.033333333333333, 0
2636, 1.7833333333333, 0.066666666666667, 0
2637, 1.7833333333333, 0.033333333333333, 0
2638, 1.8666666666667, 0.066666666666667, 0
2639, 1.8666666666667, 0.033333333333333, 0
2640, 1.95, 0.066666666666667, 0
2641, 1.95, 0.033333333333333, 0
2642, 2.0333333333333, 0.066666666666667, 0
2643, 2.0333333333333, 0.033333333333333, 0
2644, 2.1166666666667, 0.066666666666667, 0
2645, 2.1166666666667, 0.033333333333333, 0
2646, 1.2, 0.066666666666667, 0.083333333333333
2647, 1.2, 0.033333333333333, 0.083333333333333
2648, 1.2, 0.066666666666667, 0.16666666666667
2649, 1.2, 0.033333333333333, 0.16666666666667
2650, 1.2, 0.066666666666667, 0.25
2651, 1.2, 0.033333333333333, 0.25
2652, 1.2, 0.066666666666667, 0.33333333333333
2653, 1.2, 0.033333333333333, 0.33333333333333
2654, 1.2, 0.066666666666667, 0.41666666666667
2655, 1.2, 0.033333333333333, 0.41666666666667
2656, 2.2, 0.066666666666667, 0.083333333333333
2657, 2.2, 0.033333333333333, 0.083333333333333
2658, 2.2, 0.066666666666667, 0.16666666666667
2659, 2.2, 0.033333333333333, 0.16666666666667
2660, 2.2, 0.066666666666667, 0.25
2661, 2.2, 0.033333333333333, 0.25
2662, 2.2, 0.066666666666667, 0.33333333333333
2663, 2.2, 0.033333333333333, 0.33333333333333
2664, 2.2, 0.066666666666667, 0.41666666666667
2665, 2.2, 0.033333333333333, 0.41666666666667
2666, 1.2833333333333, 1.2490009027033e-16, 0.083333333333333
2667, 1.3666666666667, 1.2490009027033e-16, 0.083333333333333
2668, 1.45, 1.2490009027033e-16, 0.083333333333333
2669, 1.5333333333333, 1.2490009027033e-16, 0.083333333333333
2670, 1.6166666666667, 1.2490009027033e-16, 0.083333333333333
2671, 1.7, 1.2490009027033e-16, 0.083333333333333
2672, 1.7833333333333, 1.2490009027033e-16, 0.083333333333333
2673, 1.8666666666667, 1.2490009027033e-16, 0.083333333333333
2674, 1.95, 1.2490009027033e-16, 0.083333333333333
2675, 2.0333333333333, 1.2490009027033e-16, 0.083333333333333
2676, 2.1166666666667, 1.2490009027033e-16, 0.083333333333333
2677, 1.2833333333333, 1.2490009027033e-16, 0.16666666666667
2678, 1.3666666666667, 1.2490009027033e-16, 0.16666666666667
2679, 1.45, 1.2490009027033e-16, 0.16666666666667
2680, 1.5333333333333, 1.2490009027033e-16, 0.16666666666667
2681, 1.6166666666667, 1.2490009027033e-16, 0.16666666666667
2682, 1.7, 1.2490009027033e-16, 0.16666666666667
2683, 1.7833333333333, 1.2490009027033e-16, 0.16666666666667
2684, 1.8666666666667, 1.2490009027033e-16, 0.16666666666667
2685, 1.95, 1.2490009027033e-16, 0.16666666666667
2686, 2.0333333333333, 1.2490009027033e-16, 0.16666666666667
2687, 2.1166666666667, 1.2490009027033e-16, 0.16666666666667
2688, 1.2833333333333, 1.2490009027033e-16, 0.25
2689, 1.3666666666667, 1.2490009027033e-16, 0.25
2690, 1.45, 1.2490009027033e-16, 0.25
2691, 1.5333333333333, 1.2490009027033e-16, 0.25
2692, 1.6166666666667, 1.2490009027033e-16, 0.25
2693, 1.7, 1.2490009027033e-16, 0.25
2694, 1.7833333333333, 1.2490009027033e-16, 0.25
2695, 1.8666666666667, 1.2490009027033e-16, 0.25
2696, 1.95, 1.2490009027033e-16, 0.25
2697, 2.0333333333333, 1.2490009027033e-16, 0.25
2698, 2.1166666666667, 1.2490009027033e-16, 0.25
2699, 1.2833333333333, 1.2490009027033e-16, 0.33333333333333
2700, 1.3666666666667, 1.2490009027033e-16, 0.33333333333333
2701, 1.45, 1.2490009027033e-16, 0.33333333333333
2702, 1.5333333333333, 1.2490009027033e-16, 0.33333333333333
2703, 1.6166666666667, 1.2490009027033e-16, 0.33333333333333
2704, 1.7, 1.2490009027033e-16, 0.33333333333333
2705, 1.7833333333333, 1.2490009027033e-16, 0.33333333333333
2706, 1.8666666666667, 1.2490009027033e-16, 0.33333333333333
2707, 1.95, 1.2490009027033e-16, 0.33333333333333
2708, 2.0333333333333, 1.2490009027033e-16, 0.33333333333333
2709, 2.1166666666667, 1.2490009027033e-16, 0.33333333333333
2710, 1.2833333333333, 1.2490009027033e-16, 0.41666666666667
2711, 1.3666666666667, 1.2490009027033e-16, 0.41666666666667
2712, 1.45, 1.2490009027033e-16, 0.41666666666667
2713, 1.5333333333333, 1.2490009027033e-16, 0.41666666666667
2714, 1.6166666666667, 1.2490009027033e-16, 0.41666666666667
2715, 1.7, 1.2490009027033e-16, 0.41666666666667
2716, 1.7833333333333, 1.2490009027033e-16, 0.41666666666667
2717, 1.8666666666667, 1.2490009027033e-16, 0.41666666666667
2718, 1.95, 1.2490009027033e-16, 0.41666666666667
2719, 2.0333333333333, 1.2490009027033e-16, 0.41666666666667
2720, 2.1166666666667, 1.2490009027033e-16, 0.41666666666667
2721, 2.3, 0.066666666666667, 0.083333333333333
2722, 2.3, 0.033333333333333, 0.083333333333333
2723, 2.3, 0.066666666666667, 0.16666666666667
2724, 2.3, 0.033333333333333, 0.16666666666667
2725, 2.3, 0.066666666666667, 0.25
2726, 2.3, 0.033333333333333, 0.25
2727, 2.3, 0.066666666666667, 0.33333333333333
2728, 2.3, 0.033333333333333, 0.33333333333333
2729, 2.3, 0.066666666666667, 0.41666666666667
2730, 2.3, 0.033333333333333, 0.41666666666667
2731, -0.1, 0.033333333333333, 0.083333333333333
2732, -0.1, 0.066666666666667, 0.083333333333333
2733, -0.1, 0.033333333333333, 0.16666666666667
2734, -0.1, 0.066666666666667, 0.16666666666667
2735, -0.1, 0.033333333333333, 0.25
2736, -0.1, 0.066666666666667, 0.25
2737, -0.1, 0.033333333333333, 0.33333333333333
2738, -0.1, 0.066666666666667, 0.33333333333333
2739, -0.1, 0.033333333333333, 0.41666666666667
2740, -0.1, 0.066666666666667, 0.41666666666667
2741, 1.05, 0.25, 0.083333333333333
2742, 1.05, 0.35, 0.083333333333333
2743, 1.05, 0.45, 0.083333333333333
2744, 1.05, 0.55, 0.083333333333333
2745, 1.05, 0.65, 0.083333333333333
2746, 1.05, 0.75, 0.083333333333333
2747, 1.05, 0.85, 0.083333333333333
2748, 1.05, 0.95, 0.083333333333333
2749, 1.05, 1.05, 0.083333333333333
2750, 1.05, 1.15, 0.083333333333333
2751, 1.05, 1.25, 0.083333333333333
2752, 1.05, 0.25, 0.16666666666667
2753, 1.05, 0.35, 0.16666666666667
2754, 1.05, 0.45, 0.16666666666667
2755, 1.05, 0.55, 0.16666666666667
2756, 1.05, 0.65, 0.16666666666667
2757, 1.05, 0.75, 0.16666666666667
2758, 1.05, 0.85, 0.16666666666667
2759, 1.05, 0.95, 0.16666666666667
2760, 1.05, 1.05, 0.16666666666667
2761, 1.05, 1.15, 0.16666666666667
2762, 1.05, 1.25, 0.16666666666667
2763, 1.05, 0.25, 0.25
2764, 1.05, 0.35, 0.25
2765, 1.05, 0.45, 0.25
2766, 1.05, 0.55, 0.25
2767, 1.05, 0.65, 0.25
2768, 1.05, 0.75, 0.25
2769, 1.05, 0.85, 0.25
2770, 1.05, 0.95, 0.25
2771, 1.05, 1.05, 0.25
2772, 1.05, 1.15, 0.25
2773, 1.05, 1.25, 0.25
2774, 1.05, 0.25, 0.33333333333333
2775, 1.05, 0.35, 0.33333333333333
2776, 1.05, 0.45, 0.33333333333333
2777, 1.05, 0.55, 0.33333333333333
2778, 1.05, 0.65, 0.33333333333333
2779, 1.05, 0.75, 0.33333333333333
2780, 1.05, 0.85, 0.33333333333333
2781, 1.05, 0.95, 0.33333333333333
2782, 1.05, 1.05, 0.33333333333333
2783, 1.05, 1.15, 0.33333333333333
2784, 1.05, 1.25, 0.33333333333333
2785, 1.05, 0.25, 0.41666666666667
2786, 1.05, 0.35, 0.41666666666667
2787, 1.05, 0.45, 0.41666666666667
2788, 1.05, 0.55, 0.41666666666667
2789, 1.05, 0.65, 0.41666666666667
2790, 1.05, 0.75, 0.41666666666667
2791, 1.05, 0.85, 0.41666666666667
2792, 1.05, 0.95, 0.41666666666667
2793, 1.05, 1.05, 0.41666666666667
2794, 1.05, 1.15, 0.41666666666667
2795, 1.05, 1.25, 0.41666666666667
2796, 1.15, 1.25, 0.083333333333333
2797, 1.15, 1.15, 0.083333333333333
2798, 1.15, 1.05, 0.083333333333333
2799, 1.15, 0.95, 0.083333333333333
2800, 1.15, 0.85, 0.083333333333333
2801, 1.15, 0.75, 0.083333333333333
2802, 1.15, 0.65, 0.083333333333333
2803, 1.15, 0.55, 0.083333333333333
2804, 1.15, 0.45, 0.083333333333333
2805, 1.15, 0.35, 0.083333333333333
2806, 1.15, 0.25, 0.083333333333333
2807, 1.15, 1.25, 0.16666666666667
2808, 1.15, 1.15, 0.16666666666667
2809, 1.15, 1.05, 0.16666666666667
2810, 1.15, 0.95, 0.16666666666667
2811, 1.15, 0.85, 0.16666666666667
2812, 1.15, 0.75, 0.16666666666667
2813, 1.15, 0.65, 0.16666666666667
2814, 1.15, 0.55, 0.16666666666667
2815, 1.15, 0.45, 0.16666666666667
2816, 1.15, 0.35, 0.16666666666667
2817, 1.15, 0.25, 0.16666666666667
2818, 1.15, 1.25, 0.25
2819, 1.15, 1.15, 0.25
2820, 1.15, 1.05, 0.25
2821, 1.15, 0.95, 0.25
2822, 1.15, 0.85, 0.25
2823, 1.15, 0.75, 0.25
2824, 1.15, 0.65, 0.25
2825, 1.15, 0.55, 0.25
2826, 1.15, 0.45, 0.25
2827, 1.15, 0.35, 0.25
2828, 1.15, 0.25, 0.25
2829, 1.15, 1.25, 0.33333333333333
2830, 1.15, 1.15, 0.33333333333333
2831, 1.15, 1.05, 0.33333333333333
2832, 1.15, 0.95, 0.33333333333333
2833, 1.15, 0.85, 0.33333333333333
2834, 1.15, 0.75, 0.33333333333333
2835, 1.15, 0.65, 0.33333333333333
2836, 1.15, 0.55, 0.33333333333333
2837, 1.15, 0.45, 0.33333333333333
2838, 1.15, 0.35, 0.33333333333333
2839, 1.15, 0.25, 0.33333333333333
2840, 1.15, 1.25, 0.41666666666667
2841, 1.15, 1.15, 0.41666666666667
2842, 1.15, 1.05, 0.41666666666667
2843, 1.15, 0.95, 0.41666666666667
2844, 1.15, 0.85, 0.41666666666667
2845, 1.15, 0.75, 0.41666666666667
2846, 1.15, 0.65, 0.41666666666667
2847, 1.15, 0.55, 0.41666666666667
2848, 1.15, 0.45, 0.41666666666667
2849, 1.15, 0.35, 0.41666666666667
2850, 1.15, 0.25, 0.41666666666667
2851, 0.083333333333333, 0.25, -0.1
2852, 0.083333333333333, 0.35, -0.1
2853, 0.083333333333333, 0.45, -0.1
2854, 0.083333333333333, 0.55, -0.1
2855, 0.083333333333333, 0.65, -0.1
2856, 0.083333333333333, 0.75, -0.1
2857, 0.083333333333333, 0.85, -0.1
2858, 0.083333333333333, 0.95, -0.1
2859, 0.083333333333333, 1.05, -0.1
2860, 0.083333333333333, 1.15, -0.1
2861, 0.083333333333333, 1.25, -0.1
2862, 0.16666666666667, 0.25, -0.1
2863, 0.16666666666667, 0.35, -0.1
2864, 0.16666666666667, 0.45, -0.1
2865, 0.16666666666667, 0.55, -0.1
2866, 0.16666666666667, 0.65, -0.1
2867, 0.16666666666667, 0.75, -0.1
2868, 0.16666666666667, 0.85, -0.1
2869, 0.16666666666667, 0.95, -0.1
2870, 0.16666666666667, 1.05, -0.1
2871, 0.16666666666667, 1.15, -0.1
2872, 0.16666666666667, 1.25, -0.1
2873, 0.25, 0.25, -0.1
2874, 0.25, 0.35, -0.1
2875, 0.25, 0.45, -0.1
2876, 0.25, 0.55, -0.1
2877, 0.25, 0.65, -0.1
2878, 0.25, 0.75, -0.1
2879, 0.25, 0.85, -0.1
2880, 0.25, 0.95, -0.1
2881, 0.25, 1.05, -0.1
2882, 0.25, 1.15, -0.1
2883, 0.25, 1.25, -0.1
2884, 0.33333333333333, 0.25, -0.1
2885, 0.33333333333333, 0.35, -0.1
2886, 0.33333333333333, 0.45, -0.1
2887, 0.33333333333333, 0.55, -0.1
2888, 0.33333333333333, 0.65, -0.1
2889, 0.33333333333333, 0.75, -0.1
2890, 0.33333333333333, 0.85, -0.1
2891, 0.33333333333333, 0.95, -0.1
2892, 0.33333333333333, 1.05, -0.1
2893, 0.33333333333333, 1.15, -0.1
2894, 0.33333333333333, 1.25, -0.1
2895, 0.41666666666667, 0.25, -0.1
2896, 0.41666666666667, 0.35, -0.1
2897, 0.41666666666667, 0.45, -0.1
2898, 0.41666666666667, 0.55, -0.1
2899, 0.41666666666667, 0.65, -0.1
2900, 0.41666666666667, 0.75, -0.1
2901, 0.41666666666667, 0.85, -0.1
2902, 0.41666666666667, 0.95, -0.1
2903, 0.41666666666667, 1.05, -0.1
2904, 0.41666666666667, 1.15, -0.1
2905, 0.41666666666667, 1.25, -0.1
2906, 0.5, 0.25, -0.1
2907, 0.5, 0.35, -0.1
2908, 0.5, 0.45, -0.1
2909, 0.5, 0.55, -0.1
2910, 0.5, 0.65, -0.1
2911, 0.5, 0.75, -0.1
2912, 0.5, 0.85, -0.1
2913, 0.5, 0.95, -0.1
2914, 0.5, 1.05, -0.1
2915, 0.5, 1.15, -0.1
2916, 0.5, 1.25, -0.1
2917, 0.58333333333333, 0.25, -0.1
2918, 0.58333333333333, 0.35, -0.1
2919, 0.58333333333333, 0.45, -0.1
2920, 0.58333333333333, 0.55, -0.1
2921, 0.58333333333333, 0.65, -0.1
2922, 0.58333333333333, 0.75, -0.1
2923, 0.58333333333333, 0.85, -0.1
2924, 0.58333333333333, 0.95, -0.1
2925, 0.58333333333333, 1.05, -0.1
2926, 0.58333333333333, 1.15, -0.1
2927, 0.58333333333333, 1.25, -0.1
2928, 0.66666666666667, 0.25, -0.1
2929, 0.66666666666667, 0.35, -0.1
2930, 0.66666666666667, 0.45, -0.1
2931, 0.66666666666667, 0.55, -0.1
2932, 0.66666666666667, 0.65, -0.1
2933, 0.66666666666667, 0.75, -0.1
2934, 0.66666666666667, 0.85, -0.1
2935, 0.66666666666667, 0.95, -0.1
2936, 0.66666666666667, 1.05, -0.1
2937, 0.66666666666667, 1.15, -0.1
2938, 0.66666666666667, 1.25, -0.1
2939, 0.75, 0.25, -0.1
2940, 0.75, 0.35, -0.1
2941, 0.75, 0.45, -0.1
2942, 0.75, 0.55, -0.1
2943, 0.75, 0.65, -0.1
2944, 0.75, 0.75, -0.1
2945, 0.75, 0.85, -0.1
2946, 0.75, 0.95, -0.1
2947, 0.75, 1.05, -0.1
2948, 0.75, 1.15, -0.1
2949, 0.75, 1.25, -0.1
2950, 0.83333333333333, 0.25, -0.1
2951, 0.83333333333333, 0.35, -0.1
2952, 0.83333333333333, 0.45, -0.1
2953, 0.83333333333333, 0.55, -0.1
2954, 0.83333333333333, 0.65, -0.1
2955, 0.83333333333333, 0.75, -0.1
2956, 0.83333333333333, 0.85, -0.1
2957, 0.83333333333333, 0.95, -0.1
2958, 0.83333333333333, 1.05, -0.1
2959, 0.83333333333333, 1.15, -0.1
2960, 0.83333333333333, 1.25, -0.1
2961, 0.91666666666667, 0.25, -0.1
2962, 0.91666666666667, 0.35, -0.1
2963, 0.91666666666667, 0.45, -0.1
2964, 0.91666666666667, 0.55, -0.1
2965, 0.91666666666667, 0.65, -0.1
2966, 0.91666666666667, 0.75, -0.1
2967, 0.91666666666667, 0.85, -0.1
2968, 0.91666666666667, 0.95, -0.1
2969, 0.91666666666667, 1.05, -0.1
2970, 0.91666666666667, 1.15, -0.1
2971, 0.91666666666667, 1.25, -0.1
2972, 1.2833333333333, 1.25, -0.1
2973, 1.2833333333333, 1.15, -0.1
2974, 1.2833333333333, 1.05, -0.1
2975, 1.2833333333333, 0.95, -0.1
2976, 1.2833333333333, 0.85, -0.1
2977, 1.2833333333333, 0.75, -0.1
2978, 1.2833333333333, 0.65, -0.1
2979, 1.2833333333333, 0.55, -0.1
2980, 1.2833333333333, 0.45, -0.1
2981, 1.2833333333333, 0.35, -0.1
2982, 1.2833333333333, 0.25, -0.1
2983, 1.3666666666667, 1.25, -0.1
2984, 1.3666666666667, 1.15, -0.1
2985, 1.3666666666667, 1.05, -0.1
2986, 1.3666666666667, 0.95, -0.1
2987, 1.3666666666667, 0.85, -0.1
2988, 1.3666666666667, 0.75, -0.1
2989, 1.3666666666667, 0.65, -0.1
2990, 1.3666666666667, 0.55, -0.1
2991, 1.3666666666667, 0.45, -0.1
2992, 1.3666666666667, 0.35, -0.1
2993, 1.3666666666667, 0.25, -0.1
2994, 1.45, 1.25, -0.1
2995, 1.45, 1.15, -0.1
2996, 1.45, 1.05, -0.1
2997, 1.45, 0.95, -0.1
2998, 1.45, 0.85, -0.1
2999, 1.45, 0.75, -0.1
3000, 1.45, 0.65, -0.1
3001, 1.45, 0.55, -0.1
3002, 1.45, 0.45, -0.1
3003, 1.45, 0.35, -0.1
3004, 1.45, 0.25, -0.1
3005, 1.5333333333333, 1.25, -0.1
3006, 1.5333333333333, 1.15, -0.1
3007, 1.5333333333333, 1.05, -0.1
3008, 1.5333333333333, 0.95, -0.1
3009, 1.5333333333333, 0.85, -0.1
3010, 1.5333333333333, 0.75, -0.1
3011, 1.5333333333333, 0.65, -0.1
3012, 1.5333333333333, 0.55, -0.1
3013, 1.5333333333333, 0.45, -0.1
3014, 1.5333333333333, 0.35, -0.1
3015, 1.5333333333333, 0.25, -0.1
3016, 1.6166666666667, 1.25, -0.1
3017, 1.6166666666667, 1.15, -0.1
3018, 1.6166666666667, 1.05, -0.1
3019, 1.6166666666667, 0.95, -0.1
3020, 1.6166666666667, 0.85, -0.1
3021, 1.6166666666667, 0.75, -0.1
3022, 1.6166666666667, 0.65, -0.1
3023, 1.6166666666667, 0.55, -0.1
3024, 1.6166666666667, 0.45, -0.1
3025, 1.6166666666667, 0.35, -0.1
3026, 1.6166666666667, 0.25, -0.1
3027, 1.7, 1.25, -0.1
3028, 1.7, 1.15, -0.1
3029, 1.7, 1.05, -0.1
3030, 1.7, 0.95, -0.1
3031, 1.7, 0.85, -0.1
3032, 1.7, 0.75, -0.1
3033, 1.7, 0.65, -0.1
3034, 1.7, 0.55, -0.1
3035, 1.7, 0.45, -0.1
3036, 1.7, 0.35, -0.1
3037, 1.7, 0.25, -0.1
3038, 1.7833333333333, 1.25, -0.1
3039, 1.7833333333333, 1.15, -0.1
3040, 1.7833333333333, 1.05, -0.1
3041, 1.7833333333333, 0.95, -0.1
3042, 1.7833333333333, 0.85, -0.1
3043, 1.7833333333333, 0.75, -0.1
3044, 1.7833333333333, 0.65, -0.1
3045, 1.7833333333333, 0.55, -0.1
3046, 1.7833333333333, 0.45, -0.1
3047, 1.7833333333333, 0.35, -0.1
3048, 1.7833333333333, 0.25, -0.1
3049, 1.8666666666667, 1.25, -0.1
3050, 1.8666666666667, 1.15, -0.1
3051, 1.8666666666667, 1.05, -0.1
3052, 1.8666666666667, 0.95, -0.1
3053, 1.8666666666667, 0.85, -0.1
3054, 1.8666666666667, 0.75, -0.1
3055, 1.8666666666667, 0.65, -0.1
3056, 1.8666666666667, 0.55, -0.1
3057, 1.8666666666667, 0.45, -0.1
3058, 1.8666666666667, 0.35, -0.1
3059, 1.8666666666667, 0.25, -0.1
3060, 1.95, 1.25, -0.1
3061, 1.95, 1.15, -0.1
3062, 1.95, 1.05, -0.1
3063, 1.95, 0.95, -0.1
3064, 1.95, 0.85, -0.1
3065, 1.95, 0.75, -0.1
3066, 1.95, 0.65, -0.1
3067, 1.95, 0.55, -0.1
3068, 1.95, 0.45, -0.1
3069, 1.95, 0.35, -0.1
3070, 1.95, 0.25, -0.1
3071, 2.0333333333333, 1.25, -0.1
3072, 2.0333333333333, 1.15, -0.1
3073, 2.0333333333333, 1.05, -0.1
3074, 2.0333333333333, 0.95, -0.1
3075, 2.0333333333333, 0.85, -0.1
3076, 2.0333333333333, 0.75, -0.1
3077, 2.0333333333333, 0.65, -0.1
3078, 2.0333333333333, 0.55, -0.1
3079, 2.0333333333333, 0.45, -0.1
3080, 2.0333333333333, 0.35, -0.1
3081, 2.0333333333333, 0.25, -0.1
3082, 2.1166666666667, 1.25, -0.1
3083, 2.1166666666667, 1.15, -0.1
3084, 2.1166666666667, 1.05, -0.1
3085, 2.1166666666667, 0.95, -0.1
3086, 2.1166666666667, 0.85, -0.1
3087, 2.1166666666667, 0.75, -0.1
3088, 2.1166666666667, 0.65, -0.1
3089, 2.1166666666667, 0.55, -0.1
3090, 2.1166666666667, 0.45, -0.1
3091, 2.1166666666667, 0.35, -0.1
3092, 2.1166666666667, 0.25, -0.1
3093, 0.083333333333333, 1.54, 0
3094, 0.083333333333333, 1.58, 0
3095, 0.083333333333333, 1.62, 0
3096, 0.083333333333333, 1.66, 0
3097, 0.16666666666667, 1.54, 0
3098, 0.16666666666667, 1.58, 0
3099, 0.16666666666667, 1.62, 0
3100, 0.16666666666667, 1.66, 0
