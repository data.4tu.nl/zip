5789, 152, 1145, 1150, 153, 174, 1244, 1249, 175
5790, 1145, 1146, 1151, 1150, 1244, 1245, 1250, 1249
5791, 1146, 1147, 1152, 1151, 1245, 1246, 1251, 1250
5792, 1147, 1148, 1153, 1152, 1246, 1247, 1252, 1251
5793, 1148, 1149, 1154, 1153, 1247, 1248, 1253, 1252
5794, 1149, 163, 164, 1154, 1248, 190, 191, 1253
5795, 153, 1150, 1155, 154, 175, 1249, 1254, 176
5796, 1150, 1151, 1156, 1155, 1249, 1250, 1255, 1254
5797, 1151, 1152, 1157, 1156, 1250, 1251, 1256, 1255
5798, 1152, 1153, 1158, 1157, 1251, 1252, 1257, 1256
5799, 1153, 1154, 1159, 1158, 1252, 1253, 1258, 1257
5800, 1154, 164, 165, 1159, 1253, 191, 192, 1258
5801, 154, 1155, 1160, 155, 176, 1254, 1259, 177
5802, 1155, 1156, 1161, 1160, 1254, 1255, 1260, 1259
5803, 1156, 1157, 1162, 1161, 1255, 1256, 1261, 1260
5804, 1157, 1158, 1163, 1162, 1256, 1257, 1262, 1261
5805, 1158, 1159, 1164, 1163, 1257, 1258, 1263, 1262
5806, 1159, 165, 166, 1164, 1258, 192, 193, 1263
5807, 155, 1160, 1165, 156, 177, 1259, 1264, 178
5808, 1160, 1161, 1166, 1165, 1259, 1260, 1265, 1264
5809, 1161, 1162, 1167, 1166, 1260, 1261, 1266, 1265
5810, 1162, 1163, 1168, 1167, 1261, 1262, 1267, 1266
5811, 1163, 1164, 1169, 1168, 1262, 1263, 1268, 1267
5812, 1164, 166, 167, 1169, 1263, 193, 194, 1268
5813, 156, 1165, 1170, 157, 178, 1264, 1269, 179
5814, 1165, 1166, 1171, 1170, 1264, 1265, 1270, 1269
5815, 1166, 1167, 1172, 1171, 1265, 1266, 1271, 1270
5816, 1167, 1168, 1173, 1172, 1266, 1267, 1272, 1271
5817, 1168, 1169, 1174, 1173, 1267, 1268, 1273, 1272
5818, 1169, 167, 168, 1174, 1268, 194, 195, 1273
5819, 157, 1170, 118, 8, 179, 1269, 180, 9
5820, 1170, 1171, 119, 118, 1269, 1270, 181, 180
5821, 1171, 1172, 120, 119, 1270, 1271, 182, 181
5822, 1172, 1173, 121, 120, 1271, 1272, 183, 182
5823, 1173, 1174, 122, 121, 1272, 1273, 184, 183
5824, 1174, 168, 7, 122, 1273, 195, 11, 184
*ELEMENT, type=C3D8, ELSET=Volume3
5825, 10, 196, 1219, 169, 212, 1571, 4027, 1274
5826, 212, 1571, 4027, 1274, 213, 1572, 4028, 1275
5827, 213, 1572, 4028, 1275, 214, 1573, 4029, 1276
5828, 214, 1573, 4029, 1276, 215, 1574, 4030, 1277
5829, 215, 1574, 4030, 1277, 216, 1575, 4031, 1278
5830, 216, 1575, 4031, 1278, 217, 1576, 4032, 1279
5831, 217, 1576, 4032, 1279, 218, 1577, 4033, 1280
5832, 218, 1577, 4033, 1280, 219, 1578, 4034, 1281
5833, 219, 1578, 4034, 1281, 220, 1579, 4035, 1282
5834, 220, 1579, 4035, 1282, 221, 1580, 4036, 1283
5835, 221, 1580, 4036, 1283, 222, 1581, 4037, 1284
5836, 222, 1581, 4037, 1284, 14, 272, 1626, 223
5837, 196, 197, 1220, 1219, 1571, 1582, 4038, 4027
5838, 1571, 1582, 4038, 4027, 1572, 1583, 4039, 4028
5839, 1572, 1583, 4039, 4028, 1573, 1584, 4040, 4029
5840, 1573, 1584, 4040, 4029, 1574, 1585, 4041, 4030
5841, 1574, 1585, 4041, 4030, 1575, 1586, 4042, 4031
5842, 1575, 1586, 4042, 4031, 1576, 1587, 4043, 4032
5843, 1576, 1587, 4043, 4032, 1577, 1588, 4044, 4033
5844, 1577, 1588, 4044, 4033, 1578, 1589, 4045, 4034
5845, 1578, 1589, 4045, 4034, 1579, 1590, 4046, 4035
5846, 1579, 1590, 4046, 4035, 1580, 1591, 4047, 4036
5847, 1580, 1591, 4047, 4036, 1581, 1592, 4048, 4037
5848, 1581, 1592, 4048, 4037, 272, 273, 1627, 1626
5849, 197, 198, 1221, 1220, 1582, 1593, 4049, 4038
5850, 1582, 1593, 4049, 4038, 1583, 1594, 4050, 4039
5851, 1583, 1594, 4050, 4039, 1584, 1595, 4051, 4040
5852, 1584, 1595, 4051, 4040, 1585, 1596, 4052, 4041
5853, 1585, 1596, 4052, 4041, 1586, 1597, 4053, 4042
5854, 1586, 1597, 4053, 4042, 1587, 1598, 4054, 4043
5855, 1587, 1598, 4054, 4043, 1588, 1599, 4055, 4044
5856, 1588, 1599, 4055, 4044, 1589, 1600, 4056, 4045
5857, 1589, 1600, 4056, 4045, 1590, 1601, 4057, 4046
5858, 1590, 1601, 4057, 4046, 1591, 1602, 4058, 4047
5859, 1591, 1602, 4058, 4047, 1592, 1603, 4059, 4048
5860, 1592, 1603, 4059, 4048, 273, 274, 1628, 1627
5861, 198, 199, 1222, 1221, 1593, 1604, 4060, 4049
5862, 1593, 1604, 4060, 4049, 1594, 1605, 4061, 4050
5863, 1594, 1605, 4061, 4050, 1595, 1606, 4062, 4051
5864, 1595, 1606, 4062, 4051, 1596, 1607, 4063, 4052
5865, 1596, 1607, 4063, 4052, 1597, 1608, 4064, 4053
5866, 1597, 1608, 4064, 4053, 1598, 1609, 4065, 4054
5867, 1598, 1609, 4065, 4054, 1599, 1610, 4066, 4055
5868, 1599, 1610, 4066, 4055, 1600, 1611, 4067, 4056
5869, 1600, 1611, 4067, 4056, 1601, 1612, 4068, 4057
5870, 1601, 1612, 4068, 4057, 1602, 1613, 4069, 4058
5871, 1602, 1613, 4069, 4058, 1603, 1614, 4070, 4059
5872, 1603, 1614, 4070, 4059, 274, 275, 1629, 1628
5873, 199, 200, 1223, 1222, 1604, 1615, 4071, 4060
5874, 1604, 1615, 4071, 4060, 1605, 1616, 4072, 4061
5875, 1605, 1616, 4072, 4061, 1606, 1617, 4073, 4062
5876, 1606, 1617, 4073, 4062, 1607, 1618, 4074, 4063
5877, 1607, 1618, 4074, 4063, 1608, 1619, 4075, 4064
5878, 1608, 1619, 4075, 4064, 1609, 1620, 4076, 4065
5879, 1609, 1620, 4076, 4065, 1610, 1621, 4077, 4066
5880, 1610, 1621, 4077, 4066, 1611, 1622, 4078, 4067
5881, 1611, 1622, 4078, 4067, 1612, 1623, 4079, 4068
5882, 1612, 1623, 4079, 4068, 1613, 1624, 4080, 4069
5883, 1613, 1624, 4080, 4069, 1614, 1625, 4081, 4070
5884, 1614, 1625, 4081, 4070, 275, 276, 1630, 1629
5885, 200, 12, 185, 1223, 1615, 250, 1450, 4071
5886, 1615, 250, 1450, 4071, 1616, 251, 1451, 4072
5887, 1616, 251, 1451, 4072, 1617, 252, 1452, 4073
5888, 1617, 252, 1452, 4073, 1618, 253, 1453, 4074
5889, 1618, 253, 1453, 4074, 1619, 254, 1454, 4075
5890, 1619, 254, 1454, 4075, 1620, 255, 1455, 4076
5891, 1620, 255, 1455, 4076, 1621, 256, 1456, 4077
5892, 1621, 256, 1456, 4077, 1622, 257, 1457, 4078
5893, 1622, 257, 1457, 4078, 1623, 258, 1458, 4079
5894, 1623, 258, 1458, 4079, 1624, 259, 1459, 4080
5895, 1624, 259, 1459, 4080, 1625, 260, 1460, 4081
5896, 1625, 260, 1460, 4081, 276, 16, 261, 1630
5897, 169, 1219, 1224, 170, 1274, 4027, 4082, 1285
5898, 1274, 4027, 4082, 1285, 1275, 4028, 4083, 1286
5899, 1275, 4028, 4083, 1286, 1276, 4029, 4084, 1287
5900, 1276, 4029, 4084, 1287, 1277, 4030, 4085, 1288
5901, 1277, 4030, 4085, 1288, 1278, 4031, 4086, 1289
5902, 1278, 4031, 4086, 1289, 1279, 4032, 4087, 1290
5903, 1279, 4032, 4087, 1290, 1280, 4033, 4088, 1291
5904, 1280, 4033, 4088, 1291, 1281, 4034, 4089, 1292
5905, 1281, 4034, 4089, 1292, 1282, 4035, 4090, 1293
5906, 1282, 4035, 4090, 1293, 1283, 4036, 4091, 1294
5907, 1283, 4036, 4091, 1294, 1284, 4037, 4092, 1295
5908, 1284, 4037, 4092, 1295, 223, 1626, 1631, 224
5909, 1219, 1220, 1225, 1224, 4027, 4038, 4093, 4082
5910, 4027, 4038, 4093, 4082, 4028, 4039, 4094, 4083
5911, 4028, 4039, 4094, 4083, 4029, 4040, 4095, 4084
5912, 4029, 4040, 4095, 4084, 4030, 4041, 4096, 4085
5913, 4030, 4041, 4096, 4085, 4031, 4042, 4097, 4086
5914, 4031, 4042, 4097, 4086, 4032, 4043, 4098, 4087
5915, 4032, 4043, 4098, 4087, 4033, 4044, 4099, 4088
5916, 4033, 4044, 4099, 4088, 4034, 4045, 4100, 4089
5917, 4034, 4045, 4100, 4089, 4035, 4046, 4101, 4090
5918, 4035, 4046, 4101, 4090, 4036, 4047, 4102, 4091
5919, 4036, 4047, 4102, 4091, 4037, 4048, 4103, 4092
5920, 4037, 4048, 4103, 4092, 1626, 1627, 1632, 1631
5921, 1220, 1221, 1226, 1225, 4038, 4049, 4104, 4093
5922, 4038, 4049, 4104, 4093, 4039, 4050, 4105, 4094
5923, 4039, 4050, 4105, 4094, 4040, 4051, 4106, 4095
5924, 4040, 4051, 4106, 4095, 4041, 4052, 4107, 4096
5925, 4041, 4052, 4107, 4096, 4042, 4053, 4108, 4097
5926, 4042, 4053, 4108, 4097, 4043, 4054, 4109, 4098
5927, 4043, 4054, 4109, 4098, 4044, 4055, 4110, 4099
5928, 4044, 4055, 4110, 4099, 4045, 4056, 4111, 4100
5929, 4045, 4056, 4111, 4100, 4046, 4057, 4112, 4101
5930, 4046, 4057, 4112, 4101, 4047, 4058, 4113, 4102
5931, 4047, 4058, 4113, 4102, 4048, 4059, 4114, 4103
5932, 4048, 4059, 4114, 4103, 1627, 1628, 1633, 1632
5933, 1221, 1222, 1227, 1226, 4049, 4060, 4115, 4104
5934, 4049, 4060, 4115, 4104, 4050, 4061, 4116, 4105
5935, 4050, 4061, 4116, 4105, 4051, 4062, 4117, 4106
5936, 4051, 4062, 4117, 4106, 4052, 4063, 4118, 4107
5937, 4052, 4063, 4118, 4107, 4053, 4064, 4119, 4108
5938, 4053, 4064, 4119, 4108, 4054, 4065, 4120, 4109
5939, 4054, 4065, 4120, 4109, 4055, 4066, 4121, 4110
5940, 4055, 4066, 4121, 4110, 4056, 4067, 4122, 4111
5941, 4056, 4067, 4122, 4111, 4057, 4068, 4123, 4112
5942, 4057, 4068, 4123, 4112, 4058, 4069, 4124, 4113
5943, 4058, 4069, 4124, 4113, 4059, 4070, 4125, 4114
5944, 4059, 4070, 4125, 4114, 1628, 1629, 1634, 1633
5945, 1222, 1223, 1228, 1227, 4060, 4071, 4126, 4115
5946, 4060, 4071, 4126, 4115, 4061, 4072, 4127, 4116
5947, 4061, 4072, 4127, 4116, 4062, 4073, 4128, 4117
5948, 4062, 4073, 4128, 4117, 4063, 4074, 4129, 4118
5949, 4063, 4074, 4129, 4118, 4064, 4075, 4130, 4119
5950, 4064, 4075, 4130, 4119, 4065, 4076, 4131, 4120
5951, 4065, 4076, 4131, 4120, 4066, 4077, 4132, 4121
5952, 4066, 4077, 4132, 4121, 4067, 4078, 4133, 4122
5953, 4067, 4078, 4133, 4122, 4068, 4079, 4134, 4123
5954, 4068, 4079, 4134, 4123, 4069, 4080, 4135, 4124
5955, 4069, 4080, 4135, 4124, 4070, 4081, 4136, 4125
5956, 4070, 4081, 4136, 4125, 1629, 1630, 1635, 1634
5957, 1223, 185, 186, 1228, 4071, 1450, 1461, 4126
5958, 4071, 1450, 1461, 4126, 4072, 1451, 1462, 4127
5959, 4072, 1451, 1462, 4127, 4073, 1452, 1463, 4128
5960, 4073, 1452, 1463, 4128, 4074, 1453, 1464, 4129
5961, 4074, 1453, 1464, 4129, 4075, 1454, 1465, 4130
5962, 4075, 1454, 1465, 4130, 4076, 1455, 1466, 4131
5963, 4076, 1455, 1466, 4131, 4077, 1456, 1467, 4132
5964, 4077, 1456, 1467, 4132, 4078, 1457, 1468, 4133
5965, 4078, 1457, 1468, 4133, 4079, 1458, 1469, 4134
5966, 4079, 1458, 1469, 4134, 4080, 1459, 1470, 4135
5967, 4080, 1459, 1470, 4135, 4081, 1460, 1471, 4136
5968, 4081, 1460, 1471, 4136, 1630, 261, 262, 1635
5969, 170, 1224, 1229, 171, 1285, 4082, 4137, 1296
5970, 1285, 4082, 4137, 1296, 1286, 4083, 4138, 1297
5971, 1286, 4083, 4138, 1297, 1287, 4084, 4139, 1298
5972, 1287, 4084, 4139, 1298, 1288, 4085, 4140, 1299
5973, 1288, 4085, 4140, 1299, 1289, 4086, 4141, 1300
5974, 1289, 4086, 4141, 1300, 1290, 4087, 4142, 1301
5975, 1290, 4087, 4142, 1301, 1291, 4088, 4143, 1302
5976, 1291, 4088, 4143, 1302, 1292, 4089, 4144, 1303
5977, 1292, 4089, 4144, 1303, 1293, 4090, 4145, 1304
5978, 1293, 4090, 4145, 1304, 1294, 4091, 4146, 1305
5979, 1294, 4091, 4146, 1305, 1295, 4092, 4147, 1306
5980, 1295, 4092, 4147, 1306, 224, 1631, 1636, 225
5981, 1224, 1225, 1230, 1229, 4082, 4093, 4148, 4137
5982, 4082, 4093, 4148, 4137, 4083, 4094, 4149, 4138
5983, 4083, 4094, 4149, 4138, 4084, 4095, 4150, 4139
5984, 4084, 4095, 4150, 4139, 4085, 4096, 4151, 4140
5985, 4085, 4096, 4151, 4140, 4086, 4097, 4152, 4141
5986, 4086, 4097, 4152, 4141, 4087, 4098, 4153, 4142
5987, 4087, 4098, 4153, 4142, 4088, 4099, 4154, 4143
5988, 4088, 4099, 4154, 4143, 4089, 4100, 4155, 4144
5989, 4089, 4100, 4155, 4144, 4090, 4101, 4156, 4145
5990, 4090, 4101, 4156, 4145, 4091, 4102, 4157, 4146
5991, 4091, 4102, 4157, 4146, 4092, 4103, 4158, 4147
5992, 4092, 4103, 4158, 4147, 1631, 1632, 1637, 1636
5993, 1225, 1226, 1231, 1230, 4093, 4104, 4159, 4148
5994, 4093, 4104, 4159, 4148, 4094, 4105, 4160, 4149
5995, 4094, 4105, 4160, 4149, 4095, 4106, 4161, 4150
5996, 4095, 4106, 4161, 4150, 4096, 4107, 4162, 4151
5997, 4096, 4107, 4162, 4151, 4097, 4108, 4163, 4152
5998, 4097, 4108, 4163, 4152, 4098, 4109, 4164, 4153
5999, 4098, 4109, 4164, 4153, 4099, 4110, 4165, 4154
6000, 4099, 4110, 4165, 4154, 4100, 4111, 4166, 4155
6001, 4100, 4111, 4166, 4155, 4101, 4112, 4167, 4156
6002, 4101, 4112, 4167, 4156, 4102, 4113, 4168, 4157
6003, 4102, 4113, 4168, 4157, 4103, 4114, 4169, 4158
6004, 4103, 4114, 4169, 4158, 1632, 1633, 1638, 1637
6005, 1226, 1227, 1232, 1231, 4104, 4115, 4170, 4159
6006, 4104, 4115, 4170, 4159, 4105, 4116, 4171, 4160
6007, 4105, 4116, 4171, 4160, 4106, 4117, 4172, 4161
6008, 4106, 4117, 4172, 4161, 4107, 4118, 4173, 4162
6009, 4107, 4118, 4173, 4162, 4108, 4119, 4174, 4163
6010, 4108, 4119, 4174, 4163, 4109, 4120, 4175, 4164
6011, 4109, 4120, 4175, 4164, 4110, 4121, 4176, 4165
6012, 4110, 4121, 4176, 4165, 4111, 4122, 4177, 4166
6013, 4111, 4122, 4177, 4166, 4112, 4123, 4178, 4167
6014, 4112, 4123, 4178, 4167, 4113, 4124, 4179, 4168
6015, 4113, 4124, 4179, 4168, 4114, 4125, 4180, 4169
6016, 4114, 4125, 4180, 4169, 1633, 1634, 1639, 1638
6017, 1227, 1228, 1233, 1232, 4115, 4126, 4181, 4170
6018, 4115, 4126, 4181, 4170, 4116, 4127, 4182, 4171
6019, 4116, 4127, 4182, 4171, 4117, 4128, 4183, 4172
6020, 4117, 4128, 4183, 4172, 4118, 4129, 4184, 4173
6021, 4118, 4129, 4184, 4173, 4119, 4130, 4185, 4174
6022, 4119, 4130, 4185, 4174, 4120, 4131, 4186, 4175
6023, 4120, 4131, 4186, 4175, 4121, 4132, 4187, 4176
6024, 4121, 4132, 4187, 4176, 4122, 4133, 4188, 4177
6025, 4122, 4133, 4188, 4177, 4123, 4134, 4189, 4178
6026, 4123, 4134, 4189, 4178, 4124, 4135, 4190, 4179
6027, 4124, 4135, 4190, 4179, 4125, 4136, 4191, 4180
6028, 4125, 4136, 4191, 4180, 1634, 1635, 1640, 1639
6029, 1228, 186, 187, 1233, 4126, 1461, 1472, 4181
6030, 4126, 1461, 1472, 4181, 4127, 1462, 1473, 4182
6031, 4127, 1462, 1473, 4182, 4128, 1463, 1474, 4183
6032, 4128, 1463, 1474, 4183, 4129, 1464, 1475, 4184
6033, 4129, 1464, 1475, 4184, 4130, 1465, 1476, 4185
6034, 4130, 1465, 1476, 4185, 4131, 1466, 1477, 4186
6035, 4131, 1466, 1477, 4186, 4132, 1467, 1478, 4187
6036, 4132, 1467, 1478, 4187, 4133, 1468, 1479, 4188
6037, 4133, 1468, 1479, 4188, 4134, 1469, 1480, 4189
6038, 4134, 1469, 1480, 4189, 4135, 1470, 1481, 4190
6039, 4135, 1470, 1481, 4190, 4136, 1471, 1482, 4191
6040, 4136, 1471, 1482, 4191, 1635, 262, 263, 1640
6041, 171, 1229, 1234, 172, 1296, 4137, 4192, 1307
6042, 1296, 4137, 4192, 1307, 1297, 4138, 4193, 1308
6043, 1297, 4138, 4193, 1308, 1298, 4139, 4194, 1309
6044, 1298, 4139, 4194, 1309, 1299, 4140, 4195, 1310
6045, 1299, 4140, 4195, 1310, 1300, 4141, 4196, 1311
6046, 1300, 4141, 4196, 1311, 1301, 4142, 4197, 1312
6047, 1301, 4142, 4197, 1312, 1302, 4143, 4198, 1313
6048, 1302, 4143, 4198, 1313, 1303, 4144, 4199, 1314
6049, 1303, 4144, 4199, 1314, 1304, 4145, 4200, 1315
6050, 1304, 4145, 4200, 1315, 1305, 4146, 4201, 1316
6051, 1305, 4146, 4201, 1316, 1306, 4147, 4202, 1317
6052, 1306, 4147, 4202, 1317, 225, 1636, 1641, 226
6053, 1229, 1230, 1235, 1234, 4137, 4148, 4203, 4192
6054, 4137, 4148, 4203, 4192, 4138, 4149, 4204, 4193
6055, 4138, 4149, 4204, 4193, 4139, 4150, 4205, 4194
6056, 4139, 4150, 4205, 4194, 4140, 4151, 4206, 4195
6057, 4140, 4151, 4206, 4195, 4141, 4152, 4207, 4196
6058, 4141, 4152, 4207, 4196, 4142, 4153, 4208, 4197
6059, 4142, 4153, 4208, 4197, 4143, 4154, 4209, 4198
6060, 4143, 4154, 4209, 4198, 4144, 4155, 4210, 4199
6061, 4144, 4155, 4210, 4199, 4145, 4156, 4211, 4200
6062, 4145, 4156, 4211, 4200, 4146, 4157, 4212, 4201
6063, 4146, 4157, 4212, 4201, 4147, 4158, 4213, 4202
6064, 4147, 4158, 4213, 4202, 1636, 1637, 1642, 1641
6065, 1230, 1231, 1236, 1235, 4148, 4159, 4214, 4203
6066, 4148, 4159, 4214, 4203, 4149, 4160, 4215, 4204
6067, 4149, 4160, 4215, 4204, 4150, 4161, 4216, 4205
6068, 4150, 4161, 4216, 4205, 4151, 4162, 4217, 4206
6069, 4151, 4162, 4217, 4206, 4152, 4163, 4218, 4207
6070, 4152, 4163, 4218, 4207, 4153, 4164, 4219, 4208
6071, 4153, 4164, 4219, 4208, 4154, 4165, 4220, 4209
6072, 4154, 4165, 4220, 4209, 4155, 4166, 4221, 4210
6073, 4155, 4166, 4221, 4210, 4156, 4167, 4222, 4211
6074, 4156, 4167, 4222, 4211, 4157, 4168, 4223, 4212
6075, 4157, 4168, 4223, 4212, 4158, 4169, 4224, 4213
6076, 4158, 4169, 4224, 4213, 1637, 1638, 1643, 1642
6077, 1231, 1232, 1237, 1236, 4159, 4170, 4225, 4214
6078, 4159, 4170, 4225, 4214, 4160, 4171, 4226, 4215
6079, 4160, 4171, 4226, 4215, 4161, 4172, 4227, 4216
6080, 4161, 4172, 4227, 4216, 4162, 4173, 4228, 4217
6081, 4162, 4173, 4228, 4217, 4163, 4174, 4229, 4218
6082, 4163, 4174, 4229, 4218, 4164, 4175, 4230, 4219
6083, 4164, 4175, 4230, 4219, 4165, 4176, 4231, 4220
6084, 4165, 4176, 4231, 4220, 4166, 4177, 4232, 4221
6085, 4166, 4177, 4232, 4221, 4167, 4178, 4233, 4222
6086, 4167, 4178, 4233, 4222, 4168, 4179, 4234, 4223
6087, 4168, 4179, 4234, 4223, 4169, 4180, 4235, 4224
6088, 4169, 4180, 4235, 4224, 1638, 1639, 1644, 1643
6089, 1232, 1233, 1238, 1237, 4170, 4181, 4236, 4225
6090, 4170, 4181, 4236, 4225, 4171, 4182, 4237, 4226
6091, 4171, 4182, 4237, 4226, 4172, 4183, 4238, 4227
6092, 4172, 4183, 4238, 4227, 4173, 4184, 4239, 4228
6093, 4173, 4184, 4239, 4228, 4174, 4185, 4240, 4229
6094, 4174, 4185, 4240, 4229, 4175, 4186, 4241, 4230
6095, 4175, 4186, 4241, 4230, 4176, 4187, 4242, 4231
6096, 4176, 4187, 4242, 4231, 4177, 4188, 4243, 4232
6097, 4177, 4188, 4243, 4232, 4178, 4189, 4244, 4233
6098, 4178, 4189, 4244, 4233, 4179, 4190, 4245, 4234
6099, 4179, 4190, 4245, 4234, 4180, 4191, 4246, 4235
6100, 4180, 4191, 4246, 4235, 1639, 1640, 1645, 1644
6101, 1233, 187, 188, 1238, 4181, 1472, 1483, 4236
6102, 4181, 1472, 1483, 4236, 4182, 1473, 1484, 4237
6103, 4182, 1473, 1484, 4237, 4183, 1474, 1485, 4238
6104, 4183, 1474, 1485, 4238, 4184, 1475, 1486, 4239
6105, 4184, 1475, 1486, 4239, 4185, 1476, 1487, 4240
6106, 4185, 1476, 1487, 4240, 4186, 1477, 1488, 4241
6107, 4186, 1477, 1488, 4241, 4187, 1478, 1489, 4242
6108, 4187, 1478, 1489, 4242, 4188, 1479, 1490, 4243
6109, 4188, 1479, 1490, 4243, 4189, 1480, 1491, 4244
6110, 4189, 1480, 1491, 4244, 4190, 1481, 1492, 4245
6111, 4190, 1481, 1492, 4245, 4191, 1482, 1493, 4246
6112, 4191, 1482, 1493, 4246, 1640, 263, 264, 1645
6113, 172, 1234, 1239, 173, 1307, 4192, 4247, 1318
6114, 1307, 4192, 4247, 1318, 1308, 4193, 4248, 1319
6115, 1308, 4193, 4248, 1319, 1309, 4194, 4249, 1320
6116, 1309, 4194, 4249, 1320, 1310, 4195, 4250, 1321
6117, 1310, 4195, 4250, 1321, 1311, 4196, 4251, 1322
6118, 1311, 4196, 4251, 1322, 1312, 4197, 4252, 1323
6119, 1312, 4197, 4252, 1323, 1313, 4198, 4253, 1324
6120, 1313, 4198, 4253, 1324, 1314, 4199, 4254, 1325
6121, 1314, 4199, 4254, 1325, 1315, 4200, 4255, 1326
6122, 1315, 4200, 4255, 1326, 1316, 4201, 4256, 1327
6123, 1316, 4201, 4256, 1327, 1317, 4202, 4257, 1328
6124, 1317, 4202, 4257, 1328, 226, 1641, 1646, 227
6125, 1234, 1235, 1240, 1239, 4192, 4203, 4258, 4247
6126, 4192, 4203, 4258, 4247, 4193, 4204, 4259, 4248
6127, 4193, 4204, 4259, 4248, 4194, 4205, 4260, 4249
6128, 4194, 4205, 4260, 4249, 4195, 4206, 4261, 4250
6129, 4195, 4206, 4261, 4250, 4196, 4207, 4262, 4251
6130, 4196, 4207, 4262, 4251, 4197, 4208, 4263, 4252
6131, 4197, 4208, 4263, 4252, 4198, 4209, 4264, 4253
6132, 4198, 4209, 4264, 4253, 4199, 4210, 4265, 4254
6133, 4199, 4210, 4265, 4254, 4200, 4211, 4266, 4255
6134, 4200, 4211, 4266, 4255, 4201, 4212, 4267, 4256
6135, 4201, 4212, 4267, 4256, 4202, 4213, 4268, 4257
6136, 4202, 4213, 4268, 4257, 1641, 1642, 1647, 1646
6137, 1235, 1236, 1241, 1240, 4203, 4214, 4269, 4258
6138, 4203, 4214, 4269, 4258, 4204, 4215, 4270, 4259
6139, 4204, 4215, 4270, 4259, 4205, 4216, 4271, 4260
6140, 4205, 4216, 4271, 4260, 4206, 4217, 4272, 4261
6141, 4206, 4217, 4272, 4261, 4207, 4218, 4273, 4262
6142, 4207, 4218, 4273, 4262, 4208, 4219, 4274, 4263
6143, 4208, 4219, 4274, 4263, 4209, 4220, 4275, 4264
6144, 4209, 4220, 4275, 4264, 4210, 4221, 4276, 4265
6145, 4210, 4221, 4276, 4265, 4211, 4222, 4277, 4266
6146, 4211, 4222, 4277, 4266, 4212, 4223, 4278, 4267
6147, 4212, 4223, 4278, 4267, 4213, 4224, 4279, 4268
6148, 4213, 4224, 4279, 4268, 1642, 1643, 1648, 1647
6149, 1236, 1237, 1242, 1241, 4214, 4225, 4280, 4269
6150, 4214, 4225, 4280, 4269, 4215, 4226, 4281, 4270
6151, 4215, 4226, 4281, 4270, 4216, 4227, 4282, 4271
6152, 4216, 4227, 4282, 4271, 4217, 4228, 4283, 4272
6153, 4217, 4228, 4283, 4272, 4218, 4229, 4284, 4273
6154, 4218, 4229, 4284, 4273, 4219, 4230, 4285, 4274
6155, 4219, 4230, 4285, 4274, 4220, 4231, 4286, 4275
6156, 4220, 4231, 4286, 4275, 4221, 4232, 4287, 4276
6157, 4221, 4232, 4287, 4276, 4222, 4233, 4288, 4277
6158, 4222, 4233, 4288, 4277, 4223, 4234, 4289, 4278
6159, 4223, 4234, 4289, 4278, 4224, 4235, 4290, 4279
6160, 4224, 4235, 4290, 4279, 1643, 1644, 1649, 1648
6161, 1237, 1238, 1243, 1242, 4225, 4236, 4291, 4280
6162, 4225, 4236, 4291, 4280, 4226, 4237, 4292, 4281
6163, 4226, 4237, 4292, 4281, 4227, 4238, 4293, 4282
6164, 4227, 4238, 4293, 4282, 4228, 4239, 4294, 4283
6165, 4228, 4239, 4294, 4283, 4229, 4240, 4295, 4284
6166, 4229, 4240, 4295, 4284, 4230, 4241, 4296, 4285
6167, 4230, 4241, 4296, 4285, 4231, 4242, 4297, 4286
6168, 4231, 4242, 4297, 4286, 4232, 4243, 4298, 4287
6169, 4232, 4243, 4298, 4287, 4233, 4244, 4299, 4288
6170, 4233, 4244, 4299, 4288, 4234, 4245, 4300, 4289
6171, 4234, 4245, 4300, 4289, 4235, 4246, 4301, 4290
6172, 4235, 4246, 4301, 4290, 1644, 1645, 1650, 1649
6173, 1238, 188, 189, 1243, 4236, 1483, 1494, 4291
6174, 4236, 1483, 1494, 4291, 4237, 1484, 1495, 4292
6175, 4237, 1484, 1495, 4292, 4238, 1485, 1496, 4293
6176, 4238, 1485, 1496, 4293, 4239, 1486, 1497, 4294
6177, 4239, 1486, 1497, 4294, 4240, 1487, 1498, 4295
6178, 4240, 1487, 1498, 4295, 4241, 1488, 1499, 4296
6179, 4241, 1488, 1499, 4296, 4242, 1489, 1500, 4297
6180, 4242, 1489, 1500, 4297, 4243, 1490, 1501, 4298
6181, 4243, 1490, 1501, 4298, 4244, 1491, 1502, 4299
6182, 4244, 1491, 1502, 4299, 4245, 1492, 1503, 4300
6183, 4245, 1492, 1503, 4300, 4246, 1493, 1504, 4301
6184, 4246, 1493, 1504, 4301, 1645, 264, 265, 1650
6185, 173, 1239, 1244, 174, 1318, 4247, 4302, 1329
6186, 1318, 4247, 4302, 1329, 1319, 4248, 4303, 1330
6187, 1319, 4248, 4303, 1330, 1320, 4249, 4304, 1331
6188, 1320, 4249, 4304, 1331, 1321, 4250, 4305, 1332
6189, 1321, 4250, 4305, 1332, 1322, 4251, 4306, 1333
6190, 1322, 4251, 4306, 1333, 1323, 4252, 4307, 1334
6191, 1323, 4252, 4307, 1334, 1324, 4253, 4308, 1335
6192, 1324, 4253, 4308, 1335, 1325, 4254, 4309, 1336
6193, 1325, 4254, 4309, 1336, 1326, 4255, 4310, 1337
6194, 1326, 4255, 4310, 1337, 1327, 4256, 4311, 1338
6195, 1327, 4256, 4311, 1338, 1328, 4257, 4312, 1339
6196, 1328, 4257, 4312, 1339, 227, 1646, 1651, 228
6197, 1239, 1240, 1245, 1244, 4247, 4258, 4313, 4302
6198, 4247, 4258, 4313, 4302, 4248, 4259, 4314, 4303
6199, 4248, 4259, 4314, 4303, 4249, 4260, 4315, 4304
6200, 4249, 4260, 4315, 4304, 4250, 4261, 4316, 4305
6201, 4250, 4261, 4316, 4305, 4251, 4262, 4317, 4306
6202, 4251, 4262, 4317, 4306, 4252, 4263, 4318, 4307
6203, 4252, 4263, 4318, 4307, 4253, 4264, 4319, 4308
6204, 4253, 4264, 4319, 4308, 4254, 4265, 4320, 4309
6205, 4254, 4265, 4320, 4309, 4255, 4266, 4321, 4310
6206, 4255, 4266, 4321, 4310, 4256, 4267, 4322, 4311
6207, 4256, 4267, 4322, 4311, 4257, 4268, 4323, 4312
6208, 4257, 4268, 4323, 4312, 1646, 1647, 1652, 1651
6209, 1240, 1241, 1246, 1245, 4258, 4269, 4324, 4313
6210, 4258, 4269, 4324, 4313, 4259, 4270, 4325, 4314
6211, 4259, 4270, 4325, 4314, 4260, 4271, 4326, 4315
6212, 4260, 4271, 4326, 4315, 4261, 4272, 4327, 4316
6213, 4261, 4272, 4327, 4316, 4262, 4273, 4328, 4317
6214, 4262, 4273, 4328, 4317, 4263, 4274, 4329, 4318
6215, 4263, 4274, 4329, 4318, 4264, 4275, 4330, 4319
6216, 4264, 4275, 4330, 4319, 4265, 4276, 4331, 4320
6217, 4265, 4276, 4331, 4320, 4266, 4277, 4332, 4321
6218, 4266, 4277, 4332, 4321, 4267, 4278, 4333, 4322
6219, 4267, 4278, 4333, 4322, 4268, 4279, 4334, 4323
6220, 4268, 4279, 4334, 4323, 1647, 1648, 1653, 1652
6221, 1241, 1242, 1247, 1246, 4269, 4280, 4335, 4324
6222, 4269, 4280, 4335, 4324, 4270, 4281, 4336, 4325
6223, 4270, 4281, 4336, 4325, 4271, 4282, 4337, 4326
6224, 4271, 4282, 4337, 4326, 4272, 4283, 4338, 4327
6225, 4272, 4283, 4338, 4327, 4273, 4284, 4339, 4328
6226, 4273, 4284, 4339, 4328, 4274, 4285, 4340, 4329
6227, 4274, 4285, 4340, 4329, 4275, 4286, 4341, 4330
6228, 4275, 4286, 4341, 4330, 4276, 4287, 4342, 4331
6229, 4276, 4287, 4342, 4331, 4277, 4288, 4343, 4332
6230, 4277, 4288, 4343, 4332, 4278, 4289, 4344, 4333
6231, 4278, 4289, 4344, 4333, 4279, 4290, 4345, 4334
6232, 4279, 4290, 4345, 4334, 1648, 1649, 1654, 1653
6233, 1242, 1243, 1248, 1247, 4280, 4291, 4346, 4335
6234, 4280, 4291, 4346, 4335, 4281, 4292, 4347, 4336
6235, 4281, 4292, 4347, 4336, 4282, 4293, 4348, 4337
6236, 4282, 4293, 4348, 4337, 4283, 4294, 4349, 4338
6237, 4283, 4294, 4349, 4338, 4284, 4295, 4350, 4339
6238, 4284, 4295, 4350, 4339, 4285, 4296, 4351, 4340
6239, 4285, 4296, 4351, 4340, 4286, 4297, 4352, 4341
6240, 4286, 4297, 4352, 4341, 4287, 4298, 4353, 4342
6241, 4287, 4298, 4353, 4342, 4288, 4299, 4354, 4343
6242, 4288, 4299, 4354, 4343, 4289, 4300, 4355, 4344
6243, 4289, 4300, 4355, 4344, 4290, 4301, 4356, 4345
6244, 4290, 4301, 4356, 4345, 1649, 1650, 1655, 1654
6245, 1243, 189, 190, 1248, 4291, 1494, 1505, 4346
6246, 4291, 1494, 1505, 4346, 4292, 1495, 1506, 4347
6247, 4292, 1495, 1506, 4347, 4293, 1496, 1507, 4348
6248, 4293, 1496, 1507, 4348, 4294, 1497, 1508, 4349
6249, 4294, 1497, 1508, 4349, 4295, 1498, 1509, 4350
6250, 4295, 1498, 1509, 4350, 4296, 1499, 1510, 4351
6251, 4296, 1499, 1510, 4351, 4297, 1500, 1511, 4352
6252, 4297, 1500, 1511, 4352, 4298, 1501, 1512, 4353
6253, 4298, 1501, 1512, 4353, 4299, 1502, 1513, 4354
6254, 4299, 1502, 1513, 4354, 4300, 1503, 1514, 4355
6255, 4300, 1503, 1514, 4355, 4301, 1504, 1515, 4356
6256, 4301, 1504, 1515, 4356, 1650, 265, 266, 1655
6257, 174, 1244, 1249, 175, 1329, 4302, 4357, 1340
6258, 1329, 4302, 4357, 1340, 1330, 4303, 4358, 1341
6259, 1330, 4303, 4358, 1341, 1331, 4304, 4359, 1342
6260, 1331, 4304, 4359, 1342, 1332, 4305, 4360, 1343
6261, 1332, 4305, 4360, 1343, 1333, 4306, 4361, 1344
6262, 1333, 4306, 4361, 1344, 1334, 4307, 4362, 1345
6263, 1334, 4307, 4362, 1345, 1335, 4308, 4363, 1346
6264, 1335, 4308, 4363, 1346, 1336, 4309, 4364, 1347
6265, 1336, 4309, 4364, 1347, 1337, 4310, 4365, 1348
6266, 1337, 4310, 4365, 1348, 1338, 4311, 4366, 1349
6267, 1338, 4311, 4366, 1349, 1339, 4312, 4367, 1350
6268, 1339, 4312, 4367, 1350, 228, 1651, 1656, 229
6269, 1244, 1245, 1250, 1249, 4302, 4313, 4368, 4357
6270, 4302, 4313, 4368, 4357, 4303, 4314, 4369, 4358
6271, 4303, 4314, 4369, 4358, 4304, 4315, 4370, 4359
6272, 4304, 4315, 4370, 4359, 4305, 4316, 4371, 4360
6273, 4305, 4316, 4371, 4360, 4306, 4317, 4372, 4361
6274, 4306, 4317, 4372, 4361, 4307, 4318, 4373, 4362
6275, 4307, 4318, 4373, 4362, 4308, 4319, 4374, 4363
6276, 4308, 4319, 4374, 4363, 4309, 4320, 4375, 4364
6277, 4309, 4320, 4375, 4364, 4310, 4321, 4376, 4365
6278, 4310, 4321, 4376, 4365, 4311, 4322, 4377, 4366
6279, 4311, 4322, 4377, 4366, 4312, 4323, 4378, 4367
6280, 4312, 4323, 4378, 4367, 1651, 1652, 1657, 1656
6281, 1245, 1246, 1251, 1250, 4313, 4324, 4379, 4368
6282, 4313, 4324, 4379, 4368, 4314, 4325, 4380, 4369
6283, 4314, 4325, 4380, 4369, 4315, 4326, 4381, 4370
6284, 4315, 4326, 4381, 4370, 4316, 4327, 4382, 4371
6285, 4316, 4327, 4382, 4371, 4317, 4328, 4383, 4372
6286, 4317, 4328, 4383, 4372, 4318, 4329, 4384, 4373
6287, 4318, 4329, 4384, 4373, 4319, 4330, 4385, 4374
6288, 4319, 4330, 4385, 4374, 4320, 4331, 4386, 4375
6289, 4320, 4331, 4386, 4375, 4321, 4332, 4387, 4376
6290, 4321, 4332, 4387, 4376, 4322, 4333, 4388, 4377
6291, 4322, 4333, 4388, 4377, 4323, 4334, 4389, 4378
6292, 4323, 4334, 4389, 4378, 1652, 1653, 1658, 1657
6293, 1246, 1247, 1252, 1251, 4324, 4335, 4390, 4379
6294, 4324, 4335, 4390, 4379, 4325, 4336, 4391, 4380
6295, 4325, 4336, 4391, 4380, 4326, 4337, 4392, 4381
6296, 4326, 4337, 4392, 4381, 4327, 4338, 4393, 4382
6297, 4327, 4338, 4393, 4382, 4328, 4339, 4394, 4383
6298, 4328, 4339, 4394, 4383, 4329, 4340, 4395, 4384
6299, 4329, 4340, 4395, 4384, 4330, 4341, 4396, 4385
6300, 4330, 4341, 4396, 4385, 4331, 4342, 4397, 4386
6301, 4331, 4342, 4397, 4386, 4332, 4343, 4398, 4387
6302, 4332, 4343, 4398, 4387, 4333, 4344, 4399, 4388
6303, 4333, 4344, 4399, 4388, 4334, 4345, 4400, 4389
6304, 4334, 4345, 4400, 4389, 1653, 1654, 1659, 1658
6305, 1247, 1248, 1253, 1252, 4335, 4346, 4401, 4390
6306, 4335, 4346, 4401, 4390, 4336, 4347, 4402, 4391
6307, 4336, 4347, 4402, 4391, 4337, 4348, 4403, 4392
6308, 4337, 4348, 4403, 4392, 4338, 4349, 4404, 4393
6309, 4338, 4349, 4404, 4393, 4339, 4350, 4405, 4394
6310, 4339, 4350, 4405, 4394, 4340, 4351, 4406, 4395
6311, 4340, 4351, 4406, 4395, 4341, 4352, 4407, 4396
6312, 4341, 4352, 4407, 4396, 4342, 4353, 4408, 4397
6313, 4342, 4353, 4408, 4397, 4343, 4354, 4409, 4398
6314, 4343, 4354, 4409, 4398, 4344, 4355, 4410, 4399
6315, 4344, 4355, 4410, 4399, 4345, 4356, 4411, 4400
6316, 4345, 4356, 4411, 4400, 1654, 1655, 1660, 1659
6317, 1248, 190, 191, 1253, 4346, 1505, 1516, 4401
6318, 4346, 1505, 1516, 4401, 4347, 1506, 1517, 4402
6319, 4347, 1506, 1517, 4402, 4348, 1507, 1518, 4403
6320, 4348, 1507, 1518, 4403, 4349, 1508, 1519, 4404
6321, 4349, 1508, 1519, 4404, 4350, 1509, 1520, 4405
6322, 4350, 1509, 1520, 4405, 4351, 1510, 1521, 4406
6323, 4351, 1510, 1521, 4406, 4352, 1511, 1522, 4407
6324, 4352, 1511, 1522, 4407, 4353, 1512, 1523, 4408
6325, 4353, 1512, 1523, 4408, 4354, 1513, 1524, 4409
6326, 4354, 1513, 1524, 4409, 4355, 1514, 1525, 4410
6327, 4355, 1514, 1525, 4410, 4356, 1515, 1526, 4411
6328, 4356, 1515, 1526, 4411, 1655, 266, 267, 1660
6329, 175, 1249, 1254, 176, 1340, 4357, 4412, 1351
6330, 1340, 4357, 4412, 1351, 1341, 4358, 4413, 1352
6331, 1341, 4358, 4413, 1352, 1342, 4359, 4414, 1353
6332, 1342, 4359, 4414, 1353, 1343, 4360, 4415, 1354
6333, 1343, 4360, 4415, 1354, 1344, 4361, 4416, 1355
6334, 1344, 4361, 4416, 1355, 1345, 4362, 4417, 1356
6335, 1345, 4362, 4417, 1356, 1346, 4363, 4418, 1357
6336, 1346, 4363, 4418, 1357, 1347, 4364, 4419, 1358
6337, 1347, 4364, 4419, 1358, 1348, 4365, 4420, 1359
6338, 1348, 4365, 4420, 1359, 1349, 4366, 4421, 1360
6339, 1349, 4366, 4421, 1360, 1350, 4367, 4422, 1361
6340, 1350, 4367, 4422, 1361, 229, 1656, 1661, 230
6341, 1249, 1250, 1255, 1254, 4357, 4368, 4423, 4412
6342, 4357, 4368, 4423, 4412, 4358, 4369, 4424, 4413
6343, 4358, 4369, 4424, 4413, 4359, 4370, 4425, 4414
6344, 4359, 4370, 4425, 4414, 4360, 4371, 4426, 4415
6345, 4360, 4371, 4426, 4415, 4361, 4372, 4427, 4416
6346, 4361, 4372, 4427, 4416, 4362, 4373, 4428, 4417
6347, 4362, 4373, 4428, 4417, 4363, 4374, 4429, 4418
6348, 4363, 4374, 4429, 4418, 4364, 4375, 4430, 4419
6349, 4364, 4375, 4430, 4419, 4365, 4376, 4431, 4420
6350, 4365, 4376, 4431, 4420, 4366, 4377, 4432, 4421
6351, 4366, 4377, 4432, 4421, 4367, 4378, 4433, 4422
6352, 4367, 4378, 4433, 4422, 1656, 1657, 1662, 1661
6353, 1250, 1251, 1256, 1255, 4368, 4379, 4434, 4423
6354, 4368, 4379, 4434, 4423, 4369, 4380, 4435, 4424
6355, 4369, 4380, 4435, 4424, 4370, 4381, 4436, 4425
6356, 4370, 4381, 4436, 4425, 4371, 4382, 4437, 4426
6357, 4371, 4382, 4437, 4426, 4372, 4383, 4438, 4427
6358, 4372, 4383, 4438, 4427, 4373, 4384, 4439, 4428
6359, 4373, 4384, 4439, 4428, 4374, 4385, 4440, 4429
6360, 4374, 4385, 4440, 4429, 4375, 4386, 4441, 4430
6361, 4375, 4386, 4441, 4430, 4376, 4387, 4442, 4431
6362, 4376, 4387, 4442, 4431, 4377, 4388, 4443, 4432
6363, 4377, 4388, 4443, 4432, 4378, 4389, 4444, 4433
6364, 4378, 4389, 4444, 4433, 1657, 1658, 1663, 1662
6365, 1251, 1252, 1257, 1256, 4379, 4390, 4445, 4434
6366, 4379, 4390, 4445, 4434, 4380, 4391, 4446, 4435
6367, 4380, 4391, 4446, 4435, 4381, 4392, 4447, 4436
6368, 4381, 4392, 4447, 4436, 4382, 4393, 4448, 4437
6369, 4382, 4393, 4448, 4437, 4383, 4394, 4449, 4438
6370, 4383, 4394, 4449, 4438, 4384, 4395, 4450, 4439
6371, 4384, 4395, 4450, 4439, 4385, 4396, 4451, 4440
6372, 4385, 4396, 4451, 4440, 4386, 4397, 4452, 4441
6373, 4386, 4397, 4452, 4441, 4387, 4398, 4453, 4442
6374, 4387, 4398, 4453, 4442, 4388, 4399, 4454, 4443
6375, 4388, 4399, 4454, 4443, 4389, 4400, 4455, 4444
6376, 4389, 4400, 4455, 4444, 1658, 1659, 1664, 1663
6377, 1252, 1253, 1258, 1257, 4390, 4401, 4456, 4445
6378, 4390, 4401, 4456, 4445, 4391, 4402, 4457, 4446
6379, 4391, 4402, 4457, 4446, 4392, 4403, 4458, 4447
6380, 4392, 4403, 4458, 4447, 4393, 4404, 4459, 4448
6381, 4393, 4404, 4459, 4448, 4394, 4405, 4460, 4449
6382, 4394, 4405, 4460, 4449, 4395, 4406, 4461, 4450
6383, 4395, 4406, 4461, 4450, 4396, 4407, 4462, 4451
6384, 4396, 4407, 4462, 4451, 4397, 4408, 4463, 4452
6385, 4397, 4408, 4463, 4452, 4398, 4409, 4464, 4453
6386, 4398, 4409, 4464, 4453, 4399, 4410, 4465, 4454
6387, 4399, 4410, 4465, 4454, 4400, 4411, 4466, 4455
6388, 4400, 4411, 4466, 4455, 1659, 1660, 1665, 1664
6389, 1253, 191, 192, 1258, 4401, 1516, 1527, 4456
6390, 4401, 1516, 1527, 4456, 4402, 1517, 1528, 4457
6391, 4402, 1517, 1528, 4457, 4403, 1518, 1529, 4458
6392, 4403, 1518, 1529, 4458, 4404, 1519, 1530, 4459
6393, 4404, 1519, 1530, 4459, 4405, 1520, 1531, 4460
6394, 4405, 1520, 1531, 4460, 4406, 1521, 1532, 4461
6395, 4406, 1521, 1532, 4461, 4407, 1522, 1533, 4462
6396, 4407, 1522, 1533, 4462, 4408, 1523, 1534, 4463
6397, 4408, 1523, 1534, 4463, 4409, 1524, 1535, 4464
6398, 4409, 1524, 1535, 4464, 4410, 1525, 1536, 4465
6399, 4410, 1525, 1536, 4465, 4411, 1526, 1537, 4466
6400, 4411, 1526, 1537, 4466, 1660, 267, 268, 1665
6401, 176, 1254, 1259, 177, 1351, 4412, 4467, 1362
6402, 1351, 4412, 4467, 1362, 1352, 4413, 4468, 1363
6403, 1352, 4413, 4468, 1363, 1353, 4414, 4469, 1364
6404, 1353, 4414, 4469, 1364, 1354, 4415, 4470, 1365
6405, 1354, 4415, 4470, 1365, 1355, 4416, 4471, 1366
6406, 1355, 4416, 4471, 1366, 1356, 4417, 4472, 1367
6407, 1356, 4417, 4472, 1367, 1357, 4418, 4473, 1368
6408, 1357, 4418, 4473, 1368, 1358, 4419, 4474, 1369
6409, 1358, 4419, 4474, 1369, 1359, 4420, 4475, 1370
6410, 1359, 4420, 4475, 1370, 1360, 4421, 4476, 1371
6411, 1360, 4421, 4476, 1371, 1361, 4422, 4477, 1372
6412, 1361, 4422, 4477, 1372, 230, 1661, 1666, 231
6413, 1254, 1255, 1260, 1259, 4412, 4423, 4478, 4467
6414, 4412, 4423, 4478, 4467, 4413, 4424, 4479, 4468
6415, 4413, 4424, 4479, 4468, 4414, 4425, 4480, 4469
6416, 4414, 4425, 4480, 4469, 4415, 4426, 4481, 4470
6417, 4415, 4426, 4481, 4470, 4416, 4427, 4482, 4471
6418, 4416, 4427, 4482, 4471, 4417, 4428, 4483, 4472
6419, 4417, 4428, 4483, 4472, 4418, 4429, 4484, 4473
6420, 4418, 4429, 4484, 4473, 4419, 4430, 4485, 4474
6421, 4419, 4430, 4485, 4474, 4420, 4431, 4486, 4475
6422, 4420, 4431, 4486, 4475, 4421, 4432, 4487, 4476
6423, 4421, 4432, 4487, 4476, 4422, 4433, 4488, 4477
6424, 4422, 4433, 4488, 4477, 1661, 1662, 1667, 1666
6425, 1255, 1256, 1261, 1260, 4423, 4434, 4489, 4478
6426, 4423, 4434, 4489, 4478, 4424, 4435, 4490, 4479
6427, 4424, 4435, 4490, 4479, 4425, 4436, 4491, 4480
6428, 4425, 4436, 4491, 4480, 4426, 4437, 4492, 4481
6429, 4426, 4437, 4492, 4481, 4427, 4438, 4493, 4482
6430, 4427, 4438, 4493, 4482, 4428, 4439, 4494, 4483
6431, 4428, 4439, 4494, 4483, 4429, 4440, 4495, 4484
6432, 4429, 4440, 4495, 4484, 4430, 4441, 4496, 4485
6433, 4430, 4441, 4496, 4485, 4431, 4442, 4497, 4486
6434, 4431, 4442, 4497, 4486, 4432, 4443, 4498, 4487
6435, 4432, 4443, 4498, 4487, 4433, 4444, 4499, 4488
6436, 4433, 4444, 4499, 4488, 1662, 1663, 1668, 1667
6437, 1256, 1257, 1262, 1261, 4434, 4445, 4500, 4489
6438, 4434, 4445, 4500, 4489, 4435, 4446, 4501, 4490
6439, 4435, 4446, 4501, 4490, 4436, 4447, 4502, 4491
6440, 4436, 4447, 4502, 4491, 4437, 4448, 4503, 4492
6441, 4437, 4448, 4503, 4492, 4438, 4449, 4504, 4493
6442, 4438, 4449, 4504, 4493, 4439, 4450, 4505, 4494
6443, 4439, 4450, 4505, 4494, 4440, 4451, 4506, 4495
6444, 4440, 4451, 4506, 4495, 4441, 4452, 4507, 4496
6445, 4441, 4452, 4507, 4496, 4442, 4453, 4508, 4497
6446, 4442, 4453, 4508, 4497, 4443, 4454, 4509, 4498
6447, 4443, 4454, 4509, 4498, 4444, 4455, 4510, 4499
6448, 4444, 4455, 4510, 4499, 1663, 1664, 1669, 1668
6449, 1257, 1258, 1263, 1262, 4445, 4456, 4511, 4500
6450, 4445, 4456, 4511, 4500, 4446, 4457, 4512, 4501
6451, 4446, 4457, 4512, 4501, 4447, 4458, 4513, 4502
6452, 4447, 4458, 4513, 4502, 4448, 4459, 4514, 4503
6453, 4448, 4459, 4514, 4503, 4449, 4460, 4515, 4504
6454, 4449, 4460, 4515, 4504, 4450, 4461, 4516, 4505
6455, 4450, 4461, 4516, 4505, 4451, 4462, 4517, 4506
6456, 4451, 4462, 4517, 4506, 4452, 4463, 4518, 4507
6457, 4452, 4463, 4518, 4507, 4453, 4464, 4519, 4508
6458, 4453, 4464, 4519, 4508, 4454, 4465, 4520, 4509
6459, 4454, 4465, 4520, 4509, 4455, 4466, 4521, 4510
6460, 4455, 4466, 4521, 4510, 1664, 1665, 1670, 1669
6461, 1258, 192, 193, 1263, 4456, 1527, 1538, 4511
6462, 4456, 1527, 1538, 4511, 4457, 1528, 1539, 4512
6463, 4457, 1528, 1539, 4512, 4458, 1529, 1540, 4513
6464, 4458, 1529, 1540, 4513, 4459, 1530, 1541, 4514
6465, 4459, 1530, 1541, 4514, 4460, 1531, 1542, 4515
6466, 4460, 1531, 1542, 4515, 4461, 1532, 1543, 4516
6467, 4461, 1532, 1543, 4516, 4462, 1533, 1544, 4517
6468, 4462, 1533, 1544, 4517, 4463, 1534, 1545, 4518
6469, 4463, 1534, 1545, 4518, 4464, 1535, 1546, 4519
6470, 4464, 1535, 1546, 4519, 4465, 1536, 1547, 4520
6471, 4465, 1536, 1547, 4520, 4466, 1537, 1548, 4521
6472, 4466, 1537, 1548, 4521, 1665, 268, 269, 1670
6473, 177, 1259, 1264, 178, 1362, 4467, 4522, 1373
6474, 1362, 4467, 4522, 1373, 1363, 4468, 4523, 1374
6475, 1363, 4468, 4523, 1374, 1364, 4469, 4524, 1375
6476, 1364, 4469, 4524, 1375, 1365, 4470, 4525, 1376
6477, 1365, 4470, 4525, 1376, 1366, 4471, 4526, 1377
6478, 1366, 4471, 4526, 1377, 1367, 4472, 4527, 1378
6479, 1367, 4472, 4527, 1378, 1368, 4473, 4528, 1379
6480, 1368, 4473, 4528, 1379, 1369, 4474, 4529, 1380
6481, 1369, 4474, 4529, 1380, 1370, 4475, 4530, 1381
6482, 1370, 4475, 4530, 1381, 1371, 4476, 4531, 1382
6483, 1371, 4476, 4531, 1382, 1372, 4477, 4532, 1383
6484, 1372, 4477, 4532, 1383, 231, 1666, 1671, 232
6485, 1259, 1260, 1265, 1264, 4467, 4478, 4533, 4522
6486, 4467, 4478, 4533, 4522, 4468, 4479, 4534, 4523
6487, 4468, 4479, 4534, 4523, 4469, 4480, 4535, 4524
6488, 4469, 4480, 4535, 4524, 4470, 4481, 4536, 4525
6489, 4470, 4481, 4536, 4525, 4471, 4482, 4537, 4526
6490, 4471, 4482, 4537, 4526, 4472, 4483, 4538, 4527
6491, 4472, 4483, 4538, 4527, 4473, 4484, 4539, 4528
6492, 4473, 4484, 4539, 4528, 4474, 4485, 4540, 4529
6493, 4474, 4485, 4540, 4529, 4475, 4486, 4541, 4530
6494, 4475, 4486, 4541, 4530, 4476, 4487, 4542, 4531
6495, 4476, 4487, 4542, 4531, 4477, 4488, 4543, 4532
6496, 4477, 4488, 4543, 4532, 1666, 1667, 1672, 1671
6497, 1260, 1261, 1266, 1265, 4478, 4489, 4544, 4533
6498, 4478, 4489, 4544, 4533, 4479, 4490, 4545, 4534
6499, 4479, 4490, 4545, 4534, 4480, 4491, 4546, 4535
6500, 4480, 4491, 4546, 4535, 4481, 4492, 4547, 4536
6501, 4481, 4492, 4547, 4536, 4482, 4493, 4548, 4537
6502, 4482, 4493, 4548, 4537, 4483, 4494, 4549, 4538
6503, 4483, 4494, 4549, 4538, 4484, 4495, 4550, 4539
6504, 4484, 4495, 4550, 4539, 4485, 4496, 4551, 4540
6505, 4485, 4496, 4551, 4540, 4486, 4497, 4552, 4541
6506, 4486, 4497, 4552, 4541, 4487, 4498, 4553, 4542
6507, 4487, 4498, 4553, 4542, 4488, 4499, 4554, 4543
6508, 4488, 4499, 4554, 4543, 1667, 1668, 1673, 1672
6509, 1261, 1262, 1267, 1266, 4489, 4500, 4555, 4544
6510, 4489, 4500, 4555, 4544, 4490, 4501, 4556, 4545
6511, 4490, 4501, 4556, 4545, 4491, 4502, 4557, 4546
6512, 4491, 4502, 4557, 4546, 4492, 4503, 4558, 4547
6513, 4492, 4503, 4558, 4547, 4493, 4504, 4559, 4548
6514, 4493, 4504, 4559, 4548, 4494, 4505, 4560, 4549
6515, 4494, 4505, 4560, 4549, 4495, 4506, 4561, 4550
6516, 4495, 4506, 4561, 4550, 4496, 4507, 4562, 4551
6517, 4496, 4507, 4562, 4551, 4497, 4508, 4563, 4552
6518, 4497, 4508, 4563, 4552, 4498, 4509, 4564, 4553
6519, 4498, 4509, 4564, 4553, 4499, 4510, 4565, 4554
6520, 4499, 4510, 4565, 4554, 1668, 1669, 1674, 1673
6521, 1262, 1263, 1268, 1267, 4500, 4511, 4566, 4555
6522, 4500, 4511, 4566, 4555, 4501, 4512, 4567, 4556
6523, 4501, 4512, 4567, 4556, 4502, 4513, 4568, 4557
6524, 4502, 4513, 4568, 4557, 4503, 4514, 4569, 4558
6525, 4503, 4514, 4569, 4558, 4504, 4515, 4570, 4559
6526, 4504, 4515, 4570, 4559, 4505, 4516, 4571, 4560
6527, 4505, 4516, 4571, 4560, 4506, 4517, 4572, 4561
6528, 4506, 4517, 4572, 4561, 4507, 4518, 4573, 4562
6529, 4507, 4518, 4573, 4562, 4508, 4519, 4574, 4563
6530, 4508, 4519, 4574, 4563, 4509, 4520, 4575, 4564
6531, 4509, 4520, 4575, 4564, 4510, 4521, 4576, 4565
6532, 4510, 4521, 4576, 4565, 1669, 1670, 1675, 1674
6533, 1263, 193, 194, 1268, 4511, 1538, 1549, 4566
6534, 4511, 1538, 1549, 4566, 4512, 1539, 1550, 4567
6535, 4512, 1539, 1550, 4567, 4513, 1540, 1551, 4568
6536, 4513, 1540, 1551, 4568, 4514, 1541, 1552, 4569
6537, 4514, 1541, 1552, 4569, 4515, 1542, 1553, 4570
6538, 4515, 1542, 1553, 4570, 4516, 1543, 1554, 4571
6539, 4516, 1543, 1554, 4571, 4517, 1544, 1555, 4572
6540, 4517, 1544, 1555, 4572, 4518, 1545, 1556, 4573
6541, 4518, 1545, 1556, 4573, 4519, 1546, 1557, 4574
6542, 4519, 1546, 1557, 4574, 4520, 1547, 1558, 4575
6543, 4520, 1547, 1558, 4575, 4521, 1548, 1559, 4576
6544, 4521, 1548, 1559, 4576, 1670, 269, 270, 1675
6545, 178, 1264, 1269, 179, 1373, 4522, 4577, 1384
6546, 1373, 4522, 4577, 1384, 1374, 4523, 4578, 1385
6547, 1374, 4523, 4578, 1385, 1375, 4524, 4579, 1386
6548, 1375, 4524, 4579, 1386, 1376, 4525, 4580, 1387
6549, 1376, 4525, 4580, 1387, 1377, 4526, 4581, 1388
6550, 1377, 4526, 4581, 1388, 1378, 4527, 4582, 1389
6551, 1378, 4527, 4582, 1389, 1379, 4528, 4583, 1390
6552, 1379, 4528, 4583, 1390, 1380, 4529, 4584, 1391
6553, 1380, 4529, 4584, 1391, 1381, 4530, 4585, 1392
6554, 1381, 4530, 4585, 1392, 1382, 4531, 4586, 1393
6555, 1382, 4531, 4586, 1393, 1383, 4532, 4587, 1394
6556, 1383, 4532, 4587, 1394, 232, 1671, 1676, 233
6557, 1264, 1265, 1270, 1269, 4522, 4533, 4588, 4577
6558, 4522, 4533, 4588, 4577, 4523, 4534, 4589, 4578
6559, 4523, 4534, 4589, 4578, 4524, 4535, 4590, 4579
6560, 4524, 4535, 4590, 4579, 4525, 4536, 4591, 4580
6561, 4525, 4536, 4591, 4580, 4526, 4537, 4592, 4581
6562, 4526, 4537, 4592, 4581, 4527, 4538, 4593, 4582
6563, 4527, 4538, 4593, 4582, 4528, 4539, 4594, 4583
6564, 4528, 4539, 4594, 4583, 4529, 4540, 4595, 4584
6565, 4529, 4540, 4595, 4584, 4530, 4541, 4596, 4585
6566, 4530, 4541, 4596, 4585, 4531, 4542, 4597, 4586
6567, 4531, 4542, 4597, 4586, 4532, 4543, 4598, 4587
6568, 4532, 4543, 4598, 4587, 1671, 1672, 1677, 1676
6569, 1265, 1266, 1271, 1270, 4533, 4544, 4599, 4588
6570, 4533, 4544, 4599, 4588, 4534, 4545, 4600, 4589
6571, 4534, 4545, 4600, 4589, 4535, 4546, 4601, 4590
6572, 4535, 4546, 4601, 4590, 4536, 4547, 4602, 4591
6573, 4536, 4547, 4602, 4591, 4537, 4548, 4603, 4592
6574, 4537, 4548, 4603, 4592, 4538, 4549, 4604, 4593
6575, 4538, 4549, 4604, 4593, 4539, 4550, 4605, 4594
6576, 4539, 4550, 4605, 4594, 4540, 4551, 4606, 4595
6577, 4540, 4551, 4606, 4595, 4541, 4552, 4607, 4596
6578, 4541, 4552, 4607, 4596, 4542, 4553, 4608, 4597
6579, 4542, 4553, 4608, 4597, 4543, 4554, 4609, 4598
6580, 4543, 4554, 4609, 4598, 1672, 1673, 1678, 1677
6581, 1266, 1267, 1272, 1271, 4544, 4555, 4610, 4599
6582, 4544, 4555, 4610, 4599, 4545, 4556, 4611, 4600
6583, 4545, 4556, 4611, 4600, 4546, 4557, 4612, 4601
6584, 4546, 4557, 4612, 4601, 4547, 4558, 4613, 4602
6585, 4547, 4558, 4613, 4602, 4548, 4559, 4614, 4603
6586, 4548, 4559, 4614, 4603, 4549, 4560, 4615, 4604
6587, 4549, 4560, 4615, 4604, 4550, 4561, 4616, 4605
6588, 4550, 4561, 4616, 4605, 4551, 4562, 4617, 4606
6589, 4551, 4562, 4617, 4606, 4552, 4563, 4618, 4607
6590, 4552, 4563, 4618, 4607, 4553, 4564, 4619, 4608
6591, 4553, 4564, 4619, 4608, 4554, 4565, 4620, 4609
6592, 4554, 4565, 4620, 4609, 1673, 1674, 1679, 1678
6593, 1267, 1268, 1273, 1272, 4555, 4566, 4621, 4610
6594, 4555, 4566, 4621, 4610, 4556, 4567, 4622, 4611
6595, 4556, 4567, 4622, 4611, 4557, 4568, 4623, 4612
6596, 4557, 4568, 4623, 4612, 4558, 4569, 4624, 4613
6597, 4558, 4569, 4624, 4613, 4559, 4570, 4625, 4614
6598, 4559, 4570, 4625, 4614, 4560, 4571, 4626, 4615
6599, 4560, 4571, 4626, 4615, 4561, 4572, 4627, 4616
6600, 4561, 4572, 4627, 4616, 4562, 4573, 4628, 4617
6601, 4562, 4573, 4628, 4617, 4563, 4574, 4629, 4618
6602, 4563, 4574, 4629, 4618, 4564, 4575, 4630, 4619
6603, 4564, 4575, 4630, 4619, 4565, 4576, 4631, 4620
6604, 4565, 4576, 4631, 4620, 1674, 1675, 1680, 1679
6605, 1268, 194, 195, 1273, 4566, 1549, 1560, 4621
6606, 4566, 1549, 1560, 4621, 4567, 1550, 1561, 4622
6607, 4567, 1550, 1561, 4622, 4568, 1551, 1562, 4623
6608, 4568, 1551, 1562, 4623, 4569, 1552, 1563, 4624
6609, 4569, 1552, 1563, 4624, 4570, 1553, 1564, 4625
6610, 4570, 1553, 1564, 4625, 4571, 1554, 1565, 4626
6611, 4571, 1554, 1565, 4626, 4572, 1555, 1566, 4627
6612, 4572, 1555, 1566, 4627, 4573, 1556, 1567, 4628
6613, 4573, 1556, 1567, 4628, 4574, 1557, 1568, 4629
6614, 4574, 1557, 1568, 4629, 4575, 1558, 1569, 4630
6615, 4575, 1558, 1569, 4630, 4576, 1559, 1570, 4631
6616, 4576, 1559, 1570, 4631, 1675, 270, 271, 1680
6617, 179, 1269, 180, 9, 1384, 4577, 1395, 201
6618, 1384, 4577, 1395, 201, 1385, 4578, 1396, 202
6619, 1385, 4578, 1396, 202, 1386, 4579, 1397, 203
6620, 1386, 4579, 1397, 203, 1387, 4580, 1398, 204
6621, 1387, 4580, 1398, 204, 1388, 4581, 1399, 205
6622, 1388, 4581, 1399, 205, 1389, 4582, 1400, 206
6623, 1389, 4582, 1400, 206, 1390, 4583, 1401, 207
6624, 1390, 4583, 1401, 207, 1391, 4584, 1402, 208
6625, 1391, 4584, 1402, 208, 1392, 4585, 1403, 209
6626, 1392, 4585, 1403, 209, 1393, 4586, 1404, 210
6627, 1393, 4586, 1404, 210, 1394, 4587, 1405, 211
6628, 1394, 4587, 1405, 211, 233, 1676, 245, 13
6629, 1269, 1270, 181, 180, 4577, 4588, 1406, 1395
6630, 4577, 4588, 1406, 1395, 4578, 4589, 1407, 1396
6631, 4578, 4589, 1407, 1396, 4579, 4590, 1408, 1397
6632, 4579, 4590, 1408, 1397, 4580, 4591, 1409, 1398
6633, 4580, 4591, 1409, 1398, 4581, 4592, 1410, 1399
6634, 4581, 4592, 1410, 1399, 4582, 4593, 1411, 1400
6635, 4582, 4593, 1411, 1400, 4583, 4594, 1412, 1401
6636, 4583, 4594, 1412, 1401, 4584, 4595, 1413, 1402
6637, 4584, 4595, 1413, 1402, 4585, 4596, 1414, 1403
6638, 4585, 4596, 1414, 1403, 4586, 4597, 1415, 1404
6639, 4586, 4597, 1415, 1404, 4587, 4598, 1416, 1405
6640, 4587, 4598, 1416, 1405, 1676, 1677, 246, 245
6641, 1270, 1271, 182, 181, 4588, 4599, 1417, 1406
6642, 4588, 4599, 1417, 1406, 4589, 4600, 1418, 1407
6643, 4589, 4600, 1418, 1407, 4590, 4601, 1419, 1408
6644, 4590, 4601, 1419, 1408, 4591, 4602, 1420, 1409
6645, 4591, 4602, 1420, 1409, 4592, 4603, 1421, 1410
6646, 4592, 4603, 1421, 1410, 4593, 4604, 1422, 1411
6647, 4593, 4604, 1422, 1411, 4594, 4605, 1423, 1412
6648, 4594, 4605, 1423, 1412, 4595, 4606, 1424, 1413
6649, 4595, 4606, 1424, 1413, 4596, 4607, 1425, 1414
6650, 4596, 4607, 1425, 1414, 4597, 4608, 1426, 1415
6651, 4597, 4608, 1426, 1415, 4598, 4609, 1427, 1416
6652, 4598, 4609, 1427, 1416, 1677, 1678, 247, 246
6653, 1271, 1272, 183, 182, 4599, 4610, 1428, 1417
6654, 4599, 4610, 1428, 1417, 4600, 4611, 1429, 1418
6655, 4600, 4611, 1429, 1418, 4601, 4612, 1430, 1419
6656, 4601, 4612, 1430, 1419, 4602, 4613, 1431, 1420
6657, 4602, 4613, 1431, 1420, 4603, 4614, 1432, 1421
6658, 4603, 4614, 1432, 1421, 4604, 4615, 1433, 1422
6659, 4604, 4615, 1433, 1422, 4605, 4616, 1434, 1423
6660, 4605, 4616, 1434, 1423, 4606, 4617, 1435, 1424
6661, 4606, 4617, 1435, 1424, 4607, 4618, 1436, 1425
6662, 4607, 4618, 1436, 1425, 4608, 4619, 1437, 1426
6663, 4608, 4619, 1437, 1426, 4609, 4620, 1438, 1427
6664, 4609, 4620, 1438, 1427, 1678, 1679, 248, 247
6665, 1272, 1273, 184, 183, 4610, 4621, 1439, 1428
6666, 4610, 4621, 1439, 1428, 4611, 4622, 1440, 1429
6667, 4611, 4622, 1440, 1429, 4612, 4623, 1441, 1430
6668, 4612, 4623, 1441, 1430, 4613, 4624, 1442, 1431
6669, 4613, 4624, 1442, 1431, 4614, 4625, 1443, 1432
6670, 4614, 4625, 1443, 1432, 4615, 4626, 1444, 1433
6671, 4615, 4626, 1444, 1433, 4616, 4627, 1445, 1434
6672, 4616, 4627, 1445, 1434, 4617, 4628, 1446, 1435
6673, 4617, 4628, 1446, 1435, 4618, 4629, 1447, 1436
6674, 4618, 4629, 1447, 1436, 4619, 4630, 1448, 1437
6675, 4619, 4630, 1448, 1437, 4620, 4631, 1449, 1438
6676, 4620, 4631, 1449, 1438, 1679, 1680, 249, 248
6677, 1273, 195, 11, 184, 4621, 1560, 234, 1439
6678, 4621, 1560, 234, 1439, 4622, 1561, 235, 1440
6679, 4622, 1561, 235, 1440, 4623, 1562, 236, 1441
6680, 4623, 1562, 236, 1441, 4624, 1563, 237, 1442
6681, 4624, 1563, 237, 1442, 4625, 1564, 238, 1443
6682, 4625, 1564, 238, 1443, 4626, 1565, 239, 1444
6683, 4626, 1565, 239, 1444, 4627, 1566, 240, 1445
6684, 4627, 1566, 240, 1445, 4628, 1567, 241, 1446
6685, 4628, 1567, 241, 1446, 4629, 1568, 242, 1447
6686, 4629, 1568, 242, 1447, 4630, 1569, 243, 1448
6687, 4630, 1569, 243, 1448, 4631, 1570, 244, 1449
6688, 4631, 1570, 244, 1449, 1680, 271, 15, 249
*ELEMENT, type=C3D8, ELSET=Volume4
6689, 14, 272, 1626, 223, 18, 304, 1681, 277
6690, 272, 273, 1627, 1626, 304, 305, 1682, 1681
6691, 273, 274, 1628, 1627, 305, 306, 1683, 1682
6692, 274, 275, 1629, 1628, 306, 307, 1684, 1683
6693, 275, 276, 1630, 1629, 307, 308, 1685, 1684
6694, 276, 16, 261, 1630, 308, 20, 293, 1685
6695, 223, 1626, 1631, 224, 277, 1681, 1686, 278
6696, 1626, 1627, 1632, 1631, 1681, 1682, 1687, 1686
6697, 1627, 1628, 1633, 1632, 1682, 1683, 1688, 1687
6698, 1628, 1629, 1634, 1633, 1683, 1684, 1689, 1688
6699, 1629, 1630, 1635, 1634, 1684, 1685, 1690, 1689
6700, 1630, 261, 262, 1635, 1685, 293, 294, 1690
6701, 224, 1631, 1636, 225, 278, 1686, 1691, 279
6702, 1631, 1632, 1637, 1636, 1686, 1687, 1692, 1691
6703, 1632, 1633, 1638, 1637, 1687, 1688, 1693, 1692
6704, 1633, 1634, 1639, 1638, 1688, 1689, 1694, 1693
6705, 1634, 1635, 1640, 1639, 1689, 1690, 1695, 1694
6706, 1635, 262, 263, 1640, 1690, 294, 295, 1695
6707, 225, 1636, 1641, 226, 279, 1691, 1696, 280
6708, 1636, 1637, 1642, 1641, 1691, 1692, 1697, 1696
6709, 1637, 1638, 1643, 1642, 1692, 1693, 1698, 1697
6710, 1638, 1639, 1644, 1643, 1693, 1694, 1699, 1698
6711, 1639, 1640, 1645, 1644, 1694, 1695, 1700, 1699
6712, 1640, 263, 264, 1645, 1695, 295, 296, 1700
6713, 226, 1641, 1646, 227, 280, 1696, 1701, 281
6714, 1641, 1642, 1647, 1646, 1696, 1697, 1702, 1701
6715, 1642, 1643, 1648, 1647, 1697, 1698, 1703, 1702
6716, 1643, 1644, 1649, 1648, 1698, 1699, 1704, 1703
6717, 1644, 1645, 1650, 1649, 1699, 1700, 1705, 1704
6718, 1645, 264, 265, 1650, 1700, 296, 297, 1705
6719, 227, 1646, 1651, 228, 281, 1701, 1706, 282
6720, 1646, 1647, 1652, 1651, 1701, 1702, 1707, 1706
6721, 1647, 1648, 1653, 1652, 1702, 1703, 1708, 1707
6722, 1648, 1649, 1654, 1653, 1703, 1704, 1709, 1708
6723, 1649, 1650, 1655, 1654, 1704, 1705, 1710, 1709
6724, 1650, 265, 266, 1655, 1705, 297, 298, 1710
6725, 228, 1651, 1656, 229, 282, 1706, 1711, 283
6726, 1651, 1652, 1657, 1656, 1706, 1707, 1712, 1711
6727, 1652, 1653, 1658, 1657, 1707, 1708, 1713, 1712
6728, 1653, 1654, 1659, 1658, 1708, 1709, 1714, 1713
6729, 1654, 1655, 1660, 1659, 1709, 1710, 1715, 1714
6730, 1655, 266, 267, 1660, 1710, 298, 299, 1715
6731, 229, 1656, 1661, 230, 283, 1711, 1716, 284
6732, 1656, 1657, 1662, 1661, 1711, 1712, 1717, 1716
6733, 1657, 1658, 1663, 1662, 1712, 1713, 1718, 1717
6734, 1658, 1659, 1664, 1663, 1713, 1714, 1719, 1718
6735, 1659, 1660, 1665, 1664, 1714, 1715, 1720, 1719
6736, 1660, 267, 268, 1665, 1715, 299, 300, 1720
6737, 230, 1661, 1666, 231, 284, 1716, 1721, 285
6738, 1661, 1662, 1667, 1666, 1716, 1717, 1722, 1721
6739, 1662, 1663, 1668, 1667, 1717, 1718, 1723, 1722
6740, 1663, 1664, 1669, 1668, 1718, 1719, 1724, 1723
6741, 1664, 1665, 1670, 1669, 1719, 1720, 1725, 1724
6742, 1665, 268, 269, 1670, 1720, 300, 301, 1725
6743, 231, 1666, 1671, 232, 285, 1721, 1726, 286
6744, 1666, 1667, 1672, 1671, 1721, 1722, 1727, 1726
6745, 1667, 1668, 1673, 1672, 1722, 1723, 1728, 1727
6746, 1668, 1669, 1674, 1673, 1723, 1724, 1729, 1728
6747, 1669, 1670, 1675, 1674, 1724, 1725, 1730, 1729
6748, 1670, 269, 270, 1675, 1725, 301, 302, 1730
6749, 232, 1671, 1676, 233, 286, 1726, 1731, 287
6750, 1671, 1672, 1677, 1676, 1726, 1727, 1732, 1731
6751, 1672, 1673, 1678, 1677, 1727, 1728, 1733, 1732
6752, 1673, 1674, 1679, 1678, 1728, 1729, 1734, 1733
6753, 1674, 1675, 1680, 1679, 1729, 1730, 1735, 1734
6754, 1675, 270, 271, 1680, 1730, 302, 303, 1735
6755, 233, 1676, 245, 13, 287, 1731, 288, 17
6756, 1676, 1677, 246, 245, 1731, 1732, 289, 288
6757, 1677, 1678, 247, 246, 1732, 1733, 290, 289
6758, 1678, 1679, 248, 247, 1733, 1734, 291, 290
6759, 1679, 1680, 249, 248, 1734, 1735, 292, 291
6760, 1680, 271, 15, 249, 1735, 303, 19, 292
*ELEMENT, type=C3D8, ELSET=Volume5
6761, 18, 304, 1681, 277, 311, 1790, 4632, 1736
6762, 311, 1790, 4632, 1736, 312, 1791, 4633, 1737
6763, 312, 1791, 4633, 1737, 22, 344, 1800, 313
6764, 304, 305, 1682, 1681, 1790, 1792, 4634, 4632
6765, 1790, 1792, 4634, 4632, 1791, 1793, 4635, 4633
6766, 1791, 1793, 4635, 4633, 344, 345, 1801, 1800
6767, 305, 306, 1683, 1682, 1792, 1794, 4636, 4634
6768, 1792, 1794, 4636, 4634, 1793, 1795, 4637, 4635
6769, 1793, 1795, 4637, 4635, 345, 346, 1802, 1801
6770, 306, 307, 1684, 1683, 1794, 1796, 4638, 4636
6771, 1794, 1796, 4638, 4636, 1795, 1797, 4639, 4637
6772, 1795, 1797, 4639, 4637, 346, 347, 1803, 1802
6773, 307, 308, 1685, 1684, 1796, 1798, 4640, 4638
6774, 1796, 1798, 4640, 4638, 1797, 1799, 4641, 4639
6775, 1797, 1799, 4641, 4639, 347, 348, 1804, 1803
6776, 308, 20, 293, 1685, 1798, 331, 1768, 4640
6777, 1798, 331, 1768, 4640, 1799, 332, 1769, 4641
6778, 1799, 332, 1769, 4641, 348, 24, 333, 1804
6779, 277, 1681, 1686, 278, 1736, 4632, 4642, 1738
6780, 1736, 4632, 4642, 1738, 1737, 4633, 4643, 1739
6781, 1737, 4633, 4643, 1739, 313, 1800, 1805, 314
6782, 1681, 1682, 1687, 1686, 4632, 4634, 4644, 4642
6783, 4632, 4634, 4644, 4642, 4633, 4635, 4645, 4643
6784, 4633, 4635, 4645, 4643, 1800, 1801, 1806, 1805
6785, 1682, 1683, 1688, 1687, 4634, 4636, 4646, 4644
6786, 4634, 4636, 4646, 4644, 4635, 4637, 4647, 4645
6787, 4635, 4637, 4647, 4645, 1801, 1802, 1807, 1806
6788, 1683, 1684, 1689, 1688, 4636, 4638, 4648, 4646
6789, 4636, 4638, 4648, 4646, 4637, 4639, 4649, 4647
6790, 4637, 4639, 4649, 4647, 1802, 1803, 1808, 1807
6791, 1684, 1685, 1690, 1689, 4638, 4640, 4650, 4648
6792, 4638, 4640, 4650, 4648, 4639, 4641, 4651, 4649
6793, 4639, 4641, 4651, 4649, 1803, 1804, 1809, 1808
6794, 1685, 293, 294, 1690, 4640, 1768, 1770, 4650
6795, 4640, 1768, 1770, 4650, 4641, 1769, 1771, 4651
6796, 4641, 1769, 1771, 4651, 1804, 333, 334, 1809
6797, 278, 1686, 1691, 279, 1738, 4642, 4652, 1740
6798, 1738, 4642, 4652, 1740, 1739, 4643, 4653, 1741
6799, 1739, 4643, 4653, 1741, 314, 1805, 1810, 315
6800, 1686, 1687, 1692, 1691, 4642, 4644, 4654, 4652
6801, 4642, 4644, 4654, 4652, 4643, 4645, 4655, 4653
6802, 4643, 4645, 4655, 4653, 1805, 1806, 1811, 1810
6803, 1687, 1688, 1693, 1692, 4644, 4646, 4656, 4654
6804, 4644, 4646, 4656, 4654, 4645, 4647, 4657, 4655
6805, 4645, 4647, 4657, 4655, 1806, 1807, 1812, 1811
6806, 1688, 1689, 1694, 1693, 4646, 4648, 4658, 4656
6807, 4646, 4648, 4658, 4656, 4647, 4649, 4659, 4657
6808, 4647, 4649, 4659, 4657, 1807, 1808, 1813, 1812
6809, 1689, 1690, 1695, 1694, 4648, 4650, 4660, 4658
6810, 4648, 4650, 4660, 4658, 4649, 4651, 4661, 4659
6811, 4649, 4651, 4661, 4659, 1808, 1809, 1814, 1813
6812, 1690, 294, 295, 1695, 4650, 1770, 1772, 4660
6813, 4650, 1770, 1772, 4660, 4651, 1771, 1773, 4661
6814, 4651, 1771, 1773, 4661, 1809, 334, 335, 1814
6815, 279, 1691, 1696, 280, 1740, 4652, 4662, 1742
6816, 1740, 4652, 4662, 1742, 1741, 4653, 4663, 1743
6817, 1741, 4653, 4663, 1743, 315, 1810, 1815, 316
6818, 1691, 1692, 1697, 1696, 4652, 4654, 4664, 4662
6819, 4652, 4654, 4664, 4662, 4653, 4655, 4665, 4663
6820, 4653, 4655, 4665, 4663, 1810, 1811, 1816, 1815
6821, 1692, 1693, 1698, 1697, 4654, 4656, 4666, 4664
6822, 4654, 4656, 4666, 4664, 4655, 4657, 4667, 4665
6823, 4655, 4657, 4667, 4665, 1811, 1812, 1817, 1816
6824, 1693, 1694, 1699, 1698, 4656, 4658, 4668, 4666
6825, 4656, 4658, 4668, 4666, 4657, 4659, 4669, 4667
6826, 4657, 4659, 4669, 4667, 1812, 1813, 1818, 1817
6827, 1694, 1695, 1700, 1699, 4658, 4660, 4670, 4668
6828, 4658, 4660, 4670, 4668, 4659, 4661, 4671, 4669
6829, 4659, 4661, 4671, 4669, 1813, 1814, 1819, 1818
6830, 1695, 295, 296, 1700, 4660, 1772, 1774, 4670
6831, 4660, 1772, 1774, 4670, 4661, 1773, 1775, 4671
6832, 4661, 1773, 1775, 4671, 1814, 335, 336, 1819
6833, 280, 1696, 1701, 281, 1742, 4662, 4672, 1744
6834, 1742, 4662, 4672, 1744, 1743, 4663, 4673, 1745
6835, 1743, 4663, 4673, 1745, 316, 1815, 1820, 317
6836, 1696, 1697, 1702, 1701, 4662, 4664, 4674, 4672
6837, 4662, 4664, 4674, 4672, 4663, 4665, 4675, 4673
6838, 4663, 4665, 4675, 4673, 1815, 1816, 1821, 1820
6839, 1697, 1698, 1703, 1702, 4664, 4666, 4676, 4674
6840, 4664, 4666, 4676, 4674, 4665, 4667, 4677, 4675
6841, 4665, 4667, 4677, 4675, 1816, 1817, 1822, 1821
6842, 1698, 1699, 1704, 1703, 4666, 4668, 4678, 4676
6843, 4666, 4668, 4678, 4676, 4667, 4669, 4679, 4677
6844, 4667, 4669, 4679, 4677, 1817, 1818, 1823, 1822
6845, 1699, 1700, 1705, 1704, 4668, 4670, 4680, 4678
6846, 4668, 4670, 4680, 4678, 4669, 4671, 4681, 4679
6847, 4669, 4671, 4681, 4679, 1818, 1819, 1824, 1823
6848, 1700, 296, 297, 1705, 4670, 1774, 1776, 4680
6849, 4670, 1774, 1776, 4680, 4671, 1775, 1777, 4681
6850, 4671, 1775, 1777, 4681, 1819, 336, 337, 1824
6851, 281, 1701, 1706, 282, 1744, 4672, 4682, 1746
6852, 1744, 4672, 4682, 1746, 1745, 4673, 4683, 1747
6853, 1745, 4673, 4683, 1747, 317, 1820, 1825, 318
6854, 1701, 1702, 1707, 1706, 4672, 4674, 4684, 4682
6855, 4672, 4674, 4684, 4682, 4673, 4675, 4685, 4683
6856, 4673, 4675, 4685, 4683, 1820, 1821, 1826, 1825
6857, 1702, 1703, 1708, 1707, 4674, 4676, 4686, 4684
6858, 4674, 4676, 4686, 4684, 4675, 4677, 4687, 4685
6859, 4675, 4677, 4687, 4685, 1821, 1822, 1827, 1826
6860, 1703, 1704, 1709, 1708, 4676, 4678, 4688, 4686
6861, 4676, 4678, 4688, 4686, 4677, 4679, 4689, 4687
6862, 4677, 4679, 4689, 4687, 1822, 1823, 1828, 1827
6863, 1704, 1705, 1710, 1709, 4678, 4680, 4690, 4688
6864, 4678, 4680, 4690, 4688, 4679, 4681, 4691, 4689
6865, 4679, 4681, 4691, 4689, 1823, 1824, 1829, 1828
6866, 1705, 297, 298, 1710, 4680, 1776, 1778, 4690
6867, 4680, 1776, 1778, 4690, 4681, 1777, 1779, 4691
6868, 4681, 1777, 1779, 4691, 1824, 337, 338, 1829
6869, 282, 1706, 1711, 283, 1746, 4682, 4692, 1748
6870, 1746, 4682, 4692, 1748, 1747, 4683, 4693, 1749
6871, 1747, 4683, 4693, 1749, 318, 1825, 1830, 319
6872, 1706, 1707, 1712, 1711, 4682, 4684, 4694, 4692
6873, 4682, 4684, 4694, 4692, 4683, 4685, 4695, 4693
6874, 4683, 4685, 4695, 4693, 1825, 1826, 1831, 1830
6875, 1707, 1708, 1713, 1712, 4684, 4686, 4696, 4694
6876, 4684, 4686, 4696, 4694, 4685, 4687, 4697, 4695
6877, 4685, 4687, 4697, 4695, 1826, 1827, 1832, 1831
6878, 1708, 1709, 1714, 1713, 4686, 4688, 4698, 4696
6879, 4686, 4688, 4698, 4696, 4687, 4689, 4699, 4697
6880, 4687, 4689, 4699, 4697, 1827, 1828, 1833, 1832
6881, 1709, 1710, 1715, 1714, 4688, 4690, 4700, 4698
6882, 4688, 4690, 4700, 4698, 4689, 4691, 4701, 4699
6883, 4689, 4691, 4701, 4699, 1828, 1829, 1834, 1833
6884, 1710, 298, 299, 1715, 4690, 1778, 1780, 4700
6885, 4690, 1778, 1780, 4700, 4691, 1779, 1781, 4701
6886, 4691, 1779, 1781, 4701, 1829, 338, 339, 1834
6887, 283, 1711, 1716, 284, 1748, 4692, 4702, 1750
6888, 1748, 4692, 4702, 1750, 1749, 4693, 4703, 1751
6889, 1749, 4693, 4703, 1751, 319, 1830, 1835, 320
6890, 1711, 1712, 1717, 1716, 4692, 4694, 4704, 4702
6891, 4692, 4694, 4704, 4702, 4693, 4695, 4705, 4703
6892, 4693, 4695, 4705, 4703, 1830, 1831, 1836, 1835
6893, 1712, 1713, 1718, 1717, 4694, 4696, 4706, 4704
6894, 4694, 4696, 4706, 4704, 4695, 4697, 4707, 4705
6895, 4695, 4697, 4707, 4705, 1831, 1832, 1837, 1836
6896, 1713, 1714, 1719, 1718, 4696, 4698, 4708, 4706
6897, 4696, 4698, 4708, 4706, 4697, 4699, 4709, 4707
6898, 4697, 4699, 4709, 4707, 1832, 1833, 1838, 1837
6899, 1714, 1715, 1720, 1719, 4698, 4700, 4710, 4708
6900, 4698, 4700, 4710, 4708, 4699, 4701, 4711, 4709
6901, 4699, 4701, 4711, 4709, 1833, 1834, 1839, 1838
6902, 1715, 299, 300, 1720, 4700, 1780, 1782, 4710
6903, 4700, 1780, 1782, 4710, 4701, 1781, 1783, 4711
6904, 4701, 1781, 1783, 4711, 1834, 339, 340, 1839
6905, 284, 1716, 1721, 285, 1750, 4702, 4712, 1752
6906, 1750, 4702, 4712, 1752, 1751, 4703, 4713, 1753
6907, 1751, 4703, 4713, 1753, 320, 1835, 1840, 321
6908, 1716, 1717, 1722, 1721, 4702, 4704, 4714, 4712
6909, 4702, 4704, 4714, 4712, 4703, 4705, 4715, 4713
6910, 4703, 4705, 4715, 4713, 1835, 1836, 1841, 1840
6911, 1717, 1718, 1723, 1722, 4704, 4706, 4716, 4714
6912, 4704, 4706, 4716, 4714, 4705, 4707, 4717, 4715
6913, 4705, 4707, 4717, 4715, 1836, 1837, 1842, 1841
6914, 1718, 1719, 1724, 1723, 4706, 4708, 4718, 4716
6915, 4706, 4708, 4718, 4716, 4707, 4709, 4719, 4717
6916, 4707, 4709, 4719, 4717, 1837, 1838, 1843, 1842
6917, 1719, 1720, 1725, 1724, 4708, 4710, 4720, 4718
6918, 4708, 4710, 4720, 4718, 4709, 4711, 4721, 4719
6919, 4709, 4711, 4721, 4719, 1838, 1839, 1844, 1843
6920, 1720, 300, 301, 1725, 4710, 1782, 1784, 4720
6921, 4710, 1782, 1784, 4720, 4711, 1783, 1785, 4721
6922, 4711, 1783, 1785, 4721, 1839, 340, 341, 1844
6923, 285, 1721, 1726, 286, 1752, 4712, 4722, 1754
6924, 1752, 4712, 4722, 1754, 1753, 4713, 4723, 1755
6925, 1753, 4713, 4723, 1755, 321, 1840, 1845, 322
6926, 1721, 1722, 1727, 1726, 4712, 4714, 4724, 4722
6927, 4712, 4714, 4724, 4722, 4713, 4715, 4725, 4723
6928, 4713, 4715, 4725, 4723, 1840, 1841, 1846, 1845
6929, 1722, 1723, 1728, 1727, 4714, 4716, 4726, 4724
6930, 4714, 4716, 4726, 4724, 4715, 4717, 4727, 4725
6931, 4715, 4717, 4727, 4725, 1841, 1842, 1847, 1846
6932, 1723, 1724, 1729, 1728, 4716, 4718, 4728, 4726
6933, 4716, 4718, 4728, 4726, 4717, 4719, 4729, 4727
6934, 4717, 4719, 4729, 4727, 1842, 1843, 1848, 1847
6935, 1724, 1725, 1730, 1729, 4718, 4720, 4730, 4728
6936, 4718, 4720, 4730, 4728, 4719, 4721, 4731, 4729
6937, 4719, 4721, 4731, 4729, 1843, 1844, 1849, 1848
6938, 1725, 301, 302, 1730, 4720, 1784, 1786, 4730
6939, 4720, 1784, 1786, 4730, 4721, 1785, 1787, 4731
6940, 4721, 1785, 1787, 4731, 1844, 341, 342, 1849
6941, 286, 1726, 1731, 287, 1754, 4722, 4732, 1756
6942, 1754, 4722, 4732, 1756, 1755, 4723, 4733, 1757
6943, 1755, 4723, 4733, 1757, 322, 1845, 1850, 323
6944, 1726, 1727, 1732, 1731, 4722, 4724, 4734, 4732
6945, 4722, 4724, 4734, 4732, 4723, 4725, 4735, 4733
6946, 4723, 4725, 4735, 4733, 1845, 1846, 1851, 1850
6947, 1727, 1728, 1733, 1732, 4724, 4726, 4736, 4734
6948, 4724, 4726, 4736, 4734, 4725, 4727, 4737, 4735
6949, 4725, 4727, 4737, 4735, 1846, 1847, 1852, 1851
6950, 1728, 1729, 1734, 1733, 4726, 4728, 4738, 4736
6951, 4726, 4728, 4738, 4736, 4727, 4729, 4739, 4737
6952, 4727, 4729, 4739, 4737, 1847, 1848, 1853, 1852
6953, 1729, 1730, 1735, 1734, 4728, 4730, 4740, 4738
6954, 4728, 4730, 4740, 4738, 4729, 4731, 4741, 4739
6955, 4729, 4731, 4741, 4739, 1848, 1849, 1854, 1853
6956, 1730, 302, 303, 1735, 4730, 1786, 1788, 4740
6957, 4730, 1786, 1788, 4740, 4731, 1787, 1789, 4741
6958, 4731, 1787, 1789, 4741, 1849, 342, 343, 1854
6959, 287, 1731, 288, 17, 1756, 4732, 1758, 309
6960, 1756, 4732, 1758, 309, 1757, 4733, 1759, 310
6961, 1757, 4733, 1759, 310, 323, 1850, 326, 21
6962, 1731, 1732, 289, 288, 4732, 4734, 1760, 1758
6963, 4732, 4734, 1760, 1758, 4733, 4735, 1761, 1759
6964, 4733, 4735, 1761, 1759, 1850, 1851, 327, 326
6965, 1732, 1733, 290, 289, 4734, 4736, 1762, 1760
6966, 4734, 4736, 1762, 1760, 4735, 4737, 1763, 1761
6967, 4735, 4737, 1763, 1761, 1851, 1852, 328, 327
6968, 1733, 1734, 291, 290, 4736, 4738, 1764, 1762
6969, 4736, 4738, 1764, 1762, 4737, 4739, 1765, 1763
6970, 4737, 4739, 1765, 1763, 1852, 1853, 329, 328
6971, 1734, 1735, 292, 291, 4738, 4740, 1766, 1764
6972, 4738, 4740, 1766, 1764, 4739, 4741, 1767, 1765
6973, 4739, 4741, 1767, 1765, 1853, 1854, 330, 329
6974, 1735, 303, 19, 292, 4740, 1788, 324, 1766
6975, 4740, 1788, 324, 1766, 4741, 1789, 325, 1767
6976, 4741, 1789, 325, 1767, 1854, 343, 23, 330
*ELEMENT, type=C3D8, ELSET=Volume6
6977, 17, 309, 1758, 288, 359, 1863, 4742, 1871
6978, 359, 1863, 4742, 1871, 360, 1864, 4743, 1872
6979, 360, 1864, 4743, 1872, 361, 1865, 4744, 1873
6980, 361, 1865, 4744, 1873, 362, 1866, 4745, 1874
6981, 362, 1866, 4745, 1874, 27, 367, 1911, 369
6982, 309, 310, 1759, 1758, 1863, 1867, 4746, 4742
6983, 1863, 1867, 4746, 4742, 1864, 1868, 4747, 4743
6984, 1864, 1868, 4747, 4743, 1865, 1869, 4748, 4744
6985, 1865, 1869, 4748, 4744, 1866, 1870, 4749, 4745
6986, 1866, 1870, 4749, 4745, 367, 368, 1912, 1911
6987, 310, 21, 326, 1759, 1867, 363, 1891, 4746
6988, 1867, 363, 1891, 4746, 1868, 364, 1892, 4747
6989, 1868, 364, 1892, 4747, 1869, 365, 1893, 4748
6990, 1869, 365, 1893, 4748, 1870, 366, 1894, 4749
6991, 1870, 366, 1894, 4749, 368, 28, 374, 1912
6992, 288, 1758, 1760, 289, 1871, 4742, 4750, 1875
6993, 1871, 4742, 4750, 1875, 1872, 4743, 4751, 1876
6994, 1872, 4743, 4751, 1876, 1873, 4744, 4752, 1877
6995, 1873, 4744, 4752, 1877, 1874, 4745, 4753, 1878
6996, 1874, 4745, 4753, 1878, 369, 1911, 1913, 370
6997, 1758, 1759, 1761, 1760, 4742, 4746, 4754, 4750
6998, 4742, 4746, 4754, 4750, 4743, 4747, 4755, 4751
6999, 4743, 4747, 4755, 4751, 4744, 4748, 4756, 4752
7000, 4744, 4748, 4756, 4752, 4745, 4749, 4757, 4753
7001, 4745, 4749, 4757, 4753, 1911, 1912, 1914, 1913
7002, 1759, 326, 327, 1761, 4746, 1891, 1895, 4754
7003, 4746, 1891, 1895, 4754, 4747, 1892, 1896, 4755
7004, 4747, 1892, 1896, 4755, 4748, 1893, 1897, 4756
7005, 4748, 1893, 1897, 4756, 4749, 1894, 1898, 4757
7006, 4749, 1894, 1898, 4757, 1912, 374, 375, 1914
7007, 289, 1760, 1762, 290, 1875, 4750, 4758, 1879
7008, 1875, 4750, 4758, 1879, 1876, 4751, 4759, 1880
7009, 1876, 4751, 4759, 1880, 1877, 4752, 4760, 1881
7010, 1877, 4752, 4760, 1881, 1878, 4753, 4761, 1882
7011, 1878, 4753, 4761, 1882, 370, 1913, 1915, 371
7012, 1760, 1761, 1763, 1762, 4750, 4754, 4762, 4758
7013, 4750, 4754, 4762, 4758, 4751, 4755, 4763, 4759
7014, 4751, 4755, 4763, 4759, 4752, 4756, 4764, 4760
7015, 4752, 4756, 4764, 4760, 4753, 4757, 4765, 4761
7016, 4753, 4757, 4765, 4761, 1913, 1914, 1916, 1915
7017, 1761, 327, 328, 1763, 4754, 1895, 1899, 4762
7018, 4754, 1895, 1899, 4762, 4755, 1896, 1900, 4763
7019, 4755, 1896, 1900, 4763, 4756, 1897, 1901, 4764
7020, 4756, 1897, 1901, 4764, 4757, 1898, 1902, 4765
7021, 4757, 1898, 1902, 4765, 1914, 375, 376, 1916
7022, 290, 1762, 1764, 291, 1879, 4758, 4766, 1883
7023, 1879, 4758, 4766, 1883, 1880, 4759, 4767, 1884
7024, 1880, 4759, 4767, 1884, 1881, 4760, 4768, 1885
7025, 1881, 4760, 4768, 1885, 1882, 4761, 4769, 1886
7026, 1882, 4761, 4769, 1886, 371, 1915, 1917, 372
7027, 1762, 1763, 1765, 1764, 4758, 4762, 4770, 4766
7028, 4758, 4762, 4770, 4766, 4759, 4763, 4771, 4767
7029, 4759, 4763, 4771, 4767, 4760, 4764, 4772, 4768
7030, 4760, 4764, 4772, 4768, 4761, 4765, 4773, 4769
7031, 4761, 4765, 4773, 4769, 1915, 1916, 1918, 1917
7032, 1763, 328, 329, 1765, 4762, 1899, 1903, 4770
7033, 4762, 1899, 1903, 4770, 4763, 1900, 1904, 4771
7034, 4763, 1900, 1904, 4771, 4764, 1901, 1905, 4772
7035, 4764, 1901, 1905, 4772, 4765, 1902, 1906, 4773
7036, 4765, 1902, 1906, 4773, 1916, 376, 377, 1918
7037, 291, 1764, 1766, 292, 1883, 4766, 4774, 1887
7038, 1883, 4766, 4774, 1887, 1884, 4767, 4775, 1888
7039, 1884, 4767, 4775, 1888, 1885, 4768, 4776, 1889
7040, 1885, 4768, 4776, 1889, 1886, 4769, 4777, 1890
7041, 1886, 4769, 4777, 1890, 372, 1917, 1919, 373
7042, 1764, 1765, 1767, 1766, 4766, 4770, 4778, 4774
7043, 4766, 4770, 4778, 4774, 4767, 4771, 4779, 4775
7044, 4767, 4771, 4779, 4775, 4768, 4772, 4780, 4776
7045, 4768, 4772, 4780, 4776, 4769, 4773, 4781, 4777
7046, 4769, 4773, 4781, 4777, 1917, 1918, 1920, 1919
7047, 1765, 329, 330, 1767, 4770, 1903, 1907, 4778
7048, 4770, 1903, 1907, 4778, 4771, 1904, 1908, 4779
7049, 4771, 1904, 1908, 4779, 4772, 1905, 1909, 4780
7050, 4772, 1905, 1909, 4780, 4773, 1906, 1910, 4781
7051, 4773, 1906, 1910, 4781, 1918, 377, 378, 1920
7052, 292, 1766, 324, 19, 1887, 4774, 1855, 349
7053, 1887, 4774, 1855, 349, 1888, 4775, 1856, 350
7054, 1888, 4775, 1856, 350, 1889, 4776, 1857, 351
7055, 1889, 4776, 1857, 351, 1890, 4777, 1858, 352
7056, 1890, 4777, 1858, 352, 373, 1919, 357, 25
7057, 1766, 1767, 325, 324, 4774, 4778, 1859, 1855
7058, 4774, 4778, 1859, 1855, 4775, 4779, 1860, 1856
7059, 4775, 4779, 1860, 1856, 4776, 4780, 1861, 1857
7060, 4776, 4780, 1861, 1857, 4777, 4781, 1862, 1858
7061, 4777, 4781, 1862, 1858, 1919, 1920, 358, 357
7062, 1767, 330, 23, 325, 4778, 1907, 353, 1859
7063, 4778, 1907, 353, 1859, 4779, 1908, 354, 1860
7064, 4779, 1908, 354, 1860, 4780, 1909, 355, 1861
7065, 4780, 1909, 355, 1861, 4781, 1910, 356, 1862
7066, 4781, 1910, 356, 1862, 1920, 378, 26, 358
*ELEMENT, type=C3D8, ELSET=Volume7
7067, 27, 367, 1911, 369, 403, 1943, 4782, 1965
7068, 403, 1943, 4782, 1965, 404, 1944, 4783, 1966
7069, 404, 1944, 4783, 1966, 405, 1945, 4784, 1967
7070, 405, 1945, 4784, 1967, 406, 1946, 4785, 1968
7071, 406, 1946, 4785, 1968, 407, 1947, 4786, 1969
7072, 407, 1947, 4786, 1969, 408, 1948, 4787, 1970
7073, 408, 1948, 4787, 1970, 409, 1949, 4788, 1971
7074, 409, 1949, 4788, 1971, 410, 1950, 4789, 1972
7075, 410, 1950, 4789, 1972, 411, 1951, 4790, 1973
7076, 411, 1951, 4790, 1973, 412, 1952, 4791, 1974
7077, 412, 1952, 4791, 1974, 413, 1953, 4792, 1975
7078, 413, 1953, 4792, 1975, 31, 425, 2075, 427
7079, 367, 368, 1912, 1911, 1943, 1954, 4793, 4782
7080, 1943, 1954, 4793, 4782, 1944, 1955, 4794, 4783
7081, 1944, 1955, 4794, 4783, 1945, 1956, 4795, 4784
7082, 1945, 1956, 4795, 4784, 1946, 1957, 4796, 4785
7083, 1946, 1957, 4796, 4785, 1947, 1958, 4797, 4786
7084, 1947, 1958, 4797, 4786, 1948, 1959, 4798, 4787
7085, 1948, 1959, 4798, 4787, 1949, 1960, 4799, 4788
7086, 1949, 1960, 4799, 4788, 1950, 1961, 4800, 4789
7087, 1950, 1961, 4800, 4789, 1951, 1962, 4801, 4790
7088, 1951, 1962, 4801, 4790, 1952, 1963, 4802, 4791
7089, 1952, 1963, 4802, 4791, 1953, 1964, 4803, 4792
7090, 1953, 1964, 4803, 4792, 425, 426, 2076, 2075
7091, 368, 28, 374, 1912, 1954, 414, 2020, 4793
7092, 1954, 414, 2020, 4793, 1955, 415, 2021, 4794
7093, 1955, 415, 2021, 4794, 1956, 416, 2022, 4795
7094, 1956, 416, 2022, 4795, 1957, 417, 2023, 4796
7095, 1957, 417, 2023, 4796, 1958, 418, 2024, 4797
7096, 1958, 418, 2024, 4797, 1959, 419, 2025, 4798
7097, 1959, 419, 2025, 4798, 1960, 420, 2026, 4799
7098, 1960, 420, 2026, 4799, 1961, 421, 2027, 4800
7099, 1961, 421, 2027, 4800, 1962, 422, 2028, 4801
7100, 1962, 422, 2028, 4801, 1963, 423, 2029, 4802
7101, 1963, 423, 2029, 4802, 1964, 424, 2030, 4803
7102, 1964, 424, 2030, 4803, 426, 32, 432, 2076
7103, 369, 1911, 1913, 370, 1965, 4782, 4804, 1976
7104, 1965, 4782, 4804, 1976, 1966, 4783, 4805, 1977
7105, 1966, 4783, 4805, 1977, 1967, 4784, 4806, 1978
7106, 1967, 4784, 4806, 1978, 1968, 4785, 4807, 1979
7107, 1968, 4785, 4807, 1979, 1969, 4786, 4808, 1980
7108, 1969, 4786, 4808, 1980, 1970, 4787, 4809, 1981
7109, 1970, 4787, 4809, 1981, 1971, 4788, 4810, 1982
7110, 1971, 4788, 4810, 1982, 1972, 4789, 4811, 1983
7111, 1972, 4789, 4811, 1983, 1973, 4790, 4812, 1984
7112, 1973, 4790, 4812, 1984, 1974, 4791, 4813, 1985
7113, 1974, 4791, 4813, 1985, 1975, 4792, 4814, 1986
7114, 1975, 4792, 4814, 1986, 427, 2075, 2077, 428
7115, 1911, 1912, 1914, 1913, 4782, 4793, 4815, 4804
7116, 4782, 4793, 4815, 4804, 4783, 4794, 4816, 4805
7117, 4783, 4794, 4816, 4805, 4784, 4795, 4817, 4806
7118, 4784, 4795, 4817, 4806, 4785, 4796, 4818, 4807
7119, 4785, 4796, 4818, 4807, 4786, 4797, 4819, 4808
7120, 4786, 4797, 4819, 4808, 4787, 4798, 4820, 4809
7121, 4787, 4798, 4820, 4809, 4788, 4799, 4821, 4810
7122, 4788, 4799, 4821, 4810, 4789, 4800, 4822, 4811
7123, 4789, 4800, 4822, 4811, 4790, 4801, 4823, 4812
7124, 4790, 4801, 4823, 4812, 4791, 4802, 4824, 4813
7125, 4791, 4802, 4824, 4813, 4792, 4803, 4825, 4814
7126, 4792, 4803, 4825, 4814, 2075, 2076, 2078, 2077
7127, 1912, 374, 375, 1914, 4793, 2020, 2031, 4815
7128, 4793, 2020, 2031, 4815, 4794, 2021, 2032, 4816
7129, 4794, 2021, 2032, 4816, 4795, 2022, 2033, 4817
7130, 4795, 2022, 2033, 4817, 4796, 2023, 2034, 4818
7131, 4796, 2023, 2034, 4818, 4797, 2024, 2035, 4819
7132, 4797, 2024, 2035, 4819, 4798, 2025, 2036, 4820
7133, 4798, 2025, 2036, 4820, 4799, 2026, 2037, 4821
7134, 4799, 2026, 2037, 4821, 4800, 2027, 2038, 4822
7135, 4800, 2027, 2038, 4822, 4801, 2028, 2039, 4823
7136, 4801, 2028, 2039, 4823, 4802, 2029, 2040, 4824
7137, 4802, 2029, 2040, 4824, 4803, 2030, 2041, 4825
7138, 4803, 2030, 2041, 4825, 2076, 432, 433, 2078
7139, 370, 1913, 1915, 371, 1976, 4804, 4826, 1987
7140, 1976, 4804, 4826, 1987, 1977, 4805, 4827, 1988
7141, 1977, 4805, 4827, 1988, 1978, 4806, 4828, 1989
7142, 1978, 4806, 4828, 1989, 1979, 4807, 4829, 1990
7143, 1979, 4807, 4829, 1990, 1980, 4808, 4830, 1991
7144, 1980, 4808, 4830, 1991, 1981, 4809, 4831, 1992
7145, 1981, 4809, 4831, 1992, 1982, 4810, 4832, 1993
7146, 1982, 4810, 4832, 1993, 1983, 4811, 4833, 1994
7147, 1983, 4811, 4833, 1994, 1984, 4812, 4834, 1995
7148, 1984, 4812, 4834, 1995, 1985, 4813, 4835, 1996
7149, 1985, 4813, 4835, 1996, 1986, 4814, 4836, 1997
7150, 1986, 4814, 4836, 1997, 428, 2077, 2079, 429
7151, 1913, 1914, 1916, 1915, 4804, 4815, 4837, 4826
7152, 4804, 4815, 4837, 4826, 4805, 4816, 4838, 4827
7153, 4805, 4816, 4838, 4827, 4806, 4817, 4839, 4828
7154, 4806, 4817, 4839, 4828, 4807, 4818, 4840, 4829
7155, 4807, 4818, 4840, 4829, 4808, 4819, 4841, 4830
7156, 4808, 4819, 4841, 4830, 4809, 4820, 4842, 4831
7157, 4809, 4820, 4842, 4831, 4810, 4821, 4843, 4832
7158, 4810, 4821, 4843, 4832, 4811, 4822, 4844, 4833
7159, 4811, 4822, 4844, 4833, 4812, 4823, 4845, 4834
7160, 4812, 4823, 4845, 4834, 4813, 4824, 4846, 4835
7161, 4813, 4824, 4846, 4835, 4814, 4825, 4847, 4836
7162, 4814, 4825, 4847, 4836, 2077, 2078, 2080, 2079
7163, 1914, 375, 376, 1916, 4815, 2031, 2042, 4837
7164, 4815, 2031, 2042, 4837, 4816, 2032, 2043, 4838
7165, 4816, 2032, 2043, 4838, 4817, 2033, 2044, 4839
7166, 4817, 2033, 2044, 4839, 4818, 2034, 2045, 4840
7167, 4818, 2034, 2045, 4840, 4819, 2035, 2046, 4841
7168, 4819, 2035, 2046, 4841, 4820, 2036, 2047, 4842
7169, 4820, 2036, 2047, 4842, 4821, 2037, 2048, 4843
7170, 4821, 2037, 2048, 4843, 4822, 2038, 2049, 4844
7171, 4822, 2038, 2049, 4844, 4823, 2039, 2050, 4845
7172, 4823, 2039, 2050, 4845, 4824, 2040, 2051, 4846
7173, 4824, 2040, 2051, 4846, 4825, 2041, 2052, 4847
7174, 4825, 2041, 2052, 4847, 2078, 433, 434, 2080
7175, 371, 1915, 1917, 372, 1987, 4826, 4848, 1998
7176, 1987, 4826, 4848, 1998, 1988, 4827, 4849, 1999
7177, 1988, 4827, 4849, 1999, 1989, 4828, 4850, 2000
7178, 1989, 4828, 4850, 2000, 1990, 4829, 4851, 2001
7179, 1990, 4829, 4851, 2001, 1991, 4830, 4852, 2002
7180, 1991, 4830, 4852, 2002, 1992, 4831, 4853, 2003
7181, 1992, 4831, 4853, 2003, 1993, 4832, 4854, 2004
7182, 1993, 4832, 4854, 2004, 1994, 4833, 4855, 2005
7183, 1994, 4833, 4855, 2005, 1995, 4834, 4856, 2006
7184, 1995, 4834, 4856, 2006, 1996, 4835, 4857, 2007
7185, 1996, 4835, 4857, 2007, 1997, 4836, 4858, 2008
7186, 1997, 4836, 4858, 2008, 429, 2079, 2081, 430
7187, 1915, 1916, 1918, 1917, 4826, 4837, 4859, 4848
7188, 4826, 4837, 4859, 4848, 4827, 4838, 4860, 4849
7189, 4827, 4838, 4860, 4849, 4828, 4839, 4861, 4850
7190, 4828, 4839, 4861, 4850, 4829, 4840, 4862, 4851
7191, 4829, 4840, 4862, 4851, 4830, 4841, 4863, 4852
7192, 4830, 4841, 4863, 4852, 4831, 4842, 4864, 4853
7193, 4831, 4842, 4864, 4853, 4832, 4843, 4865, 4854
7194, 4832, 4843, 4865, 4854, 4833, 4844, 4866, 4855
7195, 4833, 4844, 4866, 4855, 4834, 4845, 4867, 4856
7196, 4834, 4845, 4867, 4856, 4835, 4846, 4868, 4857
7197, 4835, 4846, 4868, 4857, 4836, 4847, 4869, 4858
7198, 4836, 4847, 4869, 4858, 2079, 2080, 2082, 2081
7199, 1916, 376, 377, 1918, 4837, 2042, 2053, 4859
7200, 4837, 2042, 2053, 4859, 4838, 2043, 2054, 4860
7201, 4838, 2043, 2054, 4860, 4839, 2044, 2055, 4861
7202, 4839, 2044, 2055, 4861, 4840, 2045, 2056, 4862
7203, 4840, 2045, 2056, 4862, 4841, 2046, 2057, 4863
7204, 4841, 2046, 2057, 4863, 4842, 2047, 2058, 4864
7205, 4842, 2047, 2058, 4864, 4843, 2048, 2059, 4865
7206, 4843, 2048, 2059, 4865, 4844, 2049, 2060, 4866
7207, 4844, 2049, 2060, 4866, 4845, 2050, 2061, 4867
7208, 4845, 2050, 2061, 4867, 4846, 2051, 2062, 4868
7209, 4846, 2051, 2062, 4868, 4847, 2052, 2063, 4869
7210, 4847, 2052, 2063, 4869, 2080, 434, 435, 2082
7211, 372, 1917, 1919, 373, 1998, 4848, 4870, 2009
7212, 1998, 4848, 4870, 2009, 1999, 4849, 4871, 2010
7213, 1999, 4849, 4871, 2010, 2000, 4850, 4872, 2011
7214, 2000, 4850, 4872, 2011, 2001, 4851, 4873, 2012
7215, 2001, 4851, 4873, 2012, 2002, 4852, 4874, 2013
7216, 2002, 4852, 4874, 2013, 2003, 4853, 4875, 2014
7217, 2003, 4853, 4875, 2014, 2004, 4854, 4876, 2015
7218, 2004, 4854, 4876, 2015, 2005, 4855, 4877, 2016
7219, 2005, 4855, 4877, 2016, 2006, 4856, 4878, 2017
7220, 2006, 4856, 4878, 2017, 2007, 4857, 4879, 2018
7221, 2007, 4857, 4879, 2018, 2008, 4858, 4880, 2019
7222, 2008, 4858, 4880, 2019, 430, 2081, 2083, 431
7223, 1917, 1918, 1920, 1919, 4848, 4859, 4881, 4870
7224, 4848, 4859, 4881, 4870, 4849, 4860, 4882, 4871
7225, 4849, 4860, 4882, 4871, 4850, 4861, 4883, 4872
7226, 4850, 4861, 4883, 4872, 4851, 4862, 4884, 4873
7227, 4851, 4862, 4884, 4873, 4852, 4863, 4885, 4874
7228, 4852, 4863, 4885, 4874, 4853, 4864, 4886, 4875
7229, 4853, 4864, 4886, 4875, 4854, 4865, 4887, 4876
7230, 4854, 4865, 4887, 4876, 4855, 4866, 4888, 4877
7231, 4855, 4866, 4888, 4877, 4856, 4867, 4889, 4878
7232, 4856, 4867, 4889, 4878, 4857, 4868, 4890, 4879
7233, 4857, 4868, 4890, 4879, 4858, 4869, 4891, 4880
7234, 4858, 4869, 4891, 4880, 2081, 2082, 2084, 2083
7235, 1918, 377, 378, 1920, 4859, 2053, 2064, 4881
7236, 4859, 2053, 2064, 4881, 4860, 2054, 2065, 4882
7237, 4860, 2054, 2065, 4882, 4861, 2055, 2066, 4883
7238, 4861, 2055, 2066, 4883, 4862, 2056, 2067, 4884
7239, 4862, 2056, 2067, 4884, 4863, 2057, 2068, 4885
7240, 4863, 2057, 2068, 4885, 4864, 2058, 2069, 4886
7241, 4864, 2058, 2069, 4886, 4865, 2059, 2070, 4887
7242, 4865, 2059, 2070, 4887, 4866, 2060, 2071, 4888
7243, 4866, 2060, 2071, 4888, 4867, 2061, 2072, 4889
7244, 4867, 2061, 2072, 4889, 4868, 2062, 2073, 4890
7245, 4868, 2062, 2073, 4890, 4869, 2063, 2074, 4891
7246, 4869, 2063, 2074, 4891, 2082, 435, 436, 2084
7247, 373, 1919, 357, 25, 2009, 4870, 1921, 379
7248, 2009, 4870, 1921, 379, 2010, 4871, 1922, 380
7249, 2010, 4871, 1922, 380, 2011, 4872, 1923, 381
7250, 2011, 4872, 1923, 381, 2012, 4873, 1924, 382
7251, 2012, 4873, 1924, 382, 2013, 4874, 1925, 383
7252, 2013, 4874, 1925, 383, 2014, 4875, 1926, 384
7253, 2014, 4875, 1926, 384, 2015, 4876, 1927, 385
7254, 2015, 4876, 1927, 385, 2016, 4877, 1928, 386
7255, 2016, 4877, 1928, 386, 2017, 4878, 1929, 387
7256, 2017, 4878, 1929, 387, 2018, 4879, 1930, 388
7257, 2018, 4879, 1930, 388, 2019, 4880, 1931, 389
7258, 2019, 4880, 1931, 389, 431, 2083, 401, 29
7259, 1919, 1920, 358, 357, 4870, 4881, 1932, 1921
7260, 4870, 4881, 1932, 1921, 4871, 4882, 1933, 1922
7261, 4871, 4882, 1933, 1922, 4872, 4883, 1934, 1923
7262, 4872, 4883, 1934, 1923, 4873, 4884, 1935, 1924
7263, 4873, 4884, 1935, 1924, 4874, 4885, 1936, 1925
7264, 4874, 4885, 1936, 1925, 4875, 4886, 1937, 1926
7265, 4875, 4886, 1937, 1926, 4876, 4887, 1938, 1927
7266, 4876, 4887, 1938, 1927, 4877, 4888, 1939, 1928
7267, 4877, 4888, 1939, 1928, 4878, 4889, 1940, 1929
7268, 4878, 4889, 1940, 1929, 4879, 4890, 1941, 1930
7269, 4879, 4890, 1941, 1930, 4880, 4891, 1942, 1931
7270, 4880, 4891, 1942, 1931, 2083, 2084, 402, 401
7271, 1920, 378, 26, 358, 4881, 2064, 390, 1932
7272, 4881, 2064, 390, 1932, 4882, 2065, 391, 1933
7273, 4882, 2065, 391, 1933, 4883, 2066, 392, 1934
7274, 4883, 2066, 392, 1934, 4884, 2067, 393, 1935
7275, 4884, 2067, 393, 1935, 4885, 2068, 394, 1936
7276, 4885, 2068, 394, 1936, 4886, 2069, 395, 1937
7277, 4886, 2069, 395, 1937, 4887, 2070, 396, 1938
7278, 4887, 2070, 396, 1938, 4888, 2071, 397, 1939
7279, 4888, 2071, 397, 1939, 4889, 2072, 398, 1940
7280, 4889, 2072, 398, 1940, 4890, 2073, 399, 1941
7281, 4890, 2073, 399, 1941, 4891, 2074, 400, 1942
7282, 4891, 2074, 400, 1942, 2084, 436, 30, 402
*ELEMENT, type=C3D8, ELSET=Volume8
7283, 27, 403, 1965, 369, 35, 448, 2085, 459
7284, 403, 404, 1966, 1965, 448, 449, 2086, 2085
7285, 404, 405, 1967, 1966, 449, 450, 2087, 2086
7286, 405, 406, 1968, 1967, 450, 451, 2088, 2087
7287, 406, 407, 1969, 1968, 451, 452, 2089, 2088
7288, 407, 408, 1970, 1969, 452, 453, 2090, 2089
7289, 408, 409, 1971, 1970, 453, 454, 2091, 2090
7290, 409, 410, 1972, 1971, 454, 455, 2092, 2091
7291, 410, 411, 1973, 1972, 455, 456, 2093, 2092
7292, 411, 412, 1974, 1973, 456, 457, 2094, 2093
7293, 412, 413, 1975, 1974, 457, 458, 2095, 2094
7294, 413, 31, 427, 1975, 458, 36, 464, 2095
7295, 369, 1965, 1976, 370, 459, 2085, 2096, 460
7296, 1965, 1966, 1977, 1976, 2085, 2086, 2097, 2096
7297, 1966, 1967, 1978, 1977, 2086, 2087, 2098, 2097
7298, 1967, 1968, 1979, 1978, 2087, 2088, 2099, 2098
7299, 1968, 1969, 1980, 1979, 2088, 2089, 2100, 2099
7300, 1969, 1970, 1981, 1980, 2089, 2090, 2101, 2100
7301, 1970, 1971, 1982, 1981, 2090, 2091, 2102, 2101
7302, 1971, 1972, 1983, 1982, 2091, 2092, 2103, 2102
7303, 1972, 1973, 1984, 1983, 2092, 2093, 2104, 2103
7304, 1973, 1974, 1985, 1984, 2093, 2094, 2105, 2104
7305, 1974, 1975, 1986, 1985, 2094, 2095, 2106, 2105
7306, 1975, 427, 428, 1986, 2095, 464, 465, 2106
7307, 370, 1976, 1987, 371, 460, 2096, 2107, 461
7308, 1976, 1977, 1988, 1987, 2096, 2097, 2108, 2107
7309, 1977, 1978, 1989, 1988, 2097, 2098, 2109, 2108
7310, 1978, 1979, 1990, 1989, 2098, 2099, 2110, 2109
7311, 1979, 1980, 1991, 1990, 2099, 2100, 2111, 2110
7312, 1980, 1981, 1992, 1991, 2100, 2101, 2112, 2111
7313, 1981, 1982, 1993, 1992, 2101, 2102, 2113, 2112
7314, 1982, 1983, 1994, 1993, 2102, 2103, 2114, 2113
7315, 1983, 1984, 1995, 1994, 2103, 2104, 2115, 2114
7316, 1984, 1985, 1996, 1995, 2104, 2105, 2116, 2115
7317, 1985, 1986, 1997, 1996, 2105, 2106, 2117, 2116
7318, 1986, 428, 429, 1997, 2106, 465, 466, 2117
7319, 371, 1987, 1998, 372, 461, 2107, 2118, 462
7320, 1987, 1988, 1999, 1998, 2107, 2108, 2119, 2118
7321, 1988, 1989, 2000, 1999, 2108, 2109, 2120, 2119
7322, 1989, 1990, 2001, 2000, 2109, 2110, 2121, 2120
7323, 1990, 1991, 2002, 2001, 2110, 2111, 2122, 2121
7324, 1991, 1992, 2003, 2002, 2111, 2112, 2123, 2122
7325, 1992, 1993, 2004, 2003, 2112, 2113, 2124, 2123
7326, 1993, 1994, 2005, 2004, 2113, 2114, 2125, 2124
7327, 1994, 1995, 2006, 2005, 2114, 2115, 2126, 2125
7328, 1995, 1996, 2007, 2006, 2115, 2116, 2127, 2126
7329, 1996, 1997, 2008, 2007, 2116, 2117, 2128, 2127
7330, 1997, 429, 430, 2008, 2117, 466, 467, 2128
7331, 372, 1998, 2009, 373, 462, 2118, 2129, 463
7332, 1998, 1999, 2010, 2009, 2118, 2119, 2130, 2129
7333, 1999, 2000, 2011, 2010, 2119, 2120, 2131, 2130
7334, 2000, 2001, 2012, 2011, 2120, 2121, 2132, 2131
7335, 2001, 2002, 2013, 2012, 2121, 2122, 2133, 2132
7336, 2002, 2003, 2014, 2013, 2122, 2123, 2134, 2133
7337, 2003, 2004, 2015, 2014, 2123, 2124, 2135, 2134
7338, 2004, 2005, 2016, 2015, 2124, 2125, 2136, 2135
7339, 2005, 2006, 2017, 2016, 2125, 2126, 2137, 2136
7340, 2006, 2007, 2018, 2017, 2126, 2127, 2138, 2137
7341, 2007, 2008, 2019, 2018, 2127, 2128, 2139, 2138
7342, 2008, 430, 431, 2019, 2128, 467, 468, 2139
7343, 373, 2009, 379, 25, 463, 2129, 437, 33
7344, 2009, 2010, 380, 379, 2129, 2130, 438, 437
7345, 2010, 2011, 381, 380, 2130, 2131, 439, 438
7346, 2011, 2012, 382, 381, 2131, 2132, 440, 439
7347, 2012, 2013, 383, 382, 2132, 2133, 441, 440
7348, 2013, 2014, 384, 383, 2133, 2134, 442, 441
7349, 2014, 2015, 385, 384, 2134, 2135, 443, 442
7350, 2015, 2016, 386, 385, 2135, 2136, 444, 443
7351, 2016, 2017, 387, 386, 2136, 2137, 445, 444
7352, 2017, 2018, 388, 387, 2137, 2138, 446, 445
7353, 2018, 2019, 389, 388, 2138, 2139, 447, 446
7354, 2019, 431, 29, 389, 2139, 468, 34, 447
*ELEMENT, type=C3D8, ELSET=Volume9
7355, 35, 448, 2085, 459, 502, 2261, 4892, 2382
7356, 502, 2261, 4892, 2382, 503, 2262, 4893, 2383
7357, 503, 2262, 4893, 2383, 504, 2263, 4894, 2384
7358, 504, 2263, 4894, 2384, 505, 2264, 4895, 2385
7359, 505, 2264, 4895, 2385, 506, 2265, 4896, 2386
7360, 506, 2265, 4896, 2386, 507, 2266, 4897, 2387
7361, 507, 2266, 4897, 2387, 508, 2267, 4898, 2388
7362, 508, 2267, 4898, 2388, 509, 2268, 4899, 2389
7363, 509, 2268, 4899, 2389, 510, 2269, 4900, 2390
7364, 510, 2269, 4900, 2390, 511, 2270, 4901, 2391
7365, 511, 2270, 4901, 2391, 512, 2271, 4902, 2392
7366, 512, 2271, 4902, 2392, 39, 524, 2492, 535
7367, 448, 449, 2086, 2085, 2261, 2272, 4903, 4892
7368, 2261, 2272, 4903, 4892, 2262, 2273, 4904, 4893
7369, 2262, 2273, 4904, 4893, 2263, 2274, 4905, 4894
7370, 2263, 2274, 4905, 4894, 2264, 2275, 4906, 4895
7371, 2264, 2275, 4906, 4895, 2265, 2276, 4907, 4896
7372, 2265, 2276, 4907, 4896, 2266, 2277, 4908, 4897
7373, 2266, 2277, 4908, 4897, 2267, 2278, 4909, 4898
7374, 2267, 2278, 4909, 4898, 2268, 2279, 4910, 4899
7375, 2268, 2279, 4910, 4899, 2269, 2280, 4911, 4900
7376, 2269, 2280, 4911, 4900, 2270, 2281, 4912, 4901
7377, 2270, 2281, 4912, 4901, 2271, 2282, 4913, 4902
7378, 2271, 2282, 4913, 4902, 524, 525, 2493, 2492
7379, 449, 450, 2087, 2086, 2272, 2283, 4914, 4903
7380, 2272, 2283, 4914, 4903, 2273, 2284, 4915, 4904
7381, 2273, 2284, 4915, 4904, 2274, 2285, 4916, 4905
7382, 2274, 2285, 4916, 4905, 2275, 2286, 4917, 4906
7383, 2275, 2286, 4917, 4906, 2276, 2287, 4918, 4907
7384, 2276, 2287, 4918, 4907, 2277, 2288, 4919, 4908
7385, 2277, 2288, 4919, 4908, 2278, 2289, 4920, 4909
7386, 2278, 2289, 4920, 4909, 2279, 2290, 4921, 4910
7387, 2279, 2290, 4921, 4910, 2280, 2291, 4922, 4911
7388, 2280, 2291, 4922, 4911, 2281, 2292, 4923, 4912
7389, 2281, 2292, 4923, 4912, 2282, 2293, 4924, 4913
7390, 2282, 2293, 4924, 4913, 525, 526, 2494, 2493
7391, 450, 451, 2088, 2087, 2283, 2294, 4925, 4914
7392, 2283, 2294, 4925, 4914, 2284, 2295, 4926, 4915
7393, 2284, 2295, 4926, 4915, 2285, 2296, 4927, 4916
7394, 2285, 2296, 4927, 4916, 2286, 2297, 4928, 4917
7395, 2286, 2297, 4928, 4917, 2287, 2298, 4929, 4918
7396, 2287, 2298, 4929, 4918, 2288, 2299, 4930, 4919
7397, 2288, 2299, 4930, 4919, 2289, 2300, 4931, 4920
7398, 2289, 2300, 4931, 4920, 2290, 2301, 4932, 4921
7399, 2290, 2301, 4932, 4921, 2291, 2302, 4933, 4922
7400, 2291, 2302, 4933, 4922, 2292, 2303, 4934, 4923
7401, 2292, 2303, 4934, 4923, 2293, 2304, 4935, 4924
7402, 2293, 2304, 4935, 4924, 526, 527, 2495, 2494
7403, 451, 452, 2089, 2088, 2294, 2305, 4936, 4925
7404, 2294, 2305, 4936, 4925, 2295, 2306, 4937, 4926
7405, 2295, 2306, 4937, 4926, 2296, 2307, 4938, 4927
7406, 2296, 2307, 4938, 4927, 2297, 2308, 4939, 4928
7407, 2297, 2308, 4939, 4928, 2298, 2309, 4940, 4929
7408, 2298, 2309, 4940, 4929, 2299, 2310, 4941, 4930
7409, 2299, 2310, 4941, 4930, 2300, 2311, 4942, 4931
7410, 2300, 2311, 4942, 4931, 2301, 2312, 4943, 4932
7411, 2301, 2312, 4943, 4932, 2302, 2313, 4944, 4933
7412, 2302, 2313, 4944, 4933, 2303, 2314, 4945, 4934
7413, 2303, 2314, 4945, 4934, 2304, 2315, 4946, 4935
7414, 2304, 2315, 4946, 4935, 527, 528, 2496, 2495
7415, 452, 453, 2090, 2089, 2305, 2316, 4947, 4936
7416, 2305, 2316, 4947, 4936, 2306, 2317, 4948, 4937
7417, 2306, 2317, 4948, 4937, 2307, 2318, 4949, 4938
7418, 2307, 2318, 4949, 4938, 2308, 2319, 4950, 4939
7419, 2308, 2319, 4950, 4939, 2309, 2320, 4951, 4940
7420, 2309, 2320, 4951, 4940, 2310, 2321, 4952, 4941
7421, 2310, 2321, 4952, 4941, 2311, 2322, 4953, 4942
7422, 2311, 2322, 4953, 4942, 2312, 2323, 4954, 4943
7423, 2312, 2323, 4954, 4943, 2313, 2324, 4955, 4944
7424, 2313, 2324, 4955, 4944, 2314, 2325, 4956, 4945
7425, 2314, 2325, 4956, 4945, 2315, 2326, 4957, 4946
7426, 2315, 2326, 4957, 4946, 528, 529, 2497, 2496
7427, 453, 454, 2091, 2090, 2316, 2327, 4958, 4947
7428, 2316, 2327, 4958, 4947, 2317, 2328, 4959, 4948
7429, 2317, 2328, 4959, 4948, 2318, 2329, 4960, 4949
7430, 2318, 2329, 4960, 4949, 2319, 2330, 4961, 4950
7431, 2319, 2330, 4961, 4950, 2320, 2331, 4962, 4951
7432, 2320, 2331, 4962, 4951, 2321, 2332, 4963, 4952
7433, 2321, 2332, 4963, 4952, 2322, 2333, 4964, 4953
7434, 2322, 2333, 4964, 4953, 2323, 2334, 4965, 4954
7435, 2323, 2334, 4965, 4954, 2324, 2335, 4966, 4955
7436, 2324, 2335, 4966, 4955, 2325, 2336, 4967, 4956
7437, 2325, 2336, 4967, 4956, 2326, 2337, 4968, 4957
7438, 2326, 2337, 4968, 4957, 529, 530, 2498, 2497
7439, 454, 455, 2092, 2091, 2327, 2338, 4969, 4958
7440, 2327, 2338, 4969, 4958, 2328, 2339, 4970, 4959
7441, 2328, 2339, 4970, 4959, 2329, 2340, 4971, 4960
7442, 2329, 2340, 4971, 4960, 2330, 2341, 4972, 4961
7443, 2330, 2341, 4972, 4961, 2331, 2342, 4973, 4962
7444, 2331, 2342, 4973, 4962, 2332, 2343, 4974, 4963
7445, 2332, 2343, 4974, 4963, 2333, 2344, 4975, 4964
7446, 2333, 2344, 4975, 4964, 2334, 2345, 4976, 4965
7447, 2334, 2345, 4976, 4965, 2335, 2346, 4977, 4966
7448, 2335, 2346, 4977, 4966, 2336, 2347, 4978, 4967
7449, 2336, 2347, 4978, 4967, 2337, 2348, 4979, 4968
7450, 2337, 2348, 4979, 4968, 530, 531, 2499, 2498
7451, 455, 456, 2093, 2092, 2338, 2349, 4980, 4969
7452, 2338, 2349, 4980, 4969, 2339, 2350, 4981, 4970
7453, 2339, 2350, 4981, 4970, 2340, 2351, 4982, 4971
7454, 2340, 2351, 4982, 4971, 2341, 2352, 4983, 4972
7455, 2341, 2352, 4983, 4972, 2342, 2353, 4984, 4973
7456, 2342, 2353, 4984, 4973, 2343, 2354, 4985, 4974
7457, 2343, 2354, 4985, 4974, 2344, 2355, 4986, 4975
7458, 2344, 2355, 4986, 4975, 2345, 2356, 4987, 4976
7459, 2345, 2356, 4987, 4976, 2346, 2357, 4988, 4977
7460, 2346, 2357, 4988, 4977, 2347, 2358, 4989, 4978
7461, 2347, 2358, 4989, 4978, 2348, 2359, 4990, 4979
7462, 2348, 2359, 4990, 4979, 531, 532, 2500, 2499
7463, 456, 457, 2094, 2093, 2349, 2360, 4991, 4980
7464, 2349, 2360, 4991, 4980, 2350, 2361, 4992, 4981
7465, 2350, 2361, 4992, 4981, 2351, 2362, 4993, 4982
7466, 2351, 2362, 4993, 4982, 2352, 2363, 4994, 4983
7467, 2352, 2363, 4994, 4983, 2353, 2364, 4995, 4984
7468, 2353, 2364, 4995, 4984, 2354, 2365, 4996, 4985
7469, 2354, 2365, 4996, 4985, 2355, 2366, 4997, 4986
7470, 2355, 2366, 4997, 4986, 2356, 2367, 4998, 4987
7471, 2356, 2367, 4998, 4987, 2357, 2368, 4999, 4988
7472, 2357, 2368, 4999, 4988, 2358, 2369, 5000, 4989
7473, 2358, 2369, 5000, 4989, 2359, 2370, 5001, 4990
7474, 2359, 2370, 5001, 4990, 532, 533, 2501, 2500
7475, 457, 458, 2095, 2094, 2360, 2371, 5002, 4991
7476, 2360, 2371, 5002, 4991, 2361, 2372, 5003, 4992
7477, 2361, 2372, 5003, 4992, 2362, 2373, 5004, 4993
7478, 2362, 2373, 5004, 4993, 2363, 2374, 5005, 4994
7479, 2363, 2374, 5005, 4994, 2364, 2375, 5006, 4995
7480, 2364, 2375, 5006, 4995, 2365, 2376, 5007, 4996
7481, 2365, 2376, 5007, 4996, 2366, 2377, 5008, 4997
7482, 2366, 2377, 5008, 4997, 2367, 2378, 5009, 4998
7483, 2367, 2378, 5009, 4998, 2368, 2379, 5010, 4999
7484, 2368, 2379, 5010, 4999, 2369, 2380, 5011, 5000
7485, 2369, 2380, 5011, 5000, 2370, 2381, 5012, 5001
7486, 2370, 2381, 5012, 5001, 533, 534, 2502, 2501
7487, 458, 36, 464, 2095, 2371, 513, 2437, 5002
7488, 2371, 513, 2437, 5002, 2372, 514, 2438, 5003
7489, 2372, 514, 2438, 5003, 2373, 515, 2439, 5004
7490, 2373, 515, 2439, 5004, 2374, 516, 2440, 5005
7491, 2374, 516, 2440, 5005, 2375, 517, 2441, 5006
7492, 2375, 517, 2441, 5006, 2376, 518, 2442, 5007
7493, 2376, 518, 2442, 5007, 2377, 519, 2443, 5008
7494, 2377, 519, 2443, 5008, 2378, 520, 2444, 5009
7495, 2378, 520, 2444, 5009, 2379, 521, 2445, 5010
7496, 2379, 521, 2445, 5010, 2380, 522, 2446, 5011
7497, 2380, 522, 2446, 5011, 2381, 523, 2447, 5012
7498, 2381, 523, 2447, 5012, 534, 40, 540, 2502
7499, 459, 2085, 2096, 460, 2382, 4892, 5013, 2393
7500, 2382, 4892, 5013, 2393, 2383, 4893, 5014, 2394
7501, 2383, 4893, 5014, 2394, 2384, 4894, 5015, 2395
7502, 2384, 4894, 5015, 2395, 2385, 4895, 5016, 2396
7503, 2385, 4895, 5016, 2396, 2386, 4896, 5017, 2397
7504, 2386, 4896, 5017, 2397, 2387, 4897, 5018, 2398
7505, 2387, 4897, 5018, 2398, 2388, 4898, 5019, 2399
7506, 2388, 4898, 5019, 2399, 2389, 4899, 5020, 2400
7507, 2389, 4899, 5020, 2400, 2390, 4900, 5021, 2401
7508, 2390, 4900, 5021, 2401, 2391, 4901, 5022, 2402
7509, 2391, 4901, 5022, 2402, 2392, 4902, 5023, 2403
7510, 2392, 4902, 5023, 2403, 535, 2492, 2503, 536
7511, 2085, 2086, 2097, 2096, 4892, 4903, 5024, 5013
7512, 4892, 4903, 5024, 5013, 4893, 4904, 5025, 5014
7513, 4893, 4904, 5025, 5014, 4894, 4905, 5026, 5015
7514, 4894, 4905, 5026, 5015, 4895, 4906, 5027, 5016
7515, 4895, 4906, 5027, 5016, 4896, 4907, 5028, 5017
7516, 4896, 4907, 5028, 5017, 4897, 4908, 5029, 5018
7517, 4897, 4908, 5029, 5018, 4898, 4909, 5030, 5019
7518, 4898, 4909, 5030, 5019, 4899, 4910, 5031, 5020
7519, 4899, 4910, 5031, 5020, 4900, 4911, 5032, 5021
7520, 4900, 4911, 5032, 5021, 4901, 4912, 5033, 5022
7521, 4901, 4912, 5033, 5022, 4902, 4913, 5034, 5023
7522, 4902, 4913, 5034, 5023, 2492, 2493, 2504, 2503
7523, 2086, 2087, 2098, 2097, 4903, 4914, 5035, 5024
7524, 4903, 4914, 5035, 5024, 4904, 4915, 5036, 5025
7525, 4904, 4915, 5036, 5025, 4905, 4916, 5037, 5026
7526, 4905, 4916, 5037, 5026, 4906, 4917, 5038, 5027
7527, 4906, 4917, 5038, 5027, 4907, 4918, 5039, 5028
7528, 4907, 4918, 5039, 5028, 4908, 4919, 5040, 5029
7529, 4908, 4919, 5040, 5029, 4909, 4920, 5041, 5030
7530, 4909, 4920, 5041, 5030, 4910, 4921, 5042, 5031
7531, 4910, 4921, 5042, 5031, 4911, 4922, 5043, 5032
7532, 4911, 4922, 5043, 5032, 4912, 4923, 5044, 5033
7533, 4912, 4923, 5044, 5033, 4913, 4924, 5045, 5034
7534, 4913, 4924, 5045, 5034, 2493, 2494, 2505, 2504
7535, 2087, 2088, 2099, 2098, 4914, 4925, 5046, 5035
7536, 4914, 4925, 5046, 5035, 4915, 4926, 5047, 5036
7537, 4915, 4926, 5047, 5036, 4916, 4927, 5048, 5037
7538, 4916, 4927, 5048, 5037, 4917, 4928, 5049, 5038
7539, 4917, 4928, 5049, 5038, 4918, 4929, 5050, 5039
7540, 4918, 4929, 5050, 5039, 4919, 4930, 5051, 5040
7541, 4919, 4930, 5051, 5040, 4920, 4931, 5052, 5041
7542, 4920, 4931, 5052, 5041, 4921, 4932, 5053, 5042
7543, 4921, 4932, 5053, 5042, 4922, 4933, 5054, 5043
7544, 4922, 4933, 5054, 5043, 4923, 4934, 5055, 5044
7545, 4923, 4934, 5055, 5044, 4924, 4935, 5056, 5045
7546, 4924, 4935, 5056, 5045, 2494, 2495, 2506, 2505
7547, 2088, 2089, 2100, 2099, 4925, 4936, 5057, 5046
7548, 4925, 4936, 5057, 5046, 4926, 4937, 5058, 5047
7549, 4926, 4937, 5058, 5047, 4927, 4938, 5059, 5048
7550, 4927, 4938, 5059, 5048, 4928, 4939, 5060, 5049
7551, 4928, 4939, 5060, 5049, 4929, 4940, 5061, 5050
7552, 4929, 4940, 5061, 5050, 4930, 4941, 5062, 5051
7553, 4930, 4941, 5062, 5051, 4931, 4942, 5063, 5052
7554, 4931, 4942, 5063, 5052, 4932, 4943, 5064, 5053
7555, 4932, 4943, 5064, 5053, 4933, 4944, 5065, 5054
7556, 4933, 4944, 5065, 5054, 4934, 4945, 5066, 5055
7557, 4934, 4945, 5066, 5055, 4935, 4946, 5067, 5056
7558, 4935, 4946, 5067, 5056, 2495, 2496, 2507, 2506
7559, 2089, 2090, 2101, 2100, 4936, 4947, 5068, 5057
7560, 4936, 4947, 5068, 5057, 4937, 4948, 5069, 5058
7561, 4937, 4948, 5069, 5058, 4938, 4949, 5070, 5059
7562, 4938, 4949, 5070, 5059, 4939, 4950, 5071, 5060
7563, 4939, 4950, 5071, 5060, 4940, 4951, 5072, 5061
7564, 4940, 4951, 5072, 5061, 4941, 4952, 5073, 5062
7565, 4941, 4952, 5073, 5062, 4942, 4953, 5074, 5063
7566, 4942, 4953, 5074, 5063, 4943, 4954, 5075, 5064
7567, 4943, 4954, 5075, 5064, 4944, 4955, 5076, 5065
7568, 4944, 4955, 5076, 5065, 4945, 4956, 5077, 5066
7569, 4945, 4956, 5077, 5066, 4946, 4957, 5078, 5067
7570, 4946, 4957, 5078, 5067, 2496, 2497, 2508, 2507
7571, 2090, 2091, 2102, 2101, 4947, 4958, 5079, 5068
7572, 4947, 4958, 5079, 5068, 4948, 4959, 5080, 5069
7573, 4948, 4959, 5080, 5069, 4949, 4960, 5081, 5070
7574, 4949, 4960, 5081, 5070, 4950, 4961, 5082, 5071
7575, 4950, 4961, 5082, 5071, 4951, 4962, 5083, 5072
7576, 4951, 4962, 5083, 5072, 4952, 4963, 5084, 5073
7577, 4952, 4963, 5084, 5073, 4953, 4964, 5085, 5074
7578, 4953, 4964, 5085, 5074, 4954, 4965, 5086, 5075
7579, 4954, 4965, 5086, 5075, 4955, 4966, 5087, 5076
7580, 4955, 4966, 5087, 5076, 4956, 4967, 5088, 5077
7581, 4956, 4967, 5088, 5077, 4957, 4968, 5089, 5078
7582, 4957, 4968, 5089, 5078, 2497, 2498, 2509, 2508
7583, 2091, 2092, 2103, 2102, 4958, 4969, 5090, 5079
7584, 4958, 4969, 5090, 5079, 4959, 4970, 5091, 5080
7585, 4959, 4970, 5091, 5080, 4960, 4971, 5092, 5081
7586, 4960, 4971, 5092, 5081, 4961, 4972, 5093, 5082
7587, 4961, 4972, 5093, 5082, 4962, 4973, 5094, 5083
7588, 4962, 4973, 5094, 5083, 4963, 4974, 5095, 5084
7589, 4963, 4974, 5095, 5084, 4964, 4975, 5096, 5085
7590, 4964, 4975, 5096, 5085, 4965, 4976, 5097, 5086
7591, 4965, 4976, 5097, 5086, 4966, 4977, 5098, 5087
7592, 4966, 4977, 5098, 5087, 4967, 4978, 5099, 5088
7593, 4967, 4978, 5099, 5088, 4968, 4979, 5100, 5089
7594, 4968, 4979, 5100, 5089, 2498, 2499, 2510, 2509
7595, 2092, 2093, 2104, 2103, 4969, 4980, 5101, 5090
7596, 4969, 4980, 5101, 5090, 4970, 4981, 5102, 5091
7597, 4970, 4981, 5102, 5091, 4971, 4982, 5103, 5092
7598, 4971, 4982, 5103, 5092, 4972, 4983, 5104, 5093
7599, 4972, 4983, 5104, 5093, 4973, 4984, 5105, 5094
7600, 4973, 4984, 5105, 5094, 4974, 4985, 5106, 5095
7601, 4974, 4985, 5106, 5095, 4975, 4986, 5107, 5096
7602, 4975, 4986, 5107, 5096, 4976, 4987, 5108, 5097
7603, 4976, 4987, 5108, 5097, 4977, 4988, 5109, 5098
7604, 4977, 4988, 5109, 5098, 4978, 4989, 5110, 5099
7605, 4978, 4989, 5110, 5099, 4979, 4990, 5111, 5100
7606, 4979, 4990, 5111, 5100, 2499, 2500, 2511, 2510
7607, 2093, 2094, 2105, 2104, 4980, 4991, 5112, 5101
7608, 4980, 4991, 5112, 5101, 4981, 4992, 5113, 5102
7609, 4981, 4992, 5113, 5102, 4982, 4993, 5114, 5103
7610, 4982, 4993, 5114, 5103, 4983, 4994, 5115, 5104
7611, 4983, 4994, 5115, 5104, 4984, 4995, 5116, 5105
7612, 4984, 4995, 5116, 5105, 4985, 4996, 5117, 5106
7613, 4985, 4996, 5117, 5106, 4986, 4997, 5118, 5107
7614, 4986, 4997, 5118, 5107, 4987, 4998, 5119, 5108
7615, 4987, 4998, 5119, 5108, 4988, 4999, 5120, 5109
7616, 4988, 4999, 5120, 5109, 4989, 5000, 5121, 5110
7617, 4989, 5000, 5121, 5110, 4990, 5001, 5122, 5111
7618, 4990, 5001, 5122, 5111, 2500, 2501, 2512, 2511
7619, 2094, 2095, 2106, 2105, 4991, 5002, 5123, 5112
7620, 4991, 5002, 5123, 5112, 4992, 5003, 5124, 5113
7621, 4992, 5003, 5124, 5113, 4993, 5004, 5125, 5114
7622, 4993, 5004, 5125, 5114, 4994, 5005, 5126, 5115
7623, 4994, 5005, 5126, 5115, 4995, 5006, 5127, 5116
7624, 4995, 5006, 5127, 5116, 4996, 5007, 5128, 5117
7625, 4996, 5007, 5128, 5117, 4997, 5008, 5129, 5118
7626, 4997, 5008, 5129, 5118, 4998, 5009, 5130, 5119
7627, 4998, 5009, 5130, 5119, 4999, 5010, 5131, 5120
7628, 4999, 5010, 5131, 5120, 5000, 5011, 5132, 5121
7629, 5000, 5011, 5132, 5121, 5001, 5012, 5133, 5122
7630, 5001, 5012, 5133, 5122, 2501, 2502, 2513, 2512
7631, 2095, 464, 465, 2106, 5002, 2437, 2448, 5123
7632, 5002, 2437, 2448, 5123, 5003, 2438, 2449, 5124
7633, 5003, 2438, 2449, 5124, 5004, 2439, 2450, 5125
7634, 5004, 2439, 2450, 5125, 5005, 2440, 2451, 5126
7635, 5005, 2440, 2451, 5126, 5006, 2441, 2452, 5127
7636, 5006, 2441, 2452, 5127, 5007, 2442, 2453, 5128
7637, 5007, 2442, 2453, 5128, 5008, 2443, 2454, 5129
7638, 5008, 2443, 2454, 5129, 5009, 2444, 2455, 5130
7639, 5009, 2444, 2455, 5130, 5010, 2445, 2456, 5131
7640, 5010, 2445, 2456, 5131, 5011, 2446, 2457, 5132
7641, 5011, 2446, 2457, 5132, 5012, 2447, 2458, 5133
7642, 5012, 2447, 2458, 5133, 2502, 540, 541, 2513
7643, 460, 2096, 2107, 461, 2393, 5013, 5134, 2404
7644, 2393, 5013, 5134, 2404, 2394, 5014, 5135, 2405
7645, 2394, 5014, 5135, 2405, 2395, 5015, 5136, 2406
7646, 2395, 5015, 5136, 2406, 2396, 5016, 5137, 2407
7647, 2396, 5016, 5137, 2407, 2397, 5017, 5138, 2408
7648, 2397, 5017, 5138, 2408, 2398, 5018, 5139, 2409
7649, 2398, 5018, 5139, 2409, 2399, 5019, 5140, 2410
7650, 2399, 5019, 5140, 2410, 2400, 5020, 5141, 2411
7651, 2400, 5020, 5141, 2411, 2401, 5021, 5142, 2412
7652, 2401, 5021, 5142, 2412, 2402, 5022, 5143, 2413
7653, 2402, 5022, 5143, 2413, 2403, 5023, 5144, 2414
7654, 2403, 5023, 5144, 2414, 536, 2503, 2514, 537
7655, 2096, 2097, 2108, 2107, 5013, 5024, 5145, 5134
7656, 5013, 5024, 5145, 5134, 5014, 5025, 5146, 5135
7657, 5014, 5025, 5146, 5135, 5015, 5026, 5147, 5136
7658, 5015, 5026, 5147, 5136, 5016, 5027, 5148, 5137
7659, 5016, 5027, 5148, 5137, 5017, 5028, 5149, 5138
7660, 5017, 5028, 5149, 5138, 5018, 5029, 5150, 5139
7661, 5018, 5029, 5150, 5139, 5019, 5030, 5151, 5140
7662, 5019, 5030, 5151, 5140, 5020, 5031, 5152, 5141
7663, 5020, 5031, 5152, 5141, 5021, 5032, 5153, 5142
7664, 5021, 5032, 5153, 5142, 5022, 5033, 5154, 5143
7665, 5022, 5033, 5154, 5143, 5023, 5034, 5155, 5144
7666, 5023, 5034, 5155, 5144, 2503, 2504, 2515, 2514
7667, 2097, 2098, 2109, 2108, 5024, 5035, 5156, 5145
7668, 5024, 5035, 5156, 5145, 5025, 5036, 5157, 5146
7669, 5025, 5036, 5157, 5146, 5026, 5037, 5158, 5147
7670, 5026, 5037, 5158, 5147, 5027, 5038, 5159, 5148
7671, 5027, 5038, 5159, 5148, 5028, 5039, 5160, 5149
7672, 5028, 5039, 5160, 5149, 5029, 5040, 5161, 5150
7673, 5029, 5040, 5161, 5150, 5030, 5041, 5162, 5151
7674, 5030, 5041, 5162, 5151, 5031, 5042, 5163, 5152
7675, 5031, 5042, 5163, 5152, 5032, 5043, 5164, 5153
7676, 5032, 5043, 5164, 5153, 5033, 5044, 5165, 5154
7677, 5033, 5044, 5165, 5154, 5034, 5045, 5166, 5155
7678, 5034, 5045, 5166, 5155, 2504, 2505, 2516, 2515
7679, 2098, 2099, 2110, 2109, 5035, 5046, 5167, 5156
7680, 5035, 5046, 5167, 5156, 5036, 5047, 5168, 5157
7681, 5036, 5047, 5168, 5157, 5037, 5048, 5169, 5158
7682, 5037, 5048, 5169, 5158, 5038, 5049, 5170, 5159
7683, 5038, 5049, 5170, 5159, 5039, 5050, 5171, 5160
7684, 5039, 5050, 5171, 5160, 5040, 5051, 5172, 5161
7685, 5040, 5051, 5172, 5161, 5041, 5052, 5173, 5162
7686, 5041, 5052, 5173, 5162, 5042, 5053, 5174, 5163
7687, 5042, 5053, 5174, 5163, 5043, 5054, 5175, 5164
7688, 5043, 5054, 5175, 5164, 5044, 5055, 5176, 5165
7689, 5044, 5055, 5176, 5165, 5045, 5056, 5177, 5166
7690, 5045, 5056, 5177, 5166, 2505, 2506, 2517, 2516
7691, 2099, 2100, 2111, 2110, 5046, 5057, 5178, 5167
