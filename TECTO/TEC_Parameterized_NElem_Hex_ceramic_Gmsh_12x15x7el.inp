2884, 2178, 2179, 2190, 2189
2885, 2179, 2180, 2191, 2190
2886, 2180, 2181, 2192, 2191
2887, 2181, 2182, 2193, 2192
2888, 2182, 2183, 2194, 2193
2889, 2183, 2184, 2195, 2194
2890, 2184, 2185, 2196, 2195
2891, 2185, 2186, 2197, 2196
2892, 2186, 468, 469, 2197
2893, 463, 2187, 2198, 464
2894, 2187, 2188, 2199, 2198
2895, 2188, 2189, 2200, 2199
2896, 2189, 2190, 2201, 2200
2897, 2190, 2191, 2202, 2201
2898, 2191, 2192, 2203, 2202
2899, 2192, 2193, 2204, 2203
2900, 2193, 2194, 2205, 2204
2901, 2194, 2195, 2206, 2205
2902, 2195, 2196, 2207, 2206
2903, 2196, 2197, 2208, 2207
2904, 2197, 469, 470, 2208
2905, 464, 2198, 437, 33
2906, 2198, 2199, 438, 437
2907, 2199, 2200, 439, 438
2908, 2200, 2201, 440, 439
2909, 2201, 2202, 441, 440
2910, 2202, 2203, 442, 441
2911, 2203, 2204, 443, 442
2912, 2204, 2205, 444, 443
2913, 2205, 2206, 445, 444
2914, 2206, 2207, 446, 445
2915, 2207, 2208, 447, 446
2916, 2208, 470, 34, 447
*ELEMENT, type=CPS4, ELSET=Surface42
2917, 33, 471, 2209, 437
2918, 471, 472, 2210, 2209
2919, 472, 473, 2211, 2210
2920, 473, 474, 2212, 2211
2921, 474, 475, 2213, 2212
2922, 475, 476, 2214, 2213
2923, 476, 477, 2215, 2214
2924, 477, 478, 2216, 2215
2925, 478, 479, 2217, 2216
2926, 479, 480, 2218, 2217
2927, 480, 481, 2219, 2218
2928, 481, 482, 2220, 2219
2929, 482, 483, 2221, 2220
2930, 483, 484, 2222, 2221
2931, 484, 37, 499, 2222
2932, 437, 2209, 2223, 438
2933, 2209, 2210, 2224, 2223
2934, 2210, 2211, 2225, 2224
2935, 2211, 2212, 2226, 2225
2936, 2212, 2213, 2227, 2226
2937, 2213, 2214, 2228, 2227
2938, 2214, 2215, 2229, 2228
2939, 2215, 2216, 2230, 2229
2940, 2216, 2217, 2231, 2230
2941, 2217, 2218, 2232, 2231
2942, 2218, 2219, 2233, 2232
2943, 2219, 2220, 2234, 2233
2944, 2220, 2221, 2235, 2234
2945, 2221, 2222, 2236, 2235
2946, 2222, 499, 500, 2236
2947, 438, 2223, 2237, 439
2948, 2223, 2224, 2238, 2237
2949, 2224, 2225, 2239, 2238
2950, 2225, 2226, 2240, 2239
2951, 2226, 2227, 2241, 2240
2952, 2227, 2228, 2242, 2241
2953, 2228, 2229, 2243, 2242
2954, 2229, 2230, 2244, 2243
2955, 2230, 2231, 2245, 2244
2956, 2231, 2232, 2246, 2245
2957, 2232, 2233, 2247, 2246
2958, 2233, 2234, 2248, 2247
2959, 2234, 2235, 2249, 2248
2960, 2235, 2236, 2250, 2249
2961, 2236, 500, 501, 2250
2962, 439, 2237, 2251, 440
2963, 2237, 2238, 2252, 2251
2964, 2238, 2239, 2253, 2252
2965, 2239, 2240, 2254, 2253
2966, 2240, 2241, 2255, 2254
2967, 2241, 2242, 2256, 2255
2968, 2242, 2243, 2257, 2256
2969, 2243, 2244, 2258, 2257
2970, 2244, 2245, 2259, 2258
2971, 2245, 2246, 2260, 2259
2972, 2246, 2247, 2261, 2260
2973, 2247, 2248, 2262, 2261
2974, 2248, 2249, 2263, 2262
2975, 2249, 2250, 2264, 2263
2976, 2250, 501, 502, 2264
2977, 440, 2251, 2265, 441
2978, 2251, 2252, 2266, 2265
2979, 2252, 2253, 2267, 2266
2980, 2253, 2254, 2268, 2267
2981, 2254, 2255, 2269, 2268
2982, 2255, 2256, 2270, 2269
2983, 2256, 2257, 2271, 2270
2984, 2257, 2258, 2272, 2271
2985, 2258, 2259, 2273, 2272
2986, 2259, 2260, 2274, 2273
2987, 2260, 2261, 2275, 2274
2988, 2261, 2262, 2276, 2275
2989, 2262, 2263, 2277, 2276
2990, 2263, 2264, 2278, 2277
2991, 2264, 502, 503, 2278
2992, 441, 2265, 2279, 442
2993, 2265, 2266, 2280, 2279
2994, 2266, 2267, 2281, 2280
2995, 2267, 2268, 2282, 2281
2996, 2268, 2269, 2283, 2282
2997, 2269, 2270, 2284, 2283
2998, 2270, 2271, 2285, 2284
2999, 2271, 2272, 2286, 2285
3000, 2272, 2273, 2287, 2286
3001, 2273, 2274, 2288, 2287
3002, 2274, 2275, 2289, 2288
3003, 2275, 2276, 2290, 2289
3004, 2276, 2277, 2291, 2290
3005, 2277, 2278, 2292, 2291
3006, 2278, 503, 504, 2292
3007, 442, 2279, 2293, 443
3008, 2279, 2280, 2294, 2293
3009, 2280, 2281, 2295, 2294
3010, 2281, 2282, 2296, 2295
3011, 2282, 2283, 2297, 2296
3012, 2283, 2284, 2298, 2297
3013, 2284, 2285, 2299, 2298
3014, 2285, 2286, 2300, 2299
3015, 2286, 2287, 2301, 2300
3016, 2287, 2288, 2302, 2301
3017, 2288, 2289, 2303, 2302
3018, 2289, 2290, 2304, 2303
3019, 2290, 2291, 2305, 2304
3020, 2291, 2292, 2306, 2305
3021, 2292, 504, 505, 2306
3022, 443, 2293, 2307, 444
3023, 2293, 2294, 2308, 2307
3024, 2294, 2295, 2309, 2308
3025, 2295, 2296, 2310, 2309
3026, 2296, 2297, 2311, 2310
3027, 2297, 2298, 2312, 2311
3028, 2298, 2299, 2313, 2312
3029, 2299, 2300, 2314, 2313
3030, 2300, 2301, 2315, 2314
3031, 2301, 2302, 2316, 2315
3032, 2302, 2303, 2317, 2316
3033, 2303, 2304, 2318, 2317
3034, 2304, 2305, 2319, 2318
3035, 2305, 2306, 2320, 2319
3036, 2306, 505, 506, 2320
3037, 444, 2307, 2321, 445
3038, 2307, 2308, 2322, 2321
3039, 2308, 2309, 2323, 2322
3040, 2309, 2310, 2324, 2323
3041, 2310, 2311, 2325, 2324
3042, 2311, 2312, 2326, 2325
3043, 2312, 2313, 2327, 2326
3044, 2313, 2314, 2328, 2327
3045, 2314, 2315, 2329, 2328
3046, 2315, 2316, 2330, 2329
3047, 2316, 2317, 2331, 2330
3048, 2317, 2318, 2332, 2331
3049, 2318, 2319, 2333, 2332
3050, 2319, 2320, 2334, 2333
3051, 2320, 506, 507, 2334
3052, 445, 2321, 2335, 446
3053, 2321, 2322, 2336, 2335
3054, 2322, 2323, 2337, 2336
3055, 2323, 2324, 2338, 2337
3056, 2324, 2325, 2339, 2338
3057, 2325, 2326, 2340, 2339
3058, 2326, 2327, 2341, 2340
3059, 2327, 2328, 2342, 2341
3060, 2328, 2329, 2343, 2342
3061, 2329, 2330, 2344, 2343
3062, 2330, 2331, 2345, 2344
3063, 2331, 2332, 2346, 2345
3064, 2332, 2333, 2347, 2346
3065, 2333, 2334, 2348, 2347
3066, 2334, 507, 508, 2348
3067, 446, 2335, 2349, 447
3068, 2335, 2336, 2350, 2349
3069, 2336, 2337, 2351, 2350
3070, 2337, 2338, 2352, 2351
3071, 2338, 2339, 2353, 2352
3072, 2339, 2340, 2354, 2353
3073, 2340, 2341, 2355, 2354
3074, 2341, 2342, 2356, 2355
3075, 2342, 2343, 2357, 2356
3076, 2343, 2344, 2358, 2357
3077, 2344, 2345, 2359, 2358
3078, 2345, 2346, 2360, 2359
3079, 2346, 2347, 2361, 2360
3080, 2347, 2348, 2362, 2361
3081, 2348, 508, 509, 2362
3082, 447, 2349, 485, 34
3083, 2349, 2350, 486, 485
3084, 2350, 2351, 487, 486
3085, 2351, 2352, 488, 487
3086, 2352, 2353, 489, 488
3087, 2353, 2354, 490, 489
3088, 2354, 2355, 491, 490
3089, 2355, 2356, 492, 491
3090, 2356, 2357, 493, 492
3091, 2357, 2358, 494, 493
3092, 2358, 2359, 495, 494
3093, 2359, 2360, 496, 495
3094, 2360, 2361, 497, 496
3095, 2361, 2362, 498, 497
3096, 2362, 509, 38, 498
*ELEMENT, type=CPS4, ELSET=Surface43
3097, 35, 448, 2363, 510
3098, 510, 2363, 2364, 511
3099, 511, 2364, 2365, 512
3100, 512, 2365, 2366, 513
3101, 513, 2366, 2367, 514
3102, 514, 2367, 2368, 515
3103, 515, 2368, 2369, 516
3104, 516, 2369, 2370, 517
3105, 517, 2370, 2371, 518
3106, 518, 2371, 2372, 519
3107, 519, 2372, 2373, 520
3108, 520, 2373, 2374, 521
3109, 521, 2374, 2375, 522
3110, 522, 2375, 2376, 523
3111, 523, 2376, 538, 39
3112, 448, 449, 2377, 2363
3113, 2363, 2377, 2378, 2364
3114, 2364, 2378, 2379, 2365
3115, 2365, 2379, 2380, 2366
3116, 2366, 2380, 2381, 2367
3117, 2367, 2381, 2382, 2368
3118, 2368, 2382, 2383, 2369
3119, 2369, 2383, 2384, 2370
3120, 2370, 2384, 2385, 2371
3121, 2371, 2385, 2386, 2372
3122, 2372, 2386, 2387, 2373
3123, 2373, 2387, 2388, 2374
3124, 2374, 2388, 2389, 2375
3125, 2375, 2389, 2390, 2376
3126, 2376, 2390, 539, 538
3127, 449, 450, 2391, 2377
3128, 2377, 2391, 2392, 2378
3129, 2378, 2392, 2393, 2379
3130, 2379, 2393, 2394, 2380
3131, 2380, 2394, 2395, 2381
3132, 2381, 2395, 2396, 2382
3133, 2382, 2396, 2397, 2383
3134, 2383, 2397, 2398, 2384
3135, 2384, 2398, 2399, 2385
3136, 2385, 2399, 2400, 2386
3137, 2386, 2400, 2401, 2387
3138, 2387, 2401, 2402, 2388
3139, 2388, 2402, 2403, 2389
3140, 2389, 2403, 2404, 2390
3141, 2390, 2404, 540, 539
3142, 450, 451, 2405, 2391
3143, 2391, 2405, 2406, 2392
3144, 2392, 2406, 2407, 2393
3145, 2393, 2407, 2408, 2394
3146, 2394, 2408, 2409, 2395
3147, 2395, 2409, 2410, 2396
3148, 2396, 2410, 2411, 2397
3149, 2397, 2411, 2412, 2398
3150, 2398, 2412, 2413, 2399
3151, 2399, 2413, 2414, 2400
3152, 2400, 2414, 2415, 2401
3153, 2401, 2415, 2416, 2402
3154, 2402, 2416, 2417, 2403
3155, 2403, 2417, 2418, 2404
3156, 2404, 2418, 541, 540
3157, 451, 452, 2419, 2405
3158, 2405, 2419, 2420, 2406
3159, 2406, 2420, 2421, 2407
3160, 2407, 2421, 2422, 2408
3161, 2408, 2422, 2423, 2409
3162, 2409, 2423, 2424, 2410
3163, 2410, 2424, 2425, 2411
3164, 2411, 2425, 2426, 2412
3165, 2412, 2426, 2427, 2413
3166, 2413, 2427, 2428, 2414
3167, 2414, 2428, 2429, 2415
3168, 2415, 2429, 2430, 2416
3169, 2416, 2430, 2431, 2417
3170, 2417, 2431, 2432, 2418
3171, 2418, 2432, 542, 541
3172, 452, 453, 2433, 2419
3173, 2419, 2433, 2434, 2420
3174, 2420, 2434, 2435, 2421
3175, 2421, 2435, 2436, 2422
3176, 2422, 2436, 2437, 2423
3177, 2423, 2437, 2438, 2424
3178, 2424, 2438, 2439, 2425
3179, 2425, 2439, 2440, 2426
3180, 2426, 2440, 2441, 2427
3181, 2427, 2441, 2442, 2428
3182, 2428, 2442, 2443, 2429
3183, 2429, 2443, 2444, 2430
3184, 2430, 2444, 2445, 2431
3185, 2431, 2445, 2446, 2432
3186, 2432, 2446, 543, 542
3187, 453, 454, 2447, 2433
3188, 2433, 2447, 2448, 2434
3189, 2434, 2448, 2449, 2435
3190, 2435, 2449, 2450, 2436
3191, 2436, 2450, 2451, 2437
3192, 2437, 2451, 2452, 2438
3193, 2438, 2452, 2453, 2439
3194, 2439, 2453, 2454, 2440
3195, 2440, 2454, 2455, 2441
3196, 2441, 2455, 2456, 2442
3197, 2442, 2456, 2457, 2443
3198, 2443, 2457, 2458, 2444
3199, 2444, 2458, 2459, 2445
3200, 2445, 2459, 2460, 2446
3201, 2446, 2460, 544, 543
3202, 454, 455, 2461, 2447
3203, 2447, 2461, 2462, 2448
3204, 2448, 2462, 2463, 2449
3205, 2449, 2463, 2464, 2450
3206, 2450, 2464, 2465, 2451
3207, 2451, 2465, 2466, 2452
3208, 2452, 2466, 2467, 2453
3209, 2453, 2467, 2468, 2454
3210, 2454, 2468, 2469, 2455
3211, 2455, 2469, 2470, 2456
3212, 2456, 2470, 2471, 2457
3213, 2457, 2471, 2472, 2458
3214, 2458, 2472, 2473, 2459
3215, 2459, 2473, 2474, 2460
3216, 2460, 2474, 545, 544
3217, 455, 456, 2475, 2461
3218, 2461, 2475, 2476, 2462
3219, 2462, 2476, 2477, 2463
3220, 2463, 2477, 2478, 2464
3221, 2464, 2478, 2479, 2465
3222, 2465, 2479, 2480, 2466
3223, 2466, 2480, 2481, 2467
3224, 2467, 2481, 2482, 2468
3225, 2468, 2482, 2483, 2469
3226, 2469, 2483, 2484, 2470
3227, 2470, 2484, 2485, 2471
3228, 2471, 2485, 2486, 2472
3229, 2472, 2486, 2487, 2473
3230, 2473, 2487, 2488, 2474
3231, 2474, 2488, 546, 545
3232, 456, 457, 2489, 2475
3233, 2475, 2489, 2490, 2476
3234, 2476, 2490, 2491, 2477
3235, 2477, 2491, 2492, 2478
3236, 2478, 2492, 2493, 2479
3237, 2479, 2493, 2494, 2480
3238, 2480, 2494, 2495, 2481
3239, 2481, 2495, 2496, 2482
3240, 2482, 2496, 2497, 2483
3241, 2483, 2497, 2498, 2484
3242, 2484, 2498, 2499, 2485
3243, 2485, 2499, 2500, 2486
3244, 2486, 2500, 2501, 2487
3245, 2487, 2501, 2502, 2488
3246, 2488, 2502, 547, 546
3247, 457, 458, 2503, 2489
3248, 2489, 2503, 2504, 2490
3249, 2490, 2504, 2505, 2491
3250, 2491, 2505, 2506, 2492
3251, 2492, 2506, 2507, 2493
3252, 2493, 2507, 2508, 2494
3253, 2494, 2508, 2509, 2495
3254, 2495, 2509, 2510, 2496
3255, 2496, 2510, 2511, 2497
3256, 2497, 2511, 2512, 2498
3257, 2498, 2512, 2513, 2499
3258, 2499, 2513, 2514, 2500
3259, 2500, 2514, 2515, 2501
3260, 2501, 2515, 2516, 2502
3261, 2502, 2516, 548, 547
3262, 458, 36, 524, 2503
3263, 2503, 524, 525, 2504
3264, 2504, 525, 526, 2505
3265, 2505, 526, 527, 2506
3266, 2506, 527, 528, 2507
3267, 2507, 528, 529, 2508
3268, 2508, 529, 530, 2509
3269, 2509, 530, 531, 2510
3270, 2510, 531, 532, 2511
3271, 2511, 532, 533, 2512
3272, 2512, 533, 534, 2513
3273, 2513, 534, 535, 2514
3274, 2514, 535, 536, 2515
3275, 2515, 536, 537, 2516
3276, 2516, 537, 40, 548
*ELEMENT, type=CPS4, ELSET=Surface44
3277, 35, 510, 2517, 459
3278, 510, 511, 2518, 2517
3279, 511, 512, 2519, 2518
3280, 512, 513, 2520, 2519
3281, 513, 514, 2521, 2520
3282, 514, 515, 2522, 2521
3283, 515, 516, 2523, 2522
3284, 516, 517, 2524, 2523
3285, 517, 518, 2525, 2524
3286, 518, 519, 2526, 2525
3287, 519, 520, 2527, 2526
3288, 520, 521, 2528, 2527
3289, 521, 522, 2529, 2528
3290, 522, 523, 2530, 2529
3291, 523, 39, 549, 2530
3292, 459, 2517, 2531, 460
3293, 2517, 2518, 2532, 2531
3294, 2518, 2519, 2533, 2532
3295, 2519, 2520, 2534, 2533
3296, 2520, 2521, 2535, 2534
3297, 2521, 2522, 2536, 2535
3298, 2522, 2523, 2537, 2536
3299, 2523, 2524, 2538, 2537
3300, 2524, 2525, 2539, 2538
3301, 2525, 2526, 2540, 2539
3302, 2526, 2527, 2541, 2540
3303, 2527, 2528, 2542, 2541
3304, 2528, 2529, 2543, 2542
3305, 2529, 2530, 2544, 2543
3306, 2530, 549, 550, 2544
3307, 460, 2531, 2545, 461
3308, 2531, 2532, 2546, 2545
3309, 2532, 2533, 2547, 2546
3310, 2533, 2534, 2548, 2547
3311, 2534, 2535, 2549, 2548
3312, 2535, 2536, 2550, 2549
3313, 2536, 2537, 2551, 2550
3314, 2537, 2538, 2552, 2551
3315, 2538, 2539, 2553, 2552
3316, 2539, 2540, 2554, 2553
3317, 2540, 2541, 2555, 2554
3318, 2541, 2542, 2556, 2555
3319, 2542, 2543, 2557, 2556
3320, 2543, 2544, 2558, 2557
3321, 2544, 550, 551, 2558
3322, 461, 2545, 2559, 462
3323, 2545, 2546, 2560, 2559
3324, 2546, 2547, 2561, 2560
3325, 2547, 2548, 2562, 2561
3326, 2548, 2549, 2563, 2562
3327, 2549, 2550, 2564, 2563
3328, 2550, 2551, 2565, 2564
3329, 2551, 2552, 2566, 2565
3330, 2552, 2553, 2567, 2566
3331, 2553, 2554, 2568, 2567
3332, 2554, 2555, 2569, 2568
3333, 2555, 2556, 2570, 2569
3334, 2556, 2557, 2571, 2570
3335, 2557, 2558, 2572, 2571
3336, 2558, 551, 552, 2572
3337, 462, 2559, 2573, 463
3338, 2559, 2560, 2574, 2573
3339, 2560, 2561, 2575, 2574
3340, 2561, 2562, 2576, 2575
3341, 2562, 2563, 2577, 2576
3342, 2563, 2564, 2578, 2577
3343, 2564, 2565, 2579, 2578
3344, 2565, 2566, 2580, 2579
3345, 2566, 2567, 2581, 2580
3346, 2567, 2568, 2582, 2581
3347, 2568, 2569, 2583, 2582
3348, 2569, 2570, 2584, 2583
3349, 2570, 2571, 2585, 2584
3350, 2571, 2572, 2586, 2585
3351, 2572, 552, 553, 2586
3352, 463, 2573, 2587, 464
3353, 2573, 2574, 2588, 2587
3354, 2574, 2575, 2589, 2588
3355, 2575, 2576, 2590, 2589
3356, 2576, 2577, 2591, 2590
3357, 2577, 2578, 2592, 2591
3358, 2578, 2579, 2593, 2592
3359, 2579, 2580, 2594, 2593
3360, 2580, 2581, 2595, 2594
3361, 2581, 2582, 2596, 2595
3362, 2582, 2583, 2597, 2596
3363, 2583, 2584, 2598, 2597
3364, 2584, 2585, 2599, 2598
3365, 2585, 2586, 2600, 2599
3366, 2586, 553, 554, 2600
3367, 464, 2587, 471, 33
3368, 2587, 2588, 472, 471
3369, 2588, 2589, 473, 472
3370, 2589, 2590, 474, 473
3371, 2590, 2591, 475, 474
3372, 2591, 2592, 476, 475
3373, 2592, 2593, 477, 476
3374, 2593, 2594, 478, 477
3375, 2594, 2595, 479, 478
3376, 2595, 2596, 480, 479
3377, 2596, 2597, 481, 480
3378, 2597, 2598, 482, 481
3379, 2598, 2599, 483, 482
3380, 2599, 2600, 484, 483
3381, 2600, 554, 37, 484
*ELEMENT, type=CPS4, ELSET=Surface45
3382, 36, 465, 2601, 524
3383, 524, 2601, 2602, 525
3384, 525, 2602, 2603, 526
3385, 526, 2603, 2604, 527
3386, 527, 2604, 2605, 528
3387, 528, 2605, 2606, 529
3388, 529, 2606, 2607, 530
3389, 530, 2607, 2608, 531
3390, 531, 2608, 2609, 532
3391, 532, 2609, 2610, 533
3392, 533, 2610, 2611, 534
3393, 534, 2611, 2612, 535
3394, 535, 2612, 2613, 536
3395, 536, 2613, 2614, 537
3396, 537, 2614, 555, 40
3397, 465, 466, 2615, 2601
3398, 2601, 2615, 2616, 2602
3399, 2602, 2616, 2617, 2603
3400, 2603, 2617, 2618, 2604
3401, 2604, 2618, 2619, 2605
3402, 2605, 2619, 2620, 2606
3403, 2606, 2620, 2621, 2607
3404, 2607, 2621, 2622, 2608
3405, 2608, 2622, 2623, 2609
3406, 2609, 2623, 2624, 2610
3407, 2610, 2624, 2625, 2611
3408, 2611, 2625, 2626, 2612
3409, 2612, 2626, 2627, 2613
3410, 2613, 2627, 2628, 2614
3411, 2614, 2628, 556, 555
3412, 466, 467, 2629, 2615
3413, 2615, 2629, 2630, 2616
3414, 2616, 2630, 2631, 2617
3415, 2617, 2631, 2632, 2618
3416, 2618, 2632, 2633, 2619
3417, 2619, 2633, 2634, 2620
3418, 2620, 2634, 2635, 2621
3419, 2621, 2635, 2636, 2622
3420, 2622, 2636, 2637, 2623
3421, 2623, 2637, 2638, 2624
3422, 2624, 2638, 2639, 2625
3423, 2625, 2639, 2640, 2626
3424, 2626, 2640, 2641, 2627
3425, 2627, 2641, 2642, 2628
3426, 2628, 2642, 557, 556
3427, 467, 468, 2643, 2629
3428, 2629, 2643, 2644, 2630
3429, 2630, 2644, 2645, 2631
3430, 2631, 2645, 2646, 2632
3431, 2632, 2646, 2647, 2633
3432, 2633, 2647, 2648, 2634
3433, 2634, 2648, 2649, 2635
3434, 2635, 2649, 2650, 2636
3435, 2636, 2650, 2651, 2637
3436, 2637, 2651, 2652, 2638
3437, 2638, 2652, 2653, 2639
3438, 2639, 2653, 2654, 2640
3439, 2640, 2654, 2655, 2641
3440, 2641, 2655, 2656, 2642
3441, 2642, 2656, 558, 557
3442, 468, 469, 2657, 2643
3443, 2643, 2657, 2658, 2644
3444, 2644, 2658, 2659, 2645
3445, 2645, 2659, 2660, 2646
3446, 2646, 2660, 2661, 2647
3447, 2647, 2661, 2662, 2648
3448, 2648, 2662, 2663, 2649
3449, 2649, 2663, 2664, 2650
3450, 2650, 2664, 2665, 2651
3451, 2651, 2665, 2666, 2652
3452, 2652, 2666, 2667, 2653
3453, 2653, 2667, 2668, 2654
3454, 2654, 2668, 2669, 2655
3455, 2655, 2669, 2670, 2656
3456, 2656, 2670, 559, 558
3457, 469, 470, 2671, 2657
3458, 2657, 2671, 2672, 2658
3459, 2658, 2672, 2673, 2659
3460, 2659, 2673, 2674, 2660
3461, 2660, 2674, 2675, 2661
3462, 2661, 2675, 2676, 2662
3463, 2662, 2676, 2677, 2663
3464, 2663, 2677, 2678, 2664
3465, 2664, 2678, 2679, 2665
3466, 2665, 2679, 2680, 2666
3467, 2666, 2680, 2681, 2667
3468, 2667, 2681, 2682, 2668
3469, 2668, 2682, 2683, 2669
3470, 2669, 2683, 2684, 2670
3471, 2670, 2684, 560, 559
3472, 470, 34, 485, 2671
3473, 2671, 485, 486, 2672
3474, 2672, 486, 487, 2673
3475, 2673, 487, 488, 2674
3476, 2674, 488, 489, 2675
3477, 2675, 489, 490, 2676
3478, 2676, 490, 491, 2677
3479, 2677, 491, 492, 2678
3480, 2678, 492, 493, 2679
3481, 2679, 493, 494, 2680
3482, 2680, 494, 495, 2681
3483, 2681, 495, 496, 2682
3484, 2682, 496, 497, 2683
3485, 2683, 497, 498, 2684
3486, 2684, 498, 38, 560
*ELEMENT, type=CPS4, ELSET=Surface46
3487, 39, 538, 2685, 549
3488, 538, 539, 2686, 2685
3489, 539, 540, 2687, 2686
3490, 540, 541, 2688, 2687
3491, 541, 542, 2689, 2688
3492, 542, 543, 2690, 2689
3493, 543, 544, 2691, 2690
3494, 544, 545, 2692, 2691
3495, 545, 546, 2693, 2692
3496, 546, 547, 2694, 2693
3497, 547, 548, 2695, 2694
3498, 548, 40, 555, 2695
3499, 549, 2685, 2696, 550
3500, 2685, 2686, 2697, 2696
3501, 2686, 2687, 2698, 2697
3502, 2687, 2688, 2699, 2698
3503, 2688, 2689, 2700, 2699
3504, 2689, 2690, 2701, 2700
3505, 2690, 2691, 2702, 2701
3506, 2691, 2692, 2703, 2702
3507, 2692, 2693, 2704, 2703
3508, 2693, 2694, 2705, 2704
3509, 2694, 2695, 2706, 2705
3510, 2695, 555, 556, 2706
3511, 550, 2696, 2707, 551
3512, 2696, 2697, 2708, 2707
3513, 2697, 2698, 2709, 2708
3514, 2698, 2699, 2710, 2709
3515, 2699, 2700, 2711, 2710
3516, 2700, 2701, 2712, 2711
3517, 2701, 2702, 2713, 2712
3518, 2702, 2703, 2714, 2713
3519, 2703, 2704, 2715, 2714
3520, 2704, 2705, 2716, 2715
3521, 2705, 2706, 2717, 2716
3522, 2706, 556, 557, 2717
3523, 551, 2707, 2718, 552
3524, 2707, 2708, 2719, 2718
3525, 2708, 2709, 2720, 2719
3526, 2709, 2710, 2721, 2720
3527, 2710, 2711, 2722, 2721
3528, 2711, 2712, 2723, 2722
3529, 2712, 2713, 2724, 2723
3530, 2713, 2714, 2725, 2724
3531, 2714, 2715, 2726, 2725
3532, 2715, 2716, 2727, 2726
3533, 2716, 2717, 2728, 2727
3534, 2717, 557, 558, 2728
3535, 552, 2718, 2729, 553
3536, 2718, 2719, 2730, 2729
3537, 2719, 2720, 2731, 2730
3538, 2720, 2721, 2732, 2731
3539, 2721, 2722, 2733, 2732
3540, 2722, 2723, 2734, 2733
3541, 2723, 2724, 2735, 2734
3542, 2724, 2725, 2736, 2735
3543, 2725, 2726, 2737, 2736
3544, 2726, 2727, 2738, 2737
3545, 2727, 2728, 2739, 2738
3546, 2728, 558, 559, 2739
3547, 553, 2729, 2740, 554
3548, 2729, 2730, 2741, 2740
3549, 2730, 2731, 2742, 2741
3550, 2731, 2732, 2743, 2742
3551, 2732, 2733, 2744, 2743
3552, 2733, 2734, 2745, 2744
3553, 2734, 2735, 2746, 2745
3554, 2735, 2736, 2747, 2746
3555, 2736, 2737, 2748, 2747
3556, 2737, 2738, 2749, 2748
3557, 2738, 2739, 2750, 2749
3558, 2739, 559, 560, 2750
3559, 554, 2740, 499, 37
3560, 2740, 2741, 500, 499
3561, 2741, 2742, 501, 500
3562, 2742, 2743, 502, 501
3563, 2743, 2744, 503, 502
3564, 2744, 2745, 504, 503
3565, 2745, 2746, 505, 504
3566, 2746, 2747, 506, 505
3567, 2747, 2748, 507, 506
3568, 2748, 2749, 508, 507
3569, 2749, 2750, 509, 508
3570, 2750, 560, 38, 509
*ELEMENT, type=CPS4, ELSET=Surface47
3571, 37, 41, 561, 499
3572, 499, 561, 562, 500
3573, 500, 562, 563, 501
3574, 501, 563, 564, 502
3575, 502, 564, 565, 503
3576, 503, 565, 566, 504
3577, 504, 566, 567, 505
3578, 505, 567, 568, 506
3579, 506, 568, 569, 507
3580, 507, 569, 570, 508
3581, 508, 570, 571, 509
3582, 509, 571, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
3583, 39, 538, 572, 43
3584, 538, 539, 573, 572
3585, 539, 540, 574, 573
3586, 540, 541, 575, 574
3587, 541, 542, 576, 575
3588, 542, 543, 577, 576
3589, 543, 544, 578, 577
3590, 544, 545, 579, 578
3591, 545, 546, 580, 579
3592, 546, 547, 581, 580
3593, 547, 548, 582, 581
3594, 548, 40, 44, 582
*ELEMENT, type=CPS4, ELSET=Surface49
3595, 39, 43, 583, 549
3596, 549, 583, 584, 550
3597, 550, 584, 585, 551
3598, 551, 585, 586, 552
3599, 552, 586, 587, 553
3600, 553, 587, 588, 554
3601, 554, 588, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
3602, 40, 555, 589, 44
3603, 555, 556, 590, 589
3604, 556, 557, 591, 590
3605, 557, 558, 592, 591
3606, 558, 559, 593, 592
3607, 559, 560, 594, 593
3608, 560, 38, 42, 594
*ELEMENT, type=CPS4, ELSET=Surface51
3609, 43, 572, 2751, 583
3610, 572, 573, 2752, 2751
3611, 573, 574, 2753, 2752
3612, 574, 575, 2754, 2753
3613, 575, 576, 2755, 2754
3614, 576, 577, 2756, 2755
3615, 577, 578, 2757, 2756
3616, 578, 579, 2758, 2757
3617, 579, 580, 2759, 2758
3618, 580, 581, 2760, 2759
3619, 581, 582, 2761, 2760
3620, 582, 44, 589, 2761
3621, 583, 2751, 2762, 584
3622, 2751, 2752, 2763, 2762
3623, 2752, 2753, 2764, 2763
3624, 2753, 2754, 2765, 2764
3625, 2754, 2755, 2766, 2765
3626, 2755, 2756, 2767, 2766
3627, 2756, 2757, 2768, 2767
3628, 2757, 2758, 2769, 2768
3629, 2758, 2759, 2770, 2769
3630, 2759, 2760, 2771, 2770
3631, 2760, 2761, 2772, 2771
3632, 2761, 589, 590, 2772
3633, 584, 2762, 2773, 585
3634, 2762, 2763, 2774, 2773
3635, 2763, 2764, 2775, 2774
3636, 2764, 2765, 2776, 2775
3637, 2765, 2766, 2777, 2776
3638, 2766, 2767, 2778, 2777
3639, 2767, 2768, 2779, 2778
3640, 2768, 2769, 2780, 2779
3641, 2769, 2770, 2781, 2780
3642, 2770, 2771, 2782, 2781
3643, 2771, 2772, 2783, 2782
3644, 2772, 590, 591, 2783
3645, 585, 2773, 2784, 586
3646, 2773, 2774, 2785, 2784
3647, 2774, 2775, 2786, 2785
3648, 2775, 2776, 2787, 2786
3649, 2776, 2777, 2788, 2787
3650, 2777, 2778, 2789, 2788
3651, 2778, 2779, 2790, 2789
3652, 2779, 2780, 2791, 2790
3653, 2780, 2781, 2792, 2791
3654, 2781, 2782, 2793, 2792
3655, 2782, 2783, 2794, 2793
3656, 2783, 591, 592, 2794
3657, 586, 2784, 2795, 587
3658, 2784, 2785, 2796, 2795
3659, 2785, 2786, 2797, 2796
3660, 2786, 2787, 2798, 2797
3661, 2787, 2788, 2799, 2798
3662, 2788, 2789, 2800, 2799
3663, 2789, 2790, 2801, 2800
3664, 2790, 2791, 2802, 2801
3665, 2791, 2792, 2803, 2802
3666, 2792, 2793, 2804, 2803
3667, 2793, 2794, 2805, 2804
3668, 2794, 592, 593, 2805
3669, 587, 2795, 2806, 588
3670, 2795, 2796, 2807, 2806
3671, 2796, 2797, 2808, 2807
3672, 2797, 2798, 2809, 2808
3673, 2798, 2799, 2810, 2809
3674, 2799, 2800, 2811, 2810
3675, 2800, 2801, 2812, 2811
3676, 2801, 2802, 2813, 2812
3677, 2802, 2803, 2814, 2813
3678, 2803, 2804, 2815, 2814
3679, 2804, 2805, 2816, 2815
3680, 2805, 593, 594, 2816
3681, 588, 2806, 561, 41
3682, 2806, 2807, 562, 561
3683, 2807, 2808, 563, 562
3684, 2808, 2809, 564, 563
3685, 2809, 2810, 565, 564
3686, 2810, 2811, 566, 565
3687, 2811, 2812, 567, 566
3688, 2812, 2813, 568, 567
3689, 2813, 2814, 569, 568
3690, 2814, 2815, 570, 569
3691, 2815, 2816, 571, 570
3692, 2816, 594, 42, 571
*ELEMENT, type=CPS4, ELSET=Surface52
3693, 41, 595, 2817, 561
3694, 595, 45, 597, 2817
3695, 561, 2817, 2818, 562
3696, 2817, 597, 598, 2818
3697, 562, 2818, 2819, 563
3698, 2818, 598, 599, 2819
3699, 563, 2819, 2820, 564
3700, 2819, 599, 600, 2820
3701, 564, 2820, 2821, 565
3702, 2820, 600, 601, 2821
3703, 565, 2821, 2822, 566
3704, 2821, 601, 602, 2822
3705, 566, 2822, 2823, 567
3706, 2822, 602, 603, 2823
3707, 567, 2823, 2824, 568
3708, 2823, 603, 604, 2824
3709, 568, 2824, 2825, 569
3710, 2824, 604, 605, 2825
3711, 569, 2825, 2826, 570
3712, 2825, 605, 606, 2826
3713, 570, 2826, 2827, 571
3714, 2826, 606, 607, 2827
3715, 571, 2827, 596, 42
3716, 2827, 607, 46, 596
*ELEMENT, type=CPS4, ELSET=Surface53
3717, 43, 572, 2828, 608
3718, 608, 2828, 610, 47
3719, 572, 573, 2829, 2828
3720, 2828, 2829, 611, 610
3721, 573, 574, 2830, 2829
3722, 2829, 2830, 612, 611
3723, 574, 575, 2831, 2830
3724, 2830, 2831, 613, 612
3725, 575, 576, 2832, 2831
3726, 2831, 2832, 614, 613
3727, 576, 577, 2833, 2832
3728, 2832, 2833, 615, 614
3729, 577, 578, 2834, 2833
3730, 2833, 2834, 616, 615
3731, 578, 579, 2835, 2834
3732, 2834, 2835, 617, 616
3733, 579, 580, 2836, 2835
3734, 2835, 2836, 618, 617
3735, 580, 581, 2837, 2836
3736, 2836, 2837, 619, 618
3737, 581, 582, 2838, 2837
3738, 2837, 2838, 620, 619
3739, 582, 44, 609, 2838
3740, 2838, 609, 48, 620
*ELEMENT, type=CPS4, ELSET=Surface54
3741, 43, 608, 2839, 583
3742, 608, 47, 621, 2839
3743, 583, 2839, 2840, 584
3744, 2839, 621, 622, 2840
3745, 584, 2840, 2841, 585
3746, 2840, 622, 623, 2841
3747, 585, 2841, 2842, 586
3748, 2841, 623, 624, 2842
3749, 586, 2842, 2843, 587
3750, 2842, 624, 625, 2843
3751, 587, 2843, 2844, 588
3752, 2843, 625, 626, 2844
3753, 588, 2844, 595, 41
3754, 2844, 626, 45, 595
*ELEMENT, type=CPS4, ELSET=Surface55
3755, 44, 589, 2845, 609
3756, 609, 2845, 627, 48
3757, 589, 590, 2846, 2845
3758, 2845, 2846, 628, 627
3759, 590, 591, 2847, 2846
3760, 2846, 2847, 629, 628
3761, 591, 592, 2848, 2847
3762, 2847, 2848, 630, 629
3763, 592, 593, 2849, 2848
3764, 2848, 2849, 631, 630
3765, 593, 594, 2850, 2849
3766, 2849, 2850, 632, 631
3767, 594, 42, 596, 2850
3768, 2850, 596, 46, 632
*ELEMENT, type=CPS4, ELSET=Surface56
3769, 47, 610, 2851, 621
3770, 610, 611, 2852, 2851
3771, 611, 612, 2853, 2852
3772, 612, 613, 2854, 2853
3773, 613, 614, 2855, 2854
3774, 614, 615, 2856, 2855
3775, 615, 616, 2857, 2856
3776, 616, 617, 2858, 2857
3777, 617, 618, 2859, 2858
3778, 618, 619, 2860, 2859
3779, 619, 620, 2861, 2860
3780, 620, 48, 627, 2861
3781, 621, 2851, 2862, 622
3782, 2851, 2852, 2863, 2862
3783, 2852, 2853, 2864, 2863
3784, 2853, 2854, 2865, 2864
3785, 2854, 2855, 2866, 2865
3786, 2855, 2856, 2867, 2866
3787, 2856, 2857, 2868, 2867
3788, 2857, 2858, 2869, 2868
3789, 2858, 2859, 2870, 2869
3790, 2859, 2860, 2871, 2870
3791, 2860, 2861, 2872, 2871
3792, 2861, 627, 628, 2872
3793, 622, 2862, 2873, 623
3794, 2862, 2863, 2874, 2873
3795, 2863, 2864, 2875, 2874
3796, 2864, 2865, 2876, 2875
3797, 2865, 2866, 2877, 2876
3798, 2866, 2867, 2878, 2877
3799, 2867, 2868, 2879, 2878
3800, 2868, 2869, 2880, 2879
3801, 2869, 2870, 2881, 2880
3802, 2870, 2871, 2882, 2881
3803, 2871, 2872, 2883, 2882
3804, 2872, 628, 629, 2883
3805, 623, 2873, 2884, 624
3806, 2873, 2874, 2885, 2884
3807, 2874, 2875, 2886, 2885
3808, 2875, 2876, 2887, 2886
3809, 2876, 2877, 2888, 2887
3810, 2877, 2878, 2889, 2888
3811, 2878, 2879, 2890, 2889
3812, 2879, 2880, 2891, 2890
3813, 2880, 2881, 2892, 2891
3814, 2881, 2882, 2893, 2892
3815, 2882, 2883, 2894, 2893
3816, 2883, 629, 630, 2894
3817, 624, 2884, 2895, 625
3818, 2884, 2885, 2896, 2895
3819, 2885, 2886, 2897, 2896
3820, 2886, 2887, 2898, 2897
3821, 2887, 2888, 2899, 2898
3822, 2888, 2889, 2900, 2899
3823, 2889, 2890, 2901, 2900
3824, 2890, 2891, 2902, 2901
3825, 2891, 2892, 2903, 2902
3826, 2892, 2893, 2904, 2903
3827, 2893, 2894, 2905, 2904
3828, 2894, 630, 631, 2905
3829, 625, 2895, 2906, 626
3830, 2895, 2896, 2907, 2906
3831, 2896, 2897, 2908, 2907
3832, 2897, 2898, 2909, 2908
3833, 2898, 2899, 2910, 2909
3834, 2899, 2900, 2911, 2910
3835, 2900, 2901, 2912, 2911
3836, 2901, 2902, 2913, 2912
3837, 2902, 2903, 2914, 2913
3838, 2903, 2904, 2915, 2914
3839, 2904, 2905, 2916, 2915
3840, 2905, 631, 632, 2916
3841, 626, 2906, 597, 45
3842, 2906, 2907, 598, 597
3843, 2907, 2908, 599, 598
3844, 2908, 2909, 600, 599
3845, 2909, 2910, 601, 600
3846, 2910, 2911, 602, 601
3847, 2911, 2912, 603, 602
3848, 2912, 2913, 604, 603
3849, 2913, 2914, 605, 604
3850, 2914, 2915, 606, 605
3851, 2915, 2916, 607, 606
3852, 2916, 632, 46, 607
*ELEMENT, type=CPS4, ELSET=Surface57
3853, 42, 596, 633, 49
3854, 596, 46, 50, 633
*ELEMENT, type=CPS4, ELSET=Surface58
3855, 44, 51, 634, 609
3856, 609, 634, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
3857, 44, 589, 635, 51
3858, 589, 590, 636, 635
3859, 590, 591, 637, 636
3860, 591, 592, 638, 637
3861, 592, 593, 639, 638
3862, 593, 594, 640, 639
3863, 594, 42, 49, 640
*ELEMENT, type=CPS4, ELSET=Surface60
3864, 48, 52, 641, 627
3865, 627, 641, 642, 628
3866, 628, 642, 643, 629
3867, 629, 643, 644, 630
3868, 630, 644, 645, 631
3869, 631, 645, 646, 632
3870, 632, 646, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
3871, 51, 635, 2917, 634
3872, 634, 2917, 641, 52
3873, 635, 636, 2918, 2917
3874, 2917, 2918, 642, 641
3875, 636, 637, 2919, 2918
3876, 2918, 2919, 643, 642
3877, 637, 638, 2920, 2919
3878, 2919, 2920, 644, 643
3879, 638, 639, 2921, 2920
3880, 2920, 2921, 645, 644
3881, 639, 640, 2922, 2921
3882, 2921, 2922, 646, 645
3883, 640, 49, 633, 2922
3884, 2922, 633, 50, 646
*ELEMENT, type=CPS4, ELSET=Surface62
3885, 2, 97, 647, 54
3886, 97, 98, 648, 647
3887, 98, 99, 649, 648
3888, 99, 100, 650, 649
3889, 100, 101, 651, 650
3890, 101, 102, 652, 651
3891, 102, 1, 53, 652
*ELEMENT, type=CPS4, ELSET=Surface63
3892, 1, 103, 653, 53
3893, 103, 3, 55, 653
*ELEMENT, type=CPS4, ELSET=Surface64
3894, 4, 56, 654, 104
3895, 104, 654, 655, 105
3896, 105, 655, 656, 106
3897, 106, 656, 657, 107
3898, 107, 657, 658, 108
3899, 108, 658, 659, 109
3900, 109, 659, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
3901, 2, 54, 660, 110
3902, 110, 660, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
3903, 54, 647, 2923, 660
3904, 660, 2923, 654, 56
3905, 647, 648, 2924, 2923
3906, 2923, 2924, 655, 654
3907, 648, 649, 2925, 2924
3908, 2924, 2925, 656, 655
3909, 649, 650, 2926, 2925
3910, 2925, 2926, 657, 656
3911, 650, 651, 2927, 2926
3912, 2926, 2927, 658, 657
3913, 651, 652, 2928, 2927
3914, 2927, 2928, 659, 658
3915, 652, 53, 653, 2928
3916, 2928, 653, 55, 659
*ELEMENT, type=CPS4, ELSET=Surface77
3917, 11, 57, 661, 242
3918, 242, 661, 662, 243
3919, 243, 662, 663, 244
3920, 244, 663, 664, 245
3921, 245, 664, 665, 246
3922, 246, 665, 666, 247
3923, 247, 666, 667, 248
3924, 248, 667, 668, 249
3925, 249, 668, 669, 250
3926, 250, 669, 670, 251
3927, 251, 670, 671, 252
3928, 252, 671, 672, 253
3929, 253, 672, 673, 254
3930, 254, 673, 674, 255
3931, 255, 674, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
3932, 9, 203, 675, 59
3933, 203, 204, 676, 675
3934, 204, 205, 677, 676
3935, 205, 206, 678, 677
3936, 206, 207, 679, 678
3937, 207, 208, 680, 679
3938, 208, 209, 681, 680
3939, 209, 210, 682, 681
3940, 210, 211, 683, 682
3941, 211, 212, 684, 683
3942, 212, 213, 685, 684
3943, 213, 214, 686, 685
3944, 214, 215, 687, 686
3945, 215, 216, 688, 687
3946, 216, 13, 60, 688
*ELEMENT, type=CPS4, ELSET=Surface79
3947, 9, 59, 689, 180
3948, 180, 689, 690, 181
3949, 181, 690, 691, 182
3950, 182, 691, 692, 183
3951, 183, 692, 693, 184
3952, 184, 693, 694, 185
3953, 185, 694, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
3954, 13, 256, 695, 60
3955, 256, 257, 696, 695
3956, 257, 258, 697, 696
3957, 258, 259, 698, 697
3958, 259, 260, 699, 698
3959, 260, 261, 700, 699
3960, 261, 15, 58, 700
*ELEMENT, type=CPS4, ELSET=Surface81
3961, 59, 675, 2929, 689
3962, 675, 676, 2930, 2929
3963, 676, 677, 2931, 2930
3964, 677, 678, 2932, 2931
3965, 678, 679, 2933, 2932
3966, 679, 680, 2934, 2933
3967, 680, 681, 2935, 2934
3968, 681, 682, 2936, 2935
3969, 682, 683, 2937, 2936
3970, 683, 684, 2938, 2937
3971, 684, 685, 2939, 2938
3972, 685, 686, 2940, 2939
3973, 686, 687, 2941, 2940
3974, 687, 688, 2942, 2941
3975, 688, 60, 695, 2942
3976, 689, 2929, 2943, 690
3977, 2929, 2930, 2944, 2943
3978, 2930, 2931, 2945, 2944
3979, 2931, 2932, 2946, 2945
3980, 2932, 2933, 2947, 2946
3981, 2933, 2934, 2948, 2947
3982, 2934, 2935, 2949, 2948
3983, 2935, 2936, 2950, 2949
3984, 2936, 2937, 2951, 2950
3985, 2937, 2938, 2952, 2951
3986, 2938, 2939, 2953, 2952
3987, 2939, 2940, 2954, 2953
3988, 2940, 2941, 2955, 2954
3989, 2941, 2942, 2956, 2955
3990, 2942, 695, 696, 2956
3991, 690, 2943, 2957, 691
3992, 2943, 2944, 2958, 2957
3993, 2944, 2945, 2959, 2958
3994, 2945, 2946, 2960, 2959
3995, 2946, 2947, 2961, 2960
3996, 2947, 2948, 2962, 2961
3997, 2948, 2949, 2963, 2962
3998, 2949, 2950, 2964, 2963
3999, 2950, 2951, 2965, 2964
4000, 2951, 2952, 2966, 2965
4001, 2952, 2953, 2967, 2966
4002, 2953, 2954, 2968, 2967
4003, 2954, 2955, 2969, 2968
4004, 2955, 2956, 2970, 2969
4005, 2956, 696, 697, 2970
4006, 691, 2957, 2971, 692
4007, 2957, 2958, 2972, 2971
4008, 2958, 2959, 2973, 2972
4009, 2959, 2960, 2974, 2973
4010, 2960, 2961, 2975, 2974
4011, 2961, 2962, 2976, 2975
4012, 2962, 2963, 2977, 2976
4013, 2963, 2964, 2978, 2977
4014, 2964, 2965, 2979, 2978
4015, 2965, 2966, 2980, 2979
4016, 2966, 2967, 2981, 2980
4017, 2967, 2968, 2982, 2981
4018, 2968, 2969, 2983, 2982
4019, 2969, 2970, 2984, 2983
4020, 2970, 697, 698, 2984
4021, 692, 2971, 2985, 693
4022, 2971, 2972, 2986, 2985
4023, 2972, 2973, 2987, 2986
4024, 2973, 2974, 2988, 2987
4025, 2974, 2975, 2989, 2988
4026, 2975, 2976, 2990, 2989
4027, 2976, 2977, 2991, 2990
4028, 2977, 2978, 2992, 2991
4029, 2978, 2979, 2993, 2992
4030, 2979, 2980, 2994, 2993
4031, 2980, 2981, 2995, 2994
4032, 2981, 2982, 2996, 2995
4033, 2982, 2983, 2997, 2996
4034, 2983, 2984, 2998, 2997
4035, 2984, 698, 699, 2998
4036, 693, 2985, 2999, 694
4037, 2985, 2986, 3000, 2999
4038, 2986, 2987, 3001, 3000
4039, 2987, 2988, 3002, 3001
4040, 2988, 2989, 3003, 3002
4041, 2989, 2990, 3004, 3003
4042, 2990, 2991, 3005, 3004
4043, 2991, 2992, 3006, 3005
4044, 2992, 2993, 3007, 3006
4045, 2993, 2994, 3008, 3007
4046, 2994, 2995, 3009, 3008
4047, 2995, 2996, 3010, 3009
4048, 2996, 2997, 3011, 3010
4049, 2997, 2998, 3012, 3011
4050, 2998, 699, 700, 3012
4051, 694, 2999, 661, 57
4052, 2999, 3000, 662, 661
4053, 3000, 3001, 663, 662
4054, 3001, 3002, 664, 663
4055, 3002, 3003, 665, 664
4056, 3003, 3004, 666, 665
4057, 3004, 3005, 667, 666
4058, 3005, 3006, 668, 667
4059, 3006, 3007, 669, 668
4060, 3007, 3008, 670, 669
4061, 3008, 3009, 671, 670
4062, 3009, 3010, 672, 671
4063, 3010, 3011, 673, 672
4064, 3011, 3012, 674, 673
4065, 3012, 700, 58, 674
*ELEMENT, type=CPS4, ELSET=Surface82
4066, 33, 61, 701, 471
4067, 471, 701, 702, 472
4068, 472, 702, 703, 473
4069, 473, 703, 704, 474
4070, 474, 704, 705, 475
4071, 475, 705, 706, 476
4072, 476, 706, 707, 477
4073, 477, 707, 708, 478
4074, 478, 708, 709, 479
4075, 479, 709, 710, 480
4076, 480, 710, 711, 481
4077, 481, 711, 712, 482
4078, 482, 712, 713, 483
4079, 483, 713, 714, 484
4080, 484, 714, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
4081, 35, 510, 715, 63
4082, 510, 511, 716, 715
4083, 511, 512, 717, 716
4084, 512, 513, 718, 717
4085, 513, 514, 719, 718
4086, 514, 515, 720, 719
4087, 515, 516, 721, 720
4088, 516, 517, 722, 721
4089, 517, 518, 723, 722
4090, 518, 519, 724, 723
4091, 519, 520, 725, 724
4092, 520, 521, 726, 725
4093, 521, 522, 727, 726
4094, 522, 523, 728, 727
4095, 523, 39, 64, 728
*ELEMENT, type=CPS4, ELSET=Surface84
4096, 35, 63, 729, 459
4097, 459, 729, 730, 460
4098, 460, 730, 731, 461
4099, 461, 731, 732, 462
4100, 462, 732, 733, 463
4101, 463, 733, 734, 464
4102, 464, 734, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
4103, 39, 549, 735, 64
4104, 549, 550, 736, 735
4105, 550, 551, 737, 736
4106, 551, 552, 738, 737
4107, 552, 553, 739, 738
4108, 553, 554, 740, 739
4109, 554, 37, 62, 740
*ELEMENT, type=CPS4, ELSET=Surface86
4110, 63, 715, 3013, 729
4111, 715, 716, 3014, 3013
4112, 716, 717, 3015, 3014
4113, 717, 718, 3016, 3015
4114, 718, 719, 3017, 3016
4115, 719, 720, 3018, 3017
4116, 720, 721, 3019, 3018
4117, 721, 722, 3020, 3019
4118, 722, 723, 3021, 3020
4119, 723, 724, 3022, 3021
4120, 724, 725, 3023, 3022
4121, 725, 726, 3024, 3023
4122, 726, 727, 3025, 3024
4123, 727, 728, 3026, 3025
4124, 728, 64, 735, 3026
4125, 729, 3013, 3027, 730
4126, 3013, 3014, 3028, 3027
4127, 3014, 3015, 3029, 3028
4128, 3015, 3016, 3030, 3029
4129, 3016, 3017, 3031, 3030
4130, 3017, 3018, 3032, 3031
4131, 3018, 3019, 3033, 3032
4132, 3019, 3020, 3034, 3033
4133, 3020, 3021, 3035, 3034
4134, 3021, 3022, 3036, 3035
4135, 3022, 3023, 3037, 3036
4136, 3023, 3024, 3038, 3037
4137, 3024, 3025, 3039, 3038
4138, 3025, 3026, 3040, 3039
4139, 3026, 735, 736, 3040
4140, 730, 3027, 3041, 731
4141, 3027, 3028, 3042, 3041
4142, 3028, 3029, 3043, 3042
4143, 3029, 3030, 3044, 3043
4144, 3030, 3031, 3045, 3044
4145, 3031, 3032, 3046, 3045
4146, 3032, 3033, 3047, 3046
4147, 3033, 3034, 3048, 3047
4148, 3034, 3035, 3049, 3048
4149, 3035, 3036, 3050, 3049
4150, 3036, 3037, 3051, 3050
4151, 3037, 3038, 3052, 3051
4152, 3038, 3039, 3053, 3052
4153, 3039, 3040, 3054, 3053
4154, 3040, 736, 737, 3054
4155, 731, 3041, 3055, 732
4156, 3041, 3042, 3056, 3055
4157, 3042, 3043, 3057, 3056
4158, 3043, 3044, 3058, 3057
4159, 3044, 3045, 3059, 3058
4160, 3045, 3046, 3060, 3059
4161, 3046, 3047, 3061, 3060
4162, 3047, 3048, 3062, 3061
4163, 3048, 3049, 3063, 3062
4164, 3049, 3050, 3064, 3063
4165, 3050, 3051, 3065, 3064
4166, 3051, 3052, 3066, 3065
4167, 3052, 3053, 3067, 3066
4168, 3053, 3054, 3068, 3067
4169, 3054, 737, 738, 3068
4170, 732, 3055, 3069, 733
4171, 3055, 3056, 3070, 3069
4172, 3056, 3057, 3071, 3070
4173, 3057, 3058, 3072, 3071
4174, 3058, 3059, 3073, 3072
4175, 3059, 3060, 3074, 3073
4176, 3060, 3061, 3075, 3074
4177, 3061, 3062, 3076, 3075
4178, 3062, 3063, 3077, 3076
4179, 3063, 3064, 3078, 3077
4180, 3064, 3065, 3079, 3078
4181, 3065, 3066, 3080, 3079
4182, 3066, 3067, 3081, 3080
4183, 3067, 3068, 3082, 3081
4184, 3068, 738, 739, 3082
4185, 733, 3069, 3083, 734
4186, 3069, 3070, 3084, 3083
4187, 3070, 3071, 3085, 3084
4188, 3071, 3072, 3086, 3085
4189, 3072, 3073, 3087, 3086
4190, 3073, 3074, 3088, 3087
4191, 3074, 3075, 3089, 3088
4192, 3075, 3076, 3090, 3089
4193, 3076, 3077, 3091, 3090
4194, 3077, 3078, 3092, 3091
4195, 3078, 3079, 3093, 3092
4196, 3079, 3080, 3094, 3093
4197, 3080, 3081, 3095, 3094
4198, 3081, 3082, 3096, 3095
4199, 3082, 739, 740, 3096
4200, 734, 3083, 701, 61
4201, 3083, 3084, 702, 701
4202, 3084, 3085, 703, 702
4203, 3085, 3086, 704, 703
4204, 3086, 3087, 705, 704
4205, 3087, 3088, 706, 705
4206, 3088, 3089, 707, 706
4207, 3089, 3090, 708, 707
4208, 3090, 3091, 709, 708
4209, 3091, 3092, 710, 709
4210, 3092, 3093, 711, 710
4211, 3093, 3094, 712, 711
4212, 3094, 3095, 713, 712
4213, 3095, 3096, 714, 713
4214, 3096, 740, 62, 714
*ELEMENT, type=CPS4, ELSET=Surface87
4215, 9, 65, 741, 203
4216, 203, 741, 742, 204
4217, 204, 742, 743, 205
4218, 205, 743, 744, 206
4219, 206, 744, 745, 207
4220, 207, 745, 746, 208
4221, 208, 746, 747, 209
4222, 209, 747, 748, 210
4223, 210, 748, 749, 211
4224, 211, 749, 750, 212
4225, 212, 750, 751, 213
4226, 213, 751, 752, 214
4227, 214, 752, 753, 215
4228, 215, 753, 754, 216
4229, 216, 754, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
4230, 10, 217, 755, 67
4231, 217, 218, 756, 755
4232, 218, 219, 757, 756
4233, 219, 220, 758, 757
4234, 220, 221, 759, 758
4235, 221, 222, 760, 759
4236, 222, 223, 761, 760
4237, 223, 224, 762, 761
4238, 224, 225, 763, 762
4239, 225, 226, 764, 763
4240, 226, 227, 765, 764
4241, 227, 228, 766, 765
4242, 228, 229, 767, 766
4243, 229, 230, 768, 767
4244, 230, 14, 68, 768
*ELEMENT, type=CPS4, ELSET=Surface89
4245, 10, 67, 769, 169
4246, 169, 769, 770, 170
4247, 170, 770, 771, 171
4248, 171, 771, 772, 172
4249, 172, 772, 773, 173
4250, 173, 773, 774, 174
4251, 174, 774, 775, 175
4252, 175, 775, 776, 176
4253, 176, 776, 777, 177
4254, 177, 777, 778, 178
4255, 178, 778, 779, 179
4256, 179, 779, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
4257, 14, 231, 780, 68
4258, 231, 232, 781, 780
4259, 232, 233, 782, 781
4260, 233, 234, 783, 782
4261, 234, 235, 784, 783
4262, 235, 236, 785, 784
4263, 236, 237, 786, 785
4264, 237, 238, 787, 786
4265, 238, 239, 788, 787
4266, 239, 240, 789, 788
4267, 240, 241, 790, 789
4268, 241, 13, 66, 790
*ELEMENT, type=CPS4, ELSET=Surface91
4269, 67, 755, 3097, 769
4270, 755, 756, 3098, 3097
4271, 756, 757, 3099, 3098
4272, 757, 758, 3100, 3099
4273, 758, 759, 3101, 3100
4274, 759, 760, 3102, 3101
4275, 760, 761, 3103, 3102
4276, 761, 762, 3104, 3103
4277, 762, 763, 3105, 3104
4278, 763, 764, 3106, 3105
4279, 764, 765, 3107, 3106
4280, 765, 766, 3108, 3107
4281, 766, 767, 3109, 3108
4282, 767, 768, 3110, 3109
4283, 768, 68, 780, 3110
4284, 769, 3097, 3111, 770
4285, 3097, 3098, 3112, 3111
4286, 3098, 3099, 3113, 3112
4287, 3099, 3100, 3114, 3113
4288, 3100, 3101, 3115, 3114
4289, 3101, 3102, 3116, 3115
4290, 3102, 3103, 3117, 3116
4291, 3103, 3104, 3118, 3117
4292, 3104, 3105, 3119, 3118
4293, 3105, 3106, 3120, 3119
4294, 3106, 3107, 3121, 3120
4295, 3107, 3108, 3122, 3121
4296, 3108, 3109, 3123, 3122
4297, 3109, 3110, 3124, 3123
4298, 3110, 780, 781, 3124
4299, 770, 3111, 3125, 771
4300, 3111, 3112, 3126, 3125
4301, 3112, 3113, 3127, 3126
4302, 3113, 3114, 3128, 3127
4303, 3114, 3115, 3129, 3128
4304, 3115, 3116, 3130, 3129
4305, 3116, 3117, 3131, 3130
4306, 3117, 3118, 3132, 3131
4307, 3118, 3119, 3133, 3132
4308, 3119, 3120, 3134, 3133
4309, 3120, 3121, 3135, 3134
4310, 3121, 3122, 3136, 3135
4311, 3122, 3123, 3137, 3136
4312, 3123, 3124, 3138, 3137
4313, 3124, 781, 782, 3138
4314, 771, 3125, 3139, 772
4315, 3125, 3126, 3140, 3139
4316, 3126, 3127, 3141, 3140
4317, 3127, 3128, 3142, 3141
4318, 3128, 3129, 3143, 3142
4319, 3129, 3130, 3144, 3143
4320, 3130, 3131, 3145, 3144
4321, 3131, 3132, 3146, 3145
4322, 3132, 3133, 3147, 3146
4323, 3133, 3134, 3148, 3147
4324, 3134, 3135, 3149, 3148
4325, 3135, 3136, 3150, 3149
4326, 3136, 3137, 3151, 3150
4327, 3137, 3138, 3152, 3151
4328, 3138, 782, 783, 3152
4329, 772, 3139, 3153, 773
4330, 3139, 3140, 3154, 3153
4331, 3140, 3141, 3155, 3154
4332, 3141, 3142, 3156, 3155
4333, 3142, 3143, 3157, 3156
4334, 3143, 3144, 3158, 3157
4335, 3144, 3145, 3159, 3158
4336, 3145, 3146, 3160, 3159
4337, 3146, 3147, 3161, 3160
4338, 3147, 3148, 3162, 3161
4339, 3148, 3149, 3163, 3162
4340, 3149, 3150, 3164, 3163
4341, 3150, 3151, 3165, 3164
4342, 3151, 3152, 3166, 3165
4343, 3152, 783, 784, 3166
4344, 773, 3153, 3167, 774
4345, 3153, 3154, 3168, 3167
4346, 3154, 3155, 3169, 3168
4347, 3155, 3156, 3170, 3169
4348, 3156, 3157, 3171, 3170
4349, 3157, 3158, 3172, 3171
4350, 3158, 3159, 3173, 3172
4351, 3159, 3160, 3174, 3173
4352, 3160, 3161, 3175, 3174
4353, 3161, 3162, 3176, 3175
4354, 3162, 3163, 3177, 3176
4355, 3163, 3164, 3178, 3177
4356, 3164, 3165, 3179, 3178
4357, 3165, 3166, 3180, 3179
4358, 3166, 784, 785, 3180
4359, 774, 3167, 3181, 775
4360, 3167, 3168, 3182, 3181
4361, 3168, 3169, 3183, 3182
4362, 3169, 3170, 3184, 3183
4363, 3170, 3171, 3185, 3184
4364, 3171, 3172, 3186, 3185
4365, 3172, 3173, 3187, 3186
4366, 3173, 3174, 3188, 3187
4367, 3174, 3175, 3189, 3188
4368, 3175, 3176, 3190, 3189
4369, 3176, 3177, 3191, 3190
4370, 3177, 3178, 3192, 3191
4371, 3178, 3179, 3193, 3192
4372, 3179, 3180, 3194, 3193
4373, 3180, 785, 786, 3194
4374, 775, 3181, 3195, 776
4375, 3181, 3182, 3196, 3195
4376, 3182, 3183, 3197, 3196
4377, 3183, 3184, 3198, 3197
4378, 3184, 3185, 3199, 3198
4379, 3185, 3186, 3200, 3199
4380, 3186, 3187, 3201, 3200
4381, 3187, 3188, 3202, 3201
4382, 3188, 3189, 3203, 3202
4383, 3189, 3190, 3204, 3203
4384, 3190, 3191, 3205, 3204
4385, 3191, 3192, 3206, 3205
4386, 3192, 3193, 3207, 3206
4387, 3193, 3194, 3208, 3207
4388, 3194, 786, 787, 3208
4389, 776, 3195, 3209, 777
4390, 3195, 3196, 3210, 3209
4391, 3196, 3197, 3211, 3210
4392, 3197, 3198, 3212, 3211
4393, 3198, 3199, 3213, 3212
4394, 3199, 3200, 3214, 3213
4395, 3200, 3201, 3215, 3214
4396, 3201, 3202, 3216, 3215
4397, 3202, 3203, 3217, 3216
4398, 3203, 3204, 3218, 3217
4399, 3204, 3205, 3219, 3218
4400, 3205, 3206, 3220, 3219
4401, 3206, 3207, 3221, 3220
4402, 3207, 3208, 3222, 3221
4403, 3208, 787, 788, 3222
4404, 777, 3209, 3223, 778
4405, 3209, 3210, 3224, 3223
4406, 3210, 3211, 3225, 3224
4407, 3211, 3212, 3226, 3225
4408, 3212, 3213, 3227, 3226
4409, 3213, 3214, 3228, 3227
4410, 3214, 3215, 3229, 3228
4411, 3215, 3216, 3230, 3229
4412, 3216, 3217, 3231, 3230
4413, 3217, 3218, 3232, 3231
4414, 3218, 3219, 3233, 3232
4415, 3219, 3220, 3234, 3233
4416, 3220, 3221, 3235, 3234
4417, 3221, 3222, 3236, 3235
4418, 3222, 788, 789, 3236
4419, 778, 3223, 3237, 779
4420, 3223, 3224, 3238, 3237
4421, 3224, 3225, 3239, 3238
4422, 3225, 3226, 3240, 3239
4423, 3226, 3227, 3241, 3240
4424, 3227, 3228, 3242, 3241
4425, 3228, 3229, 3243, 3242
4426, 3229, 3230, 3244, 3243
4427, 3230, 3231, 3245, 3244
4428, 3231, 3232, 3246, 3245
4429, 3232, 3233, 3247, 3246
4430, 3233, 3234, 3248, 3247
4431, 3234, 3235, 3249, 3248
4432, 3235, 3236, 3250, 3249
4433, 3236, 789, 790, 3250
4434, 779, 3237, 741, 65
4435, 3237, 3238, 742, 741
4436, 3238, 3239, 743, 742
4437, 3239, 3240, 744, 743
4438, 3240, 3241, 745, 744
4439, 3241, 3242, 746, 745
4440, 3242, 3243, 747, 746
4441, 3243, 3244, 748, 747
4442, 3244, 3245, 749, 748
4443, 3245, 3246, 750, 749
4444, 3246, 3247, 751, 750
4445, 3247, 3248, 752, 751
4446, 3248, 3249, 753, 752
4447, 3249, 3250, 754, 753
4448, 3250, 790, 66, 754
*ELEMENT, type=CPS4, ELSET=Surface92
4449, 35, 69, 791, 510
4450, 510, 791, 792, 511
4451, 511, 792, 793, 512
4452, 512, 793, 794, 513
4453, 513, 794, 795, 514
4454, 514, 795, 796, 515
4455, 515, 796, 797, 516
4456, 516, 797, 798, 517
4457, 517, 798, 799, 518
4458, 518, 799, 800, 519
4459, 519, 800, 801, 520
4460, 520, 801, 802, 521
4461, 521, 802, 803, 522
4462, 522, 803, 804, 523
4463, 523, 804, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
4464, 36, 524, 805, 71
4465, 524, 525, 806, 805
4466, 525, 526, 807, 806
4467, 526, 527, 808, 807
4468, 527, 528, 809, 808
4469, 528, 529, 810, 809
4470, 529, 530, 811, 810
4471, 530, 531, 812, 811
4472, 531, 532, 813, 812
4473, 532, 533, 814, 813
4474, 533, 534, 815, 814
4475, 534, 535, 816, 815
4476, 535, 536, 817, 816
4477, 536, 537, 818, 817
4478, 537, 40, 72, 818
*ELEMENT, type=CPS4, ELSET=Surface94
4479, 35, 448, 819, 69
4480, 448, 449, 820, 819
4481, 449, 450, 821, 820
4482, 450, 451, 822, 821
4483, 451, 452, 823, 822
4484, 452, 453, 824, 823
4485, 453, 454, 825, 824
4486, 454, 455, 826, 825
4487, 455, 456, 827, 826
4488, 456, 457, 828, 827
4489, 457, 458, 829, 828
4490, 458, 36, 71, 829
*ELEMENT, type=CPS4, ELSET=Surface95
4491, 39, 70, 830, 538
4492, 538, 830, 831, 539
4493, 539, 831, 832, 540
4494, 540, 832, 833, 541
4495, 541, 833, 834, 542
4496, 542, 834, 835, 543
4497, 543, 835, 836, 544
4498, 544, 836, 837, 545
4499, 545, 837, 838, 546
4500, 546, 838, 839, 547
4501, 547, 839, 840, 548
4502, 548, 840, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
4503, 69, 819, 3251, 791
4504, 791, 3251, 3252, 792
4505, 792, 3252, 3253, 793
4506, 793, 3253, 3254, 794
4507, 794, 3254, 3255, 795
4508, 795, 3255, 3256, 796
4509, 796, 3256, 3257, 797
4510, 797, 3257, 3258, 798
4511, 798, 3258, 3259, 799
4512, 799, 3259, 3260, 800
4513, 800, 3260, 3261, 801
4514, 801, 3261, 3262, 802
4515, 802, 3262, 3263, 803
4516, 803, 3263, 3264, 804
4517, 804, 3264, 830, 70
4518, 819, 820, 3265, 3251
4519, 3251, 3265, 3266, 3252
4520, 3252, 3266, 3267, 3253
4521, 3253, 3267, 3268, 3254
4522, 3254, 3268, 3269, 3255
4523, 3255, 3269, 3270, 3256
4524, 3256, 3270, 3271, 3257
4525, 3257, 3271, 3272, 3258
4526, 3258, 3272, 3273, 3259
4527, 3259, 3273, 3274, 3260
4528, 3260, 3274, 3275, 3261
4529, 3261, 3275, 3276, 3262
4530, 3262, 3276, 3277, 3263
4531, 3263, 3277, 3278, 3264
4532, 3264, 3278, 831, 830
4533, 820, 821, 3279, 3265
4534, 3265, 3279, 3280, 3266
4535, 3266, 3280, 3281, 3267
4536, 3267, 3281, 3282, 3268
4537, 3268, 3282, 3283, 3269
4538, 3269, 3283, 3284, 3270
4539, 3270, 3284, 3285, 3271
4540, 3271, 3285, 3286, 3272
4541, 3272, 3286, 3287, 3273
4542, 3273, 3287, 3288, 3274
4543, 3274, 3288, 3289, 3275
4544, 3275, 3289, 3290, 3276
4545, 3276, 3290, 3291, 3277
4546, 3277, 3291, 3292, 3278
4547, 3278, 3292, 832, 831
4548, 821, 822, 3293, 3279
4549, 3279, 3293, 3294, 3280
4550, 3280, 3294, 3295, 3281
4551, 3281, 3295, 3296, 3282
4552, 3282, 3296, 3297, 3283
4553, 3283, 3297, 3298, 3284
4554, 3284, 3298, 3299, 3285
4555, 3285, 3299, 3300, 3286
4556, 3286, 3300, 3301, 3287
4557, 3287, 3301, 3302, 3288
4558, 3288, 3302, 3303, 3289
4559, 3289, 3303, 3304, 3290
4560, 3290, 3304, 3305, 3291
4561, 3291, 3305, 3306, 3292
4562, 3292, 3306, 833, 832
4563, 822, 823, 3307, 3293
4564, 3293, 3307, 3308, 3294
4565, 3294, 3308, 3309, 3295
4566, 3295, 3309, 3310, 3296
4567, 3296, 3310, 3311, 3297
4568, 3297, 3311, 3312, 3298
4569, 3298, 3312, 3313, 3299
4570, 3299, 3313, 3314, 3300
4571, 3300, 3314, 3315, 3301
4572, 3301, 3315, 3316, 3302
4573, 3302, 3316, 3317, 3303
4574, 3303, 3317, 3318, 3304
4575, 3304, 3318, 3319, 3305
4576, 3305, 3319, 3320, 3306
4577, 3306, 3320, 834, 833
4578, 823, 824, 3321, 3307
4579, 3307, 3321, 3322, 3308
4580, 3308, 3322, 3323, 3309
4581, 3309, 3323, 3324, 3310
4582, 3310, 3324, 3325, 3311
4583, 3311, 3325, 3326, 3312
4584, 3312, 3326, 3327, 3313
4585, 3313, 3327, 3328, 3314
4586, 3314, 3328, 3329, 3315
4587, 3315, 3329, 3330, 3316
4588, 3316, 3330, 3331, 3317
4589, 3317, 3331, 3332, 3318
4590, 3318, 3332, 3333, 3319
4591, 3319, 3333, 3334, 3320
4592, 3320, 3334, 835, 834
4593, 824, 825, 3335, 3321
4594, 3321, 3335, 3336, 3322
4595, 3322, 3336, 3337, 3323
4596, 3323, 3337, 3338, 3324
4597, 3324, 3338, 3339, 3325
4598, 3325, 3339, 3340, 3326
4599, 3326, 3340, 3341, 3327
4600, 3327, 3341, 3342, 3328
4601, 3328, 3342, 3343, 3329
4602, 3329, 3343, 3344, 3330
4603, 3330, 3344, 3345, 3331
4604, 3331, 3345, 3346, 3332
4605, 3332, 3346, 3347, 3333
4606, 3333, 3347, 3348, 3334
4607, 3334, 3348, 836, 835
4608, 825, 826, 3349, 3335
4609, 3335, 3349, 3350, 3336
4610, 3336, 3350, 3351, 3337
4611, 3337, 3351, 3352, 3338
4612, 3338, 3352, 3353, 3339
4613, 3339, 3353, 3354, 3340
4614, 3340, 3354, 3355, 3341
4615, 3341, 3355, 3356, 3342
4616, 3342, 3356, 3357, 3343
4617, 3343, 3357, 3358, 3344
4618, 3344, 3358, 3359, 3345
4619, 3345, 3359, 3360, 3346
4620, 3346, 3360, 3361, 3347
4621, 3347, 3361, 3362, 3348
4622, 3348, 3362, 837, 836
4623, 826, 827, 3363, 3349
4624, 3349, 3363, 3364, 3350
4625, 3350, 3364, 3365, 3351
4626, 3351, 3365, 3366, 3352
4627, 3352, 3366, 3367, 3353
4628, 3353, 3367, 3368, 3354
4629, 3354, 3368, 3369, 3355
4630, 3355, 3369, 3370, 3356
4631, 3356, 3370, 3371, 3357
4632, 3357, 3371, 3372, 3358
4633, 3358, 3372, 3373, 3359
4634, 3359, 3373, 3374, 3360
4635, 3360, 3374, 3375, 3361
4636, 3361, 3375, 3376, 3362
4637, 3362, 3376, 838, 837
4638, 827, 828, 3377, 3363
4639, 3363, 3377, 3378, 3364
4640, 3364, 3378, 3379, 3365
4641, 3365, 3379, 3380, 3366
4642, 3366, 3380, 3381, 3367
4643, 3367, 3381, 3382, 3368
4644, 3368, 3382, 3383, 3369
4645, 3369, 3383, 3384, 3370
4646, 3370, 3384, 3385, 3371
4647, 3371, 3385, 3386, 3372
4648, 3372, 3386, 3387, 3373
4649, 3373, 3387, 3388, 3374
4650, 3374, 3388, 3389, 3375
4651, 3375, 3389, 3390, 3376
4652, 3376, 3390, 839, 838
4653, 828, 829, 3391, 3377
4654, 3377, 3391, 3392, 3378
4655, 3378, 3392, 3393, 3379
4656, 3379, 3393, 3394, 3380
4657, 3380, 3394, 3395, 3381
4658, 3381, 3395, 3396, 3382
4659, 3382, 3396, 3397, 3383
4660, 3383, 3397, 3398, 3384
4661, 3384, 3398, 3399, 3385
4662, 3385, 3399, 3400, 3386
4663, 3386, 3400, 3401, 3387
4664, 3387, 3401, 3402, 3388
4665, 3388, 3402, 3403, 3389
4666, 3389, 3403, 3404, 3390
4667, 3390, 3404, 840, 839
4668, 829, 71, 805, 3391
4669, 3391, 805, 806, 3392
4670, 3392, 806, 807, 3393
4671, 3393, 807, 808, 3394
4672, 3394, 808, 809, 3395
4673, 3395, 809, 810, 3396
4674, 3396, 810, 811, 3397
4675, 3397, 811, 812, 3398
4676, 3398, 812, 813, 3399
4677, 3399, 813, 814, 3400
4678, 3400, 814, 815, 3401
4679, 3401, 815, 816, 3402
4680, 3402, 816, 817, 3403
4681, 3403, 817, 818, 3404
4682, 3404, 818, 72, 840
*ELEMENT, type=CPS4, ELSET=Surface97
4683, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
4684, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
4685, 63, 73, 841, 715
4686, 715, 841, 842, 716
4687, 716, 842, 843, 717
4688, 717, 843, 844, 718
4689, 718, 844, 845, 719
4690, 719, 845, 846, 720
4691, 720, 846, 847, 721
4692, 721, 847, 848, 722
4693, 722, 848, 849, 723
4694, 723, 849, 850, 724
4695, 724, 850, 851, 725
4696, 725, 851, 852, 726
4697, 726, 852, 853, 727
4698, 727, 853, 854, 728
4699, 728, 854, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
4700, 69, 791, 841, 73
4701, 791, 792, 842, 841
4702, 792, 793, 843, 842
4703, 793, 794, 844, 843
4704, 794, 795, 845, 844
4705, 795, 796, 846, 845
4706, 796, 797, 847, 846
4707, 797, 798, 848, 847
4708, 798, 799, 849, 848
4709, 799, 800, 850, 849
4710, 800, 801, 851, 850
4711, 801, 802, 852, 851
4712, 802, 803, 853, 852
4713, 803, 804, 854, 853
4714, 804, 70, 74, 854
*ELEMENT, type=CPS4, ELSET=Surface101
4715, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
4716, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
4717, 59, 75, 855, 675
4718, 675, 855, 856, 676
4719, 676, 856, 857, 677
4720, 677, 857, 858, 678
4721, 678, 858, 859, 679
4722, 679, 859, 860, 680
4723, 680, 860, 861, 681
4724, 681, 861, 862, 682
4725, 682, 862, 863, 683
4726, 683, 863, 864, 684
4727, 684, 864, 865, 685
4728, 685, 865, 866, 686
4729, 686, 866, 867, 687
4730, 687, 867, 868, 688
4731, 688, 868, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
4732, 65, 741, 855, 75
4733, 741, 742, 856, 855
4734, 742, 743, 857, 856
4735, 743, 744, 858, 857
4736, 744, 745, 859, 858
4737, 745, 746, 860, 859
4738, 746, 747, 861, 860
4739, 747, 748, 862, 861
4740, 748, 749, 863, 862
4741, 749, 750, 864, 863
4742, 750, 751, 865, 864
4743, 751, 752, 866, 865
4744, 752, 753, 867, 866
4745, 753, 754, 868, 867
4746, 754, 66, 76, 868
*ELEMENT, type=CPS4, ELSET=Surface105
4747, 22, 870, 3405, 329
4748, 870, 78, 871, 3405
4749, 329, 3405, 3406, 330
4750, 3405, 871, 872, 3406
4751, 330, 3406, 3407, 331
4752, 3406, 872, 873, 3407
4753, 331, 3407, 3408, 332
4754, 3407, 873, 874, 3408
4755, 332, 3408, 3409, 333
4756, 3408, 874, 875, 3409
4757, 333, 3409, 3410, 334
4758, 3409, 875, 876, 3410
4759, 334, 3410, 3411, 335
4760, 3410, 876, 877, 3411
4761, 335, 3411, 3412, 336
4762, 3411, 877, 878, 3412
4763, 336, 3412, 3413, 337
4764, 3412, 878, 879, 3413
4765, 337, 3413, 3414, 338
4766, 3413, 879, 880, 3414
4767, 338, 3414, 3415, 339
4768, 3414, 880, 881, 3415
4769, 339, 3415, 869, 21
4770, 3415, 881, 77, 869
*ELEMENT, type=CPS4, ELSET=Surface106
4771, 21, 869, 3416, 341
4772, 869, 77, 883, 3416
4773, 341, 3416, 3417, 342
4774, 3416, 883, 884, 3417
4775, 342, 3417, 3418, 343
4776, 3417, 884, 885, 3418
4777, 343, 3418, 3419, 344
4778, 3418, 885, 886, 3419
4779, 344, 3419, 3420, 345
4780, 3419, 886, 887, 3420
4781, 345, 3420, 3421, 346
4782, 3420, 887, 888, 3421
4783, 346, 3421, 882, 23
4784, 3421, 888, 79, 882
*ELEMENT, type=CPS4, ELSET=Surface107
4785, 24, 348, 3422, 889
4786, 889, 3422, 890, 80
4787, 348, 349, 3423, 3422
4788, 3422, 3423, 891, 890
4789, 349, 350, 3424, 3423
4790, 3423, 3424, 892, 891
4791, 350, 351, 3425, 3424
4792, 3424, 3425, 893, 892
4793, 351, 352, 3426, 3425
4794, 3425, 3426, 894, 893
4795, 352, 353, 3427, 3426
4796, 3426, 3427, 895, 894
4797, 353, 354, 3428, 3427
4798, 3427, 3428, 896, 895
4799, 354, 355, 3429, 3428
4800, 3428, 3429, 897, 896
4801, 355, 356, 3430, 3429
4802, 3429, 3430, 898, 897
4803, 356, 357, 3431, 3430
4804, 3430, 3431, 899, 898
4805, 357, 358, 3432, 3431
4806, 3431, 3432, 900, 899
4807, 358, 23, 882, 3432
4808, 3432, 882, 79, 900
*ELEMENT, type=CPS4, ELSET=Surface108
4809, 22, 359, 3433, 870
4810, 870, 3433, 901, 78
4811, 359, 360, 3434, 3433
4812, 3433, 3434, 902, 901
4813, 360, 361, 3435, 3434
4814, 3434, 3435, 903, 902
4815, 361, 362, 3436, 3435
4816, 3435, 3436, 904, 903
4817, 362, 363, 3437, 3436
4818, 3436, 3437, 905, 904
4819, 363, 364, 3438, 3437
4820, 3437, 3438, 906, 905
4821, 364, 24, 889, 3438
4822, 3438, 889, 80, 906
*ELEMENT, type=CPS4, ELSET=Surface109
4823, 78, 901, 3439, 871
4824, 901, 902, 3440, 3439
4825, 902, 903, 3441, 3440
4826, 903, 904, 3442, 3441
4827, 904, 905, 3443, 3442
4828, 905, 906, 3444, 3443
4829, 906, 80, 890, 3444
4830, 871, 3439, 3445, 872
4831, 3439, 3440, 3446, 3445
4832, 3440, 3441, 3447, 3446
4833, 3441, 3442, 3448, 3447
4834, 3442, 3443, 3449, 3448
4835, 3443, 3444, 3450, 3449
4836, 3444, 890, 891, 3450
4837, 872, 3445, 3451, 873
4838, 3445, 3446, 3452, 3451
4839, 3446, 3447, 3453, 3452
4840, 3447, 3448, 3454, 3453
4841, 3448, 3449, 3455, 3454
4842, 3449, 3450, 3456, 3455
4843, 3450, 891, 892, 3456
4844, 873, 3451, 3457, 874
4845, 3451, 3452, 3458, 3457
4846, 3452, 3453, 3459, 3458
4847, 3453, 3454, 3460, 3459
4848, 3454, 3455, 3461, 3460
4849, 3455, 3456, 3462, 3461
4850, 3456, 892, 893, 3462
4851, 874, 3457, 3463, 875
4852, 3457, 3458, 3464, 3463
4853, 3458, 3459, 3465, 3464
4854, 3459, 3460, 3466, 3465
4855, 3460, 3461, 3467, 3466
4856, 3461, 3462, 3468, 3467
4857, 3462, 893, 894, 3468
4858, 875, 3463, 3469, 876
4859, 3463, 3464, 3470, 3469
4860, 3464, 3465, 3471, 3470
4861, 3465, 3466, 3472, 3471
4862, 3466, 3467, 3473, 3472
4863, 3467, 3468, 3474, 3473
4864, 3468, 894, 895, 3474
4865, 876, 3469, 3475, 877
4866, 3469, 3470, 3476, 3475
4867, 3470, 3471, 3477, 3476
4868, 3471, 3472, 3478, 3477
4869, 3472, 3473, 3479, 3478
4870, 3473, 3474, 3480, 3479
4871, 3474, 895, 896, 3480
4872, 877, 3475, 3481, 878
4873, 3475, 3476, 3482, 3481
4874, 3476, 3477, 3483, 3482
4875, 3477, 3478, 3484, 3483
4876, 3478, 3479, 3485, 3484
4877, 3479, 3480, 3486, 3485
4878, 3480, 896, 897, 3486
4879, 878, 3481, 3487, 879
4880, 3481, 3482, 3488, 3487
4881, 3482, 3483, 3489, 3488
4882, 3483, 3484, 3490, 3489
4883, 3484, 3485, 3491, 3490
4884, 3485, 3486, 3492, 3491
4885, 3486, 897, 898, 3492
4886, 879, 3487, 3493, 880
4887, 3487, 3488, 3494, 3493
4888, 3488, 3489, 3495, 3494
4889, 3489, 3490, 3496, 3495
4890, 3490, 3491, 3497, 3496
4891, 3491, 3492, 3498, 3497
4892, 3492, 898, 899, 3498
4893, 880, 3493, 3499, 881
4894, 3493, 3494, 3500, 3499
4895, 3494, 3495, 3501, 3500
4896, 3495, 3496, 3502, 3501
4897, 3496, 3497, 3503, 3502
4898, 3497, 3498, 3504, 3503
4899, 3498, 899, 900, 3504
4900, 881, 3499, 883, 77
4901, 3499, 3500, 884, 883
4902, 3500, 3501, 885, 884
4903, 3501, 3502, 886, 885
4904, 3502, 3503, 887, 886
4905, 3503, 3504, 888, 887
4906, 3504, 900, 79, 888
*ELEMENT, type=CPS4, ELSET=Surface110
4907, 23, 26, 907, 882
4908, 882, 907, 81, 79
*ELEMENT, type=CPS4, ELSET=Surface111
4909, 21, 869, 908, 28
4910, 869, 77, 82, 908
*ELEMENT, type=CPS4, ELSET=Surface112
4911, 28, 908, 3505, 373
4912, 908, 82, 909, 3505
4913, 373, 3505, 3506, 374
4914, 3505, 909, 910, 3506
4915, 374, 3506, 3507, 375
4916, 3506, 910, 911, 3507
4917, 375, 3507, 3508, 376
4918, 3507, 911, 912, 3508
4919, 376, 3508, 3509, 377
4920, 3508, 912, 913, 3509
4921, 377, 3509, 3510, 378
4922, 3509, 913, 914, 3510
4923, 378, 3510, 907, 26
4924, 3510, 914, 81, 907
*ELEMENT, type=CPS4, ELSET=Surface113
4925, 77, 883, 909, 82
4926, 883, 884, 910, 909
4927, 884, 885, 911, 910
4928, 885, 886, 912, 911
4929, 886, 887, 913, 912
4930, 887, 888, 914, 913
4931, 888, 79, 81, 914
*ELEMENT, type=CPS4, ELSET=Surface114
4932, 26, 390, 3511, 907
4933, 907, 3511, 916, 81
4934, 390, 391, 3512, 3511
4935, 3511, 3512, 917, 916
4936, 391, 392, 3513, 3512
4937, 3512, 3513, 918, 917
4938, 392, 393, 3514, 3513
4939, 3513, 3514, 919, 918
4940, 393, 394, 3515, 3514
4941, 3514, 3515, 920, 919
4942, 394, 395, 3516, 3515
4943, 3515, 3516, 921, 920
4944, 395, 396, 3517, 3516
4945, 3516, 3517, 922, 921
4946, 396, 397, 3518, 3517
4947, 3517, 3518, 923, 922
4948, 397, 398, 3519, 3518
4949, 3518, 3519, 924, 923
4950, 398, 399, 3520, 3519
4951, 3519, 3520, 925, 924
4952, 399, 400, 3521, 3520
4953, 3520, 3521, 926, 925
4954, 400, 30, 915, 3521
4955, 3521, 915, 83, 926
*ELEMENT, type=CPS4, ELSET=Surface115
4956, 28, 908, 3522, 413
4957, 908, 82, 928, 3522
4958, 413, 3522, 3523, 414
4959, 3522, 928, 929, 3523
4960, 414, 3523, 3524, 415
4961, 3523, 929, 930, 3524
4962, 415, 3524, 3525, 416
4963, 3524, 930, 931, 3525
4964, 416, 3525, 3526, 417
4965, 3525, 931, 932, 3526
4966, 417, 3526, 3527, 418
4967, 3526, 932, 933, 3527
4968, 418, 3527, 3528, 419
4969, 3527, 933, 934, 3528
4970, 419, 3528, 3529, 420
4971, 3528, 934, 935, 3529
4972, 420, 3529, 3530, 421
4973, 3529, 935, 936, 3530
4974, 421, 3530, 3531, 422
4975, 3530, 936, 937, 3531
4976, 422, 3531, 3532, 423
4977, 3531, 937, 938, 3532
4978, 423, 3532, 927, 32
4979, 3532, 938, 84, 927
*ELEMENT, type=CPS4, ELSET=Surface116
4980, 32, 927, 3533, 431
4981, 927, 84, 939, 3533
4982, 431, 3533, 3534, 432
4983, 3533, 939, 940, 3534
4984, 432, 3534, 3535, 433
4985, 3534, 940, 941, 3535
4986, 433, 3535, 3536, 434
4987, 3535, 941, 942, 3536
4988, 434, 3536, 3537, 435
4989, 3536, 942, 943, 3537
4990, 435, 3537, 3538, 436
4991, 3537, 943, 944, 3538
4992, 436, 3538, 915, 30
4993, 3538, 944, 83, 915
*ELEMENT, type=CPS4, ELSET=Surface117
4994, 82, 909, 3539, 928
4995, 928, 3539, 3540, 929
4996, 929, 3540, 3541, 930
4997, 930, 3541, 3542, 931
4998, 931, 3542, 3543, 932
4999, 932, 3543, 3544, 933
5000, 933, 3544, 3545, 934
5001, 934, 3545, 3546, 935
5002, 935, 3546, 3547, 936
5003, 936, 3547, 3548, 937
5004, 937, 3548, 3549, 938
5005, 938, 3549, 939, 84
5006, 909, 910, 3550, 3539
5007, 3539, 3550, 3551, 3540
5008, 3540, 3551, 3552, 3541
5009, 3541, 3552, 3553, 3542
5010, 3542, 3553, 3554, 3543
5011, 3543, 3554, 3555, 3544
5012, 3544, 3555, 3556, 3545
5013, 3545, 3556, 3557, 3546
5014, 3546, 3557, 3558, 3547
5015, 3547, 3558, 3559, 3548
5016, 3548, 3559, 3560, 3549
5017, 3549, 3560, 940, 939
5018, 910, 911, 3561, 3550
5019, 3550, 3561, 3562, 3551
5020, 3551, 3562, 3563, 3552
5021, 3552, 3563, 3564, 3553
5022, 3553, 3564, 3565, 3554
5023, 3554, 3565, 3566, 3555
5024, 3555, 3566, 3567, 3556
5025, 3556, 3567, 3568, 3557
5026, 3557, 3568, 3569, 3558
5027, 3558, 3569, 3570, 3559
5028, 3559, 3570, 3571, 3560
5029, 3560, 3571, 941, 940
5030, 911, 912, 3572, 3561
5031, 3561, 3572, 3573, 3562
5032, 3562, 3573, 3574, 3563
5033, 3563, 3574, 3575, 3564
5034, 3564, 3575, 3576, 3565
5035, 3565, 3576, 3577, 3566
5036, 3566, 3577, 3578, 3567
5037, 3567, 3578, 3579, 3568
5038, 3568, 3579, 3580, 3569
5039, 3569, 3580, 3581, 3570
5040, 3570, 3581, 3582, 3571
5041, 3571, 3582, 942, 941
5042, 912, 913, 3583, 3572
5043, 3572, 3583, 3584, 3573
5044, 3573, 3584, 3585, 3574
5045, 3574, 3585, 3586, 3575
5046, 3575, 3586, 3587, 3576
5047, 3576, 3587, 3588, 3577
5048, 3577, 3588, 3589, 3578
5049, 3578, 3589, 3590, 3579
5050, 3579, 3590, 3591, 3580
5051, 3580, 3591, 3592, 3581
5052, 3581, 3592, 3593, 3582
5053, 3582, 3593, 943, 942
5054, 913, 914, 3594, 3583
5055, 3583, 3594, 3595, 3584
5056, 3584, 3595, 3596, 3585
5057, 3585, 3596, 3597, 3586
5058, 3586, 3597, 3598, 3587
5059, 3587, 3598, 3599, 3588
5060, 3588, 3599, 3600, 3589
5061, 3589, 3600, 3601, 3590
5062, 3590, 3601, 3602, 3591
5063, 3591, 3602, 3603, 3592
5064, 3592, 3603, 3604, 3593
5065, 3593, 3604, 944, 943
5066, 914, 81, 916, 3594
5067, 3594, 916, 917, 3595
5068, 3595, 917, 918, 3596
5069, 3596, 918, 919, 3597
5070, 3597, 919, 920, 3598
5071, 3598, 920, 921, 3599
5072, 3599, 921, 922, 3600
5073, 3600, 922, 923, 3601
5074, 3601, 923, 924, 3602
5075, 3602, 924, 925, 3603
5076, 3603, 925, 926, 3604
5077, 3604, 926, 83, 944
*ELEMENT, type=CPS4, ELSET=Surface118
5078, 2, 125, 3605, 946
5079, 946, 3605, 947, 86
5080, 125, 126, 3606, 3605
5081, 3605, 3606, 948, 947
5082, 126, 127, 3607, 3606
5083, 3606, 3607, 949, 948
5084, 127, 128, 3608, 3607
5085, 3607, 3608, 950, 949
5086, 128, 129, 3609, 3608
5087, 3608, 3609, 951, 950
5088, 129, 130, 3610, 3609
5089, 3609, 3610, 952, 951
5090, 130, 131, 3611, 3610
5091, 3610, 3611, 953, 952
5092, 131, 132, 3612, 3611
5093, 3611, 3612, 954, 953
5094, 132, 133, 3613, 3612
5095, 3612, 3613, 955, 954
5096, 133, 134, 3614, 3613
5097, 3613, 3614, 956, 955
5098, 134, 135, 3615, 3614
5099, 3614, 3615, 957, 956
5100, 135, 6, 945, 3615
5101, 3615, 945, 85, 957
*ELEMENT, type=CPS4, ELSET=Surface119
5102, 6, 111, 3616, 945
5103, 945, 3616, 959, 85
5104, 111, 112, 3617, 3616
5105, 3616, 3617, 960, 959
5106, 112, 113, 3618, 3617
5107, 3617, 3618, 961, 960
5108, 113, 114, 3619, 3618
5109, 3618, 3619, 962, 961
5110, 114, 115, 3620, 3619
5111, 3619, 3620, 963, 962
5112, 115, 116, 3621, 3620
5113, 3620, 3621, 964, 963
5114, 116, 5, 958, 3621
5115, 3621, 958, 87, 964
*ELEMENT, type=CPS4, ELSET=Surface120
5116, 1, 965, 3622, 136
5117, 965, 88, 966, 3622
5118, 136, 3622, 3623, 137
5119, 3622, 966, 967, 3623
5120, 137, 3623, 3624, 138
5121, 3623, 967, 968, 3624
5122, 138, 3624, 3625, 139
5123, 3624, 968, 969, 3625
5124, 139, 3625, 3626, 140
5125, 3625, 969, 970, 3626
5126, 140, 3626, 3627, 141
5127, 3626, 970, 971, 3627
5128, 141, 3627, 3628, 142
5129, 3627, 971, 972, 3628
5130, 142, 3628, 3629, 143
5131, 3628, 972, 973, 3629
5132, 143, 3629, 3630, 144
5133, 3629, 973, 974, 3630
5134, 144, 3630, 3631, 145
5135, 3630, 974, 975, 3631
5136, 145, 3631, 3632, 146
5137, 3631, 975, 976, 3632
5138, 146, 3632, 958, 5
5139, 3632, 976, 87, 958
*ELEMENT, type=CPS4, ELSET=Surface121
5140, 2, 946, 3633, 97
5141, 946, 86, 977, 3633
5142, 97, 3633, 3634, 98
5143, 3633, 977, 978, 3634
5144, 98, 3634, 3635, 99
5145, 3634, 978, 979, 3635
5146, 99, 3635, 3636, 100
5147, 3635, 979, 980, 3636
5148, 100, 3636, 3637, 101
5149, 3636, 980, 981, 3637
5150, 101, 3637, 3638, 102
5151, 3637, 981, 982, 3638
5152, 102, 3638, 965, 1
5153, 3638, 982, 88, 965
*ELEMENT, type=CPS4, ELSET=Surface122
5154, 86, 947, 3639, 977
5155, 977, 3639, 3640, 978
5156, 978, 3640, 3641, 979
5157, 979, 3641, 3642, 980
5158, 980, 3642, 3643, 981
5159, 981, 3643, 3644, 982
5160, 982, 3644, 966, 88
5161, 947, 948, 3645, 3639
5162, 3639, 3645, 3646, 3640
5163, 3640, 3646, 3647, 3641
5164, 3641, 3647, 3648, 3642
5165, 3642, 3648, 3649, 3643
5166, 3643, 3649, 3650, 3644
5167, 3644, 3650, 967, 966
5168, 948, 949, 3651, 3645
5169, 3645, 3651, 3652, 3646
5170, 3646, 3652, 3653, 3647
5171, 3647, 3653, 3654, 3648
5172, 3648, 3654, 3655, 3649
5173, 3649, 3655, 3656, 3650
5174, 3650, 3656, 968, 967
5175, 949, 950, 3657, 3651
5176, 3651, 3657, 3658, 3652
5177, 3652, 3658, 3659, 3653
5178, 3653, 3659, 3660, 3654
5179, 3654, 3660, 3661, 3655
5180, 3655, 3661, 3662, 3656
5181, 3656, 3662, 969, 968
5182, 950, 951, 3663, 3657
5183, 3657, 3663, 3664, 3658
5184, 3658, 3664, 3665, 3659
5185, 3659, 3665, 3666, 3660
5186, 3660, 3666, 3667, 3661
5187, 3661, 3667, 3668, 3662
5188, 3662, 3668, 970, 969
5189, 951, 952, 3669, 3663
5190, 3663, 3669, 3670, 3664
5191, 3664, 3670, 3671, 3665
5192, 3665, 3671, 3672, 3666
5193, 3666, 3672, 3673, 3667
5194, 3667, 3673, 3674, 3668
5195, 3668, 3674, 971, 970
5196, 952, 953, 3675, 3669
5197, 3669, 3675, 3676, 3670
5198, 3670, 3676, 3677, 3671
5199, 3671, 3677, 3678, 3672
5200, 3672, 3678, 3679, 3673
5201, 3673, 3679, 3680, 3674
5202, 3674, 3680, 972, 971
5203, 953, 954, 3681, 3675
5204, 3675, 3681, 3682, 3676
5205, 3676, 3682, 3683, 3677
5206, 3677, 3683, 3684, 3678
5207, 3678, 3684, 3685, 3679
5208, 3679, 3685, 3686, 3680
5209, 3680, 3686, 973, 972
5210, 954, 955, 3687, 3681
5211, 3681, 3687, 3688, 3682
5212, 3682, 3688, 3689, 3683
5213, 3683, 3689, 3690, 3684
5214, 3684, 3690, 3691, 3685
5215, 3685, 3691, 3692, 3686
5216, 3686, 3692, 974, 973
5217, 955, 956, 3693, 3687
5218, 3687, 3693, 3694, 3688
5219, 3688, 3694, 3695, 3689
5220, 3689, 3695, 3696, 3690
5221, 3690, 3696, 3697, 3691
5222, 3691, 3697, 3698, 3692
5223, 3692, 3698, 975, 974
5224, 956, 957, 3699, 3693
5225, 3693, 3699, 3700, 3694
5226, 3694, 3700, 3701, 3695
5227, 3695, 3701, 3702, 3696
5228, 3696, 3702, 3703, 3697
5229, 3697, 3703, 3704, 3698
5230, 3698, 3704, 976, 975
5231, 957, 85, 959, 3699
5232, 3699, 959, 960, 3700
5233, 3700, 960, 961, 3701
5234, 3701, 961, 962, 3702
5235, 3702, 962, 963, 3703
5236, 3703, 963, 964, 3704
5237, 3704, 964, 87, 976
*ELEMENT, type=CPS4, ELSET=Surface123
5238, 1, 53, 983, 965
5239, 965, 983, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
5240, 2, 946, 984, 54
5241, 946, 86, 90, 984
*ELEMENT, type=CPS4, ELSET=Surface125
5242, 54, 984, 3705, 647
5243, 984, 90, 985, 3705
5244, 647, 3705, 3706, 648
5245, 3705, 985, 986, 3706
5246, 648, 3706, 3707, 649
5247, 3706, 986, 987, 3707
5248, 649, 3707, 3708, 650
5249, 3707, 987, 988, 3708
5250, 650, 3708, 3709, 651
5251, 3708, 988, 989, 3709
5252, 651, 3709, 3710, 652
5253, 3709, 989, 990, 3710
5254, 652, 3710, 983, 53
5255, 3710, 990, 89, 983
*ELEMENT, type=CPS4, ELSET=Surface126
5256, 86, 977, 985, 90
5257, 977, 978, 986, 985
5258, 978, 979, 987, 986
5259, 979, 980, 988, 987
5260, 980, 981, 989, 988
5261, 981, 982, 990, 989
5262, 982, 88, 89, 990
*ELEMENT, type=CPS4, ELSET=Surface127
5263, 45, 991, 3711, 597
5264, 991, 91, 993, 3711
5265, 597, 3711, 3712, 598
5266, 3711, 993, 994, 3712
5267, 598, 3712, 3713, 599
5268, 3712, 994, 995, 3713
5269, 599, 3713, 3714, 600
5270, 3713, 995, 996, 3714
5271, 600, 3714, 3715, 601
5272, 3714, 996, 997, 3715
5273, 601, 3715, 3716, 602
5274, 3715, 997, 998, 3716
5275, 602, 3716, 3717, 603
5276, 3716, 998, 999, 3717
5277, 603, 3717, 3718, 604
5278, 3717, 999, 1000, 3718
5279, 604, 3718, 3719, 605
5280, 3718, 1000, 1001, 3719
5281, 605, 3719, 3720, 606
5282, 3719, 1001, 1002, 3720
5283, 606, 3720, 3721, 607
5284, 3720, 1002, 1003, 3721
5285, 607, 3721, 992, 46
5286, 3721, 1003, 92, 992
*ELEMENT, type=CPS4, ELSET=Surface128
5287, 47, 610, 3722, 1004
5288, 1004, 3722, 1006, 93
5289, 610, 611, 3723, 3722
5290, 3722, 3723, 1007, 1006
5291, 611, 612, 3724, 3723
5292, 3723, 3724, 1008, 1007
5293, 612, 613, 3725, 3724
5294, 3724, 3725, 1009, 1008
5295, 613, 614, 3726, 3725
5296, 3725, 3726, 1010, 1009
5297, 614, 615, 3727, 3726
5298, 3726, 3727, 1011, 1010
5299, 615, 616, 3728, 3727
5300, 3727, 3728, 1012, 1011
5301, 616, 617, 3729, 3728
5302, 3728, 3729, 1013, 1012
5303, 617, 618, 3730, 3729
5304, 3729, 3730, 1014, 1013
5305, 618, 619, 3731, 3730
5306, 3730, 3731, 1015, 1014
5307, 619, 620, 3732, 3731
5308, 3731, 3732, 1016, 1015
5309, 620, 48, 1005, 3732
5310, 3732, 1005, 94, 1016
*ELEMENT, type=CPS4, ELSET=Surface129
5311, 47, 1004, 3733, 621
5312, 1004, 93, 1017, 3733
5313, 621, 3733, 3734, 622
5314, 3733, 1017, 1018, 3734
5315, 622, 3734, 3735, 623
5316, 3734, 1018, 1019, 3735
5317, 623, 3735, 3736, 624
5318, 3735, 1019, 1020, 3736
5319, 624, 3736, 3737, 625
5320, 3736, 1020, 1021, 3737
5321, 625, 3737, 3738, 626
5322, 3737, 1021, 1022, 3738
5323, 626, 3738, 991, 45
5324, 3738, 1022, 91, 991
*ELEMENT, type=CPS4, ELSET=Surface130
5325, 48, 627, 3739, 1005
5326, 1005, 3739, 1023, 94
5327, 627, 628, 3740, 3739
5328, 3739, 3740, 1024, 1023
5329, 628, 629, 3741, 3740
5330, 3740, 3741, 1025, 1024
5331, 629, 630, 3742, 3741
5332, 3741, 3742, 1026, 1025
5333, 630, 631, 3743, 3742
5334, 3742, 3743, 1027, 1026
5335, 631, 632, 3744, 3743
5336, 3743, 3744, 1028, 1027
5337, 632, 46, 992, 3744
5338, 3744, 992, 92, 1028
*ELEMENT, type=CPS4, ELSET=Surface131
5339, 93, 1006, 3745, 1017
5340, 1006, 1007, 3746, 3745
5341, 1007, 1008, 3747, 3746
5342, 1008, 1009, 3748, 3747
5343, 1009, 1010, 3749, 3748
5344, 1010, 1011, 3750, 3749
5345, 1011, 1012, 3751, 3750
5346, 1012, 1013, 3752, 3751
5347, 1013, 1014, 3753, 3752
5348, 1014, 1015, 3754, 3753
5349, 1015, 1016, 3755, 3754
5350, 1016, 94, 1023, 3755
5351, 1017, 3745, 3756, 1018
5352, 3745, 3746, 3757, 3756
5353, 3746, 3747, 3758, 3757
5354, 3747, 3748, 3759, 3758
5355, 3748, 3749, 3760, 3759
5356, 3749, 3750, 3761, 3760
5357, 3750, 3751, 3762, 3761
5358, 3751, 3752, 3763, 3762
5359, 3752, 3753, 3764, 3763
5360, 3753, 3754, 3765, 3764
5361, 3754, 3755, 3766, 3765
5362, 3755, 1023, 1024, 3766
5363, 1018, 3756, 3767, 1019
5364, 3756, 3757, 3768, 3767
5365, 3757, 3758, 3769, 3768
5366, 3758, 3759, 3770, 3769
5367, 3759, 3760, 3771, 3770
5368, 3760, 3761, 3772, 3771
5369, 3761, 3762, 3773, 3772
5370, 3762, 3763, 3774, 3773
5371, 3763, 3764, 3775, 3774
5372, 3764, 3765, 3776, 3775
5373, 3765, 3766, 3777, 3776
5374, 3766, 1024, 1025, 3777
5375, 1019, 3767, 3778, 1020
5376, 3767, 3768, 3779, 3778
5377, 3768, 3769, 3780, 3779
5378, 3769, 3770, 3781, 3780
5379, 3770, 3771, 3782, 3781
5380, 3771, 3772, 3783, 3782
5381, 3772, 3773, 3784, 3783
5382, 3773, 3774, 3785, 3784
5383, 3774, 3775, 3786, 3785
5384, 3775, 3776, 3787, 3786
5385, 3776, 3777, 3788, 3787
5386, 3777, 1025, 1026, 3788
5387, 1020, 3778, 3789, 1021
5388, 3778, 3779, 3790, 3789
5389, 3779, 3780, 3791, 3790
5390, 3780, 3781, 3792, 3791
5391, 3781, 3782, 3793, 3792
5392, 3782, 3783, 3794, 3793
5393, 3783, 3784, 3795, 3794
5394, 3784, 3785, 3796, 3795
5395, 3785, 3786, 3797, 3796
5396, 3786, 3787, 3798, 3797
5397, 3787, 3788, 3799, 3798
5398, 3788, 1026, 1027, 3799
5399, 1021, 3789, 3800, 1022
5400, 3789, 3790, 3801, 3800
5401, 3790, 3791, 3802, 3801
5402, 3791, 3792, 3803, 3802
5403, 3792, 3793, 3804, 3803
5404, 3793, 3794, 3805, 3804
5405, 3794, 3795, 3806, 3805
5406, 3795, 3796, 3807, 3806
5407, 3796, 3797, 3808, 3807
5408, 3797, 3798, 3809, 3808
5409, 3798, 3799, 3810, 3809
5410, 3799, 1027, 1028, 3810
5411, 1022, 3800, 993, 91
5412, 3800, 3801, 994, 993
5413, 3801, 3802, 995, 994
5414, 3802, 3803, 996, 995
5415, 3803, 3804, 997, 996
5416, 3804, 3805, 998, 997
5417, 3805, 3806, 999, 998
5418, 3806, 3807, 1000, 999
5419, 3807, 3808, 1001, 1000
5420, 3808, 3809, 1002, 1001
5421, 3809, 3810, 1003, 1002
5422, 3810, 1028, 92, 1003
*ELEMENT, type=CPS4, ELSET=Surface132
5423, 46, 992, 1029, 50
5424, 992, 92, 95, 1029
*ELEMENT, type=CPS4, ELSET=Surface133
5425, 48, 52, 1030, 1005
5426, 1005, 1030, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
5427, 52, 641, 3811, 1030
5428, 1030, 3811, 1031, 96
5429, 641, 642, 3812, 3811
5430, 3811, 3812, 1032, 1031
5431, 642, 643, 3813, 3812
5432, 3812, 3813, 1033, 1032
5433, 643, 644, 3814, 3813
5434, 3813, 3814, 1034, 1033
5435, 644, 645, 3815, 3814
5436, 3814, 3815, 1035, 1034
5437, 645, 646, 3816, 3815
5438, 3815, 3816, 1036, 1035
5439, 646, 50, 1029, 3816
5440, 3816, 1029, 95, 1036
*ELEMENT, type=CPS4, ELSET=Surface135
5441, 94, 96, 1031, 1023
5442, 1023, 1031, 1032, 1024
5443, 1024, 1032, 1033, 1025
5444, 1025, 1033, 1034, 1026
5445, 1026, 1034, 1035, 1027
5446, 1027, 1035, 1036, 1028
5447, 1028, 1036, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
5448, 1037, 97, 2, 110, 3817, 1049, 125, 1181
5449, 3817, 1049, 125, 1181, 3818, 1055, 126, 1182
5450, 3818, 1055, 126, 1182, 3819, 1061, 127, 1183
5451, 3819, 1061, 127, 1183, 3820, 1067, 128, 1184
5452, 3820, 1067, 128, 1184, 3821, 1073, 129, 1185
5453, 3821, 1073, 129, 1185, 3822, 1079, 130, 1186
5454, 3822, 1079, 130, 1186, 3823, 1085, 131, 1187
5455, 3823, 1085, 131, 1187, 3824, 1091, 132, 1188
5456, 3824, 1091, 132, 1188, 3825, 1097, 133, 1189
5457, 3825, 1097, 133, 1189, 3826, 1103, 134, 1190
5458, 3826, 1103, 134, 1190, 3827, 1109, 135, 1191
5459, 3827, 1109, 135, 1191, 1043, 111, 6, 124
5460, 104, 1037, 110, 4, 1115, 3817, 1181, 147
5461, 1115, 3817, 1181, 147, 1121, 3818, 1182, 148
5462, 1121, 3818, 1182, 148, 1127, 3819, 1183, 149
5463, 1127, 3819, 1183, 149, 1133, 3820, 1184, 150
5464, 1133, 3820, 1184, 150, 1139, 3821, 1185, 151
5465, 1139, 3821, 1185, 151, 1145, 3822, 1186, 152
5466, 1145, 3822, 1186, 152, 1151, 3823, 1187, 153
5467, 1151, 3823, 1187, 153, 1157, 3824, 1188, 154
5468, 1157, 3824, 1188, 154, 1163, 3825, 1189, 155
5469, 1163, 3825, 1189, 155, 1169, 3826, 1190, 156
5470, 1169, 3826, 1190, 156, 1175, 3827, 1191, 157
5471, 1175, 3827, 1191, 157, 118, 1043, 124, 8
5472, 1038, 98, 97, 1037, 3828, 1050, 1049, 3817
5473, 3828, 1050, 1049, 3817, 3829, 1056, 1055, 3818
5474, 3829, 1056, 1055, 3818, 3830, 1062, 1061, 3819
5475, 3830, 1062, 1061, 3819, 3831, 1068, 1067, 3820
5476, 3831, 1068, 1067, 3820, 3832, 1074, 1073, 3821
5477, 3832, 1074, 1073, 3821, 3833, 1080, 1079, 3822
5478, 3833, 1080, 1079, 3822, 3834, 1086, 1085, 3823
5479, 3834, 1086, 1085, 3823, 3835, 1092, 1091, 3824
5480, 3835, 1092, 1091, 3824, 3836, 1098, 1097, 3825
5481, 3836, 1098, 1097, 3825, 3837, 1104, 1103, 3826
5482, 3837, 1104, 1103, 3826, 3838, 1110, 1109, 3827
5483, 3838, 1110, 1109, 3827, 1044, 112, 111, 1043
5484, 105, 1038, 1037, 104, 1116, 3828, 3817, 1115
5485, 1116, 3828, 3817, 1115, 1122, 3829, 3818, 1121
5486, 1122, 3829, 3818, 1121, 1128, 3830, 3819, 1127
5487, 1128, 3830, 3819, 1127, 1134, 3831, 3820, 1133
5488, 1134, 3831, 3820, 1133, 1140, 3832, 3821, 1139
5489, 1140, 3832, 3821, 1139, 1146, 3833, 3822, 1145
5490, 1146, 3833, 3822, 1145, 1152, 3834, 3823, 1151
5491, 1152, 3834, 3823, 1151, 1158, 3835, 3824, 1157
5492, 1158, 3835, 3824, 1157, 1164, 3836, 3825, 1163
5493, 1164, 3836, 3825, 1163, 1170, 3837, 3826, 1169
5494, 1170, 3837, 3826, 1169, 1176, 3838, 3827, 1175
5495, 1176, 3838, 3827, 1175, 119, 1044, 1043, 118
5496, 1039, 99, 98, 1038, 3839, 1051, 1050, 3828
5497, 3839, 1051, 1050, 3828, 3840, 1057, 1056, 3829
5498, 3840, 1057, 1056, 3829, 3841, 1063, 1062, 3830
5499, 3841, 1063, 1062, 3830, 3842, 1069, 1068, 3831
5500, 3842, 1069, 1068, 3831, 3843, 1075, 1074, 3832
5501, 3843, 1075, 1074, 3832, 3844, 1081, 1080, 3833
5502, 3844, 1081, 1080, 3833, 3845, 1087, 1086, 3834
5503, 3845, 1087, 1086, 3834, 3846, 1093, 1092, 3835
5504, 3846, 1093, 1092, 3835, 3847, 1099, 1098, 3836
5505, 3847, 1099, 1098, 3836, 3848, 1105, 1104, 3837
5506, 3848, 1105, 1104, 3837, 3849, 1111, 1110, 3838
5507, 3849, 1111, 1110, 3838, 1045, 113, 112, 1044
5508, 106, 1039, 1038, 105, 1117, 3839, 3828, 1116
5509, 1117, 3839, 3828, 1116, 1123, 3840, 3829, 1122
5510, 1123, 3840, 3829, 1122, 1129, 3841, 3830, 1128
5511, 1129, 3841, 3830, 1128, 1135, 3842, 3831, 1134
5512, 1135, 3842, 3831, 1134, 1141, 3843, 3832, 1140
5513, 1141, 3843, 3832, 1140, 1147, 3844, 3833, 1146
5514, 1147, 3844, 3833, 1146, 1153, 3845, 3834, 1152
5515, 1153, 3845, 3834, 1152, 1159, 3846, 3835, 1158
5516, 1159, 3846, 3835, 1158, 1165, 3847, 3836, 1164
5517, 1165, 3847, 3836, 1164, 1171, 3848, 3837, 1170
5518, 1171, 3848, 3837, 1170, 1177, 3849, 3838, 1176
5519, 1177, 3849, 3838, 1176, 120, 1045, 1044, 119
5520, 1040, 100, 99, 1039, 3850, 1052, 1051, 3839
5521, 3850, 1052, 1051, 3839, 3851, 1058, 1057, 3840
5522, 3851, 1058, 1057, 3840, 3852, 1064, 1063, 3841
5523, 3852, 1064, 1063, 3841, 3853, 1070, 1069, 3842
5524, 3853, 1070, 1069, 3842, 3854, 1076, 1075, 3843
5525, 3854, 1076, 1075, 3843, 3855, 1082, 1081, 3844
5526, 3855, 1082, 1081, 3844, 3856, 1088, 1087, 3845
5527, 3856, 1088, 1087, 3845, 3857, 1094, 1093, 3846
5528, 3857, 1094, 1093, 3846, 3858, 1100, 1099, 3847
5529, 3858, 1100, 1099, 3847, 3859, 1106, 1105, 3848
5530, 3859, 1106, 1105, 3848, 3860, 1112, 1111, 3849
5531, 3860, 1112, 1111, 3849, 1046, 114, 113, 1045
5532, 107, 1040, 1039, 106, 1118, 3850, 3839, 1117
5533, 1118, 3850, 3839, 1117, 1124, 3851, 3840, 1123
5534, 1124, 3851, 3840, 1123, 1130, 3852, 3841, 1129
5535, 1130, 3852, 3841, 1129, 1136, 3853, 3842, 1135
5536, 1136, 3853, 3842, 1135, 1142, 3854, 3843, 1141
5537, 1142, 3854, 3843, 1141, 1148, 3855, 3844, 1147
5538, 1148, 3855, 3844, 1147, 1154, 3856, 3845, 1153
5539, 1154, 3856, 3845, 1153, 1160, 3857, 3846, 1159
5540, 1160, 3857, 3846, 1159, 1166, 3858, 3847, 1165
5541, 1166, 3858, 3847, 1165, 1172, 3859, 3848, 1171
5542, 1172, 3859, 3848, 1171, 1178, 3860, 3849, 1177
5543, 1178, 3860, 3849, 1177, 121, 1046, 1045, 120
5544, 1041, 101, 100, 1040, 3861, 1053, 1052, 3850
5545, 3861, 1053, 1052, 3850, 3862, 1059, 1058, 3851
5546, 3862, 1059, 1058, 3851, 3863, 1065, 1064, 3852
5547, 3863, 1065, 1064, 3852, 3864, 1071, 1070, 3853
5548, 3864, 1071, 1070, 3853, 3865, 1077, 1076, 3854
5549, 3865, 1077, 1076, 3854, 3866, 1083, 1082, 3855
5550, 3866, 1083, 1082, 3855, 3867, 1089, 1088, 3856
5551, 3867, 1089, 1088, 3856, 3868, 1095, 1094, 3857
5552, 3868, 1095, 1094, 3857, 3869, 1101, 1100, 3858
5553, 3869, 1101, 1100, 3858, 3870, 1107, 1106, 3859
5554, 3870, 1107, 1106, 3859, 3871, 1113, 1112, 3860
5555, 3871, 1113, 1112, 3860, 1047, 115, 114, 1046
5556, 108, 1041, 1040, 107, 1119, 3861, 3850, 1118
5557, 1119, 3861, 3850, 1118, 1125, 3862, 3851, 1124
5558, 1125, 3862, 3851, 1124, 1131, 3863, 3852, 1130
5559, 1131, 3863, 3852, 1130, 1137, 3864, 3853, 1136
5560, 1137, 3864, 3853, 1136, 1143, 3865, 3854, 1142
5561, 1143, 3865, 3854, 1142, 1149, 3866, 3855, 1148
5562, 1149, 3866, 3855, 1148, 1155, 3867, 3856, 1154
5563, 1155, 3867, 3856, 1154, 1161, 3868, 3857, 1160
5564, 1161, 3868, 3857, 1160, 1167, 3869, 3858, 1166
5565, 1167, 3869, 3858, 1166, 1173, 3870, 3859, 1172
5566, 1173, 3870, 3859, 1172, 1179, 3871, 3860, 1178
5567, 1179, 3871, 3860, 1178, 122, 1047, 1046, 121
5568, 1042, 102, 101, 1041, 3872, 1054, 1053, 3861
5569, 3872, 1054, 1053, 3861, 3873, 1060, 1059, 3862
5570, 3873, 1060, 1059, 3862, 3874, 1066, 1065, 3863
5571, 3874, 1066, 1065, 3863, 3875, 1072, 1071, 3864
5572, 3875, 1072, 1071, 3864, 3876, 1078, 1077, 3865
5573, 3876, 1078, 1077, 3865, 3877, 1084, 1083, 3866
5574, 3877, 1084, 1083, 3866, 3878, 1090, 1089, 3867
5575, 3878, 1090, 1089, 3867, 3879, 1096, 1095, 3868
5576, 3879, 1096, 1095, 3868, 3880, 1102, 1101, 3869
5577, 3880, 1102, 1101, 3869, 3881, 1108, 1107, 3870
5578, 3881, 1108, 1107, 3870, 3882, 1114, 1113, 3871
5579, 3882, 1114, 1113, 3871, 1048, 116, 115, 1047
5580, 109, 1042, 1041, 108, 1120, 3872, 3861, 1119
5581, 1120, 3872, 3861, 1119, 1126, 3873, 3862, 1125
5582, 1126, 3873, 3862, 1125, 1132, 3874, 3863, 1131
5583, 1132, 3874, 3863, 1131, 1138, 3875, 3864, 1137
5584, 1138, 3875, 3864, 1137, 1144, 3876, 3865, 1143
5585, 1144, 3876, 3865, 1143, 1150, 3877, 3866, 1149
5586, 1150, 3877, 3866, 1149, 1156, 3878, 3867, 1155
5587, 1156, 3878, 3867, 1155, 1162, 3879, 3868, 1161
5588, 1162, 3879, 3868, 1161, 1168, 3880, 3869, 1167
5589, 1168, 3880, 3869, 1167, 1174, 3881, 3870, 1173
5590, 1174, 3881, 3870, 1173, 1180, 3882, 3871, 1179
5591, 1180, 3882, 3871, 1179, 123, 1048, 1047, 122
5592, 103, 1, 102, 1042, 1192, 136, 1054, 3872
5593, 1192, 136, 1054, 3872, 1193, 137, 1060, 3873
5594, 1193, 137, 1060, 3873, 1194, 138, 1066, 3874
5595, 1194, 138, 1066, 3874, 1195, 139, 1072, 3875
5596, 1195, 139, 1072, 3875, 1196, 140, 1078, 3876
5597, 1196, 140, 1078, 3876, 1197, 141, 1084, 3877
5598, 1197, 141, 1084, 3877, 1198, 142, 1090, 3878
5599, 1198, 142, 1090, 3878, 1199, 143, 1096, 3879
5600, 1199, 143, 1096, 3879, 1200, 144, 1102, 3880
5601, 1200, 144, 1102, 3880, 1201, 145, 1108, 3881
5602, 1201, 145, 1108, 3881, 1202, 146, 1114, 3882
5603, 1202, 146, 1114, 3882, 117, 5, 116, 1048
5604, 3, 103, 1042, 109, 158, 1192, 3872, 1120
5605, 158, 1192, 3872, 1120, 159, 1193, 3873, 1126
5606, 159, 1193, 3873, 1126, 160, 1194, 3874, 1132
5607, 160, 1194, 3874, 1132, 161, 1195, 3875, 1138
5608, 161, 1195, 3875, 1138, 162, 1196, 3876, 1144
5609, 162, 1196, 3876, 1144, 163, 1197, 3877, 1150
5610, 163, 1197, 3877, 1150, 164, 1198, 3878, 1156
5611, 164, 1198, 3878, 1156, 165, 1199, 3879, 1162
5612, 165, 1199, 3879, 1162, 166, 1200, 3880, 1168
5613, 166, 1200, 3880, 1168, 167, 1201, 3881, 1174
5614, 167, 1201, 3881, 1174, 168, 1202, 3882, 1180
5615, 168, 1202, 3882, 1180, 7, 117, 1048, 123
*ELEMENT, type=C3D8, ELSET=Volume2
5616, 4, 104, 1115, 147, 10, 197, 1203, 169
5617, 104, 105, 1116, 1115, 197, 198, 1204, 1203
5618, 105, 106, 1117, 1116, 198, 199, 1205, 1204
5619, 106, 107, 1118, 1117, 199, 200, 1206, 1205
5620, 107, 108, 1119, 1118, 200, 201, 1207, 1206
5621, 108, 109, 1120, 1119, 201, 202, 1208, 1207
5622, 109, 3, 158, 1120, 202, 12, 186, 1208
5623, 147, 1115, 1121, 148, 169, 1203, 1209, 170
5624, 1115, 1116, 1122, 1121, 1203, 1204, 1210, 1209
5625, 1116, 1117, 1123, 1122, 1204, 1205, 1211, 1210
5626, 1117, 1118, 1124, 1123, 1205, 1206, 1212, 1211
5627, 1118, 1119, 1125, 1124, 1206, 1207, 1213, 1212
5628, 1119, 1120, 1126, 1125, 1207, 1208, 1214, 1213
5629, 1120, 158, 159, 1126, 1208, 186, 187, 1214
5630, 148, 1121, 1127, 149, 170, 1209, 1215, 171
5631, 1121, 1122, 1128, 1127, 1209, 1210, 1216, 1215
5632, 1122, 1123, 1129, 1128, 1210, 1211, 1217, 1216
5633, 1123, 1124, 1130, 1129, 1211, 1212, 1218, 1217
5634, 1124, 1125, 1131, 1130, 1212, 1213, 1219, 1218
5635, 1125, 1126, 1132, 1131, 1213, 1214, 1220, 1219
5636, 1126, 159, 160, 1132, 1214, 187, 188, 1220
5637, 149, 1127, 1133, 150, 171, 1215, 1221, 172
5638, 1127, 1128, 1134, 1133, 1215, 1216, 1222, 1221
5639, 1128, 1129, 1135, 1134, 1216, 1217, 1223, 1222
5640, 1129, 1130, 1136, 1135, 1217, 1218, 1224, 1223
5641, 1130, 1131, 1137, 1136, 1218, 1219, 1225, 1224
5642, 1131, 1132, 1138, 1137, 1219, 1220, 1226, 1225
5643, 1132, 160, 161, 1138, 1220, 188, 189, 1226
5644, 150, 1133, 1139, 151, 172, 1221, 1227, 173
5645, 1133, 1134, 1140, 1139, 1221, 1222, 1228, 1227
5646, 1134, 1135, 1141, 1140, 1222, 1223, 1229, 1228
5647, 1135, 1136, 1142, 1141, 1223, 1224, 1230, 1229
5648, 1136, 1137, 1143, 1142, 1224, 1225, 1231, 1230
5649, 1137, 1138, 1144, 1143, 1225, 1226, 1232, 1231
5650, 1138, 161, 162, 1144, 1226, 189, 190, 1232
5651, 151, 1139, 1145, 152, 173, 1227, 1233, 174
5652, 1139, 1140, 1146, 1145, 1227, 1228, 1234, 1233
5653, 1140, 1141, 1147, 1146, 1228, 1229, 1235, 1234
5654, 1141, 1142, 1148, 1147, 1229, 1230, 1236, 1235
5655, 1142, 1143, 1149, 1148, 1230, 1231, 1237, 1236
5656, 1143, 1144, 1150, 1149, 1231, 1232, 1238, 1237
5657, 1144, 162, 163, 1150, 1232, 190, 191, 1238
5658, 152, 1145, 1151, 153, 174, 1233, 1239, 175
5659, 1145, 1146, 1152, 1151, 1233, 1234, 1240, 1239
5660, 1146, 1147, 1153, 1152, 1234, 1235, 1241, 1240
5661, 1147, 1148, 1154, 1153, 1235, 1236, 1242, 1241
5662, 1148, 1149, 1155, 1154, 1236, 1237, 1243, 1242
5663, 1149, 1150, 1156, 1155, 1237, 1238, 1244, 1243
5664, 1150, 163, 164, 1156, 1238, 191, 192, 1244
5665, 153, 1151, 1157, 154, 175, 1239, 1245, 176
5666, 1151, 1152, 1158, 1157, 1239, 1240, 1246, 1245
5667, 1152, 1153, 1159, 1158, 1240, 1241, 1247, 1246
5668, 1153, 1154, 1160, 1159, 1241, 1242, 1248, 1247
5669, 1154, 1155, 1161, 1160, 1242, 1243, 1249, 1248
5670, 1155, 1156, 1162, 1161, 1243, 1244, 1250, 1249
5671, 1156, 164, 165, 1162, 1244, 192, 193, 1250
5672, 154, 1157, 1163, 155, 176, 1245, 1251, 177
5673, 1157, 1158, 1164, 1163, 1245, 1246, 1252, 1251
5674, 1158, 1159, 1165, 1164, 1246, 1247, 1253, 1252
5675, 1159, 1160, 1166, 1165, 1247, 1248, 1254, 1253
5676, 1160, 1161, 1167, 1166, 1248, 1249, 1255, 1254
5677, 1161, 1162, 1168, 1167, 1249, 1250, 1256, 1255
5678, 1162, 165, 166, 1168, 1250, 193, 194, 1256
5679, 155, 1163, 1169, 156, 177, 1251, 1257, 178
5680, 1163, 1164, 1170, 1169, 1251, 1252, 1258, 1257
5681, 1164, 1165, 1171, 1170, 1252, 1253, 1259, 1258
5682, 1165, 1166, 1172, 1171, 1253, 1254, 1260, 1259
5683, 1166, 1167, 1173, 1172, 1254, 1255, 1261, 1260
5684, 1167, 1168, 1174, 1173, 1255, 1256, 1262, 1261
5685, 1168, 166, 167, 1174, 1256, 194, 195, 1262
5686, 156, 1169, 1175, 157, 178, 1257, 1263, 179
5687, 1169, 1170, 1176, 1175, 1257, 1258, 1264, 1263
5688, 1170, 1171, 1177, 1176, 1258, 1259, 1265, 1264
5689, 1171, 1172, 1178, 1177, 1259, 1260, 1266, 1265
5690, 1172, 1173, 1179, 1178, 1260, 1261, 1267, 1266
5691, 1173, 1174, 1180, 1179, 1261, 1262, 1268, 1267
5692, 1174, 167, 168, 1180, 1262, 195, 196, 1268
5693, 157, 1175, 118, 8, 179, 1263, 180, 9
5694, 1175, 1176, 119, 118, 1263, 1264, 181, 180
5695, 1176, 1177, 120, 119, 1264, 1265, 182, 181
5696, 1177, 1178, 121, 120, 1265, 1266, 183, 182
5697, 1178, 1179, 122, 121, 1266, 1267, 184, 183
5698, 1179, 1180, 123, 122, 1267, 1268, 185, 184
5699, 1180, 168, 7, 123, 1268, 196, 11, 185
*ELEMENT, type=C3D8, ELSET=Volume3
5700, 10, 197, 1203, 169, 217, 1661, 3883, 1269
5701, 217, 1661, 3883, 1269, 218, 1662, 3884, 1270
5702, 218, 1662, 3884, 1270, 219, 1663, 3885, 1271
5703, 219, 1663, 3885, 1271, 220, 1664, 3886, 1272
5704, 220, 1664, 3886, 1272, 221, 1665, 3887, 1273
5705, 221, 1665, 3887, 1273, 222, 1666, 3888, 1274
5706, 222, 1666, 3888, 1274, 223, 1667, 3889, 1275
5707, 223, 1667, 3889, 1275, 224, 1668, 3890, 1276
5708, 224, 1668, 3890, 1276, 225, 1669, 3891, 1277
5709, 225, 1669, 3891, 1277, 226, 1670, 3892, 1278
5710, 226, 1670, 3892, 1278, 227, 1671, 3893, 1279
5711, 227, 1671, 3893, 1279, 228, 1672, 3894, 1280
5712, 228, 1672, 3894, 1280, 229, 1673, 3895, 1281
5713, 229, 1673, 3895, 1281, 230, 1674, 3896, 1282
5714, 230, 1674, 3896, 1282, 14, 287, 1745, 231
5715, 197, 198, 1204, 1203, 1661, 1675, 3897, 3883
5716, 1661, 1675, 3897, 3883, 1662, 1676, 3898, 3884
5717, 1662, 1676, 3898, 3884, 1663, 1677, 3899, 3885
5718, 1663, 1677, 3899, 3885, 1664, 1678, 3900, 3886
5719, 1664, 1678, 3900, 3886, 1665, 1679, 3901, 3887
5720, 1665, 1679, 3901, 3887, 1666, 1680, 3902, 3888
5721, 1666, 1680, 3902, 3888, 1667, 1681, 3903, 3889
5722, 1667, 1681, 3903, 3889, 1668, 1682, 3904, 3890
5723, 1668, 1682, 3904, 3890, 1669, 1683, 3905, 3891
5724, 1669, 1683, 3905, 3891, 1670, 1684, 3906, 3892
5725, 1670, 1684, 3906, 3892, 1671, 1685, 3907, 3893
5726, 1671, 1685, 3907, 3893, 1672, 1686, 3908, 3894
5727, 1672, 1686, 3908, 3894, 1673, 1687, 3909, 3895
5728, 1673, 1687, 3909, 3895, 1674, 1688, 3910, 3896
5729, 1674, 1688, 3910, 3896, 287, 288, 1746, 1745
5730, 198, 199, 1205, 1204, 1675, 1689, 3911, 3897
5731, 1675, 1689, 3911, 3897, 1676, 1690, 3912, 3898
5732, 1676, 1690, 3912, 3898, 1677, 1691, 3913, 3899
5733, 1677, 1691, 3913, 3899, 1678, 1692, 3914, 3900
5734, 1678, 1692, 3914, 3900, 1679, 1693, 3915, 3901
5735, 1679, 1693, 3915, 3901, 1680, 1694, 3916, 3902
5736, 1680, 1694, 3916, 3902, 1681, 1695, 3917, 3903
5737, 1681, 1695, 3917, 3903, 1682, 1696, 3918, 3904
5738, 1682, 1696, 3918, 3904, 1683, 1697, 3919, 3905
5739, 1683, 1697, 3919, 3905, 1684, 1698, 3920, 3906
5740, 1684, 1698, 3920, 3906, 1685, 1699, 3921, 3907
5741, 1685, 1699, 3921, 3907, 1686, 1700, 3922, 3908
5742, 1686, 1700, 3922, 3908, 1687, 1701, 3923, 3909
5743, 1687, 1701, 3923, 3909, 1688, 1702, 3924, 3910
5744, 1688, 1702, 3924, 3910, 288, 289, 1747, 1746
5745, 199, 200, 1206, 1205, 1689, 1703, 3925, 3911
5746, 1689, 1703, 3925, 3911, 1690, 1704, 3926, 3912
5747, 1690, 1704, 3926, 3912, 1691, 1705, 3927, 3913
5748, 1691, 1705, 3927, 3913, 1692, 1706, 3928, 3914
5749, 1692, 1706, 3928, 3914, 1693, 1707, 3929, 3915
5750, 1693, 1707, 3929, 3915, 1694, 1708, 3930, 3916
5751, 1694, 1708, 3930, 3916, 1695, 1709, 3931, 3917
5752, 1695, 1709, 3931, 3917, 1696, 1710, 3932, 3918
5753, 1696, 1710, 3932, 3918, 1697, 1711, 3933, 3919
5754, 1697, 1711, 3933, 3919, 1698, 1712, 3934, 3920
5755, 1698, 1712, 3934, 3920, 1699, 1713, 3935, 3921
5756, 1699, 1713, 3935, 3921, 1700, 1714, 3936, 3922
5757, 1700, 1714, 3936, 3922, 1701, 1715, 3937, 3923
5758, 1701, 1715, 3937, 3923, 1702, 1716, 3938, 3924
5759, 1702, 1716, 3938, 3924, 289, 290, 1748, 1747
5760, 200, 201, 1207, 1206, 1703, 1717, 3939, 3925
5761, 1703, 1717, 3939, 3925, 1704, 1718, 3940, 3926
5762, 1704, 1718, 3940, 3926, 1705, 1719, 3941, 3927
5763, 1705, 1719, 3941, 3927, 1706, 1720, 3942, 3928
5764, 1706, 1720, 3942, 3928, 1707, 1721, 3943, 3929
5765, 1707, 1721, 3943, 3929, 1708, 1722, 3944, 3930
5766, 1708, 1722, 3944, 3930, 1709, 1723, 3945, 3931
5767, 1709, 1723, 3945, 3931, 1710, 1724, 3946, 3932
5768, 1710, 1724, 3946, 3932, 1711, 1725, 3947, 3933
5769, 1711, 1725, 3947, 3933, 1712, 1726, 3948, 3934
5770, 1712, 1726, 3948, 3934, 1713, 1727, 3949, 3935
5771, 1713, 1727, 3949, 3935, 1714, 1728, 3950, 3936
5772, 1714, 1728, 3950, 3936, 1715, 1729, 3951, 3937
5773, 1715, 1729, 3951, 3937, 1716, 1730, 3952, 3938
5774, 1716, 1730, 3952, 3938, 290, 291, 1749, 1748
5775, 201, 202, 1208, 1207, 1717, 1731, 3953, 3939
5776, 1717, 1731, 3953, 3939, 1718, 1732, 3954, 3940
5777, 1718, 1732, 3954, 3940, 1719, 1733, 3955, 3941
5778, 1719, 1733, 3955, 3941, 1720, 1734, 3956, 3942
5779, 1720, 1734, 3956, 3942, 1721, 1735, 3957, 3943
5780, 1721, 1735, 3957, 3943, 1722, 1736, 3958, 3944
5781, 1722, 1736, 3958, 3944, 1723, 1737, 3959, 3945
5782, 1723, 1737, 3959, 3945, 1724, 1738, 3960, 3946
5783, 1724, 1738, 3960, 3946, 1725, 1739, 3961, 3947
5784, 1725, 1739, 3961, 3947, 1726, 1740, 3962, 3948
5785, 1726, 1740, 3962, 3948, 1727, 1741, 3963, 3949
5786, 1727, 1741, 3963, 3949, 1728, 1742, 3964, 3950
5787, 1728, 1742, 3964, 3950, 1729, 1743, 3965, 3951
5788, 1729, 1743, 3965, 3951, 1730, 1744, 3966, 3952
5789, 1730, 1744, 3966, 3952, 291, 292, 1750, 1749
5790, 202, 12, 186, 1208, 1731, 262, 1507, 3953
5791, 1731, 262, 1507, 3953, 1732, 263, 1508, 3954
5792, 1732, 263, 1508, 3954, 1733, 264, 1509, 3955
5793, 1733, 264, 1509, 3955, 1734, 265, 1510, 3956
5794, 1734, 265, 1510, 3956, 1735, 266, 1511, 3957
5795, 1735, 266, 1511, 3957, 1736, 267, 1512, 3958
5796, 1736, 267, 1512, 3958, 1737, 268, 1513, 3959
5797, 1737, 268, 1513, 3959, 1738, 269, 1514, 3960
5798, 1738, 269, 1514, 3960, 1739, 270, 1515, 3961
5799, 1739, 270, 1515, 3961, 1740, 271, 1516, 3962
5800, 1740, 271, 1516, 3962, 1741, 272, 1517, 3963
5801, 1741, 272, 1517, 3963, 1742, 273, 1518, 3964
5802, 1742, 273, 1518, 3964, 1743, 274, 1519, 3965
5803, 1743, 274, 1519, 3965, 1744, 275, 1520, 3966
5804, 1744, 275, 1520, 3966, 292, 16, 276, 1750
5805, 169, 1203, 1209, 170, 1269, 3883, 3967, 1283
5806, 1269, 3883, 3967, 1283, 1270, 3884, 3968, 1284
5807, 1270, 3884, 3968, 1284, 1271, 3885, 3969, 1285
5808, 1271, 3885, 3969, 1285, 1272, 3886, 3970, 1286
5809, 1272, 3886, 3970, 1286, 1273, 3887, 3971, 1287
5810, 1273, 3887, 3971, 1287, 1274, 3888, 3972, 1288
5811, 1274, 3888, 3972, 1288, 1275, 3889, 3973, 1289
5812, 1275, 3889, 3973, 1289, 1276, 3890, 3974, 1290
5813, 1276, 3890, 3974, 1290, 1277, 3891, 3975, 1291
5814, 1277, 3891, 3975, 1291, 1278, 3892, 3976, 1292
5815, 1278, 3892, 3976, 1292, 1279, 3893, 3977, 1293
5816, 1279, 3893, 3977, 1293, 1280, 3894, 3978, 1294
5817, 1280, 3894, 3978, 1294, 1281, 3895, 3979, 1295
5818, 1281, 3895, 3979, 1295, 1282, 3896, 3980, 1296
5819, 1282, 3896, 3980, 1296, 231, 1745, 1751, 232
5820, 1203, 1204, 1210, 1209, 3883, 3897, 3981, 3967
5821, 3883, 3897, 3981, 3967, 3884, 3898, 3982, 3968
5822, 3884, 3898, 3982, 3968, 3885, 3899, 3983, 3969
5823, 3885, 3899, 3983, 3969, 3886, 3900, 3984, 3970
5824, 3886, 3900, 3984, 3970, 3887, 3901, 3985, 3971
5825, 3887, 3901, 3985, 3971, 3888, 3902, 3986, 3972
5826, 3888, 3902, 3986, 3972, 3889, 3903, 3987, 3973
5827, 3889, 3903, 3987, 3973, 3890, 3904, 3988, 3974
5828, 3890, 3904, 3988, 3974, 3891, 3905, 3989, 3975
5829, 3891, 3905, 3989, 3975, 3892, 3906, 3990, 3976
5830, 3892, 3906, 3990, 3976, 3893, 3907, 3991, 3977
5831, 3893, 3907, 3991, 3977, 3894, 3908, 3992, 3978
5832, 3894, 3908, 3992, 3978, 3895, 3909, 3993, 3979
5833, 3895, 3909, 3993, 3979, 3896, 3910, 3994, 3980
5834, 3896, 3910, 3994, 3980, 1745, 1746, 1752, 1751
5835, 1204, 1205, 1211, 1210, 3897, 3911, 3995, 3981
5836, 3897, 3911, 3995, 3981, 3898, 3912, 3996, 3982
5837, 3898, 3912, 3996, 3982, 3899, 3913, 3997, 3983
5838, 3899, 3913, 3997, 3983, 3900, 3914, 3998, 3984
5839, 3900, 3914, 3998, 3984, 3901, 3915, 3999, 3985
5840, 3901, 3915, 3999, 3985, 3902, 3916, 4000, 3986
5841, 3902, 3916, 4000, 3986, 3903, 3917, 4001, 3987
5842, 3903, 3917, 4001, 3987, 3904, 3918, 4002, 3988
5843, 3904, 3918, 4002, 3988, 3905, 3919, 4003, 3989
5844, 3905, 3919, 4003, 3989, 3906, 3920, 4004, 3990
5845, 3906, 3920, 4004, 3990, 3907, 3921, 4005, 3991
5846, 3907, 3921, 4005, 3991, 3908, 3922, 4006, 3992
5847, 3908, 3922, 4006, 3992, 3909, 3923, 4007, 3993
5848, 3909, 3923, 4007, 3993, 3910, 3924, 4008, 3994
5849, 3910, 3924, 4008, 3994, 1746, 1747, 1753, 1752
5850, 1205, 1206, 1212, 1211, 3911, 3925, 4009, 3995
5851, 3911, 3925, 4009, 3995, 3912, 3926, 4010, 3996
5852, 3912, 3926, 4010, 3996, 3913, 3927, 4011, 3997
5853, 3913, 3927, 4011, 3997, 3914, 3928, 4012, 3998
5854, 3914, 3928, 4012, 3998, 3915, 3929, 4013, 3999
5855, 3915, 3929, 4013, 3999, 3916, 3930, 4014, 4000
5856, 3916, 3930, 4014, 4000, 3917, 3931, 4015, 4001
5857, 3917, 3931, 4015, 4001, 3918, 3932, 4016, 4002
5858, 3918, 3932, 4016, 4002, 3919, 3933, 4017, 4003
5859, 3919, 3933, 4017, 4003, 3920, 3934, 4018, 4004
5860, 3920, 3934, 4018, 4004, 3921, 3935, 4019, 4005
5861, 3921, 3935, 4019, 4005, 3922, 3936, 4020, 4006
5862, 3922, 3936, 4020, 4006, 3923, 3937, 4021, 4007
5863, 3923, 3937, 4021, 4007, 3924, 3938, 4022, 4008
5864, 3924, 3938, 4022, 4008, 1747, 1748, 1754, 1753
5865, 1206, 1207, 1213, 1212, 3925, 3939, 4023, 4009
5866, 3925, 3939, 4023, 4009, 3926, 3940, 4024, 4010
5867, 3926, 3940, 4024, 4010, 3927, 3941, 4025, 4011
5868, 3927, 3941, 4025, 4011, 3928, 3942, 4026, 4012
5869, 3928, 3942, 4026, 4012, 3929, 3943, 4027, 4013
5870, 3929, 3943, 4027, 4013, 3930, 3944, 4028, 4014
5871, 3930, 3944, 4028, 4014, 3931, 3945, 4029, 4015
5872, 3931, 3945, 4029, 4015, 3932, 3946, 4030, 4016
5873, 3932, 3946, 4030, 4016, 3933, 3947, 4031, 4017
5874, 3933, 3947, 4031, 4017, 3934, 3948, 4032, 4018
5875, 3934, 3948, 4032, 4018, 3935, 3949, 4033, 4019
5876, 3935, 3949, 4033, 4019, 3936, 3950, 4034, 4020
5877, 3936, 3950, 4034, 4020, 3937, 3951, 4035, 4021
5878, 3937, 3951, 4035, 4021, 3938, 3952, 4036, 4022
5879, 3938, 3952, 4036, 4022, 1748, 1749, 1755, 1754
5880, 1207, 1208, 1214, 1213, 3939, 3953, 4037, 4023
5881, 3939, 3953, 4037, 4023, 3940, 3954, 4038, 4024
5882, 3940, 3954, 4038, 4024, 3941, 3955, 4039, 4025
5883, 3941, 3955, 4039, 4025, 3942, 3956, 4040, 4026
5884, 3942, 3956, 4040, 4026, 3943, 3957, 4041, 4027
5885, 3943, 3957, 4041, 4027, 3944, 3958, 4042, 4028
5886, 3944, 3958, 4042, 4028, 3945, 3959, 4043, 4029
5887, 3945, 3959, 4043, 4029, 3946, 3960, 4044, 4030
5888, 3946, 3960, 4044, 4030, 3947, 3961, 4045, 4031
5889, 3947, 3961, 4045, 4031, 3948, 3962, 4046, 4032
5890, 3948, 3962, 4046, 4032, 3949, 3963, 4047, 4033
5891, 3949, 3963, 4047, 4033, 3950, 3964, 4048, 4034
5892, 3950, 3964, 4048, 4034, 3951, 3965, 4049, 4035
5893, 3951, 3965, 4049, 4035, 3952, 3966, 4050, 4036
5894, 3952, 3966, 4050, 4036, 1749, 1750, 1756, 1755
5895, 1208, 186, 187, 1214, 3953, 1507, 1521, 4037
5896, 3953, 1507, 1521, 4037, 3954, 1508, 1522, 4038
5897, 3954, 1508, 1522, 4038, 3955, 1509, 1523, 4039
5898, 3955, 1509, 1523, 4039, 3956, 1510, 1524, 4040
5899, 3956, 1510, 1524, 4040, 3957, 1511, 1525, 4041
5900, 3957, 1511, 1525, 4041, 3958, 1512, 1526, 4042
5901, 3958, 1512, 1526, 4042, 3959, 1513, 1527, 4043
5902, 3959, 1513, 1527, 4043, 3960, 1514, 1528, 4044
5903, 3960, 1514, 1528, 4044, 3961, 1515, 1529, 4045
5904, 3961, 1515, 1529, 4045, 3962, 1516, 1530, 4046
5905, 3962, 1516, 1530, 4046, 3963, 1517, 1531, 4047
5906, 3963, 1517, 1531, 4047, 3964, 1518, 1532, 4048
5907, 3964, 1518, 1532, 4048, 3965, 1519, 1533, 4049
5908, 3965, 1519, 1533, 4049, 3966, 1520, 1534, 4050
5909, 3966, 1520, 1534, 4050, 1750, 276, 277, 1756
5910, 170, 1209, 1215, 171, 1283, 3967, 4051, 1297
5911, 1283, 3967, 4051, 1297, 1284, 3968, 4052, 1298
5912, 1284, 3968, 4052, 1298, 1285, 3969, 4053, 1299
5913, 1285, 3969, 4053, 1299, 1286, 3970, 4054, 1300
5914, 1286, 3970, 4054, 1300, 1287, 3971, 4055, 1301
5915, 1287, 3971, 4055, 1301, 1288, 3972, 4056, 1302
5916, 1288, 3972, 4056, 1302, 1289, 3973, 4057, 1303
5917, 1289, 3973, 4057, 1303, 1290, 3974, 4058, 1304
5918, 1290, 3974, 4058, 1304, 1291, 3975, 4059, 1305
5919, 1291, 3975, 4059, 1305, 1292, 3976, 4060, 1306
5920, 1292, 3976, 4060, 1306, 1293, 3977, 4061, 1307
5921, 1293, 3977, 4061, 1307, 1294, 3978, 4062, 1308
5922, 1294, 3978, 4062, 1308, 1295, 3979, 4063, 1309
5923, 1295, 3979, 4063, 1309, 1296, 3980, 4064, 1310
5924, 1296, 3980, 4064, 1310, 232, 1751, 1757, 233
5925, 1209, 1210, 1216, 1215, 3967, 3981, 4065, 4051
5926, 3967, 3981, 4065, 4051, 3968, 3982, 4066, 4052
5927, 3968, 3982, 4066, 4052, 3969, 3983, 4067, 4053
5928, 3969, 3983, 4067, 4053, 3970, 3984, 4068, 4054
5929, 3970, 3984, 4068, 4054, 3971, 3985, 4069, 4055
5930, 3971, 3985, 4069, 4055, 3972, 3986, 4070, 4056
5931, 3972, 3986, 4070, 4056, 3973, 3987, 4071, 4057
5932, 3973, 3987, 4071, 4057, 3974, 3988, 4072, 4058
5933, 3974, 3988, 4072, 4058, 3975, 3989, 4073, 4059
5934, 3975, 3989, 4073, 4059, 3976, 3990, 4074, 4060
5935, 3976, 3990, 4074, 4060, 3977, 3991, 4075, 4061
5936, 3977, 3991, 4075, 4061, 3978, 3992, 4076, 4062
5937, 3978, 3992, 4076, 4062, 3979, 3993, 4077, 4063
5938, 3979, 3993, 4077, 4063, 3980, 3994, 4078, 4064
5939, 3980, 3994, 4078, 4064, 1751, 1752, 1758, 1757
5940, 1210, 1211, 1217, 1216, 3981, 3995, 4079, 4065
5941, 3981, 3995, 4079, 4065, 3982, 3996, 4080, 4066
5942, 3982, 3996, 4080, 4066, 3983, 3997, 4081, 4067
5943, 3983, 3997, 4081, 4067, 3984, 3998, 4082, 4068
5944, 3984, 3998, 4082, 4068, 3985, 3999, 4083, 4069
5945, 3985, 3999, 4083, 4069, 3986, 4000, 4084, 4070
5946, 3986, 4000, 4084, 4070, 3987, 4001, 4085, 4071
5947, 3987, 4001, 4085, 4071, 3988, 4002, 4086, 4072
5948, 3988, 4002, 4086, 4072, 3989, 4003, 4087, 4073
5949, 3989, 4003, 4087, 4073, 3990, 4004, 4088, 4074
5950, 3990, 4004, 4088, 4074, 3991, 4005, 4089, 4075
5951, 3991, 4005, 4089, 4075, 3992, 4006, 4090, 4076
5952, 3992, 4006, 4090, 4076, 3993, 4007, 4091, 4077
