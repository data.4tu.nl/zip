3050, 1.15, 0.5, 0.21428571428571
3051, 1.15, 0.42, 0.21428571428571
3052, 1.15, 0.34, 0.21428571428571
3053, 1.15, 0.26, 0.21428571428571
3054, 1.15, 0.18, 0.21428571428571
3055, 1.15, 1.22, 0.28571428571429
3056, 1.15, 1.14, 0.28571428571429
3057, 1.15, 1.06, 0.28571428571429
3058, 1.15, 0.98, 0.28571428571429
3059, 1.15, 0.9, 0.28571428571429
3060, 1.15, 0.82, 0.28571428571429
3061, 1.15, 0.74, 0.28571428571429
3062, 1.15, 0.66, 0.28571428571429
3063, 1.15, 0.58, 0.28571428571429
3064, 1.15, 0.5, 0.28571428571429
3065, 1.15, 0.42, 0.28571428571429
3066, 1.15, 0.34, 0.28571428571429
3067, 1.15, 0.26, 0.28571428571429
3068, 1.15, 0.18, 0.28571428571429
3069, 1.15, 1.22, 0.35714285714286
3070, 1.15, 1.14, 0.35714285714286
3071, 1.15, 1.06, 0.35714285714286
3072, 1.15, 0.98, 0.35714285714286
3073, 1.15, 0.9, 0.35714285714286
3074, 1.15, 0.82, 0.35714285714286
3075, 1.15, 0.74, 0.35714285714286
3076, 1.15, 0.66, 0.35714285714286
3077, 1.15, 0.58, 0.35714285714286
3078, 1.15, 0.5, 0.35714285714286
3079, 1.15, 0.42, 0.35714285714286
3080, 1.15, 0.34, 0.35714285714286
3081, 1.15, 0.26, 0.35714285714286
3082, 1.15, 0.18, 0.35714285714286
3083, 1.15, 1.22, 0.42857142857143
3084, 1.15, 1.14, 0.42857142857143
3085, 1.15, 1.06, 0.42857142857143
3086, 1.15, 0.98, 0.42857142857143
3087, 1.15, 0.9, 0.42857142857143
3088, 1.15, 0.82, 0.42857142857143
3089, 1.15, 0.74, 0.42857142857143
3090, 1.15, 0.66, 0.42857142857143
3091, 1.15, 0.58, 0.42857142857143
3092, 1.15, 0.5, 0.42857142857143
3093, 1.15, 0.42, 0.42857142857143
3094, 1.15, 0.34, 0.42857142857143
3095, 1.15, 0.26, 0.42857142857143
3096, 1.15, 0.18, 0.42857142857143
3097, 0.083333333333333, 0.18, -0.1
3098, 0.083333333333333, 0.26, -0.1
3099, 0.083333333333333, 0.34, -0.1
3100, 0.083333333333333, 0.42, -0.1
3101, 0.083333333333333, 0.5, -0.1
3102, 0.083333333333333, 0.58, -0.1
3103, 0.083333333333333, 0.66, -0.1
3104, 0.083333333333333, 0.74, -0.1
3105, 0.083333333333333, 0.82, -0.1
3106, 0.083333333333333, 0.9, -0.1
3107, 0.083333333333333, 0.98, -0.1
3108, 0.083333333333333, 1.06, -0.1
3109, 0.083333333333333, 1.14, -0.1
3110, 0.083333333333333, 1.22, -0.1
3111, 0.16666666666667, 0.18, -0.1
3112, 0.16666666666667, 0.26, -0.1
3113, 0.16666666666667, 0.34, -0.1
3114, 0.16666666666667, 0.42, -0.1
3115, 0.16666666666667, 0.5, -0.1
3116, 0.16666666666667, 0.58, -0.1
3117, 0.16666666666667, 0.66, -0.1
3118, 0.16666666666667, 0.74, -0.1
3119, 0.16666666666667, 0.82, -0.1
3120, 0.16666666666667, 0.9, -0.1
3121, 0.16666666666667, 0.98, -0.1
3122, 0.16666666666667, 1.06, -0.1
3123, 0.16666666666667, 1.14, -0.1
3124, 0.16666666666667, 1.22, -0.1
3125, 0.25, 0.18, -0.1
3126, 0.25, 0.26, -0.1
3127, 0.25, 0.34, -0.1
3128, 0.25, 0.42, -0.1
3129, 0.25, 0.5, -0.1
3130, 0.25, 0.58, -0.1
3131, 0.25, 0.66, -0.1
3132, 0.25, 0.74, -0.1
3133, 0.25, 0.82, -0.1
3134, 0.25, 0.9, -0.1
3135, 0.25, 0.98, -0.1
3136, 0.25, 1.06, -0.1
3137, 0.25, 1.14, -0.1
3138, 0.25, 1.22, -0.1
3139, 0.33333333333333, 0.18, -0.1
3140, 0.33333333333333, 0.26, -0.1
3141, 0.33333333333333, 0.34, -0.1
3142, 0.33333333333333, 0.42, -0.1
3143, 0.33333333333333, 0.5, -0.1
3144, 0.33333333333333, 0.58, -0.1
3145, 0.33333333333333, 0.66, -0.1
3146, 0.33333333333333, 0.74, -0.1
3147, 0.33333333333333, 0.82, -0.1
3148, 0.33333333333333, 0.9, -0.1
3149, 0.33333333333333, 0.98, -0.1
3150, 0.33333333333333, 1.06, -0.1
3151, 0.33333333333333, 1.14, -0.1
3152, 0.33333333333333, 1.22, -0.1
3153, 0.41666666666667, 0.18, -0.1
3154, 0.41666666666667, 0.26, -0.1
3155, 0.41666666666667, 0.34, -0.1
3156, 0.41666666666667, 0.42, -0.1
3157, 0.41666666666667, 0.5, -0.1
3158, 0.41666666666667, 0.58, -0.1
3159, 0.41666666666667, 0.66, -0.1
3160, 0.41666666666667, 0.74, -0.1
3161, 0.41666666666667, 0.82, -0.1
3162, 0.41666666666667, 0.9, -0.1
3163, 0.41666666666667, 0.98, -0.1
3164, 0.41666666666667, 1.06, -0.1
3165, 0.41666666666667, 1.14, -0.1
3166, 0.41666666666667, 1.22, -0.1
3167, 0.5, 0.18, -0.1
3168, 0.5, 0.26, -0.1
3169, 0.5, 0.34, -0.1
3170, 0.5, 0.42, -0.1
3171, 0.5, 0.5, -0.1
3172, 0.5, 0.58, -0.1
3173, 0.5, 0.66, -0.1
3174, 0.5, 0.74, -0.1
3175, 0.5, 0.82, -0.1
3176, 0.5, 0.9, -0.1
3177, 0.5, 0.98, -0.1
3178, 0.5, 1.06, -0.1
3179, 0.5, 1.14, -0.1
3180, 0.5, 1.22, -0.1
3181, 0.58333333333333, 0.18, -0.1
3182, 0.58333333333333, 0.26, -0.1
3183, 0.58333333333333, 0.34, -0.1
3184, 0.58333333333333, 0.42, -0.1
3185, 0.58333333333333, 0.5, -0.1
3186, 0.58333333333333, 0.58, -0.1
3187, 0.58333333333333, 0.66, -0.1
3188, 0.58333333333333, 0.74, -0.1
3189, 0.58333333333333, 0.82, -0.1
3190, 0.58333333333333, 0.9, -0.1
3191, 0.58333333333333, 0.98, -0.1
3192, 0.58333333333333, 1.06, -0.1
3193, 0.58333333333333, 1.14, -0.1
3194, 0.58333333333333, 1.22, -0.1
3195, 0.66666666666667, 0.18, -0.1
3196, 0.66666666666667, 0.26, -0.1
3197, 0.66666666666667, 0.34, -0.1
3198, 0.66666666666667, 0.42, -0.1
3199, 0.66666666666667, 0.5, -0.1
3200, 0.66666666666667, 0.58, -0.1
3201, 0.66666666666667, 0.66, -0.1
3202, 0.66666666666667, 0.74, -0.1
3203, 0.66666666666667, 0.82, -0.1
3204, 0.66666666666667, 0.9, -0.1
3205, 0.66666666666667, 0.98, -0.1
3206, 0.66666666666667, 1.06, -0.1
3207, 0.66666666666667, 1.14, -0.1
3208, 0.66666666666667, 1.22, -0.1
3209, 0.75, 0.18, -0.1
3210, 0.75, 0.26, -0.1
3211, 0.75, 0.34, -0.1
3212, 0.75, 0.42, -0.1
3213, 0.75, 0.5, -0.1
3214, 0.75, 0.58, -0.1
3215, 0.75, 0.66, -0.1
3216, 0.75, 0.74, -0.1
3217, 0.75, 0.82, -0.1
3218, 0.75, 0.9, -0.1
3219, 0.75, 0.98, -0.1
3220, 0.75, 1.06, -0.1
3221, 0.75, 1.14, -0.1
3222, 0.75, 1.22, -0.1
3223, 0.83333333333333, 0.18, -0.1
3224, 0.83333333333333, 0.26, -0.1
3225, 0.83333333333333, 0.34, -0.1
3226, 0.83333333333333, 0.42, -0.1
3227, 0.83333333333333, 0.5, -0.1
3228, 0.83333333333333, 0.58, -0.1
3229, 0.83333333333333, 0.66, -0.1
3230, 0.83333333333333, 0.74, -0.1
3231, 0.83333333333333, 0.82, -0.1
3232, 0.83333333333333, 0.9, -0.1
3233, 0.83333333333333, 0.98, -0.1
3234, 0.83333333333333, 1.06, -0.1
3235, 0.83333333333333, 1.14, -0.1
3236, 0.83333333333333, 1.22, -0.1
3237, 0.91666666666667, 0.18, -0.1
3238, 0.91666666666667, 0.26, -0.1
3239, 0.91666666666667, 0.34, -0.1
3240, 0.91666666666667, 0.42, -0.1
3241, 0.91666666666667, 0.5, -0.1
3242, 0.91666666666667, 0.58, -0.1
3243, 0.91666666666667, 0.66, -0.1
3244, 0.91666666666667, 0.74, -0.1
3245, 0.91666666666667, 0.82, -0.1
3246, 0.91666666666667, 0.9, -0.1
3247, 0.91666666666667, 0.98, -0.1
3248, 0.91666666666667, 1.06, -0.1
3249, 0.91666666666667, 1.14, -0.1
3250, 0.91666666666667, 1.22, -0.1
3251, 1.2833333333333, 1.22, -0.1
3252, 1.2833333333333, 1.14, -0.1
3253, 1.2833333333333, 1.06, -0.1
3254, 1.2833333333333, 0.98, -0.1
3255, 1.2833333333333, 0.9, -0.1
3256, 1.2833333333333, 0.82, -0.1
3257, 1.2833333333333, 0.74, -0.1
3258, 1.2833333333333, 0.66, -0.1
3259, 1.2833333333333, 0.58, -0.1
3260, 1.2833333333333, 0.5, -0.1
3261, 1.2833333333333, 0.42, -0.1
3262, 1.2833333333333, 0.34, -0.1
3263, 1.2833333333333, 0.26, -0.1
3264, 1.2833333333333, 0.18, -0.1
3265, 1.3666666666667, 1.22, -0.1
3266, 1.3666666666667, 1.14, -0.1
3267, 1.3666666666667, 1.06, -0.1
3268, 1.3666666666667, 0.98, -0.1
3269, 1.3666666666667, 0.9, -0.1
3270, 1.3666666666667, 0.82, -0.1
3271, 1.3666666666667, 0.74, -0.1
3272, 1.3666666666667, 0.66, -0.1
3273, 1.3666666666667, 0.58, -0.1
3274, 1.3666666666667, 0.5, -0.1
3275, 1.3666666666667, 0.42, -0.1
3276, 1.3666666666667, 0.34, -0.1
3277, 1.3666666666667, 0.26, -0.1
3278, 1.3666666666667, 0.18, -0.1
3279, 1.45, 1.22, -0.1
3280, 1.45, 1.14, -0.1
3281, 1.45, 1.06, -0.1
3282, 1.45, 0.98, -0.1
3283, 1.45, 0.9, -0.1
3284, 1.45, 0.82, -0.1
3285, 1.45, 0.74, -0.1
3286, 1.45, 0.66, -0.1
3287, 1.45, 0.58, -0.1
3288, 1.45, 0.5, -0.1
3289, 1.45, 0.42, -0.1
3290, 1.45, 0.34, -0.1
3291, 1.45, 0.26, -0.1
3292, 1.45, 0.18, -0.1
3293, 1.5333333333333, 1.22, -0.1
3294, 1.5333333333333, 1.14, -0.1
3295, 1.5333333333333, 1.06, -0.1
3296, 1.5333333333333, 0.98, -0.1
3297, 1.5333333333333, 0.9, -0.1
3298, 1.5333333333333, 0.82, -0.1
3299, 1.5333333333333, 0.74, -0.1
3300, 1.5333333333333, 0.66, -0.1
3301, 1.5333333333333, 0.58, -0.1
3302, 1.5333333333333, 0.5, -0.1
3303, 1.5333333333333, 0.42, -0.1
3304, 1.5333333333333, 0.34, -0.1
3305, 1.5333333333333, 0.26, -0.1
3306, 1.5333333333333, 0.18, -0.1
3307, 1.6166666666667, 1.22, -0.1
3308, 1.6166666666667, 1.14, -0.1
3309, 1.6166666666667, 1.06, -0.1
3310, 1.6166666666667, 0.98, -0.1
3311, 1.6166666666667, 0.9, -0.1
3312, 1.6166666666667, 0.82, -0.1
3313, 1.6166666666667, 0.74, -0.1
3314, 1.6166666666667, 0.66, -0.1
3315, 1.6166666666667, 0.58, -0.1
3316, 1.6166666666667, 0.5, -0.1
3317, 1.6166666666667, 0.42, -0.1
3318, 1.6166666666667, 0.34, -0.1
3319, 1.6166666666667, 0.26, -0.1
3320, 1.6166666666667, 0.18, -0.1
3321, 1.7, 1.22, -0.1
3322, 1.7, 1.14, -0.1
3323, 1.7, 1.06, -0.1
3324, 1.7, 0.98, -0.1
3325, 1.7, 0.9, -0.1
3326, 1.7, 0.82, -0.1
3327, 1.7, 0.74, -0.1
3328, 1.7, 0.66, -0.1
3329, 1.7, 0.58, -0.1
3330, 1.7, 0.5, -0.1
3331, 1.7, 0.42, -0.1
3332, 1.7, 0.34, -0.1
3333, 1.7, 0.26, -0.1
3334, 1.7, 0.18, -0.1
3335, 1.7833333333333, 1.22, -0.1
3336, 1.7833333333333, 1.14, -0.1
3337, 1.7833333333333, 1.06, -0.1
3338, 1.7833333333333, 0.98, -0.1
3339, 1.7833333333333, 0.9, -0.1
3340, 1.7833333333333, 0.82, -0.1
3341, 1.7833333333333, 0.74, -0.1
3342, 1.7833333333333, 0.66, -0.1
3343, 1.7833333333333, 0.58, -0.1
3344, 1.7833333333333, 0.5, -0.1
3345, 1.7833333333333, 0.42, -0.1
3346, 1.7833333333333, 0.34, -0.1
3347, 1.7833333333333, 0.26, -0.1
3348, 1.7833333333333, 0.18, -0.1
3349, 1.8666666666667, 1.22, -0.1
3350, 1.8666666666667, 1.14, -0.1
3351, 1.8666666666667, 1.06, -0.1
3352, 1.8666666666667, 0.98, -0.1
3353, 1.8666666666667, 0.9, -0.1
3354, 1.8666666666667, 0.82, -0.1
3355, 1.8666666666667, 0.74, -0.1
3356, 1.8666666666667, 0.66, -0.1
3357, 1.8666666666667, 0.58, -0.1
3358, 1.8666666666667, 0.5, -0.1
3359, 1.8666666666667, 0.42, -0.1
3360, 1.8666666666667, 0.34, -0.1
3361, 1.8666666666667, 0.26, -0.1
3362, 1.8666666666667, 0.18, -0.1
3363, 1.95, 1.22, -0.1
3364, 1.95, 1.14, -0.1
3365, 1.95, 1.06, -0.1
3366, 1.95, 0.98, -0.1
3367, 1.95, 0.9, -0.1
3368, 1.95, 0.82, -0.1
3369, 1.95, 0.74, -0.1
3370, 1.95, 0.66, -0.1
3371, 1.95, 0.58, -0.1
3372, 1.95, 0.5, -0.1
3373, 1.95, 0.42, -0.1
3374, 1.95, 0.34, -0.1
3375, 1.95, 0.26, -0.1
3376, 1.95, 0.18, -0.1
3377, 2.0333333333333, 1.22, -0.1
3378, 2.0333333333333, 1.14, -0.1
3379, 2.0333333333333, 1.06, -0.1
3380, 2.0333333333333, 0.98, -0.1
3381, 2.0333333333333, 0.9, -0.1
3382, 2.0333333333333, 0.82, -0.1
3383, 2.0333333333333, 0.74, -0.1
3384, 2.0333333333333, 0.66, -0.1
3385, 2.0333333333333, 0.58, -0.1
3386, 2.0333333333333, 0.5, -0.1
3387, 2.0333333333333, 0.42, -0.1
3388, 2.0333333333333, 0.34, -0.1
3389, 2.0333333333333, 0.26, -0.1
3390, 2.0333333333333, 0.18, -0.1
3391, 2.1166666666667, 1.22, -0.1
3392, 2.1166666666667, 1.14, -0.1
3393, 2.1166666666667, 1.06, -0.1
3394, 2.1166666666667, 0.98, -0.1
3395, 2.1166666666667, 0.9, -0.1
3396, 2.1166666666667, 0.82, -0.1
3397, 2.1166666666667, 0.74, -0.1
3398, 2.1166666666667, 0.66, -0.1
3399, 2.1166666666667, 0.58, -0.1
3400, 2.1166666666667, 0.5, -0.1
3401, 2.1166666666667, 0.42, -0.1
3402, 2.1166666666667, 0.34, -0.1
3403, 2.1166666666667, 0.26, -0.1
3404, 2.1166666666667, 0.18, -0.1
3405, 0.083333333333333, 1.5, 0
3406, 0.16666666666667, 1.5, 0
3407, 0.25, 1.5, 0
3408, 0.33333333333333, 1.5, 0
3409, 0.41666666666667, 1.5, 0
3410, 0.5, 1.5, 0
3411, 0.58333333333333, 1.5, 0
3412, 0.66666666666667, 1.5, 0
3413, 0.75, 1.5, 0
3414, 0.83333333333333, 1.5, 0
3415, 0.91666666666667, 1.5, 0
3416, 1, 1.5, 0.071428571428571
3417, 1, 1.5, 0.14285714285714
3418, 1, 1.5, 0.21428571428571
3419, 1, 1.5, 0.28571428571429
3420, 1, 1.5, 0.35714285714286
3421, 1, 1.5, 0.42857142857143
3422, 0.083333333333333, 1.5, 0.5
3423, 0.16666666666667, 1.5, 0.5
3424, 0.25, 1.5, 0.5
3425, 0.33333333333333, 1.5, 0.5
3426, 0.41666666666667, 1.5, 0.5
3427, 0.5, 1.5, 0.5
3428, 0.58333333333333, 1.5, 0.5
3429, 0.66666666666667, 1.5, 0.5
3430, 0.75, 1.5, 0.5
3431, 0.83333333333333, 1.5, 0.5
3432, 0.91666666666667, 1.5, 0.5
3433, 0, 1.5, 0.071428571428571
3434, 0, 1.5, 0.14285714285714
3435, 0, 1.5, 0.21428571428571
3436, 0, 1.5, 0.28571428571429
3437, 0, 1.5, 0.35714285714286
3438, 0, 1.5, 0.42857142857143
3439, 0.083333333333333, 1.6, 0.071428571428571
3440, 0.083333333333333, 1.6, 0.14285714285714
3441, 0.083333333333333, 1.6, 0.21428571428571
3442, 0.083333333333333, 1.6, 0.28571428571429
3443, 0.083333333333333, 1.6, 0.35714285714286
3444, 0.083333333333333, 1.6, 0.42857142857143
3445, 0.16666666666667, 1.6, 0.071428571428571
3446, 0.16666666666667, 1.6, 0.14285714285714
3447, 0.16666666666667, 1.6, 0.21428571428571
3448, 0.16666666666667, 1.6, 0.28571428571429
3449, 0.16666666666667, 1.6, 0.35714285714286
3450, 0.16666666666667, 1.6, 0.42857142857143
3451, 0.25, 1.6, 0.071428571428571
3452, 0.25, 1.6, 0.14285714285714
3453, 0.25, 1.6, 0.21428571428571
3454, 0.25, 1.6, 0.28571428571429
3455, 0.25, 1.6, 0.35714285714286
3456, 0.25, 1.6, 0.42857142857143
3457, 0.33333333333333, 1.6, 0.071428571428571
3458, 0.33333333333333, 1.6, 0.14285714285714
3459, 0.33333333333333, 1.6, 0.21428571428571
3460, 0.33333333333333, 1.6, 0.28571428571429
3461, 0.33333333333333, 1.6, 0.35714285714286
3462, 0.33333333333333, 1.6, 0.42857142857143
3463, 0.41666666666667, 1.6, 0.071428571428571
3464, 0.41666666666667, 1.6, 0.14285714285714
3465, 0.41666666666667, 1.6, 0.21428571428571
3466, 0.41666666666667, 1.6, 0.28571428571429
3467, 0.41666666666667, 1.6, 0.35714285714286
3468, 0.41666666666667, 1.6, 0.42857142857143
3469, 0.5, 1.6, 0.071428571428571
3470, 0.5, 1.6, 0.14285714285714
3471, 0.5, 1.6, 0.21428571428571
3472, 0.5, 1.6, 0.28571428571429
3473, 0.5, 1.6, 0.35714285714286
3474, 0.5, 1.6, 0.42857142857143
3475, 0.58333333333333, 1.6, 0.071428571428571
3476, 0.58333333333333, 1.6, 0.14285714285714
3477, 0.58333333333333, 1.6, 0.21428571428571
3478, 0.58333333333333, 1.6, 0.28571428571429
3479, 0.58333333333333, 1.6, 0.35714285714286
3480, 0.58333333333333, 1.6, 0.42857142857143
3481, 0.66666666666667, 1.6, 0.071428571428571
3482, 0.66666666666667, 1.6, 0.14285714285714
3483, 0.66666666666667, 1.6, 0.21428571428571
3484, 0.66666666666667, 1.6, 0.28571428571429
3485, 0.66666666666667, 1.6, 0.35714285714286
3486, 0.66666666666667, 1.6, 0.42857142857143
3487, 0.75, 1.6, 0.071428571428571
3488, 0.75, 1.6, 0.14285714285714
3489, 0.75, 1.6, 0.21428571428571
3490, 0.75, 1.6, 0.28571428571429
3491, 0.75, 1.6, 0.35714285714286
3492, 0.75, 1.6, 0.42857142857143
3493, 0.83333333333333, 1.6, 0.071428571428571
3494, 0.83333333333333, 1.6, 0.14285714285714
3495, 0.83333333333333, 1.6, 0.21428571428571
3496, 0.83333333333333, 1.6, 0.28571428571429
3497, 0.83333333333333, 1.6, 0.35714285714286
3498, 0.83333333333333, 1.6, 0.42857142857143
3499, 0.91666666666667, 1.6, 0.071428571428571
3500, 0.91666666666667, 1.6, 0.14285714285714
3501, 0.91666666666667, 1.6, 0.21428571428571
3502, 0.91666666666667, 1.6, 0.28571428571429
3503, 0.91666666666667, 1.6, 0.35714285714286
3504, 0.91666666666667, 1.6, 0.42857142857143
3505, 1.2, 1.5, 0.071428571428571
3506, 1.2, 1.5, 0.14285714285714
3507, 1.2, 1.5, 0.21428571428571
3508, 1.2, 1.5, 0.28571428571429
3509, 1.2, 1.5, 0.35714285714286
3510, 1.2, 1.5, 0.42857142857143
3511, 1.2833333333333, 1.5, 0.5
3512, 1.3666666666667, 1.5, 0.5
3513, 1.45, 1.5, 0.5
3514, 1.5333333333333, 1.5, 0.5
3515, 1.6166666666667, 1.5, 0.5
3516, 1.7, 1.5, 0.5
3517, 1.7833333333333, 1.5, 0.5
3518, 1.8666666666667, 1.5, 0.5
3519, 1.95, 1.5, 0.5
3520, 2.0333333333333, 1.5, 0.5
3521, 2.1166666666667, 1.5, 0.5
3522, 1.2833333333333, 1.5, 0
3523, 1.3666666666667, 1.5, 0
3524, 1.45, 1.5, 0
3525, 1.5333333333333, 1.5, 0
3526, 1.6166666666667, 1.5, 0
3527, 1.7, 1.5, 0
3528, 1.7833333333333, 1.5, 0
3529, 1.8666666666667, 1.5, 0
3530, 1.95, 1.5, 0
3531, 2.0333333333333, 1.5, 0
3532, 2.1166666666667, 1.5, 0
3533, 2.2, 1.5, 0.071428571428571
3534, 2.2, 1.5, 0.14285714285714
3535, 2.2, 1.5, 0.21428571428571
3536, 2.2, 1.5, 0.28571428571429
3537, 2.2, 1.5, 0.35714285714286
3538, 2.2, 1.5, 0.42857142857143
3539, 1.2833333333333, 1.6, 0.071428571428571
3540, 1.3666666666667, 1.6, 0.071428571428571
3541, 1.45, 1.6, 0.071428571428571
3542, 1.5333333333333, 1.6, 0.071428571428571
3543, 1.6166666666667, 1.6, 0.071428571428571
3544, 1.7, 1.6, 0.071428571428571
3545, 1.7833333333333, 1.6, 0.071428571428571
3546, 1.8666666666667, 1.6, 0.071428571428571
3547, 1.95, 1.6, 0.071428571428571
3548, 2.0333333333333, 1.6, 0.071428571428571
3549, 2.1166666666667, 1.6, 0.071428571428571
3550, 1.2833333333333, 1.6, 0.14285714285714
3551, 1.3666666666667, 1.6, 0.14285714285714
3552, 1.45, 1.6, 0.14285714285714
3553, 1.5333333333333, 1.6, 0.14285714285714
3554, 1.6166666666667, 1.6, 0.14285714285714
3555, 1.7, 1.6, 0.14285714285714
3556, 1.7833333333333, 1.6, 0.14285714285714
3557, 1.8666666666667, 1.6, 0.14285714285714
3558, 1.95, 1.6, 0.14285714285714
3559, 2.0333333333333, 1.6, 0.14285714285714
3560, 2.1166666666667, 1.6, 0.14285714285714
3561, 1.2833333333333, 1.6, 0.21428571428571
3562, 1.3666666666667, 1.6, 0.21428571428571
3563, 1.45, 1.6, 0.21428571428571
3564, 1.5333333333333, 1.6, 0.21428571428571
3565, 1.6166666666667, 1.6, 0.21428571428571
3566, 1.7, 1.6, 0.21428571428571
3567, 1.7833333333333, 1.6, 0.21428571428571
3568, 1.8666666666667, 1.6, 0.21428571428571
3569, 1.95, 1.6, 0.21428571428571
3570, 2.0333333333333, 1.6, 0.21428571428571
3571, 2.1166666666667, 1.6, 0.21428571428571
3572, 1.2833333333333, 1.6, 0.28571428571429
3573, 1.3666666666667, 1.6, 0.28571428571429
3574, 1.45, 1.6, 0.28571428571429
3575, 1.5333333333333, 1.6, 0.28571428571429
3576, 1.6166666666667, 1.6, 0.28571428571429
3577, 1.7, 1.6, 0.28571428571429
3578, 1.7833333333333, 1.6, 0.28571428571429
3579, 1.8666666666667, 1.6, 0.28571428571429
3580, 1.95, 1.6, 0.28571428571429
3581, 2.0333333333333, 1.6, 0.28571428571429
3582, 2.1166666666667, 1.6, 0.28571428571429
3583, 1.2833333333333, 1.6, 0.35714285714286
3584, 1.3666666666667, 1.6, 0.35714285714286
3585, 1.45, 1.6, 0.35714285714286
3586, 1.5333333333333, 1.6, 0.35714285714286
3587, 1.6166666666667, 1.6, 0.35714285714286
3588, 1.7, 1.6, 0.35714285714286
3589, 1.7833333333333, 1.6, 0.35714285714286
3590, 1.8666666666667, 1.6, 0.35714285714286
3591, 1.95, 1.6, 0.35714285714286
3592, 2.0333333333333, 1.6, 0.35714285714286
3593, 2.1166666666667, 1.6, 0.35714285714286
3594, 1.2833333333333, 1.6, 0.42857142857143
3595, 1.3666666666667, 1.6, 0.42857142857143
3596, 1.45, 1.6, 0.42857142857143
3597, 1.5333333333333, 1.6, 0.42857142857143
3598, 1.6166666666667, 1.6, 0.42857142857143
3599, 1.7, 1.6, 0.42857142857143
3600, 1.7833333333333, 1.6, 0.42857142857143
3601, 1.8666666666667, 1.6, 0.42857142857143
3602, 1.95, 1.6, 0.42857142857143
3603, 2.0333333333333, 1.6, 0.42857142857143
3604, 2.1166666666667, 1.6, 0.42857142857143
3605, 0.083333333333333, -0.1, 0
3606, 0.16666666666667, -0.1, 0
3607, 0.25, -0.1, 0
3608, 0.33333333333333, -0.1, 0
3609, 0.41666666666667, -0.1, 0
3610, 0.5, -0.1, 0
3611, 0.58333333333333, -0.1, 0
3612, 0.66666666666667, -0.1, 0
3613, 0.75, -0.1, 0
3614, 0.83333333333333, -0.1, 0
3615, 0.91666666666667, -0.1, 0
3616, 1, -0.1, 0.071428571428571
3617, 1, -0.1, 0.14285714285714
3618, 1, -0.1, 0.21428571428571
3619, 1, -0.1, 0.28571428571429
3620, 1, -0.1, 0.35714285714286
3621, 1, -0.1, 0.42857142857143
3622, 0.083333333333333, -0.1, 0.5
3623, 0.16666666666667, -0.1, 0.5
3624, 0.25, -0.1, 0.5
3625, 0.33333333333333, -0.1, 0.5
3626, 0.41666666666667, -0.1, 0.5
3627, 0.5, -0.1, 0.5
3628, 0.58333333333333, -0.1, 0.5
3629, 0.66666666666667, -0.1, 0.5
3630, 0.75, -0.1, 0.5
3631, 0.83333333333333, -0.1, 0.5
3632, 0.91666666666667, -0.1, 0.5
3633, 0, -0.1, 0.071428571428571
3634, 0, -0.1, 0.14285714285714
3635, 0, -0.1, 0.21428571428571
3636, 0, -0.1, 0.28571428571429
3637, 0, -0.1, 0.35714285714286
3638, 0, -0.1, 0.42857142857143
3639, 0.083333333333333, -0.2, 0.071428571428571
3640, 0.083333333333333, -0.2, 0.14285714285714
3641, 0.083333333333333, -0.2, 0.21428571428571
3642, 0.083333333333333, -0.2, 0.28571428571429
3643, 0.083333333333333, -0.2, 0.35714285714286
3644, 0.083333333333333, -0.2, 0.42857142857143
3645, 0.16666666666667, -0.2, 0.071428571428571
3646, 0.16666666666667, -0.2, 0.14285714285714
3647, 0.16666666666667, -0.2, 0.21428571428571
3648, 0.16666666666667, -0.2, 0.28571428571429
3649, 0.16666666666667, -0.2, 0.35714285714286
3650, 0.16666666666667, -0.2, 0.42857142857143
3651, 0.25, -0.2, 0.071428571428571
3652, 0.25, -0.2, 0.14285714285714
3653, 0.25, -0.2, 0.21428571428571
3654, 0.25, -0.2, 0.28571428571429
3655, 0.25, -0.2, 0.35714285714286
3656, 0.25, -0.2, 0.42857142857143
3657, 0.33333333333333, -0.2, 0.071428571428571
3658, 0.33333333333333, -0.2, 0.14285714285714
3659, 0.33333333333333, -0.2, 0.21428571428571
3660, 0.33333333333333, -0.2, 0.28571428571429
3661, 0.33333333333333, -0.2, 0.35714285714286
3662, 0.33333333333333, -0.2, 0.42857142857143
3663, 0.41666666666667, -0.2, 0.071428571428571
3664, 0.41666666666667, -0.2, 0.14285714285714
3665, 0.41666666666667, -0.2, 0.21428571428571
3666, 0.41666666666667, -0.2, 0.28571428571429
3667, 0.41666666666667, -0.2, 0.35714285714286
3668, 0.41666666666667, -0.2, 0.42857142857143
3669, 0.5, -0.2, 0.071428571428571
3670, 0.5, -0.2, 0.14285714285714
3671, 0.5, -0.2, 0.21428571428571
3672, 0.5, -0.2, 0.28571428571429
3673, 0.5, -0.2, 0.35714285714286
3674, 0.5, -0.2, 0.42857142857143
3675, 0.58333333333333, -0.2, 0.071428571428571
3676, 0.58333333333333, -0.2, 0.14285714285714
3677, 0.58333333333333, -0.2, 0.21428571428571
3678, 0.58333333333333, -0.2, 0.28571428571429
3679, 0.58333333333333, -0.2, 0.35714285714286
3680, 0.58333333333333, -0.2, 0.42857142857143
3681, 0.66666666666667, -0.2, 0.071428571428571
3682, 0.66666666666667, -0.2, 0.14285714285714
3683, 0.66666666666667, -0.2, 0.21428571428571
3684, 0.66666666666667, -0.2, 0.28571428571429
3685, 0.66666666666667, -0.2, 0.35714285714286
3686, 0.66666666666667, -0.2, 0.42857142857143
3687, 0.75, -0.2, 0.071428571428571
3688, 0.75, -0.2, 0.14285714285714
3689, 0.75, -0.2, 0.21428571428571
3690, 0.75, -0.2, 0.28571428571429
3691, 0.75, -0.2, 0.35714285714286
3692, 0.75, -0.2, 0.42857142857143
3693, 0.83333333333333, -0.2, 0.071428571428571
3694, 0.83333333333333, -0.2, 0.14285714285714
3695, 0.83333333333333, -0.2, 0.21428571428571
3696, 0.83333333333333, -0.2, 0.28571428571429
3697, 0.83333333333333, -0.2, 0.35714285714286
3698, 0.83333333333333, -0.2, 0.42857142857143
3699, 0.91666666666667, -0.2, 0.071428571428571
3700, 0.91666666666667, -0.2, 0.14285714285714
3701, 0.91666666666667, -0.2, 0.21428571428571
3702, 0.91666666666667, -0.2, 0.28571428571429
3703, 0.91666666666667, -0.2, 0.35714285714286
3704, 0.91666666666667, -0.2, 0.42857142857143
3705, -0.1, -0.1, 0.071428571428571
3706, -0.1, -0.1, 0.14285714285714
3707, -0.1, -0.1, 0.21428571428571
3708, -0.1, -0.1, 0.28571428571429
3709, -0.1, -0.1, 0.35714285714286
3710, -0.1, -0.1, 0.42857142857143
3711, 1.2833333333333, -0.1, 0.5
3712, 1.3666666666667, -0.1, 0.5
3713, 1.45, -0.1, 0.5
3714, 1.5333333333333, -0.1, 0.5
3715, 1.6166666666667, -0.1, 0.5
3716, 1.7, -0.1, 0.5
3717, 1.7833333333333, -0.1, 0.5
3718, 1.8666666666667, -0.1, 0.5
3719, 1.95, -0.1, 0.5
3720, 2.0333333333333, -0.1, 0.5
3721, 2.1166666666667, -0.1, 0.5
3722, 1.2833333333333, -0.1, 0
3723, 1.3666666666667, -0.1, 0
3724, 1.45, -0.1, 0
3725, 1.5333333333333, -0.1, 0
3726, 1.6166666666667, -0.1, 0
3727, 1.7, -0.1, 0
3728, 1.7833333333333, -0.1, 0
3729, 1.8666666666667, -0.1, 0
3730, 1.95, -0.1, 0
3731, 2.0333333333333, -0.1, 0
3732, 2.1166666666667, -0.1, 0
3733, 1.2, -0.1, 0.071428571428571
3734, 1.2, -0.1, 0.14285714285714
3735, 1.2, -0.1, 0.21428571428571
3736, 1.2, -0.1, 0.28571428571429
3737, 1.2, -0.1, 0.35714285714286
3738, 1.2, -0.1, 0.42857142857143
3739, 2.2, -0.1, 0.071428571428571
3740, 2.2, -0.1, 0.14285714285714
3741, 2.2, -0.1, 0.21428571428571
3742, 2.2, -0.1, 0.28571428571429
3743, 2.2, -0.1, 0.35714285714286
3744, 2.2, -0.1, 0.42857142857143
3745, 1.2833333333333, -0.2, 0.071428571428571
3746, 1.3666666666667, -0.2, 0.071428571428571
3747, 1.45, -0.2, 0.071428571428571
3748, 1.5333333333333, -0.2, 0.071428571428571
3749, 1.6166666666667, -0.2, 0.071428571428571
3750, 1.7, -0.2, 0.071428571428571
3751, 1.7833333333333, -0.2, 0.071428571428571
3752, 1.8666666666667, -0.2, 0.071428571428571
3753, 1.95, -0.2, 0.071428571428571
3754, 2.0333333333333, -0.2, 0.071428571428571
3755, 2.1166666666667, -0.2, 0.071428571428571
3756, 1.2833333333333, -0.2, 0.14285714285714
3757, 1.3666666666667, -0.2, 0.14285714285714
3758, 1.45, -0.2, 0.14285714285714
3759, 1.5333333333333, -0.2, 0.14285714285714
3760, 1.6166666666667, -0.2, 0.14285714285714
3761, 1.7, -0.2, 0.14285714285714
3762, 1.7833333333333, -0.2, 0.14285714285714
3763, 1.8666666666667, -0.2, 0.14285714285714
3764, 1.95, -0.2, 0.14285714285714
3765, 2.0333333333333, -0.2, 0.14285714285714
3766, 2.1166666666667, -0.2, 0.14285714285714
3767, 1.2833333333333, -0.2, 0.21428571428571
3768, 1.3666666666667, -0.2, 0.21428571428571
3769, 1.45, -0.2, 0.21428571428571
3770, 1.5333333333333, -0.2, 0.21428571428571
3771, 1.6166666666667, -0.2, 0.21428571428571
3772, 1.7, -0.2, 0.21428571428571
3773, 1.7833333333333, -0.2, 0.21428571428571
3774, 1.8666666666667, -0.2, 0.21428571428571
3775, 1.95, -0.2, 0.21428571428571
3776, 2.0333333333333, -0.2, 0.21428571428571
3777, 2.1166666666667, -0.2, 0.21428571428571
3778, 1.2833333333333, -0.2, 0.28571428571429
3779, 1.3666666666667, -0.2, 0.28571428571429
3780, 1.45, -0.2, 0.28571428571429
3781, 1.5333333333333, -0.2, 0.28571428571429
3782, 1.6166666666667, -0.2, 0.28571428571429
3783, 1.7, -0.2, 0.28571428571429
3784, 1.7833333333333, -0.2, 0.28571428571429
3785, 1.8666666666667, -0.2, 0.28571428571429
3786, 1.95, -0.2, 0.28571428571429
3787, 2.0333333333333, -0.2, 0.28571428571429
3788, 2.1166666666667, -0.2, 0.28571428571429
3789, 1.2833333333333, -0.2, 0.35714285714286
3790, 1.3666666666667, -0.2, 0.35714285714286
3791, 1.45, -0.2, 0.35714285714286
3792, 1.5333333333333, -0.2, 0.35714285714286
3793, 1.6166666666667, -0.2, 0.35714285714286
3794, 1.7, -0.2, 0.35714285714286
3795, 1.7833333333333, -0.2, 0.35714285714286
3796, 1.8666666666667, -0.2, 0.35714285714286
3797, 1.95, -0.2, 0.35714285714286
3798, 2.0333333333333, -0.2, 0.35714285714286
3799, 2.1166666666667, -0.2, 0.35714285714286
3800, 1.2833333333333, -0.2, 0.42857142857143
3801, 1.3666666666667, -0.2, 0.42857142857143
3802, 1.45, -0.2, 0.42857142857143
3803, 1.5333333333333, -0.2, 0.42857142857143
3804, 1.6166666666667, -0.2, 0.42857142857143
3805, 1.7, -0.2, 0.42857142857143
3806, 1.7833333333333, -0.2, 0.42857142857143
3807, 1.8666666666667, -0.2, 0.42857142857143
3808, 1.95, -0.2, 0.42857142857143
3809, 2.0333333333333, -0.2, 0.42857142857143
3810, 2.1166666666667, -0.2, 0.42857142857143
3811, 2.3, -0.1, 0.071428571428571
3812, 2.3, -0.1, 0.14285714285714
3813, 2.3, -0.1, 0.21428571428571
3814, 2.3, -0.1, 0.28571428571429
3815, 2.3, -0.1, 0.35714285714286
3816, 2.3, -0.1, 0.42857142857143
3817, 0.083333333333333, 0.025, 0.071428571428571
3818, 0.16666666666667, 0.025, 0.071428571428571
3819, 0.25, 0.025, 0.071428571428571
3820, 0.33333333333333, 0.025, 0.071428571428571
3821, 0.41666666666667, 0.025, 0.071428571428571
3822, 0.5, 0.025, 0.071428571428571
3823, 0.58333333333333, 0.025, 0.071428571428571
3824, 0.66666666666667, 0.025, 0.071428571428571
3825, 0.75, 0.025, 0.071428571428571
3826, 0.83333333333333, 0.025, 0.071428571428571
3827, 0.91666666666667, 0.025, 0.071428571428571
3828, 0.083333333333333, 0.025, 0.14285714285714
3829, 0.16666666666667, 0.025, 0.14285714285714
3830, 0.25, 0.025, 0.14285714285714
3831, 0.33333333333333, 0.025, 0.14285714285714
3832, 0.41666666666667, 0.025, 0.14285714285714
3833, 0.5, 0.025, 0.14285714285714
3834, 0.58333333333333, 0.025, 0.14285714285714
3835, 0.66666666666667, 0.025, 0.14285714285714
3836, 0.75, 0.025, 0.14285714285714
3837, 0.83333333333333, 0.025, 0.14285714285714
3838, 0.91666666666667, 0.025, 0.14285714285714
3839, 0.083333333333333, 0.025, 0.21428571428571
3840, 0.16666666666667, 0.025, 0.21428571428571
3841, 0.25, 0.025, 0.21428571428571
3842, 0.33333333333333, 0.025, 0.21428571428571
3843, 0.41666666666667, 0.025, 0.21428571428571
3844, 0.5, 0.025, 0.21428571428571
3845, 0.58333333333333, 0.025, 0.21428571428571
3846, 0.66666666666667, 0.025, 0.21428571428571
3847, 0.75, 0.025, 0.21428571428571
3848, 0.83333333333333, 0.025, 0.21428571428571
3849, 0.91666666666667, 0.025, 0.21428571428571
3850, 0.083333333333333, 0.025, 0.28571428571429
3851, 0.16666666666667, 0.025, 0.28571428571429
3852, 0.25, 0.025, 0.28571428571429
3853, 0.33333333333333, 0.025, 0.28571428571429
3854, 0.41666666666667, 0.025, 0.28571428571429
3855, 0.5, 0.025, 0.28571428571429
3856, 0.58333333333333, 0.025, 0.28571428571429
3857, 0.66666666666667, 0.025, 0.28571428571429
3858, 0.75, 0.025, 0.28571428571429
3859, 0.83333333333333, 0.025, 0.28571428571429
3860, 0.91666666666667, 0.025, 0.28571428571429
3861, 0.083333333333333, 0.025, 0.35714285714286
3862, 0.16666666666667, 0.025, 0.35714285714286
3863, 0.25, 0.025, 0.35714285714286
3864, 0.33333333333333, 0.025, 0.35714285714286
3865, 0.41666666666667, 0.025, 0.35714285714286
3866, 0.5, 0.025, 0.35714285714286
3867, 0.58333333333333, 0.025, 0.35714285714286
3868, 0.66666666666667, 0.025, 0.35714285714286
3869, 0.75, 0.025, 0.35714285714286
3870, 0.83333333333333, 0.025, 0.35714285714286
3871, 0.91666666666667, 0.025, 0.35714285714286
3872, 0.083333333333333, 0.025, 0.42857142857143
3873, 0.16666666666667, 0.025, 0.42857142857143
3874, 0.25, 0.025, 0.42857142857143
3875, 0.33333333333333, 0.025, 0.42857142857143
3876, 0.41666666666667, 0.025, 0.42857142857143
3877, 0.5, 0.025, 0.42857142857143
3878, 0.58333333333333, 0.025, 0.42857142857143
3879, 0.66666666666667, 0.025, 0.42857142857143
3880, 0.75, 0.025, 0.42857142857143
3881, 0.83333333333333, 0.025, 0.42857142857143
3882, 0.91666666666667, 0.025, 0.42857142857143
3883, 0.083333333333333, 0.18, 0.071428571428571
3884, 0.083333333333333, 0.26, 0.071428571428571
3885, 0.083333333333333, 0.34, 0.071428571428571
3886, 0.083333333333333, 0.42, 0.071428571428571
3887, 0.083333333333333, 0.5, 0.071428571428571
3888, 0.083333333333333, 0.58, 0.071428571428571
3889, 0.083333333333333, 0.66, 0.071428571428571
3890, 0.083333333333333, 0.74, 0.071428571428571
3891, 0.083333333333333, 0.82, 0.071428571428571
3892, 0.083333333333333, 0.9, 0.071428571428571
3893, 0.083333333333333, 0.98, 0.071428571428571
3894, 0.083333333333333, 1.06, 0.071428571428571
3895, 0.083333333333333, 1.14, 0.071428571428571
3896, 0.083333333333333, 1.22, 0.071428571428571
3897, 0.083333333333333, 0.18, 0.14285714285714
3898, 0.083333333333333, 0.26, 0.14285714285714
3899, 0.083333333333333, 0.34, 0.14285714285714
3900, 0.083333333333333, 0.42, 0.14285714285714
3901, 0.083333333333333, 0.5, 0.14285714285714
3902, 0.083333333333333, 0.58, 0.14285714285714
3903, 0.083333333333333, 0.66, 0.14285714285714
3904, 0.083333333333333, 0.74, 0.14285714285714
3905, 0.083333333333333, 0.82, 0.14285714285714
3906, 0.083333333333333, 0.9, 0.14285714285714
3907, 0.083333333333333, 0.98, 0.14285714285714
3908, 0.083333333333333, 1.06, 0.14285714285714
3909, 0.083333333333333, 1.14, 0.14285714285714
3910, 0.083333333333333, 1.22, 0.14285714285714
3911, 0.083333333333333, 0.18, 0.21428571428571
3912, 0.083333333333333, 0.26, 0.21428571428571
3913, 0.083333333333333, 0.34, 0.21428571428571
3914, 0.083333333333333, 0.42, 0.21428571428571
3915, 0.083333333333333, 0.5, 0.21428571428571
3916, 0.083333333333333, 0.58, 0.21428571428571
3917, 0.083333333333333, 0.66, 0.21428571428571
3918, 0.083333333333333, 0.74, 0.21428571428571
3919, 0.083333333333333, 0.82, 0.21428571428571
3920, 0.083333333333333, 0.9, 0.21428571428571
3921, 0.083333333333333, 0.98, 0.21428571428571
3922, 0.083333333333333, 1.06, 0.21428571428571
3923, 0.083333333333333, 1.14, 0.21428571428571
3924, 0.083333333333333, 1.22, 0.21428571428571
3925, 0.083333333333333, 0.18, 0.28571428571429
3926, 0.083333333333333, 0.26, 0.28571428571429
3927, 0.083333333333333, 0.34, 0.28571428571429
3928, 0.083333333333333, 0.42, 0.28571428571429
3929, 0.083333333333333, 0.5, 0.28571428571429
3930, 0.083333333333333, 0.58, 0.28571428571429
3931, 0.083333333333333, 0.66, 0.28571428571429
3932, 0.083333333333333, 0.74, 0.28571428571429
3933, 0.083333333333333, 0.82, 0.28571428571429
3934, 0.083333333333333, 0.9, 0.28571428571429
3935, 0.083333333333333, 0.98, 0.28571428571429
3936, 0.083333333333333, 1.06, 0.28571428571429
3937, 0.083333333333333, 1.14, 0.28571428571429
3938, 0.083333333333333, 1.22, 0.28571428571429
3939, 0.083333333333333, 0.18, 0.35714285714286
3940, 0.083333333333333, 0.26, 0.35714285714286
3941, 0.083333333333333, 0.34, 0.35714285714286
3942, 0.083333333333333, 0.42, 0.35714285714286
3943, 0.083333333333333, 0.5, 0.35714285714286
3944, 0.083333333333333, 0.58, 0.35714285714286
3945, 0.083333333333333, 0.66, 0.35714285714286
3946, 0.083333333333333, 0.74, 0.35714285714286
3947, 0.083333333333333, 0.82, 0.35714285714286
3948, 0.083333333333333, 0.9, 0.35714285714286
3949, 0.083333333333333, 0.98, 0.35714285714286
3950, 0.083333333333333, 1.06, 0.35714285714286
3951, 0.083333333333333, 1.14, 0.35714285714286
3952, 0.083333333333333, 1.22, 0.35714285714286
3953, 0.083333333333333, 0.18, 0.42857142857143
3954, 0.083333333333333, 0.26, 0.42857142857143
3955, 0.083333333333333, 0.34, 0.42857142857143
3956, 0.083333333333333, 0.42, 0.42857142857143
3957, 0.083333333333333, 0.5, 0.42857142857143
3958, 0.083333333333333, 0.58, 0.42857142857143
3959, 0.083333333333333, 0.66, 0.42857142857143
3960, 0.083333333333333, 0.74, 0.42857142857143
3961, 0.083333333333333, 0.82, 0.42857142857143
3962, 0.083333333333333, 0.9, 0.42857142857143
3963, 0.083333333333333, 0.98, 0.42857142857143
3964, 0.083333333333333, 1.06, 0.42857142857143
3965, 0.083333333333333, 1.14, 0.42857142857143
3966, 0.083333333333333, 1.22, 0.42857142857143
3967, 0.16666666666667, 0.18, 0.071428571428571
3968, 0.16666666666667, 0.26, 0.071428571428571
3969, 0.16666666666667, 0.34, 0.071428571428571
3970, 0.16666666666667, 0.42, 0.071428571428571
3971, 0.16666666666667, 0.5, 0.071428571428571
3972, 0.16666666666667, 0.58, 0.071428571428571
3973, 0.16666666666667, 0.66, 0.071428571428571
3974, 0.16666666666667, 0.74, 0.071428571428571
3975, 0.16666666666667, 0.82, 0.071428571428571
3976, 0.16666666666667, 0.9, 0.071428571428571
3977, 0.16666666666667, 0.98, 0.071428571428571
3978, 0.16666666666667, 1.06, 0.071428571428571
3979, 0.16666666666667, 1.14, 0.071428571428571
3980, 0.16666666666667, 1.22, 0.071428571428571
3981, 0.16666666666667, 0.18, 0.14285714285714
3982, 0.16666666666667, 0.26, 0.14285714285714
3983, 0.16666666666667, 0.34, 0.14285714285714
3984, 0.16666666666667, 0.42, 0.14285714285714
3985, 0.16666666666667, 0.5, 0.14285714285714
3986, 0.16666666666667, 0.58, 0.14285714285714
3987, 0.16666666666667, 0.66, 0.14285714285714
3988, 0.16666666666667, 0.74, 0.14285714285714
3989, 0.16666666666667, 0.82, 0.14285714285714
3990, 0.16666666666667, 0.9, 0.14285714285714
3991, 0.16666666666667, 0.98, 0.14285714285714
3992, 0.16666666666667, 1.06, 0.14285714285714
3993, 0.16666666666667, 1.14, 0.14285714285714
3994, 0.16666666666667, 1.22, 0.14285714285714
3995, 0.16666666666667, 0.18, 0.21428571428571
3996, 0.16666666666667, 0.26, 0.21428571428571
3997, 0.16666666666667, 0.34, 0.21428571428571
3998, 0.16666666666667, 0.42, 0.21428571428571
3999, 0.16666666666667, 0.5, 0.21428571428571
4000, 0.16666666666667, 0.58, 0.21428571428571
4001, 0.16666666666667, 0.66, 0.21428571428571
4002, 0.16666666666667, 0.74, 0.21428571428571
4003, 0.16666666666667, 0.82, 0.21428571428571
4004, 0.16666666666667, 0.9, 0.21428571428571
4005, 0.16666666666667, 0.98, 0.21428571428571
4006, 0.16666666666667, 1.06, 0.21428571428571
4007, 0.16666666666667, 1.14, 0.21428571428571
4008, 0.16666666666667, 1.22, 0.21428571428571
4009, 0.16666666666667, 0.18, 0.28571428571429
4010, 0.16666666666667, 0.26, 0.28571428571429
4011, 0.16666666666667, 0.34, 0.28571428571429
4012, 0.16666666666667, 0.42, 0.28571428571429
4013, 0.16666666666667, 0.5, 0.28571428571429
4014, 0.16666666666667, 0.58, 0.28571428571429
4015, 0.16666666666667, 0.66, 0.28571428571429
4016, 0.16666666666667, 0.74, 0.28571428571429
4017, 0.16666666666667, 0.82, 0.28571428571429
4018, 0.16666666666667, 0.9, 0.28571428571429
4019, 0.16666666666667, 0.98, 0.28571428571429
4020, 0.16666666666667, 1.06, 0.28571428571429
4021, 0.16666666666667, 1.14, 0.28571428571429
4022, 0.16666666666667, 1.22, 0.28571428571429
4023, 0.16666666666667, 0.18, 0.35714285714286
4024, 0.16666666666667, 0.26, 0.35714285714286
4025, 0.16666666666667, 0.34, 0.35714285714286
4026, 0.16666666666667, 0.42, 0.35714285714286
4027, 0.16666666666667, 0.5, 0.35714285714286
4028, 0.16666666666667, 0.58, 0.35714285714286
4029, 0.16666666666667, 0.66, 0.35714285714286
4030, 0.16666666666667, 0.74, 0.35714285714286
4031, 0.16666666666667, 0.82, 0.35714285714286
4032, 0.16666666666667, 0.9, 0.35714285714286
4033, 0.16666666666667, 0.98, 0.35714285714286
4034, 0.16666666666667, 1.06, 0.35714285714286
4035, 0.16666666666667, 1.14, 0.35714285714286
4036, 0.16666666666667, 1.22, 0.35714285714286
4037, 0.16666666666667, 0.18, 0.42857142857143
4038, 0.16666666666667, 0.26, 0.42857142857143
4039, 0.16666666666667, 0.34, 0.42857142857143
4040, 0.16666666666667, 0.42, 0.42857142857143
4041, 0.16666666666667, 0.5, 0.42857142857143
4042, 0.16666666666667, 0.58, 0.42857142857143
4043, 0.16666666666667, 0.66, 0.42857142857143
4044, 0.16666666666667, 0.74, 0.42857142857143
4045, 0.16666666666667, 0.82, 0.42857142857143
4046, 0.16666666666667, 0.9, 0.42857142857143
4047, 0.16666666666667, 0.98, 0.42857142857143
4048, 0.16666666666667, 1.06, 0.42857142857143
4049, 0.16666666666667, 1.14, 0.42857142857143
4050, 0.16666666666667, 1.22, 0.42857142857143
4051, 0.25, 0.18, 0.071428571428571
4052, 0.25, 0.26, 0.071428571428571
4053, 0.25, 0.34, 0.071428571428571
4054, 0.25, 0.42, 0.071428571428571
4055, 0.25, 0.5, 0.071428571428571
4056, 0.25, 0.58, 0.071428571428571
4057, 0.25, 0.66, 0.071428571428571
4058, 0.25, 0.74, 0.071428571428571
4059, 0.25, 0.82, 0.071428571428571
4060, 0.25, 0.9, 0.071428571428571
4061, 0.25, 0.98, 0.071428571428571
4062, 0.25, 1.06, 0.071428571428571
4063, 0.25, 1.14, 0.071428571428571
4064, 0.25, 1.22, 0.071428571428571
4065, 0.25, 0.18, 0.14285714285714
4066, 0.25, 0.26, 0.14285714285714
4067, 0.25, 0.34, 0.14285714285714
4068, 0.25, 0.42, 0.14285714285714
4069, 0.25, 0.5, 0.14285714285714
4070, 0.25, 0.58, 0.14285714285714
4071, 0.25, 0.66, 0.14285714285714
4072, 0.25, 0.74, 0.14285714285714
4073, 0.25, 0.82, 0.14285714285714
4074, 0.25, 0.9, 0.14285714285714
4075, 0.25, 0.98, 0.14285714285714
4076, 0.25, 1.06, 0.14285714285714
4077, 0.25, 1.14, 0.14285714285714
4078, 0.25, 1.22, 0.14285714285714
4079, 0.25, 0.18, 0.21428571428571
4080, 0.25, 0.26, 0.21428571428571
4081, 0.25, 0.34, 0.21428571428571
4082, 0.25, 0.42, 0.21428571428571
4083, 0.25, 0.5, 0.21428571428571
4084, 0.25, 0.58, 0.21428571428571
4085, 0.25, 0.66, 0.21428571428571
4086, 0.25, 0.74, 0.21428571428571
4087, 0.25, 0.82, 0.21428571428571
4088, 0.25, 0.9, 0.21428571428571
4089, 0.25, 0.98, 0.21428571428571
4090, 0.25, 1.06, 0.21428571428571
4091, 0.25, 1.14, 0.21428571428571
4092, 0.25, 1.22, 0.21428571428571
4093, 0.25, 0.18, 0.28571428571429
4094, 0.25, 0.26, 0.28571428571429
4095, 0.25, 0.34, 0.28571428571429
4096, 0.25, 0.42, 0.28571428571429
4097, 0.25, 0.5, 0.28571428571429
4098, 0.25, 0.58, 0.28571428571429
4099, 0.25, 0.66, 0.28571428571429
4100, 0.25, 0.74, 0.28571428571429
4101, 0.25, 0.82, 0.28571428571429
4102, 0.25, 0.9, 0.28571428571429
4103, 0.25, 0.98, 0.28571428571429
4104, 0.25, 1.06, 0.28571428571429
4105, 0.25, 1.14, 0.28571428571429
4106, 0.25, 1.22, 0.28571428571429
4107, 0.25, 0.18, 0.35714285714286
4108, 0.25, 0.26, 0.35714285714286
4109, 0.25, 0.34, 0.35714285714286
4110, 0.25, 0.42, 0.35714285714286
4111, 0.25, 0.5, 0.35714285714286
4112, 0.25, 0.58, 0.35714285714286
4113, 0.25, 0.66, 0.35714285714286
4114, 0.25, 0.74, 0.35714285714286
4115, 0.25, 0.82, 0.35714285714286
4116, 0.25, 0.9, 0.35714285714286
4117, 0.25, 0.98, 0.35714285714286
4118, 0.25, 1.06, 0.35714285714286
4119, 0.25, 1.14, 0.35714285714286
4120, 0.25, 1.22, 0.35714285714286
4121, 0.25, 0.18, 0.42857142857143
4122, 0.25, 0.26, 0.42857142857143
4123, 0.25, 0.34, 0.42857142857143
4124, 0.25, 0.42, 0.42857142857143
4125, 0.25, 0.5, 0.42857142857143
4126, 0.25, 0.58, 0.42857142857143
4127, 0.25, 0.66, 0.42857142857143
4128, 0.25, 0.74, 0.42857142857143
4129, 0.25, 0.82, 0.42857142857143
4130, 0.25, 0.9, 0.42857142857143
4131, 0.25, 0.98, 0.42857142857143
4132, 0.25, 1.06, 0.42857142857143
4133, 0.25, 1.14, 0.42857142857143
4134, 0.25, 1.22, 0.42857142857143
4135, 0.33333333333333, 0.18, 0.071428571428571
4136, 0.33333333333333, 0.26, 0.071428571428571
4137, 0.33333333333333, 0.34, 0.071428571428571
4138, 0.33333333333333, 0.42, 0.071428571428571
4139, 0.33333333333333, 0.5, 0.071428571428571
4140, 0.33333333333333, 0.58, 0.071428571428571
4141, 0.33333333333333, 0.66, 0.071428571428571
4142, 0.33333333333333, 0.74, 0.071428571428571
4143, 0.33333333333333, 0.82, 0.071428571428571
4144, 0.33333333333333, 0.9, 0.071428571428571
4145, 0.33333333333333, 0.98, 0.071428571428571
4146, 0.33333333333333, 1.06, 0.071428571428571
4147, 0.33333333333333, 1.14, 0.071428571428571
4148, 0.33333333333333, 1.22, 0.071428571428571
4149, 0.33333333333333, 0.18, 0.14285714285714
4150, 0.33333333333333, 0.26, 0.14285714285714
4151, 0.33333333333333, 0.34, 0.14285714285714
4152, 0.33333333333333, 0.42, 0.14285714285714
4153, 0.33333333333333, 0.5, 0.14285714285714
4154, 0.33333333333333, 0.58, 0.14285714285714
4155, 0.33333333333333, 0.66, 0.14285714285714
4156, 0.33333333333333, 0.74, 0.14285714285714
4157, 0.33333333333333, 0.82, 0.14285714285714
4158, 0.33333333333333, 0.9, 0.14285714285714
4159, 0.33333333333333, 0.98, 0.14285714285714
4160, 0.33333333333333, 1.06, 0.14285714285714
4161, 0.33333333333333, 1.14, 0.14285714285714
4162, 0.33333333333333, 1.22, 0.14285714285714
4163, 0.33333333333333, 0.18, 0.21428571428571
4164, 0.33333333333333, 0.26, 0.21428571428571
4165, 0.33333333333333, 0.34, 0.21428571428571
4166, 0.33333333333333, 0.42, 0.21428571428571
4167, 0.33333333333333, 0.5, 0.21428571428571
4168, 0.33333333333333, 0.58, 0.21428571428571
4169, 0.33333333333333, 0.66, 0.21428571428571
4170, 0.33333333333333, 0.74, 0.21428571428571
4171, 0.33333333333333, 0.82, 0.21428571428571
4172, 0.33333333333333, 0.9, 0.21428571428571
4173, 0.33333333333333, 0.98, 0.21428571428571
4174, 0.33333333333333, 1.06, 0.21428571428571
4175, 0.33333333333333, 1.14, 0.21428571428571
4176, 0.33333333333333, 1.22, 0.21428571428571
4177, 0.33333333333333, 0.18, 0.28571428571429
4178, 0.33333333333333, 0.26, 0.28571428571429
4179, 0.33333333333333, 0.34, 0.28571428571429
4180, 0.33333333333333, 0.42, 0.28571428571429
4181, 0.33333333333333, 0.5, 0.28571428571429
4182, 0.33333333333333, 0.58, 0.28571428571429
4183, 0.33333333333333, 0.66, 0.28571428571429
4184, 0.33333333333333, 0.74, 0.28571428571429
4185, 0.33333333333333, 0.82, 0.28571428571429
4186, 0.33333333333333, 0.9, 0.28571428571429
4187, 0.33333333333333, 0.98, 0.28571428571429
4188, 0.33333333333333, 1.06, 0.28571428571429
4189, 0.33333333333333, 1.14, 0.28571428571429
4190, 0.33333333333333, 1.22, 0.28571428571429
4191, 0.33333333333333, 0.18, 0.35714285714286
4192, 0.33333333333333, 0.26, 0.35714285714286
4193, 0.33333333333333, 0.34, 0.35714285714286
4194, 0.33333333333333, 0.42, 0.35714285714286
4195, 0.33333333333333, 0.5, 0.35714285714286
4196, 0.33333333333333, 0.58, 0.35714285714286
4197, 0.33333333333333, 0.66, 0.35714285714286
4198, 0.33333333333333, 0.74, 0.35714285714286
4199, 0.33333333333333, 0.82, 0.35714285714286
4200, 0.33333333333333, 0.9, 0.35714285714286
4201, 0.33333333333333, 0.98, 0.35714285714286
4202, 0.33333333333333, 1.06, 0.35714285714286
4203, 0.33333333333333, 1.14, 0.35714285714286
4204, 0.33333333333333, 1.22, 0.35714285714286
4205, 0.33333333333333, 0.18, 0.42857142857143
4206, 0.33333333333333, 0.26, 0.42857142857143
4207, 0.33333333333333, 0.34, 0.42857142857143
4208, 0.33333333333333, 0.42, 0.42857142857143
4209, 0.33333333333333, 0.5, 0.42857142857143
4210, 0.33333333333333, 0.58, 0.42857142857143
4211, 0.33333333333333, 0.66, 0.42857142857143
4212, 0.33333333333333, 0.74, 0.42857142857143
4213, 0.33333333333333, 0.82, 0.42857142857143
4214, 0.33333333333333, 0.9, 0.42857142857143
4215, 0.33333333333333, 0.98, 0.42857142857143
4216, 0.33333333333333, 1.06, 0.42857142857143
4217, 0.33333333333333, 1.14, 0.42857142857143
4218, 0.33333333333333, 1.22, 0.42857142857143
4219, 0.41666666666667, 0.18, 0.071428571428571
4220, 0.41666666666667, 0.26, 0.071428571428571
4221, 0.41666666666667, 0.34, 0.071428571428571
4222, 0.41666666666667, 0.42, 0.071428571428571
4223, 0.41666666666667, 0.5, 0.071428571428571
4224, 0.41666666666667, 0.58, 0.071428571428571
4225, 0.41666666666667, 0.66, 0.071428571428571
4226, 0.41666666666667, 0.74, 0.071428571428571
4227, 0.41666666666667, 0.82, 0.071428571428571
4228, 0.41666666666667, 0.9, 0.071428571428571
4229, 0.41666666666667, 0.98, 0.071428571428571
4230, 0.41666666666667, 1.06, 0.071428571428571
4231, 0.41666666666667, 1.14, 0.071428571428571
4232, 0.41666666666667, 1.22, 0.071428571428571
4233, 0.41666666666667, 0.18, 0.14285714285714
4234, 0.41666666666667, 0.26, 0.14285714285714
4235, 0.41666666666667, 0.34, 0.14285714285714
4236, 0.41666666666667, 0.42, 0.14285714285714
4237, 0.41666666666667, 0.5, 0.14285714285714
4238, 0.41666666666667, 0.58, 0.14285714285714
4239, 0.41666666666667, 0.66, 0.14285714285714
4240, 0.41666666666667, 0.74, 0.14285714285714
4241, 0.41666666666667, 0.82, 0.14285714285714
4242, 0.41666666666667, 0.9, 0.14285714285714
4243, 0.41666666666667, 0.98, 0.14285714285714
4244, 0.41666666666667, 1.06, 0.14285714285714
4245, 0.41666666666667, 1.14, 0.14285714285714
4246, 0.41666666666667, 1.22, 0.14285714285714
4247, 0.41666666666667, 0.18, 0.21428571428571
4248, 0.41666666666667, 0.26, 0.21428571428571
4249, 0.41666666666667, 0.34, 0.21428571428571
4250, 0.41666666666667, 0.42, 0.21428571428571
4251, 0.41666666666667, 0.5, 0.21428571428571
4252, 0.41666666666667, 0.58, 0.21428571428571
4253, 0.41666666666667, 0.66, 0.21428571428571
4254, 0.41666666666667, 0.74, 0.21428571428571
4255, 0.41666666666667, 0.82, 0.21428571428571
4256, 0.41666666666667, 0.9, 0.21428571428571
4257, 0.41666666666667, 0.98, 0.21428571428571
4258, 0.41666666666667, 1.06, 0.21428571428571
4259, 0.41666666666667, 1.14, 0.21428571428571
4260, 0.41666666666667, 1.22, 0.21428571428571
4261, 0.41666666666667, 0.18, 0.28571428571429
4262, 0.41666666666667, 0.26, 0.28571428571429
4263, 0.41666666666667, 0.34, 0.28571428571429
4264, 0.41666666666667, 0.42, 0.28571428571429
4265, 0.41666666666667, 0.5, 0.28571428571429
4266, 0.41666666666667, 0.58, 0.28571428571429
4267, 0.41666666666667, 0.66, 0.28571428571429
4268, 0.41666666666667, 0.74, 0.28571428571429
4269, 0.41666666666667, 0.82, 0.28571428571429
4270, 0.41666666666667, 0.9, 0.28571428571429
4271, 0.41666666666667, 0.98, 0.28571428571429
4272, 0.41666666666667, 1.06, 0.28571428571429
4273, 0.41666666666667, 1.14, 0.28571428571429
4274, 0.41666666666667, 1.22, 0.28571428571429
4275, 0.41666666666667, 0.18, 0.35714285714286
4276, 0.41666666666667, 0.26, 0.35714285714286
4277, 0.41666666666667, 0.34, 0.35714285714286
4278, 0.41666666666667, 0.42, 0.35714285714286
4279, 0.41666666666667, 0.5, 0.35714285714286
4280, 0.41666666666667, 0.58, 0.35714285714286
4281, 0.41666666666667, 0.66, 0.35714285714286
4282, 0.41666666666667, 0.74, 0.35714285714286
4283, 0.41666666666667, 0.82, 0.35714285714286
4284, 0.41666666666667, 0.9, 0.35714285714286
4285, 0.41666666666667, 0.98, 0.35714285714286
4286, 0.41666666666667, 1.06, 0.35714285714286
4287, 0.41666666666667, 1.14, 0.35714285714286
4288, 0.41666666666667, 1.22, 0.35714285714286
4289, 0.41666666666667, 0.18, 0.42857142857143
4290, 0.41666666666667, 0.26, 0.42857142857143
4291, 0.41666666666667, 0.34, 0.42857142857143
4292, 0.41666666666667, 0.42, 0.42857142857143
4293, 0.41666666666667, 0.5, 0.42857142857143
4294, 0.41666666666667, 0.58, 0.42857142857143
4295, 0.41666666666667, 0.66, 0.42857142857143
4296, 0.41666666666667, 0.74, 0.42857142857143
4297, 0.41666666666667, 0.82, 0.42857142857143
4298, 0.41666666666667, 0.9, 0.42857142857143
4299, 0.41666666666667, 0.98, 0.42857142857143
4300, 0.41666666666667, 1.06, 0.42857142857143
4301, 0.41666666666667, 1.14, 0.42857142857143
4302, 0.41666666666667, 1.22, 0.42857142857143
4303, 0.5, 0.18, 0.071428571428571
4304, 0.5, 0.26, 0.071428571428571
4305, 0.5, 0.34, 0.071428571428571
4306, 0.5, 0.42, 0.071428571428571
4307, 0.5, 0.5, 0.071428571428571
4308, 0.5, 0.58, 0.071428571428571
4309, 0.5, 0.66, 0.071428571428571
4310, 0.5, 0.74, 0.071428571428571
4311, 0.5, 0.82, 0.071428571428571
4312, 0.5, 0.9, 0.071428571428571
4313, 0.5, 0.98, 0.071428571428571
4314, 0.5, 1.06, 0.071428571428571
4315, 0.5, 1.14, 0.071428571428571
4316, 0.5, 1.22, 0.071428571428571
4317, 0.5, 0.18, 0.14285714285714
4318, 0.5, 0.26, 0.14285714285714
4319, 0.5, 0.34, 0.14285714285714
4320, 0.5, 0.42, 0.14285714285714
4321, 0.5, 0.5, 0.14285714285714
4322, 0.5, 0.58, 0.14285714285714
4323, 0.5, 0.66, 0.14285714285714
4324, 0.5, 0.74, 0.14285714285714
4325, 0.5, 0.82, 0.14285714285714
4326, 0.5, 0.9, 0.14285714285714
4327, 0.5, 0.98, 0.14285714285714
4328, 0.5, 1.06, 0.14285714285714
4329, 0.5, 1.14, 0.14285714285714
4330, 0.5, 1.22, 0.14285714285714
4331, 0.5, 0.18, 0.21428571428571
4332, 0.5, 0.26, 0.21428571428571
4333, 0.5, 0.34, 0.21428571428571
4334, 0.5, 0.42, 0.21428571428571
4335, 0.5, 0.5, 0.21428571428571
4336, 0.5, 0.58, 0.21428571428571
4337, 0.5, 0.66, 0.21428571428571
4338, 0.5, 0.74, 0.21428571428571
4339, 0.5, 0.82, 0.21428571428571
4340, 0.5, 0.9, 0.21428571428571
4341, 0.5, 0.98, 0.21428571428571
4342, 0.5, 1.06, 0.21428571428571
4343, 0.5, 1.14, 0.21428571428571
4344, 0.5, 1.22, 0.21428571428571
4345, 0.5, 0.18, 0.28571428571429
4346, 0.5, 0.26, 0.28571428571429
4347, 0.5, 0.34, 0.28571428571429
4348, 0.5, 0.42, 0.28571428571429
4349, 0.5, 0.5, 0.28571428571429
4350, 0.5, 0.58, 0.28571428571429
4351, 0.5, 0.66, 0.28571428571429
4352, 0.5, 0.74, 0.28571428571429
4353, 0.5, 0.82, 0.28571428571429
4354, 0.5, 0.9, 0.28571428571429
4355, 0.5, 0.98, 0.28571428571429
4356, 0.5, 1.06, 0.28571428571429
4357, 0.5, 1.14, 0.28571428571429
4358, 0.5, 1.22, 0.28571428571429
4359, 0.5, 0.18, 0.35714285714286
4360, 0.5, 0.26, 0.35714285714286
4361, 0.5, 0.34, 0.35714285714286
4362, 0.5, 0.42, 0.35714285714286
4363, 0.5, 0.5, 0.35714285714286
4364, 0.5, 0.58, 0.35714285714286
4365, 0.5, 0.66, 0.35714285714286
4366, 0.5, 0.74, 0.35714285714286
4367, 0.5, 0.82, 0.35714285714286
4368, 0.5, 0.9, 0.35714285714286
4369, 0.5, 0.98, 0.35714285714286
4370, 0.5, 1.06, 0.35714285714286
4371, 0.5, 1.14, 0.35714285714286
4372, 0.5, 1.22, 0.35714285714286
4373, 0.5, 0.18, 0.42857142857143
4374, 0.5, 0.26, 0.42857142857143
4375, 0.5, 0.34, 0.42857142857143
4376, 0.5, 0.42, 0.42857142857143
4377, 0.5, 0.5, 0.42857142857143
4378, 0.5, 0.58, 0.42857142857143
4379, 0.5, 0.66, 0.42857142857143
4380, 0.5, 0.74, 0.42857142857143
4381, 0.5, 0.82, 0.42857142857143
4382, 0.5, 0.9, 0.42857142857143
4383, 0.5, 0.98, 0.42857142857143
4384, 0.5, 1.06, 0.42857142857143
4385, 0.5, 1.14, 0.42857142857143
4386, 0.5, 1.22, 0.42857142857143
4387, 0.58333333333333, 0.18, 0.071428571428571
4388, 0.58333333333333, 0.26, 0.071428571428571
4389, 0.58333333333333, 0.34, 0.071428571428571
4390, 0.58333333333333, 0.42, 0.071428571428571
4391, 0.58333333333333, 0.5, 0.071428571428571
4392, 0.58333333333333, 0.58, 0.071428571428571
4393, 0.58333333333333, 0.66, 0.071428571428571
4394, 0.58333333333333, 0.74, 0.071428571428571
4395, 0.58333333333333, 0.82, 0.071428571428571
4396, 0.58333333333333, 0.9, 0.071428571428571
4397, 0.58333333333333, 0.98, 0.071428571428571
4398, 0.58333333333333, 1.06, 0.071428571428571
4399, 0.58333333333333, 1.14, 0.071428571428571
4400, 0.58333333333333, 1.22, 0.071428571428571
4401, 0.58333333333333, 0.18, 0.14285714285714
4402, 0.58333333333333, 0.26, 0.14285714285714
4403, 0.58333333333333, 0.34, 0.14285714285714
4404, 0.58333333333333, 0.42, 0.14285714285714
4405, 0.58333333333333, 0.5, 0.14285714285714
4406, 0.58333333333333, 0.58, 0.14285714285714
4407, 0.58333333333333, 0.66, 0.14285714285714
4408, 0.58333333333333, 0.74, 0.14285714285714
4409, 0.58333333333333, 0.82, 0.14285714285714
4410, 0.58333333333333, 0.9, 0.14285714285714
4411, 0.58333333333333, 0.98, 0.14285714285714
4412, 0.58333333333333, 1.06, 0.14285714285714
4413, 0.58333333333333, 1.14, 0.14285714285714
4414, 0.58333333333333, 1.22, 0.14285714285714
4415, 0.58333333333333, 0.18, 0.21428571428571
4416, 0.58333333333333, 0.26, 0.21428571428571
4417, 0.58333333333333, 0.34, 0.21428571428571
4418, 0.58333333333333, 0.42, 0.21428571428571
4419, 0.58333333333333, 0.5, 0.21428571428571
4420, 0.58333333333333, 0.58, 0.21428571428571
4421, 0.58333333333333, 0.66, 0.21428571428571
4422, 0.58333333333333, 0.74, 0.21428571428571
4423, 0.58333333333333, 0.82, 0.21428571428571
4424, 0.58333333333333, 0.9, 0.21428571428571
4425, 0.58333333333333, 0.98, 0.21428571428571
4426, 0.58333333333333, 1.06, 0.21428571428571
4427, 0.58333333333333, 1.14, 0.21428571428571
4428, 0.58333333333333, 1.22, 0.21428571428571
4429, 0.58333333333333, 0.18, 0.28571428571429
4430, 0.58333333333333, 0.26, 0.28571428571429
4431, 0.58333333333333, 0.34, 0.28571428571429
4432, 0.58333333333333, 0.42, 0.28571428571429
4433, 0.58333333333333, 0.5, 0.28571428571429
4434, 0.58333333333333, 0.58, 0.28571428571429
4435, 0.58333333333333, 0.66, 0.28571428571429
4436, 0.58333333333333, 0.74, 0.28571428571429
4437, 0.58333333333333, 0.82, 0.28571428571429
4438, 0.58333333333333, 0.9, 0.28571428571429
4439, 0.58333333333333, 0.98, 0.28571428571429
4440, 0.58333333333333, 1.06, 0.28571428571429
4441, 0.58333333333333, 1.14, 0.28571428571429
4442, 0.58333333333333, 1.22, 0.28571428571429
4443, 0.58333333333333, 0.18, 0.35714285714286
4444, 0.58333333333333, 0.26, 0.35714285714286
4445, 0.58333333333333, 0.34, 0.35714285714286
4446, 0.58333333333333, 0.42, 0.35714285714286
4447, 0.58333333333333, 0.5, 0.35714285714286
4448, 0.58333333333333, 0.58, 0.35714285714286
4449, 0.58333333333333, 0.66, 0.35714285714286
4450, 0.58333333333333, 0.74, 0.35714285714286
4451, 0.58333333333333, 0.82, 0.35714285714286
4452, 0.58333333333333, 0.9, 0.35714285714286
4453, 0.58333333333333, 0.98, 0.35714285714286
4454, 0.58333333333333, 1.06, 0.35714285714286
4455, 0.58333333333333, 1.14, 0.35714285714286
4456, 0.58333333333333, 1.22, 0.35714285714286
4457, 0.58333333333333, 0.18, 0.42857142857143
4458, 0.58333333333333, 0.26, 0.42857142857143
4459, 0.58333333333333, 0.34, 0.42857142857143
4460, 0.58333333333333, 0.42, 0.42857142857143
4461, 0.58333333333333, 0.5, 0.42857142857143
4462, 0.58333333333333, 0.58, 0.42857142857143
4463, 0.58333333333333, 0.66, 0.42857142857143
4464, 0.58333333333333, 0.74, 0.42857142857143
4465, 0.58333333333333, 0.82, 0.42857142857143
4466, 0.58333333333333, 0.9, 0.42857142857143
4467, 0.58333333333333, 0.98, 0.42857142857143
4468, 0.58333333333333, 1.06, 0.42857142857143
4469, 0.58333333333333, 1.14, 0.42857142857143
4470, 0.58333333333333, 1.22, 0.42857142857143
4471, 0.66666666666667, 0.18, 0.071428571428571
4472, 0.66666666666667, 0.26, 0.071428571428571
4473, 0.66666666666667, 0.34, 0.071428571428571
4474, 0.66666666666667, 0.42, 0.071428571428571
4475, 0.66666666666667, 0.5, 0.071428571428571
4476, 0.66666666666667, 0.58, 0.071428571428571
4477, 0.66666666666667, 0.66, 0.071428571428571
4478, 0.66666666666667, 0.74, 0.071428571428571
4479, 0.66666666666667, 0.82, 0.071428571428571
4480, 0.66666666666667, 0.9, 0.071428571428571
4481, 0.66666666666667, 0.98, 0.071428571428571
4482, 0.66666666666667, 1.06, 0.071428571428571
4483, 0.66666666666667, 1.14, 0.071428571428571
4484, 0.66666666666667, 1.22, 0.071428571428571
4485, 0.66666666666667, 0.18, 0.14285714285714
4486, 0.66666666666667, 0.26, 0.14285714285714
4487, 0.66666666666667, 0.34, 0.14285714285714
4488, 0.66666666666667, 0.42, 0.14285714285714
4489, 0.66666666666667, 0.5, 0.14285714285714
4490, 0.66666666666667, 0.58, 0.14285714285714
4491, 0.66666666666667, 0.66, 0.14285714285714
4492, 0.66666666666667, 0.74, 0.14285714285714
4493, 0.66666666666667, 0.82, 0.14285714285714
4494, 0.66666666666667, 0.9, 0.14285714285714
4495, 0.66666666666667, 0.98, 0.14285714285714
4496, 0.66666666666667, 1.06, 0.14285714285714
4497, 0.66666666666667, 1.14, 0.14285714285714
4498, 0.66666666666667, 1.22, 0.14285714285714
4499, 0.66666666666667, 0.18, 0.21428571428571
4500, 0.66666666666667, 0.26, 0.21428571428571
4501, 0.66666666666667, 0.34, 0.21428571428571
4502, 0.66666666666667, 0.42, 0.21428571428571
4503, 0.66666666666667, 0.5, 0.21428571428571
4504, 0.66666666666667, 0.58, 0.21428571428571
4505, 0.66666666666667, 0.66, 0.21428571428571
4506, 0.66666666666667, 0.74, 0.21428571428571
4507, 0.66666666666667, 0.82, 0.21428571428571
4508, 0.66666666666667, 0.9, 0.21428571428571
4509, 0.66666666666667, 0.98, 0.21428571428571
4510, 0.66666666666667, 1.06, 0.21428571428571
4511, 0.66666666666667, 1.14, 0.21428571428571
4512, 0.66666666666667, 1.22, 0.21428571428571
4513, 0.66666666666667, 0.18, 0.28571428571429
4514, 0.66666666666667, 0.26, 0.28571428571429
4515, 0.66666666666667, 0.34, 0.28571428571429
4516, 0.66666666666667, 0.42, 0.28571428571429
4517, 0.66666666666667, 0.5, 0.28571428571429
4518, 0.66666666666667, 0.58, 0.28571428571429
4519, 0.66666666666667, 0.66, 0.28571428571429
4520, 0.66666666666667, 0.74, 0.28571428571429
4521, 0.66666666666667, 0.82, 0.28571428571429
4522, 0.66666666666667, 0.9, 0.28571428571429
4523, 0.66666666666667, 0.98, 0.28571428571429
4524, 0.66666666666667, 1.06, 0.28571428571429
4525, 0.66666666666667, 1.14, 0.28571428571429
4526, 0.66666666666667, 1.22, 0.28571428571429
4527, 0.66666666666667, 0.18, 0.35714285714286
4528, 0.66666666666667, 0.26, 0.35714285714286
4529, 0.66666666666667, 0.34, 0.35714285714286
4530, 0.66666666666667, 0.42, 0.35714285714286
4531, 0.66666666666667, 0.5, 0.35714285714286
4532, 0.66666666666667, 0.58, 0.35714285714286
4533, 0.66666666666667, 0.66, 0.35714285714286
4534, 0.66666666666667, 0.74, 0.35714285714286
4535, 0.66666666666667, 0.82, 0.35714285714286
4536, 0.66666666666667, 0.9, 0.35714285714286
4537, 0.66666666666667, 0.98, 0.35714285714286
4538, 0.66666666666667, 1.06, 0.35714285714286
4539, 0.66666666666667, 1.14, 0.35714285714286
4540, 0.66666666666667, 1.22, 0.35714285714286
4541, 0.66666666666667, 0.18, 0.42857142857143
4542, 0.66666666666667, 0.26, 0.42857142857143
4543, 0.66666666666667, 0.34, 0.42857142857143
4544, 0.66666666666667, 0.42, 0.42857142857143
4545, 0.66666666666667, 0.5, 0.42857142857143
4546, 0.66666666666667, 0.58, 0.42857142857143
4547, 0.66666666666667, 0.66, 0.42857142857143
4548, 0.66666666666667, 0.74, 0.42857142857143
4549, 0.66666666666667, 0.82, 0.42857142857143
4550, 0.66666666666667, 0.9, 0.42857142857143
4551, 0.66666666666667, 0.98, 0.42857142857143
4552, 0.66666666666667, 1.06, 0.42857142857143
4553, 0.66666666666667, 1.14, 0.42857142857143
4554, 0.66666666666667, 1.22, 0.42857142857143
4555, 0.75, 0.18, 0.071428571428571
4556, 0.75, 0.26, 0.071428571428571
4557, 0.75, 0.34, 0.071428571428571
4558, 0.75, 0.42, 0.071428571428571
4559, 0.75, 0.5, 0.071428571428571
4560, 0.75, 0.58, 0.071428571428571
4561, 0.75, 0.66, 0.071428571428571
4562, 0.75, 0.74, 0.071428571428571
4563, 0.75, 0.82, 0.071428571428571
4564, 0.75, 0.9, 0.071428571428571
4565, 0.75, 0.98, 0.071428571428571
4566, 0.75, 1.06, 0.071428571428571
4567, 0.75, 1.14, 0.071428571428571
4568, 0.75, 1.22, 0.071428571428571
4569, 0.75, 0.18, 0.14285714285714
4570, 0.75, 0.26, 0.14285714285714
4571, 0.75, 0.34, 0.14285714285714
4572, 0.75, 0.42, 0.14285714285714
4573, 0.75, 0.5, 0.14285714285714
4574, 0.75, 0.58, 0.14285714285714
4575, 0.75, 0.66, 0.14285714285714
4576, 0.75, 0.74, 0.14285714285714
4577, 0.75, 0.82, 0.14285714285714
4578, 0.75, 0.9, 0.14285714285714
4579, 0.75, 0.98, 0.14285714285714
4580, 0.75, 1.06, 0.14285714285714
4581, 0.75, 1.14, 0.14285714285714
4582, 0.75, 1.22, 0.14285714285714
4583, 0.75, 0.18, 0.21428571428571
4584, 0.75, 0.26, 0.21428571428571
4585, 0.75, 0.34, 0.21428571428571
4586, 0.75, 0.42, 0.21428571428571
4587, 0.75, 0.5, 0.21428571428571
4588, 0.75, 0.58, 0.21428571428571
4589, 0.75, 0.66, 0.21428571428571
4590, 0.75, 0.74, 0.21428571428571
4591, 0.75, 0.82, 0.21428571428571
4592, 0.75, 0.9, 0.21428571428571
4593, 0.75, 0.98, 0.21428571428571
4594, 0.75, 1.06, 0.21428571428571
4595, 0.75, 1.14, 0.21428571428571
4596, 0.75, 1.22, 0.21428571428571
4597, 0.75, 0.18, 0.28571428571429
4598, 0.75, 0.26, 0.28571428571429
4599, 0.75, 0.34, 0.28571428571429
4600, 0.75, 0.42, 0.28571428571429
4601, 0.75, 0.5, 0.28571428571429
4602, 0.75, 0.58, 0.28571428571429
4603, 0.75, 0.66, 0.28571428571429
4604, 0.75, 0.74, 0.28571428571429
4605, 0.75, 0.82, 0.28571428571429
4606, 0.75, 0.9, 0.28571428571429
4607, 0.75, 0.98, 0.28571428571429
4608, 0.75, 1.06, 0.28571428571429
4609, 0.75, 1.14, 0.28571428571429
4610, 0.75, 1.22, 0.28571428571429
4611, 0.75, 0.18, 0.35714285714286
4612, 0.75, 0.26, 0.35714285714286
4613, 0.75, 0.34, 0.35714285714286
4614, 0.75, 0.42, 0.35714285714286
4615, 0.75, 0.5, 0.35714285714286
4616, 0.75, 0.58, 0.35714285714286
4617, 0.75, 0.66, 0.35714285714286
4618, 0.75, 0.74, 0.35714285714286
4619, 0.75, 0.82, 0.35714285714286
4620, 0.75, 0.9, 0.35714285714286
4621, 0.75, 0.98, 0.35714285714286
4622, 0.75, 1.06, 0.35714285714286
4623, 0.75, 1.14, 0.35714285714286
4624, 0.75, 1.22, 0.35714285714286
4625, 0.75, 0.18, 0.42857142857143
4626, 0.75, 0.26, 0.42857142857143
4627, 0.75, 0.34, 0.42857142857143
4628, 0.75, 0.42, 0.42857142857143
4629, 0.75, 0.5, 0.42857142857143
4630, 0.75, 0.58, 0.42857142857143
4631, 0.75, 0.66, 0.42857142857143
4632, 0.75, 0.74, 0.42857142857143
4633, 0.75, 0.82, 0.42857142857143
4634, 0.75, 0.9, 0.42857142857143
4635, 0.75, 0.98, 0.42857142857143
4636, 0.75, 1.06, 0.42857142857143
4637, 0.75, 1.14, 0.42857142857143
4638, 0.75, 1.22, 0.42857142857143
4639, 0.83333333333333, 0.18, 0.071428571428571
4640, 0.83333333333333, 0.26, 0.071428571428571
4641, 0.83333333333333, 0.34, 0.071428571428571
4642, 0.83333333333333, 0.42, 0.071428571428571
4643, 0.83333333333333, 0.5, 0.071428571428571
4644, 0.83333333333333, 0.58, 0.071428571428571
4645, 0.83333333333333, 0.66, 0.071428571428571
4646, 0.83333333333333, 0.74, 0.071428571428571
4647, 0.83333333333333, 0.82, 0.071428571428571
4648, 0.83333333333333, 0.9, 0.071428571428571
4649, 0.83333333333333, 0.98, 0.071428571428571
4650, 0.83333333333333, 1.06, 0.071428571428571
4651, 0.83333333333333, 1.14, 0.071428571428571
4652, 0.83333333333333, 1.22, 0.071428571428571
4653, 0.83333333333333, 0.18, 0.14285714285714
4654, 0.83333333333333, 0.26, 0.14285714285714
4655, 0.83333333333333, 0.34, 0.14285714285714
4656, 0.83333333333333, 0.42, 0.14285714285714
4657, 0.83333333333333, 0.5, 0.14285714285714
4658, 0.83333333333333, 0.58, 0.14285714285714
4659, 0.83333333333333, 0.66, 0.14285714285714
4660, 0.83333333333333, 0.74, 0.14285714285714
4661, 0.83333333333333, 0.82, 0.14285714285714
4662, 0.83333333333333, 0.9, 0.14285714285714
4663, 0.83333333333333, 0.98, 0.14285714285714
4664, 0.83333333333333, 1.06, 0.14285714285714
4665, 0.83333333333333, 1.14, 0.14285714285714
4666, 0.83333333333333, 1.22, 0.14285714285714
4667, 0.83333333333333, 0.18, 0.21428571428571
4668, 0.83333333333333, 0.26, 0.21428571428571
4669, 0.83333333333333, 0.34, 0.21428571428571
4670, 0.83333333333333, 0.42, 0.21428571428571
4671, 0.83333333333333, 0.5, 0.21428571428571
4672, 0.83333333333333, 0.58, 0.21428571428571
4673, 0.83333333333333, 0.66, 0.21428571428571
4674, 0.83333333333333, 0.74, 0.21428571428571
4675, 0.83333333333333, 0.82, 0.21428571428571
4676, 0.83333333333333, 0.9, 0.21428571428571
4677, 0.83333333333333, 0.98, 0.21428571428571
4678, 0.83333333333333, 1.06, 0.21428571428571
4679, 0.83333333333333, 1.14, 0.21428571428571
4680, 0.83333333333333, 1.22, 0.21428571428571
4681, 0.83333333333333, 0.18, 0.28571428571429
4682, 0.83333333333333, 0.26, 0.28571428571429
4683, 0.83333333333333, 0.34, 0.28571428571429
4684, 0.83333333333333, 0.42, 0.28571428571429
4685, 0.83333333333333, 0.5, 0.28571428571429
4686, 0.83333333333333, 0.58, 0.28571428571429
4687, 0.83333333333333, 0.66, 0.28571428571429
4688, 0.83333333333333, 0.74, 0.28571428571429
4689, 0.83333333333333, 0.82, 0.28571428571429
4690, 0.83333333333333, 0.9, 0.28571428571429
4691, 0.83333333333333, 0.98, 0.28571428571429
4692, 0.83333333333333, 1.06, 0.28571428571429
4693, 0.83333333333333, 1.14, 0.28571428571429
4694, 0.83333333333333, 1.22, 0.28571428571429
4695, 0.83333333333333, 0.18, 0.35714285714286
4696, 0.83333333333333, 0.26, 0.35714285714286
4697, 0.83333333333333, 0.34, 0.35714285714286
4698, 0.83333333333333, 0.42, 0.35714285714286
4699, 0.83333333333333, 0.5, 0.35714285714286
4700, 0.83333333333333, 0.58, 0.35714285714286
4701, 0.83333333333333, 0.66, 0.35714285714286
4702, 0.83333333333333, 0.74, 0.35714285714286
4703, 0.83333333333333, 0.82, 0.35714285714286
4704, 0.83333333333333, 0.9, 0.35714285714286
4705, 0.83333333333333, 0.98, 0.35714285714286
4706, 0.83333333333333, 1.06, 0.35714285714286
4707, 0.83333333333333, 1.14, 0.35714285714286
4708, 0.83333333333333, 1.22, 0.35714285714286
4709, 0.83333333333333, 0.18, 0.42857142857143
4710, 0.83333333333333, 0.26, 0.42857142857143
4711, 0.83333333333333, 0.34, 0.42857142857143
4712, 0.83333333333333, 0.42, 0.42857142857143
4713, 0.83333333333333, 0.5, 0.42857142857143
4714, 0.83333333333333, 0.58, 0.42857142857143
4715, 0.83333333333333, 0.66, 0.42857142857143
4716, 0.83333333333333, 0.74, 0.42857142857143
4717, 0.83333333333333, 0.82, 0.42857142857143
4718, 0.83333333333333, 0.9, 0.42857142857143
4719, 0.83333333333333, 0.98, 0.42857142857143
4720, 0.83333333333333, 1.06, 0.42857142857143
4721, 0.83333333333333, 1.14, 0.42857142857143
4722, 0.83333333333333, 1.22, 0.42857142857143
4723, 0.91666666666667, 0.18, 0.071428571428571
4724, 0.91666666666667, 0.26, 0.071428571428571
4725, 0.91666666666667, 0.34, 0.071428571428571
4726, 0.91666666666667, 0.42, 0.071428571428571
4727, 0.91666666666667, 0.5, 0.071428571428571
4728, 0.91666666666667, 0.58, 0.071428571428571
4729, 0.91666666666667, 0.66, 0.071428571428571
4730, 0.91666666666667, 0.74, 0.071428571428571
4731, 0.91666666666667, 0.82, 0.071428571428571
4732, 0.91666666666667, 0.9, 0.071428571428571
4733, 0.91666666666667, 0.98, 0.071428571428571
4734, 0.91666666666667, 1.06, 0.071428571428571
4735, 0.91666666666667, 1.14, 0.071428571428571
4736, 0.91666666666667, 1.22, 0.071428571428571
4737, 0.91666666666667, 0.18, 0.14285714285714
4738, 0.91666666666667, 0.26, 0.14285714285714
4739, 0.91666666666667, 0.34, 0.14285714285714
4740, 0.91666666666667, 0.42, 0.14285714285714
4741, 0.91666666666667, 0.5, 0.14285714285714
4742, 0.91666666666667, 0.58, 0.14285714285714
4743, 0.91666666666667, 0.66, 0.14285714285714
4744, 0.91666666666667, 0.74, 0.14285714285714
4745, 0.91666666666667, 0.82, 0.14285714285714
4746, 0.91666666666667, 0.9, 0.14285714285714
4747, 0.91666666666667, 0.98, 0.14285714285714
4748, 0.91666666666667, 1.06, 0.14285714285714
4749, 0.91666666666667, 1.14, 0.14285714285714
4750, 0.91666666666667, 1.22, 0.14285714285714
4751, 0.91666666666667, 0.18, 0.21428571428571
4752, 0.91666666666667, 0.26, 0.21428571428571
4753, 0.91666666666667, 0.34, 0.21428571428571
4754, 0.91666666666667, 0.42, 0.21428571428571
4755, 0.91666666666667, 0.5, 0.21428571428571
4756, 0.91666666666667, 0.58, 0.21428571428571
4757, 0.91666666666667, 0.66, 0.21428571428571
4758, 0.91666666666667, 0.74, 0.21428571428571
4759, 0.91666666666667, 0.82, 0.21428571428571
4760, 0.91666666666667, 0.9, 0.21428571428571
4761, 0.91666666666667, 0.98, 0.21428571428571
4762, 0.91666666666667, 1.06, 0.21428571428571
4763, 0.91666666666667, 1.14, 0.21428571428571
4764, 0.91666666666667, 1.22, 0.21428571428571
4765, 0.91666666666667, 0.18, 0.28571428571429
4766, 0.91666666666667, 0.26, 0.28571428571429
4767, 0.91666666666667, 0.34, 0.28571428571429
4768, 0.91666666666667, 0.42, 0.28571428571429
4769, 0.91666666666667, 0.5, 0.28571428571429
4770, 0.91666666666667, 0.58, 0.28571428571429
4771, 0.91666666666667, 0.66, 0.28571428571429
4772, 0.91666666666667, 0.74, 0.28571428571429
4773, 0.91666666666667, 0.82, 0.28571428571429
4774, 0.91666666666667, 0.9, 0.28571428571429
4775, 0.91666666666667, 0.98, 0.28571428571429
4776, 0.91666666666667, 1.06, 0.28571428571429
4777, 0.91666666666667, 1.14, 0.28571428571429
4778, 0.91666666666667, 1.22, 0.28571428571429
4779, 0.91666666666667, 0.18, 0.35714285714286
4780, 0.91666666666667, 0.26, 0.35714285714286
4781, 0.91666666666667, 0.34, 0.35714285714286
4782, 0.91666666666667, 0.42, 0.35714285714286
4783, 0.91666666666667, 0.5, 0.35714285714286
4784, 0.91666666666667, 0.58, 0.35714285714286
4785, 0.91666666666667, 0.66, 0.35714285714286
4786, 0.91666666666667, 0.74, 0.35714285714286
4787, 0.91666666666667, 0.82, 0.35714285714286
4788, 0.91666666666667, 0.9, 0.35714285714286
4789, 0.91666666666667, 0.98, 0.35714285714286
4790, 0.91666666666667, 1.06, 0.35714285714286
4791, 0.91666666666667, 1.14, 0.35714285714286
4792, 0.91666666666667, 1.22, 0.35714285714286
4793, 0.91666666666667, 0.18, 0.42857142857143
4794, 0.91666666666667, 0.26, 0.42857142857143
4795, 0.91666666666667, 0.34, 0.42857142857143
4796, 0.91666666666667, 0.42, 0.42857142857143
4797, 0.91666666666667, 0.5, 0.42857142857143
4798, 0.91666666666667, 0.58, 0.42857142857143
4799, 0.91666666666667, 0.66, 0.42857142857143
4800, 0.91666666666667, 0.74, 0.42857142857143
4801, 0.91666666666667, 0.82, 0.42857142857143
4802, 0.91666666666667, 0.9, 0.42857142857143
4803, 0.91666666666667, 0.98, 0.42857142857143
4804, 0.91666666666667, 1.06, 0.42857142857143
4805, 0.91666666666667, 1.14, 0.42857142857143
4806, 0.91666666666667, 1.22, 0.42857142857143
4807, 0.083333333333333, 1.375, 0.071428571428571
4808, 0.083333333333333, 1.375, 0.14285714285714
4809, 0.083333333333333, 1.375, 0.21428571428571
4810, 0.083333333333333, 1.375, 0.28571428571429
4811, 0.083333333333333, 1.375, 0.35714285714286
4812, 0.083333333333333, 1.375, 0.42857142857143
4813, 0.16666666666667, 1.375, 0.071428571428571
4814, 0.16666666666667, 1.375, 0.14285714285714
4815, 0.16666666666667, 1.375, 0.21428571428571
4816, 0.16666666666667, 1.375, 0.28571428571429
4817, 0.16666666666667, 1.375, 0.35714285714286
4818, 0.16666666666667, 1.375, 0.42857142857143
4819, 0.25, 1.375, 0.071428571428571
4820, 0.25, 1.375, 0.14285714285714
4821, 0.25, 1.375, 0.21428571428571
4822, 0.25, 1.375, 0.28571428571429
4823, 0.25, 1.375, 0.35714285714286
4824, 0.25, 1.375, 0.42857142857143
4825, 0.33333333333333, 1.375, 0.071428571428571
4826, 0.33333333333333, 1.375, 0.14285714285714
4827, 0.33333333333333, 1.375, 0.21428571428571
4828, 0.33333333333333, 1.375, 0.28571428571429
4829, 0.33333333333333, 1.375, 0.35714285714286
4830, 0.33333333333333, 1.375, 0.42857142857143
4831, 0.41666666666667, 1.375, 0.071428571428571
4832, 0.41666666666667, 1.375, 0.14285714285714
4833, 0.41666666666667, 1.375, 0.21428571428571
4834, 0.41666666666667, 1.375, 0.28571428571429
4835, 0.41666666666667, 1.375, 0.35714285714286
4836, 0.41666666666667, 1.375, 0.42857142857143
4837, 0.5, 1.375, 0.071428571428571
4838, 0.5, 1.375, 0.14285714285714
4839, 0.5, 1.375, 0.21428571428571
4840, 0.5, 1.375, 0.28571428571429
4841, 0.5, 1.375, 0.35714285714286
4842, 0.5, 1.375, 0.42857142857143
4843, 0.58333333333333, 1.375, 0.071428571428571
4844, 0.58333333333333, 1.375, 0.14285714285714
4845, 0.58333333333333, 1.375, 0.21428571428571
4846, 0.58333333333333, 1.375, 0.28571428571429
4847, 0.58333333333333, 1.375, 0.35714285714286
4848, 0.58333333333333, 1.375, 0.42857142857143
4849, 0.66666666666667, 1.375, 0.071428571428571
4850, 0.66666666666667, 1.375, 0.14285714285714
4851, 0.66666666666667, 1.375, 0.21428571428571
4852, 0.66666666666667, 1.375, 0.28571428571429
4853, 0.66666666666667, 1.375, 0.35714285714286
4854, 0.66666666666667, 1.375, 0.42857142857143
4855, 0.75, 1.375, 0.071428571428571
4856, 0.75, 1.375, 0.14285714285714
4857, 0.75, 1.375, 0.21428571428571
4858, 0.75, 1.375, 0.28571428571429
4859, 0.75, 1.375, 0.35714285714286
4860, 0.75, 1.375, 0.42857142857143
4861, 0.83333333333333, 1.375, 0.071428571428571
4862, 0.83333333333333, 1.375, 0.14285714285714
4863, 0.83333333333333, 1.375, 0.21428571428571
4864, 0.83333333333333, 1.375, 0.28571428571429
4865, 0.83333333333333, 1.375, 0.35714285714286
4866, 0.83333333333333, 1.375, 0.42857142857143
4867, 0.91666666666667, 1.375, 0.071428571428571
4868, 0.91666666666667, 1.375, 0.14285714285714
4869, 0.91666666666667, 1.375, 0.21428571428571
4870, 0.91666666666667, 1.375, 0.28571428571429
4871, 0.91666666666667, 1.375, 0.35714285714286
4872, 0.91666666666667, 1.375, 0.42857142857143
4873, 1.2833333333333, 1.375, 0.071428571428571
4874, 1.3666666666667, 1.375, 0.071428571428571
4875, 1.45, 1.375, 0.071428571428571
4876, 1.5333333333333, 1.375, 0.071428571428571
4877, 1.6166666666667, 1.375, 0.071428571428571
4878, 1.7, 1.375, 0.071428571428571
4879, 1.7833333333333, 1.375, 0.071428571428571
4880, 1.8666666666667, 1.375, 0.071428571428571
4881, 1.95, 1.375, 0.071428571428571
4882, 2.0333333333333, 1.375, 0.071428571428571
4883, 2.1166666666667, 1.375, 0.071428571428571
4884, 1.2833333333333, 1.375, 0.14285714285714
4885, 1.3666666666667, 1.375, 0.14285714285714
4886, 1.45, 1.375, 0.14285714285714
4887, 1.5333333333333, 1.375, 0.14285714285714
4888, 1.6166666666667, 1.375, 0.14285714285714
4889, 1.7, 1.375, 0.14285714285714
4890, 1.7833333333333, 1.375, 0.14285714285714
4891, 1.8666666666667, 1.375, 0.14285714285714
4892, 1.95, 1.375, 0.14285714285714
4893, 2.0333333333333, 1.375, 0.14285714285714
4894, 2.1166666666667, 1.375, 0.14285714285714
4895, 1.2833333333333, 1.375, 0.21428571428571
4896, 1.3666666666667, 1.375, 0.21428571428571
4897, 1.45, 1.375, 0.21428571428571
4898, 1.5333333333333, 1.375, 0.21428571428571
4899, 1.6166666666667, 1.375, 0.21428571428571
4900, 1.7, 1.375, 0.21428571428571
4901, 1.7833333333333, 1.375, 0.21428571428571
4902, 1.8666666666667, 1.375, 0.21428571428571
4903, 1.95, 1.375, 0.21428571428571
4904, 2.0333333333333, 1.375, 0.21428571428571
4905, 2.1166666666667, 1.375, 0.21428571428571
4906, 1.2833333333333, 1.375, 0.28571428571429
4907, 1.3666666666667, 1.375, 0.28571428571429
4908, 1.45, 1.375, 0.28571428571429
4909, 1.5333333333333, 1.375, 0.28571428571429
4910, 1.6166666666667, 1.375, 0.28571428571429
4911, 1.7, 1.375, 0.28571428571429
4912, 1.7833333333333, 1.375, 0.28571428571429
4913, 1.8666666666667, 1.375, 0.28571428571429
4914, 1.95, 1.375, 0.28571428571429
4915, 2.0333333333333, 1.375, 0.28571428571429
4916, 2.1166666666667, 1.375, 0.28571428571429
4917, 1.2833333333333, 1.375, 0.35714285714286
4918, 1.3666666666667, 1.375, 0.35714285714286
4919, 1.45, 1.375, 0.35714285714286
4920, 1.5333333333333, 1.375, 0.35714285714286
4921, 1.6166666666667, 1.375, 0.35714285714286
4922, 1.7, 1.375, 0.35714285714286
4923, 1.7833333333333, 1.375, 0.35714285714286
4924, 1.8666666666667, 1.375, 0.35714285714286
4925, 1.95, 1.375, 0.35714285714286
4926, 2.0333333333333, 1.375, 0.35714285714286
4927, 2.1166666666667, 1.375, 0.35714285714286
4928, 1.2833333333333, 1.375, 0.42857142857143
4929, 1.3666666666667, 1.375, 0.42857142857143
4930, 1.45, 1.375, 0.42857142857143
4931, 1.5333333333333, 1.375, 0.42857142857143
4932, 1.6166666666667, 1.375, 0.42857142857143
4933, 1.7, 1.375, 0.42857142857143
4934, 1.7833333333333, 1.375, 0.42857142857143
4935, 1.8666666666667, 1.375, 0.42857142857143
4936, 1.95, 1.375, 0.42857142857143
4937, 2.0333333333333, 1.375, 0.42857142857143
4938, 2.1166666666667, 1.375, 0.42857142857143
4939, 1.2833333333333, 1.22, 0.071428571428571
4940, 1.2833333333333, 1.14, 0.071428571428571
4941, 1.2833333333333, 1.06, 0.071428571428571
4942, 1.2833333333333, 0.98, 0.071428571428571
4943, 1.2833333333333, 0.9, 0.071428571428571
4944, 1.2833333333333, 0.82, 0.071428571428571
4945, 1.2833333333333, 0.74, 0.071428571428571
4946, 1.2833333333333, 0.66, 0.071428571428571
4947, 1.2833333333333, 0.58, 0.071428571428571
4948, 1.2833333333333, 0.5, 0.071428571428571
4949, 1.2833333333333, 0.42, 0.071428571428571
4950, 1.2833333333333, 0.34, 0.071428571428571
4951, 1.2833333333333, 0.26, 0.071428571428571
4952, 1.2833333333333, 0.18, 0.071428571428571
4953, 1.3666666666667, 1.22, 0.071428571428571
4954, 1.3666666666667, 1.14, 0.071428571428571
4955, 1.3666666666667, 1.06, 0.071428571428571
4956, 1.3666666666667, 0.98, 0.071428571428571
4957, 1.3666666666667, 0.9, 0.071428571428571
4958, 1.3666666666667, 0.82, 0.071428571428571
4959, 1.3666666666667, 0.74, 0.071428571428571
4960, 1.3666666666667, 0.66, 0.071428571428571
4961, 1.3666666666667, 0.58, 0.071428571428571
4962, 1.3666666666667, 0.5, 0.071428571428571
4963, 1.3666666666667, 0.42, 0.071428571428571
4964, 1.3666666666667, 0.34, 0.071428571428571
4965, 1.3666666666667, 0.26, 0.071428571428571
4966, 1.3666666666667, 0.18, 0.071428571428571
4967, 1.45, 1.22, 0.071428571428571
4968, 1.45, 1.14, 0.071428571428571
4969, 1.45, 1.06, 0.071428571428571
4970, 1.45, 0.98, 0.071428571428571
4971, 1.45, 0.9, 0.071428571428571
4972, 1.45, 0.82, 0.071428571428571
4973, 1.45, 0.74, 0.071428571428571
4974, 1.45, 0.66, 0.071428571428571
4975, 1.45, 0.58, 0.071428571428571
4976, 1.45, 0.5, 0.071428571428571
4977, 1.45, 0.42, 0.071428571428571
4978, 1.45, 0.34, 0.071428571428571
4979, 1.45, 0.26, 0.071428571428571
4980, 1.45, 0.18, 0.071428571428571
4981, 1.5333333333333, 1.22, 0.071428571428571
4982, 1.5333333333333, 1.14, 0.071428571428571
4983, 1.5333333333333, 1.06, 0.071428571428571
4984, 1.5333333333333, 0.98, 0.071428571428571
4985, 1.5333333333333, 0.9, 0.071428571428571
4986, 1.5333333333333, 0.82, 0.071428571428571
4987, 1.5333333333333, 0.74, 0.071428571428571
4988, 1.5333333333333, 0.66, 0.071428571428571
4989, 1.5333333333333, 0.58, 0.071428571428571
4990, 1.5333333333333, 0.5, 0.071428571428571
4991, 1.5333333333333, 0.42, 0.071428571428571
4992, 1.5333333333333, 0.34, 0.071428571428571
4993, 1.5333333333333, 0.26, 0.071428571428571
4994, 1.5333333333333, 0.18, 0.071428571428571
4995, 1.6166666666667, 1.22, 0.071428571428571
4996, 1.6166666666667, 1.14, 0.071428571428571
4997, 1.6166666666667, 1.06, 0.071428571428571
4998, 1.6166666666667, 0.98, 0.071428571428571
4999, 1.6166666666667, 0.9, 0.071428571428571
5000, 1.6166666666667, 0.82, 0.071428571428571
5001, 1.6166666666667, 0.74, 0.071428571428571
5002, 1.6166666666667, 0.66, 0.071428571428571
5003, 1.6166666666667, 0.58, 0.071428571428571
5004, 1.6166666666667, 0.5, 0.071428571428571
5005, 1.6166666666667, 0.42, 0.071428571428571
5006, 1.6166666666667, 0.34, 0.071428571428571
5007, 1.6166666666667, 0.26, 0.071428571428571
5008, 1.6166666666667, 0.18, 0.071428571428571
5009, 1.7, 1.22, 0.071428571428571
5010, 1.7, 1.14, 0.071428571428571
5011, 1.7, 1.06, 0.071428571428571
5012, 1.7, 0.98, 0.071428571428571
5013, 1.7, 0.9, 0.071428571428571
5014, 1.7, 0.82, 0.071428571428571
5015, 1.7, 0.74, 0.071428571428571
5016, 1.7, 0.66, 0.071428571428571
5017, 1.7, 0.58, 0.071428571428571
5018, 1.7, 0.5, 0.071428571428571
5019, 1.7, 0.42, 0.071428571428571
5020, 1.7, 0.34, 0.071428571428571
5021, 1.7, 0.26, 0.071428571428571
5022, 1.7, 0.18, 0.071428571428571
5023, 1.7833333333333, 1.22, 0.071428571428571
5024, 1.7833333333333, 1.14, 0.071428571428571
5025, 1.7833333333333, 1.06, 0.071428571428571
5026, 1.7833333333333, 0.98, 0.071428571428571
5027, 1.7833333333333, 0.9, 0.071428571428571
5028, 1.7833333333333, 0.82, 0.071428571428571
5029, 1.7833333333333, 0.74, 0.071428571428571
5030, 1.7833333333333, 0.66, 0.071428571428571
5031, 1.7833333333333, 0.58, 0.071428571428571
5032, 1.7833333333333, 0.5, 0.071428571428571
5033, 1.7833333333333, 0.42, 0.071428571428571
5034, 1.7833333333333, 0.34, 0.071428571428571
5035, 1.7833333333333, 0.26, 0.071428571428571
5036, 1.7833333333333, 0.18, 0.071428571428571
5037, 1.8666666666667, 1.22, 0.071428571428571
5038, 1.8666666666667, 1.14, 0.071428571428571
5039, 1.8666666666667, 1.06, 0.071428571428571
5040, 1.8666666666667, 0.98, 0.071428571428571
5041, 1.8666666666667, 0.9, 0.071428571428571
5042, 1.8666666666667, 0.82, 0.071428571428571
5043, 1.8666666666667, 0.74, 0.071428571428571
5044, 1.8666666666667, 0.66, 0.071428571428571
5045, 1.8666666666667, 0.58, 0.071428571428571
5046, 1.8666666666667, 0.5, 0.071428571428571
5047, 1.8666666666667, 0.42, 0.071428571428571
5048, 1.8666666666667, 0.34, 0.071428571428571
5049, 1.8666666666667, 0.26, 0.071428571428571
5050, 1.8666666666667, 0.18, 0.071428571428571
5051, 1.95, 1.22, 0.071428571428571
5052, 1.95, 1.14, 0.071428571428571
5053, 1.95, 1.06, 0.071428571428571
5054, 1.95, 0.98, 0.071428571428571
5055, 1.95, 0.9, 0.071428571428571
5056, 1.95, 0.82, 0.071428571428571
5057, 1.95, 0.74, 0.071428571428571
5058, 1.95, 0.66, 0.071428571428571
5059, 1.95, 0.58, 0.071428571428571
5060, 1.95, 0.5, 0.071428571428571
5061, 1.95, 0.42, 0.071428571428571
5062, 1.95, 0.34, 0.071428571428571
5063, 1.95, 0.26, 0.071428571428571
5064, 1.95, 0.18, 0.071428571428571
5065, 2.0333333333333, 1.22, 0.071428571428571
5066, 2.0333333333333, 1.14, 0.071428571428571
5067, 2.0333333333333, 1.06, 0.071428571428571
5068, 2.0333333333333, 0.98, 0.071428571428571
5069, 2.0333333333333, 0.9, 0.071428571428571
5070, 2.0333333333333, 0.82, 0.071428571428571
5071, 2.0333333333333, 0.74, 0.071428571428571
5072, 2.0333333333333, 0.66, 0.071428571428571
5073, 2.0333333333333, 0.58, 0.071428571428571
5074, 2.0333333333333, 0.5, 0.071428571428571
5075, 2.0333333333333, 0.42, 0.071428571428571
5076, 2.0333333333333, 0.34, 0.071428571428571
5077, 2.0333333333333, 0.26, 0.071428571428571
5078, 2.0333333333333, 0.18, 0.071428571428571
5079, 2.1166666666667, 1.22, 0.071428571428571
5080, 2.1166666666667, 1.14, 0.071428571428571
5081, 2.1166666666667, 1.06, 0.071428571428571
5082, 2.1166666666667, 0.98, 0.071428571428571
5083, 2.1166666666667, 0.9, 0.071428571428571
5084, 2.1166666666667, 0.82, 0.071428571428571
5085, 2.1166666666667, 0.74, 0.071428571428571
5086, 2.1166666666667, 0.66, 0.071428571428571
5087, 2.1166666666667, 0.58, 0.071428571428571
5088, 2.1166666666667, 0.5, 0.071428571428571
5089, 2.1166666666667, 0.42, 0.071428571428571
5090, 2.1166666666667, 0.34, 0.071428571428571
5091, 2.1166666666667, 0.26, 0.071428571428571
5092, 2.1166666666667, 0.18, 0.071428571428571
5093, 1.2833333333333, 1.22, 0.14285714285714
5094, 1.2833333333333, 1.14, 0.14285714285714
5095, 1.2833333333333, 1.06, 0.14285714285714
5096, 1.2833333333333, 0.98, 0.14285714285714
5097, 1.2833333333333, 0.9, 0.14285714285714
5098, 1.2833333333333, 0.82, 0.14285714285714
5099, 1.2833333333333, 0.74, 0.14285714285714
5100, 1.2833333333333, 0.66, 0.14285714285714
5101, 1.2833333333333, 0.58, 0.14285714285714
5102, 1.2833333333333, 0.5, 0.14285714285714
5103, 1.2833333333333, 0.42, 0.14285714285714
5104, 1.2833333333333, 0.34, 0.14285714285714
5105, 1.2833333333333, 0.26, 0.14285714285714
5106, 1.2833333333333, 0.18, 0.14285714285714
5107, 1.3666666666667, 1.22, 0.14285714285714
5108, 1.3666666666667, 1.14, 0.14285714285714
5109, 1.3666666666667, 1.06, 0.14285714285714
5110, 1.3666666666667, 0.98, 0.14285714285714
5111, 1.3666666666667, 0.9, 0.14285714285714
5112, 1.3666666666667, 0.82, 0.14285714285714
5113, 1.3666666666667, 0.74, 0.14285714285714
5114, 1.3666666666667, 0.66, 0.14285714285714
5115, 1.3666666666667, 0.58, 0.14285714285714
5116, 1.3666666666667, 0.5, 0.14285714285714
5117, 1.3666666666667, 0.42, 0.14285714285714
5118, 1.3666666666667, 0.34, 0.14285714285714
5119, 1.3666666666667, 0.26, 0.14285714285714
5120, 1.3666666666667, 0.18, 0.14285714285714
5121, 1.45, 1.22, 0.14285714285714
5122, 1.45, 1.14, 0.14285714285714
5123, 1.45, 1.06, 0.14285714285714
5124, 1.45, 0.98, 0.14285714285714
5125, 1.45, 0.9, 0.14285714285714
5126, 1.45, 0.82, 0.14285714285714
5127, 1.45, 0.74, 0.14285714285714
5128, 1.45, 0.66, 0.14285714285714
5129, 1.45, 0.58, 0.14285714285714
5130, 1.45, 0.5, 0.14285714285714
5131, 1.45, 0.42, 0.14285714285714
5132, 1.45, 0.34, 0.14285714285714
5133, 1.45, 0.26, 0.14285714285714
5134, 1.45, 0.18, 0.14285714285714
5135, 1.5333333333333, 1.22, 0.14285714285714
5136, 1.5333333333333, 1.14, 0.14285714285714
5137, 1.5333333333333, 1.06, 0.14285714285714
5138, 1.5333333333333, 0.98, 0.14285714285714
5139, 1.5333333333333, 0.9, 0.14285714285714
5140, 1.5333333333333, 0.82, 0.14285714285714
5141, 1.5333333333333, 0.74, 0.14285714285714
5142, 1.5333333333333, 0.66, 0.14285714285714
5143, 1.5333333333333, 0.58, 0.14285714285714
5144, 1.5333333333333, 0.5, 0.14285714285714
5145, 1.5333333333333, 0.42, 0.14285714285714
5146, 1.5333333333333, 0.34, 0.14285714285714
5147, 1.5333333333333, 0.26, 0.14285714285714
5148, 1.5333333333333, 0.18, 0.14285714285714
5149, 1.6166666666667, 1.22, 0.14285714285714
5150, 1.6166666666667, 1.14, 0.14285714285714
5151, 1.6166666666667, 1.06, 0.14285714285714
5152, 1.6166666666667, 0.98, 0.14285714285714
5153, 1.6166666666667, 0.9, 0.14285714285714
5154, 1.6166666666667, 0.82, 0.14285714285714
5155, 1.6166666666667, 0.74, 0.14285714285714
5156, 1.6166666666667, 0.66, 0.14285714285714
5157, 1.6166666666667, 0.58, 0.14285714285714
5158, 1.6166666666667, 0.5, 0.14285714285714
5159, 1.6166666666667, 0.42, 0.14285714285714
5160, 1.6166666666667, 0.34, 0.14285714285714
5161, 1.6166666666667, 0.26, 0.14285714285714
5162, 1.6166666666667, 0.18, 0.14285714285714
5163, 1.7, 1.22, 0.14285714285714
5164, 1.7, 1.14, 0.14285714285714
5165, 1.7, 1.06, 0.14285714285714
5166, 1.7, 0.98, 0.14285714285714
5167, 1.7, 0.9, 0.14285714285714
5168, 1.7, 0.82, 0.14285714285714
5169, 1.7, 0.74, 0.14285714285714
5170, 1.7, 0.66, 0.14285714285714
5171, 1.7, 0.58, 0.14285714285714
5172, 1.7, 0.5, 0.14285714285714
5173, 1.7, 0.42, 0.14285714285714
5174, 1.7, 0.34, 0.14285714285714
5175, 1.7, 0.26, 0.14285714285714
5176, 1.7, 0.18, 0.14285714285714
5177, 1.7833333333333, 1.22, 0.14285714285714
5178, 1.7833333333333, 1.14, 0.14285714285714
5179, 1.7833333333333, 1.06, 0.14285714285714
5180, 1.7833333333333, 0.98, 0.14285714285714
5181, 1.7833333333333, 0.9, 0.14285714285714
5182, 1.7833333333333, 0.82, 0.14285714285714
5183, 1.7833333333333, 0.74, 0.14285714285714
5184, 1.7833333333333, 0.66, 0.14285714285714
5185, 1.7833333333333, 0.58, 0.14285714285714
5186, 1.7833333333333, 0.5, 0.14285714285714
5187, 1.7833333333333, 0.42, 0.14285714285714
5188, 1.7833333333333, 0.34, 0.14285714285714
5189, 1.7833333333333, 0.26, 0.14285714285714
5190, 1.7833333333333, 0.18, 0.14285714285714
5191, 1.8666666666667, 1.22, 0.14285714285714
5192, 1.8666666666667, 1.14, 0.14285714285714
5193, 1.8666666666667, 1.06, 0.14285714285714
5194, 1.8666666666667, 0.98, 0.14285714285714
5195, 1.8666666666667, 0.9, 0.14285714285714
5196, 1.8666666666667, 0.82, 0.14285714285714
5197, 1.8666666666667, 0.74, 0.14285714285714
5198, 1.8666666666667, 0.66, 0.14285714285714
5199, 1.8666666666667, 0.58, 0.14285714285714
5200, 1.8666666666667, 0.5, 0.14285714285714
5201, 1.8666666666667, 0.42, 0.14285714285714
5202, 1.8666666666667, 0.34, 0.14285714285714
5203, 1.8666666666667, 0.26, 0.14285714285714
5204, 1.8666666666667, 0.18, 0.14285714285714
5205, 1.95, 1.22, 0.14285714285714
5206, 1.95, 1.14, 0.14285714285714
5207, 1.95, 1.06, 0.14285714285714
5208, 1.95, 0.98, 0.14285714285714
5209, 1.95, 0.9, 0.14285714285714
5210, 1.95, 0.82, 0.14285714285714
5211, 1.95, 0.74, 0.14285714285714
5212, 1.95, 0.66, 0.14285714285714
5213, 1.95, 0.58, 0.14285714285714
5214, 1.95, 0.5, 0.14285714285714
5215, 1.95, 0.42, 0.14285714285714
5216, 1.95, 0.34, 0.14285714285714
5217, 1.95, 0.26, 0.14285714285714
5218, 1.95, 0.18, 0.14285714285714
5219, 2.0333333333333, 1.22, 0.14285714285714
5220, 2.0333333333333, 1.14, 0.14285714285714
5221, 2.0333333333333, 1.06, 0.14285714285714
5222, 2.0333333333333, 0.98, 0.14285714285714
5223, 2.0333333333333, 0.9, 0.14285714285714
5224, 2.0333333333333, 0.82, 0.14285714285714
5225, 2.0333333333333, 0.74, 0.14285714285714
5226, 2.0333333333333, 0.66, 0.14285714285714
5227, 2.0333333333333, 0.58, 0.14285714285714
5228, 2.0333333333333, 0.5, 0.14285714285714
5229, 2.0333333333333, 0.42, 0.14285714285714
5230, 2.0333333333333, 0.34, 0.14285714285714
5231, 2.0333333333333, 0.26, 0.14285714285714
5232, 2.0333333333333, 0.18, 0.14285714285714
5233, 2.1166666666667, 1.22, 0.14285714285714
5234, 2.1166666666667, 1.14, 0.14285714285714
5235, 2.1166666666667, 1.06, 0.14285714285714
5236, 2.1166666666667, 0.98, 0.14285714285714
5237, 2.1166666666667, 0.9, 0.14285714285714
5238, 2.1166666666667, 0.82, 0.14285714285714
5239, 2.1166666666667, 0.74, 0.14285714285714
5240, 2.1166666666667, 0.66, 0.14285714285714
5241, 2.1166666666667, 0.58, 0.14285714285714
5242, 2.1166666666667, 0.5, 0.14285714285714
5243, 2.1166666666667, 0.42, 0.14285714285714
5244, 2.1166666666667, 0.34, 0.14285714285714
5245, 2.1166666666667, 0.26, 0.14285714285714
5246, 2.1166666666667, 0.18, 0.14285714285714
5247, 1.2833333333333, 1.22, 0.21428571428571
5248, 1.2833333333333, 1.14, 0.21428571428571
5249, 1.2833333333333, 1.06, 0.21428571428571
5250, 1.2833333333333, 0.98, 0.21428571428571
5251, 1.2833333333333, 0.9, 0.21428571428571
5252, 1.2833333333333, 0.82, 0.21428571428571
5253, 1.2833333333333, 0.74, 0.21428571428571
5254, 1.2833333333333, 0.66, 0.21428571428571
5255, 1.2833333333333, 0.58, 0.21428571428571
5256, 1.2833333333333, 0.5, 0.21428571428571
5257, 1.2833333333333, 0.42, 0.21428571428571
5258, 1.2833333333333, 0.34, 0.21428571428571
5259, 1.2833333333333, 0.26, 0.21428571428571
5260, 1.2833333333333, 0.18, 0.21428571428571
5261, 1.3666666666667, 1.22, 0.21428571428571
5262, 1.3666666666667, 1.14, 0.21428571428571
5263, 1.3666666666667, 1.06, 0.21428571428571
5264, 1.3666666666667, 0.98, 0.21428571428571
5265, 1.3666666666667, 0.9, 0.21428571428571
5266, 1.3666666666667, 0.82, 0.21428571428571
5267, 1.3666666666667, 0.74, 0.21428571428571
5268, 1.3666666666667, 0.66, 0.21428571428571
5269, 1.3666666666667, 0.58, 0.21428571428571
5270, 1.3666666666667, 0.5, 0.21428571428571
5271, 1.3666666666667, 0.42, 0.21428571428571
5272, 1.3666666666667, 0.34, 0.21428571428571
5273, 1.3666666666667, 0.26, 0.21428571428571
5274, 1.3666666666667, 0.18, 0.21428571428571
5275, 1.45, 1.22, 0.21428571428571
5276, 1.45, 1.14, 0.21428571428571
5277, 1.45, 1.06, 0.21428571428571
5278, 1.45, 0.98, 0.21428571428571
5279, 1.45, 0.9, 0.21428571428571
5280, 1.45, 0.82, 0.21428571428571
5281, 1.45, 0.74, 0.21428571428571
5282, 1.45, 0.66, 0.21428571428571
5283, 1.45, 0.58, 0.21428571428571
5284, 1.45, 0.5, 0.21428571428571
5285, 1.45, 0.42, 0.21428571428571
5286, 1.45, 0.34, 0.21428571428571
5287, 1.45, 0.26, 0.21428571428571
5288, 1.45, 0.18, 0.21428571428571
5289, 1.5333333333333, 1.22, 0.21428571428571
5290, 1.5333333333333, 1.14, 0.21428571428571
5291, 1.5333333333333, 1.06, 0.21428571428571
5292, 1.5333333333333, 0.98, 0.21428571428571
5293, 1.5333333333333, 0.9, 0.21428571428571
5294, 1.5333333333333, 0.82, 0.21428571428571
5295, 1.5333333333333, 0.74, 0.21428571428571
5296, 1.5333333333333, 0.66, 0.21428571428571
5297, 1.5333333333333, 0.58, 0.21428571428571
5298, 1.5333333333333, 0.5, 0.21428571428571
5299, 1.5333333333333, 0.42, 0.21428571428571
5300, 1.5333333333333, 0.34, 0.21428571428571
5301, 1.5333333333333, 0.26, 0.21428571428571
5302, 1.5333333333333, 0.18, 0.21428571428571
5303, 1.6166666666667, 1.22, 0.21428571428571
5304, 1.6166666666667, 1.14, 0.21428571428571
5305, 1.6166666666667, 1.06, 0.21428571428571
5306, 1.6166666666667, 0.98, 0.21428571428571
5307, 1.6166666666667, 0.9, 0.21428571428571
5308, 1.6166666666667, 0.82, 0.21428571428571
5309, 1.6166666666667, 0.74, 0.21428571428571
5310, 1.6166666666667, 0.66, 0.21428571428571
5311, 1.6166666666667, 0.58, 0.21428571428571
5312, 1.6166666666667, 0.5, 0.21428571428571
5313, 1.6166666666667, 0.42, 0.21428571428571
5314, 1.6166666666667, 0.34, 0.21428571428571
5315, 1.6166666666667, 0.26, 0.21428571428571
5316, 1.6166666666667, 0.18, 0.21428571428571
5317, 1.7, 1.22, 0.21428571428571
5318, 1.7, 1.14, 0.21428571428571
5319, 1.7, 1.06, 0.21428571428571
5320, 1.7, 0.98, 0.21428571428571
5321, 1.7, 0.9, 0.21428571428571
5322, 1.7, 0.82, 0.21428571428571
5323, 1.7, 0.74, 0.21428571428571
5324, 1.7, 0.66, 0.21428571428571
5325, 1.7, 0.58, 0.21428571428571
5326, 1.7, 0.5, 0.21428571428571
5327, 1.7, 0.42, 0.21428571428571
5328, 1.7, 0.34, 0.21428571428571
5329, 1.7, 0.26, 0.21428571428571
5330, 1.7, 0.18, 0.21428571428571
5331, 1.7833333333333, 1.22, 0.21428571428571
5332, 1.7833333333333, 1.14, 0.21428571428571
5333, 1.7833333333333, 1.06, 0.21428571428571
5334, 1.7833333333333, 0.98, 0.21428571428571
5335, 1.7833333333333, 0.9, 0.21428571428571
5336, 1.7833333333333, 0.82, 0.21428571428571
5337, 1.7833333333333, 0.74, 0.21428571428571
5338, 1.7833333333333, 0.66, 0.21428571428571
5339, 1.7833333333333, 0.58, 0.21428571428571
5340, 1.7833333333333, 0.5, 0.21428571428571
5341, 1.7833333333333, 0.42, 0.21428571428571
5342, 1.7833333333333, 0.34, 0.21428571428571
5343, 1.7833333333333, 0.26, 0.21428571428571
5344, 1.7833333333333, 0.18, 0.21428571428571
5345, 1.8666666666667, 1.22, 0.21428571428571
5346, 1.8666666666667, 1.14, 0.21428571428571
5347, 1.8666666666667, 1.06, 0.21428571428571
5348, 1.8666666666667, 0.98, 0.21428571428571
5349, 1.8666666666667, 0.9, 0.21428571428571
5350, 1.8666666666667, 0.82, 0.21428571428571
5351, 1.8666666666667, 0.74, 0.21428571428571
5352, 1.8666666666667, 0.66, 0.21428571428571
5353, 1.8666666666667, 0.58, 0.21428571428571
5354, 1.8666666666667, 0.5, 0.21428571428571
5355, 1.8666666666667, 0.42, 0.21428571428571
5356, 1.8666666666667, 0.34, 0.21428571428571
5357, 1.8666666666667, 0.26, 0.21428571428571
5358, 1.8666666666667, 0.18, 0.21428571428571
5359, 1.95, 1.22, 0.21428571428571
5360, 1.95, 1.14, 0.21428571428571
5361, 1.95, 1.06, 0.21428571428571
5362, 1.95, 0.98, 0.21428571428571
5363, 1.95, 0.9, 0.21428571428571
5364, 1.95, 0.82, 0.21428571428571
5365, 1.95, 0.74, 0.21428571428571
5366, 1.95, 0.66, 0.21428571428571
5367, 1.95, 0.58, 0.21428571428571
5368, 1.95, 0.5, 0.21428571428571
5369, 1.95, 0.42, 0.21428571428571
5370, 1.95, 0.34, 0.21428571428571
5371, 1.95, 0.26, 0.21428571428571
5372, 1.95, 0.18, 0.21428571428571
5373, 2.0333333333333, 1.22, 0.21428571428571
5374, 2.0333333333333, 1.14, 0.21428571428571
5375, 2.0333333333333, 1.06, 0.21428571428571
5376, 2.0333333333333, 0.98, 0.21428571428571
5377, 2.0333333333333, 0.9, 0.21428571428571
5378, 2.0333333333333, 0.82, 0.21428571428571
5379, 2.0333333333333, 0.74, 0.21428571428571
5380, 2.0333333333333, 0.66, 0.21428571428571
5381, 2.0333333333333, 0.58, 0.21428571428571
5382, 2.0333333333333, 0.5, 0.21428571428571
5383, 2.0333333333333, 0.42, 0.21428571428571
5384, 2.0333333333333, 0.34, 0.21428571428571
5385, 2.0333333333333, 0.26, 0.21428571428571
5386, 2.0333333333333, 0.18, 0.21428571428571
5387, 2.1166666666667, 1.22, 0.21428571428571
5388, 2.1166666666667, 1.14, 0.21428571428571
5389, 2.1166666666667, 1.06, 0.21428571428571
5390, 2.1166666666667, 0.98, 0.21428571428571
5391, 2.1166666666667, 0.9, 0.21428571428571
5392, 2.1166666666667, 0.82, 0.21428571428571
5393, 2.1166666666667, 0.74, 0.21428571428571
5394, 2.1166666666667, 0.66, 0.21428571428571
5395, 2.1166666666667, 0.58, 0.21428571428571
5396, 2.1166666666667, 0.5, 0.21428571428571
5397, 2.1166666666667, 0.42, 0.21428571428571
5398, 2.1166666666667, 0.34, 0.21428571428571
5399, 2.1166666666667, 0.26, 0.21428571428571
5400, 2.1166666666667, 0.18, 0.21428571428571
5401, 1.2833333333333, 1.22, 0.28571428571429
5402, 1.2833333333333, 1.14, 0.28571428571429
5403, 1.2833333333333, 1.06, 0.28571428571429
5404, 1.2833333333333, 0.98, 0.28571428571429
5405, 1.2833333333333, 0.9, 0.28571428571429
5406, 1.2833333333333, 0.82, 0.28571428571429
5407, 1.2833333333333, 0.74, 0.28571428571429
5408, 1.2833333333333, 0.66, 0.28571428571429
5409, 1.2833333333333, 0.58, 0.28571428571429
5410, 1.2833333333333, 0.5, 0.28571428571429
5411, 1.2833333333333, 0.42, 0.28571428571429
5412, 1.2833333333333, 0.34, 0.28571428571429
5413, 1.2833333333333, 0.26, 0.28571428571429
5414, 1.2833333333333, 0.18, 0.28571428571429
5415, 1.3666666666667, 1.22, 0.28571428571429
5416, 1.3666666666667, 1.14, 0.28571428571429
5417, 1.3666666666667, 1.06, 0.28571428571429
5418, 1.3666666666667, 0.98, 0.28571428571429
5419, 1.3666666666667, 0.9, 0.28571428571429
5420, 1.3666666666667, 0.82, 0.28571428571429
5421, 1.3666666666667, 0.74, 0.28571428571429
5422, 1.3666666666667, 0.66, 0.28571428571429
5423, 1.3666666666667, 0.58, 0.28571428571429
5424, 1.3666666666667, 0.5, 0.28571428571429
5425, 1.3666666666667, 0.42, 0.28571428571429
5426, 1.3666666666667, 0.34, 0.28571428571429
5427, 1.3666666666667, 0.26, 0.28571428571429
5428, 1.3666666666667, 0.18, 0.28571428571429
5429, 1.45, 1.22, 0.28571428571429
5430, 1.45, 1.14, 0.28571428571429
5431, 1.45, 1.06, 0.28571428571429
5432, 1.45, 0.98, 0.28571428571429
5433, 1.45, 0.9, 0.28571428571429
5434, 1.45, 0.82, 0.28571428571429
5435, 1.45, 0.74, 0.28571428571429
5436, 1.45, 0.66, 0.28571428571429
5437, 1.45, 0.58, 0.28571428571429
5438, 1.45, 0.5, 0.28571428571429
5439, 1.45, 0.42, 0.28571428571429
5440, 1.45, 0.34, 0.28571428571429
5441, 1.45, 0.26, 0.28571428571429
5442, 1.45, 0.18, 0.28571428571429
5443, 1.5333333333333, 1.22, 0.28571428571429
5444, 1.5333333333333, 1.14, 0.28571428571429
5445, 1.5333333333333, 1.06, 0.28571428571429
5446, 1.5333333333333, 0.98, 0.28571428571429
5447, 1.5333333333333, 0.9, 0.28571428571429
5448, 1.5333333333333, 0.82, 0.28571428571429
5449, 1.5333333333333, 0.74, 0.28571428571429
5450, 1.5333333333333, 0.66, 0.28571428571429
5451, 1.5333333333333, 0.58, 0.28571428571429
5452, 1.5333333333333, 0.5, 0.28571428571429
5453, 1.5333333333333, 0.42, 0.28571428571429
5454, 1.5333333333333, 0.34, 0.28571428571429
5455, 1.5333333333333, 0.26, 0.28571428571429
5456, 1.5333333333333, 0.18, 0.28571428571429
5457, 1.6166666666667, 1.22, 0.28571428571429
5458, 1.6166666666667, 1.14, 0.28571428571429
5459, 1.6166666666667, 1.06, 0.28571428571429
5460, 1.6166666666667, 0.98, 0.28571428571429
5461, 1.6166666666667, 0.9, 0.28571428571429
5462, 1.6166666666667, 0.82, 0.28571428571429
5463, 1.6166666666667, 0.74, 0.28571428571429
5464, 1.6166666666667, 0.66, 0.28571428571429
5465, 1.6166666666667, 0.58, 0.28571428571429
5466, 1.6166666666667, 0.5, 0.28571428571429
5467, 1.6166666666667, 0.42, 0.28571428571429
5468, 1.6166666666667, 0.34, 0.28571428571429
5469, 1.6166666666667, 0.26, 0.28571428571429
5470, 1.6166666666667, 0.18, 0.28571428571429
5471, 1.7, 1.22, 0.28571428571429
5472, 1.7, 1.14, 0.28571428571429
5473, 1.7, 1.06, 0.28571428571429
5474, 1.7, 0.98, 0.28571428571429
5475, 1.7, 0.9, 0.28571428571429
5476, 1.7, 0.82, 0.28571428571429
5477, 1.7, 0.74, 0.28571428571429
5478, 1.7, 0.66, 0.28571428571429
5479, 1.7, 0.58, 0.28571428571429
5480, 1.7, 0.5, 0.28571428571429
5481, 1.7, 0.42, 0.28571428571429
5482, 1.7, 0.34, 0.28571428571429
5483, 1.7, 0.26, 0.28571428571429
5484, 1.7, 0.18, 0.28571428571429
5485, 1.7833333333333, 1.22, 0.28571428571429
5486, 1.7833333333333, 1.14, 0.28571428571429
5487, 1.7833333333333, 1.06, 0.28571428571429
5488, 1.7833333333333, 0.98, 0.28571428571429
