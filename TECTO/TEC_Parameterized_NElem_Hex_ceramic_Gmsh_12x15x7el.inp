5489, 1.7833333333333, 0.9, 0.28571428571429
5490, 1.7833333333333, 0.82, 0.28571428571429
5491, 1.7833333333333, 0.74, 0.28571428571429
5492, 1.7833333333333, 0.66, 0.28571428571429
5493, 1.7833333333333, 0.58, 0.28571428571429
5494, 1.7833333333333, 0.5, 0.28571428571429
5495, 1.7833333333333, 0.42, 0.28571428571429
5496, 1.7833333333333, 0.34, 0.28571428571429
5497, 1.7833333333333, 0.26, 0.28571428571429
5498, 1.7833333333333, 0.18, 0.28571428571429
5499, 1.8666666666667, 1.22, 0.28571428571429
5500, 1.8666666666667, 1.14, 0.28571428571429
5501, 1.8666666666667, 1.06, 0.28571428571429
5502, 1.8666666666667, 0.98, 0.28571428571429
5503, 1.8666666666667, 0.9, 0.28571428571429
5504, 1.8666666666667, 0.82, 0.28571428571429
5505, 1.8666666666667, 0.74, 0.28571428571429
5506, 1.8666666666667, 0.66, 0.28571428571429
5507, 1.8666666666667, 0.58, 0.28571428571429
5508, 1.8666666666667, 0.5, 0.28571428571429
5509, 1.8666666666667, 0.42, 0.28571428571429
5510, 1.8666666666667, 0.34, 0.28571428571429
5511, 1.8666666666667, 0.26, 0.28571428571429
5512, 1.8666666666667, 0.18, 0.28571428571429
5513, 1.95, 1.22, 0.28571428571429
5514, 1.95, 1.14, 0.28571428571429
5515, 1.95, 1.06, 0.28571428571429
5516, 1.95, 0.98, 0.28571428571429
5517, 1.95, 0.9, 0.28571428571429
5518, 1.95, 0.82, 0.28571428571429
5519, 1.95, 0.74, 0.28571428571429
5520, 1.95, 0.66, 0.28571428571429
5521, 1.95, 0.58, 0.28571428571429
5522, 1.95, 0.5, 0.28571428571429
5523, 1.95, 0.42, 0.28571428571429
5524, 1.95, 0.34, 0.28571428571429
5525, 1.95, 0.26, 0.28571428571429
5526, 1.95, 0.18, 0.28571428571429
5527, 2.0333333333333, 1.22, 0.28571428571429
5528, 2.0333333333333, 1.14, 0.28571428571429
5529, 2.0333333333333, 1.06, 0.28571428571429
5530, 2.0333333333333, 0.98, 0.28571428571429
5531, 2.0333333333333, 0.9, 0.28571428571429
5532, 2.0333333333333, 0.82, 0.28571428571429
5533, 2.0333333333333, 0.74, 0.28571428571429
5534, 2.0333333333333, 0.66, 0.28571428571429
5535, 2.0333333333333, 0.58, 0.28571428571429
5536, 2.0333333333333, 0.5, 0.28571428571429
5537, 2.0333333333333, 0.42, 0.28571428571429
5538, 2.0333333333333, 0.34, 0.28571428571429
5539, 2.0333333333333, 0.26, 0.28571428571429
5540, 2.0333333333333, 0.18, 0.28571428571429
5541, 2.1166666666667, 1.22, 0.28571428571429
5542, 2.1166666666667, 1.14, 0.28571428571429
5543, 2.1166666666667, 1.06, 0.28571428571429
5544, 2.1166666666667, 0.98, 0.28571428571429
5545, 2.1166666666667, 0.9, 0.28571428571429
5546, 2.1166666666667, 0.82, 0.28571428571429
5547, 2.1166666666667, 0.74, 0.28571428571429
5548, 2.1166666666667, 0.66, 0.28571428571429
5549, 2.1166666666667, 0.58, 0.28571428571429
5550, 2.1166666666667, 0.5, 0.28571428571429
5551, 2.1166666666667, 0.42, 0.28571428571429
5552, 2.1166666666667, 0.34, 0.28571428571429
5553, 2.1166666666667, 0.26, 0.28571428571429
5554, 2.1166666666667, 0.18, 0.28571428571429
5555, 1.2833333333333, 1.22, 0.35714285714286
5556, 1.2833333333333, 1.14, 0.35714285714286
5557, 1.2833333333333, 1.06, 0.35714285714286
5558, 1.2833333333333, 0.98, 0.35714285714286
5559, 1.2833333333333, 0.9, 0.35714285714286
5560, 1.2833333333333, 0.82, 0.35714285714286
5561, 1.2833333333333, 0.74, 0.35714285714286
5562, 1.2833333333333, 0.66, 0.35714285714286
5563, 1.2833333333333, 0.58, 0.35714285714286
5564, 1.2833333333333, 0.5, 0.35714285714286
5565, 1.2833333333333, 0.42, 0.35714285714286
5566, 1.2833333333333, 0.34, 0.35714285714286
5567, 1.2833333333333, 0.26, 0.35714285714286
5568, 1.2833333333333, 0.18, 0.35714285714286
5569, 1.3666666666667, 1.22, 0.35714285714286
5570, 1.3666666666667, 1.14, 0.35714285714286
5571, 1.3666666666667, 1.06, 0.35714285714286
5572, 1.3666666666667, 0.98, 0.35714285714286
5573, 1.3666666666667, 0.9, 0.35714285714286
5574, 1.3666666666667, 0.82, 0.35714285714286
5575, 1.3666666666667, 0.74, 0.35714285714286
5576, 1.3666666666667, 0.66, 0.35714285714286
5577, 1.3666666666667, 0.58, 0.35714285714286
5578, 1.3666666666667, 0.5, 0.35714285714286
5579, 1.3666666666667, 0.42, 0.35714285714286
5580, 1.3666666666667, 0.34, 0.35714285714286
5581, 1.3666666666667, 0.26, 0.35714285714286
5582, 1.3666666666667, 0.18, 0.35714285714286
5583, 1.45, 1.22, 0.35714285714286
5584, 1.45, 1.14, 0.35714285714286
5585, 1.45, 1.06, 0.35714285714286
5586, 1.45, 0.98, 0.35714285714286
5587, 1.45, 0.9, 0.35714285714286
5588, 1.45, 0.82, 0.35714285714286
5589, 1.45, 0.74, 0.35714285714286
5590, 1.45, 0.66, 0.35714285714286
5591, 1.45, 0.58, 0.35714285714286
5592, 1.45, 0.5, 0.35714285714286
5593, 1.45, 0.42, 0.35714285714286
5594, 1.45, 0.34, 0.35714285714286
5595, 1.45, 0.26, 0.35714285714286
5596, 1.45, 0.18, 0.35714285714286
5597, 1.5333333333333, 1.22, 0.35714285714286
5598, 1.5333333333333, 1.14, 0.35714285714286
5599, 1.5333333333333, 1.06, 0.35714285714286
5600, 1.5333333333333, 0.98, 0.35714285714286
5601, 1.5333333333333, 0.9, 0.35714285714286
5602, 1.5333333333333, 0.82, 0.35714285714286
5603, 1.5333333333333, 0.74, 0.35714285714286
5604, 1.5333333333333, 0.66, 0.35714285714286
5605, 1.5333333333333, 0.58, 0.35714285714286
5606, 1.5333333333333, 0.5, 0.35714285714286
5607, 1.5333333333333, 0.42, 0.35714285714286
5608, 1.5333333333333, 0.34, 0.35714285714286
5609, 1.5333333333333, 0.26, 0.35714285714286
5610, 1.5333333333333, 0.18, 0.35714285714286
5611, 1.6166666666667, 1.22, 0.35714285714286
5612, 1.6166666666667, 1.14, 0.35714285714286
5613, 1.6166666666667, 1.06, 0.35714285714286
5614, 1.6166666666667, 0.98, 0.35714285714286
5615, 1.6166666666667, 0.9, 0.35714285714286
5616, 1.6166666666667, 0.82, 0.35714285714286
5617, 1.6166666666667, 0.74, 0.35714285714286
5618, 1.6166666666667, 0.66, 0.35714285714286
5619, 1.6166666666667, 0.58, 0.35714285714286
5620, 1.6166666666667, 0.5, 0.35714285714286
5621, 1.6166666666667, 0.42, 0.35714285714286
5622, 1.6166666666667, 0.34, 0.35714285714286
5623, 1.6166666666667, 0.26, 0.35714285714286
5624, 1.6166666666667, 0.18, 0.35714285714286
5625, 1.7, 1.22, 0.35714285714286
5626, 1.7, 1.14, 0.35714285714286
5627, 1.7, 1.06, 0.35714285714286
5628, 1.7, 0.98, 0.35714285714286
5629, 1.7, 0.9, 0.35714285714286
5630, 1.7, 0.82, 0.35714285714286
5631, 1.7, 0.74, 0.35714285714286
5632, 1.7, 0.66, 0.35714285714286
5633, 1.7, 0.58, 0.35714285714286
5634, 1.7, 0.5, 0.35714285714286
5635, 1.7, 0.42, 0.35714285714286
5636, 1.7, 0.34, 0.35714285714286
5637, 1.7, 0.26, 0.35714285714286
5638, 1.7, 0.18, 0.35714285714286
5639, 1.7833333333333, 1.22, 0.35714285714286
5640, 1.7833333333333, 1.14, 0.35714285714286
5641, 1.7833333333333, 1.06, 0.35714285714286
5642, 1.7833333333333, 0.98, 0.35714285714286
5643, 1.7833333333333, 0.9, 0.35714285714286
5644, 1.7833333333333, 0.82, 0.35714285714286
5645, 1.7833333333333, 0.74, 0.35714285714286
5646, 1.7833333333333, 0.66, 0.35714285714286
5647, 1.7833333333333, 0.58, 0.35714285714286
5648, 1.7833333333333, 0.5, 0.35714285714286
5649, 1.7833333333333, 0.42, 0.35714285714286
5650, 1.7833333333333, 0.34, 0.35714285714286
5651, 1.7833333333333, 0.26, 0.35714285714286
5652, 1.7833333333333, 0.18, 0.35714285714286
5653, 1.8666666666667, 1.22, 0.35714285714286
5654, 1.8666666666667, 1.14, 0.35714285714286
5655, 1.8666666666667, 1.06, 0.35714285714286
5656, 1.8666666666667, 0.98, 0.35714285714286
5657, 1.8666666666667, 0.9, 0.35714285714286
5658, 1.8666666666667, 0.82, 0.35714285714286
5659, 1.8666666666667, 0.74, 0.35714285714286
5660, 1.8666666666667, 0.66, 0.35714285714286
5661, 1.8666666666667, 0.58, 0.35714285714286
5662, 1.8666666666667, 0.5, 0.35714285714286
5663, 1.8666666666667, 0.42, 0.35714285714286
5664, 1.8666666666667, 0.34, 0.35714285714286
5665, 1.8666666666667, 0.26, 0.35714285714286
5666, 1.8666666666667, 0.18, 0.35714285714286
5667, 1.95, 1.22, 0.35714285714286
5668, 1.95, 1.14, 0.35714285714286
5669, 1.95, 1.06, 0.35714285714286
5670, 1.95, 0.98, 0.35714285714286
5671, 1.95, 0.9, 0.35714285714286
5672, 1.95, 0.82, 0.35714285714286
5673, 1.95, 0.74, 0.35714285714286
5674, 1.95, 0.66, 0.35714285714286
5675, 1.95, 0.58, 0.35714285714286
5676, 1.95, 0.5, 0.35714285714286
5677, 1.95, 0.42, 0.35714285714286
5678, 1.95, 0.34, 0.35714285714286
5679, 1.95, 0.26, 0.35714285714286
5680, 1.95, 0.18, 0.35714285714286
5681, 2.0333333333333, 1.22, 0.35714285714286
5682, 2.0333333333333, 1.14, 0.35714285714286
5683, 2.0333333333333, 1.06, 0.35714285714286
5684, 2.0333333333333, 0.98, 0.35714285714286
5685, 2.0333333333333, 0.9, 0.35714285714286
5686, 2.0333333333333, 0.82, 0.35714285714286
5687, 2.0333333333333, 0.74, 0.35714285714286
5688, 2.0333333333333, 0.66, 0.35714285714286
5689, 2.0333333333333, 0.58, 0.35714285714286
5690, 2.0333333333333, 0.5, 0.35714285714286
5691, 2.0333333333333, 0.42, 0.35714285714286
5692, 2.0333333333333, 0.34, 0.35714285714286
5693, 2.0333333333333, 0.26, 0.35714285714286
5694, 2.0333333333333, 0.18, 0.35714285714286
5695, 2.1166666666667, 1.22, 0.35714285714286
5696, 2.1166666666667, 1.14, 0.35714285714286
5697, 2.1166666666667, 1.06, 0.35714285714286
5698, 2.1166666666667, 0.98, 0.35714285714286
5699, 2.1166666666667, 0.9, 0.35714285714286
5700, 2.1166666666667, 0.82, 0.35714285714286
5701, 2.1166666666667, 0.74, 0.35714285714286
5702, 2.1166666666667, 0.66, 0.35714285714286
5703, 2.1166666666667, 0.58, 0.35714285714286
5704, 2.1166666666667, 0.5, 0.35714285714286
5705, 2.1166666666667, 0.42, 0.35714285714286
5706, 2.1166666666667, 0.34, 0.35714285714286
5707, 2.1166666666667, 0.26, 0.35714285714286
5708, 2.1166666666667, 0.18, 0.35714285714286
5709, 1.2833333333333, 1.22, 0.42857142857143
5710, 1.2833333333333, 1.14, 0.42857142857143
5711, 1.2833333333333, 1.06, 0.42857142857143
5712, 1.2833333333333, 0.98, 0.42857142857143
5713, 1.2833333333333, 0.9, 0.42857142857143
5714, 1.2833333333333, 0.82, 0.42857142857143
5715, 1.2833333333333, 0.74, 0.42857142857143
5716, 1.2833333333333, 0.66, 0.42857142857143
5717, 1.2833333333333, 0.58, 0.42857142857143
5718, 1.2833333333333, 0.5, 0.42857142857143
5719, 1.2833333333333, 0.42, 0.42857142857143
5720, 1.2833333333333, 0.34, 0.42857142857143
5721, 1.2833333333333, 0.26, 0.42857142857143
5722, 1.2833333333333, 0.18, 0.42857142857143
5723, 1.3666666666667, 1.22, 0.42857142857143
5724, 1.3666666666667, 1.14, 0.42857142857143
5725, 1.3666666666667, 1.06, 0.42857142857143
5726, 1.3666666666667, 0.98, 0.42857142857143
5727, 1.3666666666667, 0.9, 0.42857142857143
5728, 1.3666666666667, 0.82, 0.42857142857143
5729, 1.3666666666667, 0.74, 0.42857142857143
5730, 1.3666666666667, 0.66, 0.42857142857143
5731, 1.3666666666667, 0.58, 0.42857142857143
5732, 1.3666666666667, 0.5, 0.42857142857143
5733, 1.3666666666667, 0.42, 0.42857142857143
5734, 1.3666666666667, 0.34, 0.42857142857143
5735, 1.3666666666667, 0.26, 0.42857142857143
5736, 1.3666666666667, 0.18, 0.42857142857143
5737, 1.45, 1.22, 0.42857142857143
5738, 1.45, 1.14, 0.42857142857143
5739, 1.45, 1.06, 0.42857142857143
5740, 1.45, 0.98, 0.42857142857143
5741, 1.45, 0.9, 0.42857142857143
5742, 1.45, 0.82, 0.42857142857143
5743, 1.45, 0.74, 0.42857142857143
5744, 1.45, 0.66, 0.42857142857143
5745, 1.45, 0.58, 0.42857142857143
5746, 1.45, 0.5, 0.42857142857143
5747, 1.45, 0.42, 0.42857142857143
5748, 1.45, 0.34, 0.42857142857143
5749, 1.45, 0.26, 0.42857142857143
5750, 1.45, 0.18, 0.42857142857143
5751, 1.5333333333333, 1.22, 0.42857142857143
5752, 1.5333333333333, 1.14, 0.42857142857143
5753, 1.5333333333333, 1.06, 0.42857142857143
5754, 1.5333333333333, 0.98, 0.42857142857143
5755, 1.5333333333333, 0.9, 0.42857142857143
5756, 1.5333333333333, 0.82, 0.42857142857143
5757, 1.5333333333333, 0.74, 0.42857142857143
5758, 1.5333333333333, 0.66, 0.42857142857143
5759, 1.5333333333333, 0.58, 0.42857142857143
5760, 1.5333333333333, 0.5, 0.42857142857143
5761, 1.5333333333333, 0.42, 0.42857142857143
5762, 1.5333333333333, 0.34, 0.42857142857143
5763, 1.5333333333333, 0.26, 0.42857142857143
5764, 1.5333333333333, 0.18, 0.42857142857143
5765, 1.6166666666667, 1.22, 0.42857142857143
5766, 1.6166666666667, 1.14, 0.42857142857143
5767, 1.6166666666667, 1.06, 0.42857142857143
5768, 1.6166666666667, 0.98, 0.42857142857143
5769, 1.6166666666667, 0.9, 0.42857142857143
5770, 1.6166666666667, 0.82, 0.42857142857143
5771, 1.6166666666667, 0.74, 0.42857142857143
5772, 1.6166666666667, 0.66, 0.42857142857143
5773, 1.6166666666667, 0.58, 0.42857142857143
5774, 1.6166666666667, 0.5, 0.42857142857143
5775, 1.6166666666667, 0.42, 0.42857142857143
5776, 1.6166666666667, 0.34, 0.42857142857143
5777, 1.6166666666667, 0.26, 0.42857142857143
5778, 1.6166666666667, 0.18, 0.42857142857143
5779, 1.7, 1.22, 0.42857142857143
5780, 1.7, 1.14, 0.42857142857143
5781, 1.7, 1.06, 0.42857142857143
5782, 1.7, 0.98, 0.42857142857143
5783, 1.7, 0.9, 0.42857142857143
5784, 1.7, 0.82, 0.42857142857143
5785, 1.7, 0.74, 0.42857142857143
5786, 1.7, 0.66, 0.42857142857143
5787, 1.7, 0.58, 0.42857142857143
5788, 1.7, 0.5, 0.42857142857143
5789, 1.7, 0.42, 0.42857142857143
5790, 1.7, 0.34, 0.42857142857143
5791, 1.7, 0.26, 0.42857142857143
5792, 1.7, 0.18, 0.42857142857143
5793, 1.7833333333333, 1.22, 0.42857142857143
5794, 1.7833333333333, 1.14, 0.42857142857143
5795, 1.7833333333333, 1.06, 0.42857142857143
5796, 1.7833333333333, 0.98, 0.42857142857143
5797, 1.7833333333333, 0.9, 0.42857142857143
5798, 1.7833333333333, 0.82, 0.42857142857143
5799, 1.7833333333333, 0.74, 0.42857142857143
5800, 1.7833333333333, 0.66, 0.42857142857143
5801, 1.7833333333333, 0.58, 0.42857142857143
5802, 1.7833333333333, 0.5, 0.42857142857143
5803, 1.7833333333333, 0.42, 0.42857142857143
5804, 1.7833333333333, 0.34, 0.42857142857143
5805, 1.7833333333333, 0.26, 0.42857142857143
5806, 1.7833333333333, 0.18, 0.42857142857143
5807, 1.8666666666667, 1.22, 0.42857142857143
5808, 1.8666666666667, 1.14, 0.42857142857143
5809, 1.8666666666667, 1.06, 0.42857142857143
5810, 1.8666666666667, 0.98, 0.42857142857143
5811, 1.8666666666667, 0.9, 0.42857142857143
5812, 1.8666666666667, 0.82, 0.42857142857143
5813, 1.8666666666667, 0.74, 0.42857142857143
5814, 1.8666666666667, 0.66, 0.42857142857143
5815, 1.8666666666667, 0.58, 0.42857142857143
5816, 1.8666666666667, 0.5, 0.42857142857143
5817, 1.8666666666667, 0.42, 0.42857142857143
5818, 1.8666666666667, 0.34, 0.42857142857143
5819, 1.8666666666667, 0.26, 0.42857142857143
5820, 1.8666666666667, 0.18, 0.42857142857143
5821, 1.95, 1.22, 0.42857142857143
5822, 1.95, 1.14, 0.42857142857143
5823, 1.95, 1.06, 0.42857142857143
5824, 1.95, 0.98, 0.42857142857143
5825, 1.95, 0.9, 0.42857142857143
5826, 1.95, 0.82, 0.42857142857143
5827, 1.95, 0.74, 0.42857142857143
5828, 1.95, 0.66, 0.42857142857143
5829, 1.95, 0.58, 0.42857142857143
5830, 1.95, 0.5, 0.42857142857143
5831, 1.95, 0.42, 0.42857142857143
5832, 1.95, 0.34, 0.42857142857143
5833, 1.95, 0.26, 0.42857142857143
5834, 1.95, 0.18, 0.42857142857143
5835, 2.0333333333333, 1.22, 0.42857142857143
5836, 2.0333333333333, 1.14, 0.42857142857143
5837, 2.0333333333333, 1.06, 0.42857142857143
5838, 2.0333333333333, 0.98, 0.42857142857143
5839, 2.0333333333333, 0.9, 0.42857142857143
5840, 2.0333333333333, 0.82, 0.42857142857143
5841, 2.0333333333333, 0.74, 0.42857142857143
5842, 2.0333333333333, 0.66, 0.42857142857143
5843, 2.0333333333333, 0.58, 0.42857142857143
5844, 2.0333333333333, 0.5, 0.42857142857143
5845, 2.0333333333333, 0.42, 0.42857142857143
5846, 2.0333333333333, 0.34, 0.42857142857143
5847, 2.0333333333333, 0.26, 0.42857142857143
5848, 2.0333333333333, 0.18, 0.42857142857143
5849, 2.1166666666667, 1.22, 0.42857142857143
5850, 2.1166666666667, 1.14, 0.42857142857143
5851, 2.1166666666667, 1.06, 0.42857142857143
5852, 2.1166666666667, 0.98, 0.42857142857143
5853, 2.1166666666667, 0.9, 0.42857142857143
5854, 2.1166666666667, 0.82, 0.42857142857143
5855, 2.1166666666667, 0.74, 0.42857142857143
5856, 2.1166666666667, 0.66, 0.42857142857143
5857, 2.1166666666667, 0.58, 0.42857142857143
5858, 2.1166666666667, 0.5, 0.42857142857143
5859, 2.1166666666667, 0.42, 0.42857142857143
5860, 2.1166666666667, 0.34, 0.42857142857143
5861, 2.1166666666667, 0.26, 0.42857142857143
5862, 2.1166666666667, 0.18, 0.42857142857143
5863, 1.2833333333333, 0.025, 0.071428571428571
5864, 1.3666666666667, 0.025, 0.071428571428571
5865, 1.45, 0.025, 0.071428571428571
5866, 1.5333333333333, 0.025, 0.071428571428571
5867, 1.6166666666667, 0.025, 0.071428571428571
5868, 1.7, 0.025, 0.071428571428571
5869, 1.7833333333333, 0.025, 0.071428571428571
5870, 1.8666666666667, 0.025, 0.071428571428571
5871, 1.95, 0.025, 0.071428571428571
5872, 2.0333333333333, 0.025, 0.071428571428571
5873, 2.1166666666667, 0.025, 0.071428571428571
5874, 1.2833333333333, 0.025, 0.14285714285714
5875, 1.3666666666667, 0.025, 0.14285714285714
5876, 1.45, 0.025, 0.14285714285714
5877, 1.5333333333333, 0.025, 0.14285714285714
5878, 1.6166666666667, 0.025, 0.14285714285714
5879, 1.7, 0.025, 0.14285714285714
5880, 1.7833333333333, 0.025, 0.14285714285714
5881, 1.8666666666667, 0.025, 0.14285714285714
5882, 1.95, 0.025, 0.14285714285714
5883, 2.0333333333333, 0.025, 0.14285714285714
5884, 2.1166666666667, 0.025, 0.14285714285714
5885, 1.2833333333333, 0.025, 0.21428571428571
5886, 1.3666666666667, 0.025, 0.21428571428571
5887, 1.45, 0.025, 0.21428571428571
5888, 1.5333333333333, 0.025, 0.21428571428571
5889, 1.6166666666667, 0.025, 0.21428571428571
5890, 1.7, 0.025, 0.21428571428571
5891, 1.7833333333333, 0.025, 0.21428571428571
5892, 1.8666666666667, 0.025, 0.21428571428571
5893, 1.95, 0.025, 0.21428571428571
5894, 2.0333333333333, 0.025, 0.21428571428571
5895, 2.1166666666667, 0.025, 0.21428571428571
5896, 1.2833333333333, 0.025, 0.28571428571429
5897, 1.3666666666667, 0.025, 0.28571428571429
5898, 1.45, 0.025, 0.28571428571429
5899, 1.5333333333333, 0.025, 0.28571428571429
5900, 1.6166666666667, 0.025, 0.28571428571429
5901, 1.7, 0.025, 0.28571428571429
5902, 1.7833333333333, 0.025, 0.28571428571429
5903, 1.8666666666667, 0.025, 0.28571428571429
5904, 1.95, 0.025, 0.28571428571429
5905, 2.0333333333333, 0.025, 0.28571428571429
5906, 2.1166666666667, 0.025, 0.28571428571429
5907, 1.2833333333333, 0.025, 0.35714285714286
5908, 1.3666666666667, 0.025, 0.35714285714286
5909, 1.45, 0.025, 0.35714285714286
5910, 1.5333333333333, 0.025, 0.35714285714286
5911, 1.6166666666667, 0.025, 0.35714285714286
5912, 1.7, 0.025, 0.35714285714286
5913, 1.7833333333333, 0.025, 0.35714285714286
5914, 1.8666666666667, 0.025, 0.35714285714286
5915, 1.95, 0.025, 0.35714285714286
5916, 2.0333333333333, 0.025, 0.35714285714286
5917, 2.1166666666667, 0.025, 0.35714285714286
5918, 1.2833333333333, 0.025, 0.42857142857143
5919, 1.3666666666667, 0.025, 0.42857142857143
5920, 1.45, 0.025, 0.42857142857143
5921, 1.5333333333333, 0.025, 0.42857142857143
5922, 1.6166666666667, 0.025, 0.42857142857143
5923, 1.7, 0.025, 0.42857142857143
5924, 1.7833333333333, 0.025, 0.42857142857143
5925, 1.8666666666667, 0.025, 0.42857142857143
5926, 1.95, 0.025, 0.42857142857143
5927, 2.0333333333333, 0.025, 0.42857142857143
5928, 2.1166666666667, 0.025, 0.42857142857143
5929, 0.083333333333333, 1.5, 0.071428571428571
5930, 0.083333333333333, 1.5, 0.14285714285714
5931, 0.083333333333333, 1.5, 0.21428571428571
5932, 0.083333333333333, 1.5, 0.28571428571429
5933, 0.083333333333333, 1.5, 0.35714285714286
5934, 0.083333333333333, 1.5, 0.42857142857143
5935, 0.16666666666667, 1.5, 0.071428571428571
5936, 0.16666666666667, 1.5, 0.14285714285714
5937, 0.16666666666667, 1.5, 0.21428571428571
5938, 0.16666666666667, 1.5, 0.28571428571429
5939, 0.16666666666667, 1.5, 0.35714285714286
5940, 0.16666666666667, 1.5, 0.42857142857143
5941, 0.25, 1.5, 0.071428571428571
5942, 0.25, 1.5, 0.14285714285714
5943, 0.25, 1.5, 0.21428571428571
5944, 0.25, 1.5, 0.28571428571429
5945, 0.25, 1.5, 0.35714285714286
5946, 0.25, 1.5, 0.42857142857143
5947, 0.33333333333333, 1.5, 0.071428571428571
5948, 0.33333333333333, 1.5, 0.14285714285714
5949, 0.33333333333333, 1.5, 0.21428571428571
5950, 0.33333333333333, 1.5, 0.28571428571429
5951, 0.33333333333333, 1.5, 0.35714285714286
5952, 0.33333333333333, 1.5, 0.42857142857143
5953, 0.41666666666667, 1.5, 0.071428571428571
5954, 0.41666666666667, 1.5, 0.14285714285714
5955, 0.41666666666667, 1.5, 0.21428571428571
5956, 0.41666666666667, 1.5, 0.28571428571429
5957, 0.41666666666667, 1.5, 0.35714285714286
5958, 0.41666666666667, 1.5, 0.42857142857143
5959, 0.5, 1.5, 0.071428571428571
5960, 0.5, 1.5, 0.14285714285714
5961, 0.5, 1.5, 0.21428571428571
5962, 0.5, 1.5, 0.28571428571429
5963, 0.5, 1.5, 0.35714285714286
5964, 0.5, 1.5, 0.42857142857143
5965, 0.58333333333333, 1.5, 0.071428571428571
5966, 0.58333333333333, 1.5, 0.14285714285714
5967, 0.58333333333333, 1.5, 0.21428571428571
5968, 0.58333333333333, 1.5, 0.28571428571429
5969, 0.58333333333333, 1.5, 0.35714285714286
5970, 0.58333333333333, 1.5, 0.42857142857143
5971, 0.66666666666667, 1.5, 0.071428571428571
5972, 0.66666666666667, 1.5, 0.14285714285714
5973, 0.66666666666667, 1.5, 0.21428571428571
5974, 0.66666666666667, 1.5, 0.28571428571429
5975, 0.66666666666667, 1.5, 0.35714285714286
5976, 0.66666666666667, 1.5, 0.42857142857143
5977, 0.75, 1.5, 0.071428571428571
5978, 0.75, 1.5, 0.14285714285714
5979, 0.75, 1.5, 0.21428571428571
5980, 0.75, 1.5, 0.28571428571429
5981, 0.75, 1.5, 0.35714285714286
5982, 0.75, 1.5, 0.42857142857143
5983, 0.83333333333333, 1.5, 0.071428571428571
5984, 0.83333333333333, 1.5, 0.14285714285714
5985, 0.83333333333333, 1.5, 0.21428571428571
5986, 0.83333333333333, 1.5, 0.28571428571429
5987, 0.83333333333333, 1.5, 0.35714285714286
5988, 0.83333333333333, 1.5, 0.42857142857143
5989, 0.91666666666667, 1.5, 0.071428571428571
5990, 0.91666666666667, 1.5, 0.14285714285714
5991, 0.91666666666667, 1.5, 0.21428571428571
5992, 0.91666666666667, 1.5, 0.28571428571429
5993, 0.91666666666667, 1.5, 0.35714285714286
5994, 0.91666666666667, 1.5, 0.42857142857143
5995, 1.2833333333333, 1.5, 0.071428571428571
5996, 1.3666666666667, 1.5, 0.071428571428571
5997, 1.45, 1.5, 0.071428571428571
5998, 1.5333333333333, 1.5, 0.071428571428571
5999, 1.6166666666667, 1.5, 0.071428571428571
6000, 1.7, 1.5, 0.071428571428571
6001, 1.7833333333333, 1.5, 0.071428571428571
6002, 1.8666666666667, 1.5, 0.071428571428571
6003, 1.95, 1.5, 0.071428571428571
6004, 2.0333333333333, 1.5, 0.071428571428571
6005, 2.1166666666667, 1.5, 0.071428571428571
6006, 1.2833333333333, 1.5, 0.14285714285714
6007, 1.3666666666667, 1.5, 0.14285714285714
6008, 1.45, 1.5, 0.14285714285714
6009, 1.5333333333333, 1.5, 0.14285714285714
6010, 1.6166666666667, 1.5, 0.14285714285714
6011, 1.7, 1.5, 0.14285714285714
6012, 1.7833333333333, 1.5, 0.14285714285714
6013, 1.8666666666667, 1.5, 0.14285714285714
6014, 1.95, 1.5, 0.14285714285714
6015, 2.0333333333333, 1.5, 0.14285714285714
6016, 2.1166666666667, 1.5, 0.14285714285714
6017, 1.2833333333333, 1.5, 0.21428571428571
6018, 1.3666666666667, 1.5, 0.21428571428571
6019, 1.45, 1.5, 0.21428571428571
6020, 1.5333333333333, 1.5, 0.21428571428571
6021, 1.6166666666667, 1.5, 0.21428571428571
6022, 1.7, 1.5, 0.21428571428571
6023, 1.7833333333333, 1.5, 0.21428571428571
6024, 1.8666666666667, 1.5, 0.21428571428571
6025, 1.95, 1.5, 0.21428571428571
6026, 2.0333333333333, 1.5, 0.21428571428571
6027, 2.1166666666667, 1.5, 0.21428571428571
6028, 1.2833333333333, 1.5, 0.28571428571429
6029, 1.3666666666667, 1.5, 0.28571428571429
6030, 1.45, 1.5, 0.28571428571429
6031, 1.5333333333333, 1.5, 0.28571428571429
6032, 1.6166666666667, 1.5, 0.28571428571429
6033, 1.7, 1.5, 0.28571428571429
6034, 1.7833333333333, 1.5, 0.28571428571429
6035, 1.8666666666667, 1.5, 0.28571428571429
6036, 1.95, 1.5, 0.28571428571429
6037, 2.0333333333333, 1.5, 0.28571428571429
6038, 2.1166666666667, 1.5, 0.28571428571429
6039, 1.2833333333333, 1.5, 0.35714285714286
6040, 1.3666666666667, 1.5, 0.35714285714286
6041, 1.45, 1.5, 0.35714285714286
6042, 1.5333333333333, 1.5, 0.35714285714286
6043, 1.6166666666667, 1.5, 0.35714285714286
6044, 1.7, 1.5, 0.35714285714286
6045, 1.7833333333333, 1.5, 0.35714285714286
6046, 1.8666666666667, 1.5, 0.35714285714286
6047, 1.95, 1.5, 0.35714285714286
6048, 2.0333333333333, 1.5, 0.35714285714286
6049, 2.1166666666667, 1.5, 0.35714285714286
6050, 1.2833333333333, 1.5, 0.42857142857143
6051, 1.3666666666667, 1.5, 0.42857142857143
6052, 1.45, 1.5, 0.42857142857143
6053, 1.5333333333333, 1.5, 0.42857142857143
6054, 1.6166666666667, 1.5, 0.42857142857143
6055, 1.7, 1.5, 0.42857142857143
6056, 1.7833333333333, 1.5, 0.42857142857143
6057, 1.8666666666667, 1.5, 0.42857142857143
6058, 1.95, 1.5, 0.42857142857143
6059, 2.0333333333333, 1.5, 0.42857142857143
6060, 2.1166666666667, 1.5, 0.42857142857143
6061, 0.083333333333333, -0.1, 0.071428571428571
6062, 0.083333333333333, -0.1, 0.14285714285714
6063, 0.083333333333333, -0.1, 0.21428571428571
6064, 0.083333333333333, -0.1, 0.28571428571429
6065, 0.083333333333333, -0.1, 0.35714285714286
6066, 0.083333333333333, -0.1, 0.42857142857143
6067, 0.16666666666667, -0.1, 0.071428571428571
6068, 0.16666666666667, -0.1, 0.14285714285714
6069, 0.16666666666667, -0.1, 0.21428571428571
6070, 0.16666666666667, -0.1, 0.28571428571429
6071, 0.16666666666667, -0.1, 0.35714285714286
6072, 0.16666666666667, -0.1, 0.42857142857143
6073, 0.25, -0.1, 0.071428571428571
6074, 0.25, -0.1, 0.14285714285714
6075, 0.25, -0.1, 0.21428571428571
6076, 0.25, -0.1, 0.28571428571429
6077, 0.25, -0.1, 0.35714285714286
6078, 0.25, -0.1, 0.42857142857143
6079, 0.33333333333333, -0.1, 0.071428571428571
6080, 0.33333333333333, -0.1, 0.14285714285714
6081, 0.33333333333333, -0.1, 0.21428571428571
6082, 0.33333333333333, -0.1, 0.28571428571429
6083, 0.33333333333333, -0.1, 0.35714285714286
6084, 0.33333333333333, -0.1, 0.42857142857143
6085, 0.41666666666667, -0.1, 0.071428571428571
6086, 0.41666666666667, -0.1, 0.14285714285714
6087, 0.41666666666667, -0.1, 0.21428571428571
6088, 0.41666666666667, -0.1, 0.28571428571429
6089, 0.41666666666667, -0.1, 0.35714285714286
6090, 0.41666666666667, -0.1, 0.42857142857143
6091, 0.5, -0.1, 0.071428571428571
6092, 0.5, -0.1, 0.14285714285714
6093, 0.5, -0.1, 0.21428571428571
6094, 0.5, -0.1, 0.28571428571429
6095, 0.5, -0.1, 0.35714285714286
6096, 0.5, -0.1, 0.42857142857143
6097, 0.58333333333333, -0.1, 0.071428571428571
6098, 0.58333333333333, -0.1, 0.14285714285714
6099, 0.58333333333333, -0.1, 0.21428571428571
6100, 0.58333333333333, -0.1, 0.28571428571429
6101, 0.58333333333333, -0.1, 0.35714285714286
6102, 0.58333333333333, -0.1, 0.42857142857143
6103, 0.66666666666667, -0.1, 0.071428571428571
6104, 0.66666666666667, -0.1, 0.14285714285714
6105, 0.66666666666667, -0.1, 0.21428571428571
6106, 0.66666666666667, -0.1, 0.28571428571429
6107, 0.66666666666667, -0.1, 0.35714285714286
6108, 0.66666666666667, -0.1, 0.42857142857143
6109, 0.75, -0.1, 0.071428571428571
6110, 0.75, -0.1, 0.14285714285714
6111, 0.75, -0.1, 0.21428571428571
6112, 0.75, -0.1, 0.28571428571429
6113, 0.75, -0.1, 0.35714285714286
6114, 0.75, -0.1, 0.42857142857143
6115, 0.83333333333333, -0.1, 0.071428571428571
6116, 0.83333333333333, -0.1, 0.14285714285714
6117, 0.83333333333333, -0.1, 0.21428571428571
6118, 0.83333333333333, -0.1, 0.28571428571429
6119, 0.83333333333333, -0.1, 0.35714285714286
6120, 0.83333333333333, -0.1, 0.42857142857143
6121, 0.91666666666667, -0.1, 0.071428571428571
6122, 0.91666666666667, -0.1, 0.14285714285714
6123, 0.91666666666667, -0.1, 0.21428571428571
6124, 0.91666666666667, -0.1, 0.28571428571429
6125, 0.91666666666667, -0.1, 0.35714285714286
6126, 0.91666666666667, -0.1, 0.42857142857143
6127, 1.2833333333333, -0.1, 0.071428571428571
6128, 1.3666666666667, -0.1, 0.071428571428571
6129, 1.45, -0.1, 0.071428571428571
6130, 1.5333333333333, -0.1, 0.071428571428571
6131, 1.6166666666667, -0.1, 0.071428571428571
6132, 1.7, -0.1, 0.071428571428571
6133, 1.7833333333333, -0.1, 0.071428571428571
6134, 1.8666666666667, -0.1, 0.071428571428571
6135, 1.95, -0.1, 0.071428571428571
6136, 2.0333333333333, -0.1, 0.071428571428571
6137, 2.1166666666667, -0.1, 0.071428571428571
6138, 1.2833333333333, -0.1, 0.14285714285714
6139, 1.3666666666667, -0.1, 0.14285714285714
6140, 1.45, -0.1, 0.14285714285714
6141, 1.5333333333333, -0.1, 0.14285714285714
6142, 1.6166666666667, -0.1, 0.14285714285714
6143, 1.7, -0.1, 0.14285714285714
6144, 1.7833333333333, -0.1, 0.14285714285714
6145, 1.8666666666667, -0.1, 0.14285714285714
6146, 1.95, -0.1, 0.14285714285714
6147, 2.0333333333333, -0.1, 0.14285714285714
6148, 2.1166666666667, -0.1, 0.14285714285714
6149, 1.2833333333333, -0.1, 0.21428571428571
6150, 1.3666666666667, -0.1, 0.21428571428571
6151, 1.45, -0.1, 0.21428571428571
6152, 1.5333333333333, -0.1, 0.21428571428571
6153, 1.6166666666667, -0.1, 0.21428571428571
6154, 1.7, -0.1, 0.21428571428571
6155, 1.7833333333333, -0.1, 0.21428571428571
6156, 1.8666666666667, -0.1, 0.21428571428571
6157, 1.95, -0.1, 0.21428571428571
6158, 2.0333333333333, -0.1, 0.21428571428571
6159, 2.1166666666667, -0.1, 0.21428571428571
6160, 1.2833333333333, -0.1, 0.28571428571429
6161, 1.3666666666667, -0.1, 0.28571428571429
6162, 1.45, -0.1, 0.28571428571429
6163, 1.5333333333333, -0.1, 0.28571428571429
6164, 1.6166666666667, -0.1, 0.28571428571429
6165, 1.7, -0.1, 0.28571428571429
6166, 1.7833333333333, -0.1, 0.28571428571429
6167, 1.8666666666667, -0.1, 0.28571428571429
6168, 1.95, -0.1, 0.28571428571429
6169, 2.0333333333333, -0.1, 0.28571428571429
6170, 2.1166666666667, -0.1, 0.28571428571429
6171, 1.2833333333333, -0.1, 0.35714285714286
6172, 1.3666666666667, -0.1, 0.35714285714286
6173, 1.45, -0.1, 0.35714285714286
6174, 1.5333333333333, -0.1, 0.35714285714286
6175, 1.6166666666667, -0.1, 0.35714285714286
6176, 1.7, -0.1, 0.35714285714286
6177, 1.7833333333333, -0.1, 0.35714285714286
6178, 1.8666666666667, -0.1, 0.35714285714286
6179, 1.95, -0.1, 0.35714285714286
6180, 2.0333333333333, -0.1, 0.35714285714286
6181, 2.1166666666667, -0.1, 0.35714285714286
6182, 1.2833333333333, -0.1, 0.42857142857143
6183, 1.3666666666667, -0.1, 0.42857142857143
6184, 1.45, -0.1, 0.42857142857143
6185, 1.5333333333333, -0.1, 0.42857142857143
6186, 1.6166666666667, -0.1, 0.42857142857143
6187, 1.7, -0.1, 0.42857142857143
6188, 1.7833333333333, -0.1, 0.42857142857143
6189, 1.8666666666667, -0.1, 0.42857142857143
6190, 1.95, -0.1, 0.42857142857143
6191, 2.0333333333333, -0.1, 0.42857142857143
6192, 2.1166666666667, -0.1, 0.42857142857143
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 99
100, 99, 100
101, 100, 101
102, 101, 102
103, 102, 1
*ELEMENT, type=T3D2, ELSET=Line2
104, 1, 103
105, 103, 3
*ELEMENT, type=T3D2, ELSET=Line3
106, 4, 104
107, 104, 105
108, 105, 106
109, 106, 107
110, 107, 108
111, 108, 109
112, 109, 3
*ELEMENT, type=T3D2, ELSET=Line4
113, 2, 110
114, 110, 4
*ELEMENT, type=T3D2, ELSET=Line5
115, 6, 111
116, 111, 112
117, 112, 113
118, 113, 114
119, 114, 115
120, 115, 116
121, 116, 5
*ELEMENT, type=T3D2, ELSET=Line6
122, 5, 117
123, 117, 7
*ELEMENT, type=T3D2, ELSET=Line7
124, 8, 118
125, 118, 119
126, 119, 120
127, 120, 121
128, 121, 122
129, 122, 123
130, 123, 7
*ELEMENT, type=T3D2, ELSET=Line8
131, 6, 124
132, 124, 8
*ELEMENT, type=T3D2, ELSET=Line9
133, 2, 125
134, 125, 126
135, 126, 127
136, 127, 128
137, 128, 129
138, 129, 130
139, 130, 131
140, 131, 132
141, 132, 133
142, 133, 134
143, 134, 135
144, 135, 6
*ELEMENT, type=T3D2, ELSET=Line10
145, 1, 136
146, 136, 137
147, 137, 138
148, 138, 139
149, 139, 140
150, 140, 141
151, 141, 142
152, 142, 143
153, 143, 144
154, 144, 145
155, 145, 146
156, 146, 5
*ELEMENT, type=T3D2, ELSET=Line11
157, 4, 147
158, 147, 148
159, 148, 149
160, 149, 150
161, 150, 151
162, 151, 152
163, 152, 153
164, 153, 154
165, 154, 155
166, 155, 156
167, 156, 157
168, 157, 8
*ELEMENT, type=T3D2, ELSET=Line12
169, 3, 158
170, 158, 159
171, 159, 160
172, 160, 161
173, 161, 162
174, 162, 163
175, 163, 164
176, 164, 165
177, 165, 166
178, 166, 167
179, 167, 168
180, 168, 7
*ELEMENT, type=T3D2, ELSET=Line13
181, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
182, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
183, 10, 169
184, 169, 170
185, 170, 171
186, 171, 172
187, 172, 173
188, 173, 174
189, 174, 175
190, 175, 176
191, 176, 177
192, 177, 178
193, 178, 179
194, 179, 9
*ELEMENT, type=T3D2, ELSET=Line16
195, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
196, 9, 180
197, 180, 181
198, 181, 182
199, 182, 183
200, 183, 184
201, 184, 185
202, 185, 11
*ELEMENT, type=T3D2, ELSET=Line18
203, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
204, 12, 186
205, 186, 187
206, 187, 188
207, 188, 189
208, 189, 190
209, 190, 191
210, 191, 192
211, 192, 193
212, 193, 194
213, 194, 195
214, 195, 196
215, 196, 11
*ELEMENT, type=T3D2, ELSET=Line20
216, 10, 197
217, 197, 198
218, 198, 199
219, 199, 200
220, 200, 201
221, 201, 202
222, 202, 12
*ELEMENT, type=T3D2, ELSET=Line21
223, 9, 203
224, 203, 204
225, 204, 205
226, 205, 206
227, 206, 207
228, 207, 208
229, 208, 209
230, 209, 210
231, 210, 211
232, 211, 212
233, 212, 213
234, 213, 214
235, 214, 215
236, 215, 216
237, 216, 13
*ELEMENT, type=T3D2, ELSET=Line22
238, 10, 217
239, 217, 218
240, 218, 219
241, 219, 220
242, 220, 221
243, 221, 222
244, 222, 223
245, 223, 224
246, 224, 225
247, 225, 226
248, 226, 227
249, 227, 228
250, 228, 229
251, 229, 230
252, 230, 14
*ELEMENT, type=T3D2, ELSET=Line23
253, 14, 231
254, 231, 232
255, 232, 233
256, 233, 234
257, 234, 235
258, 235, 236
259, 236, 237
260, 237, 238
261, 238, 239
262, 239, 240
263, 240, 241
264, 241, 13
*ELEMENT, type=T3D2, ELSET=Line24
265, 11, 242
266, 242, 243
267, 243, 244
268, 244, 245
269, 245, 246
270, 246, 247
271, 247, 248
272, 248, 249
273, 249, 250
274, 250, 251
275, 251, 252
276, 252, 253
277, 253, 254
278, 254, 255
279, 255, 15
*ELEMENT, type=T3D2, ELSET=Line25
280, 13, 256
281, 256, 257
282, 257, 258
283, 258, 259
284, 259, 260
285, 260, 261
286, 261, 15
*ELEMENT, type=T3D2, ELSET=Line26
287, 12, 262
288, 262, 263
289, 263, 264
290, 264, 265
291, 265, 266
292, 266, 267
293, 267, 268
294, 268, 269
295, 269, 270
296, 270, 271
297, 271, 272
298, 272, 273
299, 273, 274
300, 274, 275
301, 275, 16
*ELEMENT, type=T3D2, ELSET=Line27
302, 16, 276
303, 276, 277
304, 277, 278
305, 278, 279
306, 279, 280
307, 280, 281
308, 281, 282
309, 282, 283
310, 283, 284
311, 284, 285
312, 285, 286
313, 286, 15
*ELEMENT, type=T3D2, ELSET=Line28
314, 14, 287
315, 287, 288
316, 288, 289
317, 289, 290
318, 290, 291
319, 291, 292
320, 292, 16
*ELEMENT, type=T3D2, ELSET=Line29
321, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
322, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
323, 18, 293
324, 293, 294
325, 294, 295
326, 295, 296
327, 296, 297
328, 297, 298
329, 298, 299
330, 299, 300
331, 300, 301
332, 301, 302
333, 302, 303
334, 303, 17
*ELEMENT, type=T3D2, ELSET=Line32
335, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
336, 17, 304
337, 304, 305
338, 305, 306
339, 306, 307
340, 307, 308
341, 308, 309
342, 309, 19
*ELEMENT, type=T3D2, ELSET=Line34
343, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
344, 20, 310
345, 310, 311
346, 311, 312
347, 312, 313
348, 313, 314
349, 314, 315
350, 315, 316
351, 316, 317
352, 317, 318
353, 318, 319
354, 319, 320
355, 320, 19
*ELEMENT, type=T3D2, ELSET=Line36
356, 18, 321
357, 321, 322
358, 322, 323
359, 323, 324
360, 324, 325
361, 325, 326
362, 326, 20
*ELEMENT, type=T3D2, ELSET=Line37
363, 17, 327
364, 327, 21
*ELEMENT, type=T3D2, ELSET=Line38
365, 18, 328
366, 328, 22
*ELEMENT, type=T3D2, ELSET=Line39
367, 22, 329
368, 329, 330
369, 330, 331
370, 331, 332
371, 332, 333
372, 333, 334
373, 334, 335
374, 335, 336
375, 336, 337
376, 337, 338
377, 338, 339
378, 339, 21
*ELEMENT, type=T3D2, ELSET=Line40
379, 19, 340
380, 340, 23
*ELEMENT, type=T3D2, ELSET=Line41
381, 21, 341
382, 341, 342
383, 342, 343
384, 343, 344
385, 344, 345
386, 345, 346
387, 346, 23
*ELEMENT, type=T3D2, ELSET=Line42
388, 20, 347
389, 347, 24
*ELEMENT, type=T3D2, ELSET=Line43
390, 24, 348
391, 348, 349
392, 349, 350
393, 350, 351
394, 351, 352
395, 352, 353
396, 353, 354
397, 354, 355
398, 355, 356
399, 356, 357
400, 357, 358
401, 358, 23
*ELEMENT, type=T3D2, ELSET=Line44
402, 22, 359
403, 359, 360
404, 360, 361
405, 361, 362
406, 362, 363
407, 363, 364
408, 364, 24
*ELEMENT, type=T3D2, ELSET=Line45
409, 19, 25
*ELEMENT, type=T3D2, ELSET=Line46
410, 23, 26
*ELEMENT, type=T3D2, ELSET=Line47
411, 25, 365
412, 365, 26
*ELEMENT, type=T3D2, ELSET=Line48
413, 17, 27
*ELEMENT, type=T3D2, ELSET=Line49
414, 21, 28
*ELEMENT, type=T3D2, ELSET=Line50
415, 27, 366
416, 366, 28
*ELEMENT, type=T3D2, ELSET=Line51
417, 27, 367
418, 367, 368
419, 368, 369
420, 369, 370
421, 370, 371
422, 371, 372
423, 372, 25
*ELEMENT, type=T3D2, ELSET=Line52
424, 28, 373
425, 373, 374
426, 374, 375
427, 375, 376
428, 376, 377
429, 377, 378
430, 378, 26
*ELEMENT, type=T3D2, ELSET=Line53
431, 25, 379
432, 379, 380
433, 380, 381
434, 381, 382
435, 382, 383
436, 383, 384
437, 384, 385
438, 385, 386
439, 386, 387
440, 387, 388
441, 388, 389
442, 389, 29
*ELEMENT, type=T3D2, ELSET=Line54
443, 26, 390
444, 390, 391
445, 391, 392
446, 392, 393
447, 393, 394
448, 394, 395
449, 395, 396
450, 396, 397
451, 397, 398
452, 398, 399
453, 399, 400
454, 400, 30
*ELEMENT, type=T3D2, ELSET=Line55
455, 29, 401
456, 401, 30
*ELEMENT, type=T3D2, ELSET=Line56
457, 27, 402
458, 402, 403
459, 403, 404
460, 404, 405
461, 405, 406
462, 406, 407
463, 407, 408
464, 408, 409
465, 409, 410
466, 410, 411
467, 411, 412
468, 412, 31
*ELEMENT, type=T3D2, ELSET=Line57
469, 28, 413
470, 413, 414
471, 414, 415
472, 415, 416
473, 416, 417
474, 417, 418
475, 418, 419
476, 419, 420
477, 420, 421
478, 421, 422
479, 422, 423
480, 423, 32
*ELEMENT, type=T3D2, ELSET=Line58
481, 31, 424
482, 424, 32
*ELEMENT, type=T3D2, ELSET=Line59
483, 31, 425
484, 425, 426
485, 426, 427
486, 427, 428
487, 428, 429
488, 429, 430
489, 430, 29
*ELEMENT, type=T3D2, ELSET=Line60
490, 32, 431
491, 431, 432
492, 432, 433
493, 433, 434
494, 434, 435
495, 435, 436
496, 436, 30
*ELEMENT, type=T3D2, ELSET=Line61
497, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
498, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
499, 33, 437
500, 437, 438
501, 438, 439
502, 439, 440
503, 440, 441
504, 441, 442
505, 442, 443
506, 443, 444
507, 444, 445
508, 445, 446
509, 446, 447
510, 447, 34
*ELEMENT, type=T3D2, ELSET=Line64
511, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
512, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
513, 35, 448
514, 448, 449
515, 449, 450
516, 450, 451
517, 451, 452
518, 452, 453
519, 453, 454
520, 454, 455
521, 455, 456
522, 456, 457
523, 457, 458
524, 458, 36
*ELEMENT, type=T3D2, ELSET=Line67
525, 35, 459
526, 459, 460
527, 460, 461
528, 461, 462
529, 462, 463
530, 463, 464
531, 464, 33
*ELEMENT, type=T3D2, ELSET=Line68
532, 36, 465
533, 465, 466
534, 466, 467
535, 467, 468
536, 468, 469
537, 469, 470
538, 470, 34
*ELEMENT, type=T3D2, ELSET=Line69
539, 33, 471
540, 471, 472
541, 472, 473
542, 473, 474
543, 474, 475
544, 475, 476
545, 476, 477
546, 477, 478
547, 478, 479
548, 479, 480
549, 480, 481
550, 481, 482
551, 482, 483
552, 483, 484
553, 484, 37
*ELEMENT, type=T3D2, ELSET=Line70
554, 34, 485
555, 485, 486
556, 486, 487
557, 487, 488
558, 488, 489
559, 489, 490
560, 490, 491
561, 491, 492
562, 492, 493
563, 493, 494
564, 494, 495
565, 495, 496
566, 496, 497
567, 497, 498
568, 498, 38
*ELEMENT, type=T3D2, ELSET=Line71
569, 37, 499
570, 499, 500
571, 500, 501
572, 501, 502
573, 502, 503
574, 503, 504
575, 504, 505
576, 505, 506
577, 506, 507
578, 507, 508
579, 508, 509
580, 509, 38
*ELEMENT, type=T3D2, ELSET=Line72
581, 35, 510
582, 510, 511
583, 511, 512
584, 512, 513
585, 513, 514
586, 514, 515
587, 515, 516
588, 516, 517
589, 517, 518
590, 518, 519
591, 519, 520
592, 520, 521
593, 521, 522
594, 522, 523
595, 523, 39
*ELEMENT, type=T3D2, ELSET=Line73
596, 36, 524
597, 524, 525
598, 525, 526
599, 526, 527
600, 527, 528
601, 528, 529
602, 529, 530
603, 530, 531
604, 531, 532
605, 532, 533
606, 533, 534
607, 534, 535
608, 535, 536
609, 536, 537
610, 537, 40
*ELEMENT, type=T3D2, ELSET=Line74
611, 39, 538
612, 538, 539
613, 539, 540
614, 540, 541
615, 541, 542
616, 542, 543
617, 543, 544
618, 544, 545
619, 545, 546
620, 546, 547
621, 547, 548
622, 548, 40
*ELEMENT, type=T3D2, ELSET=Line75
623, 39, 549
624, 549, 550
625, 550, 551
626, 551, 552
627, 552, 553
628, 553, 554
629, 554, 37
*ELEMENT, type=T3D2, ELSET=Line76
630, 40, 555
631, 555, 556
632, 556, 557
633, 557, 558
634, 558, 559
635, 559, 560
636, 560, 38
*ELEMENT, type=T3D2, ELSET=Line77
637, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
638, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
639, 41, 561
640, 561, 562
641, 562, 563
642, 563, 564
643, 564, 565
644, 565, 566
645, 566, 567
646, 567, 568
647, 568, 569
648, 569, 570
649, 570, 571
650, 571, 42
*ELEMENT, type=T3D2, ELSET=Line80
651, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
652, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
653, 43, 572
654, 572, 573
655, 573, 574
656, 574, 575
657, 575, 576
658, 576, 577
659, 577, 578
660, 578, 579
661, 579, 580
662, 580, 581
663, 581, 582
664, 582, 44
*ELEMENT, type=T3D2, ELSET=Line83
665, 43, 583
666, 583, 584
667, 584, 585
668, 585, 586
669, 586, 587
670, 587, 588
671, 588, 41
*ELEMENT, type=T3D2, ELSET=Line84
672, 44, 589
673, 589, 590
674, 590, 591
675, 591, 592
676, 592, 593
677, 593, 594
678, 594, 42
*ELEMENT, type=T3D2, ELSET=Line85
679, 41, 595
680, 595, 45
*ELEMENT, type=T3D2, ELSET=Line86
681, 42, 596
682, 596, 46
*ELEMENT, type=T3D2, ELSET=Line87
683, 45, 597
684, 597, 598
685, 598, 599
686, 599, 600
687, 600, 601
688, 601, 602
689, 602, 603
690, 603, 604
691, 604, 605
692, 605, 606
693, 606, 607
694, 607, 46
*ELEMENT, type=T3D2, ELSET=Line88
695, 43, 608
696, 608, 47
*ELEMENT, type=T3D2, ELSET=Line89
697, 44, 609
698, 609, 48
*ELEMENT, type=T3D2, ELSET=Line90
699, 47, 610
700, 610, 611
701, 611, 612
702, 612, 613
703, 613, 614
704, 614, 615
705, 615, 616
706, 616, 617
707, 617, 618
708, 618, 619
709, 619, 620
710, 620, 48
*ELEMENT, type=T3D2, ELSET=Line91
711, 47, 621
712, 621, 622
713, 622, 623
714, 623, 624
715, 624, 625
716, 625, 626
717, 626, 45
*ELEMENT, type=T3D2, ELSET=Line92
718, 48, 627
719, 627, 628
720, 628, 629
721, 629, 630
722, 630, 631
723, 631, 632
724, 632, 46
*ELEMENT, type=T3D2, ELSET=Line93
725, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
726, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
727, 49, 633
728, 633, 50
*ELEMENT, type=T3D2, ELSET=Line96
729, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
730, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
731, 51, 634
732, 634, 52
*ELEMENT, type=T3D2, ELSET=Line99
733, 51, 635
734, 635, 636
735, 636, 637
736, 637, 638
737, 638, 639
738, 639, 640
739, 640, 49
*ELEMENT, type=T3D2, ELSET=Line100
740, 52, 641
741, 641, 642
742, 642, 643
743, 643, 644
744, 644, 645
745, 645, 646
746, 646, 50
*ELEMENT, type=T3D2, ELSET=Line101
747, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
748, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
749, 54, 647
750, 647, 648
751, 648, 649
752, 649, 650
753, 650, 651
754, 651, 652
755, 652, 53
*ELEMENT, type=T3D2, ELSET=Line104
756, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
757, 53, 653
758, 653, 55
*ELEMENT, type=T3D2, ELSET=Line106
759, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
760, 56, 654
761, 654, 655
762, 655, 656
763, 656, 657
764, 657, 658
765, 658, 659
766, 659, 55
*ELEMENT, type=T3D2, ELSET=Line108
767, 54, 660
768, 660, 56
*ELEMENT, type=T3D2, ELSET=Line125
769, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
770, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
771, 57, 661
772, 661, 662
773, 662, 663
774, 663, 664
775, 664, 665
776, 665, 666
777, 666, 667
778, 667, 668
779, 668, 669
780, 669, 670
781, 670, 671
782, 671, 672
783, 672, 673
784, 673, 674
785, 674, 58
*ELEMENT, type=T3D2, ELSET=Line128
786, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
787, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
788, 59, 675
789, 675, 676
790, 676, 677
791, 677, 678
792, 678, 679
793, 679, 680
794, 680, 681
795, 681, 682
796, 682, 683
797, 683, 684
798, 684, 685
799, 685, 686
800, 686, 687
801, 687, 688
802, 688, 60
*ELEMENT, type=T3D2, ELSET=Line131
803, 59, 689
804, 689, 690
805, 690, 691
806, 691, 692
807, 692, 693
808, 693, 694
809, 694, 57
*ELEMENT, type=T3D2, ELSET=Line132
810, 60, 695
811, 695, 696
812, 696, 697
813, 697, 698
814, 698, 699
815, 699, 700
816, 700, 58
*ELEMENT, type=T3D2, ELSET=Line133
817, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
818, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
819, 61, 701
820, 701, 702
821, 702, 703
822, 703, 704
823, 704, 705
824, 705, 706
825, 706, 707
826, 707, 708
827, 708, 709
828, 709, 710
829, 710, 711
830, 711, 712
831, 712, 713
832, 713, 714
833, 714, 62
*ELEMENT, type=T3D2, ELSET=Line136
834, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
835, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
836, 63, 715
837, 715, 716
838, 716, 717
839, 717, 718
840, 718, 719
841, 719, 720
842, 720, 721
843, 721, 722
844, 722, 723
845, 723, 724
846, 724, 725
847, 725, 726
848, 726, 727
849, 727, 728
850, 728, 64
*ELEMENT, type=T3D2, ELSET=Line139
851, 63, 729
852, 729, 730
853, 730, 731
854, 731, 732
855, 732, 733
856, 733, 734
857, 734, 61
*ELEMENT, type=T3D2, ELSET=Line140
858, 64, 735
859, 735, 736
860, 736, 737
861, 737, 738
862, 738, 739
863, 739, 740
864, 740, 62
*ELEMENT, type=T3D2, ELSET=Line141
865, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
866, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
867, 65, 741
868, 741, 742
869, 742, 743
870, 743, 744
871, 744, 745
872, 745, 746
873, 746, 747
874, 747, 748
875, 748, 749
876, 749, 750
877, 750, 751
878, 751, 752
879, 752, 753
880, 753, 754
881, 754, 66
*ELEMENT, type=T3D2, ELSET=Line144
882, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
883, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
884, 67, 755
885, 755, 756
886, 756, 757
887, 757, 758
888, 758, 759
889, 759, 760
890, 760, 761
891, 761, 762
892, 762, 763
893, 763, 764
894, 764, 765
895, 765, 766
896, 766, 767
897, 767, 768
898, 768, 68
*ELEMENT, type=T3D2, ELSET=Line147
899, 67, 769
900, 769, 770
901, 770, 771
902, 771, 772
903, 772, 773
904, 773, 774
905, 774, 775
906, 775, 776
907, 776, 777
908, 777, 778
909, 778, 779
910, 779, 65
*ELEMENT, type=T3D2, ELSET=Line148
911, 68, 780
912, 780, 781
913, 781, 782
914, 782, 783
915, 783, 784
916, 784, 785
917, 785, 786
918, 786, 787
919, 787, 788
920, 788, 789
921, 789, 790
922, 790, 66
*ELEMENT, type=T3D2, ELSET=Line149
923, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
924, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
925, 69, 791
926, 791, 792
927, 792, 793
928, 793, 794
929, 794, 795
930, 795, 796
931, 796, 797
932, 797, 798
933, 798, 799
934, 799, 800
935, 800, 801
936, 801, 802
937, 802, 803
938, 803, 804
939, 804, 70
*ELEMENT, type=T3D2, ELSET=Line152
940, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
941, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
942, 71, 805
943, 805, 806
944, 806, 807
945, 807, 808
946, 808, 809
947, 809, 810
948, 810, 811
949, 811, 812
950, 812, 813
951, 813, 814
952, 814, 815
953, 815, 816
954, 816, 817
955, 817, 818
956, 818, 72
*ELEMENT, type=T3D2, ELSET=Line155
957, 69, 819
958, 819, 820
959, 820, 821
960, 821, 822
961, 822, 823
962, 823, 824
963, 824, 825
964, 825, 826
965, 826, 827
966, 827, 828
967, 828, 829
968, 829, 71
*ELEMENT, type=T3D2, ELSET=Line156
969, 70, 830
970, 830, 831
971, 831, 832
972, 832, 833
973, 833, 834
974, 834, 835
975, 835, 836
976, 836, 837
977, 837, 838
978, 838, 839
979, 839, 840
980, 840, 72
*ELEMENT, type=T3D2, ELSET=Line157
981, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
982, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
983, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
984, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
985, 73, 841
986, 841, 842
987, 842, 843
988, 843, 844
989, 844, 845
990, 845, 846
991, 846, 847
992, 847, 848
993, 848, 849
994, 849, 850
995, 850, 851
996, 851, 852
997, 852, 853
998, 853, 854
999, 854, 74
*ELEMENT, type=T3D2, ELSET=Line162
1000, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
1001, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
1002, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
1003, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
1004, 75, 855
1005, 855, 856
1006, 856, 857
1007, 857, 858
1008, 858, 859
1009, 859, 860
1010, 860, 861
1011, 861, 862
1012, 862, 863
1013, 863, 864
1014, 864, 865
1015, 865, 866
1016, 866, 867
1017, 867, 868
1018, 868, 76
*ELEMENT, type=T3D2, ELSET=Line167
1019, 21, 869
1020, 869, 77
*ELEMENT, type=T3D2, ELSET=Line168
1021, 22, 870
1022, 870, 78
*ELEMENT, type=T3D2, ELSET=Line169
1023, 78, 871
1024, 871, 872
1025, 872, 873
1026, 873, 874
1027, 874, 875
1028, 875, 876
1029, 876, 877
1030, 877, 878
1031, 878, 879
1032, 879, 880
1033, 880, 881
1034, 881, 77
*ELEMENT, type=T3D2, ELSET=Line170
1035, 23, 882
1036, 882, 79
*ELEMENT, type=T3D2, ELSET=Line171
1037, 77, 883
1038, 883, 884
1039, 884, 885
1040, 885, 886
1041, 886, 887
1042, 887, 888
1043, 888, 79
*ELEMENT, type=T3D2, ELSET=Line172
1044, 24, 889
1045, 889, 80
*ELEMENT, type=T3D2, ELSET=Line173
1046, 80, 890
1047, 890, 891
1048, 891, 892
1049, 892, 893
1050, 893, 894
1051, 894, 895
1052, 895, 896
1053, 896, 897
1054, 897, 898
1055, 898, 899
1056, 899, 900
1057, 900, 79
*ELEMENT, type=T3D2, ELSET=Line174
1058, 78, 901
1059, 901, 902
1060, 902, 903
1061, 903, 904
1062, 904, 905
1063, 905, 906
1064, 906, 80
*ELEMENT, type=T3D2, ELSET=Line175
1065, 26, 907
1066, 907, 81
*ELEMENT, type=T3D2, ELSET=Line176
1067, 79, 81
*ELEMENT, type=T3D2, ELSET=Line177
1068, 28, 908
1069, 908, 82
*ELEMENT, type=T3D2, ELSET=Line178
1070, 77, 82
*ELEMENT, type=T3D2, ELSET=Line179
1071, 82, 909
1072, 909, 910
1073, 910, 911
1074, 911, 912
1075, 912, 913
1076, 913, 914
1077, 914, 81
*ELEMENT, type=T3D2, ELSET=Line180
1078, 30, 915
1079, 915, 83
*ELEMENT, type=T3D2, ELSET=Line181
1080, 81, 916
1081, 916, 917
1082, 917, 918
1083, 918, 919
1084, 919, 920
1085, 920, 921
1086, 921, 922
1087, 922, 923
1088, 923, 924
1089, 924, 925
1090, 925, 926
1091, 926, 83
*ELEMENT, type=T3D2, ELSET=Line182
1092, 32, 927
1093, 927, 84
*ELEMENT, type=T3D2, ELSET=Line183
1094, 82, 928
1095, 928, 929
1096, 929, 930
1097, 930, 931
1098, 931, 932
1099, 932, 933
1100, 933, 934
1101, 934, 935
1102, 935, 936
1103, 936, 937
1104, 937, 938
1105, 938, 84
*ELEMENT, type=T3D2, ELSET=Line184
1106, 84, 939
1107, 939, 940
1108, 940, 941
1109, 941, 942
1110, 942, 943
1111, 943, 944
1112, 944, 83
*ELEMENT, type=T3D2, ELSET=Line185
1113, 6, 945
1114, 945, 85
*ELEMENT, type=T3D2, ELSET=Line186
1115, 2, 946
1116, 946, 86
*ELEMENT, type=T3D2, ELSET=Line187
1117, 86, 947
1118, 947, 948
1119, 948, 949
1120, 949, 950
1121, 950, 951
1122, 951, 952
1123, 952, 953
1124, 953, 954
1125, 954, 955
1126, 955, 956
1127, 956, 957
1128, 957, 85
*ELEMENT, type=T3D2, ELSET=Line188
1129, 5, 958
1130, 958, 87
*ELEMENT, type=T3D2, ELSET=Line189
1131, 85, 959
1132, 959, 960
1133, 960, 961
1134, 961, 962
1135, 962, 963
1136, 963, 964
1137, 964, 87
*ELEMENT, type=T3D2, ELSET=Line190
1138, 1, 965
1139, 965, 88
*ELEMENT, type=T3D2, ELSET=Line191
1140, 88, 966
1141, 966, 967
1142, 967, 968
1143, 968, 969
1144, 969, 970
1145, 970, 971
1146, 971, 972
1147, 972, 973
1148, 973, 974
1149, 974, 975
1150, 975, 976
1151, 976, 87
*ELEMENT, type=T3D2, ELSET=Line192
1152, 86, 977
1153, 977, 978
1154, 978, 979
1155, 979, 980
1156, 980, 981
1157, 981, 982
1158, 982, 88
*ELEMENT, type=T3D2, ELSET=Line193
1159, 53, 983
1160, 983, 89
*ELEMENT, type=T3D2, ELSET=Line194
1161, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
1162, 54, 984
1163, 984, 90
*ELEMENT, type=T3D2, ELSET=Line196
1164, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
1165, 90, 985
1166, 985, 986
1167, 986, 987
1168, 987, 988
1169, 988, 989
1170, 989, 990
1171, 990, 89
*ELEMENT, type=T3D2, ELSET=Line198
1172, 45, 991
1173, 991, 91
*ELEMENT, type=T3D2, ELSET=Line199
1174, 46, 992
1175, 992, 92
*ELEMENT, type=T3D2, ELSET=Line200
1176, 91, 993
1177, 993, 994
1178, 994, 995
1179, 995, 996
1180, 996, 997
1181, 997, 998
1182, 998, 999
1183, 999, 1000
1184, 1000, 1001
1185, 1001, 1002
1186, 1002, 1003
1187, 1003, 92
*ELEMENT, type=T3D2, ELSET=Line201
1188, 47, 1004
1189, 1004, 93
*ELEMENT, type=T3D2, ELSET=Line202
1190, 48, 1005
1191, 1005, 94
*ELEMENT, type=T3D2, ELSET=Line203
1192, 93, 1006
1193, 1006, 1007
1194, 1007, 1008
1195, 1008, 1009
1196, 1009, 1010
1197, 1010, 1011
1198, 1011, 1012
1199, 1012, 1013
1200, 1013, 1014
1201, 1014, 1015
1202, 1015, 1016
1203, 1016, 94
*ELEMENT, type=T3D2, ELSET=Line204
1204, 93, 1017
1205, 1017, 1018
1206, 1018, 1019
1207, 1019, 1020
1208, 1020, 1021
1209, 1021, 1022
1210, 1022, 91
*ELEMENT, type=T3D2, ELSET=Line205
1211, 94, 1023
1212, 1023, 1024
1213, 1024, 1025
1214, 1025, 1026
1215, 1026, 1027
1216, 1027, 1028
1217, 1028, 92
*ELEMENT, type=T3D2, ELSET=Line206
1218, 50, 1029
1219, 1029, 95
*ELEMENT, type=T3D2, ELSET=Line207
1220, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
1221, 52, 1030
1222, 1030, 96
*ELEMENT, type=T3D2, ELSET=Line209
1223, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
1224, 96, 1031
1225, 1031, 1032
1226, 1032, 1033
1227, 1033, 1034
1228, 1034, 1035
1229, 1035, 1036
1230, 1036, 95
*ELEMENT, type=CPS4, ELSET=Surface1
1231, 2, 97, 1037, 110
1232, 110, 1037, 104, 4
1233, 97, 98, 1038, 1037
1234, 1037, 1038, 105, 104
1235, 98, 99, 1039, 1038
1236, 1038, 1039, 106, 105
1237, 99, 100, 1040, 1039
1238, 1039, 1040, 107, 106
1239, 100, 101, 1041, 1040
1240, 1040, 1041, 108, 107
1241, 101, 102, 1042, 1041
1242, 1041, 1042, 109, 108
1243, 102, 1, 103, 1042
1244, 1042, 103, 3, 109
*ELEMENT, type=CPS4, ELSET=Surface2
1245, 6, 124, 1043, 111
1246, 124, 8, 118, 1043
1247, 111, 1043, 1044, 112
1248, 1043, 118, 119, 1044
1249, 112, 1044, 1045, 113
1250, 1044, 119, 120, 1045
1251, 113, 1045, 1046, 114
1252, 1045, 120, 121, 1046
1253, 114, 1046, 1047, 115
1254, 1046, 121, 122, 1047
1255, 115, 1047, 1048, 116
1256, 1047, 122, 123, 1048
1257, 116, 1048, 117, 5
1258, 1048, 123, 7, 117
*ELEMENT, type=CPS4, ELSET=Surface3
1259, 2, 125, 1049, 97
1260, 97, 1049, 1050, 98
1261, 98, 1050, 1051, 99
1262, 99, 1051, 1052, 100
1263, 100, 1052, 1053, 101
1264, 101, 1053, 1054, 102
1265, 102, 1054, 136, 1
1266, 125, 126, 1055, 1049
1267, 1049, 1055, 1056, 1050
1268, 1050, 1056, 1057, 1051
1269, 1051, 1057, 1058, 1052
1270, 1052, 1058, 1059, 1053
1271, 1053, 1059, 1060, 1054
1272, 1054, 1060, 137, 136
1273, 126, 127, 1061, 1055
1274, 1055, 1061, 1062, 1056
1275, 1056, 1062, 1063, 1057
1276, 1057, 1063, 1064, 1058
1277, 1058, 1064, 1065, 1059
1278, 1059, 1065, 1066, 1060
1279, 1060, 1066, 138, 137
1280, 127, 128, 1067, 1061
1281, 1061, 1067, 1068, 1062
1282, 1062, 1068, 1069, 1063
1283, 1063, 1069, 1070, 1064
1284, 1064, 1070, 1071, 1065
1285, 1065, 1071, 1072, 1066
1286, 1066, 1072, 139, 138
1287, 128, 129, 1073, 1067
1288, 1067, 1073, 1074, 1068
1289, 1068, 1074, 1075, 1069
1290, 1069, 1075, 1076, 1070
1291, 1070, 1076, 1077, 1071
1292, 1071, 1077, 1078, 1072
1293, 1072, 1078, 140, 139
1294, 129, 130, 1079, 1073
1295, 1073, 1079, 1080, 1074
1296, 1074, 1080, 1081, 1075
1297, 1075, 1081, 1082, 1076
1298, 1076, 1082, 1083, 1077
1299, 1077, 1083, 1084, 1078
1300, 1078, 1084, 141, 140
1301, 130, 131, 1085, 1079
1302, 1079, 1085, 1086, 1080
1303, 1080, 1086, 1087, 1081
1304, 1081, 1087, 1088, 1082
1305, 1082, 1088, 1089, 1083
1306, 1083, 1089, 1090, 1084
1307, 1084, 1090, 142, 141
1308, 131, 132, 1091, 1085
1309, 1085, 1091, 1092, 1086
1310, 1086, 1092, 1093, 1087
1311, 1087, 1093, 1094, 1088
1312, 1088, 1094, 1095, 1089
1313, 1089, 1095, 1096, 1090
1314, 1090, 1096, 143, 142
1315, 132, 133, 1097, 1091
1316, 1091, 1097, 1098, 1092
1317, 1092, 1098, 1099, 1093
1318, 1093, 1099, 1100, 1094
1319, 1094, 1100, 1101, 1095
1320, 1095, 1101, 1102, 1096
1321, 1096, 1102, 144, 143
1322, 133, 134, 1103, 1097
1323, 1097, 1103, 1104, 1098
1324, 1098, 1104, 1105, 1099
1325, 1099, 1105, 1106, 1100
1326, 1100, 1106, 1107, 1101
1327, 1101, 1107, 1108, 1102
1328, 1102, 1108, 145, 144
1329, 134, 135, 1109, 1103
1330, 1103, 1109, 1110, 1104
1331, 1104, 1110, 1111, 1105
1332, 1105, 1111, 1112, 1106
1333, 1106, 1112, 1113, 1107
1334, 1107, 1113, 1114, 1108
1335, 1108, 1114, 146, 145
1336, 135, 6, 111, 1109
1337, 1109, 111, 112, 1110
1338, 1110, 112, 113, 1111
1339, 1111, 113, 114, 1112
1340, 1112, 114, 115, 1113
1341, 1113, 115, 116, 1114
1342, 1114, 116, 5, 146
*ELEMENT, type=CPS4, ELSET=Surface4
1343, 4, 104, 1115, 147
1344, 104, 105, 1116, 1115
1345, 105, 106, 1117, 1116
1346, 106, 107, 1118, 1117
1347, 107, 108, 1119, 1118
1348, 108, 109, 1120, 1119
1349, 109, 3, 158, 1120
1350, 147, 1115, 1121, 148
1351, 1115, 1116, 1122, 1121
1352, 1116, 1117, 1123, 1122
1353, 1117, 1118, 1124, 1123
1354, 1118, 1119, 1125, 1124
1355, 1119, 1120, 1126, 1125
1356, 1120, 158, 159, 1126
1357, 148, 1121, 1127, 149
1358, 1121, 1122, 1128, 1127
1359, 1122, 1123, 1129, 1128
1360, 1123, 1124, 1130, 1129
1361, 1124, 1125, 1131, 1130
1362, 1125, 1126, 1132, 1131
1363, 1126, 159, 160, 1132
1364, 149, 1127, 1133, 150
1365, 1127, 1128, 1134, 1133
1366, 1128, 1129, 1135, 1134
1367, 1129, 1130, 1136, 1135
1368, 1130, 1131, 1137, 1136
1369, 1131, 1132, 1138, 1137
1370, 1132, 160, 161, 1138
1371, 150, 1133, 1139, 151
1372, 1133, 1134, 1140, 1139
1373, 1134, 1135, 1141, 1140
1374, 1135, 1136, 1142, 1141
1375, 1136, 1137, 1143, 1142
1376, 1137, 1138, 1144, 1143
1377, 1138, 161, 162, 1144
1378, 151, 1139, 1145, 152
1379, 1139, 1140, 1146, 1145
1380, 1140, 1141, 1147, 1146
1381, 1141, 1142, 1148, 1147
1382, 1142, 1143, 1149, 1148
1383, 1143, 1144, 1150, 1149
1384, 1144, 162, 163, 1150
1385, 152, 1145, 1151, 153
1386, 1145, 1146, 1152, 1151
1387, 1146, 1147, 1153, 1152
1388, 1147, 1148, 1154, 1153
1389, 1148, 1149, 1155, 1154
1390, 1149, 1150, 1156, 1155
1391, 1150, 163, 164, 1156
1392, 153, 1151, 1157, 154
1393, 1151, 1152, 1158, 1157
1394, 1152, 1153, 1159, 1158
1395, 1153, 1154, 1160, 1159
1396, 1154, 1155, 1161, 1160
1397, 1155, 1156, 1162, 1161
1398, 1156, 164, 165, 1162
1399, 154, 1157, 1163, 155
1400, 1157, 1158, 1164, 1163
1401, 1158, 1159, 1165, 1164
1402, 1159, 1160, 1166, 1165
1403, 1160, 1161, 1167, 1166
1404, 1161, 1162, 1168, 1167
1405, 1162, 165, 166, 1168
1406, 155, 1163, 1169, 156
1407, 1163, 1164, 1170, 1169
1408, 1164, 1165, 1171, 1170
1409, 1165, 1166, 1172, 1171
1410, 1166, 1167, 1173, 1172
1411, 1167, 1168, 1174, 1173
1412, 1168, 166, 167, 1174
1413, 156, 1169, 1175, 157
1414, 1169, 1170, 1176, 1175
1415, 1170, 1171, 1177, 1176
1416, 1171, 1172, 1178, 1177
1417, 1172, 1173, 1179, 1178
1418, 1173, 1174, 1180, 1179
1419, 1174, 167, 168, 1180
1420, 157, 1175, 118, 8
1421, 1175, 1176, 119, 118
1422, 1176, 1177, 120, 119
1423, 1177, 1178, 121, 120
1424, 1178, 1179, 122, 121
1425, 1179, 1180, 123, 122
1426, 1180, 168, 7, 123
*ELEMENT, type=CPS4, ELSET=Surface5
1427, 2, 110, 1181, 125
1428, 125, 1181, 1182, 126
1429, 126, 1182, 1183, 127
1430, 127, 1183, 1184, 128
1431, 128, 1184, 1185, 129
1432, 129, 1185, 1186, 130
1433, 130, 1186, 1187, 131
1434, 131, 1187, 1188, 132
1435, 132, 1188, 1189, 133
1436, 133, 1189, 1190, 134
1437, 134, 1190, 1191, 135
1438, 135, 1191, 124, 6
1439, 110, 4, 147, 1181
1440, 1181, 147, 148, 1182
1441, 1182, 148, 149, 1183
1442, 1183, 149, 150, 1184
1443, 1184, 150, 151, 1185
1444, 1185, 151, 152, 1186
1445, 1186, 152, 153, 1187
1446, 1187, 153, 154, 1188
1447, 1188, 154, 155, 1189
1448, 1189, 155, 156, 1190
1449, 1190, 156, 157, 1191
1450, 1191, 157, 8, 124
*ELEMENT, type=CPS4, ELSET=Surface6
1451, 1, 136, 1192, 103
1452, 136, 137, 1193, 1192
1453, 137, 138, 1194, 1193
1454, 138, 139, 1195, 1194
1455, 139, 140, 1196, 1195
1456, 140, 141, 1197, 1196
1457, 141, 142, 1198, 1197
1458, 142, 143, 1199, 1198
1459, 143, 144, 1200, 1199
1460, 144, 145, 1201, 1200
1461, 145, 146, 1202, 1201
1462, 146, 5, 117, 1202
1463, 103, 1192, 158, 3
1464, 1192, 1193, 159, 158
1465, 1193, 1194, 160, 159
1466, 1194, 1195, 161, 160
1467, 1195, 1196, 162, 161
1468, 1196, 1197, 163, 162
1469, 1197, 1198, 164, 163
1470, 1198, 1199, 165, 164
1471, 1199, 1200, 166, 165
1472, 1200, 1201, 167, 166
1473, 1201, 1202, 168, 167
1474, 1202, 117, 7, 168
*ELEMENT, type=CPS4, ELSET=Surface7
1475, 4, 10, 169, 147
1476, 147, 169, 170, 148
1477, 148, 170, 171, 149
1478, 149, 171, 172, 150
1479, 150, 172, 173, 151
1480, 151, 173, 174, 152
1481, 152, 174, 175, 153
1482, 153, 175, 176, 154
1483, 154, 176, 177, 155
1484, 155, 177, 178, 156
1485, 156, 178, 179, 157
1486, 157, 179, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
1487, 8, 9, 180, 118
1488, 118, 180, 181, 119
1489, 119, 181, 182, 120
1490, 120, 182, 183, 121
1491, 121, 183, 184, 122
1492, 122, 184, 185, 123
1493, 123, 185, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
1494, 3, 158, 186, 12
1495, 158, 159, 187, 186
1496, 159, 160, 188, 187
1497, 160, 161, 189, 188
1498, 161, 162, 190, 189
1499, 162, 163, 191, 190
1500, 163, 164, 192, 191
1501, 164, 165, 193, 192
1502, 165, 166, 194, 193
1503, 166, 167, 195, 194
1504, 167, 168, 196, 195
1505, 168, 7, 11, 196
*ELEMENT, type=CPS4, ELSET=Surface10
1506, 4, 104, 197, 10
1507, 104, 105, 198, 197
1508, 105, 106, 199, 198
1509, 106, 107, 200, 199
1510, 107, 108, 201, 200
1511, 108, 109, 202, 201
1512, 109, 3, 12, 202
*ELEMENT, type=CPS4, ELSET=Surface11
1513, 10, 197, 1203, 169
1514, 197, 198, 1204, 1203
1515, 198, 199, 1205, 1204
1516, 199, 200, 1206, 1205
1517, 200, 201, 1207, 1206
1518, 201, 202, 1208, 1207
1519, 202, 12, 186, 1208
1520, 169, 1203, 1209, 170
1521, 1203, 1204, 1210, 1209
1522, 1204, 1205, 1211, 1210
1523, 1205, 1206, 1212, 1211
1524, 1206, 1207, 1213, 1212
1525, 1207, 1208, 1214, 1213
1526, 1208, 186, 187, 1214
1527, 170, 1209, 1215, 171
1528, 1209, 1210, 1216, 1215
1529, 1210, 1211, 1217, 1216
1530, 1211, 1212, 1218, 1217
1531, 1212, 1213, 1219, 1218
1532, 1213, 1214, 1220, 1219
1533, 1214, 187, 188, 1220
1534, 171, 1215, 1221, 172
1535, 1215, 1216, 1222, 1221
1536, 1216, 1217, 1223, 1222
1537, 1217, 1218, 1224, 1223
1538, 1218, 1219, 1225, 1224
1539, 1219, 1220, 1226, 1225
1540, 1220, 188, 189, 1226
1541, 172, 1221, 1227, 173
1542, 1221, 1222, 1228, 1227
1543, 1222, 1223, 1229, 1228
1544, 1223, 1224, 1230, 1229
1545, 1224, 1225, 1231, 1230
1546, 1225, 1226, 1232, 1231
1547, 1226, 189, 190, 1232
1548, 173, 1227, 1233, 174
1549, 1227, 1228, 1234, 1233
1550, 1228, 1229, 1235, 1234
1551, 1229, 1230, 1236, 1235
1552, 1230, 1231, 1237, 1236
1553, 1231, 1232, 1238, 1237
1554, 1232, 190, 191, 1238
1555, 174, 1233, 1239, 175
1556, 1233, 1234, 1240, 1239
1557, 1234, 1235, 1241, 1240
1558, 1235, 1236, 1242, 1241
1559, 1236, 1237, 1243, 1242
1560, 1237, 1238, 1244, 1243
1561, 1238, 191, 192, 1244
1562, 175, 1239, 1245, 176
1563, 1239, 1240, 1246, 1245
1564, 1240, 1241, 1247, 1246
1565, 1241, 1242, 1248, 1247
1566, 1242, 1243, 1249, 1248
1567, 1243, 1244, 1250, 1249
1568, 1244, 192, 193, 1250
1569, 176, 1245, 1251, 177
1570, 1245, 1246, 1252, 1251
1571, 1246, 1247, 1253, 1252
1572, 1247, 1248, 1254, 1253
1573, 1248, 1249, 1255, 1254
1574, 1249, 1250, 1256, 1255
1575, 1250, 193, 194, 1256
1576, 177, 1251, 1257, 178
1577, 1251, 1252, 1258, 1257
1578, 1252, 1253, 1259, 1258
1579, 1253, 1254, 1260, 1259
1580, 1254, 1255, 1261, 1260
1581, 1255, 1256, 1262, 1261
1582, 1256, 194, 195, 1262
1583, 178, 1257, 1263, 179
1584, 1257, 1258, 1264, 1263
1585, 1258, 1259, 1265, 1264
1586, 1259, 1260, 1266, 1265
1587, 1260, 1261, 1267, 1266
1588, 1261, 1262, 1268, 1267
1589, 1262, 195, 196, 1268
1590, 179, 1263, 180, 9
1591, 1263, 1264, 181, 180
1592, 1264, 1265, 182, 181
1593, 1265, 1266, 183, 182
1594, 1266, 1267, 184, 183
1595, 1267, 1268, 185, 184
1596, 1268, 196, 11, 185
*ELEMENT, type=CPS4, ELSET=Surface12
1597, 10, 217, 1269, 169
1598, 217, 218, 1270, 1269
1599, 218, 219, 1271, 1270
1600, 219, 220, 1272, 1271
1601, 220, 221, 1273, 1272
1602, 221, 222, 1274, 1273
1603, 222, 223, 1275, 1274
1604, 223, 224, 1276, 1275
1605, 224, 225, 1277, 1276
1606, 225, 226, 1278, 1277
1607, 226, 227, 1279, 1278
1608, 227, 228, 1280, 1279
1609, 228, 229, 1281, 1280
1610, 229, 230, 1282, 1281
1611, 230, 14, 231, 1282
1612, 169, 1269, 1283, 170
1613, 1269, 1270, 1284, 1283
1614, 1270, 1271, 1285, 1284
1615, 1271, 1272, 1286, 1285
1616, 1272, 1273, 1287, 1286
1617, 1273, 1274, 1288, 1287
1618, 1274, 1275, 1289, 1288
1619, 1275, 1276, 1290, 1289
1620, 1276, 1277, 1291, 1290
1621, 1277, 1278, 1292, 1291
1622, 1278, 1279, 1293, 1292
1623, 1279, 1280, 1294, 1293
1624, 1280, 1281, 1295, 1294
1625, 1281, 1282, 1296, 1295
1626, 1282, 231, 232, 1296
1627, 170, 1283, 1297, 171
1628, 1283, 1284, 1298, 1297
1629, 1284, 1285, 1299, 1298
1630, 1285, 1286, 1300, 1299
1631, 1286, 1287, 1301, 1300
1632, 1287, 1288, 1302, 1301
1633, 1288, 1289, 1303, 1302
1634, 1289, 1290, 1304, 1303
1635, 1290, 1291, 1305, 1304
1636, 1291, 1292, 1306, 1305
1637, 1292, 1293, 1307, 1306
1638, 1293, 1294, 1308, 1307
1639, 1294, 1295, 1309, 1308
1640, 1295, 1296, 1310, 1309
1641, 1296, 232, 233, 1310
1642, 171, 1297, 1311, 172
1643, 1297, 1298, 1312, 1311
1644, 1298, 1299, 1313, 1312
1645, 1299, 1300, 1314, 1313
1646, 1300, 1301, 1315, 1314
1647, 1301, 1302, 1316, 1315
1648, 1302, 1303, 1317, 1316
1649, 1303, 1304, 1318, 1317
1650, 1304, 1305, 1319, 1318
1651, 1305, 1306, 1320, 1319
1652, 1306, 1307, 1321, 1320
1653, 1307, 1308, 1322, 1321
1654, 1308, 1309, 1323, 1322
1655, 1309, 1310, 1324, 1323
1656, 1310, 233, 234, 1324
1657, 172, 1311, 1325, 173
1658, 1311, 1312, 1326, 1325
1659, 1312, 1313, 1327, 1326
1660, 1313, 1314, 1328, 1327
1661, 1314, 1315, 1329, 1328
1662, 1315, 1316, 1330, 1329
1663, 1316, 1317, 1331, 1330
1664, 1317, 1318, 1332, 1331
1665, 1318, 1319, 1333, 1332
1666, 1319, 1320, 1334, 1333
1667, 1320, 1321, 1335, 1334
1668, 1321, 1322, 1336, 1335
1669, 1322, 1323, 1337, 1336
1670, 1323, 1324, 1338, 1337
1671, 1324, 234, 235, 1338
1672, 173, 1325, 1339, 174
1673, 1325, 1326, 1340, 1339
1674, 1326, 1327, 1341, 1340
1675, 1327, 1328, 1342, 1341
1676, 1328, 1329, 1343, 1342
1677, 1329, 1330, 1344, 1343
1678, 1330, 1331, 1345, 1344
1679, 1331, 1332, 1346, 1345
1680, 1332, 1333, 1347, 1346
1681, 1333, 1334, 1348, 1347
1682, 1334, 1335, 1349, 1348
1683, 1335, 1336, 1350, 1349
1684, 1336, 1337, 1351, 1350
1685, 1337, 1338, 1352, 1351
1686, 1338, 235, 236, 1352
1687, 174, 1339, 1353, 175
1688, 1339, 1340, 1354, 1353
1689, 1340, 1341, 1355, 1354
1690, 1341, 1342, 1356, 1355
1691, 1342, 1343, 1357, 1356
1692, 1343, 1344, 1358, 1357
1693, 1344, 1345, 1359, 1358
1694, 1345, 1346, 1360, 1359
1695, 1346, 1347, 1361, 1360
1696, 1347, 1348, 1362, 1361
1697, 1348, 1349, 1363, 1362
1698, 1349, 1350, 1364, 1363
1699, 1350, 1351, 1365, 1364
1700, 1351, 1352, 1366, 1365
1701, 1352, 236, 237, 1366
1702, 175, 1353, 1367, 176
1703, 1353, 1354, 1368, 1367
1704, 1354, 1355, 1369, 1368
1705, 1355, 1356, 1370, 1369
1706, 1356, 1357, 1371, 1370
1707, 1357, 1358, 1372, 1371
1708, 1358, 1359, 1373, 1372
1709, 1359, 1360, 1374, 1373
1710, 1360, 1361, 1375, 1374
1711, 1361, 1362, 1376, 1375
1712, 1362, 1363, 1377, 1376
1713, 1363, 1364, 1378, 1377
1714, 1364, 1365, 1379, 1378
1715, 1365, 1366, 1380, 1379
1716, 1366, 237, 238, 1380
1717, 176, 1367, 1381, 177
1718, 1367, 1368, 1382, 1381
1719, 1368, 1369, 1383, 1382
1720, 1369, 1370, 1384, 1383
1721, 1370, 1371, 1385, 1384
1722, 1371, 1372, 1386, 1385
1723, 1372, 1373, 1387, 1386
1724, 1373, 1374, 1388, 1387
1725, 1374, 1375, 1389, 1388
1726, 1375, 1376, 1390, 1389
1727, 1376, 1377, 1391, 1390
1728, 1377, 1378, 1392, 1391
1729, 1378, 1379, 1393, 1392
1730, 1379, 1380, 1394, 1393
1731, 1380, 238, 239, 1394
1732, 177, 1381, 1395, 178
1733, 1381, 1382, 1396, 1395
1734, 1382, 1383, 1397, 1396
1735, 1383, 1384, 1398, 1397
1736, 1384, 1385, 1399, 1398
1737, 1385, 1386, 1400, 1399
1738, 1386, 1387, 1401, 1400
1739, 1387, 1388, 1402, 1401
1740, 1388, 1389, 1403, 1402
1741, 1389, 1390, 1404, 1403
1742, 1390, 1391, 1405, 1404
1743, 1391, 1392, 1406, 1405
1744, 1392, 1393, 1407, 1406
1745, 1393, 1394, 1408, 1407
1746, 1394, 239, 240, 1408
1747, 178, 1395, 1409, 179
1748, 1395, 1396, 1410, 1409
1749, 1396, 1397, 1411, 1410
1750, 1397, 1398, 1412, 1411
1751, 1398, 1399, 1413, 1412
1752, 1399, 1400, 1414, 1413
1753, 1400, 1401, 1415, 1414
1754, 1401, 1402, 1416, 1415
1755, 1402, 1403, 1417, 1416
1756, 1403, 1404, 1418, 1417
1757, 1404, 1405, 1419, 1418
1758, 1405, 1406, 1420, 1419
1759, 1406, 1407, 1421, 1420
1760, 1407, 1408, 1422, 1421
1761, 1408, 240, 241, 1422
1762, 179, 1409, 203, 9
1763, 1409, 1410, 204, 203
1764, 1410, 1411, 205, 204
1765, 1411, 1412, 206, 205
1766, 1412, 1413, 207, 206
1767, 1413, 1414, 208, 207
1768, 1414, 1415, 209, 208
1769, 1415, 1416, 210, 209
1770, 1416, 1417, 211, 210
1771, 1417, 1418, 212, 211
1772, 1418, 1419, 213, 212
1773, 1419, 1420, 214, 213
1774, 1420, 1421, 215, 214
1775, 1421, 1422, 216, 215
1776, 1422, 241, 13, 216
*ELEMENT, type=CPS4, ELSET=Surface13
1777, 9, 203, 1423, 180
1778, 203, 204, 1424, 1423
1779, 204, 205, 1425, 1424
1780, 205, 206, 1426, 1425
1781, 206, 207, 1427, 1426
1782, 207, 208, 1428, 1427
1783, 208, 209, 1429, 1428
1784, 209, 210, 1430, 1429
1785, 210, 211, 1431, 1430
1786, 211, 212, 1432, 1431
1787, 212, 213, 1433, 1432
1788, 213, 214, 1434, 1433
1789, 214, 215, 1435, 1434
1790, 215, 216, 1436, 1435
1791, 216, 13, 256, 1436
1792, 180, 1423, 1437, 181
1793, 1423, 1424, 1438, 1437
1794, 1424, 1425, 1439, 1438
1795, 1425, 1426, 1440, 1439
1796, 1426, 1427, 1441, 1440
1797, 1427, 1428, 1442, 1441
1798, 1428, 1429, 1443, 1442
1799, 1429, 1430, 1444, 1443
1800, 1430, 1431, 1445, 1444
1801, 1431, 1432, 1446, 1445
1802, 1432, 1433, 1447, 1446
1803, 1433, 1434, 1448, 1447
1804, 1434, 1435, 1449, 1448
1805, 1435, 1436, 1450, 1449
1806, 1436, 256, 257, 1450
1807, 181, 1437, 1451, 182
1808, 1437, 1438, 1452, 1451
1809, 1438, 1439, 1453, 1452
1810, 1439, 1440, 1454, 1453
1811, 1440, 1441, 1455, 1454
1812, 1441, 1442, 1456, 1455
1813, 1442, 1443, 1457, 1456
1814, 1443, 1444, 1458, 1457
1815, 1444, 1445, 1459, 1458
1816, 1445, 1446, 1460, 1459
1817, 1446, 1447, 1461, 1460
1818, 1447, 1448, 1462, 1461
1819, 1448, 1449, 1463, 1462
1820, 1449, 1450, 1464, 1463
1821, 1450, 257, 258, 1464
1822, 182, 1451, 1465, 183
1823, 1451, 1452, 1466, 1465
1824, 1452, 1453, 1467, 1466
1825, 1453, 1454, 1468, 1467
1826, 1454, 1455, 1469, 1468
1827, 1455, 1456, 1470, 1469
1828, 1456, 1457, 1471, 1470
1829, 1457, 1458, 1472, 1471
1830, 1458, 1459, 1473, 1472
1831, 1459, 1460, 1474, 1473
1832, 1460, 1461, 1475, 1474
1833, 1461, 1462, 1476, 1475
1834, 1462, 1463, 1477, 1476
1835, 1463, 1464, 1478, 1477
1836, 1464, 258, 259, 1478
1837, 183, 1465, 1479, 184
1838, 1465, 1466, 1480, 1479
1839, 1466, 1467, 1481, 1480
1840, 1467, 1468, 1482, 1481
1841, 1468, 1469, 1483, 1482
1842, 1469, 1470, 1484, 1483
1843, 1470, 1471, 1485, 1484
1844, 1471, 1472, 1486, 1485
1845, 1472, 1473, 1487, 1486
1846, 1473, 1474, 1488, 1487
1847, 1474, 1475, 1489, 1488
1848, 1475, 1476, 1490, 1489
1849, 1476, 1477, 1491, 1490
1850, 1477, 1478, 1492, 1491
1851, 1478, 259, 260, 1492
1852, 184, 1479, 1493, 185
1853, 1479, 1480, 1494, 1493
1854, 1480, 1481, 1495, 1494
1855, 1481, 1482, 1496, 1495
1856, 1482, 1483, 1497, 1496
1857, 1483, 1484, 1498, 1497
1858, 1484, 1485, 1499, 1498
1859, 1485, 1486, 1500, 1499
1860, 1486, 1487, 1501, 1500
1861, 1487, 1488, 1502, 1501
1862, 1488, 1489, 1503, 1502
1863, 1489, 1490, 1504, 1503
1864, 1490, 1491, 1505, 1504
1865, 1491, 1492, 1506, 1505
1866, 1492, 260, 261, 1506
1867, 185, 1493, 242, 11
1868, 1493, 1494, 243, 242
1869, 1494, 1495, 244, 243
1870, 1495, 1496, 245, 244
1871, 1496, 1497, 246, 245
1872, 1497, 1498, 247, 246
1873, 1498, 1499, 248, 247
1874, 1499, 1500, 249, 248
1875, 1500, 1501, 250, 249
1876, 1501, 1502, 251, 250
1877, 1502, 1503, 252, 251
1878, 1503, 1504, 253, 252
1879, 1504, 1505, 254, 253
1880, 1505, 1506, 255, 254
1881, 1506, 261, 15, 255
*ELEMENT, type=CPS4, ELSET=Surface14
1882, 12, 186, 1507, 262
1883, 262, 1507, 1508, 263
1884, 263, 1508, 1509, 264
1885, 264, 1509, 1510, 265
1886, 265, 1510, 1511, 266
1887, 266, 1511, 1512, 267
1888, 267, 1512, 1513, 268
1889, 268, 1513, 1514, 269
1890, 269, 1514, 1515, 270
1891, 270, 1515, 1516, 271
1892, 271, 1516, 1517, 272
1893, 272, 1517, 1518, 273
1894, 273, 1518, 1519, 274
1895, 274, 1519, 1520, 275
1896, 275, 1520, 276, 16
1897, 186, 187, 1521, 1507
1898, 1507, 1521, 1522, 1508
1899, 1508, 1522, 1523, 1509
1900, 1509, 1523, 1524, 1510
1901, 1510, 1524, 1525, 1511
1902, 1511, 1525, 1526, 1512
1903, 1512, 1526, 1527, 1513
1904, 1513, 1527, 1528, 1514
1905, 1514, 1528, 1529, 1515
1906, 1515, 1529, 1530, 1516
1907, 1516, 1530, 1531, 1517
1908, 1517, 1531, 1532, 1518
1909, 1518, 1532, 1533, 1519
1910, 1519, 1533, 1534, 1520
1911, 1520, 1534, 277, 276
1912, 187, 188, 1535, 1521
1913, 1521, 1535, 1536, 1522
1914, 1522, 1536, 1537, 1523
1915, 1523, 1537, 1538, 1524
1916, 1524, 1538, 1539, 1525
1917, 1525, 1539, 1540, 1526
1918, 1526, 1540, 1541, 1527
1919, 1527, 1541, 1542, 1528
1920, 1528, 1542, 1543, 1529
1921, 1529, 1543, 1544, 1530
1922, 1530, 1544, 1545, 1531
1923, 1531, 1545, 1546, 1532
1924, 1532, 1546, 1547, 1533
1925, 1533, 1547, 1548, 1534
1926, 1534, 1548, 278, 277
1927, 188, 189, 1549, 1535
1928, 1535, 1549, 1550, 1536
1929, 1536, 1550, 1551, 1537
1930, 1537, 1551, 1552, 1538
1931, 1538, 1552, 1553, 1539
1932, 1539, 1553, 1554, 1540
1933, 1540, 1554, 1555, 1541
1934, 1541, 1555, 1556, 1542
1935, 1542, 1556, 1557, 1543
1936, 1543, 1557, 1558, 1544
1937, 1544, 1558, 1559, 1545
1938, 1545, 1559, 1560, 1546
1939, 1546, 1560, 1561, 1547
1940, 1547, 1561, 1562, 1548
1941, 1548, 1562, 279, 278
1942, 189, 190, 1563, 1549
1943, 1549, 1563, 1564, 1550
1944, 1550, 1564, 1565, 1551
1945, 1551, 1565, 1566, 1552
1946, 1552, 1566, 1567, 1553
1947, 1553, 1567, 1568, 1554
1948, 1554, 1568, 1569, 1555
1949, 1555, 1569, 1570, 1556
1950, 1556, 1570, 1571, 1557
1951, 1557, 1571, 1572, 1558
1952, 1558, 1572, 1573, 1559
1953, 1559, 1573, 1574, 1560
1954, 1560, 1574, 1575, 1561
1955, 1561, 1575, 1576, 1562
1956, 1562, 1576, 280, 279
1957, 190, 191, 1577, 1563
1958, 1563, 1577, 1578, 1564
1959, 1564, 1578, 1579, 1565
1960, 1565, 1579, 1580, 1566
1961, 1566, 1580, 1581, 1567
1962, 1567, 1581, 1582, 1568
1963, 1568, 1582, 1583, 1569
1964, 1569, 1583, 1584, 1570
1965, 1570, 1584, 1585, 1571
1966, 1571, 1585, 1586, 1572
1967, 1572, 1586, 1587, 1573
1968, 1573, 1587, 1588, 1574
1969, 1574, 1588, 1589, 1575
1970, 1575, 1589, 1590, 1576
1971, 1576, 1590, 281, 280
1972, 191, 192, 1591, 1577
1973, 1577, 1591, 1592, 1578
1974, 1578, 1592, 1593, 1579
1975, 1579, 1593, 1594, 1580
1976, 1580, 1594, 1595, 1581
1977, 1581, 1595, 1596, 1582
1978, 1582, 1596, 1597, 1583
1979, 1583, 1597, 1598, 1584
1980, 1584, 1598, 1599, 1585
1981, 1585, 1599, 1600, 1586
1982, 1586, 1600, 1601, 1587
1983, 1587, 1601, 1602, 1588
1984, 1588, 1602, 1603, 1589
1985, 1589, 1603, 1604, 1590
1986, 1590, 1604, 282, 281
1987, 192, 193, 1605, 1591
1988, 1591, 1605, 1606, 1592
1989, 1592, 1606, 1607, 1593
1990, 1593, 1607, 1608, 1594
1991, 1594, 1608, 1609, 1595
1992, 1595, 1609, 1610, 1596
1993, 1596, 1610, 1611, 1597
1994, 1597, 1611, 1612, 1598
1995, 1598, 1612, 1613, 1599
1996, 1599, 1613, 1614, 1600
1997, 1600, 1614, 1615, 1601
1998, 1601, 1615, 1616, 1602
1999, 1602, 1616, 1617, 1603
2000, 1603, 1617, 1618, 1604
2001, 1604, 1618, 283, 282
2002, 193, 194, 1619, 1605
2003, 1605, 1619, 1620, 1606
2004, 1606, 1620, 1621, 1607
2005, 1607, 1621, 1622, 1608
2006, 1608, 1622, 1623, 1609
2007, 1609, 1623, 1624, 1610
2008, 1610, 1624, 1625, 1611
2009, 1611, 1625, 1626, 1612
2010, 1612, 1626, 1627, 1613
2011, 1613, 1627, 1628, 1614
2012, 1614, 1628, 1629, 1615
2013, 1615, 1629, 1630, 1616
2014, 1616, 1630, 1631, 1617
2015, 1617, 1631, 1632, 1618
2016, 1618, 1632, 284, 283
2017, 194, 195, 1633, 1619
2018, 1619, 1633, 1634, 1620
2019, 1620, 1634, 1635, 1621
2020, 1621, 1635, 1636, 1622
2021, 1622, 1636, 1637, 1623
2022, 1623, 1637, 1638, 1624
2023, 1624, 1638, 1639, 1625
2024, 1625, 1639, 1640, 1626
2025, 1626, 1640, 1641, 1627
2026, 1627, 1641, 1642, 1628
2027, 1628, 1642, 1643, 1629
2028, 1629, 1643, 1644, 1630
2029, 1630, 1644, 1645, 1631
2030, 1631, 1645, 1646, 1632
2031, 1632, 1646, 285, 284
2032, 195, 196, 1647, 1633
2033, 1633, 1647, 1648, 1634
2034, 1634, 1648, 1649, 1635
2035, 1635, 1649, 1650, 1636
2036, 1636, 1650, 1651, 1637
2037, 1637, 1651, 1652, 1638
2038, 1638, 1652, 1653, 1639
2039, 1639, 1653, 1654, 1640
2040, 1640, 1654, 1655, 1641
2041, 1641, 1655, 1656, 1642
2042, 1642, 1656, 1657, 1643
2043, 1643, 1657, 1658, 1644
2044, 1644, 1658, 1659, 1645
2045, 1645, 1659, 1660, 1646
2046, 1646, 1660, 286, 285
2047, 196, 11, 242, 1647
2048, 1647, 242, 243, 1648
2049, 1648, 243, 244, 1649
2050, 1649, 244, 245, 1650
2051, 1650, 245, 246, 1651
2052, 1651, 246, 247, 1652
2053, 1652, 247, 248, 1653
2054, 1653, 248, 249, 1654
2055, 1654, 249, 250, 1655
2056, 1655, 250, 251, 1656
2057, 1656, 251, 252, 1657
2058, 1657, 252, 253, 1658
2059, 1658, 253, 254, 1659
2060, 1659, 254, 255, 1660
2061, 1660, 255, 15, 286
*ELEMENT, type=CPS4, ELSET=Surface15
2062, 10, 197, 1661, 217
2063, 217, 1661, 1662, 218
2064, 218, 1662, 1663, 219
2065, 219, 1663, 1664, 220
2066, 220, 1664, 1665, 221
2067, 221, 1665, 1666, 222
2068, 222, 1666, 1667, 223
2069, 223, 1667, 1668, 224
2070, 224, 1668, 1669, 225
2071, 225, 1669, 1670, 226
2072, 226, 1670, 1671, 227
2073, 227, 1671, 1672, 228
2074, 228, 1672, 1673, 229
2075, 229, 1673, 1674, 230
2076, 230, 1674, 287, 14
2077, 197, 198, 1675, 1661
2078, 1661, 1675, 1676, 1662
2079, 1662, 1676, 1677, 1663
2080, 1663, 1677, 1678, 1664
2081, 1664, 1678, 1679, 1665
2082, 1665, 1679, 1680, 1666
2083, 1666, 1680, 1681, 1667
2084, 1667, 1681, 1682, 1668
2085, 1668, 1682, 1683, 1669
2086, 1669, 1683, 1684, 1670
2087, 1670, 1684, 1685, 1671
2088, 1671, 1685, 1686, 1672
2089, 1672, 1686, 1687, 1673
2090, 1673, 1687, 1688, 1674
2091, 1674, 1688, 288, 287
2092, 198, 199, 1689, 1675
2093, 1675, 1689, 1690, 1676
2094, 1676, 1690, 1691, 1677
2095, 1677, 1691, 1692, 1678
2096, 1678, 1692, 1693, 1679
2097, 1679, 1693, 1694, 1680
2098, 1680, 1694, 1695, 1681
2099, 1681, 1695, 1696, 1682
2100, 1682, 1696, 1697, 1683
2101, 1683, 1697, 1698, 1684
2102, 1684, 1698, 1699, 1685
2103, 1685, 1699, 1700, 1686
2104, 1686, 1700, 1701, 1687
2105, 1687, 1701, 1702, 1688
2106, 1688, 1702, 289, 288
2107, 199, 200, 1703, 1689
2108, 1689, 1703, 1704, 1690
2109, 1690, 1704, 1705, 1691
2110, 1691, 1705, 1706, 1692
2111, 1692, 1706, 1707, 1693
2112, 1693, 1707, 1708, 1694
2113, 1694, 1708, 1709, 1695
2114, 1695, 1709, 1710, 1696
2115, 1696, 1710, 1711, 1697
2116, 1697, 1711, 1712, 1698
2117, 1698, 1712, 1713, 1699
2118, 1699, 1713, 1714, 1700
2119, 1700, 1714, 1715, 1701
2120, 1701, 1715, 1716, 1702
2121, 1702, 1716, 290, 289
2122, 200, 201, 1717, 1703
2123, 1703, 1717, 1718, 1704
2124, 1704, 1718, 1719, 1705
2125, 1705, 1719, 1720, 1706
2126, 1706, 1720, 1721, 1707
2127, 1707, 1721, 1722, 1708
2128, 1708, 1722, 1723, 1709
2129, 1709, 1723, 1724, 1710
2130, 1710, 1724, 1725, 1711
2131, 1711, 1725, 1726, 1712
2132, 1712, 1726, 1727, 1713
2133, 1713, 1727, 1728, 1714
2134, 1714, 1728, 1729, 1715
2135, 1715, 1729, 1730, 1716
2136, 1716, 1730, 291, 290
2137, 201, 202, 1731, 1717
2138, 1717, 1731, 1732, 1718
2139, 1718, 1732, 1733, 1719
2140, 1719, 1733, 1734, 1720
2141, 1720, 1734, 1735, 1721
2142, 1721, 1735, 1736, 1722
2143, 1722, 1736, 1737, 1723
2144, 1723, 1737, 1738, 1724
2145, 1724, 1738, 1739, 1725
2146, 1725, 1739, 1740, 1726
2147, 1726, 1740, 1741, 1727
2148, 1727, 1741, 1742, 1728
2149, 1728, 1742, 1743, 1729
2150, 1729, 1743, 1744, 1730
2151, 1730, 1744, 292, 291
2152, 202, 12, 262, 1731
2153, 1731, 262, 263, 1732
2154, 1732, 263, 264, 1733
2155, 1733, 264, 265, 1734
2156, 1734, 265, 266, 1735
2157, 1735, 266, 267, 1736
2158, 1736, 267, 268, 1737
2159, 1737, 268, 269, 1738
2160, 1738, 269, 270, 1739
2161, 1739, 270, 271, 1740
2162, 1740, 271, 272, 1741
2163, 1741, 272, 273, 1742
2164, 1742, 273, 274, 1743
2165, 1743, 274, 275, 1744
2166, 1744, 275, 16, 292
*ELEMENT, type=CPS4, ELSET=Surface16
2167, 14, 287, 1745, 231
2168, 287, 288, 1746, 1745
2169, 288, 289, 1747, 1746
2170, 289, 290, 1748, 1747
2171, 290, 291, 1749, 1748
2172, 291, 292, 1750, 1749
2173, 292, 16, 276, 1750
2174, 231, 1745, 1751, 232
2175, 1745, 1746, 1752, 1751
2176, 1746, 1747, 1753, 1752
2177, 1747, 1748, 1754, 1753
2178, 1748, 1749, 1755, 1754
2179, 1749, 1750, 1756, 1755
2180, 1750, 276, 277, 1756
2181, 232, 1751, 1757, 233
2182, 1751, 1752, 1758, 1757
2183, 1752, 1753, 1759, 1758
2184, 1753, 1754, 1760, 1759
2185, 1754, 1755, 1761, 1760
2186, 1755, 1756, 1762, 1761
2187, 1756, 277, 278, 1762
2188, 233, 1757, 1763, 234
2189, 1757, 1758, 1764, 1763
2190, 1758, 1759, 1765, 1764
2191, 1759, 1760, 1766, 1765
2192, 1760, 1761, 1767, 1766
2193, 1761, 1762, 1768, 1767
2194, 1762, 278, 279, 1768
2195, 234, 1763, 1769, 235
2196, 1763, 1764, 1770, 1769
2197, 1764, 1765, 1771, 1770
2198, 1765, 1766, 1772, 1771
2199, 1766, 1767, 1773, 1772
2200, 1767, 1768, 1774, 1773
2201, 1768, 279, 280, 1774
2202, 235, 1769, 1775, 236
2203, 1769, 1770, 1776, 1775
2204, 1770, 1771, 1777, 1776
2205, 1771, 1772, 1778, 1777
2206, 1772, 1773, 1779, 1778
2207, 1773, 1774, 1780, 1779
2208, 1774, 280, 281, 1780
2209, 236, 1775, 1781, 237
2210, 1775, 1776, 1782, 1781
2211, 1776, 1777, 1783, 1782
2212, 1777, 1778, 1784, 1783
2213, 1778, 1779, 1785, 1784
2214, 1779, 1780, 1786, 1785
2215, 1780, 281, 282, 1786
2216, 237, 1781, 1787, 238
2217, 1781, 1782, 1788, 1787
2218, 1782, 1783, 1789, 1788
2219, 1783, 1784, 1790, 1789
2220, 1784, 1785, 1791, 1790
2221, 1785, 1786, 1792, 1791
2222, 1786, 282, 283, 1792
2223, 238, 1787, 1793, 239
2224, 1787, 1788, 1794, 1793
2225, 1788, 1789, 1795, 1794
2226, 1789, 1790, 1796, 1795
2227, 1790, 1791, 1797, 1796
2228, 1791, 1792, 1798, 1797
2229, 1792, 283, 284, 1798
2230, 239, 1793, 1799, 240
2231, 1793, 1794, 1800, 1799
2232, 1794, 1795, 1801, 1800
2233, 1795, 1796, 1802, 1801
2234, 1796, 1797, 1803, 1802
2235, 1797, 1798, 1804, 1803
2236, 1798, 284, 285, 1804
2237, 240, 1799, 1805, 241
2238, 1799, 1800, 1806, 1805
2239, 1800, 1801, 1807, 1806
2240, 1801, 1802, 1808, 1807
2241, 1802, 1803, 1809, 1808
2242, 1803, 1804, 1810, 1809
2243, 1804, 285, 286, 1810
2244, 241, 1805, 256, 13
2245, 1805, 1806, 257, 256
2246, 1806, 1807, 258, 257
2247, 1807, 1808, 259, 258
2248, 1808, 1809, 260, 259
2249, 1809, 1810, 261, 260
2250, 1810, 286, 15, 261
*ELEMENT, type=CPS4, ELSET=Surface17
2251, 14, 18, 293, 231
2252, 231, 293, 294, 232
2253, 232, 294, 295, 233
2254, 233, 295, 296, 234
2255, 234, 296, 297, 235
2256, 235, 297, 298, 236
2257, 236, 298, 299, 237
2258, 237, 299, 300, 238
2259, 238, 300, 301, 239
2260, 239, 301, 302, 240
2261, 240, 302, 303, 241
2262, 241, 303, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
2263, 13, 17, 304, 256
2264, 256, 304, 305, 257
2265, 257, 305, 306, 258
2266, 258, 306, 307, 259
2267, 259, 307, 308, 260
2268, 260, 308, 309, 261
2269, 261, 309, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
2270, 16, 276, 310, 20
2271, 276, 277, 311, 310
2272, 277, 278, 312, 311
2273, 278, 279, 313, 312
2274, 279, 280, 314, 313
2275, 280, 281, 315, 314
2276, 281, 282, 316, 315
2277, 282, 283, 317, 316
2278, 283, 284, 318, 317
2279, 284, 285, 319, 318
2280, 285, 286, 320, 319
2281, 286, 15, 19, 320
*ELEMENT, type=CPS4, ELSET=Surface20
2282, 14, 287, 321, 18
2283, 287, 288, 322, 321
2284, 288, 289, 323, 322
2285, 289, 290, 324, 323
2286, 290, 291, 325, 324
2287, 291, 292, 326, 325
2288, 292, 16, 20, 326
*ELEMENT, type=CPS4, ELSET=Surface21
2289, 18, 321, 1811, 293
2290, 321, 322, 1812, 1811
2291, 322, 323, 1813, 1812
2292, 323, 324, 1814, 1813
2293, 324, 325, 1815, 1814
2294, 325, 326, 1816, 1815
2295, 326, 20, 310, 1816
2296, 293, 1811, 1817, 294
2297, 1811, 1812, 1818, 1817
2298, 1812, 1813, 1819, 1818
2299, 1813, 1814, 1820, 1819
2300, 1814, 1815, 1821, 1820
2301, 1815, 1816, 1822, 1821
2302, 1816, 310, 311, 1822
2303, 294, 1817, 1823, 295
2304, 1817, 1818, 1824, 1823
2305, 1818, 1819, 1825, 1824
2306, 1819, 1820, 1826, 1825
2307, 1820, 1821, 1827, 1826
2308, 1821, 1822, 1828, 1827
2309, 1822, 311, 312, 1828
2310, 295, 1823, 1829, 296
2311, 1823, 1824, 1830, 1829
2312, 1824, 1825, 1831, 1830
2313, 1825, 1826, 1832, 1831
2314, 1826, 1827, 1833, 1832
2315, 1827, 1828, 1834, 1833
2316, 1828, 312, 313, 1834
2317, 296, 1829, 1835, 297
2318, 1829, 1830, 1836, 1835
2319, 1830, 1831, 1837, 1836
2320, 1831, 1832, 1838, 1837
2321, 1832, 1833, 1839, 1838
2322, 1833, 1834, 1840, 1839
2323, 1834, 313, 314, 1840
2324, 297, 1835, 1841, 298
2325, 1835, 1836, 1842, 1841
2326, 1836, 1837, 1843, 1842
2327, 1837, 1838, 1844, 1843
2328, 1838, 1839, 1845, 1844
2329, 1839, 1840, 1846, 1845
2330, 1840, 314, 315, 1846
2331, 298, 1841, 1847, 299
2332, 1841, 1842, 1848, 1847
2333, 1842, 1843, 1849, 1848
2334, 1843, 1844, 1850, 1849
2335, 1844, 1845, 1851, 1850
2336, 1845, 1846, 1852, 1851
2337, 1846, 315, 316, 1852
2338, 299, 1847, 1853, 300
2339, 1847, 1848, 1854, 1853
2340, 1848, 1849, 1855, 1854
2341, 1849, 1850, 1856, 1855
2342, 1850, 1851, 1857, 1856
2343, 1851, 1852, 1858, 1857
2344, 1852, 316, 317, 1858
2345, 300, 1853, 1859, 301
2346, 1853, 1854, 1860, 1859
2347, 1854, 1855, 1861, 1860
2348, 1855, 1856, 1862, 1861
2349, 1856, 1857, 1863, 1862
2350, 1857, 1858, 1864, 1863
2351, 1858, 317, 318, 1864
2352, 301, 1859, 1865, 302
2353, 1859, 1860, 1866, 1865
2354, 1860, 1861, 1867, 1866
2355, 1861, 1862, 1868, 1867
2356, 1862, 1863, 1869, 1868
2357, 1863, 1864, 1870, 1869
2358, 1864, 318, 319, 1870
2359, 302, 1865, 1871, 303
2360, 1865, 1866, 1872, 1871
2361, 1866, 1867, 1873, 1872
2362, 1867, 1868, 1874, 1873
2363, 1868, 1869, 1875, 1874
2364, 1869, 1870, 1876, 1875
2365, 1870, 319, 320, 1876
2366, 303, 1871, 304, 17
2367, 1871, 1872, 305, 304
2368, 1872, 1873, 306, 305
2369, 1873, 1874, 307, 306
2370, 1874, 1875, 308, 307
2371, 1875, 1876, 309, 308
2372, 1876, 320, 19, 309
*ELEMENT, type=CPS4, ELSET=Surface22
2373, 18, 328, 1877, 293
2374, 328, 22, 329, 1877
2375, 293, 1877, 1878, 294
2376, 1877, 329, 330, 1878
2377, 294, 1878, 1879, 295
2378, 1878, 330, 331, 1879
2379, 295, 1879, 1880, 296
2380, 1879, 331, 332, 1880
2381, 296, 1880, 1881, 297
2382, 1880, 332, 333, 1881
2383, 297, 1881, 1882, 298
2384, 1881, 333, 334, 1882
2385, 298, 1882, 1883, 299
2386, 1882, 334, 335, 1883
2387, 299, 1883, 1884, 300
2388, 1883, 335, 336, 1884
2389, 300, 1884, 1885, 301
2390, 1884, 336, 337, 1885
2391, 301, 1885, 1886, 302
2392, 1885, 337, 338, 1886
2393, 302, 1886, 1887, 303
2394, 1886, 338, 339, 1887
2395, 303, 1887, 327, 17
2396, 1887, 339, 21, 327
*ELEMENT, type=CPS4, ELSET=Surface23
2397, 17, 327, 1888, 304
2398, 327, 21, 341, 1888
2399, 304, 1888, 1889, 305
2400, 1888, 341, 342, 1889
2401, 305, 1889, 1890, 306
2402, 1889, 342, 343, 1890
2403, 306, 1890, 1891, 307
2404, 1890, 343, 344, 1891
2405, 307, 1891, 1892, 308
2406, 1891, 344, 345, 1892
2407, 308, 1892, 1893, 309
2408, 1892, 345, 346, 1893
2409, 309, 1893, 340, 19
2410, 1893, 346, 23, 340
*ELEMENT, type=CPS4, ELSET=Surface24
2411, 20, 310, 1894, 347
2412, 347, 1894, 348, 24
2413, 310, 311, 1895, 1894
2414, 1894, 1895, 349, 348
2415, 311, 312, 1896, 1895
2416, 1895, 1896, 350, 349
2417, 312, 313, 1897, 1896
2418, 1896, 1897, 351, 350
2419, 313, 314, 1898, 1897
2420, 1897, 1898, 352, 351
2421, 314, 315, 1899, 1898
2422, 1898, 1899, 353, 352
2423, 315, 316, 1900, 1899
2424, 1899, 1900, 354, 353
2425, 316, 317, 1901, 1900
2426, 1900, 1901, 355, 354
2427, 317, 318, 1902, 1901
2428, 1901, 1902, 356, 355
2429, 318, 319, 1903, 1902
2430, 1902, 1903, 357, 356
2431, 319, 320, 1904, 1903
2432, 1903, 1904, 358, 357
2433, 320, 19, 340, 1904
2434, 1904, 340, 23, 358
*ELEMENT, type=CPS4, ELSET=Surface25
2435, 18, 321, 1905, 328
2436, 328, 1905, 359, 22
2437, 321, 322, 1906, 1905
2438, 1905, 1906, 360, 359
2439, 322, 323, 1907, 1906
2440, 1906, 1907, 361, 360
2441, 323, 324, 1908, 1907
2442, 1907, 1908, 362, 361
2443, 324, 325, 1909, 1908
2444, 1908, 1909, 363, 362
2445, 325, 326, 1910, 1909
2446, 1909, 1910, 364, 363
2447, 326, 20, 347, 1910
2448, 1910, 347, 24, 364
*ELEMENT, type=CPS4, ELSET=Surface26
2449, 22, 359, 1911, 329
2450, 359, 360, 1912, 1911
2451, 360, 361, 1913, 1912
2452, 361, 362, 1914, 1913
2453, 362, 363, 1915, 1914
2454, 363, 364, 1916, 1915
2455, 364, 24, 348, 1916
2456, 329, 1911, 1917, 330
2457, 1911, 1912, 1918, 1917
2458, 1912, 1913, 1919, 1918
2459, 1913, 1914, 1920, 1919
2460, 1914, 1915, 1921, 1920
2461, 1915, 1916, 1922, 1921
2462, 1916, 348, 349, 1922
2463, 330, 1917, 1923, 331
2464, 1917, 1918, 1924, 1923
2465, 1918, 1919, 1925, 1924
2466, 1919, 1920, 1926, 1925
2467, 1920, 1921, 1927, 1926
2468, 1921, 1922, 1928, 1927
2469, 1922, 349, 350, 1928
2470, 331, 1923, 1929, 332
2471, 1923, 1924, 1930, 1929
2472, 1924, 1925, 1931, 1930
2473, 1925, 1926, 1932, 1931
2474, 1926, 1927, 1933, 1932
2475, 1927, 1928, 1934, 1933
2476, 1928, 350, 351, 1934
2477, 332, 1929, 1935, 333
2478, 1929, 1930, 1936, 1935
2479, 1930, 1931, 1937, 1936
2480, 1931, 1932, 1938, 1937
2481, 1932, 1933, 1939, 1938
2482, 1933, 1934, 1940, 1939
2483, 1934, 351, 352, 1940
2484, 333, 1935, 1941, 334
2485, 1935, 1936, 1942, 1941
2486, 1936, 1937, 1943, 1942
2487, 1937, 1938, 1944, 1943
2488, 1938, 1939, 1945, 1944
2489, 1939, 1940, 1946, 1945
2490, 1940, 352, 353, 1946
2491, 334, 1941, 1947, 335
2492, 1941, 1942, 1948, 1947
2493, 1942, 1943, 1949, 1948
2494, 1943, 1944, 1950, 1949
2495, 1944, 1945, 1951, 1950
2496, 1945, 1946, 1952, 1951
2497, 1946, 353, 354, 1952
2498, 335, 1947, 1953, 336
2499, 1947, 1948, 1954, 1953
2500, 1948, 1949, 1955, 1954
2501, 1949, 1950, 1956, 1955
2502, 1950, 1951, 1957, 1956
2503, 1951, 1952, 1958, 1957
2504, 1952, 354, 355, 1958
2505, 336, 1953, 1959, 337
2506, 1953, 1954, 1960, 1959
2507, 1954, 1955, 1961, 1960
2508, 1955, 1956, 1962, 1961
2509, 1956, 1957, 1963, 1962
2510, 1957, 1958, 1964, 1963
2511, 1958, 355, 356, 1964
2512, 337, 1959, 1965, 338
2513, 1959, 1960, 1966, 1965
2514, 1960, 1961, 1967, 1966
2515, 1961, 1962, 1968, 1967
2516, 1962, 1963, 1969, 1968
2517, 1963, 1964, 1970, 1969
2518, 1964, 356, 357, 1970
2519, 338, 1965, 1971, 339
2520, 1965, 1966, 1972, 1971
2521, 1966, 1967, 1973, 1972
2522, 1967, 1968, 1974, 1973
2523, 1968, 1969, 1975, 1974
2524, 1969, 1970, 1976, 1975
2525, 1970, 357, 358, 1976
2526, 339, 1971, 341, 21
2527, 1971, 1972, 342, 341
2528, 1972, 1973, 343, 342
2529, 1973, 1974, 344, 343
2530, 1974, 1975, 345, 344
2531, 1975, 1976, 346, 345
2532, 1976, 358, 23, 346
*ELEMENT, type=CPS4, ELSET=Surface27
2533, 19, 25, 365, 340
2534, 340, 365, 26, 23
*ELEMENT, type=CPS4, ELSET=Surface28
2535, 17, 327, 366, 27
2536, 327, 21, 28, 366
*ELEMENT, type=CPS4, ELSET=Surface29
2537, 17, 27, 367, 304
2538, 304, 367, 368, 305
2539, 305, 368, 369, 306
2540, 306, 369, 370, 307
2541, 307, 370, 371, 308
2542, 308, 371, 372, 309
2543, 309, 372, 25, 19
*ELEMENT, type=CPS4, ELSET=Surface30
2544, 21, 341, 373, 28
2545, 341, 342, 374, 373
2546, 342, 343, 375, 374
2547, 343, 344, 376, 375
2548, 344, 345, 377, 376
2549, 345, 346, 378, 377
2550, 346, 23, 26, 378
*ELEMENT, type=CPS4, ELSET=Surface31
2551, 27, 366, 1977, 367
2552, 366, 28, 373, 1977
2553, 367, 1977, 1978, 368
2554, 1977, 373, 374, 1978
2555, 368, 1978, 1979, 369
2556, 1978, 374, 375, 1979
2557, 369, 1979, 1980, 370
2558, 1979, 375, 376, 1980
2559, 370, 1980, 1981, 371
2560, 1980, 376, 377, 1981
2561, 371, 1981, 1982, 372
2562, 1981, 377, 378, 1982
2563, 372, 1982, 365, 25
2564, 1982, 378, 26, 365
*ELEMENT, type=CPS4, ELSET=Surface32
2565, 25, 379, 1983, 365
2566, 379, 380, 1984, 1983
2567, 380, 381, 1985, 1984
2568, 381, 382, 1986, 1985
2569, 382, 383, 1987, 1986
2570, 383, 384, 1988, 1987
2571, 384, 385, 1989, 1988
2572, 385, 386, 1990, 1989
2573, 386, 387, 1991, 1990
2574, 387, 388, 1992, 1991
2575, 388, 389, 1993, 1992
2576, 389, 29, 401, 1993
2577, 365, 1983, 390, 26
2578, 1983, 1984, 391, 390
2579, 1984, 1985, 392, 391
2580, 1985, 1986, 393, 392
2581, 1986, 1987, 394, 393
2582, 1987, 1988, 395, 394
2583, 1988, 1989, 396, 395
2584, 1989, 1990, 397, 396
2585, 1990, 1991, 398, 397
2586, 1991, 1992, 399, 398
2587, 1992, 1993, 400, 399
2588, 1993, 401, 30, 400
*ELEMENT, type=CPS4, ELSET=Surface33
2589, 27, 366, 1994, 402
2590, 402, 1994, 1995, 403
2591, 403, 1995, 1996, 404
2592, 404, 1996, 1997, 405
2593, 405, 1997, 1998, 406
2594, 406, 1998, 1999, 407
2595, 407, 1999, 2000, 408
2596, 408, 2000, 2001, 409
2597, 409, 2001, 2002, 410
2598, 410, 2002, 2003, 411
2599, 411, 2003, 2004, 412
2600, 412, 2004, 424, 31
2601, 366, 28, 413, 1994
2602, 1994, 413, 414, 1995
2603, 1995, 414, 415, 1996
2604, 1996, 415, 416, 1997
2605, 1997, 416, 417, 1998
2606, 1998, 417, 418, 1999
2607, 1999, 418, 419, 2000
2608, 2000, 419, 420, 2001
2609, 2001, 420, 421, 2002
2610, 2002, 421, 422, 2003
2611, 2003, 422, 423, 2004
2612, 2004, 423, 32, 424
*ELEMENT, type=CPS4, ELSET=Surface34
2613, 27, 402, 2005, 367
2614, 402, 403, 2006, 2005
2615, 403, 404, 2007, 2006
2616, 404, 405, 2008, 2007
2617, 405, 406, 2009, 2008
2618, 406, 407, 2010, 2009
2619, 407, 408, 2011, 2010
2620, 408, 409, 2012, 2011
2621, 409, 410, 2013, 2012
2622, 410, 411, 2014, 2013
2623, 411, 412, 2015, 2014
2624, 412, 31, 425, 2015
2625, 367, 2005, 2016, 368
2626, 2005, 2006, 2017, 2016
2627, 2006, 2007, 2018, 2017
2628, 2007, 2008, 2019, 2018
2629, 2008, 2009, 2020, 2019
2630, 2009, 2010, 2021, 2020
2631, 2010, 2011, 2022, 2021
2632, 2011, 2012, 2023, 2022
2633, 2012, 2013, 2024, 2023
2634, 2013, 2014, 2025, 2024
2635, 2014, 2015, 2026, 2025
2636, 2015, 425, 426, 2026
2637, 368, 2016, 2027, 369
2638, 2016, 2017, 2028, 2027
2639, 2017, 2018, 2029, 2028
2640, 2018, 2019, 2030, 2029
2641, 2019, 2020, 2031, 2030
2642, 2020, 2021, 2032, 2031
2643, 2021, 2022, 2033, 2032
2644, 2022, 2023, 2034, 2033
2645, 2023, 2024, 2035, 2034
2646, 2024, 2025, 2036, 2035
2647, 2025, 2026, 2037, 2036
2648, 2026, 426, 427, 2037
2649, 369, 2027, 2038, 370
2650, 2027, 2028, 2039, 2038
2651, 2028, 2029, 2040, 2039
2652, 2029, 2030, 2041, 2040
2653, 2030, 2031, 2042, 2041
2654, 2031, 2032, 2043, 2042
2655, 2032, 2033, 2044, 2043
2656, 2033, 2034, 2045, 2044
2657, 2034, 2035, 2046, 2045
2658, 2035, 2036, 2047, 2046
2659, 2036, 2037, 2048, 2047
2660, 2037, 427, 428, 2048
2661, 370, 2038, 2049, 371
2662, 2038, 2039, 2050, 2049
2663, 2039, 2040, 2051, 2050
2664, 2040, 2041, 2052, 2051
2665, 2041, 2042, 2053, 2052
2666, 2042, 2043, 2054, 2053
2667, 2043, 2044, 2055, 2054
2668, 2044, 2045, 2056, 2055
2669, 2045, 2046, 2057, 2056
2670, 2046, 2047, 2058, 2057
2671, 2047, 2048, 2059, 2058
2672, 2048, 428, 429, 2059
2673, 371, 2049, 2060, 372
2674, 2049, 2050, 2061, 2060
2675, 2050, 2051, 2062, 2061
2676, 2051, 2052, 2063, 2062
2677, 2052, 2053, 2064, 2063
2678, 2053, 2054, 2065, 2064
2679, 2054, 2055, 2066, 2065
2680, 2055, 2056, 2067, 2066
2681, 2056, 2057, 2068, 2067
2682, 2057, 2058, 2069, 2068
2683, 2058, 2059, 2070, 2069
2684, 2059, 429, 430, 2070
2685, 372, 2060, 379, 25
2686, 2060, 2061, 380, 379
2687, 2061, 2062, 381, 380
2688, 2062, 2063, 382, 381
2689, 2063, 2064, 383, 382
2690, 2064, 2065, 384, 383
2691, 2065, 2066, 385, 384
2692, 2066, 2067, 386, 385
2693, 2067, 2068, 387, 386
2694, 2068, 2069, 388, 387
2695, 2069, 2070, 389, 388
2696, 2070, 430, 29, 389
*ELEMENT, type=CPS4, ELSET=Surface35
2697, 28, 373, 2071, 413
2698, 413, 2071, 2072, 414
2699, 414, 2072, 2073, 415
2700, 415, 2073, 2074, 416
2701, 416, 2074, 2075, 417
2702, 417, 2075, 2076, 418
2703, 418, 2076, 2077, 419
2704, 419, 2077, 2078, 420
2705, 420, 2078, 2079, 421
2706, 421, 2079, 2080, 422
2707, 422, 2080, 2081, 423
2708, 423, 2081, 431, 32
2709, 373, 374, 2082, 2071
2710, 2071, 2082, 2083, 2072
2711, 2072, 2083, 2084, 2073
2712, 2073, 2084, 2085, 2074
2713, 2074, 2085, 2086, 2075
2714, 2075, 2086, 2087, 2076
2715, 2076, 2087, 2088, 2077
2716, 2077, 2088, 2089, 2078
2717, 2078, 2089, 2090, 2079
2718, 2079, 2090, 2091, 2080
2719, 2080, 2091, 2092, 2081
2720, 2081, 2092, 432, 431
2721, 374, 375, 2093, 2082
2722, 2082, 2093, 2094, 2083
2723, 2083, 2094, 2095, 2084
2724, 2084, 2095, 2096, 2085
2725, 2085, 2096, 2097, 2086
2726, 2086, 2097, 2098, 2087
2727, 2087, 2098, 2099, 2088
2728, 2088, 2099, 2100, 2089
2729, 2089, 2100, 2101, 2090
2730, 2090, 2101, 2102, 2091
2731, 2091, 2102, 2103, 2092
2732, 2092, 2103, 433, 432
2733, 375, 376, 2104, 2093
2734, 2093, 2104, 2105, 2094
2735, 2094, 2105, 2106, 2095
2736, 2095, 2106, 2107, 2096
2737, 2096, 2107, 2108, 2097
2738, 2097, 2108, 2109, 2098
2739, 2098, 2109, 2110, 2099
2740, 2099, 2110, 2111, 2100
2741, 2100, 2111, 2112, 2101
2742, 2101, 2112, 2113, 2102
2743, 2102, 2113, 2114, 2103
2744, 2103, 2114, 434, 433
2745, 376, 377, 2115, 2104
2746, 2104, 2115, 2116, 2105
2747, 2105, 2116, 2117, 2106
2748, 2106, 2117, 2118, 2107
2749, 2107, 2118, 2119, 2108
2750, 2108, 2119, 2120, 2109
2751, 2109, 2120, 2121, 2110
2752, 2110, 2121, 2122, 2111
2753, 2111, 2122, 2123, 2112
2754, 2112, 2123, 2124, 2113
2755, 2113, 2124, 2125, 2114
2756, 2114, 2125, 435, 434
2757, 377, 378, 2126, 2115
2758, 2115, 2126, 2127, 2116
2759, 2116, 2127, 2128, 2117
2760, 2117, 2128, 2129, 2118
2761, 2118, 2129, 2130, 2119
2762, 2119, 2130, 2131, 2120
2763, 2120, 2131, 2132, 2121
2764, 2121, 2132, 2133, 2122
2765, 2122, 2133, 2134, 2123
2766, 2123, 2134, 2135, 2124
2767, 2124, 2135, 2136, 2125
2768, 2125, 2136, 436, 435
2769, 378, 26, 390, 2126
2770, 2126, 390, 391, 2127
2771, 2127, 391, 392, 2128
2772, 2128, 392, 393, 2129
2773, 2129, 393, 394, 2130
2774, 2130, 394, 395, 2131
2775, 2131, 395, 396, 2132
2776, 2132, 396, 397, 2133
2777, 2133, 397, 398, 2134
2778, 2134, 398, 399, 2135
2779, 2135, 399, 400, 2136
2780, 2136, 400, 30, 436
*ELEMENT, type=CPS4, ELSET=Surface36
2781, 31, 424, 2137, 425
2782, 424, 32, 431, 2137
2783, 425, 2137, 2138, 426
2784, 2137, 431, 432, 2138
2785, 426, 2138, 2139, 427
2786, 2138, 432, 433, 2139
2787, 427, 2139, 2140, 428
2788, 2139, 433, 434, 2140
2789, 428, 2140, 2141, 429
2790, 2140, 434, 435, 2141
2791, 429, 2141, 2142, 430
2792, 2141, 435, 436, 2142
2793, 430, 2142, 401, 29
2794, 2142, 436, 30, 401
*ELEMENT, type=CPS4, ELSET=Surface37
2795, 25, 33, 437, 379
2796, 379, 437, 438, 380
2797, 380, 438, 439, 381
2798, 381, 439, 440, 382
2799, 382, 440, 441, 383
2800, 383, 441, 442, 384
2801, 384, 442, 443, 385
2802, 385, 443, 444, 386
2803, 386, 444, 445, 387
2804, 387, 445, 446, 388
2805, 388, 446, 447, 389
2806, 389, 447, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
2807, 27, 402, 448, 35
2808, 402, 403, 449, 448
2809, 403, 404, 450, 449
2810, 404, 405, 451, 450
2811, 405, 406, 452, 451
2812, 406, 407, 453, 452
2813, 407, 408, 454, 453
2814, 408, 409, 455, 454
2815, 409, 410, 456, 455
2816, 410, 411, 457, 456
2817, 411, 412, 458, 457
2818, 412, 31, 36, 458
*ELEMENT, type=CPS4, ELSET=Surface39
2819, 27, 35, 459, 367
2820, 367, 459, 460, 368
2821, 368, 460, 461, 369
2822, 369, 461, 462, 370
2823, 370, 462, 463, 371
2824, 371, 463, 464, 372
2825, 372, 464, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
2826, 31, 425, 465, 36
2827, 425, 426, 466, 465
2828, 426, 427, 467, 466
2829, 427, 428, 468, 467
2830, 428, 429, 469, 468
2831, 429, 430, 470, 469
2832, 430, 29, 34, 470
*ELEMENT, type=CPS4, ELSET=Surface41
2833, 35, 448, 2143, 459
2834, 448, 449, 2144, 2143
2835, 449, 450, 2145, 2144
2836, 450, 451, 2146, 2145
2837, 451, 452, 2147, 2146
2838, 452, 453, 2148, 2147
2839, 453, 454, 2149, 2148
2840, 454, 455, 2150, 2149
2841, 455, 456, 2151, 2150
2842, 456, 457, 2152, 2151
2843, 457, 458, 2153, 2152
2844, 458, 36, 465, 2153
2845, 459, 2143, 2154, 460
2846, 2143, 2144, 2155, 2154
2847, 2144, 2145, 2156, 2155
2848, 2145, 2146, 2157, 2156
2849, 2146, 2147, 2158, 2157
2850, 2147, 2148, 2159, 2158
2851, 2148, 2149, 2160, 2159
2852, 2149, 2150, 2161, 2160
2853, 2150, 2151, 2162, 2161
2854, 2151, 2152, 2163, 2162
2855, 2152, 2153, 2164, 2163
2856, 2153, 465, 466, 2164
2857, 460, 2154, 2165, 461
2858, 2154, 2155, 2166, 2165
2859, 2155, 2156, 2167, 2166
2860, 2156, 2157, 2168, 2167
2861, 2157, 2158, 2169, 2168
2862, 2158, 2159, 2170, 2169
2863, 2159, 2160, 2171, 2170
2864, 2160, 2161, 2172, 2171
2865, 2161, 2162, 2173, 2172
2866, 2162, 2163, 2174, 2173
2867, 2163, 2164, 2175, 2174
2868, 2164, 466, 467, 2175
2869, 461, 2165, 2176, 462
2870, 2165, 2166, 2177, 2176
2871, 2166, 2167, 2178, 2177
2872, 2167, 2168, 2179, 2178
2873, 2168, 2169, 2180, 2179
2874, 2169, 2170, 2181, 2180
2875, 2170, 2171, 2182, 2181
2876, 2171, 2172, 2183, 2182
2877, 2172, 2173, 2184, 2183
2878, 2173, 2174, 2185, 2184
2879, 2174, 2175, 2186, 2185
2880, 2175, 467, 468, 2186
2881, 462, 2176, 2187, 463
2882, 2176, 2177, 2188, 2187
2883, 2177, 2178, 2189, 2188
