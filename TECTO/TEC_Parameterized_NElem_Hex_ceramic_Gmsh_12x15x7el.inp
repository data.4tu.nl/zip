*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_12x15x7el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 1, 1.6, 0
78, 0, 1.6, 0
79, 1, 1.6, 0.5
80, 0, 1.6, 0.5
81, 1.2, 1.6, 0.5
82, 1.2, 1.6, 0
83, 2.2, 1.6, 0.5
84, 2.2, 1.6, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.071428571428571
98, 0, 0, 0.14285714285714
99, 0, 0, 0.21428571428571
100, 0, 0, 0.28571428571429
101, 0, 0, 0.35714285714286
102, 0, 0, 0.42857142857143
103, 0, 0.025, 0.5
104, 0, 0.05, 0.071428571428571
105, 0, 0.05, 0.14285714285714
106, 0, 0.05, 0.21428571428571
107, 0, 0.05, 0.28571428571429
108, 0, 0.05, 0.35714285714286
109, 0, 0.05, 0.42857142857143
110, 0, 0.025, 0
111, 1, 0, 0.071428571428571
112, 1, 0, 0.14285714285714
113, 1, 0, 0.21428571428571
114, 1, 0, 0.28571428571429
115, 1, 0, 0.35714285714286
116, 1, 0, 0.42857142857143
117, 1, 0.025, 0.5
118, 1, 0.05, 0.071428571428571
119, 1, 0.05, 0.14285714285714
120, 1, 0.05, 0.21428571428571
121, 1, 0.05, 0.28571428571429
122, 1, 0.05, 0.35714285714286
123, 1, 0.05, 0.42857142857143
124, 1, 0.025, 0
125, 0.083333333333333, 0, 0
126, 0.16666666666667, 0, 0
127, 0.25, 0, 0
128, 0.33333333333333, 0, 0
129, 0.41666666666667, 0, 0
130, 0.5, 0, 0
131, 0.58333333333333, 0, 0
132, 0.66666666666667, 0, 0
133, 0.75, 0, 0
134, 0.83333333333333, 0, 0
135, 0.91666666666667, 0, 0
136, 0.083333333333333, 0, 0.5
137, 0.16666666666667, 0, 0.5
138, 0.25, 0, 0.5
139, 0.33333333333333, 0, 0.5
140, 0.41666666666667, 0, 0.5
141, 0.5, 0, 0.5
142, 0.58333333333333, 0, 0.5
143, 0.66666666666667, 0, 0.5
144, 0.75, 0, 0.5
145, 0.83333333333333, 0, 0.5
146, 0.91666666666667, 0, 0.5
147, 0.083333333333333, 0.05, 0
148, 0.16666666666667, 0.05, 0
149, 0.25, 0.05, 0
150, 0.33333333333333, 0.05, 0
151, 0.41666666666667, 0.05, 0
152, 0.5, 0.05, 0
153, 0.58333333333333, 0.05, 0
154, 0.66666666666667, 0.05, 0
155, 0.75, 0.05, 0
156, 0.83333333333333, 0.05, 0
157, 0.91666666666667, 0.05, 0
158, 0.083333333333333, 0.05, 0.5
159, 0.16666666666667, 0.05, 0.5
160, 0.25, 0.05, 0.5
161, 0.33333333333333, 0.05, 0.5
162, 0.41666666666667, 0.05, 0.5
163, 0.5, 0.05, 0.5
164, 0.58333333333333, 0.05, 0.5
165, 0.66666666666667, 0.05, 0.5
166, 0.75, 0.05, 0.5
167, 0.83333333333333, 0.05, 0.5
168, 0.91666666666667, 0.05, 0.5
169, 0.083333333333333, 0.1, 0
170, 0.16666666666667, 0.1, 0
171, 0.25, 0.1, 0
172, 0.33333333333333, 0.1, 0
173, 0.41666666666667, 0.1, 0
174, 0.5, 0.1, 0
175, 0.58333333333333, 0.1, 0
176, 0.66666666666667, 0.1, 0
177, 0.75, 0.1, 0
178, 0.83333333333333, 0.1, 0
179, 0.91666666666667, 0.1, 0
180, 1, 0.1, 0.071428571428571
181, 1, 0.1, 0.14285714285714
182, 1, 0.1, 0.21428571428571
183, 1, 0.1, 0.28571428571429
184, 1, 0.1, 0.35714285714286
185, 1, 0.1, 0.42857142857143
186, 0.083333333333333, 0.1, 0.5
187, 0.16666666666667, 0.1, 0.5
188, 0.25, 0.1, 0.5
189, 0.33333333333333, 0.1, 0.5
190, 0.41666666666667, 0.1, 0.5
191, 0.5, 0.1, 0.5
192, 0.58333333333333, 0.1, 0.5
193, 0.66666666666667, 0.1, 0.5
194, 0.75, 0.1, 0.5
195, 0.83333333333333, 0.1, 0.5
196, 0.91666666666667, 0.1, 0.5
197, 0, 0.1, 0.071428571428571
198, 0, 0.1, 0.14285714285714
199, 0, 0.1, 0.21428571428571
200, 0, 0.1, 0.28571428571429
201, 0, 0.1, 0.35714285714286
202, 0, 0.1, 0.42857142857143
203, 1, 0.18, 0
204, 1, 0.26, 0
205, 1, 0.34, 0
206, 1, 0.42, 0
207, 1, 0.5, 0
208, 1, 0.58, 0
209, 1, 0.66, 0
210, 1, 0.74, 0
211, 1, 0.82, 0
212, 1, 0.9, 0
213, 1, 0.98, 0
214, 1, 1.06, 0
215, 1, 1.14, 0
216, 1, 1.22, 0
217, 0, 0.18, 0
218, 0, 0.26, 0
219, 0, 0.34, 0
220, 0, 0.42, 0
221, 0, 0.5, 0
222, 0, 0.58, 0
223, 0, 0.66, 0
224, 0, 0.74, 0
225, 0, 0.82, 0
226, 0, 0.9, 0
227, 0, 0.98, 0
228, 0, 1.06, 0
229, 0, 1.14, 0
230, 0, 1.22, 0
231, 0.083333333333333, 1.3, 0
232, 0.16666666666667, 1.3, 0
233, 0.25, 1.3, 0
234, 0.33333333333333, 1.3, 0
235, 0.41666666666667, 1.3, 0
236, 0.5, 1.3, 0
237, 0.58333333333333, 1.3, 0
238, 0.66666666666667, 1.3, 0
239, 0.75, 1.3, 0
240, 0.83333333333333, 1.3, 0
241, 0.91666666666667, 1.3, 0
242, 1, 0.18, 0.5
243, 1, 0.26, 0.5
244, 1, 0.34, 0.5
245, 1, 0.42, 0.5
246, 1, 0.5, 0.5
247, 1, 0.58, 0.5
248, 1, 0.66, 0.5
249, 1, 0.74, 0.5
250, 1, 0.82, 0.5
251, 1, 0.9, 0.5
252, 1, 0.98, 0.5
253, 1, 1.06, 0.5
254, 1, 1.14, 0.5
255, 1, 1.22, 0.5
256, 1, 1.3, 0.071428571428571
257, 1, 1.3, 0.14285714285714
258, 1, 1.3, 0.21428571428571
259, 1, 1.3, 0.28571428571429
260, 1, 1.3, 0.35714285714286
261, 1, 1.3, 0.42857142857143
262, 0, 0.18, 0.5
263, 0, 0.26, 0.5
264, 0, 0.34, 0.5
265, 0, 0.42, 0.5
266, 0, 0.5, 0.5
267, 0, 0.58, 0.5
268, 0, 0.66, 0.5
269, 0, 0.74, 0.5
270, 0, 0.82, 0.5
271, 0, 0.9, 0.5
272, 0, 0.98, 0.5
273, 0, 1.06, 0.5
274, 0, 1.14, 0.5
275, 0, 1.22, 0.5
276, 0.083333333333333, 1.3, 0.5
277, 0.16666666666667, 1.3, 0.5
278, 0.25, 1.3, 0.5
279, 0.33333333333333, 1.3, 0.5
280, 0.41666666666667, 1.3, 0.5
281, 0.5, 1.3, 0.5
282, 0.58333333333333, 1.3, 0.5
283, 0.66666666666667, 1.3, 0.5
284, 0.75, 1.3, 0.5
285, 0.83333333333333, 1.3, 0.5
286, 0.91666666666667, 1.3, 0.5
287, 0, 1.3, 0.071428571428571
288, 0, 1.3, 0.14285714285714
289, 0, 1.3, 0.21428571428571
290, 0, 1.3, 0.28571428571429
291, 0, 1.3, 0.35714285714286
292, 0, 1.3, 0.42857142857143
293, 0.083333333333333, 1.35, 0
294, 0.16666666666667, 1.35, 0
295, 0.25, 1.35, 0
296, 0.33333333333333, 1.35, 0
297, 0.41666666666667, 1.35, 0
298, 0.5, 1.35, 0
299, 0.58333333333333, 1.35, 0
300, 0.66666666666667, 1.35, 0
301, 0.75, 1.35, 0
302, 0.83333333333333, 1.35, 0
303, 0.91666666666667, 1.35, 0
304, 1, 1.35, 0.071428571428571
305, 1, 1.35, 0.14285714285714
306, 1, 1.35, 0.21428571428571
307, 1, 1.35, 0.28571428571429
308, 1, 1.35, 0.35714285714286
309, 1, 1.35, 0.42857142857143
310, 0.083333333333333, 1.35, 0.5
311, 0.16666666666667, 1.35, 0.5
312, 0.25, 1.35, 0.5
313, 0.33333333333333, 1.35, 0.5
314, 0.41666666666667, 1.35, 0.5
315, 0.5, 1.35, 0.5
316, 0.58333333333333, 1.35, 0.5
317, 0.66666666666667, 1.35, 0.5
318, 0.75, 1.35, 0.5
319, 0.83333333333333, 1.35, 0.5
320, 0.91666666666667, 1.35, 0.5
321, 0, 1.35, 0.071428571428571
322, 0, 1.35, 0.14285714285714
323, 0, 1.35, 0.21428571428571
324, 0, 1.35, 0.28571428571429
325, 0, 1.35, 0.35714285714286
326, 0, 1.35, 0.42857142857143
327, 1, 1.375, 0
328, 0, 1.375, 0
329, 0.083333333333333, 1.4, 0
330, 0.16666666666667, 1.4, 0
331, 0.25, 1.4, 0
332, 0.33333333333333, 1.4, 0
333, 0.41666666666667, 1.4, 0
334, 0.5, 1.4, 0
335, 0.58333333333333, 1.4, 0
336, 0.66666666666667, 1.4, 0
337, 0.75, 1.4, 0
338, 0.83333333333333, 1.4, 0
339, 0.91666666666667, 1.4, 0
340, 1, 1.375, 0.5
341, 1, 1.4, 0.071428571428571
342, 1, 1.4, 0.14285714285714
343, 1, 1.4, 0.21428571428571
344, 1, 1.4, 0.28571428571429
345, 1, 1.4, 0.35714285714286
346, 1, 1.4, 0.42857142857143
347, 0, 1.375, 0.5
348, 0.083333333333333, 1.4, 0.5
349, 0.16666666666667, 1.4, 0.5
350, 0.25, 1.4, 0.5
351, 0.33333333333333, 1.4, 0.5
352, 0.41666666666667, 1.4, 0.5
353, 0.5, 1.4, 0.5
354, 0.58333333333333, 1.4, 0.5
355, 0.66666666666667, 1.4, 0.5
356, 0.75, 1.4, 0.5
357, 0.83333333333333, 1.4, 0.5
358, 0.91666666666667, 1.4, 0.5
359, 0, 1.4, 0.071428571428571
360, 0, 1.4, 0.14285714285714
361, 0, 1.4, 0.21428571428571
362, 0, 1.4, 0.28571428571429
363, 0, 1.4, 0.35714285714286
364, 0, 1.4, 0.42857142857143
365, 1.2, 1.375, 0.5
366, 1.2, 1.375, 0
367, 1.2, 1.35, 0.071428571428571
368, 1.2, 1.35, 0.14285714285714
369, 1.2, 1.35, 0.21428571428571
370, 1.2, 1.35, 0.28571428571429
371, 1.2, 1.35, 0.35714285714286
372, 1.2, 1.35, 0.42857142857143
373, 1.2, 1.4, 0.071428571428571
374, 1.2, 1.4, 0.14285714285714
375, 1.2, 1.4, 0.21428571428571
376, 1.2, 1.4, 0.28571428571429
377, 1.2, 1.4, 0.35714285714286
378, 1.2, 1.4, 0.42857142857143
379, 1.2833333333333, 1.35, 0.5
380, 1.3666666666667, 1.35, 0.5
381, 1.45, 1.35, 0.5
382, 1.5333333333333, 1.35, 0.5
383, 1.6166666666667, 1.35, 0.5
384, 1.7, 1.35, 0.5
385, 1.7833333333333, 1.35, 0.5
386, 1.8666666666667, 1.35, 0.5
387, 1.95, 1.35, 0.5
388, 2.0333333333333, 1.35, 0.5
389, 2.1166666666667, 1.35, 0.5
390, 1.2833333333333, 1.4, 0.5
391, 1.3666666666667, 1.4, 0.5
392, 1.45, 1.4, 0.5
393, 1.5333333333333, 1.4, 0.5
394, 1.6166666666667, 1.4, 0.5
395, 1.7, 1.4, 0.5
396, 1.7833333333333, 1.4, 0.5
397, 1.8666666666667, 1.4, 0.5
398, 1.95, 1.4, 0.5
399, 2.0333333333333, 1.4, 0.5
400, 2.1166666666667, 1.4, 0.5
401, 2.2, 1.375, 0.5
402, 1.2833333333333, 1.35, 0
403, 1.3666666666667, 1.35, 0
404, 1.45, 1.35, 0
405, 1.5333333333333, 1.35, 0
406, 1.6166666666667, 1.35, 0
407, 1.7, 1.35, 0
408, 1.7833333333333, 1.35, 0
409, 1.8666666666667, 1.35, 0
410, 1.95, 1.35, 0
411, 2.0333333333333, 1.35, 0
412, 2.1166666666667, 1.35, 0
413, 1.2833333333333, 1.4, 0
414, 1.3666666666667, 1.4, 0
415, 1.45, 1.4, 0
416, 1.5333333333333, 1.4, 0
417, 1.6166666666667, 1.4, 0
418, 1.7, 1.4, 0
419, 1.7833333333333, 1.4, 0
420, 1.8666666666667, 1.4, 0
421, 1.95, 1.4, 0
422, 2.0333333333333, 1.4, 0
423, 2.1166666666667, 1.4, 0
424, 2.2, 1.375, 0
425, 2.2, 1.35, 0.071428571428571
426, 2.2, 1.35, 0.14285714285714
427, 2.2, 1.35, 0.21428571428571
428, 2.2, 1.35, 0.28571428571429
429, 2.2, 1.35, 0.35714285714286
430, 2.2, 1.35, 0.42857142857143
431, 2.2, 1.4, 0.071428571428571
432, 2.2, 1.4, 0.14285714285714
433, 2.2, 1.4, 0.21428571428571
434, 2.2, 1.4, 0.28571428571429
435, 2.2, 1.4, 0.35714285714286
436, 2.2, 1.4, 0.42857142857143
437, 1.2833333333333, 1.3, 0.5
438, 1.3666666666667, 1.3, 0.5
439, 1.45, 1.3, 0.5
440, 1.5333333333333, 1.3, 0.5
441, 1.6166666666667, 1.3, 0.5
442, 1.7, 1.3, 0.5
443, 1.7833333333333, 1.3, 0.5
444, 1.8666666666667, 1.3, 0.5
445, 1.95, 1.3, 0.5
446, 2.0333333333333, 1.3, 0.5
447, 2.1166666666667, 1.3, 0.5
448, 1.2833333333333, 1.3, 0
449, 1.3666666666667, 1.3, 0
450, 1.45, 1.3, 0
451, 1.5333333333333, 1.3, 0
452, 1.6166666666667, 1.3, 0
453, 1.7, 1.3, 0
454, 1.7833333333333, 1.3, 0
455, 1.8666666666667, 1.3, 0
456, 1.95, 1.3, 0
457, 2.0333333333333, 1.3, 0
458, 2.1166666666667, 1.3, 0
459, 1.2, 1.3, 0.071428571428571
460, 1.2, 1.3, 0.14285714285714
461, 1.2, 1.3, 0.21428571428571
462, 1.2, 1.3, 0.28571428571429
463, 1.2, 1.3, 0.35714285714286
464, 1.2, 1.3, 0.42857142857143
465, 2.2, 1.3, 0.071428571428571
466, 2.2, 1.3, 0.14285714285714
467, 2.2, 1.3, 0.21428571428571
468, 2.2, 1.3, 0.28571428571429
469, 2.2, 1.3, 0.35714285714286
470, 2.2, 1.3, 0.42857142857143
471, 1.2, 1.22, 0.5
472, 1.2, 1.14, 0.5
473, 1.2, 1.06, 0.5
474, 1.2, 0.98, 0.5
475, 1.2, 0.9, 0.5
476, 1.2, 0.82, 0.5
477, 1.2, 0.74, 0.5
478, 1.2, 0.66, 0.5
479, 1.2, 0.58, 0.5
480, 1.2, 0.5, 0.5
481, 1.2, 0.42, 0.5
482, 1.2, 0.34, 0.5
483, 1.2, 0.26, 0.5
484, 1.2, 0.18, 0.5
485, 2.2, 1.22, 0.5
486, 2.2, 1.14, 0.5
487, 2.2, 1.06, 0.5
488, 2.2, 0.98, 0.5
489, 2.2, 0.9, 0.5
490, 2.2, 0.82, 0.5
491, 2.2, 0.74, 0.5
492, 2.2, 0.66, 0.5
493, 2.2, 0.58, 0.5
494, 2.2, 0.5, 0.5
495, 2.2, 0.42, 0.5
496, 2.2, 0.34, 0.5
497, 2.2, 0.26, 0.5
498, 2.2, 0.18, 0.5
499, 1.2833333333333, 0.1, 0.5
500, 1.3666666666667, 0.1, 0.5
501, 1.45, 0.1, 0.5
502, 1.5333333333333, 0.1, 0.5
503, 1.6166666666667, 0.1, 0.5
504, 1.7, 0.1, 0.5
505, 1.7833333333333, 0.1, 0.5
506, 1.8666666666667, 0.1, 0.5
507, 1.95, 0.1, 0.5
508, 2.0333333333333, 0.1, 0.5
509, 2.1166666666667, 0.1, 0.5
510, 1.2, 1.22, 0
511, 1.2, 1.14, 0
512, 1.2, 1.06, 0
513, 1.2, 0.98, 0
514, 1.2, 0.9, 0
515, 1.2, 0.82, 0
516, 1.2, 0.74, 0
517, 1.2, 0.66, 0
518, 1.2, 0.58, 0
519, 1.2, 0.5, 0
520, 1.2, 0.42, 0
521, 1.2, 0.34, 0
522, 1.2, 0.26, 0
523, 1.2, 0.18, 0
524, 2.2, 1.22, 0
525, 2.2, 1.14, 0
526, 2.2, 1.06, 0
527, 2.2, 0.98, 0
528, 2.2, 0.9, 0
529, 2.2, 0.82, 0
530, 2.2, 0.74, 0
531, 2.2, 0.66, 0
532, 2.2, 0.58, 0
533, 2.2, 0.5, 0
534, 2.2, 0.42, 0
535, 2.2, 0.34, 0
536, 2.2, 0.26, 0
537, 2.2, 0.18, 0
538, 1.2833333333333, 0.1, 0
539, 1.3666666666667, 0.1, 0
540, 1.45, 0.1, 0
541, 1.5333333333333, 0.1, 0
542, 1.6166666666667, 0.1, 0
543, 1.7, 0.1, 0
544, 1.7833333333333, 0.1, 0
545, 1.8666666666667, 0.1, 0
546, 1.95, 0.1, 0
547, 2.0333333333333, 0.1, 0
548, 2.1166666666667, 0.1, 0
549, 1.2, 0.1, 0.071428571428571
550, 1.2, 0.1, 0.14285714285714
551, 1.2, 0.1, 0.21428571428571
552, 1.2, 0.1, 0.28571428571429
553, 1.2, 0.1, 0.35714285714286
554, 1.2, 0.1, 0.42857142857143
555, 2.2, 0.1, 0.071428571428571
556, 2.2, 0.1, 0.14285714285714
557, 2.2, 0.1, 0.21428571428571
558, 2.2, 0.1, 0.28571428571429
559, 2.2, 0.1, 0.35714285714286
560, 2.2, 0.1, 0.42857142857143
561, 1.2833333333333, 0.05, 0.5
562, 1.3666666666667, 0.05, 0.5
563, 1.45, 0.05, 0.5
564, 1.5333333333333, 0.05, 0.5
565, 1.6166666666667, 0.05, 0.5
566, 1.7, 0.05, 0.5
567, 1.7833333333333, 0.05, 0.5
568, 1.8666666666667, 0.05, 0.5
569, 1.95, 0.05, 0.5
570, 2.0333333333333, 0.05, 0.5
571, 2.1166666666667, 0.05, 0.5
572, 1.2833333333333, 0.05, 0
573, 1.3666666666667, 0.05, 0
574, 1.45, 0.05, 0
575, 1.5333333333333, 0.05, 0
576, 1.6166666666667, 0.05, 0
577, 1.7, 0.05, 0
578, 1.7833333333333, 0.05, 0
579, 1.8666666666667, 0.05, 0
580, 1.95, 0.05, 0
581, 2.0333333333333, 0.05, 0
582, 2.1166666666667, 0.05, 0
583, 1.2, 0.05, 0.071428571428571
584, 1.2, 0.05, 0.14285714285714
585, 1.2, 0.05, 0.21428571428571
586, 1.2, 0.05, 0.28571428571429
587, 1.2, 0.05, 0.35714285714286
588, 1.2, 0.05, 0.42857142857143
589, 2.2, 0.05, 0.071428571428571
590, 2.2, 0.05, 0.14285714285714
591, 2.2, 0.05, 0.21428571428571
592, 2.2, 0.05, 0.28571428571429
593, 2.2, 0.05, 0.35714285714286
594, 2.2, 0.05, 0.42857142857143
595, 1.2, 0.025, 0.5
596, 2.2, 0.025, 0.5
597, 1.2833333333333, 8.3266726846887e-17, 0.5
598, 1.3666666666667, 8.3266726846887e-17, 0.5
599, 1.45, 8.3266726846887e-17, 0.5
600, 1.5333333333333, 8.3266726846887e-17, 0.5
601, 1.6166666666667, 8.3266726846887e-17, 0.5
602, 1.7, 8.3266726846887e-17, 0.5
603, 1.7833333333333, 8.3266726846887e-17, 0.5
604, 1.8666666666667, 8.3266726846887e-17, 0.5
605, 1.95, 8.3266726846887e-17, 0.5
606, 2.0333333333333, 8.3266726846887e-17, 0.5
607, 2.1166666666667, 8.3266726846887e-17, 0.5
608, 1.2, 0.025, 0
609, 2.2, 0.025, 0
610, 1.2833333333333, 8.3266726846887e-17, 0
611, 1.3666666666667, 8.3266726846887e-17, 0
612, 1.45, 8.3266726846887e-17, 0
613, 1.5333333333333, 8.3266726846887e-17, 0
614, 1.6166666666667, 8.3266726846887e-17, 0
615, 1.7, 8.3266726846887e-17, 0
616, 1.7833333333333, 8.3266726846887e-17, 0
617, 1.8666666666667, 8.3266726846887e-17, 0
618, 1.95, 8.3266726846887e-17, 0
619, 2.0333333333333, 8.3266726846887e-17, 0
620, 2.1166666666667, 8.3266726846887e-17, 0
621, 1.2, 8.3266726846887e-17, 0.071428571428571
622, 1.2, 8.3266726846887e-17, 0.14285714285714
623, 1.2, 8.3266726846887e-17, 0.21428571428571
624, 1.2, 8.3266726846887e-17, 0.28571428571429
625, 1.2, 8.3266726846887e-17, 0.35714285714286
626, 1.2, 8.3266726846887e-17, 0.42857142857143
627, 2.2, 8.3266726846887e-17, 0.071428571428571
628, 2.2, 8.3266726846887e-17, 0.14285714285714
629, 2.2, 8.3266726846887e-17, 0.21428571428571
630, 2.2, 8.3266726846887e-17, 0.28571428571429
631, 2.2, 8.3266726846887e-17, 0.35714285714286
632, 2.2, 8.3266726846887e-17, 0.42857142857143
633, 2.3, 0.025, 0.5
634, 2.3, 0.025, 0
635, 2.3, 0.05, 0.071428571428571
636, 2.3, 0.05, 0.14285714285714
637, 2.3, 0.05, 0.21428571428571
638, 2.3, 0.05, 0.28571428571429
639, 2.3, 0.05, 0.35714285714286
640, 2.3, 0.05, 0.42857142857143
641, 2.3, 8.3266726846887e-17, 0.071428571428571
642, 2.3, 8.3266726846887e-17, 0.14285714285714
643, 2.3, 8.3266726846887e-17, 0.21428571428571
644, 2.3, 8.3266726846887e-17, 0.28571428571429
645, 2.3, 8.3266726846887e-17, 0.35714285714286
646, 2.3, 8.3266726846887e-17, 0.42857142857143
647, -0.1, 0, 0.071428571428571
648, -0.1, 0, 0.14285714285714
649, -0.1, 0, 0.21428571428571
650, -0.1, 0, 0.28571428571429
651, -0.1, 0, 0.35714285714286
652, -0.1, 0, 0.42857142857143
653, -0.1, 0.025, 0.5
654, -0.1, 0.05, 0.071428571428571
655, -0.1, 0.05, 0.14285714285714
656, -0.1, 0.05, 0.21428571428571
657, -0.1, 0.05, 0.28571428571429
658, -0.1, 0.05, 0.35714285714286
659, -0.1, 0.05, 0.42857142857143
660, -0.1, 0.025, 0
661, 1.05, 0.18, 0.5
662, 1.05, 0.26, 0.5
663, 1.05, 0.34, 0.5
664, 1.05, 0.42, 0.5
665, 1.05, 0.5, 0.5
666, 1.05, 0.58, 0.5
667, 1.05, 0.66, 0.5
668, 1.05, 0.74, 0.5
669, 1.05, 0.82, 0.5
670, 1.05, 0.9, 0.5
671, 1.05, 0.98, 0.5
672, 1.05, 1.06, 0.5
673, 1.05, 1.14, 0.5
674, 1.05, 1.22, 0.5
675, 1.05, 0.18, 0
676, 1.05, 0.26, 0
677, 1.05, 0.34, 0
678, 1.05, 0.42, 0
679, 1.05, 0.5, 0
680, 1.05, 0.58, 0
681, 1.05, 0.66, 0
682, 1.05, 0.74, 0
683, 1.05, 0.82, 0
684, 1.05, 0.9, 0
685, 1.05, 0.98, 0
686, 1.05, 1.06, 0
687, 1.05, 1.14, 0
688, 1.05, 1.22, 0
689, 1.05, 0.1, 0.071428571428571
690, 1.05, 0.1, 0.14285714285714
691, 1.05, 0.1, 0.21428571428571
692, 1.05, 0.1, 0.28571428571429
693, 1.05, 0.1, 0.35714285714286
694, 1.05, 0.1, 0.42857142857143
695, 1.05, 1.3, 0.071428571428571
696, 1.05, 1.3, 0.14285714285714
697, 1.05, 1.3, 0.21428571428571
698, 1.05, 1.3, 0.28571428571429
699, 1.05, 1.3, 0.35714285714286
700, 1.05, 1.3, 0.42857142857143
701, 1.15, 1.22, 0.5
702, 1.15, 1.14, 0.5
703, 1.15, 1.06, 0.5
704, 1.15, 0.98, 0.5
705, 1.15, 0.9, 0.5
706, 1.15, 0.82, 0.5
707, 1.15, 0.74, 0.5
708, 1.15, 0.66, 0.5
709, 1.15, 0.58, 0.5
710, 1.15, 0.5, 0.5
711, 1.15, 0.42, 0.5
712, 1.15, 0.34, 0.5
713, 1.15, 0.26, 0.5
714, 1.15, 0.18, 0.5
715, 1.15, 1.22, 0
716, 1.15, 1.14, 0
717, 1.15, 1.06, 0
718, 1.15, 0.98, 0
719, 1.15, 0.9, 0
720, 1.15, 0.82, 0
721, 1.15, 0.74, 0
722, 1.15, 0.66, 0
723, 1.15, 0.58, 0
724, 1.15, 0.5, 0
725, 1.15, 0.42, 0
726, 1.15, 0.34, 0
727, 1.15, 0.26, 0
728, 1.15, 0.18, 0
729, 1.15, 1.3, 0.071428571428571
730, 1.15, 1.3, 0.14285714285714
731, 1.15, 1.3, 0.21428571428571
732, 1.15, 1.3, 0.28571428571429
733, 1.15, 1.3, 0.35714285714286
734, 1.15, 1.3, 0.42857142857143
735, 1.15, 0.1, 0.071428571428571
736, 1.15, 0.1, 0.14285714285714
737, 1.15, 0.1, 0.21428571428571
738, 1.15, 0.1, 0.28571428571429
739, 1.15, 0.1, 0.35714285714286
740, 1.15, 0.1, 0.42857142857143
741, 1, 0.18, -0.1
742, 1, 0.26, -0.1
743, 1, 0.34, -0.1
744, 1, 0.42, -0.1
745, 1, 0.5, -0.1
746, 1, 0.58, -0.1
747, 1, 0.66, -0.1
748, 1, 0.74, -0.1
749, 1, 0.82, -0.1
750, 1, 0.9, -0.1
751, 1, 0.98, -0.1
752, 1, 1.06, -0.1
753, 1, 1.14, -0.1
754, 1, 1.22, -0.1
755, 0, 0.18, -0.1
756, 0, 0.26, -0.1
757, 0, 0.34, -0.1
758, 0, 0.42, -0.1
759, 0, 0.5, -0.1
760, 0, 0.58, -0.1
761, 0, 0.66, -0.1
762, 0, 0.74, -0.1
763, 0, 0.82, -0.1
764, 0, 0.9, -0.1
765, 0, 0.98, -0.1
766, 0, 1.06, -0.1
767, 0, 1.14, -0.1
768, 0, 1.22, -0.1
769, 0.083333333333333, 0.1, -0.1
770, 0.16666666666667, 0.1, -0.1
771, 0.25, 0.1, -0.1
772, 0.33333333333333, 0.1, -0.1
773, 0.41666666666667, 0.1, -0.1
774, 0.5, 0.1, -0.1
775, 0.58333333333333, 0.1, -0.1
776, 0.66666666666667, 0.1, -0.1
777, 0.75, 0.1, -0.1
778, 0.83333333333333, 0.1, -0.1
779, 0.91666666666667, 0.1, -0.1
780, 0.083333333333333, 1.3, -0.1
781, 0.16666666666667, 1.3, -0.1
782, 0.25, 1.3, -0.1
783, 0.33333333333333, 1.3, -0.1
784, 0.41666666666667, 1.3, -0.1
785, 0.5, 1.3, -0.1
786, 0.58333333333333, 1.3, -0.1
787, 0.66666666666667, 1.3, -0.1
788, 0.75, 1.3, -0.1
789, 0.83333333333333, 1.3, -0.1
790, 0.91666666666667, 1.3, -0.1
791, 1.2, 1.22, -0.1
792, 1.2, 1.14, -0.1
793, 1.2, 1.06, -0.1
794, 1.2, 0.98, -0.1
795, 1.2, 0.9, -0.1
796, 1.2, 0.82, -0.1
797, 1.2, 0.74, -0.1
798, 1.2, 0.66, -0.1
799, 1.2, 0.58, -0.1
800, 1.2, 0.5, -0.1
801, 1.2, 0.42, -0.1
802, 1.2, 0.34, -0.1
803, 1.2, 0.26, -0.1
804, 1.2, 0.18, -0.1
805, 2.2, 1.22, -0.1
806, 2.2, 1.14, -0.1
807, 2.2, 1.06, -0.1
808, 2.2, 0.98, -0.1
809, 2.2, 0.9, -0.1
810, 2.2, 0.82, -0.1
811, 2.2, 0.74, -0.1
812, 2.2, 0.66, -0.1
813, 2.2, 0.58, -0.1
814, 2.2, 0.5, -0.1
815, 2.2, 0.42, -0.1
816, 2.2, 0.34, -0.1
817, 2.2, 0.26, -0.1
818, 2.2, 0.18, -0.1
819, 1.2833333333333, 1.3, -0.1
820, 1.3666666666667, 1.3, -0.1
821, 1.45, 1.3, -0.1
822, 1.5333333333333, 1.3, -0.1
823, 1.6166666666667, 1.3, -0.1
824, 1.7, 1.3, -0.1
825, 1.7833333333333, 1.3, -0.1
826, 1.8666666666667, 1.3, -0.1
827, 1.95, 1.3, -0.1
828, 2.0333333333333, 1.3, -0.1
829, 2.1166666666667, 1.3, -0.1
830, 1.2833333333333, 0.1, -0.1
831, 1.3666666666667, 0.1, -0.1
832, 1.45, 0.1, -0.1
833, 1.5333333333333, 0.1, -0.1
834, 1.6166666666667, 0.1, -0.1
835, 1.7, 0.1, -0.1
836, 1.7833333333333, 0.1, -0.1
837, 1.8666666666667, 0.1, -0.1
838, 1.95, 0.1, -0.1
839, 2.0333333333333, 0.1, -0.1
840, 2.1166666666667, 0.1, -0.1
841, 1.15, 1.22, -0.1
842, 1.15, 1.14, -0.1
843, 1.15, 1.06, -0.1
844, 1.15, 0.98, -0.1
845, 1.15, 0.9, -0.1
846, 1.15, 0.82, -0.1
847, 1.15, 0.74, -0.1
848, 1.15, 0.66, -0.1
849, 1.15, 0.58, -0.1
850, 1.15, 0.5, -0.1
851, 1.15, 0.42, -0.1
852, 1.15, 0.34, -0.1
853, 1.15, 0.26, -0.1
854, 1.15, 0.18, -0.1
855, 1.05, 0.18, -0.1
856, 1.05, 0.26, -0.1
857, 1.05, 0.34, -0.1
858, 1.05, 0.42, -0.1
859, 1.05, 0.5, -0.1
860, 1.05, 0.58, -0.1
861, 1.05, 0.66, -0.1
862, 1.05, 0.74, -0.1
863, 1.05, 0.82, -0.1
864, 1.05, 0.9, -0.1
865, 1.05, 0.98, -0.1
866, 1.05, 1.06, -0.1
867, 1.05, 1.14, -0.1
868, 1.05, 1.22, -0.1
869, 1, 1.5, 0
870, 0, 1.5, 0
871, 0.083333333333333, 1.6, 0
872, 0.16666666666667, 1.6, 0
873, 0.25, 1.6, 0
874, 0.33333333333333, 1.6, 0
875, 0.41666666666667, 1.6, 0
876, 0.5, 1.6, 0
877, 0.58333333333333, 1.6, 0
878, 0.66666666666667, 1.6, 0
879, 0.75, 1.6, 0
880, 0.83333333333333, 1.6, 0
881, 0.91666666666667, 1.6, 0
882, 1, 1.5, 0.5
883, 1, 1.6, 0.071428571428571
884, 1, 1.6, 0.14285714285714
885, 1, 1.6, 0.21428571428571
886, 1, 1.6, 0.28571428571429
887, 1, 1.6, 0.35714285714286
888, 1, 1.6, 0.42857142857143
889, 0, 1.5, 0.5
890, 0.083333333333333, 1.6, 0.5
891, 0.16666666666667, 1.6, 0.5
892, 0.25, 1.6, 0.5
893, 0.33333333333333, 1.6, 0.5
894, 0.41666666666667, 1.6, 0.5
895, 0.5, 1.6, 0.5
896, 0.58333333333333, 1.6, 0.5
897, 0.66666666666667, 1.6, 0.5
898, 0.75, 1.6, 0.5
899, 0.83333333333333, 1.6, 0.5
900, 0.91666666666667, 1.6, 0.5
901, 0, 1.6, 0.071428571428571
902, 0, 1.6, 0.14285714285714
903, 0, 1.6, 0.21428571428571
904, 0, 1.6, 0.28571428571429
905, 0, 1.6, 0.35714285714286
906, 0, 1.6, 0.42857142857143
907, 1.2, 1.5, 0.5
908, 1.2, 1.5, 0
909, 1.2, 1.6, 0.071428571428571
910, 1.2, 1.6, 0.14285714285714
911, 1.2, 1.6, 0.21428571428571
912, 1.2, 1.6, 0.28571428571429
913, 1.2, 1.6, 0.35714285714286
914, 1.2, 1.6, 0.42857142857143
915, 2.2, 1.5, 0.5
916, 1.2833333333333, 1.6, 0.5
917, 1.3666666666667, 1.6, 0.5
918, 1.45, 1.6, 0.5
919, 1.5333333333333, 1.6, 0.5
920, 1.6166666666667, 1.6, 0.5
921, 1.7, 1.6, 0.5
922, 1.7833333333333, 1.6, 0.5
923, 1.8666666666667, 1.6, 0.5
924, 1.95, 1.6, 0.5
925, 2.0333333333333, 1.6, 0.5
926, 2.1166666666667, 1.6, 0.5
927, 2.2, 1.5, 0
928, 1.2833333333333, 1.6, 0
929, 1.3666666666667, 1.6, 0
930, 1.45, 1.6, 0
931, 1.5333333333333, 1.6, 0
932, 1.6166666666667, 1.6, 0
933, 1.7, 1.6, 0
934, 1.7833333333333, 1.6, 0
935, 1.8666666666667, 1.6, 0
936, 1.95, 1.6, 0
937, 2.0333333333333, 1.6, 0
938, 2.1166666666667, 1.6, 0
939, 2.2, 1.6, 0.071428571428571
940, 2.2, 1.6, 0.14285714285714
941, 2.2, 1.6, 0.21428571428571
942, 2.2, 1.6, 0.28571428571429
943, 2.2, 1.6, 0.35714285714286
944, 2.2, 1.6, 0.42857142857143
945, 1, -0.1, 0
946, 0, -0.1, 0
947, 0.083333333333333, -0.2, 0
948, 0.16666666666667, -0.2, 0
949, 0.25, -0.2, 0
950, 0.33333333333333, -0.2, 0
951, 0.41666666666667, -0.2, 0
952, 0.5, -0.2, 0
953, 0.58333333333333, -0.2, 0
954, 0.66666666666667, -0.2, 0
955, 0.75, -0.2, 0
956, 0.83333333333333, -0.2, 0
957, 0.91666666666667, -0.2, 0
958, 1, -0.1, 0.5
959, 1, -0.2, 0.071428571428571
960, 1, -0.2, 0.14285714285714
961, 1, -0.2, 0.21428571428571
962, 1, -0.2, 0.28571428571429
963, 1, -0.2, 0.35714285714286
964, 1, -0.2, 0.42857142857143
965, 0, -0.1, 0.5
966, 0.083333333333333, -0.2, 0.5
967, 0.16666666666667, -0.2, 0.5
968, 0.25, -0.2, 0.5
969, 0.33333333333333, -0.2, 0.5
970, 0.41666666666667, -0.2, 0.5
971, 0.5, -0.2, 0.5
972, 0.58333333333333, -0.2, 0.5
973, 0.66666666666667, -0.2, 0.5
974, 0.75, -0.2, 0.5
975, 0.83333333333333, -0.2, 0.5
976, 0.91666666666667, -0.2, 0.5
977, 0, -0.2, 0.071428571428571
978, 0, -0.2, 0.14285714285714
979, 0, -0.2, 0.21428571428571
980, 0, -0.2, 0.28571428571429
981, 0, -0.2, 0.35714285714286
982, 0, -0.2, 0.42857142857143
983, -0.1, -0.1, 0.5
984, -0.1, -0.1, 0
985, -0.1, -0.2, 0.071428571428571
986, -0.1, -0.2, 0.14285714285714
987, -0.1, -0.2, 0.21428571428571
988, -0.1, -0.2, 0.28571428571429
989, -0.1, -0.2, 0.35714285714286
990, -0.1, -0.2, 0.42857142857143
991, 1.2, -0.1, 0.5
992, 2.2, -0.1, 0.5
993, 1.2833333333333, -0.2, 0.5
994, 1.3666666666667, -0.2, 0.5
995, 1.45, -0.2, 0.5
996, 1.5333333333333, -0.2, 0.5
997, 1.6166666666667, -0.2, 0.5
998, 1.7, -0.2, 0.5
999, 1.7833333333333, -0.2, 0.5
1000, 1.8666666666667, -0.2, 0.5
1001, 1.95, -0.2, 0.5
1002, 2.0333333333333, -0.2, 0.5
1003, 2.1166666666667, -0.2, 0.5
1004, 1.2, -0.1, 0
1005, 2.2, -0.1, 0
1006, 1.2833333333333, -0.2, 0
1007, 1.3666666666667, -0.2, 0
1008, 1.45, -0.2, 0
1009, 1.5333333333333, -0.2, 0
1010, 1.6166666666667, -0.2, 0
1011, 1.7, -0.2, 0
1012, 1.7833333333333, -0.2, 0
1013, 1.8666666666667, -0.2, 0
1014, 1.95, -0.2, 0
1015, 2.0333333333333, -0.2, 0
1016, 2.1166666666667, -0.2, 0
1017, 1.2, -0.2, 0.071428571428571
1018, 1.2, -0.2, 0.14285714285714
1019, 1.2, -0.2, 0.21428571428571
1020, 1.2, -0.2, 0.28571428571429
1021, 1.2, -0.2, 0.35714285714286
1022, 1.2, -0.2, 0.42857142857143
1023, 2.2, -0.2, 0.071428571428571
1024, 2.2, -0.2, 0.14285714285714
1025, 2.2, -0.2, 0.21428571428571
1026, 2.2, -0.2, 0.28571428571429
1027, 2.2, -0.2, 0.35714285714286
1028, 2.2, -0.2, 0.42857142857143
1029, 2.3, -0.1, 0.5
1030, 2.3, -0.1, 0
1031, 2.3, -0.2, 0.071428571428571
1032, 2.3, -0.2, 0.14285714285714
1033, 2.3, -0.2, 0.21428571428571
1034, 2.3, -0.2, 0.28571428571429
1035, 2.3, -0.2, 0.35714285714286
1036, 2.3, -0.2, 0.42857142857143
1037, 0, 0.025, 0.071428571428571
1038, 0, 0.025, 0.14285714285714
1039, 0, 0.025, 0.21428571428571
1040, 0, 0.025, 0.28571428571429
1041, 0, 0.025, 0.35714285714286
1042, 0, 0.025, 0.42857142857143
1043, 1, 0.025, 0.071428571428571
1044, 1, 0.025, 0.14285714285714
1045, 1, 0.025, 0.21428571428571
1046, 1, 0.025, 0.28571428571429
1047, 1, 0.025, 0.35714285714286
1048, 1, 0.025, 0.42857142857143
1049, 0.083333333333333, 0, 0.071428571428571
1050, 0.083333333333333, 0, 0.14285714285714
1051, 0.083333333333333, 0, 0.21428571428571
1052, 0.083333333333333, 0, 0.28571428571429
1053, 0.083333333333333, 0, 0.35714285714286
1054, 0.083333333333333, 0, 0.42857142857143
1055, 0.16666666666667, 0, 0.071428571428571
1056, 0.16666666666667, 0, 0.14285714285714
1057, 0.16666666666667, 0, 0.21428571428571
1058, 0.16666666666667, 0, 0.28571428571429
1059, 0.16666666666667, 0, 0.35714285714286
1060, 0.16666666666667, 0, 0.42857142857143
1061, 0.25, 0, 0.071428571428571
1062, 0.25, 0, 0.14285714285714
1063, 0.25, 0, 0.21428571428571
1064, 0.25, 0, 0.28571428571429
1065, 0.25, 0, 0.35714285714286
1066, 0.25, 0, 0.42857142857143
1067, 0.33333333333333, 0, 0.071428571428571
1068, 0.33333333333333, 0, 0.14285714285714
1069, 0.33333333333333, 0, 0.21428571428571
1070, 0.33333333333333, 0, 0.28571428571429
1071, 0.33333333333333, 0, 0.35714285714286
1072, 0.33333333333333, 0, 0.42857142857143
1073, 0.41666666666667, 0, 0.071428571428571
1074, 0.41666666666667, 0, 0.14285714285714
1075, 0.41666666666667, 0, 0.21428571428571
1076, 0.41666666666667, 0, 0.28571428571429
1077, 0.41666666666667, 0, 0.35714285714286
1078, 0.41666666666667, 0, 0.42857142857143
1079, 0.5, 0, 0.071428571428571
1080, 0.5, 0, 0.14285714285714
1081, 0.5, 0, 0.21428571428571
1082, 0.5, 0, 0.28571428571429
1083, 0.5, 0, 0.35714285714286
1084, 0.5, 0, 0.42857142857143
1085, 0.58333333333333, 0, 0.071428571428571
1086, 0.58333333333333, 0, 0.14285714285714
1087, 0.58333333333333, 0, 0.21428571428571
1088, 0.58333333333333, 0, 0.28571428571429
1089, 0.58333333333333, 0, 0.35714285714286
1090, 0.58333333333333, 0, 0.42857142857143
1091, 0.66666666666667, 0, 0.071428571428571
1092, 0.66666666666667, 0, 0.14285714285714
1093, 0.66666666666667, 0, 0.21428571428571
1094, 0.66666666666667, 0, 0.28571428571429
1095, 0.66666666666667, 0, 0.35714285714286
1096, 0.66666666666667, 0, 0.42857142857143
1097, 0.75, 0, 0.071428571428571
1098, 0.75, 0, 0.14285714285714
1099, 0.75, 0, 0.21428571428571
1100, 0.75, 0, 0.28571428571429
1101, 0.75, 0, 0.35714285714286
1102, 0.75, 0, 0.42857142857143
1103, 0.83333333333333, 0, 0.071428571428571
1104, 0.83333333333333, 0, 0.14285714285714
1105, 0.83333333333333, 0, 0.21428571428571
1106, 0.83333333333333, 0, 0.28571428571429
1107, 0.83333333333333, 0, 0.35714285714286
1108, 0.83333333333333, 0, 0.42857142857143
1109, 0.91666666666667, 0, 0.071428571428571
1110, 0.91666666666667, 0, 0.14285714285714
1111, 0.91666666666667, 0, 0.21428571428571
1112, 0.91666666666667, 0, 0.28571428571429
1113, 0.91666666666667, 0, 0.35714285714286
1114, 0.91666666666667, 0, 0.42857142857143
1115, 0.083333333333333, 0.05, 0.071428571428571
1116, 0.083333333333333, 0.05, 0.14285714285714
1117, 0.083333333333333, 0.05, 0.21428571428571
1118, 0.083333333333333, 0.05, 0.28571428571429
1119, 0.083333333333333, 0.05, 0.35714285714286
1120, 0.083333333333333, 0.05, 0.42857142857143
1121, 0.16666666666667, 0.05, 0.071428571428571
1122, 0.16666666666667, 0.05, 0.14285714285714
1123, 0.16666666666667, 0.05, 0.21428571428571
1124, 0.16666666666667, 0.05, 0.28571428571429
1125, 0.16666666666667, 0.05, 0.35714285714286
1126, 0.16666666666667, 0.05, 0.42857142857143
1127, 0.25, 0.05, 0.071428571428571
1128, 0.25, 0.05, 0.14285714285714
1129, 0.25, 0.05, 0.21428571428571
1130, 0.25, 0.05, 0.28571428571429
1131, 0.25, 0.05, 0.35714285714286
1132, 0.25, 0.05, 0.42857142857143
1133, 0.33333333333333, 0.05, 0.071428571428571
1134, 0.33333333333333, 0.05, 0.14285714285714
1135, 0.33333333333333, 0.05, 0.21428571428571
1136, 0.33333333333333, 0.05, 0.28571428571429
1137, 0.33333333333333, 0.05, 0.35714285714286
1138, 0.33333333333333, 0.05, 0.42857142857143
1139, 0.41666666666667, 0.05, 0.071428571428571
1140, 0.41666666666667, 0.05, 0.14285714285714
1141, 0.41666666666667, 0.05, 0.21428571428571
1142, 0.41666666666667, 0.05, 0.28571428571429
1143, 0.41666666666667, 0.05, 0.35714285714286
1144, 0.41666666666667, 0.05, 0.42857142857143
1145, 0.5, 0.05, 0.071428571428571
1146, 0.5, 0.05, 0.14285714285714
1147, 0.5, 0.05, 0.21428571428571
1148, 0.5, 0.05, 0.28571428571429
1149, 0.5, 0.05, 0.35714285714286
1150, 0.5, 0.05, 0.42857142857143
1151, 0.58333333333333, 0.05, 0.071428571428571
1152, 0.58333333333333, 0.05, 0.14285714285714
1153, 0.58333333333333, 0.05, 0.21428571428571
1154, 0.58333333333333, 0.05, 0.28571428571429
1155, 0.58333333333333, 0.05, 0.35714285714286
1156, 0.58333333333333, 0.05, 0.42857142857143
1157, 0.66666666666667, 0.05, 0.071428571428571
1158, 0.66666666666667, 0.05, 0.14285714285714
1159, 0.66666666666667, 0.05, 0.21428571428571
1160, 0.66666666666667, 0.05, 0.28571428571429
1161, 0.66666666666667, 0.05, 0.35714285714286
1162, 0.66666666666667, 0.05, 0.42857142857143
1163, 0.75, 0.05, 0.071428571428571
1164, 0.75, 0.05, 0.14285714285714
1165, 0.75, 0.05, 0.21428571428571
1166, 0.75, 0.05, 0.28571428571429
1167, 0.75, 0.05, 0.35714285714286
1168, 0.75, 0.05, 0.42857142857143
1169, 0.83333333333333, 0.05, 0.071428571428571
1170, 0.83333333333333, 0.05, 0.14285714285714
1171, 0.83333333333333, 0.05, 0.21428571428571
1172, 0.83333333333333, 0.05, 0.28571428571429
1173, 0.83333333333333, 0.05, 0.35714285714286
1174, 0.83333333333333, 0.05, 0.42857142857143
1175, 0.91666666666667, 0.05, 0.071428571428571
1176, 0.91666666666667, 0.05, 0.14285714285714
1177, 0.91666666666667, 0.05, 0.21428571428571
1178, 0.91666666666667, 0.05, 0.28571428571429
1179, 0.91666666666667, 0.05, 0.35714285714286
1180, 0.91666666666667, 0.05, 0.42857142857143
1181, 0.083333333333333, 0.025, 0
1182, 0.16666666666667, 0.025, 0
1183, 0.25, 0.025, 0
1184, 0.33333333333333, 0.025, 0
1185, 0.41666666666667, 0.025, 0
1186, 0.5, 0.025, 0
1187, 0.58333333333333, 0.025, 0
1188, 0.66666666666667, 0.025, 0
1189, 0.75, 0.025, 0
1190, 0.83333333333333, 0.025, 0
1191, 0.91666666666667, 0.025, 0
1192, 0.083333333333333, 0.025, 0.5
1193, 0.16666666666667, 0.025, 0.5
1194, 0.25, 0.025, 0.5
1195, 0.33333333333333, 0.025, 0.5
1196, 0.41666666666667, 0.025, 0.5
1197, 0.5, 0.025, 0.5
1198, 0.58333333333333, 0.025, 0.5
1199, 0.66666666666667, 0.025, 0.5
1200, 0.75, 0.025, 0.5
1201, 0.83333333333333, 0.025, 0.5
1202, 0.91666666666667, 0.025, 0.5
1203, 0.083333333333333, 0.1, 0.071428571428571
1204, 0.083333333333333, 0.1, 0.14285714285714
1205, 0.083333333333333, 0.1, 0.21428571428571
1206, 0.083333333333333, 0.1, 0.28571428571429
1207, 0.083333333333333, 0.1, 0.35714285714286
1208, 0.083333333333333, 0.1, 0.42857142857143
1209, 0.16666666666667, 0.1, 0.071428571428571
1210, 0.16666666666667, 0.1, 0.14285714285714
1211, 0.16666666666667, 0.1, 0.21428571428571
1212, 0.16666666666667, 0.1, 0.28571428571429
1213, 0.16666666666667, 0.1, 0.35714285714286
1214, 0.16666666666667, 0.1, 0.42857142857143
1215, 0.25, 0.1, 0.071428571428571
1216, 0.25, 0.1, 0.14285714285714
1217, 0.25, 0.1, 0.21428571428571
1218, 0.25, 0.1, 0.28571428571429
1219, 0.25, 0.1, 0.35714285714286
1220, 0.25, 0.1, 0.42857142857143
1221, 0.33333333333333, 0.1, 0.071428571428571
1222, 0.33333333333333, 0.1, 0.14285714285714
1223, 0.33333333333333, 0.1, 0.21428571428571
1224, 0.33333333333333, 0.1, 0.28571428571429
1225, 0.33333333333333, 0.1, 0.35714285714286
1226, 0.33333333333333, 0.1, 0.42857142857143
1227, 0.41666666666667, 0.1, 0.071428571428571
1228, 0.41666666666667, 0.1, 0.14285714285714
1229, 0.41666666666667, 0.1, 0.21428571428571
1230, 0.41666666666667, 0.1, 0.28571428571429
1231, 0.41666666666667, 0.1, 0.35714285714286
1232, 0.41666666666667, 0.1, 0.42857142857143
1233, 0.5, 0.1, 0.071428571428571
1234, 0.5, 0.1, 0.14285714285714
1235, 0.5, 0.1, 0.21428571428571
1236, 0.5, 0.1, 0.28571428571429
1237, 0.5, 0.1, 0.35714285714286
1238, 0.5, 0.1, 0.42857142857143
1239, 0.58333333333333, 0.1, 0.071428571428571
1240, 0.58333333333333, 0.1, 0.14285714285714
1241, 0.58333333333333, 0.1, 0.21428571428571
1242, 0.58333333333333, 0.1, 0.28571428571429
1243, 0.58333333333333, 0.1, 0.35714285714286
1244, 0.58333333333333, 0.1, 0.42857142857143
1245, 0.66666666666667, 0.1, 0.071428571428571
1246, 0.66666666666667, 0.1, 0.14285714285714
1247, 0.66666666666667, 0.1, 0.21428571428571
1248, 0.66666666666667, 0.1, 0.28571428571429
1249, 0.66666666666667, 0.1, 0.35714285714286
1250, 0.66666666666667, 0.1, 0.42857142857143
1251, 0.75, 0.1, 0.071428571428571
1252, 0.75, 0.1, 0.14285714285714
1253, 0.75, 0.1, 0.21428571428571
1254, 0.75, 0.1, 0.28571428571429
1255, 0.75, 0.1, 0.35714285714286
1256, 0.75, 0.1, 0.42857142857143
1257, 0.83333333333333, 0.1, 0.071428571428571
1258, 0.83333333333333, 0.1, 0.14285714285714
1259, 0.83333333333333, 0.1, 0.21428571428571
1260, 0.83333333333333, 0.1, 0.28571428571429
1261, 0.83333333333333, 0.1, 0.35714285714286
1262, 0.83333333333333, 0.1, 0.42857142857143
1263, 0.91666666666667, 0.1, 0.071428571428571
1264, 0.91666666666667, 0.1, 0.14285714285714
1265, 0.91666666666667, 0.1, 0.21428571428571
1266, 0.91666666666667, 0.1, 0.28571428571429
1267, 0.91666666666667, 0.1, 0.35714285714286
1268, 0.91666666666667, 0.1, 0.42857142857143
1269, 0.083333333333333, 0.18, 0
1270, 0.083333333333333, 0.26, 0
1271, 0.083333333333333, 0.34, 0
1272, 0.083333333333333, 0.42, 0
1273, 0.083333333333333, 0.5, 0
1274, 0.083333333333333, 0.58, 0
1275, 0.083333333333333, 0.66, 0
1276, 0.083333333333333, 0.74, 0
1277, 0.083333333333333, 0.82, 0
1278, 0.083333333333333, 0.9, 0
1279, 0.083333333333333, 0.98, 0
1280, 0.083333333333333, 1.06, 0
1281, 0.083333333333333, 1.14, 0
1282, 0.083333333333333, 1.22, 0
1283, 0.16666666666667, 0.18, 0
1284, 0.16666666666667, 0.26, 0
1285, 0.16666666666667, 0.34, 0
1286, 0.16666666666667, 0.42, 0
1287, 0.16666666666667, 0.5, 0
1288, 0.16666666666667, 0.58, 0
1289, 0.16666666666667, 0.66, 0
1290, 0.16666666666667, 0.74, 0
1291, 0.16666666666667, 0.82, 0
1292, 0.16666666666667, 0.9, 0
1293, 0.16666666666667, 0.98, 0
1294, 0.16666666666667, 1.06, 0
1295, 0.16666666666667, 1.14, 0
1296, 0.16666666666667, 1.22, 0
1297, 0.25, 0.18, 0
1298, 0.25, 0.26, 0
1299, 0.25, 0.34, 0
1300, 0.25, 0.42, 0
1301, 0.25, 0.5, 0
1302, 0.25, 0.58, 0
1303, 0.25, 0.66, 0
1304, 0.25, 0.74, 0
1305, 0.25, 0.82, 0
1306, 0.25, 0.9, 0
1307, 0.25, 0.98, 0
1308, 0.25, 1.06, 0
1309, 0.25, 1.14, 0
1310, 0.25, 1.22, 0
1311, 0.33333333333333, 0.18, 0
1312, 0.33333333333333, 0.26, 0
1313, 0.33333333333333, 0.34, 0
1314, 0.33333333333333, 0.42, 0
1315, 0.33333333333333, 0.5, 0
1316, 0.33333333333333, 0.58, 0
1317, 0.33333333333333, 0.66, 0
1318, 0.33333333333333, 0.74, 0
1319, 0.33333333333333, 0.82, 0
1320, 0.33333333333333, 0.9, 0
1321, 0.33333333333333, 0.98, 0
1322, 0.33333333333333, 1.06, 0
1323, 0.33333333333333, 1.14, 0
1324, 0.33333333333333, 1.22, 0
1325, 0.41666666666667, 0.18, 0
1326, 0.41666666666667, 0.26, 0
1327, 0.41666666666667, 0.34, 0
1328, 0.41666666666667, 0.42, 0
1329, 0.41666666666667, 0.5, 0
1330, 0.41666666666667, 0.58, 0
1331, 0.41666666666667, 0.66, 0
1332, 0.41666666666667, 0.74, 0
1333, 0.41666666666667, 0.82, 0
1334, 0.41666666666667, 0.9, 0
1335, 0.41666666666667, 0.98, 0
1336, 0.41666666666667, 1.06, 0
1337, 0.41666666666667, 1.14, 0
1338, 0.41666666666667, 1.22, 0
1339, 0.5, 0.18, 0
1340, 0.5, 0.26, 0
1341, 0.5, 0.34, 0
1342, 0.5, 0.42, 0
1343, 0.5, 0.5, 0
1344, 0.5, 0.58, 0
1345, 0.5, 0.66, 0
1346, 0.5, 0.74, 0
1347, 0.5, 0.82, 0
1348, 0.5, 0.9, 0
1349, 0.5, 0.98, 0
1350, 0.5, 1.06, 0
1351, 0.5, 1.14, 0
1352, 0.5, 1.22, 0
1353, 0.58333333333333, 0.18, 0
1354, 0.58333333333333, 0.26, 0
1355, 0.58333333333333, 0.34, 0
1356, 0.58333333333333, 0.42, 0
1357, 0.58333333333333, 0.5, 0
1358, 0.58333333333333, 0.58, 0
1359, 0.58333333333333, 0.66, 0
1360, 0.58333333333333, 0.74, 0
1361, 0.58333333333333, 0.82, 0
1362, 0.58333333333333, 0.9, 0
1363, 0.58333333333333, 0.98, 0
1364, 0.58333333333333, 1.06, 0
1365, 0.58333333333333, 1.14, 0
1366, 0.58333333333333, 1.22, 0
1367, 0.66666666666667, 0.18, 0
1368, 0.66666666666667, 0.26, 0
1369, 0.66666666666667, 0.34, 0
1370, 0.66666666666667, 0.42, 0
1371, 0.66666666666667, 0.5, 0
1372, 0.66666666666667, 0.58, 0
1373, 0.66666666666667, 0.66, 0
1374, 0.66666666666667, 0.74, 0
1375, 0.66666666666667, 0.82, 0
1376, 0.66666666666667, 0.9, 0
1377, 0.66666666666667, 0.98, 0
1378, 0.66666666666667, 1.06, 0
1379, 0.66666666666667, 1.14, 0
1380, 0.66666666666667, 1.22, 0
1381, 0.75, 0.18, 0
1382, 0.75, 0.26, 0
1383, 0.75, 0.34, 0
1384, 0.75, 0.42, 0
1385, 0.75, 0.5, 0
1386, 0.75, 0.58, 0
1387, 0.75, 0.66, 0
1388, 0.75, 0.74, 0
1389, 0.75, 0.82, 0
1390, 0.75, 0.9, 0
1391, 0.75, 0.98, 0
1392, 0.75, 1.06, 0
1393, 0.75, 1.14, 0
1394, 0.75, 1.22, 0
1395, 0.83333333333333, 0.18, 0
1396, 0.83333333333333, 0.26, 0
1397, 0.83333333333333, 0.34, 0
1398, 0.83333333333333, 0.42, 0
1399, 0.83333333333333, 0.5, 0
1400, 0.83333333333333, 0.58, 0
1401, 0.83333333333333, 0.66, 0
1402, 0.83333333333333, 0.74, 0
1403, 0.83333333333333, 0.82, 0
1404, 0.83333333333333, 0.9, 0
1405, 0.83333333333333, 0.98, 0
1406, 0.83333333333333, 1.06, 0
1407, 0.83333333333333, 1.14, 0
1408, 0.83333333333333, 1.22, 0
1409, 0.91666666666667, 0.18, 0
1410, 0.91666666666667, 0.26, 0
1411, 0.91666666666667, 0.34, 0
1412, 0.91666666666667, 0.42, 0
1413, 0.91666666666667, 0.5, 0
1414, 0.91666666666667, 0.58, 0
1415, 0.91666666666667, 0.66, 0
1416, 0.91666666666667, 0.74, 0
1417, 0.91666666666667, 0.82, 0
1418, 0.91666666666667, 0.9, 0
1419, 0.91666666666667, 0.98, 0
1420, 0.91666666666667, 1.06, 0
1421, 0.91666666666667, 1.14, 0
1422, 0.91666666666667, 1.22, 0
1423, 1, 0.18, 0.071428571428571
1424, 1, 0.26, 0.071428571428571
1425, 1, 0.34, 0.071428571428571
1426, 1, 0.42, 0.071428571428571
1427, 1, 0.5, 0.071428571428571
1428, 1, 0.58, 0.071428571428571
1429, 1, 0.66, 0.071428571428571
1430, 1, 0.74, 0.071428571428571
1431, 1, 0.82, 0.071428571428571
1432, 1, 0.9, 0.071428571428571
1433, 1, 0.98, 0.071428571428571
1434, 1, 1.06, 0.071428571428571
1435, 1, 1.14, 0.071428571428571
1436, 1, 1.22, 0.071428571428571
1437, 1, 0.18, 0.14285714285714
1438, 1, 0.26, 0.14285714285714
1439, 1, 0.34, 0.14285714285714
1440, 1, 0.42, 0.14285714285714
1441, 1, 0.5, 0.14285714285714
1442, 1, 0.58, 0.14285714285714
1443, 1, 0.66, 0.14285714285714
1444, 1, 0.74, 0.14285714285714
1445, 1, 0.82, 0.14285714285714
1446, 1, 0.9, 0.14285714285714
1447, 1, 0.98, 0.14285714285714
1448, 1, 1.06, 0.14285714285714
1449, 1, 1.14, 0.14285714285714
1450, 1, 1.22, 0.14285714285714
1451, 1, 0.18, 0.21428571428571
1452, 1, 0.26, 0.21428571428571
1453, 1, 0.34, 0.21428571428571
1454, 1, 0.42, 0.21428571428571
1455, 1, 0.5, 0.21428571428571
1456, 1, 0.58, 0.21428571428571
1457, 1, 0.66, 0.21428571428571
1458, 1, 0.74, 0.21428571428571
1459, 1, 0.82, 0.21428571428571
1460, 1, 0.9, 0.21428571428571
1461, 1, 0.98, 0.21428571428571
1462, 1, 1.06, 0.21428571428571
1463, 1, 1.14, 0.21428571428571
1464, 1, 1.22, 0.21428571428571
1465, 1, 0.18, 0.28571428571429
1466, 1, 0.26, 0.28571428571429
1467, 1, 0.34, 0.28571428571429
1468, 1, 0.42, 0.28571428571429
1469, 1, 0.5, 0.28571428571429
1470, 1, 0.58, 0.28571428571429
1471, 1, 0.66, 0.28571428571429
1472, 1, 0.74, 0.28571428571429
1473, 1, 0.82, 0.28571428571429
1474, 1, 0.9, 0.28571428571429
1475, 1, 0.98, 0.28571428571429
1476, 1, 1.06, 0.28571428571429
1477, 1, 1.14, 0.28571428571429
1478, 1, 1.22, 0.28571428571429
1479, 1, 0.18, 0.35714285714286
1480, 1, 0.26, 0.35714285714286
1481, 1, 0.34, 0.35714285714286
1482, 1, 0.42, 0.35714285714286
1483, 1, 0.5, 0.35714285714286
1484, 1, 0.58, 0.35714285714286
1485, 1, 0.66, 0.35714285714286
1486, 1, 0.74, 0.35714285714286
1487, 1, 0.82, 0.35714285714286
1488, 1, 0.9, 0.35714285714286
1489, 1, 0.98, 0.35714285714286
1490, 1, 1.06, 0.35714285714286
1491, 1, 1.14, 0.35714285714286
1492, 1, 1.22, 0.35714285714286
1493, 1, 0.18, 0.42857142857143
1494, 1, 0.26, 0.42857142857143
1495, 1, 0.34, 0.42857142857143
1496, 1, 0.42, 0.42857142857143
1497, 1, 0.5, 0.42857142857143
1498, 1, 0.58, 0.42857142857143
1499, 1, 0.66, 0.42857142857143
1500, 1, 0.74, 0.42857142857143
1501, 1, 0.82, 0.42857142857143
1502, 1, 0.9, 0.42857142857143
1503, 1, 0.98, 0.42857142857143
1504, 1, 1.06, 0.42857142857143
1505, 1, 1.14, 0.42857142857143
1506, 1, 1.22, 0.42857142857143
1507, 0.083333333333333, 0.18, 0.5
1508, 0.083333333333333, 0.26, 0.5
1509, 0.083333333333333, 0.34, 0.5
1510, 0.083333333333333, 0.42, 0.5
1511, 0.083333333333333, 0.5, 0.5
1512, 0.083333333333333, 0.58, 0.5
1513, 0.083333333333333, 0.66, 0.5
1514, 0.083333333333333, 0.74, 0.5
1515, 0.083333333333333, 0.82, 0.5
1516, 0.083333333333333, 0.9, 0.5
1517, 0.083333333333333, 0.98, 0.5
1518, 0.083333333333333, 1.06, 0.5
1519, 0.083333333333333, 1.14, 0.5
1520, 0.083333333333333, 1.22, 0.5
1521, 0.16666666666667, 0.18, 0.5
1522, 0.16666666666667, 0.26, 0.5
1523, 0.16666666666667, 0.34, 0.5
1524, 0.16666666666667, 0.42, 0.5
1525, 0.16666666666667, 0.5, 0.5
1526, 0.16666666666667, 0.58, 0.5
1527, 0.16666666666667, 0.66, 0.5
1528, 0.16666666666667, 0.74, 0.5
1529, 0.16666666666667, 0.82, 0.5
1530, 0.16666666666667, 0.9, 0.5
1531, 0.16666666666667, 0.98, 0.5
1532, 0.16666666666667, 1.06, 0.5
1533, 0.16666666666667, 1.14, 0.5
1534, 0.16666666666667, 1.22, 0.5
1535, 0.25, 0.18, 0.5
1536, 0.25, 0.26, 0.5
1537, 0.25, 0.34, 0.5
1538, 0.25, 0.42, 0.5
1539, 0.25, 0.5, 0.5
1540, 0.25, 0.58, 0.5
1541, 0.25, 0.66, 0.5
1542, 0.25, 0.74, 0.5
1543, 0.25, 0.82, 0.5
1544, 0.25, 0.9, 0.5
1545, 0.25, 0.98, 0.5
1546, 0.25, 1.06, 0.5
1547, 0.25, 1.14, 0.5
1548, 0.25, 1.22, 0.5
1549, 0.33333333333333, 0.18, 0.5
1550, 0.33333333333333, 0.26, 0.5
1551, 0.33333333333333, 0.34, 0.5
1552, 0.33333333333333, 0.42, 0.5
1553, 0.33333333333333, 0.5, 0.5
1554, 0.33333333333333, 0.58, 0.5
1555, 0.33333333333333, 0.66, 0.5
1556, 0.33333333333333, 0.74, 0.5
1557, 0.33333333333333, 0.82, 0.5
1558, 0.33333333333333, 0.9, 0.5
1559, 0.33333333333333, 0.98, 0.5
1560, 0.33333333333333, 1.06, 0.5
1561, 0.33333333333333, 1.14, 0.5
1562, 0.33333333333333, 1.22, 0.5
1563, 0.41666666666667, 0.18, 0.5
1564, 0.41666666666667, 0.26, 0.5
1565, 0.41666666666667, 0.34, 0.5
1566, 0.41666666666667, 0.42, 0.5
1567, 0.41666666666667, 0.5, 0.5
1568, 0.41666666666667, 0.58, 0.5
1569, 0.41666666666667, 0.66, 0.5
1570, 0.41666666666667, 0.74, 0.5
1571, 0.41666666666667, 0.82, 0.5
1572, 0.41666666666667, 0.9, 0.5
1573, 0.41666666666667, 0.98, 0.5
1574, 0.41666666666667, 1.06, 0.5
1575, 0.41666666666667, 1.14, 0.5
1576, 0.41666666666667, 1.22, 0.5
1577, 0.5, 0.18, 0.5
1578, 0.5, 0.26, 0.5
1579, 0.5, 0.34, 0.5
1580, 0.5, 0.42, 0.5
1581, 0.5, 0.5, 0.5
1582, 0.5, 0.58, 0.5
1583, 0.5, 0.66, 0.5
1584, 0.5, 0.74, 0.5
1585, 0.5, 0.82, 0.5
1586, 0.5, 0.9, 0.5
1587, 0.5, 0.98, 0.5
1588, 0.5, 1.06, 0.5
1589, 0.5, 1.14, 0.5
1590, 0.5, 1.22, 0.5
1591, 0.58333333333333, 0.18, 0.5
1592, 0.58333333333333, 0.26, 0.5
1593, 0.58333333333333, 0.34, 0.5
1594, 0.58333333333333, 0.42, 0.5
1595, 0.58333333333333, 0.5, 0.5
1596, 0.58333333333333, 0.58, 0.5
1597, 0.58333333333333, 0.66, 0.5
1598, 0.58333333333333, 0.74, 0.5
1599, 0.58333333333333, 0.82, 0.5
1600, 0.58333333333333, 0.9, 0.5
1601, 0.58333333333333, 0.98, 0.5
1602, 0.58333333333333, 1.06, 0.5
1603, 0.58333333333333, 1.14, 0.5
1604, 0.58333333333333, 1.22, 0.5
1605, 0.66666666666667, 0.18, 0.5
1606, 0.66666666666667, 0.26, 0.5
1607, 0.66666666666667, 0.34, 0.5
1608, 0.66666666666667, 0.42, 0.5
1609, 0.66666666666667, 0.5, 0.5
1610, 0.66666666666667, 0.58, 0.5
1611, 0.66666666666667, 0.66, 0.5
1612, 0.66666666666667, 0.74, 0.5
1613, 0.66666666666667, 0.82, 0.5
1614, 0.66666666666667, 0.9, 0.5
1615, 0.66666666666667, 0.98, 0.5
1616, 0.66666666666667, 1.06, 0.5
1617, 0.66666666666667, 1.14, 0.5
1618, 0.66666666666667, 1.22, 0.5
1619, 0.75, 0.18, 0.5
1620, 0.75, 0.26, 0.5
1621, 0.75, 0.34, 0.5
1622, 0.75, 0.42, 0.5
1623, 0.75, 0.5, 0.5
1624, 0.75, 0.58, 0.5
1625, 0.75, 0.66, 0.5
1626, 0.75, 0.74, 0.5
1627, 0.75, 0.82, 0.5
1628, 0.75, 0.9, 0.5
1629, 0.75, 0.98, 0.5
1630, 0.75, 1.06, 0.5
1631, 0.75, 1.14, 0.5
1632, 0.75, 1.22, 0.5
1633, 0.83333333333333, 0.18, 0.5
1634, 0.83333333333333, 0.26, 0.5
1635, 0.83333333333333, 0.34, 0.5
1636, 0.83333333333333, 0.42, 0.5
1637, 0.83333333333333, 0.5, 0.5
1638, 0.83333333333333, 0.58, 0.5
1639, 0.83333333333333, 0.66, 0.5
1640, 0.83333333333333, 0.74, 0.5
1641, 0.83333333333333, 0.82, 0.5
1642, 0.83333333333333, 0.9, 0.5
1643, 0.83333333333333, 0.98, 0.5
1644, 0.83333333333333, 1.06, 0.5
1645, 0.83333333333333, 1.14, 0.5
1646, 0.83333333333333, 1.22, 0.5
1647, 0.91666666666667, 0.18, 0.5
1648, 0.91666666666667, 0.26, 0.5
1649, 0.91666666666667, 0.34, 0.5
1650, 0.91666666666667, 0.42, 0.5
1651, 0.91666666666667, 0.5, 0.5
1652, 0.91666666666667, 0.58, 0.5
1653, 0.91666666666667, 0.66, 0.5
1654, 0.91666666666667, 0.74, 0.5
1655, 0.91666666666667, 0.82, 0.5
1656, 0.91666666666667, 0.9, 0.5
1657, 0.91666666666667, 0.98, 0.5
1658, 0.91666666666667, 1.06, 0.5
1659, 0.91666666666667, 1.14, 0.5
1660, 0.91666666666667, 1.22, 0.5
1661, 0, 0.18, 0.071428571428571
1662, 0, 0.26, 0.071428571428571
1663, 0, 0.34, 0.071428571428571
1664, 0, 0.42, 0.071428571428571
1665, 0, 0.5, 0.071428571428571
1666, 0, 0.58, 0.071428571428571
1667, 0, 0.66, 0.071428571428571
1668, 0, 0.74, 0.071428571428571
1669, 0, 0.82, 0.071428571428571
1670, 0, 0.9, 0.071428571428571
1671, 0, 0.98, 0.071428571428571
1672, 0, 1.06, 0.071428571428571
1673, 0, 1.14, 0.071428571428571
1674, 0, 1.22, 0.071428571428571
1675, 0, 0.18, 0.14285714285714
1676, 0, 0.26, 0.14285714285714
1677, 0, 0.34, 0.14285714285714
1678, 0, 0.42, 0.14285714285714
1679, 0, 0.5, 0.14285714285714
1680, 0, 0.58, 0.14285714285714
1681, 0, 0.66, 0.14285714285714
1682, 0, 0.74, 0.14285714285714
1683, 0, 0.82, 0.14285714285714
1684, 0, 0.9, 0.14285714285714
1685, 0, 0.98, 0.14285714285714
1686, 0, 1.06, 0.14285714285714
1687, 0, 1.14, 0.14285714285714
1688, 0, 1.22, 0.14285714285714
1689, 0, 0.18, 0.21428571428571
1690, 0, 0.26, 0.21428571428571
1691, 0, 0.34, 0.21428571428571
1692, 0, 0.42, 0.21428571428571
1693, 0, 0.5, 0.21428571428571
1694, 0, 0.58, 0.21428571428571
1695, 0, 0.66, 0.21428571428571
1696, 0, 0.74, 0.21428571428571
1697, 0, 0.82, 0.21428571428571
1698, 0, 0.9, 0.21428571428571
1699, 0, 0.98, 0.21428571428571
1700, 0, 1.06, 0.21428571428571
1701, 0, 1.14, 0.21428571428571
1702, 0, 1.22, 0.21428571428571
1703, 0, 0.18, 0.28571428571429
1704, 0, 0.26, 0.28571428571429
1705, 0, 0.34, 0.28571428571429
1706, 0, 0.42, 0.28571428571429
1707, 0, 0.5, 0.28571428571429
1708, 0, 0.58, 0.28571428571429
1709, 0, 0.66, 0.28571428571429
1710, 0, 0.74, 0.28571428571429
1711, 0, 0.82, 0.28571428571429
1712, 0, 0.9, 0.28571428571429
1713, 0, 0.98, 0.28571428571429
1714, 0, 1.06, 0.28571428571429
1715, 0, 1.14, 0.28571428571429
1716, 0, 1.22, 0.28571428571429
1717, 0, 0.18, 0.35714285714286
1718, 0, 0.26, 0.35714285714286
1719, 0, 0.34, 0.35714285714286
1720, 0, 0.42, 0.35714285714286
1721, 0, 0.5, 0.35714285714286
1722, 0, 0.58, 0.35714285714286
1723, 0, 0.66, 0.35714285714286
1724, 0, 0.74, 0.35714285714286
1725, 0, 0.82, 0.35714285714286
1726, 0, 0.9, 0.35714285714286
1727, 0, 0.98, 0.35714285714286
1728, 0, 1.06, 0.35714285714286
1729, 0, 1.14, 0.35714285714286
1730, 0, 1.22, 0.35714285714286
1731, 0, 0.18, 0.42857142857143
1732, 0, 0.26, 0.42857142857143
1733, 0, 0.34, 0.42857142857143
1734, 0, 0.42, 0.42857142857143
1735, 0, 0.5, 0.42857142857143
1736, 0, 0.58, 0.42857142857143
1737, 0, 0.66, 0.42857142857143
1738, 0, 0.74, 0.42857142857143
1739, 0, 0.82, 0.42857142857143
1740, 0, 0.9, 0.42857142857143
1741, 0, 0.98, 0.42857142857143
1742, 0, 1.06, 0.42857142857143
1743, 0, 1.14, 0.42857142857143
1744, 0, 1.22, 0.42857142857143
1745, 0.083333333333333, 1.3, 0.071428571428571
1746, 0.083333333333333, 1.3, 0.14285714285714
1747, 0.083333333333333, 1.3, 0.21428571428571
1748, 0.083333333333333, 1.3, 0.28571428571429
1749, 0.083333333333333, 1.3, 0.35714285714286
1750, 0.083333333333333, 1.3, 0.42857142857143
1751, 0.16666666666667, 1.3, 0.071428571428571
1752, 0.16666666666667, 1.3, 0.14285714285714
1753, 0.16666666666667, 1.3, 0.21428571428571
1754, 0.16666666666667, 1.3, 0.28571428571429
1755, 0.16666666666667, 1.3, 0.35714285714286
1756, 0.16666666666667, 1.3, 0.42857142857143
1757, 0.25, 1.3, 0.071428571428571
1758, 0.25, 1.3, 0.14285714285714
1759, 0.25, 1.3, 0.21428571428571
1760, 0.25, 1.3, 0.28571428571429
1761, 0.25, 1.3, 0.35714285714286
1762, 0.25, 1.3, 0.42857142857143
1763, 0.33333333333333, 1.3, 0.071428571428571
1764, 0.33333333333333, 1.3, 0.14285714285714
1765, 0.33333333333333, 1.3, 0.21428571428571
1766, 0.33333333333333, 1.3, 0.28571428571429
1767, 0.33333333333333, 1.3, 0.35714285714286
1768, 0.33333333333333, 1.3, 0.42857142857143
1769, 0.41666666666667, 1.3, 0.071428571428571
1770, 0.41666666666667, 1.3, 0.14285714285714
1771, 0.41666666666667, 1.3, 0.21428571428571
1772, 0.41666666666667, 1.3, 0.28571428571429
1773, 0.41666666666667, 1.3, 0.35714285714286
1774, 0.41666666666667, 1.3, 0.42857142857143
1775, 0.5, 1.3, 0.071428571428571
1776, 0.5, 1.3, 0.14285714285714
1777, 0.5, 1.3, 0.21428571428571
1778, 0.5, 1.3, 0.28571428571429
1779, 0.5, 1.3, 0.35714285714286
1780, 0.5, 1.3, 0.42857142857143
1781, 0.58333333333333, 1.3, 0.071428571428571
1782, 0.58333333333333, 1.3, 0.14285714285714
1783, 0.58333333333333, 1.3, 0.21428571428571
1784, 0.58333333333333, 1.3, 0.28571428571429
1785, 0.58333333333333, 1.3, 0.35714285714286
1786, 0.58333333333333, 1.3, 0.42857142857143
1787, 0.66666666666667, 1.3, 0.071428571428571
1788, 0.66666666666667, 1.3, 0.14285714285714
1789, 0.66666666666667, 1.3, 0.21428571428571
1790, 0.66666666666667, 1.3, 0.28571428571429
1791, 0.66666666666667, 1.3, 0.35714285714286
1792, 0.66666666666667, 1.3, 0.42857142857143
1793, 0.75, 1.3, 0.071428571428571
1794, 0.75, 1.3, 0.14285714285714
1795, 0.75, 1.3, 0.21428571428571
1796, 0.75, 1.3, 0.28571428571429
1797, 0.75, 1.3, 0.35714285714286
1798, 0.75, 1.3, 0.42857142857143
1799, 0.83333333333333, 1.3, 0.071428571428571
1800, 0.83333333333333, 1.3, 0.14285714285714
1801, 0.83333333333333, 1.3, 0.21428571428571
1802, 0.83333333333333, 1.3, 0.28571428571429
1803, 0.83333333333333, 1.3, 0.35714285714286
1804, 0.83333333333333, 1.3, 0.42857142857143
1805, 0.91666666666667, 1.3, 0.071428571428571
1806, 0.91666666666667, 1.3, 0.14285714285714
1807, 0.91666666666667, 1.3, 0.21428571428571
1808, 0.91666666666667, 1.3, 0.28571428571429
1809, 0.91666666666667, 1.3, 0.35714285714286
1810, 0.91666666666667, 1.3, 0.42857142857143
1811, 0.083333333333333, 1.35, 0.071428571428571
1812, 0.083333333333333, 1.35, 0.14285714285714
1813, 0.083333333333333, 1.35, 0.21428571428571
1814, 0.083333333333333, 1.35, 0.28571428571429
1815, 0.083333333333333, 1.35, 0.35714285714286
1816, 0.083333333333333, 1.35, 0.42857142857143
1817, 0.16666666666667, 1.35, 0.071428571428571
1818, 0.16666666666667, 1.35, 0.14285714285714
1819, 0.16666666666667, 1.35, 0.21428571428571
1820, 0.16666666666667, 1.35, 0.28571428571429
1821, 0.16666666666667, 1.35, 0.35714285714286
1822, 0.16666666666667, 1.35, 0.42857142857143
1823, 0.25, 1.35, 0.071428571428571
1824, 0.25, 1.35, 0.14285714285714
1825, 0.25, 1.35, 0.21428571428571
1826, 0.25, 1.35, 0.28571428571429
1827, 0.25, 1.35, 0.35714285714286
1828, 0.25, 1.35, 0.42857142857143
1829, 0.33333333333333, 1.35, 0.071428571428571
1830, 0.33333333333333, 1.35, 0.14285714285714
1831, 0.33333333333333, 1.35, 0.21428571428571
1832, 0.33333333333333, 1.35, 0.28571428571429
1833, 0.33333333333333, 1.35, 0.35714285714286
1834, 0.33333333333333, 1.35, 0.42857142857143
1835, 0.41666666666667, 1.35, 0.071428571428571
1836, 0.41666666666667, 1.35, 0.14285714285714
1837, 0.41666666666667, 1.35, 0.21428571428571
1838, 0.41666666666667, 1.35, 0.28571428571429
1839, 0.41666666666667, 1.35, 0.35714285714286
1840, 0.41666666666667, 1.35, 0.42857142857143
1841, 0.5, 1.35, 0.071428571428571
1842, 0.5, 1.35, 0.14285714285714
1843, 0.5, 1.35, 0.21428571428571
1844, 0.5, 1.35, 0.28571428571429
1845, 0.5, 1.35, 0.35714285714286
1846, 0.5, 1.35, 0.42857142857143
1847, 0.58333333333333, 1.35, 0.071428571428571
1848, 0.58333333333333, 1.35, 0.14285714285714
1849, 0.58333333333333, 1.35, 0.21428571428571
1850, 0.58333333333333, 1.35, 0.28571428571429
1851, 0.58333333333333, 1.35, 0.35714285714286
1852, 0.58333333333333, 1.35, 0.42857142857143
1853, 0.66666666666667, 1.35, 0.071428571428571
1854, 0.66666666666667, 1.35, 0.14285714285714
1855, 0.66666666666667, 1.35, 0.21428571428571
1856, 0.66666666666667, 1.35, 0.28571428571429
1857, 0.66666666666667, 1.35, 0.35714285714286
1858, 0.66666666666667, 1.35, 0.42857142857143
1859, 0.75, 1.35, 0.071428571428571
1860, 0.75, 1.35, 0.14285714285714
1861, 0.75, 1.35, 0.21428571428571
1862, 0.75, 1.35, 0.28571428571429
1863, 0.75, 1.35, 0.35714285714286
1864, 0.75, 1.35, 0.42857142857143
1865, 0.83333333333333, 1.35, 0.071428571428571
1866, 0.83333333333333, 1.35, 0.14285714285714
1867, 0.83333333333333, 1.35, 0.21428571428571
1868, 0.83333333333333, 1.35, 0.28571428571429
1869, 0.83333333333333, 1.35, 0.35714285714286
1870, 0.83333333333333, 1.35, 0.42857142857143
1871, 0.91666666666667, 1.35, 0.071428571428571
1872, 0.91666666666667, 1.35, 0.14285714285714
1873, 0.91666666666667, 1.35, 0.21428571428571
1874, 0.91666666666667, 1.35, 0.28571428571429
1875, 0.91666666666667, 1.35, 0.35714285714286
1876, 0.91666666666667, 1.35, 0.42857142857143
1877, 0.083333333333333, 1.375, 0
1878, 0.16666666666667, 1.375, 0
1879, 0.25, 1.375, 0
1880, 0.33333333333333, 1.375, 0
1881, 0.41666666666667, 1.375, 0
1882, 0.5, 1.375, 0
1883, 0.58333333333333, 1.375, 0
1884, 0.66666666666667, 1.375, 0
1885, 0.75, 1.375, 0
1886, 0.83333333333333, 1.375, 0
1887, 0.91666666666667, 1.375, 0
1888, 1, 1.375, 0.071428571428571
1889, 1, 1.375, 0.14285714285714
1890, 1, 1.375, 0.21428571428571
1891, 1, 1.375, 0.28571428571429
1892, 1, 1.375, 0.35714285714286
1893, 1, 1.375, 0.42857142857143
1894, 0.083333333333333, 1.375, 0.5
1895, 0.16666666666667, 1.375, 0.5
1896, 0.25, 1.375, 0.5
1897, 0.33333333333333, 1.375, 0.5
1898, 0.41666666666667, 1.375, 0.5
1899, 0.5, 1.375, 0.5
1900, 0.58333333333333, 1.375, 0.5
1901, 0.66666666666667, 1.375, 0.5
1902, 0.75, 1.375, 0.5
1903, 0.83333333333333, 1.375, 0.5
1904, 0.91666666666667, 1.375, 0.5
1905, 0, 1.375, 0.071428571428571
1906, 0, 1.375, 0.14285714285714
1907, 0, 1.375, 0.21428571428571
1908, 0, 1.375, 0.28571428571429
1909, 0, 1.375, 0.35714285714286
1910, 0, 1.375, 0.42857142857143
1911, 0.083333333333333, 1.4, 0.071428571428571
1912, 0.083333333333333, 1.4, 0.14285714285714
1913, 0.083333333333333, 1.4, 0.21428571428571
1914, 0.083333333333333, 1.4, 0.28571428571429
1915, 0.083333333333333, 1.4, 0.35714285714286
1916, 0.083333333333333, 1.4, 0.42857142857143
1917, 0.16666666666667, 1.4, 0.071428571428571
1918, 0.16666666666667, 1.4, 0.14285714285714
1919, 0.16666666666667, 1.4, 0.21428571428571
1920, 0.16666666666667, 1.4, 0.28571428571429
1921, 0.16666666666667, 1.4, 0.35714285714286
1922, 0.16666666666667, 1.4, 0.42857142857143
1923, 0.25, 1.4, 0.071428571428571
1924, 0.25, 1.4, 0.14285714285714
1925, 0.25, 1.4, 0.21428571428571
1926, 0.25, 1.4, 0.28571428571429
1927, 0.25, 1.4, 0.35714285714286
1928, 0.25, 1.4, 0.42857142857143
1929, 0.33333333333333, 1.4, 0.071428571428571
1930, 0.33333333333333, 1.4, 0.14285714285714
1931, 0.33333333333333, 1.4, 0.21428571428571
1932, 0.33333333333333, 1.4, 0.28571428571429
1933, 0.33333333333333, 1.4, 0.35714285714286
1934, 0.33333333333333, 1.4, 0.42857142857143
1935, 0.41666666666667, 1.4, 0.071428571428571
1936, 0.41666666666667, 1.4, 0.14285714285714
1937, 0.41666666666667, 1.4, 0.21428571428571
1938, 0.41666666666667, 1.4, 0.28571428571429
1939, 0.41666666666667, 1.4, 0.35714285714286
1940, 0.41666666666667, 1.4, 0.42857142857143
1941, 0.5, 1.4, 0.071428571428571
1942, 0.5, 1.4, 0.14285714285714
1943, 0.5, 1.4, 0.21428571428571
1944, 0.5, 1.4, 0.28571428571429
1945, 0.5, 1.4, 0.35714285714286
1946, 0.5, 1.4, 0.42857142857143
1947, 0.58333333333333, 1.4, 0.071428571428571
1948, 0.58333333333333, 1.4, 0.14285714285714
1949, 0.58333333333333, 1.4, 0.21428571428571
1950, 0.58333333333333, 1.4, 0.28571428571429
1951, 0.58333333333333, 1.4, 0.35714285714286
1952, 0.58333333333333, 1.4, 0.42857142857143
1953, 0.66666666666667, 1.4, 0.071428571428571
1954, 0.66666666666667, 1.4, 0.14285714285714
1955, 0.66666666666667, 1.4, 0.21428571428571
1956, 0.66666666666667, 1.4, 0.28571428571429
1957, 0.66666666666667, 1.4, 0.35714285714286
1958, 0.66666666666667, 1.4, 0.42857142857143
1959, 0.75, 1.4, 0.071428571428571
1960, 0.75, 1.4, 0.14285714285714
1961, 0.75, 1.4, 0.21428571428571
1962, 0.75, 1.4, 0.28571428571429
1963, 0.75, 1.4, 0.35714285714286
1964, 0.75, 1.4, 0.42857142857143
1965, 0.83333333333333, 1.4, 0.071428571428571
1966, 0.83333333333333, 1.4, 0.14285714285714
1967, 0.83333333333333, 1.4, 0.21428571428571
1968, 0.83333333333333, 1.4, 0.28571428571429
1969, 0.83333333333333, 1.4, 0.35714285714286
1970, 0.83333333333333, 1.4, 0.42857142857143
1971, 0.91666666666667, 1.4, 0.071428571428571
1972, 0.91666666666667, 1.4, 0.14285714285714
1973, 0.91666666666667, 1.4, 0.21428571428571
1974, 0.91666666666667, 1.4, 0.28571428571429
1975, 0.91666666666667, 1.4, 0.35714285714286
1976, 0.91666666666667, 1.4, 0.42857142857143
1977, 1.2, 1.375, 0.071428571428571
1978, 1.2, 1.375, 0.14285714285714
1979, 1.2, 1.375, 0.21428571428571
1980, 1.2, 1.375, 0.28571428571429
1981, 1.2, 1.375, 0.35714285714286
1982, 1.2, 1.375, 0.42857142857143
1983, 1.2833333333333, 1.375, 0.5
1984, 1.3666666666667, 1.375, 0.5
1985, 1.45, 1.375, 0.5
1986, 1.5333333333333, 1.375, 0.5
1987, 1.6166666666667, 1.375, 0.5
1988, 1.7, 1.375, 0.5
1989, 1.7833333333333, 1.375, 0.5
1990, 1.8666666666667, 1.375, 0.5
1991, 1.95, 1.375, 0.5
1992, 2.0333333333333, 1.375, 0.5
1993, 2.1166666666667, 1.375, 0.5
1994, 1.2833333333333, 1.375, 0
1995, 1.3666666666667, 1.375, 0
1996, 1.45, 1.375, 0
1997, 1.5333333333333, 1.375, 0
1998, 1.6166666666667, 1.375, 0
1999, 1.7, 1.375, 0
2000, 1.7833333333333, 1.375, 0
2001, 1.8666666666667, 1.375, 0
2002, 1.95, 1.375, 0
2003, 2.0333333333333, 1.375, 0
2004, 2.1166666666667, 1.375, 0
2005, 1.2833333333333, 1.35, 0.071428571428571
2006, 1.3666666666667, 1.35, 0.071428571428571
2007, 1.45, 1.35, 0.071428571428571
2008, 1.5333333333333, 1.35, 0.071428571428571
2009, 1.6166666666667, 1.35, 0.071428571428571
2010, 1.7, 1.35, 0.071428571428571
2011, 1.7833333333333, 1.35, 0.071428571428571
2012, 1.8666666666667, 1.35, 0.071428571428571
2013, 1.95, 1.35, 0.071428571428571
2014, 2.0333333333333, 1.35, 0.071428571428571
2015, 2.1166666666667, 1.35, 0.071428571428571
2016, 1.2833333333333, 1.35, 0.14285714285714
2017, 1.3666666666667, 1.35, 0.14285714285714
2018, 1.45, 1.35, 0.14285714285714
2019, 1.5333333333333, 1.35, 0.14285714285714
2020, 1.6166666666667, 1.35, 0.14285714285714
2021, 1.7, 1.35, 0.14285714285714
2022, 1.7833333333333, 1.35, 0.14285714285714
2023, 1.8666666666667, 1.35, 0.14285714285714
2024, 1.95, 1.35, 0.14285714285714
2025, 2.0333333333333, 1.35, 0.14285714285714
2026, 2.1166666666667, 1.35, 0.14285714285714
2027, 1.2833333333333, 1.35, 0.21428571428571
2028, 1.3666666666667, 1.35, 0.21428571428571
2029, 1.45, 1.35, 0.21428571428571
2030, 1.5333333333333, 1.35, 0.21428571428571
2031, 1.6166666666667, 1.35, 0.21428571428571
2032, 1.7, 1.35, 0.21428571428571
2033, 1.7833333333333, 1.35, 0.21428571428571
2034, 1.8666666666667, 1.35, 0.21428571428571
2035, 1.95, 1.35, 0.21428571428571
2036, 2.0333333333333, 1.35, 0.21428571428571
2037, 2.1166666666667, 1.35, 0.21428571428571
2038, 1.2833333333333, 1.35, 0.28571428571429
2039, 1.3666666666667, 1.35, 0.28571428571429
2040, 1.45, 1.35, 0.28571428571429
2041, 1.5333333333333, 1.35, 0.28571428571429
2042, 1.6166666666667, 1.35, 0.28571428571429
2043, 1.7, 1.35, 0.28571428571429
2044, 1.7833333333333, 1.35, 0.28571428571429
2045, 1.8666666666667, 1.35, 0.28571428571429
2046, 1.95, 1.35, 0.28571428571429
2047, 2.0333333333333, 1.35, 0.28571428571429
2048, 2.1166666666667, 1.35, 0.28571428571429
2049, 1.2833333333333, 1.35, 0.35714285714286
2050, 1.3666666666667, 1.35, 0.35714285714286
2051, 1.45, 1.35, 0.35714285714286
2052, 1.5333333333333, 1.35, 0.35714285714286
2053, 1.6166666666667, 1.35, 0.35714285714286
2054, 1.7, 1.35, 0.35714285714286
2055, 1.7833333333333, 1.35, 0.35714285714286
2056, 1.8666666666667, 1.35, 0.35714285714286
2057, 1.95, 1.35, 0.35714285714286
2058, 2.0333333333333, 1.35, 0.35714285714286
2059, 2.1166666666667, 1.35, 0.35714285714286
2060, 1.2833333333333, 1.35, 0.42857142857143
2061, 1.3666666666667, 1.35, 0.42857142857143
2062, 1.45, 1.35, 0.42857142857143
2063, 1.5333333333333, 1.35, 0.42857142857143
2064, 1.6166666666667, 1.35, 0.42857142857143
2065, 1.7, 1.35, 0.42857142857143
2066, 1.7833333333333, 1.35, 0.42857142857143
2067, 1.8666666666667, 1.35, 0.42857142857143
2068, 1.95, 1.35, 0.42857142857143
2069, 2.0333333333333, 1.35, 0.42857142857143
2070, 2.1166666666667, 1.35, 0.42857142857143
2071, 1.2833333333333, 1.4, 0.071428571428571
2072, 1.3666666666667, 1.4, 0.071428571428571
2073, 1.45, 1.4, 0.071428571428571
2074, 1.5333333333333, 1.4, 0.071428571428571
2075, 1.6166666666667, 1.4, 0.071428571428571
2076, 1.7, 1.4, 0.071428571428571
2077, 1.7833333333333, 1.4, 0.071428571428571
2078, 1.8666666666667, 1.4, 0.071428571428571
2079, 1.95, 1.4, 0.071428571428571
2080, 2.0333333333333, 1.4, 0.071428571428571
2081, 2.1166666666667, 1.4, 0.071428571428571
2082, 1.2833333333333, 1.4, 0.14285714285714
2083, 1.3666666666667, 1.4, 0.14285714285714
2084, 1.45, 1.4, 0.14285714285714
2085, 1.5333333333333, 1.4, 0.14285714285714
2086, 1.6166666666667, 1.4, 0.14285714285714
2087, 1.7, 1.4, 0.14285714285714
2088, 1.7833333333333, 1.4, 0.14285714285714
2089, 1.8666666666667, 1.4, 0.14285714285714
2090, 1.95, 1.4, 0.14285714285714
2091, 2.0333333333333, 1.4, 0.14285714285714
2092, 2.1166666666667, 1.4, 0.14285714285714
2093, 1.2833333333333, 1.4, 0.21428571428571
2094, 1.3666666666667, 1.4, 0.21428571428571
2095, 1.45, 1.4, 0.21428571428571
2096, 1.5333333333333, 1.4, 0.21428571428571
2097, 1.6166666666667, 1.4, 0.21428571428571
2098, 1.7, 1.4, 0.21428571428571
2099, 1.7833333333333, 1.4, 0.21428571428571
2100, 1.8666666666667, 1.4, 0.21428571428571
2101, 1.95, 1.4, 0.21428571428571
2102, 2.0333333333333, 1.4, 0.21428571428571
2103, 2.1166666666667, 1.4, 0.21428571428571
2104, 1.2833333333333, 1.4, 0.28571428571429
2105, 1.3666666666667, 1.4, 0.28571428571429
2106, 1.45, 1.4, 0.28571428571429
2107, 1.5333333333333, 1.4, 0.28571428571429
2108, 1.6166666666667, 1.4, 0.28571428571429
2109, 1.7, 1.4, 0.28571428571429
2110, 1.7833333333333, 1.4, 0.28571428571429
2111, 1.8666666666667, 1.4, 0.28571428571429
2112, 1.95, 1.4, 0.28571428571429
2113, 2.0333333333333, 1.4, 0.28571428571429
2114, 2.1166666666667, 1.4, 0.28571428571429
2115, 1.2833333333333, 1.4, 0.35714285714286
2116, 1.3666666666667, 1.4, 0.35714285714286
2117, 1.45, 1.4, 0.35714285714286
2118, 1.5333333333333, 1.4, 0.35714285714286
2119, 1.6166666666667, 1.4, 0.35714285714286
2120, 1.7, 1.4, 0.35714285714286
2121, 1.7833333333333, 1.4, 0.35714285714286
2122, 1.8666666666667, 1.4, 0.35714285714286
2123, 1.95, 1.4, 0.35714285714286
2124, 2.0333333333333, 1.4, 0.35714285714286
2125, 2.1166666666667, 1.4, 0.35714285714286
2126, 1.2833333333333, 1.4, 0.42857142857143
2127, 1.3666666666667, 1.4, 0.42857142857143
2128, 1.45, 1.4, 0.42857142857143
2129, 1.5333333333333, 1.4, 0.42857142857143
2130, 1.6166666666667, 1.4, 0.42857142857143
2131, 1.7, 1.4, 0.42857142857143
2132, 1.7833333333333, 1.4, 0.42857142857143
2133, 1.8666666666667, 1.4, 0.42857142857143
2134, 1.95, 1.4, 0.42857142857143
2135, 2.0333333333333, 1.4, 0.42857142857143
2136, 2.1166666666667, 1.4, 0.42857142857143
2137, 2.2, 1.375, 0.071428571428571
2138, 2.2, 1.375, 0.14285714285714
2139, 2.2, 1.375, 0.21428571428571
2140, 2.2, 1.375, 0.28571428571429
2141, 2.2, 1.375, 0.35714285714286
2142, 2.2, 1.375, 0.42857142857143
2143, 1.2833333333333, 1.3, 0.071428571428571
2144, 1.3666666666667, 1.3, 0.071428571428571
2145, 1.45, 1.3, 0.071428571428571
2146, 1.5333333333333, 1.3, 0.071428571428571
2147, 1.6166666666667, 1.3, 0.071428571428571
2148, 1.7, 1.3, 0.071428571428571
2149, 1.7833333333333, 1.3, 0.071428571428571
2150, 1.8666666666667, 1.3, 0.071428571428571
2151, 1.95, 1.3, 0.071428571428571
2152, 2.0333333333333, 1.3, 0.071428571428571
2153, 2.1166666666667, 1.3, 0.071428571428571
2154, 1.2833333333333, 1.3, 0.14285714285714
2155, 1.3666666666667, 1.3, 0.14285714285714
2156, 1.45, 1.3, 0.14285714285714
2157, 1.5333333333333, 1.3, 0.14285714285714
2158, 1.6166666666667, 1.3, 0.14285714285714
2159, 1.7, 1.3, 0.14285714285714
2160, 1.7833333333333, 1.3, 0.14285714285714
2161, 1.8666666666667, 1.3, 0.14285714285714
2162, 1.95, 1.3, 0.14285714285714
2163, 2.0333333333333, 1.3, 0.14285714285714
2164, 2.1166666666667, 1.3, 0.14285714285714
2165, 1.2833333333333, 1.3, 0.21428571428571
2166, 1.3666666666667, 1.3, 0.21428571428571
2167, 1.45, 1.3, 0.21428571428571
2168, 1.5333333333333, 1.3, 0.21428571428571
2169, 1.6166666666667, 1.3, 0.21428571428571
2170, 1.7, 1.3, 0.21428571428571
2171, 1.7833333333333, 1.3, 0.21428571428571
2172, 1.8666666666667, 1.3, 0.21428571428571
2173, 1.95, 1.3, 0.21428571428571
2174, 2.0333333333333, 1.3, 0.21428571428571
2175, 2.1166666666667, 1.3, 0.21428571428571
2176, 1.2833333333333, 1.3, 0.28571428571429
2177, 1.3666666666667, 1.3, 0.28571428571429
2178, 1.45, 1.3, 0.28571428571429
2179, 1.5333333333333, 1.3, 0.28571428571429
2180, 1.6166666666667, 1.3, 0.28571428571429
2181, 1.7, 1.3, 0.28571428571429
2182, 1.7833333333333, 1.3, 0.28571428571429
2183, 1.8666666666667, 1.3, 0.28571428571429
2184, 1.95, 1.3, 0.28571428571429
2185, 2.0333333333333, 1.3, 0.28571428571429
2186, 2.1166666666667, 1.3, 0.28571428571429
2187, 1.2833333333333, 1.3, 0.35714285714286
2188, 1.3666666666667, 1.3, 0.35714285714286
2189, 1.45, 1.3, 0.35714285714286
2190, 1.5333333333333, 1.3, 0.35714285714286
2191, 1.6166666666667, 1.3, 0.35714285714286
2192, 1.7, 1.3, 0.35714285714286
2193, 1.7833333333333, 1.3, 0.35714285714286
2194, 1.8666666666667, 1.3, 0.35714285714286
2195, 1.95, 1.3, 0.35714285714286
2196, 2.0333333333333, 1.3, 0.35714285714286
2197, 2.1166666666667, 1.3, 0.35714285714286
2198, 1.2833333333333, 1.3, 0.42857142857143
2199, 1.3666666666667, 1.3, 0.42857142857143
2200, 1.45, 1.3, 0.42857142857143
2201, 1.5333333333333, 1.3, 0.42857142857143
2202, 1.6166666666667, 1.3, 0.42857142857143
2203, 1.7, 1.3, 0.42857142857143
2204, 1.7833333333333, 1.3, 0.42857142857143
2205, 1.8666666666667, 1.3, 0.42857142857143
2206, 1.95, 1.3, 0.42857142857143
2207, 2.0333333333333, 1.3, 0.42857142857143
2208, 2.1166666666667, 1.3, 0.42857142857143
2209, 1.2833333333333, 1.22, 0.5
2210, 1.2833333333333, 1.14, 0.5
2211, 1.2833333333333, 1.06, 0.5
2212, 1.2833333333333, 0.98, 0.5
2213, 1.2833333333333, 0.9, 0.5
2214, 1.2833333333333, 0.82, 0.5
2215, 1.2833333333333, 0.74, 0.5
2216, 1.2833333333333, 0.66, 0.5
2217, 1.2833333333333, 0.58, 0.5
2218, 1.2833333333333, 0.5, 0.5
2219, 1.2833333333333, 0.42, 0.5
2220, 1.2833333333333, 0.34, 0.5
2221, 1.2833333333333, 0.26, 0.5
2222, 1.2833333333333, 0.18, 0.5
2223, 1.3666666666667, 1.22, 0.5
2224, 1.3666666666667, 1.14, 0.5
2225, 1.3666666666667, 1.06, 0.5
2226, 1.3666666666667, 0.98, 0.5
2227, 1.3666666666667, 0.9, 0.5
2228, 1.3666666666667, 0.82, 0.5
2229, 1.3666666666667, 0.74, 0.5
2230, 1.3666666666667, 0.66, 0.5
2231, 1.3666666666667, 0.58, 0.5
2232, 1.3666666666667, 0.5, 0.5
2233, 1.3666666666667, 0.42, 0.5
2234, 1.3666666666667, 0.34, 0.5
2235, 1.3666666666667, 0.26, 0.5
2236, 1.3666666666667, 0.18, 0.5
2237, 1.45, 1.22, 0.5
2238, 1.45, 1.14, 0.5
2239, 1.45, 1.06, 0.5
2240, 1.45, 0.98, 0.5
2241, 1.45, 0.9, 0.5
2242, 1.45, 0.82, 0.5
2243, 1.45, 0.74, 0.5
2244, 1.45, 0.66, 0.5
2245, 1.45, 0.58, 0.5
2246, 1.45, 0.5, 0.5
2247, 1.45, 0.42, 0.5
2248, 1.45, 0.34, 0.5
2249, 1.45, 0.26, 0.5
2250, 1.45, 0.18, 0.5
2251, 1.5333333333333, 1.22, 0.5
2252, 1.5333333333333, 1.14, 0.5
2253, 1.5333333333333, 1.06, 0.5
2254, 1.5333333333333, 0.98, 0.5
2255, 1.5333333333333, 0.9, 0.5
2256, 1.5333333333333, 0.82, 0.5
2257, 1.5333333333333, 0.74, 0.5
2258, 1.5333333333333, 0.66, 0.5
2259, 1.5333333333333, 0.58, 0.5
2260, 1.5333333333333, 0.5, 0.5
2261, 1.5333333333333, 0.42, 0.5
2262, 1.5333333333333, 0.34, 0.5
2263, 1.5333333333333, 0.26, 0.5
2264, 1.5333333333333, 0.18, 0.5
2265, 1.6166666666667, 1.22, 0.5
2266, 1.6166666666667, 1.14, 0.5
2267, 1.6166666666667, 1.06, 0.5
2268, 1.6166666666667, 0.98, 0.5
2269, 1.6166666666667, 0.9, 0.5
2270, 1.6166666666667, 0.82, 0.5
2271, 1.6166666666667, 0.74, 0.5
2272, 1.6166666666667, 0.66, 0.5
2273, 1.6166666666667, 0.58, 0.5
2274, 1.6166666666667, 0.5, 0.5
2275, 1.6166666666667, 0.42, 0.5
2276, 1.6166666666667, 0.34, 0.5
2277, 1.6166666666667, 0.26, 0.5
2278, 1.6166666666667, 0.18, 0.5
2279, 1.7, 1.22, 0.5
2280, 1.7, 1.14, 0.5
2281, 1.7, 1.06, 0.5
2282, 1.7, 0.98, 0.5
2283, 1.7, 0.9, 0.5
2284, 1.7, 0.82, 0.5
2285, 1.7, 0.74, 0.5
2286, 1.7, 0.66, 0.5
2287, 1.7, 0.58, 0.5
2288, 1.7, 0.5, 0.5
2289, 1.7, 0.42, 0.5
2290, 1.7, 0.34, 0.5
2291, 1.7, 0.26, 0.5
2292, 1.7, 0.18, 0.5
2293, 1.7833333333333, 1.22, 0.5
2294, 1.7833333333333, 1.14, 0.5
2295, 1.7833333333333, 1.06, 0.5
2296, 1.7833333333333, 0.98, 0.5
2297, 1.7833333333333, 0.9, 0.5
2298, 1.7833333333333, 0.82, 0.5
2299, 1.7833333333333, 0.74, 0.5
2300, 1.7833333333333, 0.66, 0.5
2301, 1.7833333333333, 0.58, 0.5
2302, 1.7833333333333, 0.5, 0.5
2303, 1.7833333333333, 0.42, 0.5
2304, 1.7833333333333, 0.34, 0.5
2305, 1.7833333333333, 0.26, 0.5
2306, 1.7833333333333, 0.18, 0.5
2307, 1.8666666666667, 1.22, 0.5
2308, 1.8666666666667, 1.14, 0.5
2309, 1.8666666666667, 1.06, 0.5
2310, 1.8666666666667, 0.98, 0.5
2311, 1.8666666666667, 0.9, 0.5
2312, 1.8666666666667, 0.82, 0.5
2313, 1.8666666666667, 0.74, 0.5
2314, 1.8666666666667, 0.66, 0.5
2315, 1.8666666666667, 0.58, 0.5
2316, 1.8666666666667, 0.5, 0.5
2317, 1.8666666666667, 0.42, 0.5
2318, 1.8666666666667, 0.34, 0.5
2319, 1.8666666666667, 0.26, 0.5
2320, 1.8666666666667, 0.18, 0.5
2321, 1.95, 1.22, 0.5
2322, 1.95, 1.14, 0.5
2323, 1.95, 1.06, 0.5
2324, 1.95, 0.98, 0.5
2325, 1.95, 0.9, 0.5
2326, 1.95, 0.82, 0.5
2327, 1.95, 0.74, 0.5
2328, 1.95, 0.66, 0.5
2329, 1.95, 0.58, 0.5
2330, 1.95, 0.5, 0.5
2331, 1.95, 0.42, 0.5
2332, 1.95, 0.34, 0.5
2333, 1.95, 0.26, 0.5
2334, 1.95, 0.18, 0.5
2335, 2.0333333333333, 1.22, 0.5
2336, 2.0333333333333, 1.14, 0.5
2337, 2.0333333333333, 1.06, 0.5
2338, 2.0333333333333, 0.98, 0.5
2339, 2.0333333333333, 0.9, 0.5
2340, 2.0333333333333, 0.82, 0.5
2341, 2.0333333333333, 0.74, 0.5
2342, 2.0333333333333, 0.66, 0.5
2343, 2.0333333333333, 0.58, 0.5
2344, 2.0333333333333, 0.5, 0.5
2345, 2.0333333333333, 0.42, 0.5
2346, 2.0333333333333, 0.34, 0.5
2347, 2.0333333333333, 0.26, 0.5
2348, 2.0333333333333, 0.18, 0.5
2349, 2.1166666666667, 1.22, 0.5
2350, 2.1166666666667, 1.14, 0.5
2351, 2.1166666666667, 1.06, 0.5
2352, 2.1166666666667, 0.98, 0.5
2353, 2.1166666666667, 0.9, 0.5
2354, 2.1166666666667, 0.82, 0.5
2355, 2.1166666666667, 0.74, 0.5
2356, 2.1166666666667, 0.66, 0.5
2357, 2.1166666666667, 0.58, 0.5
2358, 2.1166666666667, 0.5, 0.5
2359, 2.1166666666667, 0.42, 0.5
2360, 2.1166666666667, 0.34, 0.5
2361, 2.1166666666667, 0.26, 0.5
2362, 2.1166666666667, 0.18, 0.5
2363, 1.2833333333333, 1.22, 0
2364, 1.2833333333333, 1.14, 0
2365, 1.2833333333333, 1.06, 0
2366, 1.2833333333333, 0.98, 0
2367, 1.2833333333333, 0.9, 0
2368, 1.2833333333333, 0.82, 0
2369, 1.2833333333333, 0.74, 0
2370, 1.2833333333333, 0.66, 0
2371, 1.2833333333333, 0.58, 0
2372, 1.2833333333333, 0.5, 0
2373, 1.2833333333333, 0.42, 0
2374, 1.2833333333333, 0.34, 0
2375, 1.2833333333333, 0.26, 0
2376, 1.2833333333333, 0.18, 0
2377, 1.3666666666667, 1.22, 0
2378, 1.3666666666667, 1.14, 0
2379, 1.3666666666667, 1.06, 0
2380, 1.3666666666667, 0.98, 0
2381, 1.3666666666667, 0.9, 0
2382, 1.3666666666667, 0.82, 0
2383, 1.3666666666667, 0.74, 0
2384, 1.3666666666667, 0.66, 0
2385, 1.3666666666667, 0.58, 0
2386, 1.3666666666667, 0.5, 0
2387, 1.3666666666667, 0.42, 0
2388, 1.3666666666667, 0.34, 0
2389, 1.3666666666667, 0.26, 0
2390, 1.3666666666667, 0.18, 0
2391, 1.45, 1.22, 0
2392, 1.45, 1.14, 0
2393, 1.45, 1.06, 0
2394, 1.45, 0.98, 0
2395, 1.45, 0.9, 0
2396, 1.45, 0.82, 0
2397, 1.45, 0.74, 0
2398, 1.45, 0.66, 0
2399, 1.45, 0.58, 0
2400, 1.45, 0.5, 0
2401, 1.45, 0.42, 0
2402, 1.45, 0.34, 0
2403, 1.45, 0.26, 0
2404, 1.45, 0.18, 0
2405, 1.5333333333333, 1.22, 0
2406, 1.5333333333333, 1.14, 0
2407, 1.5333333333333, 1.06, 0
2408, 1.5333333333333, 0.98, 0
2409, 1.5333333333333, 0.9, 0
2410, 1.5333333333333, 0.82, 0
2411, 1.5333333333333, 0.74, 0
2412, 1.5333333333333, 0.66, 0
2413, 1.5333333333333, 0.58, 0
2414, 1.5333333333333, 0.5, 0
2415, 1.5333333333333, 0.42, 0
2416, 1.5333333333333, 0.34, 0
2417, 1.5333333333333, 0.26, 0
2418, 1.5333333333333, 0.18, 0
2419, 1.6166666666667, 1.22, 0
2420, 1.6166666666667, 1.14, 0
2421, 1.6166666666667, 1.06, 0
2422, 1.6166666666667, 0.98, 0
2423, 1.6166666666667, 0.9, 0
2424, 1.6166666666667, 0.82, 0
2425, 1.6166666666667, 0.74, 0
2426, 1.6166666666667, 0.66, 0
2427, 1.6166666666667, 0.58, 0
2428, 1.6166666666667, 0.5, 0
2429, 1.6166666666667, 0.42, 0
2430, 1.6166666666667, 0.34, 0
2431, 1.6166666666667, 0.26, 0
2432, 1.6166666666667, 0.18, 0
2433, 1.7, 1.22, 0
2434, 1.7, 1.14, 0
2435, 1.7, 1.06, 0
2436, 1.7, 0.98, 0
2437, 1.7, 0.9, 0
2438, 1.7, 0.82, 0
2439, 1.7, 0.74, 0
2440, 1.7, 0.66, 0
2441, 1.7, 0.58, 0
2442, 1.7, 0.5, 0
2443, 1.7, 0.42, 0
2444, 1.7, 0.34, 0
2445, 1.7, 0.26, 0
2446, 1.7, 0.18, 0
2447, 1.7833333333333, 1.22, 0
2448, 1.7833333333333, 1.14, 0
2449, 1.7833333333333, 1.06, 0
2450, 1.7833333333333, 0.98, 0
2451, 1.7833333333333, 0.9, 0
2452, 1.7833333333333, 0.82, 0
2453, 1.7833333333333, 0.74, 0
2454, 1.7833333333333, 0.66, 0
2455, 1.7833333333333, 0.58, 0
2456, 1.7833333333333, 0.5, 0
2457, 1.7833333333333, 0.42, 0
2458, 1.7833333333333, 0.34, 0
2459, 1.7833333333333, 0.26, 0
2460, 1.7833333333333, 0.18, 0
2461, 1.8666666666667, 1.22, 0
2462, 1.8666666666667, 1.14, 0
2463, 1.8666666666667, 1.06, 0
2464, 1.8666666666667, 0.98, 0
2465, 1.8666666666667, 0.9, 0
2466, 1.8666666666667, 0.82, 0
2467, 1.8666666666667, 0.74, 0
2468, 1.8666666666667, 0.66, 0
2469, 1.8666666666667, 0.58, 0
2470, 1.8666666666667, 0.5, 0
2471, 1.8666666666667, 0.42, 0
2472, 1.8666666666667, 0.34, 0
2473, 1.8666666666667, 0.26, 0
2474, 1.8666666666667, 0.18, 0
2475, 1.95, 1.22, 0
2476, 1.95, 1.14, 0
2477, 1.95, 1.06, 0
2478, 1.95, 0.98, 0
2479, 1.95, 0.9, 0
2480, 1.95, 0.82, 0
2481, 1.95, 0.74, 0
2482, 1.95, 0.66, 0
2483, 1.95, 0.58, 0
2484, 1.95, 0.5, 0
2485, 1.95, 0.42, 0
2486, 1.95, 0.34, 0
2487, 1.95, 0.26, 0
2488, 1.95, 0.18, 0
2489, 2.0333333333333, 1.22, 0
2490, 2.0333333333333, 1.14, 0
2491, 2.0333333333333, 1.06, 0
2492, 2.0333333333333, 0.98, 0
2493, 2.0333333333333, 0.9, 0
2494, 2.0333333333333, 0.82, 0
2495, 2.0333333333333, 0.74, 0
2496, 2.0333333333333, 0.66, 0
2497, 2.0333333333333, 0.58, 0
2498, 2.0333333333333, 0.5, 0
2499, 2.0333333333333, 0.42, 0
2500, 2.0333333333333, 0.34, 0
2501, 2.0333333333333, 0.26, 0
2502, 2.0333333333333, 0.18, 0
2503, 2.1166666666667, 1.22, 0
2504, 2.1166666666667, 1.14, 0
2505, 2.1166666666667, 1.06, 0
2506, 2.1166666666667, 0.98, 0
2507, 2.1166666666667, 0.9, 0
2508, 2.1166666666667, 0.82, 0
2509, 2.1166666666667, 0.74, 0
2510, 2.1166666666667, 0.66, 0
2511, 2.1166666666667, 0.58, 0
2512, 2.1166666666667, 0.5, 0
2513, 2.1166666666667, 0.42, 0
2514, 2.1166666666667, 0.34, 0
2515, 2.1166666666667, 0.26, 0
2516, 2.1166666666667, 0.18, 0
2517, 1.2, 1.22, 0.071428571428571
2518, 1.2, 1.14, 0.071428571428571
2519, 1.2, 1.06, 0.071428571428571
2520, 1.2, 0.98, 0.071428571428571
2521, 1.2, 0.9, 0.071428571428571
2522, 1.2, 0.82, 0.071428571428571
2523, 1.2, 0.74, 0.071428571428571
2524, 1.2, 0.66, 0.071428571428571
2525, 1.2, 0.58, 0.071428571428571
2526, 1.2, 0.5, 0.071428571428571
2527, 1.2, 0.42, 0.071428571428571
2528, 1.2, 0.34, 0.071428571428571
2529, 1.2, 0.26, 0.071428571428571
2530, 1.2, 0.18, 0.071428571428571
2531, 1.2, 1.22, 0.14285714285714
2532, 1.2, 1.14, 0.14285714285714
2533, 1.2, 1.06, 0.14285714285714
2534, 1.2, 0.98, 0.14285714285714
2535, 1.2, 0.9, 0.14285714285714
2536, 1.2, 0.82, 0.14285714285714
2537, 1.2, 0.74, 0.14285714285714
2538, 1.2, 0.66, 0.14285714285714
2539, 1.2, 0.58, 0.14285714285714
2540, 1.2, 0.5, 0.14285714285714
2541, 1.2, 0.42, 0.14285714285714
2542, 1.2, 0.34, 0.14285714285714
2543, 1.2, 0.26, 0.14285714285714
2544, 1.2, 0.18, 0.14285714285714
2545, 1.2, 1.22, 0.21428571428571
2546, 1.2, 1.14, 0.21428571428571
2547, 1.2, 1.06, 0.21428571428571
2548, 1.2, 0.98, 0.21428571428571
2549, 1.2, 0.9, 0.21428571428571
2550, 1.2, 0.82, 0.21428571428571
2551, 1.2, 0.74, 0.21428571428571
2552, 1.2, 0.66, 0.21428571428571
2553, 1.2, 0.58, 0.21428571428571
2554, 1.2, 0.5, 0.21428571428571
2555, 1.2, 0.42, 0.21428571428571
2556, 1.2, 0.34, 0.21428571428571
2557, 1.2, 0.26, 0.21428571428571
2558, 1.2, 0.18, 0.21428571428571
2559, 1.2, 1.22, 0.28571428571429
2560, 1.2, 1.14, 0.28571428571429
2561, 1.2, 1.06, 0.28571428571429
2562, 1.2, 0.98, 0.28571428571429
2563, 1.2, 0.9, 0.28571428571429
2564, 1.2, 0.82, 0.28571428571429
2565, 1.2, 0.74, 0.28571428571429
2566, 1.2, 0.66, 0.28571428571429
2567, 1.2, 0.58, 0.28571428571429
2568, 1.2, 0.5, 0.28571428571429
2569, 1.2, 0.42, 0.28571428571429
2570, 1.2, 0.34, 0.28571428571429
2571, 1.2, 0.26, 0.28571428571429
2572, 1.2, 0.18, 0.28571428571429
2573, 1.2, 1.22, 0.35714285714286
2574, 1.2, 1.14, 0.35714285714286
2575, 1.2, 1.06, 0.35714285714286
2576, 1.2, 0.98, 0.35714285714286
2577, 1.2, 0.9, 0.35714285714286
2578, 1.2, 0.82, 0.35714285714286
2579, 1.2, 0.74, 0.35714285714286
2580, 1.2, 0.66, 0.35714285714286
2581, 1.2, 0.58, 0.35714285714286
2582, 1.2, 0.5, 0.35714285714286
2583, 1.2, 0.42, 0.35714285714286
2584, 1.2, 0.34, 0.35714285714286
2585, 1.2, 0.26, 0.35714285714286
2586, 1.2, 0.18, 0.35714285714286
2587, 1.2, 1.22, 0.42857142857143
2588, 1.2, 1.14, 0.42857142857143
2589, 1.2, 1.06, 0.42857142857143
2590, 1.2, 0.98, 0.42857142857143
2591, 1.2, 0.9, 0.42857142857143
2592, 1.2, 0.82, 0.42857142857143
2593, 1.2, 0.74, 0.42857142857143
2594, 1.2, 0.66, 0.42857142857143
2595, 1.2, 0.58, 0.42857142857143
2596, 1.2, 0.5, 0.42857142857143
2597, 1.2, 0.42, 0.42857142857143
2598, 1.2, 0.34, 0.42857142857143
2599, 1.2, 0.26, 0.42857142857143
2600, 1.2, 0.18, 0.42857142857143
2601, 2.2, 1.22, 0.071428571428571
2602, 2.2, 1.14, 0.071428571428571
2603, 2.2, 1.06, 0.071428571428571
2604, 2.2, 0.98, 0.071428571428571
2605, 2.2, 0.9, 0.071428571428571
2606, 2.2, 0.82, 0.071428571428571
2607, 2.2, 0.74, 0.071428571428571
2608, 2.2, 0.66, 0.071428571428571
2609, 2.2, 0.58, 0.071428571428571
2610, 2.2, 0.5, 0.071428571428571
2611, 2.2, 0.42, 0.071428571428571
2612, 2.2, 0.34, 0.071428571428571
2613, 2.2, 0.26, 0.071428571428571
2614, 2.2, 0.18, 0.071428571428571
2615, 2.2, 1.22, 0.14285714285714
2616, 2.2, 1.14, 0.14285714285714
2617, 2.2, 1.06, 0.14285714285714
2618, 2.2, 0.98, 0.14285714285714
2619, 2.2, 0.9, 0.14285714285714
2620, 2.2, 0.82, 0.14285714285714
2621, 2.2, 0.74, 0.14285714285714
2622, 2.2, 0.66, 0.14285714285714
2623, 2.2, 0.58, 0.14285714285714
2624, 2.2, 0.5, 0.14285714285714
2625, 2.2, 0.42, 0.14285714285714
2626, 2.2, 0.34, 0.14285714285714
2627, 2.2, 0.26, 0.14285714285714
2628, 2.2, 0.18, 0.14285714285714
2629, 2.2, 1.22, 0.21428571428571
2630, 2.2, 1.14, 0.21428571428571
2631, 2.2, 1.06, 0.21428571428571
2632, 2.2, 0.98, 0.21428571428571
2633, 2.2, 0.9, 0.21428571428571
2634, 2.2, 0.82, 0.21428571428571
2635, 2.2, 0.74, 0.21428571428571
2636, 2.2, 0.66, 0.21428571428571
2637, 2.2, 0.58, 0.21428571428571
2638, 2.2, 0.5, 0.21428571428571
2639, 2.2, 0.42, 0.21428571428571
2640, 2.2, 0.34, 0.21428571428571
2641, 2.2, 0.26, 0.21428571428571
2642, 2.2, 0.18, 0.21428571428571
2643, 2.2, 1.22, 0.28571428571429
2644, 2.2, 1.14, 0.28571428571429
2645, 2.2, 1.06, 0.28571428571429
2646, 2.2, 0.98, 0.28571428571429
2647, 2.2, 0.9, 0.28571428571429
2648, 2.2, 0.82, 0.28571428571429
2649, 2.2, 0.74, 0.28571428571429
2650, 2.2, 0.66, 0.28571428571429
2651, 2.2, 0.58, 0.28571428571429
2652, 2.2, 0.5, 0.28571428571429
2653, 2.2, 0.42, 0.28571428571429
2654, 2.2, 0.34, 0.28571428571429
2655, 2.2, 0.26, 0.28571428571429
2656, 2.2, 0.18, 0.28571428571429
2657, 2.2, 1.22, 0.35714285714286
2658, 2.2, 1.14, 0.35714285714286
2659, 2.2, 1.06, 0.35714285714286
2660, 2.2, 0.98, 0.35714285714286
2661, 2.2, 0.9, 0.35714285714286
2662, 2.2, 0.82, 0.35714285714286
2663, 2.2, 0.74, 0.35714285714286
2664, 2.2, 0.66, 0.35714285714286
2665, 2.2, 0.58, 0.35714285714286
2666, 2.2, 0.5, 0.35714285714286
2667, 2.2, 0.42, 0.35714285714286
2668, 2.2, 0.34, 0.35714285714286
2669, 2.2, 0.26, 0.35714285714286
2670, 2.2, 0.18, 0.35714285714286
2671, 2.2, 1.22, 0.42857142857143
2672, 2.2, 1.14, 0.42857142857143
2673, 2.2, 1.06, 0.42857142857143
2674, 2.2, 0.98, 0.42857142857143
2675, 2.2, 0.9, 0.42857142857143
2676, 2.2, 0.82, 0.42857142857143
2677, 2.2, 0.74, 0.42857142857143
2678, 2.2, 0.66, 0.42857142857143
2679, 2.2, 0.58, 0.42857142857143
2680, 2.2, 0.5, 0.42857142857143
2681, 2.2, 0.42, 0.42857142857143
2682, 2.2, 0.34, 0.42857142857143
2683, 2.2, 0.26, 0.42857142857143
2684, 2.2, 0.18, 0.42857142857143
2685, 1.2833333333333, 0.1, 0.071428571428571
2686, 1.3666666666667, 0.1, 0.071428571428571
2687, 1.45, 0.1, 0.071428571428571
2688, 1.5333333333333, 0.1, 0.071428571428571
2689, 1.6166666666667, 0.1, 0.071428571428571
2690, 1.7, 0.1, 0.071428571428571
2691, 1.7833333333333, 0.1, 0.071428571428571
2692, 1.8666666666667, 0.1, 0.071428571428571
2693, 1.95, 0.1, 0.071428571428571
2694, 2.0333333333333, 0.1, 0.071428571428571
2695, 2.1166666666667, 0.1, 0.071428571428571
2696, 1.2833333333333, 0.1, 0.14285714285714
2697, 1.3666666666667, 0.1, 0.14285714285714
2698, 1.45, 0.1, 0.14285714285714
2699, 1.5333333333333, 0.1, 0.14285714285714
2700, 1.6166666666667, 0.1, 0.14285714285714
2701, 1.7, 0.1, 0.14285714285714
2702, 1.7833333333333, 0.1, 0.14285714285714
2703, 1.8666666666667, 0.1, 0.14285714285714
2704, 1.95, 0.1, 0.14285714285714
2705, 2.0333333333333, 0.1, 0.14285714285714
2706, 2.1166666666667, 0.1, 0.14285714285714
2707, 1.2833333333333, 0.1, 0.21428571428571
2708, 1.3666666666667, 0.1, 0.21428571428571
2709, 1.45, 0.1, 0.21428571428571
2710, 1.5333333333333, 0.1, 0.21428571428571
2711, 1.6166666666667, 0.1, 0.21428571428571
2712, 1.7, 0.1, 0.21428571428571
2713, 1.7833333333333, 0.1, 0.21428571428571
2714, 1.8666666666667, 0.1, 0.21428571428571
2715, 1.95, 0.1, 0.21428571428571
2716, 2.0333333333333, 0.1, 0.21428571428571
2717, 2.1166666666667, 0.1, 0.21428571428571
2718, 1.2833333333333, 0.1, 0.28571428571429
2719, 1.3666666666667, 0.1, 0.28571428571429
2720, 1.45, 0.1, 0.28571428571429
2721, 1.5333333333333, 0.1, 0.28571428571429
2722, 1.6166666666667, 0.1, 0.28571428571429
2723, 1.7, 0.1, 0.28571428571429
2724, 1.7833333333333, 0.1, 0.28571428571429
2725, 1.8666666666667, 0.1, 0.28571428571429
2726, 1.95, 0.1, 0.28571428571429
2727, 2.0333333333333, 0.1, 0.28571428571429
2728, 2.1166666666667, 0.1, 0.28571428571429
2729, 1.2833333333333, 0.1, 0.35714285714286
2730, 1.3666666666667, 0.1, 0.35714285714286
2731, 1.45, 0.1, 0.35714285714286
2732, 1.5333333333333, 0.1, 0.35714285714286
2733, 1.6166666666667, 0.1, 0.35714285714286
2734, 1.7, 0.1, 0.35714285714286
2735, 1.7833333333333, 0.1, 0.35714285714286
2736, 1.8666666666667, 0.1, 0.35714285714286
2737, 1.95, 0.1, 0.35714285714286
2738, 2.0333333333333, 0.1, 0.35714285714286
2739, 2.1166666666667, 0.1, 0.35714285714286
2740, 1.2833333333333, 0.1, 0.42857142857143
2741, 1.3666666666667, 0.1, 0.42857142857143
2742, 1.45, 0.1, 0.42857142857143
2743, 1.5333333333333, 0.1, 0.42857142857143
2744, 1.6166666666667, 0.1, 0.42857142857143
2745, 1.7, 0.1, 0.42857142857143
2746, 1.7833333333333, 0.1, 0.42857142857143
2747, 1.8666666666667, 0.1, 0.42857142857143
2748, 1.95, 0.1, 0.42857142857143
2749, 2.0333333333333, 0.1, 0.42857142857143
2750, 2.1166666666667, 0.1, 0.42857142857143
2751, 1.2833333333333, 0.05, 0.071428571428571
2752, 1.3666666666667, 0.05, 0.071428571428571
2753, 1.45, 0.05, 0.071428571428571
2754, 1.5333333333333, 0.05, 0.071428571428571
2755, 1.6166666666667, 0.05, 0.071428571428571
2756, 1.7, 0.05, 0.071428571428571
2757, 1.7833333333333, 0.05, 0.071428571428571
2758, 1.8666666666667, 0.05, 0.071428571428571
2759, 1.95, 0.05, 0.071428571428571
2760, 2.0333333333333, 0.05, 0.071428571428571
2761, 2.1166666666667, 0.05, 0.071428571428571
2762, 1.2833333333333, 0.05, 0.14285714285714
2763, 1.3666666666667, 0.05, 0.14285714285714
2764, 1.45, 0.05, 0.14285714285714
2765, 1.5333333333333, 0.05, 0.14285714285714
2766, 1.6166666666667, 0.05, 0.14285714285714
2767, 1.7, 0.05, 0.14285714285714
2768, 1.7833333333333, 0.05, 0.14285714285714
2769, 1.8666666666667, 0.05, 0.14285714285714
2770, 1.95, 0.05, 0.14285714285714
2771, 2.0333333333333, 0.05, 0.14285714285714
2772, 2.1166666666667, 0.05, 0.14285714285714
2773, 1.2833333333333, 0.05, 0.21428571428571
2774, 1.3666666666667, 0.05, 0.21428571428571
2775, 1.45, 0.05, 0.21428571428571
2776, 1.5333333333333, 0.05, 0.21428571428571
2777, 1.6166666666667, 0.05, 0.21428571428571
2778, 1.7, 0.05, 0.21428571428571
2779, 1.7833333333333, 0.05, 0.21428571428571
2780, 1.8666666666667, 0.05, 0.21428571428571
2781, 1.95, 0.05, 0.21428571428571
2782, 2.0333333333333, 0.05, 0.21428571428571
2783, 2.1166666666667, 0.05, 0.21428571428571
2784, 1.2833333333333, 0.05, 0.28571428571429
2785, 1.3666666666667, 0.05, 0.28571428571429
2786, 1.45, 0.05, 0.28571428571429
2787, 1.5333333333333, 0.05, 0.28571428571429
2788, 1.6166666666667, 0.05, 0.28571428571429
2789, 1.7, 0.05, 0.28571428571429
2790, 1.7833333333333, 0.05, 0.28571428571429
2791, 1.8666666666667, 0.05, 0.28571428571429
2792, 1.95, 0.05, 0.28571428571429
2793, 2.0333333333333, 0.05, 0.28571428571429
2794, 2.1166666666667, 0.05, 0.28571428571429
2795, 1.2833333333333, 0.05, 0.35714285714286
2796, 1.3666666666667, 0.05, 0.35714285714286
2797, 1.45, 0.05, 0.35714285714286
2798, 1.5333333333333, 0.05, 0.35714285714286
2799, 1.6166666666667, 0.05, 0.35714285714286
2800, 1.7, 0.05, 0.35714285714286
2801, 1.7833333333333, 0.05, 0.35714285714286
2802, 1.8666666666667, 0.05, 0.35714285714286
2803, 1.95, 0.05, 0.35714285714286
2804, 2.0333333333333, 0.05, 0.35714285714286
2805, 2.1166666666667, 0.05, 0.35714285714286
2806, 1.2833333333333, 0.05, 0.42857142857143
2807, 1.3666666666667, 0.05, 0.42857142857143
2808, 1.45, 0.05, 0.42857142857143
2809, 1.5333333333333, 0.05, 0.42857142857143
2810, 1.6166666666667, 0.05, 0.42857142857143
2811, 1.7, 0.05, 0.42857142857143
2812, 1.7833333333333, 0.05, 0.42857142857143
2813, 1.8666666666667, 0.05, 0.42857142857143
2814, 1.95, 0.05, 0.42857142857143
2815, 2.0333333333333, 0.05, 0.42857142857143
2816, 2.1166666666667, 0.05, 0.42857142857143
2817, 1.2833333333333, 0.025, 0.5
2818, 1.3666666666667, 0.025, 0.5
2819, 1.45, 0.025, 0.5
2820, 1.5333333333333, 0.025, 0.5
2821, 1.6166666666667, 0.025, 0.5
2822, 1.7, 0.025, 0.5
2823, 1.7833333333333, 0.025, 0.5
2824, 1.8666666666667, 0.025, 0.5
2825, 1.95, 0.025, 0.5
2826, 2.0333333333333, 0.025, 0.5
2827, 2.1166666666667, 0.025, 0.5
2828, 1.2833333333333, 0.025, 0
2829, 1.3666666666667, 0.025, 0
2830, 1.45, 0.025, 0
2831, 1.5333333333333, 0.025, 0
2832, 1.6166666666667, 0.025, 0
2833, 1.7, 0.025, 0
2834, 1.7833333333333, 0.025, 0
2835, 1.8666666666667, 0.025, 0
2836, 1.95, 0.025, 0
2837, 2.0333333333333, 0.025, 0
2838, 2.1166666666667, 0.025, 0
2839, 1.2, 0.025, 0.071428571428571
2840, 1.2, 0.025, 0.14285714285714
2841, 1.2, 0.025, 0.21428571428571
2842, 1.2, 0.025, 0.28571428571429
2843, 1.2, 0.025, 0.35714285714286
2844, 1.2, 0.025, 0.42857142857143
2845, 2.2, 0.025, 0.071428571428571
2846, 2.2, 0.025, 0.14285714285714
2847, 2.2, 0.025, 0.21428571428571
2848, 2.2, 0.025, 0.28571428571429
2849, 2.2, 0.025, 0.35714285714286
2850, 2.2, 0.025, 0.42857142857143
2851, 1.2833333333333, 8.3266726846887e-17, 0.071428571428571
2852, 1.3666666666667, 8.3266726846887e-17, 0.071428571428571
2853, 1.45, 8.3266726846887e-17, 0.071428571428571
2854, 1.5333333333333, 8.3266726846887e-17, 0.071428571428571
2855, 1.6166666666667, 8.3266726846887e-17, 0.071428571428571
2856, 1.7, 8.3266726846887e-17, 0.071428571428571
2857, 1.7833333333333, 8.3266726846887e-17, 0.071428571428571
2858, 1.8666666666667, 8.3266726846887e-17, 0.071428571428571
2859, 1.95, 8.3266726846887e-17, 0.071428571428571
2860, 2.0333333333333, 8.3266726846887e-17, 0.071428571428571
2861, 2.1166666666667, 8.3266726846887e-17, 0.071428571428571
2862, 1.2833333333333, 8.3266726846887e-17, 0.14285714285714
2863, 1.3666666666667, 8.3266726846887e-17, 0.14285714285714
2864, 1.45, 8.3266726846887e-17, 0.14285714285714
2865, 1.5333333333333, 8.3266726846887e-17, 0.14285714285714
2866, 1.6166666666667, 8.3266726846887e-17, 0.14285714285714
2867, 1.7, 8.3266726846887e-17, 0.14285714285714
2868, 1.7833333333333, 8.3266726846887e-17, 0.14285714285714
2869, 1.8666666666667, 8.3266726846887e-17, 0.14285714285714
2870, 1.95, 8.3266726846887e-17, 0.14285714285714
2871, 2.0333333333333, 8.3266726846887e-17, 0.14285714285714
2872, 2.1166666666667, 8.3266726846887e-17, 0.14285714285714
2873, 1.2833333333333, 8.3266726846887e-17, 0.21428571428571
2874, 1.3666666666667, 8.3266726846887e-17, 0.21428571428571
2875, 1.45, 8.3266726846887e-17, 0.21428571428571
2876, 1.5333333333333, 8.3266726846887e-17, 0.21428571428571
2877, 1.6166666666667, 8.3266726846887e-17, 0.21428571428571
2878, 1.7, 8.3266726846887e-17, 0.21428571428571
2879, 1.7833333333333, 8.3266726846887e-17, 0.21428571428571
2880, 1.8666666666667, 8.3266726846887e-17, 0.21428571428571
2881, 1.95, 8.3266726846887e-17, 0.21428571428571
2882, 2.0333333333333, 8.3266726846887e-17, 0.21428571428571
2883, 2.1166666666667, 8.3266726846887e-17, 0.21428571428571
2884, 1.2833333333333, 8.3266726846887e-17, 0.28571428571429
2885, 1.3666666666667, 8.3266726846887e-17, 0.28571428571429
2886, 1.45, 8.3266726846887e-17, 0.28571428571429
2887, 1.5333333333333, 8.3266726846887e-17, 0.28571428571429
2888, 1.6166666666667, 8.3266726846887e-17, 0.28571428571429
2889, 1.7, 8.3266726846887e-17, 0.28571428571429
2890, 1.7833333333333, 8.3266726846887e-17, 0.28571428571429
2891, 1.8666666666667, 8.3266726846887e-17, 0.28571428571429
2892, 1.95, 8.3266726846887e-17, 0.28571428571429
2893, 2.0333333333333, 8.3266726846887e-17, 0.28571428571429
2894, 2.1166666666667, 8.3266726846887e-17, 0.28571428571429
2895, 1.2833333333333, 8.3266726846887e-17, 0.35714285714286
2896, 1.3666666666667, 8.3266726846887e-17, 0.35714285714286
2897, 1.45, 8.3266726846887e-17, 0.35714285714286
2898, 1.5333333333333, 8.3266726846887e-17, 0.35714285714286
2899, 1.6166666666667, 8.3266726846887e-17, 0.35714285714286
2900, 1.7, 8.3266726846887e-17, 0.35714285714286
2901, 1.7833333333333, 8.3266726846887e-17, 0.35714285714286
2902, 1.8666666666667, 8.3266726846887e-17, 0.35714285714286
2903, 1.95, 8.3266726846887e-17, 0.35714285714286
2904, 2.0333333333333, 8.3266726846887e-17, 0.35714285714286
2905, 2.1166666666667, 8.3266726846887e-17, 0.35714285714286
2906, 1.2833333333333, 8.3266726846887e-17, 0.42857142857143
2907, 1.3666666666667, 8.3266726846887e-17, 0.42857142857143
2908, 1.45, 8.3266726846887e-17, 0.42857142857143
2909, 1.5333333333333, 8.3266726846887e-17, 0.42857142857143
2910, 1.6166666666667, 8.3266726846887e-17, 0.42857142857143
2911, 1.7, 8.3266726846887e-17, 0.42857142857143
2912, 1.7833333333333, 8.3266726846887e-17, 0.42857142857143
2913, 1.8666666666667, 8.3266726846887e-17, 0.42857142857143
2914, 1.95, 8.3266726846887e-17, 0.42857142857143
2915, 2.0333333333333, 8.3266726846887e-17, 0.42857142857143
2916, 2.1166666666667, 8.3266726846887e-17, 0.42857142857143
2917, 2.3, 0.025, 0.071428571428571
2918, 2.3, 0.025, 0.14285714285714
2919, 2.3, 0.025, 0.21428571428571
2920, 2.3, 0.025, 0.28571428571429
2921, 2.3, 0.025, 0.35714285714286
2922, 2.3, 0.025, 0.42857142857143
2923, -0.1, 0.025, 0.071428571428571
2924, -0.1, 0.025, 0.14285714285714
2925, -0.1, 0.025, 0.21428571428571
2926, -0.1, 0.025, 0.28571428571429
2927, -0.1, 0.025, 0.35714285714286
2928, -0.1, 0.025, 0.42857142857143
2929, 1.05, 0.18, 0.071428571428571
2930, 1.05, 0.26, 0.071428571428571
2931, 1.05, 0.34, 0.071428571428571
2932, 1.05, 0.42, 0.071428571428571
2933, 1.05, 0.5, 0.071428571428571
2934, 1.05, 0.58, 0.071428571428571
2935, 1.05, 0.66, 0.071428571428571
2936, 1.05, 0.74, 0.071428571428571
2937, 1.05, 0.82, 0.071428571428571
2938, 1.05, 0.9, 0.071428571428571
2939, 1.05, 0.98, 0.071428571428571
2940, 1.05, 1.06, 0.071428571428571
2941, 1.05, 1.14, 0.071428571428571
2942, 1.05, 1.22, 0.071428571428571
2943, 1.05, 0.18, 0.14285714285714
2944, 1.05, 0.26, 0.14285714285714
2945, 1.05, 0.34, 0.14285714285714
2946, 1.05, 0.42, 0.14285714285714
2947, 1.05, 0.5, 0.14285714285714
2948, 1.05, 0.58, 0.14285714285714
2949, 1.05, 0.66, 0.14285714285714
2950, 1.05, 0.74, 0.14285714285714
2951, 1.05, 0.82, 0.14285714285714
2952, 1.05, 0.9, 0.14285714285714
2953, 1.05, 0.98, 0.14285714285714
2954, 1.05, 1.06, 0.14285714285714
2955, 1.05, 1.14, 0.14285714285714
2956, 1.05, 1.22, 0.14285714285714
2957, 1.05, 0.18, 0.21428571428571
2958, 1.05, 0.26, 0.21428571428571
2959, 1.05, 0.34, 0.21428571428571
2960, 1.05, 0.42, 0.21428571428571
2961, 1.05, 0.5, 0.21428571428571
2962, 1.05, 0.58, 0.21428571428571
2963, 1.05, 0.66, 0.21428571428571
2964, 1.05, 0.74, 0.21428571428571
2965, 1.05, 0.82, 0.21428571428571
2966, 1.05, 0.9, 0.21428571428571
2967, 1.05, 0.98, 0.21428571428571
2968, 1.05, 1.06, 0.21428571428571
2969, 1.05, 1.14, 0.21428571428571
2970, 1.05, 1.22, 0.21428571428571
2971, 1.05, 0.18, 0.28571428571429
2972, 1.05, 0.26, 0.28571428571429
2973, 1.05, 0.34, 0.28571428571429
2974, 1.05, 0.42, 0.28571428571429
2975, 1.05, 0.5, 0.28571428571429
2976, 1.05, 0.58, 0.28571428571429
2977, 1.05, 0.66, 0.28571428571429
2978, 1.05, 0.74, 0.28571428571429
2979, 1.05, 0.82, 0.28571428571429
2980, 1.05, 0.9, 0.28571428571429
2981, 1.05, 0.98, 0.28571428571429
2982, 1.05, 1.06, 0.28571428571429
2983, 1.05, 1.14, 0.28571428571429
2984, 1.05, 1.22, 0.28571428571429
2985, 1.05, 0.18, 0.35714285714286
2986, 1.05, 0.26, 0.35714285714286
2987, 1.05, 0.34, 0.35714285714286
2988, 1.05, 0.42, 0.35714285714286
2989, 1.05, 0.5, 0.35714285714286
2990, 1.05, 0.58, 0.35714285714286
2991, 1.05, 0.66, 0.35714285714286
2992, 1.05, 0.74, 0.35714285714286
2993, 1.05, 0.82, 0.35714285714286
2994, 1.05, 0.9, 0.35714285714286
2995, 1.05, 0.98, 0.35714285714286
2996, 1.05, 1.06, 0.35714285714286
2997, 1.05, 1.14, 0.35714285714286
2998, 1.05, 1.22, 0.35714285714286
2999, 1.05, 0.18, 0.42857142857143
3000, 1.05, 0.26, 0.42857142857143
3001, 1.05, 0.34, 0.42857142857143
3002, 1.05, 0.42, 0.42857142857143
3003, 1.05, 0.5, 0.42857142857143
3004, 1.05, 0.58, 0.42857142857143
3005, 1.05, 0.66, 0.42857142857143
3006, 1.05, 0.74, 0.42857142857143
3007, 1.05, 0.82, 0.42857142857143
3008, 1.05, 0.9, 0.42857142857143
3009, 1.05, 0.98, 0.42857142857143
3010, 1.05, 1.06, 0.42857142857143
3011, 1.05, 1.14, 0.42857142857143
3012, 1.05, 1.22, 0.42857142857143
3013, 1.15, 1.22, 0.071428571428571
3014, 1.15, 1.14, 0.071428571428571
3015, 1.15, 1.06, 0.071428571428571
3016, 1.15, 0.98, 0.071428571428571
3017, 1.15, 0.9, 0.071428571428571
3018, 1.15, 0.82, 0.071428571428571
3019, 1.15, 0.74, 0.071428571428571
3020, 1.15, 0.66, 0.071428571428571
3021, 1.15, 0.58, 0.071428571428571
3022, 1.15, 0.5, 0.071428571428571
3023, 1.15, 0.42, 0.071428571428571
3024, 1.15, 0.34, 0.071428571428571
3025, 1.15, 0.26, 0.071428571428571
3026, 1.15, 0.18, 0.071428571428571
3027, 1.15, 1.22, 0.14285714285714
3028, 1.15, 1.14, 0.14285714285714
3029, 1.15, 1.06, 0.14285714285714
3030, 1.15, 0.98, 0.14285714285714
3031, 1.15, 0.9, 0.14285714285714
3032, 1.15, 0.82, 0.14285714285714
3033, 1.15, 0.74, 0.14285714285714
3034, 1.15, 0.66, 0.14285714285714
3035, 1.15, 0.58, 0.14285714285714
3036, 1.15, 0.5, 0.14285714285714
3037, 1.15, 0.42, 0.14285714285714
3038, 1.15, 0.34, 0.14285714285714
3039, 1.15, 0.26, 0.14285714285714
3040, 1.15, 0.18, 0.14285714285714
3041, 1.15, 1.22, 0.21428571428571
3042, 1.15, 1.14, 0.21428571428571
3043, 1.15, 1.06, 0.21428571428571
3044, 1.15, 0.98, 0.21428571428571
3045, 1.15, 0.9, 0.21428571428571
3046, 1.15, 0.82, 0.21428571428571
3047, 1.15, 0.74, 0.21428571428571
3048, 1.15, 0.66, 0.21428571428571
3049, 1.15, 0.58, 0.21428571428571
