7854, 5093, 5107, 5261, 5247, 5094, 5108, 5262, 5248
7855, 5094, 5108, 5262, 5248, 5095, 5109, 5263, 5249
7856, 5095, 5109, 5263, 5249, 5096, 5110, 5264, 5250
7857, 5096, 5110, 5264, 5250, 5097, 5111, 5265, 5251
7858, 5097, 5111, 5265, 5251, 5098, 5112, 5266, 5252
7859, 5098, 5112, 5266, 5252, 5099, 5113, 5267, 5253
7860, 5099, 5113, 5267, 5253, 5100, 5114, 5268, 5254
7861, 5100, 5114, 5268, 5254, 5101, 5115, 5269, 5255
7862, 5101, 5115, 5269, 5255, 5102, 5116, 5270, 5256
7863, 5102, 5116, 5270, 5256, 5103, 5117, 5271, 5257
7864, 5103, 5117, 5271, 5257, 5104, 5118, 5272, 5258
7865, 5104, 5118, 5272, 5258, 5105, 5119, 5273, 5259
7866, 5105, 5119, 5273, 5259, 5106, 5120, 5274, 5260
7867, 5106, 5120, 5274, 5260, 2696, 2697, 2708, 2707
7868, 2155, 2156, 2167, 2166, 5107, 5121, 5275, 5261
7869, 5107, 5121, 5275, 5261, 5108, 5122, 5276, 5262
7870, 5108, 5122, 5276, 5262, 5109, 5123, 5277, 5263
7871, 5109, 5123, 5277, 5263, 5110, 5124, 5278, 5264
7872, 5110, 5124, 5278, 5264, 5111, 5125, 5279, 5265
7873, 5111, 5125, 5279, 5265, 5112, 5126, 5280, 5266
7874, 5112, 5126, 5280, 5266, 5113, 5127, 5281, 5267
7875, 5113, 5127, 5281, 5267, 5114, 5128, 5282, 5268
7876, 5114, 5128, 5282, 5268, 5115, 5129, 5283, 5269
7877, 5115, 5129, 5283, 5269, 5116, 5130, 5284, 5270
7878, 5116, 5130, 5284, 5270, 5117, 5131, 5285, 5271
7879, 5117, 5131, 5285, 5271, 5118, 5132, 5286, 5272
7880, 5118, 5132, 5286, 5272, 5119, 5133, 5287, 5273
7881, 5119, 5133, 5287, 5273, 5120, 5134, 5288, 5274
7882, 5120, 5134, 5288, 5274, 2697, 2698, 2709, 2708
7883, 2156, 2157, 2168, 2167, 5121, 5135, 5289, 5275
7884, 5121, 5135, 5289, 5275, 5122, 5136, 5290, 5276
7885, 5122, 5136, 5290, 5276, 5123, 5137, 5291, 5277
7886, 5123, 5137, 5291, 5277, 5124, 5138, 5292, 5278
7887, 5124, 5138, 5292, 5278, 5125, 5139, 5293, 5279
7888, 5125, 5139, 5293, 5279, 5126, 5140, 5294, 5280
7889, 5126, 5140, 5294, 5280, 5127, 5141, 5295, 5281
7890, 5127, 5141, 5295, 5281, 5128, 5142, 5296, 5282
7891, 5128, 5142, 5296, 5282, 5129, 5143, 5297, 5283
7892, 5129, 5143, 5297, 5283, 5130, 5144, 5298, 5284
7893, 5130, 5144, 5298, 5284, 5131, 5145, 5299, 5285
7894, 5131, 5145, 5299, 5285, 5132, 5146, 5300, 5286
7895, 5132, 5146, 5300, 5286, 5133, 5147, 5301, 5287
7896, 5133, 5147, 5301, 5287, 5134, 5148, 5302, 5288
7897, 5134, 5148, 5302, 5288, 2698, 2699, 2710, 2709
7898, 2157, 2158, 2169, 2168, 5135, 5149, 5303, 5289
7899, 5135, 5149, 5303, 5289, 5136, 5150, 5304, 5290
7900, 5136, 5150, 5304, 5290, 5137, 5151, 5305, 5291
7901, 5137, 5151, 5305, 5291, 5138, 5152, 5306, 5292
7902, 5138, 5152, 5306, 5292, 5139, 5153, 5307, 5293
7903, 5139, 5153, 5307, 5293, 5140, 5154, 5308, 5294
7904, 5140, 5154, 5308, 5294, 5141, 5155, 5309, 5295
7905, 5141, 5155, 5309, 5295, 5142, 5156, 5310, 5296
7906, 5142, 5156, 5310, 5296, 5143, 5157, 5311, 5297
7907, 5143, 5157, 5311, 5297, 5144, 5158, 5312, 5298
7908, 5144, 5158, 5312, 5298, 5145, 5159, 5313, 5299
7909, 5145, 5159, 5313, 5299, 5146, 5160, 5314, 5300
7910, 5146, 5160, 5314, 5300, 5147, 5161, 5315, 5301
7911, 5147, 5161, 5315, 5301, 5148, 5162, 5316, 5302
7912, 5148, 5162, 5316, 5302, 2699, 2700, 2711, 2710
7913, 2158, 2159, 2170, 2169, 5149, 5163, 5317, 5303
7914, 5149, 5163, 5317, 5303, 5150, 5164, 5318, 5304
7915, 5150, 5164, 5318, 5304, 5151, 5165, 5319, 5305
7916, 5151, 5165, 5319, 5305, 5152, 5166, 5320, 5306
7917, 5152, 5166, 5320, 5306, 5153, 5167, 5321, 5307
7918, 5153, 5167, 5321, 5307, 5154, 5168, 5322, 5308
7919, 5154, 5168, 5322, 5308, 5155, 5169, 5323, 5309
7920, 5155, 5169, 5323, 5309, 5156, 5170, 5324, 5310
7921, 5156, 5170, 5324, 5310, 5157, 5171, 5325, 5311
7922, 5157, 5171, 5325, 5311, 5158, 5172, 5326, 5312
7923, 5158, 5172, 5326, 5312, 5159, 5173, 5327, 5313
7924, 5159, 5173, 5327, 5313, 5160, 5174, 5328, 5314
7925, 5160, 5174, 5328, 5314, 5161, 5175, 5329, 5315
7926, 5161, 5175, 5329, 5315, 5162, 5176, 5330, 5316
7927, 5162, 5176, 5330, 5316, 2700, 2701, 2712, 2711
7928, 2159, 2160, 2171, 2170, 5163, 5177, 5331, 5317
7929, 5163, 5177, 5331, 5317, 5164, 5178, 5332, 5318
7930, 5164, 5178, 5332, 5318, 5165, 5179, 5333, 5319
7931, 5165, 5179, 5333, 5319, 5166, 5180, 5334, 5320
7932, 5166, 5180, 5334, 5320, 5167, 5181, 5335, 5321
7933, 5167, 5181, 5335, 5321, 5168, 5182, 5336, 5322
7934, 5168, 5182, 5336, 5322, 5169, 5183, 5337, 5323
7935, 5169, 5183, 5337, 5323, 5170, 5184, 5338, 5324
7936, 5170, 5184, 5338, 5324, 5171, 5185, 5339, 5325
7937, 5171, 5185, 5339, 5325, 5172, 5186, 5340, 5326
7938, 5172, 5186, 5340, 5326, 5173, 5187, 5341, 5327
7939, 5173, 5187, 5341, 5327, 5174, 5188, 5342, 5328
7940, 5174, 5188, 5342, 5328, 5175, 5189, 5343, 5329
7941, 5175, 5189, 5343, 5329, 5176, 5190, 5344, 5330
7942, 5176, 5190, 5344, 5330, 2701, 2702, 2713, 2712
7943, 2160, 2161, 2172, 2171, 5177, 5191, 5345, 5331
7944, 5177, 5191, 5345, 5331, 5178, 5192, 5346, 5332
7945, 5178, 5192, 5346, 5332, 5179, 5193, 5347, 5333
7946, 5179, 5193, 5347, 5333, 5180, 5194, 5348, 5334
7947, 5180, 5194, 5348, 5334, 5181, 5195, 5349, 5335
7948, 5181, 5195, 5349, 5335, 5182, 5196, 5350, 5336
7949, 5182, 5196, 5350, 5336, 5183, 5197, 5351, 5337
7950, 5183, 5197, 5351, 5337, 5184, 5198, 5352, 5338
7951, 5184, 5198, 5352, 5338, 5185, 5199, 5353, 5339
7952, 5185, 5199, 5353, 5339, 5186, 5200, 5354, 5340
7953, 5186, 5200, 5354, 5340, 5187, 5201, 5355, 5341
7954, 5187, 5201, 5355, 5341, 5188, 5202, 5356, 5342
7955, 5188, 5202, 5356, 5342, 5189, 5203, 5357, 5343
7956, 5189, 5203, 5357, 5343, 5190, 5204, 5358, 5344
7957, 5190, 5204, 5358, 5344, 2702, 2703, 2714, 2713
7958, 2161, 2162, 2173, 2172, 5191, 5205, 5359, 5345
7959, 5191, 5205, 5359, 5345, 5192, 5206, 5360, 5346
7960, 5192, 5206, 5360, 5346, 5193, 5207, 5361, 5347
7961, 5193, 5207, 5361, 5347, 5194, 5208, 5362, 5348
7962, 5194, 5208, 5362, 5348, 5195, 5209, 5363, 5349
7963, 5195, 5209, 5363, 5349, 5196, 5210, 5364, 5350
7964, 5196, 5210, 5364, 5350, 5197, 5211, 5365, 5351
7965, 5197, 5211, 5365, 5351, 5198, 5212, 5366, 5352
7966, 5198, 5212, 5366, 5352, 5199, 5213, 5367, 5353
7967, 5199, 5213, 5367, 5353, 5200, 5214, 5368, 5354
7968, 5200, 5214, 5368, 5354, 5201, 5215, 5369, 5355
7969, 5201, 5215, 5369, 5355, 5202, 5216, 5370, 5356
7970, 5202, 5216, 5370, 5356, 5203, 5217, 5371, 5357
7971, 5203, 5217, 5371, 5357, 5204, 5218, 5372, 5358
7972, 5204, 5218, 5372, 5358, 2703, 2704, 2715, 2714
7973, 2162, 2163, 2174, 2173, 5205, 5219, 5373, 5359
7974, 5205, 5219, 5373, 5359, 5206, 5220, 5374, 5360
7975, 5206, 5220, 5374, 5360, 5207, 5221, 5375, 5361
7976, 5207, 5221, 5375, 5361, 5208, 5222, 5376, 5362
7977, 5208, 5222, 5376, 5362, 5209, 5223, 5377, 5363
7978, 5209, 5223, 5377, 5363, 5210, 5224, 5378, 5364
7979, 5210, 5224, 5378, 5364, 5211, 5225, 5379, 5365
7980, 5211, 5225, 5379, 5365, 5212, 5226, 5380, 5366
7981, 5212, 5226, 5380, 5366, 5213, 5227, 5381, 5367
7982, 5213, 5227, 5381, 5367, 5214, 5228, 5382, 5368
7983, 5214, 5228, 5382, 5368, 5215, 5229, 5383, 5369
7984, 5215, 5229, 5383, 5369, 5216, 5230, 5384, 5370
7985, 5216, 5230, 5384, 5370, 5217, 5231, 5385, 5371
7986, 5217, 5231, 5385, 5371, 5218, 5232, 5386, 5372
7987, 5218, 5232, 5386, 5372, 2704, 2705, 2716, 2715
7988, 2163, 2164, 2175, 2174, 5219, 5233, 5387, 5373
7989, 5219, 5233, 5387, 5373, 5220, 5234, 5388, 5374
7990, 5220, 5234, 5388, 5374, 5221, 5235, 5389, 5375
7991, 5221, 5235, 5389, 5375, 5222, 5236, 5390, 5376
7992, 5222, 5236, 5390, 5376, 5223, 5237, 5391, 5377
7993, 5223, 5237, 5391, 5377, 5224, 5238, 5392, 5378
7994, 5224, 5238, 5392, 5378, 5225, 5239, 5393, 5379
7995, 5225, 5239, 5393, 5379, 5226, 5240, 5394, 5380
7996, 5226, 5240, 5394, 5380, 5227, 5241, 5395, 5381
7997, 5227, 5241, 5395, 5381, 5228, 5242, 5396, 5382
7998, 5228, 5242, 5396, 5382, 5229, 5243, 5397, 5383
7999, 5229, 5243, 5397, 5383, 5230, 5244, 5398, 5384
8000, 5230, 5244, 5398, 5384, 5231, 5245, 5399, 5385
8001, 5231, 5245, 5399, 5385, 5232, 5246, 5400, 5386
8002, 5232, 5246, 5400, 5386, 2705, 2706, 2717, 2716
8003, 2164, 466, 467, 2175, 5233, 2615, 2629, 5387
8004, 5233, 2615, 2629, 5387, 5234, 2616, 2630, 5388
8005, 5234, 2616, 2630, 5388, 5235, 2617, 2631, 5389
8006, 5235, 2617, 2631, 5389, 5236, 2618, 2632, 5390
8007, 5236, 2618, 2632, 5390, 5237, 2619, 2633, 5391
8008, 5237, 2619, 2633, 5391, 5238, 2620, 2634, 5392
8009, 5238, 2620, 2634, 5392, 5239, 2621, 2635, 5393
8010, 5239, 2621, 2635, 5393, 5240, 2622, 2636, 5394
8011, 5240, 2622, 2636, 5394, 5241, 2623, 2637, 5395
8012, 5241, 2623, 2637, 5395, 5242, 2624, 2638, 5396
8013, 5242, 2624, 2638, 5396, 5243, 2625, 2639, 5397
8014, 5243, 2625, 2639, 5397, 5244, 2626, 2640, 5398
8015, 5244, 2626, 2640, 5398, 5245, 2627, 2641, 5399
8016, 5245, 2627, 2641, 5399, 5246, 2628, 2642, 5400
8017, 5246, 2628, 2642, 5400, 2706, 556, 557, 2717
8018, 461, 2165, 2176, 462, 2545, 5247, 5401, 2559
8019, 2545, 5247, 5401, 2559, 2546, 5248, 5402, 2560
8020, 2546, 5248, 5402, 2560, 2547, 5249, 5403, 2561
8021, 2547, 5249, 5403, 2561, 2548, 5250, 5404, 2562
8022, 2548, 5250, 5404, 2562, 2549, 5251, 5405, 2563
8023, 2549, 5251, 5405, 2563, 2550, 5252, 5406, 2564
8024, 2550, 5252, 5406, 2564, 2551, 5253, 5407, 2565
8025, 2551, 5253, 5407, 2565, 2552, 5254, 5408, 2566
8026, 2552, 5254, 5408, 2566, 2553, 5255, 5409, 2567
8027, 2553, 5255, 5409, 2567, 2554, 5256, 5410, 2568
8028, 2554, 5256, 5410, 2568, 2555, 5257, 5411, 2569
8029, 2555, 5257, 5411, 2569, 2556, 5258, 5412, 2570
8030, 2556, 5258, 5412, 2570, 2557, 5259, 5413, 2571
8031, 2557, 5259, 5413, 2571, 2558, 5260, 5414, 2572
8032, 2558, 5260, 5414, 2572, 551, 2707, 2718, 552
8033, 2165, 2166, 2177, 2176, 5247, 5261, 5415, 5401
8034, 5247, 5261, 5415, 5401, 5248, 5262, 5416, 5402
8035, 5248, 5262, 5416, 5402, 5249, 5263, 5417, 5403
8036, 5249, 5263, 5417, 5403, 5250, 5264, 5418, 5404
8037, 5250, 5264, 5418, 5404, 5251, 5265, 5419, 5405
8038, 5251, 5265, 5419, 5405, 5252, 5266, 5420, 5406
8039, 5252, 5266, 5420, 5406, 5253, 5267, 5421, 5407
8040, 5253, 5267, 5421, 5407, 5254, 5268, 5422, 5408
8041, 5254, 5268, 5422, 5408, 5255, 5269, 5423, 5409
8042, 5255, 5269, 5423, 5409, 5256, 5270, 5424, 5410
8043, 5256, 5270, 5424, 5410, 5257, 5271, 5425, 5411
8044, 5257, 5271, 5425, 5411, 5258, 5272, 5426, 5412
8045, 5258, 5272, 5426, 5412, 5259, 5273, 5427, 5413
8046, 5259, 5273, 5427, 5413, 5260, 5274, 5428, 5414
8047, 5260, 5274, 5428, 5414, 2707, 2708, 2719, 2718
8048, 2166, 2167, 2178, 2177, 5261, 5275, 5429, 5415
8049, 5261, 5275, 5429, 5415, 5262, 5276, 5430, 5416
8050, 5262, 5276, 5430, 5416, 5263, 5277, 5431, 5417
8051, 5263, 5277, 5431, 5417, 5264, 5278, 5432, 5418
8052, 5264, 5278, 5432, 5418, 5265, 5279, 5433, 5419
8053, 5265, 5279, 5433, 5419, 5266, 5280, 5434, 5420
8054, 5266, 5280, 5434, 5420, 5267, 5281, 5435, 5421
8055, 5267, 5281, 5435, 5421, 5268, 5282, 5436, 5422
8056, 5268, 5282, 5436, 5422, 5269, 5283, 5437, 5423
8057, 5269, 5283, 5437, 5423, 5270, 5284, 5438, 5424
8058, 5270, 5284, 5438, 5424, 5271, 5285, 5439, 5425
8059, 5271, 5285, 5439, 5425, 5272, 5286, 5440, 5426
8060, 5272, 5286, 5440, 5426, 5273, 5287, 5441, 5427
8061, 5273, 5287, 5441, 5427, 5274, 5288, 5442, 5428
8062, 5274, 5288, 5442, 5428, 2708, 2709, 2720, 2719
8063, 2167, 2168, 2179, 2178, 5275, 5289, 5443, 5429
8064, 5275, 5289, 5443, 5429, 5276, 5290, 5444, 5430
8065, 5276, 5290, 5444, 5430, 5277, 5291, 5445, 5431
8066, 5277, 5291, 5445, 5431, 5278, 5292, 5446, 5432
8067, 5278, 5292, 5446, 5432, 5279, 5293, 5447, 5433
8068, 5279, 5293, 5447, 5433, 5280, 5294, 5448, 5434
8069, 5280, 5294, 5448, 5434, 5281, 5295, 5449, 5435
8070, 5281, 5295, 5449, 5435, 5282, 5296, 5450, 5436
8071, 5282, 5296, 5450, 5436, 5283, 5297, 5451, 5437
8072, 5283, 5297, 5451, 5437, 5284, 5298, 5452, 5438
8073, 5284, 5298, 5452, 5438, 5285, 5299, 5453, 5439
8074, 5285, 5299, 5453, 5439, 5286, 5300, 5454, 5440
8075, 5286, 5300, 5454, 5440, 5287, 5301, 5455, 5441
8076, 5287, 5301, 5455, 5441, 5288, 5302, 5456, 5442
8077, 5288, 5302, 5456, 5442, 2709, 2710, 2721, 2720
8078, 2168, 2169, 2180, 2179, 5289, 5303, 5457, 5443
8079, 5289, 5303, 5457, 5443, 5290, 5304, 5458, 5444
8080, 5290, 5304, 5458, 5444, 5291, 5305, 5459, 5445
8081, 5291, 5305, 5459, 5445, 5292, 5306, 5460, 5446
8082, 5292, 5306, 5460, 5446, 5293, 5307, 5461, 5447
8083, 5293, 5307, 5461, 5447, 5294, 5308, 5462, 5448
8084, 5294, 5308, 5462, 5448, 5295, 5309, 5463, 5449
8085, 5295, 5309, 5463, 5449, 5296, 5310, 5464, 5450
8086, 5296, 5310, 5464, 5450, 5297, 5311, 5465, 5451
8087, 5297, 5311, 5465, 5451, 5298, 5312, 5466, 5452
8088, 5298, 5312, 5466, 5452, 5299, 5313, 5467, 5453
8089, 5299, 5313, 5467, 5453, 5300, 5314, 5468, 5454
8090, 5300, 5314, 5468, 5454, 5301, 5315, 5469, 5455
8091, 5301, 5315, 5469, 5455, 5302, 5316, 5470, 5456
8092, 5302, 5316, 5470, 5456, 2710, 2711, 2722, 2721
8093, 2169, 2170, 2181, 2180, 5303, 5317, 5471, 5457
8094, 5303, 5317, 5471, 5457, 5304, 5318, 5472, 5458
8095, 5304, 5318, 5472, 5458, 5305, 5319, 5473, 5459
8096, 5305, 5319, 5473, 5459, 5306, 5320, 5474, 5460
8097, 5306, 5320, 5474, 5460, 5307, 5321, 5475, 5461
8098, 5307, 5321, 5475, 5461, 5308, 5322, 5476, 5462
8099, 5308, 5322, 5476, 5462, 5309, 5323, 5477, 5463
8100, 5309, 5323, 5477, 5463, 5310, 5324, 5478, 5464
8101, 5310, 5324, 5478, 5464, 5311, 5325, 5479, 5465
8102, 5311, 5325, 5479, 5465, 5312, 5326, 5480, 5466
8103, 5312, 5326, 5480, 5466, 5313, 5327, 5481, 5467
8104, 5313, 5327, 5481, 5467, 5314, 5328, 5482, 5468
8105, 5314, 5328, 5482, 5468, 5315, 5329, 5483, 5469
8106, 5315, 5329, 5483, 5469, 5316, 5330, 5484, 5470
8107, 5316, 5330, 5484, 5470, 2711, 2712, 2723, 2722
8108, 2170, 2171, 2182, 2181, 5317, 5331, 5485, 5471
8109, 5317, 5331, 5485, 5471, 5318, 5332, 5486, 5472
8110, 5318, 5332, 5486, 5472, 5319, 5333, 5487, 5473
8111, 5319, 5333, 5487, 5473, 5320, 5334, 5488, 5474
8112, 5320, 5334, 5488, 5474, 5321, 5335, 5489, 5475
8113, 5321, 5335, 5489, 5475, 5322, 5336, 5490, 5476
8114, 5322, 5336, 5490, 5476, 5323, 5337, 5491, 5477
8115, 5323, 5337, 5491, 5477, 5324, 5338, 5492, 5478
8116, 5324, 5338, 5492, 5478, 5325, 5339, 5493, 5479
8117, 5325, 5339, 5493, 5479, 5326, 5340, 5494, 5480
8118, 5326, 5340, 5494, 5480, 5327, 5341, 5495, 5481
8119, 5327, 5341, 5495, 5481, 5328, 5342, 5496, 5482
8120, 5328, 5342, 5496, 5482, 5329, 5343, 5497, 5483
8121, 5329, 5343, 5497, 5483, 5330, 5344, 5498, 5484
8122, 5330, 5344, 5498, 5484, 2712, 2713, 2724, 2723
8123, 2171, 2172, 2183, 2182, 5331, 5345, 5499, 5485
8124, 5331, 5345, 5499, 5485, 5332, 5346, 5500, 5486
8125, 5332, 5346, 5500, 5486, 5333, 5347, 5501, 5487
8126, 5333, 5347, 5501, 5487, 5334, 5348, 5502, 5488
8127, 5334, 5348, 5502, 5488, 5335, 5349, 5503, 5489
8128, 5335, 5349, 5503, 5489, 5336, 5350, 5504, 5490
8129, 5336, 5350, 5504, 5490, 5337, 5351, 5505, 5491
8130, 5337, 5351, 5505, 5491, 5338, 5352, 5506, 5492
8131, 5338, 5352, 5506, 5492, 5339, 5353, 5507, 5493
8132, 5339, 5353, 5507, 5493, 5340, 5354, 5508, 5494
8133, 5340, 5354, 5508, 5494, 5341, 5355, 5509, 5495
8134, 5341, 5355, 5509, 5495, 5342, 5356, 5510, 5496
8135, 5342, 5356, 5510, 5496, 5343, 5357, 5511, 5497
8136, 5343, 5357, 5511, 5497, 5344, 5358, 5512, 5498
8137, 5344, 5358, 5512, 5498, 2713, 2714, 2725, 2724
8138, 2172, 2173, 2184, 2183, 5345, 5359, 5513, 5499
8139, 5345, 5359, 5513, 5499, 5346, 5360, 5514, 5500
8140, 5346, 5360, 5514, 5500, 5347, 5361, 5515, 5501
8141, 5347, 5361, 5515, 5501, 5348, 5362, 5516, 5502
8142, 5348, 5362, 5516, 5502, 5349, 5363, 5517, 5503
8143, 5349, 5363, 5517, 5503, 5350, 5364, 5518, 5504
8144, 5350, 5364, 5518, 5504, 5351, 5365, 5519, 5505
8145, 5351, 5365, 5519, 5505, 5352, 5366, 5520, 5506
8146, 5352, 5366, 5520, 5506, 5353, 5367, 5521, 5507
8147, 5353, 5367, 5521, 5507, 5354, 5368, 5522, 5508
8148, 5354, 5368, 5522, 5508, 5355, 5369, 5523, 5509
8149, 5355, 5369, 5523, 5509, 5356, 5370, 5524, 5510
8150, 5356, 5370, 5524, 5510, 5357, 5371, 5525, 5511
8151, 5357, 5371, 5525, 5511, 5358, 5372, 5526, 5512
8152, 5358, 5372, 5526, 5512, 2714, 2715, 2726, 2725
8153, 2173, 2174, 2185, 2184, 5359, 5373, 5527, 5513
8154, 5359, 5373, 5527, 5513, 5360, 5374, 5528, 5514
8155, 5360, 5374, 5528, 5514, 5361, 5375, 5529, 5515
8156, 5361, 5375, 5529, 5515, 5362, 5376, 5530, 5516
8157, 5362, 5376, 5530, 5516, 5363, 5377, 5531, 5517
8158, 5363, 5377, 5531, 5517, 5364, 5378, 5532, 5518
8159, 5364, 5378, 5532, 5518, 5365, 5379, 5533, 5519
8160, 5365, 5379, 5533, 5519, 5366, 5380, 5534, 5520
8161, 5366, 5380, 5534, 5520, 5367, 5381, 5535, 5521
8162, 5367, 5381, 5535, 5521, 5368, 5382, 5536, 5522
8163, 5368, 5382, 5536, 5522, 5369, 5383, 5537, 5523
8164, 5369, 5383, 5537, 5523, 5370, 5384, 5538, 5524
8165, 5370, 5384, 5538, 5524, 5371, 5385, 5539, 5525
8166, 5371, 5385, 5539, 5525, 5372, 5386, 5540, 5526
8167, 5372, 5386, 5540, 5526, 2715, 2716, 2727, 2726
8168, 2174, 2175, 2186, 2185, 5373, 5387, 5541, 5527
8169, 5373, 5387, 5541, 5527, 5374, 5388, 5542, 5528
8170, 5374, 5388, 5542, 5528, 5375, 5389, 5543, 5529
8171, 5375, 5389, 5543, 5529, 5376, 5390, 5544, 5530
8172, 5376, 5390, 5544, 5530, 5377, 5391, 5545, 5531
8173, 5377, 5391, 5545, 5531, 5378, 5392, 5546, 5532
8174, 5378, 5392, 5546, 5532, 5379, 5393, 5547, 5533
8175, 5379, 5393, 5547, 5533, 5380, 5394, 5548, 5534
8176, 5380, 5394, 5548, 5534, 5381, 5395, 5549, 5535
8177, 5381, 5395, 5549, 5535, 5382, 5396, 5550, 5536
8178, 5382, 5396, 5550, 5536, 5383, 5397, 5551, 5537
8179, 5383, 5397, 5551, 5537, 5384, 5398, 5552, 5538
8180, 5384, 5398, 5552, 5538, 5385, 5399, 5553, 5539
8181, 5385, 5399, 5553, 5539, 5386, 5400, 5554, 5540
8182, 5386, 5400, 5554, 5540, 2716, 2717, 2728, 2727
8183, 2175, 467, 468, 2186, 5387, 2629, 2643, 5541
8184, 5387, 2629, 2643, 5541, 5388, 2630, 2644, 5542
8185, 5388, 2630, 2644, 5542, 5389, 2631, 2645, 5543
8186, 5389, 2631, 2645, 5543, 5390, 2632, 2646, 5544
8187, 5390, 2632, 2646, 5544, 5391, 2633, 2647, 5545
8188, 5391, 2633, 2647, 5545, 5392, 2634, 2648, 5546
8189, 5392, 2634, 2648, 5546, 5393, 2635, 2649, 5547
8190, 5393, 2635, 2649, 5547, 5394, 2636, 2650, 5548
8191, 5394, 2636, 2650, 5548, 5395, 2637, 2651, 5549
8192, 5395, 2637, 2651, 5549, 5396, 2638, 2652, 5550
8193, 5396, 2638, 2652, 5550, 5397, 2639, 2653, 5551
8194, 5397, 2639, 2653, 5551, 5398, 2640, 2654, 5552
8195, 5398, 2640, 2654, 5552, 5399, 2641, 2655, 5553
8196, 5399, 2641, 2655, 5553, 5400, 2642, 2656, 5554
8197, 5400, 2642, 2656, 5554, 2717, 557, 558, 2728
8198, 462, 2176, 2187, 463, 2559, 5401, 5555, 2573
8199, 2559, 5401, 5555, 2573, 2560, 5402, 5556, 2574
8200, 2560, 5402, 5556, 2574, 2561, 5403, 5557, 2575
8201, 2561, 5403, 5557, 2575, 2562, 5404, 5558, 2576
8202, 2562, 5404, 5558, 2576, 2563, 5405, 5559, 2577
8203, 2563, 5405, 5559, 2577, 2564, 5406, 5560, 2578
8204, 2564, 5406, 5560, 2578, 2565, 5407, 5561, 2579
8205, 2565, 5407, 5561, 2579, 2566, 5408, 5562, 2580
8206, 2566, 5408, 5562, 2580, 2567, 5409, 5563, 2581
8207, 2567, 5409, 5563, 2581, 2568, 5410, 5564, 2582
8208, 2568, 5410, 5564, 2582, 2569, 5411, 5565, 2583
8209, 2569, 5411, 5565, 2583, 2570, 5412, 5566, 2584
8210, 2570, 5412, 5566, 2584, 2571, 5413, 5567, 2585
8211, 2571, 5413, 5567, 2585, 2572, 5414, 5568, 2586
8212, 2572, 5414, 5568, 2586, 552, 2718, 2729, 553
8213, 2176, 2177, 2188, 2187, 5401, 5415, 5569, 5555
8214, 5401, 5415, 5569, 5555, 5402, 5416, 5570, 5556
8215, 5402, 5416, 5570, 5556, 5403, 5417, 5571, 5557
8216, 5403, 5417, 5571, 5557, 5404, 5418, 5572, 5558
8217, 5404, 5418, 5572, 5558, 5405, 5419, 5573, 5559
8218, 5405, 5419, 5573, 5559, 5406, 5420, 5574, 5560
8219, 5406, 5420, 5574, 5560, 5407, 5421, 5575, 5561
8220, 5407, 5421, 5575, 5561, 5408, 5422, 5576, 5562
8221, 5408, 5422, 5576, 5562, 5409, 5423, 5577, 5563
8222, 5409, 5423, 5577, 5563, 5410, 5424, 5578, 5564
8223, 5410, 5424, 5578, 5564, 5411, 5425, 5579, 5565
8224, 5411, 5425, 5579, 5565, 5412, 5426, 5580, 5566
8225, 5412, 5426, 5580, 5566, 5413, 5427, 5581, 5567
8226, 5413, 5427, 5581, 5567, 5414, 5428, 5582, 5568
8227, 5414, 5428, 5582, 5568, 2718, 2719, 2730, 2729
8228, 2177, 2178, 2189, 2188, 5415, 5429, 5583, 5569
8229, 5415, 5429, 5583, 5569, 5416, 5430, 5584, 5570
8230, 5416, 5430, 5584, 5570, 5417, 5431, 5585, 5571
8231, 5417, 5431, 5585, 5571, 5418, 5432, 5586, 5572
8232, 5418, 5432, 5586, 5572, 5419, 5433, 5587, 5573
8233, 5419, 5433, 5587, 5573, 5420, 5434, 5588, 5574
8234, 5420, 5434, 5588, 5574, 5421, 5435, 5589, 5575
8235, 5421, 5435, 5589, 5575, 5422, 5436, 5590, 5576
8236, 5422, 5436, 5590, 5576, 5423, 5437, 5591, 5577
8237, 5423, 5437, 5591, 5577, 5424, 5438, 5592, 5578
8238, 5424, 5438, 5592, 5578, 5425, 5439, 5593, 5579
8239, 5425, 5439, 5593, 5579, 5426, 5440, 5594, 5580
8240, 5426, 5440, 5594, 5580, 5427, 5441, 5595, 5581
8241, 5427, 5441, 5595, 5581, 5428, 5442, 5596, 5582
8242, 5428, 5442, 5596, 5582, 2719, 2720, 2731, 2730
8243, 2178, 2179, 2190, 2189, 5429, 5443, 5597, 5583
8244, 5429, 5443, 5597, 5583, 5430, 5444, 5598, 5584
8245, 5430, 5444, 5598, 5584, 5431, 5445, 5599, 5585
8246, 5431, 5445, 5599, 5585, 5432, 5446, 5600, 5586
8247, 5432, 5446, 5600, 5586, 5433, 5447, 5601, 5587
8248, 5433, 5447, 5601, 5587, 5434, 5448, 5602, 5588
8249, 5434, 5448, 5602, 5588, 5435, 5449, 5603, 5589
8250, 5435, 5449, 5603, 5589, 5436, 5450, 5604, 5590
8251, 5436, 5450, 5604, 5590, 5437, 5451, 5605, 5591
8252, 5437, 5451, 5605, 5591, 5438, 5452, 5606, 5592
8253, 5438, 5452, 5606, 5592, 5439, 5453, 5607, 5593
8254, 5439, 5453, 5607, 5593, 5440, 5454, 5608, 5594
8255, 5440, 5454, 5608, 5594, 5441, 5455, 5609, 5595
8256, 5441, 5455, 5609, 5595, 5442, 5456, 5610, 5596
8257, 5442, 5456, 5610, 5596, 2720, 2721, 2732, 2731
8258, 2179, 2180, 2191, 2190, 5443, 5457, 5611, 5597
8259, 5443, 5457, 5611, 5597, 5444, 5458, 5612, 5598
8260, 5444, 5458, 5612, 5598, 5445, 5459, 5613, 5599
8261, 5445, 5459, 5613, 5599, 5446, 5460, 5614, 5600
8262, 5446, 5460, 5614, 5600, 5447, 5461, 5615, 5601
8263, 5447, 5461, 5615, 5601, 5448, 5462, 5616, 5602
8264, 5448, 5462, 5616, 5602, 5449, 5463, 5617, 5603
8265, 5449, 5463, 5617, 5603, 5450, 5464, 5618, 5604
8266, 5450, 5464, 5618, 5604, 5451, 5465, 5619, 5605
8267, 5451, 5465, 5619, 5605, 5452, 5466, 5620, 5606
8268, 5452, 5466, 5620, 5606, 5453, 5467, 5621, 5607
8269, 5453, 5467, 5621, 5607, 5454, 5468, 5622, 5608
8270, 5454, 5468, 5622, 5608, 5455, 5469, 5623, 5609
8271, 5455, 5469, 5623, 5609, 5456, 5470, 5624, 5610
8272, 5456, 5470, 5624, 5610, 2721, 2722, 2733, 2732
8273, 2180, 2181, 2192, 2191, 5457, 5471, 5625, 5611
8274, 5457, 5471, 5625, 5611, 5458, 5472, 5626, 5612
8275, 5458, 5472, 5626, 5612, 5459, 5473, 5627, 5613
8276, 5459, 5473, 5627, 5613, 5460, 5474, 5628, 5614
8277, 5460, 5474, 5628, 5614, 5461, 5475, 5629, 5615
8278, 5461, 5475, 5629, 5615, 5462, 5476, 5630, 5616
8279, 5462, 5476, 5630, 5616, 5463, 5477, 5631, 5617
8280, 5463, 5477, 5631, 5617, 5464, 5478, 5632, 5618
8281, 5464, 5478, 5632, 5618, 5465, 5479, 5633, 5619
8282, 5465, 5479, 5633, 5619, 5466, 5480, 5634, 5620
8283, 5466, 5480, 5634, 5620, 5467, 5481, 5635, 5621
8284, 5467, 5481, 5635, 5621, 5468, 5482, 5636, 5622
8285, 5468, 5482, 5636, 5622, 5469, 5483, 5637, 5623
8286, 5469, 5483, 5637, 5623, 5470, 5484, 5638, 5624
8287, 5470, 5484, 5638, 5624, 2722, 2723, 2734, 2733
8288, 2181, 2182, 2193, 2192, 5471, 5485, 5639, 5625
8289, 5471, 5485, 5639, 5625, 5472, 5486, 5640, 5626
8290, 5472, 5486, 5640, 5626, 5473, 5487, 5641, 5627
8291, 5473, 5487, 5641, 5627, 5474, 5488, 5642, 5628
8292, 5474, 5488, 5642, 5628, 5475, 5489, 5643, 5629
8293, 5475, 5489, 5643, 5629, 5476, 5490, 5644, 5630
8294, 5476, 5490, 5644, 5630, 5477, 5491, 5645, 5631
8295, 5477, 5491, 5645, 5631, 5478, 5492, 5646, 5632
8296, 5478, 5492, 5646, 5632, 5479, 5493, 5647, 5633
8297, 5479, 5493, 5647, 5633, 5480, 5494, 5648, 5634
8298, 5480, 5494, 5648, 5634, 5481, 5495, 5649, 5635
8299, 5481, 5495, 5649, 5635, 5482, 5496, 5650, 5636
8300, 5482, 5496, 5650, 5636, 5483, 5497, 5651, 5637
8301, 5483, 5497, 5651, 5637, 5484, 5498, 5652, 5638
8302, 5484, 5498, 5652, 5638, 2723, 2724, 2735, 2734
8303, 2182, 2183, 2194, 2193, 5485, 5499, 5653, 5639
8304, 5485, 5499, 5653, 5639, 5486, 5500, 5654, 5640
8305, 5486, 5500, 5654, 5640, 5487, 5501, 5655, 5641
8306, 5487, 5501, 5655, 5641, 5488, 5502, 5656, 5642
8307, 5488, 5502, 5656, 5642, 5489, 5503, 5657, 5643
8308, 5489, 5503, 5657, 5643, 5490, 5504, 5658, 5644
8309, 5490, 5504, 5658, 5644, 5491, 5505, 5659, 5645
8310, 5491, 5505, 5659, 5645, 5492, 5506, 5660, 5646
8311, 5492, 5506, 5660, 5646, 5493, 5507, 5661, 5647
8312, 5493, 5507, 5661, 5647, 5494, 5508, 5662, 5648
8313, 5494, 5508, 5662, 5648, 5495, 5509, 5663, 5649
8314, 5495, 5509, 5663, 5649, 5496, 5510, 5664, 5650
8315, 5496, 5510, 5664, 5650, 5497, 5511, 5665, 5651
8316, 5497, 5511, 5665, 5651, 5498, 5512, 5666, 5652
8317, 5498, 5512, 5666, 5652, 2724, 2725, 2736, 2735
8318, 2183, 2184, 2195, 2194, 5499, 5513, 5667, 5653
8319, 5499, 5513, 5667, 5653, 5500, 5514, 5668, 5654
8320, 5500, 5514, 5668, 5654, 5501, 5515, 5669, 5655
8321, 5501, 5515, 5669, 5655, 5502, 5516, 5670, 5656
8322, 5502, 5516, 5670, 5656, 5503, 5517, 5671, 5657
8323, 5503, 5517, 5671, 5657, 5504, 5518, 5672, 5658
8324, 5504, 5518, 5672, 5658, 5505, 5519, 5673, 5659
8325, 5505, 5519, 5673, 5659, 5506, 5520, 5674, 5660
8326, 5506, 5520, 5674, 5660, 5507, 5521, 5675, 5661
8327, 5507, 5521, 5675, 5661, 5508, 5522, 5676, 5662
8328, 5508, 5522, 5676, 5662, 5509, 5523, 5677, 5663
8329, 5509, 5523, 5677, 5663, 5510, 5524, 5678, 5664
8330, 5510, 5524, 5678, 5664, 5511, 5525, 5679, 5665
8331, 5511, 5525, 5679, 5665, 5512, 5526, 5680, 5666
8332, 5512, 5526, 5680, 5666, 2725, 2726, 2737, 2736
8333, 2184, 2185, 2196, 2195, 5513, 5527, 5681, 5667
8334, 5513, 5527, 5681, 5667, 5514, 5528, 5682, 5668
8335, 5514, 5528, 5682, 5668, 5515, 5529, 5683, 5669
8336, 5515, 5529, 5683, 5669, 5516, 5530, 5684, 5670
8337, 5516, 5530, 5684, 5670, 5517, 5531, 5685, 5671
8338, 5517, 5531, 5685, 5671, 5518, 5532, 5686, 5672
8339, 5518, 5532, 5686, 5672, 5519, 5533, 5687, 5673
8340, 5519, 5533, 5687, 5673, 5520, 5534, 5688, 5674
8341, 5520, 5534, 5688, 5674, 5521, 5535, 5689, 5675
8342, 5521, 5535, 5689, 5675, 5522, 5536, 5690, 5676
8343, 5522, 5536, 5690, 5676, 5523, 5537, 5691, 5677
8344, 5523, 5537, 5691, 5677, 5524, 5538, 5692, 5678
8345, 5524, 5538, 5692, 5678, 5525, 5539, 5693, 5679
8346, 5525, 5539, 5693, 5679, 5526, 5540, 5694, 5680
8347, 5526, 5540, 5694, 5680, 2726, 2727, 2738, 2737
8348, 2185, 2186, 2197, 2196, 5527, 5541, 5695, 5681
8349, 5527, 5541, 5695, 5681, 5528, 5542, 5696, 5682
8350, 5528, 5542, 5696, 5682, 5529, 5543, 5697, 5683
8351, 5529, 5543, 5697, 5683, 5530, 5544, 5698, 5684
8352, 5530, 5544, 5698, 5684, 5531, 5545, 5699, 5685
8353, 5531, 5545, 5699, 5685, 5532, 5546, 5700, 5686
8354, 5532, 5546, 5700, 5686, 5533, 5547, 5701, 5687
8355, 5533, 5547, 5701, 5687, 5534, 5548, 5702, 5688
8356, 5534, 5548, 5702, 5688, 5535, 5549, 5703, 5689
8357, 5535, 5549, 5703, 5689, 5536, 5550, 5704, 5690
8358, 5536, 5550, 5704, 5690, 5537, 5551, 5705, 5691
8359, 5537, 5551, 5705, 5691, 5538, 5552, 5706, 5692
8360, 5538, 5552, 5706, 5692, 5539, 5553, 5707, 5693
8361, 5539, 5553, 5707, 5693, 5540, 5554, 5708, 5694
8362, 5540, 5554, 5708, 5694, 2727, 2728, 2739, 2738
8363, 2186, 468, 469, 2197, 5541, 2643, 2657, 5695
8364, 5541, 2643, 2657, 5695, 5542, 2644, 2658, 5696
8365, 5542, 2644, 2658, 5696, 5543, 2645, 2659, 5697
8366, 5543, 2645, 2659, 5697, 5544, 2646, 2660, 5698
8367, 5544, 2646, 2660, 5698, 5545, 2647, 2661, 5699
8368, 5545, 2647, 2661, 5699, 5546, 2648, 2662, 5700
8369, 5546, 2648, 2662, 5700, 5547, 2649, 2663, 5701
8370, 5547, 2649, 2663, 5701, 5548, 2650, 2664, 5702
8371, 5548, 2650, 2664, 5702, 5549, 2651, 2665, 5703
8372, 5549, 2651, 2665, 5703, 5550, 2652, 2666, 5704
8373, 5550, 2652, 2666, 5704, 5551, 2653, 2667, 5705
8374, 5551, 2653, 2667, 5705, 5552, 2654, 2668, 5706
8375, 5552, 2654, 2668, 5706, 5553, 2655, 2669, 5707
8376, 5553, 2655, 2669, 5707, 5554, 2656, 2670, 5708
8377, 5554, 2656, 2670, 5708, 2728, 558, 559, 2739
8378, 463, 2187, 2198, 464, 2573, 5555, 5709, 2587
8379, 2573, 5555, 5709, 2587, 2574, 5556, 5710, 2588
8380, 2574, 5556, 5710, 2588, 2575, 5557, 5711, 2589
8381, 2575, 5557, 5711, 2589, 2576, 5558, 5712, 2590
8382, 2576, 5558, 5712, 2590, 2577, 5559, 5713, 2591
8383, 2577, 5559, 5713, 2591, 2578, 5560, 5714, 2592
8384, 2578, 5560, 5714, 2592, 2579, 5561, 5715, 2593
8385, 2579, 5561, 5715, 2593, 2580, 5562, 5716, 2594
8386, 2580, 5562, 5716, 2594, 2581, 5563, 5717, 2595
8387, 2581, 5563, 5717, 2595, 2582, 5564, 5718, 2596
8388, 2582, 5564, 5718, 2596, 2583, 5565, 5719, 2597
8389, 2583, 5565, 5719, 2597, 2584, 5566, 5720, 2598
8390, 2584, 5566, 5720, 2598, 2585, 5567, 5721, 2599
8391, 2585, 5567, 5721, 2599, 2586, 5568, 5722, 2600
8392, 2586, 5568, 5722, 2600, 553, 2729, 2740, 554
8393, 2187, 2188, 2199, 2198, 5555, 5569, 5723, 5709
8394, 5555, 5569, 5723, 5709, 5556, 5570, 5724, 5710
8395, 5556, 5570, 5724, 5710, 5557, 5571, 5725, 5711
8396, 5557, 5571, 5725, 5711, 5558, 5572, 5726, 5712
8397, 5558, 5572, 5726, 5712, 5559, 5573, 5727, 5713
8398, 5559, 5573, 5727, 5713, 5560, 5574, 5728, 5714
8399, 5560, 5574, 5728, 5714, 5561, 5575, 5729, 5715
8400, 5561, 5575, 5729, 5715, 5562, 5576, 5730, 5716
8401, 5562, 5576, 5730, 5716, 5563, 5577, 5731, 5717
8402, 5563, 5577, 5731, 5717, 5564, 5578, 5732, 5718
8403, 5564, 5578, 5732, 5718, 5565, 5579, 5733, 5719
8404, 5565, 5579, 5733, 5719, 5566, 5580, 5734, 5720
8405, 5566, 5580, 5734, 5720, 5567, 5581, 5735, 5721
8406, 5567, 5581, 5735, 5721, 5568, 5582, 5736, 5722
8407, 5568, 5582, 5736, 5722, 2729, 2730, 2741, 2740
8408, 2188, 2189, 2200, 2199, 5569, 5583, 5737, 5723
8409, 5569, 5583, 5737, 5723, 5570, 5584, 5738, 5724
8410, 5570, 5584, 5738, 5724, 5571, 5585, 5739, 5725
8411, 5571, 5585, 5739, 5725, 5572, 5586, 5740, 5726
8412, 5572, 5586, 5740, 5726, 5573, 5587, 5741, 5727
8413, 5573, 5587, 5741, 5727, 5574, 5588, 5742, 5728
8414, 5574, 5588, 5742, 5728, 5575, 5589, 5743, 5729
8415, 5575, 5589, 5743, 5729, 5576, 5590, 5744, 5730
8416, 5576, 5590, 5744, 5730, 5577, 5591, 5745, 5731
8417, 5577, 5591, 5745, 5731, 5578, 5592, 5746, 5732
8418, 5578, 5592, 5746, 5732, 5579, 5593, 5747, 5733
8419, 5579, 5593, 5747, 5733, 5580, 5594, 5748, 5734
8420, 5580, 5594, 5748, 5734, 5581, 5595, 5749, 5735
8421, 5581, 5595, 5749, 5735, 5582, 5596, 5750, 5736
8422, 5582, 5596, 5750, 5736, 2730, 2731, 2742, 2741
8423, 2189, 2190, 2201, 2200, 5583, 5597, 5751, 5737
8424, 5583, 5597, 5751, 5737, 5584, 5598, 5752, 5738
8425, 5584, 5598, 5752, 5738, 5585, 5599, 5753, 5739
8426, 5585, 5599, 5753, 5739, 5586, 5600, 5754, 5740
8427, 5586, 5600, 5754, 5740, 5587, 5601, 5755, 5741
8428, 5587, 5601, 5755, 5741, 5588, 5602, 5756, 5742
8429, 5588, 5602, 5756, 5742, 5589, 5603, 5757, 5743
8430, 5589, 5603, 5757, 5743, 5590, 5604, 5758, 5744
8431, 5590, 5604, 5758, 5744, 5591, 5605, 5759, 5745
8432, 5591, 5605, 5759, 5745, 5592, 5606, 5760, 5746
8433, 5592, 5606, 5760, 5746, 5593, 5607, 5761, 5747
8434, 5593, 5607, 5761, 5747, 5594, 5608, 5762, 5748
8435, 5594, 5608, 5762, 5748, 5595, 5609, 5763, 5749
8436, 5595, 5609, 5763, 5749, 5596, 5610, 5764, 5750
8437, 5596, 5610, 5764, 5750, 2731, 2732, 2743, 2742
8438, 2190, 2191, 2202, 2201, 5597, 5611, 5765, 5751
8439, 5597, 5611, 5765, 5751, 5598, 5612, 5766, 5752
8440, 5598, 5612, 5766, 5752, 5599, 5613, 5767, 5753
8441, 5599, 5613, 5767, 5753, 5600, 5614, 5768, 5754
8442, 5600, 5614, 5768, 5754, 5601, 5615, 5769, 5755
8443, 5601, 5615, 5769, 5755, 5602, 5616, 5770, 5756
8444, 5602, 5616, 5770, 5756, 5603, 5617, 5771, 5757
8445, 5603, 5617, 5771, 5757, 5604, 5618, 5772, 5758
8446, 5604, 5618, 5772, 5758, 5605, 5619, 5773, 5759
8447, 5605, 5619, 5773, 5759, 5606, 5620, 5774, 5760
8448, 5606, 5620, 5774, 5760, 5607, 5621, 5775, 5761
8449, 5607, 5621, 5775, 5761, 5608, 5622, 5776, 5762
8450, 5608, 5622, 5776, 5762, 5609, 5623, 5777, 5763
8451, 5609, 5623, 5777, 5763, 5610, 5624, 5778, 5764
8452, 5610, 5624, 5778, 5764, 2732, 2733, 2744, 2743
8453, 2191, 2192, 2203, 2202, 5611, 5625, 5779, 5765
8454, 5611, 5625, 5779, 5765, 5612, 5626, 5780, 5766
8455, 5612, 5626, 5780, 5766, 5613, 5627, 5781, 5767
8456, 5613, 5627, 5781, 5767, 5614, 5628, 5782, 5768
8457, 5614, 5628, 5782, 5768, 5615, 5629, 5783, 5769
8458, 5615, 5629, 5783, 5769, 5616, 5630, 5784, 5770
8459, 5616, 5630, 5784, 5770, 5617, 5631, 5785, 5771
8460, 5617, 5631, 5785, 5771, 5618, 5632, 5786, 5772
8461, 5618, 5632, 5786, 5772, 5619, 5633, 5787, 5773
8462, 5619, 5633, 5787, 5773, 5620, 5634, 5788, 5774
8463, 5620, 5634, 5788, 5774, 5621, 5635, 5789, 5775
8464, 5621, 5635, 5789, 5775, 5622, 5636, 5790, 5776
8465, 5622, 5636, 5790, 5776, 5623, 5637, 5791, 5777
8466, 5623, 5637, 5791, 5777, 5624, 5638, 5792, 5778
8467, 5624, 5638, 5792, 5778, 2733, 2734, 2745, 2744
8468, 2192, 2193, 2204, 2203, 5625, 5639, 5793, 5779
8469, 5625, 5639, 5793, 5779, 5626, 5640, 5794, 5780
8470, 5626, 5640, 5794, 5780, 5627, 5641, 5795, 5781
8471, 5627, 5641, 5795, 5781, 5628, 5642, 5796, 5782
8472, 5628, 5642, 5796, 5782, 5629, 5643, 5797, 5783
8473, 5629, 5643, 5797, 5783, 5630, 5644, 5798, 5784
8474, 5630, 5644, 5798, 5784, 5631, 5645, 5799, 5785
8475, 5631, 5645, 5799, 5785, 5632, 5646, 5800, 5786
8476, 5632, 5646, 5800, 5786, 5633, 5647, 5801, 5787
8477, 5633, 5647, 5801, 5787, 5634, 5648, 5802, 5788
8478, 5634, 5648, 5802, 5788, 5635, 5649, 5803, 5789
8479, 5635, 5649, 5803, 5789, 5636, 5650, 5804, 5790
8480, 5636, 5650, 5804, 5790, 5637, 5651, 5805, 5791
8481, 5637, 5651, 5805, 5791, 5638, 5652, 5806, 5792
8482, 5638, 5652, 5806, 5792, 2734, 2735, 2746, 2745
8483, 2193, 2194, 2205, 2204, 5639, 5653, 5807, 5793
8484, 5639, 5653, 5807, 5793, 5640, 5654, 5808, 5794
8485, 5640, 5654, 5808, 5794, 5641, 5655, 5809, 5795
8486, 5641, 5655, 5809, 5795, 5642, 5656, 5810, 5796
8487, 5642, 5656, 5810, 5796, 5643, 5657, 5811, 5797
8488, 5643, 5657, 5811, 5797, 5644, 5658, 5812, 5798
8489, 5644, 5658, 5812, 5798, 5645, 5659, 5813, 5799
8490, 5645, 5659, 5813, 5799, 5646, 5660, 5814, 5800
8491, 5646, 5660, 5814, 5800, 5647, 5661, 5815, 5801
8492, 5647, 5661, 5815, 5801, 5648, 5662, 5816, 5802
8493, 5648, 5662, 5816, 5802, 5649, 5663, 5817, 5803
8494, 5649, 5663, 5817, 5803, 5650, 5664, 5818, 5804
8495, 5650, 5664, 5818, 5804, 5651, 5665, 5819, 5805
8496, 5651, 5665, 5819, 5805, 5652, 5666, 5820, 5806
8497, 5652, 5666, 5820, 5806, 2735, 2736, 2747, 2746
8498, 2194, 2195, 2206, 2205, 5653, 5667, 5821, 5807
8499, 5653, 5667, 5821, 5807, 5654, 5668, 5822, 5808
8500, 5654, 5668, 5822, 5808, 5655, 5669, 5823, 5809
8501, 5655, 5669, 5823, 5809, 5656, 5670, 5824, 5810
8502, 5656, 5670, 5824, 5810, 5657, 5671, 5825, 5811
8503, 5657, 5671, 5825, 5811, 5658, 5672, 5826, 5812
8504, 5658, 5672, 5826, 5812, 5659, 5673, 5827, 5813
8505, 5659, 5673, 5827, 5813, 5660, 5674, 5828, 5814
8506, 5660, 5674, 5828, 5814, 5661, 5675, 5829, 5815
8507, 5661, 5675, 5829, 5815, 5662, 5676, 5830, 5816
8508, 5662, 5676, 5830, 5816, 5663, 5677, 5831, 5817
8509, 5663, 5677, 5831, 5817, 5664, 5678, 5832, 5818
8510, 5664, 5678, 5832, 5818, 5665, 5679, 5833, 5819
8511, 5665, 5679, 5833, 5819, 5666, 5680, 5834, 5820
8512, 5666, 5680, 5834, 5820, 2736, 2737, 2748, 2747
8513, 2195, 2196, 2207, 2206, 5667, 5681, 5835, 5821
8514, 5667, 5681, 5835, 5821, 5668, 5682, 5836, 5822
8515, 5668, 5682, 5836, 5822, 5669, 5683, 5837, 5823
8516, 5669, 5683, 5837, 5823, 5670, 5684, 5838, 5824
8517, 5670, 5684, 5838, 5824, 5671, 5685, 5839, 5825
8518, 5671, 5685, 5839, 5825, 5672, 5686, 5840, 5826
8519, 5672, 5686, 5840, 5826, 5673, 5687, 5841, 5827
8520, 5673, 5687, 5841, 5827, 5674, 5688, 5842, 5828
8521, 5674, 5688, 5842, 5828, 5675, 5689, 5843, 5829
8522, 5675, 5689, 5843, 5829, 5676, 5690, 5844, 5830
8523, 5676, 5690, 5844, 5830, 5677, 5691, 5845, 5831
8524, 5677, 5691, 5845, 5831, 5678, 5692, 5846, 5832
8525, 5678, 5692, 5846, 5832, 5679, 5693, 5847, 5833
8526, 5679, 5693, 5847, 5833, 5680, 5694, 5848, 5834
8527, 5680, 5694, 5848, 5834, 2737, 2738, 2749, 2748
8528, 2196, 2197, 2208, 2207, 5681, 5695, 5849, 5835
8529, 5681, 5695, 5849, 5835, 5682, 5696, 5850, 5836
8530, 5682, 5696, 5850, 5836, 5683, 5697, 5851, 5837
8531, 5683, 5697, 5851, 5837, 5684, 5698, 5852, 5838
8532, 5684, 5698, 5852, 5838, 5685, 5699, 5853, 5839
8533, 5685, 5699, 5853, 5839, 5686, 5700, 5854, 5840
8534, 5686, 5700, 5854, 5840, 5687, 5701, 5855, 5841
8535, 5687, 5701, 5855, 5841, 5688, 5702, 5856, 5842
8536, 5688, 5702, 5856, 5842, 5689, 5703, 5857, 5843
8537, 5689, 5703, 5857, 5843, 5690, 5704, 5858, 5844
8538, 5690, 5704, 5858, 5844, 5691, 5705, 5859, 5845
8539, 5691, 5705, 5859, 5845, 5692, 5706, 5860, 5846
8540, 5692, 5706, 5860, 5846, 5693, 5707, 5861, 5847
8541, 5693, 5707, 5861, 5847, 5694, 5708, 5862, 5848
8542, 5694, 5708, 5862, 5848, 2738, 2739, 2750, 2749
8543, 2197, 469, 470, 2208, 5695, 2657, 2671, 5849
8544, 5695, 2657, 2671, 5849, 5696, 2658, 2672, 5850
8545, 5696, 2658, 2672, 5850, 5697, 2659, 2673, 5851
8546, 5697, 2659, 2673, 5851, 5698, 2660, 2674, 5852
8547, 5698, 2660, 2674, 5852, 5699, 2661, 2675, 5853
8548, 5699, 2661, 2675, 5853, 5700, 2662, 2676, 5854
8549, 5700, 2662, 2676, 5854, 5701, 2663, 2677, 5855
8550, 5701, 2663, 2677, 5855, 5702, 2664, 2678, 5856
8551, 5702, 2664, 2678, 5856, 5703, 2665, 2679, 5857
8552, 5703, 2665, 2679, 5857, 5704, 2666, 2680, 5858
8553, 5704, 2666, 2680, 5858, 5705, 2667, 2681, 5859
8554, 5705, 2667, 2681, 5859, 5706, 2668, 2682, 5860
8555, 5706, 2668, 2682, 5860, 5707, 2669, 2683, 5861
8556, 5707, 2669, 2683, 5861, 5708, 2670, 2684, 5862
8557, 5708, 2670, 2684, 5862, 2739, 559, 560, 2750
8558, 464, 2198, 437, 33, 2587, 5709, 2209, 471
8559, 2587, 5709, 2209, 471, 2588, 5710, 2210, 472
8560, 2588, 5710, 2210, 472, 2589, 5711, 2211, 473
8561, 2589, 5711, 2211, 473, 2590, 5712, 2212, 474
8562, 2590, 5712, 2212, 474, 2591, 5713, 2213, 475
8563, 2591, 5713, 2213, 475, 2592, 5714, 2214, 476
8564, 2592, 5714, 2214, 476, 2593, 5715, 2215, 477
8565, 2593, 5715, 2215, 477, 2594, 5716, 2216, 478
8566, 2594, 5716, 2216, 478, 2595, 5717, 2217, 479
8567, 2595, 5717, 2217, 479, 2596, 5718, 2218, 480
8568, 2596, 5718, 2218, 480, 2597, 5719, 2219, 481
8569, 2597, 5719, 2219, 481, 2598, 5720, 2220, 482
8570, 2598, 5720, 2220, 482, 2599, 5721, 2221, 483
8571, 2599, 5721, 2221, 483, 2600, 5722, 2222, 484
8572, 2600, 5722, 2222, 484, 554, 2740, 499, 37
8573, 2198, 2199, 438, 437, 5709, 5723, 2223, 2209
8574, 5709, 5723, 2223, 2209, 5710, 5724, 2224, 2210
8575, 5710, 5724, 2224, 2210, 5711, 5725, 2225, 2211
8576, 5711, 5725, 2225, 2211, 5712, 5726, 2226, 2212
8577, 5712, 5726, 2226, 2212, 5713, 5727, 2227, 2213
8578, 5713, 5727, 2227, 2213, 5714, 5728, 2228, 2214
8579, 5714, 5728, 2228, 2214, 5715, 5729, 2229, 2215
8580, 5715, 5729, 2229, 2215, 5716, 5730, 2230, 2216
8581, 5716, 5730, 2230, 2216, 5717, 5731, 2231, 2217
8582, 5717, 5731, 2231, 2217, 5718, 5732, 2232, 2218
8583, 5718, 5732, 2232, 2218, 5719, 5733, 2233, 2219
8584, 5719, 5733, 2233, 2219, 5720, 5734, 2234, 2220
8585, 5720, 5734, 2234, 2220, 5721, 5735, 2235, 2221
8586, 5721, 5735, 2235, 2221, 5722, 5736, 2236, 2222
8587, 5722, 5736, 2236, 2222, 2740, 2741, 500, 499
8588, 2199, 2200, 439, 438, 5723, 5737, 2237, 2223
8589, 5723, 5737, 2237, 2223, 5724, 5738, 2238, 2224
8590, 5724, 5738, 2238, 2224, 5725, 5739, 2239, 2225
8591, 5725, 5739, 2239, 2225, 5726, 5740, 2240, 2226
8592, 5726, 5740, 2240, 2226, 5727, 5741, 2241, 2227
8593, 5727, 5741, 2241, 2227, 5728, 5742, 2242, 2228
8594, 5728, 5742, 2242, 2228, 5729, 5743, 2243, 2229
8595, 5729, 5743, 2243, 2229, 5730, 5744, 2244, 2230
8596, 5730, 5744, 2244, 2230, 5731, 5745, 2245, 2231
8597, 5731, 5745, 2245, 2231, 5732, 5746, 2246, 2232
8598, 5732, 5746, 2246, 2232, 5733, 5747, 2247, 2233
8599, 5733, 5747, 2247, 2233, 5734, 5748, 2248, 2234
8600, 5734, 5748, 2248, 2234, 5735, 5749, 2249, 2235
8601, 5735, 5749, 2249, 2235, 5736, 5750, 2250, 2236
8602, 5736, 5750, 2250, 2236, 2741, 2742, 501, 500
8603, 2200, 2201, 440, 439, 5737, 5751, 2251, 2237
8604, 5737, 5751, 2251, 2237, 5738, 5752, 2252, 2238
8605, 5738, 5752, 2252, 2238, 5739, 5753, 2253, 2239
8606, 5739, 5753, 2253, 2239, 5740, 5754, 2254, 2240
8607, 5740, 5754, 2254, 2240, 5741, 5755, 2255, 2241
8608, 5741, 5755, 2255, 2241, 5742, 5756, 2256, 2242
8609, 5742, 5756, 2256, 2242, 5743, 5757, 2257, 2243
8610, 5743, 5757, 2257, 2243, 5744, 5758, 2258, 2244
8611, 5744, 5758, 2258, 2244, 5745, 5759, 2259, 2245
8612, 5745, 5759, 2259, 2245, 5746, 5760, 2260, 2246
8613, 5746, 5760, 2260, 2246, 5747, 5761, 2261, 2247
8614, 5747, 5761, 2261, 2247, 5748, 5762, 2262, 2248
8615, 5748, 5762, 2262, 2248, 5749, 5763, 2263, 2249
8616, 5749, 5763, 2263, 2249, 5750, 5764, 2264, 2250
8617, 5750, 5764, 2264, 2250, 2742, 2743, 502, 501
8618, 2201, 2202, 441, 440, 5751, 5765, 2265, 2251
8619, 5751, 5765, 2265, 2251, 5752, 5766, 2266, 2252
8620, 5752, 5766, 2266, 2252, 5753, 5767, 2267, 2253
8621, 5753, 5767, 2267, 2253, 5754, 5768, 2268, 2254
8622, 5754, 5768, 2268, 2254, 5755, 5769, 2269, 2255
8623, 5755, 5769, 2269, 2255, 5756, 5770, 2270, 2256
8624, 5756, 5770, 2270, 2256, 5757, 5771, 2271, 2257
8625, 5757, 5771, 2271, 2257, 5758, 5772, 2272, 2258
8626, 5758, 5772, 2272, 2258, 5759, 5773, 2273, 2259
8627, 5759, 5773, 2273, 2259, 5760, 5774, 2274, 2260
8628, 5760, 5774, 2274, 2260, 5761, 5775, 2275, 2261
8629, 5761, 5775, 2275, 2261, 5762, 5776, 2276, 2262
8630, 5762, 5776, 2276, 2262, 5763, 5777, 2277, 2263
8631, 5763, 5777, 2277, 2263, 5764, 5778, 2278, 2264
8632, 5764, 5778, 2278, 2264, 2743, 2744, 503, 502
8633, 2202, 2203, 442, 441, 5765, 5779, 2279, 2265
8634, 5765, 5779, 2279, 2265, 5766, 5780, 2280, 2266
8635, 5766, 5780, 2280, 2266, 5767, 5781, 2281, 2267
8636, 5767, 5781, 2281, 2267, 5768, 5782, 2282, 2268
8637, 5768, 5782, 2282, 2268, 5769, 5783, 2283, 2269
8638, 5769, 5783, 2283, 2269, 5770, 5784, 2284, 2270
8639, 5770, 5784, 2284, 2270, 5771, 5785, 2285, 2271
8640, 5771, 5785, 2285, 2271, 5772, 5786, 2286, 2272
8641, 5772, 5786, 2286, 2272, 5773, 5787, 2287, 2273
8642, 5773, 5787, 2287, 2273, 5774, 5788, 2288, 2274
8643, 5774, 5788, 2288, 2274, 5775, 5789, 2289, 2275
8644, 5775, 5789, 2289, 2275, 5776, 5790, 2290, 2276
8645, 5776, 5790, 2290, 2276, 5777, 5791, 2291, 2277
8646, 5777, 5791, 2291, 2277, 5778, 5792, 2292, 2278
8647, 5778, 5792, 2292, 2278, 2744, 2745, 504, 503
8648, 2203, 2204, 443, 442, 5779, 5793, 2293, 2279
8649, 5779, 5793, 2293, 2279, 5780, 5794, 2294, 2280
8650, 5780, 5794, 2294, 2280, 5781, 5795, 2295, 2281
8651, 5781, 5795, 2295, 2281, 5782, 5796, 2296, 2282
8652, 5782, 5796, 2296, 2282, 5783, 5797, 2297, 2283
8653, 5783, 5797, 2297, 2283, 5784, 5798, 2298, 2284
8654, 5784, 5798, 2298, 2284, 5785, 5799, 2299, 2285
8655, 5785, 5799, 2299, 2285, 5786, 5800, 2300, 2286
8656, 5786, 5800, 2300, 2286, 5787, 5801, 2301, 2287
8657, 5787, 5801, 2301, 2287, 5788, 5802, 2302, 2288
8658, 5788, 5802, 2302, 2288, 5789, 5803, 2303, 2289
8659, 5789, 5803, 2303, 2289, 5790, 5804, 2304, 2290
8660, 5790, 5804, 2304, 2290, 5791, 5805, 2305, 2291
8661, 5791, 5805, 2305, 2291, 5792, 5806, 2306, 2292
8662, 5792, 5806, 2306, 2292, 2745, 2746, 505, 504
8663, 2204, 2205, 444, 443, 5793, 5807, 2307, 2293
8664, 5793, 5807, 2307, 2293, 5794, 5808, 2308, 2294
8665, 5794, 5808, 2308, 2294, 5795, 5809, 2309, 2295
8666, 5795, 5809, 2309, 2295, 5796, 5810, 2310, 2296
8667, 5796, 5810, 2310, 2296, 5797, 5811, 2311, 2297
8668, 5797, 5811, 2311, 2297, 5798, 5812, 2312, 2298
8669, 5798, 5812, 2312, 2298, 5799, 5813, 2313, 2299
8670, 5799, 5813, 2313, 2299, 5800, 5814, 2314, 2300
8671, 5800, 5814, 2314, 2300, 5801, 5815, 2315, 2301
8672, 5801, 5815, 2315, 2301, 5802, 5816, 2316, 2302
8673, 5802, 5816, 2316, 2302, 5803, 5817, 2317, 2303
8674, 5803, 5817, 2317, 2303, 5804, 5818, 2318, 2304
8675, 5804, 5818, 2318, 2304, 5805, 5819, 2319, 2305
8676, 5805, 5819, 2319, 2305, 5806, 5820, 2320, 2306
8677, 5806, 5820, 2320, 2306, 2746, 2747, 506, 505
8678, 2205, 2206, 445, 444, 5807, 5821, 2321, 2307
8679, 5807, 5821, 2321, 2307, 5808, 5822, 2322, 2308
8680, 5808, 5822, 2322, 2308, 5809, 5823, 2323, 2309
8681, 5809, 5823, 2323, 2309, 5810, 5824, 2324, 2310
8682, 5810, 5824, 2324, 2310, 5811, 5825, 2325, 2311
8683, 5811, 5825, 2325, 2311, 5812, 5826, 2326, 2312
8684, 5812, 5826, 2326, 2312, 5813, 5827, 2327, 2313
8685, 5813, 5827, 2327, 2313, 5814, 5828, 2328, 2314
8686, 5814, 5828, 2328, 2314, 5815, 5829, 2329, 2315
8687, 5815, 5829, 2329, 2315, 5816, 5830, 2330, 2316
8688, 5816, 5830, 2330, 2316, 5817, 5831, 2331, 2317
8689, 5817, 5831, 2331, 2317, 5818, 5832, 2332, 2318
8690, 5818, 5832, 2332, 2318, 5819, 5833, 2333, 2319
8691, 5819, 5833, 2333, 2319, 5820, 5834, 2334, 2320
8692, 5820, 5834, 2334, 2320, 2747, 2748, 507, 506
8693, 2206, 2207, 446, 445, 5821, 5835, 2335, 2321
8694, 5821, 5835, 2335, 2321, 5822, 5836, 2336, 2322
8695, 5822, 5836, 2336, 2322, 5823, 5837, 2337, 2323
8696, 5823, 5837, 2337, 2323, 5824, 5838, 2338, 2324
8697, 5824, 5838, 2338, 2324, 5825, 5839, 2339, 2325
8698, 5825, 5839, 2339, 2325, 5826, 5840, 2340, 2326
8699, 5826, 5840, 2340, 2326, 5827, 5841, 2341, 2327
8700, 5827, 5841, 2341, 2327, 5828, 5842, 2342, 2328
8701, 5828, 5842, 2342, 2328, 5829, 5843, 2343, 2329
8702, 5829, 5843, 2343, 2329, 5830, 5844, 2344, 2330
8703, 5830, 5844, 2344, 2330, 5831, 5845, 2345, 2331
8704, 5831, 5845, 2345, 2331, 5832, 5846, 2346, 2332
8705, 5832, 5846, 2346, 2332, 5833, 5847, 2347, 2333
8706, 5833, 5847, 2347, 2333, 5834, 5848, 2348, 2334
8707, 5834, 5848, 2348, 2334, 2748, 2749, 508, 507
8708, 2207, 2208, 447, 446, 5835, 5849, 2349, 2335
8709, 5835, 5849, 2349, 2335, 5836, 5850, 2350, 2336
8710, 5836, 5850, 2350, 2336, 5837, 5851, 2351, 2337
8711, 5837, 5851, 2351, 2337, 5838, 5852, 2352, 2338
8712, 5838, 5852, 2352, 2338, 5839, 5853, 2353, 2339
8713, 5839, 5853, 2353, 2339, 5840, 5854, 2354, 2340
8714, 5840, 5854, 2354, 2340, 5841, 5855, 2355, 2341
8715, 5841, 5855, 2355, 2341, 5842, 5856, 2356, 2342
8716, 5842, 5856, 2356, 2342, 5843, 5857, 2357, 2343
8717, 5843, 5857, 2357, 2343, 5844, 5858, 2358, 2344
8718, 5844, 5858, 2358, 2344, 5845, 5859, 2359, 2345
8719, 5845, 5859, 2359, 2345, 5846, 5860, 2360, 2346
8720, 5846, 5860, 2360, 2346, 5847, 5861, 2361, 2347
8721, 5847, 5861, 2361, 2347, 5848, 5862, 2362, 2348
8722, 5848, 5862, 2362, 2348, 2749, 2750, 509, 508
8723, 2208, 470, 34, 447, 5849, 2671, 485, 2349
8724, 5849, 2671, 485, 2349, 5850, 2672, 486, 2350
8725, 5850, 2672, 486, 2350, 5851, 2673, 487, 2351
8726, 5851, 2673, 487, 2351, 5852, 2674, 488, 2352
8727, 5852, 2674, 488, 2352, 5853, 2675, 489, 2353
8728, 5853, 2675, 489, 2353, 5854, 2676, 490, 2354
8729, 5854, 2676, 490, 2354, 5855, 2677, 491, 2355
8730, 5855, 2677, 491, 2355, 5856, 2678, 492, 2356
8731, 5856, 2678, 492, 2356, 5857, 2679, 493, 2357
8732, 5857, 2679, 493, 2357, 5858, 2680, 494, 2358
8733, 5858, 2680, 494, 2358, 5859, 2681, 495, 2359
8734, 5859, 2681, 495, 2359, 5860, 2682, 496, 2360
8735, 5860, 2682, 496, 2360, 5861, 2683, 497, 2361
8736, 5861, 2683, 497, 2361, 5862, 2684, 498, 2362
8737, 5862, 2684, 498, 2362, 2750, 560, 38, 509
*ELEMENT, type=C3D8, ELSET=Volume10
8738, 39, 538, 2685, 549, 43, 572, 2751, 583
8739, 538, 539, 2686, 2685, 572, 573, 2752, 2751
8740, 539, 540, 2687, 2686, 573, 574, 2753, 2752
8741, 540, 541, 2688, 2687, 574, 575, 2754, 2753
8742, 541, 542, 2689, 2688, 575, 576, 2755, 2754
8743, 542, 543, 2690, 2689, 576, 577, 2756, 2755
8744, 543, 544, 2691, 2690, 577, 578, 2757, 2756
8745, 544, 545, 2692, 2691, 578, 579, 2758, 2757
8746, 545, 546, 2693, 2692, 579, 580, 2759, 2758
8747, 546, 547, 2694, 2693, 580, 581, 2760, 2759
8748, 547, 548, 2695, 2694, 581, 582, 2761, 2760
8749, 548, 40, 555, 2695, 582, 44, 589, 2761
8750, 549, 2685, 2696, 550, 583, 2751, 2762, 584
8751, 2685, 2686, 2697, 2696, 2751, 2752, 2763, 2762
8752, 2686, 2687, 2698, 2697, 2752, 2753, 2764, 2763
8753, 2687, 2688, 2699, 2698, 2753, 2754, 2765, 2764
8754, 2688, 2689, 2700, 2699, 2754, 2755, 2766, 2765
8755, 2689, 2690, 2701, 2700, 2755, 2756, 2767, 2766
8756, 2690, 2691, 2702, 2701, 2756, 2757, 2768, 2767
8757, 2691, 2692, 2703, 2702, 2757, 2758, 2769, 2768
8758, 2692, 2693, 2704, 2703, 2758, 2759, 2770, 2769
8759, 2693, 2694, 2705, 2704, 2759, 2760, 2771, 2770
8760, 2694, 2695, 2706, 2705, 2760, 2761, 2772, 2771
8761, 2695, 555, 556, 2706, 2761, 589, 590, 2772
8762, 550, 2696, 2707, 551, 584, 2762, 2773, 585
8763, 2696, 2697, 2708, 2707, 2762, 2763, 2774, 2773
8764, 2697, 2698, 2709, 2708, 2763, 2764, 2775, 2774
8765, 2698, 2699, 2710, 2709, 2764, 2765, 2776, 2775
8766, 2699, 2700, 2711, 2710, 2765, 2766, 2777, 2776
8767, 2700, 2701, 2712, 2711, 2766, 2767, 2778, 2777
8768, 2701, 2702, 2713, 2712, 2767, 2768, 2779, 2778
8769, 2702, 2703, 2714, 2713, 2768, 2769, 2780, 2779
8770, 2703, 2704, 2715, 2714, 2769, 2770, 2781, 2780
8771, 2704, 2705, 2716, 2715, 2770, 2771, 2782, 2781
8772, 2705, 2706, 2717, 2716, 2771, 2772, 2783, 2782
8773, 2706, 556, 557, 2717, 2772, 590, 591, 2783
8774, 551, 2707, 2718, 552, 585, 2773, 2784, 586
8775, 2707, 2708, 2719, 2718, 2773, 2774, 2785, 2784
8776, 2708, 2709, 2720, 2719, 2774, 2775, 2786, 2785
8777, 2709, 2710, 2721, 2720, 2775, 2776, 2787, 2786
8778, 2710, 2711, 2722, 2721, 2776, 2777, 2788, 2787
8779, 2711, 2712, 2723, 2722, 2777, 2778, 2789, 2788
8780, 2712, 2713, 2724, 2723, 2778, 2779, 2790, 2789
8781, 2713, 2714, 2725, 2724, 2779, 2780, 2791, 2790
8782, 2714, 2715, 2726, 2725, 2780, 2781, 2792, 2791
8783, 2715, 2716, 2727, 2726, 2781, 2782, 2793, 2792
8784, 2716, 2717, 2728, 2727, 2782, 2783, 2794, 2793
8785, 2717, 557, 558, 2728, 2783, 591, 592, 2794
8786, 552, 2718, 2729, 553, 586, 2784, 2795, 587
8787, 2718, 2719, 2730, 2729, 2784, 2785, 2796, 2795
8788, 2719, 2720, 2731, 2730, 2785, 2786, 2797, 2796
8789, 2720, 2721, 2732, 2731, 2786, 2787, 2798, 2797
8790, 2721, 2722, 2733, 2732, 2787, 2788, 2799, 2798
8791, 2722, 2723, 2734, 2733, 2788, 2789, 2800, 2799
8792, 2723, 2724, 2735, 2734, 2789, 2790, 2801, 2800
8793, 2724, 2725, 2736, 2735, 2790, 2791, 2802, 2801
8794, 2725, 2726, 2737, 2736, 2791, 2792, 2803, 2802
8795, 2726, 2727, 2738, 2737, 2792, 2793, 2804, 2803
8796, 2727, 2728, 2739, 2738, 2793, 2794, 2805, 2804
8797, 2728, 558, 559, 2739, 2794, 592, 593, 2805
8798, 553, 2729, 2740, 554, 587, 2795, 2806, 588
8799, 2729, 2730, 2741, 2740, 2795, 2796, 2807, 2806
8800, 2730, 2731, 2742, 2741, 2796, 2797, 2808, 2807
8801, 2731, 2732, 2743, 2742, 2797, 2798, 2809, 2808
8802, 2732, 2733, 2744, 2743, 2798, 2799, 2810, 2809
8803, 2733, 2734, 2745, 2744, 2799, 2800, 2811, 2810
8804, 2734, 2735, 2746, 2745, 2800, 2801, 2812, 2811
8805, 2735, 2736, 2747, 2746, 2801, 2802, 2813, 2812
8806, 2736, 2737, 2748, 2747, 2802, 2803, 2814, 2813
8807, 2737, 2738, 2749, 2748, 2803, 2804, 2815, 2814
8808, 2738, 2739, 2750, 2749, 2804, 2805, 2816, 2815
8809, 2739, 559, 560, 2750, 2805, 593, 594, 2816
8810, 554, 2740, 499, 37, 588, 2806, 561, 41
8811, 2740, 2741, 500, 499, 2806, 2807, 562, 561
8812, 2741, 2742, 501, 500, 2807, 2808, 563, 562
8813, 2742, 2743, 502, 501, 2808, 2809, 564, 563
8814, 2743, 2744, 503, 502, 2809, 2810, 565, 564
8815, 2744, 2745, 504, 503, 2810, 2811, 566, 565
8816, 2745, 2746, 505, 504, 2811, 2812, 567, 566
8817, 2746, 2747, 506, 505, 2812, 2813, 568, 567
8818, 2747, 2748, 507, 506, 2813, 2814, 569, 568
8819, 2748, 2749, 508, 507, 2814, 2815, 570, 569
8820, 2749, 2750, 509, 508, 2815, 2816, 571, 570
8821, 2750, 560, 38, 509, 2816, 594, 42, 571
*ELEMENT, type=C3D8, ELSET=Volume11
8822, 43, 572, 2751, 583, 608, 2828, 5863, 2839
8823, 608, 2828, 5863, 2839, 47, 610, 2851, 621
8824, 572, 573, 2752, 2751, 2828, 2829, 5864, 5863
8825, 2828, 2829, 5864, 5863, 610, 611, 2852, 2851
8826, 573, 574, 2753, 2752, 2829, 2830, 5865, 5864
8827, 2829, 2830, 5865, 5864, 611, 612, 2853, 2852
8828, 574, 575, 2754, 2753, 2830, 2831, 5866, 5865
8829, 2830, 2831, 5866, 5865, 612, 613, 2854, 2853
8830, 575, 576, 2755, 2754, 2831, 2832, 5867, 5866
8831, 2831, 2832, 5867, 5866, 613, 614, 2855, 2854
8832, 576, 577, 2756, 2755, 2832, 2833, 5868, 5867
8833, 2832, 2833, 5868, 5867, 614, 615, 2856, 2855
8834, 577, 578, 2757, 2756, 2833, 2834, 5869, 5868
8835, 2833, 2834, 5869, 5868, 615, 616, 2857, 2856
8836, 578, 579, 2758, 2757, 2834, 2835, 5870, 5869
8837, 2834, 2835, 5870, 5869, 616, 617, 2858, 2857
8838, 579, 580, 2759, 2758, 2835, 2836, 5871, 5870
8839, 2835, 2836, 5871, 5870, 617, 618, 2859, 2858
8840, 580, 581, 2760, 2759, 2836, 2837, 5872, 5871
8841, 2836, 2837, 5872, 5871, 618, 619, 2860, 2859
8842, 581, 582, 2761, 2760, 2837, 2838, 5873, 5872
8843, 2837, 2838, 5873, 5872, 619, 620, 2861, 2860
8844, 582, 44, 589, 2761, 2838, 609, 2845, 5873
8845, 2838, 609, 2845, 5873, 620, 48, 627, 2861
8846, 583, 2751, 2762, 584, 2839, 5863, 5874, 2840
8847, 2839, 5863, 5874, 2840, 621, 2851, 2862, 622
8848, 2751, 2752, 2763, 2762, 5863, 5864, 5875, 5874
8849, 5863, 5864, 5875, 5874, 2851, 2852, 2863, 2862
8850, 2752, 2753, 2764, 2763, 5864, 5865, 5876, 5875
8851, 5864, 5865, 5876, 5875, 2852, 2853, 2864, 2863
8852, 2753, 2754, 2765, 2764, 5865, 5866, 5877, 5876
8853, 5865, 5866, 5877, 5876, 2853, 2854, 2865, 2864
8854, 2754, 2755, 2766, 2765, 5866, 5867, 5878, 5877
8855, 5866, 5867, 5878, 5877, 2854, 2855, 2866, 2865
8856, 2755, 2756, 2767, 2766, 5867, 5868, 5879, 5878
8857, 5867, 5868, 5879, 5878, 2855, 2856, 2867, 2866
8858, 2756, 2757, 2768, 2767, 5868, 5869, 5880, 5879
8859, 5868, 5869, 5880, 5879, 2856, 2857, 2868, 2867
8860, 2757, 2758, 2769, 2768, 5869, 5870, 5881, 5880
8861, 5869, 5870, 5881, 5880, 2857, 2858, 2869, 2868
8862, 2758, 2759, 2770, 2769, 5870, 5871, 5882, 5881
8863, 5870, 5871, 5882, 5881, 2858, 2859, 2870, 2869
8864, 2759, 2760, 2771, 2770, 5871, 5872, 5883, 5882
8865, 5871, 5872, 5883, 5882, 2859, 2860, 2871, 2870
8866, 2760, 2761, 2772, 2771, 5872, 5873, 5884, 5883
8867, 5872, 5873, 5884, 5883, 2860, 2861, 2872, 2871
8868, 2761, 589, 590, 2772, 5873, 2845, 2846, 5884
8869, 5873, 2845, 2846, 5884, 2861, 627, 628, 2872
8870, 584, 2762, 2773, 585, 2840, 5874, 5885, 2841
8871, 2840, 5874, 5885, 2841, 622, 2862, 2873, 623
8872, 2762, 2763, 2774, 2773, 5874, 5875, 5886, 5885
8873, 5874, 5875, 5886, 5885, 2862, 2863, 2874, 2873
8874, 2763, 2764, 2775, 2774, 5875, 5876, 5887, 5886
8875, 5875, 5876, 5887, 5886, 2863, 2864, 2875, 2874
8876, 2764, 2765, 2776, 2775, 5876, 5877, 5888, 5887
8877, 5876, 5877, 5888, 5887, 2864, 2865, 2876, 2875
8878, 2765, 2766, 2777, 2776, 5877, 5878, 5889, 5888
8879, 5877, 5878, 5889, 5888, 2865, 2866, 2877, 2876
8880, 2766, 2767, 2778, 2777, 5878, 5879, 5890, 5889
8881, 5878, 5879, 5890, 5889, 2866, 2867, 2878, 2877
8882, 2767, 2768, 2779, 2778, 5879, 5880, 5891, 5890
8883, 5879, 5880, 5891, 5890, 2867, 2868, 2879, 2878
8884, 2768, 2769, 2780, 2779, 5880, 5881, 5892, 5891
8885, 5880, 5881, 5892, 5891, 2868, 2869, 2880, 2879
8886, 2769, 2770, 2781, 2780, 5881, 5882, 5893, 5892
8887, 5881, 5882, 5893, 5892, 2869, 2870, 2881, 2880
8888, 2770, 2771, 2782, 2781, 5882, 5883, 5894, 5893
8889, 5882, 5883, 5894, 5893, 2870, 2871, 2882, 2881
8890, 2771, 2772, 2783, 2782, 5883, 5884, 5895, 5894
8891, 5883, 5884, 5895, 5894, 2871, 2872, 2883, 2882
8892, 2772, 590, 591, 2783, 5884, 2846, 2847, 5895
8893, 5884, 2846, 2847, 5895, 2872, 628, 629, 2883
8894, 585, 2773, 2784, 586, 2841, 5885, 5896, 2842
8895, 2841, 5885, 5896, 2842, 623, 2873, 2884, 624
8896, 2773, 2774, 2785, 2784, 5885, 5886, 5897, 5896
8897, 5885, 5886, 5897, 5896, 2873, 2874, 2885, 2884
8898, 2774, 2775, 2786, 2785, 5886, 5887, 5898, 5897
8899, 5886, 5887, 5898, 5897, 2874, 2875, 2886, 2885
8900, 2775, 2776, 2787, 2786, 5887, 5888, 5899, 5898
8901, 5887, 5888, 5899, 5898, 2875, 2876, 2887, 2886
8902, 2776, 2777, 2788, 2787, 5888, 5889, 5900, 5899
8903, 5888, 5889, 5900, 5899, 2876, 2877, 2888, 2887
8904, 2777, 2778, 2789, 2788, 5889, 5890, 5901, 5900
8905, 5889, 5890, 5901, 5900, 2877, 2878, 2889, 2888
8906, 2778, 2779, 2790, 2789, 5890, 5891, 5902, 5901
8907, 5890, 5891, 5902, 5901, 2878, 2879, 2890, 2889
8908, 2779, 2780, 2791, 2790, 5891, 5892, 5903, 5902
8909, 5891, 5892, 5903, 5902, 2879, 2880, 2891, 2890
8910, 2780, 2781, 2792, 2791, 5892, 5893, 5904, 5903
8911, 5892, 5893, 5904, 5903, 2880, 2881, 2892, 2891
8912, 2781, 2782, 2793, 2792, 5893, 5894, 5905, 5904
8913, 5893, 5894, 5905, 5904, 2881, 2882, 2893, 2892
8914, 2782, 2783, 2794, 2793, 5894, 5895, 5906, 5905
8915, 5894, 5895, 5906, 5905, 2882, 2883, 2894, 2893
8916, 2783, 591, 592, 2794, 5895, 2847, 2848, 5906
8917, 5895, 2847, 2848, 5906, 2883, 629, 630, 2894
8918, 586, 2784, 2795, 587, 2842, 5896, 5907, 2843
8919, 2842, 5896, 5907, 2843, 624, 2884, 2895, 625
8920, 2784, 2785, 2796, 2795, 5896, 5897, 5908, 5907
8921, 5896, 5897, 5908, 5907, 2884, 2885, 2896, 2895
8922, 2785, 2786, 2797, 2796, 5897, 5898, 5909, 5908
8923, 5897, 5898, 5909, 5908, 2885, 2886, 2897, 2896
8924, 2786, 2787, 2798, 2797, 5898, 5899, 5910, 5909
8925, 5898, 5899, 5910, 5909, 2886, 2887, 2898, 2897
8926, 2787, 2788, 2799, 2798, 5899, 5900, 5911, 5910
8927, 5899, 5900, 5911, 5910, 2887, 2888, 2899, 2898
8928, 2788, 2789, 2800, 2799, 5900, 5901, 5912, 5911
8929, 5900, 5901, 5912, 5911, 2888, 2889, 2900, 2899
8930, 2789, 2790, 2801, 2800, 5901, 5902, 5913, 5912
8931, 5901, 5902, 5913, 5912, 2889, 2890, 2901, 2900
8932, 2790, 2791, 2802, 2801, 5902, 5903, 5914, 5913
8933, 5902, 5903, 5914, 5913, 2890, 2891, 2902, 2901
8934, 2791, 2792, 2803, 2802, 5903, 5904, 5915, 5914
8935, 5903, 5904, 5915, 5914, 2891, 2892, 2903, 2902
8936, 2792, 2793, 2804, 2803, 5904, 5905, 5916, 5915
8937, 5904, 5905, 5916, 5915, 2892, 2893, 2904, 2903
8938, 2793, 2794, 2805, 2804, 5905, 5906, 5917, 5916
8939, 5905, 5906, 5917, 5916, 2893, 2894, 2905, 2904
8940, 2794, 592, 593, 2805, 5906, 2848, 2849, 5917
8941, 5906, 2848, 2849, 5917, 2894, 630, 631, 2905
8942, 587, 2795, 2806, 588, 2843, 5907, 5918, 2844
8943, 2843, 5907, 5918, 2844, 625, 2895, 2906, 626
8944, 2795, 2796, 2807, 2806, 5907, 5908, 5919, 5918
8945, 5907, 5908, 5919, 5918, 2895, 2896, 2907, 2906
8946, 2796, 2797, 2808, 2807, 5908, 5909, 5920, 5919
8947, 5908, 5909, 5920, 5919, 2896, 2897, 2908, 2907
8948, 2797, 2798, 2809, 2808, 5909, 5910, 5921, 5920
8949, 5909, 5910, 5921, 5920, 2897, 2898, 2909, 2908
8950, 2798, 2799, 2810, 2809, 5910, 5911, 5922, 5921
8951, 5910, 5911, 5922, 5921, 2898, 2899, 2910, 2909
8952, 2799, 2800, 2811, 2810, 5911, 5912, 5923, 5922
8953, 5911, 5912, 5923, 5922, 2899, 2900, 2911, 2910
8954, 2800, 2801, 2812, 2811, 5912, 5913, 5924, 5923
8955, 5912, 5913, 5924, 5923, 2900, 2901, 2912, 2911
8956, 2801, 2802, 2813, 2812, 5913, 5914, 5925, 5924
8957, 5913, 5914, 5925, 5924, 2901, 2902, 2913, 2912
8958, 2802, 2803, 2814, 2813, 5914, 5915, 5926, 5925
8959, 5914, 5915, 5926, 5925, 2902, 2903, 2914, 2913
8960, 2803, 2804, 2815, 2814, 5915, 5916, 5927, 5926
8961, 5915, 5916, 5927, 5926, 2903, 2904, 2915, 2914
8962, 2804, 2805, 2816, 2815, 5916, 5917, 5928, 5927
8963, 5916, 5917, 5928, 5927, 2904, 2905, 2916, 2915
8964, 2805, 593, 594, 2816, 5917, 2849, 2850, 5928
8965, 5917, 2849, 2850, 5928, 2905, 631, 632, 2916
8966, 588, 2806, 561, 41, 2844, 5918, 2817, 595
8967, 2844, 5918, 2817, 595, 626, 2906, 597, 45
8968, 2806, 2807, 562, 561, 5918, 5919, 2818, 2817
8969, 5918, 5919, 2818, 2817, 2906, 2907, 598, 597
8970, 2807, 2808, 563, 562, 5919, 5920, 2819, 2818
8971, 5919, 5920, 2819, 2818, 2907, 2908, 599, 598
8972, 2808, 2809, 564, 563, 5920, 5921, 2820, 2819
8973, 5920, 5921, 2820, 2819, 2908, 2909, 600, 599
8974, 2809, 2810, 565, 564, 5921, 5922, 2821, 2820
8975, 5921, 5922, 2821, 2820, 2909, 2910, 601, 600
8976, 2810, 2811, 566, 565, 5922, 5923, 2822, 2821
8977, 5922, 5923, 2822, 2821, 2910, 2911, 602, 601
8978, 2811, 2812, 567, 566, 5923, 5924, 2823, 2822
8979, 5923, 5924, 2823, 2822, 2911, 2912, 603, 602
8980, 2812, 2813, 568, 567, 5924, 5925, 2824, 2823
8981, 5924, 5925, 2824, 2823, 2912, 2913, 604, 603
8982, 2813, 2814, 569, 568, 5925, 5926, 2825, 2824
8983, 5925, 5926, 2825, 2824, 2913, 2914, 605, 604
8984, 2814, 2815, 570, 569, 5926, 5927, 2826, 2825
8985, 5926, 5927, 2826, 2825, 2914, 2915, 606, 605
8986, 2815, 2816, 571, 570, 5927, 5928, 2827, 2826
8987, 5927, 5928, 2827, 2826, 2915, 2916, 607, 606
8988, 2816, 594, 42, 571, 5928, 2850, 596, 2827
8989, 5928, 2850, 596, 2827, 2916, 632, 46, 607
*ELEMENT, type=C3D8, ELSET=Volume12
8990, 44, 589, 2845, 609, 51, 635, 2917, 634
8991, 609, 2845, 627, 48, 634, 2917, 641, 52
8992, 589, 590, 2846, 2845, 635, 636, 2918, 2917
8993, 2845, 2846, 628, 627, 2917, 2918, 642, 641
8994, 590, 591, 2847, 2846, 636, 637, 2919, 2918
8995, 2846, 2847, 629, 628, 2918, 2919, 643, 642
8996, 591, 592, 2848, 2847, 637, 638, 2920, 2919
8997, 2847, 2848, 630, 629, 2919, 2920, 644, 643
8998, 592, 593, 2849, 2848, 638, 639, 2921, 2920
8999, 2848, 2849, 631, 630, 2920, 2921, 645, 644
9000, 593, 594, 2850, 2849, 639, 640, 2922, 2921
9001, 2849, 2850, 632, 631, 2921, 2922, 646, 645
9002, 594, 42, 596, 2850, 640, 49, 633, 2922
9003, 2850, 596, 46, 632, 2922, 633, 50, 646
*ELEMENT, type=C3D8, ELSET=Volume13
9004, 2, 97, 1037, 110, 54, 647, 2923, 660
9005, 110, 1037, 104, 4, 660, 2923, 654, 56
9006, 97, 98, 1038, 1037, 647, 648, 2924, 2923
9007, 1037, 1038, 105, 104, 2923, 2924, 655, 654
9008, 98, 99, 1039, 1038, 648, 649, 2925, 2924
9009, 1038, 1039, 106, 105, 2924, 2925, 656, 655
9010, 99, 100, 1040, 1039, 649, 650, 2926, 2925
9011, 1039, 1040, 107, 106, 2925, 2926, 657, 656
9012, 100, 101, 1041, 1040, 650, 651, 2927, 2926
9013, 1040, 1041, 108, 107, 2926, 2927, 658, 657
9014, 101, 102, 1042, 1041, 651, 652, 2928, 2927
9015, 1041, 1042, 109, 108, 2927, 2928, 659, 658
9016, 102, 1, 103, 1042, 652, 53, 653, 2928
9017, 1042, 103, 3, 109, 2928, 653, 55, 659
*ELEMENT, type=C3D8, ELSET=Volume14
9018, 10, 217, 1269, 169, 67, 755, 3097, 769
9019, 217, 218, 1270, 1269, 755, 756, 3098, 3097
9020, 218, 219, 1271, 1270, 756, 757, 3099, 3098
9021, 219, 220, 1272, 1271, 757, 758, 3100, 3099
9022, 220, 221, 1273, 1272, 758, 759, 3101, 3100
9023, 221, 222, 1274, 1273, 759, 760, 3102, 3101
9024, 222, 223, 1275, 1274, 760, 761, 3103, 3102
9025, 223, 224, 1276, 1275, 761, 762, 3104, 3103
9026, 224, 225, 1277, 1276, 762, 763, 3105, 3104
9027, 225, 226, 1278, 1277, 763, 764, 3106, 3105
9028, 226, 227, 1279, 1278, 764, 765, 3107, 3106
9029, 227, 228, 1280, 1279, 765, 766, 3108, 3107
9030, 228, 229, 1281, 1280, 766, 767, 3109, 3108
9031, 229, 230, 1282, 1281, 767, 768, 3110, 3109
9032, 230, 14, 231, 1282, 768, 68, 780, 3110
9033, 169, 1269, 1283, 170, 769, 3097, 3111, 770
9034, 1269, 1270, 1284, 1283, 3097, 3098, 3112, 3111
9035, 1270, 1271, 1285, 1284, 3098, 3099, 3113, 3112
9036, 1271, 1272, 1286, 1285, 3099, 3100, 3114, 3113
9037, 1272, 1273, 1287, 1286, 3100, 3101, 3115, 3114
9038, 1273, 1274, 1288, 1287, 3101, 3102, 3116, 3115
9039, 1274, 1275, 1289, 1288, 3102, 3103, 3117, 3116
9040, 1275, 1276, 1290, 1289, 3103, 3104, 3118, 3117
9041, 1276, 1277, 1291, 1290, 3104, 3105, 3119, 3118
9042, 1277, 1278, 1292, 1291, 3105, 3106, 3120, 3119
9043, 1278, 1279, 1293, 1292, 3106, 3107, 3121, 3120
9044, 1279, 1280, 1294, 1293, 3107, 3108, 3122, 3121
9045, 1280, 1281, 1295, 1294, 3108, 3109, 3123, 3122
9046, 1281, 1282, 1296, 1295, 3109, 3110, 3124, 3123
9047, 1282, 231, 232, 1296, 3110, 780, 781, 3124
9048, 170, 1283, 1297, 171, 770, 3111, 3125, 771
9049, 1283, 1284, 1298, 1297, 3111, 3112, 3126, 3125
9050, 1284, 1285, 1299, 1298, 3112, 3113, 3127, 3126
9051, 1285, 1286, 1300, 1299, 3113, 3114, 3128, 3127
9052, 1286, 1287, 1301, 1300, 3114, 3115, 3129, 3128
9053, 1287, 1288, 1302, 1301, 3115, 3116, 3130, 3129
9054, 1288, 1289, 1303, 1302, 3116, 3117, 3131, 3130
9055, 1289, 1290, 1304, 1303, 3117, 3118, 3132, 3131
9056, 1290, 1291, 1305, 1304, 3118, 3119, 3133, 3132
9057, 1291, 1292, 1306, 1305, 3119, 3120, 3134, 3133
9058, 1292, 1293, 1307, 1306, 3120, 3121, 3135, 3134
9059, 1293, 1294, 1308, 1307, 3121, 3122, 3136, 3135
9060, 1294, 1295, 1309, 1308, 3122, 3123, 3137, 3136
9061, 1295, 1296, 1310, 1309, 3123, 3124, 3138, 3137
9062, 1296, 232, 233, 1310, 3124, 781, 782, 3138
9063, 171, 1297, 1311, 172, 771, 3125, 3139, 772
9064, 1297, 1298, 1312, 1311, 3125, 3126, 3140, 3139
9065, 1298, 1299, 1313, 1312, 3126, 3127, 3141, 3140
9066, 1299, 1300, 1314, 1313, 3127, 3128, 3142, 3141
9067, 1300, 1301, 1315, 1314, 3128, 3129, 3143, 3142
9068, 1301, 1302, 1316, 1315, 3129, 3130, 3144, 3143
9069, 1302, 1303, 1317, 1316, 3130, 3131, 3145, 3144
9070, 1303, 1304, 1318, 1317, 3131, 3132, 3146, 3145
9071, 1304, 1305, 1319, 1318, 3132, 3133, 3147, 3146
9072, 1305, 1306, 1320, 1319, 3133, 3134, 3148, 3147
9073, 1306, 1307, 1321, 1320, 3134, 3135, 3149, 3148
9074, 1307, 1308, 1322, 1321, 3135, 3136, 3150, 3149
9075, 1308, 1309, 1323, 1322, 3136, 3137, 3151, 3150
9076, 1309, 1310, 1324, 1323, 3137, 3138, 3152, 3151
9077, 1310, 233, 234, 1324, 3138, 782, 783, 3152
9078, 172, 1311, 1325, 173, 772, 3139, 3153, 773
9079, 1311, 1312, 1326, 1325, 3139, 3140, 3154, 3153
9080, 1312, 1313, 1327, 1326, 3140, 3141, 3155, 3154
9081, 1313, 1314, 1328, 1327, 3141, 3142, 3156, 3155
9082, 1314, 1315, 1329, 1328, 3142, 3143, 3157, 3156
9083, 1315, 1316, 1330, 1329, 3143, 3144, 3158, 3157
9084, 1316, 1317, 1331, 1330, 3144, 3145, 3159, 3158
9085, 1317, 1318, 1332, 1331, 3145, 3146, 3160, 3159
9086, 1318, 1319, 1333, 1332, 3146, 3147, 3161, 3160
9087, 1319, 1320, 1334, 1333, 3147, 3148, 3162, 3161
9088, 1320, 1321, 1335, 1334, 3148, 3149, 3163, 3162
9089, 1321, 1322, 1336, 1335, 3149, 3150, 3164, 3163
9090, 1322, 1323, 1337, 1336, 3150, 3151, 3165, 3164
9091, 1323, 1324, 1338, 1337, 3151, 3152, 3166, 3165
9092, 1324, 234, 235, 1338, 3152, 783, 784, 3166
9093, 173, 1325, 1339, 174, 773, 3153, 3167, 774
9094, 1325, 1326, 1340, 1339, 3153, 3154, 3168, 3167
9095, 1326, 1327, 1341, 1340, 3154, 3155, 3169, 3168
9096, 1327, 1328, 1342, 1341, 3155, 3156, 3170, 3169
9097, 1328, 1329, 1343, 1342, 3156, 3157, 3171, 3170
9098, 1329, 1330, 1344, 1343, 3157, 3158, 3172, 3171
9099, 1330, 1331, 1345, 1344, 3158, 3159, 3173, 3172
9100, 1331, 1332, 1346, 1345, 3159, 3160, 3174, 3173
9101, 1332, 1333, 1347, 1346, 3160, 3161, 3175, 3174
9102, 1333, 1334, 1348, 1347, 3161, 3162, 3176, 3175
9103, 1334, 1335, 1349, 1348, 3162, 3163, 3177, 3176
9104, 1335, 1336, 1350, 1349, 3163, 3164, 3178, 3177
9105, 1336, 1337, 1351, 1350, 3164, 3165, 3179, 3178
9106, 1337, 1338, 1352, 1351, 3165, 3166, 3180, 3179
9107, 1338, 235, 236, 1352, 3166, 784, 785, 3180
9108, 174, 1339, 1353, 175, 774, 3167, 3181, 775
9109, 1339, 1340, 1354, 1353, 3167, 3168, 3182, 3181
9110, 1340, 1341, 1355, 1354, 3168, 3169, 3183, 3182
9111, 1341, 1342, 1356, 1355, 3169, 3170, 3184, 3183
9112, 1342, 1343, 1357, 1356, 3170, 3171, 3185, 3184
9113, 1343, 1344, 1358, 1357, 3171, 3172, 3186, 3185
9114, 1344, 1345, 1359, 1358, 3172, 3173, 3187, 3186
9115, 1345, 1346, 1360, 1359, 3173, 3174, 3188, 3187
9116, 1346, 1347, 1361, 1360, 3174, 3175, 3189, 3188
9117, 1347, 1348, 1362, 1361, 3175, 3176, 3190, 3189
9118, 1348, 1349, 1363, 1362, 3176, 3177, 3191, 3190
9119, 1349, 1350, 1364, 1363, 3177, 3178, 3192, 3191
9120, 1350, 1351, 1365, 1364, 3178, 3179, 3193, 3192
9121, 1351, 1352, 1366, 1365, 3179, 3180, 3194, 3193
9122, 1352, 236, 237, 1366, 3180, 785, 786, 3194
9123, 175, 1353, 1367, 176, 775, 3181, 3195, 776
9124, 1353, 1354, 1368, 1367, 3181, 3182, 3196, 3195
9125, 1354, 1355, 1369, 1368, 3182, 3183, 3197, 3196
9126, 1355, 1356, 1370, 1369, 3183, 3184, 3198, 3197
9127, 1356, 1357, 1371, 1370, 3184, 3185, 3199, 3198
9128, 1357, 1358, 1372, 1371, 3185, 3186, 3200, 3199
9129, 1358, 1359, 1373, 1372, 3186, 3187, 3201, 3200
9130, 1359, 1360, 1374, 1373, 3187, 3188, 3202, 3201
9131, 1360, 1361, 1375, 1374, 3188, 3189, 3203, 3202
9132, 1361, 1362, 1376, 1375, 3189, 3190, 3204, 3203
9133, 1362, 1363, 1377, 1376, 3190, 3191, 3205, 3204
9134, 1363, 1364, 1378, 1377, 3191, 3192, 3206, 3205
9135, 1364, 1365, 1379, 1378, 3192, 3193, 3207, 3206
9136, 1365, 1366, 1380, 1379, 3193, 3194, 3208, 3207
9137, 1366, 237, 238, 1380, 3194, 786, 787, 3208
9138, 176, 1367, 1381, 177, 776, 3195, 3209, 777
9139, 1367, 1368, 1382, 1381, 3195, 3196, 3210, 3209
9140, 1368, 1369, 1383, 1382, 3196, 3197, 3211, 3210
9141, 1369, 1370, 1384, 1383, 3197, 3198, 3212, 3211
9142, 1370, 1371, 1385, 1384, 3198, 3199, 3213, 3212
9143, 1371, 1372, 1386, 1385, 3199, 3200, 3214, 3213
9144, 1372, 1373, 1387, 1386, 3200, 3201, 3215, 3214
9145, 1373, 1374, 1388, 1387, 3201, 3202, 3216, 3215
9146, 1374, 1375, 1389, 1388, 3202, 3203, 3217, 3216
9147, 1375, 1376, 1390, 1389, 3203, 3204, 3218, 3217
9148, 1376, 1377, 1391, 1390, 3204, 3205, 3219, 3218
9149, 1377, 1378, 1392, 1391, 3205, 3206, 3220, 3219
9150, 1378, 1379, 1393, 1392, 3206, 3207, 3221, 3220
9151, 1379, 1380, 1394, 1393, 3207, 3208, 3222, 3221
9152, 1380, 238, 239, 1394, 3208, 787, 788, 3222
9153, 177, 1381, 1395, 178, 777, 3209, 3223, 778
9154, 1381, 1382, 1396, 1395, 3209, 3210, 3224, 3223
9155, 1382, 1383, 1397, 1396, 3210, 3211, 3225, 3224
9156, 1383, 1384, 1398, 1397, 3211, 3212, 3226, 3225
9157, 1384, 1385, 1399, 1398, 3212, 3213, 3227, 3226
9158, 1385, 1386, 1400, 1399, 3213, 3214, 3228, 3227
9159, 1386, 1387, 1401, 1400, 3214, 3215, 3229, 3228
9160, 1387, 1388, 1402, 1401, 3215, 3216, 3230, 3229
9161, 1388, 1389, 1403, 1402, 3216, 3217, 3231, 3230
9162, 1389, 1390, 1404, 1403, 3217, 3218, 3232, 3231
9163, 1390, 1391, 1405, 1404, 3218, 3219, 3233, 3232
9164, 1391, 1392, 1406, 1405, 3219, 3220, 3234, 3233
9165, 1392, 1393, 1407, 1406, 3220, 3221, 3235, 3234
9166, 1393, 1394, 1408, 1407, 3221, 3222, 3236, 3235
9167, 1394, 239, 240, 1408, 3222, 788, 789, 3236
9168, 178, 1395, 1409, 179, 778, 3223, 3237, 779
9169, 1395, 1396, 1410, 1409, 3223, 3224, 3238, 3237
9170, 1396, 1397, 1411, 1410, 3224, 3225, 3239, 3238
9171, 1397, 1398, 1412, 1411, 3225, 3226, 3240, 3239
9172, 1398, 1399, 1413, 1412, 3226, 3227, 3241, 3240
9173, 1399, 1400, 1414, 1413, 3227, 3228, 3242, 3241
9174, 1400, 1401, 1415, 1414, 3228, 3229, 3243, 3242
9175, 1401, 1402, 1416, 1415, 3229, 3230, 3244, 3243
9176, 1402, 1403, 1417, 1416, 3230, 3231, 3245, 3244
9177, 1403, 1404, 1418, 1417, 3231, 3232, 3246, 3245
9178, 1404, 1405, 1419, 1418, 3232, 3233, 3247, 3246
9179, 1405, 1406, 1420, 1419, 3233, 3234, 3248, 3247
9180, 1406, 1407, 1421, 1420, 3234, 3235, 3249, 3248
9181, 1407, 1408, 1422, 1421, 3235, 3236, 3250, 3249
9182, 1408, 240, 241, 1422, 3236, 789, 790, 3250
9183, 179, 1409, 203, 9, 779, 3237, 741, 65
9184, 1409, 1410, 204, 203, 3237, 3238, 742, 741
9185, 1410, 1411, 205, 204, 3238, 3239, 743, 742
9186, 1411, 1412, 206, 205, 3239, 3240, 744, 743
9187, 1412, 1413, 207, 206, 3240, 3241, 745, 744
9188, 1413, 1414, 208, 207, 3241, 3242, 746, 745
9189, 1414, 1415, 209, 208, 3242, 3243, 747, 746
9190, 1415, 1416, 210, 209, 3243, 3244, 748, 747
9191, 1416, 1417, 211, 210, 3244, 3245, 749, 748
9192, 1417, 1418, 212, 211, 3245, 3246, 750, 749
9193, 1418, 1419, 213, 212, 3246, 3247, 751, 750
9194, 1419, 1420, 214, 213, 3247, 3248, 752, 751
9195, 1420, 1421, 215, 214, 3248, 3249, 753, 752
9196, 1421, 1422, 216, 215, 3249, 3250, 754, 753
9197, 1422, 241, 13, 216, 3250, 790, 66, 754
*ELEMENT, type=C3D8, ELSET=Volume15
9198, 35, 448, 2363, 510, 69, 819, 3251, 791
9199, 510, 2363, 2364, 511, 791, 3251, 3252, 792
9200, 511, 2364, 2365, 512, 792, 3252, 3253, 793
9201, 512, 2365, 2366, 513, 793, 3253, 3254, 794
9202, 513, 2366, 2367, 514, 794, 3254, 3255, 795
9203, 514, 2367, 2368, 515, 795, 3255, 3256, 796
9204, 515, 2368, 2369, 516, 796, 3256, 3257, 797
9205, 516, 2369, 2370, 517, 797, 3257, 3258, 798
9206, 517, 2370, 2371, 518, 798, 3258, 3259, 799
9207, 518, 2371, 2372, 519, 799, 3259, 3260, 800
9208, 519, 2372, 2373, 520, 800, 3260, 3261, 801
9209, 520, 2373, 2374, 521, 801, 3261, 3262, 802
9210, 521, 2374, 2375, 522, 802, 3262, 3263, 803
9211, 522, 2375, 2376, 523, 803, 3263, 3264, 804
9212, 523, 2376, 538, 39, 804, 3264, 830, 70
9213, 448, 449, 2377, 2363, 819, 820, 3265, 3251
9214, 2363, 2377, 2378, 2364, 3251, 3265, 3266, 3252
9215, 2364, 2378, 2379, 2365, 3252, 3266, 3267, 3253
9216, 2365, 2379, 2380, 2366, 3253, 3267, 3268, 3254
9217, 2366, 2380, 2381, 2367, 3254, 3268, 3269, 3255
9218, 2367, 2381, 2382, 2368, 3255, 3269, 3270, 3256
9219, 2368, 2382, 2383, 2369, 3256, 3270, 3271, 3257
9220, 2369, 2383, 2384, 2370, 3257, 3271, 3272, 3258
9221, 2370, 2384, 2385, 2371, 3258, 3272, 3273, 3259
9222, 2371, 2385, 2386, 2372, 3259, 3273, 3274, 3260
9223, 2372, 2386, 2387, 2373, 3260, 3274, 3275, 3261
9224, 2373, 2387, 2388, 2374, 3261, 3275, 3276, 3262
9225, 2374, 2388, 2389, 2375, 3262, 3276, 3277, 3263
9226, 2375, 2389, 2390, 2376, 3263, 3277, 3278, 3264
9227, 2376, 2390, 539, 538, 3264, 3278, 831, 830
9228, 449, 450, 2391, 2377, 820, 821, 3279, 3265
9229, 2377, 2391, 2392, 2378, 3265, 3279, 3280, 3266
9230, 2378, 2392, 2393, 2379, 3266, 3280, 3281, 3267
9231, 2379, 2393, 2394, 2380, 3267, 3281, 3282, 3268
9232, 2380, 2394, 2395, 2381, 3268, 3282, 3283, 3269
9233, 2381, 2395, 2396, 2382, 3269, 3283, 3284, 3270
9234, 2382, 2396, 2397, 2383, 3270, 3284, 3285, 3271
9235, 2383, 2397, 2398, 2384, 3271, 3285, 3286, 3272
9236, 2384, 2398, 2399, 2385, 3272, 3286, 3287, 3273
9237, 2385, 2399, 2400, 2386, 3273, 3287, 3288, 3274
9238, 2386, 2400, 2401, 2387, 3274, 3288, 3289, 3275
9239, 2387, 2401, 2402, 2388, 3275, 3289, 3290, 3276
9240, 2388, 2402, 2403, 2389, 3276, 3290, 3291, 3277
9241, 2389, 2403, 2404, 2390, 3277, 3291, 3292, 3278
9242, 2390, 2404, 540, 539, 3278, 3292, 832, 831
9243, 450, 451, 2405, 2391, 821, 822, 3293, 3279
9244, 2391, 2405, 2406, 2392, 3279, 3293, 3294, 3280
9245, 2392, 2406, 2407, 2393, 3280, 3294, 3295, 3281
9246, 2393, 2407, 2408, 2394, 3281, 3295, 3296, 3282
9247, 2394, 2408, 2409, 2395, 3282, 3296, 3297, 3283
9248, 2395, 2409, 2410, 2396, 3283, 3297, 3298, 3284
9249, 2396, 2410, 2411, 2397, 3284, 3298, 3299, 3285
9250, 2397, 2411, 2412, 2398, 3285, 3299, 3300, 3286
9251, 2398, 2412, 2413, 2399, 3286, 3300, 3301, 3287
9252, 2399, 2413, 2414, 2400, 3287, 3301, 3302, 3288
9253, 2400, 2414, 2415, 2401, 3288, 3302, 3303, 3289
9254, 2401, 2415, 2416, 2402, 3289, 3303, 3304, 3290
9255, 2402, 2416, 2417, 2403, 3290, 3304, 3305, 3291
9256, 2403, 2417, 2418, 2404, 3291, 3305, 3306, 3292
9257, 2404, 2418, 541, 540, 3292, 3306, 833, 832
9258, 451, 452, 2419, 2405, 822, 823, 3307, 3293
9259, 2405, 2419, 2420, 2406, 3293, 3307, 3308, 3294
9260, 2406, 2420, 2421, 2407, 3294, 3308, 3309, 3295
9261, 2407, 2421, 2422, 2408, 3295, 3309, 3310, 3296
9262, 2408, 2422, 2423, 2409, 3296, 3310, 3311, 3297
9263, 2409, 2423, 2424, 2410, 3297, 3311, 3312, 3298
9264, 2410, 2424, 2425, 2411, 3298, 3312, 3313, 3299
9265, 2411, 2425, 2426, 2412, 3299, 3313, 3314, 3300
9266, 2412, 2426, 2427, 2413, 3300, 3314, 3315, 3301
9267, 2413, 2427, 2428, 2414, 3301, 3315, 3316, 3302
9268, 2414, 2428, 2429, 2415, 3302, 3316, 3317, 3303
9269, 2415, 2429, 2430, 2416, 3303, 3317, 3318, 3304
9270, 2416, 2430, 2431, 2417, 3304, 3318, 3319, 3305
9271, 2417, 2431, 2432, 2418, 3305, 3319, 3320, 3306
9272, 2418, 2432, 542, 541, 3306, 3320, 834, 833
9273, 452, 453, 2433, 2419, 823, 824, 3321, 3307
9274, 2419, 2433, 2434, 2420, 3307, 3321, 3322, 3308
9275, 2420, 2434, 2435, 2421, 3308, 3322, 3323, 3309
9276, 2421, 2435, 2436, 2422, 3309, 3323, 3324, 3310
9277, 2422, 2436, 2437, 2423, 3310, 3324, 3325, 3311
9278, 2423, 2437, 2438, 2424, 3311, 3325, 3326, 3312
9279, 2424, 2438, 2439, 2425, 3312, 3326, 3327, 3313
9280, 2425, 2439, 2440, 2426, 3313, 3327, 3328, 3314
9281, 2426, 2440, 2441, 2427, 3314, 3328, 3329, 3315
9282, 2427, 2441, 2442, 2428, 3315, 3329, 3330, 3316
9283, 2428, 2442, 2443, 2429, 3316, 3330, 3331, 3317
9284, 2429, 2443, 2444, 2430, 3317, 3331, 3332, 3318
9285, 2430, 2444, 2445, 2431, 3318, 3332, 3333, 3319
9286, 2431, 2445, 2446, 2432, 3319, 3333, 3334, 3320
9287, 2432, 2446, 543, 542, 3320, 3334, 835, 834
9288, 453, 454, 2447, 2433, 824, 825, 3335, 3321
9289, 2433, 2447, 2448, 2434, 3321, 3335, 3336, 3322
9290, 2434, 2448, 2449, 2435, 3322, 3336, 3337, 3323
9291, 2435, 2449, 2450, 2436, 3323, 3337, 3338, 3324
9292, 2436, 2450, 2451, 2437, 3324, 3338, 3339, 3325
9293, 2437, 2451, 2452, 2438, 3325, 3339, 3340, 3326
9294, 2438, 2452, 2453, 2439, 3326, 3340, 3341, 3327
9295, 2439, 2453, 2454, 2440, 3327, 3341, 3342, 3328
9296, 2440, 2454, 2455, 2441, 3328, 3342, 3343, 3329
9297, 2441, 2455, 2456, 2442, 3329, 3343, 3344, 3330
9298, 2442, 2456, 2457, 2443, 3330, 3344, 3345, 3331
9299, 2443, 2457, 2458, 2444, 3331, 3345, 3346, 3332
9300, 2444, 2458, 2459, 2445, 3332, 3346, 3347, 3333
9301, 2445, 2459, 2460, 2446, 3333, 3347, 3348, 3334
9302, 2446, 2460, 544, 543, 3334, 3348, 836, 835
9303, 454, 455, 2461, 2447, 825, 826, 3349, 3335
9304, 2447, 2461, 2462, 2448, 3335, 3349, 3350, 3336
9305, 2448, 2462, 2463, 2449, 3336, 3350, 3351, 3337
9306, 2449, 2463, 2464, 2450, 3337, 3351, 3352, 3338
9307, 2450, 2464, 2465, 2451, 3338, 3352, 3353, 3339
9308, 2451, 2465, 2466, 2452, 3339, 3353, 3354, 3340
9309, 2452, 2466, 2467, 2453, 3340, 3354, 3355, 3341
9310, 2453, 2467, 2468, 2454, 3341, 3355, 3356, 3342
9311, 2454, 2468, 2469, 2455, 3342, 3356, 3357, 3343
9312, 2455, 2469, 2470, 2456, 3343, 3357, 3358, 3344
9313, 2456, 2470, 2471, 2457, 3344, 3358, 3359, 3345
9314, 2457, 2471, 2472, 2458, 3345, 3359, 3360, 3346
9315, 2458, 2472, 2473, 2459, 3346, 3360, 3361, 3347
9316, 2459, 2473, 2474, 2460, 3347, 3361, 3362, 3348
9317, 2460, 2474, 545, 544, 3348, 3362, 837, 836
9318, 455, 456, 2475, 2461, 826, 827, 3363, 3349
9319, 2461, 2475, 2476, 2462, 3349, 3363, 3364, 3350
9320, 2462, 2476, 2477, 2463, 3350, 3364, 3365, 3351
9321, 2463, 2477, 2478, 2464, 3351, 3365, 3366, 3352
9322, 2464, 2478, 2479, 2465, 3352, 3366, 3367, 3353
9323, 2465, 2479, 2480, 2466, 3353, 3367, 3368, 3354
9324, 2466, 2480, 2481, 2467, 3354, 3368, 3369, 3355
9325, 2467, 2481, 2482, 2468, 3355, 3369, 3370, 3356
9326, 2468, 2482, 2483, 2469, 3356, 3370, 3371, 3357
9327, 2469, 2483, 2484, 2470, 3357, 3371, 3372, 3358
9328, 2470, 2484, 2485, 2471, 3358, 3372, 3373, 3359
9329, 2471, 2485, 2486, 2472, 3359, 3373, 3374, 3360
9330, 2472, 2486, 2487, 2473, 3360, 3374, 3375, 3361
9331, 2473, 2487, 2488, 2474, 3361, 3375, 3376, 3362
9332, 2474, 2488, 546, 545, 3362, 3376, 838, 837
9333, 456, 457, 2489, 2475, 827, 828, 3377, 3363
9334, 2475, 2489, 2490, 2476, 3363, 3377, 3378, 3364
9335, 2476, 2490, 2491, 2477, 3364, 3378, 3379, 3365
9336, 2477, 2491, 2492, 2478, 3365, 3379, 3380, 3366
9337, 2478, 2492, 2493, 2479, 3366, 3380, 3381, 3367
9338, 2479, 2493, 2494, 2480, 3367, 3381, 3382, 3368
9339, 2480, 2494, 2495, 2481, 3368, 3382, 3383, 3369
9340, 2481, 2495, 2496, 2482, 3369, 3383, 3384, 3370
9341, 2482, 2496, 2497, 2483, 3370, 3384, 3385, 3371
9342, 2483, 2497, 2498, 2484, 3371, 3385, 3386, 3372
9343, 2484, 2498, 2499, 2485, 3372, 3386, 3387, 3373
9344, 2485, 2499, 2500, 2486, 3373, 3387, 3388, 3374
9345, 2486, 2500, 2501, 2487, 3374, 3388, 3389, 3375
9346, 2487, 2501, 2502, 2488, 3375, 3389, 3390, 3376
9347, 2488, 2502, 547, 546, 3376, 3390, 839, 838
9348, 457, 458, 2503, 2489, 828, 829, 3391, 3377
9349, 2489, 2503, 2504, 2490, 3377, 3391, 3392, 3378
9350, 2490, 2504, 2505, 2491, 3378, 3392, 3393, 3379
9351, 2491, 2505, 2506, 2492, 3379, 3393, 3394, 3380
9352, 2492, 2506, 2507, 2493, 3380, 3394, 3395, 3381
9353, 2493, 2507, 2508, 2494, 3381, 3395, 3396, 3382
9354, 2494, 2508, 2509, 2495, 3382, 3396, 3397, 3383
9355, 2495, 2509, 2510, 2496, 3383, 3397, 3398, 3384
9356, 2496, 2510, 2511, 2497, 3384, 3398, 3399, 3385
9357, 2497, 2511, 2512, 2498, 3385, 3399, 3400, 3386
9358, 2498, 2512, 2513, 2499, 3386, 3400, 3401, 3387
9359, 2499, 2513, 2514, 2500, 3387, 3401, 3402, 3388
9360, 2500, 2514, 2515, 2501, 3388, 3402, 3403, 3389
9361, 2501, 2515, 2516, 2502, 3389, 3403, 3404, 3390
9362, 2502, 2516, 548, 547, 3390, 3404, 840, 839
9363, 458, 36, 524, 2503, 829, 71, 805, 3391
9364, 2503, 524, 525, 2504, 3391, 805, 806, 3392
9365, 2504, 525, 526, 2505, 3392, 806, 807, 3393
9366, 2505, 526, 527, 2506, 3393, 807, 808, 3394
9367, 2506, 527, 528, 2507, 3394, 808, 809, 3395
9368, 2507, 528, 529, 2508, 3395, 809, 810, 3396
9369, 2508, 529, 530, 2509, 3396, 810, 811, 3397
9370, 2509, 530, 531, 2510, 3397, 811, 812, 3398
9371, 2510, 531, 532, 2511, 3398, 812, 813, 3399
9372, 2511, 532, 533, 2512, 3399, 813, 814, 3400
9373, 2512, 533, 534, 2513, 3400, 814, 815, 3401
9374, 2513, 534, 535, 2514, 3401, 815, 816, 3402
9375, 2514, 535, 536, 2515, 3402, 816, 817, 3403
9376, 2515, 536, 537, 2516, 3403, 817, 818, 3404
9377, 2516, 537, 40, 548, 3404, 818, 72, 840
*ELEMENT, type=C3D8, ELSET=Volume16
9378, 9, 203, 1423, 180, 59, 675, 2929, 689
9379, 203, 204, 1424, 1423, 675, 676, 2930, 2929
9380, 204, 205, 1425, 1424, 676, 677, 2931, 2930
9381, 205, 206, 1426, 1425, 677, 678, 2932, 2931
9382, 206, 207, 1427, 1426, 678, 679, 2933, 2932
9383, 207, 208, 1428, 1427, 679, 680, 2934, 2933
9384, 208, 209, 1429, 1428, 680, 681, 2935, 2934
9385, 209, 210, 1430, 1429, 681, 682, 2936, 2935
9386, 210, 211, 1431, 1430, 682, 683, 2937, 2936
9387, 211, 212, 1432, 1431, 683, 684, 2938, 2937
9388, 212, 213, 1433, 1432, 684, 685, 2939, 2938
9389, 213, 214, 1434, 1433, 685, 686, 2940, 2939
9390, 214, 215, 1435, 1434, 686, 687, 2941, 2940
9391, 215, 216, 1436, 1435, 687, 688, 2942, 2941
9392, 216, 13, 256, 1436, 688, 60, 695, 2942
9393, 180, 1423, 1437, 181, 689, 2929, 2943, 690
9394, 1423, 1424, 1438, 1437, 2929, 2930, 2944, 2943
9395, 1424, 1425, 1439, 1438, 2930, 2931, 2945, 2944
9396, 1425, 1426, 1440, 1439, 2931, 2932, 2946, 2945
9397, 1426, 1427, 1441, 1440, 2932, 2933, 2947, 2946
9398, 1427, 1428, 1442, 1441, 2933, 2934, 2948, 2947
9399, 1428, 1429, 1443, 1442, 2934, 2935, 2949, 2948
9400, 1429, 1430, 1444, 1443, 2935, 2936, 2950, 2949
9401, 1430, 1431, 1445, 1444, 2936, 2937, 2951, 2950
9402, 1431, 1432, 1446, 1445, 2937, 2938, 2952, 2951
9403, 1432, 1433, 1447, 1446, 2938, 2939, 2953, 2952
9404, 1433, 1434, 1448, 1447, 2939, 2940, 2954, 2953
9405, 1434, 1435, 1449, 1448, 2940, 2941, 2955, 2954
9406, 1435, 1436, 1450, 1449, 2941, 2942, 2956, 2955
9407, 1436, 256, 257, 1450, 2942, 695, 696, 2956
9408, 181, 1437, 1451, 182, 690, 2943, 2957, 691
9409, 1437, 1438, 1452, 1451, 2943, 2944, 2958, 2957
9410, 1438, 1439, 1453, 1452, 2944, 2945, 2959, 2958
9411, 1439, 1440, 1454, 1453, 2945, 2946, 2960, 2959
9412, 1440, 1441, 1455, 1454, 2946, 2947, 2961, 2960
9413, 1441, 1442, 1456, 1455, 2947, 2948, 2962, 2961
9414, 1442, 1443, 1457, 1456, 2948, 2949, 2963, 2962
9415, 1443, 1444, 1458, 1457, 2949, 2950, 2964, 2963
9416, 1444, 1445, 1459, 1458, 2950, 2951, 2965, 2964
9417, 1445, 1446, 1460, 1459, 2951, 2952, 2966, 2965
9418, 1446, 1447, 1461, 1460, 2952, 2953, 2967, 2966
9419, 1447, 1448, 1462, 1461, 2953, 2954, 2968, 2967
9420, 1448, 1449, 1463, 1462, 2954, 2955, 2969, 2968
9421, 1449, 1450, 1464, 1463, 2955, 2956, 2970, 2969
9422, 1450, 257, 258, 1464, 2956, 696, 697, 2970
9423, 182, 1451, 1465, 183, 691, 2957, 2971, 692
9424, 1451, 1452, 1466, 1465, 2957, 2958, 2972, 2971
9425, 1452, 1453, 1467, 1466, 2958, 2959, 2973, 2972
9426, 1453, 1454, 1468, 1467, 2959, 2960, 2974, 2973
9427, 1454, 1455, 1469, 1468, 2960, 2961, 2975, 2974
9428, 1455, 1456, 1470, 1469, 2961, 2962, 2976, 2975
9429, 1456, 1457, 1471, 1470, 2962, 2963, 2977, 2976
9430, 1457, 1458, 1472, 1471, 2963, 2964, 2978, 2977
9431, 1458, 1459, 1473, 1472, 2964, 2965, 2979, 2978
9432, 1459, 1460, 1474, 1473, 2965, 2966, 2980, 2979
9433, 1460, 1461, 1475, 1474, 2966, 2967, 2981, 2980
9434, 1461, 1462, 1476, 1475, 2967, 2968, 2982, 2981
9435, 1462, 1463, 1477, 1476, 2968, 2969, 2983, 2982
9436, 1463, 1464, 1478, 1477, 2969, 2970, 2984, 2983
9437, 1464, 258, 259, 1478, 2970, 697, 698, 2984
9438, 183, 1465, 1479, 184, 692, 2971, 2985, 693
9439, 1465, 1466, 1480, 1479, 2971, 2972, 2986, 2985
9440, 1466, 1467, 1481, 1480, 2972, 2973, 2987, 2986
9441, 1467, 1468, 1482, 1481, 2973, 2974, 2988, 2987
9442, 1468, 1469, 1483, 1482, 2974, 2975, 2989, 2988
9443, 1469, 1470, 1484, 1483, 2975, 2976, 2990, 2989
9444, 1470, 1471, 1485, 1484, 2976, 2977, 2991, 2990
9445, 1471, 1472, 1486, 1485, 2977, 2978, 2992, 2991
9446, 1472, 1473, 1487, 1486, 2978, 2979, 2993, 2992
9447, 1473, 1474, 1488, 1487, 2979, 2980, 2994, 2993
9448, 1474, 1475, 1489, 1488, 2980, 2981, 2995, 2994
9449, 1475, 1476, 1490, 1489, 2981, 2982, 2996, 2995
9450, 1476, 1477, 1491, 1490, 2982, 2983, 2997, 2996
9451, 1477, 1478, 1492, 1491, 2983, 2984, 2998, 2997
9452, 1478, 259, 260, 1492, 2984, 698, 699, 2998
9453, 184, 1479, 1493, 185, 693, 2985, 2999, 694
9454, 1479, 1480, 1494, 1493, 2985, 2986, 3000, 2999
9455, 1480, 1481, 1495, 1494, 2986, 2987, 3001, 3000
9456, 1481, 1482, 1496, 1495, 2987, 2988, 3002, 3001
9457, 1482, 1483, 1497, 1496, 2988, 2989, 3003, 3002
9458, 1483, 1484, 1498, 1497, 2989, 2990, 3004, 3003
9459, 1484, 1485, 1499, 1498, 2990, 2991, 3005, 3004
9460, 1485, 1486, 1500, 1499, 2991, 2992, 3006, 3005
9461, 1486, 1487, 1501, 1500, 2992, 2993, 3007, 3006
9462, 1487, 1488, 1502, 1501, 2993, 2994, 3008, 3007
9463, 1488, 1489, 1503, 1502, 2994, 2995, 3009, 3008
9464, 1489, 1490, 1504, 1503, 2995, 2996, 3010, 3009
9465, 1490, 1491, 1505, 1504, 2996, 2997, 3011, 3010
9466, 1491, 1492, 1506, 1505, 2997, 2998, 3012, 3011
9467, 1492, 260, 261, 1506, 2998, 699, 700, 3012
9468, 185, 1493, 242, 11, 694, 2999, 661, 57
9469, 1493, 1494, 243, 242, 2999, 3000, 662, 661
9470, 1494, 1495, 244, 243, 3000, 3001, 663, 662
9471, 1495, 1496, 245, 244, 3001, 3002, 664, 663
9472, 1496, 1497, 246, 245, 3002, 3003, 665, 664
9473, 1497, 1498, 247, 246, 3003, 3004, 666, 665
9474, 1498, 1499, 248, 247, 3004, 3005, 667, 666
9475, 1499, 1500, 249, 248, 3005, 3006, 668, 667
9476, 1500, 1501, 250, 249, 3006, 3007, 669, 668
9477, 1501, 1502, 251, 250, 3007, 3008, 670, 669
9478, 1502, 1503, 252, 251, 3008, 3009, 671, 670
9479, 1503, 1504, 253, 252, 3009, 3010, 672, 671
9480, 1504, 1505, 254, 253, 3010, 3011, 673, 672
9481, 1505, 1506, 255, 254, 3011, 3012, 674, 673
9482, 1506, 261, 15, 255, 3012, 700, 58, 674
*ELEMENT, type=C3D8, ELSET=Volume17
9483, 35, 510, 2517, 459, 63, 715, 3013, 729
9484, 510, 511, 2518, 2517, 715, 716, 3014, 3013
9485, 511, 512, 2519, 2518, 716, 717, 3015, 3014
9486, 512, 513, 2520, 2519, 717, 718, 3016, 3015
9487, 513, 514, 2521, 2520, 718, 719, 3017, 3016
9488, 514, 515, 2522, 2521, 719, 720, 3018, 3017
9489, 515, 516, 2523, 2522, 720, 721, 3019, 3018
9490, 516, 517, 2524, 2523, 721, 722, 3020, 3019
9491, 517, 518, 2525, 2524, 722, 723, 3021, 3020
9492, 518, 519, 2526, 2525, 723, 724, 3022, 3021
9493, 519, 520, 2527, 2526, 724, 725, 3023, 3022
9494, 520, 521, 2528, 2527, 725, 726, 3024, 3023
9495, 521, 522, 2529, 2528, 726, 727, 3025, 3024
9496, 522, 523, 2530, 2529, 727, 728, 3026, 3025
9497, 523, 39, 549, 2530, 728, 64, 735, 3026
9498, 459, 2517, 2531, 460, 729, 3013, 3027, 730
9499, 2517, 2518, 2532, 2531, 3013, 3014, 3028, 3027
9500, 2518, 2519, 2533, 2532, 3014, 3015, 3029, 3028
9501, 2519, 2520, 2534, 2533, 3015, 3016, 3030, 3029
9502, 2520, 2521, 2535, 2534, 3016, 3017, 3031, 3030
9503, 2521, 2522, 2536, 2535, 3017, 3018, 3032, 3031
9504, 2522, 2523, 2537, 2536, 3018, 3019, 3033, 3032
9505, 2523, 2524, 2538, 2537, 3019, 3020, 3034, 3033
9506, 2524, 2525, 2539, 2538, 3020, 3021, 3035, 3034
9507, 2525, 2526, 2540, 2539, 3021, 3022, 3036, 3035
9508, 2526, 2527, 2541, 2540, 3022, 3023, 3037, 3036
9509, 2527, 2528, 2542, 2541, 3023, 3024, 3038, 3037
9510, 2528, 2529, 2543, 2542, 3024, 3025, 3039, 3038
9511, 2529, 2530, 2544, 2543, 3025, 3026, 3040, 3039
9512, 2530, 549, 550, 2544, 3026, 735, 736, 3040
9513, 460, 2531, 2545, 461, 730, 3027, 3041, 731
9514, 2531, 2532, 2546, 2545, 3027, 3028, 3042, 3041
9515, 2532, 2533, 2547, 2546, 3028, 3029, 3043, 3042
9516, 2533, 2534, 2548, 2547, 3029, 3030, 3044, 3043
9517, 2534, 2535, 2549, 2548, 3030, 3031, 3045, 3044
9518, 2535, 2536, 2550, 2549, 3031, 3032, 3046, 3045
9519, 2536, 2537, 2551, 2550, 3032, 3033, 3047, 3046
9520, 2537, 2538, 2552, 2551, 3033, 3034, 3048, 3047
9521, 2538, 2539, 2553, 2552, 3034, 3035, 3049, 3048
9522, 2539, 2540, 2554, 2553, 3035, 3036, 3050, 3049
9523, 2540, 2541, 2555, 2554, 3036, 3037, 3051, 3050
9524, 2541, 2542, 2556, 2555, 3037, 3038, 3052, 3051
9525, 2542, 2543, 2557, 2556, 3038, 3039, 3053, 3052
9526, 2543, 2544, 2558, 2557, 3039, 3040, 3054, 3053
9527, 2544, 550, 551, 2558, 3040, 736, 737, 3054
9528, 461, 2545, 2559, 462, 731, 3041, 3055, 732
9529, 2545, 2546, 2560, 2559, 3041, 3042, 3056, 3055
9530, 2546, 2547, 2561, 2560, 3042, 3043, 3057, 3056
9531, 2547, 2548, 2562, 2561, 3043, 3044, 3058, 3057
9532, 2548, 2549, 2563, 2562, 3044, 3045, 3059, 3058
9533, 2549, 2550, 2564, 2563, 3045, 3046, 3060, 3059
9534, 2550, 2551, 2565, 2564, 3046, 3047, 3061, 3060
9535, 2551, 2552, 2566, 2565, 3047, 3048, 3062, 3061
9536, 2552, 2553, 2567, 2566, 3048, 3049, 3063, 3062
9537, 2553, 2554, 2568, 2567, 3049, 3050, 3064, 3063
9538, 2554, 2555, 2569, 2568, 3050, 3051, 3065, 3064
9539, 2555, 2556, 2570, 2569, 3051, 3052, 3066, 3065
9540, 2556, 2557, 2571, 2570, 3052, 3053, 3067, 3066
9541, 2557, 2558, 2572, 2571, 3053, 3054, 3068, 3067
9542, 2558, 551, 552, 2572, 3054, 737, 738, 3068
9543, 462, 2559, 2573, 463, 732, 3055, 3069, 733
9544, 2559, 2560, 2574, 2573, 3055, 3056, 3070, 3069
9545, 2560, 2561, 2575, 2574, 3056, 3057, 3071, 3070
9546, 2561, 2562, 2576, 2575, 3057, 3058, 3072, 3071
9547, 2562, 2563, 2577, 2576, 3058, 3059, 3073, 3072
9548, 2563, 2564, 2578, 2577, 3059, 3060, 3074, 3073
9549, 2564, 2565, 2579, 2578, 3060, 3061, 3075, 3074
9550, 2565, 2566, 2580, 2579, 3061, 3062, 3076, 3075
9551, 2566, 2567, 2581, 2580, 3062, 3063, 3077, 3076
9552, 2567, 2568, 2582, 2581, 3063, 3064, 3078, 3077
9553, 2568, 2569, 2583, 2582, 3064, 3065, 3079, 3078
9554, 2569, 2570, 2584, 2583, 3065, 3066, 3080, 3079
9555, 2570, 2571, 2585, 2584, 3066, 3067, 3081, 3080
9556, 2571, 2572, 2586, 2585, 3067, 3068, 3082, 3081
9557, 2572, 552, 553, 2586, 3068, 738, 739, 3082
9558, 463, 2573, 2587, 464, 733, 3069, 3083, 734
9559, 2573, 2574, 2588, 2587, 3069, 3070, 3084, 3083
9560, 2574, 2575, 2589, 2588, 3070, 3071, 3085, 3084
9561, 2575, 2576, 2590, 2589, 3071, 3072, 3086, 3085
9562, 2576, 2577, 2591, 2590, 3072, 3073, 3087, 3086
9563, 2577, 2578, 2592, 2591, 3073, 3074, 3088, 3087
9564, 2578, 2579, 2593, 2592, 3074, 3075, 3089, 3088
9565, 2579, 2580, 2594, 2593, 3075, 3076, 3090, 3089
9566, 2580, 2581, 2595, 2594, 3076, 3077, 3091, 3090
9567, 2581, 2582, 2596, 2595, 3077, 3078, 3092, 3091
9568, 2582, 2583, 2597, 2596, 3078, 3079, 3093, 3092
9569, 2583, 2584, 2598, 2597, 3079, 3080, 3094, 3093
9570, 2584, 2585, 2599, 2598, 3080, 3081, 3095, 3094
9571, 2585, 2586, 2600, 2599, 3081, 3082, 3096, 3095
9572, 2586, 553, 554, 2600, 3082, 739, 740, 3096
9573, 464, 2587, 471, 33, 734, 3083, 701, 61
9574, 2587, 2588, 472, 471, 3083, 3084, 702, 701
9575, 2588, 2589, 473, 472, 3084, 3085, 703, 702
9576, 2589, 2590, 474, 473, 3085, 3086, 704, 703
9577, 2590, 2591, 475, 474, 3086, 3087, 705, 704
9578, 2591, 2592, 476, 475, 3087, 3088, 706, 705
9579, 2592, 2593, 477, 476, 3088, 3089, 707, 706
9580, 2593, 2594, 478, 477, 3089, 3090, 708, 707
9581, 2594, 2595, 479, 478, 3090, 3091, 709, 708
9582, 2595, 2596, 480, 479, 3091, 3092, 710, 709
9583, 2596, 2597, 481, 480, 3092, 3093, 711, 710
9584, 2597, 2598, 482, 481, 3093, 3094, 712, 711
9585, 2598, 2599, 483, 482, 3094, 3095, 713, 712
9586, 2599, 2600, 484, 483, 3095, 3096, 714, 713
9587, 2600, 554, 37, 484, 3096, 740, 62, 714
*ELEMENT, type=C3D8, ELSET=Volume18
9588, 35, 510, 715, 63, 69, 791, 841, 73
9589, 510, 511, 716, 715, 791, 792, 842, 841
9590, 511, 512, 717, 716, 792, 793, 843, 842
9591, 512, 513, 718, 717, 793, 794, 844, 843
9592, 513, 514, 719, 718, 794, 795, 845, 844
9593, 514, 515, 720, 719, 795, 796, 846, 845
9594, 515, 516, 721, 720, 796, 797, 847, 846
9595, 516, 517, 722, 721, 797, 798, 848, 847
9596, 517, 518, 723, 722, 798, 799, 849, 848
9597, 518, 519, 724, 723, 799, 800, 850, 849
9598, 519, 520, 725, 724, 800, 801, 851, 850
9599, 520, 521, 726, 725, 801, 802, 852, 851
9600, 521, 522, 727, 726, 802, 803, 853, 852
9601, 522, 523, 728, 727, 803, 804, 854, 853
9602, 523, 39, 64, 728, 804, 70, 74, 854
*ELEMENT, type=C3D8, ELSET=Volume19
9603, 9, 203, 675, 59, 65, 741, 855, 75
9604, 203, 204, 676, 675, 741, 742, 856, 855
9605, 204, 205, 677, 676, 742, 743, 857, 856
9606, 205, 206, 678, 677, 743, 744, 858, 857
9607, 206, 207, 679, 678, 744, 745, 859, 858
9608, 207, 208, 680, 679, 745, 746, 860, 859
9609, 208, 209, 681, 680, 746, 747, 861, 860
9610, 209, 210, 682, 681, 747, 748, 862, 861
9611, 210, 211, 683, 682, 748, 749, 863, 862
9612, 211, 212, 684, 683, 749, 750, 864, 863
9613, 212, 213, 685, 684, 750, 751, 865, 864
9614, 213, 214, 686, 685, 751, 752, 866, 865
9615, 214, 215, 687, 686, 752, 753, 867, 866
9616, 215, 216, 688, 687, 753, 754, 868, 867
9617, 216, 13, 60, 688, 754, 66, 76, 868
*ELEMENT, type=C3D8, ELSET=Volume20
9618, 22, 359, 1911, 329, 870, 3433, 5929, 3405
9619, 870, 3433, 5929, 3405, 78, 901, 3439, 871
9620, 359, 360, 1912, 1911, 3433, 3434, 5930, 5929
9621, 3433, 3434, 5930, 5929, 901, 902, 3440, 3439
9622, 360, 361, 1913, 1912, 3434, 3435, 5931, 5930
9623, 3434, 3435, 5931, 5930, 902, 903, 3441, 3440
9624, 361, 362, 1914, 1913, 3435, 3436, 5932, 5931
9625, 3435, 3436, 5932, 5931, 903, 904, 3442, 3441
9626, 362, 363, 1915, 1914, 3436, 3437, 5933, 5932
9627, 3436, 3437, 5933, 5932, 904, 905, 3443, 3442
9628, 363, 364, 1916, 1915, 3437, 3438, 5934, 5933
9629, 3437, 3438, 5934, 5933, 905, 906, 3444, 3443
9630, 364, 24, 348, 1916, 3438, 889, 3422, 5934
9631, 3438, 889, 3422, 5934, 906, 80, 890, 3444
9632, 329, 1911, 1917, 330, 3405, 5929, 5935, 3406
9633, 3405, 5929, 5935, 3406, 871, 3439, 3445, 872
9634, 1911, 1912, 1918, 1917, 5929, 5930, 5936, 5935
9635, 5929, 5930, 5936, 5935, 3439, 3440, 3446, 3445
9636, 1912, 1913, 1919, 1918, 5930, 5931, 5937, 5936
9637, 5930, 5931, 5937, 5936, 3440, 3441, 3447, 3446
9638, 1913, 1914, 1920, 1919, 5931, 5932, 5938, 5937
9639, 5931, 5932, 5938, 5937, 3441, 3442, 3448, 3447
9640, 1914, 1915, 1921, 1920, 5932, 5933, 5939, 5938
9641, 5932, 5933, 5939, 5938, 3442, 3443, 3449, 3448
9642, 1915, 1916, 1922, 1921, 5933, 5934, 5940, 5939
9643, 5933, 5934, 5940, 5939, 3443, 3444, 3450, 3449
9644, 1916, 348, 349, 1922, 5934, 3422, 3423, 5940
9645, 5934, 3422, 3423, 5940, 3444, 890, 891, 3450
9646, 330, 1917, 1923, 331, 3406, 5935, 5941, 3407
9647, 3406, 5935, 5941, 3407, 872, 3445, 3451, 873
9648, 1917, 1918, 1924, 1923, 5935, 5936, 5942, 5941
9649, 5935, 5936, 5942, 5941, 3445, 3446, 3452, 3451
9650, 1918, 1919, 1925, 1924, 5936, 5937, 5943, 5942
9651, 5936, 5937, 5943, 5942, 3446, 3447, 3453, 3452
9652, 1919, 1920, 1926, 1925, 5937, 5938, 5944, 5943
9653, 5937, 5938, 5944, 5943, 3447, 3448, 3454, 3453
9654, 1920, 1921, 1927, 1926, 5938, 5939, 5945, 5944
9655, 5938, 5939, 5945, 5944, 3448, 3449, 3455, 3454
9656, 1921, 1922, 1928, 1927, 5939, 5940, 5946, 5945
9657, 5939, 5940, 5946, 5945, 3449, 3450, 3456, 3455
9658, 1922, 349, 350, 1928, 5940, 3423, 3424, 5946
9659, 5940, 3423, 3424, 5946, 3450, 891, 892, 3456
9660, 331, 1923, 1929, 332, 3407, 5941, 5947, 3408
9661, 3407, 5941, 5947, 3408, 873, 3451, 3457, 874
9662, 1923, 1924, 1930, 1929, 5941, 5942, 5948, 5947
9663, 5941, 5942, 5948, 5947, 3451, 3452, 3458, 3457
9664, 1924, 1925, 1931, 1930, 5942, 5943, 5949, 5948
9665, 5942, 5943, 5949, 5948, 3452, 3453, 3459, 3458
9666, 1925, 1926, 1932, 1931, 5943, 5944, 5950, 5949
9667, 5943, 5944, 5950, 5949, 3453, 3454, 3460, 3459
9668, 1926, 1927, 1933, 1932, 5944, 5945, 5951, 5950
9669, 5944, 5945, 5951, 5950, 3454, 3455, 3461, 3460
9670, 1927, 1928, 1934, 1933, 5945, 5946, 5952, 5951
9671, 5945, 5946, 5952, 5951, 3455, 3456, 3462, 3461
9672, 1928, 350, 351, 1934, 5946, 3424, 3425, 5952
9673, 5946, 3424, 3425, 5952, 3456, 892, 893, 3462
9674, 332, 1929, 1935, 333, 3408, 5947, 5953, 3409
9675, 3408, 5947, 5953, 3409, 874, 3457, 3463, 875
9676, 1929, 1930, 1936, 1935, 5947, 5948, 5954, 5953
9677, 5947, 5948, 5954, 5953, 3457, 3458, 3464, 3463
9678, 1930, 1931, 1937, 1936, 5948, 5949, 5955, 5954
9679, 5948, 5949, 5955, 5954, 3458, 3459, 3465, 3464
9680, 1931, 1932, 1938, 1937, 5949, 5950, 5956, 5955
9681, 5949, 5950, 5956, 5955, 3459, 3460, 3466, 3465
9682, 1932, 1933, 1939, 1938, 5950, 5951, 5957, 5956
9683, 5950, 5951, 5957, 5956, 3460, 3461, 3467, 3466
9684, 1933, 1934, 1940, 1939, 5951, 5952, 5958, 5957
9685, 5951, 5952, 5958, 5957, 3461, 3462, 3468, 3467
9686, 1934, 351, 352, 1940, 5952, 3425, 3426, 5958
9687, 5952, 3425, 3426, 5958, 3462, 893, 894, 3468
9688, 333, 1935, 1941, 334, 3409, 5953, 5959, 3410
9689, 3409, 5953, 5959, 3410, 875, 3463, 3469, 876
9690, 1935, 1936, 1942, 1941, 5953, 5954, 5960, 5959
9691, 5953, 5954, 5960, 5959, 3463, 3464, 3470, 3469
9692, 1936, 1937, 1943, 1942, 5954, 5955, 5961, 5960
9693, 5954, 5955, 5961, 5960, 3464, 3465, 3471, 3470
9694, 1937, 1938, 1944, 1943, 5955, 5956, 5962, 5961
9695, 5955, 5956, 5962, 5961, 3465, 3466, 3472, 3471
9696, 1938, 1939, 1945, 1944, 5956, 5957, 5963, 5962
9697, 5956, 5957, 5963, 5962, 3466, 3467, 3473, 3472
9698, 1939, 1940, 1946, 1945, 5957, 5958, 5964, 5963
9699, 5957, 5958, 5964, 5963, 3467, 3468, 3474, 3473
9700, 1940, 352, 353, 1946, 5958, 3426, 3427, 5964
9701, 5958, 3426, 3427, 5964, 3468, 894, 895, 3474
9702, 334, 1941, 1947, 335, 3410, 5959, 5965, 3411
9703, 3410, 5959, 5965, 3411, 876, 3469, 3475, 877
9704, 1941, 1942, 1948, 1947, 5959, 5960, 5966, 5965
9705, 5959, 5960, 5966, 5965, 3469, 3470, 3476, 3475
9706, 1942, 1943, 1949, 1948, 5960, 5961, 5967, 5966
9707, 5960, 5961, 5967, 5966, 3470, 3471, 3477, 3476
9708, 1943, 1944, 1950, 1949, 5961, 5962, 5968, 5967
9709, 5961, 5962, 5968, 5967, 3471, 3472, 3478, 3477
9710, 1944, 1945, 1951, 1950, 5962, 5963, 5969, 5968
9711, 5962, 5963, 5969, 5968, 3472, 3473, 3479, 3478
9712, 1945, 1946, 1952, 1951, 5963, 5964, 5970, 5969
9713, 5963, 5964, 5970, 5969, 3473, 3474, 3480, 3479
9714, 1946, 353, 354, 1952, 5964, 3427, 3428, 5970
9715, 5964, 3427, 3428, 5970, 3474, 895, 896, 3480
9716, 335, 1947, 1953, 336, 3411, 5965, 5971, 3412
9717, 3411, 5965, 5971, 3412, 877, 3475, 3481, 878
9718, 1947, 1948, 1954, 1953, 5965, 5966, 5972, 5971
9719, 5965, 5966, 5972, 5971, 3475, 3476, 3482, 3481
9720, 1948, 1949, 1955, 1954, 5966, 5967, 5973, 5972
9721, 5966, 5967, 5973, 5972, 3476, 3477, 3483, 3482
9722, 1949, 1950, 1956, 1955, 5967, 5968, 5974, 5973
9723, 5967, 5968, 5974, 5973, 3477, 3478, 3484, 3483
9724, 1950, 1951, 1957, 1956, 5968, 5969, 5975, 5974
9725, 5968, 5969, 5975, 5974, 3478, 3479, 3485, 3484
9726, 1951, 1952, 1958, 1957, 5969, 5970, 5976, 5975
9727, 5969, 5970, 5976, 5975, 3479, 3480, 3486, 3485
9728, 1952, 354, 355, 1958, 5970, 3428, 3429, 5976
9729, 5970, 3428, 3429, 5976, 3480, 896, 897, 3486
9730, 336, 1953, 1959, 337, 3412, 5971, 5977, 3413
9731, 3412, 5971, 5977, 3413, 878, 3481, 3487, 879
9732, 1953, 1954, 1960, 1959, 5971, 5972, 5978, 5977
9733, 5971, 5972, 5978, 5977, 3481, 3482, 3488, 3487
9734, 1954, 1955, 1961, 1960, 5972, 5973, 5979, 5978
9735, 5972, 5973, 5979, 5978, 3482, 3483, 3489, 3488
9736, 1955, 1956, 1962, 1961, 5973, 5974, 5980, 5979
9737, 5973, 5974, 5980, 5979, 3483, 3484, 3490, 3489
9738, 1956, 1957, 1963, 1962, 5974, 5975, 5981, 5980
9739, 5974, 5975, 5981, 5980, 3484, 3485, 3491, 3490
9740, 1957, 1958, 1964, 1963, 5975, 5976, 5982, 5981
9741, 5975, 5976, 5982, 5981, 3485, 3486, 3492, 3491
9742, 1958, 355, 356, 1964, 5976, 3429, 3430, 5982
9743, 5976, 3429, 3430, 5982, 3486, 897, 898, 3492
9744, 337, 1959, 1965, 338, 3413, 5977, 5983, 3414
9745, 3413, 5977, 5983, 3414, 879, 3487, 3493, 880
9746, 1959, 1960, 1966, 1965, 5977, 5978, 5984, 5983
9747, 5977, 5978, 5984, 5983, 3487, 3488, 3494, 3493
9748, 1960, 1961, 1967, 1966, 5978, 5979, 5985, 5984
9749, 5978, 5979, 5985, 5984, 3488, 3489, 3495, 3494
9750, 1961, 1962, 1968, 1967, 5979, 5980, 5986, 5985
9751, 5979, 5980, 5986, 5985, 3489, 3490, 3496, 3495
9752, 1962, 1963, 1969, 1968, 5980, 5981, 5987, 5986
9753, 5980, 5981, 5987, 5986, 3490, 3491, 3497, 3496
9754, 1963, 1964, 1970, 1969, 5981, 5982, 5988, 5987
9755, 5981, 5982, 5988, 5987, 3491, 3492, 3498, 3497
9756, 1964, 356, 357, 1970, 5982, 3430, 3431, 5988
9757, 5982, 3430, 3431, 5988, 3492, 898, 899, 3498
9758, 338, 1965, 1971, 339, 3414, 5983, 5989, 3415
9759, 3414, 5983, 5989, 3415, 880, 3493, 3499, 881
9760, 1965, 1966, 1972, 1971, 5983, 5984, 5990, 5989
9761, 5983, 5984, 5990, 5989, 3493, 3494, 3500, 3499
9762, 1966, 1967, 1973, 1972, 5984, 5985, 5991, 5990
9763, 5984, 5985, 5991, 5990, 3494, 3495, 3501, 3500
9764, 1967, 1968, 1974, 1973, 5985, 5986, 5992, 5991
9765, 5985, 5986, 5992, 5991, 3495, 3496, 3502, 3501
