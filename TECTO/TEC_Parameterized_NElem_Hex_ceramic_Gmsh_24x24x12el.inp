41615, 41616, 41617, 41618, 41619, 41620, 41621, 41622, 41623, 41624, 
41625, 41626, 41627, 41628, 41629, 41630, 41631, 41632, 41633, 41634, 
41635, 41636, 41637, 41638, 41639, 41640, 41641, 41642, 41643, 41644, 
41645, 41646, 41647, 41648, 41649, 41650, 41651, 41652, 41653, 41654, 
41655, 41656, 41657, 41658, 41659, 41660, 41661, 41662, 41663, 41664, 
41665, 41666, 41667, 41668, 41669, 41670, 41671, 41672, 41673, 41674, 
41675, 41676, 41677, 41678, 41679, 41680, 41681, 41682, 41683, 41684, 
41685, 41686, 41687, 41688, 41689, 41690, 41691, 41692, 41693, 41694, 
41695, 41696, 41697, 41698, 41699, 41700, 41701, 41702, 41703, 41704, 
41705, 41706, 41707, 41708, 41709, 41710, 41711, 41712, 41713, 41714, 
41715, 41716, 41717, 41718, 41719, 41720, 41721, 41722, 41723, 41724, 
41725, 41726, 41727, 41728, 41729, 41730, 41731, 41732, 41733, 41734, 
41735, 41736, 41737, 41738, 41739, 41740, 41741, 41742, 41743, 41744, 
41745, 41746, 41747, 41748, 41749, 41750, 41751, 41752, 41753, 41754, 
41755, 41756, 41757, 41758, 41759, 41760, 41761, 41762, 41763, 41764, 
41765, 41766, 41767, 41768, 41769, 41770, 41771, 41772, 41773, 41774, 
41775, 41776, 41777, 41778, 41779, 41780, 41781, 41782, 41783, 41784, 
41785, 41786, 41787, 41788, 41789, 41790, 41791, 41792, 41793, 41794, 
41795, 41796, 41797, 41798, 41799, 41800, 41801, 41802, 41803, 41804, 
41805, 41806, 41807, 41808, 41809, 41810, 41811, 41812, 41813, 41814, 
41815, 41816, 41817, 41818, 41819, 41820, 41821, 41822, 41823, 41824, 
41825, 41826, 41827, 41828, 41829, 41830, 41831, 41832, 41833, 41834, 
41835, 41836, 41837, 41838, 41839, 41840, 41841, 41842, 41843, 41844, 
41845, 41846, 41847, 41848, 41849, 41850, 41851, 41852, 41853, 41854, 
41855, 41856, 41857, 41858, 41859, 41860, 41861, 41862, 41863, 41864, 
41865, 41866, 41867, 41868, 41869, 41870, 41871, 41872, 41873, 41874, 
41875, 41876, 41877, 41878, 41879, 41880, 41881, 41882, 41883, 41884, 
41885, 41886, 41887, 41888, 41889, 41890, 41891, 41892, 41893, 41894, 
41895, 41896, 41897, 41898, 41899, 41900, 41901, 41902, 41903, 41904, 
41905, 41906, 41907, 41908, 41909, 41910, 41911, 41912, 41913, 41914, 
41915, 41916, 41917, 41918, 41919, 41920, 41921, 41922, 41923, 41924, 
41925, 41926, 41927, 41928, 41929, 41930, 41931, 41932, 41933, 41934, 
41935, 41936, 41937, 41938, 41939, 41940, 41941, 41942, 41943, 41944, 
41945, 41946, 41947, 41948, 41949, 41950, 41951, 41952, 41953, 41954, 
41955, 41956, 41957, 41958, 41959, 41960, 41961, 41962, 41963, 41964, 
41965, 41966, 41967, 41968, 41969, 41970, 41971, 41972, 41973, 41974, 
41975, 41976, 41977, 41978, 41979, 41980, 41981, 41982, 41983, 41984, 
41985, 41986, 41987, 41988, 41989, 41990, 41991, 41992, 41993, 41994, 
41995, 41996, 41997, 41998, 41999, 42000, 42001, 42002, 42003, 42004, 
42005, 42006, 42007, 42008, 42009, 42010, 42011, 42012, 42013, 42014, 
42015, 42016, 42017, 42018, 42019, 42020, 42021, 42022, 42023, 42024, 
42025, 42026, 42027, 42028, 42029, 42030, 42031, 42032, 42033, 42034, 
42035, 42036, 42037, 42038, 42039, 42040, 42041, 42042, 42043, 42044, 
42045, 42046, 42047, 42048, 42049, 42050, 42051, 42052, 42053, 42054, 
42055, 42056, 42057, 42058, 42059, 42060, 42061, 42062, 42063, 42064, 
42065, 42066, 42067, 42068, 42069, 42070, 42071, 42072, 42073, 42074, 
42075, 42076, 42077, 42078, 42079, 42080, 42081, 42082, 42083, 42084, 
42085, 42086, 42087, 42088, 42089, 42090, 42091, 42092, 42093, 42094, 
42095, 42096, 42097, 42098, 42099, 42100, 42101, 42102, 42103, 42104, 
42105, 42106, 42107, 42108, 42109, 42110, 42111, 42112, 42113, 42114, 
42115, 42116, 42117, 42118, 42119, 42120, 42121, 42122, 42123, 42124, 
42125, 42126, 42127, 42128, 42129, 42130, 42131, 42132, 42133, 42134, 
42135, 42136, 42137, 42138, 42139, 42140, 42141, 42142, 42143, 42144, 
42145, 42146, 42147, 42148, 42149, 42150, 42151, 42152, 42153, 42154, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 617, 618, 619, 620, 
627, 628, 629, 630, 644, 645, 646, 647, 648, 649, 
650, 651, 652, 653, 654, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 
5054, 5055, 5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 
5064, 5065, 5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 
5074, 5075, 5076, 5077, 5078, 5079, 5080, 5081, 5082, 5083, 
5084, 5085, 5086, 5087, 5088, 5089, 5090, 5091, 5092, 5093, 
5094, 5095, 5096, 5097, 5098, 5099, 5100, 5101, 5102, 5103, 
5104, 5105, 5106, 5107, 5108, 5109, 5110, 5111, 5112, 5113, 
5114, 5115, 5116, 5117, 5118, 5119, 5120, 5121, 5122, 5123, 
5124, 5125, 5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 
5134, 5135, 5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 
5144, 5145, 5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 
5154, 5155, 5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 
5164, 5165, 5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 
5174, 5175, 5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 
5184, 5185, 5186, 5187, 5188, 5189, 5190, 5191, 5192, 5193, 
5194, 5195, 5196, 5197, 5198, 5199, 5200, 5201, 5202, 5203, 
5204, 5205, 5206, 5207, 5208, 5209, 5210, 5211, 5212, 5213, 
5214, 5215, 5216, 5217, 5218, 5219, 5220, 5221, 5222, 5223, 
5224, 5225, 5226, 5227, 5228, 5229, 5230, 5231, 5232, 5233, 
5234, 5235, 5236, 5237, 5238, 5239, 5240, 5241, 5242, 5243, 
5244, 5245, 5246, 5247, 5248, 5249, 5250, 5251, 5252, 5253, 
5254, 5255, 5256, 5257, 5258, 5259, 5260, 5261, 5262, 5263, 
5264, 5265, 5266, 5267, 5268, 5269, 5270, 5271, 5272, 5273, 
5274, 5275, 5276, 5277, 5278, 5279, 5280, 5281, 5282, 5283, 
5284, 5285, 5286, 5287, 5288, 5289, 5290, 5291, 5292, 5293, 
5294, 5295, 5296, 5297, 5298, 5359, 5360, 5361, 5362, 5363, 
5364, 5365, 5366, 5367, 5368, 5369, 5370, 5371, 5372, 5373, 
5374, 5375, 5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 
5384, 5385, 5386, 5387, 5388, 5389, 5390, 5391, 5392, 5393, 
5394, 5395, 5396, 5397, 5398, 5399, 5400, 5401, 5402, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 97, 98, 
99, 100, 101, 102, 103, 104, 105, 106, 107, 123, 
124, 125, 126, 127, 128, 129, 130, 131, 132, 133, 
149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 
159, 160, 161, 162, 163, 164, 165, 166, 167, 168, 
169, 170, 171, 172, 173, 174, 175, 176, 177, 178, 
179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 
189, 190, 191, 192, 193, 194, 1073, 1074, 1075, 1076, 
1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 
1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 1100, 
1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 
1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 
1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 
1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 
1141, 1142, 1143, 1144, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 8504, 8505, 8506, 
8507, 8508, 8509, 8510, 8511, 8512, 8513, 8514, 8515, 8516, 
8517, 8518, 8519, 8520, 8521, 8522, 8523, 8524, 8525, 8526, 
8527, 8528, 8529, 8530, 8531, 8532, 8533, 8534, 8535, 8536, 
8537, 8538, 8539, 8540, 8541, 8542, 8543, 8544, 8545, 8546, 
8547, 8548, 8549, 8550, 8551, 8552, 8553, 8554, 8555, 8556, 
8557, 8558, 8559, 8560, 8561, 8562, 8563, 8564, 8565, 8566, 
8567, 8568, 8569, 8570, 8571, 8572, 8573, 8574, 8575, 8576, 
8577, 8578, 8579, 8580, 8581, 8582, 8583, 8584, 8585, 8586, 
8587, 8588, 8589, 8590, 8591, 8592, 8593, 8594, 8595, 8596, 
8597, 8598, 8599, 8600, 8601, 8602, 8603, 8604, 8605, 8606, 
8607, 8608, 8609, 8610, 8611, 8612, 8613, 8614, 8615, 8616, 
8617, 8618, 8619, 8620, 8621, 8622, 8623, 8624, 8625, 8626, 
8627, 8628, 8629, 8630, 8631, 8632, 8633, 8634, 8635, 8636, 
8637, 8638, 8639, 8640, 8641, 8642, 8643, 8644, 8645, 8646, 
8647, 8648, 8649, 8650, 8651, 8652, 8653, 8654, 8655, 8656, 
8657, 8658, 8659, 8660, 8661, 8662, 8663, 8664, 8665, 8666, 
8667, 8668, 8669, 8670, 8671, 8672, 8673, 8674, 8675, 8676, 
8677, 8678, 8679, 8680, 8681, 8682, 8683, 8684, 8685, 8686, 
8687, 8688, 8689, 8690, 8691, 8692, 8693, 8694, 8695, 8696, 
8697, 8698, 8699, 8700, 8701, 8702, 8703, 8704, 8705, 8706, 
8707, 8708, 8709, 8710, 8711, 8712, 8713, 8714, 8715, 8716, 
8717, 8718, 8719, 8720, 8721, 8722, 8723, 8724, 8725, 8726, 
8727, 8728, 8729, 8730, 8731, 8732, 8733, 8734, 8735, 8736, 
8737, 8738, 8739, 8740, 8741, 8742, 8743, 8744, 8745, 8746, 
8747, 8748, 8749, 8750, 8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 1145, 1146, 1147, 1148, 1149, 1150, 
1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 
1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 
8757, 8758, 8759, 8760, 8761, 8762, 8763, 8764, 8765, 8766, 
8767, 8768, 8769, 8770, 8771, 8772, 8773, 8774, 8775, 8776, 
8777, 8778, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 1171, 1172, 1173, 1174, 1175, 1176, 
1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 
1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 
8779, 8780, 8781, 8782, 8783, 8784, 8785, 8786, 8787, 8788, 
8789, 8790, 8791, 8792, 8793, 8794, 8795, 8796, 8797, 8798, 
8799, 8800, 
*NSET,NSET=Force
18, 20, 22, 24, 526, 527, 528, 529, 530, 531, 
532, 533, 534, 535, 536, 539, 540, 577, 578, 602, 
603, 604, 605, 606, 607, 608, 609, 610, 611, 612, 
5024, 5025, 5026, 5027, 5028, 5029, 5030, 5031, 5032, 5033, 
5034, 5035, 5036, 5037, 5038, 5039, 5040, 5041, 5042, 5043, 
5044, 5045, 
*NSET,NSET=Ceramic_Top
77, 78, 79, 80, 81, 82, 83, 84, 1571, 1572, 
1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 
1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 
1593, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1651, 1652, 1653, 1654, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1678, 1679, 1680, 1681, 1682, 
1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 
1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 10637, 10638, 10639, 10640, 10641, 10642, 10643, 10644, 
10645, 10646, 10647, 10648, 10649, 10650, 10651, 10652, 10653, 10654, 
10655, 10656, 10657, 10658, 10659, 10660, 10661, 10662, 10663, 10664, 
10665, 10666, 10667, 10668, 10669, 10670, 10671, 10672, 10673, 10674, 
10675, 10676, 10677, 10678, 10679, 10680, 10681, 10682, 10683, 10684, 
10685, 10686, 10687, 10688, 10689, 10690, 10691, 10692, 10693, 10694, 
10695, 10696, 10697, 10698, 10699, 10700, 10701, 10702, 10703, 10704, 
10705, 10706, 10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 
10715, 10716, 10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 
10725, 10726, 10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 
10735, 10736, 10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 
10745, 10746, 10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 
10755, 10756, 10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 
10765, 10766, 10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 
10775, 10776, 10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 
10785, 10786, 10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 
10795, 10796, 10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 
10805, 10806, 10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 
10815, 10816, 10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 
10825, 10826, 10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 
10835, 10836, 10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 
10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 
10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 
10865, 10866, 10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 
10875, 10876, 10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 
10885, 10886, 10887, 10888, 10889, 10966, 10967, 10968, 10969, 10970, 
10971, 10972, 10973, 10974, 10975, 10976, 10977, 10978, 10979, 10980, 
10981, 10982, 10983, 10984, 10985, 10986, 10987, 10988, 10989, 10990, 
10991, 10992, 10993, 10994, 10995, 10996, 10997, 10998, 10999, 11000, 
11001, 11002, 11003, 11004, 11005, 11006, 11007, 11008, 11009, 11238, 
11239, 11240, 11241, 11242, 11243, 11244, 11245, 11246, 11247, 11248, 
11249, 11250, 11251, 11252, 11253, 11254, 11255, 11256, 11257, 11258, 
11259, 11260, 11261, 11262, 11263, 11264, 11265, 11266, 11267, 11268, 
11269, 11270, 11271, 11272, 11273, 11274, 11275, 11276, 11277, 11278, 
11279, 11280, 11281, 11282, 11283, 11284, 11285, 11286, 11287, 11288, 
11289, 11290, 11291, 11292, 11293, 11294, 11295, 11296, 11297, 11298, 
11299, 11300, 11301, 11302, 11303, 11304, 11305, 11306, 11307, 11308, 
11309, 11310, 11311, 11312, 11313, 11314, 11315, 11316, 11317, 11318, 
11319, 11320, 11321, 11322, 11323, 11324, 11325, 11326, 11327, 11328, 
11329, 11330, 11331, 11332, 11333, 11334, 11335, 11336, 11337, 11338, 
11339, 11340, 11341, 11342, 11343, 11344, 11345, 11346, 11347, 11348, 
11349, 11350, 11351, 11352, 11353, 11354, 11355, 11356, 11357, 11358, 
11359, 11360, 11361, 11362, 11363, 11364, 11365, 11366, 11367, 11368, 
11369, 11370, 11371, 11372, 11373, 11374, 11375, 11376, 11377, 11378, 
11379, 11380, 11381, 11382, 11383, 11384, 11385, 11386, 11387, 11388, 
11389, 11390, 11391, 11392, 11393, 11394, 11395, 11396, 11397, 11398, 
11399, 11400, 11401, 11402, 11403, 11404, 11405, 11406, 11407, 11408, 
11409, 11410, 11411, 11412, 11413, 11414, 11415, 11416, 11417, 11418, 
11419, 11420, 11421, 11422, 11423, 11424, 11425, 11426, 11427, 11428, 
11429, 11430, 11431, 11432, 11433, 11434, 11435, 11436, 11437, 11438, 
11439, 11440, 11441, 11442, 11443, 11444, 11445, 11446, 11447, 11448, 
11449, 11450, 11451, 11452, 11453, 11454, 11455, 11456, 11457, 11458, 
11459, 11460, 11461, 11462, 11463, 11464, 11465, 11466, 11467, 11468, 
11469, 11470, 11471, 11472, 11473, 11474, 11475, 11476, 11477, 11478, 
11479, 11480, 11481, 11482, 11483, 11484, 11485, 11486, 11487, 11488, 
11489, 11490, 
*NSET,NSET=Ceramic_Bottom
23, 26, 79, 81, 85, 86, 87, 88, 91, 92, 
93, 94, 617, 618, 619, 620, 1594, 1595, 1596, 1597, 
1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 1747, 1748, 
1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 
1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 
1769, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 
1783, 1784, 1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 
1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 
1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 1815, 1816, 
1817, 1818, 1819, 1820, 1821, 1822, 1850, 1851, 1852, 1853, 
1854, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 
1864, 1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1881, 
1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 1891, 
1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 1901, 
1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 
1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 1921, 
1922, 1923, 1924, 1925, 10890, 10891, 10892, 10893, 10894, 10895, 
10896, 10897, 10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 
11763, 11764, 11765, 11766, 11767, 11768, 11769, 11770, 11771, 11772, 
11773, 11774, 11775, 11776, 11777, 11778, 11779, 11780, 11781, 11782, 
11783, 11784, 11785, 11786, 11787, 11788, 11789, 11790, 11791, 11792, 
11793, 11794, 11795, 11796, 11797, 11798, 11799, 11800, 11801, 11802, 
11803, 11804, 11805, 11806, 11807, 11808, 11809, 11810, 11811, 11812, 
11813, 11814, 11815, 11816, 11817, 11818, 11819, 11820, 11821, 11822, 
11823, 11824, 11825, 11826, 11827, 11828, 11829, 11830, 11831, 11832, 
11833, 11834, 11835, 11836, 11837, 11838, 11839, 11840, 11841, 11842, 
11843, 11844, 11845, 11846, 11847, 11848, 11849, 11850, 11851, 11852, 
11853, 11854, 11855, 11856, 11857, 11858, 11859, 11860, 11861, 11862, 
11863, 11864, 11865, 11866, 11867, 11868, 11869, 11870, 11871, 11872, 
11873, 11874, 11875, 11876, 11877, 11878, 11879, 11880, 11881, 11882, 
11883, 11884, 11885, 11886, 11887, 11888, 11889, 11890, 11891, 11892, 
11893, 11894, 11895, 11896, 11897, 11898, 11899, 11900, 11901, 11902, 
11903, 11904, 11905, 11906, 11907, 11908, 11909, 11910, 11911, 11912, 
11913, 11914, 11915, 11916, 11917, 11918, 11919, 11920, 11921, 11922, 
11923, 11924, 11925, 11926, 11927, 11928, 11929, 11930, 11931, 11932, 
11933, 11934, 11935, 11936, 11937, 11938, 11939, 11940, 11941, 11942, 
11943, 11944, 11945, 11946, 11947, 11948, 11949, 11950, 11951, 11952, 
11953, 11954, 11955, 11956, 11957, 11958, 11959, 11960, 11961, 11962, 
11963, 11964, 11965, 11966, 11967, 11968, 11969, 11970, 11971, 11972, 
11973, 11974, 11975, 11976, 11977, 11978, 11979, 11980, 11981, 11982, 
11983, 11984, 11985, 11986, 11987, 11988, 11989, 11990, 11991, 11992, 
11993, 11994, 11995, 11996, 11997, 11998, 11999, 12000, 12001, 12002, 
12003, 12004, 12005, 12006, 12007, 12008, 12009, 12010, 12011, 12012, 
12013, 12014, 12015, 12332, 12333, 12334, 12335, 12336, 12337, 12338, 
12339, 12340, 12341, 12342, 12343, 12344, 12345, 12346, 12347, 12348, 
12349, 12350, 12351, 12352, 12353, 12354, 12355, 12356, 12357, 12358, 
12359, 12360, 12361, 12362, 12363, 12364, 12365, 12366, 12367, 12368, 
12369, 12370, 12371, 12372, 12373, 12374, 12375, 12376, 12377, 12378, 
12379, 12380, 12381, 12382, 12383, 12384, 12385, 12386, 12387, 12388, 
12389, 12390, 12391, 12392, 12393, 12394, 12395, 12396, 12397, 12398, 
12399, 12400, 12401, 12402, 12403, 12404, 12405, 12406, 12407, 12408, 
12409, 12410, 12411, 12412, 12413, 12414, 12415, 12416, 12417, 12418, 
12419, 12420, 12421, 12422, 12423, 12424, 12425, 12426, 12427, 12428, 
12429, 12430, 12431, 12432, 12433, 12434, 12435, 12436, 12437, 12438, 
12439, 12440, 12441, 12442, 12443, 12444, 12445, 12446, 12447, 12448, 
12449, 12450, 12451, 12452, 12453, 12454, 12455, 12456, 12457, 12458, 
12459, 12460, 12461, 12462, 12463, 12464, 12465, 12466, 12467, 12468, 
12469, 12470, 12471, 12472, 12473, 12474, 12475, 12476, 12477, 12478, 
12479, 12480, 12481, 12482, 12483, 12484, 12485, 12486, 12487, 12488, 
12489, 12490, 12491, 12492, 12493, 12494, 12495, 12496, 12497, 12498, 
12499, 12500, 12501, 12502, 12503, 12504, 12505, 12506, 12507, 12508, 
12509, 12510, 12511, 12512, 12513, 12514, 12515, 12516, 12517, 12518, 
12519, 12520, 12521, 12522, 12523, 12524, 12525, 12526, 12527, 12528, 
12529, 12530, 12531, 12532, 12533, 12534, 12535, 12536, 12537, 12538, 
12539, 12540, 12541, 12542, 12543, 12544, 12545, 12546, 12547, 12548, 
12549, 12550, 12551, 12552, 12553, 12554, 12555, 12556, 12557, 12558, 
12559, 12560, 12561, 12562, 12563, 12564, 12565, 12566, 12567, 12568, 
12569, 12570, 12571, 12572, 12573, 12574, 12575, 12576, 12577, 12578, 
12579, 12580, 12581, 12582, 12583, 12584, 
*NSET,NSET=Top_Semiconductors
13, 14, 15, 16, 33, 34, 35, 36, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 401, 402, 403, 404, 405, 406, 407, 408, 409, 
410, 411, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 773, 774, 775, 776, 
777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 
787, 788, 789, 790, 791, 792, 793, 794, 795, 796, 
797, 798, 799, 800, 801, 802, 803, 804, 805, 806, 
807, 808, 809, 810, 811, 812, 813, 814, 815, 816, 
817, 818, 819, 820, 821, 822, 823, 824, 825, 826, 
827, 828, 829, 830, 831, 832, 833, 834, 835, 836, 
837, 838, 839, 840, 4404, 4405, 4406, 4407, 4408, 4409, 
4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 
4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 
4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 
4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 
4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 
4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 
4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 
4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 
4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 
4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 
4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 
4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 
4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 4539, 
4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 4549, 
4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 4559, 
4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 4569, 
4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 4579, 
4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 4589, 
4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 4599, 
4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 4609, 
4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 4619, 
4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 4629, 
4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 4639, 
4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 4649, 
4650, 4651, 4652, 4653, 4654, 4655, 4656, 6045, 6046, 6047, 
6048, 6049, 6050, 6051, 6052, 6053, 6054, 6055, 6056, 6057, 
6058, 6059, 6060, 6061, 6062, 6063, 6064, 6065, 6066, 6067, 
6068, 6069, 6070, 6071, 6072, 6073, 6074, 6075, 6076, 6077, 
6078, 6079, 6080, 6081, 6082, 6083, 6084, 6085, 6086, 6087, 
6088, 6089, 6090, 6091, 6092, 6093, 6094, 6095, 6096, 6097, 
6098, 6099, 6100, 6101, 6102, 6103, 6104, 6105, 6106, 6107, 
6108, 6109, 6110, 6111, 6112, 6113, 6114, 6115, 6116, 6117, 
6118, 6119, 6120, 6121, 6122, 6123, 6124, 6125, 6126, 6127, 
6128, 6129, 6130, 6131, 6132, 6133, 6134, 6135, 6136, 6137, 
6138, 6139, 6140, 6141, 6142, 6143, 6144, 6145, 6146, 6147, 
6148, 6149, 6150, 6151, 6152, 6153, 6154, 6155, 6156, 6157, 
6158, 6159, 6160, 6161, 6162, 6163, 6164, 6165, 6166, 6167, 
6168, 6169, 6170, 6171, 6172, 6173, 6174, 6175, 6176, 6177, 
6178, 6179, 6180, 6181, 6182, 6183, 6184, 6185, 6186, 6187, 
6188, 6189, 6190, 6191, 6192, 6193, 6194, 6195, 6196, 6197, 
6198, 6199, 6200, 6201, 6202, 6203, 6204, 6205, 6206, 6207, 
6208, 6209, 6210, 6211, 6212, 6213, 6214, 6215, 6216, 6217, 
6218, 6219, 6220, 6221, 6222, 6223, 6224, 6225, 6226, 6227, 
6228, 6229, 6230, 6231, 6232, 6233, 6234, 6235, 6236, 6237, 
6238, 6239, 6240, 6241, 6242, 6243, 6244, 6245, 6246, 6247, 
6248, 6249, 6250, 6251, 6252, 6253, 6254, 6255, 6256, 6257, 
6258, 6259, 6260, 6261, 6262, 6263, 6264, 6265, 6266, 6267, 
6268, 6269, 6270, 6271, 6272, 6273, 6274, 6275, 6276, 6277, 
6278, 6279, 6280, 6281, 6282, 6283, 6284, 6285, 6286, 6287, 
6288, 6289, 6290, 6291, 6292, 6293, 6294, 6295, 6296, 6297, 
*NSET,NSET=top
77, 78, 79, 80, 81, 82, 83, 84, 1571, 1572, 
1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 
1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 
1593, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1651, 1652, 1653, 1654, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1678, 1679, 1680, 1681, 1682, 
1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 
1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 10637, 10638, 10639, 10640, 10641, 10642, 10643, 10644, 
10645, 10646, 10647, 10648, 10649, 10650, 10651, 10652, 10653, 10654, 
10655, 10656, 10657, 10658, 10659, 10660, 10661, 10662, 10663, 10664, 
10665, 10666, 10667, 10668, 10669, 10670, 10671, 10672, 10673, 10674, 
10675, 10676, 10677, 10678, 10679, 10680, 10681, 10682, 10683, 10684, 
10685, 10686, 10687, 10688, 10689, 10690, 10691, 10692, 10693, 10694, 
10695, 10696, 10697, 10698, 10699, 10700, 10701, 10702, 10703, 10704, 
10705, 10706, 10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 
10715, 10716, 10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 
10725, 10726, 10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 
10735, 10736, 10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 
10745, 10746, 10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 
10755, 10756, 10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 
10765, 10766, 10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 
10775, 10776, 10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 
10785, 10786, 10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 
10795, 10796, 10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 
10805, 10806, 10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 
10815, 10816, 10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 
10825, 10826, 10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 
10835, 10836, 10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 
10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 
10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 
10865, 10866, 10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 
10875, 10876, 10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 
10885, 10886, 10887, 10888, 10889, 10966, 10967, 10968, 10969, 10970, 
10971, 10972, 10973, 10974, 10975, 10976, 10977, 10978, 10979, 10980, 
10981, 10982, 10983, 10984, 10985, 10986, 10987, 10988, 10989, 10990, 
10991, 10992, 10993, 10994, 10995, 10996, 10997, 10998, 10999, 11000, 
11001, 11002, 11003, 11004, 11005, 11006, 11007, 11008, 11009, 11238, 
11239, 11240, 11241, 11242, 11243, 11244, 11245, 11246, 11247, 11248, 
11249, 11250, 11251, 11252, 11253, 11254, 11255, 11256, 11257, 11258, 
11259, 11260, 11261, 11262, 11263, 11264, 11265, 11266, 11267, 11268, 
11269, 11270, 11271, 11272, 11273, 11274, 11275, 11276, 11277, 11278, 
11279, 11280, 11281, 11282, 11283, 11284, 11285, 11286, 11287, 11288, 
11289, 11290, 11291, 11292, 11293, 11294, 11295, 11296, 11297, 11298, 
11299, 11300, 11301, 11302, 11303, 11304, 11305, 11306, 11307, 11308, 
11309, 11310, 11311, 11312, 11313, 11314, 11315, 11316, 11317, 11318, 
11319, 11320, 11321, 11322, 11323, 11324, 11325, 11326, 11327, 11328, 
11329, 11330, 11331, 11332, 11333, 11334, 11335, 11336, 11337, 11338, 
11339, 11340, 11341, 11342, 11343, 11344, 11345, 11346, 11347, 11348, 
11349, 11350, 11351, 11352, 11353, 11354, 11355, 11356, 11357, 11358, 
11359, 11360, 11361, 11362, 11363, 11364, 11365, 11366, 11367, 11368, 
11369, 11370, 11371, 11372, 11373, 11374, 11375, 11376, 11377, 11378, 
11379, 11380, 11381, 11382, 11383, 11384, 11385, 11386, 11387, 11388, 
11389, 11390, 11391, 11392, 11393, 11394, 11395, 11396, 11397, 11398, 
11399, 11400, 11401, 11402, 11403, 11404, 11405, 11406, 11407, 11408, 
11409, 11410, 11411, 11412, 11413, 11414, 11415, 11416, 11417, 11418, 
11419, 11420, 11421, 11422, 11423, 11424, 11425, 11426, 11427, 11428, 
11429, 11430, 11431, 11432, 11433, 11434, 11435, 11436, 11437, 11438, 
11439, 11440, 11441, 11442, 11443, 11444, 11445, 11446, 11447, 11448, 
11449, 11450, 11451, 11452, 11453, 11454, 11455, 11456, 11457, 11458, 
11459, 11460, 11461, 11462, 11463, 11464, 11465, 11466, 11467, 11468, 
11469, 11470, 11471, 11472, 11473, 11474, 11475, 11476, 11477, 11478, 
11479, 11480, 11481, 11482, 11483, 11484, 11485, 11486, 11487, 11488, 
11489, 11490, 
*NSET,NSET=bottom
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 
1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 
1765, 1766, 1767, 1768, 1769, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1789, 1790, 1791, 1792, 
1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 
1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 
1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 
1831, 1832, 1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 
1841, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 
1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 
1869, 1870, 1871, 1872, 1881, 1882, 1883, 1884, 1885, 1886, 
1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 1895, 1896, 
1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 1905, 1906, 
1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 1915, 1916, 
1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 1925, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
11763, 11764, 11765, 11766, 11767, 11768, 11769, 11770, 11771, 11772, 
11773, 11774, 11775, 11776, 11777, 11778, 11779, 11780, 11781, 11782, 
11783, 11784, 11785, 11786, 11787, 11788, 11789, 11790, 11791, 11792, 
11793, 11794, 11795, 11796, 11797, 11798, 11799, 11800, 11801, 11802, 
11803, 11804, 11805, 11806, 11807, 11808, 11809, 11810, 11811, 11812, 
11813, 11814, 11815, 11816, 11817, 11818, 11819, 11820, 11821, 11822, 
11823, 11824, 11825, 11826, 11827, 11828, 11829, 11830, 11831, 11832, 
11833, 11834, 11835, 11836, 11837, 11838, 11839, 11840, 11841, 11842, 
11843, 11844, 11845, 11846, 11847, 11848, 11849, 11850, 11851, 11852, 
11853, 11854, 11855, 11856, 11857, 11858, 11859, 11860, 11861, 11862, 
11863, 11864, 11865, 11866, 11867, 11868, 11869, 11870, 11871, 11872, 
11873, 11874, 11875, 11876, 11877, 11878, 11879, 11880, 11881, 11882, 
11883, 11884, 11885, 11886, 11887, 11888, 11889, 11890, 11891, 11892, 
11893, 11894, 11895, 11896, 11897, 11898, 11899, 11900, 11901, 11902, 
11903, 11904, 11905, 11906, 11907, 11908, 11909, 11910, 11911, 11912, 
11913, 11914, 11915, 11916, 11917, 11918, 11919, 11920, 11921, 11922, 
11923, 11924, 11925, 11926, 11927, 11928, 11929, 11930, 11931, 11932, 
11933, 11934, 11935, 11936, 11937, 11938, 11939, 11940, 11941, 11942, 
11943, 11944, 11945, 11946, 11947, 11948, 11949, 11950, 11951, 11952, 
11953, 11954, 11955, 11956, 11957, 11958, 11959, 11960, 11961, 11962, 
11963, 11964, 11965, 11966, 11967, 11968, 11969, 11970, 11971, 11972, 
11973, 11974, 11975, 11976, 11977, 11978, 11979, 11980, 11981, 11982, 
11983, 11984, 11985, 11986, 11987, 11988, 11989, 11990, 11991, 11992, 
11993, 11994, 11995, 11996, 11997, 11998, 11999, 12000, 12001, 12002, 
12003, 12004, 12005, 12006, 12007, 12008, 12009, 12010, 12011, 12012, 
12013, 12014, 12015, 12332, 12333, 12334, 12335, 12336, 12337, 12338, 
12339, 12340, 12341, 12342, 12343, 12344, 12345, 12346, 12347, 12348, 
12349, 12350, 12351, 12352, 12353, 12354, 12355, 12356, 12357, 12358, 
12359, 12360, 12361, 12362, 12363, 12364, 12365, 12366, 12367, 12368, 
12369, 12370, 12371, 12372, 12373, 12374, 12375, 12376, 12377, 12378, 
12379, 12380, 12381, 12382, 12383, 12384, 12385, 12386, 12387, 12388, 
12389, 12390, 12391, 12392, 12393, 12394, 12395, 12396, 12397, 12398, 
12399, 12400, 12401, 12402, 12403, 12404, 12405, 12406, 12407, 12408, 
12409, 12410, 12411, 12412, 12413, 12414, 12415, 12416, 12417, 12418, 
12419, 12420, 12421, 12422, 12423, 12424, 12425, 12426, 12427, 12428, 
12429, 12430, 12431, 12432, 12433, 12434, 12435, 12436, 12437, 12438, 
12439, 12440, 12441, 12442, 12443, 12444, 12445, 12446, 12447, 12448, 
12449, 12450, 12451, 12452, 12453, 12454, 12455, 12456, 12457, 12458, 
12459, 12460, 12461, 12462, 12463, 12464, 12465, 12466, 12467, 12468, 
12469, 12470, 12471, 12472, 12473, 12474, 12475, 12476, 12477, 12478, 
12479, 12480, 12481, 12482, 12483, 12484, 12485, 12486, 12487, 12488, 
12489, 12490, 12491, 12492, 12493, 12494, 12495, 12496, 12497, 12498, 
12499, 12500, 12501, 12502, 12503, 12504, 12505, 12506, 12507, 12508, 
12509, 12510, 12511, 12512, 12513, 12514, 12515, 12516, 12517, 12518, 
12519, 12520, 12521, 12522, 12523, 12524, 12525, 12526, 12527, 12528, 
12529, 12530, 12531, 12532, 12533, 12534, 12535, 12536, 12537, 12538, 
12539, 12540, 12541, 12542, 12543, 12544, 12545, 12546, 12547, 12548, 
12549, 12550, 12551, 12552, 12553, 12554, 12555, 12556, 12557, 12558, 
12559, 12560, 12561, 12562, 12563, 12564, 12565, 12566, 12567, 12568, 
12569, 12570, 12571, 12572, 12573, 12574, 12575, 12576, 12577, 12578, 
12579, 12580, 12581, 12582, 12583, 12584, 
*NSET,NSET=symmetry
1, 3, 5, 7, 11, 12, 15, 16, 19, 20, 
23, 24, 25, 26, 29, 30, 33, 34, 37, 38, 
41, 42, 45, 46, 49, 50, 53, 55, 57, 58, 
61, 62, 79, 80, 81, 83, 87, 88, 89, 91, 
92, 95, 108, 109, 134, 135, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 218, 
219, 220, 221, 222, 223, 224, 225, 226, 227, 228, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 275, 276, 277, 278, 279, 280, 281, 282, 
283, 284, 285, 286, 287, 288, 289, 290, 291, 292, 
293, 294, 295, 296, 297, 378, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 412, 413, 
414, 415, 416, 417, 418, 419, 420, 421, 422, 423, 
424, 425, 426, 427, 428, 429, 430, 431, 432, 433, 
434, 435, 436, 437, 438, 439, 440, 441, 442, 443, 
444, 445, 446, 447, 448, 449, 450, 451, 452, 453, 
454, 455, 456, 457, 503, 504, 505, 506, 507, 508, 
509, 510, 511, 512, 513, 514, 515, 516, 517, 518, 
519, 520, 521, 522, 523, 524, 525, 564, 565, 577, 
578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 
588, 589, 590, 591, 592, 593, 594, 595, 596, 597, 
598, 599, 600, 601, 613, 614, 615, 616, 617, 618, 
619, 620, 621, 622, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 773, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 841, 842, 843, 844, 845, 
846, 847, 848, 849, 850, 851, 852, 853, 854, 855, 
856, 857, 858, 859, 860, 861, 862, 863, 864, 865, 
866, 867, 868, 869, 870, 871, 872, 873, 874, 875, 
876, 877, 878, 879, 880, 881, 882, 883, 884, 885, 
886, 887, 888, 889, 890, 891, 892, 893, 894, 895, 
896, 897, 898, 899, 900, 901, 902, 903, 904, 905, 
906, 907, 908, 909, 1001, 1002, 1003, 1004, 1005, 1006, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1019, 1020, 1021, 1022, 1023, 1069, 1070, 1071, 
1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 
1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 
1092, 1093, 1094, 1095, 1145, 1146, 1182, 1183, 1197, 1198, 
1199, 1200, 1201, 1202, 1203, 1204, 1205, 1206, 1207, 1208, 
1209, 1210, 1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218, 
1219, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 
1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 
1284, 1285, 1286, 1287, 1594, 1595, 1596, 1597, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1647, 1648, 1649, 1650, 1651, 
1652, 1653, 1654, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1770, 1771, 1772, 1773, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 
1811, 1823, 1824, 1825, 1826, 1842, 1843, 1844, 1845, 1846, 
1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 
1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 
1867, 1868, 1869, 1870, 1871, 1872, 1926, 1927, 1928, 1929, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 3622, 3623, 3624, 3625, 
3626, 3627, 3628, 3629, 3630, 3631, 3632, 3633, 3634, 3635, 
3636, 3637, 3638, 3639, 3640, 3641, 3642, 3643, 3644, 3645, 
3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 3655, 
3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 3665, 
3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 3675, 
3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 3685, 
3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 
3696, 3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 3705, 
3706, 3707, 3708, 3709, 3710, 3711, 3712, 3713, 3714, 3715, 
3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724, 3725, 
3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 3735, 
3736, 3737, 3738, 3739, 3740, 3741, 3742, 3743, 3744, 3745, 
3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 3755, 
3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 3765, 
3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 3775, 
3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 3785, 
3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 3795, 
3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 3805, 
3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 3815, 
3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 3825, 
3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 3835, 
3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 3845, 
3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 
3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 
3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 
3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 
3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 
3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 3905, 
3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 3915, 
3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 3925, 
3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 
3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 3945, 
3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 3955, 
3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 3965, 
3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 3975, 
3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 3985, 
3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 3995, 
3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 4005, 
4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 4015, 
4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 4025, 
4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 4035, 
4036, 4037, 4038, 4039, 4040, 4041, 4042, 4043, 4044, 4045, 
4046, 4047, 4048, 4049, 4050, 4051, 4052, 4053, 4054, 4055, 
4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 
4066, 4067, 4068, 4069, 4070, 4071, 4072, 4073, 4074, 4075, 
4076, 4077, 4078, 4079, 4080, 4081, 4082, 4083, 4084, 4085, 
4086, 4087, 4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 
4096, 4097, 4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 
4106, 4107, 4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 
4116, 4117, 4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 
4126, 4127, 4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 
4136, 4137, 4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 
4146, 4147, 4148, 4149, 4150, 4978, 4979, 4980, 4981, 4982, 
4983, 4984, 4985, 4986, 4987, 4988, 4989, 4990, 4991, 4992, 
4993, 4994, 4995, 4996, 4997, 4998, 4999, 5000, 5001, 5002, 
5003, 5004, 5005, 5006, 5007, 5008, 5009, 5010, 5011, 5012, 
5013, 5014, 5015, 5016, 5017, 5018, 5019, 5020, 5021, 5022, 
5023, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 5425, 
5426, 5427, 5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 
5436, 5437, 5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 
5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 
5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 
5466, 5467, 5468, 5469, 5470, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 6322, 
6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 6332, 
6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 6342, 
6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 6352, 
6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 6362, 
6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 
6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 
6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 
6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 
6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 
6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 
6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 6432, 
6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 
6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 
6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 
6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 
6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 6482, 
6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 6491, 6492, 
6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 6501, 6502, 
6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 6511, 6512, 
6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 6521, 6522, 
6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 6531, 6532, 
6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 6541, 6542, 
6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 6551, 6552, 
6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 6561, 6562, 
6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 6571, 6572, 
6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 6581, 6582, 
6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 6591, 6592, 
6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 6601, 6602, 
6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 6611, 6612, 
6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 6621, 6622, 
6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 6631, 6632, 
6633, 6634, 6635, 6636, 6637, 6638, 6639, 6640, 6641, 6642, 
6643, 6644, 6645, 6646, 6647, 6648, 6649, 6650, 6651, 6652, 
6653, 6654, 6655, 6656, 6657, 6658, 6659, 6660, 6661, 6662, 
6663, 6664, 6665, 6666, 6667, 6668, 6669, 6670, 6671, 6672, 
6673, 6674, 6675, 6676, 6677, 6678, 6679, 6680, 6681, 6682, 
6683, 6684, 6685, 6686, 6687, 6688, 6689, 6690, 6691, 6692, 
6693, 6694, 6695, 6696, 6697, 6698, 6699, 6700, 6701, 6702, 
6703, 6704, 6705, 6706, 6707, 6708, 6709, 6710, 6711, 6712, 
6713, 6714, 6715, 6716, 6717, 6718, 6719, 6720, 6721, 6722, 
6723, 6724, 6725, 6726, 6727, 6728, 6729, 6730, 6731, 6732, 
6733, 6734, 6735, 6736, 6737, 6738, 6739, 6740, 6741, 6742, 
6743, 6744, 6745, 6746, 6747, 6748, 6749, 6750, 6751, 6752, 
6753, 6754, 6755, 6756, 6757, 6758, 6759, 6760, 6761, 6762, 
6763, 6764, 6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 
6773, 6774, 6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 
6783, 6784, 6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 
6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 
6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 
6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 
6823, 6824, 6825, 6826, 8368, 8369, 8370, 8371, 8372, 8373, 
8374, 8375, 8376, 8377, 8378, 8379, 8380, 8381, 8382, 8383, 
8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 8392, 8393, 
8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 8402, 8403, 
8404, 8405, 8406, 8407, 8408, 8409, 8410, 8411, 8412, 8413, 
10501, 10502, 10503, 10504, 10505, 10506, 10507, 10508, 10509, 10510, 
10511, 10512, 10513, 10514, 10515, 10516, 10517, 10518, 10519, 10520, 
10521, 10522, 10523, 10524, 10525, 10526, 10527, 10528, 10529, 10530, 
10531, 10532, 10533, 10534, 10535, 10536, 10537, 10538, 10539, 10540, 
10541, 10542, 10543, 10544, 10545, 10546, 10547, 10548, 10549, 10550, 
10551, 10552, 10553, 10554, 10555, 10556, 10557, 10558, 10559, 10560, 
10561, 10562, 10563, 10564, 10565, 10566, 10567, 10568, 10569, 10570, 
10571, 10572, 10573, 10574, 10575, 10576, 10577, 10578, 10579, 10580, 
10581, 10582, 10583, 10584, 10585, 10586, 10587, 10588, 10589, 10590, 
10591, 10592, 10890, 10891, 10892, 10893, 10894, 10895, 10896, 10897, 
10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 11010, 11011, 
11012, 11013, 11014, 11015, 11016, 11017, 11018, 11019, 11020, 11021, 
11022, 11023, 11024, 11025, 11026, 11027, 11028, 11029, 11030, 11031, 
11032, 11033, 11034, 11035, 11036, 11037, 11038, 11039, 11040, 11041, 
11042, 11043, 11044, 11045, 11046, 11047, 11048, 11049, 11050, 11051, 
11052, 11053, 11054, 11055, 11056, 11057, 11058, 11059, 11060, 11061, 
11062, 11063, 11064, 11065, 11066, 11067, 11068, 11069, 11070, 11071, 
11072, 11073, 11074, 11075, 11076, 11077, 11078, 11079, 11080, 11081, 
11082, 11083, 11084, 11085, 11086, 11087, 11088, 11089, 11090, 11091, 
11092, 11093, 11094, 11095, 11096, 11097, 11098, 11099, 11100, 11101, 
11627, 11628, 11629, 11630, 11631, 11632, 11633, 11634, 11635, 11636, 
11637, 11638, 11639, 11640, 11641, 11642, 11643, 11644, 11645, 11646, 
11647, 11648, 11649, 11650, 11651, 11652, 11653, 11654, 11655, 11656, 
11657, 11658, 11659, 11660, 11661, 11662, 11663, 11664, 11665, 11666, 
11667, 11668, 11669, 11670, 11671, 11672, 11673, 11674, 11675, 11676, 
11677, 11678, 11679, 11680, 11681, 11682, 11683, 11684, 11685, 11686, 
11687, 11688, 11689, 11690, 11691, 11692, 11693, 11694, 11695, 11696, 
11697, 11698, 11699, 11700, 11701, 11702, 11703, 11704, 11705, 11706, 
11707, 11708, 11709, 11710, 11711, 11712, 11713, 11714, 11715, 11716, 
11717, 11718, 12060, 12061, 12062, 12063, 12064, 12065, 12066, 12067, 
12068, 12069, 12070, 12071, 12072, 12073, 12074, 12075, 12076, 12077, 
12078, 12079, 12080, 12081, 12082, 12083, 12084, 12085, 12086, 12087, 
12088, 12089, 12090, 12091, 12092, 12093, 12094, 12095, 12096, 12097, 
12098, 12099, 12100, 12101, 12102, 12103, 12104, 12105, 12106, 12107, 
12108, 12109, 12110, 12111, 12112, 12113, 12114, 12115, 12116, 12117, 
12118, 12119, 12120, 12121, 12122, 12123, 12124, 12125, 12126, 12127, 
12128, 12129, 12130, 12131, 12132, 12133, 12134, 12135, 12136, 12137, 
12138, 12139, 12140, 12141, 12142, 12143, 12144, 12145, 12146, 12147, 
12148, 12149, 12150, 12151, 
*NSET,NSET=Ceramic_Contact
1, 2, 5, 6, 21, 22, 23, 24, 26, 28, 
30, 32, 45, 46, 47, 48, 50, 52, 53, 54, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 123, 124, 125, 126, 127, 128, 129, 130, 131, 
132, 133, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 644, 645, 646, 647, 
648, 649, 650, 651, 652, 653, 654, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
726, 727, 728, 729, 730, 731, 732, 733, 734, 735, 
736, 737, 738, 739, 740, 741, 742, 743, 744, 745, 
746, 747, 748, 762, 763, 764, 765, 766, 767, 768, 
769, 770, 771, 772, 1073, 1074, 1075, 1076, 1077, 1078, 
1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 
1089, 1090, 1091, 1092, 1093, 1094, 1095, 1100, 1101, 1102, 
1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 
1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 
1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 
1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 
1143, 1144, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 
1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 1177, 
1178, 1179, 1180, 1181, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 5046, 5047, 5048, 
5049, 5050, 5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 
5059, 5060, 5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 
5069, 5070, 5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 
5079, 5080, 5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 
5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 
5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 
5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 
5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 
5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 
5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 
5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 
5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 
5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 
5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 
5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 
5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 
5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 
5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 
5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 
5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 
5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 
5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 
5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 
5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 
5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 
5770, 5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 
5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 
5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 
5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 
5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 
5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 
5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 
5840, 5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 
5850, 5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 
5860, 5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 
5870, 5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 
5880, 5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 
5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 
5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 
5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 
5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 
5930, 5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 
5940, 5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 
5950, 5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 
5960, 5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 
5970, 5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 
5980, 5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 
5990, 5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 
6000, 6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 
6010, 6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 
6020, 6021, 6022, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 
8511, 8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 
8521, 8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 
8531, 8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 
8541, 8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 
8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 
8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 
8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 
8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 
8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 
8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 
8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 
8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 
8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 
8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 
8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 
8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 
8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 
8681, 8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 
8691, 8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 
8701, 8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 
8711, 8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 
8721, 8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 
8731, 8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 
8741, 8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 
8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=Contact_CeramicTop
21, 22, 23, 24, 26, 28, 30, 32, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 617, 618, 619, 620, 
627, 628, 629, 630, 644, 645, 646, 647, 648, 649, 
650, 651, 652, 653, 654, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 
5054, 5055, 5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 
5064, 5065, 5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 
5074, 5075, 5076, 5077, 5078, 5079, 5080, 5081, 5082, 5083, 
5084, 5085, 5086, 5087, 5088, 5089, 5090, 5091, 5092, 5093, 
5094, 5095, 5096, 5097, 5098, 5099, 5100, 5101, 5102, 5103, 
5104, 5105, 5106, 5107, 5108, 5109, 5110, 5111, 5112, 5113, 
5114, 5115, 5116, 5117, 5118, 5119, 5120, 5121, 5122, 5123, 
5124, 5125, 5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 
5134, 5135, 5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 
5144, 5145, 5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 
5154, 5155, 5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 
5164, 5165, 5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 
5174, 5175, 5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 
5184, 5185, 5186, 5187, 5188, 5189, 5190, 5191, 5192, 5193, 
5194, 5195, 5196, 5197, 5198, 5199, 5200, 5201, 5202, 5203, 
5204, 5205, 5206, 5207, 5208, 5209, 5210, 5211, 5212, 5213, 
5214, 5215, 5216, 5217, 5218, 5219, 5220, 5221, 5222, 5223, 
5224, 5225, 5226, 5227, 5228, 5229, 5230, 5231, 5232, 5233, 
5234, 5235, 5236, 5237, 5238, 5239, 5240, 5241, 5242, 5243, 
5244, 5245, 5246, 5247, 5248, 5249, 5250, 5251, 5252, 5253, 
5254, 5255, 5256, 5257, 5258, 5259, 5260, 5261, 5262, 5263, 
5264, 5265, 5266, 5267, 5268, 5269, 5270, 5271, 5272, 5273, 
5274, 5275, 5276, 5277, 5278, 5279, 5280, 5281, 5282, 5283, 
5284, 5285, 5286, 5287, 5288, 5289, 5290, 5291, 5292, 5293, 
5294, 5295, 5296, 5297, 5298, 5359, 5360, 5361, 5362, 5363, 
5364, 5365, 5366, 5367, 5368, 5369, 5370, 5371, 5372, 5373, 
5374, 5375, 5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 
5384, 5385, 5386, 5387, 5388, 5389, 5390, 5391, 5392, 5393, 
5394, 5395, 5396, 5397, 5398, 5399, 5400, 5401, 5402, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 
*NSET,NSET=Contact_CeramicBottom
1, 2, 5, 6, 45, 46, 47, 48, 50, 52, 
53, 54, 97, 98, 99, 100, 101, 102, 103, 104, 
105, 106, 107, 123, 124, 125, 126, 127, 128, 129, 
130, 131, 132, 133, 149, 150, 151, 152, 153, 154, 
155, 156, 157, 158, 159, 160, 161, 162, 163, 164, 
165, 166, 167, 168, 169, 170, 171, 172, 173, 174, 
175, 176, 177, 178, 179, 180, 181, 182, 183, 184, 
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 
1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 
1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 1125, 1126, 
1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 
1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 1160, 1161, 
1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 
1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 
1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 
1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 
2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 
2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 
2029, 2030, 2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 
2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 
2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 
2059, 2060, 2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 
2069, 2070, 2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 
2079, 2080, 2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 
2089, 2090, 2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 
2099, 2100, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 
2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 
2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 
2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 
2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 
2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 
2159, 2160, 2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 
2169, 2170, 2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 
2179, 2180, 2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 
2189, 2190, 2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 
2199, 2200, 2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 
2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 
2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 
2239, 2240, 2241, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 
8511, 8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 
8521, 8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 
8531, 8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 
8541, 8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 
8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 
8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 
8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 
8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 
8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 
8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 
8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 
8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 
8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 
8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 
8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 
8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 
8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 
8681, 8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 
8691, 8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 
8701, 8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 
8711, 8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 
8721, 8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 
8731, 8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 
8741, 8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 
8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 
495, 496, 497, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 
615, 616, 617, 618, 619, 620, 621, 622, 623, 624, 
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 
645, 646, 647, 648, 649, 650, 651, 652, 653, 654, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 713, 714, 
715, 716, 717, 718, 719, 720, 721, 722, 723, 724, 
725, 726, 727, 728, 729, 730, 731, 732, 733, 734, 
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 1001, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 
1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 
1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 
1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 
1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 
1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 
1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 
1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 
1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 
1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 
1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 
1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 
1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 
1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 
1193, 1194, 1195, 1196, 1945, 1946, 1947, 1948, 1949, 1950, 
1951, 1952, 1953, 1954, 1955, 1956, 1957, 1958, 1959, 1960, 
1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 
1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 
1981, 1982, 1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 
1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 
2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 
2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 
2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 
2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 
2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 
2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 
2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 
2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 
2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 
2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 
2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 2189, 2190, 
2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 2199, 2200, 
2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 2209, 2210, 
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 2499, 2500, 
2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 2509, 2510, 
2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 2519, 2520, 
2521, 2522, 2523, 2524, 2525, 2526, 2527, 2528, 2529, 2530, 
2531, 2532, 2533, 2534, 2535, 2536, 2537, 2538, 2539, 2540, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 4657, 4658, 4659, 4660, 
4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 4669, 4670, 
4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 4679, 4680, 
4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 4689, 4690, 
4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 4699, 4700, 
4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 4709, 4710, 
4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 4719, 4720, 
4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 4729, 4730, 
4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 4739, 4740, 
4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 4749, 4750, 
4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 4759, 4760, 
4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 4769, 4770, 
4771, 4772, 4773, 4774, 4775, 4776, 4777, 4778, 4779, 4780, 
4781, 4782, 4783, 4784, 4785, 4786, 4787, 4788, 4789, 4790, 
4791, 4792, 4793, 4794, 4795, 4796, 4797, 4798, 4799, 4800, 
4801, 4802, 4803, 4804, 4805, 4806, 4807, 4808, 4809, 4810, 
4811, 4812, 4813, 4814, 4815, 4816, 4817, 4818, 4819, 4820, 
4821, 4822, 4823, 4824, 4825, 4826, 4827, 4828, 4829, 4830, 
4831, 4832, 4833, 4834, 4835, 4836, 4837, 4838, 4839, 4840, 
4841, 4842, 4843, 4844, 4845, 4846, 4847, 4848, 4849, 4850, 
4851, 4852, 4853, 4854, 4855, 4856, 4857, 4858, 4859, 4860, 
4861, 4862, 4863, 4864, 4865, 4866, 4867, 4868, 4869, 4870, 
4871, 4872, 4873, 4874, 4875, 4876, 4877, 4878, 4879, 4880, 
4881, 4882, 4883, 4884, 4885, 4886, 4887, 4888, 4889, 4890, 
4891, 4892, 4893, 4894, 4895, 4896, 4897, 4898, 4899, 4900, 
4901, 4902, 4903, 4904, 4905, 4906, 4907, 4908, 4909, 4910, 
4911, 4912, 4913, 4914, 4915, 4916, 4917, 4918, 4919, 4920, 
4921, 4922, 4923, 4924, 4925, 4926, 4927, 4928, 4929, 4930, 
4931, 4932, 4933, 4934, 4935, 4936, 4937, 4938, 4939, 4940, 
4941, 4942, 4943, 4944, 4945, 4946, 4947, 4948, 4949, 4950, 
4951, 4952, 4953, 4954, 4955, 4956, 4957, 4958, 4959, 4960, 
4961, 4962, 4963, 4964, 4965, 4966, 4967, 4968, 4969, 4970, 
4971, 4972, 4973, 4974, 4975, 4976, 4977, 4978, 4979, 4980, 
4981, 4982, 4983, 4984, 4985, 4986, 4987, 4988, 4989, 4990, 
4991, 4992, 4993, 4994, 4995, 4996, 4997, 4998, 4999, 5000, 
5001, 5002, 5003, 5004, 5005, 5006, 5007, 5008, 5009, 5010, 
5011, 5012, 5013, 5014, 5015, 5016, 5017, 5018, 5019, 5020, 
5021, 5022, 5023, 5024, 5025, 5026, 5027, 5028, 5029, 5030, 
5031, 5032, 5033, 5034, 5035, 5036, 5037, 5038, 5039, 5040, 
5041, 5042, 5043, 5044, 5045, 5046, 5047, 5048, 5049, 5050, 
5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 5059, 5060, 
5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 5069, 5070, 
5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 5079, 5080, 
5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 5089, 5090, 
5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 5099, 5100, 
5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 5109, 5110, 
5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 5119, 5120, 
5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 5129, 5130, 
5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 5139, 5140, 
5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 5149, 5150, 
5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 5159, 5160, 
5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 5169, 5170, 
5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 5179, 5180, 
5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 5189, 5190, 
5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 5199, 5200, 
5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 5209, 5210, 
5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 5219, 5220, 
5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 5229, 5230, 
5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 5239, 5240, 
5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 5249, 5250, 
5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 5259, 5260, 
5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 5269, 5270, 
5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 5279, 5280, 
5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 5289, 5290, 
5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 5299, 5300, 
5301, 5302, 5303, 5304, 5305, 5306, 5307, 5308, 5309, 5310, 
5311, 5312, 5313, 5314, 5315, 5316, 5317, 5318, 5319, 5320, 
5321, 5322, 5323, 5324, 5325, 5326, 5327, 5328, 5329, 5330, 
5331, 5332, 5333, 5334, 5335, 5336, 5337, 5338, 5339, 5340, 
5341, 5342, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5367, 5368, 5369, 5370, 
5371, 5372, 5373, 5374, 5375, 5376, 5377, 5378, 5379, 5380, 
5381, 5382, 5383, 5384, 5385, 5386, 5387, 5388, 5389, 5390, 
5391, 5392, 5393, 5394, 5395, 5396, 5397, 5398, 5399, 5400, 
5401, 5402, 5403, 5404, 5405, 5406, 5407, 5408, 5409, 5410, 
5411, 5412, 5413, 5414, 5415, 5416, 5417, 5418, 5419, 5420, 
5421, 5422, 5423, 5424, 5425, 5426, 5427, 5428, 5429, 5430, 
5431, 5432, 5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 
5441, 5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 
5451, 5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 
5461, 5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 
5471, 5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 
5481, 5482, 5483, 5484, 5485, 5486, 5487, 5488, 5489, 5490, 
5491, 5492, 5493, 5494, 5495, 5496, 5497, 5498, 5499, 5500, 
5501, 5502, 5503, 5504, 5505, 5506, 5507, 5508, 5509, 5510, 
5511, 5512, 5513, 5514, 5515, 5516, 5517, 5518, 5519, 5520, 
5521, 5522, 5523, 5524, 5525, 5526, 5527, 5528, 5529, 5530, 
5531, 5532, 5533, 5534, 5535, 5536, 5537, 5538, 5539, 5540, 
5541, 5542, 5543, 5544, 5545, 5546, 5547, 5548, 5549, 5550, 
5551, 5552, 5553, 5554, 5555, 5556, 5557, 5558, 5559, 5560, 
5561, 5562, 5563, 5564, 5565, 5566, 5567, 5568, 5569, 5570, 
5571, 5572, 5573, 5574, 5575, 5576, 5577, 5578, 5579, 5580, 
5581, 5582, 5583, 5584, 5585, 5586, 5587, 5588, 5589, 5590, 
5591, 5592, 5593, 5594, 5595, 5596, 5597, 5598, 5599, 5600, 
5601, 5602, 5603, 5604, 5605, 5606, 5607, 5608, 5609, 5610, 
5611, 5612, 5613, 5614, 5615, 5616, 5617, 5618, 5619, 5620, 
5621, 5622, 5623, 5624, 5625, 5626, 5627, 5628, 5629, 5630, 
5631, 5632, 5633, 5634, 5635, 5636, 5637, 5638, 5639, 5640, 
5641, 5642, 5643, 5644, 5645, 5646, 5647, 5648, 5649, 5650, 
5651, 5652, 5653, 5654, 5655, 5656, 5657, 5658, 5659, 5660, 
5661, 5662, 5663, 5664, 5665, 5666, 5667, 5668, 5669, 5670, 
5671, 5672, 5673, 5674, 5675, 5676, 5677, 5678, 5679, 5680, 
5681, 5682, 5683, 5684, 5685, 5686, 5687, 5688, 5689, 5690, 
5691, 5692, 5693, 5694, 5695, 5696, 5697, 5698, 5699, 5700, 
5701, 5702, 5703, 5704, 5705, 5706, 5707, 5708, 5709, 5710, 
5711, 5712, 5713, 5714, 5715, 5716, 5717, 5718, 5719, 5720, 
5721, 5722, 5723, 5724, 5725, 5726, 5727, 5728, 5729, 5730, 
5731, 5732, 5733, 5734, 5735, 5736, 5737, 5738, 5739, 5740, 
5741, 5742, 5743, 5744, 5745, 5746, 5747, 5748, 5749, 5750, 
5751, 5752, 5753, 5754, 5755, 5756, 5757, 5758, 5759, 5760, 
5761, 5762, 5763, 5764, 5765, 5766, 5767, 5768, 5769, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 
6031, 6032, 6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 
6041, 6042, 6043, 6044, 8115, 8116, 8117, 8118, 8119, 8120, 
8121, 8122, 8123, 8124, 8125, 8126, 8127, 8128, 8129, 8130, 
8131, 8132, 8133, 8134, 8135, 8136, 8137, 8138, 8139, 8140, 
8141, 8142, 8143, 8144, 8145, 8146, 8147, 8148, 8149, 8150, 
8151, 8152, 8153, 8154, 8155, 8156, 8157, 8158, 8159, 8160, 
8161, 8162, 8163, 8164, 8165, 8166, 8167, 8168, 8169, 8170, 
8171, 8172, 8173, 8174, 8175, 8176, 8177, 8178, 8179, 8180, 
8181, 8182, 8183, 8184, 8185, 8186, 8187, 8188, 8189, 8190, 
8191, 8192, 8193, 8194, 8195, 8196, 8197, 8198, 8199, 8200, 
8201, 8202, 8203, 8204, 8205, 8206, 8207, 8208, 8209, 8210, 
8211, 8212, 8213, 8214, 8215, 8216, 8217, 8218, 8219, 8220, 
8221, 8222, 8223, 8224, 8225, 8226, 8227, 8228, 8229, 8230, 
8231, 8232, 8233, 8234, 8235, 8236, 8237, 8238, 8239, 8240, 
8241, 8242, 8243, 8244, 8245, 8246, 8247, 8248, 8249, 8250, 
8251, 8252, 8253, 8254, 8255, 8256, 8257, 8258, 8259, 8260, 
8261, 8262, 8263, 8264, 8265, 8266, 8267, 8268, 8269, 8270, 
8271, 8272, 8273, 8274, 8275, 8276, 8277, 8278, 8279, 8280, 
8281, 8282, 8283, 8284, 8285, 8286, 8287, 8288, 8289, 8290, 
8291, 8292, 8293, 8294, 8295, 8296, 8297, 8298, 8299, 8300, 
8301, 8302, 8303, 8304, 8305, 8306, 8307, 8308, 8309, 8310, 
8311, 8312, 8313, 8314, 8315, 8316, 8317, 8318, 8319, 8320, 
8321, 8322, 8323, 8324, 8325, 8326, 8327, 8328, 8329, 8330, 
8331, 8332, 8333, 8334, 8335, 8336, 8337, 8338, 8339, 8340, 
8341, 8342, 8343, 8344, 8345, 8346, 8347, 8348, 8349, 8350, 
8351, 8352, 8353, 8354, 8355, 8356, 8357, 8358, 8359, 8360, 
8361, 8362, 8363, 8364, 8365, 8366, 8367, 8368, 8369, 8370, 
8371, 8372, 8373, 8374, 8375, 8376, 8377, 8378, 8379, 8380, 
8381, 8382, 8383, 8384, 8385, 8386, 8387, 8388, 8389, 8390, 
8391, 8392, 8393, 8394, 8395, 8396, 8397, 8398, 8399, 8400, 
8401, 8402, 8403, 8404, 8405, 8406, 8407, 8408, 8409, 8410, 
8411, 8412, 8413, 8414, 8415, 8416, 8417, 8418, 8419, 8420, 
8421, 8422, 8423, 8424, 8425, 8426, 8427, 8428, 8429, 8430, 
8431, 8432, 8433, 8434, 8435, 8436, 8437, 8438, 8439, 8440, 
8441, 8442, 8443, 8444, 8445, 8446, 8447, 8448, 8449, 8450, 
8451, 8452, 8453, 8454, 8455, 8456, 8457, 8458, 8459, 8460, 
8461, 8462, 8463, 8464, 8465, 8466, 8467, 8468, 8469, 8470, 
8471, 8472, 8473, 8474, 8475, 8476, 8477, 8478, 8479, 8480, 
8481, 8482, 8483, 8484, 8485, 8486, 8487, 8488, 8489, 8490, 
8491, 8492, 8493, 8494, 8495, 8496, 8497, 8498, 8499, 8500, 
8501, 8502, 8503, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 
8511, 8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 
8521, 8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 
8531, 8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 
8541, 8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 
8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 
8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 
8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 
8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 
8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 
8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 
8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 
8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 
8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 
8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 
8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 
8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 
8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 
8681, 8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 
8691, 8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 
8701, 8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 
8711, 8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 
8721, 8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 
8731, 8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 
8741, 8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 
8751, 8752, 8753, 8754, 8755, 8756, 8757, 8758, 8759, 8760, 
8761, 8762, 8763, 8764, 8765, 8766, 8767, 8768, 8769, 8770, 
8771, 8772, 8773, 8774, 8775, 8776, 8777, 8778, 8779, 8780, 
8781, 8782, 8783, 8784, 8785, 8786, 8787, 8788, 8789, 8790, 
8791, 8792, 8793, 8794, 8795, 8796, 8797, 8798, 8799, 8800, 
12629, 12630, 12631, 12632, 12633, 12634, 12635, 12636, 12637, 12638, 
12639, 12640, 12641, 12642, 12643, 12644, 12645, 12646, 12647, 12648, 
12649, 12650, 12651, 12652, 12653, 12654, 12655, 12656, 12657, 12658, 
12659, 12660, 12661, 12662, 12663, 12664, 12665, 12666, 12667, 12668, 
12669, 12670, 12671, 12672, 12673, 12674, 12675, 12676, 12677, 12678, 
12679, 12680, 12681, 12682, 12683, 12684, 12685, 12686, 12687, 12688, 
12689, 12690, 12691, 12692, 12693, 12694, 12695, 12696, 12697, 12698, 
12699, 12700, 12701, 12702, 12703, 12704, 12705, 12706, 12707, 12708, 
12709, 12710, 12711, 12712, 12713, 12714, 12715, 12716, 12717, 12718, 
12719, 12720, 12721, 12722, 12723, 12724, 12725, 12726, 12727, 12728, 
12729, 12730, 12731, 12732, 12733, 12734, 12735, 12736, 12737, 12738, 
12739, 12740, 12741, 12742, 12743, 12744, 12745, 12746, 12747, 12748, 
12749, 12750, 12751, 12752, 12753, 12754, 12755, 12756, 12757, 12758, 
12759, 12760, 12761, 12762, 12763, 12764, 12765, 12766, 12767, 12768, 
12769, 12770, 12771, 12772, 12773, 12774, 12775, 12776, 12777, 12778, 
12779, 12780, 12781, 12782, 12783, 12784, 12785, 12786, 12787, 12788, 
12789, 12790, 12791, 12792, 12793, 12794, 12795, 12796, 12797, 12798, 
12799, 12800, 12801, 12802, 12803, 12804, 12805, 12806, 12807, 12808, 
12809, 12810, 12811, 12812, 12813, 12814, 12815, 12816, 12817, 12818, 
12819, 12820, 12821, 12822, 12823, 12824, 12825, 12826, 12827, 12828, 
12829, 12830, 12831, 12832, 12833, 12834, 12835, 12836, 12837, 12838, 
12839, 12840, 12841, 12842, 12843, 12844, 12845, 12846, 12847, 12848, 
12849, 12850, 12851, 12852, 12853, 12854, 12855, 12856, 12857, 12858, 
12859, 12860, 12861, 12862, 12863, 12864, 12865, 12866, 12867, 12868, 
12869, 12870, 12871, 12872, 12873, 12874, 12875, 12876, 12877, 12878, 
12879, 12880, 12881, 12882, 12883, 12884, 12885, 12886, 12887, 12888, 
12889, 12890, 12891, 12892, 12893, 12894, 12895, 12896, 12897, 12898, 
12899, 12900, 12901, 12902, 12903, 12904, 12905, 12906, 12907, 12908, 
12909, 12910, 12911, 12912, 12913, 12914, 12915, 12916, 12917, 12918, 
12919, 12920, 12921, 12922, 12923, 12924, 12925, 12926, 12927, 12928, 
12929, 12930, 12931, 12932, 12933, 12934, 12935, 12936, 12937, 12938, 
12939, 12940, 12941, 12942, 12943, 12944, 12945, 12946, 12947, 12948, 
12949, 12950, 12951, 12952, 12953, 12954, 12955, 12956, 12957, 12958, 
12959, 12960, 12961, 12962, 12963, 12964, 12965, 12966, 12967, 12968, 
12969, 12970, 12971, 12972, 12973, 12974, 12975, 12976, 12977, 12978, 
12979, 12980, 12981, 12982, 12983, 12984, 12985, 12986, 12987, 12988, 
12989, 12990, 12991, 12992, 12993, 12994, 12995, 12996, 12997, 12998, 
12999, 13000, 13001, 13002, 13003, 13004, 13005, 13006, 13007, 13008, 
13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 13018, 
13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 13028, 
13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 13038, 
13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 13048, 
13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 13058, 
13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 13068, 
13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 
13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 13088, 
13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 13098, 
13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 13108, 
13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 13118, 
13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 13128, 
13129, 13130, 13131, 13132, 13133, 13134, 18954, 18955, 18956, 18957, 
18958, 18959, 18960, 18961, 18962, 18963, 18964, 18965, 18966, 18967, 
18968, 18969, 18970, 18971, 18972, 18973, 18974, 18975, 18976, 18977, 
18978, 18979, 18980, 18981, 18982, 18983, 18984, 18985, 18986, 18987, 
18988, 18989, 18990, 18991, 18992, 18993, 18994, 18995, 18996, 18997, 
18998, 18999, 19000, 19001, 19002, 19003, 19004, 19005, 19006, 19007, 
19008, 19009, 19010, 19011, 19012, 19013, 19014, 19015, 19016, 19017, 
19018, 19019, 19020, 19021, 19022, 19023, 19024, 19025, 19026, 19027, 
19028, 19029, 19030, 19031, 19032, 19033, 19034, 19035, 19036, 19037, 
19038, 19039, 19040, 19041, 19042, 19043, 19044, 19045, 19046, 19047, 
19048, 19049, 19050, 19051, 19052, 19053, 19054, 19055, 19056, 19057, 
19058, 19059, 19060, 19061, 19062, 19063, 19064, 19065, 19066, 19067, 
19068, 19069, 19070, 19071, 19072, 19073, 19074, 19075, 19076, 19077, 
19078, 19079, 19080, 19081, 19082, 19083, 19084, 19085, 19086, 19087, 
19088, 19089, 19090, 19091, 19092, 19093, 19094, 19095, 19096, 19097, 
19098, 19099, 19100, 19101, 19102, 19103, 19104, 19105, 19106, 19107, 
19108, 19109, 19110, 19111, 19112, 19113, 19114, 19115, 19116, 19117, 
19118, 19119, 19120, 19121, 19122, 19123, 19124, 19125, 19126, 19127, 
19128, 19129, 19130, 19131, 19132, 19133, 19134, 19135, 19136, 19137, 
19138, 19139, 19140, 19141, 19142, 19143, 19144, 19145, 19146, 19147, 
19148, 19149, 19150, 19151, 19152, 19153, 19154, 19155, 19156, 19157, 
19158, 19159, 19160, 19161, 19162, 19163, 19164, 19165, 19166, 19167, 
19168, 19169, 19170, 19171, 19172, 19173, 19174, 19175, 19176, 19177, 
19178, 19179, 19180, 19181, 19182, 19183, 19184, 19185, 19186, 19187, 
19188, 19189, 19190, 19191, 19192, 19193, 19194, 19195, 19196, 19197, 
19198, 19199, 19200, 19201, 19202, 19203, 19204, 19205, 19206, 19207, 
19208, 19209, 19210, 19211, 19212, 19213, 19214, 19215, 19216, 19217, 
19218, 19219, 19220, 19221, 19222, 19223, 19224, 19225, 19226, 19227, 
19228, 19229, 19230, 19231, 19232, 19233, 19234, 19235, 19236, 19237, 
19238, 19239, 19240, 19241, 19242, 19243, 19244, 19245, 19246, 19247, 
19248, 19249, 19250, 19251, 19252, 19253, 19254, 19255, 19256, 19257, 
19258, 19259, 19260, 19261, 19262, 19263, 19264, 19265, 19266, 19267, 
19268, 19269, 19270, 19271, 19272, 19273, 19274, 19275, 19276, 19277, 
19278, 19279, 19280, 19281, 19282, 19283, 19284, 19285, 19286, 19287, 
19288, 19289, 19290, 19291, 19292, 19293, 19294, 19295, 19296, 19297, 
19298, 19299, 19300, 19301, 19302, 19303, 19304, 19305, 19306, 19307, 
19308, 19309, 19310, 19311, 19312, 19313, 19314, 19315, 19316, 19317, 
19318, 19319, 19320, 19321, 19322, 19323, 19324, 19325, 19326, 19327, 
19328, 19329, 19330, 19331, 19332, 19333, 19334, 19335, 19336, 19337, 
19338, 19339, 19340, 19341, 19342, 19343, 19344, 19345, 19346, 19347, 
19348, 19349, 19350, 19351, 19352, 19353, 19354, 19355, 19356, 19357, 
19358, 19359, 19360, 19361, 19362, 19363, 19364, 19365, 19366, 19367, 
19368, 19369, 19370, 19371, 19372, 19373, 19374, 19375, 19376, 19377, 
19378, 19379, 19380, 19381, 19382, 19383, 19384, 19385, 19386, 19387, 
19388, 19389, 19390, 19391, 19392, 19393, 19394, 19395, 19396, 19397, 
19398, 19399, 19400, 19401, 19402, 19403, 19404, 19405, 19406, 19407, 
19408, 19409, 19410, 19411, 19412, 19413, 19414, 19415, 19416, 19417, 
19418, 19419, 19420, 19421, 19422, 19423, 19424, 19425, 19426, 19427, 
19428, 19429, 19430, 19431, 19432, 19433, 19434, 19435, 19436, 19437, 
19438, 19439, 19440, 19441, 19442, 19443, 19444, 19445, 19446, 19447, 
19448, 19449, 19450, 19451, 19452, 19453, 19454, 19455, 19456, 19457, 
19458, 19459, 19460, 19461, 19462, 19463, 19464, 19465, 19466, 19467, 
19468, 19469, 19470, 19471, 19472, 19473, 19474, 19475, 19476, 19477, 
19478, 19479, 19480, 19481, 19482, 19483, 19484, 19485, 19486, 19487, 
19488, 19489, 19490, 19491, 19492, 19493, 19494, 19495, 19496, 19497, 
19498, 19499, 19500, 19501, 19502, 19503, 19504, 19505, 19506, 19507, 
19508, 19509, 19510, 19511, 19512, 19513, 19514, 19515, 19516, 19517, 
19518, 19519, 19520, 19521, 19522, 19523, 19524, 19525, 19526, 19527, 
19528, 19529, 19530, 19531, 19532, 19533, 19534, 19535, 19536, 19537, 
19538, 19539, 19540, 19541, 19542, 19543, 19544, 19545, 19546, 19547, 
19548, 19549, 19550, 19551, 19552, 19553, 19554, 19555, 19556, 19557, 
19558, 19559, 19560, 19561, 19562, 19563, 19564, 19565, 19566, 19567, 
19568, 19569, 19570, 19571, 19572, 19573, 19574, 19575, 19576, 19577, 
19578, 19579, 19580, 19581, 19582, 19583, 19584, 19585, 19586, 19587, 
19588, 19589, 19590, 19591, 19592, 19593, 19594, 19595, 19596, 19597, 
19598, 19599, 19600, 19601, 19602, 19603, 19604, 19605, 19606, 19607, 
19608, 19609, 19610, 19611, 19612, 19613, 19614, 19615, 19616, 19617, 
19618, 19619, 19620, 19621, 19622, 19623, 19624, 19625, 19626, 19627, 
19628, 19629, 19630, 19631, 19632, 19633, 19634, 19635, 19636, 19637, 
19638, 19639, 19640, 19641, 19642, 19643, 19644, 19645, 19646, 19647, 
19648, 19649, 19650, 19651, 19652, 19653, 19654, 19655, 19656, 19657, 
19658, 19659, 19660, 19661, 19662, 19663, 19664, 19665, 19666, 19667, 
19668, 19669, 19670, 19671, 19672, 19673, 19674, 19675, 19676, 19677, 
19678, 19679, 19680, 19681, 19682, 19683, 19684, 19685, 19686, 19687, 
19688, 19689, 19690, 19691, 19692, 19693, 19694, 19695, 19696, 19697, 
19698, 19699, 19700, 19701, 19702, 19703, 19704, 19705, 19706, 19707, 
19708, 19709, 19710, 19711, 19712, 19713, 19714, 19715, 19716, 19717, 
19718, 19719, 19720, 19721, 19722, 19723, 19724, 19725, 19726, 19727, 
19728, 19729, 19730, 19731, 19732, 19733, 19734, 19735, 19736, 19737, 
19738, 19739, 19740, 19741, 19742, 19743, 19744, 19745, 19746, 19747, 
19748, 19749, 19750, 19751, 19752, 19753, 19754, 19755, 19756, 19757, 
19758, 19759, 19760, 19761, 19762, 19763, 19764, 19765, 19766, 19767, 
19768, 19769, 19770, 19771, 19772, 19773, 19774, 19775, 19776, 19777, 
19778, 19779, 19780, 19781, 19782, 19783, 19784, 19785, 19786, 19787, 
19788, 19789, 19790, 19791, 19792, 19793, 19794, 19795, 19796, 19797, 
19798, 19799, 19800, 19801, 19802, 19803, 19804, 19805, 19806, 19807, 
19808, 19809, 19810, 19811, 19812, 19813, 19814, 19815, 19816, 19817, 
19818, 19819, 19820, 19821, 19822, 19823, 19824, 19825, 19826, 19827, 
19828, 19829, 19830, 19831, 19832, 19833, 19834, 19835, 19836, 19837, 
19838, 19839, 19840, 19841, 19842, 19843, 19844, 19845, 19846, 19847, 
19848, 19849, 19850, 19851, 19852, 19853, 19854, 19855, 19856, 19857, 
19858, 19859, 19860, 19861, 19862, 19863, 19864, 19865, 19866, 19867, 
19868, 19869, 19870, 19871, 19872, 19873, 19874, 19875, 19876, 19877, 
19878, 19879, 19880, 19881, 19882, 19883, 19884, 19885, 19886, 19887, 
19888, 19889, 19890, 19891, 19892, 19893, 19894, 19895, 19896, 19897, 
19898, 19899, 19900, 19901, 19902, 19903, 19904, 19905, 19906, 19907, 
19908, 19909, 19910, 19911, 19912, 19913, 19914, 19915, 19916, 19917, 
19918, 19919, 19920, 19921, 19922, 19923, 19924, 19925, 19926, 19927, 
19928, 19929, 19930, 19931, 19932, 19933, 19934, 19935, 19936, 19937, 
19938, 19939, 19940, 19941, 19942, 19943, 19944, 19945, 19946, 19947, 
19948, 19949, 19950, 19951, 19952, 19953, 19954, 19955, 19956, 19957, 
19958, 19959, 19960, 19961, 19962, 19963, 19964, 19965, 19966, 19967, 
19968, 19969, 19970, 19971, 19972, 19973, 19974, 19975, 19976, 19977, 
19978, 19979, 19980, 19981, 19982, 19983, 19984, 19985, 19986, 19987, 
19988, 19989, 19990, 19991, 19992, 19993, 19994, 19995, 19996, 19997, 
19998, 19999, 20000, 20001, 20002, 20003, 20004, 20005, 20006, 20007, 
20008, 20009, 20010, 20011, 20012, 20013, 20014, 20015, 20016, 20017, 
20018, 20019, 20020, 20021, 20022, 20023, 20024, 20025, 20026, 20027, 
20028, 20029, 20030, 20031, 20032, 20033, 20034, 20035, 20036, 20037, 
20038, 20039, 20040, 20041, 20042, 20043, 20044, 20045, 20046, 20047, 
20048, 20049, 20050, 20051, 20052, 20053, 25873, 25874, 25875, 25876, 
25877, 25878, 25879, 25880, 25881, 25882, 25883, 25884, 25885, 25886, 
25887, 25888, 25889, 25890, 25891, 25892, 25893, 25894, 25895, 25896, 
25897, 25898, 25899, 25900, 25901, 25902, 25903, 25904, 25905, 25906, 
25907, 25908, 25909, 25910, 25911, 25912, 25913, 25914, 25915, 25916, 
25917, 25918, 25919, 25920, 25921, 25922, 25923, 25924, 25925, 25926, 
25927, 25928, 25929, 25930, 25931, 25932, 25933, 25934, 25935, 25936, 
25937, 25938, 25939, 25940, 25941, 25942, 25943, 25944, 25945, 25946, 
25947, 25948, 25949, 25950, 25951, 25952, 25953, 25954, 25955, 25956, 
25957, 25958, 25959, 25960, 25961, 25962, 25963, 25964, 25965, 25966, 
25967, 25968, 25969, 25970, 25971, 25972, 25973, 25974, 25975, 25976, 
25977, 25978, 25979, 25980, 25981, 25982, 25983, 25984, 25985, 25986, 
25987, 25988, 25989, 25990, 25991, 25992, 25993, 25994, 25995, 25996, 
25997, 25998, 25999, 26000, 26001, 26002, 26003, 26004, 26005, 26006, 
26007, 26008, 26009, 26010, 26011, 26012, 26013, 26014, 26015, 26016, 
26017, 26018, 26019, 26020, 26021, 26022, 26023, 26024, 26025, 26026, 
26027, 26028, 26029, 26030, 26031, 26032, 26033, 26034, 26035, 26036, 
26037, 26038, 26039, 26040, 26041, 26042, 26043, 26044, 26045, 26046, 
26047, 26048, 26049, 26050, 26051, 26052, 26053, 26054, 26055, 26056, 
26057, 26058, 26059, 26060, 26061, 26062, 26063, 26064, 26065, 26066, 
26067, 26068, 26069, 26070, 26071, 26072, 26073, 26074, 26075, 26076, 
26077, 26078, 26079, 26080, 26081, 26082, 26083, 26084, 26085, 26086, 
26087, 26088, 26089, 26090, 26091, 26092, 26093, 26094, 26095, 26096, 
26097, 26098, 26099, 26100, 26101, 26102, 26103, 26104, 26105, 26106, 
26107, 26108, 26109, 26110, 26111, 26112, 26113, 26114, 26115, 26116, 
26117, 26118, 26119, 26120, 26121, 26122, 26123, 26124, 26125, 26126, 
26127, 26128, 26129, 26130, 26131, 26132, 26133, 26134, 26135, 26136, 
26137, 26138, 26139, 26140, 26141, 26142, 26143, 26144, 26145, 26146, 
26147, 26148, 26149, 26150, 26151, 26152, 26153, 26154, 26155, 26156, 
26157, 26158, 26159, 26160, 26161, 26162, 26163, 26164, 26165, 26166, 
26167, 26168, 26169, 26170, 26171, 26172, 26173, 26174, 26175, 26176, 
26177, 26178, 26179, 26180, 26181, 26182, 26183, 26184, 26185, 26186, 
26187, 26188, 26189, 26190, 26191, 26192, 26193, 26194, 26195, 26196, 
26197, 26198, 26199, 26200, 26201, 26202, 26203, 26204, 26205, 26206, 
26207, 26208, 26209, 26210, 26211, 26212, 26213, 26214, 26215, 26216, 
26217, 26218, 26219, 26220, 26221, 26222, 26223, 26224, 26225, 26226, 
26227, 26228, 26229, 26230, 26231, 26232, 26233, 26234, 26235, 26236, 
26237, 26238, 26239, 26240, 26241, 26242, 26243, 26244, 26245, 26246, 
26247, 26248, 26249, 26250, 26251, 26252, 26253, 26254, 26255, 26256, 
26257, 26258, 26259, 26260, 26261, 26262, 26263, 26264, 26265, 26266, 
26267, 26268, 26269, 26270, 26271, 26272, 26273, 26274, 26275, 26276, 
