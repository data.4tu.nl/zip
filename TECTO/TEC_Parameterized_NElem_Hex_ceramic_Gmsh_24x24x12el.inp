4951, 4338, 4361, 4362, 4339
4952, 4339, 4362, 4363, 4340
4953, 4340, 4363, 4364, 4341
4954, 4341, 4364, 4365, 4342
4955, 4342, 4365, 4366, 4343
4956, 4343, 4366, 4367, 4344
4957, 4344, 4367, 4368, 4345
4958, 4345, 4368, 4369, 4346
4959, 4346, 4369, 4370, 4347
4960, 4347, 4370, 4371, 4348
4961, 4348, 4371, 4372, 4349
4962, 4349, 4372, 4373, 4350
4963, 4350, 4373, 4374, 4351
4964, 4351, 4374, 4375, 4352
4965, 4352, 4375, 4376, 4353
4966, 4353, 4376, 4377, 4354
4967, 4354, 4377, 4378, 4355
4968, 4355, 4378, 4379, 4356
4969, 4356, 4379, 4380, 4357
4970, 4357, 4380, 467, 466
4971, 307, 308, 4381, 4358
4972, 4358, 4381, 4382, 4359
4973, 4359, 4382, 4383, 4360
4974, 4360, 4383, 4384, 4361
4975, 4361, 4384, 4385, 4362
4976, 4362, 4385, 4386, 4363
4977, 4363, 4386, 4387, 4364
4978, 4364, 4387, 4388, 4365
4979, 4365, 4388, 4389, 4366
4980, 4366, 4389, 4390, 4367
4981, 4367, 4390, 4391, 4368
4982, 4368, 4391, 4392, 4369
4983, 4369, 4392, 4393, 4370
4984, 4370, 4393, 4394, 4371
4985, 4371, 4394, 4395, 4372
4986, 4372, 4395, 4396, 4373
4987, 4373, 4396, 4397, 4374
4988, 4374, 4397, 4398, 4375
4989, 4375, 4398, 4399, 4376
4990, 4376, 4399, 4400, 4377
4991, 4377, 4400, 4401, 4378
4992, 4378, 4401, 4402, 4379
4993, 4379, 4402, 4403, 4380
4994, 4380, 4403, 468, 467
4995, 308, 12, 412, 4381
4996, 4381, 412, 413, 4382
4997, 4382, 413, 414, 4383
4998, 4383, 414, 415, 4384
4999, 4384, 415, 416, 4385
5000, 4385, 416, 417, 4386
5001, 4386, 417, 418, 4387
5002, 4387, 418, 419, 4388
5003, 4388, 419, 420, 4389
5004, 4389, 420, 421, 4390
5005, 4390, 421, 422, 4391
5006, 4391, 422, 423, 4392
5007, 4392, 423, 424, 4393
5008, 4393, 424, 425, 4394
5009, 4394, 425, 426, 4395
5010, 4395, 426, 427, 4396
5011, 4396, 427, 428, 4397
5012, 4397, 428, 429, 4398
5013, 4398, 429, 430, 4399
5014, 4399, 430, 431, 4400
5015, 4400, 431, 432, 4401
5016, 4401, 432, 433, 4402
5017, 4402, 433, 434, 4403
5018, 4403, 434, 16, 468
*ELEMENT, type=CPS4, ELSET=Surface16
5019, 14, 458, 4404, 355
5020, 458, 459, 4405, 4404
5021, 459, 460, 4406, 4405
5022, 460, 461, 4407, 4406
5023, 461, 462, 4408, 4407
5024, 462, 463, 4409, 4408
5025, 463, 464, 4410, 4409
5026, 464, 465, 4411, 4410
5027, 465, 466, 4412, 4411
5028, 466, 467, 4413, 4412
5029, 467, 468, 4414, 4413
5030, 468, 16, 435, 4414
5031, 355, 4404, 4415, 356
5032, 4404, 4405, 4416, 4415
5033, 4405, 4406, 4417, 4416
5034, 4406, 4407, 4418, 4417
5035, 4407, 4408, 4419, 4418
5036, 4408, 4409, 4420, 4419
5037, 4409, 4410, 4421, 4420
5038, 4410, 4411, 4422, 4421
5039, 4411, 4412, 4423, 4422
5040, 4412, 4413, 4424, 4423
5041, 4413, 4414, 4425, 4424
5042, 4414, 435, 436, 4425
5043, 356, 4415, 4426, 357
5044, 4415, 4416, 4427, 4426
5045, 4416, 4417, 4428, 4427
5046, 4417, 4418, 4429, 4428
5047, 4418, 4419, 4430, 4429
5048, 4419, 4420, 4431, 4430
5049, 4420, 4421, 4432, 4431
5050, 4421, 4422, 4433, 4432
5051, 4422, 4423, 4434, 4433
5052, 4423, 4424, 4435, 4434
5053, 4424, 4425, 4436, 4435
5054, 4425, 436, 437, 4436
5055, 357, 4426, 4437, 358
5056, 4426, 4427, 4438, 4437
5057, 4427, 4428, 4439, 4438
5058, 4428, 4429, 4440, 4439
5059, 4429, 4430, 4441, 4440
5060, 4430, 4431, 4442, 4441
5061, 4431, 4432, 4443, 4442
5062, 4432, 4433, 4444, 4443
5063, 4433, 4434, 4445, 4444
5064, 4434, 4435, 4446, 4445
5065, 4435, 4436, 4447, 4446
5066, 4436, 437, 438, 4447
5067, 358, 4437, 4448, 359
5068, 4437, 4438, 4449, 4448
5069, 4438, 4439, 4450, 4449
5070, 4439, 4440, 4451, 4450
5071, 4440, 4441, 4452, 4451
5072, 4441, 4442, 4453, 4452
5073, 4442, 4443, 4454, 4453
5074, 4443, 4444, 4455, 4454
5075, 4444, 4445, 4456, 4455
5076, 4445, 4446, 4457, 4456
5077, 4446, 4447, 4458, 4457
5078, 4447, 438, 439, 4458
5079, 359, 4448, 4459, 360
5080, 4448, 4449, 4460, 4459
5081, 4449, 4450, 4461, 4460
5082, 4450, 4451, 4462, 4461
5083, 4451, 4452, 4463, 4462
5084, 4452, 4453, 4464, 4463
5085, 4453, 4454, 4465, 4464
5086, 4454, 4455, 4466, 4465
5087, 4455, 4456, 4467, 4466
5088, 4456, 4457, 4468, 4467
5089, 4457, 4458, 4469, 4468
5090, 4458, 439, 440, 4469
5091, 360, 4459, 4470, 361
5092, 4459, 4460, 4471, 4470
5093, 4460, 4461, 4472, 4471
5094, 4461, 4462, 4473, 4472
5095, 4462, 4463, 4474, 4473
5096, 4463, 4464, 4475, 4474
5097, 4464, 4465, 4476, 4475
5098, 4465, 4466, 4477, 4476
5099, 4466, 4467, 4478, 4477
5100, 4467, 4468, 4479, 4478
5101, 4468, 4469, 4480, 4479
5102, 4469, 440, 441, 4480
5103, 361, 4470, 4481, 362
5104, 4470, 4471, 4482, 4481
5105, 4471, 4472, 4483, 4482
5106, 4472, 4473, 4484, 4483
5107, 4473, 4474, 4485, 4484
5108, 4474, 4475, 4486, 4485
5109, 4475, 4476, 4487, 4486
5110, 4476, 4477, 4488, 4487
5111, 4477, 4478, 4489, 4488
5112, 4478, 4479, 4490, 4489
5113, 4479, 4480, 4491, 4490
5114, 4480, 441, 442, 4491
5115, 362, 4481, 4492, 363
5116, 4481, 4482, 4493, 4492
5117, 4482, 4483, 4494, 4493
5118, 4483, 4484, 4495, 4494
5119, 4484, 4485, 4496, 4495
5120, 4485, 4486, 4497, 4496
5121, 4486, 4487, 4498, 4497
5122, 4487, 4488, 4499, 4498
5123, 4488, 4489, 4500, 4499
5124, 4489, 4490, 4501, 4500
5125, 4490, 4491, 4502, 4501
5126, 4491, 442, 443, 4502
5127, 363, 4492, 4503, 364
5128, 4492, 4493, 4504, 4503
5129, 4493, 4494, 4505, 4504
5130, 4494, 4495, 4506, 4505
5131, 4495, 4496, 4507, 4506
5132, 4496, 4497, 4508, 4507
5133, 4497, 4498, 4509, 4508
5134, 4498, 4499, 4510, 4509
5135, 4499, 4500, 4511, 4510
5136, 4500, 4501, 4512, 4511
5137, 4501, 4502, 4513, 4512
5138, 4502, 443, 444, 4513
5139, 364, 4503, 4514, 365
5140, 4503, 4504, 4515, 4514
5141, 4504, 4505, 4516, 4515
5142, 4505, 4506, 4517, 4516
5143, 4506, 4507, 4518, 4517
5144, 4507, 4508, 4519, 4518
5145, 4508, 4509, 4520, 4519
5146, 4509, 4510, 4521, 4520
5147, 4510, 4511, 4522, 4521
5148, 4511, 4512, 4523, 4522
5149, 4512, 4513, 4524, 4523
5150, 4513, 444, 445, 4524
5151, 365, 4514, 4525, 366
5152, 4514, 4515, 4526, 4525
5153, 4515, 4516, 4527, 4526
5154, 4516, 4517, 4528, 4527
5155, 4517, 4518, 4529, 4528
5156, 4518, 4519, 4530, 4529
5157, 4519, 4520, 4531, 4530
5158, 4520, 4521, 4532, 4531
5159, 4521, 4522, 4533, 4532
5160, 4522, 4523, 4534, 4533
5161, 4523, 4524, 4535, 4534
5162, 4524, 445, 446, 4535
5163, 366, 4525, 4536, 367
5164, 4525, 4526, 4537, 4536
5165, 4526, 4527, 4538, 4537
5166, 4527, 4528, 4539, 4538
5167, 4528, 4529, 4540, 4539
5168, 4529, 4530, 4541, 4540
5169, 4530, 4531, 4542, 4541
5170, 4531, 4532, 4543, 4542
5171, 4532, 4533, 4544, 4543
5172, 4533, 4534, 4545, 4544
5173, 4534, 4535, 4546, 4545
5174, 4535, 446, 447, 4546
5175, 367, 4536, 4547, 368
5176, 4536, 4537, 4548, 4547
5177, 4537, 4538, 4549, 4548
5178, 4538, 4539, 4550, 4549
5179, 4539, 4540, 4551, 4550
5180, 4540, 4541, 4552, 4551
5181, 4541, 4542, 4553, 4552
5182, 4542, 4543, 4554, 4553
5183, 4543, 4544, 4555, 4554
5184, 4544, 4545, 4556, 4555
5185, 4545, 4546, 4557, 4556
5186, 4546, 447, 448, 4557
5187, 368, 4547, 4558, 369
5188, 4547, 4548, 4559, 4558
5189, 4548, 4549, 4560, 4559
5190, 4549, 4550, 4561, 4560
5191, 4550, 4551, 4562, 4561
5192, 4551, 4552, 4563, 4562
5193, 4552, 4553, 4564, 4563
5194, 4553, 4554, 4565, 4564
5195, 4554, 4555, 4566, 4565
5196, 4555, 4556, 4567, 4566
5197, 4556, 4557, 4568, 4567
5198, 4557, 448, 449, 4568
5199, 369, 4558, 4569, 370
5200, 4558, 4559, 4570, 4569
5201, 4559, 4560, 4571, 4570
5202, 4560, 4561, 4572, 4571
5203, 4561, 4562, 4573, 4572
5204, 4562, 4563, 4574, 4573
5205, 4563, 4564, 4575, 4574
5206, 4564, 4565, 4576, 4575
5207, 4565, 4566, 4577, 4576
5208, 4566, 4567, 4578, 4577
5209, 4567, 4568, 4579, 4578
5210, 4568, 449, 450, 4579
5211, 370, 4569, 4580, 371
5212, 4569, 4570, 4581, 4580
5213, 4570, 4571, 4582, 4581
5214, 4571, 4572, 4583, 4582
5215, 4572, 4573, 4584, 4583
5216, 4573, 4574, 4585, 4584
5217, 4574, 4575, 4586, 4585
5218, 4575, 4576, 4587, 4586
5219, 4576, 4577, 4588, 4587
5220, 4577, 4578, 4589, 4588
5221, 4578, 4579, 4590, 4589
5222, 4579, 450, 451, 4590
5223, 371, 4580, 4591, 372
5224, 4580, 4581, 4592, 4591
5225, 4581, 4582, 4593, 4592
5226, 4582, 4583, 4594, 4593
5227, 4583, 4584, 4595, 4594
5228, 4584, 4585, 4596, 4595
5229, 4585, 4586, 4597, 4596
5230, 4586, 4587, 4598, 4597
5231, 4587, 4588, 4599, 4598
5232, 4588, 4589, 4600, 4599
5233, 4589, 4590, 4601, 4600
5234, 4590, 451, 452, 4601
5235, 372, 4591, 4602, 373
5236, 4591, 4592, 4603, 4602
5237, 4592, 4593, 4604, 4603
5238, 4593, 4594, 4605, 4604
5239, 4594, 4595, 4606, 4605
5240, 4595, 4596, 4607, 4606
5241, 4596, 4597, 4608, 4607
5242, 4597, 4598, 4609, 4608
5243, 4598, 4599, 4610, 4609
5244, 4599, 4600, 4611, 4610
5245, 4600, 4601, 4612, 4611
5246, 4601, 452, 453, 4612
5247, 373, 4602, 4613, 374
5248, 4602, 4603, 4614, 4613
5249, 4603, 4604, 4615, 4614
5250, 4604, 4605, 4616, 4615
5251, 4605, 4606, 4617, 4616
5252, 4606, 4607, 4618, 4617
5253, 4607, 4608, 4619, 4618
5254, 4608, 4609, 4620, 4619
5255, 4609, 4610, 4621, 4620
5256, 4610, 4611, 4622, 4621
5257, 4611, 4612, 4623, 4622
5258, 4612, 453, 454, 4623
5259, 374, 4613, 4624, 375
5260, 4613, 4614, 4625, 4624
5261, 4614, 4615, 4626, 4625
5262, 4615, 4616, 4627, 4626
5263, 4616, 4617, 4628, 4627
5264, 4617, 4618, 4629, 4628
5265, 4618, 4619, 4630, 4629
5266, 4619, 4620, 4631, 4630
5267, 4620, 4621, 4632, 4631
5268, 4621, 4622, 4633, 4632
5269, 4622, 4623, 4634, 4633
5270, 4623, 454, 455, 4634
5271, 375, 4624, 4635, 376
5272, 4624, 4625, 4636, 4635
5273, 4625, 4626, 4637, 4636
5274, 4626, 4627, 4638, 4637
5275, 4627, 4628, 4639, 4638
5276, 4628, 4629, 4640, 4639
5277, 4629, 4630, 4641, 4640
5278, 4630, 4631, 4642, 4641
5279, 4631, 4632, 4643, 4642
5280, 4632, 4633, 4644, 4643
5281, 4633, 4634, 4645, 4644
5282, 4634, 455, 456, 4645
5283, 376, 4635, 4646, 377
5284, 4635, 4636, 4647, 4646
5285, 4636, 4637, 4648, 4647
5286, 4637, 4638, 4649, 4648
5287, 4638, 4639, 4650, 4649
5288, 4639, 4640, 4651, 4650
5289, 4640, 4641, 4652, 4651
5290, 4641, 4642, 4653, 4652
5291, 4642, 4643, 4654, 4653
5292, 4643, 4644, 4655, 4654
5293, 4644, 4645, 4656, 4655
5294, 4645, 456, 457, 4656
5295, 377, 4646, 401, 13
5296, 4646, 4647, 402, 401
5297, 4647, 4648, 403, 402
5298, 4648, 4649, 404, 403
5299, 4649, 4650, 405, 404
5300, 4650, 4651, 406, 405
5301, 4651, 4652, 407, 406
5302, 4652, 4653, 408, 407
5303, 4653, 4654, 409, 408
5304, 4654, 4655, 410, 409
5305, 4655, 4656, 411, 410
5306, 4656, 457, 15, 411
*ELEMENT, type=CPS4, ELSET=Surface17
5307, 14, 18, 469, 355
5308, 355, 469, 470, 356
5309, 356, 470, 471, 357
5310, 357, 471, 472, 358
5311, 358, 472, 473, 359
5312, 359, 473, 474, 360
5313, 360, 474, 475, 361
5314, 361, 475, 476, 362
5315, 362, 476, 477, 363
5316, 363, 477, 478, 364
5317, 364, 478, 479, 365
5318, 365, 479, 480, 366
5319, 366, 480, 481, 367
5320, 367, 481, 482, 368
5321, 368, 482, 483, 369
5322, 369, 483, 484, 370
5323, 370, 484, 485, 371
5324, 371, 485, 486, 372
5325, 372, 486, 487, 373
5326, 373, 487, 488, 374
5327, 374, 488, 489, 375
5328, 375, 489, 490, 376
5329, 376, 490, 491, 377
5330, 377, 491, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
5331, 13, 17, 492, 401
5332, 401, 492, 493, 402
5333, 402, 493, 494, 403
5334, 403, 494, 495, 404
5335, 404, 495, 496, 405
5336, 405, 496, 497, 406
5337, 406, 497, 498, 407
5338, 407, 498, 499, 408
5339, 408, 499, 500, 409
5340, 409, 500, 501, 410
5341, 410, 501, 502, 411
5342, 411, 502, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
5343, 16, 435, 503, 20
5344, 435, 436, 504, 503
5345, 436, 437, 505, 504
5346, 437, 438, 506, 505
5347, 438, 439, 507, 506
5348, 439, 440, 508, 507
5349, 440, 441, 509, 508
5350, 441, 442, 510, 509
5351, 442, 443, 511, 510
5352, 443, 444, 512, 511
5353, 444, 445, 513, 512
5354, 445, 446, 514, 513
5355, 446, 447, 515, 514
5356, 447, 448, 516, 515
5357, 448, 449, 517, 516
5358, 449, 450, 518, 517
5359, 450, 451, 519, 518
5360, 451, 452, 520, 519
5361, 452, 453, 521, 520
5362, 453, 454, 522, 521
5363, 454, 455, 523, 522
5364, 455, 456, 524, 523
5365, 456, 457, 525, 524
5366, 457, 15, 19, 525
*ELEMENT, type=CPS4, ELSET=Surface20
5367, 14, 458, 526, 18
5368, 458, 459, 527, 526
5369, 459, 460, 528, 527
5370, 460, 461, 529, 528
5371, 461, 462, 530, 529
5372, 462, 463, 531, 530
5373, 463, 464, 532, 531
5374, 464, 465, 533, 532
5375, 465, 466, 534, 533
5376, 466, 467, 535, 534
5377, 467, 468, 536, 535
5378, 468, 16, 20, 536
*ELEMENT, type=CPS4, ELSET=Surface21
5379, 18, 526, 4657, 469
5380, 526, 527, 4658, 4657
5381, 527, 528, 4659, 4658
5382, 528, 529, 4660, 4659
5383, 529, 530, 4661, 4660
5384, 530, 531, 4662, 4661
5385, 531, 532, 4663, 4662
5386, 532, 533, 4664, 4663
5387, 533, 534, 4665, 4664
5388, 534, 535, 4666, 4665
5389, 535, 536, 4667, 4666
5390, 536, 20, 503, 4667
5391, 469, 4657, 4668, 470
5392, 4657, 4658, 4669, 4668
5393, 4658, 4659, 4670, 4669
5394, 4659, 4660, 4671, 4670
5395, 4660, 4661, 4672, 4671
5396, 4661, 4662, 4673, 4672
5397, 4662, 4663, 4674, 4673
5398, 4663, 4664, 4675, 4674
5399, 4664, 4665, 4676, 4675
5400, 4665, 4666, 4677, 4676
5401, 4666, 4667, 4678, 4677
5402, 4667, 503, 504, 4678
5403, 470, 4668, 4679, 471
5404, 4668, 4669, 4680, 4679
5405, 4669, 4670, 4681, 4680
5406, 4670, 4671, 4682, 4681
5407, 4671, 4672, 4683, 4682
5408, 4672, 4673, 4684, 4683
5409, 4673, 4674, 4685, 4684
5410, 4674, 4675, 4686, 4685
5411, 4675, 4676, 4687, 4686
5412, 4676, 4677, 4688, 4687
5413, 4677, 4678, 4689, 4688
5414, 4678, 504, 505, 4689
5415, 471, 4679, 4690, 472
5416, 4679, 4680, 4691, 4690
5417, 4680, 4681, 4692, 4691
5418, 4681, 4682, 4693, 4692
5419, 4682, 4683, 4694, 4693
5420, 4683, 4684, 4695, 4694
5421, 4684, 4685, 4696, 4695
5422, 4685, 4686, 4697, 4696
5423, 4686, 4687, 4698, 4697
5424, 4687, 4688, 4699, 4698
5425, 4688, 4689, 4700, 4699
5426, 4689, 505, 506, 4700
5427, 472, 4690, 4701, 473
5428, 4690, 4691, 4702, 4701
5429, 4691, 4692, 4703, 4702
5430, 4692, 4693, 4704, 4703
5431, 4693, 4694, 4705, 4704
5432, 4694, 4695, 4706, 4705
5433, 4695, 4696, 4707, 4706
5434, 4696, 4697, 4708, 4707
5435, 4697, 4698, 4709, 4708
5436, 4698, 4699, 4710, 4709
5437, 4699, 4700, 4711, 4710
5438, 4700, 506, 507, 4711
5439, 473, 4701, 4712, 474
5440, 4701, 4702, 4713, 4712
5441, 4702, 4703, 4714, 4713
5442, 4703, 4704, 4715, 4714
5443, 4704, 4705, 4716, 4715
5444, 4705, 4706, 4717, 4716
5445, 4706, 4707, 4718, 4717
5446, 4707, 4708, 4719, 4718
5447, 4708, 4709, 4720, 4719
5448, 4709, 4710, 4721, 4720
5449, 4710, 4711, 4722, 4721
5450, 4711, 507, 508, 4722
5451, 474, 4712, 4723, 475
5452, 4712, 4713, 4724, 4723
5453, 4713, 4714, 4725, 4724
5454, 4714, 4715, 4726, 4725
5455, 4715, 4716, 4727, 4726
5456, 4716, 4717, 4728, 4727
5457, 4717, 4718, 4729, 4728
5458, 4718, 4719, 4730, 4729
5459, 4719, 4720, 4731, 4730
5460, 4720, 4721, 4732, 4731
5461, 4721, 4722, 4733, 4732
5462, 4722, 508, 509, 4733
5463, 475, 4723, 4734, 476
5464, 4723, 4724, 4735, 4734
5465, 4724, 4725, 4736, 4735
5466, 4725, 4726, 4737, 4736
5467, 4726, 4727, 4738, 4737
5468, 4727, 4728, 4739, 4738
5469, 4728, 4729, 4740, 4739
5470, 4729, 4730, 4741, 4740
5471, 4730, 4731, 4742, 4741
5472, 4731, 4732, 4743, 4742
5473, 4732, 4733, 4744, 4743
5474, 4733, 509, 510, 4744
5475, 476, 4734, 4745, 477
5476, 4734, 4735, 4746, 4745
5477, 4735, 4736, 4747, 4746
5478, 4736, 4737, 4748, 4747
5479, 4737, 4738, 4749, 4748
5480, 4738, 4739, 4750, 4749
5481, 4739, 4740, 4751, 4750
5482, 4740, 4741, 4752, 4751
5483, 4741, 4742, 4753, 4752
5484, 4742, 4743, 4754, 4753
5485, 4743, 4744, 4755, 4754
5486, 4744, 510, 511, 4755
5487, 477, 4745, 4756, 478
5488, 4745, 4746, 4757, 4756
5489, 4746, 4747, 4758, 4757
5490, 4747, 4748, 4759, 4758
5491, 4748, 4749, 4760, 4759
5492, 4749, 4750, 4761, 4760
5493, 4750, 4751, 4762, 4761
5494, 4751, 4752, 4763, 4762
5495, 4752, 4753, 4764, 4763
5496, 4753, 4754, 4765, 4764
5497, 4754, 4755, 4766, 4765
5498, 4755, 511, 512, 4766
5499, 478, 4756, 4767, 479
5500, 4756, 4757, 4768, 4767
5501, 4757, 4758, 4769, 4768
5502, 4758, 4759, 4770, 4769
5503, 4759, 4760, 4771, 4770
5504, 4760, 4761, 4772, 4771
5505, 4761, 4762, 4773, 4772
5506, 4762, 4763, 4774, 4773
5507, 4763, 4764, 4775, 4774
5508, 4764, 4765, 4776, 4775
5509, 4765, 4766, 4777, 4776
5510, 4766, 512, 513, 4777
5511, 479, 4767, 4778, 480
5512, 4767, 4768, 4779, 4778
5513, 4768, 4769, 4780, 4779
5514, 4769, 4770, 4781, 4780
5515, 4770, 4771, 4782, 4781
5516, 4771, 4772, 4783, 4782
5517, 4772, 4773, 4784, 4783
5518, 4773, 4774, 4785, 4784
5519, 4774, 4775, 4786, 4785
5520, 4775, 4776, 4787, 4786
5521, 4776, 4777, 4788, 4787
5522, 4777, 513, 514, 4788
5523, 480, 4778, 4789, 481
5524, 4778, 4779, 4790, 4789
5525, 4779, 4780, 4791, 4790
5526, 4780, 4781, 4792, 4791
5527, 4781, 4782, 4793, 4792
5528, 4782, 4783, 4794, 4793
5529, 4783, 4784, 4795, 4794
5530, 4784, 4785, 4796, 4795
5531, 4785, 4786, 4797, 4796
5532, 4786, 4787, 4798, 4797
5533, 4787, 4788, 4799, 4798
5534, 4788, 514, 515, 4799
5535, 481, 4789, 4800, 482
5536, 4789, 4790, 4801, 4800
5537, 4790, 4791, 4802, 4801
5538, 4791, 4792, 4803, 4802
5539, 4792, 4793, 4804, 4803
5540, 4793, 4794, 4805, 4804
5541, 4794, 4795, 4806, 4805
5542, 4795, 4796, 4807, 4806
5543, 4796, 4797, 4808, 4807
5544, 4797, 4798, 4809, 4808
5545, 4798, 4799, 4810, 4809
5546, 4799, 515, 516, 4810
5547, 482, 4800, 4811, 483
5548, 4800, 4801, 4812, 4811
5549, 4801, 4802, 4813, 4812
5550, 4802, 4803, 4814, 4813
5551, 4803, 4804, 4815, 4814
5552, 4804, 4805, 4816, 4815
5553, 4805, 4806, 4817, 4816
5554, 4806, 4807, 4818, 4817
5555, 4807, 4808, 4819, 4818
5556, 4808, 4809, 4820, 4819
5557, 4809, 4810, 4821, 4820
5558, 4810, 516, 517, 4821
5559, 483, 4811, 4822, 484
5560, 4811, 4812, 4823, 4822
5561, 4812, 4813, 4824, 4823
5562, 4813, 4814, 4825, 4824
5563, 4814, 4815, 4826, 4825
5564, 4815, 4816, 4827, 4826
5565, 4816, 4817, 4828, 4827
5566, 4817, 4818, 4829, 4828
5567, 4818, 4819, 4830, 4829
5568, 4819, 4820, 4831, 4830
5569, 4820, 4821, 4832, 4831
5570, 4821, 517, 518, 4832
5571, 484, 4822, 4833, 485
5572, 4822, 4823, 4834, 4833
5573, 4823, 4824, 4835, 4834
5574, 4824, 4825, 4836, 4835
5575, 4825, 4826, 4837, 4836
5576, 4826, 4827, 4838, 4837
5577, 4827, 4828, 4839, 4838
5578, 4828, 4829, 4840, 4839
5579, 4829, 4830, 4841, 4840
5580, 4830, 4831, 4842, 4841
5581, 4831, 4832, 4843, 4842
5582, 4832, 518, 519, 4843
5583, 485, 4833, 4844, 486
5584, 4833, 4834, 4845, 4844
5585, 4834, 4835, 4846, 4845
5586, 4835, 4836, 4847, 4846
5587, 4836, 4837, 4848, 4847
5588, 4837, 4838, 4849, 4848
5589, 4838, 4839, 4850, 4849
5590, 4839, 4840, 4851, 4850
5591, 4840, 4841, 4852, 4851
5592, 4841, 4842, 4853, 4852
5593, 4842, 4843, 4854, 4853
5594, 4843, 519, 520, 4854
5595, 486, 4844, 4855, 487
5596, 4844, 4845, 4856, 4855
5597, 4845, 4846, 4857, 4856
5598, 4846, 4847, 4858, 4857
5599, 4847, 4848, 4859, 4858
5600, 4848, 4849, 4860, 4859
5601, 4849, 4850, 4861, 4860
5602, 4850, 4851, 4862, 4861
5603, 4851, 4852, 4863, 4862
5604, 4852, 4853, 4864, 4863
5605, 4853, 4854, 4865, 4864
5606, 4854, 520, 521, 4865
5607, 487, 4855, 4866, 488
5608, 4855, 4856, 4867, 4866
5609, 4856, 4857, 4868, 4867
5610, 4857, 4858, 4869, 4868
5611, 4858, 4859, 4870, 4869
5612, 4859, 4860, 4871, 4870
5613, 4860, 4861, 4872, 4871
5614, 4861, 4862, 4873, 4872
5615, 4862, 4863, 4874, 4873
5616, 4863, 4864, 4875, 4874
5617, 4864, 4865, 4876, 4875
5618, 4865, 521, 522, 4876
5619, 488, 4866, 4877, 489
5620, 4866, 4867, 4878, 4877
5621, 4867, 4868, 4879, 4878
5622, 4868, 4869, 4880, 4879
5623, 4869, 4870, 4881, 4880
5624, 4870, 4871, 4882, 4881
5625, 4871, 4872, 4883, 4882
5626, 4872, 4873, 4884, 4883
5627, 4873, 4874, 4885, 4884
5628, 4874, 4875, 4886, 4885
5629, 4875, 4876, 4887, 4886
5630, 4876, 522, 523, 4887
5631, 489, 4877, 4888, 490
5632, 4877, 4878, 4889, 4888
5633, 4878, 4879, 4890, 4889
5634, 4879, 4880, 4891, 4890
5635, 4880, 4881, 4892, 4891
5636, 4881, 4882, 4893, 4892
5637, 4882, 4883, 4894, 4893
5638, 4883, 4884, 4895, 4894
5639, 4884, 4885, 4896, 4895
5640, 4885, 4886, 4897, 4896
5641, 4886, 4887, 4898, 4897
5642, 4887, 523, 524, 4898
5643, 490, 4888, 4899, 491
5644, 4888, 4889, 4900, 4899
5645, 4889, 4890, 4901, 4900
5646, 4890, 4891, 4902, 4901
5647, 4891, 4892, 4903, 4902
5648, 4892, 4893, 4904, 4903
5649, 4893, 4894, 4905, 4904
5650, 4894, 4895, 4906, 4905
5651, 4895, 4896, 4907, 4906
5652, 4896, 4897, 4908, 4907
5653, 4897, 4898, 4909, 4908
5654, 4898, 524, 525, 4909
5655, 491, 4899, 492, 17
5656, 4899, 4900, 493, 492
5657, 4900, 4901, 494, 493
5658, 4901, 4902, 495, 494
5659, 4902, 4903, 496, 495
5660, 4903, 4904, 497, 496
5661, 4904, 4905, 498, 497
5662, 4905, 4906, 499, 498
5663, 4906, 4907, 500, 499
5664, 4907, 4908, 501, 500
5665, 4908, 4909, 502, 501
5666, 4909, 525, 19, 502
*ELEMENT, type=CPS4, ELSET=Surface22
5667, 18, 539, 4910, 469
5668, 539, 540, 4911, 4910
5669, 540, 22, 541, 4911
5670, 469, 4910, 4912, 470
5671, 4910, 4911, 4913, 4912
5672, 4911, 541, 542, 4913
5673, 470, 4912, 4914, 471
5674, 4912, 4913, 4915, 4914
5675, 4913, 542, 543, 4915
5676, 471, 4914, 4916, 472
5677, 4914, 4915, 4917, 4916
5678, 4915, 543, 544, 4917
5679, 472, 4916, 4918, 473
5680, 4916, 4917, 4919, 4918
5681, 4917, 544, 545, 4919
5682, 473, 4918, 4920, 474
5683, 4918, 4919, 4921, 4920
5684, 4919, 545, 546, 4921
5685, 474, 4920, 4922, 475
5686, 4920, 4921, 4923, 4922
5687, 4921, 546, 547, 4923
5688, 475, 4922, 4924, 476
5689, 4922, 4923, 4925, 4924
5690, 4923, 547, 548, 4925
5691, 476, 4924, 4926, 477
5692, 4924, 4925, 4927, 4926
5693, 4925, 548, 549, 4927
5694, 477, 4926, 4928, 478
5695, 4926, 4927, 4929, 4928
5696, 4927, 549, 550, 4929
5697, 478, 4928, 4930, 479
5698, 4928, 4929, 4931, 4930
5699, 4929, 550, 551, 4931
5700, 479, 4930, 4932, 480
5701, 4930, 4931, 4933, 4932
5702, 4931, 551, 552, 4933
5703, 480, 4932, 4934, 481
5704, 4932, 4933, 4935, 4934
5705, 4933, 552, 553, 4935
5706, 481, 4934, 4936, 482
5707, 4934, 4935, 4937, 4936
5708, 4935, 553, 554, 4937
5709, 482, 4936, 4938, 483
5710, 4936, 4937, 4939, 4938
5711, 4937, 554, 555, 4939
5712, 483, 4938, 4940, 484
5713, 4938, 4939, 4941, 4940
5714, 4939, 555, 556, 4941
5715, 484, 4940, 4942, 485
5716, 4940, 4941, 4943, 4942
5717, 4941, 556, 557, 4943
5718, 485, 4942, 4944, 486
5719, 4942, 4943, 4945, 4944
5720, 4943, 557, 558, 4945
5721, 486, 4944, 4946, 487
5722, 4944, 4945, 4947, 4946
5723, 4945, 558, 559, 4947
5724, 487, 4946, 4948, 488
5725, 4946, 4947, 4949, 4948
5726, 4947, 559, 560, 4949
5727, 488, 4948, 4950, 489
5728, 4948, 4949, 4951, 4950
5729, 4949, 560, 561, 4951
5730, 489, 4950, 4952, 490
5731, 4950, 4951, 4953, 4952
5732, 4951, 561, 562, 4953
5733, 490, 4952, 4954, 491
5734, 4952, 4953, 4955, 4954
5735, 4953, 562, 563, 4955
5736, 491, 4954, 537, 17
5737, 4954, 4955, 538, 537
5738, 4955, 563, 21, 538
*ELEMENT, type=CPS4, ELSET=Surface23
5739, 17, 537, 4956, 492
5740, 537, 538, 4957, 4956
5741, 538, 21, 566, 4957
5742, 492, 4956, 4958, 493
5743, 4956, 4957, 4959, 4958
5744, 4957, 566, 567, 4959
5745, 493, 4958, 4960, 494
5746, 4958, 4959, 4961, 4960
5747, 4959, 567, 568, 4961
5748, 494, 4960, 4962, 495
5749, 4960, 4961, 4963, 4962
5750, 4961, 568, 569, 4963
5751, 495, 4962, 4964, 496
5752, 4962, 4963, 4965, 4964
5753, 4963, 569, 570, 4965
5754, 496, 4964, 4966, 497
5755, 4964, 4965, 4967, 4966
5756, 4965, 570, 571, 4967
5757, 497, 4966, 4968, 498
5758, 4966, 4967, 4969, 4968
5759, 4967, 571, 572, 4969
5760, 498, 4968, 4970, 499
5761, 4968, 4969, 4971, 4970
5762, 4969, 572, 573, 4971
5763, 499, 4970, 4972, 500
5764, 4970, 4971, 4973, 4972
5765, 4971, 573, 574, 4973
5766, 500, 4972, 4974, 501
5767, 4972, 4973, 4975, 4974
5768, 4973, 574, 575, 4975
5769, 501, 4974, 4976, 502
5770, 4974, 4975, 4977, 4976
5771, 4975, 575, 576, 4977
5772, 502, 4976, 564, 19
5773, 4976, 4977, 565, 564
5774, 4977, 576, 23, 565
*ELEMENT, type=CPS4, ELSET=Surface24
5775, 20, 503, 4978, 577
5776, 577, 4978, 4979, 578
5777, 578, 4979, 579, 24
5778, 503, 504, 4980, 4978
5779, 4978, 4980, 4981, 4979
5780, 4979, 4981, 580, 579
5781, 504, 505, 4982, 4980
5782, 4980, 4982, 4983, 4981
5783, 4981, 4983, 581, 580
5784, 505, 506, 4984, 4982
5785, 4982, 4984, 4985, 4983
5786, 4983, 4985, 582, 581
5787, 506, 507, 4986, 4984
5788, 4984, 4986, 4987, 4985
5789, 4985, 4987, 583, 582
5790, 507, 508, 4988, 4986
5791, 4986, 4988, 4989, 4987
5792, 4987, 4989, 584, 583
5793, 508, 509, 4990, 4988
5794, 4988, 4990, 4991, 4989
5795, 4989, 4991, 585, 584
5796, 509, 510, 4992, 4990
5797, 4990, 4992, 4993, 4991
5798, 4991, 4993, 586, 585
5799, 510, 511, 4994, 4992
5800, 4992, 4994, 4995, 4993
5801, 4993, 4995, 587, 586
5802, 511, 512, 4996, 4994
5803, 4994, 4996, 4997, 4995
5804, 4995, 4997, 588, 587
5805, 512, 513, 4998, 4996
5806, 4996, 4998, 4999, 4997
5807, 4997, 4999, 589, 588
5808, 513, 514, 5000, 4998
5809, 4998, 5000, 5001, 4999
5810, 4999, 5001, 590, 589
5811, 514, 515, 5002, 5000
5812, 5000, 5002, 5003, 5001
5813, 5001, 5003, 591, 590
5814, 515, 516, 5004, 5002
5815, 5002, 5004, 5005, 5003
5816, 5003, 5005, 592, 591
5817, 516, 517, 5006, 5004
5818, 5004, 5006, 5007, 5005
5819, 5005, 5007, 593, 592
5820, 517, 518, 5008, 5006
5821, 5006, 5008, 5009, 5007
5822, 5007, 5009, 594, 593
5823, 518, 519, 5010, 5008
5824, 5008, 5010, 5011, 5009
5825, 5009, 5011, 595, 594
5826, 519, 520, 5012, 5010
5827, 5010, 5012, 5013, 5011
5828, 5011, 5013, 596, 595
5829, 520, 521, 5014, 5012
5830, 5012, 5014, 5015, 5013
5831, 5013, 5015, 597, 596
5832, 521, 522, 5016, 5014
5833, 5014, 5016, 5017, 5015
5834, 5015, 5017, 598, 597
5835, 522, 523, 5018, 5016
5836, 5016, 5018, 5019, 5017
5837, 5017, 5019, 599, 598
5838, 523, 524, 5020, 5018
5839, 5018, 5020, 5021, 5019
5840, 5019, 5021, 600, 599
5841, 524, 525, 5022, 5020
5842, 5020, 5022, 5023, 5021
5843, 5021, 5023, 601, 600
5844, 525, 19, 564, 5022
5845, 5022, 564, 565, 5023
5846, 5023, 565, 23, 601
*ELEMENT, type=CPS4, ELSET=Surface25
5847, 18, 526, 5024, 539
5848, 539, 5024, 5025, 540
5849, 540, 5025, 602, 22
5850, 526, 527, 5026, 5024
5851, 5024, 5026, 5027, 5025
5852, 5025, 5027, 603, 602
5853, 527, 528, 5028, 5026
5854, 5026, 5028, 5029, 5027
5855, 5027, 5029, 604, 603
5856, 528, 529, 5030, 5028
5857, 5028, 5030, 5031, 5029
5858, 5029, 5031, 605, 604
5859, 529, 530, 5032, 5030
5860, 5030, 5032, 5033, 5031
5861, 5031, 5033, 606, 605
5862, 530, 531, 5034, 5032
5863, 5032, 5034, 5035, 5033
5864, 5033, 5035, 607, 606
5865, 531, 532, 5036, 5034
5866, 5034, 5036, 5037, 5035
5867, 5035, 5037, 608, 607
5868, 532, 533, 5038, 5036
5869, 5036, 5038, 5039, 5037
5870, 5037, 5039, 609, 608
5871, 533, 534, 5040, 5038
5872, 5038, 5040, 5041, 5039
5873, 5039, 5041, 610, 609
5874, 534, 535, 5042, 5040
5875, 5040, 5042, 5043, 5041
5876, 5041, 5043, 611, 610
5877, 535, 536, 5044, 5042
5878, 5042, 5044, 5045, 5043
5879, 5043, 5045, 612, 611
5880, 536, 20, 577, 5044
5881, 5044, 577, 578, 5045
5882, 5045, 578, 24, 612
*ELEMENT, type=CPS4, ELSET=Surface26
5883, 22, 602, 5046, 541
5884, 602, 603, 5047, 5046
5885, 603, 604, 5048, 5047
5886, 604, 605, 5049, 5048
5887, 605, 606, 5050, 5049
5888, 606, 607, 5051, 5050
5889, 607, 608, 5052, 5051
5890, 608, 609, 5053, 5052
5891, 609, 610, 5054, 5053
5892, 610, 611, 5055, 5054
5893, 611, 612, 5056, 5055
5894, 612, 24, 579, 5056
5895, 541, 5046, 5057, 542
5896, 5046, 5047, 5058, 5057
5897, 5047, 5048, 5059, 5058
5898, 5048, 5049, 5060, 5059
5899, 5049, 5050, 5061, 5060
5900, 5050, 5051, 5062, 5061
5901, 5051, 5052, 5063, 5062
5902, 5052, 5053, 5064, 5063
5903, 5053, 5054, 5065, 5064
5904, 5054, 5055, 5066, 5065
5905, 5055, 5056, 5067, 5066
5906, 5056, 579, 580, 5067
5907, 542, 5057, 5068, 543
5908, 5057, 5058, 5069, 5068
5909, 5058, 5059, 5070, 5069
5910, 5059, 5060, 5071, 5070
5911, 5060, 5061, 5072, 5071
5912, 5061, 5062, 5073, 5072
5913, 5062, 5063, 5074, 5073
5914, 5063, 5064, 5075, 5074
5915, 5064, 5065, 5076, 5075
5916, 5065, 5066, 5077, 5076
5917, 5066, 5067, 5078, 5077
5918, 5067, 580, 581, 5078
5919, 543, 5068, 5079, 544
5920, 5068, 5069, 5080, 5079
5921, 5069, 5070, 5081, 5080
5922, 5070, 5071, 5082, 5081
5923, 5071, 5072, 5083, 5082
5924, 5072, 5073, 5084, 5083
5925, 5073, 5074, 5085, 5084
5926, 5074, 5075, 5086, 5085
5927, 5075, 5076, 5087, 5086
5928, 5076, 5077, 5088, 5087
5929, 5077, 5078, 5089, 5088
5930, 5078, 581, 582, 5089
5931, 544, 5079, 5090, 545
5932, 5079, 5080, 5091, 5090
5933, 5080, 5081, 5092, 5091
5934, 5081, 5082, 5093, 5092
5935, 5082, 5083, 5094, 5093
5936, 5083, 5084, 5095, 5094
5937, 5084, 5085, 5096, 5095
5938, 5085, 5086, 5097, 5096
5939, 5086, 5087, 5098, 5097
5940, 5087, 5088, 5099, 5098
5941, 5088, 5089, 5100, 5099
5942, 5089, 582, 583, 5100
5943, 545, 5090, 5101, 546
5944, 5090, 5091, 5102, 5101
5945, 5091, 5092, 5103, 5102
5946, 5092, 5093, 5104, 5103
5947, 5093, 5094, 5105, 5104
5948, 5094, 5095, 5106, 5105
5949, 5095, 5096, 5107, 5106
5950, 5096, 5097, 5108, 5107
5951, 5097, 5098, 5109, 5108
5952, 5098, 5099, 5110, 5109
5953, 5099, 5100, 5111, 5110
5954, 5100, 583, 584, 5111
5955, 546, 5101, 5112, 547
5956, 5101, 5102, 5113, 5112
5957, 5102, 5103, 5114, 5113
5958, 5103, 5104, 5115, 5114
5959, 5104, 5105, 5116, 5115
5960, 5105, 5106, 5117, 5116
5961, 5106, 5107, 5118, 5117
5962, 5107, 5108, 5119, 5118
5963, 5108, 5109, 5120, 5119
5964, 5109, 5110, 5121, 5120
5965, 5110, 5111, 5122, 5121
5966, 5111, 584, 585, 5122
5967, 547, 5112, 5123, 548
5968, 5112, 5113, 5124, 5123
5969, 5113, 5114, 5125, 5124
5970, 5114, 5115, 5126, 5125
5971, 5115, 5116, 5127, 5126
5972, 5116, 5117, 5128, 5127
5973, 5117, 5118, 5129, 5128
5974, 5118, 5119, 5130, 5129
5975, 5119, 5120, 5131, 5130
5976, 5120, 5121, 5132, 5131
5977, 5121, 5122, 5133, 5132
5978, 5122, 585, 586, 5133
5979, 548, 5123, 5134, 549
5980, 5123, 5124, 5135, 5134
5981, 5124, 5125, 5136, 5135
5982, 5125, 5126, 5137, 5136
5983, 5126, 5127, 5138, 5137
5984, 5127, 5128, 5139, 5138
5985, 5128, 5129, 5140, 5139
5986, 5129, 5130, 5141, 5140
5987, 5130, 5131, 5142, 5141
5988, 5131, 5132, 5143, 5142
5989, 5132, 5133, 5144, 5143
5990, 5133, 586, 587, 5144
5991, 549, 5134, 5145, 550
5992, 5134, 5135, 5146, 5145
5993, 5135, 5136, 5147, 5146
5994, 5136, 5137, 5148, 5147
5995, 5137, 5138, 5149, 5148
5996, 5138, 5139, 5150, 5149
5997, 5139, 5140, 5151, 5150
5998, 5140, 5141, 5152, 5151
5999, 5141, 5142, 5153, 5152
6000, 5142, 5143, 5154, 5153
6001, 5143, 5144, 5155, 5154
6002, 5144, 587, 588, 5155
6003, 550, 5145, 5156, 551
6004, 5145, 5146, 5157, 5156
6005, 5146, 5147, 5158, 5157
6006, 5147, 5148, 5159, 5158
6007, 5148, 5149, 5160, 5159
6008, 5149, 5150, 5161, 5160
6009, 5150, 5151, 5162, 5161
6010, 5151, 5152, 5163, 5162
6011, 5152, 5153, 5164, 5163
6012, 5153, 5154, 5165, 5164
6013, 5154, 5155, 5166, 5165
6014, 5155, 588, 589, 5166
6015, 551, 5156, 5167, 552
6016, 5156, 5157, 5168, 5167
6017, 5157, 5158, 5169, 5168
6018, 5158, 5159, 5170, 5169
6019, 5159, 5160, 5171, 5170
6020, 5160, 5161, 5172, 5171
6021, 5161, 5162, 5173, 5172
6022, 5162, 5163, 5174, 5173
6023, 5163, 5164, 5175, 5174
6024, 5164, 5165, 5176, 5175
6025, 5165, 5166, 5177, 5176
6026, 5166, 589, 590, 5177
6027, 552, 5167, 5178, 553
6028, 5167, 5168, 5179, 5178
6029, 5168, 5169, 5180, 5179
6030, 5169, 5170, 5181, 5180
6031, 5170, 5171, 5182, 5181
6032, 5171, 5172, 5183, 5182
6033, 5172, 5173, 5184, 5183
6034, 5173, 5174, 5185, 5184
6035, 5174, 5175, 5186, 5185
6036, 5175, 5176, 5187, 5186
6037, 5176, 5177, 5188, 5187
6038, 5177, 590, 591, 5188
6039, 553, 5178, 5189, 554
6040, 5178, 5179, 5190, 5189
6041, 5179, 5180, 5191, 5190
6042, 5180, 5181, 5192, 5191
6043, 5181, 5182, 5193, 5192
6044, 5182, 5183, 5194, 5193
6045, 5183, 5184, 5195, 5194
6046, 5184, 5185, 5196, 5195
6047, 5185, 5186, 5197, 5196
6048, 5186, 5187, 5198, 5197
6049, 5187, 5188, 5199, 5198
6050, 5188, 591, 592, 5199
6051, 554, 5189, 5200, 555
6052, 5189, 5190, 5201, 5200
6053, 5190, 5191, 5202, 5201
6054, 5191, 5192, 5203, 5202
6055, 5192, 5193, 5204, 5203
6056, 5193, 5194, 5205, 5204
6057, 5194, 5195, 5206, 5205
6058, 5195, 5196, 5207, 5206
6059, 5196, 5197, 5208, 5207
6060, 5197, 5198, 5209, 5208
6061, 5198, 5199, 5210, 5209
6062, 5199, 592, 593, 5210
6063, 555, 5200, 5211, 556
6064, 5200, 5201, 5212, 5211
6065, 5201, 5202, 5213, 5212
6066, 5202, 5203, 5214, 5213
6067, 5203, 5204, 5215, 5214
6068, 5204, 5205, 5216, 5215
6069, 5205, 5206, 5217, 5216
6070, 5206, 5207, 5218, 5217
6071, 5207, 5208, 5219, 5218
6072, 5208, 5209, 5220, 5219
6073, 5209, 5210, 5221, 5220
6074, 5210, 593, 594, 5221
6075, 556, 5211, 5222, 557
6076, 5211, 5212, 5223, 5222
6077, 5212, 5213, 5224, 5223
6078, 5213, 5214, 5225, 5224
6079, 5214, 5215, 5226, 5225
6080, 5215, 5216, 5227, 5226
6081, 5216, 5217, 5228, 5227
6082, 5217, 5218, 5229, 5228
6083, 5218, 5219, 5230, 5229
6084, 5219, 5220, 5231, 5230
6085, 5220, 5221, 5232, 5231
6086, 5221, 594, 595, 5232
6087, 557, 5222, 5233, 558
6088, 5222, 5223, 5234, 5233
6089, 5223, 5224, 5235, 5234
6090, 5224, 5225, 5236, 5235
6091, 5225, 5226, 5237, 5236
6092, 5226, 5227, 5238, 5237
6093, 5227, 5228, 5239, 5238
6094, 5228, 5229, 5240, 5239
6095, 5229, 5230, 5241, 5240
6096, 5230, 5231, 5242, 5241
6097, 5231, 5232, 5243, 5242
6098, 5232, 595, 596, 5243
6099, 558, 5233, 5244, 559
6100, 5233, 5234, 5245, 5244
6101, 5234, 5235, 5246, 5245
6102, 5235, 5236, 5247, 5246
6103, 5236, 5237, 5248, 5247
6104, 5237, 5238, 5249, 5248
6105, 5238, 5239, 5250, 5249
6106, 5239, 5240, 5251, 5250
6107, 5240, 5241, 5252, 5251
6108, 5241, 5242, 5253, 5252
6109, 5242, 5243, 5254, 5253
6110, 5243, 596, 597, 5254
6111, 559, 5244, 5255, 560
6112, 5244, 5245, 5256, 5255
6113, 5245, 5246, 5257, 5256
6114, 5246, 5247, 5258, 5257
6115, 5247, 5248, 5259, 5258
6116, 5248, 5249, 5260, 5259
6117, 5249, 5250, 5261, 5260
6118, 5250, 5251, 5262, 5261
6119, 5251, 5252, 5263, 5262
6120, 5252, 5253, 5264, 5263
6121, 5253, 5254, 5265, 5264
6122, 5254, 597, 598, 5265
6123, 560, 5255, 5266, 561
6124, 5255, 5256, 5267, 5266
6125, 5256, 5257, 5268, 5267
6126, 5257, 5258, 5269, 5268
6127, 5258, 5259, 5270, 5269
6128, 5259, 5260, 5271, 5270
6129, 5260, 5261, 5272, 5271
6130, 5261, 5262, 5273, 5272
6131, 5262, 5263, 5274, 5273
6132, 5263, 5264, 5275, 5274
6133, 5264, 5265, 5276, 5275
6134, 5265, 598, 599, 5276
6135, 561, 5266, 5277, 562
6136, 5266, 5267, 5278, 5277
6137, 5267, 5268, 5279, 5278
6138, 5268, 5269, 5280, 5279
6139, 5269, 5270, 5281, 5280
6140, 5270, 5271, 5282, 5281
6141, 5271, 5272, 5283, 5282
6142, 5272, 5273, 5284, 5283
6143, 5273, 5274, 5285, 5284
6144, 5274, 5275, 5286, 5285
6145, 5275, 5276, 5287, 5286
6146, 5276, 599, 600, 5287
6147, 562, 5277, 5288, 563
6148, 5277, 5278, 5289, 5288
6149, 5278, 5279, 5290, 5289
6150, 5279, 5280, 5291, 5290
6151, 5280, 5281, 5292, 5291
6152, 5281, 5282, 5293, 5292
6153, 5282, 5283, 5294, 5293
6154, 5283, 5284, 5295, 5294
6155, 5284, 5285, 5296, 5295
6156, 5285, 5286, 5297, 5296
6157, 5286, 5287, 5298, 5297
6158, 5287, 600, 601, 5298
6159, 563, 5288, 566, 21
6160, 5288, 5289, 567, 566
6161, 5289, 5290, 568, 567
6162, 5290, 5291, 569, 568
6163, 5291, 5292, 570, 569
6164, 5292, 5293, 571, 570
6165, 5293, 5294, 572, 571
6166, 5294, 5295, 573, 572
6167, 5295, 5296, 574, 573
6168, 5296, 5297, 575, 574
6169, 5297, 5298, 576, 575
6170, 5298, 601, 23, 576
*ELEMENT, type=CPS4, ELSET=Surface27
6171, 19, 613, 5299, 564
6172, 613, 614, 5300, 5299
6173, 614, 615, 5301, 5300
6174, 615, 616, 5302, 5301
6175, 616, 25, 621, 5302
6176, 564, 5299, 5303, 565
6177, 5299, 5300, 5304, 5303
6178, 5300, 5301, 5305, 5304
6179, 5301, 5302, 5306, 5305
6180, 5302, 621, 622, 5306
6181, 565, 5303, 617, 23
6182, 5303, 5304, 618, 617
6183, 5304, 5305, 619, 618
6184, 5305, 5306, 620, 619
6185, 5306, 622, 26, 620
*ELEMENT, type=CPS4, ELSET=Surface28
6186, 17, 537, 5307, 623
6187, 623, 5307, 5308, 624
6188, 624, 5308, 5309, 625
6189, 625, 5309, 5310, 626
6190, 626, 5310, 631, 27
6191, 537, 538, 5311, 5307
6192, 5307, 5311, 5312, 5308
6193, 5308, 5312, 5313, 5309
6194, 5309, 5313, 5314, 5310
6195, 5310, 5314, 632, 631
6196, 538, 21, 627, 5311
6197, 5311, 627, 628, 5312
6198, 5312, 628, 629, 5313
6199, 5313, 629, 630, 5314
6200, 5314, 630, 28, 632
*ELEMENT, type=CPS4, ELSET=Surface29
6201, 17, 623, 5315, 492
6202, 623, 624, 5316, 5315
6203, 624, 625, 5317, 5316
6204, 625, 626, 5318, 5317
6205, 626, 27, 633, 5318
6206, 492, 5315, 5319, 493
6207, 5315, 5316, 5320, 5319
6208, 5316, 5317, 5321, 5320
6209, 5317, 5318, 5322, 5321
6210, 5318, 633, 634, 5322
6211, 493, 5319, 5323, 494
6212, 5319, 5320, 5324, 5323
6213, 5320, 5321, 5325, 5324
6214, 5321, 5322, 5326, 5325
6215, 5322, 634, 635, 5326
6216, 494, 5323, 5327, 495
6217, 5323, 5324, 5328, 5327
6218, 5324, 5325, 5329, 5328
6219, 5325, 5326, 5330, 5329
6220, 5326, 635, 636, 5330
6221, 495, 5327, 5331, 496
6222, 5327, 5328, 5332, 5331
6223, 5328, 5329, 5333, 5332
6224, 5329, 5330, 5334, 5333
6225, 5330, 636, 637, 5334
6226, 496, 5331, 5335, 497
6227, 5331, 5332, 5336, 5335
6228, 5332, 5333, 5337, 5336
6229, 5333, 5334, 5338, 5337
6230, 5334, 637, 638, 5338
6231, 497, 5335, 5339, 498
6232, 5335, 5336, 5340, 5339
6233, 5336, 5337, 5341, 5340
6234, 5337, 5338, 5342, 5341
6235, 5338, 638, 639, 5342
6236, 498, 5339, 5343, 499
6237, 5339, 5340, 5344, 5343
6238, 5340, 5341, 5345, 5344
6239, 5341, 5342, 5346, 5345
6240, 5342, 639, 640, 5346
6241, 499, 5343, 5347, 500
6242, 5343, 5344, 5348, 5347
6243, 5344, 5345, 5349, 5348
6244, 5345, 5346, 5350, 5349
6245, 5346, 640, 641, 5350
6246, 500, 5347, 5351, 501
6247, 5347, 5348, 5352, 5351
6248, 5348, 5349, 5353, 5352
6249, 5349, 5350, 5354, 5353
6250, 5350, 641, 642, 5354
6251, 501, 5351, 5355, 502
6252, 5351, 5352, 5356, 5355
6253, 5352, 5353, 5357, 5356
6254, 5353, 5354, 5358, 5357
6255, 5354, 642, 643, 5358
6256, 502, 5355, 613, 19
6257, 5355, 5356, 614, 613
6258, 5356, 5357, 615, 614
6259, 5357, 5358, 616, 615
6260, 5358, 643, 25, 616
*ELEMENT, type=CPS4, ELSET=Surface30
6261, 21, 566, 5359, 627
6262, 627, 5359, 5360, 628
6263, 628, 5360, 5361, 629
6264, 629, 5361, 5362, 630
6265, 630, 5362, 644, 28
6266, 566, 567, 5363, 5359
6267, 5359, 5363, 5364, 5360
6268, 5360, 5364, 5365, 5361
6269, 5361, 5365, 5366, 5362
6270, 5362, 5366, 645, 644
6271, 567, 568, 5367, 5363
6272, 5363, 5367, 5368, 5364
6273, 5364, 5368, 5369, 5365
6274, 5365, 5369, 5370, 5366
6275, 5366, 5370, 646, 645
6276, 568, 569, 5371, 5367
6277, 5367, 5371, 5372, 5368
6278, 5368, 5372, 5373, 5369
6279, 5369, 5373, 5374, 5370
6280, 5370, 5374, 647, 646
6281, 569, 570, 5375, 5371
6282, 5371, 5375, 5376, 5372
6283, 5372, 5376, 5377, 5373
6284, 5373, 5377, 5378, 5374
6285, 5374, 5378, 648, 647
6286, 570, 571, 5379, 5375
6287, 5375, 5379, 5380, 5376
6288, 5376, 5380, 5381, 5377
6289, 5377, 5381, 5382, 5378
6290, 5378, 5382, 649, 648
6291, 571, 572, 5383, 5379
6292, 5379, 5383, 5384, 5380
6293, 5380, 5384, 5385, 5381
6294, 5381, 5385, 5386, 5382
6295, 5382, 5386, 650, 649
6296, 572, 573, 5387, 5383
6297, 5383, 5387, 5388, 5384
6298, 5384, 5388, 5389, 5385
6299, 5385, 5389, 5390, 5386
6300, 5386, 5390, 651, 650
6301, 573, 574, 5391, 5387
6302, 5387, 5391, 5392, 5388
6303, 5388, 5392, 5393, 5389
6304, 5389, 5393, 5394, 5390
6305, 5390, 5394, 652, 651
6306, 574, 575, 5395, 5391
6307, 5391, 5395, 5396, 5392
6308, 5392, 5396, 5397, 5393
6309, 5393, 5397, 5398, 5394
6310, 5394, 5398, 653, 652
6311, 575, 576, 5399, 5395
6312, 5395, 5399, 5400, 5396
6313, 5396, 5400, 5401, 5397
6314, 5397, 5401, 5402, 5398
6315, 5398, 5402, 654, 653
6316, 576, 23, 617, 5399
6317, 5399, 617, 618, 5400
6318, 5400, 618, 619, 5401
6319, 5401, 619, 620, 5402
6320, 5402, 620, 26, 654
*ELEMENT, type=CPS4, ELSET=Surface31
6321, 27, 631, 5403, 633
6322, 631, 632, 5404, 5403
6323, 632, 28, 644, 5404
6324, 633, 5403, 5405, 634
6325, 5403, 5404, 5406, 5405
6326, 5404, 644, 645, 5406
6327, 634, 5405, 5407, 635
6328, 5405, 5406, 5408, 5407
6329, 5406, 645, 646, 5408
6330, 635, 5407, 5409, 636
6331, 5407, 5408, 5410, 5409
6332, 5408, 646, 647, 5410
6333, 636, 5409, 5411, 637
6334, 5409, 5410, 5412, 5411
6335, 5410, 647, 648, 5412
6336, 637, 5411, 5413, 638
6337, 5411, 5412, 5414, 5413
6338, 5412, 648, 649, 5414
6339, 638, 5413, 5415, 639
6340, 5413, 5414, 5416, 5415
6341, 5414, 649, 650, 5416
6342, 639, 5415, 5417, 640
6343, 5415, 5416, 5418, 5417
6344, 5416, 650, 651, 5418
6345, 640, 5417, 5419, 641
6346, 5417, 5418, 5420, 5419
6347, 5418, 651, 652, 5420
6348, 641, 5419, 5421, 642
6349, 5419, 5420, 5422, 5421
6350, 5420, 652, 653, 5422
6351, 642, 5421, 5423, 643
6352, 5421, 5422, 5424, 5423
6353, 5422, 653, 654, 5424
6354, 643, 5423, 621, 25
6355, 5423, 5424, 622, 621
6356, 5424, 654, 26, 622
*ELEMENT, type=CPS4, ELSET=Surface32
6357, 25, 655, 5425, 621
6358, 655, 656, 5426, 5425
6359, 656, 657, 5427, 5426
6360, 657, 658, 5428, 5427
6361, 658, 659, 5429, 5428
6362, 659, 660, 5430, 5429
6363, 660, 661, 5431, 5430
6364, 661, 662, 5432, 5431
6365, 662, 663, 5433, 5432
6366, 663, 664, 5434, 5433
6367, 664, 665, 5435, 5434
6368, 665, 666, 5436, 5435
6369, 666, 667, 5437, 5436
6370, 667, 668, 5438, 5437
6371, 668, 669, 5439, 5438
6372, 669, 670, 5440, 5439
6373, 670, 671, 5441, 5440
6374, 671, 672, 5442, 5441
6375, 672, 673, 5443, 5442
6376, 673, 674, 5444, 5443
6377, 674, 675, 5445, 5444
6378, 675, 676, 5446, 5445
6379, 676, 677, 5447, 5446
6380, 677, 29, 701, 5447
6381, 621, 5425, 5448, 622
6382, 5425, 5426, 5449, 5448
6383, 5426, 5427, 5450, 5449
6384, 5427, 5428, 5451, 5450
6385, 5428, 5429, 5452, 5451
6386, 5429, 5430, 5453, 5452
6387, 5430, 5431, 5454, 5453
6388, 5431, 5432, 5455, 5454
6389, 5432, 5433, 5456, 5455
6390, 5433, 5434, 5457, 5456
6391, 5434, 5435, 5458, 5457
6392, 5435, 5436, 5459, 5458
6393, 5436, 5437, 5460, 5459
6394, 5437, 5438, 5461, 5460
6395, 5438, 5439, 5462, 5461
6396, 5439, 5440, 5463, 5462
6397, 5440, 5441, 5464, 5463
6398, 5441, 5442, 5465, 5464
6399, 5442, 5443, 5466, 5465
6400, 5443, 5444, 5467, 5466
6401, 5444, 5445, 5468, 5467
6402, 5445, 5446, 5469, 5468
6403, 5446, 5447, 5470, 5469
6404, 5447, 701, 702, 5470
6405, 622, 5448, 678, 26
6406, 5448, 5449, 679, 678
6407, 5449, 5450, 680, 679
6408, 5450, 5451, 681, 680
6409, 5451, 5452, 682, 681
6410, 5452, 5453, 683, 682
6411, 5453, 5454, 684, 683
6412, 5454, 5455, 685, 684
6413, 5455, 5456, 686, 685
6414, 5456, 5457, 687, 686
6415, 5457, 5458, 688, 687
6416, 5458, 5459, 689, 688
6417, 5459, 5460, 690, 689
6418, 5460, 5461, 691, 690
6419, 5461, 5462, 692, 691
6420, 5462, 5463, 693, 692
6421, 5463, 5464, 694, 693
6422, 5464, 5465, 695, 694
6423, 5465, 5466, 696, 695
6424, 5466, 5467, 697, 696
6425, 5467, 5468, 698, 697
6426, 5468, 5469, 699, 698
6427, 5469, 5470, 700, 699
6428, 5470, 702, 30, 700
*ELEMENT, type=CPS4, ELSET=Surface33
6429, 27, 631, 5471, 703
6430, 703, 5471, 5472, 704
6431, 704, 5472, 5473, 705
6432, 705, 5473, 5474, 706
6433, 706, 5474, 5475, 707
6434, 707, 5475, 5476, 708
6435, 708, 5476, 5477, 709
6436, 709, 5477, 5478, 710
6437, 710, 5478, 5479, 711
6438, 711, 5479, 5480, 712
6439, 712, 5480, 5481, 713
6440, 713, 5481, 5482, 714
6441, 714, 5482, 5483, 715
6442, 715, 5483, 5484, 716
6443, 716, 5484, 5485, 717
6444, 717, 5485, 5486, 718
6445, 718, 5486, 5487, 719
6446, 719, 5487, 5488, 720
6447, 720, 5488, 5489, 721
6448, 721, 5489, 5490, 722
6449, 722, 5490, 5491, 723
6450, 723, 5491, 5492, 724
6451, 724, 5492, 5493, 725
6452, 725, 5493, 749, 31
6453, 631, 632, 5494, 5471
6454, 5471, 5494, 5495, 5472
6455, 5472, 5495, 5496, 5473
6456, 5473, 5496, 5497, 5474
6457, 5474, 5497, 5498, 5475
6458, 5475, 5498, 5499, 5476
6459, 5476, 5499, 5500, 5477
6460, 5477, 5500, 5501, 5478
6461, 5478, 5501, 5502, 5479
6462, 5479, 5502, 5503, 5480
6463, 5480, 5503, 5504, 5481
6464, 5481, 5504, 5505, 5482
6465, 5482, 5505, 5506, 5483
6466, 5483, 5506, 5507, 5484
6467, 5484, 5507, 5508, 5485
6468, 5485, 5508, 5509, 5486
6469, 5486, 5509, 5510, 5487
6470, 5487, 5510, 5511, 5488
6471, 5488, 5511, 5512, 5489
6472, 5489, 5512, 5513, 5490
6473, 5490, 5513, 5514, 5491
6474, 5491, 5514, 5515, 5492
6475, 5492, 5515, 5516, 5493
6476, 5493, 5516, 750, 749
6477, 632, 28, 726, 5494
6478, 5494, 726, 727, 5495
6479, 5495, 727, 728, 5496
6480, 5496, 728, 729, 5497
6481, 5497, 729, 730, 5498
6482, 5498, 730, 731, 5499
6483, 5499, 731, 732, 5500
6484, 5500, 732, 733, 5501
6485, 5501, 733, 734, 5502
6486, 5502, 734, 735, 5503
6487, 5503, 735, 736, 5504
6488, 5504, 736, 737, 5505
6489, 5505, 737, 738, 5506
6490, 5506, 738, 739, 5507
6491, 5507, 739, 740, 5508
6492, 5508, 740, 741, 5509
6493, 5509, 741, 742, 5510
6494, 5510, 742, 743, 5511
6495, 5511, 743, 744, 5512
6496, 5512, 744, 745, 5513
6497, 5513, 745, 746, 5514
6498, 5514, 746, 747, 5515
6499, 5515, 747, 748, 5516
6500, 5516, 748, 32, 750
*ELEMENT, type=CPS4, ELSET=Surface34
6501, 27, 703, 5517, 633
6502, 703, 704, 5518, 5517
6503, 704, 705, 5519, 5518
6504, 705, 706, 5520, 5519
6505, 706, 707, 5521, 5520
6506, 707, 708, 5522, 5521
6507, 708, 709, 5523, 5522
6508, 709, 710, 5524, 5523
6509, 710, 711, 5525, 5524
6510, 711, 712, 5526, 5525
6511, 712, 713, 5527, 5526
6512, 713, 714, 5528, 5527
6513, 714, 715, 5529, 5528
6514, 715, 716, 5530, 5529
6515, 716, 717, 5531, 5530
6516, 717, 718, 5532, 5531
6517, 718, 719, 5533, 5532
6518, 719, 720, 5534, 5533
6519, 720, 721, 5535, 5534
6520, 721, 722, 5536, 5535
6521, 722, 723, 5537, 5536
6522, 723, 724, 5538, 5537
6523, 724, 725, 5539, 5538
6524, 725, 31, 751, 5539
6525, 633, 5517, 5540, 634
6526, 5517, 5518, 5541, 5540
6527, 5518, 5519, 5542, 5541
6528, 5519, 5520, 5543, 5542
6529, 5520, 5521, 5544, 5543
6530, 5521, 5522, 5545, 5544
6531, 5522, 5523, 5546, 5545
6532, 5523, 5524, 5547, 5546
6533, 5524, 5525, 5548, 5547
6534, 5525, 5526, 5549, 5548
6535, 5526, 5527, 5550, 5549
6536, 5527, 5528, 5551, 5550
6537, 5528, 5529, 5552, 5551
6538, 5529, 5530, 5553, 5552
6539, 5530, 5531, 5554, 5553
6540, 5531, 5532, 5555, 5554
6541, 5532, 5533, 5556, 5555
6542, 5533, 5534, 5557, 5556
6543, 5534, 5535, 5558, 5557
6544, 5535, 5536, 5559, 5558
6545, 5536, 5537, 5560, 5559
6546, 5537, 5538, 5561, 5560
6547, 5538, 5539, 5562, 5561
6548, 5539, 751, 752, 5562
6549, 634, 5540, 5563, 635
6550, 5540, 5541, 5564, 5563
6551, 5541, 5542, 5565, 5564
6552, 5542, 5543, 5566, 5565
6553, 5543, 5544, 5567, 5566
6554, 5544, 5545, 5568, 5567
6555, 5545, 5546, 5569, 5568
6556, 5546, 5547, 5570, 5569
6557, 5547, 5548, 5571, 5570
6558, 5548, 5549, 5572, 5571
6559, 5549, 5550, 5573, 5572
6560, 5550, 5551, 5574, 5573
6561, 5551, 5552, 5575, 5574
6562, 5552, 5553, 5576, 5575
6563, 5553, 5554, 5577, 5576
6564, 5554, 5555, 5578, 5577
6565, 5555, 5556, 5579, 5578
6566, 5556, 5557, 5580, 5579
6567, 5557, 5558, 5581, 5580
6568, 5558, 5559, 5582, 5581
6569, 5559, 5560, 5583, 5582
6570, 5560, 5561, 5584, 5583
6571, 5561, 5562, 5585, 5584
6572, 5562, 752, 753, 5585
6573, 635, 5563, 5586, 636
6574, 5563, 5564, 5587, 5586
6575, 5564, 5565, 5588, 5587
6576, 5565, 5566, 5589, 5588
6577, 5566, 5567, 5590, 5589
6578, 5567, 5568, 5591, 5590
6579, 5568, 5569, 5592, 5591
6580, 5569, 5570, 5593, 5592
6581, 5570, 5571, 5594, 5593
6582, 5571, 5572, 5595, 5594
6583, 5572, 5573, 5596, 5595
6584, 5573, 5574, 5597, 5596
6585, 5574, 5575, 5598, 5597
6586, 5575, 5576, 5599, 5598
6587, 5576, 5577, 5600, 5599
6588, 5577, 5578, 5601, 5600
6589, 5578, 5579, 5602, 5601
6590, 5579, 5580, 5603, 5602
6591, 5580, 5581, 5604, 5603
6592, 5581, 5582, 5605, 5604
6593, 5582, 5583, 5606, 5605
6594, 5583, 5584, 5607, 5606
6595, 5584, 5585, 5608, 5607
6596, 5585, 753, 754, 5608
6597, 636, 5586, 5609, 637
6598, 5586, 5587, 5610, 5609
6599, 5587, 5588, 5611, 5610
6600, 5588, 5589, 5612, 5611
6601, 5589, 5590, 5613, 5612
6602, 5590, 5591, 5614, 5613
6603, 5591, 5592, 5615, 5614
6604, 5592, 5593, 5616, 5615
6605, 5593, 5594, 5617, 5616
6606, 5594, 5595, 5618, 5617
6607, 5595, 5596, 5619, 5618
6608, 5596, 5597, 5620, 5619
6609, 5597, 5598, 5621, 5620
6610, 5598, 5599, 5622, 5621
6611, 5599, 5600, 5623, 5622
6612, 5600, 5601, 5624, 5623
6613, 5601, 5602, 5625, 5624
6614, 5602, 5603, 5626, 5625
6615, 5603, 5604, 5627, 5626
6616, 5604, 5605, 5628, 5627
6617, 5605, 5606, 5629, 5628
6618, 5606, 5607, 5630, 5629
6619, 5607, 5608, 5631, 5630
6620, 5608, 754, 755, 5631
6621, 637, 5609, 5632, 638
6622, 5609, 5610, 5633, 5632
6623, 5610, 5611, 5634, 5633
6624, 5611, 5612, 5635, 5634
6625, 5612, 5613, 5636, 5635
6626, 5613, 5614, 5637, 5636
6627, 5614, 5615, 5638, 5637
6628, 5615, 5616, 5639, 5638
6629, 5616, 5617, 5640, 5639
6630, 5617, 5618, 5641, 5640
6631, 5618, 5619, 5642, 5641
6632, 5619, 5620, 5643, 5642
6633, 5620, 5621, 5644, 5643
6634, 5621, 5622, 5645, 5644
6635, 5622, 5623, 5646, 5645
6636, 5623, 5624, 5647, 5646
6637, 5624, 5625, 5648, 5647
6638, 5625, 5626, 5649, 5648
6639, 5626, 5627, 5650, 5649
6640, 5627, 5628, 5651, 5650
6641, 5628, 5629, 5652, 5651
6642, 5629, 5630, 5653, 5652
6643, 5630, 5631, 5654, 5653
6644, 5631, 755, 756, 5654
6645, 638, 5632, 5655, 639
6646, 5632, 5633, 5656, 5655
6647, 5633, 5634, 5657, 5656
6648, 5634, 5635, 5658, 5657
6649, 5635, 5636, 5659, 5658
6650, 5636, 5637, 5660, 5659
6651, 5637, 5638, 5661, 5660
6652, 5638, 5639, 5662, 5661
6653, 5639, 5640, 5663, 5662
6654, 5640, 5641, 5664, 5663
6655, 5641, 5642, 5665, 5664
6656, 5642, 5643, 5666, 5665
6657, 5643, 5644, 5667, 5666
6658, 5644, 5645, 5668, 5667
6659, 5645, 5646, 5669, 5668
6660, 5646, 5647, 5670, 5669
6661, 5647, 5648, 5671, 5670
6662, 5648, 5649, 5672, 5671
6663, 5649, 5650, 5673, 5672
6664, 5650, 5651, 5674, 5673
6665, 5651, 5652, 5675, 5674
6666, 5652, 5653, 5676, 5675
6667, 5653, 5654, 5677, 5676
6668, 5654, 756, 757, 5677
6669, 639, 5655, 5678, 640
6670, 5655, 5656, 5679, 5678
6671, 5656, 5657, 5680, 5679
6672, 5657, 5658, 5681, 5680
6673, 5658, 5659, 5682, 5681
6674, 5659, 5660, 5683, 5682
6675, 5660, 5661, 5684, 5683
6676, 5661, 5662, 5685, 5684
6677, 5662, 5663, 5686, 5685
6678, 5663, 5664, 5687, 5686
6679, 5664, 5665, 5688, 5687
6680, 5665, 5666, 5689, 5688
6681, 5666, 5667, 5690, 5689
6682, 5667, 5668, 5691, 5690
6683, 5668, 5669, 5692, 5691
6684, 5669, 5670, 5693, 5692
6685, 5670, 5671, 5694, 5693
6686, 5671, 5672, 5695, 5694
6687, 5672, 5673, 5696, 5695
6688, 5673, 5674, 5697, 5696
6689, 5674, 5675, 5698, 5697
6690, 5675, 5676, 5699, 5698
6691, 5676, 5677, 5700, 5699
6692, 5677, 757, 758, 5700
6693, 640, 5678, 5701, 641
6694, 5678, 5679, 5702, 5701
6695, 5679, 5680, 5703, 5702
6696, 5680, 5681, 5704, 5703
6697, 5681, 5682, 5705, 5704
6698, 5682, 5683, 5706, 5705
6699, 5683, 5684, 5707, 5706
6700, 5684, 5685, 5708, 5707
6701, 5685, 5686, 5709, 5708
6702, 5686, 5687, 5710, 5709
6703, 5687, 5688, 5711, 5710
6704, 5688, 5689, 5712, 5711
6705, 5689, 5690, 5713, 5712
6706, 5690, 5691, 5714, 5713
6707, 5691, 5692, 5715, 5714
6708, 5692, 5693, 5716, 5715
6709, 5693, 5694, 5717, 5716
6710, 5694, 5695, 5718, 5717
6711, 5695, 5696, 5719, 5718
6712, 5696, 5697, 5720, 5719
6713, 5697, 5698, 5721, 5720
6714, 5698, 5699, 5722, 5721
6715, 5699, 5700, 5723, 5722
6716, 5700, 758, 759, 5723
6717, 641, 5701, 5724, 642
6718, 5701, 5702, 5725, 5724
6719, 5702, 5703, 5726, 5725
6720, 5703, 5704, 5727, 5726
6721, 5704, 5705, 5728, 5727
6722, 5705, 5706, 5729, 5728
6723, 5706, 5707, 5730, 5729
6724, 5707, 5708, 5731, 5730
6725, 5708, 5709, 5732, 5731
6726, 5709, 5710, 5733, 5732
6727, 5710, 5711, 5734, 5733
6728, 5711, 5712, 5735, 5734
6729, 5712, 5713, 5736, 5735
6730, 5713, 5714, 5737, 5736
6731, 5714, 5715, 5738, 5737
6732, 5715, 5716, 5739, 5738
6733, 5716, 5717, 5740, 5739
6734, 5717, 5718, 5741, 5740
6735, 5718, 5719, 5742, 5741
6736, 5719, 5720, 5743, 5742
6737, 5720, 5721, 5744, 5743
6738, 5721, 5722, 5745, 5744
6739, 5722, 5723, 5746, 5745
6740, 5723, 759, 760, 5746
6741, 642, 5724, 5747, 643
6742, 5724, 5725, 5748, 5747
6743, 5725, 5726, 5749, 5748
6744, 5726, 5727, 5750, 5749
6745, 5727, 5728, 5751, 5750
6746, 5728, 5729, 5752, 5751
6747, 5729, 5730, 5753, 5752
6748, 5730, 5731, 5754, 5753
6749, 5731, 5732, 5755, 5754
6750, 5732, 5733, 5756, 5755
6751, 5733, 5734, 5757, 5756
6752, 5734, 5735, 5758, 5757
6753, 5735, 5736, 5759, 5758
6754, 5736, 5737, 5760, 5759
6755, 5737, 5738, 5761, 5760
6756, 5738, 5739, 5762, 5761
6757, 5739, 5740, 5763, 5762
6758, 5740, 5741, 5764, 5763
6759, 5741, 5742, 5765, 5764
6760, 5742, 5743, 5766, 5765
6761, 5743, 5744, 5767, 5766
6762, 5744, 5745, 5768, 5767
6763, 5745, 5746, 5769, 5768
6764, 5746, 760, 761, 5769
6765, 643, 5747, 655, 25
6766, 5747, 5748, 656, 655
6767, 5748, 5749, 657, 656
6768, 5749, 5750, 658, 657
6769, 5750, 5751, 659, 658
6770, 5751, 5752, 660, 659
6771, 5752, 5753, 661, 660
6772, 5753, 5754, 662, 661
6773, 5754, 5755, 663, 662
6774, 5755, 5756, 664, 663
6775, 5756, 5757, 665, 664
6776, 5757, 5758, 666, 665
6777, 5758, 5759, 667, 666
6778, 5759, 5760, 668, 667
6779, 5760, 5761, 669, 668
6780, 5761, 5762, 670, 669
6781, 5762, 5763, 671, 670
6782, 5763, 5764, 672, 671
6783, 5764, 5765, 673, 672
6784, 5765, 5766, 674, 673
6785, 5766, 5767, 675, 674
6786, 5767, 5768, 676, 675
6787, 5768, 5769, 677, 676
6788, 5769, 761, 29, 677
*ELEMENT, type=CPS4, ELSET=Surface35
6789, 28, 644, 5770, 726
6790, 726, 5770, 5771, 727
6791, 727, 5771, 5772, 728
6792, 728, 5772, 5773, 729
6793, 729, 5773, 5774, 730
6794, 730, 5774, 5775, 731
6795, 731, 5775, 5776, 732
6796, 732, 5776, 5777, 733
6797, 733, 5777, 5778, 734
6798, 734, 5778, 5779, 735
6799, 735, 5779, 5780, 736
6800, 736, 5780, 5781, 737
6801, 737, 5781, 5782, 738
6802, 738, 5782, 5783, 739
6803, 739, 5783, 5784, 740
6804, 740, 5784, 5785, 741
6805, 741, 5785, 5786, 742
6806, 742, 5786, 5787, 743
6807, 743, 5787, 5788, 744
6808, 744, 5788, 5789, 745
6809, 745, 5789, 5790, 746
6810, 746, 5790, 5791, 747
6811, 747, 5791, 5792, 748
6812, 748, 5792, 762, 32
6813, 644, 645, 5793, 5770
6814, 5770, 5793, 5794, 5771
6815, 5771, 5794, 5795, 5772
6816, 5772, 5795, 5796, 5773
6817, 5773, 5796, 5797, 5774
6818, 5774, 5797, 5798, 5775
6819, 5775, 5798, 5799, 5776
6820, 5776, 5799, 5800, 5777
6821, 5777, 5800, 5801, 5778
6822, 5778, 5801, 5802, 5779
6823, 5779, 5802, 5803, 5780
6824, 5780, 5803, 5804, 5781
6825, 5781, 5804, 5805, 5782
6826, 5782, 5805, 5806, 5783
6827, 5783, 5806, 5807, 5784
6828, 5784, 5807, 5808, 5785
6829, 5785, 5808, 5809, 5786
6830, 5786, 5809, 5810, 5787
6831, 5787, 5810, 5811, 5788
6832, 5788, 5811, 5812, 5789
6833, 5789, 5812, 5813, 5790
6834, 5790, 5813, 5814, 5791
6835, 5791, 5814, 5815, 5792
6836, 5792, 5815, 763, 762
6837, 645, 646, 5816, 5793
6838, 5793, 5816, 5817, 5794
6839, 5794, 5817, 5818, 5795
6840, 5795, 5818, 5819, 5796
6841, 5796, 5819, 5820, 5797
6842, 5797, 5820, 5821, 5798
6843, 5798, 5821, 5822, 5799
6844, 5799, 5822, 5823, 5800
6845, 5800, 5823, 5824, 5801
6846, 5801, 5824, 5825, 5802
6847, 5802, 5825, 5826, 5803
6848, 5803, 5826, 5827, 5804
6849, 5804, 5827, 5828, 5805
6850, 5805, 5828, 5829, 5806
6851, 5806, 5829, 5830, 5807
6852, 5807, 5830, 5831, 5808
6853, 5808, 5831, 5832, 5809
6854, 5809, 5832, 5833, 5810
6855, 5810, 5833, 5834, 5811
6856, 5811, 5834, 5835, 5812
6857, 5812, 5835, 5836, 5813
6858, 5813, 5836, 5837, 5814
6859, 5814, 5837, 5838, 5815
6860, 5815, 5838, 764, 763
6861, 646, 647, 5839, 5816
6862, 5816, 5839, 5840, 5817
6863, 5817, 5840, 5841, 5818
6864, 5818, 5841, 5842, 5819
6865, 5819, 5842, 5843, 5820
6866, 5820, 5843, 5844, 5821
6867, 5821, 5844, 5845, 5822
6868, 5822, 5845, 5846, 5823
6869, 5823, 5846, 5847, 5824
6870, 5824, 5847, 5848, 5825
6871, 5825, 5848, 5849, 5826
6872, 5826, 5849, 5850, 5827
6873, 5827, 5850, 5851, 5828
6874, 5828, 5851, 5852, 5829
6875, 5829, 5852, 5853, 5830
6876, 5830, 5853, 5854, 5831
6877, 5831, 5854, 5855, 5832
6878, 5832, 5855, 5856, 5833
6879, 5833, 5856, 5857, 5834
6880, 5834, 5857, 5858, 5835
6881, 5835, 5858, 5859, 5836
6882, 5836, 5859, 5860, 5837
6883, 5837, 5860, 5861, 5838
6884, 5838, 5861, 765, 764
6885, 647, 648, 5862, 5839
6886, 5839, 5862, 5863, 5840
6887, 5840, 5863, 5864, 5841
6888, 5841, 5864, 5865, 5842
6889, 5842, 5865, 5866, 5843
6890, 5843, 5866, 5867, 5844
6891, 5844, 5867, 5868, 5845
6892, 5845, 5868, 5869, 5846
6893, 5846, 5869, 5870, 5847
6894, 5847, 5870, 5871, 5848
6895, 5848, 5871, 5872, 5849
6896, 5849, 5872, 5873, 5850
6897, 5850, 5873, 5874, 5851
6898, 5851, 5874, 5875, 5852
6899, 5852, 5875, 5876, 5853
6900, 5853, 5876, 5877, 5854
6901, 5854, 5877, 5878, 5855
6902, 5855, 5878, 5879, 5856
6903, 5856, 5879, 5880, 5857
6904, 5857, 5880, 5881, 5858
6905, 5858, 5881, 5882, 5859
6906, 5859, 5882, 5883, 5860
6907, 5860, 5883, 5884, 5861
6908, 5861, 5884, 766, 765
6909, 648, 649, 5885, 5862
6910, 5862, 5885, 5886, 5863
6911, 5863, 5886, 5887, 5864
6912, 5864, 5887, 5888, 5865
6913, 5865, 5888, 5889, 5866
6914, 5866, 5889, 5890, 5867
6915, 5867, 5890, 5891, 5868
6916, 5868, 5891, 5892, 5869
6917, 5869, 5892, 5893, 5870
6918, 5870, 5893, 5894, 5871
6919, 5871, 5894, 5895, 5872
6920, 5872, 5895, 5896, 5873
6921, 5873, 5896, 5897, 5874
6922, 5874, 5897, 5898, 5875
6923, 5875, 5898, 5899, 5876
6924, 5876, 5899, 5900, 5877
6925, 5877, 5900, 5901, 5878
6926, 5878, 5901, 5902, 5879
6927, 5879, 5902, 5903, 5880
6928, 5880, 5903, 5904, 5881
6929, 5881, 5904, 5905, 5882
6930, 5882, 5905, 5906, 5883
6931, 5883, 5906, 5907, 5884
6932, 5884, 5907, 767, 766
6933, 649, 650, 5908, 5885
6934, 5885, 5908, 5909, 5886
6935, 5886, 5909, 5910, 5887
6936, 5887, 5910, 5911, 5888
6937, 5888, 5911, 5912, 5889
6938, 5889, 5912, 5913, 5890
6939, 5890, 5913, 5914, 5891
6940, 5891, 5914, 5915, 5892
6941, 5892, 5915, 5916, 5893
6942, 5893, 5916, 5917, 5894
6943, 5894, 5917, 5918, 5895
6944, 5895, 5918, 5919, 5896
6945, 5896, 5919, 5920, 5897
6946, 5897, 5920, 5921, 5898
6947, 5898, 5921, 5922, 5899
6948, 5899, 5922, 5923, 5900
6949, 5900, 5923, 5924, 5901
6950, 5901, 5924, 5925, 5902
6951, 5902, 5925, 5926, 5903
6952, 5903, 5926, 5927, 5904
6953, 5904, 5927, 5928, 5905
6954, 5905, 5928, 5929, 5906
6955, 5906, 5929, 5930, 5907
6956, 5907, 5930, 768, 767
6957, 650, 651, 5931, 5908
6958, 5908, 5931, 5932, 5909
6959, 5909, 5932, 5933, 5910
6960, 5910, 5933, 5934, 5911
6961, 5911, 5934, 5935, 5912
6962, 5912, 5935, 5936, 5913
6963, 5913, 5936, 5937, 5914
6964, 5914, 5937, 5938, 5915
6965, 5915, 5938, 5939, 5916
6966, 5916, 5939, 5940, 5917
6967, 5917, 5940, 5941, 5918
6968, 5918, 5941, 5942, 5919
6969, 5919, 5942, 5943, 5920
6970, 5920, 5943, 5944, 5921
6971, 5921, 5944, 5945, 5922
6972, 5922, 5945, 5946, 5923
6973, 5923, 5946, 5947, 5924
6974, 5924, 5947, 5948, 5925
6975, 5925, 5948, 5949, 5926
6976, 5926, 5949, 5950, 5927
6977, 5927, 5950, 5951, 5928
6978, 5928, 5951, 5952, 5929
6979, 5929, 5952, 5953, 5930
6980, 5930, 5953, 769, 768
6981, 651, 652, 5954, 5931
6982, 5931, 5954, 5955, 5932
6983, 5932, 5955, 5956, 5933
6984, 5933, 5956, 5957, 5934
6985, 5934, 5957, 5958, 5935
6986, 5935, 5958, 5959, 5936
6987, 5936, 5959, 5960, 5937
6988, 5937, 5960, 5961, 5938
6989, 5938, 5961, 5962, 5939
6990, 5939, 5962, 5963, 5940
6991, 5940, 5963, 5964, 5941
6992, 5941, 5964, 5965, 5942
6993, 5942, 5965, 5966, 5943
6994, 5943, 5966, 5967, 5944
6995, 5944, 5967, 5968, 5945
6996, 5945, 5968, 5969, 5946
6997, 5946, 5969, 5970, 5947
6998, 5947, 5970, 5971, 5948
6999, 5948, 5971, 5972, 5949
7000, 5949, 5972, 5973, 5950
7001, 5950, 5973, 5974, 5951
7002, 5951, 5974, 5975, 5952
7003, 5952, 5975, 5976, 5953
7004, 5953, 5976, 770, 769
7005, 652, 653, 5977, 5954
7006, 5954, 5977, 5978, 5955
7007, 5955, 5978, 5979, 5956
7008, 5956, 5979, 5980, 5957
7009, 5957, 5980, 5981, 5958
7010, 5958, 5981, 5982, 5959
7011, 5959, 5982, 5983, 5960
7012, 5960, 5983, 5984, 5961
7013, 5961, 5984, 5985, 5962
7014, 5962, 5985, 5986, 5963
7015, 5963, 5986, 5987, 5964
7016, 5964, 5987, 5988, 5965
7017, 5965, 5988, 5989, 5966
7018, 5966, 5989, 5990, 5967
7019, 5967, 5990, 5991, 5968
7020, 5968, 5991, 5992, 5969
7021, 5969, 5992, 5993, 5970
7022, 5970, 5993, 5994, 5971
7023, 5971, 5994, 5995, 5972
7024, 5972, 5995, 5996, 5973
7025, 5973, 5996, 5997, 5974
7026, 5974, 5997, 5998, 5975
7027, 5975, 5998, 5999, 5976
7028, 5976, 5999, 771, 770
7029, 653, 654, 6000, 5977
7030, 5977, 6000, 6001, 5978
7031, 5978, 6001, 6002, 5979
7032, 5979, 6002, 6003, 5980
7033, 5980, 6003, 6004, 5981
7034, 5981, 6004, 6005, 5982
7035, 5982, 6005, 6006, 5983
7036, 5983, 6006, 6007, 5984
7037, 5984, 6007, 6008, 5985
7038, 5985, 6008, 6009, 5986
7039, 5986, 6009, 6010, 5987
7040, 5987, 6010, 6011, 5988
7041, 5988, 6011, 6012, 5989
7042, 5989, 6012, 6013, 5990
7043, 5990, 6013, 6014, 5991
7044, 5991, 6014, 6015, 5992
7045, 5992, 6015, 6016, 5993
7046, 5993, 6016, 6017, 5994
7047, 5994, 6017, 6018, 5995
7048, 5995, 6018, 6019, 5996
7049, 5996, 6019, 6020, 5997
7050, 5997, 6020, 6021, 5998
7051, 5998, 6021, 6022, 5999
7052, 5999, 6022, 772, 771
7053, 654, 26, 678, 6000
7054, 6000, 678, 679, 6001
7055, 6001, 679, 680, 6002
7056, 6002, 680, 681, 6003
7057, 6003, 681, 682, 6004
7058, 6004, 682, 683, 6005
7059, 6005, 683, 684, 6006
7060, 6006, 684, 685, 6007
7061, 6007, 685, 686, 6008
7062, 6008, 686, 687, 6009
7063, 6009, 687, 688, 6010
7064, 6010, 688, 689, 6011
7065, 6011, 689, 690, 6012
7066, 6012, 690, 691, 6013
7067, 6013, 691, 692, 6014
7068, 6014, 692, 693, 6015
7069, 6015, 693, 694, 6016
7070, 6016, 694, 695, 6017
7071, 6017, 695, 696, 6018
7072, 6018, 696, 697, 6019
7073, 6019, 697, 698, 6020
7074, 6020, 698, 699, 6021
7075, 6021, 699, 700, 6022
7076, 6022, 700, 30, 772
*ELEMENT, type=CPS4, ELSET=Surface36
7077, 31, 749, 6023, 751
7078, 749, 750, 6024, 6023
7079, 750, 32, 762, 6024
7080, 751, 6023, 6025, 752
7081, 6023, 6024, 6026, 6025
7082, 6024, 762, 763, 6026
7083, 752, 6025, 6027, 753
7084, 6025, 6026, 6028, 6027
7085, 6026, 763, 764, 6028
7086, 753, 6027, 6029, 754
7087, 6027, 6028, 6030, 6029
7088, 6028, 764, 765, 6030
7089, 754, 6029, 6031, 755
7090, 6029, 6030, 6032, 6031
7091, 6030, 765, 766, 6032
7092, 755, 6031, 6033, 756
7093, 6031, 6032, 6034, 6033
7094, 6032, 766, 767, 6034
7095, 756, 6033, 6035, 757
7096, 6033, 6034, 6036, 6035
7097, 6034, 767, 768, 6036
7098, 757, 6035, 6037, 758
7099, 6035, 6036, 6038, 6037
7100, 6036, 768, 769, 6038
7101, 758, 6037, 6039, 759
7102, 6037, 6038, 6040, 6039
7103, 6038, 769, 770, 6040
7104, 759, 6039, 6041, 760
7105, 6039, 6040, 6042, 6041
7106, 6040, 770, 771, 6042
7107, 760, 6041, 6043, 761
7108, 6041, 6042, 6044, 6043
7109, 6042, 771, 772, 6044
7110, 761, 6043, 701, 29
7111, 6043, 6044, 702, 701
7112, 6044, 772, 30, 702
*ELEMENT, type=CPS4, ELSET=Surface37
7113, 25, 33, 773, 655
7114, 655, 773, 774, 656
7115, 656, 774, 775, 657
7116, 657, 775, 776, 658
7117, 658, 776, 777, 659
7118, 659, 777, 778, 660
7119, 660, 778, 779, 661
7120, 661, 779, 780, 662
7121, 662, 780, 781, 663
7122, 663, 781, 782, 664
7123, 664, 782, 783, 665
7124, 665, 783, 784, 666
7125, 666, 784, 785, 667
7126, 667, 785, 786, 668
7127, 668, 786, 787, 669
7128, 669, 787, 788, 670
7129, 670, 788, 789, 671
7130, 671, 789, 790, 672
7131, 672, 790, 791, 673
7132, 673, 791, 792, 674
7133, 674, 792, 793, 675
7134, 675, 793, 794, 676
7135, 676, 794, 795, 677
7136, 677, 795, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
7137, 27, 703, 796, 35
7138, 703, 704, 797, 796
7139, 704, 705, 798, 797
7140, 705, 706, 799, 798
7141, 706, 707, 800, 799
7142, 707, 708, 801, 800
7143, 708, 709, 802, 801
7144, 709, 710, 803, 802
7145, 710, 711, 804, 803
7146, 711, 712, 805, 804
7147, 712, 713, 806, 805
7148, 713, 714, 807, 806
7149, 714, 715, 808, 807
7150, 715, 716, 809, 808
7151, 716, 717, 810, 809
7152, 717, 718, 811, 810
7153, 718, 719, 812, 811
7154, 719, 720, 813, 812
7155, 720, 721, 814, 813
7156, 721, 722, 815, 814
7157, 722, 723, 816, 815
7158, 723, 724, 817, 816
7159, 724, 725, 818, 817
7160, 725, 31, 36, 818
*ELEMENT, type=CPS4, ELSET=Surface39
7161, 27, 35, 819, 633
7162, 633, 819, 820, 634
7163, 634, 820, 821, 635
7164, 635, 821, 822, 636
7165, 636, 822, 823, 637
7166, 637, 823, 824, 638
7167, 638, 824, 825, 639
7168, 639, 825, 826, 640
7169, 640, 826, 827, 641
7170, 641, 827, 828, 642
7171, 642, 828, 829, 643
7172, 643, 829, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
7173, 31, 751, 830, 36
7174, 751, 752, 831, 830
7175, 752, 753, 832, 831
7176, 753, 754, 833, 832
7177, 754, 755, 834, 833
7178, 755, 756, 835, 834
7179, 756, 757, 836, 835
7180, 757, 758, 837, 836
7181, 758, 759, 838, 837
7182, 759, 760, 839, 838
7183, 760, 761, 840, 839
7184, 761, 29, 34, 840
*ELEMENT, type=CPS4, ELSET=Surface41
7185, 35, 796, 6045, 819
7186, 796, 797, 6046, 6045
7187, 797, 798, 6047, 6046
7188, 798, 799, 6048, 6047
7189, 799, 800, 6049, 6048
7190, 800, 801, 6050, 6049
7191, 801, 802, 6051, 6050
7192, 802, 803, 6052, 6051
7193, 803, 804, 6053, 6052
7194, 804, 805, 6054, 6053
7195, 805, 806, 6055, 6054
7196, 806, 807, 6056, 6055
7197, 807, 808, 6057, 6056
7198, 808, 809, 6058, 6057
7199, 809, 810, 6059, 6058
7200, 810, 811, 6060, 6059
7201, 811, 812, 6061, 6060
7202, 812, 813, 6062, 6061
7203, 813, 814, 6063, 6062
7204, 814, 815, 6064, 6063
7205, 815, 816, 6065, 6064
7206, 816, 817, 6066, 6065
7207, 817, 818, 6067, 6066
7208, 818, 36, 830, 6067
7209, 819, 6045, 6068, 820
7210, 6045, 6046, 6069, 6068
7211, 6046, 6047, 6070, 6069
7212, 6047, 6048, 6071, 6070
7213, 6048, 6049, 6072, 6071
7214, 6049, 6050, 6073, 6072
7215, 6050, 6051, 6074, 6073
7216, 6051, 6052, 6075, 6074
7217, 6052, 6053, 6076, 6075
7218, 6053, 6054, 6077, 6076
7219, 6054, 6055, 6078, 6077
7220, 6055, 6056, 6079, 6078
7221, 6056, 6057, 6080, 6079
7222, 6057, 6058, 6081, 6080
7223, 6058, 6059, 6082, 6081
7224, 6059, 6060, 6083, 6082
7225, 6060, 6061, 6084, 6083
7226, 6061, 6062, 6085, 6084
7227, 6062, 6063, 6086, 6085
7228, 6063, 6064, 6087, 6086
7229, 6064, 6065, 6088, 6087
7230, 6065, 6066, 6089, 6088
7231, 6066, 6067, 6090, 6089
7232, 6067, 830, 831, 6090
7233, 820, 6068, 6091, 821
7234, 6068, 6069, 6092, 6091
7235, 6069, 6070, 6093, 6092
7236, 6070, 6071, 6094, 6093
7237, 6071, 6072, 6095, 6094
7238, 6072, 6073, 6096, 6095
7239, 6073, 6074, 6097, 6096
7240, 6074, 6075, 6098, 6097
7241, 6075, 6076, 6099, 6098
7242, 6076, 6077, 6100, 6099
7243, 6077, 6078, 6101, 6100
7244, 6078, 6079, 6102, 6101
7245, 6079, 6080, 6103, 6102
7246, 6080, 6081, 6104, 6103
7247, 6081, 6082, 6105, 6104
7248, 6082, 6083, 6106, 6105
7249, 6083, 6084, 6107, 6106
7250, 6084, 6085, 6108, 6107
7251, 6085, 6086, 6109, 6108
7252, 6086, 6087, 6110, 6109
7253, 6087, 6088, 6111, 6110
7254, 6088, 6089, 6112, 6111
7255, 6089, 6090, 6113, 6112
7256, 6090, 831, 832, 6113
7257, 821, 6091, 6114, 822
7258, 6091, 6092, 6115, 6114
7259, 6092, 6093, 6116, 6115
7260, 6093, 6094, 6117, 6116
7261, 6094, 6095, 6118, 6117
7262, 6095, 6096, 6119, 6118
7263, 6096, 6097, 6120, 6119
7264, 6097, 6098, 6121, 6120
7265, 6098, 6099, 6122, 6121
7266, 6099, 6100, 6123, 6122
7267, 6100, 6101, 6124, 6123
7268, 6101, 6102, 6125, 6124
7269, 6102, 6103, 6126, 6125
7270, 6103, 6104, 6127, 6126
7271, 6104, 6105, 6128, 6127
7272, 6105, 6106, 6129, 6128
7273, 6106, 6107, 6130, 6129
7274, 6107, 6108, 6131, 6130
7275, 6108, 6109, 6132, 6131
7276, 6109, 6110, 6133, 6132
7277, 6110, 6111, 6134, 6133
7278, 6111, 6112, 6135, 6134
7279, 6112, 6113, 6136, 6135
7280, 6113, 832, 833, 6136
7281, 822, 6114, 6137, 823
7282, 6114, 6115, 6138, 6137
7283, 6115, 6116, 6139, 6138
7284, 6116, 6117, 6140, 6139
7285, 6117, 6118, 6141, 6140
7286, 6118, 6119, 6142, 6141
7287, 6119, 6120, 6143, 6142
7288, 6120, 6121, 6144, 6143
7289, 6121, 6122, 6145, 6144
7290, 6122, 6123, 6146, 6145
7291, 6123, 6124, 6147, 6146
7292, 6124, 6125, 6148, 6147
7293, 6125, 6126, 6149, 6148
7294, 6126, 6127, 6150, 6149
7295, 6127, 6128, 6151, 6150
7296, 6128, 6129, 6152, 6151
7297, 6129, 6130, 6153, 6152
7298, 6130, 6131, 6154, 6153
7299, 6131, 6132, 6155, 6154
7300, 6132, 6133, 6156, 6155
7301, 6133, 6134, 6157, 6156
7302, 6134, 6135, 6158, 6157
7303, 6135, 6136, 6159, 6158
7304, 6136, 833, 834, 6159
7305, 823, 6137, 6160, 824
7306, 6137, 6138, 6161, 6160
7307, 6138, 6139, 6162, 6161
7308, 6139, 6140, 6163, 6162
7309, 6140, 6141, 6164, 6163
7310, 6141, 6142, 6165, 6164
7311, 6142, 6143, 6166, 6165
7312, 6143, 6144, 6167, 6166
7313, 6144, 6145, 6168, 6167
7314, 6145, 6146, 6169, 6168
7315, 6146, 6147, 6170, 6169
7316, 6147, 6148, 6171, 6170
7317, 6148, 6149, 6172, 6171
7318, 6149, 6150, 6173, 6172
7319, 6150, 6151, 6174, 6173
7320, 6151, 6152, 6175, 6174
7321, 6152, 6153, 6176, 6175
7322, 6153, 6154, 6177, 6176
7323, 6154, 6155, 6178, 6177
7324, 6155, 6156, 6179, 6178
7325, 6156, 6157, 6180, 6179
7326, 6157, 6158, 6181, 6180
7327, 6158, 6159, 6182, 6181
7328, 6159, 834, 835, 6182
7329, 824, 6160, 6183, 825
7330, 6160, 6161, 6184, 6183
7331, 6161, 6162, 6185, 6184
7332, 6162, 6163, 6186, 6185
7333, 6163, 6164, 6187, 6186
7334, 6164, 6165, 6188, 6187
7335, 6165, 6166, 6189, 6188
7336, 6166, 6167, 6190, 6189
7337, 6167, 6168, 6191, 6190
7338, 6168, 6169, 6192, 6191
7339, 6169, 6170, 6193, 6192
7340, 6170, 6171, 6194, 6193
7341, 6171, 6172, 6195, 6194
7342, 6172, 6173, 6196, 6195
7343, 6173, 6174, 6197, 6196
7344, 6174, 6175, 6198, 6197
7345, 6175, 6176, 6199, 6198
7346, 6176, 6177, 6200, 6199
7347, 6177, 6178, 6201, 6200
7348, 6178, 6179, 6202, 6201
7349, 6179, 6180, 6203, 6202
7350, 6180, 6181, 6204, 6203
7351, 6181, 6182, 6205, 6204
7352, 6182, 835, 836, 6205
7353, 825, 6183, 6206, 826
7354, 6183, 6184, 6207, 6206
7355, 6184, 6185, 6208, 6207
7356, 6185, 6186, 6209, 6208
7357, 6186, 6187, 6210, 6209
7358, 6187, 6188, 6211, 6210
7359, 6188, 6189, 6212, 6211
7360, 6189, 6190, 6213, 6212
7361, 6190, 6191, 6214, 6213
7362, 6191, 6192, 6215, 6214
7363, 6192, 6193, 6216, 6215
7364, 6193, 6194, 6217, 6216
7365, 6194, 6195, 6218, 6217
7366, 6195, 6196, 6219, 6218
7367, 6196, 6197, 6220, 6219
7368, 6197, 6198, 6221, 6220
7369, 6198, 6199, 6222, 6221
7370, 6199, 6200, 6223, 6222
7371, 6200, 6201, 6224, 6223
7372, 6201, 6202, 6225, 6224
7373, 6202, 6203, 6226, 6225
7374, 6203, 6204, 6227, 6226
7375, 6204, 6205, 6228, 6227
7376, 6205, 836, 837, 6228
7377, 826, 6206, 6229, 827
7378, 6206, 6207, 6230, 6229
7379, 6207, 6208, 6231, 6230
7380, 6208, 6209, 6232, 6231
7381, 6209, 6210, 6233, 6232
7382, 6210, 6211, 6234, 6233
7383, 6211, 6212, 6235, 6234
7384, 6212, 6213, 6236, 6235
7385, 6213, 6214, 6237, 6236
7386, 6214, 6215, 6238, 6237
7387, 6215, 6216, 6239, 6238
7388, 6216, 6217, 6240, 6239
7389, 6217, 6218, 6241, 6240
7390, 6218, 6219, 6242, 6241
7391, 6219, 6220, 6243, 6242
7392, 6220, 6221, 6244, 6243
7393, 6221, 6222, 6245, 6244
7394, 6222, 6223, 6246, 6245
7395, 6223, 6224, 6247, 6246
7396, 6224, 6225, 6248, 6247
7397, 6225, 6226, 6249, 6248
7398, 6226, 6227, 6250, 6249
7399, 6227, 6228, 6251, 6250
7400, 6228, 837, 838, 6251
7401, 827, 6229, 6252, 828
7402, 6229, 6230, 6253, 6252
7403, 6230, 6231, 6254, 6253
7404, 6231, 6232, 6255, 6254
7405, 6232, 6233, 6256, 6255
7406, 6233, 6234, 6257, 6256
7407, 6234, 6235, 6258, 6257
7408, 6235, 6236, 6259, 6258
7409, 6236, 6237, 6260, 6259
7410, 6237, 6238, 6261, 6260
7411, 6238, 6239, 6262, 6261
7412, 6239, 6240, 6263, 6262
7413, 6240, 6241, 6264, 6263
7414, 6241, 6242, 6265, 6264
7415, 6242, 6243, 6266, 6265
7416, 6243, 6244, 6267, 6266
7417, 6244, 6245, 6268, 6267
7418, 6245, 6246, 6269, 6268
7419, 6246, 6247, 6270, 6269
7420, 6247, 6248, 6271, 6270
7421, 6248, 6249, 6272, 6271
7422, 6249, 6250, 6273, 6272
7423, 6250, 6251, 6274, 6273
7424, 6251, 838, 839, 6274
7425, 828, 6252, 6275, 829
7426, 6252, 6253, 6276, 6275
7427, 6253, 6254, 6277, 6276
7428, 6254, 6255, 6278, 6277
7429, 6255, 6256, 6279, 6278
7430, 6256, 6257, 6280, 6279
7431, 6257, 6258, 6281, 6280
7432, 6258, 6259, 6282, 6281
7433, 6259, 6260, 6283, 6282
7434, 6260, 6261, 6284, 6283
7435, 6261, 6262, 6285, 6284
7436, 6262, 6263, 6286, 6285
7437, 6263, 6264, 6287, 6286
7438, 6264, 6265, 6288, 6287
7439, 6265, 6266, 6289, 6288
7440, 6266, 6267, 6290, 6289
7441, 6267, 6268, 6291, 6290
7442, 6268, 6269, 6292, 6291
7443, 6269, 6270, 6293, 6292
7444, 6270, 6271, 6294, 6293
7445, 6271, 6272, 6295, 6294
7446, 6272, 6273, 6296, 6295
7447, 6273, 6274, 6297, 6296
7448, 6274, 839, 840, 6297
7449, 829, 6275, 773, 33
7450, 6275, 6276, 774, 773
7451, 6276, 6277, 775, 774
7452, 6277, 6278, 776, 775
7453, 6278, 6279, 777, 776
7454, 6279, 6280, 778, 777
7455, 6280, 6281, 779, 778
7456, 6281, 6282, 780, 779
7457, 6282, 6283, 781, 780
7458, 6283, 6284, 782, 781
7459, 6284, 6285, 783, 782
7460, 6285, 6286, 784, 783
7461, 6286, 6287, 785, 784
7462, 6287, 6288, 786, 785
7463, 6288, 6289, 787, 786
7464, 6289, 6290, 788, 787
7465, 6290, 6291, 789, 788
7466, 6291, 6292, 790, 789
7467, 6292, 6293, 791, 790
7468, 6293, 6294, 792, 791
7469, 6294, 6295, 793, 792
7470, 6295, 6296, 794, 793
7471, 6296, 6297, 795, 794
7472, 6297, 840, 34, 795
*ELEMENT, type=CPS4, ELSET=Surface42
7473, 33, 841, 6298, 773
7474, 841, 842, 6299, 6298
7475, 842, 843, 6300, 6299
7476, 843, 844, 6301, 6300
7477, 844, 845, 6302, 6301
7478, 845, 846, 6303, 6302
7479, 846, 847, 6304, 6303
7480, 847, 848, 6305, 6304
7481, 848, 849, 6306, 6305
7482, 849, 850, 6307, 6306
7483, 850, 851, 6308, 6307
7484, 851, 852, 6309, 6308
7485, 852, 853, 6310, 6309
7486, 853, 854, 6311, 6310
7487, 854, 855, 6312, 6311
7488, 855, 856, 6313, 6312
7489, 856, 857, 6314, 6313
7490, 857, 858, 6315, 6314
7491, 858, 859, 6316, 6315
7492, 859, 860, 6317, 6316
7493, 860, 861, 6318, 6317
7494, 861, 862, 6319, 6318
7495, 862, 863, 6320, 6319
7496, 863, 37, 887, 6320
7497, 773, 6298, 6321, 774
7498, 6298, 6299, 6322, 6321
7499, 6299, 6300, 6323, 6322
7500, 6300, 6301, 6324, 6323
7501, 6301, 6302, 6325, 6324
7502, 6302, 6303, 6326, 6325
7503, 6303, 6304, 6327, 6326
7504, 6304, 6305, 6328, 6327
7505, 6305, 6306, 6329, 6328
7506, 6306, 6307, 6330, 6329
7507, 6307, 6308, 6331, 6330
7508, 6308, 6309, 6332, 6331
7509, 6309, 6310, 6333, 6332
7510, 6310, 6311, 6334, 6333
7511, 6311, 6312, 6335, 6334
7512, 6312, 6313, 6336, 6335
7513, 6313, 6314, 6337, 6336
7514, 6314, 6315, 6338, 6337
7515, 6315, 6316, 6339, 6338
7516, 6316, 6317, 6340, 6339
7517, 6317, 6318, 6341, 6340
7518, 6318, 6319, 6342, 6341
7519, 6319, 6320, 6343, 6342
7520, 6320, 887, 888, 6343
7521, 774, 6321, 6344, 775
7522, 6321, 6322, 6345, 6344
7523, 6322, 6323, 6346, 6345
7524, 6323, 6324, 6347, 6346
7525, 6324, 6325, 6348, 6347
7526, 6325, 6326, 6349, 6348
7527, 6326, 6327, 6350, 6349
7528, 6327, 6328, 6351, 6350
7529, 6328, 6329, 6352, 6351
7530, 6329, 6330, 6353, 6352
7531, 6330, 6331, 6354, 6353
7532, 6331, 6332, 6355, 6354
7533, 6332, 6333, 6356, 6355
7534, 6333, 6334, 6357, 6356
7535, 6334, 6335, 6358, 6357
7536, 6335, 6336, 6359, 6358
7537, 6336, 6337, 6360, 6359
7538, 6337, 6338, 6361, 6360
7539, 6338, 6339, 6362, 6361
7540, 6339, 6340, 6363, 6362
7541, 6340, 6341, 6364, 6363
7542, 6341, 6342, 6365, 6364
7543, 6342, 6343, 6366, 6365
7544, 6343, 888, 889, 6366
7545, 775, 6344, 6367, 776
7546, 6344, 6345, 6368, 6367
7547, 6345, 6346, 6369, 6368
7548, 6346, 6347, 6370, 6369
7549, 6347, 6348, 6371, 6370
7550, 6348, 6349, 6372, 6371
7551, 6349, 6350, 6373, 6372
7552, 6350, 6351, 6374, 6373
7553, 6351, 6352, 6375, 6374
7554, 6352, 6353, 6376, 6375
7555, 6353, 6354, 6377, 6376
7556, 6354, 6355, 6378, 6377
7557, 6355, 6356, 6379, 6378
7558, 6356, 6357, 6380, 6379
7559, 6357, 6358, 6381, 6380
7560, 6358, 6359, 6382, 6381
7561, 6359, 6360, 6383, 6382
7562, 6360, 6361, 6384, 6383
7563, 6361, 6362, 6385, 6384
7564, 6362, 6363, 6386, 6385
7565, 6363, 6364, 6387, 6386
7566, 6364, 6365, 6388, 6387
7567, 6365, 6366, 6389, 6388
7568, 6366, 889, 890, 6389
7569, 776, 6367, 6390, 777
7570, 6367, 6368, 6391, 6390
7571, 6368, 6369, 6392, 6391
7572, 6369, 6370, 6393, 6392
7573, 6370, 6371, 6394, 6393
7574, 6371, 6372, 6395, 6394
7575, 6372, 6373, 6396, 6395
7576, 6373, 6374, 6397, 6396
7577, 6374, 6375, 6398, 6397
7578, 6375, 6376, 6399, 6398
7579, 6376, 6377, 6400, 6399
7580, 6377, 6378, 6401, 6400
7581, 6378, 6379, 6402, 6401
7582, 6379, 6380, 6403, 6402
7583, 6380, 6381, 6404, 6403
7584, 6381, 6382, 6405, 6404
7585, 6382, 6383, 6406, 6405
7586, 6383, 6384, 6407, 6406
7587, 6384, 6385, 6408, 6407
7588, 6385, 6386, 6409, 6408
7589, 6386, 6387, 6410, 6409
7590, 6387, 6388, 6411, 6410
7591, 6388, 6389, 6412, 6411
7592, 6389, 890, 891, 6412
7593, 777, 6390, 6413, 778
7594, 6390, 6391, 6414, 6413
7595, 6391, 6392, 6415, 6414
7596, 6392, 6393, 6416, 6415
7597, 6393, 6394, 6417, 6416
7598, 6394, 6395, 6418, 6417
7599, 6395, 6396, 6419, 6418
7600, 6396, 6397, 6420, 6419
7601, 6397, 6398, 6421, 6420
7602, 6398, 6399, 6422, 6421
7603, 6399, 6400, 6423, 6422
7604, 6400, 6401, 6424, 6423
7605, 6401, 6402, 6425, 6424
7606, 6402, 6403, 6426, 6425
7607, 6403, 6404, 6427, 6426
7608, 6404, 6405, 6428, 6427
7609, 6405, 6406, 6429, 6428
7610, 6406, 6407, 6430, 6429
7611, 6407, 6408, 6431, 6430
7612, 6408, 6409, 6432, 6431
7613, 6409, 6410, 6433, 6432
7614, 6410, 6411, 6434, 6433
7615, 6411, 6412, 6435, 6434
7616, 6412, 891, 892, 6435
7617, 778, 6413, 6436, 779
7618, 6413, 6414, 6437, 6436
7619, 6414, 6415, 6438, 6437
7620, 6415, 6416, 6439, 6438
7621, 6416, 6417, 6440, 6439
7622, 6417, 6418, 6441, 6440
7623, 6418, 6419, 6442, 6441
7624, 6419, 6420, 6443, 6442
7625, 6420, 6421, 6444, 6443
7626, 6421, 6422, 6445, 6444
7627, 6422, 6423, 6446, 6445
7628, 6423, 6424, 6447, 6446
7629, 6424, 6425, 6448, 6447
7630, 6425, 6426, 6449, 6448
7631, 6426, 6427, 6450, 6449
7632, 6427, 6428, 6451, 6450
7633, 6428, 6429, 6452, 6451
7634, 6429, 6430, 6453, 6452
7635, 6430, 6431, 6454, 6453
7636, 6431, 6432, 6455, 6454
7637, 6432, 6433, 6456, 6455
7638, 6433, 6434, 6457, 6456
7639, 6434, 6435, 6458, 6457
7640, 6435, 892, 893, 6458
7641, 779, 6436, 6459, 780
7642, 6436, 6437, 6460, 6459
7643, 6437, 6438, 6461, 6460
7644, 6438, 6439, 6462, 6461
7645, 6439, 6440, 6463, 6462
7646, 6440, 6441, 6464, 6463
7647, 6441, 6442, 6465, 6464
7648, 6442, 6443, 6466, 6465
7649, 6443, 6444, 6467, 6466
7650, 6444, 6445, 6468, 6467
7651, 6445, 6446, 6469, 6468
7652, 6446, 6447, 6470, 6469
7653, 6447, 6448, 6471, 6470
7654, 6448, 6449, 6472, 6471
7655, 6449, 6450, 6473, 6472
7656, 6450, 6451, 6474, 6473
7657, 6451, 6452, 6475, 6474
7658, 6452, 6453, 6476, 6475
7659, 6453, 6454, 6477, 6476
7660, 6454, 6455, 6478, 6477
7661, 6455, 6456, 6479, 6478
7662, 6456, 6457, 6480, 6479
7663, 6457, 6458, 6481, 6480
7664, 6458, 893, 894, 6481
7665, 780, 6459, 6482, 781
7666, 6459, 6460, 6483, 6482
7667, 6460, 6461, 6484, 6483
7668, 6461, 6462, 6485, 6484
7669, 6462, 6463, 6486, 6485
7670, 6463, 6464, 6487, 6486
7671, 6464, 6465, 6488, 6487
7672, 6465, 6466, 6489, 6488
7673, 6466, 6467, 6490, 6489
7674, 6467, 6468, 6491, 6490
7675, 6468, 6469, 6492, 6491
7676, 6469, 6470, 6493, 6492
7677, 6470, 6471, 6494, 6493
7678, 6471, 6472, 6495, 6494
7679, 6472, 6473, 6496, 6495
7680, 6473, 6474, 6497, 6496
7681, 6474, 6475, 6498, 6497
7682, 6475, 6476, 6499, 6498
7683, 6476, 6477, 6500, 6499
7684, 6477, 6478, 6501, 6500
7685, 6478, 6479, 6502, 6501
7686, 6479, 6480, 6503, 6502
7687, 6480, 6481, 6504, 6503
7688, 6481, 894, 895, 6504
7689, 781, 6482, 6505, 782
7690, 6482, 6483, 6506, 6505
7691, 6483, 6484, 6507, 6506
7692, 6484, 6485, 6508, 6507
7693, 6485, 6486, 6509, 6508
7694, 6486, 6487, 6510, 6509
7695, 6487, 6488, 6511, 6510
7696, 6488, 6489, 6512, 6511
7697, 6489, 6490, 6513, 6512
7698, 6490, 6491, 6514, 6513
7699, 6491, 6492, 6515, 6514
7700, 6492, 6493, 6516, 6515
7701, 6493, 6494, 6517, 6516
7702, 6494, 6495, 6518, 6517
7703, 6495, 6496, 6519, 6518
7704, 6496, 6497, 6520, 6519
7705, 6497, 6498, 6521, 6520
7706, 6498, 6499, 6522, 6521
7707, 6499, 6500, 6523, 6522
7708, 6500, 6501, 6524, 6523
7709, 6501, 6502, 6525, 6524
7710, 6502, 6503, 6526, 6525
7711, 6503, 6504, 6527, 6526
7712, 6504, 895, 896, 6527
7713, 782, 6505, 6528, 783
7714, 6505, 6506, 6529, 6528
7715, 6506, 6507, 6530, 6529
7716, 6507, 6508, 6531, 6530
7717, 6508, 6509, 6532, 6531
7718, 6509, 6510, 6533, 6532
7719, 6510, 6511, 6534, 6533
7720, 6511, 6512, 6535, 6534
7721, 6512, 6513, 6536, 6535
7722, 6513, 6514, 6537, 6536
7723, 6514, 6515, 6538, 6537
7724, 6515, 6516, 6539, 6538
7725, 6516, 6517, 6540, 6539
7726, 6517, 6518, 6541, 6540
7727, 6518, 6519, 6542, 6541
7728, 6519, 6520, 6543, 6542
7729, 6520, 6521, 6544, 6543
7730, 6521, 6522, 6545, 6544
7731, 6522, 6523, 6546, 6545
7732, 6523, 6524, 6547, 6546
7733, 6524, 6525, 6548, 6547
7734, 6525, 6526, 6549, 6548
7735, 6526, 6527, 6550, 6549
7736, 6527, 896, 897, 6550
7737, 783, 6528, 6551, 784
7738, 6528, 6529, 6552, 6551
7739, 6529, 6530, 6553, 6552
7740, 6530, 6531, 6554, 6553
7741, 6531, 6532, 6555, 6554
7742, 6532, 6533, 6556, 6555
7743, 6533, 6534, 6557, 6556
7744, 6534, 6535, 6558, 6557
7745, 6535, 6536, 6559, 6558
7746, 6536, 6537, 6560, 6559
7747, 6537, 6538, 6561, 6560
7748, 6538, 6539, 6562, 6561
7749, 6539, 6540, 6563, 6562
7750, 6540, 6541, 6564, 6563
7751, 6541, 6542, 6565, 6564
7752, 6542, 6543, 6566, 6565
7753, 6543, 6544, 6567, 6566
7754, 6544, 6545, 6568, 6567
7755, 6545, 6546, 6569, 6568
7756, 6546, 6547, 6570, 6569
7757, 6547, 6548, 6571, 6570
7758, 6548, 6549, 6572, 6571
7759, 6549, 6550, 6573, 6572
7760, 6550, 897, 898, 6573
7761, 784, 6551, 6574, 785
7762, 6551, 6552, 6575, 6574
7763, 6552, 6553, 6576, 6575
7764, 6553, 6554, 6577, 6576
7765, 6554, 6555, 6578, 6577
7766, 6555, 6556, 6579, 6578
7767, 6556, 6557, 6580, 6579
7768, 6557, 6558, 6581, 6580
7769, 6558, 6559, 6582, 6581
7770, 6559, 6560, 6583, 6582
7771, 6560, 6561, 6584, 6583
7772, 6561, 6562, 6585, 6584
7773, 6562, 6563, 6586, 6585
7774, 6563, 6564, 6587, 6586
7775, 6564, 6565, 6588, 6587
7776, 6565, 6566, 6589, 6588
7777, 6566, 6567, 6590, 6589
7778, 6567, 6568, 6591, 6590
7779, 6568, 6569, 6592, 6591
7780, 6569, 6570, 6593, 6592
7781, 6570, 6571, 6594, 6593
7782, 6571, 6572, 6595, 6594
7783, 6572, 6573, 6596, 6595
7784, 6573, 898, 899, 6596
7785, 785, 6574, 6597, 786
7786, 6574, 6575, 6598, 6597
7787, 6575, 6576, 6599, 6598
7788, 6576, 6577, 6600, 6599
7789, 6577, 6578, 6601, 6600
7790, 6578, 6579, 6602, 6601
7791, 6579, 6580, 6603, 6602
7792, 6580, 6581, 6604, 6603
7793, 6581, 6582, 6605, 6604
7794, 6582, 6583, 6606, 6605
7795, 6583, 6584, 6607, 6606
7796, 6584, 6585, 6608, 6607
7797, 6585, 6586, 6609, 6608
7798, 6586, 6587, 6610, 6609
7799, 6587, 6588, 6611, 6610
7800, 6588, 6589, 6612, 6611
7801, 6589, 6590, 6613, 6612
7802, 6590, 6591, 6614, 6613
7803, 6591, 6592, 6615, 6614
7804, 6592, 6593, 6616, 6615
7805, 6593, 6594, 6617, 6616
7806, 6594, 6595, 6618, 6617
7807, 6595, 6596, 6619, 6618
7808, 6596, 899, 900, 6619
7809, 786, 6597, 6620, 787
7810, 6597, 6598, 6621, 6620
7811, 6598, 6599, 6622, 6621
7812, 6599, 6600, 6623, 6622
7813, 6600, 6601, 6624, 6623
7814, 6601, 6602, 6625, 6624
7815, 6602, 6603, 6626, 6625
7816, 6603, 6604, 6627, 6626
7817, 6604, 6605, 6628, 6627
7818, 6605, 6606, 6629, 6628
7819, 6606, 6607, 6630, 6629
7820, 6607, 6608, 6631, 6630
7821, 6608, 6609, 6632, 6631
7822, 6609, 6610, 6633, 6632
7823, 6610, 6611, 6634, 6633
7824, 6611, 6612, 6635, 6634
7825, 6612, 6613, 6636, 6635
7826, 6613, 6614, 6637, 6636
7827, 6614, 6615, 6638, 6637
7828, 6615, 6616, 6639, 6638
7829, 6616, 6617, 6640, 6639
7830, 6617, 6618, 6641, 6640
7831, 6618, 6619, 6642, 6641
7832, 6619, 900, 901, 6642
7833, 787, 6620, 6643, 788
7834, 6620, 6621, 6644, 6643
7835, 6621, 6622, 6645, 6644
7836, 6622, 6623, 6646, 6645
7837, 6623, 6624, 6647, 6646
7838, 6624, 6625, 6648, 6647
7839, 6625, 6626, 6649, 6648
7840, 6626, 6627, 6650, 6649
7841, 6627, 6628, 6651, 6650
7842, 6628, 6629, 6652, 6651
7843, 6629, 6630, 6653, 6652
7844, 6630, 6631, 6654, 6653
7845, 6631, 6632, 6655, 6654
7846, 6632, 6633, 6656, 6655
7847, 6633, 6634, 6657, 6656
7848, 6634, 6635, 6658, 6657
7849, 6635, 6636, 6659, 6658
7850, 6636, 6637, 6660, 6659
7851, 6637, 6638, 6661, 6660
7852, 6638, 6639, 6662, 6661
7853, 6639, 6640, 6663, 6662
7854, 6640, 6641, 6664, 6663
7855, 6641, 6642, 6665, 6664
7856, 6642, 901, 902, 6665
7857, 788, 6643, 6666, 789
7858, 6643, 6644, 6667, 6666
7859, 6644, 6645, 6668, 6667
7860, 6645, 6646, 6669, 6668
7861, 6646, 6647, 6670, 6669
7862, 6647, 6648, 6671, 6670
7863, 6648, 6649, 6672, 6671
7864, 6649, 6650, 6673, 6672
7865, 6650, 6651, 6674, 6673
7866, 6651, 6652, 6675, 6674
7867, 6652, 6653, 6676, 6675
7868, 6653, 6654, 6677, 6676
7869, 6654, 6655, 6678, 6677
7870, 6655, 6656, 6679, 6678
7871, 6656, 6657, 6680, 6679
7872, 6657, 6658, 6681, 6680
7873, 6658, 6659, 6682, 6681
7874, 6659, 6660, 6683, 6682
7875, 6660, 6661, 6684, 6683
7876, 6661, 6662, 6685, 6684
7877, 6662, 6663, 6686, 6685
7878, 6663, 6664, 6687, 6686
7879, 6664, 6665, 6688, 6687
7880, 6665, 902, 903, 6688
7881, 789, 6666, 6689, 790
7882, 6666, 6667, 6690, 6689
7883, 6667, 6668, 6691, 6690
7884, 6668, 6669, 6692, 6691
7885, 6669, 6670, 6693, 6692
7886, 6670, 6671, 6694, 6693
7887, 6671, 6672, 6695, 6694
7888, 6672, 6673, 6696, 6695
7889, 6673, 6674, 6697, 6696
7890, 6674, 6675, 6698, 6697
7891, 6675, 6676, 6699, 6698
7892, 6676, 6677, 6700, 6699
7893, 6677, 6678, 6701, 6700
7894, 6678, 6679, 6702, 6701
7895, 6679, 6680, 6703, 6702
7896, 6680, 6681, 6704, 6703
7897, 6681, 6682, 6705, 6704
7898, 6682, 6683, 6706, 6705
7899, 6683, 6684, 6707, 6706
7900, 6684, 6685, 6708, 6707
7901, 6685, 6686, 6709, 6708
7902, 6686, 6687, 6710, 6709
7903, 6687, 6688, 6711, 6710
7904, 6688, 903, 904, 6711
7905, 790, 6689, 6712, 791
7906, 6689, 6690, 6713, 6712
7907, 6690, 6691, 6714, 6713
7908, 6691, 6692, 6715, 6714
7909, 6692, 6693, 6716, 6715
7910, 6693, 6694, 6717, 6716
7911, 6694, 6695, 6718, 6717
7912, 6695, 6696, 6719, 6718
7913, 6696, 6697, 6720, 6719
7914, 6697, 6698, 6721, 6720
7915, 6698, 6699, 6722, 6721
7916, 6699, 6700, 6723, 6722
7917, 6700, 6701, 6724, 6723
7918, 6701, 6702, 6725, 6724
7919, 6702, 6703, 6726, 6725
7920, 6703, 6704, 6727, 6726
7921, 6704, 6705, 6728, 6727
7922, 6705, 6706, 6729, 6728
7923, 6706, 6707, 6730, 6729
7924, 6707, 6708, 6731, 6730
7925, 6708, 6709, 6732, 6731
7926, 6709, 6710, 6733, 6732
7927, 6710, 6711, 6734, 6733
7928, 6711, 904, 905, 6734
7929, 791, 6712, 6735, 792
7930, 6712, 6713, 6736, 6735
7931, 6713, 6714, 6737, 6736
7932, 6714, 6715, 6738, 6737
7933, 6715, 6716, 6739, 6738
7934, 6716, 6717, 6740, 6739
7935, 6717, 6718, 6741, 6740
7936, 6718, 6719, 6742, 6741
7937, 6719, 6720, 6743, 6742
7938, 6720, 6721, 6744, 6743
7939, 6721, 6722, 6745, 6744
7940, 6722, 6723, 6746, 6745
7941, 6723, 6724, 6747, 6746
7942, 6724, 6725, 6748, 6747
7943, 6725, 6726, 6749, 6748
7944, 6726, 6727, 6750, 6749
7945, 6727, 6728, 6751, 6750
7946, 6728, 6729, 6752, 6751
7947, 6729, 6730, 6753, 6752
7948, 6730, 6731, 6754, 6753
7949, 6731, 6732, 6755, 6754
7950, 6732, 6733, 6756, 6755
7951, 6733, 6734, 6757, 6756
7952, 6734, 905, 906, 6757
7953, 792, 6735, 6758, 793
7954, 6735, 6736, 6759, 6758
7955, 6736, 6737, 6760, 6759
7956, 6737, 6738, 6761, 6760
7957, 6738, 6739, 6762, 6761
7958, 6739, 6740, 6763, 6762
7959, 6740, 6741, 6764, 6763
7960, 6741, 6742, 6765, 6764
7961, 6742, 6743, 6766, 6765
7962, 6743, 6744, 6767, 6766
7963, 6744, 6745, 6768, 6767
7964, 6745, 6746, 6769, 6768
7965, 6746, 6747, 6770, 6769
7966, 6747, 6748, 6771, 6770
7967, 6748, 6749, 6772, 6771
7968, 6749, 6750, 6773, 6772
7969, 6750, 6751, 6774, 6773
7970, 6751, 6752, 6775, 6774
7971, 6752, 6753, 6776, 6775
7972, 6753, 6754, 6777, 6776
7973, 6754, 6755, 6778, 6777
7974, 6755, 6756, 6779, 6778
7975, 6756, 6757, 6780, 6779
7976, 6757, 906, 907, 6780
7977, 793, 6758, 6781, 794
7978, 6758, 6759, 6782, 6781
7979, 6759, 6760, 6783, 6782
7980, 6760, 6761, 6784, 6783
7981, 6761, 6762, 6785, 6784
7982, 6762, 6763, 6786, 6785
7983, 6763, 6764, 6787, 6786
7984, 6764, 6765, 6788, 6787
7985, 6765, 6766, 6789, 6788
7986, 6766, 6767, 6790, 6789
7987, 6767, 6768, 6791, 6790
7988, 6768, 6769, 6792, 6791
7989, 6769, 6770, 6793, 6792
7990, 6770, 6771, 6794, 6793
7991, 6771, 6772, 6795, 6794
7992, 6772, 6773, 6796, 6795
7993, 6773, 6774, 6797, 6796
7994, 6774, 6775, 6798, 6797
7995, 6775, 6776, 6799, 6798
7996, 6776, 6777, 6800, 6799
7997, 6777, 6778, 6801, 6800
7998, 6778, 6779, 6802, 6801
7999, 6779, 6780, 6803, 6802
8000, 6780, 907, 908, 6803
8001, 794, 6781, 6804, 795
8002, 6781, 6782, 6805, 6804
8003, 6782, 6783, 6806, 6805
8004, 6783, 6784, 6807, 6806
8005, 6784, 6785, 6808, 6807
8006, 6785, 6786, 6809, 6808
8007, 6786, 6787, 6810, 6809
8008, 6787, 6788, 6811, 6810
8009, 6788, 6789, 6812, 6811
8010, 6789, 6790, 6813, 6812
8011, 6790, 6791, 6814, 6813
8012, 6791, 6792, 6815, 6814
8013, 6792, 6793, 6816, 6815
8014, 6793, 6794, 6817, 6816
8015, 6794, 6795, 6818, 6817
8016, 6795, 6796, 6819, 6818
8017, 6796, 6797, 6820, 6819
8018, 6797, 6798, 6821, 6820
8019, 6798, 6799, 6822, 6821
8020, 6799, 6800, 6823, 6822
8021, 6800, 6801, 6824, 6823
8022, 6801, 6802, 6825, 6824
8023, 6802, 6803, 6826, 6825
8024, 6803, 908, 909, 6826
8025, 795, 6804, 864, 34
8026, 6804, 6805, 865, 864
8027, 6805, 6806, 866, 865
8028, 6806, 6807, 867, 866
8029, 6807, 6808, 868, 867
8030, 6808, 6809, 869, 868
8031, 6809, 6810, 870, 869
8032, 6810, 6811, 871, 870
8033, 6811, 6812, 872, 871
8034, 6812, 6813, 873, 872
8035, 6813, 6814, 874, 873
8036, 6814, 6815, 875, 874
8037, 6815, 6816, 876, 875
8038, 6816, 6817, 877, 876
8039, 6817, 6818, 878, 877
8040, 6818, 6819, 879, 878
8041, 6819, 6820, 880, 879
8042, 6820, 6821, 881, 880
8043, 6821, 6822, 882, 881
8044, 6822, 6823, 883, 882
8045, 6823, 6824, 884, 883
8046, 6824, 6825, 885, 884
8047, 6825, 6826, 886, 885
8048, 6826, 909, 38, 886
*ELEMENT, type=CPS4, ELSET=Surface43
8049, 35, 796, 6827, 910
8050, 910, 6827, 6828, 911
8051, 911, 6828, 6829, 912
8052, 912, 6829, 6830, 913
8053, 913, 6830, 6831, 914
8054, 914, 6831, 6832, 915
8055, 915, 6832, 6833, 916
8056, 916, 6833, 6834, 917
8057, 917, 6834, 6835, 918
8058, 918, 6835, 6836, 919
8059, 919, 6836, 6837, 920
8060, 920, 6837, 6838, 921
8061, 921, 6838, 6839, 922
8062, 922, 6839, 6840, 923
8063, 923, 6840, 6841, 924
8064, 924, 6841, 6842, 925
8065, 925, 6842, 6843, 926
8066, 926, 6843, 6844, 927
8067, 927, 6844, 6845, 928
8068, 928, 6845, 6846, 929
8069, 929, 6846, 6847, 930
8070, 930, 6847, 6848, 931
8071, 931, 6848, 6849, 932
8072, 932, 6849, 956, 39
8073, 796, 797, 6850, 6827
8074, 6827, 6850, 6851, 6828
8075, 6828, 6851, 6852, 6829
8076, 6829, 6852, 6853, 6830
8077, 6830, 6853, 6854, 6831
8078, 6831, 6854, 6855, 6832
8079, 6832, 6855, 6856, 6833
8080, 6833, 6856, 6857, 6834
8081, 6834, 6857, 6858, 6835
8082, 6835, 6858, 6859, 6836
8083, 6836, 6859, 6860, 6837
8084, 6837, 6860, 6861, 6838
8085, 6838, 6861, 6862, 6839
8086, 6839, 6862, 6863, 6840
8087, 6840, 6863, 6864, 6841
8088, 6841, 6864, 6865, 6842
8089, 6842, 6865, 6866, 6843
8090, 6843, 6866, 6867, 6844
8091, 6844, 6867, 6868, 6845
8092, 6845, 6868, 6869, 6846
8093, 6846, 6869, 6870, 6847
8094, 6847, 6870, 6871, 6848
8095, 6848, 6871, 6872, 6849
8096, 6849, 6872, 957, 956
8097, 797, 798, 6873, 6850
8098, 6850, 6873, 6874, 6851
8099, 6851, 6874, 6875, 6852
8100, 6852, 6875, 6876, 6853
8101, 6853, 6876, 6877, 6854
8102, 6854, 6877, 6878, 6855
8103, 6855, 6878, 6879, 6856
8104, 6856, 6879, 6880, 6857
8105, 6857, 6880, 6881, 6858
8106, 6858, 6881, 6882, 6859
8107, 6859, 6882, 6883, 6860
8108, 6860, 6883, 6884, 6861
8109, 6861, 6884, 6885, 6862
8110, 6862, 6885, 6886, 6863
8111, 6863, 6886, 6887, 6864
8112, 6864, 6887, 6888, 6865
8113, 6865, 6888, 6889, 6866
8114, 6866, 6889, 6890, 6867
8115, 6867, 6890, 6891, 6868
8116, 6868, 6891, 6892, 6869
8117, 6869, 6892, 6893, 6870
8118, 6870, 6893, 6894, 6871
8119, 6871, 6894, 6895, 6872
8120, 6872, 6895, 958, 957
8121, 798, 799, 6896, 6873
8122, 6873, 6896, 6897, 6874
8123, 6874, 6897, 6898, 6875
8124, 6875, 6898, 6899, 6876
8125, 6876, 6899, 6900, 6877
8126, 6877, 6900, 6901, 6878
8127, 6878, 6901, 6902, 6879
8128, 6879, 6902, 6903, 6880
8129, 6880, 6903, 6904, 6881
8130, 6881, 6904, 6905, 6882
8131, 6882, 6905, 6906, 6883
8132, 6883, 6906, 6907, 6884
8133, 6884, 6907, 6908, 6885
8134, 6885, 6908, 6909, 6886
8135, 6886, 6909, 6910, 6887
8136, 6887, 6910, 6911, 6888
8137, 6888, 6911, 6912, 6889
8138, 6889, 6912, 6913, 6890
8139, 6890, 6913, 6914, 6891
8140, 6891, 6914, 6915, 6892
8141, 6892, 6915, 6916, 6893
8142, 6893, 6916, 6917, 6894
8143, 6894, 6917, 6918, 6895
8144, 6895, 6918, 959, 958
8145, 799, 800, 6919, 6896
8146, 6896, 6919, 6920, 6897
8147, 6897, 6920, 6921, 6898
8148, 6898, 6921, 6922, 6899
8149, 6899, 6922, 6923, 6900
8150, 6900, 6923, 6924, 6901
8151, 6901, 6924, 6925, 6902
8152, 6902, 6925, 6926, 6903
8153, 6903, 6926, 6927, 6904
8154, 6904, 6927, 6928, 6905
8155, 6905, 6928, 6929, 6906
8156, 6906, 6929, 6930, 6907
8157, 6907, 6930, 6931, 6908
8158, 6908, 6931, 6932, 6909
8159, 6909, 6932, 6933, 6910
8160, 6910, 6933, 6934, 6911
8161, 6911, 6934, 6935, 6912
8162, 6912, 6935, 6936, 6913
8163, 6913, 6936, 6937, 6914
8164, 6914, 6937, 6938, 6915
8165, 6915, 6938, 6939, 6916
8166, 6916, 6939, 6940, 6917
8167, 6917, 6940, 6941, 6918
8168, 6918, 6941, 960, 959
8169, 800, 801, 6942, 6919
8170, 6919, 6942, 6943, 6920
8171, 6920, 6943, 6944, 6921
8172, 6921, 6944, 6945, 6922
8173, 6922, 6945, 6946, 6923
8174, 6923, 6946, 6947, 6924
8175, 6924, 6947, 6948, 6925
8176, 6925, 6948, 6949, 6926
8177, 6926, 6949, 6950, 6927
8178, 6927, 6950, 6951, 6928
8179, 6928, 6951, 6952, 6929
8180, 6929, 6952, 6953, 6930
8181, 6930, 6953, 6954, 6931
8182, 6931, 6954, 6955, 6932
8183, 6932, 6955, 6956, 6933
8184, 6933, 6956, 6957, 6934
8185, 6934, 6957, 6958, 6935
8186, 6935, 6958, 6959, 6936
8187, 6936, 6959, 6960, 6937
8188, 6937, 6960, 6961, 6938
8189, 6938, 6961, 6962, 6939
8190, 6939, 6962, 6963, 6940
8191, 6940, 6963, 6964, 6941
8192, 6941, 6964, 961, 960
8193, 801, 802, 6965, 6942
8194, 6942, 6965, 6966, 6943
8195, 6943, 6966, 6967, 6944
8196, 6944, 6967, 6968, 6945
8197, 6945, 6968, 6969, 6946
8198, 6946, 6969, 6970, 6947
8199, 6947, 6970, 6971, 6948
8200, 6948, 6971, 6972, 6949
8201, 6949, 6972, 6973, 6950
8202, 6950, 6973, 6974, 6951
8203, 6951, 6974, 6975, 6952
8204, 6952, 6975, 6976, 6953
8205, 6953, 6976, 6977, 6954
8206, 6954, 6977, 6978, 6955
8207, 6955, 6978, 6979, 6956
8208, 6956, 6979, 6980, 6957
8209, 6957, 6980, 6981, 6958
8210, 6958, 6981, 6982, 6959
8211, 6959, 6982, 6983, 6960
8212, 6960, 6983, 6984, 6961
8213, 6961, 6984, 6985, 6962
8214, 6962, 6985, 6986, 6963
8215, 6963, 6986, 6987, 6964
8216, 6964, 6987, 962, 961
8217, 802, 803, 6988, 6965
8218, 6965, 6988, 6989, 6966
8219, 6966, 6989, 6990, 6967
8220, 6967, 6990, 6991, 6968
8221, 6968, 6991, 6992, 6969
8222, 6969, 6992, 6993, 6970
8223, 6970, 6993, 6994, 6971
8224, 6971, 6994, 6995, 6972
8225, 6972, 6995, 6996, 6973
8226, 6973, 6996, 6997, 6974
8227, 6974, 6997, 6998, 6975
8228, 6975, 6998, 6999, 6976
8229, 6976, 6999, 7000, 6977
8230, 6977, 7000, 7001, 6978
8231, 6978, 7001, 7002, 6979
8232, 6979, 7002, 7003, 6980
8233, 6980, 7003, 7004, 6981
8234, 6981, 7004, 7005, 6982
8235, 6982, 7005, 7006, 6983
8236, 6983, 7006, 7007, 6984
8237, 6984, 7007, 7008, 6985
8238, 6985, 7008, 7009, 6986
8239, 6986, 7009, 7010, 6987
8240, 6987, 7010, 963, 962
8241, 803, 804, 7011, 6988
8242, 6988, 7011, 7012, 6989
8243, 6989, 7012, 7013, 6990
8244, 6990, 7013, 7014, 6991
8245, 6991, 7014, 7015, 6992
8246, 6992, 7015, 7016, 6993
8247, 6993, 7016, 7017, 6994
8248, 6994, 7017, 7018, 6995
8249, 6995, 7018, 7019, 6996
8250, 6996, 7019, 7020, 6997
8251, 6997, 7020, 7021, 6998
8252, 6998, 7021, 7022, 6999
8253, 6999, 7022, 7023, 7000
8254, 7000, 7023, 7024, 7001
8255, 7001, 7024, 7025, 7002
8256, 7002, 7025, 7026, 7003
8257, 7003, 7026, 7027, 7004
8258, 7004, 7027, 7028, 7005
8259, 7005, 7028, 7029, 7006
8260, 7006, 7029, 7030, 7007
8261, 7007, 7030, 7031, 7008
8262, 7008, 7031, 7032, 7009
8263, 7009, 7032, 7033, 7010
8264, 7010, 7033, 964, 963
8265, 804, 805, 7034, 7011
8266, 7011, 7034, 7035, 7012
8267, 7012, 7035, 7036, 7013
8268, 7013, 7036, 7037, 7014
8269, 7014, 7037, 7038, 7015
8270, 7015, 7038, 7039, 7016
8271, 7016, 7039, 7040, 7017
8272, 7017, 7040, 7041, 7018
8273, 7018, 7041, 7042, 7019
8274, 7019, 7042, 7043, 7020
8275, 7020, 7043, 7044, 7021
8276, 7021, 7044, 7045, 7022
8277, 7022, 7045, 7046, 7023
8278, 7023, 7046, 7047, 7024
8279, 7024, 7047, 7048, 7025
8280, 7025, 7048, 7049, 7026
8281, 7026, 7049, 7050, 7027
8282, 7027, 7050, 7051, 7028
8283, 7028, 7051, 7052, 7029
8284, 7029, 7052, 7053, 7030
8285, 7030, 7053, 7054, 7031
8286, 7031, 7054, 7055, 7032
8287, 7032, 7055, 7056, 7033
8288, 7033, 7056, 965, 964
8289, 805, 806, 7057, 7034
8290, 7034, 7057, 7058, 7035
8291, 7035, 7058, 7059, 7036
8292, 7036, 7059, 7060, 7037
8293, 7037, 7060, 7061, 7038
8294, 7038, 7061, 7062, 7039
8295, 7039, 7062, 7063, 7040
8296, 7040, 7063, 7064, 7041
8297, 7041, 7064, 7065, 7042
8298, 7042, 7065, 7066, 7043
8299, 7043, 7066, 7067, 7044
8300, 7044, 7067, 7068, 7045
8301, 7045, 7068, 7069, 7046
8302, 7046, 7069, 7070, 7047
8303, 7047, 7070, 7071, 7048
8304, 7048, 7071, 7072, 7049
8305, 7049, 7072, 7073, 7050
8306, 7050, 7073, 7074, 7051
8307, 7051, 7074, 7075, 7052
8308, 7052, 7075, 7076, 7053
8309, 7053, 7076, 7077, 7054
8310, 7054, 7077, 7078, 7055
8311, 7055, 7078, 7079, 7056
8312, 7056, 7079, 966, 965
8313, 806, 807, 7080, 7057
8314, 7057, 7080, 7081, 7058
8315, 7058, 7081, 7082, 7059
8316, 7059, 7082, 7083, 7060
8317, 7060, 7083, 7084, 7061
8318, 7061, 7084, 7085, 7062
8319, 7062, 7085, 7086, 7063
8320, 7063, 7086, 7087, 7064
8321, 7064, 7087, 7088, 7065
8322, 7065, 7088, 7089, 7066
8323, 7066, 7089, 7090, 7067
8324, 7067, 7090, 7091, 7068
8325, 7068, 7091, 7092, 7069
8326, 7069, 7092, 7093, 7070
8327, 7070, 7093, 7094, 7071
8328, 7071, 7094, 7095, 7072
8329, 7072, 7095, 7096, 7073
8330, 7073, 7096, 7097, 7074
8331, 7074, 7097, 7098, 7075
8332, 7075, 7098, 7099, 7076
8333, 7076, 7099, 7100, 7077
8334, 7077, 7100, 7101, 7078
8335, 7078, 7101, 7102, 7079
8336, 7079, 7102, 967, 966
8337, 807, 808, 7103, 7080
8338, 7080, 7103, 7104, 7081
8339, 7081, 7104, 7105, 7082
8340, 7082, 7105, 7106, 7083
8341, 7083, 7106, 7107, 7084
8342, 7084, 7107, 7108, 7085
8343, 7085, 7108, 7109, 7086
8344, 7086, 7109, 7110, 7087
8345, 7087, 7110, 7111, 7088
8346, 7088, 7111, 7112, 7089
8347, 7089, 7112, 7113, 7090
8348, 7090, 7113, 7114, 7091
8349, 7091, 7114, 7115, 7092
8350, 7092, 7115, 7116, 7093
8351, 7093, 7116, 7117, 7094
8352, 7094, 7117, 7118, 7095
8353, 7095, 7118, 7119, 7096
8354, 7096, 7119, 7120, 7097
8355, 7097, 7120, 7121, 7098
8356, 7098, 7121, 7122, 7099
8357, 7099, 7122, 7123, 7100
8358, 7100, 7123, 7124, 7101
8359, 7101, 7124, 7125, 7102
8360, 7102, 7125, 968, 967
8361, 808, 809, 7126, 7103
8362, 7103, 7126, 7127, 7104
8363, 7104, 7127, 7128, 7105
8364, 7105, 7128, 7129, 7106
8365, 7106, 7129, 7130, 7107
8366, 7107, 7130, 7131, 7108
8367, 7108, 7131, 7132, 7109
8368, 7109, 7132, 7133, 7110
8369, 7110, 7133, 7134, 7111
8370, 7111, 7134, 7135, 7112
8371, 7112, 7135, 7136, 7113
8372, 7113, 7136, 7137, 7114
8373, 7114, 7137, 7138, 7115
8374, 7115, 7138, 7139, 7116
8375, 7116, 7139, 7140, 7117
8376, 7117, 7140, 7141, 7118
8377, 7118, 7141, 7142, 7119
8378, 7119, 7142, 7143, 7120
8379, 7120, 7143, 7144, 7121
8380, 7121, 7144, 7145, 7122
8381, 7122, 7145, 7146, 7123
8382, 7123, 7146, 7147, 7124
8383, 7124, 7147, 7148, 7125
8384, 7125, 7148, 969, 968
8385, 809, 810, 7149, 7126
8386, 7126, 7149, 7150, 7127
8387, 7127, 7150, 7151, 7128
8388, 7128, 7151, 7152, 7129
8389, 7129, 7152, 7153, 7130
8390, 7130, 7153, 7154, 7131
8391, 7131, 7154, 7155, 7132
8392, 7132, 7155, 7156, 7133
8393, 7133, 7156, 7157, 7134
8394, 7134, 7157, 7158, 7135
8395, 7135, 7158, 7159, 7136
8396, 7136, 7159, 7160, 7137
8397, 7137, 7160, 7161, 7138
8398, 7138, 7161, 7162, 7139
8399, 7139, 7162, 7163, 7140
8400, 7140, 7163, 7164, 7141
8401, 7141, 7164, 7165, 7142
8402, 7142, 7165, 7166, 7143
8403, 7143, 7166, 7167, 7144
8404, 7144, 7167, 7168, 7145
8405, 7145, 7168, 7169, 7146
8406, 7146, 7169, 7170, 7147
8407, 7147, 7170, 7171, 7148
8408, 7148, 7171, 970, 969
8409, 810, 811, 7172, 7149
8410, 7149, 7172, 7173, 7150
8411, 7150, 7173, 7174, 7151
8412, 7151, 7174, 7175, 7152
8413, 7152, 7175, 7176, 7153
8414, 7153, 7176, 7177, 7154
8415, 7154, 7177, 7178, 7155
8416, 7155, 7178, 7179, 7156
8417, 7156, 7179, 7180, 7157
8418, 7157, 7180, 7181, 7158
8419, 7158, 7181, 7182, 7159
8420, 7159, 7182, 7183, 7160
8421, 7160, 7183, 7184, 7161
8422, 7161, 7184, 7185, 7162
8423, 7162, 7185, 7186, 7163
8424, 7163, 7186, 7187, 7164
8425, 7164, 7187, 7188, 7165
8426, 7165, 7188, 7189, 7166
8427, 7166, 7189, 7190, 7167
8428, 7167, 7190, 7191, 7168
8429, 7168, 7191, 7192, 7169
8430, 7169, 7192, 7193, 7170
8431, 7170, 7193, 7194, 7171
8432, 7171, 7194, 971, 970
8433, 811, 812, 7195, 7172
8434, 7172, 7195, 7196, 7173
8435, 7173, 7196, 7197, 7174
8436, 7174, 7197, 7198, 7175
8437, 7175, 7198, 7199, 7176
8438, 7176, 7199, 7200, 7177
8439, 7177, 7200, 7201, 7178
8440, 7178, 7201, 7202, 7179
8441, 7179, 7202, 7203, 7180
8442, 7180, 7203, 7204, 7181
8443, 7181, 7204, 7205, 7182
8444, 7182, 7205, 7206, 7183
8445, 7183, 7206, 7207, 7184
8446, 7184, 7207, 7208, 7185
8447, 7185, 7208, 7209, 7186
8448, 7186, 7209, 7210, 7187
8449, 7187, 7210, 7211, 7188
8450, 7188, 7211, 7212, 7189
8451, 7189, 7212, 7213, 7190
8452, 7190, 7213, 7214, 7191
8453, 7191, 7214, 7215, 7192
8454, 7192, 7215, 7216, 7193
8455, 7193, 7216, 7217, 7194
8456, 7194, 7217, 972, 971
