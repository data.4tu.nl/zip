8457, 812, 813, 7218, 7195
8458, 7195, 7218, 7219, 7196
8459, 7196, 7219, 7220, 7197
8460, 7197, 7220, 7221, 7198
8461, 7198, 7221, 7222, 7199
8462, 7199, 7222, 7223, 7200
8463, 7200, 7223, 7224, 7201
8464, 7201, 7224, 7225, 7202
8465, 7202, 7225, 7226, 7203
8466, 7203, 7226, 7227, 7204
8467, 7204, 7227, 7228, 7205
8468, 7205, 7228, 7229, 7206
8469, 7206, 7229, 7230, 7207
8470, 7207, 7230, 7231, 7208
8471, 7208, 7231, 7232, 7209
8472, 7209, 7232, 7233, 7210
8473, 7210, 7233, 7234, 7211
8474, 7211, 7234, 7235, 7212
8475, 7212, 7235, 7236, 7213
8476, 7213, 7236, 7237, 7214
8477, 7214, 7237, 7238, 7215
8478, 7215, 7238, 7239, 7216
8479, 7216, 7239, 7240, 7217
8480, 7217, 7240, 973, 972
8481, 813, 814, 7241, 7218
8482, 7218, 7241, 7242, 7219
8483, 7219, 7242, 7243, 7220
8484, 7220, 7243, 7244, 7221
8485, 7221, 7244, 7245, 7222
8486, 7222, 7245, 7246, 7223
8487, 7223, 7246, 7247, 7224
8488, 7224, 7247, 7248, 7225
8489, 7225, 7248, 7249, 7226
8490, 7226, 7249, 7250, 7227
8491, 7227, 7250, 7251, 7228
8492, 7228, 7251, 7252, 7229
8493, 7229, 7252, 7253, 7230
8494, 7230, 7253, 7254, 7231
8495, 7231, 7254, 7255, 7232
8496, 7232, 7255, 7256, 7233
8497, 7233, 7256, 7257, 7234
8498, 7234, 7257, 7258, 7235
8499, 7235, 7258, 7259, 7236
8500, 7236, 7259, 7260, 7237
8501, 7237, 7260, 7261, 7238
8502, 7238, 7261, 7262, 7239
8503, 7239, 7262, 7263, 7240
8504, 7240, 7263, 974, 973
8505, 814, 815, 7264, 7241
8506, 7241, 7264, 7265, 7242
8507, 7242, 7265, 7266, 7243
8508, 7243, 7266, 7267, 7244
8509, 7244, 7267, 7268, 7245
8510, 7245, 7268, 7269, 7246
8511, 7246, 7269, 7270, 7247
8512, 7247, 7270, 7271, 7248
8513, 7248, 7271, 7272, 7249
8514, 7249, 7272, 7273, 7250
8515, 7250, 7273, 7274, 7251
8516, 7251, 7274, 7275, 7252
8517, 7252, 7275, 7276, 7253
8518, 7253, 7276, 7277, 7254
8519, 7254, 7277, 7278, 7255
8520, 7255, 7278, 7279, 7256
8521, 7256, 7279, 7280, 7257
8522, 7257, 7280, 7281, 7258
8523, 7258, 7281, 7282, 7259
8524, 7259, 7282, 7283, 7260
8525, 7260, 7283, 7284, 7261
8526, 7261, 7284, 7285, 7262
8527, 7262, 7285, 7286, 7263
8528, 7263, 7286, 975, 974
8529, 815, 816, 7287, 7264
8530, 7264, 7287, 7288, 7265
8531, 7265, 7288, 7289, 7266
8532, 7266, 7289, 7290, 7267
8533, 7267, 7290, 7291, 7268
8534, 7268, 7291, 7292, 7269
8535, 7269, 7292, 7293, 7270
8536, 7270, 7293, 7294, 7271
8537, 7271, 7294, 7295, 7272
8538, 7272, 7295, 7296, 7273
8539, 7273, 7296, 7297, 7274
8540, 7274, 7297, 7298, 7275
8541, 7275, 7298, 7299, 7276
8542, 7276, 7299, 7300, 7277
8543, 7277, 7300, 7301, 7278
8544, 7278, 7301, 7302, 7279
8545, 7279, 7302, 7303, 7280
8546, 7280, 7303, 7304, 7281
8547, 7281, 7304, 7305, 7282
8548, 7282, 7305, 7306, 7283
8549, 7283, 7306, 7307, 7284
8550, 7284, 7307, 7308, 7285
8551, 7285, 7308, 7309, 7286
8552, 7286, 7309, 976, 975
8553, 816, 817, 7310, 7287
8554, 7287, 7310, 7311, 7288
8555, 7288, 7311, 7312, 7289
8556, 7289, 7312, 7313, 7290
8557, 7290, 7313, 7314, 7291
8558, 7291, 7314, 7315, 7292
8559, 7292, 7315, 7316, 7293
8560, 7293, 7316, 7317, 7294
8561, 7294, 7317, 7318, 7295
8562, 7295, 7318, 7319, 7296
8563, 7296, 7319, 7320, 7297
8564, 7297, 7320, 7321, 7298
8565, 7298, 7321, 7322, 7299
8566, 7299, 7322, 7323, 7300
8567, 7300, 7323, 7324, 7301
8568, 7301, 7324, 7325, 7302
8569, 7302, 7325, 7326, 7303
8570, 7303, 7326, 7327, 7304
8571, 7304, 7327, 7328, 7305
8572, 7305, 7328, 7329, 7306
8573, 7306, 7329, 7330, 7307
8574, 7307, 7330, 7331, 7308
8575, 7308, 7331, 7332, 7309
8576, 7309, 7332, 977, 976
8577, 817, 818, 7333, 7310
8578, 7310, 7333, 7334, 7311
8579, 7311, 7334, 7335, 7312
8580, 7312, 7335, 7336, 7313
8581, 7313, 7336, 7337, 7314
8582, 7314, 7337, 7338, 7315
8583, 7315, 7338, 7339, 7316
8584, 7316, 7339, 7340, 7317
8585, 7317, 7340, 7341, 7318
8586, 7318, 7341, 7342, 7319
8587, 7319, 7342, 7343, 7320
8588, 7320, 7343, 7344, 7321
8589, 7321, 7344, 7345, 7322
8590, 7322, 7345, 7346, 7323
8591, 7323, 7346, 7347, 7324
8592, 7324, 7347, 7348, 7325
8593, 7325, 7348, 7349, 7326
8594, 7326, 7349, 7350, 7327
8595, 7327, 7350, 7351, 7328
8596, 7328, 7351, 7352, 7329
8597, 7329, 7352, 7353, 7330
8598, 7330, 7353, 7354, 7331
8599, 7331, 7354, 7355, 7332
8600, 7332, 7355, 978, 977
8601, 818, 36, 933, 7333
8602, 7333, 933, 934, 7334
8603, 7334, 934, 935, 7335
8604, 7335, 935, 936, 7336
8605, 7336, 936, 937, 7337
8606, 7337, 937, 938, 7338
8607, 7338, 938, 939, 7339
8608, 7339, 939, 940, 7340
8609, 7340, 940, 941, 7341
8610, 7341, 941, 942, 7342
8611, 7342, 942, 943, 7343
8612, 7343, 943, 944, 7344
8613, 7344, 944, 945, 7345
8614, 7345, 945, 946, 7346
8615, 7346, 946, 947, 7347
8616, 7347, 947, 948, 7348
8617, 7348, 948, 949, 7349
8618, 7349, 949, 950, 7350
8619, 7350, 950, 951, 7351
8620, 7351, 951, 952, 7352
8621, 7352, 952, 953, 7353
8622, 7353, 953, 954, 7354
8623, 7354, 954, 955, 7355
8624, 7355, 955, 40, 978
*ELEMENT, type=CPS4, ELSET=Surface44
8625, 35, 910, 7356, 819
8626, 910, 911, 7357, 7356
8627, 911, 912, 7358, 7357
8628, 912, 913, 7359, 7358
8629, 913, 914, 7360, 7359
8630, 914, 915, 7361, 7360
8631, 915, 916, 7362, 7361
8632, 916, 917, 7363, 7362
8633, 917, 918, 7364, 7363
8634, 918, 919, 7365, 7364
8635, 919, 920, 7366, 7365
8636, 920, 921, 7367, 7366
8637, 921, 922, 7368, 7367
8638, 922, 923, 7369, 7368
8639, 923, 924, 7370, 7369
8640, 924, 925, 7371, 7370
8641, 925, 926, 7372, 7371
8642, 926, 927, 7373, 7372
8643, 927, 928, 7374, 7373
8644, 928, 929, 7375, 7374
8645, 929, 930, 7376, 7375
8646, 930, 931, 7377, 7376
8647, 931, 932, 7378, 7377
8648, 932, 39, 979, 7378
8649, 819, 7356, 7379, 820
8650, 7356, 7357, 7380, 7379
8651, 7357, 7358, 7381, 7380
8652, 7358, 7359, 7382, 7381
8653, 7359, 7360, 7383, 7382
8654, 7360, 7361, 7384, 7383
8655, 7361, 7362, 7385, 7384
8656, 7362, 7363, 7386, 7385
8657, 7363, 7364, 7387, 7386
8658, 7364, 7365, 7388, 7387
8659, 7365, 7366, 7389, 7388
8660, 7366, 7367, 7390, 7389
8661, 7367, 7368, 7391, 7390
8662, 7368, 7369, 7392, 7391
8663, 7369, 7370, 7393, 7392
8664, 7370, 7371, 7394, 7393
8665, 7371, 7372, 7395, 7394
8666, 7372, 7373, 7396, 7395
8667, 7373, 7374, 7397, 7396
8668, 7374, 7375, 7398, 7397
8669, 7375, 7376, 7399, 7398
8670, 7376, 7377, 7400, 7399
8671, 7377, 7378, 7401, 7400
8672, 7378, 979, 980, 7401
8673, 820, 7379, 7402, 821
8674, 7379, 7380, 7403, 7402
8675, 7380, 7381, 7404, 7403
8676, 7381, 7382, 7405, 7404
8677, 7382, 7383, 7406, 7405
8678, 7383, 7384, 7407, 7406
8679, 7384, 7385, 7408, 7407
8680, 7385, 7386, 7409, 7408
8681, 7386, 7387, 7410, 7409
8682, 7387, 7388, 7411, 7410
8683, 7388, 7389, 7412, 7411
8684, 7389, 7390, 7413, 7412
8685, 7390, 7391, 7414, 7413
8686, 7391, 7392, 7415, 7414
8687, 7392, 7393, 7416, 7415
8688, 7393, 7394, 7417, 7416
8689, 7394, 7395, 7418, 7417
8690, 7395, 7396, 7419, 7418
8691, 7396, 7397, 7420, 7419
8692, 7397, 7398, 7421, 7420
8693, 7398, 7399, 7422, 7421
8694, 7399, 7400, 7423, 7422
8695, 7400, 7401, 7424, 7423
8696, 7401, 980, 981, 7424
8697, 821, 7402, 7425, 822
8698, 7402, 7403, 7426, 7425
8699, 7403, 7404, 7427, 7426
8700, 7404, 7405, 7428, 7427
8701, 7405, 7406, 7429, 7428
8702, 7406, 7407, 7430, 7429
8703, 7407, 7408, 7431, 7430
8704, 7408, 7409, 7432, 7431
8705, 7409, 7410, 7433, 7432
8706, 7410, 7411, 7434, 7433
8707, 7411, 7412, 7435, 7434
8708, 7412, 7413, 7436, 7435
8709, 7413, 7414, 7437, 7436
8710, 7414, 7415, 7438, 7437
8711, 7415, 7416, 7439, 7438
8712, 7416, 7417, 7440, 7439
8713, 7417, 7418, 7441, 7440
8714, 7418, 7419, 7442, 7441
8715, 7419, 7420, 7443, 7442
8716, 7420, 7421, 7444, 7443
8717, 7421, 7422, 7445, 7444
8718, 7422, 7423, 7446, 7445
8719, 7423, 7424, 7447, 7446
8720, 7424, 981, 982, 7447
8721, 822, 7425, 7448, 823
8722, 7425, 7426, 7449, 7448
8723, 7426, 7427, 7450, 7449
8724, 7427, 7428, 7451, 7450
8725, 7428, 7429, 7452, 7451
8726, 7429, 7430, 7453, 7452
8727, 7430, 7431, 7454, 7453
8728, 7431, 7432, 7455, 7454
8729, 7432, 7433, 7456, 7455
8730, 7433, 7434, 7457, 7456
8731, 7434, 7435, 7458, 7457
8732, 7435, 7436, 7459, 7458
8733, 7436, 7437, 7460, 7459
8734, 7437, 7438, 7461, 7460
8735, 7438, 7439, 7462, 7461
8736, 7439, 7440, 7463, 7462
8737, 7440, 7441, 7464, 7463
8738, 7441, 7442, 7465, 7464
8739, 7442, 7443, 7466, 7465
8740, 7443, 7444, 7467, 7466
8741, 7444, 7445, 7468, 7467
8742, 7445, 7446, 7469, 7468
8743, 7446, 7447, 7470, 7469
8744, 7447, 982, 983, 7470
8745, 823, 7448, 7471, 824
8746, 7448, 7449, 7472, 7471
8747, 7449, 7450, 7473, 7472
8748, 7450, 7451, 7474, 7473
8749, 7451, 7452, 7475, 7474
8750, 7452, 7453, 7476, 7475
8751, 7453, 7454, 7477, 7476
8752, 7454, 7455, 7478, 7477
8753, 7455, 7456, 7479, 7478
8754, 7456, 7457, 7480, 7479
8755, 7457, 7458, 7481, 7480
8756, 7458, 7459, 7482, 7481
8757, 7459, 7460, 7483, 7482
8758, 7460, 7461, 7484, 7483
8759, 7461, 7462, 7485, 7484
8760, 7462, 7463, 7486, 7485
8761, 7463, 7464, 7487, 7486
8762, 7464, 7465, 7488, 7487
8763, 7465, 7466, 7489, 7488
8764, 7466, 7467, 7490, 7489
8765, 7467, 7468, 7491, 7490
8766, 7468, 7469, 7492, 7491
8767, 7469, 7470, 7493, 7492
8768, 7470, 983, 984, 7493
8769, 824, 7471, 7494, 825
8770, 7471, 7472, 7495, 7494
8771, 7472, 7473, 7496, 7495
8772, 7473, 7474, 7497, 7496
8773, 7474, 7475, 7498, 7497
8774, 7475, 7476, 7499, 7498
8775, 7476, 7477, 7500, 7499
8776, 7477, 7478, 7501, 7500
8777, 7478, 7479, 7502, 7501
8778, 7479, 7480, 7503, 7502
8779, 7480, 7481, 7504, 7503
8780, 7481, 7482, 7505, 7504
8781, 7482, 7483, 7506, 7505
8782, 7483, 7484, 7507, 7506
8783, 7484, 7485, 7508, 7507
8784, 7485, 7486, 7509, 7508
8785, 7486, 7487, 7510, 7509
8786, 7487, 7488, 7511, 7510
8787, 7488, 7489, 7512, 7511
8788, 7489, 7490, 7513, 7512
8789, 7490, 7491, 7514, 7513
8790, 7491, 7492, 7515, 7514
8791, 7492, 7493, 7516, 7515
8792, 7493, 984, 985, 7516
8793, 825, 7494, 7517, 826
8794, 7494, 7495, 7518, 7517
8795, 7495, 7496, 7519, 7518
8796, 7496, 7497, 7520, 7519
8797, 7497, 7498, 7521, 7520
8798, 7498, 7499, 7522, 7521
8799, 7499, 7500, 7523, 7522
8800, 7500, 7501, 7524, 7523
8801, 7501, 7502, 7525, 7524
8802, 7502, 7503, 7526, 7525
8803, 7503, 7504, 7527, 7526
8804, 7504, 7505, 7528, 7527
8805, 7505, 7506, 7529, 7528
8806, 7506, 7507, 7530, 7529
8807, 7507, 7508, 7531, 7530
8808, 7508, 7509, 7532, 7531
8809, 7509, 7510, 7533, 7532
8810, 7510, 7511, 7534, 7533
8811, 7511, 7512, 7535, 7534
8812, 7512, 7513, 7536, 7535
8813, 7513, 7514, 7537, 7536
8814, 7514, 7515, 7538, 7537
8815, 7515, 7516, 7539, 7538
8816, 7516, 985, 986, 7539
8817, 826, 7517, 7540, 827
8818, 7517, 7518, 7541, 7540
8819, 7518, 7519, 7542, 7541
8820, 7519, 7520, 7543, 7542
8821, 7520, 7521, 7544, 7543
8822, 7521, 7522, 7545, 7544
8823, 7522, 7523, 7546, 7545
8824, 7523, 7524, 7547, 7546
8825, 7524, 7525, 7548, 7547
8826, 7525, 7526, 7549, 7548
8827, 7526, 7527, 7550, 7549
8828, 7527, 7528, 7551, 7550
8829, 7528, 7529, 7552, 7551
8830, 7529, 7530, 7553, 7552
8831, 7530, 7531, 7554, 7553
8832, 7531, 7532, 7555, 7554
8833, 7532, 7533, 7556, 7555
8834, 7533, 7534, 7557, 7556
8835, 7534, 7535, 7558, 7557
8836, 7535, 7536, 7559, 7558
8837, 7536, 7537, 7560, 7559
8838, 7537, 7538, 7561, 7560
8839, 7538, 7539, 7562, 7561
8840, 7539, 986, 987, 7562
8841, 827, 7540, 7563, 828
8842, 7540, 7541, 7564, 7563
8843, 7541, 7542, 7565, 7564
8844, 7542, 7543, 7566, 7565
8845, 7543, 7544, 7567, 7566
8846, 7544, 7545, 7568, 7567
8847, 7545, 7546, 7569, 7568
8848, 7546, 7547, 7570, 7569
8849, 7547, 7548, 7571, 7570
8850, 7548, 7549, 7572, 7571
8851, 7549, 7550, 7573, 7572
8852, 7550, 7551, 7574, 7573
8853, 7551, 7552, 7575, 7574
8854, 7552, 7553, 7576, 7575
8855, 7553, 7554, 7577, 7576
8856, 7554, 7555, 7578, 7577
8857, 7555, 7556, 7579, 7578
8858, 7556, 7557, 7580, 7579
8859, 7557, 7558, 7581, 7580
8860, 7558, 7559, 7582, 7581
8861, 7559, 7560, 7583, 7582
8862, 7560, 7561, 7584, 7583
8863, 7561, 7562, 7585, 7584
8864, 7562, 987, 988, 7585
8865, 828, 7563, 7586, 829
8866, 7563, 7564, 7587, 7586
8867, 7564, 7565, 7588, 7587
8868, 7565, 7566, 7589, 7588
8869, 7566, 7567, 7590, 7589
8870, 7567, 7568, 7591, 7590
8871, 7568, 7569, 7592, 7591
8872, 7569, 7570, 7593, 7592
8873, 7570, 7571, 7594, 7593
8874, 7571, 7572, 7595, 7594
8875, 7572, 7573, 7596, 7595
8876, 7573, 7574, 7597, 7596
8877, 7574, 7575, 7598, 7597
8878, 7575, 7576, 7599, 7598
8879, 7576, 7577, 7600, 7599
8880, 7577, 7578, 7601, 7600
8881, 7578, 7579, 7602, 7601
8882, 7579, 7580, 7603, 7602
8883, 7580, 7581, 7604, 7603
8884, 7581, 7582, 7605, 7604
8885, 7582, 7583, 7606, 7605
8886, 7583, 7584, 7607, 7606
8887, 7584, 7585, 7608, 7607
8888, 7585, 988, 989, 7608
8889, 829, 7586, 841, 33
8890, 7586, 7587, 842, 841
8891, 7587, 7588, 843, 842
8892, 7588, 7589, 844, 843
8893, 7589, 7590, 845, 844
8894, 7590, 7591, 846, 845
8895, 7591, 7592, 847, 846
8896, 7592, 7593, 848, 847
8897, 7593, 7594, 849, 848
8898, 7594, 7595, 850, 849
8899, 7595, 7596, 851, 850
8900, 7596, 7597, 852, 851
8901, 7597, 7598, 853, 852
8902, 7598, 7599, 854, 853
8903, 7599, 7600, 855, 854
8904, 7600, 7601, 856, 855
8905, 7601, 7602, 857, 856
8906, 7602, 7603, 858, 857
8907, 7603, 7604, 859, 858
8908, 7604, 7605, 860, 859
8909, 7605, 7606, 861, 860
8910, 7606, 7607, 862, 861
8911, 7607, 7608, 863, 862
8912, 7608, 989, 37, 863
*ELEMENT, type=CPS4, ELSET=Surface45
8913, 36, 830, 7609, 933
8914, 933, 7609, 7610, 934
8915, 934, 7610, 7611, 935
8916, 935, 7611, 7612, 936
8917, 936, 7612, 7613, 937
8918, 937, 7613, 7614, 938
8919, 938, 7614, 7615, 939
8920, 939, 7615, 7616, 940
8921, 940, 7616, 7617, 941
8922, 941, 7617, 7618, 942
8923, 942, 7618, 7619, 943
8924, 943, 7619, 7620, 944
8925, 944, 7620, 7621, 945
8926, 945, 7621, 7622, 946
8927, 946, 7622, 7623, 947
8928, 947, 7623, 7624, 948
8929, 948, 7624, 7625, 949
8930, 949, 7625, 7626, 950
8931, 950, 7626, 7627, 951
8932, 951, 7627, 7628, 952
8933, 952, 7628, 7629, 953
8934, 953, 7629, 7630, 954
8935, 954, 7630, 7631, 955
8936, 955, 7631, 990, 40
8937, 830, 831, 7632, 7609
8938, 7609, 7632, 7633, 7610
8939, 7610, 7633, 7634, 7611
8940, 7611, 7634, 7635, 7612
8941, 7612, 7635, 7636, 7613
8942, 7613, 7636, 7637, 7614
8943, 7614, 7637, 7638, 7615
8944, 7615, 7638, 7639, 7616
8945, 7616, 7639, 7640, 7617
8946, 7617, 7640, 7641, 7618
8947, 7618, 7641, 7642, 7619
8948, 7619, 7642, 7643, 7620
8949, 7620, 7643, 7644, 7621
8950, 7621, 7644, 7645, 7622
8951, 7622, 7645, 7646, 7623
8952, 7623, 7646, 7647, 7624
8953, 7624, 7647, 7648, 7625
8954, 7625, 7648, 7649, 7626
8955, 7626, 7649, 7650, 7627
8956, 7627, 7650, 7651, 7628
8957, 7628, 7651, 7652, 7629
8958, 7629, 7652, 7653, 7630
8959, 7630, 7653, 7654, 7631
8960, 7631, 7654, 991, 990
8961, 831, 832, 7655, 7632
8962, 7632, 7655, 7656, 7633
8963, 7633, 7656, 7657, 7634
8964, 7634, 7657, 7658, 7635
8965, 7635, 7658, 7659, 7636
8966, 7636, 7659, 7660, 7637
8967, 7637, 7660, 7661, 7638
8968, 7638, 7661, 7662, 7639
8969, 7639, 7662, 7663, 7640
8970, 7640, 7663, 7664, 7641
8971, 7641, 7664, 7665, 7642
8972, 7642, 7665, 7666, 7643
8973, 7643, 7666, 7667, 7644
8974, 7644, 7667, 7668, 7645
8975, 7645, 7668, 7669, 7646
8976, 7646, 7669, 7670, 7647
8977, 7647, 7670, 7671, 7648
8978, 7648, 7671, 7672, 7649
8979, 7649, 7672, 7673, 7650
8980, 7650, 7673, 7674, 7651
8981, 7651, 7674, 7675, 7652
8982, 7652, 7675, 7676, 7653
8983, 7653, 7676, 7677, 7654
8984, 7654, 7677, 992, 991
8985, 832, 833, 7678, 7655
8986, 7655, 7678, 7679, 7656
8987, 7656, 7679, 7680, 7657
8988, 7657, 7680, 7681, 7658
8989, 7658, 7681, 7682, 7659
8990, 7659, 7682, 7683, 7660
8991, 7660, 7683, 7684, 7661
8992, 7661, 7684, 7685, 7662
8993, 7662, 7685, 7686, 7663
8994, 7663, 7686, 7687, 7664
8995, 7664, 7687, 7688, 7665
8996, 7665, 7688, 7689, 7666
8997, 7666, 7689, 7690, 7667
8998, 7667, 7690, 7691, 7668
8999, 7668, 7691, 7692, 7669
9000, 7669, 7692, 7693, 7670
9001, 7670, 7693, 7694, 7671
9002, 7671, 7694, 7695, 7672
9003, 7672, 7695, 7696, 7673
9004, 7673, 7696, 7697, 7674
9005, 7674, 7697, 7698, 7675
9006, 7675, 7698, 7699, 7676
9007, 7676, 7699, 7700, 7677
9008, 7677, 7700, 993, 992
9009, 833, 834, 7701, 7678
9010, 7678, 7701, 7702, 7679
9011, 7679, 7702, 7703, 7680
9012, 7680, 7703, 7704, 7681
9013, 7681, 7704, 7705, 7682
9014, 7682, 7705, 7706, 7683
9015, 7683, 7706, 7707, 7684
9016, 7684, 7707, 7708, 7685
9017, 7685, 7708, 7709, 7686
9018, 7686, 7709, 7710, 7687
9019, 7687, 7710, 7711, 7688
9020, 7688, 7711, 7712, 7689
9021, 7689, 7712, 7713, 7690
9022, 7690, 7713, 7714, 7691
9023, 7691, 7714, 7715, 7692
9024, 7692, 7715, 7716, 7693
9025, 7693, 7716, 7717, 7694
9026, 7694, 7717, 7718, 7695
9027, 7695, 7718, 7719, 7696
9028, 7696, 7719, 7720, 7697
9029, 7697, 7720, 7721, 7698
9030, 7698, 7721, 7722, 7699
9031, 7699, 7722, 7723, 7700
9032, 7700, 7723, 994, 993
9033, 834, 835, 7724, 7701
9034, 7701, 7724, 7725, 7702
9035, 7702, 7725, 7726, 7703
9036, 7703, 7726, 7727, 7704
9037, 7704, 7727, 7728, 7705
9038, 7705, 7728, 7729, 7706
9039, 7706, 7729, 7730, 7707
9040, 7707, 7730, 7731, 7708
9041, 7708, 7731, 7732, 7709
9042, 7709, 7732, 7733, 7710
9043, 7710, 7733, 7734, 7711
9044, 7711, 7734, 7735, 7712
9045, 7712, 7735, 7736, 7713
9046, 7713, 7736, 7737, 7714
9047, 7714, 7737, 7738, 7715
9048, 7715, 7738, 7739, 7716
9049, 7716, 7739, 7740, 7717
9050, 7717, 7740, 7741, 7718
9051, 7718, 7741, 7742, 7719
9052, 7719, 7742, 7743, 7720
9053, 7720, 7743, 7744, 7721
9054, 7721, 7744, 7745, 7722
9055, 7722, 7745, 7746, 7723
9056, 7723, 7746, 995, 994
9057, 835, 836, 7747, 7724
9058, 7724, 7747, 7748, 7725
9059, 7725, 7748, 7749, 7726
9060, 7726, 7749, 7750, 7727
9061, 7727, 7750, 7751, 7728
9062, 7728, 7751, 7752, 7729
9063, 7729, 7752, 7753, 7730
9064, 7730, 7753, 7754, 7731
9065, 7731, 7754, 7755, 7732
9066, 7732, 7755, 7756, 7733
9067, 7733, 7756, 7757, 7734
9068, 7734, 7757, 7758, 7735
9069, 7735, 7758, 7759, 7736
9070, 7736, 7759, 7760, 7737
9071, 7737, 7760, 7761, 7738
9072, 7738, 7761, 7762, 7739
9073, 7739, 7762, 7763, 7740
9074, 7740, 7763, 7764, 7741
9075, 7741, 7764, 7765, 7742
9076, 7742, 7765, 7766, 7743
9077, 7743, 7766, 7767, 7744
9078, 7744, 7767, 7768, 7745
9079, 7745, 7768, 7769, 7746
9080, 7746, 7769, 996, 995
9081, 836, 837, 7770, 7747
9082, 7747, 7770, 7771, 7748
9083, 7748, 7771, 7772, 7749
9084, 7749, 7772, 7773, 7750
9085, 7750, 7773, 7774, 7751
9086, 7751, 7774, 7775, 7752
9087, 7752, 7775, 7776, 7753
9088, 7753, 7776, 7777, 7754
9089, 7754, 7777, 7778, 7755
9090, 7755, 7778, 7779, 7756
9091, 7756, 7779, 7780, 7757
9092, 7757, 7780, 7781, 7758
9093, 7758, 7781, 7782, 7759
9094, 7759, 7782, 7783, 7760
9095, 7760, 7783, 7784, 7761
9096, 7761, 7784, 7785, 7762
9097, 7762, 7785, 7786, 7763
9098, 7763, 7786, 7787, 7764
9099, 7764, 7787, 7788, 7765
9100, 7765, 7788, 7789, 7766
9101, 7766, 7789, 7790, 7767
9102, 7767, 7790, 7791, 7768
9103, 7768, 7791, 7792, 7769
9104, 7769, 7792, 997, 996
9105, 837, 838, 7793, 7770
9106, 7770, 7793, 7794, 7771
9107, 7771, 7794, 7795, 7772
9108, 7772, 7795, 7796, 7773
9109, 7773, 7796, 7797, 7774
9110, 7774, 7797, 7798, 7775
9111, 7775, 7798, 7799, 7776
9112, 7776, 7799, 7800, 7777
9113, 7777, 7800, 7801, 7778
9114, 7778, 7801, 7802, 7779
9115, 7779, 7802, 7803, 7780
9116, 7780, 7803, 7804, 7781
9117, 7781, 7804, 7805, 7782
9118, 7782, 7805, 7806, 7783
9119, 7783, 7806, 7807, 7784
9120, 7784, 7807, 7808, 7785
9121, 7785, 7808, 7809, 7786
9122, 7786, 7809, 7810, 7787
9123, 7787, 7810, 7811, 7788
9124, 7788, 7811, 7812, 7789
9125, 7789, 7812, 7813, 7790
9126, 7790, 7813, 7814, 7791
9127, 7791, 7814, 7815, 7792
9128, 7792, 7815, 998, 997
9129, 838, 839, 7816, 7793
9130, 7793, 7816, 7817, 7794
9131, 7794, 7817, 7818, 7795
9132, 7795, 7818, 7819, 7796
9133, 7796, 7819, 7820, 7797
9134, 7797, 7820, 7821, 7798
9135, 7798, 7821, 7822, 7799
9136, 7799, 7822, 7823, 7800
9137, 7800, 7823, 7824, 7801
9138, 7801, 7824, 7825, 7802
9139, 7802, 7825, 7826, 7803
9140, 7803, 7826, 7827, 7804
9141, 7804, 7827, 7828, 7805
9142, 7805, 7828, 7829, 7806
9143, 7806, 7829, 7830, 7807
9144, 7807, 7830, 7831, 7808
9145, 7808, 7831, 7832, 7809
9146, 7809, 7832, 7833, 7810
9147, 7810, 7833, 7834, 7811
9148, 7811, 7834, 7835, 7812
9149, 7812, 7835, 7836, 7813
9150, 7813, 7836, 7837, 7814
9151, 7814, 7837, 7838, 7815
9152, 7815, 7838, 999, 998
9153, 839, 840, 7839, 7816
9154, 7816, 7839, 7840, 7817
9155, 7817, 7840, 7841, 7818
9156, 7818, 7841, 7842, 7819
9157, 7819, 7842, 7843, 7820
9158, 7820, 7843, 7844, 7821
9159, 7821, 7844, 7845, 7822
9160, 7822, 7845, 7846, 7823
9161, 7823, 7846, 7847, 7824
9162, 7824, 7847, 7848, 7825
9163, 7825, 7848, 7849, 7826
9164, 7826, 7849, 7850, 7827
9165, 7827, 7850, 7851, 7828
9166, 7828, 7851, 7852, 7829
9167, 7829, 7852, 7853, 7830
9168, 7830, 7853, 7854, 7831
9169, 7831, 7854, 7855, 7832
9170, 7832, 7855, 7856, 7833
9171, 7833, 7856, 7857, 7834
9172, 7834, 7857, 7858, 7835
9173, 7835, 7858, 7859, 7836
9174, 7836, 7859, 7860, 7837
9175, 7837, 7860, 7861, 7838
9176, 7838, 7861, 1000, 999
9177, 840, 34, 864, 7839
9178, 7839, 864, 865, 7840
9179, 7840, 865, 866, 7841
9180, 7841, 866, 867, 7842
9181, 7842, 867, 868, 7843
9182, 7843, 868, 869, 7844
9183, 7844, 869, 870, 7845
9184, 7845, 870, 871, 7846
9185, 7846, 871, 872, 7847
9186, 7847, 872, 873, 7848
9187, 7848, 873, 874, 7849
9188, 7849, 874, 875, 7850
9189, 7850, 875, 876, 7851
9190, 7851, 876, 877, 7852
9191, 7852, 877, 878, 7853
9192, 7853, 878, 879, 7854
9193, 7854, 879, 880, 7855
9194, 7855, 880, 881, 7856
9195, 7856, 881, 882, 7857
9196, 7857, 882, 883, 7858
9197, 7858, 883, 884, 7859
9198, 7859, 884, 885, 7860
9199, 7860, 885, 886, 7861
9200, 7861, 886, 38, 1000
*ELEMENT, type=CPS4, ELSET=Surface46
9201, 39, 956, 7862, 979
9202, 956, 957, 7863, 7862
9203, 957, 958, 7864, 7863
9204, 958, 959, 7865, 7864
9205, 959, 960, 7866, 7865
9206, 960, 961, 7867, 7866
9207, 961, 962, 7868, 7867
9208, 962, 963, 7869, 7868
9209, 963, 964, 7870, 7869
9210, 964, 965, 7871, 7870
9211, 965, 966, 7872, 7871
9212, 966, 967, 7873, 7872
9213, 967, 968, 7874, 7873
9214, 968, 969, 7875, 7874
9215, 969, 970, 7876, 7875
9216, 970, 971, 7877, 7876
9217, 971, 972, 7878, 7877
9218, 972, 973, 7879, 7878
9219, 973, 974, 7880, 7879
9220, 974, 975, 7881, 7880
9221, 975, 976, 7882, 7881
9222, 976, 977, 7883, 7882
9223, 977, 978, 7884, 7883
9224, 978, 40, 990, 7884
9225, 979, 7862, 7885, 980
9226, 7862, 7863, 7886, 7885
9227, 7863, 7864, 7887, 7886
9228, 7864, 7865, 7888, 7887
9229, 7865, 7866, 7889, 7888
9230, 7866, 7867, 7890, 7889
9231, 7867, 7868, 7891, 7890
9232, 7868, 7869, 7892, 7891
9233, 7869, 7870, 7893, 7892
9234, 7870, 7871, 7894, 7893
9235, 7871, 7872, 7895, 7894
9236, 7872, 7873, 7896, 7895
9237, 7873, 7874, 7897, 7896
9238, 7874, 7875, 7898, 7897
9239, 7875, 7876, 7899, 7898
9240, 7876, 7877, 7900, 7899
9241, 7877, 7878, 7901, 7900
9242, 7878, 7879, 7902, 7901
9243, 7879, 7880, 7903, 7902
9244, 7880, 7881, 7904, 7903
9245, 7881, 7882, 7905, 7904
9246, 7882, 7883, 7906, 7905
9247, 7883, 7884, 7907, 7906
9248, 7884, 990, 991, 7907
9249, 980, 7885, 7908, 981
9250, 7885, 7886, 7909, 7908
9251, 7886, 7887, 7910, 7909
9252, 7887, 7888, 7911, 7910
9253, 7888, 7889, 7912, 7911
9254, 7889, 7890, 7913, 7912
9255, 7890, 7891, 7914, 7913
9256, 7891, 7892, 7915, 7914
9257, 7892, 7893, 7916, 7915
9258, 7893, 7894, 7917, 7916
9259, 7894, 7895, 7918, 7917
9260, 7895, 7896, 7919, 7918
9261, 7896, 7897, 7920, 7919
9262, 7897, 7898, 7921, 7920
9263, 7898, 7899, 7922, 7921
9264, 7899, 7900, 7923, 7922
9265, 7900, 7901, 7924, 7923
9266, 7901, 7902, 7925, 7924
9267, 7902, 7903, 7926, 7925
9268, 7903, 7904, 7927, 7926
9269, 7904, 7905, 7928, 7927
9270, 7905, 7906, 7929, 7928
9271, 7906, 7907, 7930, 7929
9272, 7907, 991, 992, 7930
9273, 981, 7908, 7931, 982
9274, 7908, 7909, 7932, 7931
9275, 7909, 7910, 7933, 7932
9276, 7910, 7911, 7934, 7933
9277, 7911, 7912, 7935, 7934
9278, 7912, 7913, 7936, 7935
9279, 7913, 7914, 7937, 7936
9280, 7914, 7915, 7938, 7937
9281, 7915, 7916, 7939, 7938
9282, 7916, 7917, 7940, 7939
9283, 7917, 7918, 7941, 7940
9284, 7918, 7919, 7942, 7941
9285, 7919, 7920, 7943, 7942
9286, 7920, 7921, 7944, 7943
9287, 7921, 7922, 7945, 7944
9288, 7922, 7923, 7946, 7945
9289, 7923, 7924, 7947, 7946
9290, 7924, 7925, 7948, 7947
9291, 7925, 7926, 7949, 7948
9292, 7926, 7927, 7950, 7949
9293, 7927, 7928, 7951, 7950
9294, 7928, 7929, 7952, 7951
9295, 7929, 7930, 7953, 7952
9296, 7930, 992, 993, 7953
9297, 982, 7931, 7954, 983
9298, 7931, 7932, 7955, 7954
9299, 7932, 7933, 7956, 7955
9300, 7933, 7934, 7957, 7956
9301, 7934, 7935, 7958, 7957
9302, 7935, 7936, 7959, 7958
9303, 7936, 7937, 7960, 7959
9304, 7937, 7938, 7961, 7960
9305, 7938, 7939, 7962, 7961
9306, 7939, 7940, 7963, 7962
9307, 7940, 7941, 7964, 7963
9308, 7941, 7942, 7965, 7964
9309, 7942, 7943, 7966, 7965
9310, 7943, 7944, 7967, 7966
9311, 7944, 7945, 7968, 7967
9312, 7945, 7946, 7969, 7968
9313, 7946, 7947, 7970, 7969
9314, 7947, 7948, 7971, 7970
9315, 7948, 7949, 7972, 7971
9316, 7949, 7950, 7973, 7972
9317, 7950, 7951, 7974, 7973
9318, 7951, 7952, 7975, 7974
9319, 7952, 7953, 7976, 7975
9320, 7953, 993, 994, 7976
9321, 983, 7954, 7977, 984
9322, 7954, 7955, 7978, 7977
9323, 7955, 7956, 7979, 7978
9324, 7956, 7957, 7980, 7979
9325, 7957, 7958, 7981, 7980
9326, 7958, 7959, 7982, 7981
9327, 7959, 7960, 7983, 7982
9328, 7960, 7961, 7984, 7983
9329, 7961, 7962, 7985, 7984
9330, 7962, 7963, 7986, 7985
9331, 7963, 7964, 7987, 7986
9332, 7964, 7965, 7988, 7987
9333, 7965, 7966, 7989, 7988
9334, 7966, 7967, 7990, 7989
9335, 7967, 7968, 7991, 7990
9336, 7968, 7969, 7992, 7991
9337, 7969, 7970, 7993, 7992
9338, 7970, 7971, 7994, 7993
9339, 7971, 7972, 7995, 7994
9340, 7972, 7973, 7996, 7995
9341, 7973, 7974, 7997, 7996
9342, 7974, 7975, 7998, 7997
9343, 7975, 7976, 7999, 7998
9344, 7976, 994, 995, 7999
9345, 984, 7977, 8000, 985
9346, 7977, 7978, 8001, 8000
9347, 7978, 7979, 8002, 8001
9348, 7979, 7980, 8003, 8002
9349, 7980, 7981, 8004, 8003
9350, 7981, 7982, 8005, 8004
9351, 7982, 7983, 8006, 8005
9352, 7983, 7984, 8007, 8006
9353, 7984, 7985, 8008, 8007
9354, 7985, 7986, 8009, 8008
9355, 7986, 7987, 8010, 8009
9356, 7987, 7988, 8011, 8010
9357, 7988, 7989, 8012, 8011
9358, 7989, 7990, 8013, 8012
9359, 7990, 7991, 8014, 8013
9360, 7991, 7992, 8015, 8014
9361, 7992, 7993, 8016, 8015
9362, 7993, 7994, 8017, 8016
9363, 7994, 7995, 8018, 8017
9364, 7995, 7996, 8019, 8018
9365, 7996, 7997, 8020, 8019
9366, 7997, 7998, 8021, 8020
9367, 7998, 7999, 8022, 8021
9368, 7999, 995, 996, 8022
9369, 985, 8000, 8023, 986
9370, 8000, 8001, 8024, 8023
9371, 8001, 8002, 8025, 8024
9372, 8002, 8003, 8026, 8025
9373, 8003, 8004, 8027, 8026
9374, 8004, 8005, 8028, 8027
9375, 8005, 8006, 8029, 8028
9376, 8006, 8007, 8030, 8029
9377, 8007, 8008, 8031, 8030
9378, 8008, 8009, 8032, 8031
9379, 8009, 8010, 8033, 8032
9380, 8010, 8011, 8034, 8033
9381, 8011, 8012, 8035, 8034
9382, 8012, 8013, 8036, 8035
9383, 8013, 8014, 8037, 8036
9384, 8014, 8015, 8038, 8037
9385, 8015, 8016, 8039, 8038
9386, 8016, 8017, 8040, 8039
9387, 8017, 8018, 8041, 8040
9388, 8018, 8019, 8042, 8041
9389, 8019, 8020, 8043, 8042
9390, 8020, 8021, 8044, 8043
9391, 8021, 8022, 8045, 8044
9392, 8022, 996, 997, 8045
9393, 986, 8023, 8046, 987
9394, 8023, 8024, 8047, 8046
9395, 8024, 8025, 8048, 8047
9396, 8025, 8026, 8049, 8048
9397, 8026, 8027, 8050, 8049
9398, 8027, 8028, 8051, 8050
9399, 8028, 8029, 8052, 8051
9400, 8029, 8030, 8053, 8052
9401, 8030, 8031, 8054, 8053
9402, 8031, 8032, 8055, 8054
9403, 8032, 8033, 8056, 8055
9404, 8033, 8034, 8057, 8056
9405, 8034, 8035, 8058, 8057
9406, 8035, 8036, 8059, 8058
9407, 8036, 8037, 8060, 8059
9408, 8037, 8038, 8061, 8060
9409, 8038, 8039, 8062, 8061
9410, 8039, 8040, 8063, 8062
9411, 8040, 8041, 8064, 8063
9412, 8041, 8042, 8065, 8064
9413, 8042, 8043, 8066, 8065
9414, 8043, 8044, 8067, 8066
9415, 8044, 8045, 8068, 8067
9416, 8045, 997, 998, 8068
9417, 987, 8046, 8069, 988
9418, 8046, 8047, 8070, 8069
9419, 8047, 8048, 8071, 8070
9420, 8048, 8049, 8072, 8071
9421, 8049, 8050, 8073, 8072
9422, 8050, 8051, 8074, 8073
9423, 8051, 8052, 8075, 8074
9424, 8052, 8053, 8076, 8075
9425, 8053, 8054, 8077, 8076
9426, 8054, 8055, 8078, 8077
9427, 8055, 8056, 8079, 8078
9428, 8056, 8057, 8080, 8079
9429, 8057, 8058, 8081, 8080
9430, 8058, 8059, 8082, 8081
9431, 8059, 8060, 8083, 8082
9432, 8060, 8061, 8084, 8083
9433, 8061, 8062, 8085, 8084
9434, 8062, 8063, 8086, 8085
9435, 8063, 8064, 8087, 8086
9436, 8064, 8065, 8088, 8087
9437, 8065, 8066, 8089, 8088
9438, 8066, 8067, 8090, 8089
9439, 8067, 8068, 8091, 8090
9440, 8068, 998, 999, 8091
9441, 988, 8069, 8092, 989
9442, 8069, 8070, 8093, 8092
9443, 8070, 8071, 8094, 8093
9444, 8071, 8072, 8095, 8094
9445, 8072, 8073, 8096, 8095
9446, 8073, 8074, 8097, 8096
9447, 8074, 8075, 8098, 8097
9448, 8075, 8076, 8099, 8098
9449, 8076, 8077, 8100, 8099
9450, 8077, 8078, 8101, 8100
9451, 8078, 8079, 8102, 8101
9452, 8079, 8080, 8103, 8102
9453, 8080, 8081, 8104, 8103
9454, 8081, 8082, 8105, 8104
9455, 8082, 8083, 8106, 8105
9456, 8083, 8084, 8107, 8106
9457, 8084, 8085, 8108, 8107
9458, 8085, 8086, 8109, 8108
9459, 8086, 8087, 8110, 8109
9460, 8087, 8088, 8111, 8110
9461, 8088, 8089, 8112, 8111
9462, 8089, 8090, 8113, 8112
9463, 8090, 8091, 8114, 8113
9464, 8091, 999, 1000, 8114
9465, 989, 8092, 887, 37
9466, 8092, 8093, 888, 887
9467, 8093, 8094, 889, 888
9468, 8094, 8095, 890, 889
9469, 8095, 8096, 891, 890
9470, 8096, 8097, 892, 891
9471, 8097, 8098, 893, 892
9472, 8098, 8099, 894, 893
9473, 8099, 8100, 895, 894
9474, 8100, 8101, 896, 895
9475, 8101, 8102, 897, 896
9476, 8102, 8103, 898, 897
9477, 8103, 8104, 899, 898
9478, 8104, 8105, 900, 899
9479, 8105, 8106, 901, 900
9480, 8106, 8107, 902, 901
9481, 8107, 8108, 903, 902
9482, 8108, 8109, 904, 903
9483, 8109, 8110, 905, 904
9484, 8110, 8111, 906, 905
9485, 8111, 8112, 907, 906
9486, 8112, 8113, 908, 907
9487, 8113, 8114, 909, 908
9488, 8114, 1000, 38, 909
*ELEMENT, type=CPS4, ELSET=Surface47
9489, 37, 41, 1001, 887
9490, 887, 1001, 1002, 888
9491, 888, 1002, 1003, 889
9492, 889, 1003, 1004, 890
9493, 890, 1004, 1005, 891
9494, 891, 1005, 1006, 892
9495, 892, 1006, 1007, 893
9496, 893, 1007, 1008, 894
9497, 894, 1008, 1009, 895
9498, 895, 1009, 1010, 896
9499, 896, 1010, 1011, 897
9500, 897, 1011, 1012, 898
9501, 898, 1012, 1013, 899
9502, 899, 1013, 1014, 900
9503, 900, 1014, 1015, 901
9504, 901, 1015, 1016, 902
9505, 902, 1016, 1017, 903
9506, 903, 1017, 1018, 904
9507, 904, 1018, 1019, 905
9508, 905, 1019, 1020, 906
9509, 906, 1020, 1021, 907
9510, 907, 1021, 1022, 908
9511, 908, 1022, 1023, 909
9512, 909, 1023, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
9513, 39, 956, 1024, 43
9514, 956, 957, 1025, 1024
9515, 957, 958, 1026, 1025
9516, 958, 959, 1027, 1026
9517, 959, 960, 1028, 1027
9518, 960, 961, 1029, 1028
9519, 961, 962, 1030, 1029
9520, 962, 963, 1031, 1030
9521, 963, 964, 1032, 1031
9522, 964, 965, 1033, 1032
9523, 965, 966, 1034, 1033
9524, 966, 967, 1035, 1034
9525, 967, 968, 1036, 1035
9526, 968, 969, 1037, 1036
9527, 969, 970, 1038, 1037
9528, 970, 971, 1039, 1038
9529, 971, 972, 1040, 1039
9530, 972, 973, 1041, 1040
9531, 973, 974, 1042, 1041
9532, 974, 975, 1043, 1042
9533, 975, 976, 1044, 1043
9534, 976, 977, 1045, 1044
9535, 977, 978, 1046, 1045
9536, 978, 40, 44, 1046
*ELEMENT, type=CPS4, ELSET=Surface49
9537, 39, 43, 1047, 979
9538, 979, 1047, 1048, 980
9539, 980, 1048, 1049, 981
9540, 981, 1049, 1050, 982
9541, 982, 1050, 1051, 983
9542, 983, 1051, 1052, 984
9543, 984, 1052, 1053, 985
9544, 985, 1053, 1054, 986
9545, 986, 1054, 1055, 987
9546, 987, 1055, 1056, 988
9547, 988, 1056, 1057, 989
9548, 989, 1057, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
9549, 40, 990, 1058, 44
9550, 990, 991, 1059, 1058
9551, 991, 992, 1060, 1059
9552, 992, 993, 1061, 1060
9553, 993, 994, 1062, 1061
9554, 994, 995, 1063, 1062
9555, 995, 996, 1064, 1063
9556, 996, 997, 1065, 1064
9557, 997, 998, 1066, 1065
9558, 998, 999, 1067, 1066
9559, 999, 1000, 1068, 1067
9560, 1000, 38, 42, 1068
*ELEMENT, type=CPS4, ELSET=Surface51
9561, 43, 1024, 8115, 1047
9562, 1024, 1025, 8116, 8115
9563, 1025, 1026, 8117, 8116
9564, 1026, 1027, 8118, 8117
9565, 1027, 1028, 8119, 8118
9566, 1028, 1029, 8120, 8119
9567, 1029, 1030, 8121, 8120
9568, 1030, 1031, 8122, 8121
9569, 1031, 1032, 8123, 8122
9570, 1032, 1033, 8124, 8123
9571, 1033, 1034, 8125, 8124
9572, 1034, 1035, 8126, 8125
9573, 1035, 1036, 8127, 8126
9574, 1036, 1037, 8128, 8127
9575, 1037, 1038, 8129, 8128
9576, 1038, 1039, 8130, 8129
9577, 1039, 1040, 8131, 8130
9578, 1040, 1041, 8132, 8131
9579, 1041, 1042, 8133, 8132
9580, 1042, 1043, 8134, 8133
9581, 1043, 1044, 8135, 8134
9582, 1044, 1045, 8136, 8135
9583, 1045, 1046, 8137, 8136
9584, 1046, 44, 1058, 8137
9585, 1047, 8115, 8138, 1048
9586, 8115, 8116, 8139, 8138
9587, 8116, 8117, 8140, 8139
9588, 8117, 8118, 8141, 8140
9589, 8118, 8119, 8142, 8141
9590, 8119, 8120, 8143, 8142
9591, 8120, 8121, 8144, 8143
9592, 8121, 8122, 8145, 8144
9593, 8122, 8123, 8146, 8145
9594, 8123, 8124, 8147, 8146
9595, 8124, 8125, 8148, 8147
9596, 8125, 8126, 8149, 8148
9597, 8126, 8127, 8150, 8149
9598, 8127, 8128, 8151, 8150
9599, 8128, 8129, 8152, 8151
9600, 8129, 8130, 8153, 8152
9601, 8130, 8131, 8154, 8153
9602, 8131, 8132, 8155, 8154
9603, 8132, 8133, 8156, 8155
9604, 8133, 8134, 8157, 8156
9605, 8134, 8135, 8158, 8157
9606, 8135, 8136, 8159, 8158
9607, 8136, 8137, 8160, 8159
9608, 8137, 1058, 1059, 8160
9609, 1048, 8138, 8161, 1049
9610, 8138, 8139, 8162, 8161
9611, 8139, 8140, 8163, 8162
9612, 8140, 8141, 8164, 8163
9613, 8141, 8142, 8165, 8164
9614, 8142, 8143, 8166, 8165
9615, 8143, 8144, 8167, 8166
9616, 8144, 8145, 8168, 8167
9617, 8145, 8146, 8169, 8168
9618, 8146, 8147, 8170, 8169
9619, 8147, 8148, 8171, 8170
9620, 8148, 8149, 8172, 8171
9621, 8149, 8150, 8173, 8172
9622, 8150, 8151, 8174, 8173
9623, 8151, 8152, 8175, 8174
9624, 8152, 8153, 8176, 8175
9625, 8153, 8154, 8177, 8176
9626, 8154, 8155, 8178, 8177
9627, 8155, 8156, 8179, 8178
9628, 8156, 8157, 8180, 8179
9629, 8157, 8158, 8181, 8180
9630, 8158, 8159, 8182, 8181
9631, 8159, 8160, 8183, 8182
9632, 8160, 1059, 1060, 8183
9633, 1049, 8161, 8184, 1050
9634, 8161, 8162, 8185, 8184
9635, 8162, 8163, 8186, 8185
9636, 8163, 8164, 8187, 8186
9637, 8164, 8165, 8188, 8187
9638, 8165, 8166, 8189, 8188
9639, 8166, 8167, 8190, 8189
9640, 8167, 8168, 8191, 8190
9641, 8168, 8169, 8192, 8191
9642, 8169, 8170, 8193, 8192
9643, 8170, 8171, 8194, 8193
9644, 8171, 8172, 8195, 8194
9645, 8172, 8173, 8196, 8195
9646, 8173, 8174, 8197, 8196
9647, 8174, 8175, 8198, 8197
9648, 8175, 8176, 8199, 8198
9649, 8176, 8177, 8200, 8199
9650, 8177, 8178, 8201, 8200
9651, 8178, 8179, 8202, 8201
9652, 8179, 8180, 8203, 8202
9653, 8180, 8181, 8204, 8203
9654, 8181, 8182, 8205, 8204
9655, 8182, 8183, 8206, 8205
9656, 8183, 1060, 1061, 8206
9657, 1050, 8184, 8207, 1051
9658, 8184, 8185, 8208, 8207
9659, 8185, 8186, 8209, 8208
9660, 8186, 8187, 8210, 8209
9661, 8187, 8188, 8211, 8210
9662, 8188, 8189, 8212, 8211
9663, 8189, 8190, 8213, 8212
9664, 8190, 8191, 8214, 8213
9665, 8191, 8192, 8215, 8214
9666, 8192, 8193, 8216, 8215
9667, 8193, 8194, 8217, 8216
9668, 8194, 8195, 8218, 8217
9669, 8195, 8196, 8219, 8218
9670, 8196, 8197, 8220, 8219
9671, 8197, 8198, 8221, 8220
9672, 8198, 8199, 8222, 8221
9673, 8199, 8200, 8223, 8222
9674, 8200, 8201, 8224, 8223
9675, 8201, 8202, 8225, 8224
9676, 8202, 8203, 8226, 8225
9677, 8203, 8204, 8227, 8226
9678, 8204, 8205, 8228, 8227
9679, 8205, 8206, 8229, 8228
9680, 8206, 1061, 1062, 8229
9681, 1051, 8207, 8230, 1052
9682, 8207, 8208, 8231, 8230
9683, 8208, 8209, 8232, 8231
9684, 8209, 8210, 8233, 8232
9685, 8210, 8211, 8234, 8233
9686, 8211, 8212, 8235, 8234
9687, 8212, 8213, 8236, 8235
9688, 8213, 8214, 8237, 8236
9689, 8214, 8215, 8238, 8237
9690, 8215, 8216, 8239, 8238
9691, 8216, 8217, 8240, 8239
9692, 8217, 8218, 8241, 8240
9693, 8218, 8219, 8242, 8241
9694, 8219, 8220, 8243, 8242
9695, 8220, 8221, 8244, 8243
9696, 8221, 8222, 8245, 8244
9697, 8222, 8223, 8246, 8245
9698, 8223, 8224, 8247, 8246
9699, 8224, 8225, 8248, 8247
9700, 8225, 8226, 8249, 8248
9701, 8226, 8227, 8250, 8249
9702, 8227, 8228, 8251, 8250
9703, 8228, 8229, 8252, 8251
9704, 8229, 1062, 1063, 8252
9705, 1052, 8230, 8253, 1053
9706, 8230, 8231, 8254, 8253
9707, 8231, 8232, 8255, 8254
9708, 8232, 8233, 8256, 8255
9709, 8233, 8234, 8257, 8256
9710, 8234, 8235, 8258, 8257
9711, 8235, 8236, 8259, 8258
9712, 8236, 8237, 8260, 8259
9713, 8237, 8238, 8261, 8260
9714, 8238, 8239, 8262, 8261
9715, 8239, 8240, 8263, 8262
9716, 8240, 8241, 8264, 8263
9717, 8241, 8242, 8265, 8264
9718, 8242, 8243, 8266, 8265
9719, 8243, 8244, 8267, 8266
9720, 8244, 8245, 8268, 8267
9721, 8245, 8246, 8269, 8268
9722, 8246, 8247, 8270, 8269
9723, 8247, 8248, 8271, 8270
9724, 8248, 8249, 8272, 8271
9725, 8249, 8250, 8273, 8272
9726, 8250, 8251, 8274, 8273
9727, 8251, 8252, 8275, 8274
9728, 8252, 1063, 1064, 8275
9729, 1053, 8253, 8276, 1054
9730, 8253, 8254, 8277, 8276
9731, 8254, 8255, 8278, 8277
9732, 8255, 8256, 8279, 8278
9733, 8256, 8257, 8280, 8279
9734, 8257, 8258, 8281, 8280
9735, 8258, 8259, 8282, 8281
9736, 8259, 8260, 8283, 8282
9737, 8260, 8261, 8284, 8283
9738, 8261, 8262, 8285, 8284
9739, 8262, 8263, 8286, 8285
9740, 8263, 8264, 8287, 8286
9741, 8264, 8265, 8288, 8287
9742, 8265, 8266, 8289, 8288
9743, 8266, 8267, 8290, 8289
9744, 8267, 8268, 8291, 8290
9745, 8268, 8269, 8292, 8291
9746, 8269, 8270, 8293, 8292
9747, 8270, 8271, 8294, 8293
9748, 8271, 8272, 8295, 8294
9749, 8272, 8273, 8296, 8295
9750, 8273, 8274, 8297, 8296
9751, 8274, 8275, 8298, 8297
9752, 8275, 1064, 1065, 8298
9753, 1054, 8276, 8299, 1055
9754, 8276, 8277, 8300, 8299
9755, 8277, 8278, 8301, 8300
9756, 8278, 8279, 8302, 8301
9757, 8279, 8280, 8303, 8302
9758, 8280, 8281, 8304, 8303
9759, 8281, 8282, 8305, 8304
9760, 8282, 8283, 8306, 8305
9761, 8283, 8284, 8307, 8306
9762, 8284, 8285, 8308, 8307
9763, 8285, 8286, 8309, 8308
9764, 8286, 8287, 8310, 8309
9765, 8287, 8288, 8311, 8310
9766, 8288, 8289, 8312, 8311
9767, 8289, 8290, 8313, 8312
9768, 8290, 8291, 8314, 8313
9769, 8291, 8292, 8315, 8314
9770, 8292, 8293, 8316, 8315
9771, 8293, 8294, 8317, 8316
9772, 8294, 8295, 8318, 8317
9773, 8295, 8296, 8319, 8318
9774, 8296, 8297, 8320, 8319
9775, 8297, 8298, 8321, 8320
9776, 8298, 1065, 1066, 8321
9777, 1055, 8299, 8322, 1056
9778, 8299, 8300, 8323, 8322
9779, 8300, 8301, 8324, 8323
9780, 8301, 8302, 8325, 8324
9781, 8302, 8303, 8326, 8325
9782, 8303, 8304, 8327, 8326
9783, 8304, 8305, 8328, 8327
9784, 8305, 8306, 8329, 8328
9785, 8306, 8307, 8330, 8329
9786, 8307, 8308, 8331, 8330
9787, 8308, 8309, 8332, 8331
9788, 8309, 8310, 8333, 8332
9789, 8310, 8311, 8334, 8333
9790, 8311, 8312, 8335, 8334
9791, 8312, 8313, 8336, 8335
9792, 8313, 8314, 8337, 8336
9793, 8314, 8315, 8338, 8337
9794, 8315, 8316, 8339, 8338
9795, 8316, 8317, 8340, 8339
9796, 8317, 8318, 8341, 8340
9797, 8318, 8319, 8342, 8341
9798, 8319, 8320, 8343, 8342
9799, 8320, 8321, 8344, 8343
9800, 8321, 1066, 1067, 8344
9801, 1056, 8322, 8345, 1057
9802, 8322, 8323, 8346, 8345
9803, 8323, 8324, 8347, 8346
9804, 8324, 8325, 8348, 8347
9805, 8325, 8326, 8349, 8348
9806, 8326, 8327, 8350, 8349
9807, 8327, 8328, 8351, 8350
9808, 8328, 8329, 8352, 8351
9809, 8329, 8330, 8353, 8352
9810, 8330, 8331, 8354, 8353
9811, 8331, 8332, 8355, 8354
9812, 8332, 8333, 8356, 8355
9813, 8333, 8334, 8357, 8356
9814, 8334, 8335, 8358, 8357
9815, 8335, 8336, 8359, 8358
9816, 8336, 8337, 8360, 8359
9817, 8337, 8338, 8361, 8360
9818, 8338, 8339, 8362, 8361
9819, 8339, 8340, 8363, 8362
9820, 8340, 8341, 8364, 8363
9821, 8341, 8342, 8365, 8364
9822, 8342, 8343, 8366, 8365
9823, 8343, 8344, 8367, 8366
9824, 8344, 1067, 1068, 8367
9825, 1057, 8345, 1001, 41
9826, 8345, 8346, 1002, 1001
9827, 8346, 8347, 1003, 1002
9828, 8347, 8348, 1004, 1003
9829, 8348, 8349, 1005, 1004
9830, 8349, 8350, 1006, 1005
9831, 8350, 8351, 1007, 1006
9832, 8351, 8352, 1008, 1007
9833, 8352, 8353, 1009, 1008
9834, 8353, 8354, 1010, 1009
9835, 8354, 8355, 1011, 1010
9836, 8355, 8356, 1012, 1011
9837, 8356, 8357, 1013, 1012
9838, 8357, 8358, 1014, 1013
9839, 8358, 8359, 1015, 1014
9840, 8359, 8360, 1016, 1015
9841, 8360, 8361, 1017, 1016
9842, 8361, 8362, 1018, 1017
9843, 8362, 8363, 1019, 1018
9844, 8363, 8364, 1020, 1019
9845, 8364, 8365, 1021, 1020
9846, 8365, 8366, 1022, 1021
9847, 8366, 8367, 1023, 1022
9848, 8367, 1068, 42, 1023
*ELEMENT, type=CPS4, ELSET=Surface52
9849, 41, 1069, 8368, 1001
9850, 1069, 1070, 8369, 8368
9851, 1070, 45, 1073, 8369
9852, 1001, 8368, 8370, 1002
9853, 8368, 8369, 8371, 8370
9854, 8369, 1073, 1074, 8371
9855, 1002, 8370, 8372, 1003
9856, 8370, 8371, 8373, 8372
9857, 8371, 1074, 1075, 8373
9858, 1003, 8372, 8374, 1004
9859, 8372, 8373, 8375, 8374
9860, 8373, 1075, 1076, 8375
9861, 1004, 8374, 8376, 1005
9862, 8374, 8375, 8377, 8376
9863, 8375, 1076, 1077, 8377
9864, 1005, 8376, 8378, 1006
9865, 8376, 8377, 8379, 8378
9866, 8377, 1077, 1078, 8379
9867, 1006, 8378, 8380, 1007
9868, 8378, 8379, 8381, 8380
9869, 8379, 1078, 1079, 8381
9870, 1007, 8380, 8382, 1008
9871, 8380, 8381, 8383, 8382
9872, 8381, 1079, 1080, 8383
9873, 1008, 8382, 8384, 1009
9874, 8382, 8383, 8385, 8384
9875, 8383, 1080, 1081, 8385
9876, 1009, 8384, 8386, 1010
9877, 8384, 8385, 8387, 8386
9878, 8385, 1081, 1082, 8387
9879, 1010, 8386, 8388, 1011
9880, 8386, 8387, 8389, 8388
9881, 8387, 1082, 1083, 8389
9882, 1011, 8388, 8390, 1012
9883, 8388, 8389, 8391, 8390
9884, 8389, 1083, 1084, 8391
9885, 1012, 8390, 8392, 1013
9886, 8390, 8391, 8393, 8392
9887, 8391, 1084, 1085, 8393
9888, 1013, 8392, 8394, 1014
9889, 8392, 8393, 8395, 8394
9890, 8393, 1085, 1086, 8395
9891, 1014, 8394, 8396, 1015
9892, 8394, 8395, 8397, 8396
9893, 8395, 1086, 1087, 8397
9894, 1015, 8396, 8398, 1016
9895, 8396, 8397, 8399, 8398
9896, 8397, 1087, 1088, 8399
9897, 1016, 8398, 8400, 1017
9898, 8398, 8399, 8401, 8400
9899, 8399, 1088, 1089, 8401
9900, 1017, 8400, 8402, 1018
9901, 8400, 8401, 8403, 8402
9902, 8401, 1089, 1090, 8403
9903, 1018, 8402, 8404, 1019
9904, 8402, 8403, 8405, 8404
9905, 8403, 1090, 1091, 8405
9906, 1019, 8404, 8406, 1020
9907, 8404, 8405, 8407, 8406
9908, 8405, 1091, 1092, 8407
9909, 1020, 8406, 8408, 1021
9910, 8406, 8407, 8409, 8408
9911, 8407, 1092, 1093, 8409
9912, 1021, 8408, 8410, 1022
9913, 8408, 8409, 8411, 8410
9914, 8409, 1093, 1094, 8411
9915, 1022, 8410, 8412, 1023
9916, 8410, 8411, 8413, 8412
9917, 8411, 1094, 1095, 8413
9918, 1023, 8412, 1071, 42
9919, 8412, 8413, 1072, 1071
9920, 8413, 1095, 46, 1072
*ELEMENT, type=CPS4, ELSET=Surface53
9921, 43, 1024, 8414, 1096
9922, 1096, 8414, 8415, 1097
9923, 1097, 8415, 1100, 47
9924, 1024, 1025, 8416, 8414
9925, 8414, 8416, 8417, 8415
9926, 8415, 8417, 1101, 1100
9927, 1025, 1026, 8418, 8416
9928, 8416, 8418, 8419, 8417
9929, 8417, 8419, 1102, 1101
9930, 1026, 1027, 8420, 8418
9931, 8418, 8420, 8421, 8419
9932, 8419, 8421, 1103, 1102
9933, 1027, 1028, 8422, 8420
9934, 8420, 8422, 8423, 8421
9935, 8421, 8423, 1104, 1103
9936, 1028, 1029, 8424, 8422
9937, 8422, 8424, 8425, 8423
9938, 8423, 8425, 1105, 1104
9939, 1029, 1030, 8426, 8424
9940, 8424, 8426, 8427, 8425
9941, 8425, 8427, 1106, 1105
9942, 1030, 1031, 8428, 8426
9943, 8426, 8428, 8429, 8427
9944, 8427, 8429, 1107, 1106
9945, 1031, 1032, 8430, 8428
9946, 8428, 8430, 8431, 8429
9947, 8429, 8431, 1108, 1107
9948, 1032, 1033, 8432, 8430
9949, 8430, 8432, 8433, 8431
9950, 8431, 8433, 1109, 1108
9951, 1033, 1034, 8434, 8432
9952, 8432, 8434, 8435, 8433
9953, 8433, 8435, 1110, 1109
9954, 1034, 1035, 8436, 8434
9955, 8434, 8436, 8437, 8435
9956, 8435, 8437, 1111, 1110
9957, 1035, 1036, 8438, 8436
9958, 8436, 8438, 8439, 8437
9959, 8437, 8439, 1112, 1111
9960, 1036, 1037, 8440, 8438
9961, 8438, 8440, 8441, 8439
9962, 8439, 8441, 1113, 1112
9963, 1037, 1038, 8442, 8440
9964, 8440, 8442, 8443, 8441
9965, 8441, 8443, 1114, 1113
9966, 1038, 1039, 8444, 8442
9967, 8442, 8444, 8445, 8443
9968, 8443, 8445, 1115, 1114
9969, 1039, 1040, 8446, 8444
9970, 8444, 8446, 8447, 8445
9971, 8445, 8447, 1116, 1115
9972, 1040, 1041, 8448, 8446
9973, 8446, 8448, 8449, 8447
9974, 8447, 8449, 1117, 1116
9975, 1041, 1042, 8450, 8448
9976, 8448, 8450, 8451, 8449
9977, 8449, 8451, 1118, 1117
9978, 1042, 1043, 8452, 8450
9979, 8450, 8452, 8453, 8451
9980, 8451, 8453, 1119, 1118
9981, 1043, 1044, 8454, 8452
9982, 8452, 8454, 8455, 8453
9983, 8453, 8455, 1120, 1119
9984, 1044, 1045, 8456, 8454
9985, 8454, 8456, 8457, 8455
9986, 8455, 8457, 1121, 1120
9987, 1045, 1046, 8458, 8456
9988, 8456, 8458, 8459, 8457
9989, 8457, 8459, 1122, 1121
9990, 1046, 44, 1098, 8458
9991, 8458, 1098, 1099, 8459
9992, 8459, 1099, 48, 1122
*ELEMENT, type=CPS4, ELSET=Surface54
9993, 43, 1096, 8460, 1047
9994, 1096, 1097, 8461, 8460
9995, 1097, 47, 1123, 8461
9996, 1047, 8460, 8462, 1048
9997, 8460, 8461, 8463, 8462
9998, 8461, 1123, 1124, 8463
9999, 1048, 8462, 8464, 1049
10000, 8462, 8463, 8465, 8464
10001, 8463, 1124, 1125, 8465
10002, 1049, 8464, 8466, 1050
10003, 8464, 8465, 8467, 8466
10004, 8465, 1125, 1126, 8467
10005, 1050, 8466, 8468, 1051
10006, 8466, 8467, 8469, 8468
10007, 8467, 1126, 1127, 8469
10008, 1051, 8468, 8470, 1052
10009, 8468, 8469, 8471, 8470
10010, 8469, 1127, 1128, 8471
10011, 1052, 8470, 8472, 1053
10012, 8470, 8471, 8473, 8472
10013, 8471, 1128, 1129, 8473
10014, 1053, 8472, 8474, 1054
10015, 8472, 8473, 8475, 8474
10016, 8473, 1129, 1130, 8475
10017, 1054, 8474, 8476, 1055
10018, 8474, 8475, 8477, 8476
10019, 8475, 1130, 1131, 8477
10020, 1055, 8476, 8478, 1056
10021, 8476, 8477, 8479, 8478
10022, 8477, 1131, 1132, 8479
10023, 1056, 8478, 8480, 1057
10024, 8478, 8479, 8481, 8480
10025, 8479, 1132, 1133, 8481
10026, 1057, 8480, 1069, 41
10027, 8480, 8481, 1070, 1069
10028, 8481, 1133, 45, 1070
*ELEMENT, type=CPS4, ELSET=Surface55
10029, 44, 1058, 8482, 1098
10030, 1098, 8482, 8483, 1099
10031, 1099, 8483, 1134, 48
10032, 1058, 1059, 8484, 8482
10033, 8482, 8484, 8485, 8483
10034, 8483, 8485, 1135, 1134
10035, 1059, 1060, 8486, 8484
10036, 8484, 8486, 8487, 8485
10037, 8485, 8487, 1136, 1135
10038, 1060, 1061, 8488, 8486
10039, 8486, 8488, 8489, 8487
10040, 8487, 8489, 1137, 1136
10041, 1061, 1062, 8490, 8488
10042, 8488, 8490, 8491, 8489
10043, 8489, 8491, 1138, 1137
10044, 1062, 1063, 8492, 8490
10045, 8490, 8492, 8493, 8491
10046, 8491, 8493, 1139, 1138
10047, 1063, 1064, 8494, 8492
10048, 8492, 8494, 8495, 8493
10049, 8493, 8495, 1140, 1139
10050, 1064, 1065, 8496, 8494
10051, 8494, 8496, 8497, 8495
10052, 8495, 8497, 1141, 1140
10053, 1065, 1066, 8498, 8496
10054, 8496, 8498, 8499, 8497
10055, 8497, 8499, 1142, 1141
10056, 1066, 1067, 8500, 8498
10057, 8498, 8500, 8501, 8499
10058, 8499, 8501, 1143, 1142
10059, 1067, 1068, 8502, 8500
10060, 8500, 8502, 8503, 8501
10061, 8501, 8503, 1144, 1143
10062, 1068, 42, 1071, 8502
10063, 8502, 1071, 1072, 8503
10064, 8503, 1072, 46, 1144
*ELEMENT, type=CPS4, ELSET=Surface56
10065, 47, 1100, 8504, 1123
10066, 1100, 1101, 8505, 8504
10067, 1101, 1102, 8506, 8505
10068, 1102, 1103, 8507, 8506
10069, 1103, 1104, 8508, 8507
10070, 1104, 1105, 8509, 8508
10071, 1105, 1106, 8510, 8509
10072, 1106, 1107, 8511, 8510
10073, 1107, 1108, 8512, 8511
10074, 1108, 1109, 8513, 8512
10075, 1109, 1110, 8514, 8513
10076, 1110, 1111, 8515, 8514
10077, 1111, 1112, 8516, 8515
10078, 1112, 1113, 8517, 8516
10079, 1113, 1114, 8518, 8517
10080, 1114, 1115, 8519, 8518
10081, 1115, 1116, 8520, 8519
10082, 1116, 1117, 8521, 8520
10083, 1117, 1118, 8522, 8521
10084, 1118, 1119, 8523, 8522
10085, 1119, 1120, 8524, 8523
10086, 1120, 1121, 8525, 8524
10087, 1121, 1122, 8526, 8525
10088, 1122, 48, 1134, 8526
10089, 1123, 8504, 8527, 1124
10090, 8504, 8505, 8528, 8527
10091, 8505, 8506, 8529, 8528
10092, 8506, 8507, 8530, 8529
10093, 8507, 8508, 8531, 8530
10094, 8508, 8509, 8532, 8531
10095, 8509, 8510, 8533, 8532
10096, 8510, 8511, 8534, 8533
10097, 8511, 8512, 8535, 8534
10098, 8512, 8513, 8536, 8535
10099, 8513, 8514, 8537, 8536
10100, 8514, 8515, 8538, 8537
10101, 8515, 8516, 8539, 8538
10102, 8516, 8517, 8540, 8539
10103, 8517, 8518, 8541, 8540
10104, 8518, 8519, 8542, 8541
10105, 8519, 8520, 8543, 8542
10106, 8520, 8521, 8544, 8543
10107, 8521, 8522, 8545, 8544
10108, 8522, 8523, 8546, 8545
10109, 8523, 8524, 8547, 8546
10110, 8524, 8525, 8548, 8547
10111, 8525, 8526, 8549, 8548
10112, 8526, 1134, 1135, 8549
10113, 1124, 8527, 8550, 1125
10114, 8527, 8528, 8551, 8550
10115, 8528, 8529, 8552, 8551
10116, 8529, 8530, 8553, 8552
10117, 8530, 8531, 8554, 8553
10118, 8531, 8532, 8555, 8554
10119, 8532, 8533, 8556, 8555
10120, 8533, 8534, 8557, 8556
10121, 8534, 8535, 8558, 8557
10122, 8535, 8536, 8559, 8558
10123, 8536, 8537, 8560, 8559
10124, 8537, 8538, 8561, 8560
10125, 8538, 8539, 8562, 8561
10126, 8539, 8540, 8563, 8562
10127, 8540, 8541, 8564, 8563
10128, 8541, 8542, 8565, 8564
10129, 8542, 8543, 8566, 8565
10130, 8543, 8544, 8567, 8566
10131, 8544, 8545, 8568, 8567
10132, 8545, 8546, 8569, 8568
10133, 8546, 8547, 8570, 8569
10134, 8547, 8548, 8571, 8570
10135, 8548, 8549, 8572, 8571
10136, 8549, 1135, 1136, 8572
10137, 1125, 8550, 8573, 1126
10138, 8550, 8551, 8574, 8573
10139, 8551, 8552, 8575, 8574
10140, 8552, 8553, 8576, 8575
10141, 8553, 8554, 8577, 8576
10142, 8554, 8555, 8578, 8577
10143, 8555, 8556, 8579, 8578
10144, 8556, 8557, 8580, 8579
10145, 8557, 8558, 8581, 8580
10146, 8558, 8559, 8582, 8581
10147, 8559, 8560, 8583, 8582
10148, 8560, 8561, 8584, 8583
10149, 8561, 8562, 8585, 8584
10150, 8562, 8563, 8586, 8585
10151, 8563, 8564, 8587, 8586
10152, 8564, 8565, 8588, 8587
10153, 8565, 8566, 8589, 8588
10154, 8566, 8567, 8590, 8589
10155, 8567, 8568, 8591, 8590
10156, 8568, 8569, 8592, 8591
10157, 8569, 8570, 8593, 8592
10158, 8570, 8571, 8594, 8593
10159, 8571, 8572, 8595, 8594
10160, 8572, 1136, 1137, 8595
10161, 1126, 8573, 8596, 1127
10162, 8573, 8574, 8597, 8596
10163, 8574, 8575, 8598, 8597
10164, 8575, 8576, 8599, 8598
10165, 8576, 8577, 8600, 8599
10166, 8577, 8578, 8601, 8600
10167, 8578, 8579, 8602, 8601
10168, 8579, 8580, 8603, 8602
10169, 8580, 8581, 8604, 8603
10170, 8581, 8582, 8605, 8604
10171, 8582, 8583, 8606, 8605
10172, 8583, 8584, 8607, 8606
10173, 8584, 8585, 8608, 8607
10174, 8585, 8586, 8609, 8608
10175, 8586, 8587, 8610, 8609
10176, 8587, 8588, 8611, 8610
10177, 8588, 8589, 8612, 8611
10178, 8589, 8590, 8613, 8612
10179, 8590, 8591, 8614, 8613
10180, 8591, 8592, 8615, 8614
10181, 8592, 8593, 8616, 8615
10182, 8593, 8594, 8617, 8616
10183, 8594, 8595, 8618, 8617
10184, 8595, 1137, 1138, 8618
10185, 1127, 8596, 8619, 1128
10186, 8596, 8597, 8620, 8619
10187, 8597, 8598, 8621, 8620
10188, 8598, 8599, 8622, 8621
10189, 8599, 8600, 8623, 8622
10190, 8600, 8601, 8624, 8623
10191, 8601, 8602, 8625, 8624
10192, 8602, 8603, 8626, 8625
10193, 8603, 8604, 8627, 8626
10194, 8604, 8605, 8628, 8627
10195, 8605, 8606, 8629, 8628
10196, 8606, 8607, 8630, 8629
10197, 8607, 8608, 8631, 8630
10198, 8608, 8609, 8632, 8631
10199, 8609, 8610, 8633, 8632
10200, 8610, 8611, 8634, 8633
10201, 8611, 8612, 8635, 8634
10202, 8612, 8613, 8636, 8635
10203, 8613, 8614, 8637, 8636
10204, 8614, 8615, 8638, 8637
10205, 8615, 8616, 8639, 8638
10206, 8616, 8617, 8640, 8639
10207, 8617, 8618, 8641, 8640
10208, 8618, 1138, 1139, 8641
10209, 1128, 8619, 8642, 1129
10210, 8619, 8620, 8643, 8642
10211, 8620, 8621, 8644, 8643
10212, 8621, 8622, 8645, 8644
10213, 8622, 8623, 8646, 8645
10214, 8623, 8624, 8647, 8646
10215, 8624, 8625, 8648, 8647
10216, 8625, 8626, 8649, 8648
10217, 8626, 8627, 8650, 8649
10218, 8627, 8628, 8651, 8650
10219, 8628, 8629, 8652, 8651
10220, 8629, 8630, 8653, 8652
10221, 8630, 8631, 8654, 8653
10222, 8631, 8632, 8655, 8654
10223, 8632, 8633, 8656, 8655
10224, 8633, 8634, 8657, 8656
10225, 8634, 8635, 8658, 8657
10226, 8635, 8636, 8659, 8658
10227, 8636, 8637, 8660, 8659
10228, 8637, 8638, 8661, 8660
10229, 8638, 8639, 8662, 8661
10230, 8639, 8640, 8663, 8662
10231, 8640, 8641, 8664, 8663
10232, 8641, 1139, 1140, 8664
10233, 1129, 8642, 8665, 1130
10234, 8642, 8643, 8666, 8665
10235, 8643, 8644, 8667, 8666
10236, 8644, 8645, 8668, 8667
10237, 8645, 8646, 8669, 8668
10238, 8646, 8647, 8670, 8669
10239, 8647, 8648, 8671, 8670
10240, 8648, 8649, 8672, 8671
10241, 8649, 8650, 8673, 8672
10242, 8650, 8651, 8674, 8673
10243, 8651, 8652, 8675, 8674
10244, 8652, 8653, 8676, 8675
10245, 8653, 8654, 8677, 8676
10246, 8654, 8655, 8678, 8677
10247, 8655, 8656, 8679, 8678
10248, 8656, 8657, 8680, 8679
10249, 8657, 8658, 8681, 8680
10250, 8658, 8659, 8682, 8681
10251, 8659, 8660, 8683, 8682
10252, 8660, 8661, 8684, 8683
10253, 8661, 8662, 8685, 8684
10254, 8662, 8663, 8686, 8685
10255, 8663, 8664, 8687, 8686
10256, 8664, 1140, 1141, 8687
10257, 1130, 8665, 8688, 1131
10258, 8665, 8666, 8689, 8688
10259, 8666, 8667, 8690, 8689
10260, 8667, 8668, 8691, 8690
10261, 8668, 8669, 8692, 8691
10262, 8669, 8670, 8693, 8692
10263, 8670, 8671, 8694, 8693
10264, 8671, 8672, 8695, 8694
10265, 8672, 8673, 8696, 8695
10266, 8673, 8674, 8697, 8696
10267, 8674, 8675, 8698, 8697
10268, 8675, 8676, 8699, 8698
10269, 8676, 8677, 8700, 8699
10270, 8677, 8678, 8701, 8700
10271, 8678, 8679, 8702, 8701
10272, 8679, 8680, 8703, 8702
10273, 8680, 8681, 8704, 8703
10274, 8681, 8682, 8705, 8704
10275, 8682, 8683, 8706, 8705
10276, 8683, 8684, 8707, 8706
10277, 8684, 8685, 8708, 8707
10278, 8685, 8686, 8709, 8708
10279, 8686, 8687, 8710, 8709
10280, 8687, 1141, 1142, 8710
10281, 1131, 8688, 8711, 1132
10282, 8688, 8689, 8712, 8711
10283, 8689, 8690, 8713, 8712
10284, 8690, 8691, 8714, 8713
10285, 8691, 8692, 8715, 8714
10286, 8692, 8693, 8716, 8715
10287, 8693, 8694, 8717, 8716
10288, 8694, 8695, 8718, 8717
10289, 8695, 8696, 8719, 8718
10290, 8696, 8697, 8720, 8719
10291, 8697, 8698, 8721, 8720
10292, 8698, 8699, 8722, 8721
10293, 8699, 8700, 8723, 8722
10294, 8700, 8701, 8724, 8723
10295, 8701, 8702, 8725, 8724
10296, 8702, 8703, 8726, 8725
10297, 8703, 8704, 8727, 8726
10298, 8704, 8705, 8728, 8727
10299, 8705, 8706, 8729, 8728
10300, 8706, 8707, 8730, 8729
10301, 8707, 8708, 8731, 8730
10302, 8708, 8709, 8732, 8731
10303, 8709, 8710, 8733, 8732
10304, 8710, 1142, 1143, 8733
10305, 1132, 8711, 8734, 1133
10306, 8711, 8712, 8735, 8734
10307, 8712, 8713, 8736, 8735
10308, 8713, 8714, 8737, 8736
10309, 8714, 8715, 8738, 8737
10310, 8715, 8716, 8739, 8738
10311, 8716, 8717, 8740, 8739
10312, 8717, 8718, 8741, 8740
10313, 8718, 8719, 8742, 8741
10314, 8719, 8720, 8743, 8742
10315, 8720, 8721, 8744, 8743
10316, 8721, 8722, 8745, 8744
10317, 8722, 8723, 8746, 8745
10318, 8723, 8724, 8747, 8746
10319, 8724, 8725, 8748, 8747
10320, 8725, 8726, 8749, 8748
10321, 8726, 8727, 8750, 8749
10322, 8727, 8728, 8751, 8750
10323, 8728, 8729, 8752, 8751
10324, 8729, 8730, 8753, 8752
10325, 8730, 8731, 8754, 8753
10326, 8731, 8732, 8755, 8754
10327, 8732, 8733, 8756, 8755
10328, 8733, 1143, 1144, 8756
10329, 1133, 8734, 1073, 45
10330, 8734, 8735, 1074, 1073
10331, 8735, 8736, 1075, 1074
10332, 8736, 8737, 1076, 1075
10333, 8737, 8738, 1077, 1076
10334, 8738, 8739, 1078, 1077
10335, 8739, 8740, 1079, 1078
10336, 8740, 8741, 1080, 1079
10337, 8741, 8742, 1081, 1080
10338, 8742, 8743, 1082, 1081
10339, 8743, 8744, 1083, 1082
10340, 8744, 8745, 1084, 1083
10341, 8745, 8746, 1085, 1084
10342, 8746, 8747, 1086, 1085
10343, 8747, 8748, 1087, 1086
10344, 8748, 8749, 1088, 1087
10345, 8749, 8750, 1089, 1088
10346, 8750, 8751, 1090, 1089
10347, 8751, 8752, 1091, 1090
10348, 8752, 8753, 1092, 1091
10349, 8753, 8754, 1093, 1092
10350, 8754, 8755, 1094, 1093
10351, 8755, 8756, 1095, 1094
10352, 8756, 1144, 46, 1095
*ELEMENT, type=CPS4, ELSET=Surface57
10353, 42, 1071, 1145, 49
10354, 1071, 1072, 1146, 1145
10355, 1072, 46, 50, 1146
*ELEMENT, type=CPS4, ELSET=Surface58
10356, 44, 51, 1147, 1098
10357, 1098, 1147, 1148, 1099
10358, 1099, 1148, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
10359, 44, 1058, 1149, 51
10360, 1058, 1059, 1150, 1149
10361, 1059, 1060, 1151, 1150
10362, 1060, 1061, 1152, 1151
10363, 1061, 1062, 1153, 1152
10364, 1062, 1063, 1154, 1153
10365, 1063, 1064, 1155, 1154
10366, 1064, 1065, 1156, 1155
10367, 1065, 1066, 1157, 1156
10368, 1066, 1067, 1158, 1157
10369, 1067, 1068, 1159, 1158
10370, 1068, 42, 49, 1159
*ELEMENT, type=CPS4, ELSET=Surface60
10371, 48, 52, 1160, 1134
10372, 1134, 1160, 1161, 1135
10373, 1135, 1161, 1162, 1136
10374, 1136, 1162, 1163, 1137
10375, 1137, 1163, 1164, 1138
10376, 1138, 1164, 1165, 1139
10377, 1139, 1165, 1166, 1140
10378, 1140, 1166, 1167, 1141
10379, 1141, 1167, 1168, 1142
10380, 1142, 1168, 1169, 1143
10381, 1143, 1169, 1170, 1144
10382, 1144, 1170, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
10383, 51, 1149, 8757, 1147
10384, 1147, 8757, 8758, 1148
10385, 1148, 8758, 1160, 52
10386, 1149, 1150, 8759, 8757
10387, 8757, 8759, 8760, 8758
10388, 8758, 8760, 1161, 1160
10389, 1150, 1151, 8761, 8759
10390, 8759, 8761, 8762, 8760
10391, 8760, 8762, 1162, 1161
10392, 1151, 1152, 8763, 8761
10393, 8761, 8763, 8764, 8762
10394, 8762, 8764, 1163, 1162
10395, 1152, 1153, 8765, 8763
10396, 8763, 8765, 8766, 8764
10397, 8764, 8766, 1164, 1163
10398, 1153, 1154, 8767, 8765
10399, 8765, 8767, 8768, 8766
10400, 8766, 8768, 1165, 1164
10401, 1154, 1155, 8769, 8767
10402, 8767, 8769, 8770, 8768
10403, 8768, 8770, 1166, 1165
10404, 1155, 1156, 8771, 8769
10405, 8769, 8771, 8772, 8770
10406, 8770, 8772, 1167, 1166
10407, 1156, 1157, 8773, 8771
10408, 8771, 8773, 8774, 8772
10409, 8772, 8774, 1168, 1167
10410, 1157, 1158, 8775, 8773
10411, 8773, 8775, 8776, 8774
10412, 8774, 8776, 1169, 1168
10413, 1158, 1159, 8777, 8775
10414, 8775, 8777, 8778, 8776
10415, 8776, 8778, 1170, 1169
10416, 1159, 49, 1145, 8777
10417, 8777, 1145, 1146, 8778
10418, 8778, 1146, 50, 1170
*ELEMENT, type=CPS4, ELSET=Surface62
10419, 2, 97, 1171, 54
10420, 97, 98, 1172, 1171
10421, 98, 99, 1173, 1172
10422, 99, 100, 1174, 1173
10423, 100, 101, 1175, 1174
10424, 101, 102, 1176, 1175
10425, 102, 103, 1177, 1176
10426, 103, 104, 1178, 1177
10427, 104, 105, 1179, 1178
10428, 105, 106, 1180, 1179
10429, 106, 107, 1181, 1180
10430, 107, 1, 53, 1181
*ELEMENT, type=CPS4, ELSET=Surface63
10431, 1, 108, 1182, 53
10432, 108, 109, 1183, 1182
10433, 109, 3, 55, 1183
*ELEMENT, type=CPS4, ELSET=Surface64
10434, 4, 56, 1184, 110
10435, 110, 1184, 1185, 111
10436, 111, 1185, 1186, 112
10437, 112, 1186, 1187, 113
10438, 113, 1187, 1188, 114
10439, 114, 1188, 1189, 115
10440, 115, 1189, 1190, 116
10441, 116, 1190, 1191, 117
10442, 117, 1191, 1192, 118
10443, 118, 1192, 1193, 119
10444, 119, 1193, 1194, 120
10445, 120, 1194, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
10446, 2, 54, 1195, 121
10447, 121, 1195, 1196, 122
10448, 122, 1196, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
10449, 54, 1171, 8779, 1195
10450, 1195, 8779, 8780, 1196
10451, 1196, 8780, 1184, 56
10452, 1171, 1172, 8781, 8779
10453, 8779, 8781, 8782, 8780
10454, 8780, 8782, 1185, 1184
10455, 1172, 1173, 8783, 8781
10456, 8781, 8783, 8784, 8782
10457, 8782, 8784, 1186, 1185
10458, 1173, 1174, 8785, 8783
10459, 8783, 8785, 8786, 8784
10460, 8784, 8786, 1187, 1186
10461, 1174, 1175, 8787, 8785
10462, 8785, 8787, 8788, 8786
10463, 8786, 8788, 1188, 1187
10464, 1175, 1176, 8789, 8787
10465, 8787, 8789, 8790, 8788
10466, 8788, 8790, 1189, 1188
10467, 1176, 1177, 8791, 8789
10468, 8789, 8791, 8792, 8790
10469, 8790, 8792, 1190, 1189
10470, 1177, 1178, 8793, 8791
10471, 8791, 8793, 8794, 8792
10472, 8792, 8794, 1191, 1190
10473, 1178, 1179, 8795, 8793
10474, 8793, 8795, 8796, 8794
10475, 8794, 8796, 1192, 1191
10476, 1179, 1180, 8797, 8795
10477, 8795, 8797, 8798, 8796
10478, 8796, 8798, 1193, 1192
10479, 1180, 1181, 8799, 8797
10480, 8797, 8799, 8800, 8798
10481, 8798, 8800, 1194, 1193
10482, 1181, 53, 1182, 8799
10483, 8799, 1182, 1183, 8800
10484, 8800, 1183, 55, 1194
*ELEMENT, type=CPS4, ELSET=Surface77
10485, 11, 57, 1197, 378
10486, 378, 1197, 1198, 379
10487, 379, 1198, 1199, 380
10488, 380, 1199, 1200, 381
10489, 381, 1200, 1201, 382
10490, 382, 1201, 1202, 383
10491, 383, 1202, 1203, 384
10492, 384, 1203, 1204, 385
10493, 385, 1204, 1205, 386
10494, 386, 1205, 1206, 387
10495, 387, 1206, 1207, 388
10496, 388, 1207, 1208, 389
10497, 389, 1208, 1209, 390
10498, 390, 1209, 1210, 391
10499, 391, 1210, 1211, 392
10500, 392, 1211, 1212, 393
10501, 393, 1212, 1213, 394
10502, 394, 1213, 1214, 395
10503, 395, 1214, 1215, 396
10504, 396, 1215, 1216, 397
10505, 397, 1216, 1217, 398
10506, 398, 1217, 1218, 399
10507, 399, 1218, 1219, 400
10508, 400, 1219, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
10509, 9, 309, 1220, 59
10510, 309, 310, 1221, 1220
10511, 310, 311, 1222, 1221
10512, 311, 312, 1223, 1222
10513, 312, 313, 1224, 1223
10514, 313, 314, 1225, 1224
10515, 314, 315, 1226, 1225
10516, 315, 316, 1227, 1226
10517, 316, 317, 1228, 1227
10518, 317, 318, 1229, 1228
10519, 318, 319, 1230, 1229
10520, 319, 320, 1231, 1230
10521, 320, 321, 1232, 1231
10522, 321, 322, 1233, 1232
10523, 322, 323, 1234, 1233
10524, 323, 324, 1235, 1234
10525, 324, 325, 1236, 1235
10526, 325, 326, 1237, 1236
10527, 326, 327, 1238, 1237
10528, 327, 328, 1239, 1238
10529, 328, 329, 1240, 1239
10530, 329, 330, 1241, 1240
10531, 330, 331, 1242, 1241
10532, 331, 13, 60, 1242
*ELEMENT, type=CPS4, ELSET=Surface79
10533, 9, 59, 1243, 264
10534, 264, 1243, 1244, 265
10535, 265, 1244, 1245, 266
10536, 266, 1245, 1246, 267
10537, 267, 1246, 1247, 268
10538, 268, 1247, 1248, 269
10539, 269, 1248, 1249, 270
10540, 270, 1249, 1250, 271
10541, 271, 1250, 1251, 272
10542, 272, 1251, 1252, 273
10543, 273, 1252, 1253, 274
10544, 274, 1253, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
10545, 13, 401, 1254, 60
10546, 401, 402, 1255, 1254
10547, 402, 403, 1256, 1255
10548, 403, 404, 1257, 1256
10549, 404, 405, 1258, 1257
10550, 405, 406, 1259, 1258
10551, 406, 407, 1260, 1259
10552, 407, 408, 1261, 1260
10553, 408, 409, 1262, 1261
10554, 409, 410, 1263, 1262
10555, 410, 411, 1264, 1263
10556, 411, 15, 58, 1264
*ELEMENT, type=CPS4, ELSET=Surface81
10557, 59, 1220, 8801, 1243
10558, 1220, 1221, 8802, 8801
10559, 1221, 1222, 8803, 8802
10560, 1222, 1223, 8804, 8803
10561, 1223, 1224, 8805, 8804
10562, 1224, 1225, 8806, 8805
10563, 1225, 1226, 8807, 8806
10564, 1226, 1227, 8808, 8807
10565, 1227, 1228, 8809, 8808
10566, 1228, 1229, 8810, 8809
10567, 1229, 1230, 8811, 8810
10568, 1230, 1231, 8812, 8811
10569, 1231, 1232, 8813, 8812
10570, 1232, 1233, 8814, 8813
10571, 1233, 1234, 8815, 8814
10572, 1234, 1235, 8816, 8815
10573, 1235, 1236, 8817, 8816
10574, 1236, 1237, 8818, 8817
10575, 1237, 1238, 8819, 8818
10576, 1238, 1239, 8820, 8819
10577, 1239, 1240, 8821, 8820
10578, 1240, 1241, 8822, 8821
10579, 1241, 1242, 8823, 8822
10580, 1242, 60, 1254, 8823
10581, 1243, 8801, 8824, 1244
10582, 8801, 8802, 8825, 8824
10583, 8802, 8803, 8826, 8825
10584, 8803, 8804, 8827, 8826
10585, 8804, 8805, 8828, 8827
10586, 8805, 8806, 8829, 8828
10587, 8806, 8807, 8830, 8829
10588, 8807, 8808, 8831, 8830
10589, 8808, 8809, 8832, 8831
10590, 8809, 8810, 8833, 8832
10591, 8810, 8811, 8834, 8833
10592, 8811, 8812, 8835, 8834
10593, 8812, 8813, 8836, 8835
10594, 8813, 8814, 8837, 8836
10595, 8814, 8815, 8838, 8837
10596, 8815, 8816, 8839, 8838
10597, 8816, 8817, 8840, 8839
10598, 8817, 8818, 8841, 8840
10599, 8818, 8819, 8842, 8841
10600, 8819, 8820, 8843, 8842
10601, 8820, 8821, 8844, 8843
10602, 8821, 8822, 8845, 8844
10603, 8822, 8823, 8846, 8845
10604, 8823, 1254, 1255, 8846
10605, 1244, 8824, 8847, 1245
10606, 8824, 8825, 8848, 8847
10607, 8825, 8826, 8849, 8848
10608, 8826, 8827, 8850, 8849
10609, 8827, 8828, 8851, 8850
10610, 8828, 8829, 8852, 8851
10611, 8829, 8830, 8853, 8852
10612, 8830, 8831, 8854, 8853
10613, 8831, 8832, 8855, 8854
10614, 8832, 8833, 8856, 8855
10615, 8833, 8834, 8857, 8856
10616, 8834, 8835, 8858, 8857
10617, 8835, 8836, 8859, 8858
10618, 8836, 8837, 8860, 8859
10619, 8837, 8838, 8861, 8860
10620, 8838, 8839, 8862, 8861
10621, 8839, 8840, 8863, 8862
10622, 8840, 8841, 8864, 8863
10623, 8841, 8842, 8865, 8864
10624, 8842, 8843, 8866, 8865
10625, 8843, 8844, 8867, 8866
10626, 8844, 8845, 8868, 8867
10627, 8845, 8846, 8869, 8868
10628, 8846, 1255, 1256, 8869
10629, 1245, 8847, 8870, 1246
10630, 8847, 8848, 8871, 8870
10631, 8848, 8849, 8872, 8871
10632, 8849, 8850, 8873, 8872
10633, 8850, 8851, 8874, 8873
10634, 8851, 8852, 8875, 8874
10635, 8852, 8853, 8876, 8875
10636, 8853, 8854, 8877, 8876
10637, 8854, 8855, 8878, 8877
10638, 8855, 8856, 8879, 8878
10639, 8856, 8857, 8880, 8879
10640, 8857, 8858, 8881, 8880
10641, 8858, 8859, 8882, 8881
10642, 8859, 8860, 8883, 8882
10643, 8860, 8861, 8884, 8883
10644, 8861, 8862, 8885, 8884
10645, 8862, 8863, 8886, 8885
10646, 8863, 8864, 8887, 8886
10647, 8864, 8865, 8888, 8887
10648, 8865, 8866, 8889, 8888
10649, 8866, 8867, 8890, 8889
10650, 8867, 8868, 8891, 8890
10651, 8868, 8869, 8892, 8891
10652, 8869, 1256, 1257, 8892
10653, 1246, 8870, 8893, 1247
10654, 8870, 8871, 8894, 8893
10655, 8871, 8872, 8895, 8894
10656, 8872, 8873, 8896, 8895
10657, 8873, 8874, 8897, 8896
10658, 8874, 8875, 8898, 8897
10659, 8875, 8876, 8899, 8898
10660, 8876, 8877, 8900, 8899
10661, 8877, 8878, 8901, 8900
10662, 8878, 8879, 8902, 8901
10663, 8879, 8880, 8903, 8902
10664, 8880, 8881, 8904, 8903
10665, 8881, 8882, 8905, 8904
10666, 8882, 8883, 8906, 8905
10667, 8883, 8884, 8907, 8906
10668, 8884, 8885, 8908, 8907
10669, 8885, 8886, 8909, 8908
10670, 8886, 8887, 8910, 8909
10671, 8887, 8888, 8911, 8910
10672, 8888, 8889, 8912, 8911
10673, 8889, 8890, 8913, 8912
10674, 8890, 8891, 8914, 8913
10675, 8891, 8892, 8915, 8914
10676, 8892, 1257, 1258, 8915
10677, 1247, 8893, 8916, 1248
10678, 8893, 8894, 8917, 8916
10679, 8894, 8895, 8918, 8917
10680, 8895, 8896, 8919, 8918
10681, 8896, 8897, 8920, 8919
10682, 8897, 8898, 8921, 8920
10683, 8898, 8899, 8922, 8921
10684, 8899, 8900, 8923, 8922
10685, 8900, 8901, 8924, 8923
10686, 8901, 8902, 8925, 8924
10687, 8902, 8903, 8926, 8925
10688, 8903, 8904, 8927, 8926
10689, 8904, 8905, 8928, 8927
10690, 8905, 8906, 8929, 8928
10691, 8906, 8907, 8930, 8929
10692, 8907, 8908, 8931, 8930
10693, 8908, 8909, 8932, 8931
10694, 8909, 8910, 8933, 8932
10695, 8910, 8911, 8934, 8933
10696, 8911, 8912, 8935, 8934
10697, 8912, 8913, 8936, 8935
10698, 8913, 8914, 8937, 8936
10699, 8914, 8915, 8938, 8937
10700, 8915, 1258, 1259, 8938
10701, 1248, 8916, 8939, 1249
10702, 8916, 8917, 8940, 8939
10703, 8917, 8918, 8941, 8940
10704, 8918, 8919, 8942, 8941
10705, 8919, 8920, 8943, 8942
10706, 8920, 8921, 8944, 8943
10707, 8921, 8922, 8945, 8944
10708, 8922, 8923, 8946, 8945
10709, 8923, 8924, 8947, 8946
10710, 8924, 8925, 8948, 8947
10711, 8925, 8926, 8949, 8948
10712, 8926, 8927, 8950, 8949
10713, 8927, 8928, 8951, 8950
10714, 8928, 8929, 8952, 8951
10715, 8929, 8930, 8953, 8952
10716, 8930, 8931, 8954, 8953
10717, 8931, 8932, 8955, 8954
10718, 8932, 8933, 8956, 8955
10719, 8933, 8934, 8957, 8956
10720, 8934, 8935, 8958, 8957
10721, 8935, 8936, 8959, 8958
10722, 8936, 8937, 8960, 8959
10723, 8937, 8938, 8961, 8960
10724, 8938, 1259, 1260, 8961
10725, 1249, 8939, 8962, 1250
10726, 8939, 8940, 8963, 8962
10727, 8940, 8941, 8964, 8963
10728, 8941, 8942, 8965, 8964
10729, 8942, 8943, 8966, 8965
10730, 8943, 8944, 8967, 8966
10731, 8944, 8945, 8968, 8967
10732, 8945, 8946, 8969, 8968
10733, 8946, 8947, 8970, 8969
10734, 8947, 8948, 8971, 8970
10735, 8948, 8949, 8972, 8971
10736, 8949, 8950, 8973, 8972
10737, 8950, 8951, 8974, 8973
10738, 8951, 8952, 8975, 8974
10739, 8952, 8953, 8976, 8975
10740, 8953, 8954, 8977, 8976
10741, 8954, 8955, 8978, 8977
10742, 8955, 8956, 8979, 8978
10743, 8956, 8957, 8980, 8979
10744, 8957, 8958, 8981, 8980
10745, 8958, 8959, 8982, 8981
10746, 8959, 8960, 8983, 8982
10747, 8960, 8961, 8984, 8983
10748, 8961, 1260, 1261, 8984
10749, 1250, 8962, 8985, 1251
10750, 8962, 8963, 8986, 8985
10751, 8963, 8964, 8987, 8986
10752, 8964, 8965, 8988, 8987
10753, 8965, 8966, 8989, 8988
10754, 8966, 8967, 8990, 8989
10755, 8967, 8968, 8991, 8990
10756, 8968, 8969, 8992, 8991
10757, 8969, 8970, 8993, 8992
10758, 8970, 8971, 8994, 8993
10759, 8971, 8972, 8995, 8994
10760, 8972, 8973, 8996, 8995
10761, 8973, 8974, 8997, 8996
10762, 8974, 8975, 8998, 8997
10763, 8975, 8976, 8999, 8998
10764, 8976, 8977, 9000, 8999
10765, 8977, 8978, 9001, 9000
10766, 8978, 8979, 9002, 9001
10767, 8979, 8980, 9003, 9002
10768, 8980, 8981, 9004, 9003
10769, 8981, 8982, 9005, 9004
10770, 8982, 8983, 9006, 9005
10771, 8983, 8984, 9007, 9006
10772, 8984, 1261, 1262, 9007
10773, 1251, 8985, 9008, 1252
10774, 8985, 8986, 9009, 9008
10775, 8986, 8987, 9010, 9009
10776, 8987, 8988, 9011, 9010
10777, 8988, 8989, 9012, 9011
10778, 8989, 8990, 9013, 9012
10779, 8990, 8991, 9014, 9013
10780, 8991, 8992, 9015, 9014
10781, 8992, 8993, 9016, 9015
10782, 8993, 8994, 9017, 9016
10783, 8994, 8995, 9018, 9017
10784, 8995, 8996, 9019, 9018
10785, 8996, 8997, 9020, 9019
10786, 8997, 8998, 9021, 9020
10787, 8998, 8999, 9022, 9021
10788, 8999, 9000, 9023, 9022
10789, 9000, 9001, 9024, 9023
10790, 9001, 9002, 9025, 9024
10791, 9002, 9003, 9026, 9025
10792, 9003, 9004, 9027, 9026
10793, 9004, 9005, 9028, 9027
10794, 9005, 9006, 9029, 9028
10795, 9006, 9007, 9030, 9029
10796, 9007, 1262, 1263, 9030
10797, 1252, 9008, 9031, 1253
10798, 9008, 9009, 9032, 9031
10799, 9009, 9010, 9033, 9032
10800, 9010, 9011, 9034, 9033
10801, 9011, 9012, 9035, 9034
10802, 9012, 9013, 9036, 9035
10803, 9013, 9014, 9037, 9036
10804, 9014, 9015, 9038, 9037
10805, 9015, 9016, 9039, 9038
10806, 9016, 9017, 9040, 9039
10807, 9017, 9018, 9041, 9040
10808, 9018, 9019, 9042, 9041
10809, 9019, 9020, 9043, 9042
10810, 9020, 9021, 9044, 9043
10811, 9021, 9022, 9045, 9044
10812, 9022, 9023, 9046, 9045
10813, 9023, 9024, 9047, 9046
10814, 9024, 9025, 9048, 9047
10815, 9025, 9026, 9049, 9048
10816, 9026, 9027, 9050, 9049
10817, 9027, 9028, 9051, 9050
10818, 9028, 9029, 9052, 9051
10819, 9029, 9030, 9053, 9052
10820, 9030, 1263, 1264, 9053
10821, 1253, 9031, 1197, 57
10822, 9031, 9032, 1198, 1197
10823, 9032, 9033, 1199, 1198
10824, 9033, 9034, 1200, 1199
10825, 9034, 9035, 1201, 1200
10826, 9035, 9036, 1202, 1201
10827, 9036, 9037, 1203, 1202
10828, 9037, 9038, 1204, 1203
10829, 9038, 9039, 1205, 1204
10830, 9039, 9040, 1206, 1205
10831, 9040, 9041, 1207, 1206
10832, 9041, 9042, 1208, 1207
10833, 9042, 9043, 1209, 1208
10834, 9043, 9044, 1210, 1209
10835, 9044, 9045, 1211, 1210
10836, 9045, 9046, 1212, 1211
10837, 9046, 9047, 1213, 1212
10838, 9047, 9048, 1214, 1213
10839, 9048, 9049, 1215, 1214
10840, 9049, 9050, 1216, 1215
10841, 9050, 9051, 1217, 1216
10842, 9051, 9052, 1218, 1217
10843, 9052, 9053, 1219, 1218
10844, 9053, 1264, 58, 1219
*ELEMENT, type=CPS4, ELSET=Surface82
10845, 33, 61, 1265, 841
10846, 841, 1265, 1266, 842
10847, 842, 1266, 1267, 843
10848, 843, 1267, 1268, 844
10849, 844, 1268, 1269, 845
10850, 845, 1269, 1270, 846
10851, 846, 1270, 1271, 847
10852, 847, 1271, 1272, 848
10853, 848, 1272, 1273, 849
10854, 849, 1273, 1274, 850
10855, 850, 1274, 1275, 851
10856, 851, 1275, 1276, 852
10857, 852, 1276, 1277, 853
10858, 853, 1277, 1278, 854
10859, 854, 1278, 1279, 855
10860, 855, 1279, 1280, 856
10861, 856, 1280, 1281, 857
10862, 857, 1281, 1282, 858
10863, 858, 1282, 1283, 859
10864, 859, 1283, 1284, 860
10865, 860, 1284, 1285, 861
10866, 861, 1285, 1286, 862
10867, 862, 1286, 1287, 863
10868, 863, 1287, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
10869, 35, 910, 1288, 63
10870, 910, 911, 1289, 1288
10871, 911, 912, 1290, 1289
10872, 912, 913, 1291, 1290
10873, 913, 914, 1292, 1291
10874, 914, 915, 1293, 1292
10875, 915, 916, 1294, 1293
10876, 916, 917, 1295, 1294
10877, 917, 918, 1296, 1295
10878, 918, 919, 1297, 1296
10879, 919, 920, 1298, 1297
10880, 920, 921, 1299, 1298
10881, 921, 922, 1300, 1299
10882, 922, 923, 1301, 1300
10883, 923, 924, 1302, 1301
10884, 924, 925, 1303, 1302
10885, 925, 926, 1304, 1303
10886, 926, 927, 1305, 1304
10887, 927, 928, 1306, 1305
10888, 928, 929, 1307, 1306
10889, 929, 930, 1308, 1307
10890, 930, 931, 1309, 1308
10891, 931, 932, 1310, 1309
10892, 932, 39, 64, 1310
*ELEMENT, type=CPS4, ELSET=Surface84
10893, 35, 63, 1311, 819
10894, 819, 1311, 1312, 820
10895, 820, 1312, 1313, 821
10896, 821, 1313, 1314, 822
10897, 822, 1314, 1315, 823
10898, 823, 1315, 1316, 824
10899, 824, 1316, 1317, 825
10900, 825, 1317, 1318, 826
10901, 826, 1318, 1319, 827
10902, 827, 1319, 1320, 828
10903, 828, 1320, 1321, 829
10904, 829, 1321, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
10905, 39, 979, 1322, 64
10906, 979, 980, 1323, 1322
10907, 980, 981, 1324, 1323
10908, 981, 982, 1325, 1324
10909, 982, 983, 1326, 1325
10910, 983, 984, 1327, 1326
10911, 984, 985, 1328, 1327
10912, 985, 986, 1329, 1328
10913, 986, 987, 1330, 1329
10914, 987, 988, 1331, 1330
10915, 988, 989, 1332, 1331
10916, 989, 37, 62, 1332
*ELEMENT, type=CPS4, ELSET=Surface86
10917, 63, 1288, 9054, 1311
10918, 1288, 1289, 9055, 9054
10919, 1289, 1290, 9056, 9055
10920, 1290, 1291, 9057, 9056
10921, 1291, 1292, 9058, 9057
10922, 1292, 1293, 9059, 9058
10923, 1293, 1294, 9060, 9059
10924, 1294, 1295, 9061, 9060
10925, 1295, 1296, 9062, 9061
10926, 1296, 1297, 9063, 9062
10927, 1297, 1298, 9064, 9063
10928, 1298, 1299, 9065, 9064
10929, 1299, 1300, 9066, 9065
10930, 1300, 1301, 9067, 9066
10931, 1301, 1302, 9068, 9067
10932, 1302, 1303, 9069, 9068
10933, 1303, 1304, 9070, 9069
10934, 1304, 1305, 9071, 9070
10935, 1305, 1306, 9072, 9071
10936, 1306, 1307, 9073, 9072
10937, 1307, 1308, 9074, 9073
10938, 1308, 1309, 9075, 9074
10939, 1309, 1310, 9076, 9075
10940, 1310, 64, 1322, 9076
10941, 1311, 9054, 9077, 1312
10942, 9054, 9055, 9078, 9077
10943, 9055, 9056, 9079, 9078
10944, 9056, 9057, 9080, 9079
10945, 9057, 9058, 9081, 9080
10946, 9058, 9059, 9082, 9081
10947, 9059, 9060, 9083, 9082
10948, 9060, 9061, 9084, 9083
10949, 9061, 9062, 9085, 9084
10950, 9062, 9063, 9086, 9085
10951, 9063, 9064, 9087, 9086
10952, 9064, 9065, 9088, 9087
10953, 9065, 9066, 9089, 9088
10954, 9066, 9067, 9090, 9089
10955, 9067, 9068, 9091, 9090
10956, 9068, 9069, 9092, 9091
10957, 9069, 9070, 9093, 9092
10958, 9070, 9071, 9094, 9093
10959, 9071, 9072, 9095, 9094
10960, 9072, 9073, 9096, 9095
10961, 9073, 9074, 9097, 9096
10962, 9074, 9075, 9098, 9097
10963, 9075, 9076, 9099, 9098
10964, 9076, 1322, 1323, 9099
10965, 1312, 9077, 9100, 1313
10966, 9077, 9078, 9101, 9100
10967, 9078, 9079, 9102, 9101
10968, 9079, 9080, 9103, 9102
10969, 9080, 9081, 9104, 9103
10970, 9081, 9082, 9105, 9104
10971, 9082, 9083, 9106, 9105
10972, 9083, 9084, 9107, 9106
10973, 9084, 9085, 9108, 9107
10974, 9085, 9086, 9109, 9108
10975, 9086, 9087, 9110, 9109
10976, 9087, 9088, 9111, 9110
10977, 9088, 9089, 9112, 9111
10978, 9089, 9090, 9113, 9112
10979, 9090, 9091, 9114, 9113
10980, 9091, 9092, 9115, 9114
10981, 9092, 9093, 9116, 9115
10982, 9093, 9094, 9117, 9116
10983, 9094, 9095, 9118, 9117
10984, 9095, 9096, 9119, 9118
10985, 9096, 9097, 9120, 9119
10986, 9097, 9098, 9121, 9120
10987, 9098, 9099, 9122, 9121
10988, 9099, 1323, 1324, 9122
10989, 1313, 9100, 9123, 1314
10990, 9100, 9101, 9124, 9123
10991, 9101, 9102, 9125, 9124
10992, 9102, 9103, 9126, 9125
10993, 9103, 9104, 9127, 9126
10994, 9104, 9105, 9128, 9127
10995, 9105, 9106, 9129, 9128
10996, 9106, 9107, 9130, 9129
10997, 9107, 9108, 9131, 9130
10998, 9108, 9109, 9132, 9131
10999, 9109, 9110, 9133, 9132
11000, 9110, 9111, 9134, 9133
11001, 9111, 9112, 9135, 9134
11002, 9112, 9113, 9136, 9135
11003, 9113, 9114, 9137, 9136
11004, 9114, 9115, 9138, 9137
11005, 9115, 9116, 9139, 9138
11006, 9116, 9117, 9140, 9139
11007, 9117, 9118, 9141, 9140
11008, 9118, 9119, 9142, 9141
11009, 9119, 9120, 9143, 9142
11010, 9120, 9121, 9144, 9143
11011, 9121, 9122, 9145, 9144
11012, 9122, 1324, 1325, 9145
11013, 1314, 9123, 9146, 1315
11014, 9123, 9124, 9147, 9146
11015, 9124, 9125, 9148, 9147
11016, 9125, 9126, 9149, 9148
11017, 9126, 9127, 9150, 9149
11018, 9127, 9128, 9151, 9150
11019, 9128, 9129, 9152, 9151
11020, 9129, 9130, 9153, 9152
11021, 9130, 9131, 9154, 9153
11022, 9131, 9132, 9155, 9154
11023, 9132, 9133, 9156, 9155
11024, 9133, 9134, 9157, 9156
11025, 9134, 9135, 9158, 9157
11026, 9135, 9136, 9159, 9158
11027, 9136, 9137, 9160, 9159
11028, 9137, 9138, 9161, 9160
11029, 9138, 9139, 9162, 9161
11030, 9139, 9140, 9163, 9162
11031, 9140, 9141, 9164, 9163
11032, 9141, 9142, 9165, 9164
11033, 9142, 9143, 9166, 9165
11034, 9143, 9144, 9167, 9166
11035, 9144, 9145, 9168, 9167
11036, 9145, 1325, 1326, 9168
11037, 1315, 9146, 9169, 1316
11038, 9146, 9147, 9170, 9169
11039, 9147, 9148, 9171, 9170
11040, 9148, 9149, 9172, 9171
11041, 9149, 9150, 9173, 9172
11042, 9150, 9151, 9174, 9173
11043, 9151, 9152, 9175, 9174
11044, 9152, 9153, 9176, 9175
11045, 9153, 9154, 9177, 9176
11046, 9154, 9155, 9178, 9177
11047, 9155, 9156, 9179, 9178
11048, 9156, 9157, 9180, 9179
11049, 9157, 9158, 9181, 9180
11050, 9158, 9159, 9182, 9181
11051, 9159, 9160, 9183, 9182
11052, 9160, 9161, 9184, 9183
11053, 9161, 9162, 9185, 9184
11054, 9162, 9163, 9186, 9185
11055, 9163, 9164, 9187, 9186
11056, 9164, 9165, 9188, 9187
11057, 9165, 9166, 9189, 9188
11058, 9166, 9167, 9190, 9189
11059, 9167, 9168, 9191, 9190
11060, 9168, 1326, 1327, 9191
11061, 1316, 9169, 9192, 1317
11062, 9169, 9170, 9193, 9192
11063, 9170, 9171, 9194, 9193
11064, 9171, 9172, 9195, 9194
11065, 9172, 9173, 9196, 9195
11066, 9173, 9174, 9197, 9196
11067, 9174, 9175, 9198, 9197
11068, 9175, 9176, 9199, 9198
11069, 9176, 9177, 9200, 9199
11070, 9177, 9178, 9201, 9200
11071, 9178, 9179, 9202, 9201
11072, 9179, 9180, 9203, 9202
11073, 9180, 9181, 9204, 9203
11074, 9181, 9182, 9205, 9204
11075, 9182, 9183, 9206, 9205
11076, 9183, 9184, 9207, 9206
11077, 9184, 9185, 9208, 9207
11078, 9185, 9186, 9209, 9208
11079, 9186, 9187, 9210, 9209
11080, 9187, 9188, 9211, 9210
11081, 9188, 9189, 9212, 9211
11082, 9189, 9190, 9213, 9212
11083, 9190, 9191, 9214, 9213
11084, 9191, 1327, 1328, 9214
11085, 1317, 9192, 9215, 1318
11086, 9192, 9193, 9216, 9215
11087, 9193, 9194, 9217, 9216
11088, 9194, 9195, 9218, 9217
11089, 9195, 9196, 9219, 9218
11090, 9196, 9197, 9220, 9219
11091, 9197, 9198, 9221, 9220
11092, 9198, 9199, 9222, 9221
11093, 9199, 9200, 9223, 9222
11094, 9200, 9201, 9224, 9223
11095, 9201, 9202, 9225, 9224
11096, 9202, 9203, 9226, 9225
11097, 9203, 9204, 9227, 9226
11098, 9204, 9205, 9228, 9227
11099, 9205, 9206, 9229, 9228
11100, 9206, 9207, 9230, 9229
11101, 9207, 9208, 9231, 9230
11102, 9208, 9209, 9232, 9231
11103, 9209, 9210, 9233, 9232
11104, 9210, 9211, 9234, 9233
11105, 9211, 9212, 9235, 9234
11106, 9212, 9213, 9236, 9235
11107, 9213, 9214, 9237, 9236
11108, 9214, 1328, 1329, 9237
11109, 1318, 9215, 9238, 1319
11110, 9215, 9216, 9239, 9238
11111, 9216, 9217, 9240, 9239
11112, 9217, 9218, 9241, 9240
11113, 9218, 9219, 9242, 9241
11114, 9219, 9220, 9243, 9242
11115, 9220, 9221, 9244, 9243
11116, 9221, 9222, 9245, 9244
11117, 9222, 9223, 9246, 9245
11118, 9223, 9224, 9247, 9246
11119, 9224, 9225, 9248, 9247
11120, 9225, 9226, 9249, 9248
11121, 9226, 9227, 9250, 9249
11122, 9227, 9228, 9251, 9250
11123, 9228, 9229, 9252, 9251
11124, 9229, 9230, 9253, 9252
11125, 9230, 9231, 9254, 9253
11126, 9231, 9232, 9255, 9254
11127, 9232, 9233, 9256, 9255
11128, 9233, 9234, 9257, 9256
11129, 9234, 9235, 9258, 9257
11130, 9235, 9236, 9259, 9258
11131, 9236, 9237, 9260, 9259
11132, 9237, 1329, 1330, 9260
11133, 1319, 9238, 9261, 1320
11134, 9238, 9239, 9262, 9261
11135, 9239, 9240, 9263, 9262
11136, 9240, 9241, 9264, 9263
11137, 9241, 9242, 9265, 9264
11138, 9242, 9243, 9266, 9265
11139, 9243, 9244, 9267, 9266
11140, 9244, 9245, 9268, 9267
11141, 9245, 9246, 9269, 9268
11142, 9246, 9247, 9270, 9269
11143, 9247, 9248, 9271, 9270
11144, 9248, 9249, 9272, 9271
11145, 9249, 9250, 9273, 9272
11146, 9250, 9251, 9274, 9273
11147, 9251, 9252, 9275, 9274
11148, 9252, 9253, 9276, 9275
11149, 9253, 9254, 9277, 9276
11150, 9254, 9255, 9278, 9277
11151, 9255, 9256, 9279, 9278
11152, 9256, 9257, 9280, 9279
11153, 9257, 9258, 9281, 9280
11154, 9258, 9259, 9282, 9281
11155, 9259, 9260, 9283, 9282
11156, 9260, 1330, 1331, 9283
11157, 1320, 9261, 9284, 1321
11158, 9261, 9262, 9285, 9284
11159, 9262, 9263, 9286, 9285
11160, 9263, 9264, 9287, 9286
11161, 9264, 9265, 9288, 9287
11162, 9265, 9266, 9289, 9288
11163, 9266, 9267, 9290, 9289
11164, 9267, 9268, 9291, 9290
11165, 9268, 9269, 9292, 9291
11166, 9269, 9270, 9293, 9292
11167, 9270, 9271, 9294, 9293
11168, 9271, 9272, 9295, 9294
11169, 9272, 9273, 9296, 9295
11170, 9273, 9274, 9297, 9296
11171, 9274, 9275, 9298, 9297
11172, 9275, 9276, 9299, 9298
11173, 9276, 9277, 9300, 9299
11174, 9277, 9278, 9301, 9300
11175, 9278, 9279, 9302, 9301
11176, 9279, 9280, 9303, 9302
11177, 9280, 9281, 9304, 9303
11178, 9281, 9282, 9305, 9304
11179, 9282, 9283, 9306, 9305
11180, 9283, 1331, 1332, 9306
11181, 1321, 9284, 1265, 61
11182, 9284, 9285, 1266, 1265
11183, 9285, 9286, 1267, 1266
11184, 9286, 9287, 1268, 1267
11185, 9287, 9288, 1269, 1268
11186, 9288, 9289, 1270, 1269
11187, 9289, 9290, 1271, 1270
11188, 9290, 9291, 1272, 1271
11189, 9291, 9292, 1273, 1272
11190, 9292, 9293, 1274, 1273
11191, 9293, 9294, 1275, 1274
11192, 9294, 9295, 1276, 1275
11193, 9295, 9296, 1277, 1276
11194, 9296, 9297, 1278, 1277
11195, 9297, 9298, 1279, 1278
11196, 9298, 9299, 1280, 1279
11197, 9299, 9300, 1281, 1280
11198, 9300, 9301, 1282, 1281
11199, 9301, 9302, 1283, 1282
11200, 9302, 9303, 1284, 1283
11201, 9303, 9304, 1285, 1284
11202, 9304, 9305, 1286, 1285
11203, 9305, 9306, 1287, 1286
11204, 9306, 1332, 62, 1287
*ELEMENT, type=CPS4, ELSET=Surface87
11205, 9, 65, 1333, 309
11206, 309, 1333, 1334, 310
11207, 310, 1334, 1335, 311
11208, 311, 1335, 1336, 312
11209, 312, 1336, 1337, 313
11210, 313, 1337, 1338, 314
11211, 314, 1338, 1339, 315
11212, 315, 1339, 1340, 316
11213, 316, 1340, 1341, 317
11214, 317, 1341, 1342, 318
11215, 318, 1342, 1343, 319
11216, 319, 1343, 1344, 320
11217, 320, 1344, 1345, 321
11218, 321, 1345, 1346, 322
11219, 322, 1346, 1347, 323
11220, 323, 1347, 1348, 324
11221, 324, 1348, 1349, 325
11222, 325, 1349, 1350, 326
11223, 326, 1350, 1351, 327
11224, 327, 1351, 1352, 328
11225, 328, 1352, 1353, 329
11226, 329, 1353, 1354, 330
11227, 330, 1354, 1355, 331
11228, 331, 1355, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
11229, 10, 332, 1356, 67
11230, 332, 333, 1357, 1356
11231, 333, 334, 1358, 1357
11232, 334, 335, 1359, 1358
11233, 335, 336, 1360, 1359
11234, 336, 337, 1361, 1360
11235, 337, 338, 1362, 1361
11236, 338, 339, 1363, 1362
11237, 339, 340, 1364, 1363
11238, 340, 341, 1365, 1364
11239, 341, 342, 1366, 1365
11240, 342, 343, 1367, 1366
11241, 343, 344, 1368, 1367
11242, 344, 345, 1369, 1368
11243, 345, 346, 1370, 1369
11244, 346, 347, 1371, 1370
11245, 347, 348, 1372, 1371
11246, 348, 349, 1373, 1372
11247, 349, 350, 1374, 1373
11248, 350, 351, 1375, 1374
11249, 351, 352, 1376, 1375
11250, 352, 353, 1377, 1376
11251, 353, 354, 1378, 1377
11252, 354, 14, 68, 1378
*ELEMENT, type=CPS4, ELSET=Surface89
11253, 10, 67, 1379, 241
11254, 241, 1379, 1380, 242
11255, 242, 1380, 1381, 243
11256, 243, 1381, 1382, 244
11257, 244, 1382, 1383, 245
11258, 245, 1383, 1384, 246
11259, 246, 1384, 1385, 247
11260, 247, 1385, 1386, 248
11261, 248, 1386, 1387, 249
11262, 249, 1387, 1388, 250
11263, 250, 1388, 1389, 251
11264, 251, 1389, 1390, 252
11265, 252, 1390, 1391, 253
11266, 253, 1391, 1392, 254
11267, 254, 1392, 1393, 255
11268, 255, 1393, 1394, 256
11269, 256, 1394, 1395, 257
11270, 257, 1395, 1396, 258
11271, 258, 1396, 1397, 259
11272, 259, 1397, 1398, 260
11273, 260, 1398, 1399, 261
11274, 261, 1399, 1400, 262
11275, 262, 1400, 1401, 263
11276, 263, 1401, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
11277, 14, 355, 1402, 68
11278, 355, 356, 1403, 1402
11279, 356, 357, 1404, 1403
11280, 357, 358, 1405, 1404
11281, 358, 359, 1406, 1405
11282, 359, 360, 1407, 1406
11283, 360, 361, 1408, 1407
11284, 361, 362, 1409, 1408
11285, 362, 363, 1410, 1409
11286, 363, 364, 1411, 1410
11287, 364, 365, 1412, 1411
11288, 365, 366, 1413, 1412
11289, 366, 367, 1414, 1413
11290, 367, 368, 1415, 1414
11291, 368, 369, 1416, 1415
11292, 369, 370, 1417, 1416
11293, 370, 371, 1418, 1417
11294, 371, 372, 1419, 1418
11295, 372, 373, 1420, 1419
11296, 373, 374, 1421, 1420
11297, 374, 375, 1422, 1421
11298, 375, 376, 1423, 1422
11299, 376, 377, 1424, 1423
11300, 377, 13, 66, 1424
*ELEMENT, type=CPS4, ELSET=Surface91
11301, 67, 1356, 9307, 1379
11302, 1356, 1357, 9308, 9307
11303, 1357, 1358, 9309, 9308
11304, 1358, 1359, 9310, 9309
11305, 1359, 1360, 9311, 9310
11306, 1360, 1361, 9312, 9311
11307, 1361, 1362, 9313, 9312
11308, 1362, 1363, 9314, 9313
11309, 1363, 1364, 9315, 9314
11310, 1364, 1365, 9316, 9315
11311, 1365, 1366, 9317, 9316
11312, 1366, 1367, 9318, 9317
11313, 1367, 1368, 9319, 9318
11314, 1368, 1369, 9320, 9319
11315, 1369, 1370, 9321, 9320
11316, 1370, 1371, 9322, 9321
11317, 1371, 1372, 9323, 9322
11318, 1372, 1373, 9324, 9323
11319, 1373, 1374, 9325, 9324
11320, 1374, 1375, 9326, 9325
11321, 1375, 1376, 9327, 9326
11322, 1376, 1377, 9328, 9327
11323, 1377, 1378, 9329, 9328
11324, 1378, 68, 1402, 9329
11325, 1379, 9307, 9330, 1380
11326, 9307, 9308, 9331, 9330
11327, 9308, 9309, 9332, 9331
11328, 9309, 9310, 9333, 9332
11329, 9310, 9311, 9334, 9333
11330, 9311, 9312, 9335, 9334
11331, 9312, 9313, 9336, 9335
11332, 9313, 9314, 9337, 9336
11333, 9314, 9315, 9338, 9337
11334, 9315, 9316, 9339, 9338
11335, 9316, 9317, 9340, 9339
11336, 9317, 9318, 9341, 9340
11337, 9318, 9319, 9342, 9341
11338, 9319, 9320, 9343, 9342
11339, 9320, 9321, 9344, 9343
11340, 9321, 9322, 9345, 9344
11341, 9322, 9323, 9346, 9345
11342, 9323, 9324, 9347, 9346
11343, 9324, 9325, 9348, 9347
11344, 9325, 9326, 9349, 9348
11345, 9326, 9327, 9350, 9349
11346, 9327, 9328, 9351, 9350
11347, 9328, 9329, 9352, 9351
11348, 9329, 1402, 1403, 9352
11349, 1380, 9330, 9353, 1381
11350, 9330, 9331, 9354, 9353
11351, 9331, 9332, 9355, 9354
11352, 9332, 9333, 9356, 9355
11353, 9333, 9334, 9357, 9356
11354, 9334, 9335, 9358, 9357
11355, 9335, 9336, 9359, 9358
11356, 9336, 9337, 9360, 9359
11357, 9337, 9338, 9361, 9360
11358, 9338, 9339, 9362, 9361
11359, 9339, 9340, 9363, 9362
11360, 9340, 9341, 9364, 9363
11361, 9341, 9342, 9365, 9364
11362, 9342, 9343, 9366, 9365
11363, 9343, 9344, 9367, 9366
11364, 9344, 9345, 9368, 9367
11365, 9345, 9346, 9369, 9368
11366, 9346, 9347, 9370, 9369
11367, 9347, 9348, 9371, 9370
11368, 9348, 9349, 9372, 9371
11369, 9349, 9350, 9373, 9372
11370, 9350, 9351, 9374, 9373
11371, 9351, 9352, 9375, 9374
11372, 9352, 1403, 1404, 9375
11373, 1381, 9353, 9376, 1382
11374, 9353, 9354, 9377, 9376
11375, 9354, 9355, 9378, 9377
11376, 9355, 9356, 9379, 9378
11377, 9356, 9357, 9380, 9379
11378, 9357, 9358, 9381, 9380
11379, 9358, 9359, 9382, 9381
11380, 9359, 9360, 9383, 9382
11381, 9360, 9361, 9384, 9383
11382, 9361, 9362, 9385, 9384
11383, 9362, 9363, 9386, 9385
11384, 9363, 9364, 9387, 9386
11385, 9364, 9365, 9388, 9387
11386, 9365, 9366, 9389, 9388
11387, 9366, 9367, 9390, 9389
11388, 9367, 9368, 9391, 9390
11389, 9368, 9369, 9392, 9391
11390, 9369, 9370, 9393, 9392
11391, 9370, 9371, 9394, 9393
11392, 9371, 9372, 9395, 9394
11393, 9372, 9373, 9396, 9395
11394, 9373, 9374, 9397, 9396
11395, 9374, 9375, 9398, 9397
11396, 9375, 1404, 1405, 9398
11397, 1382, 9376, 9399, 1383
11398, 9376, 9377, 9400, 9399
11399, 9377, 9378, 9401, 9400
11400, 9378, 9379, 9402, 9401
11401, 9379, 9380, 9403, 9402
11402, 9380, 9381, 9404, 9403
11403, 9381, 9382, 9405, 9404
11404, 9382, 9383, 9406, 9405
11405, 9383, 9384, 9407, 9406
11406, 9384, 9385, 9408, 9407
11407, 9385, 9386, 9409, 9408
11408, 9386, 9387, 9410, 9409
11409, 9387, 9388, 9411, 9410
11410, 9388, 9389, 9412, 9411
11411, 9389, 9390, 9413, 9412
11412, 9390, 9391, 9414, 9413
11413, 9391, 9392, 9415, 9414
11414, 9392, 9393, 9416, 9415
11415, 9393, 9394, 9417, 9416
11416, 9394, 9395, 9418, 9417
11417, 9395, 9396, 9419, 9418
11418, 9396, 9397, 9420, 9419
11419, 9397, 9398, 9421, 9420
11420, 9398, 1405, 1406, 9421
11421, 1383, 9399, 9422, 1384
11422, 9399, 9400, 9423, 9422
11423, 9400, 9401, 9424, 9423
11424, 9401, 9402, 9425, 9424
11425, 9402, 9403, 9426, 9425
11426, 9403, 9404, 9427, 9426
11427, 9404, 9405, 9428, 9427
11428, 9405, 9406, 9429, 9428
11429, 9406, 9407, 9430, 9429
11430, 9407, 9408, 9431, 9430
11431, 9408, 9409, 9432, 9431
11432, 9409, 9410, 9433, 9432
11433, 9410, 9411, 9434, 9433
11434, 9411, 9412, 9435, 9434
11435, 9412, 9413, 9436, 9435
11436, 9413, 9414, 9437, 9436
11437, 9414, 9415, 9438, 9437
11438, 9415, 9416, 9439, 9438
11439, 9416, 9417, 9440, 9439
11440, 9417, 9418, 9441, 9440
11441, 9418, 9419, 9442, 9441
11442, 9419, 9420, 9443, 9442
11443, 9420, 9421, 9444, 9443
11444, 9421, 1406, 1407, 9444
11445, 1384, 9422, 9445, 1385
11446, 9422, 9423, 9446, 9445
11447, 9423, 9424, 9447, 9446
11448, 9424, 9425, 9448, 9447
11449, 9425, 9426, 9449, 9448
11450, 9426, 9427, 9450, 9449
11451, 9427, 9428, 9451, 9450
11452, 9428, 9429, 9452, 9451
11453, 9429, 9430, 9453, 9452
11454, 9430, 9431, 9454, 9453
11455, 9431, 9432, 9455, 9454
11456, 9432, 9433, 9456, 9455
11457, 9433, 9434, 9457, 9456
11458, 9434, 9435, 9458, 9457
11459, 9435, 9436, 9459, 9458
11460, 9436, 9437, 9460, 9459
11461, 9437, 9438, 9461, 9460
11462, 9438, 9439, 9462, 9461
11463, 9439, 9440, 9463, 9462
11464, 9440, 9441, 9464, 9463
11465, 9441, 9442, 9465, 9464
11466, 9442, 9443, 9466, 9465
11467, 9443, 9444, 9467, 9466
11468, 9444, 1407, 1408, 9467
11469, 1385, 9445, 9468, 1386
11470, 9445, 9446, 9469, 9468
11471, 9446, 9447, 9470, 9469
11472, 9447, 9448, 9471, 9470
11473, 9448, 9449, 9472, 9471
11474, 9449, 9450, 9473, 9472
11475, 9450, 9451, 9474, 9473
11476, 9451, 9452, 9475, 9474
11477, 9452, 9453, 9476, 9475
11478, 9453, 9454, 9477, 9476
11479, 9454, 9455, 9478, 9477
11480, 9455, 9456, 9479, 9478
11481, 9456, 9457, 9480, 9479
11482, 9457, 9458, 9481, 9480
11483, 9458, 9459, 9482, 9481
11484, 9459, 9460, 9483, 9482
11485, 9460, 9461, 9484, 9483
11486, 9461, 9462, 9485, 9484
11487, 9462, 9463, 9486, 9485
11488, 9463, 9464, 9487, 9486
11489, 9464, 9465, 9488, 9487
11490, 9465, 9466, 9489, 9488
11491, 9466, 9467, 9490, 9489
11492, 9467, 1408, 1409, 9490
11493, 1386, 9468, 9491, 1387
11494, 9468, 9469, 9492, 9491
11495, 9469, 9470, 9493, 9492
11496, 9470, 9471, 9494, 9493
11497, 9471, 9472, 9495, 9494
11498, 9472, 9473, 9496, 9495
11499, 9473, 9474, 9497, 9496
11500, 9474, 9475, 9498, 9497
11501, 9475, 9476, 9499, 9498
11502, 9476, 9477, 9500, 9499
11503, 9477, 9478, 9501, 9500
11504, 9478, 9479, 9502, 9501
11505, 9479, 9480, 9503, 9502
11506, 9480, 9481, 9504, 9503
11507, 9481, 9482, 9505, 9504
11508, 9482, 9483, 9506, 9505
11509, 9483, 9484, 9507, 9506
11510, 9484, 9485, 9508, 9507
11511, 9485, 9486, 9509, 9508
11512, 9486, 9487, 9510, 9509
11513, 9487, 9488, 9511, 9510
11514, 9488, 9489, 9512, 9511
11515, 9489, 9490, 9513, 9512
11516, 9490, 1409, 1410, 9513
11517, 1387, 9491, 9514, 1388
11518, 9491, 9492, 9515, 9514
11519, 9492, 9493, 9516, 9515
11520, 9493, 9494, 9517, 9516
11521, 9494, 9495, 9518, 9517
11522, 9495, 9496, 9519, 9518
11523, 9496, 9497, 9520, 9519
11524, 9497, 9498, 9521, 9520
11525, 9498, 9499, 9522, 9521
11526, 9499, 9500, 9523, 9522
11527, 9500, 9501, 9524, 9523
11528, 9501, 9502, 9525, 9524
11529, 9502, 9503, 9526, 9525
11530, 9503, 9504, 9527, 9526
11531, 9504, 9505, 9528, 9527
11532, 9505, 9506, 9529, 9528
11533, 9506, 9507, 9530, 9529
11534, 9507, 9508, 9531, 9530
11535, 9508, 9509, 9532, 9531
11536, 9509, 9510, 9533, 9532
11537, 9510, 9511, 9534, 9533
11538, 9511, 9512, 9535, 9534
11539, 9512, 9513, 9536, 9535
11540, 9513, 1410, 1411, 9536
11541, 1388, 9514, 9537, 1389
11542, 9514, 9515, 9538, 9537
11543, 9515, 9516, 9539, 9538
11544, 9516, 9517, 9540, 9539
11545, 9517, 9518, 9541, 9540
11546, 9518, 9519, 9542, 9541
11547, 9519, 9520, 9543, 9542
11548, 9520, 9521, 9544, 9543
11549, 9521, 9522, 9545, 9544
11550, 9522, 9523, 9546, 9545
11551, 9523, 9524, 9547, 9546
11552, 9524, 9525, 9548, 9547
11553, 9525, 9526, 9549, 9548
11554, 9526, 9527, 9550, 9549
11555, 9527, 9528, 9551, 9550
11556, 9528, 9529, 9552, 9551
11557, 9529, 9530, 9553, 9552
11558, 9530, 9531, 9554, 9553
11559, 9531, 9532, 9555, 9554
11560, 9532, 9533, 9556, 9555
11561, 9533, 9534, 9557, 9556
11562, 9534, 9535, 9558, 9557
11563, 9535, 9536, 9559, 9558
11564, 9536, 1411, 1412, 9559
11565, 1389, 9537, 9560, 1390
11566, 9537, 9538, 9561, 9560
11567, 9538, 9539, 9562, 9561
11568, 9539, 9540, 9563, 9562
11569, 9540, 9541, 9564, 9563
11570, 9541, 9542, 9565, 9564
11571, 9542, 9543, 9566, 9565
11572, 9543, 9544, 9567, 9566
11573, 9544, 9545, 9568, 9567
11574, 9545, 9546, 9569, 9568
11575, 9546, 9547, 9570, 9569
11576, 9547, 9548, 9571, 9570
11577, 9548, 9549, 9572, 9571
11578, 9549, 9550, 9573, 9572
11579, 9550, 9551, 9574, 9573
11580, 9551, 9552, 9575, 9574
11581, 9552, 9553, 9576, 9575
11582, 9553, 9554, 9577, 9576
11583, 9554, 9555, 9578, 9577
11584, 9555, 9556, 9579, 9578
11585, 9556, 9557, 9580, 9579
11586, 9557, 9558, 9581, 9580
11587, 9558, 9559, 9582, 9581
11588, 9559, 1412, 1413, 9582
11589, 1390, 9560, 9583, 1391
11590, 9560, 9561, 9584, 9583
11591, 9561, 9562, 9585, 9584
11592, 9562, 9563, 9586, 9585
11593, 9563, 9564, 9587, 9586
11594, 9564, 9565, 9588, 9587
11595, 9565, 9566, 9589, 9588
11596, 9566, 9567, 9590, 9589
11597, 9567, 9568, 9591, 9590
11598, 9568, 9569, 9592, 9591
11599, 9569, 9570, 9593, 9592
11600, 9570, 9571, 9594, 9593
11601, 9571, 9572, 9595, 9594
11602, 9572, 9573, 9596, 9595
11603, 9573, 9574, 9597, 9596
11604, 9574, 9575, 9598, 9597
11605, 9575, 9576, 9599, 9598
11606, 9576, 9577, 9600, 9599
11607, 9577, 9578, 9601, 9600
11608, 9578, 9579, 9602, 9601
11609, 9579, 9580, 9603, 9602
11610, 9580, 9581, 9604, 9603
11611, 9581, 9582, 9605, 9604
11612, 9582, 1413, 1414, 9605
11613, 1391, 9583, 9606, 1392
11614, 9583, 9584, 9607, 9606
11615, 9584, 9585, 9608, 9607
11616, 9585, 9586, 9609, 9608
11617, 9586, 9587, 9610, 9609
11618, 9587, 9588, 9611, 9610
11619, 9588, 9589, 9612, 9611
11620, 9589, 9590, 9613, 9612
11621, 9590, 9591, 9614, 9613
11622, 9591, 9592, 9615, 9614
11623, 9592, 9593, 9616, 9615
11624, 9593, 9594, 9617, 9616
11625, 9594, 9595, 9618, 9617
11626, 9595, 9596, 9619, 9618
11627, 9596, 9597, 9620, 9619
11628, 9597, 9598, 9621, 9620
11629, 9598, 9599, 9622, 9621
11630, 9599, 9600, 9623, 9622
11631, 9600, 9601, 9624, 9623
11632, 9601, 9602, 9625, 9624
11633, 9602, 9603, 9626, 9625
11634, 9603, 9604, 9627, 9626
11635, 9604, 9605, 9628, 9627
11636, 9605, 1414, 1415, 9628
11637, 1392, 9606, 9629, 1393
11638, 9606, 9607, 9630, 9629
11639, 9607, 9608, 9631, 9630
11640, 9608, 9609, 9632, 9631
11641, 9609, 9610, 9633, 9632
11642, 9610, 9611, 9634, 9633
11643, 9611, 9612, 9635, 9634
11644, 9612, 9613, 9636, 9635
11645, 9613, 9614, 9637, 9636
11646, 9614, 9615, 9638, 9637
11647, 9615, 9616, 9639, 9638
11648, 9616, 9617, 9640, 9639
11649, 9617, 9618, 9641, 9640
11650, 9618, 9619, 9642, 9641
11651, 9619, 9620, 9643, 9642
11652, 9620, 9621, 9644, 9643
11653, 9621, 9622, 9645, 9644
11654, 9622, 9623, 9646, 9645
11655, 9623, 9624, 9647, 9646
11656, 9624, 9625, 9648, 9647
11657, 9625, 9626, 9649, 9648
11658, 9626, 9627, 9650, 9649
11659, 9627, 9628, 9651, 9650
11660, 9628, 1415, 1416, 9651
11661, 1393, 9629, 9652, 1394
11662, 9629, 9630, 9653, 9652
11663, 9630, 9631, 9654, 9653
11664, 9631, 9632, 9655, 9654
11665, 9632, 9633, 9656, 9655
11666, 9633, 9634, 9657, 9656
11667, 9634, 9635, 9658, 9657
11668, 9635, 9636, 9659, 9658
11669, 9636, 9637, 9660, 9659
11670, 9637, 9638, 9661, 9660
11671, 9638, 9639, 9662, 9661
11672, 9639, 9640, 9663, 9662
11673, 9640, 9641, 9664, 9663
11674, 9641, 9642, 9665, 9664
11675, 9642, 9643, 9666, 9665
11676, 9643, 9644, 9667, 9666
11677, 9644, 9645, 9668, 9667
11678, 9645, 9646, 9669, 9668
11679, 9646, 9647, 9670, 9669
11680, 9647, 9648, 9671, 9670
11681, 9648, 9649, 9672, 9671
11682, 9649, 9650, 9673, 9672
11683, 9650, 9651, 9674, 9673
11684, 9651, 1416, 1417, 9674
11685, 1394, 9652, 9675, 1395
11686, 9652, 9653, 9676, 9675
11687, 9653, 9654, 9677, 9676
11688, 9654, 9655, 9678, 9677
11689, 9655, 9656, 9679, 9678
11690, 9656, 9657, 9680, 9679
11691, 9657, 9658, 9681, 9680
11692, 9658, 9659, 9682, 9681
11693, 9659, 9660, 9683, 9682
11694, 9660, 9661, 9684, 9683
11695, 9661, 9662, 9685, 9684
11696, 9662, 9663, 9686, 9685
11697, 9663, 9664, 9687, 9686
11698, 9664, 9665, 9688, 9687
11699, 9665, 9666, 9689, 9688
11700, 9666, 9667, 9690, 9689
11701, 9667, 9668, 9691, 9690
11702, 9668, 9669, 9692, 9691
11703, 9669, 9670, 9693, 9692
11704, 9670, 9671, 9694, 9693
11705, 9671, 9672, 9695, 9694
11706, 9672, 9673, 9696, 9695
11707, 9673, 9674, 9697, 9696
11708, 9674, 1417, 1418, 9697
11709, 1395, 9675, 9698, 1396
11710, 9675, 9676, 9699, 9698
11711, 9676, 9677, 9700, 9699
11712, 9677, 9678, 9701, 9700
11713, 9678, 9679, 9702, 9701
11714, 9679, 9680, 9703, 9702
11715, 9680, 9681, 9704, 9703
11716, 9681, 9682, 9705, 9704
11717, 9682, 9683, 9706, 9705
11718, 9683, 9684, 9707, 9706
11719, 9684, 9685, 9708, 9707
11720, 9685, 9686, 9709, 9708
11721, 9686, 9687, 9710, 9709
11722, 9687, 9688, 9711, 9710
11723, 9688, 9689, 9712, 9711
11724, 9689, 9690, 9713, 9712
11725, 9690, 9691, 9714, 9713
11726, 9691, 9692, 9715, 9714
11727, 9692, 9693, 9716, 9715
11728, 9693, 9694, 9717, 9716
11729, 9694, 9695, 9718, 9717
11730, 9695, 9696, 9719, 9718
11731, 9696, 9697, 9720, 9719
11732, 9697, 1418, 1419, 9720
11733, 1396, 9698, 9721, 1397
11734, 9698, 9699, 9722, 9721
11735, 9699, 9700, 9723, 9722
11736, 9700, 9701, 9724, 9723
11737, 9701, 9702, 9725, 9724
11738, 9702, 9703, 9726, 9725
11739, 9703, 9704, 9727, 9726
11740, 9704, 9705, 9728, 9727
11741, 9705, 9706, 9729, 9728
11742, 9706, 9707, 9730, 9729
11743, 9707, 9708, 9731, 9730
11744, 9708, 9709, 9732, 9731
11745, 9709, 9710, 9733, 9732
11746, 9710, 9711, 9734, 9733
11747, 9711, 9712, 9735, 9734
11748, 9712, 9713, 9736, 9735
11749, 9713, 9714, 9737, 9736
11750, 9714, 9715, 9738, 9737
11751, 9715, 9716, 9739, 9738
11752, 9716, 9717, 9740, 9739
11753, 9717, 9718, 9741, 9740
11754, 9718, 9719, 9742, 9741
11755, 9719, 9720, 9743, 9742
11756, 9720, 1419, 1420, 9743
11757, 1397, 9721, 9744, 1398
11758, 9721, 9722, 9745, 9744
11759, 9722, 9723, 9746, 9745
11760, 9723, 9724, 9747, 9746
11761, 9724, 9725, 9748, 9747
11762, 9725, 9726, 9749, 9748
11763, 9726, 9727, 9750, 9749
11764, 9727, 9728, 9751, 9750
11765, 9728, 9729, 9752, 9751
11766, 9729, 9730, 9753, 9752
11767, 9730, 9731, 9754, 9753
11768, 9731, 9732, 9755, 9754
11769, 9732, 9733, 9756, 9755
11770, 9733, 9734, 9757, 9756
11771, 9734, 9735, 9758, 9757
11772, 9735, 9736, 9759, 9758
11773, 9736, 9737, 9760, 9759
11774, 9737, 9738, 9761, 9760
11775, 9738, 9739, 9762, 9761
11776, 9739, 9740, 9763, 9762
11777, 9740, 9741, 9764, 9763
11778, 9741, 9742, 9765, 9764
11779, 9742, 9743, 9766, 9765
11780, 9743, 1420, 1421, 9766
11781, 1398, 9744, 9767, 1399
11782, 9744, 9745, 9768, 9767
11783, 9745, 9746, 9769, 9768
11784, 9746, 9747, 9770, 9769
11785, 9747, 9748, 9771, 9770
11786, 9748, 9749, 9772, 9771
11787, 9749, 9750, 9773, 9772
11788, 9750, 9751, 9774, 9773
11789, 9751, 9752, 9775, 9774
11790, 9752, 9753, 9776, 9775
11791, 9753, 9754, 9777, 9776
11792, 9754, 9755, 9778, 9777
11793, 9755, 9756, 9779, 9778
11794, 9756, 9757, 9780, 9779
11795, 9757, 9758, 9781, 9780
11796, 9758, 9759, 9782, 9781
11797, 9759, 9760, 9783, 9782
11798, 9760, 9761, 9784, 9783
11799, 9761, 9762, 9785, 9784
11800, 9762, 9763, 9786, 9785
11801, 9763, 9764, 9787, 9786
11802, 9764, 9765, 9788, 9787
11803, 9765, 9766, 9789, 9788
11804, 9766, 1421, 1422, 9789
11805, 1399, 9767, 9790, 1400
11806, 9767, 9768, 9791, 9790
11807, 9768, 9769, 9792, 9791
11808, 9769, 9770, 9793, 9792
11809, 9770, 9771, 9794, 9793
11810, 9771, 9772, 9795, 9794
11811, 9772, 9773, 9796, 9795
11812, 9773, 9774, 9797, 9796
11813, 9774, 9775, 9798, 9797
11814, 9775, 9776, 9799, 9798
11815, 9776, 9777, 9800, 9799
11816, 9777, 9778, 9801, 9800
11817, 9778, 9779, 9802, 9801
11818, 9779, 9780, 9803, 9802
11819, 9780, 9781, 9804, 9803
11820, 9781, 9782, 9805, 9804
11821, 9782, 9783, 9806, 9805
11822, 9783, 9784, 9807, 9806
11823, 9784, 9785, 9808, 9807
11824, 9785, 9786, 9809, 9808
11825, 9786, 9787, 9810, 9809
11826, 9787, 9788, 9811, 9810
11827, 9788, 9789, 9812, 9811
11828, 9789, 1422, 1423, 9812
11829, 1400, 9790, 9813, 1401
11830, 9790, 9791, 9814, 9813
11831, 9791, 9792, 9815, 9814
11832, 9792, 9793, 9816, 9815
11833, 9793, 9794, 9817, 9816
11834, 9794, 9795, 9818, 9817
11835, 9795, 9796, 9819, 9818
11836, 9796, 9797, 9820, 9819
11837, 9797, 9798, 9821, 9820
11838, 9798, 9799, 9822, 9821
11839, 9799, 9800, 9823, 9822
11840, 9800, 9801, 9824, 9823
11841, 9801, 9802, 9825, 9824
