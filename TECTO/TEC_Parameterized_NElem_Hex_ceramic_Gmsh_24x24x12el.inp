40321, 29387, 29431, 29435, 29391, 29388, 29432, 29436, 29392
40322, 29388, 29432, 29436, 29392, 29389, 29433, 29437, 29393
40323, 29389, 29433, 29437, 29393, 29390, 29434, 29438, 29394
40324, 29390, 29434, 29438, 29394, 11965, 11976, 11977, 11966
40325, 2192, 2203, 2204, 2193, 29391, 29435, 29439, 29395
40326, 29391, 29435, 29439, 29395, 29392, 29436, 29440, 29396
40327, 29392, 29436, 29440, 29396, 29393, 29437, 29441, 29397
40328, 29393, 29437, 29441, 29397, 29394, 29438, 29442, 29398
40329, 29394, 29438, 29442, 29398, 11966, 11977, 11978, 11967
40330, 2193, 2204, 2205, 2194, 29395, 29439, 29443, 29399
40331, 29395, 29439, 29443, 29399, 29396, 29440, 29444, 29400
40332, 29396, 29440, 29444, 29400, 29397, 29441, 29445, 29401
40333, 29397, 29441, 29445, 29401, 29398, 29442, 29446, 29402
40334, 29398, 29442, 29446, 29402, 11967, 11978, 11979, 11968
40335, 2194, 2205, 2206, 2195, 29399, 29443, 29447, 29403
40336, 29399, 29443, 29447, 29403, 29400, 29444, 29448, 29404
40337, 29400, 29444, 29448, 29404, 29401, 29445, 29449, 29405
40338, 29401, 29445, 29449, 29405, 29402, 29446, 29450, 29406
40339, 29402, 29446, 29450, 29406, 11968, 11979, 11980, 11969
40340, 2195, 2206, 2207, 2196, 29403, 29447, 29451, 29407
40341, 29403, 29447, 29451, 29407, 29404, 29448, 29452, 29408
40342, 29404, 29448, 29452, 29408, 29405, 29449, 29453, 29409
40343, 29405, 29449, 29453, 29409, 29406, 29450, 29454, 29410
40344, 29406, 29450, 29454, 29410, 11969, 11980, 11981, 11970
40345, 2196, 2207, 2208, 2197, 29407, 29451, 29455, 29411
40346, 29407, 29451, 29455, 29411, 29408, 29452, 29456, 29412
40347, 29408, 29452, 29456, 29412, 29409, 29453, 29457, 29413
40348, 29409, 29453, 29457, 29413, 29410, 29454, 29458, 29414
40349, 29410, 29454, 29458, 29414, 11970, 11981, 11982, 11971
40350, 2197, 2208, 191, 190, 29411, 29455, 11703, 11699
40351, 29411, 29455, 11703, 11699, 29412, 29456, 11704, 11700
40352, 29412, 29456, 11704, 11700, 29413, 29457, 11705, 11701
40353, 29413, 29457, 11705, 11701, 29414, 29458, 11706, 11702
40354, 29414, 29458, 11706, 11702, 11971, 11982, 1808, 1807
40355, 168, 169, 2209, 2198, 11567, 11571, 29459, 29415
40356, 11567, 11571, 29459, 29415, 11568, 11572, 29460, 29416
40357, 11568, 11572, 29460, 29416, 11569, 11573, 29461, 29417
40358, 11569, 11573, 29461, 29417, 11570, 11574, 29462, 29418
40359, 11570, 11574, 29462, 29418, 1766, 1767, 11983, 11972
40360, 2198, 2209, 2210, 2199, 29415, 29459, 29463, 29419
40361, 29415, 29459, 29463, 29419, 29416, 29460, 29464, 29420
40362, 29416, 29460, 29464, 29420, 29417, 29461, 29465, 29421
40363, 29417, 29461, 29465, 29421, 29418, 29462, 29466, 29422
40364, 29418, 29462, 29466, 29422, 11972, 11983, 11984, 11973
40365, 2199, 2210, 2211, 2200, 29419, 29463, 29467, 29423
40366, 29419, 29463, 29467, 29423, 29420, 29464, 29468, 29424
40367, 29420, 29464, 29468, 29424, 29421, 29465, 29469, 29425
40368, 29421, 29465, 29469, 29425, 29422, 29466, 29470, 29426
40369, 29422, 29466, 29470, 29426, 11973, 11984, 11985, 11974
40370, 2200, 2211, 2212, 2201, 29423, 29467, 29471, 29427
40371, 29423, 29467, 29471, 29427, 29424, 29468, 29472, 29428
40372, 29424, 29468, 29472, 29428, 29425, 29469, 29473, 29429
40373, 29425, 29469, 29473, 29429, 29426, 29470, 29474, 29430
40374, 29426, 29470, 29474, 29430, 11974, 11985, 11986, 11975
40375, 2201, 2212, 2213, 2202, 29427, 29471, 29475, 29431
40376, 29427, 29471, 29475, 29431, 29428, 29472, 29476, 29432
40377, 29428, 29472, 29476, 29432, 29429, 29473, 29477, 29433
40378, 29429, 29473, 29477, 29433, 29430, 29474, 29478, 29434
40379, 29430, 29474, 29478, 29434, 11975, 11986, 11987, 11976
40380, 2202, 2213, 2214, 2203, 29431, 29475, 29479, 29435
40381, 29431, 29475, 29479, 29435, 29432, 29476, 29480, 29436
40382, 29432, 29476, 29480, 29436, 29433, 29477, 29481, 29437
40383, 29433, 29477, 29481, 29437, 29434, 29478, 29482, 29438
40384, 29434, 29478, 29482, 29438, 11976, 11987, 11988, 11977
40385, 2203, 2214, 2215, 2204, 29435, 29479, 29483, 29439
40386, 29435, 29479, 29483, 29439, 29436, 29480, 29484, 29440
40387, 29436, 29480, 29484, 29440, 29437, 29481, 29485, 29441
40388, 29437, 29481, 29485, 29441, 29438, 29482, 29486, 29442
40389, 29438, 29482, 29486, 29442, 11977, 11988, 11989, 11978
40390, 2204, 2215, 2216, 2205, 29439, 29483, 29487, 29443
40391, 29439, 29483, 29487, 29443, 29440, 29484, 29488, 29444
40392, 29440, 29484, 29488, 29444, 29441, 29485, 29489, 29445
40393, 29441, 29485, 29489, 29445, 29442, 29486, 29490, 29446
40394, 29442, 29486, 29490, 29446, 11978, 11989, 11990, 11979
40395, 2205, 2216, 2217, 2206, 29443, 29487, 29491, 29447
40396, 29443, 29487, 29491, 29447, 29444, 29488, 29492, 29448
40397, 29444, 29488, 29492, 29448, 29445, 29489, 29493, 29449
40398, 29445, 29489, 29493, 29449, 29446, 29490, 29494, 29450
40399, 29446, 29490, 29494, 29450, 11979, 11990, 11991, 11980
40400, 2206, 2217, 2218, 2207, 29447, 29491, 29495, 29451
40401, 29447, 29491, 29495, 29451, 29448, 29492, 29496, 29452
40402, 29448, 29492, 29496, 29452, 29449, 29493, 29497, 29453
40403, 29449, 29493, 29497, 29453, 29450, 29494, 29498, 29454
40404, 29450, 29494, 29498, 29454, 11980, 11991, 11992, 11981
40405, 2207, 2218, 2219, 2208, 29451, 29495, 29499, 29455
40406, 29451, 29495, 29499, 29455, 29452, 29496, 29500, 29456
40407, 29452, 29496, 29500, 29456, 29453, 29497, 29501, 29457
40408, 29453, 29497, 29501, 29457, 29454, 29498, 29502, 29458
40409, 29454, 29498, 29502, 29458, 11981, 11992, 11993, 11982
40410, 2208, 2219, 192, 191, 29455, 29499, 11707, 11703
40411, 29455, 29499, 11707, 11703, 29456, 29500, 11708, 11704
40412, 29456, 29500, 11708, 11704, 29457, 29501, 11709, 11705
40413, 29457, 29501, 11709, 11705, 29458, 29502, 11710, 11706
40414, 29458, 29502, 11710, 11706, 11982, 11993, 1809, 1808
40415, 169, 170, 2220, 2209, 11571, 11575, 29503, 29459
40416, 11571, 11575, 29503, 29459, 11572, 11576, 29504, 29460
40417, 11572, 11576, 29504, 29460, 11573, 11577, 29505, 29461
40418, 11573, 11577, 29505, 29461, 11574, 11578, 29506, 29462
40419, 11574, 11578, 29506, 29462, 1767, 1768, 11994, 11983
40420, 2209, 2220, 2221, 2210, 29459, 29503, 29507, 29463
40421, 29459, 29503, 29507, 29463, 29460, 29504, 29508, 29464
40422, 29460, 29504, 29508, 29464, 29461, 29505, 29509, 29465
40423, 29461, 29505, 29509, 29465, 29462, 29506, 29510, 29466
40424, 29462, 29506, 29510, 29466, 11983, 11994, 11995, 11984
40425, 2210, 2221, 2222, 2211, 29463, 29507, 29511, 29467
40426, 29463, 29507, 29511, 29467, 29464, 29508, 29512, 29468
40427, 29464, 29508, 29512, 29468, 29465, 29509, 29513, 29469
40428, 29465, 29509, 29513, 29469, 29466, 29510, 29514, 29470
40429, 29466, 29510, 29514, 29470, 11984, 11995, 11996, 11985
40430, 2211, 2222, 2223, 2212, 29467, 29511, 29515, 29471
40431, 29467, 29511, 29515, 29471, 29468, 29512, 29516, 29472
40432, 29468, 29512, 29516, 29472, 29469, 29513, 29517, 29473
40433, 29469, 29513, 29517, 29473, 29470, 29514, 29518, 29474
40434, 29470, 29514, 29518, 29474, 11985, 11996, 11997, 11986
40435, 2212, 2223, 2224, 2213, 29471, 29515, 29519, 29475
40436, 29471, 29515, 29519, 29475, 29472, 29516, 29520, 29476
40437, 29472, 29516, 29520, 29476, 29473, 29517, 29521, 29477
40438, 29473, 29517, 29521, 29477, 29474, 29518, 29522, 29478
40439, 29474, 29518, 29522, 29478, 11986, 11997, 11998, 11987
40440, 2213, 2224, 2225, 2214, 29475, 29519, 29523, 29479
40441, 29475, 29519, 29523, 29479, 29476, 29520, 29524, 29480
40442, 29476, 29520, 29524, 29480, 29477, 29521, 29525, 29481
40443, 29477, 29521, 29525, 29481, 29478, 29522, 29526, 29482
40444, 29478, 29522, 29526, 29482, 11987, 11998, 11999, 11988
40445, 2214, 2225, 2226, 2215, 29479, 29523, 29527, 29483
40446, 29479, 29523, 29527, 29483, 29480, 29524, 29528, 29484
40447, 29480, 29524, 29528, 29484, 29481, 29525, 29529, 29485
40448, 29481, 29525, 29529, 29485, 29482, 29526, 29530, 29486
40449, 29482, 29526, 29530, 29486, 11988, 11999, 12000, 11989
40450, 2215, 2226, 2227, 2216, 29483, 29527, 29531, 29487
40451, 29483, 29527, 29531, 29487, 29484, 29528, 29532, 29488
40452, 29484, 29528, 29532, 29488, 29485, 29529, 29533, 29489
40453, 29485, 29529, 29533, 29489, 29486, 29530, 29534, 29490
40454, 29486, 29530, 29534, 29490, 11989, 12000, 12001, 11990
40455, 2216, 2227, 2228, 2217, 29487, 29531, 29535, 29491
40456, 29487, 29531, 29535, 29491, 29488, 29532, 29536, 29492
40457, 29488, 29532, 29536, 29492, 29489, 29533, 29537, 29493
40458, 29489, 29533, 29537, 29493, 29490, 29534, 29538, 29494
40459, 29490, 29534, 29538, 29494, 11990, 12001, 12002, 11991
40460, 2217, 2228, 2229, 2218, 29491, 29535, 29539, 29495
40461, 29491, 29535, 29539, 29495, 29492, 29536, 29540, 29496
40462, 29492, 29536, 29540, 29496, 29493, 29537, 29541, 29497
40463, 29493, 29537, 29541, 29497, 29494, 29538, 29542, 29498
40464, 29494, 29538, 29542, 29498, 11991, 12002, 12003, 11992
40465, 2218, 2229, 2230, 2219, 29495, 29539, 29543, 29499
40466, 29495, 29539, 29543, 29499, 29496, 29540, 29544, 29500
40467, 29496, 29540, 29544, 29500, 29497, 29541, 29545, 29501
40468, 29497, 29541, 29545, 29501, 29498, 29542, 29546, 29502
40469, 29498, 29542, 29546, 29502, 11992, 12003, 12004, 11993
40470, 2219, 2230, 193, 192, 29499, 29543, 11711, 11707
40471, 29499, 29543, 11711, 11707, 29500, 29544, 11712, 11708
40472, 29500, 29544, 11712, 11708, 29501, 29545, 11713, 11709
40473, 29501, 29545, 11713, 11709, 29502, 29546, 11714, 11710
40474, 29502, 29546, 11714, 11710, 11993, 12004, 1810, 1809
40475, 170, 171, 2231, 2220, 11575, 11579, 29547, 29503
40476, 11575, 11579, 29547, 29503, 11576, 11580, 29548, 29504
40477, 11576, 11580, 29548, 29504, 11577, 11581, 29549, 29505
40478, 11577, 11581, 29549, 29505, 11578, 11582, 29550, 29506
40479, 11578, 11582, 29550, 29506, 1768, 1769, 12005, 11994
40480, 2220, 2231, 2232, 2221, 29503, 29547, 29551, 29507
40481, 29503, 29547, 29551, 29507, 29504, 29548, 29552, 29508
40482, 29504, 29548, 29552, 29508, 29505, 29549, 29553, 29509
40483, 29505, 29549, 29553, 29509, 29506, 29550, 29554, 29510
40484, 29506, 29550, 29554, 29510, 11994, 12005, 12006, 11995
40485, 2221, 2232, 2233, 2222, 29507, 29551, 29555, 29511
40486, 29507, 29551, 29555, 29511, 29508, 29552, 29556, 29512
40487, 29508, 29552, 29556, 29512, 29509, 29553, 29557, 29513
40488, 29509, 29553, 29557, 29513, 29510, 29554, 29558, 29514
40489, 29510, 29554, 29558, 29514, 11995, 12006, 12007, 11996
40490, 2222, 2233, 2234, 2223, 29511, 29555, 29559, 29515
40491, 29511, 29555, 29559, 29515, 29512, 29556, 29560, 29516
40492, 29512, 29556, 29560, 29516, 29513, 29557, 29561, 29517
40493, 29513, 29557, 29561, 29517, 29514, 29558, 29562, 29518
40494, 29514, 29558, 29562, 29518, 11996, 12007, 12008, 11997
40495, 2223, 2234, 2235, 2224, 29515, 29559, 29563, 29519
40496, 29515, 29559, 29563, 29519, 29516, 29560, 29564, 29520
40497, 29516, 29560, 29564, 29520, 29517, 29561, 29565, 29521
40498, 29517, 29561, 29565, 29521, 29518, 29562, 29566, 29522
40499, 29518, 29562, 29566, 29522, 11997, 12008, 12009, 11998
40500, 2224, 2235, 2236, 2225, 29519, 29563, 29567, 29523
40501, 29519, 29563, 29567, 29523, 29520, 29564, 29568, 29524
40502, 29520, 29564, 29568, 29524, 29521, 29565, 29569, 29525
40503, 29521, 29565, 29569, 29525, 29522, 29566, 29570, 29526
40504, 29522, 29566, 29570, 29526, 11998, 12009, 12010, 11999
40505, 2225, 2236, 2237, 2226, 29523, 29567, 29571, 29527
40506, 29523, 29567, 29571, 29527, 29524, 29568, 29572, 29528
40507, 29524, 29568, 29572, 29528, 29525, 29569, 29573, 29529
40508, 29525, 29569, 29573, 29529, 29526, 29570, 29574, 29530
40509, 29526, 29570, 29574, 29530, 11999, 12010, 12011, 12000
40510, 2226, 2237, 2238, 2227, 29527, 29571, 29575, 29531
40511, 29527, 29571, 29575, 29531, 29528, 29572, 29576, 29532
40512, 29528, 29572, 29576, 29532, 29529, 29573, 29577, 29533
40513, 29529, 29573, 29577, 29533, 29530, 29574, 29578, 29534
40514, 29530, 29574, 29578, 29534, 12000, 12011, 12012, 12001
40515, 2227, 2238, 2239, 2228, 29531, 29575, 29579, 29535
40516, 29531, 29575, 29579, 29535, 29532, 29576, 29580, 29536
40517, 29532, 29576, 29580, 29536, 29533, 29577, 29581, 29537
40518, 29533, 29577, 29581, 29537, 29534, 29578, 29582, 29538
40519, 29534, 29578, 29582, 29538, 12001, 12012, 12013, 12002
40520, 2228, 2239, 2240, 2229, 29535, 29579, 29583, 29539
40521, 29535, 29579, 29583, 29539, 29536, 29580, 29584, 29540
40522, 29536, 29580, 29584, 29540, 29537, 29581, 29585, 29541
40523, 29537, 29581, 29585, 29541, 29538, 29582, 29586, 29542
40524, 29538, 29582, 29586, 29542, 12002, 12013, 12014, 12003
40525, 2229, 2240, 2241, 2230, 29539, 29583, 29587, 29543
40526, 29539, 29583, 29587, 29543, 29540, 29584, 29588, 29544
40527, 29540, 29584, 29588, 29544, 29541, 29585, 29589, 29545
40528, 29541, 29585, 29589, 29545, 29542, 29586, 29590, 29546
40529, 29542, 29586, 29590, 29546, 12003, 12014, 12015, 12004
40530, 2230, 2241, 194, 193, 29543, 29587, 11715, 11711
40531, 29543, 29587, 11715, 11711, 29544, 29588, 11716, 11712
40532, 29544, 29588, 11716, 11712, 29545, 29589, 11717, 11713
40533, 29545, 29589, 11717, 11713, 29546, 29590, 11718, 11714
40534, 29546, 29590, 11718, 11714, 12004, 12015, 1811, 1810
40535, 171, 6, 123, 2231, 11579, 1739, 11583, 29547
40536, 11579, 1739, 11583, 29547, 11580, 1740, 11584, 29548
40537, 11580, 1740, 11584, 29548, 11581, 1741, 11585, 29549
40538, 11581, 1741, 11585, 29549, 11582, 1742, 11586, 29550
40539, 11582, 1742, 11586, 29550, 1769, 85, 1774, 12005
40540, 2231, 123, 124, 2232, 29547, 11583, 11587, 29551
40541, 29547, 11583, 11587, 29551, 29548, 11584, 11588, 29552
40542, 29548, 11584, 11588, 29552, 29549, 11585, 11589, 29553
40543, 29549, 11585, 11589, 29553, 29550, 11586, 11590, 29554
40544, 29550, 11586, 11590, 29554, 12005, 1774, 1775, 12006
40545, 2232, 124, 125, 2233, 29551, 11587, 11591, 29555
40546, 29551, 11587, 11591, 29555, 29552, 11588, 11592, 29556
40547, 29552, 11588, 11592, 29556, 29553, 11589, 11593, 29557
40548, 29553, 11589, 11593, 29557, 29554, 11590, 11594, 29558
40549, 29554, 11590, 11594, 29558, 12006, 1775, 1776, 12007
40550, 2233, 125, 126, 2234, 29555, 11591, 11595, 29559
40551, 29555, 11591, 11595, 29559, 29556, 11592, 11596, 29560
40552, 29556, 11592, 11596, 29560, 29557, 11593, 11597, 29561
40553, 29557, 11593, 11597, 29561, 29558, 11594, 11598, 29562
40554, 29558, 11594, 11598, 29562, 12007, 1776, 1777, 12008
40555, 2234, 126, 127, 2235, 29559, 11595, 11599, 29563
40556, 29559, 11595, 11599, 29563, 29560, 11596, 11600, 29564
40557, 29560, 11596, 11600, 29564, 29561, 11597, 11601, 29565
40558, 29561, 11597, 11601, 29565, 29562, 11598, 11602, 29566
40559, 29562, 11598, 11602, 29566, 12008, 1777, 1778, 12009
40560, 2235, 127, 128, 2236, 29563, 11599, 11603, 29567
40561, 29563, 11599, 11603, 29567, 29564, 11600, 11604, 29568
40562, 29564, 11600, 11604, 29568, 29565, 11601, 11605, 29569
40563, 29565, 11601, 11605, 29569, 29566, 11602, 11606, 29570
40564, 29566, 11602, 11606, 29570, 12009, 1778, 1779, 12010
40565, 2236, 128, 129, 2237, 29567, 11603, 11607, 29571
40566, 29567, 11603, 11607, 29571, 29568, 11604, 11608, 29572
40567, 29568, 11604, 11608, 29572, 29569, 11605, 11609, 29573
40568, 29569, 11605, 11609, 29573, 29570, 11606, 11610, 29574
40569, 29570, 11606, 11610, 29574, 12010, 1779, 1780, 12011
40570, 2237, 129, 130, 2238, 29571, 11607, 11611, 29575
40571, 29571, 11607, 11611, 29575, 29572, 11608, 11612, 29576
40572, 29572, 11608, 11612, 29576, 29573, 11609, 11613, 29577
40573, 29573, 11609, 11613, 29577, 29574, 11610, 11614, 29578
40574, 29574, 11610, 11614, 29578, 12011, 1780, 1781, 12012
40575, 2238, 130, 131, 2239, 29575, 11611, 11615, 29579
40576, 29575, 11611, 11615, 29579, 29576, 11612, 11616, 29580
40577, 29576, 11612, 11616, 29580, 29577, 11613, 11617, 29581
40578, 29577, 11613, 11617, 29581, 29578, 11614, 11618, 29582
40579, 29578, 11614, 11618, 29582, 12012, 1781, 1782, 12013
40580, 2239, 131, 132, 2240, 29579, 11615, 11619, 29583
40581, 29579, 11615, 11619, 29583, 29580, 11616, 11620, 29584
40582, 29580, 11616, 11620, 29584, 29581, 11617, 11621, 29585
40583, 29581, 11617, 11621, 29585, 29582, 11618, 11622, 29586
40584, 29582, 11618, 11622, 29586, 12013, 1782, 1783, 12014
40585, 2240, 132, 133, 2241, 29583, 11619, 11623, 29587
40586, 29583, 11619, 11623, 29587, 29584, 11620, 11624, 29588
40587, 29584, 11620, 11624, 29588, 29585, 11621, 11625, 29589
40588, 29585, 11621, 11625, 29589, 29586, 11622, 11626, 29590
40589, 29586, 11622, 11626, 29590, 12014, 1783, 1784, 12015
40590, 2241, 133, 5, 194, 29587, 11623, 1770, 11715
40591, 29587, 11623, 1770, 11715, 29588, 11624, 1771, 11716
40592, 29588, 11624, 1771, 11716, 29589, 11625, 1772, 11717
40593, 29589, 11625, 1772, 11717, 29590, 11626, 1773, 11718
40594, 29590, 11626, 1773, 11718, 12015, 1784, 87, 1811
*ELEMENT, type=C3D8, ELSET=Volume24
40595, 2, 97, 1171, 54, 1743, 11719, 12016, 1827
40596, 1743, 11719, 12016, 1827, 1744, 11720, 12017, 1828
40597, 1744, 11720, 12017, 1828, 1745, 11721, 12018, 1829
40598, 1745, 11721, 12018, 1829, 1746, 11722, 12019, 1830
40599, 1746, 11722, 12019, 1830, 86, 1812, 1831, 90
40600, 97, 98, 1172, 1171, 11719, 11723, 12020, 12016
40601, 11719, 11723, 12020, 12016, 11720, 11724, 12021, 12017
40602, 11720, 11724, 12021, 12017, 11721, 11725, 12022, 12018
40603, 11721, 11725, 12022, 12018, 11722, 11726, 12023, 12019
40604, 11722, 11726, 12023, 12019, 1812, 1813, 1832, 1831
40605, 98, 99, 1173, 1172, 11723, 11727, 12024, 12020
40606, 11723, 11727, 12024, 12020, 11724, 11728, 12025, 12021
40607, 11724, 11728, 12025, 12021, 11725, 11729, 12026, 12022
40608, 11725, 11729, 12026, 12022, 11726, 11730, 12027, 12023
40609, 11726, 11730, 12027, 12023, 1813, 1814, 1833, 1832
40610, 99, 100, 1174, 1173, 11727, 11731, 12028, 12024
40611, 11727, 11731, 12028, 12024, 11728, 11732, 12029, 12025
40612, 11728, 11732, 12029, 12025, 11729, 11733, 12030, 12026
40613, 11729, 11733, 12030, 12026, 11730, 11734, 12031, 12027
40614, 11730, 11734, 12031, 12027, 1814, 1815, 1834, 1833
40615, 100, 101, 1175, 1174, 11731, 11735, 12032, 12028
40616, 11731, 11735, 12032, 12028, 11732, 11736, 12033, 12029
40617, 11732, 11736, 12033, 12029, 11733, 11737, 12034, 12030
40618, 11733, 11737, 12034, 12030, 11734, 11738, 12035, 12031
40619, 11734, 11738, 12035, 12031, 1815, 1816, 1835, 1834
40620, 101, 102, 1176, 1175, 11735, 11739, 12036, 12032
40621, 11735, 11739, 12036, 12032, 11736, 11740, 12037, 12033
40622, 11736, 11740, 12037, 12033, 11737, 11741, 12038, 12034
40623, 11737, 11741, 12038, 12034, 11738, 11742, 12039, 12035
40624, 11738, 11742, 12039, 12035, 1816, 1817, 1836, 1835
40625, 102, 103, 1177, 1176, 11739, 11743, 12040, 12036
40626, 11739, 11743, 12040, 12036, 11740, 11744, 12041, 12037
40627, 11740, 11744, 12041, 12037, 11741, 11745, 12042, 12038
40628, 11741, 11745, 12042, 12038, 11742, 11746, 12043, 12039
40629, 11742, 11746, 12043, 12039, 1817, 1818, 1837, 1836
40630, 103, 104, 1178, 1177, 11743, 11747, 12044, 12040
40631, 11743, 11747, 12044, 12040, 11744, 11748, 12045, 12041
40632, 11744, 11748, 12045, 12041, 11745, 11749, 12046, 12042
40633, 11745, 11749, 12046, 12042, 11746, 11750, 12047, 12043
40634, 11746, 11750, 12047, 12043, 1818, 1819, 1838, 1837
40635, 104, 105, 1179, 1178, 11747, 11751, 12048, 12044
40636, 11747, 11751, 12048, 12044, 11748, 11752, 12049, 12045
40637, 11748, 11752, 12049, 12045, 11749, 11753, 12050, 12046
40638, 11749, 11753, 12050, 12046, 11750, 11754, 12051, 12047
40639, 11750, 11754, 12051, 12047, 1819, 1820, 1839, 1838
40640, 105, 106, 1180, 1179, 11751, 11755, 12052, 12048
40641, 11751, 11755, 12052, 12048, 11752, 11756, 12053, 12049
40642, 11752, 11756, 12053, 12049, 11753, 11757, 12054, 12050
40643, 11753, 11757, 12054, 12050, 11754, 11758, 12055, 12051
40644, 11754, 11758, 12055, 12051, 1820, 1821, 1840, 1839
40645, 106, 107, 1181, 1180, 11755, 11759, 12056, 12052
40646, 11755, 11759, 12056, 12052, 11756, 11760, 12057, 12053
40647, 11756, 11760, 12057, 12053, 11757, 11761, 12058, 12054
40648, 11757, 11761, 12058, 12054, 11758, 11762, 12059, 12055
40649, 11758, 11762, 12059, 12055, 1821, 1822, 1841, 1840
40650, 107, 1, 53, 1181, 11759, 1785, 1823, 12056
40651, 11759, 1785, 1823, 12056, 11760, 1786, 1824, 12057
40652, 11760, 1786, 1824, 12057, 11761, 1787, 1825, 12058
40653, 11761, 1787, 1825, 12058, 11762, 1788, 1826, 12059
40654, 11762, 1788, 1826, 12059, 1822, 88, 89, 1841
*ELEMENT, type=C3D8, ELSET=Volume25
40655, 47, 1100, 8504, 1123, 1873, 12152, 29591, 12244
40656, 1873, 12152, 29591, 12244, 1874, 12153, 29592, 12245
40657, 1874, 12153, 29592, 12245, 1875, 12154, 29593, 12246
40658, 1875, 12154, 29593, 12246, 1876, 12155, 29594, 12247
40659, 1876, 12155, 29594, 12247, 93, 1881, 12332, 1904
40660, 1100, 1101, 8505, 8504, 12152, 12156, 29595, 29591
40661, 12152, 12156, 29595, 29591, 12153, 12157, 29596, 29592
40662, 12153, 12157, 29596, 29592, 12154, 12158, 29597, 29593
40663, 12154, 12158, 29597, 29593, 12155, 12159, 29598, 29594
40664, 12155, 12159, 29598, 29594, 1881, 1882, 12333, 12332
40665, 1101, 1102, 8506, 8505, 12156, 12160, 29599, 29595
40666, 12156, 12160, 29599, 29595, 12157, 12161, 29600, 29596
40667, 12157, 12161, 29600, 29596, 12158, 12162, 29601, 29597
40668, 12158, 12162, 29601, 29597, 12159, 12163, 29602, 29598
40669, 12159, 12163, 29602, 29598, 1882, 1883, 12334, 12333
40670, 1102, 1103, 8507, 8506, 12160, 12164, 29603, 29599
40671, 12160, 12164, 29603, 29599, 12161, 12165, 29604, 29600
40672, 12161, 12165, 29604, 29600, 12162, 12166, 29605, 29601
40673, 12162, 12166, 29605, 29601, 12163, 12167, 29606, 29602
40674, 12163, 12167, 29606, 29602, 1883, 1884, 12335, 12334
40675, 1103, 1104, 8508, 8507, 12164, 12168, 29607, 29603
40676, 12164, 12168, 29607, 29603, 12165, 12169, 29608, 29604
40677, 12165, 12169, 29608, 29604, 12166, 12170, 29609, 29605
40678, 12166, 12170, 29609, 29605, 12167, 12171, 29610, 29606
40679, 12167, 12171, 29610, 29606, 1884, 1885, 12336, 12335
40680, 1104, 1105, 8509, 8508, 12168, 12172, 29611, 29607
40681, 12168, 12172, 29611, 29607, 12169, 12173, 29612, 29608
40682, 12169, 12173, 29612, 29608, 12170, 12174, 29613, 29609
40683, 12170, 12174, 29613, 29609, 12171, 12175, 29614, 29610
40684, 12171, 12175, 29614, 29610, 1885, 1886, 12337, 12336
40685, 1105, 1106, 8510, 8509, 12172, 12176, 29615, 29611
40686, 12172, 12176, 29615, 29611, 12173, 12177, 29616, 29612
40687, 12173, 12177, 29616, 29612, 12174, 12178, 29617, 29613
40688, 12174, 12178, 29617, 29613, 12175, 12179, 29618, 29614
40689, 12175, 12179, 29618, 29614, 1886, 1887, 12338, 12337
40690, 1106, 1107, 8511, 8510, 12176, 12180, 29619, 29615
40691, 12176, 12180, 29619, 29615, 12177, 12181, 29620, 29616
40692, 12177, 12181, 29620, 29616, 12178, 12182, 29621, 29617
40693, 12178, 12182, 29621, 29617, 12179, 12183, 29622, 29618
40694, 12179, 12183, 29622, 29618, 1887, 1888, 12339, 12338
40695, 1107, 1108, 8512, 8511, 12180, 12184, 29623, 29619
40696, 12180, 12184, 29623, 29619, 12181, 12185, 29624, 29620
40697, 12181, 12185, 29624, 29620, 12182, 12186, 29625, 29621
40698, 12182, 12186, 29625, 29621, 12183, 12187, 29626, 29622
40699, 12183, 12187, 29626, 29622, 1888, 1889, 12340, 12339
40700, 1108, 1109, 8513, 8512, 12184, 12188, 29627, 29623
40701, 12184, 12188, 29627, 29623, 12185, 12189, 29628, 29624
40702, 12185, 12189, 29628, 29624, 12186, 12190, 29629, 29625
40703, 12186, 12190, 29629, 29625, 12187, 12191, 29630, 29626
40704, 12187, 12191, 29630, 29626, 1889, 1890, 12341, 12340
40705, 1109, 1110, 8514, 8513, 12188, 12192, 29631, 29627
40706, 12188, 12192, 29631, 29627, 12189, 12193, 29632, 29628
40707, 12189, 12193, 29632, 29628, 12190, 12194, 29633, 29629
40708, 12190, 12194, 29633, 29629, 12191, 12195, 29634, 29630
40709, 12191, 12195, 29634, 29630, 1890, 1891, 12342, 12341
40710, 1110, 1111, 8515, 8514, 12192, 12196, 29635, 29631
40711, 12192, 12196, 29635, 29631, 12193, 12197, 29636, 29632
40712, 12193, 12197, 29636, 29632, 12194, 12198, 29637, 29633
40713, 12194, 12198, 29637, 29633, 12195, 12199, 29638, 29634
40714, 12195, 12199, 29638, 29634, 1891, 1892, 12343, 12342
40715, 1111, 1112, 8516, 8515, 12196, 12200, 29639, 29635
40716, 12196, 12200, 29639, 29635, 12197, 12201, 29640, 29636
40717, 12197, 12201, 29640, 29636, 12198, 12202, 29641, 29637
40718, 12198, 12202, 29641, 29637, 12199, 12203, 29642, 29638
40719, 12199, 12203, 29642, 29638, 1892, 1893, 12344, 12343
40720, 1112, 1113, 8517, 8516, 12200, 12204, 29643, 29639
40721, 12200, 12204, 29643, 29639, 12201, 12205, 29644, 29640
40722, 12201, 12205, 29644, 29640, 12202, 12206, 29645, 29641
40723, 12202, 12206, 29645, 29641, 12203, 12207, 29646, 29642
40724, 12203, 12207, 29646, 29642, 1893, 1894, 12345, 12344
40725, 1113, 1114, 8518, 8517, 12204, 12208, 29647, 29643
40726, 12204, 12208, 29647, 29643, 12205, 12209, 29648, 29644
40727, 12205, 12209, 29648, 29644, 12206, 12210, 29649, 29645
40728, 12206, 12210, 29649, 29645, 12207, 12211, 29650, 29646
40729, 12207, 12211, 29650, 29646, 1894, 1895, 12346, 12345
40730, 1114, 1115, 8519, 8518, 12208, 12212, 29651, 29647
40731, 12208, 12212, 29651, 29647, 12209, 12213, 29652, 29648
40732, 12209, 12213, 29652, 29648, 12210, 12214, 29653, 29649
40733, 12210, 12214, 29653, 29649, 12211, 12215, 29654, 29650
40734, 12211, 12215, 29654, 29650, 1895, 1896, 12347, 12346
40735, 1115, 1116, 8520, 8519, 12212, 12216, 29655, 29651
40736, 12212, 12216, 29655, 29651, 12213, 12217, 29656, 29652
40737, 12213, 12217, 29656, 29652, 12214, 12218, 29657, 29653
40738, 12214, 12218, 29657, 29653, 12215, 12219, 29658, 29654
40739, 12215, 12219, 29658, 29654, 1896, 1897, 12348, 12347
40740, 1116, 1117, 8521, 8520, 12216, 12220, 29659, 29655
40741, 12216, 12220, 29659, 29655, 12217, 12221, 29660, 29656
40742, 12217, 12221, 29660, 29656, 12218, 12222, 29661, 29657
40743, 12218, 12222, 29661, 29657, 12219, 12223, 29662, 29658
40744, 12219, 12223, 29662, 29658, 1897, 1898, 12349, 12348
40745, 1117, 1118, 8522, 8521, 12220, 12224, 29663, 29659
40746, 12220, 12224, 29663, 29659, 12221, 12225, 29664, 29660
40747, 12221, 12225, 29664, 29660, 12222, 12226, 29665, 29661
40748, 12222, 12226, 29665, 29661, 12223, 12227, 29666, 29662
40749, 12223, 12227, 29666, 29662, 1898, 1899, 12350, 12349
40750, 1118, 1119, 8523, 8522, 12224, 12228, 29667, 29663
40751, 12224, 12228, 29667, 29663, 12225, 12229, 29668, 29664
40752, 12225, 12229, 29668, 29664, 12226, 12230, 29669, 29665
40753, 12226, 12230, 29669, 29665, 12227, 12231, 29670, 29666
40754, 12227, 12231, 29670, 29666, 1899, 1900, 12351, 12350
40755, 1119, 1120, 8524, 8523, 12228, 12232, 29671, 29667
40756, 12228, 12232, 29671, 29667, 12229, 12233, 29672, 29668
40757, 12229, 12233, 29672, 29668, 12230, 12234, 29673, 29669
40758, 12230, 12234, 29673, 29669, 12231, 12235, 29674, 29670
40759, 12231, 12235, 29674, 29670, 1900, 1901, 12352, 12351
40760, 1120, 1121, 8525, 8524, 12232, 12236, 29675, 29671
40761, 12232, 12236, 29675, 29671, 12233, 12237, 29676, 29672
40762, 12233, 12237, 29676, 29672, 12234, 12238, 29677, 29673
40763, 12234, 12238, 29677, 29673, 12235, 12239, 29678, 29674
40764, 12235, 12239, 29678, 29674, 1901, 1902, 12353, 12352
40765, 1121, 1122, 8526, 8525, 12236, 12240, 29679, 29675
40766, 12236, 12240, 29679, 29675, 12237, 12241, 29680, 29676
40767, 12237, 12241, 29680, 29676, 12238, 12242, 29681, 29677
40768, 12238, 12242, 29681, 29677, 12239, 12243, 29682, 29678
40769, 12239, 12243, 29682, 29678, 1902, 1903, 12354, 12353
40770, 1122, 48, 1134, 8526, 12240, 1877, 12288, 29679
40771, 12240, 1877, 12288, 29679, 12241, 1878, 12289, 29680
40772, 12241, 1878, 12289, 29680, 12242, 1879, 12290, 29681
40773, 12242, 1879, 12290, 29681, 12243, 1880, 12291, 29682
40774, 12243, 1880, 12291, 29682, 1903, 94, 1915, 12354
40775, 1123, 8504, 8527, 1124, 12244, 29591, 29683, 12248
40776, 12244, 29591, 29683, 12248, 12245, 29592, 29684, 12249
40777, 12245, 29592, 29684, 12249, 12246, 29593, 29685, 12250
40778, 12246, 29593, 29685, 12250, 12247, 29594, 29686, 12251
40779, 12247, 29594, 29686, 12251, 1904, 12332, 12355, 1905
40780, 8504, 8505, 8528, 8527, 29591, 29595, 29687, 29683
40781, 29591, 29595, 29687, 29683, 29592, 29596, 29688, 29684
40782, 29592, 29596, 29688, 29684, 29593, 29597, 29689, 29685
40783, 29593, 29597, 29689, 29685, 29594, 29598, 29690, 29686
40784, 29594, 29598, 29690, 29686, 12332, 12333, 12356, 12355
40785, 8505, 8506, 8529, 8528, 29595, 29599, 29691, 29687
40786, 29595, 29599, 29691, 29687, 29596, 29600, 29692, 29688
40787, 29596, 29600, 29692, 29688, 29597, 29601, 29693, 29689
40788, 29597, 29601, 29693, 29689, 29598, 29602, 29694, 29690
40789, 29598, 29602, 29694, 29690, 12333, 12334, 12357, 12356
40790, 8506, 8507, 8530, 8529, 29599, 29603, 29695, 29691
40791, 29599, 29603, 29695, 29691, 29600, 29604, 29696, 29692
40792, 29600, 29604, 29696, 29692, 29601, 29605, 29697, 29693
40793, 29601, 29605, 29697, 29693, 29602, 29606, 29698, 29694
40794, 29602, 29606, 29698, 29694, 12334, 12335, 12358, 12357
40795, 8507, 8508, 8531, 8530, 29603, 29607, 29699, 29695
40796, 29603, 29607, 29699, 29695, 29604, 29608, 29700, 29696
40797, 29604, 29608, 29700, 29696, 29605, 29609, 29701, 29697
40798, 29605, 29609, 29701, 29697, 29606, 29610, 29702, 29698
40799, 29606, 29610, 29702, 29698, 12335, 12336, 12359, 12358
40800, 8508, 8509, 8532, 8531, 29607, 29611, 29703, 29699
40801, 29607, 29611, 29703, 29699, 29608, 29612, 29704, 29700
40802, 29608, 29612, 29704, 29700, 29609, 29613, 29705, 29701
40803, 29609, 29613, 29705, 29701, 29610, 29614, 29706, 29702
40804, 29610, 29614, 29706, 29702, 12336, 12337, 12360, 12359
40805, 8509, 8510, 8533, 8532, 29611, 29615, 29707, 29703
40806, 29611, 29615, 29707, 29703, 29612, 29616, 29708, 29704
40807, 29612, 29616, 29708, 29704, 29613, 29617, 29709, 29705
40808, 29613, 29617, 29709, 29705, 29614, 29618, 29710, 29706
40809, 29614, 29618, 29710, 29706, 12337, 12338, 12361, 12360
40810, 8510, 8511, 8534, 8533, 29615, 29619, 29711, 29707
40811, 29615, 29619, 29711, 29707, 29616, 29620, 29712, 29708
40812, 29616, 29620, 29712, 29708, 29617, 29621, 29713, 29709
40813, 29617, 29621, 29713, 29709, 29618, 29622, 29714, 29710
40814, 29618, 29622, 29714, 29710, 12338, 12339, 12362, 12361
40815, 8511, 8512, 8535, 8534, 29619, 29623, 29715, 29711
40816, 29619, 29623, 29715, 29711, 29620, 29624, 29716, 29712
40817, 29620, 29624, 29716, 29712, 29621, 29625, 29717, 29713
40818, 29621, 29625, 29717, 29713, 29622, 29626, 29718, 29714
40819, 29622, 29626, 29718, 29714, 12339, 12340, 12363, 12362
40820, 8512, 8513, 8536, 8535, 29623, 29627, 29719, 29715
40821, 29623, 29627, 29719, 29715, 29624, 29628, 29720, 29716
40822, 29624, 29628, 29720, 29716, 29625, 29629, 29721, 29717
40823, 29625, 29629, 29721, 29717, 29626, 29630, 29722, 29718
40824, 29626, 29630, 29722, 29718, 12340, 12341, 12364, 12363
40825, 8513, 8514, 8537, 8536, 29627, 29631, 29723, 29719
40826, 29627, 29631, 29723, 29719, 29628, 29632, 29724, 29720
40827, 29628, 29632, 29724, 29720, 29629, 29633, 29725, 29721
40828, 29629, 29633, 29725, 29721, 29630, 29634, 29726, 29722
40829, 29630, 29634, 29726, 29722, 12341, 12342, 12365, 12364
40830, 8514, 8515, 8538, 8537, 29631, 29635, 29727, 29723
40831, 29631, 29635, 29727, 29723, 29632, 29636, 29728, 29724
40832, 29632, 29636, 29728, 29724, 29633, 29637, 29729, 29725
40833, 29633, 29637, 29729, 29725, 29634, 29638, 29730, 29726
40834, 29634, 29638, 29730, 29726, 12342, 12343, 12366, 12365
40835, 8515, 8516, 8539, 8538, 29635, 29639, 29731, 29727
40836, 29635, 29639, 29731, 29727, 29636, 29640, 29732, 29728
40837, 29636, 29640, 29732, 29728, 29637, 29641, 29733, 29729
40838, 29637, 29641, 29733, 29729, 29638, 29642, 29734, 29730
40839, 29638, 29642, 29734, 29730, 12343, 12344, 12367, 12366
40840, 8516, 8517, 8540, 8539, 29639, 29643, 29735, 29731
40841, 29639, 29643, 29735, 29731, 29640, 29644, 29736, 29732
40842, 29640, 29644, 29736, 29732, 29641, 29645, 29737, 29733
40843, 29641, 29645, 29737, 29733, 29642, 29646, 29738, 29734
40844, 29642, 29646, 29738, 29734, 12344, 12345, 12368, 12367
40845, 8517, 8518, 8541, 8540, 29643, 29647, 29739, 29735
40846, 29643, 29647, 29739, 29735, 29644, 29648, 29740, 29736
40847, 29644, 29648, 29740, 29736, 29645, 29649, 29741, 29737
40848, 29645, 29649, 29741, 29737, 29646, 29650, 29742, 29738
40849, 29646, 29650, 29742, 29738, 12345, 12346, 12369, 12368
40850, 8518, 8519, 8542, 8541, 29647, 29651, 29743, 29739
40851, 29647, 29651, 29743, 29739, 29648, 29652, 29744, 29740
40852, 29648, 29652, 29744, 29740, 29649, 29653, 29745, 29741
40853, 29649, 29653, 29745, 29741, 29650, 29654, 29746, 29742
40854, 29650, 29654, 29746, 29742, 12346, 12347, 12370, 12369
40855, 8519, 8520, 8543, 8542, 29651, 29655, 29747, 29743
40856, 29651, 29655, 29747, 29743, 29652, 29656, 29748, 29744
40857, 29652, 29656, 29748, 29744, 29653, 29657, 29749, 29745
40858, 29653, 29657, 29749, 29745, 29654, 29658, 29750, 29746
40859, 29654, 29658, 29750, 29746, 12347, 12348, 12371, 12370
40860, 8520, 8521, 8544, 8543, 29655, 29659, 29751, 29747
40861, 29655, 29659, 29751, 29747, 29656, 29660, 29752, 29748
40862, 29656, 29660, 29752, 29748, 29657, 29661, 29753, 29749
40863, 29657, 29661, 29753, 29749, 29658, 29662, 29754, 29750
40864, 29658, 29662, 29754, 29750, 12348, 12349, 12372, 12371
40865, 8521, 8522, 8545, 8544, 29659, 29663, 29755, 29751
40866, 29659, 29663, 29755, 29751, 29660, 29664, 29756, 29752
40867, 29660, 29664, 29756, 29752, 29661, 29665, 29757, 29753
40868, 29661, 29665, 29757, 29753, 29662, 29666, 29758, 29754
40869, 29662, 29666, 29758, 29754, 12349, 12350, 12373, 12372
40870, 8522, 8523, 8546, 8545, 29663, 29667, 29759, 29755
40871, 29663, 29667, 29759, 29755, 29664, 29668, 29760, 29756
40872, 29664, 29668, 29760, 29756, 29665, 29669, 29761, 29757
40873, 29665, 29669, 29761, 29757, 29666, 29670, 29762, 29758
40874, 29666, 29670, 29762, 29758, 12350, 12351, 12374, 12373
40875, 8523, 8524, 8547, 8546, 29667, 29671, 29763, 29759
40876, 29667, 29671, 29763, 29759, 29668, 29672, 29764, 29760
40877, 29668, 29672, 29764, 29760, 29669, 29673, 29765, 29761
40878, 29669, 29673, 29765, 29761, 29670, 29674, 29766, 29762
40879, 29670, 29674, 29766, 29762, 12351, 12352, 12375, 12374
40880, 8524, 8525, 8548, 8547, 29671, 29675, 29767, 29763
40881, 29671, 29675, 29767, 29763, 29672, 29676, 29768, 29764
40882, 29672, 29676, 29768, 29764, 29673, 29677, 29769, 29765
40883, 29673, 29677, 29769, 29765, 29674, 29678, 29770, 29766
40884, 29674, 29678, 29770, 29766, 12352, 12353, 12376, 12375
40885, 8525, 8526, 8549, 8548, 29675, 29679, 29771, 29767
40886, 29675, 29679, 29771, 29767, 29676, 29680, 29772, 29768
40887, 29676, 29680, 29772, 29768, 29677, 29681, 29773, 29769
40888, 29677, 29681, 29773, 29769, 29678, 29682, 29774, 29770
40889, 29678, 29682, 29774, 29770, 12353, 12354, 12377, 12376
40890, 8526, 1134, 1135, 8549, 29679, 12288, 12292, 29771
40891, 29679, 12288, 12292, 29771, 29680, 12289, 12293, 29772
40892, 29680, 12289, 12293, 29772, 29681, 12290, 12294, 29773
40893, 29681, 12290, 12294, 29773, 29682, 12291, 12295, 29774
40894, 29682, 12291, 12295, 29774, 12354, 1915, 1916, 12377
40895, 1124, 8527, 8550, 1125, 12248, 29683, 29775, 12252
40896, 12248, 29683, 29775, 12252, 12249, 29684, 29776, 12253
40897, 12249, 29684, 29776, 12253, 12250, 29685, 29777, 12254
40898, 12250, 29685, 29777, 12254, 12251, 29686, 29778, 12255
40899, 12251, 29686, 29778, 12255, 1905, 12355, 12378, 1906
40900, 8527, 8528, 8551, 8550, 29683, 29687, 29779, 29775
40901, 29683, 29687, 29779, 29775, 29684, 29688, 29780, 29776
40902, 29684, 29688, 29780, 29776, 29685, 29689, 29781, 29777
40903, 29685, 29689, 29781, 29777, 29686, 29690, 29782, 29778
40904, 29686, 29690, 29782, 29778, 12355, 12356, 12379, 12378
40905, 8528, 8529, 8552, 8551, 29687, 29691, 29783, 29779
40906, 29687, 29691, 29783, 29779, 29688, 29692, 29784, 29780
40907, 29688, 29692, 29784, 29780, 29689, 29693, 29785, 29781
40908, 29689, 29693, 29785, 29781, 29690, 29694, 29786, 29782
40909, 29690, 29694, 29786, 29782, 12356, 12357, 12380, 12379
40910, 8529, 8530, 8553, 8552, 29691, 29695, 29787, 29783
40911, 29691, 29695, 29787, 29783, 29692, 29696, 29788, 29784
40912, 29692, 29696, 29788, 29784, 29693, 29697, 29789, 29785
40913, 29693, 29697, 29789, 29785, 29694, 29698, 29790, 29786
40914, 29694, 29698, 29790, 29786, 12357, 12358, 12381, 12380
40915, 8530, 8531, 8554, 8553, 29695, 29699, 29791, 29787
40916, 29695, 29699, 29791, 29787, 29696, 29700, 29792, 29788
40917, 29696, 29700, 29792, 29788, 29697, 29701, 29793, 29789
40918, 29697, 29701, 29793, 29789, 29698, 29702, 29794, 29790
40919, 29698, 29702, 29794, 29790, 12358, 12359, 12382, 12381
40920, 8531, 8532, 8555, 8554, 29699, 29703, 29795, 29791
40921, 29699, 29703, 29795, 29791, 29700, 29704, 29796, 29792
40922, 29700, 29704, 29796, 29792, 29701, 29705, 29797, 29793
40923, 29701, 29705, 29797, 29793, 29702, 29706, 29798, 29794
40924, 29702, 29706, 29798, 29794, 12359, 12360, 12383, 12382
40925, 8532, 8533, 8556, 8555, 29703, 29707, 29799, 29795
40926, 29703, 29707, 29799, 29795, 29704, 29708, 29800, 29796
40927, 29704, 29708, 29800, 29796, 29705, 29709, 29801, 29797
40928, 29705, 29709, 29801, 29797, 29706, 29710, 29802, 29798
40929, 29706, 29710, 29802, 29798, 12360, 12361, 12384, 12383
40930, 8533, 8534, 8557, 8556, 29707, 29711, 29803, 29799
40931, 29707, 29711, 29803, 29799, 29708, 29712, 29804, 29800
40932, 29708, 29712, 29804, 29800, 29709, 29713, 29805, 29801
40933, 29709, 29713, 29805, 29801, 29710, 29714, 29806, 29802
40934, 29710, 29714, 29806, 29802, 12361, 12362, 12385, 12384
40935, 8534, 8535, 8558, 8557, 29711, 29715, 29807, 29803
40936, 29711, 29715, 29807, 29803, 29712, 29716, 29808, 29804
40937, 29712, 29716, 29808, 29804, 29713, 29717, 29809, 29805
40938, 29713, 29717, 29809, 29805, 29714, 29718, 29810, 29806
40939, 29714, 29718, 29810, 29806, 12362, 12363, 12386, 12385
40940, 8535, 8536, 8559, 8558, 29715, 29719, 29811, 29807
40941, 29715, 29719, 29811, 29807, 29716, 29720, 29812, 29808
40942, 29716, 29720, 29812, 29808, 29717, 29721, 29813, 29809
40943, 29717, 29721, 29813, 29809, 29718, 29722, 29814, 29810
40944, 29718, 29722, 29814, 29810, 12363, 12364, 12387, 12386
40945, 8536, 8537, 8560, 8559, 29719, 29723, 29815, 29811
40946, 29719, 29723, 29815, 29811, 29720, 29724, 29816, 29812
40947, 29720, 29724, 29816, 29812, 29721, 29725, 29817, 29813
40948, 29721, 29725, 29817, 29813, 29722, 29726, 29818, 29814
40949, 29722, 29726, 29818, 29814, 12364, 12365, 12388, 12387
40950, 8537, 8538, 8561, 8560, 29723, 29727, 29819, 29815
40951, 29723, 29727, 29819, 29815, 29724, 29728, 29820, 29816
40952, 29724, 29728, 29820, 29816, 29725, 29729, 29821, 29817
40953, 29725, 29729, 29821, 29817, 29726, 29730, 29822, 29818
40954, 29726, 29730, 29822, 29818, 12365, 12366, 12389, 12388
40955, 8538, 8539, 8562, 8561, 29727, 29731, 29823, 29819
40956, 29727, 29731, 29823, 29819, 29728, 29732, 29824, 29820
40957, 29728, 29732, 29824, 29820, 29729, 29733, 29825, 29821
40958, 29729, 29733, 29825, 29821, 29730, 29734, 29826, 29822
40959, 29730, 29734, 29826, 29822, 12366, 12367, 12390, 12389
40960, 8539, 8540, 8563, 8562, 29731, 29735, 29827, 29823
40961, 29731, 29735, 29827, 29823, 29732, 29736, 29828, 29824
40962, 29732, 29736, 29828, 29824, 29733, 29737, 29829, 29825
40963, 29733, 29737, 29829, 29825, 29734, 29738, 29830, 29826
40964, 29734, 29738, 29830, 29826, 12367, 12368, 12391, 12390
40965, 8540, 8541, 8564, 8563, 29735, 29739, 29831, 29827
40966, 29735, 29739, 29831, 29827, 29736, 29740, 29832, 29828
40967, 29736, 29740, 29832, 29828, 29737, 29741, 29833, 29829
40968, 29737, 29741, 29833, 29829, 29738, 29742, 29834, 29830
40969, 29738, 29742, 29834, 29830, 12368, 12369, 12392, 12391
40970, 8541, 8542, 8565, 8564, 29739, 29743, 29835, 29831
40971, 29739, 29743, 29835, 29831, 29740, 29744, 29836, 29832
40972, 29740, 29744, 29836, 29832, 29741, 29745, 29837, 29833
40973, 29741, 29745, 29837, 29833, 29742, 29746, 29838, 29834
40974, 29742, 29746, 29838, 29834, 12369, 12370, 12393, 12392
40975, 8542, 8543, 8566, 8565, 29743, 29747, 29839, 29835
40976, 29743, 29747, 29839, 29835, 29744, 29748, 29840, 29836
40977, 29744, 29748, 29840, 29836, 29745, 29749, 29841, 29837
40978, 29745, 29749, 29841, 29837, 29746, 29750, 29842, 29838
40979, 29746, 29750, 29842, 29838, 12370, 12371, 12394, 12393
40980, 8543, 8544, 8567, 8566, 29747, 29751, 29843, 29839
40981, 29747, 29751, 29843, 29839, 29748, 29752, 29844, 29840
40982, 29748, 29752, 29844, 29840, 29749, 29753, 29845, 29841
40983, 29749, 29753, 29845, 29841, 29750, 29754, 29846, 29842
40984, 29750, 29754, 29846, 29842, 12371, 12372, 12395, 12394
40985, 8544, 8545, 8568, 8567, 29751, 29755, 29847, 29843
40986, 29751, 29755, 29847, 29843, 29752, 29756, 29848, 29844
40987, 29752, 29756, 29848, 29844, 29753, 29757, 29849, 29845
40988, 29753, 29757, 29849, 29845, 29754, 29758, 29850, 29846
40989, 29754, 29758, 29850, 29846, 12372, 12373, 12396, 12395
40990, 8545, 8546, 8569, 8568, 29755, 29759, 29851, 29847
40991, 29755, 29759, 29851, 29847, 29756, 29760, 29852, 29848
40992, 29756, 29760, 29852, 29848, 29757, 29761, 29853, 29849
40993, 29757, 29761, 29853, 29849, 29758, 29762, 29854, 29850
40994, 29758, 29762, 29854, 29850, 12373, 12374, 12397, 12396
40995, 8546, 8547, 8570, 8569, 29759, 29763, 29855, 29851
40996, 29759, 29763, 29855, 29851, 29760, 29764, 29856, 29852
40997, 29760, 29764, 29856, 29852, 29761, 29765, 29857, 29853
40998, 29761, 29765, 29857, 29853, 29762, 29766, 29858, 29854
40999, 29762, 29766, 29858, 29854, 12374, 12375, 12398, 12397
41000, 8547, 8548, 8571, 8570, 29763, 29767, 29859, 29855
41001, 29763, 29767, 29859, 29855, 29764, 29768, 29860, 29856
41002, 29764, 29768, 29860, 29856, 29765, 29769, 29861, 29857
41003, 29765, 29769, 29861, 29857, 29766, 29770, 29862, 29858
41004, 29766, 29770, 29862, 29858, 12375, 12376, 12399, 12398
41005, 8548, 8549, 8572, 8571, 29767, 29771, 29863, 29859
41006, 29767, 29771, 29863, 29859, 29768, 29772, 29864, 29860
41007, 29768, 29772, 29864, 29860, 29769, 29773, 29865, 29861
41008, 29769, 29773, 29865, 29861, 29770, 29774, 29866, 29862
41009, 29770, 29774, 29866, 29862, 12376, 12377, 12400, 12399
41010, 8549, 1135, 1136, 8572, 29771, 12292, 12296, 29863
41011, 29771, 12292, 12296, 29863, 29772, 12293, 12297, 29864
41012, 29772, 12293, 12297, 29864, 29773, 12294, 12298, 29865
41013, 29773, 12294, 12298, 29865, 29774, 12295, 12299, 29866
41014, 29774, 12295, 12299, 29866, 12377, 1916, 1917, 12400
41015, 1125, 8550, 8573, 1126, 12252, 29775, 29867, 12256
41016, 12252, 29775, 29867, 12256, 12253, 29776, 29868, 12257
41017, 12253, 29776, 29868, 12257, 12254, 29777, 29869, 12258
41018, 12254, 29777, 29869, 12258, 12255, 29778, 29870, 12259
41019, 12255, 29778, 29870, 12259, 1906, 12378, 12401, 1907
41020, 8550, 8551, 8574, 8573, 29775, 29779, 29871, 29867
41021, 29775, 29779, 29871, 29867, 29776, 29780, 29872, 29868
41022, 29776, 29780, 29872, 29868, 29777, 29781, 29873, 29869
41023, 29777, 29781, 29873, 29869, 29778, 29782, 29874, 29870
41024, 29778, 29782, 29874, 29870, 12378, 12379, 12402, 12401
41025, 8551, 8552, 8575, 8574, 29779, 29783, 29875, 29871
41026, 29779, 29783, 29875, 29871, 29780, 29784, 29876, 29872
41027, 29780, 29784, 29876, 29872, 29781, 29785, 29877, 29873
41028, 29781, 29785, 29877, 29873, 29782, 29786, 29878, 29874
41029, 29782, 29786, 29878, 29874, 12379, 12380, 12403, 12402
41030, 8552, 8553, 8576, 8575, 29783, 29787, 29879, 29875
41031, 29783, 29787, 29879, 29875, 29784, 29788, 29880, 29876
41032, 29784, 29788, 29880, 29876, 29785, 29789, 29881, 29877
41033, 29785, 29789, 29881, 29877, 29786, 29790, 29882, 29878
41034, 29786, 29790, 29882, 29878, 12380, 12381, 12404, 12403
41035, 8553, 8554, 8577, 8576, 29787, 29791, 29883, 29879
41036, 29787, 29791, 29883, 29879, 29788, 29792, 29884, 29880
41037, 29788, 29792, 29884, 29880, 29789, 29793, 29885, 29881
41038, 29789, 29793, 29885, 29881, 29790, 29794, 29886, 29882
41039, 29790, 29794, 29886, 29882, 12381, 12382, 12405, 12404
41040, 8554, 8555, 8578, 8577, 29791, 29795, 29887, 29883
41041, 29791, 29795, 29887, 29883, 29792, 29796, 29888, 29884
41042, 29792, 29796, 29888, 29884, 29793, 29797, 29889, 29885
41043, 29793, 29797, 29889, 29885, 29794, 29798, 29890, 29886
41044, 29794, 29798, 29890, 29886, 12382, 12383, 12406, 12405
41045, 8555, 8556, 8579, 8578, 29795, 29799, 29891, 29887
41046, 29795, 29799, 29891, 29887, 29796, 29800, 29892, 29888
41047, 29796, 29800, 29892, 29888, 29797, 29801, 29893, 29889
41048, 29797, 29801, 29893, 29889, 29798, 29802, 29894, 29890
41049, 29798, 29802, 29894, 29890, 12383, 12384, 12407, 12406
41050, 8556, 8557, 8580, 8579, 29799, 29803, 29895, 29891
41051, 29799, 29803, 29895, 29891, 29800, 29804, 29896, 29892
41052, 29800, 29804, 29896, 29892, 29801, 29805, 29897, 29893
41053, 29801, 29805, 29897, 29893, 29802, 29806, 29898, 29894
41054, 29802, 29806, 29898, 29894, 12384, 12385, 12408, 12407
41055, 8557, 8558, 8581, 8580, 29803, 29807, 29899, 29895
41056, 29803, 29807, 29899, 29895, 29804, 29808, 29900, 29896
41057, 29804, 29808, 29900, 29896, 29805, 29809, 29901, 29897
41058, 29805, 29809, 29901, 29897, 29806, 29810, 29902, 29898
41059, 29806, 29810, 29902, 29898, 12385, 12386, 12409, 12408
41060, 8558, 8559, 8582, 8581, 29807, 29811, 29903, 29899
41061, 29807, 29811, 29903, 29899, 29808, 29812, 29904, 29900
41062, 29808, 29812, 29904, 29900, 29809, 29813, 29905, 29901
41063, 29809, 29813, 29905, 29901, 29810, 29814, 29906, 29902
41064, 29810, 29814, 29906, 29902, 12386, 12387, 12410, 12409
41065, 8559, 8560, 8583, 8582, 29811, 29815, 29907, 29903
41066, 29811, 29815, 29907, 29903, 29812, 29816, 29908, 29904
41067, 29812, 29816, 29908, 29904, 29813, 29817, 29909, 29905
41068, 29813, 29817, 29909, 29905, 29814, 29818, 29910, 29906
41069, 29814, 29818, 29910, 29906, 12387, 12388, 12411, 12410
41070, 8560, 8561, 8584, 8583, 29815, 29819, 29911, 29907
41071, 29815, 29819, 29911, 29907, 29816, 29820, 29912, 29908
41072, 29816, 29820, 29912, 29908, 29817, 29821, 29913, 29909
41073, 29817, 29821, 29913, 29909, 29818, 29822, 29914, 29910
41074, 29818, 29822, 29914, 29910, 12388, 12389, 12412, 12411
41075, 8561, 8562, 8585, 8584, 29819, 29823, 29915, 29911
41076, 29819, 29823, 29915, 29911, 29820, 29824, 29916, 29912
41077, 29820, 29824, 29916, 29912, 29821, 29825, 29917, 29913
41078, 29821, 29825, 29917, 29913, 29822, 29826, 29918, 29914
41079, 29822, 29826, 29918, 29914, 12389, 12390, 12413, 12412
41080, 8562, 8563, 8586, 8585, 29823, 29827, 29919, 29915
41081, 29823, 29827, 29919, 29915, 29824, 29828, 29920, 29916
41082, 29824, 29828, 29920, 29916, 29825, 29829, 29921, 29917
41083, 29825, 29829, 29921, 29917, 29826, 29830, 29922, 29918
41084, 29826, 29830, 29922, 29918, 12390, 12391, 12414, 12413
41085, 8563, 8564, 8587, 8586, 29827, 29831, 29923, 29919
41086, 29827, 29831, 29923, 29919, 29828, 29832, 29924, 29920
41087, 29828, 29832, 29924, 29920, 29829, 29833, 29925, 29921
41088, 29829, 29833, 29925, 29921, 29830, 29834, 29926, 29922
41089, 29830, 29834, 29926, 29922, 12391, 12392, 12415, 12414
41090, 8564, 8565, 8588, 8587, 29831, 29835, 29927, 29923
41091, 29831, 29835, 29927, 29923, 29832, 29836, 29928, 29924
41092, 29832, 29836, 29928, 29924, 29833, 29837, 29929, 29925
41093, 29833, 29837, 29929, 29925, 29834, 29838, 29930, 29926
41094, 29834, 29838, 29930, 29926, 12392, 12393, 12416, 12415
41095, 8565, 8566, 8589, 8588, 29835, 29839, 29931, 29927
41096, 29835, 29839, 29931, 29927, 29836, 29840, 29932, 29928
41097, 29836, 29840, 29932, 29928, 29837, 29841, 29933, 29929
41098, 29837, 29841, 29933, 29929, 29838, 29842, 29934, 29930
41099, 29838, 29842, 29934, 29930, 12393, 12394, 12417, 12416
41100, 8566, 8567, 8590, 8589, 29839, 29843, 29935, 29931
41101, 29839, 29843, 29935, 29931, 29840, 29844, 29936, 29932
41102, 29840, 29844, 29936, 29932, 29841, 29845, 29937, 29933
41103, 29841, 29845, 29937, 29933, 29842, 29846, 29938, 29934
41104, 29842, 29846, 29938, 29934, 12394, 12395, 12418, 12417
41105, 8567, 8568, 8591, 8590, 29843, 29847, 29939, 29935
41106, 29843, 29847, 29939, 29935, 29844, 29848, 29940, 29936
41107, 29844, 29848, 29940, 29936, 29845, 29849, 29941, 29937
41108, 29845, 29849, 29941, 29937, 29846, 29850, 29942, 29938
41109, 29846, 29850, 29942, 29938, 12395, 12396, 12419, 12418
41110, 8568, 8569, 8592, 8591, 29847, 29851, 29943, 29939
41111, 29847, 29851, 29943, 29939, 29848, 29852, 29944, 29940
41112, 29848, 29852, 29944, 29940, 29849, 29853, 29945, 29941
41113, 29849, 29853, 29945, 29941, 29850, 29854, 29946, 29942
41114, 29850, 29854, 29946, 29942, 12396, 12397, 12420, 12419
41115, 8569, 8570, 8593, 8592, 29851, 29855, 29947, 29943
41116, 29851, 29855, 29947, 29943, 29852, 29856, 29948, 29944
41117, 29852, 29856, 29948, 29944, 29853, 29857, 29949, 29945
41118, 29853, 29857, 29949, 29945, 29854, 29858, 29950, 29946
41119, 29854, 29858, 29950, 29946, 12397, 12398, 12421, 12420
41120, 8570, 8571, 8594, 8593, 29855, 29859, 29951, 29947
41121, 29855, 29859, 29951, 29947, 29856, 29860, 29952, 29948
41122, 29856, 29860, 29952, 29948, 29857, 29861, 29953, 29949
41123, 29857, 29861, 29953, 29949, 29858, 29862, 29954, 29950
41124, 29858, 29862, 29954, 29950, 12398, 12399, 12422, 12421
41125, 8571, 8572, 8595, 8594, 29859, 29863, 29955, 29951
41126, 29859, 29863, 29955, 29951, 29860, 29864, 29956, 29952
41127, 29860, 29864, 29956, 29952, 29861, 29865, 29957, 29953
41128, 29861, 29865, 29957, 29953, 29862, 29866, 29958, 29954
41129, 29862, 29866, 29958, 29954, 12399, 12400, 12423, 12422
41130, 8572, 1136, 1137, 8595, 29863, 12296, 12300, 29955
41131, 29863, 12296, 12300, 29955, 29864, 12297, 12301, 29956
41132, 29864, 12297, 12301, 29956, 29865, 12298, 12302, 29957
41133, 29865, 12298, 12302, 29957, 29866, 12299, 12303, 29958
41134, 29866, 12299, 12303, 29958, 12400, 1917, 1918, 12423
41135, 1126, 8573, 8596, 1127, 12256, 29867, 29959, 12260
41136, 12256, 29867, 29959, 12260, 12257, 29868, 29960, 12261
41137, 12257, 29868, 29960, 12261, 12258, 29869, 29961, 12262
41138, 12258, 29869, 29961, 12262, 12259, 29870, 29962, 12263
41139, 12259, 29870, 29962, 12263, 1907, 12401, 12424, 1908
41140, 8573, 8574, 8597, 8596, 29867, 29871, 29963, 29959
41141, 29867, 29871, 29963, 29959, 29868, 29872, 29964, 29960
41142, 29868, 29872, 29964, 29960, 29869, 29873, 29965, 29961
41143, 29869, 29873, 29965, 29961, 29870, 29874, 29966, 29962
41144, 29870, 29874, 29966, 29962, 12401, 12402, 12425, 12424
41145, 8574, 8575, 8598, 8597, 29871, 29875, 29967, 29963
41146, 29871, 29875, 29967, 29963, 29872, 29876, 29968, 29964
41147, 29872, 29876, 29968, 29964, 29873, 29877, 29969, 29965
41148, 29873, 29877, 29969, 29965, 29874, 29878, 29970, 29966
41149, 29874, 29878, 29970, 29966, 12402, 12403, 12426, 12425
41150, 8575, 8576, 8599, 8598, 29875, 29879, 29971, 29967
41151, 29875, 29879, 29971, 29967, 29876, 29880, 29972, 29968
41152, 29876, 29880, 29972, 29968, 29877, 29881, 29973, 29969
41153, 29877, 29881, 29973, 29969, 29878, 29882, 29974, 29970
41154, 29878, 29882, 29974, 29970, 12403, 12404, 12427, 12426
41155, 8576, 8577, 8600, 8599, 29879, 29883, 29975, 29971
41156, 29879, 29883, 29975, 29971, 29880, 29884, 29976, 29972
41157, 29880, 29884, 29976, 29972, 29881, 29885, 29977, 29973
41158, 29881, 29885, 29977, 29973, 29882, 29886, 29978, 29974
41159, 29882, 29886, 29978, 29974, 12404, 12405, 12428, 12427
41160, 8577, 8578, 8601, 8600, 29883, 29887, 29979, 29975
41161, 29883, 29887, 29979, 29975, 29884, 29888, 29980, 29976
41162, 29884, 29888, 29980, 29976, 29885, 29889, 29981, 29977
41163, 29885, 29889, 29981, 29977, 29886, 29890, 29982, 29978
41164, 29886, 29890, 29982, 29978, 12405, 12406, 12429, 12428
41165, 8578, 8579, 8602, 8601, 29887, 29891, 29983, 29979
41166, 29887, 29891, 29983, 29979, 29888, 29892, 29984, 29980
41167, 29888, 29892, 29984, 29980, 29889, 29893, 29985, 29981
41168, 29889, 29893, 29985, 29981, 29890, 29894, 29986, 29982
41169, 29890, 29894, 29986, 29982, 12406, 12407, 12430, 12429
41170, 8579, 8580, 8603, 8602, 29891, 29895, 29987, 29983
41171, 29891, 29895, 29987, 29983, 29892, 29896, 29988, 29984
41172, 29892, 29896, 29988, 29984, 29893, 29897, 29989, 29985
41173, 29893, 29897, 29989, 29985, 29894, 29898, 29990, 29986
41174, 29894, 29898, 29990, 29986, 12407, 12408, 12431, 12430
41175, 8580, 8581, 8604, 8603, 29895, 29899, 29991, 29987
41176, 29895, 29899, 29991, 29987, 29896, 29900, 29992, 29988
41177, 29896, 29900, 29992, 29988, 29897, 29901, 29993, 29989
41178, 29897, 29901, 29993, 29989, 29898, 29902, 29994, 29990
41179, 29898, 29902, 29994, 29990, 12408, 12409, 12432, 12431
41180, 8581, 8582, 8605, 8604, 29899, 29903, 29995, 29991
41181, 29899, 29903, 29995, 29991, 29900, 29904, 29996, 29992
41182, 29900, 29904, 29996, 29992, 29901, 29905, 29997, 29993
41183, 29901, 29905, 29997, 29993, 29902, 29906, 29998, 29994
41184, 29902, 29906, 29998, 29994, 12409, 12410, 12433, 12432
41185, 8582, 8583, 8606, 8605, 29903, 29907, 29999, 29995
41186, 29903, 29907, 29999, 29995, 29904, 29908, 30000, 29996
41187, 29904, 29908, 30000, 29996, 29905, 29909, 30001, 29997
41188, 29905, 29909, 30001, 29997, 29906, 29910, 30002, 29998
41189, 29906, 29910, 30002, 29998, 12410, 12411, 12434, 12433
41190, 8583, 8584, 8607, 8606, 29907, 29911, 30003, 29999
41191, 29907, 29911, 30003, 29999, 29908, 29912, 30004, 30000
41192, 29908, 29912, 30004, 30000, 29909, 29913, 30005, 30001
41193, 29909, 29913, 30005, 30001, 29910, 29914, 30006, 30002
41194, 29910, 29914, 30006, 30002, 12411, 12412, 12435, 12434
41195, 8584, 8585, 8608, 8607, 29911, 29915, 30007, 30003
41196, 29911, 29915, 30007, 30003, 29912, 29916, 30008, 30004
41197, 29912, 29916, 30008, 30004, 29913, 29917, 30009, 30005
41198, 29913, 29917, 30009, 30005, 29914, 29918, 30010, 30006
41199, 29914, 29918, 30010, 30006, 12412, 12413, 12436, 12435
41200, 8585, 8586, 8609, 8608, 29915, 29919, 30011, 30007
41201, 29915, 29919, 30011, 30007, 29916, 29920, 30012, 30008
41202, 29916, 29920, 30012, 30008, 29917, 29921, 30013, 30009
41203, 29917, 29921, 30013, 30009, 29918, 29922, 30014, 30010
41204, 29918, 29922, 30014, 30010, 12413, 12414, 12437, 12436
41205, 8586, 8587, 8610, 8609, 29919, 29923, 30015, 30011
41206, 29919, 29923, 30015, 30011, 29920, 29924, 30016, 30012
41207, 29920, 29924, 30016, 30012, 29921, 29925, 30017, 30013
41208, 29921, 29925, 30017, 30013, 29922, 29926, 30018, 30014
41209, 29922, 29926, 30018, 30014, 12414, 12415, 12438, 12437
41210, 8587, 8588, 8611, 8610, 29923, 29927, 30019, 30015
41211, 29923, 29927, 30019, 30015, 29924, 29928, 30020, 30016
41212, 29924, 29928, 30020, 30016, 29925, 29929, 30021, 30017
41213, 29925, 29929, 30021, 30017, 29926, 29930, 30022, 30018
41214, 29926, 29930, 30022, 30018, 12415, 12416, 12439, 12438
41215, 8588, 8589, 8612, 8611, 29927, 29931, 30023, 30019
41216, 29927, 29931, 30023, 30019, 29928, 29932, 30024, 30020
41217, 29928, 29932, 30024, 30020, 29929, 29933, 30025, 30021
41218, 29929, 29933, 30025, 30021, 29930, 29934, 30026, 30022
41219, 29930, 29934, 30026, 30022, 12416, 12417, 12440, 12439
41220, 8589, 8590, 8613, 8612, 29931, 29935, 30027, 30023
41221, 29931, 29935, 30027, 30023, 29932, 29936, 30028, 30024
41222, 29932, 29936, 30028, 30024, 29933, 29937, 30029, 30025
41223, 29933, 29937, 30029, 30025, 29934, 29938, 30030, 30026
41224, 29934, 29938, 30030, 30026, 12417, 12418, 12441, 12440
41225, 8590, 8591, 8614, 8613, 29935, 29939, 30031, 30027
41226, 29935, 29939, 30031, 30027, 29936, 29940, 30032, 30028
41227, 29936, 29940, 30032, 30028, 29937, 29941, 30033, 30029
41228, 29937, 29941, 30033, 30029, 29938, 29942, 30034, 30030
41229, 29938, 29942, 30034, 30030, 12418, 12419, 12442, 12441
41230, 8591, 8592, 8615, 8614, 29939, 29943, 30035, 30031
41231, 29939, 29943, 30035, 30031, 29940, 29944, 30036, 30032
41232, 29940, 29944, 30036, 30032, 29941, 29945, 30037, 30033
41233, 29941, 29945, 30037, 30033, 29942, 29946, 30038, 30034
41234, 29942, 29946, 30038, 30034, 12419, 12420, 12443, 12442
41235, 8592, 8593, 8616, 8615, 29943, 29947, 30039, 30035
41236, 29943, 29947, 30039, 30035, 29944, 29948, 30040, 30036
41237, 29944, 29948, 30040, 30036, 29945, 29949, 30041, 30037
41238, 29945, 29949, 30041, 30037, 29946, 29950, 30042, 30038
41239, 29946, 29950, 30042, 30038, 12420, 12421, 12444, 12443
41240, 8593, 8594, 8617, 8616, 29947, 29951, 30043, 30039
41241, 29947, 29951, 30043, 30039, 29948, 29952, 30044, 30040
41242, 29948, 29952, 30044, 30040, 29949, 29953, 30045, 30041
41243, 29949, 29953, 30045, 30041, 29950, 29954, 30046, 30042
41244, 29950, 29954, 30046, 30042, 12421, 12422, 12445, 12444
41245, 8594, 8595, 8618, 8617, 29951, 29955, 30047, 30043
41246, 29951, 29955, 30047, 30043, 29952, 29956, 30048, 30044
41247, 29952, 29956, 30048, 30044, 29953, 29957, 30049, 30045
41248, 29953, 29957, 30049, 30045, 29954, 29958, 30050, 30046
41249, 29954, 29958, 30050, 30046, 12422, 12423, 12446, 12445
41250, 8595, 1137, 1138, 8618, 29955, 12300, 12304, 30047
41251, 29955, 12300, 12304, 30047, 29956, 12301, 12305, 30048
41252, 29956, 12301, 12305, 30048, 29957, 12302, 12306, 30049
41253, 29957, 12302, 12306, 30049, 29958, 12303, 12307, 30050
41254, 29958, 12303, 12307, 30050, 12423, 1918, 1919, 12446
41255, 1127, 8596, 8619, 1128, 12260, 29959, 30051, 12264
41256, 12260, 29959, 30051, 12264, 12261, 29960, 30052, 12265
41257, 12261, 29960, 30052, 12265, 12262, 29961, 30053, 12266
41258, 12262, 29961, 30053, 12266, 12263, 29962, 30054, 12267
41259, 12263, 29962, 30054, 12267, 1908, 12424, 12447, 1909
41260, 8596, 8597, 8620, 8619, 29959, 29963, 30055, 30051
41261, 29959, 29963, 30055, 30051, 29960, 29964, 30056, 30052
41262, 29960, 29964, 30056, 30052, 29961, 29965, 30057, 30053
41263, 29961, 29965, 30057, 30053, 29962, 29966, 30058, 30054
41264, 29962, 29966, 30058, 30054, 12424, 12425, 12448, 12447
41265, 8597, 8598, 8621, 8620, 29963, 29967, 30059, 30055
41266, 29963, 29967, 30059, 30055, 29964, 29968, 30060, 30056
41267, 29964, 29968, 30060, 30056, 29965, 29969, 30061, 30057
41268, 29965, 29969, 30061, 30057, 29966, 29970, 30062, 30058
41269, 29966, 29970, 30062, 30058, 12425, 12426, 12449, 12448
41270, 8598, 8599, 8622, 8621, 29967, 29971, 30063, 30059
41271, 29967, 29971, 30063, 30059, 29968, 29972, 30064, 30060
41272, 29968, 29972, 30064, 30060, 29969, 29973, 30065, 30061
41273, 29969, 29973, 30065, 30061, 29970, 29974, 30066, 30062
41274, 29970, 29974, 30066, 30062, 12426, 12427, 12450, 12449
41275, 8599, 8600, 8623, 8622, 29971, 29975, 30067, 30063
41276, 29971, 29975, 30067, 30063, 29972, 29976, 30068, 30064
41277, 29972, 29976, 30068, 30064, 29973, 29977, 30069, 30065
41278, 29973, 29977, 30069, 30065, 29974, 29978, 30070, 30066
41279, 29974, 29978, 30070, 30066, 12427, 12428, 12451, 12450
41280, 8600, 8601, 8624, 8623, 29975, 29979, 30071, 30067
41281, 29975, 29979, 30071, 30067, 29976, 29980, 30072, 30068
41282, 29976, 29980, 30072, 30068, 29977, 29981, 30073, 30069
41283, 29977, 29981, 30073, 30069, 29978, 29982, 30074, 30070
41284, 29978, 29982, 30074, 30070, 12428, 12429, 12452, 12451
41285, 8601, 8602, 8625, 8624, 29979, 29983, 30075, 30071
41286, 29979, 29983, 30075, 30071, 29980, 29984, 30076, 30072
41287, 29980, 29984, 30076, 30072, 29981, 29985, 30077, 30073
41288, 29981, 29985, 30077, 30073, 29982, 29986, 30078, 30074
41289, 29982, 29986, 30078, 30074, 12429, 12430, 12453, 12452
41290, 8602, 8603, 8626, 8625, 29983, 29987, 30079, 30075
41291, 29983, 29987, 30079, 30075, 29984, 29988, 30080, 30076
41292, 29984, 29988, 30080, 30076, 29985, 29989, 30081, 30077
41293, 29985, 29989, 30081, 30077, 29986, 29990, 30082, 30078
41294, 29986, 29990, 30082, 30078, 12430, 12431, 12454, 12453
41295, 8603, 8604, 8627, 8626, 29987, 29991, 30083, 30079
41296, 29987, 29991, 30083, 30079, 29988, 29992, 30084, 30080
41297, 29988, 29992, 30084, 30080, 29989, 29993, 30085, 30081
41298, 29989, 29993, 30085, 30081, 29990, 29994, 30086, 30082
41299, 29990, 29994, 30086, 30082, 12431, 12432, 12455, 12454
41300, 8604, 8605, 8628, 8627, 29991, 29995, 30087, 30083
41301, 29991, 29995, 30087, 30083, 29992, 29996, 30088, 30084
41302, 29992, 29996, 30088, 30084, 29993, 29997, 30089, 30085
41303, 29993, 29997, 30089, 30085, 29994, 29998, 30090, 30086
41304, 29994, 29998, 30090, 30086, 12432, 12433, 12456, 12455
41305, 8605, 8606, 8629, 8628, 29995, 29999, 30091, 30087
41306, 29995, 29999, 30091, 30087, 29996, 30000, 30092, 30088
41307, 29996, 30000, 30092, 30088, 29997, 30001, 30093, 30089
41308, 29997, 30001, 30093, 30089, 29998, 30002, 30094, 30090
41309, 29998, 30002, 30094, 30090, 12433, 12434, 12457, 12456
41310, 8606, 8607, 8630, 8629, 29999, 30003, 30095, 30091
41311, 29999, 30003, 30095, 30091, 30000, 30004, 30096, 30092
41312, 30000, 30004, 30096, 30092, 30001, 30005, 30097, 30093
41313, 30001, 30005, 30097, 30093, 30002, 30006, 30098, 30094
41314, 30002, 30006, 30098, 30094, 12434, 12435, 12458, 12457
41315, 8607, 8608, 8631, 8630, 30003, 30007, 30099, 30095
41316, 30003, 30007, 30099, 30095, 30004, 30008, 30100, 30096
41317, 30004, 30008, 30100, 30096, 30005, 30009, 30101, 30097
41318, 30005, 30009, 30101, 30097, 30006, 30010, 30102, 30098
41319, 30006, 30010, 30102, 30098, 12435, 12436, 12459, 12458
41320, 8608, 8609, 8632, 8631, 30007, 30011, 30103, 30099
41321, 30007, 30011, 30103, 30099, 30008, 30012, 30104, 30100
41322, 30008, 30012, 30104, 30100, 30009, 30013, 30105, 30101
41323, 30009, 30013, 30105, 30101, 30010, 30014, 30106, 30102
41324, 30010, 30014, 30106, 30102, 12436, 12437, 12460, 12459
41325, 8609, 8610, 8633, 8632, 30011, 30015, 30107, 30103
41326, 30011, 30015, 30107, 30103, 30012, 30016, 30108, 30104
41327, 30012, 30016, 30108, 30104, 30013, 30017, 30109, 30105
41328, 30013, 30017, 30109, 30105, 30014, 30018, 30110, 30106
41329, 30014, 30018, 30110, 30106, 12437, 12438, 12461, 12460
41330, 8610, 8611, 8634, 8633, 30015, 30019, 30111, 30107
41331, 30015, 30019, 30111, 30107, 30016, 30020, 30112, 30108
41332, 30016, 30020, 30112, 30108, 30017, 30021, 30113, 30109
41333, 30017, 30021, 30113, 30109, 30018, 30022, 30114, 30110
41334, 30018, 30022, 30114, 30110, 12438, 12439, 12462, 12461
41335, 8611, 8612, 8635, 8634, 30019, 30023, 30115, 30111
41336, 30019, 30023, 30115, 30111, 30020, 30024, 30116, 30112
41337, 30020, 30024, 30116, 30112, 30021, 30025, 30117, 30113
41338, 30021, 30025, 30117, 30113, 30022, 30026, 30118, 30114
41339, 30022, 30026, 30118, 30114, 12439, 12440, 12463, 12462
41340, 8612, 8613, 8636, 8635, 30023, 30027, 30119, 30115
41341, 30023, 30027, 30119, 30115, 30024, 30028, 30120, 30116
41342, 30024, 30028, 30120, 30116, 30025, 30029, 30121, 30117
41343, 30025, 30029, 30121, 30117, 30026, 30030, 30122, 30118
41344, 30026, 30030, 30122, 30118, 12440, 12441, 12464, 12463
41345, 8613, 8614, 8637, 8636, 30027, 30031, 30123, 30119
41346, 30027, 30031, 30123, 30119, 30028, 30032, 30124, 30120
41347, 30028, 30032, 30124, 30120, 30029, 30033, 30125, 30121
41348, 30029, 30033, 30125, 30121, 30030, 30034, 30126, 30122
41349, 30030, 30034, 30126, 30122, 12441, 12442, 12465, 12464
41350, 8614, 8615, 8638, 8637, 30031, 30035, 30127, 30123
41351, 30031, 30035, 30127, 30123, 30032, 30036, 30128, 30124
41352, 30032, 30036, 30128, 30124, 30033, 30037, 30129, 30125
41353, 30033, 30037, 30129, 30125, 30034, 30038, 30130, 30126
41354, 30034, 30038, 30130, 30126, 12442, 12443, 12466, 12465
41355, 8615, 8616, 8639, 8638, 30035, 30039, 30131, 30127
41356, 30035, 30039, 30131, 30127, 30036, 30040, 30132, 30128
41357, 30036, 30040, 30132, 30128, 30037, 30041, 30133, 30129
41358, 30037, 30041, 30133, 30129, 30038, 30042, 30134, 30130
41359, 30038, 30042, 30134, 30130, 12443, 12444, 12467, 12466
41360, 8616, 8617, 8640, 8639, 30039, 30043, 30135, 30131
41361, 30039, 30043, 30135, 30131, 30040, 30044, 30136, 30132
41362, 30040, 30044, 30136, 30132, 30041, 30045, 30137, 30133
41363, 30041, 30045, 30137, 30133, 30042, 30046, 30138, 30134
41364, 30042, 30046, 30138, 30134, 12444, 12445, 12468, 12467
41365, 8617, 8618, 8641, 8640, 30043, 30047, 30139, 30135
41366, 30043, 30047, 30139, 30135, 30044, 30048, 30140, 30136
41367, 30044, 30048, 30140, 30136, 30045, 30049, 30141, 30137
41368, 30045, 30049, 30141, 30137, 30046, 30050, 30142, 30138
41369, 30046, 30050, 30142, 30138, 12445, 12446, 12469, 12468
41370, 8618, 1138, 1139, 8641, 30047, 12304, 12308, 30139
41371, 30047, 12304, 12308, 30139, 30048, 12305, 12309, 30140
41372, 30048, 12305, 12309, 30140, 30049, 12306, 12310, 30141
41373, 30049, 12306, 12310, 30141, 30050, 12307, 12311, 30142
41374, 30050, 12307, 12311, 30142, 12446, 1919, 1920, 12469
41375, 1128, 8619, 8642, 1129, 12264, 30051, 30143, 12268
41376, 12264, 30051, 30143, 12268, 12265, 30052, 30144, 12269
41377, 12265, 30052, 30144, 12269, 12266, 30053, 30145, 12270
41378, 12266, 30053, 30145, 12270, 12267, 30054, 30146, 12271
41379, 12267, 30054, 30146, 12271, 1909, 12447, 12470, 1910
41380, 8619, 8620, 8643, 8642, 30051, 30055, 30147, 30143
41381, 30051, 30055, 30147, 30143, 30052, 30056, 30148, 30144
41382, 30052, 30056, 30148, 30144, 30053, 30057, 30149, 30145
41383, 30053, 30057, 30149, 30145, 30054, 30058, 30150, 30146
41384, 30054, 30058, 30150, 30146, 12447, 12448, 12471, 12470
41385, 8620, 8621, 8644, 8643, 30055, 30059, 30151, 30147
41386, 30055, 30059, 30151, 30147, 30056, 30060, 30152, 30148
41387, 30056, 30060, 30152, 30148, 30057, 30061, 30153, 30149
41388, 30057, 30061, 30153, 30149, 30058, 30062, 30154, 30150
41389, 30058, 30062, 30154, 30150, 12448, 12449, 12472, 12471
41390, 8621, 8622, 8645, 8644, 30059, 30063, 30155, 30151
41391, 30059, 30063, 30155, 30151, 30060, 30064, 30156, 30152
41392, 30060, 30064, 30156, 30152, 30061, 30065, 30157, 30153
41393, 30061, 30065, 30157, 30153, 30062, 30066, 30158, 30154
41394, 30062, 30066, 30158, 30154, 12449, 12450, 12473, 12472
41395, 8622, 8623, 8646, 8645, 30063, 30067, 30159, 30155
41396, 30063, 30067, 30159, 30155, 30064, 30068, 30160, 30156
41397, 30064, 30068, 30160, 30156, 30065, 30069, 30161, 30157
41398, 30065, 30069, 30161, 30157, 30066, 30070, 30162, 30158
41399, 30066, 30070, 30162, 30158, 12450, 12451, 12474, 12473
41400, 8623, 8624, 8647, 8646, 30067, 30071, 30163, 30159
41401, 30067, 30071, 30163, 30159, 30068, 30072, 30164, 30160
41402, 30068, 30072, 30164, 30160, 30069, 30073, 30165, 30161
41403, 30069, 30073, 30165, 30161, 30070, 30074, 30166, 30162
41404, 30070, 30074, 30166, 30162, 12451, 12452, 12475, 12474
41405, 8624, 8625, 8648, 8647, 30071, 30075, 30167, 30163
41406, 30071, 30075, 30167, 30163, 30072, 30076, 30168, 30164
41407, 30072, 30076, 30168, 30164, 30073, 30077, 30169, 30165
41408, 30073, 30077, 30169, 30165, 30074, 30078, 30170, 30166
41409, 30074, 30078, 30170, 30166, 12452, 12453, 12476, 12475
41410, 8625, 8626, 8649, 8648, 30075, 30079, 30171, 30167
41411, 30075, 30079, 30171, 30167, 30076, 30080, 30172, 30168
41412, 30076, 30080, 30172, 30168, 30077, 30081, 30173, 30169
41413, 30077, 30081, 30173, 30169, 30078, 30082, 30174, 30170
41414, 30078, 30082, 30174, 30170, 12453, 12454, 12477, 12476
41415, 8626, 8627, 8650, 8649, 30079, 30083, 30175, 30171
41416, 30079, 30083, 30175, 30171, 30080, 30084, 30176, 30172
41417, 30080, 30084, 30176, 30172, 30081, 30085, 30177, 30173
41418, 30081, 30085, 30177, 30173, 30082, 30086, 30178, 30174
41419, 30082, 30086, 30178, 30174, 12454, 12455, 12478, 12477
41420, 8627, 8628, 8651, 8650, 30083, 30087, 30179, 30175
41421, 30083, 30087, 30179, 30175, 30084, 30088, 30180, 30176
41422, 30084, 30088, 30180, 30176, 30085, 30089, 30181, 30177
41423, 30085, 30089, 30181, 30177, 30086, 30090, 30182, 30178
41424, 30086, 30090, 30182, 30178, 12455, 12456, 12479, 12478
41425, 8628, 8629, 8652, 8651, 30087, 30091, 30183, 30179
41426, 30087, 30091, 30183, 30179, 30088, 30092, 30184, 30180
41427, 30088, 30092, 30184, 30180, 30089, 30093, 30185, 30181
41428, 30089, 30093, 30185, 30181, 30090, 30094, 30186, 30182
41429, 30090, 30094, 30186, 30182, 12456, 12457, 12480, 12479
41430, 8629, 8630, 8653, 8652, 30091, 30095, 30187, 30183
41431, 30091, 30095, 30187, 30183, 30092, 30096, 30188, 30184
41432, 30092, 30096, 30188, 30184, 30093, 30097, 30189, 30185
41433, 30093, 30097, 30189, 30185, 30094, 30098, 30190, 30186
41434, 30094, 30098, 30190, 30186, 12457, 12458, 12481, 12480
41435, 8630, 8631, 8654, 8653, 30095, 30099, 30191, 30187
41436, 30095, 30099, 30191, 30187, 30096, 30100, 30192, 30188
41437, 30096, 30100, 30192, 30188, 30097, 30101, 30193, 30189
41438, 30097, 30101, 30193, 30189, 30098, 30102, 30194, 30190
41439, 30098, 30102, 30194, 30190, 12458, 12459, 12482, 12481
41440, 8631, 8632, 8655, 8654, 30099, 30103, 30195, 30191
41441, 30099, 30103, 30195, 30191, 30100, 30104, 30196, 30192
41442, 30100, 30104, 30196, 30192, 30101, 30105, 30197, 30193
41443, 30101, 30105, 30197, 30193, 30102, 30106, 30198, 30194
41444, 30102, 30106, 30198, 30194, 12459, 12460, 12483, 12482
41445, 8632, 8633, 8656, 8655, 30103, 30107, 30199, 30195
41446, 30103, 30107, 30199, 30195, 30104, 30108, 30200, 30196
41447, 30104, 30108, 30200, 30196, 30105, 30109, 30201, 30197
41448, 30105, 30109, 30201, 30197, 30106, 30110, 30202, 30198
41449, 30106, 30110, 30202, 30198, 12460, 12461, 12484, 12483
41450, 8633, 8634, 8657, 8656, 30107, 30111, 30203, 30199
41451, 30107, 30111, 30203, 30199, 30108, 30112, 30204, 30200
41452, 30108, 30112, 30204, 30200, 30109, 30113, 30205, 30201
41453, 30109, 30113, 30205, 30201, 30110, 30114, 30206, 30202
41454, 30110, 30114, 30206, 30202, 12461, 12462, 12485, 12484
41455, 8634, 8635, 8658, 8657, 30111, 30115, 30207, 30203
41456, 30111, 30115, 30207, 30203, 30112, 30116, 30208, 30204
41457, 30112, 30116, 30208, 30204, 30113, 30117, 30209, 30205
41458, 30113, 30117, 30209, 30205, 30114, 30118, 30210, 30206
41459, 30114, 30118, 30210, 30206, 12462, 12463, 12486, 12485
41460, 8635, 8636, 8659, 8658, 30115, 30119, 30211, 30207
41461, 30115, 30119, 30211, 30207, 30116, 30120, 30212, 30208
41462, 30116, 30120, 30212, 30208, 30117, 30121, 30213, 30209
41463, 30117, 30121, 30213, 30209, 30118, 30122, 30214, 30210
41464, 30118, 30122, 30214, 30210, 12463, 12464, 12487, 12486
41465, 8636, 8637, 8660, 8659, 30119, 30123, 30215, 30211
41466, 30119, 30123, 30215, 30211, 30120, 30124, 30216, 30212
41467, 30120, 30124, 30216, 30212, 30121, 30125, 30217, 30213
41468, 30121, 30125, 30217, 30213, 30122, 30126, 30218, 30214
41469, 30122, 30126, 30218, 30214, 12464, 12465, 12488, 12487
41470, 8637, 8638, 8661, 8660, 30123, 30127, 30219, 30215
41471, 30123, 30127, 30219, 30215, 30124, 30128, 30220, 30216
41472, 30124, 30128, 30220, 30216, 30125, 30129, 30221, 30217
41473, 30125, 30129, 30221, 30217, 30126, 30130, 30222, 30218
41474, 30126, 30130, 30222, 30218, 12465, 12466, 12489, 12488
41475, 8638, 8639, 8662, 8661, 30127, 30131, 30223, 30219
41476, 30127, 30131, 30223, 30219, 30128, 30132, 30224, 30220
41477, 30128, 30132, 30224, 30220, 30129, 30133, 30225, 30221
41478, 30129, 30133, 30225, 30221, 30130, 30134, 30226, 30222
41479, 30130, 30134, 30226, 30222, 12466, 12467, 12490, 12489
41480, 8639, 8640, 8663, 8662, 30131, 30135, 30227, 30223
41481, 30131, 30135, 30227, 30223, 30132, 30136, 30228, 30224
41482, 30132, 30136, 30228, 30224, 30133, 30137, 30229, 30225
41483, 30133, 30137, 30229, 30225, 30134, 30138, 30230, 30226
41484, 30134, 30138, 30230, 30226, 12467, 12468, 12491, 12490
41485, 8640, 8641, 8664, 8663, 30135, 30139, 30231, 30227
41486, 30135, 30139, 30231, 30227, 30136, 30140, 30232, 30228
41487, 30136, 30140, 30232, 30228, 30137, 30141, 30233, 30229
41488, 30137, 30141, 30233, 30229, 30138, 30142, 30234, 30230
41489, 30138, 30142, 30234, 30230, 12468, 12469, 12492, 12491
41490, 8641, 1139, 1140, 8664, 30139, 12308, 12312, 30231
41491, 30139, 12308, 12312, 30231, 30140, 12309, 12313, 30232
41492, 30140, 12309, 12313, 30232, 30141, 12310, 12314, 30233
41493, 30141, 12310, 12314, 30233, 30142, 12311, 12315, 30234
41494, 30142, 12311, 12315, 30234, 12469, 1920, 1921, 12492
41495, 1129, 8642, 8665, 1130, 12268, 30143, 30235, 12272
41496, 12268, 30143, 30235, 12272, 12269, 30144, 30236, 12273
41497, 12269, 30144, 30236, 12273, 12270, 30145, 30237, 12274
41498, 12270, 30145, 30237, 12274, 12271, 30146, 30238, 12275
41499, 12271, 30146, 30238, 12275, 1910, 12470, 12493, 1911
41500, 8642, 8643, 8666, 8665, 30143, 30147, 30239, 30235
41501, 30143, 30147, 30239, 30235, 30144, 30148, 30240, 30236
41502, 30144, 30148, 30240, 30236, 30145, 30149, 30241, 30237
41503, 30145, 30149, 30241, 30237, 30146, 30150, 30242, 30238
41504, 30146, 30150, 30242, 30238, 12470, 12471, 12494, 12493
41505, 8643, 8644, 8667, 8666, 30147, 30151, 30243, 30239
41506, 30147, 30151, 30243, 30239, 30148, 30152, 30244, 30240
41507, 30148, 30152, 30244, 30240, 30149, 30153, 30245, 30241
41508, 30149, 30153, 30245, 30241, 30150, 30154, 30246, 30242
41509, 30150, 30154, 30246, 30242, 12471, 12472, 12495, 12494
41510, 8644, 8645, 8668, 8667, 30151, 30155, 30247, 30243
41511, 30151, 30155, 30247, 30243, 30152, 30156, 30248, 30244
41512, 30152, 30156, 30248, 30244, 30153, 30157, 30249, 30245
41513, 30153, 30157, 30249, 30245, 30154, 30158, 30250, 30246
41514, 30154, 30158, 30250, 30246, 12472, 12473, 12496, 12495
41515, 8645, 8646, 8669, 8668, 30155, 30159, 30251, 30247
41516, 30155, 30159, 30251, 30247, 30156, 30160, 30252, 30248
41517, 30156, 30160, 30252, 30248, 30157, 30161, 30253, 30249
41518, 30157, 30161, 30253, 30249, 30158, 30162, 30254, 30250
41519, 30158, 30162, 30254, 30250, 12473, 12474, 12497, 12496
41520, 8646, 8647, 8670, 8669, 30159, 30163, 30255, 30251
41521, 30159, 30163, 30255, 30251, 30160, 30164, 30256, 30252
41522, 30160, 30164, 30256, 30252, 30161, 30165, 30257, 30253
41523, 30161, 30165, 30257, 30253, 30162, 30166, 30258, 30254
41524, 30162, 30166, 30258, 30254, 12474, 12475, 12498, 12497
41525, 8647, 8648, 8671, 8670, 30163, 30167, 30259, 30255
41526, 30163, 30167, 30259, 30255, 30164, 30168, 30260, 30256
41527, 30164, 30168, 30260, 30256, 30165, 30169, 30261, 30257
41528, 30165, 30169, 30261, 30257, 30166, 30170, 30262, 30258
41529, 30166, 30170, 30262, 30258, 12475, 12476, 12499, 12498
41530, 8648, 8649, 8672, 8671, 30167, 30171, 30263, 30259
41531, 30167, 30171, 30263, 30259, 30168, 30172, 30264, 30260
41532, 30168, 30172, 30264, 30260, 30169, 30173, 30265, 30261
41533, 30169, 30173, 30265, 30261, 30170, 30174, 30266, 30262
41534, 30170, 30174, 30266, 30262, 12476, 12477, 12500, 12499
41535, 8649, 8650, 8673, 8672, 30171, 30175, 30267, 30263
41536, 30171, 30175, 30267, 30263, 30172, 30176, 30268, 30264
41537, 30172, 30176, 30268, 30264, 30173, 30177, 30269, 30265
41538, 30173, 30177, 30269, 30265, 30174, 30178, 30270, 30266
41539, 30174, 30178, 30270, 30266, 12477, 12478, 12501, 12500
41540, 8650, 8651, 8674, 8673, 30175, 30179, 30271, 30267
41541, 30175, 30179, 30271, 30267, 30176, 30180, 30272, 30268
41542, 30176, 30180, 30272, 30268, 30177, 30181, 30273, 30269
41543, 30177, 30181, 30273, 30269, 30178, 30182, 30274, 30270
41544, 30178, 30182, 30274, 30270, 12478, 12479, 12502, 12501
41545, 8651, 8652, 8675, 8674, 30179, 30183, 30275, 30271
41546, 30179, 30183, 30275, 30271, 30180, 30184, 30276, 30272
41547, 30180, 30184, 30276, 30272, 30181, 30185, 30277, 30273
41548, 30181, 30185, 30277, 30273, 30182, 30186, 30278, 30274
41549, 30182, 30186, 30278, 30274, 12479, 12480, 12503, 12502
41550, 8652, 8653, 8676, 8675, 30183, 30187, 30279, 30275
41551, 30183, 30187, 30279, 30275, 30184, 30188, 30280, 30276
41552, 30184, 30188, 30280, 30276, 30185, 30189, 30281, 30277
41553, 30185, 30189, 30281, 30277, 30186, 30190, 30282, 30278
41554, 30186, 30190, 30282, 30278, 12480, 12481, 12504, 12503
41555, 8653, 8654, 8677, 8676, 30187, 30191, 30283, 30279
41556, 30187, 30191, 30283, 30279, 30188, 30192, 30284, 30280
41557, 30188, 30192, 30284, 30280, 30189, 30193, 30285, 30281
41558, 30189, 30193, 30285, 30281, 30190, 30194, 30286, 30282
41559, 30190, 30194, 30286, 30282, 12481, 12482, 12505, 12504
41560, 8654, 8655, 8678, 8677, 30191, 30195, 30287, 30283
41561, 30191, 30195, 30287, 30283, 30192, 30196, 30288, 30284
41562, 30192, 30196, 30288, 30284, 30193, 30197, 30289, 30285
41563, 30193, 30197, 30289, 30285, 30194, 30198, 30290, 30286
41564, 30194, 30198, 30290, 30286, 12482, 12483, 12506, 12505
41565, 8655, 8656, 8679, 8678, 30195, 30199, 30291, 30287
41566, 30195, 30199, 30291, 30287, 30196, 30200, 30292, 30288
41567, 30196, 30200, 30292, 30288, 30197, 30201, 30293, 30289
41568, 30197, 30201, 30293, 30289, 30198, 30202, 30294, 30290
41569, 30198, 30202, 30294, 30290, 12483, 12484, 12507, 12506
41570, 8656, 8657, 8680, 8679, 30199, 30203, 30295, 30291
41571, 30199, 30203, 30295, 30291, 30200, 30204, 30296, 30292
41572, 30200, 30204, 30296, 30292, 30201, 30205, 30297, 30293
41573, 30201, 30205, 30297, 30293, 30202, 30206, 30298, 30294
41574, 30202, 30206, 30298, 30294, 12484, 12485, 12508, 12507
41575, 8657, 8658, 8681, 8680, 30203, 30207, 30299, 30295
41576, 30203, 30207, 30299, 30295, 30204, 30208, 30300, 30296
41577, 30204, 30208, 30300, 30296, 30205, 30209, 30301, 30297
41578, 30205, 30209, 30301, 30297, 30206, 30210, 30302, 30298
41579, 30206, 30210, 30302, 30298, 12485, 12486, 12509, 12508
41580, 8658, 8659, 8682, 8681, 30207, 30211, 30303, 30299
41581, 30207, 30211, 30303, 30299, 30208, 30212, 30304, 30300
41582, 30208, 30212, 30304, 30300, 30209, 30213, 30305, 30301
41583, 30209, 30213, 30305, 30301, 30210, 30214, 30306, 30302
41584, 30210, 30214, 30306, 30302, 12486, 12487, 12510, 12509
41585, 8659, 8660, 8683, 8682, 30211, 30215, 30307, 30303
41586, 30211, 30215, 30307, 30303, 30212, 30216, 30308, 30304
41587, 30212, 30216, 30308, 30304, 30213, 30217, 30309, 30305
41588, 30213, 30217, 30309, 30305, 30214, 30218, 30310, 30306
41589, 30214, 30218, 30310, 30306, 12487, 12488, 12511, 12510
41590, 8660, 8661, 8684, 8683, 30215, 30219, 30311, 30307
41591, 30215, 30219, 30311, 30307, 30216, 30220, 30312, 30308
41592, 30216, 30220, 30312, 30308, 30217, 30221, 30313, 30309
41593, 30217, 30221, 30313, 30309, 30218, 30222, 30314, 30310
41594, 30218, 30222, 30314, 30310, 12488, 12489, 12512, 12511
41595, 8661, 8662, 8685, 8684, 30219, 30223, 30315, 30311
41596, 30219, 30223, 30315, 30311, 30220, 30224, 30316, 30312
41597, 30220, 30224, 30316, 30312, 30221, 30225, 30317, 30313
41598, 30221, 30225, 30317, 30313, 30222, 30226, 30318, 30314
41599, 30222, 30226, 30318, 30314, 12489, 12490, 12513, 12512
41600, 8662, 8663, 8686, 8685, 30223, 30227, 30319, 30315
41601, 30223, 30227, 30319, 30315, 30224, 30228, 30320, 30316
41602, 30224, 30228, 30320, 30316, 30225, 30229, 30321, 30317
41603, 30225, 30229, 30321, 30317, 30226, 30230, 30322, 30318
41604, 30226, 30230, 30322, 30318, 12490, 12491, 12514, 12513
41605, 8663, 8664, 8687, 8686, 30227, 30231, 30323, 30319
41606, 30227, 30231, 30323, 30319, 30228, 30232, 30324, 30320
41607, 30228, 30232, 30324, 30320, 30229, 30233, 30325, 30321
41608, 30229, 30233, 30325, 30321, 30230, 30234, 30326, 30322
41609, 30230, 30234, 30326, 30322, 12491, 12492, 12515, 12514
41610, 8664, 1140, 1141, 8687, 30231, 12312, 12316, 30323
41611, 30231, 12312, 12316, 30323, 30232, 12313, 12317, 30324
41612, 30232, 12313, 12317, 30324, 30233, 12314, 12318, 30325
41613, 30233, 12314, 12318, 30325, 30234, 12315, 12319, 30326
41614, 30234, 12315, 12319, 30326, 12492, 1921, 1922, 12515
41615, 1130, 8665, 8688, 1131, 12272, 30235, 30327, 12276
41616, 12272, 30235, 30327, 12276, 12273, 30236, 30328, 12277
41617, 12273, 30236, 30328, 12277, 12274, 30237, 30329, 12278
41618, 12274, 30237, 30329, 12278, 12275, 30238, 30330, 12279
41619, 12275, 30238, 30330, 12279, 1911, 12493, 12516, 1912
41620, 8665, 8666, 8689, 8688, 30235, 30239, 30331, 30327
41621, 30235, 30239, 30331, 30327, 30236, 30240, 30332, 30328
41622, 30236, 30240, 30332, 30328, 30237, 30241, 30333, 30329
41623, 30237, 30241, 30333, 30329, 30238, 30242, 30334, 30330
41624, 30238, 30242, 30334, 30330, 12493, 12494, 12517, 12516
41625, 8666, 8667, 8690, 8689, 30239, 30243, 30335, 30331
41626, 30239, 30243, 30335, 30331, 30240, 30244, 30336, 30332
41627, 30240, 30244, 30336, 30332, 30241, 30245, 30337, 30333
41628, 30241, 30245, 30337, 30333, 30242, 30246, 30338, 30334
41629, 30242, 30246, 30338, 30334, 12494, 12495, 12518, 12517
41630, 8667, 8668, 8691, 8690, 30243, 30247, 30339, 30335
41631, 30243, 30247, 30339, 30335, 30244, 30248, 30340, 30336
41632, 30244, 30248, 30340, 30336, 30245, 30249, 30341, 30337
41633, 30245, 30249, 30341, 30337, 30246, 30250, 30342, 30338
41634, 30246, 30250, 30342, 30338, 12495, 12496, 12519, 12518
41635, 8668, 8669, 8692, 8691, 30247, 30251, 30343, 30339
41636, 30247, 30251, 30343, 30339, 30248, 30252, 30344, 30340
41637, 30248, 30252, 30344, 30340, 30249, 30253, 30345, 30341
41638, 30249, 30253, 30345, 30341, 30250, 30254, 30346, 30342
41639, 30250, 30254, 30346, 30342, 12496, 12497, 12520, 12519
41640, 8669, 8670, 8693, 8692, 30251, 30255, 30347, 30343
41641, 30251, 30255, 30347, 30343, 30252, 30256, 30348, 30344
41642, 30252, 30256, 30348, 30344, 30253, 30257, 30349, 30345
41643, 30253, 30257, 30349, 30345, 30254, 30258, 30350, 30346
41644, 30254, 30258, 30350, 30346, 12497, 12498, 12521, 12520
41645, 8670, 8671, 8694, 8693, 30255, 30259, 30351, 30347
41646, 30255, 30259, 30351, 30347, 30256, 30260, 30352, 30348
41647, 30256, 30260, 30352, 30348, 30257, 30261, 30353, 30349
41648, 30257, 30261, 30353, 30349, 30258, 30262, 30354, 30350
41649, 30258, 30262, 30354, 30350, 12498, 12499, 12522, 12521
41650, 8671, 8672, 8695, 8694, 30259, 30263, 30355, 30351
41651, 30259, 30263, 30355, 30351, 30260, 30264, 30356, 30352
41652, 30260, 30264, 30356, 30352, 30261, 30265, 30357, 30353
41653, 30261, 30265, 30357, 30353, 30262, 30266, 30358, 30354
41654, 30262, 30266, 30358, 30354, 12499, 12500, 12523, 12522
41655, 8672, 8673, 8696, 8695, 30263, 30267, 30359, 30355
41656, 30263, 30267, 30359, 30355, 30264, 30268, 30360, 30356
41657, 30264, 30268, 30360, 30356, 30265, 30269, 30361, 30357
41658, 30265, 30269, 30361, 30357, 30266, 30270, 30362, 30358
41659, 30266, 30270, 30362, 30358, 12500, 12501, 12524, 12523
41660, 8673, 8674, 8697, 8696, 30267, 30271, 30363, 30359
41661, 30267, 30271, 30363, 30359, 30268, 30272, 30364, 30360
41662, 30268, 30272, 30364, 30360, 30269, 30273, 30365, 30361
41663, 30269, 30273, 30365, 30361, 30270, 30274, 30366, 30362
41664, 30270, 30274, 30366, 30362, 12501, 12502, 12525, 12524
41665, 8674, 8675, 8698, 8697, 30271, 30275, 30367, 30363
41666, 30271, 30275, 30367, 30363, 30272, 30276, 30368, 30364
41667, 30272, 30276, 30368, 30364, 30273, 30277, 30369, 30365
41668, 30273, 30277, 30369, 30365, 30274, 30278, 30370, 30366
41669, 30274, 30278, 30370, 30366, 12502, 12503, 12526, 12525
41670, 8675, 8676, 8699, 8698, 30275, 30279, 30371, 30367
41671, 30275, 30279, 30371, 30367, 30276, 30280, 30372, 30368
41672, 30276, 30280, 30372, 30368, 30277, 30281, 30373, 30369
41673, 30277, 30281, 30373, 30369, 30278, 30282, 30374, 30370
41674, 30278, 30282, 30374, 30370, 12503, 12504, 12527, 12526
41675, 8676, 8677, 8700, 8699, 30279, 30283, 30375, 30371
41676, 30279, 30283, 30375, 30371, 30280, 30284, 30376, 30372
41677, 30280, 30284, 30376, 30372, 30281, 30285, 30377, 30373
41678, 30281, 30285, 30377, 30373, 30282, 30286, 30378, 30374
41679, 30282, 30286, 30378, 30374, 12504, 12505, 12528, 12527
41680, 8677, 8678, 8701, 8700, 30283, 30287, 30379, 30375
41681, 30283, 30287, 30379, 30375, 30284, 30288, 30380, 30376
41682, 30284, 30288, 30380, 30376, 30285, 30289, 30381, 30377
41683, 30285, 30289, 30381, 30377, 30286, 30290, 30382, 30378
41684, 30286, 30290, 30382, 30378, 12505, 12506, 12529, 12528
41685, 8678, 8679, 8702, 8701, 30287, 30291, 30383, 30379
41686, 30287, 30291, 30383, 30379, 30288, 30292, 30384, 30380
41687, 30288, 30292, 30384, 30380, 30289, 30293, 30385, 30381
41688, 30289, 30293, 30385, 30381, 30290, 30294, 30386, 30382
41689, 30290, 30294, 30386, 30382, 12506, 12507, 12530, 12529
41690, 8679, 8680, 8703, 8702, 30291, 30295, 30387, 30383
41691, 30291, 30295, 30387, 30383, 30292, 30296, 30388, 30384
41692, 30292, 30296, 30388, 30384, 30293, 30297, 30389, 30385
41693, 30293, 30297, 30389, 30385, 30294, 30298, 30390, 30386
41694, 30294, 30298, 30390, 30386, 12507, 12508, 12531, 12530
41695, 8680, 8681, 8704, 8703, 30295, 30299, 30391, 30387
41696, 30295, 30299, 30391, 30387, 30296, 30300, 30392, 30388
41697, 30296, 30300, 30392, 30388, 30297, 30301, 30393, 30389
41698, 30297, 30301, 30393, 30389, 30298, 30302, 30394, 30390
41699, 30298, 30302, 30394, 30390, 12508, 12509, 12532, 12531
41700, 8681, 8682, 8705, 8704, 30299, 30303, 30395, 30391
41701, 30299, 30303, 30395, 30391, 30300, 30304, 30396, 30392
41702, 30300, 30304, 30396, 30392, 30301, 30305, 30397, 30393
41703, 30301, 30305, 30397, 30393, 30302, 30306, 30398, 30394
41704, 30302, 30306, 30398, 30394, 12509, 12510, 12533, 12532
41705, 8682, 8683, 8706, 8705, 30303, 30307, 30399, 30395
41706, 30303, 30307, 30399, 30395, 30304, 30308, 30400, 30396
41707, 30304, 30308, 30400, 30396, 30305, 30309, 30401, 30397
41708, 30305, 30309, 30401, 30397, 30306, 30310, 30402, 30398
41709, 30306, 30310, 30402, 30398, 12510, 12511, 12534, 12533
41710, 8683, 8684, 8707, 8706, 30307, 30311, 30403, 30399
41711, 30307, 30311, 30403, 30399, 30308, 30312, 30404, 30400
41712, 30308, 30312, 30404, 30400, 30309, 30313, 30405, 30401
41713, 30309, 30313, 30405, 30401, 30310, 30314, 30406, 30402
41714, 30310, 30314, 30406, 30402, 12511, 12512, 12535, 12534
41715, 8684, 8685, 8708, 8707, 30311, 30315, 30407, 30403
41716, 30311, 30315, 30407, 30403, 30312, 30316, 30408, 30404
41717, 30312, 30316, 30408, 30404, 30313, 30317, 30409, 30405
41718, 30313, 30317, 30409, 30405, 30314, 30318, 30410, 30406
41719, 30314, 30318, 30410, 30406, 12512, 12513, 12536, 12535
41720, 8685, 8686, 8709, 8708, 30315, 30319, 30411, 30407
41721, 30315, 30319, 30411, 30407, 30316, 30320, 30412, 30408
41722, 30316, 30320, 30412, 30408, 30317, 30321, 30413, 30409
41723, 30317, 30321, 30413, 30409, 30318, 30322, 30414, 30410
41724, 30318, 30322, 30414, 30410, 12513, 12514, 12537, 12536
41725, 8686, 8687, 8710, 8709, 30319, 30323, 30415, 30411
41726, 30319, 30323, 30415, 30411, 30320, 30324, 30416, 30412
41727, 30320, 30324, 30416, 30412, 30321, 30325, 30417, 30413
41728, 30321, 30325, 30417, 30413, 30322, 30326, 30418, 30414
41729, 30322, 30326, 30418, 30414, 12514, 12515, 12538, 12537
41730, 8687, 1141, 1142, 8710, 30323, 12316, 12320, 30415
41731, 30323, 12316, 12320, 30415, 30324, 12317, 12321, 30416
41732, 30324, 12317, 12321, 30416, 30325, 12318, 12322, 30417
41733, 30325, 12318, 12322, 30417, 30326, 12319, 12323, 30418
41734, 30326, 12319, 12323, 30418, 12515, 1922, 1923, 12538
41735, 1131, 8688, 8711, 1132, 12276, 30327, 30419, 12280
41736, 12276, 30327, 30419, 12280, 12277, 30328, 30420, 12281
41737, 12277, 30328, 30420, 12281, 12278, 30329, 30421, 12282
41738, 12278, 30329, 30421, 12282, 12279, 30330, 30422, 12283
41739, 12279, 30330, 30422, 12283, 1912, 12516, 12539, 1913
41740, 8688, 8689, 8712, 8711, 30327, 30331, 30423, 30419
41741, 30327, 30331, 30423, 30419, 30328, 30332, 30424, 30420
41742, 30328, 30332, 30424, 30420, 30329, 30333, 30425, 30421
41743, 30329, 30333, 30425, 30421, 30330, 30334, 30426, 30422
41744, 30330, 30334, 30426, 30422, 12516, 12517, 12540, 12539
41745, 8689, 8690, 8713, 8712, 30331, 30335, 30427, 30423
41746, 30331, 30335, 30427, 30423, 30332, 30336, 30428, 30424
41747, 30332, 30336, 30428, 30424, 30333, 30337, 30429, 30425
41748, 30333, 30337, 30429, 30425, 30334, 30338, 30430, 30426
41749, 30334, 30338, 30430, 30426, 12517, 12518, 12541, 12540
41750, 8690, 8691, 8714, 8713, 30335, 30339, 30431, 30427
41751, 30335, 30339, 30431, 30427, 30336, 30340, 30432, 30428
41752, 30336, 30340, 30432, 30428, 30337, 30341, 30433, 30429
41753, 30337, 30341, 30433, 30429, 30338, 30342, 30434, 30430
41754, 30338, 30342, 30434, 30430, 12518, 12519, 12542, 12541
41755, 8691, 8692, 8715, 8714, 30339, 30343, 30435, 30431
41756, 30339, 30343, 30435, 30431, 30340, 30344, 30436, 30432
41757, 30340, 30344, 30436, 30432, 30341, 30345, 30437, 30433
41758, 30341, 30345, 30437, 30433, 30342, 30346, 30438, 30434
41759, 30342, 30346, 30438, 30434, 12519, 12520, 12543, 12542
41760, 8692, 8693, 8716, 8715, 30343, 30347, 30439, 30435
41761, 30343, 30347, 30439, 30435, 30344, 30348, 30440, 30436
41762, 30344, 30348, 30440, 30436, 30345, 30349, 30441, 30437
41763, 30345, 30349, 30441, 30437, 30346, 30350, 30442, 30438
41764, 30346, 30350, 30442, 30438, 12520, 12521, 12544, 12543
41765, 8693, 8694, 8717, 8716, 30347, 30351, 30443, 30439
41766, 30347, 30351, 30443, 30439, 30348, 30352, 30444, 30440
41767, 30348, 30352, 30444, 30440, 30349, 30353, 30445, 30441
41768, 30349, 30353, 30445, 30441, 30350, 30354, 30446, 30442
41769, 30350, 30354, 30446, 30442, 12521, 12522, 12545, 12544
41770, 8694, 8695, 8718, 8717, 30351, 30355, 30447, 30443
41771, 30351, 30355, 30447, 30443, 30352, 30356, 30448, 30444
41772, 30352, 30356, 30448, 30444, 30353, 30357, 30449, 30445
41773, 30353, 30357, 30449, 30445, 30354, 30358, 30450, 30446
41774, 30354, 30358, 30450, 30446, 12522, 12523, 12546, 12545
41775, 8695, 8696, 8719, 8718, 30355, 30359, 30451, 30447
41776, 30355, 30359, 30451, 30447, 30356, 30360, 30452, 30448
41777, 30356, 30360, 30452, 30448, 30357, 30361, 30453, 30449
41778, 30357, 30361, 30453, 30449, 30358, 30362, 30454, 30450
41779, 30358, 30362, 30454, 30450, 12523, 12524, 12547, 12546
41780, 8696, 8697, 8720, 8719, 30359, 30363, 30455, 30451
41781, 30359, 30363, 30455, 30451, 30360, 30364, 30456, 30452
41782, 30360, 30364, 30456, 30452, 30361, 30365, 30457, 30453
41783, 30361, 30365, 30457, 30453, 30362, 30366, 30458, 30454
41784, 30362, 30366, 30458, 30454, 12524, 12525, 12548, 12547
41785, 8697, 8698, 8721, 8720, 30363, 30367, 30459, 30455
41786, 30363, 30367, 30459, 30455, 30364, 30368, 30460, 30456
41787, 30364, 30368, 30460, 30456, 30365, 30369, 30461, 30457
41788, 30365, 30369, 30461, 30457, 30366, 30370, 30462, 30458
41789, 30366, 30370, 30462, 30458, 12525, 12526, 12549, 12548
41790, 8698, 8699, 8722, 8721, 30367, 30371, 30463, 30459
41791, 30367, 30371, 30463, 30459, 30368, 30372, 30464, 30460
41792, 30368, 30372, 30464, 30460, 30369, 30373, 30465, 30461
41793, 30369, 30373, 30465, 30461, 30370, 30374, 30466, 30462
41794, 30370, 30374, 30466, 30462, 12526, 12527, 12550, 12549
41795, 8699, 8700, 8723, 8722, 30371, 30375, 30467, 30463
41796, 30371, 30375, 30467, 30463, 30372, 30376, 30468, 30464
41797, 30372, 30376, 30468, 30464, 30373, 30377, 30469, 30465
41798, 30373, 30377, 30469, 30465, 30374, 30378, 30470, 30466
41799, 30374, 30378, 30470, 30466, 12527, 12528, 12551, 12550
41800, 8700, 8701, 8724, 8723, 30375, 30379, 30471, 30467
41801, 30375, 30379, 30471, 30467, 30376, 30380, 30472, 30468
41802, 30376, 30380, 30472, 30468, 30377, 30381, 30473, 30469
41803, 30377, 30381, 30473, 30469, 30378, 30382, 30474, 30470
41804, 30378, 30382, 30474, 30470, 12528, 12529, 12552, 12551
41805, 8701, 8702, 8725, 8724, 30379, 30383, 30475, 30471
41806, 30379, 30383, 30475, 30471, 30380, 30384, 30476, 30472
41807, 30380, 30384, 30476, 30472, 30381, 30385, 30477, 30473
41808, 30381, 30385, 30477, 30473, 30382, 30386, 30478, 30474
41809, 30382, 30386, 30478, 30474, 12529, 12530, 12553, 12552
41810, 8702, 8703, 8726, 8725, 30383, 30387, 30479, 30475
41811, 30383, 30387, 30479, 30475, 30384, 30388, 30480, 30476
41812, 30384, 30388, 30480, 30476, 30385, 30389, 30481, 30477
41813, 30385, 30389, 30481, 30477, 30386, 30390, 30482, 30478
41814, 30386, 30390, 30482, 30478, 12530, 12531, 12554, 12553
41815, 8703, 8704, 8727, 8726, 30387, 30391, 30483, 30479
41816, 30387, 30391, 30483, 30479, 30388, 30392, 30484, 30480
41817, 30388, 30392, 30484, 30480, 30389, 30393, 30485, 30481
41818, 30389, 30393, 30485, 30481, 30390, 30394, 30486, 30482
41819, 30390, 30394, 30486, 30482, 12531, 12532, 12555, 12554
41820, 8704, 8705, 8728, 8727, 30391, 30395, 30487, 30483
41821, 30391, 30395, 30487, 30483, 30392, 30396, 30488, 30484
41822, 30392, 30396, 30488, 30484, 30393, 30397, 30489, 30485
41823, 30393, 30397, 30489, 30485, 30394, 30398, 30490, 30486
41824, 30394, 30398, 30490, 30486, 12532, 12533, 12556, 12555
41825, 8705, 8706, 8729, 8728, 30395, 30399, 30491, 30487
41826, 30395, 30399, 30491, 30487, 30396, 30400, 30492, 30488
41827, 30396, 30400, 30492, 30488, 30397, 30401, 30493, 30489
41828, 30397, 30401, 30493, 30489, 30398, 30402, 30494, 30490
41829, 30398, 30402, 30494, 30490, 12533, 12534, 12557, 12556
41830, 8706, 8707, 8730, 8729, 30399, 30403, 30495, 30491
41831, 30399, 30403, 30495, 30491, 30400, 30404, 30496, 30492
41832, 30400, 30404, 30496, 30492, 30401, 30405, 30497, 30493
41833, 30401, 30405, 30497, 30493, 30402, 30406, 30498, 30494
41834, 30402, 30406, 30498, 30494, 12534, 12535, 12558, 12557
41835, 8707, 8708, 8731, 8730, 30403, 30407, 30499, 30495
41836, 30403, 30407, 30499, 30495, 30404, 30408, 30500, 30496
41837, 30404, 30408, 30500, 30496, 30405, 30409, 30501, 30497
41838, 30405, 30409, 30501, 30497, 30406, 30410, 30502, 30498
41839, 30406, 30410, 30502, 30498, 12535, 12536, 12559, 12558
41840, 8708, 8709, 8732, 8731, 30407, 30411, 30503, 30499
41841, 30407, 30411, 30503, 30499, 30408, 30412, 30504, 30500
41842, 30408, 30412, 30504, 30500, 30409, 30413, 30505, 30501
41843, 30409, 30413, 30505, 30501, 30410, 30414, 30506, 30502
41844, 30410, 30414, 30506, 30502, 12536, 12537, 12560, 12559
41845, 8709, 8710, 8733, 8732, 30411, 30415, 30507, 30503
41846, 30411, 30415, 30507, 30503, 30412, 30416, 30508, 30504
41847, 30412, 30416, 30508, 30504, 30413, 30417, 30509, 30505
41848, 30413, 30417, 30509, 30505, 30414, 30418, 30510, 30506
41849, 30414, 30418, 30510, 30506, 12537, 12538, 12561, 12560
41850, 8710, 1142, 1143, 8733, 30415, 12320, 12324, 30507
41851, 30415, 12320, 12324, 30507, 30416, 12321, 12325, 30508
41852, 30416, 12321, 12325, 30508, 30417, 12322, 12326, 30509
41853, 30417, 12322, 12326, 30509, 30418, 12323, 12327, 30510
41854, 30418, 12323, 12327, 30510, 12538, 1923, 1924, 12561
41855, 1132, 8711, 8734, 1133, 12280, 30419, 30511, 12284
41856, 12280, 30419, 30511, 12284, 12281, 30420, 30512, 12285
41857, 12281, 30420, 30512, 12285, 12282, 30421, 30513, 12286
41858, 12282, 30421, 30513, 12286, 12283, 30422, 30514, 12287
41859, 12283, 30422, 30514, 12287, 1913, 12539, 12562, 1914
41860, 8711, 8712, 8735, 8734, 30419, 30423, 30515, 30511
41861, 30419, 30423, 30515, 30511, 30420, 30424, 30516, 30512
41862, 30420, 30424, 30516, 30512, 30421, 30425, 30517, 30513
41863, 30421, 30425, 30517, 30513, 30422, 30426, 30518, 30514
41864, 30422, 30426, 30518, 30514, 12539, 12540, 12563, 12562
41865, 8712, 8713, 8736, 8735, 30423, 30427, 30519, 30515
41866, 30423, 30427, 30519, 30515, 30424, 30428, 30520, 30516
41867, 30424, 30428, 30520, 30516, 30425, 30429, 30521, 30517
41868, 30425, 30429, 30521, 30517, 30426, 30430, 30522, 30518
41869, 30426, 30430, 30522, 30518, 12540, 12541, 12564, 12563
41870, 8713, 8714, 8737, 8736, 30427, 30431, 30523, 30519
41871, 30427, 30431, 30523, 30519, 30428, 30432, 30524, 30520
41872, 30428, 30432, 30524, 30520, 30429, 30433, 30525, 30521
41873, 30429, 30433, 30525, 30521, 30430, 30434, 30526, 30522
41874, 30430, 30434, 30526, 30522, 12541, 12542, 12565, 12564
41875, 8714, 8715, 8738, 8737, 30431, 30435, 30527, 30523
41876, 30431, 30435, 30527, 30523, 30432, 30436, 30528, 30524
41877, 30432, 30436, 30528, 30524, 30433, 30437, 30529, 30525
41878, 30433, 30437, 30529, 30525, 30434, 30438, 30530, 30526
41879, 30434, 30438, 30530, 30526, 12542, 12543, 12566, 12565
41880, 8715, 8716, 8739, 8738, 30435, 30439, 30531, 30527
41881, 30435, 30439, 30531, 30527, 30436, 30440, 30532, 30528
41882, 30436, 30440, 30532, 30528, 30437, 30441, 30533, 30529
41883, 30437, 30441, 30533, 30529, 30438, 30442, 30534, 30530
41884, 30438, 30442, 30534, 30530, 12543, 12544, 12567, 12566
41885, 8716, 8717, 8740, 8739, 30439, 30443, 30535, 30531
41886, 30439, 30443, 30535, 30531, 30440, 30444, 30536, 30532
41887, 30440, 30444, 30536, 30532, 30441, 30445, 30537, 30533
41888, 30441, 30445, 30537, 30533, 30442, 30446, 30538, 30534
41889, 30442, 30446, 30538, 30534, 12544, 12545, 12568, 12567
41890, 8717, 8718, 8741, 8740, 30443, 30447, 30539, 30535
41891, 30443, 30447, 30539, 30535, 30444, 30448, 30540, 30536
41892, 30444, 30448, 30540, 30536, 30445, 30449, 30541, 30537
41893, 30445, 30449, 30541, 30537, 30446, 30450, 30542, 30538
41894, 30446, 30450, 30542, 30538, 12545, 12546, 12569, 12568
41895, 8718, 8719, 8742, 8741, 30447, 30451, 30543, 30539
41896, 30447, 30451, 30543, 30539, 30448, 30452, 30544, 30540
41897, 30448, 30452, 30544, 30540, 30449, 30453, 30545, 30541
41898, 30449, 30453, 30545, 30541, 30450, 30454, 30546, 30542
41899, 30450, 30454, 30546, 30542, 12546, 12547, 12570, 12569
41900, 8719, 8720, 8743, 8742, 30451, 30455, 30547, 30543
41901, 30451, 30455, 30547, 30543, 30452, 30456, 30548, 30544
41902, 30452, 30456, 30548, 30544, 30453, 30457, 30549, 30545
41903, 30453, 30457, 30549, 30545, 30454, 30458, 30550, 30546
41904, 30454, 30458, 30550, 30546, 12547, 12548, 12571, 12570
41905, 8720, 8721, 8744, 8743, 30455, 30459, 30551, 30547
41906, 30455, 30459, 30551, 30547, 30456, 30460, 30552, 30548
41907, 30456, 30460, 30552, 30548, 30457, 30461, 30553, 30549
41908, 30457, 30461, 30553, 30549, 30458, 30462, 30554, 30550
41909, 30458, 30462, 30554, 30550, 12548, 12549, 12572, 12571
41910, 8721, 8722, 8745, 8744, 30459, 30463, 30555, 30551
41911, 30459, 30463, 30555, 30551, 30460, 30464, 30556, 30552
41912, 30460, 30464, 30556, 30552, 30461, 30465, 30557, 30553
41913, 30461, 30465, 30557, 30553, 30462, 30466, 30558, 30554
41914, 30462, 30466, 30558, 30554, 12549, 12550, 12573, 12572
41915, 8722, 8723, 8746, 8745, 30463, 30467, 30559, 30555
41916, 30463, 30467, 30559, 30555, 30464, 30468, 30560, 30556
41917, 30464, 30468, 30560, 30556, 30465, 30469, 30561, 30557
41918, 30465, 30469, 30561, 30557, 30466, 30470, 30562, 30558
41919, 30466, 30470, 30562, 30558, 12550, 12551, 12574, 12573
41920, 8723, 8724, 8747, 8746, 30467, 30471, 30563, 30559
41921, 30467, 30471, 30563, 30559, 30468, 30472, 30564, 30560
41922, 30468, 30472, 30564, 30560, 30469, 30473, 30565, 30561
41923, 30469, 30473, 30565, 30561, 30470, 30474, 30566, 30562
41924, 30470, 30474, 30566, 30562, 12551, 12552, 12575, 12574
41925, 8724, 8725, 8748, 8747, 30471, 30475, 30567, 30563
41926, 30471, 30475, 30567, 30563, 30472, 30476, 30568, 30564
41927, 30472, 30476, 30568, 30564, 30473, 30477, 30569, 30565
41928, 30473, 30477, 30569, 30565, 30474, 30478, 30570, 30566
41929, 30474, 30478, 30570, 30566, 12552, 12553, 12576, 12575
41930, 8725, 8726, 8749, 8748, 30475, 30479, 30571, 30567
41931, 30475, 30479, 30571, 30567, 30476, 30480, 30572, 30568
41932, 30476, 30480, 30572, 30568, 30477, 30481, 30573, 30569
41933, 30477, 30481, 30573, 30569, 30478, 30482, 30574, 30570
41934, 30478, 30482, 30574, 30570, 12553, 12554, 12577, 12576
41935, 8726, 8727, 8750, 8749, 30479, 30483, 30575, 30571
41936, 30479, 30483, 30575, 30571, 30480, 30484, 30576, 30572
41937, 30480, 30484, 30576, 30572, 30481, 30485, 30577, 30573
41938, 30481, 30485, 30577, 30573, 30482, 30486, 30578, 30574
41939, 30482, 30486, 30578, 30574, 12554, 12555, 12578, 12577
41940, 8727, 8728, 8751, 8750, 30483, 30487, 30579, 30575
41941, 30483, 30487, 30579, 30575, 30484, 30488, 30580, 30576
41942, 30484, 30488, 30580, 30576, 30485, 30489, 30581, 30577
41943, 30485, 30489, 30581, 30577, 30486, 30490, 30582, 30578
41944, 30486, 30490, 30582, 30578, 12555, 12556, 12579, 12578
41945, 8728, 8729, 8752, 8751, 30487, 30491, 30583, 30579
41946, 30487, 30491, 30583, 30579, 30488, 30492, 30584, 30580
41947, 30488, 30492, 30584, 30580, 30489, 30493, 30585, 30581
41948, 30489, 30493, 30585, 30581, 30490, 30494, 30586, 30582
41949, 30490, 30494, 30586, 30582, 12556, 12557, 12580, 12579
41950, 8729, 8730, 8753, 8752, 30491, 30495, 30587, 30583
41951, 30491, 30495, 30587, 30583, 30492, 30496, 30588, 30584
41952, 30492, 30496, 30588, 30584, 30493, 30497, 30589, 30585
41953, 30493, 30497, 30589, 30585, 30494, 30498, 30590, 30586
41954, 30494, 30498, 30590, 30586, 12557, 12558, 12581, 12580
41955, 8730, 8731, 8754, 8753, 30495, 30499, 30591, 30587
41956, 30495, 30499, 30591, 30587, 30496, 30500, 30592, 30588
41957, 30496, 30500, 30592, 30588, 30497, 30501, 30593, 30589
41958, 30497, 30501, 30593, 30589, 30498, 30502, 30594, 30590
