11842, 9802, 9803, 9826, 9825
11843, 9803, 9804, 9827, 9826
11844, 9804, 9805, 9828, 9827
11845, 9805, 9806, 9829, 9828
11846, 9806, 9807, 9830, 9829
11847, 9807, 9808, 9831, 9830
11848, 9808, 9809, 9832, 9831
11849, 9809, 9810, 9833, 9832
11850, 9810, 9811, 9834, 9833
11851, 9811, 9812, 9835, 9834
11852, 9812, 1423, 1424, 9835
11853, 1401, 9813, 1333, 65
11854, 9813, 9814, 1334, 1333
11855, 9814, 9815, 1335, 1334
11856, 9815, 9816, 1336, 1335
11857, 9816, 9817, 1337, 1336
11858, 9817, 9818, 1338, 1337
11859, 9818, 9819, 1339, 1338
11860, 9819, 9820, 1340, 1339
11861, 9820, 9821, 1341, 1340
11862, 9821, 9822, 1342, 1341
11863, 9822, 9823, 1343, 1342
11864, 9823, 9824, 1344, 1343
11865, 9824, 9825, 1345, 1344
11866, 9825, 9826, 1346, 1345
11867, 9826, 9827, 1347, 1346
11868, 9827, 9828, 1348, 1347
11869, 9828, 9829, 1349, 1348
11870, 9829, 9830, 1350, 1349
11871, 9830, 9831, 1351, 1350
11872, 9831, 9832, 1352, 1351
11873, 9832, 9833, 1353, 1352
11874, 9833, 9834, 1354, 1353
11875, 9834, 9835, 1355, 1354
11876, 9835, 1424, 66, 1355
*ELEMENT, type=CPS4, ELSET=Surface92
11877, 35, 69, 1425, 910
11878, 910, 1425, 1426, 911
11879, 911, 1426, 1427, 912
11880, 912, 1427, 1428, 913
11881, 913, 1428, 1429, 914
11882, 914, 1429, 1430, 915
11883, 915, 1430, 1431, 916
11884, 916, 1431, 1432, 917
11885, 917, 1432, 1433, 918
11886, 918, 1433, 1434, 919
11887, 919, 1434, 1435, 920
11888, 920, 1435, 1436, 921
11889, 921, 1436, 1437, 922
11890, 922, 1437, 1438, 923
11891, 923, 1438, 1439, 924
11892, 924, 1439, 1440, 925
11893, 925, 1440, 1441, 926
11894, 926, 1441, 1442, 927
11895, 927, 1442, 1443, 928
11896, 928, 1443, 1444, 929
11897, 929, 1444, 1445, 930
11898, 930, 1445, 1446, 931
11899, 931, 1446, 1447, 932
11900, 932, 1447, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
11901, 36, 933, 1448, 71
11902, 933, 934, 1449, 1448
11903, 934, 935, 1450, 1449
11904, 935, 936, 1451, 1450
11905, 936, 937, 1452, 1451
11906, 937, 938, 1453, 1452
11907, 938, 939, 1454, 1453
11908, 939, 940, 1455, 1454
11909, 940, 941, 1456, 1455
11910, 941, 942, 1457, 1456
11911, 942, 943, 1458, 1457
11912, 943, 944, 1459, 1458
11913, 944, 945, 1460, 1459
11914, 945, 946, 1461, 1460
11915, 946, 947, 1462, 1461
11916, 947, 948, 1463, 1462
11917, 948, 949, 1464, 1463
11918, 949, 950, 1465, 1464
11919, 950, 951, 1466, 1465
11920, 951, 952, 1467, 1466
11921, 952, 953, 1468, 1467
11922, 953, 954, 1469, 1468
11923, 954, 955, 1470, 1469
11924, 955, 40, 72, 1470
*ELEMENT, type=CPS4, ELSET=Surface94
11925, 35, 796, 1471, 69
11926, 796, 797, 1472, 1471
11927, 797, 798, 1473, 1472
11928, 798, 799, 1474, 1473
11929, 799, 800, 1475, 1474
11930, 800, 801, 1476, 1475
11931, 801, 802, 1477, 1476
11932, 802, 803, 1478, 1477
11933, 803, 804, 1479, 1478
11934, 804, 805, 1480, 1479
11935, 805, 806, 1481, 1480
11936, 806, 807, 1482, 1481
11937, 807, 808, 1483, 1482
11938, 808, 809, 1484, 1483
11939, 809, 810, 1485, 1484
11940, 810, 811, 1486, 1485
11941, 811, 812, 1487, 1486
11942, 812, 813, 1488, 1487
11943, 813, 814, 1489, 1488
11944, 814, 815, 1490, 1489
11945, 815, 816, 1491, 1490
11946, 816, 817, 1492, 1491
11947, 817, 818, 1493, 1492
11948, 818, 36, 71, 1493
*ELEMENT, type=CPS4, ELSET=Surface95
11949, 39, 70, 1494, 956
11950, 956, 1494, 1495, 957
11951, 957, 1495, 1496, 958
11952, 958, 1496, 1497, 959
11953, 959, 1497, 1498, 960
11954, 960, 1498, 1499, 961
11955, 961, 1499, 1500, 962
11956, 962, 1500, 1501, 963
11957, 963, 1501, 1502, 964
11958, 964, 1502, 1503, 965
11959, 965, 1503, 1504, 966
11960, 966, 1504, 1505, 967
11961, 967, 1505, 1506, 968
11962, 968, 1506, 1507, 969
11963, 969, 1507, 1508, 970
11964, 970, 1508, 1509, 971
11965, 971, 1509, 1510, 972
11966, 972, 1510, 1511, 973
11967, 973, 1511, 1512, 974
11968, 974, 1512, 1513, 975
11969, 975, 1513, 1514, 976
11970, 976, 1514, 1515, 977
11971, 977, 1515, 1516, 978
11972, 978, 1516, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
11973, 69, 1471, 9836, 1425
11974, 1425, 9836, 9837, 1426
11975, 1426, 9837, 9838, 1427
11976, 1427, 9838, 9839, 1428
11977, 1428, 9839, 9840, 1429
11978, 1429, 9840, 9841, 1430
11979, 1430, 9841, 9842, 1431
11980, 1431, 9842, 9843, 1432
11981, 1432, 9843, 9844, 1433
11982, 1433, 9844, 9845, 1434
11983, 1434, 9845, 9846, 1435
11984, 1435, 9846, 9847, 1436
11985, 1436, 9847, 9848, 1437
11986, 1437, 9848, 9849, 1438
11987, 1438, 9849, 9850, 1439
11988, 1439, 9850, 9851, 1440
11989, 1440, 9851, 9852, 1441
11990, 1441, 9852, 9853, 1442
11991, 1442, 9853, 9854, 1443
11992, 1443, 9854, 9855, 1444
11993, 1444, 9855, 9856, 1445
11994, 1445, 9856, 9857, 1446
11995, 1446, 9857, 9858, 1447
11996, 1447, 9858, 1494, 70
11997, 1471, 1472, 9859, 9836
11998, 9836, 9859, 9860, 9837
11999, 9837, 9860, 9861, 9838
12000, 9838, 9861, 9862, 9839
12001, 9839, 9862, 9863, 9840
12002, 9840, 9863, 9864, 9841
12003, 9841, 9864, 9865, 9842
12004, 9842, 9865, 9866, 9843
12005, 9843, 9866, 9867, 9844
12006, 9844, 9867, 9868, 9845
12007, 9845, 9868, 9869, 9846
12008, 9846, 9869, 9870, 9847
12009, 9847, 9870, 9871, 9848
12010, 9848, 9871, 9872, 9849
12011, 9849, 9872, 9873, 9850
12012, 9850, 9873, 9874, 9851
12013, 9851, 9874, 9875, 9852
12014, 9852, 9875, 9876, 9853
12015, 9853, 9876, 9877, 9854
12016, 9854, 9877, 9878, 9855
12017, 9855, 9878, 9879, 9856
12018, 9856, 9879, 9880, 9857
12019, 9857, 9880, 9881, 9858
12020, 9858, 9881, 1495, 1494
12021, 1472, 1473, 9882, 9859
12022, 9859, 9882, 9883, 9860
12023, 9860, 9883, 9884, 9861
12024, 9861, 9884, 9885, 9862
12025, 9862, 9885, 9886, 9863
12026, 9863, 9886, 9887, 9864
12027, 9864, 9887, 9888, 9865
12028, 9865, 9888, 9889, 9866
12029, 9866, 9889, 9890, 9867
12030, 9867, 9890, 9891, 9868
12031, 9868, 9891, 9892, 9869
12032, 9869, 9892, 9893, 9870
12033, 9870, 9893, 9894, 9871
12034, 9871, 9894, 9895, 9872
12035, 9872, 9895, 9896, 9873
12036, 9873, 9896, 9897, 9874
12037, 9874, 9897, 9898, 9875
12038, 9875, 9898, 9899, 9876
12039, 9876, 9899, 9900, 9877
12040, 9877, 9900, 9901, 9878
12041, 9878, 9901, 9902, 9879
12042, 9879, 9902, 9903, 9880
12043, 9880, 9903, 9904, 9881
12044, 9881, 9904, 1496, 1495
12045, 1473, 1474, 9905, 9882
12046, 9882, 9905, 9906, 9883
12047, 9883, 9906, 9907, 9884
12048, 9884, 9907, 9908, 9885
12049, 9885, 9908, 9909, 9886
12050, 9886, 9909, 9910, 9887
12051, 9887, 9910, 9911, 9888
12052, 9888, 9911, 9912, 9889
12053, 9889, 9912, 9913, 9890
12054, 9890, 9913, 9914, 9891
12055, 9891, 9914, 9915, 9892
12056, 9892, 9915, 9916, 9893
12057, 9893, 9916, 9917, 9894
12058, 9894, 9917, 9918, 9895
12059, 9895, 9918, 9919, 9896
12060, 9896, 9919, 9920, 9897
12061, 9897, 9920, 9921, 9898
12062, 9898, 9921, 9922, 9899
12063, 9899, 9922, 9923, 9900
12064, 9900, 9923, 9924, 9901
12065, 9901, 9924, 9925, 9902
12066, 9902, 9925, 9926, 9903
12067, 9903, 9926, 9927, 9904
12068, 9904, 9927, 1497, 1496
12069, 1474, 1475, 9928, 9905
12070, 9905, 9928, 9929, 9906
12071, 9906, 9929, 9930, 9907
12072, 9907, 9930, 9931, 9908
12073, 9908, 9931, 9932, 9909
12074, 9909, 9932, 9933, 9910
12075, 9910, 9933, 9934, 9911
12076, 9911, 9934, 9935, 9912
12077, 9912, 9935, 9936, 9913
12078, 9913, 9936, 9937, 9914
12079, 9914, 9937, 9938, 9915
12080, 9915, 9938, 9939, 9916
12081, 9916, 9939, 9940, 9917
12082, 9917, 9940, 9941, 9918
12083, 9918, 9941, 9942, 9919
12084, 9919, 9942, 9943, 9920
12085, 9920, 9943, 9944, 9921
12086, 9921, 9944, 9945, 9922
12087, 9922, 9945, 9946, 9923
12088, 9923, 9946, 9947, 9924
12089, 9924, 9947, 9948, 9925
12090, 9925, 9948, 9949, 9926
12091, 9926, 9949, 9950, 9927
12092, 9927, 9950, 1498, 1497
12093, 1475, 1476, 9951, 9928
12094, 9928, 9951, 9952, 9929
12095, 9929, 9952, 9953, 9930
12096, 9930, 9953, 9954, 9931
12097, 9931, 9954, 9955, 9932
12098, 9932, 9955, 9956, 9933
12099, 9933, 9956, 9957, 9934
12100, 9934, 9957, 9958, 9935
12101, 9935, 9958, 9959, 9936
12102, 9936, 9959, 9960, 9937
12103, 9937, 9960, 9961, 9938
12104, 9938, 9961, 9962, 9939
12105, 9939, 9962, 9963, 9940
12106, 9940, 9963, 9964, 9941
12107, 9941, 9964, 9965, 9942
12108, 9942, 9965, 9966, 9943
12109, 9943, 9966, 9967, 9944
12110, 9944, 9967, 9968, 9945
12111, 9945, 9968, 9969, 9946
12112, 9946, 9969, 9970, 9947
12113, 9947, 9970, 9971, 9948
12114, 9948, 9971, 9972, 9949
12115, 9949, 9972, 9973, 9950
12116, 9950, 9973, 1499, 1498
12117, 1476, 1477, 9974, 9951
12118, 9951, 9974, 9975, 9952
12119, 9952, 9975, 9976, 9953
12120, 9953, 9976, 9977, 9954
12121, 9954, 9977, 9978, 9955
12122, 9955, 9978, 9979, 9956
12123, 9956, 9979, 9980, 9957
12124, 9957, 9980, 9981, 9958
12125, 9958, 9981, 9982, 9959
12126, 9959, 9982, 9983, 9960
12127, 9960, 9983, 9984, 9961
12128, 9961, 9984, 9985, 9962
12129, 9962, 9985, 9986, 9963
12130, 9963, 9986, 9987, 9964
12131, 9964, 9987, 9988, 9965
12132, 9965, 9988, 9989, 9966
12133, 9966, 9989, 9990, 9967
12134, 9967, 9990, 9991, 9968
12135, 9968, 9991, 9992, 9969
12136, 9969, 9992, 9993, 9970
12137, 9970, 9993, 9994, 9971
12138, 9971, 9994, 9995, 9972
12139, 9972, 9995, 9996, 9973
12140, 9973, 9996, 1500, 1499
12141, 1477, 1478, 9997, 9974
12142, 9974, 9997, 9998, 9975
12143, 9975, 9998, 9999, 9976
12144, 9976, 9999, 10000, 9977
12145, 9977, 10000, 10001, 9978
12146, 9978, 10001, 10002, 9979
12147, 9979, 10002, 10003, 9980
12148, 9980, 10003, 10004, 9981
12149, 9981, 10004, 10005, 9982
12150, 9982, 10005, 10006, 9983
12151, 9983, 10006, 10007, 9984
12152, 9984, 10007, 10008, 9985
12153, 9985, 10008, 10009, 9986
12154, 9986, 10009, 10010, 9987
12155, 9987, 10010, 10011, 9988
12156, 9988, 10011, 10012, 9989
12157, 9989, 10012, 10013, 9990
12158, 9990, 10013, 10014, 9991
12159, 9991, 10014, 10015, 9992
12160, 9992, 10015, 10016, 9993
12161, 9993, 10016, 10017, 9994
12162, 9994, 10017, 10018, 9995
12163, 9995, 10018, 10019, 9996
12164, 9996, 10019, 1501, 1500
12165, 1478, 1479, 10020, 9997
12166, 9997, 10020, 10021, 9998
12167, 9998, 10021, 10022, 9999
12168, 9999, 10022, 10023, 10000
12169, 10000, 10023, 10024, 10001
12170, 10001, 10024, 10025, 10002
12171, 10002, 10025, 10026, 10003
12172, 10003, 10026, 10027, 10004
12173, 10004, 10027, 10028, 10005
12174, 10005, 10028, 10029, 10006
12175, 10006, 10029, 10030, 10007
12176, 10007, 10030, 10031, 10008
12177, 10008, 10031, 10032, 10009
12178, 10009, 10032, 10033, 10010
12179, 10010, 10033, 10034, 10011
12180, 10011, 10034, 10035, 10012
12181, 10012, 10035, 10036, 10013
12182, 10013, 10036, 10037, 10014
12183, 10014, 10037, 10038, 10015
12184, 10015, 10038, 10039, 10016
12185, 10016, 10039, 10040, 10017
12186, 10017, 10040, 10041, 10018
12187, 10018, 10041, 10042, 10019
12188, 10019, 10042, 1502, 1501
12189, 1479, 1480, 10043, 10020
12190, 10020, 10043, 10044, 10021
12191, 10021, 10044, 10045, 10022
12192, 10022, 10045, 10046, 10023
12193, 10023, 10046, 10047, 10024
12194, 10024, 10047, 10048, 10025
12195, 10025, 10048, 10049, 10026
12196, 10026, 10049, 10050, 10027
12197, 10027, 10050, 10051, 10028
12198, 10028, 10051, 10052, 10029
12199, 10029, 10052, 10053, 10030
12200, 10030, 10053, 10054, 10031
12201, 10031, 10054, 10055, 10032
12202, 10032, 10055, 10056, 10033
12203, 10033, 10056, 10057, 10034
12204, 10034, 10057, 10058, 10035
12205, 10035, 10058, 10059, 10036
12206, 10036, 10059, 10060, 10037
12207, 10037, 10060, 10061, 10038
12208, 10038, 10061, 10062, 10039
12209, 10039, 10062, 10063, 10040
12210, 10040, 10063, 10064, 10041
12211, 10041, 10064, 10065, 10042
12212, 10042, 10065, 1503, 1502
12213, 1480, 1481, 10066, 10043
12214, 10043, 10066, 10067, 10044
12215, 10044, 10067, 10068, 10045
12216, 10045, 10068, 10069, 10046
12217, 10046, 10069, 10070, 10047
12218, 10047, 10070, 10071, 10048
12219, 10048, 10071, 10072, 10049
12220, 10049, 10072, 10073, 10050
12221, 10050, 10073, 10074, 10051
12222, 10051, 10074, 10075, 10052
12223, 10052, 10075, 10076, 10053
12224, 10053, 10076, 10077, 10054
12225, 10054, 10077, 10078, 10055
12226, 10055, 10078, 10079, 10056
12227, 10056, 10079, 10080, 10057
12228, 10057, 10080, 10081, 10058
12229, 10058, 10081, 10082, 10059
12230, 10059, 10082, 10083, 10060
12231, 10060, 10083, 10084, 10061
12232, 10061, 10084, 10085, 10062
12233, 10062, 10085, 10086, 10063
12234, 10063, 10086, 10087, 10064
12235, 10064, 10087, 10088, 10065
12236, 10065, 10088, 1504, 1503
12237, 1481, 1482, 10089, 10066
12238, 10066, 10089, 10090, 10067
12239, 10067, 10090, 10091, 10068
12240, 10068, 10091, 10092, 10069
12241, 10069, 10092, 10093, 10070
12242, 10070, 10093, 10094, 10071
12243, 10071, 10094, 10095, 10072
12244, 10072, 10095, 10096, 10073
12245, 10073, 10096, 10097, 10074
12246, 10074, 10097, 10098, 10075
12247, 10075, 10098, 10099, 10076
12248, 10076, 10099, 10100, 10077
12249, 10077, 10100, 10101, 10078
12250, 10078, 10101, 10102, 10079
12251, 10079, 10102, 10103, 10080
12252, 10080, 10103, 10104, 10081
12253, 10081, 10104, 10105, 10082
12254, 10082, 10105, 10106, 10083
12255, 10083, 10106, 10107, 10084
12256, 10084, 10107, 10108, 10085
12257, 10085, 10108, 10109, 10086
12258, 10086, 10109, 10110, 10087
12259, 10087, 10110, 10111, 10088
12260, 10088, 10111, 1505, 1504
12261, 1482, 1483, 10112, 10089
12262, 10089, 10112, 10113, 10090
12263, 10090, 10113, 10114, 10091
12264, 10091, 10114, 10115, 10092
12265, 10092, 10115, 10116, 10093
12266, 10093, 10116, 10117, 10094
12267, 10094, 10117, 10118, 10095
12268, 10095, 10118, 10119, 10096
12269, 10096, 10119, 10120, 10097
12270, 10097, 10120, 10121, 10098
12271, 10098, 10121, 10122, 10099
12272, 10099, 10122, 10123, 10100
12273, 10100, 10123, 10124, 10101
12274, 10101, 10124, 10125, 10102
12275, 10102, 10125, 10126, 10103
12276, 10103, 10126, 10127, 10104
12277, 10104, 10127, 10128, 10105
12278, 10105, 10128, 10129, 10106
12279, 10106, 10129, 10130, 10107
12280, 10107, 10130, 10131, 10108
12281, 10108, 10131, 10132, 10109
12282, 10109, 10132, 10133, 10110
12283, 10110, 10133, 10134, 10111
12284, 10111, 10134, 1506, 1505
12285, 1483, 1484, 10135, 10112
12286, 10112, 10135, 10136, 10113
12287, 10113, 10136, 10137, 10114
12288, 10114, 10137, 10138, 10115
12289, 10115, 10138, 10139, 10116
12290, 10116, 10139, 10140, 10117
12291, 10117, 10140, 10141, 10118
12292, 10118, 10141, 10142, 10119
12293, 10119, 10142, 10143, 10120
12294, 10120, 10143, 10144, 10121
12295, 10121, 10144, 10145, 10122
12296, 10122, 10145, 10146, 10123
12297, 10123, 10146, 10147, 10124
12298, 10124, 10147, 10148, 10125
12299, 10125, 10148, 10149, 10126
12300, 10126, 10149, 10150, 10127
12301, 10127, 10150, 10151, 10128
12302, 10128, 10151, 10152, 10129
12303, 10129, 10152, 10153, 10130
12304, 10130, 10153, 10154, 10131
12305, 10131, 10154, 10155, 10132
12306, 10132, 10155, 10156, 10133
12307, 10133, 10156, 10157, 10134
12308, 10134, 10157, 1507, 1506
12309, 1484, 1485, 10158, 10135
12310, 10135, 10158, 10159, 10136
12311, 10136, 10159, 10160, 10137
12312, 10137, 10160, 10161, 10138
12313, 10138, 10161, 10162, 10139
12314, 10139, 10162, 10163, 10140
12315, 10140, 10163, 10164, 10141
12316, 10141, 10164, 10165, 10142
12317, 10142, 10165, 10166, 10143
12318, 10143, 10166, 10167, 10144
12319, 10144, 10167, 10168, 10145
12320, 10145, 10168, 10169, 10146
12321, 10146, 10169, 10170, 10147
12322, 10147, 10170, 10171, 10148
12323, 10148, 10171, 10172, 10149
12324, 10149, 10172, 10173, 10150
12325, 10150, 10173, 10174, 10151
12326, 10151, 10174, 10175, 10152
12327, 10152, 10175, 10176, 10153
12328, 10153, 10176, 10177, 10154
12329, 10154, 10177, 10178, 10155
12330, 10155, 10178, 10179, 10156
12331, 10156, 10179, 10180, 10157
12332, 10157, 10180, 1508, 1507
12333, 1485, 1486, 10181, 10158
12334, 10158, 10181, 10182, 10159
12335, 10159, 10182, 10183, 10160
12336, 10160, 10183, 10184, 10161
12337, 10161, 10184, 10185, 10162
12338, 10162, 10185, 10186, 10163
12339, 10163, 10186, 10187, 10164
12340, 10164, 10187, 10188, 10165
12341, 10165, 10188, 10189, 10166
12342, 10166, 10189, 10190, 10167
12343, 10167, 10190, 10191, 10168
12344, 10168, 10191, 10192, 10169
12345, 10169, 10192, 10193, 10170
12346, 10170, 10193, 10194, 10171
12347, 10171, 10194, 10195, 10172
12348, 10172, 10195, 10196, 10173
12349, 10173, 10196, 10197, 10174
12350, 10174, 10197, 10198, 10175
12351, 10175, 10198, 10199, 10176
12352, 10176, 10199, 10200, 10177
12353, 10177, 10200, 10201, 10178
12354, 10178, 10201, 10202, 10179
12355, 10179, 10202, 10203, 10180
12356, 10180, 10203, 1509, 1508
12357, 1486, 1487, 10204, 10181
12358, 10181, 10204, 10205, 10182
12359, 10182, 10205, 10206, 10183
12360, 10183, 10206, 10207, 10184
12361, 10184, 10207, 10208, 10185
12362, 10185, 10208, 10209, 10186
12363, 10186, 10209, 10210, 10187
12364, 10187, 10210, 10211, 10188
12365, 10188, 10211, 10212, 10189
12366, 10189, 10212, 10213, 10190
12367, 10190, 10213, 10214, 10191
12368, 10191, 10214, 10215, 10192
12369, 10192, 10215, 10216, 10193
12370, 10193, 10216, 10217, 10194
12371, 10194, 10217, 10218, 10195
12372, 10195, 10218, 10219, 10196
12373, 10196, 10219, 10220, 10197
12374, 10197, 10220, 10221, 10198
12375, 10198, 10221, 10222, 10199
12376, 10199, 10222, 10223, 10200
12377, 10200, 10223, 10224, 10201
12378, 10201, 10224, 10225, 10202
12379, 10202, 10225, 10226, 10203
12380, 10203, 10226, 1510, 1509
12381, 1487, 1488, 10227, 10204
12382, 10204, 10227, 10228, 10205
12383, 10205, 10228, 10229, 10206
12384, 10206, 10229, 10230, 10207
12385, 10207, 10230, 10231, 10208
12386, 10208, 10231, 10232, 10209
12387, 10209, 10232, 10233, 10210
12388, 10210, 10233, 10234, 10211
12389, 10211, 10234, 10235, 10212
12390, 10212, 10235, 10236, 10213
12391, 10213, 10236, 10237, 10214
12392, 10214, 10237, 10238, 10215
12393, 10215, 10238, 10239, 10216
12394, 10216, 10239, 10240, 10217
12395, 10217, 10240, 10241, 10218
12396, 10218, 10241, 10242, 10219
12397, 10219, 10242, 10243, 10220
12398, 10220, 10243, 10244, 10221
12399, 10221, 10244, 10245, 10222
12400, 10222, 10245, 10246, 10223
12401, 10223, 10246, 10247, 10224
12402, 10224, 10247, 10248, 10225
12403, 10225, 10248, 10249, 10226
12404, 10226, 10249, 1511, 1510
12405, 1488, 1489, 10250, 10227
12406, 10227, 10250, 10251, 10228
12407, 10228, 10251, 10252, 10229
12408, 10229, 10252, 10253, 10230
12409, 10230, 10253, 10254, 10231
12410, 10231, 10254, 10255, 10232
12411, 10232, 10255, 10256, 10233
12412, 10233, 10256, 10257, 10234
12413, 10234, 10257, 10258, 10235
12414, 10235, 10258, 10259, 10236
12415, 10236, 10259, 10260, 10237
12416, 10237, 10260, 10261, 10238
12417, 10238, 10261, 10262, 10239
12418, 10239, 10262, 10263, 10240
12419, 10240, 10263, 10264, 10241
12420, 10241, 10264, 10265, 10242
12421, 10242, 10265, 10266, 10243
12422, 10243, 10266, 10267, 10244
12423, 10244, 10267, 10268, 10245
12424, 10245, 10268, 10269, 10246
12425, 10246, 10269, 10270, 10247
12426, 10247, 10270, 10271, 10248
12427, 10248, 10271, 10272, 10249
12428, 10249, 10272, 1512, 1511
12429, 1489, 1490, 10273, 10250
12430, 10250, 10273, 10274, 10251
12431, 10251, 10274, 10275, 10252
12432, 10252, 10275, 10276, 10253
12433, 10253, 10276, 10277, 10254
12434, 10254, 10277, 10278, 10255
12435, 10255, 10278, 10279, 10256
12436, 10256, 10279, 10280, 10257
12437, 10257, 10280, 10281, 10258
12438, 10258, 10281, 10282, 10259
12439, 10259, 10282, 10283, 10260
12440, 10260, 10283, 10284, 10261
12441, 10261, 10284, 10285, 10262
12442, 10262, 10285, 10286, 10263
12443, 10263, 10286, 10287, 10264
12444, 10264, 10287, 10288, 10265
12445, 10265, 10288, 10289, 10266
12446, 10266, 10289, 10290, 10267
12447, 10267, 10290, 10291, 10268
12448, 10268, 10291, 10292, 10269
12449, 10269, 10292, 10293, 10270
12450, 10270, 10293, 10294, 10271
12451, 10271, 10294, 10295, 10272
12452, 10272, 10295, 1513, 1512
12453, 1490, 1491, 10296, 10273
12454, 10273, 10296, 10297, 10274
12455, 10274, 10297, 10298, 10275
12456, 10275, 10298, 10299, 10276
12457, 10276, 10299, 10300, 10277
12458, 10277, 10300, 10301, 10278
12459, 10278, 10301, 10302, 10279
12460, 10279, 10302, 10303, 10280
12461, 10280, 10303, 10304, 10281
12462, 10281, 10304, 10305, 10282
12463, 10282, 10305, 10306, 10283
12464, 10283, 10306, 10307, 10284
12465, 10284, 10307, 10308, 10285
12466, 10285, 10308, 10309, 10286
12467, 10286, 10309, 10310, 10287
12468, 10287, 10310, 10311, 10288
12469, 10288, 10311, 10312, 10289
12470, 10289, 10312, 10313, 10290
12471, 10290, 10313, 10314, 10291
12472, 10291, 10314, 10315, 10292
12473, 10292, 10315, 10316, 10293
12474, 10293, 10316, 10317, 10294
12475, 10294, 10317, 10318, 10295
12476, 10295, 10318, 1514, 1513
12477, 1491, 1492, 10319, 10296
12478, 10296, 10319, 10320, 10297
12479, 10297, 10320, 10321, 10298
12480, 10298, 10321, 10322, 10299
12481, 10299, 10322, 10323, 10300
12482, 10300, 10323, 10324, 10301
12483, 10301, 10324, 10325, 10302
12484, 10302, 10325, 10326, 10303
12485, 10303, 10326, 10327, 10304
12486, 10304, 10327, 10328, 10305
12487, 10305, 10328, 10329, 10306
12488, 10306, 10329, 10330, 10307
12489, 10307, 10330, 10331, 10308
12490, 10308, 10331, 10332, 10309
12491, 10309, 10332, 10333, 10310
12492, 10310, 10333, 10334, 10311
12493, 10311, 10334, 10335, 10312
12494, 10312, 10335, 10336, 10313
12495, 10313, 10336, 10337, 10314
12496, 10314, 10337, 10338, 10315
12497, 10315, 10338, 10339, 10316
12498, 10316, 10339, 10340, 10317
12499, 10317, 10340, 10341, 10318
12500, 10318, 10341, 1515, 1514
12501, 1492, 1493, 10342, 10319
12502, 10319, 10342, 10343, 10320
12503, 10320, 10343, 10344, 10321
12504, 10321, 10344, 10345, 10322
12505, 10322, 10345, 10346, 10323
12506, 10323, 10346, 10347, 10324
12507, 10324, 10347, 10348, 10325
12508, 10325, 10348, 10349, 10326
12509, 10326, 10349, 10350, 10327
12510, 10327, 10350, 10351, 10328
12511, 10328, 10351, 10352, 10329
12512, 10329, 10352, 10353, 10330
12513, 10330, 10353, 10354, 10331
12514, 10331, 10354, 10355, 10332
12515, 10332, 10355, 10356, 10333
12516, 10333, 10356, 10357, 10334
12517, 10334, 10357, 10358, 10335
12518, 10335, 10358, 10359, 10336
12519, 10336, 10359, 10360, 10337
12520, 10337, 10360, 10361, 10338
12521, 10338, 10361, 10362, 10339
12522, 10339, 10362, 10363, 10340
12523, 10340, 10363, 10364, 10341
12524, 10341, 10364, 1516, 1515
12525, 1493, 71, 1448, 10342
12526, 10342, 1448, 1449, 10343
12527, 10343, 1449, 1450, 10344
12528, 10344, 1450, 1451, 10345
12529, 10345, 1451, 1452, 10346
12530, 10346, 1452, 1453, 10347
12531, 10347, 1453, 1454, 10348
12532, 10348, 1454, 1455, 10349
12533, 10349, 1455, 1456, 10350
12534, 10350, 1456, 1457, 10351
12535, 10351, 1457, 1458, 10352
12536, 10352, 1458, 1459, 10353
12537, 10353, 1459, 1460, 10354
12538, 10354, 1460, 1461, 10355
12539, 10355, 1461, 1462, 10356
12540, 10356, 1462, 1463, 10357
12541, 10357, 1463, 1464, 10358
12542, 10358, 1464, 1465, 10359
12543, 10359, 1465, 1466, 10360
12544, 10360, 1466, 1467, 10361
12545, 10361, 1467, 1468, 10362
12546, 10362, 1468, 1469, 10363
12547, 10363, 1469, 1470, 10364
12548, 10364, 1470, 72, 1516
*ELEMENT, type=CPS4, ELSET=Surface97
12549, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
12550, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
12551, 63, 73, 1517, 1288
12552, 1288, 1517, 1518, 1289
12553, 1289, 1518, 1519, 1290
12554, 1290, 1519, 1520, 1291
12555, 1291, 1520, 1521, 1292
12556, 1292, 1521, 1522, 1293
12557, 1293, 1522, 1523, 1294
12558, 1294, 1523, 1524, 1295
12559, 1295, 1524, 1525, 1296
12560, 1296, 1525, 1526, 1297
12561, 1297, 1526, 1527, 1298
12562, 1298, 1527, 1528, 1299
12563, 1299, 1528, 1529, 1300
12564, 1300, 1529, 1530, 1301
12565, 1301, 1530, 1531, 1302
12566, 1302, 1531, 1532, 1303
12567, 1303, 1532, 1533, 1304
12568, 1304, 1533, 1534, 1305
12569, 1305, 1534, 1535, 1306
12570, 1306, 1535, 1536, 1307
12571, 1307, 1536, 1537, 1308
12572, 1308, 1537, 1538, 1309
12573, 1309, 1538, 1539, 1310
12574, 1310, 1539, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
12575, 69, 1425, 1517, 73
12576, 1425, 1426, 1518, 1517
12577, 1426, 1427, 1519, 1518
12578, 1427, 1428, 1520, 1519
12579, 1428, 1429, 1521, 1520
12580, 1429, 1430, 1522, 1521
12581, 1430, 1431, 1523, 1522
12582, 1431, 1432, 1524, 1523
12583, 1432, 1433, 1525, 1524
12584, 1433, 1434, 1526, 1525
12585, 1434, 1435, 1527, 1526
12586, 1435, 1436, 1528, 1527
12587, 1436, 1437, 1529, 1528
12588, 1437, 1438, 1530, 1529
12589, 1438, 1439, 1531, 1530
12590, 1439, 1440, 1532, 1531
12591, 1440, 1441, 1533, 1532
12592, 1441, 1442, 1534, 1533
12593, 1442, 1443, 1535, 1534
12594, 1443, 1444, 1536, 1535
12595, 1444, 1445, 1537, 1536
12596, 1445, 1446, 1538, 1537
12597, 1446, 1447, 1539, 1538
12598, 1447, 70, 74, 1539
*ELEMENT, type=CPS4, ELSET=Surface101
12599, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
12600, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
12601, 59, 75, 1540, 1220
12602, 1220, 1540, 1541, 1221
12603, 1221, 1541, 1542, 1222
12604, 1222, 1542, 1543, 1223
12605, 1223, 1543, 1544, 1224
12606, 1224, 1544, 1545, 1225
12607, 1225, 1545, 1546, 1226
12608, 1226, 1546, 1547, 1227
12609, 1227, 1547, 1548, 1228
12610, 1228, 1548, 1549, 1229
12611, 1229, 1549, 1550, 1230
12612, 1230, 1550, 1551, 1231
12613, 1231, 1551, 1552, 1232
12614, 1232, 1552, 1553, 1233
12615, 1233, 1553, 1554, 1234
12616, 1234, 1554, 1555, 1235
12617, 1235, 1555, 1556, 1236
12618, 1236, 1556, 1557, 1237
12619, 1237, 1557, 1558, 1238
12620, 1238, 1558, 1559, 1239
12621, 1239, 1559, 1560, 1240
12622, 1240, 1560, 1561, 1241
12623, 1241, 1561, 1562, 1242
12624, 1242, 1562, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
12625, 65, 1333, 1540, 75
12626, 1333, 1334, 1541, 1540
12627, 1334, 1335, 1542, 1541
12628, 1335, 1336, 1543, 1542
12629, 1336, 1337, 1544, 1543
12630, 1337, 1338, 1545, 1544
12631, 1338, 1339, 1546, 1545
12632, 1339, 1340, 1547, 1546
12633, 1340, 1341, 1548, 1547
12634, 1341, 1342, 1549, 1548
12635, 1342, 1343, 1550, 1549
12636, 1343, 1344, 1551, 1550
12637, 1344, 1345, 1552, 1551
12638, 1345, 1346, 1553, 1552
12639, 1346, 1347, 1554, 1553
12640, 1347, 1348, 1555, 1554
12641, 1348, 1349, 1556, 1555
12642, 1349, 1350, 1557, 1556
12643, 1350, 1351, 1558, 1557
12644, 1351, 1352, 1559, 1558
12645, 1352, 1353, 1560, 1559
12646, 1353, 1354, 1561, 1560
12647, 1354, 1355, 1562, 1561
12648, 1355, 66, 76, 1562
*ELEMENT, type=CPS4, ELSET=Surface105
12649, 22, 1567, 10365, 541
12650, 1567, 1568, 10366, 10365
12651, 1568, 1569, 10367, 10366
12652, 1569, 1570, 10368, 10367
12653, 1570, 78, 1571, 10368
12654, 541, 10365, 10369, 542
12655, 10365, 10366, 10370, 10369
12656, 10366, 10367, 10371, 10370
12657, 10367, 10368, 10372, 10371
12658, 10368, 1571, 1572, 10372
12659, 542, 10369, 10373, 543
12660, 10369, 10370, 10374, 10373
12661, 10370, 10371, 10375, 10374
12662, 10371, 10372, 10376, 10375
12663, 10372, 1572, 1573, 10376
12664, 543, 10373, 10377, 544
12665, 10373, 10374, 10378, 10377
12666, 10374, 10375, 10379, 10378
12667, 10375, 10376, 10380, 10379
12668, 10376, 1573, 1574, 10380
12669, 544, 10377, 10381, 545
12670, 10377, 10378, 10382, 10381
12671, 10378, 10379, 10383, 10382
12672, 10379, 10380, 10384, 10383
12673, 10380, 1574, 1575, 10384
12674, 545, 10381, 10385, 546
12675, 10381, 10382, 10386, 10385
12676, 10382, 10383, 10387, 10386
12677, 10383, 10384, 10388, 10387
12678, 10384, 1575, 1576, 10388
12679, 546, 10385, 10389, 547
12680, 10385, 10386, 10390, 10389
12681, 10386, 10387, 10391, 10390
12682, 10387, 10388, 10392, 10391
12683, 10388, 1576, 1577, 10392
12684, 547, 10389, 10393, 548
12685, 10389, 10390, 10394, 10393
12686, 10390, 10391, 10395, 10394
12687, 10391, 10392, 10396, 10395
12688, 10392, 1577, 1578, 10396
12689, 548, 10393, 10397, 549
12690, 10393, 10394, 10398, 10397
12691, 10394, 10395, 10399, 10398
12692, 10395, 10396, 10400, 10399
12693, 10396, 1578, 1579, 10400
12694, 549, 10397, 10401, 550
12695, 10397, 10398, 10402, 10401
12696, 10398, 10399, 10403, 10402
12697, 10399, 10400, 10404, 10403
12698, 10400, 1579, 1580, 10404
12699, 550, 10401, 10405, 551
12700, 10401, 10402, 10406, 10405
12701, 10402, 10403, 10407, 10406
12702, 10403, 10404, 10408, 10407
12703, 10404, 1580, 1581, 10408
12704, 551, 10405, 10409, 552
12705, 10405, 10406, 10410, 10409
12706, 10406, 10407, 10411, 10410
12707, 10407, 10408, 10412, 10411
12708, 10408, 1581, 1582, 10412
12709, 552, 10409, 10413, 553
12710, 10409, 10410, 10414, 10413
12711, 10410, 10411, 10415, 10414
12712, 10411, 10412, 10416, 10415
12713, 10412, 1582, 1583, 10416
12714, 553, 10413, 10417, 554
12715, 10413, 10414, 10418, 10417
12716, 10414, 10415, 10419, 10418
12717, 10415, 10416, 10420, 10419
12718, 10416, 1583, 1584, 10420
12719, 554, 10417, 10421, 555
12720, 10417, 10418, 10422, 10421
12721, 10418, 10419, 10423, 10422
12722, 10419, 10420, 10424, 10423
12723, 10420, 1584, 1585, 10424
12724, 555, 10421, 10425, 556
12725, 10421, 10422, 10426, 10425
12726, 10422, 10423, 10427, 10426
12727, 10423, 10424, 10428, 10427
12728, 10424, 1585, 1586, 10428
12729, 556, 10425, 10429, 557
12730, 10425, 10426, 10430, 10429
12731, 10426, 10427, 10431, 10430
12732, 10427, 10428, 10432, 10431
12733, 10428, 1586, 1587, 10432
12734, 557, 10429, 10433, 558
12735, 10429, 10430, 10434, 10433
12736, 10430, 10431, 10435, 10434
12737, 10431, 10432, 10436, 10435
12738, 10432, 1587, 1588, 10436
12739, 558, 10433, 10437, 559
12740, 10433, 10434, 10438, 10437
12741, 10434, 10435, 10439, 10438
12742, 10435, 10436, 10440, 10439
12743, 10436, 1588, 1589, 10440
12744, 559, 10437, 10441, 560
12745, 10437, 10438, 10442, 10441
12746, 10438, 10439, 10443, 10442
12747, 10439, 10440, 10444, 10443
12748, 10440, 1589, 1590, 10444
12749, 560, 10441, 10445, 561
12750, 10441, 10442, 10446, 10445
12751, 10442, 10443, 10447, 10446
12752, 10443, 10444, 10448, 10447
12753, 10444, 1590, 1591, 10448
12754, 561, 10445, 10449, 562
12755, 10445, 10446, 10450, 10449
12756, 10446, 10447, 10451, 10450
12757, 10447, 10448, 10452, 10451
12758, 10448, 1591, 1592, 10452
12759, 562, 10449, 10453, 563
12760, 10449, 10450, 10454, 10453
12761, 10450, 10451, 10455, 10454
12762, 10451, 10452, 10456, 10455
12763, 10452, 1592, 1593, 10456
12764, 563, 10453, 1563, 21
12765, 10453, 10454, 1564, 1563
12766, 10454, 10455, 1565, 1564
12767, 10455, 10456, 1566, 1565
12768, 10456, 1593, 77, 1566
*ELEMENT, type=CPS4, ELSET=Surface106
12769, 21, 1563, 10457, 566
12770, 1563, 1564, 10458, 10457
12771, 1564, 1565, 10459, 10458
12772, 1565, 1566, 10460, 10459
12773, 1566, 77, 1598, 10460
12774, 566, 10457, 10461, 567
12775, 10457, 10458, 10462, 10461
12776, 10458, 10459, 10463, 10462
12777, 10459, 10460, 10464, 10463
12778, 10460, 1598, 1599, 10464
12779, 567, 10461, 10465, 568
12780, 10461, 10462, 10466, 10465
12781, 10462, 10463, 10467, 10466
12782, 10463, 10464, 10468, 10467
12783, 10464, 1599, 1600, 10468
12784, 568, 10465, 10469, 569
12785, 10465, 10466, 10470, 10469
12786, 10466, 10467, 10471, 10470
12787, 10467, 10468, 10472, 10471
12788, 10468, 1600, 1601, 10472
12789, 569, 10469, 10473, 570
12790, 10469, 10470, 10474, 10473
12791, 10470, 10471, 10475, 10474
12792, 10471, 10472, 10476, 10475
12793, 10472, 1601, 1602, 10476
12794, 570, 10473, 10477, 571
12795, 10473, 10474, 10478, 10477
12796, 10474, 10475, 10479, 10478
12797, 10475, 10476, 10480, 10479
12798, 10476, 1602, 1603, 10480
12799, 571, 10477, 10481, 572
12800, 10477, 10478, 10482, 10481
12801, 10478, 10479, 10483, 10482
12802, 10479, 10480, 10484, 10483
12803, 10480, 1603, 1604, 10484
12804, 572, 10481, 10485, 573
12805, 10481, 10482, 10486, 10485
12806, 10482, 10483, 10487, 10486
12807, 10483, 10484, 10488, 10487
12808, 10484, 1604, 1605, 10488
12809, 573, 10485, 10489, 574
12810, 10485, 10486, 10490, 10489
12811, 10486, 10487, 10491, 10490
12812, 10487, 10488, 10492, 10491
12813, 10488, 1605, 1606, 10492
12814, 574, 10489, 10493, 575
12815, 10489, 10490, 10494, 10493
12816, 10490, 10491, 10495, 10494
12817, 10491, 10492, 10496, 10495
12818, 10492, 1606, 1607, 10496
12819, 575, 10493, 10497, 576
12820, 10493, 10494, 10498, 10497
12821, 10494, 10495, 10499, 10498
12822, 10495, 10496, 10500, 10499
12823, 10496, 1607, 1608, 10500
12824, 576, 10497, 1594, 23
12825, 10497, 10498, 1595, 1594
12826, 10498, 10499, 1596, 1595
12827, 10499, 10500, 1597, 1596
12828, 10500, 1608, 79, 1597
*ELEMENT, type=CPS4, ELSET=Surface107
12829, 24, 579, 10501, 1609
12830, 1609, 10501, 10502, 1610
12831, 1610, 10502, 10503, 1611
12832, 1611, 10503, 10504, 1612
12833, 1612, 10504, 1613, 80
12834, 579, 580, 10505, 10501
12835, 10501, 10505, 10506, 10502
12836, 10502, 10506, 10507, 10503
12837, 10503, 10507, 10508, 10504
12838, 10504, 10508, 1614, 1613
12839, 580, 581, 10509, 10505
12840, 10505, 10509, 10510, 10506
12841, 10506, 10510, 10511, 10507
12842, 10507, 10511, 10512, 10508
12843, 10508, 10512, 1615, 1614
12844, 581, 582, 10513, 10509
12845, 10509, 10513, 10514, 10510
12846, 10510, 10514, 10515, 10511
12847, 10511, 10515, 10516, 10512
12848, 10512, 10516, 1616, 1615
12849, 582, 583, 10517, 10513
12850, 10513, 10517, 10518, 10514
12851, 10514, 10518, 10519, 10515
12852, 10515, 10519, 10520, 10516
12853, 10516, 10520, 1617, 1616
12854, 583, 584, 10521, 10517
12855, 10517, 10521, 10522, 10518
12856, 10518, 10522, 10523, 10519
12857, 10519, 10523, 10524, 10520
12858, 10520, 10524, 1618, 1617
12859, 584, 585, 10525, 10521
12860, 10521, 10525, 10526, 10522
12861, 10522, 10526, 10527, 10523
12862, 10523, 10527, 10528, 10524
12863, 10524, 10528, 1619, 1618
12864, 585, 586, 10529, 10525
12865, 10525, 10529, 10530, 10526
12866, 10526, 10530, 10531, 10527
12867, 10527, 10531, 10532, 10528
12868, 10528, 10532, 1620, 1619
12869, 586, 587, 10533, 10529
12870, 10529, 10533, 10534, 10530
12871, 10530, 10534, 10535, 10531
12872, 10531, 10535, 10536, 10532
12873, 10532, 10536, 1621, 1620
12874, 587, 588, 10537, 10533
12875, 10533, 10537, 10538, 10534
12876, 10534, 10538, 10539, 10535
12877, 10535, 10539, 10540, 10536
12878, 10536, 10540, 1622, 1621
12879, 588, 589, 10541, 10537
12880, 10537, 10541, 10542, 10538
12881, 10538, 10542, 10543, 10539
12882, 10539, 10543, 10544, 10540
12883, 10540, 10544, 1623, 1622
12884, 589, 590, 10545, 10541
12885, 10541, 10545, 10546, 10542
12886, 10542, 10546, 10547, 10543
12887, 10543, 10547, 10548, 10544
12888, 10544, 10548, 1624, 1623
12889, 590, 591, 10549, 10545
12890, 10545, 10549, 10550, 10546
12891, 10546, 10550, 10551, 10547
12892, 10547, 10551, 10552, 10548
12893, 10548, 10552, 1625, 1624
12894, 591, 592, 10553, 10549
12895, 10549, 10553, 10554, 10550
12896, 10550, 10554, 10555, 10551
12897, 10551, 10555, 10556, 10552
12898, 10552, 10556, 1626, 1625
12899, 592, 593, 10557, 10553
12900, 10553, 10557, 10558, 10554
12901, 10554, 10558, 10559, 10555
12902, 10555, 10559, 10560, 10556
12903, 10556, 10560, 1627, 1626
12904, 593, 594, 10561, 10557
12905, 10557, 10561, 10562, 10558
12906, 10558, 10562, 10563, 10559
12907, 10559, 10563, 10564, 10560
12908, 10560, 10564, 1628, 1627
12909, 594, 595, 10565, 10561
12910, 10561, 10565, 10566, 10562
12911, 10562, 10566, 10567, 10563
12912, 10563, 10567, 10568, 10564
12913, 10564, 10568, 1629, 1628
12914, 595, 596, 10569, 10565
12915, 10565, 10569, 10570, 10566
12916, 10566, 10570, 10571, 10567
12917, 10567, 10571, 10572, 10568
12918, 10568, 10572, 1630, 1629
12919, 596, 597, 10573, 10569
12920, 10569, 10573, 10574, 10570
12921, 10570, 10574, 10575, 10571
12922, 10571, 10575, 10576, 10572
12923, 10572, 10576, 1631, 1630
12924, 597, 598, 10577, 10573
12925, 10573, 10577, 10578, 10574
12926, 10574, 10578, 10579, 10575
12927, 10575, 10579, 10580, 10576
12928, 10576, 10580, 1632, 1631
12929, 598, 599, 10581, 10577
12930, 10577, 10581, 10582, 10578
12931, 10578, 10582, 10583, 10579
12932, 10579, 10583, 10584, 10580
12933, 10580, 10584, 1633, 1632
12934, 599, 600, 10585, 10581
12935, 10581, 10585, 10586, 10582
12936, 10582, 10586, 10587, 10583
12937, 10583, 10587, 10588, 10584
12938, 10584, 10588, 1634, 1633
12939, 600, 601, 10589, 10585
12940, 10585, 10589, 10590, 10586
12941, 10586, 10590, 10591, 10587
12942, 10587, 10591, 10592, 10588
12943, 10588, 10592, 1635, 1634
12944, 601, 23, 1594, 10589
12945, 10589, 1594, 1595, 10590
12946, 10590, 1595, 1596, 10591
12947, 10591, 1596, 1597, 10592
12948, 10592, 1597, 79, 1635
*ELEMENT, type=CPS4, ELSET=Surface108
12949, 22, 602, 10593, 1567
12950, 1567, 10593, 10594, 1568
12951, 1568, 10594, 10595, 1569
12952, 1569, 10595, 10596, 1570
12953, 1570, 10596, 1636, 78
12954, 602, 603, 10597, 10593
12955, 10593, 10597, 10598, 10594
12956, 10594, 10598, 10599, 10595
12957, 10595, 10599, 10600, 10596
12958, 10596, 10600, 1637, 1636
12959, 603, 604, 10601, 10597
12960, 10597, 10601, 10602, 10598
12961, 10598, 10602, 10603, 10599
12962, 10599, 10603, 10604, 10600
12963, 10600, 10604, 1638, 1637
12964, 604, 605, 10605, 10601
12965, 10601, 10605, 10606, 10602
12966, 10602, 10606, 10607, 10603
12967, 10603, 10607, 10608, 10604
12968, 10604, 10608, 1639, 1638
12969, 605, 606, 10609, 10605
12970, 10605, 10609, 10610, 10606
12971, 10606, 10610, 10611, 10607
12972, 10607, 10611, 10612, 10608
12973, 10608, 10612, 1640, 1639
12974, 606, 607, 10613, 10609
12975, 10609, 10613, 10614, 10610
12976, 10610, 10614, 10615, 10611
12977, 10611, 10615, 10616, 10612
12978, 10612, 10616, 1641, 1640
12979, 607, 608, 10617, 10613
12980, 10613, 10617, 10618, 10614
12981, 10614, 10618, 10619, 10615
12982, 10615, 10619, 10620, 10616
12983, 10616, 10620, 1642, 1641
12984, 608, 609, 10621, 10617
12985, 10617, 10621, 10622, 10618
12986, 10618, 10622, 10623, 10619
12987, 10619, 10623, 10624, 10620
12988, 10620, 10624, 1643, 1642
12989, 609, 610, 10625, 10621
12990, 10621, 10625, 10626, 10622
12991, 10622, 10626, 10627, 10623
12992, 10623, 10627, 10628, 10624
12993, 10624, 10628, 1644, 1643
12994, 610, 611, 10629, 10625
12995, 10625, 10629, 10630, 10626
12996, 10626, 10630, 10631, 10627
12997, 10627, 10631, 10632, 10628
12998, 10628, 10632, 1645, 1644
12999, 611, 612, 10633, 10629
13000, 10629, 10633, 10634, 10630
13001, 10630, 10634, 10635, 10631
13002, 10631, 10635, 10636, 10632
13003, 10632, 10636, 1646, 1645
13004, 612, 24, 1609, 10633
13005, 10633, 1609, 1610, 10634
13006, 10634, 1610, 1611, 10635
13007, 10635, 1611, 1612, 10636
13008, 10636, 1612, 80, 1646
*ELEMENT, type=CPS4, ELSET=Surface109
13009, 78, 1636, 10637, 1571
13010, 1636, 1637, 10638, 10637
13011, 1637, 1638, 10639, 10638
13012, 1638, 1639, 10640, 10639
13013, 1639, 1640, 10641, 10640
13014, 1640, 1641, 10642, 10641
13015, 1641, 1642, 10643, 10642
13016, 1642, 1643, 10644, 10643
13017, 1643, 1644, 10645, 10644
13018, 1644, 1645, 10646, 10645
13019, 1645, 1646, 10647, 10646
13020, 1646, 80, 1613, 10647
13021, 1571, 10637, 10648, 1572
13022, 10637, 10638, 10649, 10648
13023, 10638, 10639, 10650, 10649
13024, 10639, 10640, 10651, 10650
13025, 10640, 10641, 10652, 10651
13026, 10641, 10642, 10653, 10652
13027, 10642, 10643, 10654, 10653
13028, 10643, 10644, 10655, 10654
13029, 10644, 10645, 10656, 10655
13030, 10645, 10646, 10657, 10656
13031, 10646, 10647, 10658, 10657
13032, 10647, 1613, 1614, 10658
13033, 1572, 10648, 10659, 1573
13034, 10648, 10649, 10660, 10659
13035, 10649, 10650, 10661, 10660
13036, 10650, 10651, 10662, 10661
13037, 10651, 10652, 10663, 10662
13038, 10652, 10653, 10664, 10663
13039, 10653, 10654, 10665, 10664
13040, 10654, 10655, 10666, 10665
13041, 10655, 10656, 10667, 10666
13042, 10656, 10657, 10668, 10667
13043, 10657, 10658, 10669, 10668
13044, 10658, 1614, 1615, 10669
13045, 1573, 10659, 10670, 1574
13046, 10659, 10660, 10671, 10670
13047, 10660, 10661, 10672, 10671
13048, 10661, 10662, 10673, 10672
13049, 10662, 10663, 10674, 10673
13050, 10663, 10664, 10675, 10674
13051, 10664, 10665, 10676, 10675
13052, 10665, 10666, 10677, 10676
13053, 10666, 10667, 10678, 10677
13054, 10667, 10668, 10679, 10678
13055, 10668, 10669, 10680, 10679
13056, 10669, 1615, 1616, 10680
13057, 1574, 10670, 10681, 1575
13058, 10670, 10671, 10682, 10681
13059, 10671, 10672, 10683, 10682
13060, 10672, 10673, 10684, 10683
13061, 10673, 10674, 10685, 10684
13062, 10674, 10675, 10686, 10685
13063, 10675, 10676, 10687, 10686
13064, 10676, 10677, 10688, 10687
13065, 10677, 10678, 10689, 10688
13066, 10678, 10679, 10690, 10689
13067, 10679, 10680, 10691, 10690
13068, 10680, 1616, 1617, 10691
13069, 1575, 10681, 10692, 1576
13070, 10681, 10682, 10693, 10692
13071, 10682, 10683, 10694, 10693
13072, 10683, 10684, 10695, 10694
13073, 10684, 10685, 10696, 10695
13074, 10685, 10686, 10697, 10696
13075, 10686, 10687, 10698, 10697
13076, 10687, 10688, 10699, 10698
13077, 10688, 10689, 10700, 10699
13078, 10689, 10690, 10701, 10700
13079, 10690, 10691, 10702, 10701
13080, 10691, 1617, 1618, 10702
13081, 1576, 10692, 10703, 1577
13082, 10692, 10693, 10704, 10703
13083, 10693, 10694, 10705, 10704
13084, 10694, 10695, 10706, 10705
13085, 10695, 10696, 10707, 10706
13086, 10696, 10697, 10708, 10707
13087, 10697, 10698, 10709, 10708
13088, 10698, 10699, 10710, 10709
13089, 10699, 10700, 10711, 10710
13090, 10700, 10701, 10712, 10711
13091, 10701, 10702, 10713, 10712
13092, 10702, 1618, 1619, 10713
13093, 1577, 10703, 10714, 1578
13094, 10703, 10704, 10715, 10714
13095, 10704, 10705, 10716, 10715
13096, 10705, 10706, 10717, 10716
13097, 10706, 10707, 10718, 10717
13098, 10707, 10708, 10719, 10718
13099, 10708, 10709, 10720, 10719
13100, 10709, 10710, 10721, 10720
13101, 10710, 10711, 10722, 10721
13102, 10711, 10712, 10723, 10722
13103, 10712, 10713, 10724, 10723
13104, 10713, 1619, 1620, 10724
13105, 1578, 10714, 10725, 1579
13106, 10714, 10715, 10726, 10725
13107, 10715, 10716, 10727, 10726
13108, 10716, 10717, 10728, 10727
13109, 10717, 10718, 10729, 10728
13110, 10718, 10719, 10730, 10729
13111, 10719, 10720, 10731, 10730
13112, 10720, 10721, 10732, 10731
13113, 10721, 10722, 10733, 10732
13114, 10722, 10723, 10734, 10733
13115, 10723, 10724, 10735, 10734
13116, 10724, 1620, 1621, 10735
13117, 1579, 10725, 10736, 1580
13118, 10725, 10726, 10737, 10736
13119, 10726, 10727, 10738, 10737
13120, 10727, 10728, 10739, 10738
13121, 10728, 10729, 10740, 10739
13122, 10729, 10730, 10741, 10740
13123, 10730, 10731, 10742, 10741
13124, 10731, 10732, 10743, 10742
13125, 10732, 10733, 10744, 10743
13126, 10733, 10734, 10745, 10744
13127, 10734, 10735, 10746, 10745
13128, 10735, 1621, 1622, 10746
13129, 1580, 10736, 10747, 1581
13130, 10736, 10737, 10748, 10747
13131, 10737, 10738, 10749, 10748
13132, 10738, 10739, 10750, 10749
13133, 10739, 10740, 10751, 10750
13134, 10740, 10741, 10752, 10751
13135, 10741, 10742, 10753, 10752
13136, 10742, 10743, 10754, 10753
13137, 10743, 10744, 10755, 10754
13138, 10744, 10745, 10756, 10755
13139, 10745, 10746, 10757, 10756
13140, 10746, 1622, 1623, 10757
13141, 1581, 10747, 10758, 1582
13142, 10747, 10748, 10759, 10758
13143, 10748, 10749, 10760, 10759
13144, 10749, 10750, 10761, 10760
13145, 10750, 10751, 10762, 10761
13146, 10751, 10752, 10763, 10762
13147, 10752, 10753, 10764, 10763
13148, 10753, 10754, 10765, 10764
13149, 10754, 10755, 10766, 10765
13150, 10755, 10756, 10767, 10766
13151, 10756, 10757, 10768, 10767
13152, 10757, 1623, 1624, 10768
13153, 1582, 10758, 10769, 1583
13154, 10758, 10759, 10770, 10769
13155, 10759, 10760, 10771, 10770
13156, 10760, 10761, 10772, 10771
13157, 10761, 10762, 10773, 10772
13158, 10762, 10763, 10774, 10773
13159, 10763, 10764, 10775, 10774
13160, 10764, 10765, 10776, 10775
13161, 10765, 10766, 10777, 10776
13162, 10766, 10767, 10778, 10777
13163, 10767, 10768, 10779, 10778
13164, 10768, 1624, 1625, 10779
13165, 1583, 10769, 10780, 1584
13166, 10769, 10770, 10781, 10780
13167, 10770, 10771, 10782, 10781
13168, 10771, 10772, 10783, 10782
13169, 10772, 10773, 10784, 10783
13170, 10773, 10774, 10785, 10784
13171, 10774, 10775, 10786, 10785
13172, 10775, 10776, 10787, 10786
13173, 10776, 10777, 10788, 10787
13174, 10777, 10778, 10789, 10788
13175, 10778, 10779, 10790, 10789
13176, 10779, 1625, 1626, 10790
13177, 1584, 10780, 10791, 1585
13178, 10780, 10781, 10792, 10791
13179, 10781, 10782, 10793, 10792
13180, 10782, 10783, 10794, 10793
13181, 10783, 10784, 10795, 10794
13182, 10784, 10785, 10796, 10795
13183, 10785, 10786, 10797, 10796
13184, 10786, 10787, 10798, 10797
13185, 10787, 10788, 10799, 10798
13186, 10788, 10789, 10800, 10799
13187, 10789, 10790, 10801, 10800
13188, 10790, 1626, 1627, 10801
13189, 1585, 10791, 10802, 1586
13190, 10791, 10792, 10803, 10802
13191, 10792, 10793, 10804, 10803
13192, 10793, 10794, 10805, 10804
13193, 10794, 10795, 10806, 10805
13194, 10795, 10796, 10807, 10806
13195, 10796, 10797, 10808, 10807
13196, 10797, 10798, 10809, 10808
13197, 10798, 10799, 10810, 10809
13198, 10799, 10800, 10811, 10810
13199, 10800, 10801, 10812, 10811
13200, 10801, 1627, 1628, 10812
13201, 1586, 10802, 10813, 1587
13202, 10802, 10803, 10814, 10813
13203, 10803, 10804, 10815, 10814
13204, 10804, 10805, 10816, 10815
13205, 10805, 10806, 10817, 10816
13206, 10806, 10807, 10818, 10817
13207, 10807, 10808, 10819, 10818
13208, 10808, 10809, 10820, 10819
13209, 10809, 10810, 10821, 10820
13210, 10810, 10811, 10822, 10821
13211, 10811, 10812, 10823, 10822
13212, 10812, 1628, 1629, 10823
13213, 1587, 10813, 10824, 1588
13214, 10813, 10814, 10825, 10824
13215, 10814, 10815, 10826, 10825
13216, 10815, 10816, 10827, 10826
13217, 10816, 10817, 10828, 10827
13218, 10817, 10818, 10829, 10828
13219, 10818, 10819, 10830, 10829
13220, 10819, 10820, 10831, 10830
13221, 10820, 10821, 10832, 10831
13222, 10821, 10822, 10833, 10832
13223, 10822, 10823, 10834, 10833
13224, 10823, 1629, 1630, 10834
13225, 1588, 10824, 10835, 1589
13226, 10824, 10825, 10836, 10835
13227, 10825, 10826, 10837, 10836
13228, 10826, 10827, 10838, 10837
13229, 10827, 10828, 10839, 10838
13230, 10828, 10829, 10840, 10839
13231, 10829, 10830, 10841, 10840
13232, 10830, 10831, 10842, 10841
13233, 10831, 10832, 10843, 10842
13234, 10832, 10833, 10844, 10843
13235, 10833, 10834, 10845, 10844
13236, 10834, 1630, 1631, 10845
13237, 1589, 10835, 10846, 1590
13238, 10835, 10836, 10847, 10846
13239, 10836, 10837, 10848, 10847
13240, 10837, 10838, 10849, 10848
13241, 10838, 10839, 10850, 10849
13242, 10839, 10840, 10851, 10850
13243, 10840, 10841, 10852, 10851
13244, 10841, 10842, 10853, 10852
13245, 10842, 10843, 10854, 10853
13246, 10843, 10844, 10855, 10854
13247, 10844, 10845, 10856, 10855
13248, 10845, 1631, 1632, 10856
13249, 1590, 10846, 10857, 1591
13250, 10846, 10847, 10858, 10857
13251, 10847, 10848, 10859, 10858
13252, 10848, 10849, 10860, 10859
13253, 10849, 10850, 10861, 10860
13254, 10850, 10851, 10862, 10861
13255, 10851, 10852, 10863, 10862
13256, 10852, 10853, 10864, 10863
13257, 10853, 10854, 10865, 10864
13258, 10854, 10855, 10866, 10865
13259, 10855, 10856, 10867, 10866
13260, 10856, 1632, 1633, 10867
13261, 1591, 10857, 10868, 1592
13262, 10857, 10858, 10869, 10868
13263, 10858, 10859, 10870, 10869
13264, 10859, 10860, 10871, 10870
13265, 10860, 10861, 10872, 10871
13266, 10861, 10862, 10873, 10872
13267, 10862, 10863, 10874, 10873
13268, 10863, 10864, 10875, 10874
13269, 10864, 10865, 10876, 10875
13270, 10865, 10866, 10877, 10876
13271, 10866, 10867, 10878, 10877
13272, 10867, 1633, 1634, 10878
13273, 1592, 10868, 10879, 1593
13274, 10868, 10869, 10880, 10879
13275, 10869, 10870, 10881, 10880
13276, 10870, 10871, 10882, 10881
13277, 10871, 10872, 10883, 10882
13278, 10872, 10873, 10884, 10883
13279, 10873, 10874, 10885, 10884
13280, 10874, 10875, 10886, 10885
13281, 10875, 10876, 10887, 10886
13282, 10876, 10877, 10888, 10887
13283, 10877, 10878, 10889, 10888
13284, 10878, 1634, 1635, 10889
13285, 1593, 10879, 1598, 77
13286, 10879, 10880, 1599, 1598
13287, 10880, 10881, 1600, 1599
13288, 10881, 10882, 1601, 1600
13289, 10882, 10883, 1602, 1601
13290, 10883, 10884, 1603, 1602
13291, 10884, 10885, 1604, 1603
13292, 10885, 10886, 1605, 1604
13293, 10886, 10887, 1606, 1605
13294, 10887, 10888, 1607, 1606
13295, 10888, 10889, 1608, 1607
13296, 10889, 1635, 79, 1608
*ELEMENT, type=CPS4, ELSET=Surface110
13297, 23, 617, 10890, 1594
13298, 1594, 10890, 10891, 1595
13299, 1595, 10891, 10892, 1596
13300, 1596, 10892, 10893, 1597
13301, 1597, 10893, 1651, 79
13302, 617, 618, 10894, 10890
13303, 10890, 10894, 10895, 10891
13304, 10891, 10895, 10896, 10892
13305, 10892, 10896, 10897, 10893
13306, 10893, 10897, 1652, 1651
13307, 618, 619, 10898, 10894
13308, 10894, 10898, 10899, 10895
13309, 10895, 10899, 10900, 10896
13310, 10896, 10900, 10901, 10897
13311, 10897, 10901, 1653, 1652
13312, 619, 620, 10902, 10898
13313, 10898, 10902, 10903, 10899
13314, 10899, 10903, 10904, 10900
13315, 10900, 10904, 10905, 10901
13316, 10901, 10905, 1654, 1653
13317, 620, 26, 1647, 10902
13318, 10902, 1647, 1648, 10903
13319, 10903, 1648, 1649, 10904
13320, 10904, 1649, 1650, 10905
13321, 10905, 1650, 81, 1654
*ELEMENT, type=CPS4, ELSET=Surface111
13322, 21, 1563, 10906, 627
13323, 1563, 1564, 10907, 10906
13324, 1564, 1565, 10908, 10907
13325, 1565, 1566, 10909, 10908
13326, 1566, 77, 1659, 10909
13327, 627, 10906, 10910, 628
13328, 10906, 10907, 10911, 10910
13329, 10907, 10908, 10912, 10911
13330, 10908, 10909, 10913, 10912
13331, 10909, 1659, 1660, 10913
13332, 628, 10910, 10914, 629
13333, 10910, 10911, 10915, 10914
13334, 10911, 10912, 10916, 10915
13335, 10912, 10913, 10917, 10916
13336, 10913, 1660, 1661, 10917
13337, 629, 10914, 10918, 630
13338, 10914, 10915, 10919, 10918
13339, 10915, 10916, 10920, 10919
13340, 10916, 10917, 10921, 10920
13341, 10917, 1661, 1662, 10921
13342, 630, 10918, 1655, 28
13343, 10918, 10919, 1656, 1655
13344, 10919, 10920, 1657, 1656
13345, 10920, 10921, 1658, 1657
13346, 10921, 1662, 82, 1658
*ELEMENT, type=CPS4, ELSET=Surface112
13347, 28, 1655, 10922, 644
13348, 1655, 1656, 10923, 10922
13349, 1656, 1657, 10924, 10923
13350, 1657, 1658, 10925, 10924
13351, 1658, 82, 1663, 10925
13352, 644, 10922, 10926, 645
13353, 10922, 10923, 10927, 10926
13354, 10923, 10924, 10928, 10927
13355, 10924, 10925, 10929, 10928
13356, 10925, 1663, 1664, 10929
13357, 645, 10926, 10930, 646
13358, 10926, 10927, 10931, 10930
13359, 10927, 10928, 10932, 10931
13360, 10928, 10929, 10933, 10932
13361, 10929, 1664, 1665, 10933
13362, 646, 10930, 10934, 647
13363, 10930, 10931, 10935, 10934
13364, 10931, 10932, 10936, 10935
13365, 10932, 10933, 10937, 10936
13366, 10933, 1665, 1666, 10937
13367, 647, 10934, 10938, 648
13368, 10934, 10935, 10939, 10938
13369, 10935, 10936, 10940, 10939
13370, 10936, 10937, 10941, 10940
13371, 10937, 1666, 1667, 10941
13372, 648, 10938, 10942, 649
13373, 10938, 10939, 10943, 10942
13374, 10939, 10940, 10944, 10943
13375, 10940, 10941, 10945, 10944
13376, 10941, 1667, 1668, 10945
13377, 649, 10942, 10946, 650
13378, 10942, 10943, 10947, 10946
13379, 10943, 10944, 10948, 10947
13380, 10944, 10945, 10949, 10948
13381, 10945, 1668, 1669, 10949
13382, 650, 10946, 10950, 651
13383, 10946, 10947, 10951, 10950
13384, 10947, 10948, 10952, 10951
13385, 10948, 10949, 10953, 10952
13386, 10949, 1669, 1670, 10953
13387, 651, 10950, 10954, 652
13388, 10950, 10951, 10955, 10954
13389, 10951, 10952, 10956, 10955
13390, 10952, 10953, 10957, 10956
13391, 10953, 1670, 1671, 10957
13392, 652, 10954, 10958, 653
13393, 10954, 10955, 10959, 10958
13394, 10955, 10956, 10960, 10959
13395, 10956, 10957, 10961, 10960
13396, 10957, 1671, 1672, 10961
13397, 653, 10958, 10962, 654
13398, 10958, 10959, 10963, 10962
13399, 10959, 10960, 10964, 10963
13400, 10960, 10961, 10965, 10964
13401, 10961, 1672, 1673, 10965
13402, 654, 10962, 1647, 26
13403, 10962, 10963, 1648, 1647
13404, 10963, 10964, 1649, 1648
13405, 10964, 10965, 1650, 1649
13406, 10965, 1673, 81, 1650
*ELEMENT, type=CPS4, ELSET=Surface113
13407, 77, 1598, 10966, 1659
13408, 1659, 10966, 10967, 1660
13409, 1660, 10967, 10968, 1661
13410, 1661, 10968, 10969, 1662
13411, 1662, 10969, 1663, 82
13412, 1598, 1599, 10970, 10966
13413, 10966, 10970, 10971, 10967
13414, 10967, 10971, 10972, 10968
13415, 10968, 10972, 10973, 10969
13416, 10969, 10973, 1664, 1663
13417, 1599, 1600, 10974, 10970
13418, 10970, 10974, 10975, 10971
13419, 10971, 10975, 10976, 10972
13420, 10972, 10976, 10977, 10973
13421, 10973, 10977, 1665, 1664
13422, 1600, 1601, 10978, 10974
13423, 10974, 10978, 10979, 10975
13424, 10975, 10979, 10980, 10976
13425, 10976, 10980, 10981, 10977
13426, 10977, 10981, 1666, 1665
13427, 1601, 1602, 10982, 10978
13428, 10978, 10982, 10983, 10979
13429, 10979, 10983, 10984, 10980
13430, 10980, 10984, 10985, 10981
13431, 10981, 10985, 1667, 1666
13432, 1602, 1603, 10986, 10982
13433, 10982, 10986, 10987, 10983
13434, 10983, 10987, 10988, 10984
13435, 10984, 10988, 10989, 10985
13436, 10985, 10989, 1668, 1667
13437, 1603, 1604, 10990, 10986
13438, 10986, 10990, 10991, 10987
13439, 10987, 10991, 10992, 10988
13440, 10988, 10992, 10993, 10989
13441, 10989, 10993, 1669, 1668
13442, 1604, 1605, 10994, 10990
13443, 10990, 10994, 10995, 10991
13444, 10991, 10995, 10996, 10992
13445, 10992, 10996, 10997, 10993
13446, 10993, 10997, 1670, 1669
13447, 1605, 1606, 10998, 10994
13448, 10994, 10998, 10999, 10995
13449, 10995, 10999, 11000, 10996
13450, 10996, 11000, 11001, 10997
13451, 10997, 11001, 1671, 1670
13452, 1606, 1607, 11002, 10998
13453, 10998, 11002, 11003, 10999
13454, 10999, 11003, 11004, 11000
13455, 11000, 11004, 11005, 11001
13456, 11001, 11005, 1672, 1671
13457, 1607, 1608, 11006, 11002
13458, 11002, 11006, 11007, 11003
13459, 11003, 11007, 11008, 11004
13460, 11004, 11008, 11009, 11005
13461, 11005, 11009, 1673, 1672
13462, 1608, 79, 1651, 11006
13463, 11006, 1651, 1652, 11007
13464, 11007, 1652, 1653, 11008
13465, 11008, 1653, 1654, 11009
13466, 11009, 1654, 81, 1673
*ELEMENT, type=CPS4, ELSET=Surface114
13467, 26, 678, 11010, 1647
13468, 1647, 11010, 11011, 1648
13469, 1648, 11011, 11012, 1649
13470, 1649, 11012, 11013, 1650
13471, 1650, 11013, 1678, 81
13472, 678, 679, 11014, 11010
13473, 11010, 11014, 11015, 11011
13474, 11011, 11015, 11016, 11012
13475, 11012, 11016, 11017, 11013
13476, 11013, 11017, 1679, 1678
13477, 679, 680, 11018, 11014
13478, 11014, 11018, 11019, 11015
13479, 11015, 11019, 11020, 11016
13480, 11016, 11020, 11021, 11017
13481, 11017, 11021, 1680, 1679
13482, 680, 681, 11022, 11018
13483, 11018, 11022, 11023, 11019
13484, 11019, 11023, 11024, 11020
13485, 11020, 11024, 11025, 11021
13486, 11021, 11025, 1681, 1680
13487, 681, 682, 11026, 11022
13488, 11022, 11026, 11027, 11023
13489, 11023, 11027, 11028, 11024
13490, 11024, 11028, 11029, 11025
13491, 11025, 11029, 1682, 1681
13492, 682, 683, 11030, 11026
13493, 11026, 11030, 11031, 11027
13494, 11027, 11031, 11032, 11028
13495, 11028, 11032, 11033, 11029
13496, 11029, 11033, 1683, 1682
13497, 683, 684, 11034, 11030
13498, 11030, 11034, 11035, 11031
13499, 11031, 11035, 11036, 11032
13500, 11032, 11036, 11037, 11033
13501, 11033, 11037, 1684, 1683
13502, 684, 685, 11038, 11034
13503, 11034, 11038, 11039, 11035
13504, 11035, 11039, 11040, 11036
13505, 11036, 11040, 11041, 11037
13506, 11037, 11041, 1685, 1684
13507, 685, 686, 11042, 11038
13508, 11038, 11042, 11043, 11039
13509, 11039, 11043, 11044, 11040
13510, 11040, 11044, 11045, 11041
13511, 11041, 11045, 1686, 1685
13512, 686, 687, 11046, 11042
13513, 11042, 11046, 11047, 11043
13514, 11043, 11047, 11048, 11044
13515, 11044, 11048, 11049, 11045
13516, 11045, 11049, 1687, 1686
13517, 687, 688, 11050, 11046
13518, 11046, 11050, 11051, 11047
13519, 11047, 11051, 11052, 11048
13520, 11048, 11052, 11053, 11049
13521, 11049, 11053, 1688, 1687
13522, 688, 689, 11054, 11050
13523, 11050, 11054, 11055, 11051
13524, 11051, 11055, 11056, 11052
13525, 11052, 11056, 11057, 11053
13526, 11053, 11057, 1689, 1688
13527, 689, 690, 11058, 11054
13528, 11054, 11058, 11059, 11055
13529, 11055, 11059, 11060, 11056
13530, 11056, 11060, 11061, 11057
13531, 11057, 11061, 1690, 1689
13532, 690, 691, 11062, 11058
13533, 11058, 11062, 11063, 11059
13534, 11059, 11063, 11064, 11060
13535, 11060, 11064, 11065, 11061
13536, 11061, 11065, 1691, 1690
13537, 691, 692, 11066, 11062
13538, 11062, 11066, 11067, 11063
13539, 11063, 11067, 11068, 11064
13540, 11064, 11068, 11069, 11065
13541, 11065, 11069, 1692, 1691
13542, 692, 693, 11070, 11066
13543, 11066, 11070, 11071, 11067
13544, 11067, 11071, 11072, 11068
13545, 11068, 11072, 11073, 11069
13546, 11069, 11073, 1693, 1692
13547, 693, 694, 11074, 11070
13548, 11070, 11074, 11075, 11071
13549, 11071, 11075, 11076, 11072
13550, 11072, 11076, 11077, 11073
13551, 11073, 11077, 1694, 1693
13552, 694, 695, 11078, 11074
13553, 11074, 11078, 11079, 11075
13554, 11075, 11079, 11080, 11076
13555, 11076, 11080, 11081, 11077
13556, 11077, 11081, 1695, 1694
13557, 695, 696, 11082, 11078
13558, 11078, 11082, 11083, 11079
13559, 11079, 11083, 11084, 11080
13560, 11080, 11084, 11085, 11081
13561, 11081, 11085, 1696, 1695
13562, 696, 697, 11086, 11082
13563, 11082, 11086, 11087, 11083
13564, 11083, 11087, 11088, 11084
13565, 11084, 11088, 11089, 11085
13566, 11085, 11089, 1697, 1696
13567, 697, 698, 11090, 11086
13568, 11086, 11090, 11091, 11087
13569, 11087, 11091, 11092, 11088
13570, 11088, 11092, 11093, 11089
13571, 11089, 11093, 1698, 1697
13572, 698, 699, 11094, 11090
13573, 11090, 11094, 11095, 11091
13574, 11091, 11095, 11096, 11092
13575, 11092, 11096, 11097, 11093
13576, 11093, 11097, 1699, 1698
13577, 699, 700, 11098, 11094
13578, 11094, 11098, 11099, 11095
13579, 11095, 11099, 11100, 11096
13580, 11096, 11100, 11101, 11097
13581, 11097, 11101, 1700, 1699
13582, 700, 30, 1674, 11098
13583, 11098, 1674, 1675, 11099
13584, 11099, 1675, 1676, 11100
13585, 11100, 1676, 1677, 11101
13586, 11101, 1677, 83, 1700
*ELEMENT, type=CPS4, ELSET=Surface115
13587, 28, 1655, 11102, 726
13588, 1655, 1656, 11103, 11102
13589, 1656, 1657, 11104, 11103
13590, 1657, 1658, 11105, 11104
13591, 1658, 82, 1705, 11105
13592, 726, 11102, 11106, 727
13593, 11102, 11103, 11107, 11106
13594, 11103, 11104, 11108, 11107
13595, 11104, 11105, 11109, 11108
13596, 11105, 1705, 1706, 11109
13597, 727, 11106, 11110, 728
13598, 11106, 11107, 11111, 11110
13599, 11107, 11108, 11112, 11111
13600, 11108, 11109, 11113, 11112
13601, 11109, 1706, 1707, 11113
13602, 728, 11110, 11114, 729
13603, 11110, 11111, 11115, 11114
13604, 11111, 11112, 11116, 11115
13605, 11112, 11113, 11117, 11116
13606, 11113, 1707, 1708, 11117
13607, 729, 11114, 11118, 730
13608, 11114, 11115, 11119, 11118
13609, 11115, 11116, 11120, 11119
13610, 11116, 11117, 11121, 11120
13611, 11117, 1708, 1709, 11121
13612, 730, 11118, 11122, 731
13613, 11118, 11119, 11123, 11122
13614, 11119, 11120, 11124, 11123
13615, 11120, 11121, 11125, 11124
13616, 11121, 1709, 1710, 11125
13617, 731, 11122, 11126, 732
13618, 11122, 11123, 11127, 11126
13619, 11123, 11124, 11128, 11127
13620, 11124, 11125, 11129, 11128
13621, 11125, 1710, 1711, 11129
13622, 732, 11126, 11130, 733
13623, 11126, 11127, 11131, 11130
13624, 11127, 11128, 11132, 11131
13625, 11128, 11129, 11133, 11132
13626, 11129, 1711, 1712, 11133
13627, 733, 11130, 11134, 734
13628, 11130, 11131, 11135, 11134
13629, 11131, 11132, 11136, 11135
13630, 11132, 11133, 11137, 11136
13631, 11133, 1712, 1713, 11137
13632, 734, 11134, 11138, 735
13633, 11134, 11135, 11139, 11138
13634, 11135, 11136, 11140, 11139
13635, 11136, 11137, 11141, 11140
13636, 11137, 1713, 1714, 11141
13637, 735, 11138, 11142, 736
13638, 11138, 11139, 11143, 11142
13639, 11139, 11140, 11144, 11143
13640, 11140, 11141, 11145, 11144
13641, 11141, 1714, 1715, 11145
13642, 736, 11142, 11146, 737
13643, 11142, 11143, 11147, 11146
13644, 11143, 11144, 11148, 11147
13645, 11144, 11145, 11149, 11148
13646, 11145, 1715, 1716, 11149
13647, 737, 11146, 11150, 738
13648, 11146, 11147, 11151, 11150
13649, 11147, 11148, 11152, 11151
13650, 11148, 11149, 11153, 11152
13651, 11149, 1716, 1717, 11153
13652, 738, 11150, 11154, 739
13653, 11150, 11151, 11155, 11154
13654, 11151, 11152, 11156, 11155
13655, 11152, 11153, 11157, 11156
13656, 11153, 1717, 1718, 11157
13657, 739, 11154, 11158, 740
13658, 11154, 11155, 11159, 11158
13659, 11155, 11156, 11160, 11159
13660, 11156, 11157, 11161, 11160
13661, 11157, 1718, 1719, 11161
13662, 740, 11158, 11162, 741
13663, 11158, 11159, 11163, 11162
13664, 11159, 11160, 11164, 11163
13665, 11160, 11161, 11165, 11164
13666, 11161, 1719, 1720, 11165
13667, 741, 11162, 11166, 742
13668, 11162, 11163, 11167, 11166
13669, 11163, 11164, 11168, 11167
13670, 11164, 11165, 11169, 11168
13671, 11165, 1720, 1721, 11169
13672, 742, 11166, 11170, 743
13673, 11166, 11167, 11171, 11170
13674, 11167, 11168, 11172, 11171
13675, 11168, 11169, 11173, 11172
13676, 11169, 1721, 1722, 11173
13677, 743, 11170, 11174, 744
13678, 11170, 11171, 11175, 11174
13679, 11171, 11172, 11176, 11175
13680, 11172, 11173, 11177, 11176
13681, 11173, 1722, 1723, 11177
13682, 744, 11174, 11178, 745
13683, 11174, 11175, 11179, 11178
13684, 11175, 11176, 11180, 11179
13685, 11176, 11177, 11181, 11180
13686, 11177, 1723, 1724, 11181
13687, 745, 11178, 11182, 746
13688, 11178, 11179, 11183, 11182
13689, 11179, 11180, 11184, 11183
13690, 11180, 11181, 11185, 11184
13691, 11181, 1724, 1725, 11185
13692, 746, 11182, 11186, 747
13693, 11182, 11183, 11187, 11186
13694, 11183, 11184, 11188, 11187
13695, 11184, 11185, 11189, 11188
13696, 11185, 1725, 1726, 11189
13697, 747, 11186, 11190, 748
13698, 11186, 11187, 11191, 11190
13699, 11187, 11188, 11192, 11191
13700, 11188, 11189, 11193, 11192
13701, 11189, 1726, 1727, 11193
13702, 748, 11190, 1701, 32
13703, 11190, 11191, 1702, 1701
13704, 11191, 11192, 1703, 1702
13705, 11192, 11193, 1704, 1703
13706, 11193, 1727, 84, 1704
*ELEMENT, type=CPS4, ELSET=Surface116
13707, 32, 1701, 11194, 762
13708, 1701, 1702, 11195, 11194
13709, 1702, 1703, 11196, 11195
13710, 1703, 1704, 11197, 11196
13711, 1704, 84, 1728, 11197
13712, 762, 11194, 11198, 763
13713, 11194, 11195, 11199, 11198
13714, 11195, 11196, 11200, 11199
13715, 11196, 11197, 11201, 11200
13716, 11197, 1728, 1729, 11201
13717, 763, 11198, 11202, 764
13718, 11198, 11199, 11203, 11202
13719, 11199, 11200, 11204, 11203
13720, 11200, 11201, 11205, 11204
13721, 11201, 1729, 1730, 11205
13722, 764, 11202, 11206, 765
13723, 11202, 11203, 11207, 11206
13724, 11203, 11204, 11208, 11207
13725, 11204, 11205, 11209, 11208
13726, 11205, 1730, 1731, 11209
13727, 765, 11206, 11210, 766
13728, 11206, 11207, 11211, 11210
13729, 11207, 11208, 11212, 11211
13730, 11208, 11209, 11213, 11212
13731, 11209, 1731, 1732, 11213
13732, 766, 11210, 11214, 767
13733, 11210, 11211, 11215, 11214
13734, 11211, 11212, 11216, 11215
13735, 11212, 11213, 11217, 11216
13736, 11213, 1732, 1733, 11217
13737, 767, 11214, 11218, 768
13738, 11214, 11215, 11219, 11218
13739, 11215, 11216, 11220, 11219
13740, 11216, 11217, 11221, 11220
13741, 11217, 1733, 1734, 11221
13742, 768, 11218, 11222, 769
13743, 11218, 11219, 11223, 11222
13744, 11219, 11220, 11224, 11223
13745, 11220, 11221, 11225, 11224
13746, 11221, 1734, 1735, 11225
13747, 769, 11222, 11226, 770
13748, 11222, 11223, 11227, 11226
13749, 11223, 11224, 11228, 11227
13750, 11224, 11225, 11229, 11228
13751, 11225, 1735, 1736, 11229
13752, 770, 11226, 11230, 771
13753, 11226, 11227, 11231, 11230
13754, 11227, 11228, 11232, 11231
13755, 11228, 11229, 11233, 11232
13756, 11229, 1736, 1737, 11233
13757, 771, 11230, 11234, 772
13758, 11230, 11231, 11235, 11234
13759, 11231, 11232, 11236, 11235
13760, 11232, 11233, 11237, 11236
13761, 11233, 1737, 1738, 11237
13762, 772, 11234, 1674, 30
13763, 11234, 11235, 1675, 1674
13764, 11235, 11236, 1676, 1675
13765, 11236, 11237, 1677, 1676
13766, 11237, 1738, 83, 1677
*ELEMENT, type=CPS4, ELSET=Surface117
13767, 82, 1663, 11238, 1705
13768, 1705, 11238, 11239, 1706
13769, 1706, 11239, 11240, 1707
13770, 1707, 11240, 11241, 1708
13771, 1708, 11241, 11242, 1709
13772, 1709, 11242, 11243, 1710
13773, 1710, 11243, 11244, 1711
13774, 1711, 11244, 11245, 1712
13775, 1712, 11245, 11246, 1713
13776, 1713, 11246, 11247, 1714
13777, 1714, 11247, 11248, 1715
13778, 1715, 11248, 11249, 1716
13779, 1716, 11249, 11250, 1717
13780, 1717, 11250, 11251, 1718
13781, 1718, 11251, 11252, 1719
13782, 1719, 11252, 11253, 1720
13783, 1720, 11253, 11254, 1721
13784, 1721, 11254, 11255, 1722
13785, 1722, 11255, 11256, 1723
13786, 1723, 11256, 11257, 1724
13787, 1724, 11257, 11258, 1725
13788, 1725, 11258, 11259, 1726
13789, 1726, 11259, 11260, 1727
13790, 1727, 11260, 1728, 84
13791, 1663, 1664, 11261, 11238
13792, 11238, 11261, 11262, 11239
13793, 11239, 11262, 11263, 11240
13794, 11240, 11263, 11264, 11241
13795, 11241, 11264, 11265, 11242
13796, 11242, 11265, 11266, 11243
13797, 11243, 11266, 11267, 11244
13798, 11244, 11267, 11268, 11245
13799, 11245, 11268, 11269, 11246
13800, 11246, 11269, 11270, 11247
13801, 11247, 11270, 11271, 11248
13802, 11248, 11271, 11272, 11249
13803, 11249, 11272, 11273, 11250
13804, 11250, 11273, 11274, 11251
13805, 11251, 11274, 11275, 11252
13806, 11252, 11275, 11276, 11253
13807, 11253, 11276, 11277, 11254
13808, 11254, 11277, 11278, 11255
13809, 11255, 11278, 11279, 11256
13810, 11256, 11279, 11280, 11257
13811, 11257, 11280, 11281, 11258
13812, 11258, 11281, 11282, 11259
13813, 11259, 11282, 11283, 11260
13814, 11260, 11283, 1729, 1728
13815, 1664, 1665, 11284, 11261
13816, 11261, 11284, 11285, 11262
13817, 11262, 11285, 11286, 11263
13818, 11263, 11286, 11287, 11264
13819, 11264, 11287, 11288, 11265
13820, 11265, 11288, 11289, 11266
13821, 11266, 11289, 11290, 11267
13822, 11267, 11290, 11291, 11268
13823, 11268, 11291, 11292, 11269
13824, 11269, 11292, 11293, 11270
13825, 11270, 11293, 11294, 11271
13826, 11271, 11294, 11295, 11272
13827, 11272, 11295, 11296, 11273
13828, 11273, 11296, 11297, 11274
13829, 11274, 11297, 11298, 11275
13830, 11275, 11298, 11299, 11276
13831, 11276, 11299, 11300, 11277
13832, 11277, 11300, 11301, 11278
13833, 11278, 11301, 11302, 11279
13834, 11279, 11302, 11303, 11280
13835, 11280, 11303, 11304, 11281
13836, 11281, 11304, 11305, 11282
13837, 11282, 11305, 11306, 11283
13838, 11283, 11306, 1730, 1729
13839, 1665, 1666, 11307, 11284
13840, 11284, 11307, 11308, 11285
13841, 11285, 11308, 11309, 11286
13842, 11286, 11309, 11310, 11287
13843, 11287, 11310, 11311, 11288
13844, 11288, 11311, 11312, 11289
13845, 11289, 11312, 11313, 11290
13846, 11290, 11313, 11314, 11291
13847, 11291, 11314, 11315, 11292
13848, 11292, 11315, 11316, 11293
13849, 11293, 11316, 11317, 11294
13850, 11294, 11317, 11318, 11295
13851, 11295, 11318, 11319, 11296
13852, 11296, 11319, 11320, 11297
13853, 11297, 11320, 11321, 11298
13854, 11298, 11321, 11322, 11299
13855, 11299, 11322, 11323, 11300
13856, 11300, 11323, 11324, 11301
13857, 11301, 11324, 11325, 11302
13858, 11302, 11325, 11326, 11303
13859, 11303, 11326, 11327, 11304
13860, 11304, 11327, 11328, 11305
13861, 11305, 11328, 11329, 11306
13862, 11306, 11329, 1731, 1730
13863, 1666, 1667, 11330, 11307
13864, 11307, 11330, 11331, 11308
13865, 11308, 11331, 11332, 11309
13866, 11309, 11332, 11333, 11310
13867, 11310, 11333, 11334, 11311
13868, 11311, 11334, 11335, 11312
13869, 11312, 11335, 11336, 11313
13870, 11313, 11336, 11337, 11314
13871, 11314, 11337, 11338, 11315
13872, 11315, 11338, 11339, 11316
13873, 11316, 11339, 11340, 11317
13874, 11317, 11340, 11341, 11318
13875, 11318, 11341, 11342, 11319
13876, 11319, 11342, 11343, 11320
13877, 11320, 11343, 11344, 11321
13878, 11321, 11344, 11345, 11322
13879, 11322, 11345, 11346, 11323
13880, 11323, 11346, 11347, 11324
13881, 11324, 11347, 11348, 11325
13882, 11325, 11348, 11349, 11326
13883, 11326, 11349, 11350, 11327
13884, 11327, 11350, 11351, 11328
13885, 11328, 11351, 11352, 11329
13886, 11329, 11352, 1732, 1731
13887, 1667, 1668, 11353, 11330
13888, 11330, 11353, 11354, 11331
13889, 11331, 11354, 11355, 11332
13890, 11332, 11355, 11356, 11333
13891, 11333, 11356, 11357, 11334
13892, 11334, 11357, 11358, 11335
13893, 11335, 11358, 11359, 11336
13894, 11336, 11359, 11360, 11337
13895, 11337, 11360, 11361, 11338
13896, 11338, 11361, 11362, 11339
13897, 11339, 11362, 11363, 11340
13898, 11340, 11363, 11364, 11341
13899, 11341, 11364, 11365, 11342
13900, 11342, 11365, 11366, 11343
13901, 11343, 11366, 11367, 11344
13902, 11344, 11367, 11368, 11345
13903, 11345, 11368, 11369, 11346
13904, 11346, 11369, 11370, 11347
13905, 11347, 11370, 11371, 11348
13906, 11348, 11371, 11372, 11349
13907, 11349, 11372, 11373, 11350
13908, 11350, 11373, 11374, 11351
13909, 11351, 11374, 11375, 11352
13910, 11352, 11375, 1733, 1732
13911, 1668, 1669, 11376, 11353
13912, 11353, 11376, 11377, 11354
13913, 11354, 11377, 11378, 11355
13914, 11355, 11378, 11379, 11356
13915, 11356, 11379, 11380, 11357
13916, 11357, 11380, 11381, 11358
13917, 11358, 11381, 11382, 11359
13918, 11359, 11382, 11383, 11360
13919, 11360, 11383, 11384, 11361
13920, 11361, 11384, 11385, 11362
13921, 11362, 11385, 11386, 11363
13922, 11363, 11386, 11387, 11364
13923, 11364, 11387, 11388, 11365
13924, 11365, 11388, 11389, 11366
13925, 11366, 11389, 11390, 11367
13926, 11367, 11390, 11391, 11368
13927, 11368, 11391, 11392, 11369
13928, 11369, 11392, 11393, 11370
13929, 11370, 11393, 11394, 11371
13930, 11371, 11394, 11395, 11372
13931, 11372, 11395, 11396, 11373
13932, 11373, 11396, 11397, 11374
13933, 11374, 11397, 11398, 11375
13934, 11375, 11398, 1734, 1733
13935, 1669, 1670, 11399, 11376
13936, 11376, 11399, 11400, 11377
13937, 11377, 11400, 11401, 11378
13938, 11378, 11401, 11402, 11379
13939, 11379, 11402, 11403, 11380
13940, 11380, 11403, 11404, 11381
13941, 11381, 11404, 11405, 11382
13942, 11382, 11405, 11406, 11383
13943, 11383, 11406, 11407, 11384
13944, 11384, 11407, 11408, 11385
13945, 11385, 11408, 11409, 11386
13946, 11386, 11409, 11410, 11387
13947, 11387, 11410, 11411, 11388
13948, 11388, 11411, 11412, 11389
13949, 11389, 11412, 11413, 11390
13950, 11390, 11413, 11414, 11391
13951, 11391, 11414, 11415, 11392
13952, 11392, 11415, 11416, 11393
13953, 11393, 11416, 11417, 11394
13954, 11394, 11417, 11418, 11395
13955, 11395, 11418, 11419, 11396
13956, 11396, 11419, 11420, 11397
13957, 11397, 11420, 11421, 11398
13958, 11398, 11421, 1735, 1734
13959, 1670, 1671, 11422, 11399
13960, 11399, 11422, 11423, 11400
13961, 11400, 11423, 11424, 11401
13962, 11401, 11424, 11425, 11402
13963, 11402, 11425, 11426, 11403
13964, 11403, 11426, 11427, 11404
13965, 11404, 11427, 11428, 11405
13966, 11405, 11428, 11429, 11406
13967, 11406, 11429, 11430, 11407
13968, 11407, 11430, 11431, 11408
13969, 11408, 11431, 11432, 11409
13970, 11409, 11432, 11433, 11410
13971, 11410, 11433, 11434, 11411
13972, 11411, 11434, 11435, 11412
13973, 11412, 11435, 11436, 11413
13974, 11413, 11436, 11437, 11414
13975, 11414, 11437, 11438, 11415
13976, 11415, 11438, 11439, 11416
13977, 11416, 11439, 11440, 11417
13978, 11417, 11440, 11441, 11418
13979, 11418, 11441, 11442, 11419
13980, 11419, 11442, 11443, 11420
13981, 11420, 11443, 11444, 11421
13982, 11421, 11444, 1736, 1735
13983, 1671, 1672, 11445, 11422
13984, 11422, 11445, 11446, 11423
13985, 11423, 11446, 11447, 11424
13986, 11424, 11447, 11448, 11425
13987, 11425, 11448, 11449, 11426
13988, 11426, 11449, 11450, 11427
13989, 11427, 11450, 11451, 11428
13990, 11428, 11451, 11452, 11429
13991, 11429, 11452, 11453, 11430
13992, 11430, 11453, 11454, 11431
13993, 11431, 11454, 11455, 11432
13994, 11432, 11455, 11456, 11433
13995, 11433, 11456, 11457, 11434
13996, 11434, 11457, 11458, 11435
13997, 11435, 11458, 11459, 11436
13998, 11436, 11459, 11460, 11437
13999, 11437, 11460, 11461, 11438
14000, 11438, 11461, 11462, 11439
14001, 11439, 11462, 11463, 11440
14002, 11440, 11463, 11464, 11441
14003, 11441, 11464, 11465, 11442
14004, 11442, 11465, 11466, 11443
14005, 11443, 11466, 11467, 11444
14006, 11444, 11467, 1737, 1736
14007, 1672, 1673, 11468, 11445
14008, 11445, 11468, 11469, 11446
14009, 11446, 11469, 11470, 11447
14010, 11447, 11470, 11471, 11448
14011, 11448, 11471, 11472, 11449
14012, 11449, 11472, 11473, 11450
14013, 11450, 11473, 11474, 11451
14014, 11451, 11474, 11475, 11452
14015, 11452, 11475, 11476, 11453
14016, 11453, 11476, 11477, 11454
14017, 11454, 11477, 11478, 11455
14018, 11455, 11478, 11479, 11456
14019, 11456, 11479, 11480, 11457
14020, 11457, 11480, 11481, 11458
14021, 11458, 11481, 11482, 11459
14022, 11459, 11482, 11483, 11460
14023, 11460, 11483, 11484, 11461
14024, 11461, 11484, 11485, 11462
14025, 11462, 11485, 11486, 11463
14026, 11463, 11486, 11487, 11464
14027, 11464, 11487, 11488, 11465
14028, 11465, 11488, 11489, 11466
14029, 11466, 11489, 11490, 11467
14030, 11467, 11490, 1738, 1737
14031, 1673, 81, 1678, 11468
14032, 11468, 1678, 1679, 11469
14033, 11469, 1679, 1680, 11470
14034, 11470, 1680, 1681, 11471
14035, 11471, 1681, 1682, 11472
14036, 11472, 1682, 1683, 11473
14037, 11473, 1683, 1684, 11474
14038, 11474, 1684, 1685, 11475
14039, 11475, 1685, 1686, 11476
14040, 11476, 1686, 1687, 11477
14041, 11477, 1687, 1688, 11478
14042, 11478, 1688, 1689, 11479
14043, 11479, 1689, 1690, 11480
14044, 11480, 1690, 1691, 11481
14045, 11481, 1691, 1692, 11482
14046, 11482, 1692, 1693, 11483
14047, 11483, 1693, 1694, 11484
14048, 11484, 1694, 1695, 11485
14049, 11485, 1695, 1696, 11486
14050, 11486, 1696, 1697, 11487
14051, 11487, 1697, 1698, 11488
14052, 11488, 1698, 1699, 11489
14053, 11489, 1699, 1700, 11490
14054, 11490, 1700, 83, 1738
*ELEMENT, type=CPS4, ELSET=Surface118
14055, 2, 149, 11491, 1743
14056, 1743, 11491, 11492, 1744
14057, 1744, 11492, 11493, 1745
14058, 1745, 11493, 11494, 1746
14059, 1746, 11494, 1747, 86
14060, 149, 150, 11495, 11491
14061, 11491, 11495, 11496, 11492
14062, 11492, 11496, 11497, 11493
14063, 11493, 11497, 11498, 11494
14064, 11494, 11498, 1748, 1747
14065, 150, 151, 11499, 11495
14066, 11495, 11499, 11500, 11496
14067, 11496, 11500, 11501, 11497
14068, 11497, 11501, 11502, 11498
14069, 11498, 11502, 1749, 1748
14070, 151, 152, 11503, 11499
14071, 11499, 11503, 11504, 11500
14072, 11500, 11504, 11505, 11501
14073, 11501, 11505, 11506, 11502
14074, 11502, 11506, 1750, 1749
14075, 152, 153, 11507, 11503
14076, 11503, 11507, 11508, 11504
14077, 11504, 11508, 11509, 11505
14078, 11505, 11509, 11510, 11506
14079, 11506, 11510, 1751, 1750
14080, 153, 154, 11511, 11507
14081, 11507, 11511, 11512, 11508
14082, 11508, 11512, 11513, 11509
14083, 11509, 11513, 11514, 11510
14084, 11510, 11514, 1752, 1751
14085, 154, 155, 11515, 11511
14086, 11511, 11515, 11516, 11512
14087, 11512, 11516, 11517, 11513
14088, 11513, 11517, 11518, 11514
14089, 11514, 11518, 1753, 1752
14090, 155, 156, 11519, 11515
14091, 11515, 11519, 11520, 11516
14092, 11516, 11520, 11521, 11517
14093, 11517, 11521, 11522, 11518
14094, 11518, 11522, 1754, 1753
14095, 156, 157, 11523, 11519
14096, 11519, 11523, 11524, 11520
14097, 11520, 11524, 11525, 11521
14098, 11521, 11525, 11526, 11522
14099, 11522, 11526, 1755, 1754
14100, 157, 158, 11527, 11523
14101, 11523, 11527, 11528, 11524
14102, 11524, 11528, 11529, 11525
14103, 11525, 11529, 11530, 11526
14104, 11526, 11530, 1756, 1755
14105, 158, 159, 11531, 11527
14106, 11527, 11531, 11532, 11528
14107, 11528, 11532, 11533, 11529
14108, 11529, 11533, 11534, 11530
14109, 11530, 11534, 1757, 1756
14110, 159, 160, 11535, 11531
14111, 11531, 11535, 11536, 11532
14112, 11532, 11536, 11537, 11533
14113, 11533, 11537, 11538, 11534
14114, 11534, 11538, 1758, 1757
14115, 160, 161, 11539, 11535
14116, 11535, 11539, 11540, 11536
14117, 11536, 11540, 11541, 11537
14118, 11537, 11541, 11542, 11538
14119, 11538, 11542, 1759, 1758
14120, 161, 162, 11543, 11539
14121, 11539, 11543, 11544, 11540
14122, 11540, 11544, 11545, 11541
14123, 11541, 11545, 11546, 11542
14124, 11542, 11546, 1760, 1759
14125, 162, 163, 11547, 11543
14126, 11543, 11547, 11548, 11544
14127, 11544, 11548, 11549, 11545
14128, 11545, 11549, 11550, 11546
14129, 11546, 11550, 1761, 1760
14130, 163, 164, 11551, 11547
14131, 11547, 11551, 11552, 11548
14132, 11548, 11552, 11553, 11549
14133, 11549, 11553, 11554, 11550
14134, 11550, 11554, 1762, 1761
14135, 164, 165, 11555, 11551
14136, 11551, 11555, 11556, 11552
14137, 11552, 11556, 11557, 11553
14138, 11553, 11557, 11558, 11554
14139, 11554, 11558, 1763, 1762
14140, 165, 166, 11559, 11555
14141, 11555, 11559, 11560, 11556
14142, 11556, 11560, 11561, 11557
14143, 11557, 11561, 11562, 11558
14144, 11558, 11562, 1764, 1763
14145, 166, 167, 11563, 11559
14146, 11559, 11563, 11564, 11560
14147, 11560, 11564, 11565, 11561
14148, 11561, 11565, 11566, 11562
14149, 11562, 11566, 1765, 1764
14150, 167, 168, 11567, 11563
14151, 11563, 11567, 11568, 11564
14152, 11564, 11568, 11569, 11565
14153, 11565, 11569, 11570, 11566
14154, 11566, 11570, 1766, 1765
14155, 168, 169, 11571, 11567
14156, 11567, 11571, 11572, 11568
14157, 11568, 11572, 11573, 11569
14158, 11569, 11573, 11574, 11570
14159, 11570, 11574, 1767, 1766
14160, 169, 170, 11575, 11571
14161, 11571, 11575, 11576, 11572
14162, 11572, 11576, 11577, 11573
14163, 11573, 11577, 11578, 11574
14164, 11574, 11578, 1768, 1767
14165, 170, 171, 11579, 11575
14166, 11575, 11579, 11580, 11576
14167, 11576, 11580, 11581, 11577
14168, 11577, 11581, 11582, 11578
14169, 11578, 11582, 1769, 1768
14170, 171, 6, 1739, 11579
14171, 11579, 1739, 1740, 11580
14172, 11580, 1740, 1741, 11581
14173, 11581, 1741, 1742, 11582
14174, 11582, 1742, 85, 1769
*ELEMENT, type=CPS4, ELSET=Surface119
14175, 6, 123, 11583, 1739
14176, 1739, 11583, 11584, 1740
14177, 1740, 11584, 11585, 1741
14178, 1741, 11585, 11586, 1742
14179, 1742, 11586, 1774, 85
14180, 123, 124, 11587, 11583
14181, 11583, 11587, 11588, 11584
14182, 11584, 11588, 11589, 11585
14183, 11585, 11589, 11590, 11586
14184, 11586, 11590, 1775, 1774
14185, 124, 125, 11591, 11587
14186, 11587, 11591, 11592, 11588
14187, 11588, 11592, 11593, 11589
14188, 11589, 11593, 11594, 11590
14189, 11590, 11594, 1776, 1775
14190, 125, 126, 11595, 11591
14191, 11591, 11595, 11596, 11592
14192, 11592, 11596, 11597, 11593
14193, 11593, 11597, 11598, 11594
14194, 11594, 11598, 1777, 1776
14195, 126, 127, 11599, 11595
14196, 11595, 11599, 11600, 11596
14197, 11596, 11600, 11601, 11597
14198, 11597, 11601, 11602, 11598
14199, 11598, 11602, 1778, 1777
14200, 127, 128, 11603, 11599
14201, 11599, 11603, 11604, 11600
14202, 11600, 11604, 11605, 11601
14203, 11601, 11605, 11606, 11602
14204, 11602, 11606, 1779, 1778
14205, 128, 129, 11607, 11603
14206, 11603, 11607, 11608, 11604
14207, 11604, 11608, 11609, 11605
14208, 11605, 11609, 11610, 11606
14209, 11606, 11610, 1780, 1779
14210, 129, 130, 11611, 11607
14211, 11607, 11611, 11612, 11608
14212, 11608, 11612, 11613, 11609
14213, 11609, 11613, 11614, 11610
14214, 11610, 11614, 1781, 1780
14215, 130, 131, 11615, 11611
14216, 11611, 11615, 11616, 11612
14217, 11612, 11616, 11617, 11613
14218, 11613, 11617, 11618, 11614
14219, 11614, 11618, 1782, 1781
14220, 131, 132, 11619, 11615
14221, 11615, 11619, 11620, 11616
14222, 11616, 11620, 11621, 11617
14223, 11617, 11621, 11622, 11618
14224, 11618, 11622, 1783, 1782
14225, 132, 133, 11623, 11619
14226, 11619, 11623, 11624, 11620
14227, 11620, 11624, 11625, 11621
14228, 11621, 11625, 11626, 11622
14229, 11622, 11626, 1784, 1783
14230, 133, 5, 1770, 11623
14231, 11623, 1770, 1771, 11624
14232, 11624, 1771, 1772, 11625
14233, 11625, 1772, 1773, 11626
14234, 11626, 1773, 87, 1784
*ELEMENT, type=CPS4, ELSET=Surface120
14235, 1, 1785, 11627, 172
14236, 1785, 1786, 11628, 11627
14237, 1786, 1787, 11629, 11628
14238, 1787, 1788, 11630, 11629
14239, 1788, 88, 1789, 11630
14240, 172, 11627, 11631, 173
14241, 11627, 11628, 11632, 11631
14242, 11628, 11629, 11633, 11632
14243, 11629, 11630, 11634, 11633
14244, 11630, 1789, 1790, 11634
14245, 173, 11631, 11635, 174
14246, 11631, 11632, 11636, 11635
14247, 11632, 11633, 11637, 11636
14248, 11633, 11634, 11638, 11637
14249, 11634, 1790, 1791, 11638
14250, 174, 11635, 11639, 175
14251, 11635, 11636, 11640, 11639
14252, 11636, 11637, 11641, 11640
14253, 11637, 11638, 11642, 11641
14254, 11638, 1791, 1792, 11642
14255, 175, 11639, 11643, 176
14256, 11639, 11640, 11644, 11643
14257, 11640, 11641, 11645, 11644
14258, 11641, 11642, 11646, 11645
14259, 11642, 1792, 1793, 11646
14260, 176, 11643, 11647, 177
14261, 11643, 11644, 11648, 11647
14262, 11644, 11645, 11649, 11648
14263, 11645, 11646, 11650, 11649
14264, 11646, 1793, 1794, 11650
14265, 177, 11647, 11651, 178
14266, 11647, 11648, 11652, 11651
14267, 11648, 11649, 11653, 11652
14268, 11649, 11650, 11654, 11653
14269, 11650, 1794, 1795, 11654
14270, 178, 11651, 11655, 179
14271, 11651, 11652, 11656, 11655
14272, 11652, 11653, 11657, 11656
14273, 11653, 11654, 11658, 11657
14274, 11654, 1795, 1796, 11658
14275, 179, 11655, 11659, 180
14276, 11655, 11656, 11660, 11659
14277, 11656, 11657, 11661, 11660
14278, 11657, 11658, 11662, 11661
14279, 11658, 1796, 1797, 11662
14280, 180, 11659, 11663, 181
14281, 11659, 11660, 11664, 11663
14282, 11660, 11661, 11665, 11664
14283, 11661, 11662, 11666, 11665
14284, 11662, 1797, 1798, 11666
14285, 181, 11663, 11667, 182
14286, 11663, 11664, 11668, 11667
14287, 11664, 11665, 11669, 11668
14288, 11665, 11666, 11670, 11669
14289, 11666, 1798, 1799, 11670
14290, 182, 11667, 11671, 183
14291, 11667, 11668, 11672, 11671
14292, 11668, 11669, 11673, 11672
14293, 11669, 11670, 11674, 11673
14294, 11670, 1799, 1800, 11674
14295, 183, 11671, 11675, 184
14296, 11671, 11672, 11676, 11675
14297, 11672, 11673, 11677, 11676
14298, 11673, 11674, 11678, 11677
14299, 11674, 1800, 1801, 11678
14300, 184, 11675, 11679, 185
14301, 11675, 11676, 11680, 11679
14302, 11676, 11677, 11681, 11680
14303, 11677, 11678, 11682, 11681
14304, 11678, 1801, 1802, 11682
14305, 185, 11679, 11683, 186
14306, 11679, 11680, 11684, 11683
14307, 11680, 11681, 11685, 11684
14308, 11681, 11682, 11686, 11685
14309, 11682, 1802, 1803, 11686
14310, 186, 11683, 11687, 187
14311, 11683, 11684, 11688, 11687
14312, 11684, 11685, 11689, 11688
14313, 11685, 11686, 11690, 11689
14314, 11686, 1803, 1804, 11690
14315, 187, 11687, 11691, 188
14316, 11687, 11688, 11692, 11691
14317, 11688, 11689, 11693, 11692
14318, 11689, 11690, 11694, 11693
14319, 11690, 1804, 1805, 11694
14320, 188, 11691, 11695, 189
14321, 11691, 11692, 11696, 11695
14322, 11692, 11693, 11697, 11696
14323, 11693, 11694, 11698, 11697
14324, 11694, 1805, 1806, 11698
14325, 189, 11695, 11699, 190
14326, 11695, 11696, 11700, 11699
14327, 11696, 11697, 11701, 11700
14328, 11697, 11698, 11702, 11701
14329, 11698, 1806, 1807, 11702
14330, 190, 11699, 11703, 191
14331, 11699, 11700, 11704, 11703
14332, 11700, 11701, 11705, 11704
14333, 11701, 11702, 11706, 11705
14334, 11702, 1807, 1808, 11706
14335, 191, 11703, 11707, 192
14336, 11703, 11704, 11708, 11707
14337, 11704, 11705, 11709, 11708
14338, 11705, 11706, 11710, 11709
14339, 11706, 1808, 1809, 11710
14340, 192, 11707, 11711, 193
14341, 11707, 11708, 11712, 11711
14342, 11708, 11709, 11713, 11712
14343, 11709, 11710, 11714, 11713
14344, 11710, 1809, 1810, 11714
14345, 193, 11711, 11715, 194
14346, 11711, 11712, 11716, 11715
14347, 11712, 11713, 11717, 11716
14348, 11713, 11714, 11718, 11717
14349, 11714, 1810, 1811, 11718
14350, 194, 11715, 1770, 5
14351, 11715, 11716, 1771, 1770
14352, 11716, 11717, 1772, 1771
14353, 11717, 11718, 1773, 1772
14354, 11718, 1811, 87, 1773
*ELEMENT, type=CPS4, ELSET=Surface121
14355, 2, 1743, 11719, 97
14356, 1743, 1744, 11720, 11719
14357, 1744, 1745, 11721, 11720
14358, 1745, 1746, 11722, 11721
14359, 1746, 86, 1812, 11722
14360, 97, 11719, 11723, 98
14361, 11719, 11720, 11724, 11723
14362, 11720, 11721, 11725, 11724
14363, 11721, 11722, 11726, 11725
14364, 11722, 1812, 1813, 11726
14365, 98, 11723, 11727, 99
14366, 11723, 11724, 11728, 11727
14367, 11724, 11725, 11729, 11728
14368, 11725, 11726, 11730, 11729
14369, 11726, 1813, 1814, 11730
14370, 99, 11727, 11731, 100
14371, 11727, 11728, 11732, 11731
14372, 11728, 11729, 11733, 11732
14373, 11729, 11730, 11734, 11733
14374, 11730, 1814, 1815, 11734
14375, 100, 11731, 11735, 101
14376, 11731, 11732, 11736, 11735
14377, 11732, 11733, 11737, 11736
14378, 11733, 11734, 11738, 11737
14379, 11734, 1815, 1816, 11738
14380, 101, 11735, 11739, 102
14381, 11735, 11736, 11740, 11739
14382, 11736, 11737, 11741, 11740
14383, 11737, 11738, 11742, 11741
14384, 11738, 1816, 1817, 11742
14385, 102, 11739, 11743, 103
14386, 11739, 11740, 11744, 11743
14387, 11740, 11741, 11745, 11744
14388, 11741, 11742, 11746, 11745
14389, 11742, 1817, 1818, 11746
14390, 103, 11743, 11747, 104
14391, 11743, 11744, 11748, 11747
14392, 11744, 11745, 11749, 11748
14393, 11745, 11746, 11750, 11749
14394, 11746, 1818, 1819, 11750
14395, 104, 11747, 11751, 105
14396, 11747, 11748, 11752, 11751
14397, 11748, 11749, 11753, 11752
14398, 11749, 11750, 11754, 11753
14399, 11750, 1819, 1820, 11754
14400, 105, 11751, 11755, 106
14401, 11751, 11752, 11756, 11755
14402, 11752, 11753, 11757, 11756
14403, 11753, 11754, 11758, 11757
14404, 11754, 1820, 1821, 11758
14405, 106, 11755, 11759, 107
14406, 11755, 11756, 11760, 11759
14407, 11756, 11757, 11761, 11760
14408, 11757, 11758, 11762, 11761
14409, 11758, 1821, 1822, 11762
14410, 107, 11759, 1785, 1
14411, 11759, 11760, 1786, 1785
14412, 11760, 11761, 1787, 1786
14413, 11761, 11762, 1788, 1787
14414, 11762, 1822, 88, 1788
*ELEMENT, type=CPS4, ELSET=Surface122
14415, 86, 1747, 11763, 1812
14416, 1812, 11763, 11764, 1813
14417, 1813, 11764, 11765, 1814
14418, 1814, 11765, 11766, 1815
14419, 1815, 11766, 11767, 1816
14420, 1816, 11767, 11768, 1817
14421, 1817, 11768, 11769, 1818
14422, 1818, 11769, 11770, 1819
14423, 1819, 11770, 11771, 1820
14424, 1820, 11771, 11772, 1821
14425, 1821, 11772, 11773, 1822
14426, 1822, 11773, 1789, 88
14427, 1747, 1748, 11774, 11763
14428, 11763, 11774, 11775, 11764
14429, 11764, 11775, 11776, 11765
14430, 11765, 11776, 11777, 11766
14431, 11766, 11777, 11778, 11767
14432, 11767, 11778, 11779, 11768
14433, 11768, 11779, 11780, 11769
14434, 11769, 11780, 11781, 11770
14435, 11770, 11781, 11782, 11771
14436, 11771, 11782, 11783, 11772
14437, 11772, 11783, 11784, 11773
14438, 11773, 11784, 1790, 1789
14439, 1748, 1749, 11785, 11774
14440, 11774, 11785, 11786, 11775
14441, 11775, 11786, 11787, 11776
14442, 11776, 11787, 11788, 11777
14443, 11777, 11788, 11789, 11778
14444, 11778, 11789, 11790, 11779
14445, 11779, 11790, 11791, 11780
14446, 11780, 11791, 11792, 11781
14447, 11781, 11792, 11793, 11782
14448, 11782, 11793, 11794, 11783
14449, 11783, 11794, 11795, 11784
14450, 11784, 11795, 1791, 1790
14451, 1749, 1750, 11796, 11785
14452, 11785, 11796, 11797, 11786
14453, 11786, 11797, 11798, 11787
14454, 11787, 11798, 11799, 11788
14455, 11788, 11799, 11800, 11789
14456, 11789, 11800, 11801, 11790
14457, 11790, 11801, 11802, 11791
14458, 11791, 11802, 11803, 11792
14459, 11792, 11803, 11804, 11793
14460, 11793, 11804, 11805, 11794
14461, 11794, 11805, 11806, 11795
14462, 11795, 11806, 1792, 1791
14463, 1750, 1751, 11807, 11796
14464, 11796, 11807, 11808, 11797
14465, 11797, 11808, 11809, 11798
14466, 11798, 11809, 11810, 11799
14467, 11799, 11810, 11811, 11800
14468, 11800, 11811, 11812, 11801
14469, 11801, 11812, 11813, 11802
14470, 11802, 11813, 11814, 11803
14471, 11803, 11814, 11815, 11804
14472, 11804, 11815, 11816, 11805
14473, 11805, 11816, 11817, 11806
14474, 11806, 11817, 1793, 1792
14475, 1751, 1752, 11818, 11807
14476, 11807, 11818, 11819, 11808
14477, 11808, 11819, 11820, 11809
14478, 11809, 11820, 11821, 11810
14479, 11810, 11821, 11822, 11811
14480, 11811, 11822, 11823, 11812
14481, 11812, 11823, 11824, 11813
14482, 11813, 11824, 11825, 11814
14483, 11814, 11825, 11826, 11815
14484, 11815, 11826, 11827, 11816
14485, 11816, 11827, 11828, 11817
14486, 11817, 11828, 1794, 1793
14487, 1752, 1753, 11829, 11818
14488, 11818, 11829, 11830, 11819
14489, 11819, 11830, 11831, 11820
14490, 11820, 11831, 11832, 11821
14491, 11821, 11832, 11833, 11822
14492, 11822, 11833, 11834, 11823
14493, 11823, 11834, 11835, 11824
14494, 11824, 11835, 11836, 11825
14495, 11825, 11836, 11837, 11826
14496, 11826, 11837, 11838, 11827
14497, 11827, 11838, 11839, 11828
14498, 11828, 11839, 1795, 1794
14499, 1753, 1754, 11840, 11829
14500, 11829, 11840, 11841, 11830
14501, 11830, 11841, 11842, 11831
14502, 11831, 11842, 11843, 11832
14503, 11832, 11843, 11844, 11833
14504, 11833, 11844, 11845, 11834
14505, 11834, 11845, 11846, 11835
14506, 11835, 11846, 11847, 11836
14507, 11836, 11847, 11848, 11837
14508, 11837, 11848, 11849, 11838
14509, 11838, 11849, 11850, 11839
14510, 11839, 11850, 1796, 1795
14511, 1754, 1755, 11851, 11840
14512, 11840, 11851, 11852, 11841
14513, 11841, 11852, 11853, 11842
14514, 11842, 11853, 11854, 11843
14515, 11843, 11854, 11855, 11844
14516, 11844, 11855, 11856, 11845
14517, 11845, 11856, 11857, 11846
14518, 11846, 11857, 11858, 11847
14519, 11847, 11858, 11859, 11848
14520, 11848, 11859, 11860, 11849
14521, 11849, 11860, 11861, 11850
14522, 11850, 11861, 1797, 1796
14523, 1755, 1756, 11862, 11851
14524, 11851, 11862, 11863, 11852
14525, 11852, 11863, 11864, 11853
14526, 11853, 11864, 11865, 11854
14527, 11854, 11865, 11866, 11855
14528, 11855, 11866, 11867, 11856
14529, 11856, 11867, 11868, 11857
14530, 11857, 11868, 11869, 11858
14531, 11858, 11869, 11870, 11859
14532, 11859, 11870, 11871, 11860
14533, 11860, 11871, 11872, 11861
14534, 11861, 11872, 1798, 1797
14535, 1756, 1757, 11873, 11862
14536, 11862, 11873, 11874, 11863
14537, 11863, 11874, 11875, 11864
14538, 11864, 11875, 11876, 11865
14539, 11865, 11876, 11877, 11866
14540, 11866, 11877, 11878, 11867
14541, 11867, 11878, 11879, 11868
14542, 11868, 11879, 11880, 11869
14543, 11869, 11880, 11881, 11870
14544, 11870, 11881, 11882, 11871
14545, 11871, 11882, 11883, 11872
14546, 11872, 11883, 1799, 1798
14547, 1757, 1758, 11884, 11873
14548, 11873, 11884, 11885, 11874
14549, 11874, 11885, 11886, 11875
14550, 11875, 11886, 11887, 11876
14551, 11876, 11887, 11888, 11877
14552, 11877, 11888, 11889, 11878
14553, 11878, 11889, 11890, 11879
14554, 11879, 11890, 11891, 11880
14555, 11880, 11891, 11892, 11881
14556, 11881, 11892, 11893, 11882
14557, 11882, 11893, 11894, 11883
14558, 11883, 11894, 1800, 1799
14559, 1758, 1759, 11895, 11884
14560, 11884, 11895, 11896, 11885
14561, 11885, 11896, 11897, 11886
14562, 11886, 11897, 11898, 11887
14563, 11887, 11898, 11899, 11888
14564, 11888, 11899, 11900, 11889
14565, 11889, 11900, 11901, 11890
14566, 11890, 11901, 11902, 11891
14567, 11891, 11902, 11903, 11892
14568, 11892, 11903, 11904, 11893
14569, 11893, 11904, 11905, 11894
14570, 11894, 11905, 1801, 1800
14571, 1759, 1760, 11906, 11895
14572, 11895, 11906, 11907, 11896
14573, 11896, 11907, 11908, 11897
14574, 11897, 11908, 11909, 11898
14575, 11898, 11909, 11910, 11899
14576, 11899, 11910, 11911, 11900
14577, 11900, 11911, 11912, 11901
14578, 11901, 11912, 11913, 11902
14579, 11902, 11913, 11914, 11903
14580, 11903, 11914, 11915, 11904
14581, 11904, 11915, 11916, 11905
14582, 11905, 11916, 1802, 1801
14583, 1760, 1761, 11917, 11906
14584, 11906, 11917, 11918, 11907
14585, 11907, 11918, 11919, 11908
14586, 11908, 11919, 11920, 11909
14587, 11909, 11920, 11921, 11910
14588, 11910, 11921, 11922, 11911
14589, 11911, 11922, 11923, 11912
14590, 11912, 11923, 11924, 11913
14591, 11913, 11924, 11925, 11914
14592, 11914, 11925, 11926, 11915
14593, 11915, 11926, 11927, 11916
14594, 11916, 11927, 1803, 1802
14595, 1761, 1762, 11928, 11917
14596, 11917, 11928, 11929, 11918
14597, 11918, 11929, 11930, 11919
14598, 11919, 11930, 11931, 11920
14599, 11920, 11931, 11932, 11921
14600, 11921, 11932, 11933, 11922
14601, 11922, 11933, 11934, 11923
14602, 11923, 11934, 11935, 11924
14603, 11924, 11935, 11936, 11925
14604, 11925, 11936, 11937, 11926
14605, 11926, 11937, 11938, 11927
14606, 11927, 11938, 1804, 1803
14607, 1762, 1763, 11939, 11928
14608, 11928, 11939, 11940, 11929
14609, 11929, 11940, 11941, 11930
14610, 11930, 11941, 11942, 11931
14611, 11931, 11942, 11943, 11932
14612, 11932, 11943, 11944, 11933
14613, 11933, 11944, 11945, 11934
14614, 11934, 11945, 11946, 11935
14615, 11935, 11946, 11947, 11936
14616, 11936, 11947, 11948, 11937
14617, 11937, 11948, 11949, 11938
14618, 11938, 11949, 1805, 1804
14619, 1763, 1764, 11950, 11939
14620, 11939, 11950, 11951, 11940
14621, 11940, 11951, 11952, 11941
14622, 11941, 11952, 11953, 11942
14623, 11942, 11953, 11954, 11943
14624, 11943, 11954, 11955, 11944
14625, 11944, 11955, 11956, 11945
14626, 11945, 11956, 11957, 11946
14627, 11946, 11957, 11958, 11947
14628, 11947, 11958, 11959, 11948
14629, 11948, 11959, 11960, 11949
14630, 11949, 11960, 1806, 1805
14631, 1764, 1765, 11961, 11950
14632, 11950, 11961, 11962, 11951
14633, 11951, 11962, 11963, 11952
14634, 11952, 11963, 11964, 11953
14635, 11953, 11964, 11965, 11954
14636, 11954, 11965, 11966, 11955
14637, 11955, 11966, 11967, 11956
14638, 11956, 11967, 11968, 11957
14639, 11957, 11968, 11969, 11958
14640, 11958, 11969, 11970, 11959
14641, 11959, 11970, 11971, 11960
14642, 11960, 11971, 1807, 1806
14643, 1765, 1766, 11972, 11961
14644, 11961, 11972, 11973, 11962
14645, 11962, 11973, 11974, 11963
14646, 11963, 11974, 11975, 11964
14647, 11964, 11975, 11976, 11965
14648, 11965, 11976, 11977, 11966
14649, 11966, 11977, 11978, 11967
14650, 11967, 11978, 11979, 11968
14651, 11968, 11979, 11980, 11969
14652, 11969, 11980, 11981, 11970
14653, 11970, 11981, 11982, 11971
14654, 11971, 11982, 1808, 1807
14655, 1766, 1767, 11983, 11972
14656, 11972, 11983, 11984, 11973
14657, 11973, 11984, 11985, 11974
14658, 11974, 11985, 11986, 11975
14659, 11975, 11986, 11987, 11976
14660, 11976, 11987, 11988, 11977
14661, 11977, 11988, 11989, 11978
14662, 11978, 11989, 11990, 11979
14663, 11979, 11990, 11991, 11980
14664, 11980, 11991, 11992, 11981
14665, 11981, 11992, 11993, 11982
14666, 11982, 11993, 1809, 1808
14667, 1767, 1768, 11994, 11983
14668, 11983, 11994, 11995, 11984
14669, 11984, 11995, 11996, 11985
14670, 11985, 11996, 11997, 11986
14671, 11986, 11997, 11998, 11987
14672, 11987, 11998, 11999, 11988
14673, 11988, 11999, 12000, 11989
14674, 11989, 12000, 12001, 11990
14675, 11990, 12001, 12002, 11991
14676, 11991, 12002, 12003, 11992
14677, 11992, 12003, 12004, 11993
14678, 11993, 12004, 1810, 1809
14679, 1768, 1769, 12005, 11994
14680, 11994, 12005, 12006, 11995
14681, 11995, 12006, 12007, 11996
14682, 11996, 12007, 12008, 11997
14683, 11997, 12008, 12009, 11998
14684, 11998, 12009, 12010, 11999
14685, 11999, 12010, 12011, 12000
14686, 12000, 12011, 12012, 12001
14687, 12001, 12012, 12013, 12002
14688, 12002, 12013, 12014, 12003
14689, 12003, 12014, 12015, 12004
14690, 12004, 12015, 1811, 1810
14691, 1769, 85, 1774, 12005
14692, 12005, 1774, 1775, 12006
14693, 12006, 1775, 1776, 12007
14694, 12007, 1776, 1777, 12008
14695, 12008, 1777, 1778, 12009
14696, 12009, 1778, 1779, 12010
14697, 12010, 1779, 1780, 12011
14698, 12011, 1780, 1781, 12012
14699, 12012, 1781, 1782, 12013
14700, 12013, 1782, 1783, 12014
14701, 12014, 1783, 1784, 12015
14702, 12015, 1784, 87, 1811
*ELEMENT, type=CPS4, ELSET=Surface123
14703, 1, 53, 1823, 1785
14704, 1785, 1823, 1824, 1786
14705, 1786, 1824, 1825, 1787
14706, 1787, 1825, 1826, 1788
14707, 1788, 1826, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
14708, 2, 1743, 1827, 54
14709, 1743, 1744, 1828, 1827
14710, 1744, 1745, 1829, 1828
14711, 1745, 1746, 1830, 1829
14712, 1746, 86, 90, 1830
*ELEMENT, type=CPS4, ELSET=Surface125
14713, 54, 1827, 12016, 1171
14714, 1827, 1828, 12017, 12016
14715, 1828, 1829, 12018, 12017
14716, 1829, 1830, 12019, 12018
14717, 1830, 90, 1831, 12019
14718, 1171, 12016, 12020, 1172
14719, 12016, 12017, 12021, 12020
14720, 12017, 12018, 12022, 12021
14721, 12018, 12019, 12023, 12022
14722, 12019, 1831, 1832, 12023
14723, 1172, 12020, 12024, 1173
14724, 12020, 12021, 12025, 12024
14725, 12021, 12022, 12026, 12025
14726, 12022, 12023, 12027, 12026
14727, 12023, 1832, 1833, 12027
14728, 1173, 12024, 12028, 1174
14729, 12024, 12025, 12029, 12028
14730, 12025, 12026, 12030, 12029
14731, 12026, 12027, 12031, 12030
14732, 12027, 1833, 1834, 12031
14733, 1174, 12028, 12032, 1175
14734, 12028, 12029, 12033, 12032
14735, 12029, 12030, 12034, 12033
14736, 12030, 12031, 12035, 12034
14737, 12031, 1834, 1835, 12035
14738, 1175, 12032, 12036, 1176
14739, 12032, 12033, 12037, 12036
14740, 12033, 12034, 12038, 12037
14741, 12034, 12035, 12039, 12038
14742, 12035, 1835, 1836, 12039
14743, 1176, 12036, 12040, 1177
14744, 12036, 12037, 12041, 12040
14745, 12037, 12038, 12042, 12041
14746, 12038, 12039, 12043, 12042
14747, 12039, 1836, 1837, 12043
14748, 1177, 12040, 12044, 1178
14749, 12040, 12041, 12045, 12044
14750, 12041, 12042, 12046, 12045
14751, 12042, 12043, 12047, 12046
14752, 12043, 1837, 1838, 12047
14753, 1178, 12044, 12048, 1179
14754, 12044, 12045, 12049, 12048
14755, 12045, 12046, 12050, 12049
14756, 12046, 12047, 12051, 12050
14757, 12047, 1838, 1839, 12051
14758, 1179, 12048, 12052, 1180
14759, 12048, 12049, 12053, 12052
14760, 12049, 12050, 12054, 12053
14761, 12050, 12051, 12055, 12054
14762, 12051, 1839, 1840, 12055
14763, 1180, 12052, 12056, 1181
14764, 12052, 12053, 12057, 12056
14765, 12053, 12054, 12058, 12057
14766, 12054, 12055, 12059, 12058
14767, 12055, 1840, 1841, 12059
14768, 1181, 12056, 1823, 53
14769, 12056, 12057, 1824, 1823
14770, 12057, 12058, 1825, 1824
14771, 12058, 12059, 1826, 1825
14772, 12059, 1841, 89, 1826
*ELEMENT, type=CPS4, ELSET=Surface126
14773, 86, 1812, 1831, 90
14774, 1812, 1813, 1832, 1831
14775, 1813, 1814, 1833, 1832
14776, 1814, 1815, 1834, 1833
14777, 1815, 1816, 1835, 1834
14778, 1816, 1817, 1836, 1835
14779, 1817, 1818, 1837, 1836
14780, 1818, 1819, 1838, 1837
14781, 1819, 1820, 1839, 1838
14782, 1820, 1821, 1840, 1839
14783, 1821, 1822, 1841, 1840
14784, 1822, 88, 89, 1841
*ELEMENT, type=CPS4, ELSET=Surface127
14785, 45, 1842, 12060, 1073
14786, 1842, 1843, 12061, 12060
14787, 1843, 1844, 12062, 12061
14788, 1844, 1845, 12063, 12062
14789, 1845, 91, 1850, 12063
14790, 1073, 12060, 12064, 1074
14791, 12060, 12061, 12065, 12064
14792, 12061, 12062, 12066, 12065
14793, 12062, 12063, 12067, 12066
14794, 12063, 1850, 1851, 12067
14795, 1074, 12064, 12068, 1075
14796, 12064, 12065, 12069, 12068
14797, 12065, 12066, 12070, 12069
14798, 12066, 12067, 12071, 12070
14799, 12067, 1851, 1852, 12071
14800, 1075, 12068, 12072, 1076
14801, 12068, 12069, 12073, 12072
14802, 12069, 12070, 12074, 12073
14803, 12070, 12071, 12075, 12074
14804, 12071, 1852, 1853, 12075
14805, 1076, 12072, 12076, 1077
14806, 12072, 12073, 12077, 12076
14807, 12073, 12074, 12078, 12077
14808, 12074, 12075, 12079, 12078
14809, 12075, 1853, 1854, 12079
14810, 1077, 12076, 12080, 1078
14811, 12076, 12077, 12081, 12080
14812, 12077, 12078, 12082, 12081
14813, 12078, 12079, 12083, 12082
14814, 12079, 1854, 1855, 12083
14815, 1078, 12080, 12084, 1079
14816, 12080, 12081, 12085, 12084
14817, 12081, 12082, 12086, 12085
14818, 12082, 12083, 12087, 12086
14819, 12083, 1855, 1856, 12087
14820, 1079, 12084, 12088, 1080
14821, 12084, 12085, 12089, 12088
14822, 12085, 12086, 12090, 12089
14823, 12086, 12087, 12091, 12090
14824, 12087, 1856, 1857, 12091
14825, 1080, 12088, 12092, 1081
14826, 12088, 12089, 12093, 12092
14827, 12089, 12090, 12094, 12093
14828, 12090, 12091, 12095, 12094
14829, 12091, 1857, 1858, 12095
14830, 1081, 12092, 12096, 1082
14831, 12092, 12093, 12097, 12096
14832, 12093, 12094, 12098, 12097
14833, 12094, 12095, 12099, 12098
14834, 12095, 1858, 1859, 12099
14835, 1082, 12096, 12100, 1083
14836, 12096, 12097, 12101, 12100
14837, 12097, 12098, 12102, 12101
14838, 12098, 12099, 12103, 12102
14839, 12099, 1859, 1860, 12103
14840, 1083, 12100, 12104, 1084
14841, 12100, 12101, 12105, 12104
14842, 12101, 12102, 12106, 12105
14843, 12102, 12103, 12107, 12106
14844, 12103, 1860, 1861, 12107
14845, 1084, 12104, 12108, 1085
14846, 12104, 12105, 12109, 12108
14847, 12105, 12106, 12110, 12109
14848, 12106, 12107, 12111, 12110
14849, 12107, 1861, 1862, 12111
14850, 1085, 12108, 12112, 1086
14851, 12108, 12109, 12113, 12112
14852, 12109, 12110, 12114, 12113
14853, 12110, 12111, 12115, 12114
14854, 12111, 1862, 1863, 12115
14855, 1086, 12112, 12116, 1087
14856, 12112, 12113, 12117, 12116
14857, 12113, 12114, 12118, 12117
14858, 12114, 12115, 12119, 12118
14859, 12115, 1863, 1864, 12119
14860, 1087, 12116, 12120, 1088
14861, 12116, 12117, 12121, 12120
14862, 12117, 12118, 12122, 12121
14863, 12118, 12119, 12123, 12122
14864, 12119, 1864, 1865, 12123
14865, 1088, 12120, 12124, 1089
14866, 12120, 12121, 12125, 12124
14867, 12121, 12122, 12126, 12125
14868, 12122, 12123, 12127, 12126
14869, 12123, 1865, 1866, 12127
14870, 1089, 12124, 12128, 1090
14871, 12124, 12125, 12129, 12128
14872, 12125, 12126, 12130, 12129
14873, 12126, 12127, 12131, 12130
14874, 12127, 1866, 1867, 12131
14875, 1090, 12128, 12132, 1091
