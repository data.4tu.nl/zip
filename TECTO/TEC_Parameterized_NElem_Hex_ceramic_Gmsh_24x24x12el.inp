1179, 1092, 1093
1180, 1093, 1094
1181, 1094, 1095
1182, 1095, 46
*ELEMENT, type=T3D2, ELSET=Line88
1183, 43, 1096
1184, 1096, 1097
1185, 1097, 47
*ELEMENT, type=T3D2, ELSET=Line89
1186, 44, 1098
1187, 1098, 1099
1188, 1099, 48
*ELEMENT, type=T3D2, ELSET=Line90
1189, 47, 1100
1190, 1100, 1101
1191, 1101, 1102
1192, 1102, 1103
1193, 1103, 1104
1194, 1104, 1105
1195, 1105, 1106
1196, 1106, 1107
1197, 1107, 1108
1198, 1108, 1109
1199, 1109, 1110
1200, 1110, 1111
1201, 1111, 1112
1202, 1112, 1113
1203, 1113, 1114
1204, 1114, 1115
1205, 1115, 1116
1206, 1116, 1117
1207, 1117, 1118
1208, 1118, 1119
1209, 1119, 1120
1210, 1120, 1121
1211, 1121, 1122
1212, 1122, 48
*ELEMENT, type=T3D2, ELSET=Line91
1213, 47, 1123
1214, 1123, 1124
1215, 1124, 1125
1216, 1125, 1126
1217, 1126, 1127
1218, 1127, 1128
1219, 1128, 1129
1220, 1129, 1130
1221, 1130, 1131
1222, 1131, 1132
1223, 1132, 1133
1224, 1133, 45
*ELEMENT, type=T3D2, ELSET=Line92
1225, 48, 1134
1226, 1134, 1135
1227, 1135, 1136
1228, 1136, 1137
1229, 1137, 1138
1230, 1138, 1139
1231, 1139, 1140
1232, 1140, 1141
1233, 1141, 1142
1234, 1142, 1143
1235, 1143, 1144
1236, 1144, 46
*ELEMENT, type=T3D2, ELSET=Line93
1237, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
1238, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
1239, 49, 1145
1240, 1145, 1146
1241, 1146, 50
*ELEMENT, type=T3D2, ELSET=Line96
1242, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
1243, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
1244, 51, 1147
1245, 1147, 1148
1246, 1148, 52
*ELEMENT, type=T3D2, ELSET=Line99
1247, 51, 1149
1248, 1149, 1150
1249, 1150, 1151
1250, 1151, 1152
1251, 1152, 1153
1252, 1153, 1154
1253, 1154, 1155
1254, 1155, 1156
1255, 1156, 1157
1256, 1157, 1158
1257, 1158, 1159
1258, 1159, 49
*ELEMENT, type=T3D2, ELSET=Line100
1259, 52, 1160
1260, 1160, 1161
1261, 1161, 1162
1262, 1162, 1163
1263, 1163, 1164
1264, 1164, 1165
1265, 1165, 1166
1266, 1166, 1167
1267, 1167, 1168
1268, 1168, 1169
1269, 1169, 1170
1270, 1170, 50
*ELEMENT, type=T3D2, ELSET=Line101
1271, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
1272, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
1273, 54, 1171
1274, 1171, 1172
1275, 1172, 1173
1276, 1173, 1174
1277, 1174, 1175
1278, 1175, 1176
1279, 1176, 1177
1280, 1177, 1178
1281, 1178, 1179
1282, 1179, 1180
1283, 1180, 1181
1284, 1181, 53
*ELEMENT, type=T3D2, ELSET=Line104
1285, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
1286, 53, 1182
1287, 1182, 1183
1288, 1183, 55
*ELEMENT, type=T3D2, ELSET=Line106
1289, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
1290, 56, 1184
1291, 1184, 1185
1292, 1185, 1186
1293, 1186, 1187
1294, 1187, 1188
1295, 1188, 1189
1296, 1189, 1190
1297, 1190, 1191
1298, 1191, 1192
1299, 1192, 1193
1300, 1193, 1194
1301, 1194, 55
*ELEMENT, type=T3D2, ELSET=Line108
1302, 54, 1195
1303, 1195, 1196
1304, 1196, 56
*ELEMENT, type=T3D2, ELSET=Line125
1305, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
1306, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
1307, 57, 1197
1308, 1197, 1198
1309, 1198, 1199
1310, 1199, 1200
1311, 1200, 1201
1312, 1201, 1202
1313, 1202, 1203
1314, 1203, 1204
1315, 1204, 1205
1316, 1205, 1206
1317, 1206, 1207
1318, 1207, 1208
1319, 1208, 1209
1320, 1209, 1210
1321, 1210, 1211
1322, 1211, 1212
1323, 1212, 1213
1324, 1213, 1214
1325, 1214, 1215
1326, 1215, 1216
1327, 1216, 1217
1328, 1217, 1218
1329, 1218, 1219
1330, 1219, 58
*ELEMENT, type=T3D2, ELSET=Line128
1331, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
1332, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
1333, 59, 1220
1334, 1220, 1221
1335, 1221, 1222
1336, 1222, 1223
1337, 1223, 1224
1338, 1224, 1225
1339, 1225, 1226
1340, 1226, 1227
1341, 1227, 1228
1342, 1228, 1229
1343, 1229, 1230
1344, 1230, 1231
1345, 1231, 1232
1346, 1232, 1233
1347, 1233, 1234
1348, 1234, 1235
1349, 1235, 1236
1350, 1236, 1237
1351, 1237, 1238
1352, 1238, 1239
1353, 1239, 1240
1354, 1240, 1241
1355, 1241, 1242
1356, 1242, 60
*ELEMENT, type=T3D2, ELSET=Line131
1357, 59, 1243
1358, 1243, 1244
1359, 1244, 1245
1360, 1245, 1246
1361, 1246, 1247
1362, 1247, 1248
1363, 1248, 1249
1364, 1249, 1250
1365, 1250, 1251
1366, 1251, 1252
1367, 1252, 1253
1368, 1253, 57
*ELEMENT, type=T3D2, ELSET=Line132
1369, 60, 1254
1370, 1254, 1255
1371, 1255, 1256
1372, 1256, 1257
1373, 1257, 1258
1374, 1258, 1259
1375, 1259, 1260
1376, 1260, 1261
1377, 1261, 1262
1378, 1262, 1263
1379, 1263, 1264
1380, 1264, 58
*ELEMENT, type=T3D2, ELSET=Line133
1381, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
1382, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
1383, 61, 1265
1384, 1265, 1266
1385, 1266, 1267
1386, 1267, 1268
1387, 1268, 1269
1388, 1269, 1270
1389, 1270, 1271
1390, 1271, 1272
1391, 1272, 1273
1392, 1273, 1274
1393, 1274, 1275
1394, 1275, 1276
1395, 1276, 1277
1396, 1277, 1278
1397, 1278, 1279
1398, 1279, 1280
1399, 1280, 1281
1400, 1281, 1282
1401, 1282, 1283
1402, 1283, 1284
1403, 1284, 1285
1404, 1285, 1286
1405, 1286, 1287
1406, 1287, 62
*ELEMENT, type=T3D2, ELSET=Line136
1407, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
1408, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
1409, 63, 1288
1410, 1288, 1289
1411, 1289, 1290
1412, 1290, 1291
1413, 1291, 1292
1414, 1292, 1293
1415, 1293, 1294
1416, 1294, 1295
1417, 1295, 1296
1418, 1296, 1297
1419, 1297, 1298
1420, 1298, 1299
1421, 1299, 1300
1422, 1300, 1301
1423, 1301, 1302
1424, 1302, 1303
1425, 1303, 1304
1426, 1304, 1305
1427, 1305, 1306
1428, 1306, 1307
1429, 1307, 1308
1430, 1308, 1309
1431, 1309, 1310
1432, 1310, 64
*ELEMENT, type=T3D2, ELSET=Line139
1433, 63, 1311
1434, 1311, 1312
1435, 1312, 1313
1436, 1313, 1314
1437, 1314, 1315
1438, 1315, 1316
1439, 1316, 1317
1440, 1317, 1318
1441, 1318, 1319
1442, 1319, 1320
1443, 1320, 1321
1444, 1321, 61
*ELEMENT, type=T3D2, ELSET=Line140
1445, 64, 1322
1446, 1322, 1323
1447, 1323, 1324
1448, 1324, 1325
1449, 1325, 1326
1450, 1326, 1327
1451, 1327, 1328
1452, 1328, 1329
1453, 1329, 1330
1454, 1330, 1331
1455, 1331, 1332
1456, 1332, 62
*ELEMENT, type=T3D2, ELSET=Line141
1457, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
1458, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
1459, 65, 1333
1460, 1333, 1334
1461, 1334, 1335
1462, 1335, 1336
1463, 1336, 1337
1464, 1337, 1338
1465, 1338, 1339
1466, 1339, 1340
1467, 1340, 1341
1468, 1341, 1342
1469, 1342, 1343
1470, 1343, 1344
1471, 1344, 1345
1472, 1345, 1346
1473, 1346, 1347
1474, 1347, 1348
1475, 1348, 1349
1476, 1349, 1350
1477, 1350, 1351
1478, 1351, 1352
1479, 1352, 1353
1480, 1353, 1354
1481, 1354, 1355
1482, 1355, 66
*ELEMENT, type=T3D2, ELSET=Line144
1483, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
1484, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
1485, 67, 1356
1486, 1356, 1357
1487, 1357, 1358
1488, 1358, 1359
1489, 1359, 1360
1490, 1360, 1361
1491, 1361, 1362
1492, 1362, 1363
1493, 1363, 1364
1494, 1364, 1365
1495, 1365, 1366
1496, 1366, 1367
1497, 1367, 1368
1498, 1368, 1369
1499, 1369, 1370
1500, 1370, 1371
1501, 1371, 1372
1502, 1372, 1373
1503, 1373, 1374
1504, 1374, 1375
1505, 1375, 1376
1506, 1376, 1377
1507, 1377, 1378
1508, 1378, 68
*ELEMENT, type=T3D2, ELSET=Line147
1509, 67, 1379
1510, 1379, 1380
1511, 1380, 1381
1512, 1381, 1382
1513, 1382, 1383
1514, 1383, 1384
1515, 1384, 1385
1516, 1385, 1386
1517, 1386, 1387
1518, 1387, 1388
1519, 1388, 1389
1520, 1389, 1390
1521, 1390, 1391
1522, 1391, 1392
1523, 1392, 1393
1524, 1393, 1394
1525, 1394, 1395
1526, 1395, 1396
1527, 1396, 1397
1528, 1397, 1398
1529, 1398, 1399
1530, 1399, 1400
1531, 1400, 1401
1532, 1401, 65
*ELEMENT, type=T3D2, ELSET=Line148
1533, 68, 1402
1534, 1402, 1403
1535, 1403, 1404
1536, 1404, 1405
1537, 1405, 1406
1538, 1406, 1407
1539, 1407, 1408
1540, 1408, 1409
1541, 1409, 1410
1542, 1410, 1411
1543, 1411, 1412
1544, 1412, 1413
1545, 1413, 1414
1546, 1414, 1415
1547, 1415, 1416
1548, 1416, 1417
1549, 1417, 1418
1550, 1418, 1419
1551, 1419, 1420
1552, 1420, 1421
1553, 1421, 1422
1554, 1422, 1423
1555, 1423, 1424
1556, 1424, 66
*ELEMENT, type=T3D2, ELSET=Line149
1557, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
1558, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
1559, 69, 1425
1560, 1425, 1426
1561, 1426, 1427
1562, 1427, 1428
1563, 1428, 1429
1564, 1429, 1430
1565, 1430, 1431
1566, 1431, 1432
1567, 1432, 1433
1568, 1433, 1434
1569, 1434, 1435
1570, 1435, 1436
1571, 1436, 1437
1572, 1437, 1438
1573, 1438, 1439
1574, 1439, 1440
1575, 1440, 1441
1576, 1441, 1442
1577, 1442, 1443
1578, 1443, 1444
1579, 1444, 1445
1580, 1445, 1446
1581, 1446, 1447
1582, 1447, 70
*ELEMENT, type=T3D2, ELSET=Line152
1583, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
1584, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
1585, 71, 1448
1586, 1448, 1449
1587, 1449, 1450
1588, 1450, 1451
1589, 1451, 1452
1590, 1452, 1453
1591, 1453, 1454
1592, 1454, 1455
1593, 1455, 1456
1594, 1456, 1457
1595, 1457, 1458
1596, 1458, 1459
1597, 1459, 1460
1598, 1460, 1461
1599, 1461, 1462
1600, 1462, 1463
1601, 1463, 1464
1602, 1464, 1465
1603, 1465, 1466
1604, 1466, 1467
1605, 1467, 1468
1606, 1468, 1469
1607, 1469, 1470
1608, 1470, 72
*ELEMENT, type=T3D2, ELSET=Line155
1609, 69, 1471
1610, 1471, 1472
1611, 1472, 1473
1612, 1473, 1474
1613, 1474, 1475
1614, 1475, 1476
1615, 1476, 1477
1616, 1477, 1478
1617, 1478, 1479
1618, 1479, 1480
1619, 1480, 1481
1620, 1481, 1482
1621, 1482, 1483
1622, 1483, 1484
1623, 1484, 1485
1624, 1485, 1486
1625, 1486, 1487
1626, 1487, 1488
1627, 1488, 1489
1628, 1489, 1490
1629, 1490, 1491
1630, 1491, 1492
1631, 1492, 1493
1632, 1493, 71
*ELEMENT, type=T3D2, ELSET=Line156
1633, 70, 1494
1634, 1494, 1495
1635, 1495, 1496
1636, 1496, 1497
1637, 1497, 1498
1638, 1498, 1499
1639, 1499, 1500
1640, 1500, 1501
1641, 1501, 1502
1642, 1502, 1503
1643, 1503, 1504
1644, 1504, 1505
1645, 1505, 1506
1646, 1506, 1507
1647, 1507, 1508
1648, 1508, 1509
1649, 1509, 1510
1650, 1510, 1511
1651, 1511, 1512
1652, 1512, 1513
1653, 1513, 1514
1654, 1514, 1515
1655, 1515, 1516
1656, 1516, 72
*ELEMENT, type=T3D2, ELSET=Line157
1657, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
1658, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
1659, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
1660, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
1661, 73, 1517
1662, 1517, 1518
1663, 1518, 1519
1664, 1519, 1520
1665, 1520, 1521
1666, 1521, 1522
1667, 1522, 1523
1668, 1523, 1524
1669, 1524, 1525
1670, 1525, 1526
1671, 1526, 1527
1672, 1527, 1528
1673, 1528, 1529
1674, 1529, 1530
1675, 1530, 1531
1676, 1531, 1532
1677, 1532, 1533
1678, 1533, 1534
1679, 1534, 1535
1680, 1535, 1536
1681, 1536, 1537
1682, 1537, 1538
1683, 1538, 1539
1684, 1539, 74
*ELEMENT, type=T3D2, ELSET=Line162
1685, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
1686, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
1687, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
1688, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
1689, 75, 1540
1690, 1540, 1541
1691, 1541, 1542
1692, 1542, 1543
1693, 1543, 1544
1694, 1544, 1545
1695, 1545, 1546
1696, 1546, 1547
1697, 1547, 1548
1698, 1548, 1549
1699, 1549, 1550
1700, 1550, 1551
1701, 1551, 1552
1702, 1552, 1553
1703, 1553, 1554
1704, 1554, 1555
1705, 1555, 1556
1706, 1556, 1557
1707, 1557, 1558
1708, 1558, 1559
1709, 1559, 1560
1710, 1560, 1561
1711, 1561, 1562
1712, 1562, 76
*ELEMENT, type=T3D2, ELSET=Line167
1713, 21, 1563
1714, 1563, 1564
1715, 1564, 1565
1716, 1565, 1566
1717, 1566, 77
*ELEMENT, type=T3D2, ELSET=Line168
1718, 22, 1567
1719, 1567, 1568
1720, 1568, 1569
1721, 1569, 1570
1722, 1570, 78
*ELEMENT, type=T3D2, ELSET=Line169
1723, 78, 1571
1724, 1571, 1572
1725, 1572, 1573
1726, 1573, 1574
1727, 1574, 1575
1728, 1575, 1576
1729, 1576, 1577
1730, 1577, 1578
1731, 1578, 1579
1732, 1579, 1580
1733, 1580, 1581
1734, 1581, 1582
1735, 1582, 1583
1736, 1583, 1584
1737, 1584, 1585
1738, 1585, 1586
1739, 1586, 1587
1740, 1587, 1588
1741, 1588, 1589
1742, 1589, 1590
1743, 1590, 1591
1744, 1591, 1592
1745, 1592, 1593
1746, 1593, 77
*ELEMENT, type=T3D2, ELSET=Line170
1747, 23, 1594
1748, 1594, 1595
1749, 1595, 1596
1750, 1596, 1597
1751, 1597, 79
*ELEMENT, type=T3D2, ELSET=Line171
1752, 77, 1598
1753, 1598, 1599
1754, 1599, 1600
1755, 1600, 1601
1756, 1601, 1602
1757, 1602, 1603
1758, 1603, 1604
1759, 1604, 1605
1760, 1605, 1606
1761, 1606, 1607
1762, 1607, 1608
1763, 1608, 79
*ELEMENT, type=T3D2, ELSET=Line172
1764, 24, 1609
1765, 1609, 1610
1766, 1610, 1611
1767, 1611, 1612
1768, 1612, 80
*ELEMENT, type=T3D2, ELSET=Line173
1769, 80, 1613
1770, 1613, 1614
1771, 1614, 1615
1772, 1615, 1616
1773, 1616, 1617
1774, 1617, 1618
1775, 1618, 1619
1776, 1619, 1620
1777, 1620, 1621
1778, 1621, 1622
1779, 1622, 1623
1780, 1623, 1624
1781, 1624, 1625
1782, 1625, 1626
1783, 1626, 1627
1784, 1627, 1628
1785, 1628, 1629
1786, 1629, 1630
1787, 1630, 1631
1788, 1631, 1632
1789, 1632, 1633
1790, 1633, 1634
1791, 1634, 1635
1792, 1635, 79
*ELEMENT, type=T3D2, ELSET=Line174
1793, 78, 1636
1794, 1636, 1637
1795, 1637, 1638
1796, 1638, 1639
1797, 1639, 1640
1798, 1640, 1641
1799, 1641, 1642
1800, 1642, 1643
1801, 1643, 1644
1802, 1644, 1645
1803, 1645, 1646
1804, 1646, 80
*ELEMENT, type=T3D2, ELSET=Line175
1805, 26, 1647
1806, 1647, 1648
1807, 1648, 1649
1808, 1649, 1650
1809, 1650, 81
*ELEMENT, type=T3D2, ELSET=Line176
1810, 79, 1651
1811, 1651, 1652
1812, 1652, 1653
1813, 1653, 1654
1814, 1654, 81
*ELEMENT, type=T3D2, ELSET=Line177
1815, 28, 1655
1816, 1655, 1656
1817, 1656, 1657
1818, 1657, 1658
1819, 1658, 82
*ELEMENT, type=T3D2, ELSET=Line178
1820, 77, 1659
1821, 1659, 1660
1822, 1660, 1661
1823, 1661, 1662
1824, 1662, 82
*ELEMENT, type=T3D2, ELSET=Line179
1825, 82, 1663
1826, 1663, 1664
1827, 1664, 1665
1828, 1665, 1666
1829, 1666, 1667
1830, 1667, 1668
1831, 1668, 1669
1832, 1669, 1670
1833, 1670, 1671
1834, 1671, 1672
1835, 1672, 1673
1836, 1673, 81
*ELEMENT, type=T3D2, ELSET=Line180
1837, 30, 1674
1838, 1674, 1675
1839, 1675, 1676
1840, 1676, 1677
1841, 1677, 83
*ELEMENT, type=T3D2, ELSET=Line181
1842, 81, 1678
1843, 1678, 1679
1844, 1679, 1680
1845, 1680, 1681
1846, 1681, 1682
1847, 1682, 1683
1848, 1683, 1684
1849, 1684, 1685
1850, 1685, 1686
1851, 1686, 1687
1852, 1687, 1688
1853, 1688, 1689
1854, 1689, 1690
1855, 1690, 1691
1856, 1691, 1692
1857, 1692, 1693
1858, 1693, 1694
1859, 1694, 1695
1860, 1695, 1696
1861, 1696, 1697
1862, 1697, 1698
1863, 1698, 1699
1864, 1699, 1700
1865, 1700, 83
*ELEMENT, type=T3D2, ELSET=Line182
1866, 32, 1701
1867, 1701, 1702
1868, 1702, 1703
1869, 1703, 1704
1870, 1704, 84
*ELEMENT, type=T3D2, ELSET=Line183
1871, 82, 1705
1872, 1705, 1706
1873, 1706, 1707
1874, 1707, 1708
1875, 1708, 1709
1876, 1709, 1710
1877, 1710, 1711
1878, 1711, 1712
1879, 1712, 1713
1880, 1713, 1714
1881, 1714, 1715
1882, 1715, 1716
1883, 1716, 1717
1884, 1717, 1718
1885, 1718, 1719
1886, 1719, 1720
1887, 1720, 1721
1888, 1721, 1722
1889, 1722, 1723
1890, 1723, 1724
1891, 1724, 1725
1892, 1725, 1726
1893, 1726, 1727
1894, 1727, 84
*ELEMENT, type=T3D2, ELSET=Line184
1895, 84, 1728
1896, 1728, 1729
1897, 1729, 1730
1898, 1730, 1731
1899, 1731, 1732
1900, 1732, 1733
1901, 1733, 1734
1902, 1734, 1735
1903, 1735, 1736
1904, 1736, 1737
1905, 1737, 1738
1906, 1738, 83
*ELEMENT, type=T3D2, ELSET=Line185
1907, 6, 1739
1908, 1739, 1740
1909, 1740, 1741
1910, 1741, 1742
1911, 1742, 85
*ELEMENT, type=T3D2, ELSET=Line186
1912, 2, 1743
1913, 1743, 1744
1914, 1744, 1745
1915, 1745, 1746
1916, 1746, 86
*ELEMENT, type=T3D2, ELSET=Line187
1917, 86, 1747
1918, 1747, 1748
1919, 1748, 1749
1920, 1749, 1750
1921, 1750, 1751
1922, 1751, 1752
1923, 1752, 1753
1924, 1753, 1754
1925, 1754, 1755
1926, 1755, 1756
1927, 1756, 1757
1928, 1757, 1758
1929, 1758, 1759
1930, 1759, 1760
1931, 1760, 1761
1932, 1761, 1762
1933, 1762, 1763
1934, 1763, 1764
1935, 1764, 1765
1936, 1765, 1766
1937, 1766, 1767
1938, 1767, 1768
1939, 1768, 1769
1940, 1769, 85
*ELEMENT, type=T3D2, ELSET=Line188
1941, 5, 1770
1942, 1770, 1771
1943, 1771, 1772
1944, 1772, 1773
1945, 1773, 87
*ELEMENT, type=T3D2, ELSET=Line189
1946, 85, 1774
1947, 1774, 1775
1948, 1775, 1776
1949, 1776, 1777
1950, 1777, 1778
1951, 1778, 1779
1952, 1779, 1780
1953, 1780, 1781
1954, 1781, 1782
1955, 1782, 1783
1956, 1783, 1784
1957, 1784, 87
*ELEMENT, type=T3D2, ELSET=Line190
1958, 1, 1785
1959, 1785, 1786
1960, 1786, 1787
1961, 1787, 1788
1962, 1788, 88
*ELEMENT, type=T3D2, ELSET=Line191
1963, 88, 1789
1964, 1789, 1790
1965, 1790, 1791
1966, 1791, 1792
1967, 1792, 1793
1968, 1793, 1794
1969, 1794, 1795
1970, 1795, 1796
1971, 1796, 1797
1972, 1797, 1798
1973, 1798, 1799
1974, 1799, 1800
1975, 1800, 1801
1976, 1801, 1802
1977, 1802, 1803
1978, 1803, 1804
1979, 1804, 1805
1980, 1805, 1806
1981, 1806, 1807
1982, 1807, 1808
1983, 1808, 1809
1984, 1809, 1810
1985, 1810, 1811
1986, 1811, 87
*ELEMENT, type=T3D2, ELSET=Line192
1987, 86, 1812
1988, 1812, 1813
1989, 1813, 1814
1990, 1814, 1815
1991, 1815, 1816
1992, 1816, 1817
1993, 1817, 1818
1994, 1818, 1819
1995, 1819, 1820
1996, 1820, 1821
1997, 1821, 1822
1998, 1822, 88
*ELEMENT, type=T3D2, ELSET=Line193
1999, 53, 1823
2000, 1823, 1824
2001, 1824, 1825
2002, 1825, 1826
2003, 1826, 89
*ELEMENT, type=T3D2, ELSET=Line194
2004, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
2005, 54, 1827
2006, 1827, 1828
2007, 1828, 1829
2008, 1829, 1830
2009, 1830, 90
*ELEMENT, type=T3D2, ELSET=Line196
2010, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
2011, 90, 1831
2012, 1831, 1832
2013, 1832, 1833
2014, 1833, 1834
2015, 1834, 1835
2016, 1835, 1836
2017, 1836, 1837
2018, 1837, 1838
2019, 1838, 1839
2020, 1839, 1840
2021, 1840, 1841
2022, 1841, 89
*ELEMENT, type=T3D2, ELSET=Line198
2023, 45, 1842
2024, 1842, 1843
2025, 1843, 1844
2026, 1844, 1845
2027, 1845, 91
*ELEMENT, type=T3D2, ELSET=Line199
2028, 46, 1846
2029, 1846, 1847
2030, 1847, 1848
2031, 1848, 1849
2032, 1849, 92
*ELEMENT, type=T3D2, ELSET=Line200
2033, 91, 1850
2034, 1850, 1851
2035, 1851, 1852
2036, 1852, 1853
2037, 1853, 1854
2038, 1854, 1855
2039, 1855, 1856
2040, 1856, 1857
2041, 1857, 1858
2042, 1858, 1859
2043, 1859, 1860
2044, 1860, 1861
2045, 1861, 1862
2046, 1862, 1863
2047, 1863, 1864
2048, 1864, 1865
2049, 1865, 1866
2050, 1866, 1867
2051, 1867, 1868
2052, 1868, 1869
2053, 1869, 1870
2054, 1870, 1871
2055, 1871, 1872
2056, 1872, 92
*ELEMENT, type=T3D2, ELSET=Line201
2057, 47, 1873
2058, 1873, 1874
2059, 1874, 1875
2060, 1875, 1876
2061, 1876, 93
*ELEMENT, type=T3D2, ELSET=Line202
2062, 48, 1877
2063, 1877, 1878
2064, 1878, 1879
2065, 1879, 1880
2066, 1880, 94
*ELEMENT, type=T3D2, ELSET=Line203
2067, 93, 1881
2068, 1881, 1882
2069, 1882, 1883
2070, 1883, 1884
2071, 1884, 1885
2072, 1885, 1886
2073, 1886, 1887
2074, 1887, 1888
2075, 1888, 1889
2076, 1889, 1890
2077, 1890, 1891
2078, 1891, 1892
2079, 1892, 1893
2080, 1893, 1894
2081, 1894, 1895
2082, 1895, 1896
2083, 1896, 1897
2084, 1897, 1898
2085, 1898, 1899
2086, 1899, 1900
2087, 1900, 1901
2088, 1901, 1902
2089, 1902, 1903
2090, 1903, 94
*ELEMENT, type=T3D2, ELSET=Line204
2091, 93, 1904
2092, 1904, 1905
2093, 1905, 1906
2094, 1906, 1907
2095, 1907, 1908
2096, 1908, 1909
2097, 1909, 1910
2098, 1910, 1911
2099, 1911, 1912
2100, 1912, 1913
2101, 1913, 1914
2102, 1914, 91
*ELEMENT, type=T3D2, ELSET=Line205
2103, 94, 1915
2104, 1915, 1916
2105, 1916, 1917
2106, 1917, 1918
2107, 1918, 1919
2108, 1919, 1920
2109, 1920, 1921
2110, 1921, 1922
2111, 1922, 1923
2112, 1923, 1924
2113, 1924, 1925
2114, 1925, 92
*ELEMENT, type=T3D2, ELSET=Line206
2115, 50, 1926
2116, 1926, 1927
2117, 1927, 1928
2118, 1928, 1929
2119, 1929, 95
*ELEMENT, type=T3D2, ELSET=Line207
2120, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
2121, 52, 1930
2122, 1930, 1931
2123, 1931, 1932
2124, 1932, 1933
2125, 1933, 96
*ELEMENT, type=T3D2, ELSET=Line209
2126, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
2127, 96, 1934
2128, 1934, 1935
2129, 1935, 1936
2130, 1936, 1937
2131, 1937, 1938
2132, 1938, 1939
2133, 1939, 1940
2134, 1940, 1941
2135, 1941, 1942
2136, 1942, 1943
2137, 1943, 1944
2138, 1944, 95
*ELEMENT, type=CPS4, ELSET=Surface1
2139, 2, 97, 1945, 121
2140, 121, 1945, 1946, 122
2141, 122, 1946, 110, 4
2142, 97, 98, 1947, 1945
2143, 1945, 1947, 1948, 1946
2144, 1946, 1948, 111, 110
2145, 98, 99, 1949, 1947
2146, 1947, 1949, 1950, 1948
2147, 1948, 1950, 112, 111
2148, 99, 100, 1951, 1949
2149, 1949, 1951, 1952, 1950
2150, 1950, 1952, 113, 112
2151, 100, 101, 1953, 1951
2152, 1951, 1953, 1954, 1952
2153, 1952, 1954, 114, 113
2154, 101, 102, 1955, 1953
2155, 1953, 1955, 1956, 1954
2156, 1954, 1956, 115, 114
2157, 102, 103, 1957, 1955
2158, 1955, 1957, 1958, 1956
2159, 1956, 1958, 116, 115
2160, 103, 104, 1959, 1957
2161, 1957, 1959, 1960, 1958
2162, 1958, 1960, 117, 116
2163, 104, 105, 1961, 1959
2164, 1959, 1961, 1962, 1960
2165, 1960, 1962, 118, 117
2166, 105, 106, 1963, 1961
2167, 1961, 1963, 1964, 1962
2168, 1962, 1964, 119, 118
2169, 106, 107, 1965, 1963
2170, 1963, 1965, 1966, 1964
2171, 1964, 1966, 120, 119
2172, 107, 1, 108, 1965
2173, 1965, 108, 109, 1966
2174, 1966, 109, 3, 120
*ELEMENT, type=CPS4, ELSET=Surface2
2175, 6, 147, 1967, 123
2176, 147, 148, 1968, 1967
2177, 148, 8, 136, 1968
2178, 123, 1967, 1969, 124
2179, 1967, 1968, 1970, 1969
2180, 1968, 136, 137, 1970
2181, 124, 1969, 1971, 125
2182, 1969, 1970, 1972, 1971
2183, 1970, 137, 138, 1972
2184, 125, 1971, 1973, 126
2185, 1971, 1972, 1974, 1973
2186, 1972, 138, 139, 1974
2187, 126, 1973, 1975, 127
2188, 1973, 1974, 1976, 1975
2189, 1974, 139, 140, 1976
2190, 127, 1975, 1977, 128
2191, 1975, 1976, 1978, 1977
2192, 1976, 140, 141, 1978
2193, 128, 1977, 1979, 129
2194, 1977, 1978, 1980, 1979
2195, 1978, 141, 142, 1980
2196, 129, 1979, 1981, 130
2197, 1979, 1980, 1982, 1981
2198, 1980, 142, 143, 1982
2199, 130, 1981, 1983, 131
2200, 1981, 1982, 1984, 1983
2201, 1982, 143, 144, 1984
2202, 131, 1983, 1985, 132
2203, 1983, 1984, 1986, 1985
2204, 1984, 144, 145, 1986
2205, 132, 1985, 1987, 133
2206, 1985, 1986, 1988, 1987
2207, 1986, 145, 146, 1988
2208, 133, 1987, 134, 5
2209, 1987, 1988, 135, 134
2210, 1988, 146, 7, 135
*ELEMENT, type=CPS4, ELSET=Surface3
2211, 2, 149, 1989, 97
2212, 97, 1989, 1990, 98
2213, 98, 1990, 1991, 99
2214, 99, 1991, 1992, 100
2215, 100, 1992, 1993, 101
2216, 101, 1993, 1994, 102
2217, 102, 1994, 1995, 103
2218, 103, 1995, 1996, 104
2219, 104, 1996, 1997, 105
2220, 105, 1997, 1998, 106
2221, 106, 1998, 1999, 107
2222, 107, 1999, 172, 1
2223, 149, 150, 2000, 1989
2224, 1989, 2000, 2001, 1990
2225, 1990, 2001, 2002, 1991
2226, 1991, 2002, 2003, 1992
2227, 1992, 2003, 2004, 1993
2228, 1993, 2004, 2005, 1994
2229, 1994, 2005, 2006, 1995
2230, 1995, 2006, 2007, 1996
2231, 1996, 2007, 2008, 1997
2232, 1997, 2008, 2009, 1998
2233, 1998, 2009, 2010, 1999
2234, 1999, 2010, 173, 172
2235, 150, 151, 2011, 2000
2236, 2000, 2011, 2012, 2001
2237, 2001, 2012, 2013, 2002
2238, 2002, 2013, 2014, 2003
2239, 2003, 2014, 2015, 2004
2240, 2004, 2015, 2016, 2005
2241, 2005, 2016, 2017, 2006
2242, 2006, 2017, 2018, 2007
2243, 2007, 2018, 2019, 2008
2244, 2008, 2019, 2020, 2009
2245, 2009, 2020, 2021, 2010
2246, 2010, 2021, 174, 173
2247, 151, 152, 2022, 2011
2248, 2011, 2022, 2023, 2012
2249, 2012, 2023, 2024, 2013
2250, 2013, 2024, 2025, 2014
2251, 2014, 2025, 2026, 2015
2252, 2015, 2026, 2027, 2016
2253, 2016, 2027, 2028, 2017
2254, 2017, 2028, 2029, 2018
2255, 2018, 2029, 2030, 2019
2256, 2019, 2030, 2031, 2020
2257, 2020, 2031, 2032, 2021
2258, 2021, 2032, 175, 174
2259, 152, 153, 2033, 2022
2260, 2022, 2033, 2034, 2023
2261, 2023, 2034, 2035, 2024
2262, 2024, 2035, 2036, 2025
2263, 2025, 2036, 2037, 2026
2264, 2026, 2037, 2038, 2027
2265, 2027, 2038, 2039, 2028
2266, 2028, 2039, 2040, 2029
2267, 2029, 2040, 2041, 2030
2268, 2030, 2041, 2042, 2031
2269, 2031, 2042, 2043, 2032
2270, 2032, 2043, 176, 175
2271, 153, 154, 2044, 2033
2272, 2033, 2044, 2045, 2034
2273, 2034, 2045, 2046, 2035
2274, 2035, 2046, 2047, 2036
2275, 2036, 2047, 2048, 2037
2276, 2037, 2048, 2049, 2038
2277, 2038, 2049, 2050, 2039
2278, 2039, 2050, 2051, 2040
2279, 2040, 2051, 2052, 2041
2280, 2041, 2052, 2053, 2042
2281, 2042, 2053, 2054, 2043
2282, 2043, 2054, 177, 176
2283, 154, 155, 2055, 2044
2284, 2044, 2055, 2056, 2045
2285, 2045, 2056, 2057, 2046
2286, 2046, 2057, 2058, 2047
2287, 2047, 2058, 2059, 2048
2288, 2048, 2059, 2060, 2049
2289, 2049, 2060, 2061, 2050
2290, 2050, 2061, 2062, 2051
2291, 2051, 2062, 2063, 2052
2292, 2052, 2063, 2064, 2053
2293, 2053, 2064, 2065, 2054
2294, 2054, 2065, 178, 177
2295, 155, 156, 2066, 2055
2296, 2055, 2066, 2067, 2056
2297, 2056, 2067, 2068, 2057
2298, 2057, 2068, 2069, 2058
2299, 2058, 2069, 2070, 2059
2300, 2059, 2070, 2071, 2060
2301, 2060, 2071, 2072, 2061
2302, 2061, 2072, 2073, 2062
2303, 2062, 2073, 2074, 2063
2304, 2063, 2074, 2075, 2064
2305, 2064, 2075, 2076, 2065
2306, 2065, 2076, 179, 178
2307, 156, 157, 2077, 2066
2308, 2066, 2077, 2078, 2067
2309, 2067, 2078, 2079, 2068
2310, 2068, 2079, 2080, 2069
2311, 2069, 2080, 2081, 2070
2312, 2070, 2081, 2082, 2071
2313, 2071, 2082, 2083, 2072
2314, 2072, 2083, 2084, 2073
2315, 2073, 2084, 2085, 2074
2316, 2074, 2085, 2086, 2075
2317, 2075, 2086, 2087, 2076
2318, 2076, 2087, 180, 179
2319, 157, 158, 2088, 2077
2320, 2077, 2088, 2089, 2078
2321, 2078, 2089, 2090, 2079
2322, 2079, 2090, 2091, 2080
2323, 2080, 2091, 2092, 2081
2324, 2081, 2092, 2093, 2082
2325, 2082, 2093, 2094, 2083
2326, 2083, 2094, 2095, 2084
2327, 2084, 2095, 2096, 2085
2328, 2085, 2096, 2097, 2086
2329, 2086, 2097, 2098, 2087
2330, 2087, 2098, 181, 180
2331, 158, 159, 2099, 2088
2332, 2088, 2099, 2100, 2089
2333, 2089, 2100, 2101, 2090
2334, 2090, 2101, 2102, 2091
2335, 2091, 2102, 2103, 2092
2336, 2092, 2103, 2104, 2093
2337, 2093, 2104, 2105, 2094
2338, 2094, 2105, 2106, 2095
2339, 2095, 2106, 2107, 2096
2340, 2096, 2107, 2108, 2097
2341, 2097, 2108, 2109, 2098
2342, 2098, 2109, 182, 181
2343, 159, 160, 2110, 2099
2344, 2099, 2110, 2111, 2100
2345, 2100, 2111, 2112, 2101
2346, 2101, 2112, 2113, 2102
2347, 2102, 2113, 2114, 2103
2348, 2103, 2114, 2115, 2104
2349, 2104, 2115, 2116, 2105
2350, 2105, 2116, 2117, 2106
2351, 2106, 2117, 2118, 2107
2352, 2107, 2118, 2119, 2108
2353, 2108, 2119, 2120, 2109
2354, 2109, 2120, 183, 182
2355, 160, 161, 2121, 2110
2356, 2110, 2121, 2122, 2111
2357, 2111, 2122, 2123, 2112
2358, 2112, 2123, 2124, 2113
2359, 2113, 2124, 2125, 2114
2360, 2114, 2125, 2126, 2115
2361, 2115, 2126, 2127, 2116
2362, 2116, 2127, 2128, 2117
2363, 2117, 2128, 2129, 2118
2364, 2118, 2129, 2130, 2119
2365, 2119, 2130, 2131, 2120
2366, 2120, 2131, 184, 183
2367, 161, 162, 2132, 2121
2368, 2121, 2132, 2133, 2122
2369, 2122, 2133, 2134, 2123
2370, 2123, 2134, 2135, 2124
2371, 2124, 2135, 2136, 2125
2372, 2125, 2136, 2137, 2126
2373, 2126, 2137, 2138, 2127
2374, 2127, 2138, 2139, 2128
2375, 2128, 2139, 2140, 2129
2376, 2129, 2140, 2141, 2130
2377, 2130, 2141, 2142, 2131
2378, 2131, 2142, 185, 184
2379, 162, 163, 2143, 2132
2380, 2132, 2143, 2144, 2133
2381, 2133, 2144, 2145, 2134
2382, 2134, 2145, 2146, 2135
2383, 2135, 2146, 2147, 2136
2384, 2136, 2147, 2148, 2137
2385, 2137, 2148, 2149, 2138
2386, 2138, 2149, 2150, 2139
2387, 2139, 2150, 2151, 2140
2388, 2140, 2151, 2152, 2141
2389, 2141, 2152, 2153, 2142
2390, 2142, 2153, 186, 185
2391, 163, 164, 2154, 2143
2392, 2143, 2154, 2155, 2144
2393, 2144, 2155, 2156, 2145
2394, 2145, 2156, 2157, 2146
2395, 2146, 2157, 2158, 2147
2396, 2147, 2158, 2159, 2148
2397, 2148, 2159, 2160, 2149
2398, 2149, 2160, 2161, 2150
2399, 2150, 2161, 2162, 2151
2400, 2151, 2162, 2163, 2152
2401, 2152, 2163, 2164, 2153
2402, 2153, 2164, 187, 186
2403, 164, 165, 2165, 2154
2404, 2154, 2165, 2166, 2155
2405, 2155, 2166, 2167, 2156
2406, 2156, 2167, 2168, 2157
2407, 2157, 2168, 2169, 2158
2408, 2158, 2169, 2170, 2159
2409, 2159, 2170, 2171, 2160
2410, 2160, 2171, 2172, 2161
2411, 2161, 2172, 2173, 2162
2412, 2162, 2173, 2174, 2163
2413, 2163, 2174, 2175, 2164
2414, 2164, 2175, 188, 187
2415, 165, 166, 2176, 2165
2416, 2165, 2176, 2177, 2166
2417, 2166, 2177, 2178, 2167
2418, 2167, 2178, 2179, 2168
2419, 2168, 2179, 2180, 2169
2420, 2169, 2180, 2181, 2170
2421, 2170, 2181, 2182, 2171
2422, 2171, 2182, 2183, 2172
2423, 2172, 2183, 2184, 2173
2424, 2173, 2184, 2185, 2174
2425, 2174, 2185, 2186, 2175
2426, 2175, 2186, 189, 188
2427, 166, 167, 2187, 2176
2428, 2176, 2187, 2188, 2177
2429, 2177, 2188, 2189, 2178
2430, 2178, 2189, 2190, 2179
2431, 2179, 2190, 2191, 2180
2432, 2180, 2191, 2192, 2181
2433, 2181, 2192, 2193, 2182
2434, 2182, 2193, 2194, 2183
2435, 2183, 2194, 2195, 2184
2436, 2184, 2195, 2196, 2185
2437, 2185, 2196, 2197, 2186
2438, 2186, 2197, 190, 189
2439, 167, 168, 2198, 2187
2440, 2187, 2198, 2199, 2188
2441, 2188, 2199, 2200, 2189
2442, 2189, 2200, 2201, 2190
2443, 2190, 2201, 2202, 2191
2444, 2191, 2202, 2203, 2192
2445, 2192, 2203, 2204, 2193
2446, 2193, 2204, 2205, 2194
2447, 2194, 2205, 2206, 2195
2448, 2195, 2206, 2207, 2196
2449, 2196, 2207, 2208, 2197
2450, 2197, 2208, 191, 190
2451, 168, 169, 2209, 2198
2452, 2198, 2209, 2210, 2199
2453, 2199, 2210, 2211, 2200
2454, 2200, 2211, 2212, 2201
2455, 2201, 2212, 2213, 2202
2456, 2202, 2213, 2214, 2203
2457, 2203, 2214, 2215, 2204
2458, 2204, 2215, 2216, 2205
2459, 2205, 2216, 2217, 2206
2460, 2206, 2217, 2218, 2207
2461, 2207, 2218, 2219, 2208
2462, 2208, 2219, 192, 191
2463, 169, 170, 2220, 2209
2464, 2209, 2220, 2221, 2210
2465, 2210, 2221, 2222, 2211
2466, 2211, 2222, 2223, 2212
2467, 2212, 2223, 2224, 2213
2468, 2213, 2224, 2225, 2214
2469, 2214, 2225, 2226, 2215
2470, 2215, 2226, 2227, 2216
2471, 2216, 2227, 2228, 2217
2472, 2217, 2228, 2229, 2218
2473, 2218, 2229, 2230, 2219
2474, 2219, 2230, 193, 192
2475, 170, 171, 2231, 2220
2476, 2220, 2231, 2232, 2221
2477, 2221, 2232, 2233, 2222
2478, 2222, 2233, 2234, 2223
2479, 2223, 2234, 2235, 2224
2480, 2224, 2235, 2236, 2225
2481, 2225, 2236, 2237, 2226
2482, 2226, 2237, 2238, 2227
2483, 2227, 2238, 2239, 2228
2484, 2228, 2239, 2240, 2229
2485, 2229, 2240, 2241, 2230
2486, 2230, 2241, 194, 193
2487, 171, 6, 123, 2231
2488, 2231, 123, 124, 2232
2489, 2232, 124, 125, 2233
2490, 2233, 125, 126, 2234
2491, 2234, 126, 127, 2235
2492, 2235, 127, 128, 2236
2493, 2236, 128, 129, 2237
2494, 2237, 129, 130, 2238
2495, 2238, 130, 131, 2239
2496, 2239, 131, 132, 2240
2497, 2240, 132, 133, 2241
2498, 2241, 133, 5, 194
*ELEMENT, type=CPS4, ELSET=Surface4
2499, 4, 110, 2242, 195
2500, 110, 111, 2243, 2242
2501, 111, 112, 2244, 2243
2502, 112, 113, 2245, 2244
2503, 113, 114, 2246, 2245
2504, 114, 115, 2247, 2246
2505, 115, 116, 2248, 2247
2506, 116, 117, 2249, 2248
2507, 117, 118, 2250, 2249
2508, 118, 119, 2251, 2250
2509, 119, 120, 2252, 2251
2510, 120, 3, 218, 2252
2511, 195, 2242, 2253, 196
2512, 2242, 2243, 2254, 2253
2513, 2243, 2244, 2255, 2254
2514, 2244, 2245, 2256, 2255
2515, 2245, 2246, 2257, 2256
2516, 2246, 2247, 2258, 2257
2517, 2247, 2248, 2259, 2258
2518, 2248, 2249, 2260, 2259
2519, 2249, 2250, 2261, 2260
2520, 2250, 2251, 2262, 2261
2521, 2251, 2252, 2263, 2262
2522, 2252, 218, 219, 2263
2523, 196, 2253, 2264, 197
2524, 2253, 2254, 2265, 2264
2525, 2254, 2255, 2266, 2265
2526, 2255, 2256, 2267, 2266
2527, 2256, 2257, 2268, 2267
2528, 2257, 2258, 2269, 2268
2529, 2258, 2259, 2270, 2269
2530, 2259, 2260, 2271, 2270
2531, 2260, 2261, 2272, 2271
2532, 2261, 2262, 2273, 2272
2533, 2262, 2263, 2274, 2273
2534, 2263, 219, 220, 2274
2535, 197, 2264, 2275, 198
2536, 2264, 2265, 2276, 2275
2537, 2265, 2266, 2277, 2276
2538, 2266, 2267, 2278, 2277
2539, 2267, 2268, 2279, 2278
2540, 2268, 2269, 2280, 2279
2541, 2269, 2270, 2281, 2280
2542, 2270, 2271, 2282, 2281
2543, 2271, 2272, 2283, 2282
2544, 2272, 2273, 2284, 2283
2545, 2273, 2274, 2285, 2284
2546, 2274, 220, 221, 2285
2547, 198, 2275, 2286, 199
2548, 2275, 2276, 2287, 2286
2549, 2276, 2277, 2288, 2287
2550, 2277, 2278, 2289, 2288
2551, 2278, 2279, 2290, 2289
2552, 2279, 2280, 2291, 2290
2553, 2280, 2281, 2292, 2291
2554, 2281, 2282, 2293, 2292
2555, 2282, 2283, 2294, 2293
2556, 2283, 2284, 2295, 2294
2557, 2284, 2285, 2296, 2295
2558, 2285, 221, 222, 2296
2559, 199, 2286, 2297, 200
2560, 2286, 2287, 2298, 2297
2561, 2287, 2288, 2299, 2298
2562, 2288, 2289, 2300, 2299
2563, 2289, 2290, 2301, 2300
2564, 2290, 2291, 2302, 2301
2565, 2291, 2292, 2303, 2302
2566, 2292, 2293, 2304, 2303
2567, 2293, 2294, 2305, 2304
2568, 2294, 2295, 2306, 2305
2569, 2295, 2296, 2307, 2306
2570, 2296, 222, 223, 2307
2571, 200, 2297, 2308, 201
2572, 2297, 2298, 2309, 2308
2573, 2298, 2299, 2310, 2309
2574, 2299, 2300, 2311, 2310
2575, 2300, 2301, 2312, 2311
2576, 2301, 2302, 2313, 2312
2577, 2302, 2303, 2314, 2313
2578, 2303, 2304, 2315, 2314
2579, 2304, 2305, 2316, 2315
2580, 2305, 2306, 2317, 2316
2581, 2306, 2307, 2318, 2317
2582, 2307, 223, 224, 2318
2583, 201, 2308, 2319, 202
2584, 2308, 2309, 2320, 2319
2585, 2309, 2310, 2321, 2320
2586, 2310, 2311, 2322, 2321
2587, 2311, 2312, 2323, 2322
2588, 2312, 2313, 2324, 2323
2589, 2313, 2314, 2325, 2324
2590, 2314, 2315, 2326, 2325
2591, 2315, 2316, 2327, 2326
2592, 2316, 2317, 2328, 2327
2593, 2317, 2318, 2329, 2328
2594, 2318, 224, 225, 2329
2595, 202, 2319, 2330, 203
2596, 2319, 2320, 2331, 2330
2597, 2320, 2321, 2332, 2331
2598, 2321, 2322, 2333, 2332
2599, 2322, 2323, 2334, 2333
2600, 2323, 2324, 2335, 2334
2601, 2324, 2325, 2336, 2335
2602, 2325, 2326, 2337, 2336
2603, 2326, 2327, 2338, 2337
2604, 2327, 2328, 2339, 2338
2605, 2328, 2329, 2340, 2339
2606, 2329, 225, 226, 2340
2607, 203, 2330, 2341, 204
2608, 2330, 2331, 2342, 2341
2609, 2331, 2332, 2343, 2342
2610, 2332, 2333, 2344, 2343
2611, 2333, 2334, 2345, 2344
2612, 2334, 2335, 2346, 2345
2613, 2335, 2336, 2347, 2346
2614, 2336, 2337, 2348, 2347
2615, 2337, 2338, 2349, 2348
2616, 2338, 2339, 2350, 2349
2617, 2339, 2340, 2351, 2350
2618, 2340, 226, 227, 2351
2619, 204, 2341, 2352, 205
2620, 2341, 2342, 2353, 2352
2621, 2342, 2343, 2354, 2353
2622, 2343, 2344, 2355, 2354
2623, 2344, 2345, 2356, 2355
2624, 2345, 2346, 2357, 2356
2625, 2346, 2347, 2358, 2357
2626, 2347, 2348, 2359, 2358
2627, 2348, 2349, 2360, 2359
2628, 2349, 2350, 2361, 2360
2629, 2350, 2351, 2362, 2361
2630, 2351, 227, 228, 2362
2631, 205, 2352, 2363, 206
2632, 2352, 2353, 2364, 2363
2633, 2353, 2354, 2365, 2364
2634, 2354, 2355, 2366, 2365
2635, 2355, 2356, 2367, 2366
2636, 2356, 2357, 2368, 2367
2637, 2357, 2358, 2369, 2368
2638, 2358, 2359, 2370, 2369
2639, 2359, 2360, 2371, 2370
2640, 2360, 2361, 2372, 2371
2641, 2361, 2362, 2373, 2372
2642, 2362, 228, 229, 2373
2643, 206, 2363, 2374, 207
2644, 2363, 2364, 2375, 2374
2645, 2364, 2365, 2376, 2375
2646, 2365, 2366, 2377, 2376
2647, 2366, 2367, 2378, 2377
2648, 2367, 2368, 2379, 2378
2649, 2368, 2369, 2380, 2379
2650, 2369, 2370, 2381, 2380
2651, 2370, 2371, 2382, 2381
2652, 2371, 2372, 2383, 2382
2653, 2372, 2373, 2384, 2383
2654, 2373, 229, 230, 2384
2655, 207, 2374, 2385, 208
2656, 2374, 2375, 2386, 2385
2657, 2375, 2376, 2387, 2386
2658, 2376, 2377, 2388, 2387
2659, 2377, 2378, 2389, 2388
2660, 2378, 2379, 2390, 2389
2661, 2379, 2380, 2391, 2390
2662, 2380, 2381, 2392, 2391
2663, 2381, 2382, 2393, 2392
2664, 2382, 2383, 2394, 2393
2665, 2383, 2384, 2395, 2394
2666, 2384, 230, 231, 2395
2667, 208, 2385, 2396, 209
2668, 2385, 2386, 2397, 2396
2669, 2386, 2387, 2398, 2397
2670, 2387, 2388, 2399, 2398
2671, 2388, 2389, 2400, 2399
2672, 2389, 2390, 2401, 2400
2673, 2390, 2391, 2402, 2401
2674, 2391, 2392, 2403, 2402
2675, 2392, 2393, 2404, 2403
2676, 2393, 2394, 2405, 2404
2677, 2394, 2395, 2406, 2405
2678, 2395, 231, 232, 2406
2679, 209, 2396, 2407, 210
2680, 2396, 2397, 2408, 2407
2681, 2397, 2398, 2409, 2408
2682, 2398, 2399, 2410, 2409
2683, 2399, 2400, 2411, 2410
2684, 2400, 2401, 2412, 2411
2685, 2401, 2402, 2413, 2412
2686, 2402, 2403, 2414, 2413
2687, 2403, 2404, 2415, 2414
2688, 2404, 2405, 2416, 2415
2689, 2405, 2406, 2417, 2416
2690, 2406, 232, 233, 2417
2691, 210, 2407, 2418, 211
2692, 2407, 2408, 2419, 2418
2693, 2408, 2409, 2420, 2419
2694, 2409, 2410, 2421, 2420
2695, 2410, 2411, 2422, 2421
2696, 2411, 2412, 2423, 2422
2697, 2412, 2413, 2424, 2423
2698, 2413, 2414, 2425, 2424
2699, 2414, 2415, 2426, 2425
2700, 2415, 2416, 2427, 2426
2701, 2416, 2417, 2428, 2427
2702, 2417, 233, 234, 2428
2703, 211, 2418, 2429, 212
2704, 2418, 2419, 2430, 2429
2705, 2419, 2420, 2431, 2430
2706, 2420, 2421, 2432, 2431
2707, 2421, 2422, 2433, 2432
2708, 2422, 2423, 2434, 2433
2709, 2423, 2424, 2435, 2434
2710, 2424, 2425, 2436, 2435
2711, 2425, 2426, 2437, 2436
2712, 2426, 2427, 2438, 2437
2713, 2427, 2428, 2439, 2438
2714, 2428, 234, 235, 2439
2715, 212, 2429, 2440, 213
2716, 2429, 2430, 2441, 2440
2717, 2430, 2431, 2442, 2441
2718, 2431, 2432, 2443, 2442
2719, 2432, 2433, 2444, 2443
2720, 2433, 2434, 2445, 2444
2721, 2434, 2435, 2446, 2445
2722, 2435, 2436, 2447, 2446
2723, 2436, 2437, 2448, 2447
2724, 2437, 2438, 2449, 2448
2725, 2438, 2439, 2450, 2449
2726, 2439, 235, 236, 2450
2727, 213, 2440, 2451, 214
2728, 2440, 2441, 2452, 2451
2729, 2441, 2442, 2453, 2452
2730, 2442, 2443, 2454, 2453
2731, 2443, 2444, 2455, 2454
2732, 2444, 2445, 2456, 2455
2733, 2445, 2446, 2457, 2456
2734, 2446, 2447, 2458, 2457
2735, 2447, 2448, 2459, 2458
2736, 2448, 2449, 2460, 2459
2737, 2449, 2450, 2461, 2460
2738, 2450, 236, 237, 2461
2739, 214, 2451, 2462, 215
2740, 2451, 2452, 2463, 2462
2741, 2452, 2453, 2464, 2463
2742, 2453, 2454, 2465, 2464
2743, 2454, 2455, 2466, 2465
2744, 2455, 2456, 2467, 2466
2745, 2456, 2457, 2468, 2467
2746, 2457, 2458, 2469, 2468
2747, 2458, 2459, 2470, 2469
2748, 2459, 2460, 2471, 2470
2749, 2460, 2461, 2472, 2471
2750, 2461, 237, 238, 2472
2751, 215, 2462, 2473, 216
2752, 2462, 2463, 2474, 2473
2753, 2463, 2464, 2475, 2474
2754, 2464, 2465, 2476, 2475
2755, 2465, 2466, 2477, 2476
2756, 2466, 2467, 2478, 2477
2757, 2467, 2468, 2479, 2478
2758, 2468, 2469, 2480, 2479
2759, 2469, 2470, 2481, 2480
2760, 2470, 2471, 2482, 2481
2761, 2471, 2472, 2483, 2482
2762, 2472, 238, 239, 2483
2763, 216, 2473, 2484, 217
2764, 2473, 2474, 2485, 2484
2765, 2474, 2475, 2486, 2485
2766, 2475, 2476, 2487, 2486
2767, 2476, 2477, 2488, 2487
2768, 2477, 2478, 2489, 2488
2769, 2478, 2479, 2490, 2489
2770, 2479, 2480, 2491, 2490
2771, 2480, 2481, 2492, 2491
2772, 2481, 2482, 2493, 2492
2773, 2482, 2483, 2494, 2493
2774, 2483, 239, 240, 2494
2775, 217, 2484, 136, 8
2776, 2484, 2485, 137, 136
2777, 2485, 2486, 138, 137
2778, 2486, 2487, 139, 138
2779, 2487, 2488, 140, 139
2780, 2488, 2489, 141, 140
2781, 2489, 2490, 142, 141
2782, 2490, 2491, 143, 142
2783, 2491, 2492, 144, 143
2784, 2492, 2493, 145, 144
2785, 2493, 2494, 146, 145
2786, 2494, 240, 7, 146
*ELEMENT, type=CPS4, ELSET=Surface5
2787, 2, 121, 2495, 149
2788, 149, 2495, 2496, 150
2789, 150, 2496, 2497, 151
2790, 151, 2497, 2498, 152
2791, 152, 2498, 2499, 153
2792, 153, 2499, 2500, 154
2793, 154, 2500, 2501, 155
2794, 155, 2501, 2502, 156
2795, 156, 2502, 2503, 157
2796, 157, 2503, 2504, 158
2797, 158, 2504, 2505, 159
2798, 159, 2505, 2506, 160
2799, 160, 2506, 2507, 161
2800, 161, 2507, 2508, 162
2801, 162, 2508, 2509, 163
2802, 163, 2509, 2510, 164
2803, 164, 2510, 2511, 165
2804, 165, 2511, 2512, 166
2805, 166, 2512, 2513, 167
2806, 167, 2513, 2514, 168
2807, 168, 2514, 2515, 169
2808, 169, 2515, 2516, 170
2809, 170, 2516, 2517, 171
2810, 171, 2517, 147, 6
2811, 121, 122, 2518, 2495
2812, 2495, 2518, 2519, 2496
2813, 2496, 2519, 2520, 2497
2814, 2497, 2520, 2521, 2498
2815, 2498, 2521, 2522, 2499
2816, 2499, 2522, 2523, 2500
2817, 2500, 2523, 2524, 2501
2818, 2501, 2524, 2525, 2502
2819, 2502, 2525, 2526, 2503
2820, 2503, 2526, 2527, 2504
2821, 2504, 2527, 2528, 2505
2822, 2505, 2528, 2529, 2506
2823, 2506, 2529, 2530, 2507
2824, 2507, 2530, 2531, 2508
2825, 2508, 2531, 2532, 2509
2826, 2509, 2532, 2533, 2510
2827, 2510, 2533, 2534, 2511
2828, 2511, 2534, 2535, 2512
2829, 2512, 2535, 2536, 2513
2830, 2513, 2536, 2537, 2514
2831, 2514, 2537, 2538, 2515
2832, 2515, 2538, 2539, 2516
2833, 2516, 2539, 2540, 2517
2834, 2517, 2540, 148, 147
2835, 122, 4, 195, 2518
2836, 2518, 195, 196, 2519
2837, 2519, 196, 197, 2520
2838, 2520, 197, 198, 2521
2839, 2521, 198, 199, 2522
2840, 2522, 199, 200, 2523
2841, 2523, 200, 201, 2524
2842, 2524, 201, 202, 2525
2843, 2525, 202, 203, 2526
2844, 2526, 203, 204, 2527
2845, 2527, 204, 205, 2528
2846, 2528, 205, 206, 2529
2847, 2529, 206, 207, 2530
2848, 2530, 207, 208, 2531
2849, 2531, 208, 209, 2532
2850, 2532, 209, 210, 2533
2851, 2533, 210, 211, 2534
2852, 2534, 211, 212, 2535
2853, 2535, 212, 213, 2536
2854, 2536, 213, 214, 2537
2855, 2537, 214, 215, 2538
2856, 2538, 215, 216, 2539
2857, 2539, 216, 217, 2540
2858, 2540, 217, 8, 148
*ELEMENT, type=CPS4, ELSET=Surface6
2859, 1, 172, 2541, 108
2860, 172, 173, 2542, 2541
2861, 173, 174, 2543, 2542
2862, 174, 175, 2544, 2543
2863, 175, 176, 2545, 2544
2864, 176, 177, 2546, 2545
2865, 177, 178, 2547, 2546
2866, 178, 179, 2548, 2547
2867, 179, 180, 2549, 2548
2868, 180, 181, 2550, 2549
2869, 181, 182, 2551, 2550
2870, 182, 183, 2552, 2551
2871, 183, 184, 2553, 2552
2872, 184, 185, 2554, 2553
2873, 185, 186, 2555, 2554
2874, 186, 187, 2556, 2555
2875, 187, 188, 2557, 2556
2876, 188, 189, 2558, 2557
2877, 189, 190, 2559, 2558
2878, 190, 191, 2560, 2559
2879, 191, 192, 2561, 2560
2880, 192, 193, 2562, 2561
2881, 193, 194, 2563, 2562
2882, 194, 5, 134, 2563
2883, 108, 2541, 2564, 109
2884, 2541, 2542, 2565, 2564
2885, 2542, 2543, 2566, 2565
2886, 2543, 2544, 2567, 2566
2887, 2544, 2545, 2568, 2567
2888, 2545, 2546, 2569, 2568
2889, 2546, 2547, 2570, 2569
2890, 2547, 2548, 2571, 2570
2891, 2548, 2549, 2572, 2571
2892, 2549, 2550, 2573, 2572
2893, 2550, 2551, 2574, 2573
2894, 2551, 2552, 2575, 2574
2895, 2552, 2553, 2576, 2575
2896, 2553, 2554, 2577, 2576
2897, 2554, 2555, 2578, 2577
2898, 2555, 2556, 2579, 2578
2899, 2556, 2557, 2580, 2579
2900, 2557, 2558, 2581, 2580
2901, 2558, 2559, 2582, 2581
2902, 2559, 2560, 2583, 2582
2903, 2560, 2561, 2584, 2583
2904, 2561, 2562, 2585, 2584
2905, 2562, 2563, 2586, 2585
2906, 2563, 134, 135, 2586
2907, 109, 2564, 218, 3
2908, 2564, 2565, 219, 218
2909, 2565, 2566, 220, 219
2910, 2566, 2567, 221, 220
2911, 2567, 2568, 222, 221
2912, 2568, 2569, 223, 222
2913, 2569, 2570, 224, 223
2914, 2570, 2571, 225, 224
2915, 2571, 2572, 226, 225
2916, 2572, 2573, 227, 226
2917, 2573, 2574, 228, 227
2918, 2574, 2575, 229, 228
2919, 2575, 2576, 230, 229
2920, 2576, 2577, 231, 230
2921, 2577, 2578, 232, 231
2922, 2578, 2579, 233, 232
2923, 2579, 2580, 234, 233
2924, 2580, 2581, 235, 234
2925, 2581, 2582, 236, 235
2926, 2582, 2583, 237, 236
2927, 2583, 2584, 238, 237
2928, 2584, 2585, 239, 238
2929, 2585, 2586, 240, 239
2930, 2586, 135, 7, 240
*ELEMENT, type=CPS4, ELSET=Surface7
2931, 4, 10, 241, 195
2932, 195, 241, 242, 196
2933, 196, 242, 243, 197
2934, 197, 243, 244, 198
2935, 198, 244, 245, 199
2936, 199, 245, 246, 200
2937, 200, 246, 247, 201
2938, 201, 247, 248, 202
2939, 202, 248, 249, 203
2940, 203, 249, 250, 204
2941, 204, 250, 251, 205
2942, 205, 251, 252, 206
2943, 206, 252, 253, 207
2944, 207, 253, 254, 208
2945, 208, 254, 255, 209
2946, 209, 255, 256, 210
2947, 210, 256, 257, 211
2948, 211, 257, 258, 212
2949, 212, 258, 259, 213
2950, 213, 259, 260, 214
2951, 214, 260, 261, 215
2952, 215, 261, 262, 216
2953, 216, 262, 263, 217
2954, 217, 263, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
2955, 8, 9, 264, 136
2956, 136, 264, 265, 137
2957, 137, 265, 266, 138
2958, 138, 266, 267, 139
2959, 139, 267, 268, 140
2960, 140, 268, 269, 141
2961, 141, 269, 270, 142
2962, 142, 270, 271, 143
2963, 143, 271, 272, 144
2964, 144, 272, 273, 145
2965, 145, 273, 274, 146
2966, 146, 274, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
2967, 3, 218, 275, 12
2968, 218, 219, 276, 275
2969, 219, 220, 277, 276
2970, 220, 221, 278, 277
2971, 221, 222, 279, 278
2972, 222, 223, 280, 279
2973, 223, 224, 281, 280
2974, 224, 225, 282, 281
2975, 225, 226, 283, 282
2976, 226, 227, 284, 283
2977, 227, 228, 285, 284
2978, 228, 229, 286, 285
2979, 229, 230, 287, 286
2980, 230, 231, 288, 287
2981, 231, 232, 289, 288
2982, 232, 233, 290, 289
2983, 233, 234, 291, 290
2984, 234, 235, 292, 291
2985, 235, 236, 293, 292
2986, 236, 237, 294, 293
2987, 237, 238, 295, 294
2988, 238, 239, 296, 295
2989, 239, 240, 297, 296
2990, 240, 7, 11, 297
*ELEMENT, type=CPS4, ELSET=Surface10
2991, 4, 110, 298, 10
2992, 110, 111, 299, 298
2993, 111, 112, 300, 299
2994, 112, 113, 301, 300
2995, 113, 114, 302, 301
2996, 114, 115, 303, 302
2997, 115, 116, 304, 303
2998, 116, 117, 305, 304
2999, 117, 118, 306, 305
3000, 118, 119, 307, 306
3001, 119, 120, 308, 307
3002, 120, 3, 12, 308
*ELEMENT, type=CPS4, ELSET=Surface11
3003, 10, 298, 2587, 241
3004, 298, 299, 2588, 2587
3005, 299, 300, 2589, 2588
3006, 300, 301, 2590, 2589
3007, 301, 302, 2591, 2590
3008, 302, 303, 2592, 2591
3009, 303, 304, 2593, 2592
3010, 304, 305, 2594, 2593
3011, 305, 306, 2595, 2594
3012, 306, 307, 2596, 2595
3013, 307, 308, 2597, 2596
3014, 308, 12, 275, 2597
3015, 241, 2587, 2598, 242
3016, 2587, 2588, 2599, 2598
3017, 2588, 2589, 2600, 2599
3018, 2589, 2590, 2601, 2600
3019, 2590, 2591, 2602, 2601
3020, 2591, 2592, 2603, 2602
3021, 2592, 2593, 2604, 2603
3022, 2593, 2594, 2605, 2604
3023, 2594, 2595, 2606, 2605
3024, 2595, 2596, 2607, 2606
3025, 2596, 2597, 2608, 2607
3026, 2597, 275, 276, 2608
3027, 242, 2598, 2609, 243
3028, 2598, 2599, 2610, 2609
3029, 2599, 2600, 2611, 2610
3030, 2600, 2601, 2612, 2611
3031, 2601, 2602, 2613, 2612
3032, 2602, 2603, 2614, 2613
3033, 2603, 2604, 2615, 2614
3034, 2604, 2605, 2616, 2615
3035, 2605, 2606, 2617, 2616
3036, 2606, 2607, 2618, 2617
3037, 2607, 2608, 2619, 2618
3038, 2608, 276, 277, 2619
3039, 243, 2609, 2620, 244
3040, 2609, 2610, 2621, 2620
3041, 2610, 2611, 2622, 2621
3042, 2611, 2612, 2623, 2622
3043, 2612, 2613, 2624, 2623
3044, 2613, 2614, 2625, 2624
3045, 2614, 2615, 2626, 2625
3046, 2615, 2616, 2627, 2626
3047, 2616, 2617, 2628, 2627
3048, 2617, 2618, 2629, 2628
3049, 2618, 2619, 2630, 2629
3050, 2619, 277, 278, 2630
3051, 244, 2620, 2631, 245
3052, 2620, 2621, 2632, 2631
3053, 2621, 2622, 2633, 2632
3054, 2622, 2623, 2634, 2633
3055, 2623, 2624, 2635, 2634
3056, 2624, 2625, 2636, 2635
3057, 2625, 2626, 2637, 2636
3058, 2626, 2627, 2638, 2637
3059, 2627, 2628, 2639, 2638
3060, 2628, 2629, 2640, 2639
3061, 2629, 2630, 2641, 2640
3062, 2630, 278, 279, 2641
3063, 245, 2631, 2642, 246
3064, 2631, 2632, 2643, 2642
3065, 2632, 2633, 2644, 2643
3066, 2633, 2634, 2645, 2644
3067, 2634, 2635, 2646, 2645
3068, 2635, 2636, 2647, 2646
3069, 2636, 2637, 2648, 2647
3070, 2637, 2638, 2649, 2648
3071, 2638, 2639, 2650, 2649
3072, 2639, 2640, 2651, 2650
3073, 2640, 2641, 2652, 2651
3074, 2641, 279, 280, 2652
3075, 246, 2642, 2653, 247
3076, 2642, 2643, 2654, 2653
3077, 2643, 2644, 2655, 2654
3078, 2644, 2645, 2656, 2655
3079, 2645, 2646, 2657, 2656
3080, 2646, 2647, 2658, 2657
3081, 2647, 2648, 2659, 2658
3082, 2648, 2649, 2660, 2659
3083, 2649, 2650, 2661, 2660
3084, 2650, 2651, 2662, 2661
3085, 2651, 2652, 2663, 2662
3086, 2652, 280, 281, 2663
3087, 247, 2653, 2664, 248
3088, 2653, 2654, 2665, 2664
3089, 2654, 2655, 2666, 2665
3090, 2655, 2656, 2667, 2666
3091, 2656, 2657, 2668, 2667
3092, 2657, 2658, 2669, 2668
3093, 2658, 2659, 2670, 2669
3094, 2659, 2660, 2671, 2670
3095, 2660, 2661, 2672, 2671
3096, 2661, 2662, 2673, 2672
3097, 2662, 2663, 2674, 2673
3098, 2663, 281, 282, 2674
3099, 248, 2664, 2675, 249
3100, 2664, 2665, 2676, 2675
3101, 2665, 2666, 2677, 2676
3102, 2666, 2667, 2678, 2677
3103, 2667, 2668, 2679, 2678
3104, 2668, 2669, 2680, 2679
3105, 2669, 2670, 2681, 2680
3106, 2670, 2671, 2682, 2681
3107, 2671, 2672, 2683, 2682
3108, 2672, 2673, 2684, 2683
3109, 2673, 2674, 2685, 2684
3110, 2674, 282, 283, 2685
3111, 249, 2675, 2686, 250
3112, 2675, 2676, 2687, 2686
3113, 2676, 2677, 2688, 2687
3114, 2677, 2678, 2689, 2688
3115, 2678, 2679, 2690, 2689
3116, 2679, 2680, 2691, 2690
3117, 2680, 2681, 2692, 2691
3118, 2681, 2682, 2693, 2692
3119, 2682, 2683, 2694, 2693
3120, 2683, 2684, 2695, 2694
3121, 2684, 2685, 2696, 2695
3122, 2685, 283, 284, 2696
3123, 250, 2686, 2697, 251
3124, 2686, 2687, 2698, 2697
3125, 2687, 2688, 2699, 2698
3126, 2688, 2689, 2700, 2699
3127, 2689, 2690, 2701, 2700
3128, 2690, 2691, 2702, 2701
3129, 2691, 2692, 2703, 2702
3130, 2692, 2693, 2704, 2703
3131, 2693, 2694, 2705, 2704
3132, 2694, 2695, 2706, 2705
3133, 2695, 2696, 2707, 2706
3134, 2696, 284, 285, 2707
3135, 251, 2697, 2708, 252
3136, 2697, 2698, 2709, 2708
3137, 2698, 2699, 2710, 2709
3138, 2699, 2700, 2711, 2710
3139, 2700, 2701, 2712, 2711
3140, 2701, 2702, 2713, 2712
3141, 2702, 2703, 2714, 2713
3142, 2703, 2704, 2715, 2714
3143, 2704, 2705, 2716, 2715
3144, 2705, 2706, 2717, 2716
3145, 2706, 2707, 2718, 2717
3146, 2707, 285, 286, 2718
3147, 252, 2708, 2719, 253
3148, 2708, 2709, 2720, 2719
3149, 2709, 2710, 2721, 2720
3150, 2710, 2711, 2722, 2721
3151, 2711, 2712, 2723, 2722
3152, 2712, 2713, 2724, 2723
3153, 2713, 2714, 2725, 2724
3154, 2714, 2715, 2726, 2725
3155, 2715, 2716, 2727, 2726
3156, 2716, 2717, 2728, 2727
3157, 2717, 2718, 2729, 2728
3158, 2718, 286, 287, 2729
3159, 253, 2719, 2730, 254
3160, 2719, 2720, 2731, 2730
3161, 2720, 2721, 2732, 2731
3162, 2721, 2722, 2733, 2732
3163, 2722, 2723, 2734, 2733
3164, 2723, 2724, 2735, 2734
3165, 2724, 2725, 2736, 2735
3166, 2725, 2726, 2737, 2736
3167, 2726, 2727, 2738, 2737
3168, 2727, 2728, 2739, 2738
3169, 2728, 2729, 2740, 2739
3170, 2729, 287, 288, 2740
3171, 254, 2730, 2741, 255
3172, 2730, 2731, 2742, 2741
3173, 2731, 2732, 2743, 2742
3174, 2732, 2733, 2744, 2743
3175, 2733, 2734, 2745, 2744
3176, 2734, 2735, 2746, 2745
3177, 2735, 2736, 2747, 2746
3178, 2736, 2737, 2748, 2747
3179, 2737, 2738, 2749, 2748
3180, 2738, 2739, 2750, 2749
3181, 2739, 2740, 2751, 2750
3182, 2740, 288, 289, 2751
3183, 255, 2741, 2752, 256
3184, 2741, 2742, 2753, 2752
3185, 2742, 2743, 2754, 2753
3186, 2743, 2744, 2755, 2754
3187, 2744, 2745, 2756, 2755
3188, 2745, 2746, 2757, 2756
3189, 2746, 2747, 2758, 2757
3190, 2747, 2748, 2759, 2758
3191, 2748, 2749, 2760, 2759
3192, 2749, 2750, 2761, 2760
3193, 2750, 2751, 2762, 2761
3194, 2751, 289, 290, 2762
3195, 256, 2752, 2763, 257
3196, 2752, 2753, 2764, 2763
3197, 2753, 2754, 2765, 2764
3198, 2754, 2755, 2766, 2765
3199, 2755, 2756, 2767, 2766
3200, 2756, 2757, 2768, 2767
3201, 2757, 2758, 2769, 2768
3202, 2758, 2759, 2770, 2769
3203, 2759, 2760, 2771, 2770
3204, 2760, 2761, 2772, 2771
3205, 2761, 2762, 2773, 2772
3206, 2762, 290, 291, 2773
3207, 257, 2763, 2774, 258
3208, 2763, 2764, 2775, 2774
3209, 2764, 2765, 2776, 2775
3210, 2765, 2766, 2777, 2776
3211, 2766, 2767, 2778, 2777
3212, 2767, 2768, 2779, 2778
3213, 2768, 2769, 2780, 2779
3214, 2769, 2770, 2781, 2780
3215, 2770, 2771, 2782, 2781
3216, 2771, 2772, 2783, 2782
3217, 2772, 2773, 2784, 2783
3218, 2773, 291, 292, 2784
3219, 258, 2774, 2785, 259
3220, 2774, 2775, 2786, 2785
3221, 2775, 2776, 2787, 2786
3222, 2776, 2777, 2788, 2787
3223, 2777, 2778, 2789, 2788
3224, 2778, 2779, 2790, 2789
3225, 2779, 2780, 2791, 2790
3226, 2780, 2781, 2792, 2791
3227, 2781, 2782, 2793, 2792
3228, 2782, 2783, 2794, 2793
3229, 2783, 2784, 2795, 2794
3230, 2784, 292, 293, 2795
3231, 259, 2785, 2796, 260
3232, 2785, 2786, 2797, 2796
3233, 2786, 2787, 2798, 2797
3234, 2787, 2788, 2799, 2798
3235, 2788, 2789, 2800, 2799
3236, 2789, 2790, 2801, 2800
3237, 2790, 2791, 2802, 2801
3238, 2791, 2792, 2803, 2802
3239, 2792, 2793, 2804, 2803
3240, 2793, 2794, 2805, 2804
3241, 2794, 2795, 2806, 2805
3242, 2795, 293, 294, 2806
3243, 260, 2796, 2807, 261
3244, 2796, 2797, 2808, 2807
3245, 2797, 2798, 2809, 2808
3246, 2798, 2799, 2810, 2809
3247, 2799, 2800, 2811, 2810
3248, 2800, 2801, 2812, 2811
3249, 2801, 2802, 2813, 2812
3250, 2802, 2803, 2814, 2813
3251, 2803, 2804, 2815, 2814
3252, 2804, 2805, 2816, 2815
3253, 2805, 2806, 2817, 2816
3254, 2806, 294, 295, 2817
3255, 261, 2807, 2818, 262
3256, 2807, 2808, 2819, 2818
3257, 2808, 2809, 2820, 2819
3258, 2809, 2810, 2821, 2820
3259, 2810, 2811, 2822, 2821
3260, 2811, 2812, 2823, 2822
3261, 2812, 2813, 2824, 2823
3262, 2813, 2814, 2825, 2824
3263, 2814, 2815, 2826, 2825
3264, 2815, 2816, 2827, 2826
3265, 2816, 2817, 2828, 2827
3266, 2817, 295, 296, 2828
3267, 262, 2818, 2829, 263
3268, 2818, 2819, 2830, 2829
3269, 2819, 2820, 2831, 2830
3270, 2820, 2821, 2832, 2831
3271, 2821, 2822, 2833, 2832
3272, 2822, 2823, 2834, 2833
3273, 2823, 2824, 2835, 2834
3274, 2824, 2825, 2836, 2835
3275, 2825, 2826, 2837, 2836
3276, 2826, 2827, 2838, 2837
3277, 2827, 2828, 2839, 2838
3278, 2828, 296, 297, 2839
3279, 263, 2829, 264, 9
3280, 2829, 2830, 265, 264
3281, 2830, 2831, 266, 265
3282, 2831, 2832, 267, 266
3283, 2832, 2833, 268, 267
3284, 2833, 2834, 269, 268
3285, 2834, 2835, 270, 269
3286, 2835, 2836, 271, 270
3287, 2836, 2837, 272, 271
3288, 2837, 2838, 273, 272
3289, 2838, 2839, 274, 273
3290, 2839, 297, 11, 274
*ELEMENT, type=CPS4, ELSET=Surface12
3291, 10, 332, 2840, 241
3292, 332, 333, 2841, 2840
3293, 333, 334, 2842, 2841
3294, 334, 335, 2843, 2842
3295, 335, 336, 2844, 2843
3296, 336, 337, 2845, 2844
3297, 337, 338, 2846, 2845
3298, 338, 339, 2847, 2846
3299, 339, 340, 2848, 2847
3300, 340, 341, 2849, 2848
3301, 341, 342, 2850, 2849
3302, 342, 343, 2851, 2850
3303, 343, 344, 2852, 2851
3304, 344, 345, 2853, 2852
3305, 345, 346, 2854, 2853
3306, 346, 347, 2855, 2854
3307, 347, 348, 2856, 2855
3308, 348, 349, 2857, 2856
3309, 349, 350, 2858, 2857
3310, 350, 351, 2859, 2858
3311, 351, 352, 2860, 2859
3312, 352, 353, 2861, 2860
3313, 353, 354, 2862, 2861
3314, 354, 14, 355, 2862
3315, 241, 2840, 2863, 242
3316, 2840, 2841, 2864, 2863
3317, 2841, 2842, 2865, 2864
3318, 2842, 2843, 2866, 2865
3319, 2843, 2844, 2867, 2866
3320, 2844, 2845, 2868, 2867
3321, 2845, 2846, 2869, 2868
3322, 2846, 2847, 2870, 2869
3323, 2847, 2848, 2871, 2870
3324, 2848, 2849, 2872, 2871
3325, 2849, 2850, 2873, 2872
3326, 2850, 2851, 2874, 2873
3327, 2851, 2852, 2875, 2874
3328, 2852, 2853, 2876, 2875
3329, 2853, 2854, 2877, 2876
3330, 2854, 2855, 2878, 2877
3331, 2855, 2856, 2879, 2878
3332, 2856, 2857, 2880, 2879
3333, 2857, 2858, 2881, 2880
3334, 2858, 2859, 2882, 2881
3335, 2859, 2860, 2883, 2882
3336, 2860, 2861, 2884, 2883
3337, 2861, 2862, 2885, 2884
3338, 2862, 355, 356, 2885
3339, 242, 2863, 2886, 243
3340, 2863, 2864, 2887, 2886
3341, 2864, 2865, 2888, 2887
3342, 2865, 2866, 2889, 2888
3343, 2866, 2867, 2890, 2889
3344, 2867, 2868, 2891, 2890
3345, 2868, 2869, 2892, 2891
3346, 2869, 2870, 2893, 2892
3347, 2870, 2871, 2894, 2893
3348, 2871, 2872, 2895, 2894
3349, 2872, 2873, 2896, 2895
3350, 2873, 2874, 2897, 2896
3351, 2874, 2875, 2898, 2897
3352, 2875, 2876, 2899, 2898
3353, 2876, 2877, 2900, 2899
3354, 2877, 2878, 2901, 2900
3355, 2878, 2879, 2902, 2901
3356, 2879, 2880, 2903, 2902
3357, 2880, 2881, 2904, 2903
3358, 2881, 2882, 2905, 2904
3359, 2882, 2883, 2906, 2905
3360, 2883, 2884, 2907, 2906
3361, 2884, 2885, 2908, 2907
3362, 2885, 356, 357, 2908
3363, 243, 2886, 2909, 244
3364, 2886, 2887, 2910, 2909
3365, 2887, 2888, 2911, 2910
3366, 2888, 2889, 2912, 2911
3367, 2889, 2890, 2913, 2912
3368, 2890, 2891, 2914, 2913
3369, 2891, 2892, 2915, 2914
3370, 2892, 2893, 2916, 2915
3371, 2893, 2894, 2917, 2916
3372, 2894, 2895, 2918, 2917
3373, 2895, 2896, 2919, 2918
3374, 2896, 2897, 2920, 2919
3375, 2897, 2898, 2921, 2920
3376, 2898, 2899, 2922, 2921
3377, 2899, 2900, 2923, 2922
3378, 2900, 2901, 2924, 2923
3379, 2901, 2902, 2925, 2924
3380, 2902, 2903, 2926, 2925
3381, 2903, 2904, 2927, 2926
3382, 2904, 2905, 2928, 2927
3383, 2905, 2906, 2929, 2928
3384, 2906, 2907, 2930, 2929
3385, 2907, 2908, 2931, 2930
3386, 2908, 357, 358, 2931
3387, 244, 2909, 2932, 245
3388, 2909, 2910, 2933, 2932
3389, 2910, 2911, 2934, 2933
3390, 2911, 2912, 2935, 2934
3391, 2912, 2913, 2936, 2935
3392, 2913, 2914, 2937, 2936
3393, 2914, 2915, 2938, 2937
3394, 2915, 2916, 2939, 2938
3395, 2916, 2917, 2940, 2939
3396, 2917, 2918, 2941, 2940
3397, 2918, 2919, 2942, 2941
3398, 2919, 2920, 2943, 2942
3399, 2920, 2921, 2944, 2943
3400, 2921, 2922, 2945, 2944
3401, 2922, 2923, 2946, 2945
3402, 2923, 2924, 2947, 2946
3403, 2924, 2925, 2948, 2947
3404, 2925, 2926, 2949, 2948
3405, 2926, 2927, 2950, 2949
3406, 2927, 2928, 2951, 2950
3407, 2928, 2929, 2952, 2951
3408, 2929, 2930, 2953, 2952
3409, 2930, 2931, 2954, 2953
3410, 2931, 358, 359, 2954
3411, 245, 2932, 2955, 246
3412, 2932, 2933, 2956, 2955
3413, 2933, 2934, 2957, 2956
3414, 2934, 2935, 2958, 2957
3415, 2935, 2936, 2959, 2958
3416, 2936, 2937, 2960, 2959
3417, 2937, 2938, 2961, 2960
3418, 2938, 2939, 2962, 2961
3419, 2939, 2940, 2963, 2962
3420, 2940, 2941, 2964, 2963
3421, 2941, 2942, 2965, 2964
3422, 2942, 2943, 2966, 2965
3423, 2943, 2944, 2967, 2966
3424, 2944, 2945, 2968, 2967
3425, 2945, 2946, 2969, 2968
3426, 2946, 2947, 2970, 2969
3427, 2947, 2948, 2971, 2970
3428, 2948, 2949, 2972, 2971
3429, 2949, 2950, 2973, 2972
3430, 2950, 2951, 2974, 2973
3431, 2951, 2952, 2975, 2974
3432, 2952, 2953, 2976, 2975
3433, 2953, 2954, 2977, 2976
3434, 2954, 359, 360, 2977
3435, 246, 2955, 2978, 247
3436, 2955, 2956, 2979, 2978
3437, 2956, 2957, 2980, 2979
3438, 2957, 2958, 2981, 2980
3439, 2958, 2959, 2982, 2981
3440, 2959, 2960, 2983, 2982
3441, 2960, 2961, 2984, 2983
3442, 2961, 2962, 2985, 2984
3443, 2962, 2963, 2986, 2985
3444, 2963, 2964, 2987, 2986
3445, 2964, 2965, 2988, 2987
3446, 2965, 2966, 2989, 2988
3447, 2966, 2967, 2990, 2989
3448, 2967, 2968, 2991, 2990
3449, 2968, 2969, 2992, 2991
3450, 2969, 2970, 2993, 2992
3451, 2970, 2971, 2994, 2993
3452, 2971, 2972, 2995, 2994
3453, 2972, 2973, 2996, 2995
3454, 2973, 2974, 2997, 2996
3455, 2974, 2975, 2998, 2997
3456, 2975, 2976, 2999, 2998
3457, 2976, 2977, 3000, 2999
3458, 2977, 360, 361, 3000
3459, 247, 2978, 3001, 248
3460, 2978, 2979, 3002, 3001
3461, 2979, 2980, 3003, 3002
3462, 2980, 2981, 3004, 3003
3463, 2981, 2982, 3005, 3004
3464, 2982, 2983, 3006, 3005
3465, 2983, 2984, 3007, 3006
3466, 2984, 2985, 3008, 3007
3467, 2985, 2986, 3009, 3008
3468, 2986, 2987, 3010, 3009
3469, 2987, 2988, 3011, 3010
3470, 2988, 2989, 3012, 3011
3471, 2989, 2990, 3013, 3012
3472, 2990, 2991, 3014, 3013
3473, 2991, 2992, 3015, 3014
3474, 2992, 2993, 3016, 3015
3475, 2993, 2994, 3017, 3016
3476, 2994, 2995, 3018, 3017
3477, 2995, 2996, 3019, 3018
3478, 2996, 2997, 3020, 3019
3479, 2997, 2998, 3021, 3020
3480, 2998, 2999, 3022, 3021
3481, 2999, 3000, 3023, 3022
3482, 3000, 361, 362, 3023
3483, 248, 3001, 3024, 249
3484, 3001, 3002, 3025, 3024
3485, 3002, 3003, 3026, 3025
3486, 3003, 3004, 3027, 3026
3487, 3004, 3005, 3028, 3027
3488, 3005, 3006, 3029, 3028
3489, 3006, 3007, 3030, 3029
3490, 3007, 3008, 3031, 3030
3491, 3008, 3009, 3032, 3031
3492, 3009, 3010, 3033, 3032
3493, 3010, 3011, 3034, 3033
3494, 3011, 3012, 3035, 3034
3495, 3012, 3013, 3036, 3035
3496, 3013, 3014, 3037, 3036
3497, 3014, 3015, 3038, 3037
3498, 3015, 3016, 3039, 3038
3499, 3016, 3017, 3040, 3039
3500, 3017, 3018, 3041, 3040
3501, 3018, 3019, 3042, 3041
3502, 3019, 3020, 3043, 3042
3503, 3020, 3021, 3044, 3043
3504, 3021, 3022, 3045, 3044
3505, 3022, 3023, 3046, 3045
3506, 3023, 362, 363, 3046
3507, 249, 3024, 3047, 250
3508, 3024, 3025, 3048, 3047
3509, 3025, 3026, 3049, 3048
3510, 3026, 3027, 3050, 3049
3511, 3027, 3028, 3051, 3050
3512, 3028, 3029, 3052, 3051
3513, 3029, 3030, 3053, 3052
3514, 3030, 3031, 3054, 3053
3515, 3031, 3032, 3055, 3054
3516, 3032, 3033, 3056, 3055
3517, 3033, 3034, 3057, 3056
3518, 3034, 3035, 3058, 3057
3519, 3035, 3036, 3059, 3058
3520, 3036, 3037, 3060, 3059
3521, 3037, 3038, 3061, 3060
3522, 3038, 3039, 3062, 3061
3523, 3039, 3040, 3063, 3062
3524, 3040, 3041, 3064, 3063
3525, 3041, 3042, 3065, 3064
3526, 3042, 3043, 3066, 3065
3527, 3043, 3044, 3067, 3066
3528, 3044, 3045, 3068, 3067
3529, 3045, 3046, 3069, 3068
3530, 3046, 363, 364, 3069
3531, 250, 3047, 3070, 251
3532, 3047, 3048, 3071, 3070
3533, 3048, 3049, 3072, 3071
3534, 3049, 3050, 3073, 3072
3535, 3050, 3051, 3074, 3073
3536, 3051, 3052, 3075, 3074
3537, 3052, 3053, 3076, 3075
3538, 3053, 3054, 3077, 3076
3539, 3054, 3055, 3078, 3077
3540, 3055, 3056, 3079, 3078
3541, 3056, 3057, 3080, 3079
3542, 3057, 3058, 3081, 3080
3543, 3058, 3059, 3082, 3081
3544, 3059, 3060, 3083, 3082
3545, 3060, 3061, 3084, 3083
3546, 3061, 3062, 3085, 3084
3547, 3062, 3063, 3086, 3085
3548, 3063, 3064, 3087, 3086
3549, 3064, 3065, 3088, 3087
3550, 3065, 3066, 3089, 3088
3551, 3066, 3067, 3090, 3089
3552, 3067, 3068, 3091, 3090
3553, 3068, 3069, 3092, 3091
3554, 3069, 364, 365, 3092
3555, 251, 3070, 3093, 252
3556, 3070, 3071, 3094, 3093
3557, 3071, 3072, 3095, 3094
3558, 3072, 3073, 3096, 3095
3559, 3073, 3074, 3097, 3096
3560, 3074, 3075, 3098, 3097
3561, 3075, 3076, 3099, 3098
3562, 3076, 3077, 3100, 3099
3563, 3077, 3078, 3101, 3100
3564, 3078, 3079, 3102, 3101
3565, 3079, 3080, 3103, 3102
3566, 3080, 3081, 3104, 3103
3567, 3081, 3082, 3105, 3104
3568, 3082, 3083, 3106, 3105
3569, 3083, 3084, 3107, 3106
3570, 3084, 3085, 3108, 3107
3571, 3085, 3086, 3109, 3108
3572, 3086, 3087, 3110, 3109
3573, 3087, 3088, 3111, 3110
3574, 3088, 3089, 3112, 3111
3575, 3089, 3090, 3113, 3112
3576, 3090, 3091, 3114, 3113
3577, 3091, 3092, 3115, 3114
3578, 3092, 365, 366, 3115
3579, 252, 3093, 3116, 253
3580, 3093, 3094, 3117, 3116
3581, 3094, 3095, 3118, 3117
3582, 3095, 3096, 3119, 3118
3583, 3096, 3097, 3120, 3119
3584, 3097, 3098, 3121, 3120
3585, 3098, 3099, 3122, 3121
3586, 3099, 3100, 3123, 3122
3587, 3100, 3101, 3124, 3123
3588, 3101, 3102, 3125, 3124
3589, 3102, 3103, 3126, 3125
3590, 3103, 3104, 3127, 3126
3591, 3104, 3105, 3128, 3127
3592, 3105, 3106, 3129, 3128
3593, 3106, 3107, 3130, 3129
3594, 3107, 3108, 3131, 3130
3595, 3108, 3109, 3132, 3131
3596, 3109, 3110, 3133, 3132
3597, 3110, 3111, 3134, 3133
3598, 3111, 3112, 3135, 3134
3599, 3112, 3113, 3136, 3135
3600, 3113, 3114, 3137, 3136
3601, 3114, 3115, 3138, 3137
3602, 3115, 366, 367, 3138
3603, 253, 3116, 3139, 254
3604, 3116, 3117, 3140, 3139
3605, 3117, 3118, 3141, 3140
3606, 3118, 3119, 3142, 3141
3607, 3119, 3120, 3143, 3142
3608, 3120, 3121, 3144, 3143
3609, 3121, 3122, 3145, 3144
3610, 3122, 3123, 3146, 3145
3611, 3123, 3124, 3147, 3146
3612, 3124, 3125, 3148, 3147
3613, 3125, 3126, 3149, 3148
3614, 3126, 3127, 3150, 3149
3615, 3127, 3128, 3151, 3150
3616, 3128, 3129, 3152, 3151
3617, 3129, 3130, 3153, 3152
3618, 3130, 3131, 3154, 3153
3619, 3131, 3132, 3155, 3154
3620, 3132, 3133, 3156, 3155
3621, 3133, 3134, 3157, 3156
3622, 3134, 3135, 3158, 3157
3623, 3135, 3136, 3159, 3158
3624, 3136, 3137, 3160, 3159
3625, 3137, 3138, 3161, 3160
3626, 3138, 367, 368, 3161
3627, 254, 3139, 3162, 255
3628, 3139, 3140, 3163, 3162
3629, 3140, 3141, 3164, 3163
3630, 3141, 3142, 3165, 3164
3631, 3142, 3143, 3166, 3165
3632, 3143, 3144, 3167, 3166
3633, 3144, 3145, 3168, 3167
3634, 3145, 3146, 3169, 3168
3635, 3146, 3147, 3170, 3169
3636, 3147, 3148, 3171, 3170
3637, 3148, 3149, 3172, 3171
3638, 3149, 3150, 3173, 3172
3639, 3150, 3151, 3174, 3173
3640, 3151, 3152, 3175, 3174
3641, 3152, 3153, 3176, 3175
3642, 3153, 3154, 3177, 3176
3643, 3154, 3155, 3178, 3177
3644, 3155, 3156, 3179, 3178
3645, 3156, 3157, 3180, 3179
3646, 3157, 3158, 3181, 3180
3647, 3158, 3159, 3182, 3181
3648, 3159, 3160, 3183, 3182
3649, 3160, 3161, 3184, 3183
3650, 3161, 368, 369, 3184
3651, 255, 3162, 3185, 256
3652, 3162, 3163, 3186, 3185
3653, 3163, 3164, 3187, 3186
3654, 3164, 3165, 3188, 3187
3655, 3165, 3166, 3189, 3188
3656, 3166, 3167, 3190, 3189
3657, 3167, 3168, 3191, 3190
3658, 3168, 3169, 3192, 3191
3659, 3169, 3170, 3193, 3192
3660, 3170, 3171, 3194, 3193
3661, 3171, 3172, 3195, 3194
3662, 3172, 3173, 3196, 3195
3663, 3173, 3174, 3197, 3196
3664, 3174, 3175, 3198, 3197
3665, 3175, 3176, 3199, 3198
3666, 3176, 3177, 3200, 3199
3667, 3177, 3178, 3201, 3200
3668, 3178, 3179, 3202, 3201
3669, 3179, 3180, 3203, 3202
3670, 3180, 3181, 3204, 3203
3671, 3181, 3182, 3205, 3204
3672, 3182, 3183, 3206, 3205
3673, 3183, 3184, 3207, 3206
3674, 3184, 369, 370, 3207
3675, 256, 3185, 3208, 257
3676, 3185, 3186, 3209, 3208
3677, 3186, 3187, 3210, 3209
3678, 3187, 3188, 3211, 3210
3679, 3188, 3189, 3212, 3211
3680, 3189, 3190, 3213, 3212
3681, 3190, 3191, 3214, 3213
3682, 3191, 3192, 3215, 3214
3683, 3192, 3193, 3216, 3215
3684, 3193, 3194, 3217, 3216
3685, 3194, 3195, 3218, 3217
3686, 3195, 3196, 3219, 3218
3687, 3196, 3197, 3220, 3219
3688, 3197, 3198, 3221, 3220
3689, 3198, 3199, 3222, 3221
3690, 3199, 3200, 3223, 3222
3691, 3200, 3201, 3224, 3223
3692, 3201, 3202, 3225, 3224
3693, 3202, 3203, 3226, 3225
3694, 3203, 3204, 3227, 3226
3695, 3204, 3205, 3228, 3227
3696, 3205, 3206, 3229, 3228
3697, 3206, 3207, 3230, 3229
3698, 3207, 370, 371, 3230
3699, 257, 3208, 3231, 258
3700, 3208, 3209, 3232, 3231
3701, 3209, 3210, 3233, 3232
3702, 3210, 3211, 3234, 3233
3703, 3211, 3212, 3235, 3234
3704, 3212, 3213, 3236, 3235
3705, 3213, 3214, 3237, 3236
3706, 3214, 3215, 3238, 3237
3707, 3215, 3216, 3239, 3238
3708, 3216, 3217, 3240, 3239
3709, 3217, 3218, 3241, 3240
3710, 3218, 3219, 3242, 3241
3711, 3219, 3220, 3243, 3242
3712, 3220, 3221, 3244, 3243
3713, 3221, 3222, 3245, 3244
3714, 3222, 3223, 3246, 3245
3715, 3223, 3224, 3247, 3246
3716, 3224, 3225, 3248, 3247
3717, 3225, 3226, 3249, 3248
3718, 3226, 3227, 3250, 3249
3719, 3227, 3228, 3251, 3250
3720, 3228, 3229, 3252, 3251
3721, 3229, 3230, 3253, 3252
3722, 3230, 371, 372, 3253
3723, 258, 3231, 3254, 259
3724, 3231, 3232, 3255, 3254
3725, 3232, 3233, 3256, 3255
3726, 3233, 3234, 3257, 3256
3727, 3234, 3235, 3258, 3257
3728, 3235, 3236, 3259, 3258
3729, 3236, 3237, 3260, 3259
3730, 3237, 3238, 3261, 3260
3731, 3238, 3239, 3262, 3261
3732, 3239, 3240, 3263, 3262
3733, 3240, 3241, 3264, 3263
3734, 3241, 3242, 3265, 3264
3735, 3242, 3243, 3266, 3265
3736, 3243, 3244, 3267, 3266
3737, 3244, 3245, 3268, 3267
3738, 3245, 3246, 3269, 3268
3739, 3246, 3247, 3270, 3269
3740, 3247, 3248, 3271, 3270
3741, 3248, 3249, 3272, 3271
3742, 3249, 3250, 3273, 3272
3743, 3250, 3251, 3274, 3273
3744, 3251, 3252, 3275, 3274
3745, 3252, 3253, 3276, 3275
3746, 3253, 372, 373, 3276
3747, 259, 3254, 3277, 260
3748, 3254, 3255, 3278, 3277
3749, 3255, 3256, 3279, 3278
3750, 3256, 3257, 3280, 3279
3751, 3257, 3258, 3281, 3280
3752, 3258, 3259, 3282, 3281
3753, 3259, 3260, 3283, 3282
3754, 3260, 3261, 3284, 3283
3755, 3261, 3262, 3285, 3284
3756, 3262, 3263, 3286, 3285
3757, 3263, 3264, 3287, 3286
3758, 3264, 3265, 3288, 3287
3759, 3265, 3266, 3289, 3288
3760, 3266, 3267, 3290, 3289
3761, 3267, 3268, 3291, 3290
3762, 3268, 3269, 3292, 3291
3763, 3269, 3270, 3293, 3292
3764, 3270, 3271, 3294, 3293
3765, 3271, 3272, 3295, 3294
3766, 3272, 3273, 3296, 3295
3767, 3273, 3274, 3297, 3296
3768, 3274, 3275, 3298, 3297
3769, 3275, 3276, 3299, 3298
3770, 3276, 373, 374, 3299
3771, 260, 3277, 3300, 261
3772, 3277, 3278, 3301, 3300
3773, 3278, 3279, 3302, 3301
3774, 3279, 3280, 3303, 3302
3775, 3280, 3281, 3304, 3303
3776, 3281, 3282, 3305, 3304
3777, 3282, 3283, 3306, 3305
3778, 3283, 3284, 3307, 3306
3779, 3284, 3285, 3308, 3307
3780, 3285, 3286, 3309, 3308
3781, 3286, 3287, 3310, 3309
3782, 3287, 3288, 3311, 3310
3783, 3288, 3289, 3312, 3311
3784, 3289, 3290, 3313, 3312
3785, 3290, 3291, 3314, 3313
3786, 3291, 3292, 3315, 3314
3787, 3292, 3293, 3316, 3315
3788, 3293, 3294, 3317, 3316
3789, 3294, 3295, 3318, 3317
3790, 3295, 3296, 3319, 3318
3791, 3296, 3297, 3320, 3319
3792, 3297, 3298, 3321, 3320
3793, 3298, 3299, 3322, 3321
3794, 3299, 374, 375, 3322
3795, 261, 3300, 3323, 262
3796, 3300, 3301, 3324, 3323
3797, 3301, 3302, 3325, 3324
3798, 3302, 3303, 3326, 3325
3799, 3303, 3304, 3327, 3326
3800, 3304, 3305, 3328, 3327
3801, 3305, 3306, 3329, 3328
3802, 3306, 3307, 3330, 3329
3803, 3307, 3308, 3331, 3330
3804, 3308, 3309, 3332, 3331
3805, 3309, 3310, 3333, 3332
3806, 3310, 3311, 3334, 3333
3807, 3311, 3312, 3335, 3334
3808, 3312, 3313, 3336, 3335
3809, 3313, 3314, 3337, 3336
3810, 3314, 3315, 3338, 3337
3811, 3315, 3316, 3339, 3338
3812, 3316, 3317, 3340, 3339
3813, 3317, 3318, 3341, 3340
3814, 3318, 3319, 3342, 3341
3815, 3319, 3320, 3343, 3342
3816, 3320, 3321, 3344, 3343
3817, 3321, 3322, 3345, 3344
3818, 3322, 375, 376, 3345
3819, 262, 3323, 3346, 263
3820, 3323, 3324, 3347, 3346
3821, 3324, 3325, 3348, 3347
3822, 3325, 3326, 3349, 3348
3823, 3326, 3327, 3350, 3349
3824, 3327, 3328, 3351, 3350
3825, 3328, 3329, 3352, 3351
3826, 3329, 3330, 3353, 3352
3827, 3330, 3331, 3354, 3353
3828, 3331, 3332, 3355, 3354
3829, 3332, 3333, 3356, 3355
3830, 3333, 3334, 3357, 3356
3831, 3334, 3335, 3358, 3357
3832, 3335, 3336, 3359, 3358
3833, 3336, 3337, 3360, 3359
3834, 3337, 3338, 3361, 3360
3835, 3338, 3339, 3362, 3361
3836, 3339, 3340, 3363, 3362
3837, 3340, 3341, 3364, 3363
3838, 3341, 3342, 3365, 3364
3839, 3342, 3343, 3366, 3365
3840, 3343, 3344, 3367, 3366
3841, 3344, 3345, 3368, 3367
3842, 3345, 376, 377, 3368
3843, 263, 3346, 309, 9
3844, 3346, 3347, 310, 309
3845, 3347, 3348, 311, 310
3846, 3348, 3349, 312, 311
3847, 3349, 3350, 313, 312
3848, 3350, 3351, 314, 313
3849, 3351, 3352, 315, 314
3850, 3352, 3353, 316, 315
3851, 3353, 3354, 317, 316
3852, 3354, 3355, 318, 317
3853, 3355, 3356, 319, 318
3854, 3356, 3357, 320, 319
3855, 3357, 3358, 321, 320
3856, 3358, 3359, 322, 321
3857, 3359, 3360, 323, 322
3858, 3360, 3361, 324, 323
3859, 3361, 3362, 325, 324
3860, 3362, 3363, 326, 325
3861, 3363, 3364, 327, 326
3862, 3364, 3365, 328, 327
3863, 3365, 3366, 329, 328
3864, 3366, 3367, 330, 329
3865, 3367, 3368, 331, 330
3866, 3368, 377, 13, 331
*ELEMENT, type=CPS4, ELSET=Surface13
3867, 9, 309, 3369, 264
3868, 309, 310, 3370, 3369
3869, 310, 311, 3371, 3370
3870, 311, 312, 3372, 3371
3871, 312, 313, 3373, 3372
3872, 313, 314, 3374, 3373
3873, 314, 315, 3375, 3374
3874, 315, 316, 3376, 3375
3875, 316, 317, 3377, 3376
3876, 317, 318, 3378, 3377
3877, 318, 319, 3379, 3378
3878, 319, 320, 3380, 3379
3879, 320, 321, 3381, 3380
3880, 321, 322, 3382, 3381
3881, 322, 323, 3383, 3382
3882, 323, 324, 3384, 3383
3883, 324, 325, 3385, 3384
3884, 325, 326, 3386, 3385
3885, 326, 327, 3387, 3386
3886, 327, 328, 3388, 3387
3887, 328, 329, 3389, 3388
3888, 329, 330, 3390, 3389
3889, 330, 331, 3391, 3390
3890, 331, 13, 401, 3391
3891, 264, 3369, 3392, 265
3892, 3369, 3370, 3393, 3392
3893, 3370, 3371, 3394, 3393
3894, 3371, 3372, 3395, 3394
3895, 3372, 3373, 3396, 3395
3896, 3373, 3374, 3397, 3396
3897, 3374, 3375, 3398, 3397
3898, 3375, 3376, 3399, 3398
3899, 3376, 3377, 3400, 3399
3900, 3377, 3378, 3401, 3400
3901, 3378, 3379, 3402, 3401
3902, 3379, 3380, 3403, 3402
3903, 3380, 3381, 3404, 3403
3904, 3381, 3382, 3405, 3404
3905, 3382, 3383, 3406, 3405
3906, 3383, 3384, 3407, 3406
3907, 3384, 3385, 3408, 3407
3908, 3385, 3386, 3409, 3408
3909, 3386, 3387, 3410, 3409
3910, 3387, 3388, 3411, 3410
3911, 3388, 3389, 3412, 3411
3912, 3389, 3390, 3413, 3412
3913, 3390, 3391, 3414, 3413
3914, 3391, 401, 402, 3414
3915, 265, 3392, 3415, 266
3916, 3392, 3393, 3416, 3415
3917, 3393, 3394, 3417, 3416
3918, 3394, 3395, 3418, 3417
3919, 3395, 3396, 3419, 3418
3920, 3396, 3397, 3420, 3419
3921, 3397, 3398, 3421, 3420
3922, 3398, 3399, 3422, 3421
3923, 3399, 3400, 3423, 3422
3924, 3400, 3401, 3424, 3423
3925, 3401, 3402, 3425, 3424
3926, 3402, 3403, 3426, 3425
3927, 3403, 3404, 3427, 3426
3928, 3404, 3405, 3428, 3427
3929, 3405, 3406, 3429, 3428
3930, 3406, 3407, 3430, 3429
3931, 3407, 3408, 3431, 3430
3932, 3408, 3409, 3432, 3431
3933, 3409, 3410, 3433, 3432
3934, 3410, 3411, 3434, 3433
3935, 3411, 3412, 3435, 3434
3936, 3412, 3413, 3436, 3435
3937, 3413, 3414, 3437, 3436
3938, 3414, 402, 403, 3437
3939, 266, 3415, 3438, 267
3940, 3415, 3416, 3439, 3438
3941, 3416, 3417, 3440, 3439
3942, 3417, 3418, 3441, 3440
3943, 3418, 3419, 3442, 3441
3944, 3419, 3420, 3443, 3442
3945, 3420, 3421, 3444, 3443
3946, 3421, 3422, 3445, 3444
3947, 3422, 3423, 3446, 3445
3948, 3423, 3424, 3447, 3446
3949, 3424, 3425, 3448, 3447
3950, 3425, 3426, 3449, 3448
3951, 3426, 3427, 3450, 3449
3952, 3427, 3428, 3451, 3450
3953, 3428, 3429, 3452, 3451
3954, 3429, 3430, 3453, 3452
3955, 3430, 3431, 3454, 3453
3956, 3431, 3432, 3455, 3454
3957, 3432, 3433, 3456, 3455
3958, 3433, 3434, 3457, 3456
3959, 3434, 3435, 3458, 3457
3960, 3435, 3436, 3459, 3458
3961, 3436, 3437, 3460, 3459
3962, 3437, 403, 404, 3460
3963, 267, 3438, 3461, 268
3964, 3438, 3439, 3462, 3461
3965, 3439, 3440, 3463, 3462
3966, 3440, 3441, 3464, 3463
3967, 3441, 3442, 3465, 3464
3968, 3442, 3443, 3466, 3465
3969, 3443, 3444, 3467, 3466
3970, 3444, 3445, 3468, 3467
3971, 3445, 3446, 3469, 3468
3972, 3446, 3447, 3470, 3469
3973, 3447, 3448, 3471, 3470
3974, 3448, 3449, 3472, 3471
3975, 3449, 3450, 3473, 3472
3976, 3450, 3451, 3474, 3473
3977, 3451, 3452, 3475, 3474
3978, 3452, 3453, 3476, 3475
3979, 3453, 3454, 3477, 3476
3980, 3454, 3455, 3478, 3477
3981, 3455, 3456, 3479, 3478
3982, 3456, 3457, 3480, 3479
3983, 3457, 3458, 3481, 3480
3984, 3458, 3459, 3482, 3481
3985, 3459, 3460, 3483, 3482
3986, 3460, 404, 405, 3483
3987, 268, 3461, 3484, 269
3988, 3461, 3462, 3485, 3484
3989, 3462, 3463, 3486, 3485
3990, 3463, 3464, 3487, 3486
3991, 3464, 3465, 3488, 3487
3992, 3465, 3466, 3489, 3488
3993, 3466, 3467, 3490, 3489
3994, 3467, 3468, 3491, 3490
3995, 3468, 3469, 3492, 3491
3996, 3469, 3470, 3493, 3492
3997, 3470, 3471, 3494, 3493
3998, 3471, 3472, 3495, 3494
3999, 3472, 3473, 3496, 3495
4000, 3473, 3474, 3497, 3496
4001, 3474, 3475, 3498, 3497
4002, 3475, 3476, 3499, 3498
4003, 3476, 3477, 3500, 3499
4004, 3477, 3478, 3501, 3500
4005, 3478, 3479, 3502, 3501
4006, 3479, 3480, 3503, 3502
4007, 3480, 3481, 3504, 3503
4008, 3481, 3482, 3505, 3504
4009, 3482, 3483, 3506, 3505
4010, 3483, 405, 406, 3506
4011, 269, 3484, 3507, 270
4012, 3484, 3485, 3508, 3507
4013, 3485, 3486, 3509, 3508
4014, 3486, 3487, 3510, 3509
4015, 3487, 3488, 3511, 3510
4016, 3488, 3489, 3512, 3511
4017, 3489, 3490, 3513, 3512
4018, 3490, 3491, 3514, 3513
4019, 3491, 3492, 3515, 3514
4020, 3492, 3493, 3516, 3515
4021, 3493, 3494, 3517, 3516
4022, 3494, 3495, 3518, 3517
4023, 3495, 3496, 3519, 3518
4024, 3496, 3497, 3520, 3519
4025, 3497, 3498, 3521, 3520
4026, 3498, 3499, 3522, 3521
4027, 3499, 3500, 3523, 3522
4028, 3500, 3501, 3524, 3523
4029, 3501, 3502, 3525, 3524
4030, 3502, 3503, 3526, 3525
4031, 3503, 3504, 3527, 3526
4032, 3504, 3505, 3528, 3527
4033, 3505, 3506, 3529, 3528
4034, 3506, 406, 407, 3529
4035, 270, 3507, 3530, 271
4036, 3507, 3508, 3531, 3530
4037, 3508, 3509, 3532, 3531
4038, 3509, 3510, 3533, 3532
4039, 3510, 3511, 3534, 3533
4040, 3511, 3512, 3535, 3534
4041, 3512, 3513, 3536, 3535
4042, 3513, 3514, 3537, 3536
4043, 3514, 3515, 3538, 3537
4044, 3515, 3516, 3539, 3538
4045, 3516, 3517, 3540, 3539
4046, 3517, 3518, 3541, 3540
4047, 3518, 3519, 3542, 3541
4048, 3519, 3520, 3543, 3542
4049, 3520, 3521, 3544, 3543
4050, 3521, 3522, 3545, 3544
4051, 3522, 3523, 3546, 3545
4052, 3523, 3524, 3547, 3546
4053, 3524, 3525, 3548, 3547
4054, 3525, 3526, 3549, 3548
4055, 3526, 3527, 3550, 3549
4056, 3527, 3528, 3551, 3550
4057, 3528, 3529, 3552, 3551
4058, 3529, 407, 408, 3552
4059, 271, 3530, 3553, 272
4060, 3530, 3531, 3554, 3553
4061, 3531, 3532, 3555, 3554
4062, 3532, 3533, 3556, 3555
4063, 3533, 3534, 3557, 3556
4064, 3534, 3535, 3558, 3557
4065, 3535, 3536, 3559, 3558
4066, 3536, 3537, 3560, 3559
4067, 3537, 3538, 3561, 3560
4068, 3538, 3539, 3562, 3561
4069, 3539, 3540, 3563, 3562
4070, 3540, 3541, 3564, 3563
4071, 3541, 3542, 3565, 3564
4072, 3542, 3543, 3566, 3565
4073, 3543, 3544, 3567, 3566
4074, 3544, 3545, 3568, 3567
4075, 3545, 3546, 3569, 3568
4076, 3546, 3547, 3570, 3569
4077, 3547, 3548, 3571, 3570
4078, 3548, 3549, 3572, 3571
4079, 3549, 3550, 3573, 3572
4080, 3550, 3551, 3574, 3573
4081, 3551, 3552, 3575, 3574
4082, 3552, 408, 409, 3575
4083, 272, 3553, 3576, 273
4084, 3553, 3554, 3577, 3576
4085, 3554, 3555, 3578, 3577
4086, 3555, 3556, 3579, 3578
4087, 3556, 3557, 3580, 3579
4088, 3557, 3558, 3581, 3580
4089, 3558, 3559, 3582, 3581
4090, 3559, 3560, 3583, 3582
4091, 3560, 3561, 3584, 3583
4092, 3561, 3562, 3585, 3584
4093, 3562, 3563, 3586, 3585
4094, 3563, 3564, 3587, 3586
4095, 3564, 3565, 3588, 3587
4096, 3565, 3566, 3589, 3588
4097, 3566, 3567, 3590, 3589
4098, 3567, 3568, 3591, 3590
4099, 3568, 3569, 3592, 3591
4100, 3569, 3570, 3593, 3592
4101, 3570, 3571, 3594, 3593
4102, 3571, 3572, 3595, 3594
4103, 3572, 3573, 3596, 3595
4104, 3573, 3574, 3597, 3596
4105, 3574, 3575, 3598, 3597
4106, 3575, 409, 410, 3598
4107, 273, 3576, 3599, 274
4108, 3576, 3577, 3600, 3599
4109, 3577, 3578, 3601, 3600
4110, 3578, 3579, 3602, 3601
4111, 3579, 3580, 3603, 3602
4112, 3580, 3581, 3604, 3603
4113, 3581, 3582, 3605, 3604
4114, 3582, 3583, 3606, 3605
4115, 3583, 3584, 3607, 3606
4116, 3584, 3585, 3608, 3607
4117, 3585, 3586, 3609, 3608
4118, 3586, 3587, 3610, 3609
4119, 3587, 3588, 3611, 3610
4120, 3588, 3589, 3612, 3611
4121, 3589, 3590, 3613, 3612
4122, 3590, 3591, 3614, 3613
4123, 3591, 3592, 3615, 3614
4124, 3592, 3593, 3616, 3615
4125, 3593, 3594, 3617, 3616
4126, 3594, 3595, 3618, 3617
4127, 3595, 3596, 3619, 3618
4128, 3596, 3597, 3620, 3619
4129, 3597, 3598, 3621, 3620
4130, 3598, 410, 411, 3621
4131, 274, 3599, 378, 11
4132, 3599, 3600, 379, 378
4133, 3600, 3601, 380, 379
4134, 3601, 3602, 381, 380
4135, 3602, 3603, 382, 381
4136, 3603, 3604, 383, 382
4137, 3604, 3605, 384, 383
4138, 3605, 3606, 385, 384
4139, 3606, 3607, 386, 385
4140, 3607, 3608, 387, 386
4141, 3608, 3609, 388, 387
4142, 3609, 3610, 389, 388
4143, 3610, 3611, 390, 389
4144, 3611, 3612, 391, 390
4145, 3612, 3613, 392, 391
4146, 3613, 3614, 393, 392
4147, 3614, 3615, 394, 393
4148, 3615, 3616, 395, 394
4149, 3616, 3617, 396, 395
4150, 3617, 3618, 397, 396
4151, 3618, 3619, 398, 397
4152, 3619, 3620, 399, 398
4153, 3620, 3621, 400, 399
4154, 3621, 411, 15, 400
*ELEMENT, type=CPS4, ELSET=Surface14
4155, 12, 275, 3622, 412
4156, 412, 3622, 3623, 413
4157, 413, 3623, 3624, 414
4158, 414, 3624, 3625, 415
4159, 415, 3625, 3626, 416
4160, 416, 3626, 3627, 417
4161, 417, 3627, 3628, 418
4162, 418, 3628, 3629, 419
4163, 419, 3629, 3630, 420
4164, 420, 3630, 3631, 421
4165, 421, 3631, 3632, 422
4166, 422, 3632, 3633, 423
4167, 423, 3633, 3634, 424
4168, 424, 3634, 3635, 425
4169, 425, 3635, 3636, 426
4170, 426, 3636, 3637, 427
4171, 427, 3637, 3638, 428
4172, 428, 3638, 3639, 429
4173, 429, 3639, 3640, 430
4174, 430, 3640, 3641, 431
4175, 431, 3641, 3642, 432
4176, 432, 3642, 3643, 433
4177, 433, 3643, 3644, 434
4178, 434, 3644, 435, 16
4179, 275, 276, 3645, 3622
4180, 3622, 3645, 3646, 3623
4181, 3623, 3646, 3647, 3624
4182, 3624, 3647, 3648, 3625
4183, 3625, 3648, 3649, 3626
4184, 3626, 3649, 3650, 3627
4185, 3627, 3650, 3651, 3628
4186, 3628, 3651, 3652, 3629
4187, 3629, 3652, 3653, 3630
4188, 3630, 3653, 3654, 3631
4189, 3631, 3654, 3655, 3632
4190, 3632, 3655, 3656, 3633
4191, 3633, 3656, 3657, 3634
4192, 3634, 3657, 3658, 3635
4193, 3635, 3658, 3659, 3636
4194, 3636, 3659, 3660, 3637
4195, 3637, 3660, 3661, 3638
4196, 3638, 3661, 3662, 3639
4197, 3639, 3662, 3663, 3640
4198, 3640, 3663, 3664, 3641
4199, 3641, 3664, 3665, 3642
4200, 3642, 3665, 3666, 3643
4201, 3643, 3666, 3667, 3644
4202, 3644, 3667, 436, 435
4203, 276, 277, 3668, 3645
4204, 3645, 3668, 3669, 3646
4205, 3646, 3669, 3670, 3647
4206, 3647, 3670, 3671, 3648
4207, 3648, 3671, 3672, 3649
4208, 3649, 3672, 3673, 3650
4209, 3650, 3673, 3674, 3651
4210, 3651, 3674, 3675, 3652
4211, 3652, 3675, 3676, 3653
4212, 3653, 3676, 3677, 3654
4213, 3654, 3677, 3678, 3655
4214, 3655, 3678, 3679, 3656
4215, 3656, 3679, 3680, 3657
4216, 3657, 3680, 3681, 3658
4217, 3658, 3681, 3682, 3659
4218, 3659, 3682, 3683, 3660
4219, 3660, 3683, 3684, 3661
4220, 3661, 3684, 3685, 3662
4221, 3662, 3685, 3686, 3663
4222, 3663, 3686, 3687, 3664
4223, 3664, 3687, 3688, 3665
4224, 3665, 3688, 3689, 3666
4225, 3666, 3689, 3690, 3667
4226, 3667, 3690, 437, 436
4227, 277, 278, 3691, 3668
4228, 3668, 3691, 3692, 3669
4229, 3669, 3692, 3693, 3670
4230, 3670, 3693, 3694, 3671
4231, 3671, 3694, 3695, 3672
4232, 3672, 3695, 3696, 3673
4233, 3673, 3696, 3697, 3674
4234, 3674, 3697, 3698, 3675
4235, 3675, 3698, 3699, 3676
4236, 3676, 3699, 3700, 3677
4237, 3677, 3700, 3701, 3678
4238, 3678, 3701, 3702, 3679
4239, 3679, 3702, 3703, 3680
4240, 3680, 3703, 3704, 3681
4241, 3681, 3704, 3705, 3682
4242, 3682, 3705, 3706, 3683
4243, 3683, 3706, 3707, 3684
4244, 3684, 3707, 3708, 3685
4245, 3685, 3708, 3709, 3686
4246, 3686, 3709, 3710, 3687
4247, 3687, 3710, 3711, 3688
4248, 3688, 3711, 3712, 3689
4249, 3689, 3712, 3713, 3690
4250, 3690, 3713, 438, 437
4251, 278, 279, 3714, 3691
4252, 3691, 3714, 3715, 3692
4253, 3692, 3715, 3716, 3693
4254, 3693, 3716, 3717, 3694
4255, 3694, 3717, 3718, 3695
4256, 3695, 3718, 3719, 3696
4257, 3696, 3719, 3720, 3697
4258, 3697, 3720, 3721, 3698
4259, 3698, 3721, 3722, 3699
4260, 3699, 3722, 3723, 3700
4261, 3700, 3723, 3724, 3701
4262, 3701, 3724, 3725, 3702
4263, 3702, 3725, 3726, 3703
4264, 3703, 3726, 3727, 3704
4265, 3704, 3727, 3728, 3705
4266, 3705, 3728, 3729, 3706
4267, 3706, 3729, 3730, 3707
4268, 3707, 3730, 3731, 3708
4269, 3708, 3731, 3732, 3709
4270, 3709, 3732, 3733, 3710
4271, 3710, 3733, 3734, 3711
4272, 3711, 3734, 3735, 3712
4273, 3712, 3735, 3736, 3713
4274, 3713, 3736, 439, 438
4275, 279, 280, 3737, 3714
4276, 3714, 3737, 3738, 3715
4277, 3715, 3738, 3739, 3716
4278, 3716, 3739, 3740, 3717
4279, 3717, 3740, 3741, 3718
4280, 3718, 3741, 3742, 3719
4281, 3719, 3742, 3743, 3720
4282, 3720, 3743, 3744, 3721
4283, 3721, 3744, 3745, 3722
4284, 3722, 3745, 3746, 3723
4285, 3723, 3746, 3747, 3724
4286, 3724, 3747, 3748, 3725
4287, 3725, 3748, 3749, 3726
4288, 3726, 3749, 3750, 3727
4289, 3727, 3750, 3751, 3728
4290, 3728, 3751, 3752, 3729
4291, 3729, 3752, 3753, 3730
4292, 3730, 3753, 3754, 3731
4293, 3731, 3754, 3755, 3732
4294, 3732, 3755, 3756, 3733
4295, 3733, 3756, 3757, 3734
4296, 3734, 3757, 3758, 3735
4297, 3735, 3758, 3759, 3736
4298, 3736, 3759, 440, 439
4299, 280, 281, 3760, 3737
4300, 3737, 3760, 3761, 3738
4301, 3738, 3761, 3762, 3739
4302, 3739, 3762, 3763, 3740
4303, 3740, 3763, 3764, 3741
4304, 3741, 3764, 3765, 3742
4305, 3742, 3765, 3766, 3743
4306, 3743, 3766, 3767, 3744
4307, 3744, 3767, 3768, 3745
4308, 3745, 3768, 3769, 3746
4309, 3746, 3769, 3770, 3747
4310, 3747, 3770, 3771, 3748
4311, 3748, 3771, 3772, 3749
4312, 3749, 3772, 3773, 3750
4313, 3750, 3773, 3774, 3751
4314, 3751, 3774, 3775, 3752
4315, 3752, 3775, 3776, 3753
4316, 3753, 3776, 3777, 3754
4317, 3754, 3777, 3778, 3755
4318, 3755, 3778, 3779, 3756
4319, 3756, 3779, 3780, 3757
4320, 3757, 3780, 3781, 3758
4321, 3758, 3781, 3782, 3759
4322, 3759, 3782, 441, 440
4323, 281, 282, 3783, 3760
4324, 3760, 3783, 3784, 3761
4325, 3761, 3784, 3785, 3762
4326, 3762, 3785, 3786, 3763
4327, 3763, 3786, 3787, 3764
4328, 3764, 3787, 3788, 3765
4329, 3765, 3788, 3789, 3766
4330, 3766, 3789, 3790, 3767
4331, 3767, 3790, 3791, 3768
4332, 3768, 3791, 3792, 3769
4333, 3769, 3792, 3793, 3770
4334, 3770, 3793, 3794, 3771
4335, 3771, 3794, 3795, 3772
4336, 3772, 3795, 3796, 3773
4337, 3773, 3796, 3797, 3774
4338, 3774, 3797, 3798, 3775
4339, 3775, 3798, 3799, 3776
4340, 3776, 3799, 3800, 3777
4341, 3777, 3800, 3801, 3778
4342, 3778, 3801, 3802, 3779
4343, 3779, 3802, 3803, 3780
4344, 3780, 3803, 3804, 3781
4345, 3781, 3804, 3805, 3782
4346, 3782, 3805, 442, 441
4347, 282, 283, 3806, 3783
4348, 3783, 3806, 3807, 3784
4349, 3784, 3807, 3808, 3785
4350, 3785, 3808, 3809, 3786
4351, 3786, 3809, 3810, 3787
4352, 3787, 3810, 3811, 3788
4353, 3788, 3811, 3812, 3789
4354, 3789, 3812, 3813, 3790
4355, 3790, 3813, 3814, 3791
4356, 3791, 3814, 3815, 3792
4357, 3792, 3815, 3816, 3793
4358, 3793, 3816, 3817, 3794
4359, 3794, 3817, 3818, 3795
4360, 3795, 3818, 3819, 3796
4361, 3796, 3819, 3820, 3797
4362, 3797, 3820, 3821, 3798
4363, 3798, 3821, 3822, 3799
4364, 3799, 3822, 3823, 3800
4365, 3800, 3823, 3824, 3801
4366, 3801, 3824, 3825, 3802
4367, 3802, 3825, 3826, 3803
4368, 3803, 3826, 3827, 3804
4369, 3804, 3827, 3828, 3805
4370, 3805, 3828, 443, 442
4371, 283, 284, 3829, 3806
4372, 3806, 3829, 3830, 3807
4373, 3807, 3830, 3831, 3808
4374, 3808, 3831, 3832, 3809
4375, 3809, 3832, 3833, 3810
4376, 3810, 3833, 3834, 3811
4377, 3811, 3834, 3835, 3812
4378, 3812, 3835, 3836, 3813
4379, 3813, 3836, 3837, 3814
4380, 3814, 3837, 3838, 3815
4381, 3815, 3838, 3839, 3816
4382, 3816, 3839, 3840, 3817
4383, 3817, 3840, 3841, 3818
4384, 3818, 3841, 3842, 3819
4385, 3819, 3842, 3843, 3820
4386, 3820, 3843, 3844, 3821
4387, 3821, 3844, 3845, 3822
4388, 3822, 3845, 3846, 3823
4389, 3823, 3846, 3847, 3824
4390, 3824, 3847, 3848, 3825
4391, 3825, 3848, 3849, 3826
4392, 3826, 3849, 3850, 3827
4393, 3827, 3850, 3851, 3828
4394, 3828, 3851, 444, 443
4395, 284, 285, 3852, 3829
4396, 3829, 3852, 3853, 3830
4397, 3830, 3853, 3854, 3831
4398, 3831, 3854, 3855, 3832
4399, 3832, 3855, 3856, 3833
4400, 3833, 3856, 3857, 3834
4401, 3834, 3857, 3858, 3835
4402, 3835, 3858, 3859, 3836
4403, 3836, 3859, 3860, 3837
4404, 3837, 3860, 3861, 3838
4405, 3838, 3861, 3862, 3839
4406, 3839, 3862, 3863, 3840
4407, 3840, 3863, 3864, 3841
4408, 3841, 3864, 3865, 3842
4409, 3842, 3865, 3866, 3843
4410, 3843, 3866, 3867, 3844
4411, 3844, 3867, 3868, 3845
4412, 3845, 3868, 3869, 3846
4413, 3846, 3869, 3870, 3847
4414, 3847, 3870, 3871, 3848
4415, 3848, 3871, 3872, 3849
4416, 3849, 3872, 3873, 3850
4417, 3850, 3873, 3874, 3851
4418, 3851, 3874, 445, 444
4419, 285, 286, 3875, 3852
4420, 3852, 3875, 3876, 3853
4421, 3853, 3876, 3877, 3854
4422, 3854, 3877, 3878, 3855
4423, 3855, 3878, 3879, 3856
4424, 3856, 3879, 3880, 3857
4425, 3857, 3880, 3881, 3858
4426, 3858, 3881, 3882, 3859
4427, 3859, 3882, 3883, 3860
4428, 3860, 3883, 3884, 3861
4429, 3861, 3884, 3885, 3862
4430, 3862, 3885, 3886, 3863
4431, 3863, 3886, 3887, 3864
4432, 3864, 3887, 3888, 3865
4433, 3865, 3888, 3889, 3866
4434, 3866, 3889, 3890, 3867
4435, 3867, 3890, 3891, 3868
4436, 3868, 3891, 3892, 3869
4437, 3869, 3892, 3893, 3870
4438, 3870, 3893, 3894, 3871
4439, 3871, 3894, 3895, 3872
4440, 3872, 3895, 3896, 3873
4441, 3873, 3896, 3897, 3874
4442, 3874, 3897, 446, 445
4443, 286, 287, 3898, 3875
4444, 3875, 3898, 3899, 3876
4445, 3876, 3899, 3900, 3877
4446, 3877, 3900, 3901, 3878
4447, 3878, 3901, 3902, 3879
4448, 3879, 3902, 3903, 3880
4449, 3880, 3903, 3904, 3881
4450, 3881, 3904, 3905, 3882
4451, 3882, 3905, 3906, 3883
4452, 3883, 3906, 3907, 3884
4453, 3884, 3907, 3908, 3885
4454, 3885, 3908, 3909, 3886
4455, 3886, 3909, 3910, 3887
4456, 3887, 3910, 3911, 3888
4457, 3888, 3911, 3912, 3889
4458, 3889, 3912, 3913, 3890
4459, 3890, 3913, 3914, 3891
4460, 3891, 3914, 3915, 3892
4461, 3892, 3915, 3916, 3893
4462, 3893, 3916, 3917, 3894
4463, 3894, 3917, 3918, 3895
4464, 3895, 3918, 3919, 3896
4465, 3896, 3919, 3920, 3897
4466, 3897, 3920, 447, 446
4467, 287, 288, 3921, 3898
4468, 3898, 3921, 3922, 3899
4469, 3899, 3922, 3923, 3900
4470, 3900, 3923, 3924, 3901
4471, 3901, 3924, 3925, 3902
4472, 3902, 3925, 3926, 3903
4473, 3903, 3926, 3927, 3904
4474, 3904, 3927, 3928, 3905
4475, 3905, 3928, 3929, 3906
4476, 3906, 3929, 3930, 3907
4477, 3907, 3930, 3931, 3908
4478, 3908, 3931, 3932, 3909
4479, 3909, 3932, 3933, 3910
4480, 3910, 3933, 3934, 3911
4481, 3911, 3934, 3935, 3912
4482, 3912, 3935, 3936, 3913
4483, 3913, 3936, 3937, 3914
4484, 3914, 3937, 3938, 3915
4485, 3915, 3938, 3939, 3916
4486, 3916, 3939, 3940, 3917
4487, 3917, 3940, 3941, 3918
4488, 3918, 3941, 3942, 3919
4489, 3919, 3942, 3943, 3920
4490, 3920, 3943, 448, 447
4491, 288, 289, 3944, 3921
4492, 3921, 3944, 3945, 3922
4493, 3922, 3945, 3946, 3923
4494, 3923, 3946, 3947, 3924
4495, 3924, 3947, 3948, 3925
4496, 3925, 3948, 3949, 3926
4497, 3926, 3949, 3950, 3927
4498, 3927, 3950, 3951, 3928
4499, 3928, 3951, 3952, 3929
4500, 3929, 3952, 3953, 3930
4501, 3930, 3953, 3954, 3931
4502, 3931, 3954, 3955, 3932
4503, 3932, 3955, 3956, 3933
4504, 3933, 3956, 3957, 3934
4505, 3934, 3957, 3958, 3935
4506, 3935, 3958, 3959, 3936
4507, 3936, 3959, 3960, 3937
4508, 3937, 3960, 3961, 3938
4509, 3938, 3961, 3962, 3939
4510, 3939, 3962, 3963, 3940
4511, 3940, 3963, 3964, 3941
4512, 3941, 3964, 3965, 3942
4513, 3942, 3965, 3966, 3943
4514, 3943, 3966, 449, 448
4515, 289, 290, 3967, 3944
4516, 3944, 3967, 3968, 3945
4517, 3945, 3968, 3969, 3946
4518, 3946, 3969, 3970, 3947
4519, 3947, 3970, 3971, 3948
4520, 3948, 3971, 3972, 3949
4521, 3949, 3972, 3973, 3950
4522, 3950, 3973, 3974, 3951
4523, 3951, 3974, 3975, 3952
4524, 3952, 3975, 3976, 3953
4525, 3953, 3976, 3977, 3954
4526, 3954, 3977, 3978, 3955
4527, 3955, 3978, 3979, 3956
4528, 3956, 3979, 3980, 3957
4529, 3957, 3980, 3981, 3958
4530, 3958, 3981, 3982, 3959
4531, 3959, 3982, 3983, 3960
4532, 3960, 3983, 3984, 3961
4533, 3961, 3984, 3985, 3962
4534, 3962, 3985, 3986, 3963
4535, 3963, 3986, 3987, 3964
4536, 3964, 3987, 3988, 3965
4537, 3965, 3988, 3989, 3966
4538, 3966, 3989, 450, 449
4539, 290, 291, 3990, 3967
4540, 3967, 3990, 3991, 3968
4541, 3968, 3991, 3992, 3969
4542, 3969, 3992, 3993, 3970
4543, 3970, 3993, 3994, 3971
4544, 3971, 3994, 3995, 3972
4545, 3972, 3995, 3996, 3973
4546, 3973, 3996, 3997, 3974
4547, 3974, 3997, 3998, 3975
4548, 3975, 3998, 3999, 3976
4549, 3976, 3999, 4000, 3977
4550, 3977, 4000, 4001, 3978
4551, 3978, 4001, 4002, 3979
4552, 3979, 4002, 4003, 3980
4553, 3980, 4003, 4004, 3981
4554, 3981, 4004, 4005, 3982
4555, 3982, 4005, 4006, 3983
4556, 3983, 4006, 4007, 3984
4557, 3984, 4007, 4008, 3985
4558, 3985, 4008, 4009, 3986
4559, 3986, 4009, 4010, 3987
4560, 3987, 4010, 4011, 3988
4561, 3988, 4011, 4012, 3989
4562, 3989, 4012, 451, 450
4563, 291, 292, 4013, 3990
4564, 3990, 4013, 4014, 3991
4565, 3991, 4014, 4015, 3992
4566, 3992, 4015, 4016, 3993
4567, 3993, 4016, 4017, 3994
4568, 3994, 4017, 4018, 3995
4569, 3995, 4018, 4019, 3996
4570, 3996, 4019, 4020, 3997
4571, 3997, 4020, 4021, 3998
4572, 3998, 4021, 4022, 3999
4573, 3999, 4022, 4023, 4000
4574, 4000, 4023, 4024, 4001
4575, 4001, 4024, 4025, 4002
4576, 4002, 4025, 4026, 4003
4577, 4003, 4026, 4027, 4004
4578, 4004, 4027, 4028, 4005
4579, 4005, 4028, 4029, 4006
4580, 4006, 4029, 4030, 4007
4581, 4007, 4030, 4031, 4008
4582, 4008, 4031, 4032, 4009
4583, 4009, 4032, 4033, 4010
4584, 4010, 4033, 4034, 4011
4585, 4011, 4034, 4035, 4012
4586, 4012, 4035, 452, 451
4587, 292, 293, 4036, 4013
4588, 4013, 4036, 4037, 4014
4589, 4014, 4037, 4038, 4015
4590, 4015, 4038, 4039, 4016
4591, 4016, 4039, 4040, 4017
4592, 4017, 4040, 4041, 4018
4593, 4018, 4041, 4042, 4019
4594, 4019, 4042, 4043, 4020
4595, 4020, 4043, 4044, 4021
4596, 4021, 4044, 4045, 4022
4597, 4022, 4045, 4046, 4023
4598, 4023, 4046, 4047, 4024
4599, 4024, 4047, 4048, 4025
4600, 4025, 4048, 4049, 4026
4601, 4026, 4049, 4050, 4027
4602, 4027, 4050, 4051, 4028
4603, 4028, 4051, 4052, 4029
4604, 4029, 4052, 4053, 4030
4605, 4030, 4053, 4054, 4031
4606, 4031, 4054, 4055, 4032
4607, 4032, 4055, 4056, 4033
4608, 4033, 4056, 4057, 4034
4609, 4034, 4057, 4058, 4035
4610, 4035, 4058, 453, 452
4611, 293, 294, 4059, 4036
4612, 4036, 4059, 4060, 4037
4613, 4037, 4060, 4061, 4038
4614, 4038, 4061, 4062, 4039
4615, 4039, 4062, 4063, 4040
4616, 4040, 4063, 4064, 4041
4617, 4041, 4064, 4065, 4042
4618, 4042, 4065, 4066, 4043
4619, 4043, 4066, 4067, 4044
4620, 4044, 4067, 4068, 4045
4621, 4045, 4068, 4069, 4046
4622, 4046, 4069, 4070, 4047
4623, 4047, 4070, 4071, 4048
4624, 4048, 4071, 4072, 4049
4625, 4049, 4072, 4073, 4050
4626, 4050, 4073, 4074, 4051
4627, 4051, 4074, 4075, 4052
4628, 4052, 4075, 4076, 4053
4629, 4053, 4076, 4077, 4054
4630, 4054, 4077, 4078, 4055
4631, 4055, 4078, 4079, 4056
4632, 4056, 4079, 4080, 4057
4633, 4057, 4080, 4081, 4058
4634, 4058, 4081, 454, 453
4635, 294, 295, 4082, 4059
4636, 4059, 4082, 4083, 4060
4637, 4060, 4083, 4084, 4061
4638, 4061, 4084, 4085, 4062
4639, 4062, 4085, 4086, 4063
4640, 4063, 4086, 4087, 4064
4641, 4064, 4087, 4088, 4065
4642, 4065, 4088, 4089, 4066
4643, 4066, 4089, 4090, 4067
4644, 4067, 4090, 4091, 4068
4645, 4068, 4091, 4092, 4069
4646, 4069, 4092, 4093, 4070
4647, 4070, 4093, 4094, 4071
4648, 4071, 4094, 4095, 4072
4649, 4072, 4095, 4096, 4073
4650, 4073, 4096, 4097, 4074
4651, 4074, 4097, 4098, 4075
4652, 4075, 4098, 4099, 4076
4653, 4076, 4099, 4100, 4077
4654, 4077, 4100, 4101, 4078
4655, 4078, 4101, 4102, 4079
4656, 4079, 4102, 4103, 4080
4657, 4080, 4103, 4104, 4081
4658, 4081, 4104, 455, 454
4659, 295, 296, 4105, 4082
4660, 4082, 4105, 4106, 4083
4661, 4083, 4106, 4107, 4084
4662, 4084, 4107, 4108, 4085
4663, 4085, 4108, 4109, 4086
4664, 4086, 4109, 4110, 4087
4665, 4087, 4110, 4111, 4088
4666, 4088, 4111, 4112, 4089
4667, 4089, 4112, 4113, 4090
4668, 4090, 4113, 4114, 4091
4669, 4091, 4114, 4115, 4092
4670, 4092, 4115, 4116, 4093
4671, 4093, 4116, 4117, 4094
4672, 4094, 4117, 4118, 4095
4673, 4095, 4118, 4119, 4096
4674, 4096, 4119, 4120, 4097
4675, 4097, 4120, 4121, 4098
4676, 4098, 4121, 4122, 4099
4677, 4099, 4122, 4123, 4100
4678, 4100, 4123, 4124, 4101
4679, 4101, 4124, 4125, 4102
4680, 4102, 4125, 4126, 4103
4681, 4103, 4126, 4127, 4104
4682, 4104, 4127, 456, 455
4683, 296, 297, 4128, 4105
4684, 4105, 4128, 4129, 4106
4685, 4106, 4129, 4130, 4107
4686, 4107, 4130, 4131, 4108
4687, 4108, 4131, 4132, 4109
4688, 4109, 4132, 4133, 4110
4689, 4110, 4133, 4134, 4111
4690, 4111, 4134, 4135, 4112
4691, 4112, 4135, 4136, 4113
4692, 4113, 4136, 4137, 4114
4693, 4114, 4137, 4138, 4115
4694, 4115, 4138, 4139, 4116
4695, 4116, 4139, 4140, 4117
4696, 4117, 4140, 4141, 4118
4697, 4118, 4141, 4142, 4119
4698, 4119, 4142, 4143, 4120
4699, 4120, 4143, 4144, 4121
4700, 4121, 4144, 4145, 4122
4701, 4122, 4145, 4146, 4123
4702, 4123, 4146, 4147, 4124
4703, 4124, 4147, 4148, 4125
4704, 4125, 4148, 4149, 4126
4705, 4126, 4149, 4150, 4127
4706, 4127, 4150, 457, 456
4707, 297, 11, 378, 4128
4708, 4128, 378, 379, 4129
4709, 4129, 379, 380, 4130
4710, 4130, 380, 381, 4131
4711, 4131, 381, 382, 4132
4712, 4132, 382, 383, 4133
4713, 4133, 383, 384, 4134
4714, 4134, 384, 385, 4135
4715, 4135, 385, 386, 4136
4716, 4136, 386, 387, 4137
4717, 4137, 387, 388, 4138
4718, 4138, 388, 389, 4139
4719, 4139, 389, 390, 4140
4720, 4140, 390, 391, 4141
4721, 4141, 391, 392, 4142
4722, 4142, 392, 393, 4143
4723, 4143, 393, 394, 4144
4724, 4144, 394, 395, 4145
4725, 4145, 395, 396, 4146
4726, 4146, 396, 397, 4147
4727, 4147, 397, 398, 4148
4728, 4148, 398, 399, 4149
4729, 4149, 399, 400, 4150
4730, 4150, 400, 15, 457
*ELEMENT, type=CPS4, ELSET=Surface15
4731, 10, 298, 4151, 332
4732, 332, 4151, 4152, 333
4733, 333, 4152, 4153, 334
4734, 334, 4153, 4154, 335
4735, 335, 4154, 4155, 336
4736, 336, 4155, 4156, 337
4737, 337, 4156, 4157, 338
4738, 338, 4157, 4158, 339
4739, 339, 4158, 4159, 340
4740, 340, 4159, 4160, 341
4741, 341, 4160, 4161, 342
4742, 342, 4161, 4162, 343
4743, 343, 4162, 4163, 344
4744, 344, 4163, 4164, 345
4745, 345, 4164, 4165, 346
4746, 346, 4165, 4166, 347
4747, 347, 4166, 4167, 348
4748, 348, 4167, 4168, 349
4749, 349, 4168, 4169, 350
4750, 350, 4169, 4170, 351
4751, 351, 4170, 4171, 352
4752, 352, 4171, 4172, 353
4753, 353, 4172, 4173, 354
4754, 354, 4173, 458, 14
4755, 298, 299, 4174, 4151
4756, 4151, 4174, 4175, 4152
4757, 4152, 4175, 4176, 4153
4758, 4153, 4176, 4177, 4154
4759, 4154, 4177, 4178, 4155
4760, 4155, 4178, 4179, 4156
4761, 4156, 4179, 4180, 4157
4762, 4157, 4180, 4181, 4158
4763, 4158, 4181, 4182, 4159
4764, 4159, 4182, 4183, 4160
4765, 4160, 4183, 4184, 4161
4766, 4161, 4184, 4185, 4162
4767, 4162, 4185, 4186, 4163
4768, 4163, 4186, 4187, 4164
4769, 4164, 4187, 4188, 4165
4770, 4165, 4188, 4189, 4166
4771, 4166, 4189, 4190, 4167
4772, 4167, 4190, 4191, 4168
4773, 4168, 4191, 4192, 4169
4774, 4169, 4192, 4193, 4170
4775, 4170, 4193, 4194, 4171
4776, 4171, 4194, 4195, 4172
4777, 4172, 4195, 4196, 4173
4778, 4173, 4196, 459, 458
4779, 299, 300, 4197, 4174
4780, 4174, 4197, 4198, 4175
4781, 4175, 4198, 4199, 4176
4782, 4176, 4199, 4200, 4177
4783, 4177, 4200, 4201, 4178
4784, 4178, 4201, 4202, 4179
4785, 4179, 4202, 4203, 4180
4786, 4180, 4203, 4204, 4181
4787, 4181, 4204, 4205, 4182
4788, 4182, 4205, 4206, 4183
4789, 4183, 4206, 4207, 4184
4790, 4184, 4207, 4208, 4185
4791, 4185, 4208, 4209, 4186
4792, 4186, 4209, 4210, 4187
4793, 4187, 4210, 4211, 4188
4794, 4188, 4211, 4212, 4189
4795, 4189, 4212, 4213, 4190
4796, 4190, 4213, 4214, 4191
4797, 4191, 4214, 4215, 4192
4798, 4192, 4215, 4216, 4193
4799, 4193, 4216, 4217, 4194
4800, 4194, 4217, 4218, 4195
4801, 4195, 4218, 4219, 4196
4802, 4196, 4219, 460, 459
4803, 300, 301, 4220, 4197
4804, 4197, 4220, 4221, 4198
4805, 4198, 4221, 4222, 4199
4806, 4199, 4222, 4223, 4200
4807, 4200, 4223, 4224, 4201
4808, 4201, 4224, 4225, 4202
4809, 4202, 4225, 4226, 4203
4810, 4203, 4226, 4227, 4204
4811, 4204, 4227, 4228, 4205
4812, 4205, 4228, 4229, 4206
4813, 4206, 4229, 4230, 4207
4814, 4207, 4230, 4231, 4208
4815, 4208, 4231, 4232, 4209
4816, 4209, 4232, 4233, 4210
4817, 4210, 4233, 4234, 4211
4818, 4211, 4234, 4235, 4212
4819, 4212, 4235, 4236, 4213
4820, 4213, 4236, 4237, 4214
4821, 4214, 4237, 4238, 4215
4822, 4215, 4238, 4239, 4216
4823, 4216, 4239, 4240, 4217
4824, 4217, 4240, 4241, 4218
4825, 4218, 4241, 4242, 4219
4826, 4219, 4242, 461, 460
4827, 301, 302, 4243, 4220
4828, 4220, 4243, 4244, 4221
4829, 4221, 4244, 4245, 4222
4830, 4222, 4245, 4246, 4223
4831, 4223, 4246, 4247, 4224
4832, 4224, 4247, 4248, 4225
4833, 4225, 4248, 4249, 4226
4834, 4226, 4249, 4250, 4227
4835, 4227, 4250, 4251, 4228
4836, 4228, 4251, 4252, 4229
4837, 4229, 4252, 4253, 4230
4838, 4230, 4253, 4254, 4231
4839, 4231, 4254, 4255, 4232
4840, 4232, 4255, 4256, 4233
4841, 4233, 4256, 4257, 4234
4842, 4234, 4257, 4258, 4235
4843, 4235, 4258, 4259, 4236
4844, 4236, 4259, 4260, 4237
4845, 4237, 4260, 4261, 4238
4846, 4238, 4261, 4262, 4239
4847, 4239, 4262, 4263, 4240
4848, 4240, 4263, 4264, 4241
4849, 4241, 4264, 4265, 4242
4850, 4242, 4265, 462, 461
4851, 302, 303, 4266, 4243
4852, 4243, 4266, 4267, 4244
4853, 4244, 4267, 4268, 4245
4854, 4245, 4268, 4269, 4246
4855, 4246, 4269, 4270, 4247
4856, 4247, 4270, 4271, 4248
4857, 4248, 4271, 4272, 4249
4858, 4249, 4272, 4273, 4250
4859, 4250, 4273, 4274, 4251
4860, 4251, 4274, 4275, 4252
4861, 4252, 4275, 4276, 4253
4862, 4253, 4276, 4277, 4254
4863, 4254, 4277, 4278, 4255
4864, 4255, 4278, 4279, 4256
4865, 4256, 4279, 4280, 4257
4866, 4257, 4280, 4281, 4258
4867, 4258, 4281, 4282, 4259
4868, 4259, 4282, 4283, 4260
4869, 4260, 4283, 4284, 4261
4870, 4261, 4284, 4285, 4262
4871, 4262, 4285, 4286, 4263
4872, 4263, 4286, 4287, 4264
4873, 4264, 4287, 4288, 4265
4874, 4265, 4288, 463, 462
4875, 303, 304, 4289, 4266
4876, 4266, 4289, 4290, 4267
4877, 4267, 4290, 4291, 4268
4878, 4268, 4291, 4292, 4269
4879, 4269, 4292, 4293, 4270
4880, 4270, 4293, 4294, 4271
4881, 4271, 4294, 4295, 4272
4882, 4272, 4295, 4296, 4273
4883, 4273, 4296, 4297, 4274
4884, 4274, 4297, 4298, 4275
4885, 4275, 4298, 4299, 4276
4886, 4276, 4299, 4300, 4277
4887, 4277, 4300, 4301, 4278
4888, 4278, 4301, 4302, 4279
4889, 4279, 4302, 4303, 4280
4890, 4280, 4303, 4304, 4281
4891, 4281, 4304, 4305, 4282
4892, 4282, 4305, 4306, 4283
4893, 4283, 4306, 4307, 4284
4894, 4284, 4307, 4308, 4285
4895, 4285, 4308, 4309, 4286
4896, 4286, 4309, 4310, 4287
4897, 4287, 4310, 4311, 4288
4898, 4288, 4311, 464, 463
4899, 304, 305, 4312, 4289
4900, 4289, 4312, 4313, 4290
4901, 4290, 4313, 4314, 4291
4902, 4291, 4314, 4315, 4292
4903, 4292, 4315, 4316, 4293
4904, 4293, 4316, 4317, 4294
4905, 4294, 4317, 4318, 4295
4906, 4295, 4318, 4319, 4296
4907, 4296, 4319, 4320, 4297
4908, 4297, 4320, 4321, 4298
4909, 4298, 4321, 4322, 4299
4910, 4299, 4322, 4323, 4300
4911, 4300, 4323, 4324, 4301
4912, 4301, 4324, 4325, 4302
4913, 4302, 4325, 4326, 4303
4914, 4303, 4326, 4327, 4304
4915, 4304, 4327, 4328, 4305
4916, 4305, 4328, 4329, 4306
4917, 4306, 4329, 4330, 4307
4918, 4307, 4330, 4331, 4308
4919, 4308, 4331, 4332, 4309
4920, 4309, 4332, 4333, 4310
4921, 4310, 4333, 4334, 4311
4922, 4311, 4334, 465, 464
4923, 305, 306, 4335, 4312
4924, 4312, 4335, 4336, 4313
4925, 4313, 4336, 4337, 4314
4926, 4314, 4337, 4338, 4315
4927, 4315, 4338, 4339, 4316
4928, 4316, 4339, 4340, 4317
4929, 4317, 4340, 4341, 4318
4930, 4318, 4341, 4342, 4319
4931, 4319, 4342, 4343, 4320
4932, 4320, 4343, 4344, 4321
4933, 4321, 4344, 4345, 4322
4934, 4322, 4345, 4346, 4323
4935, 4323, 4346, 4347, 4324
4936, 4324, 4347, 4348, 4325
4937, 4325, 4348, 4349, 4326
4938, 4326, 4349, 4350, 4327
4939, 4327, 4350, 4351, 4328
4940, 4328, 4351, 4352, 4329
4941, 4329, 4352, 4353, 4330
4942, 4330, 4353, 4354, 4331
4943, 4331, 4354, 4355, 4332
4944, 4332, 4355, 4356, 4333
4945, 4333, 4356, 4357, 4334
4946, 4334, 4357, 466, 465
4947, 306, 307, 4358, 4335
4948, 4335, 4358, 4359, 4336
4949, 4336, 4359, 4360, 4337
4950, 4337, 4360, 4361, 4338
