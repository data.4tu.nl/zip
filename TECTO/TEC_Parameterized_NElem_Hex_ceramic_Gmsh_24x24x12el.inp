23463, 18842, 18865, 3533, 3510, 18843, 18866, 3534, 3511
23464, 18843, 18866, 3534, 3511, 18844, 18867, 3535, 3512
23465, 18844, 18867, 3535, 3512, 18845, 18868, 3536, 3513
23466, 18845, 18868, 3536, 3513, 18846, 18869, 3537, 3514
23467, 18846, 18869, 3537, 3514, 18847, 18870, 3538, 3515
23468, 18847, 18870, 3538, 3515, 18848, 18871, 3539, 3516
23469, 18848, 18871, 3539, 3516, 18849, 18872, 3540, 3517
23470, 18849, 18872, 3540, 3517, 18850, 18873, 3541, 3518
23471, 18850, 18873, 3541, 3518, 18851, 18874, 3542, 3519
23472, 18851, 18874, 3542, 3519, 18852, 18875, 3543, 3520
23473, 18852, 18875, 3543, 3520, 18853, 18876, 3544, 3521
23474, 18853, 18876, 3544, 3521, 18854, 18877, 3545, 3522
23475, 18854, 18877, 3545, 3522, 18855, 18878, 3546, 3523
23476, 18855, 18878, 3546, 3523, 18856, 18879, 3547, 3524
23477, 18856, 18879, 3547, 3524, 18857, 18880, 3548, 3525
23478, 18857, 18880, 3548, 3525, 18858, 18881, 3549, 3526
23479, 18858, 18881, 3549, 3526, 18859, 18882, 3550, 3527
23480, 18859, 18882, 3550, 3527, 18860, 18883, 3551, 3528
23481, 18860, 18883, 3551, 3528, 18861, 18884, 3552, 3529
23482, 18861, 18884, 3552, 3529, 4652, 4653, 408, 407
23483, 2836, 2837, 272, 271, 18862, 18885, 3553, 3530
23484, 18862, 18885, 3553, 3530, 18863, 18886, 3554, 3531
23485, 18863, 18886, 3554, 3531, 18864, 18887, 3555, 3532
23486, 18864, 18887, 3555, 3532, 18865, 18888, 3556, 3533
23487, 18865, 18888, 3556, 3533, 18866, 18889, 3557, 3534
23488, 18866, 18889, 3557, 3534, 18867, 18890, 3558, 3535
23489, 18867, 18890, 3558, 3535, 18868, 18891, 3559, 3536
23490, 18868, 18891, 3559, 3536, 18869, 18892, 3560, 3537
23491, 18869, 18892, 3560, 3537, 18870, 18893, 3561, 3538
23492, 18870, 18893, 3561, 3538, 18871, 18894, 3562, 3539
23493, 18871, 18894, 3562, 3539, 18872, 18895, 3563, 3540
23494, 18872, 18895, 3563, 3540, 18873, 18896, 3564, 3541
23495, 18873, 18896, 3564, 3541, 18874, 18897, 3565, 3542
23496, 18874, 18897, 3565, 3542, 18875, 18898, 3566, 3543
23497, 18875, 18898, 3566, 3543, 18876, 18899, 3567, 3544
23498, 18876, 18899, 3567, 3544, 18877, 18900, 3568, 3545
23499, 18877, 18900, 3568, 3545, 18878, 18901, 3569, 3546
23500, 18878, 18901, 3569, 3546, 18879, 18902, 3570, 3547
23501, 18879, 18902, 3570, 3547, 18880, 18903, 3571, 3548
23502, 18880, 18903, 3571, 3548, 18881, 18904, 3572, 3549
23503, 18881, 18904, 3572, 3549, 18882, 18905, 3573, 3550
23504, 18882, 18905, 3573, 3550, 18883, 18906, 3574, 3551
23505, 18883, 18906, 3574, 3551, 18884, 18907, 3575, 3552
23506, 18884, 18907, 3575, 3552, 4653, 4654, 409, 408
23507, 2837, 2838, 273, 272, 18885, 18908, 3576, 3553
23508, 18885, 18908, 3576, 3553, 18886, 18909, 3577, 3554
23509, 18886, 18909, 3577, 3554, 18887, 18910, 3578, 3555
23510, 18887, 18910, 3578, 3555, 18888, 18911, 3579, 3556
23511, 18888, 18911, 3579, 3556, 18889, 18912, 3580, 3557
23512, 18889, 18912, 3580, 3557, 18890, 18913, 3581, 3558
23513, 18890, 18913, 3581, 3558, 18891, 18914, 3582, 3559
23514, 18891, 18914, 3582, 3559, 18892, 18915, 3583, 3560
23515, 18892, 18915, 3583, 3560, 18893, 18916, 3584, 3561
23516, 18893, 18916, 3584, 3561, 18894, 18917, 3585, 3562
23517, 18894, 18917, 3585, 3562, 18895, 18918, 3586, 3563
23518, 18895, 18918, 3586, 3563, 18896, 18919, 3587, 3564
23519, 18896, 18919, 3587, 3564, 18897, 18920, 3588, 3565
23520, 18897, 18920, 3588, 3565, 18898, 18921, 3589, 3566
23521, 18898, 18921, 3589, 3566, 18899, 18922, 3590, 3567
23522, 18899, 18922, 3590, 3567, 18900, 18923, 3591, 3568
23523, 18900, 18923, 3591, 3568, 18901, 18924, 3592, 3569
23524, 18901, 18924, 3592, 3569, 18902, 18925, 3593, 3570
23525, 18902, 18925, 3593, 3570, 18903, 18926, 3594, 3571
23526, 18903, 18926, 3594, 3571, 18904, 18927, 3595, 3572
23527, 18904, 18927, 3595, 3572, 18905, 18928, 3596, 3573
23528, 18905, 18928, 3596, 3573, 18906, 18929, 3597, 3574
23529, 18906, 18929, 3597, 3574, 18907, 18930, 3598, 3575
23530, 18907, 18930, 3598, 3575, 4654, 4655, 410, 409
23531, 2838, 2839, 274, 273, 18908, 18931, 3599, 3576
23532, 18908, 18931, 3599, 3576, 18909, 18932, 3600, 3577
23533, 18909, 18932, 3600, 3577, 18910, 18933, 3601, 3578
23534, 18910, 18933, 3601, 3578, 18911, 18934, 3602, 3579
23535, 18911, 18934, 3602, 3579, 18912, 18935, 3603, 3580
23536, 18912, 18935, 3603, 3580, 18913, 18936, 3604, 3581
23537, 18913, 18936, 3604, 3581, 18914, 18937, 3605, 3582
23538, 18914, 18937, 3605, 3582, 18915, 18938, 3606, 3583
23539, 18915, 18938, 3606, 3583, 18916, 18939, 3607, 3584
23540, 18916, 18939, 3607, 3584, 18917, 18940, 3608, 3585
23541, 18917, 18940, 3608, 3585, 18918, 18941, 3609, 3586
23542, 18918, 18941, 3609, 3586, 18919, 18942, 3610, 3587
23543, 18919, 18942, 3610, 3587, 18920, 18943, 3611, 3588
23544, 18920, 18943, 3611, 3588, 18921, 18944, 3612, 3589
23545, 18921, 18944, 3612, 3589, 18922, 18945, 3613, 3590
23546, 18922, 18945, 3613, 3590, 18923, 18946, 3614, 3591
23547, 18923, 18946, 3614, 3591, 18924, 18947, 3615, 3592
23548, 18924, 18947, 3615, 3592, 18925, 18948, 3616, 3593
23549, 18925, 18948, 3616, 3593, 18926, 18949, 3617, 3594
23550, 18926, 18949, 3617, 3594, 18927, 18950, 3618, 3595
23551, 18927, 18950, 3618, 3595, 18928, 18951, 3619, 3596
23552, 18928, 18951, 3619, 3596, 18929, 18952, 3620, 3597
23553, 18929, 18952, 3620, 3597, 18930, 18953, 3621, 3598
23554, 18930, 18953, 3621, 3598, 4655, 4656, 411, 410
23555, 2839, 297, 11, 274, 18931, 4128, 378, 3599
23556, 18931, 4128, 378, 3599, 18932, 4129, 379, 3600
23557, 18932, 4129, 379, 3600, 18933, 4130, 380, 3601
23558, 18933, 4130, 380, 3601, 18934, 4131, 381, 3602
23559, 18934, 4131, 381, 3602, 18935, 4132, 382, 3603
23560, 18935, 4132, 382, 3603, 18936, 4133, 383, 3604
23561, 18936, 4133, 383, 3604, 18937, 4134, 384, 3605
23562, 18937, 4134, 384, 3605, 18938, 4135, 385, 3606
23563, 18938, 4135, 385, 3606, 18939, 4136, 386, 3607
23564, 18939, 4136, 386, 3607, 18940, 4137, 387, 3608
23565, 18940, 4137, 387, 3608, 18941, 4138, 388, 3609
23566, 18941, 4138, 388, 3609, 18942, 4139, 389, 3610
23567, 18942, 4139, 389, 3610, 18943, 4140, 390, 3611
23568, 18943, 4140, 390, 3611, 18944, 4141, 391, 3612
23569, 18944, 4141, 391, 3612, 18945, 4142, 392, 3613
23570, 18945, 4142, 392, 3613, 18946, 4143, 393, 3614
23571, 18946, 4143, 393, 3614, 18947, 4144, 394, 3615
23572, 18947, 4144, 394, 3615, 18948, 4145, 395, 3616
23573, 18948, 4145, 395, 3616, 18949, 4146, 396, 3617
23574, 18949, 4146, 396, 3617, 18950, 4147, 397, 3618
23575, 18950, 4147, 397, 3618, 18951, 4148, 398, 3619
23576, 18951, 4148, 398, 3619, 18952, 4149, 399, 3620
23577, 18952, 4149, 399, 3620, 18953, 4150, 400, 3621
23578, 18953, 4150, 400, 3621, 4656, 457, 15, 411
*ELEMENT, type=C3D8, ELSET=Volume4
23579, 14, 458, 4404, 355, 18, 526, 4657, 469
23580, 458, 459, 4405, 4404, 526, 527, 4658, 4657
23581, 459, 460, 4406, 4405, 527, 528, 4659, 4658
23582, 460, 461, 4407, 4406, 528, 529, 4660, 4659
23583, 461, 462, 4408, 4407, 529, 530, 4661, 4660
23584, 462, 463, 4409, 4408, 530, 531, 4662, 4661
23585, 463, 464, 4410, 4409, 531, 532, 4663, 4662
23586, 464, 465, 4411, 4410, 532, 533, 4664, 4663
23587, 465, 466, 4412, 4411, 533, 534, 4665, 4664
23588, 466, 467, 4413, 4412, 534, 535, 4666, 4665
23589, 467, 468, 4414, 4413, 535, 536, 4667, 4666
23590, 468, 16, 435, 4414, 536, 20, 503, 4667
23591, 355, 4404, 4415, 356, 469, 4657, 4668, 470
23592, 4404, 4405, 4416, 4415, 4657, 4658, 4669, 4668
23593, 4405, 4406, 4417, 4416, 4658, 4659, 4670, 4669
23594, 4406, 4407, 4418, 4417, 4659, 4660, 4671, 4670
23595, 4407, 4408, 4419, 4418, 4660, 4661, 4672, 4671
23596, 4408, 4409, 4420, 4419, 4661, 4662, 4673, 4672
23597, 4409, 4410, 4421, 4420, 4662, 4663, 4674, 4673
23598, 4410, 4411, 4422, 4421, 4663, 4664, 4675, 4674
23599, 4411, 4412, 4423, 4422, 4664, 4665, 4676, 4675
23600, 4412, 4413, 4424, 4423, 4665, 4666, 4677, 4676
23601, 4413, 4414, 4425, 4424, 4666, 4667, 4678, 4677
23602, 4414, 435, 436, 4425, 4667, 503, 504, 4678
23603, 356, 4415, 4426, 357, 470, 4668, 4679, 471
23604, 4415, 4416, 4427, 4426, 4668, 4669, 4680, 4679
23605, 4416, 4417, 4428, 4427, 4669, 4670, 4681, 4680
23606, 4417, 4418, 4429, 4428, 4670, 4671, 4682, 4681
23607, 4418, 4419, 4430, 4429, 4671, 4672, 4683, 4682
23608, 4419, 4420, 4431, 4430, 4672, 4673, 4684, 4683
23609, 4420, 4421, 4432, 4431, 4673, 4674, 4685, 4684
23610, 4421, 4422, 4433, 4432, 4674, 4675, 4686, 4685
23611, 4422, 4423, 4434, 4433, 4675, 4676, 4687, 4686
23612, 4423, 4424, 4435, 4434, 4676, 4677, 4688, 4687
23613, 4424, 4425, 4436, 4435, 4677, 4678, 4689, 4688
23614, 4425, 436, 437, 4436, 4678, 504, 505, 4689
23615, 357, 4426, 4437, 358, 471, 4679, 4690, 472
23616, 4426, 4427, 4438, 4437, 4679, 4680, 4691, 4690
23617, 4427, 4428, 4439, 4438, 4680, 4681, 4692, 4691
23618, 4428, 4429, 4440, 4439, 4681, 4682, 4693, 4692
23619, 4429, 4430, 4441, 4440, 4682, 4683, 4694, 4693
23620, 4430, 4431, 4442, 4441, 4683, 4684, 4695, 4694
23621, 4431, 4432, 4443, 4442, 4684, 4685, 4696, 4695
23622, 4432, 4433, 4444, 4443, 4685, 4686, 4697, 4696
23623, 4433, 4434, 4445, 4444, 4686, 4687, 4698, 4697
23624, 4434, 4435, 4446, 4445, 4687, 4688, 4699, 4698
23625, 4435, 4436, 4447, 4446, 4688, 4689, 4700, 4699
23626, 4436, 437, 438, 4447, 4689, 505, 506, 4700
23627, 358, 4437, 4448, 359, 472, 4690, 4701, 473
23628, 4437, 4438, 4449, 4448, 4690, 4691, 4702, 4701
23629, 4438, 4439, 4450, 4449, 4691, 4692, 4703, 4702
23630, 4439, 4440, 4451, 4450, 4692, 4693, 4704, 4703
23631, 4440, 4441, 4452, 4451, 4693, 4694, 4705, 4704
23632, 4441, 4442, 4453, 4452, 4694, 4695, 4706, 4705
23633, 4442, 4443, 4454, 4453, 4695, 4696, 4707, 4706
23634, 4443, 4444, 4455, 4454, 4696, 4697, 4708, 4707
23635, 4444, 4445, 4456, 4455, 4697, 4698, 4709, 4708
23636, 4445, 4446, 4457, 4456, 4698, 4699, 4710, 4709
23637, 4446, 4447, 4458, 4457, 4699, 4700, 4711, 4710
23638, 4447, 438, 439, 4458, 4700, 506, 507, 4711
23639, 359, 4448, 4459, 360, 473, 4701, 4712, 474
23640, 4448, 4449, 4460, 4459, 4701, 4702, 4713, 4712
23641, 4449, 4450, 4461, 4460, 4702, 4703, 4714, 4713
23642, 4450, 4451, 4462, 4461, 4703, 4704, 4715, 4714
23643, 4451, 4452, 4463, 4462, 4704, 4705, 4716, 4715
23644, 4452, 4453, 4464, 4463, 4705, 4706, 4717, 4716
23645, 4453, 4454, 4465, 4464, 4706, 4707, 4718, 4717
23646, 4454, 4455, 4466, 4465, 4707, 4708, 4719, 4718
23647, 4455, 4456, 4467, 4466, 4708, 4709, 4720, 4719
23648, 4456, 4457, 4468, 4467, 4709, 4710, 4721, 4720
23649, 4457, 4458, 4469, 4468, 4710, 4711, 4722, 4721
23650, 4458, 439, 440, 4469, 4711, 507, 508, 4722
23651, 360, 4459, 4470, 361, 474, 4712, 4723, 475
23652, 4459, 4460, 4471, 4470, 4712, 4713, 4724, 4723
23653, 4460, 4461, 4472, 4471, 4713, 4714, 4725, 4724
23654, 4461, 4462, 4473, 4472, 4714, 4715, 4726, 4725
23655, 4462, 4463, 4474, 4473, 4715, 4716, 4727, 4726
23656, 4463, 4464, 4475, 4474, 4716, 4717, 4728, 4727
23657, 4464, 4465, 4476, 4475, 4717, 4718, 4729, 4728
23658, 4465, 4466, 4477, 4476, 4718, 4719, 4730, 4729
23659, 4466, 4467, 4478, 4477, 4719, 4720, 4731, 4730
23660, 4467, 4468, 4479, 4478, 4720, 4721, 4732, 4731
23661, 4468, 4469, 4480, 4479, 4721, 4722, 4733, 4732
23662, 4469, 440, 441, 4480, 4722, 508, 509, 4733
23663, 361, 4470, 4481, 362, 475, 4723, 4734, 476
23664, 4470, 4471, 4482, 4481, 4723, 4724, 4735, 4734
23665, 4471, 4472, 4483, 4482, 4724, 4725, 4736, 4735
23666, 4472, 4473, 4484, 4483, 4725, 4726, 4737, 4736
23667, 4473, 4474, 4485, 4484, 4726, 4727, 4738, 4737
23668, 4474, 4475, 4486, 4485, 4727, 4728, 4739, 4738
23669, 4475, 4476, 4487, 4486, 4728, 4729, 4740, 4739
23670, 4476, 4477, 4488, 4487, 4729, 4730, 4741, 4740
23671, 4477, 4478, 4489, 4488, 4730, 4731, 4742, 4741
23672, 4478, 4479, 4490, 4489, 4731, 4732, 4743, 4742
23673, 4479, 4480, 4491, 4490, 4732, 4733, 4744, 4743
23674, 4480, 441, 442, 4491, 4733, 509, 510, 4744
23675, 362, 4481, 4492, 363, 476, 4734, 4745, 477
23676, 4481, 4482, 4493, 4492, 4734, 4735, 4746, 4745
23677, 4482, 4483, 4494, 4493, 4735, 4736, 4747, 4746
23678, 4483, 4484, 4495, 4494, 4736, 4737, 4748, 4747
23679, 4484, 4485, 4496, 4495, 4737, 4738, 4749, 4748
23680, 4485, 4486, 4497, 4496, 4738, 4739, 4750, 4749
23681, 4486, 4487, 4498, 4497, 4739, 4740, 4751, 4750
23682, 4487, 4488, 4499, 4498, 4740, 4741, 4752, 4751
23683, 4488, 4489, 4500, 4499, 4741, 4742, 4753, 4752
23684, 4489, 4490, 4501, 4500, 4742, 4743, 4754, 4753
23685, 4490, 4491, 4502, 4501, 4743, 4744, 4755, 4754
23686, 4491, 442, 443, 4502, 4744, 510, 511, 4755
23687, 363, 4492, 4503, 364, 477, 4745, 4756, 478
23688, 4492, 4493, 4504, 4503, 4745, 4746, 4757, 4756
23689, 4493, 4494, 4505, 4504, 4746, 4747, 4758, 4757
23690, 4494, 4495, 4506, 4505, 4747, 4748, 4759, 4758
23691, 4495, 4496, 4507, 4506, 4748, 4749, 4760, 4759
23692, 4496, 4497, 4508, 4507, 4749, 4750, 4761, 4760
23693, 4497, 4498, 4509, 4508, 4750, 4751, 4762, 4761
23694, 4498, 4499, 4510, 4509, 4751, 4752, 4763, 4762
23695, 4499, 4500, 4511, 4510, 4752, 4753, 4764, 4763
23696, 4500, 4501, 4512, 4511, 4753, 4754, 4765, 4764
23697, 4501, 4502, 4513, 4512, 4754, 4755, 4766, 4765
23698, 4502, 443, 444, 4513, 4755, 511, 512, 4766
23699, 364, 4503, 4514, 365, 478, 4756, 4767, 479
23700, 4503, 4504, 4515, 4514, 4756, 4757, 4768, 4767
23701, 4504, 4505, 4516, 4515, 4757, 4758, 4769, 4768
23702, 4505, 4506, 4517, 4516, 4758, 4759, 4770, 4769
23703, 4506, 4507, 4518, 4517, 4759, 4760, 4771, 4770
23704, 4507, 4508, 4519, 4518, 4760, 4761, 4772, 4771
23705, 4508, 4509, 4520, 4519, 4761, 4762, 4773, 4772
23706, 4509, 4510, 4521, 4520, 4762, 4763, 4774, 4773
23707, 4510, 4511, 4522, 4521, 4763, 4764, 4775, 4774
23708, 4511, 4512, 4523, 4522, 4764, 4765, 4776, 4775
23709, 4512, 4513, 4524, 4523, 4765, 4766, 4777, 4776
23710, 4513, 444, 445, 4524, 4766, 512, 513, 4777
23711, 365, 4514, 4525, 366, 479, 4767, 4778, 480
23712, 4514, 4515, 4526, 4525, 4767, 4768, 4779, 4778
23713, 4515, 4516, 4527, 4526, 4768, 4769, 4780, 4779
23714, 4516, 4517, 4528, 4527, 4769, 4770, 4781, 4780
23715, 4517, 4518, 4529, 4528, 4770, 4771, 4782, 4781
23716, 4518, 4519, 4530, 4529, 4771, 4772, 4783, 4782
23717, 4519, 4520, 4531, 4530, 4772, 4773, 4784, 4783
23718, 4520, 4521, 4532, 4531, 4773, 4774, 4785, 4784
23719, 4521, 4522, 4533, 4532, 4774, 4775, 4786, 4785
23720, 4522, 4523, 4534, 4533, 4775, 4776, 4787, 4786
23721, 4523, 4524, 4535, 4534, 4776, 4777, 4788, 4787
23722, 4524, 445, 446, 4535, 4777, 513, 514, 4788
23723, 366, 4525, 4536, 367, 480, 4778, 4789, 481
23724, 4525, 4526, 4537, 4536, 4778, 4779, 4790, 4789
23725, 4526, 4527, 4538, 4537, 4779, 4780, 4791, 4790
23726, 4527, 4528, 4539, 4538, 4780, 4781, 4792, 4791
23727, 4528, 4529, 4540, 4539, 4781, 4782, 4793, 4792
23728, 4529, 4530, 4541, 4540, 4782, 4783, 4794, 4793
23729, 4530, 4531, 4542, 4541, 4783, 4784, 4795, 4794
23730, 4531, 4532, 4543, 4542, 4784, 4785, 4796, 4795
23731, 4532, 4533, 4544, 4543, 4785, 4786, 4797, 4796
23732, 4533, 4534, 4545, 4544, 4786, 4787, 4798, 4797
23733, 4534, 4535, 4546, 4545, 4787, 4788, 4799, 4798
23734, 4535, 446, 447, 4546, 4788, 514, 515, 4799
23735, 367, 4536, 4547, 368, 481, 4789, 4800, 482
23736, 4536, 4537, 4548, 4547, 4789, 4790, 4801, 4800
23737, 4537, 4538, 4549, 4548, 4790, 4791, 4802, 4801
23738, 4538, 4539, 4550, 4549, 4791, 4792, 4803, 4802
23739, 4539, 4540, 4551, 4550, 4792, 4793, 4804, 4803
23740, 4540, 4541, 4552, 4551, 4793, 4794, 4805, 4804
23741, 4541, 4542, 4553, 4552, 4794, 4795, 4806, 4805
23742, 4542, 4543, 4554, 4553, 4795, 4796, 4807, 4806
23743, 4543, 4544, 4555, 4554, 4796, 4797, 4808, 4807
23744, 4544, 4545, 4556, 4555, 4797, 4798, 4809, 4808
23745, 4545, 4546, 4557, 4556, 4798, 4799, 4810, 4809
23746, 4546, 447, 448, 4557, 4799, 515, 516, 4810
23747, 368, 4547, 4558, 369, 482, 4800, 4811, 483
23748, 4547, 4548, 4559, 4558, 4800, 4801, 4812, 4811
23749, 4548, 4549, 4560, 4559, 4801, 4802, 4813, 4812
23750, 4549, 4550, 4561, 4560, 4802, 4803, 4814, 4813
23751, 4550, 4551, 4562, 4561, 4803, 4804, 4815, 4814
23752, 4551, 4552, 4563, 4562, 4804, 4805, 4816, 4815
23753, 4552, 4553, 4564, 4563, 4805, 4806, 4817, 4816
23754, 4553, 4554, 4565, 4564, 4806, 4807, 4818, 4817
23755, 4554, 4555, 4566, 4565, 4807, 4808, 4819, 4818
23756, 4555, 4556, 4567, 4566, 4808, 4809, 4820, 4819
23757, 4556, 4557, 4568, 4567, 4809, 4810, 4821, 4820
23758, 4557, 448, 449, 4568, 4810, 516, 517, 4821
23759, 369, 4558, 4569, 370, 483, 4811, 4822, 484
23760, 4558, 4559, 4570, 4569, 4811, 4812, 4823, 4822
23761, 4559, 4560, 4571, 4570, 4812, 4813, 4824, 4823
23762, 4560, 4561, 4572, 4571, 4813, 4814, 4825, 4824
23763, 4561, 4562, 4573, 4572, 4814, 4815, 4826, 4825
23764, 4562, 4563, 4574, 4573, 4815, 4816, 4827, 4826
23765, 4563, 4564, 4575, 4574, 4816, 4817, 4828, 4827
23766, 4564, 4565, 4576, 4575, 4817, 4818, 4829, 4828
23767, 4565, 4566, 4577, 4576, 4818, 4819, 4830, 4829
23768, 4566, 4567, 4578, 4577, 4819, 4820, 4831, 4830
23769, 4567, 4568, 4579, 4578, 4820, 4821, 4832, 4831
23770, 4568, 449, 450, 4579, 4821, 517, 518, 4832
23771, 370, 4569, 4580, 371, 484, 4822, 4833, 485
23772, 4569, 4570, 4581, 4580, 4822, 4823, 4834, 4833
23773, 4570, 4571, 4582, 4581, 4823, 4824, 4835, 4834
23774, 4571, 4572, 4583, 4582, 4824, 4825, 4836, 4835
23775, 4572, 4573, 4584, 4583, 4825, 4826, 4837, 4836
23776, 4573, 4574, 4585, 4584, 4826, 4827, 4838, 4837
23777, 4574, 4575, 4586, 4585, 4827, 4828, 4839, 4838
23778, 4575, 4576, 4587, 4586, 4828, 4829, 4840, 4839
23779, 4576, 4577, 4588, 4587, 4829, 4830, 4841, 4840
23780, 4577, 4578, 4589, 4588, 4830, 4831, 4842, 4841
23781, 4578, 4579, 4590, 4589, 4831, 4832, 4843, 4842
23782, 4579, 450, 451, 4590, 4832, 518, 519, 4843
23783, 371, 4580, 4591, 372, 485, 4833, 4844, 486
23784, 4580, 4581, 4592, 4591, 4833, 4834, 4845, 4844
23785, 4581, 4582, 4593, 4592, 4834, 4835, 4846, 4845
23786, 4582, 4583, 4594, 4593, 4835, 4836, 4847, 4846
23787, 4583, 4584, 4595, 4594, 4836, 4837, 4848, 4847
23788, 4584, 4585, 4596, 4595, 4837, 4838, 4849, 4848
23789, 4585, 4586, 4597, 4596, 4838, 4839, 4850, 4849
23790, 4586, 4587, 4598, 4597, 4839, 4840, 4851, 4850
23791, 4587, 4588, 4599, 4598, 4840, 4841, 4852, 4851
23792, 4588, 4589, 4600, 4599, 4841, 4842, 4853, 4852
23793, 4589, 4590, 4601, 4600, 4842, 4843, 4854, 4853
23794, 4590, 451, 452, 4601, 4843, 519, 520, 4854
23795, 372, 4591, 4602, 373, 486, 4844, 4855, 487
23796, 4591, 4592, 4603, 4602, 4844, 4845, 4856, 4855
23797, 4592, 4593, 4604, 4603, 4845, 4846, 4857, 4856
23798, 4593, 4594, 4605, 4604, 4846, 4847, 4858, 4857
23799, 4594, 4595, 4606, 4605, 4847, 4848, 4859, 4858
23800, 4595, 4596, 4607, 4606, 4848, 4849, 4860, 4859
23801, 4596, 4597, 4608, 4607, 4849, 4850, 4861, 4860
23802, 4597, 4598, 4609, 4608, 4850, 4851, 4862, 4861
23803, 4598, 4599, 4610, 4609, 4851, 4852, 4863, 4862
23804, 4599, 4600, 4611, 4610, 4852, 4853, 4864, 4863
23805, 4600, 4601, 4612, 4611, 4853, 4854, 4865, 4864
23806, 4601, 452, 453, 4612, 4854, 520, 521, 4865
23807, 373, 4602, 4613, 374, 487, 4855, 4866, 488
23808, 4602, 4603, 4614, 4613, 4855, 4856, 4867, 4866
23809, 4603, 4604, 4615, 4614, 4856, 4857, 4868, 4867
23810, 4604, 4605, 4616, 4615, 4857, 4858, 4869, 4868
23811, 4605, 4606, 4617, 4616, 4858, 4859, 4870, 4869
23812, 4606, 4607, 4618, 4617, 4859, 4860, 4871, 4870
23813, 4607, 4608, 4619, 4618, 4860, 4861, 4872, 4871
23814, 4608, 4609, 4620, 4619, 4861, 4862, 4873, 4872
23815, 4609, 4610, 4621, 4620, 4862, 4863, 4874, 4873
23816, 4610, 4611, 4622, 4621, 4863, 4864, 4875, 4874
23817, 4611, 4612, 4623, 4622, 4864, 4865, 4876, 4875
23818, 4612, 453, 454, 4623, 4865, 521, 522, 4876
23819, 374, 4613, 4624, 375, 488, 4866, 4877, 489
23820, 4613, 4614, 4625, 4624, 4866, 4867, 4878, 4877
23821, 4614, 4615, 4626, 4625, 4867, 4868, 4879, 4878
23822, 4615, 4616, 4627, 4626, 4868, 4869, 4880, 4879
23823, 4616, 4617, 4628, 4627, 4869, 4870, 4881, 4880
23824, 4617, 4618, 4629, 4628, 4870, 4871, 4882, 4881
23825, 4618, 4619, 4630, 4629, 4871, 4872, 4883, 4882
23826, 4619, 4620, 4631, 4630, 4872, 4873, 4884, 4883
23827, 4620, 4621, 4632, 4631, 4873, 4874, 4885, 4884
23828, 4621, 4622, 4633, 4632, 4874, 4875, 4886, 4885
23829, 4622, 4623, 4634, 4633, 4875, 4876, 4887, 4886
23830, 4623, 454, 455, 4634, 4876, 522, 523, 4887
23831, 375, 4624, 4635, 376, 489, 4877, 4888, 490
23832, 4624, 4625, 4636, 4635, 4877, 4878, 4889, 4888
23833, 4625, 4626, 4637, 4636, 4878, 4879, 4890, 4889
23834, 4626, 4627, 4638, 4637, 4879, 4880, 4891, 4890
23835, 4627, 4628, 4639, 4638, 4880, 4881, 4892, 4891
23836, 4628, 4629, 4640, 4639, 4881, 4882, 4893, 4892
23837, 4629, 4630, 4641, 4640, 4882, 4883, 4894, 4893
23838, 4630, 4631, 4642, 4641, 4883, 4884, 4895, 4894
23839, 4631, 4632, 4643, 4642, 4884, 4885, 4896, 4895
23840, 4632, 4633, 4644, 4643, 4885, 4886, 4897, 4896
23841, 4633, 4634, 4645, 4644, 4886, 4887, 4898, 4897
23842, 4634, 455, 456, 4645, 4887, 523, 524, 4898
23843, 376, 4635, 4646, 377, 490, 4888, 4899, 491
23844, 4635, 4636, 4647, 4646, 4888, 4889, 4900, 4899
23845, 4636, 4637, 4648, 4647, 4889, 4890, 4901, 4900
23846, 4637, 4638, 4649, 4648, 4890, 4891, 4902, 4901
23847, 4638, 4639, 4650, 4649, 4891, 4892, 4903, 4902
23848, 4639, 4640, 4651, 4650, 4892, 4893, 4904, 4903
23849, 4640, 4641, 4652, 4651, 4893, 4894, 4905, 4904
23850, 4641, 4642, 4653, 4652, 4894, 4895, 4906, 4905
23851, 4642, 4643, 4654, 4653, 4895, 4896, 4907, 4906
23852, 4643, 4644, 4655, 4654, 4896, 4897, 4908, 4907
23853, 4644, 4645, 4656, 4655, 4897, 4898, 4909, 4908
23854, 4645, 456, 457, 4656, 4898, 524, 525, 4909
23855, 377, 4646, 401, 13, 491, 4899, 492, 17
23856, 4646, 4647, 402, 401, 4899, 4900, 493, 492
23857, 4647, 4648, 403, 402, 4900, 4901, 494, 493
23858, 4648, 4649, 404, 403, 4901, 4902, 495, 494
23859, 4649, 4650, 405, 404, 4902, 4903, 496, 495
23860, 4650, 4651, 406, 405, 4903, 4904, 497, 496
23861, 4651, 4652, 407, 406, 4904, 4905, 498, 497
23862, 4652, 4653, 408, 407, 4905, 4906, 499, 498
23863, 4653, 4654, 409, 408, 4906, 4907, 500, 499
23864, 4654, 4655, 410, 409, 4907, 4908, 501, 500
23865, 4655, 4656, 411, 410, 4908, 4909, 502, 501
23866, 4656, 457, 15, 411, 4909, 525, 19, 502
*ELEMENT, type=C3D8, ELSET=Volume5
23867, 18, 526, 4657, 469, 539, 5024, 18954, 4910
23868, 539, 5024, 18954, 4910, 540, 5025, 18955, 4911
23869, 540, 5025, 18955, 4911, 22, 602, 5046, 541
23870, 526, 527, 4658, 4657, 5024, 5026, 18956, 18954
23871, 5024, 5026, 18956, 18954, 5025, 5027, 18957, 18955
23872, 5025, 5027, 18957, 18955, 602, 603, 5047, 5046
23873, 527, 528, 4659, 4658, 5026, 5028, 18958, 18956
23874, 5026, 5028, 18958, 18956, 5027, 5029, 18959, 18957
23875, 5027, 5029, 18959, 18957, 603, 604, 5048, 5047
23876, 528, 529, 4660, 4659, 5028, 5030, 18960, 18958
23877, 5028, 5030, 18960, 18958, 5029, 5031, 18961, 18959
23878, 5029, 5031, 18961, 18959, 604, 605, 5049, 5048
23879, 529, 530, 4661, 4660, 5030, 5032, 18962, 18960
23880, 5030, 5032, 18962, 18960, 5031, 5033, 18963, 18961
23881, 5031, 5033, 18963, 18961, 605, 606, 5050, 5049
23882, 530, 531, 4662, 4661, 5032, 5034, 18964, 18962
23883, 5032, 5034, 18964, 18962, 5033, 5035, 18965, 18963
23884, 5033, 5035, 18965, 18963, 606, 607, 5051, 5050
23885, 531, 532, 4663, 4662, 5034, 5036, 18966, 18964
23886, 5034, 5036, 18966, 18964, 5035, 5037, 18967, 18965
23887, 5035, 5037, 18967, 18965, 607, 608, 5052, 5051
23888, 532, 533, 4664, 4663, 5036, 5038, 18968, 18966
23889, 5036, 5038, 18968, 18966, 5037, 5039, 18969, 18967
23890, 5037, 5039, 18969, 18967, 608, 609, 5053, 5052
23891, 533, 534, 4665, 4664, 5038, 5040, 18970, 18968
23892, 5038, 5040, 18970, 18968, 5039, 5041, 18971, 18969
23893, 5039, 5041, 18971, 18969, 609, 610, 5054, 5053
23894, 534, 535, 4666, 4665, 5040, 5042, 18972, 18970
23895, 5040, 5042, 18972, 18970, 5041, 5043, 18973, 18971
23896, 5041, 5043, 18973, 18971, 610, 611, 5055, 5054
23897, 535, 536, 4667, 4666, 5042, 5044, 18974, 18972
23898, 5042, 5044, 18974, 18972, 5043, 5045, 18975, 18973
23899, 5043, 5045, 18975, 18973, 611, 612, 5056, 5055
23900, 536, 20, 503, 4667, 5044, 577, 4978, 18974
23901, 5044, 577, 4978, 18974, 5045, 578, 4979, 18975
23902, 5045, 578, 4979, 18975, 612, 24, 579, 5056
23903, 469, 4657, 4668, 470, 4910, 18954, 18976, 4912
23904, 4910, 18954, 18976, 4912, 4911, 18955, 18977, 4913
23905, 4911, 18955, 18977, 4913, 541, 5046, 5057, 542
23906, 4657, 4658, 4669, 4668, 18954, 18956, 18978, 18976
23907, 18954, 18956, 18978, 18976, 18955, 18957, 18979, 18977
23908, 18955, 18957, 18979, 18977, 5046, 5047, 5058, 5057
23909, 4658, 4659, 4670, 4669, 18956, 18958, 18980, 18978
23910, 18956, 18958, 18980, 18978, 18957, 18959, 18981, 18979
23911, 18957, 18959, 18981, 18979, 5047, 5048, 5059, 5058
23912, 4659, 4660, 4671, 4670, 18958, 18960, 18982, 18980
23913, 18958, 18960, 18982, 18980, 18959, 18961, 18983, 18981
23914, 18959, 18961, 18983, 18981, 5048, 5049, 5060, 5059
23915, 4660, 4661, 4672, 4671, 18960, 18962, 18984, 18982
23916, 18960, 18962, 18984, 18982, 18961, 18963, 18985, 18983
23917, 18961, 18963, 18985, 18983, 5049, 5050, 5061, 5060
23918, 4661, 4662, 4673, 4672, 18962, 18964, 18986, 18984
23919, 18962, 18964, 18986, 18984, 18963, 18965, 18987, 18985
23920, 18963, 18965, 18987, 18985, 5050, 5051, 5062, 5061
23921, 4662, 4663, 4674, 4673, 18964, 18966, 18988, 18986
23922, 18964, 18966, 18988, 18986, 18965, 18967, 18989, 18987
23923, 18965, 18967, 18989, 18987, 5051, 5052, 5063, 5062
23924, 4663, 4664, 4675, 4674, 18966, 18968, 18990, 18988
23925, 18966, 18968, 18990, 18988, 18967, 18969, 18991, 18989
23926, 18967, 18969, 18991, 18989, 5052, 5053, 5064, 5063
23927, 4664, 4665, 4676, 4675, 18968, 18970, 18992, 18990
23928, 18968, 18970, 18992, 18990, 18969, 18971, 18993, 18991
23929, 18969, 18971, 18993, 18991, 5053, 5054, 5065, 5064
23930, 4665, 4666, 4677, 4676, 18970, 18972, 18994, 18992
23931, 18970, 18972, 18994, 18992, 18971, 18973, 18995, 18993
23932, 18971, 18973, 18995, 18993, 5054, 5055, 5066, 5065
23933, 4666, 4667, 4678, 4677, 18972, 18974, 18996, 18994
23934, 18972, 18974, 18996, 18994, 18973, 18975, 18997, 18995
23935, 18973, 18975, 18997, 18995, 5055, 5056, 5067, 5066
23936, 4667, 503, 504, 4678, 18974, 4978, 4980, 18996
23937, 18974, 4978, 4980, 18996, 18975, 4979, 4981, 18997
23938, 18975, 4979, 4981, 18997, 5056, 579, 580, 5067
23939, 470, 4668, 4679, 471, 4912, 18976, 18998, 4914
23940, 4912, 18976, 18998, 4914, 4913, 18977, 18999, 4915
23941, 4913, 18977, 18999, 4915, 542, 5057, 5068, 543
23942, 4668, 4669, 4680, 4679, 18976, 18978, 19000, 18998
23943, 18976, 18978, 19000, 18998, 18977, 18979, 19001, 18999
23944, 18977, 18979, 19001, 18999, 5057, 5058, 5069, 5068
23945, 4669, 4670, 4681, 4680, 18978, 18980, 19002, 19000
23946, 18978, 18980, 19002, 19000, 18979, 18981, 19003, 19001
23947, 18979, 18981, 19003, 19001, 5058, 5059, 5070, 5069
23948, 4670, 4671, 4682, 4681, 18980, 18982, 19004, 19002
23949, 18980, 18982, 19004, 19002, 18981, 18983, 19005, 19003
23950, 18981, 18983, 19005, 19003, 5059, 5060, 5071, 5070
23951, 4671, 4672, 4683, 4682, 18982, 18984, 19006, 19004
23952, 18982, 18984, 19006, 19004, 18983, 18985, 19007, 19005
23953, 18983, 18985, 19007, 19005, 5060, 5061, 5072, 5071
23954, 4672, 4673, 4684, 4683, 18984, 18986, 19008, 19006
23955, 18984, 18986, 19008, 19006, 18985, 18987, 19009, 19007
23956, 18985, 18987, 19009, 19007, 5061, 5062, 5073, 5072
23957, 4673, 4674, 4685, 4684, 18986, 18988, 19010, 19008
23958, 18986, 18988, 19010, 19008, 18987, 18989, 19011, 19009
23959, 18987, 18989, 19011, 19009, 5062, 5063, 5074, 5073
23960, 4674, 4675, 4686, 4685, 18988, 18990, 19012, 19010
23961, 18988, 18990, 19012, 19010, 18989, 18991, 19013, 19011
23962, 18989, 18991, 19013, 19011, 5063, 5064, 5075, 5074
23963, 4675, 4676, 4687, 4686, 18990, 18992, 19014, 19012
23964, 18990, 18992, 19014, 19012, 18991, 18993, 19015, 19013
23965, 18991, 18993, 19015, 19013, 5064, 5065, 5076, 5075
23966, 4676, 4677, 4688, 4687, 18992, 18994, 19016, 19014
23967, 18992, 18994, 19016, 19014, 18993, 18995, 19017, 19015
23968, 18993, 18995, 19017, 19015, 5065, 5066, 5077, 5076
23969, 4677, 4678, 4689, 4688, 18994, 18996, 19018, 19016
23970, 18994, 18996, 19018, 19016, 18995, 18997, 19019, 19017
23971, 18995, 18997, 19019, 19017, 5066, 5067, 5078, 5077
23972, 4678, 504, 505, 4689, 18996, 4980, 4982, 19018
23973, 18996, 4980, 4982, 19018, 18997, 4981, 4983, 19019
23974, 18997, 4981, 4983, 19019, 5067, 580, 581, 5078
23975, 471, 4679, 4690, 472, 4914, 18998, 19020, 4916
23976, 4914, 18998, 19020, 4916, 4915, 18999, 19021, 4917
23977, 4915, 18999, 19021, 4917, 543, 5068, 5079, 544
23978, 4679, 4680, 4691, 4690, 18998, 19000, 19022, 19020
23979, 18998, 19000, 19022, 19020, 18999, 19001, 19023, 19021
23980, 18999, 19001, 19023, 19021, 5068, 5069, 5080, 5079
23981, 4680, 4681, 4692, 4691, 19000, 19002, 19024, 19022
23982, 19000, 19002, 19024, 19022, 19001, 19003, 19025, 19023
23983, 19001, 19003, 19025, 19023, 5069, 5070, 5081, 5080
23984, 4681, 4682, 4693, 4692, 19002, 19004, 19026, 19024
23985, 19002, 19004, 19026, 19024, 19003, 19005, 19027, 19025
23986, 19003, 19005, 19027, 19025, 5070, 5071, 5082, 5081
23987, 4682, 4683, 4694, 4693, 19004, 19006, 19028, 19026
23988, 19004, 19006, 19028, 19026, 19005, 19007, 19029, 19027
23989, 19005, 19007, 19029, 19027, 5071, 5072, 5083, 5082
23990, 4683, 4684, 4695, 4694, 19006, 19008, 19030, 19028
23991, 19006, 19008, 19030, 19028, 19007, 19009, 19031, 19029
23992, 19007, 19009, 19031, 19029, 5072, 5073, 5084, 5083
23993, 4684, 4685, 4696, 4695, 19008, 19010, 19032, 19030
23994, 19008, 19010, 19032, 19030, 19009, 19011, 19033, 19031
23995, 19009, 19011, 19033, 19031, 5073, 5074, 5085, 5084
23996, 4685, 4686, 4697, 4696, 19010, 19012, 19034, 19032
23997, 19010, 19012, 19034, 19032, 19011, 19013, 19035, 19033
23998, 19011, 19013, 19035, 19033, 5074, 5075, 5086, 5085
23999, 4686, 4687, 4698, 4697, 19012, 19014, 19036, 19034
24000, 19012, 19014, 19036, 19034, 19013, 19015, 19037, 19035
24001, 19013, 19015, 19037, 19035, 5075, 5076, 5087, 5086
24002, 4687, 4688, 4699, 4698, 19014, 19016, 19038, 19036
24003, 19014, 19016, 19038, 19036, 19015, 19017, 19039, 19037
24004, 19015, 19017, 19039, 19037, 5076, 5077, 5088, 5087
24005, 4688, 4689, 4700, 4699, 19016, 19018, 19040, 19038
24006, 19016, 19018, 19040, 19038, 19017, 19019, 19041, 19039
24007, 19017, 19019, 19041, 19039, 5077, 5078, 5089, 5088
24008, 4689, 505, 506, 4700, 19018, 4982, 4984, 19040
24009, 19018, 4982, 4984, 19040, 19019, 4983, 4985, 19041
24010, 19019, 4983, 4985, 19041, 5078, 581, 582, 5089
24011, 472, 4690, 4701, 473, 4916, 19020, 19042, 4918
24012, 4916, 19020, 19042, 4918, 4917, 19021, 19043, 4919
24013, 4917, 19021, 19043, 4919, 544, 5079, 5090, 545
24014, 4690, 4691, 4702, 4701, 19020, 19022, 19044, 19042
24015, 19020, 19022, 19044, 19042, 19021, 19023, 19045, 19043
24016, 19021, 19023, 19045, 19043, 5079, 5080, 5091, 5090
24017, 4691, 4692, 4703, 4702, 19022, 19024, 19046, 19044
24018, 19022, 19024, 19046, 19044, 19023, 19025, 19047, 19045
24019, 19023, 19025, 19047, 19045, 5080, 5081, 5092, 5091
24020, 4692, 4693, 4704, 4703, 19024, 19026, 19048, 19046
24021, 19024, 19026, 19048, 19046, 19025, 19027, 19049, 19047
24022, 19025, 19027, 19049, 19047, 5081, 5082, 5093, 5092
24023, 4693, 4694, 4705, 4704, 19026, 19028, 19050, 19048
24024, 19026, 19028, 19050, 19048, 19027, 19029, 19051, 19049
24025, 19027, 19029, 19051, 19049, 5082, 5083, 5094, 5093
24026, 4694, 4695, 4706, 4705, 19028, 19030, 19052, 19050
24027, 19028, 19030, 19052, 19050, 19029, 19031, 19053, 19051
24028, 19029, 19031, 19053, 19051, 5083, 5084, 5095, 5094
24029, 4695, 4696, 4707, 4706, 19030, 19032, 19054, 19052
24030, 19030, 19032, 19054, 19052, 19031, 19033, 19055, 19053
24031, 19031, 19033, 19055, 19053, 5084, 5085, 5096, 5095
24032, 4696, 4697, 4708, 4707, 19032, 19034, 19056, 19054
24033, 19032, 19034, 19056, 19054, 19033, 19035, 19057, 19055
24034, 19033, 19035, 19057, 19055, 5085, 5086, 5097, 5096
24035, 4697, 4698, 4709, 4708, 19034, 19036, 19058, 19056
24036, 19034, 19036, 19058, 19056, 19035, 19037, 19059, 19057
24037, 19035, 19037, 19059, 19057, 5086, 5087, 5098, 5097
24038, 4698, 4699, 4710, 4709, 19036, 19038, 19060, 19058
24039, 19036, 19038, 19060, 19058, 19037, 19039, 19061, 19059
24040, 19037, 19039, 19061, 19059, 5087, 5088, 5099, 5098
24041, 4699, 4700, 4711, 4710, 19038, 19040, 19062, 19060
24042, 19038, 19040, 19062, 19060, 19039, 19041, 19063, 19061
24043, 19039, 19041, 19063, 19061, 5088, 5089, 5100, 5099
24044, 4700, 506, 507, 4711, 19040, 4984, 4986, 19062
24045, 19040, 4984, 4986, 19062, 19041, 4985, 4987, 19063
24046, 19041, 4985, 4987, 19063, 5089, 582, 583, 5100
24047, 473, 4701, 4712, 474, 4918, 19042, 19064, 4920
24048, 4918, 19042, 19064, 4920, 4919, 19043, 19065, 4921
24049, 4919, 19043, 19065, 4921, 545, 5090, 5101, 546
24050, 4701, 4702, 4713, 4712, 19042, 19044, 19066, 19064
24051, 19042, 19044, 19066, 19064, 19043, 19045, 19067, 19065
24052, 19043, 19045, 19067, 19065, 5090, 5091, 5102, 5101
24053, 4702, 4703, 4714, 4713, 19044, 19046, 19068, 19066
24054, 19044, 19046, 19068, 19066, 19045, 19047, 19069, 19067
24055, 19045, 19047, 19069, 19067, 5091, 5092, 5103, 5102
24056, 4703, 4704, 4715, 4714, 19046, 19048, 19070, 19068
24057, 19046, 19048, 19070, 19068, 19047, 19049, 19071, 19069
24058, 19047, 19049, 19071, 19069, 5092, 5093, 5104, 5103
24059, 4704, 4705, 4716, 4715, 19048, 19050, 19072, 19070
24060, 19048, 19050, 19072, 19070, 19049, 19051, 19073, 19071
24061, 19049, 19051, 19073, 19071, 5093, 5094, 5105, 5104
24062, 4705, 4706, 4717, 4716, 19050, 19052, 19074, 19072
24063, 19050, 19052, 19074, 19072, 19051, 19053, 19075, 19073
24064, 19051, 19053, 19075, 19073, 5094, 5095, 5106, 5105
24065, 4706, 4707, 4718, 4717, 19052, 19054, 19076, 19074
24066, 19052, 19054, 19076, 19074, 19053, 19055, 19077, 19075
24067, 19053, 19055, 19077, 19075, 5095, 5096, 5107, 5106
24068, 4707, 4708, 4719, 4718, 19054, 19056, 19078, 19076
24069, 19054, 19056, 19078, 19076, 19055, 19057, 19079, 19077
24070, 19055, 19057, 19079, 19077, 5096, 5097, 5108, 5107
24071, 4708, 4709, 4720, 4719, 19056, 19058, 19080, 19078
24072, 19056, 19058, 19080, 19078, 19057, 19059, 19081, 19079
24073, 19057, 19059, 19081, 19079, 5097, 5098, 5109, 5108
24074, 4709, 4710, 4721, 4720, 19058, 19060, 19082, 19080
24075, 19058, 19060, 19082, 19080, 19059, 19061, 19083, 19081
24076, 19059, 19061, 19083, 19081, 5098, 5099, 5110, 5109
24077, 4710, 4711, 4722, 4721, 19060, 19062, 19084, 19082
24078, 19060, 19062, 19084, 19082, 19061, 19063, 19085, 19083
24079, 19061, 19063, 19085, 19083, 5099, 5100, 5111, 5110
24080, 4711, 507, 508, 4722, 19062, 4986, 4988, 19084
24081, 19062, 4986, 4988, 19084, 19063, 4987, 4989, 19085
24082, 19063, 4987, 4989, 19085, 5100, 583, 584, 5111
24083, 474, 4712, 4723, 475, 4920, 19064, 19086, 4922
24084, 4920, 19064, 19086, 4922, 4921, 19065, 19087, 4923
24085, 4921, 19065, 19087, 4923, 546, 5101, 5112, 547
24086, 4712, 4713, 4724, 4723, 19064, 19066, 19088, 19086
24087, 19064, 19066, 19088, 19086, 19065, 19067, 19089, 19087
24088, 19065, 19067, 19089, 19087, 5101, 5102, 5113, 5112
24089, 4713, 4714, 4725, 4724, 19066, 19068, 19090, 19088
24090, 19066, 19068, 19090, 19088, 19067, 19069, 19091, 19089
24091, 19067, 19069, 19091, 19089, 5102, 5103, 5114, 5113
24092, 4714, 4715, 4726, 4725, 19068, 19070, 19092, 19090
24093, 19068, 19070, 19092, 19090, 19069, 19071, 19093, 19091
24094, 19069, 19071, 19093, 19091, 5103, 5104, 5115, 5114
24095, 4715, 4716, 4727, 4726, 19070, 19072, 19094, 19092
24096, 19070, 19072, 19094, 19092, 19071, 19073, 19095, 19093
24097, 19071, 19073, 19095, 19093, 5104, 5105, 5116, 5115
24098, 4716, 4717, 4728, 4727, 19072, 19074, 19096, 19094
24099, 19072, 19074, 19096, 19094, 19073, 19075, 19097, 19095
24100, 19073, 19075, 19097, 19095, 5105, 5106, 5117, 5116
24101, 4717, 4718, 4729, 4728, 19074, 19076, 19098, 19096
24102, 19074, 19076, 19098, 19096, 19075, 19077, 19099, 19097
24103, 19075, 19077, 19099, 19097, 5106, 5107, 5118, 5117
24104, 4718, 4719, 4730, 4729, 19076, 19078, 19100, 19098
24105, 19076, 19078, 19100, 19098, 19077, 19079, 19101, 19099
24106, 19077, 19079, 19101, 19099, 5107, 5108, 5119, 5118
24107, 4719, 4720, 4731, 4730, 19078, 19080, 19102, 19100
24108, 19078, 19080, 19102, 19100, 19079, 19081, 19103, 19101
24109, 19079, 19081, 19103, 19101, 5108, 5109, 5120, 5119
24110, 4720, 4721, 4732, 4731, 19080, 19082, 19104, 19102
24111, 19080, 19082, 19104, 19102, 19081, 19083, 19105, 19103
24112, 19081, 19083, 19105, 19103, 5109, 5110, 5121, 5120
24113, 4721, 4722, 4733, 4732, 19082, 19084, 19106, 19104
24114, 19082, 19084, 19106, 19104, 19083, 19085, 19107, 19105
24115, 19083, 19085, 19107, 19105, 5110, 5111, 5122, 5121
24116, 4722, 508, 509, 4733, 19084, 4988, 4990, 19106
24117, 19084, 4988, 4990, 19106, 19085, 4989, 4991, 19107
24118, 19085, 4989, 4991, 19107, 5111, 584, 585, 5122
24119, 475, 4723, 4734, 476, 4922, 19086, 19108, 4924
24120, 4922, 19086, 19108, 4924, 4923, 19087, 19109, 4925
24121, 4923, 19087, 19109, 4925, 547, 5112, 5123, 548
24122, 4723, 4724, 4735, 4734, 19086, 19088, 19110, 19108
24123, 19086, 19088, 19110, 19108, 19087, 19089, 19111, 19109
24124, 19087, 19089, 19111, 19109, 5112, 5113, 5124, 5123
24125, 4724, 4725, 4736, 4735, 19088, 19090, 19112, 19110
24126, 19088, 19090, 19112, 19110, 19089, 19091, 19113, 19111
24127, 19089, 19091, 19113, 19111, 5113, 5114, 5125, 5124
24128, 4725, 4726, 4737, 4736, 19090, 19092, 19114, 19112
24129, 19090, 19092, 19114, 19112, 19091, 19093, 19115, 19113
24130, 19091, 19093, 19115, 19113, 5114, 5115, 5126, 5125
24131, 4726, 4727, 4738, 4737, 19092, 19094, 19116, 19114
24132, 19092, 19094, 19116, 19114, 19093, 19095, 19117, 19115
24133, 19093, 19095, 19117, 19115, 5115, 5116, 5127, 5126
24134, 4727, 4728, 4739, 4738, 19094, 19096, 19118, 19116
24135, 19094, 19096, 19118, 19116, 19095, 19097, 19119, 19117
24136, 19095, 19097, 19119, 19117, 5116, 5117, 5128, 5127
24137, 4728, 4729, 4740, 4739, 19096, 19098, 19120, 19118
24138, 19096, 19098, 19120, 19118, 19097, 19099, 19121, 19119
24139, 19097, 19099, 19121, 19119, 5117, 5118, 5129, 5128
24140, 4729, 4730, 4741, 4740, 19098, 19100, 19122, 19120
24141, 19098, 19100, 19122, 19120, 19099, 19101, 19123, 19121
24142, 19099, 19101, 19123, 19121, 5118, 5119, 5130, 5129
24143, 4730, 4731, 4742, 4741, 19100, 19102, 19124, 19122
24144, 19100, 19102, 19124, 19122, 19101, 19103, 19125, 19123
24145, 19101, 19103, 19125, 19123, 5119, 5120, 5131, 5130
24146, 4731, 4732, 4743, 4742, 19102, 19104, 19126, 19124
24147, 19102, 19104, 19126, 19124, 19103, 19105, 19127, 19125
24148, 19103, 19105, 19127, 19125, 5120, 5121, 5132, 5131
24149, 4732, 4733, 4744, 4743, 19104, 19106, 19128, 19126
24150, 19104, 19106, 19128, 19126, 19105, 19107, 19129, 19127
24151, 19105, 19107, 19129, 19127, 5121, 5122, 5133, 5132
24152, 4733, 509, 510, 4744, 19106, 4990, 4992, 19128
24153, 19106, 4990, 4992, 19128, 19107, 4991, 4993, 19129
24154, 19107, 4991, 4993, 19129, 5122, 585, 586, 5133
24155, 476, 4734, 4745, 477, 4924, 19108, 19130, 4926
24156, 4924, 19108, 19130, 4926, 4925, 19109, 19131, 4927
24157, 4925, 19109, 19131, 4927, 548, 5123, 5134, 549
24158, 4734, 4735, 4746, 4745, 19108, 19110, 19132, 19130
24159, 19108, 19110, 19132, 19130, 19109, 19111, 19133, 19131
24160, 19109, 19111, 19133, 19131, 5123, 5124, 5135, 5134
24161, 4735, 4736, 4747, 4746, 19110, 19112, 19134, 19132
24162, 19110, 19112, 19134, 19132, 19111, 19113, 19135, 19133
24163, 19111, 19113, 19135, 19133, 5124, 5125, 5136, 5135
24164, 4736, 4737, 4748, 4747, 19112, 19114, 19136, 19134
24165, 19112, 19114, 19136, 19134, 19113, 19115, 19137, 19135
24166, 19113, 19115, 19137, 19135, 5125, 5126, 5137, 5136
24167, 4737, 4738, 4749, 4748, 19114, 19116, 19138, 19136
24168, 19114, 19116, 19138, 19136, 19115, 19117, 19139, 19137
24169, 19115, 19117, 19139, 19137, 5126, 5127, 5138, 5137
24170, 4738, 4739, 4750, 4749, 19116, 19118, 19140, 19138
24171, 19116, 19118, 19140, 19138, 19117, 19119, 19141, 19139
24172, 19117, 19119, 19141, 19139, 5127, 5128, 5139, 5138
24173, 4739, 4740, 4751, 4750, 19118, 19120, 19142, 19140
24174, 19118, 19120, 19142, 19140, 19119, 19121, 19143, 19141
24175, 19119, 19121, 19143, 19141, 5128, 5129, 5140, 5139
24176, 4740, 4741, 4752, 4751, 19120, 19122, 19144, 19142
24177, 19120, 19122, 19144, 19142, 19121, 19123, 19145, 19143
24178, 19121, 19123, 19145, 19143, 5129, 5130, 5141, 5140
24179, 4741, 4742, 4753, 4752, 19122, 19124, 19146, 19144
24180, 19122, 19124, 19146, 19144, 19123, 19125, 19147, 19145
24181, 19123, 19125, 19147, 19145, 5130, 5131, 5142, 5141
24182, 4742, 4743, 4754, 4753, 19124, 19126, 19148, 19146
24183, 19124, 19126, 19148, 19146, 19125, 19127, 19149, 19147
24184, 19125, 19127, 19149, 19147, 5131, 5132, 5143, 5142
24185, 4743, 4744, 4755, 4754, 19126, 19128, 19150, 19148
24186, 19126, 19128, 19150, 19148, 19127, 19129, 19151, 19149
24187, 19127, 19129, 19151, 19149, 5132, 5133, 5144, 5143
24188, 4744, 510, 511, 4755, 19128, 4992, 4994, 19150
24189, 19128, 4992, 4994, 19150, 19129, 4993, 4995, 19151
24190, 19129, 4993, 4995, 19151, 5133, 586, 587, 5144
24191, 477, 4745, 4756, 478, 4926, 19130, 19152, 4928
24192, 4926, 19130, 19152, 4928, 4927, 19131, 19153, 4929
24193, 4927, 19131, 19153, 4929, 549, 5134, 5145, 550
24194, 4745, 4746, 4757, 4756, 19130, 19132, 19154, 19152
24195, 19130, 19132, 19154, 19152, 19131, 19133, 19155, 19153
24196, 19131, 19133, 19155, 19153, 5134, 5135, 5146, 5145
24197, 4746, 4747, 4758, 4757, 19132, 19134, 19156, 19154
24198, 19132, 19134, 19156, 19154, 19133, 19135, 19157, 19155
24199, 19133, 19135, 19157, 19155, 5135, 5136, 5147, 5146
24200, 4747, 4748, 4759, 4758, 19134, 19136, 19158, 19156
24201, 19134, 19136, 19158, 19156, 19135, 19137, 19159, 19157
24202, 19135, 19137, 19159, 19157, 5136, 5137, 5148, 5147
24203, 4748, 4749, 4760, 4759, 19136, 19138, 19160, 19158
24204, 19136, 19138, 19160, 19158, 19137, 19139, 19161, 19159
24205, 19137, 19139, 19161, 19159, 5137, 5138, 5149, 5148
24206, 4749, 4750, 4761, 4760, 19138, 19140, 19162, 19160
24207, 19138, 19140, 19162, 19160, 19139, 19141, 19163, 19161
24208, 19139, 19141, 19163, 19161, 5138, 5139, 5150, 5149
24209, 4750, 4751, 4762, 4761, 19140, 19142, 19164, 19162
24210, 19140, 19142, 19164, 19162, 19141, 19143, 19165, 19163
24211, 19141, 19143, 19165, 19163, 5139, 5140, 5151, 5150
24212, 4751, 4752, 4763, 4762, 19142, 19144, 19166, 19164
24213, 19142, 19144, 19166, 19164, 19143, 19145, 19167, 19165
24214, 19143, 19145, 19167, 19165, 5140, 5141, 5152, 5151
24215, 4752, 4753, 4764, 4763, 19144, 19146, 19168, 19166
24216, 19144, 19146, 19168, 19166, 19145, 19147, 19169, 19167
24217, 19145, 19147, 19169, 19167, 5141, 5142, 5153, 5152
24218, 4753, 4754, 4765, 4764, 19146, 19148, 19170, 19168
24219, 19146, 19148, 19170, 19168, 19147, 19149, 19171, 19169
24220, 19147, 19149, 19171, 19169, 5142, 5143, 5154, 5153
24221, 4754, 4755, 4766, 4765, 19148, 19150, 19172, 19170
24222, 19148, 19150, 19172, 19170, 19149, 19151, 19173, 19171
24223, 19149, 19151, 19173, 19171, 5143, 5144, 5155, 5154
24224, 4755, 511, 512, 4766, 19150, 4994, 4996, 19172
24225, 19150, 4994, 4996, 19172, 19151, 4995, 4997, 19173
24226, 19151, 4995, 4997, 19173, 5144, 587, 588, 5155
24227, 478, 4756, 4767, 479, 4928, 19152, 19174, 4930
24228, 4928, 19152, 19174, 4930, 4929, 19153, 19175, 4931
24229, 4929, 19153, 19175, 4931, 550, 5145, 5156, 551
24230, 4756, 4757, 4768, 4767, 19152, 19154, 19176, 19174
24231, 19152, 19154, 19176, 19174, 19153, 19155, 19177, 19175
24232, 19153, 19155, 19177, 19175, 5145, 5146, 5157, 5156
24233, 4757, 4758, 4769, 4768, 19154, 19156, 19178, 19176
24234, 19154, 19156, 19178, 19176, 19155, 19157, 19179, 19177
24235, 19155, 19157, 19179, 19177, 5146, 5147, 5158, 5157
24236, 4758, 4759, 4770, 4769, 19156, 19158, 19180, 19178
24237, 19156, 19158, 19180, 19178, 19157, 19159, 19181, 19179
24238, 19157, 19159, 19181, 19179, 5147, 5148, 5159, 5158
24239, 4759, 4760, 4771, 4770, 19158, 19160, 19182, 19180
24240, 19158, 19160, 19182, 19180, 19159, 19161, 19183, 19181
24241, 19159, 19161, 19183, 19181, 5148, 5149, 5160, 5159
24242, 4760, 4761, 4772, 4771, 19160, 19162, 19184, 19182
24243, 19160, 19162, 19184, 19182, 19161, 19163, 19185, 19183
24244, 19161, 19163, 19185, 19183, 5149, 5150, 5161, 5160
24245, 4761, 4762, 4773, 4772, 19162, 19164, 19186, 19184
24246, 19162, 19164, 19186, 19184, 19163, 19165, 19187, 19185
24247, 19163, 19165, 19187, 19185, 5150, 5151, 5162, 5161
24248, 4762, 4763, 4774, 4773, 19164, 19166, 19188, 19186
24249, 19164, 19166, 19188, 19186, 19165, 19167, 19189, 19187
24250, 19165, 19167, 19189, 19187, 5151, 5152, 5163, 5162
24251, 4763, 4764, 4775, 4774, 19166, 19168, 19190, 19188
24252, 19166, 19168, 19190, 19188, 19167, 19169, 19191, 19189
24253, 19167, 19169, 19191, 19189, 5152, 5153, 5164, 5163
24254, 4764, 4765, 4776, 4775, 19168, 19170, 19192, 19190
24255, 19168, 19170, 19192, 19190, 19169, 19171, 19193, 19191
24256, 19169, 19171, 19193, 19191, 5153, 5154, 5165, 5164
24257, 4765, 4766, 4777, 4776, 19170, 19172, 19194, 19192
24258, 19170, 19172, 19194, 19192, 19171, 19173, 19195, 19193
24259, 19171, 19173, 19195, 19193, 5154, 5155, 5166, 5165
24260, 4766, 512, 513, 4777, 19172, 4996, 4998, 19194
24261, 19172, 4996, 4998, 19194, 19173, 4997, 4999, 19195
24262, 19173, 4997, 4999, 19195, 5155, 588, 589, 5166
24263, 479, 4767, 4778, 480, 4930, 19174, 19196, 4932
24264, 4930, 19174, 19196, 4932, 4931, 19175, 19197, 4933
24265, 4931, 19175, 19197, 4933, 551, 5156, 5167, 552
24266, 4767, 4768, 4779, 4778, 19174, 19176, 19198, 19196
24267, 19174, 19176, 19198, 19196, 19175, 19177, 19199, 19197
24268, 19175, 19177, 19199, 19197, 5156, 5157, 5168, 5167
24269, 4768, 4769, 4780, 4779, 19176, 19178, 19200, 19198
24270, 19176, 19178, 19200, 19198, 19177, 19179, 19201, 19199
24271, 19177, 19179, 19201, 19199, 5157, 5158, 5169, 5168
24272, 4769, 4770, 4781, 4780, 19178, 19180, 19202, 19200
24273, 19178, 19180, 19202, 19200, 19179, 19181, 19203, 19201
24274, 19179, 19181, 19203, 19201, 5158, 5159, 5170, 5169
24275, 4770, 4771, 4782, 4781, 19180, 19182, 19204, 19202
24276, 19180, 19182, 19204, 19202, 19181, 19183, 19205, 19203
24277, 19181, 19183, 19205, 19203, 5159, 5160, 5171, 5170
24278, 4771, 4772, 4783, 4782, 19182, 19184, 19206, 19204
24279, 19182, 19184, 19206, 19204, 19183, 19185, 19207, 19205
24280, 19183, 19185, 19207, 19205, 5160, 5161, 5172, 5171
24281, 4772, 4773, 4784, 4783, 19184, 19186, 19208, 19206
24282, 19184, 19186, 19208, 19206, 19185, 19187, 19209, 19207
24283, 19185, 19187, 19209, 19207, 5161, 5162, 5173, 5172
24284, 4773, 4774, 4785, 4784, 19186, 19188, 19210, 19208
24285, 19186, 19188, 19210, 19208, 19187, 19189, 19211, 19209
24286, 19187, 19189, 19211, 19209, 5162, 5163, 5174, 5173
24287, 4774, 4775, 4786, 4785, 19188, 19190, 19212, 19210
24288, 19188, 19190, 19212, 19210, 19189, 19191, 19213, 19211
24289, 19189, 19191, 19213, 19211, 5163, 5164, 5175, 5174
24290, 4775, 4776, 4787, 4786, 19190, 19192, 19214, 19212
24291, 19190, 19192, 19214, 19212, 19191, 19193, 19215, 19213
24292, 19191, 19193, 19215, 19213, 5164, 5165, 5176, 5175
24293, 4776, 4777, 4788, 4787, 19192, 19194, 19216, 19214
24294, 19192, 19194, 19216, 19214, 19193, 19195, 19217, 19215
24295, 19193, 19195, 19217, 19215, 5165, 5166, 5177, 5176
24296, 4777, 513, 514, 4788, 19194, 4998, 5000, 19216
24297, 19194, 4998, 5000, 19216, 19195, 4999, 5001, 19217
24298, 19195, 4999, 5001, 19217, 5166, 589, 590, 5177
24299, 480, 4778, 4789, 481, 4932, 19196, 19218, 4934
24300, 4932, 19196, 19218, 4934, 4933, 19197, 19219, 4935
24301, 4933, 19197, 19219, 4935, 552, 5167, 5178, 553
24302, 4778, 4779, 4790, 4789, 19196, 19198, 19220, 19218
24303, 19196, 19198, 19220, 19218, 19197, 19199, 19221, 19219
24304, 19197, 19199, 19221, 19219, 5167, 5168, 5179, 5178
24305, 4779, 4780, 4791, 4790, 19198, 19200, 19222, 19220
24306, 19198, 19200, 19222, 19220, 19199, 19201, 19223, 19221
24307, 19199, 19201, 19223, 19221, 5168, 5169, 5180, 5179
24308, 4780, 4781, 4792, 4791, 19200, 19202, 19224, 19222
24309, 19200, 19202, 19224, 19222, 19201, 19203, 19225, 19223
24310, 19201, 19203, 19225, 19223, 5169, 5170, 5181, 5180
24311, 4781, 4782, 4793, 4792, 19202, 19204, 19226, 19224
24312, 19202, 19204, 19226, 19224, 19203, 19205, 19227, 19225
24313, 19203, 19205, 19227, 19225, 5170, 5171, 5182, 5181
24314, 4782, 4783, 4794, 4793, 19204, 19206, 19228, 19226
24315, 19204, 19206, 19228, 19226, 19205, 19207, 19229, 19227
24316, 19205, 19207, 19229, 19227, 5171, 5172, 5183, 5182
24317, 4783, 4784, 4795, 4794, 19206, 19208, 19230, 19228
24318, 19206, 19208, 19230, 19228, 19207, 19209, 19231, 19229
24319, 19207, 19209, 19231, 19229, 5172, 5173, 5184, 5183
24320, 4784, 4785, 4796, 4795, 19208, 19210, 19232, 19230
24321, 19208, 19210, 19232, 19230, 19209, 19211, 19233, 19231
24322, 19209, 19211, 19233, 19231, 5173, 5174, 5185, 5184
24323, 4785, 4786, 4797, 4796, 19210, 19212, 19234, 19232
24324, 19210, 19212, 19234, 19232, 19211, 19213, 19235, 19233
24325, 19211, 19213, 19235, 19233, 5174, 5175, 5186, 5185
24326, 4786, 4787, 4798, 4797, 19212, 19214, 19236, 19234
24327, 19212, 19214, 19236, 19234, 19213, 19215, 19237, 19235
24328, 19213, 19215, 19237, 19235, 5175, 5176, 5187, 5186
24329, 4787, 4788, 4799, 4798, 19214, 19216, 19238, 19236
24330, 19214, 19216, 19238, 19236, 19215, 19217, 19239, 19237
24331, 19215, 19217, 19239, 19237, 5176, 5177, 5188, 5187
24332, 4788, 514, 515, 4799, 19216, 5000, 5002, 19238
24333, 19216, 5000, 5002, 19238, 19217, 5001, 5003, 19239
24334, 19217, 5001, 5003, 19239, 5177, 590, 591, 5188
24335, 481, 4789, 4800, 482, 4934, 19218, 19240, 4936
24336, 4934, 19218, 19240, 4936, 4935, 19219, 19241, 4937
24337, 4935, 19219, 19241, 4937, 553, 5178, 5189, 554
24338, 4789, 4790, 4801, 4800, 19218, 19220, 19242, 19240
24339, 19218, 19220, 19242, 19240, 19219, 19221, 19243, 19241
24340, 19219, 19221, 19243, 19241, 5178, 5179, 5190, 5189
24341, 4790, 4791, 4802, 4801, 19220, 19222, 19244, 19242
24342, 19220, 19222, 19244, 19242, 19221, 19223, 19245, 19243
24343, 19221, 19223, 19245, 19243, 5179, 5180, 5191, 5190
24344, 4791, 4792, 4803, 4802, 19222, 19224, 19246, 19244
24345, 19222, 19224, 19246, 19244, 19223, 19225, 19247, 19245
24346, 19223, 19225, 19247, 19245, 5180, 5181, 5192, 5191
24347, 4792, 4793, 4804, 4803, 19224, 19226, 19248, 19246
24348, 19224, 19226, 19248, 19246, 19225, 19227, 19249, 19247
24349, 19225, 19227, 19249, 19247, 5181, 5182, 5193, 5192
24350, 4793, 4794, 4805, 4804, 19226, 19228, 19250, 19248
24351, 19226, 19228, 19250, 19248, 19227, 19229, 19251, 19249
24352, 19227, 19229, 19251, 19249, 5182, 5183, 5194, 5193
24353, 4794, 4795, 4806, 4805, 19228, 19230, 19252, 19250
24354, 19228, 19230, 19252, 19250, 19229, 19231, 19253, 19251
24355, 19229, 19231, 19253, 19251, 5183, 5184, 5195, 5194
24356, 4795, 4796, 4807, 4806, 19230, 19232, 19254, 19252
24357, 19230, 19232, 19254, 19252, 19231, 19233, 19255, 19253
24358, 19231, 19233, 19255, 19253, 5184, 5185, 5196, 5195
24359, 4796, 4797, 4808, 4807, 19232, 19234, 19256, 19254
24360, 19232, 19234, 19256, 19254, 19233, 19235, 19257, 19255
24361, 19233, 19235, 19257, 19255, 5185, 5186, 5197, 5196
24362, 4797, 4798, 4809, 4808, 19234, 19236, 19258, 19256
24363, 19234, 19236, 19258, 19256, 19235, 19237, 19259, 19257
24364, 19235, 19237, 19259, 19257, 5186, 5187, 5198, 5197
24365, 4798, 4799, 4810, 4809, 19236, 19238, 19260, 19258
24366, 19236, 19238, 19260, 19258, 19237, 19239, 19261, 19259
24367, 19237, 19239, 19261, 19259, 5187, 5188, 5199, 5198
24368, 4799, 515, 516, 4810, 19238, 5002, 5004, 19260
24369, 19238, 5002, 5004, 19260, 19239, 5003, 5005, 19261
24370, 19239, 5003, 5005, 19261, 5188, 591, 592, 5199
24371, 482, 4800, 4811, 483, 4936, 19240, 19262, 4938
24372, 4936, 19240, 19262, 4938, 4937, 19241, 19263, 4939
24373, 4937, 19241, 19263, 4939, 554, 5189, 5200, 555
24374, 4800, 4801, 4812, 4811, 19240, 19242, 19264, 19262
24375, 19240, 19242, 19264, 19262, 19241, 19243, 19265, 19263
24376, 19241, 19243, 19265, 19263, 5189, 5190, 5201, 5200
24377, 4801, 4802, 4813, 4812, 19242, 19244, 19266, 19264
24378, 19242, 19244, 19266, 19264, 19243, 19245, 19267, 19265
24379, 19243, 19245, 19267, 19265, 5190, 5191, 5202, 5201
24380, 4802, 4803, 4814, 4813, 19244, 19246, 19268, 19266
24381, 19244, 19246, 19268, 19266, 19245, 19247, 19269, 19267
24382, 19245, 19247, 19269, 19267, 5191, 5192, 5203, 5202
24383, 4803, 4804, 4815, 4814, 19246, 19248, 19270, 19268
24384, 19246, 19248, 19270, 19268, 19247, 19249, 19271, 19269
24385, 19247, 19249, 19271, 19269, 5192, 5193, 5204, 5203
24386, 4804, 4805, 4816, 4815, 19248, 19250, 19272, 19270
24387, 19248, 19250, 19272, 19270, 19249, 19251, 19273, 19271
24388, 19249, 19251, 19273, 19271, 5193, 5194, 5205, 5204
24389, 4805, 4806, 4817, 4816, 19250, 19252, 19274, 19272
24390, 19250, 19252, 19274, 19272, 19251, 19253, 19275, 19273
24391, 19251, 19253, 19275, 19273, 5194, 5195, 5206, 5205
24392, 4806, 4807, 4818, 4817, 19252, 19254, 19276, 19274
24393, 19252, 19254, 19276, 19274, 19253, 19255, 19277, 19275
24394, 19253, 19255, 19277, 19275, 5195, 5196, 5207, 5206
24395, 4807, 4808, 4819, 4818, 19254, 19256, 19278, 19276
24396, 19254, 19256, 19278, 19276, 19255, 19257, 19279, 19277
24397, 19255, 19257, 19279, 19277, 5196, 5197, 5208, 5207
24398, 4808, 4809, 4820, 4819, 19256, 19258, 19280, 19278
24399, 19256, 19258, 19280, 19278, 19257, 19259, 19281, 19279
24400, 19257, 19259, 19281, 19279, 5197, 5198, 5209, 5208
24401, 4809, 4810, 4821, 4820, 19258, 19260, 19282, 19280
24402, 19258, 19260, 19282, 19280, 19259, 19261, 19283, 19281
24403, 19259, 19261, 19283, 19281, 5198, 5199, 5210, 5209
24404, 4810, 516, 517, 4821, 19260, 5004, 5006, 19282
24405, 19260, 5004, 5006, 19282, 19261, 5005, 5007, 19283
24406, 19261, 5005, 5007, 19283, 5199, 592, 593, 5210
24407, 483, 4811, 4822, 484, 4938, 19262, 19284, 4940
24408, 4938, 19262, 19284, 4940, 4939, 19263, 19285, 4941
24409, 4939, 19263, 19285, 4941, 555, 5200, 5211, 556
24410, 4811, 4812, 4823, 4822, 19262, 19264, 19286, 19284
24411, 19262, 19264, 19286, 19284, 19263, 19265, 19287, 19285
24412, 19263, 19265, 19287, 19285, 5200, 5201, 5212, 5211
24413, 4812, 4813, 4824, 4823, 19264, 19266, 19288, 19286
24414, 19264, 19266, 19288, 19286, 19265, 19267, 19289, 19287
24415, 19265, 19267, 19289, 19287, 5201, 5202, 5213, 5212
24416, 4813, 4814, 4825, 4824, 19266, 19268, 19290, 19288
24417, 19266, 19268, 19290, 19288, 19267, 19269, 19291, 19289
24418, 19267, 19269, 19291, 19289, 5202, 5203, 5214, 5213
24419, 4814, 4815, 4826, 4825, 19268, 19270, 19292, 19290
24420, 19268, 19270, 19292, 19290, 19269, 19271, 19293, 19291
24421, 19269, 19271, 19293, 19291, 5203, 5204, 5215, 5214
24422, 4815, 4816, 4827, 4826, 19270, 19272, 19294, 19292
24423, 19270, 19272, 19294, 19292, 19271, 19273, 19295, 19293
24424, 19271, 19273, 19295, 19293, 5204, 5205, 5216, 5215
24425, 4816, 4817, 4828, 4827, 19272, 19274, 19296, 19294
24426, 19272, 19274, 19296, 19294, 19273, 19275, 19297, 19295
24427, 19273, 19275, 19297, 19295, 5205, 5206, 5217, 5216
24428, 4817, 4818, 4829, 4828, 19274, 19276, 19298, 19296
24429, 19274, 19276, 19298, 19296, 19275, 19277, 19299, 19297
24430, 19275, 19277, 19299, 19297, 5206, 5207, 5218, 5217
24431, 4818, 4819, 4830, 4829, 19276, 19278, 19300, 19298
24432, 19276, 19278, 19300, 19298, 19277, 19279, 19301, 19299
24433, 19277, 19279, 19301, 19299, 5207, 5208, 5219, 5218
24434, 4819, 4820, 4831, 4830, 19278, 19280, 19302, 19300
24435, 19278, 19280, 19302, 19300, 19279, 19281, 19303, 19301
24436, 19279, 19281, 19303, 19301, 5208, 5209, 5220, 5219
24437, 4820, 4821, 4832, 4831, 19280, 19282, 19304, 19302
24438, 19280, 19282, 19304, 19302, 19281, 19283, 19305, 19303
24439, 19281, 19283, 19305, 19303, 5209, 5210, 5221, 5220
24440, 4821, 517, 518, 4832, 19282, 5006, 5008, 19304
24441, 19282, 5006, 5008, 19304, 19283, 5007, 5009, 19305
24442, 19283, 5007, 5009, 19305, 5210, 593, 594, 5221
24443, 484, 4822, 4833, 485, 4940, 19284, 19306, 4942
24444, 4940, 19284, 19306, 4942, 4941, 19285, 19307, 4943
24445, 4941, 19285, 19307, 4943, 556, 5211, 5222, 557
24446, 4822, 4823, 4834, 4833, 19284, 19286, 19308, 19306
24447, 19284, 19286, 19308, 19306, 19285, 19287, 19309, 19307
24448, 19285, 19287, 19309, 19307, 5211, 5212, 5223, 5222
24449, 4823, 4824, 4835, 4834, 19286, 19288, 19310, 19308
24450, 19286, 19288, 19310, 19308, 19287, 19289, 19311, 19309
24451, 19287, 19289, 19311, 19309, 5212, 5213, 5224, 5223
24452, 4824, 4825, 4836, 4835, 19288, 19290, 19312, 19310
24453, 19288, 19290, 19312, 19310, 19289, 19291, 19313, 19311
24454, 19289, 19291, 19313, 19311, 5213, 5214, 5225, 5224
24455, 4825, 4826, 4837, 4836, 19290, 19292, 19314, 19312
24456, 19290, 19292, 19314, 19312, 19291, 19293, 19315, 19313
24457, 19291, 19293, 19315, 19313, 5214, 5215, 5226, 5225
24458, 4826, 4827, 4838, 4837, 19292, 19294, 19316, 19314
24459, 19292, 19294, 19316, 19314, 19293, 19295, 19317, 19315
24460, 19293, 19295, 19317, 19315, 5215, 5216, 5227, 5226
24461, 4827, 4828, 4839, 4838, 19294, 19296, 19318, 19316
24462, 19294, 19296, 19318, 19316, 19295, 19297, 19319, 19317
24463, 19295, 19297, 19319, 19317, 5216, 5217, 5228, 5227
24464, 4828, 4829, 4840, 4839, 19296, 19298, 19320, 19318
24465, 19296, 19298, 19320, 19318, 19297, 19299, 19321, 19319
24466, 19297, 19299, 19321, 19319, 5217, 5218, 5229, 5228
24467, 4829, 4830, 4841, 4840, 19298, 19300, 19322, 19320
24468, 19298, 19300, 19322, 19320, 19299, 19301, 19323, 19321
24469, 19299, 19301, 19323, 19321, 5218, 5219, 5230, 5229
24470, 4830, 4831, 4842, 4841, 19300, 19302, 19324, 19322
24471, 19300, 19302, 19324, 19322, 19301, 19303, 19325, 19323
24472, 19301, 19303, 19325, 19323, 5219, 5220, 5231, 5230
24473, 4831, 4832, 4843, 4842, 19302, 19304, 19326, 19324
24474, 19302, 19304, 19326, 19324, 19303, 19305, 19327, 19325
24475, 19303, 19305, 19327, 19325, 5220, 5221, 5232, 5231
24476, 4832, 518, 519, 4843, 19304, 5008, 5010, 19326
24477, 19304, 5008, 5010, 19326, 19305, 5009, 5011, 19327
24478, 19305, 5009, 5011, 19327, 5221, 594, 595, 5232
24479, 485, 4833, 4844, 486, 4942, 19306, 19328, 4944
24480, 4942, 19306, 19328, 4944, 4943, 19307, 19329, 4945
24481, 4943, 19307, 19329, 4945, 557, 5222, 5233, 558
24482, 4833, 4834, 4845, 4844, 19306, 19308, 19330, 19328
24483, 19306, 19308, 19330, 19328, 19307, 19309, 19331, 19329
24484, 19307, 19309, 19331, 19329, 5222, 5223, 5234, 5233
24485, 4834, 4835, 4846, 4845, 19308, 19310, 19332, 19330
24486, 19308, 19310, 19332, 19330, 19309, 19311, 19333, 19331
24487, 19309, 19311, 19333, 19331, 5223, 5224, 5235, 5234
24488, 4835, 4836, 4847, 4846, 19310, 19312, 19334, 19332
24489, 19310, 19312, 19334, 19332, 19311, 19313, 19335, 19333
24490, 19311, 19313, 19335, 19333, 5224, 5225, 5236, 5235
24491, 4836, 4837, 4848, 4847, 19312, 19314, 19336, 19334
24492, 19312, 19314, 19336, 19334, 19313, 19315, 19337, 19335
24493, 19313, 19315, 19337, 19335, 5225, 5226, 5237, 5236
24494, 4837, 4838, 4849, 4848, 19314, 19316, 19338, 19336
24495, 19314, 19316, 19338, 19336, 19315, 19317, 19339, 19337
24496, 19315, 19317, 19339, 19337, 5226, 5227, 5238, 5237
24497, 4838, 4839, 4850, 4849, 19316, 19318, 19340, 19338
24498, 19316, 19318, 19340, 19338, 19317, 19319, 19341, 19339
24499, 19317, 19319, 19341, 19339, 5227, 5228, 5239, 5238
24500, 4839, 4840, 4851, 4850, 19318, 19320, 19342, 19340
24501, 19318, 19320, 19342, 19340, 19319, 19321, 19343, 19341
24502, 19319, 19321, 19343, 19341, 5228, 5229, 5240, 5239
24503, 4840, 4841, 4852, 4851, 19320, 19322, 19344, 19342
24504, 19320, 19322, 19344, 19342, 19321, 19323, 19345, 19343
24505, 19321, 19323, 19345, 19343, 5229, 5230, 5241, 5240
24506, 4841, 4842, 4853, 4852, 19322, 19324, 19346, 19344
24507, 19322, 19324, 19346, 19344, 19323, 19325, 19347, 19345
24508, 19323, 19325, 19347, 19345, 5230, 5231, 5242, 5241
24509, 4842, 4843, 4854, 4853, 19324, 19326, 19348, 19346
24510, 19324, 19326, 19348, 19346, 19325, 19327, 19349, 19347
24511, 19325, 19327, 19349, 19347, 5231, 5232, 5243, 5242
24512, 4843, 519, 520, 4854, 19326, 5010, 5012, 19348
24513, 19326, 5010, 5012, 19348, 19327, 5011, 5013, 19349
24514, 19327, 5011, 5013, 19349, 5232, 595, 596, 5243
24515, 486, 4844, 4855, 487, 4944, 19328, 19350, 4946
24516, 4944, 19328, 19350, 4946, 4945, 19329, 19351, 4947
24517, 4945, 19329, 19351, 4947, 558, 5233, 5244, 559
24518, 4844, 4845, 4856, 4855, 19328, 19330, 19352, 19350
24519, 19328, 19330, 19352, 19350, 19329, 19331, 19353, 19351
24520, 19329, 19331, 19353, 19351, 5233, 5234, 5245, 5244
24521, 4845, 4846, 4857, 4856, 19330, 19332, 19354, 19352
24522, 19330, 19332, 19354, 19352, 19331, 19333, 19355, 19353
24523, 19331, 19333, 19355, 19353, 5234, 5235, 5246, 5245
24524, 4846, 4847, 4858, 4857, 19332, 19334, 19356, 19354
24525, 19332, 19334, 19356, 19354, 19333, 19335, 19357, 19355
24526, 19333, 19335, 19357, 19355, 5235, 5236, 5247, 5246
24527, 4847, 4848, 4859, 4858, 19334, 19336, 19358, 19356
24528, 19334, 19336, 19358, 19356, 19335, 19337, 19359, 19357
24529, 19335, 19337, 19359, 19357, 5236, 5237, 5248, 5247
24530, 4848, 4849, 4860, 4859, 19336, 19338, 19360, 19358
24531, 19336, 19338, 19360, 19358, 19337, 19339, 19361, 19359
24532, 19337, 19339, 19361, 19359, 5237, 5238, 5249, 5248
24533, 4849, 4850, 4861, 4860, 19338, 19340, 19362, 19360
24534, 19338, 19340, 19362, 19360, 19339, 19341, 19363, 19361
24535, 19339, 19341, 19363, 19361, 5238, 5239, 5250, 5249
24536, 4850, 4851, 4862, 4861, 19340, 19342, 19364, 19362
24537, 19340, 19342, 19364, 19362, 19341, 19343, 19365, 19363
24538, 19341, 19343, 19365, 19363, 5239, 5240, 5251, 5250
24539, 4851, 4852, 4863, 4862, 19342, 19344, 19366, 19364
24540, 19342, 19344, 19366, 19364, 19343, 19345, 19367, 19365
24541, 19343, 19345, 19367, 19365, 5240, 5241, 5252, 5251
24542, 4852, 4853, 4864, 4863, 19344, 19346, 19368, 19366
24543, 19344, 19346, 19368, 19366, 19345, 19347, 19369, 19367
24544, 19345, 19347, 19369, 19367, 5241, 5242, 5253, 5252
24545, 4853, 4854, 4865, 4864, 19346, 19348, 19370, 19368
24546, 19346, 19348, 19370, 19368, 19347, 19349, 19371, 19369
24547, 19347, 19349, 19371, 19369, 5242, 5243, 5254, 5253
24548, 4854, 520, 521, 4865, 19348, 5012, 5014, 19370
24549, 19348, 5012, 5014, 19370, 19349, 5013, 5015, 19371
24550, 19349, 5013, 5015, 19371, 5243, 596, 597, 5254
24551, 487, 4855, 4866, 488, 4946, 19350, 19372, 4948
24552, 4946, 19350, 19372, 4948, 4947, 19351, 19373, 4949
24553, 4947, 19351, 19373, 4949, 559, 5244, 5255, 560
24554, 4855, 4856, 4867, 4866, 19350, 19352, 19374, 19372
24555, 19350, 19352, 19374, 19372, 19351, 19353, 19375, 19373
24556, 19351, 19353, 19375, 19373, 5244, 5245, 5256, 5255
24557, 4856, 4857, 4868, 4867, 19352, 19354, 19376, 19374
24558, 19352, 19354, 19376, 19374, 19353, 19355, 19377, 19375
24559, 19353, 19355, 19377, 19375, 5245, 5246, 5257, 5256
24560, 4857, 4858, 4869, 4868, 19354, 19356, 19378, 19376
24561, 19354, 19356, 19378, 19376, 19355, 19357, 19379, 19377
24562, 19355, 19357, 19379, 19377, 5246, 5247, 5258, 5257
24563, 4858, 4859, 4870, 4869, 19356, 19358, 19380, 19378
24564, 19356, 19358, 19380, 19378, 19357, 19359, 19381, 19379
24565, 19357, 19359, 19381, 19379, 5247, 5248, 5259, 5258
24566, 4859, 4860, 4871, 4870, 19358, 19360, 19382, 19380
24567, 19358, 19360, 19382, 19380, 19359, 19361, 19383, 19381
24568, 19359, 19361, 19383, 19381, 5248, 5249, 5260, 5259
24569, 4860, 4861, 4872, 4871, 19360, 19362, 19384, 19382
24570, 19360, 19362, 19384, 19382, 19361, 19363, 19385, 19383
24571, 19361, 19363, 19385, 19383, 5249, 5250, 5261, 5260
24572, 4861, 4862, 4873, 4872, 19362, 19364, 19386, 19384
24573, 19362, 19364, 19386, 19384, 19363, 19365, 19387, 19385
24574, 19363, 19365, 19387, 19385, 5250, 5251, 5262, 5261
24575, 4862, 4863, 4874, 4873, 19364, 19366, 19388, 19386
24576, 19364, 19366, 19388, 19386, 19365, 19367, 19389, 19387
24577, 19365, 19367, 19389, 19387, 5251, 5252, 5263, 5262
24578, 4863, 4864, 4875, 4874, 19366, 19368, 19390, 19388
24579, 19366, 19368, 19390, 19388, 19367, 19369, 19391, 19389
24580, 19367, 19369, 19391, 19389, 5252, 5253, 5264, 5263
24581, 4864, 4865, 4876, 4875, 19368, 19370, 19392, 19390
24582, 19368, 19370, 19392, 19390, 19369, 19371, 19393, 19391
24583, 19369, 19371, 19393, 19391, 5253, 5254, 5265, 5264
24584, 4865, 521, 522, 4876, 19370, 5014, 5016, 19392
24585, 19370, 5014, 5016, 19392, 19371, 5015, 5017, 19393
24586, 19371, 5015, 5017, 19393, 5254, 597, 598, 5265
24587, 488, 4866, 4877, 489, 4948, 19372, 19394, 4950
24588, 4948, 19372, 19394, 4950, 4949, 19373, 19395, 4951
24589, 4949, 19373, 19395, 4951, 560, 5255, 5266, 561
24590, 4866, 4867, 4878, 4877, 19372, 19374, 19396, 19394
24591, 19372, 19374, 19396, 19394, 19373, 19375, 19397, 19395
24592, 19373, 19375, 19397, 19395, 5255, 5256, 5267, 5266
24593, 4867, 4868, 4879, 4878, 19374, 19376, 19398, 19396
24594, 19374, 19376, 19398, 19396, 19375, 19377, 19399, 19397
24595, 19375, 19377, 19399, 19397, 5256, 5257, 5268, 5267
24596, 4868, 4869, 4880, 4879, 19376, 19378, 19400, 19398
24597, 19376, 19378, 19400, 19398, 19377, 19379, 19401, 19399
24598, 19377, 19379, 19401, 19399, 5257, 5258, 5269, 5268
24599, 4869, 4870, 4881, 4880, 19378, 19380, 19402, 19400
24600, 19378, 19380, 19402, 19400, 19379, 19381, 19403, 19401
24601, 19379, 19381, 19403, 19401, 5258, 5259, 5270, 5269
24602, 4870, 4871, 4882, 4881, 19380, 19382, 19404, 19402
24603, 19380, 19382, 19404, 19402, 19381, 19383, 19405, 19403
24604, 19381, 19383, 19405, 19403, 5259, 5260, 5271, 5270
24605, 4871, 4872, 4883, 4882, 19382, 19384, 19406, 19404
24606, 19382, 19384, 19406, 19404, 19383, 19385, 19407, 19405
24607, 19383, 19385, 19407, 19405, 5260, 5261, 5272, 5271
24608, 4872, 4873, 4884, 4883, 19384, 19386, 19408, 19406
24609, 19384, 19386, 19408, 19406, 19385, 19387, 19409, 19407
24610, 19385, 19387, 19409, 19407, 5261, 5262, 5273, 5272
24611, 4873, 4874, 4885, 4884, 19386, 19388, 19410, 19408
24612, 19386, 19388, 19410, 19408, 19387, 19389, 19411, 19409
24613, 19387, 19389, 19411, 19409, 5262, 5263, 5274, 5273
24614, 4874, 4875, 4886, 4885, 19388, 19390, 19412, 19410
24615, 19388, 19390, 19412, 19410, 19389, 19391, 19413, 19411
24616, 19389, 19391, 19413, 19411, 5263, 5264, 5275, 5274
24617, 4875, 4876, 4887, 4886, 19390, 19392, 19414, 19412
24618, 19390, 19392, 19414, 19412, 19391, 19393, 19415, 19413
24619, 19391, 19393, 19415, 19413, 5264, 5265, 5276, 5275
24620, 4876, 522, 523, 4887, 19392, 5016, 5018, 19414
24621, 19392, 5016, 5018, 19414, 19393, 5017, 5019, 19415
24622, 19393, 5017, 5019, 19415, 5265, 598, 599, 5276
24623, 489, 4877, 4888, 490, 4950, 19394, 19416, 4952
24624, 4950, 19394, 19416, 4952, 4951, 19395, 19417, 4953
24625, 4951, 19395, 19417, 4953, 561, 5266, 5277, 562
24626, 4877, 4878, 4889, 4888, 19394, 19396, 19418, 19416
24627, 19394, 19396, 19418, 19416, 19395, 19397, 19419, 19417
24628, 19395, 19397, 19419, 19417, 5266, 5267, 5278, 5277
24629, 4878, 4879, 4890, 4889, 19396, 19398, 19420, 19418
24630, 19396, 19398, 19420, 19418, 19397, 19399, 19421, 19419
24631, 19397, 19399, 19421, 19419, 5267, 5268, 5279, 5278
24632, 4879, 4880, 4891, 4890, 19398, 19400, 19422, 19420
24633, 19398, 19400, 19422, 19420, 19399, 19401, 19423, 19421
24634, 19399, 19401, 19423, 19421, 5268, 5269, 5280, 5279
24635, 4880, 4881, 4892, 4891, 19400, 19402, 19424, 19422
24636, 19400, 19402, 19424, 19422, 19401, 19403, 19425, 19423
24637, 19401, 19403, 19425, 19423, 5269, 5270, 5281, 5280
24638, 4881, 4882, 4893, 4892, 19402, 19404, 19426, 19424
24639, 19402, 19404, 19426, 19424, 19403, 19405, 19427, 19425
24640, 19403, 19405, 19427, 19425, 5270, 5271, 5282, 5281
24641, 4882, 4883, 4894, 4893, 19404, 19406, 19428, 19426
24642, 19404, 19406, 19428, 19426, 19405, 19407, 19429, 19427
24643, 19405, 19407, 19429, 19427, 5271, 5272, 5283, 5282
24644, 4883, 4884, 4895, 4894, 19406, 19408, 19430, 19428
24645, 19406, 19408, 19430, 19428, 19407, 19409, 19431, 19429
24646, 19407, 19409, 19431, 19429, 5272, 5273, 5284, 5283
24647, 4884, 4885, 4896, 4895, 19408, 19410, 19432, 19430
24648, 19408, 19410, 19432, 19430, 19409, 19411, 19433, 19431
24649, 19409, 19411, 19433, 19431, 5273, 5274, 5285, 5284
24650, 4885, 4886, 4897, 4896, 19410, 19412, 19434, 19432
24651, 19410, 19412, 19434, 19432, 19411, 19413, 19435, 19433
24652, 19411, 19413, 19435, 19433, 5274, 5275, 5286, 5285
24653, 4886, 4887, 4898, 4897, 19412, 19414, 19436, 19434
24654, 19412, 19414, 19436, 19434, 19413, 19415, 19437, 19435
24655, 19413, 19415, 19437, 19435, 5275, 5276, 5287, 5286
24656, 4887, 523, 524, 4898, 19414, 5018, 5020, 19436
24657, 19414, 5018, 5020, 19436, 19415, 5019, 5021, 19437
24658, 19415, 5019, 5021, 19437, 5276, 599, 600, 5287
24659, 490, 4888, 4899, 491, 4952, 19416, 19438, 4954
24660, 4952, 19416, 19438, 4954, 4953, 19417, 19439, 4955
24661, 4953, 19417, 19439, 4955, 562, 5277, 5288, 563
24662, 4888, 4889, 4900, 4899, 19416, 19418, 19440, 19438
24663, 19416, 19418, 19440, 19438, 19417, 19419, 19441, 19439
24664, 19417, 19419, 19441, 19439, 5277, 5278, 5289, 5288
24665, 4889, 4890, 4901, 4900, 19418, 19420, 19442, 19440
24666, 19418, 19420, 19442, 19440, 19419, 19421, 19443, 19441
24667, 19419, 19421, 19443, 19441, 5278, 5279, 5290, 5289
24668, 4890, 4891, 4902, 4901, 19420, 19422, 19444, 19442
24669, 19420, 19422, 19444, 19442, 19421, 19423, 19445, 19443
24670, 19421, 19423, 19445, 19443, 5279, 5280, 5291, 5290
24671, 4891, 4892, 4903, 4902, 19422, 19424, 19446, 19444
24672, 19422, 19424, 19446, 19444, 19423, 19425, 19447, 19445
24673, 19423, 19425, 19447, 19445, 5280, 5281, 5292, 5291
24674, 4892, 4893, 4904, 4903, 19424, 19426, 19448, 19446
24675, 19424, 19426, 19448, 19446, 19425, 19427, 19449, 19447
24676, 19425, 19427, 19449, 19447, 5281, 5282, 5293, 5292
24677, 4893, 4894, 4905, 4904, 19426, 19428, 19450, 19448
24678, 19426, 19428, 19450, 19448, 19427, 19429, 19451, 19449
24679, 19427, 19429, 19451, 19449, 5282, 5283, 5294, 5293
24680, 4894, 4895, 4906, 4905, 19428, 19430, 19452, 19450
24681, 19428, 19430, 19452, 19450, 19429, 19431, 19453, 19451
24682, 19429, 19431, 19453, 19451, 5283, 5284, 5295, 5294
24683, 4895, 4896, 4907, 4906, 19430, 19432, 19454, 19452
24684, 19430, 19432, 19454, 19452, 19431, 19433, 19455, 19453
24685, 19431, 19433, 19455, 19453, 5284, 5285, 5296, 5295
24686, 4896, 4897, 4908, 4907, 19432, 19434, 19456, 19454
24687, 19432, 19434, 19456, 19454, 19433, 19435, 19457, 19455
24688, 19433, 19435, 19457, 19455, 5285, 5286, 5297, 5296
24689, 4897, 4898, 4909, 4908, 19434, 19436, 19458, 19456
24690, 19434, 19436, 19458, 19456, 19435, 19437, 19459, 19457
24691, 19435, 19437, 19459, 19457, 5286, 5287, 5298, 5297
24692, 4898, 524, 525, 4909, 19436, 5020, 5022, 19458
24693, 19436, 5020, 5022, 19458, 19437, 5021, 5023, 19459
24694, 19437, 5021, 5023, 19459, 5287, 600, 601, 5298
24695, 491, 4899, 492, 17, 4954, 19438, 4956, 537
24696, 4954, 19438, 4956, 537, 4955, 19439, 4957, 538
24697, 4955, 19439, 4957, 538, 563, 5288, 566, 21
24698, 4899, 4900, 493, 492, 19438, 19440, 4958, 4956
24699, 19438, 19440, 4958, 4956, 19439, 19441, 4959, 4957
24700, 19439, 19441, 4959, 4957, 5288, 5289, 567, 566
24701, 4900, 4901, 494, 493, 19440, 19442, 4960, 4958
24702, 19440, 19442, 4960, 4958, 19441, 19443, 4961, 4959
24703, 19441, 19443, 4961, 4959, 5289, 5290, 568, 567
24704, 4901, 4902, 495, 494, 19442, 19444, 4962, 4960
24705, 19442, 19444, 4962, 4960, 19443, 19445, 4963, 4961
24706, 19443, 19445, 4963, 4961, 5290, 5291, 569, 568
24707, 4902, 4903, 496, 495, 19444, 19446, 4964, 4962
24708, 19444, 19446, 4964, 4962, 19445, 19447, 4965, 4963
24709, 19445, 19447, 4965, 4963, 5291, 5292, 570, 569
24710, 4903, 4904, 497, 496, 19446, 19448, 4966, 4964
24711, 19446, 19448, 4966, 4964, 19447, 19449, 4967, 4965
24712, 19447, 19449, 4967, 4965, 5292, 5293, 571, 570
24713, 4904, 4905, 498, 497, 19448, 19450, 4968, 4966
24714, 19448, 19450, 4968, 4966, 19449, 19451, 4969, 4967
24715, 19449, 19451, 4969, 4967, 5293, 5294, 572, 571
24716, 4905, 4906, 499, 498, 19450, 19452, 4970, 4968
24717, 19450, 19452, 4970, 4968, 19451, 19453, 4971, 4969
24718, 19451, 19453, 4971, 4969, 5294, 5295, 573, 572
24719, 4906, 4907, 500, 499, 19452, 19454, 4972, 4970
24720, 19452, 19454, 4972, 4970, 19453, 19455, 4973, 4971
24721, 19453, 19455, 4973, 4971, 5295, 5296, 574, 573
24722, 4907, 4908, 501, 500, 19454, 19456, 4974, 4972
24723, 19454, 19456, 4974, 4972, 19455, 19457, 4975, 4973
24724, 19455, 19457, 4975, 4973, 5296, 5297, 575, 574
24725, 4908, 4909, 502, 501, 19456, 19458, 4976, 4974
24726, 19456, 19458, 4976, 4974, 19457, 19459, 4977, 4975
24727, 19457, 19459, 4977, 4975, 5297, 5298, 576, 575
24728, 4909, 525, 19, 502, 19458, 5022, 564, 4976
24729, 19458, 5022, 564, 4976, 19459, 5023, 565, 4977
24730, 19459, 5023, 565, 4977, 5298, 601, 23, 576
*ELEMENT, type=C3D8, ELSET=Volume6
24731, 17, 537, 4956, 492, 623, 5307, 19460, 5315
24732, 623, 5307, 19460, 5315, 624, 5308, 19461, 5316
24733, 624, 5308, 19461, 5316, 625, 5309, 19462, 5317
24734, 625, 5309, 19462, 5317, 626, 5310, 19463, 5318
24735, 626, 5310, 19463, 5318, 27, 631, 5403, 633
24736, 537, 538, 4957, 4956, 5307, 5311, 19464, 19460
24737, 5307, 5311, 19464, 19460, 5308, 5312, 19465, 19461
24738, 5308, 5312, 19465, 19461, 5309, 5313, 19466, 19462
24739, 5309, 5313, 19466, 19462, 5310, 5314, 19467, 19463
24740, 5310, 5314, 19467, 19463, 631, 632, 5404, 5403
24741, 538, 21, 566, 4957, 5311, 627, 5359, 19464
24742, 5311, 627, 5359, 19464, 5312, 628, 5360, 19465
24743, 5312, 628, 5360, 19465, 5313, 629, 5361, 19466
24744, 5313, 629, 5361, 19466, 5314, 630, 5362, 19467
24745, 5314, 630, 5362, 19467, 632, 28, 644, 5404
24746, 492, 4956, 4958, 493, 5315, 19460, 19468, 5319
24747, 5315, 19460, 19468, 5319, 5316, 19461, 19469, 5320
24748, 5316, 19461, 19469, 5320, 5317, 19462, 19470, 5321
24749, 5317, 19462, 19470, 5321, 5318, 19463, 19471, 5322
24750, 5318, 19463, 19471, 5322, 633, 5403, 5405, 634
24751, 4956, 4957, 4959, 4958, 19460, 19464, 19472, 19468
24752, 19460, 19464, 19472, 19468, 19461, 19465, 19473, 19469
24753, 19461, 19465, 19473, 19469, 19462, 19466, 19474, 19470
24754, 19462, 19466, 19474, 19470, 19463, 19467, 19475, 19471
24755, 19463, 19467, 19475, 19471, 5403, 5404, 5406, 5405
24756, 4957, 566, 567, 4959, 19464, 5359, 5363, 19472
24757, 19464, 5359, 5363, 19472, 19465, 5360, 5364, 19473
24758, 19465, 5360, 5364, 19473, 19466, 5361, 5365, 19474
24759, 19466, 5361, 5365, 19474, 19467, 5362, 5366, 19475
24760, 19467, 5362, 5366, 19475, 5404, 644, 645, 5406
24761, 493, 4958, 4960, 494, 5319, 19468, 19476, 5323
24762, 5319, 19468, 19476, 5323, 5320, 19469, 19477, 5324
24763, 5320, 19469, 19477, 5324, 5321, 19470, 19478, 5325
24764, 5321, 19470, 19478, 5325, 5322, 19471, 19479, 5326
24765, 5322, 19471, 19479, 5326, 634, 5405, 5407, 635
24766, 4958, 4959, 4961, 4960, 19468, 19472, 19480, 19476
24767, 19468, 19472, 19480, 19476, 19469, 19473, 19481, 19477
24768, 19469, 19473, 19481, 19477, 19470, 19474, 19482, 19478
24769, 19470, 19474, 19482, 19478, 19471, 19475, 19483, 19479
24770, 19471, 19475, 19483, 19479, 5405, 5406, 5408, 5407
24771, 4959, 567, 568, 4961, 19472, 5363, 5367, 19480
24772, 19472, 5363, 5367, 19480, 19473, 5364, 5368, 19481
24773, 19473, 5364, 5368, 19481, 19474, 5365, 5369, 19482
24774, 19474, 5365, 5369, 19482, 19475, 5366, 5370, 19483
24775, 19475, 5366, 5370, 19483, 5406, 645, 646, 5408
24776, 494, 4960, 4962, 495, 5323, 19476, 19484, 5327
24777, 5323, 19476, 19484, 5327, 5324, 19477, 19485, 5328
24778, 5324, 19477, 19485, 5328, 5325, 19478, 19486, 5329
24779, 5325, 19478, 19486, 5329, 5326, 19479, 19487, 5330
24780, 5326, 19479, 19487, 5330, 635, 5407, 5409, 636
24781, 4960, 4961, 4963, 4962, 19476, 19480, 19488, 19484
24782, 19476, 19480, 19488, 19484, 19477, 19481, 19489, 19485
24783, 19477, 19481, 19489, 19485, 19478, 19482, 19490, 19486
24784, 19478, 19482, 19490, 19486, 19479, 19483, 19491, 19487
24785, 19479, 19483, 19491, 19487, 5407, 5408, 5410, 5409
24786, 4961, 568, 569, 4963, 19480, 5367, 5371, 19488
24787, 19480, 5367, 5371, 19488, 19481, 5368, 5372, 19489
24788, 19481, 5368, 5372, 19489, 19482, 5369, 5373, 19490
24789, 19482, 5369, 5373, 19490, 19483, 5370, 5374, 19491
24790, 19483, 5370, 5374, 19491, 5408, 646, 647, 5410
24791, 495, 4962, 4964, 496, 5327, 19484, 19492, 5331
24792, 5327, 19484, 19492, 5331, 5328, 19485, 19493, 5332
24793, 5328, 19485, 19493, 5332, 5329, 19486, 19494, 5333
24794, 5329, 19486, 19494, 5333, 5330, 19487, 19495, 5334
24795, 5330, 19487, 19495, 5334, 636, 5409, 5411, 637
24796, 4962, 4963, 4965, 4964, 19484, 19488, 19496, 19492
24797, 19484, 19488, 19496, 19492, 19485, 19489, 19497, 19493
24798, 19485, 19489, 19497, 19493, 19486, 19490, 19498, 19494
24799, 19486, 19490, 19498, 19494, 19487, 19491, 19499, 19495
24800, 19487, 19491, 19499, 19495, 5409, 5410, 5412, 5411
24801, 4963, 569, 570, 4965, 19488, 5371, 5375, 19496
24802, 19488, 5371, 5375, 19496, 19489, 5372, 5376, 19497
24803, 19489, 5372, 5376, 19497, 19490, 5373, 5377, 19498
24804, 19490, 5373, 5377, 19498, 19491, 5374, 5378, 19499
24805, 19491, 5374, 5378, 19499, 5410, 647, 648, 5412
24806, 496, 4964, 4966, 497, 5331, 19492, 19500, 5335
24807, 5331, 19492, 19500, 5335, 5332, 19493, 19501, 5336
24808, 5332, 19493, 19501, 5336, 5333, 19494, 19502, 5337
24809, 5333, 19494, 19502, 5337, 5334, 19495, 19503, 5338
24810, 5334, 19495, 19503, 5338, 637, 5411, 5413, 638
24811, 4964, 4965, 4967, 4966, 19492, 19496, 19504, 19500
24812, 19492, 19496, 19504, 19500, 19493, 19497, 19505, 19501
24813, 19493, 19497, 19505, 19501, 19494, 19498, 19506, 19502
24814, 19494, 19498, 19506, 19502, 19495, 19499, 19507, 19503
24815, 19495, 19499, 19507, 19503, 5411, 5412, 5414, 5413
24816, 4965, 570, 571, 4967, 19496, 5375, 5379, 19504
24817, 19496, 5375, 5379, 19504, 19497, 5376, 5380, 19505
24818, 19497, 5376, 5380, 19505, 19498, 5377, 5381, 19506
24819, 19498, 5377, 5381, 19506, 19499, 5378, 5382, 19507
24820, 19499, 5378, 5382, 19507, 5412, 648, 649, 5414
24821, 497, 4966, 4968, 498, 5335, 19500, 19508, 5339
24822, 5335, 19500, 19508, 5339, 5336, 19501, 19509, 5340
24823, 5336, 19501, 19509, 5340, 5337, 19502, 19510, 5341
24824, 5337, 19502, 19510, 5341, 5338, 19503, 19511, 5342
24825, 5338, 19503, 19511, 5342, 638, 5413, 5415, 639
24826, 4966, 4967, 4969, 4968, 19500, 19504, 19512, 19508
24827, 19500, 19504, 19512, 19508, 19501, 19505, 19513, 19509
24828, 19501, 19505, 19513, 19509, 19502, 19506, 19514, 19510
24829, 19502, 19506, 19514, 19510, 19503, 19507, 19515, 19511
24830, 19503, 19507, 19515, 19511, 5413, 5414, 5416, 5415
24831, 4967, 571, 572, 4969, 19504, 5379, 5383, 19512
24832, 19504, 5379, 5383, 19512, 19505, 5380, 5384, 19513
24833, 19505, 5380, 5384, 19513, 19506, 5381, 5385, 19514
24834, 19506, 5381, 5385, 19514, 19507, 5382, 5386, 19515
24835, 19507, 5382, 5386, 19515, 5414, 649, 650, 5416
24836, 498, 4968, 4970, 499, 5339, 19508, 19516, 5343
24837, 5339, 19508, 19516, 5343, 5340, 19509, 19517, 5344
24838, 5340, 19509, 19517, 5344, 5341, 19510, 19518, 5345
24839, 5341, 19510, 19518, 5345, 5342, 19511, 19519, 5346
24840, 5342, 19511, 19519, 5346, 639, 5415, 5417, 640
24841, 4968, 4969, 4971, 4970, 19508, 19512, 19520, 19516
24842, 19508, 19512, 19520, 19516, 19509, 19513, 19521, 19517
24843, 19509, 19513, 19521, 19517, 19510, 19514, 19522, 19518
24844, 19510, 19514, 19522, 19518, 19511, 19515, 19523, 19519
24845, 19511, 19515, 19523, 19519, 5415, 5416, 5418, 5417
24846, 4969, 572, 573, 4971, 19512, 5383, 5387, 19520
24847, 19512, 5383, 5387, 19520, 19513, 5384, 5388, 19521
24848, 19513, 5384, 5388, 19521, 19514, 5385, 5389, 19522
24849, 19514, 5385, 5389, 19522, 19515, 5386, 5390, 19523
24850, 19515, 5386, 5390, 19523, 5416, 650, 651, 5418
24851, 499, 4970, 4972, 500, 5343, 19516, 19524, 5347
24852, 5343, 19516, 19524, 5347, 5344, 19517, 19525, 5348
24853, 5344, 19517, 19525, 5348, 5345, 19518, 19526, 5349
24854, 5345, 19518, 19526, 5349, 5346, 19519, 19527, 5350
24855, 5346, 19519, 19527, 5350, 640, 5417, 5419, 641
24856, 4970, 4971, 4973, 4972, 19516, 19520, 19528, 19524
24857, 19516, 19520, 19528, 19524, 19517, 19521, 19529, 19525
24858, 19517, 19521, 19529, 19525, 19518, 19522, 19530, 19526
24859, 19518, 19522, 19530, 19526, 19519, 19523, 19531, 19527
24860, 19519, 19523, 19531, 19527, 5417, 5418, 5420, 5419
24861, 4971, 573, 574, 4973, 19520, 5387, 5391, 19528
24862, 19520, 5387, 5391, 19528, 19521, 5388, 5392, 19529
24863, 19521, 5388, 5392, 19529, 19522, 5389, 5393, 19530
24864, 19522, 5389, 5393, 19530, 19523, 5390, 5394, 19531
24865, 19523, 5390, 5394, 19531, 5418, 651, 652, 5420
24866, 500, 4972, 4974, 501, 5347, 19524, 19532, 5351
24867, 5347, 19524, 19532, 5351, 5348, 19525, 19533, 5352
24868, 5348, 19525, 19533, 5352, 5349, 19526, 19534, 5353
24869, 5349, 19526, 19534, 5353, 5350, 19527, 19535, 5354
24870, 5350, 19527, 19535, 5354, 641, 5419, 5421, 642
24871, 4972, 4973, 4975, 4974, 19524, 19528, 19536, 19532
24872, 19524, 19528, 19536, 19532, 19525, 19529, 19537, 19533
24873, 19525, 19529, 19537, 19533, 19526, 19530, 19538, 19534
24874, 19526, 19530, 19538, 19534, 19527, 19531, 19539, 19535
24875, 19527, 19531, 19539, 19535, 5419, 5420, 5422, 5421
24876, 4973, 574, 575, 4975, 19528, 5391, 5395, 19536
24877, 19528, 5391, 5395, 19536, 19529, 5392, 5396, 19537
24878, 19529, 5392, 5396, 19537, 19530, 5393, 5397, 19538
24879, 19530, 5393, 5397, 19538, 19531, 5394, 5398, 19539
24880, 19531, 5394, 5398, 19539, 5420, 652, 653, 5422
24881, 501, 4974, 4976, 502, 5351, 19532, 19540, 5355
24882, 5351, 19532, 19540, 5355, 5352, 19533, 19541, 5356
24883, 5352, 19533, 19541, 5356, 5353, 19534, 19542, 5357
24884, 5353, 19534, 19542, 5357, 5354, 19535, 19543, 5358
24885, 5354, 19535, 19543, 5358, 642, 5421, 5423, 643
24886, 4974, 4975, 4977, 4976, 19532, 19536, 19544, 19540
24887, 19532, 19536, 19544, 19540, 19533, 19537, 19545, 19541
24888, 19533, 19537, 19545, 19541, 19534, 19538, 19546, 19542
24889, 19534, 19538, 19546, 19542, 19535, 19539, 19547, 19543
24890, 19535, 19539, 19547, 19543, 5421, 5422, 5424, 5423
24891, 4975, 575, 576, 4977, 19536, 5395, 5399, 19544
24892, 19536, 5395, 5399, 19544, 19537, 5396, 5400, 19545
24893, 19537, 5396, 5400, 19545, 19538, 5397, 5401, 19546
24894, 19538, 5397, 5401, 19546, 19539, 5398, 5402, 19547
24895, 19539, 5398, 5402, 19547, 5422, 653, 654, 5424
24896, 502, 4976, 564, 19, 5355, 19540, 5299, 613
24897, 5355, 19540, 5299, 613, 5356, 19541, 5300, 614
24898, 5356, 19541, 5300, 614, 5357, 19542, 5301, 615
24899, 5357, 19542, 5301, 615, 5358, 19543, 5302, 616
24900, 5358, 19543, 5302, 616, 643, 5423, 621, 25
24901, 4976, 4977, 565, 564, 19540, 19544, 5303, 5299
24902, 19540, 19544, 5303, 5299, 19541, 19545, 5304, 5300
24903, 19541, 19545, 5304, 5300, 19542, 19546, 5305, 5301
24904, 19542, 19546, 5305, 5301, 19543, 19547, 5306, 5302
24905, 19543, 19547, 5306, 5302, 5423, 5424, 622, 621
24906, 4977, 576, 23, 565, 19544, 5399, 617, 5303
24907, 19544, 5399, 617, 5303, 19545, 5400, 618, 5304
24908, 19545, 5400, 618, 5304, 19546, 5401, 619, 5305
24909, 19546, 5401, 619, 5305, 19547, 5402, 620, 5306
24910, 19547, 5402, 620, 5306, 5424, 654, 26, 622
*ELEMENT, type=C3D8, ELSET=Volume7
24911, 27, 631, 5403, 633, 703, 5471, 19548, 5517
24912, 703, 5471, 19548, 5517, 704, 5472, 19549, 5518
24913, 704, 5472, 19549, 5518, 705, 5473, 19550, 5519
24914, 705, 5473, 19550, 5519, 706, 5474, 19551, 5520
24915, 706, 5474, 19551, 5520, 707, 5475, 19552, 5521
24916, 707, 5475, 19552, 5521, 708, 5476, 19553, 5522
24917, 708, 5476, 19553, 5522, 709, 5477, 19554, 5523
24918, 709, 5477, 19554, 5523, 710, 5478, 19555, 5524
24919, 710, 5478, 19555, 5524, 711, 5479, 19556, 5525
24920, 711, 5479, 19556, 5525, 712, 5480, 19557, 5526
24921, 712, 5480, 19557, 5526, 713, 5481, 19558, 5527
24922, 713, 5481, 19558, 5527, 714, 5482, 19559, 5528
24923, 714, 5482, 19559, 5528, 715, 5483, 19560, 5529
24924, 715, 5483, 19560, 5529, 716, 5484, 19561, 5530
24925, 716, 5484, 19561, 5530, 717, 5485, 19562, 5531
24926, 717, 5485, 19562, 5531, 718, 5486, 19563, 5532
24927, 718, 5486, 19563, 5532, 719, 5487, 19564, 5533
24928, 719, 5487, 19564, 5533, 720, 5488, 19565, 5534
24929, 720, 5488, 19565, 5534, 721, 5489, 19566, 5535
24930, 721, 5489, 19566, 5535, 722, 5490, 19567, 5536
24931, 722, 5490, 19567, 5536, 723, 5491, 19568, 5537
24932, 723, 5491, 19568, 5537, 724, 5492, 19569, 5538
24933, 724, 5492, 19569, 5538, 725, 5493, 19570, 5539
24934, 725, 5493, 19570, 5539, 31, 749, 6023, 751
24935, 631, 632, 5404, 5403, 5471, 5494, 19571, 19548
24936, 5471, 5494, 19571, 19548, 5472, 5495, 19572, 19549
24937, 5472, 5495, 19572, 19549, 5473, 5496, 19573, 19550
24938, 5473, 5496, 19573, 19550, 5474, 5497, 19574, 19551
24939, 5474, 5497, 19574, 19551, 5475, 5498, 19575, 19552
24940, 5475, 5498, 19575, 19552, 5476, 5499, 19576, 19553
24941, 5476, 5499, 19576, 19553, 5477, 5500, 19577, 19554
24942, 5477, 5500, 19577, 19554, 5478, 5501, 19578, 19555
24943, 5478, 5501, 19578, 19555, 5479, 5502, 19579, 19556
24944, 5479, 5502, 19579, 19556, 5480, 5503, 19580, 19557
24945, 5480, 5503, 19580, 19557, 5481, 5504, 19581, 19558
24946, 5481, 5504, 19581, 19558, 5482, 5505, 19582, 19559
24947, 5482, 5505, 19582, 19559, 5483, 5506, 19583, 19560
24948, 5483, 5506, 19583, 19560, 5484, 5507, 19584, 19561
24949, 5484, 5507, 19584, 19561, 5485, 5508, 19585, 19562
24950, 5485, 5508, 19585, 19562, 5486, 5509, 19586, 19563
24951, 5486, 5509, 19586, 19563, 5487, 5510, 19587, 19564
24952, 5487, 5510, 19587, 19564, 5488, 5511, 19588, 19565
24953, 5488, 5511, 19588, 19565, 5489, 5512, 19589, 19566
24954, 5489, 5512, 19589, 19566, 5490, 5513, 19590, 19567
24955, 5490, 5513, 19590, 19567, 5491, 5514, 19591, 19568
24956, 5491, 5514, 19591, 19568, 5492, 5515, 19592, 19569
24957, 5492, 5515, 19592, 19569, 5493, 5516, 19593, 19570
24958, 5493, 5516, 19593, 19570, 749, 750, 6024, 6023
24959, 632, 28, 644, 5404, 5494, 726, 5770, 19571
24960, 5494, 726, 5770, 19571, 5495, 727, 5771, 19572
24961, 5495, 727, 5771, 19572, 5496, 728, 5772, 19573
24962, 5496, 728, 5772, 19573, 5497, 729, 5773, 19574
24963, 5497, 729, 5773, 19574, 5498, 730, 5774, 19575
24964, 5498, 730, 5774, 19575, 5499, 731, 5775, 19576
24965, 5499, 731, 5775, 19576, 5500, 732, 5776, 19577
24966, 5500, 732, 5776, 19577, 5501, 733, 5777, 19578
24967, 5501, 733, 5777, 19578, 5502, 734, 5778, 19579
24968, 5502, 734, 5778, 19579, 5503, 735, 5779, 19580
24969, 5503, 735, 5779, 19580, 5504, 736, 5780, 19581
24970, 5504, 736, 5780, 19581, 5505, 737, 5781, 19582
24971, 5505, 737, 5781, 19582, 5506, 738, 5782, 19583
24972, 5506, 738, 5782, 19583, 5507, 739, 5783, 19584
24973, 5507, 739, 5783, 19584, 5508, 740, 5784, 19585
24974, 5508, 740, 5784, 19585, 5509, 741, 5785, 19586
24975, 5509, 741, 5785, 19586, 5510, 742, 5786, 19587
24976, 5510, 742, 5786, 19587, 5511, 743, 5787, 19588
24977, 5511, 743, 5787, 19588, 5512, 744, 5788, 19589
24978, 5512, 744, 5788, 19589, 5513, 745, 5789, 19590
24979, 5513, 745, 5789, 19590, 5514, 746, 5790, 19591
24980, 5514, 746, 5790, 19591, 5515, 747, 5791, 19592
24981, 5515, 747, 5791, 19592, 5516, 748, 5792, 19593
24982, 5516, 748, 5792, 19593, 750, 32, 762, 6024
24983, 633, 5403, 5405, 634, 5517, 19548, 19594, 5540
24984, 5517, 19548, 19594, 5540, 5518, 19549, 19595, 5541
24985, 5518, 19549, 19595, 5541, 5519, 19550, 19596, 5542
24986, 5519, 19550, 19596, 5542, 5520, 19551, 19597, 5543
24987, 5520, 19551, 19597, 5543, 5521, 19552, 19598, 5544
24988, 5521, 19552, 19598, 5544, 5522, 19553, 19599, 5545
24989, 5522, 19553, 19599, 5545, 5523, 19554, 19600, 5546
24990, 5523, 19554, 19600, 5546, 5524, 19555, 19601, 5547
24991, 5524, 19555, 19601, 5547, 5525, 19556, 19602, 5548
24992, 5525, 19556, 19602, 5548, 5526, 19557, 19603, 5549
24993, 5526, 19557, 19603, 5549, 5527, 19558, 19604, 5550
24994, 5527, 19558, 19604, 5550, 5528, 19559, 19605, 5551
24995, 5528, 19559, 19605, 5551, 5529, 19560, 19606, 5552
24996, 5529, 19560, 19606, 5552, 5530, 19561, 19607, 5553
24997, 5530, 19561, 19607, 5553, 5531, 19562, 19608, 5554
24998, 5531, 19562, 19608, 5554, 5532, 19563, 19609, 5555
24999, 5532, 19563, 19609, 5555, 5533, 19564, 19610, 5556
25000, 5533, 19564, 19610, 5556, 5534, 19565, 19611, 5557
25001, 5534, 19565, 19611, 5557, 5535, 19566, 19612, 5558
25002, 5535, 19566, 19612, 5558, 5536, 19567, 19613, 5559
25003, 5536, 19567, 19613, 5559, 5537, 19568, 19614, 5560
25004, 5537, 19568, 19614, 5560, 5538, 19569, 19615, 5561
25005, 5538, 19569, 19615, 5561, 5539, 19570, 19616, 5562
25006, 5539, 19570, 19616, 5562, 751, 6023, 6025, 752
25007, 5403, 5404, 5406, 5405, 19548, 19571, 19617, 19594
25008, 19548, 19571, 19617, 19594, 19549, 19572, 19618, 19595
25009, 19549, 19572, 19618, 19595, 19550, 19573, 19619, 19596
25010, 19550, 19573, 19619, 19596, 19551, 19574, 19620, 19597
25011, 19551, 19574, 19620, 19597, 19552, 19575, 19621, 19598
25012, 19552, 19575, 19621, 19598, 19553, 19576, 19622, 19599
25013, 19553, 19576, 19622, 19599, 19554, 19577, 19623, 19600
25014, 19554, 19577, 19623, 19600, 19555, 19578, 19624, 19601
25015, 19555, 19578, 19624, 19601, 19556, 19579, 19625, 19602
25016, 19556, 19579, 19625, 19602, 19557, 19580, 19626, 19603
25017, 19557, 19580, 19626, 19603, 19558, 19581, 19627, 19604
25018, 19558, 19581, 19627, 19604, 19559, 19582, 19628, 19605
25019, 19559, 19582, 19628, 19605, 19560, 19583, 19629, 19606
25020, 19560, 19583, 19629, 19606, 19561, 19584, 19630, 19607
25021, 19561, 19584, 19630, 19607, 19562, 19585, 19631, 19608
25022, 19562, 19585, 19631, 19608, 19563, 19586, 19632, 19609
25023, 19563, 19586, 19632, 19609, 19564, 19587, 19633, 19610
25024, 19564, 19587, 19633, 19610, 19565, 19588, 19634, 19611
25025, 19565, 19588, 19634, 19611, 19566, 19589, 19635, 19612
25026, 19566, 19589, 19635, 19612, 19567, 19590, 19636, 19613
25027, 19567, 19590, 19636, 19613, 19568, 19591, 19637, 19614
25028, 19568, 19591, 19637, 19614, 19569, 19592, 19638, 19615
25029, 19569, 19592, 19638, 19615, 19570, 19593, 19639, 19616
25030, 19570, 19593, 19639, 19616, 6023, 6024, 6026, 6025
25031, 5404, 644, 645, 5406, 19571, 5770, 5793, 19617
25032, 19571, 5770, 5793, 19617, 19572, 5771, 5794, 19618
25033, 19572, 5771, 5794, 19618, 19573, 5772, 5795, 19619
25034, 19573, 5772, 5795, 19619, 19574, 5773, 5796, 19620
25035, 19574, 5773, 5796, 19620, 19575, 5774, 5797, 19621
25036, 19575, 5774, 5797, 19621, 19576, 5775, 5798, 19622
25037, 19576, 5775, 5798, 19622, 19577, 5776, 5799, 19623
25038, 19577, 5776, 5799, 19623, 19578, 5777, 5800, 19624
25039, 19578, 5777, 5800, 19624, 19579, 5778, 5801, 19625
25040, 19579, 5778, 5801, 19625, 19580, 5779, 5802, 19626
25041, 19580, 5779, 5802, 19626, 19581, 5780, 5803, 19627
25042, 19581, 5780, 5803, 19627, 19582, 5781, 5804, 19628
25043, 19582, 5781, 5804, 19628, 19583, 5782, 5805, 19629
25044, 19583, 5782, 5805, 19629, 19584, 5783, 5806, 19630
25045, 19584, 5783, 5806, 19630, 19585, 5784, 5807, 19631
25046, 19585, 5784, 5807, 19631, 19586, 5785, 5808, 19632
25047, 19586, 5785, 5808, 19632, 19587, 5786, 5809, 19633
25048, 19587, 5786, 5809, 19633, 19588, 5787, 5810, 19634
25049, 19588, 5787, 5810, 19634, 19589, 5788, 5811, 19635
25050, 19589, 5788, 5811, 19635, 19590, 5789, 5812, 19636
25051, 19590, 5789, 5812, 19636, 19591, 5790, 5813, 19637
25052, 19591, 5790, 5813, 19637, 19592, 5791, 5814, 19638
25053, 19592, 5791, 5814, 19638, 19593, 5792, 5815, 19639
25054, 19593, 5792, 5815, 19639, 6024, 762, 763, 6026
25055, 634, 5405, 5407, 635, 5540, 19594, 19640, 5563
25056, 5540, 19594, 19640, 5563, 5541, 19595, 19641, 5564
25057, 5541, 19595, 19641, 5564, 5542, 19596, 19642, 5565
25058, 5542, 19596, 19642, 5565, 5543, 19597, 19643, 5566
25059, 5543, 19597, 19643, 5566, 5544, 19598, 19644, 5567
25060, 5544, 19598, 19644, 5567, 5545, 19599, 19645, 5568
25061, 5545, 19599, 19645, 5568, 5546, 19600, 19646, 5569
25062, 5546, 19600, 19646, 5569, 5547, 19601, 19647, 5570
25063, 5547, 19601, 19647, 5570, 5548, 19602, 19648, 5571
25064, 5548, 19602, 19648, 5571, 5549, 19603, 19649, 5572
25065, 5549, 19603, 19649, 5572, 5550, 19604, 19650, 5573
25066, 5550, 19604, 19650, 5573, 5551, 19605, 19651, 5574
25067, 5551, 19605, 19651, 5574, 5552, 19606, 19652, 5575
25068, 5552, 19606, 19652, 5575, 5553, 19607, 19653, 5576
25069, 5553, 19607, 19653, 5576, 5554, 19608, 19654, 5577
25070, 5554, 19608, 19654, 5577, 5555, 19609, 19655, 5578
25071, 5555, 19609, 19655, 5578, 5556, 19610, 19656, 5579
25072, 5556, 19610, 19656, 5579, 5557, 19611, 19657, 5580
25073, 5557, 19611, 19657, 5580, 5558, 19612, 19658, 5581
25074, 5558, 19612, 19658, 5581, 5559, 19613, 19659, 5582
25075, 5559, 19613, 19659, 5582, 5560, 19614, 19660, 5583
25076, 5560, 19614, 19660, 5583, 5561, 19615, 19661, 5584
25077, 5561, 19615, 19661, 5584, 5562, 19616, 19662, 5585
25078, 5562, 19616, 19662, 5585, 752, 6025, 6027, 753
25079, 5405, 5406, 5408, 5407, 19594, 19617, 19663, 19640
25080, 19594, 19617, 19663, 19640, 19595, 19618, 19664, 19641
25081, 19595, 19618, 19664, 19641, 19596, 19619, 19665, 19642
25082, 19596, 19619, 19665, 19642, 19597, 19620, 19666, 19643
25083, 19597, 19620, 19666, 19643, 19598, 19621, 19667, 19644
25084, 19598, 19621, 19667, 19644, 19599, 19622, 19668, 19645
25085, 19599, 19622, 19668, 19645, 19600, 19623, 19669, 19646
25086, 19600, 19623, 19669, 19646, 19601, 19624, 19670, 19647
25087, 19601, 19624, 19670, 19647, 19602, 19625, 19671, 19648
25088, 19602, 19625, 19671, 19648, 19603, 19626, 19672, 19649
25089, 19603, 19626, 19672, 19649, 19604, 19627, 19673, 19650
25090, 19604, 19627, 19673, 19650, 19605, 19628, 19674, 19651
25091, 19605, 19628, 19674, 19651, 19606, 19629, 19675, 19652
25092, 19606, 19629, 19675, 19652, 19607, 19630, 19676, 19653
25093, 19607, 19630, 19676, 19653, 19608, 19631, 19677, 19654
25094, 19608, 19631, 19677, 19654, 19609, 19632, 19678, 19655
25095, 19609, 19632, 19678, 19655, 19610, 19633, 19679, 19656
25096, 19610, 19633, 19679, 19656, 19611, 19634, 19680, 19657
25097, 19611, 19634, 19680, 19657, 19612, 19635, 19681, 19658
25098, 19612, 19635, 19681, 19658, 19613, 19636, 19682, 19659
25099, 19613, 19636, 19682, 19659, 19614, 19637, 19683, 19660
25100, 19614, 19637, 19683, 19660, 19615, 19638, 19684, 19661
25101, 19615, 19638, 19684, 19661, 19616, 19639, 19685, 19662
25102, 19616, 19639, 19685, 19662, 6025, 6026, 6028, 6027
25103, 5406, 645, 646, 5408, 19617, 5793, 5816, 19663
25104, 19617, 5793, 5816, 19663, 19618, 5794, 5817, 19664
25105, 19618, 5794, 5817, 19664, 19619, 5795, 5818, 19665
25106, 19619, 5795, 5818, 19665, 19620, 5796, 5819, 19666
25107, 19620, 5796, 5819, 19666, 19621, 5797, 5820, 19667
25108, 19621, 5797, 5820, 19667, 19622, 5798, 5821, 19668
25109, 19622, 5798, 5821, 19668, 19623, 5799, 5822, 19669
25110, 19623, 5799, 5822, 19669, 19624, 5800, 5823, 19670
25111, 19624, 5800, 5823, 19670, 19625, 5801, 5824, 19671
25112, 19625, 5801, 5824, 19671, 19626, 5802, 5825, 19672
25113, 19626, 5802, 5825, 19672, 19627, 5803, 5826, 19673
25114, 19627, 5803, 5826, 19673, 19628, 5804, 5827, 19674
25115, 19628, 5804, 5827, 19674, 19629, 5805, 5828, 19675
25116, 19629, 5805, 5828, 19675, 19630, 5806, 5829, 19676
25117, 19630, 5806, 5829, 19676, 19631, 5807, 5830, 19677
25118, 19631, 5807, 5830, 19677, 19632, 5808, 5831, 19678
25119, 19632, 5808, 5831, 19678, 19633, 5809, 5832, 19679
25120, 19633, 5809, 5832, 19679, 19634, 5810, 5833, 19680
25121, 19634, 5810, 5833, 19680, 19635, 5811, 5834, 19681
25122, 19635, 5811, 5834, 19681, 19636, 5812, 5835, 19682
25123, 19636, 5812, 5835, 19682, 19637, 5813, 5836, 19683
25124, 19637, 5813, 5836, 19683, 19638, 5814, 5837, 19684
25125, 19638, 5814, 5837, 19684, 19639, 5815, 5838, 19685
25126, 19639, 5815, 5838, 19685, 6026, 763, 764, 6028
25127, 635, 5407, 5409, 636, 5563, 19640, 19686, 5586
25128, 5563, 19640, 19686, 5586, 5564, 19641, 19687, 5587
25129, 5564, 19641, 19687, 5587, 5565, 19642, 19688, 5588
25130, 5565, 19642, 19688, 5588, 5566, 19643, 19689, 5589
25131, 5566, 19643, 19689, 5589, 5567, 19644, 19690, 5590
25132, 5567, 19644, 19690, 5590, 5568, 19645, 19691, 5591
25133, 5568, 19645, 19691, 5591, 5569, 19646, 19692, 5592
25134, 5569, 19646, 19692, 5592, 5570, 19647, 19693, 5593
25135, 5570, 19647, 19693, 5593, 5571, 19648, 19694, 5594
25136, 5571, 19648, 19694, 5594, 5572, 19649, 19695, 5595
25137, 5572, 19649, 19695, 5595, 5573, 19650, 19696, 5596
25138, 5573, 19650, 19696, 5596, 5574, 19651, 19697, 5597
25139, 5574, 19651, 19697, 5597, 5575, 19652, 19698, 5598
25140, 5575, 19652, 19698, 5598, 5576, 19653, 19699, 5599
25141, 5576, 19653, 19699, 5599, 5577, 19654, 19700, 5600
25142, 5577, 19654, 19700, 5600, 5578, 19655, 19701, 5601
25143, 5578, 19655, 19701, 5601, 5579, 19656, 19702, 5602
25144, 5579, 19656, 19702, 5602, 5580, 19657, 19703, 5603
25145, 5580, 19657, 19703, 5603, 5581, 19658, 19704, 5604
25146, 5581, 19658, 19704, 5604, 5582, 19659, 19705, 5605
25147, 5582, 19659, 19705, 5605, 5583, 19660, 19706, 5606
25148, 5583, 19660, 19706, 5606, 5584, 19661, 19707, 5607
25149, 5584, 19661, 19707, 5607, 5585, 19662, 19708, 5608
25150, 5585, 19662, 19708, 5608, 753, 6027, 6029, 754
25151, 5407, 5408, 5410, 5409, 19640, 19663, 19709, 19686
25152, 19640, 19663, 19709, 19686, 19641, 19664, 19710, 19687
25153, 19641, 19664, 19710, 19687, 19642, 19665, 19711, 19688
25154, 19642, 19665, 19711, 19688, 19643, 19666, 19712, 19689
25155, 19643, 19666, 19712, 19689, 19644, 19667, 19713, 19690
25156, 19644, 19667, 19713, 19690, 19645, 19668, 19714, 19691
25157, 19645, 19668, 19714, 19691, 19646, 19669, 19715, 19692
25158, 19646, 19669, 19715, 19692, 19647, 19670, 19716, 19693
25159, 19647, 19670, 19716, 19693, 19648, 19671, 19717, 19694
25160, 19648, 19671, 19717, 19694, 19649, 19672, 19718, 19695
25161, 19649, 19672, 19718, 19695, 19650, 19673, 19719, 19696
25162, 19650, 19673, 19719, 19696, 19651, 19674, 19720, 19697
25163, 19651, 19674, 19720, 19697, 19652, 19675, 19721, 19698
25164, 19652, 19675, 19721, 19698, 19653, 19676, 19722, 19699
25165, 19653, 19676, 19722, 19699, 19654, 19677, 19723, 19700
25166, 19654, 19677, 19723, 19700, 19655, 19678, 19724, 19701
25167, 19655, 19678, 19724, 19701, 19656, 19679, 19725, 19702
25168, 19656, 19679, 19725, 19702, 19657, 19680, 19726, 19703
25169, 19657, 19680, 19726, 19703, 19658, 19681, 19727, 19704
25170, 19658, 19681, 19727, 19704, 19659, 19682, 19728, 19705
25171, 19659, 19682, 19728, 19705, 19660, 19683, 19729, 19706
25172, 19660, 19683, 19729, 19706, 19661, 19684, 19730, 19707
25173, 19661, 19684, 19730, 19707, 19662, 19685, 19731, 19708
25174, 19662, 19685, 19731, 19708, 6027, 6028, 6030, 6029
25175, 5408, 646, 647, 5410, 19663, 5816, 5839, 19709
25176, 19663, 5816, 5839, 19709, 19664, 5817, 5840, 19710
25177, 19664, 5817, 5840, 19710, 19665, 5818, 5841, 19711
25178, 19665, 5818, 5841, 19711, 19666, 5819, 5842, 19712
25179, 19666, 5819, 5842, 19712, 19667, 5820, 5843, 19713
25180, 19667, 5820, 5843, 19713, 19668, 5821, 5844, 19714
25181, 19668, 5821, 5844, 19714, 19669, 5822, 5845, 19715
25182, 19669, 5822, 5845, 19715, 19670, 5823, 5846, 19716
25183, 19670, 5823, 5846, 19716, 19671, 5824, 5847, 19717
25184, 19671, 5824, 5847, 19717, 19672, 5825, 5848, 19718
25185, 19672, 5825, 5848, 19718, 19673, 5826, 5849, 19719
25186, 19673, 5826, 5849, 19719, 19674, 5827, 5850, 19720
25187, 19674, 5827, 5850, 19720, 19675, 5828, 5851, 19721
25188, 19675, 5828, 5851, 19721, 19676, 5829, 5852, 19722
25189, 19676, 5829, 5852, 19722, 19677, 5830, 5853, 19723
25190, 19677, 5830, 5853, 19723, 19678, 5831, 5854, 19724
25191, 19678, 5831, 5854, 19724, 19679, 5832, 5855, 19725
25192, 19679, 5832, 5855, 19725, 19680, 5833, 5856, 19726
25193, 19680, 5833, 5856, 19726, 19681, 5834, 5857, 19727
25194, 19681, 5834, 5857, 19727, 19682, 5835, 5858, 19728
25195, 19682, 5835, 5858, 19728, 19683, 5836, 5859, 19729
25196, 19683, 5836, 5859, 19729, 19684, 5837, 5860, 19730
25197, 19684, 5837, 5860, 19730, 19685, 5838, 5861, 19731
25198, 19685, 5838, 5861, 19731, 6028, 764, 765, 6030
25199, 636, 5409, 5411, 637, 5586, 19686, 19732, 5609
25200, 5586, 19686, 19732, 5609, 5587, 19687, 19733, 5610
25201, 5587, 19687, 19733, 5610, 5588, 19688, 19734, 5611
25202, 5588, 19688, 19734, 5611, 5589, 19689, 19735, 5612
25203, 5589, 19689, 19735, 5612, 5590, 19690, 19736, 5613
25204, 5590, 19690, 19736, 5613, 5591, 19691, 19737, 5614
25205, 5591, 19691, 19737, 5614, 5592, 19692, 19738, 5615
25206, 5592, 19692, 19738, 5615, 5593, 19693, 19739, 5616
25207, 5593, 19693, 19739, 5616, 5594, 19694, 19740, 5617
25208, 5594, 19694, 19740, 5617, 5595, 19695, 19741, 5618
