37042, 27116, 27120, 27164, 27160, 27117, 27121, 27165, 27161
37043, 27117, 27121, 27165, 27161, 27118, 27122, 27166, 27162
37044, 27118, 27122, 27166, 27162, 10821, 10822, 10833, 10832
37045, 5231, 5232, 5243, 5242, 27119, 27123, 27167, 27163
37046, 27119, 27123, 27167, 27163, 27120, 27124, 27168, 27164
37047, 27120, 27124, 27168, 27164, 27121, 27125, 27169, 27165
37048, 27121, 27125, 27169, 27165, 27122, 27126, 27170, 27166
37049, 27122, 27126, 27170, 27166, 10822, 10823, 10834, 10833
37050, 5232, 595, 596, 5243, 27123, 10565, 10569, 27167
37051, 27123, 10565, 10569, 27167, 27124, 10566, 10570, 27168
37052, 27124, 10566, 10570, 27168, 27125, 10567, 10571, 27169
37053, 27125, 10567, 10571, 27169, 27126, 10568, 10572, 27170
37054, 27126, 10568, 10572, 27170, 10823, 1629, 1630, 10834
37055, 558, 5233, 5244, 559, 10433, 27127, 27171, 10437
37056, 10433, 27127, 27171, 10437, 10434, 27128, 27172, 10438
37057, 10434, 27128, 27172, 10438, 10435, 27129, 27173, 10439
37058, 10435, 27129, 27173, 10439, 10436, 27130, 27174, 10440
37059, 10436, 27130, 27174, 10440, 1588, 10824, 10835, 1589
37060, 5233, 5234, 5245, 5244, 27127, 27131, 27175, 27171
37061, 27127, 27131, 27175, 27171, 27128, 27132, 27176, 27172
37062, 27128, 27132, 27176, 27172, 27129, 27133, 27177, 27173
37063, 27129, 27133, 27177, 27173, 27130, 27134, 27178, 27174
37064, 27130, 27134, 27178, 27174, 10824, 10825, 10836, 10835
37065, 5234, 5235, 5246, 5245, 27131, 27135, 27179, 27175
37066, 27131, 27135, 27179, 27175, 27132, 27136, 27180, 27176
37067, 27132, 27136, 27180, 27176, 27133, 27137, 27181, 27177
37068, 27133, 27137, 27181, 27177, 27134, 27138, 27182, 27178
37069, 27134, 27138, 27182, 27178, 10825, 10826, 10837, 10836
37070, 5235, 5236, 5247, 5246, 27135, 27139, 27183, 27179
37071, 27135, 27139, 27183, 27179, 27136, 27140, 27184, 27180
37072, 27136, 27140, 27184, 27180, 27137, 27141, 27185, 27181
37073, 27137, 27141, 27185, 27181, 27138, 27142, 27186, 27182
37074, 27138, 27142, 27186, 27182, 10826, 10827, 10838, 10837
37075, 5236, 5237, 5248, 5247, 27139, 27143, 27187, 27183
37076, 27139, 27143, 27187, 27183, 27140, 27144, 27188, 27184
37077, 27140, 27144, 27188, 27184, 27141, 27145, 27189, 27185
37078, 27141, 27145, 27189, 27185, 27142, 27146, 27190, 27186
37079, 27142, 27146, 27190, 27186, 10827, 10828, 10839, 10838
37080, 5237, 5238, 5249, 5248, 27143, 27147, 27191, 27187
37081, 27143, 27147, 27191, 27187, 27144, 27148, 27192, 27188
37082, 27144, 27148, 27192, 27188, 27145, 27149, 27193, 27189
37083, 27145, 27149, 27193, 27189, 27146, 27150, 27194, 27190
37084, 27146, 27150, 27194, 27190, 10828, 10829, 10840, 10839
37085, 5238, 5239, 5250, 5249, 27147, 27151, 27195, 27191
37086, 27147, 27151, 27195, 27191, 27148, 27152, 27196, 27192
37087, 27148, 27152, 27196, 27192, 27149, 27153, 27197, 27193
37088, 27149, 27153, 27197, 27193, 27150, 27154, 27198, 27194
37089, 27150, 27154, 27198, 27194, 10829, 10830, 10841, 10840
37090, 5239, 5240, 5251, 5250, 27151, 27155, 27199, 27195
37091, 27151, 27155, 27199, 27195, 27152, 27156, 27200, 27196
37092, 27152, 27156, 27200, 27196, 27153, 27157, 27201, 27197
37093, 27153, 27157, 27201, 27197, 27154, 27158, 27202, 27198
37094, 27154, 27158, 27202, 27198, 10830, 10831, 10842, 10841
37095, 5240, 5241, 5252, 5251, 27155, 27159, 27203, 27199
37096, 27155, 27159, 27203, 27199, 27156, 27160, 27204, 27200
37097, 27156, 27160, 27204, 27200, 27157, 27161, 27205, 27201
37098, 27157, 27161, 27205, 27201, 27158, 27162, 27206, 27202
37099, 27158, 27162, 27206, 27202, 10831, 10832, 10843, 10842
37100, 5241, 5242, 5253, 5252, 27159, 27163, 27207, 27203
37101, 27159, 27163, 27207, 27203, 27160, 27164, 27208, 27204
37102, 27160, 27164, 27208, 27204, 27161, 27165, 27209, 27205
37103, 27161, 27165, 27209, 27205, 27162, 27166, 27210, 27206
37104, 27162, 27166, 27210, 27206, 10832, 10833, 10844, 10843
37105, 5242, 5243, 5254, 5253, 27163, 27167, 27211, 27207
37106, 27163, 27167, 27211, 27207, 27164, 27168, 27212, 27208
37107, 27164, 27168, 27212, 27208, 27165, 27169, 27213, 27209
37108, 27165, 27169, 27213, 27209, 27166, 27170, 27214, 27210
37109, 27166, 27170, 27214, 27210, 10833, 10834, 10845, 10844
37110, 5243, 596, 597, 5254, 27167, 10569, 10573, 27211
37111, 27167, 10569, 10573, 27211, 27168, 10570, 10574, 27212
37112, 27168, 10570, 10574, 27212, 27169, 10571, 10575, 27213
37113, 27169, 10571, 10575, 27213, 27170, 10572, 10576, 27214
37114, 27170, 10572, 10576, 27214, 10834, 1630, 1631, 10845
37115, 559, 5244, 5255, 560, 10437, 27171, 27215, 10441
37116, 10437, 27171, 27215, 10441, 10438, 27172, 27216, 10442
37117, 10438, 27172, 27216, 10442, 10439, 27173, 27217, 10443
37118, 10439, 27173, 27217, 10443, 10440, 27174, 27218, 10444
37119, 10440, 27174, 27218, 10444, 1589, 10835, 10846, 1590
37120, 5244, 5245, 5256, 5255, 27171, 27175, 27219, 27215
37121, 27171, 27175, 27219, 27215, 27172, 27176, 27220, 27216
37122, 27172, 27176, 27220, 27216, 27173, 27177, 27221, 27217
37123, 27173, 27177, 27221, 27217, 27174, 27178, 27222, 27218
37124, 27174, 27178, 27222, 27218, 10835, 10836, 10847, 10846
37125, 5245, 5246, 5257, 5256, 27175, 27179, 27223, 27219
37126, 27175, 27179, 27223, 27219, 27176, 27180, 27224, 27220
37127, 27176, 27180, 27224, 27220, 27177, 27181, 27225, 27221
37128, 27177, 27181, 27225, 27221, 27178, 27182, 27226, 27222
37129, 27178, 27182, 27226, 27222, 10836, 10837, 10848, 10847
37130, 5246, 5247, 5258, 5257, 27179, 27183, 27227, 27223
37131, 27179, 27183, 27227, 27223, 27180, 27184, 27228, 27224
37132, 27180, 27184, 27228, 27224, 27181, 27185, 27229, 27225
37133, 27181, 27185, 27229, 27225, 27182, 27186, 27230, 27226
37134, 27182, 27186, 27230, 27226, 10837, 10838, 10849, 10848
37135, 5247, 5248, 5259, 5258, 27183, 27187, 27231, 27227
37136, 27183, 27187, 27231, 27227, 27184, 27188, 27232, 27228
37137, 27184, 27188, 27232, 27228, 27185, 27189, 27233, 27229
37138, 27185, 27189, 27233, 27229, 27186, 27190, 27234, 27230
37139, 27186, 27190, 27234, 27230, 10838, 10839, 10850, 10849
37140, 5248, 5249, 5260, 5259, 27187, 27191, 27235, 27231
37141, 27187, 27191, 27235, 27231, 27188, 27192, 27236, 27232
37142, 27188, 27192, 27236, 27232, 27189, 27193, 27237, 27233
37143, 27189, 27193, 27237, 27233, 27190, 27194, 27238, 27234
37144, 27190, 27194, 27238, 27234, 10839, 10840, 10851, 10850
37145, 5249, 5250, 5261, 5260, 27191, 27195, 27239, 27235
37146, 27191, 27195, 27239, 27235, 27192, 27196, 27240, 27236
37147, 27192, 27196, 27240, 27236, 27193, 27197, 27241, 27237
37148, 27193, 27197, 27241, 27237, 27194, 27198, 27242, 27238
37149, 27194, 27198, 27242, 27238, 10840, 10841, 10852, 10851
37150, 5250, 5251, 5262, 5261, 27195, 27199, 27243, 27239
37151, 27195, 27199, 27243, 27239, 27196, 27200, 27244, 27240
37152, 27196, 27200, 27244, 27240, 27197, 27201, 27245, 27241
37153, 27197, 27201, 27245, 27241, 27198, 27202, 27246, 27242
37154, 27198, 27202, 27246, 27242, 10841, 10842, 10853, 10852
37155, 5251, 5252, 5263, 5262, 27199, 27203, 27247, 27243
37156, 27199, 27203, 27247, 27243, 27200, 27204, 27248, 27244
37157, 27200, 27204, 27248, 27244, 27201, 27205, 27249, 27245
37158, 27201, 27205, 27249, 27245, 27202, 27206, 27250, 27246
37159, 27202, 27206, 27250, 27246, 10842, 10843, 10854, 10853
37160, 5252, 5253, 5264, 5263, 27203, 27207, 27251, 27247
37161, 27203, 27207, 27251, 27247, 27204, 27208, 27252, 27248
37162, 27204, 27208, 27252, 27248, 27205, 27209, 27253, 27249
37163, 27205, 27209, 27253, 27249, 27206, 27210, 27254, 27250
37164, 27206, 27210, 27254, 27250, 10843, 10844, 10855, 10854
37165, 5253, 5254, 5265, 5264, 27207, 27211, 27255, 27251
37166, 27207, 27211, 27255, 27251, 27208, 27212, 27256, 27252
37167, 27208, 27212, 27256, 27252, 27209, 27213, 27257, 27253
37168, 27209, 27213, 27257, 27253, 27210, 27214, 27258, 27254
37169, 27210, 27214, 27258, 27254, 10844, 10845, 10856, 10855
37170, 5254, 597, 598, 5265, 27211, 10573, 10577, 27255
37171, 27211, 10573, 10577, 27255, 27212, 10574, 10578, 27256
37172, 27212, 10574, 10578, 27256, 27213, 10575, 10579, 27257
37173, 27213, 10575, 10579, 27257, 27214, 10576, 10580, 27258
37174, 27214, 10576, 10580, 27258, 10845, 1631, 1632, 10856
37175, 560, 5255, 5266, 561, 10441, 27215, 27259, 10445
37176, 10441, 27215, 27259, 10445, 10442, 27216, 27260, 10446
37177, 10442, 27216, 27260, 10446, 10443, 27217, 27261, 10447
37178, 10443, 27217, 27261, 10447, 10444, 27218, 27262, 10448
37179, 10444, 27218, 27262, 10448, 1590, 10846, 10857, 1591
37180, 5255, 5256, 5267, 5266, 27215, 27219, 27263, 27259
37181, 27215, 27219, 27263, 27259, 27216, 27220, 27264, 27260
37182, 27216, 27220, 27264, 27260, 27217, 27221, 27265, 27261
37183, 27217, 27221, 27265, 27261, 27218, 27222, 27266, 27262
37184, 27218, 27222, 27266, 27262, 10846, 10847, 10858, 10857
37185, 5256, 5257, 5268, 5267, 27219, 27223, 27267, 27263
37186, 27219, 27223, 27267, 27263, 27220, 27224, 27268, 27264
37187, 27220, 27224, 27268, 27264, 27221, 27225, 27269, 27265
37188, 27221, 27225, 27269, 27265, 27222, 27226, 27270, 27266
37189, 27222, 27226, 27270, 27266, 10847, 10848, 10859, 10858
37190, 5257, 5258, 5269, 5268, 27223, 27227, 27271, 27267
37191, 27223, 27227, 27271, 27267, 27224, 27228, 27272, 27268
37192, 27224, 27228, 27272, 27268, 27225, 27229, 27273, 27269
37193, 27225, 27229, 27273, 27269, 27226, 27230, 27274, 27270
37194, 27226, 27230, 27274, 27270, 10848, 10849, 10860, 10859
37195, 5258, 5259, 5270, 5269, 27227, 27231, 27275, 27271
37196, 27227, 27231, 27275, 27271, 27228, 27232, 27276, 27272
37197, 27228, 27232, 27276, 27272, 27229, 27233, 27277, 27273
37198, 27229, 27233, 27277, 27273, 27230, 27234, 27278, 27274
37199, 27230, 27234, 27278, 27274, 10849, 10850, 10861, 10860
37200, 5259, 5260, 5271, 5270, 27231, 27235, 27279, 27275
37201, 27231, 27235, 27279, 27275, 27232, 27236, 27280, 27276
37202, 27232, 27236, 27280, 27276, 27233, 27237, 27281, 27277
37203, 27233, 27237, 27281, 27277, 27234, 27238, 27282, 27278
37204, 27234, 27238, 27282, 27278, 10850, 10851, 10862, 10861
37205, 5260, 5261, 5272, 5271, 27235, 27239, 27283, 27279
37206, 27235, 27239, 27283, 27279, 27236, 27240, 27284, 27280
37207, 27236, 27240, 27284, 27280, 27237, 27241, 27285, 27281
37208, 27237, 27241, 27285, 27281, 27238, 27242, 27286, 27282
37209, 27238, 27242, 27286, 27282, 10851, 10852, 10863, 10862
37210, 5261, 5262, 5273, 5272, 27239, 27243, 27287, 27283
37211, 27239, 27243, 27287, 27283, 27240, 27244, 27288, 27284
37212, 27240, 27244, 27288, 27284, 27241, 27245, 27289, 27285
37213, 27241, 27245, 27289, 27285, 27242, 27246, 27290, 27286
37214, 27242, 27246, 27290, 27286, 10852, 10853, 10864, 10863
37215, 5262, 5263, 5274, 5273, 27243, 27247, 27291, 27287
37216, 27243, 27247, 27291, 27287, 27244, 27248, 27292, 27288
37217, 27244, 27248, 27292, 27288, 27245, 27249, 27293, 27289
37218, 27245, 27249, 27293, 27289, 27246, 27250, 27294, 27290
37219, 27246, 27250, 27294, 27290, 10853, 10854, 10865, 10864
37220, 5263, 5264, 5275, 5274, 27247, 27251, 27295, 27291
37221, 27247, 27251, 27295, 27291, 27248, 27252, 27296, 27292
37222, 27248, 27252, 27296, 27292, 27249, 27253, 27297, 27293
37223, 27249, 27253, 27297, 27293, 27250, 27254, 27298, 27294
37224, 27250, 27254, 27298, 27294, 10854, 10855, 10866, 10865
37225, 5264, 5265, 5276, 5275, 27251, 27255, 27299, 27295
37226, 27251, 27255, 27299, 27295, 27252, 27256, 27300, 27296
37227, 27252, 27256, 27300, 27296, 27253, 27257, 27301, 27297
37228, 27253, 27257, 27301, 27297, 27254, 27258, 27302, 27298
37229, 27254, 27258, 27302, 27298, 10855, 10856, 10867, 10866
37230, 5265, 598, 599, 5276, 27255, 10577, 10581, 27299
37231, 27255, 10577, 10581, 27299, 27256, 10578, 10582, 27300
37232, 27256, 10578, 10582, 27300, 27257, 10579, 10583, 27301
37233, 27257, 10579, 10583, 27301, 27258, 10580, 10584, 27302
37234, 27258, 10580, 10584, 27302, 10856, 1632, 1633, 10867
37235, 561, 5266, 5277, 562, 10445, 27259, 27303, 10449
37236, 10445, 27259, 27303, 10449, 10446, 27260, 27304, 10450
37237, 10446, 27260, 27304, 10450, 10447, 27261, 27305, 10451
37238, 10447, 27261, 27305, 10451, 10448, 27262, 27306, 10452
37239, 10448, 27262, 27306, 10452, 1591, 10857, 10868, 1592
37240, 5266, 5267, 5278, 5277, 27259, 27263, 27307, 27303
37241, 27259, 27263, 27307, 27303, 27260, 27264, 27308, 27304
37242, 27260, 27264, 27308, 27304, 27261, 27265, 27309, 27305
37243, 27261, 27265, 27309, 27305, 27262, 27266, 27310, 27306
37244, 27262, 27266, 27310, 27306, 10857, 10858, 10869, 10868
37245, 5267, 5268, 5279, 5278, 27263, 27267, 27311, 27307
37246, 27263, 27267, 27311, 27307, 27264, 27268, 27312, 27308
37247, 27264, 27268, 27312, 27308, 27265, 27269, 27313, 27309
37248, 27265, 27269, 27313, 27309, 27266, 27270, 27314, 27310
37249, 27266, 27270, 27314, 27310, 10858, 10859, 10870, 10869
37250, 5268, 5269, 5280, 5279, 27267, 27271, 27315, 27311
37251, 27267, 27271, 27315, 27311, 27268, 27272, 27316, 27312
37252, 27268, 27272, 27316, 27312, 27269, 27273, 27317, 27313
37253, 27269, 27273, 27317, 27313, 27270, 27274, 27318, 27314
37254, 27270, 27274, 27318, 27314, 10859, 10860, 10871, 10870
37255, 5269, 5270, 5281, 5280, 27271, 27275, 27319, 27315
37256, 27271, 27275, 27319, 27315, 27272, 27276, 27320, 27316
37257, 27272, 27276, 27320, 27316, 27273, 27277, 27321, 27317
37258, 27273, 27277, 27321, 27317, 27274, 27278, 27322, 27318
37259, 27274, 27278, 27322, 27318, 10860, 10861, 10872, 10871
37260, 5270, 5271, 5282, 5281, 27275, 27279, 27323, 27319
37261, 27275, 27279, 27323, 27319, 27276, 27280, 27324, 27320
37262, 27276, 27280, 27324, 27320, 27277, 27281, 27325, 27321
37263, 27277, 27281, 27325, 27321, 27278, 27282, 27326, 27322
37264, 27278, 27282, 27326, 27322, 10861, 10862, 10873, 10872
37265, 5271, 5272, 5283, 5282, 27279, 27283, 27327, 27323
37266, 27279, 27283, 27327, 27323, 27280, 27284, 27328, 27324
37267, 27280, 27284, 27328, 27324, 27281, 27285, 27329, 27325
37268, 27281, 27285, 27329, 27325, 27282, 27286, 27330, 27326
37269, 27282, 27286, 27330, 27326, 10862, 10863, 10874, 10873
37270, 5272, 5273, 5284, 5283, 27283, 27287, 27331, 27327
37271, 27283, 27287, 27331, 27327, 27284, 27288, 27332, 27328
37272, 27284, 27288, 27332, 27328, 27285, 27289, 27333, 27329
37273, 27285, 27289, 27333, 27329, 27286, 27290, 27334, 27330
37274, 27286, 27290, 27334, 27330, 10863, 10864, 10875, 10874
37275, 5273, 5274, 5285, 5284, 27287, 27291, 27335, 27331
37276, 27287, 27291, 27335, 27331, 27288, 27292, 27336, 27332
37277, 27288, 27292, 27336, 27332, 27289, 27293, 27337, 27333
37278, 27289, 27293, 27337, 27333, 27290, 27294, 27338, 27334
37279, 27290, 27294, 27338, 27334, 10864, 10865, 10876, 10875
37280, 5274, 5275, 5286, 5285, 27291, 27295, 27339, 27335
37281, 27291, 27295, 27339, 27335, 27292, 27296, 27340, 27336
37282, 27292, 27296, 27340, 27336, 27293, 27297, 27341, 27337
37283, 27293, 27297, 27341, 27337, 27294, 27298, 27342, 27338
37284, 27294, 27298, 27342, 27338, 10865, 10866, 10877, 10876
37285, 5275, 5276, 5287, 5286, 27295, 27299, 27343, 27339
37286, 27295, 27299, 27343, 27339, 27296, 27300, 27344, 27340
37287, 27296, 27300, 27344, 27340, 27297, 27301, 27345, 27341
37288, 27297, 27301, 27345, 27341, 27298, 27302, 27346, 27342
37289, 27298, 27302, 27346, 27342, 10866, 10867, 10878, 10877
37290, 5276, 599, 600, 5287, 27299, 10581, 10585, 27343
37291, 27299, 10581, 10585, 27343, 27300, 10582, 10586, 27344
37292, 27300, 10582, 10586, 27344, 27301, 10583, 10587, 27345
37293, 27301, 10583, 10587, 27345, 27302, 10584, 10588, 27346
37294, 27302, 10584, 10588, 27346, 10867, 1633, 1634, 10878
37295, 562, 5277, 5288, 563, 10449, 27303, 27347, 10453
37296, 10449, 27303, 27347, 10453, 10450, 27304, 27348, 10454
37297, 10450, 27304, 27348, 10454, 10451, 27305, 27349, 10455
37298, 10451, 27305, 27349, 10455, 10452, 27306, 27350, 10456
37299, 10452, 27306, 27350, 10456, 1592, 10868, 10879, 1593
37300, 5277, 5278, 5289, 5288, 27303, 27307, 27351, 27347
37301, 27303, 27307, 27351, 27347, 27304, 27308, 27352, 27348
37302, 27304, 27308, 27352, 27348, 27305, 27309, 27353, 27349
37303, 27305, 27309, 27353, 27349, 27306, 27310, 27354, 27350
37304, 27306, 27310, 27354, 27350, 10868, 10869, 10880, 10879
37305, 5278, 5279, 5290, 5289, 27307, 27311, 27355, 27351
37306, 27307, 27311, 27355, 27351, 27308, 27312, 27356, 27352
37307, 27308, 27312, 27356, 27352, 27309, 27313, 27357, 27353
37308, 27309, 27313, 27357, 27353, 27310, 27314, 27358, 27354
37309, 27310, 27314, 27358, 27354, 10869, 10870, 10881, 10880
37310, 5279, 5280, 5291, 5290, 27311, 27315, 27359, 27355
37311, 27311, 27315, 27359, 27355, 27312, 27316, 27360, 27356
37312, 27312, 27316, 27360, 27356, 27313, 27317, 27361, 27357
37313, 27313, 27317, 27361, 27357, 27314, 27318, 27362, 27358
37314, 27314, 27318, 27362, 27358, 10870, 10871, 10882, 10881
37315, 5280, 5281, 5292, 5291, 27315, 27319, 27363, 27359
37316, 27315, 27319, 27363, 27359, 27316, 27320, 27364, 27360
37317, 27316, 27320, 27364, 27360, 27317, 27321, 27365, 27361
37318, 27317, 27321, 27365, 27361, 27318, 27322, 27366, 27362
37319, 27318, 27322, 27366, 27362, 10871, 10872, 10883, 10882
37320, 5281, 5282, 5293, 5292, 27319, 27323, 27367, 27363
37321, 27319, 27323, 27367, 27363, 27320, 27324, 27368, 27364
37322, 27320, 27324, 27368, 27364, 27321, 27325, 27369, 27365
37323, 27321, 27325, 27369, 27365, 27322, 27326, 27370, 27366
37324, 27322, 27326, 27370, 27366, 10872, 10873, 10884, 10883
37325, 5282, 5283, 5294, 5293, 27323, 27327, 27371, 27367
37326, 27323, 27327, 27371, 27367, 27324, 27328, 27372, 27368
37327, 27324, 27328, 27372, 27368, 27325, 27329, 27373, 27369
37328, 27325, 27329, 27373, 27369, 27326, 27330, 27374, 27370
37329, 27326, 27330, 27374, 27370, 10873, 10874, 10885, 10884
37330, 5283, 5284, 5295, 5294, 27327, 27331, 27375, 27371
37331, 27327, 27331, 27375, 27371, 27328, 27332, 27376, 27372
37332, 27328, 27332, 27376, 27372, 27329, 27333, 27377, 27373
37333, 27329, 27333, 27377, 27373, 27330, 27334, 27378, 27374
37334, 27330, 27334, 27378, 27374, 10874, 10875, 10886, 10885
37335, 5284, 5285, 5296, 5295, 27331, 27335, 27379, 27375
37336, 27331, 27335, 27379, 27375, 27332, 27336, 27380, 27376
37337, 27332, 27336, 27380, 27376, 27333, 27337, 27381, 27377
37338, 27333, 27337, 27381, 27377, 27334, 27338, 27382, 27378
37339, 27334, 27338, 27382, 27378, 10875, 10876, 10887, 10886
37340, 5285, 5286, 5297, 5296, 27335, 27339, 27383, 27379
37341, 27335, 27339, 27383, 27379, 27336, 27340, 27384, 27380
37342, 27336, 27340, 27384, 27380, 27337, 27341, 27385, 27381
37343, 27337, 27341, 27385, 27381, 27338, 27342, 27386, 27382
37344, 27338, 27342, 27386, 27382, 10876, 10877, 10888, 10887
37345, 5286, 5287, 5298, 5297, 27339, 27343, 27387, 27383
37346, 27339, 27343, 27387, 27383, 27340, 27344, 27388, 27384
37347, 27340, 27344, 27388, 27384, 27341, 27345, 27389, 27385
37348, 27341, 27345, 27389, 27385, 27342, 27346, 27390, 27386
37349, 27342, 27346, 27390, 27386, 10877, 10878, 10889, 10888
37350, 5287, 600, 601, 5298, 27343, 10585, 10589, 27387
37351, 27343, 10585, 10589, 27387, 27344, 10586, 10590, 27388
37352, 27344, 10586, 10590, 27388, 27345, 10587, 10591, 27389
37353, 27345, 10587, 10591, 27389, 27346, 10588, 10592, 27390
37354, 27346, 10588, 10592, 27390, 10878, 1634, 1635, 10889
37355, 563, 5288, 566, 21, 10453, 27347, 10457, 1563
37356, 10453, 27347, 10457, 1563, 10454, 27348, 10458, 1564
37357, 10454, 27348, 10458, 1564, 10455, 27349, 10459, 1565
37358, 10455, 27349, 10459, 1565, 10456, 27350, 10460, 1566
37359, 10456, 27350, 10460, 1566, 1593, 10879, 1598, 77
37360, 5288, 5289, 567, 566, 27347, 27351, 10461, 10457
37361, 27347, 27351, 10461, 10457, 27348, 27352, 10462, 10458
37362, 27348, 27352, 10462, 10458, 27349, 27353, 10463, 10459
37363, 27349, 27353, 10463, 10459, 27350, 27354, 10464, 10460
37364, 27350, 27354, 10464, 10460, 10879, 10880, 1599, 1598
37365, 5289, 5290, 568, 567, 27351, 27355, 10465, 10461
37366, 27351, 27355, 10465, 10461, 27352, 27356, 10466, 10462
37367, 27352, 27356, 10466, 10462, 27353, 27357, 10467, 10463
37368, 27353, 27357, 10467, 10463, 27354, 27358, 10468, 10464
37369, 27354, 27358, 10468, 10464, 10880, 10881, 1600, 1599
37370, 5290, 5291, 569, 568, 27355, 27359, 10469, 10465
37371, 27355, 27359, 10469, 10465, 27356, 27360, 10470, 10466
37372, 27356, 27360, 10470, 10466, 27357, 27361, 10471, 10467
37373, 27357, 27361, 10471, 10467, 27358, 27362, 10472, 10468
37374, 27358, 27362, 10472, 10468, 10881, 10882, 1601, 1600
37375, 5291, 5292, 570, 569, 27359, 27363, 10473, 10469
37376, 27359, 27363, 10473, 10469, 27360, 27364, 10474, 10470
37377, 27360, 27364, 10474, 10470, 27361, 27365, 10475, 10471
37378, 27361, 27365, 10475, 10471, 27362, 27366, 10476, 10472
37379, 27362, 27366, 10476, 10472, 10882, 10883, 1602, 1601
37380, 5292, 5293, 571, 570, 27363, 27367, 10477, 10473
37381, 27363, 27367, 10477, 10473, 27364, 27368, 10478, 10474
37382, 27364, 27368, 10478, 10474, 27365, 27369, 10479, 10475
37383, 27365, 27369, 10479, 10475, 27366, 27370, 10480, 10476
37384, 27366, 27370, 10480, 10476, 10883, 10884, 1603, 1602
37385, 5293, 5294, 572, 571, 27367, 27371, 10481, 10477
37386, 27367, 27371, 10481, 10477, 27368, 27372, 10482, 10478
37387, 27368, 27372, 10482, 10478, 27369, 27373, 10483, 10479
37388, 27369, 27373, 10483, 10479, 27370, 27374, 10484, 10480
37389, 27370, 27374, 10484, 10480, 10884, 10885, 1604, 1603
37390, 5294, 5295, 573, 572, 27371, 27375, 10485, 10481
37391, 27371, 27375, 10485, 10481, 27372, 27376, 10486, 10482
37392, 27372, 27376, 10486, 10482, 27373, 27377, 10487, 10483
37393, 27373, 27377, 10487, 10483, 27374, 27378, 10488, 10484
37394, 27374, 27378, 10488, 10484, 10885, 10886, 1605, 1604
37395, 5295, 5296, 574, 573, 27375, 27379, 10489, 10485
37396, 27375, 27379, 10489, 10485, 27376, 27380, 10490, 10486
37397, 27376, 27380, 10490, 10486, 27377, 27381, 10491, 10487
37398, 27377, 27381, 10491, 10487, 27378, 27382, 10492, 10488
37399, 27378, 27382, 10492, 10488, 10886, 10887, 1606, 1605
37400, 5296, 5297, 575, 574, 27379, 27383, 10493, 10489
37401, 27379, 27383, 10493, 10489, 27380, 27384, 10494, 10490
37402, 27380, 27384, 10494, 10490, 27381, 27385, 10495, 10491
37403, 27381, 27385, 10495, 10491, 27382, 27386, 10496, 10492
37404, 27382, 27386, 10496, 10492, 10887, 10888, 1607, 1606
37405, 5297, 5298, 576, 575, 27383, 27387, 10497, 10493
37406, 27383, 27387, 10497, 10493, 27384, 27388, 10498, 10494
37407, 27384, 27388, 10498, 10494, 27385, 27389, 10499, 10495
37408, 27385, 27389, 10499, 10495, 27386, 27390, 10500, 10496
37409, 27386, 27390, 10500, 10496, 10888, 10889, 1608, 1607
37410, 5298, 601, 23, 576, 27387, 10589, 1594, 10497
37411, 27387, 10589, 1594, 10497, 27388, 10590, 1595, 10498
37412, 27388, 10590, 1595, 10498, 27389, 10591, 1596, 10499
37413, 27389, 10591, 1596, 10499, 27390, 10592, 1597, 10500
37414, 27390, 10592, 1597, 10500, 10889, 1635, 79, 1608
*ELEMENT, type=C3D8, ELSET=Volume21
37415, 21, 566, 5359, 627, 1563, 10457, 27391, 10906
37416, 1563, 10457, 27391, 10906, 1564, 10458, 27392, 10907
37417, 1564, 10458, 27392, 10907, 1565, 10459, 27393, 10908
37418, 1565, 10459, 27393, 10908, 1566, 10460, 27394, 10909
37419, 1566, 10460, 27394, 10909, 77, 1598, 10966, 1659
37420, 627, 5359, 5360, 628, 10906, 27391, 27395, 10910
37421, 10906, 27391, 27395, 10910, 10907, 27392, 27396, 10911
37422, 10907, 27392, 27396, 10911, 10908, 27393, 27397, 10912
37423, 10908, 27393, 27397, 10912, 10909, 27394, 27398, 10913
37424, 10909, 27394, 27398, 10913, 1659, 10966, 10967, 1660
37425, 628, 5360, 5361, 629, 10910, 27395, 27399, 10914
37426, 10910, 27395, 27399, 10914, 10911, 27396, 27400, 10915
37427, 10911, 27396, 27400, 10915, 10912, 27397, 27401, 10916
37428, 10912, 27397, 27401, 10916, 10913, 27398, 27402, 10917
37429, 10913, 27398, 27402, 10917, 1660, 10967, 10968, 1661
37430, 629, 5361, 5362, 630, 10914, 27399, 27403, 10918
37431, 10914, 27399, 27403, 10918, 10915, 27400, 27404, 10919
37432, 10915, 27400, 27404, 10919, 10916, 27401, 27405, 10920
37433, 10916, 27401, 27405, 10920, 10917, 27402, 27406, 10921
37434, 10917, 27402, 27406, 10921, 1661, 10968, 10969, 1662
37435, 630, 5362, 644, 28, 10918, 27403, 10922, 1655
37436, 10918, 27403, 10922, 1655, 10919, 27404, 10923, 1656
37437, 10919, 27404, 10923, 1656, 10920, 27405, 10924, 1657
37438, 10920, 27405, 10924, 1657, 10921, 27406, 10925, 1658
37439, 10921, 27406, 10925, 1658, 1662, 10969, 1663, 82
37440, 566, 567, 5363, 5359, 10457, 10461, 27407, 27391
37441, 10457, 10461, 27407, 27391, 10458, 10462, 27408, 27392
37442, 10458, 10462, 27408, 27392, 10459, 10463, 27409, 27393
37443, 10459, 10463, 27409, 27393, 10460, 10464, 27410, 27394
37444, 10460, 10464, 27410, 27394, 1598, 1599, 10970, 10966
37445, 5359, 5363, 5364, 5360, 27391, 27407, 27411, 27395
37446, 27391, 27407, 27411, 27395, 27392, 27408, 27412, 27396
37447, 27392, 27408, 27412, 27396, 27393, 27409, 27413, 27397
37448, 27393, 27409, 27413, 27397, 27394, 27410, 27414, 27398
37449, 27394, 27410, 27414, 27398, 10966, 10970, 10971, 10967
37450, 5360, 5364, 5365, 5361, 27395, 27411, 27415, 27399
37451, 27395, 27411, 27415, 27399, 27396, 27412, 27416, 27400
37452, 27396, 27412, 27416, 27400, 27397, 27413, 27417, 27401
37453, 27397, 27413, 27417, 27401, 27398, 27414, 27418, 27402
37454, 27398, 27414, 27418, 27402, 10967, 10971, 10972, 10968
37455, 5361, 5365, 5366, 5362, 27399, 27415, 27419, 27403
37456, 27399, 27415, 27419, 27403, 27400, 27416, 27420, 27404
37457, 27400, 27416, 27420, 27404, 27401, 27417, 27421, 27405
37458, 27401, 27417, 27421, 27405, 27402, 27418, 27422, 27406
37459, 27402, 27418, 27422, 27406, 10968, 10972, 10973, 10969
37460, 5362, 5366, 645, 644, 27403, 27419, 10926, 10922
37461, 27403, 27419, 10926, 10922, 27404, 27420, 10927, 10923
37462, 27404, 27420, 10927, 10923, 27405, 27421, 10928, 10924
37463, 27405, 27421, 10928, 10924, 27406, 27422, 10929, 10925
37464, 27406, 27422, 10929, 10925, 10969, 10973, 1664, 1663
37465, 567, 568, 5367, 5363, 10461, 10465, 27423, 27407
37466, 10461, 10465, 27423, 27407, 10462, 10466, 27424, 27408
37467, 10462, 10466, 27424, 27408, 10463, 10467, 27425, 27409
37468, 10463, 10467, 27425, 27409, 10464, 10468, 27426, 27410
37469, 10464, 10468, 27426, 27410, 1599, 1600, 10974, 10970
37470, 5363, 5367, 5368, 5364, 27407, 27423, 27427, 27411
37471, 27407, 27423, 27427, 27411, 27408, 27424, 27428, 27412
37472, 27408, 27424, 27428, 27412, 27409, 27425, 27429, 27413
37473, 27409, 27425, 27429, 27413, 27410, 27426, 27430, 27414
37474, 27410, 27426, 27430, 27414, 10970, 10974, 10975, 10971
37475, 5364, 5368, 5369, 5365, 27411, 27427, 27431, 27415
37476, 27411, 27427, 27431, 27415, 27412, 27428, 27432, 27416
37477, 27412, 27428, 27432, 27416, 27413, 27429, 27433, 27417
37478, 27413, 27429, 27433, 27417, 27414, 27430, 27434, 27418
37479, 27414, 27430, 27434, 27418, 10971, 10975, 10976, 10972
37480, 5365, 5369, 5370, 5366, 27415, 27431, 27435, 27419
37481, 27415, 27431, 27435, 27419, 27416, 27432, 27436, 27420
37482, 27416, 27432, 27436, 27420, 27417, 27433, 27437, 27421
37483, 27417, 27433, 27437, 27421, 27418, 27434, 27438, 27422
37484, 27418, 27434, 27438, 27422, 10972, 10976, 10977, 10973
37485, 5366, 5370, 646, 645, 27419, 27435, 10930, 10926
37486, 27419, 27435, 10930, 10926, 27420, 27436, 10931, 10927
37487, 27420, 27436, 10931, 10927, 27421, 27437, 10932, 10928
37488, 27421, 27437, 10932, 10928, 27422, 27438, 10933, 10929
37489, 27422, 27438, 10933, 10929, 10973, 10977, 1665, 1664
37490, 568, 569, 5371, 5367, 10465, 10469, 27439, 27423
37491, 10465, 10469, 27439, 27423, 10466, 10470, 27440, 27424
37492, 10466, 10470, 27440, 27424, 10467, 10471, 27441, 27425
37493, 10467, 10471, 27441, 27425, 10468, 10472, 27442, 27426
37494, 10468, 10472, 27442, 27426, 1600, 1601, 10978, 10974
37495, 5367, 5371, 5372, 5368, 27423, 27439, 27443, 27427
37496, 27423, 27439, 27443, 27427, 27424, 27440, 27444, 27428
37497, 27424, 27440, 27444, 27428, 27425, 27441, 27445, 27429
37498, 27425, 27441, 27445, 27429, 27426, 27442, 27446, 27430
37499, 27426, 27442, 27446, 27430, 10974, 10978, 10979, 10975
37500, 5368, 5372, 5373, 5369, 27427, 27443, 27447, 27431
37501, 27427, 27443, 27447, 27431, 27428, 27444, 27448, 27432
37502, 27428, 27444, 27448, 27432, 27429, 27445, 27449, 27433
37503, 27429, 27445, 27449, 27433, 27430, 27446, 27450, 27434
37504, 27430, 27446, 27450, 27434, 10975, 10979, 10980, 10976
37505, 5369, 5373, 5374, 5370, 27431, 27447, 27451, 27435
37506, 27431, 27447, 27451, 27435, 27432, 27448, 27452, 27436
37507, 27432, 27448, 27452, 27436, 27433, 27449, 27453, 27437
37508, 27433, 27449, 27453, 27437, 27434, 27450, 27454, 27438
37509, 27434, 27450, 27454, 27438, 10976, 10980, 10981, 10977
37510, 5370, 5374, 647, 646, 27435, 27451, 10934, 10930
37511, 27435, 27451, 10934, 10930, 27436, 27452, 10935, 10931
37512, 27436, 27452, 10935, 10931, 27437, 27453, 10936, 10932
37513, 27437, 27453, 10936, 10932, 27438, 27454, 10937, 10933
37514, 27438, 27454, 10937, 10933, 10977, 10981, 1666, 1665
37515, 569, 570, 5375, 5371, 10469, 10473, 27455, 27439
37516, 10469, 10473, 27455, 27439, 10470, 10474, 27456, 27440
37517, 10470, 10474, 27456, 27440, 10471, 10475, 27457, 27441
37518, 10471, 10475, 27457, 27441, 10472, 10476, 27458, 27442
37519, 10472, 10476, 27458, 27442, 1601, 1602, 10982, 10978
37520, 5371, 5375, 5376, 5372, 27439, 27455, 27459, 27443
37521, 27439, 27455, 27459, 27443, 27440, 27456, 27460, 27444
37522, 27440, 27456, 27460, 27444, 27441, 27457, 27461, 27445
37523, 27441, 27457, 27461, 27445, 27442, 27458, 27462, 27446
37524, 27442, 27458, 27462, 27446, 10978, 10982, 10983, 10979
37525, 5372, 5376, 5377, 5373, 27443, 27459, 27463, 27447
37526, 27443, 27459, 27463, 27447, 27444, 27460, 27464, 27448
37527, 27444, 27460, 27464, 27448, 27445, 27461, 27465, 27449
37528, 27445, 27461, 27465, 27449, 27446, 27462, 27466, 27450
37529, 27446, 27462, 27466, 27450, 10979, 10983, 10984, 10980
37530, 5373, 5377, 5378, 5374, 27447, 27463, 27467, 27451
37531, 27447, 27463, 27467, 27451, 27448, 27464, 27468, 27452
37532, 27448, 27464, 27468, 27452, 27449, 27465, 27469, 27453
37533, 27449, 27465, 27469, 27453, 27450, 27466, 27470, 27454
37534, 27450, 27466, 27470, 27454, 10980, 10984, 10985, 10981
37535, 5374, 5378, 648, 647, 27451, 27467, 10938, 10934
37536, 27451, 27467, 10938, 10934, 27452, 27468, 10939, 10935
37537, 27452, 27468, 10939, 10935, 27453, 27469, 10940, 10936
37538, 27453, 27469, 10940, 10936, 27454, 27470, 10941, 10937
37539, 27454, 27470, 10941, 10937, 10981, 10985, 1667, 1666
37540, 570, 571, 5379, 5375, 10473, 10477, 27471, 27455
37541, 10473, 10477, 27471, 27455, 10474, 10478, 27472, 27456
37542, 10474, 10478, 27472, 27456, 10475, 10479, 27473, 27457
37543, 10475, 10479, 27473, 27457, 10476, 10480, 27474, 27458
37544, 10476, 10480, 27474, 27458, 1602, 1603, 10986, 10982
37545, 5375, 5379, 5380, 5376, 27455, 27471, 27475, 27459
37546, 27455, 27471, 27475, 27459, 27456, 27472, 27476, 27460
37547, 27456, 27472, 27476, 27460, 27457, 27473, 27477, 27461
37548, 27457, 27473, 27477, 27461, 27458, 27474, 27478, 27462
37549, 27458, 27474, 27478, 27462, 10982, 10986, 10987, 10983
37550, 5376, 5380, 5381, 5377, 27459, 27475, 27479, 27463
37551, 27459, 27475, 27479, 27463, 27460, 27476, 27480, 27464
37552, 27460, 27476, 27480, 27464, 27461, 27477, 27481, 27465
37553, 27461, 27477, 27481, 27465, 27462, 27478, 27482, 27466
37554, 27462, 27478, 27482, 27466, 10983, 10987, 10988, 10984
37555, 5377, 5381, 5382, 5378, 27463, 27479, 27483, 27467
37556, 27463, 27479, 27483, 27467, 27464, 27480, 27484, 27468
37557, 27464, 27480, 27484, 27468, 27465, 27481, 27485, 27469
37558, 27465, 27481, 27485, 27469, 27466, 27482, 27486, 27470
37559, 27466, 27482, 27486, 27470, 10984, 10988, 10989, 10985
37560, 5378, 5382, 649, 648, 27467, 27483, 10942, 10938
37561, 27467, 27483, 10942, 10938, 27468, 27484, 10943, 10939
37562, 27468, 27484, 10943, 10939, 27469, 27485, 10944, 10940
37563, 27469, 27485, 10944, 10940, 27470, 27486, 10945, 10941
37564, 27470, 27486, 10945, 10941, 10985, 10989, 1668, 1667
37565, 571, 572, 5383, 5379, 10477, 10481, 27487, 27471
37566, 10477, 10481, 27487, 27471, 10478, 10482, 27488, 27472
37567, 10478, 10482, 27488, 27472, 10479, 10483, 27489, 27473
37568, 10479, 10483, 27489, 27473, 10480, 10484, 27490, 27474
37569, 10480, 10484, 27490, 27474, 1603, 1604, 10990, 10986
37570, 5379, 5383, 5384, 5380, 27471, 27487, 27491, 27475
37571, 27471, 27487, 27491, 27475, 27472, 27488, 27492, 27476
37572, 27472, 27488, 27492, 27476, 27473, 27489, 27493, 27477
37573, 27473, 27489, 27493, 27477, 27474, 27490, 27494, 27478
37574, 27474, 27490, 27494, 27478, 10986, 10990, 10991, 10987
37575, 5380, 5384, 5385, 5381, 27475, 27491, 27495, 27479
37576, 27475, 27491, 27495, 27479, 27476, 27492, 27496, 27480
37577, 27476, 27492, 27496, 27480, 27477, 27493, 27497, 27481
37578, 27477, 27493, 27497, 27481, 27478, 27494, 27498, 27482
37579, 27478, 27494, 27498, 27482, 10987, 10991, 10992, 10988
37580, 5381, 5385, 5386, 5382, 27479, 27495, 27499, 27483
37581, 27479, 27495, 27499, 27483, 27480, 27496, 27500, 27484
37582, 27480, 27496, 27500, 27484, 27481, 27497, 27501, 27485
37583, 27481, 27497, 27501, 27485, 27482, 27498, 27502, 27486
37584, 27482, 27498, 27502, 27486, 10988, 10992, 10993, 10989
37585, 5382, 5386, 650, 649, 27483, 27499, 10946, 10942
37586, 27483, 27499, 10946, 10942, 27484, 27500, 10947, 10943
37587, 27484, 27500, 10947, 10943, 27485, 27501, 10948, 10944
37588, 27485, 27501, 10948, 10944, 27486, 27502, 10949, 10945
37589, 27486, 27502, 10949, 10945, 10989, 10993, 1669, 1668
37590, 572, 573, 5387, 5383, 10481, 10485, 27503, 27487
37591, 10481, 10485, 27503, 27487, 10482, 10486, 27504, 27488
37592, 10482, 10486, 27504, 27488, 10483, 10487, 27505, 27489
37593, 10483, 10487, 27505, 27489, 10484, 10488, 27506, 27490
37594, 10484, 10488, 27506, 27490, 1604, 1605, 10994, 10990
37595, 5383, 5387, 5388, 5384, 27487, 27503, 27507, 27491
37596, 27487, 27503, 27507, 27491, 27488, 27504, 27508, 27492
37597, 27488, 27504, 27508, 27492, 27489, 27505, 27509, 27493
37598, 27489, 27505, 27509, 27493, 27490, 27506, 27510, 27494
37599, 27490, 27506, 27510, 27494, 10990, 10994, 10995, 10991
37600, 5384, 5388, 5389, 5385, 27491, 27507, 27511, 27495
37601, 27491, 27507, 27511, 27495, 27492, 27508, 27512, 27496
37602, 27492, 27508, 27512, 27496, 27493, 27509, 27513, 27497
37603, 27493, 27509, 27513, 27497, 27494, 27510, 27514, 27498
37604, 27494, 27510, 27514, 27498, 10991, 10995, 10996, 10992
37605, 5385, 5389, 5390, 5386, 27495, 27511, 27515, 27499
37606, 27495, 27511, 27515, 27499, 27496, 27512, 27516, 27500
37607, 27496, 27512, 27516, 27500, 27497, 27513, 27517, 27501
37608, 27497, 27513, 27517, 27501, 27498, 27514, 27518, 27502
37609, 27498, 27514, 27518, 27502, 10992, 10996, 10997, 10993
37610, 5386, 5390, 651, 650, 27499, 27515, 10950, 10946
37611, 27499, 27515, 10950, 10946, 27500, 27516, 10951, 10947
37612, 27500, 27516, 10951, 10947, 27501, 27517, 10952, 10948
37613, 27501, 27517, 10952, 10948, 27502, 27518, 10953, 10949
37614, 27502, 27518, 10953, 10949, 10993, 10997, 1670, 1669
37615, 573, 574, 5391, 5387, 10485, 10489, 27519, 27503
37616, 10485, 10489, 27519, 27503, 10486, 10490, 27520, 27504
37617, 10486, 10490, 27520, 27504, 10487, 10491, 27521, 27505
37618, 10487, 10491, 27521, 27505, 10488, 10492, 27522, 27506
37619, 10488, 10492, 27522, 27506, 1605, 1606, 10998, 10994
37620, 5387, 5391, 5392, 5388, 27503, 27519, 27523, 27507
37621, 27503, 27519, 27523, 27507, 27504, 27520, 27524, 27508
37622, 27504, 27520, 27524, 27508, 27505, 27521, 27525, 27509
37623, 27505, 27521, 27525, 27509, 27506, 27522, 27526, 27510
37624, 27506, 27522, 27526, 27510, 10994, 10998, 10999, 10995
37625, 5388, 5392, 5393, 5389, 27507, 27523, 27527, 27511
37626, 27507, 27523, 27527, 27511, 27508, 27524, 27528, 27512
37627, 27508, 27524, 27528, 27512, 27509, 27525, 27529, 27513
37628, 27509, 27525, 27529, 27513, 27510, 27526, 27530, 27514
37629, 27510, 27526, 27530, 27514, 10995, 10999, 11000, 10996
37630, 5389, 5393, 5394, 5390, 27511, 27527, 27531, 27515
37631, 27511, 27527, 27531, 27515, 27512, 27528, 27532, 27516
37632, 27512, 27528, 27532, 27516, 27513, 27529, 27533, 27517
37633, 27513, 27529, 27533, 27517, 27514, 27530, 27534, 27518
37634, 27514, 27530, 27534, 27518, 10996, 11000, 11001, 10997
37635, 5390, 5394, 652, 651, 27515, 27531, 10954, 10950
37636, 27515, 27531, 10954, 10950, 27516, 27532, 10955, 10951
37637, 27516, 27532, 10955, 10951, 27517, 27533, 10956, 10952
37638, 27517, 27533, 10956, 10952, 27518, 27534, 10957, 10953
37639, 27518, 27534, 10957, 10953, 10997, 11001, 1671, 1670
37640, 574, 575, 5395, 5391, 10489, 10493, 27535, 27519
37641, 10489, 10493, 27535, 27519, 10490, 10494, 27536, 27520
37642, 10490, 10494, 27536, 27520, 10491, 10495, 27537, 27521
37643, 10491, 10495, 27537, 27521, 10492, 10496, 27538, 27522
37644, 10492, 10496, 27538, 27522, 1606, 1607, 11002, 10998
37645, 5391, 5395, 5396, 5392, 27519, 27535, 27539, 27523
37646, 27519, 27535, 27539, 27523, 27520, 27536, 27540, 27524
37647, 27520, 27536, 27540, 27524, 27521, 27537, 27541, 27525
37648, 27521, 27537, 27541, 27525, 27522, 27538, 27542, 27526
37649, 27522, 27538, 27542, 27526, 10998, 11002, 11003, 10999
37650, 5392, 5396, 5397, 5393, 27523, 27539, 27543, 27527
37651, 27523, 27539, 27543, 27527, 27524, 27540, 27544, 27528
37652, 27524, 27540, 27544, 27528, 27525, 27541, 27545, 27529
37653, 27525, 27541, 27545, 27529, 27526, 27542, 27546, 27530
37654, 27526, 27542, 27546, 27530, 10999, 11003, 11004, 11000
37655, 5393, 5397, 5398, 5394, 27527, 27543, 27547, 27531
37656, 27527, 27543, 27547, 27531, 27528, 27544, 27548, 27532
37657, 27528, 27544, 27548, 27532, 27529, 27545, 27549, 27533
37658, 27529, 27545, 27549, 27533, 27530, 27546, 27550, 27534
37659, 27530, 27546, 27550, 27534, 11000, 11004, 11005, 11001
37660, 5394, 5398, 653, 652, 27531, 27547, 10958, 10954
37661, 27531, 27547, 10958, 10954, 27532, 27548, 10959, 10955
37662, 27532, 27548, 10959, 10955, 27533, 27549, 10960, 10956
37663, 27533, 27549, 10960, 10956, 27534, 27550, 10961, 10957
37664, 27534, 27550, 10961, 10957, 11001, 11005, 1672, 1671
37665, 575, 576, 5399, 5395, 10493, 10497, 27551, 27535
37666, 10493, 10497, 27551, 27535, 10494, 10498, 27552, 27536
37667, 10494, 10498, 27552, 27536, 10495, 10499, 27553, 27537
37668, 10495, 10499, 27553, 27537, 10496, 10500, 27554, 27538
37669, 10496, 10500, 27554, 27538, 1607, 1608, 11006, 11002
37670, 5395, 5399, 5400, 5396, 27535, 27551, 27555, 27539
37671, 27535, 27551, 27555, 27539, 27536, 27552, 27556, 27540
37672, 27536, 27552, 27556, 27540, 27537, 27553, 27557, 27541
37673, 27537, 27553, 27557, 27541, 27538, 27554, 27558, 27542
37674, 27538, 27554, 27558, 27542, 11002, 11006, 11007, 11003
37675, 5396, 5400, 5401, 5397, 27539, 27555, 27559, 27543
37676, 27539, 27555, 27559, 27543, 27540, 27556, 27560, 27544
37677, 27540, 27556, 27560, 27544, 27541, 27557, 27561, 27545
37678, 27541, 27557, 27561, 27545, 27542, 27558, 27562, 27546
37679, 27542, 27558, 27562, 27546, 11003, 11007, 11008, 11004
37680, 5397, 5401, 5402, 5398, 27543, 27559, 27563, 27547
37681, 27543, 27559, 27563, 27547, 27544, 27560, 27564, 27548
37682, 27544, 27560, 27564, 27548, 27545, 27561, 27565, 27549
37683, 27545, 27561, 27565, 27549, 27546, 27562, 27566, 27550
37684, 27546, 27562, 27566, 27550, 11004, 11008, 11009, 11005
37685, 5398, 5402, 654, 653, 27547, 27563, 10962, 10958
37686, 27547, 27563, 10962, 10958, 27548, 27564, 10963, 10959
37687, 27548, 27564, 10963, 10959, 27549, 27565, 10964, 10960
37688, 27549, 27565, 10964, 10960, 27550, 27566, 10965, 10961
37689, 27550, 27566, 10965, 10961, 11005, 11009, 1673, 1672
37690, 576, 23, 617, 5399, 10497, 1594, 10890, 27551
37691, 10497, 1594, 10890, 27551, 10498, 1595, 10891, 27552
37692, 10498, 1595, 10891, 27552, 10499, 1596, 10892, 27553
37693, 10499, 1596, 10892, 27553, 10500, 1597, 10893, 27554
37694, 10500, 1597, 10893, 27554, 1608, 79, 1651, 11006
37695, 5399, 617, 618, 5400, 27551, 10890, 10894, 27555
37696, 27551, 10890, 10894, 27555, 27552, 10891, 10895, 27556
37697, 27552, 10891, 10895, 27556, 27553, 10892, 10896, 27557
37698, 27553, 10892, 10896, 27557, 27554, 10893, 10897, 27558
37699, 27554, 10893, 10897, 27558, 11006, 1651, 1652, 11007
37700, 5400, 618, 619, 5401, 27555, 10894, 10898, 27559
37701, 27555, 10894, 10898, 27559, 27556, 10895, 10899, 27560
37702, 27556, 10895, 10899, 27560, 27557, 10896, 10900, 27561
37703, 27557, 10896, 10900, 27561, 27558, 10897, 10901, 27562
37704, 27558, 10897, 10901, 27562, 11007, 1652, 1653, 11008
37705, 5401, 619, 620, 5402, 27559, 10898, 10902, 27563
37706, 27559, 10898, 10902, 27563, 27560, 10899, 10903, 27564
37707, 27560, 10899, 10903, 27564, 27561, 10900, 10904, 27565
37708, 27561, 10900, 10904, 27565, 27562, 10901, 10905, 27566
37709, 27562, 10901, 10905, 27566, 11008, 1653, 1654, 11009
37710, 5402, 620, 26, 654, 27563, 10902, 1647, 10962
37711, 27563, 10902, 1647, 10962, 27564, 10903, 1648, 10963
37712, 27564, 10903, 1648, 10963, 27565, 10904, 1649, 10964
37713, 27565, 10904, 1649, 10964, 27566, 10905, 1650, 10965
37714, 27566, 10905, 1650, 10965, 11009, 1654, 81, 1673
*ELEMENT, type=C3D8, ELSET=Volume22
37715, 28, 644, 5770, 726, 1655, 10922, 27567, 11102
37716, 1655, 10922, 27567, 11102, 1656, 10923, 27568, 11103
37717, 1656, 10923, 27568, 11103, 1657, 10924, 27569, 11104
37718, 1657, 10924, 27569, 11104, 1658, 10925, 27570, 11105
37719, 1658, 10925, 27570, 11105, 82, 1663, 11238, 1705
37720, 726, 5770, 5771, 727, 11102, 27567, 27571, 11106
37721, 11102, 27567, 27571, 11106, 11103, 27568, 27572, 11107
37722, 11103, 27568, 27572, 11107, 11104, 27569, 27573, 11108
37723, 11104, 27569, 27573, 11108, 11105, 27570, 27574, 11109
37724, 11105, 27570, 27574, 11109, 1705, 11238, 11239, 1706
37725, 727, 5771, 5772, 728, 11106, 27571, 27575, 11110
37726, 11106, 27571, 27575, 11110, 11107, 27572, 27576, 11111
37727, 11107, 27572, 27576, 11111, 11108, 27573, 27577, 11112
37728, 11108, 27573, 27577, 11112, 11109, 27574, 27578, 11113
37729, 11109, 27574, 27578, 11113, 1706, 11239, 11240, 1707
37730, 728, 5772, 5773, 729, 11110, 27575, 27579, 11114
37731, 11110, 27575, 27579, 11114, 11111, 27576, 27580, 11115
37732, 11111, 27576, 27580, 11115, 11112, 27577, 27581, 11116
37733, 11112, 27577, 27581, 11116, 11113, 27578, 27582, 11117
37734, 11113, 27578, 27582, 11117, 1707, 11240, 11241, 1708
37735, 729, 5773, 5774, 730, 11114, 27579, 27583, 11118
37736, 11114, 27579, 27583, 11118, 11115, 27580, 27584, 11119
37737, 11115, 27580, 27584, 11119, 11116, 27581, 27585, 11120
37738, 11116, 27581, 27585, 11120, 11117, 27582, 27586, 11121
37739, 11117, 27582, 27586, 11121, 1708, 11241, 11242, 1709
37740, 730, 5774, 5775, 731, 11118, 27583, 27587, 11122
37741, 11118, 27583, 27587, 11122, 11119, 27584, 27588, 11123
37742, 11119, 27584, 27588, 11123, 11120, 27585, 27589, 11124
37743, 11120, 27585, 27589, 11124, 11121, 27586, 27590, 11125
37744, 11121, 27586, 27590, 11125, 1709, 11242, 11243, 1710
37745, 731, 5775, 5776, 732, 11122, 27587, 27591, 11126
37746, 11122, 27587, 27591, 11126, 11123, 27588, 27592, 11127
37747, 11123, 27588, 27592, 11127, 11124, 27589, 27593, 11128
37748, 11124, 27589, 27593, 11128, 11125, 27590, 27594, 11129
37749, 11125, 27590, 27594, 11129, 1710, 11243, 11244, 1711
37750, 732, 5776, 5777, 733, 11126, 27591, 27595, 11130
37751, 11126, 27591, 27595, 11130, 11127, 27592, 27596, 11131
37752, 11127, 27592, 27596, 11131, 11128, 27593, 27597, 11132
37753, 11128, 27593, 27597, 11132, 11129, 27594, 27598, 11133
37754, 11129, 27594, 27598, 11133, 1711, 11244, 11245, 1712
37755, 733, 5777, 5778, 734, 11130, 27595, 27599, 11134
37756, 11130, 27595, 27599, 11134, 11131, 27596, 27600, 11135
37757, 11131, 27596, 27600, 11135, 11132, 27597, 27601, 11136
37758, 11132, 27597, 27601, 11136, 11133, 27598, 27602, 11137
37759, 11133, 27598, 27602, 11137, 1712, 11245, 11246, 1713
37760, 734, 5778, 5779, 735, 11134, 27599, 27603, 11138
37761, 11134, 27599, 27603, 11138, 11135, 27600, 27604, 11139
37762, 11135, 27600, 27604, 11139, 11136, 27601, 27605, 11140
37763, 11136, 27601, 27605, 11140, 11137, 27602, 27606, 11141
37764, 11137, 27602, 27606, 11141, 1713, 11246, 11247, 1714
37765, 735, 5779, 5780, 736, 11138, 27603, 27607, 11142
37766, 11138, 27603, 27607, 11142, 11139, 27604, 27608, 11143
37767, 11139, 27604, 27608, 11143, 11140, 27605, 27609, 11144
37768, 11140, 27605, 27609, 11144, 11141, 27606, 27610, 11145
37769, 11141, 27606, 27610, 11145, 1714, 11247, 11248, 1715
37770, 736, 5780, 5781, 737, 11142, 27607, 27611, 11146
37771, 11142, 27607, 27611, 11146, 11143, 27608, 27612, 11147
37772, 11143, 27608, 27612, 11147, 11144, 27609, 27613, 11148
37773, 11144, 27609, 27613, 11148, 11145, 27610, 27614, 11149
37774, 11145, 27610, 27614, 11149, 1715, 11248, 11249, 1716
37775, 737, 5781, 5782, 738, 11146, 27611, 27615, 11150
37776, 11146, 27611, 27615, 11150, 11147, 27612, 27616, 11151
37777, 11147, 27612, 27616, 11151, 11148, 27613, 27617, 11152
37778, 11148, 27613, 27617, 11152, 11149, 27614, 27618, 11153
37779, 11149, 27614, 27618, 11153, 1716, 11249, 11250, 1717
37780, 738, 5782, 5783, 739, 11150, 27615, 27619, 11154
37781, 11150, 27615, 27619, 11154, 11151, 27616, 27620, 11155
37782, 11151, 27616, 27620, 11155, 11152, 27617, 27621, 11156
37783, 11152, 27617, 27621, 11156, 11153, 27618, 27622, 11157
37784, 11153, 27618, 27622, 11157, 1717, 11250, 11251, 1718
37785, 739, 5783, 5784, 740, 11154, 27619, 27623, 11158
37786, 11154, 27619, 27623, 11158, 11155, 27620, 27624, 11159
37787, 11155, 27620, 27624, 11159, 11156, 27621, 27625, 11160
37788, 11156, 27621, 27625, 11160, 11157, 27622, 27626, 11161
37789, 11157, 27622, 27626, 11161, 1718, 11251, 11252, 1719
37790, 740, 5784, 5785, 741, 11158, 27623, 27627, 11162
37791, 11158, 27623, 27627, 11162, 11159, 27624, 27628, 11163
37792, 11159, 27624, 27628, 11163, 11160, 27625, 27629, 11164
37793, 11160, 27625, 27629, 11164, 11161, 27626, 27630, 11165
37794, 11161, 27626, 27630, 11165, 1719, 11252, 11253, 1720
37795, 741, 5785, 5786, 742, 11162, 27627, 27631, 11166
37796, 11162, 27627, 27631, 11166, 11163, 27628, 27632, 11167
37797, 11163, 27628, 27632, 11167, 11164, 27629, 27633, 11168
37798, 11164, 27629, 27633, 11168, 11165, 27630, 27634, 11169
37799, 11165, 27630, 27634, 11169, 1720, 11253, 11254, 1721
37800, 742, 5786, 5787, 743, 11166, 27631, 27635, 11170
37801, 11166, 27631, 27635, 11170, 11167, 27632, 27636, 11171
37802, 11167, 27632, 27636, 11171, 11168, 27633, 27637, 11172
37803, 11168, 27633, 27637, 11172, 11169, 27634, 27638, 11173
37804, 11169, 27634, 27638, 11173, 1721, 11254, 11255, 1722
37805, 743, 5787, 5788, 744, 11170, 27635, 27639, 11174
37806, 11170, 27635, 27639, 11174, 11171, 27636, 27640, 11175
37807, 11171, 27636, 27640, 11175, 11172, 27637, 27641, 11176
37808, 11172, 27637, 27641, 11176, 11173, 27638, 27642, 11177
37809, 11173, 27638, 27642, 11177, 1722, 11255, 11256, 1723
37810, 744, 5788, 5789, 745, 11174, 27639, 27643, 11178
37811, 11174, 27639, 27643, 11178, 11175, 27640, 27644, 11179
37812, 11175, 27640, 27644, 11179, 11176, 27641, 27645, 11180
37813, 11176, 27641, 27645, 11180, 11177, 27642, 27646, 11181
37814, 11177, 27642, 27646, 11181, 1723, 11256, 11257, 1724
37815, 745, 5789, 5790, 746, 11178, 27643, 27647, 11182
37816, 11178, 27643, 27647, 11182, 11179, 27644, 27648, 11183
37817, 11179, 27644, 27648, 11183, 11180, 27645, 27649, 11184
37818, 11180, 27645, 27649, 11184, 11181, 27646, 27650, 11185
37819, 11181, 27646, 27650, 11185, 1724, 11257, 11258, 1725
37820, 746, 5790, 5791, 747, 11182, 27647, 27651, 11186
37821, 11182, 27647, 27651, 11186, 11183, 27648, 27652, 11187
37822, 11183, 27648, 27652, 11187, 11184, 27649, 27653, 11188
37823, 11184, 27649, 27653, 11188, 11185, 27650, 27654, 11189
37824, 11185, 27650, 27654, 11189, 1725, 11258, 11259, 1726
37825, 747, 5791, 5792, 748, 11186, 27651, 27655, 11190
37826, 11186, 27651, 27655, 11190, 11187, 27652, 27656, 11191
37827, 11187, 27652, 27656, 11191, 11188, 27653, 27657, 11192
37828, 11188, 27653, 27657, 11192, 11189, 27654, 27658, 11193
37829, 11189, 27654, 27658, 11193, 1726, 11259, 11260, 1727
37830, 748, 5792, 762, 32, 11190, 27655, 11194, 1701
37831, 11190, 27655, 11194, 1701, 11191, 27656, 11195, 1702
37832, 11191, 27656, 11195, 1702, 11192, 27657, 11196, 1703
37833, 11192, 27657, 11196, 1703, 11193, 27658, 11197, 1704
37834, 11193, 27658, 11197, 1704, 1727, 11260, 1728, 84
37835, 644, 645, 5793, 5770, 10922, 10926, 27659, 27567
37836, 10922, 10926, 27659, 27567, 10923, 10927, 27660, 27568
37837, 10923, 10927, 27660, 27568, 10924, 10928, 27661, 27569
37838, 10924, 10928, 27661, 27569, 10925, 10929, 27662, 27570
37839, 10925, 10929, 27662, 27570, 1663, 1664, 11261, 11238
37840, 5770, 5793, 5794, 5771, 27567, 27659, 27663, 27571
37841, 27567, 27659, 27663, 27571, 27568, 27660, 27664, 27572
37842, 27568, 27660, 27664, 27572, 27569, 27661, 27665, 27573
37843, 27569, 27661, 27665, 27573, 27570, 27662, 27666, 27574
37844, 27570, 27662, 27666, 27574, 11238, 11261, 11262, 11239
37845, 5771, 5794, 5795, 5772, 27571, 27663, 27667, 27575
37846, 27571, 27663, 27667, 27575, 27572, 27664, 27668, 27576
37847, 27572, 27664, 27668, 27576, 27573, 27665, 27669, 27577
37848, 27573, 27665, 27669, 27577, 27574, 27666, 27670, 27578
37849, 27574, 27666, 27670, 27578, 11239, 11262, 11263, 11240
37850, 5772, 5795, 5796, 5773, 27575, 27667, 27671, 27579
37851, 27575, 27667, 27671, 27579, 27576, 27668, 27672, 27580
37852, 27576, 27668, 27672, 27580, 27577, 27669, 27673, 27581
37853, 27577, 27669, 27673, 27581, 27578, 27670, 27674, 27582
37854, 27578, 27670, 27674, 27582, 11240, 11263, 11264, 11241
37855, 5773, 5796, 5797, 5774, 27579, 27671, 27675, 27583
37856, 27579, 27671, 27675, 27583, 27580, 27672, 27676, 27584
37857, 27580, 27672, 27676, 27584, 27581, 27673, 27677, 27585
37858, 27581, 27673, 27677, 27585, 27582, 27674, 27678, 27586
37859, 27582, 27674, 27678, 27586, 11241, 11264, 11265, 11242
37860, 5774, 5797, 5798, 5775, 27583, 27675, 27679, 27587
37861, 27583, 27675, 27679, 27587, 27584, 27676, 27680, 27588
37862, 27584, 27676, 27680, 27588, 27585, 27677, 27681, 27589
37863, 27585, 27677, 27681, 27589, 27586, 27678, 27682, 27590
37864, 27586, 27678, 27682, 27590, 11242, 11265, 11266, 11243
37865, 5775, 5798, 5799, 5776, 27587, 27679, 27683, 27591
37866, 27587, 27679, 27683, 27591, 27588, 27680, 27684, 27592
37867, 27588, 27680, 27684, 27592, 27589, 27681, 27685, 27593
37868, 27589, 27681, 27685, 27593, 27590, 27682, 27686, 27594
37869, 27590, 27682, 27686, 27594, 11243, 11266, 11267, 11244
37870, 5776, 5799, 5800, 5777, 27591, 27683, 27687, 27595
37871, 27591, 27683, 27687, 27595, 27592, 27684, 27688, 27596
37872, 27592, 27684, 27688, 27596, 27593, 27685, 27689, 27597
37873, 27593, 27685, 27689, 27597, 27594, 27686, 27690, 27598
37874, 27594, 27686, 27690, 27598, 11244, 11267, 11268, 11245
37875, 5777, 5800, 5801, 5778, 27595, 27687, 27691, 27599
37876, 27595, 27687, 27691, 27599, 27596, 27688, 27692, 27600
37877, 27596, 27688, 27692, 27600, 27597, 27689, 27693, 27601
37878, 27597, 27689, 27693, 27601, 27598, 27690, 27694, 27602
37879, 27598, 27690, 27694, 27602, 11245, 11268, 11269, 11246
37880, 5778, 5801, 5802, 5779, 27599, 27691, 27695, 27603
37881, 27599, 27691, 27695, 27603, 27600, 27692, 27696, 27604
37882, 27600, 27692, 27696, 27604, 27601, 27693, 27697, 27605
37883, 27601, 27693, 27697, 27605, 27602, 27694, 27698, 27606
37884, 27602, 27694, 27698, 27606, 11246, 11269, 11270, 11247
37885, 5779, 5802, 5803, 5780, 27603, 27695, 27699, 27607
37886, 27603, 27695, 27699, 27607, 27604, 27696, 27700, 27608
37887, 27604, 27696, 27700, 27608, 27605, 27697, 27701, 27609
37888, 27605, 27697, 27701, 27609, 27606, 27698, 27702, 27610
37889, 27606, 27698, 27702, 27610, 11247, 11270, 11271, 11248
37890, 5780, 5803, 5804, 5781, 27607, 27699, 27703, 27611
37891, 27607, 27699, 27703, 27611, 27608, 27700, 27704, 27612
37892, 27608, 27700, 27704, 27612, 27609, 27701, 27705, 27613
37893, 27609, 27701, 27705, 27613, 27610, 27702, 27706, 27614
37894, 27610, 27702, 27706, 27614, 11248, 11271, 11272, 11249
37895, 5781, 5804, 5805, 5782, 27611, 27703, 27707, 27615
37896, 27611, 27703, 27707, 27615, 27612, 27704, 27708, 27616
37897, 27612, 27704, 27708, 27616, 27613, 27705, 27709, 27617
37898, 27613, 27705, 27709, 27617, 27614, 27706, 27710, 27618
37899, 27614, 27706, 27710, 27618, 11249, 11272, 11273, 11250
37900, 5782, 5805, 5806, 5783, 27615, 27707, 27711, 27619
37901, 27615, 27707, 27711, 27619, 27616, 27708, 27712, 27620
37902, 27616, 27708, 27712, 27620, 27617, 27709, 27713, 27621
37903, 27617, 27709, 27713, 27621, 27618, 27710, 27714, 27622
37904, 27618, 27710, 27714, 27622, 11250, 11273, 11274, 11251
37905, 5783, 5806, 5807, 5784, 27619, 27711, 27715, 27623
37906, 27619, 27711, 27715, 27623, 27620, 27712, 27716, 27624
37907, 27620, 27712, 27716, 27624, 27621, 27713, 27717, 27625
37908, 27621, 27713, 27717, 27625, 27622, 27714, 27718, 27626
37909, 27622, 27714, 27718, 27626, 11251, 11274, 11275, 11252
37910, 5784, 5807, 5808, 5785, 27623, 27715, 27719, 27627
37911, 27623, 27715, 27719, 27627, 27624, 27716, 27720, 27628
37912, 27624, 27716, 27720, 27628, 27625, 27717, 27721, 27629
37913, 27625, 27717, 27721, 27629, 27626, 27718, 27722, 27630
37914, 27626, 27718, 27722, 27630, 11252, 11275, 11276, 11253
37915, 5785, 5808, 5809, 5786, 27627, 27719, 27723, 27631
37916, 27627, 27719, 27723, 27631, 27628, 27720, 27724, 27632
37917, 27628, 27720, 27724, 27632, 27629, 27721, 27725, 27633
37918, 27629, 27721, 27725, 27633, 27630, 27722, 27726, 27634
37919, 27630, 27722, 27726, 27634, 11253, 11276, 11277, 11254
37920, 5786, 5809, 5810, 5787, 27631, 27723, 27727, 27635
37921, 27631, 27723, 27727, 27635, 27632, 27724, 27728, 27636
37922, 27632, 27724, 27728, 27636, 27633, 27725, 27729, 27637
37923, 27633, 27725, 27729, 27637, 27634, 27726, 27730, 27638
37924, 27634, 27726, 27730, 27638, 11254, 11277, 11278, 11255
37925, 5787, 5810, 5811, 5788, 27635, 27727, 27731, 27639
37926, 27635, 27727, 27731, 27639, 27636, 27728, 27732, 27640
37927, 27636, 27728, 27732, 27640, 27637, 27729, 27733, 27641
37928, 27637, 27729, 27733, 27641, 27638, 27730, 27734, 27642
37929, 27638, 27730, 27734, 27642, 11255, 11278, 11279, 11256
37930, 5788, 5811, 5812, 5789, 27639, 27731, 27735, 27643
37931, 27639, 27731, 27735, 27643, 27640, 27732, 27736, 27644
37932, 27640, 27732, 27736, 27644, 27641, 27733, 27737, 27645
37933, 27641, 27733, 27737, 27645, 27642, 27734, 27738, 27646
37934, 27642, 27734, 27738, 27646, 11256, 11279, 11280, 11257
37935, 5789, 5812, 5813, 5790, 27643, 27735, 27739, 27647
37936, 27643, 27735, 27739, 27647, 27644, 27736, 27740, 27648
37937, 27644, 27736, 27740, 27648, 27645, 27737, 27741, 27649
37938, 27645, 27737, 27741, 27649, 27646, 27738, 27742, 27650
37939, 27646, 27738, 27742, 27650, 11257, 11280, 11281, 11258
37940, 5790, 5813, 5814, 5791, 27647, 27739, 27743, 27651
37941, 27647, 27739, 27743, 27651, 27648, 27740, 27744, 27652
37942, 27648, 27740, 27744, 27652, 27649, 27741, 27745, 27653
37943, 27649, 27741, 27745, 27653, 27650, 27742, 27746, 27654
37944, 27650, 27742, 27746, 27654, 11258, 11281, 11282, 11259
37945, 5791, 5814, 5815, 5792, 27651, 27743, 27747, 27655
37946, 27651, 27743, 27747, 27655, 27652, 27744, 27748, 27656
37947, 27652, 27744, 27748, 27656, 27653, 27745, 27749, 27657
37948, 27653, 27745, 27749, 27657, 27654, 27746, 27750, 27658
37949, 27654, 27746, 27750, 27658, 11259, 11282, 11283, 11260
37950, 5792, 5815, 763, 762, 27655, 27747, 11198, 11194
37951, 27655, 27747, 11198, 11194, 27656, 27748, 11199, 11195
37952, 27656, 27748, 11199, 11195, 27657, 27749, 11200, 11196
37953, 27657, 27749, 11200, 11196, 27658, 27750, 11201, 11197
37954, 27658, 27750, 11201, 11197, 11260, 11283, 1729, 1728
37955, 645, 646, 5816, 5793, 10926, 10930, 27751, 27659
37956, 10926, 10930, 27751, 27659, 10927, 10931, 27752, 27660
37957, 10927, 10931, 27752, 27660, 10928, 10932, 27753, 27661
37958, 10928, 10932, 27753, 27661, 10929, 10933, 27754, 27662
37959, 10929, 10933, 27754, 27662, 1664, 1665, 11284, 11261
37960, 5793, 5816, 5817, 5794, 27659, 27751, 27755, 27663
37961, 27659, 27751, 27755, 27663, 27660, 27752, 27756, 27664
37962, 27660, 27752, 27756, 27664, 27661, 27753, 27757, 27665
37963, 27661, 27753, 27757, 27665, 27662, 27754, 27758, 27666
37964, 27662, 27754, 27758, 27666, 11261, 11284, 11285, 11262
37965, 5794, 5817, 5818, 5795, 27663, 27755, 27759, 27667
37966, 27663, 27755, 27759, 27667, 27664, 27756, 27760, 27668
37967, 27664, 27756, 27760, 27668, 27665, 27757, 27761, 27669
37968, 27665, 27757, 27761, 27669, 27666, 27758, 27762, 27670
37969, 27666, 27758, 27762, 27670, 11262, 11285, 11286, 11263
37970, 5795, 5818, 5819, 5796, 27667, 27759, 27763, 27671
37971, 27667, 27759, 27763, 27671, 27668, 27760, 27764, 27672
37972, 27668, 27760, 27764, 27672, 27669, 27761, 27765, 27673
37973, 27669, 27761, 27765, 27673, 27670, 27762, 27766, 27674
37974, 27670, 27762, 27766, 27674, 11263, 11286, 11287, 11264
37975, 5796, 5819, 5820, 5797, 27671, 27763, 27767, 27675
37976, 27671, 27763, 27767, 27675, 27672, 27764, 27768, 27676
37977, 27672, 27764, 27768, 27676, 27673, 27765, 27769, 27677
37978, 27673, 27765, 27769, 27677, 27674, 27766, 27770, 27678
37979, 27674, 27766, 27770, 27678, 11264, 11287, 11288, 11265
37980, 5797, 5820, 5821, 5798, 27675, 27767, 27771, 27679
37981, 27675, 27767, 27771, 27679, 27676, 27768, 27772, 27680
37982, 27676, 27768, 27772, 27680, 27677, 27769, 27773, 27681
37983, 27677, 27769, 27773, 27681, 27678, 27770, 27774, 27682
37984, 27678, 27770, 27774, 27682, 11265, 11288, 11289, 11266
37985, 5798, 5821, 5822, 5799, 27679, 27771, 27775, 27683
37986, 27679, 27771, 27775, 27683, 27680, 27772, 27776, 27684
37987, 27680, 27772, 27776, 27684, 27681, 27773, 27777, 27685
37988, 27681, 27773, 27777, 27685, 27682, 27774, 27778, 27686
37989, 27682, 27774, 27778, 27686, 11266, 11289, 11290, 11267
37990, 5799, 5822, 5823, 5800, 27683, 27775, 27779, 27687
37991, 27683, 27775, 27779, 27687, 27684, 27776, 27780, 27688
37992, 27684, 27776, 27780, 27688, 27685, 27777, 27781, 27689
37993, 27685, 27777, 27781, 27689, 27686, 27778, 27782, 27690
37994, 27686, 27778, 27782, 27690, 11267, 11290, 11291, 11268
37995, 5800, 5823, 5824, 5801, 27687, 27779, 27783, 27691
37996, 27687, 27779, 27783, 27691, 27688, 27780, 27784, 27692
37997, 27688, 27780, 27784, 27692, 27689, 27781, 27785, 27693
37998, 27689, 27781, 27785, 27693, 27690, 27782, 27786, 27694
37999, 27690, 27782, 27786, 27694, 11268, 11291, 11292, 11269
38000, 5801, 5824, 5825, 5802, 27691, 27783, 27787, 27695
38001, 27691, 27783, 27787, 27695, 27692, 27784, 27788, 27696
38002, 27692, 27784, 27788, 27696, 27693, 27785, 27789, 27697
38003, 27693, 27785, 27789, 27697, 27694, 27786, 27790, 27698
38004, 27694, 27786, 27790, 27698, 11269, 11292, 11293, 11270
38005, 5802, 5825, 5826, 5803, 27695, 27787, 27791, 27699
38006, 27695, 27787, 27791, 27699, 27696, 27788, 27792, 27700
38007, 27696, 27788, 27792, 27700, 27697, 27789, 27793, 27701
38008, 27697, 27789, 27793, 27701, 27698, 27790, 27794, 27702
38009, 27698, 27790, 27794, 27702, 11270, 11293, 11294, 11271
38010, 5803, 5826, 5827, 5804, 27699, 27791, 27795, 27703
38011, 27699, 27791, 27795, 27703, 27700, 27792, 27796, 27704
38012, 27700, 27792, 27796, 27704, 27701, 27793, 27797, 27705
38013, 27701, 27793, 27797, 27705, 27702, 27794, 27798, 27706
38014, 27702, 27794, 27798, 27706, 11271, 11294, 11295, 11272
38015, 5804, 5827, 5828, 5805, 27703, 27795, 27799, 27707
38016, 27703, 27795, 27799, 27707, 27704, 27796, 27800, 27708
38017, 27704, 27796, 27800, 27708, 27705, 27797, 27801, 27709
38018, 27705, 27797, 27801, 27709, 27706, 27798, 27802, 27710
38019, 27706, 27798, 27802, 27710, 11272, 11295, 11296, 11273
38020, 5805, 5828, 5829, 5806, 27707, 27799, 27803, 27711
38021, 27707, 27799, 27803, 27711, 27708, 27800, 27804, 27712
38022, 27708, 27800, 27804, 27712, 27709, 27801, 27805, 27713
38023, 27709, 27801, 27805, 27713, 27710, 27802, 27806, 27714
38024, 27710, 27802, 27806, 27714, 11273, 11296, 11297, 11274
38025, 5806, 5829, 5830, 5807, 27711, 27803, 27807, 27715
38026, 27711, 27803, 27807, 27715, 27712, 27804, 27808, 27716
38027, 27712, 27804, 27808, 27716, 27713, 27805, 27809, 27717
38028, 27713, 27805, 27809, 27717, 27714, 27806, 27810, 27718
38029, 27714, 27806, 27810, 27718, 11274, 11297, 11298, 11275
38030, 5807, 5830, 5831, 5808, 27715, 27807, 27811, 27719
38031, 27715, 27807, 27811, 27719, 27716, 27808, 27812, 27720
38032, 27716, 27808, 27812, 27720, 27717, 27809, 27813, 27721
38033, 27717, 27809, 27813, 27721, 27718, 27810, 27814, 27722
38034, 27718, 27810, 27814, 27722, 11275, 11298, 11299, 11276
38035, 5808, 5831, 5832, 5809, 27719, 27811, 27815, 27723
38036, 27719, 27811, 27815, 27723, 27720, 27812, 27816, 27724
38037, 27720, 27812, 27816, 27724, 27721, 27813, 27817, 27725
38038, 27721, 27813, 27817, 27725, 27722, 27814, 27818, 27726
38039, 27722, 27814, 27818, 27726, 11276, 11299, 11300, 11277
38040, 5809, 5832, 5833, 5810, 27723, 27815, 27819, 27727
38041, 27723, 27815, 27819, 27727, 27724, 27816, 27820, 27728
38042, 27724, 27816, 27820, 27728, 27725, 27817, 27821, 27729
38043, 27725, 27817, 27821, 27729, 27726, 27818, 27822, 27730
38044, 27726, 27818, 27822, 27730, 11277, 11300, 11301, 11278
38045, 5810, 5833, 5834, 5811, 27727, 27819, 27823, 27731
38046, 27727, 27819, 27823, 27731, 27728, 27820, 27824, 27732
38047, 27728, 27820, 27824, 27732, 27729, 27821, 27825, 27733
38048, 27729, 27821, 27825, 27733, 27730, 27822, 27826, 27734
38049, 27730, 27822, 27826, 27734, 11278, 11301, 11302, 11279
38050, 5811, 5834, 5835, 5812, 27731, 27823, 27827, 27735
38051, 27731, 27823, 27827, 27735, 27732, 27824, 27828, 27736
38052, 27732, 27824, 27828, 27736, 27733, 27825, 27829, 27737
38053, 27733, 27825, 27829, 27737, 27734, 27826, 27830, 27738
38054, 27734, 27826, 27830, 27738, 11279, 11302, 11303, 11280
38055, 5812, 5835, 5836, 5813, 27735, 27827, 27831, 27739
38056, 27735, 27827, 27831, 27739, 27736, 27828, 27832, 27740
38057, 27736, 27828, 27832, 27740, 27737, 27829, 27833, 27741
38058, 27737, 27829, 27833, 27741, 27738, 27830, 27834, 27742
38059, 27738, 27830, 27834, 27742, 11280, 11303, 11304, 11281
38060, 5813, 5836, 5837, 5814, 27739, 27831, 27835, 27743
38061, 27739, 27831, 27835, 27743, 27740, 27832, 27836, 27744
38062, 27740, 27832, 27836, 27744, 27741, 27833, 27837, 27745
38063, 27741, 27833, 27837, 27745, 27742, 27834, 27838, 27746
38064, 27742, 27834, 27838, 27746, 11281, 11304, 11305, 11282
38065, 5814, 5837, 5838, 5815, 27743, 27835, 27839, 27747
38066, 27743, 27835, 27839, 27747, 27744, 27836, 27840, 27748
38067, 27744, 27836, 27840, 27748, 27745, 27837, 27841, 27749
38068, 27745, 27837, 27841, 27749, 27746, 27838, 27842, 27750
38069, 27746, 27838, 27842, 27750, 11282, 11305, 11306, 11283
38070, 5815, 5838, 764, 763, 27747, 27839, 11202, 11198
38071, 27747, 27839, 11202, 11198, 27748, 27840, 11203, 11199
38072, 27748, 27840, 11203, 11199, 27749, 27841, 11204, 11200
38073, 27749, 27841, 11204, 11200, 27750, 27842, 11205, 11201
38074, 27750, 27842, 11205, 11201, 11283, 11306, 1730, 1729
38075, 646, 647, 5839, 5816, 10930, 10934, 27843, 27751
38076, 10930, 10934, 27843, 27751, 10931, 10935, 27844, 27752
38077, 10931, 10935, 27844, 27752, 10932, 10936, 27845, 27753
38078, 10932, 10936, 27845, 27753, 10933, 10937, 27846, 27754
38079, 10933, 10937, 27846, 27754, 1665, 1666, 11307, 11284
38080, 5816, 5839, 5840, 5817, 27751, 27843, 27847, 27755
38081, 27751, 27843, 27847, 27755, 27752, 27844, 27848, 27756
38082, 27752, 27844, 27848, 27756, 27753, 27845, 27849, 27757
38083, 27753, 27845, 27849, 27757, 27754, 27846, 27850, 27758
38084, 27754, 27846, 27850, 27758, 11284, 11307, 11308, 11285
38085, 5817, 5840, 5841, 5818, 27755, 27847, 27851, 27759
38086, 27755, 27847, 27851, 27759, 27756, 27848, 27852, 27760
38087, 27756, 27848, 27852, 27760, 27757, 27849, 27853, 27761
38088, 27757, 27849, 27853, 27761, 27758, 27850, 27854, 27762
38089, 27758, 27850, 27854, 27762, 11285, 11308, 11309, 11286
38090, 5818, 5841, 5842, 5819, 27759, 27851, 27855, 27763
38091, 27759, 27851, 27855, 27763, 27760, 27852, 27856, 27764
38092, 27760, 27852, 27856, 27764, 27761, 27853, 27857, 27765
38093, 27761, 27853, 27857, 27765, 27762, 27854, 27858, 27766
38094, 27762, 27854, 27858, 27766, 11286, 11309, 11310, 11287
38095, 5819, 5842, 5843, 5820, 27763, 27855, 27859, 27767
38096, 27763, 27855, 27859, 27767, 27764, 27856, 27860, 27768
38097, 27764, 27856, 27860, 27768, 27765, 27857, 27861, 27769
38098, 27765, 27857, 27861, 27769, 27766, 27858, 27862, 27770
38099, 27766, 27858, 27862, 27770, 11287, 11310, 11311, 11288
38100, 5820, 5843, 5844, 5821, 27767, 27859, 27863, 27771
38101, 27767, 27859, 27863, 27771, 27768, 27860, 27864, 27772
38102, 27768, 27860, 27864, 27772, 27769, 27861, 27865, 27773
38103, 27769, 27861, 27865, 27773, 27770, 27862, 27866, 27774
38104, 27770, 27862, 27866, 27774, 11288, 11311, 11312, 11289
38105, 5821, 5844, 5845, 5822, 27771, 27863, 27867, 27775
38106, 27771, 27863, 27867, 27775, 27772, 27864, 27868, 27776
38107, 27772, 27864, 27868, 27776, 27773, 27865, 27869, 27777
38108, 27773, 27865, 27869, 27777, 27774, 27866, 27870, 27778
38109, 27774, 27866, 27870, 27778, 11289, 11312, 11313, 11290
38110, 5822, 5845, 5846, 5823, 27775, 27867, 27871, 27779
38111, 27775, 27867, 27871, 27779, 27776, 27868, 27872, 27780
38112, 27776, 27868, 27872, 27780, 27777, 27869, 27873, 27781
38113, 27777, 27869, 27873, 27781, 27778, 27870, 27874, 27782
38114, 27778, 27870, 27874, 27782, 11290, 11313, 11314, 11291
38115, 5823, 5846, 5847, 5824, 27779, 27871, 27875, 27783
38116, 27779, 27871, 27875, 27783, 27780, 27872, 27876, 27784
38117, 27780, 27872, 27876, 27784, 27781, 27873, 27877, 27785
38118, 27781, 27873, 27877, 27785, 27782, 27874, 27878, 27786
38119, 27782, 27874, 27878, 27786, 11291, 11314, 11315, 11292
38120, 5824, 5847, 5848, 5825, 27783, 27875, 27879, 27787
38121, 27783, 27875, 27879, 27787, 27784, 27876, 27880, 27788
38122, 27784, 27876, 27880, 27788, 27785, 27877, 27881, 27789
38123, 27785, 27877, 27881, 27789, 27786, 27878, 27882, 27790
38124, 27786, 27878, 27882, 27790, 11292, 11315, 11316, 11293
38125, 5825, 5848, 5849, 5826, 27787, 27879, 27883, 27791
38126, 27787, 27879, 27883, 27791, 27788, 27880, 27884, 27792
38127, 27788, 27880, 27884, 27792, 27789, 27881, 27885, 27793
38128, 27789, 27881, 27885, 27793, 27790, 27882, 27886, 27794
38129, 27790, 27882, 27886, 27794, 11293, 11316, 11317, 11294
38130, 5826, 5849, 5850, 5827, 27791, 27883, 27887, 27795
38131, 27791, 27883, 27887, 27795, 27792, 27884, 27888, 27796
38132, 27792, 27884, 27888, 27796, 27793, 27885, 27889, 27797
38133, 27793, 27885, 27889, 27797, 27794, 27886, 27890, 27798
38134, 27794, 27886, 27890, 27798, 11294, 11317, 11318, 11295
38135, 5827, 5850, 5851, 5828, 27795, 27887, 27891, 27799
38136, 27795, 27887, 27891, 27799, 27796, 27888, 27892, 27800
38137, 27796, 27888, 27892, 27800, 27797, 27889, 27893, 27801
38138, 27797, 27889, 27893, 27801, 27798, 27890, 27894, 27802
38139, 27798, 27890, 27894, 27802, 11295, 11318, 11319, 11296
38140, 5828, 5851, 5852, 5829, 27799, 27891, 27895, 27803
38141, 27799, 27891, 27895, 27803, 27800, 27892, 27896, 27804
38142, 27800, 27892, 27896, 27804, 27801, 27893, 27897, 27805
38143, 27801, 27893, 27897, 27805, 27802, 27894, 27898, 27806
38144, 27802, 27894, 27898, 27806, 11296, 11319, 11320, 11297
38145, 5829, 5852, 5853, 5830, 27803, 27895, 27899, 27807
38146, 27803, 27895, 27899, 27807, 27804, 27896, 27900, 27808
38147, 27804, 27896, 27900, 27808, 27805, 27897, 27901, 27809
38148, 27805, 27897, 27901, 27809, 27806, 27898, 27902, 27810
38149, 27806, 27898, 27902, 27810, 11297, 11320, 11321, 11298
38150, 5830, 5853, 5854, 5831, 27807, 27899, 27903, 27811
38151, 27807, 27899, 27903, 27811, 27808, 27900, 27904, 27812
38152, 27808, 27900, 27904, 27812, 27809, 27901, 27905, 27813
38153, 27809, 27901, 27905, 27813, 27810, 27902, 27906, 27814
38154, 27810, 27902, 27906, 27814, 11298, 11321, 11322, 11299
38155, 5831, 5854, 5855, 5832, 27811, 27903, 27907, 27815
38156, 27811, 27903, 27907, 27815, 27812, 27904, 27908, 27816
38157, 27812, 27904, 27908, 27816, 27813, 27905, 27909, 27817
38158, 27813, 27905, 27909, 27817, 27814, 27906, 27910, 27818
38159, 27814, 27906, 27910, 27818, 11299, 11322, 11323, 11300
38160, 5832, 5855, 5856, 5833, 27815, 27907, 27911, 27819
38161, 27815, 27907, 27911, 27819, 27816, 27908, 27912, 27820
38162, 27816, 27908, 27912, 27820, 27817, 27909, 27913, 27821
38163, 27817, 27909, 27913, 27821, 27818, 27910, 27914, 27822
38164, 27818, 27910, 27914, 27822, 11300, 11323, 11324, 11301
38165, 5833, 5856, 5857, 5834, 27819, 27911, 27915, 27823
38166, 27819, 27911, 27915, 27823, 27820, 27912, 27916, 27824
38167, 27820, 27912, 27916, 27824, 27821, 27913, 27917, 27825
38168, 27821, 27913, 27917, 27825, 27822, 27914, 27918, 27826
38169, 27822, 27914, 27918, 27826, 11301, 11324, 11325, 11302
38170, 5834, 5857, 5858, 5835, 27823, 27915, 27919, 27827
38171, 27823, 27915, 27919, 27827, 27824, 27916, 27920, 27828
38172, 27824, 27916, 27920, 27828, 27825, 27917, 27921, 27829
38173, 27825, 27917, 27921, 27829, 27826, 27918, 27922, 27830
38174, 27826, 27918, 27922, 27830, 11302, 11325, 11326, 11303
38175, 5835, 5858, 5859, 5836, 27827, 27919, 27923, 27831
38176, 27827, 27919, 27923, 27831, 27828, 27920, 27924, 27832
38177, 27828, 27920, 27924, 27832, 27829, 27921, 27925, 27833
38178, 27829, 27921, 27925, 27833, 27830, 27922, 27926, 27834
38179, 27830, 27922, 27926, 27834, 11303, 11326, 11327, 11304
38180, 5836, 5859, 5860, 5837, 27831, 27923, 27927, 27835
38181, 27831, 27923, 27927, 27835, 27832, 27924, 27928, 27836
38182, 27832, 27924, 27928, 27836, 27833, 27925, 27929, 27837
38183, 27833, 27925, 27929, 27837, 27834, 27926, 27930, 27838
38184, 27834, 27926, 27930, 27838, 11304, 11327, 11328, 11305
38185, 5837, 5860, 5861, 5838, 27835, 27927, 27931, 27839
38186, 27835, 27927, 27931, 27839, 27836, 27928, 27932, 27840
38187, 27836, 27928, 27932, 27840, 27837, 27929, 27933, 27841
38188, 27837, 27929, 27933, 27841, 27838, 27930, 27934, 27842
38189, 27838, 27930, 27934, 27842, 11305, 11328, 11329, 11306
38190, 5838, 5861, 765, 764, 27839, 27931, 11206, 11202
38191, 27839, 27931, 11206, 11202, 27840, 27932, 11207, 11203
38192, 27840, 27932, 11207, 11203, 27841, 27933, 11208, 11204
38193, 27841, 27933, 11208, 11204, 27842, 27934, 11209, 11205
38194, 27842, 27934, 11209, 11205, 11306, 11329, 1731, 1730
38195, 647, 648, 5862, 5839, 10934, 10938, 27935, 27843
38196, 10934, 10938, 27935, 27843, 10935, 10939, 27936, 27844
38197, 10935, 10939, 27936, 27844, 10936, 10940, 27937, 27845
38198, 10936, 10940, 27937, 27845, 10937, 10941, 27938, 27846
38199, 10937, 10941, 27938, 27846, 1666, 1667, 11330, 11307
38200, 5839, 5862, 5863, 5840, 27843, 27935, 27939, 27847
38201, 27843, 27935, 27939, 27847, 27844, 27936, 27940, 27848
38202, 27844, 27936, 27940, 27848, 27845, 27937, 27941, 27849
38203, 27845, 27937, 27941, 27849, 27846, 27938, 27942, 27850
38204, 27846, 27938, 27942, 27850, 11307, 11330, 11331, 11308
38205, 5840, 5863, 5864, 5841, 27847, 27939, 27943, 27851
38206, 27847, 27939, 27943, 27851, 27848, 27940, 27944, 27852
38207, 27848, 27940, 27944, 27852, 27849, 27941, 27945, 27853
38208, 27849, 27941, 27945, 27853, 27850, 27942, 27946, 27854
38209, 27850, 27942, 27946, 27854, 11308, 11331, 11332, 11309
38210, 5841, 5864, 5865, 5842, 27851, 27943, 27947, 27855
38211, 27851, 27943, 27947, 27855, 27852, 27944, 27948, 27856
38212, 27852, 27944, 27948, 27856, 27853, 27945, 27949, 27857
38213, 27853, 27945, 27949, 27857, 27854, 27946, 27950, 27858
38214, 27854, 27946, 27950, 27858, 11309, 11332, 11333, 11310
38215, 5842, 5865, 5866, 5843, 27855, 27947, 27951, 27859
38216, 27855, 27947, 27951, 27859, 27856, 27948, 27952, 27860
38217, 27856, 27948, 27952, 27860, 27857, 27949, 27953, 27861
38218, 27857, 27949, 27953, 27861, 27858, 27950, 27954, 27862
38219, 27858, 27950, 27954, 27862, 11310, 11333, 11334, 11311
38220, 5843, 5866, 5867, 5844, 27859, 27951, 27955, 27863
38221, 27859, 27951, 27955, 27863, 27860, 27952, 27956, 27864
38222, 27860, 27952, 27956, 27864, 27861, 27953, 27957, 27865
38223, 27861, 27953, 27957, 27865, 27862, 27954, 27958, 27866
38224, 27862, 27954, 27958, 27866, 11311, 11334, 11335, 11312
38225, 5844, 5867, 5868, 5845, 27863, 27955, 27959, 27867
38226, 27863, 27955, 27959, 27867, 27864, 27956, 27960, 27868
38227, 27864, 27956, 27960, 27868, 27865, 27957, 27961, 27869
38228, 27865, 27957, 27961, 27869, 27866, 27958, 27962, 27870
38229, 27866, 27958, 27962, 27870, 11312, 11335, 11336, 11313
38230, 5845, 5868, 5869, 5846, 27867, 27959, 27963, 27871
38231, 27867, 27959, 27963, 27871, 27868, 27960, 27964, 27872
38232, 27868, 27960, 27964, 27872, 27869, 27961, 27965, 27873
38233, 27869, 27961, 27965, 27873, 27870, 27962, 27966, 27874
38234, 27870, 27962, 27966, 27874, 11313, 11336, 11337, 11314
38235, 5846, 5869, 5870, 5847, 27871, 27963, 27967, 27875
38236, 27871, 27963, 27967, 27875, 27872, 27964, 27968, 27876
38237, 27872, 27964, 27968, 27876, 27873, 27965, 27969, 27877
38238, 27873, 27965, 27969, 27877, 27874, 27966, 27970, 27878
38239, 27874, 27966, 27970, 27878, 11314, 11337, 11338, 11315
38240, 5847, 5870, 5871, 5848, 27875, 27967, 27971, 27879
38241, 27875, 27967, 27971, 27879, 27876, 27968, 27972, 27880
38242, 27876, 27968, 27972, 27880, 27877, 27969, 27973, 27881
38243, 27877, 27969, 27973, 27881, 27878, 27970, 27974, 27882
38244, 27878, 27970, 27974, 27882, 11315, 11338, 11339, 11316
38245, 5848, 5871, 5872, 5849, 27879, 27971, 27975, 27883
38246, 27879, 27971, 27975, 27883, 27880, 27972, 27976, 27884
38247, 27880, 27972, 27976, 27884, 27881, 27973, 27977, 27885
38248, 27881, 27973, 27977, 27885, 27882, 27974, 27978, 27886
38249, 27882, 27974, 27978, 27886, 11316, 11339, 11340, 11317
38250, 5849, 5872, 5873, 5850, 27883, 27975, 27979, 27887
38251, 27883, 27975, 27979, 27887, 27884, 27976, 27980, 27888
38252, 27884, 27976, 27980, 27888, 27885, 27977, 27981, 27889
38253, 27885, 27977, 27981, 27889, 27886, 27978, 27982, 27890
38254, 27886, 27978, 27982, 27890, 11317, 11340, 11341, 11318
38255, 5850, 5873, 5874, 5851, 27887, 27979, 27983, 27891
38256, 27887, 27979, 27983, 27891, 27888, 27980, 27984, 27892
38257, 27888, 27980, 27984, 27892, 27889, 27981, 27985, 27893
38258, 27889, 27981, 27985, 27893, 27890, 27982, 27986, 27894
38259, 27890, 27982, 27986, 27894, 11318, 11341, 11342, 11319
38260, 5851, 5874, 5875, 5852, 27891, 27983, 27987, 27895
38261, 27891, 27983, 27987, 27895, 27892, 27984, 27988, 27896
38262, 27892, 27984, 27988, 27896, 27893, 27985, 27989, 27897
38263, 27893, 27985, 27989, 27897, 27894, 27986, 27990, 27898
38264, 27894, 27986, 27990, 27898, 11319, 11342, 11343, 11320
38265, 5852, 5875, 5876, 5853, 27895, 27987, 27991, 27899
38266, 27895, 27987, 27991, 27899, 27896, 27988, 27992, 27900
38267, 27896, 27988, 27992, 27900, 27897, 27989, 27993, 27901
38268, 27897, 27989, 27993, 27901, 27898, 27990, 27994, 27902
38269, 27898, 27990, 27994, 27902, 11320, 11343, 11344, 11321
38270, 5853, 5876, 5877, 5854, 27899, 27991, 27995, 27903
38271, 27899, 27991, 27995, 27903, 27900, 27992, 27996, 27904
38272, 27900, 27992, 27996, 27904, 27901, 27993, 27997, 27905
38273, 27901, 27993, 27997, 27905, 27902, 27994, 27998, 27906
38274, 27902, 27994, 27998, 27906, 11321, 11344, 11345, 11322
38275, 5854, 5877, 5878, 5855, 27903, 27995, 27999, 27907
38276, 27903, 27995, 27999, 27907, 27904, 27996, 28000, 27908
38277, 27904, 27996, 28000, 27908, 27905, 27997, 28001, 27909
38278, 27905, 27997, 28001, 27909, 27906, 27998, 28002, 27910
38279, 27906, 27998, 28002, 27910, 11322, 11345, 11346, 11323
38280, 5855, 5878, 5879, 5856, 27907, 27999, 28003, 27911
38281, 27907, 27999, 28003, 27911, 27908, 28000, 28004, 27912
38282, 27908, 28000, 28004, 27912, 27909, 28001, 28005, 27913
38283, 27909, 28001, 28005, 27913, 27910, 28002, 28006, 27914
38284, 27910, 28002, 28006, 27914, 11323, 11346, 11347, 11324
38285, 5856, 5879, 5880, 5857, 27911, 28003, 28007, 27915
38286, 27911, 28003, 28007, 27915, 27912, 28004, 28008, 27916
38287, 27912, 28004, 28008, 27916, 27913, 28005, 28009, 27917
38288, 27913, 28005, 28009, 27917, 27914, 28006, 28010, 27918
38289, 27914, 28006, 28010, 27918, 11324, 11347, 11348, 11325
38290, 5857, 5880, 5881, 5858, 27915, 28007, 28011, 27919
38291, 27915, 28007, 28011, 27919, 27916, 28008, 28012, 27920
38292, 27916, 28008, 28012, 27920, 27917, 28009, 28013, 27921
38293, 27917, 28009, 28013, 27921, 27918, 28010, 28014, 27922
38294, 27918, 28010, 28014, 27922, 11325, 11348, 11349, 11326
38295, 5858, 5881, 5882, 5859, 27919, 28011, 28015, 27923
38296, 27919, 28011, 28015, 27923, 27920, 28012, 28016, 27924
38297, 27920, 28012, 28016, 27924, 27921, 28013, 28017, 27925
38298, 27921, 28013, 28017, 27925, 27922, 28014, 28018, 27926
38299, 27922, 28014, 28018, 27926, 11326, 11349, 11350, 11327
38300, 5859, 5882, 5883, 5860, 27923, 28015, 28019, 27927
38301, 27923, 28015, 28019, 27927, 27924, 28016, 28020, 27928
38302, 27924, 28016, 28020, 27928, 27925, 28017, 28021, 27929
38303, 27925, 28017, 28021, 27929, 27926, 28018, 28022, 27930
38304, 27926, 28018, 28022, 27930, 11327, 11350, 11351, 11328
38305, 5860, 5883, 5884, 5861, 27927, 28019, 28023, 27931
38306, 27927, 28019, 28023, 27931, 27928, 28020, 28024, 27932
38307, 27928, 28020, 28024, 27932, 27929, 28021, 28025, 27933
38308, 27929, 28021, 28025, 27933, 27930, 28022, 28026, 27934
38309, 27930, 28022, 28026, 27934, 11328, 11351, 11352, 11329
38310, 5861, 5884, 766, 765, 27931, 28023, 11210, 11206
38311, 27931, 28023, 11210, 11206, 27932, 28024, 11211, 11207
38312, 27932, 28024, 11211, 11207, 27933, 28025, 11212, 11208
38313, 27933, 28025, 11212, 11208, 27934, 28026, 11213, 11209
38314, 27934, 28026, 11213, 11209, 11329, 11352, 1732, 1731
38315, 648, 649, 5885, 5862, 10938, 10942, 28027, 27935
38316, 10938, 10942, 28027, 27935, 10939, 10943, 28028, 27936
38317, 10939, 10943, 28028, 27936, 10940, 10944, 28029, 27937
38318, 10940, 10944, 28029, 27937, 10941, 10945, 28030, 27938
38319, 10941, 10945, 28030, 27938, 1667, 1668, 11353, 11330
38320, 5862, 5885, 5886, 5863, 27935, 28027, 28031, 27939
38321, 27935, 28027, 28031, 27939, 27936, 28028, 28032, 27940
38322, 27936, 28028, 28032, 27940, 27937, 28029, 28033, 27941
38323, 27937, 28029, 28033, 27941, 27938, 28030, 28034, 27942
38324, 27938, 28030, 28034, 27942, 11330, 11353, 11354, 11331
38325, 5863, 5886, 5887, 5864, 27939, 28031, 28035, 27943
38326, 27939, 28031, 28035, 27943, 27940, 28032, 28036, 27944
38327, 27940, 28032, 28036, 27944, 27941, 28033, 28037, 27945
38328, 27941, 28033, 28037, 27945, 27942, 28034, 28038, 27946
38329, 27942, 28034, 28038, 27946, 11331, 11354, 11355, 11332
38330, 5864, 5887, 5888, 5865, 27943, 28035, 28039, 27947
38331, 27943, 28035, 28039, 27947, 27944, 28036, 28040, 27948
38332, 27944, 28036, 28040, 27948, 27945, 28037, 28041, 27949
38333, 27945, 28037, 28041, 27949, 27946, 28038, 28042, 27950
38334, 27946, 28038, 28042, 27950, 11332, 11355, 11356, 11333
38335, 5865, 5888, 5889, 5866, 27947, 28039, 28043, 27951
38336, 27947, 28039, 28043, 27951, 27948, 28040, 28044, 27952
38337, 27948, 28040, 28044, 27952, 27949, 28041, 28045, 27953
38338, 27949, 28041, 28045, 27953, 27950, 28042, 28046, 27954
38339, 27950, 28042, 28046, 27954, 11333, 11356, 11357, 11334
38340, 5866, 5889, 5890, 5867, 27951, 28043, 28047, 27955
38341, 27951, 28043, 28047, 27955, 27952, 28044, 28048, 27956
38342, 27952, 28044, 28048, 27956, 27953, 28045, 28049, 27957
38343, 27953, 28045, 28049, 27957, 27954, 28046, 28050, 27958
38344, 27954, 28046, 28050, 27958, 11334, 11357, 11358, 11335
38345, 5867, 5890, 5891, 5868, 27955, 28047, 28051, 27959
38346, 27955, 28047, 28051, 27959, 27956, 28048, 28052, 27960
38347, 27956, 28048, 28052, 27960, 27957, 28049, 28053, 27961
38348, 27957, 28049, 28053, 27961, 27958, 28050, 28054, 27962
38349, 27958, 28050, 28054, 27962, 11335, 11358, 11359, 11336
38350, 5868, 5891, 5892, 5869, 27959, 28051, 28055, 27963
38351, 27959, 28051, 28055, 27963, 27960, 28052, 28056, 27964
38352, 27960, 28052, 28056, 27964, 27961, 28053, 28057, 27965
38353, 27961, 28053, 28057, 27965, 27962, 28054, 28058, 27966
38354, 27962, 28054, 28058, 27966, 11336, 11359, 11360, 11337
38355, 5869, 5892, 5893, 5870, 27963, 28055, 28059, 27967
38356, 27963, 28055, 28059, 27967, 27964, 28056, 28060, 27968
38357, 27964, 28056, 28060, 27968, 27965, 28057, 28061, 27969
38358, 27965, 28057, 28061, 27969, 27966, 28058, 28062, 27970
38359, 27966, 28058, 28062, 27970, 11337, 11360, 11361, 11338
38360, 5870, 5893, 5894, 5871, 27967, 28059, 28063, 27971
38361, 27967, 28059, 28063, 27971, 27968, 28060, 28064, 27972
38362, 27968, 28060, 28064, 27972, 27969, 28061, 28065, 27973
38363, 27969, 28061, 28065, 27973, 27970, 28062, 28066, 27974
38364, 27970, 28062, 28066, 27974, 11338, 11361, 11362, 11339
38365, 5871, 5894, 5895, 5872, 27971, 28063, 28067, 27975
38366, 27971, 28063, 28067, 27975, 27972, 28064, 28068, 27976
38367, 27972, 28064, 28068, 27976, 27973, 28065, 28069, 27977
38368, 27973, 28065, 28069, 27977, 27974, 28066, 28070, 27978
38369, 27974, 28066, 28070, 27978, 11339, 11362, 11363, 11340
38370, 5872, 5895, 5896, 5873, 27975, 28067, 28071, 27979
38371, 27975, 28067, 28071, 27979, 27976, 28068, 28072, 27980
38372, 27976, 28068, 28072, 27980, 27977, 28069, 28073, 27981
38373, 27977, 28069, 28073, 27981, 27978, 28070, 28074, 27982
38374, 27978, 28070, 28074, 27982, 11340, 11363, 11364, 11341
38375, 5873, 5896, 5897, 5874, 27979, 28071, 28075, 27983
38376, 27979, 28071, 28075, 27983, 27980, 28072, 28076, 27984
38377, 27980, 28072, 28076, 27984, 27981, 28073, 28077, 27985
38378, 27981, 28073, 28077, 27985, 27982, 28074, 28078, 27986
38379, 27982, 28074, 28078, 27986, 11341, 11364, 11365, 11342
38380, 5874, 5897, 5898, 5875, 27983, 28075, 28079, 27987
38381, 27983, 28075, 28079, 27987, 27984, 28076, 28080, 27988
38382, 27984, 28076, 28080, 27988, 27985, 28077, 28081, 27989
38383, 27985, 28077, 28081, 27989, 27986, 28078, 28082, 27990
38384, 27986, 28078, 28082, 27990, 11342, 11365, 11366, 11343
38385, 5875, 5898, 5899, 5876, 27987, 28079, 28083, 27991
38386, 27987, 28079, 28083, 27991, 27988, 28080, 28084, 27992
38387, 27988, 28080, 28084, 27992, 27989, 28081, 28085, 27993
38388, 27989, 28081, 28085, 27993, 27990, 28082, 28086, 27994
38389, 27990, 28082, 28086, 27994, 11343, 11366, 11367, 11344
38390, 5876, 5899, 5900, 5877, 27991, 28083, 28087, 27995
38391, 27991, 28083, 28087, 27995, 27992, 28084, 28088, 27996
38392, 27992, 28084, 28088, 27996, 27993, 28085, 28089, 27997
38393, 27993, 28085, 28089, 27997, 27994, 28086, 28090, 27998
38394, 27994, 28086, 28090, 27998, 11344, 11367, 11368, 11345
38395, 5877, 5900, 5901, 5878, 27995, 28087, 28091, 27999
38396, 27995, 28087, 28091, 27999, 27996, 28088, 28092, 28000
38397, 27996, 28088, 28092, 28000, 27997, 28089, 28093, 28001
38398, 27997, 28089, 28093, 28001, 27998, 28090, 28094, 28002
38399, 27998, 28090, 28094, 28002, 11345, 11368, 11369, 11346
38400, 5878, 5901, 5902, 5879, 27999, 28091, 28095, 28003
38401, 27999, 28091, 28095, 28003, 28000, 28092, 28096, 28004
38402, 28000, 28092, 28096, 28004, 28001, 28093, 28097, 28005
38403, 28001, 28093, 28097, 28005, 28002, 28094, 28098, 28006
38404, 28002, 28094, 28098, 28006, 11346, 11369, 11370, 11347
38405, 5879, 5902, 5903, 5880, 28003, 28095, 28099, 28007
38406, 28003, 28095, 28099, 28007, 28004, 28096, 28100, 28008
38407, 28004, 28096, 28100, 28008, 28005, 28097, 28101, 28009
38408, 28005, 28097, 28101, 28009, 28006, 28098, 28102, 28010
38409, 28006, 28098, 28102, 28010, 11347, 11370, 11371, 11348
38410, 5880, 5903, 5904, 5881, 28007, 28099, 28103, 28011
38411, 28007, 28099, 28103, 28011, 28008, 28100, 28104, 28012
38412, 28008, 28100, 28104, 28012, 28009, 28101, 28105, 28013
38413, 28009, 28101, 28105, 28013, 28010, 28102, 28106, 28014
38414, 28010, 28102, 28106, 28014, 11348, 11371, 11372, 11349
38415, 5881, 5904, 5905, 5882, 28011, 28103, 28107, 28015
38416, 28011, 28103, 28107, 28015, 28012, 28104, 28108, 28016
38417, 28012, 28104, 28108, 28016, 28013, 28105, 28109, 28017
38418, 28013, 28105, 28109, 28017, 28014, 28106, 28110, 28018
38419, 28014, 28106, 28110, 28018, 11349, 11372, 11373, 11350
38420, 5882, 5905, 5906, 5883, 28015, 28107, 28111, 28019
38421, 28015, 28107, 28111, 28019, 28016, 28108, 28112, 28020
38422, 28016, 28108, 28112, 28020, 28017, 28109, 28113, 28021
38423, 28017, 28109, 28113, 28021, 28018, 28110, 28114, 28022
38424, 28018, 28110, 28114, 28022, 11350, 11373, 11374, 11351
38425, 5883, 5906, 5907, 5884, 28019, 28111, 28115, 28023
38426, 28019, 28111, 28115, 28023, 28020, 28112, 28116, 28024
38427, 28020, 28112, 28116, 28024, 28021, 28113, 28117, 28025
38428, 28021, 28113, 28117, 28025, 28022, 28114, 28118, 28026
38429, 28022, 28114, 28118, 28026, 11351, 11374, 11375, 11352
38430, 5884, 5907, 767, 766, 28023, 28115, 11214, 11210
38431, 28023, 28115, 11214, 11210, 28024, 28116, 11215, 11211
38432, 28024, 28116, 11215, 11211, 28025, 28117, 11216, 11212
38433, 28025, 28117, 11216, 11212, 28026, 28118, 11217, 11213
38434, 28026, 28118, 11217, 11213, 11352, 11375, 1733, 1732
38435, 649, 650, 5908, 5885, 10942, 10946, 28119, 28027
38436, 10942, 10946, 28119, 28027, 10943, 10947, 28120, 28028
38437, 10943, 10947, 28120, 28028, 10944, 10948, 28121, 28029
38438, 10944, 10948, 28121, 28029, 10945, 10949, 28122, 28030
38439, 10945, 10949, 28122, 28030, 1668, 1669, 11376, 11353
38440, 5885, 5908, 5909, 5886, 28027, 28119, 28123, 28031
38441, 28027, 28119, 28123, 28031, 28028, 28120, 28124, 28032
38442, 28028, 28120, 28124, 28032, 28029, 28121, 28125, 28033
38443, 28029, 28121, 28125, 28033, 28030, 28122, 28126, 28034
38444, 28030, 28122, 28126, 28034, 11353, 11376, 11377, 11354
38445, 5886, 5909, 5910, 5887, 28031, 28123, 28127, 28035
38446, 28031, 28123, 28127, 28035, 28032, 28124, 28128, 28036
38447, 28032, 28124, 28128, 28036, 28033, 28125, 28129, 28037
38448, 28033, 28125, 28129, 28037, 28034, 28126, 28130, 28038
38449, 28034, 28126, 28130, 28038, 11354, 11377, 11378, 11355
38450, 5887, 5910, 5911, 5888, 28035, 28127, 28131, 28039
38451, 28035, 28127, 28131, 28039, 28036, 28128, 28132, 28040
38452, 28036, 28128, 28132, 28040, 28037, 28129, 28133, 28041
38453, 28037, 28129, 28133, 28041, 28038, 28130, 28134, 28042
38454, 28038, 28130, 28134, 28042, 11355, 11378, 11379, 11356
38455, 5888, 5911, 5912, 5889, 28039, 28131, 28135, 28043
38456, 28039, 28131, 28135, 28043, 28040, 28132, 28136, 28044
38457, 28040, 28132, 28136, 28044, 28041, 28133, 28137, 28045
38458, 28041, 28133, 28137, 28045, 28042, 28134, 28138, 28046
38459, 28042, 28134, 28138, 28046, 11356, 11379, 11380, 11357
38460, 5889, 5912, 5913, 5890, 28043, 28135, 28139, 28047
38461, 28043, 28135, 28139, 28047, 28044, 28136, 28140, 28048
38462, 28044, 28136, 28140, 28048, 28045, 28137, 28141, 28049
38463, 28045, 28137, 28141, 28049, 28046, 28138, 28142, 28050
38464, 28046, 28138, 28142, 28050, 11357, 11380, 11381, 11358
38465, 5890, 5913, 5914, 5891, 28047, 28139, 28143, 28051
38466, 28047, 28139, 28143, 28051, 28048, 28140, 28144, 28052
38467, 28048, 28140, 28144, 28052, 28049, 28141, 28145, 28053
38468, 28049, 28141, 28145, 28053, 28050, 28142, 28146, 28054
38469, 28050, 28142, 28146, 28054, 11358, 11381, 11382, 11359
38470, 5891, 5914, 5915, 5892, 28051, 28143, 28147, 28055
38471, 28051, 28143, 28147, 28055, 28052, 28144, 28148, 28056
38472, 28052, 28144, 28148, 28056, 28053, 28145, 28149, 28057
38473, 28053, 28145, 28149, 28057, 28054, 28146, 28150, 28058
38474, 28054, 28146, 28150, 28058, 11359, 11382, 11383, 11360
38475, 5892, 5915, 5916, 5893, 28055, 28147, 28151, 28059
38476, 28055, 28147, 28151, 28059, 28056, 28148, 28152, 28060
38477, 28056, 28148, 28152, 28060, 28057, 28149, 28153, 28061
38478, 28057, 28149, 28153, 28061, 28058, 28150, 28154, 28062
38479, 28058, 28150, 28154, 28062, 11360, 11383, 11384, 11361
38480, 5893, 5916, 5917, 5894, 28059, 28151, 28155, 28063
38481, 28059, 28151, 28155, 28063, 28060, 28152, 28156, 28064
38482, 28060, 28152, 28156, 28064, 28061, 28153, 28157, 28065
38483, 28061, 28153, 28157, 28065, 28062, 28154, 28158, 28066
38484, 28062, 28154, 28158, 28066, 11361, 11384, 11385, 11362
38485, 5894, 5917, 5918, 5895, 28063, 28155, 28159, 28067
38486, 28063, 28155, 28159, 28067, 28064, 28156, 28160, 28068
38487, 28064, 28156, 28160, 28068, 28065, 28157, 28161, 28069
38488, 28065, 28157, 28161, 28069, 28066, 28158, 28162, 28070
38489, 28066, 28158, 28162, 28070, 11362, 11385, 11386, 11363
38490, 5895, 5918, 5919, 5896, 28067, 28159, 28163, 28071
38491, 28067, 28159, 28163, 28071, 28068, 28160, 28164, 28072
38492, 28068, 28160, 28164, 28072, 28069, 28161, 28165, 28073
38493, 28069, 28161, 28165, 28073, 28070, 28162, 28166, 28074
38494, 28070, 28162, 28166, 28074, 11363, 11386, 11387, 11364
38495, 5896, 5919, 5920, 5897, 28071, 28163, 28167, 28075
38496, 28071, 28163, 28167, 28075, 28072, 28164, 28168, 28076
38497, 28072, 28164, 28168, 28076, 28073, 28165, 28169, 28077
38498, 28073, 28165, 28169, 28077, 28074, 28166, 28170, 28078
38499, 28074, 28166, 28170, 28078, 11364, 11387, 11388, 11365
38500, 5897, 5920, 5921, 5898, 28075, 28167, 28171, 28079
38501, 28075, 28167, 28171, 28079, 28076, 28168, 28172, 28080
38502, 28076, 28168, 28172, 28080, 28077, 28169, 28173, 28081
38503, 28077, 28169, 28173, 28081, 28078, 28170, 28174, 28082
38504, 28078, 28170, 28174, 28082, 11365, 11388, 11389, 11366
38505, 5898, 5921, 5922, 5899, 28079, 28171, 28175, 28083
38506, 28079, 28171, 28175, 28083, 28080, 28172, 28176, 28084
38507, 28080, 28172, 28176, 28084, 28081, 28173, 28177, 28085
38508, 28081, 28173, 28177, 28085, 28082, 28174, 28178, 28086
38509, 28082, 28174, 28178, 28086, 11366, 11389, 11390, 11367
38510, 5899, 5922, 5923, 5900, 28083, 28175, 28179, 28087
38511, 28083, 28175, 28179, 28087, 28084, 28176, 28180, 28088
38512, 28084, 28176, 28180, 28088, 28085, 28177, 28181, 28089
38513, 28085, 28177, 28181, 28089, 28086, 28178, 28182, 28090
38514, 28086, 28178, 28182, 28090, 11367, 11390, 11391, 11368
38515, 5900, 5923, 5924, 5901, 28087, 28179, 28183, 28091
38516, 28087, 28179, 28183, 28091, 28088, 28180, 28184, 28092
38517, 28088, 28180, 28184, 28092, 28089, 28181, 28185, 28093
38518, 28089, 28181, 28185, 28093, 28090, 28182, 28186, 28094
38519, 28090, 28182, 28186, 28094, 11368, 11391, 11392, 11369
38520, 5901, 5924, 5925, 5902, 28091, 28183, 28187, 28095
38521, 28091, 28183, 28187, 28095, 28092, 28184, 28188, 28096
38522, 28092, 28184, 28188, 28096, 28093, 28185, 28189, 28097
38523, 28093, 28185, 28189, 28097, 28094, 28186, 28190, 28098
38524, 28094, 28186, 28190, 28098, 11369, 11392, 11393, 11370
38525, 5902, 5925, 5926, 5903, 28095, 28187, 28191, 28099
38526, 28095, 28187, 28191, 28099, 28096, 28188, 28192, 28100
38527, 28096, 28188, 28192, 28100, 28097, 28189, 28193, 28101
38528, 28097, 28189, 28193, 28101, 28098, 28190, 28194, 28102
38529, 28098, 28190, 28194, 28102, 11370, 11393, 11394, 11371
38530, 5903, 5926, 5927, 5904, 28099, 28191, 28195, 28103
38531, 28099, 28191, 28195, 28103, 28100, 28192, 28196, 28104
38532, 28100, 28192, 28196, 28104, 28101, 28193, 28197, 28105
38533, 28101, 28193, 28197, 28105, 28102, 28194, 28198, 28106
38534, 28102, 28194, 28198, 28106, 11371, 11394, 11395, 11372
38535, 5904, 5927, 5928, 5905, 28103, 28195, 28199, 28107
38536, 28103, 28195, 28199, 28107, 28104, 28196, 28200, 28108
38537, 28104, 28196, 28200, 28108, 28105, 28197, 28201, 28109
38538, 28105, 28197, 28201, 28109, 28106, 28198, 28202, 28110
38539, 28106, 28198, 28202, 28110, 11372, 11395, 11396, 11373
38540, 5905, 5928, 5929, 5906, 28107, 28199, 28203, 28111
38541, 28107, 28199, 28203, 28111, 28108, 28200, 28204, 28112
38542, 28108, 28200, 28204, 28112, 28109, 28201, 28205, 28113
38543, 28109, 28201, 28205, 28113, 28110, 28202, 28206, 28114
38544, 28110, 28202, 28206, 28114, 11373, 11396, 11397, 11374
38545, 5906, 5929, 5930, 5907, 28111, 28203, 28207, 28115
38546, 28111, 28203, 28207, 28115, 28112, 28204, 28208, 28116
38547, 28112, 28204, 28208, 28116, 28113, 28205, 28209, 28117
38548, 28113, 28205, 28209, 28117, 28114, 28206, 28210, 28118
38549, 28114, 28206, 28210, 28118, 11374, 11397, 11398, 11375
38550, 5907, 5930, 768, 767, 28115, 28207, 11218, 11214
38551, 28115, 28207, 11218, 11214, 28116, 28208, 11219, 11215
38552, 28116, 28208, 11219, 11215, 28117, 28209, 11220, 11216
38553, 28117, 28209, 11220, 11216, 28118, 28210, 11221, 11217
38554, 28118, 28210, 11221, 11217, 11375, 11398, 1734, 1733
38555, 650, 651, 5931, 5908, 10946, 10950, 28211, 28119
38556, 10946, 10950, 28211, 28119, 10947, 10951, 28212, 28120
38557, 10947, 10951, 28212, 28120, 10948, 10952, 28213, 28121
38558, 10948, 10952, 28213, 28121, 10949, 10953, 28214, 28122
38559, 10949, 10953, 28214, 28122, 1669, 1670, 11399, 11376
38560, 5908, 5931, 5932, 5909, 28119, 28211, 28215, 28123
38561, 28119, 28211, 28215, 28123, 28120, 28212, 28216, 28124
38562, 28120, 28212, 28216, 28124, 28121, 28213, 28217, 28125
38563, 28121, 28213, 28217, 28125, 28122, 28214, 28218, 28126
38564, 28122, 28214, 28218, 28126, 11376, 11399, 11400, 11377
38565, 5909, 5932, 5933, 5910, 28123, 28215, 28219, 28127
38566, 28123, 28215, 28219, 28127, 28124, 28216, 28220, 28128
38567, 28124, 28216, 28220, 28128, 28125, 28217, 28221, 28129
38568, 28125, 28217, 28221, 28129, 28126, 28218, 28222, 28130
38569, 28126, 28218, 28222, 28130, 11377, 11400, 11401, 11378
38570, 5910, 5933, 5934, 5911, 28127, 28219, 28223, 28131
38571, 28127, 28219, 28223, 28131, 28128, 28220, 28224, 28132
38572, 28128, 28220, 28224, 28132, 28129, 28221, 28225, 28133
38573, 28129, 28221, 28225, 28133, 28130, 28222, 28226, 28134
38574, 28130, 28222, 28226, 28134, 11378, 11401, 11402, 11379
38575, 5911, 5934, 5935, 5912, 28131, 28223, 28227, 28135
38576, 28131, 28223, 28227, 28135, 28132, 28224, 28228, 28136
38577, 28132, 28224, 28228, 28136, 28133, 28225, 28229, 28137
38578, 28133, 28225, 28229, 28137, 28134, 28226, 28230, 28138
38579, 28134, 28226, 28230, 28138, 11379, 11402, 11403, 11380
38580, 5912, 5935, 5936, 5913, 28135, 28227, 28231, 28139
38581, 28135, 28227, 28231, 28139, 28136, 28228, 28232, 28140
38582, 28136, 28228, 28232, 28140, 28137, 28229, 28233, 28141
38583, 28137, 28229, 28233, 28141, 28138, 28230, 28234, 28142
38584, 28138, 28230, 28234, 28142, 11380, 11403, 11404, 11381
38585, 5913, 5936, 5937, 5914, 28139, 28231, 28235, 28143
38586, 28139, 28231, 28235, 28143, 28140, 28232, 28236, 28144
38587, 28140, 28232, 28236, 28144, 28141, 28233, 28237, 28145
38588, 28141, 28233, 28237, 28145, 28142, 28234, 28238, 28146
38589, 28142, 28234, 28238, 28146, 11381, 11404, 11405, 11382
38590, 5914, 5937, 5938, 5915, 28143, 28235, 28239, 28147
38591, 28143, 28235, 28239, 28147, 28144, 28236, 28240, 28148
38592, 28144, 28236, 28240, 28148, 28145, 28237, 28241, 28149
38593, 28145, 28237, 28241, 28149, 28146, 28238, 28242, 28150
38594, 28146, 28238, 28242, 28150, 11382, 11405, 11406, 11383
38595, 5915, 5938, 5939, 5916, 28147, 28239, 28243, 28151
38596, 28147, 28239, 28243, 28151, 28148, 28240, 28244, 28152
38597, 28148, 28240, 28244, 28152, 28149, 28241, 28245, 28153
38598, 28149, 28241, 28245, 28153, 28150, 28242, 28246, 28154
38599, 28150, 28242, 28246, 28154, 11383, 11406, 11407, 11384
38600, 5916, 5939, 5940, 5917, 28151, 28243, 28247, 28155
38601, 28151, 28243, 28247, 28155, 28152, 28244, 28248, 28156
38602, 28152, 28244, 28248, 28156, 28153, 28245, 28249, 28157
38603, 28153, 28245, 28249, 28157, 28154, 28246, 28250, 28158
38604, 28154, 28246, 28250, 28158, 11384, 11407, 11408, 11385
38605, 5917, 5940, 5941, 5918, 28155, 28247, 28251, 28159
38606, 28155, 28247, 28251, 28159, 28156, 28248, 28252, 28160
38607, 28156, 28248, 28252, 28160, 28157, 28249, 28253, 28161
38608, 28157, 28249, 28253, 28161, 28158, 28250, 28254, 28162
38609, 28158, 28250, 28254, 28162, 11385, 11408, 11409, 11386
38610, 5918, 5941, 5942, 5919, 28159, 28251, 28255, 28163
38611, 28159, 28251, 28255, 28163, 28160, 28252, 28256, 28164
38612, 28160, 28252, 28256, 28164, 28161, 28253, 28257, 28165
38613, 28161, 28253, 28257, 28165, 28162, 28254, 28258, 28166
38614, 28162, 28254, 28258, 28166, 11386, 11409, 11410, 11387
38615, 5919, 5942, 5943, 5920, 28163, 28255, 28259, 28167
38616, 28163, 28255, 28259, 28167, 28164, 28256, 28260, 28168
38617, 28164, 28256, 28260, 28168, 28165, 28257, 28261, 28169
38618, 28165, 28257, 28261, 28169, 28166, 28258, 28262, 28170
38619, 28166, 28258, 28262, 28170, 11387, 11410, 11411, 11388
38620, 5920, 5943, 5944, 5921, 28167, 28259, 28263, 28171
38621, 28167, 28259, 28263, 28171, 28168, 28260, 28264, 28172
38622, 28168, 28260, 28264, 28172, 28169, 28261, 28265, 28173
38623, 28169, 28261, 28265, 28173, 28170, 28262, 28266, 28174
38624, 28170, 28262, 28266, 28174, 11388, 11411, 11412, 11389
38625, 5921, 5944, 5945, 5922, 28171, 28263, 28267, 28175
38626, 28171, 28263, 28267, 28175, 28172, 28264, 28268, 28176
38627, 28172, 28264, 28268, 28176, 28173, 28265, 28269, 28177
38628, 28173, 28265, 28269, 28177, 28174, 28266, 28270, 28178
38629, 28174, 28266, 28270, 28178, 11389, 11412, 11413, 11390
38630, 5922, 5945, 5946, 5923, 28175, 28267, 28271, 28179
38631, 28175, 28267, 28271, 28179, 28176, 28268, 28272, 28180
38632, 28176, 28268, 28272, 28180, 28177, 28269, 28273, 28181
38633, 28177, 28269, 28273, 28181, 28178, 28270, 28274, 28182
38634, 28178, 28270, 28274, 28182, 11390, 11413, 11414, 11391
38635, 5923, 5946, 5947, 5924, 28179, 28271, 28275, 28183
38636, 28179, 28271, 28275, 28183, 28180, 28272, 28276, 28184
38637, 28180, 28272, 28276, 28184, 28181, 28273, 28277, 28185
38638, 28181, 28273, 28277, 28185, 28182, 28274, 28278, 28186
38639, 28182, 28274, 28278, 28186, 11391, 11414, 11415, 11392
38640, 5924, 5947, 5948, 5925, 28183, 28275, 28279, 28187
38641, 28183, 28275, 28279, 28187, 28184, 28276, 28280, 28188
38642, 28184, 28276, 28280, 28188, 28185, 28277, 28281, 28189
38643, 28185, 28277, 28281, 28189, 28186, 28278, 28282, 28190
38644, 28186, 28278, 28282, 28190, 11392, 11415, 11416, 11393
38645, 5925, 5948, 5949, 5926, 28187, 28279, 28283, 28191
38646, 28187, 28279, 28283, 28191, 28188, 28280, 28284, 28192
38647, 28188, 28280, 28284, 28192, 28189, 28281, 28285, 28193
38648, 28189, 28281, 28285, 28193, 28190, 28282, 28286, 28194
38649, 28190, 28282, 28286, 28194, 11393, 11416, 11417, 11394
38650, 5926, 5949, 5950, 5927, 28191, 28283, 28287, 28195
38651, 28191, 28283, 28287, 28195, 28192, 28284, 28288, 28196
38652, 28192, 28284, 28288, 28196, 28193, 28285, 28289, 28197
38653, 28193, 28285, 28289, 28197, 28194, 28286, 28290, 28198
38654, 28194, 28286, 28290, 28198, 11394, 11417, 11418, 11395
38655, 5927, 5950, 5951, 5928, 28195, 28287, 28291, 28199
38656, 28195, 28287, 28291, 28199, 28196, 28288, 28292, 28200
38657, 28196, 28288, 28292, 28200, 28197, 28289, 28293, 28201
38658, 28197, 28289, 28293, 28201, 28198, 28290, 28294, 28202
38659, 28198, 28290, 28294, 28202, 11395, 11418, 11419, 11396
38660, 5928, 5951, 5952, 5929, 28199, 28291, 28295, 28203
38661, 28199, 28291, 28295, 28203, 28200, 28292, 28296, 28204
38662, 28200, 28292, 28296, 28204, 28201, 28293, 28297, 28205
38663, 28201, 28293, 28297, 28205, 28202, 28294, 28298, 28206
38664, 28202, 28294, 28298, 28206, 11396, 11419, 11420, 11397
38665, 5929, 5952, 5953, 5930, 28203, 28295, 28299, 28207
38666, 28203, 28295, 28299, 28207, 28204, 28296, 28300, 28208
38667, 28204, 28296, 28300, 28208, 28205, 28297, 28301, 28209
38668, 28205, 28297, 28301, 28209, 28206, 28298, 28302, 28210
38669, 28206, 28298, 28302, 28210, 11397, 11420, 11421, 11398
38670, 5930, 5953, 769, 768, 28207, 28299, 11222, 11218
38671, 28207, 28299, 11222, 11218, 28208, 28300, 11223, 11219
38672, 28208, 28300, 11223, 11219, 28209, 28301, 11224, 11220
38673, 28209, 28301, 11224, 11220, 28210, 28302, 11225, 11221
38674, 28210, 28302, 11225, 11221, 11398, 11421, 1735, 1734
38675, 651, 652, 5954, 5931, 10950, 10954, 28303, 28211
38676, 10950, 10954, 28303, 28211, 10951, 10955, 28304, 28212
38677, 10951, 10955, 28304, 28212, 10952, 10956, 28305, 28213
38678, 10952, 10956, 28305, 28213, 10953, 10957, 28306, 28214
38679, 10953, 10957, 28306, 28214, 1670, 1671, 11422, 11399
38680, 5931, 5954, 5955, 5932, 28211, 28303, 28307, 28215
38681, 28211, 28303, 28307, 28215, 28212, 28304, 28308, 28216
