*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_24x24x12el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 1.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0.5
47, 1.2, -1.2490009027033e-16, 0
48, 2.2, -1.2490009027033e-16, 0
49, 2.3, 0.1, 0.5
50, 2.3, -1.2490009027033e-16, 0.5
51, 2.3, 0.1, 0
52, 2.3, -1.2490009027033e-16, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.1, 0.5
56, -0.1, 0.1, 0
57, 1.05, 0.15, 0.5
58, 1.05, 1.35, 0.5
59, 1.05, 0.15, 0
60, 1.05, 1.35, 0
61, 1.15, 1.35, 0.5
62, 1.15, 0.15, 0.5
63, 1.15, 1.35, 0
64, 1.15, 0.15, 0
65, 1, 0.15, -0.1
66, 1, 1.35, -0.1
67, 0, 0.15, -0.1
68, 0, 1.35, -0.1
69, 1.2, 1.35, -0.1
70, 1.2, 0.15, -0.1
71, 2.2, 1.35, -0.1
72, 2.2, 0.15, -0.1
73, 1.15, 1.35, -0.1
74, 1.15, 0.15, -0.1
75, 1.05, 0.15, -0.1
76, 1.05, 1.35, -0.1
77, 1, 1.7, 0
78, 0, 1.7, 0
79, 1, 1.7, 0.5
80, 0, 1.7, 0.5
81, 1.2, 1.7, 0.5
82, 1.2, 1.7, 0
83, 2.2, 1.7, 0.5
84, 2.2, 1.7, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.041666666666667
98, 0, 0, 0.083333333333333
99, 0, 0, 0.125
100, 0, 0, 0.16666666666667
101, 0, 0, 0.20833333333333
102, 0, 0, 0.25
103, 0, 0, 0.29166666666667
104, 0, 0, 0.33333333333333
105, 0, 0, 0.375
106, 0, 0, 0.41666666666667
107, 0, 0, 0.45833333333333
108, 0, 0.033333333333333, 0.5
109, 0, 0.066666666666667, 0.5
110, 0, 0.1, 0.041666666666667
111, 0, 0.1, 0.083333333333333
112, 0, 0.1, 0.125
113, 0, 0.1, 0.16666666666667
114, 0, 0.1, 0.20833333333333
115, 0, 0.1, 0.25
116, 0, 0.1, 0.29166666666667
117, 0, 0.1, 0.33333333333333
118, 0, 0.1, 0.375
119, 0, 0.1, 0.41666666666667
120, 0, 0.1, 0.45833333333333
121, 0, 0.033333333333333, 0
122, 0, 0.066666666666667, 0
123, 1, 0, 0.041666666666667
124, 1, 0, 0.083333333333333
125, 1, 0, 0.125
126, 1, 0, 0.16666666666667
127, 1, 0, 0.20833333333333
128, 1, 0, 0.25
129, 1, 0, 0.29166666666667
130, 1, 0, 0.33333333333333
131, 1, 0, 0.375
132, 1, 0, 0.41666666666667
133, 1, 0, 0.45833333333333
134, 1, 0.033333333333333, 0.5
135, 1, 0.066666666666667, 0.5
136, 1, 0.1, 0.041666666666667
137, 1, 0.1, 0.083333333333333
138, 1, 0.1, 0.125
139, 1, 0.1, 0.16666666666667
140, 1, 0.1, 0.20833333333333
141, 1, 0.1, 0.25
142, 1, 0.1, 0.29166666666667
143, 1, 0.1, 0.33333333333333
144, 1, 0.1, 0.375
145, 1, 0.1, 0.41666666666667
146, 1, 0.1, 0.45833333333333
147, 1, 0.033333333333333, 0
148, 1, 0.066666666666667, 0
149, 0.041666666666667, 0, 0
150, 0.083333333333333, 0, 0
151, 0.125, 0, 0
152, 0.16666666666667, 0, 0
153, 0.20833333333333, 0, 0
154, 0.25, 0, 0
155, 0.29166666666667, 0, 0
156, 0.33333333333333, 0, 0
157, 0.375, 0, 0
158, 0.41666666666667, 0, 0
159, 0.45833333333333, 0, 0
160, 0.5, 0, 0
161, 0.54166666666667, 0, 0
162, 0.58333333333333, 0, 0
163, 0.625, 0, 0
164, 0.66666666666667, 0, 0
165, 0.70833333333333, 0, 0
166, 0.75, 0, 0
167, 0.79166666666667, 0, 0
168, 0.83333333333333, 0, 0
169, 0.875, 0, 0
170, 0.91666666666667, 0, 0
171, 0.95833333333333, 0, 0
172, 0.041666666666667, 0, 0.5
173, 0.083333333333333, 0, 0.5
174, 0.125, 0, 0.5
175, 0.16666666666667, 0, 0.5
176, 0.20833333333333, 0, 0.5
177, 0.25, 0, 0.5
178, 0.29166666666667, 0, 0.5
179, 0.33333333333333, 0, 0.5
180, 0.375, 0, 0.5
181, 0.41666666666667, 0, 0.5
182, 0.45833333333333, 0, 0.5
183, 0.5, 0, 0.5
184, 0.54166666666667, 0, 0.5
185, 0.58333333333333, 0, 0.5
186, 0.625, 0, 0.5
187, 0.66666666666667, 0, 0.5
188, 0.70833333333333, 0, 0.5
189, 0.75, 0, 0.5
190, 0.79166666666667, 0, 0.5
191, 0.83333333333333, 0, 0.5
192, 0.875, 0, 0.5
193, 0.91666666666667, 0, 0.5
194, 0.95833333333333, 0, 0.5
195, 0.041666666666667, 0.1, 0
196, 0.083333333333333, 0.1, 0
197, 0.125, 0.1, 0
198, 0.16666666666667, 0.1, 0
199, 0.20833333333333, 0.1, 0
200, 0.25, 0.1, 0
201, 0.29166666666667, 0.1, 0
202, 0.33333333333333, 0.1, 0
203, 0.375, 0.1, 0
204, 0.41666666666667, 0.1, 0
205, 0.45833333333333, 0.1, 0
206, 0.5, 0.1, 0
207, 0.54166666666667, 0.1, 0
208, 0.58333333333333, 0.1, 0
209, 0.625, 0.1, 0
210, 0.66666666666667, 0.1, 0
211, 0.70833333333333, 0.1, 0
212, 0.75, 0.1, 0
213, 0.79166666666667, 0.1, 0
214, 0.83333333333333, 0.1, 0
215, 0.875, 0.1, 0
216, 0.91666666666667, 0.1, 0
217, 0.95833333333333, 0.1, 0
218, 0.041666666666667, 0.1, 0.5
219, 0.083333333333333, 0.1, 0.5
220, 0.125, 0.1, 0.5
221, 0.16666666666667, 0.1, 0.5
222, 0.20833333333333, 0.1, 0.5
223, 0.25, 0.1, 0.5
224, 0.29166666666667, 0.1, 0.5
225, 0.33333333333333, 0.1, 0.5
226, 0.375, 0.1, 0.5
227, 0.41666666666667, 0.1, 0.5
228, 0.45833333333333, 0.1, 0.5
229, 0.5, 0.1, 0.5
230, 0.54166666666667, 0.1, 0.5
231, 0.58333333333333, 0.1, 0.5
232, 0.625, 0.1, 0.5
233, 0.66666666666667, 0.1, 0.5
234, 0.70833333333333, 0.1, 0.5
235, 0.75, 0.1, 0.5
236, 0.79166666666667, 0.1, 0.5
237, 0.83333333333333, 0.1, 0.5
238, 0.875, 0.1, 0.5
239, 0.91666666666667, 0.1, 0.5
240, 0.95833333333333, 0.1, 0.5
241, 0.041666666666667, 0.15, 0
242, 0.083333333333333, 0.15, 0
243, 0.125, 0.15, 0
244, 0.16666666666667, 0.15, 0
245, 0.20833333333333, 0.15, 0
246, 0.25, 0.15, 0
247, 0.29166666666667, 0.15, 0
248, 0.33333333333333, 0.15, 0
249, 0.375, 0.15, 0
250, 0.41666666666667, 0.15, 0
251, 0.45833333333333, 0.15, 0
252, 0.5, 0.15, 0
253, 0.54166666666667, 0.15, 0
254, 0.58333333333333, 0.15, 0
255, 0.625, 0.15, 0
256, 0.66666666666667, 0.15, 0
257, 0.70833333333333, 0.15, 0
258, 0.75, 0.15, 0
259, 0.79166666666667, 0.15, 0
260, 0.83333333333333, 0.15, 0
261, 0.875, 0.15, 0
262, 0.91666666666667, 0.15, 0
263, 0.95833333333333, 0.15, 0
264, 1, 0.15, 0.041666666666667
265, 1, 0.15, 0.083333333333333
266, 1, 0.15, 0.125
267, 1, 0.15, 0.16666666666667
268, 1, 0.15, 0.20833333333333
269, 1, 0.15, 0.25
270, 1, 0.15, 0.29166666666667
271, 1, 0.15, 0.33333333333333
272, 1, 0.15, 0.375
273, 1, 0.15, 0.41666666666667
274, 1, 0.15, 0.45833333333333
275, 0.041666666666667, 0.15, 0.5
276, 0.083333333333333, 0.15, 0.5
277, 0.125, 0.15, 0.5
278, 0.16666666666667, 0.15, 0.5
279, 0.20833333333333, 0.15, 0.5
280, 0.25, 0.15, 0.5
281, 0.29166666666667, 0.15, 0.5
282, 0.33333333333333, 0.15, 0.5
283, 0.375, 0.15, 0.5
284, 0.41666666666667, 0.15, 0.5
285, 0.45833333333333, 0.15, 0.5
286, 0.5, 0.15, 0.5
287, 0.54166666666667, 0.15, 0.5
288, 0.58333333333333, 0.15, 0.5
289, 0.625, 0.15, 0.5
290, 0.66666666666667, 0.15, 0.5
291, 0.70833333333333, 0.15, 0.5
292, 0.75, 0.15, 0.5
293, 0.79166666666667, 0.15, 0.5
294, 0.83333333333333, 0.15, 0.5
295, 0.875, 0.15, 0.5
296, 0.91666666666667, 0.15, 0.5
297, 0.95833333333333, 0.15, 0.5
298, 0, 0.15, 0.041666666666667
299, 0, 0.15, 0.083333333333333
300, 0, 0.15, 0.125
301, 0, 0.15, 0.16666666666667
302, 0, 0.15, 0.20833333333333
303, 0, 0.15, 0.25
304, 0, 0.15, 0.29166666666667
305, 0, 0.15, 0.33333333333333
306, 0, 0.15, 0.375
307, 0, 0.15, 0.41666666666667
308, 0, 0.15, 0.45833333333333
309, 1, 0.2, 0
310, 1, 0.25, 0
311, 1, 0.3, 0
312, 1, 0.35, 0
313, 1, 0.4, 0
314, 1, 0.45, 0
315, 1, 0.5, 0
316, 1, 0.55, 0
317, 1, 0.6, 0
318, 1, 0.65, 0
319, 1, 0.7, 0
320, 1, 0.75, 0
321, 1, 0.8, 0
322, 1, 0.85, 0
323, 1, 0.9, 0
324, 1, 0.95, 0
325, 1, 1, 0
326, 1, 1.05, 0
327, 1, 1.1, 0
328, 1, 1.15, 0
329, 1, 1.2, 0
330, 1, 1.25, 0
331, 1, 1.3, 0
332, 0, 0.2, 0
333, 0, 0.25, 0
334, 0, 0.3, 0
335, 0, 0.35, 0
336, 0, 0.4, 0
337, 0, 0.45, 0
338, 0, 0.5, 0
339, 0, 0.55, 0
340, 0, 0.6, 0
341, 0, 0.65, 0
342, 0, 0.7, 0
343, 0, 0.75, 0
344, 0, 0.8, 0
345, 0, 0.85, 0
346, 0, 0.9, 0
347, 0, 0.95, 0
348, 0, 1, 0
349, 0, 1.05, 0
350, 0, 1.1, 0
351, 0, 1.15, 0
352, 0, 1.2, 0
353, 0, 1.25, 0
354, 0, 1.3, 0
355, 0.041666666666667, 1.35, 0
356, 0.083333333333333, 1.35, 0
357, 0.125, 1.35, 0
358, 0.16666666666667, 1.35, 0
359, 0.20833333333333, 1.35, 0
360, 0.25, 1.35, 0
361, 0.29166666666667, 1.35, 0
362, 0.33333333333333, 1.35, 0
363, 0.375, 1.35, 0
364, 0.41666666666667, 1.35, 0
365, 0.45833333333333, 1.35, 0
366, 0.5, 1.35, 0
367, 0.54166666666667, 1.35, 0
368, 0.58333333333333, 1.35, 0
369, 0.625, 1.35, 0
370, 0.66666666666667, 1.35, 0
371, 0.70833333333333, 1.35, 0
372, 0.75, 1.35, 0
373, 0.79166666666667, 1.35, 0
374, 0.83333333333333, 1.35, 0
375, 0.875, 1.35, 0
376, 0.91666666666667, 1.35, 0
377, 0.95833333333333, 1.35, 0
378, 1, 0.2, 0.5
379, 1, 0.25, 0.5
380, 1, 0.3, 0.5
381, 1, 0.35, 0.5
382, 1, 0.4, 0.5
383, 1, 0.45, 0.5
384, 1, 0.5, 0.5
385, 1, 0.55, 0.5
386, 1, 0.6, 0.5
387, 1, 0.65, 0.5
388, 1, 0.7, 0.5
389, 1, 0.75, 0.5
390, 1, 0.8, 0.5
391, 1, 0.85, 0.5
392, 1, 0.9, 0.5
393, 1, 0.95, 0.5
394, 1, 1, 0.5
395, 1, 1.05, 0.5
396, 1, 1.1, 0.5
397, 1, 1.15, 0.5
398, 1, 1.2, 0.5
399, 1, 1.25, 0.5
400, 1, 1.3, 0.5
401, 1, 1.35, 0.041666666666667
402, 1, 1.35, 0.083333333333333
403, 1, 1.35, 0.125
404, 1, 1.35, 0.16666666666667
405, 1, 1.35, 0.20833333333333
406, 1, 1.35, 0.25
407, 1, 1.35, 0.29166666666667
408, 1, 1.35, 0.33333333333333
409, 1, 1.35, 0.375
410, 1, 1.35, 0.41666666666667
411, 1, 1.35, 0.45833333333333
412, 0, 0.2, 0.5
413, 0, 0.25, 0.5
414, 0, 0.3, 0.5
415, 0, 0.35, 0.5
416, 0, 0.4, 0.5
417, 0, 0.45, 0.5
418, 0, 0.5, 0.5
419, 0, 0.55, 0.5
420, 0, 0.6, 0.5
421, 0, 0.65, 0.5
422, 0, 0.7, 0.5
423, 0, 0.75, 0.5
424, 0, 0.8, 0.5
425, 0, 0.85, 0.5
426, 0, 0.9, 0.5
427, 0, 0.95, 0.5
428, 0, 1, 0.5
429, 0, 1.05, 0.5
430, 0, 1.1, 0.5
431, 0, 1.15, 0.5
432, 0, 1.2, 0.5
433, 0, 1.25, 0.5
434, 0, 1.3, 0.5
435, 0.041666666666667, 1.35, 0.5
436, 0.083333333333333, 1.35, 0.5
437, 0.125, 1.35, 0.5
438, 0.16666666666667, 1.35, 0.5
439, 0.20833333333333, 1.35, 0.5
440, 0.25, 1.35, 0.5
441, 0.29166666666667, 1.35, 0.5
442, 0.33333333333333, 1.35, 0.5
443, 0.375, 1.35, 0.5
444, 0.41666666666667, 1.35, 0.5
445, 0.45833333333333, 1.35, 0.5
446, 0.5, 1.35, 0.5
447, 0.54166666666667, 1.35, 0.5
448, 0.58333333333333, 1.35, 0.5
449, 0.625, 1.35, 0.5
450, 0.66666666666667, 1.35, 0.5
451, 0.70833333333333, 1.35, 0.5
452, 0.75, 1.35, 0.5
453, 0.79166666666667, 1.35, 0.5
454, 0.83333333333333, 1.35, 0.5
455, 0.875, 1.35, 0.5
456, 0.91666666666667, 1.35, 0.5
457, 0.95833333333333, 1.35, 0.5
458, 0, 1.35, 0.041666666666667
459, 0, 1.35, 0.083333333333333
460, 0, 1.35, 0.125
461, 0, 1.35, 0.16666666666667
462, 0, 1.35, 0.20833333333333
463, 0, 1.35, 0.25
464, 0, 1.35, 0.29166666666667
465, 0, 1.35, 0.33333333333333
466, 0, 1.35, 0.375
467, 0, 1.35, 0.41666666666667
468, 0, 1.35, 0.45833333333333
469, 0.041666666666667, 1.4, 0
470, 0.083333333333333, 1.4, 0
471, 0.125, 1.4, 0
472, 0.16666666666667, 1.4, 0
473, 0.20833333333333, 1.4, 0
474, 0.25, 1.4, 0
475, 0.29166666666667, 1.4, 0
476, 0.33333333333333, 1.4, 0
477, 0.375, 1.4, 0
478, 0.41666666666667, 1.4, 0
479, 0.45833333333333, 1.4, 0
480, 0.5, 1.4, 0
481, 0.54166666666667, 1.4, 0
482, 0.58333333333333, 1.4, 0
483, 0.625, 1.4, 0
484, 0.66666666666667, 1.4, 0
485, 0.70833333333333, 1.4, 0
486, 0.75, 1.4, 0
487, 0.79166666666667, 1.4, 0
488, 0.83333333333333, 1.4, 0
489, 0.875, 1.4, 0
490, 0.91666666666667, 1.4, 0
491, 0.95833333333333, 1.4, 0
492, 1, 1.4, 0.041666666666667
493, 1, 1.4, 0.083333333333333
494, 1, 1.4, 0.125
495, 1, 1.4, 0.16666666666667
496, 1, 1.4, 0.20833333333333
497, 1, 1.4, 0.25
498, 1, 1.4, 0.29166666666667
499, 1, 1.4, 0.33333333333333
500, 1, 1.4, 0.375
501, 1, 1.4, 0.41666666666667
502, 1, 1.4, 0.45833333333333
503, 0.041666666666667, 1.4, 0.5
504, 0.083333333333333, 1.4, 0.5
505, 0.125, 1.4, 0.5
506, 0.16666666666667, 1.4, 0.5
507, 0.20833333333333, 1.4, 0.5
508, 0.25, 1.4, 0.5
509, 0.29166666666667, 1.4, 0.5
510, 0.33333333333333, 1.4, 0.5
511, 0.375, 1.4, 0.5
512, 0.41666666666667, 1.4, 0.5
513, 0.45833333333333, 1.4, 0.5
514, 0.5, 1.4, 0.5
515, 0.54166666666667, 1.4, 0.5
516, 0.58333333333333, 1.4, 0.5
517, 0.625, 1.4, 0.5
518, 0.66666666666667, 1.4, 0.5
519, 0.70833333333333, 1.4, 0.5
520, 0.75, 1.4, 0.5
521, 0.79166666666667, 1.4, 0.5
522, 0.83333333333333, 1.4, 0.5
523, 0.875, 1.4, 0.5
524, 0.91666666666667, 1.4, 0.5
525, 0.95833333333333, 1.4, 0.5
526, 0, 1.4, 0.041666666666667
527, 0, 1.4, 0.083333333333333
528, 0, 1.4, 0.125
529, 0, 1.4, 0.16666666666667
530, 0, 1.4, 0.20833333333333
531, 0, 1.4, 0.25
532, 0, 1.4, 0.29166666666667
533, 0, 1.4, 0.33333333333333
534, 0, 1.4, 0.375
535, 0, 1.4, 0.41666666666667
536, 0, 1.4, 0.45833333333333
537, 1, 1.4333333333333, 0
538, 1, 1.4666666666667, 0
539, 0, 1.4333333333333, 0
540, 0, 1.4666666666667, 0
541, 0.041666666666667, 1.5, 0
542, 0.083333333333333, 1.5, 0
543, 0.125, 1.5, 0
544, 0.16666666666667, 1.5, 0
545, 0.20833333333333, 1.5, 0
546, 0.25, 1.5, 0
547, 0.29166666666667, 1.5, 0
548, 0.33333333333333, 1.5, 0
549, 0.375, 1.5, 0
550, 0.41666666666667, 1.5, 0
551, 0.45833333333333, 1.5, 0
552, 0.5, 1.5, 0
553, 0.54166666666667, 1.5, 0
554, 0.58333333333333, 1.5, 0
555, 0.625, 1.5, 0
556, 0.66666666666667, 1.5, 0
557, 0.70833333333333, 1.5, 0
558, 0.75, 1.5, 0
559, 0.79166666666667, 1.5, 0
560, 0.83333333333333, 1.5, 0
561, 0.875, 1.5, 0
562, 0.91666666666667, 1.5, 0
563, 0.95833333333333, 1.5, 0
564, 1, 1.4333333333333, 0.5
565, 1, 1.4666666666667, 0.5
566, 1, 1.5, 0.041666666666667
567, 1, 1.5, 0.083333333333333
568, 1, 1.5, 0.125
569, 1, 1.5, 0.16666666666667
570, 1, 1.5, 0.20833333333333
571, 1, 1.5, 0.25
572, 1, 1.5, 0.29166666666667
573, 1, 1.5, 0.33333333333333
574, 1, 1.5, 0.375
575, 1, 1.5, 0.41666666666667
576, 1, 1.5, 0.45833333333333
577, 0, 1.4333333333333, 0.5
578, 0, 1.4666666666667, 0.5
579, 0.041666666666667, 1.5, 0.5
580, 0.083333333333333, 1.5, 0.5
581, 0.125, 1.5, 0.5
582, 0.16666666666667, 1.5, 0.5
583, 0.20833333333333, 1.5, 0.5
584, 0.25, 1.5, 0.5
585, 0.29166666666667, 1.5, 0.5
586, 0.33333333333333, 1.5, 0.5
587, 0.375, 1.5, 0.5
588, 0.41666666666667, 1.5, 0.5
589, 0.45833333333333, 1.5, 0.5
590, 0.5, 1.5, 0.5
591, 0.54166666666667, 1.5, 0.5
592, 0.58333333333333, 1.5, 0.5
593, 0.625, 1.5, 0.5
594, 0.66666666666667, 1.5, 0.5
595, 0.70833333333333, 1.5, 0.5
596, 0.75, 1.5, 0.5
597, 0.79166666666667, 1.5, 0.5
598, 0.83333333333333, 1.5, 0.5
599, 0.875, 1.5, 0.5
600, 0.91666666666667, 1.5, 0.5
601, 0.95833333333333, 1.5, 0.5
602, 0, 1.5, 0.041666666666667
603, 0, 1.5, 0.083333333333333
604, 0, 1.5, 0.125
605, 0, 1.5, 0.16666666666667
606, 0, 1.5, 0.20833333333333
607, 0, 1.5, 0.25
608, 0, 1.5, 0.29166666666667
609, 0, 1.5, 0.33333333333333
610, 0, 1.5, 0.375
611, 0, 1.5, 0.41666666666667
612, 0, 1.5, 0.45833333333333
613, 1.04, 1.4, 0.5
614, 1.08, 1.4, 0.5
615, 1.12, 1.4, 0.5
616, 1.16, 1.4, 0.5
617, 1.04, 1.5, 0.5
618, 1.08, 1.5, 0.5
619, 1.12, 1.5, 0.5
620, 1.16, 1.5, 0.5
621, 1.2, 1.4333333333333, 0.5
622, 1.2, 1.4666666666667, 0.5
623, 1.04, 1.4, 0
624, 1.08, 1.4, 0
625, 1.12, 1.4, 0
626, 1.16, 1.4, 0
627, 1.04, 1.5, 0
628, 1.08, 1.5, 0
629, 1.12, 1.5, 0
630, 1.16, 1.5, 0
631, 1.2, 1.4333333333333, 0
632, 1.2, 1.4666666666667, 0
633, 1.2, 1.4, 0.041666666666667
634, 1.2, 1.4, 0.083333333333333
635, 1.2, 1.4, 0.125
636, 1.2, 1.4, 0.16666666666667
637, 1.2, 1.4, 0.20833333333333
638, 1.2, 1.4, 0.25
639, 1.2, 1.4, 0.29166666666667
640, 1.2, 1.4, 0.33333333333333
641, 1.2, 1.4, 0.375
642, 1.2, 1.4, 0.41666666666667
643, 1.2, 1.4, 0.45833333333333
644, 1.2, 1.5, 0.041666666666667
645, 1.2, 1.5, 0.083333333333333
646, 1.2, 1.5, 0.125
647, 1.2, 1.5, 0.16666666666667
648, 1.2, 1.5, 0.20833333333333
649, 1.2, 1.5, 0.25
650, 1.2, 1.5, 0.29166666666667
651, 1.2, 1.5, 0.33333333333333
652, 1.2, 1.5, 0.375
653, 1.2, 1.5, 0.41666666666667
654, 1.2, 1.5, 0.45833333333333
655, 1.2416666666667, 1.4, 0.5
656, 1.2833333333333, 1.4, 0.5
657, 1.325, 1.4, 0.5
658, 1.3666666666667, 1.4, 0.5
659, 1.4083333333333, 1.4, 0.5
660, 1.45, 1.4, 0.5
661, 1.4916666666667, 1.4, 0.5
662, 1.5333333333333, 1.4, 0.5
663, 1.575, 1.4, 0.5
664, 1.6166666666667, 1.4, 0.5
665, 1.6583333333333, 1.4, 0.5
666, 1.7, 1.4, 0.5
667, 1.7416666666667, 1.4, 0.5
668, 1.7833333333333, 1.4, 0.5
669, 1.825, 1.4, 0.5
670, 1.8666666666667, 1.4, 0.5
671, 1.9083333333333, 1.4, 0.5
672, 1.95, 1.4, 0.5
673, 1.9916666666667, 1.4, 0.5
674, 2.0333333333333, 1.4, 0.5
675, 2.075, 1.4, 0.5
676, 2.1166666666667, 1.4, 0.5
677, 2.1583333333333, 1.4, 0.5
678, 1.2416666666667, 1.5, 0.5
679, 1.2833333333333, 1.5, 0.5
680, 1.325, 1.5, 0.5
681, 1.3666666666667, 1.5, 0.5
682, 1.4083333333333, 1.5, 0.5
683, 1.45, 1.5, 0.5
684, 1.4916666666667, 1.5, 0.5
685, 1.5333333333333, 1.5, 0.5
686, 1.575, 1.5, 0.5
687, 1.6166666666667, 1.5, 0.5
688, 1.6583333333333, 1.5, 0.5
689, 1.7, 1.5, 0.5
690, 1.7416666666667, 1.5, 0.5
691, 1.7833333333333, 1.5, 0.5
692, 1.825, 1.5, 0.5
693, 1.8666666666667, 1.5, 0.5
694, 1.9083333333333, 1.5, 0.5
695, 1.95, 1.5, 0.5
696, 1.9916666666667, 1.5, 0.5
697, 2.0333333333333, 1.5, 0.5
698, 2.075, 1.5, 0.5
699, 2.1166666666667, 1.5, 0.5
700, 2.1583333333333, 1.5, 0.5
701, 2.2, 1.4333333333333, 0.5
702, 2.2, 1.4666666666667, 0.5
703, 1.2416666666667, 1.4, 0
704, 1.2833333333333, 1.4, 0
705, 1.325, 1.4, 0
706, 1.3666666666667, 1.4, 0
707, 1.4083333333333, 1.4, 0
708, 1.45, 1.4, 0
709, 1.4916666666667, 1.4, 0
710, 1.5333333333333, 1.4, 0
711, 1.575, 1.4, 0
712, 1.6166666666667, 1.4, 0
713, 1.6583333333333, 1.4, 0
714, 1.7, 1.4, 0
715, 1.7416666666667, 1.4, 0
716, 1.7833333333333, 1.4, 0
717, 1.825, 1.4, 0
718, 1.8666666666667, 1.4, 0
719, 1.9083333333333, 1.4, 0
720, 1.95, 1.4, 0
721, 1.9916666666667, 1.4, 0
722, 2.0333333333333, 1.4, 0
723, 2.075, 1.4, 0
724, 2.1166666666667, 1.4, 0
725, 2.1583333333333, 1.4, 0
726, 1.2416666666667, 1.5, 0
727, 1.2833333333333, 1.5, 0
728, 1.325, 1.5, 0
729, 1.3666666666667, 1.5, 0
730, 1.4083333333333, 1.5, 0
731, 1.45, 1.5, 0
732, 1.4916666666667, 1.5, 0
733, 1.5333333333333, 1.5, 0
734, 1.575, 1.5, 0
735, 1.6166666666667, 1.5, 0
736, 1.6583333333333, 1.5, 0
737, 1.7, 1.5, 0
738, 1.7416666666667, 1.5, 0
739, 1.7833333333333, 1.5, 0
740, 1.825, 1.5, 0
741, 1.8666666666667, 1.5, 0
742, 1.9083333333333, 1.5, 0
743, 1.95, 1.5, 0
744, 1.9916666666667, 1.5, 0
745, 2.0333333333333, 1.5, 0
746, 2.075, 1.5, 0
747, 2.1166666666667, 1.5, 0
748, 2.1583333333333, 1.5, 0
749, 2.2, 1.4333333333333, 0
750, 2.2, 1.4666666666667, 0
751, 2.2, 1.4, 0.041666666666667
752, 2.2, 1.4, 0.083333333333333
753, 2.2, 1.4, 0.125
754, 2.2, 1.4, 0.16666666666667
755, 2.2, 1.4, 0.20833333333333
756, 2.2, 1.4, 0.25
757, 2.2, 1.4, 0.29166666666667
758, 2.2, 1.4, 0.33333333333333
759, 2.2, 1.4, 0.375
760, 2.2, 1.4, 0.41666666666667
761, 2.2, 1.4, 0.45833333333333
762, 2.2, 1.5, 0.041666666666667
763, 2.2, 1.5, 0.083333333333333
764, 2.2, 1.5, 0.125
765, 2.2, 1.5, 0.16666666666667
766, 2.2, 1.5, 0.20833333333333
767, 2.2, 1.5, 0.25
768, 2.2, 1.5, 0.29166666666667
769, 2.2, 1.5, 0.33333333333333
770, 2.2, 1.5, 0.375
771, 2.2, 1.5, 0.41666666666667
772, 2.2, 1.5, 0.45833333333333
773, 1.2416666666667, 1.35, 0.5
774, 1.2833333333333, 1.35, 0.5
775, 1.325, 1.35, 0.5
776, 1.3666666666667, 1.35, 0.5
777, 1.4083333333333, 1.35, 0.5
778, 1.45, 1.35, 0.5
779, 1.4916666666667, 1.35, 0.5
780, 1.5333333333333, 1.35, 0.5
781, 1.575, 1.35, 0.5
782, 1.6166666666667, 1.35, 0.5
783, 1.6583333333333, 1.35, 0.5
784, 1.7, 1.35, 0.5
785, 1.7416666666667, 1.35, 0.5
786, 1.7833333333333, 1.35, 0.5
787, 1.825, 1.35, 0.5
788, 1.8666666666667, 1.35, 0.5
789, 1.9083333333333, 1.35, 0.5
790, 1.95, 1.35, 0.5
791, 1.9916666666667, 1.35, 0.5
792, 2.0333333333333, 1.35, 0.5
793, 2.075, 1.35, 0.5
794, 2.1166666666667, 1.35, 0.5
795, 2.1583333333333, 1.35, 0.5
796, 1.2416666666667, 1.35, 0
797, 1.2833333333333, 1.35, 0
798, 1.325, 1.35, 0
799, 1.3666666666667, 1.35, 0
800, 1.4083333333333, 1.35, 0
801, 1.45, 1.35, 0
802, 1.4916666666667, 1.35, 0
803, 1.5333333333333, 1.35, 0
804, 1.575, 1.35, 0
805, 1.6166666666667, 1.35, 0
806, 1.6583333333333, 1.35, 0
807, 1.7, 1.35, 0
808, 1.7416666666667, 1.35, 0
809, 1.7833333333333, 1.35, 0
810, 1.825, 1.35, 0
811, 1.8666666666667, 1.35, 0
812, 1.9083333333333, 1.35, 0
813, 1.95, 1.35, 0
814, 1.9916666666667, 1.35, 0
815, 2.0333333333333, 1.35, 0
816, 2.075, 1.35, 0
817, 2.1166666666667, 1.35, 0
818, 2.1583333333333, 1.35, 0
819, 1.2, 1.35, 0.041666666666667
820, 1.2, 1.35, 0.083333333333333
821, 1.2, 1.35, 0.125
822, 1.2, 1.35, 0.16666666666667
823, 1.2, 1.35, 0.20833333333333
824, 1.2, 1.35, 0.25
825, 1.2, 1.35, 0.29166666666667
826, 1.2, 1.35, 0.33333333333333
827, 1.2, 1.35, 0.375
828, 1.2, 1.35, 0.41666666666667
829, 1.2, 1.35, 0.45833333333333
830, 2.2, 1.35, 0.041666666666667
831, 2.2, 1.35, 0.083333333333333
832, 2.2, 1.35, 0.125
833, 2.2, 1.35, 0.16666666666667
834, 2.2, 1.35, 0.20833333333333
835, 2.2, 1.35, 0.25
836, 2.2, 1.35, 0.29166666666667
837, 2.2, 1.35, 0.33333333333333
838, 2.2, 1.35, 0.375
839, 2.2, 1.35, 0.41666666666667
840, 2.2, 1.35, 0.45833333333333
841, 1.2, 1.3, 0.5
842, 1.2, 1.25, 0.5
843, 1.2, 1.2, 0.5
844, 1.2, 1.15, 0.5
845, 1.2, 1.1, 0.5
846, 1.2, 1.05, 0.5
847, 1.2, 1, 0.5
848, 1.2, 0.95, 0.5
849, 1.2, 0.9, 0.5
850, 1.2, 0.85, 0.5
851, 1.2, 0.8, 0.5
852, 1.2, 0.75, 0.5
853, 1.2, 0.7, 0.5
854, 1.2, 0.65, 0.5
855, 1.2, 0.6, 0.5
856, 1.2, 0.55, 0.5
857, 1.2, 0.5, 0.5
858, 1.2, 0.45, 0.5
859, 1.2, 0.4, 0.5
860, 1.2, 0.35, 0.5
861, 1.2, 0.3, 0.5
862, 1.2, 0.25, 0.5
863, 1.2, 0.2, 0.5
864, 2.2, 1.3, 0.5
865, 2.2, 1.25, 0.5
866, 2.2, 1.2, 0.5
867, 2.2, 1.15, 0.5
868, 2.2, 1.1, 0.5
869, 2.2, 1.05, 0.5
870, 2.2, 1, 0.5
871, 2.2, 0.95, 0.5
872, 2.2, 0.9, 0.5
873, 2.2, 0.85, 0.5
874, 2.2, 0.8, 0.5
875, 2.2, 0.75, 0.5
876, 2.2, 0.7, 0.5
877, 2.2, 0.65, 0.5
878, 2.2, 0.6, 0.5
879, 2.2, 0.55, 0.5
880, 2.2, 0.5, 0.5
881, 2.2, 0.45, 0.5
882, 2.2, 0.4, 0.5
883, 2.2, 0.35, 0.5
884, 2.2, 0.3, 0.5
885, 2.2, 0.25, 0.5
886, 2.2, 0.2, 0.5
887, 1.2416666666667, 0.15, 0.5
888, 1.2833333333333, 0.15, 0.5
889, 1.325, 0.15, 0.5
890, 1.3666666666667, 0.15, 0.5
891, 1.4083333333333, 0.15, 0.5
892, 1.45, 0.15, 0.5
893, 1.4916666666667, 0.15, 0.5
894, 1.5333333333333, 0.15, 0.5
895, 1.575, 0.15, 0.5
896, 1.6166666666667, 0.15, 0.5
897, 1.6583333333333, 0.15, 0.5
898, 1.7, 0.15, 0.5
899, 1.7416666666667, 0.15, 0.5
900, 1.7833333333333, 0.15, 0.5
901, 1.825, 0.15, 0.5
902, 1.8666666666667, 0.15, 0.5
903, 1.9083333333333, 0.15, 0.5
904, 1.95, 0.15, 0.5
905, 1.9916666666667, 0.15, 0.5
906, 2.0333333333333, 0.15, 0.5
907, 2.075, 0.15, 0.5
908, 2.1166666666667, 0.15, 0.5
909, 2.1583333333333, 0.15, 0.5
910, 1.2, 1.3, 0
911, 1.2, 1.25, 0
912, 1.2, 1.2, 0
913, 1.2, 1.15, 0
914, 1.2, 1.1, 0
915, 1.2, 1.05, 0
916, 1.2, 1, 0
917, 1.2, 0.95, 0
918, 1.2, 0.9, 0
919, 1.2, 0.85, 0
920, 1.2, 0.8, 0
921, 1.2, 0.75, 0
922, 1.2, 0.7, 0
923, 1.2, 0.65, 0
924, 1.2, 0.6, 0
925, 1.2, 0.55, 0
926, 1.2, 0.5, 0
927, 1.2, 0.45, 0
928, 1.2, 0.4, 0
929, 1.2, 0.35, 0
930, 1.2, 0.3, 0
931, 1.2, 0.25, 0
932, 1.2, 0.2, 0
933, 2.2, 1.3, 0
934, 2.2, 1.25, 0
935, 2.2, 1.2, 0
936, 2.2, 1.15, 0
937, 2.2, 1.1, 0
938, 2.2, 1.05, 0
939, 2.2, 1, 0
940, 2.2, 0.95, 0
941, 2.2, 0.9, 0
942, 2.2, 0.85, 0
943, 2.2, 0.8, 0
944, 2.2, 0.75, 0
945, 2.2, 0.7, 0
946, 2.2, 0.65, 0
947, 2.2, 0.6, 0
948, 2.2, 0.55, 0
949, 2.2, 0.5, 0
950, 2.2, 0.45, 0
951, 2.2, 0.4, 0
952, 2.2, 0.35, 0
953, 2.2, 0.3, 0
954, 2.2, 0.25, 0
955, 2.2, 0.2, 0
956, 1.2416666666667, 0.15, 0
957, 1.2833333333333, 0.15, 0
958, 1.325, 0.15, 0
959, 1.3666666666667, 0.15, 0
960, 1.4083333333333, 0.15, 0
961, 1.45, 0.15, 0
962, 1.4916666666667, 0.15, 0
963, 1.5333333333333, 0.15, 0
964, 1.575, 0.15, 0
965, 1.6166666666667, 0.15, 0
966, 1.6583333333333, 0.15, 0
967, 1.7, 0.15, 0
968, 1.7416666666667, 0.15, 0
969, 1.7833333333333, 0.15, 0
970, 1.825, 0.15, 0
971, 1.8666666666667, 0.15, 0
972, 1.9083333333333, 0.15, 0
973, 1.95, 0.15, 0
974, 1.9916666666667, 0.15, 0
975, 2.0333333333333, 0.15, 0
976, 2.075, 0.15, 0
977, 2.1166666666667, 0.15, 0
978, 2.1583333333333, 0.15, 0
979, 1.2, 0.15, 0.041666666666667
980, 1.2, 0.15, 0.083333333333333
981, 1.2, 0.15, 0.125
982, 1.2, 0.15, 0.16666666666667
983, 1.2, 0.15, 0.20833333333333
984, 1.2, 0.15, 0.25
985, 1.2, 0.15, 0.29166666666667
986, 1.2, 0.15, 0.33333333333333
987, 1.2, 0.15, 0.375
988, 1.2, 0.15, 0.41666666666667
989, 1.2, 0.15, 0.45833333333333
990, 2.2, 0.15, 0.041666666666667
991, 2.2, 0.15, 0.083333333333333
992, 2.2, 0.15, 0.125
993, 2.2, 0.15, 0.16666666666667
994, 2.2, 0.15, 0.20833333333333
995, 2.2, 0.15, 0.25
996, 2.2, 0.15, 0.29166666666667
997, 2.2, 0.15, 0.33333333333333
998, 2.2, 0.15, 0.375
999, 2.2, 0.15, 0.41666666666667
1000, 2.2, 0.15, 0.45833333333333
1001, 1.2416666666667, 0.1, 0.5
1002, 1.2833333333333, 0.1, 0.5
1003, 1.325, 0.1, 0.5
1004, 1.3666666666667, 0.1, 0.5
1005, 1.4083333333333, 0.1, 0.5
1006, 1.45, 0.1, 0.5
1007, 1.4916666666667, 0.1, 0.5
1008, 1.5333333333333, 0.1, 0.5
1009, 1.575, 0.1, 0.5
1010, 1.6166666666667, 0.1, 0.5
1011, 1.6583333333333, 0.1, 0.5
1012, 1.7, 0.1, 0.5
1013, 1.7416666666667, 0.1, 0.5
1014, 1.7833333333333, 0.1, 0.5
1015, 1.825, 0.1, 0.5
1016, 1.8666666666667, 0.1, 0.5
1017, 1.9083333333333, 0.1, 0.5
1018, 1.95, 0.1, 0.5
1019, 1.9916666666667, 0.1, 0.5
1020, 2.0333333333333, 0.1, 0.5
1021, 2.075, 0.1, 0.5
1022, 2.1166666666667, 0.1, 0.5
1023, 2.1583333333333, 0.1, 0.5
1024, 1.2416666666667, 0.1, 0
1025, 1.2833333333333, 0.1, 0
1026, 1.325, 0.1, 0
1027, 1.3666666666667, 0.1, 0
1028, 1.4083333333333, 0.1, 0
1029, 1.45, 0.1, 0
1030, 1.4916666666667, 0.1, 0
1031, 1.5333333333333, 0.1, 0
1032, 1.575, 0.1, 0
1033, 1.6166666666667, 0.1, 0
1034, 1.6583333333333, 0.1, 0
1035, 1.7, 0.1, 0
1036, 1.7416666666667, 0.1, 0
1037, 1.7833333333333, 0.1, 0
1038, 1.825, 0.1, 0
1039, 1.8666666666667, 0.1, 0
1040, 1.9083333333333, 0.1, 0
1041, 1.95, 0.1, 0
1042, 1.9916666666667, 0.1, 0
1043, 2.0333333333333, 0.1, 0
1044, 2.075, 0.1, 0
1045, 2.1166666666667, 0.1, 0
1046, 2.1583333333333, 0.1, 0
1047, 1.2, 0.1, 0.041666666666667
1048, 1.2, 0.1, 0.083333333333333
1049, 1.2, 0.1, 0.125
1050, 1.2, 0.1, 0.16666666666667
1051, 1.2, 0.1, 0.20833333333333
1052, 1.2, 0.1, 0.25
1053, 1.2, 0.1, 0.29166666666667
1054, 1.2, 0.1, 0.33333333333333
1055, 1.2, 0.1, 0.375
1056, 1.2, 0.1, 0.41666666666667
1057, 1.2, 0.1, 0.45833333333333
1058, 2.2, 0.1, 0.041666666666667
1059, 2.2, 0.1, 0.083333333333333
1060, 2.2, 0.1, 0.125
1061, 2.2, 0.1, 0.16666666666667
1062, 2.2, 0.1, 0.20833333333333
1063, 2.2, 0.1, 0.25
1064, 2.2, 0.1, 0.29166666666667
1065, 2.2, 0.1, 0.33333333333333
1066, 2.2, 0.1, 0.375
1067, 2.2, 0.1, 0.41666666666667
1068, 2.2, 0.1, 0.45833333333333
1069, 1.2, 0.066666666666667, 0.5
1070, 1.2, 0.033333333333333, 0.5
1071, 2.2, 0.066666666666667, 0.5
1072, 2.2, 0.033333333333333, 0.5
1073, 1.2416666666667, 1.2490009027033e-16, 0.5
1074, 1.2833333333333, 1.2490009027033e-16, 0.5
1075, 1.325, 1.2490009027033e-16, 0.5
1076, 1.3666666666667, 1.2490009027033e-16, 0.5
1077, 1.4083333333333, 1.2490009027033e-16, 0.5
1078, 1.45, 1.2490009027033e-16, 0.5
1079, 1.4916666666667, 1.2490009027033e-16, 0.5
1080, 1.5333333333333, 1.2490009027033e-16, 0.5
1081, 1.575, 1.2490009027033e-16, 0.5
1082, 1.6166666666667, 1.2490009027033e-16, 0.5
1083, 1.6583333333333, 1.2490009027033e-16, 0.5
1084, 1.7, 1.2490009027033e-16, 0.5
1085, 1.7416666666667, 1.2490009027033e-16, 0.5
1086, 1.7833333333333, 1.2490009027033e-16, 0.5
1087, 1.825, 1.2490009027033e-16, 0.5
1088, 1.8666666666667, 1.2490009027033e-16, 0.5
1089, 1.9083333333333, 1.2490009027033e-16, 0.5
1090, 1.95, 1.2490009027033e-16, 0.5
1091, 1.9916666666667, 1.2490009027033e-16, 0.5
1092, 2.0333333333333, 1.2490009027033e-16, 0.5
1093, 2.075, 1.2490009027033e-16, 0.5
1094, 2.1166666666667, 1.2490009027033e-16, 0.5
1095, 2.1583333333333, 1.2490009027033e-16, 0.5
1096, 1.2, 0.066666666666667, 0
1097, 1.2, 0.033333333333333, 0
1098, 2.2, 0.066666666666667, 0
1099, 2.2, 0.033333333333333, 0
1100, 1.2416666666667, 1.2490009027033e-16, 0
1101, 1.2833333333333, 1.2490009027033e-16, 0
1102, 1.325, 1.2490009027033e-16, 0
1103, 1.3666666666667, 1.2490009027033e-16, 0
1104, 1.4083333333333, 1.2490009027033e-16, 0
1105, 1.45, 1.2490009027033e-16, 0
1106, 1.4916666666667, 1.2490009027033e-16, 0
1107, 1.5333333333333, 1.2490009027033e-16, 0
1108, 1.575, 1.2490009027033e-16, 0
1109, 1.6166666666667, 1.2490009027033e-16, 0
1110, 1.6583333333333, 1.2490009027033e-16, 0
1111, 1.7, 1.2490009027033e-16, 0
1112, 1.7416666666667, 1.2490009027033e-16, 0
1113, 1.7833333333333, 1.2490009027033e-16, 0
1114, 1.825, 1.2490009027033e-16, 0
1115, 1.8666666666667, 1.2490009027033e-16, 0
1116, 1.9083333333333, 1.2490009027033e-16, 0
1117, 1.95, 1.2490009027033e-16, 0
1118, 1.9916666666667, 1.2490009027033e-16, 0
1119, 2.0333333333333, 1.2490009027033e-16, 0
1120, 2.075, 1.2490009027033e-16, 0
1121, 2.1166666666667, 1.2490009027033e-16, 0
1122, 2.1583333333333, 1.2490009027033e-16, 0
1123, 1.2, 1.2490009027033e-16, 0.041666666666667
1124, 1.2, 1.2490009027033e-16, 0.083333333333333
1125, 1.2, 1.2490009027033e-16, 0.125
1126, 1.2, 1.2490009027033e-16, 0.16666666666667
1127, 1.2, 1.2490009027033e-16, 0.20833333333333
1128, 1.2, 1.2490009027033e-16, 0.25
1129, 1.2, 1.2490009027033e-16, 0.29166666666667
1130, 1.2, 1.2490009027033e-16, 0.33333333333333
1131, 1.2, 1.2490009027033e-16, 0.375
1132, 1.2, 1.2490009027033e-16, 0.41666666666667
1133, 1.2, 1.2490009027033e-16, 0.45833333333333
1134, 2.2, 1.2490009027033e-16, 0.041666666666667
1135, 2.2, 1.2490009027033e-16, 0.083333333333333
1136, 2.2, 1.2490009027033e-16, 0.125
1137, 2.2, 1.2490009027033e-16, 0.16666666666667
1138, 2.2, 1.2490009027033e-16, 0.20833333333333
1139, 2.2, 1.2490009027033e-16, 0.25
1140, 2.2, 1.2490009027033e-16, 0.29166666666667
1141, 2.2, 1.2490009027033e-16, 0.33333333333333
1142, 2.2, 1.2490009027033e-16, 0.375
1143, 2.2, 1.2490009027033e-16, 0.41666666666667
1144, 2.2, 1.2490009027033e-16, 0.45833333333333
1145, 2.3, 0.066666666666667, 0.5
1146, 2.3, 0.033333333333333, 0.5
1147, 2.3, 0.066666666666667, 0
1148, 2.3, 0.033333333333333, 0
1149, 2.3, 0.1, 0.041666666666667
1150, 2.3, 0.1, 0.083333333333333
1151, 2.3, 0.1, 0.125
1152, 2.3, 0.1, 0.16666666666667
1153, 2.3, 0.1, 0.20833333333333
1154, 2.3, 0.1, 0.25
1155, 2.3, 0.1, 0.29166666666667
1156, 2.3, 0.1, 0.33333333333333
1157, 2.3, 0.1, 0.375
1158, 2.3, 0.1, 0.41666666666667
1159, 2.3, 0.1, 0.45833333333333
1160, 2.3, 1.2490009027033e-16, 0.041666666666667
1161, 2.3, 1.2490009027033e-16, 0.083333333333333
1162, 2.3, 1.2490009027033e-16, 0.125
1163, 2.3, 1.2490009027033e-16, 0.16666666666667
1164, 2.3, 1.2490009027033e-16, 0.20833333333333
1165, 2.3, 1.2490009027033e-16, 0.25
1166, 2.3, 1.2490009027033e-16, 0.29166666666667
1167, 2.3, 1.2490009027033e-16, 0.33333333333333
1168, 2.3, 1.2490009027033e-16, 0.375
1169, 2.3, 1.2490009027033e-16, 0.41666666666667
1170, 2.3, 1.2490009027033e-16, 0.45833333333333
1171, -0.1, 0, 0.041666666666667
1172, -0.1, 0, 0.083333333333333
1173, -0.1, 0, 0.125
1174, -0.1, 0, 0.16666666666667
1175, -0.1, 0, 0.20833333333333
1176, -0.1, 0, 0.25
1177, -0.1, 0, 0.29166666666667
1178, -0.1, 0, 0.33333333333333
1179, -0.1, 0, 0.375
1180, -0.1, 0, 0.41666666666667
1181, -0.1, 0, 0.45833333333333
1182, -0.1, 0.033333333333333, 0.5
1183, -0.1, 0.066666666666667, 0.5
1184, -0.1, 0.1, 0.041666666666667
1185, -0.1, 0.1, 0.083333333333333
1186, -0.1, 0.1, 0.125
1187, -0.1, 0.1, 0.16666666666667
1188, -0.1, 0.1, 0.20833333333333
1189, -0.1, 0.1, 0.25
1190, -0.1, 0.1, 0.29166666666667
1191, -0.1, 0.1, 0.33333333333333
1192, -0.1, 0.1, 0.375
1193, -0.1, 0.1, 0.41666666666667
1194, -0.1, 0.1, 0.45833333333333
1195, -0.1, 0.033333333333333, 0
1196, -0.1, 0.066666666666667, 0
1197, 1.05, 0.2, 0.5
1198, 1.05, 0.25, 0.5
1199, 1.05, 0.3, 0.5
1200, 1.05, 0.35, 0.5
1201, 1.05, 0.4, 0.5
1202, 1.05, 0.45, 0.5
1203, 1.05, 0.5, 0.5
1204, 1.05, 0.55, 0.5
1205, 1.05, 0.6, 0.5
1206, 1.05, 0.65, 0.5
1207, 1.05, 0.7, 0.5
1208, 1.05, 0.75, 0.5
1209, 1.05, 0.8, 0.5
1210, 1.05, 0.85, 0.5
1211, 1.05, 0.9, 0.5
1212, 1.05, 0.95, 0.5
1213, 1.05, 1, 0.5
1214, 1.05, 1.05, 0.5
1215, 1.05, 1.1, 0.5
1216, 1.05, 1.15, 0.5
1217, 1.05, 1.2, 0.5
1218, 1.05, 1.25, 0.5
1219, 1.05, 1.3, 0.5
1220, 1.05, 0.2, 0
1221, 1.05, 0.25, 0
1222, 1.05, 0.3, 0
1223, 1.05, 0.35, 0
1224, 1.05, 0.4, 0
1225, 1.05, 0.45, 0
1226, 1.05, 0.5, 0
1227, 1.05, 0.55, 0
1228, 1.05, 0.6, 0
1229, 1.05, 0.65, 0
1230, 1.05, 0.7, 0
1231, 1.05, 0.75, 0
1232, 1.05, 0.8, 0
1233, 1.05, 0.85, 0
1234, 1.05, 0.9, 0
1235, 1.05, 0.95, 0
1236, 1.05, 1, 0
1237, 1.05, 1.05, 0
1238, 1.05, 1.1, 0
1239, 1.05, 1.15, 0
1240, 1.05, 1.2, 0
1241, 1.05, 1.25, 0
1242, 1.05, 1.3, 0
1243, 1.05, 0.15, 0.041666666666667
1244, 1.05, 0.15, 0.083333333333333
1245, 1.05, 0.15, 0.125
1246, 1.05, 0.15, 0.16666666666667
1247, 1.05, 0.15, 0.20833333333333
1248, 1.05, 0.15, 0.25
1249, 1.05, 0.15, 0.29166666666667
1250, 1.05, 0.15, 0.33333333333333
1251, 1.05, 0.15, 0.375
1252, 1.05, 0.15, 0.41666666666667
1253, 1.05, 0.15, 0.45833333333333
1254, 1.05, 1.35, 0.041666666666667
1255, 1.05, 1.35, 0.083333333333333
1256, 1.05, 1.35, 0.125
1257, 1.05, 1.35, 0.16666666666667
1258, 1.05, 1.35, 0.20833333333333
1259, 1.05, 1.35, 0.25
1260, 1.05, 1.35, 0.29166666666667
1261, 1.05, 1.35, 0.33333333333333
1262, 1.05, 1.35, 0.375
1263, 1.05, 1.35, 0.41666666666667
1264, 1.05, 1.35, 0.45833333333333
1265, 1.15, 1.3, 0.5
1266, 1.15, 1.25, 0.5
1267, 1.15, 1.2, 0.5
1268, 1.15, 1.15, 0.5
1269, 1.15, 1.1, 0.5
1270, 1.15, 1.05, 0.5
1271, 1.15, 1, 0.5
1272, 1.15, 0.95, 0.5
1273, 1.15, 0.9, 0.5
1274, 1.15, 0.85, 0.5
1275, 1.15, 0.8, 0.5
1276, 1.15, 0.75, 0.5
1277, 1.15, 0.7, 0.5
1278, 1.15, 0.65, 0.5
1279, 1.15, 0.6, 0.5
1280, 1.15, 0.55, 0.5
1281, 1.15, 0.5, 0.5
1282, 1.15, 0.45, 0.5
1283, 1.15, 0.4, 0.5
1284, 1.15, 0.35, 0.5
1285, 1.15, 0.3, 0.5
1286, 1.15, 0.25, 0.5
1287, 1.15, 0.2, 0.5
1288, 1.15, 1.3, 0
1289, 1.15, 1.25, 0
1290, 1.15, 1.2, 0
1291, 1.15, 1.15, 0
1292, 1.15, 1.1, 0
1293, 1.15, 1.05, 0
1294, 1.15, 1, 0
1295, 1.15, 0.95, 0
1296, 1.15, 0.9, 0
1297, 1.15, 0.85, 0
1298, 1.15, 0.8, 0
1299, 1.15, 0.75, 0
1300, 1.15, 0.7, 0
1301, 1.15, 0.65, 0
1302, 1.15, 0.6, 0
1303, 1.15, 0.55, 0
1304, 1.15, 0.5, 0
1305, 1.15, 0.45, 0
1306, 1.15, 0.4, 0
1307, 1.15, 0.35, 0
1308, 1.15, 0.3, 0
1309, 1.15, 0.25, 0
1310, 1.15, 0.2, 0
1311, 1.15, 1.35, 0.041666666666667
1312, 1.15, 1.35, 0.083333333333333
1313, 1.15, 1.35, 0.125
1314, 1.15, 1.35, 0.16666666666667
1315, 1.15, 1.35, 0.20833333333333
1316, 1.15, 1.35, 0.25
1317, 1.15, 1.35, 0.29166666666667
1318, 1.15, 1.35, 0.33333333333333
1319, 1.15, 1.35, 0.375
1320, 1.15, 1.35, 0.41666666666667
1321, 1.15, 1.35, 0.45833333333333
1322, 1.15, 0.15, 0.041666666666667
1323, 1.15, 0.15, 0.083333333333333
1324, 1.15, 0.15, 0.125
1325, 1.15, 0.15, 0.16666666666667
1326, 1.15, 0.15, 0.20833333333333
1327, 1.15, 0.15, 0.25
1328, 1.15, 0.15, 0.29166666666667
1329, 1.15, 0.15, 0.33333333333333
1330, 1.15, 0.15, 0.375
1331, 1.15, 0.15, 0.41666666666667
1332, 1.15, 0.15, 0.45833333333333
1333, 1, 0.2, -0.1
1334, 1, 0.25, -0.1
1335, 1, 0.3, -0.1
1336, 1, 0.35, -0.1
1337, 1, 0.4, -0.1
1338, 1, 0.45, -0.1
1339, 1, 0.5, -0.1
1340, 1, 0.55, -0.1
1341, 1, 0.6, -0.1
1342, 1, 0.65, -0.1
1343, 1, 0.7, -0.1
1344, 1, 0.75, -0.1
1345, 1, 0.8, -0.1
1346, 1, 0.85, -0.1
1347, 1, 0.9, -0.1
1348, 1, 0.95, -0.1
1349, 1, 1, -0.1
1350, 1, 1.05, -0.1
1351, 1, 1.1, -0.1
1352, 1, 1.15, -0.1
1353, 1, 1.2, -0.1
1354, 1, 1.25, -0.1
1355, 1, 1.3, -0.1
1356, 0, 0.2, -0.1
1357, 0, 0.25, -0.1
1358, 0, 0.3, -0.1
1359, 0, 0.35, -0.1
1360, 0, 0.4, -0.1
1361, 0, 0.45, -0.1
1362, 0, 0.5, -0.1
1363, 0, 0.55, -0.1
1364, 0, 0.6, -0.1
1365, 0, 0.65, -0.1
1366, 0, 0.7, -0.1
1367, 0, 0.75, -0.1
1368, 0, 0.8, -0.1
1369, 0, 0.85, -0.1
1370, 0, 0.9, -0.1
1371, 0, 0.95, -0.1
1372, 0, 1, -0.1
1373, 0, 1.05, -0.1
1374, 0, 1.1, -0.1
1375, 0, 1.15, -0.1
1376, 0, 1.2, -0.1
1377, 0, 1.25, -0.1
1378, 0, 1.3, -0.1
1379, 0.041666666666667, 0.15, -0.1
1380, 0.083333333333333, 0.15, -0.1
1381, 0.125, 0.15, -0.1
1382, 0.16666666666667, 0.15, -0.1
1383, 0.20833333333333, 0.15, -0.1
1384, 0.25, 0.15, -0.1
1385, 0.29166666666667, 0.15, -0.1
1386, 0.33333333333333, 0.15, -0.1
1387, 0.375, 0.15, -0.1
1388, 0.41666666666667, 0.15, -0.1
1389, 0.45833333333333, 0.15, -0.1
1390, 0.5, 0.15, -0.1
1391, 0.54166666666667, 0.15, -0.1
1392, 0.58333333333333, 0.15, -0.1
1393, 0.625, 0.15, -0.1
1394, 0.66666666666667, 0.15, -0.1
1395, 0.70833333333333, 0.15, -0.1
1396, 0.75, 0.15, -0.1
1397, 0.79166666666667, 0.15, -0.1
1398, 0.83333333333333, 0.15, -0.1
1399, 0.875, 0.15, -0.1
1400, 0.91666666666667, 0.15, -0.1
1401, 0.95833333333333, 0.15, -0.1
1402, 0.041666666666667, 1.35, -0.1
1403, 0.083333333333333, 1.35, -0.1
1404, 0.125, 1.35, -0.1
1405, 0.16666666666667, 1.35, -0.1
1406, 0.20833333333333, 1.35, -0.1
1407, 0.25, 1.35, -0.1
1408, 0.29166666666667, 1.35, -0.1
1409, 0.33333333333333, 1.35, -0.1
1410, 0.375, 1.35, -0.1
1411, 0.41666666666667, 1.35, -0.1
1412, 0.45833333333333, 1.35, -0.1
1413, 0.5, 1.35, -0.1
1414, 0.54166666666667, 1.35, -0.1
1415, 0.58333333333333, 1.35, -0.1
1416, 0.625, 1.35, -0.1
1417, 0.66666666666667, 1.35, -0.1
1418, 0.70833333333333, 1.35, -0.1
1419, 0.75, 1.35, -0.1
1420, 0.79166666666667, 1.35, -0.1
1421, 0.83333333333333, 1.35, -0.1
1422, 0.875, 1.35, -0.1
1423, 0.91666666666667, 1.35, -0.1
1424, 0.95833333333333, 1.35, -0.1
1425, 1.2, 1.3, -0.1
1426, 1.2, 1.25, -0.1
1427, 1.2, 1.2, -0.1
1428, 1.2, 1.15, -0.1
1429, 1.2, 1.1, -0.1
1430, 1.2, 1.05, -0.1
1431, 1.2, 1, -0.1
1432, 1.2, 0.95, -0.1
1433, 1.2, 0.9, -0.1
1434, 1.2, 0.85, -0.1
1435, 1.2, 0.8, -0.1
1436, 1.2, 0.75, -0.1
1437, 1.2, 0.7, -0.1
1438, 1.2, 0.65, -0.1
1439, 1.2, 0.6, -0.1
1440, 1.2, 0.55, -0.1
1441, 1.2, 0.5, -0.1
1442, 1.2, 0.45, -0.1
1443, 1.2, 0.4, -0.1
1444, 1.2, 0.35, -0.1
1445, 1.2, 0.3, -0.1
1446, 1.2, 0.25, -0.1
1447, 1.2, 0.2, -0.1
1448, 2.2, 1.3, -0.1
1449, 2.2, 1.25, -0.1
1450, 2.2, 1.2, -0.1
1451, 2.2, 1.15, -0.1
1452, 2.2, 1.1, -0.1
1453, 2.2, 1.05, -0.1
1454, 2.2, 1, -0.1
1455, 2.2, 0.95, -0.1
1456, 2.2, 0.9, -0.1
1457, 2.2, 0.85, -0.1
1458, 2.2, 0.8, -0.1
1459, 2.2, 0.75, -0.1
1460, 2.2, 0.7, -0.1
1461, 2.2, 0.65, -0.1
1462, 2.2, 0.6, -0.1
1463, 2.2, 0.55, -0.1
1464, 2.2, 0.5, -0.1
1465, 2.2, 0.45, -0.1
1466, 2.2, 0.4, -0.1
1467, 2.2, 0.35, -0.1
1468, 2.2, 0.3, -0.1
1469, 2.2, 0.25, -0.1
1470, 2.2, 0.2, -0.1
1471, 1.2416666666667, 1.35, -0.1
1472, 1.2833333333333, 1.35, -0.1
1473, 1.325, 1.35, -0.1
1474, 1.3666666666667, 1.35, -0.1
1475, 1.4083333333333, 1.35, -0.1
1476, 1.45, 1.35, -0.1
1477, 1.4916666666667, 1.35, -0.1
1478, 1.5333333333333, 1.35, -0.1
1479, 1.575, 1.35, -0.1
1480, 1.6166666666667, 1.35, -0.1
1481, 1.6583333333333, 1.35, -0.1
1482, 1.7, 1.35, -0.1
1483, 1.7416666666667, 1.35, -0.1
1484, 1.7833333333333, 1.35, -0.1
1485, 1.825, 1.35, -0.1
1486, 1.8666666666667, 1.35, -0.1
1487, 1.9083333333333, 1.35, -0.1
1488, 1.95, 1.35, -0.1
1489, 1.9916666666667, 1.35, -0.1
1490, 2.0333333333333, 1.35, -0.1
1491, 2.075, 1.35, -0.1
1492, 2.1166666666667, 1.35, -0.1
1493, 2.1583333333333, 1.35, -0.1
1494, 1.2416666666667, 0.15, -0.1
1495, 1.2833333333333, 0.15, -0.1
1496, 1.325, 0.15, -0.1
1497, 1.3666666666667, 0.15, -0.1
1498, 1.4083333333333, 0.15, -0.1
1499, 1.45, 0.15, -0.1
1500, 1.4916666666667, 0.15, -0.1
1501, 1.5333333333333, 0.15, -0.1
1502, 1.575, 0.15, -0.1
1503, 1.6166666666667, 0.15, -0.1
1504, 1.6583333333333, 0.15, -0.1
1505, 1.7, 0.15, -0.1
1506, 1.7416666666667, 0.15, -0.1
1507, 1.7833333333333, 0.15, -0.1
1508, 1.825, 0.15, -0.1
1509, 1.8666666666667, 0.15, -0.1
1510, 1.9083333333333, 0.15, -0.1
1511, 1.95, 0.15, -0.1
1512, 1.9916666666667, 0.15, -0.1
1513, 2.0333333333333, 0.15, -0.1
1514, 2.075, 0.15, -0.1
1515, 2.1166666666667, 0.15, -0.1
1516, 2.1583333333333, 0.15, -0.1
1517, 1.15, 1.3, -0.1
1518, 1.15, 1.25, -0.1
1519, 1.15, 1.2, -0.1
1520, 1.15, 1.15, -0.1
1521, 1.15, 1.1, -0.1
1522, 1.15, 1.05, -0.1
1523, 1.15, 1, -0.1
1524, 1.15, 0.95, -0.1
1525, 1.15, 0.9, -0.1
1526, 1.15, 0.85, -0.1
1527, 1.15, 0.8, -0.1
1528, 1.15, 0.75, -0.1
1529, 1.15, 0.7, -0.1
1530, 1.15, 0.65, -0.1
1531, 1.15, 0.6, -0.1
1532, 1.15, 0.55, -0.1
1533, 1.15, 0.5, -0.1
1534, 1.15, 0.45, -0.1
1535, 1.15, 0.4, -0.1
1536, 1.15, 0.35, -0.1
1537, 1.15, 0.3, -0.1
1538, 1.15, 0.25, -0.1
1539, 1.15, 0.2, -0.1
1540, 1.05, 0.2, -0.1
1541, 1.05, 0.25, -0.1
1542, 1.05, 0.3, -0.1
1543, 1.05, 0.35, -0.1
1544, 1.05, 0.4, -0.1
1545, 1.05, 0.45, -0.1
1546, 1.05, 0.5, -0.1
1547, 1.05, 0.55, -0.1
1548, 1.05, 0.6, -0.1
1549, 1.05, 0.65, -0.1
1550, 1.05, 0.7, -0.1
1551, 1.05, 0.75, -0.1
1552, 1.05, 0.8, -0.1
1553, 1.05, 0.85, -0.1
1554, 1.05, 0.9, -0.1
1555, 1.05, 0.95, -0.1
1556, 1.05, 1, -0.1
1557, 1.05, 1.05, -0.1
1558, 1.05, 1.1, -0.1
1559, 1.05, 1.15, -0.1
1560, 1.05, 1.2, -0.1
1561, 1.05, 1.25, -0.1
1562, 1.05, 1.3, -0.1
1563, 1, 1.54, 0
1564, 1, 1.58, 0
1565, 1, 1.62, 0
1566, 1, 1.66, 0
1567, 0, 1.54, 0
1568, 0, 1.58, 0
1569, 0, 1.62, 0
1570, 0, 1.66, 0
1571, 0.041666666666667, 1.7, 0
1572, 0.083333333333333, 1.7, 0
1573, 0.125, 1.7, 0
1574, 0.16666666666667, 1.7, 0
1575, 0.20833333333333, 1.7, 0
1576, 0.25, 1.7, 0
1577, 0.29166666666667, 1.7, 0
1578, 0.33333333333333, 1.7, 0
1579, 0.375, 1.7, 0
1580, 0.41666666666667, 1.7, 0
1581, 0.45833333333333, 1.7, 0
1582, 0.5, 1.7, 0
1583, 0.54166666666667, 1.7, 0
1584, 0.58333333333333, 1.7, 0
1585, 0.625, 1.7, 0
1586, 0.66666666666667, 1.7, 0
1587, 0.70833333333333, 1.7, 0
1588, 0.75, 1.7, 0
1589, 0.79166666666667, 1.7, 0
1590, 0.83333333333333, 1.7, 0
1591, 0.875, 1.7, 0
1592, 0.91666666666667, 1.7, 0
1593, 0.95833333333333, 1.7, 0
1594, 1, 1.54, 0.5
1595, 1, 1.58, 0.5
1596, 1, 1.62, 0.5
1597, 1, 1.66, 0.5
1598, 1, 1.7, 0.041666666666667
1599, 1, 1.7, 0.083333333333333
1600, 1, 1.7, 0.125
1601, 1, 1.7, 0.16666666666667
1602, 1, 1.7, 0.20833333333333
1603, 1, 1.7, 0.25
1604, 1, 1.7, 0.29166666666667
1605, 1, 1.7, 0.33333333333333
1606, 1, 1.7, 0.375
1607, 1, 1.7, 0.41666666666667
1608, 1, 1.7, 0.45833333333333
1609, 0, 1.54, 0.5
1610, 0, 1.58, 0.5
1611, 0, 1.62, 0.5
1612, 0, 1.66, 0.5
1613, 0.041666666666667, 1.7, 0.5
1614, 0.083333333333333, 1.7, 0.5
1615, 0.125, 1.7, 0.5
1616, 0.16666666666667, 1.7, 0.5
1617, 0.20833333333333, 1.7, 0.5
1618, 0.25, 1.7, 0.5
1619, 0.29166666666667, 1.7, 0.5
1620, 0.33333333333333, 1.7, 0.5
1621, 0.375, 1.7, 0.5
1622, 0.41666666666667, 1.7, 0.5
1623, 0.45833333333333, 1.7, 0.5
1624, 0.5, 1.7, 0.5
1625, 0.54166666666667, 1.7, 0.5
1626, 0.58333333333333, 1.7, 0.5
1627, 0.625, 1.7, 0.5
1628, 0.66666666666667, 1.7, 0.5
1629, 0.70833333333333, 1.7, 0.5
1630, 0.75, 1.7, 0.5
1631, 0.79166666666667, 1.7, 0.5
1632, 0.83333333333333, 1.7, 0.5
1633, 0.875, 1.7, 0.5
1634, 0.91666666666667, 1.7, 0.5
1635, 0.95833333333333, 1.7, 0.5
1636, 0, 1.7, 0.041666666666667
1637, 0, 1.7, 0.083333333333333
1638, 0, 1.7, 0.125
1639, 0, 1.7, 0.16666666666667
1640, 0, 1.7, 0.20833333333333
1641, 0, 1.7, 0.25
1642, 0, 1.7, 0.29166666666667
1643, 0, 1.7, 0.33333333333333
1644, 0, 1.7, 0.375
1645, 0, 1.7, 0.41666666666667
1646, 0, 1.7, 0.45833333333333
1647, 1.2, 1.54, 0.5
1648, 1.2, 1.58, 0.5
1649, 1.2, 1.62, 0.5
1650, 1.2, 1.66, 0.5
1651, 1.04, 1.7, 0.5
1652, 1.08, 1.7, 0.5
1653, 1.12, 1.7, 0.5
1654, 1.16, 1.7, 0.5
1655, 1.2, 1.54, 0
1656, 1.2, 1.58, 0
1657, 1.2, 1.62, 0
1658, 1.2, 1.66, 0
1659, 1.04, 1.7, 0
1660, 1.08, 1.7, 0
1661, 1.12, 1.7, 0
1662, 1.16, 1.7, 0
1663, 1.2, 1.7, 0.041666666666667
1664, 1.2, 1.7, 0.083333333333333
1665, 1.2, 1.7, 0.125
1666, 1.2, 1.7, 0.16666666666667
1667, 1.2, 1.7, 0.20833333333333
1668, 1.2, 1.7, 0.25
1669, 1.2, 1.7, 0.29166666666667
1670, 1.2, 1.7, 0.33333333333333
1671, 1.2, 1.7, 0.375
1672, 1.2, 1.7, 0.41666666666667
1673, 1.2, 1.7, 0.45833333333333
1674, 2.2, 1.54, 0.5
1675, 2.2, 1.58, 0.5
1676, 2.2, 1.62, 0.5
1677, 2.2, 1.66, 0.5
1678, 1.2416666666667, 1.7, 0.5
1679, 1.2833333333333, 1.7, 0.5
1680, 1.325, 1.7, 0.5
1681, 1.3666666666667, 1.7, 0.5
1682, 1.4083333333333, 1.7, 0.5
1683, 1.45, 1.7, 0.5
1684, 1.4916666666667, 1.7, 0.5
1685, 1.5333333333333, 1.7, 0.5
1686, 1.575, 1.7, 0.5
1687, 1.6166666666667, 1.7, 0.5
1688, 1.6583333333333, 1.7, 0.5
1689, 1.7, 1.7, 0.5
1690, 1.7416666666667, 1.7, 0.5
1691, 1.7833333333333, 1.7, 0.5
1692, 1.825, 1.7, 0.5
1693, 1.8666666666667, 1.7, 0.5
1694, 1.9083333333333, 1.7, 0.5
1695, 1.95, 1.7, 0.5
1696, 1.9916666666667, 1.7, 0.5
1697, 2.0333333333333, 1.7, 0.5
1698, 2.075, 1.7, 0.5
1699, 2.1166666666667, 1.7, 0.5
1700, 2.1583333333333, 1.7, 0.5
1701, 2.2, 1.54, 0
1702, 2.2, 1.58, 0
1703, 2.2, 1.62, 0
1704, 2.2, 1.66, 0
1705, 1.2416666666667, 1.7, 0
1706, 1.2833333333333, 1.7, 0
1707, 1.325, 1.7, 0
1708, 1.3666666666667, 1.7, 0
1709, 1.4083333333333, 1.7, 0
1710, 1.45, 1.7, 0
1711, 1.4916666666667, 1.7, 0
1712, 1.5333333333333, 1.7, 0
1713, 1.575, 1.7, 0
1714, 1.6166666666667, 1.7, 0
1715, 1.6583333333333, 1.7, 0
1716, 1.7, 1.7, 0
1717, 1.7416666666667, 1.7, 0
1718, 1.7833333333333, 1.7, 0
1719, 1.825, 1.7, 0
1720, 1.8666666666667, 1.7, 0
1721, 1.9083333333333, 1.7, 0
1722, 1.95, 1.7, 0
1723, 1.9916666666667, 1.7, 0
1724, 2.0333333333333, 1.7, 0
1725, 2.075, 1.7, 0
1726, 2.1166666666667, 1.7, 0
1727, 2.1583333333333, 1.7, 0
1728, 2.2, 1.7, 0.041666666666667
1729, 2.2, 1.7, 0.083333333333333
1730, 2.2, 1.7, 0.125
1731, 2.2, 1.7, 0.16666666666667
1732, 2.2, 1.7, 0.20833333333333
1733, 2.2, 1.7, 0.25
1734, 2.2, 1.7, 0.29166666666667
1735, 2.2, 1.7, 0.33333333333333
1736, 2.2, 1.7, 0.375
1737, 2.2, 1.7, 0.41666666666667
1738, 2.2, 1.7, 0.45833333333333
1739, 1, -0.04, 0
1740, 1, -0.08, 0
1741, 1, -0.12, 0
1742, 1, -0.16, 0
1743, 0, -0.04, 0
1744, 0, -0.08, 0
1745, 0, -0.12, 0
1746, 0, -0.16, 0
1747, 0.041666666666667, -0.2, 0
1748, 0.083333333333333, -0.2, 0
1749, 0.125, -0.2, 0
1750, 0.16666666666667, -0.2, 0
1751, 0.20833333333333, -0.2, 0
1752, 0.25, -0.2, 0
1753, 0.29166666666667, -0.2, 0
1754, 0.33333333333333, -0.2, 0
1755, 0.375, -0.2, 0
1756, 0.41666666666667, -0.2, 0
1757, 0.45833333333333, -0.2, 0
1758, 0.5, -0.2, 0
1759, 0.54166666666667, -0.2, 0
1760, 0.58333333333333, -0.2, 0
1761, 0.625, -0.2, 0
1762, 0.66666666666667, -0.2, 0
1763, 0.70833333333333, -0.2, 0
1764, 0.75, -0.2, 0
1765, 0.79166666666667, -0.2, 0
1766, 0.83333333333333, -0.2, 0
1767, 0.875, -0.2, 0
1768, 0.91666666666667, -0.2, 0
1769, 0.95833333333333, -0.2, 0
1770, 1, -0.04, 0.5
1771, 1, -0.08, 0.5
1772, 1, -0.12, 0.5
1773, 1, -0.16, 0.5
1774, 1, -0.2, 0.041666666666667
1775, 1, -0.2, 0.083333333333333
1776, 1, -0.2, 0.125
1777, 1, -0.2, 0.16666666666667
1778, 1, -0.2, 0.20833333333333
1779, 1, -0.2, 0.25
1780, 1, -0.2, 0.29166666666667
1781, 1, -0.2, 0.33333333333333
1782, 1, -0.2, 0.375
1783, 1, -0.2, 0.41666666666667
1784, 1, -0.2, 0.45833333333333
1785, 0, -0.04, 0.5
1786, 0, -0.08, 0.5
1787, 0, -0.12, 0.5
1788, 0, -0.16, 0.5
1789, 0.041666666666667, -0.2, 0.5
1790, 0.083333333333333, -0.2, 0.5
1791, 0.125, -0.2, 0.5
1792, 0.16666666666667, -0.2, 0.5
1793, 0.20833333333333, -0.2, 0.5
1794, 0.25, -0.2, 0.5
1795, 0.29166666666667, -0.2, 0.5
1796, 0.33333333333333, -0.2, 0.5
1797, 0.375, -0.2, 0.5
1798, 0.41666666666667, -0.2, 0.5
1799, 0.45833333333333, -0.2, 0.5
1800, 0.5, -0.2, 0.5
1801, 0.54166666666667, -0.2, 0.5
1802, 0.58333333333333, -0.2, 0.5
1803, 0.625, -0.2, 0.5
1804, 0.66666666666667, -0.2, 0.5
1805, 0.70833333333333, -0.2, 0.5
1806, 0.75, -0.2, 0.5
1807, 0.79166666666667, -0.2, 0.5
1808, 0.83333333333333, -0.2, 0.5
1809, 0.875, -0.2, 0.5
1810, 0.91666666666667, -0.2, 0.5
1811, 0.95833333333333, -0.2, 0.5
1812, 0, -0.2, 0.041666666666667
1813, 0, -0.2, 0.083333333333333
1814, 0, -0.2, 0.125
1815, 0, -0.2, 0.16666666666667
1816, 0, -0.2, 0.20833333333333
1817, 0, -0.2, 0.25
1818, 0, -0.2, 0.29166666666667
1819, 0, -0.2, 0.33333333333333
1820, 0, -0.2, 0.375
1821, 0, -0.2, 0.41666666666667
1822, 0, -0.2, 0.45833333333333
1823, -0.1, -0.04, 0.5
1824, -0.1, -0.08, 0.5
1825, -0.1, -0.12, 0.5
1826, -0.1, -0.16, 0.5
1827, -0.1, -0.04, 0
1828, -0.1, -0.08, 0
1829, -0.1, -0.12, 0
1830, -0.1, -0.16, 0
1831, -0.1, -0.2, 0.041666666666667
1832, -0.1, -0.2, 0.083333333333333
1833, -0.1, -0.2, 0.125
1834, -0.1, -0.2, 0.16666666666667
1835, -0.1, -0.2, 0.20833333333333
1836, -0.1, -0.2, 0.25
1837, -0.1, -0.2, 0.29166666666667
1838, -0.1, -0.2, 0.33333333333333
1839, -0.1, -0.2, 0.375
1840, -0.1, -0.2, 0.41666666666667
1841, -0.1, -0.2, 0.45833333333333
1842, 1.2, -0.04, 0.5
1843, 1.2, -0.08, 0.5
1844, 1.2, -0.12, 0.5
1845, 1.2, -0.16, 0.5
1846, 2.2, -0.04, 0.5
1847, 2.2, -0.08, 0.5
1848, 2.2, -0.12, 0.5
1849, 2.2, -0.16, 0.5
1850, 1.2416666666667, -0.2, 0.5
1851, 1.2833333333333, -0.2, 0.5
1852, 1.325, -0.2, 0.5
1853, 1.3666666666667, -0.2, 0.5
1854, 1.4083333333333, -0.2, 0.5
1855, 1.45, -0.2, 0.5
1856, 1.4916666666667, -0.2, 0.5
1857, 1.5333333333333, -0.2, 0.5
1858, 1.575, -0.2, 0.5
1859, 1.6166666666667, -0.2, 0.5
1860, 1.6583333333333, -0.2, 0.5
1861, 1.7, -0.2, 0.5
1862, 1.7416666666667, -0.2, 0.5
1863, 1.7833333333333, -0.2, 0.5
1864, 1.825, -0.2, 0.5
1865, 1.8666666666667, -0.2, 0.5
1866, 1.9083333333333, -0.2, 0.5
1867, 1.95, -0.2, 0.5
1868, 1.9916666666667, -0.2, 0.5
1869, 2.0333333333333, -0.2, 0.5
1870, 2.075, -0.2, 0.5
1871, 2.1166666666667, -0.2, 0.5
1872, 2.1583333333333, -0.2, 0.5
1873, 1.2, -0.04, 0
1874, 1.2, -0.08, 0
1875, 1.2, -0.12, 0
1876, 1.2, -0.16, 0
1877, 2.2, -0.04, 0
1878, 2.2, -0.08, 0
1879, 2.2, -0.12, 0
1880, 2.2, -0.16, 0
1881, 1.2416666666667, -0.2, 0
1882, 1.2833333333333, -0.2, 0
1883, 1.325, -0.2, 0
1884, 1.3666666666667, -0.2, 0
1885, 1.4083333333333, -0.2, 0
1886, 1.45, -0.2, 0
1887, 1.4916666666667, -0.2, 0
1888, 1.5333333333333, -0.2, 0
1889, 1.575, -0.2, 0
1890, 1.6166666666667, -0.2, 0
1891, 1.6583333333333, -0.2, 0
1892, 1.7, -0.2, 0
1893, 1.7416666666667, -0.2, 0
1894, 1.7833333333333, -0.2, 0
1895, 1.825, -0.2, 0
1896, 1.8666666666667, -0.2, 0
1897, 1.9083333333333, -0.2, 0
1898, 1.95, -0.2, 0
1899, 1.9916666666667, -0.2, 0
1900, 2.0333333333333, -0.2, 0
1901, 2.075, -0.2, 0
1902, 2.1166666666667, -0.2, 0
1903, 2.1583333333333, -0.2, 0
1904, 1.2, -0.2, 0.041666666666667
1905, 1.2, -0.2, 0.083333333333333
1906, 1.2, -0.2, 0.125
1907, 1.2, -0.2, 0.16666666666667
1908, 1.2, -0.2, 0.20833333333333
1909, 1.2, -0.2, 0.25
1910, 1.2, -0.2, 0.29166666666667
1911, 1.2, -0.2, 0.33333333333333
1912, 1.2, -0.2, 0.375
1913, 1.2, -0.2, 0.41666666666667
1914, 1.2, -0.2, 0.45833333333333
1915, 2.2, -0.2, 0.041666666666667
1916, 2.2, -0.2, 0.083333333333333
1917, 2.2, -0.2, 0.125
1918, 2.2, -0.2, 0.16666666666667
1919, 2.2, -0.2, 0.20833333333333
1920, 2.2, -0.2, 0.25
1921, 2.2, -0.2, 0.29166666666667
1922, 2.2, -0.2, 0.33333333333333
1923, 2.2, -0.2, 0.375
1924, 2.2, -0.2, 0.41666666666667
1925, 2.2, -0.2, 0.45833333333333
1926, 2.3, -0.04, 0.5
1927, 2.3, -0.08, 0.5
1928, 2.3, -0.12, 0.5
1929, 2.3, -0.16, 0.5
1930, 2.3, -0.04, 0
1931, 2.3, -0.08, 0
1932, 2.3, -0.12, 0
1933, 2.3, -0.16, 0
1934, 2.3, -0.2, 0.041666666666667
1935, 2.3, -0.2, 0.083333333333333
1936, 2.3, -0.2, 0.125
1937, 2.3, -0.2, 0.16666666666667
1938, 2.3, -0.2, 0.20833333333333
1939, 2.3, -0.2, 0.25
1940, 2.3, -0.2, 0.29166666666667
1941, 2.3, -0.2, 0.33333333333333
1942, 2.3, -0.2, 0.375
1943, 2.3, -0.2, 0.41666666666667
1944, 2.3, -0.2, 0.45833333333333
1945, 0, 0.033333333333333, 0.041666666666667
1946, 0, 0.066666666666667, 0.041666666666667
1947, 0, 0.033333333333333, 0.083333333333333
1948, 0, 0.066666666666667, 0.083333333333333
1949, 0, 0.033333333333333, 0.125
1950, 0, 0.066666666666667, 0.125
1951, 0, 0.033333333333333, 0.16666666666667
1952, 0, 0.066666666666667, 0.16666666666667
1953, 0, 0.033333333333333, 0.20833333333333
1954, 0, 0.066666666666667, 0.20833333333333
1955, 0, 0.033333333333333, 0.25
1956, 0, 0.066666666666667, 0.25
1957, 0, 0.033333333333333, 0.29166666666667
1958, 0, 0.066666666666667, 0.29166666666667
1959, 0, 0.033333333333333, 0.33333333333333
1960, 0, 0.066666666666667, 0.33333333333333
1961, 0, 0.033333333333333, 0.375
1962, 0, 0.066666666666667, 0.375
1963, 0, 0.033333333333333, 0.41666666666667
1964, 0, 0.066666666666667, 0.41666666666667
1965, 0, 0.033333333333333, 0.45833333333333
1966, 0, 0.066666666666667, 0.45833333333333
1967, 1, 0.033333333333333, 0.041666666666667
1968, 1, 0.066666666666667, 0.041666666666667
1969, 1, 0.033333333333333, 0.083333333333333
1970, 1, 0.066666666666667, 0.083333333333333
1971, 1, 0.033333333333333, 0.125
1972, 1, 0.066666666666667, 0.125
1973, 1, 0.033333333333333, 0.16666666666667
1974, 1, 0.066666666666667, 0.16666666666667
1975, 1, 0.033333333333333, 0.20833333333333
1976, 1, 0.066666666666667, 0.20833333333333
1977, 1, 0.033333333333333, 0.25
1978, 1, 0.066666666666667, 0.25
1979, 1, 0.033333333333333, 0.29166666666667
1980, 1, 0.066666666666667, 0.29166666666667
1981, 1, 0.033333333333333, 0.33333333333333
1982, 1, 0.066666666666667, 0.33333333333333
1983, 1, 0.033333333333333, 0.375
1984, 1, 0.066666666666667, 0.375
1985, 1, 0.033333333333333, 0.41666666666667
1986, 1, 0.066666666666667, 0.41666666666667
1987, 1, 0.033333333333333, 0.45833333333333
1988, 1, 0.066666666666667, 0.45833333333333
1989, 0.041666666666667, 0, 0.041666666666667
1990, 0.041666666666667, 0, 0.083333333333333
1991, 0.041666666666667, 0, 0.125
1992, 0.041666666666667, 0, 0.16666666666667
1993, 0.041666666666667, 0, 0.20833333333333
1994, 0.041666666666667, 0, 0.25
1995, 0.041666666666667, 0, 0.29166666666667
1996, 0.041666666666667, 0, 0.33333333333333
1997, 0.041666666666667, 0, 0.375
1998, 0.041666666666667, 0, 0.41666666666667
1999, 0.041666666666667, 0, 0.45833333333333
2000, 0.083333333333333, 0, 0.041666666666667
2001, 0.083333333333333, 0, 0.083333333333333
2002, 0.083333333333333, 0, 0.125
2003, 0.083333333333333, 0, 0.16666666666667
2004, 0.083333333333333, 0, 0.20833333333333
2005, 0.083333333333333, 0, 0.25
2006, 0.083333333333333, 0, 0.29166666666667
2007, 0.083333333333333, 0, 0.33333333333333
2008, 0.083333333333333, 0, 0.375
2009, 0.083333333333333, 0, 0.41666666666667
2010, 0.083333333333333, 0, 0.45833333333333
2011, 0.125, 0, 0.041666666666667
2012, 0.125, 0, 0.083333333333333
2013, 0.125, 0, 0.125
2014, 0.125, 0, 0.16666666666667
2015, 0.125, 0, 0.20833333333333
2016, 0.125, 0, 0.25
2017, 0.125, 0, 0.29166666666667
2018, 0.125, 0, 0.33333333333333
2019, 0.125, 0, 0.375
2020, 0.125, 0, 0.41666666666667
2021, 0.125, 0, 0.45833333333333
2022, 0.16666666666667, 0, 0.041666666666667
2023, 0.16666666666667, 0, 0.083333333333333
2024, 0.16666666666667, 0, 0.125
2025, 0.16666666666667, 0, 0.16666666666667
2026, 0.16666666666667, 0, 0.20833333333333
2027, 0.16666666666667, 0, 0.25
2028, 0.16666666666667, 0, 0.29166666666667
2029, 0.16666666666667, 0, 0.33333333333333
2030, 0.16666666666667, 0, 0.375
2031, 0.16666666666667, 0, 0.41666666666667
2032, 0.16666666666667, 0, 0.45833333333333
2033, 0.20833333333333, 0, 0.041666666666667
2034, 0.20833333333333, 0, 0.083333333333333
2035, 0.20833333333333, 0, 0.125
2036, 0.20833333333333, 0, 0.16666666666667
2037, 0.20833333333333, 0, 0.20833333333333
2038, 0.20833333333333, 0, 0.25
2039, 0.20833333333333, 0, 0.29166666666667
2040, 0.20833333333333, 0, 0.33333333333333
2041, 0.20833333333333, 0, 0.375
2042, 0.20833333333333, 0, 0.41666666666667
2043, 0.20833333333333, 0, 0.45833333333333
2044, 0.25, 0, 0.041666666666667
2045, 0.25, 0, 0.083333333333333
2046, 0.25, 0, 0.125
2047, 0.25, 0, 0.16666666666667
2048, 0.25, 0, 0.20833333333333
2049, 0.25, 0, 0.25
2050, 0.25, 0, 0.29166666666667
2051, 0.25, 0, 0.33333333333333
2052, 0.25, 0, 0.375
2053, 0.25, 0, 0.41666666666667
2054, 0.25, 0, 0.45833333333333
2055, 0.29166666666667, 0, 0.041666666666667
2056, 0.29166666666667, 0, 0.083333333333333
2057, 0.29166666666667, 0, 0.125
2058, 0.29166666666667, 0, 0.16666666666667
2059, 0.29166666666667, 0, 0.20833333333333
2060, 0.29166666666667, 0, 0.25
2061, 0.29166666666667, 0, 0.29166666666667
2062, 0.29166666666667, 0, 0.33333333333333
2063, 0.29166666666667, 0, 0.375
2064, 0.29166666666667, 0, 0.41666666666667
2065, 0.29166666666667, 0, 0.45833333333333
2066, 0.33333333333333, 0, 0.041666666666667
2067, 0.33333333333333, 0, 0.083333333333333
2068, 0.33333333333333, 0, 0.125
2069, 0.33333333333333, 0, 0.16666666666667
2070, 0.33333333333333, 0, 0.20833333333333
2071, 0.33333333333333, 0, 0.25
2072, 0.33333333333333, 0, 0.29166666666667
2073, 0.33333333333333, 0, 0.33333333333333
2074, 0.33333333333333, 0, 0.375
2075, 0.33333333333333, 0, 0.41666666666667
2076, 0.33333333333333, 0, 0.45833333333333
2077, 0.375, 0, 0.041666666666667
2078, 0.375, 0, 0.083333333333333
2079, 0.375, 0, 0.125
2080, 0.375, 0, 0.16666666666667
2081, 0.375, 0, 0.20833333333333
2082, 0.375, 0, 0.25
2083, 0.375, 0, 0.29166666666667
2084, 0.375, 0, 0.33333333333333
2085, 0.375, 0, 0.375
2086, 0.375, 0, 0.41666666666667
2087, 0.375, 0, 0.45833333333333
2088, 0.41666666666667, 0, 0.041666666666667
2089, 0.41666666666667, 0, 0.083333333333333
2090, 0.41666666666667, 0, 0.125
2091, 0.41666666666667, 0, 0.16666666666667
2092, 0.41666666666667, 0, 0.20833333333333
2093, 0.41666666666667, 0, 0.25
2094, 0.41666666666667, 0, 0.29166666666667
2095, 0.41666666666667, 0, 0.33333333333333
2096, 0.41666666666667, 0, 0.375
2097, 0.41666666666667, 0, 0.41666666666667
2098, 0.41666666666667, 0, 0.45833333333333
2099, 0.45833333333333, 0, 0.041666666666667
2100, 0.45833333333333, 0, 0.083333333333333
2101, 0.45833333333333, 0, 0.125
2102, 0.45833333333333, 0, 0.16666666666667
2103, 0.45833333333333, 0, 0.20833333333333
2104, 0.45833333333333, 0, 0.25
2105, 0.45833333333333, 0, 0.29166666666667
2106, 0.45833333333333, 0, 0.33333333333333
2107, 0.45833333333333, 0, 0.375
2108, 0.45833333333333, 0, 0.41666666666667
2109, 0.45833333333333, 0, 0.45833333333333
2110, 0.5, 0, 0.041666666666667
2111, 0.5, 0, 0.083333333333333
2112, 0.5, 0, 0.125
2113, 0.5, 0, 0.16666666666667
2114, 0.5, 0, 0.20833333333333
2115, 0.5, 0, 0.25
2116, 0.5, 0, 0.29166666666667
2117, 0.5, 0, 0.33333333333333
2118, 0.5, 0, 0.375
2119, 0.5, 0, 0.41666666666667
2120, 0.5, 0, 0.45833333333333
2121, 0.54166666666667, 0, 0.041666666666667
2122, 0.54166666666667, 0, 0.083333333333333
2123, 0.54166666666667, 0, 0.125
2124, 0.54166666666667, 0, 0.16666666666667
2125, 0.54166666666667, 0, 0.20833333333333
2126, 0.54166666666667, 0, 0.25
2127, 0.54166666666667, 0, 0.29166666666667
2128, 0.54166666666667, 0, 0.33333333333333
2129, 0.54166666666667, 0, 0.375
2130, 0.54166666666667, 0, 0.41666666666667
2131, 0.54166666666667, 0, 0.45833333333333
2132, 0.58333333333333, 0, 0.041666666666667
2133, 0.58333333333333, 0, 0.083333333333333
2134, 0.58333333333333, 0, 0.125
2135, 0.58333333333333, 0, 0.16666666666667
2136, 0.58333333333333, 0, 0.20833333333333
2137, 0.58333333333333, 0, 0.25
2138, 0.58333333333333, 0, 0.29166666666667
2139, 0.58333333333333, 0, 0.33333333333333
2140, 0.58333333333333, 0, 0.375
2141, 0.58333333333333, 0, 0.41666666666667
2142, 0.58333333333333, 0, 0.45833333333333
2143, 0.625, 0, 0.041666666666667
2144, 0.625, 0, 0.083333333333333
2145, 0.625, 0, 0.125
2146, 0.625, 0, 0.16666666666667
2147, 0.625, 0, 0.20833333333333
2148, 0.625, 0, 0.25
2149, 0.625, 0, 0.29166666666667
2150, 0.625, 0, 0.33333333333333
2151, 0.625, 0, 0.375
2152, 0.625, 0, 0.41666666666667
2153, 0.625, 0, 0.45833333333333
2154, 0.66666666666667, 0, 0.041666666666667
2155, 0.66666666666667, 0, 0.083333333333333
2156, 0.66666666666667, 0, 0.125
2157, 0.66666666666667, 0, 0.16666666666667
2158, 0.66666666666667, 0, 0.20833333333333
2159, 0.66666666666667, 0, 0.25
2160, 0.66666666666667, 0, 0.29166666666667
2161, 0.66666666666667, 0, 0.33333333333333
2162, 0.66666666666667, 0, 0.375
2163, 0.66666666666667, 0, 0.41666666666667
2164, 0.66666666666667, 0, 0.45833333333333
2165, 0.70833333333333, 0, 0.041666666666667
2166, 0.70833333333333, 0, 0.083333333333333
2167, 0.70833333333333, 0, 0.125
2168, 0.70833333333333, 0, 0.16666666666667
2169, 0.70833333333333, 0, 0.20833333333333
2170, 0.70833333333333, 0, 0.25
2171, 0.70833333333333, 0, 0.29166666666667
2172, 0.70833333333333, 0, 0.33333333333333
2173, 0.70833333333333, 0, 0.375
2174, 0.70833333333333, 0, 0.41666666666667
2175, 0.70833333333333, 0, 0.45833333333333
2176, 0.75, 0, 0.041666666666667
2177, 0.75, 0, 0.083333333333333
2178, 0.75, 0, 0.125
2179, 0.75, 0, 0.16666666666667
2180, 0.75, 0, 0.20833333333333
2181, 0.75, 0, 0.25
2182, 0.75, 0, 0.29166666666667
2183, 0.75, 0, 0.33333333333333
2184, 0.75, 0, 0.375
2185, 0.75, 0, 0.41666666666667
2186, 0.75, 0, 0.45833333333333
2187, 0.79166666666667, 0, 0.041666666666667
2188, 0.79166666666667, 0, 0.083333333333333
2189, 0.79166666666667, 0, 0.125
2190, 0.79166666666667, 0, 0.16666666666667
2191, 0.79166666666667, 0, 0.20833333333333
2192, 0.79166666666667, 0, 0.25
2193, 0.79166666666667, 0, 0.29166666666667
2194, 0.79166666666667, 0, 0.33333333333333
2195, 0.79166666666667, 0, 0.375
2196, 0.79166666666667, 0, 0.41666666666667
2197, 0.79166666666667, 0, 0.45833333333333
2198, 0.83333333333333, 0, 0.041666666666667
2199, 0.83333333333333, 0, 0.083333333333333
2200, 0.83333333333333, 0, 0.125
2201, 0.83333333333333, 0, 0.16666666666667
2202, 0.83333333333333, 0, 0.20833333333333
2203, 0.83333333333333, 0, 0.25
2204, 0.83333333333333, 0, 0.29166666666667
2205, 0.83333333333333, 0, 0.33333333333333
2206, 0.83333333333333, 0, 0.375
2207, 0.83333333333333, 0, 0.41666666666667
2208, 0.83333333333333, 0, 0.45833333333333
2209, 0.875, 0, 0.041666666666667
2210, 0.875, 0, 0.083333333333333
2211, 0.875, 0, 0.125
2212, 0.875, 0, 0.16666666666667
2213, 0.875, 0, 0.20833333333333
2214, 0.875, 0, 0.25
2215, 0.875, 0, 0.29166666666667
2216, 0.875, 0, 0.33333333333333
2217, 0.875, 0, 0.375
2218, 0.875, 0, 0.41666666666667
2219, 0.875, 0, 0.45833333333333
2220, 0.91666666666667, 0, 0.041666666666667
2221, 0.91666666666667, 0, 0.083333333333333
2222, 0.91666666666667, 0, 0.125
2223, 0.91666666666667, 0, 0.16666666666667
2224, 0.91666666666667, 0, 0.20833333333333
2225, 0.91666666666667, 0, 0.25
2226, 0.91666666666667, 0, 0.29166666666667
2227, 0.91666666666667, 0, 0.33333333333333
2228, 0.91666666666667, 0, 0.375
2229, 0.91666666666667, 0, 0.41666666666667
2230, 0.91666666666667, 0, 0.45833333333333
2231, 0.95833333333333, 0, 0.041666666666667
2232, 0.95833333333333, 0, 0.083333333333333
2233, 0.95833333333333, 0, 0.125
2234, 0.95833333333333, 0, 0.16666666666667
2235, 0.95833333333333, 0, 0.20833333333333
2236, 0.95833333333333, 0, 0.25
2237, 0.95833333333333, 0, 0.29166666666667
2238, 0.95833333333333, 0, 0.33333333333333
2239, 0.95833333333333, 0, 0.375
2240, 0.95833333333333, 0, 0.41666666666667
2241, 0.95833333333333, 0, 0.45833333333333
2242, 0.041666666666667, 0.1, 0.041666666666667
2243, 0.041666666666667, 0.1, 0.083333333333333
2244, 0.041666666666667, 0.1, 0.125
2245, 0.041666666666667, 0.1, 0.16666666666667
2246, 0.041666666666667, 0.1, 0.20833333333333
2247, 0.041666666666667, 0.1, 0.25
2248, 0.041666666666667, 0.1, 0.29166666666667
2249, 0.041666666666667, 0.1, 0.33333333333333
2250, 0.041666666666667, 0.1, 0.375
2251, 0.041666666666667, 0.1, 0.41666666666667
2252, 0.041666666666667, 0.1, 0.45833333333333
2253, 0.083333333333333, 0.1, 0.041666666666667
2254, 0.083333333333333, 0.1, 0.083333333333333
2255, 0.083333333333333, 0.1, 0.125
2256, 0.083333333333333, 0.1, 0.16666666666667
2257, 0.083333333333333, 0.1, 0.20833333333333
2258, 0.083333333333333, 0.1, 0.25
2259, 0.083333333333333, 0.1, 0.29166666666667
2260, 0.083333333333333, 0.1, 0.33333333333333
2261, 0.083333333333333, 0.1, 0.375
2262, 0.083333333333333, 0.1, 0.41666666666667
2263, 0.083333333333333, 0.1, 0.45833333333333
2264, 0.125, 0.1, 0.041666666666667
2265, 0.125, 0.1, 0.083333333333333
2266, 0.125, 0.1, 0.125
2267, 0.125, 0.1, 0.16666666666667
2268, 0.125, 0.1, 0.20833333333333
2269, 0.125, 0.1, 0.25
2270, 0.125, 0.1, 0.29166666666667
2271, 0.125, 0.1, 0.33333333333333
2272, 0.125, 0.1, 0.375
2273, 0.125, 0.1, 0.41666666666667
2274, 0.125, 0.1, 0.45833333333333
2275, 0.16666666666667, 0.1, 0.041666666666667
2276, 0.16666666666667, 0.1, 0.083333333333333
2277, 0.16666666666667, 0.1, 0.125
2278, 0.16666666666667, 0.1, 0.16666666666667
2279, 0.16666666666667, 0.1, 0.20833333333333
2280, 0.16666666666667, 0.1, 0.25
2281, 0.16666666666667, 0.1, 0.29166666666667
2282, 0.16666666666667, 0.1, 0.33333333333333
2283, 0.16666666666667, 0.1, 0.375
2284, 0.16666666666667, 0.1, 0.41666666666667
2285, 0.16666666666667, 0.1, 0.45833333333333
2286, 0.20833333333333, 0.1, 0.041666666666667
2287, 0.20833333333333, 0.1, 0.083333333333333
2288, 0.20833333333333, 0.1, 0.125
2289, 0.20833333333333, 0.1, 0.16666666666667
2290, 0.20833333333333, 0.1, 0.20833333333333
2291, 0.20833333333333, 0.1, 0.25
2292, 0.20833333333333, 0.1, 0.29166666666667
2293, 0.20833333333333, 0.1, 0.33333333333333
2294, 0.20833333333333, 0.1, 0.375
2295, 0.20833333333333, 0.1, 0.41666666666667
2296, 0.20833333333333, 0.1, 0.45833333333333
2297, 0.25, 0.1, 0.041666666666667
2298, 0.25, 0.1, 0.083333333333333
2299, 0.25, 0.1, 0.125
2300, 0.25, 0.1, 0.16666666666667
2301, 0.25, 0.1, 0.20833333333333
2302, 0.25, 0.1, 0.25
2303, 0.25, 0.1, 0.29166666666667
2304, 0.25, 0.1, 0.33333333333333
2305, 0.25, 0.1, 0.375
2306, 0.25, 0.1, 0.41666666666667
2307, 0.25, 0.1, 0.45833333333333
2308, 0.29166666666667, 0.1, 0.041666666666667
2309, 0.29166666666667, 0.1, 0.083333333333333
2310, 0.29166666666667, 0.1, 0.125
2311, 0.29166666666667, 0.1, 0.16666666666667
2312, 0.29166666666667, 0.1, 0.20833333333333
2313, 0.29166666666667, 0.1, 0.25
2314, 0.29166666666667, 0.1, 0.29166666666667
2315, 0.29166666666667, 0.1, 0.33333333333333
2316, 0.29166666666667, 0.1, 0.375
2317, 0.29166666666667, 0.1, 0.41666666666667
2318, 0.29166666666667, 0.1, 0.45833333333333
2319, 0.33333333333333, 0.1, 0.041666666666667
2320, 0.33333333333333, 0.1, 0.083333333333333
2321, 0.33333333333333, 0.1, 0.125
2322, 0.33333333333333, 0.1, 0.16666666666667
2323, 0.33333333333333, 0.1, 0.20833333333333
2324, 0.33333333333333, 0.1, 0.25
2325, 0.33333333333333, 0.1, 0.29166666666667
2326, 0.33333333333333, 0.1, 0.33333333333333
2327, 0.33333333333333, 0.1, 0.375
2328, 0.33333333333333, 0.1, 0.41666666666667
2329, 0.33333333333333, 0.1, 0.45833333333333
2330, 0.375, 0.1, 0.041666666666667
2331, 0.375, 0.1, 0.083333333333333
2332, 0.375, 0.1, 0.125
2333, 0.375, 0.1, 0.16666666666667
2334, 0.375, 0.1, 0.20833333333333
2335, 0.375, 0.1, 0.25
2336, 0.375, 0.1, 0.29166666666667
2337, 0.375, 0.1, 0.33333333333333
2338, 0.375, 0.1, 0.375
2339, 0.375, 0.1, 0.41666666666667
2340, 0.375, 0.1, 0.45833333333333
2341, 0.41666666666667, 0.1, 0.041666666666667
2342, 0.41666666666667, 0.1, 0.083333333333333
2343, 0.41666666666667, 0.1, 0.125
2344, 0.41666666666667, 0.1, 0.16666666666667
2345, 0.41666666666667, 0.1, 0.20833333333333
2346, 0.41666666666667, 0.1, 0.25
2347, 0.41666666666667, 0.1, 0.29166666666667
2348, 0.41666666666667, 0.1, 0.33333333333333
2349, 0.41666666666667, 0.1, 0.375
2350, 0.41666666666667, 0.1, 0.41666666666667
2351, 0.41666666666667, 0.1, 0.45833333333333
2352, 0.45833333333333, 0.1, 0.041666666666667
2353, 0.45833333333333, 0.1, 0.083333333333333
2354, 0.45833333333333, 0.1, 0.125
2355, 0.45833333333333, 0.1, 0.16666666666667
2356, 0.45833333333333, 0.1, 0.20833333333333
2357, 0.45833333333333, 0.1, 0.25
2358, 0.45833333333333, 0.1, 0.29166666666667
2359, 0.45833333333333, 0.1, 0.33333333333333
2360, 0.45833333333333, 0.1, 0.375
2361, 0.45833333333333, 0.1, 0.41666666666667
2362, 0.45833333333333, 0.1, 0.45833333333333
2363, 0.5, 0.1, 0.041666666666667
2364, 0.5, 0.1, 0.083333333333333
2365, 0.5, 0.1, 0.125
2366, 0.5, 0.1, 0.16666666666667
2367, 0.5, 0.1, 0.20833333333333
2368, 0.5, 0.1, 0.25
2369, 0.5, 0.1, 0.29166666666667
2370, 0.5, 0.1, 0.33333333333333
2371, 0.5, 0.1, 0.375
2372, 0.5, 0.1, 0.41666666666667
2373, 0.5, 0.1, 0.45833333333333
2374, 0.54166666666667, 0.1, 0.041666666666667
2375, 0.54166666666667, 0.1, 0.083333333333333
2376, 0.54166666666667, 0.1, 0.125
2377, 0.54166666666667, 0.1, 0.16666666666667
2378, 0.54166666666667, 0.1, 0.20833333333333
2379, 0.54166666666667, 0.1, 0.25
2380, 0.54166666666667, 0.1, 0.29166666666667
2381, 0.54166666666667, 0.1, 0.33333333333333
2382, 0.54166666666667, 0.1, 0.375
2383, 0.54166666666667, 0.1, 0.41666666666667
2384, 0.54166666666667, 0.1, 0.45833333333333
2385, 0.58333333333333, 0.1, 0.041666666666667
2386, 0.58333333333333, 0.1, 0.083333333333333
2387, 0.58333333333333, 0.1, 0.125
2388, 0.58333333333333, 0.1, 0.16666666666667
2389, 0.58333333333333, 0.1, 0.20833333333333
2390, 0.58333333333333, 0.1, 0.25
2391, 0.58333333333333, 0.1, 0.29166666666667
2392, 0.58333333333333, 0.1, 0.33333333333333
2393, 0.58333333333333, 0.1, 0.375
2394, 0.58333333333333, 0.1, 0.41666666666667
2395, 0.58333333333333, 0.1, 0.45833333333333
2396, 0.625, 0.1, 0.041666666666667
2397, 0.625, 0.1, 0.083333333333333
2398, 0.625, 0.1, 0.125
2399, 0.625, 0.1, 0.16666666666667
2400, 0.625, 0.1, 0.20833333333333
2401, 0.625, 0.1, 0.25
2402, 0.625, 0.1, 0.29166666666667
2403, 0.625, 0.1, 0.33333333333333
2404, 0.625, 0.1, 0.375
2405, 0.625, 0.1, 0.41666666666667
2406, 0.625, 0.1, 0.45833333333333
2407, 0.66666666666667, 0.1, 0.041666666666667
2408, 0.66666666666667, 0.1, 0.083333333333333
2409, 0.66666666666667, 0.1, 0.125
2410, 0.66666666666667, 0.1, 0.16666666666667
2411, 0.66666666666667, 0.1, 0.20833333333333
2412, 0.66666666666667, 0.1, 0.25
2413, 0.66666666666667, 0.1, 0.29166666666667
2414, 0.66666666666667, 0.1, 0.33333333333333
2415, 0.66666666666667, 0.1, 0.375
2416, 0.66666666666667, 0.1, 0.41666666666667
2417, 0.66666666666667, 0.1, 0.45833333333333
2418, 0.70833333333333, 0.1, 0.041666666666667
2419, 0.70833333333333, 0.1, 0.083333333333333
2420, 0.70833333333333, 0.1, 0.125
2421, 0.70833333333333, 0.1, 0.16666666666667
2422, 0.70833333333333, 0.1, 0.20833333333333
2423, 0.70833333333333, 0.1, 0.25
2424, 0.70833333333333, 0.1, 0.29166666666667
2425, 0.70833333333333, 0.1, 0.33333333333333
2426, 0.70833333333333, 0.1, 0.375
2427, 0.70833333333333, 0.1, 0.41666666666667
2428, 0.70833333333333, 0.1, 0.45833333333333
2429, 0.75, 0.1, 0.041666666666667
2430, 0.75, 0.1, 0.083333333333333
2431, 0.75, 0.1, 0.125
2432, 0.75, 0.1, 0.16666666666667
2433, 0.75, 0.1, 0.20833333333333
2434, 0.75, 0.1, 0.25
2435, 0.75, 0.1, 0.29166666666667
2436, 0.75, 0.1, 0.33333333333333
2437, 0.75, 0.1, 0.375
2438, 0.75, 0.1, 0.41666666666667
2439, 0.75, 0.1, 0.45833333333333
2440, 0.79166666666667, 0.1, 0.041666666666667
2441, 0.79166666666667, 0.1, 0.083333333333333
2442, 0.79166666666667, 0.1, 0.125
2443, 0.79166666666667, 0.1, 0.16666666666667
2444, 0.79166666666667, 0.1, 0.20833333333333
2445, 0.79166666666667, 0.1, 0.25
2446, 0.79166666666667, 0.1, 0.29166666666667
2447, 0.79166666666667, 0.1, 0.33333333333333
2448, 0.79166666666667, 0.1, 0.375
2449, 0.79166666666667, 0.1, 0.41666666666667
2450, 0.79166666666667, 0.1, 0.45833333333333
2451, 0.83333333333333, 0.1, 0.041666666666667
2452, 0.83333333333333, 0.1, 0.083333333333333
2453, 0.83333333333333, 0.1, 0.125
2454, 0.83333333333333, 0.1, 0.16666666666667
2455, 0.83333333333333, 0.1, 0.20833333333333
2456, 0.83333333333333, 0.1, 0.25
2457, 0.83333333333333, 0.1, 0.29166666666667
2458, 0.83333333333333, 0.1, 0.33333333333333
2459, 0.83333333333333, 0.1, 0.375
2460, 0.83333333333333, 0.1, 0.41666666666667
2461, 0.83333333333333, 0.1, 0.45833333333333
2462, 0.875, 0.1, 0.041666666666667
2463, 0.875, 0.1, 0.083333333333333
2464, 0.875, 0.1, 0.125
2465, 0.875, 0.1, 0.16666666666667
2466, 0.875, 0.1, 0.20833333333333
2467, 0.875, 0.1, 0.25
2468, 0.875, 0.1, 0.29166666666667
2469, 0.875, 0.1, 0.33333333333333
2470, 0.875, 0.1, 0.375
2471, 0.875, 0.1, 0.41666666666667
2472, 0.875, 0.1, 0.45833333333333
2473, 0.91666666666667, 0.1, 0.041666666666667
2474, 0.91666666666667, 0.1, 0.083333333333333
2475, 0.91666666666667, 0.1, 0.125
2476, 0.91666666666667, 0.1, 0.16666666666667
2477, 0.91666666666667, 0.1, 0.20833333333333
2478, 0.91666666666667, 0.1, 0.25
2479, 0.91666666666667, 0.1, 0.29166666666667
2480, 0.91666666666667, 0.1, 0.33333333333333
2481, 0.91666666666667, 0.1, 0.375
2482, 0.91666666666667, 0.1, 0.41666666666667
2483, 0.91666666666667, 0.1, 0.45833333333333
2484, 0.95833333333333, 0.1, 0.041666666666667
2485, 0.95833333333333, 0.1, 0.083333333333333
2486, 0.95833333333333, 0.1, 0.125
2487, 0.95833333333333, 0.1, 0.16666666666667
2488, 0.95833333333333, 0.1, 0.20833333333333
2489, 0.95833333333333, 0.1, 0.25
2490, 0.95833333333333, 0.1, 0.29166666666667
2491, 0.95833333333333, 0.1, 0.33333333333333
2492, 0.95833333333333, 0.1, 0.375
2493, 0.95833333333333, 0.1, 0.41666666666667
2494, 0.95833333333333, 0.1, 0.45833333333333
2495, 0.041666666666667, 0.033333333333333, 0
2496, 0.083333333333333, 0.033333333333333, 0
2497, 0.125, 0.033333333333333, 0
2498, 0.16666666666667, 0.033333333333333, 0
2499, 0.20833333333333, 0.033333333333333, 0
2500, 0.25, 0.033333333333333, 0
2501, 0.29166666666667, 0.033333333333333, 0
2502, 0.33333333333333, 0.033333333333333, 0
2503, 0.375, 0.033333333333333, 0
2504, 0.41666666666667, 0.033333333333333, 0
2505, 0.45833333333333, 0.033333333333333, 0
2506, 0.5, 0.033333333333333, 0
2507, 0.54166666666667, 0.033333333333333, 0
2508, 0.58333333333333, 0.033333333333333, 0
2509, 0.625, 0.033333333333333, 0
2510, 0.66666666666667, 0.033333333333333, 0
2511, 0.70833333333333, 0.033333333333333, 0
2512, 0.75, 0.033333333333333, 0
2513, 0.79166666666667, 0.033333333333333, 0
2514, 0.83333333333333, 0.033333333333333, 0
2515, 0.875, 0.033333333333333, 0
2516, 0.91666666666667, 0.033333333333333, 0
2517, 0.95833333333333, 0.033333333333333, 0
2518, 0.041666666666667, 0.066666666666667, 0
2519, 0.083333333333333, 0.066666666666667, 0
2520, 0.125, 0.066666666666667, 0
2521, 0.16666666666667, 0.066666666666667, 0
2522, 0.20833333333333, 0.066666666666667, 0
2523, 0.25, 0.066666666666667, 0
2524, 0.29166666666667, 0.066666666666667, 0
2525, 0.33333333333333, 0.066666666666667, 0
2526, 0.375, 0.066666666666667, 0
2527, 0.41666666666667, 0.066666666666667, 0
2528, 0.45833333333333, 0.066666666666667, 0
2529, 0.5, 0.066666666666667, 0
2530, 0.54166666666667, 0.066666666666667, 0
2531, 0.58333333333333, 0.066666666666667, 0
2532, 0.625, 0.066666666666667, 0
2533, 0.66666666666667, 0.066666666666667, 0
2534, 0.70833333333333, 0.066666666666667, 0
2535, 0.75, 0.066666666666667, 0
2536, 0.79166666666667, 0.066666666666667, 0
2537, 0.83333333333333, 0.066666666666667, 0
2538, 0.875, 0.066666666666667, 0
2539, 0.91666666666667, 0.066666666666667, 0
2540, 0.95833333333333, 0.066666666666667, 0
2541, 0.041666666666667, 0.033333333333333, 0.5
2542, 0.083333333333333, 0.033333333333333, 0.5
2543, 0.125, 0.033333333333333, 0.5
2544, 0.16666666666667, 0.033333333333333, 0.5
2545, 0.20833333333333, 0.033333333333333, 0.5
2546, 0.25, 0.033333333333333, 0.5
2547, 0.29166666666667, 0.033333333333333, 0.5
2548, 0.33333333333333, 0.033333333333333, 0.5
2549, 0.375, 0.033333333333333, 0.5
2550, 0.41666666666667, 0.033333333333333, 0.5
2551, 0.45833333333333, 0.033333333333333, 0.5
2552, 0.5, 0.033333333333333, 0.5
2553, 0.54166666666667, 0.033333333333333, 0.5
2554, 0.58333333333333, 0.033333333333333, 0.5
2555, 0.625, 0.033333333333333, 0.5
2556, 0.66666666666667, 0.033333333333333, 0.5
2557, 0.70833333333333, 0.033333333333333, 0.5
2558, 0.75, 0.033333333333333, 0.5
2559, 0.79166666666667, 0.033333333333333, 0.5
2560, 0.83333333333333, 0.033333333333333, 0.5
2561, 0.875, 0.033333333333333, 0.5
2562, 0.91666666666667, 0.033333333333333, 0.5
2563, 0.95833333333333, 0.033333333333333, 0.5
2564, 0.041666666666667, 0.066666666666667, 0.5
2565, 0.083333333333333, 0.066666666666667, 0.5
2566, 0.125, 0.066666666666667, 0.5
2567, 0.16666666666667, 0.066666666666667, 0.5
2568, 0.20833333333333, 0.066666666666667, 0.5
2569, 0.25, 0.066666666666667, 0.5
2570, 0.29166666666667, 0.066666666666667, 0.5
2571, 0.33333333333333, 0.066666666666667, 0.5
2572, 0.375, 0.066666666666667, 0.5
2573, 0.41666666666667, 0.066666666666667, 0.5
2574, 0.45833333333333, 0.066666666666667, 0.5
2575, 0.5, 0.066666666666667, 0.5
2576, 0.54166666666667, 0.066666666666667, 0.5
2577, 0.58333333333333, 0.066666666666667, 0.5
2578, 0.625, 0.066666666666667, 0.5
2579, 0.66666666666667, 0.066666666666667, 0.5
2580, 0.70833333333333, 0.066666666666667, 0.5
2581, 0.75, 0.066666666666667, 0.5
2582, 0.79166666666667, 0.066666666666667, 0.5
2583, 0.83333333333333, 0.066666666666667, 0.5
2584, 0.875, 0.066666666666667, 0.5
2585, 0.91666666666667, 0.066666666666667, 0.5
2586, 0.95833333333333, 0.066666666666667, 0.5
2587, 0.041666666666667, 0.15, 0.041666666666667
2588, 0.041666666666667, 0.15, 0.083333333333333
2589, 0.041666666666667, 0.15, 0.125
2590, 0.041666666666667, 0.15, 0.16666666666667
2591, 0.041666666666667, 0.15, 0.20833333333333
2592, 0.041666666666667, 0.15, 0.25
2593, 0.041666666666667, 0.15, 0.29166666666667
2594, 0.041666666666667, 0.15, 0.33333333333333
2595, 0.041666666666667, 0.15, 0.375
2596, 0.041666666666667, 0.15, 0.41666666666667
2597, 0.041666666666667, 0.15, 0.45833333333333
2598, 0.083333333333333, 0.15, 0.041666666666667
2599, 0.083333333333333, 0.15, 0.083333333333333
2600, 0.083333333333333, 0.15, 0.125
2601, 0.083333333333333, 0.15, 0.16666666666667
2602, 0.083333333333333, 0.15, 0.20833333333333
2603, 0.083333333333333, 0.15, 0.25
2604, 0.083333333333333, 0.15, 0.29166666666667
2605, 0.083333333333333, 0.15, 0.33333333333333
2606, 0.083333333333333, 0.15, 0.375
2607, 0.083333333333333, 0.15, 0.41666666666667
2608, 0.083333333333333, 0.15, 0.45833333333333
2609, 0.125, 0.15, 0.041666666666667
2610, 0.125, 0.15, 0.083333333333333
2611, 0.125, 0.15, 0.125
2612, 0.125, 0.15, 0.16666666666667
2613, 0.125, 0.15, 0.20833333333333
2614, 0.125, 0.15, 0.25
2615, 0.125, 0.15, 0.29166666666667
2616, 0.125, 0.15, 0.33333333333333
2617, 0.125, 0.15, 0.375
2618, 0.125, 0.15, 0.41666666666667
2619, 0.125, 0.15, 0.45833333333333
2620, 0.16666666666667, 0.15, 0.041666666666667
2621, 0.16666666666667, 0.15, 0.083333333333333
2622, 0.16666666666667, 0.15, 0.125
2623, 0.16666666666667, 0.15, 0.16666666666667
2624, 0.16666666666667, 0.15, 0.20833333333333
2625, 0.16666666666667, 0.15, 0.25
2626, 0.16666666666667, 0.15, 0.29166666666667
2627, 0.16666666666667, 0.15, 0.33333333333333
2628, 0.16666666666667, 0.15, 0.375
2629, 0.16666666666667, 0.15, 0.41666666666667
2630, 0.16666666666667, 0.15, 0.45833333333333
2631, 0.20833333333333, 0.15, 0.041666666666667
2632, 0.20833333333333, 0.15, 0.083333333333333
2633, 0.20833333333333, 0.15, 0.125
2634, 0.20833333333333, 0.15, 0.16666666666667
2635, 0.20833333333333, 0.15, 0.20833333333333
2636, 0.20833333333333, 0.15, 0.25
2637, 0.20833333333333, 0.15, 0.29166666666667
2638, 0.20833333333333, 0.15, 0.33333333333333
2639, 0.20833333333333, 0.15, 0.375
2640, 0.20833333333333, 0.15, 0.41666666666667
2641, 0.20833333333333, 0.15, 0.45833333333333
2642, 0.25, 0.15, 0.041666666666667
2643, 0.25, 0.15, 0.083333333333333
2644, 0.25, 0.15, 0.125
2645, 0.25, 0.15, 0.16666666666667
2646, 0.25, 0.15, 0.20833333333333
2647, 0.25, 0.15, 0.25
2648, 0.25, 0.15, 0.29166666666667
2649, 0.25, 0.15, 0.33333333333333
2650, 0.25, 0.15, 0.375
2651, 0.25, 0.15, 0.41666666666667
2652, 0.25, 0.15, 0.45833333333333
2653, 0.29166666666667, 0.15, 0.041666666666667
2654, 0.29166666666667, 0.15, 0.083333333333333
2655, 0.29166666666667, 0.15, 0.125
2656, 0.29166666666667, 0.15, 0.16666666666667
2657, 0.29166666666667, 0.15, 0.20833333333333
2658, 0.29166666666667, 0.15, 0.25
2659, 0.29166666666667, 0.15, 0.29166666666667
2660, 0.29166666666667, 0.15, 0.33333333333333
2661, 0.29166666666667, 0.15, 0.375
2662, 0.29166666666667, 0.15, 0.41666666666667
2663, 0.29166666666667, 0.15, 0.45833333333333
2664, 0.33333333333333, 0.15, 0.041666666666667
2665, 0.33333333333333, 0.15, 0.083333333333333
2666, 0.33333333333333, 0.15, 0.125
2667, 0.33333333333333, 0.15, 0.16666666666667
2668, 0.33333333333333, 0.15, 0.20833333333333
2669, 0.33333333333333, 0.15, 0.25
2670, 0.33333333333333, 0.15, 0.29166666666667
2671, 0.33333333333333, 0.15, 0.33333333333333
2672, 0.33333333333333, 0.15, 0.375
2673, 0.33333333333333, 0.15, 0.41666666666667
2674, 0.33333333333333, 0.15, 0.45833333333333
2675, 0.375, 0.15, 0.041666666666667
2676, 0.375, 0.15, 0.083333333333333
2677, 0.375, 0.15, 0.125
2678, 0.375, 0.15, 0.16666666666667
2679, 0.375, 0.15, 0.20833333333333
2680, 0.375, 0.15, 0.25
2681, 0.375, 0.15, 0.29166666666667
2682, 0.375, 0.15, 0.33333333333333
2683, 0.375, 0.15, 0.375
2684, 0.375, 0.15, 0.41666666666667
2685, 0.375, 0.15, 0.45833333333333
2686, 0.41666666666667, 0.15, 0.041666666666667
2687, 0.41666666666667, 0.15, 0.083333333333333
2688, 0.41666666666667, 0.15, 0.125
2689, 0.41666666666667, 0.15, 0.16666666666667
2690, 0.41666666666667, 0.15, 0.20833333333333
2691, 0.41666666666667, 0.15, 0.25
2692, 0.41666666666667, 0.15, 0.29166666666667
2693, 0.41666666666667, 0.15, 0.33333333333333
2694, 0.41666666666667, 0.15, 0.375
2695, 0.41666666666667, 0.15, 0.41666666666667
2696, 0.41666666666667, 0.15, 0.45833333333333
2697, 0.45833333333333, 0.15, 0.041666666666667
2698, 0.45833333333333, 0.15, 0.083333333333333
2699, 0.45833333333333, 0.15, 0.125
2700, 0.45833333333333, 0.15, 0.16666666666667
2701, 0.45833333333333, 0.15, 0.20833333333333
2702, 0.45833333333333, 0.15, 0.25
2703, 0.45833333333333, 0.15, 0.29166666666667
2704, 0.45833333333333, 0.15, 0.33333333333333
2705, 0.45833333333333, 0.15, 0.375
2706, 0.45833333333333, 0.15, 0.41666666666667
2707, 0.45833333333333, 0.15, 0.45833333333333
2708, 0.5, 0.15, 0.041666666666667
2709, 0.5, 0.15, 0.083333333333333
2710, 0.5, 0.15, 0.125
2711, 0.5, 0.15, 0.16666666666667
2712, 0.5, 0.15, 0.20833333333333
2713, 0.5, 0.15, 0.25
2714, 0.5, 0.15, 0.29166666666667
2715, 0.5, 0.15, 0.33333333333333
2716, 0.5, 0.15, 0.375
2717, 0.5, 0.15, 0.41666666666667
2718, 0.5, 0.15, 0.45833333333333
2719, 0.54166666666667, 0.15, 0.041666666666667
2720, 0.54166666666667, 0.15, 0.083333333333333
2721, 0.54166666666667, 0.15, 0.125
2722, 0.54166666666667, 0.15, 0.16666666666667
2723, 0.54166666666667, 0.15, 0.20833333333333
2724, 0.54166666666667, 0.15, 0.25
2725, 0.54166666666667, 0.15, 0.29166666666667
2726, 0.54166666666667, 0.15, 0.33333333333333
2727, 0.54166666666667, 0.15, 0.375
2728, 0.54166666666667, 0.15, 0.41666666666667
2729, 0.54166666666667, 0.15, 0.45833333333333
2730, 0.58333333333333, 0.15, 0.041666666666667
2731, 0.58333333333333, 0.15, 0.083333333333333
2732, 0.58333333333333, 0.15, 0.125
2733, 0.58333333333333, 0.15, 0.16666666666667
2734, 0.58333333333333, 0.15, 0.20833333333333
2735, 0.58333333333333, 0.15, 0.25
2736, 0.58333333333333, 0.15, 0.29166666666667
2737, 0.58333333333333, 0.15, 0.33333333333333
2738, 0.58333333333333, 0.15, 0.375
2739, 0.58333333333333, 0.15, 0.41666666666667
2740, 0.58333333333333, 0.15, 0.45833333333333
2741, 0.625, 0.15, 0.041666666666667
2742, 0.625, 0.15, 0.083333333333333
2743, 0.625, 0.15, 0.125
2744, 0.625, 0.15, 0.16666666666667
2745, 0.625, 0.15, 0.20833333333333
2746, 0.625, 0.15, 0.25
2747, 0.625, 0.15, 0.29166666666667
2748, 0.625, 0.15, 0.33333333333333
2749, 0.625, 0.15, 0.375
2750, 0.625, 0.15, 0.41666666666667
2751, 0.625, 0.15, 0.45833333333333
2752, 0.66666666666667, 0.15, 0.041666666666667
2753, 0.66666666666667, 0.15, 0.083333333333333
2754, 0.66666666666667, 0.15, 0.125
2755, 0.66666666666667, 0.15, 0.16666666666667
2756, 0.66666666666667, 0.15, 0.20833333333333
2757, 0.66666666666667, 0.15, 0.25
2758, 0.66666666666667, 0.15, 0.29166666666667
2759, 0.66666666666667, 0.15, 0.33333333333333
2760, 0.66666666666667, 0.15, 0.375
2761, 0.66666666666667, 0.15, 0.41666666666667
2762, 0.66666666666667, 0.15, 0.45833333333333
2763, 0.70833333333333, 0.15, 0.041666666666667
2764, 0.70833333333333, 0.15, 0.083333333333333
2765, 0.70833333333333, 0.15, 0.125
2766, 0.70833333333333, 0.15, 0.16666666666667
2767, 0.70833333333333, 0.15, 0.20833333333333
2768, 0.70833333333333, 0.15, 0.25
2769, 0.70833333333333, 0.15, 0.29166666666667
2770, 0.70833333333333, 0.15, 0.33333333333333
2771, 0.70833333333333, 0.15, 0.375
2772, 0.70833333333333, 0.15, 0.41666666666667
2773, 0.70833333333333, 0.15, 0.45833333333333
2774, 0.75, 0.15, 0.041666666666667
2775, 0.75, 0.15, 0.083333333333333
2776, 0.75, 0.15, 0.125
2777, 0.75, 0.15, 0.16666666666667
2778, 0.75, 0.15, 0.20833333333333
2779, 0.75, 0.15, 0.25
2780, 0.75, 0.15, 0.29166666666667
2781, 0.75, 0.15, 0.33333333333333
2782, 0.75, 0.15, 0.375
2783, 0.75, 0.15, 0.41666666666667
2784, 0.75, 0.15, 0.45833333333333
2785, 0.79166666666667, 0.15, 0.041666666666667
2786, 0.79166666666667, 0.15, 0.083333333333333
2787, 0.79166666666667, 0.15, 0.125
2788, 0.79166666666667, 0.15, 0.16666666666667
2789, 0.79166666666667, 0.15, 0.20833333333333
2790, 0.79166666666667, 0.15, 0.25
2791, 0.79166666666667, 0.15, 0.29166666666667
2792, 0.79166666666667, 0.15, 0.33333333333333
2793, 0.79166666666667, 0.15, 0.375
2794, 0.79166666666667, 0.15, 0.41666666666667
2795, 0.79166666666667, 0.15, 0.45833333333333
2796, 0.83333333333333, 0.15, 0.041666666666667
2797, 0.83333333333333, 0.15, 0.083333333333333
2798, 0.83333333333333, 0.15, 0.125
2799, 0.83333333333333, 0.15, 0.16666666666667
2800, 0.83333333333333, 0.15, 0.20833333333333
2801, 0.83333333333333, 0.15, 0.25
2802, 0.83333333333333, 0.15, 0.29166666666667
2803, 0.83333333333333, 0.15, 0.33333333333333
2804, 0.83333333333333, 0.15, 0.375
2805, 0.83333333333333, 0.15, 0.41666666666667
2806, 0.83333333333333, 0.15, 0.45833333333333
2807, 0.875, 0.15, 0.041666666666667
2808, 0.875, 0.15, 0.083333333333333
2809, 0.875, 0.15, 0.125
2810, 0.875, 0.15, 0.16666666666667
2811, 0.875, 0.15, 0.20833333333333
2812, 0.875, 0.15, 0.25
2813, 0.875, 0.15, 0.29166666666667
2814, 0.875, 0.15, 0.33333333333333
2815, 0.875, 0.15, 0.375
2816, 0.875, 0.15, 0.41666666666667
2817, 0.875, 0.15, 0.45833333333333
2818, 0.91666666666667, 0.15, 0.041666666666667
2819, 0.91666666666667, 0.15, 0.083333333333333
2820, 0.91666666666667, 0.15, 0.125
2821, 0.91666666666667, 0.15, 0.16666666666667
2822, 0.91666666666667, 0.15, 0.20833333333333
2823, 0.91666666666667, 0.15, 0.25
2824, 0.91666666666667, 0.15, 0.29166666666667
2825, 0.91666666666667, 0.15, 0.33333333333333
2826, 0.91666666666667, 0.15, 0.375
2827, 0.91666666666667, 0.15, 0.41666666666667
2828, 0.91666666666667, 0.15, 0.45833333333333
2829, 0.95833333333333, 0.15, 0.041666666666667
2830, 0.95833333333333, 0.15, 0.083333333333333
2831, 0.95833333333333, 0.15, 0.125
2832, 0.95833333333333, 0.15, 0.16666666666667
2833, 0.95833333333333, 0.15, 0.20833333333333
2834, 0.95833333333333, 0.15, 0.25
2835, 0.95833333333333, 0.15, 0.29166666666667
2836, 0.95833333333333, 0.15, 0.33333333333333
2837, 0.95833333333333, 0.15, 0.375
2838, 0.95833333333333, 0.15, 0.41666666666667
2839, 0.95833333333333, 0.15, 0.45833333333333
2840, 0.041666666666667, 0.2, 0
2841, 0.041666666666667, 0.25, 0
2842, 0.041666666666667, 0.3, 0
2843, 0.041666666666667, 0.35, 0
2844, 0.041666666666667, 0.4, 0
2845, 0.041666666666667, 0.45, 0
2846, 0.041666666666667, 0.5, 0
2847, 0.041666666666667, 0.55, 0
2848, 0.041666666666667, 0.6, 0
2849, 0.041666666666667, 0.65, 0
2850, 0.041666666666667, 0.7, 0
2851, 0.041666666666667, 0.75, 0
2852, 0.041666666666667, 0.8, 0
2853, 0.041666666666667, 0.85, 0
2854, 0.041666666666667, 0.9, 0
2855, 0.041666666666667, 0.95, 0
2856, 0.041666666666667, 1, 0
2857, 0.041666666666667, 1.05, 0
2858, 0.041666666666667, 1.1, 0
2859, 0.041666666666667, 1.15, 0
2860, 0.041666666666667, 1.2, 0
2861, 0.041666666666667, 1.25, 0
2862, 0.041666666666667, 1.3, 0
2863, 0.083333333333333, 0.2, 0
2864, 0.083333333333333, 0.25, 0
2865, 0.083333333333333, 0.3, 0
2866, 0.083333333333333, 0.35, 0
2867, 0.083333333333333, 0.4, 0
2868, 0.083333333333333, 0.45, 0
2869, 0.083333333333333, 0.5, 0
2870, 0.083333333333333, 0.55, 0
2871, 0.083333333333333, 0.6, 0
2872, 0.083333333333333, 0.65, 0
2873, 0.083333333333333, 0.7, 0
2874, 0.083333333333333, 0.75, 0
2875, 0.083333333333333, 0.8, 0
2876, 0.083333333333333, 0.85, 0
2877, 0.083333333333333, 0.9, 0
2878, 0.083333333333333, 0.95, 0
2879, 0.083333333333333, 1, 0
2880, 0.083333333333333, 1.05, 0
2881, 0.083333333333333, 1.1, 0
2882, 0.083333333333333, 1.15, 0
2883, 0.083333333333333, 1.2, 0
2884, 0.083333333333333, 1.25, 0
2885, 0.083333333333333, 1.3, 0
2886, 0.125, 0.2, 0
2887, 0.125, 0.25, 0
2888, 0.125, 0.3, 0
2889, 0.125, 0.35, 0
2890, 0.125, 0.4, 0
2891, 0.125, 0.45, 0
2892, 0.125, 0.5, 0
2893, 0.125, 0.55, 0
2894, 0.125, 0.6, 0
2895, 0.125, 0.65, 0
2896, 0.125, 0.7, 0
2897, 0.125, 0.75, 0
2898, 0.125, 0.8, 0
2899, 0.125, 0.85, 0
2900, 0.125, 0.9, 0
2901, 0.125, 0.95, 0
2902, 0.125, 1, 0
2903, 0.125, 1.05, 0
2904, 0.125, 1.1, 0
2905, 0.125, 1.15, 0
2906, 0.125, 1.2, 0
2907, 0.125, 1.25, 0
2908, 0.125, 1.3, 0
2909, 0.16666666666667, 0.2, 0
2910, 0.16666666666667, 0.25, 0
2911, 0.16666666666667, 0.3, 0
2912, 0.16666666666667, 0.35, 0
2913, 0.16666666666667, 0.4, 0
2914, 0.16666666666667, 0.45, 0
2915, 0.16666666666667, 0.5, 0
2916, 0.16666666666667, 0.55, 0
2917, 0.16666666666667, 0.6, 0
2918, 0.16666666666667, 0.65, 0
2919, 0.16666666666667, 0.7, 0
2920, 0.16666666666667, 0.75, 0
2921, 0.16666666666667, 0.8, 0
2922, 0.16666666666667, 0.85, 0
2923, 0.16666666666667, 0.9, 0
2924, 0.16666666666667, 0.95, 0
2925, 0.16666666666667, 1, 0
2926, 0.16666666666667, 1.05, 0
2927, 0.16666666666667, 1.1, 0
2928, 0.16666666666667, 1.15, 0
2929, 0.16666666666667, 1.2, 0
2930, 0.16666666666667, 1.25, 0
2931, 0.16666666666667, 1.3, 0
2932, 0.20833333333333, 0.2, 0
2933, 0.20833333333333, 0.25, 0
2934, 0.20833333333333, 0.3, 0
2935, 0.20833333333333, 0.35, 0
2936, 0.20833333333333, 0.4, 0
2937, 0.20833333333333, 0.45, 0
2938, 0.20833333333333, 0.5, 0
2939, 0.20833333333333, 0.55, 0
2940, 0.20833333333333, 0.6, 0
2941, 0.20833333333333, 0.65, 0
2942, 0.20833333333333, 0.7, 0
2943, 0.20833333333333, 0.75, 0
2944, 0.20833333333333, 0.8, 0
2945, 0.20833333333333, 0.85, 0
2946, 0.20833333333333, 0.9, 0
2947, 0.20833333333333, 0.95, 0
2948, 0.20833333333333, 1, 0
2949, 0.20833333333333, 1.05, 0
2950, 0.20833333333333, 1.1, 0
2951, 0.20833333333333, 1.15, 0
2952, 0.20833333333333, 1.2, 0
2953, 0.20833333333333, 1.25, 0
2954, 0.20833333333333, 1.3, 0
2955, 0.25, 0.2, 0
2956, 0.25, 0.25, 0
2957, 0.25, 0.3, 0
2958, 0.25, 0.35, 0
2959, 0.25, 0.4, 0
2960, 0.25, 0.45, 0
2961, 0.25, 0.5, 0
2962, 0.25, 0.55, 0
2963, 0.25, 0.6, 0
2964, 0.25, 0.65, 0
2965, 0.25, 0.7, 0
2966, 0.25, 0.75, 0
2967, 0.25, 0.8, 0
2968, 0.25, 0.85, 0
2969, 0.25, 0.9, 0
2970, 0.25, 0.95, 0
2971, 0.25, 1, 0
2972, 0.25, 1.05, 0
2973, 0.25, 1.1, 0
2974, 0.25, 1.15, 0
2975, 0.25, 1.2, 0
2976, 0.25, 1.25, 0
2977, 0.25, 1.3, 0
2978, 0.29166666666667, 0.2, 0
2979, 0.29166666666667, 0.25, 0
2980, 0.29166666666667, 0.3, 0
2981, 0.29166666666667, 0.35, 0
2982, 0.29166666666667, 0.4, 0
2983, 0.29166666666667, 0.45, 0
2984, 0.29166666666667, 0.5, 0
2985, 0.29166666666667, 0.55, 0
2986, 0.29166666666667, 0.6, 0
2987, 0.29166666666667, 0.65, 0
2988, 0.29166666666667, 0.7, 0
2989, 0.29166666666667, 0.75, 0
2990, 0.29166666666667, 0.8, 0
2991, 0.29166666666667, 0.85, 0
2992, 0.29166666666667, 0.9, 0
2993, 0.29166666666667, 0.95, 0
2994, 0.29166666666667, 1, 0
2995, 0.29166666666667, 1.05, 0
2996, 0.29166666666667, 1.1, 0
2997, 0.29166666666667, 1.15, 0
2998, 0.29166666666667, 1.2, 0
2999, 0.29166666666667, 1.25, 0
3000, 0.29166666666667, 1.3, 0
3001, 0.33333333333333, 0.2, 0
3002, 0.33333333333333, 0.25, 0
3003, 0.33333333333333, 0.3, 0
3004, 0.33333333333333, 0.35, 0
3005, 0.33333333333333, 0.4, 0
3006, 0.33333333333333, 0.45, 0
3007, 0.33333333333333, 0.5, 0
3008, 0.33333333333333, 0.55, 0
3009, 0.33333333333333, 0.6, 0
3010, 0.33333333333333, 0.65, 0
3011, 0.33333333333333, 0.7, 0
3012, 0.33333333333333, 0.75, 0
3013, 0.33333333333333, 0.8, 0
3014, 0.33333333333333, 0.85, 0
3015, 0.33333333333333, 0.9, 0
3016, 0.33333333333333, 0.95, 0
3017, 0.33333333333333, 1, 0
3018, 0.33333333333333, 1.05, 0
3019, 0.33333333333333, 1.1, 0
3020, 0.33333333333333, 1.15, 0
3021, 0.33333333333333, 1.2, 0
3022, 0.33333333333333, 1.25, 0
3023, 0.33333333333333, 1.3, 0
3024, 0.375, 0.2, 0
3025, 0.375, 0.25, 0
3026, 0.375, 0.3, 0
3027, 0.375, 0.35, 0
3028, 0.375, 0.4, 0
3029, 0.375, 0.45, 0
3030, 0.375, 0.5, 0
3031, 0.375, 0.55, 0
3032, 0.375, 0.6, 0
3033, 0.375, 0.65, 0
3034, 0.375, 0.7, 0
3035, 0.375, 0.75, 0
3036, 0.375, 0.8, 0
3037, 0.375, 0.85, 0
3038, 0.375, 0.9, 0
3039, 0.375, 0.95, 0
3040, 0.375, 1, 0
3041, 0.375, 1.05, 0
3042, 0.375, 1.1, 0
3043, 0.375, 1.15, 0
3044, 0.375, 1.2, 0
3045, 0.375, 1.25, 0
3046, 0.375, 1.3, 0
3047, 0.41666666666667, 0.2, 0
3048, 0.41666666666667, 0.25, 0
3049, 0.41666666666667, 0.3, 0
3050, 0.41666666666667, 0.35, 0
3051, 0.41666666666667, 0.4, 0
3052, 0.41666666666667, 0.45, 0
3053, 0.41666666666667, 0.5, 0
3054, 0.41666666666667, 0.55, 0
3055, 0.41666666666667, 0.6, 0
3056, 0.41666666666667, 0.65, 0
3057, 0.41666666666667, 0.7, 0
3058, 0.41666666666667, 0.75, 0
3059, 0.41666666666667, 0.8, 0
3060, 0.41666666666667, 0.85, 0
3061, 0.41666666666667, 0.9, 0
3062, 0.41666666666667, 0.95, 0
3063, 0.41666666666667, 1, 0
3064, 0.41666666666667, 1.05, 0
3065, 0.41666666666667, 1.1, 0
3066, 0.41666666666667, 1.15, 0
3067, 0.41666666666667, 1.2, 0
3068, 0.41666666666667, 1.25, 0
3069, 0.41666666666667, 1.3, 0
3070, 0.45833333333333, 0.2, 0
3071, 0.45833333333333, 0.25, 0
3072, 0.45833333333333, 0.3, 0
3073, 0.45833333333333, 0.35, 0
3074, 0.45833333333333, 0.4, 0
3075, 0.45833333333333, 0.45, 0
3076, 0.45833333333333, 0.5, 0
3077, 0.45833333333333, 0.55, 0
3078, 0.45833333333333, 0.6, 0
3079, 0.45833333333333, 0.65, 0
3080, 0.45833333333333, 0.7, 0
3081, 0.45833333333333, 0.75, 0
3082, 0.45833333333333, 0.8, 0
3083, 0.45833333333333, 0.85, 0
3084, 0.45833333333333, 0.9, 0
3085, 0.45833333333333, 0.95, 0
3086, 0.45833333333333, 1, 0
3087, 0.45833333333333, 1.05, 0
3088, 0.45833333333333, 1.1, 0
3089, 0.45833333333333, 1.15, 0
3090, 0.45833333333333, 1.2, 0
3091, 0.45833333333333, 1.25, 0
3092, 0.45833333333333, 1.3, 0
3093, 0.5, 0.2, 0
3094, 0.5, 0.25, 0
3095, 0.5, 0.3, 0
3096, 0.5, 0.35, 0
3097, 0.5, 0.4, 0
3098, 0.5, 0.45, 0
3099, 0.5, 0.5, 0
3100, 0.5, 0.55, 0
3101, 0.5, 0.6, 0
3102, 0.5, 0.65, 0
3103, 0.5, 0.7, 0
3104, 0.5, 0.75, 0
3105, 0.5, 0.8, 0
3106, 0.5, 0.85, 0
3107, 0.5, 0.9, 0
3108, 0.5, 0.95, 0
3109, 0.5, 1, 0
3110, 0.5, 1.05, 0
3111, 0.5, 1.1, 0
3112, 0.5, 1.15, 0
3113, 0.5, 1.2, 0
3114, 0.5, 1.25, 0
3115, 0.5, 1.3, 0
3116, 0.54166666666667, 0.2, 0
3117, 0.54166666666667, 0.25, 0
3118, 0.54166666666667, 0.3, 0
3119, 0.54166666666667, 0.35, 0
3120, 0.54166666666667, 0.4, 0
3121, 0.54166666666667, 0.45, 0
3122, 0.54166666666667, 0.5, 0
3123, 0.54166666666667, 0.55, 0
3124, 0.54166666666667, 0.6, 0
3125, 0.54166666666667, 0.65, 0
3126, 0.54166666666667, 0.7, 0
3127, 0.54166666666667, 0.75, 0
3128, 0.54166666666667, 0.8, 0
3129, 0.54166666666667, 0.85, 0
3130, 0.54166666666667, 0.9, 0
3131, 0.54166666666667, 0.95, 0
3132, 0.54166666666667, 1, 0
3133, 0.54166666666667, 1.05, 0
3134, 0.54166666666667, 1.1, 0
3135, 0.54166666666667, 1.15, 0
3136, 0.54166666666667, 1.2, 0
3137, 0.54166666666667, 1.25, 0
3138, 0.54166666666667, 1.3, 0
3139, 0.58333333333333, 0.2, 0
3140, 0.58333333333333, 0.25, 0
3141, 0.58333333333333, 0.3, 0
3142, 0.58333333333333, 0.35, 0
3143, 0.58333333333333, 0.4, 0
3144, 0.58333333333333, 0.45, 0
3145, 0.58333333333333, 0.5, 0
3146, 0.58333333333333, 0.55, 0
3147, 0.58333333333333, 0.6, 0
3148, 0.58333333333333, 0.65, 0
3149, 0.58333333333333, 0.7, 0
3150, 0.58333333333333, 0.75, 0
3151, 0.58333333333333, 0.8, 0
3152, 0.58333333333333, 0.85, 0
3153, 0.58333333333333, 0.9, 0
3154, 0.58333333333333, 0.95, 0
3155, 0.58333333333333, 1, 0
3156, 0.58333333333333, 1.05, 0
3157, 0.58333333333333, 1.1, 0
3158, 0.58333333333333, 1.15, 0
3159, 0.58333333333333, 1.2, 0
3160, 0.58333333333333, 1.25, 0
3161, 0.58333333333333, 1.3, 0
3162, 0.625, 0.2, 0
3163, 0.625, 0.25, 0
3164, 0.625, 0.3, 0
3165, 0.625, 0.35, 0
3166, 0.625, 0.4, 0
3167, 0.625, 0.45, 0
3168, 0.625, 0.5, 0
3169, 0.625, 0.55, 0
3170, 0.625, 0.6, 0
3171, 0.625, 0.65, 0
3172, 0.625, 0.7, 0
3173, 0.625, 0.75, 0
3174, 0.625, 0.8, 0
3175, 0.625, 0.85, 0
3176, 0.625, 0.9, 0
3177, 0.625, 0.95, 0
3178, 0.625, 1, 0
3179, 0.625, 1.05, 0
3180, 0.625, 1.1, 0
3181, 0.625, 1.15, 0
3182, 0.625, 1.2, 0
3183, 0.625, 1.25, 0
3184, 0.625, 1.3, 0
3185, 0.66666666666667, 0.2, 0
3186, 0.66666666666667, 0.25, 0
3187, 0.66666666666667, 0.3, 0
3188, 0.66666666666667, 0.35, 0
3189, 0.66666666666667, 0.4, 0
3190, 0.66666666666667, 0.45, 0
3191, 0.66666666666667, 0.5, 0
3192, 0.66666666666667, 0.55, 0
3193, 0.66666666666667, 0.6, 0
3194, 0.66666666666667, 0.65, 0
3195, 0.66666666666667, 0.7, 0
3196, 0.66666666666667, 0.75, 0
3197, 0.66666666666667, 0.8, 0
3198, 0.66666666666667, 0.85, 0
3199, 0.66666666666667, 0.9, 0
3200, 0.66666666666667, 0.95, 0
3201, 0.66666666666667, 1, 0
3202, 0.66666666666667, 1.05, 0
3203, 0.66666666666667, 1.1, 0
3204, 0.66666666666667, 1.15, 0
3205, 0.66666666666667, 1.2, 0
3206, 0.66666666666667, 1.25, 0
3207, 0.66666666666667, 1.3, 0
3208, 0.70833333333333, 0.2, 0
3209, 0.70833333333333, 0.25, 0
3210, 0.70833333333333, 0.3, 0
3211, 0.70833333333333, 0.35, 0
3212, 0.70833333333333, 0.4, 0
3213, 0.70833333333333, 0.45, 0
3214, 0.70833333333333, 0.5, 0
3215, 0.70833333333333, 0.55, 0
3216, 0.70833333333333, 0.6, 0
3217, 0.70833333333333, 0.65, 0
3218, 0.70833333333333, 0.7, 0
3219, 0.70833333333333, 0.75, 0
3220, 0.70833333333333, 0.8, 0
3221, 0.70833333333333, 0.85, 0
3222, 0.70833333333333, 0.9, 0
3223, 0.70833333333333, 0.95, 0
3224, 0.70833333333333, 1, 0
3225, 0.70833333333333, 1.05, 0
3226, 0.70833333333333, 1.1, 0
3227, 0.70833333333333, 1.15, 0
3228, 0.70833333333333, 1.2, 0
3229, 0.70833333333333, 1.25, 0
3230, 0.70833333333333, 1.3, 0
3231, 0.75, 0.2, 0
3232, 0.75, 0.25, 0
3233, 0.75, 0.3, 0
3234, 0.75, 0.35, 0
3235, 0.75, 0.4, 0
3236, 0.75, 0.45, 0
3237, 0.75, 0.5, 0
3238, 0.75, 0.55, 0
3239, 0.75, 0.6, 0
3240, 0.75, 0.65, 0
3241, 0.75, 0.7, 0
3242, 0.75, 0.75, 0
3243, 0.75, 0.8, 0
3244, 0.75, 0.85, 0
3245, 0.75, 0.9, 0
3246, 0.75, 0.95, 0
3247, 0.75, 1, 0
3248, 0.75, 1.05, 0
3249, 0.75, 1.1, 0
3250, 0.75, 1.15, 0
3251, 0.75, 1.2, 0
3252, 0.75, 1.25, 0
3253, 0.75, 1.3, 0
3254, 0.79166666666667, 0.2, 0
3255, 0.79166666666667, 0.25, 0
3256, 0.79166666666667, 0.3, 0
3257, 0.79166666666667, 0.35, 0
3258, 0.79166666666667, 0.4, 0
3259, 0.79166666666667, 0.45, 0
3260, 0.79166666666667, 0.5, 0
3261, 0.79166666666667, 0.55, 0
3262, 0.79166666666667, 0.6, 0
3263, 0.79166666666667, 0.65, 0
3264, 0.79166666666667, 0.7, 0
3265, 0.79166666666667, 0.75, 0
3266, 0.79166666666667, 0.8, 0
3267, 0.79166666666667, 0.85, 0
3268, 0.79166666666667, 0.9, 0
3269, 0.79166666666667, 0.95, 0
3270, 0.79166666666667, 1, 0
3271, 0.79166666666667, 1.05, 0
3272, 0.79166666666667, 1.1, 0
3273, 0.79166666666667, 1.15, 0
3274, 0.79166666666667, 1.2, 0
3275, 0.79166666666667, 1.25, 0
3276, 0.79166666666667, 1.3, 0
3277, 0.83333333333333, 0.2, 0
3278, 0.83333333333333, 0.25, 0
3279, 0.83333333333333, 0.3, 0
3280, 0.83333333333333, 0.35, 0
3281, 0.83333333333333, 0.4, 0
3282, 0.83333333333333, 0.45, 0
3283, 0.83333333333333, 0.5, 0
3284, 0.83333333333333, 0.55, 0
3285, 0.83333333333333, 0.6, 0
3286, 0.83333333333333, 0.65, 0
3287, 0.83333333333333, 0.7, 0
3288, 0.83333333333333, 0.75, 0
3289, 0.83333333333333, 0.8, 0
3290, 0.83333333333333, 0.85, 0
3291, 0.83333333333333, 0.9, 0
3292, 0.83333333333333, 0.95, 0
3293, 0.83333333333333, 1, 0
3294, 0.83333333333333, 1.05, 0
3295, 0.83333333333333, 1.1, 0
3296, 0.83333333333333, 1.15, 0
3297, 0.83333333333333, 1.2, 0
3298, 0.83333333333333, 1.25, 0
3299, 0.83333333333333, 1.3, 0
3300, 0.875, 0.2, 0
3301, 0.875, 0.25, 0
3302, 0.875, 0.3, 0
3303, 0.875, 0.35, 0
3304, 0.875, 0.4, 0
3305, 0.875, 0.45, 0
3306, 0.875, 0.5, 0
3307, 0.875, 0.55, 0
3308, 0.875, 0.6, 0
3309, 0.875, 0.65, 0
3310, 0.875, 0.7, 0
3311, 0.875, 0.75, 0
