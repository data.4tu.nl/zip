28661, 0.083333333333333, -0.12, 0.41666666666667
28662, 0.083333333333333, -0.16, 0.41666666666667
28663, 0.083333333333333, -0.04, 0.45833333333333
28664, 0.083333333333333, -0.08, 0.45833333333333
28665, 0.083333333333333, -0.12, 0.45833333333333
28666, 0.083333333333333, -0.16, 0.45833333333333
28667, 0.125, -0.04, 0.041666666666667
28668, 0.125, -0.08, 0.041666666666667
28669, 0.125, -0.12, 0.041666666666667
28670, 0.125, -0.16, 0.041666666666667
28671, 0.125, -0.04, 0.083333333333333
28672, 0.125, -0.08, 0.083333333333333
28673, 0.125, -0.12, 0.083333333333333
28674, 0.125, -0.16, 0.083333333333333
28675, 0.125, -0.04, 0.125
28676, 0.125, -0.08, 0.125
28677, 0.125, -0.12, 0.125
28678, 0.125, -0.16, 0.125
28679, 0.125, -0.04, 0.16666666666667
28680, 0.125, -0.08, 0.16666666666667
28681, 0.125, -0.12, 0.16666666666667
28682, 0.125, -0.16, 0.16666666666667
28683, 0.125, -0.04, 0.20833333333333
28684, 0.125, -0.08, 0.20833333333333
28685, 0.125, -0.12, 0.20833333333333
28686, 0.125, -0.16, 0.20833333333333
28687, 0.125, -0.04, 0.25
28688, 0.125, -0.08, 0.25
28689, 0.125, -0.12, 0.25
28690, 0.125, -0.16, 0.25
28691, 0.125, -0.04, 0.29166666666667
28692, 0.125, -0.08, 0.29166666666667
28693, 0.125, -0.12, 0.29166666666667
28694, 0.125, -0.16, 0.29166666666667
28695, 0.125, -0.04, 0.33333333333333
28696, 0.125, -0.08, 0.33333333333333
28697, 0.125, -0.12, 0.33333333333333
28698, 0.125, -0.16, 0.33333333333333
28699, 0.125, -0.04, 0.375
28700, 0.125, -0.08, 0.375
28701, 0.125, -0.12, 0.375
28702, 0.125, -0.16, 0.375
28703, 0.125, -0.04, 0.41666666666667
28704, 0.125, -0.08, 0.41666666666667
28705, 0.125, -0.12, 0.41666666666667
28706, 0.125, -0.16, 0.41666666666667
28707, 0.125, -0.04, 0.45833333333333
28708, 0.125, -0.08, 0.45833333333333
28709, 0.125, -0.12, 0.45833333333333
28710, 0.125, -0.16, 0.45833333333333
28711, 0.16666666666667, -0.04, 0.041666666666667
28712, 0.16666666666667, -0.08, 0.041666666666667
28713, 0.16666666666667, -0.12, 0.041666666666667
28714, 0.16666666666667, -0.16, 0.041666666666667
28715, 0.16666666666667, -0.04, 0.083333333333333
28716, 0.16666666666667, -0.08, 0.083333333333333
28717, 0.16666666666667, -0.12, 0.083333333333333
28718, 0.16666666666667, -0.16, 0.083333333333333
28719, 0.16666666666667, -0.04, 0.125
28720, 0.16666666666667, -0.08, 0.125
28721, 0.16666666666667, -0.12, 0.125
28722, 0.16666666666667, -0.16, 0.125
28723, 0.16666666666667, -0.04, 0.16666666666667
28724, 0.16666666666667, -0.08, 0.16666666666667
28725, 0.16666666666667, -0.12, 0.16666666666667
28726, 0.16666666666667, -0.16, 0.16666666666667
28727, 0.16666666666667, -0.04, 0.20833333333333
28728, 0.16666666666667, -0.08, 0.20833333333333
28729, 0.16666666666667, -0.12, 0.20833333333333
28730, 0.16666666666667, -0.16, 0.20833333333333
28731, 0.16666666666667, -0.04, 0.25
28732, 0.16666666666667, -0.08, 0.25
28733, 0.16666666666667, -0.12, 0.25
28734, 0.16666666666667, -0.16, 0.25
28735, 0.16666666666667, -0.04, 0.29166666666667
28736, 0.16666666666667, -0.08, 0.29166666666667
28737, 0.16666666666667, -0.12, 0.29166666666667
28738, 0.16666666666667, -0.16, 0.29166666666667
28739, 0.16666666666667, -0.04, 0.33333333333333
28740, 0.16666666666667, -0.08, 0.33333333333333
28741, 0.16666666666667, -0.12, 0.33333333333333
28742, 0.16666666666667, -0.16, 0.33333333333333
28743, 0.16666666666667, -0.04, 0.375
28744, 0.16666666666667, -0.08, 0.375
28745, 0.16666666666667, -0.12, 0.375
28746, 0.16666666666667, -0.16, 0.375
28747, 0.16666666666667, -0.04, 0.41666666666667
28748, 0.16666666666667, -0.08, 0.41666666666667
28749, 0.16666666666667, -0.12, 0.41666666666667
28750, 0.16666666666667, -0.16, 0.41666666666667
28751, 0.16666666666667, -0.04, 0.45833333333333
28752, 0.16666666666667, -0.08, 0.45833333333333
28753, 0.16666666666667, -0.12, 0.45833333333333
28754, 0.16666666666667, -0.16, 0.45833333333333
28755, 0.20833333333333, -0.04, 0.041666666666667
28756, 0.20833333333333, -0.08, 0.041666666666667
28757, 0.20833333333333, -0.12, 0.041666666666667
28758, 0.20833333333333, -0.16, 0.041666666666667
28759, 0.20833333333333, -0.04, 0.083333333333333
28760, 0.20833333333333, -0.08, 0.083333333333333
28761, 0.20833333333333, -0.12, 0.083333333333333
28762, 0.20833333333333, -0.16, 0.083333333333333
28763, 0.20833333333333, -0.04, 0.125
28764, 0.20833333333333, -0.08, 0.125
28765, 0.20833333333333, -0.12, 0.125
28766, 0.20833333333333, -0.16, 0.125
28767, 0.20833333333333, -0.04, 0.16666666666667
28768, 0.20833333333333, -0.08, 0.16666666666667
28769, 0.20833333333333, -0.12, 0.16666666666667
28770, 0.20833333333333, -0.16, 0.16666666666667
28771, 0.20833333333333, -0.04, 0.20833333333333
28772, 0.20833333333333, -0.08, 0.20833333333333
28773, 0.20833333333333, -0.12, 0.20833333333333
28774, 0.20833333333333, -0.16, 0.20833333333333
28775, 0.20833333333333, -0.04, 0.25
28776, 0.20833333333333, -0.08, 0.25
28777, 0.20833333333333, -0.12, 0.25
28778, 0.20833333333333, -0.16, 0.25
28779, 0.20833333333333, -0.04, 0.29166666666667
28780, 0.20833333333333, -0.08, 0.29166666666667
28781, 0.20833333333333, -0.12, 0.29166666666667
28782, 0.20833333333333, -0.16, 0.29166666666667
28783, 0.20833333333333, -0.04, 0.33333333333333
28784, 0.20833333333333, -0.08, 0.33333333333333
28785, 0.20833333333333, -0.12, 0.33333333333333
28786, 0.20833333333333, -0.16, 0.33333333333333
28787, 0.20833333333333, -0.04, 0.375
28788, 0.20833333333333, -0.08, 0.375
28789, 0.20833333333333, -0.12, 0.375
28790, 0.20833333333333, -0.16, 0.375
28791, 0.20833333333333, -0.04, 0.41666666666667
28792, 0.20833333333333, -0.08, 0.41666666666667
28793, 0.20833333333333, -0.12, 0.41666666666667
28794, 0.20833333333333, -0.16, 0.41666666666667
28795, 0.20833333333333, -0.04, 0.45833333333333
28796, 0.20833333333333, -0.08, 0.45833333333333
28797, 0.20833333333333, -0.12, 0.45833333333333
28798, 0.20833333333333, -0.16, 0.45833333333333
28799, 0.25, -0.04, 0.041666666666667
28800, 0.25, -0.08, 0.041666666666667
28801, 0.25, -0.12, 0.041666666666667
28802, 0.25, -0.16, 0.041666666666667
28803, 0.25, -0.04, 0.083333333333333
28804, 0.25, -0.08, 0.083333333333333
28805, 0.25, -0.12, 0.083333333333333
28806, 0.25, -0.16, 0.083333333333333
28807, 0.25, -0.04, 0.125
28808, 0.25, -0.08, 0.125
28809, 0.25, -0.12, 0.125
28810, 0.25, -0.16, 0.125
28811, 0.25, -0.04, 0.16666666666667
28812, 0.25, -0.08, 0.16666666666667
28813, 0.25, -0.12, 0.16666666666667
28814, 0.25, -0.16, 0.16666666666667
28815, 0.25, -0.04, 0.20833333333333
28816, 0.25, -0.08, 0.20833333333333
28817, 0.25, -0.12, 0.20833333333333
28818, 0.25, -0.16, 0.20833333333333
28819, 0.25, -0.04, 0.25
28820, 0.25, -0.08, 0.25
28821, 0.25, -0.12, 0.25
28822, 0.25, -0.16, 0.25
28823, 0.25, -0.04, 0.29166666666667
28824, 0.25, -0.08, 0.29166666666667
28825, 0.25, -0.12, 0.29166666666667
28826, 0.25, -0.16, 0.29166666666667
28827, 0.25, -0.04, 0.33333333333333
28828, 0.25, -0.08, 0.33333333333333
28829, 0.25, -0.12, 0.33333333333333
28830, 0.25, -0.16, 0.33333333333333
28831, 0.25, -0.04, 0.375
28832, 0.25, -0.08, 0.375
28833, 0.25, -0.12, 0.375
28834, 0.25, -0.16, 0.375
28835, 0.25, -0.04, 0.41666666666667
28836, 0.25, -0.08, 0.41666666666667
28837, 0.25, -0.12, 0.41666666666667
28838, 0.25, -0.16, 0.41666666666667
28839, 0.25, -0.04, 0.45833333333333
28840, 0.25, -0.08, 0.45833333333333
28841, 0.25, -0.12, 0.45833333333333
28842, 0.25, -0.16, 0.45833333333333
28843, 0.29166666666667, -0.04, 0.041666666666667
28844, 0.29166666666667, -0.08, 0.041666666666667
28845, 0.29166666666667, -0.12, 0.041666666666667
28846, 0.29166666666667, -0.16, 0.041666666666667
28847, 0.29166666666667, -0.04, 0.083333333333333
28848, 0.29166666666667, -0.08, 0.083333333333333
28849, 0.29166666666667, -0.12, 0.083333333333333
28850, 0.29166666666667, -0.16, 0.083333333333333
28851, 0.29166666666667, -0.04, 0.125
28852, 0.29166666666667, -0.08, 0.125
28853, 0.29166666666667, -0.12, 0.125
28854, 0.29166666666667, -0.16, 0.125
28855, 0.29166666666667, -0.04, 0.16666666666667
28856, 0.29166666666667, -0.08, 0.16666666666667
28857, 0.29166666666667, -0.12, 0.16666666666667
28858, 0.29166666666667, -0.16, 0.16666666666667
28859, 0.29166666666667, -0.04, 0.20833333333333
28860, 0.29166666666667, -0.08, 0.20833333333333
28861, 0.29166666666667, -0.12, 0.20833333333333
28862, 0.29166666666667, -0.16, 0.20833333333333
28863, 0.29166666666667, -0.04, 0.25
28864, 0.29166666666667, -0.08, 0.25
28865, 0.29166666666667, -0.12, 0.25
28866, 0.29166666666667, -0.16, 0.25
28867, 0.29166666666667, -0.04, 0.29166666666667
28868, 0.29166666666667, -0.08, 0.29166666666667
28869, 0.29166666666667, -0.12, 0.29166666666667
28870, 0.29166666666667, -0.16, 0.29166666666667
28871, 0.29166666666667, -0.04, 0.33333333333333
28872, 0.29166666666667, -0.08, 0.33333333333333
28873, 0.29166666666667, -0.12, 0.33333333333333
28874, 0.29166666666667, -0.16, 0.33333333333333
28875, 0.29166666666667, -0.04, 0.375
28876, 0.29166666666667, -0.08, 0.375
28877, 0.29166666666667, -0.12, 0.375
28878, 0.29166666666667, -0.16, 0.375
28879, 0.29166666666667, -0.04, 0.41666666666667
28880, 0.29166666666667, -0.08, 0.41666666666667
28881, 0.29166666666667, -0.12, 0.41666666666667
28882, 0.29166666666667, -0.16, 0.41666666666667
28883, 0.29166666666667, -0.04, 0.45833333333333
28884, 0.29166666666667, -0.08, 0.45833333333333
28885, 0.29166666666667, -0.12, 0.45833333333333
28886, 0.29166666666667, -0.16, 0.45833333333333
28887, 0.33333333333333, -0.04, 0.041666666666667
28888, 0.33333333333333, -0.08, 0.041666666666667
28889, 0.33333333333333, -0.12, 0.041666666666667
28890, 0.33333333333333, -0.16, 0.041666666666667
28891, 0.33333333333333, -0.04, 0.083333333333333
28892, 0.33333333333333, -0.08, 0.083333333333333
28893, 0.33333333333333, -0.12, 0.083333333333333
28894, 0.33333333333333, -0.16, 0.083333333333333
28895, 0.33333333333333, -0.04, 0.125
28896, 0.33333333333333, -0.08, 0.125
28897, 0.33333333333333, -0.12, 0.125
28898, 0.33333333333333, -0.16, 0.125
28899, 0.33333333333333, -0.04, 0.16666666666667
28900, 0.33333333333333, -0.08, 0.16666666666667
28901, 0.33333333333333, -0.12, 0.16666666666667
28902, 0.33333333333333, -0.16, 0.16666666666667
28903, 0.33333333333333, -0.04, 0.20833333333333
28904, 0.33333333333333, -0.08, 0.20833333333333
28905, 0.33333333333333, -0.12, 0.20833333333333
28906, 0.33333333333333, -0.16, 0.20833333333333
28907, 0.33333333333333, -0.04, 0.25
28908, 0.33333333333333, -0.08, 0.25
28909, 0.33333333333333, -0.12, 0.25
28910, 0.33333333333333, -0.16, 0.25
28911, 0.33333333333333, -0.04, 0.29166666666667
28912, 0.33333333333333, -0.08, 0.29166666666667
28913, 0.33333333333333, -0.12, 0.29166666666667
28914, 0.33333333333333, -0.16, 0.29166666666667
28915, 0.33333333333333, -0.04, 0.33333333333333
28916, 0.33333333333333, -0.08, 0.33333333333333
28917, 0.33333333333333, -0.12, 0.33333333333333
28918, 0.33333333333333, -0.16, 0.33333333333333
28919, 0.33333333333333, -0.04, 0.375
28920, 0.33333333333333, -0.08, 0.375
28921, 0.33333333333333, -0.12, 0.375
28922, 0.33333333333333, -0.16, 0.375
28923, 0.33333333333333, -0.04, 0.41666666666667
28924, 0.33333333333333, -0.08, 0.41666666666667
28925, 0.33333333333333, -0.12, 0.41666666666667
28926, 0.33333333333333, -0.16, 0.41666666666667
28927, 0.33333333333333, -0.04, 0.45833333333333
28928, 0.33333333333333, -0.08, 0.45833333333333
28929, 0.33333333333333, -0.12, 0.45833333333333
28930, 0.33333333333333, -0.16, 0.45833333333333
28931, 0.375, -0.04, 0.041666666666667
28932, 0.375, -0.08, 0.041666666666667
28933, 0.375, -0.12, 0.041666666666667
28934, 0.375, -0.16, 0.041666666666667
28935, 0.375, -0.04, 0.083333333333333
28936, 0.375, -0.08, 0.083333333333333
28937, 0.375, -0.12, 0.083333333333333
28938, 0.375, -0.16, 0.083333333333333
28939, 0.375, -0.04, 0.125
28940, 0.375, -0.08, 0.125
28941, 0.375, -0.12, 0.125
28942, 0.375, -0.16, 0.125
28943, 0.375, -0.04, 0.16666666666667
28944, 0.375, -0.08, 0.16666666666667
28945, 0.375, -0.12, 0.16666666666667
28946, 0.375, -0.16, 0.16666666666667
28947, 0.375, -0.04, 0.20833333333333
28948, 0.375, -0.08, 0.20833333333333
28949, 0.375, -0.12, 0.20833333333333
28950, 0.375, -0.16, 0.20833333333333
28951, 0.375, -0.04, 0.25
28952, 0.375, -0.08, 0.25
28953, 0.375, -0.12, 0.25
28954, 0.375, -0.16, 0.25
28955, 0.375, -0.04, 0.29166666666667
28956, 0.375, -0.08, 0.29166666666667
28957, 0.375, -0.12, 0.29166666666667
28958, 0.375, -0.16, 0.29166666666667
28959, 0.375, -0.04, 0.33333333333333
28960, 0.375, -0.08, 0.33333333333333
28961, 0.375, -0.12, 0.33333333333333
28962, 0.375, -0.16, 0.33333333333333
28963, 0.375, -0.04, 0.375
28964, 0.375, -0.08, 0.375
28965, 0.375, -0.12, 0.375
28966, 0.375, -0.16, 0.375
28967, 0.375, -0.04, 0.41666666666667
28968, 0.375, -0.08, 0.41666666666667
28969, 0.375, -0.12, 0.41666666666667
28970, 0.375, -0.16, 0.41666666666667
28971, 0.375, -0.04, 0.45833333333333
28972, 0.375, -0.08, 0.45833333333333
28973, 0.375, -0.12, 0.45833333333333
28974, 0.375, -0.16, 0.45833333333333
28975, 0.41666666666667, -0.04, 0.041666666666667
28976, 0.41666666666667, -0.08, 0.041666666666667
28977, 0.41666666666667, -0.12, 0.041666666666667
28978, 0.41666666666667, -0.16, 0.041666666666667
28979, 0.41666666666667, -0.04, 0.083333333333333
28980, 0.41666666666667, -0.08, 0.083333333333333
28981, 0.41666666666667, -0.12, 0.083333333333333
28982, 0.41666666666667, -0.16, 0.083333333333333
28983, 0.41666666666667, -0.04, 0.125
28984, 0.41666666666667, -0.08, 0.125
28985, 0.41666666666667, -0.12, 0.125
28986, 0.41666666666667, -0.16, 0.125
28987, 0.41666666666667, -0.04, 0.16666666666667
28988, 0.41666666666667, -0.08, 0.16666666666667
28989, 0.41666666666667, -0.12, 0.16666666666667
28990, 0.41666666666667, -0.16, 0.16666666666667
28991, 0.41666666666667, -0.04, 0.20833333333333
28992, 0.41666666666667, -0.08, 0.20833333333333
28993, 0.41666666666667, -0.12, 0.20833333333333
28994, 0.41666666666667, -0.16, 0.20833333333333
28995, 0.41666666666667, -0.04, 0.25
28996, 0.41666666666667, -0.08, 0.25
28997, 0.41666666666667, -0.12, 0.25
28998, 0.41666666666667, -0.16, 0.25
28999, 0.41666666666667, -0.04, 0.29166666666667
29000, 0.41666666666667, -0.08, 0.29166666666667
29001, 0.41666666666667, -0.12, 0.29166666666667
29002, 0.41666666666667, -0.16, 0.29166666666667
29003, 0.41666666666667, -0.04, 0.33333333333333
29004, 0.41666666666667, -0.08, 0.33333333333333
29005, 0.41666666666667, -0.12, 0.33333333333333
29006, 0.41666666666667, -0.16, 0.33333333333333
29007, 0.41666666666667, -0.04, 0.375
29008, 0.41666666666667, -0.08, 0.375
29009, 0.41666666666667, -0.12, 0.375
29010, 0.41666666666667, -0.16, 0.375
29011, 0.41666666666667, -0.04, 0.41666666666667
29012, 0.41666666666667, -0.08, 0.41666666666667
29013, 0.41666666666667, -0.12, 0.41666666666667
29014, 0.41666666666667, -0.16, 0.41666666666667
29015, 0.41666666666667, -0.04, 0.45833333333333
29016, 0.41666666666667, -0.08, 0.45833333333333
29017, 0.41666666666667, -0.12, 0.45833333333333
29018, 0.41666666666667, -0.16, 0.45833333333333
29019, 0.45833333333333, -0.04, 0.041666666666667
29020, 0.45833333333333, -0.08, 0.041666666666667
29021, 0.45833333333333, -0.12, 0.041666666666667
29022, 0.45833333333333, -0.16, 0.041666666666667
29023, 0.45833333333333, -0.04, 0.083333333333333
29024, 0.45833333333333, -0.08, 0.083333333333333
29025, 0.45833333333333, -0.12, 0.083333333333333
29026, 0.45833333333333, -0.16, 0.083333333333333
29027, 0.45833333333333, -0.04, 0.125
29028, 0.45833333333333, -0.08, 0.125
29029, 0.45833333333333, -0.12, 0.125
29030, 0.45833333333333, -0.16, 0.125
29031, 0.45833333333333, -0.04, 0.16666666666667
29032, 0.45833333333333, -0.08, 0.16666666666667
29033, 0.45833333333333, -0.12, 0.16666666666667
29034, 0.45833333333333, -0.16, 0.16666666666667
29035, 0.45833333333333, -0.04, 0.20833333333333
29036, 0.45833333333333, -0.08, 0.20833333333333
29037, 0.45833333333333, -0.12, 0.20833333333333
29038, 0.45833333333333, -0.16, 0.20833333333333
29039, 0.45833333333333, -0.04, 0.25
29040, 0.45833333333333, -0.08, 0.25
29041, 0.45833333333333, -0.12, 0.25
29042, 0.45833333333333, -0.16, 0.25
29043, 0.45833333333333, -0.04, 0.29166666666667
29044, 0.45833333333333, -0.08, 0.29166666666667
29045, 0.45833333333333, -0.12, 0.29166666666667
29046, 0.45833333333333, -0.16, 0.29166666666667
29047, 0.45833333333333, -0.04, 0.33333333333333
29048, 0.45833333333333, -0.08, 0.33333333333333
29049, 0.45833333333333, -0.12, 0.33333333333333
29050, 0.45833333333333, -0.16, 0.33333333333333
29051, 0.45833333333333, -0.04, 0.375
29052, 0.45833333333333, -0.08, 0.375
29053, 0.45833333333333, -0.12, 0.375
29054, 0.45833333333333, -0.16, 0.375
29055, 0.45833333333333, -0.04, 0.41666666666667
29056, 0.45833333333333, -0.08, 0.41666666666667
29057, 0.45833333333333, -0.12, 0.41666666666667
29058, 0.45833333333333, -0.16, 0.41666666666667
29059, 0.45833333333333, -0.04, 0.45833333333333
29060, 0.45833333333333, -0.08, 0.45833333333333
29061, 0.45833333333333, -0.12, 0.45833333333333
29062, 0.45833333333333, -0.16, 0.45833333333333
29063, 0.5, -0.04, 0.041666666666667
29064, 0.5, -0.08, 0.041666666666667
29065, 0.5, -0.12, 0.041666666666667
29066, 0.5, -0.16, 0.041666666666667
29067, 0.5, -0.04, 0.083333333333333
29068, 0.5, -0.08, 0.083333333333333
29069, 0.5, -0.12, 0.083333333333333
29070, 0.5, -0.16, 0.083333333333333
29071, 0.5, -0.04, 0.125
29072, 0.5, -0.08, 0.125
29073, 0.5, -0.12, 0.125
29074, 0.5, -0.16, 0.125
29075, 0.5, -0.04, 0.16666666666667
29076, 0.5, -0.08, 0.16666666666667
29077, 0.5, -0.12, 0.16666666666667
29078, 0.5, -0.16, 0.16666666666667
29079, 0.5, -0.04, 0.20833333333333
29080, 0.5, -0.08, 0.20833333333333
29081, 0.5, -0.12, 0.20833333333333
29082, 0.5, -0.16, 0.20833333333333
29083, 0.5, -0.04, 0.25
29084, 0.5, -0.08, 0.25
29085, 0.5, -0.12, 0.25
29086, 0.5, -0.16, 0.25
29087, 0.5, -0.04, 0.29166666666667
29088, 0.5, -0.08, 0.29166666666667
29089, 0.5, -0.12, 0.29166666666667
29090, 0.5, -0.16, 0.29166666666667
29091, 0.5, -0.04, 0.33333333333333
29092, 0.5, -0.08, 0.33333333333333
29093, 0.5, -0.12, 0.33333333333333
29094, 0.5, -0.16, 0.33333333333333
29095, 0.5, -0.04, 0.375
29096, 0.5, -0.08, 0.375
29097, 0.5, -0.12, 0.375
29098, 0.5, -0.16, 0.375
29099, 0.5, -0.04, 0.41666666666667
29100, 0.5, -0.08, 0.41666666666667
29101, 0.5, -0.12, 0.41666666666667
29102, 0.5, -0.16, 0.41666666666667
29103, 0.5, -0.04, 0.45833333333333
29104, 0.5, -0.08, 0.45833333333333
29105, 0.5, -0.12, 0.45833333333333
29106, 0.5, -0.16, 0.45833333333333
29107, 0.54166666666667, -0.04, 0.041666666666667
29108, 0.54166666666667, -0.08, 0.041666666666667
29109, 0.54166666666667, -0.12, 0.041666666666667
29110, 0.54166666666667, -0.16, 0.041666666666667
29111, 0.54166666666667, -0.04, 0.083333333333333
29112, 0.54166666666667, -0.08, 0.083333333333333
29113, 0.54166666666667, -0.12, 0.083333333333333
29114, 0.54166666666667, -0.16, 0.083333333333333
29115, 0.54166666666667, -0.04, 0.125
29116, 0.54166666666667, -0.08, 0.125
29117, 0.54166666666667, -0.12, 0.125
29118, 0.54166666666667, -0.16, 0.125
29119, 0.54166666666667, -0.04, 0.16666666666667
29120, 0.54166666666667, -0.08, 0.16666666666667
29121, 0.54166666666667, -0.12, 0.16666666666667
29122, 0.54166666666667, -0.16, 0.16666666666667
29123, 0.54166666666667, -0.04, 0.20833333333333
29124, 0.54166666666667, -0.08, 0.20833333333333
29125, 0.54166666666667, -0.12, 0.20833333333333
29126, 0.54166666666667, -0.16, 0.20833333333333
29127, 0.54166666666667, -0.04, 0.25
29128, 0.54166666666667, -0.08, 0.25
29129, 0.54166666666667, -0.12, 0.25
29130, 0.54166666666667, -0.16, 0.25
29131, 0.54166666666667, -0.04, 0.29166666666667
29132, 0.54166666666667, -0.08, 0.29166666666667
29133, 0.54166666666667, -0.12, 0.29166666666667
29134, 0.54166666666667, -0.16, 0.29166666666667
29135, 0.54166666666667, -0.04, 0.33333333333333
29136, 0.54166666666667, -0.08, 0.33333333333333
29137, 0.54166666666667, -0.12, 0.33333333333333
29138, 0.54166666666667, -0.16, 0.33333333333333
29139, 0.54166666666667, -0.04, 0.375
29140, 0.54166666666667, -0.08, 0.375
29141, 0.54166666666667, -0.12, 0.375
29142, 0.54166666666667, -0.16, 0.375
29143, 0.54166666666667, -0.04, 0.41666666666667
29144, 0.54166666666667, -0.08, 0.41666666666667
29145, 0.54166666666667, -0.12, 0.41666666666667
29146, 0.54166666666667, -0.16, 0.41666666666667
29147, 0.54166666666667, -0.04, 0.45833333333333
29148, 0.54166666666667, -0.08, 0.45833333333333
29149, 0.54166666666667, -0.12, 0.45833333333333
29150, 0.54166666666667, -0.16, 0.45833333333333
29151, 0.58333333333333, -0.04, 0.041666666666667
29152, 0.58333333333333, -0.08, 0.041666666666667
29153, 0.58333333333333, -0.12, 0.041666666666667
29154, 0.58333333333333, -0.16, 0.041666666666667
29155, 0.58333333333333, -0.04, 0.083333333333333
29156, 0.58333333333333, -0.08, 0.083333333333333
29157, 0.58333333333333, -0.12, 0.083333333333333
29158, 0.58333333333333, -0.16, 0.083333333333333
29159, 0.58333333333333, -0.04, 0.125
29160, 0.58333333333333, -0.08, 0.125
29161, 0.58333333333333, -0.12, 0.125
29162, 0.58333333333333, -0.16, 0.125
29163, 0.58333333333333, -0.04, 0.16666666666667
29164, 0.58333333333333, -0.08, 0.16666666666667
29165, 0.58333333333333, -0.12, 0.16666666666667
29166, 0.58333333333333, -0.16, 0.16666666666667
29167, 0.58333333333333, -0.04, 0.20833333333333
29168, 0.58333333333333, -0.08, 0.20833333333333
29169, 0.58333333333333, -0.12, 0.20833333333333
29170, 0.58333333333333, -0.16, 0.20833333333333
29171, 0.58333333333333, -0.04, 0.25
29172, 0.58333333333333, -0.08, 0.25
29173, 0.58333333333333, -0.12, 0.25
29174, 0.58333333333333, -0.16, 0.25
29175, 0.58333333333333, -0.04, 0.29166666666667
29176, 0.58333333333333, -0.08, 0.29166666666667
29177, 0.58333333333333, -0.12, 0.29166666666667
29178, 0.58333333333333, -0.16, 0.29166666666667
29179, 0.58333333333333, -0.04, 0.33333333333333
29180, 0.58333333333333, -0.08, 0.33333333333333
29181, 0.58333333333333, -0.12, 0.33333333333333
29182, 0.58333333333333, -0.16, 0.33333333333333
29183, 0.58333333333333, -0.04, 0.375
29184, 0.58333333333333, -0.08, 0.375
29185, 0.58333333333333, -0.12, 0.375
29186, 0.58333333333333, -0.16, 0.375
29187, 0.58333333333333, -0.04, 0.41666666666667
29188, 0.58333333333333, -0.08, 0.41666666666667
29189, 0.58333333333333, -0.12, 0.41666666666667
29190, 0.58333333333333, -0.16, 0.41666666666667
29191, 0.58333333333333, -0.04, 0.45833333333333
29192, 0.58333333333333, -0.08, 0.45833333333333
29193, 0.58333333333333, -0.12, 0.45833333333333
29194, 0.58333333333333, -0.16, 0.45833333333333
29195, 0.625, -0.04, 0.041666666666667
29196, 0.625, -0.08, 0.041666666666667
29197, 0.625, -0.12, 0.041666666666667
29198, 0.625, -0.16, 0.041666666666667
29199, 0.625, -0.04, 0.083333333333333
29200, 0.625, -0.08, 0.083333333333333
29201, 0.625, -0.12, 0.083333333333333
29202, 0.625, -0.16, 0.083333333333333
29203, 0.625, -0.04, 0.125
29204, 0.625, -0.08, 0.125
29205, 0.625, -0.12, 0.125
29206, 0.625, -0.16, 0.125
29207, 0.625, -0.04, 0.16666666666667
29208, 0.625, -0.08, 0.16666666666667
29209, 0.625, -0.12, 0.16666666666667
29210, 0.625, -0.16, 0.16666666666667
29211, 0.625, -0.04, 0.20833333333333
29212, 0.625, -0.08, 0.20833333333333
29213, 0.625, -0.12, 0.20833333333333
29214, 0.625, -0.16, 0.20833333333333
29215, 0.625, -0.04, 0.25
29216, 0.625, -0.08, 0.25
29217, 0.625, -0.12, 0.25
29218, 0.625, -0.16, 0.25
29219, 0.625, -0.04, 0.29166666666667
29220, 0.625, -0.08, 0.29166666666667
29221, 0.625, -0.12, 0.29166666666667
29222, 0.625, -0.16, 0.29166666666667
29223, 0.625, -0.04, 0.33333333333333
29224, 0.625, -0.08, 0.33333333333333
29225, 0.625, -0.12, 0.33333333333333
29226, 0.625, -0.16, 0.33333333333333
29227, 0.625, -0.04, 0.375
29228, 0.625, -0.08, 0.375
29229, 0.625, -0.12, 0.375
29230, 0.625, -0.16, 0.375
29231, 0.625, -0.04, 0.41666666666667
29232, 0.625, -0.08, 0.41666666666667
29233, 0.625, -0.12, 0.41666666666667
29234, 0.625, -0.16, 0.41666666666667
29235, 0.625, -0.04, 0.45833333333333
29236, 0.625, -0.08, 0.45833333333333
29237, 0.625, -0.12, 0.45833333333333
29238, 0.625, -0.16, 0.45833333333333
29239, 0.66666666666667, -0.04, 0.041666666666667
29240, 0.66666666666667, -0.08, 0.041666666666667
29241, 0.66666666666667, -0.12, 0.041666666666667
29242, 0.66666666666667, -0.16, 0.041666666666667
29243, 0.66666666666667, -0.04, 0.083333333333333
29244, 0.66666666666667, -0.08, 0.083333333333333
29245, 0.66666666666667, -0.12, 0.083333333333333
29246, 0.66666666666667, -0.16, 0.083333333333333
29247, 0.66666666666667, -0.04, 0.125
29248, 0.66666666666667, -0.08, 0.125
29249, 0.66666666666667, -0.12, 0.125
29250, 0.66666666666667, -0.16, 0.125
29251, 0.66666666666667, -0.04, 0.16666666666667
29252, 0.66666666666667, -0.08, 0.16666666666667
29253, 0.66666666666667, -0.12, 0.16666666666667
29254, 0.66666666666667, -0.16, 0.16666666666667
29255, 0.66666666666667, -0.04, 0.20833333333333
29256, 0.66666666666667, -0.08, 0.20833333333333
29257, 0.66666666666667, -0.12, 0.20833333333333
29258, 0.66666666666667, -0.16, 0.20833333333333
29259, 0.66666666666667, -0.04, 0.25
29260, 0.66666666666667, -0.08, 0.25
29261, 0.66666666666667, -0.12, 0.25
29262, 0.66666666666667, -0.16, 0.25
29263, 0.66666666666667, -0.04, 0.29166666666667
29264, 0.66666666666667, -0.08, 0.29166666666667
29265, 0.66666666666667, -0.12, 0.29166666666667
29266, 0.66666666666667, -0.16, 0.29166666666667
29267, 0.66666666666667, -0.04, 0.33333333333333
29268, 0.66666666666667, -0.08, 0.33333333333333
29269, 0.66666666666667, -0.12, 0.33333333333333
29270, 0.66666666666667, -0.16, 0.33333333333333
29271, 0.66666666666667, -0.04, 0.375
29272, 0.66666666666667, -0.08, 0.375
29273, 0.66666666666667, -0.12, 0.375
29274, 0.66666666666667, -0.16, 0.375
29275, 0.66666666666667, -0.04, 0.41666666666667
29276, 0.66666666666667, -0.08, 0.41666666666667
29277, 0.66666666666667, -0.12, 0.41666666666667
29278, 0.66666666666667, -0.16, 0.41666666666667
29279, 0.66666666666667, -0.04, 0.45833333333333
29280, 0.66666666666667, -0.08, 0.45833333333333
29281, 0.66666666666667, -0.12, 0.45833333333333
29282, 0.66666666666667, -0.16, 0.45833333333333
29283, 0.70833333333333, -0.04, 0.041666666666667
29284, 0.70833333333333, -0.08, 0.041666666666667
29285, 0.70833333333333, -0.12, 0.041666666666667
29286, 0.70833333333333, -0.16, 0.041666666666667
29287, 0.70833333333333, -0.04, 0.083333333333333
29288, 0.70833333333333, -0.08, 0.083333333333333
29289, 0.70833333333333, -0.12, 0.083333333333333
29290, 0.70833333333333, -0.16, 0.083333333333333
29291, 0.70833333333333, -0.04, 0.125
29292, 0.70833333333333, -0.08, 0.125
29293, 0.70833333333333, -0.12, 0.125
29294, 0.70833333333333, -0.16, 0.125
29295, 0.70833333333333, -0.04, 0.16666666666667
29296, 0.70833333333333, -0.08, 0.16666666666667
29297, 0.70833333333333, -0.12, 0.16666666666667
29298, 0.70833333333333, -0.16, 0.16666666666667
29299, 0.70833333333333, -0.04, 0.20833333333333
29300, 0.70833333333333, -0.08, 0.20833333333333
29301, 0.70833333333333, -0.12, 0.20833333333333
29302, 0.70833333333333, -0.16, 0.20833333333333
29303, 0.70833333333333, -0.04, 0.25
29304, 0.70833333333333, -0.08, 0.25
29305, 0.70833333333333, -0.12, 0.25
29306, 0.70833333333333, -0.16, 0.25
29307, 0.70833333333333, -0.04, 0.29166666666667
29308, 0.70833333333333, -0.08, 0.29166666666667
29309, 0.70833333333333, -0.12, 0.29166666666667
29310, 0.70833333333333, -0.16, 0.29166666666667
29311, 0.70833333333333, -0.04, 0.33333333333333
29312, 0.70833333333333, -0.08, 0.33333333333333
29313, 0.70833333333333, -0.12, 0.33333333333333
29314, 0.70833333333333, -0.16, 0.33333333333333
29315, 0.70833333333333, -0.04, 0.375
29316, 0.70833333333333, -0.08, 0.375
29317, 0.70833333333333, -0.12, 0.375
29318, 0.70833333333333, -0.16, 0.375
29319, 0.70833333333333, -0.04, 0.41666666666667
29320, 0.70833333333333, -0.08, 0.41666666666667
29321, 0.70833333333333, -0.12, 0.41666666666667
29322, 0.70833333333333, -0.16, 0.41666666666667
29323, 0.70833333333333, -0.04, 0.45833333333333
29324, 0.70833333333333, -0.08, 0.45833333333333
29325, 0.70833333333333, -0.12, 0.45833333333333
29326, 0.70833333333333, -0.16, 0.45833333333333
29327, 0.75, -0.04, 0.041666666666667
29328, 0.75, -0.08, 0.041666666666667
29329, 0.75, -0.12, 0.041666666666667
29330, 0.75, -0.16, 0.041666666666667
29331, 0.75, -0.04, 0.083333333333333
29332, 0.75, -0.08, 0.083333333333333
29333, 0.75, -0.12, 0.083333333333333
29334, 0.75, -0.16, 0.083333333333333
29335, 0.75, -0.04, 0.125
29336, 0.75, -0.08, 0.125
29337, 0.75, -0.12, 0.125
29338, 0.75, -0.16, 0.125
29339, 0.75, -0.04, 0.16666666666667
29340, 0.75, -0.08, 0.16666666666667
29341, 0.75, -0.12, 0.16666666666667
29342, 0.75, -0.16, 0.16666666666667
29343, 0.75, -0.04, 0.20833333333333
29344, 0.75, -0.08, 0.20833333333333
29345, 0.75, -0.12, 0.20833333333333
29346, 0.75, -0.16, 0.20833333333333
29347, 0.75, -0.04, 0.25
29348, 0.75, -0.08, 0.25
29349, 0.75, -0.12, 0.25
29350, 0.75, -0.16, 0.25
29351, 0.75, -0.04, 0.29166666666667
29352, 0.75, -0.08, 0.29166666666667
29353, 0.75, -0.12, 0.29166666666667
29354, 0.75, -0.16, 0.29166666666667
29355, 0.75, -0.04, 0.33333333333333
29356, 0.75, -0.08, 0.33333333333333
29357, 0.75, -0.12, 0.33333333333333
29358, 0.75, -0.16, 0.33333333333333
29359, 0.75, -0.04, 0.375
29360, 0.75, -0.08, 0.375
29361, 0.75, -0.12, 0.375
29362, 0.75, -0.16, 0.375
29363, 0.75, -0.04, 0.41666666666667
29364, 0.75, -0.08, 0.41666666666667
29365, 0.75, -0.12, 0.41666666666667
29366, 0.75, -0.16, 0.41666666666667
29367, 0.75, -0.04, 0.45833333333333
29368, 0.75, -0.08, 0.45833333333333
29369, 0.75, -0.12, 0.45833333333333
29370, 0.75, -0.16, 0.45833333333333
29371, 0.79166666666667, -0.04, 0.041666666666667
29372, 0.79166666666667, -0.08, 0.041666666666667
29373, 0.79166666666667, -0.12, 0.041666666666667
29374, 0.79166666666667, -0.16, 0.041666666666667
29375, 0.79166666666667, -0.04, 0.083333333333333
29376, 0.79166666666667, -0.08, 0.083333333333333
29377, 0.79166666666667, -0.12, 0.083333333333333
29378, 0.79166666666667, -0.16, 0.083333333333333
29379, 0.79166666666667, -0.04, 0.125
29380, 0.79166666666667, -0.08, 0.125
29381, 0.79166666666667, -0.12, 0.125
29382, 0.79166666666667, -0.16, 0.125
29383, 0.79166666666667, -0.04, 0.16666666666667
29384, 0.79166666666667, -0.08, 0.16666666666667
29385, 0.79166666666667, -0.12, 0.16666666666667
29386, 0.79166666666667, -0.16, 0.16666666666667
29387, 0.79166666666667, -0.04, 0.20833333333333
29388, 0.79166666666667, -0.08, 0.20833333333333
29389, 0.79166666666667, -0.12, 0.20833333333333
29390, 0.79166666666667, -0.16, 0.20833333333333
29391, 0.79166666666667, -0.04, 0.25
29392, 0.79166666666667, -0.08, 0.25
29393, 0.79166666666667, -0.12, 0.25
29394, 0.79166666666667, -0.16, 0.25
29395, 0.79166666666667, -0.04, 0.29166666666667
29396, 0.79166666666667, -0.08, 0.29166666666667
29397, 0.79166666666667, -0.12, 0.29166666666667
29398, 0.79166666666667, -0.16, 0.29166666666667
29399, 0.79166666666667, -0.04, 0.33333333333333
29400, 0.79166666666667, -0.08, 0.33333333333333
29401, 0.79166666666667, -0.12, 0.33333333333333
29402, 0.79166666666667, -0.16, 0.33333333333333
29403, 0.79166666666667, -0.04, 0.375
29404, 0.79166666666667, -0.08, 0.375
29405, 0.79166666666667, -0.12, 0.375
29406, 0.79166666666667, -0.16, 0.375
29407, 0.79166666666667, -0.04, 0.41666666666667
29408, 0.79166666666667, -0.08, 0.41666666666667
29409, 0.79166666666667, -0.12, 0.41666666666667
29410, 0.79166666666667, -0.16, 0.41666666666667
29411, 0.79166666666667, -0.04, 0.45833333333333
29412, 0.79166666666667, -0.08, 0.45833333333333
29413, 0.79166666666667, -0.12, 0.45833333333333
29414, 0.79166666666667, -0.16, 0.45833333333333
29415, 0.83333333333333, -0.04, 0.041666666666667
29416, 0.83333333333333, -0.08, 0.041666666666667
29417, 0.83333333333333, -0.12, 0.041666666666667
29418, 0.83333333333333, -0.16, 0.041666666666667
29419, 0.83333333333333, -0.04, 0.083333333333333
29420, 0.83333333333333, -0.08, 0.083333333333333
29421, 0.83333333333333, -0.12, 0.083333333333333
29422, 0.83333333333333, -0.16, 0.083333333333333
29423, 0.83333333333333, -0.04, 0.125
29424, 0.83333333333333, -0.08, 0.125
29425, 0.83333333333333, -0.12, 0.125
29426, 0.83333333333333, -0.16, 0.125
29427, 0.83333333333333, -0.04, 0.16666666666667
29428, 0.83333333333333, -0.08, 0.16666666666667
29429, 0.83333333333333, -0.12, 0.16666666666667
29430, 0.83333333333333, -0.16, 0.16666666666667
29431, 0.83333333333333, -0.04, 0.20833333333333
29432, 0.83333333333333, -0.08, 0.20833333333333
29433, 0.83333333333333, -0.12, 0.20833333333333
29434, 0.83333333333333, -0.16, 0.20833333333333
29435, 0.83333333333333, -0.04, 0.25
29436, 0.83333333333333, -0.08, 0.25
29437, 0.83333333333333, -0.12, 0.25
29438, 0.83333333333333, -0.16, 0.25
29439, 0.83333333333333, -0.04, 0.29166666666667
29440, 0.83333333333333, -0.08, 0.29166666666667
29441, 0.83333333333333, -0.12, 0.29166666666667
29442, 0.83333333333333, -0.16, 0.29166666666667
29443, 0.83333333333333, -0.04, 0.33333333333333
29444, 0.83333333333333, -0.08, 0.33333333333333
29445, 0.83333333333333, -0.12, 0.33333333333333
29446, 0.83333333333333, -0.16, 0.33333333333333
29447, 0.83333333333333, -0.04, 0.375
29448, 0.83333333333333, -0.08, 0.375
29449, 0.83333333333333, -0.12, 0.375
29450, 0.83333333333333, -0.16, 0.375
29451, 0.83333333333333, -0.04, 0.41666666666667
29452, 0.83333333333333, -0.08, 0.41666666666667
29453, 0.83333333333333, -0.12, 0.41666666666667
29454, 0.83333333333333, -0.16, 0.41666666666667
29455, 0.83333333333333, -0.04, 0.45833333333333
29456, 0.83333333333333, -0.08, 0.45833333333333
29457, 0.83333333333333, -0.12, 0.45833333333333
29458, 0.83333333333333, -0.16, 0.45833333333333
29459, 0.875, -0.04, 0.041666666666667
29460, 0.875, -0.08, 0.041666666666667
29461, 0.875, -0.12, 0.041666666666667
29462, 0.875, -0.16, 0.041666666666667
29463, 0.875, -0.04, 0.083333333333333
29464, 0.875, -0.08, 0.083333333333333
29465, 0.875, -0.12, 0.083333333333333
29466, 0.875, -0.16, 0.083333333333333
29467, 0.875, -0.04, 0.125
29468, 0.875, -0.08, 0.125
29469, 0.875, -0.12, 0.125
29470, 0.875, -0.16, 0.125
29471, 0.875, -0.04, 0.16666666666667
29472, 0.875, -0.08, 0.16666666666667
29473, 0.875, -0.12, 0.16666666666667
29474, 0.875, -0.16, 0.16666666666667
29475, 0.875, -0.04, 0.20833333333333
29476, 0.875, -0.08, 0.20833333333333
29477, 0.875, -0.12, 0.20833333333333
29478, 0.875, -0.16, 0.20833333333333
29479, 0.875, -0.04, 0.25
29480, 0.875, -0.08, 0.25
29481, 0.875, -0.12, 0.25
29482, 0.875, -0.16, 0.25
29483, 0.875, -0.04, 0.29166666666667
29484, 0.875, -0.08, 0.29166666666667
29485, 0.875, -0.12, 0.29166666666667
29486, 0.875, -0.16, 0.29166666666667
29487, 0.875, -0.04, 0.33333333333333
29488, 0.875, -0.08, 0.33333333333333
29489, 0.875, -0.12, 0.33333333333333
29490, 0.875, -0.16, 0.33333333333333
29491, 0.875, -0.04, 0.375
29492, 0.875, -0.08, 0.375
29493, 0.875, -0.12, 0.375
29494, 0.875, -0.16, 0.375
29495, 0.875, -0.04, 0.41666666666667
29496, 0.875, -0.08, 0.41666666666667
29497, 0.875, -0.12, 0.41666666666667
29498, 0.875, -0.16, 0.41666666666667
29499, 0.875, -0.04, 0.45833333333333
29500, 0.875, -0.08, 0.45833333333333
29501, 0.875, -0.12, 0.45833333333333
29502, 0.875, -0.16, 0.45833333333333
29503, 0.91666666666667, -0.04, 0.041666666666667
29504, 0.91666666666667, -0.08, 0.041666666666667
29505, 0.91666666666667, -0.12, 0.041666666666667
29506, 0.91666666666667, -0.16, 0.041666666666667
29507, 0.91666666666667, -0.04, 0.083333333333333
29508, 0.91666666666667, -0.08, 0.083333333333333
29509, 0.91666666666667, -0.12, 0.083333333333333
29510, 0.91666666666667, -0.16, 0.083333333333333
29511, 0.91666666666667, -0.04, 0.125
29512, 0.91666666666667, -0.08, 0.125
29513, 0.91666666666667, -0.12, 0.125
29514, 0.91666666666667, -0.16, 0.125
29515, 0.91666666666667, -0.04, 0.16666666666667
29516, 0.91666666666667, -0.08, 0.16666666666667
29517, 0.91666666666667, -0.12, 0.16666666666667
29518, 0.91666666666667, -0.16, 0.16666666666667
29519, 0.91666666666667, -0.04, 0.20833333333333
29520, 0.91666666666667, -0.08, 0.20833333333333
29521, 0.91666666666667, -0.12, 0.20833333333333
29522, 0.91666666666667, -0.16, 0.20833333333333
29523, 0.91666666666667, -0.04, 0.25
29524, 0.91666666666667, -0.08, 0.25
29525, 0.91666666666667, -0.12, 0.25
29526, 0.91666666666667, -0.16, 0.25
29527, 0.91666666666667, -0.04, 0.29166666666667
29528, 0.91666666666667, -0.08, 0.29166666666667
29529, 0.91666666666667, -0.12, 0.29166666666667
29530, 0.91666666666667, -0.16, 0.29166666666667
29531, 0.91666666666667, -0.04, 0.33333333333333
29532, 0.91666666666667, -0.08, 0.33333333333333
29533, 0.91666666666667, -0.12, 0.33333333333333
29534, 0.91666666666667, -0.16, 0.33333333333333
29535, 0.91666666666667, -0.04, 0.375
29536, 0.91666666666667, -0.08, 0.375
29537, 0.91666666666667, -0.12, 0.375
29538, 0.91666666666667, -0.16, 0.375
29539, 0.91666666666667, -0.04, 0.41666666666667
29540, 0.91666666666667, -0.08, 0.41666666666667
29541, 0.91666666666667, -0.12, 0.41666666666667
29542, 0.91666666666667, -0.16, 0.41666666666667
29543, 0.91666666666667, -0.04, 0.45833333333333
29544, 0.91666666666667, -0.08, 0.45833333333333
29545, 0.91666666666667, -0.12, 0.45833333333333
29546, 0.91666666666667, -0.16, 0.45833333333333
29547, 0.95833333333333, -0.04, 0.041666666666667
29548, 0.95833333333333, -0.08, 0.041666666666667
29549, 0.95833333333333, -0.12, 0.041666666666667
29550, 0.95833333333333, -0.16, 0.041666666666667
29551, 0.95833333333333, -0.04, 0.083333333333333
29552, 0.95833333333333, -0.08, 0.083333333333333
29553, 0.95833333333333, -0.12, 0.083333333333333
29554, 0.95833333333333, -0.16, 0.083333333333333
29555, 0.95833333333333, -0.04, 0.125
29556, 0.95833333333333, -0.08, 0.125
29557, 0.95833333333333, -0.12, 0.125
29558, 0.95833333333333, -0.16, 0.125
29559, 0.95833333333333, -0.04, 0.16666666666667
29560, 0.95833333333333, -0.08, 0.16666666666667
29561, 0.95833333333333, -0.12, 0.16666666666667
29562, 0.95833333333333, -0.16, 0.16666666666667
29563, 0.95833333333333, -0.04, 0.20833333333333
29564, 0.95833333333333, -0.08, 0.20833333333333
29565, 0.95833333333333, -0.12, 0.20833333333333
29566, 0.95833333333333, -0.16, 0.20833333333333
29567, 0.95833333333333, -0.04, 0.25
29568, 0.95833333333333, -0.08, 0.25
29569, 0.95833333333333, -0.12, 0.25
29570, 0.95833333333333, -0.16, 0.25
29571, 0.95833333333333, -0.04, 0.29166666666667
29572, 0.95833333333333, -0.08, 0.29166666666667
29573, 0.95833333333333, -0.12, 0.29166666666667
29574, 0.95833333333333, -0.16, 0.29166666666667
29575, 0.95833333333333, -0.04, 0.33333333333333
29576, 0.95833333333333, -0.08, 0.33333333333333
29577, 0.95833333333333, -0.12, 0.33333333333333
29578, 0.95833333333333, -0.16, 0.33333333333333
29579, 0.95833333333333, -0.04, 0.375
29580, 0.95833333333333, -0.08, 0.375
29581, 0.95833333333333, -0.12, 0.375
29582, 0.95833333333333, -0.16, 0.375
29583, 0.95833333333333, -0.04, 0.41666666666667
29584, 0.95833333333333, -0.08, 0.41666666666667
29585, 0.95833333333333, -0.12, 0.41666666666667
29586, 0.95833333333333, -0.16, 0.41666666666667
29587, 0.95833333333333, -0.04, 0.45833333333333
29588, 0.95833333333333, -0.08, 0.45833333333333
29589, 0.95833333333333, -0.12, 0.45833333333333
29590, 0.95833333333333, -0.16, 0.45833333333333
29591, 1.2416666666667, -0.04, 0.041666666666667
29592, 1.2416666666667, -0.08, 0.041666666666667
29593, 1.2416666666667, -0.12, 0.041666666666667
29594, 1.2416666666667, -0.16, 0.041666666666667
29595, 1.2833333333333, -0.04, 0.041666666666667
29596, 1.2833333333333, -0.08, 0.041666666666667
29597, 1.2833333333333, -0.12, 0.041666666666667
29598, 1.2833333333333, -0.16, 0.041666666666667
29599, 1.325, -0.04, 0.041666666666667
29600, 1.325, -0.08, 0.041666666666667
29601, 1.325, -0.12, 0.041666666666667
29602, 1.325, -0.16, 0.041666666666667
29603, 1.3666666666667, -0.04, 0.041666666666667
29604, 1.3666666666667, -0.08, 0.041666666666667
29605, 1.3666666666667, -0.12, 0.041666666666667
29606, 1.3666666666667, -0.16, 0.041666666666667
29607, 1.4083333333333, -0.04, 0.041666666666667
29608, 1.4083333333333, -0.08, 0.041666666666667
29609, 1.4083333333333, -0.12, 0.041666666666667
29610, 1.4083333333333, -0.16, 0.041666666666667
29611, 1.45, -0.04, 0.041666666666667
29612, 1.45, -0.08, 0.041666666666667
29613, 1.45, -0.12, 0.041666666666667
29614, 1.45, -0.16, 0.041666666666667
29615, 1.4916666666667, -0.04, 0.041666666666667
29616, 1.4916666666667, -0.08, 0.041666666666667
29617, 1.4916666666667, -0.12, 0.041666666666667
29618, 1.4916666666667, -0.16, 0.041666666666667
29619, 1.5333333333333, -0.04, 0.041666666666667
29620, 1.5333333333333, -0.08, 0.041666666666667
29621, 1.5333333333333, -0.12, 0.041666666666667
29622, 1.5333333333333, -0.16, 0.041666666666667
29623, 1.575, -0.04, 0.041666666666667
29624, 1.575, -0.08, 0.041666666666667
29625, 1.575, -0.12, 0.041666666666667
29626, 1.575, -0.16, 0.041666666666667
29627, 1.6166666666667, -0.04, 0.041666666666667
29628, 1.6166666666667, -0.08, 0.041666666666667
29629, 1.6166666666667, -0.12, 0.041666666666667
29630, 1.6166666666667, -0.16, 0.041666666666667
29631, 1.6583333333333, -0.04, 0.041666666666667
29632, 1.6583333333333, -0.08, 0.041666666666667
29633, 1.6583333333333, -0.12, 0.041666666666667
29634, 1.6583333333333, -0.16, 0.041666666666667
29635, 1.7, -0.04, 0.041666666666667
29636, 1.7, -0.08, 0.041666666666667
29637, 1.7, -0.12, 0.041666666666667
29638, 1.7, -0.16, 0.041666666666667
29639, 1.7416666666667, -0.04, 0.041666666666667
29640, 1.7416666666667, -0.08, 0.041666666666667
29641, 1.7416666666667, -0.12, 0.041666666666667
29642, 1.7416666666667, -0.16, 0.041666666666667
29643, 1.7833333333333, -0.04, 0.041666666666667
29644, 1.7833333333333, -0.08, 0.041666666666667
29645, 1.7833333333333, -0.12, 0.041666666666667
29646, 1.7833333333333, -0.16, 0.041666666666667
29647, 1.825, -0.04, 0.041666666666667
29648, 1.825, -0.08, 0.041666666666667
29649, 1.825, -0.12, 0.041666666666667
29650, 1.825, -0.16, 0.041666666666667
29651, 1.8666666666667, -0.04, 0.041666666666667
29652, 1.8666666666667, -0.08, 0.041666666666667
29653, 1.8666666666667, -0.12, 0.041666666666667
29654, 1.8666666666667, -0.16, 0.041666666666667
29655, 1.9083333333333, -0.04, 0.041666666666667
29656, 1.9083333333333, -0.08, 0.041666666666667
29657, 1.9083333333333, -0.12, 0.041666666666667
29658, 1.9083333333333, -0.16, 0.041666666666667
29659, 1.95, -0.04, 0.041666666666667
29660, 1.95, -0.08, 0.041666666666667
29661, 1.95, -0.12, 0.041666666666667
29662, 1.95, -0.16, 0.041666666666667
29663, 1.9916666666667, -0.04, 0.041666666666667
29664, 1.9916666666667, -0.08, 0.041666666666667
29665, 1.9916666666667, -0.12, 0.041666666666667
29666, 1.9916666666667, -0.16, 0.041666666666667
29667, 2.0333333333333, -0.04, 0.041666666666667
29668, 2.0333333333333, -0.08, 0.041666666666667
29669, 2.0333333333333, -0.12, 0.041666666666667
29670, 2.0333333333333, -0.16, 0.041666666666667
29671, 2.075, -0.04, 0.041666666666667
29672, 2.075, -0.08, 0.041666666666667
29673, 2.075, -0.12, 0.041666666666667
29674, 2.075, -0.16, 0.041666666666667
29675, 2.1166666666667, -0.04, 0.041666666666667
29676, 2.1166666666667, -0.08, 0.041666666666667
29677, 2.1166666666667, -0.12, 0.041666666666667
29678, 2.1166666666667, -0.16, 0.041666666666667
29679, 2.1583333333333, -0.04, 0.041666666666667
29680, 2.1583333333333, -0.08, 0.041666666666667
29681, 2.1583333333333, -0.12, 0.041666666666667
29682, 2.1583333333333, -0.16, 0.041666666666667
29683, 1.2416666666667, -0.04, 0.083333333333333
29684, 1.2416666666667, -0.08, 0.083333333333333
29685, 1.2416666666667, -0.12, 0.083333333333333
29686, 1.2416666666667, -0.16, 0.083333333333333
29687, 1.2833333333333, -0.04, 0.083333333333333
29688, 1.2833333333333, -0.08, 0.083333333333333
29689, 1.2833333333333, -0.12, 0.083333333333333
29690, 1.2833333333333, -0.16, 0.083333333333333
29691, 1.325, -0.04, 0.083333333333333
29692, 1.325, -0.08, 0.083333333333333
29693, 1.325, -0.12, 0.083333333333333
29694, 1.325, -0.16, 0.083333333333333
29695, 1.3666666666667, -0.04, 0.083333333333333
29696, 1.3666666666667, -0.08, 0.083333333333333
29697, 1.3666666666667, -0.12, 0.083333333333333
29698, 1.3666666666667, -0.16, 0.083333333333333
29699, 1.4083333333333, -0.04, 0.083333333333333
29700, 1.4083333333333, -0.08, 0.083333333333333
29701, 1.4083333333333, -0.12, 0.083333333333333
29702, 1.4083333333333, -0.16, 0.083333333333333
29703, 1.45, -0.04, 0.083333333333333
29704, 1.45, -0.08, 0.083333333333333
29705, 1.45, -0.12, 0.083333333333333
29706, 1.45, -0.16, 0.083333333333333
29707, 1.4916666666667, -0.04, 0.083333333333333
29708, 1.4916666666667, -0.08, 0.083333333333333
29709, 1.4916666666667, -0.12, 0.083333333333333
29710, 1.4916666666667, -0.16, 0.083333333333333
29711, 1.5333333333333, -0.04, 0.083333333333333
29712, 1.5333333333333, -0.08, 0.083333333333333
29713, 1.5333333333333, -0.12, 0.083333333333333
29714, 1.5333333333333, -0.16, 0.083333333333333
29715, 1.575, -0.04, 0.083333333333333
29716, 1.575, -0.08, 0.083333333333333
29717, 1.575, -0.12, 0.083333333333333
29718, 1.575, -0.16, 0.083333333333333
29719, 1.6166666666667, -0.04, 0.083333333333333
29720, 1.6166666666667, -0.08, 0.083333333333333
29721, 1.6166666666667, -0.12, 0.083333333333333
29722, 1.6166666666667, -0.16, 0.083333333333333
29723, 1.6583333333333, -0.04, 0.083333333333333
29724, 1.6583333333333, -0.08, 0.083333333333333
29725, 1.6583333333333, -0.12, 0.083333333333333
29726, 1.6583333333333, -0.16, 0.083333333333333
29727, 1.7, -0.04, 0.083333333333333
29728, 1.7, -0.08, 0.083333333333333
29729, 1.7, -0.12, 0.083333333333333
29730, 1.7, -0.16, 0.083333333333333
29731, 1.7416666666667, -0.04, 0.083333333333333
29732, 1.7416666666667, -0.08, 0.083333333333333
29733, 1.7416666666667, -0.12, 0.083333333333333
29734, 1.7416666666667, -0.16, 0.083333333333333
29735, 1.7833333333333, -0.04, 0.083333333333333
29736, 1.7833333333333, -0.08, 0.083333333333333
29737, 1.7833333333333, -0.12, 0.083333333333333
29738, 1.7833333333333, -0.16, 0.083333333333333
29739, 1.825, -0.04, 0.083333333333333
29740, 1.825, -0.08, 0.083333333333333
29741, 1.825, -0.12, 0.083333333333333
29742, 1.825, -0.16, 0.083333333333333
29743, 1.8666666666667, -0.04, 0.083333333333333
29744, 1.8666666666667, -0.08, 0.083333333333333
29745, 1.8666666666667, -0.12, 0.083333333333333
29746, 1.8666666666667, -0.16, 0.083333333333333
29747, 1.9083333333333, -0.04, 0.083333333333333
29748, 1.9083333333333, -0.08, 0.083333333333333
29749, 1.9083333333333, -0.12, 0.083333333333333
29750, 1.9083333333333, -0.16, 0.083333333333333
29751, 1.95, -0.04, 0.083333333333333
29752, 1.95, -0.08, 0.083333333333333
29753, 1.95, -0.12, 0.083333333333333
29754, 1.95, -0.16, 0.083333333333333
29755, 1.9916666666667, -0.04, 0.083333333333333
29756, 1.9916666666667, -0.08, 0.083333333333333
29757, 1.9916666666667, -0.12, 0.083333333333333
29758, 1.9916666666667, -0.16, 0.083333333333333
29759, 2.0333333333333, -0.04, 0.083333333333333
29760, 2.0333333333333, -0.08, 0.083333333333333
29761, 2.0333333333333, -0.12, 0.083333333333333
29762, 2.0333333333333, -0.16, 0.083333333333333
29763, 2.075, -0.04, 0.083333333333333
29764, 2.075, -0.08, 0.083333333333333
29765, 2.075, -0.12, 0.083333333333333
29766, 2.075, -0.16, 0.083333333333333
29767, 2.1166666666667, -0.04, 0.083333333333333
29768, 2.1166666666667, -0.08, 0.083333333333333
29769, 2.1166666666667, -0.12, 0.083333333333333
29770, 2.1166666666667, -0.16, 0.083333333333333
29771, 2.1583333333333, -0.04, 0.083333333333333
29772, 2.1583333333333, -0.08, 0.083333333333333
29773, 2.1583333333333, -0.12, 0.083333333333333
29774, 2.1583333333333, -0.16, 0.083333333333333
29775, 1.2416666666667, -0.04, 0.125
29776, 1.2416666666667, -0.08, 0.125
29777, 1.2416666666667, -0.12, 0.125
29778, 1.2416666666667, -0.16, 0.125
29779, 1.2833333333333, -0.04, 0.125
29780, 1.2833333333333, -0.08, 0.125
29781, 1.2833333333333, -0.12, 0.125
29782, 1.2833333333333, -0.16, 0.125
29783, 1.325, -0.04, 0.125
29784, 1.325, -0.08, 0.125
29785, 1.325, -0.12, 0.125
29786, 1.325, -0.16, 0.125
29787, 1.3666666666667, -0.04, 0.125
29788, 1.3666666666667, -0.08, 0.125
29789, 1.3666666666667, -0.12, 0.125
29790, 1.3666666666667, -0.16, 0.125
29791, 1.4083333333333, -0.04, 0.125
29792, 1.4083333333333, -0.08, 0.125
29793, 1.4083333333333, -0.12, 0.125
29794, 1.4083333333333, -0.16, 0.125
29795, 1.45, -0.04, 0.125
29796, 1.45, -0.08, 0.125
29797, 1.45, -0.12, 0.125
29798, 1.45, -0.16, 0.125
29799, 1.4916666666667, -0.04, 0.125
29800, 1.4916666666667, -0.08, 0.125
29801, 1.4916666666667, -0.12, 0.125
29802, 1.4916666666667, -0.16, 0.125
29803, 1.5333333333333, -0.04, 0.125
29804, 1.5333333333333, -0.08, 0.125
29805, 1.5333333333333, -0.12, 0.125
29806, 1.5333333333333, -0.16, 0.125
29807, 1.575, -0.04, 0.125
29808, 1.575, -0.08, 0.125
29809, 1.575, -0.12, 0.125
29810, 1.575, -0.16, 0.125
29811, 1.6166666666667, -0.04, 0.125
29812, 1.6166666666667, -0.08, 0.125
29813, 1.6166666666667, -0.12, 0.125
29814, 1.6166666666667, -0.16, 0.125
29815, 1.6583333333333, -0.04, 0.125
29816, 1.6583333333333, -0.08, 0.125
29817, 1.6583333333333, -0.12, 0.125
29818, 1.6583333333333, -0.16, 0.125
29819, 1.7, -0.04, 0.125
29820, 1.7, -0.08, 0.125
29821, 1.7, -0.12, 0.125
29822, 1.7, -0.16, 0.125
29823, 1.7416666666667, -0.04, 0.125
29824, 1.7416666666667, -0.08, 0.125
29825, 1.7416666666667, -0.12, 0.125
29826, 1.7416666666667, -0.16, 0.125
29827, 1.7833333333333, -0.04, 0.125
29828, 1.7833333333333, -0.08, 0.125
29829, 1.7833333333333, -0.12, 0.125
29830, 1.7833333333333, -0.16, 0.125
29831, 1.825, -0.04, 0.125
29832, 1.825, -0.08, 0.125
29833, 1.825, -0.12, 0.125
29834, 1.825, -0.16, 0.125
29835, 1.8666666666667, -0.04, 0.125
29836, 1.8666666666667, -0.08, 0.125
29837, 1.8666666666667, -0.12, 0.125
29838, 1.8666666666667, -0.16, 0.125
29839, 1.9083333333333, -0.04, 0.125
29840, 1.9083333333333, -0.08, 0.125
29841, 1.9083333333333, -0.12, 0.125
29842, 1.9083333333333, -0.16, 0.125
29843, 1.95, -0.04, 0.125
29844, 1.95, -0.08, 0.125
29845, 1.95, -0.12, 0.125
29846, 1.95, -0.16, 0.125
29847, 1.9916666666667, -0.04, 0.125
29848, 1.9916666666667, -0.08, 0.125
29849, 1.9916666666667, -0.12, 0.125
29850, 1.9916666666667, -0.16, 0.125
29851, 2.0333333333333, -0.04, 0.125
29852, 2.0333333333333, -0.08, 0.125
29853, 2.0333333333333, -0.12, 0.125
29854, 2.0333333333333, -0.16, 0.125
29855, 2.075, -0.04, 0.125
29856, 2.075, -0.08, 0.125
29857, 2.075, -0.12, 0.125
29858, 2.075, -0.16, 0.125
29859, 2.1166666666667, -0.04, 0.125
29860, 2.1166666666667, -0.08, 0.125
29861, 2.1166666666667, -0.12, 0.125
29862, 2.1166666666667, -0.16, 0.125
29863, 2.1583333333333, -0.04, 0.125
29864, 2.1583333333333, -0.08, 0.125
29865, 2.1583333333333, -0.12, 0.125
29866, 2.1583333333333, -0.16, 0.125
29867, 1.2416666666667, -0.04, 0.16666666666667
29868, 1.2416666666667, -0.08, 0.16666666666667
29869, 1.2416666666667, -0.12, 0.16666666666667
29870, 1.2416666666667, -0.16, 0.16666666666667
29871, 1.2833333333333, -0.04, 0.16666666666667
29872, 1.2833333333333, -0.08, 0.16666666666667
29873, 1.2833333333333, -0.12, 0.16666666666667
29874, 1.2833333333333, -0.16, 0.16666666666667
29875, 1.325, -0.04, 0.16666666666667
29876, 1.325, -0.08, 0.16666666666667
29877, 1.325, -0.12, 0.16666666666667
29878, 1.325, -0.16, 0.16666666666667
29879, 1.3666666666667, -0.04, 0.16666666666667
29880, 1.3666666666667, -0.08, 0.16666666666667
29881, 1.3666666666667, -0.12, 0.16666666666667
29882, 1.3666666666667, -0.16, 0.16666666666667
29883, 1.4083333333333, -0.04, 0.16666666666667
29884, 1.4083333333333, -0.08, 0.16666666666667
29885, 1.4083333333333, -0.12, 0.16666666666667
29886, 1.4083333333333, -0.16, 0.16666666666667
29887, 1.45, -0.04, 0.16666666666667
29888, 1.45, -0.08, 0.16666666666667
29889, 1.45, -0.12, 0.16666666666667
29890, 1.45, -0.16, 0.16666666666667
29891, 1.4916666666667, -0.04, 0.16666666666667
29892, 1.4916666666667, -0.08, 0.16666666666667
29893, 1.4916666666667, -0.12, 0.16666666666667
29894, 1.4916666666667, -0.16, 0.16666666666667
29895, 1.5333333333333, -0.04, 0.16666666666667
29896, 1.5333333333333, -0.08, 0.16666666666667
29897, 1.5333333333333, -0.12, 0.16666666666667
29898, 1.5333333333333, -0.16, 0.16666666666667
29899, 1.575, -0.04, 0.16666666666667
29900, 1.575, -0.08, 0.16666666666667
29901, 1.575, -0.12, 0.16666666666667
29902, 1.575, -0.16, 0.16666666666667
29903, 1.6166666666667, -0.04, 0.16666666666667
29904, 1.6166666666667, -0.08, 0.16666666666667
29905, 1.6166666666667, -0.12, 0.16666666666667
29906, 1.6166666666667, -0.16, 0.16666666666667
29907, 1.6583333333333, -0.04, 0.16666666666667
29908, 1.6583333333333, -0.08, 0.16666666666667
29909, 1.6583333333333, -0.12, 0.16666666666667
29910, 1.6583333333333, -0.16, 0.16666666666667
29911, 1.7, -0.04, 0.16666666666667
29912, 1.7, -0.08, 0.16666666666667
29913, 1.7, -0.12, 0.16666666666667
29914, 1.7, -0.16, 0.16666666666667
29915, 1.7416666666667, -0.04, 0.16666666666667
29916, 1.7416666666667, -0.08, 0.16666666666667
29917, 1.7416666666667, -0.12, 0.16666666666667
29918, 1.7416666666667, -0.16, 0.16666666666667
29919, 1.7833333333333, -0.04, 0.16666666666667
29920, 1.7833333333333, -0.08, 0.16666666666667
29921, 1.7833333333333, -0.12, 0.16666666666667
29922, 1.7833333333333, -0.16, 0.16666666666667
29923, 1.825, -0.04, 0.16666666666667
29924, 1.825, -0.08, 0.16666666666667
29925, 1.825, -0.12, 0.16666666666667
29926, 1.825, -0.16, 0.16666666666667
29927, 1.8666666666667, -0.04, 0.16666666666667
29928, 1.8666666666667, -0.08, 0.16666666666667
29929, 1.8666666666667, -0.12, 0.16666666666667
29930, 1.8666666666667, -0.16, 0.16666666666667
29931, 1.9083333333333, -0.04, 0.16666666666667
29932, 1.9083333333333, -0.08, 0.16666666666667
29933, 1.9083333333333, -0.12, 0.16666666666667
29934, 1.9083333333333, -0.16, 0.16666666666667
29935, 1.95, -0.04, 0.16666666666667
29936, 1.95, -0.08, 0.16666666666667
29937, 1.95, -0.12, 0.16666666666667
29938, 1.95, -0.16, 0.16666666666667
29939, 1.9916666666667, -0.04, 0.16666666666667
29940, 1.9916666666667, -0.08, 0.16666666666667
29941, 1.9916666666667, -0.12, 0.16666666666667
29942, 1.9916666666667, -0.16, 0.16666666666667
29943, 2.0333333333333, -0.04, 0.16666666666667
29944, 2.0333333333333, -0.08, 0.16666666666667
29945, 2.0333333333333, -0.12, 0.16666666666667
29946, 2.0333333333333, -0.16, 0.16666666666667
29947, 2.075, -0.04, 0.16666666666667
29948, 2.075, -0.08, 0.16666666666667
29949, 2.075, -0.12, 0.16666666666667
29950, 2.075, -0.16, 0.16666666666667
29951, 2.1166666666667, -0.04, 0.16666666666667
29952, 2.1166666666667, -0.08, 0.16666666666667
29953, 2.1166666666667, -0.12, 0.16666666666667
29954, 2.1166666666667, -0.16, 0.16666666666667
29955, 2.1583333333333, -0.04, 0.16666666666667
29956, 2.1583333333333, -0.08, 0.16666666666667
29957, 2.1583333333333, -0.12, 0.16666666666667
29958, 2.1583333333333, -0.16, 0.16666666666667
29959, 1.2416666666667, -0.04, 0.20833333333333
29960, 1.2416666666667, -0.08, 0.20833333333333
29961, 1.2416666666667, -0.12, 0.20833333333333
29962, 1.2416666666667, -0.16, 0.20833333333333
29963, 1.2833333333333, -0.04, 0.20833333333333
29964, 1.2833333333333, -0.08, 0.20833333333333
29965, 1.2833333333333, -0.12, 0.20833333333333
29966, 1.2833333333333, -0.16, 0.20833333333333
29967, 1.325, -0.04, 0.20833333333333
29968, 1.325, -0.08, 0.20833333333333
29969, 1.325, -0.12, 0.20833333333333
29970, 1.325, -0.16, 0.20833333333333
29971, 1.3666666666667, -0.04, 0.20833333333333
29972, 1.3666666666667, -0.08, 0.20833333333333
29973, 1.3666666666667, -0.12, 0.20833333333333
29974, 1.3666666666667, -0.16, 0.20833333333333
29975, 1.4083333333333, -0.04, 0.20833333333333
29976, 1.4083333333333, -0.08, 0.20833333333333
29977, 1.4083333333333, -0.12, 0.20833333333333
29978, 1.4083333333333, -0.16, 0.20833333333333
29979, 1.45, -0.04, 0.20833333333333
29980, 1.45, -0.08, 0.20833333333333
29981, 1.45, -0.12, 0.20833333333333
29982, 1.45, -0.16, 0.20833333333333
29983, 1.4916666666667, -0.04, 0.20833333333333
29984, 1.4916666666667, -0.08, 0.20833333333333
29985, 1.4916666666667, -0.12, 0.20833333333333
29986, 1.4916666666667, -0.16, 0.20833333333333
29987, 1.5333333333333, -0.04, 0.20833333333333
29988, 1.5333333333333, -0.08, 0.20833333333333
29989, 1.5333333333333, -0.12, 0.20833333333333
29990, 1.5333333333333, -0.16, 0.20833333333333
29991, 1.575, -0.04, 0.20833333333333
29992, 1.575, -0.08, 0.20833333333333
29993, 1.575, -0.12, 0.20833333333333
29994, 1.575, -0.16, 0.20833333333333
29995, 1.6166666666667, -0.04, 0.20833333333333
29996, 1.6166666666667, -0.08, 0.20833333333333
29997, 1.6166666666667, -0.12, 0.20833333333333
29998, 1.6166666666667, -0.16, 0.20833333333333
29999, 1.6583333333333, -0.04, 0.20833333333333
30000, 1.6583333333333, -0.08, 0.20833333333333
30001, 1.6583333333333, -0.12, 0.20833333333333
30002, 1.6583333333333, -0.16, 0.20833333333333
30003, 1.7, -0.04, 0.20833333333333
30004, 1.7, -0.08, 0.20833333333333
30005, 1.7, -0.12, 0.20833333333333
30006, 1.7, -0.16, 0.20833333333333
30007, 1.7416666666667, -0.04, 0.20833333333333
30008, 1.7416666666667, -0.08, 0.20833333333333
30009, 1.7416666666667, -0.12, 0.20833333333333
30010, 1.7416666666667, -0.16, 0.20833333333333
30011, 1.7833333333333, -0.04, 0.20833333333333
30012, 1.7833333333333, -0.08, 0.20833333333333
30013, 1.7833333333333, -0.12, 0.20833333333333
30014, 1.7833333333333, -0.16, 0.20833333333333
30015, 1.825, -0.04, 0.20833333333333
30016, 1.825, -0.08, 0.20833333333333
30017, 1.825, -0.12, 0.20833333333333
30018, 1.825, -0.16, 0.20833333333333
30019, 1.8666666666667, -0.04, 0.20833333333333
30020, 1.8666666666667, -0.08, 0.20833333333333
30021, 1.8666666666667, -0.12, 0.20833333333333
30022, 1.8666666666667, -0.16, 0.20833333333333
30023, 1.9083333333333, -0.04, 0.20833333333333
30024, 1.9083333333333, -0.08, 0.20833333333333
30025, 1.9083333333333, -0.12, 0.20833333333333
30026, 1.9083333333333, -0.16, 0.20833333333333
30027, 1.95, -0.04, 0.20833333333333
30028, 1.95, -0.08, 0.20833333333333
30029, 1.95, -0.12, 0.20833333333333
30030, 1.95, -0.16, 0.20833333333333
30031, 1.9916666666667, -0.04, 0.20833333333333
30032, 1.9916666666667, -0.08, 0.20833333333333
30033, 1.9916666666667, -0.12, 0.20833333333333
30034, 1.9916666666667, -0.16, 0.20833333333333
30035, 2.0333333333333, -0.04, 0.20833333333333
30036, 2.0333333333333, -0.08, 0.20833333333333
30037, 2.0333333333333, -0.12, 0.20833333333333
30038, 2.0333333333333, -0.16, 0.20833333333333
30039, 2.075, -0.04, 0.20833333333333
30040, 2.075, -0.08, 0.20833333333333
30041, 2.075, -0.12, 0.20833333333333
30042, 2.075, -0.16, 0.20833333333333
30043, 2.1166666666667, -0.04, 0.20833333333333
30044, 2.1166666666667, -0.08, 0.20833333333333
30045, 2.1166666666667, -0.12, 0.20833333333333
30046, 2.1166666666667, -0.16, 0.20833333333333
30047, 2.1583333333333, -0.04, 0.20833333333333
30048, 2.1583333333333, -0.08, 0.20833333333333
30049, 2.1583333333333, -0.12, 0.20833333333333
30050, 2.1583333333333, -0.16, 0.20833333333333
30051, 1.2416666666667, -0.04, 0.25
30052, 1.2416666666667, -0.08, 0.25
30053, 1.2416666666667, -0.12, 0.25
30054, 1.2416666666667, -0.16, 0.25
30055, 1.2833333333333, -0.04, 0.25
30056, 1.2833333333333, -0.08, 0.25
30057, 1.2833333333333, -0.12, 0.25
30058, 1.2833333333333, -0.16, 0.25
30059, 1.325, -0.04, 0.25
30060, 1.325, -0.08, 0.25
30061, 1.325, -0.12, 0.25
30062, 1.325, -0.16, 0.25
30063, 1.3666666666667, -0.04, 0.25
30064, 1.3666666666667, -0.08, 0.25
30065, 1.3666666666667, -0.12, 0.25
30066, 1.3666666666667, -0.16, 0.25
30067, 1.4083333333333, -0.04, 0.25
30068, 1.4083333333333, -0.08, 0.25
30069, 1.4083333333333, -0.12, 0.25
30070, 1.4083333333333, -0.16, 0.25
30071, 1.45, -0.04, 0.25
30072, 1.45, -0.08, 0.25
30073, 1.45, -0.12, 0.25
30074, 1.45, -0.16, 0.25
30075, 1.4916666666667, -0.04, 0.25
30076, 1.4916666666667, -0.08, 0.25
30077, 1.4916666666667, -0.12, 0.25
30078, 1.4916666666667, -0.16, 0.25
30079, 1.5333333333333, -0.04, 0.25
30080, 1.5333333333333, -0.08, 0.25
30081, 1.5333333333333, -0.12, 0.25
30082, 1.5333333333333, -0.16, 0.25
30083, 1.575, -0.04, 0.25
30084, 1.575, -0.08, 0.25
30085, 1.575, -0.12, 0.25
30086, 1.575, -0.16, 0.25
30087, 1.6166666666667, -0.04, 0.25
30088, 1.6166666666667, -0.08, 0.25
30089, 1.6166666666667, -0.12, 0.25
30090, 1.6166666666667, -0.16, 0.25
30091, 1.6583333333333, -0.04, 0.25
30092, 1.6583333333333, -0.08, 0.25
30093, 1.6583333333333, -0.12, 0.25
30094, 1.6583333333333, -0.16, 0.25
30095, 1.7, -0.04, 0.25
30096, 1.7, -0.08, 0.25
30097, 1.7, -0.12, 0.25
30098, 1.7, -0.16, 0.25
30099, 1.7416666666667, -0.04, 0.25
30100, 1.7416666666667, -0.08, 0.25
30101, 1.7416666666667, -0.12, 0.25
30102, 1.7416666666667, -0.16, 0.25
30103, 1.7833333333333, -0.04, 0.25
30104, 1.7833333333333, -0.08, 0.25
30105, 1.7833333333333, -0.12, 0.25
30106, 1.7833333333333, -0.16, 0.25
30107, 1.825, -0.04, 0.25
30108, 1.825, -0.08, 0.25
30109, 1.825, -0.12, 0.25
30110, 1.825, -0.16, 0.25
30111, 1.8666666666667, -0.04, 0.25
30112, 1.8666666666667, -0.08, 0.25
30113, 1.8666666666667, -0.12, 0.25
30114, 1.8666666666667, -0.16, 0.25
30115, 1.9083333333333, -0.04, 0.25
30116, 1.9083333333333, -0.08, 0.25
30117, 1.9083333333333, -0.12, 0.25
30118, 1.9083333333333, -0.16, 0.25
30119, 1.95, -0.04, 0.25
30120, 1.95, -0.08, 0.25
30121, 1.95, -0.12, 0.25
30122, 1.95, -0.16, 0.25
30123, 1.9916666666667, -0.04, 0.25
30124, 1.9916666666667, -0.08, 0.25
30125, 1.9916666666667, -0.12, 0.25
30126, 1.9916666666667, -0.16, 0.25
30127, 2.0333333333333, -0.04, 0.25
30128, 2.0333333333333, -0.08, 0.25
30129, 2.0333333333333, -0.12, 0.25
30130, 2.0333333333333, -0.16, 0.25
30131, 2.075, -0.04, 0.25
30132, 2.075, -0.08, 0.25
30133, 2.075, -0.12, 0.25
30134, 2.075, -0.16, 0.25
30135, 2.1166666666667, -0.04, 0.25
30136, 2.1166666666667, -0.08, 0.25
30137, 2.1166666666667, -0.12, 0.25
30138, 2.1166666666667, -0.16, 0.25
30139, 2.1583333333333, -0.04, 0.25
30140, 2.1583333333333, -0.08, 0.25
30141, 2.1583333333333, -0.12, 0.25
30142, 2.1583333333333, -0.16, 0.25
30143, 1.2416666666667, -0.04, 0.29166666666667
30144, 1.2416666666667, -0.08, 0.29166666666667
30145, 1.2416666666667, -0.12, 0.29166666666667
30146, 1.2416666666667, -0.16, 0.29166666666667
30147, 1.2833333333333, -0.04, 0.29166666666667
30148, 1.2833333333333, -0.08, 0.29166666666667
30149, 1.2833333333333, -0.12, 0.29166666666667
30150, 1.2833333333333, -0.16, 0.29166666666667
30151, 1.325, -0.04, 0.29166666666667
30152, 1.325, -0.08, 0.29166666666667
30153, 1.325, -0.12, 0.29166666666667
30154, 1.325, -0.16, 0.29166666666667
30155, 1.3666666666667, -0.04, 0.29166666666667
30156, 1.3666666666667, -0.08, 0.29166666666667
30157, 1.3666666666667, -0.12, 0.29166666666667
30158, 1.3666666666667, -0.16, 0.29166666666667
30159, 1.4083333333333, -0.04, 0.29166666666667
30160, 1.4083333333333, -0.08, 0.29166666666667
30161, 1.4083333333333, -0.12, 0.29166666666667
30162, 1.4083333333333, -0.16, 0.29166666666667
30163, 1.45, -0.04, 0.29166666666667
30164, 1.45, -0.08, 0.29166666666667
30165, 1.45, -0.12, 0.29166666666667
30166, 1.45, -0.16, 0.29166666666667
30167, 1.4916666666667, -0.04, 0.29166666666667
30168, 1.4916666666667, -0.08, 0.29166666666667
30169, 1.4916666666667, -0.12, 0.29166666666667
30170, 1.4916666666667, -0.16, 0.29166666666667
30171, 1.5333333333333, -0.04, 0.29166666666667
30172, 1.5333333333333, -0.08, 0.29166666666667
30173, 1.5333333333333, -0.12, 0.29166666666667
30174, 1.5333333333333, -0.16, 0.29166666666667
30175, 1.575, -0.04, 0.29166666666667
30176, 1.575, -0.08, 0.29166666666667
30177, 1.575, -0.12, 0.29166666666667
30178, 1.575, -0.16, 0.29166666666667
30179, 1.6166666666667, -0.04, 0.29166666666667
30180, 1.6166666666667, -0.08, 0.29166666666667
30181, 1.6166666666667, -0.12, 0.29166666666667
30182, 1.6166666666667, -0.16, 0.29166666666667
30183, 1.6583333333333, -0.04, 0.29166666666667
30184, 1.6583333333333, -0.08, 0.29166666666667
30185, 1.6583333333333, -0.12, 0.29166666666667
30186, 1.6583333333333, -0.16, 0.29166666666667
30187, 1.7, -0.04, 0.29166666666667
30188, 1.7, -0.08, 0.29166666666667
30189, 1.7, -0.12, 0.29166666666667
30190, 1.7, -0.16, 0.29166666666667
30191, 1.7416666666667, -0.04, 0.29166666666667
30192, 1.7416666666667, -0.08, 0.29166666666667
30193, 1.7416666666667, -0.12, 0.29166666666667
30194, 1.7416666666667, -0.16, 0.29166666666667
30195, 1.7833333333333, -0.04, 0.29166666666667
30196, 1.7833333333333, -0.08, 0.29166666666667
30197, 1.7833333333333, -0.12, 0.29166666666667
30198, 1.7833333333333, -0.16, 0.29166666666667
30199, 1.825, -0.04, 0.29166666666667
30200, 1.825, -0.08, 0.29166666666667
30201, 1.825, -0.12, 0.29166666666667
30202, 1.825, -0.16, 0.29166666666667
30203, 1.8666666666667, -0.04, 0.29166666666667
30204, 1.8666666666667, -0.08, 0.29166666666667
30205, 1.8666666666667, -0.12, 0.29166666666667
30206, 1.8666666666667, -0.16, 0.29166666666667
30207, 1.9083333333333, -0.04, 0.29166666666667
30208, 1.9083333333333, -0.08, 0.29166666666667
30209, 1.9083333333333, -0.12, 0.29166666666667
30210, 1.9083333333333, -0.16, 0.29166666666667
30211, 1.95, -0.04, 0.29166666666667
30212, 1.95, -0.08, 0.29166666666667
30213, 1.95, -0.12, 0.29166666666667
30214, 1.95, -0.16, 0.29166666666667
30215, 1.9916666666667, -0.04, 0.29166666666667
30216, 1.9916666666667, -0.08, 0.29166666666667
30217, 1.9916666666667, -0.12, 0.29166666666667
30218, 1.9916666666667, -0.16, 0.29166666666667
30219, 2.0333333333333, -0.04, 0.29166666666667
30220, 2.0333333333333, -0.08, 0.29166666666667
30221, 2.0333333333333, -0.12, 0.29166666666667
30222, 2.0333333333333, -0.16, 0.29166666666667
30223, 2.075, -0.04, 0.29166666666667
30224, 2.075, -0.08, 0.29166666666667
30225, 2.075, -0.12, 0.29166666666667
30226, 2.075, -0.16, 0.29166666666667
30227, 2.1166666666667, -0.04, 0.29166666666667
30228, 2.1166666666667, -0.08, 0.29166666666667
30229, 2.1166666666667, -0.12, 0.29166666666667
30230, 2.1166666666667, -0.16, 0.29166666666667
30231, 2.1583333333333, -0.04, 0.29166666666667
30232, 2.1583333333333, -0.08, 0.29166666666667
30233, 2.1583333333333, -0.12, 0.29166666666667
30234, 2.1583333333333, -0.16, 0.29166666666667
30235, 1.2416666666667, -0.04, 0.33333333333333
30236, 1.2416666666667, -0.08, 0.33333333333333
30237, 1.2416666666667, -0.12, 0.33333333333333
30238, 1.2416666666667, -0.16, 0.33333333333333
30239, 1.2833333333333, -0.04, 0.33333333333333
30240, 1.2833333333333, -0.08, 0.33333333333333
30241, 1.2833333333333, -0.12, 0.33333333333333
30242, 1.2833333333333, -0.16, 0.33333333333333
30243, 1.325, -0.04, 0.33333333333333
30244, 1.325, -0.08, 0.33333333333333
30245, 1.325, -0.12, 0.33333333333333
30246, 1.325, -0.16, 0.33333333333333
30247, 1.3666666666667, -0.04, 0.33333333333333
30248, 1.3666666666667, -0.08, 0.33333333333333
30249, 1.3666666666667, -0.12, 0.33333333333333
30250, 1.3666666666667, -0.16, 0.33333333333333
30251, 1.4083333333333, -0.04, 0.33333333333333
30252, 1.4083333333333, -0.08, 0.33333333333333
30253, 1.4083333333333, -0.12, 0.33333333333333
30254, 1.4083333333333, -0.16, 0.33333333333333
30255, 1.45, -0.04, 0.33333333333333
30256, 1.45, -0.08, 0.33333333333333
30257, 1.45, -0.12, 0.33333333333333
30258, 1.45, -0.16, 0.33333333333333
30259, 1.4916666666667, -0.04, 0.33333333333333
30260, 1.4916666666667, -0.08, 0.33333333333333
30261, 1.4916666666667, -0.12, 0.33333333333333
30262, 1.4916666666667, -0.16, 0.33333333333333
30263, 1.5333333333333, -0.04, 0.33333333333333
30264, 1.5333333333333, -0.08, 0.33333333333333
30265, 1.5333333333333, -0.12, 0.33333333333333
30266, 1.5333333333333, -0.16, 0.33333333333333
30267, 1.575, -0.04, 0.33333333333333
30268, 1.575, -0.08, 0.33333333333333
30269, 1.575, -0.12, 0.33333333333333
30270, 1.575, -0.16, 0.33333333333333
30271, 1.6166666666667, -0.04, 0.33333333333333
30272, 1.6166666666667, -0.08, 0.33333333333333
30273, 1.6166666666667, -0.12, 0.33333333333333
30274, 1.6166666666667, -0.16, 0.33333333333333
30275, 1.6583333333333, -0.04, 0.33333333333333
30276, 1.6583333333333, -0.08, 0.33333333333333
30277, 1.6583333333333, -0.12, 0.33333333333333
30278, 1.6583333333333, -0.16, 0.33333333333333
30279, 1.7, -0.04, 0.33333333333333
30280, 1.7, -0.08, 0.33333333333333
30281, 1.7, -0.12, 0.33333333333333
30282, 1.7, -0.16, 0.33333333333333
30283, 1.7416666666667, -0.04, 0.33333333333333
30284, 1.7416666666667, -0.08, 0.33333333333333
30285, 1.7416666666667, -0.12, 0.33333333333333
30286, 1.7416666666667, -0.16, 0.33333333333333
30287, 1.7833333333333, -0.04, 0.33333333333333
30288, 1.7833333333333, -0.08, 0.33333333333333
30289, 1.7833333333333, -0.12, 0.33333333333333
30290, 1.7833333333333, -0.16, 0.33333333333333
30291, 1.825, -0.04, 0.33333333333333
30292, 1.825, -0.08, 0.33333333333333
30293, 1.825, -0.12, 0.33333333333333
30294, 1.825, -0.16, 0.33333333333333
30295, 1.8666666666667, -0.04, 0.33333333333333
30296, 1.8666666666667, -0.08, 0.33333333333333
30297, 1.8666666666667, -0.12, 0.33333333333333
30298, 1.8666666666667, -0.16, 0.33333333333333
30299, 1.9083333333333, -0.04, 0.33333333333333
30300, 1.9083333333333, -0.08, 0.33333333333333
30301, 1.9083333333333, -0.12, 0.33333333333333
30302, 1.9083333333333, -0.16, 0.33333333333333
30303, 1.95, -0.04, 0.33333333333333
30304, 1.95, -0.08, 0.33333333333333
30305, 1.95, -0.12, 0.33333333333333
30306, 1.95, -0.16, 0.33333333333333
30307, 1.9916666666667, -0.04, 0.33333333333333
30308, 1.9916666666667, -0.08, 0.33333333333333
30309, 1.9916666666667, -0.12, 0.33333333333333
30310, 1.9916666666667, -0.16, 0.33333333333333
30311, 2.0333333333333, -0.04, 0.33333333333333
30312, 2.0333333333333, -0.08, 0.33333333333333
30313, 2.0333333333333, -0.12, 0.33333333333333
30314, 2.0333333333333, -0.16, 0.33333333333333
30315, 2.075, -0.04, 0.33333333333333
30316, 2.075, -0.08, 0.33333333333333
30317, 2.075, -0.12, 0.33333333333333
30318, 2.075, -0.16, 0.33333333333333
30319, 2.1166666666667, -0.04, 0.33333333333333
30320, 2.1166666666667, -0.08, 0.33333333333333
30321, 2.1166666666667, -0.12, 0.33333333333333
30322, 2.1166666666667, -0.16, 0.33333333333333
30323, 2.1583333333333, -0.04, 0.33333333333333
30324, 2.1583333333333, -0.08, 0.33333333333333
30325, 2.1583333333333, -0.12, 0.33333333333333
30326, 2.1583333333333, -0.16, 0.33333333333333
30327, 1.2416666666667, -0.04, 0.375
30328, 1.2416666666667, -0.08, 0.375
30329, 1.2416666666667, -0.12, 0.375
30330, 1.2416666666667, -0.16, 0.375
30331, 1.2833333333333, -0.04, 0.375
30332, 1.2833333333333, -0.08, 0.375
30333, 1.2833333333333, -0.12, 0.375
30334, 1.2833333333333, -0.16, 0.375
30335, 1.325, -0.04, 0.375
30336, 1.325, -0.08, 0.375
30337, 1.325, -0.12, 0.375
30338, 1.325, -0.16, 0.375
30339, 1.3666666666667, -0.04, 0.375
30340, 1.3666666666667, -0.08, 0.375
30341, 1.3666666666667, -0.12, 0.375
30342, 1.3666666666667, -0.16, 0.375
30343, 1.4083333333333, -0.04, 0.375
30344, 1.4083333333333, -0.08, 0.375
30345, 1.4083333333333, -0.12, 0.375
30346, 1.4083333333333, -0.16, 0.375
30347, 1.45, -0.04, 0.375
30348, 1.45, -0.08, 0.375
30349, 1.45, -0.12, 0.375
30350, 1.45, -0.16, 0.375
30351, 1.4916666666667, -0.04, 0.375
30352, 1.4916666666667, -0.08, 0.375
30353, 1.4916666666667, -0.12, 0.375
30354, 1.4916666666667, -0.16, 0.375
30355, 1.5333333333333, -0.04, 0.375
30356, 1.5333333333333, -0.08, 0.375
30357, 1.5333333333333, -0.12, 0.375
30358, 1.5333333333333, -0.16, 0.375
30359, 1.575, -0.04, 0.375
30360, 1.575, -0.08, 0.375
30361, 1.575, -0.12, 0.375
30362, 1.575, -0.16, 0.375
30363, 1.6166666666667, -0.04, 0.375
30364, 1.6166666666667, -0.08, 0.375
30365, 1.6166666666667, -0.12, 0.375
30366, 1.6166666666667, -0.16, 0.375
30367, 1.6583333333333, -0.04, 0.375
30368, 1.6583333333333, -0.08, 0.375
30369, 1.6583333333333, -0.12, 0.375
30370, 1.6583333333333, -0.16, 0.375
30371, 1.7, -0.04, 0.375
30372, 1.7, -0.08, 0.375
30373, 1.7, -0.12, 0.375
30374, 1.7, -0.16, 0.375
30375, 1.7416666666667, -0.04, 0.375
30376, 1.7416666666667, -0.08, 0.375
30377, 1.7416666666667, -0.12, 0.375
30378, 1.7416666666667, -0.16, 0.375
30379, 1.7833333333333, -0.04, 0.375
30380, 1.7833333333333, -0.08, 0.375
30381, 1.7833333333333, -0.12, 0.375
30382, 1.7833333333333, -0.16, 0.375
30383, 1.825, -0.04, 0.375
30384, 1.825, -0.08, 0.375
30385, 1.825, -0.12, 0.375
30386, 1.825, -0.16, 0.375
30387, 1.8666666666667, -0.04, 0.375
30388, 1.8666666666667, -0.08, 0.375
30389, 1.8666666666667, -0.12, 0.375
30390, 1.8666666666667, -0.16, 0.375
30391, 1.9083333333333, -0.04, 0.375
30392, 1.9083333333333, -0.08, 0.375
30393, 1.9083333333333, -0.12, 0.375
30394, 1.9083333333333, -0.16, 0.375
30395, 1.95, -0.04, 0.375
30396, 1.95, -0.08, 0.375
30397, 1.95, -0.12, 0.375
30398, 1.95, -0.16, 0.375
30399, 1.9916666666667, -0.04, 0.375
30400, 1.9916666666667, -0.08, 0.375
30401, 1.9916666666667, -0.12, 0.375
30402, 1.9916666666667, -0.16, 0.375
30403, 2.0333333333333, -0.04, 0.375
30404, 2.0333333333333, -0.08, 0.375
30405, 2.0333333333333, -0.12, 0.375
30406, 2.0333333333333, -0.16, 0.375
30407, 2.075, -0.04, 0.375
30408, 2.075, -0.08, 0.375
30409, 2.075, -0.12, 0.375
30410, 2.075, -0.16, 0.375
30411, 2.1166666666667, -0.04, 0.375
30412, 2.1166666666667, -0.08, 0.375
30413, 2.1166666666667, -0.12, 0.375
30414, 2.1166666666667, -0.16, 0.375
30415, 2.1583333333333, -0.04, 0.375
30416, 2.1583333333333, -0.08, 0.375
30417, 2.1583333333333, -0.12, 0.375
30418, 2.1583333333333, -0.16, 0.375
30419, 1.2416666666667, -0.04, 0.41666666666667
30420, 1.2416666666667, -0.08, 0.41666666666667
30421, 1.2416666666667, -0.12, 0.41666666666667
30422, 1.2416666666667, -0.16, 0.41666666666667
30423, 1.2833333333333, -0.04, 0.41666666666667
30424, 1.2833333333333, -0.08, 0.41666666666667
30425, 1.2833333333333, -0.12, 0.41666666666667
30426, 1.2833333333333, -0.16, 0.41666666666667
30427, 1.325, -0.04, 0.41666666666667
30428, 1.325, -0.08, 0.41666666666667
30429, 1.325, -0.12, 0.41666666666667
30430, 1.325, -0.16, 0.41666666666667
30431, 1.3666666666667, -0.04, 0.41666666666667
30432, 1.3666666666667, -0.08, 0.41666666666667
30433, 1.3666666666667, -0.12, 0.41666666666667
30434, 1.3666666666667, -0.16, 0.41666666666667
30435, 1.4083333333333, -0.04, 0.41666666666667
30436, 1.4083333333333, -0.08, 0.41666666666667
30437, 1.4083333333333, -0.12, 0.41666666666667
30438, 1.4083333333333, -0.16, 0.41666666666667
30439, 1.45, -0.04, 0.41666666666667
30440, 1.45, -0.08, 0.41666666666667
30441, 1.45, -0.12, 0.41666666666667
30442, 1.45, -0.16, 0.41666666666667
30443, 1.4916666666667, -0.04, 0.41666666666667
30444, 1.4916666666667, -0.08, 0.41666666666667
30445, 1.4916666666667, -0.12, 0.41666666666667
30446, 1.4916666666667, -0.16, 0.41666666666667
30447, 1.5333333333333, -0.04, 0.41666666666667
30448, 1.5333333333333, -0.08, 0.41666666666667
30449, 1.5333333333333, -0.12, 0.41666666666667
30450, 1.5333333333333, -0.16, 0.41666666666667
30451, 1.575, -0.04, 0.41666666666667
30452, 1.575, -0.08, 0.41666666666667
30453, 1.575, -0.12, 0.41666666666667
30454, 1.575, -0.16, 0.41666666666667
30455, 1.6166666666667, -0.04, 0.41666666666667
30456, 1.6166666666667, -0.08, 0.41666666666667
30457, 1.6166666666667, -0.12, 0.41666666666667
30458, 1.6166666666667, -0.16, 0.41666666666667
30459, 1.6583333333333, -0.04, 0.41666666666667
30460, 1.6583333333333, -0.08, 0.41666666666667
30461, 1.6583333333333, -0.12, 0.41666666666667
30462, 1.6583333333333, -0.16, 0.41666666666667
30463, 1.7, -0.04, 0.41666666666667
30464, 1.7, -0.08, 0.41666666666667
30465, 1.7, -0.12, 0.41666666666667
30466, 1.7, -0.16, 0.41666666666667
30467, 1.7416666666667, -0.04, 0.41666666666667
30468, 1.7416666666667, -0.08, 0.41666666666667
30469, 1.7416666666667, -0.12, 0.41666666666667
30470, 1.7416666666667, -0.16, 0.41666666666667
30471, 1.7833333333333, -0.04, 0.41666666666667
30472, 1.7833333333333, -0.08, 0.41666666666667
30473, 1.7833333333333, -0.12, 0.41666666666667
30474, 1.7833333333333, -0.16, 0.41666666666667
30475, 1.825, -0.04, 0.41666666666667
30476, 1.825, -0.08, 0.41666666666667
30477, 1.825, -0.12, 0.41666666666667
30478, 1.825, -0.16, 0.41666666666667
30479, 1.8666666666667, -0.04, 0.41666666666667
30480, 1.8666666666667, -0.08, 0.41666666666667
30481, 1.8666666666667, -0.12, 0.41666666666667
30482, 1.8666666666667, -0.16, 0.41666666666667
30483, 1.9083333333333, -0.04, 0.41666666666667
30484, 1.9083333333333, -0.08, 0.41666666666667
30485, 1.9083333333333, -0.12, 0.41666666666667
30486, 1.9083333333333, -0.16, 0.41666666666667
30487, 1.95, -0.04, 0.41666666666667
30488, 1.95, -0.08, 0.41666666666667
30489, 1.95, -0.12, 0.41666666666667
30490, 1.95, -0.16, 0.41666666666667
30491, 1.9916666666667, -0.04, 0.41666666666667
30492, 1.9916666666667, -0.08, 0.41666666666667
30493, 1.9916666666667, -0.12, 0.41666666666667
30494, 1.9916666666667, -0.16, 0.41666666666667
30495, 2.0333333333333, -0.04, 0.41666666666667
30496, 2.0333333333333, -0.08, 0.41666666666667
30497, 2.0333333333333, -0.12, 0.41666666666667
30498, 2.0333333333333, -0.16, 0.41666666666667
30499, 2.075, -0.04, 0.41666666666667
30500, 2.075, -0.08, 0.41666666666667
30501, 2.075, -0.12, 0.41666666666667
30502, 2.075, -0.16, 0.41666666666667
30503, 2.1166666666667, -0.04, 0.41666666666667
30504, 2.1166666666667, -0.08, 0.41666666666667
30505, 2.1166666666667, -0.12, 0.41666666666667
30506, 2.1166666666667, -0.16, 0.41666666666667
30507, 2.1583333333333, -0.04, 0.41666666666667
30508, 2.1583333333333, -0.08, 0.41666666666667
30509, 2.1583333333333, -0.12, 0.41666666666667
30510, 2.1583333333333, -0.16, 0.41666666666667
30511, 1.2416666666667, -0.04, 0.45833333333333
30512, 1.2416666666667, -0.08, 0.45833333333333
30513, 1.2416666666667, -0.12, 0.45833333333333
30514, 1.2416666666667, -0.16, 0.45833333333333
30515, 1.2833333333333, -0.04, 0.45833333333333
30516, 1.2833333333333, -0.08, 0.45833333333333
30517, 1.2833333333333, -0.12, 0.45833333333333
30518, 1.2833333333333, -0.16, 0.45833333333333
30519, 1.325, -0.04, 0.45833333333333
30520, 1.325, -0.08, 0.45833333333333
30521, 1.325, -0.12, 0.45833333333333
30522, 1.325, -0.16, 0.45833333333333
30523, 1.3666666666667, -0.04, 0.45833333333333
30524, 1.3666666666667, -0.08, 0.45833333333333
30525, 1.3666666666667, -0.12, 0.45833333333333
30526, 1.3666666666667, -0.16, 0.45833333333333
30527, 1.4083333333333, -0.04, 0.45833333333333
30528, 1.4083333333333, -0.08, 0.45833333333333
30529, 1.4083333333333, -0.12, 0.45833333333333
30530, 1.4083333333333, -0.16, 0.45833333333333
30531, 1.45, -0.04, 0.45833333333333
30532, 1.45, -0.08, 0.45833333333333
30533, 1.45, -0.12, 0.45833333333333
30534, 1.45, -0.16, 0.45833333333333
30535, 1.4916666666667, -0.04, 0.45833333333333
30536, 1.4916666666667, -0.08, 0.45833333333333
30537, 1.4916666666667, -0.12, 0.45833333333333
30538, 1.4916666666667, -0.16, 0.45833333333333
30539, 1.5333333333333, -0.04, 0.45833333333333
30540, 1.5333333333333, -0.08, 0.45833333333333
30541, 1.5333333333333, -0.12, 0.45833333333333
30542, 1.5333333333333, -0.16, 0.45833333333333
30543, 1.575, -0.04, 0.45833333333333
30544, 1.575, -0.08, 0.45833333333333
30545, 1.575, -0.12, 0.45833333333333
30546, 1.575, -0.16, 0.45833333333333
30547, 1.6166666666667, -0.04, 0.45833333333333
30548, 1.6166666666667, -0.08, 0.45833333333333
30549, 1.6166666666667, -0.12, 0.45833333333333
30550, 1.6166666666667, -0.16, 0.45833333333333
30551, 1.6583333333333, -0.04, 0.45833333333333
30552, 1.6583333333333, -0.08, 0.45833333333333
30553, 1.6583333333333, -0.12, 0.45833333333333
30554, 1.6583333333333, -0.16, 0.45833333333333
30555, 1.7, -0.04, 0.45833333333333
30556, 1.7, -0.08, 0.45833333333333
30557, 1.7, -0.12, 0.45833333333333
30558, 1.7, -0.16, 0.45833333333333
30559, 1.7416666666667, -0.04, 0.45833333333333
30560, 1.7416666666667, -0.08, 0.45833333333333
30561, 1.7416666666667, -0.12, 0.45833333333333
30562, 1.7416666666667, -0.16, 0.45833333333333
30563, 1.7833333333333, -0.04, 0.45833333333333
30564, 1.7833333333333, -0.08, 0.45833333333333
30565, 1.7833333333333, -0.12, 0.45833333333333
30566, 1.7833333333333, -0.16, 0.45833333333333
30567, 1.825, -0.04, 0.45833333333333
30568, 1.825, -0.08, 0.45833333333333
30569, 1.825, -0.12, 0.45833333333333
30570, 1.825, -0.16, 0.45833333333333
30571, 1.8666666666667, -0.04, 0.45833333333333
30572, 1.8666666666667, -0.08, 0.45833333333333
30573, 1.8666666666667, -0.12, 0.45833333333333
30574, 1.8666666666667, -0.16, 0.45833333333333
30575, 1.9083333333333, -0.04, 0.45833333333333
30576, 1.9083333333333, -0.08, 0.45833333333333
30577, 1.9083333333333, -0.12, 0.45833333333333
30578, 1.9083333333333, -0.16, 0.45833333333333
30579, 1.95, -0.04, 0.45833333333333
30580, 1.95, -0.08, 0.45833333333333
30581, 1.95, -0.12, 0.45833333333333
30582, 1.95, -0.16, 0.45833333333333
30583, 1.9916666666667, -0.04, 0.45833333333333
30584, 1.9916666666667, -0.08, 0.45833333333333
30585, 1.9916666666667, -0.12, 0.45833333333333
30586, 1.9916666666667, -0.16, 0.45833333333333
30587, 2.0333333333333, -0.04, 0.45833333333333
30588, 2.0333333333333, -0.08, 0.45833333333333
30589, 2.0333333333333, -0.12, 0.45833333333333
30590, 2.0333333333333, -0.16, 0.45833333333333
30591, 2.075, -0.04, 0.45833333333333
30592, 2.075, -0.08, 0.45833333333333
30593, 2.075, -0.12, 0.45833333333333
30594, 2.075, -0.16, 0.45833333333333
30595, 2.1166666666667, -0.04, 0.45833333333333
30596, 2.1166666666667, -0.08, 0.45833333333333
30597, 2.1166666666667, -0.12, 0.45833333333333
30598, 2.1166666666667, -0.16, 0.45833333333333
30599, 2.1583333333333, -0.04, 0.45833333333333
30600, 2.1583333333333, -0.08, 0.45833333333333
30601, 2.1583333333333, -0.12, 0.45833333333333
30602, 2.1583333333333, -0.16, 0.45833333333333
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 99
100, 99, 100
101, 100, 101
102, 101, 102
103, 102, 103
104, 103, 104
105, 104, 105
106, 105, 106
107, 106, 107
108, 107, 1
*ELEMENT, type=T3D2, ELSET=Line2
109, 1, 108
110, 108, 109
111, 109, 3
*ELEMENT, type=T3D2, ELSET=Line3
112, 4, 110
113, 110, 111
114, 111, 112
115, 112, 113
116, 113, 114
117, 114, 115
118, 115, 116
119, 116, 117
120, 117, 118
121, 118, 119
122, 119, 120
123, 120, 3
*ELEMENT, type=T3D2, ELSET=Line4
124, 2, 121
125, 121, 122
126, 122, 4
*ELEMENT, type=T3D2, ELSET=Line5
127, 6, 123
128, 123, 124
129, 124, 125
130, 125, 126
131, 126, 127
132, 127, 128
133, 128, 129
134, 129, 130
135, 130, 131
136, 131, 132
137, 132, 133
138, 133, 5
*ELEMENT, type=T3D2, ELSET=Line6
139, 5, 134
140, 134, 135
141, 135, 7
*ELEMENT, type=T3D2, ELSET=Line7
142, 8, 136
143, 136, 137
144, 137, 138
145, 138, 139
146, 139, 140
147, 140, 141
148, 141, 142
149, 142, 143
150, 143, 144
151, 144, 145
152, 145, 146
153, 146, 7
*ELEMENT, type=T3D2, ELSET=Line8
154, 6, 147
155, 147, 148
156, 148, 8
*ELEMENT, type=T3D2, ELSET=Line9
157, 2, 149
158, 149, 150
159, 150, 151
160, 151, 152
161, 152, 153
162, 153, 154
163, 154, 155
164, 155, 156
165, 156, 157
166, 157, 158
167, 158, 159
168, 159, 160
169, 160, 161
170, 161, 162
171, 162, 163
172, 163, 164
173, 164, 165
174, 165, 166
175, 166, 167
176, 167, 168
177, 168, 169
178, 169, 170
179, 170, 171
180, 171, 6
*ELEMENT, type=T3D2, ELSET=Line10
181, 1, 172
182, 172, 173
183, 173, 174
184, 174, 175
185, 175, 176
186, 176, 177
187, 177, 178
188, 178, 179
189, 179, 180
190, 180, 181
191, 181, 182
192, 182, 183
193, 183, 184
194, 184, 185
195, 185, 186
196, 186, 187
197, 187, 188
198, 188, 189
199, 189, 190
200, 190, 191
201, 191, 192
202, 192, 193
203, 193, 194
204, 194, 5
*ELEMENT, type=T3D2, ELSET=Line11
205, 4, 195
206, 195, 196
207, 196, 197
208, 197, 198
209, 198, 199
210, 199, 200
211, 200, 201
212, 201, 202
213, 202, 203
214, 203, 204
215, 204, 205
216, 205, 206
217, 206, 207
218, 207, 208
219, 208, 209
220, 209, 210
221, 210, 211
222, 211, 212
223, 212, 213
224, 213, 214
225, 214, 215
226, 215, 216
227, 216, 217
228, 217, 8
*ELEMENT, type=T3D2, ELSET=Line12
229, 3, 218
230, 218, 219
231, 219, 220
232, 220, 221
233, 221, 222
234, 222, 223
235, 223, 224
236, 224, 225
237, 225, 226
238, 226, 227
239, 227, 228
240, 228, 229
241, 229, 230
242, 230, 231
243, 231, 232
244, 232, 233
245, 233, 234
246, 234, 235
247, 235, 236
248, 236, 237
249, 237, 238
250, 238, 239
251, 239, 240
252, 240, 7
*ELEMENT, type=T3D2, ELSET=Line13
253, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
254, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
255, 10, 241
256, 241, 242
257, 242, 243
258, 243, 244
259, 244, 245
260, 245, 246
261, 246, 247
262, 247, 248
263, 248, 249
264, 249, 250
265, 250, 251
266, 251, 252
267, 252, 253
268, 253, 254
269, 254, 255
270, 255, 256
271, 256, 257
272, 257, 258
273, 258, 259
274, 259, 260
275, 260, 261
276, 261, 262
277, 262, 263
278, 263, 9
*ELEMENT, type=T3D2, ELSET=Line16
279, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
280, 9, 264
281, 264, 265
282, 265, 266
283, 266, 267
284, 267, 268
285, 268, 269
286, 269, 270
287, 270, 271
288, 271, 272
289, 272, 273
290, 273, 274
291, 274, 11
*ELEMENT, type=T3D2, ELSET=Line18
292, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
293, 12, 275
294, 275, 276
295, 276, 277
296, 277, 278
297, 278, 279
298, 279, 280
299, 280, 281
300, 281, 282
301, 282, 283
302, 283, 284
303, 284, 285
304, 285, 286
305, 286, 287
306, 287, 288
307, 288, 289
308, 289, 290
309, 290, 291
310, 291, 292
311, 292, 293
312, 293, 294
313, 294, 295
314, 295, 296
315, 296, 297
316, 297, 11
*ELEMENT, type=T3D2, ELSET=Line20
317, 10, 298
318, 298, 299
319, 299, 300
320, 300, 301
321, 301, 302
322, 302, 303
323, 303, 304
324, 304, 305
325, 305, 306
326, 306, 307
327, 307, 308
328, 308, 12
*ELEMENT, type=T3D2, ELSET=Line21
329, 9, 309
330, 309, 310
331, 310, 311
332, 311, 312
333, 312, 313
334, 313, 314
335, 314, 315
336, 315, 316
337, 316, 317
338, 317, 318
339, 318, 319
340, 319, 320
341, 320, 321
342, 321, 322
343, 322, 323
344, 323, 324
345, 324, 325
346, 325, 326
347, 326, 327
348, 327, 328
349, 328, 329
350, 329, 330
351, 330, 331
352, 331, 13
*ELEMENT, type=T3D2, ELSET=Line22
353, 10, 332
354, 332, 333
355, 333, 334
356, 334, 335
357, 335, 336
358, 336, 337
359, 337, 338
360, 338, 339
361, 339, 340
362, 340, 341
363, 341, 342
364, 342, 343
365, 343, 344
366, 344, 345
367, 345, 346
368, 346, 347
369, 347, 348
370, 348, 349
371, 349, 350
372, 350, 351
373, 351, 352
374, 352, 353
375, 353, 354
376, 354, 14
*ELEMENT, type=T3D2, ELSET=Line23
377, 14, 355
378, 355, 356
379, 356, 357
380, 357, 358
381, 358, 359
382, 359, 360
383, 360, 361
384, 361, 362
385, 362, 363
386, 363, 364
387, 364, 365
388, 365, 366
389, 366, 367
390, 367, 368
391, 368, 369
392, 369, 370
393, 370, 371
394, 371, 372
395, 372, 373
396, 373, 374
397, 374, 375
398, 375, 376
399, 376, 377
400, 377, 13
*ELEMENT, type=T3D2, ELSET=Line24
401, 11, 378
402, 378, 379
403, 379, 380
404, 380, 381
405, 381, 382
406, 382, 383
407, 383, 384
408, 384, 385
409, 385, 386
410, 386, 387
411, 387, 388
412, 388, 389
413, 389, 390
414, 390, 391
415, 391, 392
416, 392, 393
417, 393, 394
418, 394, 395
419, 395, 396
420, 396, 397
421, 397, 398
422, 398, 399
423, 399, 400
424, 400, 15
*ELEMENT, type=T3D2, ELSET=Line25
425, 13, 401
426, 401, 402
427, 402, 403
428, 403, 404
429, 404, 405
430, 405, 406
431, 406, 407
432, 407, 408
433, 408, 409
434, 409, 410
435, 410, 411
436, 411, 15
*ELEMENT, type=T3D2, ELSET=Line26
437, 12, 412
438, 412, 413
439, 413, 414
440, 414, 415
441, 415, 416
442, 416, 417
443, 417, 418
444, 418, 419
445, 419, 420
446, 420, 421
447, 421, 422
448, 422, 423
449, 423, 424
450, 424, 425
451, 425, 426
452, 426, 427
453, 427, 428
454, 428, 429
455, 429, 430
456, 430, 431
457, 431, 432
458, 432, 433
459, 433, 434
460, 434, 16
*ELEMENT, type=T3D2, ELSET=Line27
461, 16, 435
462, 435, 436
463, 436, 437
464, 437, 438
465, 438, 439
466, 439, 440
467, 440, 441
468, 441, 442
469, 442, 443
470, 443, 444
471, 444, 445
472, 445, 446
473, 446, 447
474, 447, 448
475, 448, 449
476, 449, 450
477, 450, 451
478, 451, 452
479, 452, 453
480, 453, 454
481, 454, 455
482, 455, 456
483, 456, 457
484, 457, 15
*ELEMENT, type=T3D2, ELSET=Line28
485, 14, 458
486, 458, 459
487, 459, 460
488, 460, 461
489, 461, 462
490, 462, 463
491, 463, 464
492, 464, 465
493, 465, 466
494, 466, 467
495, 467, 468
496, 468, 16
*ELEMENT, type=T3D2, ELSET=Line29
497, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
498, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
499, 18, 469
500, 469, 470
501, 470, 471
502, 471, 472
503, 472, 473
504, 473, 474
505, 474, 475
506, 475, 476
507, 476, 477
508, 477, 478
509, 478, 479
510, 479, 480
511, 480, 481
512, 481, 482
513, 482, 483
514, 483, 484
515, 484, 485
516, 485, 486
517, 486, 487
518, 487, 488
519, 488, 489
520, 489, 490
521, 490, 491
522, 491, 17
*ELEMENT, type=T3D2, ELSET=Line32
523, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
524, 17, 492
525, 492, 493
526, 493, 494
527, 494, 495
528, 495, 496
529, 496, 497
530, 497, 498
531, 498, 499
532, 499, 500
533, 500, 501
534, 501, 502
535, 502, 19
*ELEMENT, type=T3D2, ELSET=Line34
536, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
537, 20, 503
538, 503, 504
539, 504, 505
540, 505, 506
541, 506, 507
542, 507, 508
543, 508, 509
544, 509, 510
545, 510, 511
546, 511, 512
547, 512, 513
548, 513, 514
549, 514, 515
550, 515, 516
551, 516, 517
552, 517, 518
553, 518, 519
554, 519, 520
555, 520, 521
556, 521, 522
557, 522, 523
558, 523, 524
559, 524, 525
560, 525, 19
*ELEMENT, type=T3D2, ELSET=Line36
561, 18, 526
562, 526, 527
563, 527, 528
564, 528, 529
565, 529, 530
566, 530, 531
567, 531, 532
568, 532, 533
569, 533, 534
570, 534, 535
571, 535, 536
572, 536, 20
*ELEMENT, type=T3D2, ELSET=Line37
573, 17, 537
574, 537, 538
575, 538, 21
*ELEMENT, type=T3D2, ELSET=Line38
576, 18, 539
577, 539, 540
578, 540, 22
*ELEMENT, type=T3D2, ELSET=Line39
579, 22, 541
580, 541, 542
581, 542, 543
582, 543, 544
583, 544, 545
584, 545, 546
585, 546, 547
586, 547, 548
587, 548, 549
588, 549, 550
589, 550, 551
590, 551, 552
591, 552, 553
592, 553, 554
593, 554, 555
594, 555, 556
595, 556, 557
596, 557, 558
597, 558, 559
598, 559, 560
599, 560, 561
600, 561, 562
601, 562, 563
602, 563, 21
*ELEMENT, type=T3D2, ELSET=Line40
603, 19, 564
604, 564, 565
605, 565, 23
*ELEMENT, type=T3D2, ELSET=Line41
606, 21, 566
607, 566, 567
608, 567, 568
609, 568, 569
610, 569, 570
611, 570, 571
612, 571, 572
613, 572, 573
614, 573, 574
615, 574, 575
616, 575, 576
617, 576, 23
*ELEMENT, type=T3D2, ELSET=Line42
618, 20, 577
619, 577, 578
620, 578, 24
*ELEMENT, type=T3D2, ELSET=Line43
621, 24, 579
622, 579, 580
623, 580, 581
624, 581, 582
625, 582, 583
626, 583, 584
627, 584, 585
628, 585, 586
629, 586, 587
630, 587, 588
631, 588, 589
632, 589, 590
633, 590, 591
634, 591, 592
635, 592, 593
636, 593, 594
637, 594, 595
638, 595, 596
639, 596, 597
640, 597, 598
641, 598, 599
642, 599, 600
643, 600, 601
644, 601, 23
*ELEMENT, type=T3D2, ELSET=Line44
645, 22, 602
646, 602, 603
647, 603, 604
648, 604, 605
649, 605, 606
650, 606, 607
651, 607, 608
652, 608, 609
653, 609, 610
654, 610, 611
655, 611, 612
656, 612, 24
*ELEMENT, type=T3D2, ELSET=Line45
657, 19, 613
658, 613, 614
659, 614, 615
660, 615, 616
661, 616, 25
*ELEMENT, type=T3D2, ELSET=Line46
662, 23, 617
663, 617, 618
664, 618, 619
665, 619, 620
666, 620, 26
*ELEMENT, type=T3D2, ELSET=Line47
667, 25, 621
668, 621, 622
669, 622, 26
*ELEMENT, type=T3D2, ELSET=Line48
670, 17, 623
671, 623, 624
672, 624, 625
673, 625, 626
674, 626, 27
*ELEMENT, type=T3D2, ELSET=Line49
675, 21, 627
676, 627, 628
677, 628, 629
678, 629, 630
679, 630, 28
*ELEMENT, type=T3D2, ELSET=Line50
680, 27, 631
681, 631, 632
682, 632, 28
*ELEMENT, type=T3D2, ELSET=Line51
683, 27, 633
684, 633, 634
685, 634, 635
686, 635, 636
687, 636, 637
688, 637, 638
689, 638, 639
690, 639, 640
691, 640, 641
692, 641, 642
693, 642, 643
694, 643, 25
*ELEMENT, type=T3D2, ELSET=Line52
695, 28, 644
696, 644, 645
697, 645, 646
698, 646, 647
699, 647, 648
700, 648, 649
701, 649, 650
702, 650, 651
703, 651, 652
704, 652, 653
705, 653, 654
706, 654, 26
*ELEMENT, type=T3D2, ELSET=Line53
707, 25, 655
708, 655, 656
709, 656, 657
710, 657, 658
711, 658, 659
712, 659, 660
713, 660, 661
714, 661, 662
715, 662, 663
716, 663, 664
717, 664, 665
718, 665, 666
719, 666, 667
720, 667, 668
721, 668, 669
722, 669, 670
723, 670, 671
724, 671, 672
725, 672, 673
726, 673, 674
727, 674, 675
728, 675, 676
729, 676, 677
730, 677, 29
*ELEMENT, type=T3D2, ELSET=Line54
731, 26, 678
732, 678, 679
733, 679, 680
734, 680, 681
735, 681, 682
736, 682, 683
737, 683, 684
738, 684, 685
739, 685, 686
740, 686, 687
741, 687, 688
742, 688, 689
743, 689, 690
744, 690, 691
745, 691, 692
746, 692, 693
747, 693, 694
748, 694, 695
749, 695, 696
750, 696, 697
751, 697, 698
752, 698, 699
753, 699, 700
754, 700, 30
*ELEMENT, type=T3D2, ELSET=Line55
755, 29, 701
756, 701, 702
757, 702, 30
*ELEMENT, type=T3D2, ELSET=Line56
758, 27, 703
759, 703, 704
760, 704, 705
761, 705, 706
762, 706, 707
763, 707, 708
764, 708, 709
765, 709, 710
766, 710, 711
767, 711, 712
768, 712, 713
769, 713, 714
770, 714, 715
771, 715, 716
772, 716, 717
773, 717, 718
774, 718, 719
775, 719, 720
776, 720, 721
777, 721, 722
778, 722, 723
779, 723, 724
780, 724, 725
781, 725, 31
*ELEMENT, type=T3D2, ELSET=Line57
782, 28, 726
783, 726, 727
784, 727, 728
785, 728, 729
786, 729, 730
787, 730, 731
788, 731, 732
789, 732, 733
790, 733, 734
791, 734, 735
792, 735, 736
793, 736, 737
794, 737, 738
795, 738, 739
796, 739, 740
797, 740, 741
798, 741, 742
799, 742, 743
800, 743, 744
801, 744, 745
802, 745, 746
803, 746, 747
804, 747, 748
805, 748, 32
*ELEMENT, type=T3D2, ELSET=Line58
806, 31, 749
807, 749, 750
808, 750, 32
*ELEMENT, type=T3D2, ELSET=Line59
809, 31, 751
810, 751, 752
811, 752, 753
812, 753, 754
813, 754, 755
814, 755, 756
815, 756, 757
816, 757, 758
817, 758, 759
818, 759, 760
819, 760, 761
820, 761, 29
*ELEMENT, type=T3D2, ELSET=Line60
821, 32, 762
822, 762, 763
823, 763, 764
824, 764, 765
825, 765, 766
826, 766, 767
827, 767, 768
828, 768, 769
829, 769, 770
830, 770, 771
831, 771, 772
832, 772, 30
*ELEMENT, type=T3D2, ELSET=Line61
833, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
834, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
835, 33, 773
836, 773, 774
837, 774, 775
838, 775, 776
839, 776, 777
840, 777, 778
841, 778, 779
842, 779, 780
843, 780, 781
844, 781, 782
845, 782, 783
846, 783, 784
847, 784, 785
848, 785, 786
849, 786, 787
850, 787, 788
851, 788, 789
852, 789, 790
853, 790, 791
854, 791, 792
855, 792, 793
856, 793, 794
857, 794, 795
858, 795, 34
*ELEMENT, type=T3D2, ELSET=Line64
859, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
860, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
861, 35, 796
862, 796, 797
863, 797, 798
864, 798, 799
865, 799, 800
866, 800, 801
867, 801, 802
868, 802, 803
869, 803, 804
870, 804, 805
871, 805, 806
872, 806, 807
873, 807, 808
874, 808, 809
875, 809, 810
876, 810, 811
877, 811, 812
878, 812, 813
879, 813, 814
880, 814, 815
881, 815, 816
882, 816, 817
883, 817, 818
884, 818, 36
*ELEMENT, type=T3D2, ELSET=Line67
885, 35, 819
886, 819, 820
887, 820, 821
888, 821, 822
889, 822, 823
890, 823, 824
891, 824, 825
892, 825, 826
893, 826, 827
894, 827, 828
895, 828, 829
896, 829, 33
*ELEMENT, type=T3D2, ELSET=Line68
897, 36, 830
898, 830, 831
899, 831, 832
900, 832, 833
901, 833, 834
902, 834, 835
903, 835, 836
904, 836, 837
905, 837, 838
906, 838, 839
907, 839, 840
908, 840, 34
*ELEMENT, type=T3D2, ELSET=Line69
909, 33, 841
910, 841, 842
911, 842, 843
912, 843, 844
913, 844, 845
914, 845, 846
915, 846, 847
916, 847, 848
917, 848, 849
918, 849, 850
919, 850, 851
920, 851, 852
921, 852, 853
922, 853, 854
923, 854, 855
924, 855, 856
925, 856, 857
926, 857, 858
927, 858, 859
928, 859, 860
929, 860, 861
930, 861, 862
931, 862, 863
932, 863, 37
*ELEMENT, type=T3D2, ELSET=Line70
933, 34, 864
934, 864, 865
935, 865, 866
936, 866, 867
937, 867, 868
938, 868, 869
939, 869, 870
940, 870, 871
941, 871, 872
942, 872, 873
943, 873, 874
944, 874, 875
945, 875, 876
946, 876, 877
947, 877, 878
948, 878, 879
949, 879, 880
950, 880, 881
951, 881, 882
952, 882, 883
953, 883, 884
954, 884, 885
955, 885, 886
956, 886, 38
*ELEMENT, type=T3D2, ELSET=Line71
957, 37, 887
958, 887, 888
959, 888, 889
960, 889, 890
961, 890, 891
962, 891, 892
963, 892, 893
964, 893, 894
965, 894, 895
966, 895, 896
967, 896, 897
968, 897, 898
969, 898, 899
970, 899, 900
971, 900, 901
972, 901, 902
973, 902, 903
974, 903, 904
975, 904, 905
976, 905, 906
977, 906, 907
978, 907, 908
979, 908, 909
980, 909, 38
*ELEMENT, type=T3D2, ELSET=Line72
981, 35, 910
982, 910, 911
983, 911, 912
984, 912, 913
985, 913, 914
986, 914, 915
987, 915, 916
988, 916, 917
989, 917, 918
990, 918, 919
991, 919, 920
992, 920, 921
993, 921, 922
994, 922, 923
995, 923, 924
996, 924, 925
997, 925, 926
998, 926, 927
999, 927, 928
1000, 928, 929
1001, 929, 930
1002, 930, 931
1003, 931, 932
1004, 932, 39
*ELEMENT, type=T3D2, ELSET=Line73
1005, 36, 933
1006, 933, 934
1007, 934, 935
1008, 935, 936
1009, 936, 937
1010, 937, 938
1011, 938, 939
1012, 939, 940
1013, 940, 941
1014, 941, 942
1015, 942, 943
1016, 943, 944
1017, 944, 945
1018, 945, 946
1019, 946, 947
1020, 947, 948
1021, 948, 949
1022, 949, 950
1023, 950, 951
1024, 951, 952
1025, 952, 953
1026, 953, 954
1027, 954, 955
1028, 955, 40
*ELEMENT, type=T3D2, ELSET=Line74
1029, 39, 956
1030, 956, 957
1031, 957, 958
1032, 958, 959
1033, 959, 960
1034, 960, 961
1035, 961, 962
1036, 962, 963
1037, 963, 964
1038, 964, 965
1039, 965, 966
1040, 966, 967
1041, 967, 968
1042, 968, 969
1043, 969, 970
1044, 970, 971
1045, 971, 972
1046, 972, 973
1047, 973, 974
1048, 974, 975
1049, 975, 976
1050, 976, 977
1051, 977, 978
1052, 978, 40
*ELEMENT, type=T3D2, ELSET=Line75
1053, 39, 979
1054, 979, 980
1055, 980, 981
1056, 981, 982
1057, 982, 983
1058, 983, 984
1059, 984, 985
1060, 985, 986
1061, 986, 987
1062, 987, 988
1063, 988, 989
1064, 989, 37
*ELEMENT, type=T3D2, ELSET=Line76
1065, 40, 990
1066, 990, 991
1067, 991, 992
1068, 992, 993
1069, 993, 994
1070, 994, 995
1071, 995, 996
1072, 996, 997
1073, 997, 998
1074, 998, 999
1075, 999, 1000
1076, 1000, 38
*ELEMENT, type=T3D2, ELSET=Line77
1077, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
1078, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
1079, 41, 1001
1080, 1001, 1002
1081, 1002, 1003
1082, 1003, 1004
1083, 1004, 1005
1084, 1005, 1006
1085, 1006, 1007
1086, 1007, 1008
1087, 1008, 1009
1088, 1009, 1010
1089, 1010, 1011
1090, 1011, 1012
1091, 1012, 1013
1092, 1013, 1014
1093, 1014, 1015
1094, 1015, 1016
1095, 1016, 1017
1096, 1017, 1018
1097, 1018, 1019
1098, 1019, 1020
1099, 1020, 1021
1100, 1021, 1022
1101, 1022, 1023
1102, 1023, 42
*ELEMENT, type=T3D2, ELSET=Line80
1103, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
1104, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
1105, 43, 1024
1106, 1024, 1025
1107, 1025, 1026
1108, 1026, 1027
1109, 1027, 1028
1110, 1028, 1029
1111, 1029, 1030
1112, 1030, 1031
1113, 1031, 1032
1114, 1032, 1033
1115, 1033, 1034
1116, 1034, 1035
1117, 1035, 1036
1118, 1036, 1037
1119, 1037, 1038
1120, 1038, 1039
1121, 1039, 1040
1122, 1040, 1041
1123, 1041, 1042
1124, 1042, 1043
1125, 1043, 1044
1126, 1044, 1045
1127, 1045, 1046
1128, 1046, 44
*ELEMENT, type=T3D2, ELSET=Line83
1129, 43, 1047
1130, 1047, 1048
1131, 1048, 1049
1132, 1049, 1050
1133, 1050, 1051
1134, 1051, 1052
1135, 1052, 1053
1136, 1053, 1054
1137, 1054, 1055
1138, 1055, 1056
1139, 1056, 1057
1140, 1057, 41
*ELEMENT, type=T3D2, ELSET=Line84
1141, 44, 1058
1142, 1058, 1059
1143, 1059, 1060
1144, 1060, 1061
1145, 1061, 1062
1146, 1062, 1063
1147, 1063, 1064
1148, 1064, 1065
1149, 1065, 1066
1150, 1066, 1067
1151, 1067, 1068
1152, 1068, 42
*ELEMENT, type=T3D2, ELSET=Line85
1153, 41, 1069
1154, 1069, 1070
1155, 1070, 45
*ELEMENT, type=T3D2, ELSET=Line86
1156, 42, 1071
1157, 1071, 1072
1158, 1072, 46
*ELEMENT, type=T3D2, ELSET=Line87
1159, 45, 1073
1160, 1073, 1074
1161, 1074, 1075
1162, 1075, 1076
1163, 1076, 1077
1164, 1077, 1078
1165, 1078, 1079
1166, 1079, 1080
1167, 1080, 1081
1168, 1081, 1082
1169, 1082, 1083
1170, 1083, 1084
1171, 1084, 1085
1172, 1085, 1086
1173, 1086, 1087
1174, 1087, 1088
1175, 1088, 1089
1176, 1089, 1090
1177, 1090, 1091
1178, 1091, 1092
