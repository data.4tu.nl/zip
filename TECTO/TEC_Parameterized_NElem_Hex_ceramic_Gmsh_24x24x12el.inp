41959, 30498, 30502, 30594, 30590, 12558, 12559, 12582, 12581
41960, 8731, 8732, 8755, 8754, 30499, 30503, 30595, 30591
41961, 30499, 30503, 30595, 30591, 30500, 30504, 30596, 30592
41962, 30500, 30504, 30596, 30592, 30501, 30505, 30597, 30593
41963, 30501, 30505, 30597, 30593, 30502, 30506, 30598, 30594
41964, 30502, 30506, 30598, 30594, 12559, 12560, 12583, 12582
41965, 8732, 8733, 8756, 8755, 30503, 30507, 30599, 30595
41966, 30503, 30507, 30599, 30595, 30504, 30508, 30600, 30596
41967, 30504, 30508, 30600, 30596, 30505, 30509, 30601, 30597
41968, 30505, 30509, 30601, 30597, 30506, 30510, 30602, 30598
41969, 30506, 30510, 30602, 30598, 12560, 12561, 12584, 12583
41970, 8733, 1143, 1144, 8756, 30507, 12324, 12328, 30599
41971, 30507, 12324, 12328, 30599, 30508, 12325, 12329, 30600
41972, 30508, 12325, 12329, 30600, 30509, 12326, 12330, 30601
41973, 30509, 12326, 12330, 30601, 30510, 12327, 12331, 30602
41974, 30510, 12327, 12331, 30602, 12561, 1924, 1925, 12584
41975, 1133, 8734, 1073, 45, 12284, 30511, 12060, 1842
41976, 12284, 30511, 12060, 1842, 12285, 30512, 12061, 1843
41977, 12285, 30512, 12061, 1843, 12286, 30513, 12062, 1844
41978, 12286, 30513, 12062, 1844, 12287, 30514, 12063, 1845
41979, 12287, 30514, 12063, 1845, 1914, 12562, 1850, 91
41980, 8734, 8735, 1074, 1073, 30511, 30515, 12064, 12060
41981, 30511, 30515, 12064, 12060, 30512, 30516, 12065, 12061
41982, 30512, 30516, 12065, 12061, 30513, 30517, 12066, 12062
41983, 30513, 30517, 12066, 12062, 30514, 30518, 12067, 12063
41984, 30514, 30518, 12067, 12063, 12562, 12563, 1851, 1850
41985, 8735, 8736, 1075, 1074, 30515, 30519, 12068, 12064
41986, 30515, 30519, 12068, 12064, 30516, 30520, 12069, 12065
41987, 30516, 30520, 12069, 12065, 30517, 30521, 12070, 12066
41988, 30517, 30521, 12070, 12066, 30518, 30522, 12071, 12067
41989, 30518, 30522, 12071, 12067, 12563, 12564, 1852, 1851
41990, 8736, 8737, 1076, 1075, 30519, 30523, 12072, 12068
41991, 30519, 30523, 12072, 12068, 30520, 30524, 12073, 12069
41992, 30520, 30524, 12073, 12069, 30521, 30525, 12074, 12070
41993, 30521, 30525, 12074, 12070, 30522, 30526, 12075, 12071
41994, 30522, 30526, 12075, 12071, 12564, 12565, 1853, 1852
41995, 8737, 8738, 1077, 1076, 30523, 30527, 12076, 12072
41996, 30523, 30527, 12076, 12072, 30524, 30528, 12077, 12073
41997, 30524, 30528, 12077, 12073, 30525, 30529, 12078, 12074
41998, 30525, 30529, 12078, 12074, 30526, 30530, 12079, 12075
41999, 30526, 30530, 12079, 12075, 12565, 12566, 1854, 1853
42000, 8738, 8739, 1078, 1077, 30527, 30531, 12080, 12076
42001, 30527, 30531, 12080, 12076, 30528, 30532, 12081, 12077
42002, 30528, 30532, 12081, 12077, 30529, 30533, 12082, 12078
42003, 30529, 30533, 12082, 12078, 30530, 30534, 12083, 12079
42004, 30530, 30534, 12083, 12079, 12566, 12567, 1855, 1854
42005, 8739, 8740, 1079, 1078, 30531, 30535, 12084, 12080
42006, 30531, 30535, 12084, 12080, 30532, 30536, 12085, 12081
42007, 30532, 30536, 12085, 12081, 30533, 30537, 12086, 12082
42008, 30533, 30537, 12086, 12082, 30534, 30538, 12087, 12083
42009, 30534, 30538, 12087, 12083, 12567, 12568, 1856, 1855
42010, 8740, 8741, 1080, 1079, 30535, 30539, 12088, 12084
42011, 30535, 30539, 12088, 12084, 30536, 30540, 12089, 12085
42012, 30536, 30540, 12089, 12085, 30537, 30541, 12090, 12086
42013, 30537, 30541, 12090, 12086, 30538, 30542, 12091, 12087
42014, 30538, 30542, 12091, 12087, 12568, 12569, 1857, 1856
42015, 8741, 8742, 1081, 1080, 30539, 30543, 12092, 12088
42016, 30539, 30543, 12092, 12088, 30540, 30544, 12093, 12089
42017, 30540, 30544, 12093, 12089, 30541, 30545, 12094, 12090
42018, 30541, 30545, 12094, 12090, 30542, 30546, 12095, 12091
42019, 30542, 30546, 12095, 12091, 12569, 12570, 1858, 1857
42020, 8742, 8743, 1082, 1081, 30543, 30547, 12096, 12092
42021, 30543, 30547, 12096, 12092, 30544, 30548, 12097, 12093
42022, 30544, 30548, 12097, 12093, 30545, 30549, 12098, 12094
42023, 30545, 30549, 12098, 12094, 30546, 30550, 12099, 12095
42024, 30546, 30550, 12099, 12095, 12570, 12571, 1859, 1858
42025, 8743, 8744, 1083, 1082, 30547, 30551, 12100, 12096
42026, 30547, 30551, 12100, 12096, 30548, 30552, 12101, 12097
42027, 30548, 30552, 12101, 12097, 30549, 30553, 12102, 12098
42028, 30549, 30553, 12102, 12098, 30550, 30554, 12103, 12099
42029, 30550, 30554, 12103, 12099, 12571, 12572, 1860, 1859
42030, 8744, 8745, 1084, 1083, 30551, 30555, 12104, 12100
42031, 30551, 30555, 12104, 12100, 30552, 30556, 12105, 12101
42032, 30552, 30556, 12105, 12101, 30553, 30557, 12106, 12102
42033, 30553, 30557, 12106, 12102, 30554, 30558, 12107, 12103
42034, 30554, 30558, 12107, 12103, 12572, 12573, 1861, 1860
42035, 8745, 8746, 1085, 1084, 30555, 30559, 12108, 12104
42036, 30555, 30559, 12108, 12104, 30556, 30560, 12109, 12105
42037, 30556, 30560, 12109, 12105, 30557, 30561, 12110, 12106
42038, 30557, 30561, 12110, 12106, 30558, 30562, 12111, 12107
42039, 30558, 30562, 12111, 12107, 12573, 12574, 1862, 1861
42040, 8746, 8747, 1086, 1085, 30559, 30563, 12112, 12108
42041, 30559, 30563, 12112, 12108, 30560, 30564, 12113, 12109
42042, 30560, 30564, 12113, 12109, 30561, 30565, 12114, 12110
42043, 30561, 30565, 12114, 12110, 30562, 30566, 12115, 12111
42044, 30562, 30566, 12115, 12111, 12574, 12575, 1863, 1862
42045, 8747, 8748, 1087, 1086, 30563, 30567, 12116, 12112
42046, 30563, 30567, 12116, 12112, 30564, 30568, 12117, 12113
42047, 30564, 30568, 12117, 12113, 30565, 30569, 12118, 12114
42048, 30565, 30569, 12118, 12114, 30566, 30570, 12119, 12115
42049, 30566, 30570, 12119, 12115, 12575, 12576, 1864, 1863
42050, 8748, 8749, 1088, 1087, 30567, 30571, 12120, 12116
42051, 30567, 30571, 12120, 12116, 30568, 30572, 12121, 12117
42052, 30568, 30572, 12121, 12117, 30569, 30573, 12122, 12118
42053, 30569, 30573, 12122, 12118, 30570, 30574, 12123, 12119
42054, 30570, 30574, 12123, 12119, 12576, 12577, 1865, 1864
42055, 8749, 8750, 1089, 1088, 30571, 30575, 12124, 12120
42056, 30571, 30575, 12124, 12120, 30572, 30576, 12125, 12121
42057, 30572, 30576, 12125, 12121, 30573, 30577, 12126, 12122
42058, 30573, 30577, 12126, 12122, 30574, 30578, 12127, 12123
42059, 30574, 30578, 12127, 12123, 12577, 12578, 1866, 1865
42060, 8750, 8751, 1090, 1089, 30575, 30579, 12128, 12124
42061, 30575, 30579, 12128, 12124, 30576, 30580, 12129, 12125
42062, 30576, 30580, 12129, 12125, 30577, 30581, 12130, 12126
42063, 30577, 30581, 12130, 12126, 30578, 30582, 12131, 12127
42064, 30578, 30582, 12131, 12127, 12578, 12579, 1867, 1866
42065, 8751, 8752, 1091, 1090, 30579, 30583, 12132, 12128
42066, 30579, 30583, 12132, 12128, 30580, 30584, 12133, 12129
42067, 30580, 30584, 12133, 12129, 30581, 30585, 12134, 12130
42068, 30581, 30585, 12134, 12130, 30582, 30586, 12135, 12131
42069, 30582, 30586, 12135, 12131, 12579, 12580, 1868, 1867
42070, 8752, 8753, 1092, 1091, 30583, 30587, 12136, 12132
42071, 30583, 30587, 12136, 12132, 30584, 30588, 12137, 12133
42072, 30584, 30588, 12137, 12133, 30585, 30589, 12138, 12134
42073, 30585, 30589, 12138, 12134, 30586, 30590, 12139, 12135
42074, 30586, 30590, 12139, 12135, 12580, 12581, 1869, 1868
42075, 8753, 8754, 1093, 1092, 30587, 30591, 12140, 12136
42076, 30587, 30591, 12140, 12136, 30588, 30592, 12141, 12137
42077, 30588, 30592, 12141, 12137, 30589, 30593, 12142, 12138
42078, 30589, 30593, 12142, 12138, 30590, 30594, 12143, 12139
42079, 30590, 30594, 12143, 12139, 12581, 12582, 1870, 1869
42080, 8754, 8755, 1094, 1093, 30591, 30595, 12144, 12140
42081, 30591, 30595, 12144, 12140, 30592, 30596, 12145, 12141
42082, 30592, 30596, 12145, 12141, 30593, 30597, 12146, 12142
42083, 30593, 30597, 12146, 12142, 30594, 30598, 12147, 12143
42084, 30594, 30598, 12147, 12143, 12582, 12583, 1871, 1870
42085, 8755, 8756, 1095, 1094, 30595, 30599, 12148, 12144
42086, 30595, 30599, 12148, 12144, 30596, 30600, 12149, 12145
42087, 30596, 30600, 12149, 12145, 30597, 30601, 12150, 12146
42088, 30597, 30601, 12150, 12146, 30598, 30602, 12151, 12147
42089, 30598, 30602, 12151, 12147, 12583, 12584, 1872, 1871
42090, 8756, 1144, 46, 1095, 30599, 12328, 1846, 12148
42091, 30599, 12328, 1846, 12148, 30600, 12329, 1847, 12149
42092, 30600, 12329, 1847, 12149, 30601, 12330, 1848, 12150
42093, 30601, 12330, 1848, 12150, 30602, 12331, 1849, 12151
42094, 30602, 12331, 1849, 12151, 12584, 1925, 92, 1872
*ELEMENT, type=C3D8, ELSET=Volume26
42095, 48, 52, 1160, 1134, 1877, 1930, 12585, 12288
42096, 1877, 1930, 12585, 12288, 1878, 1931, 12586, 12289
42097, 1878, 1931, 12586, 12289, 1879, 1932, 12587, 12290
42098, 1879, 1932, 12587, 12290, 1880, 1933, 12588, 12291
42099, 1880, 1933, 12588, 12291, 94, 96, 1934, 1915
42100, 1134, 1160, 1161, 1135, 12288, 12585, 12589, 12292
42101, 12288, 12585, 12589, 12292, 12289, 12586, 12590, 12293
42102, 12289, 12586, 12590, 12293, 12290, 12587, 12591, 12294
42103, 12290, 12587, 12591, 12294, 12291, 12588, 12592, 12295
42104, 12291, 12588, 12592, 12295, 1915, 1934, 1935, 1916
42105, 1135, 1161, 1162, 1136, 12292, 12589, 12593, 12296
42106, 12292, 12589, 12593, 12296, 12293, 12590, 12594, 12297
42107, 12293, 12590, 12594, 12297, 12294, 12591, 12595, 12298
42108, 12294, 12591, 12595, 12298, 12295, 12592, 12596, 12299
42109, 12295, 12592, 12596, 12299, 1916, 1935, 1936, 1917
42110, 1136, 1162, 1163, 1137, 12296, 12593, 12597, 12300
42111, 12296, 12593, 12597, 12300, 12297, 12594, 12598, 12301
42112, 12297, 12594, 12598, 12301, 12298, 12595, 12599, 12302
42113, 12298, 12595, 12599, 12302, 12299, 12596, 12600, 12303
42114, 12299, 12596, 12600, 12303, 1917, 1936, 1937, 1918
42115, 1137, 1163, 1164, 1138, 12300, 12597, 12601, 12304
42116, 12300, 12597, 12601, 12304, 12301, 12598, 12602, 12305
42117, 12301, 12598, 12602, 12305, 12302, 12599, 12603, 12306
42118, 12302, 12599, 12603, 12306, 12303, 12600, 12604, 12307
42119, 12303, 12600, 12604, 12307, 1918, 1937, 1938, 1919
42120, 1138, 1164, 1165, 1139, 12304, 12601, 12605, 12308
42121, 12304, 12601, 12605, 12308, 12305, 12602, 12606, 12309
42122, 12305, 12602, 12606, 12309, 12306, 12603, 12607, 12310
42123, 12306, 12603, 12607, 12310, 12307, 12604, 12608, 12311
42124, 12307, 12604, 12608, 12311, 1919, 1938, 1939, 1920
42125, 1139, 1165, 1166, 1140, 12308, 12605, 12609, 12312
42126, 12308, 12605, 12609, 12312, 12309, 12606, 12610, 12313
42127, 12309, 12606, 12610, 12313, 12310, 12607, 12611, 12314
42128, 12310, 12607, 12611, 12314, 12311, 12608, 12612, 12315
42129, 12311, 12608, 12612, 12315, 1920, 1939, 1940, 1921
42130, 1140, 1166, 1167, 1141, 12312, 12609, 12613, 12316
42131, 12312, 12609, 12613, 12316, 12313, 12610, 12614, 12317
42132, 12313, 12610, 12614, 12317, 12314, 12611, 12615, 12318
42133, 12314, 12611, 12615, 12318, 12315, 12612, 12616, 12319
42134, 12315, 12612, 12616, 12319, 1921, 1940, 1941, 1922
42135, 1141, 1167, 1168, 1142, 12316, 12613, 12617, 12320
42136, 12316, 12613, 12617, 12320, 12317, 12614, 12618, 12321
42137, 12317, 12614, 12618, 12321, 12318, 12615, 12619, 12322
42138, 12318, 12615, 12619, 12322, 12319, 12616, 12620, 12323
42139, 12319, 12616, 12620, 12323, 1922, 1941, 1942, 1923
42140, 1142, 1168, 1169, 1143, 12320, 12617, 12621, 12324
42141, 12320, 12617, 12621, 12324, 12321, 12618, 12622, 12325
42142, 12321, 12618, 12622, 12325, 12322, 12619, 12623, 12326
42143, 12322, 12619, 12623, 12326, 12323, 12620, 12624, 12327
42144, 12323, 12620, 12624, 12327, 1923, 1942, 1943, 1924
42145, 1143, 1169, 1170, 1144, 12324, 12621, 12625, 12328
42146, 12324, 12621, 12625, 12328, 12325, 12622, 12626, 12329
42147, 12325, 12622, 12626, 12329, 12326, 12623, 12627, 12330
42148, 12326, 12623, 12627, 12330, 12327, 12624, 12628, 12331
42149, 12327, 12624, 12628, 12331, 1924, 1943, 1944, 1925
42150, 1144, 1170, 50, 46, 12328, 12625, 1926, 1846
42151, 12328, 12625, 1926, 1846, 12329, 12626, 1927, 1847
42152, 12329, 12626, 1927, 1847, 12330, 12627, 1928, 1848
42153, 12330, 12627, 1928, 1848, 12331, 12628, 1929, 1849
42154, 12331, 12628, 1929, 1849, 1925, 1944, 95, 92
*ELSET,ELSET=Qin
5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 
5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 
5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 
5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 
5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 
5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 
5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 
5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 
5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 
5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 
5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 
5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 
6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 
6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 
6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 
6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 
6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 
6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 
6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 
6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 
6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 
6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 
6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 
6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 
6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 
6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 
6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 
6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 
6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 6261, 6262, 
6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 
6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 
6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 
6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6789, 6790, 
6791, 6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 
6801, 6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 
6811, 6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 
6821, 6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 
6831, 6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 
6841, 6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 
6851, 6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 
6861, 6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 
6871, 6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 
6881, 6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 
6891, 6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 
6901, 6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 
6911, 6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 
6921, 6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 
6931, 6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 
6941, 6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 
6951, 6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 
6961, 6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 
6971, 6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 
6981, 6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 
6991, 6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 
7001, 7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 
7011, 7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 
7021, 7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 
7031, 7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 
7041, 7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 
7051, 7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 
7061, 7062, 7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 
7071, 7072, 7073, 7074, 7075, 7076, 
*ELSET,ELSET=HeatSink
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 10065, 10066, 
10067, 10068, 10069, 10070, 10071, 10072, 10073, 10074, 10075, 10076, 
10077, 10078, 10079, 10080, 10081, 10082, 10083, 10084, 10085, 10086, 
10087, 10088, 10089, 10090, 10091, 10092, 10093, 10094, 10095, 10096, 
10097, 10098, 10099, 10100, 10101, 10102, 10103, 10104, 10105, 10106, 
10107, 10108, 10109, 10110, 10111, 10112, 10113, 10114, 10115, 10116, 
10117, 10118, 10119, 10120, 10121, 10122, 10123, 10124, 10125, 10126, 
10127, 10128, 10129, 10130, 10131, 10132, 10133, 10134, 10135, 10136, 
10137, 10138, 10139, 10140, 10141, 10142, 10143, 10144, 10145, 10146, 
10147, 10148, 10149, 10150, 10151, 10152, 10153, 10154, 10155, 10156, 
10157, 10158, 10159, 10160, 10161, 10162, 10163, 10164, 10165, 10166, 
10167, 10168, 10169, 10170, 10171, 10172, 10173, 10174, 10175, 10176, 
10177, 10178, 10179, 10180, 10181, 10182, 10183, 10184, 10185, 10186, 
10187, 10188, 10189, 10190, 10191, 10192, 10193, 10194, 10195, 10196, 
10197, 10198, 10199, 10200, 10201, 10202, 10203, 10204, 10205, 10206, 
10207, 10208, 10209, 10210, 10211, 10212, 10213, 10214, 10215, 10216, 
10217, 10218, 10219, 10220, 10221, 10222, 10223, 10224, 10225, 10226, 
10227, 10228, 10229, 10230, 10231, 10232, 10233, 10234, 10235, 10236, 
10237, 10238, 10239, 10240, 10241, 10242, 10243, 10244, 10245, 10246, 
10247, 10248, 10249, 10250, 10251, 10252, 10253, 10254, 10255, 10256, 
10257, 10258, 10259, 10260, 10261, 10262, 10263, 10264, 10265, 10266, 
10267, 10268, 10269, 10270, 10271, 10272, 10273, 10274, 10275, 10276, 
10277, 10278, 10279, 10280, 10281, 10282, 10283, 10284, 10285, 10286, 
10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 
10297, 10298, 10299, 10300, 10301, 10302, 10303, 10304, 10305, 10306, 
10307, 10308, 10309, 10310, 10311, 10312, 10313, 10314, 10315, 10316, 
10317, 10318, 10319, 10320, 10321, 10322, 10323, 10324, 10325, 10326, 
10327, 10328, 10329, 10330, 10331, 10332, 10333, 10334, 10335, 10336, 
10337, 10338, 10339, 10340, 10341, 10342, 10343, 10344, 10345, 10346, 
10347, 10348, 10349, 10350, 10351, 10352, 
*ELSET,ELSET=ElectrodeMaxX
10383, 10384, 10385, 10386, 10387, 10388, 10389, 10390, 10391, 10392, 
10393, 10394, 10395, 10396, 10397, 10398, 10399, 10400, 10401, 10402, 
10403, 10404, 10405, 10406, 10407, 10408, 10409, 10410, 10411, 10412, 
10413, 10414, 10415, 10416, 10417, 10418, 
*ELSET,ELSET=ElectrodeMinX
10449, 10450, 10451, 10452, 10453, 10454, 10455, 10456, 10457, 10458, 
10459, 10460, 10461, 10462, 10463, 10464, 10465, 10466, 10467, 10468, 
10469, 10470, 10471, 10472, 10473, 10474, 10475, 10476, 10477, 10478, 
10479, 10480, 10481, 10482, 10483, 10484, 
*ELSET,ELSET=Force
5847, 5848, 5849, 5850, 5851, 5852, 5853, 5854, 5855, 5856, 
5857, 5858, 5859, 5860, 5861, 5862, 5863, 5864, 5865, 5866, 
5867, 5868, 5869, 5870, 5871, 5872, 5873, 5874, 5875, 5876, 
5877, 5878, 5879, 5880, 5881, 5882, 
*ELSET,ELSET=Ceramic_Top
13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 13018, 
13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 13028, 
13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 13038, 
13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 13048, 
13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 13058, 
13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 13068, 
13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 
13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 13088, 
13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 13098, 
13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 13108, 
13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 13118, 
13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 13128, 
13129, 13130, 13131, 13132, 13133, 13134, 13135, 13136, 13137, 13138, 
13139, 13140, 13141, 13142, 13143, 13144, 13145, 13146, 13147, 13148, 
13149, 13150, 13151, 13152, 13153, 13154, 13155, 13156, 13157, 13158, 
13159, 13160, 13161, 13162, 13163, 13164, 13165, 13166, 13167, 13168, 
13169, 13170, 13171, 13172, 13173, 13174, 13175, 13176, 13177, 13178, 
13179, 13180, 13181, 13182, 13183, 13184, 13185, 13186, 13187, 13188, 
13189, 13190, 13191, 13192, 13193, 13194, 13195, 13196, 13197, 13198, 
13199, 13200, 13201, 13202, 13203, 13204, 13205, 13206, 13207, 13208, 
13209, 13210, 13211, 13212, 13213, 13214, 13215, 13216, 13217, 13218, 
13219, 13220, 13221, 13222, 13223, 13224, 13225, 13226, 13227, 13228, 
13229, 13230, 13231, 13232, 13233, 13234, 13235, 13236, 13237, 13238, 
13239, 13240, 13241, 13242, 13243, 13244, 13245, 13246, 13247, 13248, 
13249, 13250, 13251, 13252, 13253, 13254, 13255, 13256, 13257, 13258, 
13259, 13260, 13261, 13262, 13263, 13264, 13265, 13266, 13267, 13268, 
13269, 13270, 13271, 13272, 13273, 13274, 13275, 13276, 13277, 13278, 
13279, 13280, 13281, 13282, 13283, 13284, 13285, 13286, 13287, 13288, 
13289, 13290, 13291, 13292, 13293, 13294, 13295, 13296, 13407, 13408, 
13409, 13410, 13411, 13412, 13413, 13414, 13415, 13416, 13417, 13418, 
13419, 13420, 13421, 13422, 13423, 13424, 13425, 13426, 13427, 13428, 
13429, 13430, 13431, 13432, 13433, 13434, 13435, 13436, 13437, 13438, 
13439, 13440, 13441, 13442, 13443, 13444, 13445, 13446, 13447, 13448, 
13449, 13450, 13451, 13452, 13453, 13454, 13455, 13456, 13457, 13458, 
13459, 13460, 13461, 13462, 13463, 13464, 13465, 13466, 13767, 13768, 
13769, 13770, 13771, 13772, 13773, 13774, 13775, 13776, 13777, 13778, 
13779, 13780, 13781, 13782, 13783, 13784, 13785, 13786, 13787, 13788, 
13789, 13790, 13791, 13792, 13793, 13794, 13795, 13796, 13797, 13798, 
13799, 13800, 13801, 13802, 13803, 13804, 13805, 13806, 13807, 13808, 
13809, 13810, 13811, 13812, 13813, 13814, 13815, 13816, 13817, 13818, 
13819, 13820, 13821, 13822, 13823, 13824, 13825, 13826, 13827, 13828, 
13829, 13830, 13831, 13832, 13833, 13834, 13835, 13836, 13837, 13838, 
13839, 13840, 13841, 13842, 13843, 13844, 13845, 13846, 13847, 13848, 
13849, 13850, 13851, 13852, 13853, 13854, 13855, 13856, 13857, 13858, 
13859, 13860, 13861, 13862, 13863, 13864, 13865, 13866, 13867, 13868, 
13869, 13870, 13871, 13872, 13873, 13874, 13875, 13876, 13877, 13878, 
13879, 13880, 13881, 13882, 13883, 13884, 13885, 13886, 13887, 13888, 
13889, 13890, 13891, 13892, 13893, 13894, 13895, 13896, 13897, 13898, 
13899, 13900, 13901, 13902, 13903, 13904, 13905, 13906, 13907, 13908, 
13909, 13910, 13911, 13912, 13913, 13914, 13915, 13916, 13917, 13918, 
13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 13927, 13928, 
13929, 13930, 13931, 13932, 13933, 13934, 13935, 13936, 13937, 13938, 
13939, 13940, 13941, 13942, 13943, 13944, 13945, 13946, 13947, 13948, 
13949, 13950, 13951, 13952, 13953, 13954, 13955, 13956, 13957, 13958, 
13959, 13960, 13961, 13962, 13963, 13964, 13965, 13966, 13967, 13968, 
13969, 13970, 13971, 13972, 13973, 13974, 13975, 13976, 13977, 13978, 
13979, 13980, 13981, 13982, 13983, 13984, 13985, 13986, 13987, 13988, 
13989, 13990, 13991, 13992, 13993, 13994, 13995, 13996, 13997, 13998, 
13999, 14000, 14001, 14002, 14003, 14004, 14005, 14006, 14007, 14008, 
14009, 14010, 14011, 14012, 14013, 14014, 14015, 14016, 14017, 14018, 
14019, 14020, 14021, 14022, 14023, 14024, 14025, 14026, 14027, 14028, 
14029, 14030, 14031, 14032, 14033, 14034, 14035, 14036, 14037, 14038, 
14039, 14040, 14041, 14042, 14043, 14044, 14045, 14046, 14047, 14048, 
14049, 14050, 14051, 14052, 14053, 14054, 
*ELSET,ELSET=Ceramic_Bottom
13297, 13298, 13299, 13300, 13301, 13302, 13303, 13304, 13305, 13306, 
13307, 13308, 13309, 13310, 13311, 13312, 13313, 13314, 13315, 13316, 
13317, 13318, 13319, 13320, 13321, 14415, 14416, 14417, 14418, 14419, 
14420, 14421, 14422, 14423, 14424, 14425, 14426, 14427, 14428, 14429, 
14430, 14431, 14432, 14433, 14434, 14435, 14436, 14437, 14438, 14439, 
14440, 14441, 14442, 14443, 14444, 14445, 14446, 14447, 14448, 14449, 
14450, 14451, 14452, 14453, 14454, 14455, 14456, 14457, 14458, 14459, 
14460, 14461, 14462, 14463, 14464, 14465, 14466, 14467, 14468, 14469, 
14470, 14471, 14472, 14473, 14474, 14475, 14476, 14477, 14478, 14479, 
14480, 14481, 14482, 14483, 14484, 14485, 14486, 14487, 14488, 14489, 
14490, 14491, 14492, 14493, 14494, 14495, 14496, 14497, 14498, 14499, 
14500, 14501, 14502, 14503, 14504, 14505, 14506, 14507, 14508, 14509, 
14510, 14511, 14512, 14513, 14514, 14515, 14516, 14517, 14518, 14519, 
14520, 14521, 14522, 14523, 14524, 14525, 14526, 14527, 14528, 14529, 
14530, 14531, 14532, 14533, 14534, 14535, 14536, 14537, 14538, 14539, 
14540, 14541, 14542, 14543, 14544, 14545, 14546, 14547, 14548, 14549, 
14550, 14551, 14552, 14553, 14554, 14555, 14556, 14557, 14558, 14559, 
14560, 14561, 14562, 14563, 14564, 14565, 14566, 14567, 14568, 14569, 
14570, 14571, 14572, 14573, 14574, 14575, 14576, 14577, 14578, 14579, 
14580, 14581, 14582, 14583, 14584, 14585, 14586, 14587, 14588, 14589, 
14590, 14591, 14592, 14593, 14594, 14595, 14596, 14597, 14598, 14599, 
14600, 14601, 14602, 14603, 14604, 14605, 14606, 14607, 14608, 14609, 
14610, 14611, 14612, 14613, 14614, 14615, 14616, 14617, 14618, 14619, 
14620, 14621, 14622, 14623, 14624, 14625, 14626, 14627, 14628, 14629, 
14630, 14631, 14632, 14633, 14634, 14635, 14636, 14637, 14638, 14639, 
14640, 14641, 14642, 14643, 14644, 14645, 14646, 14647, 14648, 14649, 
14650, 14651, 14652, 14653, 14654, 14655, 14656, 14657, 14658, 14659, 
14660, 14661, 14662, 14663, 14664, 14665, 14666, 14667, 14668, 14669, 
14670, 14671, 14672, 14673, 14674, 14675, 14676, 14677, 14678, 14679, 
14680, 14681, 14682, 14683, 14684, 14685, 14686, 14687, 14688, 14689, 
14690, 14691, 14692, 14693, 14694, 14695, 14696, 14697, 14698, 14699, 
14700, 14701, 14702, 15145, 15146, 15147, 15148, 15149, 15150, 15151, 
15152, 15153, 15154, 15155, 15156, 15157, 15158, 15159, 15160, 15161, 
15162, 15163, 15164, 15165, 15166, 15167, 15168, 15169, 15170, 15171, 
15172, 15173, 15174, 15175, 15176, 15177, 15178, 15179, 15180, 15181, 
15182, 15183, 15184, 15185, 15186, 15187, 15188, 15189, 15190, 15191, 
15192, 15193, 15194, 15195, 15196, 15197, 15198, 15199, 15200, 15201, 
15202, 15203, 15204, 15205, 15206, 15207, 15208, 15209, 15210, 15211, 
15212, 15213, 15214, 15215, 15216, 15217, 15218, 15219, 15220, 15221, 
15222, 15223, 15224, 15225, 15226, 15227, 15228, 15229, 15230, 15231, 
15232, 15233, 15234, 15235, 15236, 15237, 15238, 15239, 15240, 15241, 
15242, 15243, 15244, 15245, 15246, 15247, 15248, 15249, 15250, 15251, 
15252, 15253, 15254, 15255, 15256, 15257, 15258, 15259, 15260, 15261, 
15262, 15263, 15264, 15265, 15266, 15267, 15268, 15269, 15270, 15271, 
15272, 15273, 15274, 15275, 15276, 15277, 15278, 15279, 15280, 15281, 
15282, 15283, 15284, 15285, 15286, 15287, 15288, 15289, 15290, 15291, 
15292, 15293, 15294, 15295, 15296, 15297, 15298, 15299, 15300, 15301, 
15302, 15303, 15304, 15305, 15306, 15307, 15308, 15309, 15310, 15311, 
15312, 15313, 15314, 15315, 15316, 15317, 15318, 15319, 15320, 15321, 
15322, 15323, 15324, 15325, 15326, 15327, 15328, 15329, 15330, 15331, 
15332, 15333, 15334, 15335, 15336, 15337, 15338, 15339, 15340, 15341, 
15342, 15343, 15344, 15345, 15346, 15347, 15348, 15349, 15350, 15351, 
15352, 15353, 15354, 15355, 15356, 15357, 15358, 15359, 15360, 15361, 
15362, 15363, 15364, 15365, 15366, 15367, 15368, 15369, 15370, 15371, 
15372, 15373, 15374, 15375, 15376, 15377, 15378, 15379, 15380, 15381, 
15382, 15383, 15384, 15385, 15386, 15387, 15388, 15389, 15390, 15391, 
15392, 15393, 15394, 15395, 15396, 15397, 15398, 15399, 15400, 15401, 
15402, 15403, 15404, 15405, 15406, 15407, 15408, 15409, 15410, 15411, 
15412, 15413, 15414, 15415, 15416, 15417, 15418, 15419, 15420, 15421, 
15422, 15423, 15424, 15425, 15426, 15427, 15428, 15429, 15430, 15431, 
15432, 
*ELSET,ELSET=Top_Semiconductors
5019, 5020, 5021, 5022, 5023, 5024, 5025, 5026, 5027, 5028, 
5029, 5030, 5031, 5032, 5033, 5034, 5035, 5036, 5037, 5038, 
5039, 5040, 5041, 5042, 5043, 5044, 5045, 5046, 5047, 5048, 
5049, 5050, 5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 
5059, 5060, 5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 
5069, 5070, 5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 
5079, 5080, 5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 
5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 
5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 
5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 
5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 
5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 
5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 
5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 
5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 
5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 
5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 
5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 
5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 
5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 
5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 
5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 
5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 
5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 
5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 
5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 
5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 
5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 
5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 7185, 7186, 
7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 7195, 7196, 
7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 7205, 7206, 
7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 7215, 7216, 
7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 7225, 7226, 
7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 7235, 7236, 
7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 7245, 7246, 
7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 7255, 7256, 
7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 7265, 7266, 
7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 7275, 7276, 
7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 7285, 7286, 
7287, 7288, 7289, 7290, 7291, 7292, 7293, 7294, 7295, 7296, 
7297, 7298, 7299, 7300, 7301, 7302, 7303, 7304, 7305, 7306, 
7307, 7308, 7309, 7310, 7311, 7312, 7313, 7314, 7315, 7316, 
7317, 7318, 7319, 7320, 7321, 7322, 7323, 7324, 7325, 7326, 
7327, 7328, 7329, 7330, 7331, 7332, 7333, 7334, 7335, 7336, 
7337, 7338, 7339, 7340, 7341, 7342, 7343, 7344, 7345, 7346, 
7347, 7348, 7349, 7350, 7351, 7352, 7353, 7354, 7355, 7356, 
7357, 7358, 7359, 7360, 7361, 7362, 7363, 7364, 7365, 7366, 
7367, 7368, 7369, 7370, 7371, 7372, 7373, 7374, 7375, 7376, 
7377, 7378, 7379, 7380, 7381, 7382, 7383, 7384, 7385, 7386, 
7387, 7388, 7389, 7390, 7391, 7392, 7393, 7394, 7395, 7396, 
7397, 7398, 7399, 7400, 7401, 7402, 7403, 7404, 7405, 7406, 
7407, 7408, 7409, 7410, 7411, 7412, 7413, 7414, 7415, 7416, 
7417, 7418, 7419, 7420, 7421, 7422, 7423, 7424, 7425, 7426, 
7427, 7428, 7429, 7430, 7431, 7432, 7433, 7434, 7435, 7436, 
7437, 7438, 7439, 7440, 7441, 7442, 7443, 7444, 7445, 7446, 
7447, 7448, 7449, 7450, 7451, 7452, 7453, 7454, 7455, 7456, 
7457, 7458, 7459, 7460, 7461, 7462, 7463, 7464, 7465, 7466, 
7467, 7468, 7469, 7470, 7471, 7472, 
*ELSET,ELSET=top
13009, 13010, 13011, 13012, 13013, 13014, 13015, 13016, 13017, 13018, 
13019, 13020, 13021, 13022, 13023, 13024, 13025, 13026, 13027, 13028, 
13029, 13030, 13031, 13032, 13033, 13034, 13035, 13036, 13037, 13038, 
13039, 13040, 13041, 13042, 13043, 13044, 13045, 13046, 13047, 13048, 
13049, 13050, 13051, 13052, 13053, 13054, 13055, 13056, 13057, 13058, 
13059, 13060, 13061, 13062, 13063, 13064, 13065, 13066, 13067, 13068, 
13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 
13079, 13080, 13081, 13082, 13083, 13084, 13085, 13086, 13087, 13088, 
13089, 13090, 13091, 13092, 13093, 13094, 13095, 13096, 13097, 13098, 
13099, 13100, 13101, 13102, 13103, 13104, 13105, 13106, 13107, 13108, 
13109, 13110, 13111, 13112, 13113, 13114, 13115, 13116, 13117, 13118, 
13119, 13120, 13121, 13122, 13123, 13124, 13125, 13126, 13127, 13128, 
13129, 13130, 13131, 13132, 13133, 13134, 13135, 13136, 13137, 13138, 
13139, 13140, 13141, 13142, 13143, 13144, 13145, 13146, 13147, 13148, 
13149, 13150, 13151, 13152, 13153, 13154, 13155, 13156, 13157, 13158, 
13159, 13160, 13161, 13162, 13163, 13164, 13165, 13166, 13167, 13168, 
13169, 13170, 13171, 13172, 13173, 13174, 13175, 13176, 13177, 13178, 
13179, 13180, 13181, 13182, 13183, 13184, 13185, 13186, 13187, 13188, 
13189, 13190, 13191, 13192, 13193, 13194, 13195, 13196, 13197, 13198, 
13199, 13200, 13201, 13202, 13203, 13204, 13205, 13206, 13207, 13208, 
13209, 13210, 13211, 13212, 13213, 13214, 13215, 13216, 13217, 13218, 
13219, 13220, 13221, 13222, 13223, 13224, 13225, 13226, 13227, 13228, 
13229, 13230, 13231, 13232, 13233, 13234, 13235, 13236, 13237, 13238, 
13239, 13240, 13241, 13242, 13243, 13244, 13245, 13246, 13247, 13248, 
13249, 13250, 13251, 13252, 13253, 13254, 13255, 13256, 13257, 13258, 
13259, 13260, 13261, 13262, 13263, 13264, 13265, 13266, 13267, 13268, 
13269, 13270, 13271, 13272, 13273, 13274, 13275, 13276, 13277, 13278, 
13279, 13280, 13281, 13282, 13283, 13284, 13285, 13286, 13287, 13288, 
13289, 13290, 13291, 13292, 13293, 13294, 13295, 13296, 13407, 13408, 
13409, 13410, 13411, 13412, 13413, 13414, 13415, 13416, 13417, 13418, 
13419, 13420, 13421, 13422, 13423, 13424, 13425, 13426, 13427, 13428, 
13429, 13430, 13431, 13432, 13433, 13434, 13435, 13436, 13437, 13438, 
13439, 13440, 13441, 13442, 13443, 13444, 13445, 13446, 13447, 13448, 
13449, 13450, 13451, 13452, 13453, 13454, 13455, 13456, 13457, 13458, 
13459, 13460, 13461, 13462, 13463, 13464, 13465, 13466, 13767, 13768, 
13769, 13770, 13771, 13772, 13773, 13774, 13775, 13776, 13777, 13778, 
13779, 13780, 13781, 13782, 13783, 13784, 13785, 13786, 13787, 13788, 
13789, 13790, 13791, 13792, 13793, 13794, 13795, 13796, 13797, 13798, 
13799, 13800, 13801, 13802, 13803, 13804, 13805, 13806, 13807, 13808, 
13809, 13810, 13811, 13812, 13813, 13814, 13815, 13816, 13817, 13818, 
13819, 13820, 13821, 13822, 13823, 13824, 13825, 13826, 13827, 13828, 
13829, 13830, 13831, 13832, 13833, 13834, 13835, 13836, 13837, 13838, 
13839, 13840, 13841, 13842, 13843, 13844, 13845, 13846, 13847, 13848, 
13849, 13850, 13851, 13852, 13853, 13854, 13855, 13856, 13857, 13858, 
13859, 13860, 13861, 13862, 13863, 13864, 13865, 13866, 13867, 13868, 
13869, 13870, 13871, 13872, 13873, 13874, 13875, 13876, 13877, 13878, 
13879, 13880, 13881, 13882, 13883, 13884, 13885, 13886, 13887, 13888, 
13889, 13890, 13891, 13892, 13893, 13894, 13895, 13896, 13897, 13898, 
13899, 13900, 13901, 13902, 13903, 13904, 13905, 13906, 13907, 13908, 
13909, 13910, 13911, 13912, 13913, 13914, 13915, 13916, 13917, 13918, 
13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 13927, 13928, 
13929, 13930, 13931, 13932, 13933, 13934, 13935, 13936, 13937, 13938, 
13939, 13940, 13941, 13942, 13943, 13944, 13945, 13946, 13947, 13948, 
13949, 13950, 13951, 13952, 13953, 13954, 13955, 13956, 13957, 13958, 
13959, 13960, 13961, 13962, 13963, 13964, 13965, 13966, 13967, 13968, 
13969, 13970, 13971, 13972, 13973, 13974, 13975, 13976, 13977, 13978, 
13979, 13980, 13981, 13982, 13983, 13984, 13985, 13986, 13987, 13988, 
13989, 13990, 13991, 13992, 13993, 13994, 13995, 13996, 13997, 13998, 
13999, 14000, 14001, 14002, 14003, 14004, 14005, 14006, 14007, 14008, 
14009, 14010, 14011, 14012, 14013, 14014, 14015, 14016, 14017, 14018, 
14019, 14020, 14021, 14022, 14023, 14024, 14025, 14026, 14027, 14028, 
14029, 14030, 14031, 14032, 14033, 14034, 14035, 14036, 14037, 14038, 
14039, 14040, 14041, 14042, 14043, 14044, 14045, 14046, 14047, 14048, 
14049, 14050, 14051, 14052, 14053, 14054, 
*ELSET,ELSET=bottom
14415, 14416, 14417, 14418, 14419, 14420, 14421, 14422, 14423, 14424, 
14425, 14426, 14427, 14428, 14429, 14430, 14431, 14432, 14433, 14434, 
14435, 14436, 14437, 14438, 14439, 14440, 14441, 14442, 14443, 14444, 
14445, 14446, 14447, 14448, 14449, 14450, 14451, 14452, 14453, 14454, 
14455, 14456, 14457, 14458, 14459, 14460, 14461, 14462, 14463, 14464, 
14465, 14466, 14467, 14468, 14469, 14470, 14471, 14472, 14473, 14474, 
14475, 14476, 14477, 14478, 14479, 14480, 14481, 14482, 14483, 14484, 
14485, 14486, 14487, 14488, 14489, 14490, 14491, 14492, 14493, 14494, 
14495, 14496, 14497, 14498, 14499, 14500, 14501, 14502, 14503, 14504, 
14505, 14506, 14507, 14508, 14509, 14510, 14511, 14512, 14513, 14514, 
14515, 14516, 14517, 14518, 14519, 14520, 14521, 14522, 14523, 14524, 
14525, 14526, 14527, 14528, 14529, 14530, 14531, 14532, 14533, 14534, 
14535, 14536, 14537, 14538, 14539, 14540, 14541, 14542, 14543, 14544, 
14545, 14546, 14547, 14548, 14549, 14550, 14551, 14552, 14553, 14554, 
14555, 14556, 14557, 14558, 14559, 14560, 14561, 14562, 14563, 14564, 
14565, 14566, 14567, 14568, 14569, 14570, 14571, 14572, 14573, 14574, 
14575, 14576, 14577, 14578, 14579, 14580, 14581, 14582, 14583, 14584, 
14585, 14586, 14587, 14588, 14589, 14590, 14591, 14592, 14593, 14594, 
14595, 14596, 14597, 14598, 14599, 14600, 14601, 14602, 14603, 14604, 
14605, 14606, 14607, 14608, 14609, 14610, 14611, 14612, 14613, 14614, 
14615, 14616, 14617, 14618, 14619, 14620, 14621, 14622, 14623, 14624, 
14625, 14626, 14627, 14628, 14629, 14630, 14631, 14632, 14633, 14634, 
14635, 14636, 14637, 14638, 14639, 14640, 14641, 14642, 14643, 14644, 
14645, 14646, 14647, 14648, 14649, 14650, 14651, 14652, 14653, 14654, 
14655, 14656, 14657, 14658, 14659, 14660, 14661, 14662, 14663, 14664, 
14665, 14666, 14667, 14668, 14669, 14670, 14671, 14672, 14673, 14674, 
14675, 14676, 14677, 14678, 14679, 14680, 14681, 14682, 14683, 14684, 
14685, 14686, 14687, 14688, 14689, 14690, 14691, 14692, 14693, 14694, 
14695, 14696, 14697, 14698, 14699, 14700, 14701, 14702, 14773, 14774, 
14775, 14776, 14777, 14778, 14779, 14780, 14781, 14782, 14783, 14784, 
15145, 15146, 15147, 15148, 15149, 15150, 15151, 15152, 15153, 15154, 
15155, 15156, 15157, 15158, 15159, 15160, 15161, 15162, 15163, 15164, 
15165, 15166, 15167, 15168, 15169, 15170, 15171, 15172, 15173, 15174, 
15175, 15176, 15177, 15178, 15179, 15180, 15181, 15182, 15183, 15184, 
15185, 15186, 15187, 15188, 15189, 15190, 15191, 15192, 15193, 15194, 
15195, 15196, 15197, 15198, 15199, 15200, 15201, 15202, 15203, 15204, 
15205, 15206, 15207, 15208, 15209, 15210, 15211, 15212, 15213, 15214, 
15215, 15216, 15217, 15218, 15219, 15220, 15221, 15222, 15223, 15224, 
15225, 15226, 15227, 15228, 15229, 15230, 15231, 15232, 15233, 15234, 
15235, 15236, 15237, 15238, 15239, 15240, 15241, 15242, 15243, 15244, 
15245, 15246, 15247, 15248, 15249, 15250, 15251, 15252, 15253, 15254, 
15255, 15256, 15257, 15258, 15259, 15260, 15261, 15262, 15263, 15264, 
15265, 15266, 15267, 15268, 15269, 15270, 15271, 15272, 15273, 15274, 
15275, 15276, 15277, 15278, 15279, 15280, 15281, 15282, 15283, 15284, 
15285, 15286, 15287, 15288, 15289, 15290, 15291, 15292, 15293, 15294, 
15295, 15296, 15297, 15298, 15299, 15300, 15301, 15302, 15303, 15304, 
15305, 15306, 15307, 15308, 15309, 15310, 15311, 15312, 15313, 15314, 
15315, 15316, 15317, 15318, 15319, 15320, 15321, 15322, 15323, 15324, 
15325, 15326, 15327, 15328, 15329, 15330, 15331, 15332, 15333, 15334, 
15335, 15336, 15337, 15338, 15339, 15340, 15341, 15342, 15343, 15344, 
15345, 15346, 15347, 15348, 15349, 15350, 15351, 15352, 15353, 15354, 
15355, 15356, 15357, 15358, 15359, 15360, 15361, 15362, 15363, 15364, 
15365, 15366, 15367, 15368, 15369, 15370, 15371, 15372, 15373, 15374, 
15375, 15376, 15377, 15378, 15379, 15380, 15381, 15382, 15383, 15384, 
15385, 15386, 15387, 15388, 15389, 15390, 15391, 15392, 15393, 15394, 
15395, 15396, 15397, 15398, 15399, 15400, 15401, 15402, 15403, 15404, 
15405, 15406, 15407, 15408, 15409, 15410, 15411, 15412, 15413, 15414, 
15415, 15416, 15417, 15418, 15419, 15420, 15421, 15422, 15423, 15424, 
15425, 15426, 15427, 15428, 15429, 15430, 15431, 15432, 15503, 15504, 
15505, 15506, 15507, 15508, 15509, 15510, 15511, 15512, 15513, 15514, 
*ELSET,ELSET=symmetry
2859, 2860, 2861, 2862, 2863, 2864, 2865, 2866, 2867, 2868, 
2869, 2870, 2871, 2872, 2873, 2874, 2875, 2876, 2877, 2878, 
2879, 2880, 2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 
2889, 2890, 2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 
2899, 2900, 2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 
2909, 2910, 2911, 2912, 2913, 2914, 2915, 2916, 2917, 2918, 
2919, 2920, 2921, 2922, 2923, 2924, 2925, 2926, 2927, 2928, 
2929, 2930, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 
2975, 2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 
2985, 2986, 2987, 2988, 2989, 2990, 4155, 4156, 4157, 4158, 
4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 
4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 
4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 
4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 
4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 
4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 
4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 
4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 
4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 
4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 
4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 
4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 
4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 
4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 
4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 
4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 
4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 
4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 
4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 
4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 
4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 
4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 
4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 
4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 
4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 
4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 
4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 
4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 
4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 
4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 
4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 
4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 
4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 
4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 
4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 
4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 
4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 
4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 
4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 
4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 
4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 
4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 
4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 
4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 
4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 
4639, 4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 
4649, 4650, 4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 
4659, 4660, 4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 
4669, 4670, 4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 
4679, 4680, 4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 
4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 
4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 
4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 
4719, 4720, 4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 
4729, 4730, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5775, 5776, 5777, 5778, 
5779, 5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 
5789, 5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 
5799, 5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 
5809, 5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 
5819, 5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 
5829, 5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 
5839, 5840, 5841, 5842, 5843, 5844, 5845, 5846, 6171, 6172, 
6173, 6174, 6175, 6176, 6177, 6178, 6179, 6180, 6181, 6182, 
6183, 6184, 6185, 6357, 6358, 6359, 6360, 6361, 6362, 6363, 
6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 6373, 
6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 6383, 
6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 6393, 
6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 6403, 
6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 6413, 
6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 6423, 
6424, 6425, 6426, 6427, 6428, 7113, 7114, 7115, 7116, 7117, 
7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 7127, 
7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 7473, 
7474, 7475, 7476, 7477, 7478, 7479, 7480, 7481, 7482, 7483, 
7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 
7494, 7495, 7496, 7497, 7498, 7499, 7500, 7501, 7502, 7503, 
7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512, 7513, 
7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 
7524, 7525, 7526, 7527, 7528, 7529, 7530, 7531, 7532, 7533, 
7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 
7544, 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 
7554, 7555, 7556, 7557, 7558, 7559, 7560, 7561, 7562, 7563, 
7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 
7574, 7575, 7576, 7577, 7578, 7579, 7580, 7581, 7582, 7583, 
7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592, 7593, 
7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 
7604, 7605, 7606, 7607, 7608, 7609, 7610, 7611, 7612, 7613, 
7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 
7624, 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 
7634, 7635, 7636, 7637, 7638, 7639, 7640, 7641, 7642, 7643, 
7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 
7654, 7655, 7656, 7657, 7658, 7659, 7660, 7661, 7662, 7663, 
7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672, 7673, 
7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 
7684, 7685, 7686, 7687, 7688, 7689, 7690, 7691, 7692, 7693, 
7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 
7704, 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 
7714, 7715, 7716, 7717, 7718, 7719, 7720, 7721, 7722, 7723, 
7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 
7734, 7735, 7736, 7737, 7738, 7739, 7740, 7741, 7742, 7743, 
7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752, 7753, 
7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 
7764, 7765, 7766, 7767, 7768, 7769, 7770, 7771, 7772, 7773, 
7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 
7784, 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 
7794, 7795, 7796, 7797, 7798, 7799, 7800, 7801, 7802, 7803, 
7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 
7814, 7815, 7816, 7817, 7818, 7819, 7820, 7821, 7822, 7823, 
7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832, 7833, 
7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 
7844, 7845, 7846, 7847, 7848, 7849, 7850, 7851, 7852, 7853, 
7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 
7864, 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 
7874, 7875, 7876, 7877, 7878, 7879, 7880, 7881, 7882, 7883, 
7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 
7894, 7895, 7896, 7897, 7898, 7899, 7900, 7901, 7902, 7903, 
7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912, 7913, 
7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 
7924, 7925, 7926, 7927, 7928, 7929, 7930, 7931, 7932, 7933, 
7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 
7944, 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 
7954, 7955, 7956, 7957, 7958, 7959, 7960, 7961, 7962, 7963, 
7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 
7974, 7975, 7976, 7977, 7978, 7979, 7980, 7981, 7982, 7983, 
7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992, 7993, 
7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 
8004, 8005, 8006, 8007, 8008, 8009, 8010, 8011, 8012, 8013, 
8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 
8024, 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 
8034, 8035, 8036, 8037, 8038, 8039, 8040, 8041, 8042, 8043, 
8044, 8045, 8046, 8047, 8048, 9489, 9490, 9491, 9492, 9493, 
9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 9503, 
9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 9849, 
9850, 9851, 9852, 9853, 9854, 9855, 9856, 9857, 9858, 9859, 
9860, 9861, 9862, 9863, 9864, 9865, 9866, 9867, 9868, 9869, 
9870, 9871, 9872, 9873, 9874, 9875, 9876, 9877, 9878, 9879, 
9880, 9881, 9882, 9883, 9884, 9885, 9886, 9887, 9888, 9889, 
9890, 9891, 9892, 9893, 9894, 9895, 9896, 9897, 9898, 9899, 
9900, 9901, 9902, 9903, 9904, 9905, 9906, 9907, 9908, 9909, 
9910, 9911, 9912, 9913, 9914, 9915, 9916, 9917, 9918, 9919, 
9920, 10353, 10354, 10355, 10431, 10432, 10433, 10485, 10486, 10487, 
10488, 10489, 10490, 10491, 10492, 10493, 10494, 10495, 10496, 10497, 
10498, 10499, 10500, 10501, 10502, 10503, 10504, 10505, 10506, 10507, 
10508, 10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 
10854, 10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 
10864, 10865, 10866, 10867, 10868, 12829, 12830, 12831, 12832, 12833, 
12834, 12835, 12836, 12837, 12838, 12839, 12840, 12841, 12842, 12843, 
12844, 12845, 12846, 12847, 12848, 12849, 12850, 12851, 12852, 12853, 
12854, 12855, 12856, 12857, 12858, 12859, 12860, 12861, 12862, 12863, 
12864, 12865, 12866, 12867, 12868, 12869, 12870, 12871, 12872, 12873, 
12874, 12875, 12876, 12877, 12878, 12879, 12880, 12881, 12882, 12883, 
12884, 12885, 12886, 12887, 12888, 12889, 12890, 12891, 12892, 12893, 
12894, 12895, 12896, 12897, 12898, 12899, 12900, 12901, 12902, 12903, 
12904, 12905, 12906, 12907, 12908, 12909, 12910, 12911, 12912, 12913, 
12914, 12915, 12916, 12917, 12918, 12919, 12920, 12921, 12922, 12923, 
12924, 12925, 12926, 12927, 12928, 12929, 12930, 12931, 12932, 12933, 
12934, 12935, 12936, 12937, 12938, 12939, 12940, 12941, 12942, 12943, 
12944, 12945, 12946, 12947, 12948, 13297, 13298, 13299, 13300, 13301, 
13302, 13303, 13304, 13305, 13306, 13307, 13308, 13309, 13310, 13311, 
13312, 13313, 13314, 13315, 13316, 13317, 13318, 13319, 13320, 13321, 
13467, 13468, 13469, 13470, 13471, 13472, 13473, 13474, 13475, 13476, 
13477, 13478, 13479, 13480, 13481, 13482, 13483, 13484, 13485, 13486, 
13487, 13488, 13489, 13490, 13491, 13492, 13493, 13494, 13495, 13496, 
13497, 13498, 13499, 13500, 13501, 13502, 13503, 13504, 13505, 13506, 
13507, 13508, 13509, 13510, 13511, 13512, 13513, 13514, 13515, 13516, 
13517, 13518, 13519, 13520, 13521, 13522, 13523, 13524, 13525, 13526, 
13527, 13528, 13529, 13530, 13531, 13532, 13533, 13534, 13535, 13536, 
13537, 13538, 13539, 13540, 13541, 13542, 13543, 13544, 13545, 13546, 
13547, 13548, 13549, 13550, 13551, 13552, 13553, 13554, 13555, 13556, 
13557, 13558, 13559, 13560, 13561, 13562, 13563, 13564, 13565, 13566, 
13567, 13568, 13569, 13570, 13571, 13572, 13573, 13574, 13575, 13576, 
13577, 13578, 13579, 13580, 13581, 13582, 13583, 13584, 13585, 13586, 
14235, 14236, 14237, 14238, 14239, 14240, 14241, 14242, 14243, 14244, 
14245, 14246, 14247, 14248, 14249, 14250, 14251, 14252, 14253, 14254, 
14255, 14256, 14257, 14258, 14259, 14260, 14261, 14262, 14263, 14264, 
14265, 14266, 14267, 14268, 14269, 14270, 14271, 14272, 14273, 14274, 
14275, 14276, 14277, 14278, 14279, 14280, 14281, 14282, 14283, 14284, 
14285, 14286, 14287, 14288, 14289, 14290, 14291, 14292, 14293, 14294, 
14295, 14296, 14297, 14298, 14299, 14300, 14301, 14302, 14303, 14304, 
14305, 14306, 14307, 14308, 14309, 14310, 14311, 14312, 14313, 14314, 
14315, 14316, 14317, 14318, 14319, 14320, 14321, 14322, 14323, 14324, 
14325, 14326, 14327, 14328, 14329, 14330, 14331, 14332, 14333, 14334, 
14335, 14336, 14337, 14338, 14339, 14340, 14341, 14342, 14343, 14344, 
14345, 14346, 14347, 14348, 14349, 14350, 14351, 14352, 14353, 14354, 
14703, 14704, 14705, 14706, 14707, 14785, 14786, 14787, 14788, 14789, 
14790, 14791, 14792, 14793, 14794, 14795, 14796, 14797, 14798, 14799, 
14800, 14801, 14802, 14803, 14804, 14805, 14806, 14807, 14808, 14809, 
14810, 14811, 14812, 14813, 14814, 14815, 14816, 14817, 14818, 14819, 
14820, 14821, 14822, 14823, 14824, 14825, 14826, 14827, 14828, 14829, 
14830, 14831, 14832, 14833, 14834, 14835, 14836, 14837, 14838, 14839, 
14840, 14841, 14842, 14843, 14844, 14845, 14846, 14847, 14848, 14849, 
14850, 14851, 14852, 14853, 14854, 14855, 14856, 14857, 14858, 14859, 
14860, 14861, 14862, 14863, 14864, 14865, 14866, 14867, 14868, 14869, 
14870, 14871, 14872, 14873, 14874, 14875, 14876, 14877, 14878, 14879, 
14880, 14881, 14882, 14883, 14884, 14885, 14886, 14887, 14888, 14889, 
14890, 14891, 14892, 14893, 14894, 14895, 14896, 14897, 14898, 14899, 
14900, 14901, 14902, 14903, 14904, 15433, 15434, 15435, 15436, 15437, 
*ELSET,ELSET=Ceramic_Contact
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 5883, 5884, 
5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 5893, 5894, 
5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 5903, 5904, 
5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 5913, 5914, 
5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 5923, 5924, 
5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 5933, 5934, 
5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 5943, 5944, 
5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 5953, 5954, 
5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 5963, 5964, 
5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 5973, 5974, 
5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 5983, 5984, 
5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 5993, 5994, 
5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 6003, 6004, 
6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 6013, 6014, 
6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 6023, 6024, 
6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 6033, 6034, 
6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 6043, 6044, 
6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 6053, 6054, 
6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 6063, 6064, 
6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 6073, 6074, 
6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 6083, 6084, 
6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 6093, 6094, 
6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 6103, 6104, 
6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 6113, 6114, 
6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 6123, 6124, 
6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 6133, 6134, 
6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 6143, 6144, 
6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 6153, 6154, 
6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 6163, 6164, 
6165, 6166, 6167, 6168, 6169, 6170, 6789, 6790, 6791, 6792, 
6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 
6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 
6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 
6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 6831, 6832, 
6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 6841, 6842, 
6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 6851, 6852, 
6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 6861, 6862, 
6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 6871, 6872, 
6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 6881, 6882, 
6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 6891, 6892, 
6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 6901, 6902, 
6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 6911, 6912, 
6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 6921, 6922, 
6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 6931, 6932, 
6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 6941, 6942, 
6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 6951, 6952, 
6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 6961, 6962, 
6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 6971, 6972, 
6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 6981, 6982, 
6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 6991, 6992, 
6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 7001, 7002, 
7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 7011, 7012, 
7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 7021, 7022, 
7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 7031, 7032, 
7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 7041, 7042, 
7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 7051, 7052, 
7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 7061, 7062, 
7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 7071, 7072, 
7073, 7074, 7075, 7076, 10065, 10066, 10067, 10068, 10069, 10070, 
10071, 10072, 10073, 10074, 10075, 10076, 10077, 10078, 10079, 10080, 
10081, 10082, 10083, 10084, 10085, 10086, 10087, 10088, 10089, 10090, 
10091, 10092, 10093, 10094, 10095, 10096, 10097, 10098, 10099, 10100, 
10101, 10102, 10103, 10104, 10105, 10106, 10107, 10108, 10109, 10110, 
10111, 10112, 10113, 10114, 10115, 10116, 10117, 10118, 10119, 10120, 
10121, 10122, 10123, 10124, 10125, 10126, 10127, 10128, 10129, 10130, 
10131, 10132, 10133, 10134, 10135, 10136, 10137, 10138, 10139, 10140, 
10141, 10142, 10143, 10144, 10145, 10146, 10147, 10148, 10149, 10150, 
10151, 10152, 10153, 10154, 10155, 10156, 10157, 10158, 10159, 10160, 
10161, 10162, 10163, 10164, 10165, 10166, 10167, 10168, 10169, 10170, 
10171, 10172, 10173, 10174, 10175, 10176, 10177, 10178, 10179, 10180, 
10181, 10182, 10183, 10184, 10185, 10186, 10187, 10188, 10189, 10190, 
10191, 10192, 10193, 10194, 10195, 10196, 10197, 10198, 10199, 10200, 
10201, 10202, 10203, 10204, 10205, 10206, 10207, 10208, 10209, 10210, 
10211, 10212, 10213, 10214, 10215, 10216, 10217, 10218, 10219, 10220, 
10221, 10222, 10223, 10224, 10225, 10226, 10227, 10228, 10229, 10230, 
10231, 10232, 10233, 10234, 10235, 10236, 10237, 10238, 10239, 10240, 
10241, 10242, 10243, 10244, 10245, 10246, 10247, 10248, 10249, 10250, 
10251, 10252, 10253, 10254, 10255, 10256, 10257, 10258, 10259, 10260, 
10261, 10262, 10263, 10264, 10265, 10266, 10267, 10268, 10269, 10270, 
10271, 10272, 10273, 10274, 10275, 10276, 10277, 10278, 10279, 10280, 
10281, 10282, 10283, 10284, 10285, 10286, 10287, 10288, 10289, 10290, 
10291, 10292, 10293, 10294, 10295, 10296, 10297, 10298, 10299, 10300, 
10301, 10302, 10303, 10304, 10305, 10306, 10307, 10308, 10309, 10310, 
10311, 10312, 10313, 10314, 10315, 10316, 10317, 10318, 10319, 10320, 
10321, 10322, 10323, 10324, 10325, 10326, 10327, 10328, 10329, 10330, 
10331, 10332, 10333, 10334, 10335, 10336, 10337, 10338, 10339, 10340, 
10341, 10342, 10343, 10344, 10345, 10346, 10347, 10348, 10349, 10350, 
10351, 10352, 10371, 10372, 10373, 10374, 10375, 10376, 10377, 10378, 
10379, 10380, 10381, 10382, 10419, 10420, 10421, 10422, 10423, 10424, 
10425, 10426, 10427, 10428, 10429, 10430, 
*ELSET,ELSET=Contact_CeramicTop
5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 5891, 5892, 
5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 5901, 5902, 
5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 5911, 5912, 
5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 5921, 5922, 
5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 5931, 5932, 
5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 5941, 5942, 
5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 5951, 5952, 
5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 5961, 5962, 
5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 5971, 5972, 
5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 5981, 5982, 
5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 5991, 5992, 
5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 6001, 6002, 
6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 6011, 6012, 
6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 6021, 6022, 
6023, 6024, 6025, 6026, 6027, 6028, 6029, 6030, 6031, 6032, 
6033, 6034, 6035, 6036, 6037, 6038, 6039, 6040, 6041, 6042, 
6043, 6044, 6045, 6046, 6047, 6048, 6049, 6050, 6051, 6052, 
6053, 6054, 6055, 6056, 6057, 6058, 6059, 6060, 6061, 6062, 
6063, 6064, 6065, 6066, 6067, 6068, 6069, 6070, 6071, 6072, 
6073, 6074, 6075, 6076, 6077, 6078, 6079, 6080, 6081, 6082, 
6083, 6084, 6085, 6086, 6087, 6088, 6089, 6090, 6091, 6092, 
6093, 6094, 6095, 6096, 6097, 6098, 6099, 6100, 6101, 6102, 
6103, 6104, 6105, 6106, 6107, 6108, 6109, 6110, 6111, 6112, 
6113, 6114, 6115, 6116, 6117, 6118, 6119, 6120, 6121, 6122, 
6123, 6124, 6125, 6126, 6127, 6128, 6129, 6130, 6131, 6132, 
6133, 6134, 6135, 6136, 6137, 6138, 6139, 6140, 6141, 6142, 
6143, 6144, 6145, 6146, 6147, 6148, 6149, 6150, 6151, 6152, 
6153, 6154, 6155, 6156, 6157, 6158, 6159, 6160, 6161, 6162, 
6163, 6164, 6165, 6166, 6167, 6168, 6169, 6170, 6261, 6262, 
6263, 6264, 6265, 6266, 6267, 6268, 6269, 6270, 6271, 6272, 
6273, 6274, 6275, 6276, 6277, 6278, 6279, 6280, 6281, 6282, 
6283, 6284, 6285, 6286, 6287, 6288, 6289, 6290, 6291, 6292, 
6293, 6294, 6295, 6296, 6297, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6789, 6790, 
6791, 6792, 6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 
6801, 6802, 6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 
6811, 6812, 6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 
6821, 6822, 6823, 6824, 6825, 6826, 6827, 6828, 6829, 6830, 
6831, 6832, 6833, 6834, 6835, 6836, 6837, 6838, 6839, 6840, 
6841, 6842, 6843, 6844, 6845, 6846, 6847, 6848, 6849, 6850, 
6851, 6852, 6853, 6854, 6855, 6856, 6857, 6858, 6859, 6860, 
6861, 6862, 6863, 6864, 6865, 6866, 6867, 6868, 6869, 6870, 
6871, 6872, 6873, 6874, 6875, 6876, 6877, 6878, 6879, 6880, 
6881, 6882, 6883, 6884, 6885, 6886, 6887, 6888, 6889, 6890, 
6891, 6892, 6893, 6894, 6895, 6896, 6897, 6898, 6899, 6900, 
6901, 6902, 6903, 6904, 6905, 6906, 6907, 6908, 6909, 6910, 
6911, 6912, 6913, 6914, 6915, 6916, 6917, 6918, 6919, 6920, 
6921, 6922, 6923, 6924, 6925, 6926, 6927, 6928, 6929, 6930, 
6931, 6932, 6933, 6934, 6935, 6936, 6937, 6938, 6939, 6940, 
6941, 6942, 6943, 6944, 6945, 6946, 6947, 6948, 6949, 6950, 
6951, 6952, 6953, 6954, 6955, 6956, 6957, 6958, 6959, 6960, 
6961, 6962, 6963, 6964, 6965, 6966, 6967, 6968, 6969, 6970, 
6971, 6972, 6973, 6974, 6975, 6976, 6977, 6978, 6979, 6980, 
6981, 6982, 6983, 6984, 6985, 6986, 6987, 6988, 6989, 6990, 
6991, 6992, 6993, 6994, 6995, 6996, 6997, 6998, 6999, 7000, 
7001, 7002, 7003, 7004, 7005, 7006, 7007, 7008, 7009, 7010, 
7011, 7012, 7013, 7014, 7015, 7016, 7017, 7018, 7019, 7020, 
7021, 7022, 7023, 7024, 7025, 7026, 7027, 7028, 7029, 7030, 
7031, 7032, 7033, 7034, 7035, 7036, 7037, 7038, 7039, 7040, 
7041, 7042, 7043, 7044, 7045, 7046, 7047, 7048, 7049, 7050, 
7051, 7052, 7053, 7054, 7055, 7056, 7057, 7058, 7059, 7060, 
7061, 7062, 7063, 7064, 7065, 7066, 7067, 7068, 7069, 7070, 
7071, 7072, 7073, 7074, 7075, 7076, 
*ELSET,ELSET=Contact_CeramicBottom
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 10065, 10066, 
10067, 10068, 10069, 10070, 10071, 10072, 10073, 10074, 10075, 10076, 
10077, 10078, 10079, 10080, 10081, 10082, 10083, 10084, 10085, 10086, 
10087, 10088, 10089, 10090, 10091, 10092, 10093, 10094, 10095, 10096, 
10097, 10098, 10099, 10100, 10101, 10102, 10103, 10104, 10105, 10106, 
10107, 10108, 10109, 10110, 10111, 10112, 10113, 10114, 10115, 10116, 
10117, 10118, 10119, 10120, 10121, 10122, 10123, 10124, 10125, 10126, 
10127, 10128, 10129, 10130, 10131, 10132, 10133, 10134, 10135, 10136, 
10137, 10138, 10139, 10140, 10141, 10142, 10143, 10144, 10145, 10146, 
10147, 10148, 10149, 10150, 10151, 10152, 10153, 10154, 10155, 10156, 
10157, 10158, 10159, 10160, 10161, 10162, 10163, 10164, 10165, 10166, 
10167, 10168, 10169, 10170, 10171, 10172, 10173, 10174, 10175, 10176, 
10177, 10178, 10179, 10180, 10181, 10182, 10183, 10184, 10185, 10186, 
10187, 10188, 10189, 10190, 10191, 10192, 10193, 10194, 10195, 10196, 
10197, 10198, 10199, 10200, 10201, 10202, 10203, 10204, 10205, 10206, 
10207, 10208, 10209, 10210, 10211, 10212, 10213, 10214, 10215, 10216, 
10217, 10218, 10219, 10220, 10221, 10222, 10223, 10224, 10225, 10226, 
10227, 10228, 10229, 10230, 10231, 10232, 10233, 10234, 10235, 10236, 
10237, 10238, 10239, 10240, 10241, 10242, 10243, 10244, 10245, 10246, 
10247, 10248, 10249, 10250, 10251, 10252, 10253, 10254, 10255, 10256, 
10257, 10258, 10259, 10260, 10261, 10262, 10263, 10264, 10265, 10266, 
10267, 10268, 10269, 10270, 10271, 10272, 10273, 10274, 10275, 10276, 
10277, 10278, 10279, 10280, 10281, 10282, 10283, 10284, 10285, 10286, 
10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 
10297, 10298, 10299, 10300, 10301, 10302, 10303, 10304, 10305, 10306, 
10307, 10308, 10309, 10310, 10311, 10312, 10313, 10314, 10315, 10316, 
10317, 10318, 10319, 10320, 10321, 10322, 10323, 10324, 10325, 10326, 
10327, 10328, 10329, 10330, 10331, 10332, 10333, 10334, 10335, 10336, 
10337, 10338, 10339, 10340, 10341, 10342, 10343, 10344, 10345, 10346, 
10347, 10348, 10349, 10350, 10351, 10352, 10371, 10372, 10373, 10374, 
10375, 10376, 10377, 10378, 10379, 10380, 10381, 10382, 10419, 10420, 
10421, 10422, 10423, 10424, 10425, 10426, 10427, 10428, 10429, 10430, 
*ELSET,ELSET=Copper
15515, 15516, 15517, 15518, 15519, 15520, 15521, 15522, 15523, 15524, 
15525, 15526, 15527, 15528, 15529, 15530, 15531, 15532, 15533, 15534, 
15535, 15536, 15537, 15538, 15539, 15540, 15541, 15542, 15543, 15544, 
15545, 15546, 15547, 15548, 15549, 15550, 15551, 15552, 15553, 15554, 
15555, 15556, 15557, 15558, 15559, 15560, 15561, 15562, 15563, 15564, 
15565, 15566, 15567, 15568, 15569, 15570, 15571, 15572, 15573, 15574, 
15575, 15576, 15577, 15578, 15579, 15580, 15581, 15582, 15583, 15584, 
15585, 15586, 15587, 15588, 15589, 15590, 15591, 15592, 15593, 15594, 
15595, 15596, 15597, 15598, 15599, 15600, 15601, 15602, 15603, 15604, 
15605, 15606, 15607, 15608, 15609, 15610, 15611, 15612, 15613, 15614, 
15615, 15616, 15617, 15618, 15619, 15620, 15621, 15622, 15623, 15624, 
15625, 15626, 15627, 15628, 15629, 15630, 15631, 15632, 15633, 15634, 
15635, 15636, 15637, 15638, 15639, 15640, 15641, 15642, 15643, 15644, 
15645, 15646, 15647, 15648, 15649, 15650, 15651, 15652, 15653, 15654, 
15655, 15656, 15657, 15658, 15659, 15660, 15661, 15662, 15663, 15664, 
15665, 15666, 15667, 15668, 15669, 15670, 15671, 15672, 15673, 15674, 
15675, 15676, 15677, 15678, 15679, 15680, 15681, 15682, 15683, 15684, 
15685, 15686, 15687, 15688, 15689, 15690, 15691, 15692, 15693, 15694, 
15695, 15696, 15697, 15698, 15699, 15700, 15701, 15702, 15703, 15704, 
15705, 15706, 15707, 15708, 15709, 15710, 15711, 15712, 15713, 15714, 
15715, 15716, 15717, 15718, 15719, 15720, 15721, 15722, 15723, 15724, 
15725, 15726, 15727, 15728, 15729, 15730, 15731, 15732, 15733, 15734, 
15735, 15736, 15737, 15738, 15739, 15740, 15741, 15742, 15743, 15744, 
15745, 15746, 15747, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 
15755, 15756, 15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 
15765, 15766, 15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 
15775, 15776, 15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 
15785, 15786, 15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 
15795, 15796, 15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 
15805, 15806, 15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 
15815, 15816, 15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 
15825, 15826, 15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 
15835, 15836, 15837, 15838, 15839, 15840, 15841, 15842, 15843, 15844, 
15845, 15846, 15847, 15848, 15849, 15850, 15851, 15852, 15853, 15854, 
15855, 15856, 15857, 15858, 15859, 15860, 15861, 15862, 15863, 15864, 
15865, 15866, 15867, 15868, 15869, 15870, 15871, 15872, 15873, 15874, 
15875, 15876, 15877, 15878, 15879, 15880, 15881, 15882, 15883, 15884, 
15885, 15886, 15887, 15888, 15889, 15890, 15891, 15892, 15893, 15894, 
15895, 15896, 15897, 15898, 15899, 15900, 15901, 15902, 15903, 15904, 
15905, 15906, 15907, 15908, 15909, 15910, 15911, 15912, 15913, 15914, 
15915, 15916, 15917, 15918, 15919, 15920, 15921, 15922, 15923, 15924, 
15925, 15926, 15927, 15928, 15929, 15930, 15931, 15932, 15933, 15934, 
15935, 15936, 15937, 15938, 15939, 15940, 15941, 15942, 15943, 15944, 
15945, 15946, 15947, 15948, 15949, 15950, 15951, 15952, 15953, 15954, 
15955, 15956, 15957, 15958, 15959, 15960, 15961, 15962, 15963, 15964, 
15965, 15966, 15967, 15968, 15969, 15970, 15971, 15972, 15973, 15974, 
15975, 15976, 15977, 15978, 15979, 15980, 15981, 15982, 15983, 15984, 
15985, 15986, 15987, 15988, 15989, 15990, 15991, 15992, 15993, 15994, 
15995, 15996, 15997, 15998, 15999, 16000, 16001, 16002, 16003, 16004, 
16005, 16006, 16007, 16008, 16009, 16010, 16011, 16012, 16013, 16014, 
16015, 16016, 16017, 16018, 16019, 16020, 16021, 16022, 16023, 16024, 
16025, 16026, 16027, 16028, 16029, 16030, 16031, 16032, 16033, 16034, 
16035, 16036, 16037, 16038, 16039, 16040, 16041, 16042, 16043, 16044, 
16045, 16046, 16047, 16048, 16049, 16050, 16051, 16052, 16053, 16054, 
16055, 16056, 16057, 16058, 16059, 16060, 16061, 16062, 16063, 16064, 
16065, 16066, 16067, 16068, 16069, 16070, 16071, 16072, 16073, 16074, 
16075, 16076, 16077, 16078, 16079, 16080, 16081, 16082, 16083, 16084, 
16085, 16086, 16087, 16088, 16089, 16090, 16091, 16092, 16093, 16094, 
16095, 16096, 16097, 16098, 16099, 16100, 16101, 16102, 16103, 16104, 
16105, 16106, 16107, 16108, 16109, 16110, 16111, 16112, 16113, 16114, 
16115, 16116, 16117, 16118, 16119, 16120, 16121, 16122, 16123, 16124, 
16125, 16126, 16127, 16128, 16129, 16130, 16131, 16132, 16133, 16134, 
16135, 16136, 16137, 16138, 16139, 16140, 16141, 16142, 16143, 16144, 
16145, 16146, 16147, 16148, 16149, 16150, 16151, 16152, 16153, 16154, 
16155, 16156, 16157, 16158, 16159, 16160, 16161, 16162, 16163, 16164, 
16165, 16166, 16167, 16168, 16169, 16170, 16171, 16172, 16173, 16174, 
16175, 16176, 16177, 16178, 16179, 16180, 16181, 16182, 16183, 16184, 
16185, 16186, 16187, 16188, 16189, 16190, 16191, 16192, 16193, 16194, 
16195, 16196, 16197, 16198, 16199, 16200, 16201, 16202, 16203, 16204, 
16205, 16206, 16207, 16208, 16209, 16210, 16211, 16212, 16213, 16214, 
16215, 16216, 16217, 16218, 16219, 16220, 16221, 16222, 16223, 16224, 
16225, 16226, 16227, 16228, 16229, 16230, 16231, 16232, 16233, 16234, 
16235, 16236, 16237, 16238, 16239, 16240, 16241, 16242, 16243, 16244, 
16245, 16246, 16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 
16255, 16256, 16257, 16258, 16259, 16260, 16261, 16262, 16263, 16264, 
16265, 16266, 16267, 16268, 16269, 16270, 16271, 16272, 16273, 16274, 
16275, 16276, 16277, 16278, 16279, 16280, 16281, 16282, 16283, 16284, 
16285, 16286, 16287, 16288, 16289, 16290, 16291, 16292, 16293, 16294, 
16295, 16296, 16297, 16298, 16299, 16300, 16301, 16302, 16303, 16304, 
16305, 16306, 16307, 16308, 16309, 16310, 16311, 16312, 16313, 16314, 
16315, 16316, 16317, 16318, 16319, 16320, 16321, 16322, 16323, 16324, 
16325, 16326, 16327, 16328, 16329, 16330, 16331, 16332, 16333, 16334, 
16335, 16336, 16337, 16338, 16339, 16340, 16341, 16342, 16343, 16344, 
16345, 16346, 16347, 16348, 16349, 16350, 16351, 16352, 16353, 16354, 
16355, 16356, 16357, 16358, 16359, 16360, 16361, 16362, 16363, 16364, 
16365, 16366, 16367, 16368, 16369, 16370, 16371, 16372, 16373, 16374, 
16375, 16376, 16377, 16378, 23867, 23868, 23869, 23870, 23871, 23872, 
23873, 23874, 23875, 23876, 23877, 23878, 23879, 23880, 23881, 23882, 
23883, 23884, 23885, 23886, 23887, 23888, 23889, 23890, 23891, 23892, 
23893, 23894, 23895, 23896, 23897, 23898, 23899, 23900, 23901, 23902, 
23903, 23904, 23905, 23906, 23907, 23908, 23909, 23910, 23911, 23912, 
23913, 23914, 23915, 23916, 23917, 23918, 23919, 23920, 23921, 23922, 
23923, 23924, 23925, 23926, 23927, 23928, 23929, 23930, 23931, 23932, 
23933, 23934, 23935, 23936, 23937, 23938, 23939, 23940, 23941, 23942, 
23943, 23944, 23945, 23946, 23947, 23948, 23949, 23950, 23951, 23952, 
23953, 23954, 23955, 23956, 23957, 23958, 23959, 23960, 23961, 23962, 
23963, 23964, 23965, 23966, 23967, 23968, 23969, 23970, 23971, 23972, 
23973, 23974, 23975, 23976, 23977, 23978, 23979, 23980, 23981, 23982, 
23983, 23984, 23985, 23986, 23987, 23988, 23989, 23990, 23991, 23992, 
23993, 23994, 23995, 23996, 23997, 23998, 23999, 24000, 24001, 24002, 
24003, 24004, 24005, 24006, 24007, 24008, 24009, 24010, 24011, 24012, 
24013, 24014, 24015, 24016, 24017, 24018, 24019, 24020, 24021, 24022, 
24023, 24024, 24025, 24026, 24027, 24028, 24029, 24030, 24031, 24032, 
24033, 24034, 24035, 24036, 24037, 24038, 24039, 24040, 24041, 24042, 
24043, 24044, 24045, 24046, 24047, 24048, 24049, 24050, 24051, 24052, 
24053, 24054, 24055, 24056, 24057, 24058, 24059, 24060, 24061, 24062, 
24063, 24064, 24065, 24066, 24067, 24068, 24069, 24070, 24071, 24072, 
24073, 24074, 24075, 24076, 24077, 24078, 24079, 24080, 24081, 24082, 
24083, 24084, 24085, 24086, 24087, 24088, 24089, 24090, 24091, 24092, 
24093, 24094, 24095, 24096, 24097, 24098, 24099, 24100, 24101, 24102, 
24103, 24104, 24105, 24106, 24107, 24108, 24109, 24110, 24111, 24112, 
24113, 24114, 24115, 24116, 24117, 24118, 24119, 24120, 24121, 24122, 
24123, 24124, 24125, 24126, 24127, 24128, 24129, 24130, 24131, 24132, 
24133, 24134, 24135, 24136, 24137, 24138, 24139, 24140, 24141, 24142, 
24143, 24144, 24145, 24146, 24147, 24148, 24149, 24150, 24151, 24152, 
24153, 24154, 24155, 24156, 24157, 24158, 24159, 24160, 24161, 24162, 
24163, 24164, 24165, 24166, 24167, 24168, 24169, 24170, 24171, 24172, 
24173, 24174, 24175, 24176, 24177, 24178, 24179, 24180, 24181, 24182, 
24183, 24184, 24185, 24186, 24187, 24188, 24189, 24190, 24191, 24192, 
24193, 24194, 24195, 24196, 24197, 24198, 24199, 24200, 24201, 24202, 
24203, 24204, 24205, 24206, 24207, 24208, 24209, 24210, 24211, 24212, 
24213, 24214, 24215, 24216, 24217, 24218, 24219, 24220, 24221, 24222, 
24223, 24224, 24225, 24226, 24227, 24228, 24229, 24230, 24231, 24232, 
24233, 24234, 24235, 24236, 24237, 24238, 24239, 24240, 24241, 24242, 
24243, 24244, 24245, 24246, 24247, 24248, 24249, 24250, 24251, 24252, 
24253, 24254, 24255, 24256, 24257, 24258, 24259, 24260, 24261, 24262, 
24263, 24264, 24265, 24266, 24267, 24268, 24269, 24270, 24271, 24272, 
24273, 24274, 24275, 24276, 24277, 24278, 24279, 24280, 24281, 24282, 
24283, 24284, 24285, 24286, 24287, 24288, 24289, 24290, 24291, 24292, 
24293, 24294, 24295, 24296, 24297, 24298, 24299, 24300, 24301, 24302, 
24303, 24304, 24305, 24306, 24307, 24308, 24309, 24310, 24311, 24312, 
24313, 24314, 24315, 24316, 24317, 24318, 24319, 24320, 24321, 24322, 
24323, 24324, 24325, 24326, 24327, 24328, 24329, 24330, 24331, 24332, 
24333, 24334, 24335, 24336, 24337, 24338, 24339, 24340, 24341, 24342, 
24343, 24344, 24345, 24346, 24347, 24348, 24349, 24350, 24351, 24352, 
24353, 24354, 24355, 24356, 24357, 24358, 24359, 24360, 24361, 24362, 
24363, 24364, 24365, 24366, 24367, 24368, 24369, 24370, 24371, 24372, 
24373, 24374, 24375, 24376, 24377, 24378, 24379, 24380, 24381, 24382, 
24383, 24384, 24385, 24386, 24387, 24388, 24389, 24390, 24391, 24392, 
24393, 24394, 24395, 24396, 24397, 24398, 24399, 24400, 24401, 24402, 
24403, 24404, 24405, 24406, 24407, 24408, 24409, 24410, 24411, 24412, 
24413, 24414, 24415, 24416, 24417, 24418, 24419, 24420, 24421, 24422, 
24423, 24424, 24425, 24426, 24427, 24428, 24429, 24430, 24431, 24432, 
24433, 24434, 24435, 24436, 24437, 24438, 24439, 24440, 24441, 24442, 
24443, 24444, 24445, 24446, 24447, 24448, 24449, 24450, 24451, 24452, 
24453, 24454, 24455, 24456, 24457, 24458, 24459, 24460, 24461, 24462, 
24463, 24464, 24465, 24466, 24467, 24468, 24469, 24470, 24471, 24472, 
24473, 24474, 24475, 24476, 24477, 24478, 24479, 24480, 24481, 24482, 
24483, 24484, 24485, 24486, 24487, 24488, 24489, 24490, 24491, 24492, 
24493, 24494, 24495, 24496, 24497, 24498, 24499, 24500, 24501, 24502, 
24503, 24504, 24505, 24506, 24507, 24508, 24509, 24510, 24511, 24512, 
24513, 24514, 24515, 24516, 24517, 24518, 24519, 24520, 24521, 24522, 
24523, 24524, 24525, 24526, 24527, 24528, 24529, 24530, 24531, 24532, 
24533, 24534, 24535, 24536, 24537, 24538, 24539, 24540, 24541, 24542, 
24543, 24544, 24545, 24546, 24547, 24548, 24549, 24550, 24551, 24552, 
24553, 24554, 24555, 24556, 24557, 24558, 24559, 24560, 24561, 24562, 
24563, 24564, 24565, 24566, 24567, 24568, 24569, 24570, 24571, 24572, 
24573, 24574, 24575, 24576, 24577, 24578, 24579, 24580, 24581, 24582, 
24583, 24584, 24585, 24586, 24587, 24588, 24589, 24590, 24591, 24592, 
24593, 24594, 24595, 24596, 24597, 24598, 24599, 24600, 24601, 24602, 
24603, 24604, 24605, 24606, 24607, 24608, 24609, 24610, 24611, 24612, 
24613, 24614, 24615, 24616, 24617, 24618, 24619, 24620, 24621, 24622, 
24623, 24624, 24625, 24626, 24627, 24628, 24629, 24630, 24631, 24632, 
24633, 24634, 24635, 24636, 24637, 24638, 24639, 24640, 24641, 24642, 
24643, 24644, 24645, 24646, 24647, 24648, 24649, 24650, 24651, 24652, 
24653, 24654, 24655, 24656, 24657, 24658, 24659, 24660, 24661, 24662, 
24663, 24664, 24665, 24666, 24667, 24668, 24669, 24670, 24671, 24672, 
24673, 24674, 24675, 24676, 24677, 24678, 24679, 24680, 24681, 24682, 
24683, 24684, 24685, 24686, 24687, 24688, 24689, 24690, 24691, 24692, 
24693, 24694, 24695, 24696, 24697, 24698, 24699, 24700, 24701, 24702, 
24703, 24704, 24705, 24706, 24707, 24708, 24709, 24710, 24711, 24712, 
24713, 24714, 24715, 24716, 24717, 24718, 24719, 24720, 24721, 24722, 
24723, 24724, 24725, 24726, 24727, 24728, 24729, 24730, 24731, 24732, 
24733, 24734, 24735, 24736, 24737, 24738, 24739, 24740, 24741, 24742, 
24743, 24744, 24745, 24746, 24747, 24748, 24749, 24750, 24751, 24752, 
24753, 24754, 24755, 24756, 24757, 24758, 24759, 24760, 24761, 24762, 
24763, 24764, 24765, 24766, 24767, 24768, 24769, 24770, 24771, 24772, 
24773, 24774, 24775, 24776, 24777, 24778, 24779, 24780, 24781, 24782, 
24783, 24784, 24785, 24786, 24787, 24788, 24789, 24790, 24791, 24792, 
24793, 24794, 24795, 24796, 24797, 24798, 24799, 24800, 24801, 24802, 
24803, 24804, 24805, 24806, 24807, 24808, 24809, 24810, 24811, 24812, 
24813, 24814, 24815, 24816, 24817, 24818, 24819, 24820, 24821, 24822, 
24823, 24824, 24825, 24826, 24827, 24828, 24829, 24830, 24831, 24832, 
24833, 24834, 24835, 24836, 24837, 24838, 24839, 24840, 24841, 24842, 
24843, 24844, 24845, 24846, 24847, 24848, 24849, 24850, 24851, 24852, 
24853, 24854, 24855, 24856, 24857, 24858, 24859, 24860, 24861, 24862, 
24863, 24864, 24865, 24866, 24867, 24868, 24869, 24870, 24871, 24872, 
24873, 24874, 24875, 24876, 24877, 24878, 24879, 24880, 24881, 24882, 
24883, 24884, 24885, 24886, 24887, 24888, 24889, 24890, 24891, 24892, 
24893, 24894, 24895, 24896, 24897, 24898, 24899, 24900, 24901, 24902, 
24903, 24904, 24905, 24906, 24907, 24908, 24909, 24910, 24911, 24912, 
24913, 24914, 24915, 24916, 24917, 24918, 24919, 24920, 24921, 24922, 
24923, 24924, 24925, 24926, 24927, 24928, 24929, 24930, 24931, 24932, 
24933, 24934, 24935, 24936, 24937, 24938, 24939, 24940, 24941, 24942, 
24943, 24944, 24945, 24946, 24947, 24948, 24949, 24950, 24951, 24952, 
24953, 24954, 24955, 24956, 24957, 24958, 24959, 24960, 24961, 24962, 
24963, 24964, 24965, 24966, 24967, 24968, 24969, 24970, 24971, 24972, 
24973, 24974, 24975, 24976, 24977, 24978, 24979, 24980, 24981, 24982, 
24983, 24984, 24985, 24986, 24987, 24988, 24989, 24990, 24991, 24992, 
24993, 24994, 24995, 24996, 24997, 24998, 24999, 25000, 25001, 25002, 
25003, 25004, 25005, 25006, 25007, 25008, 25009, 25010, 25011, 25012, 
25013, 25014, 25015, 25016, 25017, 25018, 25019, 25020, 25021, 25022, 
25023, 25024, 25025, 25026, 25027, 25028, 25029, 25030, 25031, 25032, 
25033, 25034, 25035, 25036, 25037, 25038, 25039, 25040, 25041, 25042, 
25043, 25044, 25045, 25046, 25047, 25048, 25049, 25050, 25051, 25052, 
25053, 25054, 25055, 25056, 25057, 25058, 25059, 25060, 25061, 25062, 
25063, 25064, 25065, 25066, 25067, 25068, 25069, 25070, 25071, 25072, 
25073, 25074, 25075, 25076, 25077, 25078, 25079, 25080, 25081, 25082, 
25083, 25084, 25085, 25086, 25087, 25088, 25089, 25090, 25091, 25092, 
25093, 25094, 25095, 25096, 25097, 25098, 25099, 25100, 25101, 25102, 
25103, 25104, 25105, 25106, 25107, 25108, 25109, 25110, 25111, 25112, 
25113, 25114, 25115, 25116, 25117, 25118, 25119, 25120, 25121, 25122, 
25123, 25124, 25125, 25126, 25127, 25128, 25129, 25130, 25131, 25132, 
25133, 25134, 25135, 25136, 25137, 25138, 25139, 25140, 25141, 25142, 
25143, 25144, 25145, 25146, 25147, 25148, 25149, 25150, 25151, 25152, 
25153, 25154, 25155, 25156, 25157, 25158, 25159, 25160, 25161, 25162, 
25163, 25164, 25165, 25166, 25167, 25168, 25169, 25170, 25171, 25172, 
25173, 25174, 25175, 25176, 25177, 25178, 25179, 25180, 25181, 25182, 
25183, 25184, 25185, 25186, 25187, 25188, 25189, 25190, 25191, 25192, 
25193, 25194, 25195, 25196, 25197, 25198, 25199, 25200, 25201, 25202, 
25203, 25204, 25205, 25206, 25207, 25208, 25209, 25210, 25211, 25212, 
25213, 25214, 25215, 25216, 25217, 25218, 25219, 25220, 25221, 25222, 
25223, 25224, 25225, 25226, 25227, 25228, 25229, 25230, 25231, 25232, 
25233, 25234, 25235, 25236, 25237, 25238, 25239, 25240, 25241, 25242, 
25243, 25244, 25245, 25246, 25247, 25248, 25249, 25250, 25251, 25252, 
25253, 25254, 25255, 25256, 25257, 25258, 25259, 25260, 25261, 25262, 
25263, 25264, 25265, 25266, 25267, 25268, 25269, 25270, 25271, 25272, 
25273, 25274, 25275, 25276, 25277, 25278, 25279, 25280, 25281, 25282, 
25283, 25284, 25285, 25286, 25287, 25288, 25289, 25290, 25291, 25292, 
25293, 25294, 25295, 25296, 25297, 25298, 25299, 25300, 25301, 25302, 
25303, 25304, 25305, 25306, 25307, 25308, 25309, 25310, 25311, 25312, 
25313, 25314, 25315, 25316, 25317, 25318, 25319, 25320, 25321, 25322, 
25323, 25324, 25325, 25326, 25327, 25328, 25329, 25330, 25331, 25332, 
25333, 25334, 25335, 25336, 25337, 25338, 25339, 25340, 25341, 25342, 
25343, 25344, 25345, 25346, 25347, 25348, 25349, 25350, 25351, 25352, 
25353, 25354, 25355, 25356, 25357, 25358, 25359, 25360, 25361, 25362, 
25363, 25364, 25365, 25366, 25367, 25368, 25369, 25370, 25371, 25372, 
25373, 25374, 25375, 25376, 25377, 25378, 25379, 25380, 25381, 25382, 
25383, 25384, 25385, 25386, 25387, 25388, 25389, 25390, 25391, 25392, 
25393, 25394, 25395, 25396, 25397, 25398, 25399, 25400, 25401, 25402, 
25403, 25404, 25405, 25406, 25407, 25408, 25409, 25410, 25411, 25412, 
25413, 25414, 25415, 25416, 25417, 25418, 25419, 25420, 25421, 25422, 
25423, 25424, 25425, 25426, 25427, 25428, 25429, 25430, 25431, 25432, 
25433, 25434, 25435, 25436, 25437, 25438, 25439, 25440, 25441, 25442, 
25443, 25444, 25445, 25446, 25447, 25448, 25449, 25450, 25451, 25452, 
25453, 25454, 25455, 25456, 25457, 25458, 25459, 25460, 25461, 25462, 
25463, 25464, 25465, 25466, 25467, 25468, 25469, 25470, 25471, 25472, 
25473, 25474, 25475, 25476, 25477, 25478, 25479, 25480, 25481, 25482, 
25483, 25484, 25485, 25486, 25487, 25488, 25489, 25490, 25491, 25492, 
25493, 25494, 25495, 25496, 25497, 25498, 25499, 25500, 25501, 25502, 
25503, 25504, 25505, 25506, 25507, 25508, 25509, 25510, 25511, 25512, 
25513, 25514, 25515, 25516, 25517, 25518, 25519, 25520, 25521, 25522, 
25523, 25524, 25525, 25526, 25527, 25528, 25529, 25530, 25531, 25532, 
25533, 25534, 25535, 25536, 25537, 25538, 25539, 25540, 25541, 25542, 
25543, 25544, 25545, 25546, 25547, 25548, 25549, 25550, 25551, 25552, 
25553, 25554, 25555, 25556, 25557, 25558, 25559, 25560, 25561, 25562, 
25563, 25564, 25565, 25566, 25567, 25568, 25569, 25570, 25571, 25572, 
25573, 25574, 25575, 25576, 25577, 25578, 25579, 25580, 25581, 25582, 
25583, 25584, 25585, 25586, 25587, 25588, 25589, 25590, 25591, 25592, 
25593, 25594, 25595, 25596, 25597, 25598, 25599, 25600, 25601, 25602, 
25603, 25604, 25605, 25606, 25607, 25608, 25609, 25610, 25611, 25612, 
25613, 25614, 25615, 25616, 25617, 25618, 25619, 25620, 25621, 25622, 
25623, 25624, 25625, 25626, 25627, 25628, 25629, 25630, 25631, 25632, 
25633, 25634, 25635, 25636, 25637, 25638, 25639, 25640, 25641, 25642, 
25643, 25644, 25645, 25646, 25647, 25648, 25649, 25650, 25651, 25652, 
25653, 25654, 25655, 25656, 25657, 25658, 25659, 25660, 25661, 25662, 
25663, 25664, 25665, 25666, 25667, 25668, 25669, 25670, 25671, 25672, 
25673, 25674, 25675, 25676, 25677, 25678, 25679, 25680, 25681, 25682, 
25683, 25684, 25685, 25686, 25687, 25688, 25689, 25690, 25691, 25692, 
25693, 25694, 25695, 25696, 25697, 25698, 25699, 25700, 25701, 25702, 
25703, 25704, 25705, 25706, 25707, 25708, 25709, 25710, 25711, 25712, 
25713, 25714, 25715, 25716, 25717, 25718, 25719, 25720, 25721, 25722, 
25723, 25724, 25725, 25726, 25727, 25728, 25729, 25730, 25731, 25732, 
25733, 25734, 25735, 25736, 25737, 25738, 25739, 25740, 25741, 25742, 
25743, 25744, 25745, 25746, 25747, 25748, 25749, 25750, 25751, 25752, 
25753, 25754, 25755, 25756, 25757, 25758, 25759, 25760, 25761, 25762, 
25763, 25764, 25765, 25766, 25767, 25768, 25769, 25770, 25771, 25772, 
25773, 25774, 33263, 33264, 33265, 33266, 33267, 33268, 33269, 33270, 
33271, 33272, 33273, 33274, 33275, 33276, 33277, 33278, 33279, 33280, 
33281, 33282, 33283, 33284, 33285, 33286, 33287, 33288, 33289, 33290, 
33291, 33292, 33293, 33294, 33295, 33296, 33297, 33298, 33299, 33300, 
33301, 33302, 33303, 33304, 33305, 33306, 33307, 33308, 33309, 33310, 
33311, 33312, 33313, 33314, 33315, 33316, 33317, 33318, 33319, 33320, 
33321, 33322, 33323, 33324, 33325, 33326, 33327, 33328, 33329, 33330, 
33331, 33332, 33333, 33334, 33335, 33336, 33337, 33338, 33339, 33340, 
33341, 33342, 33343, 33344, 33345, 33346, 33347, 33348, 33349, 33350, 
33351, 33352, 33353, 33354, 33355, 33356, 33357, 33358, 33359, 33360, 
33361, 33362, 33363, 33364, 33365, 33366, 33367, 33368, 33369, 33370, 
33371, 33372, 33373, 33374, 33375, 33376, 33377, 33378, 33379, 33380, 
33381, 33382, 33383, 33384, 33385, 33386, 33387, 33388, 33389, 33390, 
33391, 33392, 33393, 33394, 33395, 33396, 33397, 33398, 33399, 33400, 
33401, 33402, 33403, 33404, 33405, 33406, 33407, 33408, 33409, 33410, 
33411, 33412, 33413, 33414, 33415, 33416, 33417, 33418, 33419, 33420, 
33421, 33422, 33423, 33424, 33425, 33426, 33427, 33428, 33429, 33430, 
33431, 33432, 33433, 33434, 33435, 33436, 33437, 33438, 33439, 33440, 
33441, 33442, 33443, 33444, 33445, 33446, 33447, 33448, 33449, 33450, 
33451, 33452, 33453, 33454, 33455, 33456, 33457, 33458, 33459, 33460, 
33461, 33462, 33463, 33464, 33465, 33466, 33467, 33468, 33469, 33470, 
33471, 33472, 33473, 33474, 33475, 33476, 33477, 33478, 33479, 33480, 
33481, 33482, 33483, 33484, 33485, 33486, 33487, 33488, 33489, 33490, 
33491, 33492, 33493, 33494, 33495, 33496, 33497, 33498, 33499, 33500, 
33501, 33502, 33503, 33504, 33505, 33506, 33507, 33508, 33509, 33510, 
33511, 33512, 33513, 33514, 33515, 33516, 33517, 33518, 33519, 33520, 
33521, 33522, 33523, 33524, 33525, 33526, 33527, 33528, 33529, 33530, 
33531, 33532, 33533, 33534, 33535, 33536, 33537, 33538, 33539, 33540, 
33541, 33542, 33543, 33544, 33545, 33546, 33547, 33548, 33549, 33550, 
33551, 33552, 33553, 33554, 33555, 33556, 33557, 33558, 33559, 33560, 
33561, 33562, 33563, 33564, 33565, 33566, 33567, 33568, 33569, 33570, 
33571, 33572, 33573, 33574, 33575, 33576, 33577, 33578, 33579, 33580, 
33581, 33582, 33583, 33584, 33585, 33586, 33587, 33588, 33589, 33590, 
33591, 33592, 33593, 33594, 33595, 33596, 33597, 33598, 33599, 33600, 
33601, 33602, 33603, 33604, 33605, 33606, 33607, 33608, 33609, 33610, 
33611, 33612, 33613, 33614, 33615, 33616, 33617, 33618, 33619, 33620, 
33621, 33622, 33623, 33624, 33625, 33626, 33627, 33628, 33629, 33630, 
33631, 33632, 33633, 33634, 33635, 33636, 33637, 33638, 33639, 33640, 
33641, 33642, 33643, 33644, 33645, 33646, 33647, 33648, 33649, 33650, 
33651, 33652, 33653, 33654, 33655, 33656, 33657, 33658, 33659, 33660, 
33661, 33662, 33663, 33664, 33665, 33666, 33667, 33668, 33669, 33670, 
33671, 33672, 33673, 33674, 33675, 33676, 33677, 33678, 33679, 33680, 
33681, 33682, 33683, 33684, 33685, 33686, 33687, 33688, 33689, 33690, 
33691, 33692, 33693, 33694, 33695, 33696, 33697, 33698, 33699, 33700, 
33701, 33702, 33703, 33704, 33705, 33706, 33707, 33708, 33709, 33710, 
33711, 33712, 33713, 33714, 33715, 33716, 33717, 33718, 33719, 33720, 
33721, 33722, 33723, 33724, 33725, 33726, 33727, 33728, 33729, 33730, 
33731, 33732, 33733, 33734, 33735, 33736, 33737, 33738, 33739, 33740, 
33741, 33742, 33743, 33744, 33745, 33746, 33747, 33748, 33749, 33750, 
33751, 33752, 33753, 33754, 33755, 33756, 33757, 33758, 33759, 33760, 
33761, 33762, 33763, 33764, 33765, 33766, 33767, 33768, 33769, 33770, 
33771, 33772, 33773, 33774, 33775, 33776, 33777, 33778, 33779, 33780, 
33781, 33782, 33783, 33784, 33785, 33786, 33787, 33788, 33789, 33790, 
33791, 33792, 33793, 33794, 33795, 33796, 33797, 33798, 33799, 33800, 
33801, 33802, 33803, 33804, 33805, 33806, 33807, 33808, 33809, 33810, 
33811, 33812, 33813, 33814, 33815, 33816, 33817, 33818, 33819, 33820, 
33821, 33822, 33823, 33824, 33825, 33826, 33827, 33828, 33829, 33830, 
33831, 33832, 33833, 33834, 33835, 33836, 33837, 33838, 33839, 33840, 
33841, 33842, 33843, 33844, 33845, 33846, 33847, 33848, 33849, 33850, 
33851, 33852, 33853, 33854, 33855, 33856, 33857, 33858, 33859, 33860, 
33861, 33862, 33863, 33864, 33865, 33866, 33867, 33868, 33869, 33870, 
33871, 33872, 33873, 33874, 33875, 33876, 33877, 33878, 33879, 33880, 
33881, 33882, 33883, 33884, 33885, 33886, 33887, 33888, 33889, 33890, 
33891, 33892, 33893, 33894, 33895, 33896, 33897, 33898, 33899, 33900, 
33901, 33902, 33903, 33904, 33905, 33906, 33907, 33908, 33909, 33910, 
33911, 33912, 33913, 33914, 33915, 33916, 33917, 33918, 33919, 33920, 
33921, 33922, 33923, 33924, 33925, 33926, 33927, 33928, 33929, 33930, 
33931, 33932, 33933, 33934, 33935, 33936, 33937, 33938, 33939, 33940, 
33941, 33942, 33943, 33944, 33945, 33946, 33947, 33948, 33949, 33950, 
33951, 33952, 33953, 33954, 33955, 33956, 33957, 33958, 33959, 33960, 
33961, 33962, 33963, 33964, 33965, 33966, 33967, 33968, 33969, 33970, 
33971, 33972, 33973, 33974, 33975, 33976, 33977, 33978, 33979, 33980, 
33981, 33982, 33983, 33984, 33985, 33986, 33987, 33988, 33989, 33990, 
33991, 33992, 33993, 33994, 33995, 33996, 33997, 33998, 33999, 34000, 
34001, 34002, 34003, 34004, 34005, 34006, 34007, 34008, 34009, 34010, 
34011, 34012, 34013, 34014, 34015, 34016, 34017, 34018, 34019, 34020, 
34021, 34022, 34023, 34024, 34025, 34026, 34027, 34028, 34029, 34030, 
34031, 34032, 34033, 34034, 34035, 34036, 34037, 34038, 34039, 34040, 
34041, 34042, 34043, 34044, 34045, 34046, 34047, 34048, 34049, 34050, 
34051, 34052, 34053, 34054, 34055, 34056, 34057, 34058, 34059, 34060, 
34061, 34062, 34063, 34064, 34065, 34066, 34067, 34068, 34069, 34070, 
34071, 34072, 34073, 34074, 34075, 34076, 34077, 34078, 34079, 34080, 
34081, 34082, 34083, 34084, 34085, 34086, 34087, 34088, 34089, 34090, 
34091, 34092, 34093, 34094, 34095, 34096, 34097, 34098, 34099, 34100, 
34101, 34102, 34103, 34104, 34105, 34106, 34107, 34108, 34109, 34110, 
34111, 34112, 34113, 34114, 34115, 34116, 34117, 34118, 34119, 34120, 
34121, 34122, 34123, 34124, 34125, 34126, 34127, 34128, 34129, 34130, 
34131, 34132, 34133, 34134, 34135, 34136, 34137, 34138, 34139, 34140, 
34141, 34142, 34143, 34144, 34145, 34146, 34147, 34148, 34149, 34150, 
34151, 34152, 34153, 34154, 34155, 34156, 34157, 34158, 34159, 34160, 
34161, 34162, 34163, 34164, 34165, 34166, 34167, 34168, 34169, 34170, 
34171, 34172, 34173, 34174, 34175, 34176, 34177, 34178, 34179, 34180, 
34181, 34182, 34183, 34184, 34185, 34186, 34187, 34188, 34189, 34190, 
34191, 34192, 34193, 34194, 34195, 34196, 34197, 34198, 
*ELSET,ELSET=SemiconductorN-
16667, 16668, 16669, 16670, 16671, 16672, 16673, 16674, 16675, 16676, 
16677, 16678, 16679, 16680, 16681, 16682, 16683, 16684, 16685, 16686, 
16687, 16688, 16689, 16690, 16691, 16692, 16693, 16694, 16695, 16696, 
16697, 16698, 16699, 16700, 16701, 16702, 16703, 16704, 16705, 16706, 
16707, 16708, 16709, 16710, 16711, 16712, 16713, 16714, 16715, 16716, 
16717, 16718, 16719, 16720, 16721, 16722, 16723, 16724, 16725, 16726, 
16727, 16728, 16729, 16730, 16731, 16732, 16733, 16734, 16735, 16736, 
16737, 16738, 16739, 16740, 16741, 16742, 16743, 16744, 16745, 16746, 
16747, 16748, 16749, 16750, 16751, 16752, 16753, 16754, 16755, 16756, 
16757, 16758, 16759, 16760, 16761, 16762, 16763, 16764, 16765, 16766, 
16767, 16768, 16769, 16770, 16771, 16772, 16773, 16774, 16775, 16776, 
16777, 16778, 16779, 16780, 16781, 16782, 16783, 16784, 16785, 16786, 
16787, 16788, 16789, 16790, 16791, 16792, 16793, 16794, 16795, 16796, 
16797, 16798, 16799, 16800, 16801, 16802, 16803, 16804, 16805, 16806, 
16807, 16808, 16809, 16810, 16811, 16812, 16813, 16814, 16815, 16816, 
16817, 16818, 16819, 16820, 16821, 16822, 16823, 16824, 16825, 16826, 
16827, 16828, 16829, 16830, 16831, 16832, 16833, 16834, 16835, 16836, 
16837, 16838, 16839, 16840, 16841, 16842, 16843, 16844, 16845, 16846, 
16847, 16848, 16849, 16850, 16851, 16852, 16853, 16854, 16855, 16856, 
16857, 16858, 16859, 16860, 16861, 16862, 16863, 16864, 16865, 16866, 
16867, 16868, 16869, 16870, 16871, 16872, 16873, 16874, 16875, 16876, 
16877, 16878, 16879, 16880, 16881, 16882, 16883, 16884, 16885, 16886, 
16887, 16888, 16889, 16890, 16891, 16892, 16893, 16894, 16895, 16896, 
16897, 16898, 16899, 16900, 16901, 16902, 16903, 16904, 16905, 16906, 
16907, 16908, 16909, 16910, 16911, 16912, 16913, 16914, 16915, 16916, 
16917, 16918, 16919, 16920, 16921, 16922, 16923, 16924, 16925, 16926, 
16927, 16928, 16929, 16930, 16931, 16932, 16933, 16934, 16935, 16936, 
16937, 16938, 16939, 16940, 16941, 16942, 16943, 16944, 16945, 16946, 
16947, 16948, 16949, 16950, 16951, 16952, 16953, 16954, 16955, 16956, 
16957, 16958, 16959, 16960, 16961, 16962, 16963, 16964, 16965, 16966, 
16967, 16968, 16969, 16970, 16971, 16972, 16973, 16974, 16975, 16976, 
16977, 16978, 16979, 16980, 16981, 16982, 16983, 16984, 16985, 16986, 
16987, 16988, 16989, 16990, 16991, 16992, 16993, 16994, 16995, 16996, 
16997, 16998, 16999, 17000, 17001, 17002, 17003, 17004, 17005, 17006, 
17007, 17008, 17009, 17010, 17011, 17012, 17013, 17014, 17015, 17016, 
17017, 17018, 17019, 17020, 17021, 17022, 17023, 17024, 17025, 17026, 
17027, 17028, 17029, 17030, 17031, 17032, 17033, 17034, 17035, 17036, 
17037, 17038, 17039, 17040, 17041, 17042, 17043, 17044, 17045, 17046, 
17047, 17048, 17049, 17050, 17051, 17052, 17053, 17054, 17055, 17056, 
17057, 17058, 17059, 17060, 17061, 17062, 17063, 17064, 17065, 17066, 
17067, 17068, 17069, 17070, 17071, 17072, 17073, 17074, 17075, 17076, 
17077, 17078, 17079, 17080, 17081, 17082, 17083, 17084, 17085, 17086, 
17087, 17088, 17089, 17090, 17091, 17092, 17093, 17094, 17095, 17096, 
