14876, 12128, 12129, 12133, 12132
14877, 12129, 12130, 12134, 12133
14878, 12130, 12131, 12135, 12134
14879, 12131, 1867, 1868, 12135
14880, 1091, 12132, 12136, 1092
14881, 12132, 12133, 12137, 12136
14882, 12133, 12134, 12138, 12137
14883, 12134, 12135, 12139, 12138
14884, 12135, 1868, 1869, 12139
14885, 1092, 12136, 12140, 1093
14886, 12136, 12137, 12141, 12140
14887, 12137, 12138, 12142, 12141
14888, 12138, 12139, 12143, 12142
14889, 12139, 1869, 1870, 12143
14890, 1093, 12140, 12144, 1094
14891, 12140, 12141, 12145, 12144
14892, 12141, 12142, 12146, 12145
14893, 12142, 12143, 12147, 12146
14894, 12143, 1870, 1871, 12147
14895, 1094, 12144, 12148, 1095
14896, 12144, 12145, 12149, 12148
14897, 12145, 12146, 12150, 12149
14898, 12146, 12147, 12151, 12150
14899, 12147, 1871, 1872, 12151
14900, 1095, 12148, 1846, 46
14901, 12148, 12149, 1847, 1846
14902, 12149, 12150, 1848, 1847
14903, 12150, 12151, 1849, 1848
14904, 12151, 1872, 92, 1849
*ELEMENT, type=CPS4, ELSET=Surface128
14905, 47, 1100, 12152, 1873
14906, 1873, 12152, 12153, 1874
14907, 1874, 12153, 12154, 1875
14908, 1875, 12154, 12155, 1876
14909, 1876, 12155, 1881, 93
14910, 1100, 1101, 12156, 12152
14911, 12152, 12156, 12157, 12153
14912, 12153, 12157, 12158, 12154
14913, 12154, 12158, 12159, 12155
14914, 12155, 12159, 1882, 1881
14915, 1101, 1102, 12160, 12156
14916, 12156, 12160, 12161, 12157
14917, 12157, 12161, 12162, 12158
14918, 12158, 12162, 12163, 12159
14919, 12159, 12163, 1883, 1882
14920, 1102, 1103, 12164, 12160
14921, 12160, 12164, 12165, 12161
14922, 12161, 12165, 12166, 12162
14923, 12162, 12166, 12167, 12163
14924, 12163, 12167, 1884, 1883
14925, 1103, 1104, 12168, 12164
14926, 12164, 12168, 12169, 12165
14927, 12165, 12169, 12170, 12166
14928, 12166, 12170, 12171, 12167
14929, 12167, 12171, 1885, 1884
14930, 1104, 1105, 12172, 12168
14931, 12168, 12172, 12173, 12169
14932, 12169, 12173, 12174, 12170
14933, 12170, 12174, 12175, 12171
14934, 12171, 12175, 1886, 1885
14935, 1105, 1106, 12176, 12172
14936, 12172, 12176, 12177, 12173
14937, 12173, 12177, 12178, 12174
14938, 12174, 12178, 12179, 12175
14939, 12175, 12179, 1887, 1886
14940, 1106, 1107, 12180, 12176
14941, 12176, 12180, 12181, 12177
14942, 12177, 12181, 12182, 12178
14943, 12178, 12182, 12183, 12179
14944, 12179, 12183, 1888, 1887
14945, 1107, 1108, 12184, 12180
14946, 12180, 12184, 12185, 12181
14947, 12181, 12185, 12186, 12182
14948, 12182, 12186, 12187, 12183
14949, 12183, 12187, 1889, 1888
14950, 1108, 1109, 12188, 12184
14951, 12184, 12188, 12189, 12185
14952, 12185, 12189, 12190, 12186
14953, 12186, 12190, 12191, 12187
14954, 12187, 12191, 1890, 1889
14955, 1109, 1110, 12192, 12188
14956, 12188, 12192, 12193, 12189
14957, 12189, 12193, 12194, 12190
14958, 12190, 12194, 12195, 12191
14959, 12191, 12195, 1891, 1890
14960, 1110, 1111, 12196, 12192
14961, 12192, 12196, 12197, 12193
14962, 12193, 12197, 12198, 12194
14963, 12194, 12198, 12199, 12195
14964, 12195, 12199, 1892, 1891
14965, 1111, 1112, 12200, 12196
14966, 12196, 12200, 12201, 12197
14967, 12197, 12201, 12202, 12198
14968, 12198, 12202, 12203, 12199
14969, 12199, 12203, 1893, 1892
14970, 1112, 1113, 12204, 12200
14971, 12200, 12204, 12205, 12201
14972, 12201, 12205, 12206, 12202
14973, 12202, 12206, 12207, 12203
14974, 12203, 12207, 1894, 1893
14975, 1113, 1114, 12208, 12204
14976, 12204, 12208, 12209, 12205
14977, 12205, 12209, 12210, 12206
14978, 12206, 12210, 12211, 12207
14979, 12207, 12211, 1895, 1894
14980, 1114, 1115, 12212, 12208
14981, 12208, 12212, 12213, 12209
14982, 12209, 12213, 12214, 12210
14983, 12210, 12214, 12215, 12211
14984, 12211, 12215, 1896, 1895
14985, 1115, 1116, 12216, 12212
14986, 12212, 12216, 12217, 12213
14987, 12213, 12217, 12218, 12214
14988, 12214, 12218, 12219, 12215
14989, 12215, 12219, 1897, 1896
14990, 1116, 1117, 12220, 12216
14991, 12216, 12220, 12221, 12217
14992, 12217, 12221, 12222, 12218
14993, 12218, 12222, 12223, 12219
14994, 12219, 12223, 1898, 1897
14995, 1117, 1118, 12224, 12220
14996, 12220, 12224, 12225, 12221
14997, 12221, 12225, 12226, 12222
14998, 12222, 12226, 12227, 12223
14999, 12223, 12227, 1899, 1898
15000, 1118, 1119, 12228, 12224
15001, 12224, 12228, 12229, 12225
15002, 12225, 12229, 12230, 12226
15003, 12226, 12230, 12231, 12227
15004, 12227, 12231, 1900, 1899
15005, 1119, 1120, 12232, 12228
15006, 12228, 12232, 12233, 12229
15007, 12229, 12233, 12234, 12230
15008, 12230, 12234, 12235, 12231
15009, 12231, 12235, 1901, 1900
15010, 1120, 1121, 12236, 12232
15011, 12232, 12236, 12237, 12233
15012, 12233, 12237, 12238, 12234
15013, 12234, 12238, 12239, 12235
15014, 12235, 12239, 1902, 1901
15015, 1121, 1122, 12240, 12236
15016, 12236, 12240, 12241, 12237
15017, 12237, 12241, 12242, 12238
15018, 12238, 12242, 12243, 12239
15019, 12239, 12243, 1903, 1902
15020, 1122, 48, 1877, 12240
15021, 12240, 1877, 1878, 12241
15022, 12241, 1878, 1879, 12242
15023, 12242, 1879, 1880, 12243
15024, 12243, 1880, 94, 1903
*ELEMENT, type=CPS4, ELSET=Surface129
15025, 47, 1873, 12244, 1123
15026, 1873, 1874, 12245, 12244
15027, 1874, 1875, 12246, 12245
15028, 1875, 1876, 12247, 12246
15029, 1876, 93, 1904, 12247
15030, 1123, 12244, 12248, 1124
15031, 12244, 12245, 12249, 12248
15032, 12245, 12246, 12250, 12249
15033, 12246, 12247, 12251, 12250
15034, 12247, 1904, 1905, 12251
15035, 1124, 12248, 12252, 1125
15036, 12248, 12249, 12253, 12252
15037, 12249, 12250, 12254, 12253
15038, 12250, 12251, 12255, 12254
15039, 12251, 1905, 1906, 12255
15040, 1125, 12252, 12256, 1126
15041, 12252, 12253, 12257, 12256
15042, 12253, 12254, 12258, 12257
15043, 12254, 12255, 12259, 12258
15044, 12255, 1906, 1907, 12259
15045, 1126, 12256, 12260, 1127
15046, 12256, 12257, 12261, 12260
15047, 12257, 12258, 12262, 12261
15048, 12258, 12259, 12263, 12262
15049, 12259, 1907, 1908, 12263
15050, 1127, 12260, 12264, 1128
15051, 12260, 12261, 12265, 12264
15052, 12261, 12262, 12266, 12265
15053, 12262, 12263, 12267, 12266
15054, 12263, 1908, 1909, 12267
15055, 1128, 12264, 12268, 1129
15056, 12264, 12265, 12269, 12268
15057, 12265, 12266, 12270, 12269
15058, 12266, 12267, 12271, 12270
15059, 12267, 1909, 1910, 12271
15060, 1129, 12268, 12272, 1130
15061, 12268, 12269, 12273, 12272
15062, 12269, 12270, 12274, 12273
15063, 12270, 12271, 12275, 12274
15064, 12271, 1910, 1911, 12275
15065, 1130, 12272, 12276, 1131
15066, 12272, 12273, 12277, 12276
15067, 12273, 12274, 12278, 12277
15068, 12274, 12275, 12279, 12278
15069, 12275, 1911, 1912, 12279
15070, 1131, 12276, 12280, 1132
15071, 12276, 12277, 12281, 12280
15072, 12277, 12278, 12282, 12281
15073, 12278, 12279, 12283, 12282
15074, 12279, 1912, 1913, 12283
15075, 1132, 12280, 12284, 1133
15076, 12280, 12281, 12285, 12284
15077, 12281, 12282, 12286, 12285
15078, 12282, 12283, 12287, 12286
15079, 12283, 1913, 1914, 12287
15080, 1133, 12284, 1842, 45
15081, 12284, 12285, 1843, 1842
15082, 12285, 12286, 1844, 1843
15083, 12286, 12287, 1845, 1844
15084, 12287, 1914, 91, 1845
*ELEMENT, type=CPS4, ELSET=Surface130
15085, 48, 1134, 12288, 1877
15086, 1877, 12288, 12289, 1878
15087, 1878, 12289, 12290, 1879
15088, 1879, 12290, 12291, 1880
15089, 1880, 12291, 1915, 94
15090, 1134, 1135, 12292, 12288
15091, 12288, 12292, 12293, 12289
15092, 12289, 12293, 12294, 12290
15093, 12290, 12294, 12295, 12291
15094, 12291, 12295, 1916, 1915
15095, 1135, 1136, 12296, 12292
15096, 12292, 12296, 12297, 12293
15097, 12293, 12297, 12298, 12294
15098, 12294, 12298, 12299, 12295
15099, 12295, 12299, 1917, 1916
15100, 1136, 1137, 12300, 12296
15101, 12296, 12300, 12301, 12297
15102, 12297, 12301, 12302, 12298
15103, 12298, 12302, 12303, 12299
15104, 12299, 12303, 1918, 1917
15105, 1137, 1138, 12304, 12300
15106, 12300, 12304, 12305, 12301
15107, 12301, 12305, 12306, 12302
15108, 12302, 12306, 12307, 12303
15109, 12303, 12307, 1919, 1918
15110, 1138, 1139, 12308, 12304
15111, 12304, 12308, 12309, 12305
15112, 12305, 12309, 12310, 12306
15113, 12306, 12310, 12311, 12307
15114, 12307, 12311, 1920, 1919
15115, 1139, 1140, 12312, 12308
15116, 12308, 12312, 12313, 12309
15117, 12309, 12313, 12314, 12310
15118, 12310, 12314, 12315, 12311
15119, 12311, 12315, 1921, 1920
15120, 1140, 1141, 12316, 12312
15121, 12312, 12316, 12317, 12313
15122, 12313, 12317, 12318, 12314
15123, 12314, 12318, 12319, 12315
15124, 12315, 12319, 1922, 1921
15125, 1141, 1142, 12320, 12316
15126, 12316, 12320, 12321, 12317
15127, 12317, 12321, 12322, 12318
15128, 12318, 12322, 12323, 12319
15129, 12319, 12323, 1923, 1922
15130, 1142, 1143, 12324, 12320
15131, 12320, 12324, 12325, 12321
15132, 12321, 12325, 12326, 12322
15133, 12322, 12326, 12327, 12323
15134, 12323, 12327, 1924, 1923
15135, 1143, 1144, 12328, 12324
15136, 12324, 12328, 12329, 12325
15137, 12325, 12329, 12330, 12326
15138, 12326, 12330, 12331, 12327
15139, 12327, 12331, 1925, 1924
15140, 1144, 46, 1846, 12328
15141, 12328, 1846, 1847, 12329
15142, 12329, 1847, 1848, 12330
15143, 12330, 1848, 1849, 12331
15144, 12331, 1849, 92, 1925
*ELEMENT, type=CPS4, ELSET=Surface131
15145, 93, 1881, 12332, 1904
15146, 1881, 1882, 12333, 12332
15147, 1882, 1883, 12334, 12333
15148, 1883, 1884, 12335, 12334
15149, 1884, 1885, 12336, 12335
15150, 1885, 1886, 12337, 12336
15151, 1886, 1887, 12338, 12337
15152, 1887, 1888, 12339, 12338
15153, 1888, 1889, 12340, 12339
15154, 1889, 1890, 12341, 12340
15155, 1890, 1891, 12342, 12341
15156, 1891, 1892, 12343, 12342
15157, 1892, 1893, 12344, 12343
15158, 1893, 1894, 12345, 12344
15159, 1894, 1895, 12346, 12345
15160, 1895, 1896, 12347, 12346
15161, 1896, 1897, 12348, 12347
15162, 1897, 1898, 12349, 12348
15163, 1898, 1899, 12350, 12349
15164, 1899, 1900, 12351, 12350
15165, 1900, 1901, 12352, 12351
15166, 1901, 1902, 12353, 12352
15167, 1902, 1903, 12354, 12353
15168, 1903, 94, 1915, 12354
15169, 1904, 12332, 12355, 1905
15170, 12332, 12333, 12356, 12355
15171, 12333, 12334, 12357, 12356
15172, 12334, 12335, 12358, 12357
15173, 12335, 12336, 12359, 12358
15174, 12336, 12337, 12360, 12359
15175, 12337, 12338, 12361, 12360
15176, 12338, 12339, 12362, 12361
15177, 12339, 12340, 12363, 12362
15178, 12340, 12341, 12364, 12363
15179, 12341, 12342, 12365, 12364
15180, 12342, 12343, 12366, 12365
15181, 12343, 12344, 12367, 12366
15182, 12344, 12345, 12368, 12367
15183, 12345, 12346, 12369, 12368
15184, 12346, 12347, 12370, 12369
15185, 12347, 12348, 12371, 12370
15186, 12348, 12349, 12372, 12371
15187, 12349, 12350, 12373, 12372
15188, 12350, 12351, 12374, 12373
15189, 12351, 12352, 12375, 12374
15190, 12352, 12353, 12376, 12375
15191, 12353, 12354, 12377, 12376
15192, 12354, 1915, 1916, 12377
15193, 1905, 12355, 12378, 1906
15194, 12355, 12356, 12379, 12378
15195, 12356, 12357, 12380, 12379
15196, 12357, 12358, 12381, 12380
15197, 12358, 12359, 12382, 12381
15198, 12359, 12360, 12383, 12382
15199, 12360, 12361, 12384, 12383
15200, 12361, 12362, 12385, 12384
15201, 12362, 12363, 12386, 12385
15202, 12363, 12364, 12387, 12386
15203, 12364, 12365, 12388, 12387
15204, 12365, 12366, 12389, 12388
15205, 12366, 12367, 12390, 12389
15206, 12367, 12368, 12391, 12390
15207, 12368, 12369, 12392, 12391
15208, 12369, 12370, 12393, 12392
15209, 12370, 12371, 12394, 12393
15210, 12371, 12372, 12395, 12394
15211, 12372, 12373, 12396, 12395
15212, 12373, 12374, 12397, 12396
15213, 12374, 12375, 12398, 12397
15214, 12375, 12376, 12399, 12398
15215, 12376, 12377, 12400, 12399
15216, 12377, 1916, 1917, 12400
15217, 1906, 12378, 12401, 1907
15218, 12378, 12379, 12402, 12401
15219, 12379, 12380, 12403, 12402
15220, 12380, 12381, 12404, 12403
15221, 12381, 12382, 12405, 12404
15222, 12382, 12383, 12406, 12405
15223, 12383, 12384, 12407, 12406
15224, 12384, 12385, 12408, 12407
15225, 12385, 12386, 12409, 12408
15226, 12386, 12387, 12410, 12409
15227, 12387, 12388, 12411, 12410
15228, 12388, 12389, 12412, 12411
15229, 12389, 12390, 12413, 12412
15230, 12390, 12391, 12414, 12413
15231, 12391, 12392, 12415, 12414
15232, 12392, 12393, 12416, 12415
15233, 12393, 12394, 12417, 12416
15234, 12394, 12395, 12418, 12417
15235, 12395, 12396, 12419, 12418
15236, 12396, 12397, 12420, 12419
15237, 12397, 12398, 12421, 12420
15238, 12398, 12399, 12422, 12421
15239, 12399, 12400, 12423, 12422
15240, 12400, 1917, 1918, 12423
15241, 1907, 12401, 12424, 1908
15242, 12401, 12402, 12425, 12424
15243, 12402, 12403, 12426, 12425
15244, 12403, 12404, 12427, 12426
15245, 12404, 12405, 12428, 12427
15246, 12405, 12406, 12429, 12428
15247, 12406, 12407, 12430, 12429
15248, 12407, 12408, 12431, 12430
15249, 12408, 12409, 12432, 12431
15250, 12409, 12410, 12433, 12432
15251, 12410, 12411, 12434, 12433
15252, 12411, 12412, 12435, 12434
15253, 12412, 12413, 12436, 12435
15254, 12413, 12414, 12437, 12436
15255, 12414, 12415, 12438, 12437
15256, 12415, 12416, 12439, 12438
15257, 12416, 12417, 12440, 12439
15258, 12417, 12418, 12441, 12440
15259, 12418, 12419, 12442, 12441
15260, 12419, 12420, 12443, 12442
15261, 12420, 12421, 12444, 12443
15262, 12421, 12422, 12445, 12444
15263, 12422, 12423, 12446, 12445
15264, 12423, 1918, 1919, 12446
15265, 1908, 12424, 12447, 1909
15266, 12424, 12425, 12448, 12447
15267, 12425, 12426, 12449, 12448
15268, 12426, 12427, 12450, 12449
15269, 12427, 12428, 12451, 12450
15270, 12428, 12429, 12452, 12451
15271, 12429, 12430, 12453, 12452
15272, 12430, 12431, 12454, 12453
15273, 12431, 12432, 12455, 12454
15274, 12432, 12433, 12456, 12455
15275, 12433, 12434, 12457, 12456
15276, 12434, 12435, 12458, 12457
15277, 12435, 12436, 12459, 12458
15278, 12436, 12437, 12460, 12459
15279, 12437, 12438, 12461, 12460
15280, 12438, 12439, 12462, 12461
15281, 12439, 12440, 12463, 12462
15282, 12440, 12441, 12464, 12463
15283, 12441, 12442, 12465, 12464
15284, 12442, 12443, 12466, 12465
15285, 12443, 12444, 12467, 12466
15286, 12444, 12445, 12468, 12467
15287, 12445, 12446, 12469, 12468
15288, 12446, 1919, 1920, 12469
15289, 1909, 12447, 12470, 1910
15290, 12447, 12448, 12471, 12470
15291, 12448, 12449, 12472, 12471
15292, 12449, 12450, 12473, 12472
15293, 12450, 12451, 12474, 12473
15294, 12451, 12452, 12475, 12474
15295, 12452, 12453, 12476, 12475
15296, 12453, 12454, 12477, 12476
15297, 12454, 12455, 12478, 12477
15298, 12455, 12456, 12479, 12478
15299, 12456, 12457, 12480, 12479
15300, 12457, 12458, 12481, 12480
15301, 12458, 12459, 12482, 12481
15302, 12459, 12460, 12483, 12482
15303, 12460, 12461, 12484, 12483
15304, 12461, 12462, 12485, 12484
15305, 12462, 12463, 12486, 12485
15306, 12463, 12464, 12487, 12486
15307, 12464, 12465, 12488, 12487
15308, 12465, 12466, 12489, 12488
15309, 12466, 12467, 12490, 12489
15310, 12467, 12468, 12491, 12490
15311, 12468, 12469, 12492, 12491
15312, 12469, 1920, 1921, 12492
15313, 1910, 12470, 12493, 1911
15314, 12470, 12471, 12494, 12493
15315, 12471, 12472, 12495, 12494
15316, 12472, 12473, 12496, 12495
15317, 12473, 12474, 12497, 12496
15318, 12474, 12475, 12498, 12497
15319, 12475, 12476, 12499, 12498
15320, 12476, 12477, 12500, 12499
15321, 12477, 12478, 12501, 12500
15322, 12478, 12479, 12502, 12501
15323, 12479, 12480, 12503, 12502
15324, 12480, 12481, 12504, 12503
15325, 12481, 12482, 12505, 12504
15326, 12482, 12483, 12506, 12505
15327, 12483, 12484, 12507, 12506
15328, 12484, 12485, 12508, 12507
15329, 12485, 12486, 12509, 12508
15330, 12486, 12487, 12510, 12509
15331, 12487, 12488, 12511, 12510
15332, 12488, 12489, 12512, 12511
15333, 12489, 12490, 12513, 12512
15334, 12490, 12491, 12514, 12513
15335, 12491, 12492, 12515, 12514
15336, 12492, 1921, 1922, 12515
15337, 1911, 12493, 12516, 1912
15338, 12493, 12494, 12517, 12516
15339, 12494, 12495, 12518, 12517
15340, 12495, 12496, 12519, 12518
15341, 12496, 12497, 12520, 12519
15342, 12497, 12498, 12521, 12520
15343, 12498, 12499, 12522, 12521
15344, 12499, 12500, 12523, 12522
15345, 12500, 12501, 12524, 12523
15346, 12501, 12502, 12525, 12524
15347, 12502, 12503, 12526, 12525
15348, 12503, 12504, 12527, 12526
15349, 12504, 12505, 12528, 12527
15350, 12505, 12506, 12529, 12528
15351, 12506, 12507, 12530, 12529
15352, 12507, 12508, 12531, 12530
15353, 12508, 12509, 12532, 12531
15354, 12509, 12510, 12533, 12532
15355, 12510, 12511, 12534, 12533
15356, 12511, 12512, 12535, 12534
15357, 12512, 12513, 12536, 12535
15358, 12513, 12514, 12537, 12536
15359, 12514, 12515, 12538, 12537
15360, 12515, 1922, 1923, 12538
15361, 1912, 12516, 12539, 1913
15362, 12516, 12517, 12540, 12539
15363, 12517, 12518, 12541, 12540
15364, 12518, 12519, 12542, 12541
15365, 12519, 12520, 12543, 12542
15366, 12520, 12521, 12544, 12543
15367, 12521, 12522, 12545, 12544
15368, 12522, 12523, 12546, 12545
15369, 12523, 12524, 12547, 12546
15370, 12524, 12525, 12548, 12547
15371, 12525, 12526, 12549, 12548
15372, 12526, 12527, 12550, 12549
15373, 12527, 12528, 12551, 12550
15374, 12528, 12529, 12552, 12551
15375, 12529, 12530, 12553, 12552
15376, 12530, 12531, 12554, 12553
15377, 12531, 12532, 12555, 12554
15378, 12532, 12533, 12556, 12555
15379, 12533, 12534, 12557, 12556
15380, 12534, 12535, 12558, 12557
15381, 12535, 12536, 12559, 12558
15382, 12536, 12537, 12560, 12559
15383, 12537, 12538, 12561, 12560
15384, 12538, 1923, 1924, 12561
15385, 1913, 12539, 12562, 1914
15386, 12539, 12540, 12563, 12562
15387, 12540, 12541, 12564, 12563
15388, 12541, 12542, 12565, 12564
15389, 12542, 12543, 12566, 12565
15390, 12543, 12544, 12567, 12566
15391, 12544, 12545, 12568, 12567
15392, 12545, 12546, 12569, 12568
15393, 12546, 12547, 12570, 12569
15394, 12547, 12548, 12571, 12570
15395, 12548, 12549, 12572, 12571
15396, 12549, 12550, 12573, 12572
15397, 12550, 12551, 12574, 12573
15398, 12551, 12552, 12575, 12574
15399, 12552, 12553, 12576, 12575
15400, 12553, 12554, 12577, 12576
15401, 12554, 12555, 12578, 12577
15402, 12555, 12556, 12579, 12578
15403, 12556, 12557, 12580, 12579
15404, 12557, 12558, 12581, 12580
15405, 12558, 12559, 12582, 12581
15406, 12559, 12560, 12583, 12582
15407, 12560, 12561, 12584, 12583
15408, 12561, 1924, 1925, 12584
15409, 1914, 12562, 1850, 91
15410, 12562, 12563, 1851, 1850
15411, 12563, 12564, 1852, 1851
15412, 12564, 12565, 1853, 1852
15413, 12565, 12566, 1854, 1853
15414, 12566, 12567, 1855, 1854
15415, 12567, 12568, 1856, 1855
15416, 12568, 12569, 1857, 1856
15417, 12569, 12570, 1858, 1857
15418, 12570, 12571, 1859, 1858
15419, 12571, 12572, 1860, 1859
15420, 12572, 12573, 1861, 1860
15421, 12573, 12574, 1862, 1861
15422, 12574, 12575, 1863, 1862
15423, 12575, 12576, 1864, 1863
15424, 12576, 12577, 1865, 1864
15425, 12577, 12578, 1866, 1865
15426, 12578, 12579, 1867, 1866
15427, 12579, 12580, 1868, 1867
15428, 12580, 12581, 1869, 1868
15429, 12581, 12582, 1870, 1869
15430, 12582, 12583, 1871, 1870
15431, 12583, 12584, 1872, 1871
15432, 12584, 1925, 92, 1872
*ELEMENT, type=CPS4, ELSET=Surface132
15433, 46, 1846, 1926, 50
15434, 1846, 1847, 1927, 1926
15435, 1847, 1848, 1928, 1927
15436, 1848, 1849, 1929, 1928
15437, 1849, 92, 95, 1929
*ELEMENT, type=CPS4, ELSET=Surface133
15438, 48, 52, 1930, 1877
15439, 1877, 1930, 1931, 1878
15440, 1878, 1931, 1932, 1879
15441, 1879, 1932, 1933, 1880
15442, 1880, 1933, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
15443, 52, 1160, 12585, 1930
15444, 1930, 12585, 12586, 1931
15445, 1931, 12586, 12587, 1932
15446, 1932, 12587, 12588, 1933
15447, 1933, 12588, 1934, 96
15448, 1160, 1161, 12589, 12585
15449, 12585, 12589, 12590, 12586
15450, 12586, 12590, 12591, 12587
15451, 12587, 12591, 12592, 12588
15452, 12588, 12592, 1935, 1934
15453, 1161, 1162, 12593, 12589
15454, 12589, 12593, 12594, 12590
15455, 12590, 12594, 12595, 12591
15456, 12591, 12595, 12596, 12592
15457, 12592, 12596, 1936, 1935
15458, 1162, 1163, 12597, 12593
15459, 12593, 12597, 12598, 12594
15460, 12594, 12598, 12599, 12595
15461, 12595, 12599, 12600, 12596
15462, 12596, 12600, 1937, 1936
15463, 1163, 1164, 12601, 12597
15464, 12597, 12601, 12602, 12598
15465, 12598, 12602, 12603, 12599
15466, 12599, 12603, 12604, 12600
15467, 12600, 12604, 1938, 1937
15468, 1164, 1165, 12605, 12601
15469, 12601, 12605, 12606, 12602
15470, 12602, 12606, 12607, 12603
15471, 12603, 12607, 12608, 12604
15472, 12604, 12608, 1939, 1938
15473, 1165, 1166, 12609, 12605
15474, 12605, 12609, 12610, 12606
15475, 12606, 12610, 12611, 12607
15476, 12607, 12611, 12612, 12608
15477, 12608, 12612, 1940, 1939
15478, 1166, 1167, 12613, 12609
15479, 12609, 12613, 12614, 12610
15480, 12610, 12614, 12615, 12611
15481, 12611, 12615, 12616, 12612
15482, 12612, 12616, 1941, 1940
15483, 1167, 1168, 12617, 12613
15484, 12613, 12617, 12618, 12614
15485, 12614, 12618, 12619, 12615
15486, 12615, 12619, 12620, 12616
15487, 12616, 12620, 1942, 1941
15488, 1168, 1169, 12621, 12617
15489, 12617, 12621, 12622, 12618
15490, 12618, 12622, 12623, 12619
15491, 12619, 12623, 12624, 12620
15492, 12620, 12624, 1943, 1942
15493, 1169, 1170, 12625, 12621
15494, 12621, 12625, 12626, 12622
15495, 12622, 12626, 12627, 12623
15496, 12623, 12627, 12628, 12624
15497, 12624, 12628, 1944, 1943
15498, 1170, 50, 1926, 12625
15499, 12625, 1926, 1927, 12626
15500, 12626, 1927, 1928, 12627
15501, 12627, 1928, 1929, 12628
15502, 12628, 1929, 95, 1944
*ELEMENT, type=CPS4, ELSET=Surface135
15503, 94, 96, 1934, 1915
15504, 1915, 1934, 1935, 1916
15505, 1916, 1935, 1936, 1917
15506, 1917, 1936, 1937, 1918
15507, 1918, 1937, 1938, 1919
15508, 1919, 1938, 1939, 1920
15509, 1920, 1939, 1940, 1921
15510, 1921, 1940, 1941, 1922
15511, 1922, 1941, 1942, 1923
15512, 1923, 1942, 1943, 1924
15513, 1924, 1943, 1944, 1925
15514, 1925, 1944, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
15515, 1945, 97, 2, 121, 12629, 1989, 149, 2495
15516, 12629, 1989, 149, 2495, 12630, 2000, 150, 2496
15517, 12630, 2000, 150, 2496, 12631, 2011, 151, 2497
15518, 12631, 2011, 151, 2497, 12632, 2022, 152, 2498
15519, 12632, 2022, 152, 2498, 12633, 2033, 153, 2499
15520, 12633, 2033, 153, 2499, 12634, 2044, 154, 2500
15521, 12634, 2044, 154, 2500, 12635, 2055, 155, 2501
15522, 12635, 2055, 155, 2501, 12636, 2066, 156, 2502
15523, 12636, 2066, 156, 2502, 12637, 2077, 157, 2503
15524, 12637, 2077, 157, 2503, 12638, 2088, 158, 2504
15525, 12638, 2088, 158, 2504, 12639, 2099, 159, 2505
15526, 12639, 2099, 159, 2505, 12640, 2110, 160, 2506
15527, 12640, 2110, 160, 2506, 12641, 2121, 161, 2507
15528, 12641, 2121, 161, 2507, 12642, 2132, 162, 2508
15529, 12642, 2132, 162, 2508, 12643, 2143, 163, 2509
15530, 12643, 2143, 163, 2509, 12644, 2154, 164, 2510
15531, 12644, 2154, 164, 2510, 12645, 2165, 165, 2511
15532, 12645, 2165, 165, 2511, 12646, 2176, 166, 2512
15533, 12646, 2176, 166, 2512, 12647, 2187, 167, 2513
15534, 12647, 2187, 167, 2513, 12648, 2198, 168, 2514
15535, 12648, 2198, 168, 2514, 12649, 2209, 169, 2515
15536, 12649, 2209, 169, 2515, 12650, 2220, 170, 2516
15537, 12650, 2220, 170, 2516, 12651, 2231, 171, 2517
15538, 12651, 2231, 171, 2517, 1967, 123, 6, 147
15539, 1946, 1945, 121, 122, 12652, 12629, 2495, 2518
15540, 12652, 12629, 2495, 2518, 12653, 12630, 2496, 2519
15541, 12653, 12630, 2496, 2519, 12654, 12631, 2497, 2520
15542, 12654, 12631, 2497, 2520, 12655, 12632, 2498, 2521
15543, 12655, 12632, 2498, 2521, 12656, 12633, 2499, 2522
15544, 12656, 12633, 2499, 2522, 12657, 12634, 2500, 2523
15545, 12657, 12634, 2500, 2523, 12658, 12635, 2501, 2524
15546, 12658, 12635, 2501, 2524, 12659, 12636, 2502, 2525
15547, 12659, 12636, 2502, 2525, 12660, 12637, 2503, 2526
15548, 12660, 12637, 2503, 2526, 12661, 12638, 2504, 2527
15549, 12661, 12638, 2504, 2527, 12662, 12639, 2505, 2528
15550, 12662, 12639, 2505, 2528, 12663, 12640, 2506, 2529
15551, 12663, 12640, 2506, 2529, 12664, 12641, 2507, 2530
15552, 12664, 12641, 2507, 2530, 12665, 12642, 2508, 2531
15553, 12665, 12642, 2508, 2531, 12666, 12643, 2509, 2532
15554, 12666, 12643, 2509, 2532, 12667, 12644, 2510, 2533
15555, 12667, 12644, 2510, 2533, 12668, 12645, 2511, 2534
15556, 12668, 12645, 2511, 2534, 12669, 12646, 2512, 2535
15557, 12669, 12646, 2512, 2535, 12670, 12647, 2513, 2536
15558, 12670, 12647, 2513, 2536, 12671, 12648, 2514, 2537
15559, 12671, 12648, 2514, 2537, 12672, 12649, 2515, 2538
15560, 12672, 12649, 2515, 2538, 12673, 12650, 2516, 2539
15561, 12673, 12650, 2516, 2539, 12674, 12651, 2517, 2540
15562, 12674, 12651, 2517, 2540, 1968, 1967, 147, 148
15563, 110, 1946, 122, 4, 2242, 12652, 2518, 195
15564, 2242, 12652, 2518, 195, 2253, 12653, 2519, 196
15565, 2253, 12653, 2519, 196, 2264, 12654, 2520, 197
15566, 2264, 12654, 2520, 197, 2275, 12655, 2521, 198
15567, 2275, 12655, 2521, 198, 2286, 12656, 2522, 199
15568, 2286, 12656, 2522, 199, 2297, 12657, 2523, 200
15569, 2297, 12657, 2523, 200, 2308, 12658, 2524, 201
15570, 2308, 12658, 2524, 201, 2319, 12659, 2525, 202
15571, 2319, 12659, 2525, 202, 2330, 12660, 2526, 203
15572, 2330, 12660, 2526, 203, 2341, 12661, 2527, 204
15573, 2341, 12661, 2527, 204, 2352, 12662, 2528, 205
15574, 2352, 12662, 2528, 205, 2363, 12663, 2529, 206
15575, 2363, 12663, 2529, 206, 2374, 12664, 2530, 207
15576, 2374, 12664, 2530, 207, 2385, 12665, 2531, 208
15577, 2385, 12665, 2531, 208, 2396, 12666, 2532, 209
15578, 2396, 12666, 2532, 209, 2407, 12667, 2533, 210
15579, 2407, 12667, 2533, 210, 2418, 12668, 2534, 211
15580, 2418, 12668, 2534, 211, 2429, 12669, 2535, 212
15581, 2429, 12669, 2535, 212, 2440, 12670, 2536, 213
15582, 2440, 12670, 2536, 213, 2451, 12671, 2537, 214
15583, 2451, 12671, 2537, 214, 2462, 12672, 2538, 215
15584, 2462, 12672, 2538, 215, 2473, 12673, 2539, 216
15585, 2473, 12673, 2539, 216, 2484, 12674, 2540, 217
15586, 2484, 12674, 2540, 217, 136, 1968, 148, 8
15587, 1947, 98, 97, 1945, 12675, 1990, 1989, 12629
15588, 12675, 1990, 1989, 12629, 12676, 2001, 2000, 12630
15589, 12676, 2001, 2000, 12630, 12677, 2012, 2011, 12631
15590, 12677, 2012, 2011, 12631, 12678, 2023, 2022, 12632
15591, 12678, 2023, 2022, 12632, 12679, 2034, 2033, 12633
15592, 12679, 2034, 2033, 12633, 12680, 2045, 2044, 12634
15593, 12680, 2045, 2044, 12634, 12681, 2056, 2055, 12635
15594, 12681, 2056, 2055, 12635, 12682, 2067, 2066, 12636
15595, 12682, 2067, 2066, 12636, 12683, 2078, 2077, 12637
15596, 12683, 2078, 2077, 12637, 12684, 2089, 2088, 12638
15597, 12684, 2089, 2088, 12638, 12685, 2100, 2099, 12639
15598, 12685, 2100, 2099, 12639, 12686, 2111, 2110, 12640
15599, 12686, 2111, 2110, 12640, 12687, 2122, 2121, 12641
15600, 12687, 2122, 2121, 12641, 12688, 2133, 2132, 12642
15601, 12688, 2133, 2132, 12642, 12689, 2144, 2143, 12643
15602, 12689, 2144, 2143, 12643, 12690, 2155, 2154, 12644
15603, 12690, 2155, 2154, 12644, 12691, 2166, 2165, 12645
15604, 12691, 2166, 2165, 12645, 12692, 2177, 2176, 12646
15605, 12692, 2177, 2176, 12646, 12693, 2188, 2187, 12647
15606, 12693, 2188, 2187, 12647, 12694, 2199, 2198, 12648
15607, 12694, 2199, 2198, 12648, 12695, 2210, 2209, 12649
15608, 12695, 2210, 2209, 12649, 12696, 2221, 2220, 12650
15609, 12696, 2221, 2220, 12650, 12697, 2232, 2231, 12651
15610, 12697, 2232, 2231, 12651, 1969, 124, 123, 1967
15611, 1948, 1947, 1945, 1946, 12698, 12675, 12629, 12652
15612, 12698, 12675, 12629, 12652, 12699, 12676, 12630, 12653
15613, 12699, 12676, 12630, 12653, 12700, 12677, 12631, 12654
15614, 12700, 12677, 12631, 12654, 12701, 12678, 12632, 12655
15615, 12701, 12678, 12632, 12655, 12702, 12679, 12633, 12656
15616, 12702, 12679, 12633, 12656, 12703, 12680, 12634, 12657
15617, 12703, 12680, 12634, 12657, 12704, 12681, 12635, 12658
15618, 12704, 12681, 12635, 12658, 12705, 12682, 12636, 12659
15619, 12705, 12682, 12636, 12659, 12706, 12683, 12637, 12660
15620, 12706, 12683, 12637, 12660, 12707, 12684, 12638, 12661
15621, 12707, 12684, 12638, 12661, 12708, 12685, 12639, 12662
15622, 12708, 12685, 12639, 12662, 12709, 12686, 12640, 12663
15623, 12709, 12686, 12640, 12663, 12710, 12687, 12641, 12664
15624, 12710, 12687, 12641, 12664, 12711, 12688, 12642, 12665
15625, 12711, 12688, 12642, 12665, 12712, 12689, 12643, 12666
15626, 12712, 12689, 12643, 12666, 12713, 12690, 12644, 12667
15627, 12713, 12690, 12644, 12667, 12714, 12691, 12645, 12668
15628, 12714, 12691, 12645, 12668, 12715, 12692, 12646, 12669
15629, 12715, 12692, 12646, 12669, 12716, 12693, 12647, 12670
15630, 12716, 12693, 12647, 12670, 12717, 12694, 12648, 12671
15631, 12717, 12694, 12648, 12671, 12718, 12695, 12649, 12672
15632, 12718, 12695, 12649, 12672, 12719, 12696, 12650, 12673
15633, 12719, 12696, 12650, 12673, 12720, 12697, 12651, 12674
15634, 12720, 12697, 12651, 12674, 1970, 1969, 1967, 1968
15635, 111, 1948, 1946, 110, 2243, 12698, 12652, 2242
15636, 2243, 12698, 12652, 2242, 2254, 12699, 12653, 2253
15637, 2254, 12699, 12653, 2253, 2265, 12700, 12654, 2264
15638, 2265, 12700, 12654, 2264, 2276, 12701, 12655, 2275
15639, 2276, 12701, 12655, 2275, 2287, 12702, 12656, 2286
15640, 2287, 12702, 12656, 2286, 2298, 12703, 12657, 2297
15641, 2298, 12703, 12657, 2297, 2309, 12704, 12658, 2308
15642, 2309, 12704, 12658, 2308, 2320, 12705, 12659, 2319
15643, 2320, 12705, 12659, 2319, 2331, 12706, 12660, 2330
15644, 2331, 12706, 12660, 2330, 2342, 12707, 12661, 2341
15645, 2342, 12707, 12661, 2341, 2353, 12708, 12662, 2352
15646, 2353, 12708, 12662, 2352, 2364, 12709, 12663, 2363
15647, 2364, 12709, 12663, 2363, 2375, 12710, 12664, 2374
15648, 2375, 12710, 12664, 2374, 2386, 12711, 12665, 2385
15649, 2386, 12711, 12665, 2385, 2397, 12712, 12666, 2396
15650, 2397, 12712, 12666, 2396, 2408, 12713, 12667, 2407
15651, 2408, 12713, 12667, 2407, 2419, 12714, 12668, 2418
15652, 2419, 12714, 12668, 2418, 2430, 12715, 12669, 2429
15653, 2430, 12715, 12669, 2429, 2441, 12716, 12670, 2440
15654, 2441, 12716, 12670, 2440, 2452, 12717, 12671, 2451
15655, 2452, 12717, 12671, 2451, 2463, 12718, 12672, 2462
15656, 2463, 12718, 12672, 2462, 2474, 12719, 12673, 2473
15657, 2474, 12719, 12673, 2473, 2485, 12720, 12674, 2484
15658, 2485, 12720, 12674, 2484, 137, 1970, 1968, 136
15659, 1949, 99, 98, 1947, 12721, 1991, 1990, 12675
15660, 12721, 1991, 1990, 12675, 12722, 2002, 2001, 12676
15661, 12722, 2002, 2001, 12676, 12723, 2013, 2012, 12677
15662, 12723, 2013, 2012, 12677, 12724, 2024, 2023, 12678
15663, 12724, 2024, 2023, 12678, 12725, 2035, 2034, 12679
15664, 12725, 2035, 2034, 12679, 12726, 2046, 2045, 12680
15665, 12726, 2046, 2045, 12680, 12727, 2057, 2056, 12681
15666, 12727, 2057, 2056, 12681, 12728, 2068, 2067, 12682
15667, 12728, 2068, 2067, 12682, 12729, 2079, 2078, 12683
15668, 12729, 2079, 2078, 12683, 12730, 2090, 2089, 12684
15669, 12730, 2090, 2089, 12684, 12731, 2101, 2100, 12685
15670, 12731, 2101, 2100, 12685, 12732, 2112, 2111, 12686
15671, 12732, 2112, 2111, 12686, 12733, 2123, 2122, 12687
15672, 12733, 2123, 2122, 12687, 12734, 2134, 2133, 12688
15673, 12734, 2134, 2133, 12688, 12735, 2145, 2144, 12689
15674, 12735, 2145, 2144, 12689, 12736, 2156, 2155, 12690
15675, 12736, 2156, 2155, 12690, 12737, 2167, 2166, 12691
15676, 12737, 2167, 2166, 12691, 12738, 2178, 2177, 12692
15677, 12738, 2178, 2177, 12692, 12739, 2189, 2188, 12693
15678, 12739, 2189, 2188, 12693, 12740, 2200, 2199, 12694
15679, 12740, 2200, 2199, 12694, 12741, 2211, 2210, 12695
15680, 12741, 2211, 2210, 12695, 12742, 2222, 2221, 12696
15681, 12742, 2222, 2221, 12696, 12743, 2233, 2232, 12697
15682, 12743, 2233, 2232, 12697, 1971, 125, 124, 1969
15683, 1950, 1949, 1947, 1948, 12744, 12721, 12675, 12698
15684, 12744, 12721, 12675, 12698, 12745, 12722, 12676, 12699
15685, 12745, 12722, 12676, 12699, 12746, 12723, 12677, 12700
15686, 12746, 12723, 12677, 12700, 12747, 12724, 12678, 12701
15687, 12747, 12724, 12678, 12701, 12748, 12725, 12679, 12702
15688, 12748, 12725, 12679, 12702, 12749, 12726, 12680, 12703
15689, 12749, 12726, 12680, 12703, 12750, 12727, 12681, 12704
15690, 12750, 12727, 12681, 12704, 12751, 12728, 12682, 12705
15691, 12751, 12728, 12682, 12705, 12752, 12729, 12683, 12706
15692, 12752, 12729, 12683, 12706, 12753, 12730, 12684, 12707
15693, 12753, 12730, 12684, 12707, 12754, 12731, 12685, 12708
15694, 12754, 12731, 12685, 12708, 12755, 12732, 12686, 12709
15695, 12755, 12732, 12686, 12709, 12756, 12733, 12687, 12710
15696, 12756, 12733, 12687, 12710, 12757, 12734, 12688, 12711
15697, 12757, 12734, 12688, 12711, 12758, 12735, 12689, 12712
15698, 12758, 12735, 12689, 12712, 12759, 12736, 12690, 12713
15699, 12759, 12736, 12690, 12713, 12760, 12737, 12691, 12714
15700, 12760, 12737, 12691, 12714, 12761, 12738, 12692, 12715
15701, 12761, 12738, 12692, 12715, 12762, 12739, 12693, 12716
15702, 12762, 12739, 12693, 12716, 12763, 12740, 12694, 12717
15703, 12763, 12740, 12694, 12717, 12764, 12741, 12695, 12718
15704, 12764, 12741, 12695, 12718, 12765, 12742, 12696, 12719
15705, 12765, 12742, 12696, 12719, 12766, 12743, 12697, 12720
15706, 12766, 12743, 12697, 12720, 1972, 1971, 1969, 1970
15707, 112, 1950, 1948, 111, 2244, 12744, 12698, 2243
15708, 2244, 12744, 12698, 2243, 2255, 12745, 12699, 2254
15709, 2255, 12745, 12699, 2254, 2266, 12746, 12700, 2265
15710, 2266, 12746, 12700, 2265, 2277, 12747, 12701, 2276
15711, 2277, 12747, 12701, 2276, 2288, 12748, 12702, 2287
15712, 2288, 12748, 12702, 2287, 2299, 12749, 12703, 2298
15713, 2299, 12749, 12703, 2298, 2310, 12750, 12704, 2309
15714, 2310, 12750, 12704, 2309, 2321, 12751, 12705, 2320
15715, 2321, 12751, 12705, 2320, 2332, 12752, 12706, 2331
15716, 2332, 12752, 12706, 2331, 2343, 12753, 12707, 2342
15717, 2343, 12753, 12707, 2342, 2354, 12754, 12708, 2353
15718, 2354, 12754, 12708, 2353, 2365, 12755, 12709, 2364
15719, 2365, 12755, 12709, 2364, 2376, 12756, 12710, 2375
15720, 2376, 12756, 12710, 2375, 2387, 12757, 12711, 2386
15721, 2387, 12757, 12711, 2386, 2398, 12758, 12712, 2397
15722, 2398, 12758, 12712, 2397, 2409, 12759, 12713, 2408
15723, 2409, 12759, 12713, 2408, 2420, 12760, 12714, 2419
15724, 2420, 12760, 12714, 2419, 2431, 12761, 12715, 2430
15725, 2431, 12761, 12715, 2430, 2442, 12762, 12716, 2441
15726, 2442, 12762, 12716, 2441, 2453, 12763, 12717, 2452
15727, 2453, 12763, 12717, 2452, 2464, 12764, 12718, 2463
15728, 2464, 12764, 12718, 2463, 2475, 12765, 12719, 2474
15729, 2475, 12765, 12719, 2474, 2486, 12766, 12720, 2485
15730, 2486, 12766, 12720, 2485, 138, 1972, 1970, 137
15731, 1951, 100, 99, 1949, 12767, 1992, 1991, 12721
15732, 12767, 1992, 1991, 12721, 12768, 2003, 2002, 12722
15733, 12768, 2003, 2002, 12722, 12769, 2014, 2013, 12723
15734, 12769, 2014, 2013, 12723, 12770, 2025, 2024, 12724
15735, 12770, 2025, 2024, 12724, 12771, 2036, 2035, 12725
15736, 12771, 2036, 2035, 12725, 12772, 2047, 2046, 12726
15737, 12772, 2047, 2046, 12726, 12773, 2058, 2057, 12727
15738, 12773, 2058, 2057, 12727, 12774, 2069, 2068, 12728
15739, 12774, 2069, 2068, 12728, 12775, 2080, 2079, 12729
15740, 12775, 2080, 2079, 12729, 12776, 2091, 2090, 12730
15741, 12776, 2091, 2090, 12730, 12777, 2102, 2101, 12731
15742, 12777, 2102, 2101, 12731, 12778, 2113, 2112, 12732
15743, 12778, 2113, 2112, 12732, 12779, 2124, 2123, 12733
15744, 12779, 2124, 2123, 12733, 12780, 2135, 2134, 12734
15745, 12780, 2135, 2134, 12734, 12781, 2146, 2145, 12735
15746, 12781, 2146, 2145, 12735, 12782, 2157, 2156, 12736
15747, 12782, 2157, 2156, 12736, 12783, 2168, 2167, 12737
15748, 12783, 2168, 2167, 12737, 12784, 2179, 2178, 12738
15749, 12784, 2179, 2178, 12738, 12785, 2190, 2189, 12739
15750, 12785, 2190, 2189, 12739, 12786, 2201, 2200, 12740
15751, 12786, 2201, 2200, 12740, 12787, 2212, 2211, 12741
15752, 12787, 2212, 2211, 12741, 12788, 2223, 2222, 12742
15753, 12788, 2223, 2222, 12742, 12789, 2234, 2233, 12743
15754, 12789, 2234, 2233, 12743, 1973, 126, 125, 1971
15755, 1952, 1951, 1949, 1950, 12790, 12767, 12721, 12744
15756, 12790, 12767, 12721, 12744, 12791, 12768, 12722, 12745
15757, 12791, 12768, 12722, 12745, 12792, 12769, 12723, 12746
15758, 12792, 12769, 12723, 12746, 12793, 12770, 12724, 12747
15759, 12793, 12770, 12724, 12747, 12794, 12771, 12725, 12748
15760, 12794, 12771, 12725, 12748, 12795, 12772, 12726, 12749
15761, 12795, 12772, 12726, 12749, 12796, 12773, 12727, 12750
15762, 12796, 12773, 12727, 12750, 12797, 12774, 12728, 12751
15763, 12797, 12774, 12728, 12751, 12798, 12775, 12729, 12752
15764, 12798, 12775, 12729, 12752, 12799, 12776, 12730, 12753
15765, 12799, 12776, 12730, 12753, 12800, 12777, 12731, 12754
15766, 12800, 12777, 12731, 12754, 12801, 12778, 12732, 12755
15767, 12801, 12778, 12732, 12755, 12802, 12779, 12733, 12756
15768, 12802, 12779, 12733, 12756, 12803, 12780, 12734, 12757
15769, 12803, 12780, 12734, 12757, 12804, 12781, 12735, 12758
15770, 12804, 12781, 12735, 12758, 12805, 12782, 12736, 12759
15771, 12805, 12782, 12736, 12759, 12806, 12783, 12737, 12760
15772, 12806, 12783, 12737, 12760, 12807, 12784, 12738, 12761
15773, 12807, 12784, 12738, 12761, 12808, 12785, 12739, 12762
15774, 12808, 12785, 12739, 12762, 12809, 12786, 12740, 12763
15775, 12809, 12786, 12740, 12763, 12810, 12787, 12741, 12764
15776, 12810, 12787, 12741, 12764, 12811, 12788, 12742, 12765
15777, 12811, 12788, 12742, 12765, 12812, 12789, 12743, 12766
15778, 12812, 12789, 12743, 12766, 1974, 1973, 1971, 1972
15779, 113, 1952, 1950, 112, 2245, 12790, 12744, 2244
15780, 2245, 12790, 12744, 2244, 2256, 12791, 12745, 2255
15781, 2256, 12791, 12745, 2255, 2267, 12792, 12746, 2266
15782, 2267, 12792, 12746, 2266, 2278, 12793, 12747, 2277
15783, 2278, 12793, 12747, 2277, 2289, 12794, 12748, 2288
15784, 2289, 12794, 12748, 2288, 2300, 12795, 12749, 2299
15785, 2300, 12795, 12749, 2299, 2311, 12796, 12750, 2310
15786, 2311, 12796, 12750, 2310, 2322, 12797, 12751, 2321
15787, 2322, 12797, 12751, 2321, 2333, 12798, 12752, 2332
15788, 2333, 12798, 12752, 2332, 2344, 12799, 12753, 2343
15789, 2344, 12799, 12753, 2343, 2355, 12800, 12754, 2354
15790, 2355, 12800, 12754, 2354, 2366, 12801, 12755, 2365
15791, 2366, 12801, 12755, 2365, 2377, 12802, 12756, 2376
15792, 2377, 12802, 12756, 2376, 2388, 12803, 12757, 2387
15793, 2388, 12803, 12757, 2387, 2399, 12804, 12758, 2398
15794, 2399, 12804, 12758, 2398, 2410, 12805, 12759, 2409
15795, 2410, 12805, 12759, 2409, 2421, 12806, 12760, 2420
15796, 2421, 12806, 12760, 2420, 2432, 12807, 12761, 2431
15797, 2432, 12807, 12761, 2431, 2443, 12808, 12762, 2442
15798, 2443, 12808, 12762, 2442, 2454, 12809, 12763, 2453
15799, 2454, 12809, 12763, 2453, 2465, 12810, 12764, 2464
15800, 2465, 12810, 12764, 2464, 2476, 12811, 12765, 2475
15801, 2476, 12811, 12765, 2475, 2487, 12812, 12766, 2486
15802, 2487, 12812, 12766, 2486, 139, 1974, 1972, 138
15803, 1953, 101, 100, 1951, 12813, 1993, 1992, 12767
15804, 12813, 1993, 1992, 12767, 12814, 2004, 2003, 12768
15805, 12814, 2004, 2003, 12768, 12815, 2015, 2014, 12769
15806, 12815, 2015, 2014, 12769, 12816, 2026, 2025, 12770
15807, 12816, 2026, 2025, 12770, 12817, 2037, 2036, 12771
15808, 12817, 2037, 2036, 12771, 12818, 2048, 2047, 12772
15809, 12818, 2048, 2047, 12772, 12819, 2059, 2058, 12773
15810, 12819, 2059, 2058, 12773, 12820, 2070, 2069, 12774
15811, 12820, 2070, 2069, 12774, 12821, 2081, 2080, 12775
15812, 12821, 2081, 2080, 12775, 12822, 2092, 2091, 12776
15813, 12822, 2092, 2091, 12776, 12823, 2103, 2102, 12777
15814, 12823, 2103, 2102, 12777, 12824, 2114, 2113, 12778
15815, 12824, 2114, 2113, 12778, 12825, 2125, 2124, 12779
15816, 12825, 2125, 2124, 12779, 12826, 2136, 2135, 12780
15817, 12826, 2136, 2135, 12780, 12827, 2147, 2146, 12781
15818, 12827, 2147, 2146, 12781, 12828, 2158, 2157, 12782
15819, 12828, 2158, 2157, 12782, 12829, 2169, 2168, 12783
15820, 12829, 2169, 2168, 12783, 12830, 2180, 2179, 12784
15821, 12830, 2180, 2179, 12784, 12831, 2191, 2190, 12785
15822, 12831, 2191, 2190, 12785, 12832, 2202, 2201, 12786
15823, 12832, 2202, 2201, 12786, 12833, 2213, 2212, 12787
15824, 12833, 2213, 2212, 12787, 12834, 2224, 2223, 12788
15825, 12834, 2224, 2223, 12788, 12835, 2235, 2234, 12789
15826, 12835, 2235, 2234, 12789, 1975, 127, 126, 1973
15827, 1954, 1953, 1951, 1952, 12836, 12813, 12767, 12790
15828, 12836, 12813, 12767, 12790, 12837, 12814, 12768, 12791
15829, 12837, 12814, 12768, 12791, 12838, 12815, 12769, 12792
15830, 12838, 12815, 12769, 12792, 12839, 12816, 12770, 12793
15831, 12839, 12816, 12770, 12793, 12840, 12817, 12771, 12794
15832, 12840, 12817, 12771, 12794, 12841, 12818, 12772, 12795
15833, 12841, 12818, 12772, 12795, 12842, 12819, 12773, 12796
15834, 12842, 12819, 12773, 12796, 12843, 12820, 12774, 12797
15835, 12843, 12820, 12774, 12797, 12844, 12821, 12775, 12798
15836, 12844, 12821, 12775, 12798, 12845, 12822, 12776, 12799
15837, 12845, 12822, 12776, 12799, 12846, 12823, 12777, 12800
15838, 12846, 12823, 12777, 12800, 12847, 12824, 12778, 12801
15839, 12847, 12824, 12778, 12801, 12848, 12825, 12779, 12802
15840, 12848, 12825, 12779, 12802, 12849, 12826, 12780, 12803
15841, 12849, 12826, 12780, 12803, 12850, 12827, 12781, 12804
15842, 12850, 12827, 12781, 12804, 12851, 12828, 12782, 12805
15843, 12851, 12828, 12782, 12805, 12852, 12829, 12783, 12806
15844, 12852, 12829, 12783, 12806, 12853, 12830, 12784, 12807
15845, 12853, 12830, 12784, 12807, 12854, 12831, 12785, 12808
15846, 12854, 12831, 12785, 12808, 12855, 12832, 12786, 12809
15847, 12855, 12832, 12786, 12809, 12856, 12833, 12787, 12810
15848, 12856, 12833, 12787, 12810, 12857, 12834, 12788, 12811
15849, 12857, 12834, 12788, 12811, 12858, 12835, 12789, 12812
15850, 12858, 12835, 12789, 12812, 1976, 1975, 1973, 1974
15851, 114, 1954, 1952, 113, 2246, 12836, 12790, 2245
15852, 2246, 12836, 12790, 2245, 2257, 12837, 12791, 2256
15853, 2257, 12837, 12791, 2256, 2268, 12838, 12792, 2267
15854, 2268, 12838, 12792, 2267, 2279, 12839, 12793, 2278
15855, 2279, 12839, 12793, 2278, 2290, 12840, 12794, 2289
15856, 2290, 12840, 12794, 2289, 2301, 12841, 12795, 2300
15857, 2301, 12841, 12795, 2300, 2312, 12842, 12796, 2311
15858, 2312, 12842, 12796, 2311, 2323, 12843, 12797, 2322
15859, 2323, 12843, 12797, 2322, 2334, 12844, 12798, 2333
15860, 2334, 12844, 12798, 2333, 2345, 12845, 12799, 2344
15861, 2345, 12845, 12799, 2344, 2356, 12846, 12800, 2355
15862, 2356, 12846, 12800, 2355, 2367, 12847, 12801, 2366
15863, 2367, 12847, 12801, 2366, 2378, 12848, 12802, 2377
15864, 2378, 12848, 12802, 2377, 2389, 12849, 12803, 2388
15865, 2389, 12849, 12803, 2388, 2400, 12850, 12804, 2399
15866, 2400, 12850, 12804, 2399, 2411, 12851, 12805, 2410
15867, 2411, 12851, 12805, 2410, 2422, 12852, 12806, 2421
15868, 2422, 12852, 12806, 2421, 2433, 12853, 12807, 2432
15869, 2433, 12853, 12807, 2432, 2444, 12854, 12808, 2443
15870, 2444, 12854, 12808, 2443, 2455, 12855, 12809, 2454
15871, 2455, 12855, 12809, 2454, 2466, 12856, 12810, 2465
15872, 2466, 12856, 12810, 2465, 2477, 12857, 12811, 2476
15873, 2477, 12857, 12811, 2476, 2488, 12858, 12812, 2487
15874, 2488, 12858, 12812, 2487, 140, 1976, 1974, 139
15875, 1955, 102, 101, 1953, 12859, 1994, 1993, 12813
15876, 12859, 1994, 1993, 12813, 12860, 2005, 2004, 12814
15877, 12860, 2005, 2004, 12814, 12861, 2016, 2015, 12815
15878, 12861, 2016, 2015, 12815, 12862, 2027, 2026, 12816
15879, 12862, 2027, 2026, 12816, 12863, 2038, 2037, 12817
15880, 12863, 2038, 2037, 12817, 12864, 2049, 2048, 12818
15881, 12864, 2049, 2048, 12818, 12865, 2060, 2059, 12819
15882, 12865, 2060, 2059, 12819, 12866, 2071, 2070, 12820
15883, 12866, 2071, 2070, 12820, 12867, 2082, 2081, 12821
15884, 12867, 2082, 2081, 12821, 12868, 2093, 2092, 12822
15885, 12868, 2093, 2092, 12822, 12869, 2104, 2103, 12823
15886, 12869, 2104, 2103, 12823, 12870, 2115, 2114, 12824
15887, 12870, 2115, 2114, 12824, 12871, 2126, 2125, 12825
15888, 12871, 2126, 2125, 12825, 12872, 2137, 2136, 12826
15889, 12872, 2137, 2136, 12826, 12873, 2148, 2147, 12827
15890, 12873, 2148, 2147, 12827, 12874, 2159, 2158, 12828
15891, 12874, 2159, 2158, 12828, 12875, 2170, 2169, 12829
15892, 12875, 2170, 2169, 12829, 12876, 2181, 2180, 12830
15893, 12876, 2181, 2180, 12830, 12877, 2192, 2191, 12831
15894, 12877, 2192, 2191, 12831, 12878, 2203, 2202, 12832
15895, 12878, 2203, 2202, 12832, 12879, 2214, 2213, 12833
15896, 12879, 2214, 2213, 12833, 12880, 2225, 2224, 12834
15897, 12880, 2225, 2224, 12834, 12881, 2236, 2235, 12835
15898, 12881, 2236, 2235, 12835, 1977, 128, 127, 1975
15899, 1956, 1955, 1953, 1954, 12882, 12859, 12813, 12836
15900, 12882, 12859, 12813, 12836, 12883, 12860, 12814, 12837
15901, 12883, 12860, 12814, 12837, 12884, 12861, 12815, 12838
15902, 12884, 12861, 12815, 12838, 12885, 12862, 12816, 12839
15903, 12885, 12862, 12816, 12839, 12886, 12863, 12817, 12840
15904, 12886, 12863, 12817, 12840, 12887, 12864, 12818, 12841
15905, 12887, 12864, 12818, 12841, 12888, 12865, 12819, 12842
15906, 12888, 12865, 12819, 12842, 12889, 12866, 12820, 12843
15907, 12889, 12866, 12820, 12843, 12890, 12867, 12821, 12844
15908, 12890, 12867, 12821, 12844, 12891, 12868, 12822, 12845
15909, 12891, 12868, 12822, 12845, 12892, 12869, 12823, 12846
15910, 12892, 12869, 12823, 12846, 12893, 12870, 12824, 12847
15911, 12893, 12870, 12824, 12847, 12894, 12871, 12825, 12848
15912, 12894, 12871, 12825, 12848, 12895, 12872, 12826, 12849
15913, 12895, 12872, 12826, 12849, 12896, 12873, 12827, 12850
15914, 12896, 12873, 12827, 12850, 12897, 12874, 12828, 12851
15915, 12897, 12874, 12828, 12851, 12898, 12875, 12829, 12852
15916, 12898, 12875, 12829, 12852, 12899, 12876, 12830, 12853
15917, 12899, 12876, 12830, 12853, 12900, 12877, 12831, 12854
15918, 12900, 12877, 12831, 12854, 12901, 12878, 12832, 12855
15919, 12901, 12878, 12832, 12855, 12902, 12879, 12833, 12856
15920, 12902, 12879, 12833, 12856, 12903, 12880, 12834, 12857
15921, 12903, 12880, 12834, 12857, 12904, 12881, 12835, 12858
15922, 12904, 12881, 12835, 12858, 1978, 1977, 1975, 1976
15923, 115, 1956, 1954, 114, 2247, 12882, 12836, 2246
15924, 2247, 12882, 12836, 2246, 2258, 12883, 12837, 2257
15925, 2258, 12883, 12837, 2257, 2269, 12884, 12838, 2268
15926, 2269, 12884, 12838, 2268, 2280, 12885, 12839, 2279
15927, 2280, 12885, 12839, 2279, 2291, 12886, 12840, 2290
15928, 2291, 12886, 12840, 2290, 2302, 12887, 12841, 2301
15929, 2302, 12887, 12841, 2301, 2313, 12888, 12842, 2312
15930, 2313, 12888, 12842, 2312, 2324, 12889, 12843, 2323
15931, 2324, 12889, 12843, 2323, 2335, 12890, 12844, 2334
15932, 2335, 12890, 12844, 2334, 2346, 12891, 12845, 2345
15933, 2346, 12891, 12845, 2345, 2357, 12892, 12846, 2356
15934, 2357, 12892, 12846, 2356, 2368, 12893, 12847, 2367
15935, 2368, 12893, 12847, 2367, 2379, 12894, 12848, 2378
15936, 2379, 12894, 12848, 2378, 2390, 12895, 12849, 2389
15937, 2390, 12895, 12849, 2389, 2401, 12896, 12850, 2400
15938, 2401, 12896, 12850, 2400, 2412, 12897, 12851, 2411
15939, 2412, 12897, 12851, 2411, 2423, 12898, 12852, 2422
15940, 2423, 12898, 12852, 2422, 2434, 12899, 12853, 2433
15941, 2434, 12899, 12853, 2433, 2445, 12900, 12854, 2444
15942, 2445, 12900, 12854, 2444, 2456, 12901, 12855, 2455
15943, 2456, 12901, 12855, 2455, 2467, 12902, 12856, 2466
15944, 2467, 12902, 12856, 2466, 2478, 12903, 12857, 2477
15945, 2478, 12903, 12857, 2477, 2489, 12904, 12858, 2488
15946, 2489, 12904, 12858, 2488, 141, 1978, 1976, 140
15947, 1957, 103, 102, 1955, 12905, 1995, 1994, 12859
15948, 12905, 1995, 1994, 12859, 12906, 2006, 2005, 12860
15949, 12906, 2006, 2005, 12860, 12907, 2017, 2016, 12861
15950, 12907, 2017, 2016, 12861, 12908, 2028, 2027, 12862
15951, 12908, 2028, 2027, 12862, 12909, 2039, 2038, 12863
15952, 12909, 2039, 2038, 12863, 12910, 2050, 2049, 12864
15953, 12910, 2050, 2049, 12864, 12911, 2061, 2060, 12865
15954, 12911, 2061, 2060, 12865, 12912, 2072, 2071, 12866
15955, 12912, 2072, 2071, 12866, 12913, 2083, 2082, 12867
15956, 12913, 2083, 2082, 12867, 12914, 2094, 2093, 12868
15957, 12914, 2094, 2093, 12868, 12915, 2105, 2104, 12869
15958, 12915, 2105, 2104, 12869, 12916, 2116, 2115, 12870
15959, 12916, 2116, 2115, 12870, 12917, 2127, 2126, 12871
15960, 12917, 2127, 2126, 12871, 12918, 2138, 2137, 12872
15961, 12918, 2138, 2137, 12872, 12919, 2149, 2148, 12873
15962, 12919, 2149, 2148, 12873, 12920, 2160, 2159, 12874
15963, 12920, 2160, 2159, 12874, 12921, 2171, 2170, 12875
15964, 12921, 2171, 2170, 12875, 12922, 2182, 2181, 12876
15965, 12922, 2182, 2181, 12876, 12923, 2193, 2192, 12877
15966, 12923, 2193, 2192, 12877, 12924, 2204, 2203, 12878
15967, 12924, 2204, 2203, 12878, 12925, 2215, 2214, 12879
15968, 12925, 2215, 2214, 12879, 12926, 2226, 2225, 12880
15969, 12926, 2226, 2225, 12880, 12927, 2237, 2236, 12881
15970, 12927, 2237, 2236, 12881, 1979, 129, 128, 1977
15971, 1958, 1957, 1955, 1956, 12928, 12905, 12859, 12882
15972, 12928, 12905, 12859, 12882, 12929, 12906, 12860, 12883
15973, 12929, 12906, 12860, 12883, 12930, 12907, 12861, 12884
15974, 12930, 12907, 12861, 12884, 12931, 12908, 12862, 12885
15975, 12931, 12908, 12862, 12885, 12932, 12909, 12863, 12886
15976, 12932, 12909, 12863, 12886, 12933, 12910, 12864, 12887
15977, 12933, 12910, 12864, 12887, 12934, 12911, 12865, 12888
15978, 12934, 12911, 12865, 12888, 12935, 12912, 12866, 12889
15979, 12935, 12912, 12866, 12889, 12936, 12913, 12867, 12890
15980, 12936, 12913, 12867, 12890, 12937, 12914, 12868, 12891
15981, 12937, 12914, 12868, 12891, 12938, 12915, 12869, 12892
15982, 12938, 12915, 12869, 12892, 12939, 12916, 12870, 12893
15983, 12939, 12916, 12870, 12893, 12940, 12917, 12871, 12894
15984, 12940, 12917, 12871, 12894, 12941, 12918, 12872, 12895
15985, 12941, 12918, 12872, 12895, 12942, 12919, 12873, 12896
15986, 12942, 12919, 12873, 12896, 12943, 12920, 12874, 12897
15987, 12943, 12920, 12874, 12897, 12944, 12921, 12875, 12898
15988, 12944, 12921, 12875, 12898, 12945, 12922, 12876, 12899
15989, 12945, 12922, 12876, 12899, 12946, 12923, 12877, 12900
15990, 12946, 12923, 12877, 12900, 12947, 12924, 12878, 12901
15991, 12947, 12924, 12878, 12901, 12948, 12925, 12879, 12902
15992, 12948, 12925, 12879, 12902, 12949, 12926, 12880, 12903
15993, 12949, 12926, 12880, 12903, 12950, 12927, 12881, 12904
15994, 12950, 12927, 12881, 12904, 1980, 1979, 1977, 1978
15995, 116, 1958, 1956, 115, 2248, 12928, 12882, 2247
15996, 2248, 12928, 12882, 2247, 2259, 12929, 12883, 2258
15997, 2259, 12929, 12883, 2258, 2270, 12930, 12884, 2269
15998, 2270, 12930, 12884, 2269, 2281, 12931, 12885, 2280
15999, 2281, 12931, 12885, 2280, 2292, 12932, 12886, 2291
16000, 2292, 12932, 12886, 2291, 2303, 12933, 12887, 2302
16001, 2303, 12933, 12887, 2302, 2314, 12934, 12888, 2313
16002, 2314, 12934, 12888, 2313, 2325, 12935, 12889, 2324
16003, 2325, 12935, 12889, 2324, 2336, 12936, 12890, 2335
16004, 2336, 12936, 12890, 2335, 2347, 12937, 12891, 2346
16005, 2347, 12937, 12891, 2346, 2358, 12938, 12892, 2357
16006, 2358, 12938, 12892, 2357, 2369, 12939, 12893, 2368
16007, 2369, 12939, 12893, 2368, 2380, 12940, 12894, 2379
16008, 2380, 12940, 12894, 2379, 2391, 12941, 12895, 2390
16009, 2391, 12941, 12895, 2390, 2402, 12942, 12896, 2401
16010, 2402, 12942, 12896, 2401, 2413, 12943, 12897, 2412
16011, 2413, 12943, 12897, 2412, 2424, 12944, 12898, 2423
16012, 2424, 12944, 12898, 2423, 2435, 12945, 12899, 2434
16013, 2435, 12945, 12899, 2434, 2446, 12946, 12900, 2445
16014, 2446, 12946, 12900, 2445, 2457, 12947, 12901, 2456
16015, 2457, 12947, 12901, 2456, 2468, 12948, 12902, 2467
16016, 2468, 12948, 12902, 2467, 2479, 12949, 12903, 2478
16017, 2479, 12949, 12903, 2478, 2490, 12950, 12904, 2489
16018, 2490, 12950, 12904, 2489, 142, 1980, 1978, 141
16019, 1959, 104, 103, 1957, 12951, 1996, 1995, 12905
16020, 12951, 1996, 1995, 12905, 12952, 2007, 2006, 12906
16021, 12952, 2007, 2006, 12906, 12953, 2018, 2017, 12907
16022, 12953, 2018, 2017, 12907, 12954, 2029, 2028, 12908
16023, 12954, 2029, 2028, 12908, 12955, 2040, 2039, 12909
16024, 12955, 2040, 2039, 12909, 12956, 2051, 2050, 12910
16025, 12956, 2051, 2050, 12910, 12957, 2062, 2061, 12911
16026, 12957, 2062, 2061, 12911, 12958, 2073, 2072, 12912
16027, 12958, 2073, 2072, 12912, 12959, 2084, 2083, 12913
16028, 12959, 2084, 2083, 12913, 12960, 2095, 2094, 12914
16029, 12960, 2095, 2094, 12914, 12961, 2106, 2105, 12915
16030, 12961, 2106, 2105, 12915, 12962, 2117, 2116, 12916
16031, 12962, 2117, 2116, 12916, 12963, 2128, 2127, 12917
16032, 12963, 2128, 2127, 12917, 12964, 2139, 2138, 12918
16033, 12964, 2139, 2138, 12918, 12965, 2150, 2149, 12919
16034, 12965, 2150, 2149, 12919, 12966, 2161, 2160, 12920
16035, 12966, 2161, 2160, 12920, 12967, 2172, 2171, 12921
16036, 12967, 2172, 2171, 12921, 12968, 2183, 2182, 12922
16037, 12968, 2183, 2182, 12922, 12969, 2194, 2193, 12923
16038, 12969, 2194, 2193, 12923, 12970, 2205, 2204, 12924
16039, 12970, 2205, 2204, 12924, 12971, 2216, 2215, 12925
16040, 12971, 2216, 2215, 12925, 12972, 2227, 2226, 12926
16041, 12972, 2227, 2226, 12926, 12973, 2238, 2237, 12927
16042, 12973, 2238, 2237, 12927, 1981, 130, 129, 1979
16043, 1960, 1959, 1957, 1958, 12974, 12951, 12905, 12928
16044, 12974, 12951, 12905, 12928, 12975, 12952, 12906, 12929
16045, 12975, 12952, 12906, 12929, 12976, 12953, 12907, 12930
16046, 12976, 12953, 12907, 12930, 12977, 12954, 12908, 12931
16047, 12977, 12954, 12908, 12931, 12978, 12955, 12909, 12932
16048, 12978, 12955, 12909, 12932, 12979, 12956, 12910, 12933
16049, 12979, 12956, 12910, 12933, 12980, 12957, 12911, 12934
16050, 12980, 12957, 12911, 12934, 12981, 12958, 12912, 12935
16051, 12981, 12958, 12912, 12935, 12982, 12959, 12913, 12936
16052, 12982, 12959, 12913, 12936, 12983, 12960, 12914, 12937
16053, 12983, 12960, 12914, 12937, 12984, 12961, 12915, 12938
16054, 12984, 12961, 12915, 12938, 12985, 12962, 12916, 12939
16055, 12985, 12962, 12916, 12939, 12986, 12963, 12917, 12940
16056, 12986, 12963, 12917, 12940, 12987, 12964, 12918, 12941
16057, 12987, 12964, 12918, 12941, 12988, 12965, 12919, 12942
16058, 12988, 12965, 12919, 12942, 12989, 12966, 12920, 12943
16059, 12989, 12966, 12920, 12943, 12990, 12967, 12921, 12944
16060, 12990, 12967, 12921, 12944, 12991, 12968, 12922, 12945
16061, 12991, 12968, 12922, 12945, 12992, 12969, 12923, 12946
16062, 12992, 12969, 12923, 12946, 12993, 12970, 12924, 12947
16063, 12993, 12970, 12924, 12947, 12994, 12971, 12925, 12948
16064, 12994, 12971, 12925, 12948, 12995, 12972, 12926, 12949
16065, 12995, 12972, 12926, 12949, 12996, 12973, 12927, 12950
16066, 12996, 12973, 12927, 12950, 1982, 1981, 1979, 1980
16067, 117, 1960, 1958, 116, 2249, 12974, 12928, 2248
16068, 2249, 12974, 12928, 2248, 2260, 12975, 12929, 2259
16069, 2260, 12975, 12929, 2259, 2271, 12976, 12930, 2270
16070, 2271, 12976, 12930, 2270, 2282, 12977, 12931, 2281
16071, 2282, 12977, 12931, 2281, 2293, 12978, 12932, 2292
16072, 2293, 12978, 12932, 2292, 2304, 12979, 12933, 2303
16073, 2304, 12979, 12933, 2303, 2315, 12980, 12934, 2314
16074, 2315, 12980, 12934, 2314, 2326, 12981, 12935, 2325
16075, 2326, 12981, 12935, 2325, 2337, 12982, 12936, 2336
16076, 2337, 12982, 12936, 2336, 2348, 12983, 12937, 2347
16077, 2348, 12983, 12937, 2347, 2359, 12984, 12938, 2358
16078, 2359, 12984, 12938, 2358, 2370, 12985, 12939, 2369
16079, 2370, 12985, 12939, 2369, 2381, 12986, 12940, 2380
16080, 2381, 12986, 12940, 2380, 2392, 12987, 12941, 2391
16081, 2392, 12987, 12941, 2391, 2403, 12988, 12942, 2402
16082, 2403, 12988, 12942, 2402, 2414, 12989, 12943, 2413
16083, 2414, 12989, 12943, 2413, 2425, 12990, 12944, 2424
16084, 2425, 12990, 12944, 2424, 2436, 12991, 12945, 2435
16085, 2436, 12991, 12945, 2435, 2447, 12992, 12946, 2446
16086, 2447, 12992, 12946, 2446, 2458, 12993, 12947, 2457
16087, 2458, 12993, 12947, 2457, 2469, 12994, 12948, 2468
16088, 2469, 12994, 12948, 2468, 2480, 12995, 12949, 2479
16089, 2480, 12995, 12949, 2479, 2491, 12996, 12950, 2490
16090, 2491, 12996, 12950, 2490, 143, 1982, 1980, 142
16091, 1961, 105, 104, 1959, 12997, 1997, 1996, 12951
16092, 12997, 1997, 1996, 12951, 12998, 2008, 2007, 12952
16093, 12998, 2008, 2007, 12952, 12999, 2019, 2018, 12953
16094, 12999, 2019, 2018, 12953, 13000, 2030, 2029, 12954
16095, 13000, 2030, 2029, 12954, 13001, 2041, 2040, 12955
16096, 13001, 2041, 2040, 12955, 13002, 2052, 2051, 12956
16097, 13002, 2052, 2051, 12956, 13003, 2063, 2062, 12957
16098, 13003, 2063, 2062, 12957, 13004, 2074, 2073, 12958
16099, 13004, 2074, 2073, 12958, 13005, 2085, 2084, 12959
16100, 13005, 2085, 2084, 12959, 13006, 2096, 2095, 12960
16101, 13006, 2096, 2095, 12960, 13007, 2107, 2106, 12961
16102, 13007, 2107, 2106, 12961, 13008, 2118, 2117, 12962
16103, 13008, 2118, 2117, 12962, 13009, 2129, 2128, 12963
16104, 13009, 2129, 2128, 12963, 13010, 2140, 2139, 12964
16105, 13010, 2140, 2139, 12964, 13011, 2151, 2150, 12965
16106, 13011, 2151, 2150, 12965, 13012, 2162, 2161, 12966
16107, 13012, 2162, 2161, 12966, 13013, 2173, 2172, 12967
16108, 13013, 2173, 2172, 12967, 13014, 2184, 2183, 12968
16109, 13014, 2184, 2183, 12968, 13015, 2195, 2194, 12969
16110, 13015, 2195, 2194, 12969, 13016, 2206, 2205, 12970
16111, 13016, 2206, 2205, 12970, 13017, 2217, 2216, 12971
16112, 13017, 2217, 2216, 12971, 13018, 2228, 2227, 12972
16113, 13018, 2228, 2227, 12972, 13019, 2239, 2238, 12973
16114, 13019, 2239, 2238, 12973, 1983, 131, 130, 1981
16115, 1962, 1961, 1959, 1960, 13020, 12997, 12951, 12974
16116, 13020, 12997, 12951, 12974, 13021, 12998, 12952, 12975
16117, 13021, 12998, 12952, 12975, 13022, 12999, 12953, 12976
16118, 13022, 12999, 12953, 12976, 13023, 13000, 12954, 12977
16119, 13023, 13000, 12954, 12977, 13024, 13001, 12955, 12978
16120, 13024, 13001, 12955, 12978, 13025, 13002, 12956, 12979
16121, 13025, 13002, 12956, 12979, 13026, 13003, 12957, 12980
16122, 13026, 13003, 12957, 12980, 13027, 13004, 12958, 12981
16123, 13027, 13004, 12958, 12981, 13028, 13005, 12959, 12982
16124, 13028, 13005, 12959, 12982, 13029, 13006, 12960, 12983
16125, 13029, 13006, 12960, 12983, 13030, 13007, 12961, 12984
16126, 13030, 13007, 12961, 12984, 13031, 13008, 12962, 12985
16127, 13031, 13008, 12962, 12985, 13032, 13009, 12963, 12986
16128, 13032, 13009, 12963, 12986, 13033, 13010, 12964, 12987
16129, 13033, 13010, 12964, 12987, 13034, 13011, 12965, 12988
16130, 13034, 13011, 12965, 12988, 13035, 13012, 12966, 12989
16131, 13035, 13012, 12966, 12989, 13036, 13013, 12967, 12990
16132, 13036, 13013, 12967, 12990, 13037, 13014, 12968, 12991
16133, 13037, 13014, 12968, 12991, 13038, 13015, 12969, 12992
16134, 13038, 13015, 12969, 12992, 13039, 13016, 12970, 12993
16135, 13039, 13016, 12970, 12993, 13040, 13017, 12971, 12994
16136, 13040, 13017, 12971, 12994, 13041, 13018, 12972, 12995
16137, 13041, 13018, 12972, 12995, 13042, 13019, 12973, 12996
16138, 13042, 13019, 12973, 12996, 1984, 1983, 1981, 1982
16139, 118, 1962, 1960, 117, 2250, 13020, 12974, 2249
16140, 2250, 13020, 12974, 2249, 2261, 13021, 12975, 2260
16141, 2261, 13021, 12975, 2260, 2272, 13022, 12976, 2271
16142, 2272, 13022, 12976, 2271, 2283, 13023, 12977, 2282
16143, 2283, 13023, 12977, 2282, 2294, 13024, 12978, 2293
16144, 2294, 13024, 12978, 2293, 2305, 13025, 12979, 2304
16145, 2305, 13025, 12979, 2304, 2316, 13026, 12980, 2315
16146, 2316, 13026, 12980, 2315, 2327, 13027, 12981, 2326
16147, 2327, 13027, 12981, 2326, 2338, 13028, 12982, 2337
16148, 2338, 13028, 12982, 2337, 2349, 13029, 12983, 2348
16149, 2349, 13029, 12983, 2348, 2360, 13030, 12984, 2359
16150, 2360, 13030, 12984, 2359, 2371, 13031, 12985, 2370
16151, 2371, 13031, 12985, 2370, 2382, 13032, 12986, 2381
16152, 2382, 13032, 12986, 2381, 2393, 13033, 12987, 2392
16153, 2393, 13033, 12987, 2392, 2404, 13034, 12988, 2403
16154, 2404, 13034, 12988, 2403, 2415, 13035, 12989, 2414
16155, 2415, 13035, 12989, 2414, 2426, 13036, 12990, 2425
16156, 2426, 13036, 12990, 2425, 2437, 13037, 12991, 2436
16157, 2437, 13037, 12991, 2436, 2448, 13038, 12992, 2447
16158, 2448, 13038, 12992, 2447, 2459, 13039, 12993, 2458
16159, 2459, 13039, 12993, 2458, 2470, 13040, 12994, 2469
16160, 2470, 13040, 12994, 2469, 2481, 13041, 12995, 2480
16161, 2481, 13041, 12995, 2480, 2492, 13042, 12996, 2491
16162, 2492, 13042, 12996, 2491, 144, 1984, 1982, 143
16163, 1963, 106, 105, 1961, 13043, 1998, 1997, 12997
16164, 13043, 1998, 1997, 12997, 13044, 2009, 2008, 12998
16165, 13044, 2009, 2008, 12998, 13045, 2020, 2019, 12999
16166, 13045, 2020, 2019, 12999, 13046, 2031, 2030, 13000
16167, 13046, 2031, 2030, 13000, 13047, 2042, 2041, 13001
16168, 13047, 2042, 2041, 13001, 13048, 2053, 2052, 13002
16169, 13048, 2053, 2052, 13002, 13049, 2064, 2063, 13003
16170, 13049, 2064, 2063, 13003, 13050, 2075, 2074, 13004
16171, 13050, 2075, 2074, 13004, 13051, 2086, 2085, 13005
16172, 13051, 2086, 2085, 13005, 13052, 2097, 2096, 13006
16173, 13052, 2097, 2096, 13006, 13053, 2108, 2107, 13007
16174, 13053, 2108, 2107, 13007, 13054, 2119, 2118, 13008
16175, 13054, 2119, 2118, 13008, 13055, 2130, 2129, 13009
16176, 13055, 2130, 2129, 13009, 13056, 2141, 2140, 13010
16177, 13056, 2141, 2140, 13010, 13057, 2152, 2151, 13011
16178, 13057, 2152, 2151, 13011, 13058, 2163, 2162, 13012
16179, 13058, 2163, 2162, 13012, 13059, 2174, 2173, 13013
16180, 13059, 2174, 2173, 13013, 13060, 2185, 2184, 13014
16181, 13060, 2185, 2184, 13014, 13061, 2196, 2195, 13015
16182, 13061, 2196, 2195, 13015, 13062, 2207, 2206, 13016
16183, 13062, 2207, 2206, 13016, 13063, 2218, 2217, 13017
16184, 13063, 2218, 2217, 13017, 13064, 2229, 2228, 13018
16185, 13064, 2229, 2228, 13018, 13065, 2240, 2239, 13019
16186, 13065, 2240, 2239, 13019, 1985, 132, 131, 1983
16187, 1964, 1963, 1961, 1962, 13066, 13043, 12997, 13020
16188, 13066, 13043, 12997, 13020, 13067, 13044, 12998, 13021
16189, 13067, 13044, 12998, 13021, 13068, 13045, 12999, 13022
16190, 13068, 13045, 12999, 13022, 13069, 13046, 13000, 13023
16191, 13069, 13046, 13000, 13023, 13070, 13047, 13001, 13024
16192, 13070, 13047, 13001, 13024, 13071, 13048, 13002, 13025
16193, 13071, 13048, 13002, 13025, 13072, 13049, 13003, 13026
16194, 13072, 13049, 13003, 13026, 13073, 13050, 13004, 13027
16195, 13073, 13050, 13004, 13027, 13074, 13051, 13005, 13028
16196, 13074, 13051, 13005, 13028, 13075, 13052, 13006, 13029
16197, 13075, 13052, 13006, 13029, 13076, 13053, 13007, 13030
16198, 13076, 13053, 13007, 13030, 13077, 13054, 13008, 13031
16199, 13077, 13054, 13008, 13031, 13078, 13055, 13009, 13032
16200, 13078, 13055, 13009, 13032, 13079, 13056, 13010, 13033
16201, 13079, 13056, 13010, 13033, 13080, 13057, 13011, 13034
16202, 13080, 13057, 13011, 13034, 13081, 13058, 13012, 13035
16203, 13081, 13058, 13012, 13035, 13082, 13059, 13013, 13036
16204, 13082, 13059, 13013, 13036, 13083, 13060, 13014, 13037
16205, 13083, 13060, 13014, 13037, 13084, 13061, 13015, 13038
16206, 13084, 13061, 13015, 13038, 13085, 13062, 13016, 13039
16207, 13085, 13062, 13016, 13039, 13086, 13063, 13017, 13040
16208, 13086, 13063, 13017, 13040, 13087, 13064, 13018, 13041
16209, 13087, 13064, 13018, 13041, 13088, 13065, 13019, 13042
16210, 13088, 13065, 13019, 13042, 1986, 1985, 1983, 1984
16211, 119, 1964, 1962, 118, 2251, 13066, 13020, 2250
16212, 2251, 13066, 13020, 2250, 2262, 13067, 13021, 2261
16213, 2262, 13067, 13021, 2261, 2273, 13068, 13022, 2272
16214, 2273, 13068, 13022, 2272, 2284, 13069, 13023, 2283
16215, 2284, 13069, 13023, 2283, 2295, 13070, 13024, 2294
16216, 2295, 13070, 13024, 2294, 2306, 13071, 13025, 2305
16217, 2306, 13071, 13025, 2305, 2317, 13072, 13026, 2316
16218, 2317, 13072, 13026, 2316, 2328, 13073, 13027, 2327
16219, 2328, 13073, 13027, 2327, 2339, 13074, 13028, 2338
16220, 2339, 13074, 13028, 2338, 2350, 13075, 13029, 2349
16221, 2350, 13075, 13029, 2349, 2361, 13076, 13030, 2360
16222, 2361, 13076, 13030, 2360, 2372, 13077, 13031, 2371
16223, 2372, 13077, 13031, 2371, 2383, 13078, 13032, 2382
16224, 2383, 13078, 13032, 2382, 2394, 13079, 13033, 2393
16225, 2394, 13079, 13033, 2393, 2405, 13080, 13034, 2404
16226, 2405, 13080, 13034, 2404, 2416, 13081, 13035, 2415
16227, 2416, 13081, 13035, 2415, 2427, 13082, 13036, 2426
16228, 2427, 13082, 13036, 2426, 2438, 13083, 13037, 2437
16229, 2438, 13083, 13037, 2437, 2449, 13084, 13038, 2448
16230, 2449, 13084, 13038, 2448, 2460, 13085, 13039, 2459
16231, 2460, 13085, 13039, 2459, 2471, 13086, 13040, 2470
16232, 2471, 13086, 13040, 2470, 2482, 13087, 13041, 2481
16233, 2482, 13087, 13041, 2481, 2493, 13088, 13042, 2492
16234, 2493, 13088, 13042, 2492, 145, 1986, 1984, 144
16235, 1965, 107, 106, 1963, 13089, 1999, 1998, 13043
16236, 13089, 1999, 1998, 13043, 13090, 2010, 2009, 13044
16237, 13090, 2010, 2009, 13044, 13091, 2021, 2020, 13045
16238, 13091, 2021, 2020, 13045, 13092, 2032, 2031, 13046
16239, 13092, 2032, 2031, 13046, 13093, 2043, 2042, 13047
16240, 13093, 2043, 2042, 13047, 13094, 2054, 2053, 13048
16241, 13094, 2054, 2053, 13048, 13095, 2065, 2064, 13049
16242, 13095, 2065, 2064, 13049, 13096, 2076, 2075, 13050
16243, 13096, 2076, 2075, 13050, 13097, 2087, 2086, 13051
16244, 13097, 2087, 2086, 13051, 13098, 2098, 2097, 13052
16245, 13098, 2098, 2097, 13052, 13099, 2109, 2108, 13053
16246, 13099, 2109, 2108, 13053, 13100, 2120, 2119, 13054
16247, 13100, 2120, 2119, 13054, 13101, 2131, 2130, 13055
16248, 13101, 2131, 2130, 13055, 13102, 2142, 2141, 13056
16249, 13102, 2142, 2141, 13056, 13103, 2153, 2152, 13057
16250, 13103, 2153, 2152, 13057, 13104, 2164, 2163, 13058
16251, 13104, 2164, 2163, 13058, 13105, 2175, 2174, 13059
16252, 13105, 2175, 2174, 13059, 13106, 2186, 2185, 13060
16253, 13106, 2186, 2185, 13060, 13107, 2197, 2196, 13061
16254, 13107, 2197, 2196, 13061, 13108, 2208, 2207, 13062
16255, 13108, 2208, 2207, 13062, 13109, 2219, 2218, 13063
16256, 13109, 2219, 2218, 13063, 13110, 2230, 2229, 13064
16257, 13110, 2230, 2229, 13064, 13111, 2241, 2240, 13065
16258, 13111, 2241, 2240, 13065, 1987, 133, 132, 1985
16259, 1966, 1965, 1963, 1964, 13112, 13089, 13043, 13066
16260, 13112, 13089, 13043, 13066, 13113, 13090, 13044, 13067
16261, 13113, 13090, 13044, 13067, 13114, 13091, 13045, 13068
16262, 13114, 13091, 13045, 13068, 13115, 13092, 13046, 13069
16263, 13115, 13092, 13046, 13069, 13116, 13093, 13047, 13070
16264, 13116, 13093, 13047, 13070, 13117, 13094, 13048, 13071
16265, 13117, 13094, 13048, 13071, 13118, 13095, 13049, 13072
16266, 13118, 13095, 13049, 13072, 13119, 13096, 13050, 13073
16267, 13119, 13096, 13050, 13073, 13120, 13097, 13051, 13074
16268, 13120, 13097, 13051, 13074, 13121, 13098, 13052, 13075
16269, 13121, 13098, 13052, 13075, 13122, 13099, 13053, 13076
16270, 13122, 13099, 13053, 13076, 13123, 13100, 13054, 13077
16271, 13123, 13100, 13054, 13077, 13124, 13101, 13055, 13078
16272, 13124, 13101, 13055, 13078, 13125, 13102, 13056, 13079
16273, 13125, 13102, 13056, 13079, 13126, 13103, 13057, 13080
16274, 13126, 13103, 13057, 13080, 13127, 13104, 13058, 13081
16275, 13127, 13104, 13058, 13081, 13128, 13105, 13059, 13082
16276, 13128, 13105, 13059, 13082, 13129, 13106, 13060, 13083
16277, 13129, 13106, 13060, 13083, 13130, 13107, 13061, 13084
16278, 13130, 13107, 13061, 13084, 13131, 13108, 13062, 13085
16279, 13131, 13108, 13062, 13085, 13132, 13109, 13063, 13086
16280, 13132, 13109, 13063, 13086, 13133, 13110, 13064, 13087
16281, 13133, 13110, 13064, 13087, 13134, 13111, 13065, 13088
16282, 13134, 13111, 13065, 13088, 1988, 1987, 1985, 1986
16283, 120, 1966, 1964, 119, 2252, 13112, 13066, 2251
16284, 2252, 13112, 13066, 2251, 2263, 13113, 13067, 2262
16285, 2263, 13113, 13067, 2262, 2274, 13114, 13068, 2273
16286, 2274, 13114, 13068, 2273, 2285, 13115, 13069, 2284
16287, 2285, 13115, 13069, 2284, 2296, 13116, 13070, 2295
16288, 2296, 13116, 13070, 2295, 2307, 13117, 13071, 2306
16289, 2307, 13117, 13071, 2306, 2318, 13118, 13072, 2317
16290, 2318, 13118, 13072, 2317, 2329, 13119, 13073, 2328
16291, 2329, 13119, 13073, 2328, 2340, 13120, 13074, 2339
16292, 2340, 13120, 13074, 2339, 2351, 13121, 13075, 2350
16293, 2351, 13121, 13075, 2350, 2362, 13122, 13076, 2361
16294, 2362, 13122, 13076, 2361, 2373, 13123, 13077, 2372
16295, 2373, 13123, 13077, 2372, 2384, 13124, 13078, 2383
16296, 2384, 13124, 13078, 2383, 2395, 13125, 13079, 2394
16297, 2395, 13125, 13079, 2394, 2406, 13126, 13080, 2405
16298, 2406, 13126, 13080, 2405, 2417, 13127, 13081, 2416
16299, 2417, 13127, 13081, 2416, 2428, 13128, 13082, 2427
16300, 2428, 13128, 13082, 2427, 2439, 13129, 13083, 2438
16301, 2439, 13129, 13083, 2438, 2450, 13130, 13084, 2449
16302, 2450, 13130, 13084, 2449, 2461, 13131, 13085, 2460
16303, 2461, 13131, 13085, 2460, 2472, 13132, 13086, 2471
16304, 2472, 13132, 13086, 2471, 2483, 13133, 13087, 2482
16305, 2483, 13133, 13087, 2482, 2494, 13134, 13088, 2493
16306, 2494, 13134, 13088, 2493, 146, 1988, 1986, 145
16307, 108, 1, 107, 1965, 2541, 172, 1999, 13089
16308, 2541, 172, 1999, 13089, 2542, 173, 2010, 13090
16309, 2542, 173, 2010, 13090, 2543, 174, 2021, 13091
16310, 2543, 174, 2021, 13091, 2544, 175, 2032, 13092
16311, 2544, 175, 2032, 13092, 2545, 176, 2043, 13093
16312, 2545, 176, 2043, 13093, 2546, 177, 2054, 13094
16313, 2546, 177, 2054, 13094, 2547, 178, 2065, 13095
16314, 2547, 178, 2065, 13095, 2548, 179, 2076, 13096
16315, 2548, 179, 2076, 13096, 2549, 180, 2087, 13097
16316, 2549, 180, 2087, 13097, 2550, 181, 2098, 13098
16317, 2550, 181, 2098, 13098, 2551, 182, 2109, 13099
16318, 2551, 182, 2109, 13099, 2552, 183, 2120, 13100
16319, 2552, 183, 2120, 13100, 2553, 184, 2131, 13101
16320, 2553, 184, 2131, 13101, 2554, 185, 2142, 13102
16321, 2554, 185, 2142, 13102, 2555, 186, 2153, 13103
16322, 2555, 186, 2153, 13103, 2556, 187, 2164, 13104
16323, 2556, 187, 2164, 13104, 2557, 188, 2175, 13105
16324, 2557, 188, 2175, 13105, 2558, 189, 2186, 13106
16325, 2558, 189, 2186, 13106, 2559, 190, 2197, 13107
16326, 2559, 190, 2197, 13107, 2560, 191, 2208, 13108
16327, 2560, 191, 2208, 13108, 2561, 192, 2219, 13109
16328, 2561, 192, 2219, 13109, 2562, 193, 2230, 13110
16329, 2562, 193, 2230, 13110, 2563, 194, 2241, 13111
16330, 2563, 194, 2241, 13111, 134, 5, 133, 1987
16331, 109, 108, 1965, 1966, 2564, 2541, 13089, 13112
16332, 2564, 2541, 13089, 13112, 2565, 2542, 13090, 13113
16333, 2565, 2542, 13090, 13113, 2566, 2543, 13091, 13114
16334, 2566, 2543, 13091, 13114, 2567, 2544, 13092, 13115
16335, 2567, 2544, 13092, 13115, 2568, 2545, 13093, 13116
16336, 2568, 2545, 13093, 13116, 2569, 2546, 13094, 13117
16337, 2569, 2546, 13094, 13117, 2570, 2547, 13095, 13118
16338, 2570, 2547, 13095, 13118, 2571, 2548, 13096, 13119
16339, 2571, 2548, 13096, 13119, 2572, 2549, 13097, 13120
16340, 2572, 2549, 13097, 13120, 2573, 2550, 13098, 13121
16341, 2573, 2550, 13098, 13121, 2574, 2551, 13099, 13122
16342, 2574, 2551, 13099, 13122, 2575, 2552, 13100, 13123
16343, 2575, 2552, 13100, 13123, 2576, 2553, 13101, 13124
16344, 2576, 2553, 13101, 13124, 2577, 2554, 13102, 13125
16345, 2577, 2554, 13102, 13125, 2578, 2555, 13103, 13126
16346, 2578, 2555, 13103, 13126, 2579, 2556, 13104, 13127
16347, 2579, 2556, 13104, 13127, 2580, 2557, 13105, 13128
16348, 2580, 2557, 13105, 13128, 2581, 2558, 13106, 13129
16349, 2581, 2558, 13106, 13129, 2582, 2559, 13107, 13130
16350, 2582, 2559, 13107, 13130, 2583, 2560, 13108, 13131
16351, 2583, 2560, 13108, 13131, 2584, 2561, 13109, 13132
16352, 2584, 2561, 13109, 13132, 2585, 2562, 13110, 13133
16353, 2585, 2562, 13110, 13133, 2586, 2563, 13111, 13134
16354, 2586, 2563, 13111, 13134, 135, 134, 1987, 1988
16355, 3, 109, 1966, 120, 218, 2564, 13112, 2252
16356, 218, 2564, 13112, 2252, 219, 2565, 13113, 2263
16357, 219, 2565, 13113, 2263, 220, 2566, 13114, 2274
16358, 220, 2566, 13114, 2274, 221, 2567, 13115, 2285
16359, 221, 2567, 13115, 2285, 222, 2568, 13116, 2296
16360, 222, 2568, 13116, 2296, 223, 2569, 13117, 2307
16361, 223, 2569, 13117, 2307, 224, 2570, 13118, 2318
16362, 224, 2570, 13118, 2318, 225, 2571, 13119, 2329
16363, 225, 2571, 13119, 2329, 226, 2572, 13120, 2340
16364, 226, 2572, 13120, 2340, 227, 2573, 13121, 2351
16365, 227, 2573, 13121, 2351, 228, 2574, 13122, 2362
16366, 228, 2574, 13122, 2362, 229, 2575, 13123, 2373
16367, 229, 2575, 13123, 2373, 230, 2576, 13124, 2384
16368, 230, 2576, 13124, 2384, 231, 2577, 13125, 2395
16369, 231, 2577, 13125, 2395, 232, 2578, 13126, 2406
16370, 232, 2578, 13126, 2406, 233, 2579, 13127, 2417
16371, 233, 2579, 13127, 2417, 234, 2580, 13128, 2428
16372, 234, 2580, 13128, 2428, 235, 2581, 13129, 2439
16373, 235, 2581, 13129, 2439, 236, 2582, 13130, 2450
16374, 236, 2582, 13130, 2450, 237, 2583, 13131, 2461
16375, 237, 2583, 13131, 2461, 238, 2584, 13132, 2472
16376, 238, 2584, 13132, 2472, 239, 2585, 13133, 2483
16377, 239, 2585, 13133, 2483, 240, 2586, 13134, 2494
16378, 240, 2586, 13134, 2494, 7, 135, 1988, 146
*ELEMENT, type=C3D8, ELSET=Volume2
16379, 4, 110, 2242, 195, 10, 298, 2587, 241
16380, 110, 111, 2243, 2242, 298, 299, 2588, 2587
16381, 111, 112, 2244, 2243, 299, 300, 2589, 2588
16382, 112, 113, 2245, 2244, 300, 301, 2590, 2589
16383, 113, 114, 2246, 2245, 301, 302, 2591, 2590
16384, 114, 115, 2247, 2246, 302, 303, 2592, 2591
16385, 115, 116, 2248, 2247, 303, 304, 2593, 2592
16386, 116, 117, 2249, 2248, 304, 305, 2594, 2593
16387, 117, 118, 2250, 2249, 305, 306, 2595, 2594
16388, 118, 119, 2251, 2250, 306, 307, 2596, 2595
16389, 119, 120, 2252, 2251, 307, 308, 2597, 2596
16390, 120, 3, 218, 2252, 308, 12, 275, 2597
16391, 195, 2242, 2253, 196, 241, 2587, 2598, 242
16392, 2242, 2243, 2254, 2253, 2587, 2588, 2599, 2598
16393, 2243, 2244, 2255, 2254, 2588, 2589, 2600, 2599
16394, 2244, 2245, 2256, 2255, 2589, 2590, 2601, 2600
16395, 2245, 2246, 2257, 2256, 2590, 2591, 2602, 2601
16396, 2246, 2247, 2258, 2257, 2591, 2592, 2603, 2602
16397, 2247, 2248, 2259, 2258, 2592, 2593, 2604, 2603
16398, 2248, 2249, 2260, 2259, 2593, 2594, 2605, 2604
16399, 2249, 2250, 2261, 2260, 2594, 2595, 2606, 2605
16400, 2250, 2251, 2262, 2261, 2595, 2596, 2607, 2606
16401, 2251, 2252, 2263, 2262, 2596, 2597, 2608, 2607
16402, 2252, 218, 219, 2263, 2597, 275, 276, 2608
16403, 196, 2253, 2264, 197, 242, 2598, 2609, 243
16404, 2253, 2254, 2265, 2264, 2598, 2599, 2610, 2609
16405, 2254, 2255, 2266, 2265, 2599, 2600, 2611, 2610
16406, 2255, 2256, 2267, 2266, 2600, 2601, 2612, 2611
16407, 2256, 2257, 2268, 2267, 2601, 2602, 2613, 2612
16408, 2257, 2258, 2269, 2268, 2602, 2603, 2614, 2613
16409, 2258, 2259, 2270, 2269, 2603, 2604, 2615, 2614
16410, 2259, 2260, 2271, 2270, 2604, 2605, 2616, 2615
16411, 2260, 2261, 2272, 2271, 2605, 2606, 2617, 2616
16412, 2261, 2262, 2273, 2272, 2606, 2607, 2618, 2617
16413, 2262, 2263, 2274, 2273, 2607, 2608, 2619, 2618
16414, 2263, 219, 220, 2274, 2608, 276, 277, 2619
16415, 197, 2264, 2275, 198, 243, 2609, 2620, 244
16416, 2264, 2265, 2276, 2275, 2609, 2610, 2621, 2620
16417, 2265, 2266, 2277, 2276, 2610, 2611, 2622, 2621
16418, 2266, 2267, 2278, 2277, 2611, 2612, 2623, 2622
16419, 2267, 2268, 2279, 2278, 2612, 2613, 2624, 2623
16420, 2268, 2269, 2280, 2279, 2613, 2614, 2625, 2624
16421, 2269, 2270, 2281, 2280, 2614, 2615, 2626, 2625
16422, 2270, 2271, 2282, 2281, 2615, 2616, 2627, 2626
16423, 2271, 2272, 2283, 2282, 2616, 2617, 2628, 2627
16424, 2272, 2273, 2284, 2283, 2617, 2618, 2629, 2628
16425, 2273, 2274, 2285, 2284, 2618, 2619, 2630, 2629
16426, 2274, 220, 221, 2285, 2619, 277, 278, 2630
16427, 198, 2275, 2286, 199, 244, 2620, 2631, 245
16428, 2275, 2276, 2287, 2286, 2620, 2621, 2632, 2631
16429, 2276, 2277, 2288, 2287, 2621, 2622, 2633, 2632
16430, 2277, 2278, 2289, 2288, 2622, 2623, 2634, 2633
16431, 2278, 2279, 2290, 2289, 2623, 2624, 2635, 2634
16432, 2279, 2280, 2291, 2290, 2624, 2625, 2636, 2635
16433, 2280, 2281, 2292, 2291, 2625, 2626, 2637, 2636
16434, 2281, 2282, 2293, 2292, 2626, 2627, 2638, 2637
16435, 2282, 2283, 2294, 2293, 2627, 2628, 2639, 2638
16436, 2283, 2284, 2295, 2294, 2628, 2629, 2640, 2639
16437, 2284, 2285, 2296, 2295, 2629, 2630, 2641, 2640
16438, 2285, 221, 222, 2296, 2630, 278, 279, 2641
16439, 199, 2286, 2297, 200, 245, 2631, 2642, 246
16440, 2286, 2287, 2298, 2297, 2631, 2632, 2643, 2642
16441, 2287, 2288, 2299, 2298, 2632, 2633, 2644, 2643
16442, 2288, 2289, 2300, 2299, 2633, 2634, 2645, 2644
16443, 2289, 2290, 2301, 2300, 2634, 2635, 2646, 2645
16444, 2290, 2291, 2302, 2301, 2635, 2636, 2647, 2646
16445, 2291, 2292, 2303, 2302, 2636, 2637, 2648, 2647
16446, 2292, 2293, 2304, 2303, 2637, 2638, 2649, 2648
16447, 2293, 2294, 2305, 2304, 2638, 2639, 2650, 2649
16448, 2294, 2295, 2306, 2305, 2639, 2640, 2651, 2650
16449, 2295, 2296, 2307, 2306, 2640, 2641, 2652, 2651
16450, 2296, 222, 223, 2307, 2641, 279, 280, 2652
16451, 200, 2297, 2308, 201, 246, 2642, 2653, 247
16452, 2297, 2298, 2309, 2308, 2642, 2643, 2654, 2653
16453, 2298, 2299, 2310, 2309, 2643, 2644, 2655, 2654
16454, 2299, 2300, 2311, 2310, 2644, 2645, 2656, 2655
16455, 2300, 2301, 2312, 2311, 2645, 2646, 2657, 2656
16456, 2301, 2302, 2313, 2312, 2646, 2647, 2658, 2657
16457, 2302, 2303, 2314, 2313, 2647, 2648, 2659, 2658
16458, 2303, 2304, 2315, 2314, 2648, 2649, 2660, 2659
16459, 2304, 2305, 2316, 2315, 2649, 2650, 2661, 2660
16460, 2305, 2306, 2317, 2316, 2650, 2651, 2662, 2661
16461, 2306, 2307, 2318, 2317, 2651, 2652, 2663, 2662
16462, 2307, 223, 224, 2318, 2652, 280, 281, 2663
16463, 201, 2308, 2319, 202, 247, 2653, 2664, 248
16464, 2308, 2309, 2320, 2319, 2653, 2654, 2665, 2664
16465, 2309, 2310, 2321, 2320, 2654, 2655, 2666, 2665
16466, 2310, 2311, 2322, 2321, 2655, 2656, 2667, 2666
16467, 2311, 2312, 2323, 2322, 2656, 2657, 2668, 2667
16468, 2312, 2313, 2324, 2323, 2657, 2658, 2669, 2668
16469, 2313, 2314, 2325, 2324, 2658, 2659, 2670, 2669
16470, 2314, 2315, 2326, 2325, 2659, 2660, 2671, 2670
16471, 2315, 2316, 2327, 2326, 2660, 2661, 2672, 2671
16472, 2316, 2317, 2328, 2327, 2661, 2662, 2673, 2672
16473, 2317, 2318, 2329, 2328, 2662, 2663, 2674, 2673
16474, 2318, 224, 225, 2329, 2663, 281, 282, 2674
16475, 202, 2319, 2330, 203, 248, 2664, 2675, 249
16476, 2319, 2320, 2331, 2330, 2664, 2665, 2676, 2675
16477, 2320, 2321, 2332, 2331, 2665, 2666, 2677, 2676
16478, 2321, 2322, 2333, 2332, 2666, 2667, 2678, 2677
16479, 2322, 2323, 2334, 2333, 2667, 2668, 2679, 2678
16480, 2323, 2324, 2335, 2334, 2668, 2669, 2680, 2679
16481, 2324, 2325, 2336, 2335, 2669, 2670, 2681, 2680
16482, 2325, 2326, 2337, 2336, 2670, 2671, 2682, 2681
16483, 2326, 2327, 2338, 2337, 2671, 2672, 2683, 2682
16484, 2327, 2328, 2339, 2338, 2672, 2673, 2684, 2683
16485, 2328, 2329, 2340, 2339, 2673, 2674, 2685, 2684
16486, 2329, 225, 226, 2340, 2674, 282, 283, 2685
16487, 203, 2330, 2341, 204, 249, 2675, 2686, 250
16488, 2330, 2331, 2342, 2341, 2675, 2676, 2687, 2686
16489, 2331, 2332, 2343, 2342, 2676, 2677, 2688, 2687
16490, 2332, 2333, 2344, 2343, 2677, 2678, 2689, 2688
16491, 2333, 2334, 2345, 2344, 2678, 2679, 2690, 2689
16492, 2334, 2335, 2346, 2345, 2679, 2680, 2691, 2690
16493, 2335, 2336, 2347, 2346, 2680, 2681, 2692, 2691
16494, 2336, 2337, 2348, 2347, 2681, 2682, 2693, 2692
16495, 2337, 2338, 2349, 2348, 2682, 2683, 2694, 2693
16496, 2338, 2339, 2350, 2349, 2683, 2684, 2695, 2694
16497, 2339, 2340, 2351, 2350, 2684, 2685, 2696, 2695
16498, 2340, 226, 227, 2351, 2685, 283, 284, 2696
16499, 204, 2341, 2352, 205, 250, 2686, 2697, 251
16500, 2341, 2342, 2353, 2352, 2686, 2687, 2698, 2697
16501, 2342, 2343, 2354, 2353, 2687, 2688, 2699, 2698
16502, 2343, 2344, 2355, 2354, 2688, 2689, 2700, 2699
16503, 2344, 2345, 2356, 2355, 2689, 2690, 2701, 2700
16504, 2345, 2346, 2357, 2356, 2690, 2691, 2702, 2701
16505, 2346, 2347, 2358, 2357, 2691, 2692, 2703, 2702
16506, 2347, 2348, 2359, 2358, 2692, 2693, 2704, 2703
16507, 2348, 2349, 2360, 2359, 2693, 2694, 2705, 2704
16508, 2349, 2350, 2361, 2360, 2694, 2695, 2706, 2705
16509, 2350, 2351, 2362, 2361, 2695, 2696, 2707, 2706
16510, 2351, 227, 228, 2362, 2696, 284, 285, 2707
16511, 205, 2352, 2363, 206, 251, 2697, 2708, 252
16512, 2352, 2353, 2364, 2363, 2697, 2698, 2709, 2708
16513, 2353, 2354, 2365, 2364, 2698, 2699, 2710, 2709
16514, 2354, 2355, 2366, 2365, 2699, 2700, 2711, 2710
16515, 2355, 2356, 2367, 2366, 2700, 2701, 2712, 2711
16516, 2356, 2357, 2368, 2367, 2701, 2702, 2713, 2712
16517, 2357, 2358, 2369, 2368, 2702, 2703, 2714, 2713
16518, 2358, 2359, 2370, 2369, 2703, 2704, 2715, 2714
16519, 2359, 2360, 2371, 2370, 2704, 2705, 2716, 2715
16520, 2360, 2361, 2372, 2371, 2705, 2706, 2717, 2716
16521, 2361, 2362, 2373, 2372, 2706, 2707, 2718, 2717
16522, 2362, 228, 229, 2373, 2707, 285, 286, 2718
16523, 206, 2363, 2374, 207, 252, 2708, 2719, 253
16524, 2363, 2364, 2375, 2374, 2708, 2709, 2720, 2719
16525, 2364, 2365, 2376, 2375, 2709, 2710, 2721, 2720
16526, 2365, 2366, 2377, 2376, 2710, 2711, 2722, 2721
16527, 2366, 2367, 2378, 2377, 2711, 2712, 2723, 2722
16528, 2367, 2368, 2379, 2378, 2712, 2713, 2724, 2723
16529, 2368, 2369, 2380, 2379, 2713, 2714, 2725, 2724
16530, 2369, 2370, 2381, 2380, 2714, 2715, 2726, 2725
16531, 2370, 2371, 2382, 2381, 2715, 2716, 2727, 2726
16532, 2371, 2372, 2383, 2382, 2716, 2717, 2728, 2727
16533, 2372, 2373, 2384, 2383, 2717, 2718, 2729, 2728
16534, 2373, 229, 230, 2384, 2718, 286, 287, 2729
16535, 207, 2374, 2385, 208, 253, 2719, 2730, 254
16536, 2374, 2375, 2386, 2385, 2719, 2720, 2731, 2730
16537, 2375, 2376, 2387, 2386, 2720, 2721, 2732, 2731
16538, 2376, 2377, 2388, 2387, 2721, 2722, 2733, 2732
16539, 2377, 2378, 2389, 2388, 2722, 2723, 2734, 2733
16540, 2378, 2379, 2390, 2389, 2723, 2724, 2735, 2734
16541, 2379, 2380, 2391, 2390, 2724, 2725, 2736, 2735
16542, 2380, 2381, 2392, 2391, 2725, 2726, 2737, 2736
16543, 2381, 2382, 2393, 2392, 2726, 2727, 2738, 2737
16544, 2382, 2383, 2394, 2393, 2727, 2728, 2739, 2738
16545, 2383, 2384, 2395, 2394, 2728, 2729, 2740, 2739
16546, 2384, 230, 231, 2395, 2729, 287, 288, 2740
16547, 208, 2385, 2396, 209, 254, 2730, 2741, 255
16548, 2385, 2386, 2397, 2396, 2730, 2731, 2742, 2741
16549, 2386, 2387, 2398, 2397, 2731, 2732, 2743, 2742
16550, 2387, 2388, 2399, 2398, 2732, 2733, 2744, 2743
16551, 2388, 2389, 2400, 2399, 2733, 2734, 2745, 2744
16552, 2389, 2390, 2401, 2400, 2734, 2735, 2746, 2745
16553, 2390, 2391, 2402, 2401, 2735, 2736, 2747, 2746
16554, 2391, 2392, 2403, 2402, 2736, 2737, 2748, 2747
16555, 2392, 2393, 2404, 2403, 2737, 2738, 2749, 2748
16556, 2393, 2394, 2405, 2404, 2738, 2739, 2750, 2749
16557, 2394, 2395, 2406, 2405, 2739, 2740, 2751, 2750
16558, 2395, 231, 232, 2406, 2740, 288, 289, 2751
16559, 209, 2396, 2407, 210, 255, 2741, 2752, 256
16560, 2396, 2397, 2408, 2407, 2741, 2742, 2753, 2752
16561, 2397, 2398, 2409, 2408, 2742, 2743, 2754, 2753
16562, 2398, 2399, 2410, 2409, 2743, 2744, 2755, 2754
16563, 2399, 2400, 2411, 2410, 2744, 2745, 2756, 2755
16564, 2400, 2401, 2412, 2411, 2745, 2746, 2757, 2756
16565, 2401, 2402, 2413, 2412, 2746, 2747, 2758, 2757
16566, 2402, 2403, 2414, 2413, 2747, 2748, 2759, 2758
16567, 2403, 2404, 2415, 2414, 2748, 2749, 2760, 2759
16568, 2404, 2405, 2416, 2415, 2749, 2750, 2761, 2760
16569, 2405, 2406, 2417, 2416, 2750, 2751, 2762, 2761
16570, 2406, 232, 233, 2417, 2751, 289, 290, 2762
16571, 210, 2407, 2418, 211, 256, 2752, 2763, 257
16572, 2407, 2408, 2419, 2418, 2752, 2753, 2764, 2763
16573, 2408, 2409, 2420, 2419, 2753, 2754, 2765, 2764
16574, 2409, 2410, 2421, 2420, 2754, 2755, 2766, 2765
16575, 2410, 2411, 2422, 2421, 2755, 2756, 2767, 2766
16576, 2411, 2412, 2423, 2422, 2756, 2757, 2768, 2767
16577, 2412, 2413, 2424, 2423, 2757, 2758, 2769, 2768
16578, 2413, 2414, 2425, 2424, 2758, 2759, 2770, 2769
16579, 2414, 2415, 2426, 2425, 2759, 2760, 2771, 2770
16580, 2415, 2416, 2427, 2426, 2760, 2761, 2772, 2771
16581, 2416, 2417, 2428, 2427, 2761, 2762, 2773, 2772
16582, 2417, 233, 234, 2428, 2762, 290, 291, 2773
16583, 211, 2418, 2429, 212, 257, 2763, 2774, 258
16584, 2418, 2419, 2430, 2429, 2763, 2764, 2775, 2774
16585, 2419, 2420, 2431, 2430, 2764, 2765, 2776, 2775
16586, 2420, 2421, 2432, 2431, 2765, 2766, 2777, 2776
16587, 2421, 2422, 2433, 2432, 2766, 2767, 2778, 2777
16588, 2422, 2423, 2434, 2433, 2767, 2768, 2779, 2778
16589, 2423, 2424, 2435, 2434, 2768, 2769, 2780, 2779
16590, 2424, 2425, 2436, 2435, 2769, 2770, 2781, 2780
16591, 2425, 2426, 2437, 2436, 2770, 2771, 2782, 2781
16592, 2426, 2427, 2438, 2437, 2771, 2772, 2783, 2782
16593, 2427, 2428, 2439, 2438, 2772, 2773, 2784, 2783
16594, 2428, 234, 235, 2439, 2773, 291, 292, 2784
16595, 212, 2429, 2440, 213, 258, 2774, 2785, 259
16596, 2429, 2430, 2441, 2440, 2774, 2775, 2786, 2785
16597, 2430, 2431, 2442, 2441, 2775, 2776, 2787, 2786
16598, 2431, 2432, 2443, 2442, 2776, 2777, 2788, 2787
16599, 2432, 2433, 2444, 2443, 2777, 2778, 2789, 2788
16600, 2433, 2434, 2445, 2444, 2778, 2779, 2790, 2789
16601, 2434, 2435, 2446, 2445, 2779, 2780, 2791, 2790
16602, 2435, 2436, 2447, 2446, 2780, 2781, 2792, 2791
16603, 2436, 2437, 2448, 2447, 2781, 2782, 2793, 2792
16604, 2437, 2438, 2449, 2448, 2782, 2783, 2794, 2793
16605, 2438, 2439, 2450, 2449, 2783, 2784, 2795, 2794
16606, 2439, 235, 236, 2450, 2784, 292, 293, 2795
16607, 213, 2440, 2451, 214, 259, 2785, 2796, 260
16608, 2440, 2441, 2452, 2451, 2785, 2786, 2797, 2796
16609, 2441, 2442, 2453, 2452, 2786, 2787, 2798, 2797
16610, 2442, 2443, 2454, 2453, 2787, 2788, 2799, 2798
16611, 2443, 2444, 2455, 2454, 2788, 2789, 2800, 2799
16612, 2444, 2445, 2456, 2455, 2789, 2790, 2801, 2800
16613, 2445, 2446, 2457, 2456, 2790, 2791, 2802, 2801
16614, 2446, 2447, 2458, 2457, 2791, 2792, 2803, 2802
16615, 2447, 2448, 2459, 2458, 2792, 2793, 2804, 2803
16616, 2448, 2449, 2460, 2459, 2793, 2794, 2805, 2804
16617, 2449, 2450, 2461, 2460, 2794, 2795, 2806, 2805
16618, 2450, 236, 237, 2461, 2795, 293, 294, 2806
16619, 214, 2451, 2462, 215, 260, 2796, 2807, 261
16620, 2451, 2452, 2463, 2462, 2796, 2797, 2808, 2807
16621, 2452, 2453, 2464, 2463, 2797, 2798, 2809, 2808
16622, 2453, 2454, 2465, 2464, 2798, 2799, 2810, 2809
16623, 2454, 2455, 2466, 2465, 2799, 2800, 2811, 2810
16624, 2455, 2456, 2467, 2466, 2800, 2801, 2812, 2811
16625, 2456, 2457, 2468, 2467, 2801, 2802, 2813, 2812
16626, 2457, 2458, 2469, 2468, 2802, 2803, 2814, 2813
16627, 2458, 2459, 2470, 2469, 2803, 2804, 2815, 2814
16628, 2459, 2460, 2471, 2470, 2804, 2805, 2816, 2815
16629, 2460, 2461, 2472, 2471, 2805, 2806, 2817, 2816
16630, 2461, 237, 238, 2472, 2806, 294, 295, 2817
16631, 215, 2462, 2473, 216, 261, 2807, 2818, 262
16632, 2462, 2463, 2474, 2473, 2807, 2808, 2819, 2818
16633, 2463, 2464, 2475, 2474, 2808, 2809, 2820, 2819
16634, 2464, 2465, 2476, 2475, 2809, 2810, 2821, 2820
16635, 2465, 2466, 2477, 2476, 2810, 2811, 2822, 2821
16636, 2466, 2467, 2478, 2477, 2811, 2812, 2823, 2822
16637, 2467, 2468, 2479, 2478, 2812, 2813, 2824, 2823
16638, 2468, 2469, 2480, 2479, 2813, 2814, 2825, 2824
16639, 2469, 2470, 2481, 2480, 2814, 2815, 2826, 2825
16640, 2470, 2471, 2482, 2481, 2815, 2816, 2827, 2826
16641, 2471, 2472, 2483, 2482, 2816, 2817, 2828, 2827
16642, 2472, 238, 239, 2483, 2817, 295, 296, 2828
16643, 216, 2473, 2484, 217, 262, 2818, 2829, 263
16644, 2473, 2474, 2485, 2484, 2818, 2819, 2830, 2829
16645, 2474, 2475, 2486, 2485, 2819, 2820, 2831, 2830
16646, 2475, 2476, 2487, 2486, 2820, 2821, 2832, 2831
16647, 2476, 2477, 2488, 2487, 2821, 2822, 2833, 2832
16648, 2477, 2478, 2489, 2488, 2822, 2823, 2834, 2833
16649, 2478, 2479, 2490, 2489, 2823, 2824, 2835, 2834
16650, 2479, 2480, 2491, 2490, 2824, 2825, 2836, 2835
16651, 2480, 2481, 2492, 2491, 2825, 2826, 2837, 2836
16652, 2481, 2482, 2493, 2492, 2826, 2827, 2838, 2837
16653, 2482, 2483, 2494, 2493, 2827, 2828, 2839, 2838
16654, 2483, 239, 240, 2494, 2828, 296, 297, 2839
16655, 217, 2484, 136, 8, 263, 2829, 264, 9
16656, 2484, 2485, 137, 136, 2829, 2830, 265, 264
16657, 2485, 2486, 138, 137, 2830, 2831, 266, 265
16658, 2486, 2487, 139, 138, 2831, 2832, 267, 266
16659, 2487, 2488, 140, 139, 2832, 2833, 268, 267
16660, 2488, 2489, 141, 140, 2833, 2834, 269, 268
16661, 2489, 2490, 142, 141, 2834, 2835, 270, 269
16662, 2490, 2491, 143, 142, 2835, 2836, 271, 270
16663, 2491, 2492, 144, 143, 2836, 2837, 272, 271
16664, 2492, 2493, 145, 144, 2837, 2838, 273, 272
16665, 2493, 2494, 146, 145, 2838, 2839, 274, 273
16666, 2494, 240, 7, 146, 2839, 297, 11, 274
*ELEMENT, type=C3D8, ELSET=Volume3
16667, 10, 298, 2587, 241, 332, 4151, 13135, 2840
16668, 332, 4151, 13135, 2840, 333, 4152, 13136, 2841
16669, 333, 4152, 13136, 2841, 334, 4153, 13137, 2842
16670, 334, 4153, 13137, 2842, 335, 4154, 13138, 2843
16671, 335, 4154, 13138, 2843, 336, 4155, 13139, 2844
16672, 336, 4155, 13139, 2844, 337, 4156, 13140, 2845
16673, 337, 4156, 13140, 2845, 338, 4157, 13141, 2846
16674, 338, 4157, 13141, 2846, 339, 4158, 13142, 2847
16675, 339, 4158, 13142, 2847, 340, 4159, 13143, 2848
16676, 340, 4159, 13143, 2848, 341, 4160, 13144, 2849
16677, 341, 4160, 13144, 2849, 342, 4161, 13145, 2850
16678, 342, 4161, 13145, 2850, 343, 4162, 13146, 2851
16679, 343, 4162, 13146, 2851, 344, 4163, 13147, 2852
16680, 344, 4163, 13147, 2852, 345, 4164, 13148, 2853
16681, 345, 4164, 13148, 2853, 346, 4165, 13149, 2854
16682, 346, 4165, 13149, 2854, 347, 4166, 13150, 2855
16683, 347, 4166, 13150, 2855, 348, 4167, 13151, 2856
16684, 348, 4167, 13151, 2856, 349, 4168, 13152, 2857
16685, 349, 4168, 13152, 2857, 350, 4169, 13153, 2858
16686, 350, 4169, 13153, 2858, 351, 4170, 13154, 2859
16687, 351, 4170, 13154, 2859, 352, 4171, 13155, 2860
16688, 352, 4171, 13155, 2860, 353, 4172, 13156, 2861
16689, 353, 4172, 13156, 2861, 354, 4173, 13157, 2862
16690, 354, 4173, 13157, 2862, 14, 458, 4404, 355
16691, 298, 299, 2588, 2587, 4151, 4174, 13158, 13135
16692, 4151, 4174, 13158, 13135, 4152, 4175, 13159, 13136
16693, 4152, 4175, 13159, 13136, 4153, 4176, 13160, 13137
16694, 4153, 4176, 13160, 13137, 4154, 4177, 13161, 13138
16695, 4154, 4177, 13161, 13138, 4155, 4178, 13162, 13139
16696, 4155, 4178, 13162, 13139, 4156, 4179, 13163, 13140
16697, 4156, 4179, 13163, 13140, 4157, 4180, 13164, 13141
16698, 4157, 4180, 13164, 13141, 4158, 4181, 13165, 13142
16699, 4158, 4181, 13165, 13142, 4159, 4182, 13166, 13143
16700, 4159, 4182, 13166, 13143, 4160, 4183, 13167, 13144
16701, 4160, 4183, 13167, 13144, 4161, 4184, 13168, 13145
16702, 4161, 4184, 13168, 13145, 4162, 4185, 13169, 13146
16703, 4162, 4185, 13169, 13146, 4163, 4186, 13170, 13147
16704, 4163, 4186, 13170, 13147, 4164, 4187, 13171, 13148
16705, 4164, 4187, 13171, 13148, 4165, 4188, 13172, 13149
16706, 4165, 4188, 13172, 13149, 4166, 4189, 13173, 13150
16707, 4166, 4189, 13173, 13150, 4167, 4190, 13174, 13151
16708, 4167, 4190, 13174, 13151, 4168, 4191, 13175, 13152
16709, 4168, 4191, 13175, 13152, 4169, 4192, 13176, 13153
16710, 4169, 4192, 13176, 13153, 4170, 4193, 13177, 13154
16711, 4170, 4193, 13177, 13154, 4171, 4194, 13178, 13155
16712, 4171, 4194, 13178, 13155, 4172, 4195, 13179, 13156
16713, 4172, 4195, 13179, 13156, 4173, 4196, 13180, 13157
16714, 4173, 4196, 13180, 13157, 458, 459, 4405, 4404
16715, 299, 300, 2589, 2588, 4174, 4197, 13181, 13158
16716, 4174, 4197, 13181, 13158, 4175, 4198, 13182, 13159
16717, 4175, 4198, 13182, 13159, 4176, 4199, 13183, 13160
16718, 4176, 4199, 13183, 13160, 4177, 4200, 13184, 13161
16719, 4177, 4200, 13184, 13161, 4178, 4201, 13185, 13162
16720, 4178, 4201, 13185, 13162, 4179, 4202, 13186, 13163
16721, 4179, 4202, 13186, 13163, 4180, 4203, 13187, 13164
16722, 4180, 4203, 13187, 13164, 4181, 4204, 13188, 13165
16723, 4181, 4204, 13188, 13165, 4182, 4205, 13189, 13166
16724, 4182, 4205, 13189, 13166, 4183, 4206, 13190, 13167
16725, 4183, 4206, 13190, 13167, 4184, 4207, 13191, 13168
16726, 4184, 4207, 13191, 13168, 4185, 4208, 13192, 13169
16727, 4185, 4208, 13192, 13169, 4186, 4209, 13193, 13170
16728, 4186, 4209, 13193, 13170, 4187, 4210, 13194, 13171
16729, 4187, 4210, 13194, 13171, 4188, 4211, 13195, 13172
16730, 4188, 4211, 13195, 13172, 4189, 4212, 13196, 13173
16731, 4189, 4212, 13196, 13173, 4190, 4213, 13197, 13174
16732, 4190, 4213, 13197, 13174, 4191, 4214, 13198, 13175
16733, 4191, 4214, 13198, 13175, 4192, 4215, 13199, 13176
16734, 4192, 4215, 13199, 13176, 4193, 4216, 13200, 13177
16735, 4193, 4216, 13200, 13177, 4194, 4217, 13201, 13178
16736, 4194, 4217, 13201, 13178, 4195, 4218, 13202, 13179
16737, 4195, 4218, 13202, 13179, 4196, 4219, 13203, 13180
16738, 4196, 4219, 13203, 13180, 459, 460, 4406, 4405
16739, 300, 301, 2590, 2589, 4197, 4220, 13204, 13181
16740, 4197, 4220, 13204, 13181, 4198, 4221, 13205, 13182
16741, 4198, 4221, 13205, 13182, 4199, 4222, 13206, 13183
16742, 4199, 4222, 13206, 13183, 4200, 4223, 13207, 13184
16743, 4200, 4223, 13207, 13184, 4201, 4224, 13208, 13185
16744, 4201, 4224, 13208, 13185, 4202, 4225, 13209, 13186
16745, 4202, 4225, 13209, 13186, 4203, 4226, 13210, 13187
16746, 4203, 4226, 13210, 13187, 4204, 4227, 13211, 13188
16747, 4204, 4227, 13211, 13188, 4205, 4228, 13212, 13189
16748, 4205, 4228, 13212, 13189, 4206, 4229, 13213, 13190
16749, 4206, 4229, 13213, 13190, 4207, 4230, 13214, 13191
16750, 4207, 4230, 13214, 13191, 4208, 4231, 13215, 13192
16751, 4208, 4231, 13215, 13192, 4209, 4232, 13216, 13193
16752, 4209, 4232, 13216, 13193, 4210, 4233, 13217, 13194
16753, 4210, 4233, 13217, 13194, 4211, 4234, 13218, 13195
16754, 4211, 4234, 13218, 13195, 4212, 4235, 13219, 13196
16755, 4212, 4235, 13219, 13196, 4213, 4236, 13220, 13197
16756, 4213, 4236, 13220, 13197, 4214, 4237, 13221, 13198
16757, 4214, 4237, 13221, 13198, 4215, 4238, 13222, 13199
16758, 4215, 4238, 13222, 13199, 4216, 4239, 13223, 13200
16759, 4216, 4239, 13223, 13200, 4217, 4240, 13224, 13201
16760, 4217, 4240, 13224, 13201, 4218, 4241, 13225, 13202
16761, 4218, 4241, 13225, 13202, 4219, 4242, 13226, 13203
16762, 4219, 4242, 13226, 13203, 460, 461, 4407, 4406
16763, 301, 302, 2591, 2590, 4220, 4243, 13227, 13204
16764, 4220, 4243, 13227, 13204, 4221, 4244, 13228, 13205
16765, 4221, 4244, 13228, 13205, 4222, 4245, 13229, 13206
16766, 4222, 4245, 13229, 13206, 4223, 4246, 13230, 13207
16767, 4223, 4246, 13230, 13207, 4224, 4247, 13231, 13208
16768, 4224, 4247, 13231, 13208, 4225, 4248, 13232, 13209
16769, 4225, 4248, 13232, 13209, 4226, 4249, 13233, 13210
16770, 4226, 4249, 13233, 13210, 4227, 4250, 13234, 13211
16771, 4227, 4250, 13234, 13211, 4228, 4251, 13235, 13212
16772, 4228, 4251, 13235, 13212, 4229, 4252, 13236, 13213
16773, 4229, 4252, 13236, 13213, 4230, 4253, 13237, 13214
16774, 4230, 4253, 13237, 13214, 4231, 4254, 13238, 13215
16775, 4231, 4254, 13238, 13215, 4232, 4255, 13239, 13216
16776, 4232, 4255, 13239, 13216, 4233, 4256, 13240, 13217
16777, 4233, 4256, 13240, 13217, 4234, 4257, 13241, 13218
16778, 4234, 4257, 13241, 13218, 4235, 4258, 13242, 13219
16779, 4235, 4258, 13242, 13219, 4236, 4259, 13243, 13220
16780, 4236, 4259, 13243, 13220, 4237, 4260, 13244, 13221
16781, 4237, 4260, 13244, 13221, 4238, 4261, 13245, 13222
16782, 4238, 4261, 13245, 13222, 4239, 4262, 13246, 13223
16783, 4239, 4262, 13246, 13223, 4240, 4263, 13247, 13224
16784, 4240, 4263, 13247, 13224, 4241, 4264, 13248, 13225
16785, 4241, 4264, 13248, 13225, 4242, 4265, 13249, 13226
16786, 4242, 4265, 13249, 13226, 461, 462, 4408, 4407
16787, 302, 303, 2592, 2591, 4243, 4266, 13250, 13227
16788, 4243, 4266, 13250, 13227, 4244, 4267, 13251, 13228
16789, 4244, 4267, 13251, 13228, 4245, 4268, 13252, 13229
16790, 4245, 4268, 13252, 13229, 4246, 4269, 13253, 13230
16791, 4246, 4269, 13253, 13230, 4247, 4270, 13254, 13231
16792, 4247, 4270, 13254, 13231, 4248, 4271, 13255, 13232
16793, 4248, 4271, 13255, 13232, 4249, 4272, 13256, 13233
16794, 4249, 4272, 13256, 13233, 4250, 4273, 13257, 13234
16795, 4250, 4273, 13257, 13234, 4251, 4274, 13258, 13235
16796, 4251, 4274, 13258, 13235, 4252, 4275, 13259, 13236
16797, 4252, 4275, 13259, 13236, 4253, 4276, 13260, 13237
16798, 4253, 4276, 13260, 13237, 4254, 4277, 13261, 13238
16799, 4254, 4277, 13261, 13238, 4255, 4278, 13262, 13239
16800, 4255, 4278, 13262, 13239, 4256, 4279, 13263, 13240
16801, 4256, 4279, 13263, 13240, 4257, 4280, 13264, 13241
16802, 4257, 4280, 13264, 13241, 4258, 4281, 13265, 13242
16803, 4258, 4281, 13265, 13242, 4259, 4282, 13266, 13243
16804, 4259, 4282, 13266, 13243, 4260, 4283, 13267, 13244
16805, 4260, 4283, 13267, 13244, 4261, 4284, 13268, 13245
16806, 4261, 4284, 13268, 13245, 4262, 4285, 13269, 13246
16807, 4262, 4285, 13269, 13246, 4263, 4286, 13270, 13247
16808, 4263, 4286, 13270, 13247, 4264, 4287, 13271, 13248
16809, 4264, 4287, 13271, 13248, 4265, 4288, 13272, 13249
16810, 4265, 4288, 13272, 13249, 462, 463, 4409, 4408
16811, 303, 304, 2593, 2592, 4266, 4289, 13273, 13250
16812, 4266, 4289, 13273, 13250, 4267, 4290, 13274, 13251
16813, 4267, 4290, 13274, 13251, 4268, 4291, 13275, 13252
16814, 4268, 4291, 13275, 13252, 4269, 4292, 13276, 13253
16815, 4269, 4292, 13276, 13253, 4270, 4293, 13277, 13254
16816, 4270, 4293, 13277, 13254, 4271, 4294, 13278, 13255
16817, 4271, 4294, 13278, 13255, 4272, 4295, 13279, 13256
16818, 4272, 4295, 13279, 13256, 4273, 4296, 13280, 13257
16819, 4273, 4296, 13280, 13257, 4274, 4297, 13281, 13258
16820, 4274, 4297, 13281, 13258, 4275, 4298, 13282, 13259
16821, 4275, 4298, 13282, 13259, 4276, 4299, 13283, 13260
16822, 4276, 4299, 13283, 13260, 4277, 4300, 13284, 13261
16823, 4277, 4300, 13284, 13261, 4278, 4301, 13285, 13262
16824, 4278, 4301, 13285, 13262, 4279, 4302, 13286, 13263
16825, 4279, 4302, 13286, 13263, 4280, 4303, 13287, 13264
16826, 4280, 4303, 13287, 13264, 4281, 4304, 13288, 13265
16827, 4281, 4304, 13288, 13265, 4282, 4305, 13289, 13266
16828, 4282, 4305, 13289, 13266, 4283, 4306, 13290, 13267
16829, 4283, 4306, 13290, 13267, 4284, 4307, 13291, 13268
16830, 4284, 4307, 13291, 13268, 4285, 4308, 13292, 13269
16831, 4285, 4308, 13292, 13269, 4286, 4309, 13293, 13270
16832, 4286, 4309, 13293, 13270, 4287, 4310, 13294, 13271
16833, 4287, 4310, 13294, 13271, 4288, 4311, 13295, 13272
16834, 4288, 4311, 13295, 13272, 463, 464, 4410, 4409
16835, 304, 305, 2594, 2593, 4289, 4312, 13296, 13273
16836, 4289, 4312, 13296, 13273, 4290, 4313, 13297, 13274
16837, 4290, 4313, 13297, 13274, 4291, 4314, 13298, 13275
16838, 4291, 4314, 13298, 13275, 4292, 4315, 13299, 13276
16839, 4292, 4315, 13299, 13276, 4293, 4316, 13300, 13277
16840, 4293, 4316, 13300, 13277, 4294, 4317, 13301, 13278
16841, 4294, 4317, 13301, 13278, 4295, 4318, 13302, 13279
16842, 4295, 4318, 13302, 13279, 4296, 4319, 13303, 13280
16843, 4296, 4319, 13303, 13280, 4297, 4320, 13304, 13281
16844, 4297, 4320, 13304, 13281, 4298, 4321, 13305, 13282
16845, 4298, 4321, 13305, 13282, 4299, 4322, 13306, 13283
16846, 4299, 4322, 13306, 13283, 4300, 4323, 13307, 13284
16847, 4300, 4323, 13307, 13284, 4301, 4324, 13308, 13285
16848, 4301, 4324, 13308, 13285, 4302, 4325, 13309, 13286
16849, 4302, 4325, 13309, 13286, 4303, 4326, 13310, 13287
16850, 4303, 4326, 13310, 13287, 4304, 4327, 13311, 13288
16851, 4304, 4327, 13311, 13288, 4305, 4328, 13312, 13289
16852, 4305, 4328, 13312, 13289, 4306, 4329, 13313, 13290
16853, 4306, 4329, 13313, 13290, 4307, 4330, 13314, 13291
16854, 4307, 4330, 13314, 13291, 4308, 4331, 13315, 13292
16855, 4308, 4331, 13315, 13292, 4309, 4332, 13316, 13293
16856, 4309, 4332, 13316, 13293, 4310, 4333, 13317, 13294
16857, 4310, 4333, 13317, 13294, 4311, 4334, 13318, 13295
16858, 4311, 4334, 13318, 13295, 464, 465, 4411, 4410
16859, 305, 306, 2595, 2594, 4312, 4335, 13319, 13296
16860, 4312, 4335, 13319, 13296, 4313, 4336, 13320, 13297
16861, 4313, 4336, 13320, 13297, 4314, 4337, 13321, 13298
16862, 4314, 4337, 13321, 13298, 4315, 4338, 13322, 13299
16863, 4315, 4338, 13322, 13299, 4316, 4339, 13323, 13300
16864, 4316, 4339, 13323, 13300, 4317, 4340, 13324, 13301
16865, 4317, 4340, 13324, 13301, 4318, 4341, 13325, 13302
16866, 4318, 4341, 13325, 13302, 4319, 4342, 13326, 13303
16867, 4319, 4342, 13326, 13303, 4320, 4343, 13327, 13304
16868, 4320, 4343, 13327, 13304, 4321, 4344, 13328, 13305
16869, 4321, 4344, 13328, 13305, 4322, 4345, 13329, 13306
16870, 4322, 4345, 13329, 13306, 4323, 4346, 13330, 13307
16871, 4323, 4346, 13330, 13307, 4324, 4347, 13331, 13308
16872, 4324, 4347, 13331, 13308, 4325, 4348, 13332, 13309
16873, 4325, 4348, 13332, 13309, 4326, 4349, 13333, 13310
16874, 4326, 4349, 13333, 13310, 4327, 4350, 13334, 13311
16875, 4327, 4350, 13334, 13311, 4328, 4351, 13335, 13312
16876, 4328, 4351, 13335, 13312, 4329, 4352, 13336, 13313
16877, 4329, 4352, 13336, 13313, 4330, 4353, 13337, 13314
16878, 4330, 4353, 13337, 13314, 4331, 4354, 13338, 13315
16879, 4331, 4354, 13338, 13315, 4332, 4355, 13339, 13316
16880, 4332, 4355, 13339, 13316, 4333, 4356, 13340, 13317
16881, 4333, 4356, 13340, 13317, 4334, 4357, 13341, 13318
16882, 4334, 4357, 13341, 13318, 465, 466, 4412, 4411
16883, 306, 307, 2596, 2595, 4335, 4358, 13342, 13319
16884, 4335, 4358, 13342, 13319, 4336, 4359, 13343, 13320
16885, 4336, 4359, 13343, 13320, 4337, 4360, 13344, 13321
16886, 4337, 4360, 13344, 13321, 4338, 4361, 13345, 13322
16887, 4338, 4361, 13345, 13322, 4339, 4362, 13346, 13323
16888, 4339, 4362, 13346, 13323, 4340, 4363, 13347, 13324
16889, 4340, 4363, 13347, 13324, 4341, 4364, 13348, 13325
16890, 4341, 4364, 13348, 13325, 4342, 4365, 13349, 13326
