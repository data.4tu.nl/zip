33545, 8182, 8183, 8206, 8205, 26007, 26009, 26055, 26053
33546, 26007, 26009, 26055, 26053, 26008, 26010, 26056, 26054
33547, 26008, 26010, 26056, 26054, 8571, 8572, 8595, 8594
33548, 8183, 1060, 1061, 8206, 26009, 8486, 8488, 26055
33549, 26009, 8486, 8488, 26055, 26010, 8487, 8489, 26056
33550, 26010, 8487, 8489, 26056, 8572, 1136, 1137, 8595
33551, 1050, 8184, 8207, 1051, 8466, 26011, 26057, 8468
33552, 8466, 26011, 26057, 8468, 8467, 26012, 26058, 8469
33553, 8467, 26012, 26058, 8469, 1126, 8573, 8596, 1127
33554, 8184, 8185, 8208, 8207, 26011, 26013, 26059, 26057
33555, 26011, 26013, 26059, 26057, 26012, 26014, 26060, 26058
33556, 26012, 26014, 26060, 26058, 8573, 8574, 8597, 8596
33557, 8185, 8186, 8209, 8208, 26013, 26015, 26061, 26059
33558, 26013, 26015, 26061, 26059, 26014, 26016, 26062, 26060
33559, 26014, 26016, 26062, 26060, 8574, 8575, 8598, 8597
33560, 8186, 8187, 8210, 8209, 26015, 26017, 26063, 26061
33561, 26015, 26017, 26063, 26061, 26016, 26018, 26064, 26062
33562, 26016, 26018, 26064, 26062, 8575, 8576, 8599, 8598
33563, 8187, 8188, 8211, 8210, 26017, 26019, 26065, 26063
33564, 26017, 26019, 26065, 26063, 26018, 26020, 26066, 26064
33565, 26018, 26020, 26066, 26064, 8576, 8577, 8600, 8599
33566, 8188, 8189, 8212, 8211, 26019, 26021, 26067, 26065
33567, 26019, 26021, 26067, 26065, 26020, 26022, 26068, 26066
33568, 26020, 26022, 26068, 26066, 8577, 8578, 8601, 8600
33569, 8189, 8190, 8213, 8212, 26021, 26023, 26069, 26067
33570, 26021, 26023, 26069, 26067, 26022, 26024, 26070, 26068
33571, 26022, 26024, 26070, 26068, 8578, 8579, 8602, 8601
33572, 8190, 8191, 8214, 8213, 26023, 26025, 26071, 26069
33573, 26023, 26025, 26071, 26069, 26024, 26026, 26072, 26070
33574, 26024, 26026, 26072, 26070, 8579, 8580, 8603, 8602
33575, 8191, 8192, 8215, 8214, 26025, 26027, 26073, 26071
33576, 26025, 26027, 26073, 26071, 26026, 26028, 26074, 26072
33577, 26026, 26028, 26074, 26072, 8580, 8581, 8604, 8603
33578, 8192, 8193, 8216, 8215, 26027, 26029, 26075, 26073
33579, 26027, 26029, 26075, 26073, 26028, 26030, 26076, 26074
33580, 26028, 26030, 26076, 26074, 8581, 8582, 8605, 8604
33581, 8193, 8194, 8217, 8216, 26029, 26031, 26077, 26075
33582, 26029, 26031, 26077, 26075, 26030, 26032, 26078, 26076
33583, 26030, 26032, 26078, 26076, 8582, 8583, 8606, 8605
33584, 8194, 8195, 8218, 8217, 26031, 26033, 26079, 26077
33585, 26031, 26033, 26079, 26077, 26032, 26034, 26080, 26078
33586, 26032, 26034, 26080, 26078, 8583, 8584, 8607, 8606
33587, 8195, 8196, 8219, 8218, 26033, 26035, 26081, 26079
33588, 26033, 26035, 26081, 26079, 26034, 26036, 26082, 26080
33589, 26034, 26036, 26082, 26080, 8584, 8585, 8608, 8607
33590, 8196, 8197, 8220, 8219, 26035, 26037, 26083, 26081
33591, 26035, 26037, 26083, 26081, 26036, 26038, 26084, 26082
33592, 26036, 26038, 26084, 26082, 8585, 8586, 8609, 8608
33593, 8197, 8198, 8221, 8220, 26037, 26039, 26085, 26083
33594, 26037, 26039, 26085, 26083, 26038, 26040, 26086, 26084
33595, 26038, 26040, 26086, 26084, 8586, 8587, 8610, 8609
33596, 8198, 8199, 8222, 8221, 26039, 26041, 26087, 26085
33597, 26039, 26041, 26087, 26085, 26040, 26042, 26088, 26086
33598, 26040, 26042, 26088, 26086, 8587, 8588, 8611, 8610
33599, 8199, 8200, 8223, 8222, 26041, 26043, 26089, 26087
33600, 26041, 26043, 26089, 26087, 26042, 26044, 26090, 26088
33601, 26042, 26044, 26090, 26088, 8588, 8589, 8612, 8611
33602, 8200, 8201, 8224, 8223, 26043, 26045, 26091, 26089
33603, 26043, 26045, 26091, 26089, 26044, 26046, 26092, 26090
33604, 26044, 26046, 26092, 26090, 8589, 8590, 8613, 8612
33605, 8201, 8202, 8225, 8224, 26045, 26047, 26093, 26091
33606, 26045, 26047, 26093, 26091, 26046, 26048, 26094, 26092
33607, 26046, 26048, 26094, 26092, 8590, 8591, 8614, 8613
33608, 8202, 8203, 8226, 8225, 26047, 26049, 26095, 26093
33609, 26047, 26049, 26095, 26093, 26048, 26050, 26096, 26094
33610, 26048, 26050, 26096, 26094, 8591, 8592, 8615, 8614
33611, 8203, 8204, 8227, 8226, 26049, 26051, 26097, 26095
33612, 26049, 26051, 26097, 26095, 26050, 26052, 26098, 26096
33613, 26050, 26052, 26098, 26096, 8592, 8593, 8616, 8615
33614, 8204, 8205, 8228, 8227, 26051, 26053, 26099, 26097
33615, 26051, 26053, 26099, 26097, 26052, 26054, 26100, 26098
33616, 26052, 26054, 26100, 26098, 8593, 8594, 8617, 8616
33617, 8205, 8206, 8229, 8228, 26053, 26055, 26101, 26099
33618, 26053, 26055, 26101, 26099, 26054, 26056, 26102, 26100
33619, 26054, 26056, 26102, 26100, 8594, 8595, 8618, 8617
33620, 8206, 1061, 1062, 8229, 26055, 8488, 8490, 26101
33621, 26055, 8488, 8490, 26101, 26056, 8489, 8491, 26102
33622, 26056, 8489, 8491, 26102, 8595, 1137, 1138, 8618
33623, 1051, 8207, 8230, 1052, 8468, 26057, 26103, 8470
33624, 8468, 26057, 26103, 8470, 8469, 26058, 26104, 8471
33625, 8469, 26058, 26104, 8471, 1127, 8596, 8619, 1128
33626, 8207, 8208, 8231, 8230, 26057, 26059, 26105, 26103
33627, 26057, 26059, 26105, 26103, 26058, 26060, 26106, 26104
33628, 26058, 26060, 26106, 26104, 8596, 8597, 8620, 8619
33629, 8208, 8209, 8232, 8231, 26059, 26061, 26107, 26105
33630, 26059, 26061, 26107, 26105, 26060, 26062, 26108, 26106
33631, 26060, 26062, 26108, 26106, 8597, 8598, 8621, 8620
33632, 8209, 8210, 8233, 8232, 26061, 26063, 26109, 26107
33633, 26061, 26063, 26109, 26107, 26062, 26064, 26110, 26108
33634, 26062, 26064, 26110, 26108, 8598, 8599, 8622, 8621
33635, 8210, 8211, 8234, 8233, 26063, 26065, 26111, 26109
33636, 26063, 26065, 26111, 26109, 26064, 26066, 26112, 26110
33637, 26064, 26066, 26112, 26110, 8599, 8600, 8623, 8622
33638, 8211, 8212, 8235, 8234, 26065, 26067, 26113, 26111
33639, 26065, 26067, 26113, 26111, 26066, 26068, 26114, 26112
33640, 26066, 26068, 26114, 26112, 8600, 8601, 8624, 8623
33641, 8212, 8213, 8236, 8235, 26067, 26069, 26115, 26113
33642, 26067, 26069, 26115, 26113, 26068, 26070, 26116, 26114
33643, 26068, 26070, 26116, 26114, 8601, 8602, 8625, 8624
33644, 8213, 8214, 8237, 8236, 26069, 26071, 26117, 26115
33645, 26069, 26071, 26117, 26115, 26070, 26072, 26118, 26116
33646, 26070, 26072, 26118, 26116, 8602, 8603, 8626, 8625
33647, 8214, 8215, 8238, 8237, 26071, 26073, 26119, 26117
33648, 26071, 26073, 26119, 26117, 26072, 26074, 26120, 26118
33649, 26072, 26074, 26120, 26118, 8603, 8604, 8627, 8626
33650, 8215, 8216, 8239, 8238, 26073, 26075, 26121, 26119
33651, 26073, 26075, 26121, 26119, 26074, 26076, 26122, 26120
33652, 26074, 26076, 26122, 26120, 8604, 8605, 8628, 8627
33653, 8216, 8217, 8240, 8239, 26075, 26077, 26123, 26121
33654, 26075, 26077, 26123, 26121, 26076, 26078, 26124, 26122
33655, 26076, 26078, 26124, 26122, 8605, 8606, 8629, 8628
33656, 8217, 8218, 8241, 8240, 26077, 26079, 26125, 26123
33657, 26077, 26079, 26125, 26123, 26078, 26080, 26126, 26124
33658, 26078, 26080, 26126, 26124, 8606, 8607, 8630, 8629
33659, 8218, 8219, 8242, 8241, 26079, 26081, 26127, 26125
33660, 26079, 26081, 26127, 26125, 26080, 26082, 26128, 26126
33661, 26080, 26082, 26128, 26126, 8607, 8608, 8631, 8630
33662, 8219, 8220, 8243, 8242, 26081, 26083, 26129, 26127
33663, 26081, 26083, 26129, 26127, 26082, 26084, 26130, 26128
33664, 26082, 26084, 26130, 26128, 8608, 8609, 8632, 8631
33665, 8220, 8221, 8244, 8243, 26083, 26085, 26131, 26129
33666, 26083, 26085, 26131, 26129, 26084, 26086, 26132, 26130
33667, 26084, 26086, 26132, 26130, 8609, 8610, 8633, 8632
33668, 8221, 8222, 8245, 8244, 26085, 26087, 26133, 26131
33669, 26085, 26087, 26133, 26131, 26086, 26088, 26134, 26132
33670, 26086, 26088, 26134, 26132, 8610, 8611, 8634, 8633
33671, 8222, 8223, 8246, 8245, 26087, 26089, 26135, 26133
33672, 26087, 26089, 26135, 26133, 26088, 26090, 26136, 26134
33673, 26088, 26090, 26136, 26134, 8611, 8612, 8635, 8634
33674, 8223, 8224, 8247, 8246, 26089, 26091, 26137, 26135
33675, 26089, 26091, 26137, 26135, 26090, 26092, 26138, 26136
33676, 26090, 26092, 26138, 26136, 8612, 8613, 8636, 8635
33677, 8224, 8225, 8248, 8247, 26091, 26093, 26139, 26137
33678, 26091, 26093, 26139, 26137, 26092, 26094, 26140, 26138
33679, 26092, 26094, 26140, 26138, 8613, 8614, 8637, 8636
33680, 8225, 8226, 8249, 8248, 26093, 26095, 26141, 26139
33681, 26093, 26095, 26141, 26139, 26094, 26096, 26142, 26140
33682, 26094, 26096, 26142, 26140, 8614, 8615, 8638, 8637
33683, 8226, 8227, 8250, 8249, 26095, 26097, 26143, 26141
33684, 26095, 26097, 26143, 26141, 26096, 26098, 26144, 26142
33685, 26096, 26098, 26144, 26142, 8615, 8616, 8639, 8638
33686, 8227, 8228, 8251, 8250, 26097, 26099, 26145, 26143
33687, 26097, 26099, 26145, 26143, 26098, 26100, 26146, 26144
33688, 26098, 26100, 26146, 26144, 8616, 8617, 8640, 8639
33689, 8228, 8229, 8252, 8251, 26099, 26101, 26147, 26145
33690, 26099, 26101, 26147, 26145, 26100, 26102, 26148, 26146
33691, 26100, 26102, 26148, 26146, 8617, 8618, 8641, 8640
33692, 8229, 1062, 1063, 8252, 26101, 8490, 8492, 26147
33693, 26101, 8490, 8492, 26147, 26102, 8491, 8493, 26148
33694, 26102, 8491, 8493, 26148, 8618, 1138, 1139, 8641
33695, 1052, 8230, 8253, 1053, 8470, 26103, 26149, 8472
33696, 8470, 26103, 26149, 8472, 8471, 26104, 26150, 8473
33697, 8471, 26104, 26150, 8473, 1128, 8619, 8642, 1129
33698, 8230, 8231, 8254, 8253, 26103, 26105, 26151, 26149
33699, 26103, 26105, 26151, 26149, 26104, 26106, 26152, 26150
33700, 26104, 26106, 26152, 26150, 8619, 8620, 8643, 8642
33701, 8231, 8232, 8255, 8254, 26105, 26107, 26153, 26151
33702, 26105, 26107, 26153, 26151, 26106, 26108, 26154, 26152
33703, 26106, 26108, 26154, 26152, 8620, 8621, 8644, 8643
33704, 8232, 8233, 8256, 8255, 26107, 26109, 26155, 26153
33705, 26107, 26109, 26155, 26153, 26108, 26110, 26156, 26154
33706, 26108, 26110, 26156, 26154, 8621, 8622, 8645, 8644
33707, 8233, 8234, 8257, 8256, 26109, 26111, 26157, 26155
33708, 26109, 26111, 26157, 26155, 26110, 26112, 26158, 26156
33709, 26110, 26112, 26158, 26156, 8622, 8623, 8646, 8645
33710, 8234, 8235, 8258, 8257, 26111, 26113, 26159, 26157
33711, 26111, 26113, 26159, 26157, 26112, 26114, 26160, 26158
33712, 26112, 26114, 26160, 26158, 8623, 8624, 8647, 8646
33713, 8235, 8236, 8259, 8258, 26113, 26115, 26161, 26159
33714, 26113, 26115, 26161, 26159, 26114, 26116, 26162, 26160
33715, 26114, 26116, 26162, 26160, 8624, 8625, 8648, 8647
33716, 8236, 8237, 8260, 8259, 26115, 26117, 26163, 26161
33717, 26115, 26117, 26163, 26161, 26116, 26118, 26164, 26162
33718, 26116, 26118, 26164, 26162, 8625, 8626, 8649, 8648
33719, 8237, 8238, 8261, 8260, 26117, 26119, 26165, 26163
33720, 26117, 26119, 26165, 26163, 26118, 26120, 26166, 26164
33721, 26118, 26120, 26166, 26164, 8626, 8627, 8650, 8649
33722, 8238, 8239, 8262, 8261, 26119, 26121, 26167, 26165
33723, 26119, 26121, 26167, 26165, 26120, 26122, 26168, 26166
33724, 26120, 26122, 26168, 26166, 8627, 8628, 8651, 8650
33725, 8239, 8240, 8263, 8262, 26121, 26123, 26169, 26167
33726, 26121, 26123, 26169, 26167, 26122, 26124, 26170, 26168
33727, 26122, 26124, 26170, 26168, 8628, 8629, 8652, 8651
33728, 8240, 8241, 8264, 8263, 26123, 26125, 26171, 26169
33729, 26123, 26125, 26171, 26169, 26124, 26126, 26172, 26170
33730, 26124, 26126, 26172, 26170, 8629, 8630, 8653, 8652
33731, 8241, 8242, 8265, 8264, 26125, 26127, 26173, 26171
33732, 26125, 26127, 26173, 26171, 26126, 26128, 26174, 26172
33733, 26126, 26128, 26174, 26172, 8630, 8631, 8654, 8653
33734, 8242, 8243, 8266, 8265, 26127, 26129, 26175, 26173
33735, 26127, 26129, 26175, 26173, 26128, 26130, 26176, 26174
33736, 26128, 26130, 26176, 26174, 8631, 8632, 8655, 8654
33737, 8243, 8244, 8267, 8266, 26129, 26131, 26177, 26175
33738, 26129, 26131, 26177, 26175, 26130, 26132, 26178, 26176
33739, 26130, 26132, 26178, 26176, 8632, 8633, 8656, 8655
33740, 8244, 8245, 8268, 8267, 26131, 26133, 26179, 26177
33741, 26131, 26133, 26179, 26177, 26132, 26134, 26180, 26178
33742, 26132, 26134, 26180, 26178, 8633, 8634, 8657, 8656
33743, 8245, 8246, 8269, 8268, 26133, 26135, 26181, 26179
33744, 26133, 26135, 26181, 26179, 26134, 26136, 26182, 26180
33745, 26134, 26136, 26182, 26180, 8634, 8635, 8658, 8657
33746, 8246, 8247, 8270, 8269, 26135, 26137, 26183, 26181
33747, 26135, 26137, 26183, 26181, 26136, 26138, 26184, 26182
33748, 26136, 26138, 26184, 26182, 8635, 8636, 8659, 8658
33749, 8247, 8248, 8271, 8270, 26137, 26139, 26185, 26183
33750, 26137, 26139, 26185, 26183, 26138, 26140, 26186, 26184
33751, 26138, 26140, 26186, 26184, 8636, 8637, 8660, 8659
33752, 8248, 8249, 8272, 8271, 26139, 26141, 26187, 26185
33753, 26139, 26141, 26187, 26185, 26140, 26142, 26188, 26186
33754, 26140, 26142, 26188, 26186, 8637, 8638, 8661, 8660
33755, 8249, 8250, 8273, 8272, 26141, 26143, 26189, 26187
33756, 26141, 26143, 26189, 26187, 26142, 26144, 26190, 26188
33757, 26142, 26144, 26190, 26188, 8638, 8639, 8662, 8661
33758, 8250, 8251, 8274, 8273, 26143, 26145, 26191, 26189
33759, 26143, 26145, 26191, 26189, 26144, 26146, 26192, 26190
33760, 26144, 26146, 26192, 26190, 8639, 8640, 8663, 8662
33761, 8251, 8252, 8275, 8274, 26145, 26147, 26193, 26191
33762, 26145, 26147, 26193, 26191, 26146, 26148, 26194, 26192
33763, 26146, 26148, 26194, 26192, 8640, 8641, 8664, 8663
33764, 8252, 1063, 1064, 8275, 26147, 8492, 8494, 26193
33765, 26147, 8492, 8494, 26193, 26148, 8493, 8495, 26194
33766, 26148, 8493, 8495, 26194, 8641, 1139, 1140, 8664
33767, 1053, 8253, 8276, 1054, 8472, 26149, 26195, 8474
33768, 8472, 26149, 26195, 8474, 8473, 26150, 26196, 8475
33769, 8473, 26150, 26196, 8475, 1129, 8642, 8665, 1130
33770, 8253, 8254, 8277, 8276, 26149, 26151, 26197, 26195
33771, 26149, 26151, 26197, 26195, 26150, 26152, 26198, 26196
33772, 26150, 26152, 26198, 26196, 8642, 8643, 8666, 8665
33773, 8254, 8255, 8278, 8277, 26151, 26153, 26199, 26197
33774, 26151, 26153, 26199, 26197, 26152, 26154, 26200, 26198
33775, 26152, 26154, 26200, 26198, 8643, 8644, 8667, 8666
33776, 8255, 8256, 8279, 8278, 26153, 26155, 26201, 26199
33777, 26153, 26155, 26201, 26199, 26154, 26156, 26202, 26200
33778, 26154, 26156, 26202, 26200, 8644, 8645, 8668, 8667
33779, 8256, 8257, 8280, 8279, 26155, 26157, 26203, 26201
33780, 26155, 26157, 26203, 26201, 26156, 26158, 26204, 26202
33781, 26156, 26158, 26204, 26202, 8645, 8646, 8669, 8668
33782, 8257, 8258, 8281, 8280, 26157, 26159, 26205, 26203
33783, 26157, 26159, 26205, 26203, 26158, 26160, 26206, 26204
33784, 26158, 26160, 26206, 26204, 8646, 8647, 8670, 8669
33785, 8258, 8259, 8282, 8281, 26159, 26161, 26207, 26205
33786, 26159, 26161, 26207, 26205, 26160, 26162, 26208, 26206
33787, 26160, 26162, 26208, 26206, 8647, 8648, 8671, 8670
33788, 8259, 8260, 8283, 8282, 26161, 26163, 26209, 26207
33789, 26161, 26163, 26209, 26207, 26162, 26164, 26210, 26208
33790, 26162, 26164, 26210, 26208, 8648, 8649, 8672, 8671
33791, 8260, 8261, 8284, 8283, 26163, 26165, 26211, 26209
33792, 26163, 26165, 26211, 26209, 26164, 26166, 26212, 26210
33793, 26164, 26166, 26212, 26210, 8649, 8650, 8673, 8672
33794, 8261, 8262, 8285, 8284, 26165, 26167, 26213, 26211
33795, 26165, 26167, 26213, 26211, 26166, 26168, 26214, 26212
33796, 26166, 26168, 26214, 26212, 8650, 8651, 8674, 8673
33797, 8262, 8263, 8286, 8285, 26167, 26169, 26215, 26213
33798, 26167, 26169, 26215, 26213, 26168, 26170, 26216, 26214
33799, 26168, 26170, 26216, 26214, 8651, 8652, 8675, 8674
33800, 8263, 8264, 8287, 8286, 26169, 26171, 26217, 26215
33801, 26169, 26171, 26217, 26215, 26170, 26172, 26218, 26216
33802, 26170, 26172, 26218, 26216, 8652, 8653, 8676, 8675
33803, 8264, 8265, 8288, 8287, 26171, 26173, 26219, 26217
33804, 26171, 26173, 26219, 26217, 26172, 26174, 26220, 26218
33805, 26172, 26174, 26220, 26218, 8653, 8654, 8677, 8676
33806, 8265, 8266, 8289, 8288, 26173, 26175, 26221, 26219
33807, 26173, 26175, 26221, 26219, 26174, 26176, 26222, 26220
33808, 26174, 26176, 26222, 26220, 8654, 8655, 8678, 8677
33809, 8266, 8267, 8290, 8289, 26175, 26177, 26223, 26221
33810, 26175, 26177, 26223, 26221, 26176, 26178, 26224, 26222
33811, 26176, 26178, 26224, 26222, 8655, 8656, 8679, 8678
33812, 8267, 8268, 8291, 8290, 26177, 26179, 26225, 26223
33813, 26177, 26179, 26225, 26223, 26178, 26180, 26226, 26224
33814, 26178, 26180, 26226, 26224, 8656, 8657, 8680, 8679
33815, 8268, 8269, 8292, 8291, 26179, 26181, 26227, 26225
33816, 26179, 26181, 26227, 26225, 26180, 26182, 26228, 26226
33817, 26180, 26182, 26228, 26226, 8657, 8658, 8681, 8680
33818, 8269, 8270, 8293, 8292, 26181, 26183, 26229, 26227
33819, 26181, 26183, 26229, 26227, 26182, 26184, 26230, 26228
33820, 26182, 26184, 26230, 26228, 8658, 8659, 8682, 8681
33821, 8270, 8271, 8294, 8293, 26183, 26185, 26231, 26229
33822, 26183, 26185, 26231, 26229, 26184, 26186, 26232, 26230
33823, 26184, 26186, 26232, 26230, 8659, 8660, 8683, 8682
33824, 8271, 8272, 8295, 8294, 26185, 26187, 26233, 26231
33825, 26185, 26187, 26233, 26231, 26186, 26188, 26234, 26232
33826, 26186, 26188, 26234, 26232, 8660, 8661, 8684, 8683
33827, 8272, 8273, 8296, 8295, 26187, 26189, 26235, 26233
33828, 26187, 26189, 26235, 26233, 26188, 26190, 26236, 26234
33829, 26188, 26190, 26236, 26234, 8661, 8662, 8685, 8684
33830, 8273, 8274, 8297, 8296, 26189, 26191, 26237, 26235
33831, 26189, 26191, 26237, 26235, 26190, 26192, 26238, 26236
33832, 26190, 26192, 26238, 26236, 8662, 8663, 8686, 8685
33833, 8274, 8275, 8298, 8297, 26191, 26193, 26239, 26237
33834, 26191, 26193, 26239, 26237, 26192, 26194, 26240, 26238
33835, 26192, 26194, 26240, 26238, 8663, 8664, 8687, 8686
33836, 8275, 1064, 1065, 8298, 26193, 8494, 8496, 26239
33837, 26193, 8494, 8496, 26239, 26194, 8495, 8497, 26240
33838, 26194, 8495, 8497, 26240, 8664, 1140, 1141, 8687
33839, 1054, 8276, 8299, 1055, 8474, 26195, 26241, 8476
33840, 8474, 26195, 26241, 8476, 8475, 26196, 26242, 8477
33841, 8475, 26196, 26242, 8477, 1130, 8665, 8688, 1131
33842, 8276, 8277, 8300, 8299, 26195, 26197, 26243, 26241
33843, 26195, 26197, 26243, 26241, 26196, 26198, 26244, 26242
33844, 26196, 26198, 26244, 26242, 8665, 8666, 8689, 8688
33845, 8277, 8278, 8301, 8300, 26197, 26199, 26245, 26243
33846, 26197, 26199, 26245, 26243, 26198, 26200, 26246, 26244
33847, 26198, 26200, 26246, 26244, 8666, 8667, 8690, 8689
33848, 8278, 8279, 8302, 8301, 26199, 26201, 26247, 26245
33849, 26199, 26201, 26247, 26245, 26200, 26202, 26248, 26246
33850, 26200, 26202, 26248, 26246, 8667, 8668, 8691, 8690
33851, 8279, 8280, 8303, 8302, 26201, 26203, 26249, 26247
33852, 26201, 26203, 26249, 26247, 26202, 26204, 26250, 26248
33853, 26202, 26204, 26250, 26248, 8668, 8669, 8692, 8691
33854, 8280, 8281, 8304, 8303, 26203, 26205, 26251, 26249
33855, 26203, 26205, 26251, 26249, 26204, 26206, 26252, 26250
33856, 26204, 26206, 26252, 26250, 8669, 8670, 8693, 8692
33857, 8281, 8282, 8305, 8304, 26205, 26207, 26253, 26251
33858, 26205, 26207, 26253, 26251, 26206, 26208, 26254, 26252
33859, 26206, 26208, 26254, 26252, 8670, 8671, 8694, 8693
33860, 8282, 8283, 8306, 8305, 26207, 26209, 26255, 26253
33861, 26207, 26209, 26255, 26253, 26208, 26210, 26256, 26254
33862, 26208, 26210, 26256, 26254, 8671, 8672, 8695, 8694
33863, 8283, 8284, 8307, 8306, 26209, 26211, 26257, 26255
33864, 26209, 26211, 26257, 26255, 26210, 26212, 26258, 26256
33865, 26210, 26212, 26258, 26256, 8672, 8673, 8696, 8695
33866, 8284, 8285, 8308, 8307, 26211, 26213, 26259, 26257
33867, 26211, 26213, 26259, 26257, 26212, 26214, 26260, 26258
33868, 26212, 26214, 26260, 26258, 8673, 8674, 8697, 8696
33869, 8285, 8286, 8309, 8308, 26213, 26215, 26261, 26259
33870, 26213, 26215, 26261, 26259, 26214, 26216, 26262, 26260
33871, 26214, 26216, 26262, 26260, 8674, 8675, 8698, 8697
33872, 8286, 8287, 8310, 8309, 26215, 26217, 26263, 26261
33873, 26215, 26217, 26263, 26261, 26216, 26218, 26264, 26262
33874, 26216, 26218, 26264, 26262, 8675, 8676, 8699, 8698
33875, 8287, 8288, 8311, 8310, 26217, 26219, 26265, 26263
33876, 26217, 26219, 26265, 26263, 26218, 26220, 26266, 26264
33877, 26218, 26220, 26266, 26264, 8676, 8677, 8700, 8699
33878, 8288, 8289, 8312, 8311, 26219, 26221, 26267, 26265
33879, 26219, 26221, 26267, 26265, 26220, 26222, 26268, 26266
33880, 26220, 26222, 26268, 26266, 8677, 8678, 8701, 8700
33881, 8289, 8290, 8313, 8312, 26221, 26223, 26269, 26267
33882, 26221, 26223, 26269, 26267, 26222, 26224, 26270, 26268
33883, 26222, 26224, 26270, 26268, 8678, 8679, 8702, 8701
33884, 8290, 8291, 8314, 8313, 26223, 26225, 26271, 26269
33885, 26223, 26225, 26271, 26269, 26224, 26226, 26272, 26270
33886, 26224, 26226, 26272, 26270, 8679, 8680, 8703, 8702
33887, 8291, 8292, 8315, 8314, 26225, 26227, 26273, 26271
33888, 26225, 26227, 26273, 26271, 26226, 26228, 26274, 26272
33889, 26226, 26228, 26274, 26272, 8680, 8681, 8704, 8703
33890, 8292, 8293, 8316, 8315, 26227, 26229, 26275, 26273
33891, 26227, 26229, 26275, 26273, 26228, 26230, 26276, 26274
33892, 26228, 26230, 26276, 26274, 8681, 8682, 8705, 8704
33893, 8293, 8294, 8317, 8316, 26229, 26231, 26277, 26275
33894, 26229, 26231, 26277, 26275, 26230, 26232, 26278, 26276
33895, 26230, 26232, 26278, 26276, 8682, 8683, 8706, 8705
33896, 8294, 8295, 8318, 8317, 26231, 26233, 26279, 26277
33897, 26231, 26233, 26279, 26277, 26232, 26234, 26280, 26278
33898, 26232, 26234, 26280, 26278, 8683, 8684, 8707, 8706
33899, 8295, 8296, 8319, 8318, 26233, 26235, 26281, 26279
33900, 26233, 26235, 26281, 26279, 26234, 26236, 26282, 26280
33901, 26234, 26236, 26282, 26280, 8684, 8685, 8708, 8707
33902, 8296, 8297, 8320, 8319, 26235, 26237, 26283, 26281
33903, 26235, 26237, 26283, 26281, 26236, 26238, 26284, 26282
33904, 26236, 26238, 26284, 26282, 8685, 8686, 8709, 8708
33905, 8297, 8298, 8321, 8320, 26237, 26239, 26285, 26283
33906, 26237, 26239, 26285, 26283, 26238, 26240, 26286, 26284
33907, 26238, 26240, 26286, 26284, 8686, 8687, 8710, 8709
33908, 8298, 1065, 1066, 8321, 26239, 8496, 8498, 26285
33909, 26239, 8496, 8498, 26285, 26240, 8497, 8499, 26286
33910, 26240, 8497, 8499, 26286, 8687, 1141, 1142, 8710
33911, 1055, 8299, 8322, 1056, 8476, 26241, 26287, 8478
33912, 8476, 26241, 26287, 8478, 8477, 26242, 26288, 8479
33913, 8477, 26242, 26288, 8479, 1131, 8688, 8711, 1132
33914, 8299, 8300, 8323, 8322, 26241, 26243, 26289, 26287
33915, 26241, 26243, 26289, 26287, 26242, 26244, 26290, 26288
33916, 26242, 26244, 26290, 26288, 8688, 8689, 8712, 8711
33917, 8300, 8301, 8324, 8323, 26243, 26245, 26291, 26289
33918, 26243, 26245, 26291, 26289, 26244, 26246, 26292, 26290
33919, 26244, 26246, 26292, 26290, 8689, 8690, 8713, 8712
33920, 8301, 8302, 8325, 8324, 26245, 26247, 26293, 26291
33921, 26245, 26247, 26293, 26291, 26246, 26248, 26294, 26292
33922, 26246, 26248, 26294, 26292, 8690, 8691, 8714, 8713
33923, 8302, 8303, 8326, 8325, 26247, 26249, 26295, 26293
33924, 26247, 26249, 26295, 26293, 26248, 26250, 26296, 26294
33925, 26248, 26250, 26296, 26294, 8691, 8692, 8715, 8714
33926, 8303, 8304, 8327, 8326, 26249, 26251, 26297, 26295
33927, 26249, 26251, 26297, 26295, 26250, 26252, 26298, 26296
33928, 26250, 26252, 26298, 26296, 8692, 8693, 8716, 8715
33929, 8304, 8305, 8328, 8327, 26251, 26253, 26299, 26297
33930, 26251, 26253, 26299, 26297, 26252, 26254, 26300, 26298
33931, 26252, 26254, 26300, 26298, 8693, 8694, 8717, 8716
33932, 8305, 8306, 8329, 8328, 26253, 26255, 26301, 26299
33933, 26253, 26255, 26301, 26299, 26254, 26256, 26302, 26300
33934, 26254, 26256, 26302, 26300, 8694, 8695, 8718, 8717
33935, 8306, 8307, 8330, 8329, 26255, 26257, 26303, 26301
33936, 26255, 26257, 26303, 26301, 26256, 26258, 26304, 26302
33937, 26256, 26258, 26304, 26302, 8695, 8696, 8719, 8718
33938, 8307, 8308, 8331, 8330, 26257, 26259, 26305, 26303
33939, 26257, 26259, 26305, 26303, 26258, 26260, 26306, 26304
33940, 26258, 26260, 26306, 26304, 8696, 8697, 8720, 8719
33941, 8308, 8309, 8332, 8331, 26259, 26261, 26307, 26305
33942, 26259, 26261, 26307, 26305, 26260, 26262, 26308, 26306
33943, 26260, 26262, 26308, 26306, 8697, 8698, 8721, 8720
33944, 8309, 8310, 8333, 8332, 26261, 26263, 26309, 26307
33945, 26261, 26263, 26309, 26307, 26262, 26264, 26310, 26308
33946, 26262, 26264, 26310, 26308, 8698, 8699, 8722, 8721
33947, 8310, 8311, 8334, 8333, 26263, 26265, 26311, 26309
33948, 26263, 26265, 26311, 26309, 26264, 26266, 26312, 26310
33949, 26264, 26266, 26312, 26310, 8699, 8700, 8723, 8722
33950, 8311, 8312, 8335, 8334, 26265, 26267, 26313, 26311
33951, 26265, 26267, 26313, 26311, 26266, 26268, 26314, 26312
33952, 26266, 26268, 26314, 26312, 8700, 8701, 8724, 8723
33953, 8312, 8313, 8336, 8335, 26267, 26269, 26315, 26313
33954, 26267, 26269, 26315, 26313, 26268, 26270, 26316, 26314
33955, 26268, 26270, 26316, 26314, 8701, 8702, 8725, 8724
33956, 8313, 8314, 8337, 8336, 26269, 26271, 26317, 26315
33957, 26269, 26271, 26317, 26315, 26270, 26272, 26318, 26316
33958, 26270, 26272, 26318, 26316, 8702, 8703, 8726, 8725
33959, 8314, 8315, 8338, 8337, 26271, 26273, 26319, 26317
33960, 26271, 26273, 26319, 26317, 26272, 26274, 26320, 26318
33961, 26272, 26274, 26320, 26318, 8703, 8704, 8727, 8726
33962, 8315, 8316, 8339, 8338, 26273, 26275, 26321, 26319
33963, 26273, 26275, 26321, 26319, 26274, 26276, 26322, 26320
33964, 26274, 26276, 26322, 26320, 8704, 8705, 8728, 8727
33965, 8316, 8317, 8340, 8339, 26275, 26277, 26323, 26321
33966, 26275, 26277, 26323, 26321, 26276, 26278, 26324, 26322
33967, 26276, 26278, 26324, 26322, 8705, 8706, 8729, 8728
33968, 8317, 8318, 8341, 8340, 26277, 26279, 26325, 26323
33969, 26277, 26279, 26325, 26323, 26278, 26280, 26326, 26324
33970, 26278, 26280, 26326, 26324, 8706, 8707, 8730, 8729
33971, 8318, 8319, 8342, 8341, 26279, 26281, 26327, 26325
33972, 26279, 26281, 26327, 26325, 26280, 26282, 26328, 26326
33973, 26280, 26282, 26328, 26326, 8707, 8708, 8731, 8730
33974, 8319, 8320, 8343, 8342, 26281, 26283, 26329, 26327
33975, 26281, 26283, 26329, 26327, 26282, 26284, 26330, 26328
33976, 26282, 26284, 26330, 26328, 8708, 8709, 8732, 8731
33977, 8320, 8321, 8344, 8343, 26283, 26285, 26331, 26329
33978, 26283, 26285, 26331, 26329, 26284, 26286, 26332, 26330
33979, 26284, 26286, 26332, 26330, 8709, 8710, 8733, 8732
33980, 8321, 1066, 1067, 8344, 26285, 8498, 8500, 26331
33981, 26285, 8498, 8500, 26331, 26286, 8499, 8501, 26332
33982, 26286, 8499, 8501, 26332, 8710, 1142, 1143, 8733
33983, 1056, 8322, 8345, 1057, 8478, 26287, 26333, 8480
33984, 8478, 26287, 26333, 8480, 8479, 26288, 26334, 8481
33985, 8479, 26288, 26334, 8481, 1132, 8711, 8734, 1133
33986, 8322, 8323, 8346, 8345, 26287, 26289, 26335, 26333
33987, 26287, 26289, 26335, 26333, 26288, 26290, 26336, 26334
33988, 26288, 26290, 26336, 26334, 8711, 8712, 8735, 8734
33989, 8323, 8324, 8347, 8346, 26289, 26291, 26337, 26335
33990, 26289, 26291, 26337, 26335, 26290, 26292, 26338, 26336
33991, 26290, 26292, 26338, 26336, 8712, 8713, 8736, 8735
33992, 8324, 8325, 8348, 8347, 26291, 26293, 26339, 26337
33993, 26291, 26293, 26339, 26337, 26292, 26294, 26340, 26338
33994, 26292, 26294, 26340, 26338, 8713, 8714, 8737, 8736
33995, 8325, 8326, 8349, 8348, 26293, 26295, 26341, 26339
33996, 26293, 26295, 26341, 26339, 26294, 26296, 26342, 26340
33997, 26294, 26296, 26342, 26340, 8714, 8715, 8738, 8737
33998, 8326, 8327, 8350, 8349, 26295, 26297, 26343, 26341
33999, 26295, 26297, 26343, 26341, 26296, 26298, 26344, 26342
34000, 26296, 26298, 26344, 26342, 8715, 8716, 8739, 8738
34001, 8327, 8328, 8351, 8350, 26297, 26299, 26345, 26343
34002, 26297, 26299, 26345, 26343, 26298, 26300, 26346, 26344
34003, 26298, 26300, 26346, 26344, 8716, 8717, 8740, 8739
34004, 8328, 8329, 8352, 8351, 26299, 26301, 26347, 26345
34005, 26299, 26301, 26347, 26345, 26300, 26302, 26348, 26346
34006, 26300, 26302, 26348, 26346, 8717, 8718, 8741, 8740
34007, 8329, 8330, 8353, 8352, 26301, 26303, 26349, 26347
34008, 26301, 26303, 26349, 26347, 26302, 26304, 26350, 26348
34009, 26302, 26304, 26350, 26348, 8718, 8719, 8742, 8741
34010, 8330, 8331, 8354, 8353, 26303, 26305, 26351, 26349
34011, 26303, 26305, 26351, 26349, 26304, 26306, 26352, 26350
34012, 26304, 26306, 26352, 26350, 8719, 8720, 8743, 8742
34013, 8331, 8332, 8355, 8354, 26305, 26307, 26353, 26351
34014, 26305, 26307, 26353, 26351, 26306, 26308, 26354, 26352
34015, 26306, 26308, 26354, 26352, 8720, 8721, 8744, 8743
34016, 8332, 8333, 8356, 8355, 26307, 26309, 26355, 26353
34017, 26307, 26309, 26355, 26353, 26308, 26310, 26356, 26354
34018, 26308, 26310, 26356, 26354, 8721, 8722, 8745, 8744
34019, 8333, 8334, 8357, 8356, 26309, 26311, 26357, 26355
34020, 26309, 26311, 26357, 26355, 26310, 26312, 26358, 26356
34021, 26310, 26312, 26358, 26356, 8722, 8723, 8746, 8745
34022, 8334, 8335, 8358, 8357, 26311, 26313, 26359, 26357
34023, 26311, 26313, 26359, 26357, 26312, 26314, 26360, 26358
34024, 26312, 26314, 26360, 26358, 8723, 8724, 8747, 8746
34025, 8335, 8336, 8359, 8358, 26313, 26315, 26361, 26359
34026, 26313, 26315, 26361, 26359, 26314, 26316, 26362, 26360
34027, 26314, 26316, 26362, 26360, 8724, 8725, 8748, 8747
34028, 8336, 8337, 8360, 8359, 26315, 26317, 26363, 26361
34029, 26315, 26317, 26363, 26361, 26316, 26318, 26364, 26362
34030, 26316, 26318, 26364, 26362, 8725, 8726, 8749, 8748
34031, 8337, 8338, 8361, 8360, 26317, 26319, 26365, 26363
34032, 26317, 26319, 26365, 26363, 26318, 26320, 26366, 26364
34033, 26318, 26320, 26366, 26364, 8726, 8727, 8750, 8749
34034, 8338, 8339, 8362, 8361, 26319, 26321, 26367, 26365
34035, 26319, 26321, 26367, 26365, 26320, 26322, 26368, 26366
34036, 26320, 26322, 26368, 26366, 8727, 8728, 8751, 8750
34037, 8339, 8340, 8363, 8362, 26321, 26323, 26369, 26367
34038, 26321, 26323, 26369, 26367, 26322, 26324, 26370, 26368
34039, 26322, 26324, 26370, 26368, 8728, 8729, 8752, 8751
34040, 8340, 8341, 8364, 8363, 26323, 26325, 26371, 26369
34041, 26323, 26325, 26371, 26369, 26324, 26326, 26372, 26370
34042, 26324, 26326, 26372, 26370, 8729, 8730, 8753, 8752
34043, 8341, 8342, 8365, 8364, 26325, 26327, 26373, 26371
34044, 26325, 26327, 26373, 26371, 26326, 26328, 26374, 26372
34045, 26326, 26328, 26374, 26372, 8730, 8731, 8754, 8753
34046, 8342, 8343, 8366, 8365, 26327, 26329, 26375, 26373
34047, 26327, 26329, 26375, 26373, 26328, 26330, 26376, 26374
34048, 26328, 26330, 26376, 26374, 8731, 8732, 8755, 8754
34049, 8343, 8344, 8367, 8366, 26329, 26331, 26377, 26375
34050, 26329, 26331, 26377, 26375, 26330, 26332, 26378, 26376
34051, 26330, 26332, 26378, 26376, 8732, 8733, 8756, 8755
34052, 8344, 1067, 1068, 8367, 26331, 8500, 8502, 26377
34053, 26331, 8500, 8502, 26377, 26332, 8501, 8503, 26378
34054, 26332, 8501, 8503, 26378, 8733, 1143, 1144, 8756
34055, 1057, 8345, 1001, 41, 8480, 26333, 8368, 1069
34056, 8480, 26333, 8368, 1069, 8481, 26334, 8369, 1070
34057, 8481, 26334, 8369, 1070, 1133, 8734, 1073, 45
34058, 8345, 8346, 1002, 1001, 26333, 26335, 8370, 8368
34059, 26333, 26335, 8370, 8368, 26334, 26336, 8371, 8369
34060, 26334, 26336, 8371, 8369, 8734, 8735, 1074, 1073
34061, 8346, 8347, 1003, 1002, 26335, 26337, 8372, 8370
34062, 26335, 26337, 8372, 8370, 26336, 26338, 8373, 8371
34063, 26336, 26338, 8373, 8371, 8735, 8736, 1075, 1074
34064, 8347, 8348, 1004, 1003, 26337, 26339, 8374, 8372
34065, 26337, 26339, 8374, 8372, 26338, 26340, 8375, 8373
34066, 26338, 26340, 8375, 8373, 8736, 8737, 1076, 1075
34067, 8348, 8349, 1005, 1004, 26339, 26341, 8376, 8374
34068, 26339, 26341, 8376, 8374, 26340, 26342, 8377, 8375
34069, 26340, 26342, 8377, 8375, 8737, 8738, 1077, 1076
34070, 8349, 8350, 1006, 1005, 26341, 26343, 8378, 8376
34071, 26341, 26343, 8378, 8376, 26342, 26344, 8379, 8377
34072, 26342, 26344, 8379, 8377, 8738, 8739, 1078, 1077
34073, 8350, 8351, 1007, 1006, 26343, 26345, 8380, 8378
34074, 26343, 26345, 8380, 8378, 26344, 26346, 8381, 8379
34075, 26344, 26346, 8381, 8379, 8739, 8740, 1079, 1078
34076, 8351, 8352, 1008, 1007, 26345, 26347, 8382, 8380
34077, 26345, 26347, 8382, 8380, 26346, 26348, 8383, 8381
34078, 26346, 26348, 8383, 8381, 8740, 8741, 1080, 1079
34079, 8352, 8353, 1009, 1008, 26347, 26349, 8384, 8382
34080, 26347, 26349, 8384, 8382, 26348, 26350, 8385, 8383
34081, 26348, 26350, 8385, 8383, 8741, 8742, 1081, 1080
34082, 8353, 8354, 1010, 1009, 26349, 26351, 8386, 8384
34083, 26349, 26351, 8386, 8384, 26350, 26352, 8387, 8385
34084, 26350, 26352, 8387, 8385, 8742, 8743, 1082, 1081
34085, 8354, 8355, 1011, 1010, 26351, 26353, 8388, 8386
34086, 26351, 26353, 8388, 8386, 26352, 26354, 8389, 8387
34087, 26352, 26354, 8389, 8387, 8743, 8744, 1083, 1082
34088, 8355, 8356, 1012, 1011, 26353, 26355, 8390, 8388
34089, 26353, 26355, 8390, 8388, 26354, 26356, 8391, 8389
34090, 26354, 26356, 8391, 8389, 8744, 8745, 1084, 1083
34091, 8356, 8357, 1013, 1012, 26355, 26357, 8392, 8390
34092, 26355, 26357, 8392, 8390, 26356, 26358, 8393, 8391
34093, 26356, 26358, 8393, 8391, 8745, 8746, 1085, 1084
34094, 8357, 8358, 1014, 1013, 26357, 26359, 8394, 8392
34095, 26357, 26359, 8394, 8392, 26358, 26360, 8395, 8393
34096, 26358, 26360, 8395, 8393, 8746, 8747, 1086, 1085
34097, 8358, 8359, 1015, 1014, 26359, 26361, 8396, 8394
34098, 26359, 26361, 8396, 8394, 26360, 26362, 8397, 8395
34099, 26360, 26362, 8397, 8395, 8747, 8748, 1087, 1086
34100, 8359, 8360, 1016, 1015, 26361, 26363, 8398, 8396
34101, 26361, 26363, 8398, 8396, 26362, 26364, 8399, 8397
34102, 26362, 26364, 8399, 8397, 8748, 8749, 1088, 1087
34103, 8360, 8361, 1017, 1016, 26363, 26365, 8400, 8398
34104, 26363, 26365, 8400, 8398, 26364, 26366, 8401, 8399
34105, 26364, 26366, 8401, 8399, 8749, 8750, 1089, 1088
34106, 8361, 8362, 1018, 1017, 26365, 26367, 8402, 8400
34107, 26365, 26367, 8402, 8400, 26366, 26368, 8403, 8401
34108, 26366, 26368, 8403, 8401, 8750, 8751, 1090, 1089
34109, 8362, 8363, 1019, 1018, 26367, 26369, 8404, 8402
34110, 26367, 26369, 8404, 8402, 26368, 26370, 8405, 8403
34111, 26368, 26370, 8405, 8403, 8751, 8752, 1091, 1090
34112, 8363, 8364, 1020, 1019, 26369, 26371, 8406, 8404
34113, 26369, 26371, 8406, 8404, 26370, 26372, 8407, 8405
34114, 26370, 26372, 8407, 8405, 8752, 8753, 1092, 1091
34115, 8364, 8365, 1021, 1020, 26371, 26373, 8408, 8406
34116, 26371, 26373, 8408, 8406, 26372, 26374, 8409, 8407
34117, 26372, 26374, 8409, 8407, 8753, 8754, 1093, 1092
34118, 8365, 8366, 1022, 1021, 26373, 26375, 8410, 8408
34119, 26373, 26375, 8410, 8408, 26374, 26376, 8411, 8409
34120, 26374, 26376, 8411, 8409, 8754, 8755, 1094, 1093
34121, 8366, 8367, 1023, 1022, 26375, 26377, 8412, 8410
34122, 26375, 26377, 8412, 8410, 26376, 26378, 8413, 8411
34123, 26376, 26378, 8413, 8411, 8755, 8756, 1095, 1094
34124, 8367, 1068, 42, 1023, 26377, 8502, 1071, 8412
34125, 26377, 8502, 1071, 8412, 26378, 8503, 1072, 8413
34126, 26378, 8503, 1072, 8413, 8756, 1144, 46, 1095
*ELEMENT, type=C3D8, ELSET=Volume12
34127, 44, 1058, 8482, 1098, 51, 1149, 8757, 1147
34128, 1098, 8482, 8483, 1099, 1147, 8757, 8758, 1148
34129, 1099, 8483, 1134, 48, 1148, 8758, 1160, 52
34130, 1058, 1059, 8484, 8482, 1149, 1150, 8759, 8757
34131, 8482, 8484, 8485, 8483, 8757, 8759, 8760, 8758
34132, 8483, 8485, 1135, 1134, 8758, 8760, 1161, 1160
34133, 1059, 1060, 8486, 8484, 1150, 1151, 8761, 8759
34134, 8484, 8486, 8487, 8485, 8759, 8761, 8762, 8760
34135, 8485, 8487, 1136, 1135, 8760, 8762, 1162, 1161
34136, 1060, 1061, 8488, 8486, 1151, 1152, 8763, 8761
34137, 8486, 8488, 8489, 8487, 8761, 8763, 8764, 8762
34138, 8487, 8489, 1137, 1136, 8762, 8764, 1163, 1162
34139, 1061, 1062, 8490, 8488, 1152, 1153, 8765, 8763
34140, 8488, 8490, 8491, 8489, 8763, 8765, 8766, 8764
34141, 8489, 8491, 1138, 1137, 8764, 8766, 1164, 1163
34142, 1062, 1063, 8492, 8490, 1153, 1154, 8767, 8765
34143, 8490, 8492, 8493, 8491, 8765, 8767, 8768, 8766
34144, 8491, 8493, 1139, 1138, 8766, 8768, 1165, 1164
34145, 1063, 1064, 8494, 8492, 1154, 1155, 8769, 8767
34146, 8492, 8494, 8495, 8493, 8767, 8769, 8770, 8768
34147, 8493, 8495, 1140, 1139, 8768, 8770, 1166, 1165
34148, 1064, 1065, 8496, 8494, 1155, 1156, 8771, 8769
34149, 8494, 8496, 8497, 8495, 8769, 8771, 8772, 8770
34150, 8495, 8497, 1141, 1140, 8770, 8772, 1167, 1166
34151, 1065, 1066, 8498, 8496, 1156, 1157, 8773, 8771
34152, 8496, 8498, 8499, 8497, 8771, 8773, 8774, 8772
34153, 8497, 8499, 1142, 1141, 8772, 8774, 1168, 1167
34154, 1066, 1067, 8500, 8498, 1157, 1158, 8775, 8773
34155, 8498, 8500, 8501, 8499, 8773, 8775, 8776, 8774
34156, 8499, 8501, 1143, 1142, 8774, 8776, 1169, 1168
34157, 1067, 1068, 8502, 8500, 1158, 1159, 8777, 8775
34158, 8500, 8502, 8503, 8501, 8775, 8777, 8778, 8776
34159, 8501, 8503, 1144, 1143, 8776, 8778, 1170, 1169
34160, 1068, 42, 1071, 8502, 1159, 49, 1145, 8777
34161, 8502, 1071, 1072, 8503, 8777, 1145, 1146, 8778
34162, 8503, 1072, 46, 1144, 8778, 1146, 50, 1170
*ELEMENT, type=C3D8, ELSET=Volume13
34163, 2, 97, 1945, 121, 54, 1171, 8779, 1195
34164, 121, 1945, 1946, 122, 1195, 8779, 8780, 1196
34165, 122, 1946, 110, 4, 1196, 8780, 1184, 56
34166, 97, 98, 1947, 1945, 1171, 1172, 8781, 8779
34167, 1945, 1947, 1948, 1946, 8779, 8781, 8782, 8780
34168, 1946, 1948, 111, 110, 8780, 8782, 1185, 1184
34169, 98, 99, 1949, 1947, 1172, 1173, 8783, 8781
34170, 1947, 1949, 1950, 1948, 8781, 8783, 8784, 8782
34171, 1948, 1950, 112, 111, 8782, 8784, 1186, 1185
34172, 99, 100, 1951, 1949, 1173, 1174, 8785, 8783
34173, 1949, 1951, 1952, 1950, 8783, 8785, 8786, 8784
34174, 1950, 1952, 113, 112, 8784, 8786, 1187, 1186
34175, 100, 101, 1953, 1951, 1174, 1175, 8787, 8785
34176, 1951, 1953, 1954, 1952, 8785, 8787, 8788, 8786
34177, 1952, 1954, 114, 113, 8786, 8788, 1188, 1187
34178, 101, 102, 1955, 1953, 1175, 1176, 8789, 8787
34179, 1953, 1955, 1956, 1954, 8787, 8789, 8790, 8788
34180, 1954, 1956, 115, 114, 8788, 8790, 1189, 1188
34181, 102, 103, 1957, 1955, 1176, 1177, 8791, 8789
34182, 1955, 1957, 1958, 1956, 8789, 8791, 8792, 8790
34183, 1956, 1958, 116, 115, 8790, 8792, 1190, 1189
34184, 103, 104, 1959, 1957, 1177, 1178, 8793, 8791
34185, 1957, 1959, 1960, 1958, 8791, 8793, 8794, 8792
34186, 1958, 1960, 117, 116, 8792, 8794, 1191, 1190
34187, 104, 105, 1961, 1959, 1178, 1179, 8795, 8793
34188, 1959, 1961, 1962, 1960, 8793, 8795, 8796, 8794
34189, 1960, 1962, 118, 117, 8794, 8796, 1192, 1191
34190, 105, 106, 1963, 1961, 1179, 1180, 8797, 8795
34191, 1961, 1963, 1964, 1962, 8795, 8797, 8798, 8796
34192, 1962, 1964, 119, 118, 8796, 8798, 1193, 1192
34193, 106, 107, 1965, 1963, 1180, 1181, 8799, 8797
34194, 1963, 1965, 1966, 1964, 8797, 8799, 8800, 8798
34195, 1964, 1966, 120, 119, 8798, 8800, 1194, 1193
34196, 107, 1, 108, 1965, 1181, 53, 1182, 8799
34197, 1965, 108, 109, 1966, 8799, 1182, 1183, 8800
34198, 1966, 109, 3, 120, 8800, 1183, 55, 1194
*ELEMENT, type=C3D8, ELSET=Volume14
34199, 10, 332, 2840, 241, 67, 1356, 9307, 1379
34200, 332, 333, 2841, 2840, 1356, 1357, 9308, 9307
34201, 333, 334, 2842, 2841, 1357, 1358, 9309, 9308
34202, 334, 335, 2843, 2842, 1358, 1359, 9310, 9309
34203, 335, 336, 2844, 2843, 1359, 1360, 9311, 9310
34204, 336, 337, 2845, 2844, 1360, 1361, 9312, 9311
34205, 337, 338, 2846, 2845, 1361, 1362, 9313, 9312
34206, 338, 339, 2847, 2846, 1362, 1363, 9314, 9313
34207, 339, 340, 2848, 2847, 1363, 1364, 9315, 9314
34208, 340, 341, 2849, 2848, 1364, 1365, 9316, 9315
34209, 341, 342, 2850, 2849, 1365, 1366, 9317, 9316
34210, 342, 343, 2851, 2850, 1366, 1367, 9318, 9317
34211, 343, 344, 2852, 2851, 1367, 1368, 9319, 9318
34212, 344, 345, 2853, 2852, 1368, 1369, 9320, 9319
34213, 345, 346, 2854, 2853, 1369, 1370, 9321, 9320
34214, 346, 347, 2855, 2854, 1370, 1371, 9322, 9321
34215, 347, 348, 2856, 2855, 1371, 1372, 9323, 9322
34216, 348, 349, 2857, 2856, 1372, 1373, 9324, 9323
34217, 349, 350, 2858, 2857, 1373, 1374, 9325, 9324
34218, 350, 351, 2859, 2858, 1374, 1375, 9326, 9325
34219, 351, 352, 2860, 2859, 1375, 1376, 9327, 9326
34220, 352, 353, 2861, 2860, 1376, 1377, 9328, 9327
34221, 353, 354, 2862, 2861, 1377, 1378, 9329, 9328
34222, 354, 14, 355, 2862, 1378, 68, 1402, 9329
34223, 241, 2840, 2863, 242, 1379, 9307, 9330, 1380
34224, 2840, 2841, 2864, 2863, 9307, 9308, 9331, 9330
34225, 2841, 2842, 2865, 2864, 9308, 9309, 9332, 9331
34226, 2842, 2843, 2866, 2865, 9309, 9310, 9333, 9332
34227, 2843, 2844, 2867, 2866, 9310, 9311, 9334, 9333
34228, 2844, 2845, 2868, 2867, 9311, 9312, 9335, 9334
34229, 2845, 2846, 2869, 2868, 9312, 9313, 9336, 9335
34230, 2846, 2847, 2870, 2869, 9313, 9314, 9337, 9336
34231, 2847, 2848, 2871, 2870, 9314, 9315, 9338, 9337
34232, 2848, 2849, 2872, 2871, 9315, 9316, 9339, 9338
34233, 2849, 2850, 2873, 2872, 9316, 9317, 9340, 9339
34234, 2850, 2851, 2874, 2873, 9317, 9318, 9341, 9340
34235, 2851, 2852, 2875, 2874, 9318, 9319, 9342, 9341
34236, 2852, 2853, 2876, 2875, 9319, 9320, 9343, 9342
34237, 2853, 2854, 2877, 2876, 9320, 9321, 9344, 9343
34238, 2854, 2855, 2878, 2877, 9321, 9322, 9345, 9344
34239, 2855, 2856, 2879, 2878, 9322, 9323, 9346, 9345
34240, 2856, 2857, 2880, 2879, 9323, 9324, 9347, 9346
34241, 2857, 2858, 2881, 2880, 9324, 9325, 9348, 9347
34242, 2858, 2859, 2882, 2881, 9325, 9326, 9349, 9348
34243, 2859, 2860, 2883, 2882, 9326, 9327, 9350, 9349
34244, 2860, 2861, 2884, 2883, 9327, 9328, 9351, 9350
34245, 2861, 2862, 2885, 2884, 9328, 9329, 9352, 9351
34246, 2862, 355, 356, 2885, 9329, 1402, 1403, 9352
34247, 242, 2863, 2886, 243, 1380, 9330, 9353, 1381
34248, 2863, 2864, 2887, 2886, 9330, 9331, 9354, 9353
34249, 2864, 2865, 2888, 2887, 9331, 9332, 9355, 9354
34250, 2865, 2866, 2889, 2888, 9332, 9333, 9356, 9355
34251, 2866, 2867, 2890, 2889, 9333, 9334, 9357, 9356
34252, 2867, 2868, 2891, 2890, 9334, 9335, 9358, 9357
34253, 2868, 2869, 2892, 2891, 9335, 9336, 9359, 9358
34254, 2869, 2870, 2893, 2892, 9336, 9337, 9360, 9359
34255, 2870, 2871, 2894, 2893, 9337, 9338, 9361, 9360
34256, 2871, 2872, 2895, 2894, 9338, 9339, 9362, 9361
34257, 2872, 2873, 2896, 2895, 9339, 9340, 9363, 9362
34258, 2873, 2874, 2897, 2896, 9340, 9341, 9364, 9363
34259, 2874, 2875, 2898, 2897, 9341, 9342, 9365, 9364
34260, 2875, 2876, 2899, 2898, 9342, 9343, 9366, 9365
34261, 2876, 2877, 2900, 2899, 9343, 9344, 9367, 9366
34262, 2877, 2878, 2901, 2900, 9344, 9345, 9368, 9367
34263, 2878, 2879, 2902, 2901, 9345, 9346, 9369, 9368
34264, 2879, 2880, 2903, 2902, 9346, 9347, 9370, 9369
34265, 2880, 2881, 2904, 2903, 9347, 9348, 9371, 9370
34266, 2881, 2882, 2905, 2904, 9348, 9349, 9372, 9371
34267, 2882, 2883, 2906, 2905, 9349, 9350, 9373, 9372
34268, 2883, 2884, 2907, 2906, 9350, 9351, 9374, 9373
34269, 2884, 2885, 2908, 2907, 9351, 9352, 9375, 9374
34270, 2885, 356, 357, 2908, 9352, 1403, 1404, 9375
34271, 243, 2886, 2909, 244, 1381, 9353, 9376, 1382
34272, 2886, 2887, 2910, 2909, 9353, 9354, 9377, 9376
34273, 2887, 2888, 2911, 2910, 9354, 9355, 9378, 9377
34274, 2888, 2889, 2912, 2911, 9355, 9356, 9379, 9378
34275, 2889, 2890, 2913, 2912, 9356, 9357, 9380, 9379
34276, 2890, 2891, 2914, 2913, 9357, 9358, 9381, 9380
34277, 2891, 2892, 2915, 2914, 9358, 9359, 9382, 9381
34278, 2892, 2893, 2916, 2915, 9359, 9360, 9383, 9382
34279, 2893, 2894, 2917, 2916, 9360, 9361, 9384, 9383
34280, 2894, 2895, 2918, 2917, 9361, 9362, 9385, 9384
34281, 2895, 2896, 2919, 2918, 9362, 9363, 9386, 9385
34282, 2896, 2897, 2920, 2919, 9363, 9364, 9387, 9386
34283, 2897, 2898, 2921, 2920, 9364, 9365, 9388, 9387
34284, 2898, 2899, 2922, 2921, 9365, 9366, 9389, 9388
34285, 2899, 2900, 2923, 2922, 9366, 9367, 9390, 9389
34286, 2900, 2901, 2924, 2923, 9367, 9368, 9391, 9390
34287, 2901, 2902, 2925, 2924, 9368, 9369, 9392, 9391
34288, 2902, 2903, 2926, 2925, 9369, 9370, 9393, 9392
34289, 2903, 2904, 2927, 2926, 9370, 9371, 9394, 9393
34290, 2904, 2905, 2928, 2927, 9371, 9372, 9395, 9394
34291, 2905, 2906, 2929, 2928, 9372, 9373, 9396, 9395
34292, 2906, 2907, 2930, 2929, 9373, 9374, 9397, 9396
34293, 2907, 2908, 2931, 2930, 9374, 9375, 9398, 9397
34294, 2908, 357, 358, 2931, 9375, 1404, 1405, 9398
34295, 244, 2909, 2932, 245, 1382, 9376, 9399, 1383
34296, 2909, 2910, 2933, 2932, 9376, 9377, 9400, 9399
34297, 2910, 2911, 2934, 2933, 9377, 9378, 9401, 9400
34298, 2911, 2912, 2935, 2934, 9378, 9379, 9402, 9401
34299, 2912, 2913, 2936, 2935, 9379, 9380, 9403, 9402
34300, 2913, 2914, 2937, 2936, 9380, 9381, 9404, 9403
34301, 2914, 2915, 2938, 2937, 9381, 9382, 9405, 9404
34302, 2915, 2916, 2939, 2938, 9382, 9383, 9406, 9405
34303, 2916, 2917, 2940, 2939, 9383, 9384, 9407, 9406
34304, 2917, 2918, 2941, 2940, 9384, 9385, 9408, 9407
34305, 2918, 2919, 2942, 2941, 9385, 9386, 9409, 9408
34306, 2919, 2920, 2943, 2942, 9386, 9387, 9410, 9409
34307, 2920, 2921, 2944, 2943, 9387, 9388, 9411, 9410
34308, 2921, 2922, 2945, 2944, 9388, 9389, 9412, 9411
34309, 2922, 2923, 2946, 2945, 9389, 9390, 9413, 9412
34310, 2923, 2924, 2947, 2946, 9390, 9391, 9414, 9413
34311, 2924, 2925, 2948, 2947, 9391, 9392, 9415, 9414
34312, 2925, 2926, 2949, 2948, 9392, 9393, 9416, 9415
34313, 2926, 2927, 2950, 2949, 9393, 9394, 9417, 9416
34314, 2927, 2928, 2951, 2950, 9394, 9395, 9418, 9417
34315, 2928, 2929, 2952, 2951, 9395, 9396, 9419, 9418
34316, 2929, 2930, 2953, 2952, 9396, 9397, 9420, 9419
34317, 2930, 2931, 2954, 2953, 9397, 9398, 9421, 9420
34318, 2931, 358, 359, 2954, 9398, 1405, 1406, 9421
34319, 245, 2932, 2955, 246, 1383, 9399, 9422, 1384
34320, 2932, 2933, 2956, 2955, 9399, 9400, 9423, 9422
34321, 2933, 2934, 2957, 2956, 9400, 9401, 9424, 9423
34322, 2934, 2935, 2958, 2957, 9401, 9402, 9425, 9424
34323, 2935, 2936, 2959, 2958, 9402, 9403, 9426, 9425
34324, 2936, 2937, 2960, 2959, 9403, 9404, 9427, 9426
34325, 2937, 2938, 2961, 2960, 9404, 9405, 9428, 9427
34326, 2938, 2939, 2962, 2961, 9405, 9406, 9429, 9428
34327, 2939, 2940, 2963, 2962, 9406, 9407, 9430, 9429
34328, 2940, 2941, 2964, 2963, 9407, 9408, 9431, 9430
34329, 2941, 2942, 2965, 2964, 9408, 9409, 9432, 9431
34330, 2942, 2943, 2966, 2965, 9409, 9410, 9433, 9432
34331, 2943, 2944, 2967, 2966, 9410, 9411, 9434, 9433
34332, 2944, 2945, 2968, 2967, 9411, 9412, 9435, 9434
34333, 2945, 2946, 2969, 2968, 9412, 9413, 9436, 9435
34334, 2946, 2947, 2970, 2969, 9413, 9414, 9437, 9436
34335, 2947, 2948, 2971, 2970, 9414, 9415, 9438, 9437
34336, 2948, 2949, 2972, 2971, 9415, 9416, 9439, 9438
34337, 2949, 2950, 2973, 2972, 9416, 9417, 9440, 9439
34338, 2950, 2951, 2974, 2973, 9417, 9418, 9441, 9440
34339, 2951, 2952, 2975, 2974, 9418, 9419, 9442, 9441
34340, 2952, 2953, 2976, 2975, 9419, 9420, 9443, 9442
34341, 2953, 2954, 2977, 2976, 9420, 9421, 9444, 9443
34342, 2954, 359, 360, 2977, 9421, 1406, 1407, 9444
34343, 246, 2955, 2978, 247, 1384, 9422, 9445, 1385
34344, 2955, 2956, 2979, 2978, 9422, 9423, 9446, 9445
34345, 2956, 2957, 2980, 2979, 9423, 9424, 9447, 9446
34346, 2957, 2958, 2981, 2980, 9424, 9425, 9448, 9447
34347, 2958, 2959, 2982, 2981, 9425, 9426, 9449, 9448
34348, 2959, 2960, 2983, 2982, 9426, 9427, 9450, 9449
34349, 2960, 2961, 2984, 2983, 9427, 9428, 9451, 9450
34350, 2961, 2962, 2985, 2984, 9428, 9429, 9452, 9451
34351, 2962, 2963, 2986, 2985, 9429, 9430, 9453, 9452
34352, 2963, 2964, 2987, 2986, 9430, 9431, 9454, 9453
34353, 2964, 2965, 2988, 2987, 9431, 9432, 9455, 9454
34354, 2965, 2966, 2989, 2988, 9432, 9433, 9456, 9455
34355, 2966, 2967, 2990, 2989, 9433, 9434, 9457, 9456
34356, 2967, 2968, 2991, 2990, 9434, 9435, 9458, 9457
34357, 2968, 2969, 2992, 2991, 9435, 9436, 9459, 9458
34358, 2969, 2970, 2993, 2992, 9436, 9437, 9460, 9459
34359, 2970, 2971, 2994, 2993, 9437, 9438, 9461, 9460
34360, 2971, 2972, 2995, 2994, 9438, 9439, 9462, 9461
34361, 2972, 2973, 2996, 2995, 9439, 9440, 9463, 9462
34362, 2973, 2974, 2997, 2996, 9440, 9441, 9464, 9463
34363, 2974, 2975, 2998, 2997, 9441, 9442, 9465, 9464
34364, 2975, 2976, 2999, 2998, 9442, 9443, 9466, 9465
34365, 2976, 2977, 3000, 2999, 9443, 9444, 9467, 9466
34366, 2977, 360, 361, 3000, 9444, 1407, 1408, 9467
34367, 247, 2978, 3001, 248, 1385, 9445, 9468, 1386
34368, 2978, 2979, 3002, 3001, 9445, 9446, 9469, 9468
34369, 2979, 2980, 3003, 3002, 9446, 9447, 9470, 9469
34370, 2980, 2981, 3004, 3003, 9447, 9448, 9471, 9470
34371, 2981, 2982, 3005, 3004, 9448, 9449, 9472, 9471
34372, 2982, 2983, 3006, 3005, 9449, 9450, 9473, 9472
34373, 2983, 2984, 3007, 3006, 9450, 9451, 9474, 9473
34374, 2984, 2985, 3008, 3007, 9451, 9452, 9475, 9474
34375, 2985, 2986, 3009, 3008, 9452, 9453, 9476, 9475
34376, 2986, 2987, 3010, 3009, 9453, 9454, 9477, 9476
34377, 2987, 2988, 3011, 3010, 9454, 9455, 9478, 9477
34378, 2988, 2989, 3012, 3011, 9455, 9456, 9479, 9478
34379, 2989, 2990, 3013, 3012, 9456, 9457, 9480, 9479
34380, 2990, 2991, 3014, 3013, 9457, 9458, 9481, 9480
34381, 2991, 2992, 3015, 3014, 9458, 9459, 9482, 9481
34382, 2992, 2993, 3016, 3015, 9459, 9460, 9483, 9482
34383, 2993, 2994, 3017, 3016, 9460, 9461, 9484, 9483
34384, 2994, 2995, 3018, 3017, 9461, 9462, 9485, 9484
34385, 2995, 2996, 3019, 3018, 9462, 9463, 9486, 9485
34386, 2996, 2997, 3020, 3019, 9463, 9464, 9487, 9486
34387, 2997, 2998, 3021, 3020, 9464, 9465, 9488, 9487
34388, 2998, 2999, 3022, 3021, 9465, 9466, 9489, 9488
34389, 2999, 3000, 3023, 3022, 9466, 9467, 9490, 9489
34390, 3000, 361, 362, 3023, 9467, 1408, 1409, 9490
34391, 248, 3001, 3024, 249, 1386, 9468, 9491, 1387
34392, 3001, 3002, 3025, 3024, 9468, 9469, 9492, 9491
34393, 3002, 3003, 3026, 3025, 9469, 9470, 9493, 9492
34394, 3003, 3004, 3027, 3026, 9470, 9471, 9494, 9493
34395, 3004, 3005, 3028, 3027, 9471, 9472, 9495, 9494
34396, 3005, 3006, 3029, 3028, 9472, 9473, 9496, 9495
34397, 3006, 3007, 3030, 3029, 9473, 9474, 9497, 9496
34398, 3007, 3008, 3031, 3030, 9474, 9475, 9498, 9497
34399, 3008, 3009, 3032, 3031, 9475, 9476, 9499, 9498
34400, 3009, 3010, 3033, 3032, 9476, 9477, 9500, 9499
34401, 3010, 3011, 3034, 3033, 9477, 9478, 9501, 9500
34402, 3011, 3012, 3035, 3034, 9478, 9479, 9502, 9501
34403, 3012, 3013, 3036, 3035, 9479, 9480, 9503, 9502
34404, 3013, 3014, 3037, 3036, 9480, 9481, 9504, 9503
34405, 3014, 3015, 3038, 3037, 9481, 9482, 9505, 9504
34406, 3015, 3016, 3039, 3038, 9482, 9483, 9506, 9505
34407, 3016, 3017, 3040, 3039, 9483, 9484, 9507, 9506
34408, 3017, 3018, 3041, 3040, 9484, 9485, 9508, 9507
34409, 3018, 3019, 3042, 3041, 9485, 9486, 9509, 9508
34410, 3019, 3020, 3043, 3042, 9486, 9487, 9510, 9509
34411, 3020, 3021, 3044, 3043, 9487, 9488, 9511, 9510
34412, 3021, 3022, 3045, 3044, 9488, 9489, 9512, 9511
34413, 3022, 3023, 3046, 3045, 9489, 9490, 9513, 9512
34414, 3023, 362, 363, 3046, 9490, 1409, 1410, 9513
34415, 249, 3024, 3047, 250, 1387, 9491, 9514, 1388
34416, 3024, 3025, 3048, 3047, 9491, 9492, 9515, 9514
34417, 3025, 3026, 3049, 3048, 9492, 9493, 9516, 9515
34418, 3026, 3027, 3050, 3049, 9493, 9494, 9517, 9516
34419, 3027, 3028, 3051, 3050, 9494, 9495, 9518, 9517
34420, 3028, 3029, 3052, 3051, 9495, 9496, 9519, 9518
34421, 3029, 3030, 3053, 3052, 9496, 9497, 9520, 9519
34422, 3030, 3031, 3054, 3053, 9497, 9498, 9521, 9520
34423, 3031, 3032, 3055, 3054, 9498, 9499, 9522, 9521
34424, 3032, 3033, 3056, 3055, 9499, 9500, 9523, 9522
34425, 3033, 3034, 3057, 3056, 9500, 9501, 9524, 9523
34426, 3034, 3035, 3058, 3057, 9501, 9502, 9525, 9524
34427, 3035, 3036, 3059, 3058, 9502, 9503, 9526, 9525
34428, 3036, 3037, 3060, 3059, 9503, 9504, 9527, 9526
34429, 3037, 3038, 3061, 3060, 9504, 9505, 9528, 9527
34430, 3038, 3039, 3062, 3061, 9505, 9506, 9529, 9528
34431, 3039, 3040, 3063, 3062, 9506, 9507, 9530, 9529
34432, 3040, 3041, 3064, 3063, 9507, 9508, 9531, 9530
34433, 3041, 3042, 3065, 3064, 9508, 9509, 9532, 9531
34434, 3042, 3043, 3066, 3065, 9509, 9510, 9533, 9532
34435, 3043, 3044, 3067, 3066, 9510, 9511, 9534, 9533
34436, 3044, 3045, 3068, 3067, 9511, 9512, 9535, 9534
34437, 3045, 3046, 3069, 3068, 9512, 9513, 9536, 9535
34438, 3046, 363, 364, 3069, 9513, 1410, 1411, 9536
34439, 250, 3047, 3070, 251, 1388, 9514, 9537, 1389
34440, 3047, 3048, 3071, 3070, 9514, 9515, 9538, 9537
34441, 3048, 3049, 3072, 3071, 9515, 9516, 9539, 9538
34442, 3049, 3050, 3073, 3072, 9516, 9517, 9540, 9539
34443, 3050, 3051, 3074, 3073, 9517, 9518, 9541, 9540
34444, 3051, 3052, 3075, 3074, 9518, 9519, 9542, 9541
34445, 3052, 3053, 3076, 3075, 9519, 9520, 9543, 9542
34446, 3053, 3054, 3077, 3076, 9520, 9521, 9544, 9543
34447, 3054, 3055, 3078, 3077, 9521, 9522, 9545, 9544
34448, 3055, 3056, 3079, 3078, 9522, 9523, 9546, 9545
34449, 3056, 3057, 3080, 3079, 9523, 9524, 9547, 9546
34450, 3057, 3058, 3081, 3080, 9524, 9525, 9548, 9547
34451, 3058, 3059, 3082, 3081, 9525, 9526, 9549, 9548
34452, 3059, 3060, 3083, 3082, 9526, 9527, 9550, 9549
34453, 3060, 3061, 3084, 3083, 9527, 9528, 9551, 9550
34454, 3061, 3062, 3085, 3084, 9528, 9529, 9552, 9551
34455, 3062, 3063, 3086, 3085, 9529, 9530, 9553, 9552
34456, 3063, 3064, 3087, 3086, 9530, 9531, 9554, 9553
34457, 3064, 3065, 3088, 3087, 9531, 9532, 9555, 9554
34458, 3065, 3066, 3089, 3088, 9532, 9533, 9556, 9555
34459, 3066, 3067, 3090, 3089, 9533, 9534, 9557, 9556
34460, 3067, 3068, 3091, 3090, 9534, 9535, 9558, 9557
34461, 3068, 3069, 3092, 3091, 9535, 9536, 9559, 9558
34462, 3069, 364, 365, 3092, 9536, 1411, 1412, 9559
34463, 251, 3070, 3093, 252, 1389, 9537, 9560, 1390
34464, 3070, 3071, 3094, 3093, 9537, 9538, 9561, 9560
34465, 3071, 3072, 3095, 3094, 9538, 9539, 9562, 9561
34466, 3072, 3073, 3096, 3095, 9539, 9540, 9563, 9562
34467, 3073, 3074, 3097, 3096, 9540, 9541, 9564, 9563
34468, 3074, 3075, 3098, 3097, 9541, 9542, 9565, 9564
34469, 3075, 3076, 3099, 3098, 9542, 9543, 9566, 9565
34470, 3076, 3077, 3100, 3099, 9543, 9544, 9567, 9566
34471, 3077, 3078, 3101, 3100, 9544, 9545, 9568, 9567
34472, 3078, 3079, 3102, 3101, 9545, 9546, 9569, 9568
34473, 3079, 3080, 3103, 3102, 9546, 9547, 9570, 9569
34474, 3080, 3081, 3104, 3103, 9547, 9548, 9571, 9570
34475, 3081, 3082, 3105, 3104, 9548, 9549, 9572, 9571
34476, 3082, 3083, 3106, 3105, 9549, 9550, 9573, 9572
34477, 3083, 3084, 3107, 3106, 9550, 9551, 9574, 9573
34478, 3084, 3085, 3108, 3107, 9551, 9552, 9575, 9574
34479, 3085, 3086, 3109, 3108, 9552, 9553, 9576, 9575
34480, 3086, 3087, 3110, 3109, 9553, 9554, 9577, 9576
34481, 3087, 3088, 3111, 3110, 9554, 9555, 9578, 9577
34482, 3088, 3089, 3112, 3111, 9555, 9556, 9579, 9578
34483, 3089, 3090, 3113, 3112, 9556, 9557, 9580, 9579
34484, 3090, 3091, 3114, 3113, 9557, 9558, 9581, 9580
34485, 3091, 3092, 3115, 3114, 9558, 9559, 9582, 9581
34486, 3092, 365, 366, 3115, 9559, 1412, 1413, 9582
34487, 252, 3093, 3116, 253, 1390, 9560, 9583, 1391
34488, 3093, 3094, 3117, 3116, 9560, 9561, 9584, 9583
34489, 3094, 3095, 3118, 3117, 9561, 9562, 9585, 9584
34490, 3095, 3096, 3119, 3118, 9562, 9563, 9586, 9585
34491, 3096, 3097, 3120, 3119, 9563, 9564, 9587, 9586
34492, 3097, 3098, 3121, 3120, 9564, 9565, 9588, 9587
34493, 3098, 3099, 3122, 3121, 9565, 9566, 9589, 9588
34494, 3099, 3100, 3123, 3122, 9566, 9567, 9590, 9589
34495, 3100, 3101, 3124, 3123, 9567, 9568, 9591, 9590
34496, 3101, 3102, 3125, 3124, 9568, 9569, 9592, 9591
34497, 3102, 3103, 3126, 3125, 9569, 9570, 9593, 9592
34498, 3103, 3104, 3127, 3126, 9570, 9571, 9594, 9593
34499, 3104, 3105, 3128, 3127, 9571, 9572, 9595, 9594
34500, 3105, 3106, 3129, 3128, 9572, 9573, 9596, 9595
34501, 3106, 3107, 3130, 3129, 9573, 9574, 9597, 9596
34502, 3107, 3108, 3131, 3130, 9574, 9575, 9598, 9597
34503, 3108, 3109, 3132, 3131, 9575, 9576, 9599, 9598
34504, 3109, 3110, 3133, 3132, 9576, 9577, 9600, 9599
34505, 3110, 3111, 3134, 3133, 9577, 9578, 9601, 9600
34506, 3111, 3112, 3135, 3134, 9578, 9579, 9602, 9601
34507, 3112, 3113, 3136, 3135, 9579, 9580, 9603, 9602
34508, 3113, 3114, 3137, 3136, 9580, 9581, 9604, 9603
34509, 3114, 3115, 3138, 3137, 9581, 9582, 9605, 9604
34510, 3115, 366, 367, 3138, 9582, 1413, 1414, 9605
34511, 253, 3116, 3139, 254, 1391, 9583, 9606, 1392
34512, 3116, 3117, 3140, 3139, 9583, 9584, 9607, 9606
34513, 3117, 3118, 3141, 3140, 9584, 9585, 9608, 9607
34514, 3118, 3119, 3142, 3141, 9585, 9586, 9609, 9608
34515, 3119, 3120, 3143, 3142, 9586, 9587, 9610, 9609
34516, 3120, 3121, 3144, 3143, 9587, 9588, 9611, 9610
34517, 3121, 3122, 3145, 3144, 9588, 9589, 9612, 9611
34518, 3122, 3123, 3146, 3145, 9589, 9590, 9613, 9612
34519, 3123, 3124, 3147, 3146, 9590, 9591, 9614, 9613
34520, 3124, 3125, 3148, 3147, 9591, 9592, 9615, 9614
34521, 3125, 3126, 3149, 3148, 9592, 9593, 9616, 9615
34522, 3126, 3127, 3150, 3149, 9593, 9594, 9617, 9616
34523, 3127, 3128, 3151, 3150, 9594, 9595, 9618, 9617
34524, 3128, 3129, 3152, 3151, 9595, 9596, 9619, 9618
34525, 3129, 3130, 3153, 3152, 9596, 9597, 9620, 9619
34526, 3130, 3131, 3154, 3153, 9597, 9598, 9621, 9620
34527, 3131, 3132, 3155, 3154, 9598, 9599, 9622, 9621
34528, 3132, 3133, 3156, 3155, 9599, 9600, 9623, 9622
34529, 3133, 3134, 3157, 3156, 9600, 9601, 9624, 9623
34530, 3134, 3135, 3158, 3157, 9601, 9602, 9625, 9624
34531, 3135, 3136, 3159, 3158, 9602, 9603, 9626, 9625
34532, 3136, 3137, 3160, 3159, 9603, 9604, 9627, 9626
34533, 3137, 3138, 3161, 3160, 9604, 9605, 9628, 9627
34534, 3138, 367, 368, 3161, 9605, 1414, 1415, 9628
34535, 254, 3139, 3162, 255, 1392, 9606, 9629, 1393
34536, 3139, 3140, 3163, 3162, 9606, 9607, 9630, 9629
34537, 3140, 3141, 3164, 3163, 9607, 9608, 9631, 9630
34538, 3141, 3142, 3165, 3164, 9608, 9609, 9632, 9631
34539, 3142, 3143, 3166, 3165, 9609, 9610, 9633, 9632
34540, 3143, 3144, 3167, 3166, 9610, 9611, 9634, 9633
34541, 3144, 3145, 3168, 3167, 9611, 9612, 9635, 9634
34542, 3145, 3146, 3169, 3168, 9612, 9613, 9636, 9635
34543, 3146, 3147, 3170, 3169, 9613, 9614, 9637, 9636
34544, 3147, 3148, 3171, 3170, 9614, 9615, 9638, 9637
34545, 3148, 3149, 3172, 3171, 9615, 9616, 9639, 9638
34546, 3149, 3150, 3173, 3172, 9616, 9617, 9640, 9639
34547, 3150, 3151, 3174, 3173, 9617, 9618, 9641, 9640
34548, 3151, 3152, 3175, 3174, 9618, 9619, 9642, 9641
34549, 3152, 3153, 3176, 3175, 9619, 9620, 9643, 9642
34550, 3153, 3154, 3177, 3176, 9620, 9621, 9644, 9643
34551, 3154, 3155, 3178, 3177, 9621, 9622, 9645, 9644
34552, 3155, 3156, 3179, 3178, 9622, 9623, 9646, 9645
34553, 3156, 3157, 3180, 3179, 9623, 9624, 9647, 9646
34554, 3157, 3158, 3181, 3180, 9624, 9625, 9648, 9647
34555, 3158, 3159, 3182, 3181, 9625, 9626, 9649, 9648
34556, 3159, 3160, 3183, 3182, 9626, 9627, 9650, 9649
34557, 3160, 3161, 3184, 3183, 9627, 9628, 9651, 9650
34558, 3161, 368, 369, 3184, 9628, 1415, 1416, 9651
34559, 255, 3162, 3185, 256, 1393, 9629, 9652, 1394
34560, 3162, 3163, 3186, 3185, 9629, 9630, 9653, 9652
34561, 3163, 3164, 3187, 3186, 9630, 9631, 9654, 9653
34562, 3164, 3165, 3188, 3187, 9631, 9632, 9655, 9654
34563, 3165, 3166, 3189, 3188, 9632, 9633, 9656, 9655
34564, 3166, 3167, 3190, 3189, 9633, 9634, 9657, 9656
34565, 3167, 3168, 3191, 3190, 9634, 9635, 9658, 9657
34566, 3168, 3169, 3192, 3191, 9635, 9636, 9659, 9658
34567, 3169, 3170, 3193, 3192, 9636, 9637, 9660, 9659
34568, 3170, 3171, 3194, 3193, 9637, 9638, 9661, 9660
34569, 3171, 3172, 3195, 3194, 9638, 9639, 9662, 9661
34570, 3172, 3173, 3196, 3195, 9639, 9640, 9663, 9662
34571, 3173, 3174, 3197, 3196, 9640, 9641, 9664, 9663
34572, 3174, 3175, 3198, 3197, 9641, 9642, 9665, 9664
34573, 3175, 3176, 3199, 3198, 9642, 9643, 9666, 9665
34574, 3176, 3177, 3200, 3199, 9643, 9644, 9667, 9666
34575, 3177, 3178, 3201, 3200, 9644, 9645, 9668, 9667
34576, 3178, 3179, 3202, 3201, 9645, 9646, 9669, 9668
34577, 3179, 3180, 3203, 3202, 9646, 9647, 9670, 9669
34578, 3180, 3181, 3204, 3203, 9647, 9648, 9671, 9670
34579, 3181, 3182, 3205, 3204, 9648, 9649, 9672, 9671
34580, 3182, 3183, 3206, 3205, 9649, 9650, 9673, 9672
34581, 3183, 3184, 3207, 3206, 9650, 9651, 9674, 9673
34582, 3184, 369, 370, 3207, 9651, 1416, 1417, 9674
34583, 256, 3185, 3208, 257, 1394, 9652, 9675, 1395
34584, 3185, 3186, 3209, 3208, 9652, 9653, 9676, 9675
34585, 3186, 3187, 3210, 3209, 9653, 9654, 9677, 9676
34586, 3187, 3188, 3211, 3210, 9654, 9655, 9678, 9677
34587, 3188, 3189, 3212, 3211, 9655, 9656, 9679, 9678
34588, 3189, 3190, 3213, 3212, 9656, 9657, 9680, 9679
34589, 3190, 3191, 3214, 3213, 9657, 9658, 9681, 9680
34590, 3191, 3192, 3215, 3214, 9658, 9659, 9682, 9681
34591, 3192, 3193, 3216, 3215, 9659, 9660, 9683, 9682
34592, 3193, 3194, 3217, 3216, 9660, 9661, 9684, 9683
34593, 3194, 3195, 3218, 3217, 9661, 9662, 9685, 9684
34594, 3195, 3196, 3219, 3218, 9662, 9663, 9686, 9685
34595, 3196, 3197, 3220, 3219, 9663, 9664, 9687, 9686
34596, 3197, 3198, 3221, 3220, 9664, 9665, 9688, 9687
34597, 3198, 3199, 3222, 3221, 9665, 9666, 9689, 9688
34598, 3199, 3200, 3223, 3222, 9666, 9667, 9690, 9689
34599, 3200, 3201, 3224, 3223, 9667, 9668, 9691, 9690
34600, 3201, 3202, 3225, 3224, 9668, 9669, 9692, 9691
34601, 3202, 3203, 3226, 3225, 9669, 9670, 9693, 9692
34602, 3203, 3204, 3227, 3226, 9670, 9671, 9694, 9693
34603, 3204, 3205, 3228, 3227, 9671, 9672, 9695, 9694
34604, 3205, 3206, 3229, 3228, 9672, 9673, 9696, 9695
34605, 3206, 3207, 3230, 3229, 9673, 9674, 9697, 9696
34606, 3207, 370, 371, 3230, 9674, 1417, 1418, 9697
34607, 257, 3208, 3231, 258, 1395, 9675, 9698, 1396
34608, 3208, 3209, 3232, 3231, 9675, 9676, 9699, 9698
34609, 3209, 3210, 3233, 3232, 9676, 9677, 9700, 9699
34610, 3210, 3211, 3234, 3233, 9677, 9678, 9701, 9700
34611, 3211, 3212, 3235, 3234, 9678, 9679, 9702, 9701
34612, 3212, 3213, 3236, 3235, 9679, 9680, 9703, 9702
34613, 3213, 3214, 3237, 3236, 9680, 9681, 9704, 9703
34614, 3214, 3215, 3238, 3237, 9681, 9682, 9705, 9704
34615, 3215, 3216, 3239, 3238, 9682, 9683, 9706, 9705
34616, 3216, 3217, 3240, 3239, 9683, 9684, 9707, 9706
34617, 3217, 3218, 3241, 3240, 9684, 9685, 9708, 9707
34618, 3218, 3219, 3242, 3241, 9685, 9686, 9709, 9708
34619, 3219, 3220, 3243, 3242, 9686, 9687, 9710, 9709
34620, 3220, 3221, 3244, 3243, 9687, 9688, 9711, 9710
34621, 3221, 3222, 3245, 3244, 9688, 9689, 9712, 9711
34622, 3222, 3223, 3246, 3245, 9689, 9690, 9713, 9712
34623, 3223, 3224, 3247, 3246, 9690, 9691, 9714, 9713
34624, 3224, 3225, 3248, 3247, 9691, 9692, 9715, 9714
34625, 3225, 3226, 3249, 3248, 9692, 9693, 9716, 9715
34626, 3226, 3227, 3250, 3249, 9693, 9694, 9717, 9716
34627, 3227, 3228, 3251, 3250, 9694, 9695, 9718, 9717
34628, 3228, 3229, 3252, 3251, 9695, 9696, 9719, 9718
34629, 3229, 3230, 3253, 3252, 9696, 9697, 9720, 9719
34630, 3230, 371, 372, 3253, 9697, 1418, 1419, 9720
34631, 258, 3231, 3254, 259, 1396, 9698, 9721, 1397
34632, 3231, 3232, 3255, 3254, 9698, 9699, 9722, 9721
34633, 3232, 3233, 3256, 3255, 9699, 9700, 9723, 9722
34634, 3233, 3234, 3257, 3256, 9700, 9701, 9724, 9723
34635, 3234, 3235, 3258, 3257, 9701, 9702, 9725, 9724
34636, 3235, 3236, 3259, 3258, 9702, 9703, 9726, 9725
34637, 3236, 3237, 3260, 3259, 9703, 9704, 9727, 9726
34638, 3237, 3238, 3261, 3260, 9704, 9705, 9728, 9727
34639, 3238, 3239, 3262, 3261, 9705, 9706, 9729, 9728
34640, 3239, 3240, 3263, 3262, 9706, 9707, 9730, 9729
34641, 3240, 3241, 3264, 3263, 9707, 9708, 9731, 9730
34642, 3241, 3242, 3265, 3264, 9708, 9709, 9732, 9731
34643, 3242, 3243, 3266, 3265, 9709, 9710, 9733, 9732
34644, 3243, 3244, 3267, 3266, 9710, 9711, 9734, 9733
34645, 3244, 3245, 3268, 3267, 9711, 9712, 9735, 9734
34646, 3245, 3246, 3269, 3268, 9712, 9713, 9736, 9735
34647, 3246, 3247, 3270, 3269, 9713, 9714, 9737, 9736
34648, 3247, 3248, 3271, 3270, 9714, 9715, 9738, 9737
34649, 3248, 3249, 3272, 3271, 9715, 9716, 9739, 9738
34650, 3249, 3250, 3273, 3272, 9716, 9717, 9740, 9739
34651, 3250, 3251, 3274, 3273, 9717, 9718, 9741, 9740
34652, 3251, 3252, 3275, 3274, 9718, 9719, 9742, 9741
34653, 3252, 3253, 3276, 3275, 9719, 9720, 9743, 9742
34654, 3253, 372, 373, 3276, 9720, 1419, 1420, 9743
34655, 259, 3254, 3277, 260, 1397, 9721, 9744, 1398
34656, 3254, 3255, 3278, 3277, 9721, 9722, 9745, 9744
34657, 3255, 3256, 3279, 3278, 9722, 9723, 9746, 9745
34658, 3256, 3257, 3280, 3279, 9723, 9724, 9747, 9746
34659, 3257, 3258, 3281, 3280, 9724, 9725, 9748, 9747
34660, 3258, 3259, 3282, 3281, 9725, 9726, 9749, 9748
34661, 3259, 3260, 3283, 3282, 9726, 9727, 9750, 9749
34662, 3260, 3261, 3284, 3283, 9727, 9728, 9751, 9750
34663, 3261, 3262, 3285, 3284, 9728, 9729, 9752, 9751
34664, 3262, 3263, 3286, 3285, 9729, 9730, 9753, 9752
34665, 3263, 3264, 3287, 3286, 9730, 9731, 9754, 9753
34666, 3264, 3265, 3288, 3287, 9731, 9732, 9755, 9754
34667, 3265, 3266, 3289, 3288, 9732, 9733, 9756, 9755
34668, 3266, 3267, 3290, 3289, 9733, 9734, 9757, 9756
34669, 3267, 3268, 3291, 3290, 9734, 9735, 9758, 9757
34670, 3268, 3269, 3292, 3291, 9735, 9736, 9759, 9758
34671, 3269, 3270, 3293, 3292, 9736, 9737, 9760, 9759
34672, 3270, 3271, 3294, 3293, 9737, 9738, 9761, 9760
34673, 3271, 3272, 3295, 3294, 9738, 9739, 9762, 9761
34674, 3272, 3273, 3296, 3295, 9739, 9740, 9763, 9762
34675, 3273, 3274, 3297, 3296, 9740, 9741, 9764, 9763
34676, 3274, 3275, 3298, 3297, 9741, 9742, 9765, 9764
34677, 3275, 3276, 3299, 3298, 9742, 9743, 9766, 9765
34678, 3276, 373, 374, 3299, 9743, 1420, 1421, 9766
34679, 260, 3277, 3300, 261, 1398, 9744, 9767, 1399
34680, 3277, 3278, 3301, 3300, 9744, 9745, 9768, 9767
34681, 3278, 3279, 3302, 3301, 9745, 9746, 9769, 9768
34682, 3279, 3280, 3303, 3302, 9746, 9747, 9770, 9769
34683, 3280, 3281, 3304, 3303, 9747, 9748, 9771, 9770
34684, 3281, 3282, 3305, 3304, 9748, 9749, 9772, 9771
34685, 3282, 3283, 3306, 3305, 9749, 9750, 9773, 9772
34686, 3283, 3284, 3307, 3306, 9750, 9751, 9774, 9773
34687, 3284, 3285, 3308, 3307, 9751, 9752, 9775, 9774
34688, 3285, 3286, 3309, 3308, 9752, 9753, 9776, 9775
34689, 3286, 3287, 3310, 3309, 9753, 9754, 9777, 9776
34690, 3287, 3288, 3311, 3310, 9754, 9755, 9778, 9777
34691, 3288, 3289, 3312, 3311, 9755, 9756, 9779, 9778
34692, 3289, 3290, 3313, 3312, 9756, 9757, 9780, 9779
34693, 3290, 3291, 3314, 3313, 9757, 9758, 9781, 9780
34694, 3291, 3292, 3315, 3314, 9758, 9759, 9782, 9781
34695, 3292, 3293, 3316, 3315, 9759, 9760, 9783, 9782
34696, 3293, 3294, 3317, 3316, 9760, 9761, 9784, 9783
34697, 3294, 3295, 3318, 3317, 9761, 9762, 9785, 9784
34698, 3295, 3296, 3319, 3318, 9762, 9763, 9786, 9785
34699, 3296, 3297, 3320, 3319, 9763, 9764, 9787, 9786
34700, 3297, 3298, 3321, 3320, 9764, 9765, 9788, 9787
34701, 3298, 3299, 3322, 3321, 9765, 9766, 9789, 9788
34702, 3299, 374, 375, 3322, 9766, 1421, 1422, 9789
34703, 261, 3300, 3323, 262, 1399, 9767, 9790, 1400
34704, 3300, 3301, 3324, 3323, 9767, 9768, 9791, 9790
34705, 3301, 3302, 3325, 3324, 9768, 9769, 9792, 9791
34706, 3302, 3303, 3326, 3325, 9769, 9770, 9793, 9792
34707, 3303, 3304, 3327, 3326, 9770, 9771, 9794, 9793
34708, 3304, 3305, 3328, 3327, 9771, 9772, 9795, 9794
34709, 3305, 3306, 3329, 3328, 9772, 9773, 9796, 9795
34710, 3306, 3307, 3330, 3329, 9773, 9774, 9797, 9796
34711, 3307, 3308, 3331, 3330, 9774, 9775, 9798, 9797
34712, 3308, 3309, 3332, 3331, 9775, 9776, 9799, 9798
34713, 3309, 3310, 3333, 3332, 9776, 9777, 9800, 9799
34714, 3310, 3311, 3334, 3333, 9777, 9778, 9801, 9800
34715, 3311, 3312, 3335, 3334, 9778, 9779, 9802, 9801
34716, 3312, 3313, 3336, 3335, 9779, 9780, 9803, 9802
34717, 3313, 3314, 3337, 3336, 9780, 9781, 9804, 9803
34718, 3314, 3315, 3338, 3337, 9781, 9782, 9805, 9804
34719, 3315, 3316, 3339, 3338, 9782, 9783, 9806, 9805
34720, 3316, 3317, 3340, 3339, 9783, 9784, 9807, 9806
34721, 3317, 3318, 3341, 3340, 9784, 9785, 9808, 9807
34722, 3318, 3319, 3342, 3341, 9785, 9786, 9809, 9808
34723, 3319, 3320, 3343, 3342, 9786, 9787, 9810, 9809
34724, 3320, 3321, 3344, 3343, 9787, 9788, 9811, 9810
34725, 3321, 3322, 3345, 3344, 9788, 9789, 9812, 9811
34726, 3322, 375, 376, 3345, 9789, 1422, 1423, 9812
34727, 262, 3323, 3346, 263, 1400, 9790, 9813, 1401
34728, 3323, 3324, 3347, 3346, 9790, 9791, 9814, 9813
34729, 3324, 3325, 3348, 3347, 9791, 9792, 9815, 9814
34730, 3325, 3326, 3349, 3348, 9792, 9793, 9816, 9815
34731, 3326, 3327, 3350, 3349, 9793, 9794, 9817, 9816
34732, 3327, 3328, 3351, 3350, 9794, 9795, 9818, 9817
34733, 3328, 3329, 3352, 3351, 9795, 9796, 9819, 9818
34734, 3329, 3330, 3353, 3352, 9796, 9797, 9820, 9819
34735, 3330, 3331, 3354, 3353, 9797, 9798, 9821, 9820
34736, 3331, 3332, 3355, 3354, 9798, 9799, 9822, 9821
34737, 3332, 3333, 3356, 3355, 9799, 9800, 9823, 9822
34738, 3333, 3334, 3357, 3356, 9800, 9801, 9824, 9823
34739, 3334, 3335, 3358, 3357, 9801, 9802, 9825, 9824
34740, 3335, 3336, 3359, 3358, 9802, 9803, 9826, 9825
34741, 3336, 3337, 3360, 3359, 9803, 9804, 9827, 9826
34742, 3337, 3338, 3361, 3360, 9804, 9805, 9828, 9827
34743, 3338, 3339, 3362, 3361, 9805, 9806, 9829, 9828
34744, 3339, 3340, 3363, 3362, 9806, 9807, 9830, 9829
34745, 3340, 3341, 3364, 3363, 9807, 9808, 9831, 9830
34746, 3341, 3342, 3365, 3364, 9808, 9809, 9832, 9831
34747, 3342, 3343, 3366, 3365, 9809, 9810, 9833, 9832
34748, 3343, 3344, 3367, 3366, 9810, 9811, 9834, 9833
34749, 3344, 3345, 3368, 3367, 9811, 9812, 9835, 9834
34750, 3345, 376, 377, 3368, 9812, 1423, 1424, 9835
34751, 263, 3346, 309, 9, 1401, 9813, 1333, 65
34752, 3346, 3347, 310, 309, 9813, 9814, 1334, 1333
34753, 3347, 3348, 311, 310, 9814, 9815, 1335, 1334
34754, 3348, 3349, 312, 311, 9815, 9816, 1336, 1335
34755, 3349, 3350, 313, 312, 9816, 9817, 1337, 1336
34756, 3350, 3351, 314, 313, 9817, 9818, 1338, 1337
34757, 3351, 3352, 315, 314, 9818, 9819, 1339, 1338
34758, 3352, 3353, 316, 315, 9819, 9820, 1340, 1339
34759, 3353, 3354, 317, 316, 9820, 9821, 1341, 1340
34760, 3354, 3355, 318, 317, 9821, 9822, 1342, 1341
34761, 3355, 3356, 319, 318, 9822, 9823, 1343, 1342
34762, 3356, 3357, 320, 319, 9823, 9824, 1344, 1343
34763, 3357, 3358, 321, 320, 9824, 9825, 1345, 1344
34764, 3358, 3359, 322, 321, 9825, 9826, 1346, 1345
34765, 3359, 3360, 323, 322, 9826, 9827, 1347, 1346
34766, 3360, 3361, 324, 323, 9827, 9828, 1348, 1347
34767, 3361, 3362, 325, 324, 9828, 9829, 1349, 1348
34768, 3362, 3363, 326, 325, 9829, 9830, 1350, 1349
34769, 3363, 3364, 327, 326, 9830, 9831, 1351, 1350
34770, 3364, 3365, 328, 327, 9831, 9832, 1352, 1351
34771, 3365, 3366, 329, 328, 9832, 9833, 1353, 1352
34772, 3366, 3367, 330, 329, 9833, 9834, 1354, 1353
34773, 3367, 3368, 331, 330, 9834, 9835, 1355, 1354
34774, 3368, 377, 13, 331, 9835, 1424, 66, 1355
*ELEMENT, type=C3D8, ELSET=Volume15
34775, 35, 796, 6827, 910, 69, 1471, 9836, 1425
34776, 910, 6827, 6828, 911, 1425, 9836, 9837, 1426
34777, 911, 6828, 6829, 912, 1426, 9837, 9838, 1427
34778, 912, 6829, 6830, 913, 1427, 9838, 9839, 1428
34779, 913, 6830, 6831, 914, 1428, 9839, 9840, 1429
34780, 914, 6831, 6832, 915, 1429, 9840, 9841, 1430
34781, 915, 6832, 6833, 916, 1430, 9841, 9842, 1431
34782, 916, 6833, 6834, 917, 1431, 9842, 9843, 1432
34783, 917, 6834, 6835, 918, 1432, 9843, 9844, 1433
34784, 918, 6835, 6836, 919, 1433, 9844, 9845, 1434
34785, 919, 6836, 6837, 920, 1434, 9845, 9846, 1435
34786, 920, 6837, 6838, 921, 1435, 9846, 9847, 1436
34787, 921, 6838, 6839, 922, 1436, 9847, 9848, 1437
34788, 922, 6839, 6840, 923, 1437, 9848, 9849, 1438
34789, 923, 6840, 6841, 924, 1438, 9849, 9850, 1439
34790, 924, 6841, 6842, 925, 1439, 9850, 9851, 1440
34791, 925, 6842, 6843, 926, 1440, 9851, 9852, 1441
34792, 926, 6843, 6844, 927, 1441, 9852, 9853, 1442
34793, 927, 6844, 6845, 928, 1442, 9853, 9854, 1443
34794, 928, 6845, 6846, 929, 1443, 9854, 9855, 1444
34795, 929, 6846, 6847, 930, 1444, 9855, 9856, 1445
34796, 930, 6847, 6848, 931, 1445, 9856, 9857, 1446
34797, 931, 6848, 6849, 932, 1446, 9857, 9858, 1447
34798, 932, 6849, 956, 39, 1447, 9858, 1494, 70
34799, 796, 797, 6850, 6827, 1471, 1472, 9859, 9836
34800, 6827, 6850, 6851, 6828, 9836, 9859, 9860, 9837
34801, 6828, 6851, 6852, 6829, 9837, 9860, 9861, 9838
34802, 6829, 6852, 6853, 6830, 9838, 9861, 9862, 9839
34803, 6830, 6853, 6854, 6831, 9839, 9862, 9863, 9840
34804, 6831, 6854, 6855, 6832, 9840, 9863, 9864, 9841
34805, 6832, 6855, 6856, 6833, 9841, 9864, 9865, 9842
34806, 6833, 6856, 6857, 6834, 9842, 9865, 9866, 9843
34807, 6834, 6857, 6858, 6835, 9843, 9866, 9867, 9844
34808, 6835, 6858, 6859, 6836, 9844, 9867, 9868, 9845
34809, 6836, 6859, 6860, 6837, 9845, 9868, 9869, 9846
34810, 6837, 6860, 6861, 6838, 9846, 9869, 9870, 9847
34811, 6838, 6861, 6862, 6839, 9847, 9870, 9871, 9848
34812, 6839, 6862, 6863, 6840, 9848, 9871, 9872, 9849
34813, 6840, 6863, 6864, 6841, 9849, 9872, 9873, 9850
34814, 6841, 6864, 6865, 6842, 9850, 9873, 9874, 9851
34815, 6842, 6865, 6866, 6843, 9851, 9874, 9875, 9852
34816, 6843, 6866, 6867, 6844, 9852, 9875, 9876, 9853
34817, 6844, 6867, 6868, 6845, 9853, 9876, 9877, 9854
34818, 6845, 6868, 6869, 6846, 9854, 9877, 9878, 9855
34819, 6846, 6869, 6870, 6847, 9855, 9878, 9879, 9856
34820, 6847, 6870, 6871, 6848, 9856, 9879, 9880, 9857
34821, 6848, 6871, 6872, 6849, 9857, 9880, 9881, 9858
34822, 6849, 6872, 957, 956, 9858, 9881, 1495, 1494
34823, 797, 798, 6873, 6850, 1472, 1473, 9882, 9859
34824, 6850, 6873, 6874, 6851, 9859, 9882, 9883, 9860
34825, 6851, 6874, 6875, 6852, 9860, 9883, 9884, 9861
34826, 6852, 6875, 6876, 6853, 9861, 9884, 9885, 9862
34827, 6853, 6876, 6877, 6854, 9862, 9885, 9886, 9863
34828, 6854, 6877, 6878, 6855, 9863, 9886, 9887, 9864
34829, 6855, 6878, 6879, 6856, 9864, 9887, 9888, 9865
34830, 6856, 6879, 6880, 6857, 9865, 9888, 9889, 9866
34831, 6857, 6880, 6881, 6858, 9866, 9889, 9890, 9867
34832, 6858, 6881, 6882, 6859, 9867, 9890, 9891, 9868
34833, 6859, 6882, 6883, 6860, 9868, 9891, 9892, 9869
34834, 6860, 6883, 6884, 6861, 9869, 9892, 9893, 9870
34835, 6861, 6884, 6885, 6862, 9870, 9893, 9894, 9871
34836, 6862, 6885, 6886, 6863, 9871, 9894, 9895, 9872
34837, 6863, 6886, 6887, 6864, 9872, 9895, 9896, 9873
34838, 6864, 6887, 6888, 6865, 9873, 9896, 9897, 9874
34839, 6865, 6888, 6889, 6866, 9874, 9897, 9898, 9875
34840, 6866, 6889, 6890, 6867, 9875, 9898, 9899, 9876
34841, 6867, 6890, 6891, 6868, 9876, 9899, 9900, 9877
34842, 6868, 6891, 6892, 6869, 9877, 9900, 9901, 9878
34843, 6869, 6892, 6893, 6870, 9878, 9901, 9902, 9879
34844, 6870, 6893, 6894, 6871, 9879, 9902, 9903, 9880
34845, 6871, 6894, 6895, 6872, 9880, 9903, 9904, 9881
34846, 6872, 6895, 958, 957, 9881, 9904, 1496, 1495
34847, 798, 799, 6896, 6873, 1473, 1474, 9905, 9882
34848, 6873, 6896, 6897, 6874, 9882, 9905, 9906, 9883
34849, 6874, 6897, 6898, 6875, 9883, 9906, 9907, 9884
34850, 6875, 6898, 6899, 6876, 9884, 9907, 9908, 9885
34851, 6876, 6899, 6900, 6877, 9885, 9908, 9909, 9886
34852, 6877, 6900, 6901, 6878, 9886, 9909, 9910, 9887
34853, 6878, 6901, 6902, 6879, 9887, 9910, 9911, 9888
34854, 6879, 6902, 6903, 6880, 9888, 9911, 9912, 9889
34855, 6880, 6903, 6904, 6881, 9889, 9912, 9913, 9890
34856, 6881, 6904, 6905, 6882, 9890, 9913, 9914, 9891
34857, 6882, 6905, 6906, 6883, 9891, 9914, 9915, 9892
34858, 6883, 6906, 6907, 6884, 9892, 9915, 9916, 9893
34859, 6884, 6907, 6908, 6885, 9893, 9916, 9917, 9894
34860, 6885, 6908, 6909, 6886, 9894, 9917, 9918, 9895
34861, 6886, 6909, 6910, 6887, 9895, 9918, 9919, 9896
34862, 6887, 6910, 6911, 6888, 9896, 9919, 9920, 9897
34863, 6888, 6911, 6912, 6889, 9897, 9920, 9921, 9898
34864, 6889, 6912, 6913, 6890, 9898, 9921, 9922, 9899
34865, 6890, 6913, 6914, 6891, 9899, 9922, 9923, 9900
34866, 6891, 6914, 6915, 6892, 9900, 9923, 9924, 9901
34867, 6892, 6915, 6916, 6893, 9901, 9924, 9925, 9902
34868, 6893, 6916, 6917, 6894, 9902, 9925, 9926, 9903
34869, 6894, 6917, 6918, 6895, 9903, 9926, 9927, 9904
34870, 6895, 6918, 959, 958, 9904, 9927, 1497, 1496
34871, 799, 800, 6919, 6896, 1474, 1475, 9928, 9905
34872, 6896, 6919, 6920, 6897, 9905, 9928, 9929, 9906
34873, 6897, 6920, 6921, 6898, 9906, 9929, 9930, 9907
34874, 6898, 6921, 6922, 6899, 9907, 9930, 9931, 9908
34875, 6899, 6922, 6923, 6900, 9908, 9931, 9932, 9909
34876, 6900, 6923, 6924, 6901, 9909, 9932, 9933, 9910
34877, 6901, 6924, 6925, 6902, 9910, 9933, 9934, 9911
34878, 6902, 6925, 6926, 6903, 9911, 9934, 9935, 9912
34879, 6903, 6926, 6927, 6904, 9912, 9935, 9936, 9913
34880, 6904, 6927, 6928, 6905, 9913, 9936, 9937, 9914
34881, 6905, 6928, 6929, 6906, 9914, 9937, 9938, 9915
34882, 6906, 6929, 6930, 6907, 9915, 9938, 9939, 9916
34883, 6907, 6930, 6931, 6908, 9916, 9939, 9940, 9917
34884, 6908, 6931, 6932, 6909, 9917, 9940, 9941, 9918
34885, 6909, 6932, 6933, 6910, 9918, 9941, 9942, 9919
34886, 6910, 6933, 6934, 6911, 9919, 9942, 9943, 9920
34887, 6911, 6934, 6935, 6912, 9920, 9943, 9944, 9921
34888, 6912, 6935, 6936, 6913, 9921, 9944, 9945, 9922
34889, 6913, 6936, 6937, 6914, 9922, 9945, 9946, 9923
34890, 6914, 6937, 6938, 6915, 9923, 9946, 9947, 9924
34891, 6915, 6938, 6939, 6916, 9924, 9947, 9948, 9925
34892, 6916, 6939, 6940, 6917, 9925, 9948, 9949, 9926
34893, 6917, 6940, 6941, 6918, 9926, 9949, 9950, 9927
34894, 6918, 6941, 960, 959, 9927, 9950, 1498, 1497
34895, 800, 801, 6942, 6919, 1475, 1476, 9951, 9928
34896, 6919, 6942, 6943, 6920, 9928, 9951, 9952, 9929
34897, 6920, 6943, 6944, 6921, 9929, 9952, 9953, 9930
34898, 6921, 6944, 6945, 6922, 9930, 9953, 9954, 9931
34899, 6922, 6945, 6946, 6923, 9931, 9954, 9955, 9932
34900, 6923, 6946, 6947, 6924, 9932, 9955, 9956, 9933
34901, 6924, 6947, 6948, 6925, 9933, 9956, 9957, 9934
34902, 6925, 6948, 6949, 6926, 9934, 9957, 9958, 9935
34903, 6926, 6949, 6950, 6927, 9935, 9958, 9959, 9936
34904, 6927, 6950, 6951, 6928, 9936, 9959, 9960, 9937
34905, 6928, 6951, 6952, 6929, 9937, 9960, 9961, 9938
34906, 6929, 6952, 6953, 6930, 9938, 9961, 9962, 9939
34907, 6930, 6953, 6954, 6931, 9939, 9962, 9963, 9940
34908, 6931, 6954, 6955, 6932, 9940, 9963, 9964, 9941
34909, 6932, 6955, 6956, 6933, 9941, 9964, 9965, 9942
34910, 6933, 6956, 6957, 6934, 9942, 9965, 9966, 9943
34911, 6934, 6957, 6958, 6935, 9943, 9966, 9967, 9944
34912, 6935, 6958, 6959, 6936, 9944, 9967, 9968, 9945
34913, 6936, 6959, 6960, 6937, 9945, 9968, 9969, 9946
34914, 6937, 6960, 6961, 6938, 9946, 9969, 9970, 9947
34915, 6938, 6961, 6962, 6939, 9947, 9970, 9971, 9948
34916, 6939, 6962, 6963, 6940, 9948, 9971, 9972, 9949
34917, 6940, 6963, 6964, 6941, 9949, 9972, 9973, 9950
34918, 6941, 6964, 961, 960, 9950, 9973, 1499, 1498
34919, 801, 802, 6965, 6942, 1476, 1477, 9974, 9951
34920, 6942, 6965, 6966, 6943, 9951, 9974, 9975, 9952
34921, 6943, 6966, 6967, 6944, 9952, 9975, 9976, 9953
34922, 6944, 6967, 6968, 6945, 9953, 9976, 9977, 9954
34923, 6945, 6968, 6969, 6946, 9954, 9977, 9978, 9955
34924, 6946, 6969, 6970, 6947, 9955, 9978, 9979, 9956
34925, 6947, 6970, 6971, 6948, 9956, 9979, 9980, 9957
34926, 6948, 6971, 6972, 6949, 9957, 9980, 9981, 9958
34927, 6949, 6972, 6973, 6950, 9958, 9981, 9982, 9959
34928, 6950, 6973, 6974, 6951, 9959, 9982, 9983, 9960
34929, 6951, 6974, 6975, 6952, 9960, 9983, 9984, 9961
34930, 6952, 6975, 6976, 6953, 9961, 9984, 9985, 9962
34931, 6953, 6976, 6977, 6954, 9962, 9985, 9986, 9963
34932, 6954, 6977, 6978, 6955, 9963, 9986, 9987, 9964
34933, 6955, 6978, 6979, 6956, 9964, 9987, 9988, 9965
34934, 6956, 6979, 6980, 6957, 9965, 9988, 9989, 9966
34935, 6957, 6980, 6981, 6958, 9966, 9989, 9990, 9967
34936, 6958, 6981, 6982, 6959, 9967, 9990, 9991, 9968
34937, 6959, 6982, 6983, 6960, 9968, 9991, 9992, 9969
34938, 6960, 6983, 6984, 6961, 9969, 9992, 9993, 9970
34939, 6961, 6984, 6985, 6962, 9970, 9993, 9994, 9971
34940, 6962, 6985, 6986, 6963, 9971, 9994, 9995, 9972
34941, 6963, 6986, 6987, 6964, 9972, 9995, 9996, 9973
34942, 6964, 6987, 962, 961, 9973, 9996, 1500, 1499
34943, 802, 803, 6988, 6965, 1477, 1478, 9997, 9974
34944, 6965, 6988, 6989, 6966, 9974, 9997, 9998, 9975
34945, 6966, 6989, 6990, 6967, 9975, 9998, 9999, 9976
34946, 6967, 6990, 6991, 6968, 9976, 9999, 10000, 9977
34947, 6968, 6991, 6992, 6969, 9977, 10000, 10001, 9978
34948, 6969, 6992, 6993, 6970, 9978, 10001, 10002, 9979
34949, 6970, 6993, 6994, 6971, 9979, 10002, 10003, 9980
34950, 6971, 6994, 6995, 6972, 9980, 10003, 10004, 9981
34951, 6972, 6995, 6996, 6973, 9981, 10004, 10005, 9982
34952, 6973, 6996, 6997, 6974, 9982, 10005, 10006, 9983
34953, 6974, 6997, 6998, 6975, 9983, 10006, 10007, 9984
34954, 6975, 6998, 6999, 6976, 9984, 10007, 10008, 9985
34955, 6976, 6999, 7000, 6977, 9985, 10008, 10009, 9986
34956, 6977, 7000, 7001, 6978, 9986, 10009, 10010, 9987
34957, 6978, 7001, 7002, 6979, 9987, 10010, 10011, 9988
34958, 6979, 7002, 7003, 6980, 9988, 10011, 10012, 9989
34959, 6980, 7003, 7004, 6981, 9989, 10012, 10013, 9990
34960, 6981, 7004, 7005, 6982, 9990, 10013, 10014, 9991
34961, 6982, 7005, 7006, 6983, 9991, 10014, 10015, 9992
34962, 6983, 7006, 7007, 6984, 9992, 10015, 10016, 9993
34963, 6984, 7007, 7008, 6985, 9993, 10016, 10017, 9994
34964, 6985, 7008, 7009, 6986, 9994, 10017, 10018, 9995
34965, 6986, 7009, 7010, 6987, 9995, 10018, 10019, 9996
34966, 6987, 7010, 963, 962, 9996, 10019, 1501, 1500
34967, 803, 804, 7011, 6988, 1478, 1479, 10020, 9997
34968, 6988, 7011, 7012, 6989, 9997, 10020, 10021, 9998
34969, 6989, 7012, 7013, 6990, 9998, 10021, 10022, 9999
34970, 6990, 7013, 7014, 6991, 9999, 10022, 10023, 10000
34971, 6991, 7014, 7015, 6992, 10000, 10023, 10024, 10001
34972, 6992, 7015, 7016, 6993, 10001, 10024, 10025, 10002
34973, 6993, 7016, 7017, 6994, 10002, 10025, 10026, 10003
34974, 6994, 7017, 7018, 6995, 10003, 10026, 10027, 10004
34975, 6995, 7018, 7019, 6996, 10004, 10027, 10028, 10005
34976, 6996, 7019, 7020, 6997, 10005, 10028, 10029, 10006
34977, 6997, 7020, 7021, 6998, 10006, 10029, 10030, 10007
34978, 6998, 7021, 7022, 6999, 10007, 10030, 10031, 10008
34979, 6999, 7022, 7023, 7000, 10008, 10031, 10032, 10009
34980, 7000, 7023, 7024, 7001, 10009, 10032, 10033, 10010
34981, 7001, 7024, 7025, 7002, 10010, 10033, 10034, 10011
34982, 7002, 7025, 7026, 7003, 10011, 10034, 10035, 10012
34983, 7003, 7026, 7027, 7004, 10012, 10035, 10036, 10013
34984, 7004, 7027, 7028, 7005, 10013, 10036, 10037, 10014
34985, 7005, 7028, 7029, 7006, 10014, 10037, 10038, 10015
34986, 7006, 7029, 7030, 7007, 10015, 10038, 10039, 10016
34987, 7007, 7030, 7031, 7008, 10016, 10039, 10040, 10017
34988, 7008, 7031, 7032, 7009, 10017, 10040, 10041, 10018
34989, 7009, 7032, 7033, 7010, 10018, 10041, 10042, 10019
34990, 7010, 7033, 964, 963, 10019, 10042, 1502, 1501
34991, 804, 805, 7034, 7011, 1479, 1480, 10043, 10020
34992, 7011, 7034, 7035, 7012, 10020, 10043, 10044, 10021
34993, 7012, 7035, 7036, 7013, 10021, 10044, 10045, 10022
34994, 7013, 7036, 7037, 7014, 10022, 10045, 10046, 10023
34995, 7014, 7037, 7038, 7015, 10023, 10046, 10047, 10024
34996, 7015, 7038, 7039, 7016, 10024, 10047, 10048, 10025
34997, 7016, 7039, 7040, 7017, 10025, 10048, 10049, 10026
34998, 7017, 7040, 7041, 7018, 10026, 10049, 10050, 10027
34999, 7018, 7041, 7042, 7019, 10027, 10050, 10051, 10028
35000, 7019, 7042, 7043, 7020, 10028, 10051, 10052, 10029
35001, 7020, 7043, 7044, 7021, 10029, 10052, 10053, 10030
35002, 7021, 7044, 7045, 7022, 10030, 10053, 10054, 10031
35003, 7022, 7045, 7046, 7023, 10031, 10054, 10055, 10032
35004, 7023, 7046, 7047, 7024, 10032, 10055, 10056, 10033
35005, 7024, 7047, 7048, 7025, 10033, 10056, 10057, 10034
35006, 7025, 7048, 7049, 7026, 10034, 10057, 10058, 10035
35007, 7026, 7049, 7050, 7027, 10035, 10058, 10059, 10036
35008, 7027, 7050, 7051, 7028, 10036, 10059, 10060, 10037
35009, 7028, 7051, 7052, 7029, 10037, 10060, 10061, 10038
35010, 7029, 7052, 7053, 7030, 10038, 10061, 10062, 10039
35011, 7030, 7053, 7054, 7031, 10039, 10062, 10063, 10040
35012, 7031, 7054, 7055, 7032, 10040, 10063, 10064, 10041
35013, 7032, 7055, 7056, 7033, 10041, 10064, 10065, 10042
35014, 7033, 7056, 965, 964, 10042, 10065, 1503, 1502
35015, 805, 806, 7057, 7034, 1480, 1481, 10066, 10043
35016, 7034, 7057, 7058, 7035, 10043, 10066, 10067, 10044
35017, 7035, 7058, 7059, 7036, 10044, 10067, 10068, 10045
35018, 7036, 7059, 7060, 7037, 10045, 10068, 10069, 10046
35019, 7037, 7060, 7061, 7038, 10046, 10069, 10070, 10047
35020, 7038, 7061, 7062, 7039, 10047, 10070, 10071, 10048
35021, 7039, 7062, 7063, 7040, 10048, 10071, 10072, 10049
35022, 7040, 7063, 7064, 7041, 10049, 10072, 10073, 10050
35023, 7041, 7064, 7065, 7042, 10050, 10073, 10074, 10051
35024, 7042, 7065, 7066, 7043, 10051, 10074, 10075, 10052
35025, 7043, 7066, 7067, 7044, 10052, 10075, 10076, 10053
35026, 7044, 7067, 7068, 7045, 10053, 10076, 10077, 10054
35027, 7045, 7068, 7069, 7046, 10054, 10077, 10078, 10055
35028, 7046, 7069, 7070, 7047, 10055, 10078, 10079, 10056
35029, 7047, 7070, 7071, 7048, 10056, 10079, 10080, 10057
35030, 7048, 7071, 7072, 7049, 10057, 10080, 10081, 10058
35031, 7049, 7072, 7073, 7050, 10058, 10081, 10082, 10059
35032, 7050, 7073, 7074, 7051, 10059, 10082, 10083, 10060
35033, 7051, 7074, 7075, 7052, 10060, 10083, 10084, 10061
35034, 7052, 7075, 7076, 7053, 10061, 10084, 10085, 10062
35035, 7053, 7076, 7077, 7054, 10062, 10085, 10086, 10063
35036, 7054, 7077, 7078, 7055, 10063, 10086, 10087, 10064
35037, 7055, 7078, 7079, 7056, 10064, 10087, 10088, 10065
35038, 7056, 7079, 966, 965, 10065, 10088, 1504, 1503
35039, 806, 807, 7080, 7057, 1481, 1482, 10089, 10066
35040, 7057, 7080, 7081, 7058, 10066, 10089, 10090, 10067
35041, 7058, 7081, 7082, 7059, 10067, 10090, 10091, 10068
35042, 7059, 7082, 7083, 7060, 10068, 10091, 10092, 10069
35043, 7060, 7083, 7084, 7061, 10069, 10092, 10093, 10070
35044, 7061, 7084, 7085, 7062, 10070, 10093, 10094, 10071
35045, 7062, 7085, 7086, 7063, 10071, 10094, 10095, 10072
35046, 7063, 7086, 7087, 7064, 10072, 10095, 10096, 10073
35047, 7064, 7087, 7088, 7065, 10073, 10096, 10097, 10074
35048, 7065, 7088, 7089, 7066, 10074, 10097, 10098, 10075
35049, 7066, 7089, 7090, 7067, 10075, 10098, 10099, 10076
35050, 7067, 7090, 7091, 7068, 10076, 10099, 10100, 10077
35051, 7068, 7091, 7092, 7069, 10077, 10100, 10101, 10078
35052, 7069, 7092, 7093, 7070, 10078, 10101, 10102, 10079
35053, 7070, 7093, 7094, 7071, 10079, 10102, 10103, 10080
35054, 7071, 7094, 7095, 7072, 10080, 10103, 10104, 10081
35055, 7072, 7095, 7096, 7073, 10081, 10104, 10105, 10082
35056, 7073, 7096, 7097, 7074, 10082, 10105, 10106, 10083
35057, 7074, 7097, 7098, 7075, 10083, 10106, 10107, 10084
35058, 7075, 7098, 7099, 7076, 10084, 10107, 10108, 10085
35059, 7076, 7099, 7100, 7077, 10085, 10108, 10109, 10086
35060, 7077, 7100, 7101, 7078, 10086, 10109, 10110, 10087
35061, 7078, 7101, 7102, 7079, 10087, 10110, 10111, 10088
35062, 7079, 7102, 967, 966, 10088, 10111, 1505, 1504
35063, 807, 808, 7103, 7080, 1482, 1483, 10112, 10089
35064, 7080, 7103, 7104, 7081, 10089, 10112, 10113, 10090
35065, 7081, 7104, 7105, 7082, 10090, 10113, 10114, 10091
35066, 7082, 7105, 7106, 7083, 10091, 10114, 10115, 10092
35067, 7083, 7106, 7107, 7084, 10092, 10115, 10116, 10093
35068, 7084, 7107, 7108, 7085, 10093, 10116, 10117, 10094
35069, 7085, 7108, 7109, 7086, 10094, 10117, 10118, 10095
35070, 7086, 7109, 7110, 7087, 10095, 10118, 10119, 10096
35071, 7087, 7110, 7111, 7088, 10096, 10119, 10120, 10097
35072, 7088, 7111, 7112, 7089, 10097, 10120, 10121, 10098
35073, 7089, 7112, 7113, 7090, 10098, 10121, 10122, 10099
35074, 7090, 7113, 7114, 7091, 10099, 10122, 10123, 10100
35075, 7091, 7114, 7115, 7092, 10100, 10123, 10124, 10101
35076, 7092, 7115, 7116, 7093, 10101, 10124, 10125, 10102
35077, 7093, 7116, 7117, 7094, 10102, 10125, 10126, 10103
35078, 7094, 7117, 7118, 7095, 10103, 10126, 10127, 10104
35079, 7095, 7118, 7119, 7096, 10104, 10127, 10128, 10105
35080, 7096, 7119, 7120, 7097, 10105, 10128, 10129, 10106
35081, 7097, 7120, 7121, 7098, 10106, 10129, 10130, 10107
35082, 7098, 7121, 7122, 7099, 10107, 10130, 10131, 10108
35083, 7099, 7122, 7123, 7100, 10108, 10131, 10132, 10109
35084, 7100, 7123, 7124, 7101, 10109, 10132, 10133, 10110
35085, 7101, 7124, 7125, 7102, 10110, 10133, 10134, 10111
35086, 7102, 7125, 968, 967, 10111, 10134, 1506, 1505
35087, 808, 809, 7126, 7103, 1483, 1484, 10135, 10112
35088, 7103, 7126, 7127, 7104, 10112, 10135, 10136, 10113
35089, 7104, 7127, 7128, 7105, 10113, 10136, 10137, 10114
35090, 7105, 7128, 7129, 7106, 10114, 10137, 10138, 10115
35091, 7106, 7129, 7130, 7107, 10115, 10138, 10139, 10116
35092, 7107, 7130, 7131, 7108, 10116, 10139, 10140, 10117
35093, 7108, 7131, 7132, 7109, 10117, 10140, 10141, 10118
35094, 7109, 7132, 7133, 7110, 10118, 10141, 10142, 10119
35095, 7110, 7133, 7134, 7111, 10119, 10142, 10143, 10120
35096, 7111, 7134, 7135, 7112, 10120, 10143, 10144, 10121
35097, 7112, 7135, 7136, 7113, 10121, 10144, 10145, 10122
35098, 7113, 7136, 7137, 7114, 10122, 10145, 10146, 10123
35099, 7114, 7137, 7138, 7115, 10123, 10146, 10147, 10124
35100, 7115, 7138, 7139, 7116, 10124, 10147, 10148, 10125
35101, 7116, 7139, 7140, 7117, 10125, 10148, 10149, 10126
35102, 7117, 7140, 7141, 7118, 10126, 10149, 10150, 10127
35103, 7118, 7141, 7142, 7119, 10127, 10150, 10151, 10128
35104, 7119, 7142, 7143, 7120, 10128, 10151, 10152, 10129
35105, 7120, 7143, 7144, 7121, 10129, 10152, 10153, 10130
35106, 7121, 7144, 7145, 7122, 10130, 10153, 10154, 10131
35107, 7122, 7145, 7146, 7123, 10131, 10154, 10155, 10132
35108, 7123, 7146, 7147, 7124, 10132, 10155, 10156, 10133
35109, 7124, 7147, 7148, 7125, 10133, 10156, 10157, 10134
35110, 7125, 7148, 969, 968, 10134, 10157, 1507, 1506
35111, 809, 810, 7149, 7126, 1484, 1485, 10158, 10135
35112, 7126, 7149, 7150, 7127, 10135, 10158, 10159, 10136
35113, 7127, 7150, 7151, 7128, 10136, 10159, 10160, 10137
35114, 7128, 7151, 7152, 7129, 10137, 10160, 10161, 10138
35115, 7129, 7152, 7153, 7130, 10138, 10161, 10162, 10139
35116, 7130, 7153, 7154, 7131, 10139, 10162, 10163, 10140
35117, 7131, 7154, 7155, 7132, 10140, 10163, 10164, 10141
35118, 7132, 7155, 7156, 7133, 10141, 10164, 10165, 10142
35119, 7133, 7156, 7157, 7134, 10142, 10165, 10166, 10143
35120, 7134, 7157, 7158, 7135, 10143, 10166, 10167, 10144
35121, 7135, 7158, 7159, 7136, 10144, 10167, 10168, 10145
35122, 7136, 7159, 7160, 7137, 10145, 10168, 10169, 10146
35123, 7137, 7160, 7161, 7138, 10146, 10169, 10170, 10147
35124, 7138, 7161, 7162, 7139, 10147, 10170, 10171, 10148
35125, 7139, 7162, 7163, 7140, 10148, 10171, 10172, 10149
35126, 7140, 7163, 7164, 7141, 10149, 10172, 10173, 10150
35127, 7141, 7164, 7165, 7142, 10150, 10173, 10174, 10151
35128, 7142, 7165, 7166, 7143, 10151, 10174, 10175, 10152
35129, 7143, 7166, 7167, 7144, 10152, 10175, 10176, 10153
35130, 7144, 7167, 7168, 7145, 10153, 10176, 10177, 10154
35131, 7145, 7168, 7169, 7146, 10154, 10177, 10178, 10155
35132, 7146, 7169, 7170, 7147, 10155, 10178, 10179, 10156
35133, 7147, 7170, 7171, 7148, 10156, 10179, 10180, 10157
35134, 7148, 7171, 970, 969, 10157, 10180, 1508, 1507
35135, 810, 811, 7172, 7149, 1485, 1486, 10181, 10158
35136, 7149, 7172, 7173, 7150, 10158, 10181, 10182, 10159
35137, 7150, 7173, 7174, 7151, 10159, 10182, 10183, 10160
35138, 7151, 7174, 7175, 7152, 10160, 10183, 10184, 10161
35139, 7152, 7175, 7176, 7153, 10161, 10184, 10185, 10162
35140, 7153, 7176, 7177, 7154, 10162, 10185, 10186, 10163
35141, 7154, 7177, 7178, 7155, 10163, 10186, 10187, 10164
35142, 7155, 7178, 7179, 7156, 10164, 10187, 10188, 10165
35143, 7156, 7179, 7180, 7157, 10165, 10188, 10189, 10166
35144, 7157, 7180, 7181, 7158, 10166, 10189, 10190, 10167
35145, 7158, 7181, 7182, 7159, 10167, 10190, 10191, 10168
35146, 7159, 7182, 7183, 7160, 10168, 10191, 10192, 10169
35147, 7160, 7183, 7184, 7161, 10169, 10192, 10193, 10170
35148, 7161, 7184, 7185, 7162, 10170, 10193, 10194, 10171
35149, 7162, 7185, 7186, 7163, 10171, 10194, 10195, 10172
35150, 7163, 7186, 7187, 7164, 10172, 10195, 10196, 10173
35151, 7164, 7187, 7188, 7165, 10173, 10196, 10197, 10174
35152, 7165, 7188, 7189, 7166, 10174, 10197, 10198, 10175
35153, 7166, 7189, 7190, 7167, 10175, 10198, 10199, 10176
35154, 7167, 7190, 7191, 7168, 10176, 10199, 10200, 10177
35155, 7168, 7191, 7192, 7169, 10177, 10200, 10201, 10178
35156, 7169, 7192, 7193, 7170, 10178, 10201, 10202, 10179
35157, 7170, 7193, 7194, 7171, 10179, 10202, 10203, 10180
35158, 7171, 7194, 971, 970, 10180, 10203, 1509, 1508
35159, 811, 812, 7195, 7172, 1486, 1487, 10204, 10181
35160, 7172, 7195, 7196, 7173, 10181, 10204, 10205, 10182
35161, 7173, 7196, 7197, 7174, 10182, 10205, 10206, 10183
35162, 7174, 7197, 7198, 7175, 10183, 10206, 10207, 10184
35163, 7175, 7198, 7199, 7176, 10184, 10207, 10208, 10185
35164, 7176, 7199, 7200, 7177, 10185, 10208, 10209, 10186
35165, 7177, 7200, 7201, 7178, 10186, 10209, 10210, 10187
35166, 7178, 7201, 7202, 7179, 10187, 10210, 10211, 10188
35167, 7179, 7202, 7203, 7180, 10188, 10211, 10212, 10189
35168, 7180, 7203, 7204, 7181, 10189, 10212, 10213, 10190
35169, 7181, 7204, 7205, 7182, 10190, 10213, 10214, 10191
35170, 7182, 7205, 7206, 7183, 10191, 10214, 10215, 10192
35171, 7183, 7206, 7207, 7184, 10192, 10215, 10216, 10193
35172, 7184, 7207, 7208, 7185, 10193, 10216, 10217, 10194
35173, 7185, 7208, 7209, 7186, 10194, 10217, 10218, 10195
35174, 7186, 7209, 7210, 7187, 10195, 10218, 10219, 10196
35175, 7187, 7210, 7211, 7188, 10196, 10219, 10220, 10197
35176, 7188, 7211, 7212, 7189, 10197, 10220, 10221, 10198
35177, 7189, 7212, 7213, 7190, 10198, 10221, 10222, 10199
35178, 7190, 7213, 7214, 7191, 10199, 10222, 10223, 10200
35179, 7191, 7214, 7215, 7192, 10200, 10223, 10224, 10201
35180, 7192, 7215, 7216, 7193, 10201, 10224, 10225, 10202
35181, 7193, 7216, 7217, 7194, 10202, 10225, 10226, 10203
35182, 7194, 7217, 972, 971, 10203, 10226, 1510, 1509
35183, 812, 813, 7218, 7195, 1487, 1488, 10227, 10204
35184, 7195, 7218, 7219, 7196, 10204, 10227, 10228, 10205
35185, 7196, 7219, 7220, 7197, 10205, 10228, 10229, 10206
35186, 7197, 7220, 7221, 7198, 10206, 10229, 10230, 10207
35187, 7198, 7221, 7222, 7199, 10207, 10230, 10231, 10208
35188, 7199, 7222, 7223, 7200, 10208, 10231, 10232, 10209
35189, 7200, 7223, 7224, 7201, 10209, 10232, 10233, 10210
35190, 7201, 7224, 7225, 7202, 10210, 10233, 10234, 10211
35191, 7202, 7225, 7226, 7203, 10211, 10234, 10235, 10212
35192, 7203, 7226, 7227, 7204, 10212, 10235, 10236, 10213
35193, 7204, 7227, 7228, 7205, 10213, 10236, 10237, 10214
35194, 7205, 7228, 7229, 7206, 10214, 10237, 10238, 10215
35195, 7206, 7229, 7230, 7207, 10215, 10238, 10239, 10216
35196, 7207, 7230, 7231, 7208, 10216, 10239, 10240, 10217
35197, 7208, 7231, 7232, 7209, 10217, 10240, 10241, 10218
35198, 7209, 7232, 7233, 7210, 10218, 10241, 10242, 10219
35199, 7210, 7233, 7234, 7211, 10219, 10242, 10243, 10220
35200, 7211, 7234, 7235, 7212, 10220, 10243, 10244, 10221
35201, 7212, 7235, 7236, 7213, 10221, 10244, 10245, 10222
35202, 7213, 7236, 7237, 7214, 10222, 10245, 10246, 10223
35203, 7214, 7237, 7238, 7215, 10223, 10246, 10247, 10224
35204, 7215, 7238, 7239, 7216, 10224, 10247, 10248, 10225
35205, 7216, 7239, 7240, 7217, 10225, 10248, 10249, 10226
35206, 7217, 7240, 973, 972, 10226, 10249, 1511, 1510
35207, 813, 814, 7241, 7218, 1488, 1489, 10250, 10227
35208, 7218, 7241, 7242, 7219, 10227, 10250, 10251, 10228
35209, 7219, 7242, 7243, 7220, 10228, 10251, 10252, 10229
35210, 7220, 7243, 7244, 7221, 10229, 10252, 10253, 10230
35211, 7221, 7244, 7245, 7222, 10230, 10253, 10254, 10231
35212, 7222, 7245, 7246, 7223, 10231, 10254, 10255, 10232
35213, 7223, 7246, 7247, 7224, 10232, 10255, 10256, 10233
35214, 7224, 7247, 7248, 7225, 10233, 10256, 10257, 10234
35215, 7225, 7248, 7249, 7226, 10234, 10257, 10258, 10235
35216, 7226, 7249, 7250, 7227, 10235, 10258, 10259, 10236
35217, 7227, 7250, 7251, 7228, 10236, 10259, 10260, 10237
35218, 7228, 7251, 7252, 7229, 10237, 10260, 10261, 10238
35219, 7229, 7252, 7253, 7230, 10238, 10261, 10262, 10239
35220, 7230, 7253, 7254, 7231, 10239, 10262, 10263, 10240
35221, 7231, 7254, 7255, 7232, 10240, 10263, 10264, 10241
35222, 7232, 7255, 7256, 7233, 10241, 10264, 10265, 10242
35223, 7233, 7256, 7257, 7234, 10242, 10265, 10266, 10243
35224, 7234, 7257, 7258, 7235, 10243, 10266, 10267, 10244
35225, 7235, 7258, 7259, 7236, 10244, 10267, 10268, 10245
35226, 7236, 7259, 7260, 7237, 10245, 10268, 10269, 10246
35227, 7237, 7260, 7261, 7238, 10246, 10269, 10270, 10247
35228, 7238, 7261, 7262, 7239, 10247, 10270, 10271, 10248
35229, 7239, 7262, 7263, 7240, 10248, 10271, 10272, 10249
35230, 7240, 7263, 974, 973, 10249, 10272, 1512, 1511
35231, 814, 815, 7264, 7241, 1489, 1490, 10273, 10250
35232, 7241, 7264, 7265, 7242, 10250, 10273, 10274, 10251
35233, 7242, 7265, 7266, 7243, 10251, 10274, 10275, 10252
35234, 7243, 7266, 7267, 7244, 10252, 10275, 10276, 10253
35235, 7244, 7267, 7268, 7245, 10253, 10276, 10277, 10254
35236, 7245, 7268, 7269, 7246, 10254, 10277, 10278, 10255
35237, 7246, 7269, 7270, 7247, 10255, 10278, 10279, 10256
35238, 7247, 7270, 7271, 7248, 10256, 10279, 10280, 10257
35239, 7248, 7271, 7272, 7249, 10257, 10280, 10281, 10258
35240, 7249, 7272, 7273, 7250, 10258, 10281, 10282, 10259
35241, 7250, 7273, 7274, 7251, 10259, 10282, 10283, 10260
35242, 7251, 7274, 7275, 7252, 10260, 10283, 10284, 10261
35243, 7252, 7275, 7276, 7253, 10261, 10284, 10285, 10262
35244, 7253, 7276, 7277, 7254, 10262, 10285, 10286, 10263
35245, 7254, 7277, 7278, 7255, 10263, 10286, 10287, 10264
35246, 7255, 7278, 7279, 7256, 10264, 10287, 10288, 10265
35247, 7256, 7279, 7280, 7257, 10265, 10288, 10289, 10266
35248, 7257, 7280, 7281, 7258, 10266, 10289, 10290, 10267
35249, 7258, 7281, 7282, 7259, 10267, 10290, 10291, 10268
35250, 7259, 7282, 7283, 7260, 10268, 10291, 10292, 10269
35251, 7260, 7283, 7284, 7261, 10269, 10292, 10293, 10270
35252, 7261, 7284, 7285, 7262, 10270, 10293, 10294, 10271
35253, 7262, 7285, 7286, 7263, 10271, 10294, 10295, 10272
35254, 7263, 7286, 975, 974, 10272, 10295, 1513, 1512
35255, 815, 816, 7287, 7264, 1490, 1491, 10296, 10273
35256, 7264, 7287, 7288, 7265, 10273, 10296, 10297, 10274
35257, 7265, 7288, 7289, 7266, 10274, 10297, 10298, 10275
35258, 7266, 7289, 7290, 7267, 10275, 10298, 10299, 10276
35259, 7267, 7290, 7291, 7268, 10276, 10299, 10300, 10277
35260, 7268, 7291, 7292, 7269, 10277, 10300, 10301, 10278
35261, 7269, 7292, 7293, 7270, 10278, 10301, 10302, 10279
35262, 7270, 7293, 7294, 7271, 10279, 10302, 10303, 10280
35263, 7271, 7294, 7295, 7272, 10280, 10303, 10304, 10281
35264, 7272, 7295, 7296, 7273, 10281, 10304, 10305, 10282
35265, 7273, 7296, 7297, 7274, 10282, 10305, 10306, 10283
35266, 7274, 7297, 7298, 7275, 10283, 10306, 10307, 10284
35267, 7275, 7298, 7299, 7276, 10284, 10307, 10308, 10285
35268, 7276, 7299, 7300, 7277, 10285, 10308, 10309, 10286
35269, 7277, 7300, 7301, 7278, 10286, 10309, 10310, 10287
35270, 7278, 7301, 7302, 7279, 10287, 10310, 10311, 10288
35271, 7279, 7302, 7303, 7280, 10288, 10311, 10312, 10289
35272, 7280, 7303, 7304, 7281, 10289, 10312, 10313, 10290
35273, 7281, 7304, 7305, 7282, 10290, 10313, 10314, 10291
35274, 7282, 7305, 7306, 7283, 10291, 10314, 10315, 10292
35275, 7283, 7306, 7307, 7284, 10292, 10315, 10316, 10293
35276, 7284, 7307, 7308, 7285, 10293, 10316, 10317, 10294
35277, 7285, 7308, 7309, 7286, 10294, 10317, 10318, 10295
35278, 7286, 7309, 976, 975, 10295, 10318, 1514, 1513
35279, 816, 817, 7310, 7287, 1491, 1492, 10319, 10296
35280, 7287, 7310, 7311, 7288, 10296, 10319, 10320, 10297
35281, 7288, 7311, 7312, 7289, 10297, 10320, 10321, 10298
35282, 7289, 7312, 7313, 7290, 10298, 10321, 10322, 10299
35283, 7290, 7313, 7314, 7291, 10299, 10322, 10323, 10300
35284, 7291, 7314, 7315, 7292, 10300, 10323, 10324, 10301
35285, 7292, 7315, 7316, 7293, 10301, 10324, 10325, 10302
35286, 7293, 7316, 7317, 7294, 10302, 10325, 10326, 10303
35287, 7294, 7317, 7318, 7295, 10303, 10326, 10327, 10304
35288, 7295, 7318, 7319, 7296, 10304, 10327, 10328, 10305
35289, 7296, 7319, 7320, 7297, 10305, 10328, 10329, 10306
35290, 7297, 7320, 7321, 7298, 10306, 10329, 10330, 10307
35291, 7298, 7321, 7322, 7299, 10307, 10330, 10331, 10308
35292, 7299, 7322, 7323, 7300, 10308, 10331, 10332, 10309
35293, 7300, 7323, 7324, 7301, 10309, 10332, 10333, 10310
35294, 7301, 7324, 7325, 7302, 10310, 10333, 10334, 10311
35295, 7302, 7325, 7326, 7303, 10311, 10334, 10335, 10312
35296, 7303, 7326, 7327, 7304, 10312, 10335, 10336, 10313
35297, 7304, 7327, 7328, 7305, 10313, 10336, 10337, 10314
35298, 7305, 7328, 7329, 7306, 10314, 10337, 10338, 10315
35299, 7306, 7329, 7330, 7307, 10315, 10338, 10339, 10316
35300, 7307, 7330, 7331, 7308, 10316, 10339, 10340, 10317
35301, 7308, 7331, 7332, 7309, 10317, 10340, 10341, 10318
35302, 7309, 7332, 977, 976, 10318, 10341, 1515, 1514
35303, 817, 818, 7333, 7310, 1492, 1493, 10342, 10319
35304, 7310, 7333, 7334, 7311, 10319, 10342, 10343, 10320
35305, 7311, 7334, 7335, 7312, 10320, 10343, 10344, 10321
35306, 7312, 7335, 7336, 7313, 10321, 10344, 10345, 10322
35307, 7313, 7336, 7337, 7314, 10322, 10345, 10346, 10323
35308, 7314, 7337, 7338, 7315, 10323, 10346, 10347, 10324
35309, 7315, 7338, 7339, 7316, 10324, 10347, 10348, 10325
35310, 7316, 7339, 7340, 7317, 10325, 10348, 10349, 10326
35311, 7317, 7340, 7341, 7318, 10326, 10349, 10350, 10327
35312, 7318, 7341, 7342, 7319, 10327, 10350, 10351, 10328
35313, 7319, 7342, 7343, 7320, 10328, 10351, 10352, 10329
35314, 7320, 7343, 7344, 7321, 10329, 10352, 10353, 10330
35315, 7321, 7344, 7345, 7322, 10330, 10353, 10354, 10331
35316, 7322, 7345, 7346, 7323, 10331, 10354, 10355, 10332
35317, 7323, 7346, 7347, 7324, 10332, 10355, 10356, 10333
35318, 7324, 7347, 7348, 7325, 10333, 10356, 10357, 10334
35319, 7325, 7348, 7349, 7326, 10334, 10357, 10358, 10335
35320, 7326, 7349, 7350, 7327, 10335, 10358, 10359, 10336
35321, 7327, 7350, 7351, 7328, 10336, 10359, 10360, 10337
35322, 7328, 7351, 7352, 7329, 10337, 10360, 10361, 10338
35323, 7329, 7352, 7353, 7330, 10338, 10361, 10362, 10339
