*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_3x3x3el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 1, 1.6, 0
78, 0, 1.6, 0
79, 1, 1.6, 0.5
80, 0, 1.6, 0.5
81, 1.2, 1.6, 0.5
82, 1.2, 1.6, 0
83, 2.2, 1.6, 0.5
84, 2.2, 1.6, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.16666666666667
98, 0, 0, 0.33333333333333
99, 0, 0.025, 0.5
100, 0, 0.05, 0.16666666666667
101, 0, 0.05, 0.33333333333333
102, 0, 0.025, 0
103, 1, 0, 0.16666666666667
104, 1, 0, 0.33333333333333
105, 1, 0.025, 0.5
106, 1, 0.05, 0.16666666666667
107, 1, 0.05, 0.33333333333333
108, 1, 0.025, 0
109, 0.33333333333333, 0, 0
110, 0.66666666666667, 0, 0
111, 0.33333333333333, 0, 0.5
112, 0.66666666666667, 0, 0.5
113, 0.33333333333333, 0.05, 0
114, 0.66666666666667, 0.05, 0
115, 0.33333333333333, 0.05, 0.5
116, 0.66666666666667, 0.05, 0.5
117, 0.33333333333333, 0.1, 0
118, 0.66666666666667, 0.1, 0
119, 1, 0.1, 0.16666666666667
120, 1, 0.1, 0.33333333333333
121, 0.33333333333333, 0.1, 0.5
122, 0.66666666666667, 0.1, 0.5
123, 0, 0.1, 0.16666666666667
124, 0, 0.1, 0.33333333333333
125, 1, 0.5, 0
126, 1, 0.9, 0
127, 0, 0.5, 0
128, 0, 0.9, 0
129, 0.33333333333333, 1.3, 0
130, 0.66666666666667, 1.3, 0
131, 1, 0.5, 0.5
132, 1, 0.9, 0.5
133, 1, 1.3, 0.16666666666667
134, 1, 1.3, 0.33333333333333
135, 0, 0.5, 0.5
136, 0, 0.9, 0.5
137, 0.33333333333333, 1.3, 0.5
138, 0.66666666666667, 1.3, 0.5
139, 0, 1.3, 0.16666666666667
140, 0, 1.3, 0.33333333333333
141, 0.33333333333333, 1.35, 0
142, 0.66666666666667, 1.35, 0
143, 1, 1.35, 0.16666666666667
144, 1, 1.35, 0.33333333333333
145, 0.33333333333333, 1.35, 0.5
146, 0.66666666666667, 1.35, 0.5
147, 0, 1.35, 0.16666666666667
148, 0, 1.35, 0.33333333333333
149, 1, 1.375, 0
150, 0, 1.375, 0
151, 0.33333333333333, 1.4, 0
152, 0.66666666666667, 1.4, 0
153, 1, 1.375, 0.5
154, 1, 1.4, 0.16666666666667
155, 1, 1.4, 0.33333333333333
156, 0, 1.375, 0.5
157, 0.33333333333333, 1.4, 0.5
158, 0.66666666666667, 1.4, 0.5
159, 0, 1.4, 0.16666666666667
160, 0, 1.4, 0.33333333333333
161, 1.0666666666667, 1.35, 0.5
162, 1.1333333333333, 1.35, 0.5
163, 1.0666666666667, 1.4, 0.5
164, 1.1333333333333, 1.4, 0.5
165, 1.2, 1.375, 0.5
166, 1.0666666666667, 1.35, 0
167, 1.1333333333333, 1.35, 0
168, 1.0666666666667, 1.4, 0
169, 1.1333333333333, 1.4, 0
170, 1.2, 1.375, 0
171, 1.2, 1.35, 0.16666666666667
172, 1.2, 1.35, 0.33333333333333
173, 1.2, 1.4, 0.16666666666667
174, 1.2, 1.4, 0.33333333333333
175, 1.5333333333333, 1.35, 0.5
176, 1.8666666666667, 1.35, 0.5
177, 1.5333333333333, 1.4, 0.5
178, 1.8666666666667, 1.4, 0.5
179, 2.2, 1.375, 0.5
180, 1.5333333333333, 1.35, 0
181, 1.8666666666667, 1.35, 0
182, 1.5333333333333, 1.4, 0
183, 1.8666666666667, 1.4, 0
184, 2.2, 1.375, 0
185, 2.2, 1.35, 0.16666666666667
186, 2.2, 1.35, 0.33333333333333
187, 2.2, 1.4, 0.16666666666667
188, 2.2, 1.4, 0.33333333333333
189, 1.5333333333333, 1.3, 0.5
190, 1.8666666666667, 1.3, 0.5
191, 1.5333333333333, 1.3, 0
192, 1.8666666666667, 1.3, 0
193, 1.2, 1.3, 0.16666666666667
194, 1.2, 1.3, 0.33333333333333
195, 2.2, 1.3, 0.16666666666667
196, 2.2, 1.3, 0.33333333333333
197, 1.2, 0.9, 0.5
198, 1.2, 0.5, 0.5
199, 2.2, 0.9, 0.5
200, 2.2, 0.5, 0.5
201, 1.5333333333333, 0.1, 0.5
202, 1.8666666666667, 0.1, 0.5
203, 1.2, 0.9, 0
204, 1.2, 0.5, 0
205, 2.2, 0.9, 0
206, 2.2, 0.5, 0
207, 1.5333333333333, 0.1, 0
208, 1.8666666666667, 0.1, 0
209, 1.2, 0.1, 0.16666666666667
210, 1.2, 0.1, 0.33333333333333
211, 2.2, 0.1, 0.16666666666667
212, 2.2, 0.1, 0.33333333333333
213, 1.5333333333333, 0.05, 0.5
214, 1.8666666666667, 0.05, 0.5
215, 1.5333333333333, 0.05, 0
216, 1.8666666666667, 0.05, 0
217, 1.2, 0.05, 0.16666666666667
218, 1.2, 0.05, 0.33333333333333
219, 2.2, 0.05, 0.16666666666667
220, 2.2, 0.05, 0.33333333333333
221, 1.2, 0.025, 0.5
222, 2.2, 0.025, 0.5
223, 1.5333333333333, 8.3266726846887e-17, 0.5
224, 1.8666666666667, 8.3266726846887e-17, 0.5
225, 1.2, 0.025, 0
226, 2.2, 0.025, 0
227, 1.5333333333333, 8.3266726846887e-17, 0
228, 1.8666666666667, 8.3266726846887e-17, 0
229, 1.2, 8.3266726846887e-17, 0.16666666666667
230, 1.2, 8.3266726846887e-17, 0.33333333333333
231, 2.2, 8.3266726846887e-17, 0.16666666666667
232, 2.2, 8.3266726846887e-17, 0.33333333333333
233, 2.3, 0.025, 0.5
234, 2.3, 0.025, 0
235, 2.3, 0.05, 0.16666666666667
236, 2.3, 0.05, 0.33333333333333
237, 2.3, 8.3266726846887e-17, 0.16666666666667
238, 2.3, 8.3266726846887e-17, 0.33333333333333
239, -0.1, 0, 0.16666666666667
240, -0.1, 0, 0.33333333333333
241, -0.1, 0.025, 0.5
242, -0.1, 0.05, 0.16666666666667
243, -0.1, 0.05, 0.33333333333333
244, -0.1, 0.025, 0
245, 1.05, 0.5, 0.5
246, 1.05, 0.9, 0.5
247, 1.05, 0.5, 0
248, 1.05, 0.9, 0
249, 1.05, 0.1, 0.16666666666667
250, 1.05, 0.1, 0.33333333333333
251, 1.05, 1.3, 0.16666666666667
252, 1.05, 1.3, 0.33333333333333
253, 1.15, 0.9, 0.5
254, 1.15, 0.5, 0.5
255, 1.15, 0.9, 0
256, 1.15, 0.5, 0
257, 1.15, 1.3, 0.16666666666667
258, 1.15, 1.3, 0.33333333333333
259, 1.15, 0.1, 0.16666666666667
260, 1.15, 0.1, 0.33333333333333
261, 1, 0.5, -0.1
262, 1, 0.9, -0.1
263, 0, 0.5, -0.1
264, 0, 0.9, -0.1
265, 0.33333333333333, 0.1, -0.1
266, 0.66666666666667, 0.1, -0.1
267, 0.33333333333333, 1.3, -0.1
268, 0.66666666666667, 1.3, -0.1
269, 1.2, 0.9, -0.1
270, 1.2, 0.5, -0.1
271, 2.2, 0.9, -0.1
272, 2.2, 0.5, -0.1
273, 1.5333333333333, 1.3, -0.1
274, 1.8666666666667, 1.3, -0.1
275, 1.5333333333333, 0.1, -0.1
276, 1.8666666666667, 0.1, -0.1
277, 1.15, 0.9, -0.1
278, 1.15, 0.5, -0.1
279, 1.05, 0.5, -0.1
280, 1.05, 0.9, -0.1
281, 1, 1.4666666666667, 0
282, 1, 1.5333333333333, 0
283, 0, 1.4666666666667, 0
284, 0, 1.5333333333333, 0
285, 0.33333333333333, 1.6, 0
286, 0.66666666666667, 1.6, 0
287, 1, 1.4666666666667, 0.5
288, 1, 1.5333333333333, 0.5
289, 1, 1.6, 0.16666666666667
290, 1, 1.6, 0.33333333333333
291, 0, 1.4666666666667, 0.5
292, 0, 1.5333333333333, 0.5
293, 0.33333333333333, 1.6, 0.5
294, 0.66666666666667, 1.6, 0.5
295, 0, 1.6, 0.16666666666667
296, 0, 1.6, 0.33333333333333
297, 1.2, 1.4666666666667, 0.5
298, 1.2, 1.5333333333333, 0.5
299, 1.0666666666667, 1.6, 0.5
300, 1.1333333333333, 1.6, 0.5
301, 1.2, 1.4666666666667, 0
302, 1.2, 1.5333333333333, 0
303, 1.0666666666667, 1.6, 0
304, 1.1333333333333, 1.6, 0
305, 1.2, 1.6, 0.16666666666667
306, 1.2, 1.6, 0.33333333333333
307, 2.2, 1.4666666666667, 0.5
308, 2.2, 1.5333333333333, 0.5
309, 1.5333333333333, 1.6, 0.5
310, 1.8666666666667, 1.6, 0.5
311, 2.2, 1.4666666666667, 0
312, 2.2, 1.5333333333333, 0
313, 1.5333333333333, 1.6, 0
314, 1.8666666666667, 1.6, 0
315, 2.2, 1.6, 0.16666666666667
316, 2.2, 1.6, 0.33333333333333
317, 1, -0.066666666666667, 0
318, 1, -0.13333333333333, 0
319, 0, -0.066666666666667, 0
320, 0, -0.13333333333333, 0
321, 0.33333333333333, -0.2, 0
322, 0.66666666666667, -0.2, 0
323, 1, -0.066666666666667, 0.5
324, 1, -0.13333333333333, 0.5
325, 1, -0.2, 0.16666666666667
326, 1, -0.2, 0.33333333333333
327, 0, -0.066666666666667, 0.5
328, 0, -0.13333333333333, 0.5
329, 0.33333333333333, -0.2, 0.5
330, 0.66666666666667, -0.2, 0.5
331, 0, -0.2, 0.16666666666667
332, 0, -0.2, 0.33333333333333
333, -0.1, -0.066666666666667, 0.5
334, -0.1, -0.13333333333333, 0.5
335, -0.1, -0.066666666666667, 0
336, -0.1, -0.13333333333333, 0
337, -0.1, -0.2, 0.16666666666667
338, -0.1, -0.2, 0.33333333333333
339, 1.2, -0.066666666666667, 0.5
340, 1.2, -0.13333333333333, 0.5
341, 2.2, -0.066666666666667, 0.5
342, 2.2, -0.13333333333333, 0.5
343, 1.5333333333333, -0.2, 0.5
344, 1.8666666666667, -0.2, 0.5
345, 1.2, -0.066666666666667, 0
346, 1.2, -0.13333333333333, 0
347, 2.2, -0.066666666666667, 0
348, 2.2, -0.13333333333333, 0
349, 1.5333333333333, -0.2, 0
350, 1.8666666666667, -0.2, 0
351, 1.2, -0.2, 0.16666666666667
352, 1.2, -0.2, 0.33333333333333
353, 2.2, -0.2, 0.16666666666667
354, 2.2, -0.2, 0.33333333333333
355, 2.3, -0.066666666666667, 0.5
356, 2.3, -0.13333333333333, 0.5
357, 2.3, -0.066666666666667, 0
358, 2.3, -0.13333333333333, 0
359, 2.3, -0.2, 0.16666666666667
360, 2.3, -0.2, 0.33333333333333
361, 0, 0.025, 0.16666666666667
362, 0, 0.025, 0.33333333333333
363, 1, 0.025, 0.16666666666667
364, 1, 0.025, 0.33333333333333
365, 0.33333333333333, 0, 0.16666666666667
366, 0.33333333333333, 0, 0.33333333333333
367, 0.66666666666667, 0, 0.16666666666667
368, 0.66666666666667, 0, 0.33333333333333
369, 0.33333333333333, 0.05, 0.16666666666667
370, 0.33333333333333, 0.05, 0.33333333333333
371, 0.66666666666667, 0.05, 0.16666666666667
372, 0.66666666666667, 0.05, 0.33333333333333
373, 0.33333333333333, 0.025, 0
374, 0.66666666666667, 0.025, 0
375, 0.33333333333333, 0.025, 0.5
376, 0.66666666666667, 0.025, 0.5
377, 0.33333333333333, 0.1, 0.16666666666667
378, 0.33333333333333, 0.1, 0.33333333333333
379, 0.66666666666667, 0.1, 0.16666666666667
380, 0.66666666666667, 0.1, 0.33333333333333
381, 0.33333333333333, 0.5, 0
382, 0.33333333333333, 0.9, 0
383, 0.66666666666667, 0.5, 0
384, 0.66666666666667, 0.9, 0
385, 1, 0.5, 0.16666666666667
386, 1, 0.9, 0.16666666666667
387, 1, 0.5, 0.33333333333333
388, 1, 0.9, 0.33333333333333
389, 0.33333333333333, 0.5, 0.5
390, 0.33333333333333, 0.9, 0.5
391, 0.66666666666667, 0.5, 0.5
392, 0.66666666666667, 0.9, 0.5
393, 0, 0.5, 0.16666666666667
394, 0, 0.9, 0.16666666666667
395, 0, 0.5, 0.33333333333333
396, 0, 0.9, 0.33333333333333
397, 0.33333333333333, 1.3, 0.16666666666667
398, 0.33333333333333, 1.3, 0.33333333333333
399, 0.66666666666667, 1.3, 0.16666666666667
400, 0.66666666666667, 1.3, 0.33333333333333
401, 0.33333333333333, 1.35, 0.16666666666667
402, 0.33333333333333, 1.35, 0.33333333333333
403, 0.66666666666667, 1.35, 0.16666666666667
404, 0.66666666666667, 1.35, 0.33333333333333
405, 0.33333333333333, 1.375, 0
406, 0.66666666666667, 1.375, 0
407, 1, 1.375, 0.16666666666667
408, 1, 1.375, 0.33333333333333
409, 0.33333333333333, 1.375, 0.5
410, 0.66666666666667, 1.375, 0.5
411, 0, 1.375, 0.16666666666667
412, 0, 1.375, 0.33333333333333
413, 0.33333333333333, 1.4, 0.16666666666667
414, 0.33333333333333, 1.4, 0.33333333333333
415, 0.66666666666667, 1.4, 0.16666666666667
416, 0.66666666666667, 1.4, 0.33333333333333
417, 1.0666666666667, 1.375, 0.5
418, 1.1333333333333, 1.375, 0.5
419, 1.0666666666667, 1.375, 0
420, 1.1333333333333, 1.375, 0
421, 1.0666666666667, 1.35, 0.16666666666667
422, 1.1333333333333, 1.35, 0.16666666666667
423, 1.0666666666667, 1.35, 0.33333333333333
424, 1.1333333333333, 1.35, 0.33333333333333
425, 1.0666666666667, 1.4, 0.16666666666667
426, 1.1333333333333, 1.4, 0.16666666666667
427, 1.0666666666667, 1.4, 0.33333333333333
428, 1.1333333333333, 1.4, 0.33333333333333
429, 1.2, 1.375, 0.16666666666667
430, 1.2, 1.375, 0.33333333333333
431, 1.5333333333333, 1.375, 0.5
432, 1.8666666666667, 1.375, 0.5
433, 1.5333333333333, 1.375, 0
434, 1.8666666666667, 1.375, 0
435, 1.5333333333333, 1.35, 0.16666666666667
436, 1.8666666666667, 1.35, 0.16666666666667
437, 1.5333333333333, 1.35, 0.33333333333333
438, 1.8666666666667, 1.35, 0.33333333333333
439, 1.5333333333333, 1.4, 0.16666666666667
440, 1.8666666666667, 1.4, 0.16666666666667
441, 1.5333333333333, 1.4, 0.33333333333333
442, 1.8666666666667, 1.4, 0.33333333333333
443, 2.2, 1.375, 0.16666666666667
444, 2.2, 1.375, 0.33333333333333
445, 1.5333333333333, 1.3, 0.16666666666667
446, 1.8666666666667, 1.3, 0.16666666666667
447, 1.5333333333333, 1.3, 0.33333333333333
448, 1.8666666666667, 1.3, 0.33333333333333
449, 1.5333333333333, 0.9, 0.5
450, 1.5333333333333, 0.5, 0.5
451, 1.8666666666667, 0.9, 0.5
452, 1.8666666666667, 0.5, 0.5
453, 1.5333333333333, 0.9, 0
454, 1.5333333333333, 0.5, 0
455, 1.8666666666667, 0.9, 0
456, 1.8666666666667, 0.5, 0
457, 1.2, 0.9, 0.16666666666667
458, 1.2, 0.5, 0.16666666666667
459, 1.2, 0.9, 0.33333333333333
460, 1.2, 0.5, 0.33333333333333
461, 2.2, 0.9, 0.16666666666667
462, 2.2, 0.5, 0.16666666666667
463, 2.2, 0.9, 0.33333333333333
464, 2.2, 0.5, 0.33333333333333
465, 1.5333333333333, 0.1, 0.16666666666667
466, 1.8666666666667, 0.1, 0.16666666666667
467, 1.5333333333333, 0.1, 0.33333333333333
468, 1.8666666666667, 0.1, 0.33333333333333
469, 1.5333333333333, 0.05, 0.16666666666667
470, 1.8666666666667, 0.05, 0.16666666666667
471, 1.5333333333333, 0.05, 0.33333333333333
472, 1.8666666666667, 0.05, 0.33333333333333
473, 1.5333333333333, 0.025, 0.5
474, 1.8666666666667, 0.025, 0.5
475, 1.5333333333333, 0.025, 0
476, 1.8666666666667, 0.025, 0
477, 1.2, 0.025, 0.16666666666667
478, 1.2, 0.025, 0.33333333333333
479, 2.2, 0.025, 0.16666666666667
480, 2.2, 0.025, 0.33333333333333
481, 1.5333333333333, 8.3266726846887e-17, 0.16666666666667
482, 1.8666666666667, 8.3266726846887e-17, 0.16666666666667
483, 1.5333333333333, 8.3266726846887e-17, 0.33333333333333
484, 1.8666666666667, 8.3266726846887e-17, 0.33333333333333
485, 2.3, 0.025, 0.16666666666667
486, 2.3, 0.025, 0.33333333333333
487, -0.1, 0.025, 0.16666666666667
488, -0.1, 0.025, 0.33333333333333
489, 1.05, 0.5, 0.16666666666667
490, 1.05, 0.9, 0.16666666666667
491, 1.05, 0.5, 0.33333333333333
492, 1.05, 0.9, 0.33333333333333
493, 1.15, 0.9, 0.16666666666667
494, 1.15, 0.5, 0.16666666666667
495, 1.15, 0.9, 0.33333333333333
496, 1.15, 0.5, 0.33333333333333
497, 0.33333333333333, 0.5, -0.1
498, 0.33333333333333, 0.9, -0.1
499, 0.66666666666667, 0.5, -0.1
500, 0.66666666666667, 0.9, -0.1
501, 1.5333333333333, 0.9, -0.1
502, 1.5333333333333, 0.5, -0.1
503, 1.8666666666667, 0.9, -0.1
504, 1.8666666666667, 0.5, -0.1
505, 0.33333333333333, 1.4666666666667, 0
506, 0.33333333333333, 1.5333333333333, 0
507, 0.66666666666667, 1.4666666666667, 0
508, 0.66666666666667, 1.5333333333333, 0
509, 1, 1.4666666666667, 0.16666666666667
510, 1, 1.5333333333333, 0.16666666666667
511, 1, 1.4666666666667, 0.33333333333333
512, 1, 1.5333333333333, 0.33333333333333
513, 0.33333333333333, 1.4666666666667, 0.5
514, 0.33333333333333, 1.5333333333333, 0.5
515, 0.66666666666667, 1.4666666666667, 0.5
516, 0.66666666666667, 1.5333333333333, 0.5
517, 0, 1.4666666666667, 0.16666666666667
518, 0, 1.5333333333333, 0.16666666666667
519, 0, 1.4666666666667, 0.33333333333333
520, 0, 1.5333333333333, 0.33333333333333
521, 0.33333333333333, 1.6, 0.16666666666667
522, 0.33333333333333, 1.6, 0.33333333333333
523, 0.66666666666667, 1.6, 0.16666666666667
524, 0.66666666666667, 1.6, 0.33333333333333
525, 1.0666666666667, 1.4666666666667, 0.5
526, 1.0666666666667, 1.5333333333333, 0.5
527, 1.1333333333333, 1.4666666666667, 0.5
528, 1.1333333333333, 1.5333333333333, 0.5
529, 1.0666666666667, 1.4666666666667, 0
530, 1.0666666666667, 1.5333333333333, 0
531, 1.1333333333333, 1.4666666666667, 0
532, 1.1333333333333, 1.5333333333333, 0
533, 1.2, 1.4666666666667, 0.16666666666667
534, 1.2, 1.5333333333333, 0.16666666666667
535, 1.2, 1.4666666666667, 0.33333333333333
536, 1.2, 1.5333333333333, 0.33333333333333
537, 1.0666666666667, 1.6, 0.16666666666667
538, 1.1333333333333, 1.6, 0.16666666666667
539, 1.0666666666667, 1.6, 0.33333333333333
540, 1.1333333333333, 1.6, 0.33333333333333
541, 1.5333333333333, 1.4666666666667, 0.5
542, 1.5333333333333, 1.5333333333333, 0.5
543, 1.8666666666667, 1.4666666666667, 0.5
544, 1.8666666666667, 1.5333333333333, 0.5
545, 1.5333333333333, 1.4666666666667, 0
546, 1.5333333333333, 1.5333333333333, 0
547, 1.8666666666667, 1.4666666666667, 0
548, 1.8666666666667, 1.5333333333333, 0
549, 2.2, 1.4666666666667, 0.16666666666667
550, 2.2, 1.5333333333333, 0.16666666666667
551, 2.2, 1.4666666666667, 0.33333333333333
552, 2.2, 1.5333333333333, 0.33333333333333
553, 1.5333333333333, 1.6, 0.16666666666667
554, 1.8666666666667, 1.6, 0.16666666666667
555, 1.5333333333333, 1.6, 0.33333333333333
556, 1.8666666666667, 1.6, 0.33333333333333
557, 0.33333333333333, -0.066666666666667, 0
558, 0.33333333333333, -0.13333333333333, 0
559, 0.66666666666667, -0.066666666666667, 0
560, 0.66666666666667, -0.13333333333333, 0
561, 1, -0.066666666666667, 0.16666666666667
562, 1, -0.13333333333333, 0.16666666666667
563, 1, -0.066666666666667, 0.33333333333333
564, 1, -0.13333333333333, 0.33333333333333
565, 0.33333333333333, -0.066666666666667, 0.5
566, 0.33333333333333, -0.13333333333333, 0.5
567, 0.66666666666667, -0.066666666666667, 0.5
568, 0.66666666666667, -0.13333333333333, 0.5
569, 0, -0.066666666666667, 0.16666666666667
570, 0, -0.13333333333333, 0.16666666666667
571, 0, -0.066666666666667, 0.33333333333333
572, 0, -0.13333333333333, 0.33333333333333
573, 0.33333333333333, -0.2, 0.16666666666667
574, 0.33333333333333, -0.2, 0.33333333333333
575, 0.66666666666667, -0.2, 0.16666666666667
576, 0.66666666666667, -0.2, 0.33333333333333
577, -0.1, -0.066666666666667, 0.16666666666667
578, -0.1, -0.13333333333333, 0.16666666666667
579, -0.1, -0.066666666666667, 0.33333333333333
580, -0.1, -0.13333333333333, 0.33333333333333
581, 1.5333333333333, -0.066666666666667, 0.5
582, 1.5333333333333, -0.13333333333333, 0.5
583, 1.8666666666667, -0.066666666666667, 0.5
584, 1.8666666666667, -0.13333333333333, 0.5
585, 1.5333333333333, -0.066666666666667, 0
586, 1.5333333333333, -0.13333333333333, 0
587, 1.8666666666667, -0.066666666666667, 0
588, 1.8666666666667, -0.13333333333333, 0
589, 1.2, -0.066666666666667, 0.16666666666667
590, 1.2, -0.13333333333333, 0.16666666666667
591, 1.2, -0.066666666666667, 0.33333333333333
592, 1.2, -0.13333333333333, 0.33333333333333
593, 2.2, -0.066666666666667, 0.16666666666667
594, 2.2, -0.13333333333333, 0.16666666666667
595, 2.2, -0.066666666666667, 0.33333333333333
596, 2.2, -0.13333333333333, 0.33333333333333
597, 1.5333333333333, -0.2, 0.16666666666667
598, 1.8666666666667, -0.2, 0.16666666666667
599, 1.5333333333333, -0.2, 0.33333333333333
600, 1.8666666666667, -0.2, 0.33333333333333
601, 2.3, -0.066666666666667, 0.16666666666667
602, 2.3, -0.13333333333333, 0.16666666666667
603, 2.3, -0.066666666666667, 0.33333333333333
604, 2.3, -0.13333333333333, 0.33333333333333
605, 0.33333333333333, 0.025, 0.16666666666667
606, 0.66666666666667, 0.025, 0.16666666666667
607, 0.33333333333333, 0.025, 0.33333333333333
608, 0.66666666666667, 0.025, 0.33333333333333
609, 0.33333333333333, 0.5, 0.16666666666667
610, 0.33333333333333, 0.9, 0.16666666666667
611, 0.33333333333333, 0.5, 0.33333333333333
612, 0.33333333333333, 0.9, 0.33333333333333
613, 0.66666666666667, 0.5, 0.16666666666667
614, 0.66666666666667, 0.9, 0.16666666666667
615, 0.66666666666667, 0.5, 0.33333333333333
616, 0.66666666666667, 0.9, 0.33333333333333
617, 0.33333333333333, 1.375, 0.16666666666667
618, 0.33333333333333, 1.375, 0.33333333333333
619, 0.66666666666667, 1.375, 0.16666666666667
620, 0.66666666666667, 1.375, 0.33333333333333
621, 1.0666666666667, 1.375, 0.16666666666667
622, 1.1333333333333, 1.375, 0.16666666666667
623, 1.0666666666667, 1.375, 0.33333333333333
624, 1.1333333333333, 1.375, 0.33333333333333
625, 1.5333333333333, 1.375, 0.16666666666667
626, 1.8666666666667, 1.375, 0.16666666666667
627, 1.5333333333333, 1.375, 0.33333333333333
628, 1.8666666666667, 1.375, 0.33333333333333
629, 1.5333333333333, 0.9, 0.16666666666667
630, 1.5333333333333, 0.5, 0.16666666666667
631, 1.8666666666667, 0.9, 0.16666666666667
632, 1.8666666666667, 0.5, 0.16666666666667
633, 1.5333333333333, 0.9, 0.33333333333333
634, 1.5333333333333, 0.5, 0.33333333333333
635, 1.8666666666667, 0.9, 0.33333333333333
636, 1.8666666666667, 0.5, 0.33333333333333
637, 1.5333333333333, 0.025, 0.16666666666667
638, 1.8666666666667, 0.025, 0.16666666666667
639, 1.5333333333333, 0.025, 0.33333333333333
640, 1.8666666666667, 0.025, 0.33333333333333
641, 0.33333333333333, 1.4666666666667, 0.16666666666667
642, 0.33333333333333, 1.5333333333333, 0.16666666666667
643, 0.33333333333333, 1.4666666666667, 0.33333333333333
644, 0.33333333333333, 1.5333333333333, 0.33333333333333
645, 0.66666666666667, 1.4666666666667, 0.16666666666667
646, 0.66666666666667, 1.5333333333333, 0.16666666666667
647, 0.66666666666667, 1.4666666666667, 0.33333333333333
648, 0.66666666666667, 1.5333333333333, 0.33333333333333
649, 1.0666666666667, 1.4666666666667, 0.16666666666667
650, 1.0666666666667, 1.5333333333333, 0.16666666666667
651, 1.1333333333333, 1.4666666666667, 0.16666666666667
652, 1.1333333333333, 1.5333333333333, 0.16666666666667
653, 1.0666666666667, 1.4666666666667, 0.33333333333333
654, 1.0666666666667, 1.5333333333333, 0.33333333333333
655, 1.1333333333333, 1.4666666666667, 0.33333333333333
656, 1.1333333333333, 1.5333333333333, 0.33333333333333
657, 1.5333333333333, 1.4666666666667, 0.16666666666667
658, 1.5333333333333, 1.5333333333333, 0.16666666666667
659, 1.8666666666667, 1.4666666666667, 0.16666666666667
660, 1.8666666666667, 1.5333333333333, 0.16666666666667
661, 1.5333333333333, 1.4666666666667, 0.33333333333333
662, 1.5333333333333, 1.5333333333333, 0.33333333333333
663, 1.8666666666667, 1.4666666666667, 0.33333333333333
664, 1.8666666666667, 1.5333333333333, 0.33333333333333
665, 0.33333333333333, -0.066666666666667, 0.16666666666667
666, 0.33333333333333, -0.13333333333333, 0.16666666666667
667, 0.33333333333333, -0.066666666666667, 0.33333333333333
668, 0.33333333333333, -0.13333333333333, 0.33333333333333
669, 0.66666666666667, -0.066666666666667, 0.16666666666667
670, 0.66666666666667, -0.13333333333333, 0.16666666666667
671, 0.66666666666667, -0.066666666666667, 0.33333333333333
672, 0.66666666666667, -0.13333333333333, 0.33333333333333
673, 1.5333333333333, -0.066666666666667, 0.16666666666667
674, 1.5333333333333, -0.13333333333333, 0.16666666666667
675, 1.8666666666667, -0.066666666666667, 0.16666666666667
676, 1.8666666666667, -0.13333333333333, 0.16666666666667
677, 1.5333333333333, -0.066666666666667, 0.33333333333333
678, 1.5333333333333, -0.13333333333333, 0.33333333333333
679, 1.8666666666667, -0.066666666666667, 0.33333333333333
680, 1.8666666666667, -0.13333333333333, 0.33333333333333
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 1
*ELEMENT, type=T3D2, ELSET=Line2
100, 1, 99
101, 99, 3
*ELEMENT, type=T3D2, ELSET=Line3
102, 4, 100
103, 100, 101
104, 101, 3
*ELEMENT, type=T3D2, ELSET=Line4
105, 2, 102
106, 102, 4
*ELEMENT, type=T3D2, ELSET=Line5
107, 6, 103
108, 103, 104
109, 104, 5
*ELEMENT, type=T3D2, ELSET=Line6
110, 5, 105
111, 105, 7
*ELEMENT, type=T3D2, ELSET=Line7
112, 8, 106
113, 106, 107
114, 107, 7
*ELEMENT, type=T3D2, ELSET=Line8
115, 6, 108
116, 108, 8
*ELEMENT, type=T3D2, ELSET=Line9
117, 2, 109
118, 109, 110
119, 110, 6
*ELEMENT, type=T3D2, ELSET=Line10
120, 1, 111
121, 111, 112
122, 112, 5
*ELEMENT, type=T3D2, ELSET=Line11
123, 4, 113
124, 113, 114
125, 114, 8
*ELEMENT, type=T3D2, ELSET=Line12
126, 3, 115
127, 115, 116
128, 116, 7
*ELEMENT, type=T3D2, ELSET=Line13
129, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
130, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
131, 10, 117
132, 117, 118
133, 118, 9
*ELEMENT, type=T3D2, ELSET=Line16
134, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
135, 9, 119
136, 119, 120
137, 120, 11
*ELEMENT, type=T3D2, ELSET=Line18
138, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
139, 12, 121
140, 121, 122
141, 122, 11
*ELEMENT, type=T3D2, ELSET=Line20
142, 10, 123
143, 123, 124
144, 124, 12
*ELEMENT, type=T3D2, ELSET=Line21
145, 9, 125
146, 125, 126
147, 126, 13
*ELEMENT, type=T3D2, ELSET=Line22
148, 10, 127
149, 127, 128
150, 128, 14
*ELEMENT, type=T3D2, ELSET=Line23
151, 14, 129
152, 129, 130
153, 130, 13
*ELEMENT, type=T3D2, ELSET=Line24
154, 11, 131
155, 131, 132
156, 132, 15
*ELEMENT, type=T3D2, ELSET=Line25
157, 13, 133
158, 133, 134
159, 134, 15
*ELEMENT, type=T3D2, ELSET=Line26
160, 12, 135
161, 135, 136
162, 136, 16
*ELEMENT, type=T3D2, ELSET=Line27
163, 16, 137
164, 137, 138
165, 138, 15
*ELEMENT, type=T3D2, ELSET=Line28
166, 14, 139
167, 139, 140
168, 140, 16
*ELEMENT, type=T3D2, ELSET=Line29
169, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
170, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
171, 18, 141
172, 141, 142
173, 142, 17
*ELEMENT, type=T3D2, ELSET=Line32
174, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
175, 17, 143
176, 143, 144
177, 144, 19
*ELEMENT, type=T3D2, ELSET=Line34
178, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
179, 20, 145
180, 145, 146
181, 146, 19
*ELEMENT, type=T3D2, ELSET=Line36
182, 18, 147
183, 147, 148
184, 148, 20
*ELEMENT, type=T3D2, ELSET=Line37
185, 17, 149
186, 149, 21
*ELEMENT, type=T3D2, ELSET=Line38
187, 18, 150
188, 150, 22
*ELEMENT, type=T3D2, ELSET=Line39
189, 22, 151
190, 151, 152
191, 152, 21
*ELEMENT, type=T3D2, ELSET=Line40
192, 19, 153
193, 153, 23
*ELEMENT, type=T3D2, ELSET=Line41
194, 21, 154
195, 154, 155
196, 155, 23
*ELEMENT, type=T3D2, ELSET=Line42
197, 20, 156
198, 156, 24
*ELEMENT, type=T3D2, ELSET=Line43
199, 24, 157
200, 157, 158
201, 158, 23
*ELEMENT, type=T3D2, ELSET=Line44
202, 22, 159
203, 159, 160
204, 160, 24
*ELEMENT, type=T3D2, ELSET=Line45
205, 19, 161
206, 161, 162
207, 162, 25
*ELEMENT, type=T3D2, ELSET=Line46
208, 23, 163
209, 163, 164
210, 164, 26
*ELEMENT, type=T3D2, ELSET=Line47
211, 25, 165
212, 165, 26
*ELEMENT, type=T3D2, ELSET=Line48
213, 17, 166
214, 166, 167
215, 167, 27
*ELEMENT, type=T3D2, ELSET=Line49
216, 21, 168
217, 168, 169
218, 169, 28
*ELEMENT, type=T3D2, ELSET=Line50
219, 27, 170
220, 170, 28
*ELEMENT, type=T3D2, ELSET=Line51
221, 27, 171
222, 171, 172
223, 172, 25
*ELEMENT, type=T3D2, ELSET=Line52
224, 28, 173
225, 173, 174
226, 174, 26
*ELEMENT, type=T3D2, ELSET=Line53
227, 25, 175
228, 175, 176
229, 176, 29
*ELEMENT, type=T3D2, ELSET=Line54
230, 26, 177
231, 177, 178
232, 178, 30
*ELEMENT, type=T3D2, ELSET=Line55
233, 29, 179
234, 179, 30
*ELEMENT, type=T3D2, ELSET=Line56
235, 27, 180
236, 180, 181
237, 181, 31
*ELEMENT, type=T3D2, ELSET=Line57
238, 28, 182
239, 182, 183
240, 183, 32
*ELEMENT, type=T3D2, ELSET=Line58
241, 31, 184
242, 184, 32
*ELEMENT, type=T3D2, ELSET=Line59
243, 31, 185
244, 185, 186
245, 186, 29
*ELEMENT, type=T3D2, ELSET=Line60
246, 32, 187
247, 187, 188
248, 188, 30
*ELEMENT, type=T3D2, ELSET=Line61
249, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
250, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
251, 33, 189
252, 189, 190
253, 190, 34
*ELEMENT, type=T3D2, ELSET=Line64
254, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
255, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
256, 35, 191
257, 191, 192
258, 192, 36
*ELEMENT, type=T3D2, ELSET=Line67
259, 35, 193
260, 193, 194
261, 194, 33
*ELEMENT, type=T3D2, ELSET=Line68
262, 36, 195
263, 195, 196
264, 196, 34
*ELEMENT, type=T3D2, ELSET=Line69
265, 33, 197
266, 197, 198
267, 198, 37
*ELEMENT, type=T3D2, ELSET=Line70
268, 34, 199
269, 199, 200
270, 200, 38
*ELEMENT, type=T3D2, ELSET=Line71
271, 37, 201
272, 201, 202
273, 202, 38
*ELEMENT, type=T3D2, ELSET=Line72
274, 35, 203
275, 203, 204
276, 204, 39
*ELEMENT, type=T3D2, ELSET=Line73
277, 36, 205
278, 205, 206
279, 206, 40
*ELEMENT, type=T3D2, ELSET=Line74
280, 39, 207
281, 207, 208
282, 208, 40
*ELEMENT, type=T3D2, ELSET=Line75
283, 39, 209
284, 209, 210
285, 210, 37
*ELEMENT, type=T3D2, ELSET=Line76
286, 40, 211
287, 211, 212
288, 212, 38
*ELEMENT, type=T3D2, ELSET=Line77
289, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
290, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
291, 41, 213
292, 213, 214
293, 214, 42
*ELEMENT, type=T3D2, ELSET=Line80
294, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
295, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
296, 43, 215
297, 215, 216
298, 216, 44
*ELEMENT, type=T3D2, ELSET=Line83
299, 43, 217
300, 217, 218
301, 218, 41
*ELEMENT, type=T3D2, ELSET=Line84
302, 44, 219
303, 219, 220
304, 220, 42
*ELEMENT, type=T3D2, ELSET=Line85
305, 41, 221
306, 221, 45
*ELEMENT, type=T3D2, ELSET=Line86
307, 42, 222
308, 222, 46
*ELEMENT, type=T3D2, ELSET=Line87
309, 45, 223
310, 223, 224
311, 224, 46
*ELEMENT, type=T3D2, ELSET=Line88
312, 43, 225
313, 225, 47
*ELEMENT, type=T3D2, ELSET=Line89
314, 44, 226
315, 226, 48
*ELEMENT, type=T3D2, ELSET=Line90
316, 47, 227
317, 227, 228
318, 228, 48
*ELEMENT, type=T3D2, ELSET=Line91
319, 47, 229
320, 229, 230
321, 230, 45
*ELEMENT, type=T3D2, ELSET=Line92
322, 48, 231
323, 231, 232
324, 232, 46
*ELEMENT, type=T3D2, ELSET=Line93
325, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
326, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
327, 49, 233
328, 233, 50
*ELEMENT, type=T3D2, ELSET=Line96
329, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
330, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
331, 51, 234
332, 234, 52
*ELEMENT, type=T3D2, ELSET=Line99
333, 51, 235
334, 235, 236
335, 236, 49
*ELEMENT, type=T3D2, ELSET=Line100
336, 52, 237
337, 237, 238
338, 238, 50
*ELEMENT, type=T3D2, ELSET=Line101
339, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
340, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
341, 54, 239
342, 239, 240
343, 240, 53
*ELEMENT, type=T3D2, ELSET=Line104
344, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
345, 53, 241
346, 241, 55
*ELEMENT, type=T3D2, ELSET=Line106
347, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
348, 56, 242
349, 242, 243
350, 243, 55
*ELEMENT, type=T3D2, ELSET=Line108
351, 54, 244
352, 244, 56
*ELEMENT, type=T3D2, ELSET=Line125
353, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
354, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
355, 57, 245
356, 245, 246
357, 246, 58
*ELEMENT, type=T3D2, ELSET=Line128
358, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
359, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
360, 59, 247
361, 247, 248
362, 248, 60
*ELEMENT, type=T3D2, ELSET=Line131
363, 59, 249
364, 249, 250
365, 250, 57
*ELEMENT, type=T3D2, ELSET=Line132
366, 60, 251
367, 251, 252
368, 252, 58
*ELEMENT, type=T3D2, ELSET=Line133
369, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
370, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
371, 61, 253
372, 253, 254
373, 254, 62
*ELEMENT, type=T3D2, ELSET=Line136
374, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
375, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
376, 63, 255
377, 255, 256
378, 256, 64
*ELEMENT, type=T3D2, ELSET=Line139
379, 63, 257
380, 257, 258
381, 258, 61
*ELEMENT, type=T3D2, ELSET=Line140
382, 64, 259
383, 259, 260
384, 260, 62
*ELEMENT, type=T3D2, ELSET=Line141
385, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
386, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
387, 65, 261
388, 261, 262
389, 262, 66
*ELEMENT, type=T3D2, ELSET=Line144
390, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
391, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
392, 67, 263
393, 263, 264
394, 264, 68
*ELEMENT, type=T3D2, ELSET=Line147
395, 67, 265
396, 265, 266
397, 266, 65
*ELEMENT, type=T3D2, ELSET=Line148
398, 68, 267
399, 267, 268
400, 268, 66
*ELEMENT, type=T3D2, ELSET=Line149
401, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
402, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
403, 69, 269
404, 269, 270
405, 270, 70
*ELEMENT, type=T3D2, ELSET=Line152
406, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
407, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
408, 71, 271
409, 271, 272
410, 272, 72
*ELEMENT, type=T3D2, ELSET=Line155
411, 69, 273
412, 273, 274
413, 274, 71
*ELEMENT, type=T3D2, ELSET=Line156
414, 70, 275
415, 275, 276
416, 276, 72
*ELEMENT, type=T3D2, ELSET=Line157
417, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
418, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
419, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
420, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
421, 73, 277
422, 277, 278
423, 278, 74
*ELEMENT, type=T3D2, ELSET=Line162
424, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
425, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
426, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
427, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
428, 75, 279
429, 279, 280
430, 280, 76
*ELEMENT, type=T3D2, ELSET=Line167
431, 21, 281
432, 281, 282
433, 282, 77
*ELEMENT, type=T3D2, ELSET=Line168
434, 22, 283
435, 283, 284
436, 284, 78
*ELEMENT, type=T3D2, ELSET=Line169
437, 78, 285
438, 285, 286
439, 286, 77
*ELEMENT, type=T3D2, ELSET=Line170
440, 23, 287
441, 287, 288
442, 288, 79
*ELEMENT, type=T3D2, ELSET=Line171
443, 77, 289
444, 289, 290
445, 290, 79
*ELEMENT, type=T3D2, ELSET=Line172
446, 24, 291
447, 291, 292
448, 292, 80
*ELEMENT, type=T3D2, ELSET=Line173
449, 80, 293
450, 293, 294
451, 294, 79
*ELEMENT, type=T3D2, ELSET=Line174
452, 78, 295
453, 295, 296
454, 296, 80
*ELEMENT, type=T3D2, ELSET=Line175
455, 26, 297
456, 297, 298
457, 298, 81
*ELEMENT, type=T3D2, ELSET=Line176
458, 79, 299
459, 299, 300
460, 300, 81
*ELEMENT, type=T3D2, ELSET=Line177
461, 28, 301
462, 301, 302
463, 302, 82
*ELEMENT, type=T3D2, ELSET=Line178
464, 77, 303
465, 303, 304
466, 304, 82
*ELEMENT, type=T3D2, ELSET=Line179
467, 82, 305
468, 305, 306
469, 306, 81
*ELEMENT, type=T3D2, ELSET=Line180
470, 30, 307
471, 307, 308
472, 308, 83
*ELEMENT, type=T3D2, ELSET=Line181
473, 81, 309
474, 309, 310
475, 310, 83
*ELEMENT, type=T3D2, ELSET=Line182
476, 32, 311
477, 311, 312
478, 312, 84
*ELEMENT, type=T3D2, ELSET=Line183
479, 82, 313
480, 313, 314
481, 314, 84
*ELEMENT, type=T3D2, ELSET=Line184
482, 84, 315
483, 315, 316
484, 316, 83
*ELEMENT, type=T3D2, ELSET=Line185
485, 6, 317
486, 317, 318
487, 318, 85
*ELEMENT, type=T3D2, ELSET=Line186
488, 2, 319
489, 319, 320
490, 320, 86
*ELEMENT, type=T3D2, ELSET=Line187
491, 86, 321
492, 321, 322
493, 322, 85
*ELEMENT, type=T3D2, ELSET=Line188
494, 5, 323
495, 323, 324
496, 324, 87
*ELEMENT, type=T3D2, ELSET=Line189
497, 85, 325
498, 325, 326
499, 326, 87
*ELEMENT, type=T3D2, ELSET=Line190
500, 1, 327
501, 327, 328
502, 328, 88
*ELEMENT, type=T3D2, ELSET=Line191
503, 88, 329
504, 329, 330
505, 330, 87
*ELEMENT, type=T3D2, ELSET=Line192
506, 86, 331
507, 331, 332
508, 332, 88
*ELEMENT, type=T3D2, ELSET=Line193
509, 53, 333
510, 333, 334
511, 334, 89
*ELEMENT, type=T3D2, ELSET=Line194
512, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
513, 54, 335
514, 335, 336
515, 336, 90
*ELEMENT, type=T3D2, ELSET=Line196
516, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
517, 90, 337
518, 337, 338
519, 338, 89
*ELEMENT, type=T3D2, ELSET=Line198
520, 45, 339
521, 339, 340
522, 340, 91
*ELEMENT, type=T3D2, ELSET=Line199
523, 46, 341
524, 341, 342
525, 342, 92
*ELEMENT, type=T3D2, ELSET=Line200
526, 91, 343
527, 343, 344
528, 344, 92
*ELEMENT, type=T3D2, ELSET=Line201
529, 47, 345
530, 345, 346
531, 346, 93
*ELEMENT, type=T3D2, ELSET=Line202
532, 48, 347
533, 347, 348
534, 348, 94
*ELEMENT, type=T3D2, ELSET=Line203
535, 93, 349
536, 349, 350
537, 350, 94
*ELEMENT, type=T3D2, ELSET=Line204
538, 93, 351
539, 351, 352
540, 352, 91
*ELEMENT, type=T3D2, ELSET=Line205
541, 94, 353
542, 353, 354
543, 354, 92
*ELEMENT, type=T3D2, ELSET=Line206
544, 50, 355
545, 355, 356
546, 356, 95
*ELEMENT, type=T3D2, ELSET=Line207
547, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
548, 52, 357
549, 357, 358
550, 358, 96
*ELEMENT, type=T3D2, ELSET=Line209
551, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
552, 96, 359
553, 359, 360
554, 360, 95
*ELEMENT, type=CPS4, ELSET=Surface1
555, 2, 97, 361, 102
556, 102, 361, 100, 4
557, 97, 98, 362, 361
558, 361, 362, 101, 100
559, 98, 1, 99, 362
560, 362, 99, 3, 101
*ELEMENT, type=CPS4, ELSET=Surface2
561, 6, 108, 363, 103
562, 108, 8, 106, 363
563, 103, 363, 364, 104
564, 363, 106, 107, 364
565, 104, 364, 105, 5
566, 364, 107, 7, 105
*ELEMENT, type=CPS4, ELSET=Surface3
567, 2, 109, 365, 97
568, 97, 365, 366, 98
569, 98, 366, 111, 1
570, 109, 110, 367, 365
571, 365, 367, 368, 366
572, 366, 368, 112, 111
573, 110, 6, 103, 367
574, 367, 103, 104, 368
575, 368, 104, 5, 112
*ELEMENT, type=CPS4, ELSET=Surface4
576, 4, 100, 369, 113
577, 100, 101, 370, 369
578, 101, 3, 115, 370
579, 113, 369, 371, 114
580, 369, 370, 372, 371
581, 370, 115, 116, 372
582, 114, 371, 106, 8
583, 371, 372, 107, 106
584, 372, 116, 7, 107
*ELEMENT, type=CPS4, ELSET=Surface5
585, 2, 102, 373, 109
586, 109, 373, 374, 110
587, 110, 374, 108, 6
588, 102, 4, 113, 373
589, 373, 113, 114, 374
590, 374, 114, 8, 108
*ELEMENT, type=CPS4, ELSET=Surface6
591, 1, 111, 375, 99
592, 111, 112, 376, 375
593, 112, 5, 105, 376
594, 99, 375, 115, 3
595, 375, 376, 116, 115
596, 376, 105, 7, 116
*ELEMENT, type=CPS4, ELSET=Surface7
597, 4, 10, 117, 113
598, 113, 117, 118, 114
599, 114, 118, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
600, 8, 9, 119, 106
601, 106, 119, 120, 107
602, 107, 120, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
603, 3, 115, 121, 12
604, 115, 116, 122, 121
605, 116, 7, 11, 122
*ELEMENT, type=CPS4, ELSET=Surface10
606, 4, 100, 123, 10
607, 100, 101, 124, 123
608, 101, 3, 12, 124
*ELEMENT, type=CPS4, ELSET=Surface11
609, 10, 123, 377, 117
610, 123, 124, 378, 377
611, 124, 12, 121, 378
612, 117, 377, 379, 118
613, 377, 378, 380, 379
614, 378, 121, 122, 380
615, 118, 379, 119, 9
616, 379, 380, 120, 119
617, 380, 122, 11, 120
*ELEMENT, type=CPS4, ELSET=Surface12
618, 10, 127, 381, 117
619, 127, 128, 382, 381
620, 128, 14, 129, 382
621, 117, 381, 383, 118
622, 381, 382, 384, 383
623, 382, 129, 130, 384
624, 118, 383, 125, 9
625, 383, 384, 126, 125
626, 384, 130, 13, 126
*ELEMENT, type=CPS4, ELSET=Surface13
627, 9, 125, 385, 119
628, 125, 126, 386, 385
629, 126, 13, 133, 386
630, 119, 385, 387, 120
631, 385, 386, 388, 387
632, 386, 133, 134, 388
633, 120, 387, 131, 11
634, 387, 388, 132, 131
635, 388, 134, 15, 132
*ELEMENT, type=CPS4, ELSET=Surface14
636, 12, 121, 389, 135
637, 135, 389, 390, 136
638, 136, 390, 137, 16
639, 121, 122, 391, 389
640, 389, 391, 392, 390
641, 390, 392, 138, 137
642, 122, 11, 131, 391
643, 391, 131, 132, 392
644, 392, 132, 15, 138
*ELEMENT, type=CPS4, ELSET=Surface15
645, 10, 123, 393, 127
646, 127, 393, 394, 128
647, 128, 394, 139, 14
648, 123, 124, 395, 393
649, 393, 395, 396, 394
650, 394, 396, 140, 139
651, 124, 12, 135, 395
652, 395, 135, 136, 396
653, 396, 136, 16, 140
*ELEMENT, type=CPS4, ELSET=Surface16
654, 14, 139, 397, 129
655, 139, 140, 398, 397
656, 140, 16, 137, 398
657, 129, 397, 399, 130
658, 397, 398, 400, 399
659, 398, 137, 138, 400
660, 130, 399, 133, 13
661, 399, 400, 134, 133
662, 400, 138, 15, 134
*ELEMENT, type=CPS4, ELSET=Surface17
663, 14, 18, 141, 129
664, 129, 141, 142, 130
665, 130, 142, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
666, 13, 17, 143, 133
667, 133, 143, 144, 134
668, 134, 144, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
669, 16, 137, 145, 20
670, 137, 138, 146, 145
671, 138, 15, 19, 146
*ELEMENT, type=CPS4, ELSET=Surface20
672, 14, 139, 147, 18
673, 139, 140, 148, 147
674, 140, 16, 20, 148
*ELEMENT, type=CPS4, ELSET=Surface21
675, 18, 147, 401, 141
676, 147, 148, 402, 401
677, 148, 20, 145, 402
678, 141, 401, 403, 142
679, 401, 402, 404, 403
680, 402, 145, 146, 404
681, 142, 403, 143, 17
682, 403, 404, 144, 143
683, 404, 146, 19, 144
*ELEMENT, type=CPS4, ELSET=Surface22
684, 18, 150, 405, 141
685, 150, 22, 151, 405
686, 141, 405, 406, 142
687, 405, 151, 152, 406
688, 142, 406, 149, 17
689, 406, 152, 21, 149
*ELEMENT, type=CPS4, ELSET=Surface23
690, 17, 149, 407, 143
691, 149, 21, 154, 407
692, 143, 407, 408, 144
693, 407, 154, 155, 408
694, 144, 408, 153, 19
695, 408, 155, 23, 153
*ELEMENT, type=CPS4, ELSET=Surface24
696, 20, 145, 409, 156
697, 156, 409, 157, 24
698, 145, 146, 410, 409
699, 409, 410, 158, 157
700, 146, 19, 153, 410
701, 410, 153, 23, 158
*ELEMENT, type=CPS4, ELSET=Surface25
702, 18, 147, 411, 150
703, 150, 411, 159, 22
704, 147, 148, 412, 411
705, 411, 412, 160, 159
706, 148, 20, 156, 412
707, 412, 156, 24, 160
*ELEMENT, type=CPS4, ELSET=Surface26
708, 22, 159, 413, 151
709, 159, 160, 414, 413
710, 160, 24, 157, 414
711, 151, 413, 415, 152
712, 413, 414, 416, 415
713, 414, 157, 158, 416
714, 152, 415, 154, 21
715, 415, 416, 155, 154
716, 416, 158, 23, 155
*ELEMENT, type=CPS4, ELSET=Surface27
717, 19, 161, 417, 153
718, 161, 162, 418, 417
719, 162, 25, 165, 418
720, 153, 417, 163, 23
721, 417, 418, 164, 163
722, 418, 165, 26, 164
*ELEMENT, type=CPS4, ELSET=Surface28
723, 17, 149, 419, 166
724, 166, 419, 420, 167
725, 167, 420, 170, 27
726, 149, 21, 168, 419
727, 419, 168, 169, 420
728, 420, 169, 28, 170
*ELEMENT, type=CPS4, ELSET=Surface29
729, 17, 166, 421, 143
730, 166, 167, 422, 421
731, 167, 27, 171, 422
732, 143, 421, 423, 144
733, 421, 422, 424, 423
734, 422, 171, 172, 424
735, 144, 423, 161, 19
736, 423, 424, 162, 161
737, 424, 172, 25, 162
*ELEMENT, type=CPS4, ELSET=Surface30
738, 21, 154, 425, 168
739, 168, 425, 426, 169
740, 169, 426, 173, 28
741, 154, 155, 427, 425
742, 425, 427, 428, 426
743, 426, 428, 174, 173
744, 155, 23, 163, 427
745, 427, 163, 164, 428
746, 428, 164, 26, 174
*ELEMENT, type=CPS4, ELSET=Surface31
747, 27, 170, 429, 171
748, 170, 28, 173, 429
749, 171, 429, 430, 172
750, 429, 173, 174, 430
751, 172, 430, 165, 25
752, 430, 174, 26, 165
*ELEMENT, type=CPS4, ELSET=Surface32
753, 25, 175, 431, 165
754, 175, 176, 432, 431
755, 176, 29, 179, 432
756, 165, 431, 177, 26
757, 431, 432, 178, 177
758, 432, 179, 30, 178
*ELEMENT, type=CPS4, ELSET=Surface33
759, 27, 170, 433, 180
760, 180, 433, 434, 181
761, 181, 434, 184, 31
762, 170, 28, 182, 433
763, 433, 182, 183, 434
764, 434, 183, 32, 184
*ELEMENT, type=CPS4, ELSET=Surface34
765, 27, 180, 435, 171
766, 180, 181, 436, 435
767, 181, 31, 185, 436
768, 171, 435, 437, 172
769, 435, 436, 438, 437
770, 436, 185, 186, 438
771, 172, 437, 175, 25
772, 437, 438, 176, 175
773, 438, 186, 29, 176
*ELEMENT, type=CPS4, ELSET=Surface35
774, 28, 173, 439, 182
775, 182, 439, 440, 183
776, 183, 440, 187, 32
777, 173, 174, 441, 439
778, 439, 441, 442, 440
779, 440, 442, 188, 187
780, 174, 26, 177, 441
781, 441, 177, 178, 442
782, 442, 178, 30, 188
*ELEMENT, type=CPS4, ELSET=Surface36
783, 31, 184, 443, 185
784, 184, 32, 187, 443
785, 185, 443, 444, 186
786, 443, 187, 188, 444
787, 186, 444, 179, 29
788, 444, 188, 30, 179
*ELEMENT, type=CPS4, ELSET=Surface37
789, 25, 33, 189, 175
790, 175, 189, 190, 176
791, 176, 190, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
792, 27, 180, 191, 35
793, 180, 181, 192, 191
794, 181, 31, 36, 192
*ELEMENT, type=CPS4, ELSET=Surface39
795, 27, 35, 193, 171
796, 171, 193, 194, 172
797, 172, 194, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
798, 31, 185, 195, 36
799, 185, 186, 196, 195
800, 186, 29, 34, 196
*ELEMENT, type=CPS4, ELSET=Surface41
801, 35, 191, 445, 193
802, 191, 192, 446, 445
803, 192, 36, 195, 446
804, 193, 445, 447, 194
805, 445, 446, 448, 447
806, 446, 195, 196, 448
807, 194, 447, 189, 33
808, 447, 448, 190, 189
809, 448, 196, 34, 190
*ELEMENT, type=CPS4, ELSET=Surface42
810, 33, 197, 449, 189
811, 197, 198, 450, 449
812, 198, 37, 201, 450
813, 189, 449, 451, 190
814, 449, 450, 452, 451
815, 450, 201, 202, 452
816, 190, 451, 199, 34
817, 451, 452, 200, 199
818, 452, 202, 38, 200
*ELEMENT, type=CPS4, ELSET=Surface43
819, 35, 191, 453, 203
820, 203, 453, 454, 204
821, 204, 454, 207, 39
822, 191, 192, 455, 453
823, 453, 455, 456, 454
824, 454, 456, 208, 207
825, 192, 36, 205, 455
826, 455, 205, 206, 456
827, 456, 206, 40, 208
*ELEMENT, type=CPS4, ELSET=Surface44
828, 35, 203, 457, 193
829, 203, 204, 458, 457
830, 204, 39, 209, 458
831, 193, 457, 459, 194
832, 457, 458, 460, 459
833, 458, 209, 210, 460
834, 194, 459, 197, 33
835, 459, 460, 198, 197
836, 460, 210, 37, 198
*ELEMENT, type=CPS4, ELSET=Surface45
837, 36, 195, 461, 205
838, 205, 461, 462, 206
839, 206, 462, 211, 40
840, 195, 196, 463, 461
841, 461, 463, 464, 462
842, 462, 464, 212, 211
843, 196, 34, 199, 463
844, 463, 199, 200, 464
845, 464, 200, 38, 212
*ELEMENT, type=CPS4, ELSET=Surface46
846, 39, 207, 465, 209
847, 207, 208, 466, 465
848, 208, 40, 211, 466
849, 209, 465, 467, 210
850, 465, 466, 468, 467
851, 466, 211, 212, 468
852, 210, 467, 201, 37
853, 467, 468, 202, 201
854, 468, 212, 38, 202
*ELEMENT, type=CPS4, ELSET=Surface47
855, 37, 41, 213, 201
856, 201, 213, 214, 202
857, 202, 214, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
858, 39, 207, 215, 43
859, 207, 208, 216, 215
860, 208, 40, 44, 216
*ELEMENT, type=CPS4, ELSET=Surface49
861, 39, 43, 217, 209
862, 209, 217, 218, 210
863, 210, 218, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
864, 40, 211, 219, 44
865, 211, 212, 220, 219
866, 212, 38, 42, 220
*ELEMENT, type=CPS4, ELSET=Surface51
867, 43, 215, 469, 217
868, 215, 216, 470, 469
869, 216, 44, 219, 470
870, 217, 469, 471, 218
871, 469, 470, 472, 471
872, 470, 219, 220, 472
873, 218, 471, 213, 41
874, 471, 472, 214, 213
875, 472, 220, 42, 214
*ELEMENT, type=CPS4, ELSET=Surface52
876, 41, 221, 473, 213
877, 221, 45, 223, 473
878, 213, 473, 474, 214
879, 473, 223, 224, 474
880, 214, 474, 222, 42
881, 474, 224, 46, 222
*ELEMENT, type=CPS4, ELSET=Surface53
882, 43, 215, 475, 225
883, 225, 475, 227, 47
884, 215, 216, 476, 475
885, 475, 476, 228, 227
886, 216, 44, 226, 476
887, 476, 226, 48, 228
*ELEMENT, type=CPS4, ELSET=Surface54
888, 43, 225, 477, 217
889, 225, 47, 229, 477
890, 217, 477, 478, 218
891, 477, 229, 230, 478
892, 218, 478, 221, 41
893, 478, 230, 45, 221
*ELEMENT, type=CPS4, ELSET=Surface55
894, 44, 219, 479, 226
895, 226, 479, 231, 48
896, 219, 220, 480, 479
897, 479, 480, 232, 231
898, 220, 42, 222, 480
899, 480, 222, 46, 232
*ELEMENT, type=CPS4, ELSET=Surface56
900, 47, 227, 481, 229
901, 227, 228, 482, 481
902, 228, 48, 231, 482
903, 229, 481, 483, 230
904, 481, 482, 484, 483
905, 482, 231, 232, 484
906, 230, 483, 223, 45
907, 483, 484, 224, 223
908, 484, 232, 46, 224
*ELEMENT, type=CPS4, ELSET=Surface57
909, 42, 222, 233, 49
910, 222, 46, 50, 233
*ELEMENT, type=CPS4, ELSET=Surface58
911, 44, 51, 234, 226
912, 226, 234, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
913, 44, 219, 235, 51
914, 219, 220, 236, 235
915, 220, 42, 49, 236
*ELEMENT, type=CPS4, ELSET=Surface60
916, 48, 52, 237, 231
917, 231, 237, 238, 232
918, 232, 238, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
919, 51, 235, 485, 234
920, 234, 485, 237, 52
921, 235, 236, 486, 485
922, 485, 486, 238, 237
923, 236, 49, 233, 486
924, 486, 233, 50, 238
*ELEMENT, type=CPS4, ELSET=Surface62
925, 2, 97, 239, 54
926, 97, 98, 240, 239
927, 98, 1, 53, 240
*ELEMENT, type=CPS4, ELSET=Surface63
928, 1, 99, 241, 53
929, 99, 3, 55, 241
*ELEMENT, type=CPS4, ELSET=Surface64
930, 4, 56, 242, 100
931, 100, 242, 243, 101
932, 101, 243, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
933, 2, 54, 244, 102
934, 102, 244, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
935, 54, 239, 487, 244
936, 244, 487, 242, 56
937, 239, 240, 488, 487
938, 487, 488, 243, 242
939, 240, 53, 241, 488
940, 488, 241, 55, 243
*ELEMENT, type=CPS4, ELSET=Surface77
941, 11, 57, 245, 131
942, 131, 245, 246, 132
943, 132, 246, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
944, 9, 125, 247, 59
945, 125, 126, 248, 247
946, 126, 13, 60, 248
*ELEMENT, type=CPS4, ELSET=Surface79
947, 9, 59, 249, 119
948, 119, 249, 250, 120
949, 120, 250, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
950, 13, 133, 251, 60
951, 133, 134, 252, 251
952, 134, 15, 58, 252
*ELEMENT, type=CPS4, ELSET=Surface81
953, 59, 247, 489, 249
954, 247, 248, 490, 489
955, 248, 60, 251, 490
956, 249, 489, 491, 250
957, 489, 490, 492, 491
958, 490, 251, 252, 492
959, 250, 491, 245, 57
960, 491, 492, 246, 245
961, 492, 252, 58, 246
*ELEMENT, type=CPS4, ELSET=Surface82
962, 33, 61, 253, 197
963, 197, 253, 254, 198
964, 198, 254, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
965, 35, 203, 255, 63
966, 203, 204, 256, 255
967, 204, 39, 64, 256
*ELEMENT, type=CPS4, ELSET=Surface84
968, 35, 63, 257, 193
969, 193, 257, 258, 194
970, 194, 258, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
971, 39, 209, 259, 64
972, 209, 210, 260, 259
973, 210, 37, 62, 260
*ELEMENT, type=CPS4, ELSET=Surface86
974, 63, 255, 493, 257
975, 255, 256, 494, 493
976, 256, 64, 259, 494
977, 257, 493, 495, 258
978, 493, 494, 496, 495
979, 494, 259, 260, 496
980, 258, 495, 253, 61
981, 495, 496, 254, 253
982, 496, 260, 62, 254
*ELEMENT, type=CPS4, ELSET=Surface87
983, 9, 65, 261, 125
984, 125, 261, 262, 126
985, 126, 262, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
986, 10, 127, 263, 67
987, 127, 128, 264, 263
988, 128, 14, 68, 264
*ELEMENT, type=CPS4, ELSET=Surface89
989, 10, 67, 265, 117
990, 117, 265, 266, 118
991, 118, 266, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
992, 14, 129, 267, 68
993, 129, 130, 268, 267
994, 130, 13, 66, 268
*ELEMENT, type=CPS4, ELSET=Surface91
995, 67, 263, 497, 265
996, 263, 264, 498, 497
997, 264, 68, 267, 498
998, 265, 497, 499, 266
999, 497, 498, 500, 499
1000, 498, 267, 268, 500
1001, 266, 499, 261, 65
1002, 499, 500, 262, 261
1003, 500, 268, 66, 262
*ELEMENT, type=CPS4, ELSET=Surface92
1004, 35, 69, 269, 203
1005, 203, 269, 270, 204
1006, 204, 270, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
1007, 36, 205, 271, 71
1008, 205, 206, 272, 271
1009, 206, 40, 72, 272
*ELEMENT, type=CPS4, ELSET=Surface94
1010, 35, 191, 273, 69
1011, 191, 192, 274, 273
1012, 192, 36, 71, 274
*ELEMENT, type=CPS4, ELSET=Surface95
1013, 39, 70, 275, 207
1014, 207, 275, 276, 208
1015, 208, 276, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
1016, 69, 273, 501, 269
1017, 269, 501, 502, 270
1018, 270, 502, 275, 70
1019, 273, 274, 503, 501
1020, 501, 503, 504, 502
1021, 502, 504, 276, 275
1022, 274, 71, 271, 503
1023, 503, 271, 272, 504
1024, 504, 272, 72, 276
*ELEMENT, type=CPS4, ELSET=Surface97
1025, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
1026, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
1027, 63, 73, 277, 255
1028, 255, 277, 278, 256
1029, 256, 278, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
1030, 69, 269, 277, 73
1031, 269, 270, 278, 277
1032, 270, 70, 74, 278
*ELEMENT, type=CPS4, ELSET=Surface101
1033, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
1034, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
1035, 59, 75, 279, 247
1036, 247, 279, 280, 248
1037, 248, 280, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
1038, 65, 261, 279, 75
1039, 261, 262, 280, 279
1040, 262, 66, 76, 280
*ELEMENT, type=CPS4, ELSET=Surface105
1041, 22, 283, 505, 151
1042, 283, 284, 506, 505
1043, 284, 78, 285, 506
1044, 151, 505, 507, 152
1045, 505, 506, 508, 507
1046, 506, 285, 286, 508
1047, 152, 507, 281, 21
1048, 507, 508, 282, 281
1049, 508, 286, 77, 282
*ELEMENT, type=CPS4, ELSET=Surface106
1050, 21, 281, 509, 154
1051, 281, 282, 510, 509
1052, 282, 77, 289, 510
1053, 154, 509, 511, 155
1054, 509, 510, 512, 511
1055, 510, 289, 290, 512
1056, 155, 511, 287, 23
1057, 511, 512, 288, 287
1058, 512, 290, 79, 288
*ELEMENT, type=CPS4, ELSET=Surface107
1059, 24, 157, 513, 291
1060, 291, 513, 514, 292
1061, 292, 514, 293, 80
1062, 157, 158, 515, 513
1063, 513, 515, 516, 514
1064, 514, 516, 294, 293
1065, 158, 23, 287, 515
1066, 515, 287, 288, 516
1067, 516, 288, 79, 294
*ELEMENT, type=CPS4, ELSET=Surface108
1068, 22, 159, 517, 283
1069, 283, 517, 518, 284
1070, 284, 518, 295, 78
1071, 159, 160, 519, 517
1072, 517, 519, 520, 518
1073, 518, 520, 296, 295
1074, 160, 24, 291, 519
1075, 519, 291, 292, 520
1076, 520, 292, 80, 296
*ELEMENT, type=CPS4, ELSET=Surface109
1077, 78, 295, 521, 285
1078, 295, 296, 522, 521
1079, 296, 80, 293, 522
1080, 285, 521, 523, 286
1081, 521, 522, 524, 523
1082, 522, 293, 294, 524
1083, 286, 523, 289, 77
1084, 523, 524, 290, 289
1085, 524, 294, 79, 290
*ELEMENT, type=CPS4, ELSET=Surface110
1086, 23, 163, 525, 287
1087, 287, 525, 526, 288
1088, 288, 526, 299, 79
1089, 163, 164, 527, 525
1090, 525, 527, 528, 526
1091, 526, 528, 300, 299
1092, 164, 26, 297, 527
1093, 527, 297, 298, 528
1094, 528, 298, 81, 300
*ELEMENT, type=CPS4, ELSET=Surface111
1095, 21, 281, 529, 168
1096, 281, 282, 530, 529
1097, 282, 77, 303, 530
1098, 168, 529, 531, 169
1099, 529, 530, 532, 531
1100, 530, 303, 304, 532
1101, 169, 531, 301, 28
1102, 531, 532, 302, 301
1103, 532, 304, 82, 302
*ELEMENT, type=CPS4, ELSET=Surface112
1104, 28, 301, 533, 173
1105, 301, 302, 534, 533
1106, 302, 82, 305, 534
1107, 173, 533, 535, 174
1108, 533, 534, 536, 535
1109, 534, 305, 306, 536
1110, 174, 535, 297, 26
1111, 535, 536, 298, 297
1112, 536, 306, 81, 298
*ELEMENT, type=CPS4, ELSET=Surface113
1113, 77, 289, 537, 303
1114, 303, 537, 538, 304
1115, 304, 538, 305, 82
1116, 289, 290, 539, 537
1117, 537, 539, 540, 538
1118, 538, 540, 306, 305
1119, 290, 79, 299, 539
1120, 539, 299, 300, 540
1121, 540, 300, 81, 306
*ELEMENT, type=CPS4, ELSET=Surface114
1122, 26, 177, 541, 297
1123, 297, 541, 542, 298
1124, 298, 542, 309, 81
1125, 177, 178, 543, 541
1126, 541, 543, 544, 542
1127, 542, 544, 310, 309
1128, 178, 30, 307, 543
1129, 543, 307, 308, 544
1130, 544, 308, 83, 310
*ELEMENT, type=CPS4, ELSET=Surface115
1131, 28, 301, 545, 182
1132, 301, 302, 546, 545
1133, 302, 82, 313, 546
1134, 182, 545, 547, 183
1135, 545, 546, 548, 547
1136, 546, 313, 314, 548
1137, 183, 547, 311, 32
1138, 547, 548, 312, 311
1139, 548, 314, 84, 312
*ELEMENT, type=CPS4, ELSET=Surface116
1140, 32, 311, 549, 187
1141, 311, 312, 550, 549
1142, 312, 84, 315, 550
1143, 187, 549, 551, 188
1144, 549, 550, 552, 551
1145, 550, 315, 316, 552
1146, 188, 551, 307, 30
1147, 551, 552, 308, 307
1148, 552, 316, 83, 308
*ELEMENT, type=CPS4, ELSET=Surface117
1149, 82, 305, 553, 313
1150, 313, 553, 554, 314
1151, 314, 554, 315, 84
1152, 305, 306, 555, 553
1153, 553, 555, 556, 554
1154, 554, 556, 316, 315
1155, 306, 81, 309, 555
1156, 555, 309, 310, 556
1157, 556, 310, 83, 316
*ELEMENT, type=CPS4, ELSET=Surface118
1158, 2, 109, 557, 319
1159, 319, 557, 558, 320
1160, 320, 558, 321, 86
1161, 109, 110, 559, 557
1162, 557, 559, 560, 558
1163, 558, 560, 322, 321
1164, 110, 6, 317, 559
1165, 559, 317, 318, 560
1166, 560, 318, 85, 322
*ELEMENT, type=CPS4, ELSET=Surface119
1167, 6, 103, 561, 317
1168, 317, 561, 562, 318
1169, 318, 562, 325, 85
1170, 103, 104, 563, 561
1171, 561, 563, 564, 562
1172, 562, 564, 326, 325
1173, 104, 5, 323, 563
1174, 563, 323, 324, 564
1175, 564, 324, 87, 326
*ELEMENT, type=CPS4, ELSET=Surface120
1176, 1, 327, 565, 111
1177, 327, 328, 566, 565
1178, 328, 88, 329, 566
1179, 111, 565, 567, 112
1180, 565, 566, 568, 567
1181, 566, 329, 330, 568
1182, 112, 567, 323, 5
1183, 567, 568, 324, 323
1184, 568, 330, 87, 324
*ELEMENT, type=CPS4, ELSET=Surface121
1185, 2, 319, 569, 97
1186, 319, 320, 570, 569
1187, 320, 86, 331, 570
1188, 97, 569, 571, 98
1189, 569, 570, 572, 571
1190, 570, 331, 332, 572
1191, 98, 571, 327, 1
1192, 571, 572, 328, 327
1193, 572, 332, 88, 328
*ELEMENT, type=CPS4, ELSET=Surface122
1194, 86, 321, 573, 331
1195, 331, 573, 574, 332
1196, 332, 574, 329, 88
1197, 321, 322, 575, 573
1198, 573, 575, 576, 574
1199, 574, 576, 330, 329
1200, 322, 85, 325, 575
1201, 575, 325, 326, 576
1202, 576, 326, 87, 330
*ELEMENT, type=CPS4, ELSET=Surface123
1203, 1, 53, 333, 327
1204, 327, 333, 334, 328
1205, 328, 334, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
1206, 2, 319, 335, 54
1207, 319, 320, 336, 335
1208, 320, 86, 90, 336
*ELEMENT, type=CPS4, ELSET=Surface125
1209, 54, 335, 577, 239
1210, 335, 336, 578, 577
1211, 336, 90, 337, 578
1212, 239, 577, 579, 240
1213, 577, 578, 580, 579
1214, 578, 337, 338, 580
1215, 240, 579, 333, 53
1216, 579, 580, 334, 333
1217, 580, 338, 89, 334
*ELEMENT, type=CPS4, ELSET=Surface126
1218, 86, 331, 337, 90
1219, 331, 332, 338, 337
1220, 332, 88, 89, 338
*ELEMENT, type=CPS4, ELSET=Surface127
1221, 45, 339, 581, 223
1222, 339, 340, 582, 581
1223, 340, 91, 343, 582
1224, 223, 581, 583, 224
1225, 581, 582, 584, 583
1226, 582, 343, 344, 584
1227, 224, 583, 341, 46
1228, 583, 584, 342, 341
1229, 584, 344, 92, 342
*ELEMENT, type=CPS4, ELSET=Surface128
1230, 47, 227, 585, 345
1231, 345, 585, 586, 346
1232, 346, 586, 349, 93
1233, 227, 228, 587, 585
1234, 585, 587, 588, 586
1235, 586, 588, 350, 349
1236, 228, 48, 347, 587
1237, 587, 347, 348, 588
1238, 588, 348, 94, 350
*ELEMENT, type=CPS4, ELSET=Surface129
1239, 47, 345, 589, 229
1240, 345, 346, 590, 589
1241, 346, 93, 351, 590
1242, 229, 589, 591, 230
1243, 589, 590, 592, 591
1244, 590, 351, 352, 592
1245, 230, 591, 339, 45
1246, 591, 592, 340, 339
1247, 592, 352, 91, 340
*ELEMENT, type=CPS4, ELSET=Surface130
1248, 48, 231, 593, 347
1249, 347, 593, 594, 348
1250, 348, 594, 353, 94
1251, 231, 232, 595, 593
1252, 593, 595, 596, 594
1253, 594, 596, 354, 353
1254, 232, 46, 341, 595
1255, 595, 341, 342, 596
1256, 596, 342, 92, 354
*ELEMENT, type=CPS4, ELSET=Surface131
1257, 93, 349, 597, 351
1258, 349, 350, 598, 597
1259, 350, 94, 353, 598
1260, 351, 597, 599, 352
1261, 597, 598, 600, 599
1262, 598, 353, 354, 600
1263, 352, 599, 343, 91
1264, 599, 600, 344, 343
1265, 600, 354, 92, 344
*ELEMENT, type=CPS4, ELSET=Surface132
1266, 46, 341, 355, 50
1267, 341, 342, 356, 355
1268, 342, 92, 95, 356
*ELEMENT, type=CPS4, ELSET=Surface133
1269, 48, 52, 357, 347
1270, 347, 357, 358, 348
1271, 348, 358, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
1272, 52, 237, 601, 357
1273, 357, 601, 602, 358
1274, 358, 602, 359, 96
1275, 237, 238, 603, 601
1276, 601, 603, 604, 602
1277, 602, 604, 360, 359
1278, 238, 50, 355, 603
1279, 603, 355, 356, 604
1280, 604, 356, 95, 360
*ELEMENT, type=CPS4, ELSET=Surface135
1281, 94, 96, 359, 353
1282, 353, 359, 360, 354
1283, 354, 360, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
1284, 361, 97, 2, 102, 605, 365, 109, 373
1285, 605, 365, 109, 373, 606, 367, 110, 374
1286, 606, 367, 110, 374, 363, 103, 6, 108
1287, 100, 361, 102, 4, 369, 605, 373, 113
1288, 369, 605, 373, 113, 371, 606, 374, 114
1289, 371, 606, 374, 114, 106, 363, 108, 8
1290, 362, 98, 97, 361, 607, 366, 365, 605
1291, 607, 366, 365, 605, 608, 368, 367, 606
1292, 608, 368, 367, 606, 364, 104, 103, 363
1293, 101, 362, 361, 100, 370, 607, 605, 369
1294, 370, 607, 605, 369, 372, 608, 606, 371
1295, 372, 608, 606, 371, 107, 364, 363, 106
1296, 99, 1, 98, 362, 375, 111, 366, 607
1297, 375, 111, 366, 607, 376, 112, 368, 608
1298, 376, 112, 368, 608, 105, 5, 104, 364
1299, 3, 99, 362, 101, 115, 375, 607, 370
1300, 115, 375, 607, 370, 116, 376, 608, 372
1301, 116, 376, 608, 372, 7, 105, 364, 107
*ELEMENT, type=C3D8, ELSET=Volume2
1302, 4, 100, 369, 113, 10, 123, 377, 117
1303, 100, 101, 370, 369, 123, 124, 378, 377
1304, 101, 3, 115, 370, 124, 12, 121, 378
1305, 113, 369, 371, 114, 117, 377, 379, 118
1306, 369, 370, 372, 371, 377, 378, 380, 379
1307, 370, 115, 116, 372, 378, 121, 122, 380
1308, 114, 371, 106, 8, 118, 379, 119, 9
1309, 371, 372, 107, 106, 379, 380, 120, 119
1310, 372, 116, 7, 107, 380, 122, 11, 120
*ELEMENT, type=C3D8, ELSET=Volume3
1311, 10, 123, 377, 117, 127, 393, 609, 381
1312, 127, 393, 609, 381, 128, 394, 610, 382
1313, 128, 394, 610, 382, 14, 139, 397, 129
1314, 123, 124, 378, 377, 393, 395, 611, 609
1315, 393, 395, 611, 609, 394, 396, 612, 610
1316, 394, 396, 612, 610, 139, 140, 398, 397
1317, 124, 12, 121, 378, 395, 135, 389, 611
1318, 395, 135, 389, 611, 396, 136, 390, 612
1319, 396, 136, 390, 612, 140, 16, 137, 398
1320, 117, 377, 379, 118, 381, 609, 613, 383
1321, 381, 609, 613, 383, 382, 610, 614, 384
1322, 382, 610, 614, 384, 129, 397, 399, 130
1323, 377, 378, 380, 379, 609, 611, 615, 613
1324, 609, 611, 615, 613, 610, 612, 616, 614
1325, 610, 612, 616, 614, 397, 398, 400, 399
1326, 378, 121, 122, 380, 611, 389, 391, 615
1327, 611, 389, 391, 615, 612, 390, 392, 616
1328, 612, 390, 392, 616, 398, 137, 138, 400
1329, 118, 379, 119, 9, 383, 613, 385, 125
1330, 383, 613, 385, 125, 384, 614, 386, 126
1331, 384, 614, 386, 126, 130, 399, 133, 13
1332, 379, 380, 120, 119, 613, 615, 387, 385
1333, 613, 615, 387, 385, 614, 616, 388, 386
1334, 614, 616, 388, 386, 399, 400, 134, 133
1335, 380, 122, 11, 120, 615, 391, 131, 387
1336, 615, 391, 131, 387, 616, 392, 132, 388
1337, 616, 392, 132, 388, 400, 138, 15, 134
*ELEMENT, type=C3D8, ELSET=Volume4
1338, 14, 139, 397, 129, 18, 147, 401, 141
1339, 139, 140, 398, 397, 147, 148, 402, 401
1340, 140, 16, 137, 398, 148, 20, 145, 402
1341, 129, 397, 399, 130, 141, 401, 403, 142
1342, 397, 398, 400, 399, 401, 402, 404, 403
1343, 398, 137, 138, 400, 402, 145, 146, 404
1344, 130, 399, 133, 13, 142, 403, 143, 17
1345, 399, 400, 134, 133, 403, 404, 144, 143
1346, 400, 138, 15, 134, 404, 146, 19, 144
*ELEMENT, type=C3D8, ELSET=Volume5
1347, 18, 147, 401, 141, 150, 411, 617, 405
1348, 150, 411, 617, 405, 22, 159, 413, 151
1349, 147, 148, 402, 401, 411, 412, 618, 617
1350, 411, 412, 618, 617, 159, 160, 414, 413
1351, 148, 20, 145, 402, 412, 156, 409, 618
1352, 412, 156, 409, 618, 160, 24, 157, 414
1353, 141, 401, 403, 142, 405, 617, 619, 406
1354, 405, 617, 619, 406, 151, 413, 415, 152
1355, 401, 402, 404, 403, 617, 618, 620, 619
1356, 617, 618, 620, 619, 413, 414, 416, 415
1357, 402, 145, 146, 404, 618, 409, 410, 620
1358, 618, 409, 410, 620, 414, 157, 158, 416
1359, 142, 403, 143, 17, 406, 619, 407, 149
1360, 406, 619, 407, 149, 152, 415, 154, 21
1361, 403, 404, 144, 143, 619, 620, 408, 407
1362, 619, 620, 408, 407, 415, 416, 155, 154
1363, 404, 146, 19, 144, 620, 410, 153, 408
1364, 620, 410, 153, 408, 416, 158, 23, 155
*ELEMENT, type=C3D8, ELSET=Volume6
1365, 17, 149, 407, 143, 166, 419, 621, 421
1366, 166, 419, 621, 421, 167, 420, 622, 422
1367, 167, 420, 622, 422, 27, 170, 429, 171
1368, 149, 21, 154, 407, 419, 168, 425, 621
1369, 419, 168, 425, 621, 420, 169, 426, 622
1370, 420, 169, 426, 622, 170, 28, 173, 429
1371, 143, 407, 408, 144, 421, 621, 623, 423
1372, 421, 621, 623, 423, 422, 622, 624, 424
1373, 422, 622, 624, 424, 171, 429, 430, 172
1374, 407, 154, 155, 408, 621, 425, 427, 623
1375, 621, 425, 427, 623, 622, 426, 428, 624
1376, 622, 426, 428, 624, 429, 173, 174, 430
1377, 144, 408, 153, 19, 423, 623, 417, 161
1378, 423, 623, 417, 161, 424, 624, 418, 162
1379, 424, 624, 418, 162, 172, 430, 165, 25
1380, 408, 155, 23, 153, 623, 427, 163, 417
1381, 623, 427, 163, 417, 624, 428, 164, 418
1382, 624, 428, 164, 418, 430, 174, 26, 165
*ELEMENT, type=C3D8, ELSET=Volume7
1383, 27, 170, 429, 171, 180, 433, 625, 435
1384, 180, 433, 625, 435, 181, 434, 626, 436
1385, 181, 434, 626, 436, 31, 184, 443, 185
1386, 170, 28, 173, 429, 433, 182, 439, 625
1387, 433, 182, 439, 625, 434, 183, 440, 626
1388, 434, 183, 440, 626, 184, 32, 187, 443
1389, 171, 429, 430, 172, 435, 625, 627, 437
1390, 435, 625, 627, 437, 436, 626, 628, 438
1391, 436, 626, 628, 438, 185, 443, 444, 186
1392, 429, 173, 174, 430, 625, 439, 441, 627
1393, 625, 439, 441, 627, 626, 440, 442, 628
1394, 626, 440, 442, 628, 443, 187, 188, 444
1395, 172, 430, 165, 25, 437, 627, 431, 175
1396, 437, 627, 431, 175, 438, 628, 432, 176
1397, 438, 628, 432, 176, 186, 444, 179, 29
1398, 430, 174, 26, 165, 627, 441, 177, 431
1399, 627, 441, 177, 431, 628, 442, 178, 432
1400, 628, 442, 178, 432, 444, 188, 30, 179
*ELEMENT, type=C3D8, ELSET=Volume8
1401, 27, 180, 435, 171, 35, 191, 445, 193
1402, 180, 181, 436, 435, 191, 192, 446, 445
1403, 181, 31, 185, 436, 192, 36, 195, 446
1404, 171, 435, 437, 172, 193, 445, 447, 194
1405, 435, 436, 438, 437, 445, 446, 448, 447
1406, 436, 185, 186, 438, 446, 195, 196, 448
1407, 172, 437, 175, 25, 194, 447, 189, 33
1408, 437, 438, 176, 175, 447, 448, 190, 189
1409, 438, 186, 29, 176, 448, 196, 34, 190
*ELEMENT, type=C3D8, ELSET=Volume9
1410, 35, 191, 445, 193, 203, 453, 629, 457
1411, 203, 453, 629, 457, 204, 454, 630, 458
1412, 204, 454, 630, 458, 39, 207, 465, 209
1413, 191, 192, 446, 445, 453, 455, 631, 629
1414, 453, 455, 631, 629, 454, 456, 632, 630
1415, 454, 456, 632, 630, 207, 208, 466, 465
1416, 192, 36, 195, 446, 455, 205, 461, 631
1417, 455, 205, 461, 631, 456, 206, 462, 632
1418, 456, 206, 462, 632, 208, 40, 211, 466
1419, 193, 445, 447, 194, 457, 629, 633, 459
1420, 457, 629, 633, 459, 458, 630, 634, 460
1421, 458, 630, 634, 460, 209, 465, 467, 210
1422, 445, 446, 448, 447, 629, 631, 635, 633
1423, 629, 631, 635, 633, 630, 632, 636, 634
1424, 630, 632, 636, 634, 465, 466, 468, 467
1425, 446, 195, 196, 448, 631, 461, 463, 635
1426, 631, 461, 463, 635, 632, 462, 464, 636
1427, 632, 462, 464, 636, 466, 211, 212, 468
1428, 194, 447, 189, 33, 459, 633, 449, 197
1429, 459, 633, 449, 197, 460, 634, 450, 198
1430, 460, 634, 450, 198, 210, 467, 201, 37
1431, 447, 448, 190, 189, 633, 635, 451, 449
1432, 633, 635, 451, 449, 634, 636, 452, 450
1433, 634, 636, 452, 450, 467, 468, 202, 201
1434, 448, 196, 34, 190, 635, 463, 199, 451
1435, 635, 463, 199, 451, 636, 464, 200, 452
1436, 636, 464, 200, 452, 468, 212, 38, 202
*ELEMENT, type=C3D8, ELSET=Volume10
1437, 39, 207, 465, 209, 43, 215, 469, 217
1438, 207, 208, 466, 465, 215, 216, 470, 469
1439, 208, 40, 211, 466, 216, 44, 219, 470
1440, 209, 465, 467, 210, 217, 469, 471, 218
1441, 465, 466, 468, 467, 469, 470, 472, 471
1442, 466, 211, 212, 468, 470, 219, 220, 472
1443, 210, 467, 201, 37, 218, 471, 213, 41
1444, 467, 468, 202, 201, 471, 472, 214, 213
1445, 468, 212, 38, 202, 472, 220, 42, 214
*ELEMENT, type=C3D8, ELSET=Volume11
1446, 43, 215, 469, 217, 225, 475, 637, 477
1447, 225, 475, 637, 477, 47, 227, 481, 229
1448, 215, 216, 470, 469, 475, 476, 638, 637
1449, 475, 476, 638, 637, 227, 228, 482, 481
1450, 216, 44, 219, 470, 476, 226, 479, 638
1451, 476, 226, 479, 638, 228, 48, 231, 482
1452, 217, 469, 471, 218, 477, 637, 639, 478
1453, 477, 637, 639, 478, 229, 481, 483, 230
1454, 469, 470, 472, 471, 637, 638, 640, 639
1455, 637, 638, 640, 639, 481, 482, 484, 483
1456, 470, 219, 220, 472, 638, 479, 480, 640
1457, 638, 479, 480, 640, 482, 231, 232, 484
1458, 218, 471, 213, 41, 478, 639, 473, 221
1459, 478, 639, 473, 221, 230, 483, 223, 45
1460, 471, 472, 214, 213, 639, 640, 474, 473
1461, 639, 640, 474, 473, 483, 484, 224, 223
1462, 472, 220, 42, 214, 640, 480, 222, 474
1463, 640, 480, 222, 474, 484, 232, 46, 224
*ELEMENT, type=C3D8, ELSET=Volume12
1464, 44, 219, 479, 226, 51, 235, 485, 234
1465, 226, 479, 231, 48, 234, 485, 237, 52
1466, 219, 220, 480, 479, 235, 236, 486, 485
1467, 479, 480, 232, 231, 485, 486, 238, 237
1468, 220, 42, 222, 480, 236, 49, 233, 486
1469, 480, 222, 46, 232, 486, 233, 50, 238
*ELEMENT, type=C3D8, ELSET=Volume13
1470, 2, 97, 361, 102, 54, 239, 487, 244
1471, 102, 361, 100, 4, 244, 487, 242, 56
1472, 97, 98, 362, 361, 239, 240, 488, 487
1473, 361, 362, 101, 100, 487, 488, 243, 242
1474, 98, 1, 99, 362, 240, 53, 241, 488
1475, 362, 99, 3, 101, 488, 241, 55, 243
*ELEMENT, type=C3D8, ELSET=Volume14
1476, 10, 127, 381, 117, 67, 263, 497, 265
1477, 127, 128, 382, 381, 263, 264, 498, 497
1478, 128, 14, 129, 382, 264, 68, 267, 498
1479, 117, 381, 383, 118, 265, 497, 499, 266
1480, 381, 382, 384, 383, 497, 498, 500, 499
1481, 382, 129, 130, 384, 498, 267, 268, 500
1482, 118, 383, 125, 9, 266, 499, 261, 65
1483, 383, 384, 126, 125, 499, 500, 262, 261
1484, 384, 130, 13, 126, 500, 268, 66, 262
*ELEMENT, type=C3D8, ELSET=Volume15
1485, 35, 191, 453, 203, 69, 273, 501, 269
1486, 203, 453, 454, 204, 269, 501, 502, 270
1487, 204, 454, 207, 39, 270, 502, 275, 70
1488, 191, 192, 455, 453, 273, 274, 503, 501
1489, 453, 455, 456, 454, 501, 503, 504, 502
1490, 454, 456, 208, 207, 502, 504, 276, 275
1491, 192, 36, 205, 455, 274, 71, 271, 503
1492, 455, 205, 206, 456, 503, 271, 272, 504
1493, 456, 206, 40, 208, 504, 272, 72, 276
*ELEMENT, type=C3D8, ELSET=Volume16
1494, 9, 125, 385, 119, 59, 247, 489, 249
1495, 125, 126, 386, 385, 247, 248, 490, 489
1496, 126, 13, 133, 386, 248, 60, 251, 490
1497, 119, 385, 387, 120, 249, 489, 491, 250
1498, 385, 386, 388, 387, 489, 490, 492, 491
1499, 386, 133, 134, 388, 490, 251, 252, 492
1500, 120, 387, 131, 11, 250, 491, 245, 57
1501, 387, 388, 132, 131, 491, 492, 246, 245
1502, 388, 134, 15, 132, 492, 252, 58, 246
*ELEMENT, type=C3D8, ELSET=Volume17
1503, 35, 203, 457, 193, 63, 255, 493, 257
1504, 203, 204, 458, 457, 255, 256, 494, 493
1505, 204, 39, 209, 458, 256, 64, 259, 494
1506, 193, 457, 459, 194, 257, 493, 495, 258
1507, 457, 458, 460, 459, 493, 494, 496, 495
1508, 458, 209, 210, 460, 494, 259, 260, 496
1509, 194, 459, 197, 33, 258, 495, 253, 61
1510, 459, 460, 198, 197, 495, 496, 254, 253
1511, 460, 210, 37, 198, 496, 260, 62, 254
*ELEMENT, type=C3D8, ELSET=Volume18
1512, 35, 203, 255, 63, 69, 269, 277, 73
1513, 203, 204, 256, 255, 269, 270, 278, 277
1514, 204, 39, 64, 256, 270, 70, 74, 278
*ELEMENT, type=C3D8, ELSET=Volume19
1515, 9, 125, 247, 59, 65, 261, 279, 75
1516, 125, 126, 248, 247, 261, 262, 280, 279
1517, 126, 13, 60, 248, 262, 66, 76, 280
*ELEMENT, type=C3D8, ELSET=Volume20
1518, 22, 159, 413, 151, 283, 517, 641, 505
1519, 283, 517, 641, 505, 284, 518, 642, 506
1520, 284, 518, 642, 506, 78, 295, 521, 285
1521, 159, 160, 414, 413, 517, 519, 643, 641
1522, 517, 519, 643, 641, 518, 520, 644, 642
1523, 518, 520, 644, 642, 295, 296, 522, 521
1524, 160, 24, 157, 414, 519, 291, 513, 643
1525, 519, 291, 513, 643, 520, 292, 514, 644
1526, 520, 292, 514, 644, 296, 80, 293, 522
1527, 151, 413, 415, 152, 505, 641, 645, 507
1528, 505, 641, 645, 507, 506, 642, 646, 508
1529, 506, 642, 646, 508, 285, 521, 523, 286
1530, 413, 414, 416, 415, 641, 643, 647, 645
1531, 641, 643, 647, 645, 642, 644, 648, 646
1532, 642, 644, 648, 646, 521, 522, 524, 523
1533, 414, 157, 158, 416, 643, 513, 515, 647
1534, 643, 513, 515, 647, 644, 514, 516, 648
1535, 644, 514, 516, 648, 522, 293, 294, 524
1536, 152, 415, 154, 21, 507, 645, 509, 281
1537, 507, 645, 509, 281, 508, 646, 510, 282
1538, 508, 646, 510, 282, 286, 523, 289, 77
1539, 415, 416, 155, 154, 645, 647, 511, 509
1540, 645, 647, 511, 509, 646, 648, 512, 510
1541, 646, 648, 512, 510, 523, 524, 290, 289
1542, 416, 158, 23, 155, 647, 515, 287, 511
1543, 647, 515, 287, 511, 648, 516, 288, 512
1544, 648, 516, 288, 512, 524, 294, 79, 290
*ELEMENT, type=C3D8, ELSET=Volume21
1545, 21, 154, 425, 168, 281, 509, 649, 529
1546, 281, 509, 649, 529, 282, 510, 650, 530
1547, 282, 510, 650, 530, 77, 289, 537, 303
1548, 168, 425, 426, 169, 529, 649, 651, 531
1549, 529, 649, 651, 531, 530, 650, 652, 532
1550, 530, 650, 652, 532, 303, 537, 538, 304
1551, 169, 426, 173, 28, 531, 651, 533, 301
1552, 531, 651, 533, 301, 532, 652, 534, 302
1553, 532, 652, 534, 302, 304, 538, 305, 82
1554, 154, 155, 427, 425, 509, 511, 653, 649
1555, 509, 511, 653, 649, 510, 512, 654, 650
1556, 510, 512, 654, 650, 289, 290, 539, 537
1557, 425, 427, 428, 426, 649, 653, 655, 651
1558, 649, 653, 655, 651, 650, 654, 656, 652
1559, 650, 654, 656, 652, 537, 539, 540, 538
1560, 426, 428, 174, 173, 651, 655, 535, 533
1561, 651, 655, 535, 533, 652, 656, 536, 534
1562, 652, 656, 536, 534, 538, 540, 306, 305
1563, 155, 23, 163, 427, 511, 287, 525, 653
1564, 511, 287, 525, 653, 512, 288, 526, 654
1565, 512, 288, 526, 654, 290, 79, 299, 539
1566, 427, 163, 164, 428, 653, 525, 527, 655
1567, 653, 525, 527, 655, 654, 526, 528, 656
1568, 654, 526, 528, 656, 539, 299, 300, 540
1569, 428, 164, 26, 174, 655, 527, 297, 535
1570, 655, 527, 297, 535, 656, 528, 298, 536
1571, 656, 528, 298, 536, 540, 300, 81, 306
*ELEMENT, type=C3D8, ELSET=Volume22
1572, 28, 173, 439, 182, 301, 533, 657, 545
1573, 301, 533, 657, 545, 302, 534, 658, 546
1574, 302, 534, 658, 546, 82, 305, 553, 313
1575, 182, 439, 440, 183, 545, 657, 659, 547
1576, 545, 657, 659, 547, 546, 658, 660, 548
1577, 546, 658, 660, 548, 313, 553, 554, 314
1578, 183, 440, 187, 32, 547, 659, 549, 311
1579, 547, 659, 549, 311, 548, 660, 550, 312
1580, 548, 660, 550, 312, 314, 554, 315, 84
1581, 173, 174, 441, 439, 533, 535, 661, 657
1582, 533, 535, 661, 657, 534, 536, 662, 658
1583, 534, 536, 662, 658, 305, 306, 555, 553
1584, 439, 441, 442, 440, 657, 661, 663, 659
1585, 657, 661, 663, 659, 658, 662, 664, 660
1586, 658, 662, 664, 660, 553, 555, 556, 554
1587, 440, 442, 188, 187, 659, 663, 551, 549
1588, 659, 663, 551, 549, 660, 664, 552, 550
1589, 660, 664, 552, 550, 554, 556, 316, 315
1590, 174, 26, 177, 441, 535, 297, 541, 661
1591, 535, 297, 541, 661, 536, 298, 542, 662
1592, 536, 298, 542, 662, 306, 81, 309, 555
1593, 441, 177, 178, 442, 661, 541, 543, 663
1594, 661, 541, 543, 663, 662, 542, 544, 664
1595, 662, 542, 544, 664, 555, 309, 310, 556
1596, 442, 178, 30, 188, 663, 543, 307, 551
1597, 663, 543, 307, 551, 664, 544, 308, 552
1598, 664, 544, 308, 552, 556, 310, 83, 316
*ELEMENT, type=C3D8, ELSET=Volume23
1599, 2, 109, 365, 97, 319, 557, 665, 569
1600, 319, 557, 665, 569, 320, 558, 666, 570
1601, 320, 558, 666, 570, 86, 321, 573, 331
1602, 97, 365, 366, 98, 569, 665, 667, 571
1603, 569, 665, 667, 571, 570, 666, 668, 572
1604, 570, 666, 668, 572, 331, 573, 574, 332
1605, 98, 366, 111, 1, 571, 667, 565, 327
1606, 571, 667, 565, 327, 572, 668, 566, 328
1607, 572, 668, 566, 328, 332, 574, 329, 88
1608, 109, 110, 367, 365, 557, 559, 669, 665
1609, 557, 559, 669, 665, 558, 560, 670, 666
1610, 558, 560, 670, 666, 321, 322, 575, 573
1611, 365, 367, 368, 366, 665, 669, 671, 667
1612, 665, 669, 671, 667, 666, 670, 672, 668
1613, 666, 670, 672, 668, 573, 575, 576, 574
1614, 366, 368, 112, 111, 667, 671, 567, 565
1615, 667, 671, 567, 565, 668, 672, 568, 566
1616, 668, 672, 568, 566, 574, 576, 330, 329
1617, 110, 6, 103, 367, 559, 317, 561, 669
1618, 559, 317, 561, 669, 560, 318, 562, 670
1619, 560, 318, 562, 670, 322, 85, 325, 575
1620, 367, 103, 104, 368, 669, 561, 563, 671
1621, 669, 561, 563, 671, 670, 562, 564, 672
1622, 670, 562, 564, 672, 575, 325, 326, 576
1623, 368, 104, 5, 112, 671, 563, 323, 567
1624, 671, 563, 323, 567, 672, 564, 324, 568
1625, 672, 564, 324, 568, 576, 326, 87, 330
*ELEMENT, type=C3D8, ELSET=Volume24
1626, 2, 97, 239, 54, 319, 569, 577, 335
1627, 319, 569, 577, 335, 320, 570, 578, 336
1628, 320, 570, 578, 336, 86, 331, 337, 90
1629, 97, 98, 240, 239, 569, 571, 579, 577
1630, 569, 571, 579, 577, 570, 572, 580, 578
1631, 570, 572, 580, 578, 331, 332, 338, 337
1632, 98, 1, 53, 240, 571, 327, 333, 579
1633, 571, 327, 333, 579, 572, 328, 334, 580
1634, 572, 328, 334, 580, 332, 88, 89, 338
*ELEMENT, type=C3D8, ELSET=Volume25
1635, 47, 227, 481, 229, 345, 585, 673, 589
1636, 345, 585, 673, 589, 346, 586, 674, 590
1637, 346, 586, 674, 590, 93, 349, 597, 351
1638, 227, 228, 482, 481, 585, 587, 675, 673
1639, 585, 587, 675, 673, 586, 588, 676, 674
1640, 586, 588, 676, 674, 349, 350, 598, 597
1641, 228, 48, 231, 482, 587, 347, 593, 675
1642, 587, 347, 593, 675, 588, 348, 594, 676
1643, 588, 348, 594, 676, 350, 94, 353, 598
1644, 229, 481, 483, 230, 589, 673, 677, 591
1645, 589, 673, 677, 591, 590, 674, 678, 592
1646, 590, 674, 678, 592, 351, 597, 599, 352
1647, 481, 482, 484, 483, 673, 675, 679, 677
1648, 673, 675, 679, 677, 674, 676, 680, 678
1649, 674, 676, 680, 678, 597, 598, 600, 599
1650, 482, 231, 232, 484, 675, 593, 595, 679
1651, 675, 593, 595, 679, 676, 594, 596, 680
1652, 676, 594, 596, 680, 598, 353, 354, 600
1653, 230, 483, 223, 45, 591, 677, 581, 339
1654, 591, 677, 581, 339, 592, 678, 582, 340
1655, 592, 678, 582, 340, 352, 599, 343, 91
1656, 483, 484, 224, 223, 677, 679, 583, 581
1657, 677, 679, 583, 581, 678, 680, 584, 582
1658, 678, 680, 584, 582, 599, 600, 344, 343
1659, 484, 232, 46, 224, 679, 595, 341, 583
1660, 679, 595, 341, 583, 680, 596, 342, 584
1661, 680, 596, 342, 584, 600, 354, 92, 344
*ELEMENT, type=C3D8, ELSET=Volume26
1662, 48, 52, 237, 231, 347, 357, 601, 593
1663, 347, 357, 601, 593, 348, 358, 602, 594
1664, 348, 358, 602, 594, 94, 96, 359, 353
1665, 231, 237, 238, 232, 593, 601, 603, 595
1666, 593, 601, 603, 595, 594, 602, 604, 596
1667, 594, 602, 604, 596, 353, 359, 360, 354
1668, 232, 238, 50, 46, 595, 603, 355, 341
1669, 595, 603, 355, 341, 596, 604, 356, 342
1670, 596, 604, 356, 342, 354, 360, 95, 92
*ELSET,ELSET=Qin
708, 709, 710, 711, 712, 713, 714, 715, 716, 738, 
739, 740, 741, 742, 743, 744, 745, 746, 774, 775, 
776, 777, 778, 779, 780, 781, 782, 
*ELSET,ELSET=HeatSink
567, 568, 569, 570, 571, 572, 573, 574, 575, 900, 
901, 902, 903, 904, 905, 906, 907, 908, 
*ELSET,ELSET=ElectrodeMaxX
919, 920, 921, 922, 923, 924, 
*ELSET,ELSET=ElectrodeMinX
935, 936, 937, 938, 939, 940, 
*ELSET,ELSET=Force
702, 703, 704, 705, 706, 707, 
*ELSET,ELSET=Ceramic_Top
1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1113, 
1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1149, 1150, 
1151, 1152, 1153, 1154, 1155, 1156, 1157, 
*ELSET,ELSET=Ceramic_Bottom
1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1257, 1258, 
1259, 1260, 1261, 1262, 1263, 1264, 1265, 
*ELSET,ELSET=Top_Semiconductors
654, 655, 656, 657, 658, 659, 660, 661, 662, 801, 
802, 803, 804, 805, 806, 807, 808, 809, 
*ELSET,ELSET=Copper
1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 
1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 1347, 1348, 
1349, 1350, 1351, 1352, 1353, 1354, 1355, 1356, 1357, 1358, 
1359, 1360, 1361, 1362, 1363, 1364, 1365, 1366, 1367, 1368, 
1369, 1370, 1371, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 
1379, 1380, 1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 
1389, 1390, 1391, 1392, 1393, 1394, 1395, 1396, 1397, 1398, 
1399, 1400, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 
1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 
1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 
1474, 1475, 
*ELSET,ELSET=SemiconductorN-
1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 
1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 
1331, 1332, 1333, 1334, 1335, 1336, 1337, 1476, 1477, 1478, 
1479, 1480, 1481, 1482, 1483, 1484, 1494, 1495, 1496, 1497, 
1498, 1499, 1500, 1501, 1502, 1515, 1516, 1517, 
*ELSET,ELSET=SemiconductorP+
1410, 1411, 1412, 1413, 1414, 1415, 1416, 1417, 1418, 1419, 
1420, 1421, 1422, 1423, 1424, 1425, 1426, 1427, 1428, 1429, 
1430, 1431, 1432, 1433, 1434, 1435, 1436, 1485, 1486, 1487, 
1488, 1489, 1490, 1491, 1492, 1493, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 
*ELSET,ELSET=Solder
1302, 1303, 1304, 1305, 1306, 1307, 1308, 1309, 1310, 1338, 
1339, 1340, 1341, 1342, 1343, 1344, 1345, 1346, 1401, 1402, 
1403, 1404, 1405, 1406, 1407, 1408, 1409, 1437, 1438, 1439, 
1440, 1441, 1442, 1443, 1444, 1445, 
*ELSET,ELSET=Volume
1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 
1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 
1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 
1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 
1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 
1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 
1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 
1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 
1364, 1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 
1374, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 
1384, 1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 
1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 
1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 
1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 
1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 
1434, 1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 
1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 
1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 
1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 
1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 
1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 
1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 
1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 
1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 
1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 
1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 
1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 
1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 
1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 
1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 1583, 
1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 
1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 
1604, 1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 
1614, 1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 
1624, 1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 
1634, 1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 
1644, 1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 
1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 
1664, 1665, 1666, 1667, 1668, 1669, 1670, 
*ELSET,ELSET=TO
1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 
1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 
1331, 1332, 1333, 1334, 1335, 1336, 1337, 1410, 1411, 1412, 
1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 
1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 
1433, 1434, 1435, 1436, 1476, 1477, 1478, 1479, 1480, 1481, 
1482, 1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 
1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 
1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 
1512, 1513, 1514, 1515, 1516, 1517, 
*ELSET,ELSET=Ceramic
1518, 1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 1527, 
1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 1537, 
1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 1547, 
1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 1557, 
1558, 1559, 1560, 1561, 1562, 1563, 1564, 1565, 1566, 1567, 
1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 1577, 
1578, 1579, 1580, 1581, 1582, 1583, 1584, 1585, 1586, 1587, 
1588, 1589, 1590, 1591, 1592, 1593, 1594, 1595, 1596, 1597, 
1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 1607, 
1608, 1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617, 
1618, 1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 1627, 
1628, 1629, 1630, 1631, 1632, 1633, 1634, 1635, 1636, 1637, 
1638, 1639, 1640, 1641, 1642, 1643, 1644, 1645, 1646, 1647, 
1648, 1649, 1650, 1651, 1652, 1653, 1654, 1655, 1656, 1657, 
1658, 1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 
1668, 1669, 1670, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 151, 152, 
154, 155, 157, 158, 159, 160, 163, 164, 168, 169, 
173, 174, 177, 178, 182, 183, 187, 188, 413, 414, 
415, 416, 425, 426, 427, 428, 439, 440, 441, 442, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 97, 98, 
103, 104, 109, 110, 111, 112, 223, 224, 227, 228, 
229, 230, 231, 232, 365, 366, 367, 368, 481, 482, 
483, 484, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 233, 234, 235, 236, 237, 238, 
485, 486, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 239, 240, 241, 242, 243, 244, 
487, 488, 
*NSET,NSET=Force
18, 20, 22, 24, 147, 148, 150, 156, 159, 160, 
411, 412, 
*NSET,NSET=Ceramic_Top
77, 78, 79, 80, 81, 82, 83, 84, 285, 286, 
289, 290, 293, 294, 295, 296, 299, 300, 303, 304, 
305, 306, 309, 310, 313, 314, 315, 316, 521, 522, 
523, 524, 537, 538, 539, 540, 553, 554, 555, 556, 
*NSET,NSET=Ceramic_Bottom
23, 26, 79, 81, 85, 86, 87, 88, 91, 92, 
93, 94, 163, 164, 287, 288, 297, 298, 299, 300, 
321, 322, 325, 326, 329, 330, 331, 332, 343, 344, 
349, 350, 351, 352, 353, 354, 525, 526, 527, 528, 
573, 574, 575, 576, 597, 598, 599, 600, 
*NSET,NSET=Top_Semiconductors
13, 14, 15, 16, 33, 34, 35, 36, 129, 130, 
133, 134, 137, 138, 139, 140, 189, 190, 191, 192, 
193, 194, 195, 196, 397, 398, 399, 400, 445, 446, 
447, 448, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 401, 402, 403, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 
479, 480, 481, 482, 483, 484, 485, 486, 487, 488, 
605, 606, 607, 608, 617, 618, 619, 620, 621, 622, 
623, 624, 625, 626, 627, 628, 637, 638, 639, 640, 
*NSET,NSET=SemiconductorN-
9, 10, 11, 12, 13, 14, 15, 16, 57, 58, 
59, 60, 65, 66, 67, 68, 75, 76, 117, 118, 
119, 120, 121, 122, 123, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 245, 246, 247, 248, 249, 250, 251, 252, 
261, 262, 263, 264, 265, 266, 267, 268, 279, 280, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 489, 490, 491, 492, 497, 498, 
499, 500, 609, 610, 611, 612, 613, 614, 615, 616, 
*NSET,NSET=SemiconductorP+
33, 34, 35, 36, 37, 38, 39, 40, 61, 62, 
63, 64, 69, 70, 71, 72, 73, 74, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 253, 254, 255, 256, 257, 258, 259, 260, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 493, 494, 495, 496, 501, 502, 
503, 504, 629, 630, 631, 632, 633, 634, 635, 636, 
*NSET,NSET=Solder
3, 4, 7, 8, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 25, 27, 29, 31, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 100, 101, 106, 107, 113, 114, 115, 116, 
117, 118, 119, 120, 121, 122, 123, 124, 129, 130, 
133, 134, 137, 138, 139, 140, 141, 142, 143, 144, 
145, 146, 147, 148, 171, 172, 175, 176, 180, 181, 
185, 186, 189, 190, 191, 192, 193, 194, 195, 196, 
201, 202, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 369, 370, 371, 372, 
377, 378, 379, 380, 397, 398, 399, 400, 401, 402, 
403, 404, 435, 436, 437, 438, 445, 446, 447, 448, 
465, 466, 467, 468, 469, 470, 471, 472, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 592, 593, 594, 595, 596, 597, 598, 599, 600, 
601, 602, 603, 604, 605, 606, 607, 608, 609, 610, 
611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 
621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 
631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
*NSET,NSET=TO
9, 10, 11, 12, 13, 14, 15, 16, 33, 34, 
35, 36, 37, 38, 39, 40, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
189, 190, 191, 192, 193, 194, 195, 196, 197, 198, 
199, 200, 201, 202, 203, 204, 205, 206, 207, 208, 
209, 210, 211, 212, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 609, 610, 611, 612, 613, 614, 
615, 616, 629, 630, 631, 632, 633, 634, 635, 636, 
*NSET,NSET=Ceramic
1, 2, 5, 6, 21, 22, 23, 24, 26, 28, 
30, 32, 45, 46, 47, 48, 50, 52, 53, 54, 
77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 
87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 
97, 98, 103, 104, 109, 110, 111, 112, 151, 152, 
154, 155, 157, 158, 159, 160, 163, 164, 168, 169, 
173, 174, 177, 178, 182, 183, 187, 188, 223, 224, 
227, 228, 229, 230, 231, 232, 237, 238, 239, 240, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
365, 366, 367, 368, 413, 414, 415, 416, 425, 426, 
427, 428, 439, 440, 441, 442, 481, 482, 483, 484, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
