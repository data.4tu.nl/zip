*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_5x5x5el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.1, 0.5
4, 0, 0.1, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.1, 0.5
8, 1, 0.1, 0
9, 1, 0.15, 0
10, 0, 0.15, 0
11, 1, 0.15, 0.5
12, 0, 0.15, 0.5
13, 1, 1.35, 0
14, 0, 1.35, 0
15, 1, 1.35, 0.5
16, 0, 1.35, 0.5
17, 1, 1.4, 0
18, 0, 1.4, 0
19, 1, 1.4, 0.5
20, 0, 1.4, 0.5
21, 1, 1.5, 0
22, 0, 1.5, 0
23, 1, 1.5, 0.5
24, 0, 1.5, 0.5
25, 1.2, 1.4, 0.5
26, 1.2, 1.5, 0.5
27, 1.2, 1.4, 0
28, 1.2, 1.5, 0
29, 2.2, 1.4, 0.5
30, 2.2, 1.5, 0.5
31, 2.2, 1.4, 0
32, 2.2, 1.5, 0
33, 1.2, 1.35, 0.5
34, 2.2, 1.35, 0.5
35, 1.2, 1.35, 0
36, 2.2, 1.35, 0
37, 1.2, 0.15, 0.5
38, 2.2, 0.15, 0.5
39, 1.2, 0.15, 0
40, 2.2, 0.15, 0
41, 1.2, 0.1, 0.5
42, 2.2, 0.1, 0.5
43, 1.2, 0.1, 0
44, 2.2, 0.1, 0
45, 1.2, -1.2490009027033e-16, 0.5
46, 2.2, -1.2490009027033e-16, 0.5
47, 1.2, -1.2490009027033e-16, 0
48, 2.2, -1.2490009027033e-16, 0
49, 2.3, 0.1, 0.5
50, 2.3, -1.2490009027033e-16, 0.5
51, 2.3, 0.1, 0
52, 2.3, -1.2490009027033e-16, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.1, 0.5
56, -0.1, 0.1, 0
57, 1.05, 0.15, 0.5
58, 1.05, 1.35, 0.5
59, 1.05, 0.15, 0
60, 1.05, 1.35, 0
61, 1.15, 1.35, 0.5
62, 1.15, 0.15, 0.5
63, 1.15, 1.35, 0
64, 1.15, 0.15, 0
65, 1, 0.15, -0.1
66, 1, 1.35, -0.1
67, 0, 0.15, -0.1
68, 0, 1.35, -0.1
69, 1.2, 1.35, -0.1
70, 1.2, 0.15, -0.1
71, 2.2, 1.35, -0.1
72, 2.2, 0.15, -0.1
73, 1.15, 1.35, -0.1
74, 1.15, 0.15, -0.1
75, 1.05, 0.15, -0.1
76, 1.05, 1.35, -0.1
77, 1, 1.7, 0
78, 0, 1.7, 0
79, 1, 1.7, 0.5
80, 0, 1.7, 0.5
81, 1.2, 1.7, 0.5
82, 1.2, 1.7, 0
83, 2.2, 1.7, 0.5
84, 2.2, 1.7, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.1
98, 0, 0, 0.2
99, 0, 0, 0.3
100, 0, 0, 0.4
101, 0, 0.033333333333333, 0.5
102, 0, 0.066666666666667, 0.5
103, 0, 0.1, 0.1
104, 0, 0.1, 0.2
105, 0, 0.1, 0.3
106, 0, 0.1, 0.4
107, 0, 0.033333333333333, 0
108, 0, 0.066666666666667, 0
109, 1, 0, 0.1
110, 1, 0, 0.2
111, 1, 0, 0.3
112, 1, 0, 0.4
113, 1, 0.033333333333333, 0.5
114, 1, 0.066666666666667, 0.5
115, 1, 0.1, 0.1
116, 1, 0.1, 0.2
117, 1, 0.1, 0.3
118, 1, 0.1, 0.4
119, 1, 0.033333333333333, 0
120, 1, 0.066666666666667, 0
121, 0.2, 0, 0
122, 0.4, 0, 0
123, 0.6, 0, 0
124, 0.8, 0, 0
125, 0.2, 0, 0.5
126, 0.4, 0, 0.5
127, 0.6, 0, 0.5
128, 0.8, 0, 0.5
129, 0.2, 0.1, 0
130, 0.4, 0.1, 0
131, 0.6, 0.1, 0
132, 0.8, 0.1, 0
133, 0.2, 0.1, 0.5
134, 0.4, 0.1, 0.5
135, 0.6, 0.1, 0.5
136, 0.8, 0.1, 0.5
137, 0.2, 0.15, 0
138, 0.4, 0.15, 0
139, 0.6, 0.15, 0
140, 0.8, 0.15, 0
141, 1, 0.15, 0.1
142, 1, 0.15, 0.2
143, 1, 0.15, 0.3
144, 1, 0.15, 0.4
145, 0.2, 0.15, 0.5
146, 0.4, 0.15, 0.5
147, 0.6, 0.15, 0.5
148, 0.8, 0.15, 0.5
149, 0, 0.15, 0.1
150, 0, 0.15, 0.2
151, 0, 0.15, 0.3
152, 0, 0.15, 0.4
153, 1, 0.39, 0
154, 1, 0.63, 0
155, 1, 0.87, 0
156, 1, 1.11, 0
157, 0, 0.39, 0
158, 0, 0.63, 0
159, 0, 0.87, 0
160, 0, 1.11, 0
161, 0.2, 1.35, 0
162, 0.4, 1.35, 0
163, 0.6, 1.35, 0
164, 0.8, 1.35, 0
165, 1, 0.39, 0.5
166, 1, 0.63, 0.5
167, 1, 0.87, 0.5
168, 1, 1.11, 0.5
169, 1, 1.35, 0.1
170, 1, 1.35, 0.2
171, 1, 1.35, 0.3
172, 1, 1.35, 0.4
173, 0, 0.39, 0.5
174, 0, 0.63, 0.5
175, 0, 0.87, 0.5
176, 0, 1.11, 0.5
177, 0.2, 1.35, 0.5
178, 0.4, 1.35, 0.5
179, 0.6, 1.35, 0.5
180, 0.8, 1.35, 0.5
181, 0, 1.35, 0.1
182, 0, 1.35, 0.2
183, 0, 1.35, 0.3
184, 0, 1.35, 0.4
185, 0.2, 1.4, 0
186, 0.4, 1.4, 0
187, 0.6, 1.4, 0
188, 0.8, 1.4, 0
189, 1, 1.4, 0.1
190, 1, 1.4, 0.2
191, 1, 1.4, 0.3
192, 1, 1.4, 0.4
193, 0.2, 1.4, 0.5
194, 0.4, 1.4, 0.5
195, 0.6, 1.4, 0.5
196, 0.8, 1.4, 0.5
197, 0, 1.4, 0.1
198, 0, 1.4, 0.2
199, 0, 1.4, 0.3
200, 0, 1.4, 0.4
201, 1, 1.4333333333333, 0
202, 1, 1.4666666666667, 0
203, 0, 1.4333333333333, 0
204, 0, 1.4666666666667, 0
205, 0.2, 1.5, 0
206, 0.4, 1.5, 0
207, 0.6, 1.5, 0
208, 0.8, 1.5, 0
209, 1, 1.4333333333333, 0.5
210, 1, 1.4666666666667, 0.5
211, 1, 1.5, 0.1
212, 1, 1.5, 0.2
213, 1, 1.5, 0.3
214, 1, 1.5, 0.4
215, 0, 1.4333333333333, 0.5
216, 0, 1.4666666666667, 0.5
217, 0.2, 1.5, 0.5
218, 0.4, 1.5, 0.5
219, 0.6, 1.5, 0.5
220, 0.8, 1.5, 0.5
221, 0, 1.5, 0.1
222, 0, 1.5, 0.2
223, 0, 1.5, 0.3
224, 0, 1.5, 0.4
225, 1.04, 1.4, 0.5
226, 1.08, 1.4, 0.5
227, 1.12, 1.4, 0.5
228, 1.16, 1.4, 0.5
229, 1.04, 1.5, 0.5
230, 1.08, 1.5, 0.5
231, 1.12, 1.5, 0.5
232, 1.16, 1.5, 0.5
233, 1.2, 1.4333333333333, 0.5
234, 1.2, 1.4666666666667, 0.5
235, 1.04, 1.4, 0
236, 1.08, 1.4, 0
237, 1.12, 1.4, 0
238, 1.16, 1.4, 0
239, 1.04, 1.5, 0
240, 1.08, 1.5, 0
241, 1.12, 1.5, 0
242, 1.16, 1.5, 0
243, 1.2, 1.4333333333333, 0
244, 1.2, 1.4666666666667, 0
245, 1.2, 1.4, 0.1
246, 1.2, 1.4, 0.2
247, 1.2, 1.4, 0.3
248, 1.2, 1.4, 0.4
249, 1.2, 1.5, 0.1
250, 1.2, 1.5, 0.2
251, 1.2, 1.5, 0.3
252, 1.2, 1.5, 0.4
253, 1.4, 1.4, 0.5
254, 1.6, 1.4, 0.5
255, 1.8, 1.4, 0.5
256, 2, 1.4, 0.5
257, 1.4, 1.5, 0.5
258, 1.6, 1.5, 0.5
259, 1.8, 1.5, 0.5
260, 2, 1.5, 0.5
261, 2.2, 1.4333333333333, 0.5
262, 2.2, 1.4666666666667, 0.5
263, 1.4, 1.4, 0
264, 1.6, 1.4, 0
265, 1.8, 1.4, 0
266, 2, 1.4, 0
267, 1.4, 1.5, 0
268, 1.6, 1.5, 0
269, 1.8, 1.5, 0
270, 2, 1.5, 0
271, 2.2, 1.4333333333333, 0
272, 2.2, 1.4666666666667, 0
273, 2.2, 1.4, 0.1
274, 2.2, 1.4, 0.2
275, 2.2, 1.4, 0.3
276, 2.2, 1.4, 0.4
277, 2.2, 1.5, 0.1
278, 2.2, 1.5, 0.2
279, 2.2, 1.5, 0.3
280, 2.2, 1.5, 0.4
281, 1.4, 1.35, 0.5
282, 1.6, 1.35, 0.5
283, 1.8, 1.35, 0.5
284, 2, 1.35, 0.5
285, 1.4, 1.35, 0
286, 1.6, 1.35, 0
287, 1.8, 1.35, 0
288, 2, 1.35, 0
289, 1.2, 1.35, 0.1
290, 1.2, 1.35, 0.2
291, 1.2, 1.35, 0.3
292, 1.2, 1.35, 0.4
293, 2.2, 1.35, 0.1
294, 2.2, 1.35, 0.2
295, 2.2, 1.35, 0.3
296, 2.2, 1.35, 0.4
297, 1.2, 1.11, 0.5
298, 1.2, 0.87, 0.5
299, 1.2, 0.63, 0.5
300, 1.2, 0.39, 0.5
301, 2.2, 1.11, 0.5
302, 2.2, 0.87, 0.5
303, 2.2, 0.63, 0.5
304, 2.2, 0.39, 0.5
305, 1.4, 0.15, 0.5
306, 1.6, 0.15, 0.5
307, 1.8, 0.15, 0.5
308, 2, 0.15, 0.5
309, 1.2, 1.11, 0
310, 1.2, 0.87, 0
311, 1.2, 0.63, 0
312, 1.2, 0.39, 0
313, 2.2, 1.11, 0
314, 2.2, 0.87, 0
315, 2.2, 0.63, 0
316, 2.2, 0.39, 0
317, 1.4, 0.15, 0
318, 1.6, 0.15, 0
319, 1.8, 0.15, 0
320, 2, 0.15, 0
321, 1.2, 0.15, 0.1
322, 1.2, 0.15, 0.2
323, 1.2, 0.15, 0.3
324, 1.2, 0.15, 0.4
325, 2.2, 0.15, 0.1
326, 2.2, 0.15, 0.2
327, 2.2, 0.15, 0.3
328, 2.2, 0.15, 0.4
329, 1.4, 0.1, 0.5
330, 1.6, 0.1, 0.5
331, 1.8, 0.1, 0.5
332, 2, 0.1, 0.5
333, 1.4, 0.1, 0
334, 1.6, 0.1, 0
335, 1.8, 0.1, 0
336, 2, 0.1, 0
337, 1.2, 0.1, 0.1
338, 1.2, 0.1, 0.2
339, 1.2, 0.1, 0.3
340, 1.2, 0.1, 0.4
341, 2.2, 0.1, 0.1
342, 2.2, 0.1, 0.2
343, 2.2, 0.1, 0.3
344, 2.2, 0.1, 0.4
345, 1.2, 0.066666666666667, 0.5
346, 1.2, 0.033333333333333, 0.5
347, 2.2, 0.066666666666667, 0.5
348, 2.2, 0.033333333333333, 0.5
349, 1.4, 1.2490009027033e-16, 0.5
350, 1.6, 1.2490009027033e-16, 0.5
351, 1.8, 1.2490009027033e-16, 0.5
352, 2, 1.2490009027033e-16, 0.5
353, 1.2, 0.066666666666667, 0
354, 1.2, 0.033333333333333, 0
355, 2.2, 0.066666666666667, 0
356, 2.2, 0.033333333333333, 0
357, 1.4, 1.2490009027033e-16, 0
358, 1.6, 1.2490009027033e-16, 0
359, 1.8, 1.2490009027033e-16, 0
360, 2, 1.2490009027033e-16, 0
361, 1.2, 1.2490009027033e-16, 0.1
362, 1.2, 1.2490009027033e-16, 0.2
363, 1.2, 1.2490009027033e-16, 0.3
364, 1.2, 1.2490009027033e-16, 0.4
365, 2.2, 1.2490009027033e-16, 0.1
366, 2.2, 1.2490009027033e-16, 0.2
367, 2.2, 1.2490009027033e-16, 0.3
368, 2.2, 1.2490009027033e-16, 0.4
369, 2.3, 0.066666666666667, 0.5
370, 2.3, 0.033333333333333, 0.5
371, 2.3, 0.066666666666667, 0
372, 2.3, 0.033333333333333, 0
373, 2.3, 0.1, 0.1
374, 2.3, 0.1, 0.2
375, 2.3, 0.1, 0.3
376, 2.3, 0.1, 0.4
377, 2.3, 1.2490009027033e-16, 0.1
378, 2.3, 1.2490009027033e-16, 0.2
379, 2.3, 1.2490009027033e-16, 0.3
380, 2.3, 1.2490009027033e-16, 0.4
381, -0.1, 0, 0.1
382, -0.1, 0, 0.2
383, -0.1, 0, 0.3
384, -0.1, 0, 0.4
385, -0.1, 0.033333333333333, 0.5
386, -0.1, 0.066666666666667, 0.5
387, -0.1, 0.1, 0.1
388, -0.1, 0.1, 0.2
389, -0.1, 0.1, 0.3
390, -0.1, 0.1, 0.4
391, -0.1, 0.033333333333333, 0
392, -0.1, 0.066666666666667, 0
393, 1.05, 0.39, 0.5
394, 1.05, 0.63, 0.5
395, 1.05, 0.87, 0.5
396, 1.05, 1.11, 0.5
397, 1.05, 0.39, 0
398, 1.05, 0.63, 0
399, 1.05, 0.87, 0
400, 1.05, 1.11, 0
401, 1.05, 0.15, 0.1
402, 1.05, 0.15, 0.2
403, 1.05, 0.15, 0.3
404, 1.05, 0.15, 0.4
405, 1.05, 1.35, 0.1
406, 1.05, 1.35, 0.2
407, 1.05, 1.35, 0.3
408, 1.05, 1.35, 0.4
409, 1.15, 1.11, 0.5
410, 1.15, 0.87, 0.5
411, 1.15, 0.63, 0.5
412, 1.15, 0.39, 0.5
413, 1.15, 1.11, 0
414, 1.15, 0.87, 0
415, 1.15, 0.63, 0
416, 1.15, 0.39, 0
417, 1.15, 1.35, 0.1
418, 1.15, 1.35, 0.2
419, 1.15, 1.35, 0.3
420, 1.15, 1.35, 0.4
421, 1.15, 0.15, 0.1
422, 1.15, 0.15, 0.2
423, 1.15, 0.15, 0.3
424, 1.15, 0.15, 0.4
425, 1, 0.39, -0.1
426, 1, 0.63, -0.1
427, 1, 0.87, -0.1
428, 1, 1.11, -0.1
429, 0, 0.39, -0.1
430, 0, 0.63, -0.1
431, 0, 0.87, -0.1
432, 0, 1.11, -0.1
433, 0.2, 0.15, -0.1
434, 0.4, 0.15, -0.1
435, 0.6, 0.15, -0.1
436, 0.8, 0.15, -0.1
437, 0.2, 1.35, -0.1
438, 0.4, 1.35, -0.1
439, 0.6, 1.35, -0.1
440, 0.8, 1.35, -0.1
441, 1.2, 1.11, -0.1
442, 1.2, 0.87, -0.1
443, 1.2, 0.63, -0.1
444, 1.2, 0.39, -0.1
445, 2.2, 1.11, -0.1
446, 2.2, 0.87, -0.1
447, 2.2, 0.63, -0.1
448, 2.2, 0.39, -0.1
449, 1.4, 1.35, -0.1
450, 1.6, 1.35, -0.1
451, 1.8, 1.35, -0.1
452, 2, 1.35, -0.1
453, 1.4, 0.15, -0.1
454, 1.6, 0.15, -0.1
455, 1.8, 0.15, -0.1
456, 2, 0.15, -0.1
457, 1.15, 1.11, -0.1
458, 1.15, 0.87, -0.1
459, 1.15, 0.63, -0.1
460, 1.15, 0.39, -0.1
461, 1.05, 0.39, -0.1
462, 1.05, 0.63, -0.1
463, 1.05, 0.87, -0.1
464, 1.05, 1.11, -0.1
465, 1, 1.54, 0
466, 1, 1.58, 0
467, 1, 1.62, 0
468, 1, 1.66, 0
469, 0, 1.54, 0
470, 0, 1.58, 0
471, 0, 1.62, 0
472, 0, 1.66, 0
473, 0.2, 1.7, 0
474, 0.4, 1.7, 0
475, 0.6, 1.7, 0
476, 0.8, 1.7, 0
477, 1, 1.54, 0.5
478, 1, 1.58, 0.5
479, 1, 1.62, 0.5
480, 1, 1.66, 0.5
481, 1, 1.7, 0.1
482, 1, 1.7, 0.2
483, 1, 1.7, 0.3
484, 1, 1.7, 0.4
485, 0, 1.54, 0.5
486, 0, 1.58, 0.5
487, 0, 1.62, 0.5
488, 0, 1.66, 0.5
489, 0.2, 1.7, 0.5
490, 0.4, 1.7, 0.5
491, 0.6, 1.7, 0.5
492, 0.8, 1.7, 0.5
493, 0, 1.7, 0.1
494, 0, 1.7, 0.2
495, 0, 1.7, 0.3
496, 0, 1.7, 0.4
497, 1.2, 1.54, 0.5
498, 1.2, 1.58, 0.5
499, 1.2, 1.62, 0.5
500, 1.2, 1.66, 0.5
501, 1.04, 1.7, 0.5
502, 1.08, 1.7, 0.5
503, 1.12, 1.7, 0.5
504, 1.16, 1.7, 0.5
505, 1.2, 1.54, 0
506, 1.2, 1.58, 0
507, 1.2, 1.62, 0
508, 1.2, 1.66, 0
509, 1.04, 1.7, 0
510, 1.08, 1.7, 0
511, 1.12, 1.7, 0
512, 1.16, 1.7, 0
513, 1.2, 1.7, 0.1
514, 1.2, 1.7, 0.2
515, 1.2, 1.7, 0.3
516, 1.2, 1.7, 0.4
517, 2.2, 1.54, 0.5
518, 2.2, 1.58, 0.5
519, 2.2, 1.62, 0.5
520, 2.2, 1.66, 0.5
521, 1.4, 1.7, 0.5
522, 1.6, 1.7, 0.5
523, 1.8, 1.7, 0.5
524, 2, 1.7, 0.5
525, 2.2, 1.54, 0
526, 2.2, 1.58, 0
527, 2.2, 1.62, 0
528, 2.2, 1.66, 0
529, 1.4, 1.7, 0
530, 1.6, 1.7, 0
531, 1.8, 1.7, 0
532, 2, 1.7, 0
533, 2.2, 1.7, 0.1
534, 2.2, 1.7, 0.2
535, 2.2, 1.7, 0.3
536, 2.2, 1.7, 0.4
537, 1, -0.04, 0
538, 1, -0.08, 0
539, 1, -0.12, 0
540, 1, -0.16, 0
541, 0, -0.04, 0
542, 0, -0.08, 0
543, 0, -0.12, 0
544, 0, -0.16, 0
545, 0.2, -0.2, 0
546, 0.4, -0.2, 0
547, 0.6, -0.2, 0
548, 0.8, -0.2, 0
549, 1, -0.04, 0.5
550, 1, -0.08, 0.5
551, 1, -0.12, 0.5
552, 1, -0.16, 0.5
553, 1, -0.2, 0.1
554, 1, -0.2, 0.2
555, 1, -0.2, 0.3
556, 1, -0.2, 0.4
557, 0, -0.04, 0.5
558, 0, -0.08, 0.5
559, 0, -0.12, 0.5
560, 0, -0.16, 0.5
561, 0.2, -0.2, 0.5
562, 0.4, -0.2, 0.5
563, 0.6, -0.2, 0.5
564, 0.8, -0.2, 0.5
565, 0, -0.2, 0.1
566, 0, -0.2, 0.2
567, 0, -0.2, 0.3
568, 0, -0.2, 0.4
569, -0.1, -0.04, 0.5
570, -0.1, -0.08, 0.5
571, -0.1, -0.12, 0.5
572, -0.1, -0.16, 0.5
573, -0.1, -0.04, 0
574, -0.1, -0.08, 0
575, -0.1, -0.12, 0
576, -0.1, -0.16, 0
577, -0.1, -0.2, 0.1
578, -0.1, -0.2, 0.2
579, -0.1, -0.2, 0.3
580, -0.1, -0.2, 0.4
581, 1.2, -0.04, 0.5
582, 1.2, -0.08, 0.5
583, 1.2, -0.12, 0.5
584, 1.2, -0.16, 0.5
585, 2.2, -0.04, 0.5
586, 2.2, -0.08, 0.5
587, 2.2, -0.12, 0.5
588, 2.2, -0.16, 0.5
589, 1.4, -0.2, 0.5
590, 1.6, -0.2, 0.5
591, 1.8, -0.2, 0.5
592, 2, -0.2, 0.5
593, 1.2, -0.04, 0
594, 1.2, -0.08, 0
595, 1.2, -0.12, 0
596, 1.2, -0.16, 0
597, 2.2, -0.04, 0
598, 2.2, -0.08, 0
599, 2.2, -0.12, 0
600, 2.2, -0.16, 0
601, 1.4, -0.2, 0
602, 1.6, -0.2, 0
603, 1.8, -0.2, 0
604, 2, -0.2, 0
605, 1.2, -0.2, 0.1
606, 1.2, -0.2, 0.2
607, 1.2, -0.2, 0.3
608, 1.2, -0.2, 0.4
609, 2.2, -0.2, 0.1
610, 2.2, -0.2, 0.2
611, 2.2, -0.2, 0.3
612, 2.2, -0.2, 0.4
613, 2.3, -0.04, 0.5
614, 2.3, -0.08, 0.5
615, 2.3, -0.12, 0.5
616, 2.3, -0.16, 0.5
617, 2.3, -0.04, 0
618, 2.3, -0.08, 0
619, 2.3, -0.12, 0
620, 2.3, -0.16, 0
621, 2.3, -0.2, 0.1
622, 2.3, -0.2, 0.2
623, 2.3, -0.2, 0.3
624, 2.3, -0.2, 0.4
625, 0, 0.033333333333333, 0.1
626, 0, 0.066666666666667, 0.1
627, 0, 0.033333333333333, 0.2
628, 0, 0.066666666666667, 0.2
629, 0, 0.033333333333333, 0.3
630, 0, 0.066666666666667, 0.3
631, 0, 0.033333333333333, 0.4
632, 0, 0.066666666666667, 0.4
633, 1, 0.033333333333333, 0.1
634, 1, 0.066666666666667, 0.1
635, 1, 0.033333333333333, 0.2
636, 1, 0.066666666666667, 0.2
637, 1, 0.033333333333333, 0.3
638, 1, 0.066666666666667, 0.3
639, 1, 0.033333333333333, 0.4
640, 1, 0.066666666666667, 0.4
641, 0.2, 0, 0.1
642, 0.2, 0, 0.2
643, 0.2, 0, 0.3
644, 0.2, 0, 0.4
645, 0.4, 0, 0.1
646, 0.4, 0, 0.2
647, 0.4, 0, 0.3
648, 0.4, 0, 0.4
649, 0.6, 0, 0.1
650, 0.6, 0, 0.2
651, 0.6, 0, 0.3
652, 0.6, 0, 0.4
653, 0.8, 0, 0.1
654, 0.8, 0, 0.2
655, 0.8, 0, 0.3
656, 0.8, 0, 0.4
657, 0.2, 0.1, 0.1
658, 0.2, 0.1, 0.2
659, 0.2, 0.1, 0.3
660, 0.2, 0.1, 0.4
661, 0.4, 0.1, 0.1
662, 0.4, 0.1, 0.2
663, 0.4, 0.1, 0.3
664, 0.4, 0.1, 0.4
665, 0.6, 0.1, 0.1
666, 0.6, 0.1, 0.2
667, 0.6, 0.1, 0.3
668, 0.6, 0.1, 0.4
669, 0.8, 0.1, 0.1
670, 0.8, 0.1, 0.2
671, 0.8, 0.1, 0.3
672, 0.8, 0.1, 0.4
673, 0.2, 0.033333333333333, 0
674, 0.4, 0.033333333333333, 0
675, 0.6, 0.033333333333333, 0
676, 0.8, 0.033333333333333, 0
677, 0.2, 0.066666666666667, 0
678, 0.4, 0.066666666666667, 0
679, 0.6, 0.066666666666667, 0
680, 0.8, 0.066666666666667, 0
681, 0.2, 0.033333333333333, 0.5
682, 0.4, 0.033333333333333, 0.5
683, 0.6, 0.033333333333333, 0.5
684, 0.8, 0.033333333333333, 0.5
685, 0.2, 0.066666666666667, 0.5
686, 0.4, 0.066666666666667, 0.5
687, 0.6, 0.066666666666667, 0.5
688, 0.8, 0.066666666666667, 0.5
689, 0.2, 0.15, 0.1
690, 0.2, 0.15, 0.2
691, 0.2, 0.15, 0.3
692, 0.2, 0.15, 0.4
693, 0.4, 0.15, 0.1
694, 0.4, 0.15, 0.2
695, 0.4, 0.15, 0.3
696, 0.4, 0.15, 0.4
697, 0.6, 0.15, 0.1
698, 0.6, 0.15, 0.2
699, 0.6, 0.15, 0.3
700, 0.6, 0.15, 0.4
701, 0.8, 0.15, 0.1
702, 0.8, 0.15, 0.2
703, 0.8, 0.15, 0.3
704, 0.8, 0.15, 0.4
705, 0.2, 0.39, 0
706, 0.2, 0.63, 0
707, 0.2, 0.87, 0
708, 0.2, 1.11, 0
709, 0.4, 0.39, 0
710, 0.4, 0.63, 0
711, 0.4, 0.87, 0
712, 0.4, 1.11, 0
713, 0.6, 0.39, 0
714, 0.6, 0.63, 0
715, 0.6, 0.87, 0
716, 0.6, 1.11, 0
717, 0.8, 0.39, 0
718, 0.8, 0.63, 0
719, 0.8, 0.87, 0
720, 0.8, 1.11, 0
721, 1, 0.39, 0.1
722, 1, 0.63, 0.1
723, 1, 0.87, 0.1
724, 1, 1.11, 0.1
725, 1, 0.39, 0.2
726, 1, 0.63, 0.2
727, 1, 0.87, 0.2
728, 1, 1.11, 0.2
729, 1, 0.39, 0.3
730, 1, 0.63, 0.3
731, 1, 0.87, 0.3
732, 1, 1.11, 0.3
733, 1, 0.39, 0.4
734, 1, 0.63, 0.4
735, 1, 0.87, 0.4
736, 1, 1.11, 0.4
737, 0.2, 0.39, 0.5
738, 0.2, 0.63, 0.5
739, 0.2, 0.87, 0.5
740, 0.2, 1.11, 0.5
741, 0.4, 0.39, 0.5
742, 0.4, 0.63, 0.5
743, 0.4, 0.87, 0.5
744, 0.4, 1.11, 0.5
745, 0.6, 0.39, 0.5
746, 0.6, 0.63, 0.5
747, 0.6, 0.87, 0.5
748, 0.6, 1.11, 0.5
749, 0.8, 0.39, 0.5
750, 0.8, 0.63, 0.5
751, 0.8, 0.87, 0.5
752, 0.8, 1.11, 0.5
753, 0, 0.39, 0.1
754, 0, 0.63, 0.1
755, 0, 0.87, 0.1
756, 0, 1.11, 0.1
757, 0, 0.39, 0.2
758, 0, 0.63, 0.2
759, 0, 0.87, 0.2
760, 0, 1.11, 0.2
761, 0, 0.39, 0.3
762, 0, 0.63, 0.3
763, 0, 0.87, 0.3
764, 0, 1.11, 0.3
765, 0, 0.39, 0.4
766, 0, 0.63, 0.4
767, 0, 0.87, 0.4
768, 0, 1.11, 0.4
769, 0.2, 1.35, 0.1
770, 0.2, 1.35, 0.2
771, 0.2, 1.35, 0.3
772, 0.2, 1.35, 0.4
773, 0.4, 1.35, 0.1
774, 0.4, 1.35, 0.2
775, 0.4, 1.35, 0.3
776, 0.4, 1.35, 0.4
777, 0.6, 1.35, 0.1
778, 0.6, 1.35, 0.2
779, 0.6, 1.35, 0.3
780, 0.6, 1.35, 0.4
781, 0.8, 1.35, 0.1
782, 0.8, 1.35, 0.2
783, 0.8, 1.35, 0.3
784, 0.8, 1.35, 0.4
785, 0.2, 1.4, 0.1
786, 0.2, 1.4, 0.2
787, 0.2, 1.4, 0.3
788, 0.2, 1.4, 0.4
789, 0.4, 1.4, 0.1
790, 0.4, 1.4, 0.2
791, 0.4, 1.4, 0.3
792, 0.4, 1.4, 0.4
793, 0.6, 1.4, 0.1
794, 0.6, 1.4, 0.2
795, 0.6, 1.4, 0.3
796, 0.6, 1.4, 0.4
797, 0.8, 1.4, 0.1
798, 0.8, 1.4, 0.2
799, 0.8, 1.4, 0.3
800, 0.8, 1.4, 0.4
801, 0.2, 1.4333333333333, 0
802, 0.2, 1.4666666666667, 0
803, 0.4, 1.4333333333333, 0
804, 0.4, 1.4666666666667, 0
805, 0.6, 1.4333333333333, 0
806, 0.6, 1.4666666666667, 0
807, 0.8, 1.4333333333333, 0
808, 0.8, 1.4666666666667, 0
809, 1, 1.4333333333333, 0.1
810, 1, 1.4666666666667, 0.1
811, 1, 1.4333333333333, 0.2
812, 1, 1.4666666666667, 0.2
813, 1, 1.4333333333333, 0.3
814, 1, 1.4666666666667, 0.3
815, 1, 1.4333333333333, 0.4
816, 1, 1.4666666666667, 0.4
817, 0.2, 1.4333333333333, 0.5
818, 0.2, 1.4666666666667, 0.5
819, 0.4, 1.4333333333333, 0.5
820, 0.4, 1.4666666666667, 0.5
821, 0.6, 1.4333333333333, 0.5
822, 0.6, 1.4666666666667, 0.5
823, 0.8, 1.4333333333333, 0.5
824, 0.8, 1.4666666666667, 0.5
825, 0, 1.4333333333333, 0.1
826, 0, 1.4666666666667, 0.1
827, 0, 1.4333333333333, 0.2
828, 0, 1.4666666666667, 0.2
829, 0, 1.4333333333333, 0.3
830, 0, 1.4666666666667, 0.3
831, 0, 1.4333333333333, 0.4
832, 0, 1.4666666666667, 0.4
833, 0.2, 1.5, 0.1
834, 0.2, 1.5, 0.2
835, 0.2, 1.5, 0.3
836, 0.2, 1.5, 0.4
837, 0.4, 1.5, 0.1
838, 0.4, 1.5, 0.2
839, 0.4, 1.5, 0.3
840, 0.4, 1.5, 0.4
841, 0.6, 1.5, 0.1
842, 0.6, 1.5, 0.2
843, 0.6, 1.5, 0.3
844, 0.6, 1.5, 0.4
845, 0.8, 1.5, 0.1
846, 0.8, 1.5, 0.2
847, 0.8, 1.5, 0.3
848, 0.8, 1.5, 0.4
849, 1.04, 1.4333333333333, 0.5
850, 1.08, 1.4333333333333, 0.5
851, 1.12, 1.4333333333333, 0.5
852, 1.16, 1.4333333333333, 0.5
853, 1.04, 1.4666666666667, 0.5
854, 1.08, 1.4666666666667, 0.5
855, 1.12, 1.4666666666667, 0.5
856, 1.16, 1.4666666666667, 0.5
857, 1.04, 1.4333333333333, 0
858, 1.08, 1.4333333333333, 0
859, 1.12, 1.4333333333333, 0
860, 1.16, 1.4333333333333, 0
861, 1.04, 1.4666666666667, 0
862, 1.08, 1.4666666666667, 0
863, 1.12, 1.4666666666667, 0
864, 1.16, 1.4666666666667, 0
865, 1.04, 1.4, 0.1
866, 1.08, 1.4, 0.1
867, 1.12, 1.4, 0.1
868, 1.16, 1.4, 0.1
869, 1.04, 1.4, 0.2
870, 1.08, 1.4, 0.2
871, 1.12, 1.4, 0.2
872, 1.16, 1.4, 0.2
873, 1.04, 1.4, 0.3
874, 1.08, 1.4, 0.3
875, 1.12, 1.4, 0.3
876, 1.16, 1.4, 0.3
877, 1.04, 1.4, 0.4
878, 1.08, 1.4, 0.4
879, 1.12, 1.4, 0.4
880, 1.16, 1.4, 0.4
881, 1.04, 1.5, 0.1
882, 1.08, 1.5, 0.1
883, 1.12, 1.5, 0.1
884, 1.16, 1.5, 0.1
885, 1.04, 1.5, 0.2
886, 1.08, 1.5, 0.2
887, 1.12, 1.5, 0.2
888, 1.16, 1.5, 0.2
889, 1.04, 1.5, 0.3
890, 1.08, 1.5, 0.3
891, 1.12, 1.5, 0.3
892, 1.16, 1.5, 0.3
893, 1.04, 1.5, 0.4
894, 1.08, 1.5, 0.4
895, 1.12, 1.5, 0.4
896, 1.16, 1.5, 0.4
897, 1.2, 1.4333333333333, 0.1
898, 1.2, 1.4666666666667, 0.1
899, 1.2, 1.4333333333333, 0.2
900, 1.2, 1.4666666666667, 0.2
901, 1.2, 1.4333333333333, 0.3
902, 1.2, 1.4666666666667, 0.3
903, 1.2, 1.4333333333333, 0.4
904, 1.2, 1.4666666666667, 0.4
905, 1.4, 1.4333333333333, 0.5
906, 1.6, 1.4333333333333, 0.5
907, 1.8, 1.4333333333333, 0.5
908, 2, 1.4333333333333, 0.5
909, 1.4, 1.4666666666667, 0.5
910, 1.6, 1.4666666666667, 0.5
911, 1.8, 1.4666666666667, 0.5
912, 2, 1.4666666666667, 0.5
913, 1.4, 1.4333333333333, 0
914, 1.6, 1.4333333333333, 0
915, 1.8, 1.4333333333333, 0
916, 2, 1.4333333333333, 0
917, 1.4, 1.4666666666667, 0
918, 1.6, 1.4666666666667, 0
919, 1.8, 1.4666666666667, 0
920, 2, 1.4666666666667, 0
921, 1.4, 1.4, 0.1
922, 1.6, 1.4, 0.1
923, 1.8, 1.4, 0.1
924, 2, 1.4, 0.1
925, 1.4, 1.4, 0.2
926, 1.6, 1.4, 0.2
927, 1.8, 1.4, 0.2
928, 2, 1.4, 0.2
929, 1.4, 1.4, 0.3
930, 1.6, 1.4, 0.3
931, 1.8, 1.4, 0.3
932, 2, 1.4, 0.3
933, 1.4, 1.4, 0.4
934, 1.6, 1.4, 0.4
935, 1.8, 1.4, 0.4
936, 2, 1.4, 0.4
937, 1.4, 1.5, 0.1
938, 1.6, 1.5, 0.1
939, 1.8, 1.5, 0.1
940, 2, 1.5, 0.1
941, 1.4, 1.5, 0.2
942, 1.6, 1.5, 0.2
943, 1.8, 1.5, 0.2
944, 2, 1.5, 0.2
945, 1.4, 1.5, 0.3
946, 1.6, 1.5, 0.3
947, 1.8, 1.5, 0.3
948, 2, 1.5, 0.3
949, 1.4, 1.5, 0.4
950, 1.6, 1.5, 0.4
951, 1.8, 1.5, 0.4
952, 2, 1.5, 0.4
953, 2.2, 1.4333333333333, 0.1
954, 2.2, 1.4666666666667, 0.1
955, 2.2, 1.4333333333333, 0.2
956, 2.2, 1.4666666666667, 0.2
957, 2.2, 1.4333333333333, 0.3
958, 2.2, 1.4666666666667, 0.3
959, 2.2, 1.4333333333333, 0.4
960, 2.2, 1.4666666666667, 0.4
961, 1.4, 1.35, 0.1
962, 1.6, 1.35, 0.1
963, 1.8, 1.35, 0.1
964, 2, 1.35, 0.1
965, 1.4, 1.35, 0.2
966, 1.6, 1.35, 0.2
967, 1.8, 1.35, 0.2
968, 2, 1.35, 0.2
969, 1.4, 1.35, 0.3
970, 1.6, 1.35, 0.3
971, 1.8, 1.35, 0.3
972, 2, 1.35, 0.3
973, 1.4, 1.35, 0.4
974, 1.6, 1.35, 0.4
975, 1.8, 1.35, 0.4
976, 2, 1.35, 0.4
977, 1.4, 1.11, 0.5
978, 1.4, 0.87, 0.5
979, 1.4, 0.63, 0.5
980, 1.4, 0.39, 0.5
981, 1.6, 1.11, 0.5
982, 1.6, 0.87, 0.5
983, 1.6, 0.63, 0.5
984, 1.6, 0.39, 0.5
985, 1.8, 1.11, 0.5
986, 1.8, 0.87, 0.5
987, 1.8, 0.63, 0.5
988, 1.8, 0.39, 0.5
989, 2, 1.11, 0.5
990, 2, 0.87, 0.5
991, 2, 0.63, 0.5
992, 2, 0.39, 0.5
993, 1.4, 1.11, 0
994, 1.4, 0.87, 0
995, 1.4, 0.63, 0
996, 1.4, 0.39, 0
997, 1.6, 1.11, 0
998, 1.6, 0.87, 0
999, 1.6, 0.63, 0
1000, 1.6, 0.39, 0
1001, 1.8, 1.11, 0
1002, 1.8, 0.87, 0
1003, 1.8, 0.63, 0
1004, 1.8, 0.39, 0
1005, 2, 1.11, 0
1006, 2, 0.87, 0
1007, 2, 0.63, 0
1008, 2, 0.39, 0
1009, 1.2, 1.11, 0.1
1010, 1.2, 0.87, 0.1
1011, 1.2, 0.63, 0.1
1012, 1.2, 0.39, 0.1
1013, 1.2, 1.11, 0.2
1014, 1.2, 0.87, 0.2
1015, 1.2, 0.63, 0.2
1016, 1.2, 0.39, 0.2
1017, 1.2, 1.11, 0.3
1018, 1.2, 0.87, 0.3
1019, 1.2, 0.63, 0.3
1020, 1.2, 0.39, 0.3
1021, 1.2, 1.11, 0.4
1022, 1.2, 0.87, 0.4
1023, 1.2, 0.63, 0.4
1024, 1.2, 0.39, 0.4
1025, 2.2, 1.11, 0.1
1026, 2.2, 0.87, 0.1
1027, 2.2, 0.63, 0.1
1028, 2.2, 0.39, 0.1
1029, 2.2, 1.11, 0.2
1030, 2.2, 0.87, 0.2
1031, 2.2, 0.63, 0.2
1032, 2.2, 0.39, 0.2
1033, 2.2, 1.11, 0.3
1034, 2.2, 0.87, 0.3
1035, 2.2, 0.63, 0.3
1036, 2.2, 0.39, 0.3
1037, 2.2, 1.11, 0.4
1038, 2.2, 0.87, 0.4
1039, 2.2, 0.63, 0.4
1040, 2.2, 0.39, 0.4
1041, 1.4, 0.15, 0.1
1042, 1.6, 0.15, 0.1
1043, 1.8, 0.15, 0.1
1044, 2, 0.15, 0.1
1045, 1.4, 0.15, 0.2
1046, 1.6, 0.15, 0.2
1047, 1.8, 0.15, 0.2
1048, 2, 0.15, 0.2
1049, 1.4, 0.15, 0.3
1050, 1.6, 0.15, 0.3
1051, 1.8, 0.15, 0.3
1052, 2, 0.15, 0.3
1053, 1.4, 0.15, 0.4
1054, 1.6, 0.15, 0.4
1055, 1.8, 0.15, 0.4
1056, 2, 0.15, 0.4
1057, 1.4, 0.1, 0.1
1058, 1.6, 0.1, 0.1
1059, 1.8, 0.1, 0.1
1060, 2, 0.1, 0.1
1061, 1.4, 0.1, 0.2
1062, 1.6, 0.1, 0.2
1063, 1.8, 0.1, 0.2
1064, 2, 0.1, 0.2
1065, 1.4, 0.1, 0.3
1066, 1.6, 0.1, 0.3
1067, 1.8, 0.1, 0.3
1068, 2, 0.1, 0.3
1069, 1.4, 0.1, 0.4
1070, 1.6, 0.1, 0.4
1071, 1.8, 0.1, 0.4
1072, 2, 0.1, 0.4
1073, 1.4, 0.066666666666667, 0.5
1074, 1.4, 0.033333333333333, 0.5
1075, 1.6, 0.066666666666667, 0.5
1076, 1.6, 0.033333333333333, 0.5
1077, 1.8, 0.066666666666667, 0.5
1078, 1.8, 0.033333333333333, 0.5
1079, 2, 0.066666666666667, 0.5
1080, 2, 0.033333333333333, 0.5
1081, 1.4, 0.066666666666667, 0
1082, 1.4, 0.033333333333333, 0
1083, 1.6, 0.066666666666667, 0
1084, 1.6, 0.033333333333333, 0
1085, 1.8, 0.066666666666667, 0
1086, 1.8, 0.033333333333333, 0
1087, 2, 0.066666666666667, 0
1088, 2, 0.033333333333333, 0
1089, 1.2, 0.066666666666667, 0.1
1090, 1.2, 0.033333333333333, 0.1
1091, 1.2, 0.066666666666667, 0.2
1092, 1.2, 0.033333333333333, 0.2
1093, 1.2, 0.066666666666667, 0.3
1094, 1.2, 0.033333333333333, 0.3
1095, 1.2, 0.066666666666667, 0.4
1096, 1.2, 0.033333333333333, 0.4
1097, 2.2, 0.066666666666667, 0.1
1098, 2.2, 0.033333333333333, 0.1
1099, 2.2, 0.066666666666667, 0.2
1100, 2.2, 0.033333333333333, 0.2
1101, 2.2, 0.066666666666667, 0.3
1102, 2.2, 0.033333333333333, 0.3
1103, 2.2, 0.066666666666667, 0.4
1104, 2.2, 0.033333333333333, 0.4
1105, 1.4, 1.2490009027033e-16, 0.1
1106, 1.6, 1.2490009027033e-16, 0.1
1107, 1.8, 1.2490009027033e-16, 0.1
1108, 2, 1.2490009027033e-16, 0.1
1109, 1.4, 1.2490009027033e-16, 0.2
1110, 1.6, 1.2490009027033e-16, 0.2
1111, 1.8, 1.2490009027033e-16, 0.2
1112, 2, 1.2490009027033e-16, 0.2
1113, 1.4, 1.2490009027033e-16, 0.3
1114, 1.6, 1.2490009027033e-16, 0.3
1115, 1.8, 1.2490009027033e-16, 0.3
1116, 2, 1.2490009027033e-16, 0.3
1117, 1.4, 1.2490009027033e-16, 0.4
1118, 1.6, 1.2490009027033e-16, 0.4
1119, 1.8, 1.2490009027033e-16, 0.4
1120, 2, 1.2490009027033e-16, 0.4
1121, 2.3, 0.066666666666667, 0.1
1122, 2.3, 0.033333333333333, 0.1
1123, 2.3, 0.066666666666667, 0.2
1124, 2.3, 0.033333333333333, 0.2
1125, 2.3, 0.066666666666667, 0.3
1126, 2.3, 0.033333333333333, 0.3
1127, 2.3, 0.066666666666667, 0.4
1128, 2.3, 0.033333333333333, 0.4
1129, -0.1, 0.033333333333333, 0.1
1130, -0.1, 0.066666666666667, 0.1
1131, -0.1, 0.033333333333333, 0.2
1132, -0.1, 0.066666666666667, 0.2
1133, -0.1, 0.033333333333333, 0.3
1134, -0.1, 0.066666666666667, 0.3
1135, -0.1, 0.033333333333333, 0.4
1136, -0.1, 0.066666666666667, 0.4
1137, 1.05, 0.39, 0.1
1138, 1.05, 0.63, 0.1
1139, 1.05, 0.87, 0.1
1140, 1.05, 1.11, 0.1
1141, 1.05, 0.39, 0.2
1142, 1.05, 0.63, 0.2
1143, 1.05, 0.87, 0.2
1144, 1.05, 1.11, 0.2
1145, 1.05, 0.39, 0.3
1146, 1.05, 0.63, 0.3
1147, 1.05, 0.87, 0.3
1148, 1.05, 1.11, 0.3
1149, 1.05, 0.39, 0.4
1150, 1.05, 0.63, 0.4
1151, 1.05, 0.87, 0.4
1152, 1.05, 1.11, 0.4
1153, 1.15, 1.11, 0.1
1154, 1.15, 0.87, 0.1
1155, 1.15, 0.63, 0.1
1156, 1.15, 0.39, 0.1
1157, 1.15, 1.11, 0.2
1158, 1.15, 0.87, 0.2
1159, 1.15, 0.63, 0.2
1160, 1.15, 0.39, 0.2
1161, 1.15, 1.11, 0.3
1162, 1.15, 0.87, 0.3
1163, 1.15, 0.63, 0.3
1164, 1.15, 0.39, 0.3
1165, 1.15, 1.11, 0.4
1166, 1.15, 0.87, 0.4
1167, 1.15, 0.63, 0.4
1168, 1.15, 0.39, 0.4
1169, 0.2, 0.39, -0.1
1170, 0.2, 0.63, -0.1
1171, 0.2, 0.87, -0.1
1172, 0.2, 1.11, -0.1
1173, 0.4, 0.39, -0.1
1174, 0.4, 0.63, -0.1
1175, 0.4, 0.87, -0.1
1176, 0.4, 1.11, -0.1
1177, 0.6, 0.39, -0.1
1178, 0.6, 0.63, -0.1
1179, 0.6, 0.87, -0.1
1180, 0.6, 1.11, -0.1
1181, 0.8, 0.39, -0.1
1182, 0.8, 0.63, -0.1
1183, 0.8, 0.87, -0.1
1184, 0.8, 1.11, -0.1
1185, 1.4, 1.11, -0.1
1186, 1.4, 0.87, -0.1
1187, 1.4, 0.63, -0.1
1188, 1.4, 0.39, -0.1
1189, 1.6, 1.11, -0.1
1190, 1.6, 0.87, -0.1
1191, 1.6, 0.63, -0.1
1192, 1.6, 0.39, -0.1
1193, 1.8, 1.11, -0.1
1194, 1.8, 0.87, -0.1
1195, 1.8, 0.63, -0.1
1196, 1.8, 0.39, -0.1
1197, 2, 1.11, -0.1
1198, 2, 0.87, -0.1
1199, 2, 0.63, -0.1
1200, 2, 0.39, -0.1
1201, 0.2, 1.54, 0
1202, 0.2, 1.58, 0
1203, 0.2, 1.62, 0
1204, 0.2, 1.66, 0
1205, 0.4, 1.54, 0
1206, 0.4, 1.58, 0
1207, 0.4, 1.62, 0
1208, 0.4, 1.66, 0
1209, 0.6, 1.54, 0
1210, 0.6, 1.58, 0
1211, 0.6, 1.62, 0
1212, 0.6, 1.66, 0
1213, 0.8, 1.54, 0
1214, 0.8, 1.58, 0
1215, 0.8, 1.62, 0
1216, 0.8, 1.66, 0
1217, 1, 1.54, 0.1
1218, 1, 1.58, 0.1
1219, 1, 1.62, 0.1
1220, 1, 1.66, 0.1
1221, 1, 1.54, 0.2
1222, 1, 1.58, 0.2
1223, 1, 1.62, 0.2
1224, 1, 1.66, 0.2
1225, 1, 1.54, 0.3
1226, 1, 1.58, 0.3
1227, 1, 1.62, 0.3
1228, 1, 1.66, 0.3
1229, 1, 1.54, 0.4
1230, 1, 1.58, 0.4
1231, 1, 1.62, 0.4
1232, 1, 1.66, 0.4
1233, 0.2, 1.54, 0.5
1234, 0.2, 1.58, 0.5
1235, 0.2, 1.62, 0.5
1236, 0.2, 1.66, 0.5
1237, 0.4, 1.54, 0.5
1238, 0.4, 1.58, 0.5
1239, 0.4, 1.62, 0.5
1240, 0.4, 1.66, 0.5
1241, 0.6, 1.54, 0.5
1242, 0.6, 1.58, 0.5
1243, 0.6, 1.62, 0.5
1244, 0.6, 1.66, 0.5
1245, 0.8, 1.54, 0.5
1246, 0.8, 1.58, 0.5
1247, 0.8, 1.62, 0.5
1248, 0.8, 1.66, 0.5
1249, 0, 1.54, 0.1
1250, 0, 1.58, 0.1
1251, 0, 1.62, 0.1
1252, 0, 1.66, 0.1
1253, 0, 1.54, 0.2
1254, 0, 1.58, 0.2
1255, 0, 1.62, 0.2
1256, 0, 1.66, 0.2
1257, 0, 1.54, 0.3
1258, 0, 1.58, 0.3
1259, 0, 1.62, 0.3
1260, 0, 1.66, 0.3
1261, 0, 1.54, 0.4
1262, 0, 1.58, 0.4
1263, 0, 1.62, 0.4
1264, 0, 1.66, 0.4
1265, 0.2, 1.7, 0.1
1266, 0.2, 1.7, 0.2
1267, 0.2, 1.7, 0.3
1268, 0.2, 1.7, 0.4
1269, 0.4, 1.7, 0.1
1270, 0.4, 1.7, 0.2
1271, 0.4, 1.7, 0.3
1272, 0.4, 1.7, 0.4
1273, 0.6, 1.7, 0.1
1274, 0.6, 1.7, 0.2
1275, 0.6, 1.7, 0.3
1276, 0.6, 1.7, 0.4
1277, 0.8, 1.7, 0.1
1278, 0.8, 1.7, 0.2
1279, 0.8, 1.7, 0.3
1280, 0.8, 1.7, 0.4
1281, 1.04, 1.54, 0.5
1282, 1.04, 1.58, 0.5
1283, 1.04, 1.62, 0.5
1284, 1.04, 1.66, 0.5
1285, 1.08, 1.54, 0.5
1286, 1.08, 1.58, 0.5
1287, 1.08, 1.62, 0.5
1288, 1.08, 1.66, 0.5
1289, 1.12, 1.54, 0.5
1290, 1.12, 1.58, 0.5
1291, 1.12, 1.62, 0.5
1292, 1.12, 1.66, 0.5
1293, 1.16, 1.54, 0.5
1294, 1.16, 1.58, 0.5
1295, 1.16, 1.62, 0.5
1296, 1.16, 1.66, 0.5
1297, 1.04, 1.54, 0
1298, 1.04, 1.58, 0
1299, 1.04, 1.62, 0
1300, 1.04, 1.66, 0
1301, 1.08, 1.54, 0
1302, 1.08, 1.58, 0
1303, 1.08, 1.62, 0
1304, 1.08, 1.66, 0
1305, 1.12, 1.54, 0
1306, 1.12, 1.58, 0
1307, 1.12, 1.62, 0
1308, 1.12, 1.66, 0
1309, 1.16, 1.54, 0
1310, 1.16, 1.58, 0
1311, 1.16, 1.62, 0
1312, 1.16, 1.66, 0
1313, 1.2, 1.54, 0.1
1314, 1.2, 1.58, 0.1
1315, 1.2, 1.62, 0.1
1316, 1.2, 1.66, 0.1
1317, 1.2, 1.54, 0.2
1318, 1.2, 1.58, 0.2
1319, 1.2, 1.62, 0.2
1320, 1.2, 1.66, 0.2
1321, 1.2, 1.54, 0.3
1322, 1.2, 1.58, 0.3
1323, 1.2, 1.62, 0.3
1324, 1.2, 1.66, 0.3
1325, 1.2, 1.54, 0.4
1326, 1.2, 1.58, 0.4
1327, 1.2, 1.62, 0.4
1328, 1.2, 1.66, 0.4
1329, 1.04, 1.7, 0.1
1330, 1.08, 1.7, 0.1
1331, 1.12, 1.7, 0.1
1332, 1.16, 1.7, 0.1
1333, 1.04, 1.7, 0.2
1334, 1.08, 1.7, 0.2
1335, 1.12, 1.7, 0.2
1336, 1.16, 1.7, 0.2
1337, 1.04, 1.7, 0.3
1338, 1.08, 1.7, 0.3
1339, 1.12, 1.7, 0.3
1340, 1.16, 1.7, 0.3
1341, 1.04, 1.7, 0.4
1342, 1.08, 1.7, 0.4
1343, 1.12, 1.7, 0.4
1344, 1.16, 1.7, 0.4
1345, 1.4, 1.54, 0.5
1346, 1.4, 1.58, 0.5
1347, 1.4, 1.62, 0.5
1348, 1.4, 1.66, 0.5
1349, 1.6, 1.54, 0.5
1350, 1.6, 1.58, 0.5
1351, 1.6, 1.62, 0.5
1352, 1.6, 1.66, 0.5
1353, 1.8, 1.54, 0.5
1354, 1.8, 1.58, 0.5
1355, 1.8, 1.62, 0.5
1356, 1.8, 1.66, 0.5
1357, 2, 1.54, 0.5
1358, 2, 1.58, 0.5
1359, 2, 1.62, 0.5
1360, 2, 1.66, 0.5
1361, 1.4, 1.54, 0
1362, 1.4, 1.58, 0
1363, 1.4, 1.62, 0
1364, 1.4, 1.66, 0
1365, 1.6, 1.54, 0
1366, 1.6, 1.58, 0
1367, 1.6, 1.62, 0
1368, 1.6, 1.66, 0
1369, 1.8, 1.54, 0
1370, 1.8, 1.58, 0
1371, 1.8, 1.62, 0
1372, 1.8, 1.66, 0
1373, 2, 1.54, 0
1374, 2, 1.58, 0
1375, 2, 1.62, 0
1376, 2, 1.66, 0
1377, 2.2, 1.54, 0.1
1378, 2.2, 1.58, 0.1
1379, 2.2, 1.62, 0.1
1380, 2.2, 1.66, 0.1
1381, 2.2, 1.54, 0.2
1382, 2.2, 1.58, 0.2
1383, 2.2, 1.62, 0.2
1384, 2.2, 1.66, 0.2
1385, 2.2, 1.54, 0.3
1386, 2.2, 1.58, 0.3
1387, 2.2, 1.62, 0.3
1388, 2.2, 1.66, 0.3
1389, 2.2, 1.54, 0.4
1390, 2.2, 1.58, 0.4
1391, 2.2, 1.62, 0.4
1392, 2.2, 1.66, 0.4
1393, 1.4, 1.7, 0.1
1394, 1.6, 1.7, 0.1
1395, 1.8, 1.7, 0.1
1396, 2, 1.7, 0.1
1397, 1.4, 1.7, 0.2
1398, 1.6, 1.7, 0.2
1399, 1.8, 1.7, 0.2
1400, 2, 1.7, 0.2
1401, 1.4, 1.7, 0.3
1402, 1.6, 1.7, 0.3
1403, 1.8, 1.7, 0.3
1404, 2, 1.7, 0.3
1405, 1.4, 1.7, 0.4
1406, 1.6, 1.7, 0.4
1407, 1.8, 1.7, 0.4
1408, 2, 1.7, 0.4
1409, 0.2, -0.04, 0
1410, 0.2, -0.08, 0
1411, 0.2, -0.12, 0
1412, 0.2, -0.16, 0
1413, 0.4, -0.04, 0
1414, 0.4, -0.08, 0
1415, 0.4, -0.12, 0
1416, 0.4, -0.16, 0
1417, 0.6, -0.04, 0
1418, 0.6, -0.08, 0
1419, 0.6, -0.12, 0
1420, 0.6, -0.16, 0
1421, 0.8, -0.04, 0
1422, 0.8, -0.08, 0
1423, 0.8, -0.12, 0
1424, 0.8, -0.16, 0
1425, 1, -0.04, 0.1
1426, 1, -0.08, 0.1
1427, 1, -0.12, 0.1
1428, 1, -0.16, 0.1
1429, 1, -0.04, 0.2
1430, 1, -0.08, 0.2
1431, 1, -0.12, 0.2
1432, 1, -0.16, 0.2
1433, 1, -0.04, 0.3
1434, 1, -0.08, 0.3
1435, 1, -0.12, 0.3
1436, 1, -0.16, 0.3
1437, 1, -0.04, 0.4
1438, 1, -0.08, 0.4
1439, 1, -0.12, 0.4
1440, 1, -0.16, 0.4
1441, 0.2, -0.04, 0.5
1442, 0.2, -0.08, 0.5
1443, 0.2, -0.12, 0.5
1444, 0.2, -0.16, 0.5
1445, 0.4, -0.04, 0.5
1446, 0.4, -0.08, 0.5
1447, 0.4, -0.12, 0.5
1448, 0.4, -0.16, 0.5
1449, 0.6, -0.04, 0.5
1450, 0.6, -0.08, 0.5
1451, 0.6, -0.12, 0.5
1452, 0.6, -0.16, 0.5
1453, 0.8, -0.04, 0.5
1454, 0.8, -0.08, 0.5
1455, 0.8, -0.12, 0.5
1456, 0.8, -0.16, 0.5
1457, 0, -0.04, 0.1
1458, 0, -0.08, 0.1
1459, 0, -0.12, 0.1
1460, 0, -0.16, 0.1
1461, 0, -0.04, 0.2
1462, 0, -0.08, 0.2
1463, 0, -0.12, 0.2
1464, 0, -0.16, 0.2
1465, 0, -0.04, 0.3
1466, 0, -0.08, 0.3
1467, 0, -0.12, 0.3
1468, 0, -0.16, 0.3
1469, 0, -0.04, 0.4
1470, 0, -0.08, 0.4
1471, 0, -0.12, 0.4
1472, 0, -0.16, 0.4
1473, 0.2, -0.2, 0.1
1474, 0.2, -0.2, 0.2
1475, 0.2, -0.2, 0.3
1476, 0.2, -0.2, 0.4
1477, 0.4, -0.2, 0.1
1478, 0.4, -0.2, 0.2
1479, 0.4, -0.2, 0.3
1480, 0.4, -0.2, 0.4
1481, 0.6, -0.2, 0.1
1482, 0.6, -0.2, 0.2
1483, 0.6, -0.2, 0.3
1484, 0.6, -0.2, 0.4
1485, 0.8, -0.2, 0.1
1486, 0.8, -0.2, 0.2
1487, 0.8, -0.2, 0.3
1488, 0.8, -0.2, 0.4
1489, -0.1, -0.04, 0.1
1490, -0.1, -0.08, 0.1
1491, -0.1, -0.12, 0.1
1492, -0.1, -0.16, 0.1
1493, -0.1, -0.04, 0.2
1494, -0.1, -0.08, 0.2
1495, -0.1, -0.12, 0.2
1496, -0.1, -0.16, 0.2
1497, -0.1, -0.04, 0.3
1498, -0.1, -0.08, 0.3
1499, -0.1, -0.12, 0.3
1500, -0.1, -0.16, 0.3
1501, -0.1, -0.04, 0.4
1502, -0.1, -0.08, 0.4
1503, -0.1, -0.12, 0.4
1504, -0.1, -0.16, 0.4
1505, 1.4, -0.04, 0.5
1506, 1.4, -0.08, 0.5
1507, 1.4, -0.12, 0.5
1508, 1.4, -0.16, 0.5
1509, 1.6, -0.04, 0.5
1510, 1.6, -0.08, 0.5
1511, 1.6, -0.12, 0.5
1512, 1.6, -0.16, 0.5
1513, 1.8, -0.04, 0.5
1514, 1.8, -0.08, 0.5
1515, 1.8, -0.12, 0.5
1516, 1.8, -0.16, 0.5
1517, 2, -0.04, 0.5
1518, 2, -0.08, 0.5
1519, 2, -0.12, 0.5
1520, 2, -0.16, 0.5
1521, 1.4, -0.04, 0
1522, 1.4, -0.08, 0
1523, 1.4, -0.12, 0
1524, 1.4, -0.16, 0
1525, 1.6, -0.04, 0
1526, 1.6, -0.08, 0
1527, 1.6, -0.12, 0
1528, 1.6, -0.16, 0
1529, 1.8, -0.04, 0
1530, 1.8, -0.08, 0
1531, 1.8, -0.12, 0
1532, 1.8, -0.16, 0
1533, 2, -0.04, 0
1534, 2, -0.08, 0
1535, 2, -0.12, 0
1536, 2, -0.16, 0
1537, 1.2, -0.04, 0.1
1538, 1.2, -0.08, 0.1
1539, 1.2, -0.12, 0.1
1540, 1.2, -0.16, 0.1
1541, 1.2, -0.04, 0.2
1542, 1.2, -0.08, 0.2
1543, 1.2, -0.12, 0.2
1544, 1.2, -0.16, 0.2
1545, 1.2, -0.04, 0.3
1546, 1.2, -0.08, 0.3
1547, 1.2, -0.12, 0.3
1548, 1.2, -0.16, 0.3
1549, 1.2, -0.04, 0.4
1550, 1.2, -0.08, 0.4
1551, 1.2, -0.12, 0.4
1552, 1.2, -0.16, 0.4
1553, 2.2, -0.04, 0.1
1554, 2.2, -0.08, 0.1
1555, 2.2, -0.12, 0.1
1556, 2.2, -0.16, 0.1
1557, 2.2, -0.04, 0.2
1558, 2.2, -0.08, 0.2
1559, 2.2, -0.12, 0.2
1560, 2.2, -0.16, 0.2
1561, 2.2, -0.04, 0.3
1562, 2.2, -0.08, 0.3
1563, 2.2, -0.12, 0.3
1564, 2.2, -0.16, 0.3
1565, 2.2, -0.04, 0.4
1566, 2.2, -0.08, 0.4
1567, 2.2, -0.12, 0.4
1568, 2.2, -0.16, 0.4
1569, 1.4, -0.2, 0.1
1570, 1.6, -0.2, 0.1
1571, 1.8, -0.2, 0.1
1572, 2, -0.2, 0.1
1573, 1.4, -0.2, 0.2
1574, 1.6, -0.2, 0.2
1575, 1.8, -0.2, 0.2
1576, 2, -0.2, 0.2
1577, 1.4, -0.2, 0.3
1578, 1.6, -0.2, 0.3
1579, 1.8, -0.2, 0.3
1580, 2, -0.2, 0.3
1581, 1.4, -0.2, 0.4
1582, 1.6, -0.2, 0.4
1583, 1.8, -0.2, 0.4
1584, 2, -0.2, 0.4
1585, 2.3, -0.04, 0.1
1586, 2.3, -0.08, 0.1
1587, 2.3, -0.12, 0.1
1588, 2.3, -0.16, 0.1
1589, 2.3, -0.04, 0.2
1590, 2.3, -0.08, 0.2
1591, 2.3, -0.12, 0.2
1592, 2.3, -0.16, 0.2
1593, 2.3, -0.04, 0.3
1594, 2.3, -0.08, 0.3
1595, 2.3, -0.12, 0.3
1596, 2.3, -0.16, 0.3
1597, 2.3, -0.04, 0.4
1598, 2.3, -0.08, 0.4
1599, 2.3, -0.12, 0.4
1600, 2.3, -0.16, 0.4
1601, 0.2, 0.033333333333333, 0.1
1602, 0.4, 0.033333333333333, 0.1
1603, 0.6, 0.033333333333333, 0.1
1604, 0.8, 0.033333333333333, 0.1
1605, 0.2, 0.066666666666667, 0.1
1606, 0.4, 0.066666666666667, 0.1
1607, 0.6, 0.066666666666667, 0.1
1608, 0.8, 0.066666666666667, 0.1
1609, 0.2, 0.033333333333333, 0.2
1610, 0.4, 0.033333333333333, 0.2
1611, 0.6, 0.033333333333333, 0.2
1612, 0.8, 0.033333333333333, 0.2
1613, 0.2, 0.066666666666667, 0.2
1614, 0.4, 0.066666666666667, 0.2
1615, 0.6, 0.066666666666667, 0.2
1616, 0.8, 0.066666666666667, 0.2
1617, 0.2, 0.033333333333333, 0.3
1618, 0.4, 0.033333333333333, 0.3
1619, 0.6, 0.033333333333333, 0.3
1620, 0.8, 0.033333333333333, 0.3
1621, 0.2, 0.066666666666667, 0.3
1622, 0.4, 0.066666666666667, 0.3
1623, 0.6, 0.066666666666667, 0.3
1624, 0.8, 0.066666666666667, 0.3
1625, 0.2, 0.033333333333333, 0.4
1626, 0.4, 0.033333333333333, 0.4
1627, 0.6, 0.033333333333333, 0.4
1628, 0.8, 0.033333333333333, 0.4
1629, 0.2, 0.066666666666667, 0.4
1630, 0.4, 0.066666666666667, 0.4
1631, 0.6, 0.066666666666667, 0.4
1632, 0.8, 0.066666666666667, 0.4
1633, 0.2, 0.39, 0.1
1634, 0.2, 0.63, 0.1
1635, 0.2, 0.87, 0.1
1636, 0.2, 1.11, 0.1
1637, 0.2, 0.39, 0.2
1638, 0.2, 0.63, 0.2
1639, 0.2, 0.87, 0.2
1640, 0.2, 1.11, 0.2
1641, 0.2, 0.39, 0.3
1642, 0.2, 0.63, 0.3
1643, 0.2, 0.87, 0.3
1644, 0.2, 1.11, 0.3
1645, 0.2, 0.39, 0.4
1646, 0.2, 0.63, 0.4
1647, 0.2, 0.87, 0.4
1648, 0.2, 1.11, 0.4
1649, 0.4, 0.39, 0.1
1650, 0.4, 0.63, 0.1
1651, 0.4, 0.87, 0.1
1652, 0.4, 1.11, 0.1
1653, 0.4, 0.39, 0.2
1654, 0.4, 0.63, 0.2
1655, 0.4, 0.87, 0.2
1656, 0.4, 1.11, 0.2
1657, 0.4, 0.39, 0.3
1658, 0.4, 0.63, 0.3
1659, 0.4, 0.87, 0.3
1660, 0.4, 1.11, 0.3
1661, 0.4, 0.39, 0.4
1662, 0.4, 0.63, 0.4
1663, 0.4, 0.87, 0.4
1664, 0.4, 1.11, 0.4
1665, 0.6, 0.39, 0.1
1666, 0.6, 0.63, 0.1
1667, 0.6, 0.87, 0.1
1668, 0.6, 1.11, 0.1
1669, 0.6, 0.39, 0.2
1670, 0.6, 0.63, 0.2
1671, 0.6, 0.87, 0.2
1672, 0.6, 1.11, 0.2
1673, 0.6, 0.39, 0.3
1674, 0.6, 0.63, 0.3
1675, 0.6, 0.87, 0.3
1676, 0.6, 1.11, 0.3
1677, 0.6, 0.39, 0.4
1678, 0.6, 0.63, 0.4
1679, 0.6, 0.87, 0.4
1680, 0.6, 1.11, 0.4
1681, 0.8, 0.39, 0.1
1682, 0.8, 0.63, 0.1
1683, 0.8, 0.87, 0.1
1684, 0.8, 1.11, 0.1
1685, 0.8, 0.39, 0.2
1686, 0.8, 0.63, 0.2
1687, 0.8, 0.87, 0.2
1688, 0.8, 1.11, 0.2
1689, 0.8, 0.39, 0.3
1690, 0.8, 0.63, 0.3
1691, 0.8, 0.87, 0.3
1692, 0.8, 1.11, 0.3
1693, 0.8, 0.39, 0.4
1694, 0.8, 0.63, 0.4
1695, 0.8, 0.87, 0.4
1696, 0.8, 1.11, 0.4
1697, 0.2, 1.4333333333333, 0.1
1698, 0.2, 1.4666666666667, 0.1
1699, 0.2, 1.4333333333333, 0.2
1700, 0.2, 1.4666666666667, 0.2
1701, 0.2, 1.4333333333333, 0.3
1702, 0.2, 1.4666666666667, 0.3
1703, 0.2, 1.4333333333333, 0.4
1704, 0.2, 1.4666666666667, 0.4
1705, 0.4, 1.4333333333333, 0.1
1706, 0.4, 1.4666666666667, 0.1
1707, 0.4, 1.4333333333333, 0.2
1708, 0.4, 1.4666666666667, 0.2
1709, 0.4, 1.4333333333333, 0.3
1710, 0.4, 1.4666666666667, 0.3
1711, 0.4, 1.4333333333333, 0.4
1712, 0.4, 1.4666666666667, 0.4
1713, 0.6, 1.4333333333333, 0.1
1714, 0.6, 1.4666666666667, 0.1
1715, 0.6, 1.4333333333333, 0.2
1716, 0.6, 1.4666666666667, 0.2
1717, 0.6, 1.4333333333333, 0.3
1718, 0.6, 1.4666666666667, 0.3
1719, 0.6, 1.4333333333333, 0.4
1720, 0.6, 1.4666666666667, 0.4
1721, 0.8, 1.4333333333333, 0.1
1722, 0.8, 1.4666666666667, 0.1
1723, 0.8, 1.4333333333333, 0.2
1724, 0.8, 1.4666666666667, 0.2
1725, 0.8, 1.4333333333333, 0.3
1726, 0.8, 1.4666666666667, 0.3
1727, 0.8, 1.4333333333333, 0.4
1728, 0.8, 1.4666666666667, 0.4
1729, 1.04, 1.4333333333333, 0.1
1730, 1.08, 1.4333333333333, 0.1
1731, 1.12, 1.4333333333333, 0.1
1732, 1.16, 1.4333333333333, 0.1
1733, 1.04, 1.4666666666667, 0.1
1734, 1.08, 1.4666666666667, 0.1
1735, 1.12, 1.4666666666667, 0.1
1736, 1.16, 1.4666666666667, 0.1
1737, 1.04, 1.4333333333333, 0.2
1738, 1.08, 1.4333333333333, 0.2
1739, 1.12, 1.4333333333333, 0.2
1740, 1.16, 1.4333333333333, 0.2
1741, 1.04, 1.4666666666667, 0.2
1742, 1.08, 1.4666666666667, 0.2
1743, 1.12, 1.4666666666667, 0.2
1744, 1.16, 1.4666666666667, 0.2
1745, 1.04, 1.4333333333333, 0.3
1746, 1.08, 1.4333333333333, 0.3
1747, 1.12, 1.4333333333333, 0.3
1748, 1.16, 1.4333333333333, 0.3
1749, 1.04, 1.4666666666667, 0.3
1750, 1.08, 1.4666666666667, 0.3
1751, 1.12, 1.4666666666667, 0.3
1752, 1.16, 1.4666666666667, 0.3
1753, 1.04, 1.4333333333333, 0.4
1754, 1.08, 1.4333333333333, 0.4
1755, 1.12, 1.4333333333333, 0.4
1756, 1.16, 1.4333333333333, 0.4
1757, 1.04, 1.4666666666667, 0.4
1758, 1.08, 1.4666666666667, 0.4
1759, 1.12, 1.4666666666667, 0.4
1760, 1.16, 1.4666666666667, 0.4
1761, 1.4, 1.4333333333333, 0.1
1762, 1.6, 1.4333333333333, 0.1
1763, 1.8, 1.4333333333333, 0.1
1764, 2, 1.4333333333333, 0.1
1765, 1.4, 1.4666666666667, 0.1
1766, 1.6, 1.4666666666667, 0.1
1767, 1.8, 1.4666666666667, 0.1
1768, 2, 1.4666666666667, 0.1
1769, 1.4, 1.4333333333333, 0.2
1770, 1.6, 1.4333333333333, 0.2
1771, 1.8, 1.4333333333333, 0.2
1772, 2, 1.4333333333333, 0.2
1773, 1.4, 1.4666666666667, 0.2
1774, 1.6, 1.4666666666667, 0.2
1775, 1.8, 1.4666666666667, 0.2
1776, 2, 1.4666666666667, 0.2
1777, 1.4, 1.4333333333333, 0.3
1778, 1.6, 1.4333333333333, 0.3
1779, 1.8, 1.4333333333333, 0.3
1780, 2, 1.4333333333333, 0.3
1781, 1.4, 1.4666666666667, 0.3
1782, 1.6, 1.4666666666667, 0.3
1783, 1.8, 1.4666666666667, 0.3
1784, 2, 1.4666666666667, 0.3
1785, 1.4, 1.4333333333333, 0.4
1786, 1.6, 1.4333333333333, 0.4
1787, 1.8, 1.4333333333333, 0.4
1788, 2, 1.4333333333333, 0.4
1789, 1.4, 1.4666666666667, 0.4
1790, 1.6, 1.4666666666667, 0.4
1791, 1.8, 1.4666666666667, 0.4
1792, 2, 1.4666666666667, 0.4
1793, 1.4, 1.11, 0.1
1794, 1.4, 0.87, 0.1
1795, 1.4, 0.63, 0.1
1796, 1.4, 0.39, 0.1
1797, 1.6, 1.11, 0.1
1798, 1.6, 0.87, 0.1
1799, 1.6, 0.63, 0.1
1800, 1.6, 0.39, 0.1
1801, 1.8, 1.11, 0.1
1802, 1.8, 0.87, 0.1
1803, 1.8, 0.63, 0.1
1804, 1.8, 0.39, 0.1
1805, 2, 1.11, 0.1
1806, 2, 0.87, 0.1
1807, 2, 0.63, 0.1
1808, 2, 0.39, 0.1
1809, 1.4, 1.11, 0.2
1810, 1.4, 0.87, 0.2
1811, 1.4, 0.63, 0.2
1812, 1.4, 0.39, 0.2
1813, 1.6, 1.11, 0.2
1814, 1.6, 0.87, 0.2
1815, 1.6, 0.63, 0.2
1816, 1.6, 0.39, 0.2
1817, 1.8, 1.11, 0.2
1818, 1.8, 0.87, 0.2
1819, 1.8, 0.63, 0.2
1820, 1.8, 0.39, 0.2
1821, 2, 1.11, 0.2
1822, 2, 0.87, 0.2
1823, 2, 0.63, 0.2
1824, 2, 0.39, 0.2
1825, 1.4, 1.11, 0.3
1826, 1.4, 0.87, 0.3
1827, 1.4, 0.63, 0.3
1828, 1.4, 0.39, 0.3
1829, 1.6, 1.11, 0.3
1830, 1.6, 0.87, 0.3
1831, 1.6, 0.63, 0.3
1832, 1.6, 0.39, 0.3
1833, 1.8, 1.11, 0.3
1834, 1.8, 0.87, 0.3
1835, 1.8, 0.63, 0.3
1836, 1.8, 0.39, 0.3
1837, 2, 1.11, 0.3
1838, 2, 0.87, 0.3
1839, 2, 0.63, 0.3
1840, 2, 0.39, 0.3
1841, 1.4, 1.11, 0.4
1842, 1.4, 0.87, 0.4
1843, 1.4, 0.63, 0.4
1844, 1.4, 0.39, 0.4
1845, 1.6, 1.11, 0.4
1846, 1.6, 0.87, 0.4
1847, 1.6, 0.63, 0.4
1848, 1.6, 0.39, 0.4
1849, 1.8, 1.11, 0.4
1850, 1.8, 0.87, 0.4
1851, 1.8, 0.63, 0.4
1852, 1.8, 0.39, 0.4
1853, 2, 1.11, 0.4
1854, 2, 0.87, 0.4
1855, 2, 0.63, 0.4
1856, 2, 0.39, 0.4
1857, 1.4, 0.066666666666667, 0.1
1858, 1.4, 0.033333333333333, 0.1
1859, 1.6, 0.066666666666667, 0.1
1860, 1.6, 0.033333333333333, 0.1
1861, 1.8, 0.066666666666667, 0.1
1862, 1.8, 0.033333333333333, 0.1
1863, 2, 0.066666666666667, 0.1
1864, 2, 0.033333333333333, 0.1
1865, 1.4, 0.066666666666667, 0.2
1866, 1.4, 0.033333333333333, 0.2
1867, 1.6, 0.066666666666667, 0.2
1868, 1.6, 0.033333333333333, 0.2
1869, 1.8, 0.066666666666667, 0.2
1870, 1.8, 0.033333333333333, 0.2
1871, 2, 0.066666666666667, 0.2
1872, 2, 0.033333333333333, 0.2
1873, 1.4, 0.066666666666667, 0.3
1874, 1.4, 0.033333333333333, 0.3
1875, 1.6, 0.066666666666667, 0.3
1876, 1.6, 0.033333333333333, 0.3
1877, 1.8, 0.066666666666667, 0.3
1878, 1.8, 0.033333333333333, 0.3
1879, 2, 0.066666666666667, 0.3
1880, 2, 0.033333333333333, 0.3
1881, 1.4, 0.066666666666667, 0.4
1882, 1.4, 0.033333333333333, 0.4
1883, 1.6, 0.066666666666667, 0.4
1884, 1.6, 0.033333333333333, 0.4
1885, 1.8, 0.066666666666667, 0.4
1886, 1.8, 0.033333333333333, 0.4
1887, 2, 0.066666666666667, 0.4
1888, 2, 0.033333333333333, 0.4
1889, 0.2, 1.54, 0.1
1890, 0.2, 1.58, 0.1
1891, 0.2, 1.62, 0.1
1892, 0.2, 1.66, 0.1
1893, 0.2, 1.54, 0.2
1894, 0.2, 1.58, 0.2
1895, 0.2, 1.62, 0.2
1896, 0.2, 1.66, 0.2
1897, 0.2, 1.54, 0.3
1898, 0.2, 1.58, 0.3
1899, 0.2, 1.62, 0.3
1900, 0.2, 1.66, 0.3
1901, 0.2, 1.54, 0.4
1902, 0.2, 1.58, 0.4
1903, 0.2, 1.62, 0.4
1904, 0.2, 1.66, 0.4
1905, 0.4, 1.54, 0.1
1906, 0.4, 1.58, 0.1
1907, 0.4, 1.62, 0.1
1908, 0.4, 1.66, 0.1
1909, 0.4, 1.54, 0.2
1910, 0.4, 1.58, 0.2
1911, 0.4, 1.62, 0.2
1912, 0.4, 1.66, 0.2
1913, 0.4, 1.54, 0.3
1914, 0.4, 1.58, 0.3
1915, 0.4, 1.62, 0.3
1916, 0.4, 1.66, 0.3
1917, 0.4, 1.54, 0.4
1918, 0.4, 1.58, 0.4
1919, 0.4, 1.62, 0.4
1920, 0.4, 1.66, 0.4
1921, 0.6, 1.54, 0.1
1922, 0.6, 1.58, 0.1
1923, 0.6, 1.62, 0.1
1924, 0.6, 1.66, 0.1
1925, 0.6, 1.54, 0.2
1926, 0.6, 1.58, 0.2
1927, 0.6, 1.62, 0.2
1928, 0.6, 1.66, 0.2
1929, 0.6, 1.54, 0.3
1930, 0.6, 1.58, 0.3
1931, 0.6, 1.62, 0.3
1932, 0.6, 1.66, 0.3
1933, 0.6, 1.54, 0.4
1934, 0.6, 1.58, 0.4
1935, 0.6, 1.62, 0.4
1936, 0.6, 1.66, 0.4
1937, 0.8, 1.54, 0.1
1938, 0.8, 1.58, 0.1
1939, 0.8, 1.62, 0.1
1940, 0.8, 1.66, 0.1
1941, 0.8, 1.54, 0.2
1942, 0.8, 1.58, 0.2
1943, 0.8, 1.62, 0.2
1944, 0.8, 1.66, 0.2
1945, 0.8, 1.54, 0.3
1946, 0.8, 1.58, 0.3
1947, 0.8, 1.62, 0.3
1948, 0.8, 1.66, 0.3
1949, 0.8, 1.54, 0.4
1950, 0.8, 1.58, 0.4
1951, 0.8, 1.62, 0.4
1952, 0.8, 1.66, 0.4
1953, 1.04, 1.54, 0.1
1954, 1.04, 1.58, 0.1
1955, 1.04, 1.62, 0.1
1956, 1.04, 1.66, 0.1
1957, 1.08, 1.54, 0.1
1958, 1.08, 1.58, 0.1
1959, 1.08, 1.62, 0.1
1960, 1.08, 1.66, 0.1
1961, 1.12, 1.54, 0.1
1962, 1.12, 1.58, 0.1
1963, 1.12, 1.62, 0.1
1964, 1.12, 1.66, 0.1
1965, 1.16, 1.54, 0.1
1966, 1.16, 1.58, 0.1
1967, 1.16, 1.62, 0.1
1968, 1.16, 1.66, 0.1
1969, 1.04, 1.54, 0.2
1970, 1.04, 1.58, 0.2
1971, 1.04, 1.62, 0.2
1972, 1.04, 1.66, 0.2
1973, 1.08, 1.54, 0.2
1974, 1.08, 1.58, 0.2
1975, 1.08, 1.62, 0.2
1976, 1.08, 1.66, 0.2
1977, 1.12, 1.54, 0.2
1978, 1.12, 1.58, 0.2
1979, 1.12, 1.62, 0.2
1980, 1.12, 1.66, 0.2
1981, 1.16, 1.54, 0.2
1982, 1.16, 1.58, 0.2
1983, 1.16, 1.62, 0.2
1984, 1.16, 1.66, 0.2
1985, 1.04, 1.54, 0.3
1986, 1.04, 1.58, 0.3
1987, 1.04, 1.62, 0.3
1988, 1.04, 1.66, 0.3
1989, 1.08, 1.54, 0.3
1990, 1.08, 1.58, 0.3
1991, 1.08, 1.62, 0.3
1992, 1.08, 1.66, 0.3
1993, 1.12, 1.54, 0.3
1994, 1.12, 1.58, 0.3
1995, 1.12, 1.62, 0.3
1996, 1.12, 1.66, 0.3
1997, 1.16, 1.54, 0.3
1998, 1.16, 1.58, 0.3
1999, 1.16, 1.62, 0.3
2000, 1.16, 1.66, 0.3
2001, 1.04, 1.54, 0.4
2002, 1.04, 1.58, 0.4
2003, 1.04, 1.62, 0.4
2004, 1.04, 1.66, 0.4
2005, 1.08, 1.54, 0.4
2006, 1.08, 1.58, 0.4
2007, 1.08, 1.62, 0.4
2008, 1.08, 1.66, 0.4
2009, 1.12, 1.54, 0.4
2010, 1.12, 1.58, 0.4
2011, 1.12, 1.62, 0.4
2012, 1.12, 1.66, 0.4
2013, 1.16, 1.54, 0.4
2014, 1.16, 1.58, 0.4
2015, 1.16, 1.62, 0.4
2016, 1.16, 1.66, 0.4
2017, 1.4, 1.54, 0.1
2018, 1.4, 1.58, 0.1
2019, 1.4, 1.62, 0.1
2020, 1.4, 1.66, 0.1
2021, 1.6, 1.54, 0.1
2022, 1.6, 1.58, 0.1
2023, 1.6, 1.62, 0.1
2024, 1.6, 1.66, 0.1
2025, 1.8, 1.54, 0.1
2026, 1.8, 1.58, 0.1
2027, 1.8, 1.62, 0.1
2028, 1.8, 1.66, 0.1
2029, 2, 1.54, 0.1
2030, 2, 1.58, 0.1
2031, 2, 1.62, 0.1
2032, 2, 1.66, 0.1
2033, 1.4, 1.54, 0.2
2034, 1.4, 1.58, 0.2
2035, 1.4, 1.62, 0.2
2036, 1.4, 1.66, 0.2
2037, 1.6, 1.54, 0.2
2038, 1.6, 1.58, 0.2
2039, 1.6, 1.62, 0.2
2040, 1.6, 1.66, 0.2
2041, 1.8, 1.54, 0.2
2042, 1.8, 1.58, 0.2
2043, 1.8, 1.62, 0.2
2044, 1.8, 1.66, 0.2
2045, 2, 1.54, 0.2
2046, 2, 1.58, 0.2
2047, 2, 1.62, 0.2
2048, 2, 1.66, 0.2
2049, 1.4, 1.54, 0.3
2050, 1.4, 1.58, 0.3
2051, 1.4, 1.62, 0.3
2052, 1.4, 1.66, 0.3
2053, 1.6, 1.54, 0.3
2054, 1.6, 1.58, 0.3
2055, 1.6, 1.62, 0.3
2056, 1.6, 1.66, 0.3
2057, 1.8, 1.54, 0.3
2058, 1.8, 1.58, 0.3
2059, 1.8, 1.62, 0.3
2060, 1.8, 1.66, 0.3
2061, 2, 1.54, 0.3
2062, 2, 1.58, 0.3
2063, 2, 1.62, 0.3
2064, 2, 1.66, 0.3
2065, 1.4, 1.54, 0.4
2066, 1.4, 1.58, 0.4
2067, 1.4, 1.62, 0.4
2068, 1.4, 1.66, 0.4
2069, 1.6, 1.54, 0.4
2070, 1.6, 1.58, 0.4
2071, 1.6, 1.62, 0.4
2072, 1.6, 1.66, 0.4
2073, 1.8, 1.54, 0.4
2074, 1.8, 1.58, 0.4
2075, 1.8, 1.62, 0.4
2076, 1.8, 1.66, 0.4
2077, 2, 1.54, 0.4
2078, 2, 1.58, 0.4
2079, 2, 1.62, 0.4
2080, 2, 1.66, 0.4
2081, 0.2, -0.04, 0.1
2082, 0.2, -0.08, 0.1
2083, 0.2, -0.12, 0.1
2084, 0.2, -0.16, 0.1
2085, 0.2, -0.04, 0.2
2086, 0.2, -0.08, 0.2
2087, 0.2, -0.12, 0.2
2088, 0.2, -0.16, 0.2
2089, 0.2, -0.04, 0.3
2090, 0.2, -0.08, 0.3
2091, 0.2, -0.12, 0.3
2092, 0.2, -0.16, 0.3
2093, 0.2, -0.04, 0.4
2094, 0.2, -0.08, 0.4
2095, 0.2, -0.12, 0.4
2096, 0.2, -0.16, 0.4
2097, 0.4, -0.04, 0.1
2098, 0.4, -0.08, 0.1
2099, 0.4, -0.12, 0.1
2100, 0.4, -0.16, 0.1
2101, 0.4, -0.04, 0.2
2102, 0.4, -0.08, 0.2
2103, 0.4, -0.12, 0.2
2104, 0.4, -0.16, 0.2
2105, 0.4, -0.04, 0.3
2106, 0.4, -0.08, 0.3
2107, 0.4, -0.12, 0.3
2108, 0.4, -0.16, 0.3
2109, 0.4, -0.04, 0.4
2110, 0.4, -0.08, 0.4
2111, 0.4, -0.12, 0.4
2112, 0.4, -0.16, 0.4
2113, 0.6, -0.04, 0.1
2114, 0.6, -0.08, 0.1
2115, 0.6, -0.12, 0.1
2116, 0.6, -0.16, 0.1
2117, 0.6, -0.04, 0.2
2118, 0.6, -0.08, 0.2
2119, 0.6, -0.12, 0.2
2120, 0.6, -0.16, 0.2
2121, 0.6, -0.04, 0.3
2122, 0.6, -0.08, 0.3
2123, 0.6, -0.12, 0.3
2124, 0.6, -0.16, 0.3
2125, 0.6, -0.04, 0.4
2126, 0.6, -0.08, 0.4
2127, 0.6, -0.12, 0.4
2128, 0.6, -0.16, 0.4
2129, 0.8, -0.04, 0.1
2130, 0.8, -0.08, 0.1
2131, 0.8, -0.12, 0.1
2132, 0.8, -0.16, 0.1
2133, 0.8, -0.04, 0.2
2134, 0.8, -0.08, 0.2
2135, 0.8, -0.12, 0.2
2136, 0.8, -0.16, 0.2
2137, 0.8, -0.04, 0.3
2138, 0.8, -0.08, 0.3
2139, 0.8, -0.12, 0.3
2140, 0.8, -0.16, 0.3
2141, 0.8, -0.04, 0.4
2142, 0.8, -0.08, 0.4
2143, 0.8, -0.12, 0.4
2144, 0.8, -0.16, 0.4
2145, 1.4, -0.04, 0.1
2146, 1.4, -0.08, 0.1
2147, 1.4, -0.12, 0.1
2148, 1.4, -0.16, 0.1
2149, 1.6, -0.04, 0.1
2150, 1.6, -0.08, 0.1
2151, 1.6, -0.12, 0.1
2152, 1.6, -0.16, 0.1
2153, 1.8, -0.04, 0.1
2154, 1.8, -0.08, 0.1
2155, 1.8, -0.12, 0.1
2156, 1.8, -0.16, 0.1
2157, 2, -0.04, 0.1
2158, 2, -0.08, 0.1
2159, 2, -0.12, 0.1
2160, 2, -0.16, 0.1
2161, 1.4, -0.04, 0.2
2162, 1.4, -0.08, 0.2
2163, 1.4, -0.12, 0.2
2164, 1.4, -0.16, 0.2
2165, 1.6, -0.04, 0.2
2166, 1.6, -0.08, 0.2
2167, 1.6, -0.12, 0.2
2168, 1.6, -0.16, 0.2
2169, 1.8, -0.04, 0.2
2170, 1.8, -0.08, 0.2
2171, 1.8, -0.12, 0.2
2172, 1.8, -0.16, 0.2
2173, 2, -0.04, 0.2
2174, 2, -0.08, 0.2
2175, 2, -0.12, 0.2
2176, 2, -0.16, 0.2
2177, 1.4, -0.04, 0.3
2178, 1.4, -0.08, 0.3
2179, 1.4, -0.12, 0.3
2180, 1.4, -0.16, 0.3
2181, 1.6, -0.04, 0.3
2182, 1.6, -0.08, 0.3
2183, 1.6, -0.12, 0.3
2184, 1.6, -0.16, 0.3
2185, 1.8, -0.04, 0.3
2186, 1.8, -0.08, 0.3
2187, 1.8, -0.12, 0.3
2188, 1.8, -0.16, 0.3
2189, 2, -0.04, 0.3
2190, 2, -0.08, 0.3
2191, 2, -0.12, 0.3
2192, 2, -0.16, 0.3
2193, 1.4, -0.04, 0.4
2194, 1.4, -0.08, 0.4
2195, 1.4, -0.12, 0.4
2196, 1.4, -0.16, 0.4
2197, 1.6, -0.04, 0.4
2198, 1.6, -0.08, 0.4
2199, 1.6, -0.12, 0.4
2200, 1.6, -0.16, 0.4
2201, 1.8, -0.04, 0.4
2202, 1.8, -0.08, 0.4
2203, 1.8, -0.12, 0.4
2204, 1.8, -0.16, 0.4
2205, 2, -0.04, 0.4
2206, 2, -0.08, 0.4
2207, 2, -0.12, 0.4
2208, 2, -0.16, 0.4
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
2298, 2, 97
2299, 97, 98
2300, 98, 99
2301, 99, 100
2302, 100, 1
*ELEMENT, type=T3D2, ELSET=Line2
2303, 1, 101
2304, 101, 102
2305, 102, 3
*ELEMENT, type=T3D2, ELSET=Line3
2306, 4, 103
2307, 103, 104
2308, 104, 105
2309, 105, 106
2310, 106, 3
*ELEMENT, type=T3D2, ELSET=Line4
2311, 2, 107
2312, 107, 108
2313, 108, 4
*ELEMENT, type=T3D2, ELSET=Line5
2314, 6, 109
2315, 109, 110
2316, 110, 111
2317, 111, 112
2318, 112, 5
*ELEMENT, type=T3D2, ELSET=Line6
2319, 5, 113
2320, 113, 114
2321, 114, 7
*ELEMENT, type=T3D2, ELSET=Line7
2322, 8, 115
2323, 115, 116
2324, 116, 117
2325, 117, 118
2326, 118, 7
*ELEMENT, type=T3D2, ELSET=Line8
2327, 6, 119
2328, 119, 120
2329, 120, 8
*ELEMENT, type=T3D2, ELSET=Line9
2330, 2, 121
2331, 121, 122
2332, 122, 123
2333, 123, 124
2334, 124, 6
*ELEMENT, type=T3D2, ELSET=Line10
2335, 1, 125
2336, 125, 126
2337, 126, 127
2338, 127, 128
2339, 128, 5
*ELEMENT, type=T3D2, ELSET=Line11
2340, 4, 129
2341, 129, 130
2342, 130, 131
2343, 131, 132
2344, 132, 8
*ELEMENT, type=T3D2, ELSET=Line12
2345, 3, 133
2346, 133, 134
2347, 134, 135
2348, 135, 136
2349, 136, 7
*ELEMENT, type=T3D2, ELSET=Line13
2350, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
2351, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
2352, 10, 137
2353, 137, 138
2354, 138, 139
2355, 139, 140
2356, 140, 9
*ELEMENT, type=T3D2, ELSET=Line16
2357, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
2358, 9, 141
2359, 141, 142
2360, 142, 143
2361, 143, 144
2362, 144, 11
*ELEMENT, type=T3D2, ELSET=Line18
2363, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
2364, 12, 145
2365, 145, 146
2366, 146, 147
2367, 147, 148
2368, 148, 11
*ELEMENT, type=T3D2, ELSET=Line20
2369, 10, 149
2370, 149, 150
2371, 150, 151
2372, 151, 152
2373, 152, 12
*ELEMENT, type=T3D2, ELSET=Line21
2374, 9, 153
2375, 153, 154
2376, 154, 155
2377, 155, 156
2378, 156, 13
*ELEMENT, type=T3D2, ELSET=Line22
2379, 10, 157
2380, 157, 158
2381, 158, 159
2382, 159, 160
2383, 160, 14
*ELEMENT, type=T3D2, ELSET=Line23
2384, 14, 161
2385, 161, 162
2386, 162, 163
2387, 163, 164
2388, 164, 13
*ELEMENT, type=T3D2, ELSET=Line24
2389, 11, 165
2390, 165, 166
2391, 166, 167
2392, 167, 168
2393, 168, 15
*ELEMENT, type=T3D2, ELSET=Line25
2394, 13, 169
2395, 169, 170
2396, 170, 171
2397, 171, 172
2398, 172, 15
*ELEMENT, type=T3D2, ELSET=Line26
2399, 12, 173
2400, 173, 174
2401, 174, 175
2402, 175, 176
2403, 176, 16
*ELEMENT, type=T3D2, ELSET=Line27
2404, 16, 177
2405, 177, 178
2406, 178, 179
2407, 179, 180
2408, 180, 15
*ELEMENT, type=T3D2, ELSET=Line28
2409, 14, 181
2410, 181, 182
2411, 182, 183
2412, 183, 184
2413, 184, 16
*ELEMENT, type=T3D2, ELSET=Line29
2414, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
2415, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
2416, 18, 185
2417, 185, 186
2418, 186, 187
2419, 187, 188
2420, 188, 17
*ELEMENT, type=T3D2, ELSET=Line32
2421, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
2422, 17, 189
2423, 189, 190
2424, 190, 191
2425, 191, 192
2426, 192, 19
*ELEMENT, type=T3D2, ELSET=Line34
2427, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
2428, 20, 193
2429, 193, 194
2430, 194, 195
2431, 195, 196
2432, 196, 19
*ELEMENT, type=T3D2, ELSET=Line36
2433, 18, 197
2434, 197, 198
2435, 198, 199
2436, 199, 200
2437, 200, 20
*ELEMENT, type=T3D2, ELSET=Line37
2438, 17, 201
2439, 201, 202
2440, 202, 21
*ELEMENT, type=T3D2, ELSET=Line38
2441, 18, 203
2442, 203, 204
2443, 204, 22
*ELEMENT, type=T3D2, ELSET=Line39
2444, 22, 205
2445, 205, 206
2446, 206, 207
2447, 207, 208
2448, 208, 21
*ELEMENT, type=T3D2, ELSET=Line40
2449, 19, 209
2450, 209, 210
2451, 210, 23
*ELEMENT, type=T3D2, ELSET=Line41
2452, 21, 211
2453, 211, 212
2454, 212, 213
2455, 213, 214
2456, 214, 23
*ELEMENT, type=T3D2, ELSET=Line42
2457, 20, 215
2458, 215, 216
2459, 216, 24
*ELEMENT, type=T3D2, ELSET=Line43
2460, 24, 217
2461, 217, 218
2462, 218, 219
2463, 219, 220
2464, 220, 23
*ELEMENT, type=T3D2, ELSET=Line44
2465, 22, 221
2466, 221, 222
2467, 222, 223
2468, 223, 224
2469, 224, 24
*ELEMENT, type=T3D2, ELSET=Line45
2470, 19, 225
2471, 225, 226
2472, 226, 227
2473, 227, 228
2474, 228, 25
*ELEMENT, type=T3D2, ELSET=Line46
2475, 23, 229
2476, 229, 230
2477, 230, 231
2478, 231, 232
2479, 232, 26
*ELEMENT, type=T3D2, ELSET=Line47
2480, 25, 233
2481, 233, 234
2482, 234, 26
*ELEMENT, type=T3D2, ELSET=Line48
2483, 17, 235
2484, 235, 236
2485, 236, 237
2486, 237, 238
2487, 238, 27
*ELEMENT, type=T3D2, ELSET=Line49
2488, 21, 239
2489, 239, 240
2490, 240, 241
2491, 241, 242
2492, 242, 28
*ELEMENT, type=T3D2, ELSET=Line50
2493, 27, 243
2494, 243, 244
2495, 244, 28
*ELEMENT, type=T3D2, ELSET=Line51
2496, 27, 245
2497, 245, 246
2498, 246, 247
2499, 247, 248
2500, 248, 25
*ELEMENT, type=T3D2, ELSET=Line52
2501, 28, 249
2502, 249, 250
2503, 250, 251
2504, 251, 252
2505, 252, 26
*ELEMENT, type=T3D2, ELSET=Line53
2506, 25, 253
2507, 253, 254
2508, 254, 255
2509, 255, 256
2510, 256, 29
*ELEMENT, type=T3D2, ELSET=Line54
2511, 26, 257
2512, 257, 258
2513, 258, 259
2514, 259, 260
2515, 260, 30
*ELEMENT, type=T3D2, ELSET=Line55
2516, 29, 261
2517, 261, 262
2518, 262, 30
*ELEMENT, type=T3D2, ELSET=Line56
2519, 27, 263
2520, 263, 264
2521, 264, 265
2522, 265, 266
2523, 266, 31
*ELEMENT, type=T3D2, ELSET=Line57
2524, 28, 267
2525, 267, 268
2526, 268, 269
2527, 269, 270
2528, 270, 32
*ELEMENT, type=T3D2, ELSET=Line58
2529, 31, 271
2530, 271, 272
2531, 272, 32
*ELEMENT, type=T3D2, ELSET=Line59
2532, 31, 273
2533, 273, 274
2534, 274, 275
2535, 275, 276
2536, 276, 29
*ELEMENT, type=T3D2, ELSET=Line60
2537, 32, 277
2538, 277, 278
2539, 278, 279
2540, 279, 280
2541, 280, 30
*ELEMENT, type=T3D2, ELSET=Line61
2542, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
2543, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
2544, 33, 281
2545, 281, 282
2546, 282, 283
2547, 283, 284
2548, 284, 34
*ELEMENT, type=T3D2, ELSET=Line64
2549, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
2550, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
2551, 35, 285
2552, 285, 286
2553, 286, 287
2554, 287, 288
2555, 288, 36
*ELEMENT, type=T3D2, ELSET=Line67
2556, 35, 289
2557, 289, 290
2558, 290, 291
2559, 291, 292
2560, 292, 33
*ELEMENT, type=T3D2, ELSET=Line68
2561, 36, 293
2562, 293, 294
2563, 294, 295
2564, 295, 296
2565, 296, 34
*ELEMENT, type=T3D2, ELSET=Line69
2566, 33, 297
2567, 297, 298
2568, 298, 299
2569, 299, 300
2570, 300, 37
*ELEMENT, type=T3D2, ELSET=Line70
2571, 34, 301
2572, 301, 302
2573, 302, 303
2574, 303, 304
2575, 304, 38
*ELEMENT, type=T3D2, ELSET=Line71
2576, 37, 305
2577, 305, 306
2578, 306, 307
2579, 307, 308
2580, 308, 38
*ELEMENT, type=T3D2, ELSET=Line72
2581, 35, 309
2582, 309, 310
2583, 310, 311
2584, 311, 312
2585, 312, 39
*ELEMENT, type=T3D2, ELSET=Line73
2586, 36, 313
2587, 313, 314
2588, 314, 315
2589, 315, 316
2590, 316, 40
*ELEMENT, type=T3D2, ELSET=Line74
2591, 39, 317
2592, 317, 318
2593, 318, 319
2594, 319, 320
2595, 320, 40
*ELEMENT, type=T3D2, ELSET=Line75
2596, 39, 321
2597, 321, 322
2598, 322, 323
2599, 323, 324
2600, 324, 37
*ELEMENT, type=T3D2, ELSET=Line76
2601, 40, 325
2602, 325, 326
2603, 326, 327
2604, 327, 328
2605, 328, 38
*ELEMENT, type=T3D2, ELSET=Line77
2606, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
2607, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
2608, 41, 329
2609, 329, 330
2610, 330, 331
2611, 331, 332
2612, 332, 42
*ELEMENT, type=T3D2, ELSET=Line80
2613, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
2614, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
2615, 43, 333
2616, 333, 334
2617, 334, 335
2618, 335, 336
2619, 336, 44
*ELEMENT, type=T3D2, ELSET=Line83
2620, 43, 337
2621, 337, 338
2622, 338, 339
2623, 339, 340
2624, 340, 41
*ELEMENT, type=T3D2, ELSET=Line84
2625, 44, 341
2626, 341, 342
2627, 342, 343
2628, 343, 344
2629, 344, 42
*ELEMENT, type=T3D2, ELSET=Line85
2630, 41, 345
2631, 345, 346
2632, 346, 45
*ELEMENT, type=T3D2, ELSET=Line86
2633, 42, 347
2634, 347, 348
2635, 348, 46
*ELEMENT, type=T3D2, ELSET=Line87
2636, 45, 349
2637, 349, 350
2638, 350, 351
2639, 351, 352
2640, 352, 46
*ELEMENT, type=T3D2, ELSET=Line88
2641, 43, 353
2642, 353, 354
2643, 354, 47
*ELEMENT, type=T3D2, ELSET=Line89
2644, 44, 355
2645, 355, 356
2646, 356, 48
*ELEMENT, type=T3D2, ELSET=Line90
2647, 47, 357
2648, 357, 358
2649, 358, 359
2650, 359, 360
2651, 360, 48
*ELEMENT, type=T3D2, ELSET=Line91
2652, 47, 361
2653, 361, 362
2654, 362, 363
2655, 363, 364
2656, 364, 45
*ELEMENT, type=T3D2, ELSET=Line92
2657, 48, 365
2658, 365, 366
2659, 366, 367
2660, 367, 368
2661, 368, 46
*ELEMENT, type=T3D2, ELSET=Line93
2662, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
2663, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
2664, 49, 369
2665, 369, 370
2666, 370, 50
*ELEMENT, type=T3D2, ELSET=Line96
2667, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
2668, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
2669, 51, 371
2670, 371, 372
2671, 372, 52
*ELEMENT, type=T3D2, ELSET=Line99
2672, 51, 373
2673, 373, 374
2674, 374, 375
2675, 375, 376
2676, 376, 49
*ELEMENT, type=T3D2, ELSET=Line100
2677, 52, 377
2678, 377, 378
2679, 378, 379
2680, 379, 380
2681, 380, 50
*ELEMENT, type=T3D2, ELSET=Line101
2682, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
2683, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
2684, 54, 381
2685, 381, 382
2686, 382, 383
2687, 383, 384
2688, 384, 53
*ELEMENT, type=T3D2, ELSET=Line104
2689, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
2690, 53, 385
2691, 385, 386
2692, 386, 55
*ELEMENT, type=T3D2, ELSET=Line106
2693, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
2694, 56, 387
2695, 387, 388
2696, 388, 389
2697, 389, 390
2698, 390, 55
*ELEMENT, type=T3D2, ELSET=Line108
2699, 54, 391
2700, 391, 392
2701, 392, 56
*ELEMENT, type=T3D2, ELSET=Line125
2702, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
2703, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
2704, 57, 393
2705, 393, 394
2706, 394, 395
2707, 395, 396
2708, 396, 58
*ELEMENT, type=T3D2, ELSET=Line128
2709, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
2710, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
2711, 59, 397
2712, 397, 398
2713, 398, 399
2714, 399, 400
2715, 400, 60
*ELEMENT, type=T3D2, ELSET=Line131
2716, 59, 401
2717, 401, 402
2718, 402, 403
2719, 403, 404
2720, 404, 57
*ELEMENT, type=T3D2, ELSET=Line132
2721, 60, 405
2722, 405, 406
2723, 406, 407
2724, 407, 408
2725, 408, 58
*ELEMENT, type=T3D2, ELSET=Line133
2726, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
2727, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
2728, 61, 409
2729, 409, 410
2730, 410, 411
2731, 411, 412
2732, 412, 62
*ELEMENT, type=T3D2, ELSET=Line136
2733, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
2734, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
2735, 63, 413
2736, 413, 414
2737, 414, 415
2738, 415, 416
2739, 416, 64
*ELEMENT, type=T3D2, ELSET=Line139
2740, 63, 417
2741, 417, 418
2742, 418, 419
2743, 419, 420
2744, 420, 61
*ELEMENT, type=T3D2, ELSET=Line140
2745, 64, 421
2746, 421, 422
2747, 422, 423
2748, 423, 424
2749, 424, 62
*ELEMENT, type=T3D2, ELSET=Line141
2750, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
2751, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
2752, 65, 425
2753, 425, 426
2754, 426, 427
2755, 427, 428
2756, 428, 66
*ELEMENT, type=T3D2, ELSET=Line144
2757, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
2758, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
2759, 67, 429
2760, 429, 430
2761, 430, 431
2762, 431, 432
2763, 432, 68
*ELEMENT, type=T3D2, ELSET=Line147
2764, 67, 433
2765, 433, 434
2766, 434, 435
2767, 435, 436
2768, 436, 65
*ELEMENT, type=T3D2, ELSET=Line148
2769, 68, 437
2770, 437, 438
2771, 438, 439
2772, 439, 440
2773, 440, 66
*ELEMENT, type=T3D2, ELSET=Line149
2774, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
2775, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
2776, 69, 441
2777, 441, 442
2778, 442, 443
2779, 443, 444
2780, 444, 70
*ELEMENT, type=T3D2, ELSET=Line152
2781, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
2782, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
2783, 71, 445
2784, 445, 446
2785, 446, 447
2786, 447, 448
2787, 448, 72
*ELEMENT, type=T3D2, ELSET=Line155
2788, 69, 449
2789, 449, 450
2790, 450, 451
2791, 451, 452
2792, 452, 71
*ELEMENT, type=T3D2, ELSET=Line156
2793, 70, 453
2794, 453, 454
2795, 454, 455
2796, 455, 456
2797, 456, 72
*ELEMENT, type=T3D2, ELSET=Line157
2798, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
2799, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
2800, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
2801, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
2802, 73, 457
2803, 457, 458
2804, 458, 459
2805, 459, 460
2806, 460, 74
*ELEMENT, type=T3D2, ELSET=Line162
2807, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
2808, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
2809, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
2810, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
2811, 75, 461
2812, 461, 462
2813, 462, 463
2814, 463, 464
2815, 464, 76
*ELEMENT, type=T3D2, ELSET=Line167
2816, 21, 465
2817, 465, 466
2818, 466, 467
2819, 467, 468
2820, 468, 77
*ELEMENT, type=T3D2, ELSET=Line168
2821, 22, 469
2822, 469, 470
2823, 470, 471
2824, 471, 472
2825, 472, 78
*ELEMENT, type=T3D2, ELSET=Line169
2826, 78, 473
2827, 473, 474
2828, 474, 475
2829, 475, 476
2830, 476, 77
*ELEMENT, type=T3D2, ELSET=Line170
2831, 23, 477
2832, 477, 478
2833, 478, 479
2834, 479, 480
2835, 480, 79
*ELEMENT, type=T3D2, ELSET=Line171
2836, 77, 481
2837, 481, 482
2838, 482, 483
2839, 483, 484
2840, 484, 79
*ELEMENT, type=T3D2, ELSET=Line172
2841, 24, 485
2842, 485, 486
2843, 486, 487
2844, 487, 488
2845, 488, 80
*ELEMENT, type=T3D2, ELSET=Line173
2846, 80, 489
2847, 489, 490
2848, 490, 491
2849, 491, 492
2850, 492, 79
*ELEMENT, type=T3D2, ELSET=Line174
2851, 78, 493
2852, 493, 494
2853, 494, 495
2854, 495, 496
2855, 496, 80
*ELEMENT, type=T3D2, ELSET=Line175
2856, 26, 497
2857, 497, 498
2858, 498, 499
2859, 499, 500
2860, 500, 81
*ELEMENT, type=T3D2, ELSET=Line176
2861, 79, 501
2862, 501, 502
2863, 502, 503
2864, 503, 504
2865, 504, 81
*ELEMENT, type=T3D2, ELSET=Line177
2866, 28, 505
2867, 505, 506
2868, 506, 507
2869, 507, 508
2870, 508, 82
*ELEMENT, type=T3D2, ELSET=Line178
2871, 77, 509
2872, 509, 510
2873, 510, 511
2874, 511, 512
2875, 512, 82
*ELEMENT, type=T3D2, ELSET=Line179
2876, 82, 513
2877, 513, 514
2878, 514, 515
2879, 515, 516
2880, 516, 81
*ELEMENT, type=T3D2, ELSET=Line180
2881, 30, 517
2882, 517, 518
2883, 518, 519
2884, 519, 520
2885, 520, 83
*ELEMENT, type=T3D2, ELSET=Line181
2886, 81, 521
2887, 521, 522
2888, 522, 523
2889, 523, 524
2890, 524, 83
*ELEMENT, type=T3D2, ELSET=Line182
2891, 32, 525
2892, 525, 526
2893, 526, 527
2894, 527, 528
2895, 528, 84
*ELEMENT, type=T3D2, ELSET=Line183
2896, 82, 529
2897, 529, 530
2898, 530, 531
2899, 531, 532
2900, 532, 84
*ELEMENT, type=T3D2, ELSET=Line184
2901, 84, 533
2902, 533, 534
2903, 534, 535
2904, 535, 536
2905, 536, 83
*ELEMENT, type=T3D2, ELSET=Line185
2906, 6, 537
2907, 537, 538
2908, 538, 539
2909, 539, 540
2910, 540, 85
*ELEMENT, type=T3D2, ELSET=Line186
2911, 2, 541
2912, 541, 542
2913, 542, 543
2914, 543, 544
2915, 544, 86
*ELEMENT, type=T3D2, ELSET=Line187
2916, 86, 545
2917, 545, 546
2918, 546, 547
2919, 547, 548
2920, 548, 85
*ELEMENT, type=T3D2, ELSET=Line188
2921, 5, 549
2922, 549, 550
2923, 550, 551
2924, 551, 552
2925, 552, 87
*ELEMENT, type=T3D2, ELSET=Line189
2926, 85, 553
2927, 553, 554
2928, 554, 555
2929, 555, 556
2930, 556, 87
*ELEMENT, type=T3D2, ELSET=Line190
2931, 1, 557
2932, 557, 558
2933, 558, 559
2934, 559, 560
2935, 560, 88
*ELEMENT, type=T3D2, ELSET=Line191
2936, 88, 561
2937, 561, 562
2938, 562, 563
2939, 563, 564
2940, 564, 87
*ELEMENT, type=T3D2, ELSET=Line192
2941, 86, 565
2942, 565, 566
2943, 566, 567
2944, 567, 568
2945, 568, 88
*ELEMENT, type=T3D2, ELSET=Line193
2946, 53, 569
2947, 569, 570
2948, 570, 571
2949, 571, 572
2950, 572, 89
*ELEMENT, type=T3D2, ELSET=Line194
2951, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
2952, 54, 573
2953, 573, 574
2954, 574, 575
2955, 575, 576
2956, 576, 90
*ELEMENT, type=T3D2, ELSET=Line196
2957, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
2958, 90, 577
2959, 577, 578
2960, 578, 579
2961, 579, 580
2962, 580, 89
*ELEMENT, type=T3D2, ELSET=Line198
2963, 45, 581
2964, 581, 582
2965, 582, 583
2966, 583, 584
2967, 584, 91
*ELEMENT, type=T3D2, ELSET=Line199
2968, 46, 585
2969, 585, 586
2970, 586, 587
2971, 587, 588
2972, 588, 92
*ELEMENT, type=T3D2, ELSET=Line200
2973, 91, 589
2974, 589, 590
2975, 590, 591
2976, 591, 592
2977, 592, 92
*ELEMENT, type=T3D2, ELSET=Line201
2978, 47, 593
2979, 593, 594
2980, 594, 595
2981, 595, 596
2982, 596, 93
*ELEMENT, type=T3D2, ELSET=Line202
2983, 48, 597
2984, 597, 598
2985, 598, 599
2986, 599, 600
2987, 600, 94
*ELEMENT, type=T3D2, ELSET=Line203
2988, 93, 601
2989, 601, 602
2990, 602, 603
2991, 603, 604
2992, 604, 94
*ELEMENT, type=T3D2, ELSET=Line204
2993, 93, 605
2994, 605, 606
2995, 606, 607
2996, 607, 608
2997, 608, 91
*ELEMENT, type=T3D2, ELSET=Line205
2998, 94, 609
2999, 609, 610
3000, 610, 611
3001, 611, 612
3002, 612, 92
*ELEMENT, type=T3D2, ELSET=Line206
3003, 50, 613
3004, 613, 614
3005, 614, 615
3006, 615, 616
3007, 616, 95
*ELEMENT, type=T3D2, ELSET=Line207
3008, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
3009, 52, 617
3010, 617, 618
3011, 618, 619
3012, 619, 620
3013, 620, 96
*ELEMENT, type=T3D2, ELSET=Line209
3014, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
3015, 96, 621
3016, 621, 622
3017, 622, 623
3018, 623, 624
3019, 624, 95
*ELEMENT, type=CPS4, ELSET=Surface1
3020, 2, 97, 625, 107
3021, 107, 625, 626, 108
3022, 108, 626, 103, 4
3023, 97, 98, 627, 625
3024, 625, 627, 628, 626
3025, 626, 628, 104, 103
3026, 98, 99, 629, 627
3027, 627, 629, 630, 628
3028, 628, 630, 105, 104
3029, 99, 100, 631, 629
3030, 629, 631, 632, 630
3031, 630, 632, 106, 105
3032, 100, 1, 101, 631
3033, 631, 101, 102, 632
3034, 632, 102, 3, 106
*ELEMENT, type=CPS4, ELSET=Surface2
3035, 6, 119, 633, 109
3036, 119, 120, 634, 633
3037, 120, 8, 115, 634
3038, 109, 633, 635, 110
3039, 633, 634, 636, 635
3040, 634, 115, 116, 636
3041, 110, 635, 637, 111
3042, 635, 636, 638, 637
3043, 636, 116, 117, 638
3044, 111, 637, 639, 112
3045, 637, 638, 640, 639
3046, 638, 117, 118, 640
3047, 112, 639, 113, 5
3048, 639, 640, 114, 113
3049, 640, 118, 7, 114
*ELEMENT, type=CPS4, ELSET=Surface3
1, 2, 121, 641, 97
2, 97, 641, 642, 98
3, 98, 642, 643, 99
4, 99, 643, 644, 100
5, 100, 644, 125, 1
6, 121, 122, 645, 641
7, 641, 645, 646, 642
8, 642, 646, 647, 643
9, 643, 647, 648, 644
10, 644, 648, 126, 125
11, 122, 123, 649, 645
12, 645, 649, 650, 646
13, 646, 650, 651, 647
14, 647, 651, 652, 648
15, 648, 652, 127, 126
16, 123, 124, 653, 649
17, 649, 653, 654, 650
18, 650, 654, 655, 651
19, 651, 655, 656, 652
20, 652, 656, 128, 127
21, 124, 6, 109, 653
22, 653, 109, 110, 654
23, 654, 110, 111, 655
24, 655, 111, 112, 656
25, 656, 112, 5, 128
*ELEMENT, type=CPS4, ELSET=Surface4
3050, 4, 103, 657, 129
3051, 103, 104, 658, 657
3052, 104, 105, 659, 658
3053, 105, 106, 660, 659
3054, 106, 3, 133, 660
3055, 129, 657, 661, 130
3056, 657, 658, 662, 661
3057, 658, 659, 663, 662
3058, 659, 660, 664, 663
3059, 660, 133, 134, 664
3060, 130, 661, 665, 131
3061, 661, 662, 666, 665
3062, 662, 663, 667, 666
3063, 663, 664, 668, 667
3064, 664, 134, 135, 668
3065, 131, 665, 669, 132
3066, 665, 666, 670, 669
3067, 666, 667, 671, 670
3068, 667, 668, 672, 671
3069, 668, 135, 136, 672
3070, 132, 669, 115, 8
3071, 669, 670, 116, 115
3072, 670, 671, 117, 116
3073, 671, 672, 118, 117
3074, 672, 136, 7, 118
*ELEMENT, type=CPS4, ELSET=Surface5
3075, 2, 107, 673, 121
3076, 121, 673, 674, 122
3077, 122, 674, 675, 123
3078, 123, 675, 676, 124
3079, 124, 676, 119, 6
3080, 107, 108, 677, 673
3081, 673, 677, 678, 674
3082, 674, 678, 679, 675
3083, 675, 679, 680, 676
3084, 676, 680, 120, 119
3085, 108, 4, 129, 677
3086, 677, 129, 130, 678
3087, 678, 130, 131, 679
3088, 679, 131, 132, 680
3089, 680, 132, 8, 120
*ELEMENT, type=CPS4, ELSET=Surface6
26, 1, 125, 681, 101
27, 125, 126, 682, 681
28, 126, 127, 683, 682
29, 127, 128, 684, 683
30, 128, 5, 113, 684
31, 101, 681, 685, 102
32, 681, 682, 686, 685
33, 682, 683, 687, 686
34, 683, 684, 688, 687
35, 684, 113, 114, 688
36, 102, 685, 133, 3
37, 685, 686, 134, 133
38, 686, 687, 135, 134
39, 687, 688, 136, 135
40, 688, 114, 7, 136
*ELEMENT, type=CPS4, ELSET=Surface7
3090, 4, 10, 137, 129
3091, 129, 137, 138, 130
3092, 130, 138, 139, 131
3093, 131, 139, 140, 132
3094, 132, 140, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
3095, 8, 9, 141, 115
3096, 115, 141, 142, 116
3097, 116, 142, 143, 117
3098, 117, 143, 144, 118
3099, 118, 144, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
41, 3, 133, 145, 12
42, 133, 134, 146, 145
43, 134, 135, 147, 146
44, 135, 136, 148, 147
45, 136, 7, 11, 148
*ELEMENT, type=CPS4, ELSET=Surface10
3100, 4, 103, 149, 10
3101, 103, 104, 150, 149
3102, 104, 105, 151, 150
3103, 105, 106, 152, 151
3104, 106, 3, 12, 152
*ELEMENT, type=CPS4, ELSET=Surface11
3105, 10, 149, 689, 137
3106, 149, 150, 690, 689
3107, 150, 151, 691, 690
3108, 151, 152, 692, 691
3109, 152, 12, 145, 692
3110, 137, 689, 693, 138
3111, 689, 690, 694, 693
3112, 690, 691, 695, 694
3113, 691, 692, 696, 695
3114, 692, 145, 146, 696
3115, 138, 693, 697, 139
3116, 693, 694, 698, 697
3117, 694, 695, 699, 698
3118, 695, 696, 700, 699
3119, 696, 146, 147, 700
3120, 139, 697, 701, 140
3121, 697, 698, 702, 701
3122, 698, 699, 703, 702
3123, 699, 700, 704, 703
3124, 700, 147, 148, 704
3125, 140, 701, 141, 9
3126, 701, 702, 142, 141
3127, 702, 703, 143, 142
3128, 703, 704, 144, 143
3129, 704, 148, 11, 144
*ELEMENT, type=CPS4, ELSET=Surface12
3130, 10, 157, 705, 137
3131, 157, 158, 706, 705
3132, 158, 159, 707, 706
3133, 159, 160, 708, 707
3134, 160, 14, 161, 708
3135, 137, 705, 709, 138
3136, 705, 706, 710, 709
3137, 706, 707, 711, 710
3138, 707, 708, 712, 711
3139, 708, 161, 162, 712
3140, 138, 709, 713, 139
3141, 709, 710, 714, 713
3142, 710, 711, 715, 714
3143, 711, 712, 716, 715
3144, 712, 162, 163, 716
3145, 139, 713, 717, 140
3146, 713, 714, 718, 717
3147, 714, 715, 719, 718
3148, 715, 716, 720, 719
3149, 716, 163, 164, 720
3150, 140, 717, 153, 9
3151, 717, 718, 154, 153
3152, 718, 719, 155, 154
3153, 719, 720, 156, 155
3154, 720, 164, 13, 156
*ELEMENT, type=CPS4, ELSET=Surface13
3155, 9, 153, 721, 141
3156, 153, 154, 722, 721
3157, 154, 155, 723, 722
3158, 155, 156, 724, 723
3159, 156, 13, 169, 724
3160, 141, 721, 725, 142
3161, 721, 722, 726, 725
3162, 722, 723, 727, 726
3163, 723, 724, 728, 727
3164, 724, 169, 170, 728
3165, 142, 725, 729, 143
3166, 725, 726, 730, 729
3167, 726, 727, 731, 730
3168, 727, 728, 732, 731
3169, 728, 170, 171, 732
3170, 143, 729, 733, 144
3171, 729, 730, 734, 733
3172, 730, 731, 735, 734
3173, 731, 732, 736, 735
3174, 732, 171, 172, 736
3175, 144, 733, 165, 11
3176, 733, 734, 166, 165
3177, 734, 735, 167, 166
3178, 735, 736, 168, 167
3179, 736, 172, 15, 168
*ELEMENT, type=CPS4, ELSET=Surface14
46, 12, 145, 737, 173
47, 173, 737, 738, 174
48, 174, 738, 739, 175
49, 175, 739, 740, 176
50, 176, 740, 177, 16
51, 145, 146, 741, 737
52, 737, 741, 742, 738
53, 738, 742, 743, 739
54, 739, 743, 744, 740
55, 740, 744, 178, 177
56, 146, 147, 745, 741
57, 741, 745, 746, 742
58, 742, 746, 747, 743
59, 743, 747, 748, 744
60, 744, 748, 179, 178
61, 147, 148, 749, 745
62, 745, 749, 750, 746
63, 746, 750, 751, 747
64, 747, 751, 752, 748
65, 748, 752, 180, 179
66, 148, 11, 165, 749
67, 749, 165, 166, 750
68, 750, 166, 167, 751
69, 751, 167, 168, 752
70, 752, 168, 15, 180
*ELEMENT, type=CPS4, ELSET=Surface15
3180, 10, 149, 753, 157
3181, 157, 753, 754, 158
3182, 158, 754, 755, 159
3183, 159, 755, 756, 160
3184, 160, 756, 181, 14
3185, 149, 150, 757, 753
3186, 753, 757, 758, 754
3187, 754, 758, 759, 755
3188, 755, 759, 760, 756
3189, 756, 760, 182, 181
3190, 150, 151, 761, 757
3191, 757, 761, 762, 758
3192, 758, 762, 763, 759
3193, 759, 763, 764, 760
3194, 760, 764, 183, 182
3195, 151, 152, 765, 761
3196, 761, 765, 766, 762
3197, 762, 766, 767, 763
3198, 763, 767, 768, 764
3199, 764, 768, 184, 183
3200, 152, 12, 173, 765
3201, 765, 173, 174, 766
3202, 766, 174, 175, 767
3203, 767, 175, 176, 768
3204, 768, 176, 16, 184
*ELEMENT, type=CPS4, ELSET=Surface16
71, 14, 181, 769, 161
72, 181, 182, 770, 769
73, 182, 183, 771, 770
74, 183, 184, 772, 771
75, 184, 16, 177, 772
76, 161, 769, 773, 162
77, 769, 770, 774, 773
78, 770, 771, 775, 774
79, 771, 772, 776, 775
80, 772, 177, 178, 776
81, 162, 773, 777, 163
82, 773, 774, 778, 777
83, 774, 775, 779, 778
84, 775, 776, 780, 779
85, 776, 178, 179, 780
86, 163, 777, 781, 164
87, 777, 778, 782, 781
88, 778, 779, 783, 782
89, 779, 780, 784, 783
90, 780, 179, 180, 784
91, 164, 781, 169, 13
92, 781, 782, 170, 169
93, 782, 783, 171, 170
94, 783, 784, 172, 171
95, 784, 180, 15, 172
*ELEMENT, type=CPS4, ELSET=Surface17
3205, 14, 18, 185, 161
3206, 161, 185, 186, 162
3207, 162, 186, 187, 163
3208, 163, 187, 188, 164
3209, 164, 188, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
3210, 13, 17, 189, 169
3211, 169, 189, 190, 170
3212, 170, 190, 191, 171
3213, 171, 191, 192, 172
3214, 172, 192, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
96, 16, 177, 193, 20
97, 177, 178, 194, 193
98, 178, 179, 195, 194
99, 179, 180, 196, 195
100, 180, 15, 19, 196
*ELEMENT, type=CPS4, ELSET=Surface20
3215, 14, 181, 197, 18
3216, 181, 182, 198, 197
3217, 182, 183, 199, 198
3218, 183, 184, 200, 199
3219, 184, 16, 20, 200
*ELEMENT, type=CPS4, ELSET=Surface21
3220, 18, 197, 785, 185
3221, 197, 198, 786, 785
3222, 198, 199, 787, 786
3223, 199, 200, 788, 787
3224, 200, 20, 193, 788
3225, 185, 785, 789, 186
3226, 785, 786, 790, 789
3227, 786, 787, 791, 790
3228, 787, 788, 792, 791
3229, 788, 193, 194, 792
3230, 186, 789, 793, 187
3231, 789, 790, 794, 793
3232, 790, 791, 795, 794
3233, 791, 792, 796, 795
3234, 792, 194, 195, 796
3235, 187, 793, 797, 188
3236, 793, 794, 798, 797
3237, 794, 795, 799, 798
3238, 795, 796, 800, 799
3239, 796, 195, 196, 800
3240, 188, 797, 189, 17
3241, 797, 798, 190, 189
3242, 798, 799, 191, 190
3243, 799, 800, 192, 191
3244, 800, 196, 19, 192
*ELEMENT, type=CPS4, ELSET=Surface22
3245, 18, 203, 801, 185
3246, 203, 204, 802, 801
3247, 204, 22, 205, 802
3248, 185, 801, 803, 186
3249, 801, 802, 804, 803
3250, 802, 205, 206, 804
3251, 186, 803, 805, 187
3252, 803, 804, 806, 805
3253, 804, 206, 207, 806
3254, 187, 805, 807, 188
3255, 805, 806, 808, 807
3256, 806, 207, 208, 808
3257, 188, 807, 201, 17
3258, 807, 808, 202, 201
3259, 808, 208, 21, 202
*ELEMENT, type=CPS4, ELSET=Surface23
3260, 17, 201, 809, 189
3261, 201, 202, 810, 809
3262, 202, 21, 211, 810
3263, 189, 809, 811, 190
3264, 809, 810, 812, 811
3265, 810, 211, 212, 812
3266, 190, 811, 813, 191
3267, 811, 812, 814, 813
3268, 812, 212, 213, 814
3269, 191, 813, 815, 192
3270, 813, 814, 816, 815
3271, 814, 213, 214, 816
3272, 192, 815, 209, 19
3273, 815, 816, 210, 209
3274, 816, 214, 23, 210
*ELEMENT, type=CPS4, ELSET=Surface24
101, 20, 193, 817, 215
102, 215, 817, 818, 216
103, 216, 818, 217, 24
104, 193, 194, 819, 817
105, 817, 819, 820, 818
106, 818, 820, 218, 217
107, 194, 195, 821, 819
108, 819, 821, 822, 820
109, 820, 822, 219, 218
110, 195, 196, 823, 821
111, 821, 823, 824, 822
112, 822, 824, 220, 219
113, 196, 19, 209, 823
114, 823, 209, 210, 824
115, 824, 210, 23, 220
*ELEMENT, type=CPS4, ELSET=Surface25
116, 18, 197, 825, 203
117, 203, 825, 826, 204
118, 204, 826, 221, 22
119, 197, 198, 827, 825
120, 825, 827, 828, 826
121, 826, 828, 222, 221
122, 198, 199, 829, 827
123, 827, 829, 830, 828
124, 828, 830, 223, 222
125, 199, 200, 831, 829
126, 829, 831, 832, 830
127, 830, 832, 224, 223
128, 200, 20, 215, 831
129, 831, 215, 216, 832
130, 832, 216, 24, 224
*ELEMENT, type=CPS4, ELSET=Surface26
131, 22, 221, 833, 205
132, 221, 222, 834, 833
133, 222, 223, 835, 834
134, 223, 224, 836, 835
135, 224, 24, 217, 836
136, 205, 833, 837, 206
137, 833, 834, 838, 837
138, 834, 835, 839, 838
139, 835, 836, 840, 839
140, 836, 217, 218, 840
141, 206, 837, 841, 207
142, 837, 838, 842, 841
143, 838, 839, 843, 842
144, 839, 840, 844, 843
145, 840, 218, 219, 844
146, 207, 841, 845, 208
147, 841, 842, 846, 845
148, 842, 843, 847, 846
149, 843, 844, 848, 847
150, 844, 219, 220, 848
151, 208, 845, 211, 21
152, 845, 846, 212, 211
153, 846, 847, 213, 212
154, 847, 848, 214, 213
155, 848, 220, 23, 214
*ELEMENT, type=CPS4, ELSET=Surface27
156, 19, 225, 849, 209
157, 225, 226, 850, 849
158, 226, 227, 851, 850
159, 227, 228, 852, 851
160, 228, 25, 233, 852
161, 209, 849, 853, 210
162, 849, 850, 854, 853
163, 850, 851, 855, 854
164, 851, 852, 856, 855
165, 852, 233, 234, 856
166, 210, 853, 229, 23
167, 853, 854, 230, 229
168, 854, 855, 231, 230
169, 855, 856, 232, 231
170, 856, 234, 26, 232
*ELEMENT, type=CPS4, ELSET=Surface28
3275, 17, 201, 857, 235
3276, 235, 857, 858, 236
3277, 236, 858, 859, 237
3278, 237, 859, 860, 238
3279, 238, 860, 243, 27
3280, 201, 202, 861, 857
3281, 857, 861, 862, 858
3282, 858, 862, 863, 859
3283, 859, 863, 864, 860
3284, 860, 864, 244, 243
3285, 202, 21, 239, 861
3286, 861, 239, 240, 862
3287, 862, 240, 241, 863
3288, 863, 241, 242, 864
3289, 864, 242, 28, 244
*ELEMENT, type=CPS4, ELSET=Surface29
3290, 17, 235, 865, 189
3291, 235, 236, 866, 865
3292, 236, 237, 867, 866
3293, 237, 238, 868, 867
3294, 238, 27, 245, 868
3295, 189, 865, 869, 190
3296, 865, 866, 870, 869
3297, 866, 867, 871, 870
3298, 867, 868, 872, 871
3299, 868, 245, 246, 872
3300, 190, 869, 873, 191
3301, 869, 870, 874, 873
3302, 870, 871, 875, 874
3303, 871, 872, 876, 875
3304, 872, 246, 247, 876
3305, 191, 873, 877, 192
3306, 873, 874, 878, 877
3307, 874, 875, 879, 878
3308, 875, 876, 880, 879
3309, 876, 247, 248, 880
3310, 192, 877, 225, 19
3311, 877, 878, 226, 225
3312, 878, 879, 227, 226
3313, 879, 880, 228, 227
3314, 880, 248, 25, 228
*ELEMENT, type=CPS4, ELSET=Surface30
171, 21, 211, 881, 239
172, 239, 881, 882, 240
173, 240, 882, 883, 241
174, 241, 883, 884, 242
175, 242, 884, 249, 28
176, 211, 212, 885, 881
177, 881, 885, 886, 882
178, 882, 886, 887, 883
179, 883, 887, 888, 884
180, 884, 888, 250, 249
181, 212, 213, 889, 885
182, 885, 889, 890, 886
183, 886, 890, 891, 887
184, 887, 891, 892, 888
185, 888, 892, 251, 250
186, 213, 214, 893, 889
187, 889, 893, 894, 890
188, 890, 894, 895, 891
189, 891, 895, 896, 892
190, 892, 896, 252, 251
191, 214, 23, 229, 893
192, 893, 229, 230, 894
193, 894, 230, 231, 895
194, 895, 231, 232, 896
195, 896, 232, 26, 252
*ELEMENT, type=CPS4, ELSET=Surface31
3315, 27, 243, 897, 245
3316, 243, 244, 898, 897
3317, 244, 28, 249, 898
3318, 245, 897, 899, 246
3319, 897, 898, 900, 899
3320, 898, 249, 250, 900
3321, 246, 899, 901, 247
3322, 899, 900, 902, 901
3323, 900, 250, 251, 902
3324, 247, 901, 903, 248
3325, 901, 902, 904, 903
3326, 902, 251, 252, 904
3327, 248, 903, 233, 25
3328, 903, 904, 234, 233
3329, 904, 252, 26, 234
*ELEMENT, type=CPS4, ELSET=Surface32
196, 25, 253, 905, 233
197, 253, 254, 906, 905
198, 254, 255, 907, 906
199, 255, 256, 908, 907
200, 256, 29, 261, 908
201, 233, 905, 909, 234
202, 905, 906, 910, 909
203, 906, 907, 911, 910
204, 907, 908, 912, 911
205, 908, 261, 262, 912
206, 234, 909, 257, 26
207, 909, 910, 258, 257
208, 910, 911, 259, 258
209, 911, 912, 260, 259
210, 912, 262, 30, 260
*ELEMENT, type=CPS4, ELSET=Surface33
3330, 27, 243, 913, 263
3331, 263, 913, 914, 264
3332, 264, 914, 915, 265
3333, 265, 915, 916, 266
3334, 266, 916, 271, 31
3335, 243, 244, 917, 913
3336, 913, 917, 918, 914
3337, 914, 918, 919, 915
3338, 915, 919, 920, 916
3339, 916, 920, 272, 271
3340, 244, 28, 267, 917
3341, 917, 267, 268, 918
3342, 918, 268, 269, 919
3343, 919, 269, 270, 920
3344, 920, 270, 32, 272
*ELEMENT, type=CPS4, ELSET=Surface34
3345, 27, 263, 921, 245
3346, 263, 264, 922, 921
3347, 264, 265, 923, 922
3348, 265, 266, 924, 923
3349, 266, 31, 273, 924
3350, 245, 921, 925, 246
3351, 921, 922, 926, 925
3352, 922, 923, 927, 926
3353, 923, 924, 928, 927
3354, 924, 273, 274, 928
3355, 246, 925, 929, 247
3356, 925, 926, 930, 929
3357, 926, 927, 931, 930
3358, 927, 928, 932, 931
3359, 928, 274, 275, 932
3360, 247, 929, 933, 248
3361, 929, 930, 934, 933
3362, 930, 931, 935, 934
3363, 931, 932, 936, 935
3364, 932, 275, 276, 936
3365, 248, 933, 253, 25
3366, 933, 934, 254, 253
3367, 934, 935, 255, 254
3368, 935, 936, 256, 255
3369, 936, 276, 29, 256
*ELEMENT, type=CPS4, ELSET=Surface35
211, 28, 249, 937, 267
212, 267, 937, 938, 268
213, 268, 938, 939, 269
214, 269, 939, 940, 270
215, 270, 940, 277, 32
216, 249, 250, 941, 937
217, 937, 941, 942, 938
218, 938, 942, 943, 939
219, 939, 943, 944, 940
220, 940, 944, 278, 277
221, 250, 251, 945, 941
222, 941, 945, 946, 942
223, 942, 946, 947, 943
224, 943, 947, 948, 944
225, 944, 948, 279, 278
226, 251, 252, 949, 945
227, 945, 949, 950, 946
228, 946, 950, 951, 947
229, 947, 951, 952, 948
230, 948, 952, 280, 279
231, 252, 26, 257, 949
232, 949, 257, 258, 950
233, 950, 258, 259, 951
234, 951, 259, 260, 952
235, 952, 260, 30, 280
*ELEMENT, type=CPS4, ELSET=Surface36
3370, 31, 271, 953, 273
3371, 271, 272, 954, 953
3372, 272, 32, 277, 954
3373, 273, 953, 955, 274
3374, 953, 954, 956, 955
3375, 954, 277, 278, 956
3376, 274, 955, 957, 275
3377, 955, 956, 958, 957
3378, 956, 278, 279, 958
3379, 275, 957, 959, 276
3380, 957, 958, 960, 959
3381, 958, 279, 280, 960
3382, 276, 959, 261, 29
3383, 959, 960, 262, 261
3384, 960, 280, 30, 262
*ELEMENT, type=CPS4, ELSET=Surface37
236, 25, 33, 281, 253
237, 253, 281, 282, 254
238, 254, 282, 283, 255
239, 255, 283, 284, 256
240, 256, 284, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
3385, 27, 263, 285, 35
3386, 263, 264, 286, 285
3387, 264, 265, 287, 286
3388, 265, 266, 288, 287
3389, 266, 31, 36, 288
*ELEMENT, type=CPS4, ELSET=Surface39
3390, 27, 35, 289, 245
3391, 245, 289, 290, 246
3392, 246, 290, 291, 247
3393, 247, 291, 292, 248
3394, 248, 292, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
3395, 31, 273, 293, 36
3396, 273, 274, 294, 293
3397, 274, 275, 295, 294
3398, 275, 276, 296, 295
3399, 276, 29, 34, 296
*ELEMENT, type=CPS4, ELSET=Surface41
241, 35, 285, 961, 289
242, 285, 286, 962, 961
243, 286, 287, 963, 962
244, 287, 288, 964, 963
245, 288, 36, 293, 964
246, 289, 961, 965, 290
247, 961, 962, 966, 965
248, 962, 963, 967, 966
249, 963, 964, 968, 967
250, 964, 293, 294, 968
251, 290, 965, 969, 291
252, 965, 966, 970, 969
253, 966, 967, 971, 970
254, 967, 968, 972, 971
255, 968, 294, 295, 972
256, 291, 969, 973, 292
257, 969, 970, 974, 973
258, 970, 971, 975, 974
259, 971, 972, 976, 975
260, 972, 295, 296, 976
261, 292, 973, 281, 33
262, 973, 974, 282, 281
263, 974, 975, 283, 282
264, 975, 976, 284, 283
265, 976, 296, 34, 284
*ELEMENT, type=CPS4, ELSET=Surface42
266, 33, 297, 977, 281
267, 297, 298, 978, 977
268, 298, 299, 979, 978
269, 299, 300, 980, 979
270, 300, 37, 305, 980
271, 281, 977, 981, 282
272, 977, 978, 982, 981
273, 978, 979, 983, 982
274, 979, 980, 984, 983
275, 980, 305, 306, 984
276, 282, 981, 985, 283
277, 981, 982, 986, 985
278, 982, 983, 987, 986
279, 983, 984, 988, 987
280, 984, 306, 307, 988
281, 283, 985, 989, 284
282, 985, 986, 990, 989
283, 986, 987, 991, 990
284, 987, 988, 992, 991
285, 988, 307, 308, 992
286, 284, 989, 301, 34
287, 989, 990, 302, 301
288, 990, 991, 303, 302
289, 991, 992, 304, 303
290, 992, 308, 38, 304
*ELEMENT, type=CPS4, ELSET=Surface43
3400, 35, 285, 993, 309
3401, 309, 993, 994, 310
3402, 310, 994, 995, 311
3403, 311, 995, 996, 312
3404, 312, 996, 317, 39
3405, 285, 286, 997, 993
3406, 993, 997, 998, 994
3407, 994, 998, 999, 995
3408, 995, 999, 1000, 996
3409, 996, 1000, 318, 317
3410, 286, 287, 1001, 997
3411, 997, 1001, 1002, 998
3412, 998, 1002, 1003, 999
3413, 999, 1003, 1004, 1000
3414, 1000, 1004, 319, 318
3415, 287, 288, 1005, 1001
3416, 1001, 1005, 1006, 1002
3417, 1002, 1006, 1007, 1003
3418, 1003, 1007, 1008, 1004
3419, 1004, 1008, 320, 319
3420, 288, 36, 313, 1005
3421, 1005, 313, 314, 1006
3422, 1006, 314, 315, 1007
3423, 1007, 315, 316, 1008
3424, 1008, 316, 40, 320
*ELEMENT, type=CPS4, ELSET=Surface44
3425, 35, 309, 1009, 289
3426, 309, 310, 1010, 1009
3427, 310, 311, 1011, 1010
3428, 311, 312, 1012, 1011
3429, 312, 39, 321, 1012
3430, 289, 1009, 1013, 290
3431, 1009, 1010, 1014, 1013
3432, 1010, 1011, 1015, 1014
3433, 1011, 1012, 1016, 1015
3434, 1012, 321, 322, 1016
3435, 290, 1013, 1017, 291
3436, 1013, 1014, 1018, 1017
3437, 1014, 1015, 1019, 1018
3438, 1015, 1016, 1020, 1019
3439, 1016, 322, 323, 1020
3440, 291, 1017, 1021, 292
3441, 1017, 1018, 1022, 1021
3442, 1018, 1019, 1023, 1022
3443, 1019, 1020, 1024, 1023
3444, 1020, 323, 324, 1024
3445, 292, 1021, 297, 33
3446, 1021, 1022, 298, 297
3447, 1022, 1023, 299, 298
3448, 1023, 1024, 300, 299
3449, 1024, 324, 37, 300
*ELEMENT, type=CPS4, ELSET=Surface45
3450, 36, 293, 1025, 313
3451, 313, 1025, 1026, 314
3452, 314, 1026, 1027, 315
3453, 315, 1027, 1028, 316
3454, 316, 1028, 325, 40
3455, 293, 294, 1029, 1025
3456, 1025, 1029, 1030, 1026
3457, 1026, 1030, 1031, 1027
3458, 1027, 1031, 1032, 1028
3459, 1028, 1032, 326, 325
3460, 294, 295, 1033, 1029
3461, 1029, 1033, 1034, 1030
3462, 1030, 1034, 1035, 1031
3463, 1031, 1035, 1036, 1032
3464, 1032, 1036, 327, 326
3465, 295, 296, 1037, 1033
3466, 1033, 1037, 1038, 1034
3467, 1034, 1038, 1039, 1035
3468, 1035, 1039, 1040, 1036
3469, 1036, 1040, 328, 327
3470, 296, 34, 301, 1037
3471, 1037, 301, 302, 1038
3472, 1038, 302, 303, 1039
3473, 1039, 303, 304, 1040
3474, 1040, 304, 38, 328
*ELEMENT, type=CPS4, ELSET=Surface46
3475, 39, 317, 1041, 321
3476, 317, 318, 1042, 1041
3477, 318, 319, 1043, 1042
3478, 319, 320, 1044, 1043
3479, 320, 40, 325, 1044
3480, 321, 1041, 1045, 322
3481, 1041, 1042, 1046, 1045
3482, 1042, 1043, 1047, 1046
3483, 1043, 1044, 1048, 1047
3484, 1044, 325, 326, 1048
3485, 322, 1045, 1049, 323
3486, 1045, 1046, 1050, 1049
3487, 1046, 1047, 1051, 1050
3488, 1047, 1048, 1052, 1051
3489, 1048, 326, 327, 1052
3490, 323, 1049, 1053, 324
3491, 1049, 1050, 1054, 1053
3492, 1050, 1051, 1055, 1054
3493, 1051, 1052, 1056, 1055
3494, 1052, 327, 328, 1056
3495, 324, 1053, 305, 37
3496, 1053, 1054, 306, 305
3497, 1054, 1055, 307, 306
3498, 1055, 1056, 308, 307
3499, 1056, 328, 38, 308
*ELEMENT, type=CPS4, ELSET=Surface47
291, 37, 41, 329, 305
292, 305, 329, 330, 306
293, 306, 330, 331, 307
294, 307, 331, 332, 308
295, 308, 332, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
3500, 39, 317, 333, 43
3501, 317, 318, 334, 333
3502, 318, 319, 335, 334
3503, 319, 320, 336, 335
3504, 320, 40, 44, 336
*ELEMENT, type=CPS4, ELSET=Surface49
3505, 39, 43, 337, 321
3506, 321, 337, 338, 322
3507, 322, 338, 339, 323
3508, 323, 339, 340, 324
3509, 324, 340, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
3510, 40, 325, 341, 44
3511, 325, 326, 342, 341
3512, 326, 327, 343, 342
3513, 327, 328, 344, 343
3514, 328, 38, 42, 344
*ELEMENT, type=CPS4, ELSET=Surface51
3515, 43, 333, 1057, 337
3516, 333, 334, 1058, 1057
3517, 334, 335, 1059, 1058
3518, 335, 336, 1060, 1059
3519, 336, 44, 341, 1060
3520, 337, 1057, 1061, 338
3521, 1057, 1058, 1062, 1061
3522, 1058, 1059, 1063, 1062
3523, 1059, 1060, 1064, 1063
3524, 1060, 341, 342, 1064
3525, 338, 1061, 1065, 339
3526, 1061, 1062, 1066, 1065
3527, 1062, 1063, 1067, 1066
3528, 1063, 1064, 1068, 1067
3529, 1064, 342, 343, 1068
3530, 339, 1065, 1069, 340
3531, 1065, 1066, 1070, 1069
3532, 1066, 1067, 1071, 1070
3533, 1067, 1068, 1072, 1071
3534, 1068, 343, 344, 1072
3535, 340, 1069, 329, 41
3536, 1069, 1070, 330, 329
3537, 1070, 1071, 331, 330
3538, 1071, 1072, 332, 331
3539, 1072, 344, 42, 332
*ELEMENT, type=CPS4, ELSET=Surface52
296, 41, 345, 1073, 329
297, 345, 346, 1074, 1073
298, 346, 45, 349, 1074
299, 329, 1073, 1075, 330
300, 1073, 1074, 1076, 1075
301, 1074, 349, 350, 1076
302, 330, 1075, 1077, 331
303, 1075, 1076, 1078, 1077
304, 1076, 350, 351, 1078
305, 331, 1077, 1079, 332
306, 1077, 1078, 1080, 1079
307, 1078, 351, 352, 1080
308, 332, 1079, 347, 42
309, 1079, 1080, 348, 347
310, 1080, 352, 46, 348
*ELEMENT, type=CPS4, ELSET=Surface53
3540, 43, 333, 1081, 353
3541, 353, 1081, 1082, 354
3542, 354, 1082, 357, 47
3543, 333, 334, 1083, 1081
3544, 1081, 1083, 1084, 1082
3545, 1082, 1084, 358, 357
3546, 334, 335, 1085, 1083
3547, 1083, 1085, 1086, 1084
3548, 1084, 1086, 359, 358
3549, 335, 336, 1087, 1085
3550, 1085, 1087, 1088, 1086
3551, 1086, 1088, 360, 359
3552, 336, 44, 355, 1087
3553, 1087, 355, 356, 1088
3554, 1088, 356, 48, 360
*ELEMENT, type=CPS4, ELSET=Surface54
3555, 43, 353, 1089, 337
3556, 353, 354, 1090, 1089
3557, 354, 47, 361, 1090
3558, 337, 1089, 1091, 338
3559, 1089, 1090, 1092, 1091
3560, 1090, 361, 362, 1092
3561, 338, 1091, 1093, 339
3562, 1091, 1092, 1094, 1093
3563, 1092, 362, 363, 1094
3564, 339, 1093, 1095, 340
3565, 1093, 1094, 1096, 1095
3566, 1094, 363, 364, 1096
3567, 340, 1095, 345, 41
3568, 1095, 1096, 346, 345
3569, 1096, 364, 45, 346
*ELEMENT, type=CPS4, ELSET=Surface55
3570, 44, 341, 1097, 355
3571, 355, 1097, 1098, 356
3572, 356, 1098, 365, 48
3573, 341, 342, 1099, 1097
3574, 1097, 1099, 1100, 1098
3575, 1098, 1100, 366, 365
3576, 342, 343, 1101, 1099
3577, 1099, 1101, 1102, 1100
3578, 1100, 1102, 367, 366
3579, 343, 344, 1103, 1101
3580, 1101, 1103, 1104, 1102
3581, 1102, 1104, 368, 367
3582, 344, 42, 347, 1103
3583, 1103, 347, 348, 1104
3584, 1104, 348, 46, 368
*ELEMENT, type=CPS4, ELSET=Surface56
311, 47, 357, 1105, 361
312, 357, 358, 1106, 1105
313, 358, 359, 1107, 1106
314, 359, 360, 1108, 1107
315, 360, 48, 365, 1108
316, 361, 1105, 1109, 362
317, 1105, 1106, 1110, 1109
318, 1106, 1107, 1111, 1110
319, 1107, 1108, 1112, 1111
320, 1108, 365, 366, 1112
321, 362, 1109, 1113, 363
322, 1109, 1110, 1114, 1113
323, 1110, 1111, 1115, 1114
324, 1111, 1112, 1116, 1115
325, 1112, 366, 367, 1116
326, 363, 1113, 1117, 364
327, 1113, 1114, 1118, 1117
328, 1114, 1115, 1119, 1118
329, 1115, 1116, 1120, 1119
330, 1116, 367, 368, 1120
331, 364, 1117, 349, 45
332, 1117, 1118, 350, 349
333, 1118, 1119, 351, 350
334, 1119, 1120, 352, 351
335, 1120, 368, 46, 352
*ELEMENT, type=CPS4, ELSET=Surface57
336, 42, 347, 369, 49
337, 347, 348, 370, 369
338, 348, 46, 50, 370
*ELEMENT, type=CPS4, ELSET=Surface58
3585, 44, 51, 371, 355
3586, 355, 371, 372, 356
3587, 356, 372, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
3588, 44, 341, 373, 51
3589, 341, 342, 374, 373
3590, 342, 343, 375, 374
3591, 343, 344, 376, 375
3592, 344, 42, 49, 376
*ELEMENT, type=CPS4, ELSET=Surface60
339, 48, 52, 377, 365
340, 365, 377, 378, 366
341, 366, 378, 379, 367
342, 367, 379, 380, 368
343, 368, 380, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
344, 51, 373, 1121, 371
345, 371, 1121, 1122, 372
346, 372, 1122, 377, 52
347, 373, 374, 1123, 1121
348, 1121, 1123, 1124, 1122
349, 1122, 1124, 378, 377
350, 374, 375, 1125, 1123
351, 1123, 1125, 1126, 1124
352, 1124, 1126, 379, 378
353, 375, 376, 1127, 1125
354, 1125, 1127, 1128, 1126
355, 1126, 1128, 380, 379
356, 376, 49, 369, 1127
357, 1127, 369, 370, 1128
358, 1128, 370, 50, 380
*ELEMENT, type=CPS4, ELSET=Surface62
359, 2, 97, 381, 54
360, 97, 98, 382, 381
361, 98, 99, 383, 382
362, 99, 100, 384, 383
363, 100, 1, 53, 384
*ELEMENT, type=CPS4, ELSET=Surface63
364, 1, 101, 385, 53
365, 101, 102, 386, 385
366, 102, 3, 55, 386
*ELEMENT, type=CPS4, ELSET=Surface64
3593, 4, 56, 387, 103
3594, 103, 387, 388, 104
3595, 104, 388, 389, 105
3596, 105, 389, 390, 106
3597, 106, 390, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
3598, 2, 54, 391, 107
3599, 107, 391, 392, 108
3600, 108, 392, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
367, 54, 381, 1129, 391
368, 391, 1129, 1130, 392
369, 392, 1130, 387, 56
370, 381, 382, 1131, 1129
371, 1129, 1131, 1132, 1130
372, 1130, 1132, 388, 387
373, 382, 383, 1133, 1131
374, 1131, 1133, 1134, 1132
375, 1132, 1134, 389, 388
376, 383, 384, 1135, 1133
377, 1133, 1135, 1136, 1134
378, 1134, 1136, 390, 389
379, 384, 53, 385, 1135
380, 1135, 385, 386, 1136
381, 1136, 386, 55, 390
*ELEMENT, type=CPS4, ELSET=Surface77
382, 11, 57, 393, 165
383, 165, 393, 394, 166
384, 166, 394, 395, 167
385, 167, 395, 396, 168
386, 168, 396, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
3601, 9, 153, 397, 59
3602, 153, 154, 398, 397
3603, 154, 155, 399, 398
3604, 155, 156, 400, 399
3605, 156, 13, 60, 400
*ELEMENT, type=CPS4, ELSET=Surface79
3606, 9, 59, 401, 141
3607, 141, 401, 402, 142
3608, 142, 402, 403, 143
3609, 143, 403, 404, 144
3610, 144, 404, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
3611, 13, 169, 405, 60
3612, 169, 170, 406, 405
3613, 170, 171, 407, 406
3614, 171, 172, 408, 407
3615, 172, 15, 58, 408
*ELEMENT, type=CPS4, ELSET=Surface81
3616, 59, 397, 1137, 401
3617, 397, 398, 1138, 1137
3618, 398, 399, 1139, 1138
3619, 399, 400, 1140, 1139
3620, 400, 60, 405, 1140
3621, 401, 1137, 1141, 402
3622, 1137, 1138, 1142, 1141
3623, 1138, 1139, 1143, 1142
3624, 1139, 1140, 1144, 1143
3625, 1140, 405, 406, 1144
3626, 402, 1141, 1145, 403
3627, 1141, 1142, 1146, 1145
3628, 1142, 1143, 1147, 1146
3629, 1143, 1144, 1148, 1147
3630, 1144, 406, 407, 1148
3631, 403, 1145, 1149, 404
3632, 1145, 1146, 1150, 1149
3633, 1146, 1147, 1151, 1150
3634, 1147, 1148, 1152, 1151
3635, 1148, 407, 408, 1152
3636, 404, 1149, 393, 57
3637, 1149, 1150, 394, 393
3638, 1150, 1151, 395, 394
3639, 1151, 1152, 396, 395
3640, 1152, 408, 58, 396
*ELEMENT, type=CPS4, ELSET=Surface82
387, 33, 61, 409, 297
388, 297, 409, 410, 298
389, 298, 410, 411, 299
390, 299, 411, 412, 300
391, 300, 412, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
3641, 35, 309, 413, 63
3642, 309, 310, 414, 413
3643, 310, 311, 415, 414
3644, 311, 312, 416, 415
3645, 312, 39, 64, 416
*ELEMENT, type=CPS4, ELSET=Surface84
3646, 35, 63, 417, 289
3647, 289, 417, 418, 290
3648, 290, 418, 419, 291
3649, 291, 419, 420, 292
3650, 292, 420, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
3651, 39, 321, 421, 64
3652, 321, 322, 422, 421
3653, 322, 323, 423, 422
3654, 323, 324, 424, 423
3655, 324, 37, 62, 424
*ELEMENT, type=CPS4, ELSET=Surface86
3656, 63, 413, 1153, 417
3657, 413, 414, 1154, 1153
3658, 414, 415, 1155, 1154
3659, 415, 416, 1156, 1155
3660, 416, 64, 421, 1156
3661, 417, 1153, 1157, 418
3662, 1153, 1154, 1158, 1157
3663, 1154, 1155, 1159, 1158
3664, 1155, 1156, 1160, 1159
3665, 1156, 421, 422, 1160
3666, 418, 1157, 1161, 419
3667, 1157, 1158, 1162, 1161
3668, 1158, 1159, 1163, 1162
3669, 1159, 1160, 1164, 1163
3670, 1160, 422, 423, 1164
3671, 419, 1161, 1165, 420
3672, 1161, 1162, 1166, 1165
3673, 1162, 1163, 1167, 1166
3674, 1163, 1164, 1168, 1167
3675, 1164, 423, 424, 1168
3676, 420, 1165, 409, 61
3677, 1165, 1166, 410, 409
3678, 1166, 1167, 411, 410
3679, 1167, 1168, 412, 411
3680, 1168, 424, 62, 412
*ELEMENT, type=CPS4, ELSET=Surface87
3681, 9, 65, 425, 153
3682, 153, 425, 426, 154
3683, 154, 426, 427, 155
3684, 155, 427, 428, 156
3685, 156, 428, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
3686, 10, 157, 429, 67
3687, 157, 158, 430, 429
3688, 158, 159, 431, 430
3689, 159, 160, 432, 431
3690, 160, 14, 68, 432
*ELEMENT, type=CPS4, ELSET=Surface89
3691, 10, 67, 433, 137
3692, 137, 433, 434, 138
3693, 138, 434, 435, 139
3694, 139, 435, 436, 140
3695, 140, 436, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
3696, 14, 161, 437, 68
3697, 161, 162, 438, 437
3698, 162, 163, 439, 438
3699, 163, 164, 440, 439
3700, 164, 13, 66, 440
*ELEMENT, type=CPS4, ELSET=Surface91
3701, 67, 429, 1169, 433
3702, 429, 430, 1170, 1169
3703, 430, 431, 1171, 1170
3704, 431, 432, 1172, 1171
3705, 432, 68, 437, 1172
3706, 433, 1169, 1173, 434
3707, 1169, 1170, 1174, 1173
3708, 1170, 1171, 1175, 1174
3709, 1171, 1172, 1176, 1175
3710, 1172, 437, 438, 1176
3711, 434, 1173, 1177, 435
3712, 1173, 1174, 1178, 1177
3713, 1174, 1175, 1179, 1178
3714, 1175, 1176, 1180, 1179
3715, 1176, 438, 439, 1180
3716, 435, 1177, 1181, 436
3717, 1177, 1178, 1182, 1181
3718, 1178, 1179, 1183, 1182
3719, 1179, 1180, 1184, 1183
3720, 1180, 439, 440, 1184
3721, 436, 1181, 425, 65
3722, 1181, 1182, 426, 425
3723, 1182, 1183, 427, 426
3724, 1183, 1184, 428, 427
3725, 1184, 440, 66, 428
*ELEMENT, type=CPS4, ELSET=Surface92
3726, 35, 69, 441, 309
3727, 309, 441, 442, 310
3728, 310, 442, 443, 311
3729, 311, 443, 444, 312
3730, 312, 444, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
3731, 36, 313, 445, 71
3732, 313, 314, 446, 445
3733, 314, 315, 447, 446
3734, 315, 316, 448, 447
3735, 316, 40, 72, 448
*ELEMENT, type=CPS4, ELSET=Surface94
3736, 35, 285, 449, 69
3737, 285, 286, 450, 449
3738, 286, 287, 451, 450
3739, 287, 288, 452, 451
3740, 288, 36, 71, 452
*ELEMENT, type=CPS4, ELSET=Surface95
3741, 39, 70, 453, 317
3742, 317, 453, 454, 318
3743, 318, 454, 455, 319
3744, 319, 455, 456, 320
3745, 320, 456, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
3746, 69, 449, 1185, 441
3747, 441, 1185, 1186, 442
3748, 442, 1186, 1187, 443
3749, 443, 1187, 1188, 444
3750, 444, 1188, 453, 70
3751, 449, 450, 1189, 1185
3752, 1185, 1189, 1190, 1186
3753, 1186, 1190, 1191, 1187
3754, 1187, 1191, 1192, 1188
3755, 1188, 1192, 454, 453
3756, 450, 451, 1193, 1189
3757, 1189, 1193, 1194, 1190
3758, 1190, 1194, 1195, 1191
3759, 1191, 1195, 1196, 1192
3760, 1192, 1196, 455, 454
3761, 451, 452, 1197, 1193
3762, 1193, 1197, 1198, 1194
3763, 1194, 1198, 1199, 1195
3764, 1195, 1199, 1200, 1196
3765, 1196, 1200, 456, 455
3766, 452, 71, 445, 1197
3767, 1197, 445, 446, 1198
3768, 1198, 446, 447, 1199
3769, 1199, 447, 448, 1200
3770, 1200, 448, 72, 456
*ELEMENT, type=CPS4, ELSET=Surface97
3771, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
3772, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
3773, 63, 73, 457, 413
3774, 413, 457, 458, 414
3775, 414, 458, 459, 415
3776, 415, 459, 460, 416
3777, 416, 460, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
3778, 69, 441, 457, 73
3779, 441, 442, 458, 457
3780, 442, 443, 459, 458
3781, 443, 444, 460, 459
3782, 444, 70, 74, 460
*ELEMENT, type=CPS4, ELSET=Surface101
3783, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
3784, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
3785, 59, 75, 461, 397
3786, 397, 461, 462, 398
3787, 398, 462, 463, 399
3788, 399, 463, 464, 400
3789, 400, 464, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
3790, 65, 425, 461, 75
3791, 425, 426, 462, 461
3792, 426, 427, 463, 462
3793, 427, 428, 464, 463
3794, 428, 66, 76, 464
*ELEMENT, type=CPS4, ELSET=Surface105
3795, 22, 469, 1201, 205
3796, 469, 470, 1202, 1201
3797, 470, 471, 1203, 1202
3798, 471, 472, 1204, 1203
3799, 472, 78, 473, 1204
3800, 205, 1201, 1205, 206
3801, 1201, 1202, 1206, 1205
3802, 1202, 1203, 1207, 1206
3803, 1203, 1204, 1208, 1207
3804, 1204, 473, 474, 1208
3805, 206, 1205, 1209, 207
3806, 1205, 1206, 1210, 1209
3807, 1206, 1207, 1211, 1210
3808, 1207, 1208, 1212, 1211
3809, 1208, 474, 475, 1212
3810, 207, 1209, 1213, 208
3811, 1209, 1210, 1214, 1213
3812, 1210, 1211, 1215, 1214
3813, 1211, 1212, 1216, 1215
3814, 1212, 475, 476, 1216
3815, 208, 1213, 465, 21
3816, 1213, 1214, 466, 465
3817, 1214, 1215, 467, 466
3818, 1215, 1216, 468, 467
3819, 1216, 476, 77, 468
*ELEMENT, type=CPS4, ELSET=Surface106
3820, 21, 465, 1217, 211
3821, 465, 466, 1218, 1217
3822, 466, 467, 1219, 1218
3823, 467, 468, 1220, 1219
3824, 468, 77, 481, 1220
3825, 211, 1217, 1221, 212
3826, 1217, 1218, 1222, 1221
3827, 1218, 1219, 1223, 1222
3828, 1219, 1220, 1224, 1223
3829, 1220, 481, 482, 1224
3830, 212, 1221, 1225, 213
3831, 1221, 1222, 1226, 1225
3832, 1222, 1223, 1227, 1226
3833, 1223, 1224, 1228, 1227
3834, 1224, 482, 483, 1228
3835, 213, 1225, 1229, 214
3836, 1225, 1226, 1230, 1229
3837, 1226, 1227, 1231, 1230
3838, 1227, 1228, 1232, 1231
3839, 1228, 483, 484, 1232
3840, 214, 1229, 477, 23
3841, 1229, 1230, 478, 477
3842, 1230, 1231, 479, 478
3843, 1231, 1232, 480, 479
