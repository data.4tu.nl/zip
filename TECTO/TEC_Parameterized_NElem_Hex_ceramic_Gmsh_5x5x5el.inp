3844, 1232, 484, 79, 480
*ELEMENT, type=CPS4, ELSET=Surface107
392, 24, 217, 1233, 485
393, 485, 1233, 1234, 486
394, 486, 1234, 1235, 487
395, 487, 1235, 1236, 488
396, 488, 1236, 489, 80
397, 217, 218, 1237, 1233
398, 1233, 1237, 1238, 1234
399, 1234, 1238, 1239, 1235
400, 1235, 1239, 1240, 1236
401, 1236, 1240, 490, 489
402, 218, 219, 1241, 1237
403, 1237, 1241, 1242, 1238
404, 1238, 1242, 1243, 1239
405, 1239, 1243, 1244, 1240
406, 1240, 1244, 491, 490
407, 219, 220, 1245, 1241
408, 1241, 1245, 1246, 1242
409, 1242, 1246, 1247, 1243
410, 1243, 1247, 1248, 1244
411, 1244, 1248, 492, 491
412, 220, 23, 477, 1245
413, 1245, 477, 478, 1246
414, 1246, 478, 479, 1247
415, 1247, 479, 480, 1248
416, 1248, 480, 79, 492
*ELEMENT, type=CPS4, ELSET=Surface108
3845, 22, 221, 1249, 469
3846, 469, 1249, 1250, 470
3847, 470, 1250, 1251, 471
3848, 471, 1251, 1252, 472
3849, 472, 1252, 493, 78
3850, 221, 222, 1253, 1249
3851, 1249, 1253, 1254, 1250
3852, 1250, 1254, 1255, 1251
3853, 1251, 1255, 1256, 1252
3854, 1252, 1256, 494, 493
3855, 222, 223, 1257, 1253
3856, 1253, 1257, 1258, 1254
3857, 1254, 1258, 1259, 1255
3858, 1255, 1259, 1260, 1256
3859, 1256, 1260, 495, 494
3860, 223, 224, 1261, 1257
3861, 1257, 1261, 1262, 1258
3862, 1258, 1262, 1263, 1259
3863, 1259, 1263, 1264, 1260
3864, 1260, 1264, 496, 495
3865, 224, 24, 485, 1261
3866, 1261, 485, 486, 1262
3867, 1262, 486, 487, 1263
3868, 1263, 487, 488, 1264
3869, 1264, 488, 80, 496
*ELEMENT, type=CPS4, ELSET=Surface109
417, 78, 493, 1265, 473
418, 493, 494, 1266, 1265
419, 494, 495, 1267, 1266
420, 495, 496, 1268, 1267
421, 496, 80, 489, 1268
422, 473, 1265, 1269, 474
423, 1265, 1266, 1270, 1269
424, 1266, 1267, 1271, 1270
425, 1267, 1268, 1272, 1271
426, 1268, 489, 490, 1272
427, 474, 1269, 1273, 475
428, 1269, 1270, 1274, 1273
429, 1270, 1271, 1275, 1274
430, 1271, 1272, 1276, 1275
431, 1272, 490, 491, 1276
432, 475, 1273, 1277, 476
433, 1273, 1274, 1278, 1277
434, 1274, 1275, 1279, 1278
435, 1275, 1276, 1280, 1279
436, 1276, 491, 492, 1280
437, 476, 1277, 481, 77
438, 1277, 1278, 482, 481
439, 1278, 1279, 483, 482
440, 1279, 1280, 484, 483
441, 1280, 492, 79, 484
*ELEMENT, type=CPS4, ELSET=Surface110
442, 23, 229, 1281, 477
443, 477, 1281, 1282, 478
444, 478, 1282, 1283, 479
445, 479, 1283, 1284, 480
446, 480, 1284, 501, 79
447, 229, 230, 1285, 1281
448, 1281, 1285, 1286, 1282
449, 1282, 1286, 1287, 1283
450, 1283, 1287, 1288, 1284
451, 1284, 1288, 502, 501
452, 230, 231, 1289, 1285
453, 1285, 1289, 1290, 1286
454, 1286, 1290, 1291, 1287
455, 1287, 1291, 1292, 1288
456, 1288, 1292, 503, 502
457, 231, 232, 1293, 1289
458, 1289, 1293, 1294, 1290
459, 1290, 1294, 1295, 1291
460, 1291, 1295, 1296, 1292
461, 1292, 1296, 504, 503
462, 232, 26, 497, 1293
463, 1293, 497, 498, 1294
464, 1294, 498, 499, 1295
465, 1295, 499, 500, 1296
466, 1296, 500, 81, 504
*ELEMENT, type=CPS4, ELSET=Surface111
3870, 21, 465, 1297, 239
3871, 465, 466, 1298, 1297
3872, 466, 467, 1299, 1298
3873, 467, 468, 1300, 1299
3874, 468, 77, 509, 1300
3875, 239, 1297, 1301, 240
3876, 1297, 1298, 1302, 1301
3877, 1298, 1299, 1303, 1302
3878, 1299, 1300, 1304, 1303
3879, 1300, 509, 510, 1304
3880, 240, 1301, 1305, 241
3881, 1301, 1302, 1306, 1305
3882, 1302, 1303, 1307, 1306
3883, 1303, 1304, 1308, 1307
3884, 1304, 510, 511, 1308
3885, 241, 1305, 1309, 242
3886, 1305, 1306, 1310, 1309
3887, 1306, 1307, 1311, 1310
3888, 1307, 1308, 1312, 1311
3889, 1308, 511, 512, 1312
3890, 242, 1309, 505, 28
3891, 1309, 1310, 506, 505
3892, 1310, 1311, 507, 506
3893, 1311, 1312, 508, 507
3894, 1312, 512, 82, 508
*ELEMENT, type=CPS4, ELSET=Surface112
3895, 28, 505, 1313, 249
3896, 505, 506, 1314, 1313
3897, 506, 507, 1315, 1314
3898, 507, 508, 1316, 1315
3899, 508, 82, 513, 1316
3900, 249, 1313, 1317, 250
3901, 1313, 1314, 1318, 1317
3902, 1314, 1315, 1319, 1318
3903, 1315, 1316, 1320, 1319
3904, 1316, 513, 514, 1320
3905, 250, 1317, 1321, 251
3906, 1317, 1318, 1322, 1321
3907, 1318, 1319, 1323, 1322
3908, 1319, 1320, 1324, 1323
3909, 1320, 514, 515, 1324
3910, 251, 1321, 1325, 252
3911, 1321, 1322, 1326, 1325
3912, 1322, 1323, 1327, 1326
3913, 1323, 1324, 1328, 1327
3914, 1324, 515, 516, 1328
3915, 252, 1325, 497, 26
3916, 1325, 1326, 498, 497
3917, 1326, 1327, 499, 498
3918, 1327, 1328, 500, 499
3919, 1328, 516, 81, 500
*ELEMENT, type=CPS4, ELSET=Surface113
467, 77, 481, 1329, 509
468, 509, 1329, 1330, 510
469, 510, 1330, 1331, 511
470, 511, 1331, 1332, 512
471, 512, 1332, 513, 82
472, 481, 482, 1333, 1329
473, 1329, 1333, 1334, 1330
474, 1330, 1334, 1335, 1331
475, 1331, 1335, 1336, 1332
476, 1332, 1336, 514, 513
477, 482, 483, 1337, 1333
478, 1333, 1337, 1338, 1334
479, 1334, 1338, 1339, 1335
480, 1335, 1339, 1340, 1336
481, 1336, 1340, 515, 514
482, 483, 484, 1341, 1337
483, 1337, 1341, 1342, 1338
484, 1338, 1342, 1343, 1339
485, 1339, 1343, 1344, 1340
486, 1340, 1344, 516, 515
487, 484, 79, 501, 1341
488, 1341, 501, 502, 1342
489, 1342, 502, 503, 1343
490, 1343, 503, 504, 1344
491, 1344, 504, 81, 516
*ELEMENT, type=CPS4, ELSET=Surface114
492, 26, 257, 1345, 497
493, 497, 1345, 1346, 498
494, 498, 1346, 1347, 499
495, 499, 1347, 1348, 500
496, 500, 1348, 521, 81
497, 257, 258, 1349, 1345
498, 1345, 1349, 1350, 1346
499, 1346, 1350, 1351, 1347
500, 1347, 1351, 1352, 1348
501, 1348, 1352, 522, 521
502, 258, 259, 1353, 1349
503, 1349, 1353, 1354, 1350
504, 1350, 1354, 1355, 1351
505, 1351, 1355, 1356, 1352
506, 1352, 1356, 523, 522
507, 259, 260, 1357, 1353
508, 1353, 1357, 1358, 1354
509, 1354, 1358, 1359, 1355
510, 1355, 1359, 1360, 1356
511, 1356, 1360, 524, 523
512, 260, 30, 517, 1357
513, 1357, 517, 518, 1358
514, 1358, 518, 519, 1359
515, 1359, 519, 520, 1360
516, 1360, 520, 83, 524
*ELEMENT, type=CPS4, ELSET=Surface115
3920, 28, 505, 1361, 267
3921, 505, 506, 1362, 1361
3922, 506, 507, 1363, 1362
3923, 507, 508, 1364, 1363
3924, 508, 82, 529, 1364
3925, 267, 1361, 1365, 268
3926, 1361, 1362, 1366, 1365
3927, 1362, 1363, 1367, 1366
3928, 1363, 1364, 1368, 1367
3929, 1364, 529, 530, 1368
3930, 268, 1365, 1369, 269
3931, 1365, 1366, 1370, 1369
3932, 1366, 1367, 1371, 1370
3933, 1367, 1368, 1372, 1371
3934, 1368, 530, 531, 1372
3935, 269, 1369, 1373, 270
3936, 1369, 1370, 1374, 1373
3937, 1370, 1371, 1375, 1374
3938, 1371, 1372, 1376, 1375
3939, 1372, 531, 532, 1376
3940, 270, 1373, 525, 32
3941, 1373, 1374, 526, 525
3942, 1374, 1375, 527, 526
3943, 1375, 1376, 528, 527
3944, 1376, 532, 84, 528
*ELEMENT, type=CPS4, ELSET=Surface116
3945, 32, 525, 1377, 277
3946, 525, 526, 1378, 1377
3947, 526, 527, 1379, 1378
3948, 527, 528, 1380, 1379
3949, 528, 84, 533, 1380
3950, 277, 1377, 1381, 278
3951, 1377, 1378, 1382, 1381
3952, 1378, 1379, 1383, 1382
3953, 1379, 1380, 1384, 1383
3954, 1380, 533, 534, 1384
3955, 278, 1381, 1385, 279
3956, 1381, 1382, 1386, 1385
3957, 1382, 1383, 1387, 1386
3958, 1383, 1384, 1388, 1387
3959, 1384, 534, 535, 1388
3960, 279, 1385, 1389, 280
3961, 1385, 1386, 1390, 1389
3962, 1386, 1387, 1391, 1390
3963, 1387, 1388, 1392, 1391
3964, 1388, 535, 536, 1392
3965, 280, 1389, 517, 30
3966, 1389, 1390, 518, 517
3967, 1390, 1391, 519, 518
3968, 1391, 1392, 520, 519
3969, 1392, 536, 83, 520
*ELEMENT, type=CPS4, ELSET=Surface117
517, 82, 513, 1393, 529
518, 529, 1393, 1394, 530
519, 530, 1394, 1395, 531
520, 531, 1395, 1396, 532
521, 532, 1396, 533, 84
522, 513, 514, 1397, 1393
523, 1393, 1397, 1398, 1394
524, 1394, 1398, 1399, 1395
525, 1395, 1399, 1400, 1396
526, 1396, 1400, 534, 533
527, 514, 515, 1401, 1397
528, 1397, 1401, 1402, 1398
529, 1398, 1402, 1403, 1399
530, 1399, 1403, 1404, 1400
531, 1400, 1404, 535, 534
532, 515, 516, 1405, 1401
533, 1401, 1405, 1406, 1402
534, 1402, 1406, 1407, 1403
535, 1403, 1407, 1408, 1404
536, 1404, 1408, 536, 535
537, 516, 81, 521, 1405
538, 1405, 521, 522, 1406
539, 1406, 522, 523, 1407
540, 1407, 523, 524, 1408
541, 1408, 524, 83, 536
*ELEMENT, type=CPS4, ELSET=Surface118
3970, 2, 121, 1409, 541
3971, 541, 1409, 1410, 542
3972, 542, 1410, 1411, 543
3973, 543, 1411, 1412, 544
3974, 544, 1412, 545, 86
3975, 121, 122, 1413, 1409
3976, 1409, 1413, 1414, 1410
3977, 1410, 1414, 1415, 1411
3978, 1411, 1415, 1416, 1412
3979, 1412, 1416, 546, 545
3980, 122, 123, 1417, 1413
3981, 1413, 1417, 1418, 1414
3982, 1414, 1418, 1419, 1415
3983, 1415, 1419, 1420, 1416
3984, 1416, 1420, 547, 546
3985, 123, 124, 1421, 1417
3986, 1417, 1421, 1422, 1418
3987, 1418, 1422, 1423, 1419
3988, 1419, 1423, 1424, 1420
3989, 1420, 1424, 548, 547
3990, 124, 6, 537, 1421
3991, 1421, 537, 538, 1422
3992, 1422, 538, 539, 1423
3993, 1423, 539, 540, 1424
3994, 1424, 540, 85, 548
*ELEMENT, type=CPS4, ELSET=Surface119
3995, 6, 109, 1425, 537
3996, 537, 1425, 1426, 538
3997, 538, 1426, 1427, 539
3998, 539, 1427, 1428, 540
3999, 540, 1428, 553, 85
4000, 109, 110, 1429, 1425
4001, 1425, 1429, 1430, 1426
4002, 1426, 1430, 1431, 1427
4003, 1427, 1431, 1432, 1428
4004, 1428, 1432, 554, 553
4005, 110, 111, 1433, 1429
4006, 1429, 1433, 1434, 1430
4007, 1430, 1434, 1435, 1431
4008, 1431, 1435, 1436, 1432
4009, 1432, 1436, 555, 554
4010, 111, 112, 1437, 1433
4011, 1433, 1437, 1438, 1434
4012, 1434, 1438, 1439, 1435
4013, 1435, 1439, 1440, 1436
4014, 1436, 1440, 556, 555
4015, 112, 5, 549, 1437
4016, 1437, 549, 550, 1438
4017, 1438, 550, 551, 1439
4018, 1439, 551, 552, 1440
4019, 1440, 552, 87, 556
*ELEMENT, type=CPS4, ELSET=Surface120
542, 1, 557, 1441, 125
543, 557, 558, 1442, 1441
544, 558, 559, 1443, 1442
545, 559, 560, 1444, 1443
546, 560, 88, 561, 1444
547, 125, 1441, 1445, 126
548, 1441, 1442, 1446, 1445
549, 1442, 1443, 1447, 1446
550, 1443, 1444, 1448, 1447
551, 1444, 561, 562, 1448
552, 126, 1445, 1449, 127
553, 1445, 1446, 1450, 1449
554, 1446, 1447, 1451, 1450
555, 1447, 1448, 1452, 1451
556, 1448, 562, 563, 1452
557, 127, 1449, 1453, 128
558, 1449, 1450, 1454, 1453
559, 1450, 1451, 1455, 1454
560, 1451, 1452, 1456, 1455
561, 1452, 563, 564, 1456
562, 128, 1453, 549, 5
563, 1453, 1454, 550, 549
564, 1454, 1455, 551, 550
565, 1455, 1456, 552, 551
566, 1456, 564, 87, 552
*ELEMENT, type=CPS4, ELSET=Surface121
4020, 2, 541, 1457, 97
4021, 541, 542, 1458, 1457
4022, 542, 543, 1459, 1458
4023, 543, 544, 1460, 1459
4024, 544, 86, 565, 1460
4025, 97, 1457, 1461, 98
4026, 1457, 1458, 1462, 1461
4027, 1458, 1459, 1463, 1462
4028, 1459, 1460, 1464, 1463
4029, 1460, 565, 566, 1464
4030, 98, 1461, 1465, 99
4031, 1461, 1462, 1466, 1465
4032, 1462, 1463, 1467, 1466
4033, 1463, 1464, 1468, 1467
4034, 1464, 566, 567, 1468
4035, 99, 1465, 1469, 100
4036, 1465, 1466, 1470, 1469
4037, 1466, 1467, 1471, 1470
4038, 1467, 1468, 1472, 1471
4039, 1468, 567, 568, 1472
4040, 100, 1469, 557, 1
4041, 1469, 1470, 558, 557
4042, 1470, 1471, 559, 558
4043, 1471, 1472, 560, 559
4044, 1472, 568, 88, 560
*ELEMENT, type=CPS4, ELSET=Surface122
567, 86, 545, 1473, 565
568, 565, 1473, 1474, 566
569, 566, 1474, 1475, 567
570, 567, 1475, 1476, 568
571, 568, 1476, 561, 88
572, 545, 546, 1477, 1473
573, 1473, 1477, 1478, 1474
574, 1474, 1478, 1479, 1475
575, 1475, 1479, 1480, 1476
576, 1476, 1480, 562, 561
577, 546, 547, 1481, 1477
578, 1477, 1481, 1482, 1478
579, 1478, 1482, 1483, 1479
580, 1479, 1483, 1484, 1480
581, 1480, 1484, 563, 562
582, 547, 548, 1485, 1481
583, 1481, 1485, 1486, 1482
584, 1482, 1486, 1487, 1483
585, 1483, 1487, 1488, 1484
586, 1484, 1488, 564, 563
587, 548, 85, 553, 1485
588, 1485, 553, 554, 1486
589, 1486, 554, 555, 1487
590, 1487, 555, 556, 1488
591, 1488, 556, 87, 564
*ELEMENT, type=CPS4, ELSET=Surface123
592, 1, 53, 569, 557
593, 557, 569, 570, 558
594, 558, 570, 571, 559
595, 559, 571, 572, 560
596, 560, 572, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
4045, 2, 541, 573, 54
4046, 541, 542, 574, 573
4047, 542, 543, 575, 574
4048, 543, 544, 576, 575
4049, 544, 86, 90, 576
*ELEMENT, type=CPS4, ELSET=Surface125
4050, 54, 573, 1489, 381
4051, 573, 574, 1490, 1489
4052, 574, 575, 1491, 1490
4053, 575, 576, 1492, 1491
4054, 576, 90, 577, 1492
4055, 381, 1489, 1493, 382
4056, 1489, 1490, 1494, 1493
4057, 1490, 1491, 1495, 1494
4058, 1491, 1492, 1496, 1495
4059, 1492, 577, 578, 1496
4060, 382, 1493, 1497, 383
4061, 1493, 1494, 1498, 1497
4062, 1494, 1495, 1499, 1498
4063, 1495, 1496, 1500, 1499
4064, 1496, 578, 579, 1500
4065, 383, 1497, 1501, 384
4066, 1497, 1498, 1502, 1501
4067, 1498, 1499, 1503, 1502
4068, 1499, 1500, 1504, 1503
4069, 1500, 579, 580, 1504
4070, 384, 1501, 569, 53
4071, 1501, 1502, 570, 569
4072, 1502, 1503, 571, 570
4073, 1503, 1504, 572, 571
4074, 1504, 580, 89, 572
*ELEMENT, type=CPS4, ELSET=Surface126
597, 86, 565, 577, 90
598, 565, 566, 578, 577
599, 566, 567, 579, 578
600, 567, 568, 580, 579
601, 568, 88, 89, 580
*ELEMENT, type=CPS4, ELSET=Surface127
602, 45, 581, 1505, 349
603, 581, 582, 1506, 1505
604, 582, 583, 1507, 1506
605, 583, 584, 1508, 1507
606, 584, 91, 589, 1508
607, 349, 1505, 1509, 350
608, 1505, 1506, 1510, 1509
609, 1506, 1507, 1511, 1510
610, 1507, 1508, 1512, 1511
611, 1508, 589, 590, 1512
612, 350, 1509, 1513, 351
613, 1509, 1510, 1514, 1513
614, 1510, 1511, 1515, 1514
615, 1511, 1512, 1516, 1515
616, 1512, 590, 591, 1516
617, 351, 1513, 1517, 352
618, 1513, 1514, 1518, 1517
619, 1514, 1515, 1519, 1518
620, 1515, 1516, 1520, 1519
621, 1516, 591, 592, 1520
622, 352, 1517, 585, 46
623, 1517, 1518, 586, 585
624, 1518, 1519, 587, 586
625, 1519, 1520, 588, 587
626, 1520, 592, 92, 588
*ELEMENT, type=CPS4, ELSET=Surface128
4075, 47, 357, 1521, 593
4076, 593, 1521, 1522, 594
4077, 594, 1522, 1523, 595
4078, 595, 1523, 1524, 596
4079, 596, 1524, 601, 93
4080, 357, 358, 1525, 1521
4081, 1521, 1525, 1526, 1522
4082, 1522, 1526, 1527, 1523
4083, 1523, 1527, 1528, 1524
4084, 1524, 1528, 602, 601
4085, 358, 359, 1529, 1525
4086, 1525, 1529, 1530, 1526
4087, 1526, 1530, 1531, 1527
4088, 1527, 1531, 1532, 1528
4089, 1528, 1532, 603, 602
4090, 359, 360, 1533, 1529
4091, 1529, 1533, 1534, 1530
4092, 1530, 1534, 1535, 1531
4093, 1531, 1535, 1536, 1532
4094, 1532, 1536, 604, 603
4095, 360, 48, 597, 1533
4096, 1533, 597, 598, 1534
4097, 1534, 598, 599, 1535
4098, 1535, 599, 600, 1536
4099, 1536, 600, 94, 604
*ELEMENT, type=CPS4, ELSET=Surface129
4100, 47, 593, 1537, 361
4101, 593, 594, 1538, 1537
4102, 594, 595, 1539, 1538
4103, 595, 596, 1540, 1539
4104, 596, 93, 605, 1540
4105, 361, 1537, 1541, 362
4106, 1537, 1538, 1542, 1541
4107, 1538, 1539, 1543, 1542
4108, 1539, 1540, 1544, 1543
4109, 1540, 605, 606, 1544
4110, 362, 1541, 1545, 363
4111, 1541, 1542, 1546, 1545
4112, 1542, 1543, 1547, 1546
4113, 1543, 1544, 1548, 1547
4114, 1544, 606, 607, 1548
4115, 363, 1545, 1549, 364
4116, 1545, 1546, 1550, 1549
4117, 1546, 1547, 1551, 1550
4118, 1547, 1548, 1552, 1551
4119, 1548, 607, 608, 1552
4120, 364, 1549, 581, 45
4121, 1549, 1550, 582, 581
4122, 1550, 1551, 583, 582
4123, 1551, 1552, 584, 583
4124, 1552, 608, 91, 584
*ELEMENT, type=CPS4, ELSET=Surface130
4125, 48, 365, 1553, 597
4126, 597, 1553, 1554, 598
4127, 598, 1554, 1555, 599
4128, 599, 1555, 1556, 600
4129, 600, 1556, 609, 94
4130, 365, 366, 1557, 1553
4131, 1553, 1557, 1558, 1554
4132, 1554, 1558, 1559, 1555
4133, 1555, 1559, 1560, 1556
4134, 1556, 1560, 610, 609
4135, 366, 367, 1561, 1557
4136, 1557, 1561, 1562, 1558
4137, 1558, 1562, 1563, 1559
4138, 1559, 1563, 1564, 1560
4139, 1560, 1564, 611, 610
4140, 367, 368, 1565, 1561
4141, 1561, 1565, 1566, 1562
4142, 1562, 1566, 1567, 1563
4143, 1563, 1567, 1568, 1564
4144, 1564, 1568, 612, 611
4145, 368, 46, 585, 1565
4146, 1565, 585, 586, 1566
4147, 1566, 586, 587, 1567
4148, 1567, 587, 588, 1568
4149, 1568, 588, 92, 612
*ELEMENT, type=CPS4, ELSET=Surface131
627, 93, 601, 1569, 605
628, 601, 602, 1570, 1569
629, 602, 603, 1571, 1570
630, 603, 604, 1572, 1571
631, 604, 94, 609, 1572
632, 605, 1569, 1573, 606
633, 1569, 1570, 1574, 1573
634, 1570, 1571, 1575, 1574
635, 1571, 1572, 1576, 1575
636, 1572, 609, 610, 1576
637, 606, 1573, 1577, 607
638, 1573, 1574, 1578, 1577
639, 1574, 1575, 1579, 1578
640, 1575, 1576, 1580, 1579
641, 1576, 610, 611, 1580
642, 607, 1577, 1581, 608
643, 1577, 1578, 1582, 1581
644, 1578, 1579, 1583, 1582
645, 1579, 1580, 1584, 1583
646, 1580, 611, 612, 1584
647, 608, 1581, 589, 91
648, 1581, 1582, 590, 589
649, 1582, 1583, 591, 590
650, 1583, 1584, 592, 591
651, 1584, 612, 92, 592
*ELEMENT, type=CPS4, ELSET=Surface132
652, 46, 585, 613, 50
653, 585, 586, 614, 613
654, 586, 587, 615, 614
655, 587, 588, 616, 615
656, 588, 92, 95, 616
*ELEMENT, type=CPS4, ELSET=Surface133
4150, 48, 52, 617, 597
4151, 597, 617, 618, 598
4152, 598, 618, 619, 599
4153, 599, 619, 620, 600
4154, 600, 620, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
4155, 52, 377, 1585, 617
4156, 617, 1585, 1586, 618
4157, 618, 1586, 1587, 619
4158, 619, 1587, 1588, 620
4159, 620, 1588, 621, 96
4160, 377, 378, 1589, 1585
4161, 1585, 1589, 1590, 1586
4162, 1586, 1590, 1591, 1587
4163, 1587, 1591, 1592, 1588
4164, 1588, 1592, 622, 621
4165, 378, 379, 1593, 1589
4166, 1589, 1593, 1594, 1590
4167, 1590, 1594, 1595, 1591
4168, 1591, 1595, 1596, 1592
4169, 1592, 1596, 623, 622
4170, 379, 380, 1597, 1593
4171, 1593, 1597, 1598, 1594
4172, 1594, 1598, 1599, 1595
4173, 1595, 1599, 1600, 1596
4174, 1596, 1600, 624, 623
4175, 380, 50, 613, 1597
4176, 1597, 613, 614, 1598
4177, 1598, 614, 615, 1599
4178, 1599, 615, 616, 1600
4179, 1600, 616, 95, 624
*ELEMENT, type=CPS4, ELSET=Surface135
657, 94, 96, 621, 609
658, 609, 621, 622, 610
659, 610, 622, 623, 611
660, 611, 623, 624, 612
661, 612, 624, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
662, 625, 97, 2, 107, 1601, 641, 121, 673
663, 1601, 641, 121, 673, 1602, 645, 122, 674
664, 1602, 645, 122, 674, 1603, 649, 123, 675
665, 1603, 649, 123, 675, 1604, 653, 124, 676
666, 1604, 653, 124, 676, 633, 109, 6, 119
667, 626, 625, 107, 108, 1605, 1601, 673, 677
668, 1605, 1601, 673, 677, 1606, 1602, 674, 678
669, 1606, 1602, 674, 678, 1607, 1603, 675, 679
670, 1607, 1603, 675, 679, 1608, 1604, 676, 680
671, 1608, 1604, 676, 680, 634, 633, 119, 120
672, 103, 626, 108, 4, 657, 1605, 677, 129
673, 657, 1605, 677, 129, 661, 1606, 678, 130
674, 661, 1606, 678, 130, 665, 1607, 679, 131
675, 665, 1607, 679, 131, 669, 1608, 680, 132
676, 669, 1608, 680, 132, 115, 634, 120, 8
677, 627, 98, 97, 625, 1609, 642, 641, 1601
678, 1609, 642, 641, 1601, 1610, 646, 645, 1602
679, 1610, 646, 645, 1602, 1611, 650, 649, 1603
680, 1611, 650, 649, 1603, 1612, 654, 653, 1604
681, 1612, 654, 653, 1604, 635, 110, 109, 633
682, 628, 627, 625, 626, 1613, 1609, 1601, 1605
683, 1613, 1609, 1601, 1605, 1614, 1610, 1602, 1606
684, 1614, 1610, 1602, 1606, 1615, 1611, 1603, 1607
685, 1615, 1611, 1603, 1607, 1616, 1612, 1604, 1608
686, 1616, 1612, 1604, 1608, 636, 635, 633, 634
687, 104, 628, 626, 103, 658, 1613, 1605, 657
688, 658, 1613, 1605, 657, 662, 1614, 1606, 661
689, 662, 1614, 1606, 661, 666, 1615, 1607, 665
690, 666, 1615, 1607, 665, 670, 1616, 1608, 669
691, 670, 1616, 1608, 669, 116, 636, 634, 115
692, 629, 99, 98, 627, 1617, 643, 642, 1609
693, 1617, 643, 642, 1609, 1618, 647, 646, 1610
694, 1618, 647, 646, 1610, 1619, 651, 650, 1611
695, 1619, 651, 650, 1611, 1620, 655, 654, 1612
696, 1620, 655, 654, 1612, 637, 111, 110, 635
697, 630, 629, 627, 628, 1621, 1617, 1609, 1613
698, 1621, 1617, 1609, 1613, 1622, 1618, 1610, 1614
699, 1622, 1618, 1610, 1614, 1623, 1619, 1611, 1615
700, 1623, 1619, 1611, 1615, 1624, 1620, 1612, 1616
701, 1624, 1620, 1612, 1616, 638, 637, 635, 636
702, 105, 630, 628, 104, 659, 1621, 1613, 658
703, 659, 1621, 1613, 658, 663, 1622, 1614, 662
704, 663, 1622, 1614, 662, 667, 1623, 1615, 666
705, 667, 1623, 1615, 666, 671, 1624, 1616, 670
706, 671, 1624, 1616, 670, 117, 638, 636, 116
707, 631, 100, 99, 629, 1625, 644, 643, 1617
708, 1625, 644, 643, 1617, 1626, 648, 647, 1618
709, 1626, 648, 647, 1618, 1627, 652, 651, 1619
710, 1627, 652, 651, 1619, 1628, 656, 655, 1620
711, 1628, 656, 655, 1620, 639, 112, 111, 637
712, 632, 631, 629, 630, 1629, 1625, 1617, 1621
713, 1629, 1625, 1617, 1621, 1630, 1626, 1618, 1622
714, 1630, 1626, 1618, 1622, 1631, 1627, 1619, 1623
715, 1631, 1627, 1619, 1623, 1632, 1628, 1620, 1624
716, 1632, 1628, 1620, 1624, 640, 639, 637, 638
717, 106, 632, 630, 105, 660, 1629, 1621, 659
718, 660, 1629, 1621, 659, 664, 1630, 1622, 663
719, 664, 1630, 1622, 663, 668, 1631, 1623, 667
720, 668, 1631, 1623, 667, 672, 1632, 1624, 671
721, 672, 1632, 1624, 671, 118, 640, 638, 117
722, 101, 1, 100, 631, 681, 125, 644, 1625
723, 681, 125, 644, 1625, 682, 126, 648, 1626
724, 682, 126, 648, 1626, 683, 127, 652, 1627
725, 683, 127, 652, 1627, 684, 128, 656, 1628
726, 684, 128, 656, 1628, 113, 5, 112, 639
727, 102, 101, 631, 632, 685, 681, 1625, 1629
728, 685, 681, 1625, 1629, 686, 682, 1626, 1630
729, 686, 682, 1626, 1630, 687, 683, 1627, 1631
730, 687, 683, 1627, 1631, 688, 684, 1628, 1632
731, 688, 684, 1628, 1632, 114, 113, 639, 640
732, 3, 102, 632, 106, 133, 685, 1629, 660
733, 133, 685, 1629, 660, 134, 686, 1630, 664
734, 134, 686, 1630, 664, 135, 687, 1631, 668
735, 135, 687, 1631, 668, 136, 688, 1632, 672
736, 136, 688, 1632, 672, 7, 114, 640, 118
*ELEMENT, type=C3D8, ELSET=Volume2
737, 4, 103, 657, 129, 10, 149, 689, 137
738, 103, 104, 658, 657, 149, 150, 690, 689
739, 104, 105, 659, 658, 150, 151, 691, 690
740, 105, 106, 660, 659, 151, 152, 692, 691
741, 106, 3, 133, 660, 152, 12, 145, 692
742, 129, 657, 661, 130, 137, 689, 693, 138
743, 657, 658, 662, 661, 689, 690, 694, 693
744, 658, 659, 663, 662, 690, 691, 695, 694
745, 659, 660, 664, 663, 691, 692, 696, 695
746, 660, 133, 134, 664, 692, 145, 146, 696
747, 130, 661, 665, 131, 138, 693, 697, 139
748, 661, 662, 666, 665, 693, 694, 698, 697
749, 662, 663, 667, 666, 694, 695, 699, 698
750, 663, 664, 668, 667, 695, 696, 700, 699
751, 664, 134, 135, 668, 696, 146, 147, 700
752, 131, 665, 669, 132, 139, 697, 701, 140
753, 665, 666, 670, 669, 697, 698, 702, 701
754, 666, 667, 671, 670, 698, 699, 703, 702
755, 667, 668, 672, 671, 699, 700, 704, 703
756, 668, 135, 136, 672, 700, 147, 148, 704
757, 132, 669, 115, 8, 140, 701, 141, 9
758, 669, 670, 116, 115, 701, 702, 142, 141
759, 670, 671, 117, 116, 702, 703, 143, 142
760, 671, 672, 118, 117, 703, 704, 144, 143
761, 672, 136, 7, 118, 704, 148, 11, 144
*ELEMENT, type=C3D8, ELSET=Volume3
762, 10, 149, 689, 137, 157, 753, 1633, 705
763, 157, 753, 1633, 705, 158, 754, 1634, 706
764, 158, 754, 1634, 706, 159, 755, 1635, 707
765, 159, 755, 1635, 707, 160, 756, 1636, 708
766, 160, 756, 1636, 708, 14, 181, 769, 161
767, 149, 150, 690, 689, 753, 757, 1637, 1633
768, 753, 757, 1637, 1633, 754, 758, 1638, 1634
769, 754, 758, 1638, 1634, 755, 759, 1639, 1635
770, 755, 759, 1639, 1635, 756, 760, 1640, 1636
771, 756, 760, 1640, 1636, 181, 182, 770, 769
772, 150, 151, 691, 690, 757, 761, 1641, 1637
773, 757, 761, 1641, 1637, 758, 762, 1642, 1638
774, 758, 762, 1642, 1638, 759, 763, 1643, 1639
775, 759, 763, 1643, 1639, 760, 764, 1644, 1640
776, 760, 764, 1644, 1640, 182, 183, 771, 770
777, 151, 152, 692, 691, 761, 765, 1645, 1641
778, 761, 765, 1645, 1641, 762, 766, 1646, 1642
779, 762, 766, 1646, 1642, 763, 767, 1647, 1643
780, 763, 767, 1647, 1643, 764, 768, 1648, 1644
781, 764, 768, 1648, 1644, 183, 184, 772, 771
782, 152, 12, 145, 692, 765, 173, 737, 1645
783, 765, 173, 737, 1645, 766, 174, 738, 1646
784, 766, 174, 738, 1646, 767, 175, 739, 1647
785, 767, 175, 739, 1647, 768, 176, 740, 1648
786, 768, 176, 740, 1648, 184, 16, 177, 772
787, 137, 689, 693, 138, 705, 1633, 1649, 709
788, 705, 1633, 1649, 709, 706, 1634, 1650, 710
789, 706, 1634, 1650, 710, 707, 1635, 1651, 711
790, 707, 1635, 1651, 711, 708, 1636, 1652, 712
791, 708, 1636, 1652, 712, 161, 769, 773, 162
792, 689, 690, 694, 693, 1633, 1637, 1653, 1649
793, 1633, 1637, 1653, 1649, 1634, 1638, 1654, 1650
794, 1634, 1638, 1654, 1650, 1635, 1639, 1655, 1651
795, 1635, 1639, 1655, 1651, 1636, 1640, 1656, 1652
796, 1636, 1640, 1656, 1652, 769, 770, 774, 773
797, 690, 691, 695, 694, 1637, 1641, 1657, 1653
798, 1637, 1641, 1657, 1653, 1638, 1642, 1658, 1654
799, 1638, 1642, 1658, 1654, 1639, 1643, 1659, 1655
800, 1639, 1643, 1659, 1655, 1640, 1644, 1660, 1656
801, 1640, 1644, 1660, 1656, 770, 771, 775, 774
802, 691, 692, 696, 695, 1641, 1645, 1661, 1657
803, 1641, 1645, 1661, 1657, 1642, 1646, 1662, 1658
804, 1642, 1646, 1662, 1658, 1643, 1647, 1663, 1659
805, 1643, 1647, 1663, 1659, 1644, 1648, 1664, 1660
806, 1644, 1648, 1664, 1660, 771, 772, 776, 775
807, 692, 145, 146, 696, 1645, 737, 741, 1661
808, 1645, 737, 741, 1661, 1646, 738, 742, 1662
809, 1646, 738, 742, 1662, 1647, 739, 743, 1663
810, 1647, 739, 743, 1663, 1648, 740, 744, 1664
811, 1648, 740, 744, 1664, 772, 177, 178, 776
812, 138, 693, 697, 139, 709, 1649, 1665, 713
813, 709, 1649, 1665, 713, 710, 1650, 1666, 714
814, 710, 1650, 1666, 714, 711, 1651, 1667, 715
815, 711, 1651, 1667, 715, 712, 1652, 1668, 716
816, 712, 1652, 1668, 716, 162, 773, 777, 163
817, 693, 694, 698, 697, 1649, 1653, 1669, 1665
818, 1649, 1653, 1669, 1665, 1650, 1654, 1670, 1666
819, 1650, 1654, 1670, 1666, 1651, 1655, 1671, 1667
820, 1651, 1655, 1671, 1667, 1652, 1656, 1672, 1668
821, 1652, 1656, 1672, 1668, 773, 774, 778, 777
822, 694, 695, 699, 698, 1653, 1657, 1673, 1669
823, 1653, 1657, 1673, 1669, 1654, 1658, 1674, 1670
824, 1654, 1658, 1674, 1670, 1655, 1659, 1675, 1671
825, 1655, 1659, 1675, 1671, 1656, 1660, 1676, 1672
826, 1656, 1660, 1676, 1672, 774, 775, 779, 778
827, 695, 696, 700, 699, 1657, 1661, 1677, 1673
828, 1657, 1661, 1677, 1673, 1658, 1662, 1678, 1674
829, 1658, 1662, 1678, 1674, 1659, 1663, 1679, 1675
830, 1659, 1663, 1679, 1675, 1660, 1664, 1680, 1676
831, 1660, 1664, 1680, 1676, 775, 776, 780, 779
832, 696, 146, 147, 700, 1661, 741, 745, 1677
833, 1661, 741, 745, 1677, 1662, 742, 746, 1678
834, 1662, 742, 746, 1678, 1663, 743, 747, 1679
835, 1663, 743, 747, 1679, 1664, 744, 748, 1680
836, 1664, 744, 748, 1680, 776, 178, 179, 780
837, 139, 697, 701, 140, 713, 1665, 1681, 717
838, 713, 1665, 1681, 717, 714, 1666, 1682, 718
839, 714, 1666, 1682, 718, 715, 1667, 1683, 719
840, 715, 1667, 1683, 719, 716, 1668, 1684, 720
841, 716, 1668, 1684, 720, 163, 777, 781, 164
842, 697, 698, 702, 701, 1665, 1669, 1685, 1681
843, 1665, 1669, 1685, 1681, 1666, 1670, 1686, 1682
844, 1666, 1670, 1686, 1682, 1667, 1671, 1687, 1683
845, 1667, 1671, 1687, 1683, 1668, 1672, 1688, 1684
846, 1668, 1672, 1688, 1684, 777, 778, 782, 781
847, 698, 699, 703, 702, 1669, 1673, 1689, 1685
848, 1669, 1673, 1689, 1685, 1670, 1674, 1690, 1686
849, 1670, 1674, 1690, 1686, 1671, 1675, 1691, 1687
850, 1671, 1675, 1691, 1687, 1672, 1676, 1692, 1688
851, 1672, 1676, 1692, 1688, 778, 779, 783, 782
852, 699, 700, 704, 703, 1673, 1677, 1693, 1689
853, 1673, 1677, 1693, 1689, 1674, 1678, 1694, 1690
854, 1674, 1678, 1694, 1690, 1675, 1679, 1695, 1691
855, 1675, 1679, 1695, 1691, 1676, 1680, 1696, 1692
856, 1676, 1680, 1696, 1692, 779, 780, 784, 783
857, 700, 147, 148, 704, 1677, 745, 749, 1693
858, 1677, 745, 749, 1693, 1678, 746, 750, 1694
859, 1678, 746, 750, 1694, 1679, 747, 751, 1695
860, 1679, 747, 751, 1695, 1680, 748, 752, 1696
861, 1680, 748, 752, 1696, 780, 179, 180, 784
862, 140, 701, 141, 9, 717, 1681, 721, 153
863, 717, 1681, 721, 153, 718, 1682, 722, 154
864, 718, 1682, 722, 154, 719, 1683, 723, 155
865, 719, 1683, 723, 155, 720, 1684, 724, 156
866, 720, 1684, 724, 156, 164, 781, 169, 13
867, 701, 702, 142, 141, 1681, 1685, 725, 721
868, 1681, 1685, 725, 721, 1682, 1686, 726, 722
869, 1682, 1686, 726, 722, 1683, 1687, 727, 723
870, 1683, 1687, 727, 723, 1684, 1688, 728, 724
871, 1684, 1688, 728, 724, 781, 782, 170, 169
872, 702, 703, 143, 142, 1685, 1689, 729, 725
873, 1685, 1689, 729, 725, 1686, 1690, 730, 726
874, 1686, 1690, 730, 726, 1687, 1691, 731, 727
875, 1687, 1691, 731, 727, 1688, 1692, 732, 728
876, 1688, 1692, 732, 728, 782, 783, 171, 170
877, 703, 704, 144, 143, 1689, 1693, 733, 729
878, 1689, 1693, 733, 729, 1690, 1694, 734, 730
879, 1690, 1694, 734, 730, 1691, 1695, 735, 731
880, 1691, 1695, 735, 731, 1692, 1696, 736, 732
881, 1692, 1696, 736, 732, 783, 784, 172, 171
882, 704, 148, 11, 144, 1693, 749, 165, 733
883, 1693, 749, 165, 733, 1694, 750, 166, 734
884, 1694, 750, 166, 734, 1695, 751, 167, 735
885, 1695, 751, 167, 735, 1696, 752, 168, 736
886, 1696, 752, 168, 736, 784, 180, 15, 172
*ELEMENT, type=C3D8, ELSET=Volume4
887, 14, 181, 769, 161, 18, 197, 785, 185
888, 181, 182, 770, 769, 197, 198, 786, 785
889, 182, 183, 771, 770, 198, 199, 787, 786
890, 183, 184, 772, 771, 199, 200, 788, 787
891, 184, 16, 177, 772, 200, 20, 193, 788
892, 161, 769, 773, 162, 185, 785, 789, 186
893, 769, 770, 774, 773, 785, 786, 790, 789
894, 770, 771, 775, 774, 786, 787, 791, 790
895, 771, 772, 776, 775, 787, 788, 792, 791
896, 772, 177, 178, 776, 788, 193, 194, 792
897, 162, 773, 777, 163, 186, 789, 793, 187
898, 773, 774, 778, 777, 789, 790, 794, 793
899, 774, 775, 779, 778, 790, 791, 795, 794
900, 775, 776, 780, 779, 791, 792, 796, 795
901, 776, 178, 179, 780, 792, 194, 195, 796
902, 163, 777, 781, 164, 187, 793, 797, 188
903, 777, 778, 782, 781, 793, 794, 798, 797
904, 778, 779, 783, 782, 794, 795, 799, 798
905, 779, 780, 784, 783, 795, 796, 800, 799
906, 780, 179, 180, 784, 796, 195, 196, 800
907, 164, 781, 169, 13, 188, 797, 189, 17
908, 781, 782, 170, 169, 797, 798, 190, 189
909, 782, 783, 171, 170, 798, 799, 191, 190
910, 783, 784, 172, 171, 799, 800, 192, 191
911, 784, 180, 15, 172, 800, 196, 19, 192
*ELEMENT, type=C3D8, ELSET=Volume5
912, 18, 197, 785, 185, 203, 825, 1697, 801
913, 203, 825, 1697, 801, 204, 826, 1698, 802
914, 204, 826, 1698, 802, 22, 221, 833, 205
915, 197, 198, 786, 785, 825, 827, 1699, 1697
916, 825, 827, 1699, 1697, 826, 828, 1700, 1698
917, 826, 828, 1700, 1698, 221, 222, 834, 833
918, 198, 199, 787, 786, 827, 829, 1701, 1699
919, 827, 829, 1701, 1699, 828, 830, 1702, 1700
920, 828, 830, 1702, 1700, 222, 223, 835, 834
921, 199, 200, 788, 787, 829, 831, 1703, 1701
922, 829, 831, 1703, 1701, 830, 832, 1704, 1702
923, 830, 832, 1704, 1702, 223, 224, 836, 835
924, 200, 20, 193, 788, 831, 215, 817, 1703
925, 831, 215, 817, 1703, 832, 216, 818, 1704
926, 832, 216, 818, 1704, 224, 24, 217, 836
927, 185, 785, 789, 186, 801, 1697, 1705, 803
928, 801, 1697, 1705, 803, 802, 1698, 1706, 804
929, 802, 1698, 1706, 804, 205, 833, 837, 206
930, 785, 786, 790, 789, 1697, 1699, 1707, 1705
931, 1697, 1699, 1707, 1705, 1698, 1700, 1708, 1706
932, 1698, 1700, 1708, 1706, 833, 834, 838, 837
933, 786, 787, 791, 790, 1699, 1701, 1709, 1707
934, 1699, 1701, 1709, 1707, 1700, 1702, 1710, 1708
935, 1700, 1702, 1710, 1708, 834, 835, 839, 838
936, 787, 788, 792, 791, 1701, 1703, 1711, 1709
937, 1701, 1703, 1711, 1709, 1702, 1704, 1712, 1710
938, 1702, 1704, 1712, 1710, 835, 836, 840, 839
939, 788, 193, 194, 792, 1703, 817, 819, 1711
940, 1703, 817, 819, 1711, 1704, 818, 820, 1712
941, 1704, 818, 820, 1712, 836, 217, 218, 840
942, 186, 789, 793, 187, 803, 1705, 1713, 805
943, 803, 1705, 1713, 805, 804, 1706, 1714, 806
944, 804, 1706, 1714, 806, 206, 837, 841, 207
945, 789, 790, 794, 793, 1705, 1707, 1715, 1713
946, 1705, 1707, 1715, 1713, 1706, 1708, 1716, 1714
947, 1706, 1708, 1716, 1714, 837, 838, 842, 841
948, 790, 791, 795, 794, 1707, 1709, 1717, 1715
949, 1707, 1709, 1717, 1715, 1708, 1710, 1718, 1716
950, 1708, 1710, 1718, 1716, 838, 839, 843, 842
951, 791, 792, 796, 795, 1709, 1711, 1719, 1717
952, 1709, 1711, 1719, 1717, 1710, 1712, 1720, 1718
953, 1710, 1712, 1720, 1718, 839, 840, 844, 843
954, 792, 194, 195, 796, 1711, 819, 821, 1719
955, 1711, 819, 821, 1719, 1712, 820, 822, 1720
956, 1712, 820, 822, 1720, 840, 218, 219, 844
957, 187, 793, 797, 188, 805, 1713, 1721, 807
958, 805, 1713, 1721, 807, 806, 1714, 1722, 808
959, 806, 1714, 1722, 808, 207, 841, 845, 208
960, 793, 794, 798, 797, 1713, 1715, 1723, 1721
961, 1713, 1715, 1723, 1721, 1714, 1716, 1724, 1722
962, 1714, 1716, 1724, 1722, 841, 842, 846, 845
963, 794, 795, 799, 798, 1715, 1717, 1725, 1723
964, 1715, 1717, 1725, 1723, 1716, 1718, 1726, 1724
965, 1716, 1718, 1726, 1724, 842, 843, 847, 846
966, 795, 796, 800, 799, 1717, 1719, 1727, 1725
967, 1717, 1719, 1727, 1725, 1718, 1720, 1728, 1726
968, 1718, 1720, 1728, 1726, 843, 844, 848, 847
969, 796, 195, 196, 800, 1719, 821, 823, 1727
970, 1719, 821, 823, 1727, 1720, 822, 824, 1728
971, 1720, 822, 824, 1728, 844, 219, 220, 848
972, 188, 797, 189, 17, 807, 1721, 809, 201
973, 807, 1721, 809, 201, 808, 1722, 810, 202
974, 808, 1722, 810, 202, 208, 845, 211, 21
975, 797, 798, 190, 189, 1721, 1723, 811, 809
976, 1721, 1723, 811, 809, 1722, 1724, 812, 810
977, 1722, 1724, 812, 810, 845, 846, 212, 211
978, 798, 799, 191, 190, 1723, 1725, 813, 811
979, 1723, 1725, 813, 811, 1724, 1726, 814, 812
980, 1724, 1726, 814, 812, 846, 847, 213, 212
981, 799, 800, 192, 191, 1725, 1727, 815, 813
982, 1725, 1727, 815, 813, 1726, 1728, 816, 814
983, 1726, 1728, 816, 814, 847, 848, 214, 213
984, 800, 196, 19, 192, 1727, 823, 209, 815
985, 1727, 823, 209, 815, 1728, 824, 210, 816
986, 1728, 824, 210, 816, 848, 220, 23, 214
*ELEMENT, type=C3D8, ELSET=Volume6
987, 17, 201, 809, 189, 235, 857, 1729, 865
988, 235, 857, 1729, 865, 236, 858, 1730, 866
989, 236, 858, 1730, 866, 237, 859, 1731, 867
990, 237, 859, 1731, 867, 238, 860, 1732, 868
991, 238, 860, 1732, 868, 27, 243, 897, 245
992, 201, 202, 810, 809, 857, 861, 1733, 1729
993, 857, 861, 1733, 1729, 858, 862, 1734, 1730
994, 858, 862, 1734, 1730, 859, 863, 1735, 1731
995, 859, 863, 1735, 1731, 860, 864, 1736, 1732
996, 860, 864, 1736, 1732, 243, 244, 898, 897
997, 202, 21, 211, 810, 861, 239, 881, 1733
998, 861, 239, 881, 1733, 862, 240, 882, 1734
999, 862, 240, 882, 1734, 863, 241, 883, 1735
1000, 863, 241, 883, 1735, 864, 242, 884, 1736
1001, 864, 242, 884, 1736, 244, 28, 249, 898
1002, 189, 809, 811, 190, 865, 1729, 1737, 869
1003, 865, 1729, 1737, 869, 866, 1730, 1738, 870
1004, 866, 1730, 1738, 870, 867, 1731, 1739, 871
1005, 867, 1731, 1739, 871, 868, 1732, 1740, 872
1006, 868, 1732, 1740, 872, 245, 897, 899, 246
1007, 809, 810, 812, 811, 1729, 1733, 1741, 1737
1008, 1729, 1733, 1741, 1737, 1730, 1734, 1742, 1738
1009, 1730, 1734, 1742, 1738, 1731, 1735, 1743, 1739
1010, 1731, 1735, 1743, 1739, 1732, 1736, 1744, 1740
1011, 1732, 1736, 1744, 1740, 897, 898, 900, 899
1012, 810, 211, 212, 812, 1733, 881, 885, 1741
1013, 1733, 881, 885, 1741, 1734, 882, 886, 1742
1014, 1734, 882, 886, 1742, 1735, 883, 887, 1743
1015, 1735, 883, 887, 1743, 1736, 884, 888, 1744
1016, 1736, 884, 888, 1744, 898, 249, 250, 900
1017, 190, 811, 813, 191, 869, 1737, 1745, 873
1018, 869, 1737, 1745, 873, 870, 1738, 1746, 874
1019, 870, 1738, 1746, 874, 871, 1739, 1747, 875
1020, 871, 1739, 1747, 875, 872, 1740, 1748, 876
1021, 872, 1740, 1748, 876, 246, 899, 901, 247
1022, 811, 812, 814, 813, 1737, 1741, 1749, 1745
1023, 1737, 1741, 1749, 1745, 1738, 1742, 1750, 1746
1024, 1738, 1742, 1750, 1746, 1739, 1743, 1751, 1747
1025, 1739, 1743, 1751, 1747, 1740, 1744, 1752, 1748
1026, 1740, 1744, 1752, 1748, 899, 900, 902, 901
1027, 812, 212, 213, 814, 1741, 885, 889, 1749
1028, 1741, 885, 889, 1749, 1742, 886, 890, 1750
1029, 1742, 886, 890, 1750, 1743, 887, 891, 1751
1030, 1743, 887, 891, 1751, 1744, 888, 892, 1752
1031, 1744, 888, 892, 1752, 900, 250, 251, 902
1032, 191, 813, 815, 192, 873, 1745, 1753, 877
1033, 873, 1745, 1753, 877, 874, 1746, 1754, 878
1034, 874, 1746, 1754, 878, 875, 1747, 1755, 879
1035, 875, 1747, 1755, 879, 876, 1748, 1756, 880
1036, 876, 1748, 1756, 880, 247, 901, 903, 248
1037, 813, 814, 816, 815, 1745, 1749, 1757, 1753
1038, 1745, 1749, 1757, 1753, 1746, 1750, 1758, 1754
1039, 1746, 1750, 1758, 1754, 1747, 1751, 1759, 1755
1040, 1747, 1751, 1759, 1755, 1748, 1752, 1760, 1756
1041, 1748, 1752, 1760, 1756, 901, 902, 904, 903
1042, 814, 213, 214, 816, 1749, 889, 893, 1757
1043, 1749, 889, 893, 1757, 1750, 890, 894, 1758
1044, 1750, 890, 894, 1758, 1751, 891, 895, 1759
1045, 1751, 891, 895, 1759, 1752, 892, 896, 1760
1046, 1752, 892, 896, 1760, 902, 251, 252, 904
1047, 192, 815, 209, 19, 877, 1753, 849, 225
1048, 877, 1753, 849, 225, 878, 1754, 850, 226
1049, 878, 1754, 850, 226, 879, 1755, 851, 227
1050, 879, 1755, 851, 227, 880, 1756, 852, 228
1051, 880, 1756, 852, 228, 248, 903, 233, 25
1052, 815, 816, 210, 209, 1753, 1757, 853, 849
1053, 1753, 1757, 853, 849, 1754, 1758, 854, 850
1054, 1754, 1758, 854, 850, 1755, 1759, 855, 851
1055, 1755, 1759, 855, 851, 1756, 1760, 856, 852
1056, 1756, 1760, 856, 852, 903, 904, 234, 233
1057, 816, 214, 23, 210, 1757, 893, 229, 853
1058, 1757, 893, 229, 853, 1758, 894, 230, 854
1059, 1758, 894, 230, 854, 1759, 895, 231, 855
1060, 1759, 895, 231, 855, 1760, 896, 232, 856
1061, 1760, 896, 232, 856, 904, 252, 26, 234
*ELEMENT, type=C3D8, ELSET=Volume7
1062, 27, 243, 897, 245, 263, 913, 1761, 921
1063, 263, 913, 1761, 921, 264, 914, 1762, 922
1064, 264, 914, 1762, 922, 265, 915, 1763, 923
1065, 265, 915, 1763, 923, 266, 916, 1764, 924
1066, 266, 916, 1764, 924, 31, 271, 953, 273
1067, 243, 244, 898, 897, 913, 917, 1765, 1761
1068, 913, 917, 1765, 1761, 914, 918, 1766, 1762
1069, 914, 918, 1766, 1762, 915, 919, 1767, 1763
1070, 915, 919, 1767, 1763, 916, 920, 1768, 1764
1071, 916, 920, 1768, 1764, 271, 272, 954, 953
1072, 244, 28, 249, 898, 917, 267, 937, 1765
1073, 917, 267, 937, 1765, 918, 268, 938, 1766
1074, 918, 268, 938, 1766, 919, 269, 939, 1767
1075, 919, 269, 939, 1767, 920, 270, 940, 1768
1076, 920, 270, 940, 1768, 272, 32, 277, 954
1077, 245, 897, 899, 246, 921, 1761, 1769, 925
1078, 921, 1761, 1769, 925, 922, 1762, 1770, 926
1079, 922, 1762, 1770, 926, 923, 1763, 1771, 927
1080, 923, 1763, 1771, 927, 924, 1764, 1772, 928
1081, 924, 1764, 1772, 928, 273, 953, 955, 274
1082, 897, 898, 900, 899, 1761, 1765, 1773, 1769
1083, 1761, 1765, 1773, 1769, 1762, 1766, 1774, 1770
1084, 1762, 1766, 1774, 1770, 1763, 1767, 1775, 1771
1085, 1763, 1767, 1775, 1771, 1764, 1768, 1776, 1772
1086, 1764, 1768, 1776, 1772, 953, 954, 956, 955
1087, 898, 249, 250, 900, 1765, 937, 941, 1773
1088, 1765, 937, 941, 1773, 1766, 938, 942, 1774
1089, 1766, 938, 942, 1774, 1767, 939, 943, 1775
1090, 1767, 939, 943, 1775, 1768, 940, 944, 1776
1091, 1768, 940, 944, 1776, 954, 277, 278, 956
1092, 246, 899, 901, 247, 925, 1769, 1777, 929
1093, 925, 1769, 1777, 929, 926, 1770, 1778, 930
1094, 926, 1770, 1778, 930, 927, 1771, 1779, 931
1095, 927, 1771, 1779, 931, 928, 1772, 1780, 932
1096, 928, 1772, 1780, 932, 274, 955, 957, 275
1097, 899, 900, 902, 901, 1769, 1773, 1781, 1777
1098, 1769, 1773, 1781, 1777, 1770, 1774, 1782, 1778
1099, 1770, 1774, 1782, 1778, 1771, 1775, 1783, 1779
1100, 1771, 1775, 1783, 1779, 1772, 1776, 1784, 1780
1101, 1772, 1776, 1784, 1780, 955, 956, 958, 957
1102, 900, 250, 251, 902, 1773, 941, 945, 1781
1103, 1773, 941, 945, 1781, 1774, 942, 946, 1782
1104, 1774, 942, 946, 1782, 1775, 943, 947, 1783
1105, 1775, 943, 947, 1783, 1776, 944, 948, 1784
1106, 1776, 944, 948, 1784, 956, 278, 279, 958
1107, 247, 901, 903, 248, 929, 1777, 1785, 933
1108, 929, 1777, 1785, 933, 930, 1778, 1786, 934
1109, 930, 1778, 1786, 934, 931, 1779, 1787, 935
1110, 931, 1779, 1787, 935, 932, 1780, 1788, 936
1111, 932, 1780, 1788, 936, 275, 957, 959, 276
1112, 901, 902, 904, 903, 1777, 1781, 1789, 1785
1113, 1777, 1781, 1789, 1785, 1778, 1782, 1790, 1786
1114, 1778, 1782, 1790, 1786, 1779, 1783, 1791, 1787
1115, 1779, 1783, 1791, 1787, 1780, 1784, 1792, 1788
1116, 1780, 1784, 1792, 1788, 957, 958, 960, 959
1117, 902, 251, 252, 904, 1781, 945, 949, 1789
1118, 1781, 945, 949, 1789, 1782, 946, 950, 1790
1119, 1782, 946, 950, 1790, 1783, 947, 951, 1791
1120, 1783, 947, 951, 1791, 1784, 948, 952, 1792
1121, 1784, 948, 952, 1792, 958, 279, 280, 960
1122, 248, 903, 233, 25, 933, 1785, 905, 253
1123, 933, 1785, 905, 253, 934, 1786, 906, 254
1124, 934, 1786, 906, 254, 935, 1787, 907, 255
1125, 935, 1787, 907, 255, 936, 1788, 908, 256
1126, 936, 1788, 908, 256, 276, 959, 261, 29
1127, 903, 904, 234, 233, 1785, 1789, 909, 905
1128, 1785, 1789, 909, 905, 1786, 1790, 910, 906
1129, 1786, 1790, 910, 906, 1787, 1791, 911, 907
1130, 1787, 1791, 911, 907, 1788, 1792, 912, 908
1131, 1788, 1792, 912, 908, 959, 960, 262, 261
1132, 904, 252, 26, 234, 1789, 949, 257, 909
1133, 1789, 949, 257, 909, 1790, 950, 258, 910
1134, 1790, 950, 258, 910, 1791, 951, 259, 911
1135, 1791, 951, 259, 911, 1792, 952, 260, 912
1136, 1792, 952, 260, 912, 960, 280, 30, 262
*ELEMENT, type=C3D8, ELSET=Volume8
1137, 27, 263, 921, 245, 35, 285, 961, 289
1138, 263, 264, 922, 921, 285, 286, 962, 961
1139, 264, 265, 923, 922, 286, 287, 963, 962
1140, 265, 266, 924, 923, 287, 288, 964, 963
1141, 266, 31, 273, 924, 288, 36, 293, 964
1142, 245, 921, 925, 246, 289, 961, 965, 290
1143, 921, 922, 926, 925, 961, 962, 966, 965
1144, 922, 923, 927, 926, 962, 963, 967, 966
1145, 923, 924, 928, 927, 963, 964, 968, 967
1146, 924, 273, 274, 928, 964, 293, 294, 968
1147, 246, 925, 929, 247, 290, 965, 969, 291
1148, 925, 926, 930, 929, 965, 966, 970, 969
1149, 926, 927, 931, 930, 966, 967, 971, 970
1150, 927, 928, 932, 931, 967, 968, 972, 971
1151, 928, 274, 275, 932, 968, 294, 295, 972
1152, 247, 929, 933, 248, 291, 969, 973, 292
1153, 929, 930, 934, 933, 969, 970, 974, 973
1154, 930, 931, 935, 934, 970, 971, 975, 974
1155, 931, 932, 936, 935, 971, 972, 976, 975
1156, 932, 275, 276, 936, 972, 295, 296, 976
1157, 248, 933, 253, 25, 292, 973, 281, 33
1158, 933, 934, 254, 253, 973, 974, 282, 281
1159, 934, 935, 255, 254, 974, 975, 283, 282
1160, 935, 936, 256, 255, 975, 976, 284, 283
1161, 936, 276, 29, 256, 976, 296, 34, 284
*ELEMENT, type=C3D8, ELSET=Volume9
1162, 35, 285, 961, 289, 309, 993, 1793, 1009
1163, 309, 993, 1793, 1009, 310, 994, 1794, 1010
1164, 310, 994, 1794, 1010, 311, 995, 1795, 1011
1165, 311, 995, 1795, 1011, 312, 996, 1796, 1012
1166, 312, 996, 1796, 1012, 39, 317, 1041, 321
1167, 285, 286, 962, 961, 993, 997, 1797, 1793
1168, 993, 997, 1797, 1793, 994, 998, 1798, 1794
1169, 994, 998, 1798, 1794, 995, 999, 1799, 1795
1170, 995, 999, 1799, 1795, 996, 1000, 1800, 1796
1171, 996, 1000, 1800, 1796, 317, 318, 1042, 1041
1172, 286, 287, 963, 962, 997, 1001, 1801, 1797
1173, 997, 1001, 1801, 1797, 998, 1002, 1802, 1798
1174, 998, 1002, 1802, 1798, 999, 1003, 1803, 1799
1175, 999, 1003, 1803, 1799, 1000, 1004, 1804, 1800
1176, 1000, 1004, 1804, 1800, 318, 319, 1043, 1042
1177, 287, 288, 964, 963, 1001, 1005, 1805, 1801
1178, 1001, 1005, 1805, 1801, 1002, 1006, 1806, 1802
1179, 1002, 1006, 1806, 1802, 1003, 1007, 1807, 1803
1180, 1003, 1007, 1807, 1803, 1004, 1008, 1808, 1804
1181, 1004, 1008, 1808, 1804, 319, 320, 1044, 1043
1182, 288, 36, 293, 964, 1005, 313, 1025, 1805
1183, 1005, 313, 1025, 1805, 1006, 314, 1026, 1806
1184, 1006, 314, 1026, 1806, 1007, 315, 1027, 1807
1185, 1007, 315, 1027, 1807, 1008, 316, 1028, 1808
1186, 1008, 316, 1028, 1808, 320, 40, 325, 1044
1187, 289, 961, 965, 290, 1009, 1793, 1809, 1013
1188, 1009, 1793, 1809, 1013, 1010, 1794, 1810, 1014
1189, 1010, 1794, 1810, 1014, 1011, 1795, 1811, 1015
1190, 1011, 1795, 1811, 1015, 1012, 1796, 1812, 1016
1191, 1012, 1796, 1812, 1016, 321, 1041, 1045, 322
1192, 961, 962, 966, 965, 1793, 1797, 1813, 1809
1193, 1793, 1797, 1813, 1809, 1794, 1798, 1814, 1810
1194, 1794, 1798, 1814, 1810, 1795, 1799, 1815, 1811
1195, 1795, 1799, 1815, 1811, 1796, 1800, 1816, 1812
1196, 1796, 1800, 1816, 1812, 1041, 1042, 1046, 1045
1197, 962, 963, 967, 966, 1797, 1801, 1817, 1813
1198, 1797, 1801, 1817, 1813, 1798, 1802, 1818, 1814
1199, 1798, 1802, 1818, 1814, 1799, 1803, 1819, 1815
1200, 1799, 1803, 1819, 1815, 1800, 1804, 1820, 1816
1201, 1800, 1804, 1820, 1816, 1042, 1043, 1047, 1046
1202, 963, 964, 968, 967, 1801, 1805, 1821, 1817
1203, 1801, 1805, 1821, 1817, 1802, 1806, 1822, 1818
1204, 1802, 1806, 1822, 1818, 1803, 1807, 1823, 1819
1205, 1803, 1807, 1823, 1819, 1804, 1808, 1824, 1820
1206, 1804, 1808, 1824, 1820, 1043, 1044, 1048, 1047
1207, 964, 293, 294, 968, 1805, 1025, 1029, 1821
1208, 1805, 1025, 1029, 1821, 1806, 1026, 1030, 1822
1209, 1806, 1026, 1030, 1822, 1807, 1027, 1031, 1823
1210, 1807, 1027, 1031, 1823, 1808, 1028, 1032, 1824
1211, 1808, 1028, 1032, 1824, 1044, 325, 326, 1048
1212, 290, 965, 969, 291, 1013, 1809, 1825, 1017
1213, 1013, 1809, 1825, 1017, 1014, 1810, 1826, 1018
1214, 1014, 1810, 1826, 1018, 1015, 1811, 1827, 1019
1215, 1015, 1811, 1827, 1019, 1016, 1812, 1828, 1020
1216, 1016, 1812, 1828, 1020, 322, 1045, 1049, 323
1217, 965, 966, 970, 969, 1809, 1813, 1829, 1825
1218, 1809, 1813, 1829, 1825, 1810, 1814, 1830, 1826
1219, 1810, 1814, 1830, 1826, 1811, 1815, 1831, 1827
1220, 1811, 1815, 1831, 1827, 1812, 1816, 1832, 1828
1221, 1812, 1816, 1832, 1828, 1045, 1046, 1050, 1049
1222, 966, 967, 971, 970, 1813, 1817, 1833, 1829
1223, 1813, 1817, 1833, 1829, 1814, 1818, 1834, 1830
1224, 1814, 1818, 1834, 1830, 1815, 1819, 1835, 1831
1225, 1815, 1819, 1835, 1831, 1816, 1820, 1836, 1832
1226, 1816, 1820, 1836, 1832, 1046, 1047, 1051, 1050
1227, 967, 968, 972, 971, 1817, 1821, 1837, 1833
1228, 1817, 1821, 1837, 1833, 1818, 1822, 1838, 1834
1229, 1818, 1822, 1838, 1834, 1819, 1823, 1839, 1835
1230, 1819, 1823, 1839, 1835, 1820, 1824, 1840, 1836
1231, 1820, 1824, 1840, 1836, 1047, 1048, 1052, 1051
1232, 968, 294, 295, 972, 1821, 1029, 1033, 1837
1233, 1821, 1029, 1033, 1837, 1822, 1030, 1034, 1838
1234, 1822, 1030, 1034, 1838, 1823, 1031, 1035, 1839
1235, 1823, 1031, 1035, 1839, 1824, 1032, 1036, 1840
1236, 1824, 1032, 1036, 1840, 1048, 326, 327, 1052
1237, 291, 969, 973, 292, 1017, 1825, 1841, 1021
1238, 1017, 1825, 1841, 1021, 1018, 1826, 1842, 1022
1239, 1018, 1826, 1842, 1022, 1019, 1827, 1843, 1023
1240, 1019, 1827, 1843, 1023, 1020, 1828, 1844, 1024
1241, 1020, 1828, 1844, 1024, 323, 1049, 1053, 324
1242, 969, 970, 974, 973, 1825, 1829, 1845, 1841
1243, 1825, 1829, 1845, 1841, 1826, 1830, 1846, 1842
1244, 1826, 1830, 1846, 1842, 1827, 1831, 1847, 1843
1245, 1827, 1831, 1847, 1843, 1828, 1832, 1848, 1844
1246, 1828, 1832, 1848, 1844, 1049, 1050, 1054, 1053
1247, 970, 971, 975, 974, 1829, 1833, 1849, 1845
1248, 1829, 1833, 1849, 1845, 1830, 1834, 1850, 1846
1249, 1830, 1834, 1850, 1846, 1831, 1835, 1851, 1847
1250, 1831, 1835, 1851, 1847, 1832, 1836, 1852, 1848
1251, 1832, 1836, 1852, 1848, 1050, 1051, 1055, 1054
1252, 971, 972, 976, 975, 1833, 1837, 1853, 1849
1253, 1833, 1837, 1853, 1849, 1834, 1838, 1854, 1850
1254, 1834, 1838, 1854, 1850, 1835, 1839, 1855, 1851
1255, 1835, 1839, 1855, 1851, 1836, 1840, 1856, 1852
1256, 1836, 1840, 1856, 1852, 1051, 1052, 1056, 1055
1257, 972, 295, 296, 976, 1837, 1033, 1037, 1853
1258, 1837, 1033, 1037, 1853, 1838, 1034, 1038, 1854
1259, 1838, 1034, 1038, 1854, 1839, 1035, 1039, 1855
1260, 1839, 1035, 1039, 1855, 1840, 1036, 1040, 1856
1261, 1840, 1036, 1040, 1856, 1052, 327, 328, 1056
1262, 292, 973, 281, 33, 1021, 1841, 977, 297
1263, 1021, 1841, 977, 297, 1022, 1842, 978, 298
1264, 1022, 1842, 978, 298, 1023, 1843, 979, 299
1265, 1023, 1843, 979, 299, 1024, 1844, 980, 300
1266, 1024, 1844, 980, 300, 324, 1053, 305, 37
1267, 973, 974, 282, 281, 1841, 1845, 981, 977
1268, 1841, 1845, 981, 977, 1842, 1846, 982, 978
1269, 1842, 1846, 982, 978, 1843, 1847, 983, 979
1270, 1843, 1847, 983, 979, 1844, 1848, 984, 980
1271, 1844, 1848, 984, 980, 1053, 1054, 306, 305
1272, 974, 975, 283, 282, 1845, 1849, 985, 981
1273, 1845, 1849, 985, 981, 1846, 1850, 986, 982
1274, 1846, 1850, 986, 982, 1847, 1851, 987, 983
1275, 1847, 1851, 987, 983, 1848, 1852, 988, 984
1276, 1848, 1852, 988, 984, 1054, 1055, 307, 306
1277, 975, 976, 284, 283, 1849, 1853, 989, 985
1278, 1849, 1853, 989, 985, 1850, 1854, 990, 986
1279, 1850, 1854, 990, 986, 1851, 1855, 991, 987
1280, 1851, 1855, 991, 987, 1852, 1856, 992, 988
1281, 1852, 1856, 992, 988, 1055, 1056, 308, 307
1282, 976, 296, 34, 284, 1853, 1037, 301, 989
1283, 1853, 1037, 301, 989, 1854, 1038, 302, 990
1284, 1854, 1038, 302, 990, 1855, 1039, 303, 991
1285, 1855, 1039, 303, 991, 1856, 1040, 304, 992
1286, 1856, 1040, 304, 992, 1056, 328, 38, 308
*ELEMENT, type=C3D8, ELSET=Volume10
1287, 39, 317, 1041, 321, 43, 333, 1057, 337
1288, 317, 318, 1042, 1041, 333, 334, 1058, 1057
1289, 318, 319, 1043, 1042, 334, 335, 1059, 1058
1290, 319, 320, 1044, 1043, 335, 336, 1060, 1059
1291, 320, 40, 325, 1044, 336, 44, 341, 1060
1292, 321, 1041, 1045, 322, 337, 1057, 1061, 338
1293, 1041, 1042, 1046, 1045, 1057, 1058, 1062, 1061
1294, 1042, 1043, 1047, 1046, 1058, 1059, 1063, 1062
1295, 1043, 1044, 1048, 1047, 1059, 1060, 1064, 1063
1296, 1044, 325, 326, 1048, 1060, 341, 342, 1064
1297, 322, 1045, 1049, 323, 338, 1061, 1065, 339
1298, 1045, 1046, 1050, 1049, 1061, 1062, 1066, 1065
1299, 1046, 1047, 1051, 1050, 1062, 1063, 1067, 1066
1300, 1047, 1048, 1052, 1051, 1063, 1064, 1068, 1067
1301, 1048, 326, 327, 1052, 1064, 342, 343, 1068
1302, 323, 1049, 1053, 324, 339, 1065, 1069, 340
1303, 1049, 1050, 1054, 1053, 1065, 1066, 1070, 1069
1304, 1050, 1051, 1055, 1054, 1066, 1067, 1071, 1070
1305, 1051, 1052, 1056, 1055, 1067, 1068, 1072, 1071
1306, 1052, 327, 328, 1056, 1068, 343, 344, 1072
1307, 324, 1053, 305, 37, 340, 1069, 329, 41
1308, 1053, 1054, 306, 305, 1069, 1070, 330, 329
1309, 1054, 1055, 307, 306, 1070, 1071, 331, 330
1310, 1055, 1056, 308, 307, 1071, 1072, 332, 331
1311, 1056, 328, 38, 308, 1072, 344, 42, 332
*ELEMENT, type=C3D8, ELSET=Volume11
1312, 43, 333, 1057, 337, 353, 1081, 1857, 1089
1313, 353, 1081, 1857, 1089, 354, 1082, 1858, 1090
1314, 354, 1082, 1858, 1090, 47, 357, 1105, 361
1315, 333, 334, 1058, 1057, 1081, 1083, 1859, 1857
1316, 1081, 1083, 1859, 1857, 1082, 1084, 1860, 1858
1317, 1082, 1084, 1860, 1858, 357, 358, 1106, 1105
1318, 334, 335, 1059, 1058, 1083, 1085, 1861, 1859
1319, 1083, 1085, 1861, 1859, 1084, 1086, 1862, 1860
1320, 1084, 1086, 1862, 1860, 358, 359, 1107, 1106
1321, 335, 336, 1060, 1059, 1085, 1087, 1863, 1861
1322, 1085, 1087, 1863, 1861, 1086, 1088, 1864, 1862
1323, 1086, 1088, 1864, 1862, 359, 360, 1108, 1107
1324, 336, 44, 341, 1060, 1087, 355, 1097, 1863
1325, 1087, 355, 1097, 1863, 1088, 356, 1098, 1864
1326, 1088, 356, 1098, 1864, 360, 48, 365, 1108
1327, 337, 1057, 1061, 338, 1089, 1857, 1865, 1091
1328, 1089, 1857, 1865, 1091, 1090, 1858, 1866, 1092
1329, 1090, 1858, 1866, 1092, 361, 1105, 1109, 362
1330, 1057, 1058, 1062, 1061, 1857, 1859, 1867, 1865
1331, 1857, 1859, 1867, 1865, 1858, 1860, 1868, 1866
1332, 1858, 1860, 1868, 1866, 1105, 1106, 1110, 1109
1333, 1058, 1059, 1063, 1062, 1859, 1861, 1869, 1867
1334, 1859, 1861, 1869, 1867, 1860, 1862, 1870, 1868
1335, 1860, 1862, 1870, 1868, 1106, 1107, 1111, 1110
1336, 1059, 1060, 1064, 1063, 1861, 1863, 1871, 1869
1337, 1861, 1863, 1871, 1869, 1862, 1864, 1872, 1870
1338, 1862, 1864, 1872, 1870, 1107, 1108, 1112, 1111
1339, 1060, 341, 342, 1064, 1863, 1097, 1099, 1871
1340, 1863, 1097, 1099, 1871, 1864, 1098, 1100, 1872
1341, 1864, 1098, 1100, 1872, 1108, 365, 366, 1112
1342, 338, 1061, 1065, 339, 1091, 1865, 1873, 1093
1343, 1091, 1865, 1873, 1093, 1092, 1866, 1874, 1094
1344, 1092, 1866, 1874, 1094, 362, 1109, 1113, 363
1345, 1061, 1062, 1066, 1065, 1865, 1867, 1875, 1873
1346, 1865, 1867, 1875, 1873, 1866, 1868, 1876, 1874
1347, 1866, 1868, 1876, 1874, 1109, 1110, 1114, 1113
1348, 1062, 1063, 1067, 1066, 1867, 1869, 1877, 1875
1349, 1867, 1869, 1877, 1875, 1868, 1870, 1878, 1876
1350, 1868, 1870, 1878, 1876, 1110, 1111, 1115, 1114
1351, 1063, 1064, 1068, 1067, 1869, 1871, 1879, 1877
1352, 1869, 1871, 1879, 1877, 1870, 1872, 1880, 1878
1353, 1870, 1872, 1880, 1878, 1111, 1112, 1116, 1115
1354, 1064, 342, 343, 1068, 1871, 1099, 1101, 1879
1355, 1871, 1099, 1101, 1879, 1872, 1100, 1102, 1880
1356, 1872, 1100, 1102, 1880, 1112, 366, 367, 1116
1357, 339, 1065, 1069, 340, 1093, 1873, 1881, 1095
1358, 1093, 1873, 1881, 1095, 1094, 1874, 1882, 1096
1359, 1094, 1874, 1882, 1096, 363, 1113, 1117, 364
1360, 1065, 1066, 1070, 1069, 1873, 1875, 1883, 1881
1361, 1873, 1875, 1883, 1881, 1874, 1876, 1884, 1882
1362, 1874, 1876, 1884, 1882, 1113, 1114, 1118, 1117
1363, 1066, 1067, 1071, 1070, 1875, 1877, 1885, 1883
1364, 1875, 1877, 1885, 1883, 1876, 1878, 1886, 1884
1365, 1876, 1878, 1886, 1884, 1114, 1115, 1119, 1118
1366, 1067, 1068, 1072, 1071, 1877, 1879, 1887, 1885
1367, 1877, 1879, 1887, 1885, 1878, 1880, 1888, 1886
1368, 1878, 1880, 1888, 1886, 1115, 1116, 1120, 1119
1369, 1068, 343, 344, 1072, 1879, 1101, 1103, 1887
1370, 1879, 1101, 1103, 1887, 1880, 1102, 1104, 1888
1371, 1880, 1102, 1104, 1888, 1116, 367, 368, 1120
1372, 340, 1069, 329, 41, 1095, 1881, 1073, 345
1373, 1095, 1881, 1073, 345, 1096, 1882, 1074, 346
1374, 1096, 1882, 1074, 346, 364, 1117, 349, 45
1375, 1069, 1070, 330, 329, 1881, 1883, 1075, 1073
1376, 1881, 1883, 1075, 1073, 1882, 1884, 1076, 1074
1377, 1882, 1884, 1076, 1074, 1117, 1118, 350, 349
1378, 1070, 1071, 331, 330, 1883, 1885, 1077, 1075
1379, 1883, 1885, 1077, 1075, 1884, 1886, 1078, 1076
1380, 1884, 1886, 1078, 1076, 1118, 1119, 351, 350
1381, 1071, 1072, 332, 331, 1885, 1887, 1079, 1077
1382, 1885, 1887, 1079, 1077, 1886, 1888, 1080, 1078
1383, 1886, 1888, 1080, 1078, 1119, 1120, 352, 351
1384, 1072, 344, 42, 332, 1887, 1103, 347, 1079
1385, 1887, 1103, 347, 1079, 1888, 1104, 348, 1080
1386, 1888, 1104, 348, 1080, 1120, 368, 46, 352
*ELEMENT, type=C3D8, ELSET=Volume12
1387, 44, 341, 1097, 355, 51, 373, 1121, 371
1388, 355, 1097, 1098, 356, 371, 1121, 1122, 372
1389, 356, 1098, 365, 48, 372, 1122, 377, 52
1390, 341, 342, 1099, 1097, 373, 374, 1123, 1121
1391, 1097, 1099, 1100, 1098, 1121, 1123, 1124, 1122
1392, 1098, 1100, 366, 365, 1122, 1124, 378, 377
1393, 342, 343, 1101, 1099, 374, 375, 1125, 1123
1394, 1099, 1101, 1102, 1100, 1123, 1125, 1126, 1124
1395, 1100, 1102, 367, 366, 1124, 1126, 379, 378
1396, 343, 344, 1103, 1101, 375, 376, 1127, 1125
1397, 1101, 1103, 1104, 1102, 1125, 1127, 1128, 1126
1398, 1102, 1104, 368, 367, 1126, 1128, 380, 379
1399, 344, 42, 347, 1103, 376, 49, 369, 1127
1400, 1103, 347, 348, 1104, 1127, 369, 370, 1128
1401, 1104, 348, 46, 368, 1128, 370, 50, 380
*ELEMENT, type=C3D8, ELSET=Volume13
1402, 2, 97, 625, 107, 54, 381, 1129, 391
1403, 107, 625, 626, 108, 391, 1129, 1130, 392
1404, 108, 626, 103, 4, 392, 1130, 387, 56
1405, 97, 98, 627, 625, 381, 382, 1131, 1129
1406, 625, 627, 628, 626, 1129, 1131, 1132, 1130
1407, 626, 628, 104, 103, 1130, 1132, 388, 387
1408, 98, 99, 629, 627, 382, 383, 1133, 1131
1409, 627, 629, 630, 628, 1131, 1133, 1134, 1132
1410, 628, 630, 105, 104, 1132, 1134, 389, 388
1411, 99, 100, 631, 629, 383, 384, 1135, 1133
1412, 629, 631, 632, 630, 1133, 1135, 1136, 1134
1413, 630, 632, 106, 105, 1134, 1136, 390, 389
1414, 100, 1, 101, 631, 384, 53, 385, 1135
1415, 631, 101, 102, 632, 1135, 385, 386, 1136
1416, 632, 102, 3, 106, 1136, 386, 55, 390
*ELEMENT, type=C3D8, ELSET=Volume14
1417, 10, 157, 705, 137, 67, 429, 1169, 433
1418, 157, 158, 706, 705, 429, 430, 1170, 1169
1419, 158, 159, 707, 706, 430, 431, 1171, 1170
1420, 159, 160, 708, 707, 431, 432, 1172, 1171
1421, 160, 14, 161, 708, 432, 68, 437, 1172
1422, 137, 705, 709, 138, 433, 1169, 1173, 434
1423, 705, 706, 710, 709, 1169, 1170, 1174, 1173
1424, 706, 707, 711, 710, 1170, 1171, 1175, 1174
1425, 707, 708, 712, 711, 1171, 1172, 1176, 1175
1426, 708, 161, 162, 712, 1172, 437, 438, 1176
1427, 138, 709, 713, 139, 434, 1173, 1177, 435
1428, 709, 710, 714, 713, 1173, 1174, 1178, 1177
1429, 710, 711, 715, 714, 1174, 1175, 1179, 1178
1430, 711, 712, 716, 715, 1175, 1176, 1180, 1179
1431, 712, 162, 163, 716, 1176, 438, 439, 1180
1432, 139, 713, 717, 140, 435, 1177, 1181, 436
1433, 713, 714, 718, 717, 1177, 1178, 1182, 1181
1434, 714, 715, 719, 718, 1178, 1179, 1183, 1182
1435, 715, 716, 720, 719, 1179, 1180, 1184, 1183
1436, 716, 163, 164, 720, 1180, 439, 440, 1184
1437, 140, 717, 153, 9, 436, 1181, 425, 65
1438, 717, 718, 154, 153, 1181, 1182, 426, 425
1439, 718, 719, 155, 154, 1182, 1183, 427, 426
1440, 719, 720, 156, 155, 1183, 1184, 428, 427
1441, 720, 164, 13, 156, 1184, 440, 66, 428
*ELEMENT, type=C3D8, ELSET=Volume15
1442, 35, 285, 993, 309, 69, 449, 1185, 441
1443, 309, 993, 994, 310, 441, 1185, 1186, 442
1444, 310, 994, 995, 311, 442, 1186, 1187, 443
1445, 311, 995, 996, 312, 443, 1187, 1188, 444
1446, 312, 996, 317, 39, 444, 1188, 453, 70
1447, 285, 286, 997, 993, 449, 450, 1189, 1185
1448, 993, 997, 998, 994, 1185, 1189, 1190, 1186
1449, 994, 998, 999, 995, 1186, 1190, 1191, 1187
1450, 995, 999, 1000, 996, 1187, 1191, 1192, 1188
1451, 996, 1000, 318, 317, 1188, 1192, 454, 453
1452, 286, 287, 1001, 997, 450, 451, 1193, 1189
1453, 997, 1001, 1002, 998, 1189, 1193, 1194, 1190
1454, 998, 1002, 1003, 999, 1190, 1194, 1195, 1191
1455, 999, 1003, 1004, 1000, 1191, 1195, 1196, 1192
1456, 1000, 1004, 319, 318, 1192, 1196, 455, 454
1457, 287, 288, 1005, 1001, 451, 452, 1197, 1193
1458, 1001, 1005, 1006, 1002, 1193, 1197, 1198, 1194
1459, 1002, 1006, 1007, 1003, 1194, 1198, 1199, 1195
1460, 1003, 1007, 1008, 1004, 1195, 1199, 1200, 1196
1461, 1004, 1008, 320, 319, 1196, 1200, 456, 455
1462, 288, 36, 313, 1005, 452, 71, 445, 1197
1463, 1005, 313, 314, 1006, 1197, 445, 446, 1198
1464, 1006, 314, 315, 1007, 1198, 446, 447, 1199
1465, 1007, 315, 316, 1008, 1199, 447, 448, 1200
1466, 1008, 316, 40, 320, 1200, 448, 72, 456
*ELEMENT, type=C3D8, ELSET=Volume16
1467, 9, 153, 721, 141, 59, 397, 1137, 401
1468, 153, 154, 722, 721, 397, 398, 1138, 1137
1469, 154, 155, 723, 722, 398, 399, 1139, 1138
1470, 155, 156, 724, 723, 399, 400, 1140, 1139
1471, 156, 13, 169, 724, 400, 60, 405, 1140
1472, 141, 721, 725, 142, 401, 1137, 1141, 402
1473, 721, 722, 726, 725, 1137, 1138, 1142, 1141
1474, 722, 723, 727, 726, 1138, 1139, 1143, 1142
1475, 723, 724, 728, 727, 1139, 1140, 1144, 1143
1476, 724, 169, 170, 728, 1140, 405, 406, 1144
1477, 142, 725, 729, 143, 402, 1141, 1145, 403
1478, 725, 726, 730, 729, 1141, 1142, 1146, 1145
1479, 726, 727, 731, 730, 1142, 1143, 1147, 1146
1480, 727, 728, 732, 731, 1143, 1144, 1148, 1147
1481, 728, 170, 171, 732, 1144, 406, 407, 1148
1482, 143, 729, 733, 144, 403, 1145, 1149, 404
1483, 729, 730, 734, 733, 1145, 1146, 1150, 1149
1484, 730, 731, 735, 734, 1146, 1147, 1151, 1150
1485, 731, 732, 736, 735, 1147, 1148, 1152, 1151
1486, 732, 171, 172, 736, 1148, 407, 408, 1152
1487, 144, 733, 165, 11, 404, 1149, 393, 57
1488, 733, 734, 166, 165, 1149, 1150, 394, 393
1489, 734, 735, 167, 166, 1150, 1151, 395, 394
1490, 735, 736, 168, 167, 1151, 1152, 396, 395
1491, 736, 172, 15, 168, 1152, 408, 58, 396
*ELEMENT, type=C3D8, ELSET=Volume17
1492, 35, 309, 1009, 289, 63, 413, 1153, 417
1493, 309, 310, 1010, 1009, 413, 414, 1154, 1153
1494, 310, 311, 1011, 1010, 414, 415, 1155, 1154
1495, 311, 312, 1012, 1011, 415, 416, 1156, 1155
1496, 312, 39, 321, 1012, 416, 64, 421, 1156
1497, 289, 1009, 1013, 290, 417, 1153, 1157, 418
1498, 1009, 1010, 1014, 1013, 1153, 1154, 1158, 1157
1499, 1010, 1011, 1015, 1014, 1154, 1155, 1159, 1158
1500, 1011, 1012, 1016, 1015, 1155, 1156, 1160, 1159
1501, 1012, 321, 322, 1016, 1156, 421, 422, 1160
1502, 290, 1013, 1017, 291, 418, 1157, 1161, 419
1503, 1013, 1014, 1018, 1017, 1157, 1158, 1162, 1161
1504, 1014, 1015, 1019, 1018, 1158, 1159, 1163, 1162
1505, 1015, 1016, 1020, 1019, 1159, 1160, 1164, 1163
1506, 1016, 322, 323, 1020, 1160, 422, 423, 1164
1507, 291, 1017, 1021, 292, 419, 1161, 1165, 420
1508, 1017, 1018, 1022, 1021, 1161, 1162, 1166, 1165
1509, 1018, 1019, 1023, 1022, 1162, 1163, 1167, 1166
1510, 1019, 1020, 1024, 1023, 1163, 1164, 1168, 1167
1511, 1020, 323, 324, 1024, 1164, 423, 424, 1168
1512, 292, 1021, 297, 33, 420, 1165, 409, 61
1513, 1021, 1022, 298, 297, 1165, 1166, 410, 409
1514, 1022, 1023, 299, 298, 1166, 1167, 411, 410
1515, 1023, 1024, 300, 299, 1167, 1168, 412, 411
1516, 1024, 324, 37, 300, 1168, 424, 62, 412
*ELEMENT, type=C3D8, ELSET=Volume18
1517, 35, 309, 413, 63, 69, 441, 457, 73
1518, 309, 310, 414, 413, 441, 442, 458, 457
1519, 310, 311, 415, 414, 442, 443, 459, 458
1520, 311, 312, 416, 415, 443, 444, 460, 459
1521, 312, 39, 64, 416, 444, 70, 74, 460
*ELEMENT, type=C3D8, ELSET=Volume19
1522, 9, 153, 397, 59, 65, 425, 461, 75
1523, 153, 154, 398, 397, 425, 426, 462, 461
1524, 154, 155, 399, 398, 426, 427, 463, 462
1525, 155, 156, 400, 399, 427, 428, 464, 463
1526, 156, 13, 60, 400, 428, 66, 76, 464
*ELEMENT, type=C3D8, ELSET=Volume20
1527, 22, 221, 833, 205, 469, 1249, 1889, 1201
1528, 469, 1249, 1889, 1201, 470, 1250, 1890, 1202
1529, 470, 1250, 1890, 1202, 471, 1251, 1891, 1203
1530, 471, 1251, 1891, 1203, 472, 1252, 1892, 1204
1531, 472, 1252, 1892, 1204, 78, 493, 1265, 473
1532, 221, 222, 834, 833, 1249, 1253, 1893, 1889
1533, 1249, 1253, 1893, 1889, 1250, 1254, 1894, 1890
1534, 1250, 1254, 1894, 1890, 1251, 1255, 1895, 1891
1535, 1251, 1255, 1895, 1891, 1252, 1256, 1896, 1892
1536, 1252, 1256, 1896, 1892, 493, 494, 1266, 1265
1537, 222, 223, 835, 834, 1253, 1257, 1897, 1893
1538, 1253, 1257, 1897, 1893, 1254, 1258, 1898, 1894
1539, 1254, 1258, 1898, 1894, 1255, 1259, 1899, 1895
1540, 1255, 1259, 1899, 1895, 1256, 1260, 1900, 1896
1541, 1256, 1260, 1900, 1896, 494, 495, 1267, 1266
1542, 223, 224, 836, 835, 1257, 1261, 1901, 1897
1543, 1257, 1261, 1901, 1897, 1258, 1262, 1902, 1898
1544, 1258, 1262, 1902, 1898, 1259, 1263, 1903, 1899
1545, 1259, 1263, 1903, 1899, 1260, 1264, 1904, 1900
1546, 1260, 1264, 1904, 1900, 495, 496, 1268, 1267
1547, 224, 24, 217, 836, 1261, 485, 1233, 1901
1548, 1261, 485, 1233, 1901, 1262, 486, 1234, 1902
1549, 1262, 486, 1234, 1902, 1263, 487, 1235, 1903
1550, 1263, 487, 1235, 1903, 1264, 488, 1236, 1904
1551, 1264, 488, 1236, 1904, 496, 80, 489, 1268
1552, 205, 833, 837, 206, 1201, 1889, 1905, 1205
1553, 1201, 1889, 1905, 1205, 1202, 1890, 1906, 1206
1554, 1202, 1890, 1906, 1206, 1203, 1891, 1907, 1207
1555, 1203, 1891, 1907, 1207, 1204, 1892, 1908, 1208
1556, 1204, 1892, 1908, 1208, 473, 1265, 1269, 474
1557, 833, 834, 838, 837, 1889, 1893, 1909, 1905
1558, 1889, 1893, 1909, 1905, 1890, 1894, 1910, 1906
1559, 1890, 1894, 1910, 1906, 1891, 1895, 1911, 1907
1560, 1891, 1895, 1911, 1907, 1892, 1896, 1912, 1908
1561, 1892, 1896, 1912, 1908, 1265, 1266, 1270, 1269
1562, 834, 835, 839, 838, 1893, 1897, 1913, 1909
1563, 1893, 1897, 1913, 1909, 1894, 1898, 1914, 1910
1564, 1894, 1898, 1914, 1910, 1895, 1899, 1915, 1911
1565, 1895, 1899, 1915, 1911, 1896, 1900, 1916, 1912
1566, 1896, 1900, 1916, 1912, 1266, 1267, 1271, 1270
1567, 835, 836, 840, 839, 1897, 1901, 1917, 1913
1568, 1897, 1901, 1917, 1913, 1898, 1902, 1918, 1914
1569, 1898, 1902, 1918, 1914, 1899, 1903, 1919, 1915
1570, 1899, 1903, 1919, 1915, 1900, 1904, 1920, 1916
1571, 1900, 1904, 1920, 1916, 1267, 1268, 1272, 1271
1572, 836, 217, 218, 840, 1901, 1233, 1237, 1917
1573, 1901, 1233, 1237, 1917, 1902, 1234, 1238, 1918
1574, 1902, 1234, 1238, 1918, 1903, 1235, 1239, 1919
1575, 1903, 1235, 1239, 1919, 1904, 1236, 1240, 1920
1576, 1904, 1236, 1240, 1920, 1268, 489, 490, 1272
1577, 206, 837, 841, 207, 1205, 1905, 1921, 1209
1578, 1205, 1905, 1921, 1209, 1206, 1906, 1922, 1210
1579, 1206, 1906, 1922, 1210, 1207, 1907, 1923, 1211
1580, 1207, 1907, 1923, 1211, 1208, 1908, 1924, 1212
1581, 1208, 1908, 1924, 1212, 474, 1269, 1273, 475
1582, 837, 838, 842, 841, 1905, 1909, 1925, 1921
1583, 1905, 1909, 1925, 1921, 1906, 1910, 1926, 1922
1584, 1906, 1910, 1926, 1922, 1907, 1911, 1927, 1923
1585, 1907, 1911, 1927, 1923, 1908, 1912, 1928, 1924
1586, 1908, 1912, 1928, 1924, 1269, 1270, 1274, 1273
1587, 838, 839, 843, 842, 1909, 1913, 1929, 1925
1588, 1909, 1913, 1929, 1925, 1910, 1914, 1930, 1926
1589, 1910, 1914, 1930, 1926, 1911, 1915, 1931, 1927
1590, 1911, 1915, 1931, 1927, 1912, 1916, 1932, 1928
1591, 1912, 1916, 1932, 1928, 1270, 1271, 1275, 1274
1592, 839, 840, 844, 843, 1913, 1917, 1933, 1929
1593, 1913, 1917, 1933, 1929, 1914, 1918, 1934, 1930
1594, 1914, 1918, 1934, 1930, 1915, 1919, 1935, 1931
1595, 1915, 1919, 1935, 1931, 1916, 1920, 1936, 1932
1596, 1916, 1920, 1936, 1932, 1271, 1272, 1276, 1275
1597, 840, 218, 219, 844, 1917, 1237, 1241, 1933
1598, 1917, 1237, 1241, 1933, 1918, 1238, 1242, 1934
1599, 1918, 1238, 1242, 1934, 1919, 1239, 1243, 1935
1600, 1919, 1239, 1243, 1935, 1920, 1240, 1244, 1936
1601, 1920, 1240, 1244, 1936, 1272, 490, 491, 1276
1602, 207, 841, 845, 208, 1209, 1921, 1937, 1213
1603, 1209, 1921, 1937, 1213, 1210, 1922, 1938, 1214
1604, 1210, 1922, 1938, 1214, 1211, 1923, 1939, 1215
1605, 1211, 1923, 1939, 1215, 1212, 1924, 1940, 1216
1606, 1212, 1924, 1940, 1216, 475, 1273, 1277, 476
1607, 841, 842, 846, 845, 1921, 1925, 1941, 1937
1608, 1921, 1925, 1941, 1937, 1922, 1926, 1942, 1938
1609, 1922, 1926, 1942, 1938, 1923, 1927, 1943, 1939
1610, 1923, 1927, 1943, 1939, 1924, 1928, 1944, 1940
1611, 1924, 1928, 1944, 1940, 1273, 1274, 1278, 1277
1612, 842, 843, 847, 846, 1925, 1929, 1945, 1941
1613, 1925, 1929, 1945, 1941, 1926, 1930, 1946, 1942
1614, 1926, 1930, 1946, 1942, 1927, 1931, 1947, 1943
1615, 1927, 1931, 1947, 1943, 1928, 1932, 1948, 1944
1616, 1928, 1932, 1948, 1944, 1274, 1275, 1279, 1278
1617, 843, 844, 848, 847, 1929, 1933, 1949, 1945
1618, 1929, 1933, 1949, 1945, 1930, 1934, 1950, 1946
1619, 1930, 1934, 1950, 1946, 1931, 1935, 1951, 1947
1620, 1931, 1935, 1951, 1947, 1932, 1936, 1952, 1948
1621, 1932, 1936, 1952, 1948, 1275, 1276, 1280, 1279
1622, 844, 219, 220, 848, 1933, 1241, 1245, 1949
1623, 1933, 1241, 1245, 1949, 1934, 1242, 1246, 1950
1624, 1934, 1242, 1246, 1950, 1935, 1243, 1247, 1951
1625, 1935, 1243, 1247, 1951, 1936, 1244, 1248, 1952
1626, 1936, 1244, 1248, 1952, 1276, 491, 492, 1280
1627, 208, 845, 211, 21, 1213, 1937, 1217, 465
1628, 1213, 1937, 1217, 465, 1214, 1938, 1218, 466
1629, 1214, 1938, 1218, 466, 1215, 1939, 1219, 467
1630, 1215, 1939, 1219, 467, 1216, 1940, 1220, 468
1631, 1216, 1940, 1220, 468, 476, 1277, 481, 77
1632, 845, 846, 212, 211, 1937, 1941, 1221, 1217
1633, 1937, 1941, 1221, 1217, 1938, 1942, 1222, 1218
1634, 1938, 1942, 1222, 1218, 1939, 1943, 1223, 1219
1635, 1939, 1943, 1223, 1219, 1940, 1944, 1224, 1220
1636, 1940, 1944, 1224, 1220, 1277, 1278, 482, 481
1637, 846, 847, 213, 212, 1941, 1945, 1225, 1221
1638, 1941, 1945, 1225, 1221, 1942, 1946, 1226, 1222
1639, 1942, 1946, 1226, 1222, 1943, 1947, 1227, 1223
1640, 1943, 1947, 1227, 1223, 1944, 1948, 1228, 1224
1641, 1944, 1948, 1228, 1224, 1278, 1279, 483, 482
1642, 847, 848, 214, 213, 1945, 1949, 1229, 1225
1643, 1945, 1949, 1229, 1225, 1946, 1950, 1230, 1226
1644, 1946, 1950, 1230, 1226, 1947, 1951, 1231, 1227
1645, 1947, 1951, 1231, 1227, 1948, 1952, 1232, 1228
1646, 1948, 1952, 1232, 1228, 1279, 1280, 484, 483
1647, 848, 220, 23, 214, 1949, 1245, 477, 1229
1648, 1949, 1245, 477, 1229, 1950, 1246, 478, 1230
1649, 1950, 1246, 478, 1230, 1951, 1247, 479, 1231
1650, 1951, 1247, 479, 1231, 1952, 1248, 480, 1232
1651, 1952, 1248, 480, 1232, 1280, 492, 79, 484
*ELEMENT, type=C3D8, ELSET=Volume21
1652, 21, 211, 881, 239, 465, 1217, 1953, 1297
1653, 465, 1217, 1953, 1297, 466, 1218, 1954, 1298
1654, 466, 1218, 1954, 1298, 467, 1219, 1955, 1299
1655, 467, 1219, 1955, 1299, 468, 1220, 1956, 1300
1656, 468, 1220, 1956, 1300, 77, 481, 1329, 509
1657, 239, 881, 882, 240, 1297, 1953, 1957, 1301
1658, 1297, 1953, 1957, 1301, 1298, 1954, 1958, 1302
1659, 1298, 1954, 1958, 1302, 1299, 1955, 1959, 1303
1660, 1299, 1955, 1959, 1303, 1300, 1956, 1960, 1304
1661, 1300, 1956, 1960, 1304, 509, 1329, 1330, 510
1662, 240, 882, 883, 241, 1301, 1957, 1961, 1305
1663, 1301, 1957, 1961, 1305, 1302, 1958, 1962, 1306
1664, 1302, 1958, 1962, 1306, 1303, 1959, 1963, 1307
1665, 1303, 1959, 1963, 1307, 1304, 1960, 1964, 1308
1666, 1304, 1960, 1964, 1308, 510, 1330, 1331, 511
1667, 241, 883, 884, 242, 1305, 1961, 1965, 1309
1668, 1305, 1961, 1965, 1309, 1306, 1962, 1966, 1310
1669, 1306, 1962, 1966, 1310, 1307, 1963, 1967, 1311
1670, 1307, 1963, 1967, 1311, 1308, 1964, 1968, 1312
1671, 1308, 1964, 1968, 1312, 511, 1331, 1332, 512
1672, 242, 884, 249, 28, 1309, 1965, 1313, 505
1673, 1309, 1965, 1313, 505, 1310, 1966, 1314, 506
1674, 1310, 1966, 1314, 506, 1311, 1967, 1315, 507
1675, 1311, 1967, 1315, 507, 1312, 1968, 1316, 508
1676, 1312, 1968, 1316, 508, 512, 1332, 513, 82
1677, 211, 212, 885, 881, 1217, 1221, 1969, 1953
1678, 1217, 1221, 1969, 1953, 1218, 1222, 1970, 1954
1679, 1218, 1222, 1970, 1954, 1219, 1223, 1971, 1955
1680, 1219, 1223, 1971, 1955, 1220, 1224, 1972, 1956
1681, 1220, 1224, 1972, 1956, 481, 482, 1333, 1329
1682, 881, 885, 886, 882, 1953, 1969, 1973, 1957
1683, 1953, 1969, 1973, 1957, 1954, 1970, 1974, 1958
1684, 1954, 1970, 1974, 1958, 1955, 1971, 1975, 1959
1685, 1955, 1971, 1975, 1959, 1956, 1972, 1976, 1960
1686, 1956, 1972, 1976, 1960, 1329, 1333, 1334, 1330
1687, 882, 886, 887, 883, 1957, 1973, 1977, 1961
1688, 1957, 1973, 1977, 1961, 1958, 1974, 1978, 1962
1689, 1958, 1974, 1978, 1962, 1959, 1975, 1979, 1963
1690, 1959, 1975, 1979, 1963, 1960, 1976, 1980, 1964
1691, 1960, 1976, 1980, 1964, 1330, 1334, 1335, 1331
1692, 883, 887, 888, 884, 1961, 1977, 1981, 1965
1693, 1961, 1977, 1981, 1965, 1962, 1978, 1982, 1966
1694, 1962, 1978, 1982, 1966, 1963, 1979, 1983, 1967
1695, 1963, 1979, 1983, 1967, 1964, 1980, 1984, 1968
1696, 1964, 1980, 1984, 1968, 1331, 1335, 1336, 1332
1697, 884, 888, 250, 249, 1965, 1981, 1317, 1313
1698, 1965, 1981, 1317, 1313, 1966, 1982, 1318, 1314
1699, 1966, 1982, 1318, 1314, 1967, 1983, 1319, 1315
1700, 1967, 1983, 1319, 1315, 1968, 1984, 1320, 1316
1701, 1968, 1984, 1320, 1316, 1332, 1336, 514, 513
1702, 212, 213, 889, 885, 1221, 1225, 1985, 1969
1703, 1221, 1225, 1985, 1969, 1222, 1226, 1986, 1970
1704, 1222, 1226, 1986, 1970, 1223, 1227, 1987, 1971
1705, 1223, 1227, 1987, 1971, 1224, 1228, 1988, 1972
1706, 1224, 1228, 1988, 1972, 482, 483, 1337, 1333
1707, 885, 889, 890, 886, 1969, 1985, 1989, 1973
1708, 1969, 1985, 1989, 1973, 1970, 1986, 1990, 1974
1709, 1970, 1986, 1990, 1974, 1971, 1987, 1991, 1975
1710, 1971, 1987, 1991, 1975, 1972, 1988, 1992, 1976
1711, 1972, 1988, 1992, 1976, 1333, 1337, 1338, 1334
1712, 886, 890, 891, 887, 1973, 1989, 1993, 1977
1713, 1973, 1989, 1993, 1977, 1974, 1990, 1994, 1978
1714, 1974, 1990, 1994, 1978, 1975, 1991, 1995, 1979
1715, 1975, 1991, 1995, 1979, 1976, 1992, 1996, 1980
1716, 1976, 1992, 1996, 1980, 1334, 1338, 1339, 1335
1717, 887, 891, 892, 888, 1977, 1993, 1997, 1981
1718, 1977, 1993, 1997, 1981, 1978, 1994, 1998, 1982
1719, 1978, 1994, 1998, 1982, 1979, 1995, 1999, 1983
1720, 1979, 1995, 1999, 1983, 1980, 1996, 2000, 1984
1721, 1980, 1996, 2000, 1984, 1335, 1339, 1340, 1336
1722, 888, 892, 251, 250, 1981, 1997, 1321, 1317
1723, 1981, 1997, 1321, 1317, 1982, 1998, 1322, 1318
1724, 1982, 1998, 1322, 1318, 1983, 1999, 1323, 1319
1725, 1983, 1999, 1323, 1319, 1984, 2000, 1324, 1320
1726, 1984, 2000, 1324, 1320, 1336, 1340, 515, 514
1727, 213, 214, 893, 889, 1225, 1229, 2001, 1985
1728, 1225, 1229, 2001, 1985, 1226, 1230, 2002, 1986
1729, 1226, 1230, 2002, 1986, 1227, 1231, 2003, 1987
1730, 1227, 1231, 2003, 1987, 1228, 1232, 2004, 1988
1731, 1228, 1232, 2004, 1988, 483, 484, 1341, 1337
1732, 889, 893, 894, 890, 1985, 2001, 2005, 1989
1733, 1985, 2001, 2005, 1989, 1986, 2002, 2006, 1990
1734, 1986, 2002, 2006, 1990, 1987, 2003, 2007, 1991
1735, 1987, 2003, 2007, 1991, 1988, 2004, 2008, 1992
1736, 1988, 2004, 2008, 1992, 1337, 1341, 1342, 1338
1737, 890, 894, 895, 891, 1989, 2005, 2009, 1993
1738, 1989, 2005, 2009, 1993, 1990, 2006, 2010, 1994
1739, 1990, 2006, 2010, 1994, 1991, 2007, 2011, 1995
1740, 1991, 2007, 2011, 1995, 1992, 2008, 2012, 1996
1741, 1992, 2008, 2012, 1996, 1338, 1342, 1343, 1339
1742, 891, 895, 896, 892, 1993, 2009, 2013, 1997
1743, 1993, 2009, 2013, 1997, 1994, 2010, 2014, 1998
1744, 1994, 2010, 2014, 1998, 1995, 2011, 2015, 1999
1745, 1995, 2011, 2015, 1999, 1996, 2012, 2016, 2000
1746, 1996, 2012, 2016, 2000, 1339, 1343, 1344, 1340
1747, 892, 896, 252, 251, 1997, 2013, 1325, 1321
1748, 1997, 2013, 1325, 1321, 1998, 2014, 1326, 1322
1749, 1998, 2014, 1326, 1322, 1999, 2015, 1327, 1323
1750, 1999, 2015, 1327, 1323, 2000, 2016, 1328, 1324
1751, 2000, 2016, 1328, 1324, 1340, 1344, 516, 515
1752, 214, 23, 229, 893, 1229, 477, 1281, 2001
1753, 1229, 477, 1281, 2001, 1230, 478, 1282, 2002
1754, 1230, 478, 1282, 2002, 1231, 479, 1283, 2003
1755, 1231, 479, 1283, 2003, 1232, 480, 1284, 2004
1756, 1232, 480, 1284, 2004, 484, 79, 501, 1341
1757, 893, 229, 230, 894, 2001, 1281, 1285, 2005
1758, 2001, 1281, 1285, 2005, 2002, 1282, 1286, 2006
1759, 2002, 1282, 1286, 2006, 2003, 1283, 1287, 2007
1760, 2003, 1283, 1287, 2007, 2004, 1284, 1288, 2008
1761, 2004, 1284, 1288, 2008, 1341, 501, 502, 1342
1762, 894, 230, 231, 895, 2005, 1285, 1289, 2009
1763, 2005, 1285, 1289, 2009, 2006, 1286, 1290, 2010
1764, 2006, 1286, 1290, 2010, 2007, 1287, 1291, 2011
1765, 2007, 1287, 1291, 2011, 2008, 1288, 1292, 2012
1766, 2008, 1288, 1292, 2012, 1342, 502, 503, 1343
1767, 895, 231, 232, 896, 2009, 1289, 1293, 2013
1768, 2009, 1289, 1293, 2013, 2010, 1290, 1294, 2014
1769, 2010, 1290, 1294, 2014, 2011, 1291, 1295, 2015
1770, 2011, 1291, 1295, 2015, 2012, 1292, 1296, 2016
1771, 2012, 1292, 1296, 2016, 1343, 503, 504, 1344
1772, 896, 232, 26, 252, 2013, 1293, 497, 1325
1773, 2013, 1293, 497, 1325, 2014, 1294, 498, 1326
1774, 2014, 1294, 498, 1326, 2015, 1295, 499, 1327
1775, 2015, 1295, 499, 1327, 2016, 1296, 500, 1328
1776, 2016, 1296, 500, 1328, 1344, 504, 81, 516
*ELEMENT, type=C3D8, ELSET=Volume22
1777, 28, 249, 937, 267, 505, 1313, 2017, 1361
1778, 505, 1313, 2017, 1361, 506, 1314, 2018, 1362
1779, 506, 1314, 2018, 1362, 507, 1315, 2019, 1363
1780, 507, 1315, 2019, 1363, 508, 1316, 2020, 1364
1781, 508, 1316, 2020, 1364, 82, 513, 1393, 529
1782, 267, 937, 938, 268, 1361, 2017, 2021, 1365
1783, 1361, 2017, 2021, 1365, 1362, 2018, 2022, 1366
1784, 1362, 2018, 2022, 1366, 1363, 2019, 2023, 1367
1785, 1363, 2019, 2023, 1367, 1364, 2020, 2024, 1368
1786, 1364, 2020, 2024, 1368, 529, 1393, 1394, 530
1787, 268, 938, 939, 269, 1365, 2021, 2025, 1369
1788, 1365, 2021, 2025, 1369, 1366, 2022, 2026, 1370
1789, 1366, 2022, 2026, 1370, 1367, 2023, 2027, 1371
1790, 1367, 2023, 2027, 1371, 1368, 2024, 2028, 1372
1791, 1368, 2024, 2028, 1372, 530, 1394, 1395, 531
1792, 269, 939, 940, 270, 1369, 2025, 2029, 1373
1793, 1369, 2025, 2029, 1373, 1370, 2026, 2030, 1374
1794, 1370, 2026, 2030, 1374, 1371, 2027, 2031, 1375
1795, 1371, 2027, 2031, 1375, 1372, 2028, 2032, 1376
1796, 1372, 2028, 2032, 1376, 531, 1395, 1396, 532
1797, 270, 940, 277, 32, 1373, 2029, 1377, 525
1798, 1373, 2029, 1377, 525, 1374, 2030, 1378, 526
1799, 1374, 2030, 1378, 526, 1375, 2031, 1379, 527
1800, 1375, 2031, 1379, 527, 1376, 2032, 1380, 528
1801, 1376, 2032, 1380, 528, 532, 1396, 533, 84
1802, 249, 250, 941, 937, 1313, 1317, 2033, 2017
1803, 1313, 1317, 2033, 2017, 1314, 1318, 2034, 2018
1804, 1314, 1318, 2034, 2018, 1315, 1319, 2035, 2019
1805, 1315, 1319, 2035, 2019, 1316, 1320, 2036, 2020
1806, 1316, 1320, 2036, 2020, 513, 514, 1397, 1393
1807, 937, 941, 942, 938, 2017, 2033, 2037, 2021
1808, 2017, 2033, 2037, 2021, 2018, 2034, 2038, 2022
1809, 2018, 2034, 2038, 2022, 2019, 2035, 2039, 2023
1810, 2019, 2035, 2039, 2023, 2020, 2036, 2040, 2024
1811, 2020, 2036, 2040, 2024, 1393, 1397, 1398, 1394
1812, 938, 942, 943, 939, 2021, 2037, 2041, 2025
1813, 2021, 2037, 2041, 2025, 2022, 2038, 2042, 2026
1814, 2022, 2038, 2042, 2026, 2023, 2039, 2043, 2027
1815, 2023, 2039, 2043, 2027, 2024, 2040, 2044, 2028
1816, 2024, 2040, 2044, 2028, 1394, 1398, 1399, 1395
1817, 939, 943, 944, 940, 2025, 2041, 2045, 2029
1818, 2025, 2041, 2045, 2029, 2026, 2042, 2046, 2030
1819, 2026, 2042, 2046, 2030, 2027, 2043, 2047, 2031
1820, 2027, 2043, 2047, 2031, 2028, 2044, 2048, 2032
1821, 2028, 2044, 2048, 2032, 1395, 1399, 1400, 1396
1822, 940, 944, 278, 277, 2029, 2045, 1381, 1377
1823, 2029, 2045, 1381, 1377, 2030, 2046, 1382, 1378
1824, 2030, 2046, 1382, 1378, 2031, 2047, 1383, 1379
1825, 2031, 2047, 1383, 1379, 2032, 2048, 1384, 1380
1826, 2032, 2048, 1384, 1380, 1396, 1400, 534, 533
1827, 250, 251, 945, 941, 1317, 1321, 2049, 2033
1828, 1317, 1321, 2049, 2033, 1318, 1322, 2050, 2034
1829, 1318, 1322, 2050, 2034, 1319, 1323, 2051, 2035
1830, 1319, 1323, 2051, 2035, 1320, 1324, 2052, 2036
1831, 1320, 1324, 2052, 2036, 514, 515, 1401, 1397
1832, 941, 945, 946, 942, 2033, 2049, 2053, 2037
1833, 2033, 2049, 2053, 2037, 2034, 2050, 2054, 2038
1834, 2034, 2050, 2054, 2038, 2035, 2051, 2055, 2039
1835, 2035, 2051, 2055, 2039, 2036, 2052, 2056, 2040
1836, 2036, 2052, 2056, 2040, 1397, 1401, 1402, 1398
1837, 942, 946, 947, 943, 2037, 2053, 2057, 2041
1838, 2037, 2053, 2057, 2041, 2038, 2054, 2058, 2042
1839, 2038, 2054, 2058, 2042, 2039, 2055, 2059, 2043
1840, 2039, 2055, 2059, 2043, 2040, 2056, 2060, 2044
1841, 2040, 2056, 2060, 2044, 1398, 1402, 1403, 1399
1842, 943, 947, 948, 944, 2041, 2057, 2061, 2045
1843, 2041, 2057, 2061, 2045, 2042, 2058, 2062, 2046
1844, 2042, 2058, 2062, 2046, 2043, 2059, 2063, 2047
1845, 2043, 2059, 2063, 2047, 2044, 2060, 2064, 2048
1846, 2044, 2060, 2064, 2048, 1399, 1403, 1404, 1400
1847, 944, 948, 279, 278, 2045, 2061, 1385, 1381
1848, 2045, 2061, 1385, 1381, 2046, 2062, 1386, 1382
1849, 2046, 2062, 1386, 1382, 2047, 2063, 1387, 1383
1850, 2047, 2063, 1387, 1383, 2048, 2064, 1388, 1384
1851, 2048, 2064, 1388, 1384, 1400, 1404, 535, 534
1852, 251, 252, 949, 945, 1321, 1325, 2065, 2049
1853, 1321, 1325, 2065, 2049, 1322, 1326, 2066, 2050
1854, 1322, 1326, 2066, 2050, 1323, 1327, 2067, 2051
1855, 1323, 1327, 2067, 2051, 1324, 1328, 2068, 2052
1856, 1324, 1328, 2068, 2052, 515, 516, 1405, 1401
1857, 945, 949, 950, 946, 2049, 2065, 2069, 2053
1858, 2049, 2065, 2069, 2053, 2050, 2066, 2070, 2054
1859, 2050, 2066, 2070, 2054, 2051, 2067, 2071, 2055
1860, 2051, 2067, 2071, 2055, 2052, 2068, 2072, 2056
1861, 2052, 2068, 2072, 2056, 1401, 1405, 1406, 1402
1862, 946, 950, 951, 947, 2053, 2069, 2073, 2057
1863, 2053, 2069, 2073, 2057, 2054, 2070, 2074, 2058
1864, 2054, 2070, 2074, 2058, 2055, 2071, 2075, 2059
1865, 2055, 2071, 2075, 2059, 2056, 2072, 2076, 2060
1866, 2056, 2072, 2076, 2060, 1402, 1406, 1407, 1403
1867, 947, 951, 952, 948, 2057, 2073, 2077, 2061
1868, 2057, 2073, 2077, 2061, 2058, 2074, 2078, 2062
1869, 2058, 2074, 2078, 2062, 2059, 2075, 2079, 2063
1870, 2059, 2075, 2079, 2063, 2060, 2076, 2080, 2064
1871, 2060, 2076, 2080, 2064, 1403, 1407, 1408, 1404
1872, 948, 952, 280, 279, 2061, 2077, 1389, 1385
1873, 2061, 2077, 1389, 1385, 2062, 2078, 1390, 1386
1874, 2062, 2078, 1390, 1386, 2063, 2079, 1391, 1387
1875, 2063, 2079, 1391, 1387, 2064, 2080, 1392, 1388
1876, 2064, 2080, 1392, 1388, 1404, 1408, 536, 535
1877, 252, 26, 257, 949, 1325, 497, 1345, 2065
1878, 1325, 497, 1345, 2065, 1326, 498, 1346, 2066
1879, 1326, 498, 1346, 2066, 1327, 499, 1347, 2067
1880, 1327, 499, 1347, 2067, 1328, 500, 1348, 2068
1881, 1328, 500, 1348, 2068, 516, 81, 521, 1405
1882, 949, 257, 258, 950, 2065, 1345, 1349, 2069
1883, 2065, 1345, 1349, 2069, 2066, 1346, 1350, 2070
1884, 2066, 1346, 1350, 2070, 2067, 1347, 1351, 2071
1885, 2067, 1347, 1351, 2071, 2068, 1348, 1352, 2072
1886, 2068, 1348, 1352, 2072, 1405, 521, 522, 1406
1887, 950, 258, 259, 951, 2069, 1349, 1353, 2073
1888, 2069, 1349, 1353, 2073, 2070, 1350, 1354, 2074
1889, 2070, 1350, 1354, 2074, 2071, 1351, 1355, 2075
1890, 2071, 1351, 1355, 2075, 2072, 1352, 1356, 2076
1891, 2072, 1352, 1356, 2076, 1406, 522, 523, 1407
1892, 951, 259, 260, 952, 2073, 1353, 1357, 2077
1893, 2073, 1353, 1357, 2077, 2074, 1354, 1358, 2078
1894, 2074, 1354, 1358, 2078, 2075, 1355, 1359, 2079
1895, 2075, 1355, 1359, 2079, 2076, 1356, 1360, 2080
1896, 2076, 1356, 1360, 2080, 1407, 523, 524, 1408
1897, 952, 260, 30, 280, 2077, 1357, 517, 1389
1898, 2077, 1357, 517, 1389, 2078, 1358, 518, 1390
1899, 2078, 1358, 518, 1390, 2079, 1359, 519, 1391
1900, 2079, 1359, 519, 1391, 2080, 1360, 520, 1392
1901, 2080, 1360, 520, 1392, 1408, 524, 83, 536
*ELEMENT, type=C3D8, ELSET=Volume23
1902, 2, 121, 641, 97, 541, 1409, 2081, 1457
1903, 541, 1409, 2081, 1457, 542, 1410, 2082, 1458
1904, 542, 1410, 2082, 1458, 543, 1411, 2083, 1459
1905, 543, 1411, 2083, 1459, 544, 1412, 2084, 1460
1906, 544, 1412, 2084, 1460, 86, 545, 1473, 565
1907, 97, 641, 642, 98, 1457, 2081, 2085, 1461
1908, 1457, 2081, 2085, 1461, 1458, 2082, 2086, 1462
1909, 1458, 2082, 2086, 1462, 1459, 2083, 2087, 1463
1910, 1459, 2083, 2087, 1463, 1460, 2084, 2088, 1464
1911, 1460, 2084, 2088, 1464, 565, 1473, 1474, 566
1912, 98, 642, 643, 99, 1461, 2085, 2089, 1465
1913, 1461, 2085, 2089, 1465, 1462, 2086, 2090, 1466
1914, 1462, 2086, 2090, 1466, 1463, 2087, 2091, 1467
1915, 1463, 2087, 2091, 1467, 1464, 2088, 2092, 1468
1916, 1464, 2088, 2092, 1468, 566, 1474, 1475, 567
1917, 99, 643, 644, 100, 1465, 2089, 2093, 1469
1918, 1465, 2089, 2093, 1469, 1466, 2090, 2094, 1470
1919, 1466, 2090, 2094, 1470, 1467, 2091, 2095, 1471
1920, 1467, 2091, 2095, 1471, 1468, 2092, 2096, 1472
1921, 1468, 2092, 2096, 1472, 567, 1475, 1476, 568
1922, 100, 644, 125, 1, 1469, 2093, 1441, 557
1923, 1469, 2093, 1441, 557, 1470, 2094, 1442, 558
1924, 1470, 2094, 1442, 558, 1471, 2095, 1443, 559
1925, 1471, 2095, 1443, 559, 1472, 2096, 1444, 560
1926, 1472, 2096, 1444, 560, 568, 1476, 561, 88
1927, 121, 122, 645, 641, 1409, 1413, 2097, 2081
1928, 1409, 1413, 2097, 2081, 1410, 1414, 2098, 2082
1929, 1410, 1414, 2098, 2082, 1411, 1415, 2099, 2083
1930, 1411, 1415, 2099, 2083, 1412, 1416, 2100, 2084
1931, 1412, 1416, 2100, 2084, 545, 546, 1477, 1473
1932, 641, 645, 646, 642, 2081, 2097, 2101, 2085
1933, 2081, 2097, 2101, 2085, 2082, 2098, 2102, 2086
1934, 2082, 2098, 2102, 2086, 2083, 2099, 2103, 2087
1935, 2083, 2099, 2103, 2087, 2084, 2100, 2104, 2088
1936, 2084, 2100, 2104, 2088, 1473, 1477, 1478, 1474
1937, 642, 646, 647, 643, 2085, 2101, 2105, 2089
1938, 2085, 2101, 2105, 2089, 2086, 2102, 2106, 2090
1939, 2086, 2102, 2106, 2090, 2087, 2103, 2107, 2091
1940, 2087, 2103, 2107, 2091, 2088, 2104, 2108, 2092
1941, 2088, 2104, 2108, 2092, 1474, 1478, 1479, 1475
1942, 643, 647, 648, 644, 2089, 2105, 2109, 2093
1943, 2089, 2105, 2109, 2093, 2090, 2106, 2110, 2094
1944, 2090, 2106, 2110, 2094, 2091, 2107, 2111, 2095
1945, 2091, 2107, 2111, 2095, 2092, 2108, 2112, 2096
1946, 2092, 2108, 2112, 2096, 1475, 1479, 1480, 1476
1947, 644, 648, 126, 125, 2093, 2109, 1445, 1441
1948, 2093, 2109, 1445, 1441, 2094, 2110, 1446, 1442
1949, 2094, 2110, 1446, 1442, 2095, 2111, 1447, 1443
1950, 2095, 2111, 1447, 1443, 2096, 2112, 1448, 1444
1951, 2096, 2112, 1448, 1444, 1476, 1480, 562, 561
1952, 122, 123, 649, 645, 1413, 1417, 2113, 2097
1953, 1413, 1417, 2113, 2097, 1414, 1418, 2114, 2098
1954, 1414, 1418, 2114, 2098, 1415, 1419, 2115, 2099
1955, 1415, 1419, 2115, 2099, 1416, 1420, 2116, 2100
1956, 1416, 1420, 2116, 2100, 546, 547, 1481, 1477
1957, 645, 649, 650, 646, 2097, 2113, 2117, 2101
1958, 2097, 2113, 2117, 2101, 2098, 2114, 2118, 2102
1959, 2098, 2114, 2118, 2102, 2099, 2115, 2119, 2103
1960, 2099, 2115, 2119, 2103, 2100, 2116, 2120, 2104
1961, 2100, 2116, 2120, 2104, 1477, 1481, 1482, 1478
1962, 646, 650, 651, 647, 2101, 2117, 2121, 2105
1963, 2101, 2117, 2121, 2105, 2102, 2118, 2122, 2106
1964, 2102, 2118, 2122, 2106, 2103, 2119, 2123, 2107
1965, 2103, 2119, 2123, 2107, 2104, 2120, 2124, 2108
1966, 2104, 2120, 2124, 2108, 1478, 1482, 1483, 1479
1967, 647, 651, 652, 648, 2105, 2121, 2125, 2109
1968, 2105, 2121, 2125, 2109, 2106, 2122, 2126, 2110
1969, 2106, 2122, 2126, 2110, 2107, 2123, 2127, 2111
1970, 2107, 2123, 2127, 2111, 2108, 2124, 2128, 2112
1971, 2108, 2124, 2128, 2112, 1479, 1483, 1484, 1480
1972, 648, 652, 127, 126, 2109, 2125, 1449, 1445
1973, 2109, 2125, 1449, 1445, 2110, 2126, 1450, 1446
1974, 2110, 2126, 1450, 1446, 2111, 2127, 1451, 1447
1975, 2111, 2127, 1451, 1447, 2112, 2128, 1452, 1448
1976, 2112, 2128, 1452, 1448, 1480, 1484, 563, 562
1977, 123, 124, 653, 649, 1417, 1421, 2129, 2113
1978, 1417, 1421, 2129, 2113, 1418, 1422, 2130, 2114
1979, 1418, 1422, 2130, 2114, 1419, 1423, 2131, 2115
1980, 1419, 1423, 2131, 2115, 1420, 1424, 2132, 2116
1981, 1420, 1424, 2132, 2116, 547, 548, 1485, 1481
1982, 649, 653, 654, 650, 2113, 2129, 2133, 2117
1983, 2113, 2129, 2133, 2117, 2114, 2130, 2134, 2118
1984, 2114, 2130, 2134, 2118, 2115, 2131, 2135, 2119
1985, 2115, 2131, 2135, 2119, 2116, 2132, 2136, 2120
1986, 2116, 2132, 2136, 2120, 1481, 1485, 1486, 1482
1987, 650, 654, 655, 651, 2117, 2133, 2137, 2121
1988, 2117, 2133, 2137, 2121, 2118, 2134, 2138, 2122
1989, 2118, 2134, 2138, 2122, 2119, 2135, 2139, 2123
1990, 2119, 2135, 2139, 2123, 2120, 2136, 2140, 2124
1991, 2120, 2136, 2140, 2124, 1482, 1486, 1487, 1483
1992, 651, 655, 656, 652, 2121, 2137, 2141, 2125
1993, 2121, 2137, 2141, 2125, 2122, 2138, 2142, 2126
1994, 2122, 2138, 2142, 2126, 2123, 2139, 2143, 2127
1995, 2123, 2139, 2143, 2127, 2124, 2140, 2144, 2128
1996, 2124, 2140, 2144, 2128, 1483, 1487, 1488, 1484
1997, 652, 656, 128, 127, 2125, 2141, 1453, 1449
1998, 2125, 2141, 1453, 1449, 2126, 2142, 1454, 1450
1999, 2126, 2142, 1454, 1450, 2127, 2143, 1455, 1451
2000, 2127, 2143, 1455, 1451, 2128, 2144, 1456, 1452
2001, 2128, 2144, 1456, 1452, 1484, 1488, 564, 563
2002, 124, 6, 109, 653, 1421, 537, 1425, 2129
2003, 1421, 537, 1425, 2129, 1422, 538, 1426, 2130
2004, 1422, 538, 1426, 2130, 1423, 539, 1427, 2131
2005, 1423, 539, 1427, 2131, 1424, 540, 1428, 2132
2006, 1424, 540, 1428, 2132, 548, 85, 553, 1485
2007, 653, 109, 110, 654, 2129, 1425, 1429, 2133
2008, 2129, 1425, 1429, 2133, 2130, 1426, 1430, 2134
2009, 2130, 1426, 1430, 2134, 2131, 1427, 1431, 2135
2010, 2131, 1427, 1431, 2135, 2132, 1428, 1432, 2136
2011, 2132, 1428, 1432, 2136, 1485, 553, 554, 1486
2012, 654, 110, 111, 655, 2133, 1429, 1433, 2137
2013, 2133, 1429, 1433, 2137, 2134, 1430, 1434, 2138
2014, 2134, 1430, 1434, 2138, 2135, 1431, 1435, 2139
2015, 2135, 1431, 1435, 2139, 2136, 1432, 1436, 2140
2016, 2136, 1432, 1436, 2140, 1486, 554, 555, 1487
2017, 655, 111, 112, 656, 2137, 1433, 1437, 2141
2018, 2137, 1433, 1437, 2141, 2138, 1434, 1438, 2142
2019, 2138, 1434, 1438, 2142, 2139, 1435, 1439, 2143
2020, 2139, 1435, 1439, 2143, 2140, 1436, 1440, 2144
2021, 2140, 1436, 1440, 2144, 1487, 555, 556, 1488
2022, 656, 112, 5, 128, 2141, 1437, 549, 1453
2023, 2141, 1437, 549, 1453, 2142, 1438, 550, 1454
2024, 2142, 1438, 550, 1454, 2143, 1439, 551, 1455
2025, 2143, 1439, 551, 1455, 2144, 1440, 552, 1456
2026, 2144, 1440, 552, 1456, 1488, 556, 87, 564
*ELEMENT, type=C3D8, ELSET=Volume24
2027, 2, 97, 381, 54, 541, 1457, 1489, 573
2028, 541, 1457, 1489, 573, 542, 1458, 1490, 574
2029, 542, 1458, 1490, 574, 543, 1459, 1491, 575
2030, 543, 1459, 1491, 575, 544, 1460, 1492, 576
2031, 544, 1460, 1492, 576, 86, 565, 577, 90
2032, 97, 98, 382, 381, 1457, 1461, 1493, 1489
2033, 1457, 1461, 1493, 1489, 1458, 1462, 1494, 1490
2034, 1458, 1462, 1494, 1490, 1459, 1463, 1495, 1491
2035, 1459, 1463, 1495, 1491, 1460, 1464, 1496, 1492
2036, 1460, 1464, 1496, 1492, 565, 566, 578, 577
2037, 98, 99, 383, 382, 1461, 1465, 1497, 1493
2038, 1461, 1465, 1497, 1493, 1462, 1466, 1498, 1494
2039, 1462, 1466, 1498, 1494, 1463, 1467, 1499, 1495
2040, 1463, 1467, 1499, 1495, 1464, 1468, 1500, 1496
2041, 1464, 1468, 1500, 1496, 566, 567, 579, 578
2042, 99, 100, 384, 383, 1465, 1469, 1501, 1497
2043, 1465, 1469, 1501, 1497, 1466, 1470, 1502, 1498
2044, 1466, 1470, 1502, 1498, 1467, 1471, 1503, 1499
2045, 1467, 1471, 1503, 1499, 1468, 1472, 1504, 1500
2046, 1468, 1472, 1504, 1500, 567, 568, 580, 579
2047, 100, 1, 53, 384, 1469, 557, 569, 1501
2048, 1469, 557, 569, 1501, 1470, 558, 570, 1502
2049, 1470, 558, 570, 1502, 1471, 559, 571, 1503
2050, 1471, 559, 571, 1503, 1472, 560, 572, 1504
2051, 1472, 560, 572, 1504, 568, 88, 89, 580
*ELEMENT, type=C3D8, ELSET=Volume25
2052, 47, 357, 1105, 361, 593, 1521, 2145, 1537
2053, 593, 1521, 2145, 1537, 594, 1522, 2146, 1538
2054, 594, 1522, 2146, 1538, 595, 1523, 2147, 1539
2055, 595, 1523, 2147, 1539, 596, 1524, 2148, 1540
2056, 596, 1524, 2148, 1540, 93, 601, 1569, 605
2057, 357, 358, 1106, 1105, 1521, 1525, 2149, 2145
2058, 1521, 1525, 2149, 2145, 1522, 1526, 2150, 2146
2059, 1522, 1526, 2150, 2146, 1523, 1527, 2151, 2147
2060, 1523, 1527, 2151, 2147, 1524, 1528, 2152, 2148
2061, 1524, 1528, 2152, 2148, 601, 602, 1570, 1569
2062, 358, 359, 1107, 1106, 1525, 1529, 2153, 2149
2063, 1525, 1529, 2153, 2149, 1526, 1530, 2154, 2150
2064, 1526, 1530, 2154, 2150, 1527, 1531, 2155, 2151
2065, 1527, 1531, 2155, 2151, 1528, 1532, 2156, 2152
2066, 1528, 1532, 2156, 2152, 602, 603, 1571, 1570
2067, 359, 360, 1108, 1107, 1529, 1533, 2157, 2153
2068, 1529, 1533, 2157, 2153, 1530, 1534, 2158, 2154
2069, 1530, 1534, 2158, 2154, 1531, 1535, 2159, 2155
2070, 1531, 1535, 2159, 2155, 1532, 1536, 2160, 2156
2071, 1532, 1536, 2160, 2156, 603, 604, 1572, 1571
2072, 360, 48, 365, 1108, 1533, 597, 1553, 2157
2073, 1533, 597, 1553, 2157, 1534, 598, 1554, 2158
2074, 1534, 598, 1554, 2158, 1535, 599, 1555, 2159
2075, 1535, 599, 1555, 2159, 1536, 600, 1556, 2160
2076, 1536, 600, 1556, 2160, 604, 94, 609, 1572
2077, 361, 1105, 1109, 362, 1537, 2145, 2161, 1541
2078, 1537, 2145, 2161, 1541, 1538, 2146, 2162, 1542
2079, 1538, 2146, 2162, 1542, 1539, 2147, 2163, 1543
2080, 1539, 2147, 2163, 1543, 1540, 2148, 2164, 1544
2081, 1540, 2148, 2164, 1544, 605, 1569, 1573, 606
2082, 1105, 1106, 1110, 1109, 2145, 2149, 2165, 2161
2083, 2145, 2149, 2165, 2161, 2146, 2150, 2166, 2162
2084, 2146, 2150, 2166, 2162, 2147, 2151, 2167, 2163
2085, 2147, 2151, 2167, 2163, 2148, 2152, 2168, 2164
2086, 2148, 2152, 2168, 2164, 1569, 1570, 1574, 1573
2087, 1106, 1107, 1111, 1110, 2149, 2153, 2169, 2165
2088, 2149, 2153, 2169, 2165, 2150, 2154, 2170, 2166
2089, 2150, 2154, 2170, 2166, 2151, 2155, 2171, 2167
2090, 2151, 2155, 2171, 2167, 2152, 2156, 2172, 2168
2091, 2152, 2156, 2172, 2168, 1570, 1571, 1575, 1574
2092, 1107, 1108, 1112, 1111, 2153, 2157, 2173, 2169
2093, 2153, 2157, 2173, 2169, 2154, 2158, 2174, 2170
2094, 2154, 2158, 2174, 2170, 2155, 2159, 2175, 2171
2095, 2155, 2159, 2175, 2171, 2156, 2160, 2176, 2172
2096, 2156, 2160, 2176, 2172, 1571, 1572, 1576, 1575
2097, 1108, 365, 366, 1112, 2157, 1553, 1557, 2173
2098, 2157, 1553, 1557, 2173, 2158, 1554, 1558, 2174
2099, 2158, 1554, 1558, 2174, 2159, 1555, 1559, 2175
2100, 2159, 1555, 1559, 2175, 2160, 1556, 1560, 2176
2101, 2160, 1556, 1560, 2176, 1572, 609, 610, 1576
2102, 362, 1109, 1113, 363, 1541, 2161, 2177, 1545
2103, 1541, 2161, 2177, 1545, 1542, 2162, 2178, 1546
2104, 1542, 2162, 2178, 1546, 1543, 2163, 2179, 1547
2105, 1543, 2163, 2179, 1547, 1544, 2164, 2180, 1548
2106, 1544, 2164, 2180, 1548, 606, 1573, 1577, 607
2107, 1109, 1110, 1114, 1113, 2161, 2165, 2181, 2177
2108, 2161, 2165, 2181, 2177, 2162, 2166, 2182, 2178
2109, 2162, 2166, 2182, 2178, 2163, 2167, 2183, 2179
2110, 2163, 2167, 2183, 2179, 2164, 2168, 2184, 2180
2111, 2164, 2168, 2184, 2180, 1573, 1574, 1578, 1577
2112, 1110, 1111, 1115, 1114, 2165, 2169, 2185, 2181
2113, 2165, 2169, 2185, 2181, 2166, 2170, 2186, 2182
2114, 2166, 2170, 2186, 2182, 2167, 2171, 2187, 2183
2115, 2167, 2171, 2187, 2183, 2168, 2172, 2188, 2184
2116, 2168, 2172, 2188, 2184, 1574, 1575, 1579, 1578
2117, 1111, 1112, 1116, 1115, 2169, 2173, 2189, 2185
2118, 2169, 2173, 2189, 2185, 2170, 2174, 2190, 2186
2119, 2170, 2174, 2190, 2186, 2171, 2175, 2191, 2187
2120, 2171, 2175, 2191, 2187, 2172, 2176, 2192, 2188
2121, 2172, 2176, 2192, 2188, 1575, 1576, 1580, 1579
2122, 1112, 366, 367, 1116, 2173, 1557, 1561, 2189
2123, 2173, 1557, 1561, 2189, 2174, 1558, 1562, 2190
2124, 2174, 1558, 1562, 2190, 2175, 1559, 1563, 2191
2125, 2175, 1559, 1563, 2191, 2176, 1560, 1564, 2192
2126, 2176, 1560, 1564, 2192, 1576, 610, 611, 1580
2127, 363, 1113, 1117, 364, 1545, 2177, 2193, 1549
2128, 1545, 2177, 2193, 1549, 1546, 2178, 2194, 1550
2129, 1546, 2178, 2194, 1550, 1547, 2179, 2195, 1551
2130, 1547, 2179, 2195, 1551, 1548, 2180, 2196, 1552
2131, 1548, 2180, 2196, 1552, 607, 1577, 1581, 608
2132, 1113, 1114, 1118, 1117, 2177, 2181, 2197, 2193
2133, 2177, 2181, 2197, 2193, 2178, 2182, 2198, 2194
2134, 2178, 2182, 2198, 2194, 2179, 2183, 2199, 2195
2135, 2179, 2183, 2199, 2195, 2180, 2184, 2200, 2196
2136, 2180, 2184, 2200, 2196, 1577, 1578, 1582, 1581
2137, 1114, 1115, 1119, 1118, 2181, 2185, 2201, 2197
2138, 2181, 2185, 2201, 2197, 2182, 2186, 2202, 2198
2139, 2182, 2186, 2202, 2198, 2183, 2187, 2203, 2199
2140, 2183, 2187, 2203, 2199, 2184, 2188, 2204, 2200
2141, 2184, 2188, 2204, 2200, 1578, 1579, 1583, 1582
2142, 1115, 1116, 1120, 1119, 2185, 2189, 2205, 2201
2143, 2185, 2189, 2205, 2201, 2186, 2190, 2206, 2202
2144, 2186, 2190, 2206, 2202, 2187, 2191, 2207, 2203
2145, 2187, 2191, 2207, 2203, 2188, 2192, 2208, 2204
2146, 2188, 2192, 2208, 2204, 1579, 1580, 1584, 1583
2147, 1116, 367, 368, 1120, 2189, 1561, 1565, 2205
2148, 2189, 1561, 1565, 2205, 2190, 1562, 1566, 2206
2149, 2190, 1562, 1566, 2206, 2191, 1563, 1567, 2207
2150, 2191, 1563, 1567, 2207, 2192, 1564, 1568, 2208
2151, 2192, 1564, 1568, 2208, 1580, 611, 612, 1584
2152, 364, 1117, 349, 45, 1549, 2193, 1505, 581
2153, 1549, 2193, 1505, 581, 1550, 2194, 1506, 582
2154, 1550, 2194, 1506, 582, 1551, 2195, 1507, 583
2155, 1551, 2195, 1507, 583, 1552, 2196, 1508, 584
2156, 1552, 2196, 1508, 584, 608, 1581, 589, 91
2157, 1117, 1118, 350, 349, 2193, 2197, 1509, 1505
2158, 2193, 2197, 1509, 1505, 2194, 2198, 1510, 1506
2159, 2194, 2198, 1510, 1506, 2195, 2199, 1511, 1507
2160, 2195, 2199, 1511, 1507, 2196, 2200, 1512, 1508
2161, 2196, 2200, 1512, 1508, 1581, 1582, 590, 589
2162, 1118, 1119, 351, 350, 2197, 2201, 1513, 1509
2163, 2197, 2201, 1513, 1509, 2198, 2202, 1514, 1510
2164, 2198, 2202, 1514, 1510, 2199, 2203, 1515, 1511
2165, 2199, 2203, 1515, 1511, 2200, 2204, 1516, 1512
2166, 2200, 2204, 1516, 1512, 1582, 1583, 591, 590
2167, 1119, 1120, 352, 351, 2201, 2205, 1517, 1513
2168, 2201, 2205, 1517, 1513, 2202, 2206, 1518, 1514
2169, 2202, 2206, 1518, 1514, 2203, 2207, 1519, 1515
2170, 2203, 2207, 1519, 1515, 2204, 2208, 1520, 1516
2171, 2204, 2208, 1520, 1516, 1583, 1584, 592, 591
2172, 1120, 368, 46, 352, 2205, 1565, 585, 1517
2173, 2205, 1565, 585, 1517, 2206, 1566, 586, 1518
2174, 2206, 1566, 586, 1518, 2207, 1567, 587, 1519
2175, 2207, 1567, 587, 1519, 2208, 1568, 588, 1520
2176, 2208, 1568, 588, 1520, 1584, 612, 92, 592
*ELEMENT, type=C3D8, ELSET=Volume26
2177, 48, 52, 377, 365, 597, 617, 1585, 1553
2178, 597, 617, 1585, 1553, 598, 618, 1586, 1554
2179, 598, 618, 1586, 1554, 599, 619, 1587, 1555
2180, 599, 619, 1587, 1555, 600, 620, 1588, 1556
2181, 600, 620, 1588, 1556, 94, 96, 621, 609
2182, 365, 377, 378, 366, 1553, 1585, 1589, 1557
2183, 1553, 1585, 1589, 1557, 1554, 1586, 1590, 1558
2184, 1554, 1586, 1590, 1558, 1555, 1587, 1591, 1559
2185, 1555, 1587, 1591, 1559, 1556, 1588, 1592, 1560
2186, 1556, 1588, 1592, 1560, 609, 621, 622, 610
2187, 366, 378, 379, 367, 1557, 1589, 1593, 1561
2188, 1557, 1589, 1593, 1561, 1558, 1590, 1594, 1562
2189, 1558, 1590, 1594, 1562, 1559, 1591, 1595, 1563
2190, 1559, 1591, 1595, 1563, 1560, 1592, 1596, 1564
2191, 1560, 1592, 1596, 1564, 610, 622, 623, 611
2192, 367, 379, 380, 368, 1561, 1593, 1597, 1565
2193, 1561, 1593, 1597, 1565, 1562, 1594, 1598, 1566
2194, 1562, 1594, 1598, 1566, 1563, 1595, 1599, 1567
2195, 1563, 1595, 1599, 1567, 1564, 1596, 1600, 1568
2196, 1564, 1596, 1600, 1568, 611, 623, 624, 612
2197, 368, 380, 50, 46, 1565, 1597, 613, 585
2198, 1565, 1597, 613, 585, 1566, 1598, 614, 586
2199, 1566, 1598, 614, 586, 1567, 1599, 615, 587
2200, 1567, 1599, 615, 587, 1568, 1600, 616, 588
2201, 1568, 1600, 616, 588, 612, 624, 95, 92
*ELSET,ELSET=Qin
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 171, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 
*ELSET,ELSET=HeatSink
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 311, 312, 313, 314, 315, 
316, 317, 318, 319, 320, 321, 322, 323, 324, 325, 
326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 
*ELSET,ELSET=ElectrodeMaxX
344, 345, 346, 347, 348, 349, 350, 351, 352, 353, 
354, 355, 356, 357, 358, 
*ELSET,ELSET=ElectrodeMinX
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 
*ELSET,ELSET=Force
116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 
126, 127, 128, 129, 130, 
*ELSET,ELSET=Ceramic_Top
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 429, 430, 431, 432, 433, 434, 435, 436, 
437, 438, 439, 440, 441, 467, 468, 469, 470, 471, 
472, 473, 474, 475, 476, 477, 478, 479, 480, 481, 
482, 483, 484, 485, 486, 487, 488, 489, 490, 491, 
517, 518, 519, 520, 521, 522, 523, 524, 525, 526, 
527, 528, 529, 530, 531, 532, 533, 534, 535, 536, 
537, 538, 539, 540, 541, 
*ELSET,ELSET=Ceramic_Bottom
442, 443, 444, 445, 446, 447, 448, 449, 450, 451, 
452, 453, 454, 455, 456, 457, 458, 459, 460, 461, 
462, 463, 464, 465, 466, 567, 568, 569, 570, 571, 
572, 573, 574, 575, 576, 577, 578, 579, 580, 581, 
582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 
627, 628, 629, 630, 631, 632, 633, 634, 635, 636, 
637, 638, 639, 640, 641, 642, 643, 644, 645, 646, 
647, 648, 649, 650, 651, 
*ELSET,ELSET=Top_Semiconductors
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 241, 242, 243, 244, 245, 
246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 
256, 257, 258, 259, 260, 261, 262, 263, 264, 265, 
*ELSET,ELSET=top
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 429, 430, 431, 432, 433, 434, 435, 436, 
437, 438, 439, 440, 441, 467, 468, 469, 470, 471, 
472, 473, 474, 475, 476, 477, 478, 479, 480, 481, 
482, 483, 484, 485, 486, 487, 488, 489, 490, 491, 
517, 518, 519, 520, 521, 522, 523, 524, 525, 526, 
527, 528, 529, 530, 531, 532, 533, 534, 535, 536, 
537, 538, 539, 540, 541, 
*ELSET,ELSET=bottom
567, 568, 569, 570, 571, 572, 573, 574, 575, 576, 
577, 578, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 597, 598, 599, 600, 601, 
627, 628, 629, 630, 631, 632, 633, 634, 635, 636, 
637, 638, 639, 640, 641, 642, 643, 644, 645, 646, 
647, 648, 649, 650, 651, 657, 658, 659, 660, 661, 
*ELSET,ELSET=symmetry
26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 
36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 
46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 
56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 
66, 67, 68, 69, 70, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
196, 197, 198, 199, 200, 201, 202, 203, 204, 205, 
206, 207, 208, 209, 210, 236, 237, 238, 239, 240, 
266, 267, 268, 269, 270, 271, 272, 273, 274, 275, 
276, 277, 278, 279, 280, 281, 282, 283, 284, 285, 
286, 287, 288, 289, 290, 291, 292, 293, 294, 295, 
296, 297, 298, 299, 300, 301, 302, 303, 304, 305, 
306, 307, 308, 309, 310, 336, 337, 338, 364, 365, 
366, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 442, 443, 444, 445, 
446, 447, 448, 449, 450, 451, 452, 453, 454, 455, 
456, 457, 458, 459, 460, 461, 462, 463, 464, 465, 
466, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 542, 543, 544, 545, 
546, 547, 548, 549, 550, 551, 552, 553, 554, 555, 
556, 557, 558, 559, 560, 561, 562, 563, 564, 565, 
566, 592, 593, 594, 595, 596, 602, 603, 604, 605, 
606, 607, 608, 609, 610, 611, 612, 613, 614, 615, 
616, 617, 618, 619, 620, 621, 622, 623, 624, 625, 
626, 652, 653, 654, 655, 656, 
*ELSET,ELSET=Ceramic_Contact
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 131, 132, 133, 134, 135, 
136, 137, 138, 139, 140, 141, 142, 143, 144, 145, 
146, 147, 148, 149, 150, 151, 152, 153, 154, 155, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 311, 312, 313, 314, 315, 
316, 317, 318, 319, 320, 321, 322, 323, 324, 325, 
326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 
339, 340, 341, 342, 343, 359, 360, 361, 362, 363, 
*ELSET,ELSET=Contact_CeramicTop
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 171, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
