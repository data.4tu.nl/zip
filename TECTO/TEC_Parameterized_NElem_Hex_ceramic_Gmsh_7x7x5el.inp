*ELEMENT, type=T3D2, ELSET=Line156
646, 70, 507
647, 507, 508
648, 508, 509
649, 509, 510
650, 510, 511
651, 511, 512
652, 512, 72
*ELEMENT, type=T3D2, ELSET=Line157
653, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
654, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
655, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
656, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
657, 73, 513
658, 513, 514
659, 514, 515
660, 515, 516
661, 516, 517
662, 517, 518
663, 518, 74
*ELEMENT, type=T3D2, ELSET=Line162
664, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
665, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
666, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
667, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
668, 75, 519
669, 519, 520
670, 520, 521
671, 521, 522
672, 522, 523
673, 523, 524
674, 524, 76
*ELEMENT, type=T3D2, ELSET=Line167
675, 21, 525
676, 525, 526
677, 526, 527
678, 527, 528
679, 528, 77
*ELEMENT, type=T3D2, ELSET=Line168
680, 22, 529
681, 529, 530
682, 530, 531
683, 531, 532
684, 532, 78
*ELEMENT, type=T3D2, ELSET=Line169
685, 78, 533
686, 533, 534
687, 534, 535
688, 535, 536
689, 536, 537
690, 537, 538
691, 538, 77
*ELEMENT, type=T3D2, ELSET=Line170
692, 23, 539
693, 539, 540
694, 540, 541
695, 541, 542
696, 542, 79
*ELEMENT, type=T3D2, ELSET=Line171
697, 77, 543
698, 543, 544
699, 544, 545
700, 545, 79
*ELEMENT, type=T3D2, ELSET=Line172
701, 24, 546
702, 546, 547
703, 547, 548
704, 548, 549
705, 549, 80
*ELEMENT, type=T3D2, ELSET=Line173
706, 80, 550
707, 550, 551
708, 551, 552
709, 552, 553
710, 553, 554
711, 554, 555
712, 555, 79
*ELEMENT, type=T3D2, ELSET=Line174
713, 78, 556
714, 556, 557
715, 557, 558
716, 558, 80
*ELEMENT, type=T3D2, ELSET=Line175
717, 26, 559
718, 559, 560
719, 560, 561
720, 561, 562
721, 562, 81
*ELEMENT, type=T3D2, ELSET=Line176
722, 79, 563
723, 563, 564
724, 564, 565
725, 565, 566
726, 566, 81
*ELEMENT, type=T3D2, ELSET=Line177
727, 28, 567
728, 567, 568
729, 568, 569
730, 569, 570
731, 570, 82
*ELEMENT, type=T3D2, ELSET=Line178
732, 77, 571
733, 571, 572
734, 572, 573
735, 573, 574
736, 574, 82
*ELEMENT, type=T3D2, ELSET=Line179
737, 82, 575
738, 575, 576
739, 576, 577
740, 577, 81
*ELEMENT, type=T3D2, ELSET=Line180
741, 30, 578
742, 578, 579
743, 579, 580
744, 580, 581
745, 581, 83
*ELEMENT, type=T3D2, ELSET=Line181
746, 81, 582
747, 582, 583
748, 583, 584
749, 584, 585
750, 585, 586
751, 586, 587
752, 587, 83
*ELEMENT, type=T3D2, ELSET=Line182
753, 32, 588
754, 588, 589
755, 589, 590
756, 590, 591
757, 591, 84
*ELEMENT, type=T3D2, ELSET=Line183
758, 82, 592
759, 592, 593
760, 593, 594
761, 594, 595
762, 595, 596
763, 596, 597
764, 597, 84
*ELEMENT, type=T3D2, ELSET=Line184
765, 84, 598
766, 598, 599
767, 599, 600
768, 600, 83
*ELEMENT, type=T3D2, ELSET=Line185
769, 6, 601
770, 601, 602
771, 602, 603
772, 603, 604
773, 604, 85
*ELEMENT, type=T3D2, ELSET=Line186
774, 2, 605
775, 605, 606
776, 606, 607
777, 607, 608
778, 608, 86
*ELEMENT, type=T3D2, ELSET=Line187
779, 86, 609
780, 609, 610
781, 610, 611
782, 611, 612
783, 612, 613
784, 613, 614
785, 614, 85
*ELEMENT, type=T3D2, ELSET=Line188
786, 5, 615
787, 615, 616
788, 616, 617
789, 617, 618
790, 618, 87
*ELEMENT, type=T3D2, ELSET=Line189
791, 85, 619
792, 619, 620
793, 620, 621
794, 621, 87
*ELEMENT, type=T3D2, ELSET=Line190
795, 1, 622
796, 622, 623
797, 623, 624
798, 624, 625
799, 625, 88
*ELEMENT, type=T3D2, ELSET=Line191
800, 88, 626
801, 626, 627
802, 627, 628
803, 628, 629
804, 629, 630
805, 630, 631
806, 631, 87
*ELEMENT, type=T3D2, ELSET=Line192
807, 86, 632
808, 632, 633
809, 633, 634
810, 634, 88
*ELEMENT, type=T3D2, ELSET=Line193
811, 53, 635
812, 635, 636
813, 636, 637
814, 637, 638
815, 638, 89
*ELEMENT, type=T3D2, ELSET=Line194
816, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
817, 54, 639
818, 639, 640
819, 640, 641
820, 641, 642
821, 642, 90
*ELEMENT, type=T3D2, ELSET=Line196
822, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
823, 90, 643
824, 643, 644
825, 644, 645
826, 645, 89
*ELEMENT, type=T3D2, ELSET=Line198
827, 45, 646
828, 646, 647
829, 647, 648
830, 648, 649
831, 649, 91
*ELEMENT, type=T3D2, ELSET=Line199
832, 46, 650
833, 650, 651
834, 651, 652
835, 652, 653
836, 653, 92
*ELEMENT, type=T3D2, ELSET=Line200
837, 91, 654
838, 654, 655
839, 655, 656
840, 656, 657
841, 657, 658
842, 658, 659
843, 659, 92
*ELEMENT, type=T3D2, ELSET=Line201
844, 47, 660
845, 660, 661
846, 661, 662
847, 662, 663
848, 663, 93
*ELEMENT, type=T3D2, ELSET=Line202
849, 48, 664
850, 664, 665
851, 665, 666
852, 666, 667
853, 667, 94
*ELEMENT, type=T3D2, ELSET=Line203
854, 93, 668
855, 668, 669
856, 669, 670
857, 670, 671
858, 671, 672
859, 672, 673
860, 673, 94
*ELEMENT, type=T3D2, ELSET=Line204
861, 93, 674
862, 674, 675
863, 675, 676
864, 676, 91
*ELEMENT, type=T3D2, ELSET=Line205
865, 94, 677
866, 677, 678
867, 678, 679
868, 679, 92
*ELEMENT, type=T3D2, ELSET=Line206
869, 50, 680
870, 680, 681
871, 681, 682
872, 682, 683
873, 683, 95
*ELEMENT, type=T3D2, ELSET=Line207
874, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
875, 52, 684
876, 684, 685
877, 685, 686
878, 686, 687
879, 687, 96
*ELEMENT, type=T3D2, ELSET=Line209
880, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
881, 96, 688
882, 688, 689
883, 689, 690
884, 690, 95
*ELEMENT, type=CPS4, ELSET=Surface1
885, 2, 97, 691, 105
886, 105, 691, 692, 106
887, 106, 692, 102, 4
888, 97, 98, 693, 691
889, 691, 693, 694, 692
890, 692, 694, 103, 102
891, 98, 99, 695, 693
892, 693, 695, 696, 694
893, 694, 696, 104, 103
894, 99, 1, 100, 695
895, 695, 100, 101, 696
896, 696, 101, 3, 104
*ELEMENT, type=CPS4, ELSET=Surface2
897, 6, 115, 697, 107
898, 115, 116, 698, 697
899, 116, 8, 112, 698
900, 107, 697, 699, 108
901, 697, 698, 700, 699
902, 698, 112, 113, 700
903, 108, 699, 701, 109
904, 699, 700, 702, 701
905, 700, 113, 114, 702
906, 109, 701, 110, 5
907, 701, 702, 111, 110
908, 702, 114, 7, 111
*ELEMENT, type=CPS4, ELSET=Surface3
909, 2, 117, 703, 97
910, 97, 703, 704, 98
911, 98, 704, 705, 99
912, 99, 705, 123, 1
913, 117, 118, 706, 703
914, 703, 706, 707, 704
915, 704, 707, 708, 705
916, 705, 708, 124, 123
917, 118, 119, 709, 706
918, 706, 709, 710, 707
919, 707, 710, 711, 708
920, 708, 711, 125, 124
921, 119, 120, 712, 709
922, 709, 712, 713, 710
923, 710, 713, 714, 711
924, 711, 714, 126, 125
925, 120, 121, 715, 712
926, 712, 715, 716, 713
927, 713, 716, 717, 714
928, 714, 717, 127, 126
929, 121, 122, 718, 715
930, 715, 718, 719, 716
931, 716, 719, 720, 717
932, 717, 720, 128, 127
933, 122, 6, 107, 718
934, 718, 107, 108, 719
935, 719, 108, 109, 720
936, 720, 109, 5, 128
*ELEMENT, type=CPS4, ELSET=Surface4
937, 4, 102, 721, 129
938, 102, 103, 722, 721
939, 103, 104, 723, 722
940, 104, 3, 135, 723
941, 129, 721, 724, 130
942, 721, 722, 725, 724
943, 722, 723, 726, 725
944, 723, 135, 136, 726
945, 130, 724, 727, 131
946, 724, 725, 728, 727
947, 725, 726, 729, 728
948, 726, 136, 137, 729
949, 131, 727, 730, 132
950, 727, 728, 731, 730
951, 728, 729, 732, 731
952, 729, 137, 138, 732
953, 132, 730, 733, 133
954, 730, 731, 734, 733
955, 731, 732, 735, 734
956, 732, 138, 139, 735
957, 133, 733, 736, 134
958, 733, 734, 737, 736
959, 734, 735, 738, 737
960, 735, 139, 140, 738
961, 134, 736, 112, 8
962, 736, 737, 113, 112
963, 737, 738, 114, 113
964, 738, 140, 7, 114
*ELEMENT, type=CPS4, ELSET=Surface5
965, 2, 105, 739, 117
966, 117, 739, 740, 118
967, 118, 740, 741, 119
968, 119, 741, 742, 120
969, 120, 742, 743, 121
970, 121, 743, 744, 122
971, 122, 744, 115, 6
972, 105, 106, 745, 739
973, 739, 745, 746, 740
974, 740, 746, 747, 741
975, 741, 747, 748, 742
976, 742, 748, 749, 743
977, 743, 749, 750, 744
978, 744, 750, 116, 115
979, 106, 4, 129, 745
980, 745, 129, 130, 746
981, 746, 130, 131, 747
982, 747, 131, 132, 748
983, 748, 132, 133, 749
984, 749, 133, 134, 750
985, 750, 134, 8, 116
*ELEMENT, type=CPS4, ELSET=Surface6
986, 1, 123, 751, 100
987, 123, 124, 752, 751
988, 124, 125, 753, 752
989, 125, 126, 754, 753
990, 126, 127, 755, 754
991, 127, 128, 756, 755
992, 128, 5, 110, 756
993, 100, 751, 757, 101
994, 751, 752, 758, 757
995, 752, 753, 759, 758
996, 753, 754, 760, 759
997, 754, 755, 761, 760
998, 755, 756, 762, 761
999, 756, 110, 111, 762
1000, 101, 757, 135, 3
1001, 757, 758, 136, 135
1002, 758, 759, 137, 136
1003, 759, 760, 138, 137
1004, 760, 761, 139, 138
1005, 761, 762, 140, 139
1006, 762, 111, 7, 140
*ELEMENT, type=CPS4, ELSET=Surface7
1007, 4, 10, 141, 129
1008, 129, 141, 142, 130
1009, 130, 142, 143, 131
1010, 131, 143, 144, 132
1011, 132, 144, 145, 133
1012, 133, 145, 146, 134
1013, 134, 146, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
1014, 8, 9, 147, 112
1015, 112, 147, 148, 113
1016, 113, 148, 149, 114
1017, 114, 149, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
1018, 3, 135, 150, 12
1019, 135, 136, 151, 150
1020, 136, 137, 152, 151
1021, 137, 138, 153, 152
1022, 138, 139, 154, 153
1023, 139, 140, 155, 154
1024, 140, 7, 11, 155
*ELEMENT, type=CPS4, ELSET=Surface10
1025, 4, 102, 156, 10
1026, 102, 103, 157, 156
1027, 103, 104, 158, 157
1028, 104, 3, 12, 158
*ELEMENT, type=CPS4, ELSET=Surface11
1029, 10, 156, 763, 141
1030, 156, 157, 764, 763
1031, 157, 158, 765, 764
1032, 158, 12, 150, 765
1033, 141, 763, 766, 142
1034, 763, 764, 767, 766
1035, 764, 765, 768, 767
1036, 765, 150, 151, 768
1037, 142, 766, 769, 143
1038, 766, 767, 770, 769
1039, 767, 768, 771, 770
1040, 768, 151, 152, 771
1041, 143, 769, 772, 144
1042, 769, 770, 773, 772
1043, 770, 771, 774, 773
1044, 771, 152, 153, 774
1045, 144, 772, 775, 145
1046, 772, 773, 776, 775
1047, 773, 774, 777, 776
1048, 774, 153, 154, 777
1049, 145, 775, 778, 146
1050, 775, 776, 779, 778
1051, 776, 777, 780, 779
1052, 777, 154, 155, 780
1053, 146, 778, 147, 9
1054, 778, 779, 148, 147
1055, 779, 780, 149, 148
1056, 780, 155, 11, 149
*ELEMENT, type=CPS4, ELSET=Surface12
1057, 10, 165, 781, 141
1058, 165, 166, 782, 781
1059, 166, 167, 783, 782
1060, 167, 168, 784, 783
1061, 168, 169, 785, 784
1062, 169, 170, 786, 785
1063, 170, 14, 171, 786
1064, 141, 781, 787, 142
1065, 781, 782, 788, 787
1066, 782, 783, 789, 788
1067, 783, 784, 790, 789
1068, 784, 785, 791, 790
1069, 785, 786, 792, 791
1070, 786, 171, 172, 792
1071, 142, 787, 793, 143
1072, 787, 788, 794, 793
1073, 788, 789, 795, 794
1074, 789, 790, 796, 795
1075, 790, 791, 797, 796
1076, 791, 792, 798, 797
1077, 792, 172, 173, 798
1078, 143, 793, 799, 144
1079, 793, 794, 800, 799
1080, 794, 795, 801, 800
1081, 795, 796, 802, 801
1082, 796, 797, 803, 802
1083, 797, 798, 804, 803
1084, 798, 173, 174, 804
1085, 144, 799, 805, 145
1086, 799, 800, 806, 805
1087, 800, 801, 807, 806
1088, 801, 802, 808, 807
1089, 802, 803, 809, 808
1090, 803, 804, 810, 809
1091, 804, 174, 175, 810
1092, 145, 805, 811, 146
1093, 805, 806, 812, 811
1094, 806, 807, 813, 812
1095, 807, 808, 814, 813
1096, 808, 809, 815, 814
1097, 809, 810, 816, 815
1098, 810, 175, 176, 816
1099, 146, 811, 159, 9
1100, 811, 812, 160, 159
1101, 812, 813, 161, 160
1102, 813, 814, 162, 161
1103, 814, 815, 163, 162
1104, 815, 816, 164, 163
1105, 816, 176, 13, 164
*ELEMENT, type=CPS4, ELSET=Surface13
1106, 9, 159, 817, 147
1107, 159, 160, 818, 817
1108, 160, 161, 819, 818
1109, 161, 162, 820, 819
1110, 162, 163, 821, 820
1111, 163, 164, 822, 821
1112, 164, 13, 183, 822
1113, 147, 817, 823, 148
1114, 817, 818, 824, 823
1115, 818, 819, 825, 824
1116, 819, 820, 826, 825
1117, 820, 821, 827, 826
1118, 821, 822, 828, 827
1119, 822, 183, 184, 828
1120, 148, 823, 829, 149
1121, 823, 824, 830, 829
1122, 824, 825, 831, 830
1123, 825, 826, 832, 831
1124, 826, 827, 833, 832
1125, 827, 828, 834, 833
1126, 828, 184, 185, 834
1127, 149, 829, 177, 11
1128, 829, 830, 178, 177
1129, 830, 831, 179, 178
1130, 831, 832, 180, 179
1131, 832, 833, 181, 180
1132, 833, 834, 182, 181
1133, 834, 185, 15, 182
*ELEMENT, type=CPS4, ELSET=Surface14
1134, 12, 150, 835, 186
1135, 186, 835, 836, 187
1136, 187, 836, 837, 188
1137, 188, 837, 838, 189
1138, 189, 838, 839, 190
1139, 190, 839, 840, 191
1140, 191, 840, 192, 16
1141, 150, 151, 841, 835
1142, 835, 841, 842, 836
1143, 836, 842, 843, 837
1144, 837, 843, 844, 838
1145, 838, 844, 845, 839
1146, 839, 845, 846, 840
1147, 840, 846, 193, 192
1148, 151, 152, 847, 841
1149, 841, 847, 848, 842
1150, 842, 848, 849, 843
1151, 843, 849, 850, 844
1152, 844, 850, 851, 845
1153, 845, 851, 852, 846
1154, 846, 852, 194, 193
1155, 152, 153, 853, 847
1156, 847, 853, 854, 848
1157, 848, 854, 855, 849
1158, 849, 855, 856, 850
1159, 850, 856, 857, 851
1160, 851, 857, 858, 852
1161, 852, 858, 195, 194
1162, 153, 154, 859, 853
1163, 853, 859, 860, 854
1164, 854, 860, 861, 855
1165, 855, 861, 862, 856
1166, 856, 862, 863, 857
1167, 857, 863, 864, 858
1168, 858, 864, 196, 195
1169, 154, 155, 865, 859
1170, 859, 865, 866, 860
1171, 860, 866, 867, 861
1172, 861, 867, 868, 862
1173, 862, 868, 869, 863
1174, 863, 869, 870, 864
1175, 864, 870, 197, 196
1176, 155, 11, 177, 865
1177, 865, 177, 178, 866
1178, 866, 178, 179, 867
1179, 867, 179, 180, 868
1180, 868, 180, 181, 869
1181, 869, 181, 182, 870
1182, 870, 182, 15, 197
*ELEMENT, type=CPS4, ELSET=Surface15
1183, 10, 156, 871, 165
1184, 165, 871, 872, 166
1185, 166, 872, 873, 167
1186, 167, 873, 874, 168
1187, 168, 874, 875, 169
1188, 169, 875, 876, 170
1189, 170, 876, 198, 14
1190, 156, 157, 877, 871
1191, 871, 877, 878, 872
1192, 872, 878, 879, 873
1193, 873, 879, 880, 874
1194, 874, 880, 881, 875
1195, 875, 881, 882, 876
1196, 876, 882, 199, 198
1197, 157, 158, 883, 877
1198, 877, 883, 884, 878
1199, 878, 884, 885, 879
1200, 879, 885, 886, 880
1201, 880, 886, 887, 881
1202, 881, 887, 888, 882
1203, 882, 888, 200, 199
1204, 158, 12, 186, 883
1205, 883, 186, 187, 884
1206, 884, 187, 188, 885
1207, 885, 188, 189, 886
1208, 886, 189, 190, 887
1209, 887, 190, 191, 888
1210, 888, 191, 16, 200
*ELEMENT, type=CPS4, ELSET=Surface16
1211, 14, 198, 889, 171
1212, 198, 199, 890, 889
1213, 199, 200, 891, 890
1214, 200, 16, 192, 891
1215, 171, 889, 892, 172
1216, 889, 890, 893, 892
1217, 890, 891, 894, 893
1218, 891, 192, 193, 894
1219, 172, 892, 895, 173
1220, 892, 893, 896, 895
1221, 893, 894, 897, 896
1222, 894, 193, 194, 897
1223, 173, 895, 898, 174
1224, 895, 896, 899, 898
1225, 896, 897, 900, 899
1226, 897, 194, 195, 900
1227, 174, 898, 901, 175
1228, 898, 899, 902, 901
1229, 899, 900, 903, 902
1230, 900, 195, 196, 903
1231, 175, 901, 904, 176
1232, 901, 902, 905, 904
1233, 902, 903, 906, 905
1234, 903, 196, 197, 906
1235, 176, 904, 183, 13
1236, 904, 905, 184, 183
1237, 905, 906, 185, 184
1238, 906, 197, 15, 185
*ELEMENT, type=CPS4, ELSET=Surface17
1239, 14, 18, 201, 171
1240, 171, 201, 202, 172
1241, 172, 202, 203, 173
1242, 173, 203, 204, 174
1243, 174, 204, 205, 175
1244, 175, 205, 206, 176
1245, 176, 206, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
1246, 13, 17, 207, 183
1247, 183, 207, 208, 184
1248, 184, 208, 209, 185
1249, 185, 209, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
1250, 16, 192, 210, 20
1251, 192, 193, 211, 210
1252, 193, 194, 212, 211
1253, 194, 195, 213, 212
1254, 195, 196, 214, 213
1255, 196, 197, 215, 214
1256, 197, 15, 19, 215
*ELEMENT, type=CPS4, ELSET=Surface20
1257, 14, 198, 216, 18
1258, 198, 199, 217, 216
1259, 199, 200, 218, 217
1260, 200, 16, 20, 218
*ELEMENT, type=CPS4, ELSET=Surface21
1261, 18, 216, 907, 201
1262, 216, 217, 908, 907
1263, 217, 218, 909, 908
1264, 218, 20, 210, 909
1265, 201, 907, 910, 202
1266, 907, 908, 911, 910
1267, 908, 909, 912, 911
1268, 909, 210, 211, 912
1269, 202, 910, 913, 203
1270, 910, 911, 914, 913
1271, 911, 912, 915, 914
1272, 912, 211, 212, 915
1273, 203, 913, 916, 204
1274, 913, 914, 917, 916
1275, 914, 915, 918, 917
1276, 915, 212, 213, 918
1277, 204, 916, 919, 205
1278, 916, 917, 920, 919
1279, 917, 918, 921, 920
1280, 918, 213, 214, 921
1281, 205, 919, 922, 206
1282, 919, 920, 923, 922
1283, 920, 921, 924, 923
1284, 921, 214, 215, 924
1285, 206, 922, 207, 17
1286, 922, 923, 208, 207
1287, 923, 924, 209, 208
1288, 924, 215, 19, 209
*ELEMENT, type=CPS4, ELSET=Surface22
1289, 18, 221, 925, 201
1290, 221, 222, 926, 925
1291, 222, 22, 223, 926
1292, 201, 925, 927, 202
1293, 925, 926, 928, 927
1294, 926, 223, 224, 928
1295, 202, 927, 929, 203
1296, 927, 928, 930, 929
1297, 928, 224, 225, 930
1298, 203, 929, 931, 204
1299, 929, 930, 932, 931
1300, 930, 225, 226, 932
1301, 204, 931, 933, 205
1302, 931, 932, 934, 933
1303, 932, 226, 227, 934
1304, 205, 933, 935, 206
1305, 933, 934, 936, 935
1306, 934, 227, 228, 936
1307, 206, 935, 219, 17
1308, 935, 936, 220, 219
1309, 936, 228, 21, 220
*ELEMENT, type=CPS4, ELSET=Surface23
1310, 17, 219, 937, 207
1311, 219, 220, 938, 937
1312, 220, 21, 231, 938
1313, 207, 937, 939, 208
1314, 937, 938, 940, 939
1315, 938, 231, 232, 940
1316, 208, 939, 941, 209
1317, 939, 940, 942, 941
1318, 940, 232, 233, 942
1319, 209, 941, 229, 19
1320, 941, 942, 230, 229
1321, 942, 233, 23, 230
*ELEMENT, type=CPS4, ELSET=Surface24
1322, 20, 210, 943, 234
1323, 234, 943, 944, 235
1324, 235, 944, 236, 24
1325, 210, 211, 945, 943
1326, 943, 945, 946, 944
1327, 944, 946, 237, 236
1328, 211, 212, 947, 945
1329, 945, 947, 948, 946
1330, 946, 948, 238, 237
1331, 212, 213, 949, 947
1332, 947, 949, 950, 948
1333, 948, 950, 239, 238
1334, 213, 214, 951, 949
1335, 949, 951, 952, 950
1336, 950, 952, 240, 239
1337, 214, 215, 953, 951
1338, 951, 953, 954, 952
1339, 952, 954, 241, 240
1340, 215, 19, 229, 953
1341, 953, 229, 230, 954
1342, 954, 230, 23, 241
*ELEMENT, type=CPS4, ELSET=Surface25
1343, 18, 216, 955, 221
1344, 221, 955, 956, 222
1345, 222, 956, 242, 22
1346, 216, 217, 957, 955
1347, 955, 957, 958, 956
1348, 956, 958, 243, 242
1349, 217, 218, 959, 957
1350, 957, 959, 960, 958
1351, 958, 960, 244, 243
1352, 218, 20, 234, 959
1353, 959, 234, 235, 960
1354, 960, 235, 24, 244
*ELEMENT, type=CPS4, ELSET=Surface26
1355, 22, 242, 961, 223
1356, 242, 243, 962, 961
1357, 243, 244, 963, 962
1358, 244, 24, 236, 963
1359, 223, 961, 964, 224
1360, 961, 962, 965, 964
1361, 962, 963, 966, 965
1362, 963, 236, 237, 966
1363, 224, 964, 967, 225
1364, 964, 965, 968, 967
1365, 965, 966, 969, 968
1366, 966, 237, 238, 969
1367, 225, 967, 970, 226
1368, 967, 968, 971, 970
1369, 968, 969, 972, 971
1370, 969, 238, 239, 972
1371, 226, 970, 973, 227
1372, 970, 971, 974, 973
1373, 971, 972, 975, 974
1374, 972, 239, 240, 975
1375, 227, 973, 976, 228
1376, 973, 974, 977, 976
1377, 974, 975, 978, 977
1378, 975, 240, 241, 978
1379, 228, 976, 231, 21
1380, 976, 977, 232, 231
1381, 977, 978, 233, 232
1382, 978, 241, 23, 233
*ELEMENT, type=CPS4, ELSET=Surface27
1383, 19, 245, 979, 229
1384, 245, 246, 980, 979
1385, 246, 247, 981, 980
1386, 247, 248, 982, 981
1387, 248, 25, 253, 982
1388, 229, 979, 983, 230
1389, 979, 980, 984, 983
1390, 980, 981, 985, 984
1391, 981, 982, 986, 985
1392, 982, 253, 254, 986
1393, 230, 983, 249, 23
1394, 983, 984, 250, 249
1395, 984, 985, 251, 250
1396, 985, 986, 252, 251
1397, 986, 254, 26, 252
*ELEMENT, type=CPS4, ELSET=Surface28
1398, 17, 219, 987, 255
1399, 255, 987, 988, 256
1400, 256, 988, 989, 257
1401, 257, 989, 990, 258
1402, 258, 990, 263, 27
1403, 219, 220, 991, 987
1404, 987, 991, 992, 988
1405, 988, 992, 993, 989
1406, 989, 993, 994, 990
1407, 990, 994, 264, 263
1408, 220, 21, 259, 991
1409, 991, 259, 260, 992
1410, 992, 260, 261, 993
1411, 993, 261, 262, 994
1412, 994, 262, 28, 264
*ELEMENT, type=CPS4, ELSET=Surface29
1413, 17, 255, 995, 207
1414, 255, 256, 996, 995
1415, 256, 257, 997, 996
1416, 257, 258, 998, 997
1417, 258, 27, 265, 998
1418, 207, 995, 999, 208
1419, 995, 996, 1000, 999
1420, 996, 997, 1001, 1000
1421, 997, 998, 1002, 1001
1422, 998, 265, 266, 1002
1423, 208, 999, 1003, 209
1424, 999, 1000, 1004, 1003
1425, 1000, 1001, 1005, 1004
1426, 1001, 1002, 1006, 1005
1427, 1002, 266, 267, 1006
1428, 209, 1003, 245, 19
1429, 1003, 1004, 246, 245
1430, 1004, 1005, 247, 246
1431, 1005, 1006, 248, 247
1432, 1006, 267, 25, 248
*ELEMENT, type=CPS4, ELSET=Surface30
1433, 21, 231, 1007, 259
1434, 259, 1007, 1008, 260
1435, 260, 1008, 1009, 261
1436, 261, 1009, 1010, 262
1437, 262, 1010, 268, 28
1438, 231, 232, 1011, 1007
1439, 1007, 1011, 1012, 1008
1440, 1008, 1012, 1013, 1009
1441, 1009, 1013, 1014, 1010
1442, 1010, 1014, 269, 268
1443, 232, 233, 1015, 1011
1444, 1011, 1015, 1016, 1012
1445, 1012, 1016, 1017, 1013
1446, 1013, 1017, 1018, 1014
1447, 1014, 1018, 270, 269
1448, 233, 23, 249, 1015
1449, 1015, 249, 250, 1016
1450, 1016, 250, 251, 1017
1451, 1017, 251, 252, 1018
1452, 1018, 252, 26, 270
*ELEMENT, type=CPS4, ELSET=Surface31
1453, 27, 263, 1019, 265
1454, 263, 264, 1020, 1019
1455, 264, 28, 268, 1020
1456, 265, 1019, 1021, 266
1457, 1019, 1020, 1022, 1021
1458, 1020, 268, 269, 1022
1459, 266, 1021, 1023, 267
1460, 1021, 1022, 1024, 1023
1461, 1022, 269, 270, 1024
1462, 267, 1023, 253, 25
1463, 1023, 1024, 254, 253
1464, 1024, 270, 26, 254
*ELEMENT, type=CPS4, ELSET=Surface32
1465, 25, 271, 1025, 253
1466, 271, 272, 1026, 1025
1467, 272, 273, 1027, 1026
1468, 273, 274, 1028, 1027
1469, 274, 275, 1029, 1028
1470, 275, 276, 1030, 1029
1471, 276, 29, 283, 1030
1472, 253, 1025, 1031, 254
1473, 1025, 1026, 1032, 1031
1474, 1026, 1027, 1033, 1032
1475, 1027, 1028, 1034, 1033
1476, 1028, 1029, 1035, 1034
1477, 1029, 1030, 1036, 1035
1478, 1030, 283, 284, 1036
1479, 254, 1031, 277, 26
1480, 1031, 1032, 278, 277
1481, 1032, 1033, 279, 278
1482, 1033, 1034, 280, 279
1483, 1034, 1035, 281, 280
1484, 1035, 1036, 282, 281
1485, 1036, 284, 30, 282
*ELEMENT, type=CPS4, ELSET=Surface33
1486, 27, 263, 1037, 285
1487, 285, 1037, 1038, 286
1488, 286, 1038, 1039, 287
1489, 287, 1039, 1040, 288
1490, 288, 1040, 1041, 289
1491, 289, 1041, 1042, 290
1492, 290, 1042, 297, 31
1493, 263, 264, 1043, 1037
1494, 1037, 1043, 1044, 1038
1495, 1038, 1044, 1045, 1039
1496, 1039, 1045, 1046, 1040
1497, 1040, 1046, 1047, 1041
1498, 1041, 1047, 1048, 1042
1499, 1042, 1048, 298, 297
1500, 264, 28, 291, 1043
1501, 1043, 291, 292, 1044
1502, 1044, 292, 293, 1045
1503, 1045, 293, 294, 1046
1504, 1046, 294, 295, 1047
1505, 1047, 295, 296, 1048
1506, 1048, 296, 32, 298
*ELEMENT, type=CPS4, ELSET=Surface34
1507, 27, 285, 1049, 265
1508, 285, 286, 1050, 1049
1509, 286, 287, 1051, 1050
1510, 287, 288, 1052, 1051
1511, 288, 289, 1053, 1052
1512, 289, 290, 1054, 1053
1513, 290, 31, 299, 1054
1514, 265, 1049, 1055, 266
1515, 1049, 1050, 1056, 1055
1516, 1050, 1051, 1057, 1056
1517, 1051, 1052, 1058, 1057
1518, 1052, 1053, 1059, 1058
1519, 1053, 1054, 1060, 1059
1520, 1054, 299, 300, 1060
1521, 266, 1055, 1061, 267
1522, 1055, 1056, 1062, 1061
1523, 1056, 1057, 1063, 1062
1524, 1057, 1058, 1064, 1063
1525, 1058, 1059, 1065, 1064
1526, 1059, 1060, 1066, 1065
1527, 1060, 300, 301, 1066
1528, 267, 1061, 271, 25
1529, 1061, 1062, 272, 271
1530, 1062, 1063, 273, 272
1531, 1063, 1064, 274, 273
1532, 1064, 1065, 275, 274
1533, 1065, 1066, 276, 275
1534, 1066, 301, 29, 276
*ELEMENT, type=CPS4, ELSET=Surface35
1535, 28, 268, 1067, 291
1536, 291, 1067, 1068, 292
1537, 292, 1068, 1069, 293
1538, 293, 1069, 1070, 294
1539, 294, 1070, 1071, 295
1540, 295, 1071, 1072, 296
1541, 296, 1072, 302, 32
1542, 268, 269, 1073, 1067
1543, 1067, 1073, 1074, 1068
1544, 1068, 1074, 1075, 1069
1545, 1069, 1075, 1076, 1070
1546, 1070, 1076, 1077, 1071
1547, 1071, 1077, 1078, 1072
1548, 1072, 1078, 303, 302
1549, 269, 270, 1079, 1073
1550, 1073, 1079, 1080, 1074
1551, 1074, 1080, 1081, 1075
1552, 1075, 1081, 1082, 1076
1553, 1076, 1082, 1083, 1077
1554, 1077, 1083, 1084, 1078
1555, 1078, 1084, 304, 303
1556, 270, 26, 277, 1079
1557, 1079, 277, 278, 1080
1558, 1080, 278, 279, 1081
1559, 1081, 279, 280, 1082
1560, 1082, 280, 281, 1083
1561, 1083, 281, 282, 1084
1562, 1084, 282, 30, 304
*ELEMENT, type=CPS4, ELSET=Surface36
1563, 31, 297, 1085, 299
1564, 297, 298, 1086, 1085
1565, 298, 32, 302, 1086
1566, 299, 1085, 1087, 300
1567, 1085, 1086, 1088, 1087
1568, 1086, 302, 303, 1088
1569, 300, 1087, 1089, 301
1570, 1087, 1088, 1090, 1089
1571, 1088, 303, 304, 1090
1572, 301, 1089, 283, 29
1573, 1089, 1090, 284, 283
1574, 1090, 304, 30, 284
*ELEMENT, type=CPS4, ELSET=Surface37
1575, 25, 33, 305, 271
1576, 271, 305, 306, 272
1577, 272, 306, 307, 273
1578, 273, 307, 308, 274
1579, 274, 308, 309, 275
1580, 275, 309, 310, 276
1581, 276, 310, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
1582, 27, 285, 311, 35
1583, 285, 286, 312, 311
1584, 286, 287, 313, 312
1585, 287, 288, 314, 313
1586, 288, 289, 315, 314
1587, 289, 290, 316, 315
1588, 290, 31, 36, 316
*ELEMENT, type=CPS4, ELSET=Surface39
1589, 27, 35, 317, 265
1590, 265, 317, 318, 266
1591, 266, 318, 319, 267
1592, 267, 319, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
1593, 31, 299, 320, 36
1594, 299, 300, 321, 320
1595, 300, 301, 322, 321
1596, 301, 29, 34, 322
*ELEMENT, type=CPS4, ELSET=Surface41
1597, 35, 311, 1091, 317
1598, 311, 312, 1092, 1091
1599, 312, 313, 1093, 1092
1600, 313, 314, 1094, 1093
1601, 314, 315, 1095, 1094
1602, 315, 316, 1096, 1095
1603, 316, 36, 320, 1096
1604, 317, 1091, 1097, 318
1605, 1091, 1092, 1098, 1097
1606, 1092, 1093, 1099, 1098
1607, 1093, 1094, 1100, 1099
1608, 1094, 1095, 1101, 1100
1609, 1095, 1096, 1102, 1101
1610, 1096, 320, 321, 1102
1611, 318, 1097, 1103, 319
1612, 1097, 1098, 1104, 1103
1613, 1098, 1099, 1105, 1104
1614, 1099, 1100, 1106, 1105
1615, 1100, 1101, 1107, 1106
1616, 1101, 1102, 1108, 1107
1617, 1102, 321, 322, 1108
1618, 319, 1103, 305, 33
1619, 1103, 1104, 306, 305
1620, 1104, 1105, 307, 306
1621, 1105, 1106, 308, 307
1622, 1106, 1107, 309, 308
1623, 1107, 1108, 310, 309
1624, 1108, 322, 34, 310
*ELEMENT, type=CPS4, ELSET=Surface42
1625, 33, 323, 1109, 305
1626, 323, 324, 1110, 1109
1627, 324, 325, 1111, 1110
1628, 325, 326, 1112, 1111
1629, 326, 327, 1113, 1112
1630, 327, 328, 1114, 1113
1631, 328, 37, 335, 1114
1632, 305, 1109, 1115, 306
1633, 1109, 1110, 1116, 1115
1634, 1110, 1111, 1117, 1116
1635, 1111, 1112, 1118, 1117
1636, 1112, 1113, 1119, 1118
1637, 1113, 1114, 1120, 1119
1638, 1114, 335, 336, 1120
1639, 306, 1115, 1121, 307
1640, 1115, 1116, 1122, 1121
1641, 1116, 1117, 1123, 1122
1642, 1117, 1118, 1124, 1123
1643, 1118, 1119, 1125, 1124
1644, 1119, 1120, 1126, 1125
1645, 1120, 336, 337, 1126
1646, 307, 1121, 1127, 308
1647, 1121, 1122, 1128, 1127
1648, 1122, 1123, 1129, 1128
1649, 1123, 1124, 1130, 1129
1650, 1124, 1125, 1131, 1130
1651, 1125, 1126, 1132, 1131
1652, 1126, 337, 338, 1132
1653, 308, 1127, 1133, 309
1654, 1127, 1128, 1134, 1133
1655, 1128, 1129, 1135, 1134
1656, 1129, 1130, 1136, 1135
1657, 1130, 1131, 1137, 1136
1658, 1131, 1132, 1138, 1137
1659, 1132, 338, 339, 1138
1660, 309, 1133, 1139, 310
1661, 1133, 1134, 1140, 1139
1662, 1134, 1135, 1141, 1140
1663, 1135, 1136, 1142, 1141
1664, 1136, 1137, 1143, 1142
1665, 1137, 1138, 1144, 1143
1666, 1138, 339, 340, 1144
1667, 310, 1139, 329, 34
1668, 1139, 1140, 330, 329
1669, 1140, 1141, 331, 330
1670, 1141, 1142, 332, 331
1671, 1142, 1143, 333, 332
1672, 1143, 1144, 334, 333
1673, 1144, 340, 38, 334
*ELEMENT, type=CPS4, ELSET=Surface43
1674, 35, 311, 1145, 341
1675, 341, 1145, 1146, 342
1676, 342, 1146, 1147, 343
1677, 343, 1147, 1148, 344
1678, 344, 1148, 1149, 345
1679, 345, 1149, 1150, 346
1680, 346, 1150, 353, 39
1681, 311, 312, 1151, 1145
1682, 1145, 1151, 1152, 1146
1683, 1146, 1152, 1153, 1147
1684, 1147, 1153, 1154, 1148
1685, 1148, 1154, 1155, 1149
1686, 1149, 1155, 1156, 1150
1687, 1150, 1156, 354, 353
1688, 312, 313, 1157, 1151
1689, 1151, 1157, 1158, 1152
1690, 1152, 1158, 1159, 1153
1691, 1153, 1159, 1160, 1154
1692, 1154, 1160, 1161, 1155
1693, 1155, 1161, 1162, 1156
1694, 1156, 1162, 355, 354
1695, 313, 314, 1163, 1157
1696, 1157, 1163, 1164, 1158
1697, 1158, 1164, 1165, 1159
1698, 1159, 1165, 1166, 1160
1699, 1160, 1166, 1167, 1161
1700, 1161, 1167, 1168, 1162
1701, 1162, 1168, 356, 355
1702, 314, 315, 1169, 1163
1703, 1163, 1169, 1170, 1164
1704, 1164, 1170, 1171, 1165
1705, 1165, 1171, 1172, 1166
1706, 1166, 1172, 1173, 1167
1707, 1167, 1173, 1174, 1168
1708, 1168, 1174, 357, 356
1709, 315, 316, 1175, 1169
1710, 1169, 1175, 1176, 1170
1711, 1170, 1176, 1177, 1171
1712, 1171, 1177, 1178, 1172
1713, 1172, 1178, 1179, 1173
1714, 1173, 1179, 1180, 1174
1715, 1174, 1180, 358, 357
1716, 316, 36, 347, 1175
1717, 1175, 347, 348, 1176
1718, 1176, 348, 349, 1177
1719, 1177, 349, 350, 1178
1720, 1178, 350, 351, 1179
1721, 1179, 351, 352, 1180
1722, 1180, 352, 40, 358
*ELEMENT, type=CPS4, ELSET=Surface44
1723, 35, 341, 1181, 317
1724, 341, 342, 1182, 1181
1725, 342, 343, 1183, 1182
1726, 343, 344, 1184, 1183
1727, 344, 345, 1185, 1184
1728, 345, 346, 1186, 1185
1729, 346, 39, 359, 1186
1730, 317, 1181, 1187, 318
1731, 1181, 1182, 1188, 1187
1732, 1182, 1183, 1189, 1188
1733, 1183, 1184, 1190, 1189
1734, 1184, 1185, 1191, 1190
1735, 1185, 1186, 1192, 1191
1736, 1186, 359, 360, 1192
1737, 318, 1187, 1193, 319
1738, 1187, 1188, 1194, 1193
1739, 1188, 1189, 1195, 1194
1740, 1189, 1190, 1196, 1195
1741, 1190, 1191, 1197, 1196
1742, 1191, 1192, 1198, 1197
1743, 1192, 360, 361, 1198
1744, 319, 1193, 323, 33
1745, 1193, 1194, 324, 323
1746, 1194, 1195, 325, 324
1747, 1195, 1196, 326, 325
1748, 1196, 1197, 327, 326
1749, 1197, 1198, 328, 327
1750, 1198, 361, 37, 328
*ELEMENT, type=CPS4, ELSET=Surface45
1751, 36, 320, 1199, 347
1752, 347, 1199, 1200, 348
1753, 348, 1200, 1201, 349
1754, 349, 1201, 1202, 350
1755, 350, 1202, 1203, 351
1756, 351, 1203, 1204, 352
1757, 352, 1204, 362, 40
1758, 320, 321, 1205, 1199
1759, 1199, 1205, 1206, 1200
1760, 1200, 1206, 1207, 1201
1761, 1201, 1207, 1208, 1202
1762, 1202, 1208, 1209, 1203
1763, 1203, 1209, 1210, 1204
1764, 1204, 1210, 363, 362
1765, 321, 322, 1211, 1205
1766, 1205, 1211, 1212, 1206
1767, 1206, 1212, 1213, 1207
1768, 1207, 1213, 1214, 1208
1769, 1208, 1214, 1215, 1209
1770, 1209, 1215, 1216, 1210
1771, 1210, 1216, 364, 363
1772, 322, 34, 329, 1211
1773, 1211, 329, 330, 1212
1774, 1212, 330, 331, 1213
1775, 1213, 331, 332, 1214
1776, 1214, 332, 333, 1215
1777, 1215, 333, 334, 1216
1778, 1216, 334, 38, 364
*ELEMENT, type=CPS4, ELSET=Surface46
1779, 39, 353, 1217, 359
1780, 353, 354, 1218, 1217
1781, 354, 355, 1219, 1218
1782, 355, 356, 1220, 1219
1783, 356, 357, 1221, 1220
1784, 357, 358, 1222, 1221
1785, 358, 40, 362, 1222
1786, 359, 1217, 1223, 360
1787, 1217, 1218, 1224, 1223
1788, 1218, 1219, 1225, 1224
1789, 1219, 1220, 1226, 1225
1790, 1220, 1221, 1227, 1226
1791, 1221, 1222, 1228, 1227
1792, 1222, 362, 363, 1228
1793, 360, 1223, 1229, 361
1794, 1223, 1224, 1230, 1229
1795, 1224, 1225, 1231, 1230
1796, 1225, 1226, 1232, 1231
1797, 1226, 1227, 1233, 1232
1798, 1227, 1228, 1234, 1233
1799, 1228, 363, 364, 1234
1800, 361, 1229, 335, 37
1801, 1229, 1230, 336, 335
1802, 1230, 1231, 337, 336
1803, 1231, 1232, 338, 337
1804, 1232, 1233, 339, 338
1805, 1233, 1234, 340, 339
1806, 1234, 364, 38, 340
*ELEMENT, type=CPS4, ELSET=Surface47
1807, 37, 41, 365, 335
1808, 335, 365, 366, 336
1809, 336, 366, 367, 337
1810, 337, 367, 368, 338
1811, 338, 368, 369, 339
1812, 339, 369, 370, 340
1813, 340, 370, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
1814, 39, 353, 371, 43
1815, 353, 354, 372, 371
1816, 354, 355, 373, 372
1817, 355, 356, 374, 373
1818, 356, 357, 375, 374
1819, 357, 358, 376, 375
1820, 358, 40, 44, 376
*ELEMENT, type=CPS4, ELSET=Surface49
1821, 39, 43, 377, 359
1822, 359, 377, 378, 360
1823, 360, 378, 379, 361
1824, 361, 379, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
1825, 40, 362, 380, 44
1826, 362, 363, 381, 380
1827, 363, 364, 382, 381
1828, 364, 38, 42, 382
*ELEMENT, type=CPS4, ELSET=Surface51
1829, 43, 371, 1235, 377
1830, 371, 372, 1236, 1235
1831, 372, 373, 1237, 1236
1832, 373, 374, 1238, 1237
1833, 374, 375, 1239, 1238
1834, 375, 376, 1240, 1239
1835, 376, 44, 380, 1240
1836, 377, 1235, 1241, 378
1837, 1235, 1236, 1242, 1241
1838, 1236, 1237, 1243, 1242
1839, 1237, 1238, 1244, 1243
1840, 1238, 1239, 1245, 1244
1841, 1239, 1240, 1246, 1245
1842, 1240, 380, 381, 1246
1843, 378, 1241, 1247, 379
1844, 1241, 1242, 1248, 1247
1845, 1242, 1243, 1249, 1248
1846, 1243, 1244, 1250, 1249
1847, 1244, 1245, 1251, 1250
1848, 1245, 1246, 1252, 1251
1849, 1246, 381, 382, 1252
1850, 379, 1247, 365, 41
1851, 1247, 1248, 366, 365
1852, 1248, 1249, 367, 366
1853, 1249, 1250, 368, 367
1854, 1250, 1251, 369, 368
1855, 1251, 1252, 370, 369
1856, 1252, 382, 42, 370
*ELEMENT, type=CPS4, ELSET=Surface52
1857, 41, 383, 1253, 365
1858, 383, 384, 1254, 1253
1859, 384, 45, 387, 1254
1860, 365, 1253, 1255, 366
1861, 1253, 1254, 1256, 1255
1862, 1254, 387, 388, 1256
1863, 366, 1255, 1257, 367
1864, 1255, 1256, 1258, 1257
1865, 1256, 388, 389, 1258
1866, 367, 1257, 1259, 368
1867, 1257, 1258, 1260, 1259
1868, 1258, 389, 390, 1260
1869, 368, 1259, 1261, 369
1870, 1259, 1260, 1262, 1261
1871, 1260, 390, 391, 1262
1872, 369, 1261, 1263, 370
1873, 1261, 1262, 1264, 1263
1874, 1262, 391, 392, 1264
1875, 370, 1263, 385, 42
1876, 1263, 1264, 386, 385
1877, 1264, 392, 46, 386
*ELEMENT, type=CPS4, ELSET=Surface53
1878, 43, 371, 1265, 393
1879, 393, 1265, 1266, 394
1880, 394, 1266, 397, 47
1881, 371, 372, 1267, 1265
1882, 1265, 1267, 1268, 1266
1883, 1266, 1268, 398, 397
1884, 372, 373, 1269, 1267
1885, 1267, 1269, 1270, 1268
1886, 1268, 1270, 399, 398
1887, 373, 374, 1271, 1269
1888, 1269, 1271, 1272, 1270
1889, 1270, 1272, 400, 399
1890, 374, 375, 1273, 1271
1891, 1271, 1273, 1274, 1272
1892, 1272, 1274, 401, 400
1893, 375, 376, 1275, 1273
1894, 1273, 1275, 1276, 1274
1895, 1274, 1276, 402, 401
1896, 376, 44, 395, 1275
1897, 1275, 395, 396, 1276
1898, 1276, 396, 48, 402
*ELEMENT, type=CPS4, ELSET=Surface54
1899, 43, 393, 1277, 377
1900, 393, 394, 1278, 1277
1901, 394, 47, 403, 1278
1902, 377, 1277, 1279, 378
1903, 1277, 1278, 1280, 1279
1904, 1278, 403, 404, 1280
1905, 378, 1279, 1281, 379
1906, 1279, 1280, 1282, 1281
1907, 1280, 404, 405, 1282
1908, 379, 1281, 383, 41
1909, 1281, 1282, 384, 383
1910, 1282, 405, 45, 384
*ELEMENT, type=CPS4, ELSET=Surface55
1911, 44, 380, 1283, 395
1912, 395, 1283, 1284, 396
1913, 396, 1284, 406, 48
1914, 380, 381, 1285, 1283
1915, 1283, 1285, 1286, 1284
1916, 1284, 1286, 407, 406
1917, 381, 382, 1287, 1285
1918, 1285, 1287, 1288, 1286
1919, 1286, 1288, 408, 407
1920, 382, 42, 385, 1287
1921, 1287, 385, 386, 1288
1922, 1288, 386, 46, 408
*ELEMENT, type=CPS4, ELSET=Surface56
1923, 47, 397, 1289, 403
1924, 397, 398, 1290, 1289
1925, 398, 399, 1291, 1290
1926, 399, 400, 1292, 1291
1927, 400, 401, 1293, 1292
1928, 401, 402, 1294, 1293
1929, 402, 48, 406, 1294
1930, 403, 1289, 1295, 404
1931, 1289, 1290, 1296, 1295
1932, 1290, 1291, 1297, 1296
1933, 1291, 1292, 1298, 1297
1934, 1292, 1293, 1299, 1298
1935, 1293, 1294, 1300, 1299
1936, 1294, 406, 407, 1300
1937, 404, 1295, 1301, 405
1938, 1295, 1296, 1302, 1301
1939, 1296, 1297, 1303, 1302
1940, 1297, 1298, 1304, 1303
1941, 1298, 1299, 1305, 1304
1942, 1299, 1300, 1306, 1305
1943, 1300, 407, 408, 1306
1944, 405, 1301, 387, 45
1945, 1301, 1302, 388, 387
1946, 1302, 1303, 389, 388
1947, 1303, 1304, 390, 389
1948, 1304, 1305, 391, 390
1949, 1305, 1306, 392, 391
1950, 1306, 408, 46, 392
*ELEMENT, type=CPS4, ELSET=Surface57
1951, 42, 385, 409, 49
1952, 385, 386, 410, 409
1953, 386, 46, 50, 410
*ELEMENT, type=CPS4, ELSET=Surface58
1954, 44, 51, 411, 395
1955, 395, 411, 412, 396
1956, 396, 412, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
1957, 44, 380, 413, 51
1958, 380, 381, 414, 413
1959, 381, 382, 415, 414
1960, 382, 42, 49, 415
*ELEMENT, type=CPS4, ELSET=Surface60
1961, 48, 52, 416, 406
1962, 406, 416, 417, 407
1963, 407, 417, 418, 408
1964, 408, 418, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
1965, 51, 413, 1307, 411
1966, 411, 1307, 1308, 412
1967, 412, 1308, 416, 52
1968, 413, 414, 1309, 1307
1969, 1307, 1309, 1310, 1308
1970, 1308, 1310, 417, 416
1971, 414, 415, 1311, 1309
1972, 1309, 1311, 1312, 1310
1973, 1310, 1312, 418, 417
1974, 415, 49, 409, 1311
1975, 1311, 409, 410, 1312
1976, 1312, 410, 50, 418
*ELEMENT, type=CPS4, ELSET=Surface62
1977, 2, 97, 419, 54
1978, 97, 98, 420, 419
1979, 98, 99, 421, 420
1980, 99, 1, 53, 421
*ELEMENT, type=CPS4, ELSET=Surface63
1981, 1, 100, 422, 53
1982, 100, 101, 423, 422
1983, 101, 3, 55, 423
*ELEMENT, type=CPS4, ELSET=Surface64
1984, 4, 56, 424, 102
1985, 102, 424, 425, 103
1986, 103, 425, 426, 104
1987, 104, 426, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
1988, 2, 54, 427, 105
1989, 105, 427, 428, 106
1990, 106, 428, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
1991, 54, 419, 1313, 427
1992, 427, 1313, 1314, 428
1993, 428, 1314, 424, 56
1994, 419, 420, 1315, 1313
1995, 1313, 1315, 1316, 1314
1996, 1314, 1316, 425, 424
1997, 420, 421, 1317, 1315
1998, 1315, 1317, 1318, 1316
1999, 1316, 1318, 426, 425
2000, 421, 53, 422, 1317
2001, 1317, 422, 423, 1318
2002, 1318, 423, 55, 426
*ELEMENT, type=CPS4, ELSET=Surface77
2003, 11, 57, 429, 177
2004, 177, 429, 430, 178
2005, 178, 430, 431, 179
2006, 179, 431, 432, 180
2007, 180, 432, 433, 181
2008, 181, 433, 434, 182
2009, 182, 434, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
2010, 9, 159, 435, 59
2011, 159, 160, 436, 435
2012, 160, 161, 437, 436
2013, 161, 162, 438, 437
2014, 162, 163, 439, 438
2015, 163, 164, 440, 439
2016, 164, 13, 60, 440
*ELEMENT, type=CPS4, ELSET=Surface79
2017, 9, 59, 441, 147
2018, 147, 441, 442, 148
2019, 148, 442, 443, 149
2020, 149, 443, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
2021, 13, 183, 444, 60
2022, 183, 184, 445, 444
2023, 184, 185, 446, 445
2024, 185, 15, 58, 446
*ELEMENT, type=CPS4, ELSET=Surface81
2025, 59, 435, 1319, 441
2026, 435, 436, 1320, 1319
2027, 436, 437, 1321, 1320
2028, 437, 438, 1322, 1321
2029, 438, 439, 1323, 1322
2030, 439, 440, 1324, 1323
2031, 440, 60, 444, 1324
2032, 441, 1319, 1325, 442
2033, 1319, 1320, 1326, 1325
2034, 1320, 1321, 1327, 1326
2035, 1321, 1322, 1328, 1327
2036, 1322, 1323, 1329, 1328
2037, 1323, 1324, 1330, 1329
2038, 1324, 444, 445, 1330
2039, 442, 1325, 1331, 443
2040, 1325, 1326, 1332, 1331
2041, 1326, 1327, 1333, 1332
2042, 1327, 1328, 1334, 1333
2043, 1328, 1329, 1335, 1334
2044, 1329, 1330, 1336, 1335
2045, 1330, 445, 446, 1336
2046, 443, 1331, 429, 57
2047, 1331, 1332, 430, 429
2048, 1332, 1333, 431, 430
2049, 1333, 1334, 432, 431
2050, 1334, 1335, 433, 432
2051, 1335, 1336, 434, 433
2052, 1336, 446, 58, 434
*ELEMENT, type=CPS4, ELSET=Surface82
2053, 33, 61, 447, 323
2054, 323, 447, 448, 324
2055, 324, 448, 449, 325
2056, 325, 449, 450, 326
2057, 326, 450, 451, 327
2058, 327, 451, 452, 328
2059, 328, 452, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
2060, 35, 341, 453, 63
2061, 341, 342, 454, 453
2062, 342, 343, 455, 454
2063, 343, 344, 456, 455
2064, 344, 345, 457, 456
2065, 345, 346, 458, 457
2066, 346, 39, 64, 458
*ELEMENT, type=CPS4, ELSET=Surface84
2067, 35, 63, 459, 317
2068, 317, 459, 460, 318
2069, 318, 460, 461, 319
2070, 319, 461, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
2071, 39, 359, 462, 64
2072, 359, 360, 463, 462
2073, 360, 361, 464, 463
2074, 361, 37, 62, 464
*ELEMENT, type=CPS4, ELSET=Surface86
2075, 63, 453, 1337, 459
2076, 453, 454, 1338, 1337
2077, 454, 455, 1339, 1338
2078, 455, 456, 1340, 1339
2079, 456, 457, 1341, 1340
2080, 457, 458, 1342, 1341
2081, 458, 64, 462, 1342
2082, 459, 1337, 1343, 460
2083, 1337, 1338, 1344, 1343
2084, 1338, 1339, 1345, 1344
2085, 1339, 1340, 1346, 1345
2086, 1340, 1341, 1347, 1346
2087, 1341, 1342, 1348, 1347
2088, 1342, 462, 463, 1348
2089, 460, 1343, 1349, 461
2090, 1343, 1344, 1350, 1349
2091, 1344, 1345, 1351, 1350
2092, 1345, 1346, 1352, 1351
2093, 1346, 1347, 1353, 1352
2094, 1347, 1348, 1354, 1353
2095, 1348, 463, 464, 1354
2096, 461, 1349, 447, 61
2097, 1349, 1350, 448, 447
2098, 1350, 1351, 449, 448
2099, 1351, 1352, 450, 449
2100, 1352, 1353, 451, 450
2101, 1353, 1354, 452, 451
2102, 1354, 464, 62, 452
*ELEMENT, type=CPS4, ELSET=Surface87
2103, 9, 65, 465, 159
2104, 159, 465, 466, 160
2105, 160, 466, 467, 161
2106, 161, 467, 468, 162
2107, 162, 468, 469, 163
2108, 163, 469, 470, 164
2109, 164, 470, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
2110, 10, 165, 471, 67
2111, 165, 166, 472, 471
2112, 166, 167, 473, 472
2113, 167, 168, 474, 473
2114, 168, 169, 475, 474
2115, 169, 170, 476, 475
2116, 170, 14, 68, 476
*ELEMENT, type=CPS4, ELSET=Surface89
2117, 10, 67, 477, 141
2118, 141, 477, 478, 142
2119, 142, 478, 479, 143
2120, 143, 479, 480, 144
2121, 144, 480, 481, 145
2122, 145, 481, 482, 146
2123, 146, 482, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
2124, 14, 171, 483, 68
2125, 171, 172, 484, 483
2126, 172, 173, 485, 484
2127, 173, 174, 486, 485
2128, 174, 175, 487, 486
2129, 175, 176, 488, 487
2130, 176, 13, 66, 488
*ELEMENT, type=CPS4, ELSET=Surface91
2131, 67, 471, 1355, 477
2132, 471, 472, 1356, 1355
2133, 472, 473, 1357, 1356
2134, 473, 474, 1358, 1357
2135, 474, 475, 1359, 1358
2136, 475, 476, 1360, 1359
2137, 476, 68, 483, 1360
2138, 477, 1355, 1361, 478
2139, 1355, 1356, 1362, 1361
2140, 1356, 1357, 1363, 1362
2141, 1357, 1358, 1364, 1363
2142, 1358, 1359, 1365, 1364
2143, 1359, 1360, 1366, 1365
2144, 1360, 483, 484, 1366
2145, 478, 1361, 1367, 479
2146, 1361, 1362, 1368, 1367
2147, 1362, 1363, 1369, 1368
2148, 1363, 1364, 1370, 1369
2149, 1364, 1365, 1371, 1370
2150, 1365, 1366, 1372, 1371
2151, 1366, 484, 485, 1372
2152, 479, 1367, 1373, 480
2153, 1367, 1368, 1374, 1373
2154, 1368, 1369, 1375, 1374
2155, 1369, 1370, 1376, 1375
2156, 1370, 1371, 1377, 1376
2157, 1371, 1372, 1378, 1377
2158, 1372, 485, 486, 1378
2159, 480, 1373, 1379, 481
2160, 1373, 1374, 1380, 1379
2161, 1374, 1375, 1381, 1380
2162, 1375, 1376, 1382, 1381
2163, 1376, 1377, 1383, 1382
2164, 1377, 1378, 1384, 1383
2165, 1378, 486, 487, 1384
2166, 481, 1379, 1385, 482
2167, 1379, 1380, 1386, 1385
2168, 1380, 1381, 1387, 1386
2169, 1381, 1382, 1388, 1387
2170, 1382, 1383, 1389, 1388
2171, 1383, 1384, 1390, 1389
2172, 1384, 487, 488, 1390
2173, 482, 1385, 465, 65
2174, 1385, 1386, 466, 465
2175, 1386, 1387, 467, 466
2176, 1387, 1388, 468, 467
2177, 1388, 1389, 469, 468
2178, 1389, 1390, 470, 469
2179, 1390, 488, 66, 470
*ELEMENT, type=CPS4, ELSET=Surface92
2180, 35, 69, 489, 341
2181, 341, 489, 490, 342
2182, 342, 490, 491, 343
2183, 343, 491, 492, 344
2184, 344, 492, 493, 345
2185, 345, 493, 494, 346
2186, 346, 494, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
2187, 36, 347, 495, 71
2188, 347, 348, 496, 495
2189, 348, 349, 497, 496
2190, 349, 350, 498, 497
2191, 350, 351, 499, 498
2192, 351, 352, 500, 499
2193, 352, 40, 72, 500
*ELEMENT, type=CPS4, ELSET=Surface94
2194, 35, 311, 501, 69
2195, 311, 312, 502, 501
2196, 312, 313, 503, 502
2197, 313, 314, 504, 503
2198, 314, 315, 505, 504
2199, 315, 316, 506, 505
2200, 316, 36, 71, 506
*ELEMENT, type=CPS4, ELSET=Surface95
2201, 39, 70, 507, 353
2202, 353, 507, 508, 354
2203, 354, 508, 509, 355
2204, 355, 509, 510, 356
2205, 356, 510, 511, 357
2206, 357, 511, 512, 358
2207, 358, 512, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
2208, 69, 501, 1391, 489
2209, 489, 1391, 1392, 490
2210, 490, 1392, 1393, 491
2211, 491, 1393, 1394, 492
2212, 492, 1394, 1395, 493
2213, 493, 1395, 1396, 494
2214, 494, 1396, 507, 70
2215, 501, 502, 1397, 1391
2216, 1391, 1397, 1398, 1392
2217, 1392, 1398, 1399, 1393
2218, 1393, 1399, 1400, 1394
2219, 1394, 1400, 1401, 1395
2220, 1395, 1401, 1402, 1396
2221, 1396, 1402, 508, 507
2222, 502, 503, 1403, 1397
2223, 1397, 1403, 1404, 1398
2224, 1398, 1404, 1405, 1399
2225, 1399, 1405, 1406, 1400
2226, 1400, 1406, 1407, 1401
2227, 1401, 1407, 1408, 1402
2228, 1402, 1408, 509, 508
2229, 503, 504, 1409, 1403
2230, 1403, 1409, 1410, 1404
2231, 1404, 1410, 1411, 1405
2232, 1405, 1411, 1412, 1406
2233, 1406, 1412, 1413, 1407
2234, 1407, 1413, 1414, 1408
2235, 1408, 1414, 510, 509
2236, 504, 505, 1415, 1409
2237, 1409, 1415, 1416, 1410
2238, 1410, 1416, 1417, 1411
2239, 1411, 1417, 1418, 1412
2240, 1412, 1418, 1419, 1413
2241, 1413, 1419, 1420, 1414
2242, 1414, 1420, 511, 510
2243, 505, 506, 1421, 1415
2244, 1415, 1421, 1422, 1416
2245, 1416, 1422, 1423, 1417
2246, 1417, 1423, 1424, 1418
2247, 1418, 1424, 1425, 1419
2248, 1419, 1425, 1426, 1420
2249, 1420, 1426, 512, 511
2250, 506, 71, 495, 1421
2251, 1421, 495, 496, 1422
2252, 1422, 496, 497, 1423
2253, 1423, 497, 498, 1424
2254, 1424, 498, 499, 1425
2255, 1425, 499, 500, 1426
2256, 1426, 500, 72, 512
*ELEMENT, type=CPS4, ELSET=Surface97
2257, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
2258, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
2259, 63, 73, 513, 453
2260, 453, 513, 514, 454
2261, 454, 514, 515, 455
2262, 455, 515, 516, 456
2263, 456, 516, 517, 457
2264, 457, 517, 518, 458
2265, 458, 518, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
2266, 69, 489, 513, 73
2267, 489, 490, 514, 513
2268, 490, 491, 515, 514
2269, 491, 492, 516, 515
2270, 492, 493, 517, 516
2271, 493, 494, 518, 517
2272, 494, 70, 74, 518
*ELEMENT, type=CPS4, ELSET=Surface101
2273, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
2274, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
2275, 59, 75, 519, 435
2276, 435, 519, 520, 436
2277, 436, 520, 521, 437
2278, 437, 521, 522, 438
2279, 438, 522, 523, 439
2280, 439, 523, 524, 440
2281, 440, 524, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
2282, 65, 465, 519, 75
2283, 465, 466, 520, 519
2284, 466, 467, 521, 520
2285, 467, 468, 522, 521
2286, 468, 469, 523, 522
2287, 469, 470, 524, 523
2288, 470, 66, 76, 524
*ELEMENT, type=CPS4, ELSET=Surface105
2289, 22, 529, 1427, 223
2290, 529, 530, 1428, 1427
2291, 530, 531, 1429, 1428
2292, 531, 532, 1430, 1429
2293, 532, 78, 533, 1430
2294, 223, 1427, 1431, 224
2295, 1427, 1428, 1432, 1431
2296, 1428, 1429, 1433, 1432
2297, 1429, 1430, 1434, 1433
2298, 1430, 533, 534, 1434
2299, 224, 1431, 1435, 225
2300, 1431, 1432, 1436, 1435
2301, 1432, 1433, 1437, 1436
2302, 1433, 1434, 1438, 1437
2303, 1434, 534, 535, 1438
2304, 225, 1435, 1439, 226
2305, 1435, 1436, 1440, 1439
2306, 1436, 1437, 1441, 1440
2307, 1437, 1438, 1442, 1441
2308, 1438, 535, 536, 1442
2309, 226, 1439, 1443, 227
2310, 1439, 1440, 1444, 1443
2311, 1440, 1441, 1445, 1444
2312, 1441, 1442, 1446, 1445
2313, 1442, 536, 537, 1446
2314, 227, 1443, 1447, 228
2315, 1443, 1444, 1448, 1447
2316, 1444, 1445, 1449, 1448
2317, 1445, 1446, 1450, 1449
2318, 1446, 537, 538, 1450
2319, 228, 1447, 525, 21
2320, 1447, 1448, 526, 525
2321, 1448, 1449, 527, 526
2322, 1449, 1450, 528, 527
2323, 1450, 538, 77, 528
*ELEMENT, type=CPS4, ELSET=Surface106
2324, 21, 525, 1451, 231
2325, 525, 526, 1452, 1451
2326, 526, 527, 1453, 1452
2327, 527, 528, 1454, 1453
2328, 528, 77, 543, 1454
2329, 231, 1451, 1455, 232
2330, 1451, 1452, 1456, 1455
2331, 1452, 1453, 1457, 1456
2332, 1453, 1454, 1458, 1457
2333, 1454, 543, 544, 1458
2334, 232, 1455, 1459, 233
2335, 1455, 1456, 1460, 1459
2336, 1456, 1457, 1461, 1460
2337, 1457, 1458, 1462, 1461
2338, 1458, 544, 545, 1462
2339, 233, 1459, 539, 23
2340, 1459, 1460, 540, 539
2341, 1460, 1461, 541, 540
2342, 1461, 1462, 542, 541
2343, 1462, 545, 79, 542
*ELEMENT, type=CPS4, ELSET=Surface107
2344, 24, 236, 1463, 546
2345, 546, 1463, 1464, 547
2346, 547, 1464, 1465, 548
2347, 548, 1465, 1466, 549
2348, 549, 1466, 550, 80
2349, 236, 237, 1467, 1463
2350, 1463, 1467, 1468, 1464
2351, 1464, 1468, 1469, 1465
2352, 1465, 1469, 1470, 1466
2353, 1466, 1470, 551, 550
2354, 237, 238, 1471, 1467
2355, 1467, 1471, 1472, 1468
2356, 1468, 1472, 1473, 1469
2357, 1469, 1473, 1474, 1470
2358, 1470, 1474, 552, 551
2359, 238, 239, 1475, 1471
2360, 1471, 1475, 1476, 1472
2361, 1472, 1476, 1477, 1473
2362, 1473, 1477, 1478, 1474
2363, 1474, 1478, 553, 552
2364, 239, 240, 1479, 1475
2365, 1475, 1479, 1480, 1476
2366, 1476, 1480, 1481, 1477
2367, 1477, 1481, 1482, 1478
2368, 1478, 1482, 554, 553
2369, 240, 241, 1483, 1479
2370, 1479, 1483, 1484, 1480
2371, 1480, 1484, 1485, 1481
2372, 1481, 1485, 1486, 1482
2373, 1482, 1486, 555, 554
2374, 241, 23, 539, 1483
2375, 1483, 539, 540, 1484
2376, 1484, 540, 541, 1485
2377, 1485, 541, 542, 1486
2378, 1486, 542, 79, 555
*ELEMENT, type=CPS4, ELSET=Surface108
2379, 22, 242, 1487, 529
2380, 529, 1487, 1488, 530
2381, 530, 1488, 1489, 531
2382, 531, 1489, 1490, 532
2383, 532, 1490, 556, 78
2384, 242, 243, 1491, 1487
2385, 1487, 1491, 1492, 1488
2386, 1488, 1492, 1493, 1489
2387, 1489, 1493, 1494, 1490
2388, 1490, 1494, 557, 556
2389, 243, 244, 1495, 1491
2390, 1491, 1495, 1496, 1492
2391, 1492, 1496, 1497, 1493
2392, 1493, 1497, 1498, 1494
2393, 1494, 1498, 558, 557
2394, 244, 24, 546, 1495
2395, 1495, 546, 547, 1496
2396, 1496, 547, 548, 1497
2397, 1497, 548, 549, 1498
2398, 1498, 549, 80, 558
*ELEMENT, type=CPS4, ELSET=Surface109
2399, 78, 556, 1499, 533
2400, 556, 557, 1500, 1499
2401, 557, 558, 1501, 1500
2402, 558, 80, 550, 1501
2403, 533, 1499, 1502, 534
2404, 1499, 1500, 1503, 1502
2405, 1500, 1501, 1504, 1503
2406, 1501, 550, 551, 1504
2407, 534, 1502, 1505, 535
2408, 1502, 1503, 1506, 1505
2409, 1503, 1504, 1507, 1506
2410, 1504, 551, 552, 1507
2411, 535, 1505, 1508, 536
2412, 1505, 1506, 1509, 1508
2413, 1506, 1507, 1510, 1509
2414, 1507, 552, 553, 1510
2415, 536, 1508, 1511, 537
2416, 1508, 1509, 1512, 1511
2417, 1509, 1510, 1513, 1512
2418, 1510, 553, 554, 1513
2419, 537, 1511, 1514, 538
2420, 1511, 1512, 1515, 1514
2421, 1512, 1513, 1516, 1515
2422, 1513, 554, 555, 1516
2423, 538, 1514, 543, 77
2424, 1514, 1515, 544, 543
2425, 1515, 1516, 545, 544
2426, 1516, 555, 79, 545
*ELEMENT, type=CPS4, ELSET=Surface110
2427, 23, 249, 1517, 539
2428, 539, 1517, 1518, 540
2429, 540, 1518, 1519, 541
2430, 541, 1519, 1520, 542
2431, 542, 1520, 563, 79
2432, 249, 250, 1521, 1517
2433, 1517, 1521, 1522, 1518
2434, 1518, 1522, 1523, 1519
2435, 1519, 1523, 1524, 1520
2436, 1520, 1524, 564, 563
2437, 250, 251, 1525, 1521
2438, 1521, 1525, 1526, 1522
2439, 1522, 1526, 1527, 1523
2440, 1523, 1527, 1528, 1524
2441, 1524, 1528, 565, 564
2442, 251, 252, 1529, 1525
2443, 1525, 1529, 1530, 1526
2444, 1526, 1530, 1531, 1527
2445, 1527, 1531, 1532, 1528
2446, 1528, 1532, 566, 565
2447, 252, 26, 559, 1529
2448, 1529, 559, 560, 1530
2449, 1530, 560, 561, 1531
2450, 1531, 561, 562, 1532
2451, 1532, 562, 81, 566
*ELEMENT, type=CPS4, ELSET=Surface111
2452, 21, 525, 1533, 259
2453, 525, 526, 1534, 1533
2454, 526, 527, 1535, 1534
2455, 527, 528, 1536, 1535
2456, 528, 77, 571, 1536
2457, 259, 1533, 1537, 260
2458, 1533, 1534, 1538, 1537
2459, 1534, 1535, 1539, 1538
2460, 1535, 1536, 1540, 1539
2461, 1536, 571, 572, 1540
2462, 260, 1537, 1541, 261
2463, 1537, 1538, 1542, 1541
2464, 1538, 1539, 1543, 1542
2465, 1539, 1540, 1544, 1543
2466, 1540, 572, 573, 1544
2467, 261, 1541, 1545, 262
2468, 1541, 1542, 1546, 1545
2469, 1542, 1543, 1547, 1546
2470, 1543, 1544, 1548, 1547
2471, 1544, 573, 574, 1548
2472, 262, 1545, 567, 28
2473, 1545, 1546, 568, 567
2474, 1546, 1547, 569, 568
2475, 1547, 1548, 570, 569
2476, 1548, 574, 82, 570
*ELEMENT, type=CPS4, ELSET=Surface112
2477, 28, 567, 1549, 268
2478, 567, 568, 1550, 1549
2479, 568, 569, 1551, 1550
2480, 569, 570, 1552, 1551
2481, 570, 82, 575, 1552
2482, 268, 1549, 1553, 269
2483, 1549, 1550, 1554, 1553
2484, 1550, 1551, 1555, 1554
2485, 1551, 1552, 1556, 1555
2486, 1552, 575, 576, 1556
2487, 269, 1553, 1557, 270
2488, 1553, 1554, 1558, 1557
2489, 1554, 1555, 1559, 1558
2490, 1555, 1556, 1560, 1559
2491, 1556, 576, 577, 1560
2492, 270, 1557, 559, 26
2493, 1557, 1558, 560, 559
2494, 1558, 1559, 561, 560
2495, 1559, 1560, 562, 561
2496, 1560, 577, 81, 562
*ELEMENT, type=CPS4, ELSET=Surface113
2497, 77, 543, 1561, 571
2498, 571, 1561, 1562, 572
2499, 572, 1562, 1563, 573
2500, 573, 1563, 1564, 574
2501, 574, 1564, 575, 82
2502, 543, 544, 1565, 1561
2503, 1561, 1565, 1566, 1562
2504, 1562, 1566, 1567, 1563
2505, 1563, 1567, 1568, 1564
2506, 1564, 1568, 576, 575
2507, 544, 545, 1569, 1565
2508, 1565, 1569, 1570, 1566
2509, 1566, 1570, 1571, 1567
2510, 1567, 1571, 1572, 1568
2511, 1568, 1572, 577, 576
2512, 545, 79, 563, 1569
2513, 1569, 563, 564, 1570
2514, 1570, 564, 565, 1571
2515, 1571, 565, 566, 1572
2516, 1572, 566, 81, 577
*ELEMENT, type=CPS4, ELSET=Surface114
2517, 26, 277, 1573, 559
2518, 559, 1573, 1574, 560
2519, 560, 1574, 1575, 561
2520, 561, 1575, 1576, 562
2521, 562, 1576, 582, 81
2522, 277, 278, 1577, 1573
2523, 1573, 1577, 1578, 1574
2524, 1574, 1578, 1579, 1575
2525, 1575, 1579, 1580, 1576
2526, 1576, 1580, 583, 582
2527, 278, 279, 1581, 1577
2528, 1577, 1581, 1582, 1578
2529, 1578, 1582, 1583, 1579
2530, 1579, 1583, 1584, 1580
2531, 1580, 1584, 584, 583
2532, 279, 280, 1585, 1581
2533, 1581, 1585, 1586, 1582
2534, 1582, 1586, 1587, 1583
2535, 1583, 1587, 1588, 1584
2536, 1584, 1588, 585, 584
2537, 280, 281, 1589, 1585
2538, 1585, 1589, 1590, 1586
2539, 1586, 1590, 1591, 1587
2540, 1587, 1591, 1592, 1588
2541, 1588, 1592, 586, 585
2542, 281, 282, 1593, 1589
2543, 1589, 1593, 1594, 1590
2544, 1590, 1594, 1595, 1591
2545, 1591, 1595, 1596, 1592
2546, 1592, 1596, 587, 586
2547, 282, 30, 578, 1593
2548, 1593, 578, 579, 1594
2549, 1594, 579, 580, 1595
2550, 1595, 580, 581, 1596
2551, 1596, 581, 83, 587
*ELEMENT, type=CPS4, ELSET=Surface115
2552, 28, 567, 1597, 291
2553, 567, 568, 1598, 1597
2554, 568, 569, 1599, 1598
2555, 569, 570, 1600, 1599
2556, 570, 82, 592, 1600
2557, 291, 1597, 1601, 292
2558, 1597, 1598, 1602, 1601
2559, 1598, 1599, 1603, 1602
2560, 1599, 1600, 1604, 1603
2561, 1600, 592, 593, 1604
2562, 292, 1601, 1605, 293
2563, 1601, 1602, 1606, 1605
2564, 1602, 1603, 1607, 1606
2565, 1603, 1604, 1608, 1607
2566, 1604, 593, 594, 1608
2567, 293, 1605, 1609, 294
2568, 1605, 1606, 1610, 1609
2569, 1606, 1607, 1611, 1610
2570, 1607, 1608, 1612, 1611
2571, 1608, 594, 595, 1612
2572, 294, 1609, 1613, 295
2573, 1609, 1610, 1614, 1613
2574, 1610, 1611, 1615, 1614
2575, 1611, 1612, 1616, 1615
2576, 1612, 595, 596, 1616
2577, 295, 1613, 1617, 296
2578, 1613, 1614, 1618, 1617
2579, 1614, 1615, 1619, 1618
2580, 1615, 1616, 1620, 1619
2581, 1616, 596, 597, 1620
2582, 296, 1617, 588, 32
2583, 1617, 1618, 589, 588
2584, 1618, 1619, 590, 589
2585, 1619, 1620, 591, 590
2586, 1620, 597, 84, 591
*ELEMENT, type=CPS4, ELSET=Surface116
2587, 32, 588, 1621, 302
2588, 588, 589, 1622, 1621
2589, 589, 590, 1623, 1622
2590, 590, 591, 1624, 1623
2591, 591, 84, 598, 1624
2592, 302, 1621, 1625, 303
2593, 1621, 1622, 1626, 1625
2594, 1622, 1623, 1627, 1626
2595, 1623, 1624, 1628, 1627
2596, 1624, 598, 599, 1628
2597, 303, 1625, 1629, 304
2598, 1625, 1626, 1630, 1629
2599, 1626, 1627, 1631, 1630
2600, 1627, 1628, 1632, 1631
2601, 1628, 599, 600, 1632
2602, 304, 1629, 578, 30
2603, 1629, 1630, 579, 578
2604, 1630, 1631, 580, 579
2605, 1631, 1632, 581, 580
2606, 1632, 600, 83, 581
*ELEMENT, type=CPS4, ELSET=Surface117
2607, 82, 575, 1633, 592
2608, 592, 1633, 1634, 593
2609, 593, 1634, 1635, 594
2610, 594, 1635, 1636, 595
2611, 595, 1636, 1637, 596
2612, 596, 1637, 1638, 597
2613, 597, 1638, 598, 84
2614, 575, 576, 1639, 1633
2615, 1633, 1639, 1640, 1634
2616, 1634, 1640, 1641, 1635
2617, 1635, 1641, 1642, 1636
2618, 1636, 1642, 1643, 1637
2619, 1637, 1643, 1644, 1638
2620, 1638, 1644, 599, 598
2621, 576, 577, 1645, 1639
2622, 1639, 1645, 1646, 1640
2623, 1640, 1646, 1647, 1641
2624, 1641, 1647, 1648, 1642
2625, 1642, 1648, 1649, 1643
2626, 1643, 1649, 1650, 1644
2627, 1644, 1650, 600, 599
2628, 577, 81, 582, 1645
2629, 1645, 582, 583, 1646
2630, 1646, 583, 584, 1647
2631, 1647, 584, 585, 1648
2632, 1648, 585, 586, 1649
2633, 1649, 586, 587, 1650
2634, 1650, 587, 83, 600
*ELEMENT, type=CPS4, ELSET=Surface118
2635, 2, 117, 1651, 605
2636, 605, 1651, 1652, 606
2637, 606, 1652, 1653, 607
2638, 607, 1653, 1654, 608
2639, 608, 1654, 609, 86
2640, 117, 118, 1655, 1651
2641, 1651, 1655, 1656, 1652
2642, 1652, 1656, 1657, 1653
2643, 1653, 1657, 1658, 1654
2644, 1654, 1658, 610, 609
2645, 118, 119, 1659, 1655
2646, 1655, 1659, 1660, 1656
2647, 1656, 1660, 1661, 1657
2648, 1657, 1661, 1662, 1658
2649, 1658, 1662, 611, 610
2650, 119, 120, 1663, 1659
2651, 1659, 1663, 1664, 1660
2652, 1660, 1664, 1665, 1661
2653, 1661, 1665, 1666, 1662
2654, 1662, 1666, 612, 611
2655, 120, 121, 1667, 1663
2656, 1663, 1667, 1668, 1664
2657, 1664, 1668, 1669, 1665
2658, 1665, 1669, 1670, 1666
2659, 1666, 1670, 613, 612
2660, 121, 122, 1671, 1667
2661, 1667, 1671, 1672, 1668
2662, 1668, 1672, 1673, 1669
2663, 1669, 1673, 1674, 1670
2664, 1670, 1674, 614, 613
2665, 122, 6, 601, 1671
2666, 1671, 601, 602, 1672
2667, 1672, 602, 603, 1673
2668, 1673, 603, 604, 1674
2669, 1674, 604, 85, 614
*ELEMENT, type=CPS4, ELSET=Surface119
2670, 6, 107, 1675, 601
2671, 601, 1675, 1676, 602
2672, 602, 1676, 1677, 603
2673, 603, 1677, 1678, 604
2674, 604, 1678, 619, 85
2675, 107, 108, 1679, 1675
2676, 1675, 1679, 1680, 1676
2677, 1676, 1680, 1681, 1677
2678, 1677, 1681, 1682, 1678
2679, 1678, 1682, 620, 619
2680, 108, 109, 1683, 1679
2681, 1679, 1683, 1684, 1680
2682, 1680, 1684, 1685, 1681
2683, 1681, 1685, 1686, 1682
2684, 1682, 1686, 621, 620
2685, 109, 5, 615, 1683
2686, 1683, 615, 616, 1684
2687, 1684, 616, 617, 1685
2688, 1685, 617, 618, 1686
2689, 1686, 618, 87, 621
*ELEMENT, type=CPS4, ELSET=Surface120
2690, 1, 622, 1687, 123
2691, 622, 623, 1688, 1687
2692, 623, 624, 1689, 1688
2693, 624, 625, 1690, 1689
2694, 625, 88, 626, 1690
2695, 123, 1687, 1691, 124
2696, 1687, 1688, 1692, 1691
2697, 1688, 1689, 1693, 1692
2698, 1689, 1690, 1694, 1693
2699, 1690, 626, 627, 1694
2700, 124, 1691, 1695, 125
2701, 1691, 1692, 1696, 1695
2702, 1692, 1693, 1697, 1696
2703, 1693, 1694, 1698, 1697
2704, 1694, 627, 628, 1698
2705, 125, 1695, 1699, 126
2706, 1695, 1696, 1700, 1699
2707, 1696, 1697, 1701, 1700
2708, 1697, 1698, 1702, 1701
2709, 1698, 628, 629, 1702
2710, 126, 1699, 1703, 127
2711, 1699, 1700, 1704, 1703
2712, 1700, 1701, 1705, 1704
2713, 1701, 1702, 1706, 1705
2714, 1702, 629, 630, 1706
2715, 127, 1703, 1707, 128
2716, 1703, 1704, 1708, 1707
2717, 1704, 1705, 1709, 1708
2718, 1705, 1706, 1710, 1709
2719, 1706, 630, 631, 1710
2720, 128, 1707, 615, 5
2721, 1707, 1708, 616, 615
2722, 1708, 1709, 617, 616
2723, 1709, 1710, 618, 617
2724, 1710, 631, 87, 618
*ELEMENT, type=CPS4, ELSET=Surface121
2725, 2, 605, 1711, 97
2726, 605, 606, 1712, 1711
2727, 606, 607, 1713, 1712
2728, 607, 608, 1714, 1713
2729, 608, 86, 632, 1714
2730, 97, 1711, 1715, 98
2731, 1711, 1712, 1716, 1715
2732, 1712, 1713, 1717, 1716
2733, 1713, 1714, 1718, 1717
2734, 1714, 632, 633, 1718
2735, 98, 1715, 1719, 99
2736, 1715, 1716, 1720, 1719
2737, 1716, 1717, 1721, 1720
2738, 1717, 1718, 1722, 1721
2739, 1718, 633, 634, 1722
2740, 99, 1719, 622, 1
2741, 1719, 1720, 623, 622
2742, 1720, 1721, 624, 623
2743, 1721, 1722, 625, 624
2744, 1722, 634, 88, 625
*ELEMENT, type=CPS4, ELSET=Surface122
2745, 86, 609, 1723, 632
2746, 632, 1723, 1724, 633
2747, 633, 1724, 1725, 634
2748, 634, 1725, 626, 88
2749, 609, 610, 1726, 1723
2750, 1723, 1726, 1727, 1724
2751, 1724, 1727, 1728, 1725
2752, 1725, 1728, 627, 626
2753, 610, 611, 1729, 1726
2754, 1726, 1729, 1730, 1727
2755, 1727, 1730, 1731, 1728
2756, 1728, 1731, 628, 627
2757, 611, 612, 1732, 1729
2758, 1729, 1732, 1733, 1730
2759, 1730, 1733, 1734, 1731
2760, 1731, 1734, 629, 628
2761, 612, 613, 1735, 1732
2762, 1732, 1735, 1736, 1733
2763, 1733, 1736, 1737, 1734
2764, 1734, 1737, 630, 629
2765, 613, 614, 1738, 1735
2766, 1735, 1738, 1739, 1736
2767, 1736, 1739, 1740, 1737
2768, 1737, 1740, 631, 630
2769, 614, 85, 619, 1738
2770, 1738, 619, 620, 1739
2771, 1739, 620, 621, 1740
2772, 1740, 621, 87, 631
*ELEMENT, type=CPS4, ELSET=Surface123
2773, 1, 53, 635, 622
2774, 622, 635, 636, 623
2775, 623, 636, 637, 624
2776, 624, 637, 638, 625
2777, 625, 638, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
2778, 2, 605, 639, 54
2779, 605, 606, 640, 639
2780, 606, 607, 641, 640
2781, 607, 608, 642, 641
2782, 608, 86, 90, 642
*ELEMENT, type=CPS4, ELSET=Surface125
2783, 54, 639, 1741, 419
2784, 639, 640, 1742, 1741
2785, 640, 641, 1743, 1742
2786, 641, 642, 1744, 1743
2787, 642, 90, 643, 1744
2788, 419, 1741, 1745, 420
2789, 1741, 1742, 1746, 1745
2790, 1742, 1743, 1747, 1746
2791, 1743, 1744, 1748, 1747
2792, 1744, 643, 644, 1748
2793, 420, 1745, 1749, 421
2794, 1745, 1746, 1750, 1749
2795, 1746, 1747, 1751, 1750
2796, 1747, 1748, 1752, 1751
2797, 1748, 644, 645, 1752
2798, 421, 1749, 635, 53
2799, 1749, 1750, 636, 635
2800, 1750, 1751, 637, 636
2801, 1751, 1752, 638, 637
2802, 1752, 645, 89, 638
*ELEMENT, type=CPS4, ELSET=Surface126
2803, 86, 632, 643, 90
2804, 632, 633, 644, 643
2805, 633, 634, 645, 644
2806, 634, 88, 89, 645
*ELEMENT, type=CPS4, ELSET=Surface127
2807, 45, 646, 1753, 387
2808, 646, 647, 1754, 1753
2809, 647, 648, 1755, 1754
2810, 648, 649, 1756, 1755
2811, 649, 91, 654, 1756
2812, 387, 1753, 1757, 388
2813, 1753, 1754, 1758, 1757
2814, 1754, 1755, 1759, 1758
2815, 1755, 1756, 1760, 1759
2816, 1756, 654, 655, 1760
2817, 388, 1757, 1761, 389
2818, 1757, 1758, 1762, 1761
2819, 1758, 1759, 1763, 1762
2820, 1759, 1760, 1764, 1763
2821, 1760, 655, 656, 1764
2822, 389, 1761, 1765, 390
2823, 1761, 1762, 1766, 1765
2824, 1762, 1763, 1767, 1766
2825, 1763, 1764, 1768, 1767
2826, 1764, 656, 657, 1768
2827, 390, 1765, 1769, 391
2828, 1765, 1766, 1770, 1769
2829, 1766, 1767, 1771, 1770
2830, 1767, 1768, 1772, 1771
2831, 1768, 657, 658, 1772
2832, 391, 1769, 1773, 392
2833, 1769, 1770, 1774, 1773
2834, 1770, 1771, 1775, 1774
2835, 1771, 1772, 1776, 1775
2836, 1772, 658, 659, 1776
2837, 392, 1773, 650, 46
2838, 1773, 1774, 651, 650
2839, 1774, 1775, 652, 651
2840, 1775, 1776, 653, 652
2841, 1776, 659, 92, 653
*ELEMENT, type=CPS4, ELSET=Surface128
2842, 47, 397, 1777, 660
2843, 660, 1777, 1778, 661
2844, 661, 1778, 1779, 662
2845, 662, 1779, 1780, 663
2846, 663, 1780, 668, 93
2847, 397, 398, 1781, 1777
2848, 1777, 1781, 1782, 1778
2849, 1778, 1782, 1783, 1779
2850, 1779, 1783, 1784, 1780
2851, 1780, 1784, 669, 668
2852, 398, 399, 1785, 1781
2853, 1781, 1785, 1786, 1782
2854, 1782, 1786, 1787, 1783
2855, 1783, 1787, 1788, 1784
2856, 1784, 1788, 670, 669
2857, 399, 400, 1789, 1785
2858, 1785, 1789, 1790, 1786
2859, 1786, 1790, 1791, 1787
2860, 1787, 1791, 1792, 1788
2861, 1788, 1792, 671, 670
2862, 400, 401, 1793, 1789
2863, 1789, 1793, 1794, 1790
2864, 1790, 1794, 1795, 1791
2865, 1791, 1795, 1796, 1792
2866, 1792, 1796, 672, 671
2867, 401, 402, 1797, 1793
2868, 1793, 1797, 1798, 1794
2869, 1794, 1798, 1799, 1795
2870, 1795, 1799, 1800, 1796
2871, 1796, 1800, 673, 672
2872, 402, 48, 664, 1797
2873, 1797, 664, 665, 1798
2874, 1798, 665, 666, 1799
2875, 1799, 666, 667, 1800
2876, 1800, 667, 94, 673
*ELEMENT, type=CPS4, ELSET=Surface129
2877, 47, 660, 1801, 403
2878, 660, 661, 1802, 1801
2879, 661, 662, 1803, 1802
2880, 662, 663, 1804, 1803
2881, 663, 93, 674, 1804
2882, 403, 1801, 1805, 404
2883, 1801, 1802, 1806, 1805
2884, 1802, 1803, 1807, 1806
2885, 1803, 1804, 1808, 1807
2886, 1804, 674, 675, 1808
2887, 404, 1805, 1809, 405
2888, 1805, 1806, 1810, 1809
2889, 1806, 1807, 1811, 1810
2890, 1807, 1808, 1812, 1811
2891, 1808, 675, 676, 1812
2892, 405, 1809, 646, 45
2893, 1809, 1810, 647, 646
2894, 1810, 1811, 648, 647
2895, 1811, 1812, 649, 648
2896, 1812, 676, 91, 649
*ELEMENT, type=CPS4, ELSET=Surface130
2897, 48, 406, 1813, 664
2898, 664, 1813, 1814, 665
2899, 665, 1814, 1815, 666
2900, 666, 1815, 1816, 667
2901, 667, 1816, 677, 94
2902, 406, 407, 1817, 1813
2903, 1813, 1817, 1818, 1814
2904, 1814, 1818, 1819, 1815
2905, 1815, 1819, 1820, 1816
2906, 1816, 1820, 678, 677
2907, 407, 408, 1821, 1817
2908, 1817, 1821, 1822, 1818
2909, 1818, 1822, 1823, 1819
2910, 1819, 1823, 1824, 1820
2911, 1820, 1824, 679, 678
2912, 408, 46, 650, 1821
2913, 1821, 650, 651, 1822
2914, 1822, 651, 652, 1823
2915, 1823, 652, 653, 1824
2916, 1824, 653, 92, 679
*ELEMENT, type=CPS4, ELSET=Surface131
2917, 93, 668, 1825, 674
2918, 668, 669, 1826, 1825
2919, 669, 670, 1827, 1826
2920, 670, 671, 1828, 1827
2921, 671, 672, 1829, 1828
2922, 672, 673, 1830, 1829
2923, 673, 94, 677, 1830
2924, 674, 1825, 1831, 675
2925, 1825, 1826, 1832, 1831
2926, 1826, 1827, 1833, 1832
2927, 1827, 1828, 1834, 1833
2928, 1828, 1829, 1835, 1834
2929, 1829, 1830, 1836, 1835
2930, 1830, 677, 678, 1836
2931, 675, 1831, 1837, 676
2932, 1831, 1832, 1838, 1837
2933, 1832, 1833, 1839, 1838
2934, 1833, 1834, 1840, 1839
2935, 1834, 1835, 1841, 1840
2936, 1835, 1836, 1842, 1841
2937, 1836, 678, 679, 1842
2938, 676, 1837, 654, 91
2939, 1837, 1838, 655, 654
2940, 1838, 1839, 656, 655
2941, 1839, 1840, 657, 656
2942, 1840, 1841, 658, 657
2943, 1841, 1842, 659, 658
2944, 1842, 679, 92, 659
*ELEMENT, type=CPS4, ELSET=Surface132
2945, 46, 650, 680, 50
2946, 650, 651, 681, 680
2947, 651, 652, 682, 681
2948, 652, 653, 683, 682
2949, 653, 92, 95, 683
*ELEMENT, type=CPS4, ELSET=Surface133
2950, 48, 52, 684, 664
2951, 664, 684, 685, 665
2952, 665, 685, 686, 666
2953, 666, 686, 687, 667
2954, 667, 687, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
2955, 52, 416, 1843, 684
2956, 684, 1843, 1844, 685
2957, 685, 1844, 1845, 686
2958, 686, 1845, 1846, 687
2959, 687, 1846, 688, 96
2960, 416, 417, 1847, 1843
2961, 1843, 1847, 1848, 1844
2962, 1844, 1848, 1849, 1845
2963, 1845, 1849, 1850, 1846
2964, 1846, 1850, 689, 688
2965, 417, 418, 1851, 1847
2966, 1847, 1851, 1852, 1848
2967, 1848, 1852, 1853, 1849
2968, 1849, 1853, 1854, 1850
2969, 1850, 1854, 690, 689
2970, 418, 50, 680, 1851
2971, 1851, 680, 681, 1852
2972, 1852, 681, 682, 1853
2973, 1853, 682, 683, 1854
2974, 1854, 683, 95, 690
*ELEMENT, type=CPS4, ELSET=Surface135
2975, 94, 96, 688, 677
2976, 677, 688, 689, 678
2977, 678, 689, 690, 679
2978, 679, 690, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
2979, 691, 97, 2, 105, 1855, 703, 117, 739
2980, 1855, 703, 117, 739, 1856, 706, 118, 740
2981, 1856, 706, 118, 740, 1857, 709, 119, 741
2982, 1857, 709, 119, 741, 1858, 712, 120, 742
2983, 1858, 712, 120, 742, 1859, 715, 121, 743
2984, 1859, 715, 121, 743, 1860, 718, 122, 744
2985, 1860, 718, 122, 744, 697, 107, 6, 115
2986, 692, 691, 105, 106, 1861, 1855, 739, 745
2987, 1861, 1855, 739, 745, 1862, 1856, 740, 746
2988, 1862, 1856, 740, 746, 1863, 1857, 741, 747
2989, 1863, 1857, 741, 747, 1864, 1858, 742, 748
2990, 1864, 1858, 742, 748, 1865, 1859, 743, 749
2991, 1865, 1859, 743, 749, 1866, 1860, 744, 750
2992, 1866, 1860, 744, 750, 698, 697, 115, 116
2993, 102, 692, 106, 4, 721, 1861, 745, 129
2994, 721, 1861, 745, 129, 724, 1862, 746, 130
2995, 724, 1862, 746, 130, 727, 1863, 747, 131
2996, 727, 1863, 747, 131, 730, 1864, 748, 132
2997, 730, 1864, 748, 132, 733, 1865, 749, 133
2998, 733, 1865, 749, 133, 736, 1866, 750, 134
2999, 736, 1866, 750, 134, 112, 698, 116, 8
3000, 693, 98, 97, 691, 1867, 704, 703, 1855
3001, 1867, 704, 703, 1855, 1868, 707, 706, 1856
3002, 1868, 707, 706, 1856, 1869, 710, 709, 1857
3003, 1869, 710, 709, 1857, 1870, 713, 712, 1858
3004, 1870, 713, 712, 1858, 1871, 716, 715, 1859
3005, 1871, 716, 715, 1859, 1872, 719, 718, 1860
3006, 1872, 719, 718, 1860, 699, 108, 107, 697
3007, 694, 693, 691, 692, 1873, 1867, 1855, 1861
3008, 1873, 1867, 1855, 1861, 1874, 1868, 1856, 1862
3009, 1874, 1868, 1856, 1862, 1875, 1869, 1857, 1863
3010, 1875, 1869, 1857, 1863, 1876, 1870, 1858, 1864
3011, 1876, 1870, 1858, 1864, 1877, 1871, 1859, 1865
3012, 1877, 1871, 1859, 1865, 1878, 1872, 1860, 1866
3013, 1878, 1872, 1860, 1866, 700, 699, 697, 698
3014, 103, 694, 692, 102, 722, 1873, 1861, 721
3015, 722, 1873, 1861, 721, 725, 1874, 1862, 724
3016, 725, 1874, 1862, 724, 728, 1875, 1863, 727
3017, 728, 1875, 1863, 727, 731, 1876, 1864, 730
3018, 731, 1876, 1864, 730, 734, 1877, 1865, 733
3019, 734, 1877, 1865, 733, 737, 1878, 1866, 736
3020, 737, 1878, 1866, 736, 113, 700, 698, 112
3021, 695, 99, 98, 693, 1879, 705, 704, 1867
3022, 1879, 705, 704, 1867, 1880, 708, 707, 1868
3023, 1880, 708, 707, 1868, 1881, 711, 710, 1869
3024, 1881, 711, 710, 1869, 1882, 714, 713, 1870
3025, 1882, 714, 713, 1870, 1883, 717, 716, 1871
3026, 1883, 717, 716, 1871, 1884, 720, 719, 1872
3027, 1884, 720, 719, 1872, 701, 109, 108, 699
3028, 696, 695, 693, 694, 1885, 1879, 1867, 1873
3029, 1885, 1879, 1867, 1873, 1886, 1880, 1868, 1874
3030, 1886, 1880, 1868, 1874, 1887, 1881, 1869, 1875
3031, 1887, 1881, 1869, 1875, 1888, 1882, 1870, 1876
3032, 1888, 1882, 1870, 1876, 1889, 1883, 1871, 1877
3033, 1889, 1883, 1871, 1877, 1890, 1884, 1872, 1878
3034, 1890, 1884, 1872, 1878, 702, 701, 699, 700
3035, 104, 696, 694, 103, 723, 1885, 1873, 722
3036, 723, 1885, 1873, 722, 726, 1886, 1874, 725
3037, 726, 1886, 1874, 725, 729, 1887, 1875, 728
3038, 729, 1887, 1875, 728, 732, 1888, 1876, 731
3039, 732, 1888, 1876, 731, 735, 1889, 1877, 734
3040, 735, 1889, 1877, 734, 738, 1890, 1878, 737
3041, 738, 1890, 1878, 737, 114, 702, 700, 113
3042, 100, 1, 99, 695, 751, 123, 705, 1879
3043, 751, 123, 705, 1879, 752, 124, 708, 1880
3044, 752, 124, 708, 1880, 753, 125, 711, 1881
3045, 753, 125, 711, 1881, 754, 126, 714, 1882
3046, 754, 126, 714, 1882, 755, 127, 717, 1883
3047, 755, 127, 717, 1883, 756, 128, 720, 1884
3048, 756, 128, 720, 1884, 110, 5, 109, 701
3049, 101, 100, 695, 696, 757, 751, 1879, 1885
3050, 757, 751, 1879, 1885, 758, 752, 1880, 1886
3051, 758, 752, 1880, 1886, 759, 753, 1881, 1887
3052, 759, 753, 1881, 1887, 760, 754, 1882, 1888
3053, 760, 754, 1882, 1888, 761, 755, 1883, 1889
3054, 761, 755, 1883, 1889, 762, 756, 1884, 1890
3055, 762, 756, 1884, 1890, 111, 110, 701, 702
3056, 3, 101, 696, 104, 135, 757, 1885, 723
3057, 135, 757, 1885, 723, 136, 758, 1886, 726
3058, 136, 758, 1886, 726, 137, 759, 1887, 729
3059, 137, 759, 1887, 729, 138, 760, 1888, 732
3060, 138, 760, 1888, 732, 139, 761, 1889, 735
3061, 139, 761, 1889, 735, 140, 762, 1890, 738
3062, 140, 762, 1890, 738, 7, 111, 702, 114
*ELEMENT, type=C3D8, ELSET=Volume2
3063, 4, 102, 721, 129, 10, 156, 763, 141
3064, 102, 103, 722, 721, 156, 157, 764, 763
3065, 103, 104, 723, 722, 157, 158, 765, 764
3066, 104, 3, 135, 723, 158, 12, 150, 765
3067, 129, 721, 724, 130, 141, 763, 766, 142
3068, 721, 722, 725, 724, 763, 764, 767, 766
3069, 722, 723, 726, 725, 764, 765, 768, 767
3070, 723, 135, 136, 726, 765, 150, 151, 768
3071, 130, 724, 727, 131, 142, 766, 769, 143
3072, 724, 725, 728, 727, 766, 767, 770, 769
3073, 725, 726, 729, 728, 767, 768, 771, 770
3074, 726, 136, 137, 729, 768, 151, 152, 771
3075, 131, 727, 730, 132, 143, 769, 772, 144
3076, 727, 728, 731, 730, 769, 770, 773, 772
3077, 728, 729, 732, 731, 770, 771, 774, 773
3078, 729, 137, 138, 732, 771, 152, 153, 774
3079, 132, 730, 733, 133, 144, 772, 775, 145
3080, 730, 731, 734, 733, 772, 773, 776, 775
3081, 731, 732, 735, 734, 773, 774, 777, 776
3082, 732, 138, 139, 735, 774, 153, 154, 777
3083, 133, 733, 736, 134, 145, 775, 778, 146
3084, 733, 734, 737, 736, 775, 776, 779, 778
3085, 734, 735, 738, 737, 776, 777, 780, 779
3086, 735, 139, 140, 738, 777, 154, 155, 780
3087, 134, 736, 112, 8, 146, 778, 147, 9
3088, 736, 737, 113, 112, 778, 779, 148, 147
3089, 737, 738, 114, 113, 779, 780, 149, 148
3090, 738, 140, 7, 114, 780, 155, 11, 149
*ELEMENT, type=C3D8, ELSET=Volume3
3091, 10, 156, 763, 141, 165, 871, 1891, 781
3092, 165, 871, 1891, 781, 166, 872, 1892, 782
3093, 166, 872, 1892, 782, 167, 873, 1893, 783
3094, 167, 873, 1893, 783, 168, 874, 1894, 784
3095, 168, 874, 1894, 784, 169, 875, 1895, 785
3096, 169, 875, 1895, 785, 170, 876, 1896, 786
3097, 170, 876, 1896, 786, 14, 198, 889, 171
3098, 156, 157, 764, 763, 871, 877, 1897, 1891
3099, 871, 877, 1897, 1891, 872, 878, 1898, 1892
3100, 872, 878, 1898, 1892, 873, 879, 1899, 1893
3101, 873, 879, 1899, 1893, 874, 880, 1900, 1894
3102, 874, 880, 1900, 1894, 875, 881, 1901, 1895
3103, 875, 881, 1901, 1895, 876, 882, 1902, 1896
3104, 876, 882, 1902, 1896, 198, 199, 890, 889
3105, 157, 158, 765, 764, 877, 883, 1903, 1897
3106, 877, 883, 1903, 1897, 878, 884, 1904, 1898
3107, 878, 884, 1904, 1898, 879, 885, 1905, 1899
3108, 879, 885, 1905, 1899, 880, 886, 1906, 1900
3109, 880, 886, 1906, 1900, 881, 887, 1907, 1901
3110, 881, 887, 1907, 1901, 882, 888, 1908, 1902
3111, 882, 888, 1908, 1902, 199, 200, 891, 890
3112, 158, 12, 150, 765, 883, 186, 835, 1903
3113, 883, 186, 835, 1903, 884, 187, 836, 1904
3114, 884, 187, 836, 1904, 885, 188, 837, 1905
3115, 885, 188, 837, 1905, 886, 189, 838, 1906
3116, 886, 189, 838, 1906, 887, 190, 839, 1907
3117, 887, 190, 839, 1907, 888, 191, 840, 1908
3118, 888, 191, 840, 1908, 200, 16, 192, 891
3119, 141, 763, 766, 142, 781, 1891, 1909, 787
3120, 781, 1891, 1909, 787, 782, 1892, 1910, 788
3121, 782, 1892, 1910, 788, 783, 1893, 1911, 789
3122, 783, 1893, 1911, 789, 784, 1894, 1912, 790
3123, 784, 1894, 1912, 790, 785, 1895, 1913, 791
3124, 785, 1895, 1913, 791, 786, 1896, 1914, 792
3125, 786, 1896, 1914, 792, 171, 889, 892, 172
3126, 763, 764, 767, 766, 1891, 1897, 1915, 1909
3127, 1891, 1897, 1915, 1909, 1892, 1898, 1916, 1910
3128, 1892, 1898, 1916, 1910, 1893, 1899, 1917, 1911
3129, 1893, 1899, 1917, 1911, 1894, 1900, 1918, 1912
3130, 1894, 1900, 1918, 1912, 1895, 1901, 1919, 1913
3131, 1895, 1901, 1919, 1913, 1896, 1902, 1920, 1914
3132, 1896, 1902, 1920, 1914, 889, 890, 893, 892
3133, 764, 765, 768, 767, 1897, 1903, 1921, 1915
3134, 1897, 1903, 1921, 1915, 1898, 1904, 1922, 1916
3135, 1898, 1904, 1922, 1916, 1899, 1905, 1923, 1917
3136, 1899, 1905, 1923, 1917, 1900, 1906, 1924, 1918
3137, 1900, 1906, 1924, 1918, 1901, 1907, 1925, 1919
3138, 1901, 1907, 1925, 1919, 1902, 1908, 1926, 1920
3139, 1902, 1908, 1926, 1920, 890, 891, 894, 893
3140, 765, 150, 151, 768, 1903, 835, 841, 1921
3141, 1903, 835, 841, 1921, 1904, 836, 842, 1922
3142, 1904, 836, 842, 1922, 1905, 837, 843, 1923
3143, 1905, 837, 843, 1923, 1906, 838, 844, 1924
3144, 1906, 838, 844, 1924, 1907, 839, 845, 1925
3145, 1907, 839, 845, 1925, 1908, 840, 846, 1926
3146, 1908, 840, 846, 1926, 891, 192, 193, 894
3147, 142, 766, 769, 143, 787, 1909, 1927, 793
3148, 787, 1909, 1927, 793, 788, 1910, 1928, 794
3149, 788, 1910, 1928, 794, 789, 1911, 1929, 795
3150, 789, 1911, 1929, 795, 790, 1912, 1930, 796
3151, 790, 1912, 1930, 796, 791, 1913, 1931, 797
3152, 791, 1913, 1931, 797, 792, 1914, 1932, 798
3153, 792, 1914, 1932, 798, 172, 892, 895, 173
3154, 766, 767, 770, 769, 1909, 1915, 1933, 1927
3155, 1909, 1915, 1933, 1927, 1910, 1916, 1934, 1928
3156, 1910, 1916, 1934, 1928, 1911, 1917, 1935, 1929
3157, 1911, 1917, 1935, 1929, 1912, 1918, 1936, 1930
3158, 1912, 1918, 1936, 1930, 1913, 1919, 1937, 1931
3159, 1913, 1919, 1937, 1931, 1914, 1920, 1938, 1932
3160, 1914, 1920, 1938, 1932, 892, 893, 896, 895
3161, 767, 768, 771, 770, 1915, 1921, 1939, 1933
3162, 1915, 1921, 1939, 1933, 1916, 1922, 1940, 1934
3163, 1916, 1922, 1940, 1934, 1917, 1923, 1941, 1935
3164, 1917, 1923, 1941, 1935, 1918, 1924, 1942, 1936
3165, 1918, 1924, 1942, 1936, 1919, 1925, 1943, 1937
3166, 1919, 1925, 1943, 1937, 1920, 1926, 1944, 1938
3167, 1920, 1926, 1944, 1938, 893, 894, 897, 896
3168, 768, 151, 152, 771, 1921, 841, 847, 1939
3169, 1921, 841, 847, 1939, 1922, 842, 848, 1940
3170, 1922, 842, 848, 1940, 1923, 843, 849, 1941
3171, 1923, 843, 849, 1941, 1924, 844, 850, 1942
3172, 1924, 844, 850, 1942, 1925, 845, 851, 1943
3173, 1925, 845, 851, 1943, 1926, 846, 852, 1944
3174, 1926, 846, 852, 1944, 894, 193, 194, 897
3175, 143, 769, 772, 144, 793, 1927, 1945, 799
3176, 793, 1927, 1945, 799, 794, 1928, 1946, 800
3177, 794, 1928, 1946, 800, 795, 1929, 1947, 801
3178, 795, 1929, 1947, 801, 796, 1930, 1948, 802
3179, 796, 1930, 1948, 802, 797, 1931, 1949, 803
3180, 797, 1931, 1949, 803, 798, 1932, 1950, 804
3181, 798, 1932, 1950, 804, 173, 895, 898, 174
3182, 769, 770, 773, 772, 1927, 1933, 1951, 1945
3183, 1927, 1933, 1951, 1945, 1928, 1934, 1952, 1946
3184, 1928, 1934, 1952, 1946, 1929, 1935, 1953, 1947
3185, 1929, 1935, 1953, 1947, 1930, 1936, 1954, 1948
3186, 1930, 1936, 1954, 1948, 1931, 1937, 1955, 1949
3187, 1931, 1937, 1955, 1949, 1932, 1938, 1956, 1950
3188, 1932, 1938, 1956, 1950, 895, 896, 899, 898
3189, 770, 771, 774, 773, 1933, 1939, 1957, 1951
3190, 1933, 1939, 1957, 1951, 1934, 1940, 1958, 1952
3191, 1934, 1940, 1958, 1952, 1935, 1941, 1959, 1953
3192, 1935, 1941, 1959, 1953, 1936, 1942, 1960, 1954
3193, 1936, 1942, 1960, 1954, 1937, 1943, 1961, 1955
3194, 1937, 1943, 1961, 1955, 1938, 1944, 1962, 1956
3195, 1938, 1944, 1962, 1956, 896, 897, 900, 899
3196, 771, 152, 153, 774, 1939, 847, 853, 1957
3197, 1939, 847, 853, 1957, 1940, 848, 854, 1958
3198, 1940, 848, 854, 1958, 1941, 849, 855, 1959
3199, 1941, 849, 855, 1959, 1942, 850, 856, 1960
3200, 1942, 850, 856, 1960, 1943, 851, 857, 1961
3201, 1943, 851, 857, 1961, 1944, 852, 858, 1962
3202, 1944, 852, 858, 1962, 897, 194, 195, 900
3203, 144, 772, 775, 145, 799, 1945, 1963, 805
3204, 799, 1945, 1963, 805, 800, 1946, 1964, 806
3205, 800, 1946, 1964, 806, 801, 1947, 1965, 807
3206, 801, 1947, 1965, 807, 802, 1948, 1966, 808
3207, 802, 1948, 1966, 808, 803, 1949, 1967, 809
3208, 803, 1949, 1967, 809, 804, 1950, 1968, 810
3209, 804, 1950, 1968, 810, 174, 898, 901, 175
3210, 772, 773, 776, 775, 1945, 1951, 1969, 1963
3211, 1945, 1951, 1969, 1963, 1946, 1952, 1970, 1964
3212, 1946, 1952, 1970, 1964, 1947, 1953, 1971, 1965
3213, 1947, 1953, 1971, 1965, 1948, 1954, 1972, 1966
3214, 1948, 1954, 1972, 1966, 1949, 1955, 1973, 1967
3215, 1949, 1955, 1973, 1967, 1950, 1956, 1974, 1968
3216, 1950, 1956, 1974, 1968, 898, 899, 902, 901
3217, 773, 774, 777, 776, 1951, 1957, 1975, 1969
3218, 1951, 1957, 1975, 1969, 1952, 1958, 1976, 1970
3219, 1952, 1958, 1976, 1970, 1953, 1959, 1977, 1971
3220, 1953, 1959, 1977, 1971, 1954, 1960, 1978, 1972
3221, 1954, 1960, 1978, 1972, 1955, 1961, 1979, 1973
3222, 1955, 1961, 1979, 1973, 1956, 1962, 1980, 1974
3223, 1956, 1962, 1980, 1974, 899, 900, 903, 902
3224, 774, 153, 154, 777, 1957, 853, 859, 1975
3225, 1957, 853, 859, 1975, 1958, 854, 860, 1976
3226, 1958, 854, 860, 1976, 1959, 855, 861, 1977
3227, 1959, 855, 861, 1977, 1960, 856, 862, 1978
3228, 1960, 856, 862, 1978, 1961, 857, 863, 1979
3229, 1961, 857, 863, 1979, 1962, 858, 864, 1980
3230, 1962, 858, 864, 1980, 900, 195, 196, 903
3231, 145, 775, 778, 146, 805, 1963, 1981, 811
3232, 805, 1963, 1981, 811, 806, 1964, 1982, 812
3233, 806, 1964, 1982, 812, 807, 1965, 1983, 813
3234, 807, 1965, 1983, 813, 808, 1966, 1984, 814
3235, 808, 1966, 1984, 814, 809, 1967, 1985, 815
3236, 809, 1967, 1985, 815, 810, 1968, 1986, 816
3237, 810, 1968, 1986, 816, 175, 901, 904, 176
3238, 775, 776, 779, 778, 1963, 1969, 1987, 1981
3239, 1963, 1969, 1987, 1981, 1964, 1970, 1988, 1982
3240, 1964, 1970, 1988, 1982, 1965, 1971, 1989, 1983
3241, 1965, 1971, 1989, 1983, 1966, 1972, 1990, 1984
3242, 1966, 1972, 1990, 1984, 1967, 1973, 1991, 1985
3243, 1967, 1973, 1991, 1985, 1968, 1974, 1992, 1986
3244, 1968, 1974, 1992, 1986, 901, 902, 905, 904
3245, 776, 777, 780, 779, 1969, 1975, 1993, 1987
3246, 1969, 1975, 1993, 1987, 1970, 1976, 1994, 1988
3247, 1970, 1976, 1994, 1988, 1971, 1977, 1995, 1989
3248, 1971, 1977, 1995, 1989, 1972, 1978, 1996, 1990
3249, 1972, 1978, 1996, 1990, 1973, 1979, 1997, 1991
3250, 1973, 1979, 1997, 1991, 1974, 1980, 1998, 1992
3251, 1974, 1980, 1998, 1992, 902, 903, 906, 905
3252, 777, 154, 155, 780, 1975, 859, 865, 1993
3253, 1975, 859, 865, 1993, 1976, 860, 866, 1994
3254, 1976, 860, 866, 1994, 1977, 861, 867, 1995
3255, 1977, 861, 867, 1995, 1978, 862, 868, 1996
3256, 1978, 862, 868, 1996, 1979, 863, 869, 1997
3257, 1979, 863, 869, 1997, 1980, 864, 870, 1998
3258, 1980, 864, 870, 1998, 903, 196, 197, 906
3259, 146, 778, 147, 9, 811, 1981, 817, 159
3260, 811, 1981, 817, 159, 812, 1982, 818, 160
3261, 812, 1982, 818, 160, 813, 1983, 819, 161
3262, 813, 1983, 819, 161, 814, 1984, 820, 162
3263, 814, 1984, 820, 162, 815, 1985, 821, 163
3264, 815, 1985, 821, 163, 816, 1986, 822, 164
3265, 816, 1986, 822, 164, 176, 904, 183, 13
3266, 778, 779, 148, 147, 1981, 1987, 823, 817
3267, 1981, 1987, 823, 817, 1982, 1988, 824, 818
3268, 1982, 1988, 824, 818, 1983, 1989, 825, 819
3269, 1983, 1989, 825, 819, 1984, 1990, 826, 820
3270, 1984, 1990, 826, 820, 1985, 1991, 827, 821
3271, 1985, 1991, 827, 821, 1986, 1992, 828, 822
3272, 1986, 1992, 828, 822, 904, 905, 184, 183
3273, 779, 780, 149, 148, 1987, 1993, 829, 823
3274, 1987, 1993, 829, 823, 1988, 1994, 830, 824
3275, 1988, 1994, 830, 824, 1989, 1995, 831, 825
3276, 1989, 1995, 831, 825, 1990, 1996, 832, 826
3277, 1990, 1996, 832, 826, 1991, 1997, 833, 827
3278, 1991, 1997, 833, 827, 1992, 1998, 834, 828
3279, 1992, 1998, 834, 828, 905, 906, 185, 184
3280, 780, 155, 11, 149, 1993, 865, 177, 829
3281, 1993, 865, 177, 829, 1994, 866, 178, 830
3282, 1994, 866, 178, 830, 1995, 867, 179, 831
3283, 1995, 867, 179, 831, 1996, 868, 180, 832
3284, 1996, 868, 180, 832, 1997, 869, 181, 833
3285, 1997, 869, 181, 833, 1998, 870, 182, 834
3286, 1998, 870, 182, 834, 906, 197, 15, 185
*ELEMENT, type=C3D8, ELSET=Volume4
3287, 14, 198, 889, 171, 18, 216, 907, 201
3288, 198, 199, 890, 889, 216, 217, 908, 907
3289, 199, 200, 891, 890, 217, 218, 909, 908
3290, 200, 16, 192, 891, 218, 20, 210, 909
3291, 171, 889, 892, 172, 201, 907, 910, 202
3292, 889, 890, 893, 892, 907, 908, 911, 910
3293, 890, 891, 894, 893, 908, 909, 912, 911
3294, 891, 192, 193, 894, 909, 210, 211, 912
3295, 172, 892, 895, 173, 202, 910, 913, 203
3296, 892, 893, 896, 895, 910, 911, 914, 913
3297, 893, 894, 897, 896, 911, 912, 915, 914
3298, 894, 193, 194, 897, 912, 211, 212, 915
3299, 173, 895, 898, 174, 203, 913, 916, 204
3300, 895, 896, 899, 898, 913, 914, 917, 916
3301, 896, 897, 900, 899, 914, 915, 918, 917
3302, 897, 194, 195, 900, 915, 212, 213, 918
3303, 174, 898, 901, 175, 204, 916, 919, 205
3304, 898, 899, 902, 901, 916, 917, 920, 919
3305, 899, 900, 903, 902, 917, 918, 921, 920
3306, 900, 195, 196, 903, 918, 213, 214, 921
3307, 175, 901, 904, 176, 205, 919, 922, 206
3308, 901, 902, 905, 904, 919, 920, 923, 922
3309, 902, 903, 906, 905, 920, 921, 924, 923
3310, 903, 196, 197, 906, 921, 214, 215, 924
3311, 176, 904, 183, 13, 206, 922, 207, 17
3312, 904, 905, 184, 183, 922, 923, 208, 207
3313, 905, 906, 185, 184, 923, 924, 209, 208
3314, 906, 197, 15, 185, 924, 215, 19, 209
*ELEMENT, type=C3D8, ELSET=Volume5
3315, 18, 216, 907, 201, 221, 955, 1999, 925
3316, 221, 955, 1999, 925, 222, 956, 2000, 926
3317, 222, 956, 2000, 926, 22, 242, 961, 223
3318, 216, 217, 908, 907, 955, 957, 2001, 1999
3319, 955, 957, 2001, 1999, 956, 958, 2002, 2000
3320, 956, 958, 2002, 2000, 242, 243, 962, 961
3321, 217, 218, 909, 908, 957, 959, 2003, 2001
3322, 957, 959, 2003, 2001, 958, 960, 2004, 2002
3323, 958, 960, 2004, 2002, 243, 244, 963, 962
3324, 218, 20, 210, 909, 959, 234, 943, 2003
3325, 959, 234, 943, 2003, 960, 235, 944, 2004
3326, 960, 235, 944, 2004, 244, 24, 236, 963
3327, 201, 907, 910, 202, 925, 1999, 2005, 927
3328, 925, 1999, 2005, 927, 926, 2000, 2006, 928
3329, 926, 2000, 2006, 928, 223, 961, 964, 224
3330, 907, 908, 911, 910, 1999, 2001, 2007, 2005
3331, 1999, 2001, 2007, 2005, 2000, 2002, 2008, 2006
3332, 2000, 2002, 2008, 2006, 961, 962, 965, 964
3333, 908, 909, 912, 911, 2001, 2003, 2009, 2007
3334, 2001, 2003, 2009, 2007, 2002, 2004, 2010, 2008
3335, 2002, 2004, 2010, 2008, 962, 963, 966, 965
3336, 909, 210, 211, 912, 2003, 943, 945, 2009
3337, 2003, 943, 945, 2009, 2004, 944, 946, 2010
3338, 2004, 944, 946, 2010, 963, 236, 237, 966
3339, 202, 910, 913, 203, 927, 2005, 2011, 929
3340, 927, 2005, 2011, 929, 928, 2006, 2012, 930
3341, 928, 2006, 2012, 930, 224, 964, 967, 225
3342, 910, 911, 914, 913, 2005, 2007, 2013, 2011
3343, 2005, 2007, 2013, 2011, 2006, 2008, 2014, 2012
3344, 2006, 2008, 2014, 2012, 964, 965, 968, 967
3345, 911, 912, 915, 914, 2007, 2009, 2015, 2013
3346, 2007, 2009, 2015, 2013, 2008, 2010, 2016, 2014
3347, 2008, 2010, 2016, 2014, 965, 966, 969, 968
3348, 912, 211, 212, 915, 2009, 945, 947, 2015
3349, 2009, 945, 947, 2015, 2010, 946, 948, 2016
3350, 2010, 946, 948, 2016, 966, 237, 238, 969
3351, 203, 913, 916, 204, 929, 2011, 2017, 931
3352, 929, 2011, 2017, 931, 930, 2012, 2018, 932
3353, 930, 2012, 2018, 932, 225, 967, 970, 226
3354, 913, 914, 917, 916, 2011, 2013, 2019, 2017
3355, 2011, 2013, 2019, 2017, 2012, 2014, 2020, 2018
3356, 2012, 2014, 2020, 2018, 967, 968, 971, 970
3357, 914, 915, 918, 917, 2013, 2015, 2021, 2019
3358, 2013, 2015, 2021, 2019, 2014, 2016, 2022, 2020
3359, 2014, 2016, 2022, 2020, 968, 969, 972, 971
3360, 915, 212, 213, 918, 2015, 947, 949, 2021
3361, 2015, 947, 949, 2021, 2016, 948, 950, 2022
3362, 2016, 948, 950, 2022, 969, 238, 239, 972
3363, 204, 916, 919, 205, 931, 2017, 2023, 933
3364, 931, 2017, 2023, 933, 932, 2018, 2024, 934
3365, 932, 2018, 2024, 934, 226, 970, 973, 227
3366, 916, 917, 920, 919, 2017, 2019, 2025, 2023
3367, 2017, 2019, 2025, 2023, 2018, 2020, 2026, 2024
3368, 2018, 2020, 2026, 2024, 970, 971, 974, 973
3369, 917, 918, 921, 920, 2019, 2021, 2027, 2025
3370, 2019, 2021, 2027, 2025, 2020, 2022, 2028, 2026
3371, 2020, 2022, 2028, 2026, 971, 972, 975, 974
3372, 918, 213, 214, 921, 2021, 949, 951, 2027
3373, 2021, 949, 951, 2027, 2022, 950, 952, 2028
3374, 2022, 950, 952, 2028, 972, 239, 240, 975
3375, 205, 919, 922, 206, 933, 2023, 2029, 935
3376, 933, 2023, 2029, 935, 934, 2024, 2030, 936
3377, 934, 2024, 2030, 936, 227, 973, 976, 228
3378, 919, 920, 923, 922, 2023, 2025, 2031, 2029
3379, 2023, 2025, 2031, 2029, 2024, 2026, 2032, 2030
3380, 2024, 2026, 2032, 2030, 973, 974, 977, 976
3381, 920, 921, 924, 923, 2025, 2027, 2033, 2031
3382, 2025, 2027, 2033, 2031, 2026, 2028, 2034, 2032
3383, 2026, 2028, 2034, 2032, 974, 975, 978, 977
3384, 921, 214, 215, 924, 2027, 951, 953, 2033
3385, 2027, 951, 953, 2033, 2028, 952, 954, 2034
3386, 2028, 952, 954, 2034, 975, 240, 241, 978
3387, 206, 922, 207, 17, 935, 2029, 937, 219
3388, 935, 2029, 937, 219, 936, 2030, 938, 220
3389, 936, 2030, 938, 220, 228, 976, 231, 21
3390, 922, 923, 208, 207, 2029, 2031, 939, 937
3391, 2029, 2031, 939, 937, 2030, 2032, 940, 938
3392, 2030, 2032, 940, 938, 976, 977, 232, 231
3393, 923, 924, 209, 208, 2031, 2033, 941, 939
3394, 2031, 2033, 941, 939, 2032, 2034, 942, 940
3395, 2032, 2034, 942, 940, 977, 978, 233, 232
3396, 924, 215, 19, 209, 2033, 953, 229, 941
3397, 2033, 953, 229, 941, 2034, 954, 230, 942
3398, 2034, 954, 230, 942, 978, 241, 23, 233
*ELEMENT, type=C3D8, ELSET=Volume6
3399, 17, 219, 937, 207, 255, 987, 2035, 995
3400, 255, 987, 2035, 995, 256, 988, 2036, 996
3401, 256, 988, 2036, 996, 257, 989, 2037, 997
3402, 257, 989, 2037, 997, 258, 990, 2038, 998
3403, 258, 990, 2038, 998, 27, 263, 1019, 265
3404, 219, 220, 938, 937, 987, 991, 2039, 2035
3405, 987, 991, 2039, 2035, 988, 992, 2040, 2036
3406, 988, 992, 2040, 2036, 989, 993, 2041, 2037
3407, 989, 993, 2041, 2037, 990, 994, 2042, 2038
3408, 990, 994, 2042, 2038, 263, 264, 1020, 1019
3409, 220, 21, 231, 938, 991, 259, 1007, 2039
3410, 991, 259, 1007, 2039, 992, 260, 1008, 2040
3411, 992, 260, 1008, 2040, 993, 261, 1009, 2041
3412, 993, 261, 1009, 2041, 994, 262, 1010, 2042
3413, 994, 262, 1010, 2042, 264, 28, 268, 1020
3414, 207, 937, 939, 208, 995, 2035, 2043, 999
3415, 995, 2035, 2043, 999, 996, 2036, 2044, 1000
3416, 996, 2036, 2044, 1000, 997, 2037, 2045, 1001
3417, 997, 2037, 2045, 1001, 998, 2038, 2046, 1002
3418, 998, 2038, 2046, 1002, 265, 1019, 1021, 266
3419, 937, 938, 940, 939, 2035, 2039, 2047, 2043
3420, 2035, 2039, 2047, 2043, 2036, 2040, 2048, 2044
3421, 2036, 2040, 2048, 2044, 2037, 2041, 2049, 2045
3422, 2037, 2041, 2049, 2045, 2038, 2042, 2050, 2046
3423, 2038, 2042, 2050, 2046, 1019, 1020, 1022, 1021
3424, 938, 231, 232, 940, 2039, 1007, 1011, 2047
3425, 2039, 1007, 1011, 2047, 2040, 1008, 1012, 2048
3426, 2040, 1008, 1012, 2048, 2041, 1009, 1013, 2049
3427, 2041, 1009, 1013, 2049, 2042, 1010, 1014, 2050
3428, 2042, 1010, 1014, 2050, 1020, 268, 269, 1022
3429, 208, 939, 941, 209, 999, 2043, 2051, 1003
3430, 999, 2043, 2051, 1003, 1000, 2044, 2052, 1004
3431, 1000, 2044, 2052, 1004, 1001, 2045, 2053, 1005
3432, 1001, 2045, 2053, 1005, 1002, 2046, 2054, 1006
3433, 1002, 2046, 2054, 1006, 266, 1021, 1023, 267
3434, 939, 940, 942, 941, 2043, 2047, 2055, 2051
3435, 2043, 2047, 2055, 2051, 2044, 2048, 2056, 2052
3436, 2044, 2048, 2056, 2052, 2045, 2049, 2057, 2053
3437, 2045, 2049, 2057, 2053, 2046, 2050, 2058, 2054
3438, 2046, 2050, 2058, 2054, 1021, 1022, 1024, 1023
3439, 940, 232, 233, 942, 2047, 1011, 1015, 2055
3440, 2047, 1011, 1015, 2055, 2048, 1012, 1016, 2056
3441, 2048, 1012, 1016, 2056, 2049, 1013, 1017, 2057
3442, 2049, 1013, 1017, 2057, 2050, 1014, 1018, 2058
3443, 2050, 1014, 1018, 2058, 1022, 269, 270, 1024
3444, 209, 941, 229, 19, 1003, 2051, 979, 245
3445, 1003, 2051, 979, 245, 1004, 2052, 980, 246
3446, 1004, 2052, 980, 246, 1005, 2053, 981, 247
3447, 1005, 2053, 981, 247, 1006, 2054, 982, 248
3448, 1006, 2054, 982, 248, 267, 1023, 253, 25
3449, 941, 942, 230, 229, 2051, 2055, 983, 979
3450, 2051, 2055, 983, 979, 2052, 2056, 984, 980
3451, 2052, 2056, 984, 980, 2053, 2057, 985, 981
3452, 2053, 2057, 985, 981, 2054, 2058, 986, 982
3453, 2054, 2058, 986, 982, 1023, 1024, 254, 253
3454, 942, 233, 23, 230, 2055, 1015, 249, 983
3455, 2055, 1015, 249, 983, 2056, 1016, 250, 984
3456, 2056, 1016, 250, 984, 2057, 1017, 251, 985
3457, 2057, 1017, 251, 985, 2058, 1018, 252, 986
3458, 2058, 1018, 252, 986, 1024, 270, 26, 254
*ELEMENT, type=C3D8, ELSET=Volume7
3459, 27, 263, 1019, 265, 285, 1037, 2059, 1049
3460, 285, 1037, 2059, 1049, 286, 1038, 2060, 1050
3461, 286, 1038, 2060, 1050, 287, 1039, 2061, 1051
3462, 287, 1039, 2061, 1051, 288, 1040, 2062, 1052
3463, 288, 1040, 2062, 1052, 289, 1041, 2063, 1053
3464, 289, 1041, 2063, 1053, 290, 1042, 2064, 1054
3465, 290, 1042, 2064, 1054, 31, 297, 1085, 299
3466, 263, 264, 1020, 1019, 1037, 1043, 2065, 2059
3467, 1037, 1043, 2065, 2059, 1038, 1044, 2066, 2060
3468, 1038, 1044, 2066, 2060, 1039, 1045, 2067, 2061
3469, 1039, 1045, 2067, 2061, 1040, 1046, 2068, 2062
3470, 1040, 1046, 2068, 2062, 1041, 1047, 2069, 2063
3471, 1041, 1047, 2069, 2063, 1042, 1048, 2070, 2064
3472, 1042, 1048, 2070, 2064, 297, 298, 1086, 1085
3473, 264, 28, 268, 1020, 1043, 291, 1067, 2065
3474, 1043, 291, 1067, 2065, 1044, 292, 1068, 2066
3475, 1044, 292, 1068, 2066, 1045, 293, 1069, 2067
3476, 1045, 293, 1069, 2067, 1046, 294, 1070, 2068
3477, 1046, 294, 1070, 2068, 1047, 295, 1071, 2069
3478, 1047, 295, 1071, 2069, 1048, 296, 1072, 2070
3479, 1048, 296, 1072, 2070, 298, 32, 302, 1086
3480, 265, 1019, 1021, 266, 1049, 2059, 2071, 1055
3481, 1049, 2059, 2071, 1055, 1050, 2060, 2072, 1056
3482, 1050, 2060, 2072, 1056, 1051, 2061, 2073, 1057
3483, 1051, 2061, 2073, 1057, 1052, 2062, 2074, 1058
3484, 1052, 2062, 2074, 1058, 1053, 2063, 2075, 1059
3485, 1053, 2063, 2075, 1059, 1054, 2064, 2076, 1060
3486, 1054, 2064, 2076, 1060, 299, 1085, 1087, 300
3487, 1019, 1020, 1022, 1021, 2059, 2065, 2077, 2071
3488, 2059, 2065, 2077, 2071, 2060, 2066, 2078, 2072
3489, 2060, 2066, 2078, 2072, 2061, 2067, 2079, 2073
3490, 2061, 2067, 2079, 2073, 2062, 2068, 2080, 2074
3491, 2062, 2068, 2080, 2074, 2063, 2069, 2081, 2075
3492, 2063, 2069, 2081, 2075, 2064, 2070, 2082, 2076
3493, 2064, 2070, 2082, 2076, 1085, 1086, 1088, 1087
3494, 1020, 268, 269, 1022, 2065, 1067, 1073, 2077
3495, 2065, 1067, 1073, 2077, 2066, 1068, 1074, 2078
3496, 2066, 1068, 1074, 2078, 2067, 1069, 1075, 2079
3497, 2067, 1069, 1075, 2079, 2068, 1070, 1076, 2080
3498, 2068, 1070, 1076, 2080, 2069, 1071, 1077, 2081
3499, 2069, 1071, 1077, 2081, 2070, 1072, 1078, 2082
3500, 2070, 1072, 1078, 2082, 1086, 302, 303, 1088
3501, 266, 1021, 1023, 267, 1055, 2071, 2083, 1061
3502, 1055, 2071, 2083, 1061, 1056, 2072, 2084, 1062
3503, 1056, 2072, 2084, 1062, 1057, 2073, 2085, 1063
3504, 1057, 2073, 2085, 1063, 1058, 2074, 2086, 1064
3505, 1058, 2074, 2086, 1064, 1059, 2075, 2087, 1065
3506, 1059, 2075, 2087, 1065, 1060, 2076, 2088, 1066
3507, 1060, 2076, 2088, 1066, 300, 1087, 1089, 301
3508, 1021, 1022, 1024, 1023, 2071, 2077, 2089, 2083
3509, 2071, 2077, 2089, 2083, 2072, 2078, 2090, 2084
3510, 2072, 2078, 2090, 2084, 2073, 2079, 2091, 2085
3511, 2073, 2079, 2091, 2085, 2074, 2080, 2092, 2086
3512, 2074, 2080, 2092, 2086, 2075, 2081, 2093, 2087
3513, 2075, 2081, 2093, 2087, 2076, 2082, 2094, 2088
3514, 2076, 2082, 2094, 2088, 1087, 1088, 1090, 1089
3515, 1022, 269, 270, 1024, 2077, 1073, 1079, 2089
3516, 2077, 1073, 1079, 2089, 2078, 1074, 1080, 2090
3517, 2078, 1074, 1080, 2090, 2079, 1075, 1081, 2091
3518, 2079, 1075, 1081, 2091, 2080, 1076, 1082, 2092
3519, 2080, 1076, 1082, 2092, 2081, 1077, 1083, 2093
3520, 2081, 1077, 1083, 2093, 2082, 1078, 1084, 2094
3521, 2082, 1078, 1084, 2094, 1088, 303, 304, 1090
3522, 267, 1023, 253, 25, 1061, 2083, 1025, 271
3523, 1061, 2083, 1025, 271, 1062, 2084, 1026, 272
3524, 1062, 2084, 1026, 272, 1063, 2085, 1027, 273
3525, 1063, 2085, 1027, 273, 1064, 2086, 1028, 274
3526, 1064, 2086, 1028, 274, 1065, 2087, 1029, 275
3527, 1065, 2087, 1029, 275, 1066, 2088, 1030, 276
3528, 1066, 2088, 1030, 276, 301, 1089, 283, 29
3529, 1023, 1024, 254, 253, 2083, 2089, 1031, 1025
3530, 2083, 2089, 1031, 1025, 2084, 2090, 1032, 1026
3531, 2084, 2090, 1032, 1026, 2085, 2091, 1033, 1027
3532, 2085, 2091, 1033, 1027, 2086, 2092, 1034, 1028
3533, 2086, 2092, 1034, 1028, 2087, 2093, 1035, 1029
3534, 2087, 2093, 1035, 1029, 2088, 2094, 1036, 1030
3535, 2088, 2094, 1036, 1030, 1089, 1090, 284, 283
3536, 1024, 270, 26, 254, 2089, 1079, 277, 1031
3537, 2089, 1079, 277, 1031, 2090, 1080, 278, 1032
3538, 2090, 1080, 278, 1032, 2091, 1081, 279, 1033
3539, 2091, 1081, 279, 1033, 2092, 1082, 280, 1034
3540, 2092, 1082, 280, 1034, 2093, 1083, 281, 1035
3541, 2093, 1083, 281, 1035, 2094, 1084, 282, 1036
3542, 2094, 1084, 282, 1036, 1090, 304, 30, 284
*ELEMENT, type=C3D8, ELSET=Volume8
3543, 27, 285, 1049, 265, 35, 311, 1091, 317
3544, 285, 286, 1050, 1049, 311, 312, 1092, 1091
3545, 286, 287, 1051, 1050, 312, 313, 1093, 1092
3546, 287, 288, 1052, 1051, 313, 314, 1094, 1093
3547, 288, 289, 1053, 1052, 314, 315, 1095, 1094
3548, 289, 290, 1054, 1053, 315, 316, 1096, 1095
3549, 290, 31, 299, 1054, 316, 36, 320, 1096
3550, 265, 1049, 1055, 266, 317, 1091, 1097, 318
3551, 1049, 1050, 1056, 1055, 1091, 1092, 1098, 1097
3552, 1050, 1051, 1057, 1056, 1092, 1093, 1099, 1098
3553, 1051, 1052, 1058, 1057, 1093, 1094, 1100, 1099
3554, 1052, 1053, 1059, 1058, 1094, 1095, 1101, 1100
3555, 1053, 1054, 1060, 1059, 1095, 1096, 1102, 1101
3556, 1054, 299, 300, 1060, 1096, 320, 321, 1102
3557, 266, 1055, 1061, 267, 318, 1097, 1103, 319
3558, 1055, 1056, 1062, 1061, 1097, 1098, 1104, 1103
3559, 1056, 1057, 1063, 1062, 1098, 1099, 1105, 1104
3560, 1057, 1058, 1064, 1063, 1099, 1100, 1106, 1105
3561, 1058, 1059, 1065, 1064, 1100, 1101, 1107, 1106
3562, 1059, 1060, 1066, 1065, 1101, 1102, 1108, 1107
3563, 1060, 300, 301, 1066, 1102, 321, 322, 1108
3564, 267, 1061, 271, 25, 319, 1103, 305, 33
3565, 1061, 1062, 272, 271, 1103, 1104, 306, 305
3566, 1062, 1063, 273, 272, 1104, 1105, 307, 306
3567, 1063, 1064, 274, 273, 1105, 1106, 308, 307
3568, 1064, 1065, 275, 274, 1106, 1107, 309, 308
3569, 1065, 1066, 276, 275, 1107, 1108, 310, 309
3570, 1066, 301, 29, 276, 1108, 322, 34, 310
*ELEMENT, type=C3D8, ELSET=Volume9
3571, 35, 311, 1091, 317, 341, 1145, 2095, 1181
3572, 341, 1145, 2095, 1181, 342, 1146, 2096, 1182
3573, 342, 1146, 2096, 1182, 343, 1147, 2097, 1183
3574, 343, 1147, 2097, 1183, 344, 1148, 2098, 1184
3575, 344, 1148, 2098, 1184, 345, 1149, 2099, 1185
3576, 345, 1149, 2099, 1185, 346, 1150, 2100, 1186
3577, 346, 1150, 2100, 1186, 39, 353, 1217, 359
3578, 311, 312, 1092, 1091, 1145, 1151, 2101, 2095
3579, 1145, 1151, 2101, 2095, 1146, 1152, 2102, 2096
3580, 1146, 1152, 2102, 2096, 1147, 1153, 2103, 2097
3581, 1147, 1153, 2103, 2097, 1148, 1154, 2104, 2098
3582, 1148, 1154, 2104, 2098, 1149, 1155, 2105, 2099
3583, 1149, 1155, 2105, 2099, 1150, 1156, 2106, 2100
3584, 1150, 1156, 2106, 2100, 353, 354, 1218, 1217
3585, 312, 313, 1093, 1092, 1151, 1157, 2107, 2101
3586, 1151, 1157, 2107, 2101, 1152, 1158, 2108, 2102
3587, 1152, 1158, 2108, 2102, 1153, 1159, 2109, 2103
3588, 1153, 1159, 2109, 2103, 1154, 1160, 2110, 2104
3589, 1154, 1160, 2110, 2104, 1155, 1161, 2111, 2105
3590, 1155, 1161, 2111, 2105, 1156, 1162, 2112, 2106
3591, 1156, 1162, 2112, 2106, 354, 355, 1219, 1218
3592, 313, 314, 1094, 1093, 1157, 1163, 2113, 2107
3593, 1157, 1163, 2113, 2107, 1158, 1164, 2114, 2108
3594, 1158, 1164, 2114, 2108, 1159, 1165, 2115, 2109
3595, 1159, 1165, 2115, 2109, 1160, 1166, 2116, 2110
3596, 1160, 1166, 2116, 2110, 1161, 1167, 2117, 2111
3597, 1161, 1167, 2117, 2111, 1162, 1168, 2118, 2112
3598, 1162, 1168, 2118, 2112, 355, 356, 1220, 1219
3599, 314, 315, 1095, 1094, 1163, 1169, 2119, 2113
3600, 1163, 1169, 2119, 2113, 1164, 1170, 2120, 2114
3601, 1164, 1170, 2120, 2114, 1165, 1171, 2121, 2115
3602, 1165, 1171, 2121, 2115, 1166, 1172, 2122, 2116
3603, 1166, 1172, 2122, 2116, 1167, 1173, 2123, 2117
3604, 1167, 1173, 2123, 2117, 1168, 1174, 2124, 2118
3605, 1168, 1174, 2124, 2118, 356, 357, 1221, 1220
3606, 315, 316, 1096, 1095, 1169, 1175, 2125, 2119
3607, 1169, 1175, 2125, 2119, 1170, 1176, 2126, 2120
3608, 1170, 1176, 2126, 2120, 1171, 1177, 2127, 2121
3609, 1171, 1177, 2127, 2121, 1172, 1178, 2128, 2122
3610, 1172, 1178, 2128, 2122, 1173, 1179, 2129, 2123
3611, 1173, 1179, 2129, 2123, 1174, 1180, 2130, 2124
3612, 1174, 1180, 2130, 2124, 357, 358, 1222, 1221
3613, 316, 36, 320, 1096, 1175, 347, 1199, 2125
3614, 1175, 347, 1199, 2125, 1176, 348, 1200, 2126
3615, 1176, 348, 1200, 2126, 1177, 349, 1201, 2127
3616, 1177, 349, 1201, 2127, 1178, 350, 1202, 2128
3617, 1178, 350, 1202, 2128, 1179, 351, 1203, 2129
3618, 1179, 351, 1203, 2129, 1180, 352, 1204, 2130
3619, 1180, 352, 1204, 2130, 358, 40, 362, 1222
3620, 317, 1091, 1097, 318, 1181, 2095, 2131, 1187
3621, 1181, 2095, 2131, 1187, 1182, 2096, 2132, 1188
3622, 1182, 2096, 2132, 1188, 1183, 2097, 2133, 1189
3623, 1183, 2097, 2133, 1189, 1184, 2098, 2134, 1190
3624, 1184, 2098, 2134, 1190, 1185, 2099, 2135, 1191
3625, 1185, 2099, 2135, 1191, 1186, 2100, 2136, 1192
3626, 1186, 2100, 2136, 1192, 359, 1217, 1223, 360
3627, 1091, 1092, 1098, 1097, 2095, 2101, 2137, 2131
3628, 2095, 2101, 2137, 2131, 2096, 2102, 2138, 2132
3629, 2096, 2102, 2138, 2132, 2097, 2103, 2139, 2133
3630, 2097, 2103, 2139, 2133, 2098, 2104, 2140, 2134
3631, 2098, 2104, 2140, 2134, 2099, 2105, 2141, 2135
3632, 2099, 2105, 2141, 2135, 2100, 2106, 2142, 2136
3633, 2100, 2106, 2142, 2136, 1217, 1218, 1224, 1223
3634, 1092, 1093, 1099, 1098, 2101, 2107, 2143, 2137
3635, 2101, 2107, 2143, 2137, 2102, 2108, 2144, 2138
3636, 2102, 2108, 2144, 2138, 2103, 2109, 2145, 2139
3637, 2103, 2109, 2145, 2139, 2104, 2110, 2146, 2140
3638, 2104, 2110, 2146, 2140, 2105, 2111, 2147, 2141
3639, 2105, 2111, 2147, 2141, 2106, 2112, 2148, 2142
3640, 2106, 2112, 2148, 2142, 1218, 1219, 1225, 1224
3641, 1093, 1094, 1100, 1099, 2107, 2113, 2149, 2143
3642, 2107, 2113, 2149, 2143, 2108, 2114, 2150, 2144
3643, 2108, 2114, 2150, 2144, 2109, 2115, 2151, 2145
3644, 2109, 2115, 2151, 2145, 2110, 2116, 2152, 2146
3645, 2110, 2116, 2152, 2146, 2111, 2117, 2153, 2147
3646, 2111, 2117, 2153, 2147, 2112, 2118, 2154, 2148
3647, 2112, 2118, 2154, 2148, 1219, 1220, 1226, 1225
3648, 1094, 1095, 1101, 1100, 2113, 2119, 2155, 2149
3649, 2113, 2119, 2155, 2149, 2114, 2120, 2156, 2150
3650, 2114, 2120, 2156, 2150, 2115, 2121, 2157, 2151
3651, 2115, 2121, 2157, 2151, 2116, 2122, 2158, 2152
3652, 2116, 2122, 2158, 2152, 2117, 2123, 2159, 2153
3653, 2117, 2123, 2159, 2153, 2118, 2124, 2160, 2154
3654, 2118, 2124, 2160, 2154, 1220, 1221, 1227, 1226
3655, 1095, 1096, 1102, 1101, 2119, 2125, 2161, 2155
3656, 2119, 2125, 2161, 2155, 2120, 2126, 2162, 2156
3657, 2120, 2126, 2162, 2156, 2121, 2127, 2163, 2157
3658, 2121, 2127, 2163, 2157, 2122, 2128, 2164, 2158
3659, 2122, 2128, 2164, 2158, 2123, 2129, 2165, 2159
3660, 2123, 2129, 2165, 2159, 2124, 2130, 2166, 2160
3661, 2124, 2130, 2166, 2160, 1221, 1222, 1228, 1227
3662, 1096, 320, 321, 1102, 2125, 1199, 1205, 2161
3663, 2125, 1199, 1205, 2161, 2126, 1200, 1206, 2162
3664, 2126, 1200, 1206, 2162, 2127, 1201, 1207, 2163
3665, 2127, 1201, 1207, 2163, 2128, 1202, 1208, 2164
3666, 2128, 1202, 1208, 2164, 2129, 1203, 1209, 2165
3667, 2129, 1203, 1209, 2165, 2130, 1204, 1210, 2166
3668, 2130, 1204, 1210, 2166, 1222, 362, 363, 1228
3669, 318, 1097, 1103, 319, 1187, 2131, 2167, 1193
3670, 1187, 2131, 2167, 1193, 1188, 2132, 2168, 1194
3671, 1188, 2132, 2168, 1194, 1189, 2133, 2169, 1195
3672, 1189, 2133, 2169, 1195, 1190, 2134, 2170, 1196
3673, 1190, 2134, 2170, 1196, 1191, 2135, 2171, 1197
3674, 1191, 2135, 2171, 1197, 1192, 2136, 2172, 1198
3675, 1192, 2136, 2172, 1198, 360, 1223, 1229, 361
3676, 1097, 1098, 1104, 1103, 2131, 2137, 2173, 2167
3677, 2131, 2137, 2173, 2167, 2132, 2138, 2174, 2168
3678, 2132, 2138, 2174, 2168, 2133, 2139, 2175, 2169
3679, 2133, 2139, 2175, 2169, 2134, 2140, 2176, 2170
3680, 2134, 2140, 2176, 2170, 2135, 2141, 2177, 2171
