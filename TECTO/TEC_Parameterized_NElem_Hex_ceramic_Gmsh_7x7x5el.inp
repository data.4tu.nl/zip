*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Hex_ceramic_Gmsh_7x7x5el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 1, 1.6, 0
78, 0, 1.6, 0
79, 1, 1.6, 0.5
80, 0, 1.6, 0.5
81, 1.2, 1.6, 0.5
82, 1.2, 1.6, 0
83, 2.2, 1.6, 0.5
84, 2.2, 1.6, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.125
98, 0, 0, 0.25
99, 0, 0, 0.375
100, 0, 0.016666666666667, 0.5
101, 0, 0.033333333333333, 0.5
102, 0, 0.05, 0.125
103, 0, 0.05, 0.25
104, 0, 0.05, 0.375
105, 0, 0.016666666666667, 0
106, 0, 0.033333333333333, 0
107, 1, 0, 0.125
108, 1, 0, 0.25
109, 1, 0, 0.375
110, 1, 0.016666666666667, 0.5
111, 1, 0.033333333333333, 0.5
112, 1, 0.05, 0.125
113, 1, 0.05, 0.25
114, 1, 0.05, 0.375
115, 1, 0.016666666666667, 0
116, 1, 0.033333333333333, 0
117, 0.14285714285714, 0, 0
118, 0.28571428571429, 0, 0
119, 0.42857142857143, 0, 0
120, 0.57142857142857, 0, 0
121, 0.71428571428571, 0, 0
122, 0.85714285714286, 0, 0
123, 0.14285714285714, 0, 0.5
124, 0.28571428571429, 0, 0.5
125, 0.42857142857143, 0, 0.5
126, 0.57142857142857, 0, 0.5
127, 0.71428571428571, 0, 0.5
128, 0.85714285714286, 0, 0.5
129, 0.14285714285714, 0.05, 0
130, 0.28571428571429, 0.05, 0
131, 0.42857142857143, 0.05, 0
132, 0.57142857142857, 0.05, 0
133, 0.71428571428571, 0.05, 0
134, 0.85714285714286, 0.05, 0
135, 0.14285714285714, 0.05, 0.5
136, 0.28571428571429, 0.05, 0.5
137, 0.42857142857143, 0.05, 0.5
138, 0.57142857142857, 0.05, 0.5
139, 0.71428571428571, 0.05, 0.5
140, 0.85714285714286, 0.05, 0.5
141, 0.14285714285714, 0.1, 0
142, 0.28571428571429, 0.1, 0
143, 0.42857142857143, 0.1, 0
144, 0.57142857142857, 0.1, 0
145, 0.71428571428571, 0.1, 0
146, 0.85714285714286, 0.1, 0
147, 1, 0.1, 0.125
148, 1, 0.1, 0.25
149, 1, 0.1, 0.375
150, 0.14285714285714, 0.1, 0.5
151, 0.28571428571429, 0.1, 0.5
152, 0.42857142857143, 0.1, 0.5
153, 0.57142857142857, 0.1, 0.5
154, 0.71428571428571, 0.1, 0.5
155, 0.85714285714286, 0.1, 0.5
156, 0, 0.1, 0.125
157, 0, 0.1, 0.25
158, 0, 0.1, 0.375
159, 1, 0.27142857142857, 0
160, 1, 0.44285714285714, 0
161, 1, 0.61428571428571, 0
162, 1, 0.78571428571429, 0
163, 1, 0.95714285714286, 0
164, 1, 1.1285714285714, 0
165, 0, 0.27142857142857, 0
166, 0, 0.44285714285714, 0
167, 0, 0.61428571428571, 0
168, 0, 0.78571428571429, 0
169, 0, 0.95714285714286, 0
170, 0, 1.1285714285714, 0
171, 0.14285714285714, 1.3, 0
172, 0.28571428571429, 1.3, 0
173, 0.42857142857143, 1.3, 0
174, 0.57142857142857, 1.3, 0
175, 0.71428571428571, 1.3, 0
176, 0.85714285714286, 1.3, 0
177, 1, 0.27142857142857, 0.5
178, 1, 0.44285714285714, 0.5
179, 1, 0.61428571428571, 0.5
180, 1, 0.78571428571429, 0.5
181, 1, 0.95714285714286, 0.5
182, 1, 1.1285714285714, 0.5
183, 1, 1.3, 0.125
184, 1, 1.3, 0.25
185, 1, 1.3, 0.375
186, 0, 0.27142857142857, 0.5
187, 0, 0.44285714285714, 0.5
188, 0, 0.61428571428571, 0.5
189, 0, 0.78571428571429, 0.5
190, 0, 0.95714285714286, 0.5
191, 0, 1.1285714285714, 0.5
192, 0.14285714285714, 1.3, 0.5
193, 0.28571428571429, 1.3, 0.5
194, 0.42857142857143, 1.3, 0.5
195, 0.57142857142857, 1.3, 0.5
196, 0.71428571428571, 1.3, 0.5
197, 0.85714285714286, 1.3, 0.5
198, 0, 1.3, 0.125
199, 0, 1.3, 0.25
200, 0, 1.3, 0.375
201, 0.14285714285714, 1.35, 0
202, 0.28571428571429, 1.35, 0
203, 0.42857142857143, 1.35, 0
204, 0.57142857142857, 1.35, 0
205, 0.71428571428571, 1.35, 0
206, 0.85714285714286, 1.35, 0
207, 1, 1.35, 0.125
208, 1, 1.35, 0.25
209, 1, 1.35, 0.375
210, 0.14285714285714, 1.35, 0.5
211, 0.28571428571429, 1.35, 0.5
212, 0.42857142857143, 1.35, 0.5
213, 0.57142857142857, 1.35, 0.5
214, 0.71428571428571, 1.35, 0.5
215, 0.85714285714286, 1.35, 0.5
216, 0, 1.35, 0.125
217, 0, 1.35, 0.25
218, 0, 1.35, 0.375
219, 1, 1.3666666666667, 0
220, 1, 1.3833333333333, 0
221, 0, 1.3666666666667, 0
222, 0, 1.3833333333333, 0
223, 0.14285714285714, 1.4, 0
224, 0.28571428571429, 1.4, 0
225, 0.42857142857143, 1.4, 0
226, 0.57142857142857, 1.4, 0
227, 0.71428571428571, 1.4, 0
228, 0.85714285714286, 1.4, 0
229, 1, 1.3666666666667, 0.5
230, 1, 1.3833333333333, 0.5
231, 1, 1.4, 0.125
232, 1, 1.4, 0.25
233, 1, 1.4, 0.375
234, 0, 1.3666666666667, 0.5
235, 0, 1.3833333333333, 0.5
236, 0.14285714285714, 1.4, 0.5
237, 0.28571428571429, 1.4, 0.5
238, 0.42857142857143, 1.4, 0.5
239, 0.57142857142857, 1.4, 0.5
240, 0.71428571428571, 1.4, 0.5
241, 0.85714285714286, 1.4, 0.5
242, 0, 1.4, 0.125
243, 0, 1.4, 0.25
244, 0, 1.4, 0.375
245, 1.04, 1.35, 0.5
246, 1.08, 1.35, 0.5
247, 1.12, 1.35, 0.5
248, 1.16, 1.35, 0.5
249, 1.04, 1.4, 0.5
250, 1.08, 1.4, 0.5
251, 1.12, 1.4, 0.5
252, 1.16, 1.4, 0.5
253, 1.2, 1.3666666666667, 0.5
254, 1.2, 1.3833333333333, 0.5
255, 1.04, 1.35, 0
256, 1.08, 1.35, 0
257, 1.12, 1.35, 0
258, 1.16, 1.35, 0
259, 1.04, 1.4, 0
260, 1.08, 1.4, 0
261, 1.12, 1.4, 0
262, 1.16, 1.4, 0
263, 1.2, 1.3666666666667, 0
264, 1.2, 1.3833333333333, 0
265, 1.2, 1.35, 0.125
266, 1.2, 1.35, 0.25
267, 1.2, 1.35, 0.375
268, 1.2, 1.4, 0.125
269, 1.2, 1.4, 0.25
270, 1.2, 1.4, 0.375
271, 1.3428571428571, 1.35, 0.5
272, 1.4857142857143, 1.35, 0.5
273, 1.6285714285714, 1.35, 0.5
274, 1.7714285714286, 1.35, 0.5
275, 1.9142857142857, 1.35, 0.5
276, 2.0571428571429, 1.35, 0.5
277, 1.3428571428571, 1.4, 0.5
278, 1.4857142857143, 1.4, 0.5
279, 1.6285714285714, 1.4, 0.5
280, 1.7714285714286, 1.4, 0.5
281, 1.9142857142857, 1.4, 0.5
282, 2.0571428571429, 1.4, 0.5
283, 2.2, 1.3666666666667, 0.5
284, 2.2, 1.3833333333333, 0.5
285, 1.3428571428571, 1.35, 0
286, 1.4857142857143, 1.35, 0
287, 1.6285714285714, 1.35, 0
288, 1.7714285714286, 1.35, 0
289, 1.9142857142857, 1.35, 0
290, 2.0571428571429, 1.35, 0
291, 1.3428571428571, 1.4, 0
292, 1.4857142857143, 1.4, 0
293, 1.6285714285714, 1.4, 0
294, 1.7714285714286, 1.4, 0
295, 1.9142857142857, 1.4, 0
296, 2.0571428571429, 1.4, 0
297, 2.2, 1.3666666666667, 0
298, 2.2, 1.3833333333333, 0
299, 2.2, 1.35, 0.125
300, 2.2, 1.35, 0.25
301, 2.2, 1.35, 0.375
302, 2.2, 1.4, 0.125
303, 2.2, 1.4, 0.25
304, 2.2, 1.4, 0.375
305, 1.3428571428571, 1.3, 0.5
306, 1.4857142857143, 1.3, 0.5
307, 1.6285714285714, 1.3, 0.5
308, 1.7714285714286, 1.3, 0.5
309, 1.9142857142857, 1.3, 0.5
310, 2.0571428571429, 1.3, 0.5
311, 1.3428571428571, 1.3, 0
312, 1.4857142857143, 1.3, 0
313, 1.6285714285714, 1.3, 0
314, 1.7714285714286, 1.3, 0
315, 1.9142857142857, 1.3, 0
316, 2.0571428571429, 1.3, 0
317, 1.2, 1.3, 0.125
318, 1.2, 1.3, 0.25
319, 1.2, 1.3, 0.375
320, 2.2, 1.3, 0.125
321, 2.2, 1.3, 0.25
322, 2.2, 1.3, 0.375
323, 1.2, 1.1285714285714, 0.5
324, 1.2, 0.95714285714286, 0.5
325, 1.2, 0.78571428571429, 0.5
326, 1.2, 0.61428571428571, 0.5
327, 1.2, 0.44285714285714, 0.5
328, 1.2, 0.27142857142857, 0.5
329, 2.2, 1.1285714285714, 0.5
330, 2.2, 0.95714285714286, 0.5
331, 2.2, 0.78571428571429, 0.5
332, 2.2, 0.61428571428571, 0.5
333, 2.2, 0.44285714285714, 0.5
334, 2.2, 0.27142857142857, 0.5
335, 1.3428571428571, 0.1, 0.5
336, 1.4857142857143, 0.1, 0.5
337, 1.6285714285714, 0.1, 0.5
338, 1.7714285714286, 0.1, 0.5
339, 1.9142857142857, 0.1, 0.5
340, 2.0571428571429, 0.1, 0.5
341, 1.2, 1.1285714285714, 0
342, 1.2, 0.95714285714286, 0
343, 1.2, 0.78571428571429, 0
344, 1.2, 0.61428571428571, 0
345, 1.2, 0.44285714285714, 0
346, 1.2, 0.27142857142857, 0
347, 2.2, 1.1285714285714, 0
348, 2.2, 0.95714285714286, 0
349, 2.2, 0.78571428571429, 0
350, 2.2, 0.61428571428571, 0
351, 2.2, 0.44285714285714, 0
352, 2.2, 0.27142857142857, 0
353, 1.3428571428571, 0.1, 0
354, 1.4857142857143, 0.1, 0
355, 1.6285714285714, 0.1, 0
356, 1.7714285714286, 0.1, 0
357, 1.9142857142857, 0.1, 0
358, 2.0571428571429, 0.1, 0
359, 1.2, 0.1, 0.125
360, 1.2, 0.1, 0.25
361, 1.2, 0.1, 0.375
362, 2.2, 0.1, 0.125
363, 2.2, 0.1, 0.25
364, 2.2, 0.1, 0.375
365, 1.3428571428571, 0.05, 0.5
366, 1.4857142857143, 0.05, 0.5
367, 1.6285714285714, 0.05, 0.5
368, 1.7714285714286, 0.05, 0.5
369, 1.9142857142857, 0.05, 0.5
370, 2.0571428571429, 0.05, 0.5
371, 1.3428571428571, 0.05, 0
372, 1.4857142857143, 0.05, 0
373, 1.6285714285714, 0.05, 0
374, 1.7714285714286, 0.05, 0
375, 1.9142857142857, 0.05, 0
376, 2.0571428571429, 0.05, 0
377, 1.2, 0.05, 0.125
378, 1.2, 0.05, 0.25
379, 1.2, 0.05, 0.375
380, 2.2, 0.05, 0.125
381, 2.2, 0.05, 0.25
382, 2.2, 0.05, 0.375
383, 1.2, 0.033333333333333, 0.5
384, 1.2, 0.016666666666667, 0.5
385, 2.2, 0.033333333333333, 0.5
386, 2.2, 0.016666666666667, 0.5
387, 1.3428571428571, 8.3266726846887e-17, 0.5
388, 1.4857142857143, 8.3266726846887e-17, 0.5
389, 1.6285714285714, 8.3266726846887e-17, 0.5
390, 1.7714285714286, 8.3266726846887e-17, 0.5
391, 1.9142857142857, 8.3266726846887e-17, 0.5
392, 2.0571428571429, 8.3266726846887e-17, 0.5
393, 1.2, 0.033333333333333, 0
394, 1.2, 0.016666666666667, 0
395, 2.2, 0.033333333333333, 0
396, 2.2, 0.016666666666667, 0
397, 1.3428571428571, 8.3266726846887e-17, 0
398, 1.4857142857143, 8.3266726846887e-17, 0
399, 1.6285714285714, 8.3266726846887e-17, 0
400, 1.7714285714286, 8.3266726846887e-17, 0
401, 1.9142857142857, 8.3266726846887e-17, 0
402, 2.0571428571429, 8.3266726846887e-17, 0
403, 1.2, 8.3266726846887e-17, 0.125
404, 1.2, 8.3266726846887e-17, 0.25
405, 1.2, 8.3266726846887e-17, 0.375
406, 2.2, 8.3266726846887e-17, 0.125
407, 2.2, 8.3266726846887e-17, 0.25
408, 2.2, 8.3266726846887e-17, 0.375
409, 2.3, 0.033333333333333, 0.5
410, 2.3, 0.016666666666667, 0.5
411, 2.3, 0.033333333333333, 0
412, 2.3, 0.016666666666667, 0
413, 2.3, 0.05, 0.125
414, 2.3, 0.05, 0.25
415, 2.3, 0.05, 0.375
416, 2.3, 8.3266726846887e-17, 0.125
417, 2.3, 8.3266726846887e-17, 0.25
418, 2.3, 8.3266726846887e-17, 0.375
419, -0.1, 0, 0.125
420, -0.1, 0, 0.25
421, -0.1, 0, 0.375
422, -0.1, 0.016666666666667, 0.5
423, -0.1, 0.033333333333333, 0.5
424, -0.1, 0.05, 0.125
425, -0.1, 0.05, 0.25
426, -0.1, 0.05, 0.375
427, -0.1, 0.016666666666667, 0
428, -0.1, 0.033333333333333, 0
429, 1.05, 0.27142857142857, 0.5
430, 1.05, 0.44285714285714, 0.5
431, 1.05, 0.61428571428571, 0.5
432, 1.05, 0.78571428571429, 0.5
433, 1.05, 0.95714285714286, 0.5
434, 1.05, 1.1285714285714, 0.5
435, 1.05, 0.27142857142857, 0
436, 1.05, 0.44285714285714, 0
437, 1.05, 0.61428571428571, 0
438, 1.05, 0.78571428571429, 0
439, 1.05, 0.95714285714286, 0
440, 1.05, 1.1285714285714, 0
441, 1.05, 0.1, 0.125
442, 1.05, 0.1, 0.25
443, 1.05, 0.1, 0.375
444, 1.05, 1.3, 0.125
445, 1.05, 1.3, 0.25
446, 1.05, 1.3, 0.375
447, 1.15, 1.1285714285714, 0.5
448, 1.15, 0.95714285714286, 0.5
449, 1.15, 0.78571428571429, 0.5
450, 1.15, 0.61428571428571, 0.5
451, 1.15, 0.44285714285714, 0.5
452, 1.15, 0.27142857142857, 0.5
453, 1.15, 1.1285714285714, 0
454, 1.15, 0.95714285714286, 0
455, 1.15, 0.78571428571429, 0
456, 1.15, 0.61428571428571, 0
457, 1.15, 0.44285714285714, 0
458, 1.15, 0.27142857142857, 0
459, 1.15, 1.3, 0.125
460, 1.15, 1.3, 0.25
461, 1.15, 1.3, 0.375
462, 1.15, 0.1, 0.125
463, 1.15, 0.1, 0.25
464, 1.15, 0.1, 0.375
465, 1, 0.27142857142857, -0.1
466, 1, 0.44285714285714, -0.1
467, 1, 0.61428571428571, -0.1
468, 1, 0.78571428571429, -0.1
469, 1, 0.95714285714286, -0.1
470, 1, 1.1285714285714, -0.1
471, 0, 0.27142857142857, -0.1
472, 0, 0.44285714285714, -0.1
473, 0, 0.61428571428571, -0.1
474, 0, 0.78571428571429, -0.1
475, 0, 0.95714285714286, -0.1
476, 0, 1.1285714285714, -0.1
477, 0.14285714285714, 0.1, -0.1
478, 0.28571428571429, 0.1, -0.1
479, 0.42857142857143, 0.1, -0.1
480, 0.57142857142857, 0.1, -0.1
481, 0.71428571428571, 0.1, -0.1
482, 0.85714285714286, 0.1, -0.1
483, 0.14285714285714, 1.3, -0.1
484, 0.28571428571429, 1.3, -0.1
485, 0.42857142857143, 1.3, -0.1
486, 0.57142857142857, 1.3, -0.1
487, 0.71428571428571, 1.3, -0.1
488, 0.85714285714286, 1.3, -0.1
489, 1.2, 1.1285714285714, -0.1
490, 1.2, 0.95714285714286, -0.1
491, 1.2, 0.78571428571429, -0.1
492, 1.2, 0.61428571428571, -0.1
493, 1.2, 0.44285714285714, -0.1
494, 1.2, 0.27142857142857, -0.1
495, 2.2, 1.1285714285714, -0.1
496, 2.2, 0.95714285714286, -0.1
497, 2.2, 0.78571428571429, -0.1
498, 2.2, 0.61428571428571, -0.1
499, 2.2, 0.44285714285714, -0.1
500, 2.2, 0.27142857142857, -0.1
501, 1.3428571428571, 1.3, -0.1
502, 1.4857142857143, 1.3, -0.1
503, 1.6285714285714, 1.3, -0.1
504, 1.7714285714286, 1.3, -0.1
505, 1.9142857142857, 1.3, -0.1
506, 2.0571428571429, 1.3, -0.1
507, 1.3428571428571, 0.1, -0.1
508, 1.4857142857143, 0.1, -0.1
509, 1.6285714285714, 0.1, -0.1
510, 1.7714285714286, 0.1, -0.1
511, 1.9142857142857, 0.1, -0.1
512, 2.0571428571429, 0.1, -0.1
513, 1.15, 1.1285714285714, -0.1
514, 1.15, 0.95714285714286, -0.1
515, 1.15, 0.78571428571429, -0.1
516, 1.15, 0.61428571428571, -0.1
517, 1.15, 0.44285714285714, -0.1
518, 1.15, 0.27142857142857, -0.1
519, 1.05, 0.27142857142857, -0.1
520, 1.05, 0.44285714285714, -0.1
521, 1.05, 0.61428571428571, -0.1
522, 1.05, 0.78571428571429, -0.1
523, 1.05, 0.95714285714286, -0.1
524, 1.05, 1.1285714285714, -0.1
525, 1, 1.44, 0
526, 1, 1.48, 0
527, 1, 1.52, 0
528, 1, 1.56, 0
529, 0, 1.44, 0
530, 0, 1.48, 0
531, 0, 1.52, 0
532, 0, 1.56, 0
533, 0.14285714285714, 1.6, 0
534, 0.28571428571429, 1.6, 0
535, 0.42857142857143, 1.6, 0
536, 0.57142857142857, 1.6, 0
537, 0.71428571428571, 1.6, 0
538, 0.85714285714286, 1.6, 0
539, 1, 1.44, 0.5
540, 1, 1.48, 0.5
541, 1, 1.52, 0.5
542, 1, 1.56, 0.5
543, 1, 1.6, 0.125
544, 1, 1.6, 0.25
545, 1, 1.6, 0.375
546, 0, 1.44, 0.5
547, 0, 1.48, 0.5
548, 0, 1.52, 0.5
549, 0, 1.56, 0.5
550, 0.14285714285714, 1.6, 0.5
551, 0.28571428571429, 1.6, 0.5
552, 0.42857142857143, 1.6, 0.5
553, 0.57142857142857, 1.6, 0.5
554, 0.71428571428571, 1.6, 0.5
555, 0.85714285714286, 1.6, 0.5
556, 0, 1.6, 0.125
557, 0, 1.6, 0.25
558, 0, 1.6, 0.375
559, 1.2, 1.44, 0.5
560, 1.2, 1.48, 0.5
561, 1.2, 1.52, 0.5
562, 1.2, 1.56, 0.5
563, 1.04, 1.6, 0.5
564, 1.08, 1.6, 0.5
565, 1.12, 1.6, 0.5
566, 1.16, 1.6, 0.5
567, 1.2, 1.44, 0
568, 1.2, 1.48, 0
569, 1.2, 1.52, 0
570, 1.2, 1.56, 0
571, 1.04, 1.6, 0
572, 1.08, 1.6, 0
573, 1.12, 1.6, 0
574, 1.16, 1.6, 0
575, 1.2, 1.6, 0.125
576, 1.2, 1.6, 0.25
577, 1.2, 1.6, 0.375
578, 2.2, 1.44, 0.5
579, 2.2, 1.48, 0.5
580, 2.2, 1.52, 0.5
581, 2.2, 1.56, 0.5
582, 1.3428571428571, 1.6, 0.5
583, 1.4857142857143, 1.6, 0.5
584, 1.6285714285714, 1.6, 0.5
585, 1.7714285714286, 1.6, 0.5
586, 1.9142857142857, 1.6, 0.5
587, 2.0571428571429, 1.6, 0.5
588, 2.2, 1.44, 0
589, 2.2, 1.48, 0
590, 2.2, 1.52, 0
591, 2.2, 1.56, 0
592, 1.3428571428571, 1.6, 0
593, 1.4857142857143, 1.6, 0
594, 1.6285714285714, 1.6, 0
595, 1.7714285714286, 1.6, 0
596, 1.9142857142857, 1.6, 0
597, 2.0571428571429, 1.6, 0
598, 2.2, 1.6, 0.125
599, 2.2, 1.6, 0.25
600, 2.2, 1.6, 0.375
601, 1, -0.04, 0
602, 1, -0.08, 0
603, 1, -0.12, 0
604, 1, -0.16, 0
605, 0, -0.04, 0
606, 0, -0.08, 0
607, 0, -0.12, 0
608, 0, -0.16, 0
609, 0.14285714285714, -0.2, 0
610, 0.28571428571429, -0.2, 0
611, 0.42857142857143, -0.2, 0
612, 0.57142857142857, -0.2, 0
613, 0.71428571428571, -0.2, 0
614, 0.85714285714286, -0.2, 0
615, 1, -0.04, 0.5
616, 1, -0.08, 0.5
617, 1, -0.12, 0.5
618, 1, -0.16, 0.5
619, 1, -0.2, 0.125
620, 1, -0.2, 0.25
621, 1, -0.2, 0.375
622, 0, -0.04, 0.5
623, 0, -0.08, 0.5
624, 0, -0.12, 0.5
625, 0, -0.16, 0.5
626, 0.14285714285714, -0.2, 0.5
627, 0.28571428571429, -0.2, 0.5
628, 0.42857142857143, -0.2, 0.5
629, 0.57142857142857, -0.2, 0.5
630, 0.71428571428571, -0.2, 0.5
631, 0.85714285714286, -0.2, 0.5
632, 0, -0.2, 0.125
633, 0, -0.2, 0.25
634, 0, -0.2, 0.375
635, -0.1, -0.04, 0.5
636, -0.1, -0.08, 0.5
637, -0.1, -0.12, 0.5
638, -0.1, -0.16, 0.5
639, -0.1, -0.04, 0
640, -0.1, -0.08, 0
641, -0.1, -0.12, 0
642, -0.1, -0.16, 0
643, -0.1, -0.2, 0.125
644, -0.1, -0.2, 0.25
645, -0.1, -0.2, 0.375
646, 1.2, -0.04, 0.5
647, 1.2, -0.08, 0.5
648, 1.2, -0.12, 0.5
649, 1.2, -0.16, 0.5
650, 2.2, -0.04, 0.5
651, 2.2, -0.08, 0.5
652, 2.2, -0.12, 0.5
653, 2.2, -0.16, 0.5
654, 1.3428571428571, -0.2, 0.5
655, 1.4857142857143, -0.2, 0.5
656, 1.6285714285714, -0.2, 0.5
657, 1.7714285714286, -0.2, 0.5
658, 1.9142857142857, -0.2, 0.5
659, 2.0571428571429, -0.2, 0.5
660, 1.2, -0.04, 0
661, 1.2, -0.08, 0
662, 1.2, -0.12, 0
663, 1.2, -0.16, 0
664, 2.2, -0.04, 0
665, 2.2, -0.08, 0
666, 2.2, -0.12, 0
667, 2.2, -0.16, 0
668, 1.3428571428571, -0.2, 0
669, 1.4857142857143, -0.2, 0
670, 1.6285714285714, -0.2, 0
671, 1.7714285714286, -0.2, 0
672, 1.9142857142857, -0.2, 0
673, 2.0571428571429, -0.2, 0
674, 1.2, -0.2, 0.125
675, 1.2, -0.2, 0.25
676, 1.2, -0.2, 0.375
677, 2.2, -0.2, 0.125
678, 2.2, -0.2, 0.25
679, 2.2, -0.2, 0.375
680, 2.3, -0.04, 0.5
681, 2.3, -0.08, 0.5
682, 2.3, -0.12, 0.5
683, 2.3, -0.16, 0.5
684, 2.3, -0.04, 0
685, 2.3, -0.08, 0
686, 2.3, -0.12, 0
687, 2.3, -0.16, 0
688, 2.3, -0.2, 0.125
689, 2.3, -0.2, 0.25
690, 2.3, -0.2, 0.375
691, 0, 0.016666666666667, 0.125
692, 0, 0.033333333333333, 0.125
693, 0, 0.016666666666667, 0.25
694, 0, 0.033333333333333, 0.25
695, 0, 0.016666666666667, 0.375
696, 0, 0.033333333333333, 0.375
697, 1, 0.016666666666667, 0.125
698, 1, 0.033333333333333, 0.125
699, 1, 0.016666666666667, 0.25
700, 1, 0.033333333333333, 0.25
701, 1, 0.016666666666667, 0.375
702, 1, 0.033333333333333, 0.375
703, 0.14285714285714, 0, 0.125
704, 0.14285714285714, 0, 0.25
705, 0.14285714285714, 0, 0.375
706, 0.28571428571429, 0, 0.125
707, 0.28571428571429, 0, 0.25
708, 0.28571428571429, 0, 0.375
709, 0.42857142857143, 0, 0.125
710, 0.42857142857143, 0, 0.25
711, 0.42857142857143, 0, 0.375
712, 0.57142857142857, 0, 0.125
713, 0.57142857142857, 0, 0.25
714, 0.57142857142857, 0, 0.375
715, 0.71428571428571, 0, 0.125
716, 0.71428571428571, 0, 0.25
717, 0.71428571428571, 0, 0.375
718, 0.85714285714286, 0, 0.125
719, 0.85714285714286, 0, 0.25
720, 0.85714285714286, 0, 0.375
721, 0.14285714285714, 0.05, 0.125
722, 0.14285714285714, 0.05, 0.25
723, 0.14285714285714, 0.05, 0.375
724, 0.28571428571429, 0.05, 0.125
725, 0.28571428571429, 0.05, 0.25
726, 0.28571428571429, 0.05, 0.375
727, 0.42857142857143, 0.05, 0.125
728, 0.42857142857143, 0.05, 0.25
729, 0.42857142857143, 0.05, 0.375
730, 0.57142857142857, 0.05, 0.125
731, 0.57142857142857, 0.05, 0.25
732, 0.57142857142857, 0.05, 0.375
733, 0.71428571428571, 0.05, 0.125
734, 0.71428571428571, 0.05, 0.25
735, 0.71428571428571, 0.05, 0.375
736, 0.85714285714286, 0.05, 0.125
737, 0.85714285714286, 0.05, 0.25
738, 0.85714285714286, 0.05, 0.375
739, 0.14285714285714, 0.016666666666667, 0
740, 0.28571428571429, 0.016666666666667, 0
741, 0.42857142857143, 0.016666666666667, 0
742, 0.57142857142857, 0.016666666666667, 0
743, 0.71428571428571, 0.016666666666667, 0
744, 0.85714285714286, 0.016666666666667, 0
745, 0.14285714285714, 0.033333333333333, 0
746, 0.28571428571429, 0.033333333333333, 0
747, 0.42857142857143, 0.033333333333333, 0
748, 0.57142857142857, 0.033333333333333, 0
749, 0.71428571428571, 0.033333333333333, 0
750, 0.85714285714286, 0.033333333333333, 0
751, 0.14285714285714, 0.016666666666667, 0.5
752, 0.28571428571429, 0.016666666666667, 0.5
753, 0.42857142857143, 0.016666666666667, 0.5
754, 0.57142857142857, 0.016666666666667, 0.5
755, 0.71428571428571, 0.016666666666667, 0.5
756, 0.85714285714286, 0.016666666666667, 0.5
757, 0.14285714285714, 0.033333333333333, 0.5
758, 0.28571428571429, 0.033333333333333, 0.5
759, 0.42857142857143, 0.033333333333333, 0.5
760, 0.57142857142857, 0.033333333333333, 0.5
761, 0.71428571428571, 0.033333333333333, 0.5
762, 0.85714285714286, 0.033333333333333, 0.5
763, 0.14285714285714, 0.1, 0.125
764, 0.14285714285714, 0.1, 0.25
765, 0.14285714285714, 0.1, 0.375
766, 0.28571428571429, 0.1, 0.125
767, 0.28571428571429, 0.1, 0.25
768, 0.28571428571429, 0.1, 0.375
769, 0.42857142857143, 0.1, 0.125
770, 0.42857142857143, 0.1, 0.25
771, 0.42857142857143, 0.1, 0.375
772, 0.57142857142857, 0.1, 0.125
773, 0.57142857142857, 0.1, 0.25
774, 0.57142857142857, 0.1, 0.375
775, 0.71428571428571, 0.1, 0.125
776, 0.71428571428571, 0.1, 0.25
777, 0.71428571428571, 0.1, 0.375
778, 0.85714285714286, 0.1, 0.125
779, 0.85714285714286, 0.1, 0.25
780, 0.85714285714286, 0.1, 0.375
781, 0.14285714285714, 0.27142857142857, 0
782, 0.14285714285714, 0.44285714285714, 0
783, 0.14285714285714, 0.61428571428571, 0
784, 0.14285714285714, 0.78571428571429, 0
785, 0.14285714285714, 0.95714285714286, 0
786, 0.14285714285714, 1.1285714285714, 0
787, 0.28571428571429, 0.27142857142857, 0
788, 0.28571428571429, 0.44285714285714, 0
789, 0.28571428571429, 0.61428571428571, 0
790, 0.28571428571429, 0.78571428571429, 0
791, 0.28571428571429, 0.95714285714286, 0
792, 0.28571428571429, 1.1285714285714, 0
793, 0.42857142857143, 0.27142857142857, 0
794, 0.42857142857143, 0.44285714285714, 0
795, 0.42857142857143, 0.61428571428571, 0
796, 0.42857142857143, 0.78571428571429, 0
797, 0.42857142857143, 0.95714285714286, 0
798, 0.42857142857143, 1.1285714285714, 0
799, 0.57142857142857, 0.27142857142857, 0
800, 0.57142857142857, 0.44285714285714, 0
801, 0.57142857142857, 0.61428571428571, 0
802, 0.57142857142857, 0.78571428571429, 0
803, 0.57142857142857, 0.95714285714286, 0
804, 0.57142857142857, 1.1285714285714, 0
805, 0.71428571428571, 0.27142857142857, 0
806, 0.71428571428571, 0.44285714285714, 0
807, 0.71428571428571, 0.61428571428571, 0
808, 0.71428571428571, 0.78571428571429, 0
809, 0.71428571428571, 0.95714285714286, 0
810, 0.71428571428571, 1.1285714285714, 0
811, 0.85714285714286, 0.27142857142857, 0
812, 0.85714285714286, 0.44285714285714, 0
813, 0.85714285714286, 0.61428571428571, 0
814, 0.85714285714286, 0.78571428571429, 0
815, 0.85714285714286, 0.95714285714286, 0
816, 0.85714285714286, 1.1285714285714, 0
817, 1, 0.27142857142857, 0.125
818, 1, 0.44285714285714, 0.125
819, 1, 0.61428571428571, 0.125
820, 1, 0.78571428571429, 0.125
821, 1, 0.95714285714286, 0.125
822, 1, 1.1285714285714, 0.125
823, 1, 0.27142857142857, 0.25
824, 1, 0.44285714285714, 0.25
825, 1, 0.61428571428571, 0.25
826, 1, 0.78571428571429, 0.25
827, 1, 0.95714285714286, 0.25
828, 1, 1.1285714285714, 0.25
829, 1, 0.27142857142857, 0.375
830, 1, 0.44285714285714, 0.375
831, 1, 0.61428571428571, 0.375
832, 1, 0.78571428571429, 0.375
833, 1, 0.95714285714286, 0.375
834, 1, 1.1285714285714, 0.375
835, 0.14285714285714, 0.27142857142857, 0.5
836, 0.14285714285714, 0.44285714285714, 0.5
837, 0.14285714285714, 0.61428571428571, 0.5
838, 0.14285714285714, 0.78571428571429, 0.5
839, 0.14285714285714, 0.95714285714286, 0.5
840, 0.14285714285714, 1.1285714285714, 0.5
841, 0.28571428571429, 0.27142857142857, 0.5
842, 0.28571428571429, 0.44285714285714, 0.5
843, 0.28571428571429, 0.61428571428571, 0.5
844, 0.28571428571429, 0.78571428571429, 0.5
845, 0.28571428571429, 0.95714285714286, 0.5
846, 0.28571428571429, 1.1285714285714, 0.5
847, 0.42857142857143, 0.27142857142857, 0.5
848, 0.42857142857143, 0.44285714285714, 0.5
849, 0.42857142857143, 0.61428571428571, 0.5
850, 0.42857142857143, 0.78571428571429, 0.5
851, 0.42857142857143, 0.95714285714286, 0.5
852, 0.42857142857143, 1.1285714285714, 0.5
853, 0.57142857142857, 0.27142857142857, 0.5
854, 0.57142857142857, 0.44285714285714, 0.5
855, 0.57142857142857, 0.61428571428571, 0.5
856, 0.57142857142857, 0.78571428571429, 0.5
857, 0.57142857142857, 0.95714285714286, 0.5
858, 0.57142857142857, 1.1285714285714, 0.5
859, 0.71428571428571, 0.27142857142857, 0.5
860, 0.71428571428571, 0.44285714285714, 0.5
861, 0.71428571428571, 0.61428571428571, 0.5
862, 0.71428571428571, 0.78571428571429, 0.5
863, 0.71428571428571, 0.95714285714286, 0.5
864, 0.71428571428571, 1.1285714285714, 0.5
865, 0.85714285714286, 0.27142857142857, 0.5
866, 0.85714285714286, 0.44285714285714, 0.5
867, 0.85714285714286, 0.61428571428571, 0.5
868, 0.85714285714286, 0.78571428571429, 0.5
869, 0.85714285714286, 0.95714285714286, 0.5
870, 0.85714285714286, 1.1285714285714, 0.5
871, 0, 0.27142857142857, 0.125
872, 0, 0.44285714285714, 0.125
873, 0, 0.61428571428571, 0.125
874, 0, 0.78571428571429, 0.125
875, 0, 0.95714285714286, 0.125
876, 0, 1.1285714285714, 0.125
877, 0, 0.27142857142857, 0.25
878, 0, 0.44285714285714, 0.25
879, 0, 0.61428571428571, 0.25
880, 0, 0.78571428571429, 0.25
881, 0, 0.95714285714286, 0.25
882, 0, 1.1285714285714, 0.25
883, 0, 0.27142857142857, 0.375
884, 0, 0.44285714285714, 0.375
885, 0, 0.61428571428571, 0.375
886, 0, 0.78571428571429, 0.375
887, 0, 0.95714285714286, 0.375
888, 0, 1.1285714285714, 0.375
889, 0.14285714285714, 1.3, 0.125
890, 0.14285714285714, 1.3, 0.25
891, 0.14285714285714, 1.3, 0.375
892, 0.28571428571429, 1.3, 0.125
893, 0.28571428571429, 1.3, 0.25
894, 0.28571428571429, 1.3, 0.375
895, 0.42857142857143, 1.3, 0.125
896, 0.42857142857143, 1.3, 0.25
897, 0.42857142857143, 1.3, 0.375
898, 0.57142857142857, 1.3, 0.125
899, 0.57142857142857, 1.3, 0.25
900, 0.57142857142857, 1.3, 0.375
901, 0.71428571428571, 1.3, 0.125
902, 0.71428571428571, 1.3, 0.25
903, 0.71428571428571, 1.3, 0.375
904, 0.85714285714286, 1.3, 0.125
905, 0.85714285714286, 1.3, 0.25
906, 0.85714285714286, 1.3, 0.375
907, 0.14285714285714, 1.35, 0.125
908, 0.14285714285714, 1.35, 0.25
909, 0.14285714285714, 1.35, 0.375
910, 0.28571428571429, 1.35, 0.125
911, 0.28571428571429, 1.35, 0.25
912, 0.28571428571429, 1.35, 0.375
913, 0.42857142857143, 1.35, 0.125
914, 0.42857142857143, 1.35, 0.25
915, 0.42857142857143, 1.35, 0.375
916, 0.57142857142857, 1.35, 0.125
917, 0.57142857142857, 1.35, 0.25
918, 0.57142857142857, 1.35, 0.375
919, 0.71428571428571, 1.35, 0.125
920, 0.71428571428571, 1.35, 0.25
921, 0.71428571428571, 1.35, 0.375
922, 0.85714285714286, 1.35, 0.125
923, 0.85714285714286, 1.35, 0.25
924, 0.85714285714286, 1.35, 0.375
925, 0.14285714285714, 1.3666666666667, 0
926, 0.14285714285714, 1.3833333333333, 0
927, 0.28571428571429, 1.3666666666667, 0
928, 0.28571428571429, 1.3833333333333, 0
929, 0.42857142857143, 1.3666666666667, 0
930, 0.42857142857143, 1.3833333333333, 0
931, 0.57142857142857, 1.3666666666667, 0
932, 0.57142857142857, 1.3833333333333, 0
933, 0.71428571428571, 1.3666666666667, 0
934, 0.71428571428571, 1.3833333333333, 0
935, 0.85714285714286, 1.3666666666667, 0
936, 0.85714285714286, 1.3833333333333, 0
937, 1, 1.3666666666667, 0.125
938, 1, 1.3833333333333, 0.125
939, 1, 1.3666666666667, 0.25
940, 1, 1.3833333333333, 0.25
941, 1, 1.3666666666667, 0.375
942, 1, 1.3833333333333, 0.375
943, 0.14285714285714, 1.3666666666667, 0.5
944, 0.14285714285714, 1.3833333333333, 0.5
945, 0.28571428571429, 1.3666666666667, 0.5
946, 0.28571428571429, 1.3833333333333, 0.5
947, 0.42857142857143, 1.3666666666667, 0.5
948, 0.42857142857143, 1.3833333333333, 0.5
949, 0.57142857142857, 1.3666666666667, 0.5
950, 0.57142857142857, 1.3833333333333, 0.5
951, 0.71428571428571, 1.3666666666667, 0.5
952, 0.71428571428571, 1.3833333333333, 0.5
953, 0.85714285714286, 1.3666666666667, 0.5
954, 0.85714285714286, 1.3833333333333, 0.5
955, 0, 1.3666666666667, 0.125
956, 0, 1.3833333333333, 0.125
957, 0, 1.3666666666667, 0.25
958, 0, 1.3833333333333, 0.25
959, 0, 1.3666666666667, 0.375
960, 0, 1.3833333333333, 0.375
961, 0.14285714285714, 1.4, 0.125
962, 0.14285714285714, 1.4, 0.25
963, 0.14285714285714, 1.4, 0.375
964, 0.28571428571429, 1.4, 0.125
965, 0.28571428571429, 1.4, 0.25
966, 0.28571428571429, 1.4, 0.375
967, 0.42857142857143, 1.4, 0.125
968, 0.42857142857143, 1.4, 0.25
969, 0.42857142857143, 1.4, 0.375
970, 0.57142857142857, 1.4, 0.125
971, 0.57142857142857, 1.4, 0.25
972, 0.57142857142857, 1.4, 0.375
973, 0.71428571428571, 1.4, 0.125
974, 0.71428571428571, 1.4, 0.25
975, 0.71428571428571, 1.4, 0.375
976, 0.85714285714286, 1.4, 0.125
977, 0.85714285714286, 1.4, 0.25
978, 0.85714285714286, 1.4, 0.375
979, 1.04, 1.3666666666667, 0.5
980, 1.08, 1.3666666666667, 0.5
981, 1.12, 1.3666666666667, 0.5
982, 1.16, 1.3666666666667, 0.5
983, 1.04, 1.3833333333333, 0.5
984, 1.08, 1.3833333333333, 0.5
985, 1.12, 1.3833333333333, 0.5
986, 1.16, 1.3833333333333, 0.5
987, 1.04, 1.3666666666667, 0
988, 1.08, 1.3666666666667, 0
989, 1.12, 1.3666666666667, 0
990, 1.16, 1.3666666666667, 0
991, 1.04, 1.3833333333333, 0
992, 1.08, 1.3833333333333, 0
993, 1.12, 1.3833333333333, 0
994, 1.16, 1.3833333333333, 0
995, 1.04, 1.35, 0.125
996, 1.08, 1.35, 0.125
997, 1.12, 1.35, 0.125
998, 1.16, 1.35, 0.125
999, 1.04, 1.35, 0.25
1000, 1.08, 1.35, 0.25
1001, 1.12, 1.35, 0.25
1002, 1.16, 1.35, 0.25
1003, 1.04, 1.35, 0.375
1004, 1.08, 1.35, 0.375
1005, 1.12, 1.35, 0.375
1006, 1.16, 1.35, 0.375
1007, 1.04, 1.4, 0.125
1008, 1.08, 1.4, 0.125
1009, 1.12, 1.4, 0.125
1010, 1.16, 1.4, 0.125
1011, 1.04, 1.4, 0.25
1012, 1.08, 1.4, 0.25
1013, 1.12, 1.4, 0.25
1014, 1.16, 1.4, 0.25
1015, 1.04, 1.4, 0.375
1016, 1.08, 1.4, 0.375
1017, 1.12, 1.4, 0.375
1018, 1.16, 1.4, 0.375
1019, 1.2, 1.3666666666667, 0.125
1020, 1.2, 1.3833333333333, 0.125
1021, 1.2, 1.3666666666667, 0.25
1022, 1.2, 1.3833333333333, 0.25
1023, 1.2, 1.3666666666667, 0.375
1024, 1.2, 1.3833333333333, 0.375
1025, 1.3428571428571, 1.3666666666667, 0.5
1026, 1.4857142857143, 1.3666666666667, 0.5
1027, 1.6285714285714, 1.3666666666667, 0.5
1028, 1.7714285714286, 1.3666666666667, 0.5
1029, 1.9142857142857, 1.3666666666667, 0.5
1030, 2.0571428571429, 1.3666666666667, 0.5
1031, 1.3428571428571, 1.3833333333333, 0.5
1032, 1.4857142857143, 1.3833333333333, 0.5
1033, 1.6285714285714, 1.3833333333333, 0.5
1034, 1.7714285714286, 1.3833333333333, 0.5
1035, 1.9142857142857, 1.3833333333333, 0.5
1036, 2.0571428571429, 1.3833333333333, 0.5
1037, 1.3428571428571, 1.3666666666667, 0
1038, 1.4857142857143, 1.3666666666667, 0
1039, 1.6285714285714, 1.3666666666667, 0
1040, 1.7714285714286, 1.3666666666667, 0
1041, 1.9142857142857, 1.3666666666667, 0
1042, 2.0571428571429, 1.3666666666667, 0
1043, 1.3428571428571, 1.3833333333333, 0
1044, 1.4857142857143, 1.3833333333333, 0
1045, 1.6285714285714, 1.3833333333333, 0
1046, 1.7714285714286, 1.3833333333333, 0
1047, 1.9142857142857, 1.3833333333333, 0
1048, 2.0571428571429, 1.3833333333333, 0
1049, 1.3428571428571, 1.35, 0.125
1050, 1.4857142857143, 1.35, 0.125
1051, 1.6285714285714, 1.35, 0.125
1052, 1.7714285714286, 1.35, 0.125
1053, 1.9142857142857, 1.35, 0.125
1054, 2.0571428571429, 1.35, 0.125
1055, 1.3428571428571, 1.35, 0.25
1056, 1.4857142857143, 1.35, 0.25
1057, 1.6285714285714, 1.35, 0.25
1058, 1.7714285714286, 1.35, 0.25
1059, 1.9142857142857, 1.35, 0.25
1060, 2.0571428571429, 1.35, 0.25
1061, 1.3428571428571, 1.35, 0.375
1062, 1.4857142857143, 1.35, 0.375
1063, 1.6285714285714, 1.35, 0.375
1064, 1.7714285714286, 1.35, 0.375
1065, 1.9142857142857, 1.35, 0.375
1066, 2.0571428571429, 1.35, 0.375
1067, 1.3428571428571, 1.4, 0.125
1068, 1.4857142857143, 1.4, 0.125
1069, 1.6285714285714, 1.4, 0.125
1070, 1.7714285714286, 1.4, 0.125
1071, 1.9142857142857, 1.4, 0.125
1072, 2.0571428571429, 1.4, 0.125
1073, 1.3428571428571, 1.4, 0.25
1074, 1.4857142857143, 1.4, 0.25
1075, 1.6285714285714, 1.4, 0.25
1076, 1.7714285714286, 1.4, 0.25
1077, 1.9142857142857, 1.4, 0.25
1078, 2.0571428571429, 1.4, 0.25
1079, 1.3428571428571, 1.4, 0.375
1080, 1.4857142857143, 1.4, 0.375
1081, 1.6285714285714, 1.4, 0.375
1082, 1.7714285714286, 1.4, 0.375
1083, 1.9142857142857, 1.4, 0.375
1084, 2.0571428571429, 1.4, 0.375
1085, 2.2, 1.3666666666667, 0.125
1086, 2.2, 1.3833333333333, 0.125
1087, 2.2, 1.3666666666667, 0.25
1088, 2.2, 1.3833333333333, 0.25
1089, 2.2, 1.3666666666667, 0.375
1090, 2.2, 1.3833333333333, 0.375
1091, 1.3428571428571, 1.3, 0.125
1092, 1.4857142857143, 1.3, 0.125
1093, 1.6285714285714, 1.3, 0.125
1094, 1.7714285714286, 1.3, 0.125
1095, 1.9142857142857, 1.3, 0.125
1096, 2.0571428571429, 1.3, 0.125
1097, 1.3428571428571, 1.3, 0.25
1098, 1.4857142857143, 1.3, 0.25
1099, 1.6285714285714, 1.3, 0.25
1100, 1.7714285714286, 1.3, 0.25
1101, 1.9142857142857, 1.3, 0.25
1102, 2.0571428571429, 1.3, 0.25
1103, 1.3428571428571, 1.3, 0.375
1104, 1.4857142857143, 1.3, 0.375
1105, 1.6285714285714, 1.3, 0.375
1106, 1.7714285714286, 1.3, 0.375
1107, 1.9142857142857, 1.3, 0.375
1108, 2.0571428571429, 1.3, 0.375
1109, 1.3428571428571, 1.1285714285714, 0.5
1110, 1.3428571428571, 0.95714285714286, 0.5
1111, 1.3428571428571, 0.78571428571429, 0.5
1112, 1.3428571428571, 0.61428571428571, 0.5
1113, 1.3428571428571, 0.44285714285714, 0.5
1114, 1.3428571428571, 0.27142857142857, 0.5
1115, 1.4857142857143, 1.1285714285714, 0.5
1116, 1.4857142857143, 0.95714285714286, 0.5
1117, 1.4857142857143, 0.78571428571429, 0.5
1118, 1.4857142857143, 0.61428571428571, 0.5
1119, 1.4857142857143, 0.44285714285714, 0.5
1120, 1.4857142857143, 0.27142857142857, 0.5
1121, 1.6285714285714, 1.1285714285714, 0.5
1122, 1.6285714285714, 0.95714285714286, 0.5
1123, 1.6285714285714, 0.78571428571429, 0.5
1124, 1.6285714285714, 0.61428571428571, 0.5
1125, 1.6285714285714, 0.44285714285714, 0.5
1126, 1.6285714285714, 0.27142857142857, 0.5
1127, 1.7714285714286, 1.1285714285714, 0.5
1128, 1.7714285714286, 0.95714285714286, 0.5
1129, 1.7714285714286, 0.78571428571429, 0.5
1130, 1.7714285714286, 0.61428571428571, 0.5
1131, 1.7714285714286, 0.44285714285714, 0.5
1132, 1.7714285714286, 0.27142857142857, 0.5
1133, 1.9142857142857, 1.1285714285714, 0.5
1134, 1.9142857142857, 0.95714285714286, 0.5
1135, 1.9142857142857, 0.78571428571429, 0.5
1136, 1.9142857142857, 0.61428571428571, 0.5
1137, 1.9142857142857, 0.44285714285714, 0.5
1138, 1.9142857142857, 0.27142857142857, 0.5
1139, 2.0571428571429, 1.1285714285714, 0.5
1140, 2.0571428571429, 0.95714285714286, 0.5
1141, 2.0571428571429, 0.78571428571429, 0.5
1142, 2.0571428571429, 0.61428571428571, 0.5
1143, 2.0571428571429, 0.44285714285714, 0.5
1144, 2.0571428571429, 0.27142857142857, 0.5
1145, 1.3428571428571, 1.1285714285714, 0
1146, 1.3428571428571, 0.95714285714286, 0
1147, 1.3428571428571, 0.78571428571429, 0
1148, 1.3428571428571, 0.61428571428571, 0
1149, 1.3428571428571, 0.44285714285714, 0
1150, 1.3428571428571, 0.27142857142857, 0
1151, 1.4857142857143, 1.1285714285714, 0
1152, 1.4857142857143, 0.95714285714286, 0
1153, 1.4857142857143, 0.78571428571429, 0
1154, 1.4857142857143, 0.61428571428571, 0
1155, 1.4857142857143, 0.44285714285714, 0
1156, 1.4857142857143, 0.27142857142857, 0
1157, 1.6285714285714, 1.1285714285714, 0
1158, 1.6285714285714, 0.95714285714286, 0
1159, 1.6285714285714, 0.78571428571429, 0
1160, 1.6285714285714, 0.61428571428571, 0
1161, 1.6285714285714, 0.44285714285714, 0
1162, 1.6285714285714, 0.27142857142857, 0
1163, 1.7714285714286, 1.1285714285714, 0
1164, 1.7714285714286, 0.95714285714286, 0
1165, 1.7714285714286, 0.78571428571429, 0
1166, 1.7714285714286, 0.61428571428571, 0
1167, 1.7714285714286, 0.44285714285714, 0
1168, 1.7714285714286, 0.27142857142857, 0
1169, 1.9142857142857, 1.1285714285714, 0
1170, 1.9142857142857, 0.95714285714286, 0
1171, 1.9142857142857, 0.78571428571429, 0
1172, 1.9142857142857, 0.61428571428571, 0
1173, 1.9142857142857, 0.44285714285714, 0
1174, 1.9142857142857, 0.27142857142857, 0
1175, 2.0571428571429, 1.1285714285714, 0
1176, 2.0571428571429, 0.95714285714286, 0
1177, 2.0571428571429, 0.78571428571429, 0
1178, 2.0571428571429, 0.61428571428571, 0
1179, 2.0571428571429, 0.44285714285714, 0
1180, 2.0571428571429, 0.27142857142857, 0
1181, 1.2, 1.1285714285714, 0.125
1182, 1.2, 0.95714285714286, 0.125
1183, 1.2, 0.78571428571429, 0.125
1184, 1.2, 0.61428571428571, 0.125
1185, 1.2, 0.44285714285714, 0.125
1186, 1.2, 0.27142857142857, 0.125
1187, 1.2, 1.1285714285714, 0.25
1188, 1.2, 0.95714285714286, 0.25
1189, 1.2, 0.78571428571429, 0.25
1190, 1.2, 0.61428571428571, 0.25
1191, 1.2, 0.44285714285714, 0.25
1192, 1.2, 0.27142857142857, 0.25
1193, 1.2, 1.1285714285714, 0.375
1194, 1.2, 0.95714285714286, 0.375
1195, 1.2, 0.78571428571429, 0.375
1196, 1.2, 0.61428571428571, 0.375
1197, 1.2, 0.44285714285714, 0.375
1198, 1.2, 0.27142857142857, 0.375
1199, 2.2, 1.1285714285714, 0.125
1200, 2.2, 0.95714285714286, 0.125
1201, 2.2, 0.78571428571429, 0.125
1202, 2.2, 0.61428571428571, 0.125
1203, 2.2, 0.44285714285714, 0.125
1204, 2.2, 0.27142857142857, 0.125
1205, 2.2, 1.1285714285714, 0.25
1206, 2.2, 0.95714285714286, 0.25
1207, 2.2, 0.78571428571429, 0.25
1208, 2.2, 0.61428571428571, 0.25
1209, 2.2, 0.44285714285714, 0.25
1210, 2.2, 0.27142857142857, 0.25
1211, 2.2, 1.1285714285714, 0.375
1212, 2.2, 0.95714285714286, 0.375
1213, 2.2, 0.78571428571429, 0.375
1214, 2.2, 0.61428571428571, 0.375
1215, 2.2, 0.44285714285714, 0.375
1216, 2.2, 0.27142857142857, 0.375
1217, 1.3428571428571, 0.1, 0.125
1218, 1.4857142857143, 0.1, 0.125
1219, 1.6285714285714, 0.1, 0.125
1220, 1.7714285714286, 0.1, 0.125
1221, 1.9142857142857, 0.1, 0.125
1222, 2.0571428571429, 0.1, 0.125
1223, 1.3428571428571, 0.1, 0.25
1224, 1.4857142857143, 0.1, 0.25
1225, 1.6285714285714, 0.1, 0.25
1226, 1.7714285714286, 0.1, 0.25
1227, 1.9142857142857, 0.1, 0.25
1228, 2.0571428571429, 0.1, 0.25
1229, 1.3428571428571, 0.1, 0.375
1230, 1.4857142857143, 0.1, 0.375
1231, 1.6285714285714, 0.1, 0.375
1232, 1.7714285714286, 0.1, 0.375
1233, 1.9142857142857, 0.1, 0.375
1234, 2.0571428571429, 0.1, 0.375
1235, 1.3428571428571, 0.05, 0.125
1236, 1.4857142857143, 0.05, 0.125
1237, 1.6285714285714, 0.05, 0.125
1238, 1.7714285714286, 0.05, 0.125
1239, 1.9142857142857, 0.05, 0.125
1240, 2.0571428571429, 0.05, 0.125
1241, 1.3428571428571, 0.05, 0.25
1242, 1.4857142857143, 0.05, 0.25
1243, 1.6285714285714, 0.05, 0.25
1244, 1.7714285714286, 0.05, 0.25
1245, 1.9142857142857, 0.05, 0.25
1246, 2.0571428571429, 0.05, 0.25
1247, 1.3428571428571, 0.05, 0.375
1248, 1.4857142857143, 0.05, 0.375
1249, 1.6285714285714, 0.05, 0.375
1250, 1.7714285714286, 0.05, 0.375
1251, 1.9142857142857, 0.05, 0.375
1252, 2.0571428571429, 0.05, 0.375
1253, 1.3428571428571, 0.033333333333333, 0.5
1254, 1.3428571428571, 0.016666666666667, 0.5
1255, 1.4857142857143, 0.033333333333333, 0.5
1256, 1.4857142857143, 0.016666666666667, 0.5
1257, 1.6285714285714, 0.033333333333333, 0.5
1258, 1.6285714285714, 0.016666666666667, 0.5
1259, 1.7714285714286, 0.033333333333333, 0.5
1260, 1.7714285714286, 0.016666666666667, 0.5
1261, 1.9142857142857, 0.033333333333333, 0.5
1262, 1.9142857142857, 0.016666666666667, 0.5
1263, 2.0571428571429, 0.033333333333333, 0.5
1264, 2.0571428571429, 0.016666666666667, 0.5
1265, 1.3428571428571, 0.033333333333333, 0
1266, 1.3428571428571, 0.016666666666667, 0
1267, 1.4857142857143, 0.033333333333333, 0
1268, 1.4857142857143, 0.016666666666667, 0
1269, 1.6285714285714, 0.033333333333333, 0
1270, 1.6285714285714, 0.016666666666667, 0
1271, 1.7714285714286, 0.033333333333333, 0
1272, 1.7714285714286, 0.016666666666667, 0
1273, 1.9142857142857, 0.033333333333333, 0
1274, 1.9142857142857, 0.016666666666667, 0
1275, 2.0571428571429, 0.033333333333333, 0
1276, 2.0571428571429, 0.016666666666667, 0
1277, 1.2, 0.033333333333333, 0.125
1278, 1.2, 0.016666666666667, 0.125
1279, 1.2, 0.033333333333333, 0.25
1280, 1.2, 0.016666666666667, 0.25
1281, 1.2, 0.033333333333333, 0.375
1282, 1.2, 0.016666666666667, 0.375
1283, 2.2, 0.033333333333333, 0.125
1284, 2.2, 0.016666666666667, 0.125
1285, 2.2, 0.033333333333333, 0.25
1286, 2.2, 0.016666666666667, 0.25
1287, 2.2, 0.033333333333333, 0.375
1288, 2.2, 0.016666666666667, 0.375
1289, 1.3428571428571, 8.3266726846887e-17, 0.125
1290, 1.4857142857143, 8.3266726846887e-17, 0.125
1291, 1.6285714285714, 8.3266726846887e-17, 0.125
1292, 1.7714285714286, 8.3266726846887e-17, 0.125
1293, 1.9142857142857, 8.3266726846887e-17, 0.125
1294, 2.0571428571429, 8.3266726846887e-17, 0.125
1295, 1.3428571428571, 8.3266726846887e-17, 0.25
1296, 1.4857142857143, 8.3266726846887e-17, 0.25
1297, 1.6285714285714, 8.3266726846887e-17, 0.25
1298, 1.7714285714286, 8.3266726846887e-17, 0.25
1299, 1.9142857142857, 8.3266726846887e-17, 0.25
1300, 2.0571428571429, 8.3266726846887e-17, 0.25
1301, 1.3428571428571, 8.3266726846887e-17, 0.375
1302, 1.4857142857143, 8.3266726846887e-17, 0.375
1303, 1.6285714285714, 8.3266726846887e-17, 0.375
1304, 1.7714285714286, 8.3266726846887e-17, 0.375
1305, 1.9142857142857, 8.3266726846887e-17, 0.375
1306, 2.0571428571429, 8.3266726846887e-17, 0.375
1307, 2.3, 0.033333333333333, 0.125
1308, 2.3, 0.016666666666667, 0.125
1309, 2.3, 0.033333333333333, 0.25
1310, 2.3, 0.016666666666667, 0.25
1311, 2.3, 0.033333333333333, 0.375
1312, 2.3, 0.016666666666667, 0.375
1313, -0.1, 0.016666666666667, 0.125
1314, -0.1, 0.033333333333333, 0.125
1315, -0.1, 0.016666666666667, 0.25
1316, -0.1, 0.033333333333333, 0.25
1317, -0.1, 0.016666666666667, 0.375
1318, -0.1, 0.033333333333333, 0.375
1319, 1.05, 0.27142857142857, 0.125
1320, 1.05, 0.44285714285714, 0.125
1321, 1.05, 0.61428571428571, 0.125
1322, 1.05, 0.78571428571429, 0.125
1323, 1.05, 0.95714285714286, 0.125
1324, 1.05, 1.1285714285714, 0.125
1325, 1.05, 0.27142857142857, 0.25
1326, 1.05, 0.44285714285714, 0.25
1327, 1.05, 0.61428571428571, 0.25
1328, 1.05, 0.78571428571429, 0.25
1329, 1.05, 0.95714285714286, 0.25
1330, 1.05, 1.1285714285714, 0.25
1331, 1.05, 0.27142857142857, 0.375
1332, 1.05, 0.44285714285714, 0.375
1333, 1.05, 0.61428571428571, 0.375
1334, 1.05, 0.78571428571429, 0.375
1335, 1.05, 0.95714285714286, 0.375
1336, 1.05, 1.1285714285714, 0.375
1337, 1.15, 1.1285714285714, 0.125
1338, 1.15, 0.95714285714286, 0.125
1339, 1.15, 0.78571428571429, 0.125
1340, 1.15, 0.61428571428571, 0.125
1341, 1.15, 0.44285714285714, 0.125
1342, 1.15, 0.27142857142857, 0.125
1343, 1.15, 1.1285714285714, 0.25
1344, 1.15, 0.95714285714286, 0.25
1345, 1.15, 0.78571428571429, 0.25
1346, 1.15, 0.61428571428571, 0.25
1347, 1.15, 0.44285714285714, 0.25
1348, 1.15, 0.27142857142857, 0.25
1349, 1.15, 1.1285714285714, 0.375
1350, 1.15, 0.95714285714286, 0.375
1351, 1.15, 0.78571428571429, 0.375
1352, 1.15, 0.61428571428571, 0.375
1353, 1.15, 0.44285714285714, 0.375
1354, 1.15, 0.27142857142857, 0.375
1355, 0.14285714285714, 0.27142857142857, -0.1
1356, 0.14285714285714, 0.44285714285714, -0.1
1357, 0.14285714285714, 0.61428571428571, -0.1
1358, 0.14285714285714, 0.78571428571429, -0.1
1359, 0.14285714285714, 0.95714285714286, -0.1
1360, 0.14285714285714, 1.1285714285714, -0.1
1361, 0.28571428571429, 0.27142857142857, -0.1
1362, 0.28571428571429, 0.44285714285714, -0.1
1363, 0.28571428571429, 0.61428571428571, -0.1
1364, 0.28571428571429, 0.78571428571429, -0.1
1365, 0.28571428571429, 0.95714285714286, -0.1
1366, 0.28571428571429, 1.1285714285714, -0.1
1367, 0.42857142857143, 0.27142857142857, -0.1
1368, 0.42857142857143, 0.44285714285714, -0.1
1369, 0.42857142857143, 0.61428571428571, -0.1
1370, 0.42857142857143, 0.78571428571429, -0.1
1371, 0.42857142857143, 0.95714285714286, -0.1
1372, 0.42857142857143, 1.1285714285714, -0.1
1373, 0.57142857142857, 0.27142857142857, -0.1
1374, 0.57142857142857, 0.44285714285714, -0.1
1375, 0.57142857142857, 0.61428571428571, -0.1
1376, 0.57142857142857, 0.78571428571429, -0.1
1377, 0.57142857142857, 0.95714285714286, -0.1
1378, 0.57142857142857, 1.1285714285714, -0.1
1379, 0.71428571428571, 0.27142857142857, -0.1
1380, 0.71428571428571, 0.44285714285714, -0.1
1381, 0.71428571428571, 0.61428571428571, -0.1
1382, 0.71428571428571, 0.78571428571429, -0.1
1383, 0.71428571428571, 0.95714285714286, -0.1
1384, 0.71428571428571, 1.1285714285714, -0.1
1385, 0.85714285714286, 0.27142857142857, -0.1
1386, 0.85714285714286, 0.44285714285714, -0.1
1387, 0.85714285714286, 0.61428571428571, -0.1
1388, 0.85714285714286, 0.78571428571429, -0.1
1389, 0.85714285714286, 0.95714285714286, -0.1
1390, 0.85714285714286, 1.1285714285714, -0.1
1391, 1.3428571428571, 1.1285714285714, -0.1
1392, 1.3428571428571, 0.95714285714286, -0.1
1393, 1.3428571428571, 0.78571428571429, -0.1
1394, 1.3428571428571, 0.61428571428571, -0.1
1395, 1.3428571428571, 0.44285714285714, -0.1
1396, 1.3428571428571, 0.27142857142857, -0.1
1397, 1.4857142857143, 1.1285714285714, -0.1
1398, 1.4857142857143, 0.95714285714286, -0.1
1399, 1.4857142857143, 0.78571428571429, -0.1
1400, 1.4857142857143, 0.61428571428571, -0.1
1401, 1.4857142857143, 0.44285714285714, -0.1
1402, 1.4857142857143, 0.27142857142857, -0.1
1403, 1.6285714285714, 1.1285714285714, -0.1
1404, 1.6285714285714, 0.95714285714286, -0.1
1405, 1.6285714285714, 0.78571428571429, -0.1
1406, 1.6285714285714, 0.61428571428571, -0.1
1407, 1.6285714285714, 0.44285714285714, -0.1
1408, 1.6285714285714, 0.27142857142857, -0.1
1409, 1.7714285714286, 1.1285714285714, -0.1
1410, 1.7714285714286, 0.95714285714286, -0.1
1411, 1.7714285714286, 0.78571428571429, -0.1
1412, 1.7714285714286, 0.61428571428571, -0.1
1413, 1.7714285714286, 0.44285714285714, -0.1
1414, 1.7714285714286, 0.27142857142857, -0.1
1415, 1.9142857142857, 1.1285714285714, -0.1
1416, 1.9142857142857, 0.95714285714286, -0.1
1417, 1.9142857142857, 0.78571428571429, -0.1
1418, 1.9142857142857, 0.61428571428571, -0.1
1419, 1.9142857142857, 0.44285714285714, -0.1
1420, 1.9142857142857, 0.27142857142857, -0.1
1421, 2.0571428571429, 1.1285714285714, -0.1
1422, 2.0571428571429, 0.95714285714286, -0.1
1423, 2.0571428571429, 0.78571428571429, -0.1
1424, 2.0571428571429, 0.61428571428571, -0.1
1425, 2.0571428571429, 0.44285714285714, -0.1
1426, 2.0571428571429, 0.27142857142857, -0.1
1427, 0.14285714285714, 1.44, 0
1428, 0.14285714285714, 1.48, 0
1429, 0.14285714285714, 1.52, 0
1430, 0.14285714285714, 1.56, 0
1431, 0.28571428571429, 1.44, 0
1432, 0.28571428571429, 1.48, 0
1433, 0.28571428571429, 1.52, 0
1434, 0.28571428571429, 1.56, 0
1435, 0.42857142857143, 1.44, 0
1436, 0.42857142857143, 1.48, 0
1437, 0.42857142857143, 1.52, 0
1438, 0.42857142857143, 1.56, 0
1439, 0.57142857142857, 1.44, 0
1440, 0.57142857142857, 1.48, 0
1441, 0.57142857142857, 1.52, 0
1442, 0.57142857142857, 1.56, 0
1443, 0.71428571428571, 1.44, 0
1444, 0.71428571428571, 1.48, 0
1445, 0.71428571428571, 1.52, 0
1446, 0.71428571428571, 1.56, 0
1447, 0.85714285714286, 1.44, 0
1448, 0.85714285714286, 1.48, 0
1449, 0.85714285714286, 1.52, 0
1450, 0.85714285714286, 1.56, 0
1451, 1, 1.44, 0.125
1452, 1, 1.48, 0.125
1453, 1, 1.52, 0.125
1454, 1, 1.56, 0.125
1455, 1, 1.44, 0.25
1456, 1, 1.48, 0.25
1457, 1, 1.52, 0.25
1458, 1, 1.56, 0.25
1459, 1, 1.44, 0.375
1460, 1, 1.48, 0.375
1461, 1, 1.52, 0.375
1462, 1, 1.56, 0.375
1463, 0.14285714285714, 1.44, 0.5
1464, 0.14285714285714, 1.48, 0.5
1465, 0.14285714285714, 1.52, 0.5
1466, 0.14285714285714, 1.56, 0.5
1467, 0.28571428571429, 1.44, 0.5
1468, 0.28571428571429, 1.48, 0.5
1469, 0.28571428571429, 1.52, 0.5
1470, 0.28571428571429, 1.56, 0.5
1471, 0.42857142857143, 1.44, 0.5
1472, 0.42857142857143, 1.48, 0.5
1473, 0.42857142857143, 1.52, 0.5
1474, 0.42857142857143, 1.56, 0.5
1475, 0.57142857142857, 1.44, 0.5
1476, 0.57142857142857, 1.48, 0.5
1477, 0.57142857142857, 1.52, 0.5
1478, 0.57142857142857, 1.56, 0.5
1479, 0.71428571428571, 1.44, 0.5
1480, 0.71428571428571, 1.48, 0.5
1481, 0.71428571428571, 1.52, 0.5
1482, 0.71428571428571, 1.56, 0.5
1483, 0.85714285714286, 1.44, 0.5
1484, 0.85714285714286, 1.48, 0.5
1485, 0.85714285714286, 1.52, 0.5
1486, 0.85714285714286, 1.56, 0.5
1487, 0, 1.44, 0.125
1488, 0, 1.48, 0.125
1489, 0, 1.52, 0.125
1490, 0, 1.56, 0.125
1491, 0, 1.44, 0.25
1492, 0, 1.48, 0.25
1493, 0, 1.52, 0.25
1494, 0, 1.56, 0.25
1495, 0, 1.44, 0.375
1496, 0, 1.48, 0.375
1497, 0, 1.52, 0.375
1498, 0, 1.56, 0.375
1499, 0.14285714285714, 1.6, 0.125
1500, 0.14285714285714, 1.6, 0.25
1501, 0.14285714285714, 1.6, 0.375
1502, 0.28571428571429, 1.6, 0.125
1503, 0.28571428571429, 1.6, 0.25
1504, 0.28571428571429, 1.6, 0.375
1505, 0.42857142857143, 1.6, 0.125
1506, 0.42857142857143, 1.6, 0.25
1507, 0.42857142857143, 1.6, 0.375
1508, 0.57142857142857, 1.6, 0.125
1509, 0.57142857142857, 1.6, 0.25
1510, 0.57142857142857, 1.6, 0.375
1511, 0.71428571428571, 1.6, 0.125
1512, 0.71428571428571, 1.6, 0.25
1513, 0.71428571428571, 1.6, 0.375
1514, 0.85714285714286, 1.6, 0.125
1515, 0.85714285714286, 1.6, 0.25
1516, 0.85714285714286, 1.6, 0.375
1517, 1.04, 1.44, 0.5
1518, 1.04, 1.48, 0.5
1519, 1.04, 1.52, 0.5
1520, 1.04, 1.56, 0.5
1521, 1.08, 1.44, 0.5
1522, 1.08, 1.48, 0.5
1523, 1.08, 1.52, 0.5
1524, 1.08, 1.56, 0.5
1525, 1.12, 1.44, 0.5
1526, 1.12, 1.48, 0.5
1527, 1.12, 1.52, 0.5
1528, 1.12, 1.56, 0.5
1529, 1.16, 1.44, 0.5
1530, 1.16, 1.48, 0.5
1531, 1.16, 1.52, 0.5
1532, 1.16, 1.56, 0.5
1533, 1.04, 1.44, 0
1534, 1.04, 1.48, 0
1535, 1.04, 1.52, 0
1536, 1.04, 1.56, 0
1537, 1.08, 1.44, 0
1538, 1.08, 1.48, 0
1539, 1.08, 1.52, 0
1540, 1.08, 1.56, 0
1541, 1.12, 1.44, 0
1542, 1.12, 1.48, 0
1543, 1.12, 1.52, 0
1544, 1.12, 1.56, 0
1545, 1.16, 1.44, 0
1546, 1.16, 1.48, 0
1547, 1.16, 1.52, 0
1548, 1.16, 1.56, 0
1549, 1.2, 1.44, 0.125
1550, 1.2, 1.48, 0.125
1551, 1.2, 1.52, 0.125
1552, 1.2, 1.56, 0.125
1553, 1.2, 1.44, 0.25
1554, 1.2, 1.48, 0.25
1555, 1.2, 1.52, 0.25
1556, 1.2, 1.56, 0.25
1557, 1.2, 1.44, 0.375
1558, 1.2, 1.48, 0.375
1559, 1.2, 1.52, 0.375
1560, 1.2, 1.56, 0.375
1561, 1.04, 1.6, 0.125
1562, 1.08, 1.6, 0.125
1563, 1.12, 1.6, 0.125
1564, 1.16, 1.6, 0.125
1565, 1.04, 1.6, 0.25
1566, 1.08, 1.6, 0.25
1567, 1.12, 1.6, 0.25
1568, 1.16, 1.6, 0.25
1569, 1.04, 1.6, 0.375
1570, 1.08, 1.6, 0.375
1571, 1.12, 1.6, 0.375
1572, 1.16, 1.6, 0.375
1573, 1.3428571428571, 1.44, 0.5
1574, 1.3428571428571, 1.48, 0.5
1575, 1.3428571428571, 1.52, 0.5
1576, 1.3428571428571, 1.56, 0.5
1577, 1.4857142857143, 1.44, 0.5
1578, 1.4857142857143, 1.48, 0.5
1579, 1.4857142857143, 1.52, 0.5
1580, 1.4857142857143, 1.56, 0.5
1581, 1.6285714285714, 1.44, 0.5
1582, 1.6285714285714, 1.48, 0.5
1583, 1.6285714285714, 1.52, 0.5
1584, 1.6285714285714, 1.56, 0.5
1585, 1.7714285714286, 1.44, 0.5
1586, 1.7714285714286, 1.48, 0.5
1587, 1.7714285714286, 1.52, 0.5
1588, 1.7714285714286, 1.56, 0.5
1589, 1.9142857142857, 1.44, 0.5
1590, 1.9142857142857, 1.48, 0.5
1591, 1.9142857142857, 1.52, 0.5
1592, 1.9142857142857, 1.56, 0.5
1593, 2.0571428571429, 1.44, 0.5
1594, 2.0571428571429, 1.48, 0.5
1595, 2.0571428571429, 1.52, 0.5
1596, 2.0571428571429, 1.56, 0.5
1597, 1.3428571428571, 1.44, 0
1598, 1.3428571428571, 1.48, 0
1599, 1.3428571428571, 1.52, 0
1600, 1.3428571428571, 1.56, 0
1601, 1.4857142857143, 1.44, 0
1602, 1.4857142857143, 1.48, 0
1603, 1.4857142857143, 1.52, 0
1604, 1.4857142857143, 1.56, 0
1605, 1.6285714285714, 1.44, 0
1606, 1.6285714285714, 1.48, 0
1607, 1.6285714285714, 1.52, 0
1608, 1.6285714285714, 1.56, 0
1609, 1.7714285714286, 1.44, 0
1610, 1.7714285714286, 1.48, 0
1611, 1.7714285714286, 1.52, 0
1612, 1.7714285714286, 1.56, 0
1613, 1.9142857142857, 1.44, 0
1614, 1.9142857142857, 1.48, 0
1615, 1.9142857142857, 1.52, 0
1616, 1.9142857142857, 1.56, 0
1617, 2.0571428571429, 1.44, 0
1618, 2.0571428571429, 1.48, 0
1619, 2.0571428571429, 1.52, 0
1620, 2.0571428571429, 1.56, 0
1621, 2.2, 1.44, 0.125
1622, 2.2, 1.48, 0.125
1623, 2.2, 1.52, 0.125
1624, 2.2, 1.56, 0.125
1625, 2.2, 1.44, 0.25
1626, 2.2, 1.48, 0.25
1627, 2.2, 1.52, 0.25
1628, 2.2, 1.56, 0.25
1629, 2.2, 1.44, 0.375
1630, 2.2, 1.48, 0.375
1631, 2.2, 1.52, 0.375
1632, 2.2, 1.56, 0.375
1633, 1.3428571428571, 1.6, 0.125
1634, 1.4857142857143, 1.6, 0.125
1635, 1.6285714285714, 1.6, 0.125
1636, 1.7714285714286, 1.6, 0.125
1637, 1.9142857142857, 1.6, 0.125
1638, 2.0571428571429, 1.6, 0.125
1639, 1.3428571428571, 1.6, 0.25
1640, 1.4857142857143, 1.6, 0.25
1641, 1.6285714285714, 1.6, 0.25
1642, 1.7714285714286, 1.6, 0.25
1643, 1.9142857142857, 1.6, 0.25
1644, 2.0571428571429, 1.6, 0.25
1645, 1.3428571428571, 1.6, 0.375
1646, 1.4857142857143, 1.6, 0.375
1647, 1.6285714285714, 1.6, 0.375
1648, 1.7714285714286, 1.6, 0.375
1649, 1.9142857142857, 1.6, 0.375
1650, 2.0571428571429, 1.6, 0.375
1651, 0.14285714285714, -0.04, 0
1652, 0.14285714285714, -0.08, 0
1653, 0.14285714285714, -0.12, 0
1654, 0.14285714285714, -0.16, 0
1655, 0.28571428571429, -0.04, 0
1656, 0.28571428571429, -0.08, 0
1657, 0.28571428571429, -0.12, 0
1658, 0.28571428571429, -0.16, 0
1659, 0.42857142857143, -0.04, 0
1660, 0.42857142857143, -0.08, 0
1661, 0.42857142857143, -0.12, 0
1662, 0.42857142857143, -0.16, 0
1663, 0.57142857142857, -0.04, 0
1664, 0.57142857142857, -0.08, 0
1665, 0.57142857142857, -0.12, 0
1666, 0.57142857142857, -0.16, 0
1667, 0.71428571428571, -0.04, 0
1668, 0.71428571428571, -0.08, 0
1669, 0.71428571428571, -0.12, 0
1670, 0.71428571428571, -0.16, 0
1671, 0.85714285714286, -0.04, 0
1672, 0.85714285714286, -0.08, 0
1673, 0.85714285714286, -0.12, 0
1674, 0.85714285714286, -0.16, 0
1675, 1, -0.04, 0.125
1676, 1, -0.08, 0.125
1677, 1, -0.12, 0.125
1678, 1, -0.16, 0.125
1679, 1, -0.04, 0.25
1680, 1, -0.08, 0.25
1681, 1, -0.12, 0.25
1682, 1, -0.16, 0.25
1683, 1, -0.04, 0.375
1684, 1, -0.08, 0.375
1685, 1, -0.12, 0.375
1686, 1, -0.16, 0.375
1687, 0.14285714285714, -0.04, 0.5
1688, 0.14285714285714, -0.08, 0.5
1689, 0.14285714285714, -0.12, 0.5
1690, 0.14285714285714, -0.16, 0.5
1691, 0.28571428571429, -0.04, 0.5
1692, 0.28571428571429, -0.08, 0.5
1693, 0.28571428571429, -0.12, 0.5
1694, 0.28571428571429, -0.16, 0.5
1695, 0.42857142857143, -0.04, 0.5
1696, 0.42857142857143, -0.08, 0.5
1697, 0.42857142857143, -0.12, 0.5
1698, 0.42857142857143, -0.16, 0.5
1699, 0.57142857142857, -0.04, 0.5
1700, 0.57142857142857, -0.08, 0.5
1701, 0.57142857142857, -0.12, 0.5
1702, 0.57142857142857, -0.16, 0.5
1703, 0.71428571428571, -0.04, 0.5
1704, 0.71428571428571, -0.08, 0.5
1705, 0.71428571428571, -0.12, 0.5
1706, 0.71428571428571, -0.16, 0.5
1707, 0.85714285714286, -0.04, 0.5
1708, 0.85714285714286, -0.08, 0.5
1709, 0.85714285714286, -0.12, 0.5
1710, 0.85714285714286, -0.16, 0.5
1711, 0, -0.04, 0.125
1712, 0, -0.08, 0.125
1713, 0, -0.12, 0.125
1714, 0, -0.16, 0.125
1715, 0, -0.04, 0.25
1716, 0, -0.08, 0.25
1717, 0, -0.12, 0.25
1718, 0, -0.16, 0.25
1719, 0, -0.04, 0.375
1720, 0, -0.08, 0.375
1721, 0, -0.12, 0.375
1722, 0, -0.16, 0.375
1723, 0.14285714285714, -0.2, 0.125
1724, 0.14285714285714, -0.2, 0.25
1725, 0.14285714285714, -0.2, 0.375
1726, 0.28571428571429, -0.2, 0.125
1727, 0.28571428571429, -0.2, 0.25
1728, 0.28571428571429, -0.2, 0.375
1729, 0.42857142857143, -0.2, 0.125
1730, 0.42857142857143, -0.2, 0.25
1731, 0.42857142857143, -0.2, 0.375
1732, 0.57142857142857, -0.2, 0.125
1733, 0.57142857142857, -0.2, 0.25
1734, 0.57142857142857, -0.2, 0.375
1735, 0.71428571428571, -0.2, 0.125
1736, 0.71428571428571, -0.2, 0.25
1737, 0.71428571428571, -0.2, 0.375
1738, 0.85714285714286, -0.2, 0.125
1739, 0.85714285714286, -0.2, 0.25
1740, 0.85714285714286, -0.2, 0.375
1741, -0.1, -0.04, 0.125
1742, -0.1, -0.08, 0.125
1743, -0.1, -0.12, 0.125
1744, -0.1, -0.16, 0.125
1745, -0.1, -0.04, 0.25
1746, -0.1, -0.08, 0.25
1747, -0.1, -0.12, 0.25
1748, -0.1, -0.16, 0.25
1749, -0.1, -0.04, 0.375
1750, -0.1, -0.08, 0.375
1751, -0.1, -0.12, 0.375
1752, -0.1, -0.16, 0.375
1753, 1.3428571428571, -0.04, 0.5
1754, 1.3428571428571, -0.08, 0.5
1755, 1.3428571428571, -0.12, 0.5
1756, 1.3428571428571, -0.16, 0.5
1757, 1.4857142857143, -0.04, 0.5
1758, 1.4857142857143, -0.08, 0.5
1759, 1.4857142857143, -0.12, 0.5
1760, 1.4857142857143, -0.16, 0.5
1761, 1.6285714285714, -0.04, 0.5
1762, 1.6285714285714, -0.08, 0.5
1763, 1.6285714285714, -0.12, 0.5
1764, 1.6285714285714, -0.16, 0.5
1765, 1.7714285714286, -0.04, 0.5
1766, 1.7714285714286, -0.08, 0.5
1767, 1.7714285714286, -0.12, 0.5
1768, 1.7714285714286, -0.16, 0.5
1769, 1.9142857142857, -0.04, 0.5
1770, 1.9142857142857, -0.08, 0.5
1771, 1.9142857142857, -0.12, 0.5
1772, 1.9142857142857, -0.16, 0.5
1773, 2.0571428571429, -0.04, 0.5
1774, 2.0571428571429, -0.08, 0.5
1775, 2.0571428571429, -0.12, 0.5
1776, 2.0571428571429, -0.16, 0.5
1777, 1.3428571428571, -0.04, 0
1778, 1.3428571428571, -0.08, 0
1779, 1.3428571428571, -0.12, 0
1780, 1.3428571428571, -0.16, 0
1781, 1.4857142857143, -0.04, 0
1782, 1.4857142857143, -0.08, 0
1783, 1.4857142857143, -0.12, 0
1784, 1.4857142857143, -0.16, 0
1785, 1.6285714285714, -0.04, 0
1786, 1.6285714285714, -0.08, 0
1787, 1.6285714285714, -0.12, 0
1788, 1.6285714285714, -0.16, 0
1789, 1.7714285714286, -0.04, 0
1790, 1.7714285714286, -0.08, 0
1791, 1.7714285714286, -0.12, 0
1792, 1.7714285714286, -0.16, 0
1793, 1.9142857142857, -0.04, 0
1794, 1.9142857142857, -0.08, 0
1795, 1.9142857142857, -0.12, 0
1796, 1.9142857142857, -0.16, 0
1797, 2.0571428571429, -0.04, 0
1798, 2.0571428571429, -0.08, 0
1799, 2.0571428571429, -0.12, 0
1800, 2.0571428571429, -0.16, 0
1801, 1.2, -0.04, 0.125
1802, 1.2, -0.08, 0.125
1803, 1.2, -0.12, 0.125
1804, 1.2, -0.16, 0.125
1805, 1.2, -0.04, 0.25
1806, 1.2, -0.08, 0.25
1807, 1.2, -0.12, 0.25
1808, 1.2, -0.16, 0.25
1809, 1.2, -0.04, 0.375
1810, 1.2, -0.08, 0.375
1811, 1.2, -0.12, 0.375
1812, 1.2, -0.16, 0.375
1813, 2.2, -0.04, 0.125
1814, 2.2, -0.08, 0.125
1815, 2.2, -0.12, 0.125
1816, 2.2, -0.16, 0.125
1817, 2.2, -0.04, 0.25
1818, 2.2, -0.08, 0.25
1819, 2.2, -0.12, 0.25
1820, 2.2, -0.16, 0.25
1821, 2.2, -0.04, 0.375
1822, 2.2, -0.08, 0.375
1823, 2.2, -0.12, 0.375
1824, 2.2, -0.16, 0.375
1825, 1.3428571428571, -0.2, 0.125
1826, 1.4857142857143, -0.2, 0.125
1827, 1.6285714285714, -0.2, 0.125
1828, 1.7714285714286, -0.2, 0.125
1829, 1.9142857142857, -0.2, 0.125
1830, 2.0571428571429, -0.2, 0.125
1831, 1.3428571428571, -0.2, 0.25
1832, 1.4857142857143, -0.2, 0.25
1833, 1.6285714285714, -0.2, 0.25
1834, 1.7714285714286, -0.2, 0.25
1835, 1.9142857142857, -0.2, 0.25
1836, 2.0571428571429, -0.2, 0.25
1837, 1.3428571428571, -0.2, 0.375
1838, 1.4857142857143, -0.2, 0.375
1839, 1.6285714285714, -0.2, 0.375
1840, 1.7714285714286, -0.2, 0.375
1841, 1.9142857142857, -0.2, 0.375
1842, 2.0571428571429, -0.2, 0.375
1843, 2.3, -0.04, 0.125
1844, 2.3, -0.08, 0.125
1845, 2.3, -0.12, 0.125
1846, 2.3, -0.16, 0.125
1847, 2.3, -0.04, 0.25
1848, 2.3, -0.08, 0.25
1849, 2.3, -0.12, 0.25
1850, 2.3, -0.16, 0.25
1851, 2.3, -0.04, 0.375
1852, 2.3, -0.08, 0.375
1853, 2.3, -0.12, 0.375
1854, 2.3, -0.16, 0.375
1855, 0.14285714285714, 0.016666666666667, 0.125
1856, 0.28571428571429, 0.016666666666667, 0.125
1857, 0.42857142857143, 0.016666666666667, 0.125
1858, 0.57142857142857, 0.016666666666667, 0.125
1859, 0.71428571428571, 0.016666666666667, 0.125
1860, 0.85714285714286, 0.016666666666667, 0.125
1861, 0.14285714285714, 0.033333333333333, 0.125
1862, 0.28571428571429, 0.033333333333333, 0.125
1863, 0.42857142857143, 0.033333333333333, 0.125
1864, 0.57142857142857, 0.033333333333333, 0.125
1865, 0.71428571428571, 0.033333333333333, 0.125
1866, 0.85714285714286, 0.033333333333333, 0.125
1867, 0.14285714285714, 0.016666666666667, 0.25
1868, 0.28571428571429, 0.016666666666667, 0.25
1869, 0.42857142857143, 0.016666666666667, 0.25
1870, 0.57142857142857, 0.016666666666667, 0.25
1871, 0.71428571428571, 0.016666666666667, 0.25
1872, 0.85714285714286, 0.016666666666667, 0.25
1873, 0.14285714285714, 0.033333333333333, 0.25
1874, 0.28571428571429, 0.033333333333333, 0.25
1875, 0.42857142857143, 0.033333333333333, 0.25
1876, 0.57142857142857, 0.033333333333333, 0.25
1877, 0.71428571428571, 0.033333333333333, 0.25
1878, 0.85714285714286, 0.033333333333333, 0.25
1879, 0.14285714285714, 0.016666666666667, 0.375
1880, 0.28571428571429, 0.016666666666667, 0.375
1881, 0.42857142857143, 0.016666666666667, 0.375
1882, 0.57142857142857, 0.016666666666667, 0.375
1883, 0.71428571428571, 0.016666666666667, 0.375
1884, 0.85714285714286, 0.016666666666667, 0.375
1885, 0.14285714285714, 0.033333333333333, 0.375
1886, 0.28571428571429, 0.033333333333333, 0.375
1887, 0.42857142857143, 0.033333333333333, 0.375
1888, 0.57142857142857, 0.033333333333333, 0.375
1889, 0.71428571428571, 0.033333333333333, 0.375
1890, 0.85714285714286, 0.033333333333333, 0.375
1891, 0.14285714285714, 0.27142857142857, 0.125
1892, 0.14285714285714, 0.44285714285714, 0.125
1893, 0.14285714285714, 0.61428571428571, 0.125
1894, 0.14285714285714, 0.78571428571429, 0.125
1895, 0.14285714285714, 0.95714285714286, 0.125
1896, 0.14285714285714, 1.1285714285714, 0.125
1897, 0.14285714285714, 0.27142857142857, 0.25
1898, 0.14285714285714, 0.44285714285714, 0.25
1899, 0.14285714285714, 0.61428571428571, 0.25
1900, 0.14285714285714, 0.78571428571429, 0.25
1901, 0.14285714285714, 0.95714285714286, 0.25
1902, 0.14285714285714, 1.1285714285714, 0.25
1903, 0.14285714285714, 0.27142857142857, 0.375
1904, 0.14285714285714, 0.44285714285714, 0.375
1905, 0.14285714285714, 0.61428571428571, 0.375
1906, 0.14285714285714, 0.78571428571429, 0.375
1907, 0.14285714285714, 0.95714285714286, 0.375
1908, 0.14285714285714, 1.1285714285714, 0.375
1909, 0.28571428571429, 0.27142857142857, 0.125
1910, 0.28571428571429, 0.44285714285714, 0.125
1911, 0.28571428571429, 0.61428571428571, 0.125
1912, 0.28571428571429, 0.78571428571429, 0.125
1913, 0.28571428571429, 0.95714285714286, 0.125
1914, 0.28571428571429, 1.1285714285714, 0.125
1915, 0.28571428571429, 0.27142857142857, 0.25
1916, 0.28571428571429, 0.44285714285714, 0.25
1917, 0.28571428571429, 0.61428571428571, 0.25
1918, 0.28571428571429, 0.78571428571429, 0.25
1919, 0.28571428571429, 0.95714285714286, 0.25
1920, 0.28571428571429, 1.1285714285714, 0.25
1921, 0.28571428571429, 0.27142857142857, 0.375
1922, 0.28571428571429, 0.44285714285714, 0.375
1923, 0.28571428571429, 0.61428571428571, 0.375
1924, 0.28571428571429, 0.78571428571429, 0.375
1925, 0.28571428571429, 0.95714285714286, 0.375
1926, 0.28571428571429, 1.1285714285714, 0.375
1927, 0.42857142857143, 0.27142857142857, 0.125
1928, 0.42857142857143, 0.44285714285714, 0.125
1929, 0.42857142857143, 0.61428571428571, 0.125
1930, 0.42857142857143, 0.78571428571429, 0.125
1931, 0.42857142857143, 0.95714285714286, 0.125
1932, 0.42857142857143, 1.1285714285714, 0.125
1933, 0.42857142857143, 0.27142857142857, 0.25
1934, 0.42857142857143, 0.44285714285714, 0.25
1935, 0.42857142857143, 0.61428571428571, 0.25
1936, 0.42857142857143, 0.78571428571429, 0.25
1937, 0.42857142857143, 0.95714285714286, 0.25
1938, 0.42857142857143, 1.1285714285714, 0.25
1939, 0.42857142857143, 0.27142857142857, 0.375
1940, 0.42857142857143, 0.44285714285714, 0.375
1941, 0.42857142857143, 0.61428571428571, 0.375
1942, 0.42857142857143, 0.78571428571429, 0.375
1943, 0.42857142857143, 0.95714285714286, 0.375
1944, 0.42857142857143, 1.1285714285714, 0.375
1945, 0.57142857142857, 0.27142857142857, 0.125
1946, 0.57142857142857, 0.44285714285714, 0.125
1947, 0.57142857142857, 0.61428571428571, 0.125
1948, 0.57142857142857, 0.78571428571429, 0.125
1949, 0.57142857142857, 0.95714285714286, 0.125
1950, 0.57142857142857, 1.1285714285714, 0.125
1951, 0.57142857142857, 0.27142857142857, 0.25
1952, 0.57142857142857, 0.44285714285714, 0.25
1953, 0.57142857142857, 0.61428571428571, 0.25
1954, 0.57142857142857, 0.78571428571429, 0.25
1955, 0.57142857142857, 0.95714285714286, 0.25
1956, 0.57142857142857, 1.1285714285714, 0.25
1957, 0.57142857142857, 0.27142857142857, 0.375
1958, 0.57142857142857, 0.44285714285714, 0.375
1959, 0.57142857142857, 0.61428571428571, 0.375
1960, 0.57142857142857, 0.78571428571429, 0.375
1961, 0.57142857142857, 0.95714285714286, 0.375
1962, 0.57142857142857, 1.1285714285714, 0.375
1963, 0.71428571428571, 0.27142857142857, 0.125
1964, 0.71428571428571, 0.44285714285714, 0.125
1965, 0.71428571428571, 0.61428571428571, 0.125
1966, 0.71428571428571, 0.78571428571429, 0.125
1967, 0.71428571428571, 0.95714285714286, 0.125
1968, 0.71428571428571, 1.1285714285714, 0.125
1969, 0.71428571428571, 0.27142857142857, 0.25
1970, 0.71428571428571, 0.44285714285714, 0.25
1971, 0.71428571428571, 0.61428571428571, 0.25
1972, 0.71428571428571, 0.78571428571429, 0.25
1973, 0.71428571428571, 0.95714285714286, 0.25
1974, 0.71428571428571, 1.1285714285714, 0.25
1975, 0.71428571428571, 0.27142857142857, 0.375
1976, 0.71428571428571, 0.44285714285714, 0.375
1977, 0.71428571428571, 0.61428571428571, 0.375
1978, 0.71428571428571, 0.78571428571429, 0.375
1979, 0.71428571428571, 0.95714285714286, 0.375
1980, 0.71428571428571, 1.1285714285714, 0.375
1981, 0.85714285714286, 0.27142857142857, 0.125
1982, 0.85714285714286, 0.44285714285714, 0.125
1983, 0.85714285714286, 0.61428571428571, 0.125
1984, 0.85714285714286, 0.78571428571429, 0.125
1985, 0.85714285714286, 0.95714285714286, 0.125
1986, 0.85714285714286, 1.1285714285714, 0.125
1987, 0.85714285714286, 0.27142857142857, 0.25
1988, 0.85714285714286, 0.44285714285714, 0.25
1989, 0.85714285714286, 0.61428571428571, 0.25
1990, 0.85714285714286, 0.78571428571429, 0.25
1991, 0.85714285714286, 0.95714285714286, 0.25
1992, 0.85714285714286, 1.1285714285714, 0.25
1993, 0.85714285714286, 0.27142857142857, 0.375
1994, 0.85714285714286, 0.44285714285714, 0.375
1995, 0.85714285714286, 0.61428571428571, 0.375
1996, 0.85714285714286, 0.78571428571429, 0.375
1997, 0.85714285714286, 0.95714285714286, 0.375
1998, 0.85714285714286, 1.1285714285714, 0.375
1999, 0.14285714285714, 1.3666666666667, 0.125
2000, 0.14285714285714, 1.3833333333333, 0.125
2001, 0.14285714285714, 1.3666666666667, 0.25
2002, 0.14285714285714, 1.3833333333333, 0.25
2003, 0.14285714285714, 1.3666666666667, 0.375
2004, 0.14285714285714, 1.3833333333333, 0.375
2005, 0.28571428571429, 1.3666666666667, 0.125
2006, 0.28571428571429, 1.3833333333333, 0.125
2007, 0.28571428571429, 1.3666666666667, 0.25
2008, 0.28571428571429, 1.3833333333333, 0.25
2009, 0.28571428571429, 1.3666666666667, 0.375
2010, 0.28571428571429, 1.3833333333333, 0.375
2011, 0.42857142857143, 1.3666666666667, 0.125
2012, 0.42857142857143, 1.3833333333333, 0.125
2013, 0.42857142857143, 1.3666666666667, 0.25
2014, 0.42857142857143, 1.3833333333333, 0.25
2015, 0.42857142857143, 1.3666666666667, 0.375
2016, 0.42857142857143, 1.3833333333333, 0.375
2017, 0.57142857142857, 1.3666666666667, 0.125
2018, 0.57142857142857, 1.3833333333333, 0.125
2019, 0.57142857142857, 1.3666666666667, 0.25
2020, 0.57142857142857, 1.3833333333333, 0.25
2021, 0.57142857142857, 1.3666666666667, 0.375
2022, 0.57142857142857, 1.3833333333333, 0.375
2023, 0.71428571428571, 1.3666666666667, 0.125
2024, 0.71428571428571, 1.3833333333333, 0.125
2025, 0.71428571428571, 1.3666666666667, 0.25
2026, 0.71428571428571, 1.3833333333333, 0.25
2027, 0.71428571428571, 1.3666666666667, 0.375
2028, 0.71428571428571, 1.3833333333333, 0.375
2029, 0.85714285714286, 1.3666666666667, 0.125
2030, 0.85714285714286, 1.3833333333333, 0.125
2031, 0.85714285714286, 1.3666666666667, 0.25
2032, 0.85714285714286, 1.3833333333333, 0.25
2033, 0.85714285714286, 1.3666666666667, 0.375
2034, 0.85714285714286, 1.3833333333333, 0.375
2035, 1.04, 1.3666666666667, 0.125
2036, 1.08, 1.3666666666667, 0.125
2037, 1.12, 1.3666666666667, 0.125
2038, 1.16, 1.3666666666667, 0.125
2039, 1.04, 1.3833333333333, 0.125
2040, 1.08, 1.3833333333333, 0.125
2041, 1.12, 1.3833333333333, 0.125
2042, 1.16, 1.3833333333333, 0.125
2043, 1.04, 1.3666666666667, 0.25
2044, 1.08, 1.3666666666667, 0.25
2045, 1.12, 1.3666666666667, 0.25
2046, 1.16, 1.3666666666667, 0.25
2047, 1.04, 1.3833333333333, 0.25
2048, 1.08, 1.3833333333333, 0.25
2049, 1.12, 1.3833333333333, 0.25
2050, 1.16, 1.3833333333333, 0.25
2051, 1.04, 1.3666666666667, 0.375
2052, 1.08, 1.3666666666667, 0.375
2053, 1.12, 1.3666666666667, 0.375
2054, 1.16, 1.3666666666667, 0.375
2055, 1.04, 1.3833333333333, 0.375
2056, 1.08, 1.3833333333333, 0.375
2057, 1.12, 1.3833333333333, 0.375
2058, 1.16, 1.3833333333333, 0.375
2059, 1.3428571428571, 1.3666666666667, 0.125
2060, 1.4857142857143, 1.3666666666667, 0.125
2061, 1.6285714285714, 1.3666666666667, 0.125
2062, 1.7714285714286, 1.3666666666667, 0.125
2063, 1.9142857142857, 1.3666666666667, 0.125
2064, 2.0571428571429, 1.3666666666667, 0.125
2065, 1.3428571428571, 1.3833333333333, 0.125
2066, 1.4857142857143, 1.3833333333333, 0.125
2067, 1.6285714285714, 1.3833333333333, 0.125
2068, 1.7714285714286, 1.3833333333333, 0.125
2069, 1.9142857142857, 1.3833333333333, 0.125
2070, 2.0571428571429, 1.3833333333333, 0.125
2071, 1.3428571428571, 1.3666666666667, 0.25
2072, 1.4857142857143, 1.3666666666667, 0.25
2073, 1.6285714285714, 1.3666666666667, 0.25
2074, 1.7714285714286, 1.3666666666667, 0.25
2075, 1.9142857142857, 1.3666666666667, 0.25
2076, 2.0571428571429, 1.3666666666667, 0.25
2077, 1.3428571428571, 1.3833333333333, 0.25
2078, 1.4857142857143, 1.3833333333333, 0.25
2079, 1.6285714285714, 1.3833333333333, 0.25
2080, 1.7714285714286, 1.3833333333333, 0.25
2081, 1.9142857142857, 1.3833333333333, 0.25
2082, 2.0571428571429, 1.3833333333333, 0.25
2083, 1.3428571428571, 1.3666666666667, 0.375
2084, 1.4857142857143, 1.3666666666667, 0.375
2085, 1.6285714285714, 1.3666666666667, 0.375
2086, 1.7714285714286, 1.3666666666667, 0.375
2087, 1.9142857142857, 1.3666666666667, 0.375
2088, 2.0571428571429, 1.3666666666667, 0.375
2089, 1.3428571428571, 1.3833333333333, 0.375
2090, 1.4857142857143, 1.3833333333333, 0.375
2091, 1.6285714285714, 1.3833333333333, 0.375
2092, 1.7714285714286, 1.3833333333333, 0.375
2093, 1.9142857142857, 1.3833333333333, 0.375
2094, 2.0571428571429, 1.3833333333333, 0.375
2095, 1.3428571428571, 1.1285714285714, 0.125
2096, 1.3428571428571, 0.95714285714286, 0.125
2097, 1.3428571428571, 0.78571428571429, 0.125
2098, 1.3428571428571, 0.61428571428571, 0.125
2099, 1.3428571428571, 0.44285714285714, 0.125
2100, 1.3428571428571, 0.27142857142857, 0.125
2101, 1.4857142857143, 1.1285714285714, 0.125
2102, 1.4857142857143, 0.95714285714286, 0.125
2103, 1.4857142857143, 0.78571428571429, 0.125
2104, 1.4857142857143, 0.61428571428571, 0.125
2105, 1.4857142857143, 0.44285714285714, 0.125
2106, 1.4857142857143, 0.27142857142857, 0.125
2107, 1.6285714285714, 1.1285714285714, 0.125
2108, 1.6285714285714, 0.95714285714286, 0.125
2109, 1.6285714285714, 0.78571428571429, 0.125
2110, 1.6285714285714, 0.61428571428571, 0.125
2111, 1.6285714285714, 0.44285714285714, 0.125
2112, 1.6285714285714, 0.27142857142857, 0.125
2113, 1.7714285714286, 1.1285714285714, 0.125
2114, 1.7714285714286, 0.95714285714286, 0.125
2115, 1.7714285714286, 0.78571428571429, 0.125
2116, 1.7714285714286, 0.61428571428571, 0.125
2117, 1.7714285714286, 0.44285714285714, 0.125
2118, 1.7714285714286, 0.27142857142857, 0.125
2119, 1.9142857142857, 1.1285714285714, 0.125
2120, 1.9142857142857, 0.95714285714286, 0.125
2121, 1.9142857142857, 0.78571428571429, 0.125
2122, 1.9142857142857, 0.61428571428571, 0.125
2123, 1.9142857142857, 0.44285714285714, 0.125
2124, 1.9142857142857, 0.27142857142857, 0.125
2125, 2.0571428571429, 1.1285714285714, 0.125
2126, 2.0571428571429, 0.95714285714286, 0.125
2127, 2.0571428571429, 0.78571428571429, 0.125
2128, 2.0571428571429, 0.61428571428571, 0.125
2129, 2.0571428571429, 0.44285714285714, 0.125
2130, 2.0571428571429, 0.27142857142857, 0.125
2131, 1.3428571428571, 1.1285714285714, 0.25
2132, 1.3428571428571, 0.95714285714286, 0.25
2133, 1.3428571428571, 0.78571428571429, 0.25
2134, 1.3428571428571, 0.61428571428571, 0.25
2135, 1.3428571428571, 0.44285714285714, 0.25
2136, 1.3428571428571, 0.27142857142857, 0.25
2137, 1.4857142857143, 1.1285714285714, 0.25
2138, 1.4857142857143, 0.95714285714286, 0.25
2139, 1.4857142857143, 0.78571428571429, 0.25
2140, 1.4857142857143, 0.61428571428571, 0.25
2141, 1.4857142857143, 0.44285714285714, 0.25
2142, 1.4857142857143, 0.27142857142857, 0.25
2143, 1.6285714285714, 1.1285714285714, 0.25
2144, 1.6285714285714, 0.95714285714286, 0.25
2145, 1.6285714285714, 0.78571428571429, 0.25
2146, 1.6285714285714, 0.61428571428571, 0.25
2147, 1.6285714285714, 0.44285714285714, 0.25
2148, 1.6285714285714, 0.27142857142857, 0.25
2149, 1.7714285714286, 1.1285714285714, 0.25
2150, 1.7714285714286, 0.95714285714286, 0.25
2151, 1.7714285714286, 0.78571428571429, 0.25
2152, 1.7714285714286, 0.61428571428571, 0.25
2153, 1.7714285714286, 0.44285714285714, 0.25
2154, 1.7714285714286, 0.27142857142857, 0.25
2155, 1.9142857142857, 1.1285714285714, 0.25
2156, 1.9142857142857, 0.95714285714286, 0.25
2157, 1.9142857142857, 0.78571428571429, 0.25
2158, 1.9142857142857, 0.61428571428571, 0.25
2159, 1.9142857142857, 0.44285714285714, 0.25
2160, 1.9142857142857, 0.27142857142857, 0.25
2161, 2.0571428571429, 1.1285714285714, 0.25
2162, 2.0571428571429, 0.95714285714286, 0.25
2163, 2.0571428571429, 0.78571428571429, 0.25
2164, 2.0571428571429, 0.61428571428571, 0.25
2165, 2.0571428571429, 0.44285714285714, 0.25
2166, 2.0571428571429, 0.27142857142857, 0.25
2167, 1.3428571428571, 1.1285714285714, 0.375
2168, 1.3428571428571, 0.95714285714286, 0.375
2169, 1.3428571428571, 0.78571428571429, 0.375
2170, 1.3428571428571, 0.61428571428571, 0.375
2171, 1.3428571428571, 0.44285714285714, 0.375
2172, 1.3428571428571, 0.27142857142857, 0.375
2173, 1.4857142857143, 1.1285714285714, 0.375
2174, 1.4857142857143, 0.95714285714286, 0.375
2175, 1.4857142857143, 0.78571428571429, 0.375
2176, 1.4857142857143, 0.61428571428571, 0.375
2177, 1.4857142857143, 0.44285714285714, 0.375
2178, 1.4857142857143, 0.27142857142857, 0.375
2179, 1.6285714285714, 1.1285714285714, 0.375
2180, 1.6285714285714, 0.95714285714286, 0.375
2181, 1.6285714285714, 0.78571428571429, 0.375
2182, 1.6285714285714, 0.61428571428571, 0.375
2183, 1.6285714285714, 0.44285714285714, 0.375
2184, 1.6285714285714, 0.27142857142857, 0.375
2185, 1.7714285714286, 1.1285714285714, 0.375
2186, 1.7714285714286, 0.95714285714286, 0.375
2187, 1.7714285714286, 0.78571428571429, 0.375
2188, 1.7714285714286, 0.61428571428571, 0.375
2189, 1.7714285714286, 0.44285714285714, 0.375
2190, 1.7714285714286, 0.27142857142857, 0.375
2191, 1.9142857142857, 1.1285714285714, 0.375
2192, 1.9142857142857, 0.95714285714286, 0.375
2193, 1.9142857142857, 0.78571428571429, 0.375
2194, 1.9142857142857, 0.61428571428571, 0.375
2195, 1.9142857142857, 0.44285714285714, 0.375
2196, 1.9142857142857, 0.27142857142857, 0.375
2197, 2.0571428571429, 1.1285714285714, 0.375
2198, 2.0571428571429, 0.95714285714286, 0.375
2199, 2.0571428571429, 0.78571428571429, 0.375
2200, 2.0571428571429, 0.61428571428571, 0.375
2201, 2.0571428571429, 0.44285714285714, 0.375
2202, 2.0571428571429, 0.27142857142857, 0.375
2203, 1.3428571428571, 0.033333333333333, 0.125
2204, 1.3428571428571, 0.016666666666667, 0.125
2205, 1.4857142857143, 0.033333333333333, 0.125
2206, 1.4857142857143, 0.016666666666667, 0.125
2207, 1.6285714285714, 0.033333333333333, 0.125
2208, 1.6285714285714, 0.016666666666667, 0.125
2209, 1.7714285714286, 0.033333333333333, 0.125
2210, 1.7714285714286, 0.016666666666667, 0.125
2211, 1.9142857142857, 0.033333333333333, 0.125
2212, 1.9142857142857, 0.016666666666667, 0.125
2213, 2.0571428571429, 0.033333333333333, 0.125
2214, 2.0571428571429, 0.016666666666667, 0.125
2215, 1.3428571428571, 0.033333333333333, 0.25
2216, 1.3428571428571, 0.016666666666667, 0.25
2217, 1.4857142857143, 0.033333333333333, 0.25
2218, 1.4857142857143, 0.016666666666667, 0.25
2219, 1.6285714285714, 0.033333333333333, 0.25
2220, 1.6285714285714, 0.016666666666667, 0.25
2221, 1.7714285714286, 0.033333333333333, 0.25
2222, 1.7714285714286, 0.016666666666667, 0.25
2223, 1.9142857142857, 0.033333333333333, 0.25
2224, 1.9142857142857, 0.016666666666667, 0.25
2225, 2.0571428571429, 0.033333333333333, 0.25
2226, 2.0571428571429, 0.016666666666667, 0.25
2227, 1.3428571428571, 0.033333333333333, 0.375
2228, 1.3428571428571, 0.016666666666667, 0.375
2229, 1.4857142857143, 0.033333333333333, 0.375
2230, 1.4857142857143, 0.016666666666667, 0.375
2231, 1.6285714285714, 0.033333333333333, 0.375
2232, 1.6285714285714, 0.016666666666667, 0.375
2233, 1.7714285714286, 0.033333333333333, 0.375
2234, 1.7714285714286, 0.016666666666667, 0.375
2235, 1.9142857142857, 0.033333333333333, 0.375
2236, 1.9142857142857, 0.016666666666667, 0.375
2237, 2.0571428571429, 0.033333333333333, 0.375
2238, 2.0571428571429, 0.016666666666667, 0.375
2239, 0.14285714285714, 1.44, 0.125
2240, 0.14285714285714, 1.48, 0.125
2241, 0.14285714285714, 1.52, 0.125
2242, 0.14285714285714, 1.56, 0.125
2243, 0.14285714285714, 1.44, 0.25
2244, 0.14285714285714, 1.48, 0.25
2245, 0.14285714285714, 1.52, 0.25
2246, 0.14285714285714, 1.56, 0.25
2247, 0.14285714285714, 1.44, 0.375
2248, 0.14285714285714, 1.48, 0.375
2249, 0.14285714285714, 1.52, 0.375
2250, 0.14285714285714, 1.56, 0.375
2251, 0.28571428571429, 1.44, 0.125
2252, 0.28571428571429, 1.48, 0.125
2253, 0.28571428571429, 1.52, 0.125
2254, 0.28571428571429, 1.56, 0.125
2255, 0.28571428571429, 1.44, 0.25
2256, 0.28571428571429, 1.48, 0.25
2257, 0.28571428571429, 1.52, 0.25
2258, 0.28571428571429, 1.56, 0.25
2259, 0.28571428571429, 1.44, 0.375
2260, 0.28571428571429, 1.48, 0.375
2261, 0.28571428571429, 1.52, 0.375
2262, 0.28571428571429, 1.56, 0.375
2263, 0.42857142857143, 1.44, 0.125
2264, 0.42857142857143, 1.48, 0.125
2265, 0.42857142857143, 1.52, 0.125
2266, 0.42857142857143, 1.56, 0.125
2267, 0.42857142857143, 1.44, 0.25
2268, 0.42857142857143, 1.48, 0.25
2269, 0.42857142857143, 1.52, 0.25
2270, 0.42857142857143, 1.56, 0.25
2271, 0.42857142857143, 1.44, 0.375
2272, 0.42857142857143, 1.48, 0.375
2273, 0.42857142857143, 1.52, 0.375
2274, 0.42857142857143, 1.56, 0.375
2275, 0.57142857142857, 1.44, 0.125
2276, 0.57142857142857, 1.48, 0.125
2277, 0.57142857142857, 1.52, 0.125
2278, 0.57142857142857, 1.56, 0.125
2279, 0.57142857142857, 1.44, 0.25
2280, 0.57142857142857, 1.48, 0.25
2281, 0.57142857142857, 1.52, 0.25
2282, 0.57142857142857, 1.56, 0.25
2283, 0.57142857142857, 1.44, 0.375
2284, 0.57142857142857, 1.48, 0.375
2285, 0.57142857142857, 1.52, 0.375
2286, 0.57142857142857, 1.56, 0.375
2287, 0.71428571428571, 1.44, 0.125
2288, 0.71428571428571, 1.48, 0.125
2289, 0.71428571428571, 1.52, 0.125
2290, 0.71428571428571, 1.56, 0.125
2291, 0.71428571428571, 1.44, 0.25
2292, 0.71428571428571, 1.48, 0.25
2293, 0.71428571428571, 1.52, 0.25
2294, 0.71428571428571, 1.56, 0.25
2295, 0.71428571428571, 1.44, 0.375
2296, 0.71428571428571, 1.48, 0.375
2297, 0.71428571428571, 1.52, 0.375
2298, 0.71428571428571, 1.56, 0.375
2299, 0.85714285714286, 1.44, 0.125
2300, 0.85714285714286, 1.48, 0.125
2301, 0.85714285714286, 1.52, 0.125
2302, 0.85714285714286, 1.56, 0.125
2303, 0.85714285714286, 1.44, 0.25
2304, 0.85714285714286, 1.48, 0.25
2305, 0.85714285714286, 1.52, 0.25
2306, 0.85714285714286, 1.56, 0.25
2307, 0.85714285714286, 1.44, 0.375
2308, 0.85714285714286, 1.48, 0.375
2309, 0.85714285714286, 1.52, 0.375
2310, 0.85714285714286, 1.56, 0.375
2311, 1.04, 1.44, 0.125
2312, 1.04, 1.48, 0.125
2313, 1.04, 1.52, 0.125
2314, 1.04, 1.56, 0.125
2315, 1.08, 1.44, 0.125
2316, 1.08, 1.48, 0.125
2317, 1.08, 1.52, 0.125
2318, 1.08, 1.56, 0.125
2319, 1.12, 1.44, 0.125
2320, 1.12, 1.48, 0.125
2321, 1.12, 1.52, 0.125
2322, 1.12, 1.56, 0.125
2323, 1.16, 1.44, 0.125
2324, 1.16, 1.48, 0.125
2325, 1.16, 1.52, 0.125
2326, 1.16, 1.56, 0.125
2327, 1.04, 1.44, 0.25
2328, 1.04, 1.48, 0.25
2329, 1.04, 1.52, 0.25
2330, 1.04, 1.56, 0.25
2331, 1.08, 1.44, 0.25
2332, 1.08, 1.48, 0.25
2333, 1.08, 1.52, 0.25
2334, 1.08, 1.56, 0.25
2335, 1.12, 1.44, 0.25
2336, 1.12, 1.48, 0.25
2337, 1.12, 1.52, 0.25
2338, 1.12, 1.56, 0.25
2339, 1.16, 1.44, 0.25
2340, 1.16, 1.48, 0.25
2341, 1.16, 1.52, 0.25
2342, 1.16, 1.56, 0.25
2343, 1.04, 1.44, 0.375
2344, 1.04, 1.48, 0.375
2345, 1.04, 1.52, 0.375
2346, 1.04, 1.56, 0.375
2347, 1.08, 1.44, 0.375
2348, 1.08, 1.48, 0.375
2349, 1.08, 1.52, 0.375
2350, 1.08, 1.56, 0.375
2351, 1.12, 1.44, 0.375
2352, 1.12, 1.48, 0.375
2353, 1.12, 1.52, 0.375
2354, 1.12, 1.56, 0.375
2355, 1.16, 1.44, 0.375
2356, 1.16, 1.48, 0.375
2357, 1.16, 1.52, 0.375
2358, 1.16, 1.56, 0.375
2359, 1.3428571428571, 1.44, 0.125
2360, 1.3428571428571, 1.48, 0.125
2361, 1.3428571428571, 1.52, 0.125
2362, 1.3428571428571, 1.56, 0.125
2363, 1.4857142857143, 1.44, 0.125
2364, 1.4857142857143, 1.48, 0.125
2365, 1.4857142857143, 1.52, 0.125
2366, 1.4857142857143, 1.56, 0.125
2367, 1.6285714285714, 1.44, 0.125
2368, 1.6285714285714, 1.48, 0.125
2369, 1.6285714285714, 1.52, 0.125
2370, 1.6285714285714, 1.56, 0.125
2371, 1.7714285714286, 1.44, 0.125
2372, 1.7714285714286, 1.48, 0.125
2373, 1.7714285714286, 1.52, 0.125
2374, 1.7714285714286, 1.56, 0.125
2375, 1.9142857142857, 1.44, 0.125
2376, 1.9142857142857, 1.48, 0.125
2377, 1.9142857142857, 1.52, 0.125
2378, 1.9142857142857, 1.56, 0.125
2379, 2.0571428571429, 1.44, 0.125
2380, 2.0571428571429, 1.48, 0.125
2381, 2.0571428571429, 1.52, 0.125
2382, 2.0571428571429, 1.56, 0.125
2383, 1.3428571428571, 1.44, 0.25
2384, 1.3428571428571, 1.48, 0.25
2385, 1.3428571428571, 1.52, 0.25
2386, 1.3428571428571, 1.56, 0.25
2387, 1.4857142857143, 1.44, 0.25
2388, 1.4857142857143, 1.48, 0.25
2389, 1.4857142857143, 1.52, 0.25
2390, 1.4857142857143, 1.56, 0.25
2391, 1.6285714285714, 1.44, 0.25
2392, 1.6285714285714, 1.48, 0.25
2393, 1.6285714285714, 1.52, 0.25
2394, 1.6285714285714, 1.56, 0.25
2395, 1.7714285714286, 1.44, 0.25
2396, 1.7714285714286, 1.48, 0.25
2397, 1.7714285714286, 1.52, 0.25
2398, 1.7714285714286, 1.56, 0.25
2399, 1.9142857142857, 1.44, 0.25
2400, 1.9142857142857, 1.48, 0.25
2401, 1.9142857142857, 1.52, 0.25
2402, 1.9142857142857, 1.56, 0.25
2403, 2.0571428571429, 1.44, 0.25
2404, 2.0571428571429, 1.48, 0.25
2405, 2.0571428571429, 1.52, 0.25
2406, 2.0571428571429, 1.56, 0.25
2407, 1.3428571428571, 1.44, 0.375
2408, 1.3428571428571, 1.48, 0.375
2409, 1.3428571428571, 1.52, 0.375
2410, 1.3428571428571, 1.56, 0.375
2411, 1.4857142857143, 1.44, 0.375
2412, 1.4857142857143, 1.48, 0.375
2413, 1.4857142857143, 1.52, 0.375
2414, 1.4857142857143, 1.56, 0.375
2415, 1.6285714285714, 1.44, 0.375
2416, 1.6285714285714, 1.48, 0.375
2417, 1.6285714285714, 1.52, 0.375
2418, 1.6285714285714, 1.56, 0.375
2419, 1.7714285714286, 1.44, 0.375
2420, 1.7714285714286, 1.48, 0.375
2421, 1.7714285714286, 1.52, 0.375
2422, 1.7714285714286, 1.56, 0.375
2423, 1.9142857142857, 1.44, 0.375
2424, 1.9142857142857, 1.48, 0.375
2425, 1.9142857142857, 1.52, 0.375
2426, 1.9142857142857, 1.56, 0.375
2427, 2.0571428571429, 1.44, 0.375
2428, 2.0571428571429, 1.48, 0.375
2429, 2.0571428571429, 1.52, 0.375
2430, 2.0571428571429, 1.56, 0.375
2431, 0.14285714285714, -0.04, 0.125
2432, 0.14285714285714, -0.08, 0.125
2433, 0.14285714285714, -0.12, 0.125
2434, 0.14285714285714, -0.16, 0.125
2435, 0.14285714285714, -0.04, 0.25
2436, 0.14285714285714, -0.08, 0.25
2437, 0.14285714285714, -0.12, 0.25
2438, 0.14285714285714, -0.16, 0.25
2439, 0.14285714285714, -0.04, 0.375
2440, 0.14285714285714, -0.08, 0.375
2441, 0.14285714285714, -0.12, 0.375
2442, 0.14285714285714, -0.16, 0.375
2443, 0.28571428571429, -0.04, 0.125
2444, 0.28571428571429, -0.08, 0.125
2445, 0.28571428571429, -0.12, 0.125
2446, 0.28571428571429, -0.16, 0.125
2447, 0.28571428571429, -0.04, 0.25
2448, 0.28571428571429, -0.08, 0.25
2449, 0.28571428571429, -0.12, 0.25
2450, 0.28571428571429, -0.16, 0.25
2451, 0.28571428571429, -0.04, 0.375
2452, 0.28571428571429, -0.08, 0.375
2453, 0.28571428571429, -0.12, 0.375
2454, 0.28571428571429, -0.16, 0.375
2455, 0.42857142857143, -0.04, 0.125
2456, 0.42857142857143, -0.08, 0.125
2457, 0.42857142857143, -0.12, 0.125
2458, 0.42857142857143, -0.16, 0.125
2459, 0.42857142857143, -0.04, 0.25
2460, 0.42857142857143, -0.08, 0.25
2461, 0.42857142857143, -0.12, 0.25
2462, 0.42857142857143, -0.16, 0.25
2463, 0.42857142857143, -0.04, 0.375
2464, 0.42857142857143, -0.08, 0.375
2465, 0.42857142857143, -0.12, 0.375
2466, 0.42857142857143, -0.16, 0.375
2467, 0.57142857142857, -0.04, 0.125
2468, 0.57142857142857, -0.08, 0.125
2469, 0.57142857142857, -0.12, 0.125
2470, 0.57142857142857, -0.16, 0.125
2471, 0.57142857142857, -0.04, 0.25
2472, 0.57142857142857, -0.08, 0.25
2473, 0.57142857142857, -0.12, 0.25
2474, 0.57142857142857, -0.16, 0.25
2475, 0.57142857142857, -0.04, 0.375
2476, 0.57142857142857, -0.08, 0.375
2477, 0.57142857142857, -0.12, 0.375
2478, 0.57142857142857, -0.16, 0.375
2479, 0.71428571428571, -0.04, 0.125
2480, 0.71428571428571, -0.08, 0.125
2481, 0.71428571428571, -0.12, 0.125
2482, 0.71428571428571, -0.16, 0.125
2483, 0.71428571428571, -0.04, 0.25
2484, 0.71428571428571, -0.08, 0.25
2485, 0.71428571428571, -0.12, 0.25
2486, 0.71428571428571, -0.16, 0.25
2487, 0.71428571428571, -0.04, 0.375
2488, 0.71428571428571, -0.08, 0.375
2489, 0.71428571428571, -0.12, 0.375
2490, 0.71428571428571, -0.16, 0.375
2491, 0.85714285714286, -0.04, 0.125
2492, 0.85714285714286, -0.08, 0.125
2493, 0.85714285714286, -0.12, 0.125
2494, 0.85714285714286, -0.16, 0.125
2495, 0.85714285714286, -0.04, 0.25
2496, 0.85714285714286, -0.08, 0.25
2497, 0.85714285714286, -0.12, 0.25
2498, 0.85714285714286, -0.16, 0.25
2499, 0.85714285714286, -0.04, 0.375
2500, 0.85714285714286, -0.08, 0.375
2501, 0.85714285714286, -0.12, 0.375
2502, 0.85714285714286, -0.16, 0.375
2503, 1.3428571428571, -0.04, 0.125
2504, 1.3428571428571, -0.08, 0.125
2505, 1.3428571428571, -0.12, 0.125
2506, 1.3428571428571, -0.16, 0.125
2507, 1.4857142857143, -0.04, 0.125
2508, 1.4857142857143, -0.08, 0.125
2509, 1.4857142857143, -0.12, 0.125
2510, 1.4857142857143, -0.16, 0.125
2511, 1.6285714285714, -0.04, 0.125
2512, 1.6285714285714, -0.08, 0.125
2513, 1.6285714285714, -0.12, 0.125
2514, 1.6285714285714, -0.16, 0.125
2515, 1.7714285714286, -0.04, 0.125
2516, 1.7714285714286, -0.08, 0.125
2517, 1.7714285714286, -0.12, 0.125
2518, 1.7714285714286, -0.16, 0.125
2519, 1.9142857142857, -0.04, 0.125
2520, 1.9142857142857, -0.08, 0.125
2521, 1.9142857142857, -0.12, 0.125
2522, 1.9142857142857, -0.16, 0.125
2523, 2.0571428571429, -0.04, 0.125
2524, 2.0571428571429, -0.08, 0.125
2525, 2.0571428571429, -0.12, 0.125
2526, 2.0571428571429, -0.16, 0.125
2527, 1.3428571428571, -0.04, 0.25
2528, 1.3428571428571, -0.08, 0.25
2529, 1.3428571428571, -0.12, 0.25
2530, 1.3428571428571, -0.16, 0.25
2531, 1.4857142857143, -0.04, 0.25
2532, 1.4857142857143, -0.08, 0.25
2533, 1.4857142857143, -0.12, 0.25
2534, 1.4857142857143, -0.16, 0.25
2535, 1.6285714285714, -0.04, 0.25
2536, 1.6285714285714, -0.08, 0.25
2537, 1.6285714285714, -0.12, 0.25
2538, 1.6285714285714, -0.16, 0.25
2539, 1.7714285714286, -0.04, 0.25
2540, 1.7714285714286, -0.08, 0.25
2541, 1.7714285714286, -0.12, 0.25
2542, 1.7714285714286, -0.16, 0.25
2543, 1.9142857142857, -0.04, 0.25
2544, 1.9142857142857, -0.08, 0.25
2545, 1.9142857142857, -0.12, 0.25
2546, 1.9142857142857, -0.16, 0.25
2547, 2.0571428571429, -0.04, 0.25
2548, 2.0571428571429, -0.08, 0.25
2549, 2.0571428571429, -0.12, 0.25
2550, 2.0571428571429, -0.16, 0.25
2551, 1.3428571428571, -0.04, 0.375
2552, 1.3428571428571, -0.08, 0.375
2553, 1.3428571428571, -0.12, 0.375
2554, 1.3428571428571, -0.16, 0.375
2555, 1.4857142857143, -0.04, 0.375
2556, 1.4857142857143, -0.08, 0.375
2557, 1.4857142857143, -0.12, 0.375
2558, 1.4857142857143, -0.16, 0.375
2559, 1.6285714285714, -0.04, 0.375
2560, 1.6285714285714, -0.08, 0.375
2561, 1.6285714285714, -0.12, 0.375
2562, 1.6285714285714, -0.16, 0.375
2563, 1.7714285714286, -0.04, 0.375
2564, 1.7714285714286, -0.08, 0.375
2565, 1.7714285714286, -0.12, 0.375
2566, 1.7714285714286, -0.16, 0.375
2567, 1.9142857142857, -0.04, 0.375
2568, 1.9142857142857, -0.08, 0.375
2569, 1.9142857142857, -0.12, 0.375
2570, 1.9142857142857, -0.16, 0.375
2571, 2.0571428571429, -0.04, 0.375
2572, 2.0571428571429, -0.08, 0.375
2573, 2.0571428571429, -0.12, 0.375
2574, 2.0571428571429, -0.16, 0.375
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
97, 2, 97
98, 97, 98
99, 98, 99
100, 99, 1
*ELEMENT, type=T3D2, ELSET=Line2
101, 1, 100
102, 100, 101
103, 101, 3
*ELEMENT, type=T3D2, ELSET=Line3
104, 4, 102
105, 102, 103
106, 103, 104
107, 104, 3
*ELEMENT, type=T3D2, ELSET=Line4
108, 2, 105
109, 105, 106
110, 106, 4
*ELEMENT, type=T3D2, ELSET=Line5
111, 6, 107
112, 107, 108
113, 108, 109
114, 109, 5
*ELEMENT, type=T3D2, ELSET=Line6
115, 5, 110
116, 110, 111
117, 111, 7
*ELEMENT, type=T3D2, ELSET=Line7
118, 8, 112
119, 112, 113
120, 113, 114
121, 114, 7
*ELEMENT, type=T3D2, ELSET=Line8
122, 6, 115
123, 115, 116
124, 116, 8
*ELEMENT, type=T3D2, ELSET=Line9
125, 2, 117
126, 117, 118
127, 118, 119
128, 119, 120
129, 120, 121
130, 121, 122
131, 122, 6
*ELEMENT, type=T3D2, ELSET=Line10
132, 1, 123
133, 123, 124
134, 124, 125
135, 125, 126
136, 126, 127
137, 127, 128
138, 128, 5
*ELEMENT, type=T3D2, ELSET=Line11
139, 4, 129
140, 129, 130
141, 130, 131
142, 131, 132
143, 132, 133
144, 133, 134
145, 134, 8
*ELEMENT, type=T3D2, ELSET=Line12
146, 3, 135
147, 135, 136
148, 136, 137
149, 137, 138
150, 138, 139
151, 139, 140
152, 140, 7
*ELEMENT, type=T3D2, ELSET=Line13
153, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
154, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
155, 10, 141
156, 141, 142
157, 142, 143
158, 143, 144
159, 144, 145
160, 145, 146
161, 146, 9
*ELEMENT, type=T3D2, ELSET=Line16
162, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
163, 9, 147
164, 147, 148
165, 148, 149
166, 149, 11
*ELEMENT, type=T3D2, ELSET=Line18
167, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
168, 12, 150
169, 150, 151
170, 151, 152
171, 152, 153
172, 153, 154
173, 154, 155
174, 155, 11
*ELEMENT, type=T3D2, ELSET=Line20
175, 10, 156
176, 156, 157
177, 157, 158
178, 158, 12
*ELEMENT, type=T3D2, ELSET=Line21
179, 9, 159
180, 159, 160
181, 160, 161
182, 161, 162
183, 162, 163
184, 163, 164
185, 164, 13
*ELEMENT, type=T3D2, ELSET=Line22
186, 10, 165
187, 165, 166
188, 166, 167
189, 167, 168
190, 168, 169
191, 169, 170
192, 170, 14
*ELEMENT, type=T3D2, ELSET=Line23
193, 14, 171
194, 171, 172
195, 172, 173
196, 173, 174
197, 174, 175
198, 175, 176
199, 176, 13
*ELEMENT, type=T3D2, ELSET=Line24
200, 11, 177
201, 177, 178
202, 178, 179
203, 179, 180
204, 180, 181
205, 181, 182
206, 182, 15
*ELEMENT, type=T3D2, ELSET=Line25
207, 13, 183
208, 183, 184
209, 184, 185
210, 185, 15
*ELEMENT, type=T3D2, ELSET=Line26
211, 12, 186
212, 186, 187
213, 187, 188
214, 188, 189
215, 189, 190
216, 190, 191
217, 191, 16
*ELEMENT, type=T3D2, ELSET=Line27
218, 16, 192
219, 192, 193
220, 193, 194
221, 194, 195
222, 195, 196
223, 196, 197
224, 197, 15
*ELEMENT, type=T3D2, ELSET=Line28
225, 14, 198
226, 198, 199
227, 199, 200
228, 200, 16
*ELEMENT, type=T3D2, ELSET=Line29
229, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
230, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
231, 18, 201
232, 201, 202
233, 202, 203
234, 203, 204
235, 204, 205
236, 205, 206
237, 206, 17
*ELEMENT, type=T3D2, ELSET=Line32
238, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
239, 17, 207
240, 207, 208
241, 208, 209
242, 209, 19
*ELEMENT, type=T3D2, ELSET=Line34
243, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
244, 20, 210
245, 210, 211
246, 211, 212
247, 212, 213
248, 213, 214
249, 214, 215
250, 215, 19
*ELEMENT, type=T3D2, ELSET=Line36
251, 18, 216
252, 216, 217
253, 217, 218
254, 218, 20
*ELEMENT, type=T3D2, ELSET=Line37
255, 17, 219
256, 219, 220
257, 220, 21
*ELEMENT, type=T3D2, ELSET=Line38
258, 18, 221
259, 221, 222
260, 222, 22
*ELEMENT, type=T3D2, ELSET=Line39
261, 22, 223
262, 223, 224
263, 224, 225
264, 225, 226
265, 226, 227
266, 227, 228
267, 228, 21
*ELEMENT, type=T3D2, ELSET=Line40
268, 19, 229
269, 229, 230
270, 230, 23
*ELEMENT, type=T3D2, ELSET=Line41
271, 21, 231
272, 231, 232
273, 232, 233
274, 233, 23
*ELEMENT, type=T3D2, ELSET=Line42
275, 20, 234
276, 234, 235
277, 235, 24
*ELEMENT, type=T3D2, ELSET=Line43
278, 24, 236
279, 236, 237
280, 237, 238
281, 238, 239
282, 239, 240
283, 240, 241
284, 241, 23
*ELEMENT, type=T3D2, ELSET=Line44
285, 22, 242
286, 242, 243
287, 243, 244
288, 244, 24
*ELEMENT, type=T3D2, ELSET=Line45
289, 19, 245
290, 245, 246
291, 246, 247
292, 247, 248
293, 248, 25
*ELEMENT, type=T3D2, ELSET=Line46
294, 23, 249
295, 249, 250
296, 250, 251
297, 251, 252
298, 252, 26
*ELEMENT, type=T3D2, ELSET=Line47
299, 25, 253
300, 253, 254
301, 254, 26
*ELEMENT, type=T3D2, ELSET=Line48
302, 17, 255
303, 255, 256
304, 256, 257
305, 257, 258
306, 258, 27
*ELEMENT, type=T3D2, ELSET=Line49
307, 21, 259
308, 259, 260
309, 260, 261
310, 261, 262
311, 262, 28
*ELEMENT, type=T3D2, ELSET=Line50
312, 27, 263
313, 263, 264
314, 264, 28
*ELEMENT, type=T3D2, ELSET=Line51
315, 27, 265
316, 265, 266
317, 266, 267
318, 267, 25
*ELEMENT, type=T3D2, ELSET=Line52
319, 28, 268
320, 268, 269
321, 269, 270
322, 270, 26
*ELEMENT, type=T3D2, ELSET=Line53
323, 25, 271
324, 271, 272
325, 272, 273
326, 273, 274
327, 274, 275
328, 275, 276
329, 276, 29
*ELEMENT, type=T3D2, ELSET=Line54
330, 26, 277
331, 277, 278
332, 278, 279
333, 279, 280
334, 280, 281
335, 281, 282
336, 282, 30
*ELEMENT, type=T3D2, ELSET=Line55
337, 29, 283
338, 283, 284
339, 284, 30
*ELEMENT, type=T3D2, ELSET=Line56
340, 27, 285
341, 285, 286
342, 286, 287
343, 287, 288
344, 288, 289
345, 289, 290
346, 290, 31
*ELEMENT, type=T3D2, ELSET=Line57
347, 28, 291
348, 291, 292
349, 292, 293
350, 293, 294
351, 294, 295
352, 295, 296
353, 296, 32
*ELEMENT, type=T3D2, ELSET=Line58
354, 31, 297
355, 297, 298
356, 298, 32
*ELEMENT, type=T3D2, ELSET=Line59
357, 31, 299
358, 299, 300
359, 300, 301
360, 301, 29
*ELEMENT, type=T3D2, ELSET=Line60
361, 32, 302
362, 302, 303
363, 303, 304
364, 304, 30
*ELEMENT, type=T3D2, ELSET=Line61
365, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
366, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
367, 33, 305
368, 305, 306
369, 306, 307
370, 307, 308
371, 308, 309
372, 309, 310
373, 310, 34
*ELEMENT, type=T3D2, ELSET=Line64
374, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
375, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
376, 35, 311
377, 311, 312
378, 312, 313
379, 313, 314
380, 314, 315
381, 315, 316
382, 316, 36
*ELEMENT, type=T3D2, ELSET=Line67
383, 35, 317
384, 317, 318
385, 318, 319
386, 319, 33
*ELEMENT, type=T3D2, ELSET=Line68
387, 36, 320
388, 320, 321
389, 321, 322
390, 322, 34
*ELEMENT, type=T3D2, ELSET=Line69
391, 33, 323
392, 323, 324
393, 324, 325
394, 325, 326
395, 326, 327
396, 327, 328
397, 328, 37
*ELEMENT, type=T3D2, ELSET=Line70
398, 34, 329
399, 329, 330
400, 330, 331
401, 331, 332
402, 332, 333
403, 333, 334
404, 334, 38
*ELEMENT, type=T3D2, ELSET=Line71
405, 37, 335
406, 335, 336
407, 336, 337
408, 337, 338
409, 338, 339
410, 339, 340
411, 340, 38
*ELEMENT, type=T3D2, ELSET=Line72
412, 35, 341
413, 341, 342
414, 342, 343
415, 343, 344
416, 344, 345
417, 345, 346
418, 346, 39
*ELEMENT, type=T3D2, ELSET=Line73
419, 36, 347
420, 347, 348
421, 348, 349
422, 349, 350
423, 350, 351
424, 351, 352
425, 352, 40
*ELEMENT, type=T3D2, ELSET=Line74
426, 39, 353
427, 353, 354
428, 354, 355
429, 355, 356
430, 356, 357
431, 357, 358
432, 358, 40
*ELEMENT, type=T3D2, ELSET=Line75
433, 39, 359
434, 359, 360
435, 360, 361
436, 361, 37
*ELEMENT, type=T3D2, ELSET=Line76
437, 40, 362
438, 362, 363
439, 363, 364
440, 364, 38
*ELEMENT, type=T3D2, ELSET=Line77
441, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
442, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
443, 41, 365
444, 365, 366
445, 366, 367
446, 367, 368
447, 368, 369
448, 369, 370
449, 370, 42
*ELEMENT, type=T3D2, ELSET=Line80
450, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
451, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
452, 43, 371
453, 371, 372
454, 372, 373
455, 373, 374
456, 374, 375
457, 375, 376
458, 376, 44
*ELEMENT, type=T3D2, ELSET=Line83
459, 43, 377
460, 377, 378
461, 378, 379
462, 379, 41
*ELEMENT, type=T3D2, ELSET=Line84
463, 44, 380
464, 380, 381
465, 381, 382
466, 382, 42
*ELEMENT, type=T3D2, ELSET=Line85
467, 41, 383
468, 383, 384
469, 384, 45
*ELEMENT, type=T3D2, ELSET=Line86
470, 42, 385
471, 385, 386
472, 386, 46
*ELEMENT, type=T3D2, ELSET=Line87
473, 45, 387
474, 387, 388
475, 388, 389
476, 389, 390
477, 390, 391
478, 391, 392
479, 392, 46
*ELEMENT, type=T3D2, ELSET=Line88
480, 43, 393
481, 393, 394
482, 394, 47
*ELEMENT, type=T3D2, ELSET=Line89
483, 44, 395
484, 395, 396
485, 396, 48
*ELEMENT, type=T3D2, ELSET=Line90
486, 47, 397
487, 397, 398
488, 398, 399
489, 399, 400
490, 400, 401
491, 401, 402
492, 402, 48
*ELEMENT, type=T3D2, ELSET=Line91
493, 47, 403
494, 403, 404
495, 404, 405
496, 405, 45
*ELEMENT, type=T3D2, ELSET=Line92
497, 48, 406
498, 406, 407
499, 407, 408
500, 408, 46
*ELEMENT, type=T3D2, ELSET=Line93
501, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
502, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
503, 49, 409
504, 409, 410
505, 410, 50
*ELEMENT, type=T3D2, ELSET=Line96
506, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
507, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
508, 51, 411
509, 411, 412
510, 412, 52
*ELEMENT, type=T3D2, ELSET=Line99
511, 51, 413
512, 413, 414
513, 414, 415
514, 415, 49
*ELEMENT, type=T3D2, ELSET=Line100
515, 52, 416
516, 416, 417
517, 417, 418
518, 418, 50
*ELEMENT, type=T3D2, ELSET=Line101
519, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
520, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
521, 54, 419
522, 419, 420
523, 420, 421
524, 421, 53
*ELEMENT, type=T3D2, ELSET=Line104
525, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
526, 53, 422
527, 422, 423
528, 423, 55
*ELEMENT, type=T3D2, ELSET=Line106
529, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
530, 56, 424
531, 424, 425
532, 425, 426
533, 426, 55
*ELEMENT, type=T3D2, ELSET=Line108
534, 54, 427
535, 427, 428
536, 428, 56
*ELEMENT, type=T3D2, ELSET=Line125
537, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
538, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
539, 57, 429
540, 429, 430
541, 430, 431
542, 431, 432
543, 432, 433
544, 433, 434
545, 434, 58
*ELEMENT, type=T3D2, ELSET=Line128
546, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
547, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
548, 59, 435
549, 435, 436
550, 436, 437
551, 437, 438
552, 438, 439
553, 439, 440
554, 440, 60
*ELEMENT, type=T3D2, ELSET=Line131
555, 59, 441
556, 441, 442
557, 442, 443
558, 443, 57
*ELEMENT, type=T3D2, ELSET=Line132
559, 60, 444
560, 444, 445
561, 445, 446
562, 446, 58
*ELEMENT, type=T3D2, ELSET=Line133
563, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
564, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
565, 61, 447
566, 447, 448
567, 448, 449
568, 449, 450
569, 450, 451
570, 451, 452
571, 452, 62
*ELEMENT, type=T3D2, ELSET=Line136
572, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
573, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
574, 63, 453
575, 453, 454
576, 454, 455
577, 455, 456
578, 456, 457
579, 457, 458
580, 458, 64
*ELEMENT, type=T3D2, ELSET=Line139
581, 63, 459
582, 459, 460
583, 460, 461
584, 461, 61
*ELEMENT, type=T3D2, ELSET=Line140
585, 64, 462
586, 462, 463
587, 463, 464
588, 464, 62
*ELEMENT, type=T3D2, ELSET=Line141
589, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
590, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
591, 65, 465
592, 465, 466
593, 466, 467
594, 467, 468
595, 468, 469
596, 469, 470
597, 470, 66
*ELEMENT, type=T3D2, ELSET=Line144
598, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
599, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
600, 67, 471
601, 471, 472
602, 472, 473
603, 473, 474
604, 474, 475
605, 475, 476
606, 476, 68
*ELEMENT, type=T3D2, ELSET=Line147
607, 67, 477
608, 477, 478
609, 478, 479
610, 479, 480
611, 480, 481
612, 481, 482
613, 482, 65
*ELEMENT, type=T3D2, ELSET=Line148
614, 68, 483
615, 483, 484
616, 484, 485
617, 485, 486
618, 486, 487
619, 487, 488
620, 488, 66
*ELEMENT, type=T3D2, ELSET=Line149
621, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
622, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
623, 69, 489
624, 489, 490
625, 490, 491
626, 491, 492
627, 492, 493
628, 493, 494
629, 494, 70
*ELEMENT, type=T3D2, ELSET=Line152
630, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
631, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
632, 71, 495
633, 495, 496
634, 496, 497
635, 497, 498
636, 498, 499
637, 499, 500
638, 500, 72
*ELEMENT, type=T3D2, ELSET=Line155
639, 69, 501
640, 501, 502
641, 502, 503
642, 503, 504
643, 504, 505
644, 505, 506
645, 506, 71
