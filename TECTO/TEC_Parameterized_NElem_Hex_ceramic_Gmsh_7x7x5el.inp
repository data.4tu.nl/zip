3681, 2135, 2141, 2177, 2171, 2136, 2142, 2178, 2172
3682, 2136, 2142, 2178, 2172, 1223, 1224, 1230, 1229
3683, 1098, 1099, 1105, 1104, 2137, 2143, 2179, 2173
3684, 2137, 2143, 2179, 2173, 2138, 2144, 2180, 2174
3685, 2138, 2144, 2180, 2174, 2139, 2145, 2181, 2175
3686, 2139, 2145, 2181, 2175, 2140, 2146, 2182, 2176
3687, 2140, 2146, 2182, 2176, 2141, 2147, 2183, 2177
3688, 2141, 2147, 2183, 2177, 2142, 2148, 2184, 2178
3689, 2142, 2148, 2184, 2178, 1224, 1225, 1231, 1230
3690, 1099, 1100, 1106, 1105, 2143, 2149, 2185, 2179
3691, 2143, 2149, 2185, 2179, 2144, 2150, 2186, 2180
3692, 2144, 2150, 2186, 2180, 2145, 2151, 2187, 2181
3693, 2145, 2151, 2187, 2181, 2146, 2152, 2188, 2182
3694, 2146, 2152, 2188, 2182, 2147, 2153, 2189, 2183
3695, 2147, 2153, 2189, 2183, 2148, 2154, 2190, 2184
3696, 2148, 2154, 2190, 2184, 1225, 1226, 1232, 1231
3697, 1100, 1101, 1107, 1106, 2149, 2155, 2191, 2185
3698, 2149, 2155, 2191, 2185, 2150, 2156, 2192, 2186
3699, 2150, 2156, 2192, 2186, 2151, 2157, 2193, 2187
3700, 2151, 2157, 2193, 2187, 2152, 2158, 2194, 2188
3701, 2152, 2158, 2194, 2188, 2153, 2159, 2195, 2189
3702, 2153, 2159, 2195, 2189, 2154, 2160, 2196, 2190
3703, 2154, 2160, 2196, 2190, 1226, 1227, 1233, 1232
3704, 1101, 1102, 1108, 1107, 2155, 2161, 2197, 2191
3705, 2155, 2161, 2197, 2191, 2156, 2162, 2198, 2192
3706, 2156, 2162, 2198, 2192, 2157, 2163, 2199, 2193
3707, 2157, 2163, 2199, 2193, 2158, 2164, 2200, 2194
3708, 2158, 2164, 2200, 2194, 2159, 2165, 2201, 2195
3709, 2159, 2165, 2201, 2195, 2160, 2166, 2202, 2196
3710, 2160, 2166, 2202, 2196, 1227, 1228, 1234, 1233
3711, 1102, 321, 322, 1108, 2161, 1205, 1211, 2197
3712, 2161, 1205, 1211, 2197, 2162, 1206, 1212, 2198
3713, 2162, 1206, 1212, 2198, 2163, 1207, 1213, 2199
3714, 2163, 1207, 1213, 2199, 2164, 1208, 1214, 2200
3715, 2164, 1208, 1214, 2200, 2165, 1209, 1215, 2201
3716, 2165, 1209, 1215, 2201, 2166, 1210, 1216, 2202
3717, 2166, 1210, 1216, 2202, 1228, 363, 364, 1234
3718, 319, 1103, 305, 33, 1193, 2167, 1109, 323
3719, 1193, 2167, 1109, 323, 1194, 2168, 1110, 324
3720, 1194, 2168, 1110, 324, 1195, 2169, 1111, 325
3721, 1195, 2169, 1111, 325, 1196, 2170, 1112, 326
3722, 1196, 2170, 1112, 326, 1197, 2171, 1113, 327
3723, 1197, 2171, 1113, 327, 1198, 2172, 1114, 328
3724, 1198, 2172, 1114, 328, 361, 1229, 335, 37
3725, 1103, 1104, 306, 305, 2167, 2173, 1115, 1109
3726, 2167, 2173, 1115, 1109, 2168, 2174, 1116, 1110
3727, 2168, 2174, 1116, 1110, 2169, 2175, 1117, 1111
3728, 2169, 2175, 1117, 1111, 2170, 2176, 1118, 1112
3729, 2170, 2176, 1118, 1112, 2171, 2177, 1119, 1113
3730, 2171, 2177, 1119, 1113, 2172, 2178, 1120, 1114
3731, 2172, 2178, 1120, 1114, 1229, 1230, 336, 335
3732, 1104, 1105, 307, 306, 2173, 2179, 1121, 1115
3733, 2173, 2179, 1121, 1115, 2174, 2180, 1122, 1116
3734, 2174, 2180, 1122, 1116, 2175, 2181, 1123, 1117
3735, 2175, 2181, 1123, 1117, 2176, 2182, 1124, 1118
3736, 2176, 2182, 1124, 1118, 2177, 2183, 1125, 1119
3737, 2177, 2183, 1125, 1119, 2178, 2184, 1126, 1120
3738, 2178, 2184, 1126, 1120, 1230, 1231, 337, 336
3739, 1105, 1106, 308, 307, 2179, 2185, 1127, 1121
3740, 2179, 2185, 1127, 1121, 2180, 2186, 1128, 1122
3741, 2180, 2186, 1128, 1122, 2181, 2187, 1129, 1123
3742, 2181, 2187, 1129, 1123, 2182, 2188, 1130, 1124
3743, 2182, 2188, 1130, 1124, 2183, 2189, 1131, 1125
3744, 2183, 2189, 1131, 1125, 2184, 2190, 1132, 1126
3745, 2184, 2190, 1132, 1126, 1231, 1232, 338, 337
3746, 1106, 1107, 309, 308, 2185, 2191, 1133, 1127
3747, 2185, 2191, 1133, 1127, 2186, 2192, 1134, 1128
3748, 2186, 2192, 1134, 1128, 2187, 2193, 1135, 1129
3749, 2187, 2193, 1135, 1129, 2188, 2194, 1136, 1130
3750, 2188, 2194, 1136, 1130, 2189, 2195, 1137, 1131
3751, 2189, 2195, 1137, 1131, 2190, 2196, 1138, 1132
3752, 2190, 2196, 1138, 1132, 1232, 1233, 339, 338
3753, 1107, 1108, 310, 309, 2191, 2197, 1139, 1133
3754, 2191, 2197, 1139, 1133, 2192, 2198, 1140, 1134
3755, 2192, 2198, 1140, 1134, 2193, 2199, 1141, 1135
3756, 2193, 2199, 1141, 1135, 2194, 2200, 1142, 1136
3757, 2194, 2200, 1142, 1136, 2195, 2201, 1143, 1137
3758, 2195, 2201, 1143, 1137, 2196, 2202, 1144, 1138
3759, 2196, 2202, 1144, 1138, 1233, 1234, 340, 339
3760, 1108, 322, 34, 310, 2197, 1211, 329, 1139
3761, 2197, 1211, 329, 1139, 2198, 1212, 330, 1140
3762, 2198, 1212, 330, 1140, 2199, 1213, 331, 1141
3763, 2199, 1213, 331, 1141, 2200, 1214, 332, 1142
3764, 2200, 1214, 332, 1142, 2201, 1215, 333, 1143
3765, 2201, 1215, 333, 1143, 2202, 1216, 334, 1144
3766, 2202, 1216, 334, 1144, 1234, 364, 38, 340
*ELEMENT, type=C3D8, ELSET=Volume10
3767, 39, 353, 1217, 359, 43, 371, 1235, 377
3768, 353, 354, 1218, 1217, 371, 372, 1236, 1235
3769, 354, 355, 1219, 1218, 372, 373, 1237, 1236
3770, 355, 356, 1220, 1219, 373, 374, 1238, 1237
3771, 356, 357, 1221, 1220, 374, 375, 1239, 1238
3772, 357, 358, 1222, 1221, 375, 376, 1240, 1239
3773, 358, 40, 362, 1222, 376, 44, 380, 1240
3774, 359, 1217, 1223, 360, 377, 1235, 1241, 378
3775, 1217, 1218, 1224, 1223, 1235, 1236, 1242, 1241
3776, 1218, 1219, 1225, 1224, 1236, 1237, 1243, 1242
3777, 1219, 1220, 1226, 1225, 1237, 1238, 1244, 1243
3778, 1220, 1221, 1227, 1226, 1238, 1239, 1245, 1244
3779, 1221, 1222, 1228, 1227, 1239, 1240, 1246, 1245
3780, 1222, 362, 363, 1228, 1240, 380, 381, 1246
3781, 360, 1223, 1229, 361, 378, 1241, 1247, 379
3782, 1223, 1224, 1230, 1229, 1241, 1242, 1248, 1247
3783, 1224, 1225, 1231, 1230, 1242, 1243, 1249, 1248
3784, 1225, 1226, 1232, 1231, 1243, 1244, 1250, 1249
3785, 1226, 1227, 1233, 1232, 1244, 1245, 1251, 1250
3786, 1227, 1228, 1234, 1233, 1245, 1246, 1252, 1251
3787, 1228, 363, 364, 1234, 1246, 381, 382, 1252
3788, 361, 1229, 335, 37, 379, 1247, 365, 41
3789, 1229, 1230, 336, 335, 1247, 1248, 366, 365
3790, 1230, 1231, 337, 336, 1248, 1249, 367, 366
3791, 1231, 1232, 338, 337, 1249, 1250, 368, 367
3792, 1232, 1233, 339, 338, 1250, 1251, 369, 368
3793, 1233, 1234, 340, 339, 1251, 1252, 370, 369
3794, 1234, 364, 38, 340, 1252, 382, 42, 370
*ELEMENT, type=C3D8, ELSET=Volume11
3795, 43, 371, 1235, 377, 393, 1265, 2203, 1277
3796, 393, 1265, 2203, 1277, 394, 1266, 2204, 1278
3797, 394, 1266, 2204, 1278, 47, 397, 1289, 403
3798, 371, 372, 1236, 1235, 1265, 1267, 2205, 2203
3799, 1265, 1267, 2205, 2203, 1266, 1268, 2206, 2204
3800, 1266, 1268, 2206, 2204, 397, 398, 1290, 1289
3801, 372, 373, 1237, 1236, 1267, 1269, 2207, 2205
3802, 1267, 1269, 2207, 2205, 1268, 1270, 2208, 2206
3803, 1268, 1270, 2208, 2206, 398, 399, 1291, 1290
3804, 373, 374, 1238, 1237, 1269, 1271, 2209, 2207
3805, 1269, 1271, 2209, 2207, 1270, 1272, 2210, 2208
3806, 1270, 1272, 2210, 2208, 399, 400, 1292, 1291
3807, 374, 375, 1239, 1238, 1271, 1273, 2211, 2209
3808, 1271, 1273, 2211, 2209, 1272, 1274, 2212, 2210
3809, 1272, 1274, 2212, 2210, 400, 401, 1293, 1292
3810, 375, 376, 1240, 1239, 1273, 1275, 2213, 2211
3811, 1273, 1275, 2213, 2211, 1274, 1276, 2214, 2212
3812, 1274, 1276, 2214, 2212, 401, 402, 1294, 1293
3813, 376, 44, 380, 1240, 1275, 395, 1283, 2213
3814, 1275, 395, 1283, 2213, 1276, 396, 1284, 2214
3815, 1276, 396, 1284, 2214, 402, 48, 406, 1294
3816, 377, 1235, 1241, 378, 1277, 2203, 2215, 1279
3817, 1277, 2203, 2215, 1279, 1278, 2204, 2216, 1280
3818, 1278, 2204, 2216, 1280, 403, 1289, 1295, 404
3819, 1235, 1236, 1242, 1241, 2203, 2205, 2217, 2215
3820, 2203, 2205, 2217, 2215, 2204, 2206, 2218, 2216
3821, 2204, 2206, 2218, 2216, 1289, 1290, 1296, 1295
3822, 1236, 1237, 1243, 1242, 2205, 2207, 2219, 2217
3823, 2205, 2207, 2219, 2217, 2206, 2208, 2220, 2218
3824, 2206, 2208, 2220, 2218, 1290, 1291, 1297, 1296
3825, 1237, 1238, 1244, 1243, 2207, 2209, 2221, 2219
3826, 2207, 2209, 2221, 2219, 2208, 2210, 2222, 2220
3827, 2208, 2210, 2222, 2220, 1291, 1292, 1298, 1297
3828, 1238, 1239, 1245, 1244, 2209, 2211, 2223, 2221
3829, 2209, 2211, 2223, 2221, 2210, 2212, 2224, 2222
3830, 2210, 2212, 2224, 2222, 1292, 1293, 1299, 1298
3831, 1239, 1240, 1246, 1245, 2211, 2213, 2225, 2223
3832, 2211, 2213, 2225, 2223, 2212, 2214, 2226, 2224
3833, 2212, 2214, 2226, 2224, 1293, 1294, 1300, 1299
3834, 1240, 380, 381, 1246, 2213, 1283, 1285, 2225
3835, 2213, 1283, 1285, 2225, 2214, 1284, 1286, 2226
3836, 2214, 1284, 1286, 2226, 1294, 406, 407, 1300
3837, 378, 1241, 1247, 379, 1279, 2215, 2227, 1281
3838, 1279, 2215, 2227, 1281, 1280, 2216, 2228, 1282
3839, 1280, 2216, 2228, 1282, 404, 1295, 1301, 405
3840, 1241, 1242, 1248, 1247, 2215, 2217, 2229, 2227
3841, 2215, 2217, 2229, 2227, 2216, 2218, 2230, 2228
3842, 2216, 2218, 2230, 2228, 1295, 1296, 1302, 1301
3843, 1242, 1243, 1249, 1248, 2217, 2219, 2231, 2229
3844, 2217, 2219, 2231, 2229, 2218, 2220, 2232, 2230
3845, 2218, 2220, 2232, 2230, 1296, 1297, 1303, 1302
3846, 1243, 1244, 1250, 1249, 2219, 2221, 2233, 2231
3847, 2219, 2221, 2233, 2231, 2220, 2222, 2234, 2232
3848, 2220, 2222, 2234, 2232, 1297, 1298, 1304, 1303
3849, 1244, 1245, 1251, 1250, 2221, 2223, 2235, 2233
3850, 2221, 2223, 2235, 2233, 2222, 2224, 2236, 2234
3851, 2222, 2224, 2236, 2234, 1298, 1299, 1305, 1304
3852, 1245, 1246, 1252, 1251, 2223, 2225, 2237, 2235
3853, 2223, 2225, 2237, 2235, 2224, 2226, 2238, 2236
3854, 2224, 2226, 2238, 2236, 1299, 1300, 1306, 1305
3855, 1246, 381, 382, 1252, 2225, 1285, 1287, 2237
3856, 2225, 1285, 1287, 2237, 2226, 1286, 1288, 2238
3857, 2226, 1286, 1288, 2238, 1300, 407, 408, 1306
3858, 379, 1247, 365, 41, 1281, 2227, 1253, 383
3859, 1281, 2227, 1253, 383, 1282, 2228, 1254, 384
3860, 1282, 2228, 1254, 384, 405, 1301, 387, 45
3861, 1247, 1248, 366, 365, 2227, 2229, 1255, 1253
3862, 2227, 2229, 1255, 1253, 2228, 2230, 1256, 1254
3863, 2228, 2230, 1256, 1254, 1301, 1302, 388, 387
3864, 1248, 1249, 367, 366, 2229, 2231, 1257, 1255
3865, 2229, 2231, 1257, 1255, 2230, 2232, 1258, 1256
3866, 2230, 2232, 1258, 1256, 1302, 1303, 389, 388
3867, 1249, 1250, 368, 367, 2231, 2233, 1259, 1257
3868, 2231, 2233, 1259, 1257, 2232, 2234, 1260, 1258
3869, 2232, 2234, 1260, 1258, 1303, 1304, 390, 389
3870, 1250, 1251, 369, 368, 2233, 2235, 1261, 1259
3871, 2233, 2235, 1261, 1259, 2234, 2236, 1262, 1260
3872, 2234, 2236, 1262, 1260, 1304, 1305, 391, 390
3873, 1251, 1252, 370, 369, 2235, 2237, 1263, 1261
3874, 2235, 2237, 1263, 1261, 2236, 2238, 1264, 1262
3875, 2236, 2238, 1264, 1262, 1305, 1306, 392, 391
3876, 1252, 382, 42, 370, 2237, 1287, 385, 1263
3877, 2237, 1287, 385, 1263, 2238, 1288, 386, 1264
3878, 2238, 1288, 386, 1264, 1306, 408, 46, 392
*ELEMENT, type=C3D8, ELSET=Volume12
3879, 44, 380, 1283, 395, 51, 413, 1307, 411
3880, 395, 1283, 1284, 396, 411, 1307, 1308, 412
3881, 396, 1284, 406, 48, 412, 1308, 416, 52
3882, 380, 381, 1285, 1283, 413, 414, 1309, 1307
3883, 1283, 1285, 1286, 1284, 1307, 1309, 1310, 1308
3884, 1284, 1286, 407, 406, 1308, 1310, 417, 416
3885, 381, 382, 1287, 1285, 414, 415, 1311, 1309
3886, 1285, 1287, 1288, 1286, 1309, 1311, 1312, 1310
3887, 1286, 1288, 408, 407, 1310, 1312, 418, 417
3888, 382, 42, 385, 1287, 415, 49, 409, 1311
3889, 1287, 385, 386, 1288, 1311, 409, 410, 1312
3890, 1288, 386, 46, 408, 1312, 410, 50, 418
*ELEMENT, type=C3D8, ELSET=Volume13
3891, 2, 97, 691, 105, 54, 419, 1313, 427
3892, 105, 691, 692, 106, 427, 1313, 1314, 428
3893, 106, 692, 102, 4, 428, 1314, 424, 56
3894, 97, 98, 693, 691, 419, 420, 1315, 1313
3895, 691, 693, 694, 692, 1313, 1315, 1316, 1314
3896, 692, 694, 103, 102, 1314, 1316, 425, 424
3897, 98, 99, 695, 693, 420, 421, 1317, 1315
3898, 693, 695, 696, 694, 1315, 1317, 1318, 1316
3899, 694, 696, 104, 103, 1316, 1318, 426, 425
3900, 99, 1, 100, 695, 421, 53, 422, 1317
3901, 695, 100, 101, 696, 1317, 422, 423, 1318
3902, 696, 101, 3, 104, 1318, 423, 55, 426
*ELEMENT, type=C3D8, ELSET=Volume14
3903, 10, 165, 781, 141, 67, 471, 1355, 477
3904, 165, 166, 782, 781, 471, 472, 1356, 1355
3905, 166, 167, 783, 782, 472, 473, 1357, 1356
3906, 167, 168, 784, 783, 473, 474, 1358, 1357
3907, 168, 169, 785, 784, 474, 475, 1359, 1358
3908, 169, 170, 786, 785, 475, 476, 1360, 1359
3909, 170, 14, 171, 786, 476, 68, 483, 1360
3910, 141, 781, 787, 142, 477, 1355, 1361, 478
3911, 781, 782, 788, 787, 1355, 1356, 1362, 1361
3912, 782, 783, 789, 788, 1356, 1357, 1363, 1362
3913, 783, 784, 790, 789, 1357, 1358, 1364, 1363
3914, 784, 785, 791, 790, 1358, 1359, 1365, 1364
3915, 785, 786, 792, 791, 1359, 1360, 1366, 1365
3916, 786, 171, 172, 792, 1360, 483, 484, 1366
3917, 142, 787, 793, 143, 478, 1361, 1367, 479
3918, 787, 788, 794, 793, 1361, 1362, 1368, 1367
3919, 788, 789, 795, 794, 1362, 1363, 1369, 1368
3920, 789, 790, 796, 795, 1363, 1364, 1370, 1369
3921, 790, 791, 797, 796, 1364, 1365, 1371, 1370
3922, 791, 792, 798, 797, 1365, 1366, 1372, 1371
3923, 792, 172, 173, 798, 1366, 484, 485, 1372
3924, 143, 793, 799, 144, 479, 1367, 1373, 480
3925, 793, 794, 800, 799, 1367, 1368, 1374, 1373
3926, 794, 795, 801, 800, 1368, 1369, 1375, 1374
3927, 795, 796, 802, 801, 1369, 1370, 1376, 1375
3928, 796, 797, 803, 802, 1370, 1371, 1377, 1376
3929, 797, 798, 804, 803, 1371, 1372, 1378, 1377
3930, 798, 173, 174, 804, 1372, 485, 486, 1378
3931, 144, 799, 805, 145, 480, 1373, 1379, 481
3932, 799, 800, 806, 805, 1373, 1374, 1380, 1379
3933, 800, 801, 807, 806, 1374, 1375, 1381, 1380
3934, 801, 802, 808, 807, 1375, 1376, 1382, 1381
3935, 802, 803, 809, 808, 1376, 1377, 1383, 1382
3936, 803, 804, 810, 809, 1377, 1378, 1384, 1383
3937, 804, 174, 175, 810, 1378, 486, 487, 1384
3938, 145, 805, 811, 146, 481, 1379, 1385, 482
3939, 805, 806, 812, 811, 1379, 1380, 1386, 1385
3940, 806, 807, 813, 812, 1380, 1381, 1387, 1386
3941, 807, 808, 814, 813, 1381, 1382, 1388, 1387
3942, 808, 809, 815, 814, 1382, 1383, 1389, 1388
3943, 809, 810, 816, 815, 1383, 1384, 1390, 1389
3944, 810, 175, 176, 816, 1384, 487, 488, 1390
3945, 146, 811, 159, 9, 482, 1385, 465, 65
3946, 811, 812, 160, 159, 1385, 1386, 466, 465
3947, 812, 813, 161, 160, 1386, 1387, 467, 466
3948, 813, 814, 162, 161, 1387, 1388, 468, 467
3949, 814, 815, 163, 162, 1388, 1389, 469, 468
3950, 815, 816, 164, 163, 1389, 1390, 470, 469
3951, 816, 176, 13, 164, 1390, 488, 66, 470
*ELEMENT, type=C3D8, ELSET=Volume15
3952, 35, 311, 1145, 341, 69, 501, 1391, 489
3953, 341, 1145, 1146, 342, 489, 1391, 1392, 490
3954, 342, 1146, 1147, 343, 490, 1392, 1393, 491
3955, 343, 1147, 1148, 344, 491, 1393, 1394, 492
3956, 344, 1148, 1149, 345, 492, 1394, 1395, 493
3957, 345, 1149, 1150, 346, 493, 1395, 1396, 494
3958, 346, 1150, 353, 39, 494, 1396, 507, 70
3959, 311, 312, 1151, 1145, 501, 502, 1397, 1391
3960, 1145, 1151, 1152, 1146, 1391, 1397, 1398, 1392
3961, 1146, 1152, 1153, 1147, 1392, 1398, 1399, 1393
3962, 1147, 1153, 1154, 1148, 1393, 1399, 1400, 1394
3963, 1148, 1154, 1155, 1149, 1394, 1400, 1401, 1395
3964, 1149, 1155, 1156, 1150, 1395, 1401, 1402, 1396
3965, 1150, 1156, 354, 353, 1396, 1402, 508, 507
3966, 312, 313, 1157, 1151, 502, 503, 1403, 1397
3967, 1151, 1157, 1158, 1152, 1397, 1403, 1404, 1398
3968, 1152, 1158, 1159, 1153, 1398, 1404, 1405, 1399
3969, 1153, 1159, 1160, 1154, 1399, 1405, 1406, 1400
3970, 1154, 1160, 1161, 1155, 1400, 1406, 1407, 1401
3971, 1155, 1161, 1162, 1156, 1401, 1407, 1408, 1402
3972, 1156, 1162, 355, 354, 1402, 1408, 509, 508
3973, 313, 314, 1163, 1157, 503, 504, 1409, 1403
3974, 1157, 1163, 1164, 1158, 1403, 1409, 1410, 1404
3975, 1158, 1164, 1165, 1159, 1404, 1410, 1411, 1405
3976, 1159, 1165, 1166, 1160, 1405, 1411, 1412, 1406
3977, 1160, 1166, 1167, 1161, 1406, 1412, 1413, 1407
3978, 1161, 1167, 1168, 1162, 1407, 1413, 1414, 1408
3979, 1162, 1168, 356, 355, 1408, 1414, 510, 509
3980, 314, 315, 1169, 1163, 504, 505, 1415, 1409
3981, 1163, 1169, 1170, 1164, 1409, 1415, 1416, 1410
3982, 1164, 1170, 1171, 1165, 1410, 1416, 1417, 1411
3983, 1165, 1171, 1172, 1166, 1411, 1417, 1418, 1412
3984, 1166, 1172, 1173, 1167, 1412, 1418, 1419, 1413
3985, 1167, 1173, 1174, 1168, 1413, 1419, 1420, 1414
3986, 1168, 1174, 357, 356, 1414, 1420, 511, 510
3987, 315, 316, 1175, 1169, 505, 506, 1421, 1415
3988, 1169, 1175, 1176, 1170, 1415, 1421, 1422, 1416
3989, 1170, 1176, 1177, 1171, 1416, 1422, 1423, 1417
3990, 1171, 1177, 1178, 1172, 1417, 1423, 1424, 1418
3991, 1172, 1178, 1179, 1173, 1418, 1424, 1425, 1419
3992, 1173, 1179, 1180, 1174, 1419, 1425, 1426, 1420
3993, 1174, 1180, 358, 357, 1420, 1426, 512, 511
3994, 316, 36, 347, 1175, 506, 71, 495, 1421
3995, 1175, 347, 348, 1176, 1421, 495, 496, 1422
3996, 1176, 348, 349, 1177, 1422, 496, 497, 1423
3997, 1177, 349, 350, 1178, 1423, 497, 498, 1424
3998, 1178, 350, 351, 1179, 1424, 498, 499, 1425
3999, 1179, 351, 352, 1180, 1425, 499, 500, 1426
4000, 1180, 352, 40, 358, 1426, 500, 72, 512
*ELEMENT, type=C3D8, ELSET=Volume16
4001, 9, 159, 817, 147, 59, 435, 1319, 441
4002, 159, 160, 818, 817, 435, 436, 1320, 1319
4003, 160, 161, 819, 818, 436, 437, 1321, 1320
4004, 161, 162, 820, 819, 437, 438, 1322, 1321
4005, 162, 163, 821, 820, 438, 439, 1323, 1322
4006, 163, 164, 822, 821, 439, 440, 1324, 1323
4007, 164, 13, 183, 822, 440, 60, 444, 1324
4008, 147, 817, 823, 148, 441, 1319, 1325, 442
4009, 817, 818, 824, 823, 1319, 1320, 1326, 1325
4010, 818, 819, 825, 824, 1320, 1321, 1327, 1326
4011, 819, 820, 826, 825, 1321, 1322, 1328, 1327
4012, 820, 821, 827, 826, 1322, 1323, 1329, 1328
4013, 821, 822, 828, 827, 1323, 1324, 1330, 1329
4014, 822, 183, 184, 828, 1324, 444, 445, 1330
4015, 148, 823, 829, 149, 442, 1325, 1331, 443
4016, 823, 824, 830, 829, 1325, 1326, 1332, 1331
4017, 824, 825, 831, 830, 1326, 1327, 1333, 1332
4018, 825, 826, 832, 831, 1327, 1328, 1334, 1333
4019, 826, 827, 833, 832, 1328, 1329, 1335, 1334
4020, 827, 828, 834, 833, 1329, 1330, 1336, 1335
4021, 828, 184, 185, 834, 1330, 445, 446, 1336
4022, 149, 829, 177, 11, 443, 1331, 429, 57
4023, 829, 830, 178, 177, 1331, 1332, 430, 429
4024, 830, 831, 179, 178, 1332, 1333, 431, 430
4025, 831, 832, 180, 179, 1333, 1334, 432, 431
4026, 832, 833, 181, 180, 1334, 1335, 433, 432
4027, 833, 834, 182, 181, 1335, 1336, 434, 433
4028, 834, 185, 15, 182, 1336, 446, 58, 434
*ELEMENT, type=C3D8, ELSET=Volume17
4029, 35, 341, 1181, 317, 63, 453, 1337, 459
4030, 341, 342, 1182, 1181, 453, 454, 1338, 1337
4031, 342, 343, 1183, 1182, 454, 455, 1339, 1338
4032, 343, 344, 1184, 1183, 455, 456, 1340, 1339
4033, 344, 345, 1185, 1184, 456, 457, 1341, 1340
4034, 345, 346, 1186, 1185, 457, 458, 1342, 1341
4035, 346, 39, 359, 1186, 458, 64, 462, 1342
4036, 317, 1181, 1187, 318, 459, 1337, 1343, 460
4037, 1181, 1182, 1188, 1187, 1337, 1338, 1344, 1343
4038, 1182, 1183, 1189, 1188, 1338, 1339, 1345, 1344
4039, 1183, 1184, 1190, 1189, 1339, 1340, 1346, 1345
4040, 1184, 1185, 1191, 1190, 1340, 1341, 1347, 1346
4041, 1185, 1186, 1192, 1191, 1341, 1342, 1348, 1347
4042, 1186, 359, 360, 1192, 1342, 462, 463, 1348
4043, 318, 1187, 1193, 319, 460, 1343, 1349, 461
4044, 1187, 1188, 1194, 1193, 1343, 1344, 1350, 1349
4045, 1188, 1189, 1195, 1194, 1344, 1345, 1351, 1350
4046, 1189, 1190, 1196, 1195, 1345, 1346, 1352, 1351
4047, 1190, 1191, 1197, 1196, 1346, 1347, 1353, 1352
4048, 1191, 1192, 1198, 1197, 1347, 1348, 1354, 1353
4049, 1192, 360, 361, 1198, 1348, 463, 464, 1354
4050, 319, 1193, 323, 33, 461, 1349, 447, 61
4051, 1193, 1194, 324, 323, 1349, 1350, 448, 447
4052, 1194, 1195, 325, 324, 1350, 1351, 449, 448
4053, 1195, 1196, 326, 325, 1351, 1352, 450, 449
4054, 1196, 1197, 327, 326, 1352, 1353, 451, 450
4055, 1197, 1198, 328, 327, 1353, 1354, 452, 451
4056, 1198, 361, 37, 328, 1354, 464, 62, 452
*ELEMENT, type=C3D8, ELSET=Volume18
4057, 35, 341, 453, 63, 69, 489, 513, 73
4058, 341, 342, 454, 453, 489, 490, 514, 513
4059, 342, 343, 455, 454, 490, 491, 515, 514
4060, 343, 344, 456, 455, 491, 492, 516, 515
4061, 344, 345, 457, 456, 492, 493, 517, 516
4062, 345, 346, 458, 457, 493, 494, 518, 517
4063, 346, 39, 64, 458, 494, 70, 74, 518
*ELEMENT, type=C3D8, ELSET=Volume19
4064, 9, 159, 435, 59, 65, 465, 519, 75
4065, 159, 160, 436, 435, 465, 466, 520, 519
4066, 160, 161, 437, 436, 466, 467, 521, 520
4067, 161, 162, 438, 437, 467, 468, 522, 521
4068, 162, 163, 439, 438, 468, 469, 523, 522
4069, 163, 164, 440, 439, 469, 470, 524, 523
4070, 164, 13, 60, 440, 470, 66, 76, 524
*ELEMENT, type=C3D8, ELSET=Volume20
4071, 22, 242, 961, 223, 529, 1487, 2239, 1427
4072, 529, 1487, 2239, 1427, 530, 1488, 2240, 1428
4073, 530, 1488, 2240, 1428, 531, 1489, 2241, 1429
4074, 531, 1489, 2241, 1429, 532, 1490, 2242, 1430
4075, 532, 1490, 2242, 1430, 78, 556, 1499, 533
4076, 242, 243, 962, 961, 1487, 1491, 2243, 2239
4077, 1487, 1491, 2243, 2239, 1488, 1492, 2244, 2240
4078, 1488, 1492, 2244, 2240, 1489, 1493, 2245, 2241
4079, 1489, 1493, 2245, 2241, 1490, 1494, 2246, 2242
4080, 1490, 1494, 2246, 2242, 556, 557, 1500, 1499
4081, 243, 244, 963, 962, 1491, 1495, 2247, 2243
4082, 1491, 1495, 2247, 2243, 1492, 1496, 2248, 2244
4083, 1492, 1496, 2248, 2244, 1493, 1497, 2249, 2245
4084, 1493, 1497, 2249, 2245, 1494, 1498, 2250, 2246
4085, 1494, 1498, 2250, 2246, 557, 558, 1501, 1500
4086, 244, 24, 236, 963, 1495, 546, 1463, 2247
4087, 1495, 546, 1463, 2247, 1496, 547, 1464, 2248
4088, 1496, 547, 1464, 2248, 1497, 548, 1465, 2249
4089, 1497, 548, 1465, 2249, 1498, 549, 1466, 2250
4090, 1498, 549, 1466, 2250, 558, 80, 550, 1501
4091, 223, 961, 964, 224, 1427, 2239, 2251, 1431
4092, 1427, 2239, 2251, 1431, 1428, 2240, 2252, 1432
4093, 1428, 2240, 2252, 1432, 1429, 2241, 2253, 1433
4094, 1429, 2241, 2253, 1433, 1430, 2242, 2254, 1434
4095, 1430, 2242, 2254, 1434, 533, 1499, 1502, 534
4096, 961, 962, 965, 964, 2239, 2243, 2255, 2251
4097, 2239, 2243, 2255, 2251, 2240, 2244, 2256, 2252
4098, 2240, 2244, 2256, 2252, 2241, 2245, 2257, 2253
4099, 2241, 2245, 2257, 2253, 2242, 2246, 2258, 2254
4100, 2242, 2246, 2258, 2254, 1499, 1500, 1503, 1502
4101, 962, 963, 966, 965, 2243, 2247, 2259, 2255
4102, 2243, 2247, 2259, 2255, 2244, 2248, 2260, 2256
4103, 2244, 2248, 2260, 2256, 2245, 2249, 2261, 2257
4104, 2245, 2249, 2261, 2257, 2246, 2250, 2262, 2258
4105, 2246, 2250, 2262, 2258, 1500, 1501, 1504, 1503
4106, 963, 236, 237, 966, 2247, 1463, 1467, 2259
4107, 2247, 1463, 1467, 2259, 2248, 1464, 1468, 2260
4108, 2248, 1464, 1468, 2260, 2249, 1465, 1469, 2261
4109, 2249, 1465, 1469, 2261, 2250, 1466, 1470, 2262
4110, 2250, 1466, 1470, 2262, 1501, 550, 551, 1504
4111, 224, 964, 967, 225, 1431, 2251, 2263, 1435
4112, 1431, 2251, 2263, 1435, 1432, 2252, 2264, 1436
4113, 1432, 2252, 2264, 1436, 1433, 2253, 2265, 1437
4114, 1433, 2253, 2265, 1437, 1434, 2254, 2266, 1438
4115, 1434, 2254, 2266, 1438, 534, 1502, 1505, 535
4116, 964, 965, 968, 967, 2251, 2255, 2267, 2263
4117, 2251, 2255, 2267, 2263, 2252, 2256, 2268, 2264
4118, 2252, 2256, 2268, 2264, 2253, 2257, 2269, 2265
4119, 2253, 2257, 2269, 2265, 2254, 2258, 2270, 2266
4120, 2254, 2258, 2270, 2266, 1502, 1503, 1506, 1505
4121, 965, 966, 969, 968, 2255, 2259, 2271, 2267
4122, 2255, 2259, 2271, 2267, 2256, 2260, 2272, 2268
4123, 2256, 2260, 2272, 2268, 2257, 2261, 2273, 2269
4124, 2257, 2261, 2273, 2269, 2258, 2262, 2274, 2270
4125, 2258, 2262, 2274, 2270, 1503, 1504, 1507, 1506
4126, 966, 237, 238, 969, 2259, 1467, 1471, 2271
4127, 2259, 1467, 1471, 2271, 2260, 1468, 1472, 2272
4128, 2260, 1468, 1472, 2272, 2261, 1469, 1473, 2273
4129, 2261, 1469, 1473, 2273, 2262, 1470, 1474, 2274
4130, 2262, 1470, 1474, 2274, 1504, 551, 552, 1507
4131, 225, 967, 970, 226, 1435, 2263, 2275, 1439
4132, 1435, 2263, 2275, 1439, 1436, 2264, 2276, 1440
4133, 1436, 2264, 2276, 1440, 1437, 2265, 2277, 1441
4134, 1437, 2265, 2277, 1441, 1438, 2266, 2278, 1442
4135, 1438, 2266, 2278, 1442, 535, 1505, 1508, 536
4136, 967, 968, 971, 970, 2263, 2267, 2279, 2275
4137, 2263, 2267, 2279, 2275, 2264, 2268, 2280, 2276
4138, 2264, 2268, 2280, 2276, 2265, 2269, 2281, 2277
4139, 2265, 2269, 2281, 2277, 2266, 2270, 2282, 2278
4140, 2266, 2270, 2282, 2278, 1505, 1506, 1509, 1508
4141, 968, 969, 972, 971, 2267, 2271, 2283, 2279
4142, 2267, 2271, 2283, 2279, 2268, 2272, 2284, 2280
4143, 2268, 2272, 2284, 2280, 2269, 2273, 2285, 2281
4144, 2269, 2273, 2285, 2281, 2270, 2274, 2286, 2282
4145, 2270, 2274, 2286, 2282, 1506, 1507, 1510, 1509
4146, 969, 238, 239, 972, 2271, 1471, 1475, 2283
4147, 2271, 1471, 1475, 2283, 2272, 1472, 1476, 2284
4148, 2272, 1472, 1476, 2284, 2273, 1473, 1477, 2285
4149, 2273, 1473, 1477, 2285, 2274, 1474, 1478, 2286
4150, 2274, 1474, 1478, 2286, 1507, 552, 553, 1510
4151, 226, 970, 973, 227, 1439, 2275, 2287, 1443
4152, 1439, 2275, 2287, 1443, 1440, 2276, 2288, 1444
4153, 1440, 2276, 2288, 1444, 1441, 2277, 2289, 1445
4154, 1441, 2277, 2289, 1445, 1442, 2278, 2290, 1446
4155, 1442, 2278, 2290, 1446, 536, 1508, 1511, 537
4156, 970, 971, 974, 973, 2275, 2279, 2291, 2287
4157, 2275, 2279, 2291, 2287, 2276, 2280, 2292, 2288
4158, 2276, 2280, 2292, 2288, 2277, 2281, 2293, 2289
4159, 2277, 2281, 2293, 2289, 2278, 2282, 2294, 2290
4160, 2278, 2282, 2294, 2290, 1508, 1509, 1512, 1511
4161, 971, 972, 975, 974, 2279, 2283, 2295, 2291
4162, 2279, 2283, 2295, 2291, 2280, 2284, 2296, 2292
4163, 2280, 2284, 2296, 2292, 2281, 2285, 2297, 2293
4164, 2281, 2285, 2297, 2293, 2282, 2286, 2298, 2294
4165, 2282, 2286, 2298, 2294, 1509, 1510, 1513, 1512
4166, 972, 239, 240, 975, 2283, 1475, 1479, 2295
4167, 2283, 1475, 1479, 2295, 2284, 1476, 1480, 2296
4168, 2284, 1476, 1480, 2296, 2285, 1477, 1481, 2297
4169, 2285, 1477, 1481, 2297, 2286, 1478, 1482, 2298
4170, 2286, 1478, 1482, 2298, 1510, 553, 554, 1513
4171, 227, 973, 976, 228, 1443, 2287, 2299, 1447
4172, 1443, 2287, 2299, 1447, 1444, 2288, 2300, 1448
4173, 1444, 2288, 2300, 1448, 1445, 2289, 2301, 1449
4174, 1445, 2289, 2301, 1449, 1446, 2290, 2302, 1450
4175, 1446, 2290, 2302, 1450, 537, 1511, 1514, 538
4176, 973, 974, 977, 976, 2287, 2291, 2303, 2299
4177, 2287, 2291, 2303, 2299, 2288, 2292, 2304, 2300
4178, 2288, 2292, 2304, 2300, 2289, 2293, 2305, 2301
4179, 2289, 2293, 2305, 2301, 2290, 2294, 2306, 2302
4180, 2290, 2294, 2306, 2302, 1511, 1512, 1515, 1514
4181, 974, 975, 978, 977, 2291, 2295, 2307, 2303
4182, 2291, 2295, 2307, 2303, 2292, 2296, 2308, 2304
4183, 2292, 2296, 2308, 2304, 2293, 2297, 2309, 2305
4184, 2293, 2297, 2309, 2305, 2294, 2298, 2310, 2306
4185, 2294, 2298, 2310, 2306, 1512, 1513, 1516, 1515
4186, 975, 240, 241, 978, 2295, 1479, 1483, 2307
4187, 2295, 1479, 1483, 2307, 2296, 1480, 1484, 2308
4188, 2296, 1480, 1484, 2308, 2297, 1481, 1485, 2309
4189, 2297, 1481, 1485, 2309, 2298, 1482, 1486, 2310
4190, 2298, 1482, 1486, 2310, 1513, 554, 555, 1516
4191, 228, 976, 231, 21, 1447, 2299, 1451, 525
4192, 1447, 2299, 1451, 525, 1448, 2300, 1452, 526
4193, 1448, 2300, 1452, 526, 1449, 2301, 1453, 527
4194, 1449, 2301, 1453, 527, 1450, 2302, 1454, 528
4195, 1450, 2302, 1454, 528, 538, 1514, 543, 77
4196, 976, 977, 232, 231, 2299, 2303, 1455, 1451
4197, 2299, 2303, 1455, 1451, 2300, 2304, 1456, 1452
4198, 2300, 2304, 1456, 1452, 2301, 2305, 1457, 1453
4199, 2301, 2305, 1457, 1453, 2302, 2306, 1458, 1454
4200, 2302, 2306, 1458, 1454, 1514, 1515, 544, 543
4201, 977, 978, 233, 232, 2303, 2307, 1459, 1455
4202, 2303, 2307, 1459, 1455, 2304, 2308, 1460, 1456
4203, 2304, 2308, 1460, 1456, 2305, 2309, 1461, 1457
4204, 2305, 2309, 1461, 1457, 2306, 2310, 1462, 1458
4205, 2306, 2310, 1462, 1458, 1515, 1516, 545, 544
4206, 978, 241, 23, 233, 2307, 1483, 539, 1459
4207, 2307, 1483, 539, 1459, 2308, 1484, 540, 1460
4208, 2308, 1484, 540, 1460, 2309, 1485, 541, 1461
4209, 2309, 1485, 541, 1461, 2310, 1486, 542, 1462
4210, 2310, 1486, 542, 1462, 1516, 555, 79, 545
*ELEMENT, type=C3D8, ELSET=Volume21
4211, 21, 231, 1007, 259, 525, 1451, 2311, 1533
4212, 525, 1451, 2311, 1533, 526, 1452, 2312, 1534
4213, 526, 1452, 2312, 1534, 527, 1453, 2313, 1535
4214, 527, 1453, 2313, 1535, 528, 1454, 2314, 1536
4215, 528, 1454, 2314, 1536, 77, 543, 1561, 571
4216, 259, 1007, 1008, 260, 1533, 2311, 2315, 1537
4217, 1533, 2311, 2315, 1537, 1534, 2312, 2316, 1538
4218, 1534, 2312, 2316, 1538, 1535, 2313, 2317, 1539
4219, 1535, 2313, 2317, 1539, 1536, 2314, 2318, 1540
4220, 1536, 2314, 2318, 1540, 571, 1561, 1562, 572
4221, 260, 1008, 1009, 261, 1537, 2315, 2319, 1541
4222, 1537, 2315, 2319, 1541, 1538, 2316, 2320, 1542
4223, 1538, 2316, 2320, 1542, 1539, 2317, 2321, 1543
4224, 1539, 2317, 2321, 1543, 1540, 2318, 2322, 1544
4225, 1540, 2318, 2322, 1544, 572, 1562, 1563, 573
4226, 261, 1009, 1010, 262, 1541, 2319, 2323, 1545
4227, 1541, 2319, 2323, 1545, 1542, 2320, 2324, 1546
4228, 1542, 2320, 2324, 1546, 1543, 2321, 2325, 1547
4229, 1543, 2321, 2325, 1547, 1544, 2322, 2326, 1548
4230, 1544, 2322, 2326, 1548, 573, 1563, 1564, 574
4231, 262, 1010, 268, 28, 1545, 2323, 1549, 567
4232, 1545, 2323, 1549, 567, 1546, 2324, 1550, 568
4233, 1546, 2324, 1550, 568, 1547, 2325, 1551, 569
4234, 1547, 2325, 1551, 569, 1548, 2326, 1552, 570
4235, 1548, 2326, 1552, 570, 574, 1564, 575, 82
4236, 231, 232, 1011, 1007, 1451, 1455, 2327, 2311
4237, 1451, 1455, 2327, 2311, 1452, 1456, 2328, 2312
4238, 1452, 1456, 2328, 2312, 1453, 1457, 2329, 2313
4239, 1453, 1457, 2329, 2313, 1454, 1458, 2330, 2314
4240, 1454, 1458, 2330, 2314, 543, 544, 1565, 1561
4241, 1007, 1011, 1012, 1008, 2311, 2327, 2331, 2315
4242, 2311, 2327, 2331, 2315, 2312, 2328, 2332, 2316
4243, 2312, 2328, 2332, 2316, 2313, 2329, 2333, 2317
4244, 2313, 2329, 2333, 2317, 2314, 2330, 2334, 2318
4245, 2314, 2330, 2334, 2318, 1561, 1565, 1566, 1562
4246, 1008, 1012, 1013, 1009, 2315, 2331, 2335, 2319
4247, 2315, 2331, 2335, 2319, 2316, 2332, 2336, 2320
4248, 2316, 2332, 2336, 2320, 2317, 2333, 2337, 2321
4249, 2317, 2333, 2337, 2321, 2318, 2334, 2338, 2322
4250, 2318, 2334, 2338, 2322, 1562, 1566, 1567, 1563
4251, 1009, 1013, 1014, 1010, 2319, 2335, 2339, 2323
4252, 2319, 2335, 2339, 2323, 2320, 2336, 2340, 2324
4253, 2320, 2336, 2340, 2324, 2321, 2337, 2341, 2325
4254, 2321, 2337, 2341, 2325, 2322, 2338, 2342, 2326
4255, 2322, 2338, 2342, 2326, 1563, 1567, 1568, 1564
4256, 1010, 1014, 269, 268, 2323, 2339, 1553, 1549
4257, 2323, 2339, 1553, 1549, 2324, 2340, 1554, 1550
4258, 2324, 2340, 1554, 1550, 2325, 2341, 1555, 1551
4259, 2325, 2341, 1555, 1551, 2326, 2342, 1556, 1552
4260, 2326, 2342, 1556, 1552, 1564, 1568, 576, 575
4261, 232, 233, 1015, 1011, 1455, 1459, 2343, 2327
4262, 1455, 1459, 2343, 2327, 1456, 1460, 2344, 2328
4263, 1456, 1460, 2344, 2328, 1457, 1461, 2345, 2329
4264, 1457, 1461, 2345, 2329, 1458, 1462, 2346, 2330
4265, 1458, 1462, 2346, 2330, 544, 545, 1569, 1565
4266, 1011, 1015, 1016, 1012, 2327, 2343, 2347, 2331
4267, 2327, 2343, 2347, 2331, 2328, 2344, 2348, 2332
4268, 2328, 2344, 2348, 2332, 2329, 2345, 2349, 2333
4269, 2329, 2345, 2349, 2333, 2330, 2346, 2350, 2334
4270, 2330, 2346, 2350, 2334, 1565, 1569, 1570, 1566
4271, 1012, 1016, 1017, 1013, 2331, 2347, 2351, 2335
4272, 2331, 2347, 2351, 2335, 2332, 2348, 2352, 2336
4273, 2332, 2348, 2352, 2336, 2333, 2349, 2353, 2337
4274, 2333, 2349, 2353, 2337, 2334, 2350, 2354, 2338
4275, 2334, 2350, 2354, 2338, 1566, 1570, 1571, 1567
4276, 1013, 1017, 1018, 1014, 2335, 2351, 2355, 2339
4277, 2335, 2351, 2355, 2339, 2336, 2352, 2356, 2340
4278, 2336, 2352, 2356, 2340, 2337, 2353, 2357, 2341
4279, 2337, 2353, 2357, 2341, 2338, 2354, 2358, 2342
4280, 2338, 2354, 2358, 2342, 1567, 1571, 1572, 1568
4281, 1014, 1018, 270, 269, 2339, 2355, 1557, 1553
4282, 2339, 2355, 1557, 1553, 2340, 2356, 1558, 1554
4283, 2340, 2356, 1558, 1554, 2341, 2357, 1559, 1555
4284, 2341, 2357, 1559, 1555, 2342, 2358, 1560, 1556
4285, 2342, 2358, 1560, 1556, 1568, 1572, 577, 576
4286, 233, 23, 249, 1015, 1459, 539, 1517, 2343
4287, 1459, 539, 1517, 2343, 1460, 540, 1518, 2344
4288, 1460, 540, 1518, 2344, 1461, 541, 1519, 2345
4289, 1461, 541, 1519, 2345, 1462, 542, 1520, 2346
4290, 1462, 542, 1520, 2346, 545, 79, 563, 1569
4291, 1015, 249, 250, 1016, 2343, 1517, 1521, 2347
4292, 2343, 1517, 1521, 2347, 2344, 1518, 1522, 2348
4293, 2344, 1518, 1522, 2348, 2345, 1519, 1523, 2349
4294, 2345, 1519, 1523, 2349, 2346, 1520, 1524, 2350
4295, 2346, 1520, 1524, 2350, 1569, 563, 564, 1570
4296, 1016, 250, 251, 1017, 2347, 1521, 1525, 2351
4297, 2347, 1521, 1525, 2351, 2348, 1522, 1526, 2352
4298, 2348, 1522, 1526, 2352, 2349, 1523, 1527, 2353
4299, 2349, 1523, 1527, 2353, 2350, 1524, 1528, 2354
4300, 2350, 1524, 1528, 2354, 1570, 564, 565, 1571
4301, 1017, 251, 252, 1018, 2351, 1525, 1529, 2355
4302, 2351, 1525, 1529, 2355, 2352, 1526, 1530, 2356
4303, 2352, 1526, 1530, 2356, 2353, 1527, 1531, 2357
4304, 2353, 1527, 1531, 2357, 2354, 1528, 1532, 2358
4305, 2354, 1528, 1532, 2358, 1571, 565, 566, 1572
4306, 1018, 252, 26, 270, 2355, 1529, 559, 1557
4307, 2355, 1529, 559, 1557, 2356, 1530, 560, 1558
4308, 2356, 1530, 560, 1558, 2357, 1531, 561, 1559
4309, 2357, 1531, 561, 1559, 2358, 1532, 562, 1560
4310, 2358, 1532, 562, 1560, 1572, 566, 81, 577
*ELEMENT, type=C3D8, ELSET=Volume22
4311, 28, 268, 1067, 291, 567, 1549, 2359, 1597
4312, 567, 1549, 2359, 1597, 568, 1550, 2360, 1598
4313, 568, 1550, 2360, 1598, 569, 1551, 2361, 1599
4314, 569, 1551, 2361, 1599, 570, 1552, 2362, 1600
4315, 570, 1552, 2362, 1600, 82, 575, 1633, 592
4316, 291, 1067, 1068, 292, 1597, 2359, 2363, 1601
4317, 1597, 2359, 2363, 1601, 1598, 2360, 2364, 1602
4318, 1598, 2360, 2364, 1602, 1599, 2361, 2365, 1603
4319, 1599, 2361, 2365, 1603, 1600, 2362, 2366, 1604
4320, 1600, 2362, 2366, 1604, 592, 1633, 1634, 593
4321, 292, 1068, 1069, 293, 1601, 2363, 2367, 1605
4322, 1601, 2363, 2367, 1605, 1602, 2364, 2368, 1606
4323, 1602, 2364, 2368, 1606, 1603, 2365, 2369, 1607
4324, 1603, 2365, 2369, 1607, 1604, 2366, 2370, 1608
4325, 1604, 2366, 2370, 1608, 593, 1634, 1635, 594
4326, 293, 1069, 1070, 294, 1605, 2367, 2371, 1609
4327, 1605, 2367, 2371, 1609, 1606, 2368, 2372, 1610
4328, 1606, 2368, 2372, 1610, 1607, 2369, 2373, 1611
4329, 1607, 2369, 2373, 1611, 1608, 2370, 2374, 1612
4330, 1608, 2370, 2374, 1612, 594, 1635, 1636, 595
4331, 294, 1070, 1071, 295, 1609, 2371, 2375, 1613
4332, 1609, 2371, 2375, 1613, 1610, 2372, 2376, 1614
4333, 1610, 2372, 2376, 1614, 1611, 2373, 2377, 1615
4334, 1611, 2373, 2377, 1615, 1612, 2374, 2378, 1616
4335, 1612, 2374, 2378, 1616, 595, 1636, 1637, 596
4336, 295, 1071, 1072, 296, 1613, 2375, 2379, 1617
4337, 1613, 2375, 2379, 1617, 1614, 2376, 2380, 1618
4338, 1614, 2376, 2380, 1618, 1615, 2377, 2381, 1619
4339, 1615, 2377, 2381, 1619, 1616, 2378, 2382, 1620
4340, 1616, 2378, 2382, 1620, 596, 1637, 1638, 597
4341, 296, 1072, 302, 32, 1617, 2379, 1621, 588
4342, 1617, 2379, 1621, 588, 1618, 2380, 1622, 589
4343, 1618, 2380, 1622, 589, 1619, 2381, 1623, 590
4344, 1619, 2381, 1623, 590, 1620, 2382, 1624, 591
4345, 1620, 2382, 1624, 591, 597, 1638, 598, 84
4346, 268, 269, 1073, 1067, 1549, 1553, 2383, 2359
4347, 1549, 1553, 2383, 2359, 1550, 1554, 2384, 2360
4348, 1550, 1554, 2384, 2360, 1551, 1555, 2385, 2361
4349, 1551, 1555, 2385, 2361, 1552, 1556, 2386, 2362
4350, 1552, 1556, 2386, 2362, 575, 576, 1639, 1633
4351, 1067, 1073, 1074, 1068, 2359, 2383, 2387, 2363
4352, 2359, 2383, 2387, 2363, 2360, 2384, 2388, 2364
4353, 2360, 2384, 2388, 2364, 2361, 2385, 2389, 2365
4354, 2361, 2385, 2389, 2365, 2362, 2386, 2390, 2366
4355, 2362, 2386, 2390, 2366, 1633, 1639, 1640, 1634
4356, 1068, 1074, 1075, 1069, 2363, 2387, 2391, 2367
4357, 2363, 2387, 2391, 2367, 2364, 2388, 2392, 2368
4358, 2364, 2388, 2392, 2368, 2365, 2389, 2393, 2369
4359, 2365, 2389, 2393, 2369, 2366, 2390, 2394, 2370
4360, 2366, 2390, 2394, 2370, 1634, 1640, 1641, 1635
4361, 1069, 1075, 1076, 1070, 2367, 2391, 2395, 2371
4362, 2367, 2391, 2395, 2371, 2368, 2392, 2396, 2372
4363, 2368, 2392, 2396, 2372, 2369, 2393, 2397, 2373
4364, 2369, 2393, 2397, 2373, 2370, 2394, 2398, 2374
4365, 2370, 2394, 2398, 2374, 1635, 1641, 1642, 1636
4366, 1070, 1076, 1077, 1071, 2371, 2395, 2399, 2375
4367, 2371, 2395, 2399, 2375, 2372, 2396, 2400, 2376
4368, 2372, 2396, 2400, 2376, 2373, 2397, 2401, 2377
4369, 2373, 2397, 2401, 2377, 2374, 2398, 2402, 2378
4370, 2374, 2398, 2402, 2378, 1636, 1642, 1643, 1637
4371, 1071, 1077, 1078, 1072, 2375, 2399, 2403, 2379
4372, 2375, 2399, 2403, 2379, 2376, 2400, 2404, 2380
4373, 2376, 2400, 2404, 2380, 2377, 2401, 2405, 2381
4374, 2377, 2401, 2405, 2381, 2378, 2402, 2406, 2382
4375, 2378, 2402, 2406, 2382, 1637, 1643, 1644, 1638
4376, 1072, 1078, 303, 302, 2379, 2403, 1625, 1621
4377, 2379, 2403, 1625, 1621, 2380, 2404, 1626, 1622
4378, 2380, 2404, 1626, 1622, 2381, 2405, 1627, 1623
4379, 2381, 2405, 1627, 1623, 2382, 2406, 1628, 1624
4380, 2382, 2406, 1628, 1624, 1638, 1644, 599, 598
4381, 269, 270, 1079, 1073, 1553, 1557, 2407, 2383
4382, 1553, 1557, 2407, 2383, 1554, 1558, 2408, 2384
4383, 1554, 1558, 2408, 2384, 1555, 1559, 2409, 2385
4384, 1555, 1559, 2409, 2385, 1556, 1560, 2410, 2386
4385, 1556, 1560, 2410, 2386, 576, 577, 1645, 1639
4386, 1073, 1079, 1080, 1074, 2383, 2407, 2411, 2387
4387, 2383, 2407, 2411, 2387, 2384, 2408, 2412, 2388
4388, 2384, 2408, 2412, 2388, 2385, 2409, 2413, 2389
4389, 2385, 2409, 2413, 2389, 2386, 2410, 2414, 2390
4390, 2386, 2410, 2414, 2390, 1639, 1645, 1646, 1640
4391, 1074, 1080, 1081, 1075, 2387, 2411, 2415, 2391
4392, 2387, 2411, 2415, 2391, 2388, 2412, 2416, 2392
4393, 2388, 2412, 2416, 2392, 2389, 2413, 2417, 2393
4394, 2389, 2413, 2417, 2393, 2390, 2414, 2418, 2394
4395, 2390, 2414, 2418, 2394, 1640, 1646, 1647, 1641
4396, 1075, 1081, 1082, 1076, 2391, 2415, 2419, 2395
4397, 2391, 2415, 2419, 2395, 2392, 2416, 2420, 2396
4398, 2392, 2416, 2420, 2396, 2393, 2417, 2421, 2397
4399, 2393, 2417, 2421, 2397, 2394, 2418, 2422, 2398
4400, 2394, 2418, 2422, 2398, 1641, 1647, 1648, 1642
4401, 1076, 1082, 1083, 1077, 2395, 2419, 2423, 2399
4402, 2395, 2419, 2423, 2399, 2396, 2420, 2424, 2400
4403, 2396, 2420, 2424, 2400, 2397, 2421, 2425, 2401
4404, 2397, 2421, 2425, 2401, 2398, 2422, 2426, 2402
4405, 2398, 2422, 2426, 2402, 1642, 1648, 1649, 1643
4406, 1077, 1083, 1084, 1078, 2399, 2423, 2427, 2403
4407, 2399, 2423, 2427, 2403, 2400, 2424, 2428, 2404
4408, 2400, 2424, 2428, 2404, 2401, 2425, 2429, 2405
4409, 2401, 2425, 2429, 2405, 2402, 2426, 2430, 2406
4410, 2402, 2426, 2430, 2406, 1643, 1649, 1650, 1644
4411, 1078, 1084, 304, 303, 2403, 2427, 1629, 1625
4412, 2403, 2427, 1629, 1625, 2404, 2428, 1630, 1626
4413, 2404, 2428, 1630, 1626, 2405, 2429, 1631, 1627
4414, 2405, 2429, 1631, 1627, 2406, 2430, 1632, 1628
4415, 2406, 2430, 1632, 1628, 1644, 1650, 600, 599
4416, 270, 26, 277, 1079, 1557, 559, 1573, 2407
4417, 1557, 559, 1573, 2407, 1558, 560, 1574, 2408
4418, 1558, 560, 1574, 2408, 1559, 561, 1575, 2409
4419, 1559, 561, 1575, 2409, 1560, 562, 1576, 2410
4420, 1560, 562, 1576, 2410, 577, 81, 582, 1645
4421, 1079, 277, 278, 1080, 2407, 1573, 1577, 2411
4422, 2407, 1573, 1577, 2411, 2408, 1574, 1578, 2412
4423, 2408, 1574, 1578, 2412, 2409, 1575, 1579, 2413
4424, 2409, 1575, 1579, 2413, 2410, 1576, 1580, 2414
4425, 2410, 1576, 1580, 2414, 1645, 582, 583, 1646
4426, 1080, 278, 279, 1081, 2411, 1577, 1581, 2415
4427, 2411, 1577, 1581, 2415, 2412, 1578, 1582, 2416
4428, 2412, 1578, 1582, 2416, 2413, 1579, 1583, 2417
4429, 2413, 1579, 1583, 2417, 2414, 1580, 1584, 2418
4430, 2414, 1580, 1584, 2418, 1646, 583, 584, 1647
4431, 1081, 279, 280, 1082, 2415, 1581, 1585, 2419
4432, 2415, 1581, 1585, 2419, 2416, 1582, 1586, 2420
4433, 2416, 1582, 1586, 2420, 2417, 1583, 1587, 2421
4434, 2417, 1583, 1587, 2421, 2418, 1584, 1588, 2422
4435, 2418, 1584, 1588, 2422, 1647, 584, 585, 1648
4436, 1082, 280, 281, 1083, 2419, 1585, 1589, 2423
4437, 2419, 1585, 1589, 2423, 2420, 1586, 1590, 2424
4438, 2420, 1586, 1590, 2424, 2421, 1587, 1591, 2425
4439, 2421, 1587, 1591, 2425, 2422, 1588, 1592, 2426
4440, 2422, 1588, 1592, 2426, 1648, 585, 586, 1649
4441, 1083, 281, 282, 1084, 2423, 1589, 1593, 2427
4442, 2423, 1589, 1593, 2427, 2424, 1590, 1594, 2428
4443, 2424, 1590, 1594, 2428, 2425, 1591, 1595, 2429
4444, 2425, 1591, 1595, 2429, 2426, 1592, 1596, 2430
4445, 2426, 1592, 1596, 2430, 1649, 586, 587, 1650
4446, 1084, 282, 30, 304, 2427, 1593, 578, 1629
4447, 2427, 1593, 578, 1629, 2428, 1594, 579, 1630
4448, 2428, 1594, 579, 1630, 2429, 1595, 580, 1631
4449, 2429, 1595, 580, 1631, 2430, 1596, 581, 1632
4450, 2430, 1596, 581, 1632, 1650, 587, 83, 600
*ELEMENT, type=C3D8, ELSET=Volume23
4451, 2, 117, 703, 97, 605, 1651, 2431, 1711
4452, 605, 1651, 2431, 1711, 606, 1652, 2432, 1712
4453, 606, 1652, 2432, 1712, 607, 1653, 2433, 1713
4454, 607, 1653, 2433, 1713, 608, 1654, 2434, 1714
4455, 608, 1654, 2434, 1714, 86, 609, 1723, 632
4456, 97, 703, 704, 98, 1711, 2431, 2435, 1715
4457, 1711, 2431, 2435, 1715, 1712, 2432, 2436, 1716
4458, 1712, 2432, 2436, 1716, 1713, 2433, 2437, 1717
4459, 1713, 2433, 2437, 1717, 1714, 2434, 2438, 1718
4460, 1714, 2434, 2438, 1718, 632, 1723, 1724, 633
4461, 98, 704, 705, 99, 1715, 2435, 2439, 1719
4462, 1715, 2435, 2439, 1719, 1716, 2436, 2440, 1720
4463, 1716, 2436, 2440, 1720, 1717, 2437, 2441, 1721
4464, 1717, 2437, 2441, 1721, 1718, 2438, 2442, 1722
4465, 1718, 2438, 2442, 1722, 633, 1724, 1725, 634
4466, 99, 705, 123, 1, 1719, 2439, 1687, 622
4467, 1719, 2439, 1687, 622, 1720, 2440, 1688, 623
4468, 1720, 2440, 1688, 623, 1721, 2441, 1689, 624
4469, 1721, 2441, 1689, 624, 1722, 2442, 1690, 625
4470, 1722, 2442, 1690, 625, 634, 1725, 626, 88
4471, 117, 118, 706, 703, 1651, 1655, 2443, 2431
4472, 1651, 1655, 2443, 2431, 1652, 1656, 2444, 2432
4473, 1652, 1656, 2444, 2432, 1653, 1657, 2445, 2433
4474, 1653, 1657, 2445, 2433, 1654, 1658, 2446, 2434
4475, 1654, 1658, 2446, 2434, 609, 610, 1726, 1723
4476, 703, 706, 707, 704, 2431, 2443, 2447, 2435
4477, 2431, 2443, 2447, 2435, 2432, 2444, 2448, 2436
4478, 2432, 2444, 2448, 2436, 2433, 2445, 2449, 2437
4479, 2433, 2445, 2449, 2437, 2434, 2446, 2450, 2438
4480, 2434, 2446, 2450, 2438, 1723, 1726, 1727, 1724
4481, 704, 707, 708, 705, 2435, 2447, 2451, 2439
4482, 2435, 2447, 2451, 2439, 2436, 2448, 2452, 2440
4483, 2436, 2448, 2452, 2440, 2437, 2449, 2453, 2441
4484, 2437, 2449, 2453, 2441, 2438, 2450, 2454, 2442
4485, 2438, 2450, 2454, 2442, 1724, 1727, 1728, 1725
4486, 705, 708, 124, 123, 2439, 2451, 1691, 1687
4487, 2439, 2451, 1691, 1687, 2440, 2452, 1692, 1688
4488, 2440, 2452, 1692, 1688, 2441, 2453, 1693, 1689
4489, 2441, 2453, 1693, 1689, 2442, 2454, 1694, 1690
4490, 2442, 2454, 1694, 1690, 1725, 1728, 627, 626
4491, 118, 119, 709, 706, 1655, 1659, 2455, 2443
4492, 1655, 1659, 2455, 2443, 1656, 1660, 2456, 2444
4493, 1656, 1660, 2456, 2444, 1657, 1661, 2457, 2445
4494, 1657, 1661, 2457, 2445, 1658, 1662, 2458, 2446
4495, 1658, 1662, 2458, 2446, 610, 611, 1729, 1726
4496, 706, 709, 710, 707, 2443, 2455, 2459, 2447
4497, 2443, 2455, 2459, 2447, 2444, 2456, 2460, 2448
4498, 2444, 2456, 2460, 2448, 2445, 2457, 2461, 2449
4499, 2445, 2457, 2461, 2449, 2446, 2458, 2462, 2450
4500, 2446, 2458, 2462, 2450, 1726, 1729, 1730, 1727
4501, 707, 710, 711, 708, 2447, 2459, 2463, 2451
4502, 2447, 2459, 2463, 2451, 2448, 2460, 2464, 2452
4503, 2448, 2460, 2464, 2452, 2449, 2461, 2465, 2453
4504, 2449, 2461, 2465, 2453, 2450, 2462, 2466, 2454
4505, 2450, 2462, 2466, 2454, 1727, 1730, 1731, 1728
4506, 708, 711, 125, 124, 2451, 2463, 1695, 1691
4507, 2451, 2463, 1695, 1691, 2452, 2464, 1696, 1692
4508, 2452, 2464, 1696, 1692, 2453, 2465, 1697, 1693
4509, 2453, 2465, 1697, 1693, 2454, 2466, 1698, 1694
4510, 2454, 2466, 1698, 1694, 1728, 1731, 628, 627
4511, 119, 120, 712, 709, 1659, 1663, 2467, 2455
4512, 1659, 1663, 2467, 2455, 1660, 1664, 2468, 2456
4513, 1660, 1664, 2468, 2456, 1661, 1665, 2469, 2457
4514, 1661, 1665, 2469, 2457, 1662, 1666, 2470, 2458
4515, 1662, 1666, 2470, 2458, 611, 612, 1732, 1729
4516, 709, 712, 713, 710, 2455, 2467, 2471, 2459
4517, 2455, 2467, 2471, 2459, 2456, 2468, 2472, 2460
4518, 2456, 2468, 2472, 2460, 2457, 2469, 2473, 2461
4519, 2457, 2469, 2473, 2461, 2458, 2470, 2474, 2462
4520, 2458, 2470, 2474, 2462, 1729, 1732, 1733, 1730
4521, 710, 713, 714, 711, 2459, 2471, 2475, 2463
4522, 2459, 2471, 2475, 2463, 2460, 2472, 2476, 2464
4523, 2460, 2472, 2476, 2464, 2461, 2473, 2477, 2465
4524, 2461, 2473, 2477, 2465, 2462, 2474, 2478, 2466
4525, 2462, 2474, 2478, 2466, 1730, 1733, 1734, 1731
4526, 711, 714, 126, 125, 2463, 2475, 1699, 1695
4527, 2463, 2475, 1699, 1695, 2464, 2476, 1700, 1696
4528, 2464, 2476, 1700, 1696, 2465, 2477, 1701, 1697
4529, 2465, 2477, 1701, 1697, 2466, 2478, 1702, 1698
4530, 2466, 2478, 1702, 1698, 1731, 1734, 629, 628
4531, 120, 121, 715, 712, 1663, 1667, 2479, 2467
4532, 1663, 1667, 2479, 2467, 1664, 1668, 2480, 2468
4533, 1664, 1668, 2480, 2468, 1665, 1669, 2481, 2469
4534, 1665, 1669, 2481, 2469, 1666, 1670, 2482, 2470
4535, 1666, 1670, 2482, 2470, 612, 613, 1735, 1732
4536, 712, 715, 716, 713, 2467, 2479, 2483, 2471
4537, 2467, 2479, 2483, 2471, 2468, 2480, 2484, 2472
4538, 2468, 2480, 2484, 2472, 2469, 2481, 2485, 2473
4539, 2469, 2481, 2485, 2473, 2470, 2482, 2486, 2474
4540, 2470, 2482, 2486, 2474, 1732, 1735, 1736, 1733
4541, 713, 716, 717, 714, 2471, 2483, 2487, 2475
4542, 2471, 2483, 2487, 2475, 2472, 2484, 2488, 2476
4543, 2472, 2484, 2488, 2476, 2473, 2485, 2489, 2477
4544, 2473, 2485, 2489, 2477, 2474, 2486, 2490, 2478
4545, 2474, 2486, 2490, 2478, 1733, 1736, 1737, 1734
4546, 714, 717, 127, 126, 2475, 2487, 1703, 1699
4547, 2475, 2487, 1703, 1699, 2476, 2488, 1704, 1700
4548, 2476, 2488, 1704, 1700, 2477, 2489, 1705, 1701
4549, 2477, 2489, 1705, 1701, 2478, 2490, 1706, 1702
4550, 2478, 2490, 1706, 1702, 1734, 1737, 630, 629
4551, 121, 122, 718, 715, 1667, 1671, 2491, 2479
4552, 1667, 1671, 2491, 2479, 1668, 1672, 2492, 2480
4553, 1668, 1672, 2492, 2480, 1669, 1673, 2493, 2481
4554, 1669, 1673, 2493, 2481, 1670, 1674, 2494, 2482
4555, 1670, 1674, 2494, 2482, 613, 614, 1738, 1735
4556, 715, 718, 719, 716, 2479, 2491, 2495, 2483
4557, 2479, 2491, 2495, 2483, 2480, 2492, 2496, 2484
4558, 2480, 2492, 2496, 2484, 2481, 2493, 2497, 2485
4559, 2481, 2493, 2497, 2485, 2482, 2494, 2498, 2486
4560, 2482, 2494, 2498, 2486, 1735, 1738, 1739, 1736
4561, 716, 719, 720, 717, 2483, 2495, 2499, 2487
4562, 2483, 2495, 2499, 2487, 2484, 2496, 2500, 2488
4563, 2484, 2496, 2500, 2488, 2485, 2497, 2501, 2489
4564, 2485, 2497, 2501, 2489, 2486, 2498, 2502, 2490
4565, 2486, 2498, 2502, 2490, 1736, 1739, 1740, 1737
4566, 717, 720, 128, 127, 2487, 2499, 1707, 1703
4567, 2487, 2499, 1707, 1703, 2488, 2500, 1708, 1704
4568, 2488, 2500, 1708, 1704, 2489, 2501, 1709, 1705
4569, 2489, 2501, 1709, 1705, 2490, 2502, 1710, 1706
4570, 2490, 2502, 1710, 1706, 1737, 1740, 631, 630
4571, 122, 6, 107, 718, 1671, 601, 1675, 2491
4572, 1671, 601, 1675, 2491, 1672, 602, 1676, 2492
4573, 1672, 602, 1676, 2492, 1673, 603, 1677, 2493
4574, 1673, 603, 1677, 2493, 1674, 604, 1678, 2494
4575, 1674, 604, 1678, 2494, 614, 85, 619, 1738
4576, 718, 107, 108, 719, 2491, 1675, 1679, 2495
4577, 2491, 1675, 1679, 2495, 2492, 1676, 1680, 2496
4578, 2492, 1676, 1680, 2496, 2493, 1677, 1681, 2497
4579, 2493, 1677, 1681, 2497, 2494, 1678, 1682, 2498
4580, 2494, 1678, 1682, 2498, 1738, 619, 620, 1739
4581, 719, 108, 109, 720, 2495, 1679, 1683, 2499
4582, 2495, 1679, 1683, 2499, 2496, 1680, 1684, 2500
4583, 2496, 1680, 1684, 2500, 2497, 1681, 1685, 2501
4584, 2497, 1681, 1685, 2501, 2498, 1682, 1686, 2502
4585, 2498, 1682, 1686, 2502, 1739, 620, 621, 1740
4586, 720, 109, 5, 128, 2499, 1683, 615, 1707
4587, 2499, 1683, 615, 1707, 2500, 1684, 616, 1708
4588, 2500, 1684, 616, 1708, 2501, 1685, 617, 1709
4589, 2501, 1685, 617, 1709, 2502, 1686, 618, 1710
4590, 2502, 1686, 618, 1710, 1740, 621, 87, 631
*ELEMENT, type=C3D8, ELSET=Volume24
4591, 2, 97, 419, 54, 605, 1711, 1741, 639
4592, 605, 1711, 1741, 639, 606, 1712, 1742, 640
4593, 606, 1712, 1742, 640, 607, 1713, 1743, 641
4594, 607, 1713, 1743, 641, 608, 1714, 1744, 642
4595, 608, 1714, 1744, 642, 86, 632, 643, 90
4596, 97, 98, 420, 419, 1711, 1715, 1745, 1741
4597, 1711, 1715, 1745, 1741, 1712, 1716, 1746, 1742
4598, 1712, 1716, 1746, 1742, 1713, 1717, 1747, 1743
4599, 1713, 1717, 1747, 1743, 1714, 1718, 1748, 1744
4600, 1714, 1718, 1748, 1744, 632, 633, 644, 643
4601, 98, 99, 421, 420, 1715, 1719, 1749, 1745
4602, 1715, 1719, 1749, 1745, 1716, 1720, 1750, 1746
4603, 1716, 1720, 1750, 1746, 1717, 1721, 1751, 1747
4604, 1717, 1721, 1751, 1747, 1718, 1722, 1752, 1748
4605, 1718, 1722, 1752, 1748, 633, 634, 645, 644
4606, 99, 1, 53, 421, 1719, 622, 635, 1749
4607, 1719, 622, 635, 1749, 1720, 623, 636, 1750
4608, 1720, 623, 636, 1750, 1721, 624, 637, 1751
4609, 1721, 624, 637, 1751, 1722, 625, 638, 1752
4610, 1722, 625, 638, 1752, 634, 88, 89, 645
*ELEMENT, type=C3D8, ELSET=Volume25
4611, 47, 397, 1289, 403, 660, 1777, 2503, 1801
4612, 660, 1777, 2503, 1801, 661, 1778, 2504, 1802
4613, 661, 1778, 2504, 1802, 662, 1779, 2505, 1803
4614, 662, 1779, 2505, 1803, 663, 1780, 2506, 1804
4615, 663, 1780, 2506, 1804, 93, 668, 1825, 674
4616, 397, 398, 1290, 1289, 1777, 1781, 2507, 2503
4617, 1777, 1781, 2507, 2503, 1778, 1782, 2508, 2504
4618, 1778, 1782, 2508, 2504, 1779, 1783, 2509, 2505
4619, 1779, 1783, 2509, 2505, 1780, 1784, 2510, 2506
4620, 1780, 1784, 2510, 2506, 668, 669, 1826, 1825
4621, 398, 399, 1291, 1290, 1781, 1785, 2511, 2507
4622, 1781, 1785, 2511, 2507, 1782, 1786, 2512, 2508
4623, 1782, 1786, 2512, 2508, 1783, 1787, 2513, 2509
4624, 1783, 1787, 2513, 2509, 1784, 1788, 2514, 2510
4625, 1784, 1788, 2514, 2510, 669, 670, 1827, 1826
4626, 399, 400, 1292, 1291, 1785, 1789, 2515, 2511
4627, 1785, 1789, 2515, 2511, 1786, 1790, 2516, 2512
4628, 1786, 1790, 2516, 2512, 1787, 1791, 2517, 2513
4629, 1787, 1791, 2517, 2513, 1788, 1792, 2518, 2514
4630, 1788, 1792, 2518, 2514, 670, 671, 1828, 1827
4631, 400, 401, 1293, 1292, 1789, 1793, 2519, 2515
4632, 1789, 1793, 2519, 2515, 1790, 1794, 2520, 2516
4633, 1790, 1794, 2520, 2516, 1791, 1795, 2521, 2517
4634, 1791, 1795, 2521, 2517, 1792, 1796, 2522, 2518
4635, 1792, 1796, 2522, 2518, 671, 672, 1829, 1828
4636, 401, 402, 1294, 1293, 1793, 1797, 2523, 2519
4637, 1793, 1797, 2523, 2519, 1794, 1798, 2524, 2520
4638, 1794, 1798, 2524, 2520, 1795, 1799, 2525, 2521
4639, 1795, 1799, 2525, 2521, 1796, 1800, 2526, 2522
4640, 1796, 1800, 2526, 2522, 672, 673, 1830, 1829
4641, 402, 48, 406, 1294, 1797, 664, 1813, 2523
4642, 1797, 664, 1813, 2523, 1798, 665, 1814, 2524
4643, 1798, 665, 1814, 2524, 1799, 666, 1815, 2525
4644, 1799, 666, 1815, 2525, 1800, 667, 1816, 2526
4645, 1800, 667, 1816, 2526, 673, 94, 677, 1830
4646, 403, 1289, 1295, 404, 1801, 2503, 2527, 1805
4647, 1801, 2503, 2527, 1805, 1802, 2504, 2528, 1806
4648, 1802, 2504, 2528, 1806, 1803, 2505, 2529, 1807
4649, 1803, 2505, 2529, 1807, 1804, 2506, 2530, 1808
4650, 1804, 2506, 2530, 1808, 674, 1825, 1831, 675
4651, 1289, 1290, 1296, 1295, 2503, 2507, 2531, 2527
4652, 2503, 2507, 2531, 2527, 2504, 2508, 2532, 2528
4653, 2504, 2508, 2532, 2528, 2505, 2509, 2533, 2529
4654, 2505, 2509, 2533, 2529, 2506, 2510, 2534, 2530
4655, 2506, 2510, 2534, 2530, 1825, 1826, 1832, 1831
4656, 1290, 1291, 1297, 1296, 2507, 2511, 2535, 2531
4657, 2507, 2511, 2535, 2531, 2508, 2512, 2536, 2532
4658, 2508, 2512, 2536, 2532, 2509, 2513, 2537, 2533
4659, 2509, 2513, 2537, 2533, 2510, 2514, 2538, 2534
4660, 2510, 2514, 2538, 2534, 1826, 1827, 1833, 1832
4661, 1291, 1292, 1298, 1297, 2511, 2515, 2539, 2535
4662, 2511, 2515, 2539, 2535, 2512, 2516, 2540, 2536
4663, 2512, 2516, 2540, 2536, 2513, 2517, 2541, 2537
4664, 2513, 2517, 2541, 2537, 2514, 2518, 2542, 2538
4665, 2514, 2518, 2542, 2538, 1827, 1828, 1834, 1833
4666, 1292, 1293, 1299, 1298, 2515, 2519, 2543, 2539
4667, 2515, 2519, 2543, 2539, 2516, 2520, 2544, 2540
4668, 2516, 2520, 2544, 2540, 2517, 2521, 2545, 2541
4669, 2517, 2521, 2545, 2541, 2518, 2522, 2546, 2542
4670, 2518, 2522, 2546, 2542, 1828, 1829, 1835, 1834
4671, 1293, 1294, 1300, 1299, 2519, 2523, 2547, 2543
4672, 2519, 2523, 2547, 2543, 2520, 2524, 2548, 2544
4673, 2520, 2524, 2548, 2544, 2521, 2525, 2549, 2545
4674, 2521, 2525, 2549, 2545, 2522, 2526, 2550, 2546
4675, 2522, 2526, 2550, 2546, 1829, 1830, 1836, 1835
4676, 1294, 406, 407, 1300, 2523, 1813, 1817, 2547
4677, 2523, 1813, 1817, 2547, 2524, 1814, 1818, 2548
4678, 2524, 1814, 1818, 2548, 2525, 1815, 1819, 2549
4679, 2525, 1815, 1819, 2549, 2526, 1816, 1820, 2550
4680, 2526, 1816, 1820, 2550, 1830, 677, 678, 1836
4681, 404, 1295, 1301, 405, 1805, 2527, 2551, 1809
4682, 1805, 2527, 2551, 1809, 1806, 2528, 2552, 1810
4683, 1806, 2528, 2552, 1810, 1807, 2529, 2553, 1811
4684, 1807, 2529, 2553, 1811, 1808, 2530, 2554, 1812
4685, 1808, 2530, 2554, 1812, 675, 1831, 1837, 676
4686, 1295, 1296, 1302, 1301, 2527, 2531, 2555, 2551
4687, 2527, 2531, 2555, 2551, 2528, 2532, 2556, 2552
4688, 2528, 2532, 2556, 2552, 2529, 2533, 2557, 2553
4689, 2529, 2533, 2557, 2553, 2530, 2534, 2558, 2554
4690, 2530, 2534, 2558, 2554, 1831, 1832, 1838, 1837
4691, 1296, 1297, 1303, 1302, 2531, 2535, 2559, 2555
4692, 2531, 2535, 2559, 2555, 2532, 2536, 2560, 2556
4693, 2532, 2536, 2560, 2556, 2533, 2537, 2561, 2557
4694, 2533, 2537, 2561, 2557, 2534, 2538, 2562, 2558
4695, 2534, 2538, 2562, 2558, 1832, 1833, 1839, 1838
4696, 1297, 1298, 1304, 1303, 2535, 2539, 2563, 2559
4697, 2535, 2539, 2563, 2559, 2536, 2540, 2564, 2560
4698, 2536, 2540, 2564, 2560, 2537, 2541, 2565, 2561
4699, 2537, 2541, 2565, 2561, 2538, 2542, 2566, 2562
4700, 2538, 2542, 2566, 2562, 1833, 1834, 1840, 1839
4701, 1298, 1299, 1305, 1304, 2539, 2543, 2567, 2563
4702, 2539, 2543, 2567, 2563, 2540, 2544, 2568, 2564
4703, 2540, 2544, 2568, 2564, 2541, 2545, 2569, 2565
4704, 2541, 2545, 2569, 2565, 2542, 2546, 2570, 2566
4705, 2542, 2546, 2570, 2566, 1834, 1835, 1841, 1840
4706, 1299, 1300, 1306, 1305, 2543, 2547, 2571, 2567
4707, 2543, 2547, 2571, 2567, 2544, 2548, 2572, 2568
4708, 2544, 2548, 2572, 2568, 2545, 2549, 2573, 2569
4709, 2545, 2549, 2573, 2569, 2546, 2550, 2574, 2570
4710, 2546, 2550, 2574, 2570, 1835, 1836, 1842, 1841
4711, 1300, 407, 408, 1306, 2547, 1817, 1821, 2571
4712, 2547, 1817, 1821, 2571, 2548, 1818, 1822, 2572
4713, 2548, 1818, 1822, 2572, 2549, 1819, 1823, 2573
4714, 2549, 1819, 1823, 2573, 2550, 1820, 1824, 2574
4715, 2550, 1820, 1824, 2574, 1836, 678, 679, 1842
4716, 405, 1301, 387, 45, 1809, 2551, 1753, 646
4717, 1809, 2551, 1753, 646, 1810, 2552, 1754, 647
4718, 1810, 2552, 1754, 647, 1811, 2553, 1755, 648
4719, 1811, 2553, 1755, 648, 1812, 2554, 1756, 649
4720, 1812, 2554, 1756, 649, 676, 1837, 654, 91
4721, 1301, 1302, 388, 387, 2551, 2555, 1757, 1753
4722, 2551, 2555, 1757, 1753, 2552, 2556, 1758, 1754
4723, 2552, 2556, 1758, 1754, 2553, 2557, 1759, 1755
4724, 2553, 2557, 1759, 1755, 2554, 2558, 1760, 1756
4725, 2554, 2558, 1760, 1756, 1837, 1838, 655, 654
4726, 1302, 1303, 389, 388, 2555, 2559, 1761, 1757
4727, 2555, 2559, 1761, 1757, 2556, 2560, 1762, 1758
4728, 2556, 2560, 1762, 1758, 2557, 2561, 1763, 1759
4729, 2557, 2561, 1763, 1759, 2558, 2562, 1764, 1760
4730, 2558, 2562, 1764, 1760, 1838, 1839, 656, 655
4731, 1303, 1304, 390, 389, 2559, 2563, 1765, 1761
4732, 2559, 2563, 1765, 1761, 2560, 2564, 1766, 1762
4733, 2560, 2564, 1766, 1762, 2561, 2565, 1767, 1763
4734, 2561, 2565, 1767, 1763, 2562, 2566, 1768, 1764
4735, 2562, 2566, 1768, 1764, 1839, 1840, 657, 656
4736, 1304, 1305, 391, 390, 2563, 2567, 1769, 1765
4737, 2563, 2567, 1769, 1765, 2564, 2568, 1770, 1766
4738, 2564, 2568, 1770, 1766, 2565, 2569, 1771, 1767
4739, 2565, 2569, 1771, 1767, 2566, 2570, 1772, 1768
4740, 2566, 2570, 1772, 1768, 1840, 1841, 658, 657
4741, 1305, 1306, 392, 391, 2567, 2571, 1773, 1769
4742, 2567, 2571, 1773, 1769, 2568, 2572, 1774, 1770
4743, 2568, 2572, 1774, 1770, 2569, 2573, 1775, 1771
4744, 2569, 2573, 1775, 1771, 2570, 2574, 1776, 1772
4745, 2570, 2574, 1776, 1772, 1841, 1842, 659, 658
4746, 1306, 408, 46, 392, 2571, 1821, 650, 1773
4747, 2571, 1821, 650, 1773, 2572, 1822, 651, 1774
4748, 2572, 1822, 651, 1774, 2573, 1823, 652, 1775
4749, 2573, 1823, 652, 1775, 2574, 1824, 653, 1776
4750, 2574, 1824, 653, 1776, 1842, 679, 92, 659
*ELEMENT, type=C3D8, ELSET=Volume26
4751, 48, 52, 416, 406, 664, 684, 1843, 1813
4752, 664, 684, 1843, 1813, 665, 685, 1844, 1814
4753, 665, 685, 1844, 1814, 666, 686, 1845, 1815
4754, 666, 686, 1845, 1815, 667, 687, 1846, 1816
4755, 667, 687, 1846, 1816, 94, 96, 688, 677
4756, 406, 416, 417, 407, 1813, 1843, 1847, 1817
4757, 1813, 1843, 1847, 1817, 1814, 1844, 1848, 1818
4758, 1814, 1844, 1848, 1818, 1815, 1845, 1849, 1819
4759, 1815, 1845, 1849, 1819, 1816, 1846, 1850, 1820
4760, 1816, 1846, 1850, 1820, 677, 688, 689, 678
4761, 407, 417, 418, 408, 1817, 1847, 1851, 1821
4762, 1817, 1847, 1851, 1821, 1818, 1848, 1852, 1822
4763, 1818, 1848, 1852, 1822, 1819, 1849, 1853, 1823
4764, 1819, 1849, 1853, 1823, 1820, 1850, 1854, 1824
4765, 1820, 1850, 1854, 1824, 678, 689, 690, 679
4766, 408, 418, 50, 46, 1821, 1851, 680, 650
4767, 1821, 1851, 680, 650, 1822, 1852, 681, 651
4768, 1822, 1852, 681, 651, 1823, 1853, 682, 652
4769, 1823, 1853, 682, 652, 1824, 1854, 683, 653
4770, 1824, 1854, 683, 653, 679, 690, 95, 92
*ELSET,ELSET=Qin
1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 
1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 
1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1433, 1434, 
1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 
1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1558, 1559, 1560, 1561, 1562, 
*ELSET,ELSET=HeatSink
909, 910, 911, 912, 913, 914, 915, 916, 917, 918, 
919, 920, 921, 922, 923, 924, 925, 926, 927, 928, 
929, 930, 931, 932, 933, 934, 935, 936, 1923, 1924, 
1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
1945, 1946, 1947, 1948, 1949, 1950, 
*ELSET,ELSET=ElectrodeMaxX
1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 
1975, 1976, 
*ELSET,ELSET=ElectrodeMinX
1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 
2001, 2002, 
*ELSET,ELSET=Force
1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 
1353, 1354, 
*ELSET,ELSET=Ceramic_Top
2399, 2400, 2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 
2409, 2410, 2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 
2419, 2420, 2421, 2422, 2423, 2424, 2425, 2426, 2497, 2498, 
2499, 2500, 2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 
2509, 2510, 2511, 2512, 2513, 2514, 2515, 2516, 2607, 2608, 
2609, 2610, 2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 
2619, 2620, 2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 
2629, 2630, 2631, 2632, 2633, 2634, 
*ELSET,ELSET=Ceramic_Bottom
2427, 2428, 2429, 2430, 2431, 2432, 2433, 2434, 2435, 2436, 
2437, 2438, 2439, 2440, 2441, 2442, 2443, 2444, 2445, 2446, 
2447, 2448, 2449, 2450, 2451, 2745, 2746, 2747, 2748, 2749, 
2750, 2751, 2752, 2753, 2754, 2755, 2756, 2757, 2758, 2759, 
2760, 2761, 2762, 2763, 2764, 2765, 2766, 2767, 2768, 2769, 
2770, 2771, 2772, 2917, 2918, 2919, 2920, 2921, 2922, 2923, 
2924, 2925, 2926, 2927, 2928, 2929, 2930, 2931, 2932, 2933, 
2934, 2935, 2936, 2937, 2938, 2939, 2940, 2941, 2942, 2943, 
2944, 
*ELSET,ELSET=Top_Semiconductors
1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218, 1219, 1220, 
1221, 1222, 1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 
1231, 1232, 1233, 1234, 1235, 1236, 1237, 1238, 1597, 1598, 
1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 
1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 
1619, 1620, 1621, 1622, 1623, 1624, 
*ELSET,ELSET=top
2399, 2400, 2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 
2409, 2410, 2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 
2419, 2420, 2421, 2422, 2423, 2424, 2425, 2426, 2497, 2498, 
2499, 2500, 2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 
2509, 2510, 2511, 2512, 2513, 2514, 2515, 2516, 2607, 2608, 
2609, 2610, 2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 
2619, 2620, 2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 
2629, 2630, 2631, 2632, 2633, 2634, 
*ELSET,ELSET=bottom
2745, 2746, 2747, 2748, 2749, 2750, 2751, 2752, 2753, 2754, 
2755, 2756, 2757, 2758, 2759, 2760, 2761, 2762, 2763, 2764, 
2765, 2766, 2767, 2768, 2769, 2770, 2771, 2772, 2803, 2804, 
2805, 2806, 2917, 2918, 2919, 2920, 2921, 2922, 2923, 2924, 
2925, 2926, 2927, 2928, 2929, 2930, 2931, 2932, 2933, 2934, 
2935, 2936, 2937, 2938, 2939, 2940, 2941, 2942, 2943, 2944, 
2975, 2976, 2977, 2978, 
*ELSET,ELSET=Copper
2979, 2980, 2981, 2982, 2983, 2984, 2985, 2986, 2987, 2988, 
2989, 2990, 2991, 2992, 2993, 2994, 2995, 2996, 2997, 2998, 
2999, 3000, 3001, 3002, 3003, 3004, 3005, 3006, 3007, 3008, 
3009, 3010, 3011, 3012, 3013, 3014, 3015, 3016, 3017, 3018, 
3019, 3020, 3021, 3022, 3023, 3024, 3025, 3026, 3027, 3028, 
3029, 3030, 3031, 3032, 3033, 3034, 3035, 3036, 3037, 3038, 
3039, 3040, 3041, 3042, 3043, 3044, 3045, 3046, 3047, 3048, 
3049, 3050, 3051, 3052, 3053, 3054, 3055, 3056, 3057, 3058, 
3059, 3060, 3061, 3062, 3315, 3316, 3317, 3318, 3319, 3320, 
3321, 3322, 3323, 3324, 3325, 3326, 3327, 3328, 3329, 3330, 
3331, 3332, 3333, 3334, 3335, 3336, 3337, 3338, 3339, 3340, 
3341, 3342, 3343, 3344, 3345, 3346, 3347, 3348, 3349, 3350, 
3351, 3352, 3353, 3354, 3355, 3356, 3357, 3358, 3359, 3360, 
3361, 3362, 3363, 3364, 3365, 3366, 3367, 3368, 3369, 3370, 
3371, 3372, 3373, 3374, 3375, 3376, 3377, 3378, 3379, 3380, 
3381, 3382, 3383, 3384, 3385, 3386, 3387, 3388, 3389, 3390, 
3391, 3392, 3393, 3394, 3395, 3396, 3397, 3398, 3399, 3400, 
3401, 3402, 3403, 3404, 3405, 3406, 3407, 3408, 3409, 3410, 
3411, 3412, 3413, 3414, 3415, 3416, 3417, 3418, 3419, 3420, 
3421, 3422, 3423, 3424, 3425, 3426, 3427, 3428, 3429, 3430, 
3431, 3432, 3433, 3434, 3435, 3436, 3437, 3438, 3439, 3440, 
3441, 3442, 3443, 3444, 3445, 3446, 3447, 3448, 3449, 3450, 
3451, 3452, 3453, 3454, 3455, 3456, 3457, 3458, 3459, 3460, 
3461, 3462, 3463, 3464, 3465, 3466, 3467, 3468, 3469, 3470, 
3471, 3472, 3473, 3474, 3475, 3476, 3477, 3478, 3479, 3480, 
3481, 3482, 3483, 3484, 3485, 3486, 3487, 3488, 3489, 3490, 
3491, 3492, 3493, 3494, 3495, 3496, 3497, 3498, 3499, 3500, 
3501, 3502, 3503, 3504, 3505, 3506, 3507, 3508, 3509, 3510, 
3511, 3512, 3513, 3514, 3515, 3516, 3517, 3518, 3519, 3520, 
3521, 3522, 3523, 3524, 3525, 3526, 3527, 3528, 3529, 3530, 
3531, 3532, 3533, 3534, 3535, 3536, 3537, 3538, 3539, 3540, 
3541, 3542, 3795, 3796, 3797, 3798, 3799, 3800, 3801, 3802, 
3803, 3804, 3805, 3806, 3807, 3808, 3809, 3810, 3811, 3812, 
3813, 3814, 3815, 3816, 3817, 3818, 3819, 3820, 3821, 3822, 
3823, 3824, 3825, 3826, 3827, 3828, 3829, 3830, 3831, 3832, 
3833, 3834, 3835, 3836, 3837, 3838, 3839, 3840, 3841, 3842, 
3843, 3844, 3845, 3846, 3847, 3848, 3849, 3850, 3851, 3852, 
3853, 3854, 3855, 3856, 3857, 3858, 3859, 3860, 3861, 3862, 
3863, 3864, 3865, 3866, 3867, 3868, 3869, 3870, 3871, 3872, 
3873, 3874, 3875, 3876, 3877, 3878, 3879, 3880, 3881, 3882, 
3883, 3884, 3885, 3886, 3887, 3888, 3889, 3890, 3891, 3892, 
3893, 3894, 3895, 3896, 3897, 3898, 3899, 3900, 3901, 3902, 
*ELSET,ELSET=SemiconductorN-
3091, 3092, 3093, 3094, 3095, 3096, 3097, 3098, 3099, 3100, 
3101, 3102, 3103, 3104, 3105, 3106, 3107, 3108, 3109, 3110, 
3111, 3112, 3113, 3114, 3115, 3116, 3117, 3118, 3119, 3120, 
3121, 3122, 3123, 3124, 3125, 3126, 3127, 3128, 3129, 3130, 
3131, 3132, 3133, 3134, 3135, 3136, 3137, 3138, 3139, 3140, 
3141, 3142, 3143, 3144, 3145, 3146, 3147, 3148, 3149, 3150, 
3151, 3152, 3153, 3154, 3155, 3156, 3157, 3158, 3159, 3160, 
3161, 3162, 3163, 3164, 3165, 3166, 3167, 3168, 3169, 3170, 
3171, 3172, 3173, 3174, 3175, 3176, 3177, 3178, 3179, 3180, 
3181, 3182, 3183, 3184, 3185, 3186, 3187, 3188, 3189, 3190, 
3191, 3192, 3193, 3194, 3195, 3196, 3197, 3198, 3199, 3200, 
3201, 3202, 3203, 3204, 3205, 3206, 3207, 3208, 3209, 3210, 
3211, 3212, 3213, 3214, 3215, 3216, 3217, 3218, 3219, 3220, 
3221, 3222, 3223, 3224, 3225, 3226, 3227, 3228, 3229, 3230, 
3231, 3232, 3233, 3234, 3235, 3236, 3237, 3238, 3239, 3240, 
3241, 3242, 3243, 3244, 3245, 3246, 3247, 3248, 3249, 3250, 
3251, 3252, 3253, 3254, 3255, 3256, 3257, 3258, 3259, 3260, 
3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 3269, 3270, 
3271, 3272, 3273, 3274, 3275, 3276, 3277, 3278, 3279, 3280, 
3281, 3282, 3283, 3284, 3285, 3286, 3903, 3904, 3905, 3906, 
3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 3915, 3916, 
3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 3925, 3926, 
3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 3936, 
3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 3945, 3946, 
3947, 3948, 3949, 3950, 3951, 4001, 4002, 4003, 4004, 4005, 
4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 4015, 
4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 4025, 
4026, 4027, 4028, 4064, 4065, 4066, 4067, 4068, 4069, 4070, 
*ELSET,ELSET=SemiconductorP+
3571, 3572, 3573, 3574, 3575, 3576, 3577, 3578, 3579, 3580, 
3581, 3582, 3583, 3584, 3585, 3586, 3587, 3588, 3589, 3590, 
3591, 3592, 3593, 3594, 3595, 3596, 3597, 3598, 3599, 3600, 
3601, 3602, 3603, 3604, 3605, 3606, 3607, 3608, 3609, 3610, 
3611, 3612, 3613, 3614, 3615, 3616, 3617, 3618, 3619, 3620, 
3621, 3622, 3623, 3624, 3625, 3626, 3627, 3628, 3629, 3630, 
3631, 3632, 3633, 3634, 3635, 3636, 3637, 3638, 3639, 3640, 
3641, 3642, 3643, 3644, 3645, 3646, 3647, 3648, 3649, 3650, 
3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 3659, 3660, 
3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 3669, 3670, 
3671, 3672, 3673, 3674, 3675, 3676, 3677, 3678, 3679, 3680, 
3681, 3682, 3683, 3684, 3685, 3686, 3687, 3688, 3689, 3690, 
3691, 3692, 3693, 3694, 3695, 3696, 3697, 3698, 3699, 3700, 
3701, 3702, 3703, 3704, 3705, 3706, 3707, 3708, 3709, 3710, 
3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 3719, 3720, 
3721, 3722, 3723, 3724, 3725, 3726, 3727, 3728, 3729, 3730, 
3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 3739, 3740, 
3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 3749, 3750, 
3751, 3752, 3753, 3754, 3755, 3756, 3757, 3758, 3759, 3760, 
3761, 3762, 3763, 3764, 3765, 3766, 3952, 3953, 3954, 3955, 
3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 3965, 
3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 3975, 
3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 3985, 
3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 3995, 
3996, 3997, 3998, 3999, 4000, 4029, 4030, 4031, 4032, 4033, 
4034, 4035, 4036, 4037, 4038, 4039, 4040, 4041, 4042, 4043, 
4044, 4045, 4046, 4047, 4048, 4049, 4050, 4051, 4052, 4053, 
4054, 4055, 4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 
*ELSET,ELSET=Solder
3063, 3064, 3065, 3066, 3067, 3068, 3069, 3070, 3071, 3072, 
3073, 3074, 3075, 3076, 3077, 3078, 3079, 3080, 3081, 3082, 
3083, 3084, 3085, 3086, 3087, 3088, 3089, 3090, 3287, 3288, 
3289, 3290, 3291, 3292, 3293, 3294, 3295, 3296, 3297, 3298, 
3299, 3300, 3301, 3302, 3303, 3304, 3305, 3306, 3307, 3308, 
3309, 3310, 3311, 3312, 3313, 3314, 3543, 3544, 3545, 3546, 
3547, 3548, 3549, 3550, 3551, 3552, 3553, 3554, 3555, 3556, 
3557, 3558, 3559, 3560, 3561, 3562, 3563, 3564, 3565, 3566, 
3567, 3568, 3569, 3570, 3767, 3768, 3769, 3770, 3771, 3772, 
3773, 3774, 3775, 3776, 3777, 3778, 3779, 3780, 3781, 3782, 
3783, 3784, 3785, 3786, 3787, 3788, 3789, 3790, 3791, 3792, 
3793, 3794, 
*ELSET,ELSET=Volume
2979, 2980, 2981, 2982, 2983, 2984, 2985, 2986, 2987, 2988, 
2989, 2990, 2991, 2992, 2993, 2994, 2995, 2996, 2997, 2998, 
2999, 3000, 3001, 3002, 3003, 3004, 3005, 3006, 3007, 3008, 
3009, 3010, 3011, 3012, 3013, 3014, 3015, 3016, 3017, 3018, 
3019, 3020, 3021, 3022, 3023, 3024, 3025, 3026, 3027, 3028, 
3029, 3030, 3031, 3032, 3033, 3034, 3035, 3036, 3037, 3038, 
3039, 3040, 3041, 3042, 3043, 3044, 3045, 3046, 3047, 3048, 
3049, 3050, 3051, 3052, 3053, 3054, 3055, 3056, 3057, 3058, 
3059, 3060, 3061, 3062, 3063, 3064, 3065, 3066, 3067, 3068, 
3069, 3070, 3071, 3072, 3073, 3074, 3075, 3076, 3077, 3078, 
3079, 3080, 3081, 3082, 3083, 3084, 3085, 3086, 3087, 3088, 
3089, 3090, 3091, 3092, 3093, 3094, 3095, 3096, 3097, 3098, 
3099, 3100, 3101, 3102, 3103, 3104, 3105, 3106, 3107, 3108, 
3109, 3110, 3111, 3112, 3113, 3114, 3115, 3116, 3117, 3118, 
3119, 3120, 3121, 3122, 3123, 3124, 3125, 3126, 3127, 3128, 
3129, 3130, 3131, 3132, 3133, 3134, 3135, 3136, 3137, 3138, 
3139, 3140, 3141, 3142, 3143, 3144, 3145, 3146, 3147, 3148, 
3149, 3150, 3151, 3152, 3153, 3154, 3155, 3156, 3157, 3158, 
3159, 3160, 3161, 3162, 3163, 3164, 3165, 3166, 3167, 3168, 
3169, 3170, 3171, 3172, 3173, 3174, 3175, 3176, 3177, 3178, 
3179, 3180, 3181, 3182, 3183, 3184, 3185, 3186, 3187, 3188, 
3189, 3190, 3191, 3192, 3193, 3194, 3195, 3196, 3197, 3198, 
3199, 3200, 3201, 3202, 3203, 3204, 3205, 3206, 3207, 3208, 
3209, 3210, 3211, 3212, 3213, 3214, 3215, 3216, 3217, 3218, 
3219, 3220, 3221, 3222, 3223, 3224, 3225, 3226, 3227, 3228, 
3229, 3230, 3231, 3232, 3233, 3234, 3235, 3236, 3237, 3238, 
3239, 3240, 3241, 3242, 3243, 3244, 3245, 3246, 3247, 3248, 
3249, 3250, 3251, 3252, 3253, 3254, 3255, 3256, 3257, 3258, 
3259, 3260, 3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 
3269, 3270, 3271, 3272, 3273, 3274, 3275, 3276, 3277, 3278, 
3279, 3280, 3281, 3282, 3283, 3284, 3285, 3286, 3287, 3288, 
3289, 3290, 3291, 3292, 3293, 3294, 3295, 3296, 3297, 3298, 
3299, 3300, 3301, 3302, 3303, 3304, 3305, 3306, 3307, 3308, 
3309, 3310, 3311, 3312, 3313, 3314, 3315, 3316, 3317, 3318, 
3319, 3320, 3321, 3322, 3323, 3324, 3325, 3326, 3327, 3328, 
3329, 3330, 3331, 3332, 3333, 3334, 3335, 3336, 3337, 3338, 
3339, 3340, 3341, 3342, 3343, 3344, 3345, 3346, 3347, 3348, 
3349, 3350, 3351, 3352, 3353, 3354, 3355, 3356, 3357, 3358, 
3359, 3360, 3361, 3362, 3363, 3364, 3365, 3366, 3367, 3368, 
3369, 3370, 3371, 3372, 3373, 3374, 3375, 3376, 3377, 3378, 
3379, 3380, 3381, 3382, 3383, 3384, 3385, 3386, 3387, 3388, 
3389, 3390, 3391, 3392, 3393, 3394, 3395, 3396, 3397, 3398, 
3399, 3400, 3401, 3402, 3403, 3404, 3405, 3406, 3407, 3408, 
3409, 3410, 3411, 3412, 3413, 3414, 3415, 3416, 3417, 3418, 
3419, 3420, 3421, 3422, 3423, 3424, 3425, 3426, 3427, 3428, 
3429, 3430, 3431, 3432, 3433, 3434, 3435, 3436, 3437, 3438, 
3439, 3440, 3441, 3442, 3443, 3444, 3445, 3446, 3447, 3448, 
3449, 3450, 3451, 3452, 3453, 3454, 3455, 3456, 3457, 3458, 
3459, 3460, 3461, 3462, 3463, 3464, 3465, 3466, 3467, 3468, 
3469, 3470, 3471, 3472, 3473, 3474, 3475, 3476, 3477, 3478, 
3479, 3480, 3481, 3482, 3483, 3484, 3485, 3486, 3487, 3488, 
3489, 3490, 3491, 3492, 3493, 3494, 3495, 3496, 3497, 3498, 
3499, 3500, 3501, 3502, 3503, 3504, 3505, 3506, 3507, 3508, 
3509, 3510, 3511, 3512, 3513, 3514, 3515, 3516, 3517, 3518, 
3519, 3520, 3521, 3522, 3523, 3524, 3525, 3526, 3527, 3528, 
3529, 3530, 3531, 3532, 3533, 3534, 3535, 3536, 3537, 3538, 
3539, 3540, 3541, 3542, 3543, 3544, 3545, 3546, 3547, 3548, 
3549, 3550, 3551, 3552, 3553, 3554, 3555, 3556, 3557, 3558, 
3559, 3560, 3561, 3562, 3563, 3564, 3565, 3566, 3567, 3568, 
3569, 3570, 3571, 3572, 3573, 3574, 3575, 3576, 3577, 3578, 
3579, 3580, 3581, 3582, 3583, 3584, 3585, 3586, 3587, 3588, 
3589, 3590, 3591, 3592, 3593, 3594, 3595, 3596, 3597, 3598, 
3599, 3600, 3601, 3602, 3603, 3604, 3605, 3606, 3607, 3608, 
3609, 3610, 3611, 3612, 3613, 3614, 3615, 3616, 3617, 3618, 
3619, 3620, 3621, 3622, 3623, 3624, 3625, 3626, 3627, 3628, 
3629, 3630, 3631, 3632, 3633, 3634, 3635, 3636, 3637, 3638, 
3639, 3640, 3641, 3642, 3643, 3644, 3645, 3646, 3647, 3648, 
3649, 3650, 3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 
3659, 3660, 3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 
3669, 3670, 3671, 3672, 3673, 3674, 3675, 3676, 3677, 3678, 
3679, 3680, 3681, 3682, 3683, 3684, 3685, 3686, 3687, 3688, 
3689, 3690, 3691, 3692, 3693, 3694, 3695, 3696, 3697, 3698, 
3699, 3700, 3701, 3702, 3703, 3704, 3705, 3706, 3707, 3708, 
3709, 3710, 3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 
3719, 3720, 3721, 3722, 3723, 3724, 3725, 3726, 3727, 3728, 
3729, 3730, 3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 
3739, 3740, 3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 
3749, 3750, 3751, 3752, 3753, 3754, 3755, 3756, 3757, 3758, 
3759, 3760, 3761, 3762, 3763, 3764, 3765, 3766, 3767, 3768, 
3769, 3770, 3771, 3772, 3773, 3774, 3775, 3776, 3777, 3778, 
3779, 3780, 3781, 3782, 3783, 3784, 3785, 3786, 3787, 3788, 
3789, 3790, 3791, 3792, 3793, 3794, 3795, 3796, 3797, 3798, 
3799, 3800, 3801, 3802, 3803, 3804, 3805, 3806, 3807, 3808, 
3809, 3810, 3811, 3812, 3813, 3814, 3815, 3816, 3817, 3818, 
3819, 3820, 3821, 3822, 3823, 3824, 3825, 3826, 3827, 3828, 
3829, 3830, 3831, 3832, 3833, 3834, 3835, 3836, 3837, 3838, 
3839, 3840, 3841, 3842, 3843, 3844, 3845, 3846, 3847, 3848, 
3849, 3850, 3851, 3852, 3853, 3854, 3855, 3856, 3857, 3858, 
3859, 3860, 3861, 3862, 3863, 3864, 3865, 3866, 3867, 3868, 
3869, 3870, 3871, 3872, 3873, 3874, 3875, 3876, 3877, 3878, 
3879, 3880, 3881, 3882, 3883, 3884, 3885, 3886, 3887, 3888, 
3889, 3890, 3891, 3892, 3893, 3894, 3895, 3896, 3897, 3898, 
3899, 3900, 3901, 3902, 3903, 3904, 3905, 3906, 3907, 3908, 
3909, 3910, 3911, 3912, 3913, 3914, 3915, 3916, 3917, 3918, 
3919, 3920, 3921, 3922, 3923, 3924, 3925, 3926, 3927, 3928, 
3929, 3930, 3931, 3932, 3933, 3934, 3935, 3936, 3937, 3938, 
3939, 3940, 3941, 3942, 3943, 3944, 3945, 3946, 3947, 3948, 
3949, 3950, 3951, 3952, 3953, 3954, 3955, 3956, 3957, 3958, 
3959, 3960, 3961, 3962, 3963, 3964, 3965, 3966, 3967, 3968, 
3969, 3970, 3971, 3972, 3973, 3974, 3975, 3976, 3977, 3978, 
3979, 3980, 3981, 3982, 3983, 3984, 3985, 3986, 3987, 3988, 
3989, 3990, 3991, 3992, 3993, 3994, 3995, 3996, 3997, 3998, 
3999, 4000, 4001, 4002, 4003, 4004, 4005, 4006, 4007, 4008, 
4009, 4010, 4011, 4012, 4013, 4014, 4015, 4016, 4017, 4018, 
4019, 4020, 4021, 4022, 4023, 4024, 4025, 4026, 4027, 4028, 
4029, 4030, 4031, 4032, 4033, 4034, 4035, 4036, 4037, 4038, 
4039, 4040, 4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 
4049, 4050, 4051, 4052, 4053, 4054, 4055, 4056, 4057, 4058, 
4059, 4060, 4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068, 
4069, 4070, 4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 
4079, 4080, 4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 
4089, 4090, 4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 
4099, 4100, 4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 
4109, 4110, 4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 
4119, 4120, 4121, 4122, 4123, 4124, 4125, 4126, 4127, 4128, 
4129, 4130, 4131, 4132, 4133, 4134, 4135, 4136, 4137, 4138, 
4139, 4140, 4141, 4142, 4143, 4144, 4145, 4146, 4147, 4148, 
4149, 4150, 4151, 4152, 4153, 4154, 4155, 4156, 4157, 4158, 
4159, 4160, 4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 
4169, 4170, 4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 
4179, 4180, 4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 
4189, 4190, 4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 
4199, 4200, 4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 
4209, 4210, 4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 
4219, 4220, 4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 
4229, 4230, 4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 
4239, 4240, 4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 
4249, 4250, 4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 
4259, 4260, 4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 
4269, 4270, 4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 
4279, 4280, 4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 
4289, 4290, 4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 
4299, 4300, 4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 
4309, 4310, 4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 
4319, 4320, 4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 
4329, 4330, 4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 
4339, 4340, 4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 
4349, 4350, 4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 
4359, 4360, 4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 
4369, 4370, 4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 
4379, 4380, 4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 
4389, 4390, 4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 
4399, 4400, 4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 
4409, 4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 
4419, 4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 
4429, 4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 
4439, 4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 
4449, 4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 
4459, 4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 
4469, 4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 
4479, 4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 
4489, 4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 
4499, 4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 
4509, 4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 
4519, 4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 
4529, 4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 
4539, 4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 
4549, 4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 
4559, 4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 
4569, 4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 
4579, 4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 
4589, 4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 
4599, 4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 
4609, 4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 
4619, 4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 
4629, 4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 
4639, 4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 
4649, 4650, 4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 
4659, 4660, 4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 
4669, 4670, 4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 
4679, 4680, 4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 
4689, 4690, 4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 
4699, 4700, 4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 
4709, 4710, 4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 
4719, 4720, 4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 
4729, 4730, 4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 
4739, 4740, 4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 
4749, 4750, 4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 
4759, 4760, 4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 
4769, 4770, 
*ELSET,ELSET=TO
3091, 3092, 3093, 3094, 3095, 3096, 3097, 3098, 3099, 3100, 
3101, 3102, 3103, 3104, 3105, 3106, 3107, 3108, 3109, 3110, 
3111, 3112, 3113, 3114, 3115, 3116, 3117, 3118, 3119, 3120, 
3121, 3122, 3123, 3124, 3125, 3126, 3127, 3128, 3129, 3130, 
3131, 3132, 3133, 3134, 3135, 3136, 3137, 3138, 3139, 3140, 
3141, 3142, 3143, 3144, 3145, 3146, 3147, 3148, 3149, 3150, 
3151, 3152, 3153, 3154, 3155, 3156, 3157, 3158, 3159, 3160, 
3161, 3162, 3163, 3164, 3165, 3166, 3167, 3168, 3169, 3170, 
3171, 3172, 3173, 3174, 3175, 3176, 3177, 3178, 3179, 3180, 
3181, 3182, 3183, 3184, 3185, 3186, 3187, 3188, 3189, 3190, 
3191, 3192, 3193, 3194, 3195, 3196, 3197, 3198, 3199, 3200, 
3201, 3202, 3203, 3204, 3205, 3206, 3207, 3208, 3209, 3210, 
3211, 3212, 3213, 3214, 3215, 3216, 3217, 3218, 3219, 3220, 
3221, 3222, 3223, 3224, 3225, 3226, 3227, 3228, 3229, 3230, 
3231, 3232, 3233, 3234, 3235, 3236, 3237, 3238, 3239, 3240, 
3241, 3242, 3243, 3244, 3245, 3246, 3247, 3248, 3249, 3250, 
3251, 3252, 3253, 3254, 3255, 3256, 3257, 3258, 3259, 3260, 
3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 3269, 3270, 
3271, 3272, 3273, 3274, 3275, 3276, 3277, 3278, 3279, 3280, 
3281, 3282, 3283, 3284, 3285, 3286, 3571, 3572, 3573, 3574, 
3575, 3576, 3577, 3578, 3579, 3580, 3581, 3582, 3583, 3584, 
3585, 3586, 3587, 3588, 3589, 3590, 3591, 3592, 3593, 3594, 
3595, 3596, 3597, 3598, 3599, 3600, 3601, 3602, 3603, 3604, 
3605, 3606, 3607, 3608, 3609, 3610, 3611, 3612, 3613, 3614, 
3615, 3616, 3617, 3618, 3619, 3620, 3621, 3622, 3623, 3624, 
3625, 3626, 3627, 3628, 3629, 3630, 3631, 3632, 3633, 3634, 
3635, 3636, 3637, 3638, 3639, 3640, 3641, 3642, 3643, 3644, 
3645, 3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 
3655, 3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 
3665, 3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 
3675, 3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 
3685, 3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 
3695, 3696, 3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 
3705, 3706, 3707, 3708, 3709, 3710, 3711, 3712, 3713, 3714, 
3715, 3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724, 
3725, 3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 
3735, 3736, 3737, 3738, 3739, 3740, 3741, 3742, 3743, 3744, 
3745, 3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 
3755, 3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 
3765, 3766, 3903, 3904, 3905, 3906, 3907, 3908, 3909, 3910, 
3911, 3912, 3913, 3914, 3915, 3916, 3917, 3918, 3919, 3920, 
3921, 3922, 3923, 3924, 3925, 3926, 3927, 3928, 3929, 3930, 
3931, 3932, 3933, 3934, 3935, 3936, 3937, 3938, 3939, 3940, 
3941, 3942, 3943, 3944, 3945, 3946, 3947, 3948, 3949, 3950, 
3951, 3952, 3953, 3954, 3955, 3956, 3957, 3958, 3959, 3960, 
3961, 3962, 3963, 3964, 3965, 3966, 3967, 3968, 3969, 3970, 
3971, 3972, 3973, 3974, 3975, 3976, 3977, 3978, 3979, 3980, 
3981, 3982, 3983, 3984, 3985, 3986, 3987, 3988, 3989, 3990, 
3991, 3992, 3993, 3994, 3995, 3996, 3997, 3998, 3999, 4000, 
4001, 4002, 4003, 4004, 4005, 4006, 4007, 4008, 4009, 4010, 
4011, 4012, 4013, 4014, 4015, 4016, 4017, 4018, 4019, 4020, 
4021, 4022, 4023, 4024, 4025, 4026, 4027, 4028, 4029, 4030, 
4031, 4032, 4033, 4034, 4035, 4036, 4037, 4038, 4039, 4040, 
4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 
4051, 4052, 4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 
4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068, 4069, 4070, 
*ELSET,ELSET=Ceramic
4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 4080, 
4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 4090, 
4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 4100, 
4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 4110, 
4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 4120, 
4121, 4122, 4123, 4124, 4125, 4126, 4127, 4128, 4129, 4130, 
4131, 4132, 4133, 4134, 4135, 4136, 4137, 4138, 4139, 4140, 
4141, 4142, 4143, 4144, 4145, 4146, 4147, 4148, 4149, 4150, 
4151, 4152, 4153, 4154, 4155, 4156, 4157, 4158, 4159, 4160, 
4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 4169, 4170, 
4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 4179, 4180, 
4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 4189, 4190, 
4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 4199, 4200, 
4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 4209, 4210, 
4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 4219, 4220, 
4221, 4222, 4223, 4224, 4225, 4226, 4227, 4228, 4229, 4230, 
4231, 4232, 4233, 4234, 4235, 4236, 4237, 4238, 4239, 4240, 
4241, 4242, 4243, 4244, 4245, 4246, 4247, 4248, 4249, 4250, 
4251, 4252, 4253, 4254, 4255, 4256, 4257, 4258, 4259, 4260, 
4261, 4262, 4263, 4264, 4265, 4266, 4267, 4268, 4269, 4270, 
4271, 4272, 4273, 4274, 4275, 4276, 4277, 4278, 4279, 4280, 
4281, 4282, 4283, 4284, 4285, 4286, 4287, 4288, 4289, 4290, 
4291, 4292, 4293, 4294, 4295, 4296, 4297, 4298, 4299, 4300, 
4301, 4302, 4303, 4304, 4305, 4306, 4307, 4308, 4309, 4310, 
4311, 4312, 4313, 4314, 4315, 4316, 4317, 4318, 4319, 4320, 
4321, 4322, 4323, 4324, 4325, 4326, 4327, 4328, 4329, 4330, 
4331, 4332, 4333, 4334, 4335, 4336, 4337, 4338, 4339, 4340, 
4341, 4342, 4343, 4344, 4345, 4346, 4347, 4348, 4349, 4350, 
4351, 4352, 4353, 4354, 4355, 4356, 4357, 4358, 4359, 4360, 
4361, 4362, 4363, 4364, 4365, 4366, 4367, 4368, 4369, 4370, 
4371, 4372, 4373, 4374, 4375, 4376, 4377, 4378, 4379, 4380, 
4381, 4382, 4383, 4384, 4385, 4386, 4387, 4388, 4389, 4390, 
4391, 4392, 4393, 4394, 4395, 4396, 4397, 4398, 4399, 4400, 
4401, 4402, 4403, 4404, 4405, 4406, 4407, 4408, 4409, 4410, 
4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 4420, 
4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 4430, 
4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 4440, 
4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 4450, 
4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 4460, 
4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 4470, 
4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 4480, 
4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 4490, 
4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 4500, 
4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 4510, 
4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 4520, 
4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 4530, 
4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 4539, 4540, 
4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 4549, 4550, 
4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 4559, 4560, 
4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 4569, 4570, 
4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 4579, 4580, 
4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 4589, 4590, 
4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 4599, 4600, 
4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 4609, 4610, 
4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 4619, 4620, 
4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 4629, 4630, 
4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 4639, 4640, 
4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 4649, 4650, 
4651, 4652, 4653, 4654, 4655, 4656, 4657, 4658, 4659, 4660, 
4661, 4662, 4663, 4664, 4665, 4666, 4667, 4668, 4669, 4670, 
4671, 4672, 4673, 4674, 4675, 4676, 4677, 4678, 4679, 4680, 
4681, 4682, 4683, 4684, 4685, 4686, 4687, 4688, 4689, 4690, 
4691, 4692, 4693, 4694, 4695, 4696, 4697, 4698, 4699, 4700, 
4701, 4702, 4703, 4704, 4705, 4706, 4707, 4708, 4709, 4710, 
4711, 4712, 4713, 4714, 4715, 4716, 4717, 4718, 4719, 4720, 
4721, 4722, 4723, 4724, 4725, 4726, 4727, 4728, 4729, 4730, 
4731, 4732, 4733, 4734, 4735, 4736, 4737, 4738, 4739, 4740, 
4741, 4742, 4743, 4744, 4745, 4746, 4747, 4748, 4749, 4750, 
4751, 4752, 4753, 4754, 4755, 4756, 4757, 4758, 4759, 4760, 
4761, 4762, 4763, 4764, 4765, 4766, 4767, 4768, 4769, 4770, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 223, 224, 
225, 226, 227, 228, 231, 232, 233, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 249, 250, 251, 252, 
259, 260, 261, 262, 268, 269, 270, 277, 278, 279, 
280, 281, 282, 291, 292, 293, 294, 295, 296, 302, 
303, 304, 961, 962, 963, 964, 965, 966, 967, 968, 
969, 970, 971, 972, 973, 974, 975, 976, 977, 978, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 97, 98, 
99, 107, 108, 109, 117, 118, 119, 120, 121, 122, 
123, 124, 125, 126, 127, 128, 387, 388, 389, 390, 
391, 392, 397, 398, 399, 400, 401, 402, 403, 404, 
405, 406, 407, 408, 703, 704, 705, 706, 707, 708, 
709, 710, 711, 712, 713, 714, 715, 716, 717, 718, 
719, 720, 1289, 1290, 1291, 1292, 1293, 1294, 1295, 1296, 
1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 1305, 1306, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 1307, 1308, 1309, 1310, 1311, 1312, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 1313, 1314, 1315, 1316, 1317, 1318, 
*NSET,NSET=Force
18, 20, 22, 24, 216, 217, 218, 221, 222, 234, 
235, 242, 243, 244, 955, 956, 957, 958, 959, 960, 
*NSET,NSET=Ceramic_Top
77, 78, 79, 80, 81, 82, 83, 84, 533, 534, 
535, 536, 537, 538, 543, 544, 545, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 563, 564, 565, 566, 
571, 572, 573, 574, 575, 576, 577, 582, 583, 584, 
585, 586, 587, 592, 593, 594, 595, 596, 597, 598, 
599, 600, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 
1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 
1571, 1572, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
*NSET,NSET=Ceramic_Bottom
23, 26, 79, 81, 85, 86, 87, 88, 91, 92, 
93, 94, 249, 250, 251, 252, 539, 540, 541, 542, 
559, 560, 561, 562, 563, 564, 565, 566, 609, 610, 
611, 612, 613, 614, 619, 620, 621, 626, 627, 628, 
629, 630, 631, 632, 633, 634, 654, 655, 656, 657, 
658, 659, 668, 669, 670, 671, 672, 673, 674, 675, 
676, 677, 678, 679, 1517, 1518, 1519, 1520, 1521, 1522, 
1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 
1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 
1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 1825, 1826, 
1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 1835, 1836, 
1837, 1838, 1839, 1840, 1841, 1842, 
*NSET,NSET=Top_Semiconductors
13, 14, 15, 16, 33, 34, 35, 36, 171, 172, 
173, 174, 175, 176, 183, 184, 185, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 305, 306, 307, 308, 
309, 310, 311, 312, 313, 314, 315, 316, 317, 318, 
319, 320, 321, 322, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 
1099, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 
*NSET,NSET=top
77, 78, 79, 80, 81, 82, 83, 84, 533, 534, 
535, 536, 537, 538, 543, 544, 545, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 563, 564, 565, 566, 
571, 572, 573, 574, 575, 576, 577, 582, 583, 584, 
585, 586, 587, 592, 593, 594, 595, 596, 597, 598, 
599, 600, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 
1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 
1571, 1572, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
*NSET,NSET=bottom
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 609, 610, 611, 612, 613, 614, 619, 620, 
621, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
643, 644, 645, 654, 655, 656, 657, 658, 659, 668, 
669, 670, 671, 672, 673, 674, 675, 676, 677, 678, 
679, 688, 689, 690, 1723, 1724, 1725, 1726, 1727, 1728, 
1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 
1739, 1740, 1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 
1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 244, 245, 246, 
247, 248, 249, 250, 251, 252, 253, 254, 255, 256, 
257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 
267, 268, 269, 270, 271, 272, 273, 274, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 298, 299, 300, 301, 302, 303, 304, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 401, 402, 403, 404, 405, 406, 
407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 691, 692, 693, 694, 695, 696, 697, 698, 
699, 700, 701, 702, 703, 704, 705, 706, 707, 708, 
709, 710, 711, 712, 713, 714, 715, 716, 717, 718, 
719, 720, 721, 722, 723, 724, 725, 726, 727, 728, 
729, 730, 731, 732, 733, 734, 735, 736, 737, 738, 
739, 740, 741, 742, 743, 744, 745, 746, 747, 748, 
749, 750, 751, 752, 753, 754, 755, 756, 757, 758, 
759, 760, 761, 762, 907, 908, 909, 910, 911, 912, 
913, 914, 915, 916, 917, 918, 919, 920, 921, 922, 
923, 924, 925, 926, 927, 928, 929, 930, 931, 932, 
933, 934, 935, 936, 937, 938, 939, 940, 941, 942, 
943, 944, 945, 946, 947, 948, 949, 950, 951, 952, 
953, 954, 955, 956, 957, 958, 959, 960, 961, 962, 
963, 964, 965, 966, 967, 968, 969, 970, 971, 972, 
973, 974, 975, 976, 977, 978, 979, 980, 981, 982, 
983, 984, 985, 986, 987, 988, 989, 990, 991, 992, 
993, 994, 995, 996, 997, 998, 999, 1000, 1001, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 
1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 
1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 
1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 
1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1235, 1236, 
1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 1245, 1246, 
1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 1255, 1256, 
1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 
1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 1275, 1276, 
1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 1285, 1286, 
1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 1295, 1296, 
1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 1305, 1306, 
1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 1315, 1316, 
1317, 1318, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 
1863, 1864, 1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 
1873, 1874, 1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 
1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 1999, 2000, 
2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 
2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 
2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2203, 2204, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 
2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 
2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 
*NSET,NSET=SemiconductorN-
9, 10, 11, 12, 13, 14, 15, 16, 57, 58, 
59, 60, 65, 66, 67, 68, 75, 76, 141, 142, 
143, 144, 145, 146, 147, 148, 149, 150, 151, 152, 
153, 154, 155, 156, 157, 158, 159, 160, 161, 162, 
163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 
173, 174, 175, 176, 177, 178, 179, 180, 181, 182, 
183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 
193, 194, 195, 196, 197, 198, 199, 200, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 465, 466, 467, 468, 
469, 470, 471, 472, 473, 474, 475, 476, 477, 478, 
479, 480, 481, 482, 483, 484, 485, 486, 487, 488, 
519, 520, 521, 522, 523, 524, 763, 764, 765, 766, 
767, 768, 769, 770, 771, 772, 773, 774, 775, 776, 
777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 
787, 788, 789, 790, 791, 792, 793, 794, 795, 796, 
797, 798, 799, 800, 801, 802, 803, 804, 805, 806, 
807, 808, 809, 810, 811, 812, 813, 814, 815, 816, 
817, 818, 819, 820, 821, 822, 823, 824, 825, 826, 
827, 828, 829, 830, 831, 832, 833, 834, 835, 836, 
837, 838, 839, 840, 841, 842, 843, 844, 845, 846, 
847, 848, 849, 850, 851, 852, 853, 854, 855, 856, 
857, 858, 859, 860, 861, 862, 863, 864, 865, 866, 
867, 868, 869, 870, 871, 872, 873, 874, 875, 876, 
877, 878, 879, 880, 881, 882, 883, 884, 885, 886, 
887, 888, 889, 890, 891, 892, 893, 894, 895, 896, 
897, 898, 899, 900, 901, 902, 903, 904, 905, 906, 
1319, 1320, 1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 
1329, 1330, 1331, 1332, 1333, 1334, 1335, 1336, 1355, 1356, 
1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 1366, 
1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 1376, 
1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 1386, 
1387, 1388, 1389, 1390, 1891, 1892, 1893, 1894, 1895, 1896, 
1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 1905, 1906, 
1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 1915, 1916, 
1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 1925, 1926, 
1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 1935, 1936, 
1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 1945, 1946, 
1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 1955, 1956, 
1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 
1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 
1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 1985, 1986, 
1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 
1997, 1998, 
*NSET,NSET=SemiconductorP+
33, 34, 35, 36, 37, 38, 39, 40, 61, 62, 
63, 64, 69, 70, 71, 72, 73, 74, 305, 306, 
307, 308, 309, 310, 311, 312, 313, 314, 315, 316, 
317, 318, 319, 320, 321, 322, 323, 324, 325, 326, 
327, 328, 329, 330, 331, 332, 333, 334, 335, 336, 
337, 338, 339, 340, 341, 342, 343, 344, 345, 346, 
347, 348, 349, 350, 351, 352, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 447, 448, 
449, 450, 451, 452, 453, 454, 455, 456, 457, 458, 
459, 460, 461, 462, 463, 464, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 1345, 1346, 
1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 1391, 1392, 
1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 
1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 
1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 
1423, 1424, 1425, 1426, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 
2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 
2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 
2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 
2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 
2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 
2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 
2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 
2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 2189, 2190, 
2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 2199, 2200, 
2201, 2202, 
*NSET,NSET=Solder
3, 4, 7, 8, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 25, 27, 29, 31, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 102, 103, 104, 112, 113, 114, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 171, 172, 
173, 174, 175, 176, 183, 184, 185, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 265, 266, 267, 271, 272, 273, 
274, 275, 276, 285, 286, 287, 288, 289, 290, 299, 
300, 301, 305, 306, 307, 308, 309, 310, 311, 312, 
313, 314, 315, 316, 317, 318, 319, 320, 321, 322, 
335, 336, 337, 338, 339, 340, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 721, 722, 723, 724, 
725, 726, 727, 728, 729, 730, 731, 732, 733, 734, 
735, 736, 737, 738, 763, 764, 765, 766, 767, 768, 
769, 770, 771, 772, 773, 774, 775, 776, 777, 778, 
779, 780, 889, 890, 891, 892, 893, 894, 895, 896, 
897, 898, 899, 900, 901, 902, 903, 904, 905, 906, 
907, 908, 909, 910, 911, 912, 913, 914, 915, 916, 
917, 918, 919, 920, 921, 922, 923, 924, 1049, 1050, 
1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 
1061, 1062, 1063, 1064, 1065, 1066, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1217, 1218, 1219, 1220, 1221, 1222, 
1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 
1233, 1234, 1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 
