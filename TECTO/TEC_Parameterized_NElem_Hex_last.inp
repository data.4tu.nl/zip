30197, 29391, 29435, 29439, 29395, 29392, 29436, 29440, 29396
30198, 29392, 29436, 29440, 29396, 29393, 29437, 29441, 29397
30199, 29393, 29437, 29441, 29397, 29394, 29438, 29442, 29398
30200, 29394, 29438, 29442, 29398, 11966, 11977, 11978, 11967
30201, 2193, 2204, 2205, 2194, 29395, 29439, 29443, 29399
30202, 29395, 29439, 29443, 29399, 29396, 29440, 29444, 29400
30203, 29396, 29440, 29444, 29400, 29397, 29441, 29445, 29401
30204, 29397, 29441, 29445, 29401, 29398, 29442, 29446, 29402
30205, 29398, 29442, 29446, 29402, 11967, 11978, 11979, 11968
30206, 2194, 2205, 2206, 2195, 29399, 29443, 29447, 29403
30207, 29399, 29443, 29447, 29403, 29400, 29444, 29448, 29404
30208, 29400, 29444, 29448, 29404, 29401, 29445, 29449, 29405
30209, 29401, 29445, 29449, 29405, 29402, 29446, 29450, 29406
30210, 29402, 29446, 29450, 29406, 11968, 11979, 11980, 11969
30211, 2195, 2206, 2207, 2196, 29403, 29447, 29451, 29407
30212, 29403, 29447, 29451, 29407, 29404, 29448, 29452, 29408
30213, 29404, 29448, 29452, 29408, 29405, 29449, 29453, 29409
30214, 29405, 29449, 29453, 29409, 29406, 29450, 29454, 29410
30215, 29406, 29450, 29454, 29410, 11969, 11980, 11981, 11970
30216, 2196, 2207, 2208, 2197, 29407, 29451, 29455, 29411
30217, 29407, 29451, 29455, 29411, 29408, 29452, 29456, 29412
30218, 29408, 29452, 29456, 29412, 29409, 29453, 29457, 29413
30219, 29409, 29453, 29457, 29413, 29410, 29454, 29458, 29414
30220, 29410, 29454, 29458, 29414, 11970, 11981, 11982, 11971
30221, 2197, 2208, 191, 190, 29411, 29455, 11703, 11699
30222, 29411, 29455, 11703, 11699, 29412, 29456, 11704, 11700
30223, 29412, 29456, 11704, 11700, 29413, 29457, 11705, 11701
30224, 29413, 29457, 11705, 11701, 29414, 29458, 11706, 11702
30225, 29414, 29458, 11706, 11702, 11971, 11982, 1808, 1807
30226, 168, 169, 2209, 2198, 11567, 11571, 29459, 29415
30227, 11567, 11571, 29459, 29415, 11568, 11572, 29460, 29416
30228, 11568, 11572, 29460, 29416, 11569, 11573, 29461, 29417
30229, 11569, 11573, 29461, 29417, 11570, 11574, 29462, 29418
30230, 11570, 11574, 29462, 29418, 1766, 1767, 11983, 11972
30231, 2198, 2209, 2210, 2199, 29415, 29459, 29463, 29419
30232, 29415, 29459, 29463, 29419, 29416, 29460, 29464, 29420
30233, 29416, 29460, 29464, 29420, 29417, 29461, 29465, 29421
30234, 29417, 29461, 29465, 29421, 29418, 29462, 29466, 29422
30235, 29418, 29462, 29466, 29422, 11972, 11983, 11984, 11973
30236, 2199, 2210, 2211, 2200, 29419, 29463, 29467, 29423
30237, 29419, 29463, 29467, 29423, 29420, 29464, 29468, 29424
30238, 29420, 29464, 29468, 29424, 29421, 29465, 29469, 29425
30239, 29421, 29465, 29469, 29425, 29422, 29466, 29470, 29426
30240, 29422, 29466, 29470, 29426, 11973, 11984, 11985, 11974
30241, 2200, 2211, 2212, 2201, 29423, 29467, 29471, 29427
30242, 29423, 29467, 29471, 29427, 29424, 29468, 29472, 29428
30243, 29424, 29468, 29472, 29428, 29425, 29469, 29473, 29429
30244, 29425, 29469, 29473, 29429, 29426, 29470, 29474, 29430
30245, 29426, 29470, 29474, 29430, 11974, 11985, 11986, 11975
30246, 2201, 2212, 2213, 2202, 29427, 29471, 29475, 29431
30247, 29427, 29471, 29475, 29431, 29428, 29472, 29476, 29432
30248, 29428, 29472, 29476, 29432, 29429, 29473, 29477, 29433
30249, 29429, 29473, 29477, 29433, 29430, 29474, 29478, 29434
30250, 29430, 29474, 29478, 29434, 11975, 11986, 11987, 11976
30251, 2202, 2213, 2214, 2203, 29431, 29475, 29479, 29435
30252, 29431, 29475, 29479, 29435, 29432, 29476, 29480, 29436
30253, 29432, 29476, 29480, 29436, 29433, 29477, 29481, 29437
30254, 29433, 29477, 29481, 29437, 29434, 29478, 29482, 29438
30255, 29434, 29478, 29482, 29438, 11976, 11987, 11988, 11977
30256, 2203, 2214, 2215, 2204, 29435, 29479, 29483, 29439
30257, 29435, 29479, 29483, 29439, 29436, 29480, 29484, 29440
30258, 29436, 29480, 29484, 29440, 29437, 29481, 29485, 29441
30259, 29437, 29481, 29485, 29441, 29438, 29482, 29486, 29442
30260, 29438, 29482, 29486, 29442, 11977, 11988, 11989, 11978
30261, 2204, 2215, 2216, 2205, 29439, 29483, 29487, 29443
30262, 29439, 29483, 29487, 29443, 29440, 29484, 29488, 29444
30263, 29440, 29484, 29488, 29444, 29441, 29485, 29489, 29445
30264, 29441, 29485, 29489, 29445, 29442, 29486, 29490, 29446
30265, 29442, 29486, 29490, 29446, 11978, 11989, 11990, 11979
30266, 2205, 2216, 2217, 2206, 29443, 29487, 29491, 29447
30267, 29443, 29487, 29491, 29447, 29444, 29488, 29492, 29448
30268, 29444, 29488, 29492, 29448, 29445, 29489, 29493, 29449
30269, 29445, 29489, 29493, 29449, 29446, 29490, 29494, 29450
30270, 29446, 29490, 29494, 29450, 11979, 11990, 11991, 11980
30271, 2206, 2217, 2218, 2207, 29447, 29491, 29495, 29451
30272, 29447, 29491, 29495, 29451, 29448, 29492, 29496, 29452
30273, 29448, 29492, 29496, 29452, 29449, 29493, 29497, 29453
30274, 29449, 29493, 29497, 29453, 29450, 29494, 29498, 29454
30275, 29450, 29494, 29498, 29454, 11980, 11991, 11992, 11981
30276, 2207, 2218, 2219, 2208, 29451, 29495, 29499, 29455
30277, 29451, 29495, 29499, 29455, 29452, 29496, 29500, 29456
30278, 29452, 29496, 29500, 29456, 29453, 29497, 29501, 29457
30279, 29453, 29497, 29501, 29457, 29454, 29498, 29502, 29458
30280, 29454, 29498, 29502, 29458, 11981, 11992, 11993, 11982
30281, 2208, 2219, 192, 191, 29455, 29499, 11707, 11703
30282, 29455, 29499, 11707, 11703, 29456, 29500, 11708, 11704
30283, 29456, 29500, 11708, 11704, 29457, 29501, 11709, 11705
30284, 29457, 29501, 11709, 11705, 29458, 29502, 11710, 11706
30285, 29458, 29502, 11710, 11706, 11982, 11993, 1809, 1808
30286, 169, 170, 2220, 2209, 11571, 11575, 29503, 29459
30287, 11571, 11575, 29503, 29459, 11572, 11576, 29504, 29460
30288, 11572, 11576, 29504, 29460, 11573, 11577, 29505, 29461
30289, 11573, 11577, 29505, 29461, 11574, 11578, 29506, 29462
30290, 11574, 11578, 29506, 29462, 1767, 1768, 11994, 11983
30291, 2209, 2220, 2221, 2210, 29459, 29503, 29507, 29463
30292, 29459, 29503, 29507, 29463, 29460, 29504, 29508, 29464
30293, 29460, 29504, 29508, 29464, 29461, 29505, 29509, 29465
30294, 29461, 29505, 29509, 29465, 29462, 29506, 29510, 29466
30295, 29462, 29506, 29510, 29466, 11983, 11994, 11995, 11984
30296, 2210, 2221, 2222, 2211, 29463, 29507, 29511, 29467
30297, 29463, 29507, 29511, 29467, 29464, 29508, 29512, 29468
30298, 29464, 29508, 29512, 29468, 29465, 29509, 29513, 29469
30299, 29465, 29509, 29513, 29469, 29466, 29510, 29514, 29470
30300, 29466, 29510, 29514, 29470, 11984, 11995, 11996, 11985
30301, 2211, 2222, 2223, 2212, 29467, 29511, 29515, 29471
30302, 29467, 29511, 29515, 29471, 29468, 29512, 29516, 29472
30303, 29468, 29512, 29516, 29472, 29469, 29513, 29517, 29473
30304, 29469, 29513, 29517, 29473, 29470, 29514, 29518, 29474
30305, 29470, 29514, 29518, 29474, 11985, 11996, 11997, 11986
30306, 2212, 2223, 2224, 2213, 29471, 29515, 29519, 29475
30307, 29471, 29515, 29519, 29475, 29472, 29516, 29520, 29476
30308, 29472, 29516, 29520, 29476, 29473, 29517, 29521, 29477
30309, 29473, 29517, 29521, 29477, 29474, 29518, 29522, 29478
30310, 29474, 29518, 29522, 29478, 11986, 11997, 11998, 11987
30311, 2213, 2224, 2225, 2214, 29475, 29519, 29523, 29479
30312, 29475, 29519, 29523, 29479, 29476, 29520, 29524, 29480
30313, 29476, 29520, 29524, 29480, 29477, 29521, 29525, 29481
30314, 29477, 29521, 29525, 29481, 29478, 29522, 29526, 29482
30315, 29478, 29522, 29526, 29482, 11987, 11998, 11999, 11988
30316, 2214, 2225, 2226, 2215, 29479, 29523, 29527, 29483
30317, 29479, 29523, 29527, 29483, 29480, 29524, 29528, 29484
30318, 29480, 29524, 29528, 29484, 29481, 29525, 29529, 29485
30319, 29481, 29525, 29529, 29485, 29482, 29526, 29530, 29486
30320, 29482, 29526, 29530, 29486, 11988, 11999, 12000, 11989
30321, 2215, 2226, 2227, 2216, 29483, 29527, 29531, 29487
30322, 29483, 29527, 29531, 29487, 29484, 29528, 29532, 29488
30323, 29484, 29528, 29532, 29488, 29485, 29529, 29533, 29489
30324, 29485, 29529, 29533, 29489, 29486, 29530, 29534, 29490
30325, 29486, 29530, 29534, 29490, 11989, 12000, 12001, 11990
30326, 2216, 2227, 2228, 2217, 29487, 29531, 29535, 29491
30327, 29487, 29531, 29535, 29491, 29488, 29532, 29536, 29492
30328, 29488, 29532, 29536, 29492, 29489, 29533, 29537, 29493
30329, 29489, 29533, 29537, 29493, 29490, 29534, 29538, 29494
30330, 29490, 29534, 29538, 29494, 11990, 12001, 12002, 11991
30331, 2217, 2228, 2229, 2218, 29491, 29535, 29539, 29495
30332, 29491, 29535, 29539, 29495, 29492, 29536, 29540, 29496
30333, 29492, 29536, 29540, 29496, 29493, 29537, 29541, 29497
30334, 29493, 29537, 29541, 29497, 29494, 29538, 29542, 29498
30335, 29494, 29538, 29542, 29498, 11991, 12002, 12003, 11992
30336, 2218, 2229, 2230, 2219, 29495, 29539, 29543, 29499
30337, 29495, 29539, 29543, 29499, 29496, 29540, 29544, 29500
30338, 29496, 29540, 29544, 29500, 29497, 29541, 29545, 29501
30339, 29497, 29541, 29545, 29501, 29498, 29542, 29546, 29502
30340, 29498, 29542, 29546, 29502, 11992, 12003, 12004, 11993
30341, 2219, 2230, 193, 192, 29499, 29543, 11711, 11707
30342, 29499, 29543, 11711, 11707, 29500, 29544, 11712, 11708
30343, 29500, 29544, 11712, 11708, 29501, 29545, 11713, 11709
30344, 29501, 29545, 11713, 11709, 29502, 29546, 11714, 11710
30345, 29502, 29546, 11714, 11710, 11993, 12004, 1810, 1809
30346, 170, 171, 2231, 2220, 11575, 11579, 29547, 29503
30347, 11575, 11579, 29547, 29503, 11576, 11580, 29548, 29504
30348, 11576, 11580, 29548, 29504, 11577, 11581, 29549, 29505
30349, 11577, 11581, 29549, 29505, 11578, 11582, 29550, 29506
30350, 11578, 11582, 29550, 29506, 1768, 1769, 12005, 11994
30351, 2220, 2231, 2232, 2221, 29503, 29547, 29551, 29507
30352, 29503, 29547, 29551, 29507, 29504, 29548, 29552, 29508
30353, 29504, 29548, 29552, 29508, 29505, 29549, 29553, 29509
30354, 29505, 29549, 29553, 29509, 29506, 29550, 29554, 29510
30355, 29506, 29550, 29554, 29510, 11994, 12005, 12006, 11995
30356, 2221, 2232, 2233, 2222, 29507, 29551, 29555, 29511
30357, 29507, 29551, 29555, 29511, 29508, 29552, 29556, 29512
30358, 29508, 29552, 29556, 29512, 29509, 29553, 29557, 29513
30359, 29509, 29553, 29557, 29513, 29510, 29554, 29558, 29514
30360, 29510, 29554, 29558, 29514, 11995, 12006, 12007, 11996
30361, 2222, 2233, 2234, 2223, 29511, 29555, 29559, 29515
30362, 29511, 29555, 29559, 29515, 29512, 29556, 29560, 29516
30363, 29512, 29556, 29560, 29516, 29513, 29557, 29561, 29517
30364, 29513, 29557, 29561, 29517, 29514, 29558, 29562, 29518
30365, 29514, 29558, 29562, 29518, 11996, 12007, 12008, 11997
30366, 2223, 2234, 2235, 2224, 29515, 29559, 29563, 29519
30367, 29515, 29559, 29563, 29519, 29516, 29560, 29564, 29520
30368, 29516, 29560, 29564, 29520, 29517, 29561, 29565, 29521
30369, 29517, 29561, 29565, 29521, 29518, 29562, 29566, 29522
30370, 29518, 29562, 29566, 29522, 11997, 12008, 12009, 11998
30371, 2224, 2235, 2236, 2225, 29519, 29563, 29567, 29523
30372, 29519, 29563, 29567, 29523, 29520, 29564, 29568, 29524
30373, 29520, 29564, 29568, 29524, 29521, 29565, 29569, 29525
30374, 29521, 29565, 29569, 29525, 29522, 29566, 29570, 29526
30375, 29522, 29566, 29570, 29526, 11998, 12009, 12010, 11999
30376, 2225, 2236, 2237, 2226, 29523, 29567, 29571, 29527
30377, 29523, 29567, 29571, 29527, 29524, 29568, 29572, 29528
30378, 29524, 29568, 29572, 29528, 29525, 29569, 29573, 29529
30379, 29525, 29569, 29573, 29529, 29526, 29570, 29574, 29530
30380, 29526, 29570, 29574, 29530, 11999, 12010, 12011, 12000
30381, 2226, 2237, 2238, 2227, 29527, 29571, 29575, 29531
30382, 29527, 29571, 29575, 29531, 29528, 29572, 29576, 29532
30383, 29528, 29572, 29576, 29532, 29529, 29573, 29577, 29533
30384, 29529, 29573, 29577, 29533, 29530, 29574, 29578, 29534
30385, 29530, 29574, 29578, 29534, 12000, 12011, 12012, 12001
30386, 2227, 2238, 2239, 2228, 29531, 29575, 29579, 29535
30387, 29531, 29575, 29579, 29535, 29532, 29576, 29580, 29536
30388, 29532, 29576, 29580, 29536, 29533, 29577, 29581, 29537
30389, 29533, 29577, 29581, 29537, 29534, 29578, 29582, 29538
30390, 29534, 29578, 29582, 29538, 12001, 12012, 12013, 12002
30391, 2228, 2239, 2240, 2229, 29535, 29579, 29583, 29539
30392, 29535, 29579, 29583, 29539, 29536, 29580, 29584, 29540
30393, 29536, 29580, 29584, 29540, 29537, 29581, 29585, 29541
30394, 29537, 29581, 29585, 29541, 29538, 29582, 29586, 29542
30395, 29538, 29582, 29586, 29542, 12002, 12013, 12014, 12003
30396, 2229, 2240, 2241, 2230, 29539, 29583, 29587, 29543
30397, 29539, 29583, 29587, 29543, 29540, 29584, 29588, 29544
30398, 29540, 29584, 29588, 29544, 29541, 29585, 29589, 29545
30399, 29541, 29585, 29589, 29545, 29542, 29586, 29590, 29546
30400, 29542, 29586, 29590, 29546, 12003, 12014, 12015, 12004
30401, 2230, 2241, 194, 193, 29543, 29587, 11715, 11711
30402, 29543, 29587, 11715, 11711, 29544, 29588, 11716, 11712
30403, 29544, 29588, 11716, 11712, 29545, 29589, 11717, 11713
30404, 29545, 29589, 11717, 11713, 29546, 29590, 11718, 11714
30405, 29546, 29590, 11718, 11714, 12004, 12015, 1811, 1810
30406, 171, 6, 123, 2231, 11579, 1739, 11583, 29547
30407, 11579, 1739, 11583, 29547, 11580, 1740, 11584, 29548
30408, 11580, 1740, 11584, 29548, 11581, 1741, 11585, 29549
30409, 11581, 1741, 11585, 29549, 11582, 1742, 11586, 29550
30410, 11582, 1742, 11586, 29550, 1769, 85, 1774, 12005
30411, 2231, 123, 124, 2232, 29547, 11583, 11587, 29551
30412, 29547, 11583, 11587, 29551, 29548, 11584, 11588, 29552
30413, 29548, 11584, 11588, 29552, 29549, 11585, 11589, 29553
30414, 29549, 11585, 11589, 29553, 29550, 11586, 11590, 29554
30415, 29550, 11586, 11590, 29554, 12005, 1774, 1775, 12006
30416, 2232, 124, 125, 2233, 29551, 11587, 11591, 29555
30417, 29551, 11587, 11591, 29555, 29552, 11588, 11592, 29556
30418, 29552, 11588, 11592, 29556, 29553, 11589, 11593, 29557
30419, 29553, 11589, 11593, 29557, 29554, 11590, 11594, 29558
30420, 29554, 11590, 11594, 29558, 12006, 1775, 1776, 12007
30421, 2233, 125, 126, 2234, 29555, 11591, 11595, 29559
30422, 29555, 11591, 11595, 29559, 29556, 11592, 11596, 29560
30423, 29556, 11592, 11596, 29560, 29557, 11593, 11597, 29561
30424, 29557, 11593, 11597, 29561, 29558, 11594, 11598, 29562
30425, 29558, 11594, 11598, 29562, 12007, 1776, 1777, 12008
30426, 2234, 126, 127, 2235, 29559, 11595, 11599, 29563
30427, 29559, 11595, 11599, 29563, 29560, 11596, 11600, 29564
30428, 29560, 11596, 11600, 29564, 29561, 11597, 11601, 29565
30429, 29561, 11597, 11601, 29565, 29562, 11598, 11602, 29566
30430, 29562, 11598, 11602, 29566, 12008, 1777, 1778, 12009
30431, 2235, 127, 128, 2236, 29563, 11599, 11603, 29567
30432, 29563, 11599, 11603, 29567, 29564, 11600, 11604, 29568
30433, 29564, 11600, 11604, 29568, 29565, 11601, 11605, 29569
30434, 29565, 11601, 11605, 29569, 29566, 11602, 11606, 29570
30435, 29566, 11602, 11606, 29570, 12009, 1778, 1779, 12010
30436, 2236, 128, 129, 2237, 29567, 11603, 11607, 29571
30437, 29567, 11603, 11607, 29571, 29568, 11604, 11608, 29572
30438, 29568, 11604, 11608, 29572, 29569, 11605, 11609, 29573
30439, 29569, 11605, 11609, 29573, 29570, 11606, 11610, 29574
30440, 29570, 11606, 11610, 29574, 12010, 1779, 1780, 12011
30441, 2237, 129, 130, 2238, 29571, 11607, 11611, 29575
30442, 29571, 11607, 11611, 29575, 29572, 11608, 11612, 29576
30443, 29572, 11608, 11612, 29576, 29573, 11609, 11613, 29577
30444, 29573, 11609, 11613, 29577, 29574, 11610, 11614, 29578
30445, 29574, 11610, 11614, 29578, 12011, 1780, 1781, 12012
30446, 2238, 130, 131, 2239, 29575, 11611, 11615, 29579
30447, 29575, 11611, 11615, 29579, 29576, 11612, 11616, 29580
30448, 29576, 11612, 11616, 29580, 29577, 11613, 11617, 29581
30449, 29577, 11613, 11617, 29581, 29578, 11614, 11618, 29582
30450, 29578, 11614, 11618, 29582, 12012, 1781, 1782, 12013
30451, 2239, 131, 132, 2240, 29579, 11615, 11619, 29583
30452, 29579, 11615, 11619, 29583, 29580, 11616, 11620, 29584
30453, 29580, 11616, 11620, 29584, 29581, 11617, 11621, 29585
30454, 29581, 11617, 11621, 29585, 29582, 11618, 11622, 29586
30455, 29582, 11618, 11622, 29586, 12013, 1782, 1783, 12014
30456, 2240, 132, 133, 2241, 29583, 11619, 11623, 29587
30457, 29583, 11619, 11623, 29587, 29584, 11620, 11624, 29588
30458, 29584, 11620, 11624, 29588, 29585, 11621, 11625, 29589
30459, 29585, 11621, 11625, 29589, 29586, 11622, 11626, 29590
30460, 29586, 11622, 11626, 29590, 12014, 1783, 1784, 12015
30461, 2241, 133, 5, 194, 29587, 11623, 1770, 11715
30462, 29587, 11623, 1770, 11715, 29588, 11624, 1771, 11716
30463, 29588, 11624, 1771, 11716, 29589, 11625, 1772, 11717
30464, 29589, 11625, 1772, 11717, 29590, 11626, 1773, 11718
30465, 29590, 11626, 1773, 11718, 12015, 1784, 87, 1811
*ELEMENT, type=C3D8, ELSET=Volume24
30466, 2, 97, 1171, 54, 1743, 11719, 12016, 1827
30467, 1743, 11719, 12016, 1827, 1744, 11720, 12017, 1828
30468, 1744, 11720, 12017, 1828, 1745, 11721, 12018, 1829
30469, 1745, 11721, 12018, 1829, 1746, 11722, 12019, 1830
30470, 1746, 11722, 12019, 1830, 86, 1812, 1831, 90
30471, 97, 98, 1172, 1171, 11719, 11723, 12020, 12016
30472, 11719, 11723, 12020, 12016, 11720, 11724, 12021, 12017
30473, 11720, 11724, 12021, 12017, 11721, 11725, 12022, 12018
30474, 11721, 11725, 12022, 12018, 11722, 11726, 12023, 12019
30475, 11722, 11726, 12023, 12019, 1812, 1813, 1832, 1831
30476, 98, 99, 1173, 1172, 11723, 11727, 12024, 12020
30477, 11723, 11727, 12024, 12020, 11724, 11728, 12025, 12021
30478, 11724, 11728, 12025, 12021, 11725, 11729, 12026, 12022
30479, 11725, 11729, 12026, 12022, 11726, 11730, 12027, 12023
30480, 11726, 11730, 12027, 12023, 1813, 1814, 1833, 1832
30481, 99, 100, 1174, 1173, 11727, 11731, 12028, 12024
30482, 11727, 11731, 12028, 12024, 11728, 11732, 12029, 12025
30483, 11728, 11732, 12029, 12025, 11729, 11733, 12030, 12026
30484, 11729, 11733, 12030, 12026, 11730, 11734, 12031, 12027
30485, 11730, 11734, 12031, 12027, 1814, 1815, 1834, 1833
30486, 100, 101, 1175, 1174, 11731, 11735, 12032, 12028
30487, 11731, 11735, 12032, 12028, 11732, 11736, 12033, 12029
30488, 11732, 11736, 12033, 12029, 11733, 11737, 12034, 12030
30489, 11733, 11737, 12034, 12030, 11734, 11738, 12035, 12031
30490, 11734, 11738, 12035, 12031, 1815, 1816, 1835, 1834
30491, 101, 102, 1176, 1175, 11735, 11739, 12036, 12032
30492, 11735, 11739, 12036, 12032, 11736, 11740, 12037, 12033
30493, 11736, 11740, 12037, 12033, 11737, 11741, 12038, 12034
30494, 11737, 11741, 12038, 12034, 11738, 11742, 12039, 12035
30495, 11738, 11742, 12039, 12035, 1816, 1817, 1836, 1835
30496, 102, 103, 1177, 1176, 11739, 11743, 12040, 12036
30497, 11739, 11743, 12040, 12036, 11740, 11744, 12041, 12037
30498, 11740, 11744, 12041, 12037, 11741, 11745, 12042, 12038
30499, 11741, 11745, 12042, 12038, 11742, 11746, 12043, 12039
30500, 11742, 11746, 12043, 12039, 1817, 1818, 1837, 1836
30501, 103, 104, 1178, 1177, 11743, 11747, 12044, 12040
30502, 11743, 11747, 12044, 12040, 11744, 11748, 12045, 12041
30503, 11744, 11748, 12045, 12041, 11745, 11749, 12046, 12042
30504, 11745, 11749, 12046, 12042, 11746, 11750, 12047, 12043
30505, 11746, 11750, 12047, 12043, 1818, 1819, 1838, 1837
30506, 104, 105, 1179, 1178, 11747, 11751, 12048, 12044
30507, 11747, 11751, 12048, 12044, 11748, 11752, 12049, 12045
30508, 11748, 11752, 12049, 12045, 11749, 11753, 12050, 12046
30509, 11749, 11753, 12050, 12046, 11750, 11754, 12051, 12047
30510, 11750, 11754, 12051, 12047, 1819, 1820, 1839, 1838
30511, 105, 106, 1180, 1179, 11751, 11755, 12052, 12048
30512, 11751, 11755, 12052, 12048, 11752, 11756, 12053, 12049
30513, 11752, 11756, 12053, 12049, 11753, 11757, 12054, 12050
30514, 11753, 11757, 12054, 12050, 11754, 11758, 12055, 12051
30515, 11754, 11758, 12055, 12051, 1820, 1821, 1840, 1839
30516, 106, 107, 1181, 1180, 11755, 11759, 12056, 12052
30517, 11755, 11759, 12056, 12052, 11756, 11760, 12057, 12053
30518, 11756, 11760, 12057, 12053, 11757, 11761, 12058, 12054
30519, 11757, 11761, 12058, 12054, 11758, 11762, 12059, 12055
30520, 11758, 11762, 12059, 12055, 1821, 1822, 1841, 1840
30521, 107, 1, 53, 1181, 11759, 1785, 1823, 12056
30522, 11759, 1785, 1823, 12056, 11760, 1786, 1824, 12057
30523, 11760, 1786, 1824, 12057, 11761, 1787, 1825, 12058
30524, 11761, 1787, 1825, 12058, 11762, 1788, 1826, 12059
30525, 11762, 1788, 1826, 12059, 1822, 88, 89, 1841
*ELEMENT, type=C3D8, ELSET=Volume25
30526, 47, 1100, 8504, 1123, 1873, 12152, 29591, 12244
30527, 1873, 12152, 29591, 12244, 1874, 12153, 29592, 12245
30528, 1874, 12153, 29592, 12245, 1875, 12154, 29593, 12246
30529, 1875, 12154, 29593, 12246, 1876, 12155, 29594, 12247
30530, 1876, 12155, 29594, 12247, 93, 1881, 12332, 1904
30531, 1100, 1101, 8505, 8504, 12152, 12156, 29595, 29591
30532, 12152, 12156, 29595, 29591, 12153, 12157, 29596, 29592
30533, 12153, 12157, 29596, 29592, 12154, 12158, 29597, 29593
30534, 12154, 12158, 29597, 29593, 12155, 12159, 29598, 29594
30535, 12155, 12159, 29598, 29594, 1881, 1882, 12333, 12332
30536, 1101, 1102, 8506, 8505, 12156, 12160, 29599, 29595
30537, 12156, 12160, 29599, 29595, 12157, 12161, 29600, 29596
30538, 12157, 12161, 29600, 29596, 12158, 12162, 29601, 29597
30539, 12158, 12162, 29601, 29597, 12159, 12163, 29602, 29598
30540, 12159, 12163, 29602, 29598, 1882, 1883, 12334, 12333
30541, 1102, 1103, 8507, 8506, 12160, 12164, 29603, 29599
30542, 12160, 12164, 29603, 29599, 12161, 12165, 29604, 29600
30543, 12161, 12165, 29604, 29600, 12162, 12166, 29605, 29601
30544, 12162, 12166, 29605, 29601, 12163, 12167, 29606, 29602
30545, 12163, 12167, 29606, 29602, 1883, 1884, 12335, 12334
30546, 1103, 1104, 8508, 8507, 12164, 12168, 29607, 29603
30547, 12164, 12168, 29607, 29603, 12165, 12169, 29608, 29604
30548, 12165, 12169, 29608, 29604, 12166, 12170, 29609, 29605
30549, 12166, 12170, 29609, 29605, 12167, 12171, 29610, 29606
30550, 12167, 12171, 29610, 29606, 1884, 1885, 12336, 12335
30551, 1104, 1105, 8509, 8508, 12168, 12172, 29611, 29607
30552, 12168, 12172, 29611, 29607, 12169, 12173, 29612, 29608
30553, 12169, 12173, 29612, 29608, 12170, 12174, 29613, 29609
30554, 12170, 12174, 29613, 29609, 12171, 12175, 29614, 29610
30555, 12171, 12175, 29614, 29610, 1885, 1886, 12337, 12336
30556, 1105, 1106, 8510, 8509, 12172, 12176, 29615, 29611
30557, 12172, 12176, 29615, 29611, 12173, 12177, 29616, 29612
30558, 12173, 12177, 29616, 29612, 12174, 12178, 29617, 29613
30559, 12174, 12178, 29617, 29613, 12175, 12179, 29618, 29614
30560, 12175, 12179, 29618, 29614, 1886, 1887, 12338, 12337
30561, 1106, 1107, 8511, 8510, 12176, 12180, 29619, 29615
30562, 12176, 12180, 29619, 29615, 12177, 12181, 29620, 29616
30563, 12177, 12181, 29620, 29616, 12178, 12182, 29621, 29617
30564, 12178, 12182, 29621, 29617, 12179, 12183, 29622, 29618
30565, 12179, 12183, 29622, 29618, 1887, 1888, 12339, 12338
30566, 1107, 1108, 8512, 8511, 12180, 12184, 29623, 29619
30567, 12180, 12184, 29623, 29619, 12181, 12185, 29624, 29620
30568, 12181, 12185, 29624, 29620, 12182, 12186, 29625, 29621
30569, 12182, 12186, 29625, 29621, 12183, 12187, 29626, 29622
30570, 12183, 12187, 29626, 29622, 1888, 1889, 12340, 12339
30571, 1108, 1109, 8513, 8512, 12184, 12188, 29627, 29623
30572, 12184, 12188, 29627, 29623, 12185, 12189, 29628, 29624
30573, 12185, 12189, 29628, 29624, 12186, 12190, 29629, 29625
30574, 12186, 12190, 29629, 29625, 12187, 12191, 29630, 29626
30575, 12187, 12191, 29630, 29626, 1889, 1890, 12341, 12340
30576, 1109, 1110, 8514, 8513, 12188, 12192, 29631, 29627
30577, 12188, 12192, 29631, 29627, 12189, 12193, 29632, 29628
30578, 12189, 12193, 29632, 29628, 12190, 12194, 29633, 29629
30579, 12190, 12194, 29633, 29629, 12191, 12195, 29634, 29630
30580, 12191, 12195, 29634, 29630, 1890, 1891, 12342, 12341
30581, 1110, 1111, 8515, 8514, 12192, 12196, 29635, 29631
30582, 12192, 12196, 29635, 29631, 12193, 12197, 29636, 29632
30583, 12193, 12197, 29636, 29632, 12194, 12198, 29637, 29633
30584, 12194, 12198, 29637, 29633, 12195, 12199, 29638, 29634
30585, 12195, 12199, 29638, 29634, 1891, 1892, 12343, 12342
30586, 1111, 1112, 8516, 8515, 12196, 12200, 29639, 29635
30587, 12196, 12200, 29639, 29635, 12197, 12201, 29640, 29636
30588, 12197, 12201, 29640, 29636, 12198, 12202, 29641, 29637
30589, 12198, 12202, 29641, 29637, 12199, 12203, 29642, 29638
30590, 12199, 12203, 29642, 29638, 1892, 1893, 12344, 12343
30591, 1112, 1113, 8517, 8516, 12200, 12204, 29643, 29639
30592, 12200, 12204, 29643, 29639, 12201, 12205, 29644, 29640
30593, 12201, 12205, 29644, 29640, 12202, 12206, 29645, 29641
30594, 12202, 12206, 29645, 29641, 12203, 12207, 29646, 29642
30595, 12203, 12207, 29646, 29642, 1893, 1894, 12345, 12344
30596, 1113, 1114, 8518, 8517, 12204, 12208, 29647, 29643
30597, 12204, 12208, 29647, 29643, 12205, 12209, 29648, 29644
30598, 12205, 12209, 29648, 29644, 12206, 12210, 29649, 29645
30599, 12206, 12210, 29649, 29645, 12207, 12211, 29650, 29646
30600, 12207, 12211, 29650, 29646, 1894, 1895, 12346, 12345
30601, 1114, 1115, 8519, 8518, 12208, 12212, 29651, 29647
30602, 12208, 12212, 29651, 29647, 12209, 12213, 29652, 29648
30603, 12209, 12213, 29652, 29648, 12210, 12214, 29653, 29649
30604, 12210, 12214, 29653, 29649, 12211, 12215, 29654, 29650
30605, 12211, 12215, 29654, 29650, 1895, 1896, 12347, 12346
30606, 1115, 1116, 8520, 8519, 12212, 12216, 29655, 29651
30607, 12212, 12216, 29655, 29651, 12213, 12217, 29656, 29652
30608, 12213, 12217, 29656, 29652, 12214, 12218, 29657, 29653
30609, 12214, 12218, 29657, 29653, 12215, 12219, 29658, 29654
30610, 12215, 12219, 29658, 29654, 1896, 1897, 12348, 12347
30611, 1116, 1117, 8521, 8520, 12216, 12220, 29659, 29655
30612, 12216, 12220, 29659, 29655, 12217, 12221, 29660, 29656
30613, 12217, 12221, 29660, 29656, 12218, 12222, 29661, 29657
30614, 12218, 12222, 29661, 29657, 12219, 12223, 29662, 29658
30615, 12219, 12223, 29662, 29658, 1897, 1898, 12349, 12348
30616, 1117, 1118, 8522, 8521, 12220, 12224, 29663, 29659
30617, 12220, 12224, 29663, 29659, 12221, 12225, 29664, 29660
30618, 12221, 12225, 29664, 29660, 12222, 12226, 29665, 29661
30619, 12222, 12226, 29665, 29661, 12223, 12227, 29666, 29662
30620, 12223, 12227, 29666, 29662, 1898, 1899, 12350, 12349
30621, 1118, 1119, 8523, 8522, 12224, 12228, 29667, 29663
30622, 12224, 12228, 29667, 29663, 12225, 12229, 29668, 29664
30623, 12225, 12229, 29668, 29664, 12226, 12230, 29669, 29665
30624, 12226, 12230, 29669, 29665, 12227, 12231, 29670, 29666
30625, 12227, 12231, 29670, 29666, 1899, 1900, 12351, 12350
30626, 1119, 1120, 8524, 8523, 12228, 12232, 29671, 29667
30627, 12228, 12232, 29671, 29667, 12229, 12233, 29672, 29668
30628, 12229, 12233, 29672, 29668, 12230, 12234, 29673, 29669
30629, 12230, 12234, 29673, 29669, 12231, 12235, 29674, 29670
30630, 12231, 12235, 29674, 29670, 1900, 1901, 12352, 12351
30631, 1120, 1121, 8525, 8524, 12232, 12236, 29675, 29671
30632, 12232, 12236, 29675, 29671, 12233, 12237, 29676, 29672
30633, 12233, 12237, 29676, 29672, 12234, 12238, 29677, 29673
30634, 12234, 12238, 29677, 29673, 12235, 12239, 29678, 29674
30635, 12235, 12239, 29678, 29674, 1901, 1902, 12353, 12352
30636, 1121, 1122, 8526, 8525, 12236, 12240, 29679, 29675
30637, 12236, 12240, 29679, 29675, 12237, 12241, 29680, 29676
30638, 12237, 12241, 29680, 29676, 12238, 12242, 29681, 29677
30639, 12238, 12242, 29681, 29677, 12239, 12243, 29682, 29678
30640, 12239, 12243, 29682, 29678, 1902, 1903, 12354, 12353
30641, 1122, 48, 1134, 8526, 12240, 1877, 12288, 29679
30642, 12240, 1877, 12288, 29679, 12241, 1878, 12289, 29680
30643, 12241, 1878, 12289, 29680, 12242, 1879, 12290, 29681
30644, 12242, 1879, 12290, 29681, 12243, 1880, 12291, 29682
30645, 12243, 1880, 12291, 29682, 1903, 94, 1915, 12354
30646, 1123, 8504, 8527, 1124, 12244, 29591, 29683, 12248
30647, 12244, 29591, 29683, 12248, 12245, 29592, 29684, 12249
30648, 12245, 29592, 29684, 12249, 12246, 29593, 29685, 12250
30649, 12246, 29593, 29685, 12250, 12247, 29594, 29686, 12251
30650, 12247, 29594, 29686, 12251, 1904, 12332, 12355, 1905
30651, 8504, 8505, 8528, 8527, 29591, 29595, 29687, 29683
30652, 29591, 29595, 29687, 29683, 29592, 29596, 29688, 29684
30653, 29592, 29596, 29688, 29684, 29593, 29597, 29689, 29685
30654, 29593, 29597, 29689, 29685, 29594, 29598, 29690, 29686
30655, 29594, 29598, 29690, 29686, 12332, 12333, 12356, 12355
30656, 8505, 8506, 8529, 8528, 29595, 29599, 29691, 29687
30657, 29595, 29599, 29691, 29687, 29596, 29600, 29692, 29688
30658, 29596, 29600, 29692, 29688, 29597, 29601, 29693, 29689
30659, 29597, 29601, 29693, 29689, 29598, 29602, 29694, 29690
30660, 29598, 29602, 29694, 29690, 12333, 12334, 12357, 12356
30661, 8506, 8507, 8530, 8529, 29599, 29603, 29695, 29691
30662, 29599, 29603, 29695, 29691, 29600, 29604, 29696, 29692
30663, 29600, 29604, 29696, 29692, 29601, 29605, 29697, 29693
30664, 29601, 29605, 29697, 29693, 29602, 29606, 29698, 29694
30665, 29602, 29606, 29698, 29694, 12334, 12335, 12358, 12357
30666, 8507, 8508, 8531, 8530, 29603, 29607, 29699, 29695
30667, 29603, 29607, 29699, 29695, 29604, 29608, 29700, 29696
30668, 29604, 29608, 29700, 29696, 29605, 29609, 29701, 29697
30669, 29605, 29609, 29701, 29697, 29606, 29610, 29702, 29698
30670, 29606, 29610, 29702, 29698, 12335, 12336, 12359, 12358
30671, 8508, 8509, 8532, 8531, 29607, 29611, 29703, 29699
30672, 29607, 29611, 29703, 29699, 29608, 29612, 29704, 29700
30673, 29608, 29612, 29704, 29700, 29609, 29613, 29705, 29701
30674, 29609, 29613, 29705, 29701, 29610, 29614, 29706, 29702
30675, 29610, 29614, 29706, 29702, 12336, 12337, 12360, 12359
30676, 8509, 8510, 8533, 8532, 29611, 29615, 29707, 29703
30677, 29611, 29615, 29707, 29703, 29612, 29616, 29708, 29704
30678, 29612, 29616, 29708, 29704, 29613, 29617, 29709, 29705
30679, 29613, 29617, 29709, 29705, 29614, 29618, 29710, 29706
30680, 29614, 29618, 29710, 29706, 12337, 12338, 12361, 12360
30681, 8510, 8511, 8534, 8533, 29615, 29619, 29711, 29707
30682, 29615, 29619, 29711, 29707, 29616, 29620, 29712, 29708
30683, 29616, 29620, 29712, 29708, 29617, 29621, 29713, 29709
30684, 29617, 29621, 29713, 29709, 29618, 29622, 29714, 29710
30685, 29618, 29622, 29714, 29710, 12338, 12339, 12362, 12361
30686, 8511, 8512, 8535, 8534, 29619, 29623, 29715, 29711
30687, 29619, 29623, 29715, 29711, 29620, 29624, 29716, 29712
30688, 29620, 29624, 29716, 29712, 29621, 29625, 29717, 29713
30689, 29621, 29625, 29717, 29713, 29622, 29626, 29718, 29714
30690, 29622, 29626, 29718, 29714, 12339, 12340, 12363, 12362
30691, 8512, 8513, 8536, 8535, 29623, 29627, 29719, 29715
30692, 29623, 29627, 29719, 29715, 29624, 29628, 29720, 29716
30693, 29624, 29628, 29720, 29716, 29625, 29629, 29721, 29717
30694, 29625, 29629, 29721, 29717, 29626, 29630, 29722, 29718
30695, 29626, 29630, 29722, 29718, 12340, 12341, 12364, 12363
30696, 8513, 8514, 8537, 8536, 29627, 29631, 29723, 29719
30697, 29627, 29631, 29723, 29719, 29628, 29632, 29724, 29720
30698, 29628, 29632, 29724, 29720, 29629, 29633, 29725, 29721
30699, 29629, 29633, 29725, 29721, 29630, 29634, 29726, 29722
30700, 29630, 29634, 29726, 29722, 12341, 12342, 12365, 12364
30701, 8514, 8515, 8538, 8537, 29631, 29635, 29727, 29723
30702, 29631, 29635, 29727, 29723, 29632, 29636, 29728, 29724
30703, 29632, 29636, 29728, 29724, 29633, 29637, 29729, 29725
30704, 29633, 29637, 29729, 29725, 29634, 29638, 29730, 29726
30705, 29634, 29638, 29730, 29726, 12342, 12343, 12366, 12365
30706, 8515, 8516, 8539, 8538, 29635, 29639, 29731, 29727
30707, 29635, 29639, 29731, 29727, 29636, 29640, 29732, 29728
30708, 29636, 29640, 29732, 29728, 29637, 29641, 29733, 29729
30709, 29637, 29641, 29733, 29729, 29638, 29642, 29734, 29730
30710, 29638, 29642, 29734, 29730, 12343, 12344, 12367, 12366
30711, 8516, 8517, 8540, 8539, 29639, 29643, 29735, 29731
30712, 29639, 29643, 29735, 29731, 29640, 29644, 29736, 29732
30713, 29640, 29644, 29736, 29732, 29641, 29645, 29737, 29733
30714, 29641, 29645, 29737, 29733, 29642, 29646, 29738, 29734
30715, 29642, 29646, 29738, 29734, 12344, 12345, 12368, 12367
30716, 8517, 8518, 8541, 8540, 29643, 29647, 29739, 29735
30717, 29643, 29647, 29739, 29735, 29644, 29648, 29740, 29736
30718, 29644, 29648, 29740, 29736, 29645, 29649, 29741, 29737
30719, 29645, 29649, 29741, 29737, 29646, 29650, 29742, 29738
30720, 29646, 29650, 29742, 29738, 12345, 12346, 12369, 12368
30721, 8518, 8519, 8542, 8541, 29647, 29651, 29743, 29739
30722, 29647, 29651, 29743, 29739, 29648, 29652, 29744, 29740
30723, 29648, 29652, 29744, 29740, 29649, 29653, 29745, 29741
30724, 29649, 29653, 29745, 29741, 29650, 29654, 29746, 29742
30725, 29650, 29654, 29746, 29742, 12346, 12347, 12370, 12369
30726, 8519, 8520, 8543, 8542, 29651, 29655, 29747, 29743
30727, 29651, 29655, 29747, 29743, 29652, 29656, 29748, 29744
30728, 29652, 29656, 29748, 29744, 29653, 29657, 29749, 29745
30729, 29653, 29657, 29749, 29745, 29654, 29658, 29750, 29746
30730, 29654, 29658, 29750, 29746, 12347, 12348, 12371, 12370
30731, 8520, 8521, 8544, 8543, 29655, 29659, 29751, 29747
30732, 29655, 29659, 29751, 29747, 29656, 29660, 29752, 29748
30733, 29656, 29660, 29752, 29748, 29657, 29661, 29753, 29749
30734, 29657, 29661, 29753, 29749, 29658, 29662, 29754, 29750
30735, 29658, 29662, 29754, 29750, 12348, 12349, 12372, 12371
30736, 8521, 8522, 8545, 8544, 29659, 29663, 29755, 29751
30737, 29659, 29663, 29755, 29751, 29660, 29664, 29756, 29752
30738, 29660, 29664, 29756, 29752, 29661, 29665, 29757, 29753
30739, 29661, 29665, 29757, 29753, 29662, 29666, 29758, 29754
30740, 29662, 29666, 29758, 29754, 12349, 12350, 12373, 12372
30741, 8522, 8523, 8546, 8545, 29663, 29667, 29759, 29755
30742, 29663, 29667, 29759, 29755, 29664, 29668, 29760, 29756
30743, 29664, 29668, 29760, 29756, 29665, 29669, 29761, 29757
30744, 29665, 29669, 29761, 29757, 29666, 29670, 29762, 29758
30745, 29666, 29670, 29762, 29758, 12350, 12351, 12374, 12373
30746, 8523, 8524, 8547, 8546, 29667, 29671, 29763, 29759
30747, 29667, 29671, 29763, 29759, 29668, 29672, 29764, 29760
30748, 29668, 29672, 29764, 29760, 29669, 29673, 29765, 29761
30749, 29669, 29673, 29765, 29761, 29670, 29674, 29766, 29762
30750, 29670, 29674, 29766, 29762, 12351, 12352, 12375, 12374
30751, 8524, 8525, 8548, 8547, 29671, 29675, 29767, 29763
30752, 29671, 29675, 29767, 29763, 29672, 29676, 29768, 29764
30753, 29672, 29676, 29768, 29764, 29673, 29677, 29769, 29765
30754, 29673, 29677, 29769, 29765, 29674, 29678, 29770, 29766
30755, 29674, 29678, 29770, 29766, 12352, 12353, 12376, 12375
30756, 8525, 8526, 8549, 8548, 29675, 29679, 29771, 29767
30757, 29675, 29679, 29771, 29767, 29676, 29680, 29772, 29768
30758, 29676, 29680, 29772, 29768, 29677, 29681, 29773, 29769
30759, 29677, 29681, 29773, 29769, 29678, 29682, 29774, 29770
30760, 29678, 29682, 29774, 29770, 12353, 12354, 12377, 12376
30761, 8526, 1134, 1135, 8549, 29679, 12288, 12292, 29771
30762, 29679, 12288, 12292, 29771, 29680, 12289, 12293, 29772
30763, 29680, 12289, 12293, 29772, 29681, 12290, 12294, 29773
30764, 29681, 12290, 12294, 29773, 29682, 12291, 12295, 29774
30765, 29682, 12291, 12295, 29774, 12354, 1915, 1916, 12377
30766, 1124, 8527, 8550, 1125, 12248, 29683, 29775, 12252
30767, 12248, 29683, 29775, 12252, 12249, 29684, 29776, 12253
30768, 12249, 29684, 29776, 12253, 12250, 29685, 29777, 12254
30769, 12250, 29685, 29777, 12254, 12251, 29686, 29778, 12255
30770, 12251, 29686, 29778, 12255, 1905, 12355, 12378, 1906
30771, 8527, 8528, 8551, 8550, 29683, 29687, 29779, 29775
30772, 29683, 29687, 29779, 29775, 29684, 29688, 29780, 29776
30773, 29684, 29688, 29780, 29776, 29685, 29689, 29781, 29777
30774, 29685, 29689, 29781, 29777, 29686, 29690, 29782, 29778
30775, 29686, 29690, 29782, 29778, 12355, 12356, 12379, 12378
30776, 8528, 8529, 8552, 8551, 29687, 29691, 29783, 29779
30777, 29687, 29691, 29783, 29779, 29688, 29692, 29784, 29780
30778, 29688, 29692, 29784, 29780, 29689, 29693, 29785, 29781
30779, 29689, 29693, 29785, 29781, 29690, 29694, 29786, 29782
30780, 29690, 29694, 29786, 29782, 12356, 12357, 12380, 12379
30781, 8529, 8530, 8553, 8552, 29691, 29695, 29787, 29783
30782, 29691, 29695, 29787, 29783, 29692, 29696, 29788, 29784
30783, 29692, 29696, 29788, 29784, 29693, 29697, 29789, 29785
30784, 29693, 29697, 29789, 29785, 29694, 29698, 29790, 29786
30785, 29694, 29698, 29790, 29786, 12357, 12358, 12381, 12380
30786, 8530, 8531, 8554, 8553, 29695, 29699, 29791, 29787
30787, 29695, 29699, 29791, 29787, 29696, 29700, 29792, 29788
30788, 29696, 29700, 29792, 29788, 29697, 29701, 29793, 29789
30789, 29697, 29701, 29793, 29789, 29698, 29702, 29794, 29790
30790, 29698, 29702, 29794, 29790, 12358, 12359, 12382, 12381
30791, 8531, 8532, 8555, 8554, 29699, 29703, 29795, 29791
30792, 29699, 29703, 29795, 29791, 29700, 29704, 29796, 29792
30793, 29700, 29704, 29796, 29792, 29701, 29705, 29797, 29793
30794, 29701, 29705, 29797, 29793, 29702, 29706, 29798, 29794
30795, 29702, 29706, 29798, 29794, 12359, 12360, 12383, 12382
30796, 8532, 8533, 8556, 8555, 29703, 29707, 29799, 29795
30797, 29703, 29707, 29799, 29795, 29704, 29708, 29800, 29796
30798, 29704, 29708, 29800, 29796, 29705, 29709, 29801, 29797
30799, 29705, 29709, 29801, 29797, 29706, 29710, 29802, 29798
30800, 29706, 29710, 29802, 29798, 12360, 12361, 12384, 12383
30801, 8533, 8534, 8557, 8556, 29707, 29711, 29803, 29799
30802, 29707, 29711, 29803, 29799, 29708, 29712, 29804, 29800
30803, 29708, 29712, 29804, 29800, 29709, 29713, 29805, 29801
30804, 29709, 29713, 29805, 29801, 29710, 29714, 29806, 29802
30805, 29710, 29714, 29806, 29802, 12361, 12362, 12385, 12384
30806, 8534, 8535, 8558, 8557, 29711, 29715, 29807, 29803
30807, 29711, 29715, 29807, 29803, 29712, 29716, 29808, 29804
30808, 29712, 29716, 29808, 29804, 29713, 29717, 29809, 29805
30809, 29713, 29717, 29809, 29805, 29714, 29718, 29810, 29806
30810, 29714, 29718, 29810, 29806, 12362, 12363, 12386, 12385
30811, 8535, 8536, 8559, 8558, 29715, 29719, 29811, 29807
30812, 29715, 29719, 29811, 29807, 29716, 29720, 29812, 29808
30813, 29716, 29720, 29812, 29808, 29717, 29721, 29813, 29809
30814, 29717, 29721, 29813, 29809, 29718, 29722, 29814, 29810
30815, 29718, 29722, 29814, 29810, 12363, 12364, 12387, 12386
30816, 8536, 8537, 8560, 8559, 29719, 29723, 29815, 29811
30817, 29719, 29723, 29815, 29811, 29720, 29724, 29816, 29812
30818, 29720, 29724, 29816, 29812, 29721, 29725, 29817, 29813
30819, 29721, 29725, 29817, 29813, 29722, 29726, 29818, 29814
30820, 29722, 29726, 29818, 29814, 12364, 12365, 12388, 12387
30821, 8537, 8538, 8561, 8560, 29723, 29727, 29819, 29815
30822, 29723, 29727, 29819, 29815, 29724, 29728, 29820, 29816
30823, 29724, 29728, 29820, 29816, 29725, 29729, 29821, 29817
30824, 29725, 29729, 29821, 29817, 29726, 29730, 29822, 29818
30825, 29726, 29730, 29822, 29818, 12365, 12366, 12389, 12388
30826, 8538, 8539, 8562, 8561, 29727, 29731, 29823, 29819
30827, 29727, 29731, 29823, 29819, 29728, 29732, 29824, 29820
30828, 29728, 29732, 29824, 29820, 29729, 29733, 29825, 29821
30829, 29729, 29733, 29825, 29821, 29730, 29734, 29826, 29822
30830, 29730, 29734, 29826, 29822, 12366, 12367, 12390, 12389
30831, 8539, 8540, 8563, 8562, 29731, 29735, 29827, 29823
30832, 29731, 29735, 29827, 29823, 29732, 29736, 29828, 29824
30833, 29732, 29736, 29828, 29824, 29733, 29737, 29829, 29825
30834, 29733, 29737, 29829, 29825, 29734, 29738, 29830, 29826
30835, 29734, 29738, 29830, 29826, 12367, 12368, 12391, 12390
30836, 8540, 8541, 8564, 8563, 29735, 29739, 29831, 29827
30837, 29735, 29739, 29831, 29827, 29736, 29740, 29832, 29828
30838, 29736, 29740, 29832, 29828, 29737, 29741, 29833, 29829
30839, 29737, 29741, 29833, 29829, 29738, 29742, 29834, 29830
30840, 29738, 29742, 29834, 29830, 12368, 12369, 12392, 12391
30841, 8541, 8542, 8565, 8564, 29739, 29743, 29835, 29831
30842, 29739, 29743, 29835, 29831, 29740, 29744, 29836, 29832
30843, 29740, 29744, 29836, 29832, 29741, 29745, 29837, 29833
30844, 29741, 29745, 29837, 29833, 29742, 29746, 29838, 29834
30845, 29742, 29746, 29838, 29834, 12369, 12370, 12393, 12392
30846, 8542, 8543, 8566, 8565, 29743, 29747, 29839, 29835
30847, 29743, 29747, 29839, 29835, 29744, 29748, 29840, 29836
30848, 29744, 29748, 29840, 29836, 29745, 29749, 29841, 29837
30849, 29745, 29749, 29841, 29837, 29746, 29750, 29842, 29838
30850, 29746, 29750, 29842, 29838, 12370, 12371, 12394, 12393
30851, 8543, 8544, 8567, 8566, 29747, 29751, 29843, 29839
30852, 29747, 29751, 29843, 29839, 29748, 29752, 29844, 29840
30853, 29748, 29752, 29844, 29840, 29749, 29753, 29845, 29841
30854, 29749, 29753, 29845, 29841, 29750, 29754, 29846, 29842
30855, 29750, 29754, 29846, 29842, 12371, 12372, 12395, 12394
30856, 8544, 8545, 8568, 8567, 29751, 29755, 29847, 29843
30857, 29751, 29755, 29847, 29843, 29752, 29756, 29848, 29844
30858, 29752, 29756, 29848, 29844, 29753, 29757, 29849, 29845
30859, 29753, 29757, 29849, 29845, 29754, 29758, 29850, 29846
30860, 29754, 29758, 29850, 29846, 12372, 12373, 12396, 12395
30861, 8545, 8546, 8569, 8568, 29755, 29759, 29851, 29847
30862, 29755, 29759, 29851, 29847, 29756, 29760, 29852, 29848
30863, 29756, 29760, 29852, 29848, 29757, 29761, 29853, 29849
30864, 29757, 29761, 29853, 29849, 29758, 29762, 29854, 29850
30865, 29758, 29762, 29854, 29850, 12373, 12374, 12397, 12396
30866, 8546, 8547, 8570, 8569, 29759, 29763, 29855, 29851
30867, 29759, 29763, 29855, 29851, 29760, 29764, 29856, 29852
30868, 29760, 29764, 29856, 29852, 29761, 29765, 29857, 29853
30869, 29761, 29765, 29857, 29853, 29762, 29766, 29858, 29854
30870, 29762, 29766, 29858, 29854, 12374, 12375, 12398, 12397
30871, 8547, 8548, 8571, 8570, 29763, 29767, 29859, 29855
30872, 29763, 29767, 29859, 29855, 29764, 29768, 29860, 29856
30873, 29764, 29768, 29860, 29856, 29765, 29769, 29861, 29857
30874, 29765, 29769, 29861, 29857, 29766, 29770, 29862, 29858
30875, 29766, 29770, 29862, 29858, 12375, 12376, 12399, 12398
30876, 8548, 8549, 8572, 8571, 29767, 29771, 29863, 29859
30877, 29767, 29771, 29863, 29859, 29768, 29772, 29864, 29860
30878, 29768, 29772, 29864, 29860, 29769, 29773, 29865, 29861
30879, 29769, 29773, 29865, 29861, 29770, 29774, 29866, 29862
30880, 29770, 29774, 29866, 29862, 12376, 12377, 12400, 12399
30881, 8549, 1135, 1136, 8572, 29771, 12292, 12296, 29863
30882, 29771, 12292, 12296, 29863, 29772, 12293, 12297, 29864
30883, 29772, 12293, 12297, 29864, 29773, 12294, 12298, 29865
30884, 29773, 12294, 12298, 29865, 29774, 12295, 12299, 29866
30885, 29774, 12295, 12299, 29866, 12377, 1916, 1917, 12400
30886, 1125, 8550, 8573, 1126, 12252, 29775, 29867, 12256
30887, 12252, 29775, 29867, 12256, 12253, 29776, 29868, 12257
30888, 12253, 29776, 29868, 12257, 12254, 29777, 29869, 12258
30889, 12254, 29777, 29869, 12258, 12255, 29778, 29870, 12259
30890, 12255, 29778, 29870, 12259, 1906, 12378, 12401, 1907
30891, 8550, 8551, 8574, 8573, 29775, 29779, 29871, 29867
30892, 29775, 29779, 29871, 29867, 29776, 29780, 29872, 29868
30893, 29776, 29780, 29872, 29868, 29777, 29781, 29873, 29869
30894, 29777, 29781, 29873, 29869, 29778, 29782, 29874, 29870
30895, 29778, 29782, 29874, 29870, 12378, 12379, 12402, 12401
30896, 8551, 8552, 8575, 8574, 29779, 29783, 29875, 29871
30897, 29779, 29783, 29875, 29871, 29780, 29784, 29876, 29872
30898, 29780, 29784, 29876, 29872, 29781, 29785, 29877, 29873
30899, 29781, 29785, 29877, 29873, 29782, 29786, 29878, 29874
30900, 29782, 29786, 29878, 29874, 12379, 12380, 12403, 12402
30901, 8552, 8553, 8576, 8575, 29783, 29787, 29879, 29875
30902, 29783, 29787, 29879, 29875, 29784, 29788, 29880, 29876
30903, 29784, 29788, 29880, 29876, 29785, 29789, 29881, 29877
30904, 29785, 29789, 29881, 29877, 29786, 29790, 29882, 29878
30905, 29786, 29790, 29882, 29878, 12380, 12381, 12404, 12403
30906, 8553, 8554, 8577, 8576, 29787, 29791, 29883, 29879
30907, 29787, 29791, 29883, 29879, 29788, 29792, 29884, 29880
30908, 29788, 29792, 29884, 29880, 29789, 29793, 29885, 29881
30909, 29789, 29793, 29885, 29881, 29790, 29794, 29886, 29882
30910, 29790, 29794, 29886, 29882, 12381, 12382, 12405, 12404
30911, 8554, 8555, 8578, 8577, 29791, 29795, 29887, 29883
30912, 29791, 29795, 29887, 29883, 29792, 29796, 29888, 29884
30913, 29792, 29796, 29888, 29884, 29793, 29797, 29889, 29885
30914, 29793, 29797, 29889, 29885, 29794, 29798, 29890, 29886
30915, 29794, 29798, 29890, 29886, 12382, 12383, 12406, 12405
30916, 8555, 8556, 8579, 8578, 29795, 29799, 29891, 29887
30917, 29795, 29799, 29891, 29887, 29796, 29800, 29892, 29888
30918, 29796, 29800, 29892, 29888, 29797, 29801, 29893, 29889
30919, 29797, 29801, 29893, 29889, 29798, 29802, 29894, 29890
30920, 29798, 29802, 29894, 29890, 12383, 12384, 12407, 12406
30921, 8556, 8557, 8580, 8579, 29799, 29803, 29895, 29891
30922, 29799, 29803, 29895, 29891, 29800, 29804, 29896, 29892
30923, 29800, 29804, 29896, 29892, 29801, 29805, 29897, 29893
30924, 29801, 29805, 29897, 29893, 29802, 29806, 29898, 29894
30925, 29802, 29806, 29898, 29894, 12384, 12385, 12408, 12407
30926, 8557, 8558, 8581, 8580, 29803, 29807, 29899, 29895
30927, 29803, 29807, 29899, 29895, 29804, 29808, 29900, 29896
30928, 29804, 29808, 29900, 29896, 29805, 29809, 29901, 29897
30929, 29805, 29809, 29901, 29897, 29806, 29810, 29902, 29898
30930, 29806, 29810, 29902, 29898, 12385, 12386, 12409, 12408
30931, 8558, 8559, 8582, 8581, 29807, 29811, 29903, 29899
30932, 29807, 29811, 29903, 29899, 29808, 29812, 29904, 29900
30933, 29808, 29812, 29904, 29900, 29809, 29813, 29905, 29901
30934, 29809, 29813, 29905, 29901, 29810, 29814, 29906, 29902
30935, 29810, 29814, 29906, 29902, 12386, 12387, 12410, 12409
30936, 8559, 8560, 8583, 8582, 29811, 29815, 29907, 29903
30937, 29811, 29815, 29907, 29903, 29812, 29816, 29908, 29904
30938, 29812, 29816, 29908, 29904, 29813, 29817, 29909, 29905
30939, 29813, 29817, 29909, 29905, 29814, 29818, 29910, 29906
30940, 29814, 29818, 29910, 29906, 12387, 12388, 12411, 12410
30941, 8560, 8561, 8584, 8583, 29815, 29819, 29911, 29907
30942, 29815, 29819, 29911, 29907, 29816, 29820, 29912, 29908
30943, 29816, 29820, 29912, 29908, 29817, 29821, 29913, 29909
30944, 29817, 29821, 29913, 29909, 29818, 29822, 29914, 29910
30945, 29818, 29822, 29914, 29910, 12388, 12389, 12412, 12411
30946, 8561, 8562, 8585, 8584, 29819, 29823, 29915, 29911
30947, 29819, 29823, 29915, 29911, 29820, 29824, 29916, 29912
30948, 29820, 29824, 29916, 29912, 29821, 29825, 29917, 29913
30949, 29821, 29825, 29917, 29913, 29822, 29826, 29918, 29914
30950, 29822, 29826, 29918, 29914, 12389, 12390, 12413, 12412
30951, 8562, 8563, 8586, 8585, 29823, 29827, 29919, 29915
30952, 29823, 29827, 29919, 29915, 29824, 29828, 29920, 29916
30953, 29824, 29828, 29920, 29916, 29825, 29829, 29921, 29917
30954, 29825, 29829, 29921, 29917, 29826, 29830, 29922, 29918
30955, 29826, 29830, 29922, 29918, 12390, 12391, 12414, 12413
30956, 8563, 8564, 8587, 8586, 29827, 29831, 29923, 29919
30957, 29827, 29831, 29923, 29919, 29828, 29832, 29924, 29920
30958, 29828, 29832, 29924, 29920, 29829, 29833, 29925, 29921
30959, 29829, 29833, 29925, 29921, 29830, 29834, 29926, 29922
30960, 29830, 29834, 29926, 29922, 12391, 12392, 12415, 12414
30961, 8564, 8565, 8588, 8587, 29831, 29835, 29927, 29923
30962, 29831, 29835, 29927, 29923, 29832, 29836, 29928, 29924
30963, 29832, 29836, 29928, 29924, 29833, 29837, 29929, 29925
30964, 29833, 29837, 29929, 29925, 29834, 29838, 29930, 29926
30965, 29834, 29838, 29930, 29926, 12392, 12393, 12416, 12415
30966, 8565, 8566, 8589, 8588, 29835, 29839, 29931, 29927
30967, 29835, 29839, 29931, 29927, 29836, 29840, 29932, 29928
30968, 29836, 29840, 29932, 29928, 29837, 29841, 29933, 29929
30969, 29837, 29841, 29933, 29929, 29838, 29842, 29934, 29930
30970, 29838, 29842, 29934, 29930, 12393, 12394, 12417, 12416
30971, 8566, 8567, 8590, 8589, 29839, 29843, 29935, 29931
30972, 29839, 29843, 29935, 29931, 29840, 29844, 29936, 29932
30973, 29840, 29844, 29936, 29932, 29841, 29845, 29937, 29933
30974, 29841, 29845, 29937, 29933, 29842, 29846, 29938, 29934
30975, 29842, 29846, 29938, 29934, 12394, 12395, 12418, 12417
30976, 8567, 8568, 8591, 8590, 29843, 29847, 29939, 29935
30977, 29843, 29847, 29939, 29935, 29844, 29848, 29940, 29936
30978, 29844, 29848, 29940, 29936, 29845, 29849, 29941, 29937
30979, 29845, 29849, 29941, 29937, 29846, 29850, 29942, 29938
30980, 29846, 29850, 29942, 29938, 12395, 12396, 12419, 12418
30981, 8568, 8569, 8592, 8591, 29847, 29851, 29943, 29939
30982, 29847, 29851, 29943, 29939, 29848, 29852, 29944, 29940
30983, 29848, 29852, 29944, 29940, 29849, 29853, 29945, 29941
30984, 29849, 29853, 29945, 29941, 29850, 29854, 29946, 29942
30985, 29850, 29854, 29946, 29942, 12396, 12397, 12420, 12419
30986, 8569, 8570, 8593, 8592, 29851, 29855, 29947, 29943
30987, 29851, 29855, 29947, 29943, 29852, 29856, 29948, 29944
30988, 29852, 29856, 29948, 29944, 29853, 29857, 29949, 29945
30989, 29853, 29857, 29949, 29945, 29854, 29858, 29950, 29946
30990, 29854, 29858, 29950, 29946, 12397, 12398, 12421, 12420
30991, 8570, 8571, 8594, 8593, 29855, 29859, 29951, 29947
30992, 29855, 29859, 29951, 29947, 29856, 29860, 29952, 29948
30993, 29856, 29860, 29952, 29948, 29857, 29861, 29953, 29949
30994, 29857, 29861, 29953, 29949, 29858, 29862, 29954, 29950
30995, 29858, 29862, 29954, 29950, 12398, 12399, 12422, 12421
30996, 8571, 8572, 8595, 8594, 29859, 29863, 29955, 29951
30997, 29859, 29863, 29955, 29951, 29860, 29864, 29956, 29952
30998, 29860, 29864, 29956, 29952, 29861, 29865, 29957, 29953
30999, 29861, 29865, 29957, 29953, 29862, 29866, 29958, 29954
31000, 29862, 29866, 29958, 29954, 12399, 12400, 12423, 12422
31001, 8572, 1136, 1137, 8595, 29863, 12296, 12300, 29955
31002, 29863, 12296, 12300, 29955, 29864, 12297, 12301, 29956
31003, 29864, 12297, 12301, 29956, 29865, 12298, 12302, 29957
31004, 29865, 12298, 12302, 29957, 29866, 12299, 12303, 29958
31005, 29866, 12299, 12303, 29958, 12400, 1917, 1918, 12423
31006, 1126, 8573, 8596, 1127, 12256, 29867, 29959, 12260
31007, 12256, 29867, 29959, 12260, 12257, 29868, 29960, 12261
31008, 12257, 29868, 29960, 12261, 12258, 29869, 29961, 12262
31009, 12258, 29869, 29961, 12262, 12259, 29870, 29962, 12263
31010, 12259, 29870, 29962, 12263, 1907, 12401, 12424, 1908
31011, 8573, 8574, 8597, 8596, 29867, 29871, 29963, 29959
31012, 29867, 29871, 29963, 29959, 29868, 29872, 29964, 29960
31013, 29868, 29872, 29964, 29960, 29869, 29873, 29965, 29961
31014, 29869, 29873, 29965, 29961, 29870, 29874, 29966, 29962
31015, 29870, 29874, 29966, 29962, 12401, 12402, 12425, 12424
31016, 8574, 8575, 8598, 8597, 29871, 29875, 29967, 29963
31017, 29871, 29875, 29967, 29963, 29872, 29876, 29968, 29964
31018, 29872, 29876, 29968, 29964, 29873, 29877, 29969, 29965
31019, 29873, 29877, 29969, 29965, 29874, 29878, 29970, 29966
31020, 29874, 29878, 29970, 29966, 12402, 12403, 12426, 12425
31021, 8575, 8576, 8599, 8598, 29875, 29879, 29971, 29967
31022, 29875, 29879, 29971, 29967, 29876, 29880, 29972, 29968
31023, 29876, 29880, 29972, 29968, 29877, 29881, 29973, 29969
31024, 29877, 29881, 29973, 29969, 29878, 29882, 29974, 29970
31025, 29878, 29882, 29974, 29970, 12403, 12404, 12427, 12426
31026, 8576, 8577, 8600, 8599, 29879, 29883, 29975, 29971
31027, 29879, 29883, 29975, 29971, 29880, 29884, 29976, 29972
31028, 29880, 29884, 29976, 29972, 29881, 29885, 29977, 29973
31029, 29881, 29885, 29977, 29973, 29882, 29886, 29978, 29974
31030, 29882, 29886, 29978, 29974, 12404, 12405, 12428, 12427
31031, 8577, 8578, 8601, 8600, 29883, 29887, 29979, 29975
31032, 29883, 29887, 29979, 29975, 29884, 29888, 29980, 29976
31033, 29884, 29888, 29980, 29976, 29885, 29889, 29981, 29977
31034, 29885, 29889, 29981, 29977, 29886, 29890, 29982, 29978
31035, 29886, 29890, 29982, 29978, 12405, 12406, 12429, 12428
31036, 8578, 8579, 8602, 8601, 29887, 29891, 29983, 29979
31037, 29887, 29891, 29983, 29979, 29888, 29892, 29984, 29980
31038, 29888, 29892, 29984, 29980, 29889, 29893, 29985, 29981
31039, 29889, 29893, 29985, 29981, 29890, 29894, 29986, 29982
31040, 29890, 29894, 29986, 29982, 12406, 12407, 12430, 12429
31041, 8579, 8580, 8603, 8602, 29891, 29895, 29987, 29983
31042, 29891, 29895, 29987, 29983, 29892, 29896, 29988, 29984
31043, 29892, 29896, 29988, 29984, 29893, 29897, 29989, 29985
31044, 29893, 29897, 29989, 29985, 29894, 29898, 29990, 29986
31045, 29894, 29898, 29990, 29986, 12407, 12408, 12431, 12430
31046, 8580, 8581, 8604, 8603, 29895, 29899, 29991, 29987
31047, 29895, 29899, 29991, 29987, 29896, 29900, 29992, 29988
31048, 29896, 29900, 29992, 29988, 29897, 29901, 29993, 29989
31049, 29897, 29901, 29993, 29989, 29898, 29902, 29994, 29990
31050, 29898, 29902, 29994, 29990, 12408, 12409, 12432, 12431
31051, 8581, 8582, 8605, 8604, 29899, 29903, 29995, 29991
31052, 29899, 29903, 29995, 29991, 29900, 29904, 29996, 29992
31053, 29900, 29904, 29996, 29992, 29901, 29905, 29997, 29993
31054, 29901, 29905, 29997, 29993, 29902, 29906, 29998, 29994
31055, 29902, 29906, 29998, 29994, 12409, 12410, 12433, 12432
31056, 8582, 8583, 8606, 8605, 29903, 29907, 29999, 29995
31057, 29903, 29907, 29999, 29995, 29904, 29908, 30000, 29996
31058, 29904, 29908, 30000, 29996, 29905, 29909, 30001, 29997
31059, 29905, 29909, 30001, 29997, 29906, 29910, 30002, 29998
31060, 29906, 29910, 30002, 29998, 12410, 12411, 12434, 12433
31061, 8583, 8584, 8607, 8606, 29907, 29911, 30003, 29999
31062, 29907, 29911, 30003, 29999, 29908, 29912, 30004, 30000
31063, 29908, 29912, 30004, 30000, 29909, 29913, 30005, 30001
31064, 29909, 29913, 30005, 30001, 29910, 29914, 30006, 30002
31065, 29910, 29914, 30006, 30002, 12411, 12412, 12435, 12434
31066, 8584, 8585, 8608, 8607, 29911, 29915, 30007, 30003
31067, 29911, 29915, 30007, 30003, 29912, 29916, 30008, 30004
31068, 29912, 29916, 30008, 30004, 29913, 29917, 30009, 30005
31069, 29913, 29917, 30009, 30005, 29914, 29918, 30010, 30006
31070, 29914, 29918, 30010, 30006, 12412, 12413, 12436, 12435
31071, 8585, 8586, 8609, 8608, 29915, 29919, 30011, 30007
31072, 29915, 29919, 30011, 30007, 29916, 29920, 30012, 30008
31073, 29916, 29920, 30012, 30008, 29917, 29921, 30013, 30009
31074, 29917, 29921, 30013, 30009, 29918, 29922, 30014, 30010
31075, 29918, 29922, 30014, 30010, 12413, 12414, 12437, 12436
31076, 8586, 8587, 8610, 8609, 29919, 29923, 30015, 30011
31077, 29919, 29923, 30015, 30011, 29920, 29924, 30016, 30012
31078, 29920, 29924, 30016, 30012, 29921, 29925, 30017, 30013
31079, 29921, 29925, 30017, 30013, 29922, 29926, 30018, 30014
31080, 29922, 29926, 30018, 30014, 12414, 12415, 12438, 12437
31081, 8587, 8588, 8611, 8610, 29923, 29927, 30019, 30015
31082, 29923, 29927, 30019, 30015, 29924, 29928, 30020, 30016
31083, 29924, 29928, 30020, 30016, 29925, 29929, 30021, 30017
31084, 29925, 29929, 30021, 30017, 29926, 29930, 30022, 30018
31085, 29926, 29930, 30022, 30018, 12415, 12416, 12439, 12438
31086, 8588, 8589, 8612, 8611, 29927, 29931, 30023, 30019
31087, 29927, 29931, 30023, 30019, 29928, 29932, 30024, 30020
31088, 29928, 29932, 30024, 30020, 29929, 29933, 30025, 30021
31089, 29929, 29933, 30025, 30021, 29930, 29934, 30026, 30022
31090, 29930, 29934, 30026, 30022, 12416, 12417, 12440, 12439
31091, 8589, 8590, 8613, 8612, 29931, 29935, 30027, 30023
31092, 29931, 29935, 30027, 30023, 29932, 29936, 30028, 30024
31093, 29932, 29936, 30028, 30024, 29933, 29937, 30029, 30025
31094, 29933, 29937, 30029, 30025, 29934, 29938, 30030, 30026
31095, 29934, 29938, 30030, 30026, 12417, 12418, 12441, 12440
31096, 8590, 8591, 8614, 8613, 29935, 29939, 30031, 30027
31097, 29935, 29939, 30031, 30027, 29936, 29940, 30032, 30028
31098, 29936, 29940, 30032, 30028, 29937, 29941, 30033, 30029
31099, 29937, 29941, 30033, 30029, 29938, 29942, 30034, 30030
31100, 29938, 29942, 30034, 30030, 12418, 12419, 12442, 12441
31101, 8591, 8592, 8615, 8614, 29939, 29943, 30035, 30031
31102, 29939, 29943, 30035, 30031, 29940, 29944, 30036, 30032
31103, 29940, 29944, 30036, 30032, 29941, 29945, 30037, 30033
31104, 29941, 29945, 30037, 30033, 29942, 29946, 30038, 30034
31105, 29942, 29946, 30038, 30034, 12419, 12420, 12443, 12442
31106, 8592, 8593, 8616, 8615, 29943, 29947, 30039, 30035
31107, 29943, 29947, 30039, 30035, 29944, 29948, 30040, 30036
31108, 29944, 29948, 30040, 30036, 29945, 29949, 30041, 30037
31109, 29945, 29949, 30041, 30037, 29946, 29950, 30042, 30038
31110, 29946, 29950, 30042, 30038, 12420, 12421, 12444, 12443
31111, 8593, 8594, 8617, 8616, 29947, 29951, 30043, 30039
31112, 29947, 29951, 30043, 30039, 29948, 29952, 30044, 30040
31113, 29948, 29952, 30044, 30040, 29949, 29953, 30045, 30041
31114, 29949, 29953, 30045, 30041, 29950, 29954, 30046, 30042
31115, 29950, 29954, 30046, 30042, 12421, 12422, 12445, 12444
31116, 8594, 8595, 8618, 8617, 29951, 29955, 30047, 30043
31117, 29951, 29955, 30047, 30043, 29952, 29956, 30048, 30044
31118, 29952, 29956, 30048, 30044, 29953, 29957, 30049, 30045
31119, 29953, 29957, 30049, 30045, 29954, 29958, 30050, 30046
31120, 29954, 29958, 30050, 30046, 12422, 12423, 12446, 12445
31121, 8595, 1137, 1138, 8618, 29955, 12300, 12304, 30047
31122, 29955, 12300, 12304, 30047, 29956, 12301, 12305, 30048
31123, 29956, 12301, 12305, 30048, 29957, 12302, 12306, 30049
31124, 29957, 12302, 12306, 30049, 29958, 12303, 12307, 30050
31125, 29958, 12303, 12307, 30050, 12423, 1918, 1919, 12446
31126, 1127, 8596, 8619, 1128, 12260, 29959, 30051, 12264
31127, 12260, 29959, 30051, 12264, 12261, 29960, 30052, 12265
31128, 12261, 29960, 30052, 12265, 12262, 29961, 30053, 12266
31129, 12262, 29961, 30053, 12266, 12263, 29962, 30054, 12267
31130, 12263, 29962, 30054, 12267, 1908, 12424, 12447, 1909
31131, 8596, 8597, 8620, 8619, 29959, 29963, 30055, 30051
31132, 29959, 29963, 30055, 30051, 29960, 29964, 30056, 30052
31133, 29960, 29964, 30056, 30052, 29961, 29965, 30057, 30053
31134, 29961, 29965, 30057, 30053, 29962, 29966, 30058, 30054
31135, 29962, 29966, 30058, 30054, 12424, 12425, 12448, 12447
31136, 8597, 8598, 8621, 8620, 29963, 29967, 30059, 30055
31137, 29963, 29967, 30059, 30055, 29964, 29968, 30060, 30056
31138, 29964, 29968, 30060, 30056, 29965, 29969, 30061, 30057
31139, 29965, 29969, 30061, 30057, 29966, 29970, 30062, 30058
31140, 29966, 29970, 30062, 30058, 12425, 12426, 12449, 12448
31141, 8598, 8599, 8622, 8621, 29967, 29971, 30063, 30059
31142, 29967, 29971, 30063, 30059, 29968, 29972, 30064, 30060
31143, 29968, 29972, 30064, 30060, 29969, 29973, 30065, 30061
31144, 29969, 29973, 30065, 30061, 29970, 29974, 30066, 30062
31145, 29970, 29974, 30066, 30062, 12426, 12427, 12450, 12449
31146, 8599, 8600, 8623, 8622, 29971, 29975, 30067, 30063
31147, 29971, 29975, 30067, 30063, 29972, 29976, 30068, 30064
31148, 29972, 29976, 30068, 30064, 29973, 29977, 30069, 30065
31149, 29973, 29977, 30069, 30065, 29974, 29978, 30070, 30066
31150, 29974, 29978, 30070, 30066, 12427, 12428, 12451, 12450
31151, 8600, 8601, 8624, 8623, 29975, 29979, 30071, 30067
31152, 29975, 29979, 30071, 30067, 29976, 29980, 30072, 30068
31153, 29976, 29980, 30072, 30068, 29977, 29981, 30073, 30069
31154, 29977, 29981, 30073, 30069, 29978, 29982, 30074, 30070
31155, 29978, 29982, 30074, 30070, 12428, 12429, 12452, 12451
31156, 8601, 8602, 8625, 8624, 29979, 29983, 30075, 30071
31157, 29979, 29983, 30075, 30071, 29980, 29984, 30076, 30072
31158, 29980, 29984, 30076, 30072, 29981, 29985, 30077, 30073
31159, 29981, 29985, 30077, 30073, 29982, 29986, 30078, 30074
31160, 29982, 29986, 30078, 30074, 12429, 12430, 12453, 12452
31161, 8602, 8603, 8626, 8625, 29983, 29987, 30079, 30075
31162, 29983, 29987, 30079, 30075, 29984, 29988, 30080, 30076
31163, 29984, 29988, 30080, 30076, 29985, 29989, 30081, 30077
31164, 29985, 29989, 30081, 30077, 29986, 29990, 30082, 30078
31165, 29986, 29990, 30082, 30078, 12430, 12431, 12454, 12453
31166, 8603, 8604, 8627, 8626, 29987, 29991, 30083, 30079
31167, 29987, 29991, 30083, 30079, 29988, 29992, 30084, 30080
31168, 29988, 29992, 30084, 30080, 29989, 29993, 30085, 30081
31169, 29989, 29993, 30085, 30081, 29990, 29994, 30086, 30082
31170, 29990, 29994, 30086, 30082, 12431, 12432, 12455, 12454
31171, 8604, 8605, 8628, 8627, 29991, 29995, 30087, 30083
31172, 29991, 29995, 30087, 30083, 29992, 29996, 30088, 30084
31173, 29992, 29996, 30088, 30084, 29993, 29997, 30089, 30085
31174, 29993, 29997, 30089, 30085, 29994, 29998, 30090, 30086
31175, 29994, 29998, 30090, 30086, 12432, 12433, 12456, 12455
31176, 8605, 8606, 8629, 8628, 29995, 29999, 30091, 30087
31177, 29995, 29999, 30091, 30087, 29996, 30000, 30092, 30088
31178, 29996, 30000, 30092, 30088, 29997, 30001, 30093, 30089
31179, 29997, 30001, 30093, 30089, 29998, 30002, 30094, 30090
31180, 29998, 30002, 30094, 30090, 12433, 12434, 12457, 12456
31181, 8606, 8607, 8630, 8629, 29999, 30003, 30095, 30091
31182, 29999, 30003, 30095, 30091, 30000, 30004, 30096, 30092
31183, 30000, 30004, 30096, 30092, 30001, 30005, 30097, 30093
31184, 30001, 30005, 30097, 30093, 30002, 30006, 30098, 30094
31185, 30002, 30006, 30098, 30094, 12434, 12435, 12458, 12457
31186, 8607, 8608, 8631, 8630, 30003, 30007, 30099, 30095
31187, 30003, 30007, 30099, 30095, 30004, 30008, 30100, 30096
31188, 30004, 30008, 30100, 30096, 30005, 30009, 30101, 30097
31189, 30005, 30009, 30101, 30097, 30006, 30010, 30102, 30098
31190, 30006, 30010, 30102, 30098, 12435, 12436, 12459, 12458
31191, 8608, 8609, 8632, 8631, 30007, 30011, 30103, 30099
31192, 30007, 30011, 30103, 30099, 30008, 30012, 30104, 30100
31193, 30008, 30012, 30104, 30100, 30009, 30013, 30105, 30101
31194, 30009, 30013, 30105, 30101, 30010, 30014, 30106, 30102
31195, 30010, 30014, 30106, 30102, 12436, 12437, 12460, 12459
31196, 8609, 8610, 8633, 8632, 30011, 30015, 30107, 30103
31197, 30011, 30015, 30107, 30103, 30012, 30016, 30108, 30104
31198, 30012, 30016, 30108, 30104, 30013, 30017, 30109, 30105
31199, 30013, 30017, 30109, 30105, 30014, 30018, 30110, 30106
31200, 30014, 30018, 30110, 30106, 12437, 12438, 12461, 12460
31201, 8610, 8611, 8634, 8633, 30015, 30019, 30111, 30107
31202, 30015, 30019, 30111, 30107, 30016, 30020, 30112, 30108
31203, 30016, 30020, 30112, 30108, 30017, 30021, 30113, 30109
31204, 30017, 30021, 30113, 30109, 30018, 30022, 30114, 30110
31205, 30018, 30022, 30114, 30110, 12438, 12439, 12462, 12461
31206, 8611, 8612, 8635, 8634, 30019, 30023, 30115, 30111
31207, 30019, 30023, 30115, 30111, 30020, 30024, 30116, 30112
31208, 30020, 30024, 30116, 30112, 30021, 30025, 30117, 30113
31209, 30021, 30025, 30117, 30113, 30022, 30026, 30118, 30114
31210, 30022, 30026, 30118, 30114, 12439, 12440, 12463, 12462
31211, 8612, 8613, 8636, 8635, 30023, 30027, 30119, 30115
31212, 30023, 30027, 30119, 30115, 30024, 30028, 30120, 30116
31213, 30024, 30028, 30120, 30116, 30025, 30029, 30121, 30117
31214, 30025, 30029, 30121, 30117, 30026, 30030, 30122, 30118
31215, 30026, 30030, 30122, 30118, 12440, 12441, 12464, 12463
31216, 8613, 8614, 8637, 8636, 30027, 30031, 30123, 30119
31217, 30027, 30031, 30123, 30119, 30028, 30032, 30124, 30120
31218, 30028, 30032, 30124, 30120, 30029, 30033, 30125, 30121
31219, 30029, 30033, 30125, 30121, 30030, 30034, 30126, 30122
31220, 30030, 30034, 30126, 30122, 12441, 12442, 12465, 12464
31221, 8614, 8615, 8638, 8637, 30031, 30035, 30127, 30123
31222, 30031, 30035, 30127, 30123, 30032, 30036, 30128, 30124
31223, 30032, 30036, 30128, 30124, 30033, 30037, 30129, 30125
31224, 30033, 30037, 30129, 30125, 30034, 30038, 30130, 30126
31225, 30034, 30038, 30130, 30126, 12442, 12443, 12466, 12465
31226, 8615, 8616, 8639, 8638, 30035, 30039, 30131, 30127
31227, 30035, 30039, 30131, 30127, 30036, 30040, 30132, 30128
31228, 30036, 30040, 30132, 30128, 30037, 30041, 30133, 30129
31229, 30037, 30041, 30133, 30129, 30038, 30042, 30134, 30130
31230, 30038, 30042, 30134, 30130, 12443, 12444, 12467, 12466
31231, 8616, 8617, 8640, 8639, 30039, 30043, 30135, 30131
31232, 30039, 30043, 30135, 30131, 30040, 30044, 30136, 30132
31233, 30040, 30044, 30136, 30132, 30041, 30045, 30137, 30133
31234, 30041, 30045, 30137, 30133, 30042, 30046, 30138, 30134
31235, 30042, 30046, 30138, 30134, 12444, 12445, 12468, 12467
31236, 8617, 8618, 8641, 8640, 30043, 30047, 30139, 30135
31237, 30043, 30047, 30139, 30135, 30044, 30048, 30140, 30136
31238, 30044, 30048, 30140, 30136, 30045, 30049, 30141, 30137
31239, 30045, 30049, 30141, 30137, 30046, 30050, 30142, 30138
31240, 30046, 30050, 30142, 30138, 12445, 12446, 12469, 12468
31241, 8618, 1138, 1139, 8641, 30047, 12304, 12308, 30139
31242, 30047, 12304, 12308, 30139, 30048, 12305, 12309, 30140
31243, 30048, 12305, 12309, 30140, 30049, 12306, 12310, 30141
31244, 30049, 12306, 12310, 30141, 30050, 12307, 12311, 30142
31245, 30050, 12307, 12311, 30142, 12446, 1919, 1920, 12469
31246, 1128, 8619, 8642, 1129, 12264, 30051, 30143, 12268
31247, 12264, 30051, 30143, 12268, 12265, 30052, 30144, 12269
31248, 12265, 30052, 30144, 12269, 12266, 30053, 30145, 12270
31249, 12266, 30053, 30145, 12270, 12267, 30054, 30146, 12271
31250, 12267, 30054, 30146, 12271, 1909, 12447, 12470, 1910
31251, 8619, 8620, 8643, 8642, 30051, 30055, 30147, 30143
31252, 30051, 30055, 30147, 30143, 30052, 30056, 30148, 30144
31253, 30052, 30056, 30148, 30144, 30053, 30057, 30149, 30145
31254, 30053, 30057, 30149, 30145, 30054, 30058, 30150, 30146
31255, 30054, 30058, 30150, 30146, 12447, 12448, 12471, 12470
31256, 8620, 8621, 8644, 8643, 30055, 30059, 30151, 30147
31257, 30055, 30059, 30151, 30147, 30056, 30060, 30152, 30148
31258, 30056, 30060, 30152, 30148, 30057, 30061, 30153, 30149
31259, 30057, 30061, 30153, 30149, 30058, 30062, 30154, 30150
31260, 30058, 30062, 30154, 30150, 12448, 12449, 12472, 12471
31261, 8621, 8622, 8645, 8644, 30059, 30063, 30155, 30151
31262, 30059, 30063, 30155, 30151, 30060, 30064, 30156, 30152
31263, 30060, 30064, 30156, 30152, 30061, 30065, 30157, 30153
31264, 30061, 30065, 30157, 30153, 30062, 30066, 30158, 30154
31265, 30062, 30066, 30158, 30154, 12449, 12450, 12473, 12472
31266, 8622, 8623, 8646, 8645, 30063, 30067, 30159, 30155
31267, 30063, 30067, 30159, 30155, 30064, 30068, 30160, 30156
31268, 30064, 30068, 30160, 30156, 30065, 30069, 30161, 30157
31269, 30065, 30069, 30161, 30157, 30066, 30070, 30162, 30158
31270, 30066, 30070, 30162, 30158, 12450, 12451, 12474, 12473
31271, 8623, 8624, 8647, 8646, 30067, 30071, 30163, 30159
31272, 30067, 30071, 30163, 30159, 30068, 30072, 30164, 30160
31273, 30068, 30072, 30164, 30160, 30069, 30073, 30165, 30161
31274, 30069, 30073, 30165, 30161, 30070, 30074, 30166, 30162
31275, 30070, 30074, 30166, 30162, 12451, 12452, 12475, 12474
31276, 8624, 8625, 8648, 8647, 30071, 30075, 30167, 30163
31277, 30071, 30075, 30167, 30163, 30072, 30076, 30168, 30164
31278, 30072, 30076, 30168, 30164, 30073, 30077, 30169, 30165
31279, 30073, 30077, 30169, 30165, 30074, 30078, 30170, 30166
31280, 30074, 30078, 30170, 30166, 12452, 12453, 12476, 12475
31281, 8625, 8626, 8649, 8648, 30075, 30079, 30171, 30167
31282, 30075, 30079, 30171, 30167, 30076, 30080, 30172, 30168
31283, 30076, 30080, 30172, 30168, 30077, 30081, 30173, 30169
31284, 30077, 30081, 30173, 30169, 30078, 30082, 30174, 30170
31285, 30078, 30082, 30174, 30170, 12453, 12454, 12477, 12476
31286, 8626, 8627, 8650, 8649, 30079, 30083, 30175, 30171
31287, 30079, 30083, 30175, 30171, 30080, 30084, 30176, 30172
31288, 30080, 30084, 30176, 30172, 30081, 30085, 30177, 30173
31289, 30081, 30085, 30177, 30173, 30082, 30086, 30178, 30174
31290, 30082, 30086, 30178, 30174, 12454, 12455, 12478, 12477
31291, 8627, 8628, 8651, 8650, 30083, 30087, 30179, 30175
31292, 30083, 30087, 30179, 30175, 30084, 30088, 30180, 30176
31293, 30084, 30088, 30180, 30176, 30085, 30089, 30181, 30177
31294, 30085, 30089, 30181, 30177, 30086, 30090, 30182, 30178
31295, 30086, 30090, 30182, 30178, 12455, 12456, 12479, 12478
31296, 8628, 8629, 8652, 8651, 30087, 30091, 30183, 30179
31297, 30087, 30091, 30183, 30179, 30088, 30092, 30184, 30180
31298, 30088, 30092, 30184, 30180, 30089, 30093, 30185, 30181
31299, 30089, 30093, 30185, 30181, 30090, 30094, 30186, 30182
31300, 30090, 30094, 30186, 30182, 12456, 12457, 12480, 12479
31301, 8629, 8630, 8653, 8652, 30091, 30095, 30187, 30183
31302, 30091, 30095, 30187, 30183, 30092, 30096, 30188, 30184
31303, 30092, 30096, 30188, 30184, 30093, 30097, 30189, 30185
31304, 30093, 30097, 30189, 30185, 30094, 30098, 30190, 30186
31305, 30094, 30098, 30190, 30186, 12457, 12458, 12481, 12480
31306, 8630, 8631, 8654, 8653, 30095, 30099, 30191, 30187
31307, 30095, 30099, 30191, 30187, 30096, 30100, 30192, 30188
31308, 30096, 30100, 30192, 30188, 30097, 30101, 30193, 30189
31309, 30097, 30101, 30193, 30189, 30098, 30102, 30194, 30190
31310, 30098, 30102, 30194, 30190, 12458, 12459, 12482, 12481
31311, 8631, 8632, 8655, 8654, 30099, 30103, 30195, 30191
31312, 30099, 30103, 30195, 30191, 30100, 30104, 30196, 30192
31313, 30100, 30104, 30196, 30192, 30101, 30105, 30197, 30193
31314, 30101, 30105, 30197, 30193, 30102, 30106, 30198, 30194
31315, 30102, 30106, 30198, 30194, 12459, 12460, 12483, 12482
31316, 8632, 8633, 8656, 8655, 30103, 30107, 30199, 30195
31317, 30103, 30107, 30199, 30195, 30104, 30108, 30200, 30196
31318, 30104, 30108, 30200, 30196, 30105, 30109, 30201, 30197
31319, 30105, 30109, 30201, 30197, 30106, 30110, 30202, 30198
31320, 30106, 30110, 30202, 30198, 12460, 12461, 12484, 12483
31321, 8633, 8634, 8657, 8656, 30107, 30111, 30203, 30199
31322, 30107, 30111, 30203, 30199, 30108, 30112, 30204, 30200
31323, 30108, 30112, 30204, 30200, 30109, 30113, 30205, 30201
31324, 30109, 30113, 30205, 30201, 30110, 30114, 30206, 30202
31325, 30110, 30114, 30206, 30202, 12461, 12462, 12485, 12484
31326, 8634, 8635, 8658, 8657, 30111, 30115, 30207, 30203
31327, 30111, 30115, 30207, 30203, 30112, 30116, 30208, 30204
31328, 30112, 30116, 30208, 30204, 30113, 30117, 30209, 30205
31329, 30113, 30117, 30209, 30205, 30114, 30118, 30210, 30206
31330, 30114, 30118, 30210, 30206, 12462, 12463, 12486, 12485
31331, 8635, 8636, 8659, 8658, 30115, 30119, 30211, 30207
31332, 30115, 30119, 30211, 30207, 30116, 30120, 30212, 30208
31333, 30116, 30120, 30212, 30208, 30117, 30121, 30213, 30209
31334, 30117, 30121, 30213, 30209, 30118, 30122, 30214, 30210
31335, 30118, 30122, 30214, 30210, 12463, 12464, 12487, 12486
31336, 8636, 8637, 8660, 8659, 30119, 30123, 30215, 30211
31337, 30119, 30123, 30215, 30211, 30120, 30124, 30216, 30212
31338, 30120, 30124, 30216, 30212, 30121, 30125, 30217, 30213
31339, 30121, 30125, 30217, 30213, 30122, 30126, 30218, 30214
31340, 30122, 30126, 30218, 30214, 12464, 12465, 12488, 12487
31341, 8637, 8638, 8661, 8660, 30123, 30127, 30219, 30215
31342, 30123, 30127, 30219, 30215, 30124, 30128, 30220, 30216
31343, 30124, 30128, 30220, 30216, 30125, 30129, 30221, 30217
31344, 30125, 30129, 30221, 30217, 30126, 30130, 30222, 30218
31345, 30126, 30130, 30222, 30218, 12465, 12466, 12489, 12488
31346, 8638, 8639, 8662, 8661, 30127, 30131, 30223, 30219
31347, 30127, 30131, 30223, 30219, 30128, 30132, 30224, 30220
31348, 30128, 30132, 30224, 30220, 30129, 30133, 30225, 30221
31349, 30129, 30133, 30225, 30221, 30130, 30134, 30226, 30222
31350, 30130, 30134, 30226, 30222, 12466, 12467, 12490, 12489
31351, 8639, 8640, 8663, 8662, 30131, 30135, 30227, 30223
31352, 30131, 30135, 30227, 30223, 30132, 30136, 30228, 30224
31353, 30132, 30136, 30228, 30224, 30133, 30137, 30229, 30225
31354, 30133, 30137, 30229, 30225, 30134, 30138, 30230, 30226
31355, 30134, 30138, 30230, 30226, 12467, 12468, 12491, 12490
31356, 8640, 8641, 8664, 8663, 30135, 30139, 30231, 30227
31357, 30135, 30139, 30231, 30227, 30136, 30140, 30232, 30228
31358, 30136, 30140, 30232, 30228, 30137, 30141, 30233, 30229
31359, 30137, 30141, 30233, 30229, 30138, 30142, 30234, 30230
31360, 30138, 30142, 30234, 30230, 12468, 12469, 12492, 12491
31361, 8641, 1139, 1140, 8664, 30139, 12308, 12312, 30231
31362, 30139, 12308, 12312, 30231, 30140, 12309, 12313, 30232
31363, 30140, 12309, 12313, 30232, 30141, 12310, 12314, 30233
31364, 30141, 12310, 12314, 30233, 30142, 12311, 12315, 30234
31365, 30142, 12311, 12315, 30234, 12469, 1920, 1921, 12492
31366, 1129, 8642, 8665, 1130, 12268, 30143, 30235, 12272
31367, 12268, 30143, 30235, 12272, 12269, 30144, 30236, 12273
31368, 12269, 30144, 30236, 12273, 12270, 30145, 30237, 12274
31369, 12270, 30145, 30237, 12274, 12271, 30146, 30238, 12275
31370, 12271, 30146, 30238, 12275, 1910, 12470, 12493, 1911
31371, 8642, 8643, 8666, 8665, 30143, 30147, 30239, 30235
31372, 30143, 30147, 30239, 30235, 30144, 30148, 30240, 30236
31373, 30144, 30148, 30240, 30236, 30145, 30149, 30241, 30237
31374, 30145, 30149, 30241, 30237, 30146, 30150, 30242, 30238
31375, 30146, 30150, 30242, 30238, 12470, 12471, 12494, 12493
31376, 8643, 8644, 8667, 8666, 30147, 30151, 30243, 30239
31377, 30147, 30151, 30243, 30239, 30148, 30152, 30244, 30240
31378, 30148, 30152, 30244, 30240, 30149, 30153, 30245, 30241
31379, 30149, 30153, 30245, 30241, 30150, 30154, 30246, 30242
31380, 30150, 30154, 30246, 30242, 12471, 12472, 12495, 12494
31381, 8644, 8645, 8668, 8667, 30151, 30155, 30247, 30243
31382, 30151, 30155, 30247, 30243, 30152, 30156, 30248, 30244
31383, 30152, 30156, 30248, 30244, 30153, 30157, 30249, 30245
31384, 30153, 30157, 30249, 30245, 30154, 30158, 30250, 30246
31385, 30154, 30158, 30250, 30246, 12472, 12473, 12496, 12495
31386, 8645, 8646, 8669, 8668, 30155, 30159, 30251, 30247
31387, 30155, 30159, 30251, 30247, 30156, 30160, 30252, 30248
31388, 30156, 30160, 30252, 30248, 30157, 30161, 30253, 30249
31389, 30157, 30161, 30253, 30249, 30158, 30162, 30254, 30250
31390, 30158, 30162, 30254, 30250, 12473, 12474, 12497, 12496
31391, 8646, 8647, 8670, 8669, 30159, 30163, 30255, 30251
31392, 30159, 30163, 30255, 30251, 30160, 30164, 30256, 30252
31393, 30160, 30164, 30256, 30252, 30161, 30165, 30257, 30253
31394, 30161, 30165, 30257, 30253, 30162, 30166, 30258, 30254
31395, 30162, 30166, 30258, 30254, 12474, 12475, 12498, 12497
31396, 8647, 8648, 8671, 8670, 30163, 30167, 30259, 30255
31397, 30163, 30167, 30259, 30255, 30164, 30168, 30260, 30256
31398, 30164, 30168, 30260, 30256, 30165, 30169, 30261, 30257
31399, 30165, 30169, 30261, 30257, 30166, 30170, 30262, 30258
31400, 30166, 30170, 30262, 30258, 12475, 12476, 12499, 12498
31401, 8648, 8649, 8672, 8671, 30167, 30171, 30263, 30259
31402, 30167, 30171, 30263, 30259, 30168, 30172, 30264, 30260
31403, 30168, 30172, 30264, 30260, 30169, 30173, 30265, 30261
31404, 30169, 30173, 30265, 30261, 30170, 30174, 30266, 30262
31405, 30170, 30174, 30266, 30262, 12476, 12477, 12500, 12499
31406, 8649, 8650, 8673, 8672, 30171, 30175, 30267, 30263
31407, 30171, 30175, 30267, 30263, 30172, 30176, 30268, 30264
31408, 30172, 30176, 30268, 30264, 30173, 30177, 30269, 30265
31409, 30173, 30177, 30269, 30265, 30174, 30178, 30270, 30266
31410, 30174, 30178, 30270, 30266, 12477, 12478, 12501, 12500
31411, 8650, 8651, 8674, 8673, 30175, 30179, 30271, 30267
31412, 30175, 30179, 30271, 30267, 30176, 30180, 30272, 30268
31413, 30176, 30180, 30272, 30268, 30177, 30181, 30273, 30269
31414, 30177, 30181, 30273, 30269, 30178, 30182, 30274, 30270
31415, 30178, 30182, 30274, 30270, 12478, 12479, 12502, 12501
31416, 8651, 8652, 8675, 8674, 30179, 30183, 30275, 30271
31417, 30179, 30183, 30275, 30271, 30180, 30184, 30276, 30272
31418, 30180, 30184, 30276, 30272, 30181, 30185, 30277, 30273
31419, 30181, 30185, 30277, 30273, 30182, 30186, 30278, 30274
31420, 30182, 30186, 30278, 30274, 12479, 12480, 12503, 12502
31421, 8652, 8653, 8676, 8675, 30183, 30187, 30279, 30275
31422, 30183, 30187, 30279, 30275, 30184, 30188, 30280, 30276
31423, 30184, 30188, 30280, 30276, 30185, 30189, 30281, 30277
31424, 30185, 30189, 30281, 30277, 30186, 30190, 30282, 30278
31425, 30186, 30190, 30282, 30278, 12480, 12481, 12504, 12503
31426, 8653, 8654, 8677, 8676, 30187, 30191, 30283, 30279
31427, 30187, 30191, 30283, 30279, 30188, 30192, 30284, 30280
31428, 30188, 30192, 30284, 30280, 30189, 30193, 30285, 30281
31429, 30189, 30193, 30285, 30281, 30190, 30194, 30286, 30282
31430, 30190, 30194, 30286, 30282, 12481, 12482, 12505, 12504
31431, 8654, 8655, 8678, 8677, 30191, 30195, 30287, 30283
31432, 30191, 30195, 30287, 30283, 30192, 30196, 30288, 30284
31433, 30192, 30196, 30288, 30284, 30193, 30197, 30289, 30285
31434, 30193, 30197, 30289, 30285, 30194, 30198, 30290, 30286
31435, 30194, 30198, 30290, 30286, 12482, 12483, 12506, 12505
31436, 8655, 8656, 8679, 8678, 30195, 30199, 30291, 30287
31437, 30195, 30199, 30291, 30287, 30196, 30200, 30292, 30288
31438, 30196, 30200, 30292, 30288, 30197, 30201, 30293, 30289
31439, 30197, 30201, 30293, 30289, 30198, 30202, 30294, 30290
31440, 30198, 30202, 30294, 30290, 12483, 12484, 12507, 12506
31441, 8656, 8657, 8680, 8679, 30199, 30203, 30295, 30291
31442, 30199, 30203, 30295, 30291, 30200, 30204, 30296, 30292
31443, 30200, 30204, 30296, 30292, 30201, 30205, 30297, 30293
31444, 30201, 30205, 30297, 30293, 30202, 30206, 30298, 30294
31445, 30202, 30206, 30298, 30294, 12484, 12485, 12508, 12507
31446, 8657, 8658, 8681, 8680, 30203, 30207, 30299, 30295
31447, 30203, 30207, 30299, 30295, 30204, 30208, 30300, 30296
31448, 30204, 30208, 30300, 30296, 30205, 30209, 30301, 30297
31449, 30205, 30209, 30301, 30297, 30206, 30210, 30302, 30298
31450, 30206, 30210, 30302, 30298, 12485, 12486, 12509, 12508
31451, 8658, 8659, 8682, 8681, 30207, 30211, 30303, 30299
31452, 30207, 30211, 30303, 30299, 30208, 30212, 30304, 30300
31453, 30208, 30212, 30304, 30300, 30209, 30213, 30305, 30301
31454, 30209, 30213, 30305, 30301, 30210, 30214, 30306, 30302
31455, 30210, 30214, 30306, 30302, 12486, 12487, 12510, 12509
31456, 8659, 8660, 8683, 8682, 30211, 30215, 30307, 30303
31457, 30211, 30215, 30307, 30303, 30212, 30216, 30308, 30304
31458, 30212, 30216, 30308, 30304, 30213, 30217, 30309, 30305
31459, 30213, 30217, 30309, 30305, 30214, 30218, 30310, 30306
31460, 30214, 30218, 30310, 30306, 12487, 12488, 12511, 12510
31461, 8660, 8661, 8684, 8683, 30215, 30219, 30311, 30307
31462, 30215, 30219, 30311, 30307, 30216, 30220, 30312, 30308
31463, 30216, 30220, 30312, 30308, 30217, 30221, 30313, 30309
31464, 30217, 30221, 30313, 30309, 30218, 30222, 30314, 30310
31465, 30218, 30222, 30314, 30310, 12488, 12489, 12512, 12511
31466, 8661, 8662, 8685, 8684, 30219, 30223, 30315, 30311
31467, 30219, 30223, 30315, 30311, 30220, 30224, 30316, 30312
31468, 30220, 30224, 30316, 30312, 30221, 30225, 30317, 30313
31469, 30221, 30225, 30317, 30313, 30222, 30226, 30318, 30314
31470, 30222, 30226, 30318, 30314, 12489, 12490, 12513, 12512
31471, 8662, 8663, 8686, 8685, 30223, 30227, 30319, 30315
31472, 30223, 30227, 30319, 30315, 30224, 30228, 30320, 30316
31473, 30224, 30228, 30320, 30316, 30225, 30229, 30321, 30317
31474, 30225, 30229, 30321, 30317, 30226, 30230, 30322, 30318
31475, 30226, 30230, 30322, 30318, 12490, 12491, 12514, 12513
31476, 8663, 8664, 8687, 8686, 30227, 30231, 30323, 30319
31477, 30227, 30231, 30323, 30319, 30228, 30232, 30324, 30320
31478, 30228, 30232, 30324, 30320, 30229, 30233, 30325, 30321
31479, 30229, 30233, 30325, 30321, 30230, 30234, 30326, 30322
31480, 30230, 30234, 30326, 30322, 12491, 12492, 12515, 12514
31481, 8664, 1140, 1141, 8687, 30231, 12312, 12316, 30323
31482, 30231, 12312, 12316, 30323, 30232, 12313, 12317, 30324
31483, 30232, 12313, 12317, 30324, 30233, 12314, 12318, 30325
31484, 30233, 12314, 12318, 30325, 30234, 12315, 12319, 30326
31485, 30234, 12315, 12319, 30326, 12492, 1921, 1922, 12515
31486, 1130, 8665, 8688, 1131, 12272, 30235, 30327, 12276
31487, 12272, 30235, 30327, 12276, 12273, 30236, 30328, 12277
31488, 12273, 30236, 30328, 12277, 12274, 30237, 30329, 12278
31489, 12274, 30237, 30329, 12278, 12275, 30238, 30330, 12279
31490, 12275, 30238, 30330, 12279, 1911, 12493, 12516, 1912
31491, 8665, 8666, 8689, 8688, 30235, 30239, 30331, 30327
31492, 30235, 30239, 30331, 30327, 30236, 30240, 30332, 30328
31493, 30236, 30240, 30332, 30328, 30237, 30241, 30333, 30329
31494, 30237, 30241, 30333, 30329, 30238, 30242, 30334, 30330
31495, 30238, 30242, 30334, 30330, 12493, 12494, 12517, 12516
31496, 8666, 8667, 8690, 8689, 30239, 30243, 30335, 30331
31497, 30239, 30243, 30335, 30331, 30240, 30244, 30336, 30332
31498, 30240, 30244, 30336, 30332, 30241, 30245, 30337, 30333
31499, 30241, 30245, 30337, 30333, 30242, 30246, 30338, 30334
31500, 30242, 30246, 30338, 30334, 12494, 12495, 12518, 12517
31501, 8667, 8668, 8691, 8690, 30243, 30247, 30339, 30335
31502, 30243, 30247, 30339, 30335, 30244, 30248, 30340, 30336
31503, 30244, 30248, 30340, 30336, 30245, 30249, 30341, 30337
31504, 30245, 30249, 30341, 30337, 30246, 30250, 30342, 30338
31505, 30246, 30250, 30342, 30338, 12495, 12496, 12519, 12518
31506, 8668, 8669, 8692, 8691, 30247, 30251, 30343, 30339
31507, 30247, 30251, 30343, 30339, 30248, 30252, 30344, 30340
31508, 30248, 30252, 30344, 30340, 30249, 30253, 30345, 30341
31509, 30249, 30253, 30345, 30341, 30250, 30254, 30346, 30342
31510, 30250, 30254, 30346, 30342, 12496, 12497, 12520, 12519
31511, 8669, 8670, 8693, 8692, 30251, 30255, 30347, 30343
31512, 30251, 30255, 30347, 30343, 30252, 30256, 30348, 30344
31513, 30252, 30256, 30348, 30344, 30253, 30257, 30349, 30345
31514, 30253, 30257, 30349, 30345, 30254, 30258, 30350, 30346
31515, 30254, 30258, 30350, 30346, 12497, 12498, 12521, 12520
31516, 8670, 8671, 8694, 8693, 30255, 30259, 30351, 30347
31517, 30255, 30259, 30351, 30347, 30256, 30260, 30352, 30348
31518, 30256, 30260, 30352, 30348, 30257, 30261, 30353, 30349
31519, 30257, 30261, 30353, 30349, 30258, 30262, 30354, 30350
31520, 30258, 30262, 30354, 30350, 12498, 12499, 12522, 12521
31521, 8671, 8672, 8695, 8694, 30259, 30263, 30355, 30351
31522, 30259, 30263, 30355, 30351, 30260, 30264, 30356, 30352
31523, 30260, 30264, 30356, 30352, 30261, 30265, 30357, 30353
31524, 30261, 30265, 30357, 30353, 30262, 30266, 30358, 30354
31525, 30262, 30266, 30358, 30354, 12499, 12500, 12523, 12522
31526, 8672, 8673, 8696, 8695, 30263, 30267, 30359, 30355
31527, 30263, 30267, 30359, 30355, 30264, 30268, 30360, 30356
31528, 30264, 30268, 30360, 30356, 30265, 30269, 30361, 30357
31529, 30265, 30269, 30361, 30357, 30266, 30270, 30362, 30358
31530, 30266, 30270, 30362, 30358, 12500, 12501, 12524, 12523
31531, 8673, 8674, 8697, 8696, 30267, 30271, 30363, 30359
31532, 30267, 30271, 30363, 30359, 30268, 30272, 30364, 30360
31533, 30268, 30272, 30364, 30360, 30269, 30273, 30365, 30361
31534, 30269, 30273, 30365, 30361, 30270, 30274, 30366, 30362
31535, 30270, 30274, 30366, 30362, 12501, 12502, 12525, 12524
31536, 8674, 8675, 8698, 8697, 30271, 30275, 30367, 30363
31537, 30271, 30275, 30367, 30363, 30272, 30276, 30368, 30364
31538, 30272, 30276, 30368, 30364, 30273, 30277, 30369, 30365
31539, 30273, 30277, 30369, 30365, 30274, 30278, 30370, 30366
31540, 30274, 30278, 30370, 30366, 12502, 12503, 12526, 12525
31541, 8675, 8676, 8699, 8698, 30275, 30279, 30371, 30367
31542, 30275, 30279, 30371, 30367, 30276, 30280, 30372, 30368
31543, 30276, 30280, 30372, 30368, 30277, 30281, 30373, 30369
31544, 30277, 30281, 30373, 30369, 30278, 30282, 30374, 30370
31545, 30278, 30282, 30374, 30370, 12503, 12504, 12527, 12526
31546, 8676, 8677, 8700, 8699, 30279, 30283, 30375, 30371
31547, 30279, 30283, 30375, 30371, 30280, 30284, 30376, 30372
31548, 30280, 30284, 30376, 30372, 30281, 30285, 30377, 30373
31549, 30281, 30285, 30377, 30373, 30282, 30286, 30378, 30374
31550, 30282, 30286, 30378, 30374, 12504, 12505, 12528, 12527
31551, 8677, 8678, 8701, 8700, 30283, 30287, 30379, 30375
31552, 30283, 30287, 30379, 30375, 30284, 30288, 30380, 30376
31553, 30284, 30288, 30380, 30376, 30285, 30289, 30381, 30377
31554, 30285, 30289, 30381, 30377, 30286, 30290, 30382, 30378
31555, 30286, 30290, 30382, 30378, 12505, 12506, 12529, 12528
31556, 8678, 8679, 8702, 8701, 30287, 30291, 30383, 30379
31557, 30287, 30291, 30383, 30379, 30288, 30292, 30384, 30380
31558, 30288, 30292, 30384, 30380, 30289, 30293, 30385, 30381
31559, 30289, 30293, 30385, 30381, 30290, 30294, 30386, 30382
31560, 30290, 30294, 30386, 30382, 12506, 12507, 12530, 12529
31561, 8679, 8680, 8703, 8702, 30291, 30295, 30387, 30383
31562, 30291, 30295, 30387, 30383, 30292, 30296, 30388, 30384
31563, 30292, 30296, 30388, 30384, 30293, 30297, 30389, 30385
31564, 30293, 30297, 30389, 30385, 30294, 30298, 30390, 30386
31565, 30294, 30298, 30390, 30386, 12507, 12508, 12531, 12530
31566, 8680, 8681, 8704, 8703, 30295, 30299, 30391, 30387
31567, 30295, 30299, 30391, 30387, 30296, 30300, 30392, 30388
31568, 30296, 30300, 30392, 30388, 30297, 30301, 30393, 30389
31569, 30297, 30301, 30393, 30389, 30298, 30302, 30394, 30390
31570, 30298, 30302, 30394, 30390, 12508, 12509, 12532, 12531
31571, 8681, 8682, 8705, 8704, 30299, 30303, 30395, 30391
31572, 30299, 30303, 30395, 30391, 30300, 30304, 30396, 30392
31573, 30300, 30304, 30396, 30392, 30301, 30305, 30397, 30393
31574, 30301, 30305, 30397, 30393, 30302, 30306, 30398, 30394
31575, 30302, 30306, 30398, 30394, 12509, 12510, 12533, 12532
31576, 8682, 8683, 8706, 8705, 30303, 30307, 30399, 30395
31577, 30303, 30307, 30399, 30395, 30304, 30308, 30400, 30396
31578, 30304, 30308, 30400, 30396, 30305, 30309, 30401, 30397
31579, 30305, 30309, 30401, 30397, 30306, 30310, 30402, 30398
31580, 30306, 30310, 30402, 30398, 12510, 12511, 12534, 12533
31581, 8683, 8684, 8707, 8706, 30307, 30311, 30403, 30399
31582, 30307, 30311, 30403, 30399, 30308, 30312, 30404, 30400
31583, 30308, 30312, 30404, 30400, 30309, 30313, 30405, 30401
31584, 30309, 30313, 30405, 30401, 30310, 30314, 30406, 30402
31585, 30310, 30314, 30406, 30402, 12511, 12512, 12535, 12534
31586, 8684, 8685, 8708, 8707, 30311, 30315, 30407, 30403
31587, 30311, 30315, 30407, 30403, 30312, 30316, 30408, 30404
31588, 30312, 30316, 30408, 30404, 30313, 30317, 30409, 30405
31589, 30313, 30317, 30409, 30405, 30314, 30318, 30410, 30406
31590, 30314, 30318, 30410, 30406, 12512, 12513, 12536, 12535
31591, 8685, 8686, 8709, 8708, 30315, 30319, 30411, 30407
31592, 30315, 30319, 30411, 30407, 30316, 30320, 30412, 30408
31593, 30316, 30320, 30412, 30408, 30317, 30321, 30413, 30409
31594, 30317, 30321, 30413, 30409, 30318, 30322, 30414, 30410
31595, 30318, 30322, 30414, 30410, 12513, 12514, 12537, 12536
31596, 8686, 8687, 8710, 8709, 30319, 30323, 30415, 30411
31597, 30319, 30323, 30415, 30411, 30320, 30324, 30416, 30412
31598, 30320, 30324, 30416, 30412, 30321, 30325, 30417, 30413
31599, 30321, 30325, 30417, 30413, 30322, 30326, 30418, 30414
31600, 30322, 30326, 30418, 30414, 12514, 12515, 12538, 12537
31601, 8687, 1141, 1142, 8710, 30323, 12316, 12320, 30415
31602, 30323, 12316, 12320, 30415, 30324, 12317, 12321, 30416
31603, 30324, 12317, 12321, 30416, 30325, 12318, 12322, 30417
31604, 30325, 12318, 12322, 30417, 30326, 12319, 12323, 30418
31605, 30326, 12319, 12323, 30418, 12515, 1922, 1923, 12538
31606, 1131, 8688, 8711, 1132, 12276, 30327, 30419, 12280
31607, 12276, 30327, 30419, 12280, 12277, 30328, 30420, 12281
31608, 12277, 30328, 30420, 12281, 12278, 30329, 30421, 12282
31609, 12278, 30329, 30421, 12282, 12279, 30330, 30422, 12283
31610, 12279, 30330, 30422, 12283, 1912, 12516, 12539, 1913
31611, 8688, 8689, 8712, 8711, 30327, 30331, 30423, 30419
31612, 30327, 30331, 30423, 30419, 30328, 30332, 30424, 30420
31613, 30328, 30332, 30424, 30420, 30329, 30333, 30425, 30421
31614, 30329, 30333, 30425, 30421, 30330, 30334, 30426, 30422
31615, 30330, 30334, 30426, 30422, 12516, 12517, 12540, 12539
31616, 8689, 8690, 8713, 8712, 30331, 30335, 30427, 30423
31617, 30331, 30335, 30427, 30423, 30332, 30336, 30428, 30424
31618, 30332, 30336, 30428, 30424, 30333, 30337, 30429, 30425
31619, 30333, 30337, 30429, 30425, 30334, 30338, 30430, 30426
31620, 30334, 30338, 30430, 30426, 12517, 12518, 12541, 12540
31621, 8690, 8691, 8714, 8713, 30335, 30339, 30431, 30427
31622, 30335, 30339, 30431, 30427, 30336, 30340, 30432, 30428
31623, 30336, 30340, 30432, 30428, 30337, 30341, 30433, 30429
31624, 30337, 30341, 30433, 30429, 30338, 30342, 30434, 30430
31625, 30338, 30342, 30434, 30430, 12518, 12519, 12542, 12541
31626, 8691, 8692, 8715, 8714, 30339, 30343, 30435, 30431
31627, 30339, 30343, 30435, 30431, 30340, 30344, 30436, 30432
31628, 30340, 30344, 30436, 30432, 30341, 30345, 30437, 30433
31629, 30341, 30345, 30437, 30433, 30342, 30346, 30438, 30434
31630, 30342, 30346, 30438, 30434, 12519, 12520, 12543, 12542
31631, 8692, 8693, 8716, 8715, 30343, 30347, 30439, 30435
31632, 30343, 30347, 30439, 30435, 30344, 30348, 30440, 30436
31633, 30344, 30348, 30440, 30436, 30345, 30349, 30441, 30437
31634, 30345, 30349, 30441, 30437, 30346, 30350, 30442, 30438
31635, 30346, 30350, 30442, 30438, 12520, 12521, 12544, 12543
31636, 8693, 8694, 8717, 8716, 30347, 30351, 30443, 30439
31637, 30347, 30351, 30443, 30439, 30348, 30352, 30444, 30440
31638, 30348, 30352, 30444, 30440, 30349, 30353, 30445, 30441
31639, 30349, 30353, 30445, 30441, 30350, 30354, 30446, 30442
31640, 30350, 30354, 30446, 30442, 12521, 12522, 12545, 12544
31641, 8694, 8695, 8718, 8717, 30351, 30355, 30447, 30443
31642, 30351, 30355, 30447, 30443, 30352, 30356, 30448, 30444
31643, 30352, 30356, 30448, 30444, 30353, 30357, 30449, 30445
31644, 30353, 30357, 30449, 30445, 30354, 30358, 30450, 30446
31645, 30354, 30358, 30450, 30446, 12522, 12523, 12546, 12545
31646, 8695, 8696, 8719, 8718, 30355, 30359, 30451, 30447
31647, 30355, 30359, 30451, 30447, 30356, 30360, 30452, 30448
31648, 30356, 30360, 30452, 30448, 30357, 30361, 30453, 30449
31649, 30357, 30361, 30453, 30449, 30358, 30362, 30454, 30450
31650, 30358, 30362, 30454, 30450, 12523, 12524, 12547, 12546
31651, 8696, 8697, 8720, 8719, 30359, 30363, 30455, 30451
31652, 30359, 30363, 30455, 30451, 30360, 30364, 30456, 30452
31653, 30360, 30364, 30456, 30452, 30361, 30365, 30457, 30453
31654, 30361, 30365, 30457, 30453, 30362, 30366, 30458, 30454
31655, 30362, 30366, 30458, 30454, 12524, 12525, 12548, 12547
31656, 8697, 8698, 8721, 8720, 30363, 30367, 30459, 30455
31657, 30363, 30367, 30459, 30455, 30364, 30368, 30460, 30456
31658, 30364, 30368, 30460, 30456, 30365, 30369, 30461, 30457
31659, 30365, 30369, 30461, 30457, 30366, 30370, 30462, 30458
31660, 30366, 30370, 30462, 30458, 12525, 12526, 12549, 12548
31661, 8698, 8699, 8722, 8721, 30367, 30371, 30463, 30459
31662, 30367, 30371, 30463, 30459, 30368, 30372, 30464, 30460
31663, 30368, 30372, 30464, 30460, 30369, 30373, 30465, 30461
31664, 30369, 30373, 30465, 30461, 30370, 30374, 30466, 30462
31665, 30370, 30374, 30466, 30462, 12526, 12527, 12550, 12549
31666, 8699, 8700, 8723, 8722, 30371, 30375, 30467, 30463
31667, 30371, 30375, 30467, 30463, 30372, 30376, 30468, 30464
31668, 30372, 30376, 30468, 30464, 30373, 30377, 30469, 30465
31669, 30373, 30377, 30469, 30465, 30374, 30378, 30470, 30466
31670, 30374, 30378, 30470, 30466, 12527, 12528, 12551, 12550
31671, 8700, 8701, 8724, 8723, 30375, 30379, 30471, 30467
31672, 30375, 30379, 30471, 30467, 30376, 30380, 30472, 30468
31673, 30376, 30380, 30472, 30468, 30377, 30381, 30473, 30469
31674, 30377, 30381, 30473, 30469, 30378, 30382, 30474, 30470
31675, 30378, 30382, 30474, 30470, 12528, 12529, 12552, 12551
31676, 8701, 8702, 8725, 8724, 30379, 30383, 30475, 30471
31677, 30379, 30383, 30475, 30471, 30380, 30384, 30476, 30472
31678, 30380, 30384, 30476, 30472, 30381, 30385, 30477, 30473
31679, 30381, 30385, 30477, 30473, 30382, 30386, 30478, 30474
31680, 30382, 30386, 30478, 30474, 12529, 12530, 12553, 12552
31681, 8702, 8703, 8726, 8725, 30383, 30387, 30479, 30475
31682, 30383, 30387, 30479, 30475, 30384, 30388, 30480, 30476
31683, 30384, 30388, 30480, 30476, 30385, 30389, 30481, 30477
31684, 30385, 30389, 30481, 30477, 30386, 30390, 30482, 30478
31685, 30386, 30390, 30482, 30478, 12530, 12531, 12554, 12553
31686, 8703, 8704, 8727, 8726, 30387, 30391, 30483, 30479
31687, 30387, 30391, 30483, 30479, 30388, 30392, 30484, 30480
31688, 30388, 30392, 30484, 30480, 30389, 30393, 30485, 30481
31689, 30389, 30393, 30485, 30481, 30390, 30394, 30486, 30482
31690, 30390, 30394, 30486, 30482, 12531, 12532, 12555, 12554
31691, 8704, 8705, 8728, 8727, 30391, 30395, 30487, 30483
31692, 30391, 30395, 30487, 30483, 30392, 30396, 30488, 30484
31693, 30392, 30396, 30488, 30484, 30393, 30397, 30489, 30485
31694, 30393, 30397, 30489, 30485, 30394, 30398, 30490, 30486
31695, 30394, 30398, 30490, 30486, 12532, 12533, 12556, 12555
31696, 8705, 8706, 8729, 8728, 30395, 30399, 30491, 30487
31697, 30395, 30399, 30491, 30487, 30396, 30400, 30492, 30488
31698, 30396, 30400, 30492, 30488, 30397, 30401, 30493, 30489
31699, 30397, 30401, 30493, 30489, 30398, 30402, 30494, 30490
31700, 30398, 30402, 30494, 30490, 12533, 12534, 12557, 12556
31701, 8706, 8707, 8730, 8729, 30399, 30403, 30495, 30491
31702, 30399, 30403, 30495, 30491, 30400, 30404, 30496, 30492
31703, 30400, 30404, 30496, 30492, 30401, 30405, 30497, 30493
31704, 30401, 30405, 30497, 30493, 30402, 30406, 30498, 30494
31705, 30402, 30406, 30498, 30494, 12534, 12535, 12558, 12557
31706, 8707, 8708, 8731, 8730, 30403, 30407, 30499, 30495
31707, 30403, 30407, 30499, 30495, 30404, 30408, 30500, 30496
31708, 30404, 30408, 30500, 30496, 30405, 30409, 30501, 30497
31709, 30405, 30409, 30501, 30497, 30406, 30410, 30502, 30498
31710, 30406, 30410, 30502, 30498, 12535, 12536, 12559, 12558
31711, 8708, 8709, 8732, 8731, 30407, 30411, 30503, 30499
31712, 30407, 30411, 30503, 30499, 30408, 30412, 30504, 30500
31713, 30408, 30412, 30504, 30500, 30409, 30413, 30505, 30501
31714, 30409, 30413, 30505, 30501, 30410, 30414, 30506, 30502
31715, 30410, 30414, 30506, 30502, 12536, 12537, 12560, 12559
31716, 8709, 8710, 8733, 8732, 30411, 30415, 30507, 30503
31717, 30411, 30415, 30507, 30503, 30412, 30416, 30508, 30504
31718, 30412, 30416, 30508, 30504, 30413, 30417, 30509, 30505
31719, 30413, 30417, 30509, 30505, 30414, 30418, 30510, 30506
31720, 30414, 30418, 30510, 30506, 12537, 12538, 12561, 12560
31721, 8710, 1142, 1143, 8733, 30415, 12320, 12324, 30507
31722, 30415, 12320, 12324, 30507, 30416, 12321, 12325, 30508
31723, 30416, 12321, 12325, 30508, 30417, 12322, 12326, 30509
31724, 30417, 12322, 12326, 30509, 30418, 12323, 12327, 30510
31725, 30418, 12323, 12327, 30510, 12538, 1923, 1924, 12561
31726, 1132, 8711, 8734, 1133, 12280, 30419, 30511, 12284
31727, 12280, 30419, 30511, 12284, 12281, 30420, 30512, 12285
31728, 12281, 30420, 30512, 12285, 12282, 30421, 30513, 12286
31729, 12282, 30421, 30513, 12286, 12283, 30422, 30514, 12287
31730, 12283, 30422, 30514, 12287, 1913, 12539, 12562, 1914
31731, 8711, 8712, 8735, 8734, 30419, 30423, 30515, 30511
31732, 30419, 30423, 30515, 30511, 30420, 30424, 30516, 30512
31733, 30420, 30424, 30516, 30512, 30421, 30425, 30517, 30513
31734, 30421, 30425, 30517, 30513, 30422, 30426, 30518, 30514
31735, 30422, 30426, 30518, 30514, 12539, 12540, 12563, 12562
31736, 8712, 8713, 8736, 8735, 30423, 30427, 30519, 30515
31737, 30423, 30427, 30519, 30515, 30424, 30428, 30520, 30516
31738, 30424, 30428, 30520, 30516, 30425, 30429, 30521, 30517
31739, 30425, 30429, 30521, 30517, 30426, 30430, 30522, 30518
31740, 30426, 30430, 30522, 30518, 12540, 12541, 12564, 12563
31741, 8713, 8714, 8737, 8736, 30427, 30431, 30523, 30519
31742, 30427, 30431, 30523, 30519, 30428, 30432, 30524, 30520
31743, 30428, 30432, 30524, 30520, 30429, 30433, 30525, 30521
31744, 30429, 30433, 30525, 30521, 30430, 30434, 30526, 30522
31745, 30430, 30434, 30526, 30522, 12541, 12542, 12565, 12564
31746, 8714, 8715, 8738, 8737, 30431, 30435, 30527, 30523
31747, 30431, 30435, 30527, 30523, 30432, 30436, 30528, 30524
31748, 30432, 30436, 30528, 30524, 30433, 30437, 30529, 30525
31749, 30433, 30437, 30529, 30525, 30434, 30438, 30530, 30526
31750, 30434, 30438, 30530, 30526, 12542, 12543, 12566, 12565
31751, 8715, 8716, 8739, 8738, 30435, 30439, 30531, 30527
31752, 30435, 30439, 30531, 30527, 30436, 30440, 30532, 30528
31753, 30436, 30440, 30532, 30528, 30437, 30441, 30533, 30529
31754, 30437, 30441, 30533, 30529, 30438, 30442, 30534, 30530
31755, 30438, 30442, 30534, 30530, 12543, 12544, 12567, 12566
31756, 8716, 8717, 8740, 8739, 30439, 30443, 30535, 30531
31757, 30439, 30443, 30535, 30531, 30440, 30444, 30536, 30532
31758, 30440, 30444, 30536, 30532, 30441, 30445, 30537, 30533
31759, 30441, 30445, 30537, 30533, 30442, 30446, 30538, 30534
31760, 30442, 30446, 30538, 30534, 12544, 12545, 12568, 12567
31761, 8717, 8718, 8741, 8740, 30443, 30447, 30539, 30535
31762, 30443, 30447, 30539, 30535, 30444, 30448, 30540, 30536
31763, 30444, 30448, 30540, 30536, 30445, 30449, 30541, 30537
31764, 30445, 30449, 30541, 30537, 30446, 30450, 30542, 30538
31765, 30446, 30450, 30542, 30538, 12545, 12546, 12569, 12568
31766, 8718, 8719, 8742, 8741, 30447, 30451, 30543, 30539
31767, 30447, 30451, 30543, 30539, 30448, 30452, 30544, 30540
31768, 30448, 30452, 30544, 30540, 30449, 30453, 30545, 30541
31769, 30449, 30453, 30545, 30541, 30450, 30454, 30546, 30542
31770, 30450, 30454, 30546, 30542, 12546, 12547, 12570, 12569
31771, 8719, 8720, 8743, 8742, 30451, 30455, 30547, 30543
31772, 30451, 30455, 30547, 30543, 30452, 30456, 30548, 30544
31773, 30452, 30456, 30548, 30544, 30453, 30457, 30549, 30545
31774, 30453, 30457, 30549, 30545, 30454, 30458, 30550, 30546
31775, 30454, 30458, 30550, 30546, 12547, 12548, 12571, 12570
31776, 8720, 8721, 8744, 8743, 30455, 30459, 30551, 30547
31777, 30455, 30459, 30551, 30547, 30456, 30460, 30552, 30548
31778, 30456, 30460, 30552, 30548, 30457, 30461, 30553, 30549
31779, 30457, 30461, 30553, 30549, 30458, 30462, 30554, 30550
31780, 30458, 30462, 30554, 30550, 12548, 12549, 12572, 12571
31781, 8721, 8722, 8745, 8744, 30459, 30463, 30555, 30551
31782, 30459, 30463, 30555, 30551, 30460, 30464, 30556, 30552
31783, 30460, 30464, 30556, 30552, 30461, 30465, 30557, 30553
31784, 30461, 30465, 30557, 30553, 30462, 30466, 30558, 30554
31785, 30462, 30466, 30558, 30554, 12549, 12550, 12573, 12572
31786, 8722, 8723, 8746, 8745, 30463, 30467, 30559, 30555
31787, 30463, 30467, 30559, 30555, 30464, 30468, 30560, 30556
31788, 30464, 30468, 30560, 30556, 30465, 30469, 30561, 30557
31789, 30465, 30469, 30561, 30557, 30466, 30470, 30562, 30558
31790, 30466, 30470, 30562, 30558, 12550, 12551, 12574, 12573
31791, 8723, 8724, 8747, 8746, 30467, 30471, 30563, 30559
31792, 30467, 30471, 30563, 30559, 30468, 30472, 30564, 30560
31793, 30468, 30472, 30564, 30560, 30469, 30473, 30565, 30561
31794, 30469, 30473, 30565, 30561, 30470, 30474, 30566, 30562
31795, 30470, 30474, 30566, 30562, 12551, 12552, 12575, 12574
31796, 8724, 8725, 8748, 8747, 30471, 30475, 30567, 30563
31797, 30471, 30475, 30567, 30563, 30472, 30476, 30568, 30564
31798, 30472, 30476, 30568, 30564, 30473, 30477, 30569, 30565
31799, 30473, 30477, 30569, 30565, 30474, 30478, 30570, 30566
31800, 30474, 30478, 30570, 30566, 12552, 12553, 12576, 12575
31801, 8725, 8726, 8749, 8748, 30475, 30479, 30571, 30567
31802, 30475, 30479, 30571, 30567, 30476, 30480, 30572, 30568
31803, 30476, 30480, 30572, 30568, 30477, 30481, 30573, 30569
31804, 30477, 30481, 30573, 30569, 30478, 30482, 30574, 30570
31805, 30478, 30482, 30574, 30570, 12553, 12554, 12577, 12576
31806, 8726, 8727, 8750, 8749, 30479, 30483, 30575, 30571
31807, 30479, 30483, 30575, 30571, 30480, 30484, 30576, 30572
31808, 30480, 30484, 30576, 30572, 30481, 30485, 30577, 30573
31809, 30481, 30485, 30577, 30573, 30482, 30486, 30578, 30574
31810, 30482, 30486, 30578, 30574, 12554, 12555, 12578, 12577
31811, 8727, 8728, 8751, 8750, 30483, 30487, 30579, 30575
31812, 30483, 30487, 30579, 30575, 30484, 30488, 30580, 30576
31813, 30484, 30488, 30580, 30576, 30485, 30489, 30581, 30577
31814, 30485, 30489, 30581, 30577, 30486, 30490, 30582, 30578
31815, 30486, 30490, 30582, 30578, 12555, 12556, 12579, 12578
31816, 8728, 8729, 8752, 8751, 30487, 30491, 30583, 30579
31817, 30487, 30491, 30583, 30579, 30488, 30492, 30584, 30580
31818, 30488, 30492, 30584, 30580, 30489, 30493, 30585, 30581
31819, 30489, 30493, 30585, 30581, 30490, 30494, 30586, 30582
31820, 30490, 30494, 30586, 30582, 12556, 12557, 12580, 12579
31821, 8729, 8730, 8753, 8752, 30491, 30495, 30587, 30583
31822, 30491, 30495, 30587, 30583, 30492, 30496, 30588, 30584
31823, 30492, 30496, 30588, 30584, 30493, 30497, 30589, 30585
31824, 30493, 30497, 30589, 30585, 30494, 30498, 30590, 30586
31825, 30494, 30498, 30590, 30586, 12557, 12558, 12581, 12580
31826, 8730, 8731, 8754, 8753, 30495, 30499, 30591, 30587
31827, 30495, 30499, 30591, 30587, 30496, 30500, 30592, 30588
31828, 30496, 30500, 30592, 30588, 30497, 30501, 30593, 30589
31829, 30497, 30501, 30593, 30589, 30498, 30502, 30594, 30590
31830, 30498, 30502, 30594, 30590, 12558, 12559, 12582, 12581
31831, 8731, 8732, 8755, 8754, 30499, 30503, 30595, 30591
31832, 30499, 30503, 30595, 30591, 30500, 30504, 30596, 30592
31833, 30500, 30504, 30596, 30592, 30501, 30505, 30597, 30593
31834, 30501, 30505, 30597, 30593, 30502, 30506, 30598, 30594
