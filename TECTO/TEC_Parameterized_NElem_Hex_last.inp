26253, 1.4916666666667, 0.066666666666667, 0.375
26254, 1.4916666666667, 0.033333333333333, 0.375
26255, 1.5333333333333, 0.066666666666667, 0.375
26256, 1.5333333333333, 0.033333333333333, 0.375
26257, 1.575, 0.066666666666667, 0.375
26258, 1.575, 0.033333333333333, 0.375
26259, 1.6166666666667, 0.066666666666667, 0.375
26260, 1.6166666666667, 0.033333333333333, 0.375
26261, 1.6583333333333, 0.066666666666667, 0.375
26262, 1.6583333333333, 0.033333333333333, 0.375
26263, 1.7, 0.066666666666667, 0.375
26264, 1.7, 0.033333333333333, 0.375
26265, 1.7416666666667, 0.066666666666667, 0.375
26266, 1.7416666666667, 0.033333333333333, 0.375
26267, 1.7833333333333, 0.066666666666667, 0.375
26268, 1.7833333333333, 0.033333333333333, 0.375
26269, 1.825, 0.066666666666667, 0.375
26270, 1.825, 0.033333333333333, 0.375
26271, 1.8666666666667, 0.066666666666667, 0.375
26272, 1.8666666666667, 0.033333333333333, 0.375
26273, 1.9083333333333, 0.066666666666667, 0.375
26274, 1.9083333333333, 0.033333333333333, 0.375
26275, 1.95, 0.066666666666667, 0.375
26276, 1.95, 0.033333333333333, 0.375
26277, 1.9916666666667, 0.066666666666667, 0.375
26278, 1.9916666666667, 0.033333333333333, 0.375
26279, 2.0333333333333, 0.066666666666667, 0.375
26280, 2.0333333333333, 0.033333333333333, 0.375
26281, 2.075, 0.066666666666667, 0.375
26282, 2.075, 0.033333333333333, 0.375
26283, 2.1166666666667, 0.066666666666667, 0.375
26284, 2.1166666666667, 0.033333333333333, 0.375
26285, 2.1583333333333, 0.066666666666667, 0.375
26286, 2.1583333333333, 0.033333333333333, 0.375
26287, 1.2416666666667, 0.066666666666667, 0.41666666666667
26288, 1.2416666666667, 0.033333333333333, 0.41666666666667
26289, 1.2833333333333, 0.066666666666667, 0.41666666666667
26290, 1.2833333333333, 0.033333333333333, 0.41666666666667
26291, 1.325, 0.066666666666667, 0.41666666666667
26292, 1.325, 0.033333333333333, 0.41666666666667
26293, 1.3666666666667, 0.066666666666667, 0.41666666666667
26294, 1.3666666666667, 0.033333333333333, 0.41666666666667
26295, 1.4083333333333, 0.066666666666667, 0.41666666666667
26296, 1.4083333333333, 0.033333333333333, 0.41666666666667
26297, 1.45, 0.066666666666667, 0.41666666666667
26298, 1.45, 0.033333333333333, 0.41666666666667
26299, 1.4916666666667, 0.066666666666667, 0.41666666666667
26300, 1.4916666666667, 0.033333333333333, 0.41666666666667
26301, 1.5333333333333, 0.066666666666667, 0.41666666666667
26302, 1.5333333333333, 0.033333333333333, 0.41666666666667
26303, 1.575, 0.066666666666667, 0.41666666666667
26304, 1.575, 0.033333333333333, 0.41666666666667
26305, 1.6166666666667, 0.066666666666667, 0.41666666666667
26306, 1.6166666666667, 0.033333333333333, 0.41666666666667
26307, 1.6583333333333, 0.066666666666667, 0.41666666666667
26308, 1.6583333333333, 0.033333333333333, 0.41666666666667
26309, 1.7, 0.066666666666667, 0.41666666666667
26310, 1.7, 0.033333333333333, 0.41666666666667
26311, 1.7416666666667, 0.066666666666667, 0.41666666666667
26312, 1.7416666666667, 0.033333333333333, 0.41666666666667
26313, 1.7833333333333, 0.066666666666667, 0.41666666666667
26314, 1.7833333333333, 0.033333333333333, 0.41666666666667
26315, 1.825, 0.066666666666667, 0.41666666666667
26316, 1.825, 0.033333333333333, 0.41666666666667
26317, 1.8666666666667, 0.066666666666667, 0.41666666666667
26318, 1.8666666666667, 0.033333333333333, 0.41666666666667
26319, 1.9083333333333, 0.066666666666667, 0.41666666666667
26320, 1.9083333333333, 0.033333333333333, 0.41666666666667
26321, 1.95, 0.066666666666667, 0.41666666666667
26322, 1.95, 0.033333333333333, 0.41666666666667
26323, 1.9916666666667, 0.066666666666667, 0.41666666666667
26324, 1.9916666666667, 0.033333333333333, 0.41666666666667
26325, 2.0333333333333, 0.066666666666667, 0.41666666666667
26326, 2.0333333333333, 0.033333333333333, 0.41666666666667
26327, 2.075, 0.066666666666667, 0.41666666666667
26328, 2.075, 0.033333333333333, 0.41666666666667
26329, 2.1166666666667, 0.066666666666667, 0.41666666666667
26330, 2.1166666666667, 0.033333333333333, 0.41666666666667
26331, 2.1583333333333, 0.066666666666667, 0.41666666666667
26332, 2.1583333333333, 0.033333333333333, 0.41666666666667
26333, 1.2416666666667, 0.066666666666667, 0.45833333333333
26334, 1.2416666666667, 0.033333333333333, 0.45833333333333
26335, 1.2833333333333, 0.066666666666667, 0.45833333333333
26336, 1.2833333333333, 0.033333333333333, 0.45833333333333
26337, 1.325, 0.066666666666667, 0.45833333333333
26338, 1.325, 0.033333333333333, 0.45833333333333
26339, 1.3666666666667, 0.066666666666667, 0.45833333333333
26340, 1.3666666666667, 0.033333333333333, 0.45833333333333
26341, 1.4083333333333, 0.066666666666667, 0.45833333333333
26342, 1.4083333333333, 0.033333333333333, 0.45833333333333
26343, 1.45, 0.066666666666667, 0.45833333333333
26344, 1.45, 0.033333333333333, 0.45833333333333
26345, 1.4916666666667, 0.066666666666667, 0.45833333333333
26346, 1.4916666666667, 0.033333333333333, 0.45833333333333
26347, 1.5333333333333, 0.066666666666667, 0.45833333333333
26348, 1.5333333333333, 0.033333333333333, 0.45833333333333
26349, 1.575, 0.066666666666667, 0.45833333333333
26350, 1.575, 0.033333333333333, 0.45833333333333
26351, 1.6166666666667, 0.066666666666667, 0.45833333333333
26352, 1.6166666666667, 0.033333333333333, 0.45833333333333
26353, 1.6583333333333, 0.066666666666667, 0.45833333333333
26354, 1.6583333333333, 0.033333333333333, 0.45833333333333
26355, 1.7, 0.066666666666667, 0.45833333333333
26356, 1.7, 0.033333333333333, 0.45833333333333
26357, 1.7416666666667, 0.066666666666667, 0.45833333333333
26358, 1.7416666666667, 0.033333333333333, 0.45833333333333
26359, 1.7833333333333, 0.066666666666667, 0.45833333333333
26360, 1.7833333333333, 0.033333333333333, 0.45833333333333
26361, 1.825, 0.066666666666667, 0.45833333333333
26362, 1.825, 0.033333333333333, 0.45833333333333
26363, 1.8666666666667, 0.066666666666667, 0.45833333333333
26364, 1.8666666666667, 0.033333333333333, 0.45833333333333
26365, 1.9083333333333, 0.066666666666667, 0.45833333333333
26366, 1.9083333333333, 0.033333333333333, 0.45833333333333
26367, 1.95, 0.066666666666667, 0.45833333333333
26368, 1.95, 0.033333333333333, 0.45833333333333
26369, 1.9916666666667, 0.066666666666667, 0.45833333333333
26370, 1.9916666666667, 0.033333333333333, 0.45833333333333
26371, 2.0333333333333, 0.066666666666667, 0.45833333333333
26372, 2.0333333333333, 0.033333333333333, 0.45833333333333
26373, 2.075, 0.066666666666667, 0.45833333333333
26374, 2.075, 0.033333333333333, 0.45833333333333
26375, 2.1166666666667, 0.066666666666667, 0.45833333333333
26376, 2.1166666666667, 0.033333333333333, 0.45833333333333
26377, 2.1583333333333, 0.066666666666667, 0.45833333333333
26378, 2.1583333333333, 0.033333333333333, 0.45833333333333
26379, 0.041666666666667, 1.54, 0.041666666666667
26380, 0.041666666666667, 1.58, 0.041666666666667
26381, 0.041666666666667, 1.62, 0.041666666666667
26382, 0.041666666666667, 1.66, 0.041666666666667
26383, 0.041666666666667, 1.54, 0.083333333333333
26384, 0.041666666666667, 1.58, 0.083333333333333
26385, 0.041666666666667, 1.62, 0.083333333333333
26386, 0.041666666666667, 1.66, 0.083333333333333
26387, 0.041666666666667, 1.54, 0.125
26388, 0.041666666666667, 1.58, 0.125
26389, 0.041666666666667, 1.62, 0.125
26390, 0.041666666666667, 1.66, 0.125
26391, 0.041666666666667, 1.54, 0.16666666666667
26392, 0.041666666666667, 1.58, 0.16666666666667
26393, 0.041666666666667, 1.62, 0.16666666666667
26394, 0.041666666666667, 1.66, 0.16666666666667
26395, 0.041666666666667, 1.54, 0.20833333333333
26396, 0.041666666666667, 1.58, 0.20833333333333
26397, 0.041666666666667, 1.62, 0.20833333333333
26398, 0.041666666666667, 1.66, 0.20833333333333
26399, 0.041666666666667, 1.54, 0.25
26400, 0.041666666666667, 1.58, 0.25
26401, 0.041666666666667, 1.62, 0.25
26402, 0.041666666666667, 1.66, 0.25
26403, 0.041666666666667, 1.54, 0.29166666666667
26404, 0.041666666666667, 1.58, 0.29166666666667
26405, 0.041666666666667, 1.62, 0.29166666666667
26406, 0.041666666666667, 1.66, 0.29166666666667
26407, 0.041666666666667, 1.54, 0.33333333333333
26408, 0.041666666666667, 1.58, 0.33333333333333
26409, 0.041666666666667, 1.62, 0.33333333333333
26410, 0.041666666666667, 1.66, 0.33333333333333
26411, 0.041666666666667, 1.54, 0.375
26412, 0.041666666666667, 1.58, 0.375
26413, 0.041666666666667, 1.62, 0.375
26414, 0.041666666666667, 1.66, 0.375
26415, 0.041666666666667, 1.54, 0.41666666666667
26416, 0.041666666666667, 1.58, 0.41666666666667
26417, 0.041666666666667, 1.62, 0.41666666666667
26418, 0.041666666666667, 1.66, 0.41666666666667
26419, 0.041666666666667, 1.54, 0.45833333333333
26420, 0.041666666666667, 1.58, 0.45833333333333
26421, 0.041666666666667, 1.62, 0.45833333333333
26422, 0.041666666666667, 1.66, 0.45833333333333
26423, 0.083333333333333, 1.54, 0.041666666666667
26424, 0.083333333333333, 1.58, 0.041666666666667
26425, 0.083333333333333, 1.62, 0.041666666666667
26426, 0.083333333333333, 1.66, 0.041666666666667
26427, 0.083333333333333, 1.54, 0.083333333333333
26428, 0.083333333333333, 1.58, 0.083333333333333
26429, 0.083333333333333, 1.62, 0.083333333333333
26430, 0.083333333333333, 1.66, 0.083333333333333
26431, 0.083333333333333, 1.54, 0.125
26432, 0.083333333333333, 1.58, 0.125
26433, 0.083333333333333, 1.62, 0.125
26434, 0.083333333333333, 1.66, 0.125
26435, 0.083333333333333, 1.54, 0.16666666666667
26436, 0.083333333333333, 1.58, 0.16666666666667
26437, 0.083333333333333, 1.62, 0.16666666666667
26438, 0.083333333333333, 1.66, 0.16666666666667
26439, 0.083333333333333, 1.54, 0.20833333333333
26440, 0.083333333333333, 1.58, 0.20833333333333
26441, 0.083333333333333, 1.62, 0.20833333333333
26442, 0.083333333333333, 1.66, 0.20833333333333
26443, 0.083333333333333, 1.54, 0.25
26444, 0.083333333333333, 1.58, 0.25
26445, 0.083333333333333, 1.62, 0.25
26446, 0.083333333333333, 1.66, 0.25
26447, 0.083333333333333, 1.54, 0.29166666666667
26448, 0.083333333333333, 1.58, 0.29166666666667
26449, 0.083333333333333, 1.62, 0.29166666666667
26450, 0.083333333333333, 1.66, 0.29166666666667
26451, 0.083333333333333, 1.54, 0.33333333333333
26452, 0.083333333333333, 1.58, 0.33333333333333
26453, 0.083333333333333, 1.62, 0.33333333333333
26454, 0.083333333333333, 1.66, 0.33333333333333
26455, 0.083333333333333, 1.54, 0.375
26456, 0.083333333333333, 1.58, 0.375
26457, 0.083333333333333, 1.62, 0.375
26458, 0.083333333333333, 1.66, 0.375
26459, 0.083333333333333, 1.54, 0.41666666666667
26460, 0.083333333333333, 1.58, 0.41666666666667
26461, 0.083333333333333, 1.62, 0.41666666666667
26462, 0.083333333333333, 1.66, 0.41666666666667
26463, 0.083333333333333, 1.54, 0.45833333333333
26464, 0.083333333333333, 1.58, 0.45833333333333
26465, 0.083333333333333, 1.62, 0.45833333333333
26466, 0.083333333333333, 1.66, 0.45833333333333
26467, 0.125, 1.54, 0.041666666666667
26468, 0.125, 1.58, 0.041666666666667
26469, 0.125, 1.62, 0.041666666666667
26470, 0.125, 1.66, 0.041666666666667
26471, 0.125, 1.54, 0.083333333333333
26472, 0.125, 1.58, 0.083333333333333
26473, 0.125, 1.62, 0.083333333333333
26474, 0.125, 1.66, 0.083333333333333
26475, 0.125, 1.54, 0.125
26476, 0.125, 1.58, 0.125
26477, 0.125, 1.62, 0.125
26478, 0.125, 1.66, 0.125
26479, 0.125, 1.54, 0.16666666666667
26480, 0.125, 1.58, 0.16666666666667
26481, 0.125, 1.62, 0.16666666666667
26482, 0.125, 1.66, 0.16666666666667
26483, 0.125, 1.54, 0.20833333333333
26484, 0.125, 1.58, 0.20833333333333
26485, 0.125, 1.62, 0.20833333333333
26486, 0.125, 1.66, 0.20833333333333
26487, 0.125, 1.54, 0.25
26488, 0.125, 1.58, 0.25
26489, 0.125, 1.62, 0.25
26490, 0.125, 1.66, 0.25
26491, 0.125, 1.54, 0.29166666666667
26492, 0.125, 1.58, 0.29166666666667
26493, 0.125, 1.62, 0.29166666666667
26494, 0.125, 1.66, 0.29166666666667
26495, 0.125, 1.54, 0.33333333333333
26496, 0.125, 1.58, 0.33333333333333
26497, 0.125, 1.62, 0.33333333333333
26498, 0.125, 1.66, 0.33333333333333
26499, 0.125, 1.54, 0.375
26500, 0.125, 1.58, 0.375
26501, 0.125, 1.62, 0.375
26502, 0.125, 1.66, 0.375
26503, 0.125, 1.54, 0.41666666666667
26504, 0.125, 1.58, 0.41666666666667
26505, 0.125, 1.62, 0.41666666666667
26506, 0.125, 1.66, 0.41666666666667
26507, 0.125, 1.54, 0.45833333333333
26508, 0.125, 1.58, 0.45833333333333
26509, 0.125, 1.62, 0.45833333333333
26510, 0.125, 1.66, 0.45833333333333
26511, 0.16666666666667, 1.54, 0.041666666666667
26512, 0.16666666666667, 1.58, 0.041666666666667
26513, 0.16666666666667, 1.62, 0.041666666666667
26514, 0.16666666666667, 1.66, 0.041666666666667
26515, 0.16666666666667, 1.54, 0.083333333333333
26516, 0.16666666666667, 1.58, 0.083333333333333
26517, 0.16666666666667, 1.62, 0.083333333333333
26518, 0.16666666666667, 1.66, 0.083333333333333
26519, 0.16666666666667, 1.54, 0.125
26520, 0.16666666666667, 1.58, 0.125
26521, 0.16666666666667, 1.62, 0.125
26522, 0.16666666666667, 1.66, 0.125
26523, 0.16666666666667, 1.54, 0.16666666666667
26524, 0.16666666666667, 1.58, 0.16666666666667
26525, 0.16666666666667, 1.62, 0.16666666666667
26526, 0.16666666666667, 1.66, 0.16666666666667
26527, 0.16666666666667, 1.54, 0.20833333333333
26528, 0.16666666666667, 1.58, 0.20833333333333
26529, 0.16666666666667, 1.62, 0.20833333333333
26530, 0.16666666666667, 1.66, 0.20833333333333
26531, 0.16666666666667, 1.54, 0.25
26532, 0.16666666666667, 1.58, 0.25
26533, 0.16666666666667, 1.62, 0.25
26534, 0.16666666666667, 1.66, 0.25
26535, 0.16666666666667, 1.54, 0.29166666666667
26536, 0.16666666666667, 1.58, 0.29166666666667
26537, 0.16666666666667, 1.62, 0.29166666666667
26538, 0.16666666666667, 1.66, 0.29166666666667
26539, 0.16666666666667, 1.54, 0.33333333333333
26540, 0.16666666666667, 1.58, 0.33333333333333
26541, 0.16666666666667, 1.62, 0.33333333333333
26542, 0.16666666666667, 1.66, 0.33333333333333
26543, 0.16666666666667, 1.54, 0.375
26544, 0.16666666666667, 1.58, 0.375
26545, 0.16666666666667, 1.62, 0.375
26546, 0.16666666666667, 1.66, 0.375
26547, 0.16666666666667, 1.54, 0.41666666666667
26548, 0.16666666666667, 1.58, 0.41666666666667
26549, 0.16666666666667, 1.62, 0.41666666666667
26550, 0.16666666666667, 1.66, 0.41666666666667
26551, 0.16666666666667, 1.54, 0.45833333333333
26552, 0.16666666666667, 1.58, 0.45833333333333
26553, 0.16666666666667, 1.62, 0.45833333333333
26554, 0.16666666666667, 1.66, 0.45833333333333
26555, 0.20833333333333, 1.54, 0.041666666666667
26556, 0.20833333333333, 1.58, 0.041666666666667
26557, 0.20833333333333, 1.62, 0.041666666666667
26558, 0.20833333333333, 1.66, 0.041666666666667
26559, 0.20833333333333, 1.54, 0.083333333333333
26560, 0.20833333333333, 1.58, 0.083333333333333
26561, 0.20833333333333, 1.62, 0.083333333333333
26562, 0.20833333333333, 1.66, 0.083333333333333
26563, 0.20833333333333, 1.54, 0.125
26564, 0.20833333333333, 1.58, 0.125
26565, 0.20833333333333, 1.62, 0.125
26566, 0.20833333333333, 1.66, 0.125
26567, 0.20833333333333, 1.54, 0.16666666666667
26568, 0.20833333333333, 1.58, 0.16666666666667
26569, 0.20833333333333, 1.62, 0.16666666666667
26570, 0.20833333333333, 1.66, 0.16666666666667
26571, 0.20833333333333, 1.54, 0.20833333333333
26572, 0.20833333333333, 1.58, 0.20833333333333
26573, 0.20833333333333, 1.62, 0.20833333333333
26574, 0.20833333333333, 1.66, 0.20833333333333
26575, 0.20833333333333, 1.54, 0.25
26576, 0.20833333333333, 1.58, 0.25
26577, 0.20833333333333, 1.62, 0.25
26578, 0.20833333333333, 1.66, 0.25
26579, 0.20833333333333, 1.54, 0.29166666666667
26580, 0.20833333333333, 1.58, 0.29166666666667
26581, 0.20833333333333, 1.62, 0.29166666666667
26582, 0.20833333333333, 1.66, 0.29166666666667
26583, 0.20833333333333, 1.54, 0.33333333333333
26584, 0.20833333333333, 1.58, 0.33333333333333
26585, 0.20833333333333, 1.62, 0.33333333333333
26586, 0.20833333333333, 1.66, 0.33333333333333
26587, 0.20833333333333, 1.54, 0.375
26588, 0.20833333333333, 1.58, 0.375
26589, 0.20833333333333, 1.62, 0.375
26590, 0.20833333333333, 1.66, 0.375
26591, 0.20833333333333, 1.54, 0.41666666666667
26592, 0.20833333333333, 1.58, 0.41666666666667
26593, 0.20833333333333, 1.62, 0.41666666666667
26594, 0.20833333333333, 1.66, 0.41666666666667
26595, 0.20833333333333, 1.54, 0.45833333333333
26596, 0.20833333333333, 1.58, 0.45833333333333
26597, 0.20833333333333, 1.62, 0.45833333333333
26598, 0.20833333333333, 1.66, 0.45833333333333
26599, 0.25, 1.54, 0.041666666666667
26600, 0.25, 1.58, 0.041666666666667
26601, 0.25, 1.62, 0.041666666666667
26602, 0.25, 1.66, 0.041666666666667
26603, 0.25, 1.54, 0.083333333333333
26604, 0.25, 1.58, 0.083333333333333
26605, 0.25, 1.62, 0.083333333333333
26606, 0.25, 1.66, 0.083333333333333
26607, 0.25, 1.54, 0.125
26608, 0.25, 1.58, 0.125
26609, 0.25, 1.62, 0.125
26610, 0.25, 1.66, 0.125
26611, 0.25, 1.54, 0.16666666666667
26612, 0.25, 1.58, 0.16666666666667
26613, 0.25, 1.62, 0.16666666666667
26614, 0.25, 1.66, 0.16666666666667
26615, 0.25, 1.54, 0.20833333333333
26616, 0.25, 1.58, 0.20833333333333
26617, 0.25, 1.62, 0.20833333333333
26618, 0.25, 1.66, 0.20833333333333
26619, 0.25, 1.54, 0.25
26620, 0.25, 1.58, 0.25
26621, 0.25, 1.62, 0.25
26622, 0.25, 1.66, 0.25
26623, 0.25, 1.54, 0.29166666666667
26624, 0.25, 1.58, 0.29166666666667
26625, 0.25, 1.62, 0.29166666666667
26626, 0.25, 1.66, 0.29166666666667
26627, 0.25, 1.54, 0.33333333333333
26628, 0.25, 1.58, 0.33333333333333
26629, 0.25, 1.62, 0.33333333333333
26630, 0.25, 1.66, 0.33333333333333
26631, 0.25, 1.54, 0.375
26632, 0.25, 1.58, 0.375
26633, 0.25, 1.62, 0.375
26634, 0.25, 1.66, 0.375
26635, 0.25, 1.54, 0.41666666666667
26636, 0.25, 1.58, 0.41666666666667
26637, 0.25, 1.62, 0.41666666666667
26638, 0.25, 1.66, 0.41666666666667
26639, 0.25, 1.54, 0.45833333333333
26640, 0.25, 1.58, 0.45833333333333
26641, 0.25, 1.62, 0.45833333333333
26642, 0.25, 1.66, 0.45833333333333
26643, 0.29166666666667, 1.54, 0.041666666666667
26644, 0.29166666666667, 1.58, 0.041666666666667
26645, 0.29166666666667, 1.62, 0.041666666666667
26646, 0.29166666666667, 1.66, 0.041666666666667
26647, 0.29166666666667, 1.54, 0.083333333333333
26648, 0.29166666666667, 1.58, 0.083333333333333
26649, 0.29166666666667, 1.62, 0.083333333333333
26650, 0.29166666666667, 1.66, 0.083333333333333
26651, 0.29166666666667, 1.54, 0.125
26652, 0.29166666666667, 1.58, 0.125
26653, 0.29166666666667, 1.62, 0.125
26654, 0.29166666666667, 1.66, 0.125
26655, 0.29166666666667, 1.54, 0.16666666666667
26656, 0.29166666666667, 1.58, 0.16666666666667
26657, 0.29166666666667, 1.62, 0.16666666666667
26658, 0.29166666666667, 1.66, 0.16666666666667
26659, 0.29166666666667, 1.54, 0.20833333333333
26660, 0.29166666666667, 1.58, 0.20833333333333
26661, 0.29166666666667, 1.62, 0.20833333333333
26662, 0.29166666666667, 1.66, 0.20833333333333
26663, 0.29166666666667, 1.54, 0.25
26664, 0.29166666666667, 1.58, 0.25
26665, 0.29166666666667, 1.62, 0.25
26666, 0.29166666666667, 1.66, 0.25
26667, 0.29166666666667, 1.54, 0.29166666666667
26668, 0.29166666666667, 1.58, 0.29166666666667
26669, 0.29166666666667, 1.62, 0.29166666666667
26670, 0.29166666666667, 1.66, 0.29166666666667
26671, 0.29166666666667, 1.54, 0.33333333333333
26672, 0.29166666666667, 1.58, 0.33333333333333
26673, 0.29166666666667, 1.62, 0.33333333333333
26674, 0.29166666666667, 1.66, 0.33333333333333
26675, 0.29166666666667, 1.54, 0.375
26676, 0.29166666666667, 1.58, 0.375
26677, 0.29166666666667, 1.62, 0.375
26678, 0.29166666666667, 1.66, 0.375
26679, 0.29166666666667, 1.54, 0.41666666666667
26680, 0.29166666666667, 1.58, 0.41666666666667
26681, 0.29166666666667, 1.62, 0.41666666666667
26682, 0.29166666666667, 1.66, 0.41666666666667
26683, 0.29166666666667, 1.54, 0.45833333333333
26684, 0.29166666666667, 1.58, 0.45833333333333
26685, 0.29166666666667, 1.62, 0.45833333333333
26686, 0.29166666666667, 1.66, 0.45833333333333
26687, 0.33333333333333, 1.54, 0.041666666666667
26688, 0.33333333333333, 1.58, 0.041666666666667
26689, 0.33333333333333, 1.62, 0.041666666666667
26690, 0.33333333333333, 1.66, 0.041666666666667
26691, 0.33333333333333, 1.54, 0.083333333333333
26692, 0.33333333333333, 1.58, 0.083333333333333
26693, 0.33333333333333, 1.62, 0.083333333333333
26694, 0.33333333333333, 1.66, 0.083333333333333
26695, 0.33333333333333, 1.54, 0.125
26696, 0.33333333333333, 1.58, 0.125
26697, 0.33333333333333, 1.62, 0.125
26698, 0.33333333333333, 1.66, 0.125
26699, 0.33333333333333, 1.54, 0.16666666666667
26700, 0.33333333333333, 1.58, 0.16666666666667
26701, 0.33333333333333, 1.62, 0.16666666666667
26702, 0.33333333333333, 1.66, 0.16666666666667
26703, 0.33333333333333, 1.54, 0.20833333333333
26704, 0.33333333333333, 1.58, 0.20833333333333
26705, 0.33333333333333, 1.62, 0.20833333333333
26706, 0.33333333333333, 1.66, 0.20833333333333
26707, 0.33333333333333, 1.54, 0.25
26708, 0.33333333333333, 1.58, 0.25
26709, 0.33333333333333, 1.62, 0.25
26710, 0.33333333333333, 1.66, 0.25
26711, 0.33333333333333, 1.54, 0.29166666666667
26712, 0.33333333333333, 1.58, 0.29166666666667
26713, 0.33333333333333, 1.62, 0.29166666666667
26714, 0.33333333333333, 1.66, 0.29166666666667
26715, 0.33333333333333, 1.54, 0.33333333333333
26716, 0.33333333333333, 1.58, 0.33333333333333
26717, 0.33333333333333, 1.62, 0.33333333333333
26718, 0.33333333333333, 1.66, 0.33333333333333
26719, 0.33333333333333, 1.54, 0.375
26720, 0.33333333333333, 1.58, 0.375
26721, 0.33333333333333, 1.62, 0.375
26722, 0.33333333333333, 1.66, 0.375
26723, 0.33333333333333, 1.54, 0.41666666666667
26724, 0.33333333333333, 1.58, 0.41666666666667
26725, 0.33333333333333, 1.62, 0.41666666666667
26726, 0.33333333333333, 1.66, 0.41666666666667
26727, 0.33333333333333, 1.54, 0.45833333333333
26728, 0.33333333333333, 1.58, 0.45833333333333
26729, 0.33333333333333, 1.62, 0.45833333333333
26730, 0.33333333333333, 1.66, 0.45833333333333
26731, 0.375, 1.54, 0.041666666666667
26732, 0.375, 1.58, 0.041666666666667
26733, 0.375, 1.62, 0.041666666666667
26734, 0.375, 1.66, 0.041666666666667
26735, 0.375, 1.54, 0.083333333333333
26736, 0.375, 1.58, 0.083333333333333
26737, 0.375, 1.62, 0.083333333333333
26738, 0.375, 1.66, 0.083333333333333
26739, 0.375, 1.54, 0.125
26740, 0.375, 1.58, 0.125
26741, 0.375, 1.62, 0.125
26742, 0.375, 1.66, 0.125
26743, 0.375, 1.54, 0.16666666666667
26744, 0.375, 1.58, 0.16666666666667
26745, 0.375, 1.62, 0.16666666666667
26746, 0.375, 1.66, 0.16666666666667
26747, 0.375, 1.54, 0.20833333333333
26748, 0.375, 1.58, 0.20833333333333
26749, 0.375, 1.62, 0.20833333333333
26750, 0.375, 1.66, 0.20833333333333
26751, 0.375, 1.54, 0.25
26752, 0.375, 1.58, 0.25
26753, 0.375, 1.62, 0.25
26754, 0.375, 1.66, 0.25
26755, 0.375, 1.54, 0.29166666666667
26756, 0.375, 1.58, 0.29166666666667
26757, 0.375, 1.62, 0.29166666666667
26758, 0.375, 1.66, 0.29166666666667
26759, 0.375, 1.54, 0.33333333333333
26760, 0.375, 1.58, 0.33333333333333
26761, 0.375, 1.62, 0.33333333333333
26762, 0.375, 1.66, 0.33333333333333
26763, 0.375, 1.54, 0.375
26764, 0.375, 1.58, 0.375
26765, 0.375, 1.62, 0.375
26766, 0.375, 1.66, 0.375
26767, 0.375, 1.54, 0.41666666666667
26768, 0.375, 1.58, 0.41666666666667
26769, 0.375, 1.62, 0.41666666666667
26770, 0.375, 1.66, 0.41666666666667
26771, 0.375, 1.54, 0.45833333333333
26772, 0.375, 1.58, 0.45833333333333
26773, 0.375, 1.62, 0.45833333333333
26774, 0.375, 1.66, 0.45833333333333
26775, 0.41666666666667, 1.54, 0.041666666666667
26776, 0.41666666666667, 1.58, 0.041666666666667
26777, 0.41666666666667, 1.62, 0.041666666666667
26778, 0.41666666666667, 1.66, 0.041666666666667
26779, 0.41666666666667, 1.54, 0.083333333333333
26780, 0.41666666666667, 1.58, 0.083333333333333
26781, 0.41666666666667, 1.62, 0.083333333333333
26782, 0.41666666666667, 1.66, 0.083333333333333
26783, 0.41666666666667, 1.54, 0.125
26784, 0.41666666666667, 1.58, 0.125
26785, 0.41666666666667, 1.62, 0.125
26786, 0.41666666666667, 1.66, 0.125
26787, 0.41666666666667, 1.54, 0.16666666666667
26788, 0.41666666666667, 1.58, 0.16666666666667
26789, 0.41666666666667, 1.62, 0.16666666666667
26790, 0.41666666666667, 1.66, 0.16666666666667
26791, 0.41666666666667, 1.54, 0.20833333333333
26792, 0.41666666666667, 1.58, 0.20833333333333
26793, 0.41666666666667, 1.62, 0.20833333333333
26794, 0.41666666666667, 1.66, 0.20833333333333
26795, 0.41666666666667, 1.54, 0.25
26796, 0.41666666666667, 1.58, 0.25
26797, 0.41666666666667, 1.62, 0.25
26798, 0.41666666666667, 1.66, 0.25
26799, 0.41666666666667, 1.54, 0.29166666666667
26800, 0.41666666666667, 1.58, 0.29166666666667
26801, 0.41666666666667, 1.62, 0.29166666666667
26802, 0.41666666666667, 1.66, 0.29166666666667
26803, 0.41666666666667, 1.54, 0.33333333333333
26804, 0.41666666666667, 1.58, 0.33333333333333
26805, 0.41666666666667, 1.62, 0.33333333333333
26806, 0.41666666666667, 1.66, 0.33333333333333
26807, 0.41666666666667, 1.54, 0.375
26808, 0.41666666666667, 1.58, 0.375
26809, 0.41666666666667, 1.62, 0.375
26810, 0.41666666666667, 1.66, 0.375
26811, 0.41666666666667, 1.54, 0.41666666666667
26812, 0.41666666666667, 1.58, 0.41666666666667
26813, 0.41666666666667, 1.62, 0.41666666666667
26814, 0.41666666666667, 1.66, 0.41666666666667
26815, 0.41666666666667, 1.54, 0.45833333333333
26816, 0.41666666666667, 1.58, 0.45833333333333
26817, 0.41666666666667, 1.62, 0.45833333333333
26818, 0.41666666666667, 1.66, 0.45833333333333
26819, 0.45833333333333, 1.54, 0.041666666666667
26820, 0.45833333333333, 1.58, 0.041666666666667
26821, 0.45833333333333, 1.62, 0.041666666666667
26822, 0.45833333333333, 1.66, 0.041666666666667
26823, 0.45833333333333, 1.54, 0.083333333333333
26824, 0.45833333333333, 1.58, 0.083333333333333
26825, 0.45833333333333, 1.62, 0.083333333333333
26826, 0.45833333333333, 1.66, 0.083333333333333
26827, 0.45833333333333, 1.54, 0.125
26828, 0.45833333333333, 1.58, 0.125
26829, 0.45833333333333, 1.62, 0.125
26830, 0.45833333333333, 1.66, 0.125
26831, 0.45833333333333, 1.54, 0.16666666666667
26832, 0.45833333333333, 1.58, 0.16666666666667
26833, 0.45833333333333, 1.62, 0.16666666666667
26834, 0.45833333333333, 1.66, 0.16666666666667
26835, 0.45833333333333, 1.54, 0.20833333333333
26836, 0.45833333333333, 1.58, 0.20833333333333
26837, 0.45833333333333, 1.62, 0.20833333333333
26838, 0.45833333333333, 1.66, 0.20833333333333
26839, 0.45833333333333, 1.54, 0.25
26840, 0.45833333333333, 1.58, 0.25
26841, 0.45833333333333, 1.62, 0.25
26842, 0.45833333333333, 1.66, 0.25
26843, 0.45833333333333, 1.54, 0.29166666666667
26844, 0.45833333333333, 1.58, 0.29166666666667
26845, 0.45833333333333, 1.62, 0.29166666666667
26846, 0.45833333333333, 1.66, 0.29166666666667
26847, 0.45833333333333, 1.54, 0.33333333333333
26848, 0.45833333333333, 1.58, 0.33333333333333
26849, 0.45833333333333, 1.62, 0.33333333333333
26850, 0.45833333333333, 1.66, 0.33333333333333
26851, 0.45833333333333, 1.54, 0.375
26852, 0.45833333333333, 1.58, 0.375
26853, 0.45833333333333, 1.62, 0.375
26854, 0.45833333333333, 1.66, 0.375
26855, 0.45833333333333, 1.54, 0.41666666666667
26856, 0.45833333333333, 1.58, 0.41666666666667
26857, 0.45833333333333, 1.62, 0.41666666666667
26858, 0.45833333333333, 1.66, 0.41666666666667
26859, 0.45833333333333, 1.54, 0.45833333333333
26860, 0.45833333333333, 1.58, 0.45833333333333
26861, 0.45833333333333, 1.62, 0.45833333333333
26862, 0.45833333333333, 1.66, 0.45833333333333
26863, 0.5, 1.54, 0.041666666666667
26864, 0.5, 1.58, 0.041666666666667
26865, 0.5, 1.62, 0.041666666666667
26866, 0.5, 1.66, 0.041666666666667
26867, 0.5, 1.54, 0.083333333333333
26868, 0.5, 1.58, 0.083333333333333
26869, 0.5, 1.62, 0.083333333333333
26870, 0.5, 1.66, 0.083333333333333
26871, 0.5, 1.54, 0.125
26872, 0.5, 1.58, 0.125
26873, 0.5, 1.62, 0.125
26874, 0.5, 1.66, 0.125
26875, 0.5, 1.54, 0.16666666666667
26876, 0.5, 1.58, 0.16666666666667
26877, 0.5, 1.62, 0.16666666666667
26878, 0.5, 1.66, 0.16666666666667
26879, 0.5, 1.54, 0.20833333333333
26880, 0.5, 1.58, 0.20833333333333
26881, 0.5, 1.62, 0.20833333333333
26882, 0.5, 1.66, 0.20833333333333
26883, 0.5, 1.54, 0.25
26884, 0.5, 1.58, 0.25
26885, 0.5, 1.62, 0.25
26886, 0.5, 1.66, 0.25
26887, 0.5, 1.54, 0.29166666666667
26888, 0.5, 1.58, 0.29166666666667
26889, 0.5, 1.62, 0.29166666666667
26890, 0.5, 1.66, 0.29166666666667
26891, 0.5, 1.54, 0.33333333333333
26892, 0.5, 1.58, 0.33333333333333
26893, 0.5, 1.62, 0.33333333333333
26894, 0.5, 1.66, 0.33333333333333
26895, 0.5, 1.54, 0.375
26896, 0.5, 1.58, 0.375
26897, 0.5, 1.62, 0.375
26898, 0.5, 1.66, 0.375
26899, 0.5, 1.54, 0.41666666666667
26900, 0.5, 1.58, 0.41666666666667
26901, 0.5, 1.62, 0.41666666666667
26902, 0.5, 1.66, 0.41666666666667
26903, 0.5, 1.54, 0.45833333333333
26904, 0.5, 1.58, 0.45833333333333
26905, 0.5, 1.62, 0.45833333333333
26906, 0.5, 1.66, 0.45833333333333
26907, 0.54166666666667, 1.54, 0.041666666666667
26908, 0.54166666666667, 1.58, 0.041666666666667
26909, 0.54166666666667, 1.62, 0.041666666666667
26910, 0.54166666666667, 1.66, 0.041666666666667
26911, 0.54166666666667, 1.54, 0.083333333333333
26912, 0.54166666666667, 1.58, 0.083333333333333
26913, 0.54166666666667, 1.62, 0.083333333333333
26914, 0.54166666666667, 1.66, 0.083333333333333
26915, 0.54166666666667, 1.54, 0.125
26916, 0.54166666666667, 1.58, 0.125
26917, 0.54166666666667, 1.62, 0.125
26918, 0.54166666666667, 1.66, 0.125
26919, 0.54166666666667, 1.54, 0.16666666666667
26920, 0.54166666666667, 1.58, 0.16666666666667
26921, 0.54166666666667, 1.62, 0.16666666666667
26922, 0.54166666666667, 1.66, 0.16666666666667
26923, 0.54166666666667, 1.54, 0.20833333333333
26924, 0.54166666666667, 1.58, 0.20833333333333
26925, 0.54166666666667, 1.62, 0.20833333333333
26926, 0.54166666666667, 1.66, 0.20833333333333
26927, 0.54166666666667, 1.54, 0.25
26928, 0.54166666666667, 1.58, 0.25
26929, 0.54166666666667, 1.62, 0.25
26930, 0.54166666666667, 1.66, 0.25
26931, 0.54166666666667, 1.54, 0.29166666666667
26932, 0.54166666666667, 1.58, 0.29166666666667
26933, 0.54166666666667, 1.62, 0.29166666666667
26934, 0.54166666666667, 1.66, 0.29166666666667
26935, 0.54166666666667, 1.54, 0.33333333333333
26936, 0.54166666666667, 1.58, 0.33333333333333
26937, 0.54166666666667, 1.62, 0.33333333333333
26938, 0.54166666666667, 1.66, 0.33333333333333
26939, 0.54166666666667, 1.54, 0.375
26940, 0.54166666666667, 1.58, 0.375
26941, 0.54166666666667, 1.62, 0.375
26942, 0.54166666666667, 1.66, 0.375
26943, 0.54166666666667, 1.54, 0.41666666666667
26944, 0.54166666666667, 1.58, 0.41666666666667
26945, 0.54166666666667, 1.62, 0.41666666666667
26946, 0.54166666666667, 1.66, 0.41666666666667
26947, 0.54166666666667, 1.54, 0.45833333333333
26948, 0.54166666666667, 1.58, 0.45833333333333
26949, 0.54166666666667, 1.62, 0.45833333333333
26950, 0.54166666666667, 1.66, 0.45833333333333
26951, 0.58333333333333, 1.54, 0.041666666666667
26952, 0.58333333333333, 1.58, 0.041666666666667
26953, 0.58333333333333, 1.62, 0.041666666666667
26954, 0.58333333333333, 1.66, 0.041666666666667
26955, 0.58333333333333, 1.54, 0.083333333333333
26956, 0.58333333333333, 1.58, 0.083333333333333
26957, 0.58333333333333, 1.62, 0.083333333333333
26958, 0.58333333333333, 1.66, 0.083333333333333
26959, 0.58333333333333, 1.54, 0.125
26960, 0.58333333333333, 1.58, 0.125
26961, 0.58333333333333, 1.62, 0.125
26962, 0.58333333333333, 1.66, 0.125
26963, 0.58333333333333, 1.54, 0.16666666666667
26964, 0.58333333333333, 1.58, 0.16666666666667
26965, 0.58333333333333, 1.62, 0.16666666666667
26966, 0.58333333333333, 1.66, 0.16666666666667
26967, 0.58333333333333, 1.54, 0.20833333333333
26968, 0.58333333333333, 1.58, 0.20833333333333
26969, 0.58333333333333, 1.62, 0.20833333333333
26970, 0.58333333333333, 1.66, 0.20833333333333
26971, 0.58333333333333, 1.54, 0.25
26972, 0.58333333333333, 1.58, 0.25
26973, 0.58333333333333, 1.62, 0.25
26974, 0.58333333333333, 1.66, 0.25
26975, 0.58333333333333, 1.54, 0.29166666666667
26976, 0.58333333333333, 1.58, 0.29166666666667
26977, 0.58333333333333, 1.62, 0.29166666666667
26978, 0.58333333333333, 1.66, 0.29166666666667
26979, 0.58333333333333, 1.54, 0.33333333333333
26980, 0.58333333333333, 1.58, 0.33333333333333
26981, 0.58333333333333, 1.62, 0.33333333333333
26982, 0.58333333333333, 1.66, 0.33333333333333
26983, 0.58333333333333, 1.54, 0.375
26984, 0.58333333333333, 1.58, 0.375
26985, 0.58333333333333, 1.62, 0.375
26986, 0.58333333333333, 1.66, 0.375
26987, 0.58333333333333, 1.54, 0.41666666666667
26988, 0.58333333333333, 1.58, 0.41666666666667
26989, 0.58333333333333, 1.62, 0.41666666666667
26990, 0.58333333333333, 1.66, 0.41666666666667
26991, 0.58333333333333, 1.54, 0.45833333333333
26992, 0.58333333333333, 1.58, 0.45833333333333
26993, 0.58333333333333, 1.62, 0.45833333333333
26994, 0.58333333333333, 1.66, 0.45833333333333
26995, 0.625, 1.54, 0.041666666666667
26996, 0.625, 1.58, 0.041666666666667
26997, 0.625, 1.62, 0.041666666666667
26998, 0.625, 1.66, 0.041666666666667
26999, 0.625, 1.54, 0.083333333333333
27000, 0.625, 1.58, 0.083333333333333
27001, 0.625, 1.62, 0.083333333333333
27002, 0.625, 1.66, 0.083333333333333
27003, 0.625, 1.54, 0.125
27004, 0.625, 1.58, 0.125
27005, 0.625, 1.62, 0.125
27006, 0.625, 1.66, 0.125
27007, 0.625, 1.54, 0.16666666666667
27008, 0.625, 1.58, 0.16666666666667
27009, 0.625, 1.62, 0.16666666666667
27010, 0.625, 1.66, 0.16666666666667
27011, 0.625, 1.54, 0.20833333333333
27012, 0.625, 1.58, 0.20833333333333
27013, 0.625, 1.62, 0.20833333333333
27014, 0.625, 1.66, 0.20833333333333
27015, 0.625, 1.54, 0.25
27016, 0.625, 1.58, 0.25
27017, 0.625, 1.62, 0.25
27018, 0.625, 1.66, 0.25
27019, 0.625, 1.54, 0.29166666666667
27020, 0.625, 1.58, 0.29166666666667
27021, 0.625, 1.62, 0.29166666666667
27022, 0.625, 1.66, 0.29166666666667
27023, 0.625, 1.54, 0.33333333333333
27024, 0.625, 1.58, 0.33333333333333
27025, 0.625, 1.62, 0.33333333333333
27026, 0.625, 1.66, 0.33333333333333
27027, 0.625, 1.54, 0.375
27028, 0.625, 1.58, 0.375
27029, 0.625, 1.62, 0.375
27030, 0.625, 1.66, 0.375
27031, 0.625, 1.54, 0.41666666666667
27032, 0.625, 1.58, 0.41666666666667
27033, 0.625, 1.62, 0.41666666666667
27034, 0.625, 1.66, 0.41666666666667
27035, 0.625, 1.54, 0.45833333333333
27036, 0.625, 1.58, 0.45833333333333
27037, 0.625, 1.62, 0.45833333333333
27038, 0.625, 1.66, 0.45833333333333
27039, 0.66666666666667, 1.54, 0.041666666666667
27040, 0.66666666666667, 1.58, 0.041666666666667
27041, 0.66666666666667, 1.62, 0.041666666666667
27042, 0.66666666666667, 1.66, 0.041666666666667
27043, 0.66666666666667, 1.54, 0.083333333333333
27044, 0.66666666666667, 1.58, 0.083333333333333
27045, 0.66666666666667, 1.62, 0.083333333333333
27046, 0.66666666666667, 1.66, 0.083333333333333
27047, 0.66666666666667, 1.54, 0.125
27048, 0.66666666666667, 1.58, 0.125
27049, 0.66666666666667, 1.62, 0.125
27050, 0.66666666666667, 1.66, 0.125
27051, 0.66666666666667, 1.54, 0.16666666666667
27052, 0.66666666666667, 1.58, 0.16666666666667
27053, 0.66666666666667, 1.62, 0.16666666666667
27054, 0.66666666666667, 1.66, 0.16666666666667
27055, 0.66666666666667, 1.54, 0.20833333333333
27056, 0.66666666666667, 1.58, 0.20833333333333
27057, 0.66666666666667, 1.62, 0.20833333333333
27058, 0.66666666666667, 1.66, 0.20833333333333
27059, 0.66666666666667, 1.54, 0.25
27060, 0.66666666666667, 1.58, 0.25
27061, 0.66666666666667, 1.62, 0.25
27062, 0.66666666666667, 1.66, 0.25
27063, 0.66666666666667, 1.54, 0.29166666666667
27064, 0.66666666666667, 1.58, 0.29166666666667
27065, 0.66666666666667, 1.62, 0.29166666666667
27066, 0.66666666666667, 1.66, 0.29166666666667
27067, 0.66666666666667, 1.54, 0.33333333333333
27068, 0.66666666666667, 1.58, 0.33333333333333
27069, 0.66666666666667, 1.62, 0.33333333333333
27070, 0.66666666666667, 1.66, 0.33333333333333
27071, 0.66666666666667, 1.54, 0.375
27072, 0.66666666666667, 1.58, 0.375
27073, 0.66666666666667, 1.62, 0.375
27074, 0.66666666666667, 1.66, 0.375
27075, 0.66666666666667, 1.54, 0.41666666666667
27076, 0.66666666666667, 1.58, 0.41666666666667
27077, 0.66666666666667, 1.62, 0.41666666666667
27078, 0.66666666666667, 1.66, 0.41666666666667
27079, 0.66666666666667, 1.54, 0.45833333333333
27080, 0.66666666666667, 1.58, 0.45833333333333
27081, 0.66666666666667, 1.62, 0.45833333333333
27082, 0.66666666666667, 1.66, 0.45833333333333
27083, 0.70833333333333, 1.54, 0.041666666666667
27084, 0.70833333333333, 1.58, 0.041666666666667
27085, 0.70833333333333, 1.62, 0.041666666666667
27086, 0.70833333333333, 1.66, 0.041666666666667
27087, 0.70833333333333, 1.54, 0.083333333333333
27088, 0.70833333333333, 1.58, 0.083333333333333
27089, 0.70833333333333, 1.62, 0.083333333333333
27090, 0.70833333333333, 1.66, 0.083333333333333
27091, 0.70833333333333, 1.54, 0.125
27092, 0.70833333333333, 1.58, 0.125
27093, 0.70833333333333, 1.62, 0.125
27094, 0.70833333333333, 1.66, 0.125
27095, 0.70833333333333, 1.54, 0.16666666666667
27096, 0.70833333333333, 1.58, 0.16666666666667
27097, 0.70833333333333, 1.62, 0.16666666666667
27098, 0.70833333333333, 1.66, 0.16666666666667
27099, 0.70833333333333, 1.54, 0.20833333333333
27100, 0.70833333333333, 1.58, 0.20833333333333
27101, 0.70833333333333, 1.62, 0.20833333333333
27102, 0.70833333333333, 1.66, 0.20833333333333
27103, 0.70833333333333, 1.54, 0.25
27104, 0.70833333333333, 1.58, 0.25
27105, 0.70833333333333, 1.62, 0.25
27106, 0.70833333333333, 1.66, 0.25
27107, 0.70833333333333, 1.54, 0.29166666666667
27108, 0.70833333333333, 1.58, 0.29166666666667
27109, 0.70833333333333, 1.62, 0.29166666666667
27110, 0.70833333333333, 1.66, 0.29166666666667
27111, 0.70833333333333, 1.54, 0.33333333333333
27112, 0.70833333333333, 1.58, 0.33333333333333
27113, 0.70833333333333, 1.62, 0.33333333333333
27114, 0.70833333333333, 1.66, 0.33333333333333
27115, 0.70833333333333, 1.54, 0.375
27116, 0.70833333333333, 1.58, 0.375
27117, 0.70833333333333, 1.62, 0.375
27118, 0.70833333333333, 1.66, 0.375
27119, 0.70833333333333, 1.54, 0.41666666666667
27120, 0.70833333333333, 1.58, 0.41666666666667
27121, 0.70833333333333, 1.62, 0.41666666666667
27122, 0.70833333333333, 1.66, 0.41666666666667
27123, 0.70833333333333, 1.54, 0.45833333333333
27124, 0.70833333333333, 1.58, 0.45833333333333
27125, 0.70833333333333, 1.62, 0.45833333333333
27126, 0.70833333333333, 1.66, 0.45833333333333
27127, 0.75, 1.54, 0.041666666666667
27128, 0.75, 1.58, 0.041666666666667
27129, 0.75, 1.62, 0.041666666666667
27130, 0.75, 1.66, 0.041666666666667
27131, 0.75, 1.54, 0.083333333333333
27132, 0.75, 1.58, 0.083333333333333
27133, 0.75, 1.62, 0.083333333333333
27134, 0.75, 1.66, 0.083333333333333
27135, 0.75, 1.54, 0.125
27136, 0.75, 1.58, 0.125
27137, 0.75, 1.62, 0.125
27138, 0.75, 1.66, 0.125
27139, 0.75, 1.54, 0.16666666666667
27140, 0.75, 1.58, 0.16666666666667
27141, 0.75, 1.62, 0.16666666666667
27142, 0.75, 1.66, 0.16666666666667
27143, 0.75, 1.54, 0.20833333333333
27144, 0.75, 1.58, 0.20833333333333
27145, 0.75, 1.62, 0.20833333333333
27146, 0.75, 1.66, 0.20833333333333
27147, 0.75, 1.54, 0.25
27148, 0.75, 1.58, 0.25
27149, 0.75, 1.62, 0.25
27150, 0.75, 1.66, 0.25
27151, 0.75, 1.54, 0.29166666666667
27152, 0.75, 1.58, 0.29166666666667
27153, 0.75, 1.62, 0.29166666666667
27154, 0.75, 1.66, 0.29166666666667
27155, 0.75, 1.54, 0.33333333333333
27156, 0.75, 1.58, 0.33333333333333
27157, 0.75, 1.62, 0.33333333333333
27158, 0.75, 1.66, 0.33333333333333
27159, 0.75, 1.54, 0.375
27160, 0.75, 1.58, 0.375
27161, 0.75, 1.62, 0.375
27162, 0.75, 1.66, 0.375
27163, 0.75, 1.54, 0.41666666666667
27164, 0.75, 1.58, 0.41666666666667
27165, 0.75, 1.62, 0.41666666666667
27166, 0.75, 1.66, 0.41666666666667
27167, 0.75, 1.54, 0.45833333333333
27168, 0.75, 1.58, 0.45833333333333
27169, 0.75, 1.62, 0.45833333333333
27170, 0.75, 1.66, 0.45833333333333
27171, 0.79166666666667, 1.54, 0.041666666666667
27172, 0.79166666666667, 1.58, 0.041666666666667
27173, 0.79166666666667, 1.62, 0.041666666666667
27174, 0.79166666666667, 1.66, 0.041666666666667
27175, 0.79166666666667, 1.54, 0.083333333333333
27176, 0.79166666666667, 1.58, 0.083333333333333
27177, 0.79166666666667, 1.62, 0.083333333333333
27178, 0.79166666666667, 1.66, 0.083333333333333
27179, 0.79166666666667, 1.54, 0.125
27180, 0.79166666666667, 1.58, 0.125
27181, 0.79166666666667, 1.62, 0.125
27182, 0.79166666666667, 1.66, 0.125
27183, 0.79166666666667, 1.54, 0.16666666666667
27184, 0.79166666666667, 1.58, 0.16666666666667
27185, 0.79166666666667, 1.62, 0.16666666666667
27186, 0.79166666666667, 1.66, 0.16666666666667
27187, 0.79166666666667, 1.54, 0.20833333333333
27188, 0.79166666666667, 1.58, 0.20833333333333
27189, 0.79166666666667, 1.62, 0.20833333333333
27190, 0.79166666666667, 1.66, 0.20833333333333
27191, 0.79166666666667, 1.54, 0.25
27192, 0.79166666666667, 1.58, 0.25
27193, 0.79166666666667, 1.62, 0.25
27194, 0.79166666666667, 1.66, 0.25
27195, 0.79166666666667, 1.54, 0.29166666666667
27196, 0.79166666666667, 1.58, 0.29166666666667
27197, 0.79166666666667, 1.62, 0.29166666666667
27198, 0.79166666666667, 1.66, 0.29166666666667
27199, 0.79166666666667, 1.54, 0.33333333333333
27200, 0.79166666666667, 1.58, 0.33333333333333
27201, 0.79166666666667, 1.62, 0.33333333333333
27202, 0.79166666666667, 1.66, 0.33333333333333
27203, 0.79166666666667, 1.54, 0.375
27204, 0.79166666666667, 1.58, 0.375
27205, 0.79166666666667, 1.62, 0.375
27206, 0.79166666666667, 1.66, 0.375
27207, 0.79166666666667, 1.54, 0.41666666666667
27208, 0.79166666666667, 1.58, 0.41666666666667
27209, 0.79166666666667, 1.62, 0.41666666666667
27210, 0.79166666666667, 1.66, 0.41666666666667
27211, 0.79166666666667, 1.54, 0.45833333333333
27212, 0.79166666666667, 1.58, 0.45833333333333
27213, 0.79166666666667, 1.62, 0.45833333333333
27214, 0.79166666666667, 1.66, 0.45833333333333
27215, 0.83333333333333, 1.54, 0.041666666666667
27216, 0.83333333333333, 1.58, 0.041666666666667
27217, 0.83333333333333, 1.62, 0.041666666666667
27218, 0.83333333333333, 1.66, 0.041666666666667
27219, 0.83333333333333, 1.54, 0.083333333333333
27220, 0.83333333333333, 1.58, 0.083333333333333
27221, 0.83333333333333, 1.62, 0.083333333333333
27222, 0.83333333333333, 1.66, 0.083333333333333
27223, 0.83333333333333, 1.54, 0.125
27224, 0.83333333333333, 1.58, 0.125
27225, 0.83333333333333, 1.62, 0.125
27226, 0.83333333333333, 1.66, 0.125
27227, 0.83333333333333, 1.54, 0.16666666666667
27228, 0.83333333333333, 1.58, 0.16666666666667
27229, 0.83333333333333, 1.62, 0.16666666666667
27230, 0.83333333333333, 1.66, 0.16666666666667
27231, 0.83333333333333, 1.54, 0.20833333333333
27232, 0.83333333333333, 1.58, 0.20833333333333
27233, 0.83333333333333, 1.62, 0.20833333333333
27234, 0.83333333333333, 1.66, 0.20833333333333
27235, 0.83333333333333, 1.54, 0.25
27236, 0.83333333333333, 1.58, 0.25
27237, 0.83333333333333, 1.62, 0.25
27238, 0.83333333333333, 1.66, 0.25
27239, 0.83333333333333, 1.54, 0.29166666666667
27240, 0.83333333333333, 1.58, 0.29166666666667
27241, 0.83333333333333, 1.62, 0.29166666666667
27242, 0.83333333333333, 1.66, 0.29166666666667
27243, 0.83333333333333, 1.54, 0.33333333333333
27244, 0.83333333333333, 1.58, 0.33333333333333
27245, 0.83333333333333, 1.62, 0.33333333333333
27246, 0.83333333333333, 1.66, 0.33333333333333
27247, 0.83333333333333, 1.54, 0.375
27248, 0.83333333333333, 1.58, 0.375
27249, 0.83333333333333, 1.62, 0.375
27250, 0.83333333333333, 1.66, 0.375
27251, 0.83333333333333, 1.54, 0.41666666666667
27252, 0.83333333333333, 1.58, 0.41666666666667
27253, 0.83333333333333, 1.62, 0.41666666666667
27254, 0.83333333333333, 1.66, 0.41666666666667
27255, 0.83333333333333, 1.54, 0.45833333333333
27256, 0.83333333333333, 1.58, 0.45833333333333
27257, 0.83333333333333, 1.62, 0.45833333333333
27258, 0.83333333333333, 1.66, 0.45833333333333
27259, 0.875, 1.54, 0.041666666666667
27260, 0.875, 1.58, 0.041666666666667
27261, 0.875, 1.62, 0.041666666666667
27262, 0.875, 1.66, 0.041666666666667
27263, 0.875, 1.54, 0.083333333333333
27264, 0.875, 1.58, 0.083333333333333
27265, 0.875, 1.62, 0.083333333333333
27266, 0.875, 1.66, 0.083333333333333
27267, 0.875, 1.54, 0.125
27268, 0.875, 1.58, 0.125
27269, 0.875, 1.62, 0.125
27270, 0.875, 1.66, 0.125
27271, 0.875, 1.54, 0.16666666666667
27272, 0.875, 1.58, 0.16666666666667
27273, 0.875, 1.62, 0.16666666666667
27274, 0.875, 1.66, 0.16666666666667
27275, 0.875, 1.54, 0.20833333333333
27276, 0.875, 1.58, 0.20833333333333
27277, 0.875, 1.62, 0.20833333333333
27278, 0.875, 1.66, 0.20833333333333
27279, 0.875, 1.54, 0.25
27280, 0.875, 1.58, 0.25
27281, 0.875, 1.62, 0.25
27282, 0.875, 1.66, 0.25
27283, 0.875, 1.54, 0.29166666666667
27284, 0.875, 1.58, 0.29166666666667
27285, 0.875, 1.62, 0.29166666666667
27286, 0.875, 1.66, 0.29166666666667
27287, 0.875, 1.54, 0.33333333333333
27288, 0.875, 1.58, 0.33333333333333
27289, 0.875, 1.62, 0.33333333333333
27290, 0.875, 1.66, 0.33333333333333
27291, 0.875, 1.54, 0.375
27292, 0.875, 1.58, 0.375
27293, 0.875, 1.62, 0.375
27294, 0.875, 1.66, 0.375
27295, 0.875, 1.54, 0.41666666666667
27296, 0.875, 1.58, 0.41666666666667
27297, 0.875, 1.62, 0.41666666666667
27298, 0.875, 1.66, 0.41666666666667
27299, 0.875, 1.54, 0.45833333333333
27300, 0.875, 1.58, 0.45833333333333
27301, 0.875, 1.62, 0.45833333333333
27302, 0.875, 1.66, 0.45833333333333
27303, 0.91666666666667, 1.54, 0.041666666666667
27304, 0.91666666666667, 1.58, 0.041666666666667
27305, 0.91666666666667, 1.62, 0.041666666666667
27306, 0.91666666666667, 1.66, 0.041666666666667
27307, 0.91666666666667, 1.54, 0.083333333333333
27308, 0.91666666666667, 1.58, 0.083333333333333
27309, 0.91666666666667, 1.62, 0.083333333333333
27310, 0.91666666666667, 1.66, 0.083333333333333
27311, 0.91666666666667, 1.54, 0.125
27312, 0.91666666666667, 1.58, 0.125
27313, 0.91666666666667, 1.62, 0.125
27314, 0.91666666666667, 1.66, 0.125
27315, 0.91666666666667, 1.54, 0.16666666666667
27316, 0.91666666666667, 1.58, 0.16666666666667
27317, 0.91666666666667, 1.62, 0.16666666666667
27318, 0.91666666666667, 1.66, 0.16666666666667
27319, 0.91666666666667, 1.54, 0.20833333333333
27320, 0.91666666666667, 1.58, 0.20833333333333
27321, 0.91666666666667, 1.62, 0.20833333333333
27322, 0.91666666666667, 1.66, 0.20833333333333
27323, 0.91666666666667, 1.54, 0.25
27324, 0.91666666666667, 1.58, 0.25
27325, 0.91666666666667, 1.62, 0.25
27326, 0.91666666666667, 1.66, 0.25
27327, 0.91666666666667, 1.54, 0.29166666666667
27328, 0.91666666666667, 1.58, 0.29166666666667
27329, 0.91666666666667, 1.62, 0.29166666666667
27330, 0.91666666666667, 1.66, 0.29166666666667
27331, 0.91666666666667, 1.54, 0.33333333333333
27332, 0.91666666666667, 1.58, 0.33333333333333
27333, 0.91666666666667, 1.62, 0.33333333333333
27334, 0.91666666666667, 1.66, 0.33333333333333
27335, 0.91666666666667, 1.54, 0.375
27336, 0.91666666666667, 1.58, 0.375
27337, 0.91666666666667, 1.62, 0.375
27338, 0.91666666666667, 1.66, 0.375
27339, 0.91666666666667, 1.54, 0.41666666666667
27340, 0.91666666666667, 1.58, 0.41666666666667
27341, 0.91666666666667, 1.62, 0.41666666666667
27342, 0.91666666666667, 1.66, 0.41666666666667
27343, 0.91666666666667, 1.54, 0.45833333333333
27344, 0.91666666666667, 1.58, 0.45833333333333
27345, 0.91666666666667, 1.62, 0.45833333333333
27346, 0.91666666666667, 1.66, 0.45833333333333
27347, 0.95833333333333, 1.54, 0.041666666666667
27348, 0.95833333333333, 1.58, 0.041666666666667
27349, 0.95833333333333, 1.62, 0.041666666666667
27350, 0.95833333333333, 1.66, 0.041666666666667
27351, 0.95833333333333, 1.54, 0.083333333333333
27352, 0.95833333333333, 1.58, 0.083333333333333
27353, 0.95833333333333, 1.62, 0.083333333333333
27354, 0.95833333333333, 1.66, 0.083333333333333
27355, 0.95833333333333, 1.54, 0.125
27356, 0.95833333333333, 1.58, 0.125
27357, 0.95833333333333, 1.62, 0.125
27358, 0.95833333333333, 1.66, 0.125
27359, 0.95833333333333, 1.54, 0.16666666666667
27360, 0.95833333333333, 1.58, 0.16666666666667
27361, 0.95833333333333, 1.62, 0.16666666666667
27362, 0.95833333333333, 1.66, 0.16666666666667
27363, 0.95833333333333, 1.54, 0.20833333333333
27364, 0.95833333333333, 1.58, 0.20833333333333
27365, 0.95833333333333, 1.62, 0.20833333333333
27366, 0.95833333333333, 1.66, 0.20833333333333
27367, 0.95833333333333, 1.54, 0.25
27368, 0.95833333333333, 1.58, 0.25
27369, 0.95833333333333, 1.62, 0.25
27370, 0.95833333333333, 1.66, 0.25
27371, 0.95833333333333, 1.54, 0.29166666666667
27372, 0.95833333333333, 1.58, 0.29166666666667
27373, 0.95833333333333, 1.62, 0.29166666666667
27374, 0.95833333333333, 1.66, 0.29166666666667
27375, 0.95833333333333, 1.54, 0.33333333333333
27376, 0.95833333333333, 1.58, 0.33333333333333
27377, 0.95833333333333, 1.62, 0.33333333333333
27378, 0.95833333333333, 1.66, 0.33333333333333
27379, 0.95833333333333, 1.54, 0.375
27380, 0.95833333333333, 1.58, 0.375
27381, 0.95833333333333, 1.62, 0.375
27382, 0.95833333333333, 1.66, 0.375
27383, 0.95833333333333, 1.54, 0.41666666666667
27384, 0.95833333333333, 1.58, 0.41666666666667
27385, 0.95833333333333, 1.62, 0.41666666666667
27386, 0.95833333333333, 1.66, 0.41666666666667
27387, 0.95833333333333, 1.54, 0.45833333333333
27388, 0.95833333333333, 1.58, 0.45833333333333
27389, 0.95833333333333, 1.62, 0.45833333333333
27390, 0.95833333333333, 1.66, 0.45833333333333
27391, 1.04, 1.54, 0.041666666666667
27392, 1.04, 1.58, 0.041666666666667
27393, 1.04, 1.62, 0.041666666666667
27394, 1.04, 1.66, 0.041666666666667
27395, 1.08, 1.54, 0.041666666666667
27396, 1.08, 1.58, 0.041666666666667
27397, 1.08, 1.62, 0.041666666666667
27398, 1.08, 1.66, 0.041666666666667
27399, 1.12, 1.54, 0.041666666666667
27400, 1.12, 1.58, 0.041666666666667
27401, 1.12, 1.62, 0.041666666666667
27402, 1.12, 1.66, 0.041666666666667
27403, 1.16, 1.54, 0.041666666666667
27404, 1.16, 1.58, 0.041666666666667
27405, 1.16, 1.62, 0.041666666666667
27406, 1.16, 1.66, 0.041666666666667
27407, 1.04, 1.54, 0.083333333333333
27408, 1.04, 1.58, 0.083333333333333
27409, 1.04, 1.62, 0.083333333333333
27410, 1.04, 1.66, 0.083333333333333
27411, 1.08, 1.54, 0.083333333333333
27412, 1.08, 1.58, 0.083333333333333
27413, 1.08, 1.62, 0.083333333333333
27414, 1.08, 1.66, 0.083333333333333
27415, 1.12, 1.54, 0.083333333333333
27416, 1.12, 1.58, 0.083333333333333
27417, 1.12, 1.62, 0.083333333333333
27418, 1.12, 1.66, 0.083333333333333
27419, 1.16, 1.54, 0.083333333333333
27420, 1.16, 1.58, 0.083333333333333
27421, 1.16, 1.62, 0.083333333333333
27422, 1.16, 1.66, 0.083333333333333
27423, 1.04, 1.54, 0.125
27424, 1.04, 1.58, 0.125
27425, 1.04, 1.62, 0.125
27426, 1.04, 1.66, 0.125
27427, 1.08, 1.54, 0.125
27428, 1.08, 1.58, 0.125
27429, 1.08, 1.62, 0.125
27430, 1.08, 1.66, 0.125
27431, 1.12, 1.54, 0.125
27432, 1.12, 1.58, 0.125
27433, 1.12, 1.62, 0.125
27434, 1.12, 1.66, 0.125
27435, 1.16, 1.54, 0.125
27436, 1.16, 1.58, 0.125
27437, 1.16, 1.62, 0.125
27438, 1.16, 1.66, 0.125
27439, 1.04, 1.54, 0.16666666666667
27440, 1.04, 1.58, 0.16666666666667
27441, 1.04, 1.62, 0.16666666666667
27442, 1.04, 1.66, 0.16666666666667
27443, 1.08, 1.54, 0.16666666666667
27444, 1.08, 1.58, 0.16666666666667
27445, 1.08, 1.62, 0.16666666666667
27446, 1.08, 1.66, 0.16666666666667
27447, 1.12, 1.54, 0.16666666666667
27448, 1.12, 1.58, 0.16666666666667
27449, 1.12, 1.62, 0.16666666666667
27450, 1.12, 1.66, 0.16666666666667
27451, 1.16, 1.54, 0.16666666666667
27452, 1.16, 1.58, 0.16666666666667
27453, 1.16, 1.62, 0.16666666666667
27454, 1.16, 1.66, 0.16666666666667
27455, 1.04, 1.54, 0.20833333333333
27456, 1.04, 1.58, 0.20833333333333
27457, 1.04, 1.62, 0.20833333333333
27458, 1.04, 1.66, 0.20833333333333
27459, 1.08, 1.54, 0.20833333333333
27460, 1.08, 1.58, 0.20833333333333
27461, 1.08, 1.62, 0.20833333333333
27462, 1.08, 1.66, 0.20833333333333
27463, 1.12, 1.54, 0.20833333333333
27464, 1.12, 1.58, 0.20833333333333
27465, 1.12, 1.62, 0.20833333333333
27466, 1.12, 1.66, 0.20833333333333
27467, 1.16, 1.54, 0.20833333333333
27468, 1.16, 1.58, 0.20833333333333
27469, 1.16, 1.62, 0.20833333333333
27470, 1.16, 1.66, 0.20833333333333
27471, 1.04, 1.54, 0.25
27472, 1.04, 1.58, 0.25
27473, 1.04, 1.62, 0.25
27474, 1.04, 1.66, 0.25
27475, 1.08, 1.54, 0.25
27476, 1.08, 1.58, 0.25
27477, 1.08, 1.62, 0.25
27478, 1.08, 1.66, 0.25
27479, 1.12, 1.54, 0.25
27480, 1.12, 1.58, 0.25
27481, 1.12, 1.62, 0.25
27482, 1.12, 1.66, 0.25
27483, 1.16, 1.54, 0.25
27484, 1.16, 1.58, 0.25
27485, 1.16, 1.62, 0.25
27486, 1.16, 1.66, 0.25
27487, 1.04, 1.54, 0.29166666666667
27488, 1.04, 1.58, 0.29166666666667
27489, 1.04, 1.62, 0.29166666666667
27490, 1.04, 1.66, 0.29166666666667
27491, 1.08, 1.54, 0.29166666666667
27492, 1.08, 1.58, 0.29166666666667
27493, 1.08, 1.62, 0.29166666666667
27494, 1.08, 1.66, 0.29166666666667
27495, 1.12, 1.54, 0.29166666666667
27496, 1.12, 1.58, 0.29166666666667
27497, 1.12, 1.62, 0.29166666666667
27498, 1.12, 1.66, 0.29166666666667
27499, 1.16, 1.54, 0.29166666666667
27500, 1.16, 1.58, 0.29166666666667
27501, 1.16, 1.62, 0.29166666666667
27502, 1.16, 1.66, 0.29166666666667
27503, 1.04, 1.54, 0.33333333333333
27504, 1.04, 1.58, 0.33333333333333
27505, 1.04, 1.62, 0.33333333333333
27506, 1.04, 1.66, 0.33333333333333
27507, 1.08, 1.54, 0.33333333333333
27508, 1.08, 1.58, 0.33333333333333
27509, 1.08, 1.62, 0.33333333333333
27510, 1.08, 1.66, 0.33333333333333
27511, 1.12, 1.54, 0.33333333333333
27512, 1.12, 1.58, 0.33333333333333
27513, 1.12, 1.62, 0.33333333333333
27514, 1.12, 1.66, 0.33333333333333
27515, 1.16, 1.54, 0.33333333333333
27516, 1.16, 1.58, 0.33333333333333
27517, 1.16, 1.62, 0.33333333333333
27518, 1.16, 1.66, 0.33333333333333
27519, 1.04, 1.54, 0.375
27520, 1.04, 1.58, 0.375
27521, 1.04, 1.62, 0.375
27522, 1.04, 1.66, 0.375
27523, 1.08, 1.54, 0.375
27524, 1.08, 1.58, 0.375
27525, 1.08, 1.62, 0.375
27526, 1.08, 1.66, 0.375
27527, 1.12, 1.54, 0.375
27528, 1.12, 1.58, 0.375
27529, 1.12, 1.62, 0.375
27530, 1.12, 1.66, 0.375
27531, 1.16, 1.54, 0.375
27532, 1.16, 1.58, 0.375
27533, 1.16, 1.62, 0.375
27534, 1.16, 1.66, 0.375
27535, 1.04, 1.54, 0.41666666666667
27536, 1.04, 1.58, 0.41666666666667
27537, 1.04, 1.62, 0.41666666666667
27538, 1.04, 1.66, 0.41666666666667
27539, 1.08, 1.54, 0.41666666666667
27540, 1.08, 1.58, 0.41666666666667
27541, 1.08, 1.62, 0.41666666666667
27542, 1.08, 1.66, 0.41666666666667
27543, 1.12, 1.54, 0.41666666666667
27544, 1.12, 1.58, 0.41666666666667
27545, 1.12, 1.62, 0.41666666666667
27546, 1.12, 1.66, 0.41666666666667
27547, 1.16, 1.54, 0.41666666666667
27548, 1.16, 1.58, 0.41666666666667
27549, 1.16, 1.62, 0.41666666666667
27550, 1.16, 1.66, 0.41666666666667
27551, 1.04, 1.54, 0.45833333333333
27552, 1.04, 1.58, 0.45833333333333
27553, 1.04, 1.62, 0.45833333333333
27554, 1.04, 1.66, 0.45833333333333
27555, 1.08, 1.54, 0.45833333333333
27556, 1.08, 1.58, 0.45833333333333
27557, 1.08, 1.62, 0.45833333333333
27558, 1.08, 1.66, 0.45833333333333
27559, 1.12, 1.54, 0.45833333333333
27560, 1.12, 1.58, 0.45833333333333
27561, 1.12, 1.62, 0.45833333333333
27562, 1.12, 1.66, 0.45833333333333
27563, 1.16, 1.54, 0.45833333333333
27564, 1.16, 1.58, 0.45833333333333
27565, 1.16, 1.62, 0.45833333333333
27566, 1.16, 1.66, 0.45833333333333
27567, 1.2416666666667, 1.54, 0.041666666666667
27568, 1.2416666666667, 1.58, 0.041666666666667
27569, 1.2416666666667, 1.62, 0.041666666666667
27570, 1.2416666666667, 1.66, 0.041666666666667
27571, 1.2833333333333, 1.54, 0.041666666666667
27572, 1.2833333333333, 1.58, 0.041666666666667
27573, 1.2833333333333, 1.62, 0.041666666666667
27574, 1.2833333333333, 1.66, 0.041666666666667
27575, 1.325, 1.54, 0.041666666666667
27576, 1.325, 1.58, 0.041666666666667
27577, 1.325, 1.62, 0.041666666666667
27578, 1.325, 1.66, 0.041666666666667
27579, 1.3666666666667, 1.54, 0.041666666666667
27580, 1.3666666666667, 1.58, 0.041666666666667
27581, 1.3666666666667, 1.62, 0.041666666666667
27582, 1.3666666666667, 1.66, 0.041666666666667
27583, 1.4083333333333, 1.54, 0.041666666666667
27584, 1.4083333333333, 1.58, 0.041666666666667
27585, 1.4083333333333, 1.62, 0.041666666666667
27586, 1.4083333333333, 1.66, 0.041666666666667
27587, 1.45, 1.54, 0.041666666666667
27588, 1.45, 1.58, 0.041666666666667
27589, 1.45, 1.62, 0.041666666666667
27590, 1.45, 1.66, 0.041666666666667
27591, 1.4916666666667, 1.54, 0.041666666666667
27592, 1.4916666666667, 1.58, 0.041666666666667
27593, 1.4916666666667, 1.62, 0.041666666666667
27594, 1.4916666666667, 1.66, 0.041666666666667
27595, 1.5333333333333, 1.54, 0.041666666666667
27596, 1.5333333333333, 1.58, 0.041666666666667
27597, 1.5333333333333, 1.62, 0.041666666666667
27598, 1.5333333333333, 1.66, 0.041666666666667
27599, 1.575, 1.54, 0.041666666666667
27600, 1.575, 1.58, 0.041666666666667
27601, 1.575, 1.62, 0.041666666666667
27602, 1.575, 1.66, 0.041666666666667
27603, 1.6166666666667, 1.54, 0.041666666666667
27604, 1.6166666666667, 1.58, 0.041666666666667
27605, 1.6166666666667, 1.62, 0.041666666666667
27606, 1.6166666666667, 1.66, 0.041666666666667
27607, 1.6583333333333, 1.54, 0.041666666666667
27608, 1.6583333333333, 1.58, 0.041666666666667
27609, 1.6583333333333, 1.62, 0.041666666666667
27610, 1.6583333333333, 1.66, 0.041666666666667
27611, 1.7, 1.54, 0.041666666666667
27612, 1.7, 1.58, 0.041666666666667
27613, 1.7, 1.62, 0.041666666666667
27614, 1.7, 1.66, 0.041666666666667
27615, 1.7416666666667, 1.54, 0.041666666666667
27616, 1.7416666666667, 1.58, 0.041666666666667
27617, 1.7416666666667, 1.62, 0.041666666666667
27618, 1.7416666666667, 1.66, 0.041666666666667
27619, 1.7833333333333, 1.54, 0.041666666666667
27620, 1.7833333333333, 1.58, 0.041666666666667
27621, 1.7833333333333, 1.62, 0.041666666666667
27622, 1.7833333333333, 1.66, 0.041666666666667
27623, 1.825, 1.54, 0.041666666666667
27624, 1.825, 1.58, 0.041666666666667
27625, 1.825, 1.62, 0.041666666666667
27626, 1.825, 1.66, 0.041666666666667
27627, 1.8666666666667, 1.54, 0.041666666666667
27628, 1.8666666666667, 1.58, 0.041666666666667
27629, 1.8666666666667, 1.62, 0.041666666666667
27630, 1.8666666666667, 1.66, 0.041666666666667
27631, 1.9083333333333, 1.54, 0.041666666666667
27632, 1.9083333333333, 1.58, 0.041666666666667
27633, 1.9083333333333, 1.62, 0.041666666666667
27634, 1.9083333333333, 1.66, 0.041666666666667
27635, 1.95, 1.54, 0.041666666666667
27636, 1.95, 1.58, 0.041666666666667
27637, 1.95, 1.62, 0.041666666666667
27638, 1.95, 1.66, 0.041666666666667
27639, 1.9916666666667, 1.54, 0.041666666666667
27640, 1.9916666666667, 1.58, 0.041666666666667
27641, 1.9916666666667, 1.62, 0.041666666666667
27642, 1.9916666666667, 1.66, 0.041666666666667
27643, 2.0333333333333, 1.54, 0.041666666666667
27644, 2.0333333333333, 1.58, 0.041666666666667
27645, 2.0333333333333, 1.62, 0.041666666666667
27646, 2.0333333333333, 1.66, 0.041666666666667
27647, 2.075, 1.54, 0.041666666666667
27648, 2.075, 1.58, 0.041666666666667
27649, 2.075, 1.62, 0.041666666666667
27650, 2.075, 1.66, 0.041666666666667
27651, 2.1166666666667, 1.54, 0.041666666666667
27652, 2.1166666666667, 1.58, 0.041666666666667
27653, 2.1166666666667, 1.62, 0.041666666666667
27654, 2.1166666666667, 1.66, 0.041666666666667
27655, 2.1583333333333, 1.54, 0.041666666666667
27656, 2.1583333333333, 1.58, 0.041666666666667
27657, 2.1583333333333, 1.62, 0.041666666666667
27658, 2.1583333333333, 1.66, 0.041666666666667
27659, 1.2416666666667, 1.54, 0.083333333333333
27660, 1.2416666666667, 1.58, 0.083333333333333
27661, 1.2416666666667, 1.62, 0.083333333333333
27662, 1.2416666666667, 1.66, 0.083333333333333
27663, 1.2833333333333, 1.54, 0.083333333333333
27664, 1.2833333333333, 1.58, 0.083333333333333
27665, 1.2833333333333, 1.62, 0.083333333333333
27666, 1.2833333333333, 1.66, 0.083333333333333
27667, 1.325, 1.54, 0.083333333333333
27668, 1.325, 1.58, 0.083333333333333
27669, 1.325, 1.62, 0.083333333333333
27670, 1.325, 1.66, 0.083333333333333
27671, 1.3666666666667, 1.54, 0.083333333333333
27672, 1.3666666666667, 1.58, 0.083333333333333
27673, 1.3666666666667, 1.62, 0.083333333333333
27674, 1.3666666666667, 1.66, 0.083333333333333
27675, 1.4083333333333, 1.54, 0.083333333333333
27676, 1.4083333333333, 1.58, 0.083333333333333
27677, 1.4083333333333, 1.62, 0.083333333333333
27678, 1.4083333333333, 1.66, 0.083333333333333
27679, 1.45, 1.54, 0.083333333333333
27680, 1.45, 1.58, 0.083333333333333
27681, 1.45, 1.62, 0.083333333333333
27682, 1.45, 1.66, 0.083333333333333
27683, 1.4916666666667, 1.54, 0.083333333333333
27684, 1.4916666666667, 1.58, 0.083333333333333
27685, 1.4916666666667, 1.62, 0.083333333333333
27686, 1.4916666666667, 1.66, 0.083333333333333
27687, 1.5333333333333, 1.54, 0.083333333333333
27688, 1.5333333333333, 1.58, 0.083333333333333
27689, 1.5333333333333, 1.62, 0.083333333333333
27690, 1.5333333333333, 1.66, 0.083333333333333
27691, 1.575, 1.54, 0.083333333333333
27692, 1.575, 1.58, 0.083333333333333
27693, 1.575, 1.62, 0.083333333333333
27694, 1.575, 1.66, 0.083333333333333
27695, 1.6166666666667, 1.54, 0.083333333333333
27696, 1.6166666666667, 1.58, 0.083333333333333
27697, 1.6166666666667, 1.62, 0.083333333333333
27698, 1.6166666666667, 1.66, 0.083333333333333
27699, 1.6583333333333, 1.54, 0.083333333333333
27700, 1.6583333333333, 1.58, 0.083333333333333
27701, 1.6583333333333, 1.62, 0.083333333333333
27702, 1.6583333333333, 1.66, 0.083333333333333
27703, 1.7, 1.54, 0.083333333333333
27704, 1.7, 1.58, 0.083333333333333
27705, 1.7, 1.62, 0.083333333333333
27706, 1.7, 1.66, 0.083333333333333
27707, 1.7416666666667, 1.54, 0.083333333333333
27708, 1.7416666666667, 1.58, 0.083333333333333
27709, 1.7416666666667, 1.62, 0.083333333333333
27710, 1.7416666666667, 1.66, 0.083333333333333
27711, 1.7833333333333, 1.54, 0.083333333333333
27712, 1.7833333333333, 1.58, 0.083333333333333
27713, 1.7833333333333, 1.62, 0.083333333333333
27714, 1.7833333333333, 1.66, 0.083333333333333
27715, 1.825, 1.54, 0.083333333333333
27716, 1.825, 1.58, 0.083333333333333
27717, 1.825, 1.62, 0.083333333333333
27718, 1.825, 1.66, 0.083333333333333
27719, 1.8666666666667, 1.54, 0.083333333333333
27720, 1.8666666666667, 1.58, 0.083333333333333
27721, 1.8666666666667, 1.62, 0.083333333333333
27722, 1.8666666666667, 1.66, 0.083333333333333
27723, 1.9083333333333, 1.54, 0.083333333333333
27724, 1.9083333333333, 1.58, 0.083333333333333
27725, 1.9083333333333, 1.62, 0.083333333333333
27726, 1.9083333333333, 1.66, 0.083333333333333
27727, 1.95, 1.54, 0.083333333333333
27728, 1.95, 1.58, 0.083333333333333
27729, 1.95, 1.62, 0.083333333333333
27730, 1.95, 1.66, 0.083333333333333
27731, 1.9916666666667, 1.54, 0.083333333333333
27732, 1.9916666666667, 1.58, 0.083333333333333
27733, 1.9916666666667, 1.62, 0.083333333333333
27734, 1.9916666666667, 1.66, 0.083333333333333
27735, 2.0333333333333, 1.54, 0.083333333333333
27736, 2.0333333333333, 1.58, 0.083333333333333
27737, 2.0333333333333, 1.62, 0.083333333333333
27738, 2.0333333333333, 1.66, 0.083333333333333
27739, 2.075, 1.54, 0.083333333333333
27740, 2.075, 1.58, 0.083333333333333
27741, 2.075, 1.62, 0.083333333333333
27742, 2.075, 1.66, 0.083333333333333
27743, 2.1166666666667, 1.54, 0.083333333333333
27744, 2.1166666666667, 1.58, 0.083333333333333
27745, 2.1166666666667, 1.62, 0.083333333333333
27746, 2.1166666666667, 1.66, 0.083333333333333
27747, 2.1583333333333, 1.54, 0.083333333333333
27748, 2.1583333333333, 1.58, 0.083333333333333
27749, 2.1583333333333, 1.62, 0.083333333333333
27750, 2.1583333333333, 1.66, 0.083333333333333
27751, 1.2416666666667, 1.54, 0.125
27752, 1.2416666666667, 1.58, 0.125
27753, 1.2416666666667, 1.62, 0.125
27754, 1.2416666666667, 1.66, 0.125
27755, 1.2833333333333, 1.54, 0.125
27756, 1.2833333333333, 1.58, 0.125
27757, 1.2833333333333, 1.62, 0.125
27758, 1.2833333333333, 1.66, 0.125
27759, 1.325, 1.54, 0.125
27760, 1.325, 1.58, 0.125
27761, 1.325, 1.62, 0.125
27762, 1.325, 1.66, 0.125
27763, 1.3666666666667, 1.54, 0.125
27764, 1.3666666666667, 1.58, 0.125
27765, 1.3666666666667, 1.62, 0.125
27766, 1.3666666666667, 1.66, 0.125
27767, 1.4083333333333, 1.54, 0.125
27768, 1.4083333333333, 1.58, 0.125
27769, 1.4083333333333, 1.62, 0.125
27770, 1.4083333333333, 1.66, 0.125
27771, 1.45, 1.54, 0.125
27772, 1.45, 1.58, 0.125
27773, 1.45, 1.62, 0.125
27774, 1.45, 1.66, 0.125
27775, 1.4916666666667, 1.54, 0.125
27776, 1.4916666666667, 1.58, 0.125
27777, 1.4916666666667, 1.62, 0.125
27778, 1.4916666666667, 1.66, 0.125
27779, 1.5333333333333, 1.54, 0.125
27780, 1.5333333333333, 1.58, 0.125
27781, 1.5333333333333, 1.62, 0.125
27782, 1.5333333333333, 1.66, 0.125
27783, 1.575, 1.54, 0.125
27784, 1.575, 1.58, 0.125
27785, 1.575, 1.62, 0.125
27786, 1.575, 1.66, 0.125
27787, 1.6166666666667, 1.54, 0.125
27788, 1.6166666666667, 1.58, 0.125
27789, 1.6166666666667, 1.62, 0.125
27790, 1.6166666666667, 1.66, 0.125
27791, 1.6583333333333, 1.54, 0.125
27792, 1.6583333333333, 1.58, 0.125
27793, 1.6583333333333, 1.62, 0.125
27794, 1.6583333333333, 1.66, 0.125
27795, 1.7, 1.54, 0.125
27796, 1.7, 1.58, 0.125
27797, 1.7, 1.62, 0.125
27798, 1.7, 1.66, 0.125
27799, 1.7416666666667, 1.54, 0.125
27800, 1.7416666666667, 1.58, 0.125
27801, 1.7416666666667, 1.62, 0.125
27802, 1.7416666666667, 1.66, 0.125
27803, 1.7833333333333, 1.54, 0.125
27804, 1.7833333333333, 1.58, 0.125
27805, 1.7833333333333, 1.62, 0.125
27806, 1.7833333333333, 1.66, 0.125
27807, 1.825, 1.54, 0.125
27808, 1.825, 1.58, 0.125
27809, 1.825, 1.62, 0.125
27810, 1.825, 1.66, 0.125
27811, 1.8666666666667, 1.54, 0.125
27812, 1.8666666666667, 1.58, 0.125
27813, 1.8666666666667, 1.62, 0.125
27814, 1.8666666666667, 1.66, 0.125
27815, 1.9083333333333, 1.54, 0.125
27816, 1.9083333333333, 1.58, 0.125
27817, 1.9083333333333, 1.62, 0.125
27818, 1.9083333333333, 1.66, 0.125
27819, 1.95, 1.54, 0.125
27820, 1.95, 1.58, 0.125
27821, 1.95, 1.62, 0.125
27822, 1.95, 1.66, 0.125
27823, 1.9916666666667, 1.54, 0.125
27824, 1.9916666666667, 1.58, 0.125
27825, 1.9916666666667, 1.62, 0.125
27826, 1.9916666666667, 1.66, 0.125
27827, 2.0333333333333, 1.54, 0.125
27828, 2.0333333333333, 1.58, 0.125
27829, 2.0333333333333, 1.62, 0.125
27830, 2.0333333333333, 1.66, 0.125
27831, 2.075, 1.54, 0.125
27832, 2.075, 1.58, 0.125
27833, 2.075, 1.62, 0.125
27834, 2.075, 1.66, 0.125
27835, 2.1166666666667, 1.54, 0.125
27836, 2.1166666666667, 1.58, 0.125
27837, 2.1166666666667, 1.62, 0.125
27838, 2.1166666666667, 1.66, 0.125
27839, 2.1583333333333, 1.54, 0.125
27840, 2.1583333333333, 1.58, 0.125
27841, 2.1583333333333, 1.62, 0.125
27842, 2.1583333333333, 1.66, 0.125
27843, 1.2416666666667, 1.54, 0.16666666666667
27844, 1.2416666666667, 1.58, 0.16666666666667
27845, 1.2416666666667, 1.62, 0.16666666666667
27846, 1.2416666666667, 1.66, 0.16666666666667
27847, 1.2833333333333, 1.54, 0.16666666666667
27848, 1.2833333333333, 1.58, 0.16666666666667
27849, 1.2833333333333, 1.62, 0.16666666666667
27850, 1.2833333333333, 1.66, 0.16666666666667
27851, 1.325, 1.54, 0.16666666666667
27852, 1.325, 1.58, 0.16666666666667
27853, 1.325, 1.62, 0.16666666666667
27854, 1.325, 1.66, 0.16666666666667
27855, 1.3666666666667, 1.54, 0.16666666666667
27856, 1.3666666666667, 1.58, 0.16666666666667
27857, 1.3666666666667, 1.62, 0.16666666666667
27858, 1.3666666666667, 1.66, 0.16666666666667
27859, 1.4083333333333, 1.54, 0.16666666666667
27860, 1.4083333333333, 1.58, 0.16666666666667
27861, 1.4083333333333, 1.62, 0.16666666666667
27862, 1.4083333333333, 1.66, 0.16666666666667
27863, 1.45, 1.54, 0.16666666666667
27864, 1.45, 1.58, 0.16666666666667
27865, 1.45, 1.62, 0.16666666666667
27866, 1.45, 1.66, 0.16666666666667
27867, 1.4916666666667, 1.54, 0.16666666666667
27868, 1.4916666666667, 1.58, 0.16666666666667
27869, 1.4916666666667, 1.62, 0.16666666666667
27870, 1.4916666666667, 1.66, 0.16666666666667
27871, 1.5333333333333, 1.54, 0.16666666666667
27872, 1.5333333333333, 1.58, 0.16666666666667
27873, 1.5333333333333, 1.62, 0.16666666666667
27874, 1.5333333333333, 1.66, 0.16666666666667
27875, 1.575, 1.54, 0.16666666666667
27876, 1.575, 1.58, 0.16666666666667
27877, 1.575, 1.62, 0.16666666666667
27878, 1.575, 1.66, 0.16666666666667
27879, 1.6166666666667, 1.54, 0.16666666666667
27880, 1.6166666666667, 1.58, 0.16666666666667
27881, 1.6166666666667, 1.62, 0.16666666666667
27882, 1.6166666666667, 1.66, 0.16666666666667
27883, 1.6583333333333, 1.54, 0.16666666666667
27884, 1.6583333333333, 1.58, 0.16666666666667
27885, 1.6583333333333, 1.62, 0.16666666666667
27886, 1.6583333333333, 1.66, 0.16666666666667
27887, 1.7, 1.54, 0.16666666666667
27888, 1.7, 1.58, 0.16666666666667
27889, 1.7, 1.62, 0.16666666666667
27890, 1.7, 1.66, 0.16666666666667
27891, 1.7416666666667, 1.54, 0.16666666666667
27892, 1.7416666666667, 1.58, 0.16666666666667
27893, 1.7416666666667, 1.62, 0.16666666666667
27894, 1.7416666666667, 1.66, 0.16666666666667
27895, 1.7833333333333, 1.54, 0.16666666666667
27896, 1.7833333333333, 1.58, 0.16666666666667
27897, 1.7833333333333, 1.62, 0.16666666666667
27898, 1.7833333333333, 1.66, 0.16666666666667
27899, 1.825, 1.54, 0.16666666666667
27900, 1.825, 1.58, 0.16666666666667
27901, 1.825, 1.62, 0.16666666666667
27902, 1.825, 1.66, 0.16666666666667
27903, 1.8666666666667, 1.54, 0.16666666666667
27904, 1.8666666666667, 1.58, 0.16666666666667
27905, 1.8666666666667, 1.62, 0.16666666666667
27906, 1.8666666666667, 1.66, 0.16666666666667
27907, 1.9083333333333, 1.54, 0.16666666666667
27908, 1.9083333333333, 1.58, 0.16666666666667
27909, 1.9083333333333, 1.62, 0.16666666666667
27910, 1.9083333333333, 1.66, 0.16666666666667
27911, 1.95, 1.54, 0.16666666666667
27912, 1.95, 1.58, 0.16666666666667
27913, 1.95, 1.62, 0.16666666666667
27914, 1.95, 1.66, 0.16666666666667
27915, 1.9916666666667, 1.54, 0.16666666666667
27916, 1.9916666666667, 1.58, 0.16666666666667
27917, 1.9916666666667, 1.62, 0.16666666666667
27918, 1.9916666666667, 1.66, 0.16666666666667
27919, 2.0333333333333, 1.54, 0.16666666666667
27920, 2.0333333333333, 1.58, 0.16666666666667
27921, 2.0333333333333, 1.62, 0.16666666666667
27922, 2.0333333333333, 1.66, 0.16666666666667
27923, 2.075, 1.54, 0.16666666666667
27924, 2.075, 1.58, 0.16666666666667
27925, 2.075, 1.62, 0.16666666666667
27926, 2.075, 1.66, 0.16666666666667
27927, 2.1166666666667, 1.54, 0.16666666666667
27928, 2.1166666666667, 1.58, 0.16666666666667
27929, 2.1166666666667, 1.62, 0.16666666666667
27930, 2.1166666666667, 1.66, 0.16666666666667
27931, 2.1583333333333, 1.54, 0.16666666666667
27932, 2.1583333333333, 1.58, 0.16666666666667
27933, 2.1583333333333, 1.62, 0.16666666666667
27934, 2.1583333333333, 1.66, 0.16666666666667
27935, 1.2416666666667, 1.54, 0.20833333333333
27936, 1.2416666666667, 1.58, 0.20833333333333
27937, 1.2416666666667, 1.62, 0.20833333333333
27938, 1.2416666666667, 1.66, 0.20833333333333
27939, 1.2833333333333, 1.54, 0.20833333333333
27940, 1.2833333333333, 1.58, 0.20833333333333
27941, 1.2833333333333, 1.62, 0.20833333333333
27942, 1.2833333333333, 1.66, 0.20833333333333
27943, 1.325, 1.54, 0.20833333333333
27944, 1.325, 1.58, 0.20833333333333
27945, 1.325, 1.62, 0.20833333333333
27946, 1.325, 1.66, 0.20833333333333
27947, 1.3666666666667, 1.54, 0.20833333333333
27948, 1.3666666666667, 1.58, 0.20833333333333
27949, 1.3666666666667, 1.62, 0.20833333333333
27950, 1.3666666666667, 1.66, 0.20833333333333
27951, 1.4083333333333, 1.54, 0.20833333333333
27952, 1.4083333333333, 1.58, 0.20833333333333
27953, 1.4083333333333, 1.62, 0.20833333333333
27954, 1.4083333333333, 1.66, 0.20833333333333
27955, 1.45, 1.54, 0.20833333333333
27956, 1.45, 1.58, 0.20833333333333
27957, 1.45, 1.62, 0.20833333333333
27958, 1.45, 1.66, 0.20833333333333
27959, 1.4916666666667, 1.54, 0.20833333333333
27960, 1.4916666666667, 1.58, 0.20833333333333
27961, 1.4916666666667, 1.62, 0.20833333333333
27962, 1.4916666666667, 1.66, 0.20833333333333
27963, 1.5333333333333, 1.54, 0.20833333333333
27964, 1.5333333333333, 1.58, 0.20833333333333
27965, 1.5333333333333, 1.62, 0.20833333333333
27966, 1.5333333333333, 1.66, 0.20833333333333
27967, 1.575, 1.54, 0.20833333333333
27968, 1.575, 1.58, 0.20833333333333
27969, 1.575, 1.62, 0.20833333333333
27970, 1.575, 1.66, 0.20833333333333
27971, 1.6166666666667, 1.54, 0.20833333333333
27972, 1.6166666666667, 1.58, 0.20833333333333
27973, 1.6166666666667, 1.62, 0.20833333333333
27974, 1.6166666666667, 1.66, 0.20833333333333
27975, 1.6583333333333, 1.54, 0.20833333333333
27976, 1.6583333333333, 1.58, 0.20833333333333
27977, 1.6583333333333, 1.62, 0.20833333333333
27978, 1.6583333333333, 1.66, 0.20833333333333
27979, 1.7, 1.54, 0.20833333333333
27980, 1.7, 1.58, 0.20833333333333
27981, 1.7, 1.62, 0.20833333333333
27982, 1.7, 1.66, 0.20833333333333
27983, 1.7416666666667, 1.54, 0.20833333333333
27984, 1.7416666666667, 1.58, 0.20833333333333
27985, 1.7416666666667, 1.62, 0.20833333333333
27986, 1.7416666666667, 1.66, 0.20833333333333
27987, 1.7833333333333, 1.54, 0.20833333333333
27988, 1.7833333333333, 1.58, 0.20833333333333
27989, 1.7833333333333, 1.62, 0.20833333333333
27990, 1.7833333333333, 1.66, 0.20833333333333
27991, 1.825, 1.54, 0.20833333333333
27992, 1.825, 1.58, 0.20833333333333
27993, 1.825, 1.62, 0.20833333333333
27994, 1.825, 1.66, 0.20833333333333
27995, 1.8666666666667, 1.54, 0.20833333333333
27996, 1.8666666666667, 1.58, 0.20833333333333
27997, 1.8666666666667, 1.62, 0.20833333333333
27998, 1.8666666666667, 1.66, 0.20833333333333
27999, 1.9083333333333, 1.54, 0.20833333333333
28000, 1.9083333333333, 1.58, 0.20833333333333
28001, 1.9083333333333, 1.62, 0.20833333333333
28002, 1.9083333333333, 1.66, 0.20833333333333
28003, 1.95, 1.54, 0.20833333333333
28004, 1.95, 1.58, 0.20833333333333
28005, 1.95, 1.62, 0.20833333333333
28006, 1.95, 1.66, 0.20833333333333
28007, 1.9916666666667, 1.54, 0.20833333333333
28008, 1.9916666666667, 1.58, 0.20833333333333
28009, 1.9916666666667, 1.62, 0.20833333333333
28010, 1.9916666666667, 1.66, 0.20833333333333
28011, 2.0333333333333, 1.54, 0.20833333333333
28012, 2.0333333333333, 1.58, 0.20833333333333
28013, 2.0333333333333, 1.62, 0.20833333333333
28014, 2.0333333333333, 1.66, 0.20833333333333
28015, 2.075, 1.54, 0.20833333333333
28016, 2.075, 1.58, 0.20833333333333
28017, 2.075, 1.62, 0.20833333333333
28018, 2.075, 1.66, 0.20833333333333
28019, 2.1166666666667, 1.54, 0.20833333333333
28020, 2.1166666666667, 1.58, 0.20833333333333
28021, 2.1166666666667, 1.62, 0.20833333333333
28022, 2.1166666666667, 1.66, 0.20833333333333
28023, 2.1583333333333, 1.54, 0.20833333333333
28024, 2.1583333333333, 1.58, 0.20833333333333
28025, 2.1583333333333, 1.62, 0.20833333333333
28026, 2.1583333333333, 1.66, 0.20833333333333
28027, 1.2416666666667, 1.54, 0.25
28028, 1.2416666666667, 1.58, 0.25
28029, 1.2416666666667, 1.62, 0.25
28030, 1.2416666666667, 1.66, 0.25
28031, 1.2833333333333, 1.54, 0.25
28032, 1.2833333333333, 1.58, 0.25
28033, 1.2833333333333, 1.62, 0.25
28034, 1.2833333333333, 1.66, 0.25
28035, 1.325, 1.54, 0.25
28036, 1.325, 1.58, 0.25
28037, 1.325, 1.62, 0.25
28038, 1.325, 1.66, 0.25
28039, 1.3666666666667, 1.54, 0.25
28040, 1.3666666666667, 1.58, 0.25
28041, 1.3666666666667, 1.62, 0.25
28042, 1.3666666666667, 1.66, 0.25
28043, 1.4083333333333, 1.54, 0.25
28044, 1.4083333333333, 1.58, 0.25
28045, 1.4083333333333, 1.62, 0.25
28046, 1.4083333333333, 1.66, 0.25
28047, 1.45, 1.54, 0.25
28048, 1.45, 1.58, 0.25
28049, 1.45, 1.62, 0.25
28050, 1.45, 1.66, 0.25
28051, 1.4916666666667, 1.54, 0.25
28052, 1.4916666666667, 1.58, 0.25
28053, 1.4916666666667, 1.62, 0.25
28054, 1.4916666666667, 1.66, 0.25
28055, 1.5333333333333, 1.54, 0.25
28056, 1.5333333333333, 1.58, 0.25
28057, 1.5333333333333, 1.62, 0.25
28058, 1.5333333333333, 1.66, 0.25
28059, 1.575, 1.54, 0.25
28060, 1.575, 1.58, 0.25
28061, 1.575, 1.62, 0.25
28062, 1.575, 1.66, 0.25
28063, 1.6166666666667, 1.54, 0.25
28064, 1.6166666666667, 1.58, 0.25
28065, 1.6166666666667, 1.62, 0.25
28066, 1.6166666666667, 1.66, 0.25
28067, 1.6583333333333, 1.54, 0.25
28068, 1.6583333333333, 1.58, 0.25
28069, 1.6583333333333, 1.62, 0.25
28070, 1.6583333333333, 1.66, 0.25
28071, 1.7, 1.54, 0.25
28072, 1.7, 1.58, 0.25
28073, 1.7, 1.62, 0.25
28074, 1.7, 1.66, 0.25
28075, 1.7416666666667, 1.54, 0.25
28076, 1.7416666666667, 1.58, 0.25
28077, 1.7416666666667, 1.62, 0.25
28078, 1.7416666666667, 1.66, 0.25
28079, 1.7833333333333, 1.54, 0.25
28080, 1.7833333333333, 1.58, 0.25
28081, 1.7833333333333, 1.62, 0.25
28082, 1.7833333333333, 1.66, 0.25
28083, 1.825, 1.54, 0.25
28084, 1.825, 1.58, 0.25
28085, 1.825, 1.62, 0.25
28086, 1.825, 1.66, 0.25
28087, 1.8666666666667, 1.54, 0.25
28088, 1.8666666666667, 1.58, 0.25
28089, 1.8666666666667, 1.62, 0.25
28090, 1.8666666666667, 1.66, 0.25
28091, 1.9083333333333, 1.54, 0.25
28092, 1.9083333333333, 1.58, 0.25
28093, 1.9083333333333, 1.62, 0.25
28094, 1.9083333333333, 1.66, 0.25
28095, 1.95, 1.54, 0.25
28096, 1.95, 1.58, 0.25
28097, 1.95, 1.62, 0.25
28098, 1.95, 1.66, 0.25
28099, 1.9916666666667, 1.54, 0.25
28100, 1.9916666666667, 1.58, 0.25
28101, 1.9916666666667, 1.62, 0.25
28102, 1.9916666666667, 1.66, 0.25
28103, 2.0333333333333, 1.54, 0.25
28104, 2.0333333333333, 1.58, 0.25
28105, 2.0333333333333, 1.62, 0.25
28106, 2.0333333333333, 1.66, 0.25
28107, 2.075, 1.54, 0.25
28108, 2.075, 1.58, 0.25
28109, 2.075, 1.62, 0.25
28110, 2.075, 1.66, 0.25
28111, 2.1166666666667, 1.54, 0.25
28112, 2.1166666666667, 1.58, 0.25
28113, 2.1166666666667, 1.62, 0.25
28114, 2.1166666666667, 1.66, 0.25
28115, 2.1583333333333, 1.54, 0.25
28116, 2.1583333333333, 1.58, 0.25
28117, 2.1583333333333, 1.62, 0.25
28118, 2.1583333333333, 1.66, 0.25
28119, 1.2416666666667, 1.54, 0.29166666666667
28120, 1.2416666666667, 1.58, 0.29166666666667
28121, 1.2416666666667, 1.62, 0.29166666666667
28122, 1.2416666666667, 1.66, 0.29166666666667
28123, 1.2833333333333, 1.54, 0.29166666666667
28124, 1.2833333333333, 1.58, 0.29166666666667
28125, 1.2833333333333, 1.62, 0.29166666666667
28126, 1.2833333333333, 1.66, 0.29166666666667
28127, 1.325, 1.54, 0.29166666666667
28128, 1.325, 1.58, 0.29166666666667
28129, 1.325, 1.62, 0.29166666666667
28130, 1.325, 1.66, 0.29166666666667
28131, 1.3666666666667, 1.54, 0.29166666666667
28132, 1.3666666666667, 1.58, 0.29166666666667
28133, 1.3666666666667, 1.62, 0.29166666666667
28134, 1.3666666666667, 1.66, 0.29166666666667
28135, 1.4083333333333, 1.54, 0.29166666666667
28136, 1.4083333333333, 1.58, 0.29166666666667
28137, 1.4083333333333, 1.62, 0.29166666666667
28138, 1.4083333333333, 1.66, 0.29166666666667
28139, 1.45, 1.54, 0.29166666666667
28140, 1.45, 1.58, 0.29166666666667
28141, 1.45, 1.62, 0.29166666666667
28142, 1.45, 1.66, 0.29166666666667
28143, 1.4916666666667, 1.54, 0.29166666666667
28144, 1.4916666666667, 1.58, 0.29166666666667
28145, 1.4916666666667, 1.62, 0.29166666666667
28146, 1.4916666666667, 1.66, 0.29166666666667
28147, 1.5333333333333, 1.54, 0.29166666666667
28148, 1.5333333333333, 1.58, 0.29166666666667
28149, 1.5333333333333, 1.62, 0.29166666666667
28150, 1.5333333333333, 1.66, 0.29166666666667
28151, 1.575, 1.54, 0.29166666666667
28152, 1.575, 1.58, 0.29166666666667
28153, 1.575, 1.62, 0.29166666666667
28154, 1.575, 1.66, 0.29166666666667
28155, 1.6166666666667, 1.54, 0.29166666666667
28156, 1.6166666666667, 1.58, 0.29166666666667
28157, 1.6166666666667, 1.62, 0.29166666666667
28158, 1.6166666666667, 1.66, 0.29166666666667
28159, 1.6583333333333, 1.54, 0.29166666666667
28160, 1.6583333333333, 1.58, 0.29166666666667
28161, 1.6583333333333, 1.62, 0.29166666666667
28162, 1.6583333333333, 1.66, 0.29166666666667
28163, 1.7, 1.54, 0.29166666666667
28164, 1.7, 1.58, 0.29166666666667
28165, 1.7, 1.62, 0.29166666666667
28166, 1.7, 1.66, 0.29166666666667
28167, 1.7416666666667, 1.54, 0.29166666666667
28168, 1.7416666666667, 1.58, 0.29166666666667
28169, 1.7416666666667, 1.62, 0.29166666666667
28170, 1.7416666666667, 1.66, 0.29166666666667
28171, 1.7833333333333, 1.54, 0.29166666666667
28172, 1.7833333333333, 1.58, 0.29166666666667
28173, 1.7833333333333, 1.62, 0.29166666666667
28174, 1.7833333333333, 1.66, 0.29166666666667
28175, 1.825, 1.54, 0.29166666666667
28176, 1.825, 1.58, 0.29166666666667
28177, 1.825, 1.62, 0.29166666666667
28178, 1.825, 1.66, 0.29166666666667
28179, 1.8666666666667, 1.54, 0.29166666666667
28180, 1.8666666666667, 1.58, 0.29166666666667
28181, 1.8666666666667, 1.62, 0.29166666666667
28182, 1.8666666666667, 1.66, 0.29166666666667
28183, 1.9083333333333, 1.54, 0.29166666666667
28184, 1.9083333333333, 1.58, 0.29166666666667
28185, 1.9083333333333, 1.62, 0.29166666666667
28186, 1.9083333333333, 1.66, 0.29166666666667
28187, 1.95, 1.54, 0.29166666666667
28188, 1.95, 1.58, 0.29166666666667
28189, 1.95, 1.62, 0.29166666666667
28190, 1.95, 1.66, 0.29166666666667
28191, 1.9916666666667, 1.54, 0.29166666666667
28192, 1.9916666666667, 1.58, 0.29166666666667
28193, 1.9916666666667, 1.62, 0.29166666666667
28194, 1.9916666666667, 1.66, 0.29166666666667
28195, 2.0333333333333, 1.54, 0.29166666666667
28196, 2.0333333333333, 1.58, 0.29166666666667
28197, 2.0333333333333, 1.62, 0.29166666666667
28198, 2.0333333333333, 1.66, 0.29166666666667
28199, 2.075, 1.54, 0.29166666666667
28200, 2.075, 1.58, 0.29166666666667
28201, 2.075, 1.62, 0.29166666666667
28202, 2.075, 1.66, 0.29166666666667
28203, 2.1166666666667, 1.54, 0.29166666666667
28204, 2.1166666666667, 1.58, 0.29166666666667
28205, 2.1166666666667, 1.62, 0.29166666666667
28206, 2.1166666666667, 1.66, 0.29166666666667
28207, 2.1583333333333, 1.54, 0.29166666666667
28208, 2.1583333333333, 1.58, 0.29166666666667
28209, 2.1583333333333, 1.62, 0.29166666666667
28210, 2.1583333333333, 1.66, 0.29166666666667
28211, 1.2416666666667, 1.54, 0.33333333333333
28212, 1.2416666666667, 1.58, 0.33333333333333
28213, 1.2416666666667, 1.62, 0.33333333333333
28214, 1.2416666666667, 1.66, 0.33333333333333
28215, 1.2833333333333, 1.54, 0.33333333333333
28216, 1.2833333333333, 1.58, 0.33333333333333
28217, 1.2833333333333, 1.62, 0.33333333333333
28218, 1.2833333333333, 1.66, 0.33333333333333
28219, 1.325, 1.54, 0.33333333333333
28220, 1.325, 1.58, 0.33333333333333
28221, 1.325, 1.62, 0.33333333333333
28222, 1.325, 1.66, 0.33333333333333
28223, 1.3666666666667, 1.54, 0.33333333333333
28224, 1.3666666666667, 1.58, 0.33333333333333
28225, 1.3666666666667, 1.62, 0.33333333333333
28226, 1.3666666666667, 1.66, 0.33333333333333
28227, 1.4083333333333, 1.54, 0.33333333333333
28228, 1.4083333333333, 1.58, 0.33333333333333
28229, 1.4083333333333, 1.62, 0.33333333333333
28230, 1.4083333333333, 1.66, 0.33333333333333
28231, 1.45, 1.54, 0.33333333333333
28232, 1.45, 1.58, 0.33333333333333
28233, 1.45, 1.62, 0.33333333333333
28234, 1.45, 1.66, 0.33333333333333
28235, 1.4916666666667, 1.54, 0.33333333333333
28236, 1.4916666666667, 1.58, 0.33333333333333
28237, 1.4916666666667, 1.62, 0.33333333333333
28238, 1.4916666666667, 1.66, 0.33333333333333
28239, 1.5333333333333, 1.54, 0.33333333333333
28240, 1.5333333333333, 1.58, 0.33333333333333
28241, 1.5333333333333, 1.62, 0.33333333333333
28242, 1.5333333333333, 1.66, 0.33333333333333
28243, 1.575, 1.54, 0.33333333333333
28244, 1.575, 1.58, 0.33333333333333
28245, 1.575, 1.62, 0.33333333333333
28246, 1.575, 1.66, 0.33333333333333
28247, 1.6166666666667, 1.54, 0.33333333333333
28248, 1.6166666666667, 1.58, 0.33333333333333
28249, 1.6166666666667, 1.62, 0.33333333333333
28250, 1.6166666666667, 1.66, 0.33333333333333
28251, 1.6583333333333, 1.54, 0.33333333333333
28252, 1.6583333333333, 1.58, 0.33333333333333
28253, 1.6583333333333, 1.62, 0.33333333333333
28254, 1.6583333333333, 1.66, 0.33333333333333
28255, 1.7, 1.54, 0.33333333333333
28256, 1.7, 1.58, 0.33333333333333
28257, 1.7, 1.62, 0.33333333333333
28258, 1.7, 1.66, 0.33333333333333
28259, 1.7416666666667, 1.54, 0.33333333333333
28260, 1.7416666666667, 1.58, 0.33333333333333
28261, 1.7416666666667, 1.62, 0.33333333333333
28262, 1.7416666666667, 1.66, 0.33333333333333
28263, 1.7833333333333, 1.54, 0.33333333333333
28264, 1.7833333333333, 1.58, 0.33333333333333
28265, 1.7833333333333, 1.62, 0.33333333333333
28266, 1.7833333333333, 1.66, 0.33333333333333
28267, 1.825, 1.54, 0.33333333333333
28268, 1.825, 1.58, 0.33333333333333
28269, 1.825, 1.62, 0.33333333333333
28270, 1.825, 1.66, 0.33333333333333
28271, 1.8666666666667, 1.54, 0.33333333333333
28272, 1.8666666666667, 1.58, 0.33333333333333
28273, 1.8666666666667, 1.62, 0.33333333333333
28274, 1.8666666666667, 1.66, 0.33333333333333
28275, 1.9083333333333, 1.54, 0.33333333333333
28276, 1.9083333333333, 1.58, 0.33333333333333
28277, 1.9083333333333, 1.62, 0.33333333333333
28278, 1.9083333333333, 1.66, 0.33333333333333
28279, 1.95, 1.54, 0.33333333333333
28280, 1.95, 1.58, 0.33333333333333
28281, 1.95, 1.62, 0.33333333333333
28282, 1.95, 1.66, 0.33333333333333
28283, 1.9916666666667, 1.54, 0.33333333333333
28284, 1.9916666666667, 1.58, 0.33333333333333
28285, 1.9916666666667, 1.62, 0.33333333333333
28286, 1.9916666666667, 1.66, 0.33333333333333
28287, 2.0333333333333, 1.54, 0.33333333333333
28288, 2.0333333333333, 1.58, 0.33333333333333
28289, 2.0333333333333, 1.62, 0.33333333333333
28290, 2.0333333333333, 1.66, 0.33333333333333
28291, 2.075, 1.54, 0.33333333333333
28292, 2.075, 1.58, 0.33333333333333
28293, 2.075, 1.62, 0.33333333333333
28294, 2.075, 1.66, 0.33333333333333
28295, 2.1166666666667, 1.54, 0.33333333333333
28296, 2.1166666666667, 1.58, 0.33333333333333
28297, 2.1166666666667, 1.62, 0.33333333333333
28298, 2.1166666666667, 1.66, 0.33333333333333
28299, 2.1583333333333, 1.54, 0.33333333333333
28300, 2.1583333333333, 1.58, 0.33333333333333
28301, 2.1583333333333, 1.62, 0.33333333333333
28302, 2.1583333333333, 1.66, 0.33333333333333
28303, 1.2416666666667, 1.54, 0.375
28304, 1.2416666666667, 1.58, 0.375
28305, 1.2416666666667, 1.62, 0.375
28306, 1.2416666666667, 1.66, 0.375
28307, 1.2833333333333, 1.54, 0.375
28308, 1.2833333333333, 1.58, 0.375
28309, 1.2833333333333, 1.62, 0.375
28310, 1.2833333333333, 1.66, 0.375
28311, 1.325, 1.54, 0.375
28312, 1.325, 1.58, 0.375
28313, 1.325, 1.62, 0.375
28314, 1.325, 1.66, 0.375
28315, 1.3666666666667, 1.54, 0.375
28316, 1.3666666666667, 1.58, 0.375
28317, 1.3666666666667, 1.62, 0.375
28318, 1.3666666666667, 1.66, 0.375
28319, 1.4083333333333, 1.54, 0.375
28320, 1.4083333333333, 1.58, 0.375
28321, 1.4083333333333, 1.62, 0.375
28322, 1.4083333333333, 1.66, 0.375
28323, 1.45, 1.54, 0.375
28324, 1.45, 1.58, 0.375
28325, 1.45, 1.62, 0.375
28326, 1.45, 1.66, 0.375
28327, 1.4916666666667, 1.54, 0.375
28328, 1.4916666666667, 1.58, 0.375
28329, 1.4916666666667, 1.62, 0.375
28330, 1.4916666666667, 1.66, 0.375
28331, 1.5333333333333, 1.54, 0.375
28332, 1.5333333333333, 1.58, 0.375
28333, 1.5333333333333, 1.62, 0.375
28334, 1.5333333333333, 1.66, 0.375
28335, 1.575, 1.54, 0.375
28336, 1.575, 1.58, 0.375
28337, 1.575, 1.62, 0.375
28338, 1.575, 1.66, 0.375
28339, 1.6166666666667, 1.54, 0.375
28340, 1.6166666666667, 1.58, 0.375
28341, 1.6166666666667, 1.62, 0.375
28342, 1.6166666666667, 1.66, 0.375
28343, 1.6583333333333, 1.54, 0.375
28344, 1.6583333333333, 1.58, 0.375
28345, 1.6583333333333, 1.62, 0.375
28346, 1.6583333333333, 1.66, 0.375
28347, 1.7, 1.54, 0.375
28348, 1.7, 1.58, 0.375
28349, 1.7, 1.62, 0.375
28350, 1.7, 1.66, 0.375
28351, 1.7416666666667, 1.54, 0.375
28352, 1.7416666666667, 1.58, 0.375
28353, 1.7416666666667, 1.62, 0.375
28354, 1.7416666666667, 1.66, 0.375
28355, 1.7833333333333, 1.54, 0.375
28356, 1.7833333333333, 1.58, 0.375
28357, 1.7833333333333, 1.62, 0.375
28358, 1.7833333333333, 1.66, 0.375
28359, 1.825, 1.54, 0.375
28360, 1.825, 1.58, 0.375
28361, 1.825, 1.62, 0.375
28362, 1.825, 1.66, 0.375
28363, 1.8666666666667, 1.54, 0.375
28364, 1.8666666666667, 1.58, 0.375
28365, 1.8666666666667, 1.62, 0.375
28366, 1.8666666666667, 1.66, 0.375
28367, 1.9083333333333, 1.54, 0.375
28368, 1.9083333333333, 1.58, 0.375
28369, 1.9083333333333, 1.62, 0.375
28370, 1.9083333333333, 1.66, 0.375
28371, 1.95, 1.54, 0.375
28372, 1.95, 1.58, 0.375
28373, 1.95, 1.62, 0.375
28374, 1.95, 1.66, 0.375
28375, 1.9916666666667, 1.54, 0.375
28376, 1.9916666666667, 1.58, 0.375
28377, 1.9916666666667, 1.62, 0.375
28378, 1.9916666666667, 1.66, 0.375
28379, 2.0333333333333, 1.54, 0.375
28380, 2.0333333333333, 1.58, 0.375
28381, 2.0333333333333, 1.62, 0.375
28382, 2.0333333333333, 1.66, 0.375
28383, 2.075, 1.54, 0.375
28384, 2.075, 1.58, 0.375
28385, 2.075, 1.62, 0.375
28386, 2.075, 1.66, 0.375
28387, 2.1166666666667, 1.54, 0.375
28388, 2.1166666666667, 1.58, 0.375
28389, 2.1166666666667, 1.62, 0.375
28390, 2.1166666666667, 1.66, 0.375
28391, 2.1583333333333, 1.54, 0.375
28392, 2.1583333333333, 1.58, 0.375
28393, 2.1583333333333, 1.62, 0.375
28394, 2.1583333333333, 1.66, 0.375
28395, 1.2416666666667, 1.54, 0.41666666666667
28396, 1.2416666666667, 1.58, 0.41666666666667
28397, 1.2416666666667, 1.62, 0.41666666666667
28398, 1.2416666666667, 1.66, 0.41666666666667
28399, 1.2833333333333, 1.54, 0.41666666666667
28400, 1.2833333333333, 1.58, 0.41666666666667
28401, 1.2833333333333, 1.62, 0.41666666666667
28402, 1.2833333333333, 1.66, 0.41666666666667
28403, 1.325, 1.54, 0.41666666666667
28404, 1.325, 1.58, 0.41666666666667
28405, 1.325, 1.62, 0.41666666666667
28406, 1.325, 1.66, 0.41666666666667
28407, 1.3666666666667, 1.54, 0.41666666666667
28408, 1.3666666666667, 1.58, 0.41666666666667
28409, 1.3666666666667, 1.62, 0.41666666666667
28410, 1.3666666666667, 1.66, 0.41666666666667
28411, 1.4083333333333, 1.54, 0.41666666666667
28412, 1.4083333333333, 1.58, 0.41666666666667
28413, 1.4083333333333, 1.62, 0.41666666666667
28414, 1.4083333333333, 1.66, 0.41666666666667
28415, 1.45, 1.54, 0.41666666666667
28416, 1.45, 1.58, 0.41666666666667
28417, 1.45, 1.62, 0.41666666666667
28418, 1.45, 1.66, 0.41666666666667
28419, 1.4916666666667, 1.54, 0.41666666666667
28420, 1.4916666666667, 1.58, 0.41666666666667
28421, 1.4916666666667, 1.62, 0.41666666666667
28422, 1.4916666666667, 1.66, 0.41666666666667
28423, 1.5333333333333, 1.54, 0.41666666666667
28424, 1.5333333333333, 1.58, 0.41666666666667
28425, 1.5333333333333, 1.62, 0.41666666666667
28426, 1.5333333333333, 1.66, 0.41666666666667
28427, 1.575, 1.54, 0.41666666666667
28428, 1.575, 1.58, 0.41666666666667
28429, 1.575, 1.62, 0.41666666666667
28430, 1.575, 1.66, 0.41666666666667
28431, 1.6166666666667, 1.54, 0.41666666666667
28432, 1.6166666666667, 1.58, 0.41666666666667
28433, 1.6166666666667, 1.62, 0.41666666666667
28434, 1.6166666666667, 1.66, 0.41666666666667
28435, 1.6583333333333, 1.54, 0.41666666666667
28436, 1.6583333333333, 1.58, 0.41666666666667
28437, 1.6583333333333, 1.62, 0.41666666666667
28438, 1.6583333333333, 1.66, 0.41666666666667
28439, 1.7, 1.54, 0.41666666666667
28440, 1.7, 1.58, 0.41666666666667
28441, 1.7, 1.62, 0.41666666666667
28442, 1.7, 1.66, 0.41666666666667
28443, 1.7416666666667, 1.54, 0.41666666666667
28444, 1.7416666666667, 1.58, 0.41666666666667
28445, 1.7416666666667, 1.62, 0.41666666666667
28446, 1.7416666666667, 1.66, 0.41666666666667
28447, 1.7833333333333, 1.54, 0.41666666666667
28448, 1.7833333333333, 1.58, 0.41666666666667
28449, 1.7833333333333, 1.62, 0.41666666666667
28450, 1.7833333333333, 1.66, 0.41666666666667
28451, 1.825, 1.54, 0.41666666666667
28452, 1.825, 1.58, 0.41666666666667
28453, 1.825, 1.62, 0.41666666666667
28454, 1.825, 1.66, 0.41666666666667
28455, 1.8666666666667, 1.54, 0.41666666666667
28456, 1.8666666666667, 1.58, 0.41666666666667
28457, 1.8666666666667, 1.62, 0.41666666666667
28458, 1.8666666666667, 1.66, 0.41666666666667
28459, 1.9083333333333, 1.54, 0.41666666666667
28460, 1.9083333333333, 1.58, 0.41666666666667
28461, 1.9083333333333, 1.62, 0.41666666666667
28462, 1.9083333333333, 1.66, 0.41666666666667
28463, 1.95, 1.54, 0.41666666666667
28464, 1.95, 1.58, 0.41666666666667
28465, 1.95, 1.62, 0.41666666666667
28466, 1.95, 1.66, 0.41666666666667
28467, 1.9916666666667, 1.54, 0.41666666666667
28468, 1.9916666666667, 1.58, 0.41666666666667
28469, 1.9916666666667, 1.62, 0.41666666666667
28470, 1.9916666666667, 1.66, 0.41666666666667
28471, 2.0333333333333, 1.54, 0.41666666666667
28472, 2.0333333333333, 1.58, 0.41666666666667
28473, 2.0333333333333, 1.62, 0.41666666666667
28474, 2.0333333333333, 1.66, 0.41666666666667
28475, 2.075, 1.54, 0.41666666666667
28476, 2.075, 1.58, 0.41666666666667
28477, 2.075, 1.62, 0.41666666666667
28478, 2.075, 1.66, 0.41666666666667
28479, 2.1166666666667, 1.54, 0.41666666666667
28480, 2.1166666666667, 1.58, 0.41666666666667
28481, 2.1166666666667, 1.62, 0.41666666666667
28482, 2.1166666666667, 1.66, 0.41666666666667
28483, 2.1583333333333, 1.54, 0.41666666666667
28484, 2.1583333333333, 1.58, 0.41666666666667
28485, 2.1583333333333, 1.62, 0.41666666666667
28486, 2.1583333333333, 1.66, 0.41666666666667
28487, 1.2416666666667, 1.54, 0.45833333333333
28488, 1.2416666666667, 1.58, 0.45833333333333
28489, 1.2416666666667, 1.62, 0.45833333333333
28490, 1.2416666666667, 1.66, 0.45833333333333
28491, 1.2833333333333, 1.54, 0.45833333333333
28492, 1.2833333333333, 1.58, 0.45833333333333
28493, 1.2833333333333, 1.62, 0.45833333333333
28494, 1.2833333333333, 1.66, 0.45833333333333
28495, 1.325, 1.54, 0.45833333333333
28496, 1.325, 1.58, 0.45833333333333
28497, 1.325, 1.62, 0.45833333333333
28498, 1.325, 1.66, 0.45833333333333
28499, 1.3666666666667, 1.54, 0.45833333333333
28500, 1.3666666666667, 1.58, 0.45833333333333
28501, 1.3666666666667, 1.62, 0.45833333333333
28502, 1.3666666666667, 1.66, 0.45833333333333
28503, 1.4083333333333, 1.54, 0.45833333333333
28504, 1.4083333333333, 1.58, 0.45833333333333
28505, 1.4083333333333, 1.62, 0.45833333333333
28506, 1.4083333333333, 1.66, 0.45833333333333
28507, 1.45, 1.54, 0.45833333333333
28508, 1.45, 1.58, 0.45833333333333
28509, 1.45, 1.62, 0.45833333333333
28510, 1.45, 1.66, 0.45833333333333
28511, 1.4916666666667, 1.54, 0.45833333333333
28512, 1.4916666666667, 1.58, 0.45833333333333
28513, 1.4916666666667, 1.62, 0.45833333333333
28514, 1.4916666666667, 1.66, 0.45833333333333
28515, 1.5333333333333, 1.54, 0.45833333333333
28516, 1.5333333333333, 1.58, 0.45833333333333
28517, 1.5333333333333, 1.62, 0.45833333333333
28518, 1.5333333333333, 1.66, 0.45833333333333
28519, 1.575, 1.54, 0.45833333333333
28520, 1.575, 1.58, 0.45833333333333
28521, 1.575, 1.62, 0.45833333333333
28522, 1.575, 1.66, 0.45833333333333
28523, 1.6166666666667, 1.54, 0.45833333333333
28524, 1.6166666666667, 1.58, 0.45833333333333
28525, 1.6166666666667, 1.62, 0.45833333333333
28526, 1.6166666666667, 1.66, 0.45833333333333
28527, 1.6583333333333, 1.54, 0.45833333333333
28528, 1.6583333333333, 1.58, 0.45833333333333
28529, 1.6583333333333, 1.62, 0.45833333333333
28530, 1.6583333333333, 1.66, 0.45833333333333
28531, 1.7, 1.54, 0.45833333333333
28532, 1.7, 1.58, 0.45833333333333
28533, 1.7, 1.62, 0.45833333333333
28534, 1.7, 1.66, 0.45833333333333
28535, 1.7416666666667, 1.54, 0.45833333333333
28536, 1.7416666666667, 1.58, 0.45833333333333
28537, 1.7416666666667, 1.62, 0.45833333333333
28538, 1.7416666666667, 1.66, 0.45833333333333
28539, 1.7833333333333, 1.54, 0.45833333333333
28540, 1.7833333333333, 1.58, 0.45833333333333
28541, 1.7833333333333, 1.62, 0.45833333333333
28542, 1.7833333333333, 1.66, 0.45833333333333
28543, 1.825, 1.54, 0.45833333333333
28544, 1.825, 1.58, 0.45833333333333
28545, 1.825, 1.62, 0.45833333333333
28546, 1.825, 1.66, 0.45833333333333
28547, 1.8666666666667, 1.54, 0.45833333333333
28548, 1.8666666666667, 1.58, 0.45833333333333
28549, 1.8666666666667, 1.62, 0.45833333333333
28550, 1.8666666666667, 1.66, 0.45833333333333
28551, 1.9083333333333, 1.54, 0.45833333333333
28552, 1.9083333333333, 1.58, 0.45833333333333
28553, 1.9083333333333, 1.62, 0.45833333333333
28554, 1.9083333333333, 1.66, 0.45833333333333
28555, 1.95, 1.54, 0.45833333333333
28556, 1.95, 1.58, 0.45833333333333
28557, 1.95, 1.62, 0.45833333333333
28558, 1.95, 1.66, 0.45833333333333
28559, 1.9916666666667, 1.54, 0.45833333333333
28560, 1.9916666666667, 1.58, 0.45833333333333
28561, 1.9916666666667, 1.62, 0.45833333333333
28562, 1.9916666666667, 1.66, 0.45833333333333
28563, 2.0333333333333, 1.54, 0.45833333333333
28564, 2.0333333333333, 1.58, 0.45833333333333
28565, 2.0333333333333, 1.62, 0.45833333333333
28566, 2.0333333333333, 1.66, 0.45833333333333
28567, 2.075, 1.54, 0.45833333333333
28568, 2.075, 1.58, 0.45833333333333
28569, 2.075, 1.62, 0.45833333333333
28570, 2.075, 1.66, 0.45833333333333
28571, 2.1166666666667, 1.54, 0.45833333333333
28572, 2.1166666666667, 1.58, 0.45833333333333
28573, 2.1166666666667, 1.62, 0.45833333333333
28574, 2.1166666666667, 1.66, 0.45833333333333
28575, 2.1583333333333, 1.54, 0.45833333333333
28576, 2.1583333333333, 1.58, 0.45833333333333
28577, 2.1583333333333, 1.62, 0.45833333333333
28578, 2.1583333333333, 1.66, 0.45833333333333
28579, 0.041666666666667, -0.04, 0.041666666666667
28580, 0.041666666666667, -0.08, 0.041666666666667
28581, 0.041666666666667, -0.12, 0.041666666666667
28582, 0.041666666666667, -0.16, 0.041666666666667
28583, 0.041666666666667, -0.04, 0.083333333333333
28584, 0.041666666666667, -0.08, 0.083333333333333
28585, 0.041666666666667, -0.12, 0.083333333333333
28586, 0.041666666666667, -0.16, 0.083333333333333
28587, 0.041666666666667, -0.04, 0.125
28588, 0.041666666666667, -0.08, 0.125
28589, 0.041666666666667, -0.12, 0.125
28590, 0.041666666666667, -0.16, 0.125
28591, 0.041666666666667, -0.04, 0.16666666666667
28592, 0.041666666666667, -0.08, 0.16666666666667
28593, 0.041666666666667, -0.12, 0.16666666666667
28594, 0.041666666666667, -0.16, 0.16666666666667
28595, 0.041666666666667, -0.04, 0.20833333333333
28596, 0.041666666666667, -0.08, 0.20833333333333
28597, 0.041666666666667, -0.12, 0.20833333333333
28598, 0.041666666666667, -0.16, 0.20833333333333
28599, 0.041666666666667, -0.04, 0.25
28600, 0.041666666666667, -0.08, 0.25
28601, 0.041666666666667, -0.12, 0.25
28602, 0.041666666666667, -0.16, 0.25
28603, 0.041666666666667, -0.04, 0.29166666666667
28604, 0.041666666666667, -0.08, 0.29166666666667
28605, 0.041666666666667, -0.12, 0.29166666666667
28606, 0.041666666666667, -0.16, 0.29166666666667
28607, 0.041666666666667, -0.04, 0.33333333333333
28608, 0.041666666666667, -0.08, 0.33333333333333
28609, 0.041666666666667, -0.12, 0.33333333333333
28610, 0.041666666666667, -0.16, 0.33333333333333
28611, 0.041666666666667, -0.04, 0.375
28612, 0.041666666666667, -0.08, 0.375
28613, 0.041666666666667, -0.12, 0.375
28614, 0.041666666666667, -0.16, 0.375
28615, 0.041666666666667, -0.04, 0.41666666666667
28616, 0.041666666666667, -0.08, 0.41666666666667
28617, 0.041666666666667, -0.12, 0.41666666666667
28618, 0.041666666666667, -0.16, 0.41666666666667
28619, 0.041666666666667, -0.04, 0.45833333333333
28620, 0.041666666666667, -0.08, 0.45833333333333
28621, 0.041666666666667, -0.12, 0.45833333333333
28622, 0.041666666666667, -0.16, 0.45833333333333
28623, 0.083333333333333, -0.04, 0.041666666666667
28624, 0.083333333333333, -0.08, 0.041666666666667
28625, 0.083333333333333, -0.12, 0.041666666666667
28626, 0.083333333333333, -0.16, 0.041666666666667
28627, 0.083333333333333, -0.04, 0.083333333333333
28628, 0.083333333333333, -0.08, 0.083333333333333
28629, 0.083333333333333, -0.12, 0.083333333333333
28630, 0.083333333333333, -0.16, 0.083333333333333
28631, 0.083333333333333, -0.04, 0.125
28632, 0.083333333333333, -0.08, 0.125
28633, 0.083333333333333, -0.12, 0.125
28634, 0.083333333333333, -0.16, 0.125
28635, 0.083333333333333, -0.04, 0.16666666666667
28636, 0.083333333333333, -0.08, 0.16666666666667
28637, 0.083333333333333, -0.12, 0.16666666666667
28638, 0.083333333333333, -0.16, 0.16666666666667
28639, 0.083333333333333, -0.04, 0.20833333333333
28640, 0.083333333333333, -0.08, 0.20833333333333
28641, 0.083333333333333, -0.12, 0.20833333333333
28642, 0.083333333333333, -0.16, 0.20833333333333
28643, 0.083333333333333, -0.04, 0.25
28644, 0.083333333333333, -0.08, 0.25
28645, 0.083333333333333, -0.12, 0.25
28646, 0.083333333333333, -0.16, 0.25
28647, 0.083333333333333, -0.04, 0.29166666666667
28648, 0.083333333333333, -0.08, 0.29166666666667
28649, 0.083333333333333, -0.12, 0.29166666666667
28650, 0.083333333333333, -0.16, 0.29166666666667
28651, 0.083333333333333, -0.04, 0.33333333333333
28652, 0.083333333333333, -0.08, 0.33333333333333
28653, 0.083333333333333, -0.12, 0.33333333333333
28654, 0.083333333333333, -0.16, 0.33333333333333
28655, 0.083333333333333, -0.04, 0.375
28656, 0.083333333333333, -0.08, 0.375
28657, 0.083333333333333, -0.12, 0.375
28658, 0.083333333333333, -0.16, 0.375
28659, 0.083333333333333, -0.04, 0.41666666666667
28660, 0.083333333333333, -0.08, 0.41666666666667
