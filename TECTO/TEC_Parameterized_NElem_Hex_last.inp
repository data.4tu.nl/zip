14322, 0.20833333333333, 0.9, 0.33333333333333
14323, 0.20833333333333, 0.95, 0.33333333333333
14324, 0.20833333333333, 1, 0.33333333333333
14325, 0.20833333333333, 1.05, 0.33333333333333
14326, 0.20833333333333, 1.1, 0.33333333333333
14327, 0.20833333333333, 1.15, 0.33333333333333
14328, 0.20833333333333, 1.2, 0.33333333333333
14329, 0.20833333333333, 1.25, 0.33333333333333
14330, 0.20833333333333, 1.3, 0.33333333333333
14331, 0.20833333333333, 0.2, 0.375
14332, 0.20833333333333, 0.25, 0.375
14333, 0.20833333333333, 0.3, 0.375
14334, 0.20833333333333, 0.35, 0.375
14335, 0.20833333333333, 0.4, 0.375
14336, 0.20833333333333, 0.45, 0.375
14337, 0.20833333333333, 0.5, 0.375
14338, 0.20833333333333, 0.55, 0.375
14339, 0.20833333333333, 0.6, 0.375
14340, 0.20833333333333, 0.65, 0.375
14341, 0.20833333333333, 0.7, 0.375
14342, 0.20833333333333, 0.75, 0.375
14343, 0.20833333333333, 0.8, 0.375
14344, 0.20833333333333, 0.85, 0.375
14345, 0.20833333333333, 0.9, 0.375
14346, 0.20833333333333, 0.95, 0.375
14347, 0.20833333333333, 1, 0.375
14348, 0.20833333333333, 1.05, 0.375
14349, 0.20833333333333, 1.1, 0.375
14350, 0.20833333333333, 1.15, 0.375
14351, 0.20833333333333, 1.2, 0.375
14352, 0.20833333333333, 1.25, 0.375
14353, 0.20833333333333, 1.3, 0.375
14354, 0.20833333333333, 0.2, 0.41666666666667
14355, 0.20833333333333, 0.25, 0.41666666666667
14356, 0.20833333333333, 0.3, 0.41666666666667
14357, 0.20833333333333, 0.35, 0.41666666666667
14358, 0.20833333333333, 0.4, 0.41666666666667
14359, 0.20833333333333, 0.45, 0.41666666666667
14360, 0.20833333333333, 0.5, 0.41666666666667
14361, 0.20833333333333, 0.55, 0.41666666666667
14362, 0.20833333333333, 0.6, 0.41666666666667
14363, 0.20833333333333, 0.65, 0.41666666666667
14364, 0.20833333333333, 0.7, 0.41666666666667
14365, 0.20833333333333, 0.75, 0.41666666666667
14366, 0.20833333333333, 0.8, 0.41666666666667
14367, 0.20833333333333, 0.85, 0.41666666666667
14368, 0.20833333333333, 0.9, 0.41666666666667
14369, 0.20833333333333, 0.95, 0.41666666666667
14370, 0.20833333333333, 1, 0.41666666666667
14371, 0.20833333333333, 1.05, 0.41666666666667
14372, 0.20833333333333, 1.1, 0.41666666666667
14373, 0.20833333333333, 1.15, 0.41666666666667
14374, 0.20833333333333, 1.2, 0.41666666666667
14375, 0.20833333333333, 1.25, 0.41666666666667
14376, 0.20833333333333, 1.3, 0.41666666666667
14377, 0.20833333333333, 0.2, 0.45833333333333
14378, 0.20833333333333, 0.25, 0.45833333333333
14379, 0.20833333333333, 0.3, 0.45833333333333
14380, 0.20833333333333, 0.35, 0.45833333333333
14381, 0.20833333333333, 0.4, 0.45833333333333
14382, 0.20833333333333, 0.45, 0.45833333333333
14383, 0.20833333333333, 0.5, 0.45833333333333
14384, 0.20833333333333, 0.55, 0.45833333333333
14385, 0.20833333333333, 0.6, 0.45833333333333
14386, 0.20833333333333, 0.65, 0.45833333333333
14387, 0.20833333333333, 0.7, 0.45833333333333
14388, 0.20833333333333, 0.75, 0.45833333333333
14389, 0.20833333333333, 0.8, 0.45833333333333
14390, 0.20833333333333, 0.85, 0.45833333333333
14391, 0.20833333333333, 0.9, 0.45833333333333
14392, 0.20833333333333, 0.95, 0.45833333333333
14393, 0.20833333333333, 1, 0.45833333333333
14394, 0.20833333333333, 1.05, 0.45833333333333
14395, 0.20833333333333, 1.1, 0.45833333333333
14396, 0.20833333333333, 1.15, 0.45833333333333
14397, 0.20833333333333, 1.2, 0.45833333333333
14398, 0.20833333333333, 1.25, 0.45833333333333
14399, 0.20833333333333, 1.3, 0.45833333333333
14400, 0.25, 0.2, 0.041666666666667
14401, 0.25, 0.25, 0.041666666666667
14402, 0.25, 0.3, 0.041666666666667
14403, 0.25, 0.35, 0.041666666666667
14404, 0.25, 0.4, 0.041666666666667
14405, 0.25, 0.45, 0.041666666666667
14406, 0.25, 0.5, 0.041666666666667
14407, 0.25, 0.55, 0.041666666666667
14408, 0.25, 0.6, 0.041666666666667
14409, 0.25, 0.65, 0.041666666666667
14410, 0.25, 0.7, 0.041666666666667
14411, 0.25, 0.75, 0.041666666666667
14412, 0.25, 0.8, 0.041666666666667
14413, 0.25, 0.85, 0.041666666666667
14414, 0.25, 0.9, 0.041666666666667
14415, 0.25, 0.95, 0.041666666666667
14416, 0.25, 1, 0.041666666666667
14417, 0.25, 1.05, 0.041666666666667
14418, 0.25, 1.1, 0.041666666666667
14419, 0.25, 1.15, 0.041666666666667
14420, 0.25, 1.2, 0.041666666666667
14421, 0.25, 1.25, 0.041666666666667
14422, 0.25, 1.3, 0.041666666666667
14423, 0.25, 0.2, 0.083333333333333
14424, 0.25, 0.25, 0.083333333333333
14425, 0.25, 0.3, 0.083333333333333
14426, 0.25, 0.35, 0.083333333333333
14427, 0.25, 0.4, 0.083333333333333
14428, 0.25, 0.45, 0.083333333333333
14429, 0.25, 0.5, 0.083333333333333
14430, 0.25, 0.55, 0.083333333333333
14431, 0.25, 0.6, 0.083333333333333
14432, 0.25, 0.65, 0.083333333333333
14433, 0.25, 0.7, 0.083333333333333
14434, 0.25, 0.75, 0.083333333333333
14435, 0.25, 0.8, 0.083333333333333
14436, 0.25, 0.85, 0.083333333333333
14437, 0.25, 0.9, 0.083333333333333
14438, 0.25, 0.95, 0.083333333333333
14439, 0.25, 1, 0.083333333333333
14440, 0.25, 1.05, 0.083333333333333
14441, 0.25, 1.1, 0.083333333333333
14442, 0.25, 1.15, 0.083333333333333
14443, 0.25, 1.2, 0.083333333333333
14444, 0.25, 1.25, 0.083333333333333
14445, 0.25, 1.3, 0.083333333333333
14446, 0.25, 0.2, 0.125
14447, 0.25, 0.25, 0.125
14448, 0.25, 0.3, 0.125
14449, 0.25, 0.35, 0.125
14450, 0.25, 0.4, 0.125
14451, 0.25, 0.45, 0.125
14452, 0.25, 0.5, 0.125
14453, 0.25, 0.55, 0.125
14454, 0.25, 0.6, 0.125
14455, 0.25, 0.65, 0.125
14456, 0.25, 0.7, 0.125
14457, 0.25, 0.75, 0.125
14458, 0.25, 0.8, 0.125
14459, 0.25, 0.85, 0.125
14460, 0.25, 0.9, 0.125
14461, 0.25, 0.95, 0.125
14462, 0.25, 1, 0.125
14463, 0.25, 1.05, 0.125
14464, 0.25, 1.1, 0.125
14465, 0.25, 1.15, 0.125
14466, 0.25, 1.2, 0.125
14467, 0.25, 1.25, 0.125
14468, 0.25, 1.3, 0.125
14469, 0.25, 0.2, 0.16666666666667
14470, 0.25, 0.25, 0.16666666666667
14471, 0.25, 0.3, 0.16666666666667
14472, 0.25, 0.35, 0.16666666666667
14473, 0.25, 0.4, 0.16666666666667
14474, 0.25, 0.45, 0.16666666666667
14475, 0.25, 0.5, 0.16666666666667
14476, 0.25, 0.55, 0.16666666666667
14477, 0.25, 0.6, 0.16666666666667
14478, 0.25, 0.65, 0.16666666666667
14479, 0.25, 0.7, 0.16666666666667
14480, 0.25, 0.75, 0.16666666666667
14481, 0.25, 0.8, 0.16666666666667
14482, 0.25, 0.85, 0.16666666666667
14483, 0.25, 0.9, 0.16666666666667
14484, 0.25, 0.95, 0.16666666666667
14485, 0.25, 1, 0.16666666666667
14486, 0.25, 1.05, 0.16666666666667
14487, 0.25, 1.1, 0.16666666666667
14488, 0.25, 1.15, 0.16666666666667
14489, 0.25, 1.2, 0.16666666666667
14490, 0.25, 1.25, 0.16666666666667
14491, 0.25, 1.3, 0.16666666666667
14492, 0.25, 0.2, 0.20833333333333
14493, 0.25, 0.25, 0.20833333333333
14494, 0.25, 0.3, 0.20833333333333
14495, 0.25, 0.35, 0.20833333333333
14496, 0.25, 0.4, 0.20833333333333
14497, 0.25, 0.45, 0.20833333333333
14498, 0.25, 0.5, 0.20833333333333
14499, 0.25, 0.55, 0.20833333333333
14500, 0.25, 0.6, 0.20833333333333
14501, 0.25, 0.65, 0.20833333333333
14502, 0.25, 0.7, 0.20833333333333
14503, 0.25, 0.75, 0.20833333333333
14504, 0.25, 0.8, 0.20833333333333
14505, 0.25, 0.85, 0.20833333333333
14506, 0.25, 0.9, 0.20833333333333
14507, 0.25, 0.95, 0.20833333333333
14508, 0.25, 1, 0.20833333333333
14509, 0.25, 1.05, 0.20833333333333
14510, 0.25, 1.1, 0.20833333333333
14511, 0.25, 1.15, 0.20833333333333
14512, 0.25, 1.2, 0.20833333333333
14513, 0.25, 1.25, 0.20833333333333
14514, 0.25, 1.3, 0.20833333333333
14515, 0.25, 0.2, 0.25
14516, 0.25, 0.25, 0.25
14517, 0.25, 0.3, 0.25
14518, 0.25, 0.35, 0.25
14519, 0.25, 0.4, 0.25
14520, 0.25, 0.45, 0.25
14521, 0.25, 0.5, 0.25
14522, 0.25, 0.55, 0.25
14523, 0.25, 0.6, 0.25
14524, 0.25, 0.65, 0.25
14525, 0.25, 0.7, 0.25
14526, 0.25, 0.75, 0.25
14527, 0.25, 0.8, 0.25
14528, 0.25, 0.85, 0.25
14529, 0.25, 0.9, 0.25
14530, 0.25, 0.95, 0.25
14531, 0.25, 1, 0.25
14532, 0.25, 1.05, 0.25
14533, 0.25, 1.1, 0.25
14534, 0.25, 1.15, 0.25
14535, 0.25, 1.2, 0.25
14536, 0.25, 1.25, 0.25
14537, 0.25, 1.3, 0.25
14538, 0.25, 0.2, 0.29166666666667
14539, 0.25, 0.25, 0.29166666666667
14540, 0.25, 0.3, 0.29166666666667
14541, 0.25, 0.35, 0.29166666666667
14542, 0.25, 0.4, 0.29166666666667
14543, 0.25, 0.45, 0.29166666666667
14544, 0.25, 0.5, 0.29166666666667
14545, 0.25, 0.55, 0.29166666666667
14546, 0.25, 0.6, 0.29166666666667
14547, 0.25, 0.65, 0.29166666666667
14548, 0.25, 0.7, 0.29166666666667
14549, 0.25, 0.75, 0.29166666666667
14550, 0.25, 0.8, 0.29166666666667
14551, 0.25, 0.85, 0.29166666666667
14552, 0.25, 0.9, 0.29166666666667
14553, 0.25, 0.95, 0.29166666666667
14554, 0.25, 1, 0.29166666666667
14555, 0.25, 1.05, 0.29166666666667
14556, 0.25, 1.1, 0.29166666666667
14557, 0.25, 1.15, 0.29166666666667
14558, 0.25, 1.2, 0.29166666666667
14559, 0.25, 1.25, 0.29166666666667
14560, 0.25, 1.3, 0.29166666666667
14561, 0.25, 0.2, 0.33333333333333
14562, 0.25, 0.25, 0.33333333333333
14563, 0.25, 0.3, 0.33333333333333
14564, 0.25, 0.35, 0.33333333333333
14565, 0.25, 0.4, 0.33333333333333
14566, 0.25, 0.45, 0.33333333333333
14567, 0.25, 0.5, 0.33333333333333
14568, 0.25, 0.55, 0.33333333333333
14569, 0.25, 0.6, 0.33333333333333
14570, 0.25, 0.65, 0.33333333333333
14571, 0.25, 0.7, 0.33333333333333
14572, 0.25, 0.75, 0.33333333333333
14573, 0.25, 0.8, 0.33333333333333
14574, 0.25, 0.85, 0.33333333333333
14575, 0.25, 0.9, 0.33333333333333
14576, 0.25, 0.95, 0.33333333333333
14577, 0.25, 1, 0.33333333333333
14578, 0.25, 1.05, 0.33333333333333
14579, 0.25, 1.1, 0.33333333333333
14580, 0.25, 1.15, 0.33333333333333
14581, 0.25, 1.2, 0.33333333333333
14582, 0.25, 1.25, 0.33333333333333
14583, 0.25, 1.3, 0.33333333333333
14584, 0.25, 0.2, 0.375
14585, 0.25, 0.25, 0.375
14586, 0.25, 0.3, 0.375
14587, 0.25, 0.35, 0.375
14588, 0.25, 0.4, 0.375
14589, 0.25, 0.45, 0.375
14590, 0.25, 0.5, 0.375
14591, 0.25, 0.55, 0.375
14592, 0.25, 0.6, 0.375
14593, 0.25, 0.65, 0.375
14594, 0.25, 0.7, 0.375
14595, 0.25, 0.75, 0.375
14596, 0.25, 0.8, 0.375
14597, 0.25, 0.85, 0.375
14598, 0.25, 0.9, 0.375
14599, 0.25, 0.95, 0.375
14600, 0.25, 1, 0.375
14601, 0.25, 1.05, 0.375
14602, 0.25, 1.1, 0.375
14603, 0.25, 1.15, 0.375
14604, 0.25, 1.2, 0.375
14605, 0.25, 1.25, 0.375
14606, 0.25, 1.3, 0.375
14607, 0.25, 0.2, 0.41666666666667
14608, 0.25, 0.25, 0.41666666666667
14609, 0.25, 0.3, 0.41666666666667
14610, 0.25, 0.35, 0.41666666666667
14611, 0.25, 0.4, 0.41666666666667
14612, 0.25, 0.45, 0.41666666666667
14613, 0.25, 0.5, 0.41666666666667
14614, 0.25, 0.55, 0.41666666666667
14615, 0.25, 0.6, 0.41666666666667
14616, 0.25, 0.65, 0.41666666666667
14617, 0.25, 0.7, 0.41666666666667
14618, 0.25, 0.75, 0.41666666666667
14619, 0.25, 0.8, 0.41666666666667
14620, 0.25, 0.85, 0.41666666666667
14621, 0.25, 0.9, 0.41666666666667
14622, 0.25, 0.95, 0.41666666666667
14623, 0.25, 1, 0.41666666666667
14624, 0.25, 1.05, 0.41666666666667
14625, 0.25, 1.1, 0.41666666666667
14626, 0.25, 1.15, 0.41666666666667
14627, 0.25, 1.2, 0.41666666666667
14628, 0.25, 1.25, 0.41666666666667
14629, 0.25, 1.3, 0.41666666666667
14630, 0.25, 0.2, 0.45833333333333
14631, 0.25, 0.25, 0.45833333333333
14632, 0.25, 0.3, 0.45833333333333
14633, 0.25, 0.35, 0.45833333333333
14634, 0.25, 0.4, 0.45833333333333
14635, 0.25, 0.45, 0.45833333333333
14636, 0.25, 0.5, 0.45833333333333
14637, 0.25, 0.55, 0.45833333333333
14638, 0.25, 0.6, 0.45833333333333
14639, 0.25, 0.65, 0.45833333333333
14640, 0.25, 0.7, 0.45833333333333
14641, 0.25, 0.75, 0.45833333333333
14642, 0.25, 0.8, 0.45833333333333
14643, 0.25, 0.85, 0.45833333333333
14644, 0.25, 0.9, 0.45833333333333
14645, 0.25, 0.95, 0.45833333333333
14646, 0.25, 1, 0.45833333333333
14647, 0.25, 1.05, 0.45833333333333
14648, 0.25, 1.1, 0.45833333333333
14649, 0.25, 1.15, 0.45833333333333
14650, 0.25, 1.2, 0.45833333333333
14651, 0.25, 1.25, 0.45833333333333
14652, 0.25, 1.3, 0.45833333333333
14653, 0.29166666666667, 0.2, 0.041666666666667
14654, 0.29166666666667, 0.25, 0.041666666666667
14655, 0.29166666666667, 0.3, 0.041666666666667
14656, 0.29166666666667, 0.35, 0.041666666666667
14657, 0.29166666666667, 0.4, 0.041666666666667
14658, 0.29166666666667, 0.45, 0.041666666666667
14659, 0.29166666666667, 0.5, 0.041666666666667
14660, 0.29166666666667, 0.55, 0.041666666666667
14661, 0.29166666666667, 0.6, 0.041666666666667
14662, 0.29166666666667, 0.65, 0.041666666666667
14663, 0.29166666666667, 0.7, 0.041666666666667
14664, 0.29166666666667, 0.75, 0.041666666666667
14665, 0.29166666666667, 0.8, 0.041666666666667
14666, 0.29166666666667, 0.85, 0.041666666666667
14667, 0.29166666666667, 0.9, 0.041666666666667
14668, 0.29166666666667, 0.95, 0.041666666666667
14669, 0.29166666666667, 1, 0.041666666666667
14670, 0.29166666666667, 1.05, 0.041666666666667
14671, 0.29166666666667, 1.1, 0.041666666666667
14672, 0.29166666666667, 1.15, 0.041666666666667
14673, 0.29166666666667, 1.2, 0.041666666666667
14674, 0.29166666666667, 1.25, 0.041666666666667
14675, 0.29166666666667, 1.3, 0.041666666666667
14676, 0.29166666666667, 0.2, 0.083333333333333
14677, 0.29166666666667, 0.25, 0.083333333333333
14678, 0.29166666666667, 0.3, 0.083333333333333
14679, 0.29166666666667, 0.35, 0.083333333333333
14680, 0.29166666666667, 0.4, 0.083333333333333
14681, 0.29166666666667, 0.45, 0.083333333333333
14682, 0.29166666666667, 0.5, 0.083333333333333
14683, 0.29166666666667, 0.55, 0.083333333333333
14684, 0.29166666666667, 0.6, 0.083333333333333
14685, 0.29166666666667, 0.65, 0.083333333333333
14686, 0.29166666666667, 0.7, 0.083333333333333
14687, 0.29166666666667, 0.75, 0.083333333333333
14688, 0.29166666666667, 0.8, 0.083333333333333
14689, 0.29166666666667, 0.85, 0.083333333333333
14690, 0.29166666666667, 0.9, 0.083333333333333
14691, 0.29166666666667, 0.95, 0.083333333333333
14692, 0.29166666666667, 1, 0.083333333333333
14693, 0.29166666666667, 1.05, 0.083333333333333
14694, 0.29166666666667, 1.1, 0.083333333333333
14695, 0.29166666666667, 1.15, 0.083333333333333
14696, 0.29166666666667, 1.2, 0.083333333333333
14697, 0.29166666666667, 1.25, 0.083333333333333
14698, 0.29166666666667, 1.3, 0.083333333333333
14699, 0.29166666666667, 0.2, 0.125
14700, 0.29166666666667, 0.25, 0.125
14701, 0.29166666666667, 0.3, 0.125
14702, 0.29166666666667, 0.35, 0.125
14703, 0.29166666666667, 0.4, 0.125
14704, 0.29166666666667, 0.45, 0.125
14705, 0.29166666666667, 0.5, 0.125
14706, 0.29166666666667, 0.55, 0.125
14707, 0.29166666666667, 0.6, 0.125
14708, 0.29166666666667, 0.65, 0.125
14709, 0.29166666666667, 0.7, 0.125
14710, 0.29166666666667, 0.75, 0.125
14711, 0.29166666666667, 0.8, 0.125
14712, 0.29166666666667, 0.85, 0.125
14713, 0.29166666666667, 0.9, 0.125
14714, 0.29166666666667, 0.95, 0.125
14715, 0.29166666666667, 1, 0.125
14716, 0.29166666666667, 1.05, 0.125
14717, 0.29166666666667, 1.1, 0.125
14718, 0.29166666666667, 1.15, 0.125
14719, 0.29166666666667, 1.2, 0.125
14720, 0.29166666666667, 1.25, 0.125
14721, 0.29166666666667, 1.3, 0.125
14722, 0.29166666666667, 0.2, 0.16666666666667
14723, 0.29166666666667, 0.25, 0.16666666666667
14724, 0.29166666666667, 0.3, 0.16666666666667
14725, 0.29166666666667, 0.35, 0.16666666666667
14726, 0.29166666666667, 0.4, 0.16666666666667
14727, 0.29166666666667, 0.45, 0.16666666666667
14728, 0.29166666666667, 0.5, 0.16666666666667
14729, 0.29166666666667, 0.55, 0.16666666666667
14730, 0.29166666666667, 0.6, 0.16666666666667
14731, 0.29166666666667, 0.65, 0.16666666666667
14732, 0.29166666666667, 0.7, 0.16666666666667
14733, 0.29166666666667, 0.75, 0.16666666666667
14734, 0.29166666666667, 0.8, 0.16666666666667
14735, 0.29166666666667, 0.85, 0.16666666666667
14736, 0.29166666666667, 0.9, 0.16666666666667
14737, 0.29166666666667, 0.95, 0.16666666666667
14738, 0.29166666666667, 1, 0.16666666666667
14739, 0.29166666666667, 1.05, 0.16666666666667
14740, 0.29166666666667, 1.1, 0.16666666666667
14741, 0.29166666666667, 1.15, 0.16666666666667
14742, 0.29166666666667, 1.2, 0.16666666666667
14743, 0.29166666666667, 1.25, 0.16666666666667
14744, 0.29166666666667, 1.3, 0.16666666666667
14745, 0.29166666666667, 0.2, 0.20833333333333
14746, 0.29166666666667, 0.25, 0.20833333333333
14747, 0.29166666666667, 0.3, 0.20833333333333
14748, 0.29166666666667, 0.35, 0.20833333333333
14749, 0.29166666666667, 0.4, 0.20833333333333
14750, 0.29166666666667, 0.45, 0.20833333333333
14751, 0.29166666666667, 0.5, 0.20833333333333
14752, 0.29166666666667, 0.55, 0.20833333333333
14753, 0.29166666666667, 0.6, 0.20833333333333
14754, 0.29166666666667, 0.65, 0.20833333333333
14755, 0.29166666666667, 0.7, 0.20833333333333
14756, 0.29166666666667, 0.75, 0.20833333333333
14757, 0.29166666666667, 0.8, 0.20833333333333
14758, 0.29166666666667, 0.85, 0.20833333333333
14759, 0.29166666666667, 0.9, 0.20833333333333
14760, 0.29166666666667, 0.95, 0.20833333333333
14761, 0.29166666666667, 1, 0.20833333333333
14762, 0.29166666666667, 1.05, 0.20833333333333
14763, 0.29166666666667, 1.1, 0.20833333333333
14764, 0.29166666666667, 1.15, 0.20833333333333
14765, 0.29166666666667, 1.2, 0.20833333333333
14766, 0.29166666666667, 1.25, 0.20833333333333
14767, 0.29166666666667, 1.3, 0.20833333333333
14768, 0.29166666666667, 0.2, 0.25
14769, 0.29166666666667, 0.25, 0.25
14770, 0.29166666666667, 0.3, 0.25
14771, 0.29166666666667, 0.35, 0.25
14772, 0.29166666666667, 0.4, 0.25
14773, 0.29166666666667, 0.45, 0.25
14774, 0.29166666666667, 0.5, 0.25
14775, 0.29166666666667, 0.55, 0.25
14776, 0.29166666666667, 0.6, 0.25
14777, 0.29166666666667, 0.65, 0.25
14778, 0.29166666666667, 0.7, 0.25
14779, 0.29166666666667, 0.75, 0.25
14780, 0.29166666666667, 0.8, 0.25
14781, 0.29166666666667, 0.85, 0.25
14782, 0.29166666666667, 0.9, 0.25
14783, 0.29166666666667, 0.95, 0.25
14784, 0.29166666666667, 1, 0.25
14785, 0.29166666666667, 1.05, 0.25
14786, 0.29166666666667, 1.1, 0.25
14787, 0.29166666666667, 1.15, 0.25
14788, 0.29166666666667, 1.2, 0.25
14789, 0.29166666666667, 1.25, 0.25
14790, 0.29166666666667, 1.3, 0.25
14791, 0.29166666666667, 0.2, 0.29166666666667
14792, 0.29166666666667, 0.25, 0.29166666666667
14793, 0.29166666666667, 0.3, 0.29166666666667
14794, 0.29166666666667, 0.35, 0.29166666666667
14795, 0.29166666666667, 0.4, 0.29166666666667
14796, 0.29166666666667, 0.45, 0.29166666666667
14797, 0.29166666666667, 0.5, 0.29166666666667
14798, 0.29166666666667, 0.55, 0.29166666666667
14799, 0.29166666666667, 0.6, 0.29166666666667
14800, 0.29166666666667, 0.65, 0.29166666666667
14801, 0.29166666666667, 0.7, 0.29166666666667
14802, 0.29166666666667, 0.75, 0.29166666666667
14803, 0.29166666666667, 0.8, 0.29166666666667
14804, 0.29166666666667, 0.85, 0.29166666666667
14805, 0.29166666666667, 0.9, 0.29166666666667
14806, 0.29166666666667, 0.95, 0.29166666666667
14807, 0.29166666666667, 1, 0.29166666666667
14808, 0.29166666666667, 1.05, 0.29166666666667
14809, 0.29166666666667, 1.1, 0.29166666666667
14810, 0.29166666666667, 1.15, 0.29166666666667
14811, 0.29166666666667, 1.2, 0.29166666666667
14812, 0.29166666666667, 1.25, 0.29166666666667
14813, 0.29166666666667, 1.3, 0.29166666666667
14814, 0.29166666666667, 0.2, 0.33333333333333
14815, 0.29166666666667, 0.25, 0.33333333333333
14816, 0.29166666666667, 0.3, 0.33333333333333
14817, 0.29166666666667, 0.35, 0.33333333333333
14818, 0.29166666666667, 0.4, 0.33333333333333
14819, 0.29166666666667, 0.45, 0.33333333333333
14820, 0.29166666666667, 0.5, 0.33333333333333
14821, 0.29166666666667, 0.55, 0.33333333333333
14822, 0.29166666666667, 0.6, 0.33333333333333
14823, 0.29166666666667, 0.65, 0.33333333333333
14824, 0.29166666666667, 0.7, 0.33333333333333
14825, 0.29166666666667, 0.75, 0.33333333333333
14826, 0.29166666666667, 0.8, 0.33333333333333
14827, 0.29166666666667, 0.85, 0.33333333333333
14828, 0.29166666666667, 0.9, 0.33333333333333
14829, 0.29166666666667, 0.95, 0.33333333333333
14830, 0.29166666666667, 1, 0.33333333333333
14831, 0.29166666666667, 1.05, 0.33333333333333
14832, 0.29166666666667, 1.1, 0.33333333333333
14833, 0.29166666666667, 1.15, 0.33333333333333
14834, 0.29166666666667, 1.2, 0.33333333333333
14835, 0.29166666666667, 1.25, 0.33333333333333
14836, 0.29166666666667, 1.3, 0.33333333333333
14837, 0.29166666666667, 0.2, 0.375
14838, 0.29166666666667, 0.25, 0.375
14839, 0.29166666666667, 0.3, 0.375
14840, 0.29166666666667, 0.35, 0.375
14841, 0.29166666666667, 0.4, 0.375
14842, 0.29166666666667, 0.45, 0.375
14843, 0.29166666666667, 0.5, 0.375
14844, 0.29166666666667, 0.55, 0.375
14845, 0.29166666666667, 0.6, 0.375
14846, 0.29166666666667, 0.65, 0.375
14847, 0.29166666666667, 0.7, 0.375
14848, 0.29166666666667, 0.75, 0.375
14849, 0.29166666666667, 0.8, 0.375
14850, 0.29166666666667, 0.85, 0.375
14851, 0.29166666666667, 0.9, 0.375
14852, 0.29166666666667, 0.95, 0.375
14853, 0.29166666666667, 1, 0.375
14854, 0.29166666666667, 1.05, 0.375
14855, 0.29166666666667, 1.1, 0.375
14856, 0.29166666666667, 1.15, 0.375
14857, 0.29166666666667, 1.2, 0.375
14858, 0.29166666666667, 1.25, 0.375
14859, 0.29166666666667, 1.3, 0.375
14860, 0.29166666666667, 0.2, 0.41666666666667
14861, 0.29166666666667, 0.25, 0.41666666666667
14862, 0.29166666666667, 0.3, 0.41666666666667
14863, 0.29166666666667, 0.35, 0.41666666666667
14864, 0.29166666666667, 0.4, 0.41666666666667
14865, 0.29166666666667, 0.45, 0.41666666666667
14866, 0.29166666666667, 0.5, 0.41666666666667
14867, 0.29166666666667, 0.55, 0.41666666666667
14868, 0.29166666666667, 0.6, 0.41666666666667
14869, 0.29166666666667, 0.65, 0.41666666666667
14870, 0.29166666666667, 0.7, 0.41666666666667
14871, 0.29166666666667, 0.75, 0.41666666666667
14872, 0.29166666666667, 0.8, 0.41666666666667
14873, 0.29166666666667, 0.85, 0.41666666666667
14874, 0.29166666666667, 0.9, 0.41666666666667
14875, 0.29166666666667, 0.95, 0.41666666666667
14876, 0.29166666666667, 1, 0.41666666666667
14877, 0.29166666666667, 1.05, 0.41666666666667
14878, 0.29166666666667, 1.1, 0.41666666666667
14879, 0.29166666666667, 1.15, 0.41666666666667
14880, 0.29166666666667, 1.2, 0.41666666666667
14881, 0.29166666666667, 1.25, 0.41666666666667
14882, 0.29166666666667, 1.3, 0.41666666666667
14883, 0.29166666666667, 0.2, 0.45833333333333
14884, 0.29166666666667, 0.25, 0.45833333333333
14885, 0.29166666666667, 0.3, 0.45833333333333
14886, 0.29166666666667, 0.35, 0.45833333333333
14887, 0.29166666666667, 0.4, 0.45833333333333
14888, 0.29166666666667, 0.45, 0.45833333333333
14889, 0.29166666666667, 0.5, 0.45833333333333
14890, 0.29166666666667, 0.55, 0.45833333333333
14891, 0.29166666666667, 0.6, 0.45833333333333
14892, 0.29166666666667, 0.65, 0.45833333333333
14893, 0.29166666666667, 0.7, 0.45833333333333
14894, 0.29166666666667, 0.75, 0.45833333333333
14895, 0.29166666666667, 0.8, 0.45833333333333
14896, 0.29166666666667, 0.85, 0.45833333333333
14897, 0.29166666666667, 0.9, 0.45833333333333
14898, 0.29166666666667, 0.95, 0.45833333333333
14899, 0.29166666666667, 1, 0.45833333333333
14900, 0.29166666666667, 1.05, 0.45833333333333
14901, 0.29166666666667, 1.1, 0.45833333333333
14902, 0.29166666666667, 1.15, 0.45833333333333
14903, 0.29166666666667, 1.2, 0.45833333333333
14904, 0.29166666666667, 1.25, 0.45833333333333
14905, 0.29166666666667, 1.3, 0.45833333333333
14906, 0.33333333333333, 0.2, 0.041666666666667
14907, 0.33333333333333, 0.25, 0.041666666666667
14908, 0.33333333333333, 0.3, 0.041666666666667
14909, 0.33333333333333, 0.35, 0.041666666666667
14910, 0.33333333333333, 0.4, 0.041666666666667
14911, 0.33333333333333, 0.45, 0.041666666666667
14912, 0.33333333333333, 0.5, 0.041666666666667
14913, 0.33333333333333, 0.55, 0.041666666666667
14914, 0.33333333333333, 0.6, 0.041666666666667
14915, 0.33333333333333, 0.65, 0.041666666666667
14916, 0.33333333333333, 0.7, 0.041666666666667
14917, 0.33333333333333, 0.75, 0.041666666666667
14918, 0.33333333333333, 0.8, 0.041666666666667
14919, 0.33333333333333, 0.85, 0.041666666666667
14920, 0.33333333333333, 0.9, 0.041666666666667
14921, 0.33333333333333, 0.95, 0.041666666666667
14922, 0.33333333333333, 1, 0.041666666666667
14923, 0.33333333333333, 1.05, 0.041666666666667
14924, 0.33333333333333, 1.1, 0.041666666666667
14925, 0.33333333333333, 1.15, 0.041666666666667
14926, 0.33333333333333, 1.2, 0.041666666666667
14927, 0.33333333333333, 1.25, 0.041666666666667
14928, 0.33333333333333, 1.3, 0.041666666666667
14929, 0.33333333333333, 0.2, 0.083333333333333
14930, 0.33333333333333, 0.25, 0.083333333333333
14931, 0.33333333333333, 0.3, 0.083333333333333
14932, 0.33333333333333, 0.35, 0.083333333333333
14933, 0.33333333333333, 0.4, 0.083333333333333
14934, 0.33333333333333, 0.45, 0.083333333333333
14935, 0.33333333333333, 0.5, 0.083333333333333
14936, 0.33333333333333, 0.55, 0.083333333333333
14937, 0.33333333333333, 0.6, 0.083333333333333
14938, 0.33333333333333, 0.65, 0.083333333333333
14939, 0.33333333333333, 0.7, 0.083333333333333
14940, 0.33333333333333, 0.75, 0.083333333333333
14941, 0.33333333333333, 0.8, 0.083333333333333
14942, 0.33333333333333, 0.85, 0.083333333333333
14943, 0.33333333333333, 0.9, 0.083333333333333
14944, 0.33333333333333, 0.95, 0.083333333333333
14945, 0.33333333333333, 1, 0.083333333333333
14946, 0.33333333333333, 1.05, 0.083333333333333
14947, 0.33333333333333, 1.1, 0.083333333333333
14948, 0.33333333333333, 1.15, 0.083333333333333
14949, 0.33333333333333, 1.2, 0.083333333333333
14950, 0.33333333333333, 1.25, 0.083333333333333
14951, 0.33333333333333, 1.3, 0.083333333333333
14952, 0.33333333333333, 0.2, 0.125
14953, 0.33333333333333, 0.25, 0.125
14954, 0.33333333333333, 0.3, 0.125
14955, 0.33333333333333, 0.35, 0.125
14956, 0.33333333333333, 0.4, 0.125
14957, 0.33333333333333, 0.45, 0.125
14958, 0.33333333333333, 0.5, 0.125
14959, 0.33333333333333, 0.55, 0.125
14960, 0.33333333333333, 0.6, 0.125
14961, 0.33333333333333, 0.65, 0.125
14962, 0.33333333333333, 0.7, 0.125
14963, 0.33333333333333, 0.75, 0.125
14964, 0.33333333333333, 0.8, 0.125
14965, 0.33333333333333, 0.85, 0.125
14966, 0.33333333333333, 0.9, 0.125
14967, 0.33333333333333, 0.95, 0.125
14968, 0.33333333333333, 1, 0.125
14969, 0.33333333333333, 1.05, 0.125
14970, 0.33333333333333, 1.1, 0.125
14971, 0.33333333333333, 1.15, 0.125
14972, 0.33333333333333, 1.2, 0.125
14973, 0.33333333333333, 1.25, 0.125
14974, 0.33333333333333, 1.3, 0.125
14975, 0.33333333333333, 0.2, 0.16666666666667
14976, 0.33333333333333, 0.25, 0.16666666666667
14977, 0.33333333333333, 0.3, 0.16666666666667
14978, 0.33333333333333, 0.35, 0.16666666666667
14979, 0.33333333333333, 0.4, 0.16666666666667
14980, 0.33333333333333, 0.45, 0.16666666666667
14981, 0.33333333333333, 0.5, 0.16666666666667
14982, 0.33333333333333, 0.55, 0.16666666666667
14983, 0.33333333333333, 0.6, 0.16666666666667
14984, 0.33333333333333, 0.65, 0.16666666666667
14985, 0.33333333333333, 0.7, 0.16666666666667
14986, 0.33333333333333, 0.75, 0.16666666666667
14987, 0.33333333333333, 0.8, 0.16666666666667
14988, 0.33333333333333, 0.85, 0.16666666666667
14989, 0.33333333333333, 0.9, 0.16666666666667
14990, 0.33333333333333, 0.95, 0.16666666666667
14991, 0.33333333333333, 1, 0.16666666666667
14992, 0.33333333333333, 1.05, 0.16666666666667
14993, 0.33333333333333, 1.1, 0.16666666666667
14994, 0.33333333333333, 1.15, 0.16666666666667
14995, 0.33333333333333, 1.2, 0.16666666666667
14996, 0.33333333333333, 1.25, 0.16666666666667
14997, 0.33333333333333, 1.3, 0.16666666666667
14998, 0.33333333333333, 0.2, 0.20833333333333
14999, 0.33333333333333, 0.25, 0.20833333333333
15000, 0.33333333333333, 0.3, 0.20833333333333
15001, 0.33333333333333, 0.35, 0.20833333333333
15002, 0.33333333333333, 0.4, 0.20833333333333
15003, 0.33333333333333, 0.45, 0.20833333333333
15004, 0.33333333333333, 0.5, 0.20833333333333
15005, 0.33333333333333, 0.55, 0.20833333333333
15006, 0.33333333333333, 0.6, 0.20833333333333
15007, 0.33333333333333, 0.65, 0.20833333333333
15008, 0.33333333333333, 0.7, 0.20833333333333
15009, 0.33333333333333, 0.75, 0.20833333333333
15010, 0.33333333333333, 0.8, 0.20833333333333
15011, 0.33333333333333, 0.85, 0.20833333333333
15012, 0.33333333333333, 0.9, 0.20833333333333
15013, 0.33333333333333, 0.95, 0.20833333333333
15014, 0.33333333333333, 1, 0.20833333333333
15015, 0.33333333333333, 1.05, 0.20833333333333
15016, 0.33333333333333, 1.1, 0.20833333333333
15017, 0.33333333333333, 1.15, 0.20833333333333
15018, 0.33333333333333, 1.2, 0.20833333333333
15019, 0.33333333333333, 1.25, 0.20833333333333
15020, 0.33333333333333, 1.3, 0.20833333333333
15021, 0.33333333333333, 0.2, 0.25
15022, 0.33333333333333, 0.25, 0.25
15023, 0.33333333333333, 0.3, 0.25
15024, 0.33333333333333, 0.35, 0.25
15025, 0.33333333333333, 0.4, 0.25
15026, 0.33333333333333, 0.45, 0.25
15027, 0.33333333333333, 0.5, 0.25
15028, 0.33333333333333, 0.55, 0.25
15029, 0.33333333333333, 0.6, 0.25
15030, 0.33333333333333, 0.65, 0.25
15031, 0.33333333333333, 0.7, 0.25
15032, 0.33333333333333, 0.75, 0.25
15033, 0.33333333333333, 0.8, 0.25
15034, 0.33333333333333, 0.85, 0.25
15035, 0.33333333333333, 0.9, 0.25
15036, 0.33333333333333, 0.95, 0.25
15037, 0.33333333333333, 1, 0.25
15038, 0.33333333333333, 1.05, 0.25
15039, 0.33333333333333, 1.1, 0.25
15040, 0.33333333333333, 1.15, 0.25
15041, 0.33333333333333, 1.2, 0.25
15042, 0.33333333333333, 1.25, 0.25
15043, 0.33333333333333, 1.3, 0.25
15044, 0.33333333333333, 0.2, 0.29166666666667
15045, 0.33333333333333, 0.25, 0.29166666666667
15046, 0.33333333333333, 0.3, 0.29166666666667
15047, 0.33333333333333, 0.35, 0.29166666666667
15048, 0.33333333333333, 0.4, 0.29166666666667
15049, 0.33333333333333, 0.45, 0.29166666666667
15050, 0.33333333333333, 0.5, 0.29166666666667
15051, 0.33333333333333, 0.55, 0.29166666666667
15052, 0.33333333333333, 0.6, 0.29166666666667
15053, 0.33333333333333, 0.65, 0.29166666666667
15054, 0.33333333333333, 0.7, 0.29166666666667
15055, 0.33333333333333, 0.75, 0.29166666666667
15056, 0.33333333333333, 0.8, 0.29166666666667
15057, 0.33333333333333, 0.85, 0.29166666666667
15058, 0.33333333333333, 0.9, 0.29166666666667
15059, 0.33333333333333, 0.95, 0.29166666666667
15060, 0.33333333333333, 1, 0.29166666666667
15061, 0.33333333333333, 1.05, 0.29166666666667
15062, 0.33333333333333, 1.1, 0.29166666666667
15063, 0.33333333333333, 1.15, 0.29166666666667
15064, 0.33333333333333, 1.2, 0.29166666666667
15065, 0.33333333333333, 1.25, 0.29166666666667
15066, 0.33333333333333, 1.3, 0.29166666666667
15067, 0.33333333333333, 0.2, 0.33333333333333
15068, 0.33333333333333, 0.25, 0.33333333333333
15069, 0.33333333333333, 0.3, 0.33333333333333
15070, 0.33333333333333, 0.35, 0.33333333333333
15071, 0.33333333333333, 0.4, 0.33333333333333
15072, 0.33333333333333, 0.45, 0.33333333333333
15073, 0.33333333333333, 0.5, 0.33333333333333
15074, 0.33333333333333, 0.55, 0.33333333333333
15075, 0.33333333333333, 0.6, 0.33333333333333
15076, 0.33333333333333, 0.65, 0.33333333333333
15077, 0.33333333333333, 0.7, 0.33333333333333
15078, 0.33333333333333, 0.75, 0.33333333333333
15079, 0.33333333333333, 0.8, 0.33333333333333
15080, 0.33333333333333, 0.85, 0.33333333333333
15081, 0.33333333333333, 0.9, 0.33333333333333
15082, 0.33333333333333, 0.95, 0.33333333333333
15083, 0.33333333333333, 1, 0.33333333333333
15084, 0.33333333333333, 1.05, 0.33333333333333
15085, 0.33333333333333, 1.1, 0.33333333333333
15086, 0.33333333333333, 1.15, 0.33333333333333
15087, 0.33333333333333, 1.2, 0.33333333333333
15088, 0.33333333333333, 1.25, 0.33333333333333
15089, 0.33333333333333, 1.3, 0.33333333333333
15090, 0.33333333333333, 0.2, 0.375
15091, 0.33333333333333, 0.25, 0.375
15092, 0.33333333333333, 0.3, 0.375
15093, 0.33333333333333, 0.35, 0.375
15094, 0.33333333333333, 0.4, 0.375
15095, 0.33333333333333, 0.45, 0.375
15096, 0.33333333333333, 0.5, 0.375
15097, 0.33333333333333, 0.55, 0.375
15098, 0.33333333333333, 0.6, 0.375
15099, 0.33333333333333, 0.65, 0.375
15100, 0.33333333333333, 0.7, 0.375
15101, 0.33333333333333, 0.75, 0.375
15102, 0.33333333333333, 0.8, 0.375
15103, 0.33333333333333, 0.85, 0.375
15104, 0.33333333333333, 0.9, 0.375
15105, 0.33333333333333, 0.95, 0.375
15106, 0.33333333333333, 1, 0.375
15107, 0.33333333333333, 1.05, 0.375
15108, 0.33333333333333, 1.1, 0.375
15109, 0.33333333333333, 1.15, 0.375
15110, 0.33333333333333, 1.2, 0.375
15111, 0.33333333333333, 1.25, 0.375
15112, 0.33333333333333, 1.3, 0.375
15113, 0.33333333333333, 0.2, 0.41666666666667
15114, 0.33333333333333, 0.25, 0.41666666666667
15115, 0.33333333333333, 0.3, 0.41666666666667
15116, 0.33333333333333, 0.35, 0.41666666666667
15117, 0.33333333333333, 0.4, 0.41666666666667
15118, 0.33333333333333, 0.45, 0.41666666666667
15119, 0.33333333333333, 0.5, 0.41666666666667
15120, 0.33333333333333, 0.55, 0.41666666666667
15121, 0.33333333333333, 0.6, 0.41666666666667
15122, 0.33333333333333, 0.65, 0.41666666666667
15123, 0.33333333333333, 0.7, 0.41666666666667
15124, 0.33333333333333, 0.75, 0.41666666666667
15125, 0.33333333333333, 0.8, 0.41666666666667
15126, 0.33333333333333, 0.85, 0.41666666666667
15127, 0.33333333333333, 0.9, 0.41666666666667
15128, 0.33333333333333, 0.95, 0.41666666666667
15129, 0.33333333333333, 1, 0.41666666666667
15130, 0.33333333333333, 1.05, 0.41666666666667
15131, 0.33333333333333, 1.1, 0.41666666666667
15132, 0.33333333333333, 1.15, 0.41666666666667
15133, 0.33333333333333, 1.2, 0.41666666666667
15134, 0.33333333333333, 1.25, 0.41666666666667
15135, 0.33333333333333, 1.3, 0.41666666666667
15136, 0.33333333333333, 0.2, 0.45833333333333
15137, 0.33333333333333, 0.25, 0.45833333333333
15138, 0.33333333333333, 0.3, 0.45833333333333
15139, 0.33333333333333, 0.35, 0.45833333333333
15140, 0.33333333333333, 0.4, 0.45833333333333
15141, 0.33333333333333, 0.45, 0.45833333333333
15142, 0.33333333333333, 0.5, 0.45833333333333
15143, 0.33333333333333, 0.55, 0.45833333333333
15144, 0.33333333333333, 0.6, 0.45833333333333
15145, 0.33333333333333, 0.65, 0.45833333333333
15146, 0.33333333333333, 0.7, 0.45833333333333
15147, 0.33333333333333, 0.75, 0.45833333333333
15148, 0.33333333333333, 0.8, 0.45833333333333
15149, 0.33333333333333, 0.85, 0.45833333333333
15150, 0.33333333333333, 0.9, 0.45833333333333
15151, 0.33333333333333, 0.95, 0.45833333333333
15152, 0.33333333333333, 1, 0.45833333333333
15153, 0.33333333333333, 1.05, 0.45833333333333
15154, 0.33333333333333, 1.1, 0.45833333333333
15155, 0.33333333333333, 1.15, 0.45833333333333
15156, 0.33333333333333, 1.2, 0.45833333333333
15157, 0.33333333333333, 1.25, 0.45833333333333
15158, 0.33333333333333, 1.3, 0.45833333333333
15159, 0.375, 0.2, 0.041666666666667
15160, 0.375, 0.25, 0.041666666666667
15161, 0.375, 0.3, 0.041666666666667
15162, 0.375, 0.35, 0.041666666666667
15163, 0.375, 0.4, 0.041666666666667
15164, 0.375, 0.45, 0.041666666666667
15165, 0.375, 0.5, 0.041666666666667
15166, 0.375, 0.55, 0.041666666666667
15167, 0.375, 0.6, 0.041666666666667
15168, 0.375, 0.65, 0.041666666666667
15169, 0.375, 0.7, 0.041666666666667
15170, 0.375, 0.75, 0.041666666666667
15171, 0.375, 0.8, 0.041666666666667
15172, 0.375, 0.85, 0.041666666666667
15173, 0.375, 0.9, 0.041666666666667
15174, 0.375, 0.95, 0.041666666666667
15175, 0.375, 1, 0.041666666666667
15176, 0.375, 1.05, 0.041666666666667
15177, 0.375, 1.1, 0.041666666666667
15178, 0.375, 1.15, 0.041666666666667
15179, 0.375, 1.2, 0.041666666666667
15180, 0.375, 1.25, 0.041666666666667
15181, 0.375, 1.3, 0.041666666666667
15182, 0.375, 0.2, 0.083333333333333
15183, 0.375, 0.25, 0.083333333333333
15184, 0.375, 0.3, 0.083333333333333
15185, 0.375, 0.35, 0.083333333333333
15186, 0.375, 0.4, 0.083333333333333
15187, 0.375, 0.45, 0.083333333333333
15188, 0.375, 0.5, 0.083333333333333
15189, 0.375, 0.55, 0.083333333333333
15190, 0.375, 0.6, 0.083333333333333
15191, 0.375, 0.65, 0.083333333333333
15192, 0.375, 0.7, 0.083333333333333
15193, 0.375, 0.75, 0.083333333333333
15194, 0.375, 0.8, 0.083333333333333
15195, 0.375, 0.85, 0.083333333333333
15196, 0.375, 0.9, 0.083333333333333
15197, 0.375, 0.95, 0.083333333333333
15198, 0.375, 1, 0.083333333333333
15199, 0.375, 1.05, 0.083333333333333
15200, 0.375, 1.1, 0.083333333333333
15201, 0.375, 1.15, 0.083333333333333
15202, 0.375, 1.2, 0.083333333333333
15203, 0.375, 1.25, 0.083333333333333
15204, 0.375, 1.3, 0.083333333333333
15205, 0.375, 0.2, 0.125
15206, 0.375, 0.25, 0.125
15207, 0.375, 0.3, 0.125
15208, 0.375, 0.35, 0.125
15209, 0.375, 0.4, 0.125
15210, 0.375, 0.45, 0.125
15211, 0.375, 0.5, 0.125
15212, 0.375, 0.55, 0.125
15213, 0.375, 0.6, 0.125
15214, 0.375, 0.65, 0.125
15215, 0.375, 0.7, 0.125
15216, 0.375, 0.75, 0.125
15217, 0.375, 0.8, 0.125
15218, 0.375, 0.85, 0.125
15219, 0.375, 0.9, 0.125
15220, 0.375, 0.95, 0.125
15221, 0.375, 1, 0.125
15222, 0.375, 1.05, 0.125
15223, 0.375, 1.1, 0.125
15224, 0.375, 1.15, 0.125
15225, 0.375, 1.2, 0.125
15226, 0.375, 1.25, 0.125
15227, 0.375, 1.3, 0.125
15228, 0.375, 0.2, 0.16666666666667
15229, 0.375, 0.25, 0.16666666666667
15230, 0.375, 0.3, 0.16666666666667
15231, 0.375, 0.35, 0.16666666666667
15232, 0.375, 0.4, 0.16666666666667
15233, 0.375, 0.45, 0.16666666666667
15234, 0.375, 0.5, 0.16666666666667
15235, 0.375, 0.55, 0.16666666666667
15236, 0.375, 0.6, 0.16666666666667
15237, 0.375, 0.65, 0.16666666666667
15238, 0.375, 0.7, 0.16666666666667
15239, 0.375, 0.75, 0.16666666666667
15240, 0.375, 0.8, 0.16666666666667
15241, 0.375, 0.85, 0.16666666666667
15242, 0.375, 0.9, 0.16666666666667
15243, 0.375, 0.95, 0.16666666666667
15244, 0.375, 1, 0.16666666666667
15245, 0.375, 1.05, 0.16666666666667
15246, 0.375, 1.1, 0.16666666666667
15247, 0.375, 1.15, 0.16666666666667
15248, 0.375, 1.2, 0.16666666666667
15249, 0.375, 1.25, 0.16666666666667
15250, 0.375, 1.3, 0.16666666666667
15251, 0.375, 0.2, 0.20833333333333
15252, 0.375, 0.25, 0.20833333333333
15253, 0.375, 0.3, 0.20833333333333
15254, 0.375, 0.35, 0.20833333333333
15255, 0.375, 0.4, 0.20833333333333
15256, 0.375, 0.45, 0.20833333333333
15257, 0.375, 0.5, 0.20833333333333
15258, 0.375, 0.55, 0.20833333333333
15259, 0.375, 0.6, 0.20833333333333
15260, 0.375, 0.65, 0.20833333333333
15261, 0.375, 0.7, 0.20833333333333
15262, 0.375, 0.75, 0.20833333333333
15263, 0.375, 0.8, 0.20833333333333
15264, 0.375, 0.85, 0.20833333333333
15265, 0.375, 0.9, 0.20833333333333
15266, 0.375, 0.95, 0.20833333333333
15267, 0.375, 1, 0.20833333333333
15268, 0.375, 1.05, 0.20833333333333
15269, 0.375, 1.1, 0.20833333333333
15270, 0.375, 1.15, 0.20833333333333
15271, 0.375, 1.2, 0.20833333333333
15272, 0.375, 1.25, 0.20833333333333
15273, 0.375, 1.3, 0.20833333333333
15274, 0.375, 0.2, 0.25
15275, 0.375, 0.25, 0.25
15276, 0.375, 0.3, 0.25
15277, 0.375, 0.35, 0.25
15278, 0.375, 0.4, 0.25
15279, 0.375, 0.45, 0.25
15280, 0.375, 0.5, 0.25
15281, 0.375, 0.55, 0.25
15282, 0.375, 0.6, 0.25
15283, 0.375, 0.65, 0.25
15284, 0.375, 0.7, 0.25
15285, 0.375, 0.75, 0.25
15286, 0.375, 0.8, 0.25
15287, 0.375, 0.85, 0.25
15288, 0.375, 0.9, 0.25
15289, 0.375, 0.95, 0.25
15290, 0.375, 1, 0.25
15291, 0.375, 1.05, 0.25
15292, 0.375, 1.1, 0.25
15293, 0.375, 1.15, 0.25
15294, 0.375, 1.2, 0.25
15295, 0.375, 1.25, 0.25
15296, 0.375, 1.3, 0.25
15297, 0.375, 0.2, 0.29166666666667
15298, 0.375, 0.25, 0.29166666666667
15299, 0.375, 0.3, 0.29166666666667
15300, 0.375, 0.35, 0.29166666666667
15301, 0.375, 0.4, 0.29166666666667
15302, 0.375, 0.45, 0.29166666666667
15303, 0.375, 0.5, 0.29166666666667
15304, 0.375, 0.55, 0.29166666666667
15305, 0.375, 0.6, 0.29166666666667
15306, 0.375, 0.65, 0.29166666666667
15307, 0.375, 0.7, 0.29166666666667
15308, 0.375, 0.75, 0.29166666666667
15309, 0.375, 0.8, 0.29166666666667
15310, 0.375, 0.85, 0.29166666666667
15311, 0.375, 0.9, 0.29166666666667
15312, 0.375, 0.95, 0.29166666666667
15313, 0.375, 1, 0.29166666666667
15314, 0.375, 1.05, 0.29166666666667
15315, 0.375, 1.1, 0.29166666666667
15316, 0.375, 1.15, 0.29166666666667
15317, 0.375, 1.2, 0.29166666666667
15318, 0.375, 1.25, 0.29166666666667
15319, 0.375, 1.3, 0.29166666666667
15320, 0.375, 0.2, 0.33333333333333
15321, 0.375, 0.25, 0.33333333333333
15322, 0.375, 0.3, 0.33333333333333
15323, 0.375, 0.35, 0.33333333333333
15324, 0.375, 0.4, 0.33333333333333
15325, 0.375, 0.45, 0.33333333333333
15326, 0.375, 0.5, 0.33333333333333
15327, 0.375, 0.55, 0.33333333333333
15328, 0.375, 0.6, 0.33333333333333
15329, 0.375, 0.65, 0.33333333333333
15330, 0.375, 0.7, 0.33333333333333
15331, 0.375, 0.75, 0.33333333333333
15332, 0.375, 0.8, 0.33333333333333
15333, 0.375, 0.85, 0.33333333333333
15334, 0.375, 0.9, 0.33333333333333
15335, 0.375, 0.95, 0.33333333333333
15336, 0.375, 1, 0.33333333333333
15337, 0.375, 1.05, 0.33333333333333
15338, 0.375, 1.1, 0.33333333333333
15339, 0.375, 1.15, 0.33333333333333
15340, 0.375, 1.2, 0.33333333333333
15341, 0.375, 1.25, 0.33333333333333
15342, 0.375, 1.3, 0.33333333333333
15343, 0.375, 0.2, 0.375
15344, 0.375, 0.25, 0.375
15345, 0.375, 0.3, 0.375
15346, 0.375, 0.35, 0.375
15347, 0.375, 0.4, 0.375
15348, 0.375, 0.45, 0.375
15349, 0.375, 0.5, 0.375
15350, 0.375, 0.55, 0.375
15351, 0.375, 0.6, 0.375
15352, 0.375, 0.65, 0.375
15353, 0.375, 0.7, 0.375
15354, 0.375, 0.75, 0.375
15355, 0.375, 0.8, 0.375
15356, 0.375, 0.85, 0.375
15357, 0.375, 0.9, 0.375
15358, 0.375, 0.95, 0.375
15359, 0.375, 1, 0.375
15360, 0.375, 1.05, 0.375
15361, 0.375, 1.1, 0.375
15362, 0.375, 1.15, 0.375
15363, 0.375, 1.2, 0.375
15364, 0.375, 1.25, 0.375
15365, 0.375, 1.3, 0.375
15366, 0.375, 0.2, 0.41666666666667
15367, 0.375, 0.25, 0.41666666666667
15368, 0.375, 0.3, 0.41666666666667
15369, 0.375, 0.35, 0.41666666666667
15370, 0.375, 0.4, 0.41666666666667
15371, 0.375, 0.45, 0.41666666666667
15372, 0.375, 0.5, 0.41666666666667
15373, 0.375, 0.55, 0.41666666666667
15374, 0.375, 0.6, 0.41666666666667
15375, 0.375, 0.65, 0.41666666666667
15376, 0.375, 0.7, 0.41666666666667
15377, 0.375, 0.75, 0.41666666666667
15378, 0.375, 0.8, 0.41666666666667
15379, 0.375, 0.85, 0.41666666666667
15380, 0.375, 0.9, 0.41666666666667
15381, 0.375, 0.95, 0.41666666666667
15382, 0.375, 1, 0.41666666666667
15383, 0.375, 1.05, 0.41666666666667
15384, 0.375, 1.1, 0.41666666666667
15385, 0.375, 1.15, 0.41666666666667
15386, 0.375, 1.2, 0.41666666666667
15387, 0.375, 1.25, 0.41666666666667
15388, 0.375, 1.3, 0.41666666666667
15389, 0.375, 0.2, 0.45833333333333
15390, 0.375, 0.25, 0.45833333333333
15391, 0.375, 0.3, 0.45833333333333
15392, 0.375, 0.35, 0.45833333333333
15393, 0.375, 0.4, 0.45833333333333
15394, 0.375, 0.45, 0.45833333333333
15395, 0.375, 0.5, 0.45833333333333
15396, 0.375, 0.55, 0.45833333333333
15397, 0.375, 0.6, 0.45833333333333
15398, 0.375, 0.65, 0.45833333333333
15399, 0.375, 0.7, 0.45833333333333
15400, 0.375, 0.75, 0.45833333333333
15401, 0.375, 0.8, 0.45833333333333
15402, 0.375, 0.85, 0.45833333333333
15403, 0.375, 0.9, 0.45833333333333
15404, 0.375, 0.95, 0.45833333333333
15405, 0.375, 1, 0.45833333333333
15406, 0.375, 1.05, 0.45833333333333
15407, 0.375, 1.1, 0.45833333333333
15408, 0.375, 1.15, 0.45833333333333
15409, 0.375, 1.2, 0.45833333333333
15410, 0.375, 1.25, 0.45833333333333
15411, 0.375, 1.3, 0.45833333333333
15412, 0.41666666666667, 0.2, 0.041666666666667
15413, 0.41666666666667, 0.25, 0.041666666666667
15414, 0.41666666666667, 0.3, 0.041666666666667
15415, 0.41666666666667, 0.35, 0.041666666666667
15416, 0.41666666666667, 0.4, 0.041666666666667
15417, 0.41666666666667, 0.45, 0.041666666666667
15418, 0.41666666666667, 0.5, 0.041666666666667
15419, 0.41666666666667, 0.55, 0.041666666666667
15420, 0.41666666666667, 0.6, 0.041666666666667
15421, 0.41666666666667, 0.65, 0.041666666666667
15422, 0.41666666666667, 0.7, 0.041666666666667
15423, 0.41666666666667, 0.75, 0.041666666666667
15424, 0.41666666666667, 0.8, 0.041666666666667
15425, 0.41666666666667, 0.85, 0.041666666666667
15426, 0.41666666666667, 0.9, 0.041666666666667
15427, 0.41666666666667, 0.95, 0.041666666666667
15428, 0.41666666666667, 1, 0.041666666666667
15429, 0.41666666666667, 1.05, 0.041666666666667
15430, 0.41666666666667, 1.1, 0.041666666666667
15431, 0.41666666666667, 1.15, 0.041666666666667
15432, 0.41666666666667, 1.2, 0.041666666666667
15433, 0.41666666666667, 1.25, 0.041666666666667
15434, 0.41666666666667, 1.3, 0.041666666666667
15435, 0.41666666666667, 0.2, 0.083333333333333
15436, 0.41666666666667, 0.25, 0.083333333333333
15437, 0.41666666666667, 0.3, 0.083333333333333
15438, 0.41666666666667, 0.35, 0.083333333333333
15439, 0.41666666666667, 0.4, 0.083333333333333
15440, 0.41666666666667, 0.45, 0.083333333333333
15441, 0.41666666666667, 0.5, 0.083333333333333
15442, 0.41666666666667, 0.55, 0.083333333333333
15443, 0.41666666666667, 0.6, 0.083333333333333
15444, 0.41666666666667, 0.65, 0.083333333333333
15445, 0.41666666666667, 0.7, 0.083333333333333
15446, 0.41666666666667, 0.75, 0.083333333333333
15447, 0.41666666666667, 0.8, 0.083333333333333
15448, 0.41666666666667, 0.85, 0.083333333333333
15449, 0.41666666666667, 0.9, 0.083333333333333
15450, 0.41666666666667, 0.95, 0.083333333333333
15451, 0.41666666666667, 1, 0.083333333333333
15452, 0.41666666666667, 1.05, 0.083333333333333
15453, 0.41666666666667, 1.1, 0.083333333333333
15454, 0.41666666666667, 1.15, 0.083333333333333
15455, 0.41666666666667, 1.2, 0.083333333333333
15456, 0.41666666666667, 1.25, 0.083333333333333
15457, 0.41666666666667, 1.3, 0.083333333333333
15458, 0.41666666666667, 0.2, 0.125
15459, 0.41666666666667, 0.25, 0.125
15460, 0.41666666666667, 0.3, 0.125
15461, 0.41666666666667, 0.35, 0.125
15462, 0.41666666666667, 0.4, 0.125
15463, 0.41666666666667, 0.45, 0.125
15464, 0.41666666666667, 0.5, 0.125
15465, 0.41666666666667, 0.55, 0.125
15466, 0.41666666666667, 0.6, 0.125
15467, 0.41666666666667, 0.65, 0.125
15468, 0.41666666666667, 0.7, 0.125
15469, 0.41666666666667, 0.75, 0.125
15470, 0.41666666666667, 0.8, 0.125
15471, 0.41666666666667, 0.85, 0.125
15472, 0.41666666666667, 0.9, 0.125
15473, 0.41666666666667, 0.95, 0.125
15474, 0.41666666666667, 1, 0.125
15475, 0.41666666666667, 1.05, 0.125
15476, 0.41666666666667, 1.1, 0.125
15477, 0.41666666666667, 1.15, 0.125
15478, 0.41666666666667, 1.2, 0.125
15479, 0.41666666666667, 1.25, 0.125
15480, 0.41666666666667, 1.3, 0.125
15481, 0.41666666666667, 0.2, 0.16666666666667
15482, 0.41666666666667, 0.25, 0.16666666666667
15483, 0.41666666666667, 0.3, 0.16666666666667
15484, 0.41666666666667, 0.35, 0.16666666666667
15485, 0.41666666666667, 0.4, 0.16666666666667
15486, 0.41666666666667, 0.45, 0.16666666666667
15487, 0.41666666666667, 0.5, 0.16666666666667
15488, 0.41666666666667, 0.55, 0.16666666666667
15489, 0.41666666666667, 0.6, 0.16666666666667
15490, 0.41666666666667, 0.65, 0.16666666666667
15491, 0.41666666666667, 0.7, 0.16666666666667
15492, 0.41666666666667, 0.75, 0.16666666666667
15493, 0.41666666666667, 0.8, 0.16666666666667
15494, 0.41666666666667, 0.85, 0.16666666666667
15495, 0.41666666666667, 0.9, 0.16666666666667
15496, 0.41666666666667, 0.95, 0.16666666666667
15497, 0.41666666666667, 1, 0.16666666666667
15498, 0.41666666666667, 1.05, 0.16666666666667
15499, 0.41666666666667, 1.1, 0.16666666666667
15500, 0.41666666666667, 1.15, 0.16666666666667
15501, 0.41666666666667, 1.2, 0.16666666666667
15502, 0.41666666666667, 1.25, 0.16666666666667
15503, 0.41666666666667, 1.3, 0.16666666666667
15504, 0.41666666666667, 0.2, 0.20833333333333
15505, 0.41666666666667, 0.25, 0.20833333333333
15506, 0.41666666666667, 0.3, 0.20833333333333
15507, 0.41666666666667, 0.35, 0.20833333333333
15508, 0.41666666666667, 0.4, 0.20833333333333
15509, 0.41666666666667, 0.45, 0.20833333333333
15510, 0.41666666666667, 0.5, 0.20833333333333
15511, 0.41666666666667, 0.55, 0.20833333333333
15512, 0.41666666666667, 0.6, 0.20833333333333
15513, 0.41666666666667, 0.65, 0.20833333333333
15514, 0.41666666666667, 0.7, 0.20833333333333
15515, 0.41666666666667, 0.75, 0.20833333333333
15516, 0.41666666666667, 0.8, 0.20833333333333
15517, 0.41666666666667, 0.85, 0.20833333333333
15518, 0.41666666666667, 0.9, 0.20833333333333
15519, 0.41666666666667, 0.95, 0.20833333333333
15520, 0.41666666666667, 1, 0.20833333333333
15521, 0.41666666666667, 1.05, 0.20833333333333
15522, 0.41666666666667, 1.1, 0.20833333333333
15523, 0.41666666666667, 1.15, 0.20833333333333
15524, 0.41666666666667, 1.2, 0.20833333333333
15525, 0.41666666666667, 1.25, 0.20833333333333
15526, 0.41666666666667, 1.3, 0.20833333333333
15527, 0.41666666666667, 0.2, 0.25
15528, 0.41666666666667, 0.25, 0.25
15529, 0.41666666666667, 0.3, 0.25
15530, 0.41666666666667, 0.35, 0.25
15531, 0.41666666666667, 0.4, 0.25
15532, 0.41666666666667, 0.45, 0.25
15533, 0.41666666666667, 0.5, 0.25
15534, 0.41666666666667, 0.55, 0.25
15535, 0.41666666666667, 0.6, 0.25
15536, 0.41666666666667, 0.65, 0.25
15537, 0.41666666666667, 0.7, 0.25
15538, 0.41666666666667, 0.75, 0.25
15539, 0.41666666666667, 0.8, 0.25
15540, 0.41666666666667, 0.85, 0.25
15541, 0.41666666666667, 0.9, 0.25
15542, 0.41666666666667, 0.95, 0.25
15543, 0.41666666666667, 1, 0.25
15544, 0.41666666666667, 1.05, 0.25
15545, 0.41666666666667, 1.1, 0.25
15546, 0.41666666666667, 1.15, 0.25
15547, 0.41666666666667, 1.2, 0.25
15548, 0.41666666666667, 1.25, 0.25
15549, 0.41666666666667, 1.3, 0.25
15550, 0.41666666666667, 0.2, 0.29166666666667
15551, 0.41666666666667, 0.25, 0.29166666666667
15552, 0.41666666666667, 0.3, 0.29166666666667
15553, 0.41666666666667, 0.35, 0.29166666666667
15554, 0.41666666666667, 0.4, 0.29166666666667
15555, 0.41666666666667, 0.45, 0.29166666666667
15556, 0.41666666666667, 0.5, 0.29166666666667
15557, 0.41666666666667, 0.55, 0.29166666666667
15558, 0.41666666666667, 0.6, 0.29166666666667
15559, 0.41666666666667, 0.65, 0.29166666666667
15560, 0.41666666666667, 0.7, 0.29166666666667
15561, 0.41666666666667, 0.75, 0.29166666666667
15562, 0.41666666666667, 0.8, 0.29166666666667
15563, 0.41666666666667, 0.85, 0.29166666666667
15564, 0.41666666666667, 0.9, 0.29166666666667
15565, 0.41666666666667, 0.95, 0.29166666666667
15566, 0.41666666666667, 1, 0.29166666666667
15567, 0.41666666666667, 1.05, 0.29166666666667
15568, 0.41666666666667, 1.1, 0.29166666666667
15569, 0.41666666666667, 1.15, 0.29166666666667
15570, 0.41666666666667, 1.2, 0.29166666666667
15571, 0.41666666666667, 1.25, 0.29166666666667
15572, 0.41666666666667, 1.3, 0.29166666666667
15573, 0.41666666666667, 0.2, 0.33333333333333
15574, 0.41666666666667, 0.25, 0.33333333333333
15575, 0.41666666666667, 0.3, 0.33333333333333
15576, 0.41666666666667, 0.35, 0.33333333333333
15577, 0.41666666666667, 0.4, 0.33333333333333
15578, 0.41666666666667, 0.45, 0.33333333333333
15579, 0.41666666666667, 0.5, 0.33333333333333
15580, 0.41666666666667, 0.55, 0.33333333333333
15581, 0.41666666666667, 0.6, 0.33333333333333
15582, 0.41666666666667, 0.65, 0.33333333333333
15583, 0.41666666666667, 0.7, 0.33333333333333
15584, 0.41666666666667, 0.75, 0.33333333333333
15585, 0.41666666666667, 0.8, 0.33333333333333
15586, 0.41666666666667, 0.85, 0.33333333333333
15587, 0.41666666666667, 0.9, 0.33333333333333
15588, 0.41666666666667, 0.95, 0.33333333333333
15589, 0.41666666666667, 1, 0.33333333333333
15590, 0.41666666666667, 1.05, 0.33333333333333
15591, 0.41666666666667, 1.1, 0.33333333333333
15592, 0.41666666666667, 1.15, 0.33333333333333
15593, 0.41666666666667, 1.2, 0.33333333333333
15594, 0.41666666666667, 1.25, 0.33333333333333
15595, 0.41666666666667, 1.3, 0.33333333333333
15596, 0.41666666666667, 0.2, 0.375
15597, 0.41666666666667, 0.25, 0.375
15598, 0.41666666666667, 0.3, 0.375
15599, 0.41666666666667, 0.35, 0.375
15600, 0.41666666666667, 0.4, 0.375
15601, 0.41666666666667, 0.45, 0.375
15602, 0.41666666666667, 0.5, 0.375
15603, 0.41666666666667, 0.55, 0.375
15604, 0.41666666666667, 0.6, 0.375
15605, 0.41666666666667, 0.65, 0.375
15606, 0.41666666666667, 0.7, 0.375
15607, 0.41666666666667, 0.75, 0.375
15608, 0.41666666666667, 0.8, 0.375
15609, 0.41666666666667, 0.85, 0.375
15610, 0.41666666666667, 0.9, 0.375
15611, 0.41666666666667, 0.95, 0.375
15612, 0.41666666666667, 1, 0.375
15613, 0.41666666666667, 1.05, 0.375
15614, 0.41666666666667, 1.1, 0.375
15615, 0.41666666666667, 1.15, 0.375
15616, 0.41666666666667, 1.2, 0.375
15617, 0.41666666666667, 1.25, 0.375
15618, 0.41666666666667, 1.3, 0.375
15619, 0.41666666666667, 0.2, 0.41666666666667
15620, 0.41666666666667, 0.25, 0.41666666666667
15621, 0.41666666666667, 0.3, 0.41666666666667
15622, 0.41666666666667, 0.35, 0.41666666666667
15623, 0.41666666666667, 0.4, 0.41666666666667
15624, 0.41666666666667, 0.45, 0.41666666666667
15625, 0.41666666666667, 0.5, 0.41666666666667
15626, 0.41666666666667, 0.55, 0.41666666666667
15627, 0.41666666666667, 0.6, 0.41666666666667
15628, 0.41666666666667, 0.65, 0.41666666666667
15629, 0.41666666666667, 0.7, 0.41666666666667
15630, 0.41666666666667, 0.75, 0.41666666666667
15631, 0.41666666666667, 0.8, 0.41666666666667
15632, 0.41666666666667, 0.85, 0.41666666666667
15633, 0.41666666666667, 0.9, 0.41666666666667
15634, 0.41666666666667, 0.95, 0.41666666666667
15635, 0.41666666666667, 1, 0.41666666666667
15636, 0.41666666666667, 1.05, 0.41666666666667
15637, 0.41666666666667, 1.1, 0.41666666666667
15638, 0.41666666666667, 1.15, 0.41666666666667
15639, 0.41666666666667, 1.2, 0.41666666666667
15640, 0.41666666666667, 1.25, 0.41666666666667
15641, 0.41666666666667, 1.3, 0.41666666666667
15642, 0.41666666666667, 0.2, 0.45833333333333
15643, 0.41666666666667, 0.25, 0.45833333333333
15644, 0.41666666666667, 0.3, 0.45833333333333
15645, 0.41666666666667, 0.35, 0.45833333333333
15646, 0.41666666666667, 0.4, 0.45833333333333
15647, 0.41666666666667, 0.45, 0.45833333333333
15648, 0.41666666666667, 0.5, 0.45833333333333
15649, 0.41666666666667, 0.55, 0.45833333333333
15650, 0.41666666666667, 0.6, 0.45833333333333
15651, 0.41666666666667, 0.65, 0.45833333333333
15652, 0.41666666666667, 0.7, 0.45833333333333
15653, 0.41666666666667, 0.75, 0.45833333333333
15654, 0.41666666666667, 0.8, 0.45833333333333
15655, 0.41666666666667, 0.85, 0.45833333333333
15656, 0.41666666666667, 0.9, 0.45833333333333
15657, 0.41666666666667, 0.95, 0.45833333333333
15658, 0.41666666666667, 1, 0.45833333333333
15659, 0.41666666666667, 1.05, 0.45833333333333
15660, 0.41666666666667, 1.1, 0.45833333333333
15661, 0.41666666666667, 1.15, 0.45833333333333
15662, 0.41666666666667, 1.2, 0.45833333333333
15663, 0.41666666666667, 1.25, 0.45833333333333
15664, 0.41666666666667, 1.3, 0.45833333333333
15665, 0.45833333333333, 0.2, 0.041666666666667
15666, 0.45833333333333, 0.25, 0.041666666666667
15667, 0.45833333333333, 0.3, 0.041666666666667
15668, 0.45833333333333, 0.35, 0.041666666666667
15669, 0.45833333333333, 0.4, 0.041666666666667
15670, 0.45833333333333, 0.45, 0.041666666666667
15671, 0.45833333333333, 0.5, 0.041666666666667
15672, 0.45833333333333, 0.55, 0.041666666666667
15673, 0.45833333333333, 0.6, 0.041666666666667
15674, 0.45833333333333, 0.65, 0.041666666666667
15675, 0.45833333333333, 0.7, 0.041666666666667
15676, 0.45833333333333, 0.75, 0.041666666666667
15677, 0.45833333333333, 0.8, 0.041666666666667
15678, 0.45833333333333, 0.85, 0.041666666666667
15679, 0.45833333333333, 0.9, 0.041666666666667
15680, 0.45833333333333, 0.95, 0.041666666666667
15681, 0.45833333333333, 1, 0.041666666666667
15682, 0.45833333333333, 1.05, 0.041666666666667
15683, 0.45833333333333, 1.1, 0.041666666666667
15684, 0.45833333333333, 1.15, 0.041666666666667
15685, 0.45833333333333, 1.2, 0.041666666666667
15686, 0.45833333333333, 1.25, 0.041666666666667
15687, 0.45833333333333, 1.3, 0.041666666666667
15688, 0.45833333333333, 0.2, 0.083333333333333
15689, 0.45833333333333, 0.25, 0.083333333333333
15690, 0.45833333333333, 0.3, 0.083333333333333
15691, 0.45833333333333, 0.35, 0.083333333333333
15692, 0.45833333333333, 0.4, 0.083333333333333
15693, 0.45833333333333, 0.45, 0.083333333333333
15694, 0.45833333333333, 0.5, 0.083333333333333
15695, 0.45833333333333, 0.55, 0.083333333333333
15696, 0.45833333333333, 0.6, 0.083333333333333
15697, 0.45833333333333, 0.65, 0.083333333333333
15698, 0.45833333333333, 0.7, 0.083333333333333
15699, 0.45833333333333, 0.75, 0.083333333333333
15700, 0.45833333333333, 0.8, 0.083333333333333
15701, 0.45833333333333, 0.85, 0.083333333333333
15702, 0.45833333333333, 0.9, 0.083333333333333
15703, 0.45833333333333, 0.95, 0.083333333333333
15704, 0.45833333333333, 1, 0.083333333333333
15705, 0.45833333333333, 1.05, 0.083333333333333
15706, 0.45833333333333, 1.1, 0.083333333333333
15707, 0.45833333333333, 1.15, 0.083333333333333
15708, 0.45833333333333, 1.2, 0.083333333333333
15709, 0.45833333333333, 1.25, 0.083333333333333
15710, 0.45833333333333, 1.3, 0.083333333333333
15711, 0.45833333333333, 0.2, 0.125
15712, 0.45833333333333, 0.25, 0.125
15713, 0.45833333333333, 0.3, 0.125
15714, 0.45833333333333, 0.35, 0.125
15715, 0.45833333333333, 0.4, 0.125
15716, 0.45833333333333, 0.45, 0.125
15717, 0.45833333333333, 0.5, 0.125
15718, 0.45833333333333, 0.55, 0.125
15719, 0.45833333333333, 0.6, 0.125
15720, 0.45833333333333, 0.65, 0.125
15721, 0.45833333333333, 0.7, 0.125
15722, 0.45833333333333, 0.75, 0.125
15723, 0.45833333333333, 0.8, 0.125
15724, 0.45833333333333, 0.85, 0.125
15725, 0.45833333333333, 0.9, 0.125
15726, 0.45833333333333, 0.95, 0.125
15727, 0.45833333333333, 1, 0.125
15728, 0.45833333333333, 1.05, 0.125
15729, 0.45833333333333, 1.1, 0.125
15730, 0.45833333333333, 1.15, 0.125
15731, 0.45833333333333, 1.2, 0.125
15732, 0.45833333333333, 1.25, 0.125
15733, 0.45833333333333, 1.3, 0.125
15734, 0.45833333333333, 0.2, 0.16666666666667
15735, 0.45833333333333, 0.25, 0.16666666666667
15736, 0.45833333333333, 0.3, 0.16666666666667
15737, 0.45833333333333, 0.35, 0.16666666666667
15738, 0.45833333333333, 0.4, 0.16666666666667
15739, 0.45833333333333, 0.45, 0.16666666666667
15740, 0.45833333333333, 0.5, 0.16666666666667
15741, 0.45833333333333, 0.55, 0.16666666666667
15742, 0.45833333333333, 0.6, 0.16666666666667
15743, 0.45833333333333, 0.65, 0.16666666666667
15744, 0.45833333333333, 0.7, 0.16666666666667
15745, 0.45833333333333, 0.75, 0.16666666666667
15746, 0.45833333333333, 0.8, 0.16666666666667
15747, 0.45833333333333, 0.85, 0.16666666666667
15748, 0.45833333333333, 0.9, 0.16666666666667
15749, 0.45833333333333, 0.95, 0.16666666666667
15750, 0.45833333333333, 1, 0.16666666666667
15751, 0.45833333333333, 1.05, 0.16666666666667
15752, 0.45833333333333, 1.1, 0.16666666666667
15753, 0.45833333333333, 1.15, 0.16666666666667
15754, 0.45833333333333, 1.2, 0.16666666666667
15755, 0.45833333333333, 1.25, 0.16666666666667
15756, 0.45833333333333, 1.3, 0.16666666666667
15757, 0.45833333333333, 0.2, 0.20833333333333
15758, 0.45833333333333, 0.25, 0.20833333333333
15759, 0.45833333333333, 0.3, 0.20833333333333
15760, 0.45833333333333, 0.35, 0.20833333333333
15761, 0.45833333333333, 0.4, 0.20833333333333
15762, 0.45833333333333, 0.45, 0.20833333333333
15763, 0.45833333333333, 0.5, 0.20833333333333
15764, 0.45833333333333, 0.55, 0.20833333333333
15765, 0.45833333333333, 0.6, 0.20833333333333
15766, 0.45833333333333, 0.65, 0.20833333333333
15767, 0.45833333333333, 0.7, 0.20833333333333
15768, 0.45833333333333, 0.75, 0.20833333333333
15769, 0.45833333333333, 0.8, 0.20833333333333
15770, 0.45833333333333, 0.85, 0.20833333333333
15771, 0.45833333333333, 0.9, 0.20833333333333
15772, 0.45833333333333, 0.95, 0.20833333333333
15773, 0.45833333333333, 1, 0.20833333333333
15774, 0.45833333333333, 1.05, 0.20833333333333
15775, 0.45833333333333, 1.1, 0.20833333333333
15776, 0.45833333333333, 1.15, 0.20833333333333
15777, 0.45833333333333, 1.2, 0.20833333333333
15778, 0.45833333333333, 1.25, 0.20833333333333
15779, 0.45833333333333, 1.3, 0.20833333333333
15780, 0.45833333333333, 0.2, 0.25
15781, 0.45833333333333, 0.25, 0.25
15782, 0.45833333333333, 0.3, 0.25
15783, 0.45833333333333, 0.35, 0.25
15784, 0.45833333333333, 0.4, 0.25
15785, 0.45833333333333, 0.45, 0.25
15786, 0.45833333333333, 0.5, 0.25
15787, 0.45833333333333, 0.55, 0.25
15788, 0.45833333333333, 0.6, 0.25
15789, 0.45833333333333, 0.65, 0.25
15790, 0.45833333333333, 0.7, 0.25
15791, 0.45833333333333, 0.75, 0.25
15792, 0.45833333333333, 0.8, 0.25
15793, 0.45833333333333, 0.85, 0.25
15794, 0.45833333333333, 0.9, 0.25
15795, 0.45833333333333, 0.95, 0.25
15796, 0.45833333333333, 1, 0.25
15797, 0.45833333333333, 1.05, 0.25
15798, 0.45833333333333, 1.1, 0.25
15799, 0.45833333333333, 1.15, 0.25
15800, 0.45833333333333, 1.2, 0.25
15801, 0.45833333333333, 1.25, 0.25
15802, 0.45833333333333, 1.3, 0.25
15803, 0.45833333333333, 0.2, 0.29166666666667
15804, 0.45833333333333, 0.25, 0.29166666666667
15805, 0.45833333333333, 0.3, 0.29166666666667
15806, 0.45833333333333, 0.35, 0.29166666666667
15807, 0.45833333333333, 0.4, 0.29166666666667
15808, 0.45833333333333, 0.45, 0.29166666666667
15809, 0.45833333333333, 0.5, 0.29166666666667
15810, 0.45833333333333, 0.55, 0.29166666666667
15811, 0.45833333333333, 0.6, 0.29166666666667
15812, 0.45833333333333, 0.65, 0.29166666666667
15813, 0.45833333333333, 0.7, 0.29166666666667
15814, 0.45833333333333, 0.75, 0.29166666666667
15815, 0.45833333333333, 0.8, 0.29166666666667
15816, 0.45833333333333, 0.85, 0.29166666666667
15817, 0.45833333333333, 0.9, 0.29166666666667
15818, 0.45833333333333, 0.95, 0.29166666666667
15819, 0.45833333333333, 1, 0.29166666666667
15820, 0.45833333333333, 1.05, 0.29166666666667
15821, 0.45833333333333, 1.1, 0.29166666666667
15822, 0.45833333333333, 1.15, 0.29166666666667
15823, 0.45833333333333, 1.2, 0.29166666666667
15824, 0.45833333333333, 1.25, 0.29166666666667
15825, 0.45833333333333, 1.3, 0.29166666666667
15826, 0.45833333333333, 0.2, 0.33333333333333
15827, 0.45833333333333, 0.25, 0.33333333333333
15828, 0.45833333333333, 0.3, 0.33333333333333
15829, 0.45833333333333, 0.35, 0.33333333333333
15830, 0.45833333333333, 0.4, 0.33333333333333
15831, 0.45833333333333, 0.45, 0.33333333333333
15832, 0.45833333333333, 0.5, 0.33333333333333
15833, 0.45833333333333, 0.55, 0.33333333333333
15834, 0.45833333333333, 0.6, 0.33333333333333
15835, 0.45833333333333, 0.65, 0.33333333333333
15836, 0.45833333333333, 0.7, 0.33333333333333
15837, 0.45833333333333, 0.75, 0.33333333333333
15838, 0.45833333333333, 0.8, 0.33333333333333
15839, 0.45833333333333, 0.85, 0.33333333333333
15840, 0.45833333333333, 0.9, 0.33333333333333
15841, 0.45833333333333, 0.95, 0.33333333333333
15842, 0.45833333333333, 1, 0.33333333333333
15843, 0.45833333333333, 1.05, 0.33333333333333
15844, 0.45833333333333, 1.1, 0.33333333333333
15845, 0.45833333333333, 1.15, 0.33333333333333
15846, 0.45833333333333, 1.2, 0.33333333333333
15847, 0.45833333333333, 1.25, 0.33333333333333
15848, 0.45833333333333, 1.3, 0.33333333333333
15849, 0.45833333333333, 0.2, 0.375
15850, 0.45833333333333, 0.25, 0.375
15851, 0.45833333333333, 0.3, 0.375
15852, 0.45833333333333, 0.35, 0.375
15853, 0.45833333333333, 0.4, 0.375
15854, 0.45833333333333, 0.45, 0.375
15855, 0.45833333333333, 0.5, 0.375
15856, 0.45833333333333, 0.55, 0.375
15857, 0.45833333333333, 0.6, 0.375
15858, 0.45833333333333, 0.65, 0.375
15859, 0.45833333333333, 0.7, 0.375
15860, 0.45833333333333, 0.75, 0.375
15861, 0.45833333333333, 0.8, 0.375
15862, 0.45833333333333, 0.85, 0.375
15863, 0.45833333333333, 0.9, 0.375
15864, 0.45833333333333, 0.95, 0.375
15865, 0.45833333333333, 1, 0.375
15866, 0.45833333333333, 1.05, 0.375
15867, 0.45833333333333, 1.1, 0.375
15868, 0.45833333333333, 1.15, 0.375
15869, 0.45833333333333, 1.2, 0.375
15870, 0.45833333333333, 1.25, 0.375
15871, 0.45833333333333, 1.3, 0.375
15872, 0.45833333333333, 0.2, 0.41666666666667
15873, 0.45833333333333, 0.25, 0.41666666666667
15874, 0.45833333333333, 0.3, 0.41666666666667
15875, 0.45833333333333, 0.35, 0.41666666666667
15876, 0.45833333333333, 0.4, 0.41666666666667
15877, 0.45833333333333, 0.45, 0.41666666666667
15878, 0.45833333333333, 0.5, 0.41666666666667
15879, 0.45833333333333, 0.55, 0.41666666666667
15880, 0.45833333333333, 0.6, 0.41666666666667
15881, 0.45833333333333, 0.65, 0.41666666666667
15882, 0.45833333333333, 0.7, 0.41666666666667
15883, 0.45833333333333, 0.75, 0.41666666666667
15884, 0.45833333333333, 0.8, 0.41666666666667
15885, 0.45833333333333, 0.85, 0.41666666666667
15886, 0.45833333333333, 0.9, 0.41666666666667
15887, 0.45833333333333, 0.95, 0.41666666666667
15888, 0.45833333333333, 1, 0.41666666666667
15889, 0.45833333333333, 1.05, 0.41666666666667
15890, 0.45833333333333, 1.1, 0.41666666666667
15891, 0.45833333333333, 1.15, 0.41666666666667
15892, 0.45833333333333, 1.2, 0.41666666666667
15893, 0.45833333333333, 1.25, 0.41666666666667
15894, 0.45833333333333, 1.3, 0.41666666666667
15895, 0.45833333333333, 0.2, 0.45833333333333
15896, 0.45833333333333, 0.25, 0.45833333333333
15897, 0.45833333333333, 0.3, 0.45833333333333
15898, 0.45833333333333, 0.35, 0.45833333333333
15899, 0.45833333333333, 0.4, 0.45833333333333
15900, 0.45833333333333, 0.45, 0.45833333333333
15901, 0.45833333333333, 0.5, 0.45833333333333
15902, 0.45833333333333, 0.55, 0.45833333333333
15903, 0.45833333333333, 0.6, 0.45833333333333
15904, 0.45833333333333, 0.65, 0.45833333333333
15905, 0.45833333333333, 0.7, 0.45833333333333
15906, 0.45833333333333, 0.75, 0.45833333333333
15907, 0.45833333333333, 0.8, 0.45833333333333
15908, 0.45833333333333, 0.85, 0.45833333333333
15909, 0.45833333333333, 0.9, 0.45833333333333
15910, 0.45833333333333, 0.95, 0.45833333333333
15911, 0.45833333333333, 1, 0.45833333333333
15912, 0.45833333333333, 1.05, 0.45833333333333
15913, 0.45833333333333, 1.1, 0.45833333333333
15914, 0.45833333333333, 1.15, 0.45833333333333
15915, 0.45833333333333, 1.2, 0.45833333333333
15916, 0.45833333333333, 1.25, 0.45833333333333
15917, 0.45833333333333, 1.3, 0.45833333333333
15918, 0.5, 0.2, 0.041666666666667
15919, 0.5, 0.25, 0.041666666666667
15920, 0.5, 0.3, 0.041666666666667
15921, 0.5, 0.35, 0.041666666666667
15922, 0.5, 0.4, 0.041666666666667
15923, 0.5, 0.45, 0.041666666666667
15924, 0.5, 0.5, 0.041666666666667
15925, 0.5, 0.55, 0.041666666666667
15926, 0.5, 0.6, 0.041666666666667
15927, 0.5, 0.65, 0.041666666666667
15928, 0.5, 0.7, 0.041666666666667
15929, 0.5, 0.75, 0.041666666666667
15930, 0.5, 0.8, 0.041666666666667
15931, 0.5, 0.85, 0.041666666666667
15932, 0.5, 0.9, 0.041666666666667
15933, 0.5, 0.95, 0.041666666666667
15934, 0.5, 1, 0.041666666666667
15935, 0.5, 1.05, 0.041666666666667
15936, 0.5, 1.1, 0.041666666666667
15937, 0.5, 1.15, 0.041666666666667
15938, 0.5, 1.2, 0.041666666666667
15939, 0.5, 1.25, 0.041666666666667
15940, 0.5, 1.3, 0.041666666666667
15941, 0.5, 0.2, 0.083333333333333
15942, 0.5, 0.25, 0.083333333333333
15943, 0.5, 0.3, 0.083333333333333
15944, 0.5, 0.35, 0.083333333333333
15945, 0.5, 0.4, 0.083333333333333
15946, 0.5, 0.45, 0.083333333333333
15947, 0.5, 0.5, 0.083333333333333
15948, 0.5, 0.55, 0.083333333333333
15949, 0.5, 0.6, 0.083333333333333
15950, 0.5, 0.65, 0.083333333333333
15951, 0.5, 0.7, 0.083333333333333
15952, 0.5, 0.75, 0.083333333333333
15953, 0.5, 0.8, 0.083333333333333
15954, 0.5, 0.85, 0.083333333333333
15955, 0.5, 0.9, 0.083333333333333
15956, 0.5, 0.95, 0.083333333333333
15957, 0.5, 1, 0.083333333333333
15958, 0.5, 1.05, 0.083333333333333
15959, 0.5, 1.1, 0.083333333333333
15960, 0.5, 1.15, 0.083333333333333
15961, 0.5, 1.2, 0.083333333333333
15962, 0.5, 1.25, 0.083333333333333
15963, 0.5, 1.3, 0.083333333333333
15964, 0.5, 0.2, 0.125
15965, 0.5, 0.25, 0.125
15966, 0.5, 0.3, 0.125
15967, 0.5, 0.35, 0.125
15968, 0.5, 0.4, 0.125
15969, 0.5, 0.45, 0.125
15970, 0.5, 0.5, 0.125
15971, 0.5, 0.55, 0.125
15972, 0.5, 0.6, 0.125
15973, 0.5, 0.65, 0.125
15974, 0.5, 0.7, 0.125
15975, 0.5, 0.75, 0.125
15976, 0.5, 0.8, 0.125
15977, 0.5, 0.85, 0.125
15978, 0.5, 0.9, 0.125
15979, 0.5, 0.95, 0.125
15980, 0.5, 1, 0.125
15981, 0.5, 1.05, 0.125
15982, 0.5, 1.1, 0.125
15983, 0.5, 1.15, 0.125
15984, 0.5, 1.2, 0.125
15985, 0.5, 1.25, 0.125
15986, 0.5, 1.3, 0.125
15987, 0.5, 0.2, 0.16666666666667
15988, 0.5, 0.25, 0.16666666666667
15989, 0.5, 0.3, 0.16666666666667
15990, 0.5, 0.35, 0.16666666666667
15991, 0.5, 0.4, 0.16666666666667
15992, 0.5, 0.45, 0.16666666666667
15993, 0.5, 0.5, 0.16666666666667
15994, 0.5, 0.55, 0.16666666666667
15995, 0.5, 0.6, 0.16666666666667
15996, 0.5, 0.65, 0.16666666666667
15997, 0.5, 0.7, 0.16666666666667
15998, 0.5, 0.75, 0.16666666666667
15999, 0.5, 0.8, 0.16666666666667
16000, 0.5, 0.85, 0.16666666666667
16001, 0.5, 0.9, 0.16666666666667
16002, 0.5, 0.95, 0.16666666666667
16003, 0.5, 1, 0.16666666666667
16004, 0.5, 1.05, 0.16666666666667
16005, 0.5, 1.1, 0.16666666666667
16006, 0.5, 1.15, 0.16666666666667
16007, 0.5, 1.2, 0.16666666666667
16008, 0.5, 1.25, 0.16666666666667
16009, 0.5, 1.3, 0.16666666666667
16010, 0.5, 0.2, 0.20833333333333
16011, 0.5, 0.25, 0.20833333333333
16012, 0.5, 0.3, 0.20833333333333
16013, 0.5, 0.35, 0.20833333333333
16014, 0.5, 0.4, 0.20833333333333
16015, 0.5, 0.45, 0.20833333333333
16016, 0.5, 0.5, 0.20833333333333
16017, 0.5, 0.55, 0.20833333333333
16018, 0.5, 0.6, 0.20833333333333
16019, 0.5, 0.65, 0.20833333333333
16020, 0.5, 0.7, 0.20833333333333
16021, 0.5, 0.75, 0.20833333333333
16022, 0.5, 0.8, 0.20833333333333
16023, 0.5, 0.85, 0.20833333333333
16024, 0.5, 0.9, 0.20833333333333
16025, 0.5, 0.95, 0.20833333333333
16026, 0.5, 1, 0.20833333333333
16027, 0.5, 1.05, 0.20833333333333
16028, 0.5, 1.1, 0.20833333333333
16029, 0.5, 1.15, 0.20833333333333
16030, 0.5, 1.2, 0.20833333333333
16031, 0.5, 1.25, 0.20833333333333
16032, 0.5, 1.3, 0.20833333333333
16033, 0.5, 0.2, 0.25
16034, 0.5, 0.25, 0.25
16035, 0.5, 0.3, 0.25
16036, 0.5, 0.35, 0.25
16037, 0.5, 0.4, 0.25
16038, 0.5, 0.45, 0.25
16039, 0.5, 0.5, 0.25
16040, 0.5, 0.55, 0.25
16041, 0.5, 0.6, 0.25
16042, 0.5, 0.65, 0.25
16043, 0.5, 0.7, 0.25
16044, 0.5, 0.75, 0.25
16045, 0.5, 0.8, 0.25
16046, 0.5, 0.85, 0.25
16047, 0.5, 0.9, 0.25
16048, 0.5, 0.95, 0.25
16049, 0.5, 1, 0.25
16050, 0.5, 1.05, 0.25
16051, 0.5, 1.1, 0.25
16052, 0.5, 1.15, 0.25
16053, 0.5, 1.2, 0.25
16054, 0.5, 1.25, 0.25
16055, 0.5, 1.3, 0.25
16056, 0.5, 0.2, 0.29166666666667
16057, 0.5, 0.25, 0.29166666666667
16058, 0.5, 0.3, 0.29166666666667
16059, 0.5, 0.35, 0.29166666666667
16060, 0.5, 0.4, 0.29166666666667
16061, 0.5, 0.45, 0.29166666666667
16062, 0.5, 0.5, 0.29166666666667
16063, 0.5, 0.55, 0.29166666666667
16064, 0.5, 0.6, 0.29166666666667
16065, 0.5, 0.65, 0.29166666666667
16066, 0.5, 0.7, 0.29166666666667
16067, 0.5, 0.75, 0.29166666666667
16068, 0.5, 0.8, 0.29166666666667
16069, 0.5, 0.85, 0.29166666666667
16070, 0.5, 0.9, 0.29166666666667
16071, 0.5, 0.95, 0.29166666666667
16072, 0.5, 1, 0.29166666666667
16073, 0.5, 1.05, 0.29166666666667
16074, 0.5, 1.1, 0.29166666666667
16075, 0.5, 1.15, 0.29166666666667
16076, 0.5, 1.2, 0.29166666666667
16077, 0.5, 1.25, 0.29166666666667
16078, 0.5, 1.3, 0.29166666666667
16079, 0.5, 0.2, 0.33333333333333
16080, 0.5, 0.25, 0.33333333333333
16081, 0.5, 0.3, 0.33333333333333
16082, 0.5, 0.35, 0.33333333333333
16083, 0.5, 0.4, 0.33333333333333
16084, 0.5, 0.45, 0.33333333333333
16085, 0.5, 0.5, 0.33333333333333
16086, 0.5, 0.55, 0.33333333333333
16087, 0.5, 0.6, 0.33333333333333
16088, 0.5, 0.65, 0.33333333333333
16089, 0.5, 0.7, 0.33333333333333
16090, 0.5, 0.75, 0.33333333333333
16091, 0.5, 0.8, 0.33333333333333
16092, 0.5, 0.85, 0.33333333333333
16093, 0.5, 0.9, 0.33333333333333
16094, 0.5, 0.95, 0.33333333333333
16095, 0.5, 1, 0.33333333333333
16096, 0.5, 1.05, 0.33333333333333
16097, 0.5, 1.1, 0.33333333333333
16098, 0.5, 1.15, 0.33333333333333
16099, 0.5, 1.2, 0.33333333333333
16100, 0.5, 1.25, 0.33333333333333
16101, 0.5, 1.3, 0.33333333333333
16102, 0.5, 0.2, 0.375
16103, 0.5, 0.25, 0.375
16104, 0.5, 0.3, 0.375
16105, 0.5, 0.35, 0.375
16106, 0.5, 0.4, 0.375
16107, 0.5, 0.45, 0.375
16108, 0.5, 0.5, 0.375
16109, 0.5, 0.55, 0.375
16110, 0.5, 0.6, 0.375
16111, 0.5, 0.65, 0.375
16112, 0.5, 0.7, 0.375
16113, 0.5, 0.75, 0.375
16114, 0.5, 0.8, 0.375
16115, 0.5, 0.85, 0.375
16116, 0.5, 0.9, 0.375
16117, 0.5, 0.95, 0.375
16118, 0.5, 1, 0.375
16119, 0.5, 1.05, 0.375
16120, 0.5, 1.1, 0.375
16121, 0.5, 1.15, 0.375
16122, 0.5, 1.2, 0.375
16123, 0.5, 1.25, 0.375
16124, 0.5, 1.3, 0.375
16125, 0.5, 0.2, 0.41666666666667
16126, 0.5, 0.25, 0.41666666666667
16127, 0.5, 0.3, 0.41666666666667
16128, 0.5, 0.35, 0.41666666666667
16129, 0.5, 0.4, 0.41666666666667
16130, 0.5, 0.45, 0.41666666666667
16131, 0.5, 0.5, 0.41666666666667
16132, 0.5, 0.55, 0.41666666666667
16133, 0.5, 0.6, 0.41666666666667
16134, 0.5, 0.65, 0.41666666666667
16135, 0.5, 0.7, 0.41666666666667
16136, 0.5, 0.75, 0.41666666666667
16137, 0.5, 0.8, 0.41666666666667
16138, 0.5, 0.85, 0.41666666666667
16139, 0.5, 0.9, 0.41666666666667
16140, 0.5, 0.95, 0.41666666666667
16141, 0.5, 1, 0.41666666666667
16142, 0.5, 1.05, 0.41666666666667
16143, 0.5, 1.1, 0.41666666666667
16144, 0.5, 1.15, 0.41666666666667
16145, 0.5, 1.2, 0.41666666666667
16146, 0.5, 1.25, 0.41666666666667
16147, 0.5, 1.3, 0.41666666666667
16148, 0.5, 0.2, 0.45833333333333
16149, 0.5, 0.25, 0.45833333333333
16150, 0.5, 0.3, 0.45833333333333
16151, 0.5, 0.35, 0.45833333333333
16152, 0.5, 0.4, 0.45833333333333
16153, 0.5, 0.45, 0.45833333333333
16154, 0.5, 0.5, 0.45833333333333
16155, 0.5, 0.55, 0.45833333333333
16156, 0.5, 0.6, 0.45833333333333
16157, 0.5, 0.65, 0.45833333333333
16158, 0.5, 0.7, 0.45833333333333
16159, 0.5, 0.75, 0.45833333333333
16160, 0.5, 0.8, 0.45833333333333
16161, 0.5, 0.85, 0.45833333333333
16162, 0.5, 0.9, 0.45833333333333
16163, 0.5, 0.95, 0.45833333333333
16164, 0.5, 1, 0.45833333333333
16165, 0.5, 1.05, 0.45833333333333
16166, 0.5, 1.1, 0.45833333333333
16167, 0.5, 1.15, 0.45833333333333
16168, 0.5, 1.2, 0.45833333333333
16169, 0.5, 1.25, 0.45833333333333
16170, 0.5, 1.3, 0.45833333333333
16171, 0.54166666666667, 0.2, 0.041666666666667
16172, 0.54166666666667, 0.25, 0.041666666666667
16173, 0.54166666666667, 0.3, 0.041666666666667
16174, 0.54166666666667, 0.35, 0.041666666666667
16175, 0.54166666666667, 0.4, 0.041666666666667
16176, 0.54166666666667, 0.45, 0.041666666666667
16177, 0.54166666666667, 0.5, 0.041666666666667
16178, 0.54166666666667, 0.55, 0.041666666666667
16179, 0.54166666666667, 0.6, 0.041666666666667
16180, 0.54166666666667, 0.65, 0.041666666666667
16181, 0.54166666666667, 0.7, 0.041666666666667
16182, 0.54166666666667, 0.75, 0.041666666666667
16183, 0.54166666666667, 0.8, 0.041666666666667
16184, 0.54166666666667, 0.85, 0.041666666666667
16185, 0.54166666666667, 0.9, 0.041666666666667
16186, 0.54166666666667, 0.95, 0.041666666666667
16187, 0.54166666666667, 1, 0.041666666666667
16188, 0.54166666666667, 1.05, 0.041666666666667
16189, 0.54166666666667, 1.1, 0.041666666666667
16190, 0.54166666666667, 1.15, 0.041666666666667
16191, 0.54166666666667, 1.2, 0.041666666666667
16192, 0.54166666666667, 1.25, 0.041666666666667
16193, 0.54166666666667, 1.3, 0.041666666666667
16194, 0.54166666666667, 0.2, 0.083333333333333
16195, 0.54166666666667, 0.25, 0.083333333333333
16196, 0.54166666666667, 0.3, 0.083333333333333
16197, 0.54166666666667, 0.35, 0.083333333333333
16198, 0.54166666666667, 0.4, 0.083333333333333
16199, 0.54166666666667, 0.45, 0.083333333333333
16200, 0.54166666666667, 0.5, 0.083333333333333
16201, 0.54166666666667, 0.55, 0.083333333333333
16202, 0.54166666666667, 0.6, 0.083333333333333
16203, 0.54166666666667, 0.65, 0.083333333333333
16204, 0.54166666666667, 0.7, 0.083333333333333
16205, 0.54166666666667, 0.75, 0.083333333333333
16206, 0.54166666666667, 0.8, 0.083333333333333
16207, 0.54166666666667, 0.85, 0.083333333333333
16208, 0.54166666666667, 0.9, 0.083333333333333
16209, 0.54166666666667, 0.95, 0.083333333333333
16210, 0.54166666666667, 1, 0.083333333333333
16211, 0.54166666666667, 1.05, 0.083333333333333
16212, 0.54166666666667, 1.1, 0.083333333333333
16213, 0.54166666666667, 1.15, 0.083333333333333
16214, 0.54166666666667, 1.2, 0.083333333333333
16215, 0.54166666666667, 1.25, 0.083333333333333
16216, 0.54166666666667, 1.3, 0.083333333333333
16217, 0.54166666666667, 0.2, 0.125
16218, 0.54166666666667, 0.25, 0.125
16219, 0.54166666666667, 0.3, 0.125
16220, 0.54166666666667, 0.35, 0.125
16221, 0.54166666666667, 0.4, 0.125
16222, 0.54166666666667, 0.45, 0.125
16223, 0.54166666666667, 0.5, 0.125
16224, 0.54166666666667, 0.55, 0.125
16225, 0.54166666666667, 0.6, 0.125
16226, 0.54166666666667, 0.65, 0.125
16227, 0.54166666666667, 0.7, 0.125
16228, 0.54166666666667, 0.75, 0.125
16229, 0.54166666666667, 0.8, 0.125
16230, 0.54166666666667, 0.85, 0.125
16231, 0.54166666666667, 0.9, 0.125
16232, 0.54166666666667, 0.95, 0.125
16233, 0.54166666666667, 1, 0.125
16234, 0.54166666666667, 1.05, 0.125
16235, 0.54166666666667, 1.1, 0.125
16236, 0.54166666666667, 1.15, 0.125
16237, 0.54166666666667, 1.2, 0.125
16238, 0.54166666666667, 1.25, 0.125
16239, 0.54166666666667, 1.3, 0.125
16240, 0.54166666666667, 0.2, 0.16666666666667
16241, 0.54166666666667, 0.25, 0.16666666666667
16242, 0.54166666666667, 0.3, 0.16666666666667
16243, 0.54166666666667, 0.35, 0.16666666666667
16244, 0.54166666666667, 0.4, 0.16666666666667
16245, 0.54166666666667, 0.45, 0.16666666666667
16246, 0.54166666666667, 0.5, 0.16666666666667
16247, 0.54166666666667, 0.55, 0.16666666666667
16248, 0.54166666666667, 0.6, 0.16666666666667
16249, 0.54166666666667, 0.65, 0.16666666666667
16250, 0.54166666666667, 0.7, 0.16666666666667
16251, 0.54166666666667, 0.75, 0.16666666666667
16252, 0.54166666666667, 0.8, 0.16666666666667
16253, 0.54166666666667, 0.85, 0.16666666666667
16254, 0.54166666666667, 0.9, 0.16666666666667
16255, 0.54166666666667, 0.95, 0.16666666666667
16256, 0.54166666666667, 1, 0.16666666666667
16257, 0.54166666666667, 1.05, 0.16666666666667
16258, 0.54166666666667, 1.1, 0.16666666666667
16259, 0.54166666666667, 1.15, 0.16666666666667
16260, 0.54166666666667, 1.2, 0.16666666666667
16261, 0.54166666666667, 1.25, 0.16666666666667
16262, 0.54166666666667, 1.3, 0.16666666666667
16263, 0.54166666666667, 0.2, 0.20833333333333
16264, 0.54166666666667, 0.25, 0.20833333333333
16265, 0.54166666666667, 0.3, 0.20833333333333
16266, 0.54166666666667, 0.35, 0.20833333333333
16267, 0.54166666666667, 0.4, 0.20833333333333
16268, 0.54166666666667, 0.45, 0.20833333333333
16269, 0.54166666666667, 0.5, 0.20833333333333
16270, 0.54166666666667, 0.55, 0.20833333333333
16271, 0.54166666666667, 0.6, 0.20833333333333
16272, 0.54166666666667, 0.65, 0.20833333333333
16273, 0.54166666666667, 0.7, 0.20833333333333
16274, 0.54166666666667, 0.75, 0.20833333333333
16275, 0.54166666666667, 0.8, 0.20833333333333
16276, 0.54166666666667, 0.85, 0.20833333333333
16277, 0.54166666666667, 0.9, 0.20833333333333
16278, 0.54166666666667, 0.95, 0.20833333333333
16279, 0.54166666666667, 1, 0.20833333333333
16280, 0.54166666666667, 1.05, 0.20833333333333
16281, 0.54166666666667, 1.1, 0.20833333333333
16282, 0.54166666666667, 1.15, 0.20833333333333
16283, 0.54166666666667, 1.2, 0.20833333333333
16284, 0.54166666666667, 1.25, 0.20833333333333
16285, 0.54166666666667, 1.3, 0.20833333333333
16286, 0.54166666666667, 0.2, 0.25
16287, 0.54166666666667, 0.25, 0.25
16288, 0.54166666666667, 0.3, 0.25
16289, 0.54166666666667, 0.35, 0.25
16290, 0.54166666666667, 0.4, 0.25
16291, 0.54166666666667, 0.45, 0.25
16292, 0.54166666666667, 0.5, 0.25
16293, 0.54166666666667, 0.55, 0.25
16294, 0.54166666666667, 0.6, 0.25
16295, 0.54166666666667, 0.65, 0.25
16296, 0.54166666666667, 0.7, 0.25
16297, 0.54166666666667, 0.75, 0.25
16298, 0.54166666666667, 0.8, 0.25
16299, 0.54166666666667, 0.85, 0.25
16300, 0.54166666666667, 0.9, 0.25
16301, 0.54166666666667, 0.95, 0.25
16302, 0.54166666666667, 1, 0.25
16303, 0.54166666666667, 1.05, 0.25
16304, 0.54166666666667, 1.1, 0.25
16305, 0.54166666666667, 1.15, 0.25
16306, 0.54166666666667, 1.2, 0.25
16307, 0.54166666666667, 1.25, 0.25
16308, 0.54166666666667, 1.3, 0.25
16309, 0.54166666666667, 0.2, 0.29166666666667
16310, 0.54166666666667, 0.25, 0.29166666666667
16311, 0.54166666666667, 0.3, 0.29166666666667
16312, 0.54166666666667, 0.35, 0.29166666666667
16313, 0.54166666666667, 0.4, 0.29166666666667
16314, 0.54166666666667, 0.45, 0.29166666666667
16315, 0.54166666666667, 0.5, 0.29166666666667
16316, 0.54166666666667, 0.55, 0.29166666666667
16317, 0.54166666666667, 0.6, 0.29166666666667
16318, 0.54166666666667, 0.65, 0.29166666666667
16319, 0.54166666666667, 0.7, 0.29166666666667
16320, 0.54166666666667, 0.75, 0.29166666666667
16321, 0.54166666666667, 0.8, 0.29166666666667
16322, 0.54166666666667, 0.85, 0.29166666666667
16323, 0.54166666666667, 0.9, 0.29166666666667
16324, 0.54166666666667, 0.95, 0.29166666666667
16325, 0.54166666666667, 1, 0.29166666666667
16326, 0.54166666666667, 1.05, 0.29166666666667
16327, 0.54166666666667, 1.1, 0.29166666666667
16328, 0.54166666666667, 1.15, 0.29166666666667
16329, 0.54166666666667, 1.2, 0.29166666666667
16330, 0.54166666666667, 1.25, 0.29166666666667
16331, 0.54166666666667, 1.3, 0.29166666666667
16332, 0.54166666666667, 0.2, 0.33333333333333
16333, 0.54166666666667, 0.25, 0.33333333333333
16334, 0.54166666666667, 0.3, 0.33333333333333
16335, 0.54166666666667, 0.35, 0.33333333333333
16336, 0.54166666666667, 0.4, 0.33333333333333
16337, 0.54166666666667, 0.45, 0.33333333333333
16338, 0.54166666666667, 0.5, 0.33333333333333
16339, 0.54166666666667, 0.55, 0.33333333333333
16340, 0.54166666666667, 0.6, 0.33333333333333
16341, 0.54166666666667, 0.65, 0.33333333333333
16342, 0.54166666666667, 0.7, 0.33333333333333
16343, 0.54166666666667, 0.75, 0.33333333333333
16344, 0.54166666666667, 0.8, 0.33333333333333
16345, 0.54166666666667, 0.85, 0.33333333333333
16346, 0.54166666666667, 0.9, 0.33333333333333
16347, 0.54166666666667, 0.95, 0.33333333333333
16348, 0.54166666666667, 1, 0.33333333333333
16349, 0.54166666666667, 1.05, 0.33333333333333
16350, 0.54166666666667, 1.1, 0.33333333333333
16351, 0.54166666666667, 1.15, 0.33333333333333
16352, 0.54166666666667, 1.2, 0.33333333333333
16353, 0.54166666666667, 1.25, 0.33333333333333
16354, 0.54166666666667, 1.3, 0.33333333333333
16355, 0.54166666666667, 0.2, 0.375
16356, 0.54166666666667, 0.25, 0.375
16357, 0.54166666666667, 0.3, 0.375
16358, 0.54166666666667, 0.35, 0.375
16359, 0.54166666666667, 0.4, 0.375
16360, 0.54166666666667, 0.45, 0.375
16361, 0.54166666666667, 0.5, 0.375
16362, 0.54166666666667, 0.55, 0.375
16363, 0.54166666666667, 0.6, 0.375
16364, 0.54166666666667, 0.65, 0.375
16365, 0.54166666666667, 0.7, 0.375
16366, 0.54166666666667, 0.75, 0.375
16367, 0.54166666666667, 0.8, 0.375
16368, 0.54166666666667, 0.85, 0.375
16369, 0.54166666666667, 0.9, 0.375
16370, 0.54166666666667, 0.95, 0.375
16371, 0.54166666666667, 1, 0.375
16372, 0.54166666666667, 1.05, 0.375
16373, 0.54166666666667, 1.1, 0.375
16374, 0.54166666666667, 1.15, 0.375
16375, 0.54166666666667, 1.2, 0.375
16376, 0.54166666666667, 1.25, 0.375
16377, 0.54166666666667, 1.3, 0.375
16378, 0.54166666666667, 0.2, 0.41666666666667
16379, 0.54166666666667, 0.25, 0.41666666666667
16380, 0.54166666666667, 0.3, 0.41666666666667
16381, 0.54166666666667, 0.35, 0.41666666666667
16382, 0.54166666666667, 0.4, 0.41666666666667
16383, 0.54166666666667, 0.45, 0.41666666666667
16384, 0.54166666666667, 0.5, 0.41666666666667
16385, 0.54166666666667, 0.55, 0.41666666666667
16386, 0.54166666666667, 0.6, 0.41666666666667
16387, 0.54166666666667, 0.65, 0.41666666666667
16388, 0.54166666666667, 0.7, 0.41666666666667
16389, 0.54166666666667, 0.75, 0.41666666666667
16390, 0.54166666666667, 0.8, 0.41666666666667
16391, 0.54166666666667, 0.85, 0.41666666666667
16392, 0.54166666666667, 0.9, 0.41666666666667
16393, 0.54166666666667, 0.95, 0.41666666666667
16394, 0.54166666666667, 1, 0.41666666666667
16395, 0.54166666666667, 1.05, 0.41666666666667
16396, 0.54166666666667, 1.1, 0.41666666666667
16397, 0.54166666666667, 1.15, 0.41666666666667
16398, 0.54166666666667, 1.2, 0.41666666666667
16399, 0.54166666666667, 1.25, 0.41666666666667
16400, 0.54166666666667, 1.3, 0.41666666666667
16401, 0.54166666666667, 0.2, 0.45833333333333
16402, 0.54166666666667, 0.25, 0.45833333333333
16403, 0.54166666666667, 0.3, 0.45833333333333
16404, 0.54166666666667, 0.35, 0.45833333333333
16405, 0.54166666666667, 0.4, 0.45833333333333
16406, 0.54166666666667, 0.45, 0.45833333333333
16407, 0.54166666666667, 0.5, 0.45833333333333
16408, 0.54166666666667, 0.55, 0.45833333333333
16409, 0.54166666666667, 0.6, 0.45833333333333
16410, 0.54166666666667, 0.65, 0.45833333333333
16411, 0.54166666666667, 0.7, 0.45833333333333
16412, 0.54166666666667, 0.75, 0.45833333333333
16413, 0.54166666666667, 0.8, 0.45833333333333
16414, 0.54166666666667, 0.85, 0.45833333333333
16415, 0.54166666666667, 0.9, 0.45833333333333
16416, 0.54166666666667, 0.95, 0.45833333333333
16417, 0.54166666666667, 1, 0.45833333333333
16418, 0.54166666666667, 1.05, 0.45833333333333
16419, 0.54166666666667, 1.1, 0.45833333333333
16420, 0.54166666666667, 1.15, 0.45833333333333
16421, 0.54166666666667, 1.2, 0.45833333333333
16422, 0.54166666666667, 1.25, 0.45833333333333
16423, 0.54166666666667, 1.3, 0.45833333333333
16424, 0.58333333333333, 0.2, 0.041666666666667
16425, 0.58333333333333, 0.25, 0.041666666666667
16426, 0.58333333333333, 0.3, 0.041666666666667
16427, 0.58333333333333, 0.35, 0.041666666666667
16428, 0.58333333333333, 0.4, 0.041666666666667
16429, 0.58333333333333, 0.45, 0.041666666666667
16430, 0.58333333333333, 0.5, 0.041666666666667
16431, 0.58333333333333, 0.55, 0.041666666666667
16432, 0.58333333333333, 0.6, 0.041666666666667
16433, 0.58333333333333, 0.65, 0.041666666666667
16434, 0.58333333333333, 0.7, 0.041666666666667
16435, 0.58333333333333, 0.75, 0.041666666666667
16436, 0.58333333333333, 0.8, 0.041666666666667
16437, 0.58333333333333, 0.85, 0.041666666666667
16438, 0.58333333333333, 0.9, 0.041666666666667
16439, 0.58333333333333, 0.95, 0.041666666666667
16440, 0.58333333333333, 1, 0.041666666666667
16441, 0.58333333333333, 1.05, 0.041666666666667
16442, 0.58333333333333, 1.1, 0.041666666666667
16443, 0.58333333333333, 1.15, 0.041666666666667
16444, 0.58333333333333, 1.2, 0.041666666666667
16445, 0.58333333333333, 1.25, 0.041666666666667
16446, 0.58333333333333, 1.3, 0.041666666666667
16447, 0.58333333333333, 0.2, 0.083333333333333
16448, 0.58333333333333, 0.25, 0.083333333333333
16449, 0.58333333333333, 0.3, 0.083333333333333
16450, 0.58333333333333, 0.35, 0.083333333333333
16451, 0.58333333333333, 0.4, 0.083333333333333
16452, 0.58333333333333, 0.45, 0.083333333333333
16453, 0.58333333333333, 0.5, 0.083333333333333
16454, 0.58333333333333, 0.55, 0.083333333333333
16455, 0.58333333333333, 0.6, 0.083333333333333
16456, 0.58333333333333, 0.65, 0.083333333333333
16457, 0.58333333333333, 0.7, 0.083333333333333
16458, 0.58333333333333, 0.75, 0.083333333333333
16459, 0.58333333333333, 0.8, 0.083333333333333
16460, 0.58333333333333, 0.85, 0.083333333333333
16461, 0.58333333333333, 0.9, 0.083333333333333
16462, 0.58333333333333, 0.95, 0.083333333333333
16463, 0.58333333333333, 1, 0.083333333333333
16464, 0.58333333333333, 1.05, 0.083333333333333
16465, 0.58333333333333, 1.1, 0.083333333333333
16466, 0.58333333333333, 1.15, 0.083333333333333
16467, 0.58333333333333, 1.2, 0.083333333333333
16468, 0.58333333333333, 1.25, 0.083333333333333
16469, 0.58333333333333, 1.3, 0.083333333333333
16470, 0.58333333333333, 0.2, 0.125
16471, 0.58333333333333, 0.25, 0.125
16472, 0.58333333333333, 0.3, 0.125
16473, 0.58333333333333, 0.35, 0.125
16474, 0.58333333333333, 0.4, 0.125
16475, 0.58333333333333, 0.45, 0.125
16476, 0.58333333333333, 0.5, 0.125
16477, 0.58333333333333, 0.55, 0.125
16478, 0.58333333333333, 0.6, 0.125
16479, 0.58333333333333, 0.65, 0.125
16480, 0.58333333333333, 0.7, 0.125
16481, 0.58333333333333, 0.75, 0.125
16482, 0.58333333333333, 0.8, 0.125
16483, 0.58333333333333, 0.85, 0.125
16484, 0.58333333333333, 0.9, 0.125
16485, 0.58333333333333, 0.95, 0.125
16486, 0.58333333333333, 1, 0.125
16487, 0.58333333333333, 1.05, 0.125
16488, 0.58333333333333, 1.1, 0.125
16489, 0.58333333333333, 1.15, 0.125
16490, 0.58333333333333, 1.2, 0.125
16491, 0.58333333333333, 1.25, 0.125
16492, 0.58333333333333, 1.3, 0.125
16493, 0.58333333333333, 0.2, 0.16666666666667
16494, 0.58333333333333, 0.25, 0.16666666666667
16495, 0.58333333333333, 0.3, 0.16666666666667
16496, 0.58333333333333, 0.35, 0.16666666666667
16497, 0.58333333333333, 0.4, 0.16666666666667
16498, 0.58333333333333, 0.45, 0.16666666666667
16499, 0.58333333333333, 0.5, 0.16666666666667
16500, 0.58333333333333, 0.55, 0.16666666666667
16501, 0.58333333333333, 0.6, 0.16666666666667
16502, 0.58333333333333, 0.65, 0.16666666666667
16503, 0.58333333333333, 0.7, 0.16666666666667
16504, 0.58333333333333, 0.75, 0.16666666666667
16505, 0.58333333333333, 0.8, 0.16666666666667
16506, 0.58333333333333, 0.85, 0.16666666666667
16507, 0.58333333333333, 0.9, 0.16666666666667
16508, 0.58333333333333, 0.95, 0.16666666666667
16509, 0.58333333333333, 1, 0.16666666666667
16510, 0.58333333333333, 1.05, 0.16666666666667
16511, 0.58333333333333, 1.1, 0.16666666666667
16512, 0.58333333333333, 1.15, 0.16666666666667
16513, 0.58333333333333, 1.2, 0.16666666666667
16514, 0.58333333333333, 1.25, 0.16666666666667
16515, 0.58333333333333, 1.3, 0.16666666666667
16516, 0.58333333333333, 0.2, 0.20833333333333
16517, 0.58333333333333, 0.25, 0.20833333333333
16518, 0.58333333333333, 0.3, 0.20833333333333
16519, 0.58333333333333, 0.35, 0.20833333333333
16520, 0.58333333333333, 0.4, 0.20833333333333
16521, 0.58333333333333, 0.45, 0.20833333333333
16522, 0.58333333333333, 0.5, 0.20833333333333
16523, 0.58333333333333, 0.55, 0.20833333333333
16524, 0.58333333333333, 0.6, 0.20833333333333
16525, 0.58333333333333, 0.65, 0.20833333333333
16526, 0.58333333333333, 0.7, 0.20833333333333
16527, 0.58333333333333, 0.75, 0.20833333333333
16528, 0.58333333333333, 0.8, 0.20833333333333
16529, 0.58333333333333, 0.85, 0.20833333333333
16530, 0.58333333333333, 0.9, 0.20833333333333
16531, 0.58333333333333, 0.95, 0.20833333333333
16532, 0.58333333333333, 1, 0.20833333333333
16533, 0.58333333333333, 1.05, 0.20833333333333
16534, 0.58333333333333, 1.1, 0.20833333333333
16535, 0.58333333333333, 1.15, 0.20833333333333
16536, 0.58333333333333, 1.2, 0.20833333333333
16537, 0.58333333333333, 1.25, 0.20833333333333
16538, 0.58333333333333, 1.3, 0.20833333333333
16539, 0.58333333333333, 0.2, 0.25
16540, 0.58333333333333, 0.25, 0.25
16541, 0.58333333333333, 0.3, 0.25
16542, 0.58333333333333, 0.35, 0.25
16543, 0.58333333333333, 0.4, 0.25
16544, 0.58333333333333, 0.45, 0.25
16545, 0.58333333333333, 0.5, 0.25
16546, 0.58333333333333, 0.55, 0.25
16547, 0.58333333333333, 0.6, 0.25
16548, 0.58333333333333, 0.65, 0.25
16549, 0.58333333333333, 0.7, 0.25
16550, 0.58333333333333, 0.75, 0.25
16551, 0.58333333333333, 0.8, 0.25
16552, 0.58333333333333, 0.85, 0.25
16553, 0.58333333333333, 0.9, 0.25
16554, 0.58333333333333, 0.95, 0.25
16555, 0.58333333333333, 1, 0.25
16556, 0.58333333333333, 1.05, 0.25
16557, 0.58333333333333, 1.1, 0.25
16558, 0.58333333333333, 1.15, 0.25
16559, 0.58333333333333, 1.2, 0.25
16560, 0.58333333333333, 1.25, 0.25
16561, 0.58333333333333, 1.3, 0.25
16562, 0.58333333333333, 0.2, 0.29166666666667
16563, 0.58333333333333, 0.25, 0.29166666666667
16564, 0.58333333333333, 0.3, 0.29166666666667
16565, 0.58333333333333, 0.35, 0.29166666666667
16566, 0.58333333333333, 0.4, 0.29166666666667
16567, 0.58333333333333, 0.45, 0.29166666666667
16568, 0.58333333333333, 0.5, 0.29166666666667
16569, 0.58333333333333, 0.55, 0.29166666666667
16570, 0.58333333333333, 0.6, 0.29166666666667
16571, 0.58333333333333, 0.65, 0.29166666666667
16572, 0.58333333333333, 0.7, 0.29166666666667
16573, 0.58333333333333, 0.75, 0.29166666666667
16574, 0.58333333333333, 0.8, 0.29166666666667
16575, 0.58333333333333, 0.85, 0.29166666666667
16576, 0.58333333333333, 0.9, 0.29166666666667
16577, 0.58333333333333, 0.95, 0.29166666666667
16578, 0.58333333333333, 1, 0.29166666666667
16579, 0.58333333333333, 1.05, 0.29166666666667
16580, 0.58333333333333, 1.1, 0.29166666666667
16581, 0.58333333333333, 1.15, 0.29166666666667
16582, 0.58333333333333, 1.2, 0.29166666666667
16583, 0.58333333333333, 1.25, 0.29166666666667
16584, 0.58333333333333, 1.3, 0.29166666666667
16585, 0.58333333333333, 0.2, 0.33333333333333
16586, 0.58333333333333, 0.25, 0.33333333333333
16587, 0.58333333333333, 0.3, 0.33333333333333
16588, 0.58333333333333, 0.35, 0.33333333333333
16589, 0.58333333333333, 0.4, 0.33333333333333
16590, 0.58333333333333, 0.45, 0.33333333333333
16591, 0.58333333333333, 0.5, 0.33333333333333
16592, 0.58333333333333, 0.55, 0.33333333333333
16593, 0.58333333333333, 0.6, 0.33333333333333
16594, 0.58333333333333, 0.65, 0.33333333333333
16595, 0.58333333333333, 0.7, 0.33333333333333
16596, 0.58333333333333, 0.75, 0.33333333333333
16597, 0.58333333333333, 0.8, 0.33333333333333
16598, 0.58333333333333, 0.85, 0.33333333333333
16599, 0.58333333333333, 0.9, 0.33333333333333
16600, 0.58333333333333, 0.95, 0.33333333333333
16601, 0.58333333333333, 1, 0.33333333333333
16602, 0.58333333333333, 1.05, 0.33333333333333
16603, 0.58333333333333, 1.1, 0.33333333333333
16604, 0.58333333333333, 1.15, 0.33333333333333
16605, 0.58333333333333, 1.2, 0.33333333333333
16606, 0.58333333333333, 1.25, 0.33333333333333
16607, 0.58333333333333, 1.3, 0.33333333333333
16608, 0.58333333333333, 0.2, 0.375
16609, 0.58333333333333, 0.25, 0.375
16610, 0.58333333333333, 0.3, 0.375
16611, 0.58333333333333, 0.35, 0.375
16612, 0.58333333333333, 0.4, 0.375
16613, 0.58333333333333, 0.45, 0.375
16614, 0.58333333333333, 0.5, 0.375
16615, 0.58333333333333, 0.55, 0.375
16616, 0.58333333333333, 0.6, 0.375
16617, 0.58333333333333, 0.65, 0.375
16618, 0.58333333333333, 0.7, 0.375
16619, 0.58333333333333, 0.75, 0.375
16620, 0.58333333333333, 0.8, 0.375
16621, 0.58333333333333, 0.85, 0.375
16622, 0.58333333333333, 0.9, 0.375
16623, 0.58333333333333, 0.95, 0.375
16624, 0.58333333333333, 1, 0.375
16625, 0.58333333333333, 1.05, 0.375
16626, 0.58333333333333, 1.1, 0.375
16627, 0.58333333333333, 1.15, 0.375
16628, 0.58333333333333, 1.2, 0.375
16629, 0.58333333333333, 1.25, 0.375
16630, 0.58333333333333, 1.3, 0.375
16631, 0.58333333333333, 0.2, 0.41666666666667
16632, 0.58333333333333, 0.25, 0.41666666666667
16633, 0.58333333333333, 0.3, 0.41666666666667
16634, 0.58333333333333, 0.35, 0.41666666666667
16635, 0.58333333333333, 0.4, 0.41666666666667
16636, 0.58333333333333, 0.45, 0.41666666666667
16637, 0.58333333333333, 0.5, 0.41666666666667
16638, 0.58333333333333, 0.55, 0.41666666666667
16639, 0.58333333333333, 0.6, 0.41666666666667
16640, 0.58333333333333, 0.65, 0.41666666666667
16641, 0.58333333333333, 0.7, 0.41666666666667
16642, 0.58333333333333, 0.75, 0.41666666666667
16643, 0.58333333333333, 0.8, 0.41666666666667
16644, 0.58333333333333, 0.85, 0.41666666666667
16645, 0.58333333333333, 0.9, 0.41666666666667
16646, 0.58333333333333, 0.95, 0.41666666666667
16647, 0.58333333333333, 1, 0.41666666666667
16648, 0.58333333333333, 1.05, 0.41666666666667
16649, 0.58333333333333, 1.1, 0.41666666666667
16650, 0.58333333333333, 1.15, 0.41666666666667
16651, 0.58333333333333, 1.2, 0.41666666666667
16652, 0.58333333333333, 1.25, 0.41666666666667
16653, 0.58333333333333, 1.3, 0.41666666666667
16654, 0.58333333333333, 0.2, 0.45833333333333
16655, 0.58333333333333, 0.25, 0.45833333333333
16656, 0.58333333333333, 0.3, 0.45833333333333
16657, 0.58333333333333, 0.35, 0.45833333333333
16658, 0.58333333333333, 0.4, 0.45833333333333
16659, 0.58333333333333, 0.45, 0.45833333333333
16660, 0.58333333333333, 0.5, 0.45833333333333
16661, 0.58333333333333, 0.55, 0.45833333333333
16662, 0.58333333333333, 0.6, 0.45833333333333
16663, 0.58333333333333, 0.65, 0.45833333333333
16664, 0.58333333333333, 0.7, 0.45833333333333
16665, 0.58333333333333, 0.75, 0.45833333333333
16666, 0.58333333333333, 0.8, 0.45833333333333
16667, 0.58333333333333, 0.85, 0.45833333333333
16668, 0.58333333333333, 0.9, 0.45833333333333
16669, 0.58333333333333, 0.95, 0.45833333333333
16670, 0.58333333333333, 1, 0.45833333333333
16671, 0.58333333333333, 1.05, 0.45833333333333
16672, 0.58333333333333, 1.1, 0.45833333333333
16673, 0.58333333333333, 1.15, 0.45833333333333
16674, 0.58333333333333, 1.2, 0.45833333333333
16675, 0.58333333333333, 1.25, 0.45833333333333
16676, 0.58333333333333, 1.3, 0.45833333333333
16677, 0.625, 0.2, 0.041666666666667
16678, 0.625, 0.25, 0.041666666666667
16679, 0.625, 0.3, 0.041666666666667
16680, 0.625, 0.35, 0.041666666666667
16681, 0.625, 0.4, 0.041666666666667
16682, 0.625, 0.45, 0.041666666666667
16683, 0.625, 0.5, 0.041666666666667
16684, 0.625, 0.55, 0.041666666666667
16685, 0.625, 0.6, 0.041666666666667
16686, 0.625, 0.65, 0.041666666666667
16687, 0.625, 0.7, 0.041666666666667
16688, 0.625, 0.75, 0.041666666666667
16689, 0.625, 0.8, 0.041666666666667
16690, 0.625, 0.85, 0.041666666666667
16691, 0.625, 0.9, 0.041666666666667
16692, 0.625, 0.95, 0.041666666666667
16693, 0.625, 1, 0.041666666666667
16694, 0.625, 1.05, 0.041666666666667
16695, 0.625, 1.1, 0.041666666666667
16696, 0.625, 1.15, 0.041666666666667
16697, 0.625, 1.2, 0.041666666666667
16698, 0.625, 1.25, 0.041666666666667
16699, 0.625, 1.3, 0.041666666666667
16700, 0.625, 0.2, 0.083333333333333
16701, 0.625, 0.25, 0.083333333333333
16702, 0.625, 0.3, 0.083333333333333
16703, 0.625, 0.35, 0.083333333333333
16704, 0.625, 0.4, 0.083333333333333
16705, 0.625, 0.45, 0.083333333333333
16706, 0.625, 0.5, 0.083333333333333
16707, 0.625, 0.55, 0.083333333333333
16708, 0.625, 0.6, 0.083333333333333
16709, 0.625, 0.65, 0.083333333333333
16710, 0.625, 0.7, 0.083333333333333
16711, 0.625, 0.75, 0.083333333333333
16712, 0.625, 0.8, 0.083333333333333
16713, 0.625, 0.85, 0.083333333333333
16714, 0.625, 0.9, 0.083333333333333
16715, 0.625, 0.95, 0.083333333333333
16716, 0.625, 1, 0.083333333333333
16717, 0.625, 1.05, 0.083333333333333
16718, 0.625, 1.1, 0.083333333333333
16719, 0.625, 1.15, 0.083333333333333
16720, 0.625, 1.2, 0.083333333333333
16721, 0.625, 1.25, 0.083333333333333
16722, 0.625, 1.3, 0.083333333333333
16723, 0.625, 0.2, 0.125
16724, 0.625, 0.25, 0.125
16725, 0.625, 0.3, 0.125
16726, 0.625, 0.35, 0.125
16727, 0.625, 0.4, 0.125
16728, 0.625, 0.45, 0.125
16729, 0.625, 0.5, 0.125
16730, 0.625, 0.55, 0.125
16731, 0.625, 0.6, 0.125
16732, 0.625, 0.65, 0.125
16733, 0.625, 0.7, 0.125
16734, 0.625, 0.75, 0.125
16735, 0.625, 0.8, 0.125
16736, 0.625, 0.85, 0.125
16737, 0.625, 0.9, 0.125
16738, 0.625, 0.95, 0.125
16739, 0.625, 1, 0.125
16740, 0.625, 1.05, 0.125
16741, 0.625, 1.1, 0.125
16742, 0.625, 1.15, 0.125
16743, 0.625, 1.2, 0.125
16744, 0.625, 1.25, 0.125
16745, 0.625, 1.3, 0.125
16746, 0.625, 0.2, 0.16666666666667
16747, 0.625, 0.25, 0.16666666666667
16748, 0.625, 0.3, 0.16666666666667
16749, 0.625, 0.35, 0.16666666666667
16750, 0.625, 0.4, 0.16666666666667
16751, 0.625, 0.45, 0.16666666666667
16752, 0.625, 0.5, 0.16666666666667
16753, 0.625, 0.55, 0.16666666666667
16754, 0.625, 0.6, 0.16666666666667
16755, 0.625, 0.65, 0.16666666666667
16756, 0.625, 0.7, 0.16666666666667
16757, 0.625, 0.75, 0.16666666666667
16758, 0.625, 0.8, 0.16666666666667
16759, 0.625, 0.85, 0.16666666666667
16760, 0.625, 0.9, 0.16666666666667
16761, 0.625, 0.95, 0.16666666666667
16762, 0.625, 1, 0.16666666666667
16763, 0.625, 1.05, 0.16666666666667
16764, 0.625, 1.1, 0.16666666666667
16765, 0.625, 1.15, 0.16666666666667
16766, 0.625, 1.2, 0.16666666666667
16767, 0.625, 1.25, 0.16666666666667
16768, 0.625, 1.3, 0.16666666666667
16769, 0.625, 0.2, 0.20833333333333
16770, 0.625, 0.25, 0.20833333333333
16771, 0.625, 0.3, 0.20833333333333
16772, 0.625, 0.35, 0.20833333333333
16773, 0.625, 0.4, 0.20833333333333
16774, 0.625, 0.45, 0.20833333333333
16775, 0.625, 0.5, 0.20833333333333
16776, 0.625, 0.55, 0.20833333333333
16777, 0.625, 0.6, 0.20833333333333
16778, 0.625, 0.65, 0.20833333333333
16779, 0.625, 0.7, 0.20833333333333
16780, 0.625, 0.75, 0.20833333333333
16781, 0.625, 0.8, 0.20833333333333
16782, 0.625, 0.85, 0.20833333333333
16783, 0.625, 0.9, 0.20833333333333
16784, 0.625, 0.95, 0.20833333333333
16785, 0.625, 1, 0.20833333333333
16786, 0.625, 1.05, 0.20833333333333
16787, 0.625, 1.1, 0.20833333333333
16788, 0.625, 1.15, 0.20833333333333
16789, 0.625, 1.2, 0.20833333333333
16790, 0.625, 1.25, 0.20833333333333
16791, 0.625, 1.3, 0.20833333333333
16792, 0.625, 0.2, 0.25
16793, 0.625, 0.25, 0.25
16794, 0.625, 0.3, 0.25
16795, 0.625, 0.35, 0.25
16796, 0.625, 0.4, 0.25
16797, 0.625, 0.45, 0.25
16798, 0.625, 0.5, 0.25
16799, 0.625, 0.55, 0.25
16800, 0.625, 0.6, 0.25
16801, 0.625, 0.65, 0.25
16802, 0.625, 0.7, 0.25
16803, 0.625, 0.75, 0.25
16804, 0.625, 0.8, 0.25
16805, 0.625, 0.85, 0.25
16806, 0.625, 0.9, 0.25
16807, 0.625, 0.95, 0.25
