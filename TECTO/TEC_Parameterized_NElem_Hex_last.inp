12019, -0.1, -0.16, 0.041666666666667
12020, -0.1, -0.04, 0.083333333333333
12021, -0.1, -0.08, 0.083333333333333
12022, -0.1, -0.12, 0.083333333333333
12023, -0.1, -0.16, 0.083333333333333
12024, -0.1, -0.04, 0.125
12025, -0.1, -0.08, 0.125
12026, -0.1, -0.12, 0.125
12027, -0.1, -0.16, 0.125
12028, -0.1, -0.04, 0.16666666666667
12029, -0.1, -0.08, 0.16666666666667
12030, -0.1, -0.12, 0.16666666666667
12031, -0.1, -0.16, 0.16666666666667
12032, -0.1, -0.04, 0.20833333333333
12033, -0.1, -0.08, 0.20833333333333
12034, -0.1, -0.12, 0.20833333333333
12035, -0.1, -0.16, 0.20833333333333
12036, -0.1, -0.04, 0.25
12037, -0.1, -0.08, 0.25
12038, -0.1, -0.12, 0.25
12039, -0.1, -0.16, 0.25
12040, -0.1, -0.04, 0.29166666666667
12041, -0.1, -0.08, 0.29166666666667
12042, -0.1, -0.12, 0.29166666666667
12043, -0.1, -0.16, 0.29166666666667
12044, -0.1, -0.04, 0.33333333333333
12045, -0.1, -0.08, 0.33333333333333
12046, -0.1, -0.12, 0.33333333333333
12047, -0.1, -0.16, 0.33333333333333
12048, -0.1, -0.04, 0.375
12049, -0.1, -0.08, 0.375
12050, -0.1, -0.12, 0.375
12051, -0.1, -0.16, 0.375
12052, -0.1, -0.04, 0.41666666666667
12053, -0.1, -0.08, 0.41666666666667
12054, -0.1, -0.12, 0.41666666666667
12055, -0.1, -0.16, 0.41666666666667
12056, -0.1, -0.04, 0.45833333333333
12057, -0.1, -0.08, 0.45833333333333
12058, -0.1, -0.12, 0.45833333333333
12059, -0.1, -0.16, 0.45833333333333
12060, 1.2416666666667, -0.04, 0.5
12061, 1.2416666666667, -0.08, 0.5
12062, 1.2416666666667, -0.12, 0.5
12063, 1.2416666666667, -0.16, 0.5
12064, 1.2833333333333, -0.04, 0.5
12065, 1.2833333333333, -0.08, 0.5
12066, 1.2833333333333, -0.12, 0.5
12067, 1.2833333333333, -0.16, 0.5
12068, 1.325, -0.04, 0.5
12069, 1.325, -0.08, 0.5
12070, 1.325, -0.12, 0.5
12071, 1.325, -0.16, 0.5
12072, 1.3666666666667, -0.04, 0.5
12073, 1.3666666666667, -0.08, 0.5
12074, 1.3666666666667, -0.12, 0.5
12075, 1.3666666666667, -0.16, 0.5
12076, 1.4083333333333, -0.04, 0.5
12077, 1.4083333333333, -0.08, 0.5
12078, 1.4083333333333, -0.12, 0.5
12079, 1.4083333333333, -0.16, 0.5
12080, 1.45, -0.04, 0.5
12081, 1.45, -0.08, 0.5
12082, 1.45, -0.12, 0.5
12083, 1.45, -0.16, 0.5
12084, 1.4916666666667, -0.04, 0.5
12085, 1.4916666666667, -0.08, 0.5
12086, 1.4916666666667, -0.12, 0.5
12087, 1.4916666666667, -0.16, 0.5
12088, 1.5333333333333, -0.04, 0.5
12089, 1.5333333333333, -0.08, 0.5
12090, 1.5333333333333, -0.12, 0.5
12091, 1.5333333333333, -0.16, 0.5
12092, 1.575, -0.04, 0.5
12093, 1.575, -0.08, 0.5
12094, 1.575, -0.12, 0.5
12095, 1.575, -0.16, 0.5
12096, 1.6166666666667, -0.04, 0.5
12097, 1.6166666666667, -0.08, 0.5
12098, 1.6166666666667, -0.12, 0.5
12099, 1.6166666666667, -0.16, 0.5
12100, 1.6583333333333, -0.04, 0.5
12101, 1.6583333333333, -0.08, 0.5
12102, 1.6583333333333, -0.12, 0.5
12103, 1.6583333333333, -0.16, 0.5
12104, 1.7, -0.04, 0.5
12105, 1.7, -0.08, 0.5
12106, 1.7, -0.12, 0.5
12107, 1.7, -0.16, 0.5
12108, 1.7416666666667, -0.04, 0.5
12109, 1.7416666666667, -0.08, 0.5
12110, 1.7416666666667, -0.12, 0.5
12111, 1.7416666666667, -0.16, 0.5
12112, 1.7833333333333, -0.04, 0.5
12113, 1.7833333333333, -0.08, 0.5
12114, 1.7833333333333, -0.12, 0.5
12115, 1.7833333333333, -0.16, 0.5
12116, 1.825, -0.04, 0.5
12117, 1.825, -0.08, 0.5
12118, 1.825, -0.12, 0.5
12119, 1.825, -0.16, 0.5
12120, 1.8666666666667, -0.04, 0.5
12121, 1.8666666666667, -0.08, 0.5
12122, 1.8666666666667, -0.12, 0.5
12123, 1.8666666666667, -0.16, 0.5
12124, 1.9083333333333, -0.04, 0.5
12125, 1.9083333333333, -0.08, 0.5
12126, 1.9083333333333, -0.12, 0.5
12127, 1.9083333333333, -0.16, 0.5
12128, 1.95, -0.04, 0.5
12129, 1.95, -0.08, 0.5
12130, 1.95, -0.12, 0.5
12131, 1.95, -0.16, 0.5
12132, 1.9916666666667, -0.04, 0.5
12133, 1.9916666666667, -0.08, 0.5
12134, 1.9916666666667, -0.12, 0.5
12135, 1.9916666666667, -0.16, 0.5
12136, 2.0333333333333, -0.04, 0.5
12137, 2.0333333333333, -0.08, 0.5
12138, 2.0333333333333, -0.12, 0.5
12139, 2.0333333333333, -0.16, 0.5
12140, 2.075, -0.04, 0.5
12141, 2.075, -0.08, 0.5
12142, 2.075, -0.12, 0.5
12143, 2.075, -0.16, 0.5
12144, 2.1166666666667, -0.04, 0.5
12145, 2.1166666666667, -0.08, 0.5
12146, 2.1166666666667, -0.12, 0.5
12147, 2.1166666666667, -0.16, 0.5
12148, 2.1583333333333, -0.04, 0.5
12149, 2.1583333333333, -0.08, 0.5
12150, 2.1583333333333, -0.12, 0.5
12151, 2.1583333333333, -0.16, 0.5
12152, 1.2416666666667, -0.04, 0
12153, 1.2416666666667, -0.08, 0
12154, 1.2416666666667, -0.12, 0
12155, 1.2416666666667, -0.16, 0
12156, 1.2833333333333, -0.04, 0
12157, 1.2833333333333, -0.08, 0
12158, 1.2833333333333, -0.12, 0
12159, 1.2833333333333, -0.16, 0
12160, 1.325, -0.04, 0
12161, 1.325, -0.08, 0
12162, 1.325, -0.12, 0
12163, 1.325, -0.16, 0
12164, 1.3666666666667, -0.04, 0
12165, 1.3666666666667, -0.08, 0
12166, 1.3666666666667, -0.12, 0
12167, 1.3666666666667, -0.16, 0
12168, 1.4083333333333, -0.04, 0
12169, 1.4083333333333, -0.08, 0
12170, 1.4083333333333, -0.12, 0
12171, 1.4083333333333, -0.16, 0
12172, 1.45, -0.04, 0
12173, 1.45, -0.08, 0
12174, 1.45, -0.12, 0
12175, 1.45, -0.16, 0
12176, 1.4916666666667, -0.04, 0
12177, 1.4916666666667, -0.08, 0
12178, 1.4916666666667, -0.12, 0
12179, 1.4916666666667, -0.16, 0
12180, 1.5333333333333, -0.04, 0
12181, 1.5333333333333, -0.08, 0
12182, 1.5333333333333, -0.12, 0
12183, 1.5333333333333, -0.16, 0
12184, 1.575, -0.04, 0
12185, 1.575, -0.08, 0
12186, 1.575, -0.12, 0
12187, 1.575, -0.16, 0
12188, 1.6166666666667, -0.04, 0
12189, 1.6166666666667, -0.08, 0
12190, 1.6166666666667, -0.12, 0
12191, 1.6166666666667, -0.16, 0
12192, 1.6583333333333, -0.04, 0
12193, 1.6583333333333, -0.08, 0
12194, 1.6583333333333, -0.12, 0
12195, 1.6583333333333, -0.16, 0
12196, 1.7, -0.04, 0
12197, 1.7, -0.08, 0
12198, 1.7, -0.12, 0
12199, 1.7, -0.16, 0
12200, 1.7416666666667, -0.04, 0
12201, 1.7416666666667, -0.08, 0
12202, 1.7416666666667, -0.12, 0
12203, 1.7416666666667, -0.16, 0
12204, 1.7833333333333, -0.04, 0
12205, 1.7833333333333, -0.08, 0
12206, 1.7833333333333, -0.12, 0
12207, 1.7833333333333, -0.16, 0
12208, 1.825, -0.04, 0
12209, 1.825, -0.08, 0
12210, 1.825, -0.12, 0
12211, 1.825, -0.16, 0
12212, 1.8666666666667, -0.04, 0
12213, 1.8666666666667, -0.08, 0
12214, 1.8666666666667, -0.12, 0
12215, 1.8666666666667, -0.16, 0
12216, 1.9083333333333, -0.04, 0
12217, 1.9083333333333, -0.08, 0
12218, 1.9083333333333, -0.12, 0
12219, 1.9083333333333, -0.16, 0
12220, 1.95, -0.04, 0
12221, 1.95, -0.08, 0
12222, 1.95, -0.12, 0
12223, 1.95, -0.16, 0
12224, 1.9916666666667, -0.04, 0
12225, 1.9916666666667, -0.08, 0
12226, 1.9916666666667, -0.12, 0
12227, 1.9916666666667, -0.16, 0
12228, 2.0333333333333, -0.04, 0
12229, 2.0333333333333, -0.08, 0
12230, 2.0333333333333, -0.12, 0
12231, 2.0333333333333, -0.16, 0
12232, 2.075, -0.04, 0
12233, 2.075, -0.08, 0
12234, 2.075, -0.12, 0
12235, 2.075, -0.16, 0
12236, 2.1166666666667, -0.04, 0
12237, 2.1166666666667, -0.08, 0
12238, 2.1166666666667, -0.12, 0
12239, 2.1166666666667, -0.16, 0
12240, 2.1583333333333, -0.04, 0
12241, 2.1583333333333, -0.08, 0
12242, 2.1583333333333, -0.12, 0
12243, 2.1583333333333, -0.16, 0
12244, 1.2, -0.04, 0.041666666666667
12245, 1.2, -0.08, 0.041666666666667
12246, 1.2, -0.12, 0.041666666666667
12247, 1.2, -0.16, 0.041666666666667
12248, 1.2, -0.04, 0.083333333333333
12249, 1.2, -0.08, 0.083333333333333
12250, 1.2, -0.12, 0.083333333333333
12251, 1.2, -0.16, 0.083333333333333
12252, 1.2, -0.04, 0.125
12253, 1.2, -0.08, 0.125
12254, 1.2, -0.12, 0.125
12255, 1.2, -0.16, 0.125
12256, 1.2, -0.04, 0.16666666666667
12257, 1.2, -0.08, 0.16666666666667
12258, 1.2, -0.12, 0.16666666666667
12259, 1.2, -0.16, 0.16666666666667
12260, 1.2, -0.04, 0.20833333333333
12261, 1.2, -0.08, 0.20833333333333
12262, 1.2, -0.12, 0.20833333333333
12263, 1.2, -0.16, 0.20833333333333
12264, 1.2, -0.04, 0.25
12265, 1.2, -0.08, 0.25
12266, 1.2, -0.12, 0.25
12267, 1.2, -0.16, 0.25
12268, 1.2, -0.04, 0.29166666666667
12269, 1.2, -0.08, 0.29166666666667
12270, 1.2, -0.12, 0.29166666666667
12271, 1.2, -0.16, 0.29166666666667
12272, 1.2, -0.04, 0.33333333333333
12273, 1.2, -0.08, 0.33333333333333
12274, 1.2, -0.12, 0.33333333333333
12275, 1.2, -0.16, 0.33333333333333
12276, 1.2, -0.04, 0.375
12277, 1.2, -0.08, 0.375
12278, 1.2, -0.12, 0.375
12279, 1.2, -0.16, 0.375
12280, 1.2, -0.04, 0.41666666666667
12281, 1.2, -0.08, 0.41666666666667
12282, 1.2, -0.12, 0.41666666666667
12283, 1.2, -0.16, 0.41666666666667
12284, 1.2, -0.04, 0.45833333333333
12285, 1.2, -0.08, 0.45833333333333
12286, 1.2, -0.12, 0.45833333333333
12287, 1.2, -0.16, 0.45833333333333
12288, 2.2, -0.04, 0.041666666666667
12289, 2.2, -0.08, 0.041666666666667
12290, 2.2, -0.12, 0.041666666666667
12291, 2.2, -0.16, 0.041666666666667
12292, 2.2, -0.04, 0.083333333333333
12293, 2.2, -0.08, 0.083333333333333
12294, 2.2, -0.12, 0.083333333333333
12295, 2.2, -0.16, 0.083333333333333
12296, 2.2, -0.04, 0.125
12297, 2.2, -0.08, 0.125
12298, 2.2, -0.12, 0.125
12299, 2.2, -0.16, 0.125
12300, 2.2, -0.04, 0.16666666666667
12301, 2.2, -0.08, 0.16666666666667
12302, 2.2, -0.12, 0.16666666666667
12303, 2.2, -0.16, 0.16666666666667
12304, 2.2, -0.04, 0.20833333333333
12305, 2.2, -0.08, 0.20833333333333
12306, 2.2, -0.12, 0.20833333333333
12307, 2.2, -0.16, 0.20833333333333
12308, 2.2, -0.04, 0.25
12309, 2.2, -0.08, 0.25
12310, 2.2, -0.12, 0.25
12311, 2.2, -0.16, 0.25
12312, 2.2, -0.04, 0.29166666666667
12313, 2.2, -0.08, 0.29166666666667
12314, 2.2, -0.12, 0.29166666666667
12315, 2.2, -0.16, 0.29166666666667
12316, 2.2, -0.04, 0.33333333333333
12317, 2.2, -0.08, 0.33333333333333
12318, 2.2, -0.12, 0.33333333333333
12319, 2.2, -0.16, 0.33333333333333
12320, 2.2, -0.04, 0.375
12321, 2.2, -0.08, 0.375
12322, 2.2, -0.12, 0.375
12323, 2.2, -0.16, 0.375
12324, 2.2, -0.04, 0.41666666666667
12325, 2.2, -0.08, 0.41666666666667
12326, 2.2, -0.12, 0.41666666666667
12327, 2.2, -0.16, 0.41666666666667
12328, 2.2, -0.04, 0.45833333333333
12329, 2.2, -0.08, 0.45833333333333
12330, 2.2, -0.12, 0.45833333333333
12331, 2.2, -0.16, 0.45833333333333
12332, 1.2416666666667, -0.2, 0.041666666666667
12333, 1.2833333333333, -0.2, 0.041666666666667
12334, 1.325, -0.2, 0.041666666666667
12335, 1.3666666666667, -0.2, 0.041666666666667
12336, 1.4083333333333, -0.2, 0.041666666666667
12337, 1.45, -0.2, 0.041666666666667
12338, 1.4916666666667, -0.2, 0.041666666666667
12339, 1.5333333333333, -0.2, 0.041666666666667
12340, 1.575, -0.2, 0.041666666666667
12341, 1.6166666666667, -0.2, 0.041666666666667
12342, 1.6583333333333, -0.2, 0.041666666666667
12343, 1.7, -0.2, 0.041666666666667
12344, 1.7416666666667, -0.2, 0.041666666666667
12345, 1.7833333333333, -0.2, 0.041666666666667
12346, 1.825, -0.2, 0.041666666666667
12347, 1.8666666666667, -0.2, 0.041666666666667
12348, 1.9083333333333, -0.2, 0.041666666666667
12349, 1.95, -0.2, 0.041666666666667
12350, 1.9916666666667, -0.2, 0.041666666666667
12351, 2.0333333333333, -0.2, 0.041666666666667
12352, 2.075, -0.2, 0.041666666666667
12353, 2.1166666666667, -0.2, 0.041666666666667
12354, 2.1583333333333, -0.2, 0.041666666666667
12355, 1.2416666666667, -0.2, 0.083333333333333
12356, 1.2833333333333, -0.2, 0.083333333333333
12357, 1.325, -0.2, 0.083333333333333
12358, 1.3666666666667, -0.2, 0.083333333333333
12359, 1.4083333333333, -0.2, 0.083333333333333
12360, 1.45, -0.2, 0.083333333333333
12361, 1.4916666666667, -0.2, 0.083333333333333
12362, 1.5333333333333, -0.2, 0.083333333333333
12363, 1.575, -0.2, 0.083333333333333
12364, 1.6166666666667, -0.2, 0.083333333333333
12365, 1.6583333333333, -0.2, 0.083333333333333
12366, 1.7, -0.2, 0.083333333333333
12367, 1.7416666666667, -0.2, 0.083333333333333
12368, 1.7833333333333, -0.2, 0.083333333333333
12369, 1.825, -0.2, 0.083333333333333
12370, 1.8666666666667, -0.2, 0.083333333333333
12371, 1.9083333333333, -0.2, 0.083333333333333
12372, 1.95, -0.2, 0.083333333333333
12373, 1.9916666666667, -0.2, 0.083333333333333
12374, 2.0333333333333, -0.2, 0.083333333333333
12375, 2.075, -0.2, 0.083333333333333
12376, 2.1166666666667, -0.2, 0.083333333333333
12377, 2.1583333333333, -0.2, 0.083333333333333
12378, 1.2416666666667, -0.2, 0.125
12379, 1.2833333333333, -0.2, 0.125
12380, 1.325, -0.2, 0.125
12381, 1.3666666666667, -0.2, 0.125
12382, 1.4083333333333, -0.2, 0.125
12383, 1.45, -0.2, 0.125
12384, 1.4916666666667, -0.2, 0.125
12385, 1.5333333333333, -0.2, 0.125
12386, 1.575, -0.2, 0.125
12387, 1.6166666666667, -0.2, 0.125
12388, 1.6583333333333, -0.2, 0.125
12389, 1.7, -0.2, 0.125
12390, 1.7416666666667, -0.2, 0.125
12391, 1.7833333333333, -0.2, 0.125
12392, 1.825, -0.2, 0.125
12393, 1.8666666666667, -0.2, 0.125
12394, 1.9083333333333, -0.2, 0.125
12395, 1.95, -0.2, 0.125
12396, 1.9916666666667, -0.2, 0.125
12397, 2.0333333333333, -0.2, 0.125
12398, 2.075, -0.2, 0.125
12399, 2.1166666666667, -0.2, 0.125
12400, 2.1583333333333, -0.2, 0.125
12401, 1.2416666666667, -0.2, 0.16666666666667
12402, 1.2833333333333, -0.2, 0.16666666666667
12403, 1.325, -0.2, 0.16666666666667
12404, 1.3666666666667, -0.2, 0.16666666666667
12405, 1.4083333333333, -0.2, 0.16666666666667
12406, 1.45, -0.2, 0.16666666666667
12407, 1.4916666666667, -0.2, 0.16666666666667
12408, 1.5333333333333, -0.2, 0.16666666666667
12409, 1.575, -0.2, 0.16666666666667
12410, 1.6166666666667, -0.2, 0.16666666666667
12411, 1.6583333333333, -0.2, 0.16666666666667
12412, 1.7, -0.2, 0.16666666666667
12413, 1.7416666666667, -0.2, 0.16666666666667
12414, 1.7833333333333, -0.2, 0.16666666666667
12415, 1.825, -0.2, 0.16666666666667
12416, 1.8666666666667, -0.2, 0.16666666666667
12417, 1.9083333333333, -0.2, 0.16666666666667
12418, 1.95, -0.2, 0.16666666666667
12419, 1.9916666666667, -0.2, 0.16666666666667
12420, 2.0333333333333, -0.2, 0.16666666666667
12421, 2.075, -0.2, 0.16666666666667
12422, 2.1166666666667, -0.2, 0.16666666666667
12423, 2.1583333333333, -0.2, 0.16666666666667
12424, 1.2416666666667, -0.2, 0.20833333333333
12425, 1.2833333333333, -0.2, 0.20833333333333
12426, 1.325, -0.2, 0.20833333333333
12427, 1.3666666666667, -0.2, 0.20833333333333
12428, 1.4083333333333, -0.2, 0.20833333333333
12429, 1.45, -0.2, 0.20833333333333
12430, 1.4916666666667, -0.2, 0.20833333333333
12431, 1.5333333333333, -0.2, 0.20833333333333
12432, 1.575, -0.2, 0.20833333333333
12433, 1.6166666666667, -0.2, 0.20833333333333
12434, 1.6583333333333, -0.2, 0.20833333333333
12435, 1.7, -0.2, 0.20833333333333
12436, 1.7416666666667, -0.2, 0.20833333333333
12437, 1.7833333333333, -0.2, 0.20833333333333
12438, 1.825, -0.2, 0.20833333333333
12439, 1.8666666666667, -0.2, 0.20833333333333
12440, 1.9083333333333, -0.2, 0.20833333333333
12441, 1.95, -0.2, 0.20833333333333
12442, 1.9916666666667, -0.2, 0.20833333333333
12443, 2.0333333333333, -0.2, 0.20833333333333
12444, 2.075, -0.2, 0.20833333333333
12445, 2.1166666666667, -0.2, 0.20833333333333
12446, 2.1583333333333, -0.2, 0.20833333333333
12447, 1.2416666666667, -0.2, 0.25
12448, 1.2833333333333, -0.2, 0.25
12449, 1.325, -0.2, 0.25
12450, 1.3666666666667, -0.2, 0.25
12451, 1.4083333333333, -0.2, 0.25
12452, 1.45, -0.2, 0.25
12453, 1.4916666666667, -0.2, 0.25
12454, 1.5333333333333, -0.2, 0.25
12455, 1.575, -0.2, 0.25
12456, 1.6166666666667, -0.2, 0.25
12457, 1.6583333333333, -0.2, 0.25
12458, 1.7, -0.2, 0.25
12459, 1.7416666666667, -0.2, 0.25
12460, 1.7833333333333, -0.2, 0.25
12461, 1.825, -0.2, 0.25
12462, 1.8666666666667, -0.2, 0.25
12463, 1.9083333333333, -0.2, 0.25
12464, 1.95, -0.2, 0.25
12465, 1.9916666666667, -0.2, 0.25
12466, 2.0333333333333, -0.2, 0.25
12467, 2.075, -0.2, 0.25
12468, 2.1166666666667, -0.2, 0.25
12469, 2.1583333333333, -0.2, 0.25
12470, 1.2416666666667, -0.2, 0.29166666666667
12471, 1.2833333333333, -0.2, 0.29166666666667
12472, 1.325, -0.2, 0.29166666666667
12473, 1.3666666666667, -0.2, 0.29166666666667
12474, 1.4083333333333, -0.2, 0.29166666666667
12475, 1.45, -0.2, 0.29166666666667
12476, 1.4916666666667, -0.2, 0.29166666666667
12477, 1.5333333333333, -0.2, 0.29166666666667
12478, 1.575, -0.2, 0.29166666666667
12479, 1.6166666666667, -0.2, 0.29166666666667
12480, 1.6583333333333, -0.2, 0.29166666666667
12481, 1.7, -0.2, 0.29166666666667
12482, 1.7416666666667, -0.2, 0.29166666666667
12483, 1.7833333333333, -0.2, 0.29166666666667
12484, 1.825, -0.2, 0.29166666666667
12485, 1.8666666666667, -0.2, 0.29166666666667
12486, 1.9083333333333, -0.2, 0.29166666666667
12487, 1.95, -0.2, 0.29166666666667
12488, 1.9916666666667, -0.2, 0.29166666666667
12489, 2.0333333333333, -0.2, 0.29166666666667
12490, 2.075, -0.2, 0.29166666666667
12491, 2.1166666666667, -0.2, 0.29166666666667
12492, 2.1583333333333, -0.2, 0.29166666666667
12493, 1.2416666666667, -0.2, 0.33333333333333
12494, 1.2833333333333, -0.2, 0.33333333333333
12495, 1.325, -0.2, 0.33333333333333
12496, 1.3666666666667, -0.2, 0.33333333333333
12497, 1.4083333333333, -0.2, 0.33333333333333
12498, 1.45, -0.2, 0.33333333333333
12499, 1.4916666666667, -0.2, 0.33333333333333
12500, 1.5333333333333, -0.2, 0.33333333333333
12501, 1.575, -0.2, 0.33333333333333
12502, 1.6166666666667, -0.2, 0.33333333333333
12503, 1.6583333333333, -0.2, 0.33333333333333
12504, 1.7, -0.2, 0.33333333333333
12505, 1.7416666666667, -0.2, 0.33333333333333
12506, 1.7833333333333, -0.2, 0.33333333333333
12507, 1.825, -0.2, 0.33333333333333
12508, 1.8666666666667, -0.2, 0.33333333333333
12509, 1.9083333333333, -0.2, 0.33333333333333
12510, 1.95, -0.2, 0.33333333333333
12511, 1.9916666666667, -0.2, 0.33333333333333
12512, 2.0333333333333, -0.2, 0.33333333333333
12513, 2.075, -0.2, 0.33333333333333
12514, 2.1166666666667, -0.2, 0.33333333333333
12515, 2.1583333333333, -0.2, 0.33333333333333
12516, 1.2416666666667, -0.2, 0.375
12517, 1.2833333333333, -0.2, 0.375
12518, 1.325, -0.2, 0.375
12519, 1.3666666666667, -0.2, 0.375
12520, 1.4083333333333, -0.2, 0.375
12521, 1.45, -0.2, 0.375
12522, 1.4916666666667, -0.2, 0.375
12523, 1.5333333333333, -0.2, 0.375
12524, 1.575, -0.2, 0.375
12525, 1.6166666666667, -0.2, 0.375
12526, 1.6583333333333, -0.2, 0.375
12527, 1.7, -0.2, 0.375
12528, 1.7416666666667, -0.2, 0.375
12529, 1.7833333333333, -0.2, 0.375
12530, 1.825, -0.2, 0.375
12531, 1.8666666666667, -0.2, 0.375
12532, 1.9083333333333, -0.2, 0.375
12533, 1.95, -0.2, 0.375
12534, 1.9916666666667, -0.2, 0.375
12535, 2.0333333333333, -0.2, 0.375
12536, 2.075, -0.2, 0.375
12537, 2.1166666666667, -0.2, 0.375
12538, 2.1583333333333, -0.2, 0.375
12539, 1.2416666666667, -0.2, 0.41666666666667
12540, 1.2833333333333, -0.2, 0.41666666666667
12541, 1.325, -0.2, 0.41666666666667
12542, 1.3666666666667, -0.2, 0.41666666666667
12543, 1.4083333333333, -0.2, 0.41666666666667
12544, 1.45, -0.2, 0.41666666666667
12545, 1.4916666666667, -0.2, 0.41666666666667
12546, 1.5333333333333, -0.2, 0.41666666666667
12547, 1.575, -0.2, 0.41666666666667
12548, 1.6166666666667, -0.2, 0.41666666666667
12549, 1.6583333333333, -0.2, 0.41666666666667
12550, 1.7, -0.2, 0.41666666666667
12551, 1.7416666666667, -0.2, 0.41666666666667
12552, 1.7833333333333, -0.2, 0.41666666666667
12553, 1.825, -0.2, 0.41666666666667
12554, 1.8666666666667, -0.2, 0.41666666666667
12555, 1.9083333333333, -0.2, 0.41666666666667
12556, 1.95, -0.2, 0.41666666666667
12557, 1.9916666666667, -0.2, 0.41666666666667
12558, 2.0333333333333, -0.2, 0.41666666666667
12559, 2.075, -0.2, 0.41666666666667
12560, 2.1166666666667, -0.2, 0.41666666666667
12561, 2.1583333333333, -0.2, 0.41666666666667
12562, 1.2416666666667, -0.2, 0.45833333333333
12563, 1.2833333333333, -0.2, 0.45833333333333
12564, 1.325, -0.2, 0.45833333333333
12565, 1.3666666666667, -0.2, 0.45833333333333
12566, 1.4083333333333, -0.2, 0.45833333333333
12567, 1.45, -0.2, 0.45833333333333
12568, 1.4916666666667, -0.2, 0.45833333333333
12569, 1.5333333333333, -0.2, 0.45833333333333
12570, 1.575, -0.2, 0.45833333333333
12571, 1.6166666666667, -0.2, 0.45833333333333
12572, 1.6583333333333, -0.2, 0.45833333333333
12573, 1.7, -0.2, 0.45833333333333
12574, 1.7416666666667, -0.2, 0.45833333333333
12575, 1.7833333333333, -0.2, 0.45833333333333
12576, 1.825, -0.2, 0.45833333333333
12577, 1.8666666666667, -0.2, 0.45833333333333
12578, 1.9083333333333, -0.2, 0.45833333333333
12579, 1.95, -0.2, 0.45833333333333
12580, 1.9916666666667, -0.2, 0.45833333333333
12581, 2.0333333333333, -0.2, 0.45833333333333
12582, 2.075, -0.2, 0.45833333333333
12583, 2.1166666666667, -0.2, 0.45833333333333
12584, 2.1583333333333, -0.2, 0.45833333333333
12585, 2.3, -0.04, 0.041666666666667
12586, 2.3, -0.08, 0.041666666666667
12587, 2.3, -0.12, 0.041666666666667
12588, 2.3, -0.16, 0.041666666666667
12589, 2.3, -0.04, 0.083333333333333
12590, 2.3, -0.08, 0.083333333333333
12591, 2.3, -0.12, 0.083333333333333
12592, 2.3, -0.16, 0.083333333333333
12593, 2.3, -0.04, 0.125
12594, 2.3, -0.08, 0.125
12595, 2.3, -0.12, 0.125
12596, 2.3, -0.16, 0.125
12597, 2.3, -0.04, 0.16666666666667
12598, 2.3, -0.08, 0.16666666666667
12599, 2.3, -0.12, 0.16666666666667
12600, 2.3, -0.16, 0.16666666666667
12601, 2.3, -0.04, 0.20833333333333
12602, 2.3, -0.08, 0.20833333333333
12603, 2.3, -0.12, 0.20833333333333
12604, 2.3, -0.16, 0.20833333333333
12605, 2.3, -0.04, 0.25
12606, 2.3, -0.08, 0.25
12607, 2.3, -0.12, 0.25
12608, 2.3, -0.16, 0.25
12609, 2.3, -0.04, 0.29166666666667
12610, 2.3, -0.08, 0.29166666666667
12611, 2.3, -0.12, 0.29166666666667
12612, 2.3, -0.16, 0.29166666666667
12613, 2.3, -0.04, 0.33333333333333
12614, 2.3, -0.08, 0.33333333333333
12615, 2.3, -0.12, 0.33333333333333
12616, 2.3, -0.16, 0.33333333333333
12617, 2.3, -0.04, 0.375
12618, 2.3, -0.08, 0.375
12619, 2.3, -0.12, 0.375
12620, 2.3, -0.16, 0.375
12621, 2.3, -0.04, 0.41666666666667
12622, 2.3, -0.08, 0.41666666666667
12623, 2.3, -0.12, 0.41666666666667
12624, 2.3, -0.16, 0.41666666666667
12625, 2.3, -0.04, 0.45833333333333
12626, 2.3, -0.08, 0.45833333333333
12627, 2.3, -0.12, 0.45833333333333
12628, 2.3, -0.16, 0.45833333333333
12629, 0.041666666666667, 0.033333333333333, 0.041666666666667
12630, 0.083333333333333, 0.033333333333333, 0.041666666666667
12631, 0.125, 0.033333333333333, 0.041666666666667
12632, 0.16666666666667, 0.033333333333333, 0.041666666666667
12633, 0.20833333333333, 0.033333333333333, 0.041666666666667
12634, 0.25, 0.033333333333333, 0.041666666666667
12635, 0.29166666666667, 0.033333333333333, 0.041666666666667
12636, 0.33333333333333, 0.033333333333333, 0.041666666666667
12637, 0.375, 0.033333333333333, 0.041666666666667
12638, 0.41666666666667, 0.033333333333333, 0.041666666666667
12639, 0.45833333333333, 0.033333333333333, 0.041666666666667
12640, 0.5, 0.033333333333333, 0.041666666666667
12641, 0.54166666666667, 0.033333333333333, 0.041666666666667
12642, 0.58333333333333, 0.033333333333333, 0.041666666666667
12643, 0.625, 0.033333333333333, 0.041666666666667
12644, 0.66666666666667, 0.033333333333333, 0.041666666666667
12645, 0.70833333333333, 0.033333333333333, 0.041666666666667
12646, 0.75, 0.033333333333333, 0.041666666666667
12647, 0.79166666666667, 0.033333333333333, 0.041666666666667
12648, 0.83333333333333, 0.033333333333333, 0.041666666666667
12649, 0.875, 0.033333333333333, 0.041666666666667
12650, 0.91666666666667, 0.033333333333333, 0.041666666666667
12651, 0.95833333333333, 0.033333333333333, 0.041666666666667
12652, 0.041666666666667, 0.066666666666667, 0.041666666666667
12653, 0.083333333333333, 0.066666666666667, 0.041666666666667
12654, 0.125, 0.066666666666667, 0.041666666666667
12655, 0.16666666666667, 0.066666666666667, 0.041666666666667
12656, 0.20833333333333, 0.066666666666667, 0.041666666666667
12657, 0.25, 0.066666666666667, 0.041666666666667
12658, 0.29166666666667, 0.066666666666667, 0.041666666666667
12659, 0.33333333333333, 0.066666666666667, 0.041666666666667
12660, 0.375, 0.066666666666667, 0.041666666666667
12661, 0.41666666666667, 0.066666666666667, 0.041666666666667
12662, 0.45833333333333, 0.066666666666667, 0.041666666666667
12663, 0.5, 0.066666666666667, 0.041666666666667
12664, 0.54166666666667, 0.066666666666667, 0.041666666666667
12665, 0.58333333333333, 0.066666666666667, 0.041666666666667
12666, 0.625, 0.066666666666667, 0.041666666666667
12667, 0.66666666666667, 0.066666666666667, 0.041666666666667
12668, 0.70833333333333, 0.066666666666667, 0.041666666666667
12669, 0.75, 0.066666666666667, 0.041666666666667
12670, 0.79166666666667, 0.066666666666667, 0.041666666666667
12671, 0.83333333333333, 0.066666666666667, 0.041666666666667
12672, 0.875, 0.066666666666667, 0.041666666666667
12673, 0.91666666666667, 0.066666666666667, 0.041666666666667
12674, 0.95833333333333, 0.066666666666667, 0.041666666666667
12675, 0.041666666666667, 0.033333333333333, 0.083333333333333
12676, 0.083333333333333, 0.033333333333333, 0.083333333333333
12677, 0.125, 0.033333333333333, 0.083333333333333
12678, 0.16666666666667, 0.033333333333333, 0.083333333333333
12679, 0.20833333333333, 0.033333333333333, 0.083333333333333
12680, 0.25, 0.033333333333333, 0.083333333333333
12681, 0.29166666666667, 0.033333333333333, 0.083333333333333
12682, 0.33333333333333, 0.033333333333333, 0.083333333333333
12683, 0.375, 0.033333333333333, 0.083333333333333
12684, 0.41666666666667, 0.033333333333333, 0.083333333333333
12685, 0.45833333333333, 0.033333333333333, 0.083333333333333
12686, 0.5, 0.033333333333333, 0.083333333333333
12687, 0.54166666666667, 0.033333333333333, 0.083333333333333
12688, 0.58333333333333, 0.033333333333333, 0.083333333333333
12689, 0.625, 0.033333333333333, 0.083333333333333
12690, 0.66666666666667, 0.033333333333333, 0.083333333333333
12691, 0.70833333333333, 0.033333333333333, 0.083333333333333
12692, 0.75, 0.033333333333333, 0.083333333333333
12693, 0.79166666666667, 0.033333333333333, 0.083333333333333
12694, 0.83333333333333, 0.033333333333333, 0.083333333333333
12695, 0.875, 0.033333333333333, 0.083333333333333
12696, 0.91666666666667, 0.033333333333333, 0.083333333333333
12697, 0.95833333333333, 0.033333333333333, 0.083333333333333
12698, 0.041666666666667, 0.066666666666667, 0.083333333333333
12699, 0.083333333333333, 0.066666666666667, 0.083333333333333
12700, 0.125, 0.066666666666667, 0.083333333333333
12701, 0.16666666666667, 0.066666666666667, 0.083333333333333
12702, 0.20833333333333, 0.066666666666667, 0.083333333333333
12703, 0.25, 0.066666666666667, 0.083333333333333
12704, 0.29166666666667, 0.066666666666667, 0.083333333333333
12705, 0.33333333333333, 0.066666666666667, 0.083333333333333
12706, 0.375, 0.066666666666667, 0.083333333333333
12707, 0.41666666666667, 0.066666666666667, 0.083333333333333
12708, 0.45833333333333, 0.066666666666667, 0.083333333333333
12709, 0.5, 0.066666666666667, 0.083333333333333
12710, 0.54166666666667, 0.066666666666667, 0.083333333333333
12711, 0.58333333333333, 0.066666666666667, 0.083333333333333
12712, 0.625, 0.066666666666667, 0.083333333333333
12713, 0.66666666666667, 0.066666666666667, 0.083333333333333
12714, 0.70833333333333, 0.066666666666667, 0.083333333333333
12715, 0.75, 0.066666666666667, 0.083333333333333
12716, 0.79166666666667, 0.066666666666667, 0.083333333333333
12717, 0.83333333333333, 0.066666666666667, 0.083333333333333
12718, 0.875, 0.066666666666667, 0.083333333333333
12719, 0.91666666666667, 0.066666666666667, 0.083333333333333
12720, 0.95833333333333, 0.066666666666667, 0.083333333333333
12721, 0.041666666666667, 0.033333333333333, 0.125
12722, 0.083333333333333, 0.033333333333333, 0.125
12723, 0.125, 0.033333333333333, 0.125
12724, 0.16666666666667, 0.033333333333333, 0.125
12725, 0.20833333333333, 0.033333333333333, 0.125
12726, 0.25, 0.033333333333333, 0.125
12727, 0.29166666666667, 0.033333333333333, 0.125
12728, 0.33333333333333, 0.033333333333333, 0.125
12729, 0.375, 0.033333333333333, 0.125
12730, 0.41666666666667, 0.033333333333333, 0.125
12731, 0.45833333333333, 0.033333333333333, 0.125
12732, 0.5, 0.033333333333333, 0.125
12733, 0.54166666666667, 0.033333333333333, 0.125
12734, 0.58333333333333, 0.033333333333333, 0.125
12735, 0.625, 0.033333333333333, 0.125
12736, 0.66666666666667, 0.033333333333333, 0.125
12737, 0.70833333333333, 0.033333333333333, 0.125
12738, 0.75, 0.033333333333333, 0.125
12739, 0.79166666666667, 0.033333333333333, 0.125
12740, 0.83333333333333, 0.033333333333333, 0.125
12741, 0.875, 0.033333333333333, 0.125
12742, 0.91666666666667, 0.033333333333333, 0.125
12743, 0.95833333333333, 0.033333333333333, 0.125
12744, 0.041666666666667, 0.066666666666667, 0.125
12745, 0.083333333333333, 0.066666666666667, 0.125
12746, 0.125, 0.066666666666667, 0.125
12747, 0.16666666666667, 0.066666666666667, 0.125
12748, 0.20833333333333, 0.066666666666667, 0.125
12749, 0.25, 0.066666666666667, 0.125
12750, 0.29166666666667, 0.066666666666667, 0.125
12751, 0.33333333333333, 0.066666666666667, 0.125
12752, 0.375, 0.066666666666667, 0.125
12753, 0.41666666666667, 0.066666666666667, 0.125
12754, 0.45833333333333, 0.066666666666667, 0.125
12755, 0.5, 0.066666666666667, 0.125
12756, 0.54166666666667, 0.066666666666667, 0.125
12757, 0.58333333333333, 0.066666666666667, 0.125
12758, 0.625, 0.066666666666667, 0.125
12759, 0.66666666666667, 0.066666666666667, 0.125
12760, 0.70833333333333, 0.066666666666667, 0.125
12761, 0.75, 0.066666666666667, 0.125
12762, 0.79166666666667, 0.066666666666667, 0.125
12763, 0.83333333333333, 0.066666666666667, 0.125
12764, 0.875, 0.066666666666667, 0.125
12765, 0.91666666666667, 0.066666666666667, 0.125
12766, 0.95833333333333, 0.066666666666667, 0.125
12767, 0.041666666666667, 0.033333333333333, 0.16666666666667
12768, 0.083333333333333, 0.033333333333333, 0.16666666666667
12769, 0.125, 0.033333333333333, 0.16666666666667
12770, 0.16666666666667, 0.033333333333333, 0.16666666666667
12771, 0.20833333333333, 0.033333333333333, 0.16666666666667
12772, 0.25, 0.033333333333333, 0.16666666666667
12773, 0.29166666666667, 0.033333333333333, 0.16666666666667
12774, 0.33333333333333, 0.033333333333333, 0.16666666666667
12775, 0.375, 0.033333333333333, 0.16666666666667
12776, 0.41666666666667, 0.033333333333333, 0.16666666666667
12777, 0.45833333333333, 0.033333333333333, 0.16666666666667
12778, 0.5, 0.033333333333333, 0.16666666666667
12779, 0.54166666666667, 0.033333333333333, 0.16666666666667
12780, 0.58333333333333, 0.033333333333333, 0.16666666666667
12781, 0.625, 0.033333333333333, 0.16666666666667
12782, 0.66666666666667, 0.033333333333333, 0.16666666666667
12783, 0.70833333333333, 0.033333333333333, 0.16666666666667
12784, 0.75, 0.033333333333333, 0.16666666666667
12785, 0.79166666666667, 0.033333333333333, 0.16666666666667
12786, 0.83333333333333, 0.033333333333333, 0.16666666666667
12787, 0.875, 0.033333333333333, 0.16666666666667
12788, 0.91666666666667, 0.033333333333333, 0.16666666666667
12789, 0.95833333333333, 0.033333333333333, 0.16666666666667
12790, 0.041666666666667, 0.066666666666667, 0.16666666666667
12791, 0.083333333333333, 0.066666666666667, 0.16666666666667
12792, 0.125, 0.066666666666667, 0.16666666666667
12793, 0.16666666666667, 0.066666666666667, 0.16666666666667
12794, 0.20833333333333, 0.066666666666667, 0.16666666666667
12795, 0.25, 0.066666666666667, 0.16666666666667
12796, 0.29166666666667, 0.066666666666667, 0.16666666666667
12797, 0.33333333333333, 0.066666666666667, 0.16666666666667
12798, 0.375, 0.066666666666667, 0.16666666666667
12799, 0.41666666666667, 0.066666666666667, 0.16666666666667
12800, 0.45833333333333, 0.066666666666667, 0.16666666666667
12801, 0.5, 0.066666666666667, 0.16666666666667
12802, 0.54166666666667, 0.066666666666667, 0.16666666666667
12803, 0.58333333333333, 0.066666666666667, 0.16666666666667
12804, 0.625, 0.066666666666667, 0.16666666666667
12805, 0.66666666666667, 0.066666666666667, 0.16666666666667
12806, 0.70833333333333, 0.066666666666667, 0.16666666666667
12807, 0.75, 0.066666666666667, 0.16666666666667
12808, 0.79166666666667, 0.066666666666667, 0.16666666666667
12809, 0.83333333333333, 0.066666666666667, 0.16666666666667
12810, 0.875, 0.066666666666667, 0.16666666666667
12811, 0.91666666666667, 0.066666666666667, 0.16666666666667
12812, 0.95833333333333, 0.066666666666667, 0.16666666666667
12813, 0.041666666666667, 0.033333333333333, 0.20833333333333
12814, 0.083333333333333, 0.033333333333333, 0.20833333333333
12815, 0.125, 0.033333333333333, 0.20833333333333
12816, 0.16666666666667, 0.033333333333333, 0.20833333333333
12817, 0.20833333333333, 0.033333333333333, 0.20833333333333
12818, 0.25, 0.033333333333333, 0.20833333333333
12819, 0.29166666666667, 0.033333333333333, 0.20833333333333
12820, 0.33333333333333, 0.033333333333333, 0.20833333333333
12821, 0.375, 0.033333333333333, 0.20833333333333
12822, 0.41666666666667, 0.033333333333333, 0.20833333333333
12823, 0.45833333333333, 0.033333333333333, 0.20833333333333
12824, 0.5, 0.033333333333333, 0.20833333333333
12825, 0.54166666666667, 0.033333333333333, 0.20833333333333
12826, 0.58333333333333, 0.033333333333333, 0.20833333333333
12827, 0.625, 0.033333333333333, 0.20833333333333
12828, 0.66666666666667, 0.033333333333333, 0.20833333333333
12829, 0.70833333333333, 0.033333333333333, 0.20833333333333
12830, 0.75, 0.033333333333333, 0.20833333333333
12831, 0.79166666666667, 0.033333333333333, 0.20833333333333
12832, 0.83333333333333, 0.033333333333333, 0.20833333333333
12833, 0.875, 0.033333333333333, 0.20833333333333
12834, 0.91666666666667, 0.033333333333333, 0.20833333333333
12835, 0.95833333333333, 0.033333333333333, 0.20833333333333
12836, 0.041666666666667, 0.066666666666667, 0.20833333333333
12837, 0.083333333333333, 0.066666666666667, 0.20833333333333
12838, 0.125, 0.066666666666667, 0.20833333333333
12839, 0.16666666666667, 0.066666666666667, 0.20833333333333
12840, 0.20833333333333, 0.066666666666667, 0.20833333333333
12841, 0.25, 0.066666666666667, 0.20833333333333
12842, 0.29166666666667, 0.066666666666667, 0.20833333333333
12843, 0.33333333333333, 0.066666666666667, 0.20833333333333
12844, 0.375, 0.066666666666667, 0.20833333333333
12845, 0.41666666666667, 0.066666666666667, 0.20833333333333
12846, 0.45833333333333, 0.066666666666667, 0.20833333333333
12847, 0.5, 0.066666666666667, 0.20833333333333
12848, 0.54166666666667, 0.066666666666667, 0.20833333333333
12849, 0.58333333333333, 0.066666666666667, 0.20833333333333
12850, 0.625, 0.066666666666667, 0.20833333333333
12851, 0.66666666666667, 0.066666666666667, 0.20833333333333
12852, 0.70833333333333, 0.066666666666667, 0.20833333333333
12853, 0.75, 0.066666666666667, 0.20833333333333
12854, 0.79166666666667, 0.066666666666667, 0.20833333333333
12855, 0.83333333333333, 0.066666666666667, 0.20833333333333
12856, 0.875, 0.066666666666667, 0.20833333333333
12857, 0.91666666666667, 0.066666666666667, 0.20833333333333
12858, 0.95833333333333, 0.066666666666667, 0.20833333333333
12859, 0.041666666666667, 0.033333333333333, 0.25
12860, 0.083333333333333, 0.033333333333333, 0.25
12861, 0.125, 0.033333333333333, 0.25
12862, 0.16666666666667, 0.033333333333333, 0.25
12863, 0.20833333333333, 0.033333333333333, 0.25
12864, 0.25, 0.033333333333333, 0.25
12865, 0.29166666666667, 0.033333333333333, 0.25
12866, 0.33333333333333, 0.033333333333333, 0.25
12867, 0.375, 0.033333333333333, 0.25
12868, 0.41666666666667, 0.033333333333333, 0.25
12869, 0.45833333333333, 0.033333333333333, 0.25
12870, 0.5, 0.033333333333333, 0.25
12871, 0.54166666666667, 0.033333333333333, 0.25
12872, 0.58333333333333, 0.033333333333333, 0.25
12873, 0.625, 0.033333333333333, 0.25
12874, 0.66666666666667, 0.033333333333333, 0.25
12875, 0.70833333333333, 0.033333333333333, 0.25
12876, 0.75, 0.033333333333333, 0.25
12877, 0.79166666666667, 0.033333333333333, 0.25
12878, 0.83333333333333, 0.033333333333333, 0.25
12879, 0.875, 0.033333333333333, 0.25
12880, 0.91666666666667, 0.033333333333333, 0.25
12881, 0.95833333333333, 0.033333333333333, 0.25
12882, 0.041666666666667, 0.066666666666667, 0.25
12883, 0.083333333333333, 0.066666666666667, 0.25
12884, 0.125, 0.066666666666667, 0.25
12885, 0.16666666666667, 0.066666666666667, 0.25
12886, 0.20833333333333, 0.066666666666667, 0.25
12887, 0.25, 0.066666666666667, 0.25
12888, 0.29166666666667, 0.066666666666667, 0.25
12889, 0.33333333333333, 0.066666666666667, 0.25
12890, 0.375, 0.066666666666667, 0.25
12891, 0.41666666666667, 0.066666666666667, 0.25
12892, 0.45833333333333, 0.066666666666667, 0.25
12893, 0.5, 0.066666666666667, 0.25
12894, 0.54166666666667, 0.066666666666667, 0.25
12895, 0.58333333333333, 0.066666666666667, 0.25
12896, 0.625, 0.066666666666667, 0.25
12897, 0.66666666666667, 0.066666666666667, 0.25
12898, 0.70833333333333, 0.066666666666667, 0.25
12899, 0.75, 0.066666666666667, 0.25
12900, 0.79166666666667, 0.066666666666667, 0.25
12901, 0.83333333333333, 0.066666666666667, 0.25
12902, 0.875, 0.066666666666667, 0.25
12903, 0.91666666666667, 0.066666666666667, 0.25
12904, 0.95833333333333, 0.066666666666667, 0.25
12905, 0.041666666666667, 0.033333333333333, 0.29166666666667
12906, 0.083333333333333, 0.033333333333333, 0.29166666666667
12907, 0.125, 0.033333333333333, 0.29166666666667
12908, 0.16666666666667, 0.033333333333333, 0.29166666666667
12909, 0.20833333333333, 0.033333333333333, 0.29166666666667
12910, 0.25, 0.033333333333333, 0.29166666666667
12911, 0.29166666666667, 0.033333333333333, 0.29166666666667
12912, 0.33333333333333, 0.033333333333333, 0.29166666666667
12913, 0.375, 0.033333333333333, 0.29166666666667
12914, 0.41666666666667, 0.033333333333333, 0.29166666666667
12915, 0.45833333333333, 0.033333333333333, 0.29166666666667
12916, 0.5, 0.033333333333333, 0.29166666666667
12917, 0.54166666666667, 0.033333333333333, 0.29166666666667
12918, 0.58333333333333, 0.033333333333333, 0.29166666666667
12919, 0.625, 0.033333333333333, 0.29166666666667
12920, 0.66666666666667, 0.033333333333333, 0.29166666666667
12921, 0.70833333333333, 0.033333333333333, 0.29166666666667
12922, 0.75, 0.033333333333333, 0.29166666666667
12923, 0.79166666666667, 0.033333333333333, 0.29166666666667
12924, 0.83333333333333, 0.033333333333333, 0.29166666666667
12925, 0.875, 0.033333333333333, 0.29166666666667
12926, 0.91666666666667, 0.033333333333333, 0.29166666666667
12927, 0.95833333333333, 0.033333333333333, 0.29166666666667
12928, 0.041666666666667, 0.066666666666667, 0.29166666666667
12929, 0.083333333333333, 0.066666666666667, 0.29166666666667
12930, 0.125, 0.066666666666667, 0.29166666666667
12931, 0.16666666666667, 0.066666666666667, 0.29166666666667
12932, 0.20833333333333, 0.066666666666667, 0.29166666666667
12933, 0.25, 0.066666666666667, 0.29166666666667
12934, 0.29166666666667, 0.066666666666667, 0.29166666666667
12935, 0.33333333333333, 0.066666666666667, 0.29166666666667
12936, 0.375, 0.066666666666667, 0.29166666666667
12937, 0.41666666666667, 0.066666666666667, 0.29166666666667
12938, 0.45833333333333, 0.066666666666667, 0.29166666666667
12939, 0.5, 0.066666666666667, 0.29166666666667
12940, 0.54166666666667, 0.066666666666667, 0.29166666666667
12941, 0.58333333333333, 0.066666666666667, 0.29166666666667
12942, 0.625, 0.066666666666667, 0.29166666666667
12943, 0.66666666666667, 0.066666666666667, 0.29166666666667
12944, 0.70833333333333, 0.066666666666667, 0.29166666666667
12945, 0.75, 0.066666666666667, 0.29166666666667
12946, 0.79166666666667, 0.066666666666667, 0.29166666666667
12947, 0.83333333333333, 0.066666666666667, 0.29166666666667
12948, 0.875, 0.066666666666667, 0.29166666666667
12949, 0.91666666666667, 0.066666666666667, 0.29166666666667
12950, 0.95833333333333, 0.066666666666667, 0.29166666666667
12951, 0.041666666666667, 0.033333333333333, 0.33333333333333
12952, 0.083333333333333, 0.033333333333333, 0.33333333333333
12953, 0.125, 0.033333333333333, 0.33333333333333
12954, 0.16666666666667, 0.033333333333333, 0.33333333333333
12955, 0.20833333333333, 0.033333333333333, 0.33333333333333
12956, 0.25, 0.033333333333333, 0.33333333333333
12957, 0.29166666666667, 0.033333333333333, 0.33333333333333
12958, 0.33333333333333, 0.033333333333333, 0.33333333333333
12959, 0.375, 0.033333333333333, 0.33333333333333
12960, 0.41666666666667, 0.033333333333333, 0.33333333333333
12961, 0.45833333333333, 0.033333333333333, 0.33333333333333
12962, 0.5, 0.033333333333333, 0.33333333333333
12963, 0.54166666666667, 0.033333333333333, 0.33333333333333
12964, 0.58333333333333, 0.033333333333333, 0.33333333333333
12965, 0.625, 0.033333333333333, 0.33333333333333
12966, 0.66666666666667, 0.033333333333333, 0.33333333333333
12967, 0.70833333333333, 0.033333333333333, 0.33333333333333
12968, 0.75, 0.033333333333333, 0.33333333333333
12969, 0.79166666666667, 0.033333333333333, 0.33333333333333
12970, 0.83333333333333, 0.033333333333333, 0.33333333333333
12971, 0.875, 0.033333333333333, 0.33333333333333
12972, 0.91666666666667, 0.033333333333333, 0.33333333333333
12973, 0.95833333333333, 0.033333333333333, 0.33333333333333
12974, 0.041666666666667, 0.066666666666667, 0.33333333333333
12975, 0.083333333333333, 0.066666666666667, 0.33333333333333
12976, 0.125, 0.066666666666667, 0.33333333333333
12977, 0.16666666666667, 0.066666666666667, 0.33333333333333
12978, 0.20833333333333, 0.066666666666667, 0.33333333333333
12979, 0.25, 0.066666666666667, 0.33333333333333
12980, 0.29166666666667, 0.066666666666667, 0.33333333333333
12981, 0.33333333333333, 0.066666666666667, 0.33333333333333
12982, 0.375, 0.066666666666667, 0.33333333333333
12983, 0.41666666666667, 0.066666666666667, 0.33333333333333
12984, 0.45833333333333, 0.066666666666667, 0.33333333333333
12985, 0.5, 0.066666666666667, 0.33333333333333
12986, 0.54166666666667, 0.066666666666667, 0.33333333333333
12987, 0.58333333333333, 0.066666666666667, 0.33333333333333
12988, 0.625, 0.066666666666667, 0.33333333333333
12989, 0.66666666666667, 0.066666666666667, 0.33333333333333
12990, 0.70833333333333, 0.066666666666667, 0.33333333333333
12991, 0.75, 0.066666666666667, 0.33333333333333
12992, 0.79166666666667, 0.066666666666667, 0.33333333333333
12993, 0.83333333333333, 0.066666666666667, 0.33333333333333
12994, 0.875, 0.066666666666667, 0.33333333333333
12995, 0.91666666666667, 0.066666666666667, 0.33333333333333
12996, 0.95833333333333, 0.066666666666667, 0.33333333333333
12997, 0.041666666666667, 0.033333333333333, 0.375
12998, 0.083333333333333, 0.033333333333333, 0.375
12999, 0.125, 0.033333333333333, 0.375
13000, 0.16666666666667, 0.033333333333333, 0.375
13001, 0.20833333333333, 0.033333333333333, 0.375
13002, 0.25, 0.033333333333333, 0.375
13003, 0.29166666666667, 0.033333333333333, 0.375
13004, 0.33333333333333, 0.033333333333333, 0.375
13005, 0.375, 0.033333333333333, 0.375
13006, 0.41666666666667, 0.033333333333333, 0.375
13007, 0.45833333333333, 0.033333333333333, 0.375
13008, 0.5, 0.033333333333333, 0.375
13009, 0.54166666666667, 0.033333333333333, 0.375
13010, 0.58333333333333, 0.033333333333333, 0.375
13011, 0.625, 0.033333333333333, 0.375
13012, 0.66666666666667, 0.033333333333333, 0.375
13013, 0.70833333333333, 0.033333333333333, 0.375
13014, 0.75, 0.033333333333333, 0.375
13015, 0.79166666666667, 0.033333333333333, 0.375
13016, 0.83333333333333, 0.033333333333333, 0.375
13017, 0.875, 0.033333333333333, 0.375
13018, 0.91666666666667, 0.033333333333333, 0.375
13019, 0.95833333333333, 0.033333333333333, 0.375
13020, 0.041666666666667, 0.066666666666667, 0.375
13021, 0.083333333333333, 0.066666666666667, 0.375
13022, 0.125, 0.066666666666667, 0.375
13023, 0.16666666666667, 0.066666666666667, 0.375
13024, 0.20833333333333, 0.066666666666667, 0.375
13025, 0.25, 0.066666666666667, 0.375
13026, 0.29166666666667, 0.066666666666667, 0.375
13027, 0.33333333333333, 0.066666666666667, 0.375
13028, 0.375, 0.066666666666667, 0.375
13029, 0.41666666666667, 0.066666666666667, 0.375
13030, 0.45833333333333, 0.066666666666667, 0.375
13031, 0.5, 0.066666666666667, 0.375
13032, 0.54166666666667, 0.066666666666667, 0.375
13033, 0.58333333333333, 0.066666666666667, 0.375
13034, 0.625, 0.066666666666667, 0.375
13035, 0.66666666666667, 0.066666666666667, 0.375
13036, 0.70833333333333, 0.066666666666667, 0.375
13037, 0.75, 0.066666666666667, 0.375
13038, 0.79166666666667, 0.066666666666667, 0.375
13039, 0.83333333333333, 0.066666666666667, 0.375
13040, 0.875, 0.066666666666667, 0.375
13041, 0.91666666666667, 0.066666666666667, 0.375
13042, 0.95833333333333, 0.066666666666667, 0.375
13043, 0.041666666666667, 0.033333333333333, 0.41666666666667
13044, 0.083333333333333, 0.033333333333333, 0.41666666666667
13045, 0.125, 0.033333333333333, 0.41666666666667
13046, 0.16666666666667, 0.033333333333333, 0.41666666666667
13047, 0.20833333333333, 0.033333333333333, 0.41666666666667
13048, 0.25, 0.033333333333333, 0.41666666666667
13049, 0.29166666666667, 0.033333333333333, 0.41666666666667
13050, 0.33333333333333, 0.033333333333333, 0.41666666666667
13051, 0.375, 0.033333333333333, 0.41666666666667
13052, 0.41666666666667, 0.033333333333333, 0.41666666666667
13053, 0.45833333333333, 0.033333333333333, 0.41666666666667
13054, 0.5, 0.033333333333333, 0.41666666666667
13055, 0.54166666666667, 0.033333333333333, 0.41666666666667
13056, 0.58333333333333, 0.033333333333333, 0.41666666666667
13057, 0.625, 0.033333333333333, 0.41666666666667
13058, 0.66666666666667, 0.033333333333333, 0.41666666666667
13059, 0.70833333333333, 0.033333333333333, 0.41666666666667
13060, 0.75, 0.033333333333333, 0.41666666666667
13061, 0.79166666666667, 0.033333333333333, 0.41666666666667
13062, 0.83333333333333, 0.033333333333333, 0.41666666666667
13063, 0.875, 0.033333333333333, 0.41666666666667
13064, 0.91666666666667, 0.033333333333333, 0.41666666666667
13065, 0.95833333333333, 0.033333333333333, 0.41666666666667
13066, 0.041666666666667, 0.066666666666667, 0.41666666666667
13067, 0.083333333333333, 0.066666666666667, 0.41666666666667
13068, 0.125, 0.066666666666667, 0.41666666666667
13069, 0.16666666666667, 0.066666666666667, 0.41666666666667
13070, 0.20833333333333, 0.066666666666667, 0.41666666666667
13071, 0.25, 0.066666666666667, 0.41666666666667
13072, 0.29166666666667, 0.066666666666667, 0.41666666666667
13073, 0.33333333333333, 0.066666666666667, 0.41666666666667
13074, 0.375, 0.066666666666667, 0.41666666666667
13075, 0.41666666666667, 0.066666666666667, 0.41666666666667
13076, 0.45833333333333, 0.066666666666667, 0.41666666666667
13077, 0.5, 0.066666666666667, 0.41666666666667
13078, 0.54166666666667, 0.066666666666667, 0.41666666666667
13079, 0.58333333333333, 0.066666666666667, 0.41666666666667
13080, 0.625, 0.066666666666667, 0.41666666666667
13081, 0.66666666666667, 0.066666666666667, 0.41666666666667
13082, 0.70833333333333, 0.066666666666667, 0.41666666666667
13083, 0.75, 0.066666666666667, 0.41666666666667
13084, 0.79166666666667, 0.066666666666667, 0.41666666666667
13085, 0.83333333333333, 0.066666666666667, 0.41666666666667
13086, 0.875, 0.066666666666667, 0.41666666666667
13087, 0.91666666666667, 0.066666666666667, 0.41666666666667
13088, 0.95833333333333, 0.066666666666667, 0.41666666666667
13089, 0.041666666666667, 0.033333333333333, 0.45833333333333
13090, 0.083333333333333, 0.033333333333333, 0.45833333333333
13091, 0.125, 0.033333333333333, 0.45833333333333
13092, 0.16666666666667, 0.033333333333333, 0.45833333333333
13093, 0.20833333333333, 0.033333333333333, 0.45833333333333
13094, 0.25, 0.033333333333333, 0.45833333333333
13095, 0.29166666666667, 0.033333333333333, 0.45833333333333
13096, 0.33333333333333, 0.033333333333333, 0.45833333333333
13097, 0.375, 0.033333333333333, 0.45833333333333
13098, 0.41666666666667, 0.033333333333333, 0.45833333333333
13099, 0.45833333333333, 0.033333333333333, 0.45833333333333
13100, 0.5, 0.033333333333333, 0.45833333333333
13101, 0.54166666666667, 0.033333333333333, 0.45833333333333
13102, 0.58333333333333, 0.033333333333333, 0.45833333333333
13103, 0.625, 0.033333333333333, 0.45833333333333
13104, 0.66666666666667, 0.033333333333333, 0.45833333333333
13105, 0.70833333333333, 0.033333333333333, 0.45833333333333
13106, 0.75, 0.033333333333333, 0.45833333333333
13107, 0.79166666666667, 0.033333333333333, 0.45833333333333
13108, 0.83333333333333, 0.033333333333333, 0.45833333333333
13109, 0.875, 0.033333333333333, 0.45833333333333
13110, 0.91666666666667, 0.033333333333333, 0.45833333333333
13111, 0.95833333333333, 0.033333333333333, 0.45833333333333
13112, 0.041666666666667, 0.066666666666667, 0.45833333333333
13113, 0.083333333333333, 0.066666666666667, 0.45833333333333
13114, 0.125, 0.066666666666667, 0.45833333333333
13115, 0.16666666666667, 0.066666666666667, 0.45833333333333
13116, 0.20833333333333, 0.066666666666667, 0.45833333333333
13117, 0.25, 0.066666666666667, 0.45833333333333
13118, 0.29166666666667, 0.066666666666667, 0.45833333333333
13119, 0.33333333333333, 0.066666666666667, 0.45833333333333
13120, 0.375, 0.066666666666667, 0.45833333333333
13121, 0.41666666666667, 0.066666666666667, 0.45833333333333
13122, 0.45833333333333, 0.066666666666667, 0.45833333333333
13123, 0.5, 0.066666666666667, 0.45833333333333
13124, 0.54166666666667, 0.066666666666667, 0.45833333333333
13125, 0.58333333333333, 0.066666666666667, 0.45833333333333
13126, 0.625, 0.066666666666667, 0.45833333333333
13127, 0.66666666666667, 0.066666666666667, 0.45833333333333
13128, 0.70833333333333, 0.066666666666667, 0.45833333333333
13129, 0.75, 0.066666666666667, 0.45833333333333
13130, 0.79166666666667, 0.066666666666667, 0.45833333333333
13131, 0.83333333333333, 0.066666666666667, 0.45833333333333
13132, 0.875, 0.066666666666667, 0.45833333333333
13133, 0.91666666666667, 0.066666666666667, 0.45833333333333
13134, 0.95833333333333, 0.066666666666667, 0.45833333333333
13135, 0.041666666666667, 0.2, 0.041666666666667
13136, 0.041666666666667, 0.25, 0.041666666666667
13137, 0.041666666666667, 0.3, 0.041666666666667
13138, 0.041666666666667, 0.35, 0.041666666666667
13139, 0.041666666666667, 0.4, 0.041666666666667
13140, 0.041666666666667, 0.45, 0.041666666666667
13141, 0.041666666666667, 0.5, 0.041666666666667
13142, 0.041666666666667, 0.55, 0.041666666666667
13143, 0.041666666666667, 0.6, 0.041666666666667
13144, 0.041666666666667, 0.65, 0.041666666666667
13145, 0.041666666666667, 0.7, 0.041666666666667
13146, 0.041666666666667, 0.75, 0.041666666666667
13147, 0.041666666666667, 0.8, 0.041666666666667
13148, 0.041666666666667, 0.85, 0.041666666666667
13149, 0.041666666666667, 0.9, 0.041666666666667
13150, 0.041666666666667, 0.95, 0.041666666666667
13151, 0.041666666666667, 1, 0.041666666666667
13152, 0.041666666666667, 1.05, 0.041666666666667
13153, 0.041666666666667, 1.1, 0.041666666666667
13154, 0.041666666666667, 1.15, 0.041666666666667
13155, 0.041666666666667, 1.2, 0.041666666666667
13156, 0.041666666666667, 1.25, 0.041666666666667
13157, 0.041666666666667, 1.3, 0.041666666666667
13158, 0.041666666666667, 0.2, 0.083333333333333
13159, 0.041666666666667, 0.25, 0.083333333333333
13160, 0.041666666666667, 0.3, 0.083333333333333
13161, 0.041666666666667, 0.35, 0.083333333333333
13162, 0.041666666666667, 0.4, 0.083333333333333
13163, 0.041666666666667, 0.45, 0.083333333333333
13164, 0.041666666666667, 0.5, 0.083333333333333
13165, 0.041666666666667, 0.55, 0.083333333333333
13166, 0.041666666666667, 0.6, 0.083333333333333
13167, 0.041666666666667, 0.65, 0.083333333333333
13168, 0.041666666666667, 0.7, 0.083333333333333
13169, 0.041666666666667, 0.75, 0.083333333333333
13170, 0.041666666666667, 0.8, 0.083333333333333
13171, 0.041666666666667, 0.85, 0.083333333333333
13172, 0.041666666666667, 0.9, 0.083333333333333
13173, 0.041666666666667, 0.95, 0.083333333333333
13174, 0.041666666666667, 1, 0.083333333333333
13175, 0.041666666666667, 1.05, 0.083333333333333
13176, 0.041666666666667, 1.1, 0.083333333333333
13177, 0.041666666666667, 1.15, 0.083333333333333
13178, 0.041666666666667, 1.2, 0.083333333333333
13179, 0.041666666666667, 1.25, 0.083333333333333
13180, 0.041666666666667, 1.3, 0.083333333333333
13181, 0.041666666666667, 0.2, 0.125
13182, 0.041666666666667, 0.25, 0.125
13183, 0.041666666666667, 0.3, 0.125
13184, 0.041666666666667, 0.35, 0.125
13185, 0.041666666666667, 0.4, 0.125
13186, 0.041666666666667, 0.45, 0.125
13187, 0.041666666666667, 0.5, 0.125
13188, 0.041666666666667, 0.55, 0.125
13189, 0.041666666666667, 0.6, 0.125
13190, 0.041666666666667, 0.65, 0.125
13191, 0.041666666666667, 0.7, 0.125
13192, 0.041666666666667, 0.75, 0.125
13193, 0.041666666666667, 0.8, 0.125
13194, 0.041666666666667, 0.85, 0.125
13195, 0.041666666666667, 0.9, 0.125
13196, 0.041666666666667, 0.95, 0.125
13197, 0.041666666666667, 1, 0.125
13198, 0.041666666666667, 1.05, 0.125
13199, 0.041666666666667, 1.1, 0.125
13200, 0.041666666666667, 1.15, 0.125
13201, 0.041666666666667, 1.2, 0.125
13202, 0.041666666666667, 1.25, 0.125
13203, 0.041666666666667, 1.3, 0.125
13204, 0.041666666666667, 0.2, 0.16666666666667
13205, 0.041666666666667, 0.25, 0.16666666666667
13206, 0.041666666666667, 0.3, 0.16666666666667
13207, 0.041666666666667, 0.35, 0.16666666666667
13208, 0.041666666666667, 0.4, 0.16666666666667
13209, 0.041666666666667, 0.45, 0.16666666666667
13210, 0.041666666666667, 0.5, 0.16666666666667
13211, 0.041666666666667, 0.55, 0.16666666666667
13212, 0.041666666666667, 0.6, 0.16666666666667
13213, 0.041666666666667, 0.65, 0.16666666666667
13214, 0.041666666666667, 0.7, 0.16666666666667
13215, 0.041666666666667, 0.75, 0.16666666666667
13216, 0.041666666666667, 0.8, 0.16666666666667
13217, 0.041666666666667, 0.85, 0.16666666666667
13218, 0.041666666666667, 0.9, 0.16666666666667
13219, 0.041666666666667, 0.95, 0.16666666666667
13220, 0.041666666666667, 1, 0.16666666666667
13221, 0.041666666666667, 1.05, 0.16666666666667
13222, 0.041666666666667, 1.1, 0.16666666666667
13223, 0.041666666666667, 1.15, 0.16666666666667
13224, 0.041666666666667, 1.2, 0.16666666666667
13225, 0.041666666666667, 1.25, 0.16666666666667
13226, 0.041666666666667, 1.3, 0.16666666666667
13227, 0.041666666666667, 0.2, 0.20833333333333
13228, 0.041666666666667, 0.25, 0.20833333333333
13229, 0.041666666666667, 0.3, 0.20833333333333
13230, 0.041666666666667, 0.35, 0.20833333333333
13231, 0.041666666666667, 0.4, 0.20833333333333
13232, 0.041666666666667, 0.45, 0.20833333333333
13233, 0.041666666666667, 0.5, 0.20833333333333
13234, 0.041666666666667, 0.55, 0.20833333333333
13235, 0.041666666666667, 0.6, 0.20833333333333
13236, 0.041666666666667, 0.65, 0.20833333333333
13237, 0.041666666666667, 0.7, 0.20833333333333
13238, 0.041666666666667, 0.75, 0.20833333333333
13239, 0.041666666666667, 0.8, 0.20833333333333
13240, 0.041666666666667, 0.85, 0.20833333333333
13241, 0.041666666666667, 0.9, 0.20833333333333
13242, 0.041666666666667, 0.95, 0.20833333333333
13243, 0.041666666666667, 1, 0.20833333333333
13244, 0.041666666666667, 1.05, 0.20833333333333
13245, 0.041666666666667, 1.1, 0.20833333333333
13246, 0.041666666666667, 1.15, 0.20833333333333
13247, 0.041666666666667, 1.2, 0.20833333333333
13248, 0.041666666666667, 1.25, 0.20833333333333
13249, 0.041666666666667, 1.3, 0.20833333333333
13250, 0.041666666666667, 0.2, 0.25
13251, 0.041666666666667, 0.25, 0.25
13252, 0.041666666666667, 0.3, 0.25
13253, 0.041666666666667, 0.35, 0.25
13254, 0.041666666666667, 0.4, 0.25
13255, 0.041666666666667, 0.45, 0.25
13256, 0.041666666666667, 0.5, 0.25
13257, 0.041666666666667, 0.55, 0.25
13258, 0.041666666666667, 0.6, 0.25
13259, 0.041666666666667, 0.65, 0.25
13260, 0.041666666666667, 0.7, 0.25
13261, 0.041666666666667, 0.75, 0.25
13262, 0.041666666666667, 0.8, 0.25
13263, 0.041666666666667, 0.85, 0.25
13264, 0.041666666666667, 0.9, 0.25
13265, 0.041666666666667, 0.95, 0.25
13266, 0.041666666666667, 1, 0.25
13267, 0.041666666666667, 1.05, 0.25
13268, 0.041666666666667, 1.1, 0.25
13269, 0.041666666666667, 1.15, 0.25
13270, 0.041666666666667, 1.2, 0.25
13271, 0.041666666666667, 1.25, 0.25
13272, 0.041666666666667, 1.3, 0.25
13273, 0.041666666666667, 0.2, 0.29166666666667
13274, 0.041666666666667, 0.25, 0.29166666666667
13275, 0.041666666666667, 0.3, 0.29166666666667
13276, 0.041666666666667, 0.35, 0.29166666666667
13277, 0.041666666666667, 0.4, 0.29166666666667
13278, 0.041666666666667, 0.45, 0.29166666666667
13279, 0.041666666666667, 0.5, 0.29166666666667
13280, 0.041666666666667, 0.55, 0.29166666666667
13281, 0.041666666666667, 0.6, 0.29166666666667
13282, 0.041666666666667, 0.65, 0.29166666666667
13283, 0.041666666666667, 0.7, 0.29166666666667
13284, 0.041666666666667, 0.75, 0.29166666666667
13285, 0.041666666666667, 0.8, 0.29166666666667
13286, 0.041666666666667, 0.85, 0.29166666666667
13287, 0.041666666666667, 0.9, 0.29166666666667
13288, 0.041666666666667, 0.95, 0.29166666666667
13289, 0.041666666666667, 1, 0.29166666666667
13290, 0.041666666666667, 1.05, 0.29166666666667
13291, 0.041666666666667, 1.1, 0.29166666666667
13292, 0.041666666666667, 1.15, 0.29166666666667
13293, 0.041666666666667, 1.2, 0.29166666666667
13294, 0.041666666666667, 1.25, 0.29166666666667
13295, 0.041666666666667, 1.3, 0.29166666666667
13296, 0.041666666666667, 0.2, 0.33333333333333
13297, 0.041666666666667, 0.25, 0.33333333333333
13298, 0.041666666666667, 0.3, 0.33333333333333
13299, 0.041666666666667, 0.35, 0.33333333333333
13300, 0.041666666666667, 0.4, 0.33333333333333
13301, 0.041666666666667, 0.45, 0.33333333333333
13302, 0.041666666666667, 0.5, 0.33333333333333
13303, 0.041666666666667, 0.55, 0.33333333333333
13304, 0.041666666666667, 0.6, 0.33333333333333
13305, 0.041666666666667, 0.65, 0.33333333333333
13306, 0.041666666666667, 0.7, 0.33333333333333
13307, 0.041666666666667, 0.75, 0.33333333333333
13308, 0.041666666666667, 0.8, 0.33333333333333
13309, 0.041666666666667, 0.85, 0.33333333333333
13310, 0.041666666666667, 0.9, 0.33333333333333
13311, 0.041666666666667, 0.95, 0.33333333333333
13312, 0.041666666666667, 1, 0.33333333333333
13313, 0.041666666666667, 1.05, 0.33333333333333
13314, 0.041666666666667, 1.1, 0.33333333333333
13315, 0.041666666666667, 1.15, 0.33333333333333
13316, 0.041666666666667, 1.2, 0.33333333333333
13317, 0.041666666666667, 1.25, 0.33333333333333
13318, 0.041666666666667, 1.3, 0.33333333333333
13319, 0.041666666666667, 0.2, 0.375
13320, 0.041666666666667, 0.25, 0.375
13321, 0.041666666666667, 0.3, 0.375
13322, 0.041666666666667, 0.35, 0.375
13323, 0.041666666666667, 0.4, 0.375
13324, 0.041666666666667, 0.45, 0.375
13325, 0.041666666666667, 0.5, 0.375
13326, 0.041666666666667, 0.55, 0.375
13327, 0.041666666666667, 0.6, 0.375
13328, 0.041666666666667, 0.65, 0.375
13329, 0.041666666666667, 0.7, 0.375
13330, 0.041666666666667, 0.75, 0.375
13331, 0.041666666666667, 0.8, 0.375
13332, 0.041666666666667, 0.85, 0.375
13333, 0.041666666666667, 0.9, 0.375
13334, 0.041666666666667, 0.95, 0.375
13335, 0.041666666666667, 1, 0.375
13336, 0.041666666666667, 1.05, 0.375
13337, 0.041666666666667, 1.1, 0.375
13338, 0.041666666666667, 1.15, 0.375
13339, 0.041666666666667, 1.2, 0.375
13340, 0.041666666666667, 1.25, 0.375
13341, 0.041666666666667, 1.3, 0.375
13342, 0.041666666666667, 0.2, 0.41666666666667
13343, 0.041666666666667, 0.25, 0.41666666666667
13344, 0.041666666666667, 0.3, 0.41666666666667
13345, 0.041666666666667, 0.35, 0.41666666666667
13346, 0.041666666666667, 0.4, 0.41666666666667
13347, 0.041666666666667, 0.45, 0.41666666666667
13348, 0.041666666666667, 0.5, 0.41666666666667
13349, 0.041666666666667, 0.55, 0.41666666666667
13350, 0.041666666666667, 0.6, 0.41666666666667
13351, 0.041666666666667, 0.65, 0.41666666666667
13352, 0.041666666666667, 0.7, 0.41666666666667
13353, 0.041666666666667, 0.75, 0.41666666666667
13354, 0.041666666666667, 0.8, 0.41666666666667
13355, 0.041666666666667, 0.85, 0.41666666666667
13356, 0.041666666666667, 0.9, 0.41666666666667
13357, 0.041666666666667, 0.95, 0.41666666666667
13358, 0.041666666666667, 1, 0.41666666666667
13359, 0.041666666666667, 1.05, 0.41666666666667
13360, 0.041666666666667, 1.1, 0.41666666666667
13361, 0.041666666666667, 1.15, 0.41666666666667
13362, 0.041666666666667, 1.2, 0.41666666666667
13363, 0.041666666666667, 1.25, 0.41666666666667
13364, 0.041666666666667, 1.3, 0.41666666666667
13365, 0.041666666666667, 0.2, 0.45833333333333
13366, 0.041666666666667, 0.25, 0.45833333333333
13367, 0.041666666666667, 0.3, 0.45833333333333
13368, 0.041666666666667, 0.35, 0.45833333333333
13369, 0.041666666666667, 0.4, 0.45833333333333
13370, 0.041666666666667, 0.45, 0.45833333333333
13371, 0.041666666666667, 0.5, 0.45833333333333
13372, 0.041666666666667, 0.55, 0.45833333333333
13373, 0.041666666666667, 0.6, 0.45833333333333
13374, 0.041666666666667, 0.65, 0.45833333333333
13375, 0.041666666666667, 0.7, 0.45833333333333
13376, 0.041666666666667, 0.75, 0.45833333333333
13377, 0.041666666666667, 0.8, 0.45833333333333
13378, 0.041666666666667, 0.85, 0.45833333333333
13379, 0.041666666666667, 0.9, 0.45833333333333
13380, 0.041666666666667, 0.95, 0.45833333333333
13381, 0.041666666666667, 1, 0.45833333333333
13382, 0.041666666666667, 1.05, 0.45833333333333
13383, 0.041666666666667, 1.1, 0.45833333333333
13384, 0.041666666666667, 1.15, 0.45833333333333
13385, 0.041666666666667, 1.2, 0.45833333333333
13386, 0.041666666666667, 1.25, 0.45833333333333
13387, 0.041666666666667, 1.3, 0.45833333333333
13388, 0.083333333333333, 0.2, 0.041666666666667
13389, 0.083333333333333, 0.25, 0.041666666666667
13390, 0.083333333333333, 0.3, 0.041666666666667
13391, 0.083333333333333, 0.35, 0.041666666666667
13392, 0.083333333333333, 0.4, 0.041666666666667
13393, 0.083333333333333, 0.45, 0.041666666666667
13394, 0.083333333333333, 0.5, 0.041666666666667
13395, 0.083333333333333, 0.55, 0.041666666666667
13396, 0.083333333333333, 0.6, 0.041666666666667
13397, 0.083333333333333, 0.65, 0.041666666666667
13398, 0.083333333333333, 0.7, 0.041666666666667
13399, 0.083333333333333, 0.75, 0.041666666666667
13400, 0.083333333333333, 0.8, 0.041666666666667
13401, 0.083333333333333, 0.85, 0.041666666666667
13402, 0.083333333333333, 0.9, 0.041666666666667
13403, 0.083333333333333, 0.95, 0.041666666666667
13404, 0.083333333333333, 1, 0.041666666666667
13405, 0.083333333333333, 1.05, 0.041666666666667
13406, 0.083333333333333, 1.1, 0.041666666666667
13407, 0.083333333333333, 1.15, 0.041666666666667
13408, 0.083333333333333, 1.2, 0.041666666666667
13409, 0.083333333333333, 1.25, 0.041666666666667
13410, 0.083333333333333, 1.3, 0.041666666666667
13411, 0.083333333333333, 0.2, 0.083333333333333
13412, 0.083333333333333, 0.25, 0.083333333333333
13413, 0.083333333333333, 0.3, 0.083333333333333
13414, 0.083333333333333, 0.35, 0.083333333333333
13415, 0.083333333333333, 0.4, 0.083333333333333
13416, 0.083333333333333, 0.45, 0.083333333333333
13417, 0.083333333333333, 0.5, 0.083333333333333
13418, 0.083333333333333, 0.55, 0.083333333333333
13419, 0.083333333333333, 0.6, 0.083333333333333
13420, 0.083333333333333, 0.65, 0.083333333333333
13421, 0.083333333333333, 0.7, 0.083333333333333
13422, 0.083333333333333, 0.75, 0.083333333333333
13423, 0.083333333333333, 0.8, 0.083333333333333
13424, 0.083333333333333, 0.85, 0.083333333333333
13425, 0.083333333333333, 0.9, 0.083333333333333
13426, 0.083333333333333, 0.95, 0.083333333333333
13427, 0.083333333333333, 1, 0.083333333333333
13428, 0.083333333333333, 1.05, 0.083333333333333
13429, 0.083333333333333, 1.1, 0.083333333333333
13430, 0.083333333333333, 1.15, 0.083333333333333
13431, 0.083333333333333, 1.2, 0.083333333333333
13432, 0.083333333333333, 1.25, 0.083333333333333
13433, 0.083333333333333, 1.3, 0.083333333333333
13434, 0.083333333333333, 0.2, 0.125
13435, 0.083333333333333, 0.25, 0.125
13436, 0.083333333333333, 0.3, 0.125
13437, 0.083333333333333, 0.35, 0.125
13438, 0.083333333333333, 0.4, 0.125
13439, 0.083333333333333, 0.45, 0.125
13440, 0.083333333333333, 0.5, 0.125
13441, 0.083333333333333, 0.55, 0.125
13442, 0.083333333333333, 0.6, 0.125
13443, 0.083333333333333, 0.65, 0.125
13444, 0.083333333333333, 0.7, 0.125
13445, 0.083333333333333, 0.75, 0.125
13446, 0.083333333333333, 0.8, 0.125
13447, 0.083333333333333, 0.85, 0.125
13448, 0.083333333333333, 0.9, 0.125
13449, 0.083333333333333, 0.95, 0.125
13450, 0.083333333333333, 1, 0.125
13451, 0.083333333333333, 1.05, 0.125
13452, 0.083333333333333, 1.1, 0.125
13453, 0.083333333333333, 1.15, 0.125
13454, 0.083333333333333, 1.2, 0.125
13455, 0.083333333333333, 1.25, 0.125
13456, 0.083333333333333, 1.3, 0.125
13457, 0.083333333333333, 0.2, 0.16666666666667
13458, 0.083333333333333, 0.25, 0.16666666666667
13459, 0.083333333333333, 0.3, 0.16666666666667
13460, 0.083333333333333, 0.35, 0.16666666666667
13461, 0.083333333333333, 0.4, 0.16666666666667
13462, 0.083333333333333, 0.45, 0.16666666666667
13463, 0.083333333333333, 0.5, 0.16666666666667
13464, 0.083333333333333, 0.55, 0.16666666666667
13465, 0.083333333333333, 0.6, 0.16666666666667
13466, 0.083333333333333, 0.65, 0.16666666666667
13467, 0.083333333333333, 0.7, 0.16666666666667
13468, 0.083333333333333, 0.75, 0.16666666666667
13469, 0.083333333333333, 0.8, 0.16666666666667
13470, 0.083333333333333, 0.85, 0.16666666666667
13471, 0.083333333333333, 0.9, 0.16666666666667
13472, 0.083333333333333, 0.95, 0.16666666666667
13473, 0.083333333333333, 1, 0.16666666666667
13474, 0.083333333333333, 1.05, 0.16666666666667
13475, 0.083333333333333, 1.1, 0.16666666666667
13476, 0.083333333333333, 1.15, 0.16666666666667
13477, 0.083333333333333, 1.2, 0.16666666666667
13478, 0.083333333333333, 1.25, 0.16666666666667
13479, 0.083333333333333, 1.3, 0.16666666666667
13480, 0.083333333333333, 0.2, 0.20833333333333
13481, 0.083333333333333, 0.25, 0.20833333333333
13482, 0.083333333333333, 0.3, 0.20833333333333
13483, 0.083333333333333, 0.35, 0.20833333333333
13484, 0.083333333333333, 0.4, 0.20833333333333
13485, 0.083333333333333, 0.45, 0.20833333333333
13486, 0.083333333333333, 0.5, 0.20833333333333
13487, 0.083333333333333, 0.55, 0.20833333333333
13488, 0.083333333333333, 0.6, 0.20833333333333
13489, 0.083333333333333, 0.65, 0.20833333333333
13490, 0.083333333333333, 0.7, 0.20833333333333
13491, 0.083333333333333, 0.75, 0.20833333333333
13492, 0.083333333333333, 0.8, 0.20833333333333
13493, 0.083333333333333, 0.85, 0.20833333333333
13494, 0.083333333333333, 0.9, 0.20833333333333
13495, 0.083333333333333, 0.95, 0.20833333333333
13496, 0.083333333333333, 1, 0.20833333333333
13497, 0.083333333333333, 1.05, 0.20833333333333
13498, 0.083333333333333, 1.1, 0.20833333333333
13499, 0.083333333333333, 1.15, 0.20833333333333
13500, 0.083333333333333, 1.2, 0.20833333333333
13501, 0.083333333333333, 1.25, 0.20833333333333
13502, 0.083333333333333, 1.3, 0.20833333333333
13503, 0.083333333333333, 0.2, 0.25
13504, 0.083333333333333, 0.25, 0.25
13505, 0.083333333333333, 0.3, 0.25
13506, 0.083333333333333, 0.35, 0.25
13507, 0.083333333333333, 0.4, 0.25
13508, 0.083333333333333, 0.45, 0.25
13509, 0.083333333333333, 0.5, 0.25
13510, 0.083333333333333, 0.55, 0.25
13511, 0.083333333333333, 0.6, 0.25
13512, 0.083333333333333, 0.65, 0.25
13513, 0.083333333333333, 0.7, 0.25
13514, 0.083333333333333, 0.75, 0.25
13515, 0.083333333333333, 0.8, 0.25
13516, 0.083333333333333, 0.85, 0.25
13517, 0.083333333333333, 0.9, 0.25
13518, 0.083333333333333, 0.95, 0.25
13519, 0.083333333333333, 1, 0.25
13520, 0.083333333333333, 1.05, 0.25
13521, 0.083333333333333, 1.1, 0.25
13522, 0.083333333333333, 1.15, 0.25
13523, 0.083333333333333, 1.2, 0.25
13524, 0.083333333333333, 1.25, 0.25
13525, 0.083333333333333, 1.3, 0.25
13526, 0.083333333333333, 0.2, 0.29166666666667
13527, 0.083333333333333, 0.25, 0.29166666666667
13528, 0.083333333333333, 0.3, 0.29166666666667
13529, 0.083333333333333, 0.35, 0.29166666666667
13530, 0.083333333333333, 0.4, 0.29166666666667
13531, 0.083333333333333, 0.45, 0.29166666666667
13532, 0.083333333333333, 0.5, 0.29166666666667
13533, 0.083333333333333, 0.55, 0.29166666666667
13534, 0.083333333333333, 0.6, 0.29166666666667
13535, 0.083333333333333, 0.65, 0.29166666666667
13536, 0.083333333333333, 0.7, 0.29166666666667
13537, 0.083333333333333, 0.75, 0.29166666666667
13538, 0.083333333333333, 0.8, 0.29166666666667
13539, 0.083333333333333, 0.85, 0.29166666666667
13540, 0.083333333333333, 0.9, 0.29166666666667
13541, 0.083333333333333, 0.95, 0.29166666666667
13542, 0.083333333333333, 1, 0.29166666666667
13543, 0.083333333333333, 1.05, 0.29166666666667
13544, 0.083333333333333, 1.1, 0.29166666666667
13545, 0.083333333333333, 1.15, 0.29166666666667
13546, 0.083333333333333, 1.2, 0.29166666666667
13547, 0.083333333333333, 1.25, 0.29166666666667
13548, 0.083333333333333, 1.3, 0.29166666666667
13549, 0.083333333333333, 0.2, 0.33333333333333
13550, 0.083333333333333, 0.25, 0.33333333333333
13551, 0.083333333333333, 0.3, 0.33333333333333
13552, 0.083333333333333, 0.35, 0.33333333333333
13553, 0.083333333333333, 0.4, 0.33333333333333
13554, 0.083333333333333, 0.45, 0.33333333333333
13555, 0.083333333333333, 0.5, 0.33333333333333
13556, 0.083333333333333, 0.55, 0.33333333333333
13557, 0.083333333333333, 0.6, 0.33333333333333
13558, 0.083333333333333, 0.65, 0.33333333333333
13559, 0.083333333333333, 0.7, 0.33333333333333
13560, 0.083333333333333, 0.75, 0.33333333333333
13561, 0.083333333333333, 0.8, 0.33333333333333
13562, 0.083333333333333, 0.85, 0.33333333333333
13563, 0.083333333333333, 0.9, 0.33333333333333
13564, 0.083333333333333, 0.95, 0.33333333333333
13565, 0.083333333333333, 1, 0.33333333333333
13566, 0.083333333333333, 1.05, 0.33333333333333
13567, 0.083333333333333, 1.1, 0.33333333333333
13568, 0.083333333333333, 1.15, 0.33333333333333
13569, 0.083333333333333, 1.2, 0.33333333333333
13570, 0.083333333333333, 1.25, 0.33333333333333
13571, 0.083333333333333, 1.3, 0.33333333333333
13572, 0.083333333333333, 0.2, 0.375
13573, 0.083333333333333, 0.25, 0.375
13574, 0.083333333333333, 0.3, 0.375
13575, 0.083333333333333, 0.35, 0.375
13576, 0.083333333333333, 0.4, 0.375
13577, 0.083333333333333, 0.45, 0.375
13578, 0.083333333333333, 0.5, 0.375
13579, 0.083333333333333, 0.55, 0.375
13580, 0.083333333333333, 0.6, 0.375
13581, 0.083333333333333, 0.65, 0.375
13582, 0.083333333333333, 0.7, 0.375
13583, 0.083333333333333, 0.75, 0.375
13584, 0.083333333333333, 0.8, 0.375
13585, 0.083333333333333, 0.85, 0.375
13586, 0.083333333333333, 0.9, 0.375
13587, 0.083333333333333, 0.95, 0.375
13588, 0.083333333333333, 1, 0.375
13589, 0.083333333333333, 1.05, 0.375
13590, 0.083333333333333, 1.1, 0.375
13591, 0.083333333333333, 1.15, 0.375
13592, 0.083333333333333, 1.2, 0.375
13593, 0.083333333333333, 1.25, 0.375
13594, 0.083333333333333, 1.3, 0.375
13595, 0.083333333333333, 0.2, 0.41666666666667
13596, 0.083333333333333, 0.25, 0.41666666666667
13597, 0.083333333333333, 0.3, 0.41666666666667
13598, 0.083333333333333, 0.35, 0.41666666666667
13599, 0.083333333333333, 0.4, 0.41666666666667
13600, 0.083333333333333, 0.45, 0.41666666666667
13601, 0.083333333333333, 0.5, 0.41666666666667
13602, 0.083333333333333, 0.55, 0.41666666666667
13603, 0.083333333333333, 0.6, 0.41666666666667
13604, 0.083333333333333, 0.65, 0.41666666666667
13605, 0.083333333333333, 0.7, 0.41666666666667
13606, 0.083333333333333, 0.75, 0.41666666666667
13607, 0.083333333333333, 0.8, 0.41666666666667
13608, 0.083333333333333, 0.85, 0.41666666666667
13609, 0.083333333333333, 0.9, 0.41666666666667
13610, 0.083333333333333, 0.95, 0.41666666666667
13611, 0.083333333333333, 1, 0.41666666666667
13612, 0.083333333333333, 1.05, 0.41666666666667
13613, 0.083333333333333, 1.1, 0.41666666666667
13614, 0.083333333333333, 1.15, 0.41666666666667
13615, 0.083333333333333, 1.2, 0.41666666666667
13616, 0.083333333333333, 1.25, 0.41666666666667
13617, 0.083333333333333, 1.3, 0.41666666666667
13618, 0.083333333333333, 0.2, 0.45833333333333
13619, 0.083333333333333, 0.25, 0.45833333333333
13620, 0.083333333333333, 0.3, 0.45833333333333
13621, 0.083333333333333, 0.35, 0.45833333333333
13622, 0.083333333333333, 0.4, 0.45833333333333
13623, 0.083333333333333, 0.45, 0.45833333333333
13624, 0.083333333333333, 0.5, 0.45833333333333
13625, 0.083333333333333, 0.55, 0.45833333333333
13626, 0.083333333333333, 0.6, 0.45833333333333
13627, 0.083333333333333, 0.65, 0.45833333333333
13628, 0.083333333333333, 0.7, 0.45833333333333
13629, 0.083333333333333, 0.75, 0.45833333333333
13630, 0.083333333333333, 0.8, 0.45833333333333
13631, 0.083333333333333, 0.85, 0.45833333333333
13632, 0.083333333333333, 0.9, 0.45833333333333
13633, 0.083333333333333, 0.95, 0.45833333333333
13634, 0.083333333333333, 1, 0.45833333333333
13635, 0.083333333333333, 1.05, 0.45833333333333
13636, 0.083333333333333, 1.1, 0.45833333333333
13637, 0.083333333333333, 1.15, 0.45833333333333
13638, 0.083333333333333, 1.2, 0.45833333333333
13639, 0.083333333333333, 1.25, 0.45833333333333
13640, 0.083333333333333, 1.3, 0.45833333333333
13641, 0.125, 0.2, 0.041666666666667
13642, 0.125, 0.25, 0.041666666666667
13643, 0.125, 0.3, 0.041666666666667
13644, 0.125, 0.35, 0.041666666666667
13645, 0.125, 0.4, 0.041666666666667
13646, 0.125, 0.45, 0.041666666666667
13647, 0.125, 0.5, 0.041666666666667
13648, 0.125, 0.55, 0.041666666666667
13649, 0.125, 0.6, 0.041666666666667
13650, 0.125, 0.65, 0.041666666666667
13651, 0.125, 0.7, 0.041666666666667
13652, 0.125, 0.75, 0.041666666666667
13653, 0.125, 0.8, 0.041666666666667
13654, 0.125, 0.85, 0.041666666666667
13655, 0.125, 0.9, 0.041666666666667
13656, 0.125, 0.95, 0.041666666666667
13657, 0.125, 1, 0.041666666666667
13658, 0.125, 1.05, 0.041666666666667
13659, 0.125, 1.1, 0.041666666666667
13660, 0.125, 1.15, 0.041666666666667
13661, 0.125, 1.2, 0.041666666666667
13662, 0.125, 1.25, 0.041666666666667
13663, 0.125, 1.3, 0.041666666666667
13664, 0.125, 0.2, 0.083333333333333
13665, 0.125, 0.25, 0.083333333333333
13666, 0.125, 0.3, 0.083333333333333
13667, 0.125, 0.35, 0.083333333333333
13668, 0.125, 0.4, 0.083333333333333
13669, 0.125, 0.45, 0.083333333333333
13670, 0.125, 0.5, 0.083333333333333
13671, 0.125, 0.55, 0.083333333333333
13672, 0.125, 0.6, 0.083333333333333
13673, 0.125, 0.65, 0.083333333333333
13674, 0.125, 0.7, 0.083333333333333
13675, 0.125, 0.75, 0.083333333333333
13676, 0.125, 0.8, 0.083333333333333
13677, 0.125, 0.85, 0.083333333333333
13678, 0.125, 0.9, 0.083333333333333
13679, 0.125, 0.95, 0.083333333333333
13680, 0.125, 1, 0.083333333333333
13681, 0.125, 1.05, 0.083333333333333
13682, 0.125, 1.1, 0.083333333333333
13683, 0.125, 1.15, 0.083333333333333
13684, 0.125, 1.2, 0.083333333333333
13685, 0.125, 1.25, 0.083333333333333
13686, 0.125, 1.3, 0.083333333333333
13687, 0.125, 0.2, 0.125
13688, 0.125, 0.25, 0.125
13689, 0.125, 0.3, 0.125
13690, 0.125, 0.35, 0.125
13691, 0.125, 0.4, 0.125
13692, 0.125, 0.45, 0.125
13693, 0.125, 0.5, 0.125
13694, 0.125, 0.55, 0.125
13695, 0.125, 0.6, 0.125
13696, 0.125, 0.65, 0.125
13697, 0.125, 0.7, 0.125
13698, 0.125, 0.75, 0.125
13699, 0.125, 0.8, 0.125
13700, 0.125, 0.85, 0.125
13701, 0.125, 0.9, 0.125
13702, 0.125, 0.95, 0.125
13703, 0.125, 1, 0.125
13704, 0.125, 1.05, 0.125
13705, 0.125, 1.1, 0.125
13706, 0.125, 1.15, 0.125
13707, 0.125, 1.2, 0.125
13708, 0.125, 1.25, 0.125
13709, 0.125, 1.3, 0.125
13710, 0.125, 0.2, 0.16666666666667
13711, 0.125, 0.25, 0.16666666666667
13712, 0.125, 0.3, 0.16666666666667
13713, 0.125, 0.35, 0.16666666666667
13714, 0.125, 0.4, 0.16666666666667
13715, 0.125, 0.45, 0.16666666666667
13716, 0.125, 0.5, 0.16666666666667
13717, 0.125, 0.55, 0.16666666666667
13718, 0.125, 0.6, 0.16666666666667
13719, 0.125, 0.65, 0.16666666666667
13720, 0.125, 0.7, 0.16666666666667
13721, 0.125, 0.75, 0.16666666666667
13722, 0.125, 0.8, 0.16666666666667
13723, 0.125, 0.85, 0.16666666666667
13724, 0.125, 0.9, 0.16666666666667
13725, 0.125, 0.95, 0.16666666666667
13726, 0.125, 1, 0.16666666666667
13727, 0.125, 1.05, 0.16666666666667
13728, 0.125, 1.1, 0.16666666666667
13729, 0.125, 1.15, 0.16666666666667
13730, 0.125, 1.2, 0.16666666666667
13731, 0.125, 1.25, 0.16666666666667
13732, 0.125, 1.3, 0.16666666666667
13733, 0.125, 0.2, 0.20833333333333
13734, 0.125, 0.25, 0.20833333333333
13735, 0.125, 0.3, 0.20833333333333
13736, 0.125, 0.35, 0.20833333333333
13737, 0.125, 0.4, 0.20833333333333
13738, 0.125, 0.45, 0.20833333333333
13739, 0.125, 0.5, 0.20833333333333
13740, 0.125, 0.55, 0.20833333333333
13741, 0.125, 0.6, 0.20833333333333
13742, 0.125, 0.65, 0.20833333333333
13743, 0.125, 0.7, 0.20833333333333
13744, 0.125, 0.75, 0.20833333333333
13745, 0.125, 0.8, 0.20833333333333
13746, 0.125, 0.85, 0.20833333333333
13747, 0.125, 0.9, 0.20833333333333
13748, 0.125, 0.95, 0.20833333333333
13749, 0.125, 1, 0.20833333333333
13750, 0.125, 1.05, 0.20833333333333
13751, 0.125, 1.1, 0.20833333333333
13752, 0.125, 1.15, 0.20833333333333
13753, 0.125, 1.2, 0.20833333333333
13754, 0.125, 1.25, 0.20833333333333
13755, 0.125, 1.3, 0.20833333333333
13756, 0.125, 0.2, 0.25
13757, 0.125, 0.25, 0.25
13758, 0.125, 0.3, 0.25
13759, 0.125, 0.35, 0.25
13760, 0.125, 0.4, 0.25
13761, 0.125, 0.45, 0.25
13762, 0.125, 0.5, 0.25
13763, 0.125, 0.55, 0.25
13764, 0.125, 0.6, 0.25
13765, 0.125, 0.65, 0.25
13766, 0.125, 0.7, 0.25
13767, 0.125, 0.75, 0.25
13768, 0.125, 0.8, 0.25
13769, 0.125, 0.85, 0.25
13770, 0.125, 0.9, 0.25
13771, 0.125, 0.95, 0.25
13772, 0.125, 1, 0.25
13773, 0.125, 1.05, 0.25
13774, 0.125, 1.1, 0.25
13775, 0.125, 1.15, 0.25
13776, 0.125, 1.2, 0.25
13777, 0.125, 1.25, 0.25
13778, 0.125, 1.3, 0.25
13779, 0.125, 0.2, 0.29166666666667
13780, 0.125, 0.25, 0.29166666666667
13781, 0.125, 0.3, 0.29166666666667
13782, 0.125, 0.35, 0.29166666666667
13783, 0.125, 0.4, 0.29166666666667
13784, 0.125, 0.45, 0.29166666666667
13785, 0.125, 0.5, 0.29166666666667
13786, 0.125, 0.55, 0.29166666666667
13787, 0.125, 0.6, 0.29166666666667
13788, 0.125, 0.65, 0.29166666666667
13789, 0.125, 0.7, 0.29166666666667
13790, 0.125, 0.75, 0.29166666666667
13791, 0.125, 0.8, 0.29166666666667
13792, 0.125, 0.85, 0.29166666666667
13793, 0.125, 0.9, 0.29166666666667
13794, 0.125, 0.95, 0.29166666666667
13795, 0.125, 1, 0.29166666666667
13796, 0.125, 1.05, 0.29166666666667
13797, 0.125, 1.1, 0.29166666666667
13798, 0.125, 1.15, 0.29166666666667
13799, 0.125, 1.2, 0.29166666666667
13800, 0.125, 1.25, 0.29166666666667
13801, 0.125, 1.3, 0.29166666666667
13802, 0.125, 0.2, 0.33333333333333
13803, 0.125, 0.25, 0.33333333333333
13804, 0.125, 0.3, 0.33333333333333
13805, 0.125, 0.35, 0.33333333333333
13806, 0.125, 0.4, 0.33333333333333
13807, 0.125, 0.45, 0.33333333333333
13808, 0.125, 0.5, 0.33333333333333
13809, 0.125, 0.55, 0.33333333333333
13810, 0.125, 0.6, 0.33333333333333
13811, 0.125, 0.65, 0.33333333333333
13812, 0.125, 0.7, 0.33333333333333
13813, 0.125, 0.75, 0.33333333333333
13814, 0.125, 0.8, 0.33333333333333
13815, 0.125, 0.85, 0.33333333333333
13816, 0.125, 0.9, 0.33333333333333
13817, 0.125, 0.95, 0.33333333333333
13818, 0.125, 1, 0.33333333333333
13819, 0.125, 1.05, 0.33333333333333
13820, 0.125, 1.1, 0.33333333333333
13821, 0.125, 1.15, 0.33333333333333
13822, 0.125, 1.2, 0.33333333333333
13823, 0.125, 1.25, 0.33333333333333
13824, 0.125, 1.3, 0.33333333333333
13825, 0.125, 0.2, 0.375
13826, 0.125, 0.25, 0.375
13827, 0.125, 0.3, 0.375
13828, 0.125, 0.35, 0.375
13829, 0.125, 0.4, 0.375
13830, 0.125, 0.45, 0.375
13831, 0.125, 0.5, 0.375
13832, 0.125, 0.55, 0.375
13833, 0.125, 0.6, 0.375
13834, 0.125, 0.65, 0.375
13835, 0.125, 0.7, 0.375
13836, 0.125, 0.75, 0.375
13837, 0.125, 0.8, 0.375
13838, 0.125, 0.85, 0.375
13839, 0.125, 0.9, 0.375
13840, 0.125, 0.95, 0.375
13841, 0.125, 1, 0.375
13842, 0.125, 1.05, 0.375
13843, 0.125, 1.1, 0.375
13844, 0.125, 1.15, 0.375
13845, 0.125, 1.2, 0.375
13846, 0.125, 1.25, 0.375
13847, 0.125, 1.3, 0.375
13848, 0.125, 0.2, 0.41666666666667
13849, 0.125, 0.25, 0.41666666666667
13850, 0.125, 0.3, 0.41666666666667
13851, 0.125, 0.35, 0.41666666666667
13852, 0.125, 0.4, 0.41666666666667
13853, 0.125, 0.45, 0.41666666666667
13854, 0.125, 0.5, 0.41666666666667
13855, 0.125, 0.55, 0.41666666666667
13856, 0.125, 0.6, 0.41666666666667
13857, 0.125, 0.65, 0.41666666666667
13858, 0.125, 0.7, 0.41666666666667
13859, 0.125, 0.75, 0.41666666666667
13860, 0.125, 0.8, 0.41666666666667
13861, 0.125, 0.85, 0.41666666666667
13862, 0.125, 0.9, 0.41666666666667
13863, 0.125, 0.95, 0.41666666666667
13864, 0.125, 1, 0.41666666666667
13865, 0.125, 1.05, 0.41666666666667
13866, 0.125, 1.1, 0.41666666666667
13867, 0.125, 1.15, 0.41666666666667
13868, 0.125, 1.2, 0.41666666666667
13869, 0.125, 1.25, 0.41666666666667
13870, 0.125, 1.3, 0.41666666666667
13871, 0.125, 0.2, 0.45833333333333
13872, 0.125, 0.25, 0.45833333333333
13873, 0.125, 0.3, 0.45833333333333
13874, 0.125, 0.35, 0.45833333333333
13875, 0.125, 0.4, 0.45833333333333
13876, 0.125, 0.45, 0.45833333333333
13877, 0.125, 0.5, 0.45833333333333
13878, 0.125, 0.55, 0.45833333333333
13879, 0.125, 0.6, 0.45833333333333
13880, 0.125, 0.65, 0.45833333333333
13881, 0.125, 0.7, 0.45833333333333
13882, 0.125, 0.75, 0.45833333333333
13883, 0.125, 0.8, 0.45833333333333
13884, 0.125, 0.85, 0.45833333333333
13885, 0.125, 0.9, 0.45833333333333
13886, 0.125, 0.95, 0.45833333333333
13887, 0.125, 1, 0.45833333333333
13888, 0.125, 1.05, 0.45833333333333
13889, 0.125, 1.1, 0.45833333333333
13890, 0.125, 1.15, 0.45833333333333
13891, 0.125, 1.2, 0.45833333333333
13892, 0.125, 1.25, 0.45833333333333
13893, 0.125, 1.3, 0.45833333333333
13894, 0.16666666666667, 0.2, 0.041666666666667
13895, 0.16666666666667, 0.25, 0.041666666666667
13896, 0.16666666666667, 0.3, 0.041666666666667
13897, 0.16666666666667, 0.35, 0.041666666666667
13898, 0.16666666666667, 0.4, 0.041666666666667
13899, 0.16666666666667, 0.45, 0.041666666666667
13900, 0.16666666666667, 0.5, 0.041666666666667
13901, 0.16666666666667, 0.55, 0.041666666666667
13902, 0.16666666666667, 0.6, 0.041666666666667
13903, 0.16666666666667, 0.65, 0.041666666666667
13904, 0.16666666666667, 0.7, 0.041666666666667
13905, 0.16666666666667, 0.75, 0.041666666666667
13906, 0.16666666666667, 0.8, 0.041666666666667
13907, 0.16666666666667, 0.85, 0.041666666666667
13908, 0.16666666666667, 0.9, 0.041666666666667
13909, 0.16666666666667, 0.95, 0.041666666666667
13910, 0.16666666666667, 1, 0.041666666666667
13911, 0.16666666666667, 1.05, 0.041666666666667
13912, 0.16666666666667, 1.1, 0.041666666666667
13913, 0.16666666666667, 1.15, 0.041666666666667
13914, 0.16666666666667, 1.2, 0.041666666666667
13915, 0.16666666666667, 1.25, 0.041666666666667
13916, 0.16666666666667, 1.3, 0.041666666666667
13917, 0.16666666666667, 0.2, 0.083333333333333
13918, 0.16666666666667, 0.25, 0.083333333333333
13919, 0.16666666666667, 0.3, 0.083333333333333
13920, 0.16666666666667, 0.35, 0.083333333333333
13921, 0.16666666666667, 0.4, 0.083333333333333
13922, 0.16666666666667, 0.45, 0.083333333333333
13923, 0.16666666666667, 0.5, 0.083333333333333
13924, 0.16666666666667, 0.55, 0.083333333333333
13925, 0.16666666666667, 0.6, 0.083333333333333
13926, 0.16666666666667, 0.65, 0.083333333333333
13927, 0.16666666666667, 0.7, 0.083333333333333
13928, 0.16666666666667, 0.75, 0.083333333333333
13929, 0.16666666666667, 0.8, 0.083333333333333
13930, 0.16666666666667, 0.85, 0.083333333333333
13931, 0.16666666666667, 0.9, 0.083333333333333
13932, 0.16666666666667, 0.95, 0.083333333333333
13933, 0.16666666666667, 1, 0.083333333333333
13934, 0.16666666666667, 1.05, 0.083333333333333
13935, 0.16666666666667, 1.1, 0.083333333333333
13936, 0.16666666666667, 1.15, 0.083333333333333
13937, 0.16666666666667, 1.2, 0.083333333333333
13938, 0.16666666666667, 1.25, 0.083333333333333
13939, 0.16666666666667, 1.3, 0.083333333333333
13940, 0.16666666666667, 0.2, 0.125
13941, 0.16666666666667, 0.25, 0.125
13942, 0.16666666666667, 0.3, 0.125
13943, 0.16666666666667, 0.35, 0.125
13944, 0.16666666666667, 0.4, 0.125
13945, 0.16666666666667, 0.45, 0.125
13946, 0.16666666666667, 0.5, 0.125
13947, 0.16666666666667, 0.55, 0.125
13948, 0.16666666666667, 0.6, 0.125
13949, 0.16666666666667, 0.65, 0.125
13950, 0.16666666666667, 0.7, 0.125
13951, 0.16666666666667, 0.75, 0.125
13952, 0.16666666666667, 0.8, 0.125
13953, 0.16666666666667, 0.85, 0.125
13954, 0.16666666666667, 0.9, 0.125
13955, 0.16666666666667, 0.95, 0.125
13956, 0.16666666666667, 1, 0.125
13957, 0.16666666666667, 1.05, 0.125
13958, 0.16666666666667, 1.1, 0.125
13959, 0.16666666666667, 1.15, 0.125
13960, 0.16666666666667, 1.2, 0.125
13961, 0.16666666666667, 1.25, 0.125
13962, 0.16666666666667, 1.3, 0.125
13963, 0.16666666666667, 0.2, 0.16666666666667
13964, 0.16666666666667, 0.25, 0.16666666666667
13965, 0.16666666666667, 0.3, 0.16666666666667
13966, 0.16666666666667, 0.35, 0.16666666666667
13967, 0.16666666666667, 0.4, 0.16666666666667
13968, 0.16666666666667, 0.45, 0.16666666666667
13969, 0.16666666666667, 0.5, 0.16666666666667
13970, 0.16666666666667, 0.55, 0.16666666666667
13971, 0.16666666666667, 0.6, 0.16666666666667
13972, 0.16666666666667, 0.65, 0.16666666666667
13973, 0.16666666666667, 0.7, 0.16666666666667
13974, 0.16666666666667, 0.75, 0.16666666666667
13975, 0.16666666666667, 0.8, 0.16666666666667
13976, 0.16666666666667, 0.85, 0.16666666666667
13977, 0.16666666666667, 0.9, 0.16666666666667
13978, 0.16666666666667, 0.95, 0.16666666666667
13979, 0.16666666666667, 1, 0.16666666666667
13980, 0.16666666666667, 1.05, 0.16666666666667
13981, 0.16666666666667, 1.1, 0.16666666666667
13982, 0.16666666666667, 1.15, 0.16666666666667
13983, 0.16666666666667, 1.2, 0.16666666666667
13984, 0.16666666666667, 1.25, 0.16666666666667
13985, 0.16666666666667, 1.3, 0.16666666666667
13986, 0.16666666666667, 0.2, 0.20833333333333
13987, 0.16666666666667, 0.25, 0.20833333333333
13988, 0.16666666666667, 0.3, 0.20833333333333
13989, 0.16666666666667, 0.35, 0.20833333333333
13990, 0.16666666666667, 0.4, 0.20833333333333
13991, 0.16666666666667, 0.45, 0.20833333333333
13992, 0.16666666666667, 0.5, 0.20833333333333
13993, 0.16666666666667, 0.55, 0.20833333333333
13994, 0.16666666666667, 0.6, 0.20833333333333
13995, 0.16666666666667, 0.65, 0.20833333333333
13996, 0.16666666666667, 0.7, 0.20833333333333
13997, 0.16666666666667, 0.75, 0.20833333333333
13998, 0.16666666666667, 0.8, 0.20833333333333
13999, 0.16666666666667, 0.85, 0.20833333333333
14000, 0.16666666666667, 0.9, 0.20833333333333
14001, 0.16666666666667, 0.95, 0.20833333333333
14002, 0.16666666666667, 1, 0.20833333333333
14003, 0.16666666666667, 1.05, 0.20833333333333
14004, 0.16666666666667, 1.1, 0.20833333333333
14005, 0.16666666666667, 1.15, 0.20833333333333
14006, 0.16666666666667, 1.2, 0.20833333333333
14007, 0.16666666666667, 1.25, 0.20833333333333
14008, 0.16666666666667, 1.3, 0.20833333333333
14009, 0.16666666666667, 0.2, 0.25
14010, 0.16666666666667, 0.25, 0.25
14011, 0.16666666666667, 0.3, 0.25
14012, 0.16666666666667, 0.35, 0.25
14013, 0.16666666666667, 0.4, 0.25
14014, 0.16666666666667, 0.45, 0.25
14015, 0.16666666666667, 0.5, 0.25
14016, 0.16666666666667, 0.55, 0.25
14017, 0.16666666666667, 0.6, 0.25
14018, 0.16666666666667, 0.65, 0.25
14019, 0.16666666666667, 0.7, 0.25
14020, 0.16666666666667, 0.75, 0.25
14021, 0.16666666666667, 0.8, 0.25
14022, 0.16666666666667, 0.85, 0.25
14023, 0.16666666666667, 0.9, 0.25
14024, 0.16666666666667, 0.95, 0.25
14025, 0.16666666666667, 1, 0.25
14026, 0.16666666666667, 1.05, 0.25
14027, 0.16666666666667, 1.1, 0.25
14028, 0.16666666666667, 1.15, 0.25
14029, 0.16666666666667, 1.2, 0.25
14030, 0.16666666666667, 1.25, 0.25
14031, 0.16666666666667, 1.3, 0.25
14032, 0.16666666666667, 0.2, 0.29166666666667
14033, 0.16666666666667, 0.25, 0.29166666666667
14034, 0.16666666666667, 0.3, 0.29166666666667
14035, 0.16666666666667, 0.35, 0.29166666666667
14036, 0.16666666666667, 0.4, 0.29166666666667
14037, 0.16666666666667, 0.45, 0.29166666666667
14038, 0.16666666666667, 0.5, 0.29166666666667
14039, 0.16666666666667, 0.55, 0.29166666666667
14040, 0.16666666666667, 0.6, 0.29166666666667
14041, 0.16666666666667, 0.65, 0.29166666666667
14042, 0.16666666666667, 0.7, 0.29166666666667
14043, 0.16666666666667, 0.75, 0.29166666666667
14044, 0.16666666666667, 0.8, 0.29166666666667
14045, 0.16666666666667, 0.85, 0.29166666666667
14046, 0.16666666666667, 0.9, 0.29166666666667
14047, 0.16666666666667, 0.95, 0.29166666666667
14048, 0.16666666666667, 1, 0.29166666666667
14049, 0.16666666666667, 1.05, 0.29166666666667
14050, 0.16666666666667, 1.1, 0.29166666666667
14051, 0.16666666666667, 1.15, 0.29166666666667
14052, 0.16666666666667, 1.2, 0.29166666666667
14053, 0.16666666666667, 1.25, 0.29166666666667
14054, 0.16666666666667, 1.3, 0.29166666666667
14055, 0.16666666666667, 0.2, 0.33333333333333
14056, 0.16666666666667, 0.25, 0.33333333333333
14057, 0.16666666666667, 0.3, 0.33333333333333
14058, 0.16666666666667, 0.35, 0.33333333333333
14059, 0.16666666666667, 0.4, 0.33333333333333
14060, 0.16666666666667, 0.45, 0.33333333333333
14061, 0.16666666666667, 0.5, 0.33333333333333
14062, 0.16666666666667, 0.55, 0.33333333333333
14063, 0.16666666666667, 0.6, 0.33333333333333
14064, 0.16666666666667, 0.65, 0.33333333333333
14065, 0.16666666666667, 0.7, 0.33333333333333
14066, 0.16666666666667, 0.75, 0.33333333333333
14067, 0.16666666666667, 0.8, 0.33333333333333
14068, 0.16666666666667, 0.85, 0.33333333333333
14069, 0.16666666666667, 0.9, 0.33333333333333
14070, 0.16666666666667, 0.95, 0.33333333333333
14071, 0.16666666666667, 1, 0.33333333333333
14072, 0.16666666666667, 1.05, 0.33333333333333
14073, 0.16666666666667, 1.1, 0.33333333333333
14074, 0.16666666666667, 1.15, 0.33333333333333
14075, 0.16666666666667, 1.2, 0.33333333333333
14076, 0.16666666666667, 1.25, 0.33333333333333
14077, 0.16666666666667, 1.3, 0.33333333333333
14078, 0.16666666666667, 0.2, 0.375
14079, 0.16666666666667, 0.25, 0.375
14080, 0.16666666666667, 0.3, 0.375
14081, 0.16666666666667, 0.35, 0.375
14082, 0.16666666666667, 0.4, 0.375
14083, 0.16666666666667, 0.45, 0.375
14084, 0.16666666666667, 0.5, 0.375
14085, 0.16666666666667, 0.55, 0.375
14086, 0.16666666666667, 0.6, 0.375
14087, 0.16666666666667, 0.65, 0.375
14088, 0.16666666666667, 0.7, 0.375
14089, 0.16666666666667, 0.75, 0.375
14090, 0.16666666666667, 0.8, 0.375
14091, 0.16666666666667, 0.85, 0.375
14092, 0.16666666666667, 0.9, 0.375
14093, 0.16666666666667, 0.95, 0.375
14094, 0.16666666666667, 1, 0.375
14095, 0.16666666666667, 1.05, 0.375
14096, 0.16666666666667, 1.1, 0.375
14097, 0.16666666666667, 1.15, 0.375
14098, 0.16666666666667, 1.2, 0.375
14099, 0.16666666666667, 1.25, 0.375
14100, 0.16666666666667, 1.3, 0.375
14101, 0.16666666666667, 0.2, 0.41666666666667
14102, 0.16666666666667, 0.25, 0.41666666666667
14103, 0.16666666666667, 0.3, 0.41666666666667
14104, 0.16666666666667, 0.35, 0.41666666666667
14105, 0.16666666666667, 0.4, 0.41666666666667
14106, 0.16666666666667, 0.45, 0.41666666666667
14107, 0.16666666666667, 0.5, 0.41666666666667
14108, 0.16666666666667, 0.55, 0.41666666666667
14109, 0.16666666666667, 0.6, 0.41666666666667
14110, 0.16666666666667, 0.65, 0.41666666666667
14111, 0.16666666666667, 0.7, 0.41666666666667
14112, 0.16666666666667, 0.75, 0.41666666666667
14113, 0.16666666666667, 0.8, 0.41666666666667
14114, 0.16666666666667, 0.85, 0.41666666666667
14115, 0.16666666666667, 0.9, 0.41666666666667
14116, 0.16666666666667, 0.95, 0.41666666666667
14117, 0.16666666666667, 1, 0.41666666666667
14118, 0.16666666666667, 1.05, 0.41666666666667
14119, 0.16666666666667, 1.1, 0.41666666666667
14120, 0.16666666666667, 1.15, 0.41666666666667
14121, 0.16666666666667, 1.2, 0.41666666666667
14122, 0.16666666666667, 1.25, 0.41666666666667
14123, 0.16666666666667, 1.3, 0.41666666666667
14124, 0.16666666666667, 0.2, 0.45833333333333
14125, 0.16666666666667, 0.25, 0.45833333333333
14126, 0.16666666666667, 0.3, 0.45833333333333
14127, 0.16666666666667, 0.35, 0.45833333333333
14128, 0.16666666666667, 0.4, 0.45833333333333
14129, 0.16666666666667, 0.45, 0.45833333333333
14130, 0.16666666666667, 0.5, 0.45833333333333
14131, 0.16666666666667, 0.55, 0.45833333333333
14132, 0.16666666666667, 0.6, 0.45833333333333
14133, 0.16666666666667, 0.65, 0.45833333333333
14134, 0.16666666666667, 0.7, 0.45833333333333
14135, 0.16666666666667, 0.75, 0.45833333333333
14136, 0.16666666666667, 0.8, 0.45833333333333
14137, 0.16666666666667, 0.85, 0.45833333333333
14138, 0.16666666666667, 0.9, 0.45833333333333
14139, 0.16666666666667, 0.95, 0.45833333333333
14140, 0.16666666666667, 1, 0.45833333333333
14141, 0.16666666666667, 1.05, 0.45833333333333
14142, 0.16666666666667, 1.1, 0.45833333333333
14143, 0.16666666666667, 1.15, 0.45833333333333
14144, 0.16666666666667, 1.2, 0.45833333333333
14145, 0.16666666666667, 1.25, 0.45833333333333
14146, 0.16666666666667, 1.3, 0.45833333333333
14147, 0.20833333333333, 0.2, 0.041666666666667
14148, 0.20833333333333, 0.25, 0.041666666666667
14149, 0.20833333333333, 0.3, 0.041666666666667
14150, 0.20833333333333, 0.35, 0.041666666666667
14151, 0.20833333333333, 0.4, 0.041666666666667
14152, 0.20833333333333, 0.45, 0.041666666666667
14153, 0.20833333333333, 0.5, 0.041666666666667
14154, 0.20833333333333, 0.55, 0.041666666666667
14155, 0.20833333333333, 0.6, 0.041666666666667
14156, 0.20833333333333, 0.65, 0.041666666666667
14157, 0.20833333333333, 0.7, 0.041666666666667
14158, 0.20833333333333, 0.75, 0.041666666666667
14159, 0.20833333333333, 0.8, 0.041666666666667
14160, 0.20833333333333, 0.85, 0.041666666666667
14161, 0.20833333333333, 0.9, 0.041666666666667
14162, 0.20833333333333, 0.95, 0.041666666666667
14163, 0.20833333333333, 1, 0.041666666666667
14164, 0.20833333333333, 1.05, 0.041666666666667
14165, 0.20833333333333, 1.1, 0.041666666666667
14166, 0.20833333333333, 1.15, 0.041666666666667
14167, 0.20833333333333, 1.2, 0.041666666666667
14168, 0.20833333333333, 1.25, 0.041666666666667
14169, 0.20833333333333, 1.3, 0.041666666666667
14170, 0.20833333333333, 0.2, 0.083333333333333
14171, 0.20833333333333, 0.25, 0.083333333333333
14172, 0.20833333333333, 0.3, 0.083333333333333
14173, 0.20833333333333, 0.35, 0.083333333333333
14174, 0.20833333333333, 0.4, 0.083333333333333
14175, 0.20833333333333, 0.45, 0.083333333333333
14176, 0.20833333333333, 0.5, 0.083333333333333
14177, 0.20833333333333, 0.55, 0.083333333333333
14178, 0.20833333333333, 0.6, 0.083333333333333
14179, 0.20833333333333, 0.65, 0.083333333333333
14180, 0.20833333333333, 0.7, 0.083333333333333
14181, 0.20833333333333, 0.75, 0.083333333333333
14182, 0.20833333333333, 0.8, 0.083333333333333
14183, 0.20833333333333, 0.85, 0.083333333333333
14184, 0.20833333333333, 0.9, 0.083333333333333
14185, 0.20833333333333, 0.95, 0.083333333333333
14186, 0.20833333333333, 1, 0.083333333333333
14187, 0.20833333333333, 1.05, 0.083333333333333
14188, 0.20833333333333, 1.1, 0.083333333333333
14189, 0.20833333333333, 1.15, 0.083333333333333
14190, 0.20833333333333, 1.2, 0.083333333333333
14191, 0.20833333333333, 1.25, 0.083333333333333
14192, 0.20833333333333, 1.3, 0.083333333333333
14193, 0.20833333333333, 0.2, 0.125
14194, 0.20833333333333, 0.25, 0.125
14195, 0.20833333333333, 0.3, 0.125
14196, 0.20833333333333, 0.35, 0.125
14197, 0.20833333333333, 0.4, 0.125
14198, 0.20833333333333, 0.45, 0.125
14199, 0.20833333333333, 0.5, 0.125
14200, 0.20833333333333, 0.55, 0.125
14201, 0.20833333333333, 0.6, 0.125
14202, 0.20833333333333, 0.65, 0.125
14203, 0.20833333333333, 0.7, 0.125
14204, 0.20833333333333, 0.75, 0.125
14205, 0.20833333333333, 0.8, 0.125
14206, 0.20833333333333, 0.85, 0.125
14207, 0.20833333333333, 0.9, 0.125
14208, 0.20833333333333, 0.95, 0.125
14209, 0.20833333333333, 1, 0.125
14210, 0.20833333333333, 1.05, 0.125
14211, 0.20833333333333, 1.1, 0.125
14212, 0.20833333333333, 1.15, 0.125
14213, 0.20833333333333, 1.2, 0.125
14214, 0.20833333333333, 1.25, 0.125
14215, 0.20833333333333, 1.3, 0.125
14216, 0.20833333333333, 0.2, 0.16666666666667
14217, 0.20833333333333, 0.25, 0.16666666666667
14218, 0.20833333333333, 0.3, 0.16666666666667
14219, 0.20833333333333, 0.35, 0.16666666666667
14220, 0.20833333333333, 0.4, 0.16666666666667
14221, 0.20833333333333, 0.45, 0.16666666666667
14222, 0.20833333333333, 0.5, 0.16666666666667
14223, 0.20833333333333, 0.55, 0.16666666666667
14224, 0.20833333333333, 0.6, 0.16666666666667
14225, 0.20833333333333, 0.65, 0.16666666666667
14226, 0.20833333333333, 0.7, 0.16666666666667
14227, 0.20833333333333, 0.75, 0.16666666666667
14228, 0.20833333333333, 0.8, 0.16666666666667
14229, 0.20833333333333, 0.85, 0.16666666666667
14230, 0.20833333333333, 0.9, 0.16666666666667
14231, 0.20833333333333, 0.95, 0.16666666666667
14232, 0.20833333333333, 1, 0.16666666666667
14233, 0.20833333333333, 1.05, 0.16666666666667
14234, 0.20833333333333, 1.1, 0.16666666666667
14235, 0.20833333333333, 1.15, 0.16666666666667
14236, 0.20833333333333, 1.2, 0.16666666666667
14237, 0.20833333333333, 1.25, 0.16666666666667
14238, 0.20833333333333, 1.3, 0.16666666666667
14239, 0.20833333333333, 0.2, 0.20833333333333
14240, 0.20833333333333, 0.25, 0.20833333333333
14241, 0.20833333333333, 0.3, 0.20833333333333
14242, 0.20833333333333, 0.35, 0.20833333333333
14243, 0.20833333333333, 0.4, 0.20833333333333
14244, 0.20833333333333, 0.45, 0.20833333333333
14245, 0.20833333333333, 0.5, 0.20833333333333
14246, 0.20833333333333, 0.55, 0.20833333333333
14247, 0.20833333333333, 0.6, 0.20833333333333
14248, 0.20833333333333, 0.65, 0.20833333333333
14249, 0.20833333333333, 0.7, 0.20833333333333
14250, 0.20833333333333, 0.75, 0.20833333333333
14251, 0.20833333333333, 0.8, 0.20833333333333
14252, 0.20833333333333, 0.85, 0.20833333333333
14253, 0.20833333333333, 0.9, 0.20833333333333
14254, 0.20833333333333, 0.95, 0.20833333333333
14255, 0.20833333333333, 1, 0.20833333333333
14256, 0.20833333333333, 1.05, 0.20833333333333
14257, 0.20833333333333, 1.1, 0.20833333333333
14258, 0.20833333333333, 1.15, 0.20833333333333
14259, 0.20833333333333, 1.2, 0.20833333333333
14260, 0.20833333333333, 1.25, 0.20833333333333
14261, 0.20833333333333, 1.3, 0.20833333333333
14262, 0.20833333333333, 0.2, 0.25
14263, 0.20833333333333, 0.25, 0.25
14264, 0.20833333333333, 0.3, 0.25
14265, 0.20833333333333, 0.35, 0.25
14266, 0.20833333333333, 0.4, 0.25
14267, 0.20833333333333, 0.45, 0.25
14268, 0.20833333333333, 0.5, 0.25
14269, 0.20833333333333, 0.55, 0.25
14270, 0.20833333333333, 0.6, 0.25
14271, 0.20833333333333, 0.65, 0.25
14272, 0.20833333333333, 0.7, 0.25
14273, 0.20833333333333, 0.75, 0.25
14274, 0.20833333333333, 0.8, 0.25
14275, 0.20833333333333, 0.85, 0.25
14276, 0.20833333333333, 0.9, 0.25
14277, 0.20833333333333, 0.95, 0.25
14278, 0.20833333333333, 1, 0.25
14279, 0.20833333333333, 1.05, 0.25
14280, 0.20833333333333, 1.1, 0.25
14281, 0.20833333333333, 1.15, 0.25
14282, 0.20833333333333, 1.2, 0.25
14283, 0.20833333333333, 1.25, 0.25
14284, 0.20833333333333, 1.3, 0.25
14285, 0.20833333333333, 0.2, 0.29166666666667
14286, 0.20833333333333, 0.25, 0.29166666666667
14287, 0.20833333333333, 0.3, 0.29166666666667
14288, 0.20833333333333, 0.35, 0.29166666666667
14289, 0.20833333333333, 0.4, 0.29166666666667
14290, 0.20833333333333, 0.45, 0.29166666666667
14291, 0.20833333333333, 0.5, 0.29166666666667
14292, 0.20833333333333, 0.55, 0.29166666666667
14293, 0.20833333333333, 0.6, 0.29166666666667
14294, 0.20833333333333, 0.65, 0.29166666666667
14295, 0.20833333333333, 0.7, 0.29166666666667
14296, 0.20833333333333, 0.75, 0.29166666666667
14297, 0.20833333333333, 0.8, 0.29166666666667
14298, 0.20833333333333, 0.85, 0.29166666666667
14299, 0.20833333333333, 0.9, 0.29166666666667
14300, 0.20833333333333, 0.95, 0.29166666666667
14301, 0.20833333333333, 1, 0.29166666666667
14302, 0.20833333333333, 1.05, 0.29166666666667
14303, 0.20833333333333, 1.1, 0.29166666666667
14304, 0.20833333333333, 1.15, 0.29166666666667
14305, 0.20833333333333, 1.2, 0.29166666666667
14306, 0.20833333333333, 1.25, 0.29166666666667
14307, 0.20833333333333, 1.3, 0.29166666666667
14308, 0.20833333333333, 0.2, 0.33333333333333
14309, 0.20833333333333, 0.25, 0.33333333333333
14310, 0.20833333333333, 0.3, 0.33333333333333
14311, 0.20833333333333, 0.35, 0.33333333333333
14312, 0.20833333333333, 0.4, 0.33333333333333
14313, 0.20833333333333, 0.45, 0.33333333333333
14314, 0.20833333333333, 0.5, 0.33333333333333
14315, 0.20833333333333, 0.55, 0.33333333333333
14316, 0.20833333333333, 0.6, 0.33333333333333
14317, 0.20833333333333, 0.65, 0.33333333333333
14318, 0.20833333333333, 0.7, 0.33333333333333
14319, 0.20833333333333, 0.75, 0.33333333333333
14320, 0.20833333333333, 0.8, 0.33333333333333
14321, 0.20833333333333, 0.85, 0.33333333333333
