33107, 1003, 1004
33108, 1004, 1005
33109, 1005, 1006
33110, 1006, 1007
33111, 1007, 1008
33112, 1008, 1009
33113, 1009, 1010
33114, 1010, 1011
33115, 1011, 1012
33116, 1012, 1013
33117, 1013, 1014
33118, 1014, 1015
33119, 1015, 1016
33120, 1016, 1017
33121, 1017, 1018
33122, 1018, 1019
33123, 1019, 1020
33124, 1020, 1021
33125, 1021, 1022
33126, 1022, 1023
33127, 1023, 42
*ELEMENT, type=T3D2, ELSET=Line80
33128, 39, 43
*ELEMENT, type=T3D2, ELSET=Line81
33129, 40, 44
*ELEMENT, type=T3D2, ELSET=Line82
33130, 43, 1024
33131, 1024, 1025
33132, 1025, 1026
33133, 1026, 1027
33134, 1027, 1028
33135, 1028, 1029
33136, 1029, 1030
33137, 1030, 1031
33138, 1031, 1032
33139, 1032, 1033
33140, 1033, 1034
33141, 1034, 1035
33142, 1035, 1036
33143, 1036, 1037
33144, 1037, 1038
33145, 1038, 1039
33146, 1039, 1040
33147, 1040, 1041
33148, 1041, 1042
33149, 1042, 1043
33150, 1043, 1044
33151, 1044, 1045
33152, 1045, 1046
33153, 1046, 44
*ELEMENT, type=T3D2, ELSET=Line83
33154, 43, 1047
33155, 1047, 1048
33156, 1048, 1049
33157, 1049, 1050
33158, 1050, 1051
33159, 1051, 1052
33160, 1052, 1053
33161, 1053, 1054
33162, 1054, 1055
33163, 1055, 1056
33164, 1056, 1057
33165, 1057, 41
*ELEMENT, type=T3D2, ELSET=Line84
33166, 44, 1058
33167, 1058, 1059
33168, 1059, 1060
33169, 1060, 1061
33170, 1061, 1062
33171, 1062, 1063
33172, 1063, 1064
33173, 1064, 1065
33174, 1065, 1066
33175, 1066, 1067
33176, 1067, 1068
33177, 1068, 42
*ELEMENT, type=T3D2, ELSET=Line85
33178, 41, 1069
33179, 1069, 1070
33180, 1070, 45
*ELEMENT, type=T3D2, ELSET=Line86
33181, 42, 1071
33182, 1071, 1072
33183, 1072, 46
*ELEMENT, type=T3D2, ELSET=Line87
33184, 45, 1073
33185, 1073, 1074
33186, 1074, 1075
33187, 1075, 1076
33188, 1076, 1077
33189, 1077, 1078
33190, 1078, 1079
33191, 1079, 1080
33192, 1080, 1081
33193, 1081, 1082
33194, 1082, 1083
33195, 1083, 1084
33196, 1084, 1085
33197, 1085, 1086
33198, 1086, 1087
33199, 1087, 1088
33200, 1088, 1089
33201, 1089, 1090
33202, 1090, 1091
33203, 1091, 1092
33204, 1092, 1093
33205, 1093, 1094
33206, 1094, 1095
33207, 1095, 46
*ELEMENT, type=T3D2, ELSET=Line88
33208, 43, 1096
33209, 1096, 1097
33210, 1097, 47
*ELEMENT, type=T3D2, ELSET=Line89
33211, 44, 1098
33212, 1098, 1099
33213, 1099, 48
*ELEMENT, type=T3D2, ELSET=Line90
33214, 47, 1100
33215, 1100, 1101
33216, 1101, 1102
33217, 1102, 1103
33218, 1103, 1104
33219, 1104, 1105
33220, 1105, 1106
33221, 1106, 1107
33222, 1107, 1108
33223, 1108, 1109
33224, 1109, 1110
33225, 1110, 1111
33226, 1111, 1112
33227, 1112, 1113
33228, 1113, 1114
33229, 1114, 1115
33230, 1115, 1116
33231, 1116, 1117
33232, 1117, 1118
33233, 1118, 1119
33234, 1119, 1120
33235, 1120, 1121
33236, 1121, 1122
33237, 1122, 48
*ELEMENT, type=T3D2, ELSET=Line91
33238, 47, 1123
33239, 1123, 1124
33240, 1124, 1125
33241, 1125, 1126
33242, 1126, 1127
33243, 1127, 1128
33244, 1128, 1129
33245, 1129, 1130
33246, 1130, 1131
33247, 1131, 1132
33248, 1132, 1133
33249, 1133, 45
*ELEMENT, type=T3D2, ELSET=Line92
33250, 48, 1134
33251, 1134, 1135
33252, 1135, 1136
33253, 1136, 1137
33254, 1137, 1138
33255, 1138, 1139
33256, 1139, 1140
33257, 1140, 1141
33258, 1141, 1142
33259, 1142, 1143
33260, 1143, 1144
33261, 1144, 46
*ELEMENT, type=T3D2, ELSET=Line93
33262, 42, 49
*ELEMENT, type=T3D2, ELSET=Line94
33263, 46, 50
*ELEMENT, type=T3D2, ELSET=Line95
1, 49, 1145
2, 1145, 1146
3, 1146, 50
*ELEMENT, type=T3D2, ELSET=Line96
33264, 44, 51
*ELEMENT, type=T3D2, ELSET=Line97
33265, 48, 52
*ELEMENT, type=T3D2, ELSET=Line98
33266, 51, 1147
33267, 1147, 1148
33268, 1148, 52
*ELEMENT, type=T3D2, ELSET=Line99
33269, 51, 1149
33270, 1149, 1150
33271, 1150, 1151
33272, 1151, 1152
33273, 1152, 1153
33274, 1153, 1154
33275, 1154, 1155
33276, 1155, 1156
33277, 1156, 1157
33278, 1157, 1158
33279, 1158, 1159
33280, 1159, 49
*ELEMENT, type=T3D2, ELSET=Line100
33281, 52, 1160
33282, 1160, 1161
33283, 1161, 1162
33284, 1162, 1163
33285, 1163, 1164
33286, 1164, 1165
33287, 1165, 1166
33288, 1166, 1167
33289, 1167, 1168
33290, 1168, 1169
33291, 1169, 1170
33292, 1170, 50
*ELEMENT, type=T3D2, ELSET=Line101
33293, 1, 53
*ELEMENT, type=T3D2, ELSET=Line102
33294, 2, 54
*ELEMENT, type=T3D2, ELSET=Line103
33295, 54, 1171
33296, 1171, 1172
33297, 1172, 1173
33298, 1173, 1174
33299, 1174, 1175
33300, 1175, 1176
33301, 1176, 1177
33302, 1177, 1178
33303, 1178, 1179
33304, 1179, 1180
33305, 1180, 1181
33306, 1181, 53
*ELEMENT, type=T3D2, ELSET=Line104
33307, 3, 55
*ELEMENT, type=T3D2, ELSET=Line105
4, 53, 1182
5, 1182, 1183
6, 1183, 55
*ELEMENT, type=T3D2, ELSET=Line106
33308, 4, 56
*ELEMENT, type=T3D2, ELSET=Line107
33309, 56, 1184
33310, 1184, 1185
33311, 1185, 1186
33312, 1186, 1187
33313, 1187, 1188
33314, 1188, 1189
33315, 1189, 1190
33316, 1190, 1191
33317, 1191, 1192
33318, 1192, 1193
33319, 1193, 1194
33320, 1194, 55
*ELEMENT, type=T3D2, ELSET=Line108
33321, 54, 1195
33322, 1195, 1196
33323, 1196, 56
*ELEMENT, type=T3D2, ELSET=Line125
33324, 11, 57
*ELEMENT, type=T3D2, ELSET=Line126
33325, 15, 58
*ELEMENT, type=T3D2, ELSET=Line127
33326, 57, 1197
33327, 1197, 1198
33328, 1198, 1199
33329, 1199, 1200
33330, 1200, 1201
33331, 1201, 1202
33332, 1202, 1203
33333, 1203, 1204
33334, 1204, 1205
33335, 1205, 1206
33336, 1206, 1207
33337, 1207, 1208
33338, 1208, 1209
33339, 1209, 1210
33340, 1210, 1211
33341, 1211, 1212
33342, 1212, 1213
33343, 1213, 1214
33344, 1214, 1215
33345, 1215, 1216
33346, 1216, 1217
33347, 1217, 1218
33348, 1218, 1219
33349, 1219, 58
*ELEMENT, type=T3D2, ELSET=Line128
33350, 9, 59
*ELEMENT, type=T3D2, ELSET=Line129
33351, 13, 60
*ELEMENT, type=T3D2, ELSET=Line130
33352, 59, 1220
33353, 1220, 1221
33354, 1221, 1222
33355, 1222, 1223
33356, 1223, 1224
33357, 1224, 1225
33358, 1225, 1226
33359, 1226, 1227
33360, 1227, 1228
33361, 1228, 1229
33362, 1229, 1230
33363, 1230, 1231
33364, 1231, 1232
33365, 1232, 1233
33366, 1233, 1234
33367, 1234, 1235
33368, 1235, 1236
33369, 1236, 1237
33370, 1237, 1238
33371, 1238, 1239
33372, 1239, 1240
33373, 1240, 1241
33374, 1241, 1242
33375, 1242, 60
*ELEMENT, type=T3D2, ELSET=Line131
33376, 59, 1243
33377, 1243, 1244
33378, 1244, 1245
33379, 1245, 1246
33380, 1246, 1247
33381, 1247, 1248
33382, 1248, 1249
33383, 1249, 1250
33384, 1250, 1251
33385, 1251, 1252
33386, 1252, 1253
33387, 1253, 57
*ELEMENT, type=T3D2, ELSET=Line132
33388, 60, 1254
33389, 1254, 1255
33390, 1255, 1256
33391, 1256, 1257
33392, 1257, 1258
33393, 1258, 1259
33394, 1259, 1260
33395, 1260, 1261
33396, 1261, 1262
33397, 1262, 1263
33398, 1263, 1264
33399, 1264, 58
*ELEMENT, type=T3D2, ELSET=Line133
33400, 33, 61
*ELEMENT, type=T3D2, ELSET=Line134
33401, 37, 62
*ELEMENT, type=T3D2, ELSET=Line135
33402, 61, 1265
33403, 1265, 1266
33404, 1266, 1267
33405, 1267, 1268
33406, 1268, 1269
33407, 1269, 1270
33408, 1270, 1271
33409, 1271, 1272
33410, 1272, 1273
33411, 1273, 1274
33412, 1274, 1275
33413, 1275, 1276
33414, 1276, 1277
33415, 1277, 1278
33416, 1278, 1279
33417, 1279, 1280
33418, 1280, 1281
33419, 1281, 1282
33420, 1282, 1283
33421, 1283, 1284
33422, 1284, 1285
33423, 1285, 1286
33424, 1286, 1287
33425, 1287, 62
*ELEMENT, type=T3D2, ELSET=Line136
33426, 35, 63
*ELEMENT, type=T3D2, ELSET=Line137
33427, 39, 64
*ELEMENT, type=T3D2, ELSET=Line138
33428, 63, 1288
33429, 1288, 1289
33430, 1289, 1290
33431, 1290, 1291
33432, 1291, 1292
33433, 1292, 1293
33434, 1293, 1294
33435, 1294, 1295
33436, 1295, 1296
33437, 1296, 1297
33438, 1297, 1298
33439, 1298, 1299
33440, 1299, 1300
33441, 1300, 1301
33442, 1301, 1302
33443, 1302, 1303
33444, 1303, 1304
33445, 1304, 1305
33446, 1305, 1306
33447, 1306, 1307
33448, 1307, 1308
33449, 1308, 1309
33450, 1309, 1310
33451, 1310, 64
*ELEMENT, type=T3D2, ELSET=Line139
33452, 63, 1311
33453, 1311, 1312
33454, 1312, 1313
33455, 1313, 1314
33456, 1314, 1315
33457, 1315, 1316
33458, 1316, 1317
33459, 1317, 1318
33460, 1318, 1319
33461, 1319, 1320
33462, 1320, 1321
33463, 1321, 61
*ELEMENT, type=T3D2, ELSET=Line140
33464, 64, 1322
33465, 1322, 1323
33466, 1323, 1324
33467, 1324, 1325
33468, 1325, 1326
33469, 1326, 1327
33470, 1327, 1328
33471, 1328, 1329
33472, 1329, 1330
33473, 1330, 1331
33474, 1331, 1332
33475, 1332, 62
*ELEMENT, type=T3D2, ELSET=Line141
33476, 9, 65
*ELEMENT, type=T3D2, ELSET=Line142
33477, 13, 66
*ELEMENT, type=T3D2, ELSET=Line143
33478, 65, 1333
33479, 1333, 1334
33480, 1334, 1335
33481, 1335, 1336
33482, 1336, 1337
33483, 1337, 1338
33484, 1338, 1339
33485, 1339, 1340
33486, 1340, 1341
33487, 1341, 1342
33488, 1342, 1343
33489, 1343, 1344
33490, 1344, 1345
33491, 1345, 1346
33492, 1346, 1347
33493, 1347, 1348
33494, 1348, 1349
33495, 1349, 1350
33496, 1350, 1351
33497, 1351, 1352
33498, 1352, 1353
33499, 1353, 1354
33500, 1354, 1355
33501, 1355, 66
*ELEMENT, type=T3D2, ELSET=Line144
33502, 10, 67
*ELEMENT, type=T3D2, ELSET=Line145
33503, 14, 68
*ELEMENT, type=T3D2, ELSET=Line146
33504, 67, 1356
33505, 1356, 1357
33506, 1357, 1358
33507, 1358, 1359
33508, 1359, 1360
33509, 1360, 1361
33510, 1361, 1362
33511, 1362, 1363
33512, 1363, 1364
33513, 1364, 1365
33514, 1365, 1366
33515, 1366, 1367
33516, 1367, 1368
33517, 1368, 1369
33518, 1369, 1370
33519, 1370, 1371
33520, 1371, 1372
33521, 1372, 1373
33522, 1373, 1374
33523, 1374, 1375
33524, 1375, 1376
33525, 1376, 1377
33526, 1377, 1378
33527, 1378, 68
*ELEMENT, type=T3D2, ELSET=Line147
33528, 67, 1379
33529, 1379, 1380
33530, 1380, 1381
33531, 1381, 1382
33532, 1382, 1383
33533, 1383, 1384
33534, 1384, 1385
33535, 1385, 1386
33536, 1386, 1387
33537, 1387, 1388
33538, 1388, 1389
33539, 1389, 1390
33540, 1390, 1391
33541, 1391, 1392
33542, 1392, 1393
33543, 1393, 1394
33544, 1394, 1395
33545, 1395, 1396
33546, 1396, 1397
33547, 1397, 1398
33548, 1398, 1399
33549, 1399, 1400
33550, 1400, 1401
33551, 1401, 65
*ELEMENT, type=T3D2, ELSET=Line148
33552, 68, 1402
33553, 1402, 1403
33554, 1403, 1404
33555, 1404, 1405
33556, 1405, 1406
33557, 1406, 1407
33558, 1407, 1408
33559, 1408, 1409
33560, 1409, 1410
33561, 1410, 1411
33562, 1411, 1412
33563, 1412, 1413
33564, 1413, 1414
33565, 1414, 1415
33566, 1415, 1416
33567, 1416, 1417
33568, 1417, 1418
33569, 1418, 1419
33570, 1419, 1420
33571, 1420, 1421
33572, 1421, 1422
33573, 1422, 1423
33574, 1423, 1424
33575, 1424, 66
*ELEMENT, type=T3D2, ELSET=Line149
33576, 35, 69
*ELEMENT, type=T3D2, ELSET=Line150
33577, 39, 70
*ELEMENT, type=T3D2, ELSET=Line151
33578, 69, 1425
33579, 1425, 1426
33580, 1426, 1427
33581, 1427, 1428
33582, 1428, 1429
33583, 1429, 1430
33584, 1430, 1431
33585, 1431, 1432
33586, 1432, 1433
33587, 1433, 1434
33588, 1434, 1435
33589, 1435, 1436
33590, 1436, 1437
33591, 1437, 1438
33592, 1438, 1439
33593, 1439, 1440
33594, 1440, 1441
33595, 1441, 1442
33596, 1442, 1443
33597, 1443, 1444
33598, 1444, 1445
33599, 1445, 1446
33600, 1446, 1447
33601, 1447, 70
*ELEMENT, type=T3D2, ELSET=Line152
33602, 36, 71
*ELEMENT, type=T3D2, ELSET=Line153
33603, 40, 72
*ELEMENT, type=T3D2, ELSET=Line154
33604, 71, 1448
33605, 1448, 1449
33606, 1449, 1450
33607, 1450, 1451
33608, 1451, 1452
33609, 1452, 1453
33610, 1453, 1454
33611, 1454, 1455
33612, 1455, 1456
33613, 1456, 1457
33614, 1457, 1458
33615, 1458, 1459
33616, 1459, 1460
33617, 1460, 1461
33618, 1461, 1462
33619, 1462, 1463
33620, 1463, 1464
33621, 1464, 1465
33622, 1465, 1466
33623, 1466, 1467
33624, 1467, 1468
33625, 1468, 1469
33626, 1469, 1470
33627, 1470, 72
*ELEMENT, type=T3D2, ELSET=Line155
33628, 69, 1471
33629, 1471, 1472
33630, 1472, 1473
33631, 1473, 1474
33632, 1474, 1475
33633, 1475, 1476
33634, 1476, 1477
33635, 1477, 1478
33636, 1478, 1479
33637, 1479, 1480
33638, 1480, 1481
33639, 1481, 1482
33640, 1482, 1483
33641, 1483, 1484
33642, 1484, 1485
33643, 1485, 1486
33644, 1486, 1487
33645, 1487, 1488
33646, 1488, 1489
33647, 1489, 1490
33648, 1490, 1491
33649, 1491, 1492
33650, 1492, 1493
33651, 1493, 71
*ELEMENT, type=T3D2, ELSET=Line156
33652, 70, 1494
33653, 1494, 1495
33654, 1495, 1496
33655, 1496, 1497
33656, 1497, 1498
33657, 1498, 1499
33658, 1499, 1500
33659, 1500, 1501
33660, 1501, 1502
33661, 1502, 1503
33662, 1503, 1504
33663, 1504, 1505
33664, 1505, 1506
33665, 1506, 1507
33666, 1507, 1508
33667, 1508, 1509
33668, 1509, 1510
33669, 1510, 1511
33670, 1511, 1512
33671, 1512, 1513
33672, 1513, 1514
33673, 1514, 1515
33674, 1515, 1516
33675, 1516, 72
*ELEMENT, type=T3D2, ELSET=Line157
33676, 63, 73
*ELEMENT, type=T3D2, ELSET=Line158
33677, 69, 73
*ELEMENT, type=T3D2, ELSET=Line159
33678, 64, 74
*ELEMENT, type=T3D2, ELSET=Line160
33679, 70, 74
*ELEMENT, type=T3D2, ELSET=Line161
33680, 73, 1517
33681, 1517, 1518
33682, 1518, 1519
33683, 1519, 1520
33684, 1520, 1521
33685, 1521, 1522
33686, 1522, 1523
33687, 1523, 1524
33688, 1524, 1525
33689, 1525, 1526
33690, 1526, 1527
33691, 1527, 1528
33692, 1528, 1529
33693, 1529, 1530
33694, 1530, 1531
33695, 1531, 1532
33696, 1532, 1533
33697, 1533, 1534
33698, 1534, 1535
33699, 1535, 1536
33700, 1536, 1537
33701, 1537, 1538
33702, 1538, 1539
33703, 1539, 74
*ELEMENT, type=T3D2, ELSET=Line162
33704, 59, 75
*ELEMENT, type=T3D2, ELSET=Line163
33705, 65, 75
*ELEMENT, type=T3D2, ELSET=Line164
33706, 60, 76
*ELEMENT, type=T3D2, ELSET=Line165
33707, 66, 76
*ELEMENT, type=T3D2, ELSET=Line166
33708, 75, 1540
33709, 1540, 1541
33710, 1541, 1542
33711, 1542, 1543
33712, 1543, 1544
33713, 1544, 1545
33714, 1545, 1546
33715, 1546, 1547
33716, 1547, 1548
33717, 1548, 1549
33718, 1549, 1550
33719, 1550, 1551
33720, 1551, 1552
33721, 1552, 1553
33722, 1553, 1554
33723, 1554, 1555
33724, 1555, 1556
33725, 1556, 1557
33726, 1557, 1558
33727, 1558, 1559
33728, 1559, 1560
33729, 1560, 1561
33730, 1561, 1562
33731, 1562, 76
*ELEMENT, type=T3D2, ELSET=Line167
33732, 21, 1563
33733, 1563, 1564
33734, 1564, 1565
33735, 1565, 1566
33736, 1566, 77
*ELEMENT, type=T3D2, ELSET=Line168
33737, 22, 1567
33738, 1567, 1568
33739, 1568, 1569
33740, 1569, 1570
33741, 1570, 78
*ELEMENT, type=T3D2, ELSET=Line169
33742, 78, 1571
33743, 1571, 1572
33744, 1572, 1573
33745, 1573, 1574
33746, 1574, 1575
33747, 1575, 1576
33748, 1576, 1577
33749, 1577, 1578
33750, 1578, 1579
33751, 1579, 1580
33752, 1580, 1581
33753, 1581, 1582
33754, 1582, 1583
33755, 1583, 1584
33756, 1584, 1585
33757, 1585, 1586
33758, 1586, 1587
33759, 1587, 1588
33760, 1588, 1589
33761, 1589, 1590
33762, 1590, 1591
33763, 1591, 1592
33764, 1592, 1593
33765, 1593, 77
*ELEMENT, type=T3D2, ELSET=Line170
33766, 23, 1594
33767, 1594, 1595
33768, 1595, 1596
33769, 1596, 1597
33770, 1597, 79
*ELEMENT, type=T3D2, ELSET=Line171
33771, 77, 1598
33772, 1598, 1599
33773, 1599, 1600
33774, 1600, 1601
33775, 1601, 1602
33776, 1602, 1603
33777, 1603, 1604
33778, 1604, 1605
33779, 1605, 1606
33780, 1606, 1607
33781, 1607, 1608
33782, 1608, 79
*ELEMENT, type=T3D2, ELSET=Line172
33783, 24, 1609
33784, 1609, 1610
33785, 1610, 1611
33786, 1611, 1612
33787, 1612, 80
*ELEMENT, type=T3D2, ELSET=Line173
7, 80, 1613
8, 1613, 1614
9, 1614, 1615
10, 1615, 1616
11, 1616, 1617
12, 1617, 1618
13, 1618, 1619
14, 1619, 1620
15, 1620, 1621
16, 1621, 1622
17, 1622, 1623
18, 1623, 1624
19, 1624, 1625
20, 1625, 1626
21, 1626, 1627
22, 1627, 1628
23, 1628, 1629
24, 1629, 1630
25, 1630, 1631
26, 1631, 1632
27, 1632, 1633
28, 1633, 1634
29, 1634, 1635
30, 1635, 79
*ELEMENT, type=T3D2, ELSET=Line174
33788, 78, 1636
33789, 1636, 1637
33790, 1637, 1638
33791, 1638, 1639
33792, 1639, 1640
33793, 1640, 1641
33794, 1641, 1642
33795, 1642, 1643
33796, 1643, 1644
33797, 1644, 1645
33798, 1645, 1646
33799, 1646, 80
*ELEMENT, type=T3D2, ELSET=Line175
33800, 26, 1647
33801, 1647, 1648
33802, 1648, 1649
33803, 1649, 1650
33804, 1650, 81
*ELEMENT, type=T3D2, ELSET=Line176
31, 79, 1651
32, 1651, 1652
33, 1652, 1653
34, 1653, 1654
35, 1654, 81
*ELEMENT, type=T3D2, ELSET=Line177
33805, 28, 1655
33806, 1655, 1656
33807, 1656, 1657
33808, 1657, 1658
33809, 1658, 82
*ELEMENT, type=T3D2, ELSET=Line178
33810, 77, 1659
33811, 1659, 1660
33812, 1660, 1661
33813, 1661, 1662
33814, 1662, 82
*ELEMENT, type=T3D2, ELSET=Line179
33815, 82, 1663
33816, 1663, 1664
33817, 1664, 1665
33818, 1665, 1666
33819, 1666, 1667
33820, 1667, 1668
33821, 1668, 1669
33822, 1669, 1670
33823, 1670, 1671
33824, 1671, 1672
33825, 1672, 1673
33826, 1673, 81
*ELEMENT, type=T3D2, ELSET=Line180
33827, 30, 1674
33828, 1674, 1675
33829, 1675, 1676
33830, 1676, 1677
33831, 1677, 83
*ELEMENT, type=T3D2, ELSET=Line181
36, 81, 1678
37, 1678, 1679
38, 1679, 1680
39, 1680, 1681
40, 1681, 1682
41, 1682, 1683
42, 1683, 1684
43, 1684, 1685
44, 1685, 1686
45, 1686, 1687
46, 1687, 1688
47, 1688, 1689
48, 1689, 1690
49, 1690, 1691
50, 1691, 1692
51, 1692, 1693
52, 1693, 1694
53, 1694, 1695
54, 1695, 1696
55, 1696, 1697
56, 1697, 1698
57, 1698, 1699
58, 1699, 1700
59, 1700, 83
*ELEMENT, type=T3D2, ELSET=Line182
33832, 32, 1701
33833, 1701, 1702
33834, 1702, 1703
33835, 1703, 1704
33836, 1704, 84
*ELEMENT, type=T3D2, ELSET=Line183
33837, 82, 1705
33838, 1705, 1706
33839, 1706, 1707
33840, 1707, 1708
33841, 1708, 1709
33842, 1709, 1710
33843, 1710, 1711
33844, 1711, 1712
33845, 1712, 1713
33846, 1713, 1714
33847, 1714, 1715
33848, 1715, 1716
33849, 1716, 1717
33850, 1717, 1718
33851, 1718, 1719
33852, 1719, 1720
33853, 1720, 1721
33854, 1721, 1722
33855, 1722, 1723
33856, 1723, 1724
33857, 1724, 1725
33858, 1725, 1726
33859, 1726, 1727
33860, 1727, 84
*ELEMENT, type=T3D2, ELSET=Line184
33861, 84, 1728
33862, 1728, 1729
33863, 1729, 1730
33864, 1730, 1731
33865, 1731, 1732
33866, 1732, 1733
33867, 1733, 1734
33868, 1734, 1735
33869, 1735, 1736
33870, 1736, 1737
33871, 1737, 1738
33872, 1738, 83
*ELEMENT, type=T3D2, ELSET=Line185
33873, 6, 1739
33874, 1739, 1740
33875, 1740, 1741
33876, 1741, 1742
33877, 1742, 85
*ELEMENT, type=T3D2, ELSET=Line186
33878, 2, 1743
33879, 1743, 1744
33880, 1744, 1745
33881, 1745, 1746
33882, 1746, 86
*ELEMENT, type=T3D2, ELSET=Line187
33883, 86, 1747
33884, 1747, 1748
33885, 1748, 1749
33886, 1749, 1750
33887, 1750, 1751
33888, 1751, 1752
33889, 1752, 1753
33890, 1753, 1754
33891, 1754, 1755
33892, 1755, 1756
33893, 1756, 1757
33894, 1757, 1758
33895, 1758, 1759
33896, 1759, 1760
33897, 1760, 1761
33898, 1761, 1762
33899, 1762, 1763
33900, 1763, 1764
33901, 1764, 1765
33902, 1765, 1766
33903, 1766, 1767
33904, 1767, 1768
33905, 1768, 1769
33906, 1769, 85
*ELEMENT, type=T3D2, ELSET=Line188
33907, 5, 1770
33908, 1770, 1771
33909, 1771, 1772
33910, 1772, 1773
33911, 1773, 87
*ELEMENT, type=T3D2, ELSET=Line189
33912, 85, 1774
33913, 1774, 1775
33914, 1775, 1776
33915, 1776, 1777
33916, 1777, 1778
33917, 1778, 1779
33918, 1779, 1780
33919, 1780, 1781
33920, 1781, 1782
33921, 1782, 1783
33922, 1783, 1784
33923, 1784, 87
*ELEMENT, type=T3D2, ELSET=Line190
33924, 1, 1785
33925, 1785, 1786
33926, 1786, 1787
33927, 1787, 1788
33928, 1788, 88
*ELEMENT, type=T3D2, ELSET=Line191
60, 88, 1789
61, 1789, 1790
62, 1790, 1791
63, 1791, 1792
64, 1792, 1793
65, 1793, 1794
66, 1794, 1795
67, 1795, 1796
68, 1796, 1797
69, 1797, 1798
70, 1798, 1799
71, 1799, 1800
72, 1800, 1801
73, 1801, 1802
74, 1802, 1803
75, 1803, 1804
76, 1804, 1805
77, 1805, 1806
78, 1806, 1807
79, 1807, 1808
80, 1808, 1809
81, 1809, 1810
82, 1810, 1811
83, 1811, 87
*ELEMENT, type=T3D2, ELSET=Line192
33929, 86, 1812
33930, 1812, 1813
33931, 1813, 1814
33932, 1814, 1815
33933, 1815, 1816
33934, 1816, 1817
33935, 1817, 1818
33936, 1818, 1819
33937, 1819, 1820
33938, 1820, 1821
33939, 1821, 1822
33940, 1822, 88
*ELEMENT, type=T3D2, ELSET=Line193
33941, 53, 1823
33942, 1823, 1824
33943, 1824, 1825
33944, 1825, 1826
33945, 1826, 89
*ELEMENT, type=T3D2, ELSET=Line194
84, 88, 89
*ELEMENT, type=T3D2, ELSET=Line195
33946, 54, 1827
33947, 1827, 1828
33948, 1828, 1829
33949, 1829, 1830
33950, 1830, 90
*ELEMENT, type=T3D2, ELSET=Line196
33951, 86, 90
*ELEMENT, type=T3D2, ELSET=Line197
33952, 90, 1831
33953, 1831, 1832
33954, 1832, 1833
33955, 1833, 1834
33956, 1834, 1835
33957, 1835, 1836
33958, 1836, 1837
33959, 1837, 1838
33960, 1838, 1839
33961, 1839, 1840
33962, 1840, 1841
33963, 1841, 89
*ELEMENT, type=T3D2, ELSET=Line198
33964, 45, 1842
33965, 1842, 1843
33966, 1843, 1844
33967, 1844, 1845
33968, 1845, 91
*ELEMENT, type=T3D2, ELSET=Line199
33969, 46, 1846
33970, 1846, 1847
33971, 1847, 1848
33972, 1848, 1849
33973, 1849, 92
*ELEMENT, type=T3D2, ELSET=Line200
85, 91, 1850
86, 1850, 1851
87, 1851, 1852
88, 1852, 1853
89, 1853, 1854
90, 1854, 1855
91, 1855, 1856
92, 1856, 1857
93, 1857, 1858
94, 1858, 1859
95, 1859, 1860
96, 1860, 1861
97, 1861, 1862
98, 1862, 1863
99, 1863, 1864
100, 1864, 1865
101, 1865, 1866
102, 1866, 1867
103, 1867, 1868
104, 1868, 1869
105, 1869, 1870
106, 1870, 1871
107, 1871, 1872
108, 1872, 92
*ELEMENT, type=T3D2, ELSET=Line201
33974, 47, 1873
33975, 1873, 1874
33976, 1874, 1875
33977, 1875, 1876
33978, 1876, 93
*ELEMENT, type=T3D2, ELSET=Line202
33979, 48, 1877
33980, 1877, 1878
33981, 1878, 1879
33982, 1879, 1880
33983, 1880, 94
*ELEMENT, type=T3D2, ELSET=Line203
33984, 93, 1881
33985, 1881, 1882
33986, 1882, 1883
33987, 1883, 1884
33988, 1884, 1885
33989, 1885, 1886
33990, 1886, 1887
33991, 1887, 1888
33992, 1888, 1889
33993, 1889, 1890
33994, 1890, 1891
33995, 1891, 1892
33996, 1892, 1893
33997, 1893, 1894
33998, 1894, 1895
33999, 1895, 1896
34000, 1896, 1897
34001, 1897, 1898
34002, 1898, 1899
34003, 1899, 1900
34004, 1900, 1901
34005, 1901, 1902
34006, 1902, 1903
34007, 1903, 94
*ELEMENT, type=T3D2, ELSET=Line204
34008, 93, 1904
34009, 1904, 1905
34010, 1905, 1906
34011, 1906, 1907
34012, 1907, 1908
34013, 1908, 1909
34014, 1909, 1910
34015, 1910, 1911
34016, 1911, 1912
34017, 1912, 1913
34018, 1913, 1914
34019, 1914, 91
*ELEMENT, type=T3D2, ELSET=Line205
34020, 94, 1915
34021, 1915, 1916
34022, 1916, 1917
34023, 1917, 1918
34024, 1918, 1919
34025, 1919, 1920
34026, 1920, 1921
34027, 1921, 1922
34028, 1922, 1923
34029, 1923, 1924
34030, 1924, 1925
34031, 1925, 92
*ELEMENT, type=T3D2, ELSET=Line206
34032, 50, 1926
34033, 1926, 1927
34034, 1927, 1928
34035, 1928, 1929
34036, 1929, 95
*ELEMENT, type=T3D2, ELSET=Line207
109, 92, 95
*ELEMENT, type=T3D2, ELSET=Line208
34037, 52, 1930
34038, 1930, 1931
34039, 1931, 1932
34040, 1932, 1933
34041, 1933, 96
*ELEMENT, type=T3D2, ELSET=Line209
34042, 94, 96
*ELEMENT, type=T3D2, ELSET=Line210
34043, 96, 1934
34044, 1934, 1935
34045, 1935, 1936
34046, 1936, 1937
34047, 1937, 1938
34048, 1938, 1939
34049, 1939, 1940
34050, 1940, 1941
34051, 1941, 1942
34052, 1942, 1943
34053, 1943, 1944
34054, 1944, 95
*ELEMENT, type=CPS4, ELSET=Surface1
34055, 2, 97, 1945, 121
34056, 121, 1945, 1946, 122
34057, 122, 1946, 110, 4
34058, 97, 98, 1947, 1945
34059, 1945, 1947, 1948, 1946
34060, 1946, 1948, 111, 110
34061, 98, 99, 1949, 1947
34062, 1947, 1949, 1950, 1948
34063, 1948, 1950, 112, 111
34064, 99, 100, 1951, 1949
34065, 1949, 1951, 1952, 1950
34066, 1950, 1952, 113, 112
34067, 100, 101, 1953, 1951
34068, 1951, 1953, 1954, 1952
34069, 1952, 1954, 114, 113
34070, 101, 102, 1955, 1953
34071, 1953, 1955, 1956, 1954
34072, 1954, 1956, 115, 114
34073, 102, 103, 1957, 1955
34074, 1955, 1957, 1958, 1956
34075, 1956, 1958, 116, 115
34076, 103, 104, 1959, 1957
34077, 1957, 1959, 1960, 1958
34078, 1958, 1960, 117, 116
34079, 104, 105, 1961, 1959
34080, 1959, 1961, 1962, 1960
34081, 1960, 1962, 118, 117
34082, 105, 106, 1963, 1961
34083, 1961, 1963, 1964, 1962
34084, 1962, 1964, 119, 118
34085, 106, 107, 1965, 1963
34086, 1963, 1965, 1966, 1964
34087, 1964, 1966, 120, 119
34088, 107, 1, 108, 1965
34089, 1965, 108, 109, 1966
34090, 1966, 109, 3, 120
*ELEMENT, type=CPS4, ELSET=Surface2
34091, 6, 147, 1967, 123
34092, 147, 148, 1968, 1967
34093, 148, 8, 136, 1968
34094, 123, 1967, 1969, 124
34095, 1967, 1968, 1970, 1969
34096, 1968, 136, 137, 1970
34097, 124, 1969, 1971, 125
34098, 1969, 1970, 1972, 1971
34099, 1970, 137, 138, 1972
34100, 125, 1971, 1973, 126
34101, 1971, 1972, 1974, 1973
34102, 1972, 138, 139, 1974
34103, 126, 1973, 1975, 127
34104, 1973, 1974, 1976, 1975
34105, 1974, 139, 140, 1976
34106, 127, 1975, 1977, 128
34107, 1975, 1976, 1978, 1977
34108, 1976, 140, 141, 1978
34109, 128, 1977, 1979, 129
34110, 1977, 1978, 1980, 1979
34111, 1978, 141, 142, 1980
34112, 129, 1979, 1981, 130
34113, 1979, 1980, 1982, 1981
34114, 1980, 142, 143, 1982
34115, 130, 1981, 1983, 131
34116, 1981, 1982, 1984, 1983
34117, 1982, 143, 144, 1984
34118, 131, 1983, 1985, 132
34119, 1983, 1984, 1986, 1985
34120, 1984, 144, 145, 1986
34121, 132, 1985, 1987, 133
34122, 1985, 1986, 1988, 1987
34123, 1986, 145, 146, 1988
34124, 133, 1987, 134, 5
34125, 1987, 1988, 135, 134
34126, 1988, 146, 7, 135
*ELEMENT, type=CPS4, ELSET=Surface3
110, 2, 149, 1989, 97
111, 97, 1989, 1990, 98
112, 98, 1990, 1991, 99
113, 99, 1991, 1992, 100
114, 100, 1992, 1993, 101
115, 101, 1993, 1994, 102
116, 102, 1994, 1995, 103
117, 103, 1995, 1996, 104
118, 104, 1996, 1997, 105
119, 105, 1997, 1998, 106
120, 106, 1998, 1999, 107
121, 107, 1999, 172, 1
122, 149, 150, 2000, 1989
123, 1989, 2000, 2001, 1990
124, 1990, 2001, 2002, 1991
125, 1991, 2002, 2003, 1992
126, 1992, 2003, 2004, 1993
127, 1993, 2004, 2005, 1994
128, 1994, 2005, 2006, 1995
129, 1995, 2006, 2007, 1996
130, 1996, 2007, 2008, 1997
131, 1997, 2008, 2009, 1998
132, 1998, 2009, 2010, 1999
133, 1999, 2010, 173, 172
134, 150, 151, 2011, 2000
135, 2000, 2011, 2012, 2001
136, 2001, 2012, 2013, 2002
137, 2002, 2013, 2014, 2003
138, 2003, 2014, 2015, 2004
139, 2004, 2015, 2016, 2005
140, 2005, 2016, 2017, 2006
141, 2006, 2017, 2018, 2007
142, 2007, 2018, 2019, 2008
143, 2008, 2019, 2020, 2009
144, 2009, 2020, 2021, 2010
145, 2010, 2021, 174, 173
146, 151, 152, 2022, 2011
147, 2011, 2022, 2023, 2012
148, 2012, 2023, 2024, 2013
149, 2013, 2024, 2025, 2014
150, 2014, 2025, 2026, 2015
151, 2015, 2026, 2027, 2016
152, 2016, 2027, 2028, 2017
153, 2017, 2028, 2029, 2018
154, 2018, 2029, 2030, 2019
155, 2019, 2030, 2031, 2020
156, 2020, 2031, 2032, 2021
157, 2021, 2032, 175, 174
158, 152, 153, 2033, 2022
159, 2022, 2033, 2034, 2023
160, 2023, 2034, 2035, 2024
161, 2024, 2035, 2036, 2025
162, 2025, 2036, 2037, 2026
163, 2026, 2037, 2038, 2027
164, 2027, 2038, 2039, 2028
165, 2028, 2039, 2040, 2029
166, 2029, 2040, 2041, 2030
167, 2030, 2041, 2042, 2031
168, 2031, 2042, 2043, 2032
169, 2032, 2043, 176, 175
170, 153, 154, 2044, 2033
171, 2033, 2044, 2045, 2034
172, 2034, 2045, 2046, 2035
173, 2035, 2046, 2047, 2036
174, 2036, 2047, 2048, 2037
175, 2037, 2048, 2049, 2038
176, 2038, 2049, 2050, 2039
177, 2039, 2050, 2051, 2040
178, 2040, 2051, 2052, 2041
179, 2041, 2052, 2053, 2042
180, 2042, 2053, 2054, 2043
181, 2043, 2054, 177, 176
182, 154, 155, 2055, 2044
183, 2044, 2055, 2056, 2045
184, 2045, 2056, 2057, 2046
185, 2046, 2057, 2058, 2047
186, 2047, 2058, 2059, 2048
187, 2048, 2059, 2060, 2049
188, 2049, 2060, 2061, 2050
189, 2050, 2061, 2062, 2051
190, 2051, 2062, 2063, 2052
191, 2052, 2063, 2064, 2053
192, 2053, 2064, 2065, 2054
193, 2054, 2065, 178, 177
194, 155, 156, 2066, 2055
195, 2055, 2066, 2067, 2056
196, 2056, 2067, 2068, 2057
197, 2057, 2068, 2069, 2058
198, 2058, 2069, 2070, 2059
199, 2059, 2070, 2071, 2060
200, 2060, 2071, 2072, 2061
201, 2061, 2072, 2073, 2062
202, 2062, 2073, 2074, 2063
203, 2063, 2074, 2075, 2064
204, 2064, 2075, 2076, 2065
205, 2065, 2076, 179, 178
206, 156, 157, 2077, 2066
207, 2066, 2077, 2078, 2067
208, 2067, 2078, 2079, 2068
209, 2068, 2079, 2080, 2069
210, 2069, 2080, 2081, 2070
211, 2070, 2081, 2082, 2071
212, 2071, 2082, 2083, 2072
213, 2072, 2083, 2084, 2073
214, 2073, 2084, 2085, 2074
215, 2074, 2085, 2086, 2075
216, 2075, 2086, 2087, 2076
217, 2076, 2087, 180, 179
218, 157, 158, 2088, 2077
219, 2077, 2088, 2089, 2078
220, 2078, 2089, 2090, 2079
221, 2079, 2090, 2091, 2080
222, 2080, 2091, 2092, 2081
223, 2081, 2092, 2093, 2082
224, 2082, 2093, 2094, 2083
225, 2083, 2094, 2095, 2084
226, 2084, 2095, 2096, 2085
227, 2085, 2096, 2097, 2086
228, 2086, 2097, 2098, 2087
229, 2087, 2098, 181, 180
230, 158, 159, 2099, 2088
231, 2088, 2099, 2100, 2089
232, 2089, 2100, 2101, 2090
233, 2090, 2101, 2102, 2091
234, 2091, 2102, 2103, 2092
235, 2092, 2103, 2104, 2093
236, 2093, 2104, 2105, 2094
237, 2094, 2105, 2106, 2095
238, 2095, 2106, 2107, 2096
239, 2096, 2107, 2108, 2097
240, 2097, 2108, 2109, 2098
241, 2098, 2109, 182, 181
242, 159, 160, 2110, 2099
243, 2099, 2110, 2111, 2100
244, 2100, 2111, 2112, 2101
245, 2101, 2112, 2113, 2102
246, 2102, 2113, 2114, 2103
247, 2103, 2114, 2115, 2104
248, 2104, 2115, 2116, 2105
249, 2105, 2116, 2117, 2106
250, 2106, 2117, 2118, 2107
251, 2107, 2118, 2119, 2108
252, 2108, 2119, 2120, 2109
253, 2109, 2120, 183, 182
254, 160, 161, 2121, 2110
255, 2110, 2121, 2122, 2111
256, 2111, 2122, 2123, 2112
257, 2112, 2123, 2124, 2113
258, 2113, 2124, 2125, 2114
259, 2114, 2125, 2126, 2115
260, 2115, 2126, 2127, 2116
261, 2116, 2127, 2128, 2117
262, 2117, 2128, 2129, 2118
263, 2118, 2129, 2130, 2119
264, 2119, 2130, 2131, 2120
265, 2120, 2131, 184, 183
266, 161, 162, 2132, 2121
267, 2121, 2132, 2133, 2122
268, 2122, 2133, 2134, 2123
269, 2123, 2134, 2135, 2124
270, 2124, 2135, 2136, 2125
271, 2125, 2136, 2137, 2126
272, 2126, 2137, 2138, 2127
273, 2127, 2138, 2139, 2128
274, 2128, 2139, 2140, 2129
275, 2129, 2140, 2141, 2130
276, 2130, 2141, 2142, 2131
277, 2131, 2142, 185, 184
278, 162, 163, 2143, 2132
279, 2132, 2143, 2144, 2133
280, 2133, 2144, 2145, 2134
281, 2134, 2145, 2146, 2135
282, 2135, 2146, 2147, 2136
283, 2136, 2147, 2148, 2137
284, 2137, 2148, 2149, 2138
285, 2138, 2149, 2150, 2139
286, 2139, 2150, 2151, 2140
287, 2140, 2151, 2152, 2141
288, 2141, 2152, 2153, 2142
289, 2142, 2153, 186, 185
290, 163, 164, 2154, 2143
291, 2143, 2154, 2155, 2144
292, 2144, 2155, 2156, 2145
293, 2145, 2156, 2157, 2146
294, 2146, 2157, 2158, 2147
295, 2147, 2158, 2159, 2148
296, 2148, 2159, 2160, 2149
297, 2149, 2160, 2161, 2150
298, 2150, 2161, 2162, 2151
299, 2151, 2162, 2163, 2152
300, 2152, 2163, 2164, 2153
301, 2153, 2164, 187, 186
302, 164, 165, 2165, 2154
303, 2154, 2165, 2166, 2155
304, 2155, 2166, 2167, 2156
305, 2156, 2167, 2168, 2157
306, 2157, 2168, 2169, 2158
307, 2158, 2169, 2170, 2159
308, 2159, 2170, 2171, 2160
309, 2160, 2171, 2172, 2161
310, 2161, 2172, 2173, 2162
311, 2162, 2173, 2174, 2163
312, 2163, 2174, 2175, 2164
313, 2164, 2175, 188, 187
314, 165, 166, 2176, 2165
315, 2165, 2176, 2177, 2166
316, 2166, 2177, 2178, 2167
317, 2167, 2178, 2179, 2168
318, 2168, 2179, 2180, 2169
319, 2169, 2180, 2181, 2170
320, 2170, 2181, 2182, 2171
321, 2171, 2182, 2183, 2172
322, 2172, 2183, 2184, 2173
323, 2173, 2184, 2185, 2174
324, 2174, 2185, 2186, 2175
325, 2175, 2186, 189, 188
326, 166, 167, 2187, 2176
327, 2176, 2187, 2188, 2177
328, 2177, 2188, 2189, 2178
329, 2178, 2189, 2190, 2179
330, 2179, 2190, 2191, 2180
331, 2180, 2191, 2192, 2181
332, 2181, 2192, 2193, 2182
333, 2182, 2193, 2194, 2183
334, 2183, 2194, 2195, 2184
335, 2184, 2195, 2196, 2185
336, 2185, 2196, 2197, 2186
337, 2186, 2197, 190, 189
338, 167, 168, 2198, 2187
339, 2187, 2198, 2199, 2188
340, 2188, 2199, 2200, 2189
341, 2189, 2200, 2201, 2190
342, 2190, 2201, 2202, 2191
343, 2191, 2202, 2203, 2192
344, 2192, 2203, 2204, 2193
345, 2193, 2204, 2205, 2194
346, 2194, 2205, 2206, 2195
347, 2195, 2206, 2207, 2196
348, 2196, 2207, 2208, 2197
349, 2197, 2208, 191, 190
350, 168, 169, 2209, 2198
351, 2198, 2209, 2210, 2199
352, 2199, 2210, 2211, 2200
353, 2200, 2211, 2212, 2201
354, 2201, 2212, 2213, 2202
355, 2202, 2213, 2214, 2203
356, 2203, 2214, 2215, 2204
357, 2204, 2215, 2216, 2205
358, 2205, 2216, 2217, 2206
359, 2206, 2217, 2218, 2207
360, 2207, 2218, 2219, 2208
361, 2208, 2219, 192, 191
362, 169, 170, 2220, 2209
363, 2209, 2220, 2221, 2210
364, 2210, 2221, 2222, 2211
365, 2211, 2222, 2223, 2212
366, 2212, 2223, 2224, 2213
367, 2213, 2224, 2225, 2214
368, 2214, 2225, 2226, 2215
369, 2215, 2226, 2227, 2216
370, 2216, 2227, 2228, 2217
371, 2217, 2228, 2229, 2218
372, 2218, 2229, 2230, 2219
373, 2219, 2230, 193, 192
374, 170, 171, 2231, 2220
375, 2220, 2231, 2232, 2221
376, 2221, 2232, 2233, 2222
377, 2222, 2233, 2234, 2223
378, 2223, 2234, 2235, 2224
379, 2224, 2235, 2236, 2225
380, 2225, 2236, 2237, 2226
381, 2226, 2237, 2238, 2227
382, 2227, 2238, 2239, 2228
383, 2228, 2239, 2240, 2229
384, 2229, 2240, 2241, 2230
385, 2230, 2241, 194, 193
386, 171, 6, 123, 2231
387, 2231, 123, 124, 2232
388, 2232, 124, 125, 2233
389, 2233, 125, 126, 2234
390, 2234, 126, 127, 2235
391, 2235, 127, 128, 2236
392, 2236, 128, 129, 2237
393, 2237, 129, 130, 2238
394, 2238, 130, 131, 2239
395, 2239, 131, 132, 2240
396, 2240, 132, 133, 2241
397, 2241, 133, 5, 194
*ELEMENT, type=CPS4, ELSET=Surface4
34127, 4, 110, 2242, 195
34128, 110, 111, 2243, 2242
34129, 111, 112, 2244, 2243
34130, 112, 113, 2245, 2244
34131, 113, 114, 2246, 2245
34132, 114, 115, 2247, 2246
34133, 115, 116, 2248, 2247
34134, 116, 117, 2249, 2248
34135, 117, 118, 2250, 2249
34136, 118, 119, 2251, 2250
34137, 119, 120, 2252, 2251
34138, 120, 3, 218, 2252
34139, 195, 2242, 2253, 196
34140, 2242, 2243, 2254, 2253
34141, 2243, 2244, 2255, 2254
34142, 2244, 2245, 2256, 2255
34143, 2245, 2246, 2257, 2256
34144, 2246, 2247, 2258, 2257
34145, 2247, 2248, 2259, 2258
34146, 2248, 2249, 2260, 2259
34147, 2249, 2250, 2261, 2260
34148, 2250, 2251, 2262, 2261
34149, 2251, 2252, 2263, 2262
34150, 2252, 218, 219, 2263
34151, 196, 2253, 2264, 197
34152, 2253, 2254, 2265, 2264
34153, 2254, 2255, 2266, 2265
34154, 2255, 2256, 2267, 2266
34155, 2256, 2257, 2268, 2267
34156, 2257, 2258, 2269, 2268
34157, 2258, 2259, 2270, 2269
34158, 2259, 2260, 2271, 2270
34159, 2260, 2261, 2272, 2271
34160, 2261, 2262, 2273, 2272
34161, 2262, 2263, 2274, 2273
34162, 2263, 219, 220, 2274
34163, 197, 2264, 2275, 198
34164, 2264, 2265, 2276, 2275
34165, 2265, 2266, 2277, 2276
34166, 2266, 2267, 2278, 2277
34167, 2267, 2268, 2279, 2278
34168, 2268, 2269, 2280, 2279
34169, 2269, 2270, 2281, 2280
34170, 2270, 2271, 2282, 2281
34171, 2271, 2272, 2283, 2282
34172, 2272, 2273, 2284, 2283
34173, 2273, 2274, 2285, 2284
34174, 2274, 220, 221, 2285
34175, 198, 2275, 2286, 199
34176, 2275, 2276, 2287, 2286
34177, 2276, 2277, 2288, 2287
34178, 2277, 2278, 2289, 2288
34179, 2278, 2279, 2290, 2289
34180, 2279, 2280, 2291, 2290
34181, 2280, 2281, 2292, 2291
34182, 2281, 2282, 2293, 2292
34183, 2282, 2283, 2294, 2293
34184, 2283, 2284, 2295, 2294
34185, 2284, 2285, 2296, 2295
34186, 2285, 221, 222, 2296
34187, 199, 2286, 2297, 200
34188, 2286, 2287, 2298, 2297
34189, 2287, 2288, 2299, 2298
34190, 2288, 2289, 2300, 2299
34191, 2289, 2290, 2301, 2300
34192, 2290, 2291, 2302, 2301
34193, 2291, 2292, 2303, 2302
34194, 2292, 2293, 2304, 2303
34195, 2293, 2294, 2305, 2304
34196, 2294, 2295, 2306, 2305
34197, 2295, 2296, 2307, 2306
34198, 2296, 222, 223, 2307
34199, 200, 2297, 2308, 201
34200, 2297, 2298, 2309, 2308
34201, 2298, 2299, 2310, 2309
34202, 2299, 2300, 2311, 2310
34203, 2300, 2301, 2312, 2311
34204, 2301, 2302, 2313, 2312
34205, 2302, 2303, 2314, 2313
34206, 2303, 2304, 2315, 2314
34207, 2304, 2305, 2316, 2315
34208, 2305, 2306, 2317, 2316
34209, 2306, 2307, 2318, 2317
34210, 2307, 223, 224, 2318
34211, 201, 2308, 2319, 202
34212, 2308, 2309, 2320, 2319
34213, 2309, 2310, 2321, 2320
34214, 2310, 2311, 2322, 2321
34215, 2311, 2312, 2323, 2322
34216, 2312, 2313, 2324, 2323
34217, 2313, 2314, 2325, 2324
34218, 2314, 2315, 2326, 2325
34219, 2315, 2316, 2327, 2326
34220, 2316, 2317, 2328, 2327
34221, 2317, 2318, 2329, 2328
34222, 2318, 224, 225, 2329
34223, 202, 2319, 2330, 203
34224, 2319, 2320, 2331, 2330
34225, 2320, 2321, 2332, 2331
34226, 2321, 2322, 2333, 2332
34227, 2322, 2323, 2334, 2333
34228, 2323, 2324, 2335, 2334
34229, 2324, 2325, 2336, 2335
34230, 2325, 2326, 2337, 2336
34231, 2326, 2327, 2338, 2337
34232, 2327, 2328, 2339, 2338
34233, 2328, 2329, 2340, 2339
34234, 2329, 225, 226, 2340
34235, 203, 2330, 2341, 204
34236, 2330, 2331, 2342, 2341
34237, 2331, 2332, 2343, 2342
34238, 2332, 2333, 2344, 2343
34239, 2333, 2334, 2345, 2344
34240, 2334, 2335, 2346, 2345
34241, 2335, 2336, 2347, 2346
34242, 2336, 2337, 2348, 2347
34243, 2337, 2338, 2349, 2348
34244, 2338, 2339, 2350, 2349
34245, 2339, 2340, 2351, 2350
34246, 2340, 226, 227, 2351
34247, 204, 2341, 2352, 205
34248, 2341, 2342, 2353, 2352
34249, 2342, 2343, 2354, 2353
34250, 2343, 2344, 2355, 2354
34251, 2344, 2345, 2356, 2355
34252, 2345, 2346, 2357, 2356
34253, 2346, 2347, 2358, 2357
34254, 2347, 2348, 2359, 2358
34255, 2348, 2349, 2360, 2359
34256, 2349, 2350, 2361, 2360
34257, 2350, 2351, 2362, 2361
34258, 2351, 227, 228, 2362
34259, 205, 2352, 2363, 206
34260, 2352, 2353, 2364, 2363
34261, 2353, 2354, 2365, 2364
34262, 2354, 2355, 2366, 2365
34263, 2355, 2356, 2367, 2366
34264, 2356, 2357, 2368, 2367
34265, 2357, 2358, 2369, 2368
34266, 2358, 2359, 2370, 2369
34267, 2359, 2360, 2371, 2370
34268, 2360, 2361, 2372, 2371
34269, 2361, 2362, 2373, 2372
34270, 2362, 228, 229, 2373
34271, 206, 2363, 2374, 207
34272, 2363, 2364, 2375, 2374
34273, 2364, 2365, 2376, 2375
34274, 2365, 2366, 2377, 2376
34275, 2366, 2367, 2378, 2377
34276, 2367, 2368, 2379, 2378
34277, 2368, 2369, 2380, 2379
34278, 2369, 2370, 2381, 2380
34279, 2370, 2371, 2382, 2381
34280, 2371, 2372, 2383, 2382
34281, 2372, 2373, 2384, 2383
34282, 2373, 229, 230, 2384
34283, 207, 2374, 2385, 208
34284, 2374, 2375, 2386, 2385
34285, 2375, 2376, 2387, 2386
34286, 2376, 2377, 2388, 2387
34287, 2377, 2378, 2389, 2388
34288, 2378, 2379, 2390, 2389
34289, 2379, 2380, 2391, 2390
34290, 2380, 2381, 2392, 2391
34291, 2381, 2382, 2393, 2392
34292, 2382, 2383, 2394, 2393
34293, 2383, 2384, 2395, 2394
34294, 2384, 230, 231, 2395
34295, 208, 2385, 2396, 209
34296, 2385, 2386, 2397, 2396
34297, 2386, 2387, 2398, 2397
34298, 2387, 2388, 2399, 2398
34299, 2388, 2389, 2400, 2399
34300, 2389, 2390, 2401, 2400
34301, 2390, 2391, 2402, 2401
34302, 2391, 2392, 2403, 2402
34303, 2392, 2393, 2404, 2403
34304, 2393, 2394, 2405, 2404
34305, 2394, 2395, 2406, 2405
34306, 2395, 231, 232, 2406
34307, 209, 2396, 2407, 210
34308, 2396, 2397, 2408, 2407
34309, 2397, 2398, 2409, 2408
34310, 2398, 2399, 2410, 2409
34311, 2399, 2400, 2411, 2410
34312, 2400, 2401, 2412, 2411
34313, 2401, 2402, 2413, 2412
34314, 2402, 2403, 2414, 2413
34315, 2403, 2404, 2415, 2414
34316, 2404, 2405, 2416, 2415
34317, 2405, 2406, 2417, 2416
34318, 2406, 232, 233, 2417
34319, 210, 2407, 2418, 211
34320, 2407, 2408, 2419, 2418
34321, 2408, 2409, 2420, 2419
34322, 2409, 2410, 2421, 2420
34323, 2410, 2411, 2422, 2421
34324, 2411, 2412, 2423, 2422
34325, 2412, 2413, 2424, 2423
34326, 2413, 2414, 2425, 2424
34327, 2414, 2415, 2426, 2425
34328, 2415, 2416, 2427, 2426
34329, 2416, 2417, 2428, 2427
34330, 2417, 233, 234, 2428
34331, 211, 2418, 2429, 212
34332, 2418, 2419, 2430, 2429
34333, 2419, 2420, 2431, 2430
34334, 2420, 2421, 2432, 2431
34335, 2421, 2422, 2433, 2432
34336, 2422, 2423, 2434, 2433
34337, 2423, 2424, 2435, 2434
34338, 2424, 2425, 2436, 2435
34339, 2425, 2426, 2437, 2436
34340, 2426, 2427, 2438, 2437
34341, 2427, 2428, 2439, 2438
34342, 2428, 234, 235, 2439
34343, 212, 2429, 2440, 213
34344, 2429, 2430, 2441, 2440
34345, 2430, 2431, 2442, 2441
34346, 2431, 2432, 2443, 2442
34347, 2432, 2433, 2444, 2443
34348, 2433, 2434, 2445, 2444
34349, 2434, 2435, 2446, 2445
34350, 2435, 2436, 2447, 2446
34351, 2436, 2437, 2448, 2447
34352, 2437, 2438, 2449, 2448
34353, 2438, 2439, 2450, 2449
34354, 2439, 235, 236, 2450
34355, 213, 2440, 2451, 214
34356, 2440, 2441, 2452, 2451
34357, 2441, 2442, 2453, 2452
34358, 2442, 2443, 2454, 2453
34359, 2443, 2444, 2455, 2454
34360, 2444, 2445, 2456, 2455
34361, 2445, 2446, 2457, 2456
34362, 2446, 2447, 2458, 2457
34363, 2447, 2448, 2459, 2458
34364, 2448, 2449, 2460, 2459
34365, 2449, 2450, 2461, 2460
34366, 2450, 236, 237, 2461
34367, 214, 2451, 2462, 215
34368, 2451, 2452, 2463, 2462
34369, 2452, 2453, 2464, 2463
34370, 2453, 2454, 2465, 2464
34371, 2454, 2455, 2466, 2465
34372, 2455, 2456, 2467, 2466
34373, 2456, 2457, 2468, 2467
34374, 2457, 2458, 2469, 2468
34375, 2458, 2459, 2470, 2469
34376, 2459, 2460, 2471, 2470
34377, 2460, 2461, 2472, 2471
34378, 2461, 237, 238, 2472
34379, 215, 2462, 2473, 216
34380, 2462, 2463, 2474, 2473
34381, 2463, 2464, 2475, 2474
34382, 2464, 2465, 2476, 2475
34383, 2465, 2466, 2477, 2476
34384, 2466, 2467, 2478, 2477
34385, 2467, 2468, 2479, 2478
34386, 2468, 2469, 2480, 2479
34387, 2469, 2470, 2481, 2480
34388, 2470, 2471, 2482, 2481
34389, 2471, 2472, 2483, 2482
34390, 2472, 238, 239, 2483
34391, 216, 2473, 2484, 217
34392, 2473, 2474, 2485, 2484
34393, 2474, 2475, 2486, 2485
34394, 2475, 2476, 2487, 2486
34395, 2476, 2477, 2488, 2487
34396, 2477, 2478, 2489, 2488
34397, 2478, 2479, 2490, 2489
34398, 2479, 2480, 2491, 2490
34399, 2480, 2481, 2492, 2491
34400, 2481, 2482, 2493, 2492
34401, 2482, 2483, 2494, 2493
34402, 2483, 239, 240, 2494
34403, 217, 2484, 136, 8
34404, 2484, 2485, 137, 136
34405, 2485, 2486, 138, 137
34406, 2486, 2487, 139, 138
34407, 2487, 2488, 140, 139
34408, 2488, 2489, 141, 140
34409, 2489, 2490, 142, 141
34410, 2490, 2491, 143, 142
34411, 2491, 2492, 144, 143
34412, 2492, 2493, 145, 144
34413, 2493, 2494, 146, 145
34414, 2494, 240, 7, 146
*ELEMENT, type=CPS4, ELSET=Surface5
34415, 2, 121, 2495, 149
34416, 149, 2495, 2496, 150
34417, 150, 2496, 2497, 151
34418, 151, 2497, 2498, 152
34419, 152, 2498, 2499, 153
34420, 153, 2499, 2500, 154
34421, 154, 2500, 2501, 155
34422, 155, 2501, 2502, 156
34423, 156, 2502, 2503, 157
34424, 157, 2503, 2504, 158
34425, 158, 2504, 2505, 159
34426, 159, 2505, 2506, 160
34427, 160, 2506, 2507, 161
34428, 161, 2507, 2508, 162
34429, 162, 2508, 2509, 163
34430, 163, 2509, 2510, 164
34431, 164, 2510, 2511, 165
34432, 165, 2511, 2512, 166
34433, 166, 2512, 2513, 167
34434, 167, 2513, 2514, 168
34435, 168, 2514, 2515, 169
34436, 169, 2515, 2516, 170
34437, 170, 2516, 2517, 171
34438, 171, 2517, 147, 6
34439, 121, 122, 2518, 2495
34440, 2495, 2518, 2519, 2496
34441, 2496, 2519, 2520, 2497
34442, 2497, 2520, 2521, 2498
34443, 2498, 2521, 2522, 2499
34444, 2499, 2522, 2523, 2500
34445, 2500, 2523, 2524, 2501
34446, 2501, 2524, 2525, 2502
34447, 2502, 2525, 2526, 2503
34448, 2503, 2526, 2527, 2504
34449, 2504, 2527, 2528, 2505
34450, 2505, 2528, 2529, 2506
34451, 2506, 2529, 2530, 2507
34452, 2507, 2530, 2531, 2508
34453, 2508, 2531, 2532, 2509
34454, 2509, 2532, 2533, 2510
34455, 2510, 2533, 2534, 2511
34456, 2511, 2534, 2535, 2512
34457, 2512, 2535, 2536, 2513
34458, 2513, 2536, 2537, 2514
34459, 2514, 2537, 2538, 2515
34460, 2515, 2538, 2539, 2516
34461, 2516, 2539, 2540, 2517
34462, 2517, 2540, 148, 147
34463, 122, 4, 195, 2518
34464, 2518, 195, 196, 2519
34465, 2519, 196, 197, 2520
34466, 2520, 197, 198, 2521
34467, 2521, 198, 199, 2522
34468, 2522, 199, 200, 2523
34469, 2523, 200, 201, 2524
34470, 2524, 201, 202, 2525
34471, 2525, 202, 203, 2526
34472, 2526, 203, 204, 2527
34473, 2527, 204, 205, 2528
34474, 2528, 205, 206, 2529
34475, 2529, 206, 207, 2530
34476, 2530, 207, 208, 2531
34477, 2531, 208, 209, 2532
34478, 2532, 209, 210, 2533
34479, 2533, 210, 211, 2534
34480, 2534, 211, 212, 2535
34481, 2535, 212, 213, 2536
34482, 2536, 213, 214, 2537
34483, 2537, 214, 215, 2538
34484, 2538, 215, 216, 2539
34485, 2539, 216, 217, 2540
34486, 2540, 217, 8, 148
*ELEMENT, type=CPS4, ELSET=Surface6
398, 1, 172, 2541, 108
399, 172, 173, 2542, 2541
400, 173, 174, 2543, 2542
401, 174, 175, 2544, 2543
402, 175, 176, 2545, 2544
403, 176, 177, 2546, 2545
404, 177, 178, 2547, 2546
405, 178, 179, 2548, 2547
406, 179, 180, 2549, 2548
407, 180, 181, 2550, 2549
408, 181, 182, 2551, 2550
409, 182, 183, 2552, 2551
410, 183, 184, 2553, 2552
411, 184, 185, 2554, 2553
412, 185, 186, 2555, 2554
413, 186, 187, 2556, 2555
414, 187, 188, 2557, 2556
415, 188, 189, 2558, 2557
416, 189, 190, 2559, 2558
417, 190, 191, 2560, 2559
418, 191, 192, 2561, 2560
419, 192, 193, 2562, 2561
420, 193, 194, 2563, 2562
421, 194, 5, 134, 2563
422, 108, 2541, 2564, 109
423, 2541, 2542, 2565, 2564
424, 2542, 2543, 2566, 2565
425, 2543, 2544, 2567, 2566
426, 2544, 2545, 2568, 2567
427, 2545, 2546, 2569, 2568
428, 2546, 2547, 2570, 2569
429, 2547, 2548, 2571, 2570
430, 2548, 2549, 2572, 2571
431, 2549, 2550, 2573, 2572
432, 2550, 2551, 2574, 2573
433, 2551, 2552, 2575, 2574
434, 2552, 2553, 2576, 2575
435, 2553, 2554, 2577, 2576
436, 2554, 2555, 2578, 2577
437, 2555, 2556, 2579, 2578
438, 2556, 2557, 2580, 2579
439, 2557, 2558, 2581, 2580
440, 2558, 2559, 2582, 2581
441, 2559, 2560, 2583, 2582
442, 2560, 2561, 2584, 2583
443, 2561, 2562, 2585, 2584
444, 2562, 2563, 2586, 2585
445, 2563, 134, 135, 2586
446, 109, 2564, 218, 3
447, 2564, 2565, 219, 218
448, 2565, 2566, 220, 219
449, 2566, 2567, 221, 220
450, 2567, 2568, 222, 221
451, 2568, 2569, 223, 222
452, 2569, 2570, 224, 223
453, 2570, 2571, 225, 224
454, 2571, 2572, 226, 225
455, 2572, 2573, 227, 226
456, 2573, 2574, 228, 227
457, 2574, 2575, 229, 228
458, 2575, 2576, 230, 229
459, 2576, 2577, 231, 230
460, 2577, 2578, 232, 231
461, 2578, 2579, 233, 232
462, 2579, 2580, 234, 233
463, 2580, 2581, 235, 234
464, 2581, 2582, 236, 235
465, 2582, 2583, 237, 236
466, 2583, 2584, 238, 237
467, 2584, 2585, 239, 238
468, 2585, 2586, 240, 239
469, 2586, 135, 7, 240
*ELEMENT, type=CPS4, ELSET=Surface7
34487, 4, 10, 241, 195
34488, 195, 241, 242, 196
34489, 196, 242, 243, 197
34490, 197, 243, 244, 198
34491, 198, 244, 245, 199
34492, 199, 245, 246, 200
34493, 200, 246, 247, 201
34494, 201, 247, 248, 202
34495, 202, 248, 249, 203
34496, 203, 249, 250, 204
34497, 204, 250, 251, 205
34498, 205, 251, 252, 206
34499, 206, 252, 253, 207
34500, 207, 253, 254, 208
34501, 208, 254, 255, 209
34502, 209, 255, 256, 210
34503, 210, 256, 257, 211
34504, 211, 257, 258, 212
34505, 212, 258, 259, 213
34506, 213, 259, 260, 214
34507, 214, 260, 261, 215
34508, 215, 261, 262, 216
34509, 216, 262, 263, 217
34510, 217, 263, 9, 8
*ELEMENT, type=CPS4, ELSET=Surface8
34511, 8, 9, 264, 136
34512, 136, 264, 265, 137
34513, 137, 265, 266, 138
34514, 138, 266, 267, 139
34515, 139, 267, 268, 140
34516, 140, 268, 269, 141
34517, 141, 269, 270, 142
34518, 142, 270, 271, 143
34519, 143, 271, 272, 144
34520, 144, 272, 273, 145
34521, 145, 273, 274, 146
34522, 146, 274, 11, 7
*ELEMENT, type=CPS4, ELSET=Surface9
470, 3, 218, 275, 12
471, 218, 219, 276, 275
472, 219, 220, 277, 276
473, 220, 221, 278, 277
474, 221, 222, 279, 278
475, 222, 223, 280, 279
476, 223, 224, 281, 280
477, 224, 225, 282, 281
478, 225, 226, 283, 282
479, 226, 227, 284, 283
480, 227, 228, 285, 284
481, 228, 229, 286, 285
482, 229, 230, 287, 286
483, 230, 231, 288, 287
484, 231, 232, 289, 288
485, 232, 233, 290, 289
486, 233, 234, 291, 290
487, 234, 235, 292, 291
488, 235, 236, 293, 292
489, 236, 237, 294, 293
490, 237, 238, 295, 294
491, 238, 239, 296, 295
492, 239, 240, 297, 296
493, 240, 7, 11, 297
*ELEMENT, type=CPS4, ELSET=Surface10
34523, 4, 110, 298, 10
34524, 110, 111, 299, 298
34525, 111, 112, 300, 299
34526, 112, 113, 301, 300
34527, 113, 114, 302, 301
34528, 114, 115, 303, 302
34529, 115, 116, 304, 303
34530, 116, 117, 305, 304
34531, 117, 118, 306, 305
34532, 118, 119, 307, 306
34533, 119, 120, 308, 307
34534, 120, 3, 12, 308
*ELEMENT, type=CPS4, ELSET=Surface11
34535, 10, 298, 2587, 241
34536, 298, 299, 2588, 2587
34537, 299, 300, 2589, 2588
34538, 300, 301, 2590, 2589
34539, 301, 302, 2591, 2590
34540, 302, 303, 2592, 2591
34541, 303, 304, 2593, 2592
34542, 304, 305, 2594, 2593
34543, 305, 306, 2595, 2594
34544, 306, 307, 2596, 2595
34545, 307, 308, 2597, 2596
34546, 308, 12, 275, 2597
34547, 241, 2587, 2598, 242
34548, 2587, 2588, 2599, 2598
34549, 2588, 2589, 2600, 2599
34550, 2589, 2590, 2601, 2600
34551, 2590, 2591, 2602, 2601
34552, 2591, 2592, 2603, 2602
34553, 2592, 2593, 2604, 2603
34554, 2593, 2594, 2605, 2604
34555, 2594, 2595, 2606, 2605
34556, 2595, 2596, 2607, 2606
34557, 2596, 2597, 2608, 2607
34558, 2597, 275, 276, 2608
34559, 242, 2598, 2609, 243
34560, 2598, 2599, 2610, 2609
34561, 2599, 2600, 2611, 2610
34562, 2600, 2601, 2612, 2611
34563, 2601, 2602, 2613, 2612
34564, 2602, 2603, 2614, 2613
34565, 2603, 2604, 2615, 2614
34566, 2604, 2605, 2616, 2615
34567, 2605, 2606, 2617, 2616
34568, 2606, 2607, 2618, 2617
34569, 2607, 2608, 2619, 2618
34570, 2608, 276, 277, 2619
34571, 243, 2609, 2620, 244
34572, 2609, 2610, 2621, 2620
34573, 2610, 2611, 2622, 2621
34574, 2611, 2612, 2623, 2622
34575, 2612, 2613, 2624, 2623
34576, 2613, 2614, 2625, 2624
34577, 2614, 2615, 2626, 2625
34578, 2615, 2616, 2627, 2626
34579, 2616, 2617, 2628, 2627
34580, 2617, 2618, 2629, 2628
34581, 2618, 2619, 2630, 2629
34582, 2619, 277, 278, 2630
34583, 244, 2620, 2631, 245
34584, 2620, 2621, 2632, 2631
34585, 2621, 2622, 2633, 2632
34586, 2622, 2623, 2634, 2633
34587, 2623, 2624, 2635, 2634
34588, 2624, 2625, 2636, 2635
34589, 2625, 2626, 2637, 2636
34590, 2626, 2627, 2638, 2637
34591, 2627, 2628, 2639, 2638
34592, 2628, 2629, 2640, 2639
34593, 2629, 2630, 2641, 2640
34594, 2630, 278, 279, 2641
34595, 245, 2631, 2642, 246
34596, 2631, 2632, 2643, 2642
34597, 2632, 2633, 2644, 2643
34598, 2633, 2634, 2645, 2644
34599, 2634, 2635, 2646, 2645
34600, 2635, 2636, 2647, 2646
34601, 2636, 2637, 2648, 2647
34602, 2637, 2638, 2649, 2648
34603, 2638, 2639, 2650, 2649
34604, 2639, 2640, 2651, 2650
34605, 2640, 2641, 2652, 2651
34606, 2641, 279, 280, 2652
34607, 246, 2642, 2653, 247
34608, 2642, 2643, 2654, 2653
34609, 2643, 2644, 2655, 2654
34610, 2644, 2645, 2656, 2655
34611, 2645, 2646, 2657, 2656
34612, 2646, 2647, 2658, 2657
34613, 2647, 2648, 2659, 2658
34614, 2648, 2649, 2660, 2659
34615, 2649, 2650, 2661, 2660
34616, 2650, 2651, 2662, 2661
34617, 2651, 2652, 2663, 2662
34618, 2652, 280, 281, 2663
34619, 247, 2653, 2664, 248
34620, 2653, 2654, 2665, 2664
34621, 2654, 2655, 2666, 2665
34622, 2655, 2656, 2667, 2666
34623, 2656, 2657, 2668, 2667
34624, 2657, 2658, 2669, 2668
34625, 2658, 2659, 2670, 2669
34626, 2659, 2660, 2671, 2670
34627, 2660, 2661, 2672, 2671
34628, 2661, 2662, 2673, 2672
34629, 2662, 2663, 2674, 2673
34630, 2663, 281, 282, 2674
34631, 248, 2664, 2675, 249
34632, 2664, 2665, 2676, 2675
34633, 2665, 2666, 2677, 2676
34634, 2666, 2667, 2678, 2677
34635, 2667, 2668, 2679, 2678
34636, 2668, 2669, 2680, 2679
34637, 2669, 2670, 2681, 2680
34638, 2670, 2671, 2682, 2681
34639, 2671, 2672, 2683, 2682
34640, 2672, 2673, 2684, 2683
34641, 2673, 2674, 2685, 2684
34642, 2674, 282, 283, 2685
34643, 249, 2675, 2686, 250
34644, 2675, 2676, 2687, 2686
34645, 2676, 2677, 2688, 2687
34646, 2677, 2678, 2689, 2688
34647, 2678, 2679, 2690, 2689
34648, 2679, 2680, 2691, 2690
34649, 2680, 2681, 2692, 2691
34650, 2681, 2682, 2693, 2692
34651, 2682, 2683, 2694, 2693
34652, 2683, 2684, 2695, 2694
34653, 2684, 2685, 2696, 2695
34654, 2685, 283, 284, 2696
34655, 250, 2686, 2697, 251
34656, 2686, 2687, 2698, 2697
34657, 2687, 2688, 2699, 2698
34658, 2688, 2689, 2700, 2699
34659, 2689, 2690, 2701, 2700
34660, 2690, 2691, 2702, 2701
34661, 2691, 2692, 2703, 2702
34662, 2692, 2693, 2704, 2703
34663, 2693, 2694, 2705, 2704
34664, 2694, 2695, 2706, 2705
34665, 2695, 2696, 2707, 2706
34666, 2696, 284, 285, 2707
34667, 251, 2697, 2708, 252
34668, 2697, 2698, 2709, 2708
34669, 2698, 2699, 2710, 2709
34670, 2699, 2700, 2711, 2710
34671, 2700, 2701, 2712, 2711
34672, 2701, 2702, 2713, 2712
34673, 2702, 2703, 2714, 2713
34674, 2703, 2704, 2715, 2714
34675, 2704, 2705, 2716, 2715
34676, 2705, 2706, 2717, 2716
34677, 2706, 2707, 2718, 2717
34678, 2707, 285, 286, 2718
34679, 252, 2708, 2719, 253
34680, 2708, 2709, 2720, 2719
34681, 2709, 2710, 2721, 2720
34682, 2710, 2711, 2722, 2721
34683, 2711, 2712, 2723, 2722
34684, 2712, 2713, 2724, 2723
34685, 2713, 2714, 2725, 2724
34686, 2714, 2715, 2726, 2725
34687, 2715, 2716, 2727, 2726
34688, 2716, 2717, 2728, 2727
34689, 2717, 2718, 2729, 2728
34690, 2718, 286, 287, 2729
34691, 253, 2719, 2730, 254
34692, 2719, 2720, 2731, 2730
34693, 2720, 2721, 2732, 2731
34694, 2721, 2722, 2733, 2732
34695, 2722, 2723, 2734, 2733
34696, 2723, 2724, 2735, 2734
34697, 2724, 2725, 2736, 2735
34698, 2725, 2726, 2737, 2736
34699, 2726, 2727, 2738, 2737
34700, 2727, 2728, 2739, 2738
34701, 2728, 2729, 2740, 2739
34702, 2729, 287, 288, 2740
34703, 254, 2730, 2741, 255
34704, 2730, 2731, 2742, 2741
34705, 2731, 2732, 2743, 2742
34706, 2732, 2733, 2744, 2743
34707, 2733, 2734, 2745, 2744
34708, 2734, 2735, 2746, 2745
34709, 2735, 2736, 2747, 2746
34710, 2736, 2737, 2748, 2747
34711, 2737, 2738, 2749, 2748
34712, 2738, 2739, 2750, 2749
34713, 2739, 2740, 2751, 2750
34714, 2740, 288, 289, 2751
34715, 255, 2741, 2752, 256
34716, 2741, 2742, 2753, 2752
34717, 2742, 2743, 2754, 2753
34718, 2743, 2744, 2755, 2754
34719, 2744, 2745, 2756, 2755
34720, 2745, 2746, 2757, 2756
34721, 2746, 2747, 2758, 2757
34722, 2747, 2748, 2759, 2758
34723, 2748, 2749, 2760, 2759
34724, 2749, 2750, 2761, 2760
34725, 2750, 2751, 2762, 2761
34726, 2751, 289, 290, 2762
34727, 256, 2752, 2763, 257
34728, 2752, 2753, 2764, 2763
34729, 2753, 2754, 2765, 2764
34730, 2754, 2755, 2766, 2765
34731, 2755, 2756, 2767, 2766
34732, 2756, 2757, 2768, 2767
34733, 2757, 2758, 2769, 2768
34734, 2758, 2759, 2770, 2769
34735, 2759, 2760, 2771, 2770
34736, 2760, 2761, 2772, 2771
34737, 2761, 2762, 2773, 2772
34738, 2762, 290, 291, 2773
34739, 257, 2763, 2774, 258
34740, 2763, 2764, 2775, 2774
34741, 2764, 2765, 2776, 2775
34742, 2765, 2766, 2777, 2776
34743, 2766, 2767, 2778, 2777
34744, 2767, 2768, 2779, 2778
34745, 2768, 2769, 2780, 2779
34746, 2769, 2770, 2781, 2780
34747, 2770, 2771, 2782, 2781
34748, 2771, 2772, 2783, 2782
34749, 2772, 2773, 2784, 2783
34750, 2773, 291, 292, 2784
34751, 258, 2774, 2785, 259
34752, 2774, 2775, 2786, 2785
34753, 2775, 2776, 2787, 2786
34754, 2776, 2777, 2788, 2787
34755, 2777, 2778, 2789, 2788
34756, 2778, 2779, 2790, 2789
34757, 2779, 2780, 2791, 2790
34758, 2780, 2781, 2792, 2791
34759, 2781, 2782, 2793, 2792
34760, 2782, 2783, 2794, 2793
34761, 2783, 2784, 2795, 2794
34762, 2784, 292, 293, 2795
34763, 259, 2785, 2796, 260
34764, 2785, 2786, 2797, 2796
34765, 2786, 2787, 2798, 2797
34766, 2787, 2788, 2799, 2798
34767, 2788, 2789, 2800, 2799
34768, 2789, 2790, 2801, 2800
34769, 2790, 2791, 2802, 2801
34770, 2791, 2792, 2803, 2802
34771, 2792, 2793, 2804, 2803
34772, 2793, 2794, 2805, 2804
34773, 2794, 2795, 2806, 2805
34774, 2795, 293, 294, 2806
34775, 260, 2796, 2807, 261
34776, 2796, 2797, 2808, 2807
34777, 2797, 2798, 2809, 2808
34778, 2798, 2799, 2810, 2809
34779, 2799, 2800, 2811, 2810
34780, 2800, 2801, 2812, 2811
34781, 2801, 2802, 2813, 2812
34782, 2802, 2803, 2814, 2813
34783, 2803, 2804, 2815, 2814
34784, 2804, 2805, 2816, 2815
34785, 2805, 2806, 2817, 2816
34786, 2806, 294, 295, 2817
34787, 261, 2807, 2818, 262
34788, 2807, 2808, 2819, 2818
34789, 2808, 2809, 2820, 2819
34790, 2809, 2810, 2821, 2820
34791, 2810, 2811, 2822, 2821
34792, 2811, 2812, 2823, 2822
34793, 2812, 2813, 2824, 2823
34794, 2813, 2814, 2825, 2824
34795, 2814, 2815, 2826, 2825
34796, 2815, 2816, 2827, 2826
34797, 2816, 2817, 2828, 2827
34798, 2817, 295, 296, 2828
34799, 262, 2818, 2829, 263
34800, 2818, 2819, 2830, 2829
34801, 2819, 2820, 2831, 2830
34802, 2820, 2821, 2832, 2831
34803, 2821, 2822, 2833, 2832
34804, 2822, 2823, 2834, 2833
34805, 2823, 2824, 2835, 2834
34806, 2824, 2825, 2836, 2835
34807, 2825, 2826, 2837, 2836
34808, 2826, 2827, 2838, 2837
34809, 2827, 2828, 2839, 2838
34810, 2828, 296, 297, 2839
34811, 263, 2829, 264, 9
34812, 2829, 2830, 265, 264
34813, 2830, 2831, 266, 265
34814, 2831, 2832, 267, 266
34815, 2832, 2833, 268, 267
34816, 2833, 2834, 269, 268
34817, 2834, 2835, 270, 269
34818, 2835, 2836, 271, 270
34819, 2836, 2837, 272, 271
34820, 2837, 2838, 273, 272
34821, 2838, 2839, 274, 273
34822, 2839, 297, 11, 274
*ELEMENT, type=CPS4, ELSET=Surface12
34823, 10, 332, 2840, 241
34824, 332, 333, 2841, 2840
34825, 333, 334, 2842, 2841
34826, 334, 335, 2843, 2842
34827, 335, 336, 2844, 2843
34828, 336, 337, 2845, 2844
34829, 337, 338, 2846, 2845
34830, 338, 339, 2847, 2846
34831, 339, 340, 2848, 2847
34832, 340, 341, 2849, 2848
34833, 341, 342, 2850, 2849
34834, 342, 343, 2851, 2850
34835, 343, 344, 2852, 2851
34836, 344, 345, 2853, 2852
34837, 345, 346, 2854, 2853
34838, 346, 347, 2855, 2854
34839, 347, 348, 2856, 2855
34840, 348, 349, 2857, 2856
34841, 349, 350, 2858, 2857
34842, 350, 351, 2859, 2858
34843, 351, 352, 2860, 2859
34844, 352, 353, 2861, 2860
34845, 353, 354, 2862, 2861
34846, 354, 14, 355, 2862
34847, 241, 2840, 2863, 242
34848, 2840, 2841, 2864, 2863
34849, 2841, 2842, 2865, 2864
34850, 2842, 2843, 2866, 2865
34851, 2843, 2844, 2867, 2866
34852, 2844, 2845, 2868, 2867
34853, 2845, 2846, 2869, 2868
34854, 2846, 2847, 2870, 2869
34855, 2847, 2848, 2871, 2870
34856, 2848, 2849, 2872, 2871
34857, 2849, 2850, 2873, 2872
34858, 2850, 2851, 2874, 2873
34859, 2851, 2852, 2875, 2874
34860, 2852, 2853, 2876, 2875
34861, 2853, 2854, 2877, 2876
34862, 2854, 2855, 2878, 2877
34863, 2855, 2856, 2879, 2878
34864, 2856, 2857, 2880, 2879
34865, 2857, 2858, 2881, 2880
34866, 2858, 2859, 2882, 2881
34867, 2859, 2860, 2883, 2882
34868, 2860, 2861, 2884, 2883
34869, 2861, 2862, 2885, 2884
34870, 2862, 355, 356, 2885
34871, 242, 2863, 2886, 243
34872, 2863, 2864, 2887, 2886
34873, 2864, 2865, 2888, 2887
34874, 2865, 2866, 2889, 2888
34875, 2866, 2867, 2890, 2889
34876, 2867, 2868, 2891, 2890
34877, 2868, 2869, 2892, 2891
34878, 2869, 2870, 2893, 2892
34879, 2870, 2871, 2894, 2893
34880, 2871, 2872, 2895, 2894
34881, 2872, 2873, 2896, 2895
34882, 2873, 2874, 2897, 2896
34883, 2874, 2875, 2898, 2897
34884, 2875, 2876, 2899, 2898
34885, 2876, 2877, 2900, 2899
34886, 2877, 2878, 2901, 2900
34887, 2878, 2879, 2902, 2901
34888, 2879, 2880, 2903, 2902
34889, 2880, 2881, 2904, 2903
34890, 2881, 2882, 2905, 2904
34891, 2882, 2883, 2906, 2905
34892, 2883, 2884, 2907, 2906
34893, 2884, 2885, 2908, 2907
34894, 2885, 356, 357, 2908
34895, 243, 2886, 2909, 244
34896, 2886, 2887, 2910, 2909
34897, 2887, 2888, 2911, 2910
34898, 2888, 2889, 2912, 2911
34899, 2889, 2890, 2913, 2912
34900, 2890, 2891, 2914, 2913
34901, 2891, 2892, 2915, 2914
34902, 2892, 2893, 2916, 2915
34903, 2893, 2894, 2917, 2916
34904, 2894, 2895, 2918, 2917
34905, 2895, 2896, 2919, 2918
34906, 2896, 2897, 2920, 2919
34907, 2897, 2898, 2921, 2920
34908, 2898, 2899, 2922, 2921
34909, 2899, 2900, 2923, 2922
34910, 2900, 2901, 2924, 2923
34911, 2901, 2902, 2925, 2924
34912, 2902, 2903, 2926, 2925
34913, 2903, 2904, 2927, 2926
34914, 2904, 2905, 2928, 2927
34915, 2905, 2906, 2929, 2928
34916, 2906, 2907, 2930, 2929
34917, 2907, 2908, 2931, 2930
34918, 2908, 357, 358, 2931
34919, 244, 2909, 2932, 245
34920, 2909, 2910, 2933, 2932
34921, 2910, 2911, 2934, 2933
34922, 2911, 2912, 2935, 2934
34923, 2912, 2913, 2936, 2935
34924, 2913, 2914, 2937, 2936
34925, 2914, 2915, 2938, 2937
34926, 2915, 2916, 2939, 2938
34927, 2916, 2917, 2940, 2939
34928, 2917, 2918, 2941, 2940
34929, 2918, 2919, 2942, 2941
34930, 2919, 2920, 2943, 2942
34931, 2920, 2921, 2944, 2943
34932, 2921, 2922, 2945, 2944
34933, 2922, 2923, 2946, 2945
34934, 2923, 2924, 2947, 2946
34935, 2924, 2925, 2948, 2947
34936, 2925, 2926, 2949, 2948
34937, 2926, 2927, 2950, 2949
34938, 2927, 2928, 2951, 2950
34939, 2928, 2929, 2952, 2951
34940, 2929, 2930, 2953, 2952
34941, 2930, 2931, 2954, 2953
34942, 2931, 358, 359, 2954
34943, 245, 2932, 2955, 246
34944, 2932, 2933, 2956, 2955
34945, 2933, 2934, 2957, 2956
34946, 2934, 2935, 2958, 2957
34947, 2935, 2936, 2959, 2958
34948, 2936, 2937, 2960, 2959
34949, 2937, 2938, 2961, 2960
34950, 2938, 2939, 2962, 2961
34951, 2939, 2940, 2963, 2962
34952, 2940, 2941, 2964, 2963
34953, 2941, 2942, 2965, 2964
34954, 2942, 2943, 2966, 2965
34955, 2943, 2944, 2967, 2966
34956, 2944, 2945, 2968, 2967
34957, 2945, 2946, 2969, 2968
34958, 2946, 2947, 2970, 2969
34959, 2947, 2948, 2971, 2970
34960, 2948, 2949, 2972, 2971
34961, 2949, 2950, 2973, 2972
34962, 2950, 2951, 2974, 2973
34963, 2951, 2952, 2975, 2974
34964, 2952, 2953, 2976, 2975
34965, 2953, 2954, 2977, 2976
34966, 2954, 359, 360, 2977
34967, 246, 2955, 2978, 247
34968, 2955, 2956, 2979, 2978
34969, 2956, 2957, 2980, 2979
34970, 2957, 2958, 2981, 2980
34971, 2958, 2959, 2982, 2981
34972, 2959, 2960, 2983, 2982
34973, 2960, 2961, 2984, 2983
34974, 2961, 2962, 2985, 2984
34975, 2962, 2963, 2986, 2985
34976, 2963, 2964, 2987, 2986
34977, 2964, 2965, 2988, 2987
34978, 2965, 2966, 2989, 2988
34979, 2966, 2967, 2990, 2989
34980, 2967, 2968, 2991, 2990
34981, 2968, 2969, 2992, 2991
34982, 2969, 2970, 2993, 2992
34983, 2970, 2971, 2994, 2993
34984, 2971, 2972, 2995, 2994
34985, 2972, 2973, 2996, 2995
34986, 2973, 2974, 2997, 2996
34987, 2974, 2975, 2998, 2997
34988, 2975, 2976, 2999, 2998
34989, 2976, 2977, 3000, 2999
34990, 2977, 360, 361, 3000
34991, 247, 2978, 3001, 248
34992, 2978, 2979, 3002, 3001
34993, 2979, 2980, 3003, 3002
34994, 2980, 2981, 3004, 3003
34995, 2981, 2982, 3005, 3004
34996, 2982, 2983, 3006, 3005
34997, 2983, 2984, 3007, 3006
34998, 2984, 2985, 3008, 3007
34999, 2985, 2986, 3009, 3008
35000, 2986, 2987, 3010, 3009
35001, 2987, 2988, 3011, 3010
35002, 2988, 2989, 3012, 3011
35003, 2989, 2990, 3013, 3012
35004, 2990, 2991, 3014, 3013
35005, 2991, 2992, 3015, 3014
35006, 2992, 2993, 3016, 3015
35007, 2993, 2994, 3017, 3016
35008, 2994, 2995, 3018, 3017
35009, 2995, 2996, 3019, 3018
35010, 2996, 2997, 3020, 3019
35011, 2997, 2998, 3021, 3020
35012, 2998, 2999, 3022, 3021
35013, 2999, 3000, 3023, 3022
35014, 3000, 361, 362, 3023
35015, 248, 3001, 3024, 249
35016, 3001, 3002, 3025, 3024
35017, 3002, 3003, 3026, 3025
35018, 3003, 3004, 3027, 3026
35019, 3004, 3005, 3028, 3027
35020, 3005, 3006, 3029, 3028
35021, 3006, 3007, 3030, 3029
35022, 3007, 3008, 3031, 3030
35023, 3008, 3009, 3032, 3031
35024, 3009, 3010, 3033, 3032
35025, 3010, 3011, 3034, 3033
35026, 3011, 3012, 3035, 3034
35027, 3012, 3013, 3036, 3035
35028, 3013, 3014, 3037, 3036
35029, 3014, 3015, 3038, 3037
35030, 3015, 3016, 3039, 3038
35031, 3016, 3017, 3040, 3039
35032, 3017, 3018, 3041, 3040
35033, 3018, 3019, 3042, 3041
35034, 3019, 3020, 3043, 3042
35035, 3020, 3021, 3044, 3043
35036, 3021, 3022, 3045, 3044
35037, 3022, 3023, 3046, 3045
35038, 3023, 362, 363, 3046
35039, 249, 3024, 3047, 250
35040, 3024, 3025, 3048, 3047
35041, 3025, 3026, 3049, 3048
35042, 3026, 3027, 3050, 3049
35043, 3027, 3028, 3051, 3050
35044, 3028, 3029, 3052, 3051
35045, 3029, 3030, 3053, 3052
35046, 3030, 3031, 3054, 3053
35047, 3031, 3032, 3055, 3054
35048, 3032, 3033, 3056, 3055
35049, 3033, 3034, 3057, 3056
35050, 3034, 3035, 3058, 3057
35051, 3035, 3036, 3059, 3058
35052, 3036, 3037, 3060, 3059
35053, 3037, 3038, 3061, 3060
35054, 3038, 3039, 3062, 3061
35055, 3039, 3040, 3063, 3062
35056, 3040, 3041, 3064, 3063
35057, 3041, 3042, 3065, 3064
35058, 3042, 3043, 3066, 3065
35059, 3043, 3044, 3067, 3066
35060, 3044, 3045, 3068, 3067
35061, 3045, 3046, 3069, 3068
35062, 3046, 363, 364, 3069
35063, 250, 3047, 3070, 251
35064, 3047, 3048, 3071, 3070
35065, 3048, 3049, 3072, 3071
35066, 3049, 3050, 3073, 3072
35067, 3050, 3051, 3074, 3073
35068, 3051, 3052, 3075, 3074
35069, 3052, 3053, 3076, 3075
35070, 3053, 3054, 3077, 3076
35071, 3054, 3055, 3078, 3077
35072, 3055, 3056, 3079, 3078
35073, 3056, 3057, 3080, 3079
35074, 3057, 3058, 3081, 3080
35075, 3058, 3059, 3082, 3081
35076, 3059, 3060, 3083, 3082
35077, 3060, 3061, 3084, 3083
35078, 3061, 3062, 3085, 3084
35079, 3062, 3063, 3086, 3085
35080, 3063, 3064, 3087, 3086
35081, 3064, 3065, 3088, 3087
35082, 3065, 3066, 3089, 3088
35083, 3066, 3067, 3090, 3089
35084, 3067, 3068, 3091, 3090
35085, 3068, 3069, 3092, 3091
35086, 3069, 364, 365, 3092
35087, 251, 3070, 3093, 252
35088, 3070, 3071, 3094, 3093
35089, 3071, 3072, 3095, 3094
35090, 3072, 3073, 3096, 3095
35091, 3073, 3074, 3097, 3096
35092, 3074, 3075, 3098, 3097
35093, 3075, 3076, 3099, 3098
35094, 3076, 3077, 3100, 3099
35095, 3077, 3078, 3101, 3100
35096, 3078, 3079, 3102, 3101
35097, 3079, 3080, 3103, 3102
35098, 3080, 3081, 3104, 3103
35099, 3081, 3082, 3105, 3104
35100, 3082, 3083, 3106, 3105
35101, 3083, 3084, 3107, 3106
35102, 3084, 3085, 3108, 3107
35103, 3085, 3086, 3109, 3108
35104, 3086, 3087, 3110, 3109
35105, 3087, 3088, 3111, 3110
35106, 3088, 3089, 3112, 3111
35107, 3089, 3090, 3113, 3112
35108, 3090, 3091, 3114, 3113
35109, 3091, 3092, 3115, 3114
35110, 3092, 365, 366, 3115
35111, 252, 3093, 3116, 253
35112, 3093, 3094, 3117, 3116
35113, 3094, 3095, 3118, 3117
35114, 3095, 3096, 3119, 3118
35115, 3096, 3097, 3120, 3119
35116, 3097, 3098, 3121, 3120
35117, 3098, 3099, 3122, 3121
35118, 3099, 3100, 3123, 3122
35119, 3100, 3101, 3124, 3123
35120, 3101, 3102, 3125, 3124
35121, 3102, 3103, 3126, 3125
35122, 3103, 3104, 3127, 3126
35123, 3104, 3105, 3128, 3127
35124, 3105, 3106, 3129, 3128
35125, 3106, 3107, 3130, 3129
35126, 3107, 3108, 3131, 3130
35127, 3108, 3109, 3132, 3131
35128, 3109, 3110, 3133, 3132
35129, 3110, 3111, 3134, 3133
35130, 3111, 3112, 3135, 3134
35131, 3112, 3113, 3136, 3135
35132, 3113, 3114, 3137, 3136
35133, 3114, 3115, 3138, 3137
35134, 3115, 366, 367, 3138
35135, 253, 3116, 3139, 254
35136, 3116, 3117, 3140, 3139
35137, 3117, 3118, 3141, 3140
35138, 3118, 3119, 3142, 3141
35139, 3119, 3120, 3143, 3142
35140, 3120, 3121, 3144, 3143
35141, 3121, 3122, 3145, 3144
35142, 3122, 3123, 3146, 3145
35143, 3123, 3124, 3147, 3146
35144, 3124, 3125, 3148, 3147
35145, 3125, 3126, 3149, 3148
35146, 3126, 3127, 3150, 3149
35147, 3127, 3128, 3151, 3150
35148, 3128, 3129, 3152, 3151
35149, 3129, 3130, 3153, 3152
35150, 3130, 3131, 3154, 3153
35151, 3131, 3132, 3155, 3154
35152, 3132, 3133, 3156, 3155
35153, 3133, 3134, 3157, 3156
35154, 3134, 3135, 3158, 3157
35155, 3135, 3136, 3159, 3158
35156, 3136, 3137, 3160, 3159
35157, 3137, 3138, 3161, 3160
35158, 3138, 367, 368, 3161
35159, 254, 3139, 3162, 255
35160, 3139, 3140, 3163, 3162
35161, 3140, 3141, 3164, 3163
35162, 3141, 3142, 3165, 3164
35163, 3142, 3143, 3166, 3165
35164, 3143, 3144, 3167, 3166
35165, 3144, 3145, 3168, 3167
35166, 3145, 3146, 3169, 3168
35167, 3146, 3147, 3170, 3169
35168, 3147, 3148, 3171, 3170
35169, 3148, 3149, 3172, 3171
35170, 3149, 3150, 3173, 3172
35171, 3150, 3151, 3174, 3173
35172, 3151, 3152, 3175, 3174
35173, 3152, 3153, 3176, 3175
35174, 3153, 3154, 3177, 3176
35175, 3154, 3155, 3178, 3177
35176, 3155, 3156, 3179, 3178
35177, 3156, 3157, 3180, 3179
35178, 3157, 3158, 3181, 3180
35179, 3158, 3159, 3182, 3181
35180, 3159, 3160, 3183, 3182
35181, 3160, 3161, 3184, 3183
35182, 3161, 368, 369, 3184
35183, 255, 3162, 3185, 256
35184, 3162, 3163, 3186, 3185
35185, 3163, 3164, 3187, 3186
35186, 3164, 3165, 3188, 3187
35187, 3165, 3166, 3189, 3188
35188, 3166, 3167, 3190, 3189
35189, 3167, 3168, 3191, 3190
35190, 3168, 3169, 3192, 3191
35191, 3169, 3170, 3193, 3192
35192, 3170, 3171, 3194, 3193
35193, 3171, 3172, 3195, 3194
35194, 3172, 3173, 3196, 3195
35195, 3173, 3174, 3197, 3196
35196, 3174, 3175, 3198, 3197
35197, 3175, 3176, 3199, 3198
35198, 3176, 3177, 3200, 3199
35199, 3177, 3178, 3201, 3200
35200, 3178, 3179, 3202, 3201
35201, 3179, 3180, 3203, 3202
35202, 3180, 3181, 3204, 3203
35203, 3181, 3182, 3205, 3204
35204, 3182, 3183, 3206, 3205
35205, 3183, 3184, 3207, 3206
35206, 3184, 369, 370, 3207
35207, 256, 3185, 3208, 257
35208, 3185, 3186, 3209, 3208
35209, 3186, 3187, 3210, 3209
35210, 3187, 3188, 3211, 3210
35211, 3188, 3189, 3212, 3211
35212, 3189, 3190, 3213, 3212
35213, 3190, 3191, 3214, 3213
35214, 3191, 3192, 3215, 3214
35215, 3192, 3193, 3216, 3215
35216, 3193, 3194, 3217, 3216
35217, 3194, 3195, 3218, 3217
35218, 3195, 3196, 3219, 3218
35219, 3196, 3197, 3220, 3219
35220, 3197, 3198, 3221, 3220
35221, 3198, 3199, 3222, 3221
35222, 3199, 3200, 3223, 3222
35223, 3200, 3201, 3224, 3223
35224, 3201, 3202, 3225, 3224
35225, 3202, 3203, 3226, 3225
35226, 3203, 3204, 3227, 3226
35227, 3204, 3205, 3228, 3227
35228, 3205, 3206, 3229, 3228
35229, 3206, 3207, 3230, 3229
35230, 3207, 370, 371, 3230
35231, 257, 3208, 3231, 258
35232, 3208, 3209, 3232, 3231
35233, 3209, 3210, 3233, 3232
35234, 3210, 3211, 3234, 3233
35235, 3211, 3212, 3235, 3234
35236, 3212, 3213, 3236, 3235
35237, 3213, 3214, 3237, 3236
35238, 3214, 3215, 3238, 3237
35239, 3215, 3216, 3239, 3238
35240, 3216, 3217, 3240, 3239
35241, 3217, 3218, 3241, 3240
35242, 3218, 3219, 3242, 3241
35243, 3219, 3220, 3243, 3242
35244, 3220, 3221, 3244, 3243
35245, 3221, 3222, 3245, 3244
35246, 3222, 3223, 3246, 3245
35247, 3223, 3224, 3247, 3246
35248, 3224, 3225, 3248, 3247
35249, 3225, 3226, 3249, 3248
35250, 3226, 3227, 3250, 3249
35251, 3227, 3228, 3251, 3250
35252, 3228, 3229, 3252, 3251
35253, 3229, 3230, 3253, 3252
35254, 3230, 371, 372, 3253
35255, 258, 3231, 3254, 259
35256, 3231, 3232, 3255, 3254
35257, 3232, 3233, 3256, 3255
35258, 3233, 3234, 3257, 3256
35259, 3234, 3235, 3258, 3257
35260, 3235, 3236, 3259, 3258
35261, 3236, 3237, 3260, 3259
35262, 3237, 3238, 3261, 3260
35263, 3238, 3239, 3262, 3261
35264, 3239, 3240, 3263, 3262
35265, 3240, 3241, 3264, 3263
35266, 3241, 3242, 3265, 3264
35267, 3242, 3243, 3266, 3265
35268, 3243, 3244, 3267, 3266
35269, 3244, 3245, 3268, 3267
35270, 3245, 3246, 3269, 3268
35271, 3246, 3247, 3270, 3269
35272, 3247, 3248, 3271, 3270
35273, 3248, 3249, 3272, 3271
35274, 3249, 3250, 3273, 3272
35275, 3250, 3251, 3274, 3273
35276, 3251, 3252, 3275, 3274
35277, 3252, 3253, 3276, 3275
35278, 3253, 372, 373, 3276
35279, 259, 3254, 3277, 260
35280, 3254, 3255, 3278, 3277
35281, 3255, 3256, 3279, 3278
35282, 3256, 3257, 3280, 3279
35283, 3257, 3258, 3281, 3280
35284, 3258, 3259, 3282, 3281
35285, 3259, 3260, 3283, 3282
35286, 3260, 3261, 3284, 3283
35287, 3261, 3262, 3285, 3284
35288, 3262, 3263, 3286, 3285
35289, 3263, 3264, 3287, 3286
35290, 3264, 3265, 3288, 3287
35291, 3265, 3266, 3289, 3288
35292, 3266, 3267, 3290, 3289
35293, 3267, 3268, 3291, 3290
35294, 3268, 3269, 3292, 3291
35295, 3269, 3270, 3293, 3292
35296, 3270, 3271, 3294, 3293
35297, 3271, 3272, 3295, 3294
35298, 3272, 3273, 3296, 3295
35299, 3273, 3274, 3297, 3296
35300, 3274, 3275, 3298, 3297
35301, 3275, 3276, 3299, 3298
35302, 3276, 373, 374, 3299
35303, 260, 3277, 3300, 261
35304, 3277, 3278, 3301, 3300
35305, 3278, 3279, 3302, 3301
35306, 3279, 3280, 3303, 3302
35307, 3280, 3281, 3304, 3303
35308, 3281, 3282, 3305, 3304
35309, 3282, 3283, 3306, 3305
35310, 3283, 3284, 3307, 3306
35311, 3284, 3285, 3308, 3307
35312, 3285, 3286, 3309, 3308
35313, 3286, 3287, 3310, 3309
35314, 3287, 3288, 3311, 3310
35315, 3288, 3289, 3312, 3311
35316, 3289, 3290, 3313, 3312
35317, 3290, 3291, 3314, 3313
35318, 3291, 3292, 3315, 3314
35319, 3292, 3293, 3316, 3315
35320, 3293, 3294, 3317, 3316
35321, 3294, 3295, 3318, 3317
35322, 3295, 3296, 3319, 3318
35323, 3296, 3297, 3320, 3319
35324, 3297, 3298, 3321, 3320
35325, 3298, 3299, 3322, 3321
35326, 3299, 374, 375, 3322
35327, 261, 3300, 3323, 262
35328, 3300, 3301, 3324, 3323
35329, 3301, 3302, 3325, 3324
35330, 3302, 3303, 3326, 3325
35331, 3303, 3304, 3327, 3326
35332, 3304, 3305, 3328, 3327
35333, 3305, 3306, 3329, 3328
35334, 3306, 3307, 3330, 3329
35335, 3307, 3308, 3331, 3330
35336, 3308, 3309, 3332, 3331
35337, 3309, 3310, 3333, 3332
35338, 3310, 3311, 3334, 3333
35339, 3311, 3312, 3335, 3334
35340, 3312, 3313, 3336, 3335
35341, 3313, 3314, 3337, 3336
35342, 3314, 3315, 3338, 3337
35343, 3315, 3316, 3339, 3338
35344, 3316, 3317, 3340, 3339
35345, 3317, 3318, 3341, 3340
35346, 3318, 3319, 3342, 3341
35347, 3319, 3320, 3343, 3342
35348, 3320, 3321, 3344, 3343
35349, 3321, 3322, 3345, 3344
35350, 3322, 375, 376, 3345
35351, 262, 3323, 3346, 263
35352, 3323, 3324, 3347, 3346
35353, 3324, 3325, 3348, 3347
35354, 3325, 3326, 3349, 3348
35355, 3326, 3327, 3350, 3349
35356, 3327, 3328, 3351, 3350
35357, 3328, 3329, 3352, 3351
35358, 3329, 3330, 3353, 3352
35359, 3330, 3331, 3354, 3353
35360, 3331, 3332, 3355, 3354
35361, 3332, 3333, 3356, 3355
35362, 3333, 3334, 3357, 3356
35363, 3334, 3335, 3358, 3357
35364, 3335, 3336, 3359, 3358
35365, 3336, 3337, 3360, 3359
35366, 3337, 3338, 3361, 3360
35367, 3338, 3339, 3362, 3361
35368, 3339, 3340, 3363, 3362
35369, 3340, 3341, 3364, 3363
35370, 3341, 3342, 3365, 3364
35371, 3342, 3343, 3366, 3365
35372, 3343, 3344, 3367, 3366
35373, 3344, 3345, 3368, 3367
35374, 3345, 376, 377, 3368
35375, 263, 3346, 309, 9
35376, 3346, 3347, 310, 309
35377, 3347, 3348, 311, 310
35378, 3348, 3349, 312, 311
35379, 3349, 3350, 313, 312
35380, 3350, 3351, 314, 313
35381, 3351, 3352, 315, 314
35382, 3352, 3353, 316, 315
35383, 3353, 3354, 317, 316
35384, 3354, 3355, 318, 317
35385, 3355, 3356, 319, 318
35386, 3356, 3357, 320, 319
35387, 3357, 3358, 321, 320
35388, 3358, 3359, 322, 321
35389, 3359, 3360, 323, 322
35390, 3360, 3361, 324, 323
35391, 3361, 3362, 325, 324
35392, 3362, 3363, 326, 325
35393, 3363, 3364, 327, 326
35394, 3364, 3365, 328, 327
35395, 3365, 3366, 329, 328
35396, 3366, 3367, 330, 329
35397, 3367, 3368, 331, 330
35398, 3368, 377, 13, 331
*ELEMENT, type=CPS4, ELSET=Surface13
35399, 9, 309, 3369, 264
35400, 309, 310, 3370, 3369
35401, 310, 311, 3371, 3370
35402, 311, 312, 3372, 3371
35403, 312, 313, 3373, 3372
35404, 313, 314, 3374, 3373
35405, 314, 315, 3375, 3374
35406, 315, 316, 3376, 3375
35407, 316, 317, 3377, 3376
35408, 317, 318, 3378, 3377
35409, 318, 319, 3379, 3378
35410, 319, 320, 3380, 3379
35411, 320, 321, 3381, 3380
35412, 321, 322, 3382, 3381
35413, 322, 323, 3383, 3382
35414, 323, 324, 3384, 3383
35415, 324, 325, 3385, 3384
35416, 325, 326, 3386, 3385
35417, 326, 327, 3387, 3386
35418, 327, 328, 3388, 3387
35419, 328, 329, 3389, 3388
35420, 329, 330, 3390, 3389
35421, 330, 331, 3391, 3390
35422, 331, 13, 401, 3391
35423, 264, 3369, 3392, 265
35424, 3369, 3370, 3393, 3392
35425, 3370, 3371, 3394, 3393
35426, 3371, 3372, 3395, 3394
35427, 3372, 3373, 3396, 3395
35428, 3373, 3374, 3397, 3396
35429, 3374, 3375, 3398, 3397
35430, 3375, 3376, 3399, 3398
35431, 3376, 3377, 3400, 3399
35432, 3377, 3378, 3401, 3400
35433, 3378, 3379, 3402, 3401
35434, 3379, 3380, 3403, 3402
35435, 3380, 3381, 3404, 3403
35436, 3381, 3382, 3405, 3404
35437, 3382, 3383, 3406, 3405
35438, 3383, 3384, 3407, 3406
35439, 3384, 3385, 3408, 3407
35440, 3385, 3386, 3409, 3408
35441, 3386, 3387, 3410, 3409
35442, 3387, 3388, 3411, 3410
35443, 3388, 3389, 3412, 3411
35444, 3389, 3390, 3413, 3412
35445, 3390, 3391, 3414, 3413
35446, 3391, 401, 402, 3414
35447, 265, 3392, 3415, 266
35448, 3392, 3393, 3416, 3415
35449, 3393, 3394, 3417, 3416
35450, 3394, 3395, 3418, 3417
35451, 3395, 3396, 3419, 3418
35452, 3396, 3397, 3420, 3419
35453, 3397, 3398, 3421, 3420
35454, 3398, 3399, 3422, 3421
35455, 3399, 3400, 3423, 3422
35456, 3400, 3401, 3424, 3423
35457, 3401, 3402, 3425, 3424
35458, 3402, 3403, 3426, 3425
35459, 3403, 3404, 3427, 3426
35460, 3404, 3405, 3428, 3427
35461, 3405, 3406, 3429, 3428
35462, 3406, 3407, 3430, 3429
35463, 3407, 3408, 3431, 3430
35464, 3408, 3409, 3432, 3431
35465, 3409, 3410, 3433, 3432
35466, 3410, 3411, 3434, 3433
35467, 3411, 3412, 3435, 3434
35468, 3412, 3413, 3436, 3435
35469, 3413, 3414, 3437, 3436
35470, 3414, 402, 403, 3437
35471, 266, 3415, 3438, 267
35472, 3415, 3416, 3439, 3438
35473, 3416, 3417, 3440, 3439
35474, 3417, 3418, 3441, 3440
35475, 3418, 3419, 3442, 3441
35476, 3419, 3420, 3443, 3442
35477, 3420, 3421, 3444, 3443
35478, 3421, 3422, 3445, 3444
35479, 3422, 3423, 3446, 3445
35480, 3423, 3424, 3447, 3446
35481, 3424, 3425, 3448, 3447
35482, 3425, 3426, 3449, 3448
35483, 3426, 3427, 3450, 3449
35484, 3427, 3428, 3451, 3450
35485, 3428, 3429, 3452, 3451
35486, 3429, 3430, 3453, 3452
35487, 3430, 3431, 3454, 3453
35488, 3431, 3432, 3455, 3454
35489, 3432, 3433, 3456, 3455
35490, 3433, 3434, 3457, 3456
35491, 3434, 3435, 3458, 3457
35492, 3435, 3436, 3459, 3458
35493, 3436, 3437, 3460, 3459
35494, 3437, 403, 404, 3460
35495, 267, 3438, 3461, 268
35496, 3438, 3439, 3462, 3461
35497, 3439, 3440, 3463, 3462
35498, 3440, 3441, 3464, 3463
35499, 3441, 3442, 3465, 3464
35500, 3442, 3443, 3466, 3465
35501, 3443, 3444, 3467, 3466
35502, 3444, 3445, 3468, 3467
35503, 3445, 3446, 3469, 3468
35504, 3446, 3447, 3470, 3469
35505, 3447, 3448, 3471, 3470
35506, 3448, 3449, 3472, 3471
35507, 3449, 3450, 3473, 3472
35508, 3450, 3451, 3474, 3473
35509, 3451, 3452, 3475, 3474
35510, 3452, 3453, 3476, 3475
35511, 3453, 3454, 3477, 3476
35512, 3454, 3455, 3478, 3477
35513, 3455, 3456, 3479, 3478
35514, 3456, 3457, 3480, 3479
35515, 3457, 3458, 3481, 3480
35516, 3458, 3459, 3482, 3481
35517, 3459, 3460, 3483, 3482
35518, 3460, 404, 405, 3483
35519, 268, 3461, 3484, 269
35520, 3461, 3462, 3485, 3484
35521, 3462, 3463, 3486, 3485
35522, 3463, 3464, 3487, 3486
35523, 3464, 3465, 3488, 3487
35524, 3465, 3466, 3489, 3488
35525, 3466, 3467, 3490, 3489
35526, 3467, 3468, 3491, 3490
35527, 3468, 3469, 3492, 3491
35528, 3469, 3470, 3493, 3492
35529, 3470, 3471, 3494, 3493
35530, 3471, 3472, 3495, 3494
35531, 3472, 3473, 3496, 3495
35532, 3473, 3474, 3497, 3496
35533, 3474, 3475, 3498, 3497
35534, 3475, 3476, 3499, 3498
35535, 3476, 3477, 3500, 3499
35536, 3477, 3478, 3501, 3500
35537, 3478, 3479, 3502, 3501
35538, 3479, 3480, 3503, 3502
35539, 3480, 3481, 3504, 3503
35540, 3481, 3482, 3505, 3504
35541, 3482, 3483, 3506, 3505
35542, 3483, 405, 406, 3506
35543, 269, 3484, 3507, 270
35544, 3484, 3485, 3508, 3507
35545, 3485, 3486, 3509, 3508
35546, 3486, 3487, 3510, 3509
35547, 3487, 3488, 3511, 3510
35548, 3488, 3489, 3512, 3511
35549, 3489, 3490, 3513, 3512
35550, 3490, 3491, 3514, 3513
35551, 3491, 3492, 3515, 3514
35552, 3492, 3493, 3516, 3515
35553, 3493, 3494, 3517, 3516
35554, 3494, 3495, 3518, 3517
35555, 3495, 3496, 3519, 3518
35556, 3496, 3497, 3520, 3519
35557, 3497, 3498, 3521, 3520
35558, 3498, 3499, 3522, 3521
35559, 3499, 3500, 3523, 3522
35560, 3500, 3501, 3524, 3523
35561, 3501, 3502, 3525, 3524
35562, 3502, 3503, 3526, 3525
35563, 3503, 3504, 3527, 3526
35564, 3504, 3505, 3528, 3527
35565, 3505, 3506, 3529, 3528
35566, 3506, 406, 407, 3529
35567, 270, 3507, 3530, 271
35568, 3507, 3508, 3531, 3530
35569, 3508, 3509, 3532, 3531
35570, 3509, 3510, 3533, 3532
35571, 3510, 3511, 3534, 3533
35572, 3511, 3512, 3535, 3534
35573, 3512, 3513, 3536, 3535
35574, 3513, 3514, 3537, 3536
35575, 3514, 3515, 3538, 3537
35576, 3515, 3516, 3539, 3538
35577, 3516, 3517, 3540, 3539
35578, 3517, 3518, 3541, 3540
35579, 3518, 3519, 3542, 3541
35580, 3519, 3520, 3543, 3542
35581, 3520, 3521, 3544, 3543
35582, 3521, 3522, 3545, 3544
35583, 3522, 3523, 3546, 3545
35584, 3523, 3524, 3547, 3546
35585, 3524, 3525, 3548, 3547
35586, 3525, 3526, 3549, 3548
35587, 3526, 3527, 3550, 3549
35588, 3527, 3528, 3551, 3550
35589, 3528, 3529, 3552, 3551
35590, 3529, 407, 408, 3552
35591, 271, 3530, 3553, 272
35592, 3530, 3531, 3554, 3553
35593, 3531, 3532, 3555, 3554
35594, 3532, 3533, 3556, 3555
35595, 3533, 3534, 3557, 3556
35596, 3534, 3535, 3558, 3557
35597, 3535, 3536, 3559, 3558
35598, 3536, 3537, 3560, 3559
35599, 3537, 3538, 3561, 3560
35600, 3538, 3539, 3562, 3561
35601, 3539, 3540, 3563, 3562
35602, 3540, 3541, 3564, 3563
35603, 3541, 3542, 3565, 3564
35604, 3542, 3543, 3566, 3565
35605, 3543, 3544, 3567, 3566
35606, 3544, 3545, 3568, 3567
35607, 3545, 3546, 3569, 3568
35608, 3546, 3547, 3570, 3569
35609, 3547, 3548, 3571, 3570
35610, 3548, 3549, 3572, 3571
35611, 3549, 3550, 3573, 3572
35612, 3550, 3551, 3574, 3573
35613, 3551, 3552, 3575, 3574
35614, 3552, 408, 409, 3575
35615, 272, 3553, 3576, 273
35616, 3553, 3554, 3577, 3576
35617, 3554, 3555, 3578, 3577
35618, 3555, 3556, 3579, 3578
35619, 3556, 3557, 3580, 3579
35620, 3557, 3558, 3581, 3580
35621, 3558, 3559, 3582, 3581
35622, 3559, 3560, 3583, 3582
35623, 3560, 3561, 3584, 3583
35624, 3561, 3562, 3585, 3584
35625, 3562, 3563, 3586, 3585
35626, 3563, 3564, 3587, 3586
35627, 3564, 3565, 3588, 3587
35628, 3565, 3566, 3589, 3588
35629, 3566, 3567, 3590, 3589
35630, 3567, 3568, 3591, 3590
35631, 3568, 3569, 3592, 3591
35632, 3569, 3570, 3593, 3592
35633, 3570, 3571, 3594, 3593
35634, 3571, 3572, 3595, 3594
35635, 3572, 3573, 3596, 3595
35636, 3573, 3574, 3597, 3596
35637, 3574, 3575, 3598, 3597
35638, 3575, 409, 410, 3598
35639, 273, 3576, 3599, 274
35640, 3576, 3577, 3600, 3599
35641, 3577, 3578, 3601, 3600
35642, 3578, 3579, 3602, 3601
35643, 3579, 3580, 3603, 3602
35644, 3580, 3581, 3604, 3603
35645, 3581, 3582, 3605, 3604
35646, 3582, 3583, 3606, 3605
35647, 3583, 3584, 3607, 3606
35648, 3584, 3585, 3608, 3607
35649, 3585, 3586, 3609, 3608
35650, 3586, 3587, 3610, 3609
35651, 3587, 3588, 3611, 3610
35652, 3588, 3589, 3612, 3611
35653, 3589, 3590, 3613, 3612
35654, 3590, 3591, 3614, 3613
35655, 3591, 3592, 3615, 3614
35656, 3592, 3593, 3616, 3615
35657, 3593, 3594, 3617, 3616
35658, 3594, 3595, 3618, 3617
35659, 3595, 3596, 3619, 3618
35660, 3596, 3597, 3620, 3619
35661, 3597, 3598, 3621, 3620
35662, 3598, 410, 411, 3621
35663, 274, 3599, 378, 11
35664, 3599, 3600, 379, 378
35665, 3600, 3601, 380, 379
35666, 3601, 3602, 381, 380
35667, 3602, 3603, 382, 381
35668, 3603, 3604, 383, 382
35669, 3604, 3605, 384, 383
35670, 3605, 3606, 385, 384
35671, 3606, 3607, 386, 385
35672, 3607, 3608, 387, 386
35673, 3608, 3609, 388, 387
35674, 3609, 3610, 389, 388
35675, 3610, 3611, 390, 389
35676, 3611, 3612, 391, 390
35677, 3612, 3613, 392, 391
35678, 3613, 3614, 393, 392
35679, 3614, 3615, 394, 393
35680, 3615, 3616, 395, 394
35681, 3616, 3617, 396, 395
35682, 3617, 3618, 397, 396
35683, 3618, 3619, 398, 397
35684, 3619, 3620, 399, 398
35685, 3620, 3621, 400, 399
35686, 3621, 411, 15, 400
*ELEMENT, type=CPS4, ELSET=Surface14
494, 12, 275, 3622, 412
495, 412, 3622, 3623, 413
496, 413, 3623, 3624, 414
497, 414, 3624, 3625, 415
498, 415, 3625, 3626, 416
499, 416, 3626, 3627, 417
500, 417, 3627, 3628, 418
501, 418, 3628, 3629, 419
502, 419, 3629, 3630, 420
503, 420, 3630, 3631, 421
504, 421, 3631, 3632, 422
505, 422, 3632, 3633, 423
506, 423, 3633, 3634, 424
507, 424, 3634, 3635, 425
508, 425, 3635, 3636, 426
509, 426, 3636, 3637, 427
510, 427, 3637, 3638, 428
511, 428, 3638, 3639, 429
512, 429, 3639, 3640, 430
513, 430, 3640, 3641, 431
514, 431, 3641, 3642, 432
515, 432, 3642, 3643, 433
516, 433, 3643, 3644, 434
517, 434, 3644, 435, 16
518, 275, 276, 3645, 3622
519, 3622, 3645, 3646, 3623
520, 3623, 3646, 3647, 3624
521, 3624, 3647, 3648, 3625
522, 3625, 3648, 3649, 3626
523, 3626, 3649, 3650, 3627
524, 3627, 3650, 3651, 3628
525, 3628, 3651, 3652, 3629
526, 3629, 3652, 3653, 3630
527, 3630, 3653, 3654, 3631
528, 3631, 3654, 3655, 3632
529, 3632, 3655, 3656, 3633
530, 3633, 3656, 3657, 3634
531, 3634, 3657, 3658, 3635
532, 3635, 3658, 3659, 3636
533, 3636, 3659, 3660, 3637
534, 3637, 3660, 3661, 3638
535, 3638, 3661, 3662, 3639
536, 3639, 3662, 3663, 3640
537, 3640, 3663, 3664, 3641
538, 3641, 3664, 3665, 3642
539, 3642, 3665, 3666, 3643
540, 3643, 3666, 3667, 3644
541, 3644, 3667, 436, 435
542, 276, 277, 3668, 3645
543, 3645, 3668, 3669, 3646
544, 3646, 3669, 3670, 3647
545, 3647, 3670, 3671, 3648
546, 3648, 3671, 3672, 3649
547, 3649, 3672, 3673, 3650
548, 3650, 3673, 3674, 3651
549, 3651, 3674, 3675, 3652
550, 3652, 3675, 3676, 3653
551, 3653, 3676, 3677, 3654
552, 3654, 3677, 3678, 3655
553, 3655, 3678, 3679, 3656
554, 3656, 3679, 3680, 3657
555, 3657, 3680, 3681, 3658
556, 3658, 3681, 3682, 3659
557, 3659, 3682, 3683, 3660
558, 3660, 3683, 3684, 3661
559, 3661, 3684, 3685, 3662
560, 3662, 3685, 3686, 3663
561, 3663, 3686, 3687, 3664
562, 3664, 3687, 3688, 3665
563, 3665, 3688, 3689, 3666
564, 3666, 3689, 3690, 3667
565, 3667, 3690, 437, 436
566, 277, 278, 3691, 3668
567, 3668, 3691, 3692, 3669
568, 3669, 3692, 3693, 3670
569, 3670, 3693, 3694, 3671
570, 3671, 3694, 3695, 3672
571, 3672, 3695, 3696, 3673
572, 3673, 3696, 3697, 3674
573, 3674, 3697, 3698, 3675
574, 3675, 3698, 3699, 3676
575, 3676, 3699, 3700, 3677
576, 3677, 3700, 3701, 3678
577, 3678, 3701, 3702, 3679
578, 3679, 3702, 3703, 3680
579, 3680, 3703, 3704, 3681
580, 3681, 3704, 3705, 3682
581, 3682, 3705, 3706, 3683
582, 3683, 3706, 3707, 3684
583, 3684, 3707, 3708, 3685
584, 3685, 3708, 3709, 3686
585, 3686, 3709, 3710, 3687
586, 3687, 3710, 3711, 3688
587, 3688, 3711, 3712, 3689
588, 3689, 3712, 3713, 3690
589, 3690, 3713, 438, 437
590, 278, 279, 3714, 3691
591, 3691, 3714, 3715, 3692
592, 3692, 3715, 3716, 3693
593, 3693, 3716, 3717, 3694
594, 3694, 3717, 3718, 3695
595, 3695, 3718, 3719, 3696
596, 3696, 3719, 3720, 3697
597, 3697, 3720, 3721, 3698
598, 3698, 3721, 3722, 3699
599, 3699, 3722, 3723, 3700
600, 3700, 3723, 3724, 3701
601, 3701, 3724, 3725, 3702
602, 3702, 3725, 3726, 3703
603, 3703, 3726, 3727, 3704
604, 3704, 3727, 3728, 3705
605, 3705, 3728, 3729, 3706
606, 3706, 3729, 3730, 3707
607, 3707, 3730, 3731, 3708
608, 3708, 3731, 3732, 3709
609, 3709, 3732, 3733, 3710
610, 3710, 3733, 3734, 3711
611, 3711, 3734, 3735, 3712
612, 3712, 3735, 3736, 3713
613, 3713, 3736, 439, 438
614, 279, 280, 3737, 3714
615, 3714, 3737, 3738, 3715
616, 3715, 3738, 3739, 3716
617, 3716, 3739, 3740, 3717
618, 3717, 3740, 3741, 3718
619, 3718, 3741, 3742, 3719
620, 3719, 3742, 3743, 3720
621, 3720, 3743, 3744, 3721
622, 3721, 3744, 3745, 3722
623, 3722, 3745, 3746, 3723
624, 3723, 3746, 3747, 3724
625, 3724, 3747, 3748, 3725
626, 3725, 3748, 3749, 3726
627, 3726, 3749, 3750, 3727
628, 3727, 3750, 3751, 3728
629, 3728, 3751, 3752, 3729
630, 3729, 3752, 3753, 3730
631, 3730, 3753, 3754, 3731
632, 3731, 3754, 3755, 3732
633, 3732, 3755, 3756, 3733
634, 3733, 3756, 3757, 3734
635, 3734, 3757, 3758, 3735
636, 3735, 3758, 3759, 3736
637, 3736, 3759, 440, 439
638, 280, 281, 3760, 3737
639, 3737, 3760, 3761, 3738
640, 3738, 3761, 3762, 3739
641, 3739, 3762, 3763, 3740
642, 3740, 3763, 3764, 3741
643, 3741, 3764, 3765, 3742
644, 3742, 3765, 3766, 3743
645, 3743, 3766, 3767, 3744
646, 3744, 3767, 3768, 3745
647, 3745, 3768, 3769, 3746
648, 3746, 3769, 3770, 3747
649, 3747, 3770, 3771, 3748
650, 3748, 3771, 3772, 3749
651, 3749, 3772, 3773, 3750
652, 3750, 3773, 3774, 3751
653, 3751, 3774, 3775, 3752
654, 3752, 3775, 3776, 3753
655, 3753, 3776, 3777, 3754
656, 3754, 3777, 3778, 3755
657, 3755, 3778, 3779, 3756
658, 3756, 3779, 3780, 3757
659, 3757, 3780, 3781, 3758
660, 3758, 3781, 3782, 3759
661, 3759, 3782, 441, 440
662, 281, 282, 3783, 3760
663, 3760, 3783, 3784, 3761
664, 3761, 3784, 3785, 3762
665, 3762, 3785, 3786, 3763
666, 3763, 3786, 3787, 3764
667, 3764, 3787, 3788, 3765
668, 3765, 3788, 3789, 3766
669, 3766, 3789, 3790, 3767
670, 3767, 3790, 3791, 3768
671, 3768, 3791, 3792, 3769
672, 3769, 3792, 3793, 3770
673, 3770, 3793, 3794, 3771
674, 3771, 3794, 3795, 3772
675, 3772, 3795, 3796, 3773
676, 3773, 3796, 3797, 3774
677, 3774, 3797, 3798, 3775
678, 3775, 3798, 3799, 3776
679, 3776, 3799, 3800, 3777
680, 3777, 3800, 3801, 3778
681, 3778, 3801, 3802, 3779
682, 3779, 3802, 3803, 3780
683, 3780, 3803, 3804, 3781
684, 3781, 3804, 3805, 3782
685, 3782, 3805, 442, 441
686, 282, 283, 3806, 3783
687, 3783, 3806, 3807, 3784
688, 3784, 3807, 3808, 3785
689, 3785, 3808, 3809, 3786
690, 3786, 3809, 3810, 3787
691, 3787, 3810, 3811, 3788
692, 3788, 3811, 3812, 3789
693, 3789, 3812, 3813, 3790
694, 3790, 3813, 3814, 3791
695, 3791, 3814, 3815, 3792
696, 3792, 3815, 3816, 3793
697, 3793, 3816, 3817, 3794
698, 3794, 3817, 3818, 3795
699, 3795, 3818, 3819, 3796
700, 3796, 3819, 3820, 3797
701, 3797, 3820, 3821, 3798
702, 3798, 3821, 3822, 3799
703, 3799, 3822, 3823, 3800
704, 3800, 3823, 3824, 3801
705, 3801, 3824, 3825, 3802
706, 3802, 3825, 3826, 3803
707, 3803, 3826, 3827, 3804
708, 3804, 3827, 3828, 3805
709, 3805, 3828, 443, 442
710, 283, 284, 3829, 3806
711, 3806, 3829, 3830, 3807
712, 3807, 3830, 3831, 3808
713, 3808, 3831, 3832, 3809
714, 3809, 3832, 3833, 3810
715, 3810, 3833, 3834, 3811
716, 3811, 3834, 3835, 3812
717, 3812, 3835, 3836, 3813
718, 3813, 3836, 3837, 3814
719, 3814, 3837, 3838, 3815
720, 3815, 3838, 3839, 3816
721, 3816, 3839, 3840, 3817
722, 3817, 3840, 3841, 3818
723, 3818, 3841, 3842, 3819
724, 3819, 3842, 3843, 3820
725, 3820, 3843, 3844, 3821
726, 3821, 3844, 3845, 3822
727, 3822, 3845, 3846, 3823
728, 3823, 3846, 3847, 3824
729, 3824, 3847, 3848, 3825
730, 3825, 3848, 3849, 3826
731, 3826, 3849, 3850, 3827
732, 3827, 3850, 3851, 3828
733, 3828, 3851, 444, 443
734, 284, 285, 3852, 3829
735, 3829, 3852, 3853, 3830
736, 3830, 3853, 3854, 3831
737, 3831, 3854, 3855, 3832
738, 3832, 3855, 3856, 3833
739, 3833, 3856, 3857, 3834
740, 3834, 3857, 3858, 3835
741, 3835, 3858, 3859, 3836
742, 3836, 3859, 3860, 3837
743, 3837, 3860, 3861, 3838
744, 3838, 3861, 3862, 3839
745, 3839, 3862, 3863, 3840
746, 3840, 3863, 3864, 3841
747, 3841, 3864, 3865, 3842
748, 3842, 3865, 3866, 3843
749, 3843, 3866, 3867, 3844
750, 3844, 3867, 3868, 3845
751, 3845, 3868, 3869, 3846
752, 3846, 3869, 3870, 3847
753, 3847, 3870, 3871, 3848
754, 3848, 3871, 3872, 3849
755, 3849, 3872, 3873, 3850
756, 3850, 3873, 3874, 3851
757, 3851, 3874, 445, 444
758, 285, 286, 3875, 3852
759, 3852, 3875, 3876, 3853
760, 3853, 3876, 3877, 3854
761, 3854, 3877, 3878, 3855
762, 3855, 3878, 3879, 3856
763, 3856, 3879, 3880, 3857
764, 3857, 3880, 3881, 3858
765, 3858, 3881, 3882, 3859
766, 3859, 3882, 3883, 3860
767, 3860, 3883, 3884, 3861
768, 3861, 3884, 3885, 3862
769, 3862, 3885, 3886, 3863
770, 3863, 3886, 3887, 3864
771, 3864, 3887, 3888, 3865
772, 3865, 3888, 3889, 3866
773, 3866, 3889, 3890, 3867
774, 3867, 3890, 3891, 3868
775, 3868, 3891, 3892, 3869
776, 3869, 3892, 3893, 3870
777, 3870, 3893, 3894, 3871
778, 3871, 3894, 3895, 3872
779, 3872, 3895, 3896, 3873
780, 3873, 3896, 3897, 3874
781, 3874, 3897, 446, 445
782, 286, 287, 3898, 3875
783, 3875, 3898, 3899, 3876
784, 3876, 3899, 3900, 3877
785, 3877, 3900, 3901, 3878
786, 3878, 3901, 3902, 3879
787, 3879, 3902, 3903, 3880
788, 3880, 3903, 3904, 3881
789, 3881, 3904, 3905, 3882
790, 3882, 3905, 3906, 3883
791, 3883, 3906, 3907, 3884
792, 3884, 3907, 3908, 3885
793, 3885, 3908, 3909, 3886
794, 3886, 3909, 3910, 3887
795, 3887, 3910, 3911, 3888
796, 3888, 3911, 3912, 3889
797, 3889, 3912, 3913, 3890
798, 3890, 3913, 3914, 3891
799, 3891, 3914, 3915, 3892
800, 3892, 3915, 3916, 3893
801, 3893, 3916, 3917, 3894
802, 3894, 3917, 3918, 3895
803, 3895, 3918, 3919, 3896
804, 3896, 3919, 3920, 3897
805, 3897, 3920, 447, 446
806, 287, 288, 3921, 3898
807, 3898, 3921, 3922, 3899
808, 3899, 3922, 3923, 3900
809, 3900, 3923, 3924, 3901
810, 3901, 3924, 3925, 3902
811, 3902, 3925, 3926, 3903
812, 3903, 3926, 3927, 3904
813, 3904, 3927, 3928, 3905
814, 3905, 3928, 3929, 3906
815, 3906, 3929, 3930, 3907
816, 3907, 3930, 3931, 3908
817, 3908, 3931, 3932, 3909
818, 3909, 3932, 3933, 3910
819, 3910, 3933, 3934, 3911
820, 3911, 3934, 3935, 3912
821, 3912, 3935, 3936, 3913
822, 3913, 3936, 3937, 3914
823, 3914, 3937, 3938, 3915
824, 3915, 3938, 3939, 3916
825, 3916, 3939, 3940, 3917
826, 3917, 3940, 3941, 3918
827, 3918, 3941, 3942, 3919
828, 3919, 3942, 3943, 3920
829, 3920, 3943, 448, 447
830, 288, 289, 3944, 3921
831, 3921, 3944, 3945, 3922
832, 3922, 3945, 3946, 3923
833, 3923, 3946, 3947, 3924
834, 3924, 3947, 3948, 3925
835, 3925, 3948, 3949, 3926
836, 3926, 3949, 3950, 3927
837, 3927, 3950, 3951, 3928
838, 3928, 3951, 3952, 3929
839, 3929, 3952, 3953, 3930
840, 3930, 3953, 3954, 3931
841, 3931, 3954, 3955, 3932
842, 3932, 3955, 3956, 3933
843, 3933, 3956, 3957, 3934
844, 3934, 3957, 3958, 3935
845, 3935, 3958, 3959, 3936
846, 3936, 3959, 3960, 3937
847, 3937, 3960, 3961, 3938
848, 3938, 3961, 3962, 3939
849, 3939, 3962, 3963, 3940
850, 3940, 3963, 3964, 3941
851, 3941, 3964, 3965, 3942
852, 3942, 3965, 3966, 3943
853, 3943, 3966, 449, 448
854, 289, 290, 3967, 3944
855, 3944, 3967, 3968, 3945
856, 3945, 3968, 3969, 3946
857, 3946, 3969, 3970, 3947
858, 3947, 3970, 3971, 3948
859, 3948, 3971, 3972, 3949
860, 3949, 3972, 3973, 3950
861, 3950, 3973, 3974, 3951
862, 3951, 3974, 3975, 3952
863, 3952, 3975, 3976, 3953
864, 3953, 3976, 3977, 3954
865, 3954, 3977, 3978, 3955
866, 3955, 3978, 3979, 3956
867, 3956, 3979, 3980, 3957
868, 3957, 3980, 3981, 3958
869, 3958, 3981, 3982, 3959
870, 3959, 3982, 3983, 3960
871, 3960, 3983, 3984, 3961
872, 3961, 3984, 3985, 3962
873, 3962, 3985, 3986, 3963
874, 3963, 3986, 3987, 3964
875, 3964, 3987, 3988, 3965
876, 3965, 3988, 3989, 3966
877, 3966, 3989, 450, 449
878, 290, 291, 3990, 3967
879, 3967, 3990, 3991, 3968
880, 3968, 3991, 3992, 3969
881, 3969, 3992, 3993, 3970
882, 3970, 3993, 3994, 3971
883, 3971, 3994, 3995, 3972
884, 3972, 3995, 3996, 3973
885, 3973, 3996, 3997, 3974
886, 3974, 3997, 3998, 3975
887, 3975, 3998, 3999, 3976
888, 3976, 3999, 4000, 3977
889, 3977, 4000, 4001, 3978
890, 3978, 4001, 4002, 3979
891, 3979, 4002, 4003, 3980
892, 3980, 4003, 4004, 3981
893, 3981, 4004, 4005, 3982
894, 3982, 4005, 4006, 3983
895, 3983, 4006, 4007, 3984
896, 3984, 4007, 4008, 3985
897, 3985, 4008, 4009, 3986
898, 3986, 4009, 4010, 3987
899, 3987, 4010, 4011, 3988
900, 3988, 4011, 4012, 3989
901, 3989, 4012, 451, 450
902, 291, 292, 4013, 3990
903, 3990, 4013, 4014, 3991
904, 3991, 4014, 4015, 3992
905, 3992, 4015, 4016, 3993
906, 3993, 4016, 4017, 3994
907, 3994, 4017, 4018, 3995
908, 3995, 4018, 4019, 3996
909, 3996, 4019, 4020, 3997
910, 3997, 4020, 4021, 3998
911, 3998, 4021, 4022, 3999
912, 3999, 4022, 4023, 4000
913, 4000, 4023, 4024, 4001
914, 4001, 4024, 4025, 4002
915, 4002, 4025, 4026, 4003
916, 4003, 4026, 4027, 4004
917, 4004, 4027, 4028, 4005
918, 4005, 4028, 4029, 4006
919, 4006, 4029, 4030, 4007
920, 4007, 4030, 4031, 4008
921, 4008, 4031, 4032, 4009
922, 4009, 4032, 4033, 4010
923, 4010, 4033, 4034, 4011
924, 4011, 4034, 4035, 4012
925, 4012, 4035, 452, 451
926, 292, 293, 4036, 4013
927, 4013, 4036, 4037, 4014
928, 4014, 4037, 4038, 4015
929, 4015, 4038, 4039, 4016
930, 4016, 4039, 4040, 4017
931, 4017, 4040, 4041, 4018
932, 4018, 4041, 4042, 4019
933, 4019, 4042, 4043, 4020
934, 4020, 4043, 4044, 4021
935, 4021, 4044, 4045, 4022
936, 4022, 4045, 4046, 4023
937, 4023, 4046, 4047, 4024
938, 4024, 4047, 4048, 4025
939, 4025, 4048, 4049, 4026
940, 4026, 4049, 4050, 4027
941, 4027, 4050, 4051, 4028
942, 4028, 4051, 4052, 4029
943, 4029, 4052, 4053, 4030
944, 4030, 4053, 4054, 4031
945, 4031, 4054, 4055, 4032
946, 4032, 4055, 4056, 4033
947, 4033, 4056, 4057, 4034
948, 4034, 4057, 4058, 4035
949, 4035, 4058, 453, 452
950, 293, 294, 4059, 4036
951, 4036, 4059, 4060, 4037
952, 4037, 4060, 4061, 4038
953, 4038, 4061, 4062, 4039
954, 4039, 4062, 4063, 4040
955, 4040, 4063, 4064, 4041
956, 4041, 4064, 4065, 4042
957, 4042, 4065, 4066, 4043
958, 4043, 4066, 4067, 4044
959, 4044, 4067, 4068, 4045
960, 4045, 4068, 4069, 4046
961, 4046, 4069, 4070, 4047
962, 4047, 4070, 4071, 4048
963, 4048, 4071, 4072, 4049
964, 4049, 4072, 4073, 4050
965, 4050, 4073, 4074, 4051
966, 4051, 4074, 4075, 4052
967, 4052, 4075, 4076, 4053
968, 4053, 4076, 4077, 4054
969, 4054, 4077, 4078, 4055
970, 4055, 4078, 4079, 4056
971, 4056, 4079, 4080, 4057
972, 4057, 4080, 4081, 4058
973, 4058, 4081, 454, 453
974, 294, 295, 4082, 4059
975, 4059, 4082, 4083, 4060
976, 4060, 4083, 4084, 4061
977, 4061, 4084, 4085, 4062
978, 4062, 4085, 4086, 4063
979, 4063, 4086, 4087, 4064
980, 4064, 4087, 4088, 4065
981, 4065, 4088, 4089, 4066
982, 4066, 4089, 4090, 4067
983, 4067, 4090, 4091, 4068
984, 4068, 4091, 4092, 4069
985, 4069, 4092, 4093, 4070
986, 4070, 4093, 4094, 4071
987, 4071, 4094, 4095, 4072
988, 4072, 4095, 4096, 4073
989, 4073, 4096, 4097, 4074
990, 4074, 4097, 4098, 4075
991, 4075, 4098, 4099, 4076
992, 4076, 4099, 4100, 4077
993, 4077, 4100, 4101, 4078
994, 4078, 4101, 4102, 4079
995, 4079, 4102, 4103, 4080
996, 4080, 4103, 4104, 4081
997, 4081, 4104, 455, 454
998, 295, 296, 4105, 4082
999, 4082, 4105, 4106, 4083
1000, 4083, 4106, 4107, 4084
1001, 4084, 4107, 4108, 4085
1002, 4085, 4108, 4109, 4086
1003, 4086, 4109, 4110, 4087
1004, 4087, 4110, 4111, 4088
1005, 4088, 4111, 4112, 4089
1006, 4089, 4112, 4113, 4090
1007, 4090, 4113, 4114, 4091
1008, 4091, 4114, 4115, 4092
1009, 4092, 4115, 4116, 4093
1010, 4093, 4116, 4117, 4094
1011, 4094, 4117, 4118, 4095
1012, 4095, 4118, 4119, 4096
1013, 4096, 4119, 4120, 4097
1014, 4097, 4120, 4121, 4098
1015, 4098, 4121, 4122, 4099
1016, 4099, 4122, 4123, 4100
1017, 4100, 4123, 4124, 4101
1018, 4101, 4124, 4125, 4102
1019, 4102, 4125, 4126, 4103
1020, 4103, 4126, 4127, 4104
1021, 4104, 4127, 456, 455
1022, 296, 297, 4128, 4105
1023, 4105, 4128, 4129, 4106
1024, 4106, 4129, 4130, 4107
1025, 4107, 4130, 4131, 4108
1026, 4108, 4131, 4132, 4109
1027, 4109, 4132, 4133, 4110
1028, 4110, 4133, 4134, 4111
1029, 4111, 4134, 4135, 4112
1030, 4112, 4135, 4136, 4113
1031, 4113, 4136, 4137, 4114
1032, 4114, 4137, 4138, 4115
1033, 4115, 4138, 4139, 4116
1034, 4116, 4139, 4140, 4117
1035, 4117, 4140, 4141, 4118
1036, 4118, 4141, 4142, 4119
1037, 4119, 4142, 4143, 4120
1038, 4120, 4143, 4144, 4121
1039, 4121, 4144, 4145, 4122
1040, 4122, 4145, 4146, 4123
1041, 4123, 4146, 4147, 4124
1042, 4124, 4147, 4148, 4125
1043, 4125, 4148, 4149, 4126
1044, 4126, 4149, 4150, 4127
1045, 4127, 4150, 457, 456
1046, 297, 11, 378, 4128
1047, 4128, 378, 379, 4129
1048, 4129, 379, 380, 4130
1049, 4130, 380, 381, 4131
1050, 4131, 381, 382, 4132
1051, 4132, 382, 383, 4133
1052, 4133, 383, 384, 4134
1053, 4134, 384, 385, 4135
1054, 4135, 385, 386, 4136
1055, 4136, 386, 387, 4137
1056, 4137, 387, 388, 4138
1057, 4138, 388, 389, 4139
1058, 4139, 389, 390, 4140
1059, 4140, 390, 391, 4141
1060, 4141, 391, 392, 4142
1061, 4142, 392, 393, 4143
1062, 4143, 393, 394, 4144
1063, 4144, 394, 395, 4145
1064, 4145, 395, 396, 4146
1065, 4146, 396, 397, 4147
1066, 4147, 397, 398, 4148
1067, 4148, 398, 399, 4149
1068, 4149, 399, 400, 4150
1069, 4150, 400, 15, 457
*ELEMENT, type=CPS4, ELSET=Surface15
35687, 10, 298, 4151, 332
35688, 332, 4151, 4152, 333
35689, 333, 4152, 4153, 334
35690, 334, 4153, 4154, 335
35691, 335, 4154, 4155, 336
35692, 336, 4155, 4156, 337
35693, 337, 4156, 4157, 338
35694, 338, 4157, 4158, 339
35695, 339, 4158, 4159, 340
35696, 340, 4159, 4160, 341
35697, 341, 4160, 4161, 342
35698, 342, 4161, 4162, 343
35699, 343, 4162, 4163, 344
35700, 344, 4163, 4164, 345
35701, 345, 4164, 4165, 346
35702, 346, 4165, 4166, 347
35703, 347, 4166, 4167, 348
35704, 348, 4167, 4168, 349
35705, 349, 4168, 4169, 350
35706, 350, 4169, 4170, 351
35707, 351, 4170, 4171, 352
35708, 352, 4171, 4172, 353
35709, 353, 4172, 4173, 354
35710, 354, 4173, 458, 14
35711, 298, 299, 4174, 4151
35712, 4151, 4174, 4175, 4152
35713, 4152, 4175, 4176, 4153
35714, 4153, 4176, 4177, 4154
35715, 4154, 4177, 4178, 4155
35716, 4155, 4178, 4179, 4156
35717, 4156, 4179, 4180, 4157
35718, 4157, 4180, 4181, 4158
35719, 4158, 4181, 4182, 4159
35720, 4159, 4182, 4183, 4160
35721, 4160, 4183, 4184, 4161
35722, 4161, 4184, 4185, 4162
35723, 4162, 4185, 4186, 4163
35724, 4163, 4186, 4187, 4164
35725, 4164, 4187, 4188, 4165
35726, 4165, 4188, 4189, 4166
35727, 4166, 4189, 4190, 4167
35728, 4167, 4190, 4191, 4168
35729, 4168, 4191, 4192, 4169
35730, 4169, 4192, 4193, 4170
35731, 4170, 4193, 4194, 4171
35732, 4171, 4194, 4195, 4172
35733, 4172, 4195, 4196, 4173
35734, 4173, 4196, 459, 458
35735, 299, 300, 4197, 4174
35736, 4174, 4197, 4198, 4175
35737, 4175, 4198, 4199, 4176
35738, 4176, 4199, 4200, 4177
35739, 4177, 4200, 4201, 4178
35740, 4178, 4201, 4202, 4179
35741, 4179, 4202, 4203, 4180
35742, 4180, 4203, 4204, 4181
35743, 4181, 4204, 4205, 4182
35744, 4182, 4205, 4206, 4183
35745, 4183, 4206, 4207, 4184
35746, 4184, 4207, 4208, 4185
35747, 4185, 4208, 4209, 4186
35748, 4186, 4209, 4210, 4187
35749, 4187, 4210, 4211, 4188
35750, 4188, 4211, 4212, 4189
35751, 4189, 4212, 4213, 4190
35752, 4190, 4213, 4214, 4191
35753, 4191, 4214, 4215, 4192
35754, 4192, 4215, 4216, 4193
35755, 4193, 4216, 4217, 4194
35756, 4194, 4217, 4218, 4195
35757, 4195, 4218, 4219, 4196
35758, 4196, 4219, 460, 459
35759, 300, 301, 4220, 4197
35760, 4197, 4220, 4221, 4198
35761, 4198, 4221, 4222, 4199
35762, 4199, 4222, 4223, 4200
35763, 4200, 4223, 4224, 4201
35764, 4201, 4224, 4225, 4202
35765, 4202, 4225, 4226, 4203
35766, 4203, 4226, 4227, 4204
35767, 4204, 4227, 4228, 4205
35768, 4205, 4228, 4229, 4206
35769, 4206, 4229, 4230, 4207
35770, 4207, 4230, 4231, 4208
35771, 4208, 4231, 4232, 4209
35772, 4209, 4232, 4233, 4210
35773, 4210, 4233, 4234, 4211
35774, 4211, 4234, 4235, 4212
35775, 4212, 4235, 4236, 4213
35776, 4213, 4236, 4237, 4214
35777, 4214, 4237, 4238, 4215
35778, 4215, 4238, 4239, 4216
35779, 4216, 4239, 4240, 4217
35780, 4217, 4240, 4241, 4218
35781, 4218, 4241, 4242, 4219
35782, 4219, 4242, 461, 460
35783, 301, 302, 4243, 4220
35784, 4220, 4243, 4244, 4221
35785, 4221, 4244, 4245, 4222
35786, 4222, 4245, 4246, 4223
