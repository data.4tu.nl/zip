28661, 0.083333333333333, -0.12, 0.41666666666667
28662, 0.083333333333333, -0.16, 0.41666666666667
28663, 0.083333333333333, -0.04, 0.45833333333333
28664, 0.083333333333333, -0.08, 0.45833333333333
28665, 0.083333333333333, -0.12, 0.45833333333333
28666, 0.083333333333333, -0.16, 0.45833333333333
28667, 0.125, -0.04, 0.041666666666667
28668, 0.125, -0.08, 0.041666666666667
28669, 0.125, -0.12, 0.041666666666667
28670, 0.125, -0.16, 0.041666666666667
28671, 0.125, -0.04, 0.083333333333333
28672, 0.125, -0.08, 0.083333333333333
28673, 0.125, -0.12, 0.083333333333333
28674, 0.125, -0.16, 0.083333333333333
28675, 0.125, -0.04, 0.125
28676, 0.125, -0.08, 0.125
28677, 0.125, -0.12, 0.125
28678, 0.125, -0.16, 0.125
28679, 0.125, -0.04, 0.16666666666667
28680, 0.125, -0.08, 0.16666666666667
28681, 0.125, -0.12, 0.16666666666667
28682, 0.125, -0.16, 0.16666666666667
28683, 0.125, -0.04, 0.20833333333333
28684, 0.125, -0.08, 0.20833333333333
28685, 0.125, -0.12, 0.20833333333333
28686, 0.125, -0.16, 0.20833333333333
28687, 0.125, -0.04, 0.25
28688, 0.125, -0.08, 0.25
28689, 0.125, -0.12, 0.25
28690, 0.125, -0.16, 0.25
28691, 0.125, -0.04, 0.29166666666667
28692, 0.125, -0.08, 0.29166666666667
28693, 0.125, -0.12, 0.29166666666667
28694, 0.125, -0.16, 0.29166666666667
28695, 0.125, -0.04, 0.33333333333333
28696, 0.125, -0.08, 0.33333333333333
28697, 0.125, -0.12, 0.33333333333333
28698, 0.125, -0.16, 0.33333333333333
28699, 0.125, -0.04, 0.375
28700, 0.125, -0.08, 0.375
28701, 0.125, -0.12, 0.375
28702, 0.125, -0.16, 0.375
28703, 0.125, -0.04, 0.41666666666667
28704, 0.125, -0.08, 0.41666666666667
28705, 0.125, -0.12, 0.41666666666667
28706, 0.125, -0.16, 0.41666666666667
28707, 0.125, -0.04, 0.45833333333333
28708, 0.125, -0.08, 0.45833333333333
28709, 0.125, -0.12, 0.45833333333333
28710, 0.125, -0.16, 0.45833333333333
28711, 0.16666666666667, -0.04, 0.041666666666667
28712, 0.16666666666667, -0.08, 0.041666666666667
28713, 0.16666666666667, -0.12, 0.041666666666667
28714, 0.16666666666667, -0.16, 0.041666666666667
28715, 0.16666666666667, -0.04, 0.083333333333333
28716, 0.16666666666667, -0.08, 0.083333333333333
28717, 0.16666666666667, -0.12, 0.083333333333333
28718, 0.16666666666667, -0.16, 0.083333333333333
28719, 0.16666666666667, -0.04, 0.125
28720, 0.16666666666667, -0.08, 0.125
28721, 0.16666666666667, -0.12, 0.125
28722, 0.16666666666667, -0.16, 0.125
28723, 0.16666666666667, -0.04, 0.16666666666667
28724, 0.16666666666667, -0.08, 0.16666666666667
28725, 0.16666666666667, -0.12, 0.16666666666667
28726, 0.16666666666667, -0.16, 0.16666666666667
28727, 0.16666666666667, -0.04, 0.20833333333333
28728, 0.16666666666667, -0.08, 0.20833333333333
28729, 0.16666666666667, -0.12, 0.20833333333333
28730, 0.16666666666667, -0.16, 0.20833333333333
28731, 0.16666666666667, -0.04, 0.25
28732, 0.16666666666667, -0.08, 0.25
28733, 0.16666666666667, -0.12, 0.25
28734, 0.16666666666667, -0.16, 0.25
28735, 0.16666666666667, -0.04, 0.29166666666667
28736, 0.16666666666667, -0.08, 0.29166666666667
28737, 0.16666666666667, -0.12, 0.29166666666667
28738, 0.16666666666667, -0.16, 0.29166666666667
28739, 0.16666666666667, -0.04, 0.33333333333333
28740, 0.16666666666667, -0.08, 0.33333333333333
28741, 0.16666666666667, -0.12, 0.33333333333333
28742, 0.16666666666667, -0.16, 0.33333333333333
28743, 0.16666666666667, -0.04, 0.375
28744, 0.16666666666667, -0.08, 0.375
28745, 0.16666666666667, -0.12, 0.375
28746, 0.16666666666667, -0.16, 0.375
28747, 0.16666666666667, -0.04, 0.41666666666667
28748, 0.16666666666667, -0.08, 0.41666666666667
28749, 0.16666666666667, -0.12, 0.41666666666667
28750, 0.16666666666667, -0.16, 0.41666666666667
28751, 0.16666666666667, -0.04, 0.45833333333333
28752, 0.16666666666667, -0.08, 0.45833333333333
28753, 0.16666666666667, -0.12, 0.45833333333333
28754, 0.16666666666667, -0.16, 0.45833333333333
28755, 0.20833333333333, -0.04, 0.041666666666667
28756, 0.20833333333333, -0.08, 0.041666666666667
28757, 0.20833333333333, -0.12, 0.041666666666667
28758, 0.20833333333333, -0.16, 0.041666666666667
28759, 0.20833333333333, -0.04, 0.083333333333333
28760, 0.20833333333333, -0.08, 0.083333333333333
28761, 0.20833333333333, -0.12, 0.083333333333333
28762, 0.20833333333333, -0.16, 0.083333333333333
28763, 0.20833333333333, -0.04, 0.125
28764, 0.20833333333333, -0.08, 0.125
28765, 0.20833333333333, -0.12, 0.125
28766, 0.20833333333333, -0.16, 0.125
28767, 0.20833333333333, -0.04, 0.16666666666667
28768, 0.20833333333333, -0.08, 0.16666666666667
28769, 0.20833333333333, -0.12, 0.16666666666667
28770, 0.20833333333333, -0.16, 0.16666666666667
28771, 0.20833333333333, -0.04, 0.20833333333333
28772, 0.20833333333333, -0.08, 0.20833333333333
28773, 0.20833333333333, -0.12, 0.20833333333333
28774, 0.20833333333333, -0.16, 0.20833333333333
28775, 0.20833333333333, -0.04, 0.25
28776, 0.20833333333333, -0.08, 0.25
28777, 0.20833333333333, -0.12, 0.25
28778, 0.20833333333333, -0.16, 0.25
28779, 0.20833333333333, -0.04, 0.29166666666667
28780, 0.20833333333333, -0.08, 0.29166666666667
28781, 0.20833333333333, -0.12, 0.29166666666667
28782, 0.20833333333333, -0.16, 0.29166666666667
28783, 0.20833333333333, -0.04, 0.33333333333333
28784, 0.20833333333333, -0.08, 0.33333333333333
28785, 0.20833333333333, -0.12, 0.33333333333333
28786, 0.20833333333333, -0.16, 0.33333333333333
28787, 0.20833333333333, -0.04, 0.375
28788, 0.20833333333333, -0.08, 0.375
28789, 0.20833333333333, -0.12, 0.375
28790, 0.20833333333333, -0.16, 0.375
28791, 0.20833333333333, -0.04, 0.41666666666667
28792, 0.20833333333333, -0.08, 0.41666666666667
28793, 0.20833333333333, -0.12, 0.41666666666667
28794, 0.20833333333333, -0.16, 0.41666666666667
28795, 0.20833333333333, -0.04, 0.45833333333333
28796, 0.20833333333333, -0.08, 0.45833333333333
28797, 0.20833333333333, -0.12, 0.45833333333333
28798, 0.20833333333333, -0.16, 0.45833333333333
28799, 0.25, -0.04, 0.041666666666667
28800, 0.25, -0.08, 0.041666666666667
28801, 0.25, -0.12, 0.041666666666667
28802, 0.25, -0.16, 0.041666666666667
28803, 0.25, -0.04, 0.083333333333333
28804, 0.25, -0.08, 0.083333333333333
28805, 0.25, -0.12, 0.083333333333333
28806, 0.25, -0.16, 0.083333333333333
28807, 0.25, -0.04, 0.125
28808, 0.25, -0.08, 0.125
28809, 0.25, -0.12, 0.125
28810, 0.25, -0.16, 0.125
28811, 0.25, -0.04, 0.16666666666667
28812, 0.25, -0.08, 0.16666666666667
28813, 0.25, -0.12, 0.16666666666667
28814, 0.25, -0.16, 0.16666666666667
28815, 0.25, -0.04, 0.20833333333333
28816, 0.25, -0.08, 0.20833333333333
28817, 0.25, -0.12, 0.20833333333333
28818, 0.25, -0.16, 0.20833333333333
28819, 0.25, -0.04, 0.25
28820, 0.25, -0.08, 0.25
28821, 0.25, -0.12, 0.25
28822, 0.25, -0.16, 0.25
28823, 0.25, -0.04, 0.29166666666667
28824, 0.25, -0.08, 0.29166666666667
28825, 0.25, -0.12, 0.29166666666667
28826, 0.25, -0.16, 0.29166666666667
28827, 0.25, -0.04, 0.33333333333333
28828, 0.25, -0.08, 0.33333333333333
28829, 0.25, -0.12, 0.33333333333333
28830, 0.25, -0.16, 0.33333333333333
28831, 0.25, -0.04, 0.375
28832, 0.25, -0.08, 0.375
28833, 0.25, -0.12, 0.375
28834, 0.25, -0.16, 0.375
28835, 0.25, -0.04, 0.41666666666667
28836, 0.25, -0.08, 0.41666666666667
28837, 0.25, -0.12, 0.41666666666667
28838, 0.25, -0.16, 0.41666666666667
28839, 0.25, -0.04, 0.45833333333333
28840, 0.25, -0.08, 0.45833333333333
28841, 0.25, -0.12, 0.45833333333333
28842, 0.25, -0.16, 0.45833333333333
28843, 0.29166666666667, -0.04, 0.041666666666667
28844, 0.29166666666667, -0.08, 0.041666666666667
28845, 0.29166666666667, -0.12, 0.041666666666667
28846, 0.29166666666667, -0.16, 0.041666666666667
28847, 0.29166666666667, -0.04, 0.083333333333333
28848, 0.29166666666667, -0.08, 0.083333333333333
28849, 0.29166666666667, -0.12, 0.083333333333333
28850, 0.29166666666667, -0.16, 0.083333333333333
28851, 0.29166666666667, -0.04, 0.125
28852, 0.29166666666667, -0.08, 0.125
28853, 0.29166666666667, -0.12, 0.125
28854, 0.29166666666667, -0.16, 0.125
28855, 0.29166666666667, -0.04, 0.16666666666667
28856, 0.29166666666667, -0.08, 0.16666666666667
28857, 0.29166666666667, -0.12, 0.16666666666667
28858, 0.29166666666667, -0.16, 0.16666666666667
28859, 0.29166666666667, -0.04, 0.20833333333333
28860, 0.29166666666667, -0.08, 0.20833333333333
28861, 0.29166666666667, -0.12, 0.20833333333333
28862, 0.29166666666667, -0.16, 0.20833333333333
28863, 0.29166666666667, -0.04, 0.25
28864, 0.29166666666667, -0.08, 0.25
28865, 0.29166666666667, -0.12, 0.25
28866, 0.29166666666667, -0.16, 0.25
28867, 0.29166666666667, -0.04, 0.29166666666667
28868, 0.29166666666667, -0.08, 0.29166666666667
28869, 0.29166666666667, -0.12, 0.29166666666667
28870, 0.29166666666667, -0.16, 0.29166666666667
28871, 0.29166666666667, -0.04, 0.33333333333333
28872, 0.29166666666667, -0.08, 0.33333333333333
28873, 0.29166666666667, -0.12, 0.33333333333333
28874, 0.29166666666667, -0.16, 0.33333333333333
28875, 0.29166666666667, -0.04, 0.375
28876, 0.29166666666667, -0.08, 0.375
28877, 0.29166666666667, -0.12, 0.375
28878, 0.29166666666667, -0.16, 0.375
28879, 0.29166666666667, -0.04, 0.41666666666667
28880, 0.29166666666667, -0.08, 0.41666666666667
28881, 0.29166666666667, -0.12, 0.41666666666667
28882, 0.29166666666667, -0.16, 0.41666666666667
28883, 0.29166666666667, -0.04, 0.45833333333333
28884, 0.29166666666667, -0.08, 0.45833333333333
28885, 0.29166666666667, -0.12, 0.45833333333333
28886, 0.29166666666667, -0.16, 0.45833333333333
28887, 0.33333333333333, -0.04, 0.041666666666667
28888, 0.33333333333333, -0.08, 0.041666666666667
28889, 0.33333333333333, -0.12, 0.041666666666667
28890, 0.33333333333333, -0.16, 0.041666666666667
28891, 0.33333333333333, -0.04, 0.083333333333333
28892, 0.33333333333333, -0.08, 0.083333333333333
28893, 0.33333333333333, -0.12, 0.083333333333333
28894, 0.33333333333333, -0.16, 0.083333333333333
28895, 0.33333333333333, -0.04, 0.125
28896, 0.33333333333333, -0.08, 0.125
28897, 0.33333333333333, -0.12, 0.125
28898, 0.33333333333333, -0.16, 0.125
28899, 0.33333333333333, -0.04, 0.16666666666667
28900, 0.33333333333333, -0.08, 0.16666666666667
28901, 0.33333333333333, -0.12, 0.16666666666667
28902, 0.33333333333333, -0.16, 0.16666666666667
28903, 0.33333333333333, -0.04, 0.20833333333333
28904, 0.33333333333333, -0.08, 0.20833333333333
28905, 0.33333333333333, -0.12, 0.20833333333333
28906, 0.33333333333333, -0.16, 0.20833333333333
28907, 0.33333333333333, -0.04, 0.25
28908, 0.33333333333333, -0.08, 0.25
28909, 0.33333333333333, -0.12, 0.25
28910, 0.33333333333333, -0.16, 0.25
28911, 0.33333333333333, -0.04, 0.29166666666667
28912, 0.33333333333333, -0.08, 0.29166666666667
28913, 0.33333333333333, -0.12, 0.29166666666667
28914, 0.33333333333333, -0.16, 0.29166666666667
28915, 0.33333333333333, -0.04, 0.33333333333333
28916, 0.33333333333333, -0.08, 0.33333333333333
28917, 0.33333333333333, -0.12, 0.33333333333333
28918, 0.33333333333333, -0.16, 0.33333333333333
28919, 0.33333333333333, -0.04, 0.375
28920, 0.33333333333333, -0.08, 0.375
28921, 0.33333333333333, -0.12, 0.375
28922, 0.33333333333333, -0.16, 0.375
28923, 0.33333333333333, -0.04, 0.41666666666667
28924, 0.33333333333333, -0.08, 0.41666666666667
28925, 0.33333333333333, -0.12, 0.41666666666667
28926, 0.33333333333333, -0.16, 0.41666666666667
28927, 0.33333333333333, -0.04, 0.45833333333333
28928, 0.33333333333333, -0.08, 0.45833333333333
28929, 0.33333333333333, -0.12, 0.45833333333333
28930, 0.33333333333333, -0.16, 0.45833333333333
28931, 0.375, -0.04, 0.041666666666667
28932, 0.375, -0.08, 0.041666666666667
28933, 0.375, -0.12, 0.041666666666667
28934, 0.375, -0.16, 0.041666666666667
28935, 0.375, -0.04, 0.083333333333333
28936, 0.375, -0.08, 0.083333333333333
28937, 0.375, -0.12, 0.083333333333333
28938, 0.375, -0.16, 0.083333333333333
28939, 0.375, -0.04, 0.125
28940, 0.375, -0.08, 0.125
28941, 0.375, -0.12, 0.125
28942, 0.375, -0.16, 0.125
28943, 0.375, -0.04, 0.16666666666667
28944, 0.375, -0.08, 0.16666666666667
28945, 0.375, -0.12, 0.16666666666667
28946, 0.375, -0.16, 0.16666666666667
28947, 0.375, -0.04, 0.20833333333333
28948, 0.375, -0.08, 0.20833333333333
28949, 0.375, -0.12, 0.20833333333333
28950, 0.375, -0.16, 0.20833333333333
28951, 0.375, -0.04, 0.25
28952, 0.375, -0.08, 0.25
28953, 0.375, -0.12, 0.25
28954, 0.375, -0.16, 0.25
28955, 0.375, -0.04, 0.29166666666667
28956, 0.375, -0.08, 0.29166666666667
28957, 0.375, -0.12, 0.29166666666667
28958, 0.375, -0.16, 0.29166666666667
28959, 0.375, -0.04, 0.33333333333333
28960, 0.375, -0.08, 0.33333333333333
28961, 0.375, -0.12, 0.33333333333333
28962, 0.375, -0.16, 0.33333333333333
28963, 0.375, -0.04, 0.375
28964, 0.375, -0.08, 0.375
28965, 0.375, -0.12, 0.375
28966, 0.375, -0.16, 0.375
28967, 0.375, -0.04, 0.41666666666667
28968, 0.375, -0.08, 0.41666666666667
28969, 0.375, -0.12, 0.41666666666667
28970, 0.375, -0.16, 0.41666666666667
28971, 0.375, -0.04, 0.45833333333333
28972, 0.375, -0.08, 0.45833333333333
28973, 0.375, -0.12, 0.45833333333333
28974, 0.375, -0.16, 0.45833333333333
28975, 0.41666666666667, -0.04, 0.041666666666667
28976, 0.41666666666667, -0.08, 0.041666666666667
28977, 0.41666666666667, -0.12, 0.041666666666667
28978, 0.41666666666667, -0.16, 0.041666666666667
28979, 0.41666666666667, -0.04, 0.083333333333333
28980, 0.41666666666667, -0.08, 0.083333333333333
28981, 0.41666666666667, -0.12, 0.083333333333333
28982, 0.41666666666667, -0.16, 0.083333333333333
28983, 0.41666666666667, -0.04, 0.125
28984, 0.41666666666667, -0.08, 0.125
28985, 0.41666666666667, -0.12, 0.125
28986, 0.41666666666667, -0.16, 0.125
28987, 0.41666666666667, -0.04, 0.16666666666667
28988, 0.41666666666667, -0.08, 0.16666666666667
28989, 0.41666666666667, -0.12, 0.16666666666667
28990, 0.41666666666667, -0.16, 0.16666666666667
28991, 0.41666666666667, -0.04, 0.20833333333333
28992, 0.41666666666667, -0.08, 0.20833333333333
28993, 0.41666666666667, -0.12, 0.20833333333333
28994, 0.41666666666667, -0.16, 0.20833333333333
28995, 0.41666666666667, -0.04, 0.25
28996, 0.41666666666667, -0.08, 0.25
28997, 0.41666666666667, -0.12, 0.25
28998, 0.41666666666667, -0.16, 0.25
28999, 0.41666666666667, -0.04, 0.29166666666667
29000, 0.41666666666667, -0.08, 0.29166666666667
29001, 0.41666666666667, -0.12, 0.29166666666667
29002, 0.41666666666667, -0.16, 0.29166666666667
29003, 0.41666666666667, -0.04, 0.33333333333333
29004, 0.41666666666667, -0.08, 0.33333333333333
29005, 0.41666666666667, -0.12, 0.33333333333333
29006, 0.41666666666667, -0.16, 0.33333333333333
29007, 0.41666666666667, -0.04, 0.375
29008, 0.41666666666667, -0.08, 0.375
29009, 0.41666666666667, -0.12, 0.375
29010, 0.41666666666667, -0.16, 0.375
29011, 0.41666666666667, -0.04, 0.41666666666667
29012, 0.41666666666667, -0.08, 0.41666666666667
29013, 0.41666666666667, -0.12, 0.41666666666667
29014, 0.41666666666667, -0.16, 0.41666666666667
29015, 0.41666666666667, -0.04, 0.45833333333333
29016, 0.41666666666667, -0.08, 0.45833333333333
29017, 0.41666666666667, -0.12, 0.45833333333333
29018, 0.41666666666667, -0.16, 0.45833333333333
29019, 0.45833333333333, -0.04, 0.041666666666667
29020, 0.45833333333333, -0.08, 0.041666666666667
29021, 0.45833333333333, -0.12, 0.041666666666667
29022, 0.45833333333333, -0.16, 0.041666666666667
29023, 0.45833333333333, -0.04, 0.083333333333333
29024, 0.45833333333333, -0.08, 0.083333333333333
29025, 0.45833333333333, -0.12, 0.083333333333333
29026, 0.45833333333333, -0.16, 0.083333333333333
29027, 0.45833333333333, -0.04, 0.125
29028, 0.45833333333333, -0.08, 0.125
29029, 0.45833333333333, -0.12, 0.125
29030, 0.45833333333333, -0.16, 0.125
29031, 0.45833333333333, -0.04, 0.16666666666667
29032, 0.45833333333333, -0.08, 0.16666666666667
29033, 0.45833333333333, -0.12, 0.16666666666667
29034, 0.45833333333333, -0.16, 0.16666666666667
29035, 0.45833333333333, -0.04, 0.20833333333333
29036, 0.45833333333333, -0.08, 0.20833333333333
29037, 0.45833333333333, -0.12, 0.20833333333333
29038, 0.45833333333333, -0.16, 0.20833333333333
29039, 0.45833333333333, -0.04, 0.25
29040, 0.45833333333333, -0.08, 0.25
29041, 0.45833333333333, -0.12, 0.25
29042, 0.45833333333333, -0.16, 0.25
29043, 0.45833333333333, -0.04, 0.29166666666667
29044, 0.45833333333333, -0.08, 0.29166666666667
29045, 0.45833333333333, -0.12, 0.29166666666667
29046, 0.45833333333333, -0.16, 0.29166666666667
29047, 0.45833333333333, -0.04, 0.33333333333333
29048, 0.45833333333333, -0.08, 0.33333333333333
29049, 0.45833333333333, -0.12, 0.33333333333333
29050, 0.45833333333333, -0.16, 0.33333333333333
29051, 0.45833333333333, -0.04, 0.375
29052, 0.45833333333333, -0.08, 0.375
29053, 0.45833333333333, -0.12, 0.375
29054, 0.45833333333333, -0.16, 0.375
29055, 0.45833333333333, -0.04, 0.41666666666667
29056, 0.45833333333333, -0.08, 0.41666666666667
29057, 0.45833333333333, -0.12, 0.41666666666667
29058, 0.45833333333333, -0.16, 0.41666666666667
29059, 0.45833333333333, -0.04, 0.45833333333333
29060, 0.45833333333333, -0.08, 0.45833333333333
29061, 0.45833333333333, -0.12, 0.45833333333333
29062, 0.45833333333333, -0.16, 0.45833333333333
29063, 0.5, -0.04, 0.041666666666667
29064, 0.5, -0.08, 0.041666666666667
29065, 0.5, -0.12, 0.041666666666667
29066, 0.5, -0.16, 0.041666666666667
29067, 0.5, -0.04, 0.083333333333333
29068, 0.5, -0.08, 0.083333333333333
29069, 0.5, -0.12, 0.083333333333333
29070, 0.5, -0.16, 0.083333333333333
29071, 0.5, -0.04, 0.125
29072, 0.5, -0.08, 0.125
29073, 0.5, -0.12, 0.125
29074, 0.5, -0.16, 0.125
29075, 0.5, -0.04, 0.16666666666667
29076, 0.5, -0.08, 0.16666666666667
29077, 0.5, -0.12, 0.16666666666667
29078, 0.5, -0.16, 0.16666666666667
29079, 0.5, -0.04, 0.20833333333333
29080, 0.5, -0.08, 0.20833333333333
29081, 0.5, -0.12, 0.20833333333333
29082, 0.5, -0.16, 0.20833333333333
29083, 0.5, -0.04, 0.25
29084, 0.5, -0.08, 0.25
29085, 0.5, -0.12, 0.25
29086, 0.5, -0.16, 0.25
29087, 0.5, -0.04, 0.29166666666667
29088, 0.5, -0.08, 0.29166666666667
29089, 0.5, -0.12, 0.29166666666667
29090, 0.5, -0.16, 0.29166666666667
29091, 0.5, -0.04, 0.33333333333333
29092, 0.5, -0.08, 0.33333333333333
29093, 0.5, -0.12, 0.33333333333333
29094, 0.5, -0.16, 0.33333333333333
29095, 0.5, -0.04, 0.375
29096, 0.5, -0.08, 0.375
29097, 0.5, -0.12, 0.375
29098, 0.5, -0.16, 0.375
29099, 0.5, -0.04, 0.41666666666667
29100, 0.5, -0.08, 0.41666666666667
29101, 0.5, -0.12, 0.41666666666667
29102, 0.5, -0.16, 0.41666666666667
29103, 0.5, -0.04, 0.45833333333333
29104, 0.5, -0.08, 0.45833333333333
29105, 0.5, -0.12, 0.45833333333333
29106, 0.5, -0.16, 0.45833333333333
29107, 0.54166666666667, -0.04, 0.041666666666667
29108, 0.54166666666667, -0.08, 0.041666666666667
29109, 0.54166666666667, -0.12, 0.041666666666667
29110, 0.54166666666667, -0.16, 0.041666666666667
29111, 0.54166666666667, -0.04, 0.083333333333333
29112, 0.54166666666667, -0.08, 0.083333333333333
29113, 0.54166666666667, -0.12, 0.083333333333333
29114, 0.54166666666667, -0.16, 0.083333333333333
29115, 0.54166666666667, -0.04, 0.125
29116, 0.54166666666667, -0.08, 0.125
29117, 0.54166666666667, -0.12, 0.125
29118, 0.54166666666667, -0.16, 0.125
29119, 0.54166666666667, -0.04, 0.16666666666667
29120, 0.54166666666667, -0.08, 0.16666666666667
29121, 0.54166666666667, -0.12, 0.16666666666667
29122, 0.54166666666667, -0.16, 0.16666666666667
29123, 0.54166666666667, -0.04, 0.20833333333333
29124, 0.54166666666667, -0.08, 0.20833333333333
29125, 0.54166666666667, -0.12, 0.20833333333333
29126, 0.54166666666667, -0.16, 0.20833333333333
29127, 0.54166666666667, -0.04, 0.25
29128, 0.54166666666667, -0.08, 0.25
29129, 0.54166666666667, -0.12, 0.25
29130, 0.54166666666667, -0.16, 0.25
29131, 0.54166666666667, -0.04, 0.29166666666667
29132, 0.54166666666667, -0.08, 0.29166666666667
29133, 0.54166666666667, -0.12, 0.29166666666667
29134, 0.54166666666667, -0.16, 0.29166666666667
29135, 0.54166666666667, -0.04, 0.33333333333333
29136, 0.54166666666667, -0.08, 0.33333333333333
29137, 0.54166666666667, -0.12, 0.33333333333333
29138, 0.54166666666667, -0.16, 0.33333333333333
29139, 0.54166666666667, -0.04, 0.375
29140, 0.54166666666667, -0.08, 0.375
29141, 0.54166666666667, -0.12, 0.375
29142, 0.54166666666667, -0.16, 0.375
29143, 0.54166666666667, -0.04, 0.41666666666667
29144, 0.54166666666667, -0.08, 0.41666666666667
29145, 0.54166666666667, -0.12, 0.41666666666667
29146, 0.54166666666667, -0.16, 0.41666666666667
29147, 0.54166666666667, -0.04, 0.45833333333333
29148, 0.54166666666667, -0.08, 0.45833333333333
29149, 0.54166666666667, -0.12, 0.45833333333333
29150, 0.54166666666667, -0.16, 0.45833333333333
29151, 0.58333333333333, -0.04, 0.041666666666667
29152, 0.58333333333333, -0.08, 0.041666666666667
29153, 0.58333333333333, -0.12, 0.041666666666667
29154, 0.58333333333333, -0.16, 0.041666666666667
29155, 0.58333333333333, -0.04, 0.083333333333333
29156, 0.58333333333333, -0.08, 0.083333333333333
29157, 0.58333333333333, -0.12, 0.083333333333333
29158, 0.58333333333333, -0.16, 0.083333333333333
29159, 0.58333333333333, -0.04, 0.125
29160, 0.58333333333333, -0.08, 0.125
29161, 0.58333333333333, -0.12, 0.125
29162, 0.58333333333333, -0.16, 0.125
29163, 0.58333333333333, -0.04, 0.16666666666667
29164, 0.58333333333333, -0.08, 0.16666666666667
29165, 0.58333333333333, -0.12, 0.16666666666667
29166, 0.58333333333333, -0.16, 0.16666666666667
29167, 0.58333333333333, -0.04, 0.20833333333333
29168, 0.58333333333333, -0.08, 0.20833333333333
29169, 0.58333333333333, -0.12, 0.20833333333333
29170, 0.58333333333333, -0.16, 0.20833333333333
29171, 0.58333333333333, -0.04, 0.25
29172, 0.58333333333333, -0.08, 0.25
29173, 0.58333333333333, -0.12, 0.25
29174, 0.58333333333333, -0.16, 0.25
29175, 0.58333333333333, -0.04, 0.29166666666667
29176, 0.58333333333333, -0.08, 0.29166666666667
29177, 0.58333333333333, -0.12, 0.29166666666667
29178, 0.58333333333333, -0.16, 0.29166666666667
29179, 0.58333333333333, -0.04, 0.33333333333333
29180, 0.58333333333333, -0.08, 0.33333333333333
29181, 0.58333333333333, -0.12, 0.33333333333333
29182, 0.58333333333333, -0.16, 0.33333333333333
29183, 0.58333333333333, -0.04, 0.375
29184, 0.58333333333333, -0.08, 0.375
29185, 0.58333333333333, -0.12, 0.375
29186, 0.58333333333333, -0.16, 0.375
29187, 0.58333333333333, -0.04, 0.41666666666667
29188, 0.58333333333333, -0.08, 0.41666666666667
29189, 0.58333333333333, -0.12, 0.41666666666667
29190, 0.58333333333333, -0.16, 0.41666666666667
29191, 0.58333333333333, -0.04, 0.45833333333333
29192, 0.58333333333333, -0.08, 0.45833333333333
29193, 0.58333333333333, -0.12, 0.45833333333333
29194, 0.58333333333333, -0.16, 0.45833333333333
29195, 0.625, -0.04, 0.041666666666667
29196, 0.625, -0.08, 0.041666666666667
29197, 0.625, -0.12, 0.041666666666667
29198, 0.625, -0.16, 0.041666666666667
29199, 0.625, -0.04, 0.083333333333333
29200, 0.625, -0.08, 0.083333333333333
29201, 0.625, -0.12, 0.083333333333333
29202, 0.625, -0.16, 0.083333333333333
29203, 0.625, -0.04, 0.125
29204, 0.625, -0.08, 0.125
29205, 0.625, -0.12, 0.125
29206, 0.625, -0.16, 0.125
29207, 0.625, -0.04, 0.16666666666667
29208, 0.625, -0.08, 0.16666666666667
29209, 0.625, -0.12, 0.16666666666667
29210, 0.625, -0.16, 0.16666666666667
29211, 0.625, -0.04, 0.20833333333333
29212, 0.625, -0.08, 0.20833333333333
29213, 0.625, -0.12, 0.20833333333333
29214, 0.625, -0.16, 0.20833333333333
29215, 0.625, -0.04, 0.25
29216, 0.625, -0.08, 0.25
29217, 0.625, -0.12, 0.25
29218, 0.625, -0.16, 0.25
29219, 0.625, -0.04, 0.29166666666667
29220, 0.625, -0.08, 0.29166666666667
29221, 0.625, -0.12, 0.29166666666667
29222, 0.625, -0.16, 0.29166666666667
29223, 0.625, -0.04, 0.33333333333333
29224, 0.625, -0.08, 0.33333333333333
29225, 0.625, -0.12, 0.33333333333333
29226, 0.625, -0.16, 0.33333333333333
29227, 0.625, -0.04, 0.375
29228, 0.625, -0.08, 0.375
29229, 0.625, -0.12, 0.375
29230, 0.625, -0.16, 0.375
29231, 0.625, -0.04, 0.41666666666667
29232, 0.625, -0.08, 0.41666666666667
29233, 0.625, -0.12, 0.41666666666667
29234, 0.625, -0.16, 0.41666666666667
29235, 0.625, -0.04, 0.45833333333333
29236, 0.625, -0.08, 0.45833333333333
29237, 0.625, -0.12, 0.45833333333333
29238, 0.625, -0.16, 0.45833333333333
29239, 0.66666666666667, -0.04, 0.041666666666667
29240, 0.66666666666667, -0.08, 0.041666666666667
29241, 0.66666666666667, -0.12, 0.041666666666667
29242, 0.66666666666667, -0.16, 0.041666666666667
29243, 0.66666666666667, -0.04, 0.083333333333333
29244, 0.66666666666667, -0.08, 0.083333333333333
29245, 0.66666666666667, -0.12, 0.083333333333333
29246, 0.66666666666667, -0.16, 0.083333333333333
29247, 0.66666666666667, -0.04, 0.125
29248, 0.66666666666667, -0.08, 0.125
29249, 0.66666666666667, -0.12, 0.125
29250, 0.66666666666667, -0.16, 0.125
29251, 0.66666666666667, -0.04, 0.16666666666667
29252, 0.66666666666667, -0.08, 0.16666666666667
29253, 0.66666666666667, -0.12, 0.16666666666667
29254, 0.66666666666667, -0.16, 0.16666666666667
29255, 0.66666666666667, -0.04, 0.20833333333333
29256, 0.66666666666667, -0.08, 0.20833333333333
29257, 0.66666666666667, -0.12, 0.20833333333333
29258, 0.66666666666667, -0.16, 0.20833333333333
29259, 0.66666666666667, -0.04, 0.25
29260, 0.66666666666667, -0.08, 0.25
29261, 0.66666666666667, -0.12, 0.25
29262, 0.66666666666667, -0.16, 0.25
29263, 0.66666666666667, -0.04, 0.29166666666667
29264, 0.66666666666667, -0.08, 0.29166666666667
29265, 0.66666666666667, -0.12, 0.29166666666667
29266, 0.66666666666667, -0.16, 0.29166666666667
29267, 0.66666666666667, -0.04, 0.33333333333333
29268, 0.66666666666667, -0.08, 0.33333333333333
29269, 0.66666666666667, -0.12, 0.33333333333333
29270, 0.66666666666667, -0.16, 0.33333333333333
29271, 0.66666666666667, -0.04, 0.375
29272, 0.66666666666667, -0.08, 0.375
29273, 0.66666666666667, -0.12, 0.375
29274, 0.66666666666667, -0.16, 0.375
29275, 0.66666666666667, -0.04, 0.41666666666667
29276, 0.66666666666667, -0.08, 0.41666666666667
29277, 0.66666666666667, -0.12, 0.41666666666667
29278, 0.66666666666667, -0.16, 0.41666666666667
29279, 0.66666666666667, -0.04, 0.45833333333333
29280, 0.66666666666667, -0.08, 0.45833333333333
29281, 0.66666666666667, -0.12, 0.45833333333333
29282, 0.66666666666667, -0.16, 0.45833333333333
29283, 0.70833333333333, -0.04, 0.041666666666667
29284, 0.70833333333333, -0.08, 0.041666666666667
29285, 0.70833333333333, -0.12, 0.041666666666667
29286, 0.70833333333333, -0.16, 0.041666666666667
29287, 0.70833333333333, -0.04, 0.083333333333333
29288, 0.70833333333333, -0.08, 0.083333333333333
29289, 0.70833333333333, -0.12, 0.083333333333333
29290, 0.70833333333333, -0.16, 0.083333333333333
29291, 0.70833333333333, -0.04, 0.125
29292, 0.70833333333333, -0.08, 0.125
29293, 0.70833333333333, -0.12, 0.125
29294, 0.70833333333333, -0.16, 0.125
29295, 0.70833333333333, -0.04, 0.16666666666667
29296, 0.70833333333333, -0.08, 0.16666666666667
29297, 0.70833333333333, -0.12, 0.16666666666667
29298, 0.70833333333333, -0.16, 0.16666666666667
29299, 0.70833333333333, -0.04, 0.20833333333333
29300, 0.70833333333333, -0.08, 0.20833333333333
29301, 0.70833333333333, -0.12, 0.20833333333333
29302, 0.70833333333333, -0.16, 0.20833333333333
29303, 0.70833333333333, -0.04, 0.25
29304, 0.70833333333333, -0.08, 0.25
29305, 0.70833333333333, -0.12, 0.25
29306, 0.70833333333333, -0.16, 0.25
29307, 0.70833333333333, -0.04, 0.29166666666667
29308, 0.70833333333333, -0.08, 0.29166666666667
29309, 0.70833333333333, -0.12, 0.29166666666667
29310, 0.70833333333333, -0.16, 0.29166666666667
29311, 0.70833333333333, -0.04, 0.33333333333333
29312, 0.70833333333333, -0.08, 0.33333333333333
29313, 0.70833333333333, -0.12, 0.33333333333333
29314, 0.70833333333333, -0.16, 0.33333333333333
29315, 0.70833333333333, -0.04, 0.375
29316, 0.70833333333333, -0.08, 0.375
29317, 0.70833333333333, -0.12, 0.375
29318, 0.70833333333333, -0.16, 0.375
29319, 0.70833333333333, -0.04, 0.41666666666667
29320, 0.70833333333333, -0.08, 0.41666666666667
29321, 0.70833333333333, -0.12, 0.41666666666667
29322, 0.70833333333333, -0.16, 0.41666666666667
29323, 0.70833333333333, -0.04, 0.45833333333333
29324, 0.70833333333333, -0.08, 0.45833333333333
29325, 0.70833333333333, -0.12, 0.45833333333333
29326, 0.70833333333333, -0.16, 0.45833333333333
29327, 0.75, -0.04, 0.041666666666667
29328, 0.75, -0.08, 0.041666666666667
29329, 0.75, -0.12, 0.041666666666667
29330, 0.75, -0.16, 0.041666666666667
29331, 0.75, -0.04, 0.083333333333333
29332, 0.75, -0.08, 0.083333333333333
29333, 0.75, -0.12, 0.083333333333333
29334, 0.75, -0.16, 0.083333333333333
29335, 0.75, -0.04, 0.125
29336, 0.75, -0.08, 0.125
29337, 0.75, -0.12, 0.125
29338, 0.75, -0.16, 0.125
29339, 0.75, -0.04, 0.16666666666667
29340, 0.75, -0.08, 0.16666666666667
29341, 0.75, -0.12, 0.16666666666667
29342, 0.75, -0.16, 0.16666666666667
29343, 0.75, -0.04, 0.20833333333333
29344, 0.75, -0.08, 0.20833333333333
29345, 0.75, -0.12, 0.20833333333333
29346, 0.75, -0.16, 0.20833333333333
29347, 0.75, -0.04, 0.25
29348, 0.75, -0.08, 0.25
29349, 0.75, -0.12, 0.25
29350, 0.75, -0.16, 0.25
29351, 0.75, -0.04, 0.29166666666667
29352, 0.75, -0.08, 0.29166666666667
29353, 0.75, -0.12, 0.29166666666667
29354, 0.75, -0.16, 0.29166666666667
29355, 0.75, -0.04, 0.33333333333333
29356, 0.75, -0.08, 0.33333333333333
29357, 0.75, -0.12, 0.33333333333333
29358, 0.75, -0.16, 0.33333333333333
29359, 0.75, -0.04, 0.375
29360, 0.75, -0.08, 0.375
29361, 0.75, -0.12, 0.375
29362, 0.75, -0.16, 0.375
29363, 0.75, -0.04, 0.41666666666667
29364, 0.75, -0.08, 0.41666666666667
29365, 0.75, -0.12, 0.41666666666667
29366, 0.75, -0.16, 0.41666666666667
29367, 0.75, -0.04, 0.45833333333333
29368, 0.75, -0.08, 0.45833333333333
29369, 0.75, -0.12, 0.45833333333333
29370, 0.75, -0.16, 0.45833333333333
29371, 0.79166666666667, -0.04, 0.041666666666667
29372, 0.79166666666667, -0.08, 0.041666666666667
29373, 0.79166666666667, -0.12, 0.041666666666667
29374, 0.79166666666667, -0.16, 0.041666666666667
29375, 0.79166666666667, -0.04, 0.083333333333333
29376, 0.79166666666667, -0.08, 0.083333333333333
29377, 0.79166666666667, -0.12, 0.083333333333333
29378, 0.79166666666667, -0.16, 0.083333333333333
29379, 0.79166666666667, -0.04, 0.125
29380, 0.79166666666667, -0.08, 0.125
29381, 0.79166666666667, -0.12, 0.125
29382, 0.79166666666667, -0.16, 0.125
29383, 0.79166666666667, -0.04, 0.16666666666667
29384, 0.79166666666667, -0.08, 0.16666666666667
29385, 0.79166666666667, -0.12, 0.16666666666667
29386, 0.79166666666667, -0.16, 0.16666666666667
29387, 0.79166666666667, -0.04, 0.20833333333333
29388, 0.79166666666667, -0.08, 0.20833333333333
29389, 0.79166666666667, -0.12, 0.20833333333333
29390, 0.79166666666667, -0.16, 0.20833333333333
29391, 0.79166666666667, -0.04, 0.25
29392, 0.79166666666667, -0.08, 0.25
29393, 0.79166666666667, -0.12, 0.25
29394, 0.79166666666667, -0.16, 0.25
29395, 0.79166666666667, -0.04, 0.29166666666667
29396, 0.79166666666667, -0.08, 0.29166666666667
29397, 0.79166666666667, -0.12, 0.29166666666667
29398, 0.79166666666667, -0.16, 0.29166666666667
29399, 0.79166666666667, -0.04, 0.33333333333333
29400, 0.79166666666667, -0.08, 0.33333333333333
29401, 0.79166666666667, -0.12, 0.33333333333333
29402, 0.79166666666667, -0.16, 0.33333333333333
29403, 0.79166666666667, -0.04, 0.375
29404, 0.79166666666667, -0.08, 0.375
29405, 0.79166666666667, -0.12, 0.375
29406, 0.79166666666667, -0.16, 0.375
29407, 0.79166666666667, -0.04, 0.41666666666667
29408, 0.79166666666667, -0.08, 0.41666666666667
29409, 0.79166666666667, -0.12, 0.41666666666667
29410, 0.79166666666667, -0.16, 0.41666666666667
29411, 0.79166666666667, -0.04, 0.45833333333333
29412, 0.79166666666667, -0.08, 0.45833333333333
29413, 0.79166666666667, -0.12, 0.45833333333333
29414, 0.79166666666667, -0.16, 0.45833333333333
29415, 0.83333333333333, -0.04, 0.041666666666667
29416, 0.83333333333333, -0.08, 0.041666666666667
29417, 0.83333333333333, -0.12, 0.041666666666667
29418, 0.83333333333333, -0.16, 0.041666666666667
29419, 0.83333333333333, -0.04, 0.083333333333333
29420, 0.83333333333333, -0.08, 0.083333333333333
29421, 0.83333333333333, -0.12, 0.083333333333333
29422, 0.83333333333333, -0.16, 0.083333333333333
29423, 0.83333333333333, -0.04, 0.125
29424, 0.83333333333333, -0.08, 0.125
29425, 0.83333333333333, -0.12, 0.125
29426, 0.83333333333333, -0.16, 0.125
29427, 0.83333333333333, -0.04, 0.16666666666667
29428, 0.83333333333333, -0.08, 0.16666666666667
29429, 0.83333333333333, -0.12, 0.16666666666667
29430, 0.83333333333333, -0.16, 0.16666666666667
29431, 0.83333333333333, -0.04, 0.20833333333333
29432, 0.83333333333333, -0.08, 0.20833333333333
29433, 0.83333333333333, -0.12, 0.20833333333333
29434, 0.83333333333333, -0.16, 0.20833333333333
29435, 0.83333333333333, -0.04, 0.25
29436, 0.83333333333333, -0.08, 0.25
29437, 0.83333333333333, -0.12, 0.25
29438, 0.83333333333333, -0.16, 0.25
29439, 0.83333333333333, -0.04, 0.29166666666667
29440, 0.83333333333333, -0.08, 0.29166666666667
29441, 0.83333333333333, -0.12, 0.29166666666667
29442, 0.83333333333333, -0.16, 0.29166666666667
29443, 0.83333333333333, -0.04, 0.33333333333333
29444, 0.83333333333333, -0.08, 0.33333333333333
29445, 0.83333333333333, -0.12, 0.33333333333333
29446, 0.83333333333333, -0.16, 0.33333333333333
29447, 0.83333333333333, -0.04, 0.375
29448, 0.83333333333333, -0.08, 0.375
29449, 0.83333333333333, -0.12, 0.375
29450, 0.83333333333333, -0.16, 0.375
29451, 0.83333333333333, -0.04, 0.41666666666667
29452, 0.83333333333333, -0.08, 0.41666666666667
29453, 0.83333333333333, -0.12, 0.41666666666667
29454, 0.83333333333333, -0.16, 0.41666666666667
29455, 0.83333333333333, -0.04, 0.45833333333333
29456, 0.83333333333333, -0.08, 0.45833333333333
29457, 0.83333333333333, -0.12, 0.45833333333333
29458, 0.83333333333333, -0.16, 0.45833333333333
29459, 0.875, -0.04, 0.041666666666667
29460, 0.875, -0.08, 0.041666666666667
29461, 0.875, -0.12, 0.041666666666667
29462, 0.875, -0.16, 0.041666666666667
29463, 0.875, -0.04, 0.083333333333333
29464, 0.875, -0.08, 0.083333333333333
29465, 0.875, -0.12, 0.083333333333333
29466, 0.875, -0.16, 0.083333333333333
29467, 0.875, -0.04, 0.125
29468, 0.875, -0.08, 0.125
29469, 0.875, -0.12, 0.125
29470, 0.875, -0.16, 0.125
29471, 0.875, -0.04, 0.16666666666667
29472, 0.875, -0.08, 0.16666666666667
29473, 0.875, -0.12, 0.16666666666667
29474, 0.875, -0.16, 0.16666666666667
29475, 0.875, -0.04, 0.20833333333333
29476, 0.875, -0.08, 0.20833333333333
29477, 0.875, -0.12, 0.20833333333333
29478, 0.875, -0.16, 0.20833333333333
29479, 0.875, -0.04, 0.25
29480, 0.875, -0.08, 0.25
29481, 0.875, -0.12, 0.25
29482, 0.875, -0.16, 0.25
29483, 0.875, -0.04, 0.29166666666667
29484, 0.875, -0.08, 0.29166666666667
29485, 0.875, -0.12, 0.29166666666667
29486, 0.875, -0.16, 0.29166666666667
29487, 0.875, -0.04, 0.33333333333333
29488, 0.875, -0.08, 0.33333333333333
29489, 0.875, -0.12, 0.33333333333333
29490, 0.875, -0.16, 0.33333333333333
29491, 0.875, -0.04, 0.375
29492, 0.875, -0.08, 0.375
29493, 0.875, -0.12, 0.375
29494, 0.875, -0.16, 0.375
29495, 0.875, -0.04, 0.41666666666667
29496, 0.875, -0.08, 0.41666666666667
29497, 0.875, -0.12, 0.41666666666667
29498, 0.875, -0.16, 0.41666666666667
29499, 0.875, -0.04, 0.45833333333333
29500, 0.875, -0.08, 0.45833333333333
29501, 0.875, -0.12, 0.45833333333333
29502, 0.875, -0.16, 0.45833333333333
29503, 0.91666666666667, -0.04, 0.041666666666667
29504, 0.91666666666667, -0.08, 0.041666666666667
29505, 0.91666666666667, -0.12, 0.041666666666667
29506, 0.91666666666667, -0.16, 0.041666666666667
29507, 0.91666666666667, -0.04, 0.083333333333333
29508, 0.91666666666667, -0.08, 0.083333333333333
29509, 0.91666666666667, -0.12, 0.083333333333333
29510, 0.91666666666667, -0.16, 0.083333333333333
29511, 0.91666666666667, -0.04, 0.125
29512, 0.91666666666667, -0.08, 0.125
29513, 0.91666666666667, -0.12, 0.125
29514, 0.91666666666667, -0.16, 0.125
29515, 0.91666666666667, -0.04, 0.16666666666667
29516, 0.91666666666667, -0.08, 0.16666666666667
29517, 0.91666666666667, -0.12, 0.16666666666667
29518, 0.91666666666667, -0.16, 0.16666666666667
29519, 0.91666666666667, -0.04, 0.20833333333333
29520, 0.91666666666667, -0.08, 0.20833333333333
29521, 0.91666666666667, -0.12, 0.20833333333333
29522, 0.91666666666667, -0.16, 0.20833333333333
29523, 0.91666666666667, -0.04, 0.25
29524, 0.91666666666667, -0.08, 0.25
29525, 0.91666666666667, -0.12, 0.25
29526, 0.91666666666667, -0.16, 0.25
29527, 0.91666666666667, -0.04, 0.29166666666667
29528, 0.91666666666667, -0.08, 0.29166666666667
29529, 0.91666666666667, -0.12, 0.29166666666667
29530, 0.91666666666667, -0.16, 0.29166666666667
29531, 0.91666666666667, -0.04, 0.33333333333333
29532, 0.91666666666667, -0.08, 0.33333333333333
29533, 0.91666666666667, -0.12, 0.33333333333333
29534, 0.91666666666667, -0.16, 0.33333333333333
29535, 0.91666666666667, -0.04, 0.375
29536, 0.91666666666667, -0.08, 0.375
29537, 0.91666666666667, -0.12, 0.375
29538, 0.91666666666667, -0.16, 0.375
29539, 0.91666666666667, -0.04, 0.41666666666667
29540, 0.91666666666667, -0.08, 0.41666666666667
29541, 0.91666666666667, -0.12, 0.41666666666667
29542, 0.91666666666667, -0.16, 0.41666666666667
29543, 0.91666666666667, -0.04, 0.45833333333333
29544, 0.91666666666667, -0.08, 0.45833333333333
29545, 0.91666666666667, -0.12, 0.45833333333333
29546, 0.91666666666667, -0.16, 0.45833333333333
29547, 0.95833333333333, -0.04, 0.041666666666667
29548, 0.95833333333333, -0.08, 0.041666666666667
29549, 0.95833333333333, -0.12, 0.041666666666667
29550, 0.95833333333333, -0.16, 0.041666666666667
29551, 0.95833333333333, -0.04, 0.083333333333333
29552, 0.95833333333333, -0.08, 0.083333333333333
29553, 0.95833333333333, -0.12, 0.083333333333333
29554, 0.95833333333333, -0.16, 0.083333333333333
29555, 0.95833333333333, -0.04, 0.125
29556, 0.95833333333333, -0.08, 0.125
29557, 0.95833333333333, -0.12, 0.125
29558, 0.95833333333333, -0.16, 0.125
29559, 0.95833333333333, -0.04, 0.16666666666667
29560, 0.95833333333333, -0.08, 0.16666666666667
29561, 0.95833333333333, -0.12, 0.16666666666667
29562, 0.95833333333333, -0.16, 0.16666666666667
29563, 0.95833333333333, -0.04, 0.20833333333333
29564, 0.95833333333333, -0.08, 0.20833333333333
29565, 0.95833333333333, -0.12, 0.20833333333333
29566, 0.95833333333333, -0.16, 0.20833333333333
29567, 0.95833333333333, -0.04, 0.25
29568, 0.95833333333333, -0.08, 0.25
29569, 0.95833333333333, -0.12, 0.25
29570, 0.95833333333333, -0.16, 0.25
29571, 0.95833333333333, -0.04, 0.29166666666667
29572, 0.95833333333333, -0.08, 0.29166666666667
29573, 0.95833333333333, -0.12, 0.29166666666667
29574, 0.95833333333333, -0.16, 0.29166666666667
29575, 0.95833333333333, -0.04, 0.33333333333333
29576, 0.95833333333333, -0.08, 0.33333333333333
29577, 0.95833333333333, -0.12, 0.33333333333333
29578, 0.95833333333333, -0.16, 0.33333333333333
29579, 0.95833333333333, -0.04, 0.375
29580, 0.95833333333333, -0.08, 0.375
29581, 0.95833333333333, -0.12, 0.375
29582, 0.95833333333333, -0.16, 0.375
29583, 0.95833333333333, -0.04, 0.41666666666667
29584, 0.95833333333333, -0.08, 0.41666666666667
29585, 0.95833333333333, -0.12, 0.41666666666667
29586, 0.95833333333333, -0.16, 0.41666666666667
29587, 0.95833333333333, -0.04, 0.45833333333333
29588, 0.95833333333333, -0.08, 0.45833333333333
29589, 0.95833333333333, -0.12, 0.45833333333333
29590, 0.95833333333333, -0.16, 0.45833333333333
29591, 1.2416666666667, -0.04, 0.041666666666667
29592, 1.2416666666667, -0.08, 0.041666666666667
29593, 1.2416666666667, -0.12, 0.041666666666667
29594, 1.2416666666667, -0.16, 0.041666666666667
29595, 1.2833333333333, -0.04, 0.041666666666667
29596, 1.2833333333333, -0.08, 0.041666666666667
29597, 1.2833333333333, -0.12, 0.041666666666667
29598, 1.2833333333333, -0.16, 0.041666666666667
29599, 1.325, -0.04, 0.041666666666667
29600, 1.325, -0.08, 0.041666666666667
29601, 1.325, -0.12, 0.041666666666667
29602, 1.325, -0.16, 0.041666666666667
29603, 1.3666666666667, -0.04, 0.041666666666667
29604, 1.3666666666667, -0.08, 0.041666666666667
29605, 1.3666666666667, -0.12, 0.041666666666667
29606, 1.3666666666667, -0.16, 0.041666666666667
29607, 1.4083333333333, -0.04, 0.041666666666667
29608, 1.4083333333333, -0.08, 0.041666666666667
29609, 1.4083333333333, -0.12, 0.041666666666667
29610, 1.4083333333333, -0.16, 0.041666666666667
29611, 1.45, -0.04, 0.041666666666667
29612, 1.45, -0.08, 0.041666666666667
29613, 1.45, -0.12, 0.041666666666667
29614, 1.45, -0.16, 0.041666666666667
29615, 1.4916666666667, -0.04, 0.041666666666667
29616, 1.4916666666667, -0.08, 0.041666666666667
29617, 1.4916666666667, -0.12, 0.041666666666667
29618, 1.4916666666667, -0.16, 0.041666666666667
29619, 1.5333333333333, -0.04, 0.041666666666667
29620, 1.5333333333333, -0.08, 0.041666666666667
29621, 1.5333333333333, -0.12, 0.041666666666667
29622, 1.5333333333333, -0.16, 0.041666666666667
29623, 1.575, -0.04, 0.041666666666667
29624, 1.575, -0.08, 0.041666666666667
29625, 1.575, -0.12, 0.041666666666667
29626, 1.575, -0.16, 0.041666666666667
29627, 1.6166666666667, -0.04, 0.041666666666667
29628, 1.6166666666667, -0.08, 0.041666666666667
29629, 1.6166666666667, -0.12, 0.041666666666667
29630, 1.6166666666667, -0.16, 0.041666666666667
29631, 1.6583333333333, -0.04, 0.041666666666667
29632, 1.6583333333333, -0.08, 0.041666666666667
29633, 1.6583333333333, -0.12, 0.041666666666667
29634, 1.6583333333333, -0.16, 0.041666666666667
29635, 1.7, -0.04, 0.041666666666667
29636, 1.7, -0.08, 0.041666666666667
29637, 1.7, -0.12, 0.041666666666667
29638, 1.7, -0.16, 0.041666666666667
29639, 1.7416666666667, -0.04, 0.041666666666667
29640, 1.7416666666667, -0.08, 0.041666666666667
29641, 1.7416666666667, -0.12, 0.041666666666667
29642, 1.7416666666667, -0.16, 0.041666666666667
29643, 1.7833333333333, -0.04, 0.041666666666667
29644, 1.7833333333333, -0.08, 0.041666666666667
29645, 1.7833333333333, -0.12, 0.041666666666667
29646, 1.7833333333333, -0.16, 0.041666666666667
29647, 1.825, -0.04, 0.041666666666667
29648, 1.825, -0.08, 0.041666666666667
29649, 1.825, -0.12, 0.041666666666667
29650, 1.825, -0.16, 0.041666666666667
29651, 1.8666666666667, -0.04, 0.041666666666667
29652, 1.8666666666667, -0.08, 0.041666666666667
29653, 1.8666666666667, -0.12, 0.041666666666667
29654, 1.8666666666667, -0.16, 0.041666666666667
29655, 1.9083333333333, -0.04, 0.041666666666667
29656, 1.9083333333333, -0.08, 0.041666666666667
29657, 1.9083333333333, -0.12, 0.041666666666667
29658, 1.9083333333333, -0.16, 0.041666666666667
29659, 1.95, -0.04, 0.041666666666667
29660, 1.95, -0.08, 0.041666666666667
29661, 1.95, -0.12, 0.041666666666667
29662, 1.95, -0.16, 0.041666666666667
29663, 1.9916666666667, -0.04, 0.041666666666667
29664, 1.9916666666667, -0.08, 0.041666666666667
29665, 1.9916666666667, -0.12, 0.041666666666667
29666, 1.9916666666667, -0.16, 0.041666666666667
29667, 2.0333333333333, -0.04, 0.041666666666667
29668, 2.0333333333333, -0.08, 0.041666666666667
29669, 2.0333333333333, -0.12, 0.041666666666667
29670, 2.0333333333333, -0.16, 0.041666666666667
29671, 2.075, -0.04, 0.041666666666667
29672, 2.075, -0.08, 0.041666666666667
29673, 2.075, -0.12, 0.041666666666667
29674, 2.075, -0.16, 0.041666666666667
29675, 2.1166666666667, -0.04, 0.041666666666667
29676, 2.1166666666667, -0.08, 0.041666666666667
29677, 2.1166666666667, -0.12, 0.041666666666667
29678, 2.1166666666667, -0.16, 0.041666666666667
29679, 2.1583333333333, -0.04, 0.041666666666667
29680, 2.1583333333333, -0.08, 0.041666666666667
29681, 2.1583333333333, -0.12, 0.041666666666667
29682, 2.1583333333333, -0.16, 0.041666666666667
29683, 1.2416666666667, -0.04, 0.083333333333333
29684, 1.2416666666667, -0.08, 0.083333333333333
29685, 1.2416666666667, -0.12, 0.083333333333333
29686, 1.2416666666667, -0.16, 0.083333333333333
29687, 1.2833333333333, -0.04, 0.083333333333333
29688, 1.2833333333333, -0.08, 0.083333333333333
29689, 1.2833333333333, -0.12, 0.083333333333333
29690, 1.2833333333333, -0.16, 0.083333333333333
29691, 1.325, -0.04, 0.083333333333333
29692, 1.325, -0.08, 0.083333333333333
29693, 1.325, -0.12, 0.083333333333333
29694, 1.325, -0.16, 0.083333333333333
29695, 1.3666666666667, -0.04, 0.083333333333333
29696, 1.3666666666667, -0.08, 0.083333333333333
29697, 1.3666666666667, -0.12, 0.083333333333333
29698, 1.3666666666667, -0.16, 0.083333333333333
29699, 1.4083333333333, -0.04, 0.083333333333333
29700, 1.4083333333333, -0.08, 0.083333333333333
29701, 1.4083333333333, -0.12, 0.083333333333333
29702, 1.4083333333333, -0.16, 0.083333333333333
29703, 1.45, -0.04, 0.083333333333333
29704, 1.45, -0.08, 0.083333333333333
29705, 1.45, -0.12, 0.083333333333333
29706, 1.45, -0.16, 0.083333333333333
29707, 1.4916666666667, -0.04, 0.083333333333333
29708, 1.4916666666667, -0.08, 0.083333333333333
29709, 1.4916666666667, -0.12, 0.083333333333333
29710, 1.4916666666667, -0.16, 0.083333333333333
29711, 1.5333333333333, -0.04, 0.083333333333333
29712, 1.5333333333333, -0.08, 0.083333333333333
29713, 1.5333333333333, -0.12, 0.083333333333333
29714, 1.5333333333333, -0.16, 0.083333333333333
29715, 1.575, -0.04, 0.083333333333333
29716, 1.575, -0.08, 0.083333333333333
29717, 1.575, -0.12, 0.083333333333333
29718, 1.575, -0.16, 0.083333333333333
29719, 1.6166666666667, -0.04, 0.083333333333333
29720, 1.6166666666667, -0.08, 0.083333333333333
29721, 1.6166666666667, -0.12, 0.083333333333333
29722, 1.6166666666667, -0.16, 0.083333333333333
29723, 1.6583333333333, -0.04, 0.083333333333333
29724, 1.6583333333333, -0.08, 0.083333333333333
29725, 1.6583333333333, -0.12, 0.083333333333333
29726, 1.6583333333333, -0.16, 0.083333333333333
29727, 1.7, -0.04, 0.083333333333333
29728, 1.7, -0.08, 0.083333333333333
29729, 1.7, -0.12, 0.083333333333333
29730, 1.7, -0.16, 0.083333333333333
29731, 1.7416666666667, -0.04, 0.083333333333333
29732, 1.7416666666667, -0.08, 0.083333333333333
29733, 1.7416666666667, -0.12, 0.083333333333333
29734, 1.7416666666667, -0.16, 0.083333333333333
29735, 1.7833333333333, -0.04, 0.083333333333333
29736, 1.7833333333333, -0.08, 0.083333333333333
29737, 1.7833333333333, -0.12, 0.083333333333333
29738, 1.7833333333333, -0.16, 0.083333333333333
29739, 1.825, -0.04, 0.083333333333333
29740, 1.825, -0.08, 0.083333333333333
29741, 1.825, -0.12, 0.083333333333333
29742, 1.825, -0.16, 0.083333333333333
29743, 1.8666666666667, -0.04, 0.083333333333333
29744, 1.8666666666667, -0.08, 0.083333333333333
29745, 1.8666666666667, -0.12, 0.083333333333333
29746, 1.8666666666667, -0.16, 0.083333333333333
29747, 1.9083333333333, -0.04, 0.083333333333333
29748, 1.9083333333333, -0.08, 0.083333333333333
29749, 1.9083333333333, -0.12, 0.083333333333333
29750, 1.9083333333333, -0.16, 0.083333333333333
29751, 1.95, -0.04, 0.083333333333333
29752, 1.95, -0.08, 0.083333333333333
29753, 1.95, -0.12, 0.083333333333333
29754, 1.95, -0.16, 0.083333333333333
29755, 1.9916666666667, -0.04, 0.083333333333333
29756, 1.9916666666667, -0.08, 0.083333333333333
29757, 1.9916666666667, -0.12, 0.083333333333333
29758, 1.9916666666667, -0.16, 0.083333333333333
29759, 2.0333333333333, -0.04, 0.083333333333333
29760, 2.0333333333333, -0.08, 0.083333333333333
29761, 2.0333333333333, -0.12, 0.083333333333333
29762, 2.0333333333333, -0.16, 0.083333333333333
29763, 2.075, -0.04, 0.083333333333333
29764, 2.075, -0.08, 0.083333333333333
29765, 2.075, -0.12, 0.083333333333333
29766, 2.075, -0.16, 0.083333333333333
29767, 2.1166666666667, -0.04, 0.083333333333333
29768, 2.1166666666667, -0.08, 0.083333333333333
29769, 2.1166666666667, -0.12, 0.083333333333333
29770, 2.1166666666667, -0.16, 0.083333333333333
29771, 2.1583333333333, -0.04, 0.083333333333333
29772, 2.1583333333333, -0.08, 0.083333333333333
29773, 2.1583333333333, -0.12, 0.083333333333333
29774, 2.1583333333333, -0.16, 0.083333333333333
29775, 1.2416666666667, -0.04, 0.125
29776, 1.2416666666667, -0.08, 0.125
29777, 1.2416666666667, -0.12, 0.125
29778, 1.2416666666667, -0.16, 0.125
29779, 1.2833333333333, -0.04, 0.125
29780, 1.2833333333333, -0.08, 0.125
29781, 1.2833333333333, -0.12, 0.125
29782, 1.2833333333333, -0.16, 0.125
29783, 1.325, -0.04, 0.125
29784, 1.325, -0.08, 0.125
29785, 1.325, -0.12, 0.125
29786, 1.325, -0.16, 0.125
29787, 1.3666666666667, -0.04, 0.125
29788, 1.3666666666667, -0.08, 0.125
29789, 1.3666666666667, -0.12, 0.125
29790, 1.3666666666667, -0.16, 0.125
29791, 1.4083333333333, -0.04, 0.125
29792, 1.4083333333333, -0.08, 0.125
29793, 1.4083333333333, -0.12, 0.125
29794, 1.4083333333333, -0.16, 0.125
29795, 1.45, -0.04, 0.125
29796, 1.45, -0.08, 0.125
29797, 1.45, -0.12, 0.125
29798, 1.45, -0.16, 0.125
29799, 1.4916666666667, -0.04, 0.125
29800, 1.4916666666667, -0.08, 0.125
29801, 1.4916666666667, -0.12, 0.125
29802, 1.4916666666667, -0.16, 0.125
29803, 1.5333333333333, -0.04, 0.125
29804, 1.5333333333333, -0.08, 0.125
29805, 1.5333333333333, -0.12, 0.125
29806, 1.5333333333333, -0.16, 0.125
29807, 1.575, -0.04, 0.125
29808, 1.575, -0.08, 0.125
29809, 1.575, -0.12, 0.125
29810, 1.575, -0.16, 0.125
29811, 1.6166666666667, -0.04, 0.125
29812, 1.6166666666667, -0.08, 0.125
29813, 1.6166666666667, -0.12, 0.125
29814, 1.6166666666667, -0.16, 0.125
29815, 1.6583333333333, -0.04, 0.125
29816, 1.6583333333333, -0.08, 0.125
29817, 1.6583333333333, -0.12, 0.125
29818, 1.6583333333333, -0.16, 0.125
29819, 1.7, -0.04, 0.125
29820, 1.7, -0.08, 0.125
29821, 1.7, -0.12, 0.125
29822, 1.7, -0.16, 0.125
29823, 1.7416666666667, -0.04, 0.125
29824, 1.7416666666667, -0.08, 0.125
29825, 1.7416666666667, -0.12, 0.125
29826, 1.7416666666667, -0.16, 0.125
29827, 1.7833333333333, -0.04, 0.125
29828, 1.7833333333333, -0.08, 0.125
29829, 1.7833333333333, -0.12, 0.125
29830, 1.7833333333333, -0.16, 0.125
29831, 1.825, -0.04, 0.125
29832, 1.825, -0.08, 0.125
29833, 1.825, -0.12, 0.125
29834, 1.825, -0.16, 0.125
29835, 1.8666666666667, -0.04, 0.125
29836, 1.8666666666667, -0.08, 0.125
29837, 1.8666666666667, -0.12, 0.125
29838, 1.8666666666667, -0.16, 0.125
29839, 1.9083333333333, -0.04, 0.125
29840, 1.9083333333333, -0.08, 0.125
29841, 1.9083333333333, -0.12, 0.125
29842, 1.9083333333333, -0.16, 0.125
29843, 1.95, -0.04, 0.125
29844, 1.95, -0.08, 0.125
29845, 1.95, -0.12, 0.125
29846, 1.95, -0.16, 0.125
29847, 1.9916666666667, -0.04, 0.125
29848, 1.9916666666667, -0.08, 0.125
29849, 1.9916666666667, -0.12, 0.125
29850, 1.9916666666667, -0.16, 0.125
29851, 2.0333333333333, -0.04, 0.125
29852, 2.0333333333333, -0.08, 0.125
29853, 2.0333333333333, -0.12, 0.125
29854, 2.0333333333333, -0.16, 0.125
29855, 2.075, -0.04, 0.125
29856, 2.075, -0.08, 0.125
29857, 2.075, -0.12, 0.125
29858, 2.075, -0.16, 0.125
29859, 2.1166666666667, -0.04, 0.125
29860, 2.1166666666667, -0.08, 0.125
29861, 2.1166666666667, -0.12, 0.125
29862, 2.1166666666667, -0.16, 0.125
29863, 2.1583333333333, -0.04, 0.125
29864, 2.1583333333333, -0.08, 0.125
29865, 2.1583333333333, -0.12, 0.125
29866, 2.1583333333333, -0.16, 0.125
29867, 1.2416666666667, -0.04, 0.16666666666667
29868, 1.2416666666667, -0.08, 0.16666666666667
29869, 1.2416666666667, -0.12, 0.16666666666667
29870, 1.2416666666667, -0.16, 0.16666666666667
29871, 1.2833333333333, -0.04, 0.16666666666667
29872, 1.2833333333333, -0.08, 0.16666666666667
29873, 1.2833333333333, -0.12, 0.16666666666667
29874, 1.2833333333333, -0.16, 0.16666666666667
29875, 1.325, -0.04, 0.16666666666667
29876, 1.325, -0.08, 0.16666666666667
29877, 1.325, -0.12, 0.16666666666667
29878, 1.325, -0.16, 0.16666666666667
29879, 1.3666666666667, -0.04, 0.16666666666667
29880, 1.3666666666667, -0.08, 0.16666666666667
29881, 1.3666666666667, -0.12, 0.16666666666667
29882, 1.3666666666667, -0.16, 0.16666666666667
29883, 1.4083333333333, -0.04, 0.16666666666667
29884, 1.4083333333333, -0.08, 0.16666666666667
29885, 1.4083333333333, -0.12, 0.16666666666667
29886, 1.4083333333333, -0.16, 0.16666666666667
29887, 1.45, -0.04, 0.16666666666667
29888, 1.45, -0.08, 0.16666666666667
29889, 1.45, -0.12, 0.16666666666667
29890, 1.45, -0.16, 0.16666666666667
29891, 1.4916666666667, -0.04, 0.16666666666667
29892, 1.4916666666667, -0.08, 0.16666666666667
29893, 1.4916666666667, -0.12, 0.16666666666667
29894, 1.4916666666667, -0.16, 0.16666666666667
29895, 1.5333333333333, -0.04, 0.16666666666667
29896, 1.5333333333333, -0.08, 0.16666666666667
29897, 1.5333333333333, -0.12, 0.16666666666667
29898, 1.5333333333333, -0.16, 0.16666666666667
29899, 1.575, -0.04, 0.16666666666667
29900, 1.575, -0.08, 0.16666666666667
29901, 1.575, -0.12, 0.16666666666667
29902, 1.575, -0.16, 0.16666666666667
29903, 1.6166666666667, -0.04, 0.16666666666667
29904, 1.6166666666667, -0.08, 0.16666666666667
29905, 1.6166666666667, -0.12, 0.16666666666667
29906, 1.6166666666667, -0.16, 0.16666666666667
29907, 1.6583333333333, -0.04, 0.16666666666667
29908, 1.6583333333333, -0.08, 0.16666666666667
29909, 1.6583333333333, -0.12, 0.16666666666667
29910, 1.6583333333333, -0.16, 0.16666666666667
29911, 1.7, -0.04, 0.16666666666667
29912, 1.7, -0.08, 0.16666666666667
29913, 1.7, -0.12, 0.16666666666667
29914, 1.7, -0.16, 0.16666666666667
29915, 1.7416666666667, -0.04, 0.16666666666667
29916, 1.7416666666667, -0.08, 0.16666666666667
29917, 1.7416666666667, -0.12, 0.16666666666667
29918, 1.7416666666667, -0.16, 0.16666666666667
29919, 1.7833333333333, -0.04, 0.16666666666667
29920, 1.7833333333333, -0.08, 0.16666666666667
29921, 1.7833333333333, -0.12, 0.16666666666667
29922, 1.7833333333333, -0.16, 0.16666666666667
29923, 1.825, -0.04, 0.16666666666667
29924, 1.825, -0.08, 0.16666666666667
29925, 1.825, -0.12, 0.16666666666667
29926, 1.825, -0.16, 0.16666666666667
29927, 1.8666666666667, -0.04, 0.16666666666667
29928, 1.8666666666667, -0.08, 0.16666666666667
29929, 1.8666666666667, -0.12, 0.16666666666667
29930, 1.8666666666667, -0.16, 0.16666666666667
29931, 1.9083333333333, -0.04, 0.16666666666667
29932, 1.9083333333333, -0.08, 0.16666666666667
29933, 1.9083333333333, -0.12, 0.16666666666667
29934, 1.9083333333333, -0.16, 0.16666666666667
29935, 1.95, -0.04, 0.16666666666667
29936, 1.95, -0.08, 0.16666666666667
29937, 1.95, -0.12, 0.16666666666667
29938, 1.95, -0.16, 0.16666666666667
29939, 1.9916666666667, -0.04, 0.16666666666667
29940, 1.9916666666667, -0.08, 0.16666666666667
29941, 1.9916666666667, -0.12, 0.16666666666667
29942, 1.9916666666667, -0.16, 0.16666666666667
29943, 2.0333333333333, -0.04, 0.16666666666667
29944, 2.0333333333333, -0.08, 0.16666666666667
29945, 2.0333333333333, -0.12, 0.16666666666667
29946, 2.0333333333333, -0.16, 0.16666666666667
29947, 2.075, -0.04, 0.16666666666667
29948, 2.075, -0.08, 0.16666666666667
29949, 2.075, -0.12, 0.16666666666667
29950, 2.075, -0.16, 0.16666666666667
29951, 2.1166666666667, -0.04, 0.16666666666667
29952, 2.1166666666667, -0.08, 0.16666666666667
29953, 2.1166666666667, -0.12, 0.16666666666667
29954, 2.1166666666667, -0.16, 0.16666666666667
29955, 2.1583333333333, -0.04, 0.16666666666667
29956, 2.1583333333333, -0.08, 0.16666666666667
29957, 2.1583333333333, -0.12, 0.16666666666667
29958, 2.1583333333333, -0.16, 0.16666666666667
29959, 1.2416666666667, -0.04, 0.20833333333333
29960, 1.2416666666667, -0.08, 0.20833333333333
29961, 1.2416666666667, -0.12, 0.20833333333333
29962, 1.2416666666667, -0.16, 0.20833333333333
29963, 1.2833333333333, -0.04, 0.20833333333333
29964, 1.2833333333333, -0.08, 0.20833333333333
29965, 1.2833333333333, -0.12, 0.20833333333333
29966, 1.2833333333333, -0.16, 0.20833333333333
29967, 1.325, -0.04, 0.20833333333333
29968, 1.325, -0.08, 0.20833333333333
29969, 1.325, -0.12, 0.20833333333333
29970, 1.325, -0.16, 0.20833333333333
29971, 1.3666666666667, -0.04, 0.20833333333333
29972, 1.3666666666667, -0.08, 0.20833333333333
29973, 1.3666666666667, -0.12, 0.20833333333333
29974, 1.3666666666667, -0.16, 0.20833333333333
29975, 1.4083333333333, -0.04, 0.20833333333333
29976, 1.4083333333333, -0.08, 0.20833333333333
29977, 1.4083333333333, -0.12, 0.20833333333333
29978, 1.4083333333333, -0.16, 0.20833333333333
29979, 1.45, -0.04, 0.20833333333333
29980, 1.45, -0.08, 0.20833333333333
29981, 1.45, -0.12, 0.20833333333333
29982, 1.45, -0.16, 0.20833333333333
29983, 1.4916666666667, -0.04, 0.20833333333333
29984, 1.4916666666667, -0.08, 0.20833333333333
29985, 1.4916666666667, -0.12, 0.20833333333333
29986, 1.4916666666667, -0.16, 0.20833333333333
29987, 1.5333333333333, -0.04, 0.20833333333333
29988, 1.5333333333333, -0.08, 0.20833333333333
29989, 1.5333333333333, -0.12, 0.20833333333333
29990, 1.5333333333333, -0.16, 0.20833333333333
29991, 1.575, -0.04, 0.20833333333333
29992, 1.575, -0.08, 0.20833333333333
29993, 1.575, -0.12, 0.20833333333333
29994, 1.575, -0.16, 0.20833333333333
29995, 1.6166666666667, -0.04, 0.20833333333333
29996, 1.6166666666667, -0.08, 0.20833333333333
29997, 1.6166666666667, -0.12, 0.20833333333333
29998, 1.6166666666667, -0.16, 0.20833333333333
29999, 1.6583333333333, -0.04, 0.20833333333333
30000, 1.6583333333333, -0.08, 0.20833333333333
30001, 1.6583333333333, -0.12, 0.20833333333333
30002, 1.6583333333333, -0.16, 0.20833333333333
30003, 1.7, -0.04, 0.20833333333333
30004, 1.7, -0.08, 0.20833333333333
30005, 1.7, -0.12, 0.20833333333333
30006, 1.7, -0.16, 0.20833333333333
30007, 1.7416666666667, -0.04, 0.20833333333333
30008, 1.7416666666667, -0.08, 0.20833333333333
30009, 1.7416666666667, -0.12, 0.20833333333333
30010, 1.7416666666667, -0.16, 0.20833333333333
30011, 1.7833333333333, -0.04, 0.20833333333333
30012, 1.7833333333333, -0.08, 0.20833333333333
30013, 1.7833333333333, -0.12, 0.20833333333333
30014, 1.7833333333333, -0.16, 0.20833333333333
30015, 1.825, -0.04, 0.20833333333333
30016, 1.825, -0.08, 0.20833333333333
30017, 1.825, -0.12, 0.20833333333333
30018, 1.825, -0.16, 0.20833333333333
30019, 1.8666666666667, -0.04, 0.20833333333333
30020, 1.8666666666667, -0.08, 0.20833333333333
30021, 1.8666666666667, -0.12, 0.20833333333333
30022, 1.8666666666667, -0.16, 0.20833333333333
30023, 1.9083333333333, -0.04, 0.20833333333333
30024, 1.9083333333333, -0.08, 0.20833333333333
30025, 1.9083333333333, -0.12, 0.20833333333333
30026, 1.9083333333333, -0.16, 0.20833333333333
30027, 1.95, -0.04, 0.20833333333333
30028, 1.95, -0.08, 0.20833333333333
30029, 1.95, -0.12, 0.20833333333333
30030, 1.95, -0.16, 0.20833333333333
30031, 1.9916666666667, -0.04, 0.20833333333333
30032, 1.9916666666667, -0.08, 0.20833333333333
30033, 1.9916666666667, -0.12, 0.20833333333333
30034, 1.9916666666667, -0.16, 0.20833333333333
30035, 2.0333333333333, -0.04, 0.20833333333333
30036, 2.0333333333333, -0.08, 0.20833333333333
30037, 2.0333333333333, -0.12, 0.20833333333333
30038, 2.0333333333333, -0.16, 0.20833333333333
30039, 2.075, -0.04, 0.20833333333333
30040, 2.075, -0.08, 0.20833333333333
30041, 2.075, -0.12, 0.20833333333333
30042, 2.075, -0.16, 0.20833333333333
30043, 2.1166666666667, -0.04, 0.20833333333333
30044, 2.1166666666667, -0.08, 0.20833333333333
30045, 2.1166666666667, -0.12, 0.20833333333333
30046, 2.1166666666667, -0.16, 0.20833333333333
30047, 2.1583333333333, -0.04, 0.20833333333333
30048, 2.1583333333333, -0.08, 0.20833333333333
30049, 2.1583333333333, -0.12, 0.20833333333333
30050, 2.1583333333333, -0.16, 0.20833333333333
30051, 1.2416666666667, -0.04, 0.25
30052, 1.2416666666667, -0.08, 0.25
30053, 1.2416666666667, -0.12, 0.25
30054, 1.2416666666667, -0.16, 0.25
30055, 1.2833333333333, -0.04, 0.25
30056, 1.2833333333333, -0.08, 0.25
30057, 1.2833333333333, -0.12, 0.25
30058, 1.2833333333333, -0.16, 0.25
30059, 1.325, -0.04, 0.25
30060, 1.325, -0.08, 0.25
30061, 1.325, -0.12, 0.25
30062, 1.325, -0.16, 0.25
30063, 1.3666666666667, -0.04, 0.25
30064, 1.3666666666667, -0.08, 0.25
30065, 1.3666666666667, -0.12, 0.25
30066, 1.3666666666667, -0.16, 0.25
30067, 1.4083333333333, -0.04, 0.25
30068, 1.4083333333333, -0.08, 0.25
30069, 1.4083333333333, -0.12, 0.25
30070, 1.4083333333333, -0.16, 0.25
30071, 1.45, -0.04, 0.25
30072, 1.45, -0.08, 0.25
30073, 1.45, -0.12, 0.25
30074, 1.45, -0.16, 0.25
30075, 1.4916666666667, -0.04, 0.25
30076, 1.4916666666667, -0.08, 0.25
30077, 1.4916666666667, -0.12, 0.25
30078, 1.4916666666667, -0.16, 0.25
30079, 1.5333333333333, -0.04, 0.25
30080, 1.5333333333333, -0.08, 0.25
30081, 1.5333333333333, -0.12, 0.25
30082, 1.5333333333333, -0.16, 0.25
30083, 1.575, -0.04, 0.25
30084, 1.575, -0.08, 0.25
30085, 1.575, -0.12, 0.25
30086, 1.575, -0.16, 0.25
30087, 1.6166666666667, -0.04, 0.25
30088, 1.6166666666667, -0.08, 0.25
30089, 1.6166666666667, -0.12, 0.25
30090, 1.6166666666667, -0.16, 0.25
30091, 1.6583333333333, -0.04, 0.25
30092, 1.6583333333333, -0.08, 0.25
30093, 1.6583333333333, -0.12, 0.25
30094, 1.6583333333333, -0.16, 0.25
30095, 1.7, -0.04, 0.25
30096, 1.7, -0.08, 0.25
30097, 1.7, -0.12, 0.25
30098, 1.7, -0.16, 0.25
30099, 1.7416666666667, -0.04, 0.25
30100, 1.7416666666667, -0.08, 0.25
30101, 1.7416666666667, -0.12, 0.25
30102, 1.7416666666667, -0.16, 0.25
30103, 1.7833333333333, -0.04, 0.25
30104, 1.7833333333333, -0.08, 0.25
30105, 1.7833333333333, -0.12, 0.25
30106, 1.7833333333333, -0.16, 0.25
30107, 1.825, -0.04, 0.25
30108, 1.825, -0.08, 0.25
30109, 1.825, -0.12, 0.25
30110, 1.825, -0.16, 0.25
30111, 1.8666666666667, -0.04, 0.25
30112, 1.8666666666667, -0.08, 0.25
30113, 1.8666666666667, -0.12, 0.25
30114, 1.8666666666667, -0.16, 0.25
30115, 1.9083333333333, -0.04, 0.25
30116, 1.9083333333333, -0.08, 0.25
30117, 1.9083333333333, -0.12, 0.25
30118, 1.9083333333333, -0.16, 0.25
30119, 1.95, -0.04, 0.25
30120, 1.95, -0.08, 0.25
30121, 1.95, -0.12, 0.25
30122, 1.95, -0.16, 0.25
30123, 1.9916666666667, -0.04, 0.25
30124, 1.9916666666667, -0.08, 0.25
30125, 1.9916666666667, -0.12, 0.25
30126, 1.9916666666667, -0.16, 0.25
30127, 2.0333333333333, -0.04, 0.25
30128, 2.0333333333333, -0.08, 0.25
30129, 2.0333333333333, -0.12, 0.25
30130, 2.0333333333333, -0.16, 0.25
30131, 2.075, -0.04, 0.25
30132, 2.075, -0.08, 0.25
30133, 2.075, -0.12, 0.25
30134, 2.075, -0.16, 0.25
30135, 2.1166666666667, -0.04, 0.25
30136, 2.1166666666667, -0.08, 0.25
30137, 2.1166666666667, -0.12, 0.25
30138, 2.1166666666667, -0.16, 0.25
30139, 2.1583333333333, -0.04, 0.25
30140, 2.1583333333333, -0.08, 0.25
30141, 2.1583333333333, -0.12, 0.25
30142, 2.1583333333333, -0.16, 0.25
30143, 1.2416666666667, -0.04, 0.29166666666667
30144, 1.2416666666667, -0.08, 0.29166666666667
30145, 1.2416666666667, -0.12, 0.29166666666667
30146, 1.2416666666667, -0.16, 0.29166666666667
30147, 1.2833333333333, -0.04, 0.29166666666667
30148, 1.2833333333333, -0.08, 0.29166666666667
30149, 1.2833333333333, -0.12, 0.29166666666667
30150, 1.2833333333333, -0.16, 0.29166666666667
30151, 1.325, -0.04, 0.29166666666667
30152, 1.325, -0.08, 0.29166666666667
30153, 1.325, -0.12, 0.29166666666667
30154, 1.325, -0.16, 0.29166666666667
30155, 1.3666666666667, -0.04, 0.29166666666667
30156, 1.3666666666667, -0.08, 0.29166666666667
30157, 1.3666666666667, -0.12, 0.29166666666667
30158, 1.3666666666667, -0.16, 0.29166666666667
30159, 1.4083333333333, -0.04, 0.29166666666667
30160, 1.4083333333333, -0.08, 0.29166666666667
30161, 1.4083333333333, -0.12, 0.29166666666667
30162, 1.4083333333333, -0.16, 0.29166666666667
30163, 1.45, -0.04, 0.29166666666667
30164, 1.45, -0.08, 0.29166666666667
30165, 1.45, -0.12, 0.29166666666667
30166, 1.45, -0.16, 0.29166666666667
30167, 1.4916666666667, -0.04, 0.29166666666667
30168, 1.4916666666667, -0.08, 0.29166666666667
30169, 1.4916666666667, -0.12, 0.29166666666667
30170, 1.4916666666667, -0.16, 0.29166666666667
30171, 1.5333333333333, -0.04, 0.29166666666667
30172, 1.5333333333333, -0.08, 0.29166666666667
30173, 1.5333333333333, -0.12, 0.29166666666667
30174, 1.5333333333333, -0.16, 0.29166666666667
30175, 1.575, -0.04, 0.29166666666667
30176, 1.575, -0.08, 0.29166666666667
30177, 1.575, -0.12, 0.29166666666667
30178, 1.575, -0.16, 0.29166666666667
30179, 1.6166666666667, -0.04, 0.29166666666667
30180, 1.6166666666667, -0.08, 0.29166666666667
30181, 1.6166666666667, -0.12, 0.29166666666667
30182, 1.6166666666667, -0.16, 0.29166666666667
30183, 1.6583333333333, -0.04, 0.29166666666667
30184, 1.6583333333333, -0.08, 0.29166666666667
30185, 1.6583333333333, -0.12, 0.29166666666667
30186, 1.6583333333333, -0.16, 0.29166666666667
30187, 1.7, -0.04, 0.29166666666667
30188, 1.7, -0.08, 0.29166666666667
30189, 1.7, -0.12, 0.29166666666667
30190, 1.7, -0.16, 0.29166666666667
30191, 1.7416666666667, -0.04, 0.29166666666667
30192, 1.7416666666667, -0.08, 0.29166666666667
30193, 1.7416666666667, -0.12, 0.29166666666667
30194, 1.7416666666667, -0.16, 0.29166666666667
30195, 1.7833333333333, -0.04, 0.29166666666667
30196, 1.7833333333333, -0.08, 0.29166666666667
30197, 1.7833333333333, -0.12, 0.29166666666667
30198, 1.7833333333333, -0.16, 0.29166666666667
30199, 1.825, -0.04, 0.29166666666667
30200, 1.825, -0.08, 0.29166666666667
30201, 1.825, -0.12, 0.29166666666667
30202, 1.825, -0.16, 0.29166666666667
30203, 1.8666666666667, -0.04, 0.29166666666667
30204, 1.8666666666667, -0.08, 0.29166666666667
30205, 1.8666666666667, -0.12, 0.29166666666667
30206, 1.8666666666667, -0.16, 0.29166666666667
30207, 1.9083333333333, -0.04, 0.29166666666667
30208, 1.9083333333333, -0.08, 0.29166666666667
30209, 1.9083333333333, -0.12, 0.29166666666667
30210, 1.9083333333333, -0.16, 0.29166666666667
30211, 1.95, -0.04, 0.29166666666667
30212, 1.95, -0.08, 0.29166666666667
30213, 1.95, -0.12, 0.29166666666667
30214, 1.95, -0.16, 0.29166666666667
30215, 1.9916666666667, -0.04, 0.29166666666667
30216, 1.9916666666667, -0.08, 0.29166666666667
30217, 1.9916666666667, -0.12, 0.29166666666667
30218, 1.9916666666667, -0.16, 0.29166666666667
30219, 2.0333333333333, -0.04, 0.29166666666667
30220, 2.0333333333333, -0.08, 0.29166666666667
30221, 2.0333333333333, -0.12, 0.29166666666667
30222, 2.0333333333333, -0.16, 0.29166666666667
30223, 2.075, -0.04, 0.29166666666667
30224, 2.075, -0.08, 0.29166666666667
30225, 2.075, -0.12, 0.29166666666667
30226, 2.075, -0.16, 0.29166666666667
30227, 2.1166666666667, -0.04, 0.29166666666667
30228, 2.1166666666667, -0.08, 0.29166666666667
30229, 2.1166666666667, -0.12, 0.29166666666667
30230, 2.1166666666667, -0.16, 0.29166666666667
30231, 2.1583333333333, -0.04, 0.29166666666667
30232, 2.1583333333333, -0.08, 0.29166666666667
30233, 2.1583333333333, -0.12, 0.29166666666667
30234, 2.1583333333333, -0.16, 0.29166666666667
30235, 1.2416666666667, -0.04, 0.33333333333333
30236, 1.2416666666667, -0.08, 0.33333333333333
30237, 1.2416666666667, -0.12, 0.33333333333333
30238, 1.2416666666667, -0.16, 0.33333333333333
30239, 1.2833333333333, -0.04, 0.33333333333333
30240, 1.2833333333333, -0.08, 0.33333333333333
30241, 1.2833333333333, -0.12, 0.33333333333333
30242, 1.2833333333333, -0.16, 0.33333333333333
30243, 1.325, -0.04, 0.33333333333333
30244, 1.325, -0.08, 0.33333333333333
30245, 1.325, -0.12, 0.33333333333333
30246, 1.325, -0.16, 0.33333333333333
30247, 1.3666666666667, -0.04, 0.33333333333333
30248, 1.3666666666667, -0.08, 0.33333333333333
30249, 1.3666666666667, -0.12, 0.33333333333333
30250, 1.3666666666667, -0.16, 0.33333333333333
30251, 1.4083333333333, -0.04, 0.33333333333333
30252, 1.4083333333333, -0.08, 0.33333333333333
30253, 1.4083333333333, -0.12, 0.33333333333333
30254, 1.4083333333333, -0.16, 0.33333333333333
30255, 1.45, -0.04, 0.33333333333333
30256, 1.45, -0.08, 0.33333333333333
30257, 1.45, -0.12, 0.33333333333333
30258, 1.45, -0.16, 0.33333333333333
30259, 1.4916666666667, -0.04, 0.33333333333333
30260, 1.4916666666667, -0.08, 0.33333333333333
30261, 1.4916666666667, -0.12, 0.33333333333333
30262, 1.4916666666667, -0.16, 0.33333333333333
30263, 1.5333333333333, -0.04, 0.33333333333333
30264, 1.5333333333333, -0.08, 0.33333333333333
30265, 1.5333333333333, -0.12, 0.33333333333333
30266, 1.5333333333333, -0.16, 0.33333333333333
30267, 1.575, -0.04, 0.33333333333333
30268, 1.575, -0.08, 0.33333333333333
30269, 1.575, -0.12, 0.33333333333333
30270, 1.575, -0.16, 0.33333333333333
30271, 1.6166666666667, -0.04, 0.33333333333333
30272, 1.6166666666667, -0.08, 0.33333333333333
30273, 1.6166666666667, -0.12, 0.33333333333333
30274, 1.6166666666667, -0.16, 0.33333333333333
30275, 1.6583333333333, -0.04, 0.33333333333333
30276, 1.6583333333333, -0.08, 0.33333333333333
30277, 1.6583333333333, -0.12, 0.33333333333333
30278, 1.6583333333333, -0.16, 0.33333333333333
30279, 1.7, -0.04, 0.33333333333333
30280, 1.7, -0.08, 0.33333333333333
30281, 1.7, -0.12, 0.33333333333333
30282, 1.7, -0.16, 0.33333333333333
30283, 1.7416666666667, -0.04, 0.33333333333333
30284, 1.7416666666667, -0.08, 0.33333333333333
30285, 1.7416666666667, -0.12, 0.33333333333333
30286, 1.7416666666667, -0.16, 0.33333333333333
30287, 1.7833333333333, -0.04, 0.33333333333333
30288, 1.7833333333333, -0.08, 0.33333333333333
30289, 1.7833333333333, -0.12, 0.33333333333333
30290, 1.7833333333333, -0.16, 0.33333333333333
30291, 1.825, -0.04, 0.33333333333333
30292, 1.825, -0.08, 0.33333333333333
30293, 1.825, -0.12, 0.33333333333333
30294, 1.825, -0.16, 0.33333333333333
30295, 1.8666666666667, -0.04, 0.33333333333333
30296, 1.8666666666667, -0.08, 0.33333333333333
30297, 1.8666666666667, -0.12, 0.33333333333333
30298, 1.8666666666667, -0.16, 0.33333333333333
30299, 1.9083333333333, -0.04, 0.33333333333333
30300, 1.9083333333333, -0.08, 0.33333333333333
30301, 1.9083333333333, -0.12, 0.33333333333333
30302, 1.9083333333333, -0.16, 0.33333333333333
30303, 1.95, -0.04, 0.33333333333333
30304, 1.95, -0.08, 0.33333333333333
30305, 1.95, -0.12, 0.33333333333333
30306, 1.95, -0.16, 0.33333333333333
30307, 1.9916666666667, -0.04, 0.33333333333333
30308, 1.9916666666667, -0.08, 0.33333333333333
30309, 1.9916666666667, -0.12, 0.33333333333333
30310, 1.9916666666667, -0.16, 0.33333333333333
30311, 2.0333333333333, -0.04, 0.33333333333333
30312, 2.0333333333333, -0.08, 0.33333333333333
30313, 2.0333333333333, -0.12, 0.33333333333333
30314, 2.0333333333333, -0.16, 0.33333333333333
30315, 2.075, -0.04, 0.33333333333333
30316, 2.075, -0.08, 0.33333333333333
30317, 2.075, -0.12, 0.33333333333333
30318, 2.075, -0.16, 0.33333333333333
30319, 2.1166666666667, -0.04, 0.33333333333333
30320, 2.1166666666667, -0.08, 0.33333333333333
30321, 2.1166666666667, -0.12, 0.33333333333333
30322, 2.1166666666667, -0.16, 0.33333333333333
30323, 2.1583333333333, -0.04, 0.33333333333333
30324, 2.1583333333333, -0.08, 0.33333333333333
30325, 2.1583333333333, -0.12, 0.33333333333333
30326, 2.1583333333333, -0.16, 0.33333333333333
30327, 1.2416666666667, -0.04, 0.375
30328, 1.2416666666667, -0.08, 0.375
30329, 1.2416666666667, -0.12, 0.375
30330, 1.2416666666667, -0.16, 0.375
30331, 1.2833333333333, -0.04, 0.375
30332, 1.2833333333333, -0.08, 0.375
30333, 1.2833333333333, -0.12, 0.375
30334, 1.2833333333333, -0.16, 0.375
30335, 1.325, -0.04, 0.375
30336, 1.325, -0.08, 0.375
30337, 1.325, -0.12, 0.375
30338, 1.325, -0.16, 0.375
30339, 1.3666666666667, -0.04, 0.375
30340, 1.3666666666667, -0.08, 0.375
30341, 1.3666666666667, -0.12, 0.375
30342, 1.3666666666667, -0.16, 0.375
30343, 1.4083333333333, -0.04, 0.375
30344, 1.4083333333333, -0.08, 0.375
30345, 1.4083333333333, -0.12, 0.375
30346, 1.4083333333333, -0.16, 0.375
30347, 1.45, -0.04, 0.375
30348, 1.45, -0.08, 0.375
30349, 1.45, -0.12, 0.375
30350, 1.45, -0.16, 0.375
30351, 1.4916666666667, -0.04, 0.375
30352, 1.4916666666667, -0.08, 0.375
30353, 1.4916666666667, -0.12, 0.375
30354, 1.4916666666667, -0.16, 0.375
30355, 1.5333333333333, -0.04, 0.375
30356, 1.5333333333333, -0.08, 0.375
30357, 1.5333333333333, -0.12, 0.375
30358, 1.5333333333333, -0.16, 0.375
30359, 1.575, -0.04, 0.375
30360, 1.575, -0.08, 0.375
30361, 1.575, -0.12, 0.375
30362, 1.575, -0.16, 0.375
30363, 1.6166666666667, -0.04, 0.375
30364, 1.6166666666667, -0.08, 0.375
30365, 1.6166666666667, -0.12, 0.375
30366, 1.6166666666667, -0.16, 0.375
30367, 1.6583333333333, -0.04, 0.375
30368, 1.6583333333333, -0.08, 0.375
30369, 1.6583333333333, -0.12, 0.375
30370, 1.6583333333333, -0.16, 0.375
30371, 1.7, -0.04, 0.375
30372, 1.7, -0.08, 0.375
30373, 1.7, -0.12, 0.375
30374, 1.7, -0.16, 0.375
30375, 1.7416666666667, -0.04, 0.375
30376, 1.7416666666667, -0.08, 0.375
30377, 1.7416666666667, -0.12, 0.375
30378, 1.7416666666667, -0.16, 0.375
30379, 1.7833333333333, -0.04, 0.375
30380, 1.7833333333333, -0.08, 0.375
30381, 1.7833333333333, -0.12, 0.375
30382, 1.7833333333333, -0.16, 0.375
30383, 1.825, -0.04, 0.375
30384, 1.825, -0.08, 0.375
30385, 1.825, -0.12, 0.375
30386, 1.825, -0.16, 0.375
30387, 1.8666666666667, -0.04, 0.375
30388, 1.8666666666667, -0.08, 0.375
30389, 1.8666666666667, -0.12, 0.375
30390, 1.8666666666667, -0.16, 0.375
30391, 1.9083333333333, -0.04, 0.375
30392, 1.9083333333333, -0.08, 0.375
30393, 1.9083333333333, -0.12, 0.375
30394, 1.9083333333333, -0.16, 0.375
30395, 1.95, -0.04, 0.375
30396, 1.95, -0.08, 0.375
30397, 1.95, -0.12, 0.375
30398, 1.95, -0.16, 0.375
30399, 1.9916666666667, -0.04, 0.375
30400, 1.9916666666667, -0.08, 0.375
30401, 1.9916666666667, -0.12, 0.375
30402, 1.9916666666667, -0.16, 0.375
30403, 2.0333333333333, -0.04, 0.375
30404, 2.0333333333333, -0.08, 0.375
30405, 2.0333333333333, -0.12, 0.375
30406, 2.0333333333333, -0.16, 0.375
30407, 2.075, -0.04, 0.375
30408, 2.075, -0.08, 0.375
30409, 2.075, -0.12, 0.375
30410, 2.075, -0.16, 0.375
30411, 2.1166666666667, -0.04, 0.375
30412, 2.1166666666667, -0.08, 0.375
30413, 2.1166666666667, -0.12, 0.375
30414, 2.1166666666667, -0.16, 0.375
30415, 2.1583333333333, -0.04, 0.375
30416, 2.1583333333333, -0.08, 0.375
30417, 2.1583333333333, -0.12, 0.375
30418, 2.1583333333333, -0.16, 0.375
30419, 1.2416666666667, -0.04, 0.41666666666667
30420, 1.2416666666667, -0.08, 0.41666666666667
30421, 1.2416666666667, -0.12, 0.41666666666667
30422, 1.2416666666667, -0.16, 0.41666666666667
30423, 1.2833333333333, -0.04, 0.41666666666667
30424, 1.2833333333333, -0.08, 0.41666666666667
30425, 1.2833333333333, -0.12, 0.41666666666667
30426, 1.2833333333333, -0.16, 0.41666666666667
30427, 1.325, -0.04, 0.41666666666667
30428, 1.325, -0.08, 0.41666666666667
30429, 1.325, -0.12, 0.41666666666667
30430, 1.325, -0.16, 0.41666666666667
30431, 1.3666666666667, -0.04, 0.41666666666667
30432, 1.3666666666667, -0.08, 0.41666666666667
30433, 1.3666666666667, -0.12, 0.41666666666667
30434, 1.3666666666667, -0.16, 0.41666666666667
30435, 1.4083333333333, -0.04, 0.41666666666667
30436, 1.4083333333333, -0.08, 0.41666666666667
30437, 1.4083333333333, -0.12, 0.41666666666667
30438, 1.4083333333333, -0.16, 0.41666666666667
30439, 1.45, -0.04, 0.41666666666667
30440, 1.45, -0.08, 0.41666666666667
30441, 1.45, -0.12, 0.41666666666667
30442, 1.45, -0.16, 0.41666666666667
30443, 1.4916666666667, -0.04, 0.41666666666667
30444, 1.4916666666667, -0.08, 0.41666666666667
30445, 1.4916666666667, -0.12, 0.41666666666667
30446, 1.4916666666667, -0.16, 0.41666666666667
30447, 1.5333333333333, -0.04, 0.41666666666667
30448, 1.5333333333333, -0.08, 0.41666666666667
30449, 1.5333333333333, -0.12, 0.41666666666667
30450, 1.5333333333333, -0.16, 0.41666666666667
30451, 1.575, -0.04, 0.41666666666667
30452, 1.575, -0.08, 0.41666666666667
30453, 1.575, -0.12, 0.41666666666667
30454, 1.575, -0.16, 0.41666666666667
30455, 1.6166666666667, -0.04, 0.41666666666667
30456, 1.6166666666667, -0.08, 0.41666666666667
30457, 1.6166666666667, -0.12, 0.41666666666667
30458, 1.6166666666667, -0.16, 0.41666666666667
30459, 1.6583333333333, -0.04, 0.41666666666667
30460, 1.6583333333333, -0.08, 0.41666666666667
30461, 1.6583333333333, -0.12, 0.41666666666667
30462, 1.6583333333333, -0.16, 0.41666666666667
30463, 1.7, -0.04, 0.41666666666667
30464, 1.7, -0.08, 0.41666666666667
30465, 1.7, -0.12, 0.41666666666667
30466, 1.7, -0.16, 0.41666666666667
30467, 1.7416666666667, -0.04, 0.41666666666667
30468, 1.7416666666667, -0.08, 0.41666666666667
30469, 1.7416666666667, -0.12, 0.41666666666667
30470, 1.7416666666667, -0.16, 0.41666666666667
30471, 1.7833333333333, -0.04, 0.41666666666667
30472, 1.7833333333333, -0.08, 0.41666666666667
30473, 1.7833333333333, -0.12, 0.41666666666667
30474, 1.7833333333333, -0.16, 0.41666666666667
30475, 1.825, -0.04, 0.41666666666667
30476, 1.825, -0.08, 0.41666666666667
30477, 1.825, -0.12, 0.41666666666667
30478, 1.825, -0.16, 0.41666666666667
30479, 1.8666666666667, -0.04, 0.41666666666667
30480, 1.8666666666667, -0.08, 0.41666666666667
30481, 1.8666666666667, -0.12, 0.41666666666667
30482, 1.8666666666667, -0.16, 0.41666666666667
30483, 1.9083333333333, -0.04, 0.41666666666667
30484, 1.9083333333333, -0.08, 0.41666666666667
30485, 1.9083333333333, -0.12, 0.41666666666667
30486, 1.9083333333333, -0.16, 0.41666666666667
30487, 1.95, -0.04, 0.41666666666667
30488, 1.95, -0.08, 0.41666666666667
30489, 1.95, -0.12, 0.41666666666667
30490, 1.95, -0.16, 0.41666666666667
30491, 1.9916666666667, -0.04, 0.41666666666667
30492, 1.9916666666667, -0.08, 0.41666666666667
30493, 1.9916666666667, -0.12, 0.41666666666667
30494, 1.9916666666667, -0.16, 0.41666666666667
30495, 2.0333333333333, -0.04, 0.41666666666667
30496, 2.0333333333333, -0.08, 0.41666666666667
30497, 2.0333333333333, -0.12, 0.41666666666667
30498, 2.0333333333333, -0.16, 0.41666666666667
30499, 2.075, -0.04, 0.41666666666667
30500, 2.075, -0.08, 0.41666666666667
30501, 2.075, -0.12, 0.41666666666667
30502, 2.075, -0.16, 0.41666666666667
30503, 2.1166666666667, -0.04, 0.41666666666667
30504, 2.1166666666667, -0.08, 0.41666666666667
30505, 2.1166666666667, -0.12, 0.41666666666667
30506, 2.1166666666667, -0.16, 0.41666666666667
30507, 2.1583333333333, -0.04, 0.41666666666667
30508, 2.1583333333333, -0.08, 0.41666666666667
30509, 2.1583333333333, -0.12, 0.41666666666667
30510, 2.1583333333333, -0.16, 0.41666666666667
30511, 1.2416666666667, -0.04, 0.45833333333333
30512, 1.2416666666667, -0.08, 0.45833333333333
30513, 1.2416666666667, -0.12, 0.45833333333333
30514, 1.2416666666667, -0.16, 0.45833333333333
30515, 1.2833333333333, -0.04, 0.45833333333333
30516, 1.2833333333333, -0.08, 0.45833333333333
30517, 1.2833333333333, -0.12, 0.45833333333333
30518, 1.2833333333333, -0.16, 0.45833333333333
30519, 1.325, -0.04, 0.45833333333333
30520, 1.325, -0.08, 0.45833333333333
30521, 1.325, -0.12, 0.45833333333333
30522, 1.325, -0.16, 0.45833333333333
30523, 1.3666666666667, -0.04, 0.45833333333333
30524, 1.3666666666667, -0.08, 0.45833333333333
30525, 1.3666666666667, -0.12, 0.45833333333333
30526, 1.3666666666667, -0.16, 0.45833333333333
30527, 1.4083333333333, -0.04, 0.45833333333333
30528, 1.4083333333333, -0.08, 0.45833333333333
30529, 1.4083333333333, -0.12, 0.45833333333333
30530, 1.4083333333333, -0.16, 0.45833333333333
30531, 1.45, -0.04, 0.45833333333333
30532, 1.45, -0.08, 0.45833333333333
30533, 1.45, -0.12, 0.45833333333333
30534, 1.45, -0.16, 0.45833333333333
30535, 1.4916666666667, -0.04, 0.45833333333333
30536, 1.4916666666667, -0.08, 0.45833333333333
30537, 1.4916666666667, -0.12, 0.45833333333333
30538, 1.4916666666667, -0.16, 0.45833333333333
30539, 1.5333333333333, -0.04, 0.45833333333333
30540, 1.5333333333333, -0.08, 0.45833333333333
30541, 1.5333333333333, -0.12, 0.45833333333333
30542, 1.5333333333333, -0.16, 0.45833333333333
30543, 1.575, -0.04, 0.45833333333333
30544, 1.575, -0.08, 0.45833333333333
30545, 1.575, -0.12, 0.45833333333333
30546, 1.575, -0.16, 0.45833333333333
30547, 1.6166666666667, -0.04, 0.45833333333333
30548, 1.6166666666667, -0.08, 0.45833333333333
30549, 1.6166666666667, -0.12, 0.45833333333333
30550, 1.6166666666667, -0.16, 0.45833333333333
30551, 1.6583333333333, -0.04, 0.45833333333333
30552, 1.6583333333333, -0.08, 0.45833333333333
30553, 1.6583333333333, -0.12, 0.45833333333333
30554, 1.6583333333333, -0.16, 0.45833333333333
30555, 1.7, -0.04, 0.45833333333333
30556, 1.7, -0.08, 0.45833333333333
30557, 1.7, -0.12, 0.45833333333333
30558, 1.7, -0.16, 0.45833333333333
30559, 1.7416666666667, -0.04, 0.45833333333333
30560, 1.7416666666667, -0.08, 0.45833333333333
30561, 1.7416666666667, -0.12, 0.45833333333333
30562, 1.7416666666667, -0.16, 0.45833333333333
30563, 1.7833333333333, -0.04, 0.45833333333333
30564, 1.7833333333333, -0.08, 0.45833333333333
30565, 1.7833333333333, -0.12, 0.45833333333333
30566, 1.7833333333333, -0.16, 0.45833333333333
30567, 1.825, -0.04, 0.45833333333333
30568, 1.825, -0.08, 0.45833333333333
30569, 1.825, -0.12, 0.45833333333333
30570, 1.825, -0.16, 0.45833333333333
30571, 1.8666666666667, -0.04, 0.45833333333333
30572, 1.8666666666667, -0.08, 0.45833333333333
30573, 1.8666666666667, -0.12, 0.45833333333333
30574, 1.8666666666667, -0.16, 0.45833333333333
30575, 1.9083333333333, -0.04, 0.45833333333333
30576, 1.9083333333333, -0.08, 0.45833333333333
30577, 1.9083333333333, -0.12, 0.45833333333333
30578, 1.9083333333333, -0.16, 0.45833333333333
30579, 1.95, -0.04, 0.45833333333333
30580, 1.95, -0.08, 0.45833333333333
30581, 1.95, -0.12, 0.45833333333333
30582, 1.95, -0.16, 0.45833333333333
30583, 1.9916666666667, -0.04, 0.45833333333333
30584, 1.9916666666667, -0.08, 0.45833333333333
30585, 1.9916666666667, -0.12, 0.45833333333333
30586, 1.9916666666667, -0.16, 0.45833333333333
30587, 2.0333333333333, -0.04, 0.45833333333333
30588, 2.0333333333333, -0.08, 0.45833333333333
30589, 2.0333333333333, -0.12, 0.45833333333333
30590, 2.0333333333333, -0.16, 0.45833333333333
30591, 2.075, -0.04, 0.45833333333333
30592, 2.075, -0.08, 0.45833333333333
30593, 2.075, -0.12, 0.45833333333333
30594, 2.075, -0.16, 0.45833333333333
30595, 2.1166666666667, -0.04, 0.45833333333333
30596, 2.1166666666667, -0.08, 0.45833333333333
30597, 2.1166666666667, -0.12, 0.45833333333333
30598, 2.1166666666667, -0.16, 0.45833333333333
30599, 2.1583333333333, -0.04, 0.45833333333333
30600, 2.1583333333333, -0.08, 0.45833333333333
30601, 2.1583333333333, -0.12, 0.45833333333333
30602, 2.1583333333333, -0.16, 0.45833333333333
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
32122, 2, 97
32123, 97, 98
32124, 98, 99
32125, 99, 100
32126, 100, 101
32127, 101, 102
32128, 102, 103
32129, 103, 104
32130, 104, 105
32131, 105, 106
32132, 106, 107
32133, 107, 1
*ELEMENT, type=T3D2, ELSET=Line2
32134, 1, 108
32135, 108, 109
32136, 109, 3
*ELEMENT, type=T3D2, ELSET=Line3
32137, 4, 110
32138, 110, 111
32139, 111, 112
32140, 112, 113
32141, 113, 114
32142, 114, 115
32143, 115, 116
32144, 116, 117
32145, 117, 118
32146, 118, 119
32147, 119, 120
32148, 120, 3
*ELEMENT, type=T3D2, ELSET=Line4
32149, 2, 121
32150, 121, 122
32151, 122, 4
*ELEMENT, type=T3D2, ELSET=Line5
32152, 6, 123
32153, 123, 124
32154, 124, 125
32155, 125, 126
32156, 126, 127
32157, 127, 128
32158, 128, 129
32159, 129, 130
32160, 130, 131
32161, 131, 132
32162, 132, 133
32163, 133, 5
*ELEMENT, type=T3D2, ELSET=Line6
32164, 5, 134
32165, 134, 135
32166, 135, 7
*ELEMENT, type=T3D2, ELSET=Line7
32167, 8, 136
32168, 136, 137
32169, 137, 138
32170, 138, 139
32171, 139, 140
32172, 140, 141
32173, 141, 142
32174, 142, 143
32175, 143, 144
32176, 144, 145
32177, 145, 146
32178, 146, 7
*ELEMENT, type=T3D2, ELSET=Line8
32179, 6, 147
32180, 147, 148
32181, 148, 8
*ELEMENT, type=T3D2, ELSET=Line9
32182, 2, 149
32183, 149, 150
32184, 150, 151
32185, 151, 152
32186, 152, 153
32187, 153, 154
32188, 154, 155
32189, 155, 156
32190, 156, 157
32191, 157, 158
32192, 158, 159
32193, 159, 160
32194, 160, 161
32195, 161, 162
32196, 162, 163
32197, 163, 164
32198, 164, 165
32199, 165, 166
32200, 166, 167
32201, 167, 168
32202, 168, 169
32203, 169, 170
32204, 170, 171
32205, 171, 6
*ELEMENT, type=T3D2, ELSET=Line10
32206, 1, 172
32207, 172, 173
32208, 173, 174
32209, 174, 175
32210, 175, 176
32211, 176, 177
32212, 177, 178
32213, 178, 179
32214, 179, 180
32215, 180, 181
32216, 181, 182
32217, 182, 183
32218, 183, 184
32219, 184, 185
32220, 185, 186
32221, 186, 187
32222, 187, 188
32223, 188, 189
32224, 189, 190
32225, 190, 191
32226, 191, 192
32227, 192, 193
32228, 193, 194
32229, 194, 5
*ELEMENT, type=T3D2, ELSET=Line11
32230, 4, 195
32231, 195, 196
32232, 196, 197
32233, 197, 198
32234, 198, 199
32235, 199, 200
32236, 200, 201
32237, 201, 202
32238, 202, 203
32239, 203, 204
32240, 204, 205
32241, 205, 206
32242, 206, 207
32243, 207, 208
32244, 208, 209
32245, 209, 210
32246, 210, 211
32247, 211, 212
32248, 212, 213
32249, 213, 214
32250, 214, 215
32251, 215, 216
32252, 216, 217
32253, 217, 8
*ELEMENT, type=T3D2, ELSET=Line12
32254, 3, 218
32255, 218, 219
32256, 219, 220
32257, 220, 221
32258, 221, 222
32259, 222, 223
32260, 223, 224
32261, 224, 225
32262, 225, 226
32263, 226, 227
32264, 227, 228
32265, 228, 229
32266, 229, 230
32267, 230, 231
32268, 231, 232
32269, 232, 233
32270, 233, 234
32271, 234, 235
32272, 235, 236
32273, 236, 237
32274, 237, 238
32275, 238, 239
32276, 239, 240
32277, 240, 7
*ELEMENT, type=T3D2, ELSET=Line13
32278, 8, 9
*ELEMENT, type=T3D2, ELSET=Line14
32279, 4, 10
*ELEMENT, type=T3D2, ELSET=Line15
32280, 10, 241
32281, 241, 242
32282, 242, 243
32283, 243, 244
32284, 244, 245
32285, 245, 246
32286, 246, 247
32287, 247, 248
32288, 248, 249
32289, 249, 250
32290, 250, 251
32291, 251, 252
32292, 252, 253
32293, 253, 254
32294, 254, 255
32295, 255, 256
32296, 256, 257
32297, 257, 258
32298, 258, 259
32299, 259, 260
32300, 260, 261
32301, 261, 262
32302, 262, 263
32303, 263, 9
*ELEMENT, type=T3D2, ELSET=Line16
32304, 7, 11
*ELEMENT, type=T3D2, ELSET=Line17
32305, 9, 264
32306, 264, 265
32307, 265, 266
32308, 266, 267
32309, 267, 268
32310, 268, 269
32311, 269, 270
32312, 270, 271
32313, 271, 272
32314, 272, 273
32315, 273, 274
32316, 274, 11
*ELEMENT, type=T3D2, ELSET=Line18
32317, 3, 12
*ELEMENT, type=T3D2, ELSET=Line19
32318, 12, 275
32319, 275, 276
32320, 276, 277
32321, 277, 278
32322, 278, 279
32323, 279, 280
32324, 280, 281
32325, 281, 282
32326, 282, 283
32327, 283, 284
32328, 284, 285
32329, 285, 286
32330, 286, 287
32331, 287, 288
32332, 288, 289
32333, 289, 290
32334, 290, 291
32335, 291, 292
32336, 292, 293
32337, 293, 294
32338, 294, 295
32339, 295, 296
32340, 296, 297
32341, 297, 11
*ELEMENT, type=T3D2, ELSET=Line20
32342, 10, 298
32343, 298, 299
32344, 299, 300
32345, 300, 301
32346, 301, 302
32347, 302, 303
32348, 303, 304
32349, 304, 305
32350, 305, 306
32351, 306, 307
32352, 307, 308
32353, 308, 12
*ELEMENT, type=T3D2, ELSET=Line21
32354, 9, 309
32355, 309, 310
32356, 310, 311
32357, 311, 312
32358, 312, 313
32359, 313, 314
32360, 314, 315
32361, 315, 316
32362, 316, 317
32363, 317, 318
32364, 318, 319
32365, 319, 320
32366, 320, 321
32367, 321, 322
32368, 322, 323
32369, 323, 324
32370, 324, 325
32371, 325, 326
32372, 326, 327
32373, 327, 328
32374, 328, 329
32375, 329, 330
32376, 330, 331
32377, 331, 13
*ELEMENT, type=T3D2, ELSET=Line22
32378, 10, 332
32379, 332, 333
32380, 333, 334
32381, 334, 335
32382, 335, 336
32383, 336, 337
32384, 337, 338
32385, 338, 339
32386, 339, 340
32387, 340, 341
32388, 341, 342
32389, 342, 343
32390, 343, 344
32391, 344, 345
32392, 345, 346
32393, 346, 347
32394, 347, 348
32395, 348, 349
32396, 349, 350
32397, 350, 351
32398, 351, 352
32399, 352, 353
32400, 353, 354
32401, 354, 14
*ELEMENT, type=T3D2, ELSET=Line23
32402, 14, 355
32403, 355, 356
32404, 356, 357
32405, 357, 358
32406, 358, 359
32407, 359, 360
32408, 360, 361
32409, 361, 362
32410, 362, 363
32411, 363, 364
32412, 364, 365
32413, 365, 366
32414, 366, 367
32415, 367, 368
32416, 368, 369
32417, 369, 370
32418, 370, 371
32419, 371, 372
32420, 372, 373
32421, 373, 374
32422, 374, 375
32423, 375, 376
32424, 376, 377
32425, 377, 13
*ELEMENT, type=T3D2, ELSET=Line24
32426, 11, 378
32427, 378, 379
32428, 379, 380
32429, 380, 381
32430, 381, 382
32431, 382, 383
32432, 383, 384
32433, 384, 385
32434, 385, 386
32435, 386, 387
32436, 387, 388
32437, 388, 389
32438, 389, 390
32439, 390, 391
32440, 391, 392
32441, 392, 393
32442, 393, 394
32443, 394, 395
32444, 395, 396
32445, 396, 397
32446, 397, 398
32447, 398, 399
32448, 399, 400
32449, 400, 15
*ELEMENT, type=T3D2, ELSET=Line25
32450, 13, 401
32451, 401, 402
32452, 402, 403
32453, 403, 404
32454, 404, 405
32455, 405, 406
32456, 406, 407
32457, 407, 408
32458, 408, 409
32459, 409, 410
32460, 410, 411
32461, 411, 15
*ELEMENT, type=T3D2, ELSET=Line26
32462, 12, 412
32463, 412, 413
32464, 413, 414
32465, 414, 415
32466, 415, 416
32467, 416, 417
32468, 417, 418
32469, 418, 419
32470, 419, 420
32471, 420, 421
32472, 421, 422
32473, 422, 423
32474, 423, 424
32475, 424, 425
32476, 425, 426
32477, 426, 427
32478, 427, 428
32479, 428, 429
32480, 429, 430
32481, 430, 431
32482, 431, 432
32483, 432, 433
32484, 433, 434
32485, 434, 16
*ELEMENT, type=T3D2, ELSET=Line27
32486, 16, 435
32487, 435, 436
32488, 436, 437
32489, 437, 438
32490, 438, 439
32491, 439, 440
32492, 440, 441
32493, 441, 442
32494, 442, 443
32495, 443, 444
32496, 444, 445
32497, 445, 446
32498, 446, 447
32499, 447, 448
32500, 448, 449
32501, 449, 450
32502, 450, 451
32503, 451, 452
32504, 452, 453
32505, 453, 454
32506, 454, 455
32507, 455, 456
32508, 456, 457
32509, 457, 15
*ELEMENT, type=T3D2, ELSET=Line28
32510, 14, 458
32511, 458, 459
32512, 459, 460
32513, 460, 461
32514, 461, 462
32515, 462, 463
32516, 463, 464
32517, 464, 465
32518, 465, 466
32519, 466, 467
32520, 467, 468
32521, 468, 16
*ELEMENT, type=T3D2, ELSET=Line29
32522, 13, 17
*ELEMENT, type=T3D2, ELSET=Line30
32523, 14, 18
*ELEMENT, type=T3D2, ELSET=Line31
32524, 18, 469
32525, 469, 470
32526, 470, 471
32527, 471, 472
32528, 472, 473
32529, 473, 474
32530, 474, 475
32531, 475, 476
32532, 476, 477
32533, 477, 478
32534, 478, 479
32535, 479, 480
32536, 480, 481
32537, 481, 482
32538, 482, 483
32539, 483, 484
32540, 484, 485
32541, 485, 486
32542, 486, 487
32543, 487, 488
32544, 488, 489
32545, 489, 490
32546, 490, 491
32547, 491, 17
*ELEMENT, type=T3D2, ELSET=Line32
32548, 15, 19
*ELEMENT, type=T3D2, ELSET=Line33
32549, 17, 492
32550, 492, 493
32551, 493, 494
32552, 494, 495
32553, 495, 496
32554, 496, 497
32555, 497, 498
32556, 498, 499
32557, 499, 500
32558, 500, 501
32559, 501, 502
32560, 502, 19
*ELEMENT, type=T3D2, ELSET=Line34
32561, 16, 20
*ELEMENT, type=T3D2, ELSET=Line35
32562, 20, 503
32563, 503, 504
32564, 504, 505
32565, 505, 506
32566, 506, 507
32567, 507, 508
32568, 508, 509
32569, 509, 510
32570, 510, 511
32571, 511, 512
32572, 512, 513
32573, 513, 514
32574, 514, 515
32575, 515, 516
32576, 516, 517
32577, 517, 518
32578, 518, 519
32579, 519, 520
32580, 520, 521
32581, 521, 522
32582, 522, 523
32583, 523, 524
32584, 524, 525
32585, 525, 19
*ELEMENT, type=T3D2, ELSET=Line36
32586, 18, 526
32587, 526, 527
32588, 527, 528
32589, 528, 529
32590, 529, 530
32591, 530, 531
32592, 531, 532
32593, 532, 533
32594, 533, 534
32595, 534, 535
32596, 535, 536
32597, 536, 20
*ELEMENT, type=T3D2, ELSET=Line37
32598, 17, 537
32599, 537, 538
32600, 538, 21
*ELEMENT, type=T3D2, ELSET=Line38
32601, 18, 539
32602, 539, 540
32603, 540, 22
*ELEMENT, type=T3D2, ELSET=Line39
32604, 22, 541
32605, 541, 542
32606, 542, 543
32607, 543, 544
32608, 544, 545
32609, 545, 546
32610, 546, 547
32611, 547, 548
32612, 548, 549
32613, 549, 550
32614, 550, 551
32615, 551, 552
32616, 552, 553
32617, 553, 554
32618, 554, 555
32619, 555, 556
32620, 556, 557
32621, 557, 558
32622, 558, 559
32623, 559, 560
32624, 560, 561
32625, 561, 562
32626, 562, 563
32627, 563, 21
*ELEMENT, type=T3D2, ELSET=Line40
32628, 19, 564
32629, 564, 565
32630, 565, 23
*ELEMENT, type=T3D2, ELSET=Line41
32631, 21, 566
32632, 566, 567
32633, 567, 568
32634, 568, 569
32635, 569, 570
32636, 570, 571
32637, 571, 572
32638, 572, 573
32639, 573, 574
32640, 574, 575
32641, 575, 576
32642, 576, 23
*ELEMENT, type=T3D2, ELSET=Line42
32643, 20, 577
32644, 577, 578
32645, 578, 24
*ELEMENT, type=T3D2, ELSET=Line43
32646, 24, 579
32647, 579, 580
32648, 580, 581
32649, 581, 582
32650, 582, 583
32651, 583, 584
32652, 584, 585
32653, 585, 586
32654, 586, 587
32655, 587, 588
32656, 588, 589
32657, 589, 590
32658, 590, 591
32659, 591, 592
32660, 592, 593
32661, 593, 594
32662, 594, 595
32663, 595, 596
32664, 596, 597
32665, 597, 598
32666, 598, 599
32667, 599, 600
32668, 600, 601
32669, 601, 23
*ELEMENT, type=T3D2, ELSET=Line44
32670, 22, 602
32671, 602, 603
32672, 603, 604
32673, 604, 605
32674, 605, 606
32675, 606, 607
32676, 607, 608
32677, 608, 609
32678, 609, 610
32679, 610, 611
32680, 611, 612
32681, 612, 24
*ELEMENT, type=T3D2, ELSET=Line45
32682, 19, 613
32683, 613, 614
32684, 614, 615
32685, 615, 616
32686, 616, 25
*ELEMENT, type=T3D2, ELSET=Line46
32687, 23, 617
32688, 617, 618
32689, 618, 619
32690, 619, 620
32691, 620, 26
*ELEMENT, type=T3D2, ELSET=Line47
32692, 25, 621
32693, 621, 622
32694, 622, 26
*ELEMENT, type=T3D2, ELSET=Line48
32695, 17, 623
32696, 623, 624
32697, 624, 625
32698, 625, 626
32699, 626, 27
*ELEMENT, type=T3D2, ELSET=Line49
32700, 21, 627
32701, 627, 628
32702, 628, 629
32703, 629, 630
32704, 630, 28
*ELEMENT, type=T3D2, ELSET=Line50
32705, 27, 631
32706, 631, 632
32707, 632, 28
*ELEMENT, type=T3D2, ELSET=Line51
32708, 27, 633
32709, 633, 634
32710, 634, 635
32711, 635, 636
32712, 636, 637
32713, 637, 638
32714, 638, 639
32715, 639, 640
32716, 640, 641
32717, 641, 642
32718, 642, 643
32719, 643, 25
*ELEMENT, type=T3D2, ELSET=Line52
32720, 28, 644
32721, 644, 645
32722, 645, 646
32723, 646, 647
32724, 647, 648
32725, 648, 649
32726, 649, 650
32727, 650, 651
32728, 651, 652
32729, 652, 653
32730, 653, 654
32731, 654, 26
*ELEMENT, type=T3D2, ELSET=Line53
32732, 25, 655
32733, 655, 656
32734, 656, 657
32735, 657, 658
32736, 658, 659
32737, 659, 660
32738, 660, 661
32739, 661, 662
32740, 662, 663
32741, 663, 664
32742, 664, 665
32743, 665, 666
32744, 666, 667
32745, 667, 668
32746, 668, 669
32747, 669, 670
32748, 670, 671
32749, 671, 672
32750, 672, 673
32751, 673, 674
32752, 674, 675
32753, 675, 676
32754, 676, 677
32755, 677, 29
*ELEMENT, type=T3D2, ELSET=Line54
32756, 26, 678
32757, 678, 679
32758, 679, 680
32759, 680, 681
32760, 681, 682
32761, 682, 683
32762, 683, 684
32763, 684, 685
32764, 685, 686
32765, 686, 687
32766, 687, 688
32767, 688, 689
32768, 689, 690
32769, 690, 691
32770, 691, 692
32771, 692, 693
32772, 693, 694
32773, 694, 695
32774, 695, 696
32775, 696, 697
32776, 697, 698
32777, 698, 699
32778, 699, 700
32779, 700, 30
*ELEMENT, type=T3D2, ELSET=Line55
32780, 29, 701
32781, 701, 702
32782, 702, 30
*ELEMENT, type=T3D2, ELSET=Line56
32783, 27, 703
32784, 703, 704
32785, 704, 705
32786, 705, 706
32787, 706, 707
32788, 707, 708
32789, 708, 709
32790, 709, 710
32791, 710, 711
32792, 711, 712
32793, 712, 713
32794, 713, 714
32795, 714, 715
32796, 715, 716
32797, 716, 717
32798, 717, 718
32799, 718, 719
32800, 719, 720
32801, 720, 721
32802, 721, 722
32803, 722, 723
32804, 723, 724
32805, 724, 725
32806, 725, 31
*ELEMENT, type=T3D2, ELSET=Line57
32807, 28, 726
32808, 726, 727
32809, 727, 728
32810, 728, 729
32811, 729, 730
32812, 730, 731
32813, 731, 732
32814, 732, 733
32815, 733, 734
32816, 734, 735
32817, 735, 736
32818, 736, 737
32819, 737, 738
32820, 738, 739
32821, 739, 740
32822, 740, 741
32823, 741, 742
32824, 742, 743
32825, 743, 744
32826, 744, 745
32827, 745, 746
32828, 746, 747
32829, 747, 748
32830, 748, 32
*ELEMENT, type=T3D2, ELSET=Line58
32831, 31, 749
32832, 749, 750
32833, 750, 32
*ELEMENT, type=T3D2, ELSET=Line59
32834, 31, 751
32835, 751, 752
32836, 752, 753
32837, 753, 754
32838, 754, 755
32839, 755, 756
32840, 756, 757
32841, 757, 758
32842, 758, 759
32843, 759, 760
32844, 760, 761
32845, 761, 29
*ELEMENT, type=T3D2, ELSET=Line60
32846, 32, 762
32847, 762, 763
32848, 763, 764
32849, 764, 765
32850, 765, 766
32851, 766, 767
32852, 767, 768
32853, 768, 769
32854, 769, 770
32855, 770, 771
32856, 771, 772
32857, 772, 30
*ELEMENT, type=T3D2, ELSET=Line61
32858, 25, 33
*ELEMENT, type=T3D2, ELSET=Line62
32859, 29, 34
*ELEMENT, type=T3D2, ELSET=Line63
32860, 33, 773
32861, 773, 774
32862, 774, 775
32863, 775, 776
32864, 776, 777
32865, 777, 778
32866, 778, 779
32867, 779, 780
32868, 780, 781
32869, 781, 782
32870, 782, 783
32871, 783, 784
32872, 784, 785
32873, 785, 786
32874, 786, 787
32875, 787, 788
32876, 788, 789
32877, 789, 790
32878, 790, 791
32879, 791, 792
32880, 792, 793
32881, 793, 794
32882, 794, 795
32883, 795, 34
*ELEMENT, type=T3D2, ELSET=Line64
32884, 27, 35
*ELEMENT, type=T3D2, ELSET=Line65
32885, 31, 36
*ELEMENT, type=T3D2, ELSET=Line66
32886, 35, 796
32887, 796, 797
32888, 797, 798
32889, 798, 799
32890, 799, 800
32891, 800, 801
32892, 801, 802
32893, 802, 803
32894, 803, 804
32895, 804, 805
32896, 805, 806
32897, 806, 807
32898, 807, 808
32899, 808, 809
32900, 809, 810
32901, 810, 811
32902, 811, 812
32903, 812, 813
32904, 813, 814
32905, 814, 815
32906, 815, 816
32907, 816, 817
32908, 817, 818
32909, 818, 36
*ELEMENT, type=T3D2, ELSET=Line67
32910, 35, 819
32911, 819, 820
32912, 820, 821
32913, 821, 822
32914, 822, 823
32915, 823, 824
32916, 824, 825
32917, 825, 826
32918, 826, 827
32919, 827, 828
32920, 828, 829
32921, 829, 33
*ELEMENT, type=T3D2, ELSET=Line68
32922, 36, 830
32923, 830, 831
32924, 831, 832
32925, 832, 833
32926, 833, 834
32927, 834, 835
32928, 835, 836
32929, 836, 837
32930, 837, 838
32931, 838, 839
32932, 839, 840
32933, 840, 34
*ELEMENT, type=T3D2, ELSET=Line69
32934, 33, 841
32935, 841, 842
32936, 842, 843
32937, 843, 844
32938, 844, 845
32939, 845, 846
32940, 846, 847
32941, 847, 848
32942, 848, 849
32943, 849, 850
32944, 850, 851
32945, 851, 852
32946, 852, 853
32947, 853, 854
32948, 854, 855
32949, 855, 856
32950, 856, 857
32951, 857, 858
32952, 858, 859
32953, 859, 860
32954, 860, 861
32955, 861, 862
32956, 862, 863
32957, 863, 37
*ELEMENT, type=T3D2, ELSET=Line70
32958, 34, 864
32959, 864, 865
32960, 865, 866
32961, 866, 867
32962, 867, 868
32963, 868, 869
32964, 869, 870
32965, 870, 871
32966, 871, 872
32967, 872, 873
32968, 873, 874
32969, 874, 875
32970, 875, 876
32971, 876, 877
32972, 877, 878
32973, 878, 879
32974, 879, 880
32975, 880, 881
32976, 881, 882
32977, 882, 883
32978, 883, 884
32979, 884, 885
32980, 885, 886
32981, 886, 38
*ELEMENT, type=T3D2, ELSET=Line71
32982, 37, 887
32983, 887, 888
32984, 888, 889
32985, 889, 890
32986, 890, 891
32987, 891, 892
32988, 892, 893
32989, 893, 894
32990, 894, 895
32991, 895, 896
32992, 896, 897
32993, 897, 898
32994, 898, 899
32995, 899, 900
32996, 900, 901
32997, 901, 902
32998, 902, 903
32999, 903, 904
33000, 904, 905
33001, 905, 906
33002, 906, 907
33003, 907, 908
33004, 908, 909
33005, 909, 38
*ELEMENT, type=T3D2, ELSET=Line72
33006, 35, 910
33007, 910, 911
33008, 911, 912
33009, 912, 913
33010, 913, 914
33011, 914, 915
33012, 915, 916
33013, 916, 917
33014, 917, 918
33015, 918, 919
33016, 919, 920
33017, 920, 921
33018, 921, 922
33019, 922, 923
33020, 923, 924
33021, 924, 925
33022, 925, 926
33023, 926, 927
33024, 927, 928
33025, 928, 929
33026, 929, 930
33027, 930, 931
33028, 931, 932
33029, 932, 39
*ELEMENT, type=T3D2, ELSET=Line73
33030, 36, 933
33031, 933, 934
33032, 934, 935
33033, 935, 936
33034, 936, 937
33035, 937, 938
33036, 938, 939
33037, 939, 940
33038, 940, 941
33039, 941, 942
33040, 942, 943
33041, 943, 944
33042, 944, 945
33043, 945, 946
33044, 946, 947
33045, 947, 948
33046, 948, 949
33047, 949, 950
33048, 950, 951
33049, 951, 952
33050, 952, 953
33051, 953, 954
33052, 954, 955
33053, 955, 40
*ELEMENT, type=T3D2, ELSET=Line74
33054, 39, 956
33055, 956, 957
33056, 957, 958
33057, 958, 959
33058, 959, 960
33059, 960, 961
33060, 961, 962
33061, 962, 963
33062, 963, 964
33063, 964, 965
33064, 965, 966
33065, 966, 967
33066, 967, 968
33067, 968, 969
33068, 969, 970
33069, 970, 971
33070, 971, 972
33071, 972, 973
33072, 973, 974
33073, 974, 975
33074, 975, 976
33075, 976, 977
33076, 977, 978
33077, 978, 40
*ELEMENT, type=T3D2, ELSET=Line75
33078, 39, 979
33079, 979, 980
33080, 980, 981
33081, 981, 982
33082, 982, 983
33083, 983, 984
33084, 984, 985
33085, 985, 986
33086, 986, 987
33087, 987, 988
33088, 988, 989
33089, 989, 37
*ELEMENT, type=T3D2, ELSET=Line76
33090, 40, 990
33091, 990, 991
33092, 991, 992
33093, 992, 993
33094, 993, 994
33095, 994, 995
33096, 995, 996
33097, 996, 997
33098, 997, 998
33099, 998, 999
33100, 999, 1000
33101, 1000, 38
*ELEMENT, type=T3D2, ELSET=Line77
33102, 37, 41
*ELEMENT, type=T3D2, ELSET=Line78
33103, 38, 42
*ELEMENT, type=T3D2, ELSET=Line79
33104, 41, 1001
33105, 1001, 1002
33106, 1002, 1003
