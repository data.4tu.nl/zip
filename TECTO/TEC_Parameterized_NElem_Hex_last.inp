41810, 1174, 12028, 12032, 1175
41811, 12028, 12029, 12033, 12032
41812, 12029, 12030, 12034, 12033
41813, 12030, 12031, 12035, 12034
41814, 12031, 1834, 1835, 12035
41815, 1175, 12032, 12036, 1176
41816, 12032, 12033, 12037, 12036
41817, 12033, 12034, 12038, 12037
41818, 12034, 12035, 12039, 12038
41819, 12035, 1835, 1836, 12039
41820, 1176, 12036, 12040, 1177
41821, 12036, 12037, 12041, 12040
41822, 12037, 12038, 12042, 12041
41823, 12038, 12039, 12043, 12042
41824, 12039, 1836, 1837, 12043
41825, 1177, 12040, 12044, 1178
41826, 12040, 12041, 12045, 12044
41827, 12041, 12042, 12046, 12045
41828, 12042, 12043, 12047, 12046
41829, 12043, 1837, 1838, 12047
41830, 1178, 12044, 12048, 1179
41831, 12044, 12045, 12049, 12048
41832, 12045, 12046, 12050, 12049
41833, 12046, 12047, 12051, 12050
41834, 12047, 1838, 1839, 12051
41835, 1179, 12048, 12052, 1180
41836, 12048, 12049, 12053, 12052
41837, 12049, 12050, 12054, 12053
41838, 12050, 12051, 12055, 12054
41839, 12051, 1839, 1840, 12055
41840, 1180, 12052, 12056, 1181
41841, 12052, 12053, 12057, 12056
41842, 12053, 12054, 12058, 12057
41843, 12054, 12055, 12059, 12058
41844, 12055, 1840, 1841, 12059
41845, 1181, 12056, 1823, 53
41846, 12056, 12057, 1824, 1823
41847, 12057, 12058, 1825, 1824
41848, 12058, 12059, 1826, 1825
41849, 12059, 1841, 89, 1826
*ELEMENT, type=CPS4, ELSET=Surface126
4949, 86, 1812, 1831, 90
4950, 1812, 1813, 1832, 1831
4951, 1813, 1814, 1833, 1832
4952, 1814, 1815, 1834, 1833
4953, 1815, 1816, 1835, 1834
4954, 1816, 1817, 1836, 1835
4955, 1817, 1818, 1837, 1836
4956, 1818, 1819, 1838, 1837
4957, 1819, 1820, 1839, 1838
4958, 1820, 1821, 1840, 1839
4959, 1821, 1822, 1841, 1840
4960, 1822, 88, 89, 1841
*ELEMENT, type=CPS4, ELSET=Surface127
4961, 45, 1842, 12060, 1073
4962, 1842, 1843, 12061, 12060
4963, 1843, 1844, 12062, 12061
4964, 1844, 1845, 12063, 12062
4965, 1845, 91, 1850, 12063
4966, 1073, 12060, 12064, 1074
4967, 12060, 12061, 12065, 12064
4968, 12061, 12062, 12066, 12065
4969, 12062, 12063, 12067, 12066
4970, 12063, 1850, 1851, 12067
4971, 1074, 12064, 12068, 1075
4972, 12064, 12065, 12069, 12068
4973, 12065, 12066, 12070, 12069
4974, 12066, 12067, 12071, 12070
4975, 12067, 1851, 1852, 12071
4976, 1075, 12068, 12072, 1076
4977, 12068, 12069, 12073, 12072
4978, 12069, 12070, 12074, 12073
4979, 12070, 12071, 12075, 12074
4980, 12071, 1852, 1853, 12075
4981, 1076, 12072, 12076, 1077
4982, 12072, 12073, 12077, 12076
4983, 12073, 12074, 12078, 12077
4984, 12074, 12075, 12079, 12078
4985, 12075, 1853, 1854, 12079
4986, 1077, 12076, 12080, 1078
4987, 12076, 12077, 12081, 12080
4988, 12077, 12078, 12082, 12081
4989, 12078, 12079, 12083, 12082
4990, 12079, 1854, 1855, 12083
4991, 1078, 12080, 12084, 1079
4992, 12080, 12081, 12085, 12084
4993, 12081, 12082, 12086, 12085
4994, 12082, 12083, 12087, 12086
4995, 12083, 1855, 1856, 12087
4996, 1079, 12084, 12088, 1080
4997, 12084, 12085, 12089, 12088
4998, 12085, 12086, 12090, 12089
4999, 12086, 12087, 12091, 12090
5000, 12087, 1856, 1857, 12091
5001, 1080, 12088, 12092, 1081
5002, 12088, 12089, 12093, 12092
5003, 12089, 12090, 12094, 12093
5004, 12090, 12091, 12095, 12094
5005, 12091, 1857, 1858, 12095
5006, 1081, 12092, 12096, 1082
5007, 12092, 12093, 12097, 12096
5008, 12093, 12094, 12098, 12097
5009, 12094, 12095, 12099, 12098
5010, 12095, 1858, 1859, 12099
5011, 1082, 12096, 12100, 1083
5012, 12096, 12097, 12101, 12100
5013, 12097, 12098, 12102, 12101
5014, 12098, 12099, 12103, 12102
5015, 12099, 1859, 1860, 12103
5016, 1083, 12100, 12104, 1084
5017, 12100, 12101, 12105, 12104
5018, 12101, 12102, 12106, 12105
5019, 12102, 12103, 12107, 12106
5020, 12103, 1860, 1861, 12107
5021, 1084, 12104, 12108, 1085
5022, 12104, 12105, 12109, 12108
5023, 12105, 12106, 12110, 12109
5024, 12106, 12107, 12111, 12110
5025, 12107, 1861, 1862, 12111
5026, 1085, 12108, 12112, 1086
5027, 12108, 12109, 12113, 12112
5028, 12109, 12110, 12114, 12113
5029, 12110, 12111, 12115, 12114
5030, 12111, 1862, 1863, 12115
5031, 1086, 12112, 12116, 1087
5032, 12112, 12113, 12117, 12116
5033, 12113, 12114, 12118, 12117
5034, 12114, 12115, 12119, 12118
5035, 12115, 1863, 1864, 12119
5036, 1087, 12116, 12120, 1088
5037, 12116, 12117, 12121, 12120
5038, 12117, 12118, 12122, 12121
5039, 12118, 12119, 12123, 12122
5040, 12119, 1864, 1865, 12123
5041, 1088, 12120, 12124, 1089
5042, 12120, 12121, 12125, 12124
5043, 12121, 12122, 12126, 12125
5044, 12122, 12123, 12127, 12126
5045, 12123, 1865, 1866, 12127
5046, 1089, 12124, 12128, 1090
5047, 12124, 12125, 12129, 12128
5048, 12125, 12126, 12130, 12129
5049, 12126, 12127, 12131, 12130
5050, 12127, 1866, 1867, 12131
5051, 1090, 12128, 12132, 1091
5052, 12128, 12129, 12133, 12132
5053, 12129, 12130, 12134, 12133
5054, 12130, 12131, 12135, 12134
5055, 12131, 1867, 1868, 12135
5056, 1091, 12132, 12136, 1092
5057, 12132, 12133, 12137, 12136
5058, 12133, 12134, 12138, 12137
5059, 12134, 12135, 12139, 12138
5060, 12135, 1868, 1869, 12139
5061, 1092, 12136, 12140, 1093
5062, 12136, 12137, 12141, 12140
5063, 12137, 12138, 12142, 12141
5064, 12138, 12139, 12143, 12142
5065, 12139, 1869, 1870, 12143
5066, 1093, 12140, 12144, 1094
5067, 12140, 12141, 12145, 12144
5068, 12141, 12142, 12146, 12145
5069, 12142, 12143, 12147, 12146
5070, 12143, 1870, 1871, 12147
5071, 1094, 12144, 12148, 1095
5072, 12144, 12145, 12149, 12148
5073, 12145, 12146, 12150, 12149
5074, 12146, 12147, 12151, 12150
5075, 12147, 1871, 1872, 12151
5076, 1095, 12148, 1846, 46
5077, 12148, 12149, 1847, 1846
5078, 12149, 12150, 1848, 1847
5079, 12150, 12151, 1849, 1848
5080, 12151, 1872, 92, 1849
*ELEMENT, type=CPS4, ELSET=Surface128
41850, 47, 1100, 12152, 1873
41851, 1873, 12152, 12153, 1874
41852, 1874, 12153, 12154, 1875
41853, 1875, 12154, 12155, 1876
41854, 1876, 12155, 1881, 93
41855, 1100, 1101, 12156, 12152
41856, 12152, 12156, 12157, 12153
41857, 12153, 12157, 12158, 12154
41858, 12154, 12158, 12159, 12155
41859, 12155, 12159, 1882, 1881
41860, 1101, 1102, 12160, 12156
41861, 12156, 12160, 12161, 12157
41862, 12157, 12161, 12162, 12158
41863, 12158, 12162, 12163, 12159
41864, 12159, 12163, 1883, 1882
41865, 1102, 1103, 12164, 12160
41866, 12160, 12164, 12165, 12161
41867, 12161, 12165, 12166, 12162
41868, 12162, 12166, 12167, 12163
41869, 12163, 12167, 1884, 1883
41870, 1103, 1104, 12168, 12164
41871, 12164, 12168, 12169, 12165
41872, 12165, 12169, 12170, 12166
41873, 12166, 12170, 12171, 12167
41874, 12167, 12171, 1885, 1884
41875, 1104, 1105, 12172, 12168
41876, 12168, 12172, 12173, 12169
41877, 12169, 12173, 12174, 12170
41878, 12170, 12174, 12175, 12171
41879, 12171, 12175, 1886, 1885
41880, 1105, 1106, 12176, 12172
41881, 12172, 12176, 12177, 12173
41882, 12173, 12177, 12178, 12174
41883, 12174, 12178, 12179, 12175
41884, 12175, 12179, 1887, 1886
41885, 1106, 1107, 12180, 12176
41886, 12176, 12180, 12181, 12177
41887, 12177, 12181, 12182, 12178
41888, 12178, 12182, 12183, 12179
41889, 12179, 12183, 1888, 1887
41890, 1107, 1108, 12184, 12180
41891, 12180, 12184, 12185, 12181
41892, 12181, 12185, 12186, 12182
41893, 12182, 12186, 12187, 12183
41894, 12183, 12187, 1889, 1888
41895, 1108, 1109, 12188, 12184
41896, 12184, 12188, 12189, 12185
41897, 12185, 12189, 12190, 12186
41898, 12186, 12190, 12191, 12187
41899, 12187, 12191, 1890, 1889
41900, 1109, 1110, 12192, 12188
41901, 12188, 12192, 12193, 12189
41902, 12189, 12193, 12194, 12190
41903, 12190, 12194, 12195, 12191
41904, 12191, 12195, 1891, 1890
41905, 1110, 1111, 12196, 12192
41906, 12192, 12196, 12197, 12193
41907, 12193, 12197, 12198, 12194
41908, 12194, 12198, 12199, 12195
41909, 12195, 12199, 1892, 1891
41910, 1111, 1112, 12200, 12196
41911, 12196, 12200, 12201, 12197
41912, 12197, 12201, 12202, 12198
41913, 12198, 12202, 12203, 12199
41914, 12199, 12203, 1893, 1892
41915, 1112, 1113, 12204, 12200
41916, 12200, 12204, 12205, 12201
41917, 12201, 12205, 12206, 12202
41918, 12202, 12206, 12207, 12203
41919, 12203, 12207, 1894, 1893
41920, 1113, 1114, 12208, 12204
41921, 12204, 12208, 12209, 12205
41922, 12205, 12209, 12210, 12206
41923, 12206, 12210, 12211, 12207
41924, 12207, 12211, 1895, 1894
41925, 1114, 1115, 12212, 12208
41926, 12208, 12212, 12213, 12209
41927, 12209, 12213, 12214, 12210
41928, 12210, 12214, 12215, 12211
41929, 12211, 12215, 1896, 1895
41930, 1115, 1116, 12216, 12212
41931, 12212, 12216, 12217, 12213
41932, 12213, 12217, 12218, 12214
41933, 12214, 12218, 12219, 12215
41934, 12215, 12219, 1897, 1896
41935, 1116, 1117, 12220, 12216
41936, 12216, 12220, 12221, 12217
41937, 12217, 12221, 12222, 12218
41938, 12218, 12222, 12223, 12219
41939, 12219, 12223, 1898, 1897
41940, 1117, 1118, 12224, 12220
41941, 12220, 12224, 12225, 12221
41942, 12221, 12225, 12226, 12222
41943, 12222, 12226, 12227, 12223
41944, 12223, 12227, 1899, 1898
41945, 1118, 1119, 12228, 12224
41946, 12224, 12228, 12229, 12225
41947, 12225, 12229, 12230, 12226
41948, 12226, 12230, 12231, 12227
41949, 12227, 12231, 1900, 1899
41950, 1119, 1120, 12232, 12228
41951, 12228, 12232, 12233, 12229
41952, 12229, 12233, 12234, 12230
41953, 12230, 12234, 12235, 12231
41954, 12231, 12235, 1901, 1900
41955, 1120, 1121, 12236, 12232
41956, 12232, 12236, 12237, 12233
41957, 12233, 12237, 12238, 12234
41958, 12234, 12238, 12239, 12235
41959, 12235, 12239, 1902, 1901
41960, 1121, 1122, 12240, 12236
41961, 12236, 12240, 12241, 12237
41962, 12237, 12241, 12242, 12238
41963, 12238, 12242, 12243, 12239
41964, 12239, 12243, 1903, 1902
41965, 1122, 48, 1877, 12240
41966, 12240, 1877, 1878, 12241
41967, 12241, 1878, 1879, 12242
41968, 12242, 1879, 1880, 12243
41969, 12243, 1880, 94, 1903
*ELEMENT, type=CPS4, ELSET=Surface129
41970, 47, 1873, 12244, 1123
41971, 1873, 1874, 12245, 12244
41972, 1874, 1875, 12246, 12245
41973, 1875, 1876, 12247, 12246
41974, 1876, 93, 1904, 12247
41975, 1123, 12244, 12248, 1124
41976, 12244, 12245, 12249, 12248
41977, 12245, 12246, 12250, 12249
41978, 12246, 12247, 12251, 12250
41979, 12247, 1904, 1905, 12251
41980, 1124, 12248, 12252, 1125
41981, 12248, 12249, 12253, 12252
41982, 12249, 12250, 12254, 12253
41983, 12250, 12251, 12255, 12254
41984, 12251, 1905, 1906, 12255
41985, 1125, 12252, 12256, 1126
41986, 12252, 12253, 12257, 12256
41987, 12253, 12254, 12258, 12257
41988, 12254, 12255, 12259, 12258
41989, 12255, 1906, 1907, 12259
41990, 1126, 12256, 12260, 1127
41991, 12256, 12257, 12261, 12260
41992, 12257, 12258, 12262, 12261
41993, 12258, 12259, 12263, 12262
41994, 12259, 1907, 1908, 12263
41995, 1127, 12260, 12264, 1128
41996, 12260, 12261, 12265, 12264
41997, 12261, 12262, 12266, 12265
41998, 12262, 12263, 12267, 12266
41999, 12263, 1908, 1909, 12267
42000, 1128, 12264, 12268, 1129
42001, 12264, 12265, 12269, 12268
42002, 12265, 12266, 12270, 12269
42003, 12266, 12267, 12271, 12270
42004, 12267, 1909, 1910, 12271
42005, 1129, 12268, 12272, 1130
42006, 12268, 12269, 12273, 12272
42007, 12269, 12270, 12274, 12273
42008, 12270, 12271, 12275, 12274
42009, 12271, 1910, 1911, 12275
42010, 1130, 12272, 12276, 1131
42011, 12272, 12273, 12277, 12276
42012, 12273, 12274, 12278, 12277
42013, 12274, 12275, 12279, 12278
42014, 12275, 1911, 1912, 12279
42015, 1131, 12276, 12280, 1132
42016, 12276, 12277, 12281, 12280
42017, 12277, 12278, 12282, 12281
42018, 12278, 12279, 12283, 12282
42019, 12279, 1912, 1913, 12283
42020, 1132, 12280, 12284, 1133
42021, 12280, 12281, 12285, 12284
42022, 12281, 12282, 12286, 12285
42023, 12282, 12283, 12287, 12286
42024, 12283, 1913, 1914, 12287
42025, 1133, 12284, 1842, 45
42026, 12284, 12285, 1843, 1842
42027, 12285, 12286, 1844, 1843
42028, 12286, 12287, 1845, 1844
42029, 12287, 1914, 91, 1845
*ELEMENT, type=CPS4, ELSET=Surface130
42030, 48, 1134, 12288, 1877
42031, 1877, 12288, 12289, 1878
42032, 1878, 12289, 12290, 1879
42033, 1879, 12290, 12291, 1880
42034, 1880, 12291, 1915, 94
42035, 1134, 1135, 12292, 12288
42036, 12288, 12292, 12293, 12289
42037, 12289, 12293, 12294, 12290
42038, 12290, 12294, 12295, 12291
42039, 12291, 12295, 1916, 1915
42040, 1135, 1136, 12296, 12292
42041, 12292, 12296, 12297, 12293
42042, 12293, 12297, 12298, 12294
42043, 12294, 12298, 12299, 12295
42044, 12295, 12299, 1917, 1916
42045, 1136, 1137, 12300, 12296
42046, 12296, 12300, 12301, 12297
42047, 12297, 12301, 12302, 12298
42048, 12298, 12302, 12303, 12299
42049, 12299, 12303, 1918, 1917
42050, 1137, 1138, 12304, 12300
42051, 12300, 12304, 12305, 12301
42052, 12301, 12305, 12306, 12302
42053, 12302, 12306, 12307, 12303
42054, 12303, 12307, 1919, 1918
42055, 1138, 1139, 12308, 12304
42056, 12304, 12308, 12309, 12305
42057, 12305, 12309, 12310, 12306
42058, 12306, 12310, 12311, 12307
42059, 12307, 12311, 1920, 1919
42060, 1139, 1140, 12312, 12308
42061, 12308, 12312, 12313, 12309
42062, 12309, 12313, 12314, 12310
42063, 12310, 12314, 12315, 12311
42064, 12311, 12315, 1921, 1920
42065, 1140, 1141, 12316, 12312
42066, 12312, 12316, 12317, 12313
42067, 12313, 12317, 12318, 12314
42068, 12314, 12318, 12319, 12315
42069, 12315, 12319, 1922, 1921
42070, 1141, 1142, 12320, 12316
42071, 12316, 12320, 12321, 12317
42072, 12317, 12321, 12322, 12318
42073, 12318, 12322, 12323, 12319
42074, 12319, 12323, 1923, 1922
42075, 1142, 1143, 12324, 12320
42076, 12320, 12324, 12325, 12321
42077, 12321, 12325, 12326, 12322
42078, 12322, 12326, 12327, 12323
42079, 12323, 12327, 1924, 1923
42080, 1143, 1144, 12328, 12324
42081, 12324, 12328, 12329, 12325
42082, 12325, 12329, 12330, 12326
42083, 12326, 12330, 12331, 12327
42084, 12327, 12331, 1925, 1924
42085, 1144, 46, 1846, 12328
42086, 12328, 1846, 1847, 12329
42087, 12329, 1847, 1848, 12330
42088, 12330, 1848, 1849, 12331
42089, 12331, 1849, 92, 1925
*ELEMENT, type=CPS4, ELSET=Surface131
5081, 93, 1881, 12332, 1904
5082, 1881, 1882, 12333, 12332
5083, 1882, 1883, 12334, 12333
5084, 1883, 1884, 12335, 12334
5085, 1884, 1885, 12336, 12335
5086, 1885, 1886, 12337, 12336
5087, 1886, 1887, 12338, 12337
5088, 1887, 1888, 12339, 12338
5089, 1888, 1889, 12340, 12339
5090, 1889, 1890, 12341, 12340
5091, 1890, 1891, 12342, 12341
5092, 1891, 1892, 12343, 12342
5093, 1892, 1893, 12344, 12343
5094, 1893, 1894, 12345, 12344
5095, 1894, 1895, 12346, 12345
5096, 1895, 1896, 12347, 12346
5097, 1896, 1897, 12348, 12347
5098, 1897, 1898, 12349, 12348
5099, 1898, 1899, 12350, 12349
5100, 1899, 1900, 12351, 12350
5101, 1900, 1901, 12352, 12351
5102, 1901, 1902, 12353, 12352
5103, 1902, 1903, 12354, 12353
5104, 1903, 94, 1915, 12354
5105, 1904, 12332, 12355, 1905
5106, 12332, 12333, 12356, 12355
5107, 12333, 12334, 12357, 12356
5108, 12334, 12335, 12358, 12357
5109, 12335, 12336, 12359, 12358
5110, 12336, 12337, 12360, 12359
5111, 12337, 12338, 12361, 12360
5112, 12338, 12339, 12362, 12361
5113, 12339, 12340, 12363, 12362
5114, 12340, 12341, 12364, 12363
5115, 12341, 12342, 12365, 12364
5116, 12342, 12343, 12366, 12365
5117, 12343, 12344, 12367, 12366
5118, 12344, 12345, 12368, 12367
5119, 12345, 12346, 12369, 12368
5120, 12346, 12347, 12370, 12369
5121, 12347, 12348, 12371, 12370
5122, 12348, 12349, 12372, 12371
5123, 12349, 12350, 12373, 12372
5124, 12350, 12351, 12374, 12373
5125, 12351, 12352, 12375, 12374
5126, 12352, 12353, 12376, 12375
5127, 12353, 12354, 12377, 12376
5128, 12354, 1915, 1916, 12377
5129, 1905, 12355, 12378, 1906
5130, 12355, 12356, 12379, 12378
5131, 12356, 12357, 12380, 12379
5132, 12357, 12358, 12381, 12380
5133, 12358, 12359, 12382, 12381
5134, 12359, 12360, 12383, 12382
5135, 12360, 12361, 12384, 12383
5136, 12361, 12362, 12385, 12384
5137, 12362, 12363, 12386, 12385
5138, 12363, 12364, 12387, 12386
5139, 12364, 12365, 12388, 12387
5140, 12365, 12366, 12389, 12388
5141, 12366, 12367, 12390, 12389
5142, 12367, 12368, 12391, 12390
5143, 12368, 12369, 12392, 12391
5144, 12369, 12370, 12393, 12392
5145, 12370, 12371, 12394, 12393
5146, 12371, 12372, 12395, 12394
5147, 12372, 12373, 12396, 12395
5148, 12373, 12374, 12397, 12396
5149, 12374, 12375, 12398, 12397
5150, 12375, 12376, 12399, 12398
5151, 12376, 12377, 12400, 12399
5152, 12377, 1916, 1917, 12400
5153, 1906, 12378, 12401, 1907
5154, 12378, 12379, 12402, 12401
5155, 12379, 12380, 12403, 12402
5156, 12380, 12381, 12404, 12403
5157, 12381, 12382, 12405, 12404
5158, 12382, 12383, 12406, 12405
5159, 12383, 12384, 12407, 12406
5160, 12384, 12385, 12408, 12407
5161, 12385, 12386, 12409, 12408
5162, 12386, 12387, 12410, 12409
5163, 12387, 12388, 12411, 12410
5164, 12388, 12389, 12412, 12411
5165, 12389, 12390, 12413, 12412
5166, 12390, 12391, 12414, 12413
5167, 12391, 12392, 12415, 12414
5168, 12392, 12393, 12416, 12415
5169, 12393, 12394, 12417, 12416
5170, 12394, 12395, 12418, 12417
5171, 12395, 12396, 12419, 12418
5172, 12396, 12397, 12420, 12419
5173, 12397, 12398, 12421, 12420
5174, 12398, 12399, 12422, 12421
5175, 12399, 12400, 12423, 12422
5176, 12400, 1917, 1918, 12423
5177, 1907, 12401, 12424, 1908
5178, 12401, 12402, 12425, 12424
5179, 12402, 12403, 12426, 12425
5180, 12403, 12404, 12427, 12426
5181, 12404, 12405, 12428, 12427
5182, 12405, 12406, 12429, 12428
5183, 12406, 12407, 12430, 12429
5184, 12407, 12408, 12431, 12430
5185, 12408, 12409, 12432, 12431
5186, 12409, 12410, 12433, 12432
5187, 12410, 12411, 12434, 12433
5188, 12411, 12412, 12435, 12434
5189, 12412, 12413, 12436, 12435
5190, 12413, 12414, 12437, 12436
5191, 12414, 12415, 12438, 12437
5192, 12415, 12416, 12439, 12438
5193, 12416, 12417, 12440, 12439
5194, 12417, 12418, 12441, 12440
5195, 12418, 12419, 12442, 12441
5196, 12419, 12420, 12443, 12442
5197, 12420, 12421, 12444, 12443
5198, 12421, 12422, 12445, 12444
5199, 12422, 12423, 12446, 12445
5200, 12423, 1918, 1919, 12446
5201, 1908, 12424, 12447, 1909
5202, 12424, 12425, 12448, 12447
5203, 12425, 12426, 12449, 12448
5204, 12426, 12427, 12450, 12449
5205, 12427, 12428, 12451, 12450
5206, 12428, 12429, 12452, 12451
5207, 12429, 12430, 12453, 12452
5208, 12430, 12431, 12454, 12453
5209, 12431, 12432, 12455, 12454
5210, 12432, 12433, 12456, 12455
5211, 12433, 12434, 12457, 12456
5212, 12434, 12435, 12458, 12457
5213, 12435, 12436, 12459, 12458
5214, 12436, 12437, 12460, 12459
5215, 12437, 12438, 12461, 12460
5216, 12438, 12439, 12462, 12461
5217, 12439, 12440, 12463, 12462
5218, 12440, 12441, 12464, 12463
5219, 12441, 12442, 12465, 12464
5220, 12442, 12443, 12466, 12465
5221, 12443, 12444, 12467, 12466
5222, 12444, 12445, 12468, 12467
5223, 12445, 12446, 12469, 12468
5224, 12446, 1919, 1920, 12469
5225, 1909, 12447, 12470, 1910
5226, 12447, 12448, 12471, 12470
5227, 12448, 12449, 12472, 12471
5228, 12449, 12450, 12473, 12472
5229, 12450, 12451, 12474, 12473
5230, 12451, 12452, 12475, 12474
5231, 12452, 12453, 12476, 12475
5232, 12453, 12454, 12477, 12476
5233, 12454, 12455, 12478, 12477
5234, 12455, 12456, 12479, 12478
5235, 12456, 12457, 12480, 12479
5236, 12457, 12458, 12481, 12480
5237, 12458, 12459, 12482, 12481
5238, 12459, 12460, 12483, 12482
5239, 12460, 12461, 12484, 12483
5240, 12461, 12462, 12485, 12484
5241, 12462, 12463, 12486, 12485
5242, 12463, 12464, 12487, 12486
5243, 12464, 12465, 12488, 12487
5244, 12465, 12466, 12489, 12488
5245, 12466, 12467, 12490, 12489
5246, 12467, 12468, 12491, 12490
5247, 12468, 12469, 12492, 12491
5248, 12469, 1920, 1921, 12492
5249, 1910, 12470, 12493, 1911
5250, 12470, 12471, 12494, 12493
5251, 12471, 12472, 12495, 12494
5252, 12472, 12473, 12496, 12495
5253, 12473, 12474, 12497, 12496
5254, 12474, 12475, 12498, 12497
5255, 12475, 12476, 12499, 12498
5256, 12476, 12477, 12500, 12499
5257, 12477, 12478, 12501, 12500
5258, 12478, 12479, 12502, 12501
5259, 12479, 12480, 12503, 12502
5260, 12480, 12481, 12504, 12503
5261, 12481, 12482, 12505, 12504
5262, 12482, 12483, 12506, 12505
5263, 12483, 12484, 12507, 12506
5264, 12484, 12485, 12508, 12507
5265, 12485, 12486, 12509, 12508
5266, 12486, 12487, 12510, 12509
5267, 12487, 12488, 12511, 12510
5268, 12488, 12489, 12512, 12511
5269, 12489, 12490, 12513, 12512
5270, 12490, 12491, 12514, 12513
5271, 12491, 12492, 12515, 12514
5272, 12492, 1921, 1922, 12515
5273, 1911, 12493, 12516, 1912
5274, 12493, 12494, 12517, 12516
5275, 12494, 12495, 12518, 12517
5276, 12495, 12496, 12519, 12518
5277, 12496, 12497, 12520, 12519
5278, 12497, 12498, 12521, 12520
5279, 12498, 12499, 12522, 12521
5280, 12499, 12500, 12523, 12522
5281, 12500, 12501, 12524, 12523
5282, 12501, 12502, 12525, 12524
5283, 12502, 12503, 12526, 12525
5284, 12503, 12504, 12527, 12526
5285, 12504, 12505, 12528, 12527
5286, 12505, 12506, 12529, 12528
5287, 12506, 12507, 12530, 12529
5288, 12507, 12508, 12531, 12530
5289, 12508, 12509, 12532, 12531
5290, 12509, 12510, 12533, 12532
5291, 12510, 12511, 12534, 12533
5292, 12511, 12512, 12535, 12534
5293, 12512, 12513, 12536, 12535
5294, 12513, 12514, 12537, 12536
5295, 12514, 12515, 12538, 12537
5296, 12515, 1922, 1923, 12538
5297, 1912, 12516, 12539, 1913
5298, 12516, 12517, 12540, 12539
5299, 12517, 12518, 12541, 12540
5300, 12518, 12519, 12542, 12541
5301, 12519, 12520, 12543, 12542
5302, 12520, 12521, 12544, 12543
5303, 12521, 12522, 12545, 12544
5304, 12522, 12523, 12546, 12545
5305, 12523, 12524, 12547, 12546
5306, 12524, 12525, 12548, 12547
5307, 12525, 12526, 12549, 12548
5308, 12526, 12527, 12550, 12549
5309, 12527, 12528, 12551, 12550
5310, 12528, 12529, 12552, 12551
5311, 12529, 12530, 12553, 12552
5312, 12530, 12531, 12554, 12553
5313, 12531, 12532, 12555, 12554
5314, 12532, 12533, 12556, 12555
5315, 12533, 12534, 12557, 12556
5316, 12534, 12535, 12558, 12557
5317, 12535, 12536, 12559, 12558
5318, 12536, 12537, 12560, 12559
5319, 12537, 12538, 12561, 12560
5320, 12538, 1923, 1924, 12561
5321, 1913, 12539, 12562, 1914
5322, 12539, 12540, 12563, 12562
5323, 12540, 12541, 12564, 12563
5324, 12541, 12542, 12565, 12564
5325, 12542, 12543, 12566, 12565
5326, 12543, 12544, 12567, 12566
5327, 12544, 12545, 12568, 12567
5328, 12545, 12546, 12569, 12568
5329, 12546, 12547, 12570, 12569
5330, 12547, 12548, 12571, 12570
5331, 12548, 12549, 12572, 12571
5332, 12549, 12550, 12573, 12572
5333, 12550, 12551, 12574, 12573
5334, 12551, 12552, 12575, 12574
5335, 12552, 12553, 12576, 12575
5336, 12553, 12554, 12577, 12576
5337, 12554, 12555, 12578, 12577
5338, 12555, 12556, 12579, 12578
5339, 12556, 12557, 12580, 12579
5340, 12557, 12558, 12581, 12580
5341, 12558, 12559, 12582, 12581
5342, 12559, 12560, 12583, 12582
5343, 12560, 12561, 12584, 12583
5344, 12561, 1924, 1925, 12584
5345, 1914, 12562, 1850, 91
5346, 12562, 12563, 1851, 1850
5347, 12563, 12564, 1852, 1851
5348, 12564, 12565, 1853, 1852
5349, 12565, 12566, 1854, 1853
5350, 12566, 12567, 1855, 1854
5351, 12567, 12568, 1856, 1855
5352, 12568, 12569, 1857, 1856
5353, 12569, 12570, 1858, 1857
5354, 12570, 12571, 1859, 1858
5355, 12571, 12572, 1860, 1859
5356, 12572, 12573, 1861, 1860
5357, 12573, 12574, 1862, 1861
5358, 12574, 12575, 1863, 1862
5359, 12575, 12576, 1864, 1863
5360, 12576, 12577, 1865, 1864
5361, 12577, 12578, 1866, 1865
5362, 12578, 12579, 1867, 1866
5363, 12579, 12580, 1868, 1867
5364, 12580, 12581, 1869, 1868
5365, 12581, 12582, 1870, 1869
5366, 12582, 12583, 1871, 1870
5367, 12583, 12584, 1872, 1871
5368, 12584, 1925, 92, 1872
*ELEMENT, type=CPS4, ELSET=Surface132
5369, 46, 1846, 1926, 50
5370, 1846, 1847, 1927, 1926
5371, 1847, 1848, 1928, 1927
5372, 1848, 1849, 1929, 1928
5373, 1849, 92, 95, 1929
*ELEMENT, type=CPS4, ELSET=Surface133
42090, 48, 52, 1930, 1877
42091, 1877, 1930, 1931, 1878
42092, 1878, 1931, 1932, 1879
42093, 1879, 1932, 1933, 1880
42094, 1880, 1933, 96, 94
*ELEMENT, type=CPS4, ELSET=Surface134
42095, 52, 1160, 12585, 1930
42096, 1930, 12585, 12586, 1931
42097, 1931, 12586, 12587, 1932
42098, 1932, 12587, 12588, 1933
42099, 1933, 12588, 1934, 96
42100, 1160, 1161, 12589, 12585
42101, 12585, 12589, 12590, 12586
42102, 12586, 12590, 12591, 12587
42103, 12587, 12591, 12592, 12588
42104, 12588, 12592, 1935, 1934
42105, 1161, 1162, 12593, 12589
42106, 12589, 12593, 12594, 12590
42107, 12590, 12594, 12595, 12591
42108, 12591, 12595, 12596, 12592
42109, 12592, 12596, 1936, 1935
42110, 1162, 1163, 12597, 12593
42111, 12593, 12597, 12598, 12594
42112, 12594, 12598, 12599, 12595
42113, 12595, 12599, 12600, 12596
42114, 12596, 12600, 1937, 1936
42115, 1163, 1164, 12601, 12597
42116, 12597, 12601, 12602, 12598
42117, 12598, 12602, 12603, 12599
42118, 12599, 12603, 12604, 12600
42119, 12600, 12604, 1938, 1937
42120, 1164, 1165, 12605, 12601
42121, 12601, 12605, 12606, 12602
42122, 12602, 12606, 12607, 12603
42123, 12603, 12607, 12608, 12604
42124, 12604, 12608, 1939, 1938
42125, 1165, 1166, 12609, 12605
42126, 12605, 12609, 12610, 12606
42127, 12606, 12610, 12611, 12607
42128, 12607, 12611, 12612, 12608
42129, 12608, 12612, 1940, 1939
42130, 1166, 1167, 12613, 12609
42131, 12609, 12613, 12614, 12610
42132, 12610, 12614, 12615, 12611
42133, 12611, 12615, 12616, 12612
42134, 12612, 12616, 1941, 1940
42135, 1167, 1168, 12617, 12613
42136, 12613, 12617, 12618, 12614
42137, 12614, 12618, 12619, 12615
42138, 12615, 12619, 12620, 12616
42139, 12616, 12620, 1942, 1941
42140, 1168, 1169, 12621, 12617
42141, 12617, 12621, 12622, 12618
42142, 12618, 12622, 12623, 12619
42143, 12619, 12623, 12624, 12620
42144, 12620, 12624, 1943, 1942
42145, 1169, 1170, 12625, 12621
42146, 12621, 12625, 12626, 12622
42147, 12622, 12626, 12627, 12623
42148, 12623, 12627, 12628, 12624
42149, 12624, 12628, 1944, 1943
42150, 1170, 50, 1926, 12625
42151, 12625, 1926, 1927, 12626
42152, 12626, 1927, 1928, 12627
42153, 12627, 1928, 1929, 12628
42154, 12628, 1929, 95, 1944
*ELEMENT, type=CPS4, ELSET=Surface135
5374, 94, 96, 1934, 1915
5375, 1915, 1934, 1935, 1916
5376, 1916, 1935, 1936, 1917
5377, 1917, 1936, 1937, 1918
5378, 1918, 1937, 1938, 1919
5379, 1919, 1938, 1939, 1920
5380, 1920, 1939, 1940, 1921
5381, 1921, 1940, 1941, 1922
5382, 1922, 1941, 1942, 1923
5383, 1923, 1942, 1943, 1924
5384, 1924, 1943, 1944, 1925
5385, 1925, 1944, 95, 92
*ELEMENT, type=C3D8, ELSET=Volume1
5386, 1945, 97, 2, 121, 12629, 1989, 149, 2495
5387, 12629, 1989, 149, 2495, 12630, 2000, 150, 2496
5388, 12630, 2000, 150, 2496, 12631, 2011, 151, 2497
5389, 12631, 2011, 151, 2497, 12632, 2022, 152, 2498
5390, 12632, 2022, 152, 2498, 12633, 2033, 153, 2499
5391, 12633, 2033, 153, 2499, 12634, 2044, 154, 2500
5392, 12634, 2044, 154, 2500, 12635, 2055, 155, 2501
5393, 12635, 2055, 155, 2501, 12636, 2066, 156, 2502
5394, 12636, 2066, 156, 2502, 12637, 2077, 157, 2503
5395, 12637, 2077, 157, 2503, 12638, 2088, 158, 2504
5396, 12638, 2088, 158, 2504, 12639, 2099, 159, 2505
5397, 12639, 2099, 159, 2505, 12640, 2110, 160, 2506
5398, 12640, 2110, 160, 2506, 12641, 2121, 161, 2507
5399, 12641, 2121, 161, 2507, 12642, 2132, 162, 2508
5400, 12642, 2132, 162, 2508, 12643, 2143, 163, 2509
5401, 12643, 2143, 163, 2509, 12644, 2154, 164, 2510
5402, 12644, 2154, 164, 2510, 12645, 2165, 165, 2511
5403, 12645, 2165, 165, 2511, 12646, 2176, 166, 2512
5404, 12646, 2176, 166, 2512, 12647, 2187, 167, 2513
5405, 12647, 2187, 167, 2513, 12648, 2198, 168, 2514
5406, 12648, 2198, 168, 2514, 12649, 2209, 169, 2515
5407, 12649, 2209, 169, 2515, 12650, 2220, 170, 2516
5408, 12650, 2220, 170, 2516, 12651, 2231, 171, 2517
5409, 12651, 2231, 171, 2517, 1967, 123, 6, 147
5410, 1946, 1945, 121, 122, 12652, 12629, 2495, 2518
5411, 12652, 12629, 2495, 2518, 12653, 12630, 2496, 2519
5412, 12653, 12630, 2496, 2519, 12654, 12631, 2497, 2520
5413, 12654, 12631, 2497, 2520, 12655, 12632, 2498, 2521
5414, 12655, 12632, 2498, 2521, 12656, 12633, 2499, 2522
5415, 12656, 12633, 2499, 2522, 12657, 12634, 2500, 2523
5416, 12657, 12634, 2500, 2523, 12658, 12635, 2501, 2524
5417, 12658, 12635, 2501, 2524, 12659, 12636, 2502, 2525
5418, 12659, 12636, 2502, 2525, 12660, 12637, 2503, 2526
5419, 12660, 12637, 2503, 2526, 12661, 12638, 2504, 2527
5420, 12661, 12638, 2504, 2527, 12662, 12639, 2505, 2528
5421, 12662, 12639, 2505, 2528, 12663, 12640, 2506, 2529
5422, 12663, 12640, 2506, 2529, 12664, 12641, 2507, 2530
5423, 12664, 12641, 2507, 2530, 12665, 12642, 2508, 2531
5424, 12665, 12642, 2508, 2531, 12666, 12643, 2509, 2532
5425, 12666, 12643, 2509, 2532, 12667, 12644, 2510, 2533
5426, 12667, 12644, 2510, 2533, 12668, 12645, 2511, 2534
5427, 12668, 12645, 2511, 2534, 12669, 12646, 2512, 2535
5428, 12669, 12646, 2512, 2535, 12670, 12647, 2513, 2536
5429, 12670, 12647, 2513, 2536, 12671, 12648, 2514, 2537
5430, 12671, 12648, 2514, 2537, 12672, 12649, 2515, 2538
5431, 12672, 12649, 2515, 2538, 12673, 12650, 2516, 2539
5432, 12673, 12650, 2516, 2539, 12674, 12651, 2517, 2540
5433, 12674, 12651, 2517, 2540, 1968, 1967, 147, 148
5434, 110, 1946, 122, 4, 2242, 12652, 2518, 195
5435, 2242, 12652, 2518, 195, 2253, 12653, 2519, 196
5436, 2253, 12653, 2519, 196, 2264, 12654, 2520, 197
5437, 2264, 12654, 2520, 197, 2275, 12655, 2521, 198
5438, 2275, 12655, 2521, 198, 2286, 12656, 2522, 199
5439, 2286, 12656, 2522, 199, 2297, 12657, 2523, 200
5440, 2297, 12657, 2523, 200, 2308, 12658, 2524, 201
5441, 2308, 12658, 2524, 201, 2319, 12659, 2525, 202
5442, 2319, 12659, 2525, 202, 2330, 12660, 2526, 203
5443, 2330, 12660, 2526, 203, 2341, 12661, 2527, 204
5444, 2341, 12661, 2527, 204, 2352, 12662, 2528, 205
5445, 2352, 12662, 2528, 205, 2363, 12663, 2529, 206
5446, 2363, 12663, 2529, 206, 2374, 12664, 2530, 207
5447, 2374, 12664, 2530, 207, 2385, 12665, 2531, 208
5448, 2385, 12665, 2531, 208, 2396, 12666, 2532, 209
5449, 2396, 12666, 2532, 209, 2407, 12667, 2533, 210
5450, 2407, 12667, 2533, 210, 2418, 12668, 2534, 211
5451, 2418, 12668, 2534, 211, 2429, 12669, 2535, 212
5452, 2429, 12669, 2535, 212, 2440, 12670, 2536, 213
5453, 2440, 12670, 2536, 213, 2451, 12671, 2537, 214
5454, 2451, 12671, 2537, 214, 2462, 12672, 2538, 215
5455, 2462, 12672, 2538, 215, 2473, 12673, 2539, 216
5456, 2473, 12673, 2539, 216, 2484, 12674, 2540, 217
5457, 2484, 12674, 2540, 217, 136, 1968, 148, 8
5458, 1947, 98, 97, 1945, 12675, 1990, 1989, 12629
5459, 12675, 1990, 1989, 12629, 12676, 2001, 2000, 12630
5460, 12676, 2001, 2000, 12630, 12677, 2012, 2011, 12631
5461, 12677, 2012, 2011, 12631, 12678, 2023, 2022, 12632
5462, 12678, 2023, 2022, 12632, 12679, 2034, 2033, 12633
5463, 12679, 2034, 2033, 12633, 12680, 2045, 2044, 12634
5464, 12680, 2045, 2044, 12634, 12681, 2056, 2055, 12635
5465, 12681, 2056, 2055, 12635, 12682, 2067, 2066, 12636
5466, 12682, 2067, 2066, 12636, 12683, 2078, 2077, 12637
5467, 12683, 2078, 2077, 12637, 12684, 2089, 2088, 12638
5468, 12684, 2089, 2088, 12638, 12685, 2100, 2099, 12639
5469, 12685, 2100, 2099, 12639, 12686, 2111, 2110, 12640
5470, 12686, 2111, 2110, 12640, 12687, 2122, 2121, 12641
5471, 12687, 2122, 2121, 12641, 12688, 2133, 2132, 12642
5472, 12688, 2133, 2132, 12642, 12689, 2144, 2143, 12643
5473, 12689, 2144, 2143, 12643, 12690, 2155, 2154, 12644
5474, 12690, 2155, 2154, 12644, 12691, 2166, 2165, 12645
5475, 12691, 2166, 2165, 12645, 12692, 2177, 2176, 12646
5476, 12692, 2177, 2176, 12646, 12693, 2188, 2187, 12647
5477, 12693, 2188, 2187, 12647, 12694, 2199, 2198, 12648
5478, 12694, 2199, 2198, 12648, 12695, 2210, 2209, 12649
5479, 12695, 2210, 2209, 12649, 12696, 2221, 2220, 12650
5480, 12696, 2221, 2220, 12650, 12697, 2232, 2231, 12651
5481, 12697, 2232, 2231, 12651, 1969, 124, 123, 1967
5482, 1948, 1947, 1945, 1946, 12698, 12675, 12629, 12652
5483, 12698, 12675, 12629, 12652, 12699, 12676, 12630, 12653
5484, 12699, 12676, 12630, 12653, 12700, 12677, 12631, 12654
5485, 12700, 12677, 12631, 12654, 12701, 12678, 12632, 12655
5486, 12701, 12678, 12632, 12655, 12702, 12679, 12633, 12656
5487, 12702, 12679, 12633, 12656, 12703, 12680, 12634, 12657
5488, 12703, 12680, 12634, 12657, 12704, 12681, 12635, 12658
5489, 12704, 12681, 12635, 12658, 12705, 12682, 12636, 12659
5490, 12705, 12682, 12636, 12659, 12706, 12683, 12637, 12660
5491, 12706, 12683, 12637, 12660, 12707, 12684, 12638, 12661
5492, 12707, 12684, 12638, 12661, 12708, 12685, 12639, 12662
5493, 12708, 12685, 12639, 12662, 12709, 12686, 12640, 12663
5494, 12709, 12686, 12640, 12663, 12710, 12687, 12641, 12664
5495, 12710, 12687, 12641, 12664, 12711, 12688, 12642, 12665
5496, 12711, 12688, 12642, 12665, 12712, 12689, 12643, 12666
5497, 12712, 12689, 12643, 12666, 12713, 12690, 12644, 12667
5498, 12713, 12690, 12644, 12667, 12714, 12691, 12645, 12668
5499, 12714, 12691, 12645, 12668, 12715, 12692, 12646, 12669
5500, 12715, 12692, 12646, 12669, 12716, 12693, 12647, 12670
5501, 12716, 12693, 12647, 12670, 12717, 12694, 12648, 12671
5502, 12717, 12694, 12648, 12671, 12718, 12695, 12649, 12672
5503, 12718, 12695, 12649, 12672, 12719, 12696, 12650, 12673
5504, 12719, 12696, 12650, 12673, 12720, 12697, 12651, 12674
5505, 12720, 12697, 12651, 12674, 1970, 1969, 1967, 1968
5506, 111, 1948, 1946, 110, 2243, 12698, 12652, 2242
5507, 2243, 12698, 12652, 2242, 2254, 12699, 12653, 2253
5508, 2254, 12699, 12653, 2253, 2265, 12700, 12654, 2264
5509, 2265, 12700, 12654, 2264, 2276, 12701, 12655, 2275
5510, 2276, 12701, 12655, 2275, 2287, 12702, 12656, 2286
5511, 2287, 12702, 12656, 2286, 2298, 12703, 12657, 2297
5512, 2298, 12703, 12657, 2297, 2309, 12704, 12658, 2308
5513, 2309, 12704, 12658, 2308, 2320, 12705, 12659, 2319
5514, 2320, 12705, 12659, 2319, 2331, 12706, 12660, 2330
5515, 2331, 12706, 12660, 2330, 2342, 12707, 12661, 2341
5516, 2342, 12707, 12661, 2341, 2353, 12708, 12662, 2352
5517, 2353, 12708, 12662, 2352, 2364, 12709, 12663, 2363
5518, 2364, 12709, 12663, 2363, 2375, 12710, 12664, 2374
5519, 2375, 12710, 12664, 2374, 2386, 12711, 12665, 2385
5520, 2386, 12711, 12665, 2385, 2397, 12712, 12666, 2396
5521, 2397, 12712, 12666, 2396, 2408, 12713, 12667, 2407
5522, 2408, 12713, 12667, 2407, 2419, 12714, 12668, 2418
5523, 2419, 12714, 12668, 2418, 2430, 12715, 12669, 2429
5524, 2430, 12715, 12669, 2429, 2441, 12716, 12670, 2440
5525, 2441, 12716, 12670, 2440, 2452, 12717, 12671, 2451
5526, 2452, 12717, 12671, 2451, 2463, 12718, 12672, 2462
5527, 2463, 12718, 12672, 2462, 2474, 12719, 12673, 2473
5528, 2474, 12719, 12673, 2473, 2485, 12720, 12674, 2484
5529, 2485, 12720, 12674, 2484, 137, 1970, 1968, 136
5530, 1949, 99, 98, 1947, 12721, 1991, 1990, 12675
5531, 12721, 1991, 1990, 12675, 12722, 2002, 2001, 12676
5532, 12722, 2002, 2001, 12676, 12723, 2013, 2012, 12677
5533, 12723, 2013, 2012, 12677, 12724, 2024, 2023, 12678
5534, 12724, 2024, 2023, 12678, 12725, 2035, 2034, 12679
5535, 12725, 2035, 2034, 12679, 12726, 2046, 2045, 12680
5536, 12726, 2046, 2045, 12680, 12727, 2057, 2056, 12681
5537, 12727, 2057, 2056, 12681, 12728, 2068, 2067, 12682
5538, 12728, 2068, 2067, 12682, 12729, 2079, 2078, 12683
5539, 12729, 2079, 2078, 12683, 12730, 2090, 2089, 12684
5540, 12730, 2090, 2089, 12684, 12731, 2101, 2100, 12685
5541, 12731, 2101, 2100, 12685, 12732, 2112, 2111, 12686
5542, 12732, 2112, 2111, 12686, 12733, 2123, 2122, 12687
5543, 12733, 2123, 2122, 12687, 12734, 2134, 2133, 12688
5544, 12734, 2134, 2133, 12688, 12735, 2145, 2144, 12689
5545, 12735, 2145, 2144, 12689, 12736, 2156, 2155, 12690
5546, 12736, 2156, 2155, 12690, 12737, 2167, 2166, 12691
5547, 12737, 2167, 2166, 12691, 12738, 2178, 2177, 12692
5548, 12738, 2178, 2177, 12692, 12739, 2189, 2188, 12693
5549, 12739, 2189, 2188, 12693, 12740, 2200, 2199, 12694
5550, 12740, 2200, 2199, 12694, 12741, 2211, 2210, 12695
5551, 12741, 2211, 2210, 12695, 12742, 2222, 2221, 12696
5552, 12742, 2222, 2221, 12696, 12743, 2233, 2232, 12697
5553, 12743, 2233, 2232, 12697, 1971, 125, 124, 1969
5554, 1950, 1949, 1947, 1948, 12744, 12721, 12675, 12698
5555, 12744, 12721, 12675, 12698, 12745, 12722, 12676, 12699
5556, 12745, 12722, 12676, 12699, 12746, 12723, 12677, 12700
5557, 12746, 12723, 12677, 12700, 12747, 12724, 12678, 12701
5558, 12747, 12724, 12678, 12701, 12748, 12725, 12679, 12702
5559, 12748, 12725, 12679, 12702, 12749, 12726, 12680, 12703
5560, 12749, 12726, 12680, 12703, 12750, 12727, 12681, 12704
5561, 12750, 12727, 12681, 12704, 12751, 12728, 12682, 12705
5562, 12751, 12728, 12682, 12705, 12752, 12729, 12683, 12706
5563, 12752, 12729, 12683, 12706, 12753, 12730, 12684, 12707
5564, 12753, 12730, 12684, 12707, 12754, 12731, 12685, 12708
5565, 12754, 12731, 12685, 12708, 12755, 12732, 12686, 12709
5566, 12755, 12732, 12686, 12709, 12756, 12733, 12687, 12710
5567, 12756, 12733, 12687, 12710, 12757, 12734, 12688, 12711
5568, 12757, 12734, 12688, 12711, 12758, 12735, 12689, 12712
5569, 12758, 12735, 12689, 12712, 12759, 12736, 12690, 12713
5570, 12759, 12736, 12690, 12713, 12760, 12737, 12691, 12714
5571, 12760, 12737, 12691, 12714, 12761, 12738, 12692, 12715
5572, 12761, 12738, 12692, 12715, 12762, 12739, 12693, 12716
5573, 12762, 12739, 12693, 12716, 12763, 12740, 12694, 12717
5574, 12763, 12740, 12694, 12717, 12764, 12741, 12695, 12718
5575, 12764, 12741, 12695, 12718, 12765, 12742, 12696, 12719
5576, 12765, 12742, 12696, 12719, 12766, 12743, 12697, 12720
5577, 12766, 12743, 12697, 12720, 1972, 1971, 1969, 1970
5578, 112, 1950, 1948, 111, 2244, 12744, 12698, 2243
5579, 2244, 12744, 12698, 2243, 2255, 12745, 12699, 2254
5580, 2255, 12745, 12699, 2254, 2266, 12746, 12700, 2265
5581, 2266, 12746, 12700, 2265, 2277, 12747, 12701, 2276
5582, 2277, 12747, 12701, 2276, 2288, 12748, 12702, 2287
5583, 2288, 12748, 12702, 2287, 2299, 12749, 12703, 2298
5584, 2299, 12749, 12703, 2298, 2310, 12750, 12704, 2309
5585, 2310, 12750, 12704, 2309, 2321, 12751, 12705, 2320
5586, 2321, 12751, 12705, 2320, 2332, 12752, 12706, 2331
5587, 2332, 12752, 12706, 2331, 2343, 12753, 12707, 2342
5588, 2343, 12753, 12707, 2342, 2354, 12754, 12708, 2353
5589, 2354, 12754, 12708, 2353, 2365, 12755, 12709, 2364
5590, 2365, 12755, 12709, 2364, 2376, 12756, 12710, 2375
5591, 2376, 12756, 12710, 2375, 2387, 12757, 12711, 2386
5592, 2387, 12757, 12711, 2386, 2398, 12758, 12712, 2397
5593, 2398, 12758, 12712, 2397, 2409, 12759, 12713, 2408
5594, 2409, 12759, 12713, 2408, 2420, 12760, 12714, 2419
5595, 2420, 12760, 12714, 2419, 2431, 12761, 12715, 2430
5596, 2431, 12761, 12715, 2430, 2442, 12762, 12716, 2441
5597, 2442, 12762, 12716, 2441, 2453, 12763, 12717, 2452
5598, 2453, 12763, 12717, 2452, 2464, 12764, 12718, 2463
5599, 2464, 12764, 12718, 2463, 2475, 12765, 12719, 2474
5600, 2475, 12765, 12719, 2474, 2486, 12766, 12720, 2485
5601, 2486, 12766, 12720, 2485, 138, 1972, 1970, 137
5602, 1951, 100, 99, 1949, 12767, 1992, 1991, 12721
5603, 12767, 1992, 1991, 12721, 12768, 2003, 2002, 12722
5604, 12768, 2003, 2002, 12722, 12769, 2014, 2013, 12723
5605, 12769, 2014, 2013, 12723, 12770, 2025, 2024, 12724
5606, 12770, 2025, 2024, 12724, 12771, 2036, 2035, 12725
5607, 12771, 2036, 2035, 12725, 12772, 2047, 2046, 12726
5608, 12772, 2047, 2046, 12726, 12773, 2058, 2057, 12727
5609, 12773, 2058, 2057, 12727, 12774, 2069, 2068, 12728
5610, 12774, 2069, 2068, 12728, 12775, 2080, 2079, 12729
5611, 12775, 2080, 2079, 12729, 12776, 2091, 2090, 12730
5612, 12776, 2091, 2090, 12730, 12777, 2102, 2101, 12731
5613, 12777, 2102, 2101, 12731, 12778, 2113, 2112, 12732
5614, 12778, 2113, 2112, 12732, 12779, 2124, 2123, 12733
5615, 12779, 2124, 2123, 12733, 12780, 2135, 2134, 12734
5616, 12780, 2135, 2134, 12734, 12781, 2146, 2145, 12735
5617, 12781, 2146, 2145, 12735, 12782, 2157, 2156, 12736
5618, 12782, 2157, 2156, 12736, 12783, 2168, 2167, 12737
5619, 12783, 2168, 2167, 12737, 12784, 2179, 2178, 12738
5620, 12784, 2179, 2178, 12738, 12785, 2190, 2189, 12739
5621, 12785, 2190, 2189, 12739, 12786, 2201, 2200, 12740
5622, 12786, 2201, 2200, 12740, 12787, 2212, 2211, 12741
5623, 12787, 2212, 2211, 12741, 12788, 2223, 2222, 12742
5624, 12788, 2223, 2222, 12742, 12789, 2234, 2233, 12743
5625, 12789, 2234, 2233, 12743, 1973, 126, 125, 1971
5626, 1952, 1951, 1949, 1950, 12790, 12767, 12721, 12744
5627, 12790, 12767, 12721, 12744, 12791, 12768, 12722, 12745
5628, 12791, 12768, 12722, 12745, 12792, 12769, 12723, 12746
5629, 12792, 12769, 12723, 12746, 12793, 12770, 12724, 12747
5630, 12793, 12770, 12724, 12747, 12794, 12771, 12725, 12748
5631, 12794, 12771, 12725, 12748, 12795, 12772, 12726, 12749
5632, 12795, 12772, 12726, 12749, 12796, 12773, 12727, 12750
5633, 12796, 12773, 12727, 12750, 12797, 12774, 12728, 12751
5634, 12797, 12774, 12728, 12751, 12798, 12775, 12729, 12752
5635, 12798, 12775, 12729, 12752, 12799, 12776, 12730, 12753
5636, 12799, 12776, 12730, 12753, 12800, 12777, 12731, 12754
5637, 12800, 12777, 12731, 12754, 12801, 12778, 12732, 12755
5638, 12801, 12778, 12732, 12755, 12802, 12779, 12733, 12756
5639, 12802, 12779, 12733, 12756, 12803, 12780, 12734, 12757
5640, 12803, 12780, 12734, 12757, 12804, 12781, 12735, 12758
5641, 12804, 12781, 12735, 12758, 12805, 12782, 12736, 12759
5642, 12805, 12782, 12736, 12759, 12806, 12783, 12737, 12760
5643, 12806, 12783, 12737, 12760, 12807, 12784, 12738, 12761
5644, 12807, 12784, 12738, 12761, 12808, 12785, 12739, 12762
5645, 12808, 12785, 12739, 12762, 12809, 12786, 12740, 12763
5646, 12809, 12786, 12740, 12763, 12810, 12787, 12741, 12764
5647, 12810, 12787, 12741, 12764, 12811, 12788, 12742, 12765
5648, 12811, 12788, 12742, 12765, 12812, 12789, 12743, 12766
5649, 12812, 12789, 12743, 12766, 1974, 1973, 1971, 1972
5650, 113, 1952, 1950, 112, 2245, 12790, 12744, 2244
5651, 2245, 12790, 12744, 2244, 2256, 12791, 12745, 2255
5652, 2256, 12791, 12745, 2255, 2267, 12792, 12746, 2266
5653, 2267, 12792, 12746, 2266, 2278, 12793, 12747, 2277
5654, 2278, 12793, 12747, 2277, 2289, 12794, 12748, 2288
5655, 2289, 12794, 12748, 2288, 2300, 12795, 12749, 2299
5656, 2300, 12795, 12749, 2299, 2311, 12796, 12750, 2310
5657, 2311, 12796, 12750, 2310, 2322, 12797, 12751, 2321
5658, 2322, 12797, 12751, 2321, 2333, 12798, 12752, 2332
5659, 2333, 12798, 12752, 2332, 2344, 12799, 12753, 2343
5660, 2344, 12799, 12753, 2343, 2355, 12800, 12754, 2354
5661, 2355, 12800, 12754, 2354, 2366, 12801, 12755, 2365
5662, 2366, 12801, 12755, 2365, 2377, 12802, 12756, 2376
5663, 2377, 12802, 12756, 2376, 2388, 12803, 12757, 2387
5664, 2388, 12803, 12757, 2387, 2399, 12804, 12758, 2398
5665, 2399, 12804, 12758, 2398, 2410, 12805, 12759, 2409
5666, 2410, 12805, 12759, 2409, 2421, 12806, 12760, 2420
5667, 2421, 12806, 12760, 2420, 2432, 12807, 12761, 2431
5668, 2432, 12807, 12761, 2431, 2443, 12808, 12762, 2442
5669, 2443, 12808, 12762, 2442, 2454, 12809, 12763, 2453
5670, 2454, 12809, 12763, 2453, 2465, 12810, 12764, 2464
5671, 2465, 12810, 12764, 2464, 2476, 12811, 12765, 2475
5672, 2476, 12811, 12765, 2475, 2487, 12812, 12766, 2486
5673, 2487, 12812, 12766, 2486, 139, 1974, 1972, 138
5674, 1953, 101, 100, 1951, 12813, 1993, 1992, 12767
5675, 12813, 1993, 1992, 12767, 12814, 2004, 2003, 12768
5676, 12814, 2004, 2003, 12768, 12815, 2015, 2014, 12769
5677, 12815, 2015, 2014, 12769, 12816, 2026, 2025, 12770
5678, 12816, 2026, 2025, 12770, 12817, 2037, 2036, 12771
5679, 12817, 2037, 2036, 12771, 12818, 2048, 2047, 12772
5680, 12818, 2048, 2047, 12772, 12819, 2059, 2058, 12773
5681, 12819, 2059, 2058, 12773, 12820, 2070, 2069, 12774
5682, 12820, 2070, 2069, 12774, 12821, 2081, 2080, 12775
5683, 12821, 2081, 2080, 12775, 12822, 2092, 2091, 12776
5684, 12822, 2092, 2091, 12776, 12823, 2103, 2102, 12777
5685, 12823, 2103, 2102, 12777, 12824, 2114, 2113, 12778
5686, 12824, 2114, 2113, 12778, 12825, 2125, 2124, 12779
5687, 12825, 2125, 2124, 12779, 12826, 2136, 2135, 12780
5688, 12826, 2136, 2135, 12780, 12827, 2147, 2146, 12781
5689, 12827, 2147, 2146, 12781, 12828, 2158, 2157, 12782
5690, 12828, 2158, 2157, 12782, 12829, 2169, 2168, 12783
5691, 12829, 2169, 2168, 12783, 12830, 2180, 2179, 12784
5692, 12830, 2180, 2179, 12784, 12831, 2191, 2190, 12785
5693, 12831, 2191, 2190, 12785, 12832, 2202, 2201, 12786
5694, 12832, 2202, 2201, 12786, 12833, 2213, 2212, 12787
5695, 12833, 2213, 2212, 12787, 12834, 2224, 2223, 12788
5696, 12834, 2224, 2223, 12788, 12835, 2235, 2234, 12789
5697, 12835, 2235, 2234, 12789, 1975, 127, 126, 1973
5698, 1954, 1953, 1951, 1952, 12836, 12813, 12767, 12790
5699, 12836, 12813, 12767, 12790, 12837, 12814, 12768, 12791
5700, 12837, 12814, 12768, 12791, 12838, 12815, 12769, 12792
5701, 12838, 12815, 12769, 12792, 12839, 12816, 12770, 12793
5702, 12839, 12816, 12770, 12793, 12840, 12817, 12771, 12794
5703, 12840, 12817, 12771, 12794, 12841, 12818, 12772, 12795
5704, 12841, 12818, 12772, 12795, 12842, 12819, 12773, 12796
5705, 12842, 12819, 12773, 12796, 12843, 12820, 12774, 12797
5706, 12843, 12820, 12774, 12797, 12844, 12821, 12775, 12798
5707, 12844, 12821, 12775, 12798, 12845, 12822, 12776, 12799
5708, 12845, 12822, 12776, 12799, 12846, 12823, 12777, 12800
5709, 12846, 12823, 12777, 12800, 12847, 12824, 12778, 12801
5710, 12847, 12824, 12778, 12801, 12848, 12825, 12779, 12802
5711, 12848, 12825, 12779, 12802, 12849, 12826, 12780, 12803
5712, 12849, 12826, 12780, 12803, 12850, 12827, 12781, 12804
5713, 12850, 12827, 12781, 12804, 12851, 12828, 12782, 12805
5714, 12851, 12828, 12782, 12805, 12852, 12829, 12783, 12806
5715, 12852, 12829, 12783, 12806, 12853, 12830, 12784, 12807
5716, 12853, 12830, 12784, 12807, 12854, 12831, 12785, 12808
5717, 12854, 12831, 12785, 12808, 12855, 12832, 12786, 12809
5718, 12855, 12832, 12786, 12809, 12856, 12833, 12787, 12810
5719, 12856, 12833, 12787, 12810, 12857, 12834, 12788, 12811
5720, 12857, 12834, 12788, 12811, 12858, 12835, 12789, 12812
5721, 12858, 12835, 12789, 12812, 1976, 1975, 1973, 1974
5722, 114, 1954, 1952, 113, 2246, 12836, 12790, 2245
5723, 2246, 12836, 12790, 2245, 2257, 12837, 12791, 2256
5724, 2257, 12837, 12791, 2256, 2268, 12838, 12792, 2267
5725, 2268, 12838, 12792, 2267, 2279, 12839, 12793, 2278
5726, 2279, 12839, 12793, 2278, 2290, 12840, 12794, 2289
5727, 2290, 12840, 12794, 2289, 2301, 12841, 12795, 2300
5728, 2301, 12841, 12795, 2300, 2312, 12842, 12796, 2311
5729, 2312, 12842, 12796, 2311, 2323, 12843, 12797, 2322
5730, 2323, 12843, 12797, 2322, 2334, 12844, 12798, 2333
5731, 2334, 12844, 12798, 2333, 2345, 12845, 12799, 2344
5732, 2345, 12845, 12799, 2344, 2356, 12846, 12800, 2355
5733, 2356, 12846, 12800, 2355, 2367, 12847, 12801, 2366
5734, 2367, 12847, 12801, 2366, 2378, 12848, 12802, 2377
5735, 2378, 12848, 12802, 2377, 2389, 12849, 12803, 2388
5736, 2389, 12849, 12803, 2388, 2400, 12850, 12804, 2399
5737, 2400, 12850, 12804, 2399, 2411, 12851, 12805, 2410
5738, 2411, 12851, 12805, 2410, 2422, 12852, 12806, 2421
5739, 2422, 12852, 12806, 2421, 2433, 12853, 12807, 2432
5740, 2433, 12853, 12807, 2432, 2444, 12854, 12808, 2443
5741, 2444, 12854, 12808, 2443, 2455, 12855, 12809, 2454
5742, 2455, 12855, 12809, 2454, 2466, 12856, 12810, 2465
5743, 2466, 12856, 12810, 2465, 2477, 12857, 12811, 2476
5744, 2477, 12857, 12811, 2476, 2488, 12858, 12812, 2487
5745, 2488, 12858, 12812, 2487, 140, 1976, 1974, 139
5746, 1955, 102, 101, 1953, 12859, 1994, 1993, 12813
5747, 12859, 1994, 1993, 12813, 12860, 2005, 2004, 12814
5748, 12860, 2005, 2004, 12814, 12861, 2016, 2015, 12815
5749, 12861, 2016, 2015, 12815, 12862, 2027, 2026, 12816
5750, 12862, 2027, 2026, 12816, 12863, 2038, 2037, 12817
5751, 12863, 2038, 2037, 12817, 12864, 2049, 2048, 12818
5752, 12864, 2049, 2048, 12818, 12865, 2060, 2059, 12819
5753, 12865, 2060, 2059, 12819, 12866, 2071, 2070, 12820
5754, 12866, 2071, 2070, 12820, 12867, 2082, 2081, 12821
5755, 12867, 2082, 2081, 12821, 12868, 2093, 2092, 12822
5756, 12868, 2093, 2092, 12822, 12869, 2104, 2103, 12823
5757, 12869, 2104, 2103, 12823, 12870, 2115, 2114, 12824
5758, 12870, 2115, 2114, 12824, 12871, 2126, 2125, 12825
5759, 12871, 2126, 2125, 12825, 12872, 2137, 2136, 12826
5760, 12872, 2137, 2136, 12826, 12873, 2148, 2147, 12827
5761, 12873, 2148, 2147, 12827, 12874, 2159, 2158, 12828
5762, 12874, 2159, 2158, 12828, 12875, 2170, 2169, 12829
5763, 12875, 2170, 2169, 12829, 12876, 2181, 2180, 12830
5764, 12876, 2181, 2180, 12830, 12877, 2192, 2191, 12831
5765, 12877, 2192, 2191, 12831, 12878, 2203, 2202, 12832
5766, 12878, 2203, 2202, 12832, 12879, 2214, 2213, 12833
5767, 12879, 2214, 2213, 12833, 12880, 2225, 2224, 12834
5768, 12880, 2225, 2224, 12834, 12881, 2236, 2235, 12835
5769, 12881, 2236, 2235, 12835, 1977, 128, 127, 1975
5770, 1956, 1955, 1953, 1954, 12882, 12859, 12813, 12836
5771, 12882, 12859, 12813, 12836, 12883, 12860, 12814, 12837
5772, 12883, 12860, 12814, 12837, 12884, 12861, 12815, 12838
5773, 12884, 12861, 12815, 12838, 12885, 12862, 12816, 12839
5774, 12885, 12862, 12816, 12839, 12886, 12863, 12817, 12840
5775, 12886, 12863, 12817, 12840, 12887, 12864, 12818, 12841
5776, 12887, 12864, 12818, 12841, 12888, 12865, 12819, 12842
5777, 12888, 12865, 12819, 12842, 12889, 12866, 12820, 12843
5778, 12889, 12866, 12820, 12843, 12890, 12867, 12821, 12844
5779, 12890, 12867, 12821, 12844, 12891, 12868, 12822, 12845
5780, 12891, 12868, 12822, 12845, 12892, 12869, 12823, 12846
5781, 12892, 12869, 12823, 12846, 12893, 12870, 12824, 12847
5782, 12893, 12870, 12824, 12847, 12894, 12871, 12825, 12848
5783, 12894, 12871, 12825, 12848, 12895, 12872, 12826, 12849
5784, 12895, 12872, 12826, 12849, 12896, 12873, 12827, 12850
5785, 12896, 12873, 12827, 12850, 12897, 12874, 12828, 12851
5786, 12897, 12874, 12828, 12851, 12898, 12875, 12829, 12852
5787, 12898, 12875, 12829, 12852, 12899, 12876, 12830, 12853
5788, 12899, 12876, 12830, 12853, 12900, 12877, 12831, 12854
5789, 12900, 12877, 12831, 12854, 12901, 12878, 12832, 12855
5790, 12901, 12878, 12832, 12855, 12902, 12879, 12833, 12856
5791, 12902, 12879, 12833, 12856, 12903, 12880, 12834, 12857
5792, 12903, 12880, 12834, 12857, 12904, 12881, 12835, 12858
5793, 12904, 12881, 12835, 12858, 1978, 1977, 1975, 1976
5794, 115, 1956, 1954, 114, 2247, 12882, 12836, 2246
5795, 2247, 12882, 12836, 2246, 2258, 12883, 12837, 2257
5796, 2258, 12883, 12837, 2257, 2269, 12884, 12838, 2268
5797, 2269, 12884, 12838, 2268, 2280, 12885, 12839, 2279
5798, 2280, 12885, 12839, 2279, 2291, 12886, 12840, 2290
5799, 2291, 12886, 12840, 2290, 2302, 12887, 12841, 2301
5800, 2302, 12887, 12841, 2301, 2313, 12888, 12842, 2312
5801, 2313, 12888, 12842, 2312, 2324, 12889, 12843, 2323
5802, 2324, 12889, 12843, 2323, 2335, 12890, 12844, 2334
5803, 2335, 12890, 12844, 2334, 2346, 12891, 12845, 2345
5804, 2346, 12891, 12845, 2345, 2357, 12892, 12846, 2356
5805, 2357, 12892, 12846, 2356, 2368, 12893, 12847, 2367
5806, 2368, 12893, 12847, 2367, 2379, 12894, 12848, 2378
5807, 2379, 12894, 12848, 2378, 2390, 12895, 12849, 2389
5808, 2390, 12895, 12849, 2389, 2401, 12896, 12850, 2400
5809, 2401, 12896, 12850, 2400, 2412, 12897, 12851, 2411
5810, 2412, 12897, 12851, 2411, 2423, 12898, 12852, 2422
5811, 2423, 12898, 12852, 2422, 2434, 12899, 12853, 2433
5812, 2434, 12899, 12853, 2433, 2445, 12900, 12854, 2444
5813, 2445, 12900, 12854, 2444, 2456, 12901, 12855, 2455
5814, 2456, 12901, 12855, 2455, 2467, 12902, 12856, 2466
5815, 2467, 12902, 12856, 2466, 2478, 12903, 12857, 2477
5816, 2478, 12903, 12857, 2477, 2489, 12904, 12858, 2488
5817, 2489, 12904, 12858, 2488, 141, 1978, 1976, 140
5818, 1957, 103, 102, 1955, 12905, 1995, 1994, 12859
5819, 12905, 1995, 1994, 12859, 12906, 2006, 2005, 12860
5820, 12906, 2006, 2005, 12860, 12907, 2017, 2016, 12861
5821, 12907, 2017, 2016, 12861, 12908, 2028, 2027, 12862
5822, 12908, 2028, 2027, 12862, 12909, 2039, 2038, 12863
5823, 12909, 2039, 2038, 12863, 12910, 2050, 2049, 12864
5824, 12910, 2050, 2049, 12864, 12911, 2061, 2060, 12865
5825, 12911, 2061, 2060, 12865, 12912, 2072, 2071, 12866
5826, 12912, 2072, 2071, 12866, 12913, 2083, 2082, 12867
5827, 12913, 2083, 2082, 12867, 12914, 2094, 2093, 12868
5828, 12914, 2094, 2093, 12868, 12915, 2105, 2104, 12869
5829, 12915, 2105, 2104, 12869, 12916, 2116, 2115, 12870
5830, 12916, 2116, 2115, 12870, 12917, 2127, 2126, 12871
5831, 12917, 2127, 2126, 12871, 12918, 2138, 2137, 12872
5832, 12918, 2138, 2137, 12872, 12919, 2149, 2148, 12873
5833, 12919, 2149, 2148, 12873, 12920, 2160, 2159, 12874
5834, 12920, 2160, 2159, 12874, 12921, 2171, 2170, 12875
5835, 12921, 2171, 2170, 12875, 12922, 2182, 2181, 12876
5836, 12922, 2182, 2181, 12876, 12923, 2193, 2192, 12877
5837, 12923, 2193, 2192, 12877, 12924, 2204, 2203, 12878
5838, 12924, 2204, 2203, 12878, 12925, 2215, 2214, 12879
5839, 12925, 2215, 2214, 12879, 12926, 2226, 2225, 12880
5840, 12926, 2226, 2225, 12880, 12927, 2237, 2236, 12881
5841, 12927, 2237, 2236, 12881, 1979, 129, 128, 1977
5842, 1958, 1957, 1955, 1956, 12928, 12905, 12859, 12882
5843, 12928, 12905, 12859, 12882, 12929, 12906, 12860, 12883
5844, 12929, 12906, 12860, 12883, 12930, 12907, 12861, 12884
5845, 12930, 12907, 12861, 12884, 12931, 12908, 12862, 12885
5846, 12931, 12908, 12862, 12885, 12932, 12909, 12863, 12886
5847, 12932, 12909, 12863, 12886, 12933, 12910, 12864, 12887
5848, 12933, 12910, 12864, 12887, 12934, 12911, 12865, 12888
5849, 12934, 12911, 12865, 12888, 12935, 12912, 12866, 12889
5850, 12935, 12912, 12866, 12889, 12936, 12913, 12867, 12890
5851, 12936, 12913, 12867, 12890, 12937, 12914, 12868, 12891
5852, 12937, 12914, 12868, 12891, 12938, 12915, 12869, 12892
5853, 12938, 12915, 12869, 12892, 12939, 12916, 12870, 12893
5854, 12939, 12916, 12870, 12893, 12940, 12917, 12871, 12894
5855, 12940, 12917, 12871, 12894, 12941, 12918, 12872, 12895
5856, 12941, 12918, 12872, 12895, 12942, 12919, 12873, 12896
5857, 12942, 12919, 12873, 12896, 12943, 12920, 12874, 12897
5858, 12943, 12920, 12874, 12897, 12944, 12921, 12875, 12898
5859, 12944, 12921, 12875, 12898, 12945, 12922, 12876, 12899
5860, 12945, 12922, 12876, 12899, 12946, 12923, 12877, 12900
5861, 12946, 12923, 12877, 12900, 12947, 12924, 12878, 12901
5862, 12947, 12924, 12878, 12901, 12948, 12925, 12879, 12902
5863, 12948, 12925, 12879, 12902, 12949, 12926, 12880, 12903
5864, 12949, 12926, 12880, 12903, 12950, 12927, 12881, 12904
5865, 12950, 12927, 12881, 12904, 1980, 1979, 1977, 1978
5866, 116, 1958, 1956, 115, 2248, 12928, 12882, 2247
5867, 2248, 12928, 12882, 2247, 2259, 12929, 12883, 2258
5868, 2259, 12929, 12883, 2258, 2270, 12930, 12884, 2269
5869, 2270, 12930, 12884, 2269, 2281, 12931, 12885, 2280
5870, 2281, 12931, 12885, 2280, 2292, 12932, 12886, 2291
5871, 2292, 12932, 12886, 2291, 2303, 12933, 12887, 2302
5872, 2303, 12933, 12887, 2302, 2314, 12934, 12888, 2313
5873, 2314, 12934, 12888, 2313, 2325, 12935, 12889, 2324
5874, 2325, 12935, 12889, 2324, 2336, 12936, 12890, 2335
5875, 2336, 12936, 12890, 2335, 2347, 12937, 12891, 2346
5876, 2347, 12937, 12891, 2346, 2358, 12938, 12892, 2357
5877, 2358, 12938, 12892, 2357, 2369, 12939, 12893, 2368
5878, 2369, 12939, 12893, 2368, 2380, 12940, 12894, 2379
5879, 2380, 12940, 12894, 2379, 2391, 12941, 12895, 2390
5880, 2391, 12941, 12895, 2390, 2402, 12942, 12896, 2401
5881, 2402, 12942, 12896, 2401, 2413, 12943, 12897, 2412
5882, 2413, 12943, 12897, 2412, 2424, 12944, 12898, 2423
5883, 2424, 12944, 12898, 2423, 2435, 12945, 12899, 2434
5884, 2435, 12945, 12899, 2434, 2446, 12946, 12900, 2445
5885, 2446, 12946, 12900, 2445, 2457, 12947, 12901, 2456
5886, 2457, 12947, 12901, 2456, 2468, 12948, 12902, 2467
5887, 2468, 12948, 12902, 2467, 2479, 12949, 12903, 2478
5888, 2479, 12949, 12903, 2478, 2490, 12950, 12904, 2489
5889, 2490, 12950, 12904, 2489, 142, 1980, 1978, 141
5890, 1959, 104, 103, 1957, 12951, 1996, 1995, 12905
5891, 12951, 1996, 1995, 12905, 12952, 2007, 2006, 12906
5892, 12952, 2007, 2006, 12906, 12953, 2018, 2017, 12907
5893, 12953, 2018, 2017, 12907, 12954, 2029, 2028, 12908
5894, 12954, 2029, 2028, 12908, 12955, 2040, 2039, 12909
5895, 12955, 2040, 2039, 12909, 12956, 2051, 2050, 12910
5896, 12956, 2051, 2050, 12910, 12957, 2062, 2061, 12911
5897, 12957, 2062, 2061, 12911, 12958, 2073, 2072, 12912
5898, 12958, 2073, 2072, 12912, 12959, 2084, 2083, 12913
5899, 12959, 2084, 2083, 12913, 12960, 2095, 2094, 12914
5900, 12960, 2095, 2094, 12914, 12961, 2106, 2105, 12915
5901, 12961, 2106, 2105, 12915, 12962, 2117, 2116, 12916
5902, 12962, 2117, 2116, 12916, 12963, 2128, 2127, 12917
5903, 12963, 2128, 2127, 12917, 12964, 2139, 2138, 12918
5904, 12964, 2139, 2138, 12918, 12965, 2150, 2149, 12919
5905, 12965, 2150, 2149, 12919, 12966, 2161, 2160, 12920
5906, 12966, 2161, 2160, 12920, 12967, 2172, 2171, 12921
5907, 12967, 2172, 2171, 12921, 12968, 2183, 2182, 12922
5908, 12968, 2183, 2182, 12922, 12969, 2194, 2193, 12923
5909, 12969, 2194, 2193, 12923, 12970, 2205, 2204, 12924
5910, 12970, 2205, 2204, 12924, 12971, 2216, 2215, 12925
5911, 12971, 2216, 2215, 12925, 12972, 2227, 2226, 12926
5912, 12972, 2227, 2226, 12926, 12973, 2238, 2237, 12927
5913, 12973, 2238, 2237, 12927, 1981, 130, 129, 1979
5914, 1960, 1959, 1957, 1958, 12974, 12951, 12905, 12928
5915, 12974, 12951, 12905, 12928, 12975, 12952, 12906, 12929
5916, 12975, 12952, 12906, 12929, 12976, 12953, 12907, 12930
5917, 12976, 12953, 12907, 12930, 12977, 12954, 12908, 12931
5918, 12977, 12954, 12908, 12931, 12978, 12955, 12909, 12932
5919, 12978, 12955, 12909, 12932, 12979, 12956, 12910, 12933
5920, 12979, 12956, 12910, 12933, 12980, 12957, 12911, 12934
5921, 12980, 12957, 12911, 12934, 12981, 12958, 12912, 12935
5922, 12981, 12958, 12912, 12935, 12982, 12959, 12913, 12936
5923, 12982, 12959, 12913, 12936, 12983, 12960, 12914, 12937
5924, 12983, 12960, 12914, 12937, 12984, 12961, 12915, 12938
5925, 12984, 12961, 12915, 12938, 12985, 12962, 12916, 12939
5926, 12985, 12962, 12916, 12939, 12986, 12963, 12917, 12940
5927, 12986, 12963, 12917, 12940, 12987, 12964, 12918, 12941
5928, 12987, 12964, 12918, 12941, 12988, 12965, 12919, 12942
5929, 12988, 12965, 12919, 12942, 12989, 12966, 12920, 12943
5930, 12989, 12966, 12920, 12943, 12990, 12967, 12921, 12944
5931, 12990, 12967, 12921, 12944, 12991, 12968, 12922, 12945
5932, 12991, 12968, 12922, 12945, 12992, 12969, 12923, 12946
5933, 12992, 12969, 12923, 12946, 12993, 12970, 12924, 12947
5934, 12993, 12970, 12924, 12947, 12994, 12971, 12925, 12948
5935, 12994, 12971, 12925, 12948, 12995, 12972, 12926, 12949
5936, 12995, 12972, 12926, 12949, 12996, 12973, 12927, 12950
5937, 12996, 12973, 12927, 12950, 1982, 1981, 1979, 1980
5938, 117, 1960, 1958, 116, 2249, 12974, 12928, 2248
5939, 2249, 12974, 12928, 2248, 2260, 12975, 12929, 2259
5940, 2260, 12975, 12929, 2259, 2271, 12976, 12930, 2270
5941, 2271, 12976, 12930, 2270, 2282, 12977, 12931, 2281
5942, 2282, 12977, 12931, 2281, 2293, 12978, 12932, 2292
5943, 2293, 12978, 12932, 2292, 2304, 12979, 12933, 2303
5944, 2304, 12979, 12933, 2303, 2315, 12980, 12934, 2314
5945, 2315, 12980, 12934, 2314, 2326, 12981, 12935, 2325
5946, 2326, 12981, 12935, 2325, 2337, 12982, 12936, 2336
5947, 2337, 12982, 12936, 2336, 2348, 12983, 12937, 2347
5948, 2348, 12983, 12937, 2347, 2359, 12984, 12938, 2358
5949, 2359, 12984, 12938, 2358, 2370, 12985, 12939, 2369
5950, 2370, 12985, 12939, 2369, 2381, 12986, 12940, 2380
5951, 2381, 12986, 12940, 2380, 2392, 12987, 12941, 2391
5952, 2392, 12987, 12941, 2391, 2403, 12988, 12942, 2402
5953, 2403, 12988, 12942, 2402, 2414, 12989, 12943, 2413
5954, 2414, 12989, 12943, 2413, 2425, 12990, 12944, 2424
5955, 2425, 12990, 12944, 2424, 2436, 12991, 12945, 2435
5956, 2436, 12991, 12945, 2435, 2447, 12992, 12946, 2446
5957, 2447, 12992, 12946, 2446, 2458, 12993, 12947, 2457
5958, 2458, 12993, 12947, 2457, 2469, 12994, 12948, 2468
5959, 2469, 12994, 12948, 2468, 2480, 12995, 12949, 2479
5960, 2480, 12995, 12949, 2479, 2491, 12996, 12950, 2490
5961, 2491, 12996, 12950, 2490, 143, 1982, 1980, 142
5962, 1961, 105, 104, 1959, 12997, 1997, 1996, 12951
5963, 12997, 1997, 1996, 12951, 12998, 2008, 2007, 12952
5964, 12998, 2008, 2007, 12952, 12999, 2019, 2018, 12953
5965, 12999, 2019, 2018, 12953, 13000, 2030, 2029, 12954
5966, 13000, 2030, 2029, 12954, 13001, 2041, 2040, 12955
5967, 13001, 2041, 2040, 12955, 13002, 2052, 2051, 12956
5968, 13002, 2052, 2051, 12956, 13003, 2063, 2062, 12957
5969, 13003, 2063, 2062, 12957, 13004, 2074, 2073, 12958
5970, 13004, 2074, 2073, 12958, 13005, 2085, 2084, 12959
5971, 13005, 2085, 2084, 12959, 13006, 2096, 2095, 12960
5972, 13006, 2096, 2095, 12960, 13007, 2107, 2106, 12961
5973, 13007, 2107, 2106, 12961, 13008, 2118, 2117, 12962
5974, 13008, 2118, 2117, 12962, 13009, 2129, 2128, 12963
5975, 13009, 2129, 2128, 12963, 13010, 2140, 2139, 12964
5976, 13010, 2140, 2139, 12964, 13011, 2151, 2150, 12965
5977, 13011, 2151, 2150, 12965, 13012, 2162, 2161, 12966
5978, 13012, 2162, 2161, 12966, 13013, 2173, 2172, 12967
5979, 13013, 2173, 2172, 12967, 13014, 2184, 2183, 12968
5980, 13014, 2184, 2183, 12968, 13015, 2195, 2194, 12969
5981, 13015, 2195, 2194, 12969, 13016, 2206, 2205, 12970
5982, 13016, 2206, 2205, 12970, 13017, 2217, 2216, 12971
5983, 13017, 2217, 2216, 12971, 13018, 2228, 2227, 12972
5984, 13018, 2228, 2227, 12972, 13019, 2239, 2238, 12973
5985, 13019, 2239, 2238, 12973, 1983, 131, 130, 1981
5986, 1962, 1961, 1959, 1960, 13020, 12997, 12951, 12974
5987, 13020, 12997, 12951, 12974, 13021, 12998, 12952, 12975
5988, 13021, 12998, 12952, 12975, 13022, 12999, 12953, 12976
5989, 13022, 12999, 12953, 12976, 13023, 13000, 12954, 12977
5990, 13023, 13000, 12954, 12977, 13024, 13001, 12955, 12978
5991, 13024, 13001, 12955, 12978, 13025, 13002, 12956, 12979
5992, 13025, 13002, 12956, 12979, 13026, 13003, 12957, 12980
5993, 13026, 13003, 12957, 12980, 13027, 13004, 12958, 12981
5994, 13027, 13004, 12958, 12981, 13028, 13005, 12959, 12982
5995, 13028, 13005, 12959, 12982, 13029, 13006, 12960, 12983
5996, 13029, 13006, 12960, 12983, 13030, 13007, 12961, 12984
5997, 13030, 13007, 12961, 12984, 13031, 13008, 12962, 12985
5998, 13031, 13008, 12962, 12985, 13032, 13009, 12963, 12986
5999, 13032, 13009, 12963, 12986, 13033, 13010, 12964, 12987
6000, 13033, 13010, 12964, 12987, 13034, 13011, 12965, 12988
6001, 13034, 13011, 12965, 12988, 13035, 13012, 12966, 12989
6002, 13035, 13012, 12966, 12989, 13036, 13013, 12967, 12990
6003, 13036, 13013, 12967, 12990, 13037, 13014, 12968, 12991
6004, 13037, 13014, 12968, 12991, 13038, 13015, 12969, 12992
6005, 13038, 13015, 12969, 12992, 13039, 13016, 12970, 12993
6006, 13039, 13016, 12970, 12993, 13040, 13017, 12971, 12994
6007, 13040, 13017, 12971, 12994, 13041, 13018, 12972, 12995
6008, 13041, 13018, 12972, 12995, 13042, 13019, 12973, 12996
6009, 13042, 13019, 12973, 12996, 1984, 1983, 1981, 1982
6010, 118, 1962, 1960, 117, 2250, 13020, 12974, 2249
6011, 2250, 13020, 12974, 2249, 2261, 13021, 12975, 2260
6012, 2261, 13021, 12975, 2260, 2272, 13022, 12976, 2271
6013, 2272, 13022, 12976, 2271, 2283, 13023, 12977, 2282
6014, 2283, 13023, 12977, 2282, 2294, 13024, 12978, 2293
6015, 2294, 13024, 12978, 2293, 2305, 13025, 12979, 2304
6016, 2305, 13025, 12979, 2304, 2316, 13026, 12980, 2315
6017, 2316, 13026, 12980, 2315, 2327, 13027, 12981, 2326
6018, 2327, 13027, 12981, 2326, 2338, 13028, 12982, 2337
6019, 2338, 13028, 12982, 2337, 2349, 13029, 12983, 2348
6020, 2349, 13029, 12983, 2348, 2360, 13030, 12984, 2359
6021, 2360, 13030, 12984, 2359, 2371, 13031, 12985, 2370
6022, 2371, 13031, 12985, 2370, 2382, 13032, 12986, 2381
6023, 2382, 13032, 12986, 2381, 2393, 13033, 12987, 2392
6024, 2393, 13033, 12987, 2392, 2404, 13034, 12988, 2403
6025, 2404, 13034, 12988, 2403, 2415, 13035, 12989, 2414
6026, 2415, 13035, 12989, 2414, 2426, 13036, 12990, 2425
6027, 2426, 13036, 12990, 2425, 2437, 13037, 12991, 2436
6028, 2437, 13037, 12991, 2436, 2448, 13038, 12992, 2447
6029, 2448, 13038, 12992, 2447, 2459, 13039, 12993, 2458
6030, 2459, 13039, 12993, 2458, 2470, 13040, 12994, 2469
6031, 2470, 13040, 12994, 2469, 2481, 13041, 12995, 2480
6032, 2481, 13041, 12995, 2480, 2492, 13042, 12996, 2491
6033, 2492, 13042, 12996, 2491, 144, 1984, 1982, 143
6034, 1963, 106, 105, 1961, 13043, 1998, 1997, 12997
6035, 13043, 1998, 1997, 12997, 13044, 2009, 2008, 12998
6036, 13044, 2009, 2008, 12998, 13045, 2020, 2019, 12999
6037, 13045, 2020, 2019, 12999, 13046, 2031, 2030, 13000
6038, 13046, 2031, 2030, 13000, 13047, 2042, 2041, 13001
6039, 13047, 2042, 2041, 13001, 13048, 2053, 2052, 13002
6040, 13048, 2053, 2052, 13002, 13049, 2064, 2063, 13003
6041, 13049, 2064, 2063, 13003, 13050, 2075, 2074, 13004
6042, 13050, 2075, 2074, 13004, 13051, 2086, 2085, 13005
6043, 13051, 2086, 2085, 13005, 13052, 2097, 2096, 13006
6044, 13052, 2097, 2096, 13006, 13053, 2108, 2107, 13007
6045, 13053, 2108, 2107, 13007, 13054, 2119, 2118, 13008
6046, 13054, 2119, 2118, 13008, 13055, 2130, 2129, 13009
6047, 13055, 2130, 2129, 13009, 13056, 2141, 2140, 13010
6048, 13056, 2141, 2140, 13010, 13057, 2152, 2151, 13011
6049, 13057, 2152, 2151, 13011, 13058, 2163, 2162, 13012
6050, 13058, 2163, 2162, 13012, 13059, 2174, 2173, 13013
6051, 13059, 2174, 2173, 13013, 13060, 2185, 2184, 13014
6052, 13060, 2185, 2184, 13014, 13061, 2196, 2195, 13015
6053, 13061, 2196, 2195, 13015, 13062, 2207, 2206, 13016
6054, 13062, 2207, 2206, 13016, 13063, 2218, 2217, 13017
6055, 13063, 2218, 2217, 13017, 13064, 2229, 2228, 13018
6056, 13064, 2229, 2228, 13018, 13065, 2240, 2239, 13019
6057, 13065, 2240, 2239, 13019, 1985, 132, 131, 1983
6058, 1964, 1963, 1961, 1962, 13066, 13043, 12997, 13020
6059, 13066, 13043, 12997, 13020, 13067, 13044, 12998, 13021
6060, 13067, 13044, 12998, 13021, 13068, 13045, 12999, 13022
6061, 13068, 13045, 12999, 13022, 13069, 13046, 13000, 13023
6062, 13069, 13046, 13000, 13023, 13070, 13047, 13001, 13024
6063, 13070, 13047, 13001, 13024, 13071, 13048, 13002, 13025
6064, 13071, 13048, 13002, 13025, 13072, 13049, 13003, 13026
6065, 13072, 13049, 13003, 13026, 13073, 13050, 13004, 13027
6066, 13073, 13050, 13004, 13027, 13074, 13051, 13005, 13028
6067, 13074, 13051, 13005, 13028, 13075, 13052, 13006, 13029
6068, 13075, 13052, 13006, 13029, 13076, 13053, 13007, 13030
6069, 13076, 13053, 13007, 13030, 13077, 13054, 13008, 13031
6070, 13077, 13054, 13008, 13031, 13078, 13055, 13009, 13032
6071, 13078, 13055, 13009, 13032, 13079, 13056, 13010, 13033
6072, 13079, 13056, 13010, 13033, 13080, 13057, 13011, 13034
6073, 13080, 13057, 13011, 13034, 13081, 13058, 13012, 13035
6074, 13081, 13058, 13012, 13035, 13082, 13059, 13013, 13036
6075, 13082, 13059, 13013, 13036, 13083, 13060, 13014, 13037
6076, 13083, 13060, 13014, 13037, 13084, 13061, 13015, 13038
6077, 13084, 13061, 13015, 13038, 13085, 13062, 13016, 13039
6078, 13085, 13062, 13016, 13039, 13086, 13063, 13017, 13040
6079, 13086, 13063, 13017, 13040, 13087, 13064, 13018, 13041
6080, 13087, 13064, 13018, 13041, 13088, 13065, 13019, 13042
6081, 13088, 13065, 13019, 13042, 1986, 1985, 1983, 1984
6082, 119, 1964, 1962, 118, 2251, 13066, 13020, 2250
6083, 2251, 13066, 13020, 2250, 2262, 13067, 13021, 2261
6084, 2262, 13067, 13021, 2261, 2273, 13068, 13022, 2272
6085, 2273, 13068, 13022, 2272, 2284, 13069, 13023, 2283
6086, 2284, 13069, 13023, 2283, 2295, 13070, 13024, 2294
6087, 2295, 13070, 13024, 2294, 2306, 13071, 13025, 2305
6088, 2306, 13071, 13025, 2305, 2317, 13072, 13026, 2316
6089, 2317, 13072, 13026, 2316, 2328, 13073, 13027, 2327
6090, 2328, 13073, 13027, 2327, 2339, 13074, 13028, 2338
6091, 2339, 13074, 13028, 2338, 2350, 13075, 13029, 2349
6092, 2350, 13075, 13029, 2349, 2361, 13076, 13030, 2360
6093, 2361, 13076, 13030, 2360, 2372, 13077, 13031, 2371
6094, 2372, 13077, 13031, 2371, 2383, 13078, 13032, 2382
6095, 2383, 13078, 13032, 2382, 2394, 13079, 13033, 2393
6096, 2394, 13079, 13033, 2393, 2405, 13080, 13034, 2404
6097, 2405, 13080, 13034, 2404, 2416, 13081, 13035, 2415
6098, 2416, 13081, 13035, 2415, 2427, 13082, 13036, 2426
6099, 2427, 13082, 13036, 2426, 2438, 13083, 13037, 2437
6100, 2438, 13083, 13037, 2437, 2449, 13084, 13038, 2448
6101, 2449, 13084, 13038, 2448, 2460, 13085, 13039, 2459
6102, 2460, 13085, 13039, 2459, 2471, 13086, 13040, 2470
6103, 2471, 13086, 13040, 2470, 2482, 13087, 13041, 2481
6104, 2482, 13087, 13041, 2481, 2493, 13088, 13042, 2492
6105, 2493, 13088, 13042, 2492, 145, 1986, 1984, 144
6106, 1965, 107, 106, 1963, 13089, 1999, 1998, 13043
6107, 13089, 1999, 1998, 13043, 13090, 2010, 2009, 13044
6108, 13090, 2010, 2009, 13044, 13091, 2021, 2020, 13045
6109, 13091, 2021, 2020, 13045, 13092, 2032, 2031, 13046
6110, 13092, 2032, 2031, 13046, 13093, 2043, 2042, 13047
6111, 13093, 2043, 2042, 13047, 13094, 2054, 2053, 13048
6112, 13094, 2054, 2053, 13048, 13095, 2065, 2064, 13049
6113, 13095, 2065, 2064, 13049, 13096, 2076, 2075, 13050
6114, 13096, 2076, 2075, 13050, 13097, 2087, 2086, 13051
6115, 13097, 2087, 2086, 13051, 13098, 2098, 2097, 13052
6116, 13098, 2098, 2097, 13052, 13099, 2109, 2108, 13053
6117, 13099, 2109, 2108, 13053, 13100, 2120, 2119, 13054
6118, 13100, 2120, 2119, 13054, 13101, 2131, 2130, 13055
6119, 13101, 2131, 2130, 13055, 13102, 2142, 2141, 13056
6120, 13102, 2142, 2141, 13056, 13103, 2153, 2152, 13057
6121, 13103, 2153, 2152, 13057, 13104, 2164, 2163, 13058
6122, 13104, 2164, 2163, 13058, 13105, 2175, 2174, 13059
6123, 13105, 2175, 2174, 13059, 13106, 2186, 2185, 13060
6124, 13106, 2186, 2185, 13060, 13107, 2197, 2196, 13061
6125, 13107, 2197, 2196, 13061, 13108, 2208, 2207, 13062
6126, 13108, 2208, 2207, 13062, 13109, 2219, 2218, 13063
6127, 13109, 2219, 2218, 13063, 13110, 2230, 2229, 13064
6128, 13110, 2230, 2229, 13064, 13111, 2241, 2240, 13065
6129, 13111, 2241, 2240, 13065, 1987, 133, 132, 1985
6130, 1966, 1965, 1963, 1964, 13112, 13089, 13043, 13066
6131, 13112, 13089, 13043, 13066, 13113, 13090, 13044, 13067
6132, 13113, 13090, 13044, 13067, 13114, 13091, 13045, 13068
6133, 13114, 13091, 13045, 13068, 13115, 13092, 13046, 13069
6134, 13115, 13092, 13046, 13069, 13116, 13093, 13047, 13070
6135, 13116, 13093, 13047, 13070, 13117, 13094, 13048, 13071
6136, 13117, 13094, 13048, 13071, 13118, 13095, 13049, 13072
6137, 13118, 13095, 13049, 13072, 13119, 13096, 13050, 13073
6138, 13119, 13096, 13050, 13073, 13120, 13097, 13051, 13074
6139, 13120, 13097, 13051, 13074, 13121, 13098, 13052, 13075
6140, 13121, 13098, 13052, 13075, 13122, 13099, 13053, 13076
6141, 13122, 13099, 13053, 13076, 13123, 13100, 13054, 13077
6142, 13123, 13100, 13054, 13077, 13124, 13101, 13055, 13078
6143, 13124, 13101, 13055, 13078, 13125, 13102, 13056, 13079
6144, 13125, 13102, 13056, 13079, 13126, 13103, 13057, 13080
6145, 13126, 13103, 13057, 13080, 13127, 13104, 13058, 13081
6146, 13127, 13104, 13058, 13081, 13128, 13105, 13059, 13082
6147, 13128, 13105, 13059, 13082, 13129, 13106, 13060, 13083
6148, 13129, 13106, 13060, 13083, 13130, 13107, 13061, 13084
6149, 13130, 13107, 13061, 13084, 13131, 13108, 13062, 13085
6150, 13131, 13108, 13062, 13085, 13132, 13109, 13063, 13086
6151, 13132, 13109, 13063, 13086, 13133, 13110, 13064, 13087
6152, 13133, 13110, 13064, 13087, 13134, 13111, 13065, 13088
6153, 13134, 13111, 13065, 13088, 1988, 1987, 1985, 1986
6154, 120, 1966, 1964, 119, 2252, 13112, 13066, 2251
6155, 2252, 13112, 13066, 2251, 2263, 13113, 13067, 2262
6156, 2263, 13113, 13067, 2262, 2274, 13114, 13068, 2273
6157, 2274, 13114, 13068, 2273, 2285, 13115, 13069, 2284
6158, 2285, 13115, 13069, 2284, 2296, 13116, 13070, 2295
6159, 2296, 13116, 13070, 2295, 2307, 13117, 13071, 2306
6160, 2307, 13117, 13071, 2306, 2318, 13118, 13072, 2317
6161, 2318, 13118, 13072, 2317, 2329, 13119, 13073, 2328
6162, 2329, 13119, 13073, 2328, 2340, 13120, 13074, 2339
6163, 2340, 13120, 13074, 2339, 2351, 13121, 13075, 2350
6164, 2351, 13121, 13075, 2350, 2362, 13122, 13076, 2361
6165, 2362, 13122, 13076, 2361, 2373, 13123, 13077, 2372
6166, 2373, 13123, 13077, 2372, 2384, 13124, 13078, 2383
6167, 2384, 13124, 13078, 2383, 2395, 13125, 13079, 2394
6168, 2395, 13125, 13079, 2394, 2406, 13126, 13080, 2405
6169, 2406, 13126, 13080, 2405, 2417, 13127, 13081, 2416
6170, 2417, 13127, 13081, 2416, 2428, 13128, 13082, 2427
6171, 2428, 13128, 13082, 2427, 2439, 13129, 13083, 2438
6172, 2439, 13129, 13083, 2438, 2450, 13130, 13084, 2449
6173, 2450, 13130, 13084, 2449, 2461, 13131, 13085, 2460
6174, 2461, 13131, 13085, 2460, 2472, 13132, 13086, 2471
6175, 2472, 13132, 13086, 2471, 2483, 13133, 13087, 2482
6176, 2483, 13133, 13087, 2482, 2494, 13134, 13088, 2493
6177, 2494, 13134, 13088, 2493, 146, 1988, 1986, 145
6178, 108, 1, 107, 1965, 2541, 172, 1999, 13089
6179, 2541, 172, 1999, 13089, 2542, 173, 2010, 13090
6180, 2542, 173, 2010, 13090, 2543, 174, 2021, 13091
6181, 2543, 174, 2021, 13091, 2544, 175, 2032, 13092
6182, 2544, 175, 2032, 13092, 2545, 176, 2043, 13093
6183, 2545, 176, 2043, 13093, 2546, 177, 2054, 13094
6184, 2546, 177, 2054, 13094, 2547, 178, 2065, 13095
6185, 2547, 178, 2065, 13095, 2548, 179, 2076, 13096
6186, 2548, 179, 2076, 13096, 2549, 180, 2087, 13097
6187, 2549, 180, 2087, 13097, 2550, 181, 2098, 13098
6188, 2550, 181, 2098, 13098, 2551, 182, 2109, 13099
6189, 2551, 182, 2109, 13099, 2552, 183, 2120, 13100
6190, 2552, 183, 2120, 13100, 2553, 184, 2131, 13101
6191, 2553, 184, 2131, 13101, 2554, 185, 2142, 13102
6192, 2554, 185, 2142, 13102, 2555, 186, 2153, 13103
6193, 2555, 186, 2153, 13103, 2556, 187, 2164, 13104
6194, 2556, 187, 2164, 13104, 2557, 188, 2175, 13105
6195, 2557, 188, 2175, 13105, 2558, 189, 2186, 13106
6196, 2558, 189, 2186, 13106, 2559, 190, 2197, 13107
6197, 2559, 190, 2197, 13107, 2560, 191, 2208, 13108
6198, 2560, 191, 2208, 13108, 2561, 192, 2219, 13109
6199, 2561, 192, 2219, 13109, 2562, 193, 2230, 13110
6200, 2562, 193, 2230, 13110, 2563, 194, 2241, 13111
6201, 2563, 194, 2241, 13111, 134, 5, 133, 1987
6202, 109, 108, 1965, 1966, 2564, 2541, 13089, 13112
6203, 2564, 2541, 13089, 13112, 2565, 2542, 13090, 13113
6204, 2565, 2542, 13090, 13113, 2566, 2543, 13091, 13114
6205, 2566, 2543, 13091, 13114, 2567, 2544, 13092, 13115
6206, 2567, 2544, 13092, 13115, 2568, 2545, 13093, 13116
6207, 2568, 2545, 13093, 13116, 2569, 2546, 13094, 13117
6208, 2569, 2546, 13094, 13117, 2570, 2547, 13095, 13118
6209, 2570, 2547, 13095, 13118, 2571, 2548, 13096, 13119
6210, 2571, 2548, 13096, 13119, 2572, 2549, 13097, 13120
6211, 2572, 2549, 13097, 13120, 2573, 2550, 13098, 13121
6212, 2573, 2550, 13098, 13121, 2574, 2551, 13099, 13122
6213, 2574, 2551, 13099, 13122, 2575, 2552, 13100, 13123
6214, 2575, 2552, 13100, 13123, 2576, 2553, 13101, 13124
6215, 2576, 2553, 13101, 13124, 2577, 2554, 13102, 13125
6216, 2577, 2554, 13102, 13125, 2578, 2555, 13103, 13126
6217, 2578, 2555, 13103, 13126, 2579, 2556, 13104, 13127
6218, 2579, 2556, 13104, 13127, 2580, 2557, 13105, 13128
6219, 2580, 2557, 13105, 13128, 2581, 2558, 13106, 13129
6220, 2581, 2558, 13106, 13129, 2582, 2559, 13107, 13130
6221, 2582, 2559, 13107, 13130, 2583, 2560, 13108, 13131
6222, 2583, 2560, 13108, 13131, 2584, 2561, 13109, 13132
6223, 2584, 2561, 13109, 13132, 2585, 2562, 13110, 13133
6224, 2585, 2562, 13110, 13133, 2586, 2563, 13111, 13134
6225, 2586, 2563, 13111, 13134, 135, 134, 1987, 1988
6226, 3, 109, 1966, 120, 218, 2564, 13112, 2252
6227, 218, 2564, 13112, 2252, 219, 2565, 13113, 2263
6228, 219, 2565, 13113, 2263, 220, 2566, 13114, 2274
6229, 220, 2566, 13114, 2274, 221, 2567, 13115, 2285
6230, 221, 2567, 13115, 2285, 222, 2568, 13116, 2296
6231, 222, 2568, 13116, 2296, 223, 2569, 13117, 2307
6232, 223, 2569, 13117, 2307, 224, 2570, 13118, 2318
6233, 224, 2570, 13118, 2318, 225, 2571, 13119, 2329
6234, 225, 2571, 13119, 2329, 226, 2572, 13120, 2340
6235, 226, 2572, 13120, 2340, 227, 2573, 13121, 2351
6236, 227, 2573, 13121, 2351, 228, 2574, 13122, 2362
6237, 228, 2574, 13122, 2362, 229, 2575, 13123, 2373
6238, 229, 2575, 13123, 2373, 230, 2576, 13124, 2384
6239, 230, 2576, 13124, 2384, 231, 2577, 13125, 2395
6240, 231, 2577, 13125, 2395, 232, 2578, 13126, 2406
6241, 232, 2578, 13126, 2406, 233, 2579, 13127, 2417
6242, 233, 2579, 13127, 2417, 234, 2580, 13128, 2428
6243, 234, 2580, 13128, 2428, 235, 2581, 13129, 2439
6244, 235, 2581, 13129, 2439, 236, 2582, 13130, 2450
6245, 236, 2582, 13130, 2450, 237, 2583, 13131, 2461
6246, 237, 2583, 13131, 2461, 238, 2584, 13132, 2472
6247, 238, 2584, 13132, 2472, 239, 2585, 13133, 2483
6248, 239, 2585, 13133, 2483, 240, 2586, 13134, 2494
6249, 240, 2586, 13134, 2494, 7, 135, 1988, 146
*ELEMENT, type=C3D8, ELSET=Volume2
6250, 4, 110, 2242, 195, 10, 298, 2587, 241
6251, 110, 111, 2243, 2242, 298, 299, 2588, 2587
6252, 111, 112, 2244, 2243, 299, 300, 2589, 2588
6253, 112, 113, 2245, 2244, 300, 301, 2590, 2589
6254, 113, 114, 2246, 2245, 301, 302, 2591, 2590
6255, 114, 115, 2247, 2246, 302, 303, 2592, 2591
6256, 115, 116, 2248, 2247, 303, 304, 2593, 2592
6257, 116, 117, 2249, 2248, 304, 305, 2594, 2593
6258, 117, 118, 2250, 2249, 305, 306, 2595, 2594
6259, 118, 119, 2251, 2250, 306, 307, 2596, 2595
6260, 119, 120, 2252, 2251, 307, 308, 2597, 2596
6261, 120, 3, 218, 2252, 308, 12, 275, 2597
6262, 195, 2242, 2253, 196, 241, 2587, 2598, 242
6263, 2242, 2243, 2254, 2253, 2587, 2588, 2599, 2598
6264, 2243, 2244, 2255, 2254, 2588, 2589, 2600, 2599
6265, 2244, 2245, 2256, 2255, 2589, 2590, 2601, 2600
6266, 2245, 2246, 2257, 2256, 2590, 2591, 2602, 2601
6267, 2246, 2247, 2258, 2257, 2591, 2592, 2603, 2602
6268, 2247, 2248, 2259, 2258, 2592, 2593, 2604, 2603
6269, 2248, 2249, 2260, 2259, 2593, 2594, 2605, 2604
6270, 2249, 2250, 2261, 2260, 2594, 2595, 2606, 2605
6271, 2250, 2251, 2262, 2261, 2595, 2596, 2607, 2606
6272, 2251, 2252, 2263, 2262, 2596, 2597, 2608, 2607
6273, 2252, 218, 219, 2263, 2597, 275, 276, 2608
6274, 196, 2253, 2264, 197, 242, 2598, 2609, 243
6275, 2253, 2254, 2265, 2264, 2598, 2599, 2610, 2609
6276, 2254, 2255, 2266, 2265, 2599, 2600, 2611, 2610
6277, 2255, 2256, 2267, 2266, 2600, 2601, 2612, 2611
6278, 2256, 2257, 2268, 2267, 2601, 2602, 2613, 2612
6279, 2257, 2258, 2269, 2268, 2602, 2603, 2614, 2613
6280, 2258, 2259, 2270, 2269, 2603, 2604, 2615, 2614
6281, 2259, 2260, 2271, 2270, 2604, 2605, 2616, 2615
6282, 2260, 2261, 2272, 2271, 2605, 2606, 2617, 2616
6283, 2261, 2262, 2273, 2272, 2606, 2607, 2618, 2617
6284, 2262, 2263, 2274, 2273, 2607, 2608, 2619, 2618
6285, 2263, 219, 220, 2274, 2608, 276, 277, 2619
6286, 197, 2264, 2275, 198, 243, 2609, 2620, 244
6287, 2264, 2265, 2276, 2275, 2609, 2610, 2621, 2620
6288, 2265, 2266, 2277, 2276, 2610, 2611, 2622, 2621
6289, 2266, 2267, 2278, 2277, 2611, 2612, 2623, 2622
6290, 2267, 2268, 2279, 2278, 2612, 2613, 2624, 2623
6291, 2268, 2269, 2280, 2279, 2613, 2614, 2625, 2624
6292, 2269, 2270, 2281, 2280, 2614, 2615, 2626, 2625
6293, 2270, 2271, 2282, 2281, 2615, 2616, 2627, 2626
6294, 2271, 2272, 2283, 2282, 2616, 2617, 2628, 2627
6295, 2272, 2273, 2284, 2283, 2617, 2618, 2629, 2628
6296, 2273, 2274, 2285, 2284, 2618, 2619, 2630, 2629
6297, 2274, 220, 221, 2285, 2619, 277, 278, 2630
6298, 198, 2275, 2286, 199, 244, 2620, 2631, 245
6299, 2275, 2276, 2287, 2286, 2620, 2621, 2632, 2631
6300, 2276, 2277, 2288, 2287, 2621, 2622, 2633, 2632
6301, 2277, 2278, 2289, 2288, 2622, 2623, 2634, 2633
6302, 2278, 2279, 2290, 2289, 2623, 2624, 2635, 2634
6303, 2279, 2280, 2291, 2290, 2624, 2625, 2636, 2635
6304, 2280, 2281, 2292, 2291, 2625, 2626, 2637, 2636
6305, 2281, 2282, 2293, 2292, 2626, 2627, 2638, 2637
6306, 2282, 2283, 2294, 2293, 2627, 2628, 2639, 2638
6307, 2283, 2284, 2295, 2294, 2628, 2629, 2640, 2639
6308, 2284, 2285, 2296, 2295, 2629, 2630, 2641, 2640
6309, 2285, 221, 222, 2296, 2630, 278, 279, 2641
6310, 199, 2286, 2297, 200, 245, 2631, 2642, 246
6311, 2286, 2287, 2298, 2297, 2631, 2632, 2643, 2642
6312, 2287, 2288, 2299, 2298, 2632, 2633, 2644, 2643
6313, 2288, 2289, 2300, 2299, 2633, 2634, 2645, 2644
6314, 2289, 2290, 2301, 2300, 2634, 2635, 2646, 2645
6315, 2290, 2291, 2302, 2301, 2635, 2636, 2647, 2646
6316, 2291, 2292, 2303, 2302, 2636, 2637, 2648, 2647
6317, 2292, 2293, 2304, 2303, 2637, 2638, 2649, 2648
6318, 2293, 2294, 2305, 2304, 2638, 2639, 2650, 2649
6319, 2294, 2295, 2306, 2305, 2639, 2640, 2651, 2650
6320, 2295, 2296, 2307, 2306, 2640, 2641, 2652, 2651
6321, 2296, 222, 223, 2307, 2641, 279, 280, 2652
6322, 200, 2297, 2308, 201, 246, 2642, 2653, 247
6323, 2297, 2298, 2309, 2308, 2642, 2643, 2654, 2653
6324, 2298, 2299, 2310, 2309, 2643, 2644, 2655, 2654
6325, 2299, 2300, 2311, 2310, 2644, 2645, 2656, 2655
6326, 2300, 2301, 2312, 2311, 2645, 2646, 2657, 2656
6327, 2301, 2302, 2313, 2312, 2646, 2647, 2658, 2657
6328, 2302, 2303, 2314, 2313, 2647, 2648, 2659, 2658
6329, 2303, 2304, 2315, 2314, 2648, 2649, 2660, 2659
6330, 2304, 2305, 2316, 2315, 2649, 2650, 2661, 2660
6331, 2305, 2306, 2317, 2316, 2650, 2651, 2662, 2661
6332, 2306, 2307, 2318, 2317, 2651, 2652, 2663, 2662
6333, 2307, 223, 224, 2318, 2652, 280, 281, 2663
6334, 201, 2308, 2319, 202, 247, 2653, 2664, 248
6335, 2308, 2309, 2320, 2319, 2653, 2654, 2665, 2664
6336, 2309, 2310, 2321, 2320, 2654, 2655, 2666, 2665
6337, 2310, 2311, 2322, 2321, 2655, 2656, 2667, 2666
6338, 2311, 2312, 2323, 2322, 2656, 2657, 2668, 2667
6339, 2312, 2313, 2324, 2323, 2657, 2658, 2669, 2668
6340, 2313, 2314, 2325, 2324, 2658, 2659, 2670, 2669
6341, 2314, 2315, 2326, 2325, 2659, 2660, 2671, 2670
6342, 2315, 2316, 2327, 2326, 2660, 2661, 2672, 2671
6343, 2316, 2317, 2328, 2327, 2661, 2662, 2673, 2672
6344, 2317, 2318, 2329, 2328, 2662, 2663, 2674, 2673
6345, 2318, 224, 225, 2329, 2663, 281, 282, 2674
6346, 202, 2319, 2330, 203, 248, 2664, 2675, 249
6347, 2319, 2320, 2331, 2330, 2664, 2665, 2676, 2675
6348, 2320, 2321, 2332, 2331, 2665, 2666, 2677, 2676
6349, 2321, 2322, 2333, 2332, 2666, 2667, 2678, 2677
6350, 2322, 2323, 2334, 2333, 2667, 2668, 2679, 2678
6351, 2323, 2324, 2335, 2334, 2668, 2669, 2680, 2679
6352, 2324, 2325, 2336, 2335, 2669, 2670, 2681, 2680
6353, 2325, 2326, 2337, 2336, 2670, 2671, 2682, 2681
6354, 2326, 2327, 2338, 2337, 2671, 2672, 2683, 2682
6355, 2327, 2328, 2339, 2338, 2672, 2673, 2684, 2683
6356, 2328, 2329, 2340, 2339, 2673, 2674, 2685, 2684
6357, 2329, 225, 226, 2340, 2674, 282, 283, 2685
6358, 203, 2330, 2341, 204, 249, 2675, 2686, 250
6359, 2330, 2331, 2342, 2341, 2675, 2676, 2687, 2686
6360, 2331, 2332, 2343, 2342, 2676, 2677, 2688, 2687
6361, 2332, 2333, 2344, 2343, 2677, 2678, 2689, 2688
6362, 2333, 2334, 2345, 2344, 2678, 2679, 2690, 2689
6363, 2334, 2335, 2346, 2345, 2679, 2680, 2691, 2690
6364, 2335, 2336, 2347, 2346, 2680, 2681, 2692, 2691
6365, 2336, 2337, 2348, 2347, 2681, 2682, 2693, 2692
6366, 2337, 2338, 2349, 2348, 2682, 2683, 2694, 2693
6367, 2338, 2339, 2350, 2349, 2683, 2684, 2695, 2694
6368, 2339, 2340, 2351, 2350, 2684, 2685, 2696, 2695
6369, 2340, 226, 227, 2351, 2685, 283, 284, 2696
6370, 204, 2341, 2352, 205, 250, 2686, 2697, 251
6371, 2341, 2342, 2353, 2352, 2686, 2687, 2698, 2697
6372, 2342, 2343, 2354, 2353, 2687, 2688, 2699, 2698
6373, 2343, 2344, 2355, 2354, 2688, 2689, 2700, 2699
6374, 2344, 2345, 2356, 2355, 2689, 2690, 2701, 2700
6375, 2345, 2346, 2357, 2356, 2690, 2691, 2702, 2701
6376, 2346, 2347, 2358, 2357, 2691, 2692, 2703, 2702
6377, 2347, 2348, 2359, 2358, 2692, 2693, 2704, 2703
6378, 2348, 2349, 2360, 2359, 2693, 2694, 2705, 2704
6379, 2349, 2350, 2361, 2360, 2694, 2695, 2706, 2705
6380, 2350, 2351, 2362, 2361, 2695, 2696, 2707, 2706
6381, 2351, 227, 228, 2362, 2696, 284, 285, 2707
6382, 205, 2352, 2363, 206, 251, 2697, 2708, 252
6383, 2352, 2353, 2364, 2363, 2697, 2698, 2709, 2708
6384, 2353, 2354, 2365, 2364, 2698, 2699, 2710, 2709
6385, 2354, 2355, 2366, 2365, 2699, 2700, 2711, 2710
6386, 2355, 2356, 2367, 2366, 2700, 2701, 2712, 2711
6387, 2356, 2357, 2368, 2367, 2701, 2702, 2713, 2712
6388, 2357, 2358, 2369, 2368, 2702, 2703, 2714, 2713
6389, 2358, 2359, 2370, 2369, 2703, 2704, 2715, 2714
6390, 2359, 2360, 2371, 2370, 2704, 2705, 2716, 2715
6391, 2360, 2361, 2372, 2371, 2705, 2706, 2717, 2716
6392, 2361, 2362, 2373, 2372, 2706, 2707, 2718, 2717
6393, 2362, 228, 229, 2373, 2707, 285, 286, 2718
6394, 206, 2363, 2374, 207, 252, 2708, 2719, 253
6395, 2363, 2364, 2375, 2374, 2708, 2709, 2720, 2719
6396, 2364, 2365, 2376, 2375, 2709, 2710, 2721, 2720
6397, 2365, 2366, 2377, 2376, 2710, 2711, 2722, 2721
6398, 2366, 2367, 2378, 2377, 2711, 2712, 2723, 2722
6399, 2367, 2368, 2379, 2378, 2712, 2713, 2724, 2723
6400, 2368, 2369, 2380, 2379, 2713, 2714, 2725, 2724
6401, 2369, 2370, 2381, 2380, 2714, 2715, 2726, 2725
6402, 2370, 2371, 2382, 2381, 2715, 2716, 2727, 2726
6403, 2371, 2372, 2383, 2382, 2716, 2717, 2728, 2727
6404, 2372, 2373, 2384, 2383, 2717, 2718, 2729, 2728
6405, 2373, 229, 230, 2384, 2718, 286, 287, 2729
6406, 207, 2374, 2385, 208, 253, 2719, 2730, 254
6407, 2374, 2375, 2386, 2385, 2719, 2720, 2731, 2730
6408, 2375, 2376, 2387, 2386, 2720, 2721, 2732, 2731
6409, 2376, 2377, 2388, 2387, 2721, 2722, 2733, 2732
6410, 2377, 2378, 2389, 2388, 2722, 2723, 2734, 2733
6411, 2378, 2379, 2390, 2389, 2723, 2724, 2735, 2734
6412, 2379, 2380, 2391, 2390, 2724, 2725, 2736, 2735
6413, 2380, 2381, 2392, 2391, 2725, 2726, 2737, 2736
6414, 2381, 2382, 2393, 2392, 2726, 2727, 2738, 2737
6415, 2382, 2383, 2394, 2393, 2727, 2728, 2739, 2738
6416, 2383, 2384, 2395, 2394, 2728, 2729, 2740, 2739
6417, 2384, 230, 231, 2395, 2729, 287, 288, 2740
6418, 208, 2385, 2396, 209, 254, 2730, 2741, 255
6419, 2385, 2386, 2397, 2396, 2730, 2731, 2742, 2741
6420, 2386, 2387, 2398, 2397, 2731, 2732, 2743, 2742
6421, 2387, 2388, 2399, 2398, 2732, 2733, 2744, 2743
6422, 2388, 2389, 2400, 2399, 2733, 2734, 2745, 2744
6423, 2389, 2390, 2401, 2400, 2734, 2735, 2746, 2745
6424, 2390, 2391, 2402, 2401, 2735, 2736, 2747, 2746
6425, 2391, 2392, 2403, 2402, 2736, 2737, 2748, 2747
6426, 2392, 2393, 2404, 2403, 2737, 2738, 2749, 2748
6427, 2393, 2394, 2405, 2404, 2738, 2739, 2750, 2749
6428, 2394, 2395, 2406, 2405, 2739, 2740, 2751, 2750
6429, 2395, 231, 232, 2406, 2740, 288, 289, 2751
6430, 209, 2396, 2407, 210, 255, 2741, 2752, 256
6431, 2396, 2397, 2408, 2407, 2741, 2742, 2753, 2752
6432, 2397, 2398, 2409, 2408, 2742, 2743, 2754, 2753
6433, 2398, 2399, 2410, 2409, 2743, 2744, 2755, 2754
6434, 2399, 2400, 2411, 2410, 2744, 2745, 2756, 2755
6435, 2400, 2401, 2412, 2411, 2745, 2746, 2757, 2756
6436, 2401, 2402, 2413, 2412, 2746, 2747, 2758, 2757
6437, 2402, 2403, 2414, 2413, 2747, 2748, 2759, 2758
6438, 2403, 2404, 2415, 2414, 2748, 2749, 2760, 2759
6439, 2404, 2405, 2416, 2415, 2749, 2750, 2761, 2760
6440, 2405, 2406, 2417, 2416, 2750, 2751, 2762, 2761
6441, 2406, 232, 233, 2417, 2751, 289, 290, 2762
6442, 210, 2407, 2418, 211, 256, 2752, 2763, 257
6443, 2407, 2408, 2419, 2418, 2752, 2753, 2764, 2763
6444, 2408, 2409, 2420, 2419, 2753, 2754, 2765, 2764
6445, 2409, 2410, 2421, 2420, 2754, 2755, 2766, 2765
6446, 2410, 2411, 2422, 2421, 2755, 2756, 2767, 2766
6447, 2411, 2412, 2423, 2422, 2756, 2757, 2768, 2767
6448, 2412, 2413, 2424, 2423, 2757, 2758, 2769, 2768
6449, 2413, 2414, 2425, 2424, 2758, 2759, 2770, 2769
6450, 2414, 2415, 2426, 2425, 2759, 2760, 2771, 2770
6451, 2415, 2416, 2427, 2426, 2760, 2761, 2772, 2771
6452, 2416, 2417, 2428, 2427, 2761, 2762, 2773, 2772
6453, 2417, 233, 234, 2428, 2762, 290, 291, 2773
6454, 211, 2418, 2429, 212, 257, 2763, 2774, 258
6455, 2418, 2419, 2430, 2429, 2763, 2764, 2775, 2774
6456, 2419, 2420, 2431, 2430, 2764, 2765, 2776, 2775
6457, 2420, 2421, 2432, 2431, 2765, 2766, 2777, 2776
6458, 2421, 2422, 2433, 2432, 2766, 2767, 2778, 2777
6459, 2422, 2423, 2434, 2433, 2767, 2768, 2779, 2778
6460, 2423, 2424, 2435, 2434, 2768, 2769, 2780, 2779
6461, 2424, 2425, 2436, 2435, 2769, 2770, 2781, 2780
6462, 2425, 2426, 2437, 2436, 2770, 2771, 2782, 2781
6463, 2426, 2427, 2438, 2437, 2771, 2772, 2783, 2782
6464, 2427, 2428, 2439, 2438, 2772, 2773, 2784, 2783
6465, 2428, 234, 235, 2439, 2773, 291, 292, 2784
6466, 212, 2429, 2440, 213, 258, 2774, 2785, 259
6467, 2429, 2430, 2441, 2440, 2774, 2775, 2786, 2785
6468, 2430, 2431, 2442, 2441, 2775, 2776, 2787, 2786
6469, 2431, 2432, 2443, 2442, 2776, 2777, 2788, 2787
6470, 2432, 2433, 2444, 2443, 2777, 2778, 2789, 2788
6471, 2433, 2434, 2445, 2444, 2778, 2779, 2790, 2789
6472, 2434, 2435, 2446, 2445, 2779, 2780, 2791, 2790
6473, 2435, 2436, 2447, 2446, 2780, 2781, 2792, 2791
6474, 2436, 2437, 2448, 2447, 2781, 2782, 2793, 2792
6475, 2437, 2438, 2449, 2448, 2782, 2783, 2794, 2793
6476, 2438, 2439, 2450, 2449, 2783, 2784, 2795, 2794
6477, 2439, 235, 236, 2450, 2784, 292, 293, 2795
6478, 213, 2440, 2451, 214, 259, 2785, 2796, 260
6479, 2440, 2441, 2452, 2451, 2785, 2786, 2797, 2796
6480, 2441, 2442, 2453, 2452, 2786, 2787, 2798, 2797
6481, 2442, 2443, 2454, 2453, 2787, 2788, 2799, 2798
6482, 2443, 2444, 2455, 2454, 2788, 2789, 2800, 2799
6483, 2444, 2445, 2456, 2455, 2789, 2790, 2801, 2800
6484, 2445, 2446, 2457, 2456, 2790, 2791, 2802, 2801
6485, 2446, 2447, 2458, 2457, 2791, 2792, 2803, 2802
6486, 2447, 2448, 2459, 2458, 2792, 2793, 2804, 2803
6487, 2448, 2449, 2460, 2459, 2793, 2794, 2805, 2804
6488, 2449, 2450, 2461, 2460, 2794, 2795, 2806, 2805
6489, 2450, 236, 237, 2461, 2795, 293, 294, 2806
6490, 214, 2451, 2462, 215, 260, 2796, 2807, 261
6491, 2451, 2452, 2463, 2462, 2796, 2797, 2808, 2807
6492, 2452, 2453, 2464, 2463, 2797, 2798, 2809, 2808
6493, 2453, 2454, 2465, 2464, 2798, 2799, 2810, 2809
6494, 2454, 2455, 2466, 2465, 2799, 2800, 2811, 2810
6495, 2455, 2456, 2467, 2466, 2800, 2801, 2812, 2811
6496, 2456, 2457, 2468, 2467, 2801, 2802, 2813, 2812
6497, 2457, 2458, 2469, 2468, 2802, 2803, 2814, 2813
6498, 2458, 2459, 2470, 2469, 2803, 2804, 2815, 2814
6499, 2459, 2460, 2471, 2470, 2804, 2805, 2816, 2815
6500, 2460, 2461, 2472, 2471, 2805, 2806, 2817, 2816
6501, 2461, 237, 238, 2472, 2806, 294, 295, 2817
6502, 215, 2462, 2473, 216, 261, 2807, 2818, 262
6503, 2462, 2463, 2474, 2473, 2807, 2808, 2819, 2818
6504, 2463, 2464, 2475, 2474, 2808, 2809, 2820, 2819
6505, 2464, 2465, 2476, 2475, 2809, 2810, 2821, 2820
6506, 2465, 2466, 2477, 2476, 2810, 2811, 2822, 2821
6507, 2466, 2467, 2478, 2477, 2811, 2812, 2823, 2822
6508, 2467, 2468, 2479, 2478, 2812, 2813, 2824, 2823
6509, 2468, 2469, 2480, 2479, 2813, 2814, 2825, 2824
6510, 2469, 2470, 2481, 2480, 2814, 2815, 2826, 2825
6511, 2470, 2471, 2482, 2481, 2815, 2816, 2827, 2826
6512, 2471, 2472, 2483, 2482, 2816, 2817, 2828, 2827
6513, 2472, 238, 239, 2483, 2817, 295, 296, 2828
6514, 216, 2473, 2484, 217, 262, 2818, 2829, 263
6515, 2473, 2474, 2485, 2484, 2818, 2819, 2830, 2829
6516, 2474, 2475, 2486, 2485, 2819, 2820, 2831, 2830
6517, 2475, 2476, 2487, 2486, 2820, 2821, 2832, 2831
6518, 2476, 2477, 2488, 2487, 2821, 2822, 2833, 2832
6519, 2477, 2478, 2489, 2488, 2822, 2823, 2834, 2833
6520, 2478, 2479, 2490, 2489, 2823, 2824, 2835, 2834
6521, 2479, 2480, 2491, 2490, 2824, 2825, 2836, 2835
6522, 2480, 2481, 2492, 2491, 2825, 2826, 2837, 2836
6523, 2481, 2482, 2493, 2492, 2826, 2827, 2838, 2837
6524, 2482, 2483, 2494, 2493, 2827, 2828, 2839, 2838
6525, 2483, 239, 240, 2494, 2828, 296, 297, 2839
6526, 217, 2484, 136, 8, 263, 2829, 264, 9
6527, 2484, 2485, 137, 136, 2829, 2830, 265, 264
6528, 2485, 2486, 138, 137, 2830, 2831, 266, 265
6529, 2486, 2487, 139, 138, 2831, 2832, 267, 266
6530, 2487, 2488, 140, 139, 2832, 2833, 268, 267
6531, 2488, 2489, 141, 140, 2833, 2834, 269, 268
6532, 2489, 2490, 142, 141, 2834, 2835, 270, 269
6533, 2490, 2491, 143, 142, 2835, 2836, 271, 270
6534, 2491, 2492, 144, 143, 2836, 2837, 272, 271
6535, 2492, 2493, 145, 144, 2837, 2838, 273, 272
6536, 2493, 2494, 146, 145, 2838, 2839, 274, 273
6537, 2494, 240, 7, 146, 2839, 297, 11, 274
*ELEMENT, type=C3D8, ELSET=Volume3
6538, 10, 298, 2587, 241, 332, 4151, 13135, 2840
6539, 332, 4151, 13135, 2840, 333, 4152, 13136, 2841
6540, 333, 4152, 13136, 2841, 334, 4153, 13137, 2842
6541, 334, 4153, 13137, 2842, 335, 4154, 13138, 2843
6542, 335, 4154, 13138, 2843, 336, 4155, 13139, 2844
6543, 336, 4155, 13139, 2844, 337, 4156, 13140, 2845
6544, 337, 4156, 13140, 2845, 338, 4157, 13141, 2846
6545, 338, 4157, 13141, 2846, 339, 4158, 13142, 2847
6546, 339, 4158, 13142, 2847, 340, 4159, 13143, 2848
6547, 340, 4159, 13143, 2848, 341, 4160, 13144, 2849
6548, 341, 4160, 13144, 2849, 342, 4161, 13145, 2850
6549, 342, 4161, 13145, 2850, 343, 4162, 13146, 2851
6550, 343, 4162, 13146, 2851, 344, 4163, 13147, 2852
6551, 344, 4163, 13147, 2852, 345, 4164, 13148, 2853
6552, 345, 4164, 13148, 2853, 346, 4165, 13149, 2854
6553, 346, 4165, 13149, 2854, 347, 4166, 13150, 2855
6554, 347, 4166, 13150, 2855, 348, 4167, 13151, 2856
6555, 348, 4167, 13151, 2856, 349, 4168, 13152, 2857
6556, 349, 4168, 13152, 2857, 350, 4169, 13153, 2858
6557, 350, 4169, 13153, 2858, 351, 4170, 13154, 2859
6558, 351, 4170, 13154, 2859, 352, 4171, 13155, 2860
6559, 352, 4171, 13155, 2860, 353, 4172, 13156, 2861
6560, 353, 4172, 13156, 2861, 354, 4173, 13157, 2862
6561, 354, 4173, 13157, 2862, 14, 458, 4404, 355
6562, 298, 299, 2588, 2587, 4151, 4174, 13158, 13135
6563, 4151, 4174, 13158, 13135, 4152, 4175, 13159, 13136
6564, 4152, 4175, 13159, 13136, 4153, 4176, 13160, 13137
6565, 4153, 4176, 13160, 13137, 4154, 4177, 13161, 13138
6566, 4154, 4177, 13161, 13138, 4155, 4178, 13162, 13139
6567, 4155, 4178, 13162, 13139, 4156, 4179, 13163, 13140
6568, 4156, 4179, 13163, 13140, 4157, 4180, 13164, 13141
6569, 4157, 4180, 13164, 13141, 4158, 4181, 13165, 13142
6570, 4158, 4181, 13165, 13142, 4159, 4182, 13166, 13143
6571, 4159, 4182, 13166, 13143, 4160, 4183, 13167, 13144
6572, 4160, 4183, 13167, 13144, 4161, 4184, 13168, 13145
6573, 4161, 4184, 13168, 13145, 4162, 4185, 13169, 13146
6574, 4162, 4185, 13169, 13146, 4163, 4186, 13170, 13147
6575, 4163, 4186, 13170, 13147, 4164, 4187, 13171, 13148
6576, 4164, 4187, 13171, 13148, 4165, 4188, 13172, 13149
6577, 4165, 4188, 13172, 13149, 4166, 4189, 13173, 13150
6578, 4166, 4189, 13173, 13150, 4167, 4190, 13174, 13151
6579, 4167, 4190, 13174, 13151, 4168, 4191, 13175, 13152
6580, 4168, 4191, 13175, 13152, 4169, 4192, 13176, 13153
6581, 4169, 4192, 13176, 13153, 4170, 4193, 13177, 13154
6582, 4170, 4193, 13177, 13154, 4171, 4194, 13178, 13155
6583, 4171, 4194, 13178, 13155, 4172, 4195, 13179, 13156
6584, 4172, 4195, 13179, 13156, 4173, 4196, 13180, 13157
6585, 4173, 4196, 13180, 13157, 458, 459, 4405, 4404
6586, 299, 300, 2589, 2588, 4174, 4197, 13181, 13158
6587, 4174, 4197, 13181, 13158, 4175, 4198, 13182, 13159
6588, 4175, 4198, 13182, 13159, 4176, 4199, 13183, 13160
6589, 4176, 4199, 13183, 13160, 4177, 4200, 13184, 13161
6590, 4177, 4200, 13184, 13161, 4178, 4201, 13185, 13162
6591, 4178, 4201, 13185, 13162, 4179, 4202, 13186, 13163
6592, 4179, 4202, 13186, 13163, 4180, 4203, 13187, 13164
6593, 4180, 4203, 13187, 13164, 4181, 4204, 13188, 13165
6594, 4181, 4204, 13188, 13165, 4182, 4205, 13189, 13166
6595, 4182, 4205, 13189, 13166, 4183, 4206, 13190, 13167
6596, 4183, 4206, 13190, 13167, 4184, 4207, 13191, 13168
6597, 4184, 4207, 13191, 13168, 4185, 4208, 13192, 13169
6598, 4185, 4208, 13192, 13169, 4186, 4209, 13193, 13170
6599, 4186, 4209, 13193, 13170, 4187, 4210, 13194, 13171
6600, 4187, 4210, 13194, 13171, 4188, 4211, 13195, 13172
6601, 4188, 4211, 13195, 13172, 4189, 4212, 13196, 13173
6602, 4189, 4212, 13196, 13173, 4190, 4213, 13197, 13174
6603, 4190, 4213, 13197, 13174, 4191, 4214, 13198, 13175
6604, 4191, 4214, 13198, 13175, 4192, 4215, 13199, 13176
6605, 4192, 4215, 13199, 13176, 4193, 4216, 13200, 13177
6606, 4193, 4216, 13200, 13177, 4194, 4217, 13201, 13178
6607, 4194, 4217, 13201, 13178, 4195, 4218, 13202, 13179
6608, 4195, 4218, 13202, 13179, 4196, 4219, 13203, 13180
6609, 4196, 4219, 13203, 13180, 459, 460, 4406, 4405
6610, 300, 301, 2590, 2589, 4197, 4220, 13204, 13181
6611, 4197, 4220, 13204, 13181, 4198, 4221, 13205, 13182
6612, 4198, 4221, 13205, 13182, 4199, 4222, 13206, 13183
6613, 4199, 4222, 13206, 13183, 4200, 4223, 13207, 13184
6614, 4200, 4223, 13207, 13184, 4201, 4224, 13208, 13185
6615, 4201, 4224, 13208, 13185, 4202, 4225, 13209, 13186
6616, 4202, 4225, 13209, 13186, 4203, 4226, 13210, 13187
6617, 4203, 4226, 13210, 13187, 4204, 4227, 13211, 13188
6618, 4204, 4227, 13211, 13188, 4205, 4228, 13212, 13189
6619, 4205, 4228, 13212, 13189, 4206, 4229, 13213, 13190
6620, 4206, 4229, 13213, 13190, 4207, 4230, 13214, 13191
6621, 4207, 4230, 13214, 13191, 4208, 4231, 13215, 13192
6622, 4208, 4231, 13215, 13192, 4209, 4232, 13216, 13193
6623, 4209, 4232, 13216, 13193, 4210, 4233, 13217, 13194
6624, 4210, 4233, 13217, 13194, 4211, 4234, 13218, 13195
6625, 4211, 4234, 13218, 13195, 4212, 4235, 13219, 13196
6626, 4212, 4235, 13219, 13196, 4213, 4236, 13220, 13197
6627, 4213, 4236, 13220, 13197, 4214, 4237, 13221, 13198
6628, 4214, 4237, 13221, 13198, 4215, 4238, 13222, 13199
6629, 4215, 4238, 13222, 13199, 4216, 4239, 13223, 13200
6630, 4216, 4239, 13223, 13200, 4217, 4240, 13224, 13201
6631, 4217, 4240, 13224, 13201, 4218, 4241, 13225, 13202
6632, 4218, 4241, 13225, 13202, 4219, 4242, 13226, 13203
6633, 4219, 4242, 13226, 13203, 460, 461, 4407, 4406
6634, 301, 302, 2591, 2590, 4220, 4243, 13227, 13204
6635, 4220, 4243, 13227, 13204, 4221, 4244, 13228, 13205
6636, 4221, 4244, 13228, 13205, 4222, 4245, 13229, 13206
6637, 4222, 4245, 13229, 13206, 4223, 4246, 13230, 13207
6638, 4223, 4246, 13230, 13207, 4224, 4247, 13231, 13208
6639, 4224, 4247, 13231, 13208, 4225, 4248, 13232, 13209
6640, 4225, 4248, 13232, 13209, 4226, 4249, 13233, 13210
6641, 4226, 4249, 13233, 13210, 4227, 4250, 13234, 13211
6642, 4227, 4250, 13234, 13211, 4228, 4251, 13235, 13212
6643, 4228, 4251, 13235, 13212, 4229, 4252, 13236, 13213
6644, 4229, 4252, 13236, 13213, 4230, 4253, 13237, 13214
6645, 4230, 4253, 13237, 13214, 4231, 4254, 13238, 13215
6646, 4231, 4254, 13238, 13215, 4232, 4255, 13239, 13216
6647, 4232, 4255, 13239, 13216, 4233, 4256, 13240, 13217
6648, 4233, 4256, 13240, 13217, 4234, 4257, 13241, 13218
6649, 4234, 4257, 13241, 13218, 4235, 4258, 13242, 13219
6650, 4235, 4258, 13242, 13219, 4236, 4259, 13243, 13220
6651, 4236, 4259, 13243, 13220, 4237, 4260, 13244, 13221
6652, 4237, 4260, 13244, 13221, 4238, 4261, 13245, 13222
6653, 4238, 4261, 13245, 13222, 4239, 4262, 13246, 13223
6654, 4239, 4262, 13246, 13223, 4240, 4263, 13247, 13224
6655, 4240, 4263, 13247, 13224, 4241, 4264, 13248, 13225
6656, 4241, 4264, 13248, 13225, 4242, 4265, 13249, 13226
6657, 4242, 4265, 13249, 13226, 461, 462, 4408, 4407
6658, 302, 303, 2592, 2591, 4243, 4266, 13250, 13227
6659, 4243, 4266, 13250, 13227, 4244, 4267, 13251, 13228
6660, 4244, 4267, 13251, 13228, 4245, 4268, 13252, 13229
6661, 4245, 4268, 13252, 13229, 4246, 4269, 13253, 13230
6662, 4246, 4269, 13253, 13230, 4247, 4270, 13254, 13231
6663, 4247, 4270, 13254, 13231, 4248, 4271, 13255, 13232
6664, 4248, 4271, 13255, 13232, 4249, 4272, 13256, 13233
6665, 4249, 4272, 13256, 13233, 4250, 4273, 13257, 13234
6666, 4250, 4273, 13257, 13234, 4251, 4274, 13258, 13235
6667, 4251, 4274, 13258, 13235, 4252, 4275, 13259, 13236
6668, 4252, 4275, 13259, 13236, 4253, 4276, 13260, 13237
6669, 4253, 4276, 13260, 13237, 4254, 4277, 13261, 13238
6670, 4254, 4277, 13261, 13238, 4255, 4278, 13262, 13239
6671, 4255, 4278, 13262, 13239, 4256, 4279, 13263, 13240
6672, 4256, 4279, 13263, 13240, 4257, 4280, 13264, 13241
6673, 4257, 4280, 13264, 13241, 4258, 4281, 13265, 13242
6674, 4258, 4281, 13265, 13242, 4259, 4282, 13266, 13243
6675, 4259, 4282, 13266, 13243, 4260, 4283, 13267, 13244
6676, 4260, 4283, 13267, 13244, 4261, 4284, 13268, 13245
6677, 4261, 4284, 13268, 13245, 4262, 4285, 13269, 13246
6678, 4262, 4285, 13269, 13246, 4263, 4286, 13270, 13247
6679, 4263, 4286, 13270, 13247, 4264, 4287, 13271, 13248
6680, 4264, 4287, 13271, 13248, 4265, 4288, 13272, 13249
6681, 4265, 4288, 13272, 13249, 462, 463, 4409, 4408
6682, 303, 304, 2593, 2592, 4266, 4289, 13273, 13250
6683, 4266, 4289, 13273, 13250, 4267, 4290, 13274, 13251
6684, 4267, 4290, 13274, 13251, 4268, 4291, 13275, 13252
6685, 4268, 4291, 13275, 13252, 4269, 4292, 13276, 13253
6686, 4269, 4292, 13276, 13253, 4270, 4293, 13277, 13254
6687, 4270, 4293, 13277, 13254, 4271, 4294, 13278, 13255
6688, 4271, 4294, 13278, 13255, 4272, 4295, 13279, 13256
6689, 4272, 4295, 13279, 13256, 4273, 4296, 13280, 13257
6690, 4273, 4296, 13280, 13257, 4274, 4297, 13281, 13258
6691, 4274, 4297, 13281, 13258, 4275, 4298, 13282, 13259
6692, 4275, 4298, 13282, 13259, 4276, 4299, 13283, 13260
6693, 4276, 4299, 13283, 13260, 4277, 4300, 13284, 13261
6694, 4277, 4300, 13284, 13261, 4278, 4301, 13285, 13262
6695, 4278, 4301, 13285, 13262, 4279, 4302, 13286, 13263
6696, 4279, 4302, 13286, 13263, 4280, 4303, 13287, 13264
6697, 4280, 4303, 13287, 13264, 4281, 4304, 13288, 13265
6698, 4281, 4304, 13288, 13265, 4282, 4305, 13289, 13266
6699, 4282, 4305, 13289, 13266, 4283, 4306, 13290, 13267
6700, 4283, 4306, 13290, 13267, 4284, 4307, 13291, 13268
6701, 4284, 4307, 13291, 13268, 4285, 4308, 13292, 13269
6702, 4285, 4308, 13292, 13269, 4286, 4309, 13293, 13270
6703, 4286, 4309, 13293, 13270, 4287, 4310, 13294, 13271
6704, 4287, 4310, 13294, 13271, 4288, 4311, 13295, 13272
6705, 4288, 4311, 13295, 13272, 463, 464, 4410, 4409
6706, 304, 305, 2594, 2593, 4289, 4312, 13296, 13273
6707, 4289, 4312, 13296, 13273, 4290, 4313, 13297, 13274
6708, 4290, 4313, 13297, 13274, 4291, 4314, 13298, 13275
6709, 4291, 4314, 13298, 13275, 4292, 4315, 13299, 13276
