23898, 1.4916666666667, 1.15, 0.33333333333333
23899, 1.4916666666667, 1.1, 0.33333333333333
23900, 1.4916666666667, 1.05, 0.33333333333333
23901, 1.4916666666667, 1, 0.33333333333333
23902, 1.4916666666667, 0.95, 0.33333333333333
23903, 1.4916666666667, 0.9, 0.33333333333333
23904, 1.4916666666667, 0.85, 0.33333333333333
23905, 1.4916666666667, 0.8, 0.33333333333333
23906, 1.4916666666667, 0.75, 0.33333333333333
23907, 1.4916666666667, 0.7, 0.33333333333333
23908, 1.4916666666667, 0.65, 0.33333333333333
23909, 1.4916666666667, 0.6, 0.33333333333333
23910, 1.4916666666667, 0.55, 0.33333333333333
23911, 1.4916666666667, 0.5, 0.33333333333333
23912, 1.4916666666667, 0.45, 0.33333333333333
23913, 1.4916666666667, 0.4, 0.33333333333333
23914, 1.4916666666667, 0.35, 0.33333333333333
23915, 1.4916666666667, 0.3, 0.33333333333333
23916, 1.4916666666667, 0.25, 0.33333333333333
23917, 1.4916666666667, 0.2, 0.33333333333333
23918, 1.5333333333333, 1.3, 0.33333333333333
23919, 1.5333333333333, 1.25, 0.33333333333333
23920, 1.5333333333333, 1.2, 0.33333333333333
23921, 1.5333333333333, 1.15, 0.33333333333333
23922, 1.5333333333333, 1.1, 0.33333333333333
23923, 1.5333333333333, 1.05, 0.33333333333333
23924, 1.5333333333333, 1, 0.33333333333333
23925, 1.5333333333333, 0.95, 0.33333333333333
23926, 1.5333333333333, 0.9, 0.33333333333333
23927, 1.5333333333333, 0.85, 0.33333333333333
23928, 1.5333333333333, 0.8, 0.33333333333333
23929, 1.5333333333333, 0.75, 0.33333333333333
23930, 1.5333333333333, 0.7, 0.33333333333333
23931, 1.5333333333333, 0.65, 0.33333333333333
23932, 1.5333333333333, 0.6, 0.33333333333333
23933, 1.5333333333333, 0.55, 0.33333333333333
23934, 1.5333333333333, 0.5, 0.33333333333333
23935, 1.5333333333333, 0.45, 0.33333333333333
23936, 1.5333333333333, 0.4, 0.33333333333333
23937, 1.5333333333333, 0.35, 0.33333333333333
23938, 1.5333333333333, 0.3, 0.33333333333333
23939, 1.5333333333333, 0.25, 0.33333333333333
23940, 1.5333333333333, 0.2, 0.33333333333333
23941, 1.575, 1.3, 0.33333333333333
23942, 1.575, 1.25, 0.33333333333333
23943, 1.575, 1.2, 0.33333333333333
23944, 1.575, 1.15, 0.33333333333333
23945, 1.575, 1.1, 0.33333333333333
23946, 1.575, 1.05, 0.33333333333333
23947, 1.575, 1, 0.33333333333333
23948, 1.575, 0.95, 0.33333333333333
23949, 1.575, 0.9, 0.33333333333333
23950, 1.575, 0.85, 0.33333333333333
23951, 1.575, 0.8, 0.33333333333333
23952, 1.575, 0.75, 0.33333333333333
23953, 1.575, 0.7, 0.33333333333333
23954, 1.575, 0.65, 0.33333333333333
23955, 1.575, 0.6, 0.33333333333333
23956, 1.575, 0.55, 0.33333333333333
23957, 1.575, 0.5, 0.33333333333333
23958, 1.575, 0.45, 0.33333333333333
23959, 1.575, 0.4, 0.33333333333333
23960, 1.575, 0.35, 0.33333333333333
23961, 1.575, 0.3, 0.33333333333333
23962, 1.575, 0.25, 0.33333333333333
23963, 1.575, 0.2, 0.33333333333333
23964, 1.6166666666667, 1.3, 0.33333333333333
23965, 1.6166666666667, 1.25, 0.33333333333333
23966, 1.6166666666667, 1.2, 0.33333333333333
23967, 1.6166666666667, 1.15, 0.33333333333333
23968, 1.6166666666667, 1.1, 0.33333333333333
23969, 1.6166666666667, 1.05, 0.33333333333333
23970, 1.6166666666667, 1, 0.33333333333333
23971, 1.6166666666667, 0.95, 0.33333333333333
23972, 1.6166666666667, 0.9, 0.33333333333333
23973, 1.6166666666667, 0.85, 0.33333333333333
23974, 1.6166666666667, 0.8, 0.33333333333333
23975, 1.6166666666667, 0.75, 0.33333333333333
23976, 1.6166666666667, 0.7, 0.33333333333333
23977, 1.6166666666667, 0.65, 0.33333333333333
23978, 1.6166666666667, 0.6, 0.33333333333333
23979, 1.6166666666667, 0.55, 0.33333333333333
23980, 1.6166666666667, 0.5, 0.33333333333333
23981, 1.6166666666667, 0.45, 0.33333333333333
23982, 1.6166666666667, 0.4, 0.33333333333333
23983, 1.6166666666667, 0.35, 0.33333333333333
23984, 1.6166666666667, 0.3, 0.33333333333333
23985, 1.6166666666667, 0.25, 0.33333333333333
23986, 1.6166666666667, 0.2, 0.33333333333333
23987, 1.6583333333333, 1.3, 0.33333333333333
23988, 1.6583333333333, 1.25, 0.33333333333333
23989, 1.6583333333333, 1.2, 0.33333333333333
23990, 1.6583333333333, 1.15, 0.33333333333333
23991, 1.6583333333333, 1.1, 0.33333333333333
23992, 1.6583333333333, 1.05, 0.33333333333333
23993, 1.6583333333333, 1, 0.33333333333333
23994, 1.6583333333333, 0.95, 0.33333333333333
23995, 1.6583333333333, 0.9, 0.33333333333333
23996, 1.6583333333333, 0.85, 0.33333333333333
23997, 1.6583333333333, 0.8, 0.33333333333333
23998, 1.6583333333333, 0.75, 0.33333333333333
23999, 1.6583333333333, 0.7, 0.33333333333333
24000, 1.6583333333333, 0.65, 0.33333333333333
24001, 1.6583333333333, 0.6, 0.33333333333333
24002, 1.6583333333333, 0.55, 0.33333333333333
24003, 1.6583333333333, 0.5, 0.33333333333333
24004, 1.6583333333333, 0.45, 0.33333333333333
24005, 1.6583333333333, 0.4, 0.33333333333333
24006, 1.6583333333333, 0.35, 0.33333333333333
24007, 1.6583333333333, 0.3, 0.33333333333333
24008, 1.6583333333333, 0.25, 0.33333333333333
24009, 1.6583333333333, 0.2, 0.33333333333333
24010, 1.7, 1.3, 0.33333333333333
24011, 1.7, 1.25, 0.33333333333333
24012, 1.7, 1.2, 0.33333333333333
24013, 1.7, 1.15, 0.33333333333333
24014, 1.7, 1.1, 0.33333333333333
24015, 1.7, 1.05, 0.33333333333333
24016, 1.7, 1, 0.33333333333333
24017, 1.7, 0.95, 0.33333333333333
24018, 1.7, 0.9, 0.33333333333333
24019, 1.7, 0.85, 0.33333333333333
24020, 1.7, 0.8, 0.33333333333333
24021, 1.7, 0.75, 0.33333333333333
24022, 1.7, 0.7, 0.33333333333333
24023, 1.7, 0.65, 0.33333333333333
24024, 1.7, 0.6, 0.33333333333333
24025, 1.7, 0.55, 0.33333333333333
24026, 1.7, 0.5, 0.33333333333333
24027, 1.7, 0.45, 0.33333333333333
24028, 1.7, 0.4, 0.33333333333333
24029, 1.7, 0.35, 0.33333333333333
24030, 1.7, 0.3, 0.33333333333333
24031, 1.7, 0.25, 0.33333333333333
24032, 1.7, 0.2, 0.33333333333333
24033, 1.7416666666667, 1.3, 0.33333333333333
24034, 1.7416666666667, 1.25, 0.33333333333333
24035, 1.7416666666667, 1.2, 0.33333333333333
24036, 1.7416666666667, 1.15, 0.33333333333333
24037, 1.7416666666667, 1.1, 0.33333333333333
24038, 1.7416666666667, 1.05, 0.33333333333333
24039, 1.7416666666667, 1, 0.33333333333333
24040, 1.7416666666667, 0.95, 0.33333333333333
24041, 1.7416666666667, 0.9, 0.33333333333333
24042, 1.7416666666667, 0.85, 0.33333333333333
24043, 1.7416666666667, 0.8, 0.33333333333333
24044, 1.7416666666667, 0.75, 0.33333333333333
24045, 1.7416666666667, 0.7, 0.33333333333333
24046, 1.7416666666667, 0.65, 0.33333333333333
24047, 1.7416666666667, 0.6, 0.33333333333333
24048, 1.7416666666667, 0.55, 0.33333333333333
24049, 1.7416666666667, 0.5, 0.33333333333333
24050, 1.7416666666667, 0.45, 0.33333333333333
24051, 1.7416666666667, 0.4, 0.33333333333333
24052, 1.7416666666667, 0.35, 0.33333333333333
24053, 1.7416666666667, 0.3, 0.33333333333333
24054, 1.7416666666667, 0.25, 0.33333333333333
24055, 1.7416666666667, 0.2, 0.33333333333333
24056, 1.7833333333333, 1.3, 0.33333333333333
24057, 1.7833333333333, 1.25, 0.33333333333333
24058, 1.7833333333333, 1.2, 0.33333333333333
24059, 1.7833333333333, 1.15, 0.33333333333333
24060, 1.7833333333333, 1.1, 0.33333333333333
24061, 1.7833333333333, 1.05, 0.33333333333333
24062, 1.7833333333333, 1, 0.33333333333333
24063, 1.7833333333333, 0.95, 0.33333333333333
24064, 1.7833333333333, 0.9, 0.33333333333333
24065, 1.7833333333333, 0.85, 0.33333333333333
24066, 1.7833333333333, 0.8, 0.33333333333333
24067, 1.7833333333333, 0.75, 0.33333333333333
24068, 1.7833333333333, 0.7, 0.33333333333333
24069, 1.7833333333333, 0.65, 0.33333333333333
24070, 1.7833333333333, 0.6, 0.33333333333333
24071, 1.7833333333333, 0.55, 0.33333333333333
24072, 1.7833333333333, 0.5, 0.33333333333333
24073, 1.7833333333333, 0.45, 0.33333333333333
24074, 1.7833333333333, 0.4, 0.33333333333333
24075, 1.7833333333333, 0.35, 0.33333333333333
24076, 1.7833333333333, 0.3, 0.33333333333333
24077, 1.7833333333333, 0.25, 0.33333333333333
24078, 1.7833333333333, 0.2, 0.33333333333333
24079, 1.825, 1.3, 0.33333333333333
24080, 1.825, 1.25, 0.33333333333333
24081, 1.825, 1.2, 0.33333333333333
24082, 1.825, 1.15, 0.33333333333333
24083, 1.825, 1.1, 0.33333333333333
24084, 1.825, 1.05, 0.33333333333333
24085, 1.825, 1, 0.33333333333333
24086, 1.825, 0.95, 0.33333333333333
24087, 1.825, 0.9, 0.33333333333333
24088, 1.825, 0.85, 0.33333333333333
24089, 1.825, 0.8, 0.33333333333333
24090, 1.825, 0.75, 0.33333333333333
24091, 1.825, 0.7, 0.33333333333333
24092, 1.825, 0.65, 0.33333333333333
24093, 1.825, 0.6, 0.33333333333333
24094, 1.825, 0.55, 0.33333333333333
24095, 1.825, 0.5, 0.33333333333333
24096, 1.825, 0.45, 0.33333333333333
24097, 1.825, 0.4, 0.33333333333333
24098, 1.825, 0.35, 0.33333333333333
24099, 1.825, 0.3, 0.33333333333333
24100, 1.825, 0.25, 0.33333333333333
24101, 1.825, 0.2, 0.33333333333333
24102, 1.8666666666667, 1.3, 0.33333333333333
24103, 1.8666666666667, 1.25, 0.33333333333333
24104, 1.8666666666667, 1.2, 0.33333333333333
24105, 1.8666666666667, 1.15, 0.33333333333333
24106, 1.8666666666667, 1.1, 0.33333333333333
24107, 1.8666666666667, 1.05, 0.33333333333333
24108, 1.8666666666667, 1, 0.33333333333333
24109, 1.8666666666667, 0.95, 0.33333333333333
24110, 1.8666666666667, 0.9, 0.33333333333333
24111, 1.8666666666667, 0.85, 0.33333333333333
24112, 1.8666666666667, 0.8, 0.33333333333333
24113, 1.8666666666667, 0.75, 0.33333333333333
24114, 1.8666666666667, 0.7, 0.33333333333333
24115, 1.8666666666667, 0.65, 0.33333333333333
24116, 1.8666666666667, 0.6, 0.33333333333333
24117, 1.8666666666667, 0.55, 0.33333333333333
24118, 1.8666666666667, 0.5, 0.33333333333333
24119, 1.8666666666667, 0.45, 0.33333333333333
24120, 1.8666666666667, 0.4, 0.33333333333333
24121, 1.8666666666667, 0.35, 0.33333333333333
24122, 1.8666666666667, 0.3, 0.33333333333333
24123, 1.8666666666667, 0.25, 0.33333333333333
24124, 1.8666666666667, 0.2, 0.33333333333333
24125, 1.9083333333333, 1.3, 0.33333333333333
24126, 1.9083333333333, 1.25, 0.33333333333333
24127, 1.9083333333333, 1.2, 0.33333333333333
24128, 1.9083333333333, 1.15, 0.33333333333333
24129, 1.9083333333333, 1.1, 0.33333333333333
24130, 1.9083333333333, 1.05, 0.33333333333333
24131, 1.9083333333333, 1, 0.33333333333333
24132, 1.9083333333333, 0.95, 0.33333333333333
24133, 1.9083333333333, 0.9, 0.33333333333333
24134, 1.9083333333333, 0.85, 0.33333333333333
24135, 1.9083333333333, 0.8, 0.33333333333333
24136, 1.9083333333333, 0.75, 0.33333333333333
24137, 1.9083333333333, 0.7, 0.33333333333333
24138, 1.9083333333333, 0.65, 0.33333333333333
24139, 1.9083333333333, 0.6, 0.33333333333333
24140, 1.9083333333333, 0.55, 0.33333333333333
24141, 1.9083333333333, 0.5, 0.33333333333333
24142, 1.9083333333333, 0.45, 0.33333333333333
24143, 1.9083333333333, 0.4, 0.33333333333333
24144, 1.9083333333333, 0.35, 0.33333333333333
24145, 1.9083333333333, 0.3, 0.33333333333333
24146, 1.9083333333333, 0.25, 0.33333333333333
24147, 1.9083333333333, 0.2, 0.33333333333333
24148, 1.95, 1.3, 0.33333333333333
24149, 1.95, 1.25, 0.33333333333333
24150, 1.95, 1.2, 0.33333333333333
24151, 1.95, 1.15, 0.33333333333333
24152, 1.95, 1.1, 0.33333333333333
24153, 1.95, 1.05, 0.33333333333333
24154, 1.95, 1, 0.33333333333333
24155, 1.95, 0.95, 0.33333333333333
24156, 1.95, 0.9, 0.33333333333333
24157, 1.95, 0.85, 0.33333333333333
24158, 1.95, 0.8, 0.33333333333333
24159, 1.95, 0.75, 0.33333333333333
24160, 1.95, 0.7, 0.33333333333333
24161, 1.95, 0.65, 0.33333333333333
24162, 1.95, 0.6, 0.33333333333333
24163, 1.95, 0.55, 0.33333333333333
24164, 1.95, 0.5, 0.33333333333333
24165, 1.95, 0.45, 0.33333333333333
24166, 1.95, 0.4, 0.33333333333333
24167, 1.95, 0.35, 0.33333333333333
24168, 1.95, 0.3, 0.33333333333333
24169, 1.95, 0.25, 0.33333333333333
24170, 1.95, 0.2, 0.33333333333333
24171, 1.9916666666667, 1.3, 0.33333333333333
24172, 1.9916666666667, 1.25, 0.33333333333333
24173, 1.9916666666667, 1.2, 0.33333333333333
24174, 1.9916666666667, 1.15, 0.33333333333333
24175, 1.9916666666667, 1.1, 0.33333333333333
24176, 1.9916666666667, 1.05, 0.33333333333333
24177, 1.9916666666667, 1, 0.33333333333333
24178, 1.9916666666667, 0.95, 0.33333333333333
24179, 1.9916666666667, 0.9, 0.33333333333333
24180, 1.9916666666667, 0.85, 0.33333333333333
24181, 1.9916666666667, 0.8, 0.33333333333333
24182, 1.9916666666667, 0.75, 0.33333333333333
24183, 1.9916666666667, 0.7, 0.33333333333333
24184, 1.9916666666667, 0.65, 0.33333333333333
24185, 1.9916666666667, 0.6, 0.33333333333333
24186, 1.9916666666667, 0.55, 0.33333333333333
24187, 1.9916666666667, 0.5, 0.33333333333333
24188, 1.9916666666667, 0.45, 0.33333333333333
24189, 1.9916666666667, 0.4, 0.33333333333333
24190, 1.9916666666667, 0.35, 0.33333333333333
24191, 1.9916666666667, 0.3, 0.33333333333333
24192, 1.9916666666667, 0.25, 0.33333333333333
24193, 1.9916666666667, 0.2, 0.33333333333333
24194, 2.0333333333333, 1.3, 0.33333333333333
24195, 2.0333333333333, 1.25, 0.33333333333333
24196, 2.0333333333333, 1.2, 0.33333333333333
24197, 2.0333333333333, 1.15, 0.33333333333333
24198, 2.0333333333333, 1.1, 0.33333333333333
24199, 2.0333333333333, 1.05, 0.33333333333333
24200, 2.0333333333333, 1, 0.33333333333333
24201, 2.0333333333333, 0.95, 0.33333333333333
24202, 2.0333333333333, 0.9, 0.33333333333333
24203, 2.0333333333333, 0.85, 0.33333333333333
24204, 2.0333333333333, 0.8, 0.33333333333333
24205, 2.0333333333333, 0.75, 0.33333333333333
24206, 2.0333333333333, 0.7, 0.33333333333333
24207, 2.0333333333333, 0.65, 0.33333333333333
24208, 2.0333333333333, 0.6, 0.33333333333333
24209, 2.0333333333333, 0.55, 0.33333333333333
24210, 2.0333333333333, 0.5, 0.33333333333333
24211, 2.0333333333333, 0.45, 0.33333333333333
24212, 2.0333333333333, 0.4, 0.33333333333333
24213, 2.0333333333333, 0.35, 0.33333333333333
24214, 2.0333333333333, 0.3, 0.33333333333333
24215, 2.0333333333333, 0.25, 0.33333333333333
24216, 2.0333333333333, 0.2, 0.33333333333333
24217, 2.075, 1.3, 0.33333333333333
24218, 2.075, 1.25, 0.33333333333333
24219, 2.075, 1.2, 0.33333333333333
24220, 2.075, 1.15, 0.33333333333333
24221, 2.075, 1.1, 0.33333333333333
24222, 2.075, 1.05, 0.33333333333333
24223, 2.075, 1, 0.33333333333333
24224, 2.075, 0.95, 0.33333333333333
24225, 2.075, 0.9, 0.33333333333333
24226, 2.075, 0.85, 0.33333333333333
24227, 2.075, 0.8, 0.33333333333333
24228, 2.075, 0.75, 0.33333333333333
24229, 2.075, 0.7, 0.33333333333333
24230, 2.075, 0.65, 0.33333333333333
24231, 2.075, 0.6, 0.33333333333333
24232, 2.075, 0.55, 0.33333333333333
24233, 2.075, 0.5, 0.33333333333333
24234, 2.075, 0.45, 0.33333333333333
24235, 2.075, 0.4, 0.33333333333333
24236, 2.075, 0.35, 0.33333333333333
24237, 2.075, 0.3, 0.33333333333333
24238, 2.075, 0.25, 0.33333333333333
24239, 2.075, 0.2, 0.33333333333333
24240, 2.1166666666667, 1.3, 0.33333333333333
24241, 2.1166666666667, 1.25, 0.33333333333333
24242, 2.1166666666667, 1.2, 0.33333333333333
24243, 2.1166666666667, 1.15, 0.33333333333333
24244, 2.1166666666667, 1.1, 0.33333333333333
24245, 2.1166666666667, 1.05, 0.33333333333333
24246, 2.1166666666667, 1, 0.33333333333333
24247, 2.1166666666667, 0.95, 0.33333333333333
24248, 2.1166666666667, 0.9, 0.33333333333333
24249, 2.1166666666667, 0.85, 0.33333333333333
24250, 2.1166666666667, 0.8, 0.33333333333333
24251, 2.1166666666667, 0.75, 0.33333333333333
24252, 2.1166666666667, 0.7, 0.33333333333333
24253, 2.1166666666667, 0.65, 0.33333333333333
24254, 2.1166666666667, 0.6, 0.33333333333333
24255, 2.1166666666667, 0.55, 0.33333333333333
24256, 2.1166666666667, 0.5, 0.33333333333333
24257, 2.1166666666667, 0.45, 0.33333333333333
24258, 2.1166666666667, 0.4, 0.33333333333333
24259, 2.1166666666667, 0.35, 0.33333333333333
24260, 2.1166666666667, 0.3, 0.33333333333333
24261, 2.1166666666667, 0.25, 0.33333333333333
24262, 2.1166666666667, 0.2, 0.33333333333333
24263, 2.1583333333333, 1.3, 0.33333333333333
24264, 2.1583333333333, 1.25, 0.33333333333333
24265, 2.1583333333333, 1.2, 0.33333333333333
24266, 2.1583333333333, 1.15, 0.33333333333333
24267, 2.1583333333333, 1.1, 0.33333333333333
24268, 2.1583333333333, 1.05, 0.33333333333333
24269, 2.1583333333333, 1, 0.33333333333333
24270, 2.1583333333333, 0.95, 0.33333333333333
24271, 2.1583333333333, 0.9, 0.33333333333333
24272, 2.1583333333333, 0.85, 0.33333333333333
24273, 2.1583333333333, 0.8, 0.33333333333333
24274, 2.1583333333333, 0.75, 0.33333333333333
24275, 2.1583333333333, 0.7, 0.33333333333333
24276, 2.1583333333333, 0.65, 0.33333333333333
24277, 2.1583333333333, 0.6, 0.33333333333333
24278, 2.1583333333333, 0.55, 0.33333333333333
24279, 2.1583333333333, 0.5, 0.33333333333333
24280, 2.1583333333333, 0.45, 0.33333333333333
24281, 2.1583333333333, 0.4, 0.33333333333333
24282, 2.1583333333333, 0.35, 0.33333333333333
24283, 2.1583333333333, 0.3, 0.33333333333333
24284, 2.1583333333333, 0.25, 0.33333333333333
24285, 2.1583333333333, 0.2, 0.33333333333333
24286, 1.2416666666667, 1.3, 0.375
24287, 1.2416666666667, 1.25, 0.375
24288, 1.2416666666667, 1.2, 0.375
24289, 1.2416666666667, 1.15, 0.375
24290, 1.2416666666667, 1.1, 0.375
24291, 1.2416666666667, 1.05, 0.375
24292, 1.2416666666667, 1, 0.375
24293, 1.2416666666667, 0.95, 0.375
24294, 1.2416666666667, 0.9, 0.375
24295, 1.2416666666667, 0.85, 0.375
24296, 1.2416666666667, 0.8, 0.375
24297, 1.2416666666667, 0.75, 0.375
24298, 1.2416666666667, 0.7, 0.375
24299, 1.2416666666667, 0.65, 0.375
24300, 1.2416666666667, 0.6, 0.375
24301, 1.2416666666667, 0.55, 0.375
24302, 1.2416666666667, 0.5, 0.375
24303, 1.2416666666667, 0.45, 0.375
24304, 1.2416666666667, 0.4, 0.375
24305, 1.2416666666667, 0.35, 0.375
24306, 1.2416666666667, 0.3, 0.375
24307, 1.2416666666667, 0.25, 0.375
24308, 1.2416666666667, 0.2, 0.375
24309, 1.2833333333333, 1.3, 0.375
24310, 1.2833333333333, 1.25, 0.375
24311, 1.2833333333333, 1.2, 0.375
24312, 1.2833333333333, 1.15, 0.375
24313, 1.2833333333333, 1.1, 0.375
24314, 1.2833333333333, 1.05, 0.375
24315, 1.2833333333333, 1, 0.375
24316, 1.2833333333333, 0.95, 0.375
24317, 1.2833333333333, 0.9, 0.375
24318, 1.2833333333333, 0.85, 0.375
24319, 1.2833333333333, 0.8, 0.375
24320, 1.2833333333333, 0.75, 0.375
24321, 1.2833333333333, 0.7, 0.375
24322, 1.2833333333333, 0.65, 0.375
24323, 1.2833333333333, 0.6, 0.375
24324, 1.2833333333333, 0.55, 0.375
24325, 1.2833333333333, 0.5, 0.375
24326, 1.2833333333333, 0.45, 0.375
24327, 1.2833333333333, 0.4, 0.375
24328, 1.2833333333333, 0.35, 0.375
24329, 1.2833333333333, 0.3, 0.375
24330, 1.2833333333333, 0.25, 0.375
24331, 1.2833333333333, 0.2, 0.375
24332, 1.325, 1.3, 0.375
24333, 1.325, 1.25, 0.375
24334, 1.325, 1.2, 0.375
24335, 1.325, 1.15, 0.375
24336, 1.325, 1.1, 0.375
24337, 1.325, 1.05, 0.375
24338, 1.325, 1, 0.375
24339, 1.325, 0.95, 0.375
24340, 1.325, 0.9, 0.375
24341, 1.325, 0.85, 0.375
24342, 1.325, 0.8, 0.375
24343, 1.325, 0.75, 0.375
24344, 1.325, 0.7, 0.375
24345, 1.325, 0.65, 0.375
24346, 1.325, 0.6, 0.375
24347, 1.325, 0.55, 0.375
24348, 1.325, 0.5, 0.375
24349, 1.325, 0.45, 0.375
24350, 1.325, 0.4, 0.375
24351, 1.325, 0.35, 0.375
24352, 1.325, 0.3, 0.375
24353, 1.325, 0.25, 0.375
24354, 1.325, 0.2, 0.375
24355, 1.3666666666667, 1.3, 0.375
24356, 1.3666666666667, 1.25, 0.375
24357, 1.3666666666667, 1.2, 0.375
24358, 1.3666666666667, 1.15, 0.375
24359, 1.3666666666667, 1.1, 0.375
24360, 1.3666666666667, 1.05, 0.375
24361, 1.3666666666667, 1, 0.375
24362, 1.3666666666667, 0.95, 0.375
24363, 1.3666666666667, 0.9, 0.375
24364, 1.3666666666667, 0.85, 0.375
24365, 1.3666666666667, 0.8, 0.375
24366, 1.3666666666667, 0.75, 0.375
24367, 1.3666666666667, 0.7, 0.375
24368, 1.3666666666667, 0.65, 0.375
24369, 1.3666666666667, 0.6, 0.375
24370, 1.3666666666667, 0.55, 0.375
24371, 1.3666666666667, 0.5, 0.375
24372, 1.3666666666667, 0.45, 0.375
24373, 1.3666666666667, 0.4, 0.375
24374, 1.3666666666667, 0.35, 0.375
24375, 1.3666666666667, 0.3, 0.375
24376, 1.3666666666667, 0.25, 0.375
24377, 1.3666666666667, 0.2, 0.375
24378, 1.4083333333333, 1.3, 0.375
24379, 1.4083333333333, 1.25, 0.375
24380, 1.4083333333333, 1.2, 0.375
24381, 1.4083333333333, 1.15, 0.375
24382, 1.4083333333333, 1.1, 0.375
24383, 1.4083333333333, 1.05, 0.375
24384, 1.4083333333333, 1, 0.375
24385, 1.4083333333333, 0.95, 0.375
24386, 1.4083333333333, 0.9, 0.375
24387, 1.4083333333333, 0.85, 0.375
24388, 1.4083333333333, 0.8, 0.375
24389, 1.4083333333333, 0.75, 0.375
24390, 1.4083333333333, 0.7, 0.375
24391, 1.4083333333333, 0.65, 0.375
24392, 1.4083333333333, 0.6, 0.375
24393, 1.4083333333333, 0.55, 0.375
24394, 1.4083333333333, 0.5, 0.375
24395, 1.4083333333333, 0.45, 0.375
24396, 1.4083333333333, 0.4, 0.375
24397, 1.4083333333333, 0.35, 0.375
24398, 1.4083333333333, 0.3, 0.375
24399, 1.4083333333333, 0.25, 0.375
24400, 1.4083333333333, 0.2, 0.375
24401, 1.45, 1.3, 0.375
24402, 1.45, 1.25, 0.375
24403, 1.45, 1.2, 0.375
24404, 1.45, 1.15, 0.375
24405, 1.45, 1.1, 0.375
24406, 1.45, 1.05, 0.375
24407, 1.45, 1, 0.375
24408, 1.45, 0.95, 0.375
24409, 1.45, 0.9, 0.375
24410, 1.45, 0.85, 0.375
24411, 1.45, 0.8, 0.375
24412, 1.45, 0.75, 0.375
24413, 1.45, 0.7, 0.375
24414, 1.45, 0.65, 0.375
24415, 1.45, 0.6, 0.375
24416, 1.45, 0.55, 0.375
24417, 1.45, 0.5, 0.375
24418, 1.45, 0.45, 0.375
24419, 1.45, 0.4, 0.375
24420, 1.45, 0.35, 0.375
24421, 1.45, 0.3, 0.375
24422, 1.45, 0.25, 0.375
24423, 1.45, 0.2, 0.375
24424, 1.4916666666667, 1.3, 0.375
24425, 1.4916666666667, 1.25, 0.375
24426, 1.4916666666667, 1.2, 0.375
24427, 1.4916666666667, 1.15, 0.375
24428, 1.4916666666667, 1.1, 0.375
24429, 1.4916666666667, 1.05, 0.375
24430, 1.4916666666667, 1, 0.375
24431, 1.4916666666667, 0.95, 0.375
24432, 1.4916666666667, 0.9, 0.375
24433, 1.4916666666667, 0.85, 0.375
24434, 1.4916666666667, 0.8, 0.375
24435, 1.4916666666667, 0.75, 0.375
24436, 1.4916666666667, 0.7, 0.375
24437, 1.4916666666667, 0.65, 0.375
24438, 1.4916666666667, 0.6, 0.375
24439, 1.4916666666667, 0.55, 0.375
24440, 1.4916666666667, 0.5, 0.375
24441, 1.4916666666667, 0.45, 0.375
24442, 1.4916666666667, 0.4, 0.375
24443, 1.4916666666667, 0.35, 0.375
24444, 1.4916666666667, 0.3, 0.375
24445, 1.4916666666667, 0.25, 0.375
24446, 1.4916666666667, 0.2, 0.375
24447, 1.5333333333333, 1.3, 0.375
24448, 1.5333333333333, 1.25, 0.375
24449, 1.5333333333333, 1.2, 0.375
24450, 1.5333333333333, 1.15, 0.375
24451, 1.5333333333333, 1.1, 0.375
24452, 1.5333333333333, 1.05, 0.375
24453, 1.5333333333333, 1, 0.375
24454, 1.5333333333333, 0.95, 0.375
24455, 1.5333333333333, 0.9, 0.375
24456, 1.5333333333333, 0.85, 0.375
24457, 1.5333333333333, 0.8, 0.375
24458, 1.5333333333333, 0.75, 0.375
24459, 1.5333333333333, 0.7, 0.375
24460, 1.5333333333333, 0.65, 0.375
24461, 1.5333333333333, 0.6, 0.375
24462, 1.5333333333333, 0.55, 0.375
24463, 1.5333333333333, 0.5, 0.375
24464, 1.5333333333333, 0.45, 0.375
24465, 1.5333333333333, 0.4, 0.375
24466, 1.5333333333333, 0.35, 0.375
24467, 1.5333333333333, 0.3, 0.375
24468, 1.5333333333333, 0.25, 0.375
24469, 1.5333333333333, 0.2, 0.375
24470, 1.575, 1.3, 0.375
24471, 1.575, 1.25, 0.375
24472, 1.575, 1.2, 0.375
24473, 1.575, 1.15, 0.375
24474, 1.575, 1.1, 0.375
24475, 1.575, 1.05, 0.375
24476, 1.575, 1, 0.375
24477, 1.575, 0.95, 0.375
24478, 1.575, 0.9, 0.375
24479, 1.575, 0.85, 0.375
24480, 1.575, 0.8, 0.375
24481, 1.575, 0.75, 0.375
24482, 1.575, 0.7, 0.375
24483, 1.575, 0.65, 0.375
24484, 1.575, 0.6, 0.375
24485, 1.575, 0.55, 0.375
24486, 1.575, 0.5, 0.375
24487, 1.575, 0.45, 0.375
24488, 1.575, 0.4, 0.375
24489, 1.575, 0.35, 0.375
24490, 1.575, 0.3, 0.375
24491, 1.575, 0.25, 0.375
24492, 1.575, 0.2, 0.375
24493, 1.6166666666667, 1.3, 0.375
24494, 1.6166666666667, 1.25, 0.375
24495, 1.6166666666667, 1.2, 0.375
24496, 1.6166666666667, 1.15, 0.375
24497, 1.6166666666667, 1.1, 0.375
24498, 1.6166666666667, 1.05, 0.375
24499, 1.6166666666667, 1, 0.375
24500, 1.6166666666667, 0.95, 0.375
24501, 1.6166666666667, 0.9, 0.375
24502, 1.6166666666667, 0.85, 0.375
24503, 1.6166666666667, 0.8, 0.375
24504, 1.6166666666667, 0.75, 0.375
24505, 1.6166666666667, 0.7, 0.375
24506, 1.6166666666667, 0.65, 0.375
24507, 1.6166666666667, 0.6, 0.375
24508, 1.6166666666667, 0.55, 0.375
24509, 1.6166666666667, 0.5, 0.375
24510, 1.6166666666667, 0.45, 0.375
24511, 1.6166666666667, 0.4, 0.375
24512, 1.6166666666667, 0.35, 0.375
24513, 1.6166666666667, 0.3, 0.375
24514, 1.6166666666667, 0.25, 0.375
24515, 1.6166666666667, 0.2, 0.375
24516, 1.6583333333333, 1.3, 0.375
24517, 1.6583333333333, 1.25, 0.375
24518, 1.6583333333333, 1.2, 0.375
24519, 1.6583333333333, 1.15, 0.375
24520, 1.6583333333333, 1.1, 0.375
24521, 1.6583333333333, 1.05, 0.375
24522, 1.6583333333333, 1, 0.375
24523, 1.6583333333333, 0.95, 0.375
24524, 1.6583333333333, 0.9, 0.375
24525, 1.6583333333333, 0.85, 0.375
24526, 1.6583333333333, 0.8, 0.375
24527, 1.6583333333333, 0.75, 0.375
24528, 1.6583333333333, 0.7, 0.375
24529, 1.6583333333333, 0.65, 0.375
24530, 1.6583333333333, 0.6, 0.375
24531, 1.6583333333333, 0.55, 0.375
24532, 1.6583333333333, 0.5, 0.375
24533, 1.6583333333333, 0.45, 0.375
24534, 1.6583333333333, 0.4, 0.375
24535, 1.6583333333333, 0.35, 0.375
24536, 1.6583333333333, 0.3, 0.375
24537, 1.6583333333333, 0.25, 0.375
24538, 1.6583333333333, 0.2, 0.375
24539, 1.7, 1.3, 0.375
24540, 1.7, 1.25, 0.375
24541, 1.7, 1.2, 0.375
24542, 1.7, 1.15, 0.375
24543, 1.7, 1.1, 0.375
24544, 1.7, 1.05, 0.375
24545, 1.7, 1, 0.375
24546, 1.7, 0.95, 0.375
24547, 1.7, 0.9, 0.375
24548, 1.7, 0.85, 0.375
24549, 1.7, 0.8, 0.375
24550, 1.7, 0.75, 0.375
24551, 1.7, 0.7, 0.375
24552, 1.7, 0.65, 0.375
24553, 1.7, 0.6, 0.375
24554, 1.7, 0.55, 0.375
24555, 1.7, 0.5, 0.375
24556, 1.7, 0.45, 0.375
24557, 1.7, 0.4, 0.375
24558, 1.7, 0.35, 0.375
24559, 1.7, 0.3, 0.375
24560, 1.7, 0.25, 0.375
24561, 1.7, 0.2, 0.375
24562, 1.7416666666667, 1.3, 0.375
24563, 1.7416666666667, 1.25, 0.375
24564, 1.7416666666667, 1.2, 0.375
24565, 1.7416666666667, 1.15, 0.375
24566, 1.7416666666667, 1.1, 0.375
24567, 1.7416666666667, 1.05, 0.375
24568, 1.7416666666667, 1, 0.375
24569, 1.7416666666667, 0.95, 0.375
24570, 1.7416666666667, 0.9, 0.375
24571, 1.7416666666667, 0.85, 0.375
24572, 1.7416666666667, 0.8, 0.375
24573, 1.7416666666667, 0.75, 0.375
24574, 1.7416666666667, 0.7, 0.375
24575, 1.7416666666667, 0.65, 0.375
24576, 1.7416666666667, 0.6, 0.375
24577, 1.7416666666667, 0.55, 0.375
24578, 1.7416666666667, 0.5, 0.375
24579, 1.7416666666667, 0.45, 0.375
24580, 1.7416666666667, 0.4, 0.375
24581, 1.7416666666667, 0.35, 0.375
24582, 1.7416666666667, 0.3, 0.375
24583, 1.7416666666667, 0.25, 0.375
24584, 1.7416666666667, 0.2, 0.375
24585, 1.7833333333333, 1.3, 0.375
24586, 1.7833333333333, 1.25, 0.375
24587, 1.7833333333333, 1.2, 0.375
24588, 1.7833333333333, 1.15, 0.375
24589, 1.7833333333333, 1.1, 0.375
24590, 1.7833333333333, 1.05, 0.375
24591, 1.7833333333333, 1, 0.375
24592, 1.7833333333333, 0.95, 0.375
24593, 1.7833333333333, 0.9, 0.375
24594, 1.7833333333333, 0.85, 0.375
24595, 1.7833333333333, 0.8, 0.375
24596, 1.7833333333333, 0.75, 0.375
24597, 1.7833333333333, 0.7, 0.375
24598, 1.7833333333333, 0.65, 0.375
24599, 1.7833333333333, 0.6, 0.375
24600, 1.7833333333333, 0.55, 0.375
24601, 1.7833333333333, 0.5, 0.375
24602, 1.7833333333333, 0.45, 0.375
24603, 1.7833333333333, 0.4, 0.375
24604, 1.7833333333333, 0.35, 0.375
24605, 1.7833333333333, 0.3, 0.375
24606, 1.7833333333333, 0.25, 0.375
24607, 1.7833333333333, 0.2, 0.375
24608, 1.825, 1.3, 0.375
24609, 1.825, 1.25, 0.375
24610, 1.825, 1.2, 0.375
24611, 1.825, 1.15, 0.375
24612, 1.825, 1.1, 0.375
24613, 1.825, 1.05, 0.375
24614, 1.825, 1, 0.375
24615, 1.825, 0.95, 0.375
24616, 1.825, 0.9, 0.375
24617, 1.825, 0.85, 0.375
24618, 1.825, 0.8, 0.375
24619, 1.825, 0.75, 0.375
24620, 1.825, 0.7, 0.375
24621, 1.825, 0.65, 0.375
24622, 1.825, 0.6, 0.375
24623, 1.825, 0.55, 0.375
24624, 1.825, 0.5, 0.375
24625, 1.825, 0.45, 0.375
24626, 1.825, 0.4, 0.375
24627, 1.825, 0.35, 0.375
24628, 1.825, 0.3, 0.375
24629, 1.825, 0.25, 0.375
24630, 1.825, 0.2, 0.375
24631, 1.8666666666667, 1.3, 0.375
24632, 1.8666666666667, 1.25, 0.375
24633, 1.8666666666667, 1.2, 0.375
24634, 1.8666666666667, 1.15, 0.375
24635, 1.8666666666667, 1.1, 0.375
24636, 1.8666666666667, 1.05, 0.375
24637, 1.8666666666667, 1, 0.375
24638, 1.8666666666667, 0.95, 0.375
24639, 1.8666666666667, 0.9, 0.375
24640, 1.8666666666667, 0.85, 0.375
24641, 1.8666666666667, 0.8, 0.375
24642, 1.8666666666667, 0.75, 0.375
24643, 1.8666666666667, 0.7, 0.375
24644, 1.8666666666667, 0.65, 0.375
24645, 1.8666666666667, 0.6, 0.375
24646, 1.8666666666667, 0.55, 0.375
24647, 1.8666666666667, 0.5, 0.375
24648, 1.8666666666667, 0.45, 0.375
24649, 1.8666666666667, 0.4, 0.375
24650, 1.8666666666667, 0.35, 0.375
24651, 1.8666666666667, 0.3, 0.375
24652, 1.8666666666667, 0.25, 0.375
24653, 1.8666666666667, 0.2, 0.375
24654, 1.9083333333333, 1.3, 0.375
24655, 1.9083333333333, 1.25, 0.375
24656, 1.9083333333333, 1.2, 0.375
24657, 1.9083333333333, 1.15, 0.375
24658, 1.9083333333333, 1.1, 0.375
24659, 1.9083333333333, 1.05, 0.375
24660, 1.9083333333333, 1, 0.375
24661, 1.9083333333333, 0.95, 0.375
24662, 1.9083333333333, 0.9, 0.375
24663, 1.9083333333333, 0.85, 0.375
24664, 1.9083333333333, 0.8, 0.375
24665, 1.9083333333333, 0.75, 0.375
24666, 1.9083333333333, 0.7, 0.375
24667, 1.9083333333333, 0.65, 0.375
24668, 1.9083333333333, 0.6, 0.375
24669, 1.9083333333333, 0.55, 0.375
24670, 1.9083333333333, 0.5, 0.375
24671, 1.9083333333333, 0.45, 0.375
24672, 1.9083333333333, 0.4, 0.375
24673, 1.9083333333333, 0.35, 0.375
24674, 1.9083333333333, 0.3, 0.375
24675, 1.9083333333333, 0.25, 0.375
24676, 1.9083333333333, 0.2, 0.375
24677, 1.95, 1.3, 0.375
24678, 1.95, 1.25, 0.375
24679, 1.95, 1.2, 0.375
24680, 1.95, 1.15, 0.375
24681, 1.95, 1.1, 0.375
24682, 1.95, 1.05, 0.375
24683, 1.95, 1, 0.375
24684, 1.95, 0.95, 0.375
24685, 1.95, 0.9, 0.375
24686, 1.95, 0.85, 0.375
24687, 1.95, 0.8, 0.375
24688, 1.95, 0.75, 0.375
24689, 1.95, 0.7, 0.375
24690, 1.95, 0.65, 0.375
24691, 1.95, 0.6, 0.375
24692, 1.95, 0.55, 0.375
24693, 1.95, 0.5, 0.375
24694, 1.95, 0.45, 0.375
24695, 1.95, 0.4, 0.375
24696, 1.95, 0.35, 0.375
24697, 1.95, 0.3, 0.375
24698, 1.95, 0.25, 0.375
24699, 1.95, 0.2, 0.375
24700, 1.9916666666667, 1.3, 0.375
24701, 1.9916666666667, 1.25, 0.375
24702, 1.9916666666667, 1.2, 0.375
24703, 1.9916666666667, 1.15, 0.375
24704, 1.9916666666667, 1.1, 0.375
24705, 1.9916666666667, 1.05, 0.375
24706, 1.9916666666667, 1, 0.375
24707, 1.9916666666667, 0.95, 0.375
24708, 1.9916666666667, 0.9, 0.375
24709, 1.9916666666667, 0.85, 0.375
24710, 1.9916666666667, 0.8, 0.375
24711, 1.9916666666667, 0.75, 0.375
24712, 1.9916666666667, 0.7, 0.375
24713, 1.9916666666667, 0.65, 0.375
24714, 1.9916666666667, 0.6, 0.375
24715, 1.9916666666667, 0.55, 0.375
24716, 1.9916666666667, 0.5, 0.375
24717, 1.9916666666667, 0.45, 0.375
24718, 1.9916666666667, 0.4, 0.375
24719, 1.9916666666667, 0.35, 0.375
24720, 1.9916666666667, 0.3, 0.375
24721, 1.9916666666667, 0.25, 0.375
24722, 1.9916666666667, 0.2, 0.375
24723, 2.0333333333333, 1.3, 0.375
24724, 2.0333333333333, 1.25, 0.375
24725, 2.0333333333333, 1.2, 0.375
24726, 2.0333333333333, 1.15, 0.375
24727, 2.0333333333333, 1.1, 0.375
24728, 2.0333333333333, 1.05, 0.375
24729, 2.0333333333333, 1, 0.375
24730, 2.0333333333333, 0.95, 0.375
24731, 2.0333333333333, 0.9, 0.375
24732, 2.0333333333333, 0.85, 0.375
24733, 2.0333333333333, 0.8, 0.375
24734, 2.0333333333333, 0.75, 0.375
24735, 2.0333333333333, 0.7, 0.375
24736, 2.0333333333333, 0.65, 0.375
24737, 2.0333333333333, 0.6, 0.375
24738, 2.0333333333333, 0.55, 0.375
24739, 2.0333333333333, 0.5, 0.375
24740, 2.0333333333333, 0.45, 0.375
24741, 2.0333333333333, 0.4, 0.375
24742, 2.0333333333333, 0.35, 0.375
24743, 2.0333333333333, 0.3, 0.375
24744, 2.0333333333333, 0.25, 0.375
24745, 2.0333333333333, 0.2, 0.375
24746, 2.075, 1.3, 0.375
24747, 2.075, 1.25, 0.375
24748, 2.075, 1.2, 0.375
24749, 2.075, 1.15, 0.375
24750, 2.075, 1.1, 0.375
24751, 2.075, 1.05, 0.375
24752, 2.075, 1, 0.375
24753, 2.075, 0.95, 0.375
24754, 2.075, 0.9, 0.375
24755, 2.075, 0.85, 0.375
24756, 2.075, 0.8, 0.375
24757, 2.075, 0.75, 0.375
24758, 2.075, 0.7, 0.375
24759, 2.075, 0.65, 0.375
24760, 2.075, 0.6, 0.375
24761, 2.075, 0.55, 0.375
24762, 2.075, 0.5, 0.375
24763, 2.075, 0.45, 0.375
24764, 2.075, 0.4, 0.375
24765, 2.075, 0.35, 0.375
24766, 2.075, 0.3, 0.375
24767, 2.075, 0.25, 0.375
24768, 2.075, 0.2, 0.375
24769, 2.1166666666667, 1.3, 0.375
24770, 2.1166666666667, 1.25, 0.375
24771, 2.1166666666667, 1.2, 0.375
24772, 2.1166666666667, 1.15, 0.375
24773, 2.1166666666667, 1.1, 0.375
24774, 2.1166666666667, 1.05, 0.375
24775, 2.1166666666667, 1, 0.375
24776, 2.1166666666667, 0.95, 0.375
24777, 2.1166666666667, 0.9, 0.375
24778, 2.1166666666667, 0.85, 0.375
24779, 2.1166666666667, 0.8, 0.375
24780, 2.1166666666667, 0.75, 0.375
24781, 2.1166666666667, 0.7, 0.375
24782, 2.1166666666667, 0.65, 0.375
24783, 2.1166666666667, 0.6, 0.375
24784, 2.1166666666667, 0.55, 0.375
24785, 2.1166666666667, 0.5, 0.375
24786, 2.1166666666667, 0.45, 0.375
24787, 2.1166666666667, 0.4, 0.375
24788, 2.1166666666667, 0.35, 0.375
24789, 2.1166666666667, 0.3, 0.375
24790, 2.1166666666667, 0.25, 0.375
24791, 2.1166666666667, 0.2, 0.375
24792, 2.1583333333333, 1.3, 0.375
24793, 2.1583333333333, 1.25, 0.375
24794, 2.1583333333333, 1.2, 0.375
24795, 2.1583333333333, 1.15, 0.375
24796, 2.1583333333333, 1.1, 0.375
24797, 2.1583333333333, 1.05, 0.375
24798, 2.1583333333333, 1, 0.375
24799, 2.1583333333333, 0.95, 0.375
24800, 2.1583333333333, 0.9, 0.375
24801, 2.1583333333333, 0.85, 0.375
24802, 2.1583333333333, 0.8, 0.375
24803, 2.1583333333333, 0.75, 0.375
24804, 2.1583333333333, 0.7, 0.375
24805, 2.1583333333333, 0.65, 0.375
24806, 2.1583333333333, 0.6, 0.375
24807, 2.1583333333333, 0.55, 0.375
24808, 2.1583333333333, 0.5, 0.375
24809, 2.1583333333333, 0.45, 0.375
24810, 2.1583333333333, 0.4, 0.375
24811, 2.1583333333333, 0.35, 0.375
24812, 2.1583333333333, 0.3, 0.375
24813, 2.1583333333333, 0.25, 0.375
24814, 2.1583333333333, 0.2, 0.375
24815, 1.2416666666667, 1.3, 0.41666666666667
24816, 1.2416666666667, 1.25, 0.41666666666667
24817, 1.2416666666667, 1.2, 0.41666666666667
24818, 1.2416666666667, 1.15, 0.41666666666667
24819, 1.2416666666667, 1.1, 0.41666666666667
24820, 1.2416666666667, 1.05, 0.41666666666667
24821, 1.2416666666667, 1, 0.41666666666667
24822, 1.2416666666667, 0.95, 0.41666666666667
24823, 1.2416666666667, 0.9, 0.41666666666667
24824, 1.2416666666667, 0.85, 0.41666666666667
24825, 1.2416666666667, 0.8, 0.41666666666667
24826, 1.2416666666667, 0.75, 0.41666666666667
24827, 1.2416666666667, 0.7, 0.41666666666667
24828, 1.2416666666667, 0.65, 0.41666666666667
24829, 1.2416666666667, 0.6, 0.41666666666667
24830, 1.2416666666667, 0.55, 0.41666666666667
24831, 1.2416666666667, 0.5, 0.41666666666667
24832, 1.2416666666667, 0.45, 0.41666666666667
24833, 1.2416666666667, 0.4, 0.41666666666667
24834, 1.2416666666667, 0.35, 0.41666666666667
24835, 1.2416666666667, 0.3, 0.41666666666667
24836, 1.2416666666667, 0.25, 0.41666666666667
24837, 1.2416666666667, 0.2, 0.41666666666667
24838, 1.2833333333333, 1.3, 0.41666666666667
24839, 1.2833333333333, 1.25, 0.41666666666667
24840, 1.2833333333333, 1.2, 0.41666666666667
24841, 1.2833333333333, 1.15, 0.41666666666667
24842, 1.2833333333333, 1.1, 0.41666666666667
24843, 1.2833333333333, 1.05, 0.41666666666667
24844, 1.2833333333333, 1, 0.41666666666667
24845, 1.2833333333333, 0.95, 0.41666666666667
24846, 1.2833333333333, 0.9, 0.41666666666667
24847, 1.2833333333333, 0.85, 0.41666666666667
24848, 1.2833333333333, 0.8, 0.41666666666667
24849, 1.2833333333333, 0.75, 0.41666666666667
24850, 1.2833333333333, 0.7, 0.41666666666667
24851, 1.2833333333333, 0.65, 0.41666666666667
24852, 1.2833333333333, 0.6, 0.41666666666667
24853, 1.2833333333333, 0.55, 0.41666666666667
24854, 1.2833333333333, 0.5, 0.41666666666667
24855, 1.2833333333333, 0.45, 0.41666666666667
24856, 1.2833333333333, 0.4, 0.41666666666667
24857, 1.2833333333333, 0.35, 0.41666666666667
24858, 1.2833333333333, 0.3, 0.41666666666667
24859, 1.2833333333333, 0.25, 0.41666666666667
24860, 1.2833333333333, 0.2, 0.41666666666667
24861, 1.325, 1.3, 0.41666666666667
24862, 1.325, 1.25, 0.41666666666667
24863, 1.325, 1.2, 0.41666666666667
24864, 1.325, 1.15, 0.41666666666667
24865, 1.325, 1.1, 0.41666666666667
24866, 1.325, 1.05, 0.41666666666667
24867, 1.325, 1, 0.41666666666667
24868, 1.325, 0.95, 0.41666666666667
24869, 1.325, 0.9, 0.41666666666667
24870, 1.325, 0.85, 0.41666666666667
24871, 1.325, 0.8, 0.41666666666667
24872, 1.325, 0.75, 0.41666666666667
24873, 1.325, 0.7, 0.41666666666667
24874, 1.325, 0.65, 0.41666666666667
24875, 1.325, 0.6, 0.41666666666667
24876, 1.325, 0.55, 0.41666666666667
24877, 1.325, 0.5, 0.41666666666667
24878, 1.325, 0.45, 0.41666666666667
24879, 1.325, 0.4, 0.41666666666667
24880, 1.325, 0.35, 0.41666666666667
24881, 1.325, 0.3, 0.41666666666667
24882, 1.325, 0.25, 0.41666666666667
24883, 1.325, 0.2, 0.41666666666667
24884, 1.3666666666667, 1.3, 0.41666666666667
24885, 1.3666666666667, 1.25, 0.41666666666667
24886, 1.3666666666667, 1.2, 0.41666666666667
24887, 1.3666666666667, 1.15, 0.41666666666667
24888, 1.3666666666667, 1.1, 0.41666666666667
24889, 1.3666666666667, 1.05, 0.41666666666667
24890, 1.3666666666667, 1, 0.41666666666667
24891, 1.3666666666667, 0.95, 0.41666666666667
24892, 1.3666666666667, 0.9, 0.41666666666667
24893, 1.3666666666667, 0.85, 0.41666666666667
24894, 1.3666666666667, 0.8, 0.41666666666667
24895, 1.3666666666667, 0.75, 0.41666666666667
24896, 1.3666666666667, 0.7, 0.41666666666667
24897, 1.3666666666667, 0.65, 0.41666666666667
24898, 1.3666666666667, 0.6, 0.41666666666667
24899, 1.3666666666667, 0.55, 0.41666666666667
24900, 1.3666666666667, 0.5, 0.41666666666667
24901, 1.3666666666667, 0.45, 0.41666666666667
24902, 1.3666666666667, 0.4, 0.41666666666667
24903, 1.3666666666667, 0.35, 0.41666666666667
24904, 1.3666666666667, 0.3, 0.41666666666667
24905, 1.3666666666667, 0.25, 0.41666666666667
24906, 1.3666666666667, 0.2, 0.41666666666667
24907, 1.4083333333333, 1.3, 0.41666666666667
24908, 1.4083333333333, 1.25, 0.41666666666667
24909, 1.4083333333333, 1.2, 0.41666666666667
24910, 1.4083333333333, 1.15, 0.41666666666667
24911, 1.4083333333333, 1.1, 0.41666666666667
24912, 1.4083333333333, 1.05, 0.41666666666667
24913, 1.4083333333333, 1, 0.41666666666667
24914, 1.4083333333333, 0.95, 0.41666666666667
24915, 1.4083333333333, 0.9, 0.41666666666667
24916, 1.4083333333333, 0.85, 0.41666666666667
24917, 1.4083333333333, 0.8, 0.41666666666667
24918, 1.4083333333333, 0.75, 0.41666666666667
24919, 1.4083333333333, 0.7, 0.41666666666667
24920, 1.4083333333333, 0.65, 0.41666666666667
24921, 1.4083333333333, 0.6, 0.41666666666667
24922, 1.4083333333333, 0.55, 0.41666666666667
24923, 1.4083333333333, 0.5, 0.41666666666667
24924, 1.4083333333333, 0.45, 0.41666666666667
24925, 1.4083333333333, 0.4, 0.41666666666667
24926, 1.4083333333333, 0.35, 0.41666666666667
24927, 1.4083333333333, 0.3, 0.41666666666667
24928, 1.4083333333333, 0.25, 0.41666666666667
24929, 1.4083333333333, 0.2, 0.41666666666667
24930, 1.45, 1.3, 0.41666666666667
24931, 1.45, 1.25, 0.41666666666667
24932, 1.45, 1.2, 0.41666666666667
24933, 1.45, 1.15, 0.41666666666667
24934, 1.45, 1.1, 0.41666666666667
24935, 1.45, 1.05, 0.41666666666667
24936, 1.45, 1, 0.41666666666667
24937, 1.45, 0.95, 0.41666666666667
24938, 1.45, 0.9, 0.41666666666667
24939, 1.45, 0.85, 0.41666666666667
24940, 1.45, 0.8, 0.41666666666667
24941, 1.45, 0.75, 0.41666666666667
24942, 1.45, 0.7, 0.41666666666667
24943, 1.45, 0.65, 0.41666666666667
24944, 1.45, 0.6, 0.41666666666667
24945, 1.45, 0.55, 0.41666666666667
24946, 1.45, 0.5, 0.41666666666667
24947, 1.45, 0.45, 0.41666666666667
24948, 1.45, 0.4, 0.41666666666667
24949, 1.45, 0.35, 0.41666666666667
24950, 1.45, 0.3, 0.41666666666667
24951, 1.45, 0.25, 0.41666666666667
24952, 1.45, 0.2, 0.41666666666667
24953, 1.4916666666667, 1.3, 0.41666666666667
24954, 1.4916666666667, 1.25, 0.41666666666667
24955, 1.4916666666667, 1.2, 0.41666666666667
24956, 1.4916666666667, 1.15, 0.41666666666667
24957, 1.4916666666667, 1.1, 0.41666666666667
24958, 1.4916666666667, 1.05, 0.41666666666667
24959, 1.4916666666667, 1, 0.41666666666667
24960, 1.4916666666667, 0.95, 0.41666666666667
24961, 1.4916666666667, 0.9, 0.41666666666667
24962, 1.4916666666667, 0.85, 0.41666666666667
24963, 1.4916666666667, 0.8, 0.41666666666667
24964, 1.4916666666667, 0.75, 0.41666666666667
24965, 1.4916666666667, 0.7, 0.41666666666667
24966, 1.4916666666667, 0.65, 0.41666666666667
24967, 1.4916666666667, 0.6, 0.41666666666667
24968, 1.4916666666667, 0.55, 0.41666666666667
24969, 1.4916666666667, 0.5, 0.41666666666667
24970, 1.4916666666667, 0.45, 0.41666666666667
24971, 1.4916666666667, 0.4, 0.41666666666667
24972, 1.4916666666667, 0.35, 0.41666666666667
24973, 1.4916666666667, 0.3, 0.41666666666667
24974, 1.4916666666667, 0.25, 0.41666666666667
24975, 1.4916666666667, 0.2, 0.41666666666667
24976, 1.5333333333333, 1.3, 0.41666666666667
24977, 1.5333333333333, 1.25, 0.41666666666667
24978, 1.5333333333333, 1.2, 0.41666666666667
24979, 1.5333333333333, 1.15, 0.41666666666667
24980, 1.5333333333333, 1.1, 0.41666666666667
24981, 1.5333333333333, 1.05, 0.41666666666667
24982, 1.5333333333333, 1, 0.41666666666667
24983, 1.5333333333333, 0.95, 0.41666666666667
24984, 1.5333333333333, 0.9, 0.41666666666667
24985, 1.5333333333333, 0.85, 0.41666666666667
24986, 1.5333333333333, 0.8, 0.41666666666667
24987, 1.5333333333333, 0.75, 0.41666666666667
24988, 1.5333333333333, 0.7, 0.41666666666667
24989, 1.5333333333333, 0.65, 0.41666666666667
24990, 1.5333333333333, 0.6, 0.41666666666667
24991, 1.5333333333333, 0.55, 0.41666666666667
24992, 1.5333333333333, 0.5, 0.41666666666667
24993, 1.5333333333333, 0.45, 0.41666666666667
24994, 1.5333333333333, 0.4, 0.41666666666667
24995, 1.5333333333333, 0.35, 0.41666666666667
24996, 1.5333333333333, 0.3, 0.41666666666667
24997, 1.5333333333333, 0.25, 0.41666666666667
24998, 1.5333333333333, 0.2, 0.41666666666667
24999, 1.575, 1.3, 0.41666666666667
25000, 1.575, 1.25, 0.41666666666667
25001, 1.575, 1.2, 0.41666666666667
25002, 1.575, 1.15, 0.41666666666667
25003, 1.575, 1.1, 0.41666666666667
25004, 1.575, 1.05, 0.41666666666667
25005, 1.575, 1, 0.41666666666667
25006, 1.575, 0.95, 0.41666666666667
25007, 1.575, 0.9, 0.41666666666667
25008, 1.575, 0.85, 0.41666666666667
25009, 1.575, 0.8, 0.41666666666667
25010, 1.575, 0.75, 0.41666666666667
25011, 1.575, 0.7, 0.41666666666667
25012, 1.575, 0.65, 0.41666666666667
25013, 1.575, 0.6, 0.41666666666667
25014, 1.575, 0.55, 0.41666666666667
25015, 1.575, 0.5, 0.41666666666667
25016, 1.575, 0.45, 0.41666666666667
25017, 1.575, 0.4, 0.41666666666667
25018, 1.575, 0.35, 0.41666666666667
25019, 1.575, 0.3, 0.41666666666667
25020, 1.575, 0.25, 0.41666666666667
25021, 1.575, 0.2, 0.41666666666667
25022, 1.6166666666667, 1.3, 0.41666666666667
25023, 1.6166666666667, 1.25, 0.41666666666667
25024, 1.6166666666667, 1.2, 0.41666666666667
25025, 1.6166666666667, 1.15, 0.41666666666667
25026, 1.6166666666667, 1.1, 0.41666666666667
25027, 1.6166666666667, 1.05, 0.41666666666667
25028, 1.6166666666667, 1, 0.41666666666667
25029, 1.6166666666667, 0.95, 0.41666666666667
25030, 1.6166666666667, 0.9, 0.41666666666667
25031, 1.6166666666667, 0.85, 0.41666666666667
25032, 1.6166666666667, 0.8, 0.41666666666667
25033, 1.6166666666667, 0.75, 0.41666666666667
25034, 1.6166666666667, 0.7, 0.41666666666667
25035, 1.6166666666667, 0.65, 0.41666666666667
25036, 1.6166666666667, 0.6, 0.41666666666667
25037, 1.6166666666667, 0.55, 0.41666666666667
25038, 1.6166666666667, 0.5, 0.41666666666667
25039, 1.6166666666667, 0.45, 0.41666666666667
25040, 1.6166666666667, 0.4, 0.41666666666667
25041, 1.6166666666667, 0.35, 0.41666666666667
25042, 1.6166666666667, 0.3, 0.41666666666667
25043, 1.6166666666667, 0.25, 0.41666666666667
25044, 1.6166666666667, 0.2, 0.41666666666667
25045, 1.6583333333333, 1.3, 0.41666666666667
25046, 1.6583333333333, 1.25, 0.41666666666667
25047, 1.6583333333333, 1.2, 0.41666666666667
25048, 1.6583333333333, 1.15, 0.41666666666667
25049, 1.6583333333333, 1.1, 0.41666666666667
25050, 1.6583333333333, 1.05, 0.41666666666667
25051, 1.6583333333333, 1, 0.41666666666667
25052, 1.6583333333333, 0.95, 0.41666666666667
25053, 1.6583333333333, 0.9, 0.41666666666667
25054, 1.6583333333333, 0.85, 0.41666666666667
25055, 1.6583333333333, 0.8, 0.41666666666667
25056, 1.6583333333333, 0.75, 0.41666666666667
25057, 1.6583333333333, 0.7, 0.41666666666667
25058, 1.6583333333333, 0.65, 0.41666666666667
25059, 1.6583333333333, 0.6, 0.41666666666667
25060, 1.6583333333333, 0.55, 0.41666666666667
25061, 1.6583333333333, 0.5, 0.41666666666667
25062, 1.6583333333333, 0.45, 0.41666666666667
25063, 1.6583333333333, 0.4, 0.41666666666667
25064, 1.6583333333333, 0.35, 0.41666666666667
25065, 1.6583333333333, 0.3, 0.41666666666667
25066, 1.6583333333333, 0.25, 0.41666666666667
25067, 1.6583333333333, 0.2, 0.41666666666667
25068, 1.7, 1.3, 0.41666666666667
25069, 1.7, 1.25, 0.41666666666667
25070, 1.7, 1.2, 0.41666666666667
25071, 1.7, 1.15, 0.41666666666667
25072, 1.7, 1.1, 0.41666666666667
25073, 1.7, 1.05, 0.41666666666667
25074, 1.7, 1, 0.41666666666667
25075, 1.7, 0.95, 0.41666666666667
25076, 1.7, 0.9, 0.41666666666667
25077, 1.7, 0.85, 0.41666666666667
25078, 1.7, 0.8, 0.41666666666667
25079, 1.7, 0.75, 0.41666666666667
25080, 1.7, 0.7, 0.41666666666667
25081, 1.7, 0.65, 0.41666666666667
25082, 1.7, 0.6, 0.41666666666667
25083, 1.7, 0.55, 0.41666666666667
25084, 1.7, 0.5, 0.41666666666667
25085, 1.7, 0.45, 0.41666666666667
25086, 1.7, 0.4, 0.41666666666667
25087, 1.7, 0.35, 0.41666666666667
25088, 1.7, 0.3, 0.41666666666667
25089, 1.7, 0.25, 0.41666666666667
25090, 1.7, 0.2, 0.41666666666667
25091, 1.7416666666667, 1.3, 0.41666666666667
25092, 1.7416666666667, 1.25, 0.41666666666667
25093, 1.7416666666667, 1.2, 0.41666666666667
25094, 1.7416666666667, 1.15, 0.41666666666667
25095, 1.7416666666667, 1.1, 0.41666666666667
25096, 1.7416666666667, 1.05, 0.41666666666667
25097, 1.7416666666667, 1, 0.41666666666667
25098, 1.7416666666667, 0.95, 0.41666666666667
25099, 1.7416666666667, 0.9, 0.41666666666667
25100, 1.7416666666667, 0.85, 0.41666666666667
25101, 1.7416666666667, 0.8, 0.41666666666667
25102, 1.7416666666667, 0.75, 0.41666666666667
25103, 1.7416666666667, 0.7, 0.41666666666667
25104, 1.7416666666667, 0.65, 0.41666666666667
25105, 1.7416666666667, 0.6, 0.41666666666667
25106, 1.7416666666667, 0.55, 0.41666666666667
25107, 1.7416666666667, 0.5, 0.41666666666667
25108, 1.7416666666667, 0.45, 0.41666666666667
25109, 1.7416666666667, 0.4, 0.41666666666667
25110, 1.7416666666667, 0.35, 0.41666666666667
25111, 1.7416666666667, 0.3, 0.41666666666667
25112, 1.7416666666667, 0.25, 0.41666666666667
25113, 1.7416666666667, 0.2, 0.41666666666667
25114, 1.7833333333333, 1.3, 0.41666666666667
25115, 1.7833333333333, 1.25, 0.41666666666667
25116, 1.7833333333333, 1.2, 0.41666666666667
25117, 1.7833333333333, 1.15, 0.41666666666667
25118, 1.7833333333333, 1.1, 0.41666666666667
25119, 1.7833333333333, 1.05, 0.41666666666667
25120, 1.7833333333333, 1, 0.41666666666667
25121, 1.7833333333333, 0.95, 0.41666666666667
25122, 1.7833333333333, 0.9, 0.41666666666667
25123, 1.7833333333333, 0.85, 0.41666666666667
25124, 1.7833333333333, 0.8, 0.41666666666667
25125, 1.7833333333333, 0.75, 0.41666666666667
25126, 1.7833333333333, 0.7, 0.41666666666667
25127, 1.7833333333333, 0.65, 0.41666666666667
25128, 1.7833333333333, 0.6, 0.41666666666667
25129, 1.7833333333333, 0.55, 0.41666666666667
25130, 1.7833333333333, 0.5, 0.41666666666667
25131, 1.7833333333333, 0.45, 0.41666666666667
25132, 1.7833333333333, 0.4, 0.41666666666667
25133, 1.7833333333333, 0.35, 0.41666666666667
25134, 1.7833333333333, 0.3, 0.41666666666667
25135, 1.7833333333333, 0.25, 0.41666666666667
25136, 1.7833333333333, 0.2, 0.41666666666667
25137, 1.825, 1.3, 0.41666666666667
25138, 1.825, 1.25, 0.41666666666667
25139, 1.825, 1.2, 0.41666666666667
25140, 1.825, 1.15, 0.41666666666667
25141, 1.825, 1.1, 0.41666666666667
25142, 1.825, 1.05, 0.41666666666667
25143, 1.825, 1, 0.41666666666667
25144, 1.825, 0.95, 0.41666666666667
25145, 1.825, 0.9, 0.41666666666667
25146, 1.825, 0.85, 0.41666666666667
25147, 1.825, 0.8, 0.41666666666667
25148, 1.825, 0.75, 0.41666666666667
25149, 1.825, 0.7, 0.41666666666667
25150, 1.825, 0.65, 0.41666666666667
25151, 1.825, 0.6, 0.41666666666667
25152, 1.825, 0.55, 0.41666666666667
25153, 1.825, 0.5, 0.41666666666667
25154, 1.825, 0.45, 0.41666666666667
25155, 1.825, 0.4, 0.41666666666667
25156, 1.825, 0.35, 0.41666666666667
25157, 1.825, 0.3, 0.41666666666667
25158, 1.825, 0.25, 0.41666666666667
25159, 1.825, 0.2, 0.41666666666667
25160, 1.8666666666667, 1.3, 0.41666666666667
25161, 1.8666666666667, 1.25, 0.41666666666667
25162, 1.8666666666667, 1.2, 0.41666666666667
25163, 1.8666666666667, 1.15, 0.41666666666667
25164, 1.8666666666667, 1.1, 0.41666666666667
25165, 1.8666666666667, 1.05, 0.41666666666667
25166, 1.8666666666667, 1, 0.41666666666667
25167, 1.8666666666667, 0.95, 0.41666666666667
25168, 1.8666666666667, 0.9, 0.41666666666667
25169, 1.8666666666667, 0.85, 0.41666666666667
25170, 1.8666666666667, 0.8, 0.41666666666667
25171, 1.8666666666667, 0.75, 0.41666666666667
25172, 1.8666666666667, 0.7, 0.41666666666667
25173, 1.8666666666667, 0.65, 0.41666666666667
25174, 1.8666666666667, 0.6, 0.41666666666667
25175, 1.8666666666667, 0.55, 0.41666666666667
25176, 1.8666666666667, 0.5, 0.41666666666667
25177, 1.8666666666667, 0.45, 0.41666666666667
25178, 1.8666666666667, 0.4, 0.41666666666667
25179, 1.8666666666667, 0.35, 0.41666666666667
25180, 1.8666666666667, 0.3, 0.41666666666667
25181, 1.8666666666667, 0.25, 0.41666666666667
25182, 1.8666666666667, 0.2, 0.41666666666667
25183, 1.9083333333333, 1.3, 0.41666666666667
25184, 1.9083333333333, 1.25, 0.41666666666667
25185, 1.9083333333333, 1.2, 0.41666666666667
25186, 1.9083333333333, 1.15, 0.41666666666667
25187, 1.9083333333333, 1.1, 0.41666666666667
25188, 1.9083333333333, 1.05, 0.41666666666667
25189, 1.9083333333333, 1, 0.41666666666667
25190, 1.9083333333333, 0.95, 0.41666666666667
25191, 1.9083333333333, 0.9, 0.41666666666667
25192, 1.9083333333333, 0.85, 0.41666666666667
25193, 1.9083333333333, 0.8, 0.41666666666667
25194, 1.9083333333333, 0.75, 0.41666666666667
25195, 1.9083333333333, 0.7, 0.41666666666667
25196, 1.9083333333333, 0.65, 0.41666666666667
25197, 1.9083333333333, 0.6, 0.41666666666667
25198, 1.9083333333333, 0.55, 0.41666666666667
25199, 1.9083333333333, 0.5, 0.41666666666667
25200, 1.9083333333333, 0.45, 0.41666666666667
25201, 1.9083333333333, 0.4, 0.41666666666667
25202, 1.9083333333333, 0.35, 0.41666666666667
25203, 1.9083333333333, 0.3, 0.41666666666667
25204, 1.9083333333333, 0.25, 0.41666666666667
25205, 1.9083333333333, 0.2, 0.41666666666667
25206, 1.95, 1.3, 0.41666666666667
25207, 1.95, 1.25, 0.41666666666667
25208, 1.95, 1.2, 0.41666666666667
25209, 1.95, 1.15, 0.41666666666667
25210, 1.95, 1.1, 0.41666666666667
25211, 1.95, 1.05, 0.41666666666667
25212, 1.95, 1, 0.41666666666667
25213, 1.95, 0.95, 0.41666666666667
25214, 1.95, 0.9, 0.41666666666667
25215, 1.95, 0.85, 0.41666666666667
25216, 1.95, 0.8, 0.41666666666667
25217, 1.95, 0.75, 0.41666666666667
25218, 1.95, 0.7, 0.41666666666667
25219, 1.95, 0.65, 0.41666666666667
25220, 1.95, 0.6, 0.41666666666667
25221, 1.95, 0.55, 0.41666666666667
25222, 1.95, 0.5, 0.41666666666667
25223, 1.95, 0.45, 0.41666666666667
25224, 1.95, 0.4, 0.41666666666667
25225, 1.95, 0.35, 0.41666666666667
25226, 1.95, 0.3, 0.41666666666667
25227, 1.95, 0.25, 0.41666666666667
25228, 1.95, 0.2, 0.41666666666667
25229, 1.9916666666667, 1.3, 0.41666666666667
25230, 1.9916666666667, 1.25, 0.41666666666667
25231, 1.9916666666667, 1.2, 0.41666666666667
25232, 1.9916666666667, 1.15, 0.41666666666667
25233, 1.9916666666667, 1.1, 0.41666666666667
25234, 1.9916666666667, 1.05, 0.41666666666667
25235, 1.9916666666667, 1, 0.41666666666667
25236, 1.9916666666667, 0.95, 0.41666666666667
25237, 1.9916666666667, 0.9, 0.41666666666667
25238, 1.9916666666667, 0.85, 0.41666666666667
25239, 1.9916666666667, 0.8, 0.41666666666667
25240, 1.9916666666667, 0.75, 0.41666666666667
25241, 1.9916666666667, 0.7, 0.41666666666667
25242, 1.9916666666667, 0.65, 0.41666666666667
25243, 1.9916666666667, 0.6, 0.41666666666667
25244, 1.9916666666667, 0.55, 0.41666666666667
25245, 1.9916666666667, 0.5, 0.41666666666667
25246, 1.9916666666667, 0.45, 0.41666666666667
25247, 1.9916666666667, 0.4, 0.41666666666667
25248, 1.9916666666667, 0.35, 0.41666666666667
25249, 1.9916666666667, 0.3, 0.41666666666667
25250, 1.9916666666667, 0.25, 0.41666666666667
25251, 1.9916666666667, 0.2, 0.41666666666667
25252, 2.0333333333333, 1.3, 0.41666666666667
25253, 2.0333333333333, 1.25, 0.41666666666667
25254, 2.0333333333333, 1.2, 0.41666666666667
25255, 2.0333333333333, 1.15, 0.41666666666667
25256, 2.0333333333333, 1.1, 0.41666666666667
25257, 2.0333333333333, 1.05, 0.41666666666667
25258, 2.0333333333333, 1, 0.41666666666667
25259, 2.0333333333333, 0.95, 0.41666666666667
25260, 2.0333333333333, 0.9, 0.41666666666667
25261, 2.0333333333333, 0.85, 0.41666666666667
25262, 2.0333333333333, 0.8, 0.41666666666667
25263, 2.0333333333333, 0.75, 0.41666666666667
25264, 2.0333333333333, 0.7, 0.41666666666667
25265, 2.0333333333333, 0.65, 0.41666666666667
25266, 2.0333333333333, 0.6, 0.41666666666667
25267, 2.0333333333333, 0.55, 0.41666666666667
25268, 2.0333333333333, 0.5, 0.41666666666667
25269, 2.0333333333333, 0.45, 0.41666666666667
25270, 2.0333333333333, 0.4, 0.41666666666667
25271, 2.0333333333333, 0.35, 0.41666666666667
25272, 2.0333333333333, 0.3, 0.41666666666667
25273, 2.0333333333333, 0.25, 0.41666666666667
25274, 2.0333333333333, 0.2, 0.41666666666667
25275, 2.075, 1.3, 0.41666666666667
25276, 2.075, 1.25, 0.41666666666667
25277, 2.075, 1.2, 0.41666666666667
25278, 2.075, 1.15, 0.41666666666667
25279, 2.075, 1.1, 0.41666666666667
25280, 2.075, 1.05, 0.41666666666667
25281, 2.075, 1, 0.41666666666667
25282, 2.075, 0.95, 0.41666666666667
25283, 2.075, 0.9, 0.41666666666667
25284, 2.075, 0.85, 0.41666666666667
25285, 2.075, 0.8, 0.41666666666667
25286, 2.075, 0.75, 0.41666666666667
25287, 2.075, 0.7, 0.41666666666667
25288, 2.075, 0.65, 0.41666666666667
25289, 2.075, 0.6, 0.41666666666667
25290, 2.075, 0.55, 0.41666666666667
25291, 2.075, 0.5, 0.41666666666667
25292, 2.075, 0.45, 0.41666666666667
25293, 2.075, 0.4, 0.41666666666667
25294, 2.075, 0.35, 0.41666666666667
25295, 2.075, 0.3, 0.41666666666667
25296, 2.075, 0.25, 0.41666666666667
25297, 2.075, 0.2, 0.41666666666667
25298, 2.1166666666667, 1.3, 0.41666666666667
25299, 2.1166666666667, 1.25, 0.41666666666667
25300, 2.1166666666667, 1.2, 0.41666666666667
25301, 2.1166666666667, 1.15, 0.41666666666667
25302, 2.1166666666667, 1.1, 0.41666666666667
25303, 2.1166666666667, 1.05, 0.41666666666667
25304, 2.1166666666667, 1, 0.41666666666667
25305, 2.1166666666667, 0.95, 0.41666666666667
25306, 2.1166666666667, 0.9, 0.41666666666667
25307, 2.1166666666667, 0.85, 0.41666666666667
25308, 2.1166666666667, 0.8, 0.41666666666667
25309, 2.1166666666667, 0.75, 0.41666666666667
25310, 2.1166666666667, 0.7, 0.41666666666667
25311, 2.1166666666667, 0.65, 0.41666666666667
25312, 2.1166666666667, 0.6, 0.41666666666667
25313, 2.1166666666667, 0.55, 0.41666666666667
25314, 2.1166666666667, 0.5, 0.41666666666667
25315, 2.1166666666667, 0.45, 0.41666666666667
25316, 2.1166666666667, 0.4, 0.41666666666667
25317, 2.1166666666667, 0.35, 0.41666666666667
25318, 2.1166666666667, 0.3, 0.41666666666667
25319, 2.1166666666667, 0.25, 0.41666666666667
25320, 2.1166666666667, 0.2, 0.41666666666667
25321, 2.1583333333333, 1.3, 0.41666666666667
25322, 2.1583333333333, 1.25, 0.41666666666667
25323, 2.1583333333333, 1.2, 0.41666666666667
25324, 2.1583333333333, 1.15, 0.41666666666667
25325, 2.1583333333333, 1.1, 0.41666666666667
25326, 2.1583333333333, 1.05, 0.41666666666667
25327, 2.1583333333333, 1, 0.41666666666667
25328, 2.1583333333333, 0.95, 0.41666666666667
25329, 2.1583333333333, 0.9, 0.41666666666667
25330, 2.1583333333333, 0.85, 0.41666666666667
25331, 2.1583333333333, 0.8, 0.41666666666667
25332, 2.1583333333333, 0.75, 0.41666666666667
25333, 2.1583333333333, 0.7, 0.41666666666667
25334, 2.1583333333333, 0.65, 0.41666666666667
25335, 2.1583333333333, 0.6, 0.41666666666667
25336, 2.1583333333333, 0.55, 0.41666666666667
25337, 2.1583333333333, 0.5, 0.41666666666667
25338, 2.1583333333333, 0.45, 0.41666666666667
25339, 2.1583333333333, 0.4, 0.41666666666667
25340, 2.1583333333333, 0.35, 0.41666666666667
25341, 2.1583333333333, 0.3, 0.41666666666667
25342, 2.1583333333333, 0.25, 0.41666666666667
25343, 2.1583333333333, 0.2, 0.41666666666667
25344, 1.2416666666667, 1.3, 0.45833333333333
25345, 1.2416666666667, 1.25, 0.45833333333333
25346, 1.2416666666667, 1.2, 0.45833333333333
25347, 1.2416666666667, 1.15, 0.45833333333333
25348, 1.2416666666667, 1.1, 0.45833333333333
25349, 1.2416666666667, 1.05, 0.45833333333333
25350, 1.2416666666667, 1, 0.45833333333333
25351, 1.2416666666667, 0.95, 0.45833333333333
25352, 1.2416666666667, 0.9, 0.45833333333333
25353, 1.2416666666667, 0.85, 0.45833333333333
25354, 1.2416666666667, 0.8, 0.45833333333333
25355, 1.2416666666667, 0.75, 0.45833333333333
25356, 1.2416666666667, 0.7, 0.45833333333333
25357, 1.2416666666667, 0.65, 0.45833333333333
25358, 1.2416666666667, 0.6, 0.45833333333333
25359, 1.2416666666667, 0.55, 0.45833333333333
25360, 1.2416666666667, 0.5, 0.45833333333333
25361, 1.2416666666667, 0.45, 0.45833333333333
25362, 1.2416666666667, 0.4, 0.45833333333333
25363, 1.2416666666667, 0.35, 0.45833333333333
25364, 1.2416666666667, 0.3, 0.45833333333333
25365, 1.2416666666667, 0.25, 0.45833333333333
25366, 1.2416666666667, 0.2, 0.45833333333333
25367, 1.2833333333333, 1.3, 0.45833333333333
25368, 1.2833333333333, 1.25, 0.45833333333333
25369, 1.2833333333333, 1.2, 0.45833333333333
25370, 1.2833333333333, 1.15, 0.45833333333333
25371, 1.2833333333333, 1.1, 0.45833333333333
25372, 1.2833333333333, 1.05, 0.45833333333333
25373, 1.2833333333333, 1, 0.45833333333333
25374, 1.2833333333333, 0.95, 0.45833333333333
25375, 1.2833333333333, 0.9, 0.45833333333333
25376, 1.2833333333333, 0.85, 0.45833333333333
25377, 1.2833333333333, 0.8, 0.45833333333333
25378, 1.2833333333333, 0.75, 0.45833333333333
25379, 1.2833333333333, 0.7, 0.45833333333333
25380, 1.2833333333333, 0.65, 0.45833333333333
25381, 1.2833333333333, 0.6, 0.45833333333333
25382, 1.2833333333333, 0.55, 0.45833333333333
25383, 1.2833333333333, 0.5, 0.45833333333333
25384, 1.2833333333333, 0.45, 0.45833333333333
25385, 1.2833333333333, 0.4, 0.45833333333333
25386, 1.2833333333333, 0.35, 0.45833333333333
25387, 1.2833333333333, 0.3, 0.45833333333333
25388, 1.2833333333333, 0.25, 0.45833333333333
25389, 1.2833333333333, 0.2, 0.45833333333333
25390, 1.325, 1.3, 0.45833333333333
25391, 1.325, 1.25, 0.45833333333333
25392, 1.325, 1.2, 0.45833333333333
25393, 1.325, 1.15, 0.45833333333333
25394, 1.325, 1.1, 0.45833333333333
25395, 1.325, 1.05, 0.45833333333333
25396, 1.325, 1, 0.45833333333333
25397, 1.325, 0.95, 0.45833333333333
25398, 1.325, 0.9, 0.45833333333333
25399, 1.325, 0.85, 0.45833333333333
25400, 1.325, 0.8, 0.45833333333333
25401, 1.325, 0.75, 0.45833333333333
25402, 1.325, 0.7, 0.45833333333333
25403, 1.325, 0.65, 0.45833333333333
25404, 1.325, 0.6, 0.45833333333333
25405, 1.325, 0.55, 0.45833333333333
25406, 1.325, 0.5, 0.45833333333333
25407, 1.325, 0.45, 0.45833333333333
25408, 1.325, 0.4, 0.45833333333333
25409, 1.325, 0.35, 0.45833333333333
25410, 1.325, 0.3, 0.45833333333333
25411, 1.325, 0.25, 0.45833333333333
25412, 1.325, 0.2, 0.45833333333333
25413, 1.3666666666667, 1.3, 0.45833333333333
25414, 1.3666666666667, 1.25, 0.45833333333333
25415, 1.3666666666667, 1.2, 0.45833333333333
25416, 1.3666666666667, 1.15, 0.45833333333333
25417, 1.3666666666667, 1.1, 0.45833333333333
25418, 1.3666666666667, 1.05, 0.45833333333333
25419, 1.3666666666667, 1, 0.45833333333333
25420, 1.3666666666667, 0.95, 0.45833333333333
25421, 1.3666666666667, 0.9, 0.45833333333333
25422, 1.3666666666667, 0.85, 0.45833333333333
25423, 1.3666666666667, 0.8, 0.45833333333333
25424, 1.3666666666667, 0.75, 0.45833333333333
25425, 1.3666666666667, 0.7, 0.45833333333333
25426, 1.3666666666667, 0.65, 0.45833333333333
25427, 1.3666666666667, 0.6, 0.45833333333333
25428, 1.3666666666667, 0.55, 0.45833333333333
25429, 1.3666666666667, 0.5, 0.45833333333333
25430, 1.3666666666667, 0.45, 0.45833333333333
25431, 1.3666666666667, 0.4, 0.45833333333333
25432, 1.3666666666667, 0.35, 0.45833333333333
25433, 1.3666666666667, 0.3, 0.45833333333333
25434, 1.3666666666667, 0.25, 0.45833333333333
25435, 1.3666666666667, 0.2, 0.45833333333333
25436, 1.4083333333333, 1.3, 0.45833333333333
25437, 1.4083333333333, 1.25, 0.45833333333333
25438, 1.4083333333333, 1.2, 0.45833333333333
25439, 1.4083333333333, 1.15, 0.45833333333333
25440, 1.4083333333333, 1.1, 0.45833333333333
25441, 1.4083333333333, 1.05, 0.45833333333333
25442, 1.4083333333333, 1, 0.45833333333333
25443, 1.4083333333333, 0.95, 0.45833333333333
25444, 1.4083333333333, 0.9, 0.45833333333333
25445, 1.4083333333333, 0.85, 0.45833333333333
25446, 1.4083333333333, 0.8, 0.45833333333333
25447, 1.4083333333333, 0.75, 0.45833333333333
25448, 1.4083333333333, 0.7, 0.45833333333333
25449, 1.4083333333333, 0.65, 0.45833333333333
25450, 1.4083333333333, 0.6, 0.45833333333333
25451, 1.4083333333333, 0.55, 0.45833333333333
25452, 1.4083333333333, 0.5, 0.45833333333333
25453, 1.4083333333333, 0.45, 0.45833333333333
25454, 1.4083333333333, 0.4, 0.45833333333333
25455, 1.4083333333333, 0.35, 0.45833333333333
25456, 1.4083333333333, 0.3, 0.45833333333333
25457, 1.4083333333333, 0.25, 0.45833333333333
25458, 1.4083333333333, 0.2, 0.45833333333333
25459, 1.45, 1.3, 0.45833333333333
25460, 1.45, 1.25, 0.45833333333333
25461, 1.45, 1.2, 0.45833333333333
25462, 1.45, 1.15, 0.45833333333333
25463, 1.45, 1.1, 0.45833333333333
25464, 1.45, 1.05, 0.45833333333333
25465, 1.45, 1, 0.45833333333333
25466, 1.45, 0.95, 0.45833333333333
25467, 1.45, 0.9, 0.45833333333333
25468, 1.45, 0.85, 0.45833333333333
25469, 1.45, 0.8, 0.45833333333333
25470, 1.45, 0.75, 0.45833333333333
25471, 1.45, 0.7, 0.45833333333333
25472, 1.45, 0.65, 0.45833333333333
25473, 1.45, 0.6, 0.45833333333333
25474, 1.45, 0.55, 0.45833333333333
25475, 1.45, 0.5, 0.45833333333333
25476, 1.45, 0.45, 0.45833333333333
25477, 1.45, 0.4, 0.45833333333333
25478, 1.45, 0.35, 0.45833333333333
25479, 1.45, 0.3, 0.45833333333333
25480, 1.45, 0.25, 0.45833333333333
25481, 1.45, 0.2, 0.45833333333333
25482, 1.4916666666667, 1.3, 0.45833333333333
25483, 1.4916666666667, 1.25, 0.45833333333333
25484, 1.4916666666667, 1.2, 0.45833333333333
25485, 1.4916666666667, 1.15, 0.45833333333333
25486, 1.4916666666667, 1.1, 0.45833333333333
25487, 1.4916666666667, 1.05, 0.45833333333333
25488, 1.4916666666667, 1, 0.45833333333333
25489, 1.4916666666667, 0.95, 0.45833333333333
25490, 1.4916666666667, 0.9, 0.45833333333333
25491, 1.4916666666667, 0.85, 0.45833333333333
25492, 1.4916666666667, 0.8, 0.45833333333333
25493, 1.4916666666667, 0.75, 0.45833333333333
25494, 1.4916666666667, 0.7, 0.45833333333333
25495, 1.4916666666667, 0.65, 0.45833333333333
25496, 1.4916666666667, 0.6, 0.45833333333333
25497, 1.4916666666667, 0.55, 0.45833333333333
25498, 1.4916666666667, 0.5, 0.45833333333333
25499, 1.4916666666667, 0.45, 0.45833333333333
25500, 1.4916666666667, 0.4, 0.45833333333333
25501, 1.4916666666667, 0.35, 0.45833333333333
25502, 1.4916666666667, 0.3, 0.45833333333333
25503, 1.4916666666667, 0.25, 0.45833333333333
25504, 1.4916666666667, 0.2, 0.45833333333333
25505, 1.5333333333333, 1.3, 0.45833333333333
25506, 1.5333333333333, 1.25, 0.45833333333333
25507, 1.5333333333333, 1.2, 0.45833333333333
25508, 1.5333333333333, 1.15, 0.45833333333333
25509, 1.5333333333333, 1.1, 0.45833333333333
25510, 1.5333333333333, 1.05, 0.45833333333333
25511, 1.5333333333333, 1, 0.45833333333333
25512, 1.5333333333333, 0.95, 0.45833333333333
25513, 1.5333333333333, 0.9, 0.45833333333333
25514, 1.5333333333333, 0.85, 0.45833333333333
25515, 1.5333333333333, 0.8, 0.45833333333333
25516, 1.5333333333333, 0.75, 0.45833333333333
25517, 1.5333333333333, 0.7, 0.45833333333333
25518, 1.5333333333333, 0.65, 0.45833333333333
25519, 1.5333333333333, 0.6, 0.45833333333333
25520, 1.5333333333333, 0.55, 0.45833333333333
25521, 1.5333333333333, 0.5, 0.45833333333333
25522, 1.5333333333333, 0.45, 0.45833333333333
25523, 1.5333333333333, 0.4, 0.45833333333333
25524, 1.5333333333333, 0.35, 0.45833333333333
25525, 1.5333333333333, 0.3, 0.45833333333333
25526, 1.5333333333333, 0.25, 0.45833333333333
25527, 1.5333333333333, 0.2, 0.45833333333333
25528, 1.575, 1.3, 0.45833333333333
25529, 1.575, 1.25, 0.45833333333333
25530, 1.575, 1.2, 0.45833333333333
25531, 1.575, 1.15, 0.45833333333333
25532, 1.575, 1.1, 0.45833333333333
25533, 1.575, 1.05, 0.45833333333333
25534, 1.575, 1, 0.45833333333333
25535, 1.575, 0.95, 0.45833333333333
25536, 1.575, 0.9, 0.45833333333333
25537, 1.575, 0.85, 0.45833333333333
25538, 1.575, 0.8, 0.45833333333333
25539, 1.575, 0.75, 0.45833333333333
25540, 1.575, 0.7, 0.45833333333333
25541, 1.575, 0.65, 0.45833333333333
25542, 1.575, 0.6, 0.45833333333333
25543, 1.575, 0.55, 0.45833333333333
25544, 1.575, 0.5, 0.45833333333333
25545, 1.575, 0.45, 0.45833333333333
25546, 1.575, 0.4, 0.45833333333333
25547, 1.575, 0.35, 0.45833333333333
25548, 1.575, 0.3, 0.45833333333333
25549, 1.575, 0.25, 0.45833333333333
25550, 1.575, 0.2, 0.45833333333333
25551, 1.6166666666667, 1.3, 0.45833333333333
25552, 1.6166666666667, 1.25, 0.45833333333333
25553, 1.6166666666667, 1.2, 0.45833333333333
25554, 1.6166666666667, 1.15, 0.45833333333333
25555, 1.6166666666667, 1.1, 0.45833333333333
25556, 1.6166666666667, 1.05, 0.45833333333333
25557, 1.6166666666667, 1, 0.45833333333333
25558, 1.6166666666667, 0.95, 0.45833333333333
25559, 1.6166666666667, 0.9, 0.45833333333333
25560, 1.6166666666667, 0.85, 0.45833333333333
25561, 1.6166666666667, 0.8, 0.45833333333333
25562, 1.6166666666667, 0.75, 0.45833333333333
25563, 1.6166666666667, 0.7, 0.45833333333333
25564, 1.6166666666667, 0.65, 0.45833333333333
25565, 1.6166666666667, 0.6, 0.45833333333333
25566, 1.6166666666667, 0.55, 0.45833333333333
25567, 1.6166666666667, 0.5, 0.45833333333333
25568, 1.6166666666667, 0.45, 0.45833333333333
25569, 1.6166666666667, 0.4, 0.45833333333333
25570, 1.6166666666667, 0.35, 0.45833333333333
25571, 1.6166666666667, 0.3, 0.45833333333333
25572, 1.6166666666667, 0.25, 0.45833333333333
25573, 1.6166666666667, 0.2, 0.45833333333333
25574, 1.6583333333333, 1.3, 0.45833333333333
25575, 1.6583333333333, 1.25, 0.45833333333333
25576, 1.6583333333333, 1.2, 0.45833333333333
25577, 1.6583333333333, 1.15, 0.45833333333333
25578, 1.6583333333333, 1.1, 0.45833333333333
25579, 1.6583333333333, 1.05, 0.45833333333333
25580, 1.6583333333333, 1, 0.45833333333333
25581, 1.6583333333333, 0.95, 0.45833333333333
25582, 1.6583333333333, 0.9, 0.45833333333333
25583, 1.6583333333333, 0.85, 0.45833333333333
25584, 1.6583333333333, 0.8, 0.45833333333333
25585, 1.6583333333333, 0.75, 0.45833333333333
25586, 1.6583333333333, 0.7, 0.45833333333333
25587, 1.6583333333333, 0.65, 0.45833333333333
25588, 1.6583333333333, 0.6, 0.45833333333333
25589, 1.6583333333333, 0.55, 0.45833333333333
25590, 1.6583333333333, 0.5, 0.45833333333333
25591, 1.6583333333333, 0.45, 0.45833333333333
25592, 1.6583333333333, 0.4, 0.45833333333333
25593, 1.6583333333333, 0.35, 0.45833333333333
25594, 1.6583333333333, 0.3, 0.45833333333333
25595, 1.6583333333333, 0.25, 0.45833333333333
25596, 1.6583333333333, 0.2, 0.45833333333333
25597, 1.7, 1.3, 0.45833333333333
25598, 1.7, 1.25, 0.45833333333333
25599, 1.7, 1.2, 0.45833333333333
25600, 1.7, 1.15, 0.45833333333333
25601, 1.7, 1.1, 0.45833333333333
25602, 1.7, 1.05, 0.45833333333333
25603, 1.7, 1, 0.45833333333333
25604, 1.7, 0.95, 0.45833333333333
25605, 1.7, 0.9, 0.45833333333333
25606, 1.7, 0.85, 0.45833333333333
25607, 1.7, 0.8, 0.45833333333333
25608, 1.7, 0.75, 0.45833333333333
25609, 1.7, 0.7, 0.45833333333333
25610, 1.7, 0.65, 0.45833333333333
25611, 1.7, 0.6, 0.45833333333333
25612, 1.7, 0.55, 0.45833333333333
25613, 1.7, 0.5, 0.45833333333333
25614, 1.7, 0.45, 0.45833333333333
25615, 1.7, 0.4, 0.45833333333333
25616, 1.7, 0.35, 0.45833333333333
25617, 1.7, 0.3, 0.45833333333333
25618, 1.7, 0.25, 0.45833333333333
25619, 1.7, 0.2, 0.45833333333333
25620, 1.7416666666667, 1.3, 0.45833333333333
25621, 1.7416666666667, 1.25, 0.45833333333333
25622, 1.7416666666667, 1.2, 0.45833333333333
25623, 1.7416666666667, 1.15, 0.45833333333333
25624, 1.7416666666667, 1.1, 0.45833333333333
25625, 1.7416666666667, 1.05, 0.45833333333333
25626, 1.7416666666667, 1, 0.45833333333333
25627, 1.7416666666667, 0.95, 0.45833333333333
25628, 1.7416666666667, 0.9, 0.45833333333333
25629, 1.7416666666667, 0.85, 0.45833333333333
25630, 1.7416666666667, 0.8, 0.45833333333333
25631, 1.7416666666667, 0.75, 0.45833333333333
25632, 1.7416666666667, 0.7, 0.45833333333333
25633, 1.7416666666667, 0.65, 0.45833333333333
25634, 1.7416666666667, 0.6, 0.45833333333333
25635, 1.7416666666667, 0.55, 0.45833333333333
25636, 1.7416666666667, 0.5, 0.45833333333333
25637, 1.7416666666667, 0.45, 0.45833333333333
25638, 1.7416666666667, 0.4, 0.45833333333333
25639, 1.7416666666667, 0.35, 0.45833333333333
25640, 1.7416666666667, 0.3, 0.45833333333333
25641, 1.7416666666667, 0.25, 0.45833333333333
25642, 1.7416666666667, 0.2, 0.45833333333333
25643, 1.7833333333333, 1.3, 0.45833333333333
25644, 1.7833333333333, 1.25, 0.45833333333333
25645, 1.7833333333333, 1.2, 0.45833333333333
25646, 1.7833333333333, 1.15, 0.45833333333333
25647, 1.7833333333333, 1.1, 0.45833333333333
25648, 1.7833333333333, 1.05, 0.45833333333333
25649, 1.7833333333333, 1, 0.45833333333333
25650, 1.7833333333333, 0.95, 0.45833333333333
25651, 1.7833333333333, 0.9, 0.45833333333333
25652, 1.7833333333333, 0.85, 0.45833333333333
25653, 1.7833333333333, 0.8, 0.45833333333333
25654, 1.7833333333333, 0.75, 0.45833333333333
25655, 1.7833333333333, 0.7, 0.45833333333333
25656, 1.7833333333333, 0.65, 0.45833333333333
25657, 1.7833333333333, 0.6, 0.45833333333333
25658, 1.7833333333333, 0.55, 0.45833333333333
25659, 1.7833333333333, 0.5, 0.45833333333333
25660, 1.7833333333333, 0.45, 0.45833333333333
25661, 1.7833333333333, 0.4, 0.45833333333333
25662, 1.7833333333333, 0.35, 0.45833333333333
25663, 1.7833333333333, 0.3, 0.45833333333333
25664, 1.7833333333333, 0.25, 0.45833333333333
25665, 1.7833333333333, 0.2, 0.45833333333333
25666, 1.825, 1.3, 0.45833333333333
25667, 1.825, 1.25, 0.45833333333333
25668, 1.825, 1.2, 0.45833333333333
25669, 1.825, 1.15, 0.45833333333333
25670, 1.825, 1.1, 0.45833333333333
25671, 1.825, 1.05, 0.45833333333333
25672, 1.825, 1, 0.45833333333333
25673, 1.825, 0.95, 0.45833333333333
25674, 1.825, 0.9, 0.45833333333333
25675, 1.825, 0.85, 0.45833333333333
25676, 1.825, 0.8, 0.45833333333333
25677, 1.825, 0.75, 0.45833333333333
25678, 1.825, 0.7, 0.45833333333333
25679, 1.825, 0.65, 0.45833333333333
25680, 1.825, 0.6, 0.45833333333333
25681, 1.825, 0.55, 0.45833333333333
25682, 1.825, 0.5, 0.45833333333333
25683, 1.825, 0.45, 0.45833333333333
25684, 1.825, 0.4, 0.45833333333333
25685, 1.825, 0.35, 0.45833333333333
25686, 1.825, 0.3, 0.45833333333333
25687, 1.825, 0.25, 0.45833333333333
25688, 1.825, 0.2, 0.45833333333333
25689, 1.8666666666667, 1.3, 0.45833333333333
25690, 1.8666666666667, 1.25, 0.45833333333333
25691, 1.8666666666667, 1.2, 0.45833333333333
25692, 1.8666666666667, 1.15, 0.45833333333333
25693, 1.8666666666667, 1.1, 0.45833333333333
25694, 1.8666666666667, 1.05, 0.45833333333333
25695, 1.8666666666667, 1, 0.45833333333333
25696, 1.8666666666667, 0.95, 0.45833333333333
25697, 1.8666666666667, 0.9, 0.45833333333333
25698, 1.8666666666667, 0.85, 0.45833333333333
25699, 1.8666666666667, 0.8, 0.45833333333333
25700, 1.8666666666667, 0.75, 0.45833333333333
25701, 1.8666666666667, 0.7, 0.45833333333333
25702, 1.8666666666667, 0.65, 0.45833333333333
25703, 1.8666666666667, 0.6, 0.45833333333333
25704, 1.8666666666667, 0.55, 0.45833333333333
25705, 1.8666666666667, 0.5, 0.45833333333333
25706, 1.8666666666667, 0.45, 0.45833333333333
25707, 1.8666666666667, 0.4, 0.45833333333333
25708, 1.8666666666667, 0.35, 0.45833333333333
25709, 1.8666666666667, 0.3, 0.45833333333333
25710, 1.8666666666667, 0.25, 0.45833333333333
25711, 1.8666666666667, 0.2, 0.45833333333333
25712, 1.9083333333333, 1.3, 0.45833333333333
25713, 1.9083333333333, 1.25, 0.45833333333333
25714, 1.9083333333333, 1.2, 0.45833333333333
25715, 1.9083333333333, 1.15, 0.45833333333333
25716, 1.9083333333333, 1.1, 0.45833333333333
25717, 1.9083333333333, 1.05, 0.45833333333333
25718, 1.9083333333333, 1, 0.45833333333333
25719, 1.9083333333333, 0.95, 0.45833333333333
25720, 1.9083333333333, 0.9, 0.45833333333333
25721, 1.9083333333333, 0.85, 0.45833333333333
25722, 1.9083333333333, 0.8, 0.45833333333333
25723, 1.9083333333333, 0.75, 0.45833333333333
25724, 1.9083333333333, 0.7, 0.45833333333333
25725, 1.9083333333333, 0.65, 0.45833333333333
25726, 1.9083333333333, 0.6, 0.45833333333333
25727, 1.9083333333333, 0.55, 0.45833333333333
25728, 1.9083333333333, 0.5, 0.45833333333333
25729, 1.9083333333333, 0.45, 0.45833333333333
25730, 1.9083333333333, 0.4, 0.45833333333333
25731, 1.9083333333333, 0.35, 0.45833333333333
25732, 1.9083333333333, 0.3, 0.45833333333333
25733, 1.9083333333333, 0.25, 0.45833333333333
25734, 1.9083333333333, 0.2, 0.45833333333333
25735, 1.95, 1.3, 0.45833333333333
25736, 1.95, 1.25, 0.45833333333333
25737, 1.95, 1.2, 0.45833333333333
25738, 1.95, 1.15, 0.45833333333333
25739, 1.95, 1.1, 0.45833333333333
25740, 1.95, 1.05, 0.45833333333333
25741, 1.95, 1, 0.45833333333333
25742, 1.95, 0.95, 0.45833333333333
25743, 1.95, 0.9, 0.45833333333333
25744, 1.95, 0.85, 0.45833333333333
25745, 1.95, 0.8, 0.45833333333333
25746, 1.95, 0.75, 0.45833333333333
25747, 1.95, 0.7, 0.45833333333333
25748, 1.95, 0.65, 0.45833333333333
25749, 1.95, 0.6, 0.45833333333333
25750, 1.95, 0.55, 0.45833333333333
25751, 1.95, 0.5, 0.45833333333333
25752, 1.95, 0.45, 0.45833333333333
25753, 1.95, 0.4, 0.45833333333333
25754, 1.95, 0.35, 0.45833333333333
25755, 1.95, 0.3, 0.45833333333333
25756, 1.95, 0.25, 0.45833333333333
25757, 1.95, 0.2, 0.45833333333333
25758, 1.9916666666667, 1.3, 0.45833333333333
25759, 1.9916666666667, 1.25, 0.45833333333333
25760, 1.9916666666667, 1.2, 0.45833333333333
25761, 1.9916666666667, 1.15, 0.45833333333333
25762, 1.9916666666667, 1.1, 0.45833333333333
25763, 1.9916666666667, 1.05, 0.45833333333333
25764, 1.9916666666667, 1, 0.45833333333333
25765, 1.9916666666667, 0.95, 0.45833333333333
25766, 1.9916666666667, 0.9, 0.45833333333333
25767, 1.9916666666667, 0.85, 0.45833333333333
25768, 1.9916666666667, 0.8, 0.45833333333333
25769, 1.9916666666667, 0.75, 0.45833333333333
25770, 1.9916666666667, 0.7, 0.45833333333333
25771, 1.9916666666667, 0.65, 0.45833333333333
25772, 1.9916666666667, 0.6, 0.45833333333333
25773, 1.9916666666667, 0.55, 0.45833333333333
25774, 1.9916666666667, 0.5, 0.45833333333333
25775, 1.9916666666667, 0.45, 0.45833333333333
25776, 1.9916666666667, 0.4, 0.45833333333333
25777, 1.9916666666667, 0.35, 0.45833333333333
25778, 1.9916666666667, 0.3, 0.45833333333333
25779, 1.9916666666667, 0.25, 0.45833333333333
25780, 1.9916666666667, 0.2, 0.45833333333333
25781, 2.0333333333333, 1.3, 0.45833333333333
25782, 2.0333333333333, 1.25, 0.45833333333333
25783, 2.0333333333333, 1.2, 0.45833333333333
25784, 2.0333333333333, 1.15, 0.45833333333333
25785, 2.0333333333333, 1.1, 0.45833333333333
25786, 2.0333333333333, 1.05, 0.45833333333333
25787, 2.0333333333333, 1, 0.45833333333333
25788, 2.0333333333333, 0.95, 0.45833333333333
25789, 2.0333333333333, 0.9, 0.45833333333333
25790, 2.0333333333333, 0.85, 0.45833333333333
25791, 2.0333333333333, 0.8, 0.45833333333333
25792, 2.0333333333333, 0.75, 0.45833333333333
25793, 2.0333333333333, 0.7, 0.45833333333333
25794, 2.0333333333333, 0.65, 0.45833333333333
25795, 2.0333333333333, 0.6, 0.45833333333333
25796, 2.0333333333333, 0.55, 0.45833333333333
25797, 2.0333333333333, 0.5, 0.45833333333333
25798, 2.0333333333333, 0.45, 0.45833333333333
25799, 2.0333333333333, 0.4, 0.45833333333333
25800, 2.0333333333333, 0.35, 0.45833333333333
25801, 2.0333333333333, 0.3, 0.45833333333333
25802, 2.0333333333333, 0.25, 0.45833333333333
25803, 2.0333333333333, 0.2, 0.45833333333333
25804, 2.075, 1.3, 0.45833333333333
25805, 2.075, 1.25, 0.45833333333333
25806, 2.075, 1.2, 0.45833333333333
25807, 2.075, 1.15, 0.45833333333333
25808, 2.075, 1.1, 0.45833333333333
25809, 2.075, 1.05, 0.45833333333333
25810, 2.075, 1, 0.45833333333333
25811, 2.075, 0.95, 0.45833333333333
25812, 2.075, 0.9, 0.45833333333333
25813, 2.075, 0.85, 0.45833333333333
25814, 2.075, 0.8, 0.45833333333333
25815, 2.075, 0.75, 0.45833333333333
25816, 2.075, 0.7, 0.45833333333333
25817, 2.075, 0.65, 0.45833333333333
25818, 2.075, 0.6, 0.45833333333333
25819, 2.075, 0.55, 0.45833333333333
25820, 2.075, 0.5, 0.45833333333333
25821, 2.075, 0.45, 0.45833333333333
25822, 2.075, 0.4, 0.45833333333333
25823, 2.075, 0.35, 0.45833333333333
25824, 2.075, 0.3, 0.45833333333333
25825, 2.075, 0.25, 0.45833333333333
25826, 2.075, 0.2, 0.45833333333333
25827, 2.1166666666667, 1.3, 0.45833333333333
25828, 2.1166666666667, 1.25, 0.45833333333333
25829, 2.1166666666667, 1.2, 0.45833333333333
25830, 2.1166666666667, 1.15, 0.45833333333333
25831, 2.1166666666667, 1.1, 0.45833333333333
25832, 2.1166666666667, 1.05, 0.45833333333333
25833, 2.1166666666667, 1, 0.45833333333333
25834, 2.1166666666667, 0.95, 0.45833333333333
25835, 2.1166666666667, 0.9, 0.45833333333333
25836, 2.1166666666667, 0.85, 0.45833333333333
25837, 2.1166666666667, 0.8, 0.45833333333333
25838, 2.1166666666667, 0.75, 0.45833333333333
25839, 2.1166666666667, 0.7, 0.45833333333333
25840, 2.1166666666667, 0.65, 0.45833333333333
25841, 2.1166666666667, 0.6, 0.45833333333333
25842, 2.1166666666667, 0.55, 0.45833333333333
25843, 2.1166666666667, 0.5, 0.45833333333333
25844, 2.1166666666667, 0.45, 0.45833333333333
25845, 2.1166666666667, 0.4, 0.45833333333333
25846, 2.1166666666667, 0.35, 0.45833333333333
25847, 2.1166666666667, 0.3, 0.45833333333333
25848, 2.1166666666667, 0.25, 0.45833333333333
25849, 2.1166666666667, 0.2, 0.45833333333333
25850, 2.1583333333333, 1.3, 0.45833333333333
25851, 2.1583333333333, 1.25, 0.45833333333333
25852, 2.1583333333333, 1.2, 0.45833333333333
25853, 2.1583333333333, 1.15, 0.45833333333333
25854, 2.1583333333333, 1.1, 0.45833333333333
25855, 2.1583333333333, 1.05, 0.45833333333333
25856, 2.1583333333333, 1, 0.45833333333333
25857, 2.1583333333333, 0.95, 0.45833333333333
25858, 2.1583333333333, 0.9, 0.45833333333333
25859, 2.1583333333333, 0.85, 0.45833333333333
25860, 2.1583333333333, 0.8, 0.45833333333333
25861, 2.1583333333333, 0.75, 0.45833333333333
25862, 2.1583333333333, 0.7, 0.45833333333333
25863, 2.1583333333333, 0.65, 0.45833333333333
25864, 2.1583333333333, 0.6, 0.45833333333333
25865, 2.1583333333333, 0.55, 0.45833333333333
25866, 2.1583333333333, 0.5, 0.45833333333333
25867, 2.1583333333333, 0.45, 0.45833333333333
25868, 2.1583333333333, 0.4, 0.45833333333333
25869, 2.1583333333333, 0.35, 0.45833333333333
25870, 2.1583333333333, 0.3, 0.45833333333333
25871, 2.1583333333333, 0.25, 0.45833333333333
25872, 2.1583333333333, 0.2, 0.45833333333333
25873, 1.2416666666667, 0.066666666666667, 0.041666666666667
25874, 1.2416666666667, 0.033333333333333, 0.041666666666667
25875, 1.2833333333333, 0.066666666666667, 0.041666666666667
25876, 1.2833333333333, 0.033333333333333, 0.041666666666667
25877, 1.325, 0.066666666666667, 0.041666666666667
25878, 1.325, 0.033333333333333, 0.041666666666667
25879, 1.3666666666667, 0.066666666666667, 0.041666666666667
25880, 1.3666666666667, 0.033333333333333, 0.041666666666667
25881, 1.4083333333333, 0.066666666666667, 0.041666666666667
25882, 1.4083333333333, 0.033333333333333, 0.041666666666667
25883, 1.45, 0.066666666666667, 0.041666666666667
25884, 1.45, 0.033333333333333, 0.041666666666667
25885, 1.4916666666667, 0.066666666666667, 0.041666666666667
25886, 1.4916666666667, 0.033333333333333, 0.041666666666667
25887, 1.5333333333333, 0.066666666666667, 0.041666666666667
25888, 1.5333333333333, 0.033333333333333, 0.041666666666667
25889, 1.575, 0.066666666666667, 0.041666666666667
25890, 1.575, 0.033333333333333, 0.041666666666667
25891, 1.6166666666667, 0.066666666666667, 0.041666666666667
25892, 1.6166666666667, 0.033333333333333, 0.041666666666667
25893, 1.6583333333333, 0.066666666666667, 0.041666666666667
25894, 1.6583333333333, 0.033333333333333, 0.041666666666667
25895, 1.7, 0.066666666666667, 0.041666666666667
25896, 1.7, 0.033333333333333, 0.041666666666667
25897, 1.7416666666667, 0.066666666666667, 0.041666666666667
25898, 1.7416666666667, 0.033333333333333, 0.041666666666667
25899, 1.7833333333333, 0.066666666666667, 0.041666666666667
25900, 1.7833333333333, 0.033333333333333, 0.041666666666667
25901, 1.825, 0.066666666666667, 0.041666666666667
25902, 1.825, 0.033333333333333, 0.041666666666667
25903, 1.8666666666667, 0.066666666666667, 0.041666666666667
25904, 1.8666666666667, 0.033333333333333, 0.041666666666667
25905, 1.9083333333333, 0.066666666666667, 0.041666666666667
25906, 1.9083333333333, 0.033333333333333, 0.041666666666667
25907, 1.95, 0.066666666666667, 0.041666666666667
25908, 1.95, 0.033333333333333, 0.041666666666667
25909, 1.9916666666667, 0.066666666666667, 0.041666666666667
25910, 1.9916666666667, 0.033333333333333, 0.041666666666667
25911, 2.0333333333333, 0.066666666666667, 0.041666666666667
25912, 2.0333333333333, 0.033333333333333, 0.041666666666667
25913, 2.075, 0.066666666666667, 0.041666666666667
25914, 2.075, 0.033333333333333, 0.041666666666667
25915, 2.1166666666667, 0.066666666666667, 0.041666666666667
25916, 2.1166666666667, 0.033333333333333, 0.041666666666667
25917, 2.1583333333333, 0.066666666666667, 0.041666666666667
25918, 2.1583333333333, 0.033333333333333, 0.041666666666667
25919, 1.2416666666667, 0.066666666666667, 0.083333333333333
25920, 1.2416666666667, 0.033333333333333, 0.083333333333333
25921, 1.2833333333333, 0.066666666666667, 0.083333333333333
25922, 1.2833333333333, 0.033333333333333, 0.083333333333333
25923, 1.325, 0.066666666666667, 0.083333333333333
25924, 1.325, 0.033333333333333, 0.083333333333333
25925, 1.3666666666667, 0.066666666666667, 0.083333333333333
25926, 1.3666666666667, 0.033333333333333, 0.083333333333333
25927, 1.4083333333333, 0.066666666666667, 0.083333333333333
25928, 1.4083333333333, 0.033333333333333, 0.083333333333333
25929, 1.45, 0.066666666666667, 0.083333333333333
25930, 1.45, 0.033333333333333, 0.083333333333333
25931, 1.4916666666667, 0.066666666666667, 0.083333333333333
25932, 1.4916666666667, 0.033333333333333, 0.083333333333333
25933, 1.5333333333333, 0.066666666666667, 0.083333333333333
25934, 1.5333333333333, 0.033333333333333, 0.083333333333333
25935, 1.575, 0.066666666666667, 0.083333333333333
25936, 1.575, 0.033333333333333, 0.083333333333333
25937, 1.6166666666667, 0.066666666666667, 0.083333333333333
25938, 1.6166666666667, 0.033333333333333, 0.083333333333333
25939, 1.6583333333333, 0.066666666666667, 0.083333333333333
25940, 1.6583333333333, 0.033333333333333, 0.083333333333333
25941, 1.7, 0.066666666666667, 0.083333333333333
25942, 1.7, 0.033333333333333, 0.083333333333333
25943, 1.7416666666667, 0.066666666666667, 0.083333333333333
25944, 1.7416666666667, 0.033333333333333, 0.083333333333333
25945, 1.7833333333333, 0.066666666666667, 0.083333333333333
25946, 1.7833333333333, 0.033333333333333, 0.083333333333333
25947, 1.825, 0.066666666666667, 0.083333333333333
25948, 1.825, 0.033333333333333, 0.083333333333333
25949, 1.8666666666667, 0.066666666666667, 0.083333333333333
25950, 1.8666666666667, 0.033333333333333, 0.083333333333333
25951, 1.9083333333333, 0.066666666666667, 0.083333333333333
25952, 1.9083333333333, 0.033333333333333, 0.083333333333333
25953, 1.95, 0.066666666666667, 0.083333333333333
25954, 1.95, 0.033333333333333, 0.083333333333333
25955, 1.9916666666667, 0.066666666666667, 0.083333333333333
25956, 1.9916666666667, 0.033333333333333, 0.083333333333333
25957, 2.0333333333333, 0.066666666666667, 0.083333333333333
25958, 2.0333333333333, 0.033333333333333, 0.083333333333333
25959, 2.075, 0.066666666666667, 0.083333333333333
25960, 2.075, 0.033333333333333, 0.083333333333333
25961, 2.1166666666667, 0.066666666666667, 0.083333333333333
25962, 2.1166666666667, 0.033333333333333, 0.083333333333333
25963, 2.1583333333333, 0.066666666666667, 0.083333333333333
25964, 2.1583333333333, 0.033333333333333, 0.083333333333333
25965, 1.2416666666667, 0.066666666666667, 0.125
25966, 1.2416666666667, 0.033333333333333, 0.125
25967, 1.2833333333333, 0.066666666666667, 0.125
25968, 1.2833333333333, 0.033333333333333, 0.125
25969, 1.325, 0.066666666666667, 0.125
25970, 1.325, 0.033333333333333, 0.125
25971, 1.3666666666667, 0.066666666666667, 0.125
25972, 1.3666666666667, 0.033333333333333, 0.125
25973, 1.4083333333333, 0.066666666666667, 0.125
25974, 1.4083333333333, 0.033333333333333, 0.125
25975, 1.45, 0.066666666666667, 0.125
25976, 1.45, 0.033333333333333, 0.125
25977, 1.4916666666667, 0.066666666666667, 0.125
25978, 1.4916666666667, 0.033333333333333, 0.125
25979, 1.5333333333333, 0.066666666666667, 0.125
25980, 1.5333333333333, 0.033333333333333, 0.125
25981, 1.575, 0.066666666666667, 0.125
25982, 1.575, 0.033333333333333, 0.125
25983, 1.6166666666667, 0.066666666666667, 0.125
25984, 1.6166666666667, 0.033333333333333, 0.125
25985, 1.6583333333333, 0.066666666666667, 0.125
25986, 1.6583333333333, 0.033333333333333, 0.125
25987, 1.7, 0.066666666666667, 0.125
25988, 1.7, 0.033333333333333, 0.125
25989, 1.7416666666667, 0.066666666666667, 0.125
25990, 1.7416666666667, 0.033333333333333, 0.125
25991, 1.7833333333333, 0.066666666666667, 0.125
25992, 1.7833333333333, 0.033333333333333, 0.125
25993, 1.825, 0.066666666666667, 0.125
25994, 1.825, 0.033333333333333, 0.125
25995, 1.8666666666667, 0.066666666666667, 0.125
25996, 1.8666666666667, 0.033333333333333, 0.125
25997, 1.9083333333333, 0.066666666666667, 0.125
25998, 1.9083333333333, 0.033333333333333, 0.125
25999, 1.95, 0.066666666666667, 0.125
26000, 1.95, 0.033333333333333, 0.125
26001, 1.9916666666667, 0.066666666666667, 0.125
26002, 1.9916666666667, 0.033333333333333, 0.125
26003, 2.0333333333333, 0.066666666666667, 0.125
26004, 2.0333333333333, 0.033333333333333, 0.125
26005, 2.075, 0.066666666666667, 0.125
26006, 2.075, 0.033333333333333, 0.125
26007, 2.1166666666667, 0.066666666666667, 0.125
26008, 2.1166666666667, 0.033333333333333, 0.125
26009, 2.1583333333333, 0.066666666666667, 0.125
26010, 2.1583333333333, 0.033333333333333, 0.125
26011, 1.2416666666667, 0.066666666666667, 0.16666666666667
26012, 1.2416666666667, 0.033333333333333, 0.16666666666667
26013, 1.2833333333333, 0.066666666666667, 0.16666666666667
26014, 1.2833333333333, 0.033333333333333, 0.16666666666667
26015, 1.325, 0.066666666666667, 0.16666666666667
26016, 1.325, 0.033333333333333, 0.16666666666667
26017, 1.3666666666667, 0.066666666666667, 0.16666666666667
26018, 1.3666666666667, 0.033333333333333, 0.16666666666667
26019, 1.4083333333333, 0.066666666666667, 0.16666666666667
26020, 1.4083333333333, 0.033333333333333, 0.16666666666667
26021, 1.45, 0.066666666666667, 0.16666666666667
26022, 1.45, 0.033333333333333, 0.16666666666667
26023, 1.4916666666667, 0.066666666666667, 0.16666666666667
26024, 1.4916666666667, 0.033333333333333, 0.16666666666667
26025, 1.5333333333333, 0.066666666666667, 0.16666666666667
26026, 1.5333333333333, 0.033333333333333, 0.16666666666667
26027, 1.575, 0.066666666666667, 0.16666666666667
26028, 1.575, 0.033333333333333, 0.16666666666667
26029, 1.6166666666667, 0.066666666666667, 0.16666666666667
26030, 1.6166666666667, 0.033333333333333, 0.16666666666667
26031, 1.6583333333333, 0.066666666666667, 0.16666666666667
26032, 1.6583333333333, 0.033333333333333, 0.16666666666667
26033, 1.7, 0.066666666666667, 0.16666666666667
26034, 1.7, 0.033333333333333, 0.16666666666667
26035, 1.7416666666667, 0.066666666666667, 0.16666666666667
26036, 1.7416666666667, 0.033333333333333, 0.16666666666667
26037, 1.7833333333333, 0.066666666666667, 0.16666666666667
26038, 1.7833333333333, 0.033333333333333, 0.16666666666667
26039, 1.825, 0.066666666666667, 0.16666666666667
26040, 1.825, 0.033333333333333, 0.16666666666667
26041, 1.8666666666667, 0.066666666666667, 0.16666666666667
26042, 1.8666666666667, 0.033333333333333, 0.16666666666667
26043, 1.9083333333333, 0.066666666666667, 0.16666666666667
26044, 1.9083333333333, 0.033333333333333, 0.16666666666667
26045, 1.95, 0.066666666666667, 0.16666666666667
26046, 1.95, 0.033333333333333, 0.16666666666667
26047, 1.9916666666667, 0.066666666666667, 0.16666666666667
26048, 1.9916666666667, 0.033333333333333, 0.16666666666667
26049, 2.0333333333333, 0.066666666666667, 0.16666666666667
26050, 2.0333333333333, 0.033333333333333, 0.16666666666667
26051, 2.075, 0.066666666666667, 0.16666666666667
26052, 2.075, 0.033333333333333, 0.16666666666667
26053, 2.1166666666667, 0.066666666666667, 0.16666666666667
26054, 2.1166666666667, 0.033333333333333, 0.16666666666667
26055, 2.1583333333333, 0.066666666666667, 0.16666666666667
26056, 2.1583333333333, 0.033333333333333, 0.16666666666667
26057, 1.2416666666667, 0.066666666666667, 0.20833333333333
26058, 1.2416666666667, 0.033333333333333, 0.20833333333333
26059, 1.2833333333333, 0.066666666666667, 0.20833333333333
26060, 1.2833333333333, 0.033333333333333, 0.20833333333333
26061, 1.325, 0.066666666666667, 0.20833333333333
26062, 1.325, 0.033333333333333, 0.20833333333333
26063, 1.3666666666667, 0.066666666666667, 0.20833333333333
26064, 1.3666666666667, 0.033333333333333, 0.20833333333333
26065, 1.4083333333333, 0.066666666666667, 0.20833333333333
26066, 1.4083333333333, 0.033333333333333, 0.20833333333333
26067, 1.45, 0.066666666666667, 0.20833333333333
26068, 1.45, 0.033333333333333, 0.20833333333333
26069, 1.4916666666667, 0.066666666666667, 0.20833333333333
26070, 1.4916666666667, 0.033333333333333, 0.20833333333333
26071, 1.5333333333333, 0.066666666666667, 0.20833333333333
26072, 1.5333333333333, 0.033333333333333, 0.20833333333333
26073, 1.575, 0.066666666666667, 0.20833333333333
26074, 1.575, 0.033333333333333, 0.20833333333333
26075, 1.6166666666667, 0.066666666666667, 0.20833333333333
26076, 1.6166666666667, 0.033333333333333, 0.20833333333333
26077, 1.6583333333333, 0.066666666666667, 0.20833333333333
26078, 1.6583333333333, 0.033333333333333, 0.20833333333333
26079, 1.7, 0.066666666666667, 0.20833333333333
26080, 1.7, 0.033333333333333, 0.20833333333333
26081, 1.7416666666667, 0.066666666666667, 0.20833333333333
26082, 1.7416666666667, 0.033333333333333, 0.20833333333333
26083, 1.7833333333333, 0.066666666666667, 0.20833333333333
26084, 1.7833333333333, 0.033333333333333, 0.20833333333333
26085, 1.825, 0.066666666666667, 0.20833333333333
26086, 1.825, 0.033333333333333, 0.20833333333333
26087, 1.8666666666667, 0.066666666666667, 0.20833333333333
26088, 1.8666666666667, 0.033333333333333, 0.20833333333333
26089, 1.9083333333333, 0.066666666666667, 0.20833333333333
26090, 1.9083333333333, 0.033333333333333, 0.20833333333333
26091, 1.95, 0.066666666666667, 0.20833333333333
26092, 1.95, 0.033333333333333, 0.20833333333333
26093, 1.9916666666667, 0.066666666666667, 0.20833333333333
26094, 1.9916666666667, 0.033333333333333, 0.20833333333333
26095, 2.0333333333333, 0.066666666666667, 0.20833333333333
26096, 2.0333333333333, 0.033333333333333, 0.20833333333333
26097, 2.075, 0.066666666666667, 0.20833333333333
26098, 2.075, 0.033333333333333, 0.20833333333333
26099, 2.1166666666667, 0.066666666666667, 0.20833333333333
26100, 2.1166666666667, 0.033333333333333, 0.20833333333333
26101, 2.1583333333333, 0.066666666666667, 0.20833333333333
26102, 2.1583333333333, 0.033333333333333, 0.20833333333333
26103, 1.2416666666667, 0.066666666666667, 0.25
26104, 1.2416666666667, 0.033333333333333, 0.25
26105, 1.2833333333333, 0.066666666666667, 0.25
26106, 1.2833333333333, 0.033333333333333, 0.25
26107, 1.325, 0.066666666666667, 0.25
26108, 1.325, 0.033333333333333, 0.25
26109, 1.3666666666667, 0.066666666666667, 0.25
26110, 1.3666666666667, 0.033333333333333, 0.25
26111, 1.4083333333333, 0.066666666666667, 0.25
26112, 1.4083333333333, 0.033333333333333, 0.25
26113, 1.45, 0.066666666666667, 0.25
26114, 1.45, 0.033333333333333, 0.25
26115, 1.4916666666667, 0.066666666666667, 0.25
26116, 1.4916666666667, 0.033333333333333, 0.25
26117, 1.5333333333333, 0.066666666666667, 0.25
26118, 1.5333333333333, 0.033333333333333, 0.25
26119, 1.575, 0.066666666666667, 0.25
26120, 1.575, 0.033333333333333, 0.25
26121, 1.6166666666667, 0.066666666666667, 0.25
26122, 1.6166666666667, 0.033333333333333, 0.25
26123, 1.6583333333333, 0.066666666666667, 0.25
26124, 1.6583333333333, 0.033333333333333, 0.25
26125, 1.7, 0.066666666666667, 0.25
26126, 1.7, 0.033333333333333, 0.25
26127, 1.7416666666667, 0.066666666666667, 0.25
26128, 1.7416666666667, 0.033333333333333, 0.25
26129, 1.7833333333333, 0.066666666666667, 0.25
26130, 1.7833333333333, 0.033333333333333, 0.25
26131, 1.825, 0.066666666666667, 0.25
26132, 1.825, 0.033333333333333, 0.25
26133, 1.8666666666667, 0.066666666666667, 0.25
26134, 1.8666666666667, 0.033333333333333, 0.25
26135, 1.9083333333333, 0.066666666666667, 0.25
26136, 1.9083333333333, 0.033333333333333, 0.25
26137, 1.95, 0.066666666666667, 0.25
26138, 1.95, 0.033333333333333, 0.25
26139, 1.9916666666667, 0.066666666666667, 0.25
26140, 1.9916666666667, 0.033333333333333, 0.25
26141, 2.0333333333333, 0.066666666666667, 0.25
26142, 2.0333333333333, 0.033333333333333, 0.25
26143, 2.075, 0.066666666666667, 0.25
26144, 2.075, 0.033333333333333, 0.25
26145, 2.1166666666667, 0.066666666666667, 0.25
26146, 2.1166666666667, 0.033333333333333, 0.25
26147, 2.1583333333333, 0.066666666666667, 0.25
26148, 2.1583333333333, 0.033333333333333, 0.25
26149, 1.2416666666667, 0.066666666666667, 0.29166666666667
26150, 1.2416666666667, 0.033333333333333, 0.29166666666667
26151, 1.2833333333333, 0.066666666666667, 0.29166666666667
26152, 1.2833333333333, 0.033333333333333, 0.29166666666667
26153, 1.325, 0.066666666666667, 0.29166666666667
26154, 1.325, 0.033333333333333, 0.29166666666667
26155, 1.3666666666667, 0.066666666666667, 0.29166666666667
26156, 1.3666666666667, 0.033333333333333, 0.29166666666667
26157, 1.4083333333333, 0.066666666666667, 0.29166666666667
26158, 1.4083333333333, 0.033333333333333, 0.29166666666667
26159, 1.45, 0.066666666666667, 0.29166666666667
26160, 1.45, 0.033333333333333, 0.29166666666667
26161, 1.4916666666667, 0.066666666666667, 0.29166666666667
26162, 1.4916666666667, 0.033333333333333, 0.29166666666667
26163, 1.5333333333333, 0.066666666666667, 0.29166666666667
26164, 1.5333333333333, 0.033333333333333, 0.29166666666667
26165, 1.575, 0.066666666666667, 0.29166666666667
26166, 1.575, 0.033333333333333, 0.29166666666667
26167, 1.6166666666667, 0.066666666666667, 0.29166666666667
26168, 1.6166666666667, 0.033333333333333, 0.29166666666667
26169, 1.6583333333333, 0.066666666666667, 0.29166666666667
26170, 1.6583333333333, 0.033333333333333, 0.29166666666667
26171, 1.7, 0.066666666666667, 0.29166666666667
26172, 1.7, 0.033333333333333, 0.29166666666667
26173, 1.7416666666667, 0.066666666666667, 0.29166666666667
26174, 1.7416666666667, 0.033333333333333, 0.29166666666667
26175, 1.7833333333333, 0.066666666666667, 0.29166666666667
26176, 1.7833333333333, 0.033333333333333, 0.29166666666667
26177, 1.825, 0.066666666666667, 0.29166666666667
26178, 1.825, 0.033333333333333, 0.29166666666667
26179, 1.8666666666667, 0.066666666666667, 0.29166666666667
26180, 1.8666666666667, 0.033333333333333, 0.29166666666667
26181, 1.9083333333333, 0.066666666666667, 0.29166666666667
26182, 1.9083333333333, 0.033333333333333, 0.29166666666667
26183, 1.95, 0.066666666666667, 0.29166666666667
26184, 1.95, 0.033333333333333, 0.29166666666667
26185, 1.9916666666667, 0.066666666666667, 0.29166666666667
26186, 1.9916666666667, 0.033333333333333, 0.29166666666667
26187, 2.0333333333333, 0.066666666666667, 0.29166666666667
26188, 2.0333333333333, 0.033333333333333, 0.29166666666667
26189, 2.075, 0.066666666666667, 0.29166666666667
26190, 2.075, 0.033333333333333, 0.29166666666667
26191, 2.1166666666667, 0.066666666666667, 0.29166666666667
26192, 2.1166666666667, 0.033333333333333, 0.29166666666667
26193, 2.1583333333333, 0.066666666666667, 0.29166666666667
26194, 2.1583333333333, 0.033333333333333, 0.29166666666667
26195, 1.2416666666667, 0.066666666666667, 0.33333333333333
26196, 1.2416666666667, 0.033333333333333, 0.33333333333333
26197, 1.2833333333333, 0.066666666666667, 0.33333333333333
26198, 1.2833333333333, 0.033333333333333, 0.33333333333333
26199, 1.325, 0.066666666666667, 0.33333333333333
26200, 1.325, 0.033333333333333, 0.33333333333333
26201, 1.3666666666667, 0.066666666666667, 0.33333333333333
26202, 1.3666666666667, 0.033333333333333, 0.33333333333333
26203, 1.4083333333333, 0.066666666666667, 0.33333333333333
26204, 1.4083333333333, 0.033333333333333, 0.33333333333333
26205, 1.45, 0.066666666666667, 0.33333333333333
26206, 1.45, 0.033333333333333, 0.33333333333333
26207, 1.4916666666667, 0.066666666666667, 0.33333333333333
26208, 1.4916666666667, 0.033333333333333, 0.33333333333333
26209, 1.5333333333333, 0.066666666666667, 0.33333333333333
26210, 1.5333333333333, 0.033333333333333, 0.33333333333333
26211, 1.575, 0.066666666666667, 0.33333333333333
26212, 1.575, 0.033333333333333, 0.33333333333333
26213, 1.6166666666667, 0.066666666666667, 0.33333333333333
26214, 1.6166666666667, 0.033333333333333, 0.33333333333333
26215, 1.6583333333333, 0.066666666666667, 0.33333333333333
26216, 1.6583333333333, 0.033333333333333, 0.33333333333333
26217, 1.7, 0.066666666666667, 0.33333333333333
26218, 1.7, 0.033333333333333, 0.33333333333333
26219, 1.7416666666667, 0.066666666666667, 0.33333333333333
26220, 1.7416666666667, 0.033333333333333, 0.33333333333333
26221, 1.7833333333333, 0.066666666666667, 0.33333333333333
26222, 1.7833333333333, 0.033333333333333, 0.33333333333333
26223, 1.825, 0.066666666666667, 0.33333333333333
26224, 1.825, 0.033333333333333, 0.33333333333333
26225, 1.8666666666667, 0.066666666666667, 0.33333333333333
26226, 1.8666666666667, 0.033333333333333, 0.33333333333333
26227, 1.9083333333333, 0.066666666666667, 0.33333333333333
26228, 1.9083333333333, 0.033333333333333, 0.33333333333333
26229, 1.95, 0.066666666666667, 0.33333333333333
26230, 1.95, 0.033333333333333, 0.33333333333333
26231, 1.9916666666667, 0.066666666666667, 0.33333333333333
26232, 1.9916666666667, 0.033333333333333, 0.33333333333333
26233, 2.0333333333333, 0.066666666666667, 0.33333333333333
26234, 2.0333333333333, 0.033333333333333, 0.33333333333333
26235, 2.075, 0.066666666666667, 0.33333333333333
26236, 2.075, 0.033333333333333, 0.33333333333333
26237, 2.1166666666667, 0.066666666666667, 0.33333333333333
26238, 2.1166666666667, 0.033333333333333, 0.33333333333333
26239, 2.1583333333333, 0.066666666666667, 0.33333333333333
26240, 2.1583333333333, 0.033333333333333, 0.33333333333333
26241, 1.2416666666667, 0.066666666666667, 0.375
26242, 1.2416666666667, 0.033333333333333, 0.375
26243, 1.2833333333333, 0.066666666666667, 0.375
26244, 1.2833333333333, 0.033333333333333, 0.375
26245, 1.325, 0.066666666666667, 0.375
26246, 1.325, 0.033333333333333, 0.375
26247, 1.3666666666667, 0.066666666666667, 0.375
26248, 1.3666666666667, 0.033333333333333, 0.375
26249, 1.4083333333333, 0.066666666666667, 0.375
26250, 1.4083333333333, 0.033333333333333, 0.375
26251, 1.45, 0.066666666666667, 0.375
26252, 1.45, 0.033333333333333, 0.375
