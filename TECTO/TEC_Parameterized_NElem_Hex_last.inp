13338, 18846, 18869, 3537, 3514, 18847, 18870, 3538, 3515
13339, 18847, 18870, 3538, 3515, 18848, 18871, 3539, 3516
13340, 18848, 18871, 3539, 3516, 18849, 18872, 3540, 3517
13341, 18849, 18872, 3540, 3517, 18850, 18873, 3541, 3518
13342, 18850, 18873, 3541, 3518, 18851, 18874, 3542, 3519
13343, 18851, 18874, 3542, 3519, 18852, 18875, 3543, 3520
13344, 18852, 18875, 3543, 3520, 18853, 18876, 3544, 3521
13345, 18853, 18876, 3544, 3521, 18854, 18877, 3545, 3522
13346, 18854, 18877, 3545, 3522, 18855, 18878, 3546, 3523
13347, 18855, 18878, 3546, 3523, 18856, 18879, 3547, 3524
13348, 18856, 18879, 3547, 3524, 18857, 18880, 3548, 3525
13349, 18857, 18880, 3548, 3525, 18858, 18881, 3549, 3526
13350, 18858, 18881, 3549, 3526, 18859, 18882, 3550, 3527
13351, 18859, 18882, 3550, 3527, 18860, 18883, 3551, 3528
13352, 18860, 18883, 3551, 3528, 18861, 18884, 3552, 3529
13353, 18861, 18884, 3552, 3529, 4652, 4653, 408, 407
13354, 2836, 2837, 272, 271, 18862, 18885, 3553, 3530
13355, 18862, 18885, 3553, 3530, 18863, 18886, 3554, 3531
13356, 18863, 18886, 3554, 3531, 18864, 18887, 3555, 3532
13357, 18864, 18887, 3555, 3532, 18865, 18888, 3556, 3533
13358, 18865, 18888, 3556, 3533, 18866, 18889, 3557, 3534
13359, 18866, 18889, 3557, 3534, 18867, 18890, 3558, 3535
13360, 18867, 18890, 3558, 3535, 18868, 18891, 3559, 3536
13361, 18868, 18891, 3559, 3536, 18869, 18892, 3560, 3537
13362, 18869, 18892, 3560, 3537, 18870, 18893, 3561, 3538
13363, 18870, 18893, 3561, 3538, 18871, 18894, 3562, 3539
13364, 18871, 18894, 3562, 3539, 18872, 18895, 3563, 3540
13365, 18872, 18895, 3563, 3540, 18873, 18896, 3564, 3541
13366, 18873, 18896, 3564, 3541, 18874, 18897, 3565, 3542
13367, 18874, 18897, 3565, 3542, 18875, 18898, 3566, 3543
13368, 18875, 18898, 3566, 3543, 18876, 18899, 3567, 3544
13369, 18876, 18899, 3567, 3544, 18877, 18900, 3568, 3545
13370, 18877, 18900, 3568, 3545, 18878, 18901, 3569, 3546
13371, 18878, 18901, 3569, 3546, 18879, 18902, 3570, 3547
13372, 18879, 18902, 3570, 3547, 18880, 18903, 3571, 3548
13373, 18880, 18903, 3571, 3548, 18881, 18904, 3572, 3549
13374, 18881, 18904, 3572, 3549, 18882, 18905, 3573, 3550
13375, 18882, 18905, 3573, 3550, 18883, 18906, 3574, 3551
13376, 18883, 18906, 3574, 3551, 18884, 18907, 3575, 3552
13377, 18884, 18907, 3575, 3552, 4653, 4654, 409, 408
13378, 2837, 2838, 273, 272, 18885, 18908, 3576, 3553
13379, 18885, 18908, 3576, 3553, 18886, 18909, 3577, 3554
13380, 18886, 18909, 3577, 3554, 18887, 18910, 3578, 3555
13381, 18887, 18910, 3578, 3555, 18888, 18911, 3579, 3556
13382, 18888, 18911, 3579, 3556, 18889, 18912, 3580, 3557
13383, 18889, 18912, 3580, 3557, 18890, 18913, 3581, 3558
13384, 18890, 18913, 3581, 3558, 18891, 18914, 3582, 3559
13385, 18891, 18914, 3582, 3559, 18892, 18915, 3583, 3560
13386, 18892, 18915, 3583, 3560, 18893, 18916, 3584, 3561
13387, 18893, 18916, 3584, 3561, 18894, 18917, 3585, 3562
13388, 18894, 18917, 3585, 3562, 18895, 18918, 3586, 3563
13389, 18895, 18918, 3586, 3563, 18896, 18919, 3587, 3564
13390, 18896, 18919, 3587, 3564, 18897, 18920, 3588, 3565
13391, 18897, 18920, 3588, 3565, 18898, 18921, 3589, 3566
13392, 18898, 18921, 3589, 3566, 18899, 18922, 3590, 3567
13393, 18899, 18922, 3590, 3567, 18900, 18923, 3591, 3568
13394, 18900, 18923, 3591, 3568, 18901, 18924, 3592, 3569
13395, 18901, 18924, 3592, 3569, 18902, 18925, 3593, 3570
13396, 18902, 18925, 3593, 3570, 18903, 18926, 3594, 3571
13397, 18903, 18926, 3594, 3571, 18904, 18927, 3595, 3572
13398, 18904, 18927, 3595, 3572, 18905, 18928, 3596, 3573
13399, 18905, 18928, 3596, 3573, 18906, 18929, 3597, 3574
13400, 18906, 18929, 3597, 3574, 18907, 18930, 3598, 3575
13401, 18907, 18930, 3598, 3575, 4654, 4655, 410, 409
13402, 2838, 2839, 274, 273, 18908, 18931, 3599, 3576
13403, 18908, 18931, 3599, 3576, 18909, 18932, 3600, 3577
13404, 18909, 18932, 3600, 3577, 18910, 18933, 3601, 3578
13405, 18910, 18933, 3601, 3578, 18911, 18934, 3602, 3579
13406, 18911, 18934, 3602, 3579, 18912, 18935, 3603, 3580
13407, 18912, 18935, 3603, 3580, 18913, 18936, 3604, 3581
13408, 18913, 18936, 3604, 3581, 18914, 18937, 3605, 3582
13409, 18914, 18937, 3605, 3582, 18915, 18938, 3606, 3583
13410, 18915, 18938, 3606, 3583, 18916, 18939, 3607, 3584
13411, 18916, 18939, 3607, 3584, 18917, 18940, 3608, 3585
13412, 18917, 18940, 3608, 3585, 18918, 18941, 3609, 3586
13413, 18918, 18941, 3609, 3586, 18919, 18942, 3610, 3587
13414, 18919, 18942, 3610, 3587, 18920, 18943, 3611, 3588
13415, 18920, 18943, 3611, 3588, 18921, 18944, 3612, 3589
13416, 18921, 18944, 3612, 3589, 18922, 18945, 3613, 3590
13417, 18922, 18945, 3613, 3590, 18923, 18946, 3614, 3591
13418, 18923, 18946, 3614, 3591, 18924, 18947, 3615, 3592
13419, 18924, 18947, 3615, 3592, 18925, 18948, 3616, 3593
13420, 18925, 18948, 3616, 3593, 18926, 18949, 3617, 3594
13421, 18926, 18949, 3617, 3594, 18927, 18950, 3618, 3595
13422, 18927, 18950, 3618, 3595, 18928, 18951, 3619, 3596
13423, 18928, 18951, 3619, 3596, 18929, 18952, 3620, 3597
13424, 18929, 18952, 3620, 3597, 18930, 18953, 3621, 3598
13425, 18930, 18953, 3621, 3598, 4655, 4656, 411, 410
13426, 2839, 297, 11, 274, 18931, 4128, 378, 3599
13427, 18931, 4128, 378, 3599, 18932, 4129, 379, 3600
13428, 18932, 4129, 379, 3600, 18933, 4130, 380, 3601
13429, 18933, 4130, 380, 3601, 18934, 4131, 381, 3602
13430, 18934, 4131, 381, 3602, 18935, 4132, 382, 3603
13431, 18935, 4132, 382, 3603, 18936, 4133, 383, 3604
13432, 18936, 4133, 383, 3604, 18937, 4134, 384, 3605
13433, 18937, 4134, 384, 3605, 18938, 4135, 385, 3606
13434, 18938, 4135, 385, 3606, 18939, 4136, 386, 3607
13435, 18939, 4136, 386, 3607, 18940, 4137, 387, 3608
13436, 18940, 4137, 387, 3608, 18941, 4138, 388, 3609
13437, 18941, 4138, 388, 3609, 18942, 4139, 389, 3610
13438, 18942, 4139, 389, 3610, 18943, 4140, 390, 3611
13439, 18943, 4140, 390, 3611, 18944, 4141, 391, 3612
13440, 18944, 4141, 391, 3612, 18945, 4142, 392, 3613
13441, 18945, 4142, 392, 3613, 18946, 4143, 393, 3614
13442, 18946, 4143, 393, 3614, 18947, 4144, 394, 3615
13443, 18947, 4144, 394, 3615, 18948, 4145, 395, 3616
13444, 18948, 4145, 395, 3616, 18949, 4146, 396, 3617
13445, 18949, 4146, 396, 3617, 18950, 4147, 397, 3618
13446, 18950, 4147, 397, 3618, 18951, 4148, 398, 3619
13447, 18951, 4148, 398, 3619, 18952, 4149, 399, 3620
13448, 18952, 4149, 399, 3620, 18953, 4150, 400, 3621
13449, 18953, 4150, 400, 3621, 4656, 457, 15, 411
*ELEMENT, type=C3D8, ELSET=Volume4
13450, 14, 458, 4404, 355, 18, 526, 4657, 469
13451, 458, 459, 4405, 4404, 526, 527, 4658, 4657
13452, 459, 460, 4406, 4405, 527, 528, 4659, 4658
13453, 460, 461, 4407, 4406, 528, 529, 4660, 4659
13454, 461, 462, 4408, 4407, 529, 530, 4661, 4660
13455, 462, 463, 4409, 4408, 530, 531, 4662, 4661
13456, 463, 464, 4410, 4409, 531, 532, 4663, 4662
13457, 464, 465, 4411, 4410, 532, 533, 4664, 4663
13458, 465, 466, 4412, 4411, 533, 534, 4665, 4664
13459, 466, 467, 4413, 4412, 534, 535, 4666, 4665
13460, 467, 468, 4414, 4413, 535, 536, 4667, 4666
13461, 468, 16, 435, 4414, 536, 20, 503, 4667
13462, 355, 4404, 4415, 356, 469, 4657, 4668, 470
13463, 4404, 4405, 4416, 4415, 4657, 4658, 4669, 4668
13464, 4405, 4406, 4417, 4416, 4658, 4659, 4670, 4669
13465, 4406, 4407, 4418, 4417, 4659, 4660, 4671, 4670
13466, 4407, 4408, 4419, 4418, 4660, 4661, 4672, 4671
13467, 4408, 4409, 4420, 4419, 4661, 4662, 4673, 4672
13468, 4409, 4410, 4421, 4420, 4662, 4663, 4674, 4673
13469, 4410, 4411, 4422, 4421, 4663, 4664, 4675, 4674
13470, 4411, 4412, 4423, 4422, 4664, 4665, 4676, 4675
13471, 4412, 4413, 4424, 4423, 4665, 4666, 4677, 4676
13472, 4413, 4414, 4425, 4424, 4666, 4667, 4678, 4677
13473, 4414, 435, 436, 4425, 4667, 503, 504, 4678
13474, 356, 4415, 4426, 357, 470, 4668, 4679, 471
13475, 4415, 4416, 4427, 4426, 4668, 4669, 4680, 4679
13476, 4416, 4417, 4428, 4427, 4669, 4670, 4681, 4680
13477, 4417, 4418, 4429, 4428, 4670, 4671, 4682, 4681
13478, 4418, 4419, 4430, 4429, 4671, 4672, 4683, 4682
13479, 4419, 4420, 4431, 4430, 4672, 4673, 4684, 4683
13480, 4420, 4421, 4432, 4431, 4673, 4674, 4685, 4684
13481, 4421, 4422, 4433, 4432, 4674, 4675, 4686, 4685
13482, 4422, 4423, 4434, 4433, 4675, 4676, 4687, 4686
13483, 4423, 4424, 4435, 4434, 4676, 4677, 4688, 4687
13484, 4424, 4425, 4436, 4435, 4677, 4678, 4689, 4688
13485, 4425, 436, 437, 4436, 4678, 504, 505, 4689
13486, 357, 4426, 4437, 358, 471, 4679, 4690, 472
13487, 4426, 4427, 4438, 4437, 4679, 4680, 4691, 4690
13488, 4427, 4428, 4439, 4438, 4680, 4681, 4692, 4691
13489, 4428, 4429, 4440, 4439, 4681, 4682, 4693, 4692
13490, 4429, 4430, 4441, 4440, 4682, 4683, 4694, 4693
13491, 4430, 4431, 4442, 4441, 4683, 4684, 4695, 4694
13492, 4431, 4432, 4443, 4442, 4684, 4685, 4696, 4695
13493, 4432, 4433, 4444, 4443, 4685, 4686, 4697, 4696
13494, 4433, 4434, 4445, 4444, 4686, 4687, 4698, 4697
13495, 4434, 4435, 4446, 4445, 4687, 4688, 4699, 4698
13496, 4435, 4436, 4447, 4446, 4688, 4689, 4700, 4699
13497, 4436, 437, 438, 4447, 4689, 505, 506, 4700
13498, 358, 4437, 4448, 359, 472, 4690, 4701, 473
13499, 4437, 4438, 4449, 4448, 4690, 4691, 4702, 4701
13500, 4438, 4439, 4450, 4449, 4691, 4692, 4703, 4702
13501, 4439, 4440, 4451, 4450, 4692, 4693, 4704, 4703
13502, 4440, 4441, 4452, 4451, 4693, 4694, 4705, 4704
13503, 4441, 4442, 4453, 4452, 4694, 4695, 4706, 4705
13504, 4442, 4443, 4454, 4453, 4695, 4696, 4707, 4706
13505, 4443, 4444, 4455, 4454, 4696, 4697, 4708, 4707
13506, 4444, 4445, 4456, 4455, 4697, 4698, 4709, 4708
13507, 4445, 4446, 4457, 4456, 4698, 4699, 4710, 4709
13508, 4446, 4447, 4458, 4457, 4699, 4700, 4711, 4710
13509, 4447, 438, 439, 4458, 4700, 506, 507, 4711
13510, 359, 4448, 4459, 360, 473, 4701, 4712, 474
13511, 4448, 4449, 4460, 4459, 4701, 4702, 4713, 4712
13512, 4449, 4450, 4461, 4460, 4702, 4703, 4714, 4713
13513, 4450, 4451, 4462, 4461, 4703, 4704, 4715, 4714
13514, 4451, 4452, 4463, 4462, 4704, 4705, 4716, 4715
13515, 4452, 4453, 4464, 4463, 4705, 4706, 4717, 4716
13516, 4453, 4454, 4465, 4464, 4706, 4707, 4718, 4717
13517, 4454, 4455, 4466, 4465, 4707, 4708, 4719, 4718
13518, 4455, 4456, 4467, 4466, 4708, 4709, 4720, 4719
13519, 4456, 4457, 4468, 4467, 4709, 4710, 4721, 4720
13520, 4457, 4458, 4469, 4468, 4710, 4711, 4722, 4721
13521, 4458, 439, 440, 4469, 4711, 507, 508, 4722
13522, 360, 4459, 4470, 361, 474, 4712, 4723, 475
13523, 4459, 4460, 4471, 4470, 4712, 4713, 4724, 4723
13524, 4460, 4461, 4472, 4471, 4713, 4714, 4725, 4724
13525, 4461, 4462, 4473, 4472, 4714, 4715, 4726, 4725
13526, 4462, 4463, 4474, 4473, 4715, 4716, 4727, 4726
13527, 4463, 4464, 4475, 4474, 4716, 4717, 4728, 4727
13528, 4464, 4465, 4476, 4475, 4717, 4718, 4729, 4728
13529, 4465, 4466, 4477, 4476, 4718, 4719, 4730, 4729
13530, 4466, 4467, 4478, 4477, 4719, 4720, 4731, 4730
13531, 4467, 4468, 4479, 4478, 4720, 4721, 4732, 4731
13532, 4468, 4469, 4480, 4479, 4721, 4722, 4733, 4732
13533, 4469, 440, 441, 4480, 4722, 508, 509, 4733
13534, 361, 4470, 4481, 362, 475, 4723, 4734, 476
13535, 4470, 4471, 4482, 4481, 4723, 4724, 4735, 4734
13536, 4471, 4472, 4483, 4482, 4724, 4725, 4736, 4735
13537, 4472, 4473, 4484, 4483, 4725, 4726, 4737, 4736
13538, 4473, 4474, 4485, 4484, 4726, 4727, 4738, 4737
13539, 4474, 4475, 4486, 4485, 4727, 4728, 4739, 4738
13540, 4475, 4476, 4487, 4486, 4728, 4729, 4740, 4739
13541, 4476, 4477, 4488, 4487, 4729, 4730, 4741, 4740
13542, 4477, 4478, 4489, 4488, 4730, 4731, 4742, 4741
13543, 4478, 4479, 4490, 4489, 4731, 4732, 4743, 4742
13544, 4479, 4480, 4491, 4490, 4732, 4733, 4744, 4743
13545, 4480, 441, 442, 4491, 4733, 509, 510, 4744
13546, 362, 4481, 4492, 363, 476, 4734, 4745, 477
13547, 4481, 4482, 4493, 4492, 4734, 4735, 4746, 4745
13548, 4482, 4483, 4494, 4493, 4735, 4736, 4747, 4746
13549, 4483, 4484, 4495, 4494, 4736, 4737, 4748, 4747
13550, 4484, 4485, 4496, 4495, 4737, 4738, 4749, 4748
13551, 4485, 4486, 4497, 4496, 4738, 4739, 4750, 4749
13552, 4486, 4487, 4498, 4497, 4739, 4740, 4751, 4750
13553, 4487, 4488, 4499, 4498, 4740, 4741, 4752, 4751
13554, 4488, 4489, 4500, 4499, 4741, 4742, 4753, 4752
13555, 4489, 4490, 4501, 4500, 4742, 4743, 4754, 4753
13556, 4490, 4491, 4502, 4501, 4743, 4744, 4755, 4754
13557, 4491, 442, 443, 4502, 4744, 510, 511, 4755
13558, 363, 4492, 4503, 364, 477, 4745, 4756, 478
13559, 4492, 4493, 4504, 4503, 4745, 4746, 4757, 4756
13560, 4493, 4494, 4505, 4504, 4746, 4747, 4758, 4757
13561, 4494, 4495, 4506, 4505, 4747, 4748, 4759, 4758
13562, 4495, 4496, 4507, 4506, 4748, 4749, 4760, 4759
13563, 4496, 4497, 4508, 4507, 4749, 4750, 4761, 4760
13564, 4497, 4498, 4509, 4508, 4750, 4751, 4762, 4761
13565, 4498, 4499, 4510, 4509, 4751, 4752, 4763, 4762
13566, 4499, 4500, 4511, 4510, 4752, 4753, 4764, 4763
13567, 4500, 4501, 4512, 4511, 4753, 4754, 4765, 4764
13568, 4501, 4502, 4513, 4512, 4754, 4755, 4766, 4765
13569, 4502, 443, 444, 4513, 4755, 511, 512, 4766
13570, 364, 4503, 4514, 365, 478, 4756, 4767, 479
13571, 4503, 4504, 4515, 4514, 4756, 4757, 4768, 4767
13572, 4504, 4505, 4516, 4515, 4757, 4758, 4769, 4768
13573, 4505, 4506, 4517, 4516, 4758, 4759, 4770, 4769
13574, 4506, 4507, 4518, 4517, 4759, 4760, 4771, 4770
13575, 4507, 4508, 4519, 4518, 4760, 4761, 4772, 4771
13576, 4508, 4509, 4520, 4519, 4761, 4762, 4773, 4772
13577, 4509, 4510, 4521, 4520, 4762, 4763, 4774, 4773
13578, 4510, 4511, 4522, 4521, 4763, 4764, 4775, 4774
13579, 4511, 4512, 4523, 4522, 4764, 4765, 4776, 4775
13580, 4512, 4513, 4524, 4523, 4765, 4766, 4777, 4776
13581, 4513, 444, 445, 4524, 4766, 512, 513, 4777
13582, 365, 4514, 4525, 366, 479, 4767, 4778, 480
13583, 4514, 4515, 4526, 4525, 4767, 4768, 4779, 4778
13584, 4515, 4516, 4527, 4526, 4768, 4769, 4780, 4779
13585, 4516, 4517, 4528, 4527, 4769, 4770, 4781, 4780
13586, 4517, 4518, 4529, 4528, 4770, 4771, 4782, 4781
13587, 4518, 4519, 4530, 4529, 4771, 4772, 4783, 4782
13588, 4519, 4520, 4531, 4530, 4772, 4773, 4784, 4783
13589, 4520, 4521, 4532, 4531, 4773, 4774, 4785, 4784
13590, 4521, 4522, 4533, 4532, 4774, 4775, 4786, 4785
13591, 4522, 4523, 4534, 4533, 4775, 4776, 4787, 4786
13592, 4523, 4524, 4535, 4534, 4776, 4777, 4788, 4787
13593, 4524, 445, 446, 4535, 4777, 513, 514, 4788
13594, 366, 4525, 4536, 367, 480, 4778, 4789, 481
13595, 4525, 4526, 4537, 4536, 4778, 4779, 4790, 4789
13596, 4526, 4527, 4538, 4537, 4779, 4780, 4791, 4790
13597, 4527, 4528, 4539, 4538, 4780, 4781, 4792, 4791
13598, 4528, 4529, 4540, 4539, 4781, 4782, 4793, 4792
13599, 4529, 4530, 4541, 4540, 4782, 4783, 4794, 4793
13600, 4530, 4531, 4542, 4541, 4783, 4784, 4795, 4794
13601, 4531, 4532, 4543, 4542, 4784, 4785, 4796, 4795
13602, 4532, 4533, 4544, 4543, 4785, 4786, 4797, 4796
13603, 4533, 4534, 4545, 4544, 4786, 4787, 4798, 4797
13604, 4534, 4535, 4546, 4545, 4787, 4788, 4799, 4798
13605, 4535, 446, 447, 4546, 4788, 514, 515, 4799
13606, 367, 4536, 4547, 368, 481, 4789, 4800, 482
13607, 4536, 4537, 4548, 4547, 4789, 4790, 4801, 4800
13608, 4537, 4538, 4549, 4548, 4790, 4791, 4802, 4801
13609, 4538, 4539, 4550, 4549, 4791, 4792, 4803, 4802
13610, 4539, 4540, 4551, 4550, 4792, 4793, 4804, 4803
13611, 4540, 4541, 4552, 4551, 4793, 4794, 4805, 4804
13612, 4541, 4542, 4553, 4552, 4794, 4795, 4806, 4805
13613, 4542, 4543, 4554, 4553, 4795, 4796, 4807, 4806
13614, 4543, 4544, 4555, 4554, 4796, 4797, 4808, 4807
13615, 4544, 4545, 4556, 4555, 4797, 4798, 4809, 4808
13616, 4545, 4546, 4557, 4556, 4798, 4799, 4810, 4809
13617, 4546, 447, 448, 4557, 4799, 515, 516, 4810
13618, 368, 4547, 4558, 369, 482, 4800, 4811, 483
13619, 4547, 4548, 4559, 4558, 4800, 4801, 4812, 4811
13620, 4548, 4549, 4560, 4559, 4801, 4802, 4813, 4812
13621, 4549, 4550, 4561, 4560, 4802, 4803, 4814, 4813
13622, 4550, 4551, 4562, 4561, 4803, 4804, 4815, 4814
13623, 4551, 4552, 4563, 4562, 4804, 4805, 4816, 4815
13624, 4552, 4553, 4564, 4563, 4805, 4806, 4817, 4816
13625, 4553, 4554, 4565, 4564, 4806, 4807, 4818, 4817
13626, 4554, 4555, 4566, 4565, 4807, 4808, 4819, 4818
13627, 4555, 4556, 4567, 4566, 4808, 4809, 4820, 4819
13628, 4556, 4557, 4568, 4567, 4809, 4810, 4821, 4820
13629, 4557, 448, 449, 4568, 4810, 516, 517, 4821
13630, 369, 4558, 4569, 370, 483, 4811, 4822, 484
13631, 4558, 4559, 4570, 4569, 4811, 4812, 4823, 4822
13632, 4559, 4560, 4571, 4570, 4812, 4813, 4824, 4823
13633, 4560, 4561, 4572, 4571, 4813, 4814, 4825, 4824
13634, 4561, 4562, 4573, 4572, 4814, 4815, 4826, 4825
13635, 4562, 4563, 4574, 4573, 4815, 4816, 4827, 4826
13636, 4563, 4564, 4575, 4574, 4816, 4817, 4828, 4827
13637, 4564, 4565, 4576, 4575, 4817, 4818, 4829, 4828
13638, 4565, 4566, 4577, 4576, 4818, 4819, 4830, 4829
13639, 4566, 4567, 4578, 4577, 4819, 4820, 4831, 4830
13640, 4567, 4568, 4579, 4578, 4820, 4821, 4832, 4831
13641, 4568, 449, 450, 4579, 4821, 517, 518, 4832
13642, 370, 4569, 4580, 371, 484, 4822, 4833, 485
13643, 4569, 4570, 4581, 4580, 4822, 4823, 4834, 4833
13644, 4570, 4571, 4582, 4581, 4823, 4824, 4835, 4834
13645, 4571, 4572, 4583, 4582, 4824, 4825, 4836, 4835
13646, 4572, 4573, 4584, 4583, 4825, 4826, 4837, 4836
13647, 4573, 4574, 4585, 4584, 4826, 4827, 4838, 4837
13648, 4574, 4575, 4586, 4585, 4827, 4828, 4839, 4838
13649, 4575, 4576, 4587, 4586, 4828, 4829, 4840, 4839
13650, 4576, 4577, 4588, 4587, 4829, 4830, 4841, 4840
13651, 4577, 4578, 4589, 4588, 4830, 4831, 4842, 4841
13652, 4578, 4579, 4590, 4589, 4831, 4832, 4843, 4842
13653, 4579, 450, 451, 4590, 4832, 518, 519, 4843
13654, 371, 4580, 4591, 372, 485, 4833, 4844, 486
13655, 4580, 4581, 4592, 4591, 4833, 4834, 4845, 4844
13656, 4581, 4582, 4593, 4592, 4834, 4835, 4846, 4845
13657, 4582, 4583, 4594, 4593, 4835, 4836, 4847, 4846
13658, 4583, 4584, 4595, 4594, 4836, 4837, 4848, 4847
13659, 4584, 4585, 4596, 4595, 4837, 4838, 4849, 4848
13660, 4585, 4586, 4597, 4596, 4838, 4839, 4850, 4849
13661, 4586, 4587, 4598, 4597, 4839, 4840, 4851, 4850
13662, 4587, 4588, 4599, 4598, 4840, 4841, 4852, 4851
13663, 4588, 4589, 4600, 4599, 4841, 4842, 4853, 4852
13664, 4589, 4590, 4601, 4600, 4842, 4843, 4854, 4853
13665, 4590, 451, 452, 4601, 4843, 519, 520, 4854
13666, 372, 4591, 4602, 373, 486, 4844, 4855, 487
13667, 4591, 4592, 4603, 4602, 4844, 4845, 4856, 4855
13668, 4592, 4593, 4604, 4603, 4845, 4846, 4857, 4856
13669, 4593, 4594, 4605, 4604, 4846, 4847, 4858, 4857
13670, 4594, 4595, 4606, 4605, 4847, 4848, 4859, 4858
13671, 4595, 4596, 4607, 4606, 4848, 4849, 4860, 4859
13672, 4596, 4597, 4608, 4607, 4849, 4850, 4861, 4860
13673, 4597, 4598, 4609, 4608, 4850, 4851, 4862, 4861
13674, 4598, 4599, 4610, 4609, 4851, 4852, 4863, 4862
13675, 4599, 4600, 4611, 4610, 4852, 4853, 4864, 4863
13676, 4600, 4601, 4612, 4611, 4853, 4854, 4865, 4864
13677, 4601, 452, 453, 4612, 4854, 520, 521, 4865
13678, 373, 4602, 4613, 374, 487, 4855, 4866, 488
13679, 4602, 4603, 4614, 4613, 4855, 4856, 4867, 4866
13680, 4603, 4604, 4615, 4614, 4856, 4857, 4868, 4867
13681, 4604, 4605, 4616, 4615, 4857, 4858, 4869, 4868
13682, 4605, 4606, 4617, 4616, 4858, 4859, 4870, 4869
13683, 4606, 4607, 4618, 4617, 4859, 4860, 4871, 4870
13684, 4607, 4608, 4619, 4618, 4860, 4861, 4872, 4871
13685, 4608, 4609, 4620, 4619, 4861, 4862, 4873, 4872
13686, 4609, 4610, 4621, 4620, 4862, 4863, 4874, 4873
13687, 4610, 4611, 4622, 4621, 4863, 4864, 4875, 4874
13688, 4611, 4612, 4623, 4622, 4864, 4865, 4876, 4875
13689, 4612, 453, 454, 4623, 4865, 521, 522, 4876
13690, 374, 4613, 4624, 375, 488, 4866, 4877, 489
13691, 4613, 4614, 4625, 4624, 4866, 4867, 4878, 4877
13692, 4614, 4615, 4626, 4625, 4867, 4868, 4879, 4878
13693, 4615, 4616, 4627, 4626, 4868, 4869, 4880, 4879
13694, 4616, 4617, 4628, 4627, 4869, 4870, 4881, 4880
13695, 4617, 4618, 4629, 4628, 4870, 4871, 4882, 4881
13696, 4618, 4619, 4630, 4629, 4871, 4872, 4883, 4882
13697, 4619, 4620, 4631, 4630, 4872, 4873, 4884, 4883
13698, 4620, 4621, 4632, 4631, 4873, 4874, 4885, 4884
13699, 4621, 4622, 4633, 4632, 4874, 4875, 4886, 4885
13700, 4622, 4623, 4634, 4633, 4875, 4876, 4887, 4886
13701, 4623, 454, 455, 4634, 4876, 522, 523, 4887
13702, 375, 4624, 4635, 376, 489, 4877, 4888, 490
13703, 4624, 4625, 4636, 4635, 4877, 4878, 4889, 4888
13704, 4625, 4626, 4637, 4636, 4878, 4879, 4890, 4889
13705, 4626, 4627, 4638, 4637, 4879, 4880, 4891, 4890
13706, 4627, 4628, 4639, 4638, 4880, 4881, 4892, 4891
13707, 4628, 4629, 4640, 4639, 4881, 4882, 4893, 4892
13708, 4629, 4630, 4641, 4640, 4882, 4883, 4894, 4893
13709, 4630, 4631, 4642, 4641, 4883, 4884, 4895, 4894
13710, 4631, 4632, 4643, 4642, 4884, 4885, 4896, 4895
13711, 4632, 4633, 4644, 4643, 4885, 4886, 4897, 4896
13712, 4633, 4634, 4645, 4644, 4886, 4887, 4898, 4897
13713, 4634, 455, 456, 4645, 4887, 523, 524, 4898
13714, 376, 4635, 4646, 377, 490, 4888, 4899, 491
13715, 4635, 4636, 4647, 4646, 4888, 4889, 4900, 4899
13716, 4636, 4637, 4648, 4647, 4889, 4890, 4901, 4900
13717, 4637, 4638, 4649, 4648, 4890, 4891, 4902, 4901
13718, 4638, 4639, 4650, 4649, 4891, 4892, 4903, 4902
13719, 4639, 4640, 4651, 4650, 4892, 4893, 4904, 4903
13720, 4640, 4641, 4652, 4651, 4893, 4894, 4905, 4904
13721, 4641, 4642, 4653, 4652, 4894, 4895, 4906, 4905
13722, 4642, 4643, 4654, 4653, 4895, 4896, 4907, 4906
13723, 4643, 4644, 4655, 4654, 4896, 4897, 4908, 4907
13724, 4644, 4645, 4656, 4655, 4897, 4898, 4909, 4908
13725, 4645, 456, 457, 4656, 4898, 524, 525, 4909
13726, 377, 4646, 401, 13, 491, 4899, 492, 17
13727, 4646, 4647, 402, 401, 4899, 4900, 493, 492
13728, 4647, 4648, 403, 402, 4900, 4901, 494, 493
13729, 4648, 4649, 404, 403, 4901, 4902, 495, 494
13730, 4649, 4650, 405, 404, 4902, 4903, 496, 495
13731, 4650, 4651, 406, 405, 4903, 4904, 497, 496
13732, 4651, 4652, 407, 406, 4904, 4905, 498, 497
13733, 4652, 4653, 408, 407, 4905, 4906, 499, 498
13734, 4653, 4654, 409, 408, 4906, 4907, 500, 499
13735, 4654, 4655, 410, 409, 4907, 4908, 501, 500
13736, 4655, 4656, 411, 410, 4908, 4909, 502, 501
13737, 4656, 457, 15, 411, 4909, 525, 19, 502
*ELEMENT, type=C3D8, ELSET=Volume5
13738, 18, 526, 4657, 469, 539, 5024, 18954, 4910
13739, 539, 5024, 18954, 4910, 540, 5025, 18955, 4911
13740, 540, 5025, 18955, 4911, 22, 602, 5046, 541
13741, 526, 527, 4658, 4657, 5024, 5026, 18956, 18954
13742, 5024, 5026, 18956, 18954, 5025, 5027, 18957, 18955
13743, 5025, 5027, 18957, 18955, 602, 603, 5047, 5046
13744, 527, 528, 4659, 4658, 5026, 5028, 18958, 18956
13745, 5026, 5028, 18958, 18956, 5027, 5029, 18959, 18957
13746, 5027, 5029, 18959, 18957, 603, 604, 5048, 5047
13747, 528, 529, 4660, 4659, 5028, 5030, 18960, 18958
13748, 5028, 5030, 18960, 18958, 5029, 5031, 18961, 18959
13749, 5029, 5031, 18961, 18959, 604, 605, 5049, 5048
13750, 529, 530, 4661, 4660, 5030, 5032, 18962, 18960
13751, 5030, 5032, 18962, 18960, 5031, 5033, 18963, 18961
13752, 5031, 5033, 18963, 18961, 605, 606, 5050, 5049
13753, 530, 531, 4662, 4661, 5032, 5034, 18964, 18962
13754, 5032, 5034, 18964, 18962, 5033, 5035, 18965, 18963
13755, 5033, 5035, 18965, 18963, 606, 607, 5051, 5050
13756, 531, 532, 4663, 4662, 5034, 5036, 18966, 18964
13757, 5034, 5036, 18966, 18964, 5035, 5037, 18967, 18965
13758, 5035, 5037, 18967, 18965, 607, 608, 5052, 5051
13759, 532, 533, 4664, 4663, 5036, 5038, 18968, 18966
13760, 5036, 5038, 18968, 18966, 5037, 5039, 18969, 18967
13761, 5037, 5039, 18969, 18967, 608, 609, 5053, 5052
13762, 533, 534, 4665, 4664, 5038, 5040, 18970, 18968
13763, 5038, 5040, 18970, 18968, 5039, 5041, 18971, 18969
13764, 5039, 5041, 18971, 18969, 609, 610, 5054, 5053
13765, 534, 535, 4666, 4665, 5040, 5042, 18972, 18970
13766, 5040, 5042, 18972, 18970, 5041, 5043, 18973, 18971
13767, 5041, 5043, 18973, 18971, 610, 611, 5055, 5054
13768, 535, 536, 4667, 4666, 5042, 5044, 18974, 18972
13769, 5042, 5044, 18974, 18972, 5043, 5045, 18975, 18973
13770, 5043, 5045, 18975, 18973, 611, 612, 5056, 5055
13771, 536, 20, 503, 4667, 5044, 577, 4978, 18974
13772, 5044, 577, 4978, 18974, 5045, 578, 4979, 18975
13773, 5045, 578, 4979, 18975, 612, 24, 579, 5056
13774, 469, 4657, 4668, 470, 4910, 18954, 18976, 4912
13775, 4910, 18954, 18976, 4912, 4911, 18955, 18977, 4913
13776, 4911, 18955, 18977, 4913, 541, 5046, 5057, 542
13777, 4657, 4658, 4669, 4668, 18954, 18956, 18978, 18976
13778, 18954, 18956, 18978, 18976, 18955, 18957, 18979, 18977
13779, 18955, 18957, 18979, 18977, 5046, 5047, 5058, 5057
13780, 4658, 4659, 4670, 4669, 18956, 18958, 18980, 18978
13781, 18956, 18958, 18980, 18978, 18957, 18959, 18981, 18979
13782, 18957, 18959, 18981, 18979, 5047, 5048, 5059, 5058
13783, 4659, 4660, 4671, 4670, 18958, 18960, 18982, 18980
13784, 18958, 18960, 18982, 18980, 18959, 18961, 18983, 18981
13785, 18959, 18961, 18983, 18981, 5048, 5049, 5060, 5059
13786, 4660, 4661, 4672, 4671, 18960, 18962, 18984, 18982
13787, 18960, 18962, 18984, 18982, 18961, 18963, 18985, 18983
13788, 18961, 18963, 18985, 18983, 5049, 5050, 5061, 5060
13789, 4661, 4662, 4673, 4672, 18962, 18964, 18986, 18984
13790, 18962, 18964, 18986, 18984, 18963, 18965, 18987, 18985
13791, 18963, 18965, 18987, 18985, 5050, 5051, 5062, 5061
13792, 4662, 4663, 4674, 4673, 18964, 18966, 18988, 18986
13793, 18964, 18966, 18988, 18986, 18965, 18967, 18989, 18987
13794, 18965, 18967, 18989, 18987, 5051, 5052, 5063, 5062
13795, 4663, 4664, 4675, 4674, 18966, 18968, 18990, 18988
13796, 18966, 18968, 18990, 18988, 18967, 18969, 18991, 18989
13797, 18967, 18969, 18991, 18989, 5052, 5053, 5064, 5063
13798, 4664, 4665, 4676, 4675, 18968, 18970, 18992, 18990
13799, 18968, 18970, 18992, 18990, 18969, 18971, 18993, 18991
13800, 18969, 18971, 18993, 18991, 5053, 5054, 5065, 5064
13801, 4665, 4666, 4677, 4676, 18970, 18972, 18994, 18992
13802, 18970, 18972, 18994, 18992, 18971, 18973, 18995, 18993
13803, 18971, 18973, 18995, 18993, 5054, 5055, 5066, 5065
13804, 4666, 4667, 4678, 4677, 18972, 18974, 18996, 18994
13805, 18972, 18974, 18996, 18994, 18973, 18975, 18997, 18995
13806, 18973, 18975, 18997, 18995, 5055, 5056, 5067, 5066
13807, 4667, 503, 504, 4678, 18974, 4978, 4980, 18996
13808, 18974, 4978, 4980, 18996, 18975, 4979, 4981, 18997
13809, 18975, 4979, 4981, 18997, 5056, 579, 580, 5067
13810, 470, 4668, 4679, 471, 4912, 18976, 18998, 4914
13811, 4912, 18976, 18998, 4914, 4913, 18977, 18999, 4915
13812, 4913, 18977, 18999, 4915, 542, 5057, 5068, 543
13813, 4668, 4669, 4680, 4679, 18976, 18978, 19000, 18998
13814, 18976, 18978, 19000, 18998, 18977, 18979, 19001, 18999
13815, 18977, 18979, 19001, 18999, 5057, 5058, 5069, 5068
13816, 4669, 4670, 4681, 4680, 18978, 18980, 19002, 19000
13817, 18978, 18980, 19002, 19000, 18979, 18981, 19003, 19001
13818, 18979, 18981, 19003, 19001, 5058, 5059, 5070, 5069
13819, 4670, 4671, 4682, 4681, 18980, 18982, 19004, 19002
13820, 18980, 18982, 19004, 19002, 18981, 18983, 19005, 19003
13821, 18981, 18983, 19005, 19003, 5059, 5060, 5071, 5070
13822, 4671, 4672, 4683, 4682, 18982, 18984, 19006, 19004
13823, 18982, 18984, 19006, 19004, 18983, 18985, 19007, 19005
13824, 18983, 18985, 19007, 19005, 5060, 5061, 5072, 5071
13825, 4672, 4673, 4684, 4683, 18984, 18986, 19008, 19006
13826, 18984, 18986, 19008, 19006, 18985, 18987, 19009, 19007
13827, 18985, 18987, 19009, 19007, 5061, 5062, 5073, 5072
13828, 4673, 4674, 4685, 4684, 18986, 18988, 19010, 19008
13829, 18986, 18988, 19010, 19008, 18987, 18989, 19011, 19009
13830, 18987, 18989, 19011, 19009, 5062, 5063, 5074, 5073
13831, 4674, 4675, 4686, 4685, 18988, 18990, 19012, 19010
13832, 18988, 18990, 19012, 19010, 18989, 18991, 19013, 19011
13833, 18989, 18991, 19013, 19011, 5063, 5064, 5075, 5074
13834, 4675, 4676, 4687, 4686, 18990, 18992, 19014, 19012
13835, 18990, 18992, 19014, 19012, 18991, 18993, 19015, 19013
13836, 18991, 18993, 19015, 19013, 5064, 5065, 5076, 5075
13837, 4676, 4677, 4688, 4687, 18992, 18994, 19016, 19014
13838, 18992, 18994, 19016, 19014, 18993, 18995, 19017, 19015
13839, 18993, 18995, 19017, 19015, 5065, 5066, 5077, 5076
13840, 4677, 4678, 4689, 4688, 18994, 18996, 19018, 19016
13841, 18994, 18996, 19018, 19016, 18995, 18997, 19019, 19017
13842, 18995, 18997, 19019, 19017, 5066, 5067, 5078, 5077
13843, 4678, 504, 505, 4689, 18996, 4980, 4982, 19018
13844, 18996, 4980, 4982, 19018, 18997, 4981, 4983, 19019
13845, 18997, 4981, 4983, 19019, 5067, 580, 581, 5078
13846, 471, 4679, 4690, 472, 4914, 18998, 19020, 4916
13847, 4914, 18998, 19020, 4916, 4915, 18999, 19021, 4917
13848, 4915, 18999, 19021, 4917, 543, 5068, 5079, 544
13849, 4679, 4680, 4691, 4690, 18998, 19000, 19022, 19020
13850, 18998, 19000, 19022, 19020, 18999, 19001, 19023, 19021
13851, 18999, 19001, 19023, 19021, 5068, 5069, 5080, 5079
13852, 4680, 4681, 4692, 4691, 19000, 19002, 19024, 19022
13853, 19000, 19002, 19024, 19022, 19001, 19003, 19025, 19023
13854, 19001, 19003, 19025, 19023, 5069, 5070, 5081, 5080
13855, 4681, 4682, 4693, 4692, 19002, 19004, 19026, 19024
13856, 19002, 19004, 19026, 19024, 19003, 19005, 19027, 19025
13857, 19003, 19005, 19027, 19025, 5070, 5071, 5082, 5081
13858, 4682, 4683, 4694, 4693, 19004, 19006, 19028, 19026
13859, 19004, 19006, 19028, 19026, 19005, 19007, 19029, 19027
13860, 19005, 19007, 19029, 19027, 5071, 5072, 5083, 5082
13861, 4683, 4684, 4695, 4694, 19006, 19008, 19030, 19028
13862, 19006, 19008, 19030, 19028, 19007, 19009, 19031, 19029
13863, 19007, 19009, 19031, 19029, 5072, 5073, 5084, 5083
13864, 4684, 4685, 4696, 4695, 19008, 19010, 19032, 19030
13865, 19008, 19010, 19032, 19030, 19009, 19011, 19033, 19031
13866, 19009, 19011, 19033, 19031, 5073, 5074, 5085, 5084
13867, 4685, 4686, 4697, 4696, 19010, 19012, 19034, 19032
13868, 19010, 19012, 19034, 19032, 19011, 19013, 19035, 19033
13869, 19011, 19013, 19035, 19033, 5074, 5075, 5086, 5085
13870, 4686, 4687, 4698, 4697, 19012, 19014, 19036, 19034
13871, 19012, 19014, 19036, 19034, 19013, 19015, 19037, 19035
13872, 19013, 19015, 19037, 19035, 5075, 5076, 5087, 5086
13873, 4687, 4688, 4699, 4698, 19014, 19016, 19038, 19036
13874, 19014, 19016, 19038, 19036, 19015, 19017, 19039, 19037
13875, 19015, 19017, 19039, 19037, 5076, 5077, 5088, 5087
13876, 4688, 4689, 4700, 4699, 19016, 19018, 19040, 19038
13877, 19016, 19018, 19040, 19038, 19017, 19019, 19041, 19039
13878, 19017, 19019, 19041, 19039, 5077, 5078, 5089, 5088
13879, 4689, 505, 506, 4700, 19018, 4982, 4984, 19040
13880, 19018, 4982, 4984, 19040, 19019, 4983, 4985, 19041
13881, 19019, 4983, 4985, 19041, 5078, 581, 582, 5089
13882, 472, 4690, 4701, 473, 4916, 19020, 19042, 4918
13883, 4916, 19020, 19042, 4918, 4917, 19021, 19043, 4919
13884, 4917, 19021, 19043, 4919, 544, 5079, 5090, 545
13885, 4690, 4691, 4702, 4701, 19020, 19022, 19044, 19042
13886, 19020, 19022, 19044, 19042, 19021, 19023, 19045, 19043
13887, 19021, 19023, 19045, 19043, 5079, 5080, 5091, 5090
13888, 4691, 4692, 4703, 4702, 19022, 19024, 19046, 19044
13889, 19022, 19024, 19046, 19044, 19023, 19025, 19047, 19045
13890, 19023, 19025, 19047, 19045, 5080, 5081, 5092, 5091
13891, 4692, 4693, 4704, 4703, 19024, 19026, 19048, 19046
13892, 19024, 19026, 19048, 19046, 19025, 19027, 19049, 19047
13893, 19025, 19027, 19049, 19047, 5081, 5082, 5093, 5092
13894, 4693, 4694, 4705, 4704, 19026, 19028, 19050, 19048
13895, 19026, 19028, 19050, 19048, 19027, 19029, 19051, 19049
13896, 19027, 19029, 19051, 19049, 5082, 5083, 5094, 5093
13897, 4694, 4695, 4706, 4705, 19028, 19030, 19052, 19050
13898, 19028, 19030, 19052, 19050, 19029, 19031, 19053, 19051
13899, 19029, 19031, 19053, 19051, 5083, 5084, 5095, 5094
13900, 4695, 4696, 4707, 4706, 19030, 19032, 19054, 19052
13901, 19030, 19032, 19054, 19052, 19031, 19033, 19055, 19053
13902, 19031, 19033, 19055, 19053, 5084, 5085, 5096, 5095
13903, 4696, 4697, 4708, 4707, 19032, 19034, 19056, 19054
13904, 19032, 19034, 19056, 19054, 19033, 19035, 19057, 19055
13905, 19033, 19035, 19057, 19055, 5085, 5086, 5097, 5096
13906, 4697, 4698, 4709, 4708, 19034, 19036, 19058, 19056
13907, 19034, 19036, 19058, 19056, 19035, 19037, 19059, 19057
13908, 19035, 19037, 19059, 19057, 5086, 5087, 5098, 5097
13909, 4698, 4699, 4710, 4709, 19036, 19038, 19060, 19058
13910, 19036, 19038, 19060, 19058, 19037, 19039, 19061, 19059
13911, 19037, 19039, 19061, 19059, 5087, 5088, 5099, 5098
13912, 4699, 4700, 4711, 4710, 19038, 19040, 19062, 19060
13913, 19038, 19040, 19062, 19060, 19039, 19041, 19063, 19061
13914, 19039, 19041, 19063, 19061, 5088, 5089, 5100, 5099
13915, 4700, 506, 507, 4711, 19040, 4984, 4986, 19062
13916, 19040, 4984, 4986, 19062, 19041, 4985, 4987, 19063
13917, 19041, 4985, 4987, 19063, 5089, 582, 583, 5100
13918, 473, 4701, 4712, 474, 4918, 19042, 19064, 4920
13919, 4918, 19042, 19064, 4920, 4919, 19043, 19065, 4921
13920, 4919, 19043, 19065, 4921, 545, 5090, 5101, 546
13921, 4701, 4702, 4713, 4712, 19042, 19044, 19066, 19064
13922, 19042, 19044, 19066, 19064, 19043, 19045, 19067, 19065
13923, 19043, 19045, 19067, 19065, 5090, 5091, 5102, 5101
13924, 4702, 4703, 4714, 4713, 19044, 19046, 19068, 19066
13925, 19044, 19046, 19068, 19066, 19045, 19047, 19069, 19067
13926, 19045, 19047, 19069, 19067, 5091, 5092, 5103, 5102
13927, 4703, 4704, 4715, 4714, 19046, 19048, 19070, 19068
13928, 19046, 19048, 19070, 19068, 19047, 19049, 19071, 19069
13929, 19047, 19049, 19071, 19069, 5092, 5093, 5104, 5103
13930, 4704, 4705, 4716, 4715, 19048, 19050, 19072, 19070
13931, 19048, 19050, 19072, 19070, 19049, 19051, 19073, 19071
13932, 19049, 19051, 19073, 19071, 5093, 5094, 5105, 5104
13933, 4705, 4706, 4717, 4716, 19050, 19052, 19074, 19072
13934, 19050, 19052, 19074, 19072, 19051, 19053, 19075, 19073
13935, 19051, 19053, 19075, 19073, 5094, 5095, 5106, 5105
13936, 4706, 4707, 4718, 4717, 19052, 19054, 19076, 19074
13937, 19052, 19054, 19076, 19074, 19053, 19055, 19077, 19075
13938, 19053, 19055, 19077, 19075, 5095, 5096, 5107, 5106
13939, 4707, 4708, 4719, 4718, 19054, 19056, 19078, 19076
13940, 19054, 19056, 19078, 19076, 19055, 19057, 19079, 19077
13941, 19055, 19057, 19079, 19077, 5096, 5097, 5108, 5107
13942, 4708, 4709, 4720, 4719, 19056, 19058, 19080, 19078
13943, 19056, 19058, 19080, 19078, 19057, 19059, 19081, 19079
13944, 19057, 19059, 19081, 19079, 5097, 5098, 5109, 5108
13945, 4709, 4710, 4721, 4720, 19058, 19060, 19082, 19080
13946, 19058, 19060, 19082, 19080, 19059, 19061, 19083, 19081
13947, 19059, 19061, 19083, 19081, 5098, 5099, 5110, 5109
13948, 4710, 4711, 4722, 4721, 19060, 19062, 19084, 19082
13949, 19060, 19062, 19084, 19082, 19061, 19063, 19085, 19083
13950, 19061, 19063, 19085, 19083, 5099, 5100, 5111, 5110
13951, 4711, 507, 508, 4722, 19062, 4986, 4988, 19084
13952, 19062, 4986, 4988, 19084, 19063, 4987, 4989, 19085
13953, 19063, 4987, 4989, 19085, 5100, 583, 584, 5111
13954, 474, 4712, 4723, 475, 4920, 19064, 19086, 4922
13955, 4920, 19064, 19086, 4922, 4921, 19065, 19087, 4923
13956, 4921, 19065, 19087, 4923, 546, 5101, 5112, 547
13957, 4712, 4713, 4724, 4723, 19064, 19066, 19088, 19086
13958, 19064, 19066, 19088, 19086, 19065, 19067, 19089, 19087
13959, 19065, 19067, 19089, 19087, 5101, 5102, 5113, 5112
13960, 4713, 4714, 4725, 4724, 19066, 19068, 19090, 19088
13961, 19066, 19068, 19090, 19088, 19067, 19069, 19091, 19089
13962, 19067, 19069, 19091, 19089, 5102, 5103, 5114, 5113
13963, 4714, 4715, 4726, 4725, 19068, 19070, 19092, 19090
13964, 19068, 19070, 19092, 19090, 19069, 19071, 19093, 19091
13965, 19069, 19071, 19093, 19091, 5103, 5104, 5115, 5114
13966, 4715, 4716, 4727, 4726, 19070, 19072, 19094, 19092
13967, 19070, 19072, 19094, 19092, 19071, 19073, 19095, 19093
13968, 19071, 19073, 19095, 19093, 5104, 5105, 5116, 5115
13969, 4716, 4717, 4728, 4727, 19072, 19074, 19096, 19094
13970, 19072, 19074, 19096, 19094, 19073, 19075, 19097, 19095
13971, 19073, 19075, 19097, 19095, 5105, 5106, 5117, 5116
13972, 4717, 4718, 4729, 4728, 19074, 19076, 19098, 19096
13973, 19074, 19076, 19098, 19096, 19075, 19077, 19099, 19097
13974, 19075, 19077, 19099, 19097, 5106, 5107, 5118, 5117
13975, 4718, 4719, 4730, 4729, 19076, 19078, 19100, 19098
13976, 19076, 19078, 19100, 19098, 19077, 19079, 19101, 19099
13977, 19077, 19079, 19101, 19099, 5107, 5108, 5119, 5118
13978, 4719, 4720, 4731, 4730, 19078, 19080, 19102, 19100
13979, 19078, 19080, 19102, 19100, 19079, 19081, 19103, 19101
13980, 19079, 19081, 19103, 19101, 5108, 5109, 5120, 5119
13981, 4720, 4721, 4732, 4731, 19080, 19082, 19104, 19102
13982, 19080, 19082, 19104, 19102, 19081, 19083, 19105, 19103
13983, 19081, 19083, 19105, 19103, 5109, 5110, 5121, 5120
13984, 4721, 4722, 4733, 4732, 19082, 19084, 19106, 19104
13985, 19082, 19084, 19106, 19104, 19083, 19085, 19107, 19105
13986, 19083, 19085, 19107, 19105, 5110, 5111, 5122, 5121
13987, 4722, 508, 509, 4733, 19084, 4988, 4990, 19106
13988, 19084, 4988, 4990, 19106, 19085, 4989, 4991, 19107
13989, 19085, 4989, 4991, 19107, 5111, 584, 585, 5122
13990, 475, 4723, 4734, 476, 4922, 19086, 19108, 4924
13991, 4922, 19086, 19108, 4924, 4923, 19087, 19109, 4925
13992, 4923, 19087, 19109, 4925, 547, 5112, 5123, 548
13993, 4723, 4724, 4735, 4734, 19086, 19088, 19110, 19108
13994, 19086, 19088, 19110, 19108, 19087, 19089, 19111, 19109
13995, 19087, 19089, 19111, 19109, 5112, 5113, 5124, 5123
13996, 4724, 4725, 4736, 4735, 19088, 19090, 19112, 19110
13997, 19088, 19090, 19112, 19110, 19089, 19091, 19113, 19111
13998, 19089, 19091, 19113, 19111, 5113, 5114, 5125, 5124
13999, 4725, 4726, 4737, 4736, 19090, 19092, 19114, 19112
14000, 19090, 19092, 19114, 19112, 19091, 19093, 19115, 19113
14001, 19091, 19093, 19115, 19113, 5114, 5115, 5126, 5125
14002, 4726, 4727, 4738, 4737, 19092, 19094, 19116, 19114
14003, 19092, 19094, 19116, 19114, 19093, 19095, 19117, 19115
14004, 19093, 19095, 19117, 19115, 5115, 5116, 5127, 5126
14005, 4727, 4728, 4739, 4738, 19094, 19096, 19118, 19116
14006, 19094, 19096, 19118, 19116, 19095, 19097, 19119, 19117
14007, 19095, 19097, 19119, 19117, 5116, 5117, 5128, 5127
14008, 4728, 4729, 4740, 4739, 19096, 19098, 19120, 19118
14009, 19096, 19098, 19120, 19118, 19097, 19099, 19121, 19119
14010, 19097, 19099, 19121, 19119, 5117, 5118, 5129, 5128
14011, 4729, 4730, 4741, 4740, 19098, 19100, 19122, 19120
14012, 19098, 19100, 19122, 19120, 19099, 19101, 19123, 19121
14013, 19099, 19101, 19123, 19121, 5118, 5119, 5130, 5129
14014, 4730, 4731, 4742, 4741, 19100, 19102, 19124, 19122
14015, 19100, 19102, 19124, 19122, 19101, 19103, 19125, 19123
14016, 19101, 19103, 19125, 19123, 5119, 5120, 5131, 5130
14017, 4731, 4732, 4743, 4742, 19102, 19104, 19126, 19124
14018, 19102, 19104, 19126, 19124, 19103, 19105, 19127, 19125
14019, 19103, 19105, 19127, 19125, 5120, 5121, 5132, 5131
14020, 4732, 4733, 4744, 4743, 19104, 19106, 19128, 19126
14021, 19104, 19106, 19128, 19126, 19105, 19107, 19129, 19127
14022, 19105, 19107, 19129, 19127, 5121, 5122, 5133, 5132
14023, 4733, 509, 510, 4744, 19106, 4990, 4992, 19128
14024, 19106, 4990, 4992, 19128, 19107, 4991, 4993, 19129
14025, 19107, 4991, 4993, 19129, 5122, 585, 586, 5133
14026, 476, 4734, 4745, 477, 4924, 19108, 19130, 4926
14027, 4924, 19108, 19130, 4926, 4925, 19109, 19131, 4927
14028, 4925, 19109, 19131, 4927, 548, 5123, 5134, 549
14029, 4734, 4735, 4746, 4745, 19108, 19110, 19132, 19130
14030, 19108, 19110, 19132, 19130, 19109, 19111, 19133, 19131
14031, 19109, 19111, 19133, 19131, 5123, 5124, 5135, 5134
14032, 4735, 4736, 4747, 4746, 19110, 19112, 19134, 19132
14033, 19110, 19112, 19134, 19132, 19111, 19113, 19135, 19133
14034, 19111, 19113, 19135, 19133, 5124, 5125, 5136, 5135
14035, 4736, 4737, 4748, 4747, 19112, 19114, 19136, 19134
14036, 19112, 19114, 19136, 19134, 19113, 19115, 19137, 19135
14037, 19113, 19115, 19137, 19135, 5125, 5126, 5137, 5136
14038, 4737, 4738, 4749, 4748, 19114, 19116, 19138, 19136
14039, 19114, 19116, 19138, 19136, 19115, 19117, 19139, 19137
14040, 19115, 19117, 19139, 19137, 5126, 5127, 5138, 5137
14041, 4738, 4739, 4750, 4749, 19116, 19118, 19140, 19138
14042, 19116, 19118, 19140, 19138, 19117, 19119, 19141, 19139
14043, 19117, 19119, 19141, 19139, 5127, 5128, 5139, 5138
14044, 4739, 4740, 4751, 4750, 19118, 19120, 19142, 19140
14045, 19118, 19120, 19142, 19140, 19119, 19121, 19143, 19141
14046, 19119, 19121, 19143, 19141, 5128, 5129, 5140, 5139
14047, 4740, 4741, 4752, 4751, 19120, 19122, 19144, 19142
14048, 19120, 19122, 19144, 19142, 19121, 19123, 19145, 19143
14049, 19121, 19123, 19145, 19143, 5129, 5130, 5141, 5140
14050, 4741, 4742, 4753, 4752, 19122, 19124, 19146, 19144
14051, 19122, 19124, 19146, 19144, 19123, 19125, 19147, 19145
14052, 19123, 19125, 19147, 19145, 5130, 5131, 5142, 5141
14053, 4742, 4743, 4754, 4753, 19124, 19126, 19148, 19146
14054, 19124, 19126, 19148, 19146, 19125, 19127, 19149, 19147
14055, 19125, 19127, 19149, 19147, 5131, 5132, 5143, 5142
14056, 4743, 4744, 4755, 4754, 19126, 19128, 19150, 19148
14057, 19126, 19128, 19150, 19148, 19127, 19129, 19151, 19149
14058, 19127, 19129, 19151, 19149, 5132, 5133, 5144, 5143
14059, 4744, 510, 511, 4755, 19128, 4992, 4994, 19150
14060, 19128, 4992, 4994, 19150, 19129, 4993, 4995, 19151
14061, 19129, 4993, 4995, 19151, 5133, 586, 587, 5144
14062, 477, 4745, 4756, 478, 4926, 19130, 19152, 4928
14063, 4926, 19130, 19152, 4928, 4927, 19131, 19153, 4929
14064, 4927, 19131, 19153, 4929, 549, 5134, 5145, 550
14065, 4745, 4746, 4757, 4756, 19130, 19132, 19154, 19152
14066, 19130, 19132, 19154, 19152, 19131, 19133, 19155, 19153
14067, 19131, 19133, 19155, 19153, 5134, 5135, 5146, 5145
14068, 4746, 4747, 4758, 4757, 19132, 19134, 19156, 19154
14069, 19132, 19134, 19156, 19154, 19133, 19135, 19157, 19155
14070, 19133, 19135, 19157, 19155, 5135, 5136, 5147, 5146
14071, 4747, 4748, 4759, 4758, 19134, 19136, 19158, 19156
14072, 19134, 19136, 19158, 19156, 19135, 19137, 19159, 19157
14073, 19135, 19137, 19159, 19157, 5136, 5137, 5148, 5147
14074, 4748, 4749, 4760, 4759, 19136, 19138, 19160, 19158
14075, 19136, 19138, 19160, 19158, 19137, 19139, 19161, 19159
14076, 19137, 19139, 19161, 19159, 5137, 5138, 5149, 5148
14077, 4749, 4750, 4761, 4760, 19138, 19140, 19162, 19160
14078, 19138, 19140, 19162, 19160, 19139, 19141, 19163, 19161
14079, 19139, 19141, 19163, 19161, 5138, 5139, 5150, 5149
14080, 4750, 4751, 4762, 4761, 19140, 19142, 19164, 19162
14081, 19140, 19142, 19164, 19162, 19141, 19143, 19165, 19163
14082, 19141, 19143, 19165, 19163, 5139, 5140, 5151, 5150
14083, 4751, 4752, 4763, 4762, 19142, 19144, 19166, 19164
14084, 19142, 19144, 19166, 19164, 19143, 19145, 19167, 19165
14085, 19143, 19145, 19167, 19165, 5140, 5141, 5152, 5151
14086, 4752, 4753, 4764, 4763, 19144, 19146, 19168, 19166
14087, 19144, 19146, 19168, 19166, 19145, 19147, 19169, 19167
14088, 19145, 19147, 19169, 19167, 5141, 5142, 5153, 5152
14089, 4753, 4754, 4765, 4764, 19146, 19148, 19170, 19168
14090, 19146, 19148, 19170, 19168, 19147, 19149, 19171, 19169
14091, 19147, 19149, 19171, 19169, 5142, 5143, 5154, 5153
14092, 4754, 4755, 4766, 4765, 19148, 19150, 19172, 19170
14093, 19148, 19150, 19172, 19170, 19149, 19151, 19173, 19171
14094, 19149, 19151, 19173, 19171, 5143, 5144, 5155, 5154
14095, 4755, 511, 512, 4766, 19150, 4994, 4996, 19172
14096, 19150, 4994, 4996, 19172, 19151, 4995, 4997, 19173
14097, 19151, 4995, 4997, 19173, 5144, 587, 588, 5155
14098, 478, 4756, 4767, 479, 4928, 19152, 19174, 4930
14099, 4928, 19152, 19174, 4930, 4929, 19153, 19175, 4931
14100, 4929, 19153, 19175, 4931, 550, 5145, 5156, 551
14101, 4756, 4757, 4768, 4767, 19152, 19154, 19176, 19174
14102, 19152, 19154, 19176, 19174, 19153, 19155, 19177, 19175
14103, 19153, 19155, 19177, 19175, 5145, 5146, 5157, 5156
14104, 4757, 4758, 4769, 4768, 19154, 19156, 19178, 19176
14105, 19154, 19156, 19178, 19176, 19155, 19157, 19179, 19177
14106, 19155, 19157, 19179, 19177, 5146, 5147, 5158, 5157
14107, 4758, 4759, 4770, 4769, 19156, 19158, 19180, 19178
14108, 19156, 19158, 19180, 19178, 19157, 19159, 19181, 19179
14109, 19157, 19159, 19181, 19179, 5147, 5148, 5159, 5158
14110, 4759, 4760, 4771, 4770, 19158, 19160, 19182, 19180
14111, 19158, 19160, 19182, 19180, 19159, 19161, 19183, 19181
14112, 19159, 19161, 19183, 19181, 5148, 5149, 5160, 5159
14113, 4760, 4761, 4772, 4771, 19160, 19162, 19184, 19182
14114, 19160, 19162, 19184, 19182, 19161, 19163, 19185, 19183
14115, 19161, 19163, 19185, 19183, 5149, 5150, 5161, 5160
14116, 4761, 4762, 4773, 4772, 19162, 19164, 19186, 19184
14117, 19162, 19164, 19186, 19184, 19163, 19165, 19187, 19185
14118, 19163, 19165, 19187, 19185, 5150, 5151, 5162, 5161
14119, 4762, 4763, 4774, 4773, 19164, 19166, 19188, 19186
14120, 19164, 19166, 19188, 19186, 19165, 19167, 19189, 19187
14121, 19165, 19167, 19189, 19187, 5151, 5152, 5163, 5162
14122, 4763, 4764, 4775, 4774, 19166, 19168, 19190, 19188
14123, 19166, 19168, 19190, 19188, 19167, 19169, 19191, 19189
14124, 19167, 19169, 19191, 19189, 5152, 5153, 5164, 5163
14125, 4764, 4765, 4776, 4775, 19168, 19170, 19192, 19190
14126, 19168, 19170, 19192, 19190, 19169, 19171, 19193, 19191
14127, 19169, 19171, 19193, 19191, 5153, 5154, 5165, 5164
14128, 4765, 4766, 4777, 4776, 19170, 19172, 19194, 19192
14129, 19170, 19172, 19194, 19192, 19171, 19173, 19195, 19193
14130, 19171, 19173, 19195, 19193, 5154, 5155, 5166, 5165
14131, 4766, 512, 513, 4777, 19172, 4996, 4998, 19194
14132, 19172, 4996, 4998, 19194, 19173, 4997, 4999, 19195
14133, 19173, 4997, 4999, 19195, 5155, 588, 589, 5166
14134, 479, 4767, 4778, 480, 4930, 19174, 19196, 4932
14135, 4930, 19174, 19196, 4932, 4931, 19175, 19197, 4933
14136, 4931, 19175, 19197, 4933, 551, 5156, 5167, 552
14137, 4767, 4768, 4779, 4778, 19174, 19176, 19198, 19196
14138, 19174, 19176, 19198, 19196, 19175, 19177, 19199, 19197
14139, 19175, 19177, 19199, 19197, 5156, 5157, 5168, 5167
14140, 4768, 4769, 4780, 4779, 19176, 19178, 19200, 19198
14141, 19176, 19178, 19200, 19198, 19177, 19179, 19201, 19199
14142, 19177, 19179, 19201, 19199, 5157, 5158, 5169, 5168
14143, 4769, 4770, 4781, 4780, 19178, 19180, 19202, 19200
14144, 19178, 19180, 19202, 19200, 19179, 19181, 19203, 19201
14145, 19179, 19181, 19203, 19201, 5158, 5159, 5170, 5169
14146, 4770, 4771, 4782, 4781, 19180, 19182, 19204, 19202
14147, 19180, 19182, 19204, 19202, 19181, 19183, 19205, 19203
14148, 19181, 19183, 19205, 19203, 5159, 5160, 5171, 5170
14149, 4771, 4772, 4783, 4782, 19182, 19184, 19206, 19204
14150, 19182, 19184, 19206, 19204, 19183, 19185, 19207, 19205
14151, 19183, 19185, 19207, 19205, 5160, 5161, 5172, 5171
14152, 4772, 4773, 4784, 4783, 19184, 19186, 19208, 19206
14153, 19184, 19186, 19208, 19206, 19185, 19187, 19209, 19207
14154, 19185, 19187, 19209, 19207, 5161, 5162, 5173, 5172
14155, 4773, 4774, 4785, 4784, 19186, 19188, 19210, 19208
14156, 19186, 19188, 19210, 19208, 19187, 19189, 19211, 19209
14157, 19187, 19189, 19211, 19209, 5162, 5163, 5174, 5173
14158, 4774, 4775, 4786, 4785, 19188, 19190, 19212, 19210
14159, 19188, 19190, 19212, 19210, 19189, 19191, 19213, 19211
14160, 19189, 19191, 19213, 19211, 5163, 5164, 5175, 5174
14161, 4775, 4776, 4787, 4786, 19190, 19192, 19214, 19212
14162, 19190, 19192, 19214, 19212, 19191, 19193, 19215, 19213
14163, 19191, 19193, 19215, 19213, 5164, 5165, 5176, 5175
14164, 4776, 4777, 4788, 4787, 19192, 19194, 19216, 19214
14165, 19192, 19194, 19216, 19214, 19193, 19195, 19217, 19215
14166, 19193, 19195, 19217, 19215, 5165, 5166, 5177, 5176
14167, 4777, 513, 514, 4788, 19194, 4998, 5000, 19216
14168, 19194, 4998, 5000, 19216, 19195, 4999, 5001, 19217
14169, 19195, 4999, 5001, 19217, 5166, 589, 590, 5177
14170, 480, 4778, 4789, 481, 4932, 19196, 19218, 4934
14171, 4932, 19196, 19218, 4934, 4933, 19197, 19219, 4935
14172, 4933, 19197, 19219, 4935, 552, 5167, 5178, 553
14173, 4778, 4779, 4790, 4789, 19196, 19198, 19220, 19218
14174, 19196, 19198, 19220, 19218, 19197, 19199, 19221, 19219
14175, 19197, 19199, 19221, 19219, 5167, 5168, 5179, 5178
14176, 4779, 4780, 4791, 4790, 19198, 19200, 19222, 19220
14177, 19198, 19200, 19222, 19220, 19199, 19201, 19223, 19221
14178, 19199, 19201, 19223, 19221, 5168, 5169, 5180, 5179
14179, 4780, 4781, 4792, 4791, 19200, 19202, 19224, 19222
14180, 19200, 19202, 19224, 19222, 19201, 19203, 19225, 19223
14181, 19201, 19203, 19225, 19223, 5169, 5170, 5181, 5180
14182, 4781, 4782, 4793, 4792, 19202, 19204, 19226, 19224
14183, 19202, 19204, 19226, 19224, 19203, 19205, 19227, 19225
14184, 19203, 19205, 19227, 19225, 5170, 5171, 5182, 5181
14185, 4782, 4783, 4794, 4793, 19204, 19206, 19228, 19226
14186, 19204, 19206, 19228, 19226, 19205, 19207, 19229, 19227
14187, 19205, 19207, 19229, 19227, 5171, 5172, 5183, 5182
14188, 4783, 4784, 4795, 4794, 19206, 19208, 19230, 19228
14189, 19206, 19208, 19230, 19228, 19207, 19209, 19231, 19229
14190, 19207, 19209, 19231, 19229, 5172, 5173, 5184, 5183
14191, 4784, 4785, 4796, 4795, 19208, 19210, 19232, 19230
14192, 19208, 19210, 19232, 19230, 19209, 19211, 19233, 19231
14193, 19209, 19211, 19233, 19231, 5173, 5174, 5185, 5184
14194, 4785, 4786, 4797, 4796, 19210, 19212, 19234, 19232
14195, 19210, 19212, 19234, 19232, 19211, 19213, 19235, 19233
14196, 19211, 19213, 19235, 19233, 5174, 5175, 5186, 5185
14197, 4786, 4787, 4798, 4797, 19212, 19214, 19236, 19234
14198, 19212, 19214, 19236, 19234, 19213, 19215, 19237, 19235
14199, 19213, 19215, 19237, 19235, 5175, 5176, 5187, 5186
14200, 4787, 4788, 4799, 4798, 19214, 19216, 19238, 19236
14201, 19214, 19216, 19238, 19236, 19215, 19217, 19239, 19237
14202, 19215, 19217, 19239, 19237, 5176, 5177, 5188, 5187
14203, 4788, 514, 515, 4799, 19216, 5000, 5002, 19238
14204, 19216, 5000, 5002, 19238, 19217, 5001, 5003, 19239
14205, 19217, 5001, 5003, 19239, 5177, 590, 591, 5188
14206, 481, 4789, 4800, 482, 4934, 19218, 19240, 4936
14207, 4934, 19218, 19240, 4936, 4935, 19219, 19241, 4937
14208, 4935, 19219, 19241, 4937, 553, 5178, 5189, 554
14209, 4789, 4790, 4801, 4800, 19218, 19220, 19242, 19240
14210, 19218, 19220, 19242, 19240, 19219, 19221, 19243, 19241
14211, 19219, 19221, 19243, 19241, 5178, 5179, 5190, 5189
14212, 4790, 4791, 4802, 4801, 19220, 19222, 19244, 19242
14213, 19220, 19222, 19244, 19242, 19221, 19223, 19245, 19243
14214, 19221, 19223, 19245, 19243, 5179, 5180, 5191, 5190
14215, 4791, 4792, 4803, 4802, 19222, 19224, 19246, 19244
14216, 19222, 19224, 19246, 19244, 19223, 19225, 19247, 19245
14217, 19223, 19225, 19247, 19245, 5180, 5181, 5192, 5191
14218, 4792, 4793, 4804, 4803, 19224, 19226, 19248, 19246
14219, 19224, 19226, 19248, 19246, 19225, 19227, 19249, 19247
14220, 19225, 19227, 19249, 19247, 5181, 5182, 5193, 5192
14221, 4793, 4794, 4805, 4804, 19226, 19228, 19250, 19248
14222, 19226, 19228, 19250, 19248, 19227, 19229, 19251, 19249
14223, 19227, 19229, 19251, 19249, 5182, 5183, 5194, 5193
14224, 4794, 4795, 4806, 4805, 19228, 19230, 19252, 19250
14225, 19228, 19230, 19252, 19250, 19229, 19231, 19253, 19251
14226, 19229, 19231, 19253, 19251, 5183, 5184, 5195, 5194
14227, 4795, 4796, 4807, 4806, 19230, 19232, 19254, 19252
14228, 19230, 19232, 19254, 19252, 19231, 19233, 19255, 19253
14229, 19231, 19233, 19255, 19253, 5184, 5185, 5196, 5195
14230, 4796, 4797, 4808, 4807, 19232, 19234, 19256, 19254
14231, 19232, 19234, 19256, 19254, 19233, 19235, 19257, 19255
14232, 19233, 19235, 19257, 19255, 5185, 5186, 5197, 5196
14233, 4797, 4798, 4809, 4808, 19234, 19236, 19258, 19256
14234, 19234, 19236, 19258, 19256, 19235, 19237, 19259, 19257
14235, 19235, 19237, 19259, 19257, 5186, 5187, 5198, 5197
14236, 4798, 4799, 4810, 4809, 19236, 19238, 19260, 19258
14237, 19236, 19238, 19260, 19258, 19237, 19239, 19261, 19259
14238, 19237, 19239, 19261, 19259, 5187, 5188, 5199, 5198
14239, 4799, 515, 516, 4810, 19238, 5002, 5004, 19260
14240, 19238, 5002, 5004, 19260, 19239, 5003, 5005, 19261
14241, 19239, 5003, 5005, 19261, 5188, 591, 592, 5199
14242, 482, 4800, 4811, 483, 4936, 19240, 19262, 4938
14243, 4936, 19240, 19262, 4938, 4937, 19241, 19263, 4939
14244, 4937, 19241, 19263, 4939, 554, 5189, 5200, 555
14245, 4800, 4801, 4812, 4811, 19240, 19242, 19264, 19262
14246, 19240, 19242, 19264, 19262, 19241, 19243, 19265, 19263
14247, 19241, 19243, 19265, 19263, 5189, 5190, 5201, 5200
14248, 4801, 4802, 4813, 4812, 19242, 19244, 19266, 19264
14249, 19242, 19244, 19266, 19264, 19243, 19245, 19267, 19265
14250, 19243, 19245, 19267, 19265, 5190, 5191, 5202, 5201
14251, 4802, 4803, 4814, 4813, 19244, 19246, 19268, 19266
14252, 19244, 19246, 19268, 19266, 19245, 19247, 19269, 19267
14253, 19245, 19247, 19269, 19267, 5191, 5192, 5203, 5202
14254, 4803, 4804, 4815, 4814, 19246, 19248, 19270, 19268
14255, 19246, 19248, 19270, 19268, 19247, 19249, 19271, 19269
14256, 19247, 19249, 19271, 19269, 5192, 5193, 5204, 5203
14257, 4804, 4805, 4816, 4815, 19248, 19250, 19272, 19270
14258, 19248, 19250, 19272, 19270, 19249, 19251, 19273, 19271
14259, 19249, 19251, 19273, 19271, 5193, 5194, 5205, 5204
14260, 4805, 4806, 4817, 4816, 19250, 19252, 19274, 19272
14261, 19250, 19252, 19274, 19272, 19251, 19253, 19275, 19273
14262, 19251, 19253, 19275, 19273, 5194, 5195, 5206, 5205
14263, 4806, 4807, 4818, 4817, 19252, 19254, 19276, 19274
14264, 19252, 19254, 19276, 19274, 19253, 19255, 19277, 19275
14265, 19253, 19255, 19277, 19275, 5195, 5196, 5207, 5206
14266, 4807, 4808, 4819, 4818, 19254, 19256, 19278, 19276
14267, 19254, 19256, 19278, 19276, 19255, 19257, 19279, 19277
14268, 19255, 19257, 19279, 19277, 5196, 5197, 5208, 5207
14269, 4808, 4809, 4820, 4819, 19256, 19258, 19280, 19278
14270, 19256, 19258, 19280, 19278, 19257, 19259, 19281, 19279
14271, 19257, 19259, 19281, 19279, 5197, 5198, 5209, 5208
14272, 4809, 4810, 4821, 4820, 19258, 19260, 19282, 19280
14273, 19258, 19260, 19282, 19280, 19259, 19261, 19283, 19281
14274, 19259, 19261, 19283, 19281, 5198, 5199, 5210, 5209
14275, 4810, 516, 517, 4821, 19260, 5004, 5006, 19282
14276, 19260, 5004, 5006, 19282, 19261, 5005, 5007, 19283
14277, 19261, 5005, 5007, 19283, 5199, 592, 593, 5210
14278, 483, 4811, 4822, 484, 4938, 19262, 19284, 4940
14279, 4938, 19262, 19284, 4940, 4939, 19263, 19285, 4941
14280, 4939, 19263, 19285, 4941, 555, 5200, 5211, 556
14281, 4811, 4812, 4823, 4822, 19262, 19264, 19286, 19284
14282, 19262, 19264, 19286, 19284, 19263, 19265, 19287, 19285
14283, 19263, 19265, 19287, 19285, 5200, 5201, 5212, 5211
14284, 4812, 4813, 4824, 4823, 19264, 19266, 19288, 19286
14285, 19264, 19266, 19288, 19286, 19265, 19267, 19289, 19287
14286, 19265, 19267, 19289, 19287, 5201, 5202, 5213, 5212
14287, 4813, 4814, 4825, 4824, 19266, 19268, 19290, 19288
14288, 19266, 19268, 19290, 19288, 19267, 19269, 19291, 19289
14289, 19267, 19269, 19291, 19289, 5202, 5203, 5214, 5213
14290, 4814, 4815, 4826, 4825, 19268, 19270, 19292, 19290
14291, 19268, 19270, 19292, 19290, 19269, 19271, 19293, 19291
14292, 19269, 19271, 19293, 19291, 5203, 5204, 5215, 5214
14293, 4815, 4816, 4827, 4826, 19270, 19272, 19294, 19292
14294, 19270, 19272, 19294, 19292, 19271, 19273, 19295, 19293
14295, 19271, 19273, 19295, 19293, 5204, 5205, 5216, 5215
14296, 4816, 4817, 4828, 4827, 19272, 19274, 19296, 19294
14297, 19272, 19274, 19296, 19294, 19273, 19275, 19297, 19295
14298, 19273, 19275, 19297, 19295, 5205, 5206, 5217, 5216
14299, 4817, 4818, 4829, 4828, 19274, 19276, 19298, 19296
14300, 19274, 19276, 19298, 19296, 19275, 19277, 19299, 19297
14301, 19275, 19277, 19299, 19297, 5206, 5207, 5218, 5217
14302, 4818, 4819, 4830, 4829, 19276, 19278, 19300, 19298
14303, 19276, 19278, 19300, 19298, 19277, 19279, 19301, 19299
14304, 19277, 19279, 19301, 19299, 5207, 5208, 5219, 5218
14305, 4819, 4820, 4831, 4830, 19278, 19280, 19302, 19300
14306, 19278, 19280, 19302, 19300, 19279, 19281, 19303, 19301
14307, 19279, 19281, 19303, 19301, 5208, 5209, 5220, 5219
14308, 4820, 4821, 4832, 4831, 19280, 19282, 19304, 19302
14309, 19280, 19282, 19304, 19302, 19281, 19283, 19305, 19303
14310, 19281, 19283, 19305, 19303, 5209, 5210, 5221, 5220
14311, 4821, 517, 518, 4832, 19282, 5006, 5008, 19304
14312, 19282, 5006, 5008, 19304, 19283, 5007, 5009, 19305
14313, 19283, 5007, 5009, 19305, 5210, 593, 594, 5221
14314, 484, 4822, 4833, 485, 4940, 19284, 19306, 4942
14315, 4940, 19284, 19306, 4942, 4941, 19285, 19307, 4943
14316, 4941, 19285, 19307, 4943, 556, 5211, 5222, 557
14317, 4822, 4823, 4834, 4833, 19284, 19286, 19308, 19306
14318, 19284, 19286, 19308, 19306, 19285, 19287, 19309, 19307
14319, 19285, 19287, 19309, 19307, 5211, 5212, 5223, 5222
14320, 4823, 4824, 4835, 4834, 19286, 19288, 19310, 19308
14321, 19286, 19288, 19310, 19308, 19287, 19289, 19311, 19309
14322, 19287, 19289, 19311, 19309, 5212, 5213, 5224, 5223
14323, 4824, 4825, 4836, 4835, 19288, 19290, 19312, 19310
14324, 19288, 19290, 19312, 19310, 19289, 19291, 19313, 19311
14325, 19289, 19291, 19313, 19311, 5213, 5214, 5225, 5224
14326, 4825, 4826, 4837, 4836, 19290, 19292, 19314, 19312
14327, 19290, 19292, 19314, 19312, 19291, 19293, 19315, 19313
14328, 19291, 19293, 19315, 19313, 5214, 5215, 5226, 5225
14329, 4826, 4827, 4838, 4837, 19292, 19294, 19316, 19314
14330, 19292, 19294, 19316, 19314, 19293, 19295, 19317, 19315
14331, 19293, 19295, 19317, 19315, 5215, 5216, 5227, 5226
14332, 4827, 4828, 4839, 4838, 19294, 19296, 19318, 19316
14333, 19294, 19296, 19318, 19316, 19295, 19297, 19319, 19317
14334, 19295, 19297, 19319, 19317, 5216, 5217, 5228, 5227
14335, 4828, 4829, 4840, 4839, 19296, 19298, 19320, 19318
14336, 19296, 19298, 19320, 19318, 19297, 19299, 19321, 19319
14337, 19297, 19299, 19321, 19319, 5217, 5218, 5229, 5228
14338, 4829, 4830, 4841, 4840, 19298, 19300, 19322, 19320
14339, 19298, 19300, 19322, 19320, 19299, 19301, 19323, 19321
14340, 19299, 19301, 19323, 19321, 5218, 5219, 5230, 5229
14341, 4830, 4831, 4842, 4841, 19300, 19302, 19324, 19322
14342, 19300, 19302, 19324, 19322, 19301, 19303, 19325, 19323
14343, 19301, 19303, 19325, 19323, 5219, 5220, 5231, 5230
14344, 4831, 4832, 4843, 4842, 19302, 19304, 19326, 19324
14345, 19302, 19304, 19326, 19324, 19303, 19305, 19327, 19325
14346, 19303, 19305, 19327, 19325, 5220, 5221, 5232, 5231
14347, 4832, 518, 519, 4843, 19304, 5008, 5010, 19326
14348, 19304, 5008, 5010, 19326, 19305, 5009, 5011, 19327
14349, 19305, 5009, 5011, 19327, 5221, 594, 595, 5232
14350, 485, 4833, 4844, 486, 4942, 19306, 19328, 4944
14351, 4942, 19306, 19328, 4944, 4943, 19307, 19329, 4945
14352, 4943, 19307, 19329, 4945, 557, 5222, 5233, 558
14353, 4833, 4834, 4845, 4844, 19306, 19308, 19330, 19328
14354, 19306, 19308, 19330, 19328, 19307, 19309, 19331, 19329
14355, 19307, 19309, 19331, 19329, 5222, 5223, 5234, 5233
14356, 4834, 4835, 4846, 4845, 19308, 19310, 19332, 19330
14357, 19308, 19310, 19332, 19330, 19309, 19311, 19333, 19331
14358, 19309, 19311, 19333, 19331, 5223, 5224, 5235, 5234
14359, 4835, 4836, 4847, 4846, 19310, 19312, 19334, 19332
14360, 19310, 19312, 19334, 19332, 19311, 19313, 19335, 19333
14361, 19311, 19313, 19335, 19333, 5224, 5225, 5236, 5235
14362, 4836, 4837, 4848, 4847, 19312, 19314, 19336, 19334
14363, 19312, 19314, 19336, 19334, 19313, 19315, 19337, 19335
14364, 19313, 19315, 19337, 19335, 5225, 5226, 5237, 5236
14365, 4837, 4838, 4849, 4848, 19314, 19316, 19338, 19336
14366, 19314, 19316, 19338, 19336, 19315, 19317, 19339, 19337
14367, 19315, 19317, 19339, 19337, 5226, 5227, 5238, 5237
14368, 4838, 4839, 4850, 4849, 19316, 19318, 19340, 19338
14369, 19316, 19318, 19340, 19338, 19317, 19319, 19341, 19339
14370, 19317, 19319, 19341, 19339, 5227, 5228, 5239, 5238
14371, 4839, 4840, 4851, 4850, 19318, 19320, 19342, 19340
14372, 19318, 19320, 19342, 19340, 19319, 19321, 19343, 19341
14373, 19319, 19321, 19343, 19341, 5228, 5229, 5240, 5239
14374, 4840, 4841, 4852, 4851, 19320, 19322, 19344, 19342
14375, 19320, 19322, 19344, 19342, 19321, 19323, 19345, 19343
14376, 19321, 19323, 19345, 19343, 5229, 5230, 5241, 5240
14377, 4841, 4842, 4853, 4852, 19322, 19324, 19346, 19344
14378, 19322, 19324, 19346, 19344, 19323, 19325, 19347, 19345
14379, 19323, 19325, 19347, 19345, 5230, 5231, 5242, 5241
14380, 4842, 4843, 4854, 4853, 19324, 19326, 19348, 19346
14381, 19324, 19326, 19348, 19346, 19325, 19327, 19349, 19347
14382, 19325, 19327, 19349, 19347, 5231, 5232, 5243, 5242
14383, 4843, 519, 520, 4854, 19326, 5010, 5012, 19348
14384, 19326, 5010, 5012, 19348, 19327, 5011, 5013, 19349
14385, 19327, 5011, 5013, 19349, 5232, 595, 596, 5243
14386, 486, 4844, 4855, 487, 4944, 19328, 19350, 4946
14387, 4944, 19328, 19350, 4946, 4945, 19329, 19351, 4947
14388, 4945, 19329, 19351, 4947, 558, 5233, 5244, 559
14389, 4844, 4845, 4856, 4855, 19328, 19330, 19352, 19350
14390, 19328, 19330, 19352, 19350, 19329, 19331, 19353, 19351
14391, 19329, 19331, 19353, 19351, 5233, 5234, 5245, 5244
14392, 4845, 4846, 4857, 4856, 19330, 19332, 19354, 19352
14393, 19330, 19332, 19354, 19352, 19331, 19333, 19355, 19353
14394, 19331, 19333, 19355, 19353, 5234, 5235, 5246, 5245
14395, 4846, 4847, 4858, 4857, 19332, 19334, 19356, 19354
14396, 19332, 19334, 19356, 19354, 19333, 19335, 19357, 19355
14397, 19333, 19335, 19357, 19355, 5235, 5236, 5247, 5246
14398, 4847, 4848, 4859, 4858, 19334, 19336, 19358, 19356
14399, 19334, 19336, 19358, 19356, 19335, 19337, 19359, 19357
14400, 19335, 19337, 19359, 19357, 5236, 5237, 5248, 5247
14401, 4848, 4849, 4860, 4859, 19336, 19338, 19360, 19358
14402, 19336, 19338, 19360, 19358, 19337, 19339, 19361, 19359
14403, 19337, 19339, 19361, 19359, 5237, 5238, 5249, 5248
14404, 4849, 4850, 4861, 4860, 19338, 19340, 19362, 19360
14405, 19338, 19340, 19362, 19360, 19339, 19341, 19363, 19361
14406, 19339, 19341, 19363, 19361, 5238, 5239, 5250, 5249
14407, 4850, 4851, 4862, 4861, 19340, 19342, 19364, 19362
14408, 19340, 19342, 19364, 19362, 19341, 19343, 19365, 19363
14409, 19341, 19343, 19365, 19363, 5239, 5240, 5251, 5250
14410, 4851, 4852, 4863, 4862, 19342, 19344, 19366, 19364
14411, 19342, 19344, 19366, 19364, 19343, 19345, 19367, 19365
14412, 19343, 19345, 19367, 19365, 5240, 5241, 5252, 5251
14413, 4852, 4853, 4864, 4863, 19344, 19346, 19368, 19366
14414, 19344, 19346, 19368, 19366, 19345, 19347, 19369, 19367
14415, 19345, 19347, 19369, 19367, 5241, 5242, 5253, 5252
14416, 4853, 4854, 4865, 4864, 19346, 19348, 19370, 19368
14417, 19346, 19348, 19370, 19368, 19347, 19349, 19371, 19369
14418, 19347, 19349, 19371, 19369, 5242, 5243, 5254, 5253
14419, 4854, 520, 521, 4865, 19348, 5012, 5014, 19370
14420, 19348, 5012, 5014, 19370, 19349, 5013, 5015, 19371
14421, 19349, 5013, 5015, 19371, 5243, 596, 597, 5254
14422, 487, 4855, 4866, 488, 4946, 19350, 19372, 4948
14423, 4946, 19350, 19372, 4948, 4947, 19351, 19373, 4949
14424, 4947, 19351, 19373, 4949, 559, 5244, 5255, 560
14425, 4855, 4856, 4867, 4866, 19350, 19352, 19374, 19372
14426, 19350, 19352, 19374, 19372, 19351, 19353, 19375, 19373
14427, 19351, 19353, 19375, 19373, 5244, 5245, 5256, 5255
14428, 4856, 4857, 4868, 4867, 19352, 19354, 19376, 19374
14429, 19352, 19354, 19376, 19374, 19353, 19355, 19377, 19375
14430, 19353, 19355, 19377, 19375, 5245, 5246, 5257, 5256
14431, 4857, 4858, 4869, 4868, 19354, 19356, 19378, 19376
14432, 19354, 19356, 19378, 19376, 19355, 19357, 19379, 19377
14433, 19355, 19357, 19379, 19377, 5246, 5247, 5258, 5257
14434, 4858, 4859, 4870, 4869, 19356, 19358, 19380, 19378
14435, 19356, 19358, 19380, 19378, 19357, 19359, 19381, 19379
14436, 19357, 19359, 19381, 19379, 5247, 5248, 5259, 5258
14437, 4859, 4860, 4871, 4870, 19358, 19360, 19382, 19380
14438, 19358, 19360, 19382, 19380, 19359, 19361, 19383, 19381
14439, 19359, 19361, 19383, 19381, 5248, 5249, 5260, 5259
14440, 4860, 4861, 4872, 4871, 19360, 19362, 19384, 19382
14441, 19360, 19362, 19384, 19382, 19361, 19363, 19385, 19383
14442, 19361, 19363, 19385, 19383, 5249, 5250, 5261, 5260
14443, 4861, 4862, 4873, 4872, 19362, 19364, 19386, 19384
14444, 19362, 19364, 19386, 19384, 19363, 19365, 19387, 19385
14445, 19363, 19365, 19387, 19385, 5250, 5251, 5262, 5261
14446, 4862, 4863, 4874, 4873, 19364, 19366, 19388, 19386
14447, 19364, 19366, 19388, 19386, 19365, 19367, 19389, 19387
14448, 19365, 19367, 19389, 19387, 5251, 5252, 5263, 5262
14449, 4863, 4864, 4875, 4874, 19366, 19368, 19390, 19388
14450, 19366, 19368, 19390, 19388, 19367, 19369, 19391, 19389
14451, 19367, 19369, 19391, 19389, 5252, 5253, 5264, 5263
14452, 4864, 4865, 4876, 4875, 19368, 19370, 19392, 19390
14453, 19368, 19370, 19392, 19390, 19369, 19371, 19393, 19391
14454, 19369, 19371, 19393, 19391, 5253, 5254, 5265, 5264
14455, 4865, 521, 522, 4876, 19370, 5014, 5016, 19392
14456, 19370, 5014, 5016, 19392, 19371, 5015, 5017, 19393
14457, 19371, 5015, 5017, 19393, 5254, 597, 598, 5265
14458, 488, 4866, 4877, 489, 4948, 19372, 19394, 4950
14459, 4948, 19372, 19394, 4950, 4949, 19373, 19395, 4951
14460, 4949, 19373, 19395, 4951, 560, 5255, 5266, 561
14461, 4866, 4867, 4878, 4877, 19372, 19374, 19396, 19394
14462, 19372, 19374, 19396, 19394, 19373, 19375, 19397, 19395
14463, 19373, 19375, 19397, 19395, 5255, 5256, 5267, 5266
14464, 4867, 4868, 4879, 4878, 19374, 19376, 19398, 19396
14465, 19374, 19376, 19398, 19396, 19375, 19377, 19399, 19397
14466, 19375, 19377, 19399, 19397, 5256, 5257, 5268, 5267
14467, 4868, 4869, 4880, 4879, 19376, 19378, 19400, 19398
14468, 19376, 19378, 19400, 19398, 19377, 19379, 19401, 19399
14469, 19377, 19379, 19401, 19399, 5257, 5258, 5269, 5268
14470, 4869, 4870, 4881, 4880, 19378, 19380, 19402, 19400
14471, 19378, 19380, 19402, 19400, 19379, 19381, 19403, 19401
14472, 19379, 19381, 19403, 19401, 5258, 5259, 5270, 5269
14473, 4870, 4871, 4882, 4881, 19380, 19382, 19404, 19402
14474, 19380, 19382, 19404, 19402, 19381, 19383, 19405, 19403
14475, 19381, 19383, 19405, 19403, 5259, 5260, 5271, 5270
14476, 4871, 4872, 4883, 4882, 19382, 19384, 19406, 19404
14477, 19382, 19384, 19406, 19404, 19383, 19385, 19407, 19405
14478, 19383, 19385, 19407, 19405, 5260, 5261, 5272, 5271
14479, 4872, 4873, 4884, 4883, 19384, 19386, 19408, 19406
14480, 19384, 19386, 19408, 19406, 19385, 19387, 19409, 19407
14481, 19385, 19387, 19409, 19407, 5261, 5262, 5273, 5272
14482, 4873, 4874, 4885, 4884, 19386, 19388, 19410, 19408
14483, 19386, 19388, 19410, 19408, 19387, 19389, 19411, 19409
14484, 19387, 19389, 19411, 19409, 5262, 5263, 5274, 5273
14485, 4874, 4875, 4886, 4885, 19388, 19390, 19412, 19410
14486, 19388, 19390, 19412, 19410, 19389, 19391, 19413, 19411
14487, 19389, 19391, 19413, 19411, 5263, 5264, 5275, 5274
14488, 4875, 4876, 4887, 4886, 19390, 19392, 19414, 19412
14489, 19390, 19392, 19414, 19412, 19391, 19393, 19415, 19413
14490, 19391, 19393, 19415, 19413, 5264, 5265, 5276, 5275
14491, 4876, 522, 523, 4887, 19392, 5016, 5018, 19414
14492, 19392, 5016, 5018, 19414, 19393, 5017, 5019, 19415
14493, 19393, 5017, 5019, 19415, 5265, 598, 599, 5276
14494, 489, 4877, 4888, 490, 4950, 19394, 19416, 4952
14495, 4950, 19394, 19416, 4952, 4951, 19395, 19417, 4953
14496, 4951, 19395, 19417, 4953, 561, 5266, 5277, 562
14497, 4877, 4878, 4889, 4888, 19394, 19396, 19418, 19416
14498, 19394, 19396, 19418, 19416, 19395, 19397, 19419, 19417
14499, 19395, 19397, 19419, 19417, 5266, 5267, 5278, 5277
14500, 4878, 4879, 4890, 4889, 19396, 19398, 19420, 19418
14501, 19396, 19398, 19420, 19418, 19397, 19399, 19421, 19419
14502, 19397, 19399, 19421, 19419, 5267, 5268, 5279, 5278
14503, 4879, 4880, 4891, 4890, 19398, 19400, 19422, 19420
14504, 19398, 19400, 19422, 19420, 19399, 19401, 19423, 19421
14505, 19399, 19401, 19423, 19421, 5268, 5269, 5280, 5279
14506, 4880, 4881, 4892, 4891, 19400, 19402, 19424, 19422
14507, 19400, 19402, 19424, 19422, 19401, 19403, 19425, 19423
14508, 19401, 19403, 19425, 19423, 5269, 5270, 5281, 5280
14509, 4881, 4882, 4893, 4892, 19402, 19404, 19426, 19424
14510, 19402, 19404, 19426, 19424, 19403, 19405, 19427, 19425
14511, 19403, 19405, 19427, 19425, 5270, 5271, 5282, 5281
14512, 4882, 4883, 4894, 4893, 19404, 19406, 19428, 19426
14513, 19404, 19406, 19428, 19426, 19405, 19407, 19429, 19427
14514, 19405, 19407, 19429, 19427, 5271, 5272, 5283, 5282
14515, 4883, 4884, 4895, 4894, 19406, 19408, 19430, 19428
14516, 19406, 19408, 19430, 19428, 19407, 19409, 19431, 19429
14517, 19407, 19409, 19431, 19429, 5272, 5273, 5284, 5283
14518, 4884, 4885, 4896, 4895, 19408, 19410, 19432, 19430
14519, 19408, 19410, 19432, 19430, 19409, 19411, 19433, 19431
14520, 19409, 19411, 19433, 19431, 5273, 5274, 5285, 5284
14521, 4885, 4886, 4897, 4896, 19410, 19412, 19434, 19432
14522, 19410, 19412, 19434, 19432, 19411, 19413, 19435, 19433
14523, 19411, 19413, 19435, 19433, 5274, 5275, 5286, 5285
14524, 4886, 4887, 4898, 4897, 19412, 19414, 19436, 19434
14525, 19412, 19414, 19436, 19434, 19413, 19415, 19437, 19435
14526, 19413, 19415, 19437, 19435, 5275, 5276, 5287, 5286
14527, 4887, 523, 524, 4898, 19414, 5018, 5020, 19436
14528, 19414, 5018, 5020, 19436, 19415, 5019, 5021, 19437
14529, 19415, 5019, 5021, 19437, 5276, 599, 600, 5287
14530, 490, 4888, 4899, 491, 4952, 19416, 19438, 4954
14531, 4952, 19416, 19438, 4954, 4953, 19417, 19439, 4955
14532, 4953, 19417, 19439, 4955, 562, 5277, 5288, 563
14533, 4888, 4889, 4900, 4899, 19416, 19418, 19440, 19438
14534, 19416, 19418, 19440, 19438, 19417, 19419, 19441, 19439
14535, 19417, 19419, 19441, 19439, 5277, 5278, 5289, 5288
14536, 4889, 4890, 4901, 4900, 19418, 19420, 19442, 19440
14537, 19418, 19420, 19442, 19440, 19419, 19421, 19443, 19441
14538, 19419, 19421, 19443, 19441, 5278, 5279, 5290, 5289
14539, 4890, 4891, 4902, 4901, 19420, 19422, 19444, 19442
14540, 19420, 19422, 19444, 19442, 19421, 19423, 19445, 19443
14541, 19421, 19423, 19445, 19443, 5279, 5280, 5291, 5290
14542, 4891, 4892, 4903, 4902, 19422, 19424, 19446, 19444
14543, 19422, 19424, 19446, 19444, 19423, 19425, 19447, 19445
14544, 19423, 19425, 19447, 19445, 5280, 5281, 5292, 5291
14545, 4892, 4893, 4904, 4903, 19424, 19426, 19448, 19446
14546, 19424, 19426, 19448, 19446, 19425, 19427, 19449, 19447
14547, 19425, 19427, 19449, 19447, 5281, 5282, 5293, 5292
14548, 4893, 4894, 4905, 4904, 19426, 19428, 19450, 19448
14549, 19426, 19428, 19450, 19448, 19427, 19429, 19451, 19449
14550, 19427, 19429, 19451, 19449, 5282, 5283, 5294, 5293
14551, 4894, 4895, 4906, 4905, 19428, 19430, 19452, 19450
14552, 19428, 19430, 19452, 19450, 19429, 19431, 19453, 19451
14553, 19429, 19431, 19453, 19451, 5283, 5284, 5295, 5294
14554, 4895, 4896, 4907, 4906, 19430, 19432, 19454, 19452
14555, 19430, 19432, 19454, 19452, 19431, 19433, 19455, 19453
14556, 19431, 19433, 19455, 19453, 5284, 5285, 5296, 5295
14557, 4896, 4897, 4908, 4907, 19432, 19434, 19456, 19454
14558, 19432, 19434, 19456, 19454, 19433, 19435, 19457, 19455
14559, 19433, 19435, 19457, 19455, 5285, 5286, 5297, 5296
14560, 4897, 4898, 4909, 4908, 19434, 19436, 19458, 19456
14561, 19434, 19436, 19458, 19456, 19435, 19437, 19459, 19457
14562, 19435, 19437, 19459, 19457, 5286, 5287, 5298, 5297
14563, 4898, 524, 525, 4909, 19436, 5020, 5022, 19458
14564, 19436, 5020, 5022, 19458, 19437, 5021, 5023, 19459
14565, 19437, 5021, 5023, 19459, 5287, 600, 601, 5298
14566, 491, 4899, 492, 17, 4954, 19438, 4956, 537
14567, 4954, 19438, 4956, 537, 4955, 19439, 4957, 538
14568, 4955, 19439, 4957, 538, 563, 5288, 566, 21
14569, 4899, 4900, 493, 492, 19438, 19440, 4958, 4956
14570, 19438, 19440, 4958, 4956, 19439, 19441, 4959, 4957
14571, 19439, 19441, 4959, 4957, 5288, 5289, 567, 566
14572, 4900, 4901, 494, 493, 19440, 19442, 4960, 4958
14573, 19440, 19442, 4960, 4958, 19441, 19443, 4961, 4959
14574, 19441, 19443, 4961, 4959, 5289, 5290, 568, 567
14575, 4901, 4902, 495, 494, 19442, 19444, 4962, 4960
14576, 19442, 19444, 4962, 4960, 19443, 19445, 4963, 4961
14577, 19443, 19445, 4963, 4961, 5290, 5291, 569, 568
14578, 4902, 4903, 496, 495, 19444, 19446, 4964, 4962
14579, 19444, 19446, 4964, 4962, 19445, 19447, 4965, 4963
14580, 19445, 19447, 4965, 4963, 5291, 5292, 570, 569
14581, 4903, 4904, 497, 496, 19446, 19448, 4966, 4964
14582, 19446, 19448, 4966, 4964, 19447, 19449, 4967, 4965
14583, 19447, 19449, 4967, 4965, 5292, 5293, 571, 570
14584, 4904, 4905, 498, 497, 19448, 19450, 4968, 4966
14585, 19448, 19450, 4968, 4966, 19449, 19451, 4969, 4967
14586, 19449, 19451, 4969, 4967, 5293, 5294, 572, 571
14587, 4905, 4906, 499, 498, 19450, 19452, 4970, 4968
14588, 19450, 19452, 4970, 4968, 19451, 19453, 4971, 4969
14589, 19451, 19453, 4971, 4969, 5294, 5295, 573, 572
14590, 4906, 4907, 500, 499, 19452, 19454, 4972, 4970
14591, 19452, 19454, 4972, 4970, 19453, 19455, 4973, 4971
14592, 19453, 19455, 4973, 4971, 5295, 5296, 574, 573
14593, 4907, 4908, 501, 500, 19454, 19456, 4974, 4972
14594, 19454, 19456, 4974, 4972, 19455, 19457, 4975, 4973
14595, 19455, 19457, 4975, 4973, 5296, 5297, 575, 574
14596, 4908, 4909, 502, 501, 19456, 19458, 4976, 4974
14597, 19456, 19458, 4976, 4974, 19457, 19459, 4977, 4975
14598, 19457, 19459, 4977, 4975, 5297, 5298, 576, 575
14599, 4909, 525, 19, 502, 19458, 5022, 564, 4976
14600, 19458, 5022, 564, 4976, 19459, 5023, 565, 4977
14601, 19459, 5023, 565, 4977, 5298, 601, 23, 576
*ELEMENT, type=C3D8, ELSET=Volume6
14602, 17, 537, 4956, 492, 623, 5307, 19460, 5315
14603, 623, 5307, 19460, 5315, 624, 5308, 19461, 5316
14604, 624, 5308, 19461, 5316, 625, 5309, 19462, 5317
14605, 625, 5309, 19462, 5317, 626, 5310, 19463, 5318
14606, 626, 5310, 19463, 5318, 27, 631, 5403, 633
14607, 537, 538, 4957, 4956, 5307, 5311, 19464, 19460
14608, 5307, 5311, 19464, 19460, 5308, 5312, 19465, 19461
14609, 5308, 5312, 19465, 19461, 5309, 5313, 19466, 19462
14610, 5309, 5313, 19466, 19462, 5310, 5314, 19467, 19463
14611, 5310, 5314, 19467, 19463, 631, 632, 5404, 5403
14612, 538, 21, 566, 4957, 5311, 627, 5359, 19464
14613, 5311, 627, 5359, 19464, 5312, 628, 5360, 19465
14614, 5312, 628, 5360, 19465, 5313, 629, 5361, 19466
14615, 5313, 629, 5361, 19466, 5314, 630, 5362, 19467
14616, 5314, 630, 5362, 19467, 632, 28, 644, 5404
14617, 492, 4956, 4958, 493, 5315, 19460, 19468, 5319
14618, 5315, 19460, 19468, 5319, 5316, 19461, 19469, 5320
14619, 5316, 19461, 19469, 5320, 5317, 19462, 19470, 5321
14620, 5317, 19462, 19470, 5321, 5318, 19463, 19471, 5322
14621, 5318, 19463, 19471, 5322, 633, 5403, 5405, 634
14622, 4956, 4957, 4959, 4958, 19460, 19464, 19472, 19468
14623, 19460, 19464, 19472, 19468, 19461, 19465, 19473, 19469
14624, 19461, 19465, 19473, 19469, 19462, 19466, 19474, 19470
14625, 19462, 19466, 19474, 19470, 19463, 19467, 19475, 19471
14626, 19463, 19467, 19475, 19471, 5403, 5404, 5406, 5405
14627, 4957, 566, 567, 4959, 19464, 5359, 5363, 19472
14628, 19464, 5359, 5363, 19472, 19465, 5360, 5364, 19473
14629, 19465, 5360, 5364, 19473, 19466, 5361, 5365, 19474
14630, 19466, 5361, 5365, 19474, 19467, 5362, 5366, 19475
14631, 19467, 5362, 5366, 19475, 5404, 644, 645, 5406
14632, 493, 4958, 4960, 494, 5319, 19468, 19476, 5323
14633, 5319, 19468, 19476, 5323, 5320, 19469, 19477, 5324
14634, 5320, 19469, 19477, 5324, 5321, 19470, 19478, 5325
14635, 5321, 19470, 19478, 5325, 5322, 19471, 19479, 5326
14636, 5322, 19471, 19479, 5326, 634, 5405, 5407, 635
14637, 4958, 4959, 4961, 4960, 19468, 19472, 19480, 19476
14638, 19468, 19472, 19480, 19476, 19469, 19473, 19481, 19477
14639, 19469, 19473, 19481, 19477, 19470, 19474, 19482, 19478
14640, 19470, 19474, 19482, 19478, 19471, 19475, 19483, 19479
14641, 19471, 19475, 19483, 19479, 5405, 5406, 5408, 5407
14642, 4959, 567, 568, 4961, 19472, 5363, 5367, 19480
14643, 19472, 5363, 5367, 19480, 19473, 5364, 5368, 19481
14644, 19473, 5364, 5368, 19481, 19474, 5365, 5369, 19482
14645, 19474, 5365, 5369, 19482, 19475, 5366, 5370, 19483
14646, 19475, 5366, 5370, 19483, 5406, 645, 646, 5408
14647, 494, 4960, 4962, 495, 5323, 19476, 19484, 5327
14648, 5323, 19476, 19484, 5327, 5324, 19477, 19485, 5328
14649, 5324, 19477, 19485, 5328, 5325, 19478, 19486, 5329
14650, 5325, 19478, 19486, 5329, 5326, 19479, 19487, 5330
14651, 5326, 19479, 19487, 5330, 635, 5407, 5409, 636
14652, 4960, 4961, 4963, 4962, 19476, 19480, 19488, 19484
14653, 19476, 19480, 19488, 19484, 19477, 19481, 19489, 19485
14654, 19477, 19481, 19489, 19485, 19478, 19482, 19490, 19486
14655, 19478, 19482, 19490, 19486, 19479, 19483, 19491, 19487
14656, 19479, 19483, 19491, 19487, 5407, 5408, 5410, 5409
14657, 4961, 568, 569, 4963, 19480, 5367, 5371, 19488
14658, 19480, 5367, 5371, 19488, 19481, 5368, 5372, 19489
14659, 19481, 5368, 5372, 19489, 19482, 5369, 5373, 19490
14660, 19482, 5369, 5373, 19490, 19483, 5370, 5374, 19491
14661, 19483, 5370, 5374, 19491, 5408, 646, 647, 5410
14662, 495, 4962, 4964, 496, 5327, 19484, 19492, 5331
14663, 5327, 19484, 19492, 5331, 5328, 19485, 19493, 5332
14664, 5328, 19485, 19493, 5332, 5329, 19486, 19494, 5333
14665, 5329, 19486, 19494, 5333, 5330, 19487, 19495, 5334
14666, 5330, 19487, 19495, 5334, 636, 5409, 5411, 637
14667, 4962, 4963, 4965, 4964, 19484, 19488, 19496, 19492
14668, 19484, 19488, 19496, 19492, 19485, 19489, 19497, 19493
14669, 19485, 19489, 19497, 19493, 19486, 19490, 19498, 19494
14670, 19486, 19490, 19498, 19494, 19487, 19491, 19499, 19495
14671, 19487, 19491, 19499, 19495, 5409, 5410, 5412, 5411
14672, 4963, 569, 570, 4965, 19488, 5371, 5375, 19496
14673, 19488, 5371, 5375, 19496, 19489, 5372, 5376, 19497
14674, 19489, 5372, 5376, 19497, 19490, 5373, 5377, 19498
14675, 19490, 5373, 5377, 19498, 19491, 5374, 5378, 19499
14676, 19491, 5374, 5378, 19499, 5410, 647, 648, 5412
14677, 496, 4964, 4966, 497, 5331, 19492, 19500, 5335
14678, 5331, 19492, 19500, 5335, 5332, 19493, 19501, 5336
14679, 5332, 19493, 19501, 5336, 5333, 19494, 19502, 5337
14680, 5333, 19494, 19502, 5337, 5334, 19495, 19503, 5338
14681, 5334, 19495, 19503, 5338, 637, 5411, 5413, 638
14682, 4964, 4965, 4967, 4966, 19492, 19496, 19504, 19500
14683, 19492, 19496, 19504, 19500, 19493, 19497, 19505, 19501
14684, 19493, 19497, 19505, 19501, 19494, 19498, 19506, 19502
14685, 19494, 19498, 19506, 19502, 19495, 19499, 19507, 19503
14686, 19495, 19499, 19507, 19503, 5411, 5412, 5414, 5413
14687, 4965, 570, 571, 4967, 19496, 5375, 5379, 19504
14688, 19496, 5375, 5379, 19504, 19497, 5376, 5380, 19505
14689, 19497, 5376, 5380, 19505, 19498, 5377, 5381, 19506
14690, 19498, 5377, 5381, 19506, 19499, 5378, 5382, 19507
14691, 19499, 5378, 5382, 19507, 5412, 648, 649, 5414
14692, 497, 4966, 4968, 498, 5335, 19500, 19508, 5339
14693, 5335, 19500, 19508, 5339, 5336, 19501, 19509, 5340
14694, 5336, 19501, 19509, 5340, 5337, 19502, 19510, 5341
14695, 5337, 19502, 19510, 5341, 5338, 19503, 19511, 5342
14696, 5338, 19503, 19511, 5342, 638, 5413, 5415, 639
14697, 4966, 4967, 4969, 4968, 19500, 19504, 19512, 19508
14698, 19500, 19504, 19512, 19508, 19501, 19505, 19513, 19509
14699, 19501, 19505, 19513, 19509, 19502, 19506, 19514, 19510
14700, 19502, 19506, 19514, 19510, 19503, 19507, 19515, 19511
14701, 19503, 19507, 19515, 19511, 5413, 5414, 5416, 5415
14702, 4967, 571, 572, 4969, 19504, 5379, 5383, 19512
14703, 19504, 5379, 5383, 19512, 19505, 5380, 5384, 19513
14704, 19505, 5380, 5384, 19513, 19506, 5381, 5385, 19514
14705, 19506, 5381, 5385, 19514, 19507, 5382, 5386, 19515
14706, 19507, 5382, 5386, 19515, 5414, 649, 650, 5416
14707, 498, 4968, 4970, 499, 5339, 19508, 19516, 5343
14708, 5339, 19508, 19516, 5343, 5340, 19509, 19517, 5344
14709, 5340, 19509, 19517, 5344, 5341, 19510, 19518, 5345
14710, 5341, 19510, 19518, 5345, 5342, 19511, 19519, 5346
14711, 5342, 19511, 19519, 5346, 639, 5415, 5417, 640
14712, 4968, 4969, 4971, 4970, 19508, 19512, 19520, 19516
14713, 19508, 19512, 19520, 19516, 19509, 19513, 19521, 19517
14714, 19509, 19513, 19521, 19517, 19510, 19514, 19522, 19518
14715, 19510, 19514, 19522, 19518, 19511, 19515, 19523, 19519
14716, 19511, 19515, 19523, 19519, 5415, 5416, 5418, 5417
14717, 4969, 572, 573, 4971, 19512, 5383, 5387, 19520
14718, 19512, 5383, 5387, 19520, 19513, 5384, 5388, 19521
14719, 19513, 5384, 5388, 19521, 19514, 5385, 5389, 19522
14720, 19514, 5385, 5389, 19522, 19515, 5386, 5390, 19523
14721, 19515, 5386, 5390, 19523, 5416, 650, 651, 5418
14722, 499, 4970, 4972, 500, 5343, 19516, 19524, 5347
14723, 5343, 19516, 19524, 5347, 5344, 19517, 19525, 5348
14724, 5344, 19517, 19525, 5348, 5345, 19518, 19526, 5349
14725, 5345, 19518, 19526, 5349, 5346, 19519, 19527, 5350
14726, 5346, 19519, 19527, 5350, 640, 5417, 5419, 641
14727, 4970, 4971, 4973, 4972, 19516, 19520, 19528, 19524
14728, 19516, 19520, 19528, 19524, 19517, 19521, 19529, 19525
14729, 19517, 19521, 19529, 19525, 19518, 19522, 19530, 19526
14730, 19518, 19522, 19530, 19526, 19519, 19523, 19531, 19527
14731, 19519, 19523, 19531, 19527, 5417, 5418, 5420, 5419
14732, 4971, 573, 574, 4973, 19520, 5387, 5391, 19528
14733, 19520, 5387, 5391, 19528, 19521, 5388, 5392, 19529
14734, 19521, 5388, 5392, 19529, 19522, 5389, 5393, 19530
14735, 19522, 5389, 5393, 19530, 19523, 5390, 5394, 19531
14736, 19523, 5390, 5394, 19531, 5418, 651, 652, 5420
14737, 500, 4972, 4974, 501, 5347, 19524, 19532, 5351
14738, 5347, 19524, 19532, 5351, 5348, 19525, 19533, 5352
14739, 5348, 19525, 19533, 5352, 5349, 19526, 19534, 5353
14740, 5349, 19526, 19534, 5353, 5350, 19527, 19535, 5354
14741, 5350, 19527, 19535, 5354, 641, 5419, 5421, 642
14742, 4972, 4973, 4975, 4974, 19524, 19528, 19536, 19532
14743, 19524, 19528, 19536, 19532, 19525, 19529, 19537, 19533
14744, 19525, 19529, 19537, 19533, 19526, 19530, 19538, 19534
14745, 19526, 19530, 19538, 19534, 19527, 19531, 19539, 19535
14746, 19527, 19531, 19539, 19535, 5419, 5420, 5422, 5421
14747, 4973, 574, 575, 4975, 19528, 5391, 5395, 19536
14748, 19528, 5391, 5395, 19536, 19529, 5392, 5396, 19537
14749, 19529, 5392, 5396, 19537, 19530, 5393, 5397, 19538
14750, 19530, 5393, 5397, 19538, 19531, 5394, 5398, 19539
14751, 19531, 5394, 5398, 19539, 5420, 652, 653, 5422
14752, 501, 4974, 4976, 502, 5351, 19532, 19540, 5355
14753, 5351, 19532, 19540, 5355, 5352, 19533, 19541, 5356
14754, 5352, 19533, 19541, 5356, 5353, 19534, 19542, 5357
14755, 5353, 19534, 19542, 5357, 5354, 19535, 19543, 5358
14756, 5354, 19535, 19543, 5358, 642, 5421, 5423, 643
14757, 4974, 4975, 4977, 4976, 19532, 19536, 19544, 19540
14758, 19532, 19536, 19544, 19540, 19533, 19537, 19545, 19541
14759, 19533, 19537, 19545, 19541, 19534, 19538, 19546, 19542
14760, 19534, 19538, 19546, 19542, 19535, 19539, 19547, 19543
14761, 19535, 19539, 19547, 19543, 5421, 5422, 5424, 5423
14762, 4975, 575, 576, 4977, 19536, 5395, 5399, 19544
14763, 19536, 5395, 5399, 19544, 19537, 5396, 5400, 19545
14764, 19537, 5396, 5400, 19545, 19538, 5397, 5401, 19546
14765, 19538, 5397, 5401, 19546, 19539, 5398, 5402, 19547
14766, 19539, 5398, 5402, 19547, 5422, 653, 654, 5424
14767, 502, 4976, 564, 19, 5355, 19540, 5299, 613
14768, 5355, 19540, 5299, 613, 5356, 19541, 5300, 614
14769, 5356, 19541, 5300, 614, 5357, 19542, 5301, 615
14770, 5357, 19542, 5301, 615, 5358, 19543, 5302, 616
14771, 5358, 19543, 5302, 616, 643, 5423, 621, 25
14772, 4976, 4977, 565, 564, 19540, 19544, 5303, 5299
14773, 19540, 19544, 5303, 5299, 19541, 19545, 5304, 5300
14774, 19541, 19545, 5304, 5300, 19542, 19546, 5305, 5301
14775, 19542, 19546, 5305, 5301, 19543, 19547, 5306, 5302
14776, 19543, 19547, 5306, 5302, 5423, 5424, 622, 621
14777, 4977, 576, 23, 565, 19544, 5399, 617, 5303
14778, 19544, 5399, 617, 5303, 19545, 5400, 618, 5304
14779, 19545, 5400, 618, 5304, 19546, 5401, 619, 5305
14780, 19546, 5401, 619, 5305, 19547, 5402, 620, 5306
14781, 19547, 5402, 620, 5306, 5424, 654, 26, 622
*ELEMENT, type=C3D8, ELSET=Volume7
14782, 27, 631, 5403, 633, 703, 5471, 19548, 5517
14783, 703, 5471, 19548, 5517, 704, 5472, 19549, 5518
14784, 704, 5472, 19549, 5518, 705, 5473, 19550, 5519
14785, 705, 5473, 19550, 5519, 706, 5474, 19551, 5520
14786, 706, 5474, 19551, 5520, 707, 5475, 19552, 5521
14787, 707, 5475, 19552, 5521, 708, 5476, 19553, 5522
14788, 708, 5476, 19553, 5522, 709, 5477, 19554, 5523
14789, 709, 5477, 19554, 5523, 710, 5478, 19555, 5524
14790, 710, 5478, 19555, 5524, 711, 5479, 19556, 5525
14791, 711, 5479, 19556, 5525, 712, 5480, 19557, 5526
14792, 712, 5480, 19557, 5526, 713, 5481, 19558, 5527
14793, 713, 5481, 19558, 5527, 714, 5482, 19559, 5528
14794, 714, 5482, 19559, 5528, 715, 5483, 19560, 5529
14795, 715, 5483, 19560, 5529, 716, 5484, 19561, 5530
14796, 716, 5484, 19561, 5530, 717, 5485, 19562, 5531
14797, 717, 5485, 19562, 5531, 718, 5486, 19563, 5532
14798, 718, 5486, 19563, 5532, 719, 5487, 19564, 5533
14799, 719, 5487, 19564, 5533, 720, 5488, 19565, 5534
14800, 720, 5488, 19565, 5534, 721, 5489, 19566, 5535
14801, 721, 5489, 19566, 5535, 722, 5490, 19567, 5536
14802, 722, 5490, 19567, 5536, 723, 5491, 19568, 5537
14803, 723, 5491, 19568, 5537, 724, 5492, 19569, 5538
14804, 724, 5492, 19569, 5538, 725, 5493, 19570, 5539
14805, 725, 5493, 19570, 5539, 31, 749, 6023, 751
14806, 631, 632, 5404, 5403, 5471, 5494, 19571, 19548
14807, 5471, 5494, 19571, 19548, 5472, 5495, 19572, 19549
14808, 5472, 5495, 19572, 19549, 5473, 5496, 19573, 19550
14809, 5473, 5496, 19573, 19550, 5474, 5497, 19574, 19551
14810, 5474, 5497, 19574, 19551, 5475, 5498, 19575, 19552
14811, 5475, 5498, 19575, 19552, 5476, 5499, 19576, 19553
14812, 5476, 5499, 19576, 19553, 5477, 5500, 19577, 19554
14813, 5477, 5500, 19577, 19554, 5478, 5501, 19578, 19555
14814, 5478, 5501, 19578, 19555, 5479, 5502, 19579, 19556
14815, 5479, 5502, 19579, 19556, 5480, 5503, 19580, 19557
14816, 5480, 5503, 19580, 19557, 5481, 5504, 19581, 19558
14817, 5481, 5504, 19581, 19558, 5482, 5505, 19582, 19559
14818, 5482, 5505, 19582, 19559, 5483, 5506, 19583, 19560
14819, 5483, 5506, 19583, 19560, 5484, 5507, 19584, 19561
14820, 5484, 5507, 19584, 19561, 5485, 5508, 19585, 19562
14821, 5485, 5508, 19585, 19562, 5486, 5509, 19586, 19563
14822, 5486, 5509, 19586, 19563, 5487, 5510, 19587, 19564
14823, 5487, 5510, 19587, 19564, 5488, 5511, 19588, 19565
14824, 5488, 5511, 19588, 19565, 5489, 5512, 19589, 19566
14825, 5489, 5512, 19589, 19566, 5490, 5513, 19590, 19567
14826, 5490, 5513, 19590, 19567, 5491, 5514, 19591, 19568
14827, 5491, 5514, 19591, 19568, 5492, 5515, 19592, 19569
14828, 5492, 5515, 19592, 19569, 5493, 5516, 19593, 19570
14829, 5493, 5516, 19593, 19570, 749, 750, 6024, 6023
14830, 632, 28, 644, 5404, 5494, 726, 5770, 19571
14831, 5494, 726, 5770, 19571, 5495, 727, 5771, 19572
14832, 5495, 727, 5771, 19572, 5496, 728, 5772, 19573
14833, 5496, 728, 5772, 19573, 5497, 729, 5773, 19574
14834, 5497, 729, 5773, 19574, 5498, 730, 5774, 19575
14835, 5498, 730, 5774, 19575, 5499, 731, 5775, 19576
14836, 5499, 731, 5775, 19576, 5500, 732, 5776, 19577
14837, 5500, 732, 5776, 19577, 5501, 733, 5777, 19578
14838, 5501, 733, 5777, 19578, 5502, 734, 5778, 19579
14839, 5502, 734, 5778, 19579, 5503, 735, 5779, 19580
14840, 5503, 735, 5779, 19580, 5504, 736, 5780, 19581
14841, 5504, 736, 5780, 19581, 5505, 737, 5781, 19582
14842, 5505, 737, 5781, 19582, 5506, 738, 5782, 19583
14843, 5506, 738, 5782, 19583, 5507, 739, 5783, 19584
14844, 5507, 739, 5783, 19584, 5508, 740, 5784, 19585
14845, 5508, 740, 5784, 19585, 5509, 741, 5785, 19586
14846, 5509, 741, 5785, 19586, 5510, 742, 5786, 19587
14847, 5510, 742, 5786, 19587, 5511, 743, 5787, 19588
14848, 5511, 743, 5787, 19588, 5512, 744, 5788, 19589
14849, 5512, 744, 5788, 19589, 5513, 745, 5789, 19590
14850, 5513, 745, 5789, 19590, 5514, 746, 5790, 19591
14851, 5514, 746, 5790, 19591, 5515, 747, 5791, 19592
14852, 5515, 747, 5791, 19592, 5516, 748, 5792, 19593
14853, 5516, 748, 5792, 19593, 750, 32, 762, 6024
14854, 633, 5403, 5405, 634, 5517, 19548, 19594, 5540
14855, 5517, 19548, 19594, 5540, 5518, 19549, 19595, 5541
14856, 5518, 19549, 19595, 5541, 5519, 19550, 19596, 5542
14857, 5519, 19550, 19596, 5542, 5520, 19551, 19597, 5543
14858, 5520, 19551, 19597, 5543, 5521, 19552, 19598, 5544
14859, 5521, 19552, 19598, 5544, 5522, 19553, 19599, 5545
14860, 5522, 19553, 19599, 5545, 5523, 19554, 19600, 5546
14861, 5523, 19554, 19600, 5546, 5524, 19555, 19601, 5547
14862, 5524, 19555, 19601, 5547, 5525, 19556, 19602, 5548
14863, 5525, 19556, 19602, 5548, 5526, 19557, 19603, 5549
14864, 5526, 19557, 19603, 5549, 5527, 19558, 19604, 5550
14865, 5527, 19558, 19604, 5550, 5528, 19559, 19605, 5551
14866, 5528, 19559, 19605, 5551, 5529, 19560, 19606, 5552
14867, 5529, 19560, 19606, 5552, 5530, 19561, 19607, 5553
14868, 5530, 19561, 19607, 5553, 5531, 19562, 19608, 5554
14869, 5531, 19562, 19608, 5554, 5532, 19563, 19609, 5555
14870, 5532, 19563, 19609, 5555, 5533, 19564, 19610, 5556
14871, 5533, 19564, 19610, 5556, 5534, 19565, 19611, 5557
14872, 5534, 19565, 19611, 5557, 5535, 19566, 19612, 5558
14873, 5535, 19566, 19612, 5558, 5536, 19567, 19613, 5559
14874, 5536, 19567, 19613, 5559, 5537, 19568, 19614, 5560
14875, 5537, 19568, 19614, 5560, 5538, 19569, 19615, 5561
14876, 5538, 19569, 19615, 5561, 5539, 19570, 19616, 5562
14877, 5539, 19570, 19616, 5562, 751, 6023, 6025, 752
14878, 5403, 5404, 5406, 5405, 19548, 19571, 19617, 19594
14879, 19548, 19571, 19617, 19594, 19549, 19572, 19618, 19595
14880, 19549, 19572, 19618, 19595, 19550, 19573, 19619, 19596
14881, 19550, 19573, 19619, 19596, 19551, 19574, 19620, 19597
14882, 19551, 19574, 19620, 19597, 19552, 19575, 19621, 19598
14883, 19552, 19575, 19621, 19598, 19553, 19576, 19622, 19599
14884, 19553, 19576, 19622, 19599, 19554, 19577, 19623, 19600
14885, 19554, 19577, 19623, 19600, 19555, 19578, 19624, 19601
14886, 19555, 19578, 19624, 19601, 19556, 19579, 19625, 19602
14887, 19556, 19579, 19625, 19602, 19557, 19580, 19626, 19603
14888, 19557, 19580, 19626, 19603, 19558, 19581, 19627, 19604
14889, 19558, 19581, 19627, 19604, 19559, 19582, 19628, 19605
14890, 19559, 19582, 19628, 19605, 19560, 19583, 19629, 19606
14891, 19560, 19583, 19629, 19606, 19561, 19584, 19630, 19607
14892, 19561, 19584, 19630, 19607, 19562, 19585, 19631, 19608
14893, 19562, 19585, 19631, 19608, 19563, 19586, 19632, 19609
14894, 19563, 19586, 19632, 19609, 19564, 19587, 19633, 19610
14895, 19564, 19587, 19633, 19610, 19565, 19588, 19634, 19611
14896, 19565, 19588, 19634, 19611, 19566, 19589, 19635, 19612
14897, 19566, 19589, 19635, 19612, 19567, 19590, 19636, 19613
14898, 19567, 19590, 19636, 19613, 19568, 19591, 19637, 19614
14899, 19568, 19591, 19637, 19614, 19569, 19592, 19638, 19615
14900, 19569, 19592, 19638, 19615, 19570, 19593, 19639, 19616
14901, 19570, 19593, 19639, 19616, 6023, 6024, 6026, 6025
14902, 5404, 644, 645, 5406, 19571, 5770, 5793, 19617
14903, 19571, 5770, 5793, 19617, 19572, 5771, 5794, 19618
14904, 19572, 5771, 5794, 19618, 19573, 5772, 5795, 19619
14905, 19573, 5772, 5795, 19619, 19574, 5773, 5796, 19620
14906, 19574, 5773, 5796, 19620, 19575, 5774, 5797, 19621
14907, 19575, 5774, 5797, 19621, 19576, 5775, 5798, 19622
14908, 19576, 5775, 5798, 19622, 19577, 5776, 5799, 19623
14909, 19577, 5776, 5799, 19623, 19578, 5777, 5800, 19624
14910, 19578, 5777, 5800, 19624, 19579, 5778, 5801, 19625
14911, 19579, 5778, 5801, 19625, 19580, 5779, 5802, 19626
14912, 19580, 5779, 5802, 19626, 19581, 5780, 5803, 19627
14913, 19581, 5780, 5803, 19627, 19582, 5781, 5804, 19628
14914, 19582, 5781, 5804, 19628, 19583, 5782, 5805, 19629
14915, 19583, 5782, 5805, 19629, 19584, 5783, 5806, 19630
14916, 19584, 5783, 5806, 19630, 19585, 5784, 5807, 19631
14917, 19585, 5784, 5807, 19631, 19586, 5785, 5808, 19632
14918, 19586, 5785, 5808, 19632, 19587, 5786, 5809, 19633
14919, 19587, 5786, 5809, 19633, 19588, 5787, 5810, 19634
14920, 19588, 5787, 5810, 19634, 19589, 5788, 5811, 19635
14921, 19589, 5788, 5811, 19635, 19590, 5789, 5812, 19636
14922, 19590, 5789, 5812, 19636, 19591, 5790, 5813, 19637
14923, 19591, 5790, 5813, 19637, 19592, 5791, 5814, 19638
14924, 19592, 5791, 5814, 19638, 19593, 5792, 5815, 19639
14925, 19593, 5792, 5815, 19639, 6024, 762, 763, 6026
14926, 634, 5405, 5407, 635, 5540, 19594, 19640, 5563
14927, 5540, 19594, 19640, 5563, 5541, 19595, 19641, 5564
14928, 5541, 19595, 19641, 5564, 5542, 19596, 19642, 5565
14929, 5542, 19596, 19642, 5565, 5543, 19597, 19643, 5566
14930, 5543, 19597, 19643, 5566, 5544, 19598, 19644, 5567
14931, 5544, 19598, 19644, 5567, 5545, 19599, 19645, 5568
14932, 5545, 19599, 19645, 5568, 5546, 19600, 19646, 5569
14933, 5546, 19600, 19646, 5569, 5547, 19601, 19647, 5570
14934, 5547, 19601, 19647, 5570, 5548, 19602, 19648, 5571
14935, 5548, 19602, 19648, 5571, 5549, 19603, 19649, 5572
14936, 5549, 19603, 19649, 5572, 5550, 19604, 19650, 5573
14937, 5550, 19604, 19650, 5573, 5551, 19605, 19651, 5574
14938, 5551, 19605, 19651, 5574, 5552, 19606, 19652, 5575
14939, 5552, 19606, 19652, 5575, 5553, 19607, 19653, 5576
14940, 5553, 19607, 19653, 5576, 5554, 19608, 19654, 5577
14941, 5554, 19608, 19654, 5577, 5555, 19609, 19655, 5578
14942, 5555, 19609, 19655, 5578, 5556, 19610, 19656, 5579
14943, 5556, 19610, 19656, 5579, 5557, 19611, 19657, 5580
14944, 5557, 19611, 19657, 5580, 5558, 19612, 19658, 5581
14945, 5558, 19612, 19658, 5581, 5559, 19613, 19659, 5582
14946, 5559, 19613, 19659, 5582, 5560, 19614, 19660, 5583
14947, 5560, 19614, 19660, 5583, 5561, 19615, 19661, 5584
14948, 5561, 19615, 19661, 5584, 5562, 19616, 19662, 5585
14949, 5562, 19616, 19662, 5585, 752, 6025, 6027, 753
14950, 5405, 5406, 5408, 5407, 19594, 19617, 19663, 19640
14951, 19594, 19617, 19663, 19640, 19595, 19618, 19664, 19641
14952, 19595, 19618, 19664, 19641, 19596, 19619, 19665, 19642
14953, 19596, 19619, 19665, 19642, 19597, 19620, 19666, 19643
14954, 19597, 19620, 19666, 19643, 19598, 19621, 19667, 19644
14955, 19598, 19621, 19667, 19644, 19599, 19622, 19668, 19645
14956, 19599, 19622, 19668, 19645, 19600, 19623, 19669, 19646
14957, 19600, 19623, 19669, 19646, 19601, 19624, 19670, 19647
14958, 19601, 19624, 19670, 19647, 19602, 19625, 19671, 19648
14959, 19602, 19625, 19671, 19648, 19603, 19626, 19672, 19649
14960, 19603, 19626, 19672, 19649, 19604, 19627, 19673, 19650
14961, 19604, 19627, 19673, 19650, 19605, 19628, 19674, 19651
14962, 19605, 19628, 19674, 19651, 19606, 19629, 19675, 19652
14963, 19606, 19629, 19675, 19652, 19607, 19630, 19676, 19653
14964, 19607, 19630, 19676, 19653, 19608, 19631, 19677, 19654
14965, 19608, 19631, 19677, 19654, 19609, 19632, 19678, 19655
14966, 19609, 19632, 19678, 19655, 19610, 19633, 19679, 19656
14967, 19610, 19633, 19679, 19656, 19611, 19634, 19680, 19657
14968, 19611, 19634, 19680, 19657, 19612, 19635, 19681, 19658
14969, 19612, 19635, 19681, 19658, 19613, 19636, 19682, 19659
14970, 19613, 19636, 19682, 19659, 19614, 19637, 19683, 19660
14971, 19614, 19637, 19683, 19660, 19615, 19638, 19684, 19661
14972, 19615, 19638, 19684, 19661, 19616, 19639, 19685, 19662
14973, 19616, 19639, 19685, 19662, 6025, 6026, 6028, 6027
14974, 5406, 645, 646, 5408, 19617, 5793, 5816, 19663
14975, 19617, 5793, 5816, 19663, 19618, 5794, 5817, 19664
14976, 19618, 5794, 5817, 19664, 19619, 5795, 5818, 19665
14977, 19619, 5795, 5818, 19665, 19620, 5796, 5819, 19666
14978, 19620, 5796, 5819, 19666, 19621, 5797, 5820, 19667
14979, 19621, 5797, 5820, 19667, 19622, 5798, 5821, 19668
14980, 19622, 5798, 5821, 19668, 19623, 5799, 5822, 19669
14981, 19623, 5799, 5822, 19669, 19624, 5800, 5823, 19670
14982, 19624, 5800, 5823, 19670, 19625, 5801, 5824, 19671
14983, 19625, 5801, 5824, 19671, 19626, 5802, 5825, 19672
14984, 19626, 5802, 5825, 19672, 19627, 5803, 5826, 19673
14985, 19627, 5803, 5826, 19673, 19628, 5804, 5827, 19674
14986, 19628, 5804, 5827, 19674, 19629, 5805, 5828, 19675
14987, 19629, 5805, 5828, 19675, 19630, 5806, 5829, 19676
14988, 19630, 5806, 5829, 19676, 19631, 5807, 5830, 19677
14989, 19631, 5807, 5830, 19677, 19632, 5808, 5831, 19678
14990, 19632, 5808, 5831, 19678, 19633, 5809, 5832, 19679
14991, 19633, 5809, 5832, 19679, 19634, 5810, 5833, 19680
14992, 19634, 5810, 5833, 19680, 19635, 5811, 5834, 19681
14993, 19635, 5811, 5834, 19681, 19636, 5812, 5835, 19682
14994, 19636, 5812, 5835, 19682, 19637, 5813, 5836, 19683
14995, 19637, 5813, 5836, 19683, 19638, 5814, 5837, 19684
14996, 19638, 5814, 5837, 19684, 19639, 5815, 5838, 19685
14997, 19639, 5815, 5838, 19685, 6026, 763, 764, 6028
14998, 635, 5407, 5409, 636, 5563, 19640, 19686, 5586
14999, 5563, 19640, 19686, 5586, 5564, 19641, 19687, 5587
15000, 5564, 19641, 19687, 5587, 5565, 19642, 19688, 5588
15001, 5565, 19642, 19688, 5588, 5566, 19643, 19689, 5589
15002, 5566, 19643, 19689, 5589, 5567, 19644, 19690, 5590
15003, 5567, 19644, 19690, 5590, 5568, 19645, 19691, 5591
15004, 5568, 19645, 19691, 5591, 5569, 19646, 19692, 5592
15005, 5569, 19646, 19692, 5592, 5570, 19647, 19693, 5593
15006, 5570, 19647, 19693, 5593, 5571, 19648, 19694, 5594
15007, 5571, 19648, 19694, 5594, 5572, 19649, 19695, 5595
15008, 5572, 19649, 19695, 5595, 5573, 19650, 19696, 5596
15009, 5573, 19650, 19696, 5596, 5574, 19651, 19697, 5597
15010, 5574, 19651, 19697, 5597, 5575, 19652, 19698, 5598
15011, 5575, 19652, 19698, 5598, 5576, 19653, 19699, 5599
15012, 5576, 19653, 19699, 5599, 5577, 19654, 19700, 5600
15013, 5577, 19654, 19700, 5600, 5578, 19655, 19701, 5601
15014, 5578, 19655, 19701, 5601, 5579, 19656, 19702, 5602
15015, 5579, 19656, 19702, 5602, 5580, 19657, 19703, 5603
15016, 5580, 19657, 19703, 5603, 5581, 19658, 19704, 5604
15017, 5581, 19658, 19704, 5604, 5582, 19659, 19705, 5605
15018, 5582, 19659, 19705, 5605, 5583, 19660, 19706, 5606
15019, 5583, 19660, 19706, 5606, 5584, 19661, 19707, 5607
15020, 5584, 19661, 19707, 5607, 5585, 19662, 19708, 5608
15021, 5585, 19662, 19708, 5608, 753, 6027, 6029, 754
15022, 5407, 5408, 5410, 5409, 19640, 19663, 19709, 19686
15023, 19640, 19663, 19709, 19686, 19641, 19664, 19710, 19687
15024, 19641, 19664, 19710, 19687, 19642, 19665, 19711, 19688
15025, 19642, 19665, 19711, 19688, 19643, 19666, 19712, 19689
15026, 19643, 19666, 19712, 19689, 19644, 19667, 19713, 19690
15027, 19644, 19667, 19713, 19690, 19645, 19668, 19714, 19691
15028, 19645, 19668, 19714, 19691, 19646, 19669, 19715, 19692
15029, 19646, 19669, 19715, 19692, 19647, 19670, 19716, 19693
15030, 19647, 19670, 19716, 19693, 19648, 19671, 19717, 19694
15031, 19648, 19671, 19717, 19694, 19649, 19672, 19718, 19695
15032, 19649, 19672, 19718, 19695, 19650, 19673, 19719, 19696
15033, 19650, 19673, 19719, 19696, 19651, 19674, 19720, 19697
15034, 19651, 19674, 19720, 19697, 19652, 19675, 19721, 19698
15035, 19652, 19675, 19721, 19698, 19653, 19676, 19722, 19699
15036, 19653, 19676, 19722, 19699, 19654, 19677, 19723, 19700
15037, 19654, 19677, 19723, 19700, 19655, 19678, 19724, 19701
15038, 19655, 19678, 19724, 19701, 19656, 19679, 19725, 19702
15039, 19656, 19679, 19725, 19702, 19657, 19680, 19726, 19703
15040, 19657, 19680, 19726, 19703, 19658, 19681, 19727, 19704
15041, 19658, 19681, 19727, 19704, 19659, 19682, 19728, 19705
15042, 19659, 19682, 19728, 19705, 19660, 19683, 19729, 19706
15043, 19660, 19683, 19729, 19706, 19661, 19684, 19730, 19707
15044, 19661, 19684, 19730, 19707, 19662, 19685, 19731, 19708
15045, 19662, 19685, 19731, 19708, 6027, 6028, 6030, 6029
15046, 5408, 646, 647, 5410, 19663, 5816, 5839, 19709
15047, 19663, 5816, 5839, 19709, 19664, 5817, 5840, 19710
15048, 19664, 5817, 5840, 19710, 19665, 5818, 5841, 19711
15049, 19665, 5818, 5841, 19711, 19666, 5819, 5842, 19712
15050, 19666, 5819, 5842, 19712, 19667, 5820, 5843, 19713
15051, 19667, 5820, 5843, 19713, 19668, 5821, 5844, 19714
15052, 19668, 5821, 5844, 19714, 19669, 5822, 5845, 19715
15053, 19669, 5822, 5845, 19715, 19670, 5823, 5846, 19716
15054, 19670, 5823, 5846, 19716, 19671, 5824, 5847, 19717
15055, 19671, 5824, 5847, 19717, 19672, 5825, 5848, 19718
15056, 19672, 5825, 5848, 19718, 19673, 5826, 5849, 19719
15057, 19673, 5826, 5849, 19719, 19674, 5827, 5850, 19720
15058, 19674, 5827, 5850, 19720, 19675, 5828, 5851, 19721
15059, 19675, 5828, 5851, 19721, 19676, 5829, 5852, 19722
15060, 19676, 5829, 5852, 19722, 19677, 5830, 5853, 19723
15061, 19677, 5830, 5853, 19723, 19678, 5831, 5854, 19724
15062, 19678, 5831, 5854, 19724, 19679, 5832, 5855, 19725
15063, 19679, 5832, 5855, 19725, 19680, 5833, 5856, 19726
15064, 19680, 5833, 5856, 19726, 19681, 5834, 5857, 19727
15065, 19681, 5834, 5857, 19727, 19682, 5835, 5858, 19728
15066, 19682, 5835, 5858, 19728, 19683, 5836, 5859, 19729
15067, 19683, 5836, 5859, 19729, 19684, 5837, 5860, 19730
15068, 19684, 5837, 5860, 19730, 19685, 5838, 5861, 19731
15069, 19685, 5838, 5861, 19731, 6028, 764, 765, 6030
15070, 636, 5409, 5411, 637, 5586, 19686, 19732, 5609
15071, 5586, 19686, 19732, 5609, 5587, 19687, 19733, 5610
15072, 5587, 19687, 19733, 5610, 5588, 19688, 19734, 5611
15073, 5588, 19688, 19734, 5611, 5589, 19689, 19735, 5612
15074, 5589, 19689, 19735, 5612, 5590, 19690, 19736, 5613
15075, 5590, 19690, 19736, 5613, 5591, 19691, 19737, 5614
15076, 5591, 19691, 19737, 5614, 5592, 19692, 19738, 5615
15077, 5592, 19692, 19738, 5615, 5593, 19693, 19739, 5616
15078, 5593, 19693, 19739, 5616, 5594, 19694, 19740, 5617
15079, 5594, 19694, 19740, 5617, 5595, 19695, 19741, 5618
15080, 5595, 19695, 19741, 5618, 5596, 19696, 19742, 5619
15081, 5596, 19696, 19742, 5619, 5597, 19697, 19743, 5620
15082, 5597, 19697, 19743, 5620, 5598, 19698, 19744, 5621
15083, 5598, 19698, 19744, 5621, 5599, 19699, 19745, 5622
