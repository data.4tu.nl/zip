23421, 26010, 8487, 8489, 26056, 8572, 1136, 1137, 8595
23422, 1050, 8184, 8207, 1051, 8466, 26011, 26057, 8468
23423, 8466, 26011, 26057, 8468, 8467, 26012, 26058, 8469
23424, 8467, 26012, 26058, 8469, 1126, 8573, 8596, 1127
23425, 8184, 8185, 8208, 8207, 26011, 26013, 26059, 26057
23426, 26011, 26013, 26059, 26057, 26012, 26014, 26060, 26058
23427, 26012, 26014, 26060, 26058, 8573, 8574, 8597, 8596
23428, 8185, 8186, 8209, 8208, 26013, 26015, 26061, 26059
23429, 26013, 26015, 26061, 26059, 26014, 26016, 26062, 26060
23430, 26014, 26016, 26062, 26060, 8574, 8575, 8598, 8597
23431, 8186, 8187, 8210, 8209, 26015, 26017, 26063, 26061
23432, 26015, 26017, 26063, 26061, 26016, 26018, 26064, 26062
23433, 26016, 26018, 26064, 26062, 8575, 8576, 8599, 8598
23434, 8187, 8188, 8211, 8210, 26017, 26019, 26065, 26063
23435, 26017, 26019, 26065, 26063, 26018, 26020, 26066, 26064
23436, 26018, 26020, 26066, 26064, 8576, 8577, 8600, 8599
23437, 8188, 8189, 8212, 8211, 26019, 26021, 26067, 26065
23438, 26019, 26021, 26067, 26065, 26020, 26022, 26068, 26066
23439, 26020, 26022, 26068, 26066, 8577, 8578, 8601, 8600
23440, 8189, 8190, 8213, 8212, 26021, 26023, 26069, 26067
23441, 26021, 26023, 26069, 26067, 26022, 26024, 26070, 26068
23442, 26022, 26024, 26070, 26068, 8578, 8579, 8602, 8601
23443, 8190, 8191, 8214, 8213, 26023, 26025, 26071, 26069
23444, 26023, 26025, 26071, 26069, 26024, 26026, 26072, 26070
23445, 26024, 26026, 26072, 26070, 8579, 8580, 8603, 8602
23446, 8191, 8192, 8215, 8214, 26025, 26027, 26073, 26071
23447, 26025, 26027, 26073, 26071, 26026, 26028, 26074, 26072
23448, 26026, 26028, 26074, 26072, 8580, 8581, 8604, 8603
23449, 8192, 8193, 8216, 8215, 26027, 26029, 26075, 26073
23450, 26027, 26029, 26075, 26073, 26028, 26030, 26076, 26074
23451, 26028, 26030, 26076, 26074, 8581, 8582, 8605, 8604
23452, 8193, 8194, 8217, 8216, 26029, 26031, 26077, 26075
23453, 26029, 26031, 26077, 26075, 26030, 26032, 26078, 26076
23454, 26030, 26032, 26078, 26076, 8582, 8583, 8606, 8605
23455, 8194, 8195, 8218, 8217, 26031, 26033, 26079, 26077
23456, 26031, 26033, 26079, 26077, 26032, 26034, 26080, 26078
23457, 26032, 26034, 26080, 26078, 8583, 8584, 8607, 8606
23458, 8195, 8196, 8219, 8218, 26033, 26035, 26081, 26079
23459, 26033, 26035, 26081, 26079, 26034, 26036, 26082, 26080
23460, 26034, 26036, 26082, 26080, 8584, 8585, 8608, 8607
23461, 8196, 8197, 8220, 8219, 26035, 26037, 26083, 26081
23462, 26035, 26037, 26083, 26081, 26036, 26038, 26084, 26082
23463, 26036, 26038, 26084, 26082, 8585, 8586, 8609, 8608
23464, 8197, 8198, 8221, 8220, 26037, 26039, 26085, 26083
23465, 26037, 26039, 26085, 26083, 26038, 26040, 26086, 26084
23466, 26038, 26040, 26086, 26084, 8586, 8587, 8610, 8609
23467, 8198, 8199, 8222, 8221, 26039, 26041, 26087, 26085
23468, 26039, 26041, 26087, 26085, 26040, 26042, 26088, 26086
23469, 26040, 26042, 26088, 26086, 8587, 8588, 8611, 8610
23470, 8199, 8200, 8223, 8222, 26041, 26043, 26089, 26087
23471, 26041, 26043, 26089, 26087, 26042, 26044, 26090, 26088
23472, 26042, 26044, 26090, 26088, 8588, 8589, 8612, 8611
23473, 8200, 8201, 8224, 8223, 26043, 26045, 26091, 26089
23474, 26043, 26045, 26091, 26089, 26044, 26046, 26092, 26090
23475, 26044, 26046, 26092, 26090, 8589, 8590, 8613, 8612
23476, 8201, 8202, 8225, 8224, 26045, 26047, 26093, 26091
23477, 26045, 26047, 26093, 26091, 26046, 26048, 26094, 26092
23478, 26046, 26048, 26094, 26092, 8590, 8591, 8614, 8613
23479, 8202, 8203, 8226, 8225, 26047, 26049, 26095, 26093
23480, 26047, 26049, 26095, 26093, 26048, 26050, 26096, 26094
23481, 26048, 26050, 26096, 26094, 8591, 8592, 8615, 8614
23482, 8203, 8204, 8227, 8226, 26049, 26051, 26097, 26095
23483, 26049, 26051, 26097, 26095, 26050, 26052, 26098, 26096
23484, 26050, 26052, 26098, 26096, 8592, 8593, 8616, 8615
23485, 8204, 8205, 8228, 8227, 26051, 26053, 26099, 26097
23486, 26051, 26053, 26099, 26097, 26052, 26054, 26100, 26098
23487, 26052, 26054, 26100, 26098, 8593, 8594, 8617, 8616
23488, 8205, 8206, 8229, 8228, 26053, 26055, 26101, 26099
23489, 26053, 26055, 26101, 26099, 26054, 26056, 26102, 26100
23490, 26054, 26056, 26102, 26100, 8594, 8595, 8618, 8617
23491, 8206, 1061, 1062, 8229, 26055, 8488, 8490, 26101
23492, 26055, 8488, 8490, 26101, 26056, 8489, 8491, 26102
23493, 26056, 8489, 8491, 26102, 8595, 1137, 1138, 8618
23494, 1051, 8207, 8230, 1052, 8468, 26057, 26103, 8470
23495, 8468, 26057, 26103, 8470, 8469, 26058, 26104, 8471
23496, 8469, 26058, 26104, 8471, 1127, 8596, 8619, 1128
23497, 8207, 8208, 8231, 8230, 26057, 26059, 26105, 26103
23498, 26057, 26059, 26105, 26103, 26058, 26060, 26106, 26104
23499, 26058, 26060, 26106, 26104, 8596, 8597, 8620, 8619
23500, 8208, 8209, 8232, 8231, 26059, 26061, 26107, 26105
23501, 26059, 26061, 26107, 26105, 26060, 26062, 26108, 26106
23502, 26060, 26062, 26108, 26106, 8597, 8598, 8621, 8620
23503, 8209, 8210, 8233, 8232, 26061, 26063, 26109, 26107
23504, 26061, 26063, 26109, 26107, 26062, 26064, 26110, 26108
23505, 26062, 26064, 26110, 26108, 8598, 8599, 8622, 8621
23506, 8210, 8211, 8234, 8233, 26063, 26065, 26111, 26109
23507, 26063, 26065, 26111, 26109, 26064, 26066, 26112, 26110
23508, 26064, 26066, 26112, 26110, 8599, 8600, 8623, 8622
23509, 8211, 8212, 8235, 8234, 26065, 26067, 26113, 26111
23510, 26065, 26067, 26113, 26111, 26066, 26068, 26114, 26112
23511, 26066, 26068, 26114, 26112, 8600, 8601, 8624, 8623
23512, 8212, 8213, 8236, 8235, 26067, 26069, 26115, 26113
23513, 26067, 26069, 26115, 26113, 26068, 26070, 26116, 26114
23514, 26068, 26070, 26116, 26114, 8601, 8602, 8625, 8624
23515, 8213, 8214, 8237, 8236, 26069, 26071, 26117, 26115
23516, 26069, 26071, 26117, 26115, 26070, 26072, 26118, 26116
23517, 26070, 26072, 26118, 26116, 8602, 8603, 8626, 8625
23518, 8214, 8215, 8238, 8237, 26071, 26073, 26119, 26117
23519, 26071, 26073, 26119, 26117, 26072, 26074, 26120, 26118
23520, 26072, 26074, 26120, 26118, 8603, 8604, 8627, 8626
23521, 8215, 8216, 8239, 8238, 26073, 26075, 26121, 26119
23522, 26073, 26075, 26121, 26119, 26074, 26076, 26122, 26120
23523, 26074, 26076, 26122, 26120, 8604, 8605, 8628, 8627
23524, 8216, 8217, 8240, 8239, 26075, 26077, 26123, 26121
23525, 26075, 26077, 26123, 26121, 26076, 26078, 26124, 26122
23526, 26076, 26078, 26124, 26122, 8605, 8606, 8629, 8628
23527, 8217, 8218, 8241, 8240, 26077, 26079, 26125, 26123
23528, 26077, 26079, 26125, 26123, 26078, 26080, 26126, 26124
23529, 26078, 26080, 26126, 26124, 8606, 8607, 8630, 8629
23530, 8218, 8219, 8242, 8241, 26079, 26081, 26127, 26125
23531, 26079, 26081, 26127, 26125, 26080, 26082, 26128, 26126
23532, 26080, 26082, 26128, 26126, 8607, 8608, 8631, 8630
23533, 8219, 8220, 8243, 8242, 26081, 26083, 26129, 26127
23534, 26081, 26083, 26129, 26127, 26082, 26084, 26130, 26128
23535, 26082, 26084, 26130, 26128, 8608, 8609, 8632, 8631
23536, 8220, 8221, 8244, 8243, 26083, 26085, 26131, 26129
23537, 26083, 26085, 26131, 26129, 26084, 26086, 26132, 26130
23538, 26084, 26086, 26132, 26130, 8609, 8610, 8633, 8632
23539, 8221, 8222, 8245, 8244, 26085, 26087, 26133, 26131
23540, 26085, 26087, 26133, 26131, 26086, 26088, 26134, 26132
23541, 26086, 26088, 26134, 26132, 8610, 8611, 8634, 8633
23542, 8222, 8223, 8246, 8245, 26087, 26089, 26135, 26133
23543, 26087, 26089, 26135, 26133, 26088, 26090, 26136, 26134
23544, 26088, 26090, 26136, 26134, 8611, 8612, 8635, 8634
23545, 8223, 8224, 8247, 8246, 26089, 26091, 26137, 26135
23546, 26089, 26091, 26137, 26135, 26090, 26092, 26138, 26136
23547, 26090, 26092, 26138, 26136, 8612, 8613, 8636, 8635
23548, 8224, 8225, 8248, 8247, 26091, 26093, 26139, 26137
23549, 26091, 26093, 26139, 26137, 26092, 26094, 26140, 26138
23550, 26092, 26094, 26140, 26138, 8613, 8614, 8637, 8636
23551, 8225, 8226, 8249, 8248, 26093, 26095, 26141, 26139
23552, 26093, 26095, 26141, 26139, 26094, 26096, 26142, 26140
23553, 26094, 26096, 26142, 26140, 8614, 8615, 8638, 8637
23554, 8226, 8227, 8250, 8249, 26095, 26097, 26143, 26141
23555, 26095, 26097, 26143, 26141, 26096, 26098, 26144, 26142
23556, 26096, 26098, 26144, 26142, 8615, 8616, 8639, 8638
23557, 8227, 8228, 8251, 8250, 26097, 26099, 26145, 26143
23558, 26097, 26099, 26145, 26143, 26098, 26100, 26146, 26144
23559, 26098, 26100, 26146, 26144, 8616, 8617, 8640, 8639
23560, 8228, 8229, 8252, 8251, 26099, 26101, 26147, 26145
23561, 26099, 26101, 26147, 26145, 26100, 26102, 26148, 26146
23562, 26100, 26102, 26148, 26146, 8617, 8618, 8641, 8640
23563, 8229, 1062, 1063, 8252, 26101, 8490, 8492, 26147
23564, 26101, 8490, 8492, 26147, 26102, 8491, 8493, 26148
23565, 26102, 8491, 8493, 26148, 8618, 1138, 1139, 8641
23566, 1052, 8230, 8253, 1053, 8470, 26103, 26149, 8472
23567, 8470, 26103, 26149, 8472, 8471, 26104, 26150, 8473
23568, 8471, 26104, 26150, 8473, 1128, 8619, 8642, 1129
23569, 8230, 8231, 8254, 8253, 26103, 26105, 26151, 26149
23570, 26103, 26105, 26151, 26149, 26104, 26106, 26152, 26150
23571, 26104, 26106, 26152, 26150, 8619, 8620, 8643, 8642
23572, 8231, 8232, 8255, 8254, 26105, 26107, 26153, 26151
23573, 26105, 26107, 26153, 26151, 26106, 26108, 26154, 26152
23574, 26106, 26108, 26154, 26152, 8620, 8621, 8644, 8643
23575, 8232, 8233, 8256, 8255, 26107, 26109, 26155, 26153
23576, 26107, 26109, 26155, 26153, 26108, 26110, 26156, 26154
23577, 26108, 26110, 26156, 26154, 8621, 8622, 8645, 8644
23578, 8233, 8234, 8257, 8256, 26109, 26111, 26157, 26155
23579, 26109, 26111, 26157, 26155, 26110, 26112, 26158, 26156
23580, 26110, 26112, 26158, 26156, 8622, 8623, 8646, 8645
23581, 8234, 8235, 8258, 8257, 26111, 26113, 26159, 26157
23582, 26111, 26113, 26159, 26157, 26112, 26114, 26160, 26158
23583, 26112, 26114, 26160, 26158, 8623, 8624, 8647, 8646
23584, 8235, 8236, 8259, 8258, 26113, 26115, 26161, 26159
23585, 26113, 26115, 26161, 26159, 26114, 26116, 26162, 26160
23586, 26114, 26116, 26162, 26160, 8624, 8625, 8648, 8647
23587, 8236, 8237, 8260, 8259, 26115, 26117, 26163, 26161
23588, 26115, 26117, 26163, 26161, 26116, 26118, 26164, 26162
23589, 26116, 26118, 26164, 26162, 8625, 8626, 8649, 8648
23590, 8237, 8238, 8261, 8260, 26117, 26119, 26165, 26163
23591, 26117, 26119, 26165, 26163, 26118, 26120, 26166, 26164
23592, 26118, 26120, 26166, 26164, 8626, 8627, 8650, 8649
23593, 8238, 8239, 8262, 8261, 26119, 26121, 26167, 26165
23594, 26119, 26121, 26167, 26165, 26120, 26122, 26168, 26166
23595, 26120, 26122, 26168, 26166, 8627, 8628, 8651, 8650
23596, 8239, 8240, 8263, 8262, 26121, 26123, 26169, 26167
23597, 26121, 26123, 26169, 26167, 26122, 26124, 26170, 26168
23598, 26122, 26124, 26170, 26168, 8628, 8629, 8652, 8651
23599, 8240, 8241, 8264, 8263, 26123, 26125, 26171, 26169
23600, 26123, 26125, 26171, 26169, 26124, 26126, 26172, 26170
23601, 26124, 26126, 26172, 26170, 8629, 8630, 8653, 8652
23602, 8241, 8242, 8265, 8264, 26125, 26127, 26173, 26171
23603, 26125, 26127, 26173, 26171, 26126, 26128, 26174, 26172
23604, 26126, 26128, 26174, 26172, 8630, 8631, 8654, 8653
23605, 8242, 8243, 8266, 8265, 26127, 26129, 26175, 26173
23606, 26127, 26129, 26175, 26173, 26128, 26130, 26176, 26174
23607, 26128, 26130, 26176, 26174, 8631, 8632, 8655, 8654
23608, 8243, 8244, 8267, 8266, 26129, 26131, 26177, 26175
23609, 26129, 26131, 26177, 26175, 26130, 26132, 26178, 26176
23610, 26130, 26132, 26178, 26176, 8632, 8633, 8656, 8655
23611, 8244, 8245, 8268, 8267, 26131, 26133, 26179, 26177
23612, 26131, 26133, 26179, 26177, 26132, 26134, 26180, 26178
23613, 26132, 26134, 26180, 26178, 8633, 8634, 8657, 8656
23614, 8245, 8246, 8269, 8268, 26133, 26135, 26181, 26179
23615, 26133, 26135, 26181, 26179, 26134, 26136, 26182, 26180
23616, 26134, 26136, 26182, 26180, 8634, 8635, 8658, 8657
23617, 8246, 8247, 8270, 8269, 26135, 26137, 26183, 26181
23618, 26135, 26137, 26183, 26181, 26136, 26138, 26184, 26182
23619, 26136, 26138, 26184, 26182, 8635, 8636, 8659, 8658
23620, 8247, 8248, 8271, 8270, 26137, 26139, 26185, 26183
23621, 26137, 26139, 26185, 26183, 26138, 26140, 26186, 26184
23622, 26138, 26140, 26186, 26184, 8636, 8637, 8660, 8659
23623, 8248, 8249, 8272, 8271, 26139, 26141, 26187, 26185
23624, 26139, 26141, 26187, 26185, 26140, 26142, 26188, 26186
23625, 26140, 26142, 26188, 26186, 8637, 8638, 8661, 8660
23626, 8249, 8250, 8273, 8272, 26141, 26143, 26189, 26187
23627, 26141, 26143, 26189, 26187, 26142, 26144, 26190, 26188
23628, 26142, 26144, 26190, 26188, 8638, 8639, 8662, 8661
23629, 8250, 8251, 8274, 8273, 26143, 26145, 26191, 26189
23630, 26143, 26145, 26191, 26189, 26144, 26146, 26192, 26190
23631, 26144, 26146, 26192, 26190, 8639, 8640, 8663, 8662
23632, 8251, 8252, 8275, 8274, 26145, 26147, 26193, 26191
23633, 26145, 26147, 26193, 26191, 26146, 26148, 26194, 26192
23634, 26146, 26148, 26194, 26192, 8640, 8641, 8664, 8663
23635, 8252, 1063, 1064, 8275, 26147, 8492, 8494, 26193
23636, 26147, 8492, 8494, 26193, 26148, 8493, 8495, 26194
23637, 26148, 8493, 8495, 26194, 8641, 1139, 1140, 8664
23638, 1053, 8253, 8276, 1054, 8472, 26149, 26195, 8474
23639, 8472, 26149, 26195, 8474, 8473, 26150, 26196, 8475
23640, 8473, 26150, 26196, 8475, 1129, 8642, 8665, 1130
23641, 8253, 8254, 8277, 8276, 26149, 26151, 26197, 26195
23642, 26149, 26151, 26197, 26195, 26150, 26152, 26198, 26196
23643, 26150, 26152, 26198, 26196, 8642, 8643, 8666, 8665
23644, 8254, 8255, 8278, 8277, 26151, 26153, 26199, 26197
23645, 26151, 26153, 26199, 26197, 26152, 26154, 26200, 26198
23646, 26152, 26154, 26200, 26198, 8643, 8644, 8667, 8666
23647, 8255, 8256, 8279, 8278, 26153, 26155, 26201, 26199
23648, 26153, 26155, 26201, 26199, 26154, 26156, 26202, 26200
23649, 26154, 26156, 26202, 26200, 8644, 8645, 8668, 8667
23650, 8256, 8257, 8280, 8279, 26155, 26157, 26203, 26201
23651, 26155, 26157, 26203, 26201, 26156, 26158, 26204, 26202
23652, 26156, 26158, 26204, 26202, 8645, 8646, 8669, 8668
23653, 8257, 8258, 8281, 8280, 26157, 26159, 26205, 26203
23654, 26157, 26159, 26205, 26203, 26158, 26160, 26206, 26204
23655, 26158, 26160, 26206, 26204, 8646, 8647, 8670, 8669
23656, 8258, 8259, 8282, 8281, 26159, 26161, 26207, 26205
23657, 26159, 26161, 26207, 26205, 26160, 26162, 26208, 26206
23658, 26160, 26162, 26208, 26206, 8647, 8648, 8671, 8670
23659, 8259, 8260, 8283, 8282, 26161, 26163, 26209, 26207
23660, 26161, 26163, 26209, 26207, 26162, 26164, 26210, 26208
23661, 26162, 26164, 26210, 26208, 8648, 8649, 8672, 8671
23662, 8260, 8261, 8284, 8283, 26163, 26165, 26211, 26209
23663, 26163, 26165, 26211, 26209, 26164, 26166, 26212, 26210
23664, 26164, 26166, 26212, 26210, 8649, 8650, 8673, 8672
23665, 8261, 8262, 8285, 8284, 26165, 26167, 26213, 26211
23666, 26165, 26167, 26213, 26211, 26166, 26168, 26214, 26212
23667, 26166, 26168, 26214, 26212, 8650, 8651, 8674, 8673
23668, 8262, 8263, 8286, 8285, 26167, 26169, 26215, 26213
23669, 26167, 26169, 26215, 26213, 26168, 26170, 26216, 26214
23670, 26168, 26170, 26216, 26214, 8651, 8652, 8675, 8674
23671, 8263, 8264, 8287, 8286, 26169, 26171, 26217, 26215
23672, 26169, 26171, 26217, 26215, 26170, 26172, 26218, 26216
23673, 26170, 26172, 26218, 26216, 8652, 8653, 8676, 8675
23674, 8264, 8265, 8288, 8287, 26171, 26173, 26219, 26217
23675, 26171, 26173, 26219, 26217, 26172, 26174, 26220, 26218
23676, 26172, 26174, 26220, 26218, 8653, 8654, 8677, 8676
23677, 8265, 8266, 8289, 8288, 26173, 26175, 26221, 26219
23678, 26173, 26175, 26221, 26219, 26174, 26176, 26222, 26220
23679, 26174, 26176, 26222, 26220, 8654, 8655, 8678, 8677
23680, 8266, 8267, 8290, 8289, 26175, 26177, 26223, 26221
23681, 26175, 26177, 26223, 26221, 26176, 26178, 26224, 26222
23682, 26176, 26178, 26224, 26222, 8655, 8656, 8679, 8678
23683, 8267, 8268, 8291, 8290, 26177, 26179, 26225, 26223
23684, 26177, 26179, 26225, 26223, 26178, 26180, 26226, 26224
23685, 26178, 26180, 26226, 26224, 8656, 8657, 8680, 8679
23686, 8268, 8269, 8292, 8291, 26179, 26181, 26227, 26225
23687, 26179, 26181, 26227, 26225, 26180, 26182, 26228, 26226
23688, 26180, 26182, 26228, 26226, 8657, 8658, 8681, 8680
23689, 8269, 8270, 8293, 8292, 26181, 26183, 26229, 26227
23690, 26181, 26183, 26229, 26227, 26182, 26184, 26230, 26228
23691, 26182, 26184, 26230, 26228, 8658, 8659, 8682, 8681
23692, 8270, 8271, 8294, 8293, 26183, 26185, 26231, 26229
23693, 26183, 26185, 26231, 26229, 26184, 26186, 26232, 26230
23694, 26184, 26186, 26232, 26230, 8659, 8660, 8683, 8682
23695, 8271, 8272, 8295, 8294, 26185, 26187, 26233, 26231
23696, 26185, 26187, 26233, 26231, 26186, 26188, 26234, 26232
23697, 26186, 26188, 26234, 26232, 8660, 8661, 8684, 8683
23698, 8272, 8273, 8296, 8295, 26187, 26189, 26235, 26233
23699, 26187, 26189, 26235, 26233, 26188, 26190, 26236, 26234
23700, 26188, 26190, 26236, 26234, 8661, 8662, 8685, 8684
23701, 8273, 8274, 8297, 8296, 26189, 26191, 26237, 26235
23702, 26189, 26191, 26237, 26235, 26190, 26192, 26238, 26236
23703, 26190, 26192, 26238, 26236, 8662, 8663, 8686, 8685
23704, 8274, 8275, 8298, 8297, 26191, 26193, 26239, 26237
23705, 26191, 26193, 26239, 26237, 26192, 26194, 26240, 26238
23706, 26192, 26194, 26240, 26238, 8663, 8664, 8687, 8686
23707, 8275, 1064, 1065, 8298, 26193, 8494, 8496, 26239
23708, 26193, 8494, 8496, 26239, 26194, 8495, 8497, 26240
23709, 26194, 8495, 8497, 26240, 8664, 1140, 1141, 8687
23710, 1054, 8276, 8299, 1055, 8474, 26195, 26241, 8476
23711, 8474, 26195, 26241, 8476, 8475, 26196, 26242, 8477
23712, 8475, 26196, 26242, 8477, 1130, 8665, 8688, 1131
23713, 8276, 8277, 8300, 8299, 26195, 26197, 26243, 26241
23714, 26195, 26197, 26243, 26241, 26196, 26198, 26244, 26242
23715, 26196, 26198, 26244, 26242, 8665, 8666, 8689, 8688
23716, 8277, 8278, 8301, 8300, 26197, 26199, 26245, 26243
23717, 26197, 26199, 26245, 26243, 26198, 26200, 26246, 26244
23718, 26198, 26200, 26246, 26244, 8666, 8667, 8690, 8689
23719, 8278, 8279, 8302, 8301, 26199, 26201, 26247, 26245
23720, 26199, 26201, 26247, 26245, 26200, 26202, 26248, 26246
23721, 26200, 26202, 26248, 26246, 8667, 8668, 8691, 8690
23722, 8279, 8280, 8303, 8302, 26201, 26203, 26249, 26247
23723, 26201, 26203, 26249, 26247, 26202, 26204, 26250, 26248
23724, 26202, 26204, 26250, 26248, 8668, 8669, 8692, 8691
23725, 8280, 8281, 8304, 8303, 26203, 26205, 26251, 26249
23726, 26203, 26205, 26251, 26249, 26204, 26206, 26252, 26250
23727, 26204, 26206, 26252, 26250, 8669, 8670, 8693, 8692
23728, 8281, 8282, 8305, 8304, 26205, 26207, 26253, 26251
23729, 26205, 26207, 26253, 26251, 26206, 26208, 26254, 26252
23730, 26206, 26208, 26254, 26252, 8670, 8671, 8694, 8693
23731, 8282, 8283, 8306, 8305, 26207, 26209, 26255, 26253
23732, 26207, 26209, 26255, 26253, 26208, 26210, 26256, 26254
23733, 26208, 26210, 26256, 26254, 8671, 8672, 8695, 8694
23734, 8283, 8284, 8307, 8306, 26209, 26211, 26257, 26255
23735, 26209, 26211, 26257, 26255, 26210, 26212, 26258, 26256
23736, 26210, 26212, 26258, 26256, 8672, 8673, 8696, 8695
23737, 8284, 8285, 8308, 8307, 26211, 26213, 26259, 26257
23738, 26211, 26213, 26259, 26257, 26212, 26214, 26260, 26258
23739, 26212, 26214, 26260, 26258, 8673, 8674, 8697, 8696
23740, 8285, 8286, 8309, 8308, 26213, 26215, 26261, 26259
23741, 26213, 26215, 26261, 26259, 26214, 26216, 26262, 26260
23742, 26214, 26216, 26262, 26260, 8674, 8675, 8698, 8697
23743, 8286, 8287, 8310, 8309, 26215, 26217, 26263, 26261
23744, 26215, 26217, 26263, 26261, 26216, 26218, 26264, 26262
23745, 26216, 26218, 26264, 26262, 8675, 8676, 8699, 8698
23746, 8287, 8288, 8311, 8310, 26217, 26219, 26265, 26263
23747, 26217, 26219, 26265, 26263, 26218, 26220, 26266, 26264
23748, 26218, 26220, 26266, 26264, 8676, 8677, 8700, 8699
23749, 8288, 8289, 8312, 8311, 26219, 26221, 26267, 26265
23750, 26219, 26221, 26267, 26265, 26220, 26222, 26268, 26266
23751, 26220, 26222, 26268, 26266, 8677, 8678, 8701, 8700
23752, 8289, 8290, 8313, 8312, 26221, 26223, 26269, 26267
23753, 26221, 26223, 26269, 26267, 26222, 26224, 26270, 26268
23754, 26222, 26224, 26270, 26268, 8678, 8679, 8702, 8701
23755, 8290, 8291, 8314, 8313, 26223, 26225, 26271, 26269
23756, 26223, 26225, 26271, 26269, 26224, 26226, 26272, 26270
23757, 26224, 26226, 26272, 26270, 8679, 8680, 8703, 8702
23758, 8291, 8292, 8315, 8314, 26225, 26227, 26273, 26271
23759, 26225, 26227, 26273, 26271, 26226, 26228, 26274, 26272
23760, 26226, 26228, 26274, 26272, 8680, 8681, 8704, 8703
23761, 8292, 8293, 8316, 8315, 26227, 26229, 26275, 26273
23762, 26227, 26229, 26275, 26273, 26228, 26230, 26276, 26274
23763, 26228, 26230, 26276, 26274, 8681, 8682, 8705, 8704
23764, 8293, 8294, 8317, 8316, 26229, 26231, 26277, 26275
23765, 26229, 26231, 26277, 26275, 26230, 26232, 26278, 26276
23766, 26230, 26232, 26278, 26276, 8682, 8683, 8706, 8705
23767, 8294, 8295, 8318, 8317, 26231, 26233, 26279, 26277
23768, 26231, 26233, 26279, 26277, 26232, 26234, 26280, 26278
23769, 26232, 26234, 26280, 26278, 8683, 8684, 8707, 8706
23770, 8295, 8296, 8319, 8318, 26233, 26235, 26281, 26279
23771, 26233, 26235, 26281, 26279, 26234, 26236, 26282, 26280
23772, 26234, 26236, 26282, 26280, 8684, 8685, 8708, 8707
23773, 8296, 8297, 8320, 8319, 26235, 26237, 26283, 26281
23774, 26235, 26237, 26283, 26281, 26236, 26238, 26284, 26282
23775, 26236, 26238, 26284, 26282, 8685, 8686, 8709, 8708
23776, 8297, 8298, 8321, 8320, 26237, 26239, 26285, 26283
23777, 26237, 26239, 26285, 26283, 26238, 26240, 26286, 26284
23778, 26238, 26240, 26286, 26284, 8686, 8687, 8710, 8709
23779, 8298, 1065, 1066, 8321, 26239, 8496, 8498, 26285
23780, 26239, 8496, 8498, 26285, 26240, 8497, 8499, 26286
23781, 26240, 8497, 8499, 26286, 8687, 1141, 1142, 8710
23782, 1055, 8299, 8322, 1056, 8476, 26241, 26287, 8478
23783, 8476, 26241, 26287, 8478, 8477, 26242, 26288, 8479
23784, 8477, 26242, 26288, 8479, 1131, 8688, 8711, 1132
23785, 8299, 8300, 8323, 8322, 26241, 26243, 26289, 26287
23786, 26241, 26243, 26289, 26287, 26242, 26244, 26290, 26288
23787, 26242, 26244, 26290, 26288, 8688, 8689, 8712, 8711
23788, 8300, 8301, 8324, 8323, 26243, 26245, 26291, 26289
23789, 26243, 26245, 26291, 26289, 26244, 26246, 26292, 26290
23790, 26244, 26246, 26292, 26290, 8689, 8690, 8713, 8712
23791, 8301, 8302, 8325, 8324, 26245, 26247, 26293, 26291
23792, 26245, 26247, 26293, 26291, 26246, 26248, 26294, 26292
23793, 26246, 26248, 26294, 26292, 8690, 8691, 8714, 8713
23794, 8302, 8303, 8326, 8325, 26247, 26249, 26295, 26293
23795, 26247, 26249, 26295, 26293, 26248, 26250, 26296, 26294
23796, 26248, 26250, 26296, 26294, 8691, 8692, 8715, 8714
23797, 8303, 8304, 8327, 8326, 26249, 26251, 26297, 26295
23798, 26249, 26251, 26297, 26295, 26250, 26252, 26298, 26296
23799, 26250, 26252, 26298, 26296, 8692, 8693, 8716, 8715
23800, 8304, 8305, 8328, 8327, 26251, 26253, 26299, 26297
23801, 26251, 26253, 26299, 26297, 26252, 26254, 26300, 26298
23802, 26252, 26254, 26300, 26298, 8693, 8694, 8717, 8716
23803, 8305, 8306, 8329, 8328, 26253, 26255, 26301, 26299
23804, 26253, 26255, 26301, 26299, 26254, 26256, 26302, 26300
23805, 26254, 26256, 26302, 26300, 8694, 8695, 8718, 8717
23806, 8306, 8307, 8330, 8329, 26255, 26257, 26303, 26301
23807, 26255, 26257, 26303, 26301, 26256, 26258, 26304, 26302
23808, 26256, 26258, 26304, 26302, 8695, 8696, 8719, 8718
23809, 8307, 8308, 8331, 8330, 26257, 26259, 26305, 26303
23810, 26257, 26259, 26305, 26303, 26258, 26260, 26306, 26304
23811, 26258, 26260, 26306, 26304, 8696, 8697, 8720, 8719
23812, 8308, 8309, 8332, 8331, 26259, 26261, 26307, 26305
23813, 26259, 26261, 26307, 26305, 26260, 26262, 26308, 26306
23814, 26260, 26262, 26308, 26306, 8697, 8698, 8721, 8720
23815, 8309, 8310, 8333, 8332, 26261, 26263, 26309, 26307
23816, 26261, 26263, 26309, 26307, 26262, 26264, 26310, 26308
23817, 26262, 26264, 26310, 26308, 8698, 8699, 8722, 8721
23818, 8310, 8311, 8334, 8333, 26263, 26265, 26311, 26309
23819, 26263, 26265, 26311, 26309, 26264, 26266, 26312, 26310
23820, 26264, 26266, 26312, 26310, 8699, 8700, 8723, 8722
23821, 8311, 8312, 8335, 8334, 26265, 26267, 26313, 26311
23822, 26265, 26267, 26313, 26311, 26266, 26268, 26314, 26312
23823, 26266, 26268, 26314, 26312, 8700, 8701, 8724, 8723
23824, 8312, 8313, 8336, 8335, 26267, 26269, 26315, 26313
23825, 26267, 26269, 26315, 26313, 26268, 26270, 26316, 26314
23826, 26268, 26270, 26316, 26314, 8701, 8702, 8725, 8724
23827, 8313, 8314, 8337, 8336, 26269, 26271, 26317, 26315
23828, 26269, 26271, 26317, 26315, 26270, 26272, 26318, 26316
23829, 26270, 26272, 26318, 26316, 8702, 8703, 8726, 8725
23830, 8314, 8315, 8338, 8337, 26271, 26273, 26319, 26317
23831, 26271, 26273, 26319, 26317, 26272, 26274, 26320, 26318
23832, 26272, 26274, 26320, 26318, 8703, 8704, 8727, 8726
23833, 8315, 8316, 8339, 8338, 26273, 26275, 26321, 26319
23834, 26273, 26275, 26321, 26319, 26274, 26276, 26322, 26320
23835, 26274, 26276, 26322, 26320, 8704, 8705, 8728, 8727
23836, 8316, 8317, 8340, 8339, 26275, 26277, 26323, 26321
23837, 26275, 26277, 26323, 26321, 26276, 26278, 26324, 26322
23838, 26276, 26278, 26324, 26322, 8705, 8706, 8729, 8728
23839, 8317, 8318, 8341, 8340, 26277, 26279, 26325, 26323
23840, 26277, 26279, 26325, 26323, 26278, 26280, 26326, 26324
23841, 26278, 26280, 26326, 26324, 8706, 8707, 8730, 8729
23842, 8318, 8319, 8342, 8341, 26279, 26281, 26327, 26325
23843, 26279, 26281, 26327, 26325, 26280, 26282, 26328, 26326
23844, 26280, 26282, 26328, 26326, 8707, 8708, 8731, 8730
23845, 8319, 8320, 8343, 8342, 26281, 26283, 26329, 26327
23846, 26281, 26283, 26329, 26327, 26282, 26284, 26330, 26328
23847, 26282, 26284, 26330, 26328, 8708, 8709, 8732, 8731
23848, 8320, 8321, 8344, 8343, 26283, 26285, 26331, 26329
23849, 26283, 26285, 26331, 26329, 26284, 26286, 26332, 26330
23850, 26284, 26286, 26332, 26330, 8709, 8710, 8733, 8732
23851, 8321, 1066, 1067, 8344, 26285, 8498, 8500, 26331
23852, 26285, 8498, 8500, 26331, 26286, 8499, 8501, 26332
23853, 26286, 8499, 8501, 26332, 8710, 1142, 1143, 8733
23854, 1056, 8322, 8345, 1057, 8478, 26287, 26333, 8480
23855, 8478, 26287, 26333, 8480, 8479, 26288, 26334, 8481
23856, 8479, 26288, 26334, 8481, 1132, 8711, 8734, 1133
23857, 8322, 8323, 8346, 8345, 26287, 26289, 26335, 26333
23858, 26287, 26289, 26335, 26333, 26288, 26290, 26336, 26334
23859, 26288, 26290, 26336, 26334, 8711, 8712, 8735, 8734
23860, 8323, 8324, 8347, 8346, 26289, 26291, 26337, 26335
23861, 26289, 26291, 26337, 26335, 26290, 26292, 26338, 26336
23862, 26290, 26292, 26338, 26336, 8712, 8713, 8736, 8735
23863, 8324, 8325, 8348, 8347, 26291, 26293, 26339, 26337
23864, 26291, 26293, 26339, 26337, 26292, 26294, 26340, 26338
23865, 26292, 26294, 26340, 26338, 8713, 8714, 8737, 8736
23866, 8325, 8326, 8349, 8348, 26293, 26295, 26341, 26339
23867, 26293, 26295, 26341, 26339, 26294, 26296, 26342, 26340
23868, 26294, 26296, 26342, 26340, 8714, 8715, 8738, 8737
23869, 8326, 8327, 8350, 8349, 26295, 26297, 26343, 26341
23870, 26295, 26297, 26343, 26341, 26296, 26298, 26344, 26342
23871, 26296, 26298, 26344, 26342, 8715, 8716, 8739, 8738
23872, 8327, 8328, 8351, 8350, 26297, 26299, 26345, 26343
23873, 26297, 26299, 26345, 26343, 26298, 26300, 26346, 26344
23874, 26298, 26300, 26346, 26344, 8716, 8717, 8740, 8739
23875, 8328, 8329, 8352, 8351, 26299, 26301, 26347, 26345
23876, 26299, 26301, 26347, 26345, 26300, 26302, 26348, 26346
23877, 26300, 26302, 26348, 26346, 8717, 8718, 8741, 8740
23878, 8329, 8330, 8353, 8352, 26301, 26303, 26349, 26347
23879, 26301, 26303, 26349, 26347, 26302, 26304, 26350, 26348
23880, 26302, 26304, 26350, 26348, 8718, 8719, 8742, 8741
23881, 8330, 8331, 8354, 8353, 26303, 26305, 26351, 26349
23882, 26303, 26305, 26351, 26349, 26304, 26306, 26352, 26350
23883, 26304, 26306, 26352, 26350, 8719, 8720, 8743, 8742
23884, 8331, 8332, 8355, 8354, 26305, 26307, 26353, 26351
23885, 26305, 26307, 26353, 26351, 26306, 26308, 26354, 26352
23886, 26306, 26308, 26354, 26352, 8720, 8721, 8744, 8743
23887, 8332, 8333, 8356, 8355, 26307, 26309, 26355, 26353
23888, 26307, 26309, 26355, 26353, 26308, 26310, 26356, 26354
23889, 26308, 26310, 26356, 26354, 8721, 8722, 8745, 8744
23890, 8333, 8334, 8357, 8356, 26309, 26311, 26357, 26355
23891, 26309, 26311, 26357, 26355, 26310, 26312, 26358, 26356
23892, 26310, 26312, 26358, 26356, 8722, 8723, 8746, 8745
23893, 8334, 8335, 8358, 8357, 26311, 26313, 26359, 26357
23894, 26311, 26313, 26359, 26357, 26312, 26314, 26360, 26358
23895, 26312, 26314, 26360, 26358, 8723, 8724, 8747, 8746
23896, 8335, 8336, 8359, 8358, 26313, 26315, 26361, 26359
23897, 26313, 26315, 26361, 26359, 26314, 26316, 26362, 26360
23898, 26314, 26316, 26362, 26360, 8724, 8725, 8748, 8747
23899, 8336, 8337, 8360, 8359, 26315, 26317, 26363, 26361
23900, 26315, 26317, 26363, 26361, 26316, 26318, 26364, 26362
23901, 26316, 26318, 26364, 26362, 8725, 8726, 8749, 8748
23902, 8337, 8338, 8361, 8360, 26317, 26319, 26365, 26363
23903, 26317, 26319, 26365, 26363, 26318, 26320, 26366, 26364
23904, 26318, 26320, 26366, 26364, 8726, 8727, 8750, 8749
23905, 8338, 8339, 8362, 8361, 26319, 26321, 26367, 26365
23906, 26319, 26321, 26367, 26365, 26320, 26322, 26368, 26366
23907, 26320, 26322, 26368, 26366, 8727, 8728, 8751, 8750
23908, 8339, 8340, 8363, 8362, 26321, 26323, 26369, 26367
23909, 26321, 26323, 26369, 26367, 26322, 26324, 26370, 26368
23910, 26322, 26324, 26370, 26368, 8728, 8729, 8752, 8751
23911, 8340, 8341, 8364, 8363, 26323, 26325, 26371, 26369
23912, 26323, 26325, 26371, 26369, 26324, 26326, 26372, 26370
23913, 26324, 26326, 26372, 26370, 8729, 8730, 8753, 8752
23914, 8341, 8342, 8365, 8364, 26325, 26327, 26373, 26371
23915, 26325, 26327, 26373, 26371, 26326, 26328, 26374, 26372
23916, 26326, 26328, 26374, 26372, 8730, 8731, 8754, 8753
23917, 8342, 8343, 8366, 8365, 26327, 26329, 26375, 26373
23918, 26327, 26329, 26375, 26373, 26328, 26330, 26376, 26374
23919, 26328, 26330, 26376, 26374, 8731, 8732, 8755, 8754
23920, 8343, 8344, 8367, 8366, 26329, 26331, 26377, 26375
23921, 26329, 26331, 26377, 26375, 26330, 26332, 26378, 26376
23922, 26330, 26332, 26378, 26376, 8732, 8733, 8756, 8755
23923, 8344, 1067, 1068, 8367, 26331, 8500, 8502, 26377
23924, 26331, 8500, 8502, 26377, 26332, 8501, 8503, 26378
23925, 26332, 8501, 8503, 26378, 8733, 1143, 1144, 8756
23926, 1057, 8345, 1001, 41, 8480, 26333, 8368, 1069
23927, 8480, 26333, 8368, 1069, 8481, 26334, 8369, 1070
23928, 8481, 26334, 8369, 1070, 1133, 8734, 1073, 45
23929, 8345, 8346, 1002, 1001, 26333, 26335, 8370, 8368
23930, 26333, 26335, 8370, 8368, 26334, 26336, 8371, 8369
23931, 26334, 26336, 8371, 8369, 8734, 8735, 1074, 1073
23932, 8346, 8347, 1003, 1002, 26335, 26337, 8372, 8370
23933, 26335, 26337, 8372, 8370, 26336, 26338, 8373, 8371
23934, 26336, 26338, 8373, 8371, 8735, 8736, 1075, 1074
23935, 8347, 8348, 1004, 1003, 26337, 26339, 8374, 8372
23936, 26337, 26339, 8374, 8372, 26338, 26340, 8375, 8373
23937, 26338, 26340, 8375, 8373, 8736, 8737, 1076, 1075
23938, 8348, 8349, 1005, 1004, 26339, 26341, 8376, 8374
23939, 26339, 26341, 8376, 8374, 26340, 26342, 8377, 8375
23940, 26340, 26342, 8377, 8375, 8737, 8738, 1077, 1076
23941, 8349, 8350, 1006, 1005, 26341, 26343, 8378, 8376
23942, 26341, 26343, 8378, 8376, 26342, 26344, 8379, 8377
23943, 26342, 26344, 8379, 8377, 8738, 8739, 1078, 1077
23944, 8350, 8351, 1007, 1006, 26343, 26345, 8380, 8378
23945, 26343, 26345, 8380, 8378, 26344, 26346, 8381, 8379
23946, 26344, 26346, 8381, 8379, 8739, 8740, 1079, 1078
23947, 8351, 8352, 1008, 1007, 26345, 26347, 8382, 8380
23948, 26345, 26347, 8382, 8380, 26346, 26348, 8383, 8381
23949, 26346, 26348, 8383, 8381, 8740, 8741, 1080, 1079
23950, 8352, 8353, 1009, 1008, 26347, 26349, 8384, 8382
23951, 26347, 26349, 8384, 8382, 26348, 26350, 8385, 8383
23952, 26348, 26350, 8385, 8383, 8741, 8742, 1081, 1080
23953, 8353, 8354, 1010, 1009, 26349, 26351, 8386, 8384
23954, 26349, 26351, 8386, 8384, 26350, 26352, 8387, 8385
23955, 26350, 26352, 8387, 8385, 8742, 8743, 1082, 1081
23956, 8354, 8355, 1011, 1010, 26351, 26353, 8388, 8386
23957, 26351, 26353, 8388, 8386, 26352, 26354, 8389, 8387
23958, 26352, 26354, 8389, 8387, 8743, 8744, 1083, 1082
23959, 8355, 8356, 1012, 1011, 26353, 26355, 8390, 8388
23960, 26353, 26355, 8390, 8388, 26354, 26356, 8391, 8389
23961, 26354, 26356, 8391, 8389, 8744, 8745, 1084, 1083
23962, 8356, 8357, 1013, 1012, 26355, 26357, 8392, 8390
23963, 26355, 26357, 8392, 8390, 26356, 26358, 8393, 8391
23964, 26356, 26358, 8393, 8391, 8745, 8746, 1085, 1084
23965, 8357, 8358, 1014, 1013, 26357, 26359, 8394, 8392
23966, 26357, 26359, 8394, 8392, 26358, 26360, 8395, 8393
23967, 26358, 26360, 8395, 8393, 8746, 8747, 1086, 1085
23968, 8358, 8359, 1015, 1014, 26359, 26361, 8396, 8394
23969, 26359, 26361, 8396, 8394, 26360, 26362, 8397, 8395
23970, 26360, 26362, 8397, 8395, 8747, 8748, 1087, 1086
23971, 8359, 8360, 1016, 1015, 26361, 26363, 8398, 8396
23972, 26361, 26363, 8398, 8396, 26362, 26364, 8399, 8397
23973, 26362, 26364, 8399, 8397, 8748, 8749, 1088, 1087
23974, 8360, 8361, 1017, 1016, 26363, 26365, 8400, 8398
23975, 26363, 26365, 8400, 8398, 26364, 26366, 8401, 8399
23976, 26364, 26366, 8401, 8399, 8749, 8750, 1089, 1088
23977, 8361, 8362, 1018, 1017, 26365, 26367, 8402, 8400
23978, 26365, 26367, 8402, 8400, 26366, 26368, 8403, 8401
23979, 26366, 26368, 8403, 8401, 8750, 8751, 1090, 1089
23980, 8362, 8363, 1019, 1018, 26367, 26369, 8404, 8402
23981, 26367, 26369, 8404, 8402, 26368, 26370, 8405, 8403
23982, 26368, 26370, 8405, 8403, 8751, 8752, 1091, 1090
23983, 8363, 8364, 1020, 1019, 26369, 26371, 8406, 8404
23984, 26369, 26371, 8406, 8404, 26370, 26372, 8407, 8405
23985, 26370, 26372, 8407, 8405, 8752, 8753, 1092, 1091
23986, 8364, 8365, 1021, 1020, 26371, 26373, 8408, 8406
23987, 26371, 26373, 8408, 8406, 26372, 26374, 8409, 8407
23988, 26372, 26374, 8409, 8407, 8753, 8754, 1093, 1092
23989, 8365, 8366, 1022, 1021, 26373, 26375, 8410, 8408
23990, 26373, 26375, 8410, 8408, 26374, 26376, 8411, 8409
23991, 26374, 26376, 8411, 8409, 8754, 8755, 1094, 1093
23992, 8366, 8367, 1023, 1022, 26375, 26377, 8412, 8410
23993, 26375, 26377, 8412, 8410, 26376, 26378, 8413, 8411
23994, 26376, 26378, 8413, 8411, 8755, 8756, 1095, 1094
23995, 8367, 1068, 42, 1023, 26377, 8502, 1071, 8412
23996, 26377, 8502, 1071, 8412, 26378, 8503, 1072, 8413
23997, 26378, 8503, 1072, 8413, 8756, 1144, 46, 1095
*ELEMENT, type=C3D8, ELSET=Volume12
23998, 44, 1058, 8482, 1098, 51, 1149, 8757, 1147
23999, 1098, 8482, 8483, 1099, 1147, 8757, 8758, 1148
24000, 1099, 8483, 1134, 48, 1148, 8758, 1160, 52
24001, 1058, 1059, 8484, 8482, 1149, 1150, 8759, 8757
24002, 8482, 8484, 8485, 8483, 8757, 8759, 8760, 8758
24003, 8483, 8485, 1135, 1134, 8758, 8760, 1161, 1160
24004, 1059, 1060, 8486, 8484, 1150, 1151, 8761, 8759
24005, 8484, 8486, 8487, 8485, 8759, 8761, 8762, 8760
24006, 8485, 8487, 1136, 1135, 8760, 8762, 1162, 1161
24007, 1060, 1061, 8488, 8486, 1151, 1152, 8763, 8761
24008, 8486, 8488, 8489, 8487, 8761, 8763, 8764, 8762
24009, 8487, 8489, 1137, 1136, 8762, 8764, 1163, 1162
24010, 1061, 1062, 8490, 8488, 1152, 1153, 8765, 8763
24011, 8488, 8490, 8491, 8489, 8763, 8765, 8766, 8764
24012, 8489, 8491, 1138, 1137, 8764, 8766, 1164, 1163
24013, 1062, 1063, 8492, 8490, 1153, 1154, 8767, 8765
24014, 8490, 8492, 8493, 8491, 8765, 8767, 8768, 8766
24015, 8491, 8493, 1139, 1138, 8766, 8768, 1165, 1164
24016, 1063, 1064, 8494, 8492, 1154, 1155, 8769, 8767
24017, 8492, 8494, 8495, 8493, 8767, 8769, 8770, 8768
24018, 8493, 8495, 1140, 1139, 8768, 8770, 1166, 1165
24019, 1064, 1065, 8496, 8494, 1155, 1156, 8771, 8769
24020, 8494, 8496, 8497, 8495, 8769, 8771, 8772, 8770
24021, 8495, 8497, 1141, 1140, 8770, 8772, 1167, 1166
24022, 1065, 1066, 8498, 8496, 1156, 1157, 8773, 8771
24023, 8496, 8498, 8499, 8497, 8771, 8773, 8774, 8772
24024, 8497, 8499, 1142, 1141, 8772, 8774, 1168, 1167
24025, 1066, 1067, 8500, 8498, 1157, 1158, 8775, 8773
24026, 8498, 8500, 8501, 8499, 8773, 8775, 8776, 8774
24027, 8499, 8501, 1143, 1142, 8774, 8776, 1169, 1168
24028, 1067, 1068, 8502, 8500, 1158, 1159, 8777, 8775
24029, 8500, 8502, 8503, 8501, 8775, 8777, 8778, 8776
24030, 8501, 8503, 1144, 1143, 8776, 8778, 1170, 1169
24031, 1068, 42, 1071, 8502, 1159, 49, 1145, 8777
24032, 8502, 1071, 1072, 8503, 8777, 1145, 1146, 8778
24033, 8503, 1072, 46, 1144, 8778, 1146, 50, 1170
*ELEMENT, type=C3D8, ELSET=Volume13
24034, 2, 97, 1945, 121, 54, 1171, 8779, 1195
24035, 121, 1945, 1946, 122, 1195, 8779, 8780, 1196
24036, 122, 1946, 110, 4, 1196, 8780, 1184, 56
24037, 97, 98, 1947, 1945, 1171, 1172, 8781, 8779
24038, 1945, 1947, 1948, 1946, 8779, 8781, 8782, 8780
24039, 1946, 1948, 111, 110, 8780, 8782, 1185, 1184
24040, 98, 99, 1949, 1947, 1172, 1173, 8783, 8781
24041, 1947, 1949, 1950, 1948, 8781, 8783, 8784, 8782
24042, 1948, 1950, 112, 111, 8782, 8784, 1186, 1185
24043, 99, 100, 1951, 1949, 1173, 1174, 8785, 8783
24044, 1949, 1951, 1952, 1950, 8783, 8785, 8786, 8784
24045, 1950, 1952, 113, 112, 8784, 8786, 1187, 1186
24046, 100, 101, 1953, 1951, 1174, 1175, 8787, 8785
24047, 1951, 1953, 1954, 1952, 8785, 8787, 8788, 8786
24048, 1952, 1954, 114, 113, 8786, 8788, 1188, 1187
24049, 101, 102, 1955, 1953, 1175, 1176, 8789, 8787
24050, 1953, 1955, 1956, 1954, 8787, 8789, 8790, 8788
24051, 1954, 1956, 115, 114, 8788, 8790, 1189, 1188
24052, 102, 103, 1957, 1955, 1176, 1177, 8791, 8789
24053, 1955, 1957, 1958, 1956, 8789, 8791, 8792, 8790
24054, 1956, 1958, 116, 115, 8790, 8792, 1190, 1189
24055, 103, 104, 1959, 1957, 1177, 1178, 8793, 8791
24056, 1957, 1959, 1960, 1958, 8791, 8793, 8794, 8792
24057, 1958, 1960, 117, 116, 8792, 8794, 1191, 1190
24058, 104, 105, 1961, 1959, 1178, 1179, 8795, 8793
24059, 1959, 1961, 1962, 1960, 8793, 8795, 8796, 8794
24060, 1960, 1962, 118, 117, 8794, 8796, 1192, 1191
24061, 105, 106, 1963, 1961, 1179, 1180, 8797, 8795
24062, 1961, 1963, 1964, 1962, 8795, 8797, 8798, 8796
24063, 1962, 1964, 119, 118, 8796, 8798, 1193, 1192
24064, 106, 107, 1965, 1963, 1180, 1181, 8799, 8797
24065, 1963, 1965, 1966, 1964, 8797, 8799, 8800, 8798
24066, 1964, 1966, 120, 119, 8798, 8800, 1194, 1193
24067, 107, 1, 108, 1965, 1181, 53, 1182, 8799
24068, 1965, 108, 109, 1966, 8799, 1182, 1183, 8800
24069, 1966, 109, 3, 120, 8800, 1183, 55, 1194
*ELEMENT, type=C3D8, ELSET=Volume14
24070, 10, 332, 2840, 241, 67, 1356, 9307, 1379
24071, 332, 333, 2841, 2840, 1356, 1357, 9308, 9307
24072, 333, 334, 2842, 2841, 1357, 1358, 9309, 9308
24073, 334, 335, 2843, 2842, 1358, 1359, 9310, 9309
24074, 335, 336, 2844, 2843, 1359, 1360, 9311, 9310
24075, 336, 337, 2845, 2844, 1360, 1361, 9312, 9311
24076, 337, 338, 2846, 2845, 1361, 1362, 9313, 9312
24077, 338, 339, 2847, 2846, 1362, 1363, 9314, 9313
24078, 339, 340, 2848, 2847, 1363, 1364, 9315, 9314
24079, 340, 341, 2849, 2848, 1364, 1365, 9316, 9315
24080, 341, 342, 2850, 2849, 1365, 1366, 9317, 9316
24081, 342, 343, 2851, 2850, 1366, 1367, 9318, 9317
24082, 343, 344, 2852, 2851, 1367, 1368, 9319, 9318
24083, 344, 345, 2853, 2852, 1368, 1369, 9320, 9319
24084, 345, 346, 2854, 2853, 1369, 1370, 9321, 9320
24085, 346, 347, 2855, 2854, 1370, 1371, 9322, 9321
24086, 347, 348, 2856, 2855, 1371, 1372, 9323, 9322
24087, 348, 349, 2857, 2856, 1372, 1373, 9324, 9323
24088, 349, 350, 2858, 2857, 1373, 1374, 9325, 9324
24089, 350, 351, 2859, 2858, 1374, 1375, 9326, 9325
24090, 351, 352, 2860, 2859, 1375, 1376, 9327, 9326
24091, 352, 353, 2861, 2860, 1376, 1377, 9328, 9327
24092, 353, 354, 2862, 2861, 1377, 1378, 9329, 9328
24093, 354, 14, 355, 2862, 1378, 68, 1402, 9329
24094, 241, 2840, 2863, 242, 1379, 9307, 9330, 1380
24095, 2840, 2841, 2864, 2863, 9307, 9308, 9331, 9330
24096, 2841, 2842, 2865, 2864, 9308, 9309, 9332, 9331
24097, 2842, 2843, 2866, 2865, 9309, 9310, 9333, 9332
24098, 2843, 2844, 2867, 2866, 9310, 9311, 9334, 9333
24099, 2844, 2845, 2868, 2867, 9311, 9312, 9335, 9334
24100, 2845, 2846, 2869, 2868, 9312, 9313, 9336, 9335
24101, 2846, 2847, 2870, 2869, 9313, 9314, 9337, 9336
24102, 2847, 2848, 2871, 2870, 9314, 9315, 9338, 9337
24103, 2848, 2849, 2872, 2871, 9315, 9316, 9339, 9338
24104, 2849, 2850, 2873, 2872, 9316, 9317, 9340, 9339
24105, 2850, 2851, 2874, 2873, 9317, 9318, 9341, 9340
24106, 2851, 2852, 2875, 2874, 9318, 9319, 9342, 9341
24107, 2852, 2853, 2876, 2875, 9319, 9320, 9343, 9342
24108, 2853, 2854, 2877, 2876, 9320, 9321, 9344, 9343
24109, 2854, 2855, 2878, 2877, 9321, 9322, 9345, 9344
24110, 2855, 2856, 2879, 2878, 9322, 9323, 9346, 9345
24111, 2856, 2857, 2880, 2879, 9323, 9324, 9347, 9346
24112, 2857, 2858, 2881, 2880, 9324, 9325, 9348, 9347
24113, 2858, 2859, 2882, 2881, 9325, 9326, 9349, 9348
24114, 2859, 2860, 2883, 2882, 9326, 9327, 9350, 9349
24115, 2860, 2861, 2884, 2883, 9327, 9328, 9351, 9350
24116, 2861, 2862, 2885, 2884, 9328, 9329, 9352, 9351
24117, 2862, 355, 356, 2885, 9329, 1402, 1403, 9352
24118, 242, 2863, 2886, 243, 1380, 9330, 9353, 1381
24119, 2863, 2864, 2887, 2886, 9330, 9331, 9354, 9353
24120, 2864, 2865, 2888, 2887, 9331, 9332, 9355, 9354
24121, 2865, 2866, 2889, 2888, 9332, 9333, 9356, 9355
24122, 2866, 2867, 2890, 2889, 9333, 9334, 9357, 9356
24123, 2867, 2868, 2891, 2890, 9334, 9335, 9358, 9357
24124, 2868, 2869, 2892, 2891, 9335, 9336, 9359, 9358
24125, 2869, 2870, 2893, 2892, 9336, 9337, 9360, 9359
24126, 2870, 2871, 2894, 2893, 9337, 9338, 9361, 9360
24127, 2871, 2872, 2895, 2894, 9338, 9339, 9362, 9361
24128, 2872, 2873, 2896, 2895, 9339, 9340, 9363, 9362
24129, 2873, 2874, 2897, 2896, 9340, 9341, 9364, 9363
24130, 2874, 2875, 2898, 2897, 9341, 9342, 9365, 9364
24131, 2875, 2876, 2899, 2898, 9342, 9343, 9366, 9365
24132, 2876, 2877, 2900, 2899, 9343, 9344, 9367, 9366
24133, 2877, 2878, 2901, 2900, 9344, 9345, 9368, 9367
24134, 2878, 2879, 2902, 2901, 9345, 9346, 9369, 9368
24135, 2879, 2880, 2903, 2902, 9346, 9347, 9370, 9369
24136, 2880, 2881, 2904, 2903, 9347, 9348, 9371, 9370
24137, 2881, 2882, 2905, 2904, 9348, 9349, 9372, 9371
24138, 2882, 2883, 2906, 2905, 9349, 9350, 9373, 9372
24139, 2883, 2884, 2907, 2906, 9350, 9351, 9374, 9373
24140, 2884, 2885, 2908, 2907, 9351, 9352, 9375, 9374
24141, 2885, 356, 357, 2908, 9352, 1403, 1404, 9375
24142, 243, 2886, 2909, 244, 1381, 9353, 9376, 1382
24143, 2886, 2887, 2910, 2909, 9353, 9354, 9377, 9376
24144, 2887, 2888, 2911, 2910, 9354, 9355, 9378, 9377
24145, 2888, 2889, 2912, 2911, 9355, 9356, 9379, 9378
24146, 2889, 2890, 2913, 2912, 9356, 9357, 9380, 9379
24147, 2890, 2891, 2914, 2913, 9357, 9358, 9381, 9380
24148, 2891, 2892, 2915, 2914, 9358, 9359, 9382, 9381
24149, 2892, 2893, 2916, 2915, 9359, 9360, 9383, 9382
24150, 2893, 2894, 2917, 2916, 9360, 9361, 9384, 9383
24151, 2894, 2895, 2918, 2917, 9361, 9362, 9385, 9384
24152, 2895, 2896, 2919, 2918, 9362, 9363, 9386, 9385
24153, 2896, 2897, 2920, 2919, 9363, 9364, 9387, 9386
24154, 2897, 2898, 2921, 2920, 9364, 9365, 9388, 9387
24155, 2898, 2899, 2922, 2921, 9365, 9366, 9389, 9388
24156, 2899, 2900, 2923, 2922, 9366, 9367, 9390, 9389
24157, 2900, 2901, 2924, 2923, 9367, 9368, 9391, 9390
24158, 2901, 2902, 2925, 2924, 9368, 9369, 9392, 9391
24159, 2902, 2903, 2926, 2925, 9369, 9370, 9393, 9392
24160, 2903, 2904, 2927, 2926, 9370, 9371, 9394, 9393
24161, 2904, 2905, 2928, 2927, 9371, 9372, 9395, 9394
24162, 2905, 2906, 2929, 2928, 9372, 9373, 9396, 9395
24163, 2906, 2907, 2930, 2929, 9373, 9374, 9397, 9396
24164, 2907, 2908, 2931, 2930, 9374, 9375, 9398, 9397
24165, 2908, 357, 358, 2931, 9375, 1404, 1405, 9398
24166, 244, 2909, 2932, 245, 1382, 9376, 9399, 1383
24167, 2909, 2910, 2933, 2932, 9376, 9377, 9400, 9399
24168, 2910, 2911, 2934, 2933, 9377, 9378, 9401, 9400
24169, 2911, 2912, 2935, 2934, 9378, 9379, 9402, 9401
24170, 2912, 2913, 2936, 2935, 9379, 9380, 9403, 9402
24171, 2913, 2914, 2937, 2936, 9380, 9381, 9404, 9403
24172, 2914, 2915, 2938, 2937, 9381, 9382, 9405, 9404
24173, 2915, 2916, 2939, 2938, 9382, 9383, 9406, 9405
24174, 2916, 2917, 2940, 2939, 9383, 9384, 9407, 9406
24175, 2917, 2918, 2941, 2940, 9384, 9385, 9408, 9407
24176, 2918, 2919, 2942, 2941, 9385, 9386, 9409, 9408
24177, 2919, 2920, 2943, 2942, 9386, 9387, 9410, 9409
24178, 2920, 2921, 2944, 2943, 9387, 9388, 9411, 9410
24179, 2921, 2922, 2945, 2944, 9388, 9389, 9412, 9411
24180, 2922, 2923, 2946, 2945, 9389, 9390, 9413, 9412
24181, 2923, 2924, 2947, 2946, 9390, 9391, 9414, 9413
24182, 2924, 2925, 2948, 2947, 9391, 9392, 9415, 9414
24183, 2925, 2926, 2949, 2948, 9392, 9393, 9416, 9415
24184, 2926, 2927, 2950, 2949, 9393, 9394, 9417, 9416
24185, 2927, 2928, 2951, 2950, 9394, 9395, 9418, 9417
24186, 2928, 2929, 2952, 2951, 9395, 9396, 9419, 9418
24187, 2929, 2930, 2953, 2952, 9396, 9397, 9420, 9419
24188, 2930, 2931, 2954, 2953, 9397, 9398, 9421, 9420
24189, 2931, 358, 359, 2954, 9398, 1405, 1406, 9421
24190, 245, 2932, 2955, 246, 1383, 9399, 9422, 1384
24191, 2932, 2933, 2956, 2955, 9399, 9400, 9423, 9422
24192, 2933, 2934, 2957, 2956, 9400, 9401, 9424, 9423
24193, 2934, 2935, 2958, 2957, 9401, 9402, 9425, 9424
24194, 2935, 2936, 2959, 2958, 9402, 9403, 9426, 9425
24195, 2936, 2937, 2960, 2959, 9403, 9404, 9427, 9426
24196, 2937, 2938, 2961, 2960, 9404, 9405, 9428, 9427
24197, 2938, 2939, 2962, 2961, 9405, 9406, 9429, 9428
24198, 2939, 2940, 2963, 2962, 9406, 9407, 9430, 9429
24199, 2940, 2941, 2964, 2963, 9407, 9408, 9431, 9430
24200, 2941, 2942, 2965, 2964, 9408, 9409, 9432, 9431
24201, 2942, 2943, 2966, 2965, 9409, 9410, 9433, 9432
24202, 2943, 2944, 2967, 2966, 9410, 9411, 9434, 9433
24203, 2944, 2945, 2968, 2967, 9411, 9412, 9435, 9434
24204, 2945, 2946, 2969, 2968, 9412, 9413, 9436, 9435
24205, 2946, 2947, 2970, 2969, 9413, 9414, 9437, 9436
24206, 2947, 2948, 2971, 2970, 9414, 9415, 9438, 9437
24207, 2948, 2949, 2972, 2971, 9415, 9416, 9439, 9438
24208, 2949, 2950, 2973, 2972, 9416, 9417, 9440, 9439
24209, 2950, 2951, 2974, 2973, 9417, 9418, 9441, 9440
24210, 2951, 2952, 2975, 2974, 9418, 9419, 9442, 9441
24211, 2952, 2953, 2976, 2975, 9419, 9420, 9443, 9442
24212, 2953, 2954, 2977, 2976, 9420, 9421, 9444, 9443
24213, 2954, 359, 360, 2977, 9421, 1406, 1407, 9444
24214, 246, 2955, 2978, 247, 1384, 9422, 9445, 1385
24215, 2955, 2956, 2979, 2978, 9422, 9423, 9446, 9445
24216, 2956, 2957, 2980, 2979, 9423, 9424, 9447, 9446
24217, 2957, 2958, 2981, 2980, 9424, 9425, 9448, 9447
24218, 2958, 2959, 2982, 2981, 9425, 9426, 9449, 9448
24219, 2959, 2960, 2983, 2982, 9426, 9427, 9450, 9449
24220, 2960, 2961, 2984, 2983, 9427, 9428, 9451, 9450
24221, 2961, 2962, 2985, 2984, 9428, 9429, 9452, 9451
24222, 2962, 2963, 2986, 2985, 9429, 9430, 9453, 9452
24223, 2963, 2964, 2987, 2986, 9430, 9431, 9454, 9453
24224, 2964, 2965, 2988, 2987, 9431, 9432, 9455, 9454
24225, 2965, 2966, 2989, 2988, 9432, 9433, 9456, 9455
24226, 2966, 2967, 2990, 2989, 9433, 9434, 9457, 9456
24227, 2967, 2968, 2991, 2990, 9434, 9435, 9458, 9457
24228, 2968, 2969, 2992, 2991, 9435, 9436, 9459, 9458
24229, 2969, 2970, 2993, 2992, 9436, 9437, 9460, 9459
24230, 2970, 2971, 2994, 2993, 9437, 9438, 9461, 9460
24231, 2971, 2972, 2995, 2994, 9438, 9439, 9462, 9461
24232, 2972, 2973, 2996, 2995, 9439, 9440, 9463, 9462
24233, 2973, 2974, 2997, 2996, 9440, 9441, 9464, 9463
24234, 2974, 2975, 2998, 2997, 9441, 9442, 9465, 9464
24235, 2975, 2976, 2999, 2998, 9442, 9443, 9466, 9465
24236, 2976, 2977, 3000, 2999, 9443, 9444, 9467, 9466
24237, 2977, 360, 361, 3000, 9444, 1407, 1408, 9467
24238, 247, 2978, 3001, 248, 1385, 9445, 9468, 1386
24239, 2978, 2979, 3002, 3001, 9445, 9446, 9469, 9468
24240, 2979, 2980, 3003, 3002, 9446, 9447, 9470, 9469
24241, 2980, 2981, 3004, 3003, 9447, 9448, 9471, 9470
24242, 2981, 2982, 3005, 3004, 9448, 9449, 9472, 9471
24243, 2982, 2983, 3006, 3005, 9449, 9450, 9473, 9472
24244, 2983, 2984, 3007, 3006, 9450, 9451, 9474, 9473
24245, 2984, 2985, 3008, 3007, 9451, 9452, 9475, 9474
24246, 2985, 2986, 3009, 3008, 9452, 9453, 9476, 9475
24247, 2986, 2987, 3010, 3009, 9453, 9454, 9477, 9476
24248, 2987, 2988, 3011, 3010, 9454, 9455, 9478, 9477
24249, 2988, 2989, 3012, 3011, 9455, 9456, 9479, 9478
24250, 2989, 2990, 3013, 3012, 9456, 9457, 9480, 9479
24251, 2990, 2991, 3014, 3013, 9457, 9458, 9481, 9480
24252, 2991, 2992, 3015, 3014, 9458, 9459, 9482, 9481
24253, 2992, 2993, 3016, 3015, 9459, 9460, 9483, 9482
24254, 2993, 2994, 3017, 3016, 9460, 9461, 9484, 9483
24255, 2994, 2995, 3018, 3017, 9461, 9462, 9485, 9484
24256, 2995, 2996, 3019, 3018, 9462, 9463, 9486, 9485
24257, 2996, 2997, 3020, 3019, 9463, 9464, 9487, 9486
24258, 2997, 2998, 3021, 3020, 9464, 9465, 9488, 9487
24259, 2998, 2999, 3022, 3021, 9465, 9466, 9489, 9488
24260, 2999, 3000, 3023, 3022, 9466, 9467, 9490, 9489
24261, 3000, 361, 362, 3023, 9467, 1408, 1409, 9490
24262, 248, 3001, 3024, 249, 1386, 9468, 9491, 1387
24263, 3001, 3002, 3025, 3024, 9468, 9469, 9492, 9491
24264, 3002, 3003, 3026, 3025, 9469, 9470, 9493, 9492
24265, 3003, 3004, 3027, 3026, 9470, 9471, 9494, 9493
24266, 3004, 3005, 3028, 3027, 9471, 9472, 9495, 9494
24267, 3005, 3006, 3029, 3028, 9472, 9473, 9496, 9495
24268, 3006, 3007, 3030, 3029, 9473, 9474, 9497, 9496
24269, 3007, 3008, 3031, 3030, 9474, 9475, 9498, 9497
24270, 3008, 3009, 3032, 3031, 9475, 9476, 9499, 9498
24271, 3009, 3010, 3033, 3032, 9476, 9477, 9500, 9499
24272, 3010, 3011, 3034, 3033, 9477, 9478, 9501, 9500
24273, 3011, 3012, 3035, 3034, 9478, 9479, 9502, 9501
24274, 3012, 3013, 3036, 3035, 9479, 9480, 9503, 9502
24275, 3013, 3014, 3037, 3036, 9480, 9481, 9504, 9503
24276, 3014, 3015, 3038, 3037, 9481, 9482, 9505, 9504
24277, 3015, 3016, 3039, 3038, 9482, 9483, 9506, 9505
24278, 3016, 3017, 3040, 3039, 9483, 9484, 9507, 9506
24279, 3017, 3018, 3041, 3040, 9484, 9485, 9508, 9507
24280, 3018, 3019, 3042, 3041, 9485, 9486, 9509, 9508
24281, 3019, 3020, 3043, 3042, 9486, 9487, 9510, 9509
24282, 3020, 3021, 3044, 3043, 9487, 9488, 9511, 9510
24283, 3021, 3022, 3045, 3044, 9488, 9489, 9512, 9511
24284, 3022, 3023, 3046, 3045, 9489, 9490, 9513, 9512
24285, 3023, 362, 363, 3046, 9490, 1409, 1410, 9513
24286, 249, 3024, 3047, 250, 1387, 9491, 9514, 1388
24287, 3024, 3025, 3048, 3047, 9491, 9492, 9515, 9514
24288, 3025, 3026, 3049, 3048, 9492, 9493, 9516, 9515
24289, 3026, 3027, 3050, 3049, 9493, 9494, 9517, 9516
24290, 3027, 3028, 3051, 3050, 9494, 9495, 9518, 9517
24291, 3028, 3029, 3052, 3051, 9495, 9496, 9519, 9518
24292, 3029, 3030, 3053, 3052, 9496, 9497, 9520, 9519
24293, 3030, 3031, 3054, 3053, 9497, 9498, 9521, 9520
24294, 3031, 3032, 3055, 3054, 9498, 9499, 9522, 9521
24295, 3032, 3033, 3056, 3055, 9499, 9500, 9523, 9522
24296, 3033, 3034, 3057, 3056, 9500, 9501, 9524, 9523
24297, 3034, 3035, 3058, 3057, 9501, 9502, 9525, 9524
24298, 3035, 3036, 3059, 3058, 9502, 9503, 9526, 9525
24299, 3036, 3037, 3060, 3059, 9503, 9504, 9527, 9526
24300, 3037, 3038, 3061, 3060, 9504, 9505, 9528, 9527
24301, 3038, 3039, 3062, 3061, 9505, 9506, 9529, 9528
24302, 3039, 3040, 3063, 3062, 9506, 9507, 9530, 9529
24303, 3040, 3041, 3064, 3063, 9507, 9508, 9531, 9530
24304, 3041, 3042, 3065, 3064, 9508, 9509, 9532, 9531
24305, 3042, 3043, 3066, 3065, 9509, 9510, 9533, 9532
24306, 3043, 3044, 3067, 3066, 9510, 9511, 9534, 9533
24307, 3044, 3045, 3068, 3067, 9511, 9512, 9535, 9534
24308, 3045, 3046, 3069, 3068, 9512, 9513, 9536, 9535
24309, 3046, 363, 364, 3069, 9513, 1410, 1411, 9536
24310, 250, 3047, 3070, 251, 1388, 9514, 9537, 1389
24311, 3047, 3048, 3071, 3070, 9514, 9515, 9538, 9537
24312, 3048, 3049, 3072, 3071, 9515, 9516, 9539, 9538
24313, 3049, 3050, 3073, 3072, 9516, 9517, 9540, 9539
24314, 3050, 3051, 3074, 3073, 9517, 9518, 9541, 9540
24315, 3051, 3052, 3075, 3074, 9518, 9519, 9542, 9541
24316, 3052, 3053, 3076, 3075, 9519, 9520, 9543, 9542
24317, 3053, 3054, 3077, 3076, 9520, 9521, 9544, 9543
24318, 3054, 3055, 3078, 3077, 9521, 9522, 9545, 9544
24319, 3055, 3056, 3079, 3078, 9522, 9523, 9546, 9545
24320, 3056, 3057, 3080, 3079, 9523, 9524, 9547, 9546
24321, 3057, 3058, 3081, 3080, 9524, 9525, 9548, 9547
24322, 3058, 3059, 3082, 3081, 9525, 9526, 9549, 9548
24323, 3059, 3060, 3083, 3082, 9526, 9527, 9550, 9549
24324, 3060, 3061, 3084, 3083, 9527, 9528, 9551, 9550
24325, 3061, 3062, 3085, 3084, 9528, 9529, 9552, 9551
24326, 3062, 3063, 3086, 3085, 9529, 9530, 9553, 9552
24327, 3063, 3064, 3087, 3086, 9530, 9531, 9554, 9553
24328, 3064, 3065, 3088, 3087, 9531, 9532, 9555, 9554
24329, 3065, 3066, 3089, 3088, 9532, 9533, 9556, 9555
24330, 3066, 3067, 3090, 3089, 9533, 9534, 9557, 9556
24331, 3067, 3068, 3091, 3090, 9534, 9535, 9558, 9557
24332, 3068, 3069, 3092, 3091, 9535, 9536, 9559, 9558
24333, 3069, 364, 365, 3092, 9536, 1411, 1412, 9559
24334, 251, 3070, 3093, 252, 1389, 9537, 9560, 1390
24335, 3070, 3071, 3094, 3093, 9537, 9538, 9561, 9560
24336, 3071, 3072, 3095, 3094, 9538, 9539, 9562, 9561
24337, 3072, 3073, 3096, 3095, 9539, 9540, 9563, 9562
24338, 3073, 3074, 3097, 3096, 9540, 9541, 9564, 9563
24339, 3074, 3075, 3098, 3097, 9541, 9542, 9565, 9564
24340, 3075, 3076, 3099, 3098, 9542, 9543, 9566, 9565
24341, 3076, 3077, 3100, 3099, 9543, 9544, 9567, 9566
24342, 3077, 3078, 3101, 3100, 9544, 9545, 9568, 9567
24343, 3078, 3079, 3102, 3101, 9545, 9546, 9569, 9568
24344, 3079, 3080, 3103, 3102, 9546, 9547, 9570, 9569
24345, 3080, 3081, 3104, 3103, 9547, 9548, 9571, 9570
24346, 3081, 3082, 3105, 3104, 9548, 9549, 9572, 9571
24347, 3082, 3083, 3106, 3105, 9549, 9550, 9573, 9572
24348, 3083, 3084, 3107, 3106, 9550, 9551, 9574, 9573
24349, 3084, 3085, 3108, 3107, 9551, 9552, 9575, 9574
24350, 3085, 3086, 3109, 3108, 9552, 9553, 9576, 9575
24351, 3086, 3087, 3110, 3109, 9553, 9554, 9577, 9576
24352, 3087, 3088, 3111, 3110, 9554, 9555, 9578, 9577
24353, 3088, 3089, 3112, 3111, 9555, 9556, 9579, 9578
24354, 3089, 3090, 3113, 3112, 9556, 9557, 9580, 9579
24355, 3090, 3091, 3114, 3113, 9557, 9558, 9581, 9580
24356, 3091, 3092, 3115, 3114, 9558, 9559, 9582, 9581
24357, 3092, 365, 366, 3115, 9559, 1412, 1413, 9582
24358, 252, 3093, 3116, 253, 1390, 9560, 9583, 1391
24359, 3093, 3094, 3117, 3116, 9560, 9561, 9584, 9583
24360, 3094, 3095, 3118, 3117, 9561, 9562, 9585, 9584
24361, 3095, 3096, 3119, 3118, 9562, 9563, 9586, 9585
24362, 3096, 3097, 3120, 3119, 9563, 9564, 9587, 9586
24363, 3097, 3098, 3121, 3120, 9564, 9565, 9588, 9587
24364, 3098, 3099, 3122, 3121, 9565, 9566, 9589, 9588
24365, 3099, 3100, 3123, 3122, 9566, 9567, 9590, 9589
24366, 3100, 3101, 3124, 3123, 9567, 9568, 9591, 9590
24367, 3101, 3102, 3125, 3124, 9568, 9569, 9592, 9591
24368, 3102, 3103, 3126, 3125, 9569, 9570, 9593, 9592
24369, 3103, 3104, 3127, 3126, 9570, 9571, 9594, 9593
24370, 3104, 3105, 3128, 3127, 9571, 9572, 9595, 9594
24371, 3105, 3106, 3129, 3128, 9572, 9573, 9596, 9595
24372, 3106, 3107, 3130, 3129, 9573, 9574, 9597, 9596
24373, 3107, 3108, 3131, 3130, 9574, 9575, 9598, 9597
24374, 3108, 3109, 3132, 3131, 9575, 9576, 9599, 9598
24375, 3109, 3110, 3133, 3132, 9576, 9577, 9600, 9599
24376, 3110, 3111, 3134, 3133, 9577, 9578, 9601, 9600
24377, 3111, 3112, 3135, 3134, 9578, 9579, 9602, 9601
24378, 3112, 3113, 3136, 3135, 9579, 9580, 9603, 9602
24379, 3113, 3114, 3137, 3136, 9580, 9581, 9604, 9603
24380, 3114, 3115, 3138, 3137, 9581, 9582, 9605, 9604
24381, 3115, 366, 367, 3138, 9582, 1413, 1414, 9605
24382, 253, 3116, 3139, 254, 1391, 9583, 9606, 1392
24383, 3116, 3117, 3140, 3139, 9583, 9584, 9607, 9606
24384, 3117, 3118, 3141, 3140, 9584, 9585, 9608, 9607
24385, 3118, 3119, 3142, 3141, 9585, 9586, 9609, 9608
24386, 3119, 3120, 3143, 3142, 9586, 9587, 9610, 9609
24387, 3120, 3121, 3144, 3143, 9587, 9588, 9611, 9610
24388, 3121, 3122, 3145, 3144, 9588, 9589, 9612, 9611
24389, 3122, 3123, 3146, 3145, 9589, 9590, 9613, 9612
24390, 3123, 3124, 3147, 3146, 9590, 9591, 9614, 9613
24391, 3124, 3125, 3148, 3147, 9591, 9592, 9615, 9614
24392, 3125, 3126, 3149, 3148, 9592, 9593, 9616, 9615
24393, 3126, 3127, 3150, 3149, 9593, 9594, 9617, 9616
24394, 3127, 3128, 3151, 3150, 9594, 9595, 9618, 9617
24395, 3128, 3129, 3152, 3151, 9595, 9596, 9619, 9618
24396, 3129, 3130, 3153, 3152, 9596, 9597, 9620, 9619
24397, 3130, 3131, 3154, 3153, 9597, 9598, 9621, 9620
24398, 3131, 3132, 3155, 3154, 9598, 9599, 9622, 9621
24399, 3132, 3133, 3156, 3155, 9599, 9600, 9623, 9622
24400, 3133, 3134, 3157, 3156, 9600, 9601, 9624, 9623
24401, 3134, 3135, 3158, 3157, 9601, 9602, 9625, 9624
24402, 3135, 3136, 3159, 3158, 9602, 9603, 9626, 9625
24403, 3136, 3137, 3160, 3159, 9603, 9604, 9627, 9626
24404, 3137, 3138, 3161, 3160, 9604, 9605, 9628, 9627
24405, 3138, 367, 368, 3161, 9605, 1414, 1415, 9628
24406, 254, 3139, 3162, 255, 1392, 9606, 9629, 1393
24407, 3139, 3140, 3163, 3162, 9606, 9607, 9630, 9629
24408, 3140, 3141, 3164, 3163, 9607, 9608, 9631, 9630
24409, 3141, 3142, 3165, 3164, 9608, 9609, 9632, 9631
24410, 3142, 3143, 3166, 3165, 9609, 9610, 9633, 9632
24411, 3143, 3144, 3167, 3166, 9610, 9611, 9634, 9633
24412, 3144, 3145, 3168, 3167, 9611, 9612, 9635, 9634
24413, 3145, 3146, 3169, 3168, 9612, 9613, 9636, 9635
24414, 3146, 3147, 3170, 3169, 9613, 9614, 9637, 9636
24415, 3147, 3148, 3171, 3170, 9614, 9615, 9638, 9637
24416, 3148, 3149, 3172, 3171, 9615, 9616, 9639, 9638
24417, 3149, 3150, 3173, 3172, 9616, 9617, 9640, 9639
24418, 3150, 3151, 3174, 3173, 9617, 9618, 9641, 9640
24419, 3151, 3152, 3175, 3174, 9618, 9619, 9642, 9641
24420, 3152, 3153, 3176, 3175, 9619, 9620, 9643, 9642
24421, 3153, 3154, 3177, 3176, 9620, 9621, 9644, 9643
24422, 3154, 3155, 3178, 3177, 9621, 9622, 9645, 9644
24423, 3155, 3156, 3179, 3178, 9622, 9623, 9646, 9645
24424, 3156, 3157, 3180, 3179, 9623, 9624, 9647, 9646
24425, 3157, 3158, 3181, 3180, 9624, 9625, 9648, 9647
24426, 3158, 3159, 3182, 3181, 9625, 9626, 9649, 9648
24427, 3159, 3160, 3183, 3182, 9626, 9627, 9650, 9649
24428, 3160, 3161, 3184, 3183, 9627, 9628, 9651, 9650
24429, 3161, 368, 369, 3184, 9628, 1415, 1416, 9651
24430, 255, 3162, 3185, 256, 1393, 9629, 9652, 1394
24431, 3162, 3163, 3186, 3185, 9629, 9630, 9653, 9652
24432, 3163, 3164, 3187, 3186, 9630, 9631, 9654, 9653
24433, 3164, 3165, 3188, 3187, 9631, 9632, 9655, 9654
24434, 3165, 3166, 3189, 3188, 9632, 9633, 9656, 9655
24435, 3166, 3167, 3190, 3189, 9633, 9634, 9657, 9656
24436, 3167, 3168, 3191, 3190, 9634, 9635, 9658, 9657
24437, 3168, 3169, 3192, 3191, 9635, 9636, 9659, 9658
24438, 3169, 3170, 3193, 3192, 9636, 9637, 9660, 9659
24439, 3170, 3171, 3194, 3193, 9637, 9638, 9661, 9660
24440, 3171, 3172, 3195, 3194, 9638, 9639, 9662, 9661
24441, 3172, 3173, 3196, 3195, 9639, 9640, 9663, 9662
24442, 3173, 3174, 3197, 3196, 9640, 9641, 9664, 9663
24443, 3174, 3175, 3198, 3197, 9641, 9642, 9665, 9664
24444, 3175, 3176, 3199, 3198, 9642, 9643, 9666, 9665
24445, 3176, 3177, 3200, 3199, 9643, 9644, 9667, 9666
24446, 3177, 3178, 3201, 3200, 9644, 9645, 9668, 9667
24447, 3178, 3179, 3202, 3201, 9645, 9646, 9669, 9668
24448, 3179, 3180, 3203, 3202, 9646, 9647, 9670, 9669
24449, 3180, 3181, 3204, 3203, 9647, 9648, 9671, 9670
24450, 3181, 3182, 3205, 3204, 9648, 9649, 9672, 9671
24451, 3182, 3183, 3206, 3205, 9649, 9650, 9673, 9672
24452, 3183, 3184, 3207, 3206, 9650, 9651, 9674, 9673
24453, 3184, 369, 370, 3207, 9651, 1416, 1417, 9674
24454, 256, 3185, 3208, 257, 1394, 9652, 9675, 1395
24455, 3185, 3186, 3209, 3208, 9652, 9653, 9676, 9675
24456, 3186, 3187, 3210, 3209, 9653, 9654, 9677, 9676
24457, 3187, 3188, 3211, 3210, 9654, 9655, 9678, 9677
24458, 3188, 3189, 3212, 3211, 9655, 9656, 9679, 9678
24459, 3189, 3190, 3213, 3212, 9656, 9657, 9680, 9679
24460, 3190, 3191, 3214, 3213, 9657, 9658, 9681, 9680
24461, 3191, 3192, 3215, 3214, 9658, 9659, 9682, 9681
24462, 3192, 3193, 3216, 3215, 9659, 9660, 9683, 9682
24463, 3193, 3194, 3217, 3216, 9660, 9661, 9684, 9683
24464, 3194, 3195, 3218, 3217, 9661, 9662, 9685, 9684
24465, 3195, 3196, 3219, 3218, 9662, 9663, 9686, 9685
24466, 3196, 3197, 3220, 3219, 9663, 9664, 9687, 9686
24467, 3197, 3198, 3221, 3220, 9664, 9665, 9688, 9687
24468, 3198, 3199, 3222, 3221, 9665, 9666, 9689, 9688
24469, 3199, 3200, 3223, 3222, 9666, 9667, 9690, 9689
24470, 3200, 3201, 3224, 3223, 9667, 9668, 9691, 9690
24471, 3201, 3202, 3225, 3224, 9668, 9669, 9692, 9691
24472, 3202, 3203, 3226, 3225, 9669, 9670, 9693, 9692
24473, 3203, 3204, 3227, 3226, 9670, 9671, 9694, 9693
24474, 3204, 3205, 3228, 3227, 9671, 9672, 9695, 9694
24475, 3205, 3206, 3229, 3228, 9672, 9673, 9696, 9695
24476, 3206, 3207, 3230, 3229, 9673, 9674, 9697, 9696
24477, 3207, 370, 371, 3230, 9674, 1417, 1418, 9697
24478, 257, 3208, 3231, 258, 1395, 9675, 9698, 1396
24479, 3208, 3209, 3232, 3231, 9675, 9676, 9699, 9698
24480, 3209, 3210, 3233, 3232, 9676, 9677, 9700, 9699
24481, 3210, 3211, 3234, 3233, 9677, 9678, 9701, 9700
24482, 3211, 3212, 3235, 3234, 9678, 9679, 9702, 9701
24483, 3212, 3213, 3236, 3235, 9679, 9680, 9703, 9702
24484, 3213, 3214, 3237, 3236, 9680, 9681, 9704, 9703
24485, 3214, 3215, 3238, 3237, 9681, 9682, 9705, 9704
24486, 3215, 3216, 3239, 3238, 9682, 9683, 9706, 9705
24487, 3216, 3217, 3240, 3239, 9683, 9684, 9707, 9706
24488, 3217, 3218, 3241, 3240, 9684, 9685, 9708, 9707
24489, 3218, 3219, 3242, 3241, 9685, 9686, 9709, 9708
24490, 3219, 3220, 3243, 3242, 9686, 9687, 9710, 9709
24491, 3220, 3221, 3244, 3243, 9687, 9688, 9711, 9710
24492, 3221, 3222, 3245, 3244, 9688, 9689, 9712, 9711
24493, 3222, 3223, 3246, 3245, 9689, 9690, 9713, 9712
24494, 3223, 3224, 3247, 3246, 9690, 9691, 9714, 9713
24495, 3224, 3225, 3248, 3247, 9691, 9692, 9715, 9714
24496, 3225, 3226, 3249, 3248, 9692, 9693, 9716, 9715
24497, 3226, 3227, 3250, 3249, 9693, 9694, 9717, 9716
24498, 3227, 3228, 3251, 3250, 9694, 9695, 9718, 9717
24499, 3228, 3229, 3252, 3251, 9695, 9696, 9719, 9718
24500, 3229, 3230, 3253, 3252, 9696, 9697, 9720, 9719
24501, 3230, 371, 372, 3253, 9697, 1418, 1419, 9720
24502, 258, 3231, 3254, 259, 1396, 9698, 9721, 1397
24503, 3231, 3232, 3255, 3254, 9698, 9699, 9722, 9721
24504, 3232, 3233, 3256, 3255, 9699, 9700, 9723, 9722
24505, 3233, 3234, 3257, 3256, 9700, 9701, 9724, 9723
24506, 3234, 3235, 3258, 3257, 9701, 9702, 9725, 9724
24507, 3235, 3236, 3259, 3258, 9702, 9703, 9726, 9725
24508, 3236, 3237, 3260, 3259, 9703, 9704, 9727, 9726
24509, 3237, 3238, 3261, 3260, 9704, 9705, 9728, 9727
24510, 3238, 3239, 3262, 3261, 9705, 9706, 9729, 9728
24511, 3239, 3240, 3263, 3262, 9706, 9707, 9730, 9729
24512, 3240, 3241, 3264, 3263, 9707, 9708, 9731, 9730
24513, 3241, 3242, 3265, 3264, 9708, 9709, 9732, 9731
24514, 3242, 3243, 3266, 3265, 9709, 9710, 9733, 9732
24515, 3243, 3244, 3267, 3266, 9710, 9711, 9734, 9733
24516, 3244, 3245, 3268, 3267, 9711, 9712, 9735, 9734
24517, 3245, 3246, 3269, 3268, 9712, 9713, 9736, 9735
24518, 3246, 3247, 3270, 3269, 9713, 9714, 9737, 9736
24519, 3247, 3248, 3271, 3270, 9714, 9715, 9738, 9737
24520, 3248, 3249, 3272, 3271, 9715, 9716, 9739, 9738
24521, 3249, 3250, 3273, 3272, 9716, 9717, 9740, 9739
24522, 3250, 3251, 3274, 3273, 9717, 9718, 9741, 9740
24523, 3251, 3252, 3275, 3274, 9718, 9719, 9742, 9741
24524, 3252, 3253, 3276, 3275, 9719, 9720, 9743, 9742
24525, 3253, 372, 373, 3276, 9720, 1419, 1420, 9743
24526, 259, 3254, 3277, 260, 1397, 9721, 9744, 1398
24527, 3254, 3255, 3278, 3277, 9721, 9722, 9745, 9744
24528, 3255, 3256, 3279, 3278, 9722, 9723, 9746, 9745
24529, 3256, 3257, 3280, 3279, 9723, 9724, 9747, 9746
24530, 3257, 3258, 3281, 3280, 9724, 9725, 9748, 9747
24531, 3258, 3259, 3282, 3281, 9725, 9726, 9749, 9748
24532, 3259, 3260, 3283, 3282, 9726, 9727, 9750, 9749
24533, 3260, 3261, 3284, 3283, 9727, 9728, 9751, 9750
24534, 3261, 3262, 3285, 3284, 9728, 9729, 9752, 9751
24535, 3262, 3263, 3286, 3285, 9729, 9730, 9753, 9752
24536, 3263, 3264, 3287, 3286, 9730, 9731, 9754, 9753
24537, 3264, 3265, 3288, 3287, 9731, 9732, 9755, 9754
24538, 3265, 3266, 3289, 3288, 9732, 9733, 9756, 9755
24539, 3266, 3267, 3290, 3289, 9733, 9734, 9757, 9756
24540, 3267, 3268, 3291, 3290, 9734, 9735, 9758, 9757
24541, 3268, 3269, 3292, 3291, 9735, 9736, 9759, 9758
24542, 3269, 3270, 3293, 3292, 9736, 9737, 9760, 9759
24543, 3270, 3271, 3294, 3293, 9737, 9738, 9761, 9760
24544, 3271, 3272, 3295, 3294, 9738, 9739, 9762, 9761
24545, 3272, 3273, 3296, 3295, 9739, 9740, 9763, 9762
24546, 3273, 3274, 3297, 3296, 9740, 9741, 9764, 9763
24547, 3274, 3275, 3298, 3297, 9741, 9742, 9765, 9764
24548, 3275, 3276, 3299, 3298, 9742, 9743, 9766, 9765
24549, 3276, 373, 374, 3299, 9743, 1420, 1421, 9766
24550, 260, 3277, 3300, 261, 1398, 9744, 9767, 1399
24551, 3277, 3278, 3301, 3300, 9744, 9745, 9768, 9767
24552, 3278, 3279, 3302, 3301, 9745, 9746, 9769, 9768
24553, 3279, 3280, 3303, 3302, 9746, 9747, 9770, 9769
24554, 3280, 3281, 3304, 3303, 9747, 9748, 9771, 9770
24555, 3281, 3282, 3305, 3304, 9748, 9749, 9772, 9771
24556, 3282, 3283, 3306, 3305, 9749, 9750, 9773, 9772
24557, 3283, 3284, 3307, 3306, 9750, 9751, 9774, 9773
24558, 3284, 3285, 3308, 3307, 9751, 9752, 9775, 9774
24559, 3285, 3286, 3309, 3308, 9752, 9753, 9776, 9775
24560, 3286, 3287, 3310, 3309, 9753, 9754, 9777, 9776
24561, 3287, 3288, 3311, 3310, 9754, 9755, 9778, 9777
24562, 3288, 3289, 3312, 3311, 9755, 9756, 9779, 9778
24563, 3289, 3290, 3313, 3312, 9756, 9757, 9780, 9779
24564, 3290, 3291, 3314, 3313, 9757, 9758, 9781, 9780
24565, 3291, 3292, 3315, 3314, 9758, 9759, 9782, 9781
24566, 3292, 3293, 3316, 3315, 9759, 9760, 9783, 9782
24567, 3293, 3294, 3317, 3316, 9760, 9761, 9784, 9783
24568, 3294, 3295, 3318, 3317, 9761, 9762, 9785, 9784
24569, 3295, 3296, 3319, 3318, 9762, 9763, 9786, 9785
24570, 3296, 3297, 3320, 3319, 9763, 9764, 9787, 9786
24571, 3297, 3298, 3321, 3320, 9764, 9765, 9788, 9787
24572, 3298, 3299, 3322, 3321, 9765, 9766, 9789, 9788
24573, 3299, 374, 375, 3322, 9766, 1421, 1422, 9789
24574, 261, 3300, 3323, 262, 1399, 9767, 9790, 1400
24575, 3300, 3301, 3324, 3323, 9767, 9768, 9791, 9790
24576, 3301, 3302, 3325, 3324, 9768, 9769, 9792, 9791
24577, 3302, 3303, 3326, 3325, 9769, 9770, 9793, 9792
24578, 3303, 3304, 3327, 3326, 9770, 9771, 9794, 9793
24579, 3304, 3305, 3328, 3327, 9771, 9772, 9795, 9794
24580, 3305, 3306, 3329, 3328, 9772, 9773, 9796, 9795
24581, 3306, 3307, 3330, 3329, 9773, 9774, 9797, 9796
24582, 3307, 3308, 3331, 3330, 9774, 9775, 9798, 9797
24583, 3308, 3309, 3332, 3331, 9775, 9776, 9799, 9798
24584, 3309, 3310, 3333, 3332, 9776, 9777, 9800, 9799
24585, 3310, 3311, 3334, 3333, 9777, 9778, 9801, 9800
24586, 3311, 3312, 3335, 3334, 9778, 9779, 9802, 9801
24587, 3312, 3313, 3336, 3335, 9779, 9780, 9803, 9802
24588, 3313, 3314, 3337, 3336, 9780, 9781, 9804, 9803
24589, 3314, 3315, 3338, 3337, 9781, 9782, 9805, 9804
24590, 3315, 3316, 3339, 3338, 9782, 9783, 9806, 9805
24591, 3316, 3317, 3340, 3339, 9783, 9784, 9807, 9806
24592, 3317, 3318, 3341, 3340, 9784, 9785, 9808, 9807
24593, 3318, 3319, 3342, 3341, 9785, 9786, 9809, 9808
24594, 3319, 3320, 3343, 3342, 9786, 9787, 9810, 9809
24595, 3320, 3321, 3344, 3343, 9787, 9788, 9811, 9810
24596, 3321, 3322, 3345, 3344, 9788, 9789, 9812, 9811
24597, 3322, 375, 376, 3345, 9789, 1422, 1423, 9812
24598, 262, 3323, 3346, 263, 1400, 9790, 9813, 1401
24599, 3323, 3324, 3347, 3346, 9790, 9791, 9814, 9813
24600, 3324, 3325, 3348, 3347, 9791, 9792, 9815, 9814
24601, 3325, 3326, 3349, 3348, 9792, 9793, 9816, 9815
24602, 3326, 3327, 3350, 3349, 9793, 9794, 9817, 9816
24603, 3327, 3328, 3351, 3350, 9794, 9795, 9818, 9817
24604, 3328, 3329, 3352, 3351, 9795, 9796, 9819, 9818
24605, 3329, 3330, 3353, 3352, 9796, 9797, 9820, 9819
24606, 3330, 3331, 3354, 3353, 9797, 9798, 9821, 9820
24607, 3331, 3332, 3355, 3354, 9798, 9799, 9822, 9821
24608, 3332, 3333, 3356, 3355, 9799, 9800, 9823, 9822
24609, 3333, 3334, 3357, 3356, 9800, 9801, 9824, 9823
24610, 3334, 3335, 3358, 3357, 9801, 9802, 9825, 9824
24611, 3335, 3336, 3359, 3358, 9802, 9803, 9826, 9825
24612, 3336, 3337, 3360, 3359, 9803, 9804, 9827, 9826
24613, 3337, 3338, 3361, 3360, 9804, 9805, 9828, 9827
24614, 3338, 3339, 3362, 3361, 9805, 9806, 9829, 9828
24615, 3339, 3340, 3363, 3362, 9806, 9807, 9830, 9829
24616, 3340, 3341, 3364, 3363, 9807, 9808, 9831, 9830
24617, 3341, 3342, 3365, 3364, 9808, 9809, 9832, 9831
24618, 3342, 3343, 3366, 3365, 9809, 9810, 9833, 9832
24619, 3343, 3344, 3367, 3366, 9810, 9811, 9834, 9833
24620, 3344, 3345, 3368, 3367, 9811, 9812, 9835, 9834
24621, 3345, 376, 377, 3368, 9812, 1423, 1424, 9835
24622, 263, 3346, 309, 9, 1401, 9813, 1333, 65
24623, 3346, 3347, 310, 309, 9813, 9814, 1334, 1333
24624, 3347, 3348, 311, 310, 9814, 9815, 1335, 1334
24625, 3348, 3349, 312, 311, 9815, 9816, 1336, 1335
24626, 3349, 3350, 313, 312, 9816, 9817, 1337, 1336
24627, 3350, 3351, 314, 313, 9817, 9818, 1338, 1337
24628, 3351, 3352, 315, 314, 9818, 9819, 1339, 1338
24629, 3352, 3353, 316, 315, 9819, 9820, 1340, 1339
24630, 3353, 3354, 317, 316, 9820, 9821, 1341, 1340
24631, 3354, 3355, 318, 317, 9821, 9822, 1342, 1341
24632, 3355, 3356, 319, 318, 9822, 9823, 1343, 1342
24633, 3356, 3357, 320, 319, 9823, 9824, 1344, 1343
24634, 3357, 3358, 321, 320, 9824, 9825, 1345, 1344
24635, 3358, 3359, 322, 321, 9825, 9826, 1346, 1345
24636, 3359, 3360, 323, 322, 9826, 9827, 1347, 1346
24637, 3360, 3361, 324, 323, 9827, 9828, 1348, 1347
24638, 3361, 3362, 325, 324, 9828, 9829, 1349, 1348
24639, 3362, 3363, 326, 325, 9829, 9830, 1350, 1349
24640, 3363, 3364, 327, 326, 9830, 9831, 1351, 1350
24641, 3364, 3365, 328, 327, 9831, 9832, 1352, 1351
24642, 3365, 3366, 329, 328, 9832, 9833, 1353, 1352
24643, 3366, 3367, 330, 329, 9833, 9834, 1354, 1353
24644, 3367, 3368, 331, 330, 9834, 9835, 1355, 1354
24645, 3368, 377, 13, 331, 9835, 1424, 66, 1355
*ELEMENT, type=C3D8, ELSET=Volume15
24646, 35, 796, 6827, 910, 69, 1471, 9836, 1425
24647, 910, 6827, 6828, 911, 1425, 9836, 9837, 1426
24648, 911, 6828, 6829, 912, 1426, 9837, 9838, 1427
24649, 912, 6829, 6830, 913, 1427, 9838, 9839, 1428
24650, 913, 6830, 6831, 914, 1428, 9839, 9840, 1429
24651, 914, 6831, 6832, 915, 1429, 9840, 9841, 1430
24652, 915, 6832, 6833, 916, 1430, 9841, 9842, 1431
24653, 916, 6833, 6834, 917, 1431, 9842, 9843, 1432
24654, 917, 6834, 6835, 918, 1432, 9843, 9844, 1433
24655, 918, 6835, 6836, 919, 1433, 9844, 9845, 1434
24656, 919, 6836, 6837, 920, 1434, 9845, 9846, 1435
24657, 920, 6837, 6838, 921, 1435, 9846, 9847, 1436
24658, 921, 6838, 6839, 922, 1436, 9847, 9848, 1437
24659, 922, 6839, 6840, 923, 1437, 9848, 9849, 1438
24660, 923, 6840, 6841, 924, 1438, 9849, 9850, 1439
24661, 924, 6841, 6842, 925, 1439, 9850, 9851, 1440
24662, 925, 6842, 6843, 926, 1440, 9851, 9852, 1441
24663, 926, 6843, 6844, 927, 1441, 9852, 9853, 1442
24664, 927, 6844, 6845, 928, 1442, 9853, 9854, 1443
24665, 928, 6845, 6846, 929, 1443, 9854, 9855, 1444
24666, 929, 6846, 6847, 930, 1444, 9855, 9856, 1445
24667, 930, 6847, 6848, 931, 1445, 9856, 9857, 1446
24668, 931, 6848, 6849, 932, 1446, 9857, 9858, 1447
24669, 932, 6849, 956, 39, 1447, 9858, 1494, 70
24670, 796, 797, 6850, 6827, 1471, 1472, 9859, 9836
24671, 6827, 6850, 6851, 6828, 9836, 9859, 9860, 9837
24672, 6828, 6851, 6852, 6829, 9837, 9860, 9861, 9838
24673, 6829, 6852, 6853, 6830, 9838, 9861, 9862, 9839
24674, 6830, 6853, 6854, 6831, 9839, 9862, 9863, 9840
24675, 6831, 6854, 6855, 6832, 9840, 9863, 9864, 9841
24676, 6832, 6855, 6856, 6833, 9841, 9864, 9865, 9842
24677, 6833, 6856, 6857, 6834, 9842, 9865, 9866, 9843
24678, 6834, 6857, 6858, 6835, 9843, 9866, 9867, 9844
24679, 6835, 6858, 6859, 6836, 9844, 9867, 9868, 9845
24680, 6836, 6859, 6860, 6837, 9845, 9868, 9869, 9846
24681, 6837, 6860, 6861, 6838, 9846, 9869, 9870, 9847
24682, 6838, 6861, 6862, 6839, 9847, 9870, 9871, 9848
24683, 6839, 6862, 6863, 6840, 9848, 9871, 9872, 9849
24684, 6840, 6863, 6864, 6841, 9849, 9872, 9873, 9850
24685, 6841, 6864, 6865, 6842, 9850, 9873, 9874, 9851
24686, 6842, 6865, 6866, 6843, 9851, 9874, 9875, 9852
24687, 6843, 6866, 6867, 6844, 9852, 9875, 9876, 9853
24688, 6844, 6867, 6868, 6845, 9853, 9876, 9877, 9854
24689, 6845, 6868, 6869, 6846, 9854, 9877, 9878, 9855
24690, 6846, 6869, 6870, 6847, 9855, 9878, 9879, 9856
24691, 6847, 6870, 6871, 6848, 9856, 9879, 9880, 9857
24692, 6848, 6871, 6872, 6849, 9857, 9880, 9881, 9858
24693, 6849, 6872, 957, 956, 9858, 9881, 1495, 1494
24694, 797, 798, 6873, 6850, 1472, 1473, 9882, 9859
24695, 6850, 6873, 6874, 6851, 9859, 9882, 9883, 9860
24696, 6851, 6874, 6875, 6852, 9860, 9883, 9884, 9861
24697, 6852, 6875, 6876, 6853, 9861, 9884, 9885, 9862
24698, 6853, 6876, 6877, 6854, 9862, 9885, 9886, 9863
24699, 6854, 6877, 6878, 6855, 9863, 9886, 9887, 9864
24700, 6855, 6878, 6879, 6856, 9864, 9887, 9888, 9865
24701, 6856, 6879, 6880, 6857, 9865, 9888, 9889, 9866
24702, 6857, 6880, 6881, 6858, 9866, 9889, 9890, 9867
24703, 6858, 6881, 6882, 6859, 9867, 9890, 9891, 9868
24704, 6859, 6882, 6883, 6860, 9868, 9891, 9892, 9869
24705, 6860, 6883, 6884, 6861, 9869, 9892, 9893, 9870
24706, 6861, 6884, 6885, 6862, 9870, 9893, 9894, 9871
24707, 6862, 6885, 6886, 6863, 9871, 9894, 9895, 9872
24708, 6863, 6886, 6887, 6864, 9872, 9895, 9896, 9873
24709, 6864, 6887, 6888, 6865, 9873, 9896, 9897, 9874
24710, 6865, 6888, 6889, 6866, 9874, 9897, 9898, 9875
24711, 6866, 6889, 6890, 6867, 9875, 9898, 9899, 9876
24712, 6867, 6890, 6891, 6868, 9876, 9899, 9900, 9877
24713, 6868, 6891, 6892, 6869, 9877, 9900, 9901, 9878
24714, 6869, 6892, 6893, 6870, 9878, 9901, 9902, 9879
24715, 6870, 6893, 6894, 6871, 9879, 9902, 9903, 9880
24716, 6871, 6894, 6895, 6872, 9880, 9903, 9904, 9881
24717, 6872, 6895, 958, 957, 9881, 9904, 1496, 1495
24718, 798, 799, 6896, 6873, 1473, 1474, 9905, 9882
24719, 6873, 6896, 6897, 6874, 9882, 9905, 9906, 9883
24720, 6874, 6897, 6898, 6875, 9883, 9906, 9907, 9884
24721, 6875, 6898, 6899, 6876, 9884, 9907, 9908, 9885
24722, 6876, 6899, 6900, 6877, 9885, 9908, 9909, 9886
24723, 6877, 6900, 6901, 6878, 9886, 9909, 9910, 9887
24724, 6878, 6901, 6902, 6879, 9887, 9910, 9911, 9888
24725, 6879, 6902, 6903, 6880, 9888, 9911, 9912, 9889
24726, 6880, 6903, 6904, 6881, 9889, 9912, 9913, 9890
24727, 6881, 6904, 6905, 6882, 9890, 9913, 9914, 9891
24728, 6882, 6905, 6906, 6883, 9891, 9914, 9915, 9892
24729, 6883, 6906, 6907, 6884, 9892, 9915, 9916, 9893
24730, 6884, 6907, 6908, 6885, 9893, 9916, 9917, 9894
24731, 6885, 6908, 6909, 6886, 9894, 9917, 9918, 9895
24732, 6886, 6909, 6910, 6887, 9895, 9918, 9919, 9896
24733, 6887, 6910, 6911, 6888, 9896, 9919, 9920, 9897
24734, 6888, 6911, 6912, 6889, 9897, 9920, 9921, 9898
24735, 6889, 6912, 6913, 6890, 9898, 9921, 9922, 9899
24736, 6890, 6913, 6914, 6891, 9899, 9922, 9923, 9900
24737, 6891, 6914, 6915, 6892, 9900, 9923, 9924, 9901
24738, 6892, 6915, 6916, 6893, 9901, 9924, 9925, 9902
24739, 6893, 6916, 6917, 6894, 9902, 9925, 9926, 9903
24740, 6894, 6917, 6918, 6895, 9903, 9926, 9927, 9904
24741, 6895, 6918, 959, 958, 9904, 9927, 1497, 1496
24742, 799, 800, 6919, 6896, 1474, 1475, 9928, 9905
24743, 6896, 6919, 6920, 6897, 9905, 9928, 9929, 9906
24744, 6897, 6920, 6921, 6898, 9906, 9929, 9930, 9907
24745, 6898, 6921, 6922, 6899, 9907, 9930, 9931, 9908
24746, 6899, 6922, 6923, 6900, 9908, 9931, 9932, 9909
24747, 6900, 6923, 6924, 6901, 9909, 9932, 9933, 9910
24748, 6901, 6924, 6925, 6902, 9910, 9933, 9934, 9911
24749, 6902, 6925, 6926, 6903, 9911, 9934, 9935, 9912
24750, 6903, 6926, 6927, 6904, 9912, 9935, 9936, 9913
24751, 6904, 6927, 6928, 6905, 9913, 9936, 9937, 9914
24752, 6905, 6928, 6929, 6906, 9914, 9937, 9938, 9915
24753, 6906, 6929, 6930, 6907, 9915, 9938, 9939, 9916
24754, 6907, 6930, 6931, 6908, 9916, 9939, 9940, 9917
24755, 6908, 6931, 6932, 6909, 9917, 9940, 9941, 9918
24756, 6909, 6932, 6933, 6910, 9918, 9941, 9942, 9919
24757, 6910, 6933, 6934, 6911, 9919, 9942, 9943, 9920
24758, 6911, 6934, 6935, 6912, 9920, 9943, 9944, 9921
24759, 6912, 6935, 6936, 6913, 9921, 9944, 9945, 9922
24760, 6913, 6936, 6937, 6914, 9922, 9945, 9946, 9923
24761, 6914, 6937, 6938, 6915, 9923, 9946, 9947, 9924
24762, 6915, 6938, 6939, 6916, 9924, 9947, 9948, 9925
24763, 6916, 6939, 6940, 6917, 9925, 9948, 9949, 9926
24764, 6917, 6940, 6941, 6918, 9926, 9949, 9950, 9927
24765, 6918, 6941, 960, 959, 9927, 9950, 1498, 1497
24766, 800, 801, 6942, 6919, 1475, 1476, 9951, 9928
24767, 6919, 6942, 6943, 6920, 9928, 9951, 9952, 9929
24768, 6920, 6943, 6944, 6921, 9929, 9952, 9953, 9930
24769, 6921, 6944, 6945, 6922, 9930, 9953, 9954, 9931
24770, 6922, 6945, 6946, 6923, 9931, 9954, 9955, 9932
24771, 6923, 6946, 6947, 6924, 9932, 9955, 9956, 9933
24772, 6924, 6947, 6948, 6925, 9933, 9956, 9957, 9934
24773, 6925, 6948, 6949, 6926, 9934, 9957, 9958, 9935
24774, 6926, 6949, 6950, 6927, 9935, 9958, 9959, 9936
24775, 6927, 6950, 6951, 6928, 9936, 9959, 9960, 9937
24776, 6928, 6951, 6952, 6929, 9937, 9960, 9961, 9938
24777, 6929, 6952, 6953, 6930, 9938, 9961, 9962, 9939
24778, 6930, 6953, 6954, 6931, 9939, 9962, 9963, 9940
24779, 6931, 6954, 6955, 6932, 9940, 9963, 9964, 9941
24780, 6932, 6955, 6956, 6933, 9941, 9964, 9965, 9942
24781, 6933, 6956, 6957, 6934, 9942, 9965, 9966, 9943
24782, 6934, 6957, 6958, 6935, 9943, 9966, 9967, 9944
24783, 6935, 6958, 6959, 6936, 9944, 9967, 9968, 9945
24784, 6936, 6959, 6960, 6937, 9945, 9968, 9969, 9946
24785, 6937, 6960, 6961, 6938, 9946, 9969, 9970, 9947
24786, 6938, 6961, 6962, 6939, 9947, 9970, 9971, 9948
24787, 6939, 6962, 6963, 6940, 9948, 9971, 9972, 9949
24788, 6940, 6963, 6964, 6941, 9949, 9972, 9973, 9950
24789, 6941, 6964, 961, 960, 9950, 9973, 1499, 1498
24790, 801, 802, 6965, 6942, 1476, 1477, 9974, 9951
24791, 6942, 6965, 6966, 6943, 9951, 9974, 9975, 9952
24792, 6943, 6966, 6967, 6944, 9952, 9975, 9976, 9953
24793, 6944, 6967, 6968, 6945, 9953, 9976, 9977, 9954
24794, 6945, 6968, 6969, 6946, 9954, 9977, 9978, 9955
24795, 6946, 6969, 6970, 6947, 9955, 9978, 9979, 9956
24796, 6947, 6970, 6971, 6948, 9956, 9979, 9980, 9957
24797, 6948, 6971, 6972, 6949, 9957, 9980, 9981, 9958
24798, 6949, 6972, 6973, 6950, 9958, 9981, 9982, 9959
24799, 6950, 6973, 6974, 6951, 9959, 9982, 9983, 9960
24800, 6951, 6974, 6975, 6952, 9960, 9983, 9984, 9961
24801, 6952, 6975, 6976, 6953, 9961, 9984, 9985, 9962
24802, 6953, 6976, 6977, 6954, 9962, 9985, 9986, 9963
24803, 6954, 6977, 6978, 6955, 9963, 9986, 9987, 9964
24804, 6955, 6978, 6979, 6956, 9964, 9987, 9988, 9965
24805, 6956, 6979, 6980, 6957, 9965, 9988, 9989, 9966
24806, 6957, 6980, 6981, 6958, 9966, 9989, 9990, 9967
24807, 6958, 6981, 6982, 6959, 9967, 9990, 9991, 9968
24808, 6959, 6982, 6983, 6960, 9968, 9991, 9992, 9969
24809, 6960, 6983, 6984, 6961, 9969, 9992, 9993, 9970
24810, 6961, 6984, 6985, 6962, 9970, 9993, 9994, 9971
24811, 6962, 6985, 6986, 6963, 9971, 9994, 9995, 9972
24812, 6963, 6986, 6987, 6964, 9972, 9995, 9996, 9973
24813, 6964, 6987, 962, 961, 9973, 9996, 1500, 1499
24814, 802, 803, 6988, 6965, 1477, 1478, 9997, 9974
24815, 6965, 6988, 6989, 6966, 9974, 9997, 9998, 9975
24816, 6966, 6989, 6990, 6967, 9975, 9998, 9999, 9976
24817, 6967, 6990, 6991, 6968, 9976, 9999, 10000, 9977
24818, 6968, 6991, 6992, 6969, 9977, 10000, 10001, 9978
24819, 6969, 6992, 6993, 6970, 9978, 10001, 10002, 9979
24820, 6970, 6993, 6994, 6971, 9979, 10002, 10003, 9980
24821, 6971, 6994, 6995, 6972, 9980, 10003, 10004, 9981
24822, 6972, 6995, 6996, 6973, 9981, 10004, 10005, 9982
24823, 6973, 6996, 6997, 6974, 9982, 10005, 10006, 9983
24824, 6974, 6997, 6998, 6975, 9983, 10006, 10007, 9984
24825, 6975, 6998, 6999, 6976, 9984, 10007, 10008, 9985
24826, 6976, 6999, 7000, 6977, 9985, 10008, 10009, 9986
24827, 6977, 7000, 7001, 6978, 9986, 10009, 10010, 9987
24828, 6978, 7001, 7002, 6979, 9987, 10010, 10011, 9988
24829, 6979, 7002, 7003, 6980, 9988, 10011, 10012, 9989
24830, 6980, 7003, 7004, 6981, 9989, 10012, 10013, 9990
24831, 6981, 7004, 7005, 6982, 9990, 10013, 10014, 9991
24832, 6982, 7005, 7006, 6983, 9991, 10014, 10015, 9992
24833, 6983, 7006, 7007, 6984, 9992, 10015, 10016, 9993
24834, 6984, 7007, 7008, 6985, 9993, 10016, 10017, 9994
24835, 6985, 7008, 7009, 6986, 9994, 10017, 10018, 9995
24836, 6986, 7009, 7010, 6987, 9995, 10018, 10019, 9996
24837, 6987, 7010, 963, 962, 9996, 10019, 1501, 1500
24838, 803, 804, 7011, 6988, 1478, 1479, 10020, 9997
24839, 6988, 7011, 7012, 6989, 9997, 10020, 10021, 9998
24840, 6989, 7012, 7013, 6990, 9998, 10021, 10022, 9999
24841, 6990, 7013, 7014, 6991, 9999, 10022, 10023, 10000
24842, 6991, 7014, 7015, 6992, 10000, 10023, 10024, 10001
24843, 6992, 7015, 7016, 6993, 10001, 10024, 10025, 10002
24844, 6993, 7016, 7017, 6994, 10002, 10025, 10026, 10003
24845, 6994, 7017, 7018, 6995, 10003, 10026, 10027, 10004
24846, 6995, 7018, 7019, 6996, 10004, 10027, 10028, 10005
24847, 6996, 7019, 7020, 6997, 10005, 10028, 10029, 10006
24848, 6997, 7020, 7021, 6998, 10006, 10029, 10030, 10007
24849, 6998, 7021, 7022, 6999, 10007, 10030, 10031, 10008
24850, 6999, 7022, 7023, 7000, 10008, 10031, 10032, 10009
24851, 7000, 7023, 7024, 7001, 10009, 10032, 10033, 10010
24852, 7001, 7024, 7025, 7002, 10010, 10033, 10034, 10011
24853, 7002, 7025, 7026, 7003, 10011, 10034, 10035, 10012
24854, 7003, 7026, 7027, 7004, 10012, 10035, 10036, 10013
24855, 7004, 7027, 7028, 7005, 10013, 10036, 10037, 10014
24856, 7005, 7028, 7029, 7006, 10014, 10037, 10038, 10015
24857, 7006, 7029, 7030, 7007, 10015, 10038, 10039, 10016
24858, 7007, 7030, 7031, 7008, 10016, 10039, 10040, 10017
24859, 7008, 7031, 7032, 7009, 10017, 10040, 10041, 10018
24860, 7009, 7032, 7033, 7010, 10018, 10041, 10042, 10019
24861, 7010, 7033, 964, 963, 10019, 10042, 1502, 1501
24862, 804, 805, 7034, 7011, 1479, 1480, 10043, 10020
24863, 7011, 7034, 7035, 7012, 10020, 10043, 10044, 10021
24864, 7012, 7035, 7036, 7013, 10021, 10044, 10045, 10022
24865, 7013, 7036, 7037, 7014, 10022, 10045, 10046, 10023
24866, 7014, 7037, 7038, 7015, 10023, 10046, 10047, 10024
24867, 7015, 7038, 7039, 7016, 10024, 10047, 10048, 10025
24868, 7016, 7039, 7040, 7017, 10025, 10048, 10049, 10026
24869, 7017, 7040, 7041, 7018, 10026, 10049, 10050, 10027
24870, 7018, 7041, 7042, 7019, 10027, 10050, 10051, 10028
24871, 7019, 7042, 7043, 7020, 10028, 10051, 10052, 10029
24872, 7020, 7043, 7044, 7021, 10029, 10052, 10053, 10030
24873, 7021, 7044, 7045, 7022, 10030, 10053, 10054, 10031
24874, 7022, 7045, 7046, 7023, 10031, 10054, 10055, 10032
24875, 7023, 7046, 7047, 7024, 10032, 10055, 10056, 10033
24876, 7024, 7047, 7048, 7025, 10033, 10056, 10057, 10034
24877, 7025, 7048, 7049, 7026, 10034, 10057, 10058, 10035
24878, 7026, 7049, 7050, 7027, 10035, 10058, 10059, 10036
24879, 7027, 7050, 7051, 7028, 10036, 10059, 10060, 10037
24880, 7028, 7051, 7052, 7029, 10037, 10060, 10061, 10038
24881, 7029, 7052, 7053, 7030, 10038, 10061, 10062, 10039
24882, 7030, 7053, 7054, 7031, 10039, 10062, 10063, 10040
24883, 7031, 7054, 7055, 7032, 10040, 10063, 10064, 10041
24884, 7032, 7055, 7056, 7033, 10041, 10064, 10065, 10042
24885, 7033, 7056, 965, 964, 10042, 10065, 1503, 1502
24886, 805, 806, 7057, 7034, 1480, 1481, 10066, 10043
24887, 7034, 7057, 7058, 7035, 10043, 10066, 10067, 10044
24888, 7035, 7058, 7059, 7036, 10044, 10067, 10068, 10045
24889, 7036, 7059, 7060, 7037, 10045, 10068, 10069, 10046
24890, 7037, 7060, 7061, 7038, 10046, 10069, 10070, 10047
24891, 7038, 7061, 7062, 7039, 10047, 10070, 10071, 10048
24892, 7039, 7062, 7063, 7040, 10048, 10071, 10072, 10049
24893, 7040, 7063, 7064, 7041, 10049, 10072, 10073, 10050
24894, 7041, 7064, 7065, 7042, 10050, 10073, 10074, 10051
24895, 7042, 7065, 7066, 7043, 10051, 10074, 10075, 10052
24896, 7043, 7066, 7067, 7044, 10052, 10075, 10076, 10053
24897, 7044, 7067, 7068, 7045, 10053, 10076, 10077, 10054
24898, 7045, 7068, 7069, 7046, 10054, 10077, 10078, 10055
24899, 7046, 7069, 7070, 7047, 10055, 10078, 10079, 10056
24900, 7047, 7070, 7071, 7048, 10056, 10079, 10080, 10057
24901, 7048, 7071, 7072, 7049, 10057, 10080, 10081, 10058
24902, 7049, 7072, 7073, 7050, 10058, 10081, 10082, 10059
24903, 7050, 7073, 7074, 7051, 10059, 10082, 10083, 10060
24904, 7051, 7074, 7075, 7052, 10060, 10083, 10084, 10061
24905, 7052, 7075, 7076, 7053, 10061, 10084, 10085, 10062
24906, 7053, 7076, 7077, 7054, 10062, 10085, 10086, 10063
24907, 7054, 7077, 7078, 7055, 10063, 10086, 10087, 10064
24908, 7055, 7078, 7079, 7056, 10064, 10087, 10088, 10065
24909, 7056, 7079, 966, 965, 10065, 10088, 1504, 1503
24910, 806, 807, 7080, 7057, 1481, 1482, 10089, 10066
24911, 7057, 7080, 7081, 7058, 10066, 10089, 10090, 10067
24912, 7058, 7081, 7082, 7059, 10067, 10090, 10091, 10068
24913, 7059, 7082, 7083, 7060, 10068, 10091, 10092, 10069
24914, 7060, 7083, 7084, 7061, 10069, 10092, 10093, 10070
24915, 7061, 7084, 7085, 7062, 10070, 10093, 10094, 10071
24916, 7062, 7085, 7086, 7063, 10071, 10094, 10095, 10072
24917, 7063, 7086, 7087, 7064, 10072, 10095, 10096, 10073
24918, 7064, 7087, 7088, 7065, 10073, 10096, 10097, 10074
24919, 7065, 7088, 7089, 7066, 10074, 10097, 10098, 10075
24920, 7066, 7089, 7090, 7067, 10075, 10098, 10099, 10076
24921, 7067, 7090, 7091, 7068, 10076, 10099, 10100, 10077
24922, 7068, 7091, 7092, 7069, 10077, 10100, 10101, 10078
24923, 7069, 7092, 7093, 7070, 10078, 10101, 10102, 10079
24924, 7070, 7093, 7094, 7071, 10079, 10102, 10103, 10080
24925, 7071, 7094, 7095, 7072, 10080, 10103, 10104, 10081
24926, 7072, 7095, 7096, 7073, 10081, 10104, 10105, 10082
24927, 7073, 7096, 7097, 7074, 10082, 10105, 10106, 10083
24928, 7074, 7097, 7098, 7075, 10083, 10106, 10107, 10084
24929, 7075, 7098, 7099, 7076, 10084, 10107, 10108, 10085
24930, 7076, 7099, 7100, 7077, 10085, 10108, 10109, 10086
24931, 7077, 7100, 7101, 7078, 10086, 10109, 10110, 10087
24932, 7078, 7101, 7102, 7079, 10087, 10110, 10111, 10088
24933, 7079, 7102, 967, 966, 10088, 10111, 1505, 1504
24934, 807, 808, 7103, 7080, 1482, 1483, 10112, 10089
24935, 7080, 7103, 7104, 7081, 10089, 10112, 10113, 10090
24936, 7081, 7104, 7105, 7082, 10090, 10113, 10114, 10091
24937, 7082, 7105, 7106, 7083, 10091, 10114, 10115, 10092
24938, 7083, 7106, 7107, 7084, 10092, 10115, 10116, 10093
24939, 7084, 7107, 7108, 7085, 10093, 10116, 10117, 10094
24940, 7085, 7108, 7109, 7086, 10094, 10117, 10118, 10095
24941, 7086, 7109, 7110, 7087, 10095, 10118, 10119, 10096
24942, 7087, 7110, 7111, 7088, 10096, 10119, 10120, 10097
24943, 7088, 7111, 7112, 7089, 10097, 10120, 10121, 10098
24944, 7089, 7112, 7113, 7090, 10098, 10121, 10122, 10099
24945, 7090, 7113, 7114, 7091, 10099, 10122, 10123, 10100
24946, 7091, 7114, 7115, 7092, 10100, 10123, 10124, 10101
24947, 7092, 7115, 7116, 7093, 10101, 10124, 10125, 10102
24948, 7093, 7116, 7117, 7094, 10102, 10125, 10126, 10103
24949, 7094, 7117, 7118, 7095, 10103, 10126, 10127, 10104
24950, 7095, 7118, 7119, 7096, 10104, 10127, 10128, 10105
24951, 7096, 7119, 7120, 7097, 10105, 10128, 10129, 10106
24952, 7097, 7120, 7121, 7098, 10106, 10129, 10130, 10107
24953, 7098, 7121, 7122, 7099, 10107, 10130, 10131, 10108
24954, 7099, 7122, 7123, 7100, 10108, 10131, 10132, 10109
24955, 7100, 7123, 7124, 7101, 10109, 10132, 10133, 10110
24956, 7101, 7124, 7125, 7102, 10110, 10133, 10134, 10111
24957, 7102, 7125, 968, 967, 10111, 10134, 1506, 1505
24958, 808, 809, 7126, 7103, 1483, 1484, 10135, 10112
24959, 7103, 7126, 7127, 7104, 10112, 10135, 10136, 10113
24960, 7104, 7127, 7128, 7105, 10113, 10136, 10137, 10114
24961, 7105, 7128, 7129, 7106, 10114, 10137, 10138, 10115
24962, 7106, 7129, 7130, 7107, 10115, 10138, 10139, 10116
24963, 7107, 7130, 7131, 7108, 10116, 10139, 10140, 10117
24964, 7108, 7131, 7132, 7109, 10117, 10140, 10141, 10118
24965, 7109, 7132, 7133, 7110, 10118, 10141, 10142, 10119
24966, 7110, 7133, 7134, 7111, 10119, 10142, 10143, 10120
24967, 7111, 7134, 7135, 7112, 10120, 10143, 10144, 10121
24968, 7112, 7135, 7136, 7113, 10121, 10144, 10145, 10122
24969, 7113, 7136, 7137, 7114, 10122, 10145, 10146, 10123
24970, 7114, 7137, 7138, 7115, 10123, 10146, 10147, 10124
24971, 7115, 7138, 7139, 7116, 10124, 10147, 10148, 10125
24972, 7116, 7139, 7140, 7117, 10125, 10148, 10149, 10126
24973, 7117, 7140, 7141, 7118, 10126, 10149, 10150, 10127
24974, 7118, 7141, 7142, 7119, 10127, 10150, 10151, 10128
24975, 7119, 7142, 7143, 7120, 10128, 10151, 10152, 10129
24976, 7120, 7143, 7144, 7121, 10129, 10152, 10153, 10130
24977, 7121, 7144, 7145, 7122, 10130, 10153, 10154, 10131
24978, 7122, 7145, 7146, 7123, 10131, 10154, 10155, 10132
24979, 7123, 7146, 7147, 7124, 10132, 10155, 10156, 10133
24980, 7124, 7147, 7148, 7125, 10133, 10156, 10157, 10134
24981, 7125, 7148, 969, 968, 10134, 10157, 1507, 1506
24982, 809, 810, 7149, 7126, 1484, 1485, 10158, 10135
24983, 7126, 7149, 7150, 7127, 10135, 10158, 10159, 10136
24984, 7127, 7150, 7151, 7128, 10136, 10159, 10160, 10137
24985, 7128, 7151, 7152, 7129, 10137, 10160, 10161, 10138
24986, 7129, 7152, 7153, 7130, 10138, 10161, 10162, 10139
24987, 7130, 7153, 7154, 7131, 10139, 10162, 10163, 10140
24988, 7131, 7154, 7155, 7132, 10140, 10163, 10164, 10141
24989, 7132, 7155, 7156, 7133, 10141, 10164, 10165, 10142
24990, 7133, 7156, 7157, 7134, 10142, 10165, 10166, 10143
24991, 7134, 7157, 7158, 7135, 10143, 10166, 10167, 10144
24992, 7135, 7158, 7159, 7136, 10144, 10167, 10168, 10145
24993, 7136, 7159, 7160, 7137, 10145, 10168, 10169, 10146
24994, 7137, 7160, 7161, 7138, 10146, 10169, 10170, 10147
24995, 7138, 7161, 7162, 7139, 10147, 10170, 10171, 10148
24996, 7139, 7162, 7163, 7140, 10148, 10171, 10172, 10149
24997, 7140, 7163, 7164, 7141, 10149, 10172, 10173, 10150
24998, 7141, 7164, 7165, 7142, 10150, 10173, 10174, 10151
24999, 7142, 7165, 7166, 7143, 10151, 10174, 10175, 10152
25000, 7143, 7166, 7167, 7144, 10152, 10175, 10176, 10153
25001, 7144, 7167, 7168, 7145, 10153, 10176, 10177, 10154
25002, 7145, 7168, 7169, 7146, 10154, 10177, 10178, 10155
25003, 7146, 7169, 7170, 7147, 10155, 10178, 10179, 10156
25004, 7147, 7170, 7171, 7148, 10156, 10179, 10180, 10157
25005, 7148, 7171, 970, 969, 10157, 10180, 1508, 1507
25006, 810, 811, 7172, 7149, 1485, 1486, 10181, 10158
25007, 7149, 7172, 7173, 7150, 10158, 10181, 10182, 10159
25008, 7150, 7173, 7174, 7151, 10159, 10182, 10183, 10160
25009, 7151, 7174, 7175, 7152, 10160, 10183, 10184, 10161
25010, 7152, 7175, 7176, 7153, 10161, 10184, 10185, 10162
25011, 7153, 7176, 7177, 7154, 10162, 10185, 10186, 10163
25012, 7154, 7177, 7178, 7155, 10163, 10186, 10187, 10164
25013, 7155, 7178, 7179, 7156, 10164, 10187, 10188, 10165
25014, 7156, 7179, 7180, 7157, 10165, 10188, 10189, 10166
25015, 7157, 7180, 7181, 7158, 10166, 10189, 10190, 10167
25016, 7158, 7181, 7182, 7159, 10167, 10190, 10191, 10168
25017, 7159, 7182, 7183, 7160, 10168, 10191, 10192, 10169
25018, 7160, 7183, 7184, 7161, 10169, 10192, 10193, 10170
25019, 7161, 7184, 7185, 7162, 10170, 10193, 10194, 10171
25020, 7162, 7185, 7186, 7163, 10171, 10194, 10195, 10172
25021, 7163, 7186, 7187, 7164, 10172, 10195, 10196, 10173
25022, 7164, 7187, 7188, 7165, 10173, 10196, 10197, 10174
25023, 7165, 7188, 7189, 7166, 10174, 10197, 10198, 10175
25024, 7166, 7189, 7190, 7167, 10175, 10198, 10199, 10176
25025, 7167, 7190, 7191, 7168, 10176, 10199, 10200, 10177
25026, 7168, 7191, 7192, 7169, 10177, 10200, 10201, 10178
25027, 7169, 7192, 7193, 7170, 10178, 10201, 10202, 10179
25028, 7170, 7193, 7194, 7171, 10179, 10202, 10203, 10180
25029, 7171, 7194, 971, 970, 10180, 10203, 1509, 1508
25030, 811, 812, 7195, 7172, 1486, 1487, 10204, 10181
25031, 7172, 7195, 7196, 7173, 10181, 10204, 10205, 10182
25032, 7173, 7196, 7197, 7174, 10182, 10205, 10206, 10183
25033, 7174, 7197, 7198, 7175, 10183, 10206, 10207, 10184
25034, 7175, 7198, 7199, 7176, 10184, 10207, 10208, 10185
25035, 7176, 7199, 7200, 7177, 10185, 10208, 10209, 10186
25036, 7177, 7200, 7201, 7178, 10186, 10209, 10210, 10187
25037, 7178, 7201, 7202, 7179, 10187, 10210, 10211, 10188
25038, 7179, 7202, 7203, 7180, 10188, 10211, 10212, 10189
25039, 7180, 7203, 7204, 7181, 10189, 10212, 10213, 10190
25040, 7181, 7204, 7205, 7182, 10190, 10213, 10214, 10191
25041, 7182, 7205, 7206, 7183, 10191, 10214, 10215, 10192
25042, 7183, 7206, 7207, 7184, 10192, 10215, 10216, 10193
25043, 7184, 7207, 7208, 7185, 10193, 10216, 10217, 10194
25044, 7185, 7208, 7209, 7186, 10194, 10217, 10218, 10195
25045, 7186, 7209, 7210, 7187, 10195, 10218, 10219, 10196
25046, 7187, 7210, 7211, 7188, 10196, 10219, 10220, 10197
25047, 7188, 7211, 7212, 7189, 10197, 10220, 10221, 10198
25048, 7189, 7212, 7213, 7190, 10198, 10221, 10222, 10199
25049, 7190, 7213, 7214, 7191, 10199, 10222, 10223, 10200
25050, 7191, 7214, 7215, 7192, 10200, 10223, 10224, 10201
25051, 7192, 7215, 7216, 7193, 10201, 10224, 10225, 10202
25052, 7193, 7216, 7217, 7194, 10202, 10225, 10226, 10203
25053, 7194, 7217, 972, 971, 10203, 10226, 1510, 1509
25054, 812, 813, 7218, 7195, 1487, 1488, 10227, 10204
25055, 7195, 7218, 7219, 7196, 10204, 10227, 10228, 10205
25056, 7196, 7219, 7220, 7197, 10205, 10228, 10229, 10206
25057, 7197, 7220, 7221, 7198, 10206, 10229, 10230, 10207
25058, 7198, 7221, 7222, 7199, 10207, 10230, 10231, 10208
25059, 7199, 7222, 7223, 7200, 10208, 10231, 10232, 10209
25060, 7200, 7223, 7224, 7201, 10209, 10232, 10233, 10210
25061, 7201, 7224, 7225, 7202, 10210, 10233, 10234, 10211
25062, 7202, 7225, 7226, 7203, 10211, 10234, 10235, 10212
25063, 7203, 7226, 7227, 7204, 10212, 10235, 10236, 10213
25064, 7204, 7227, 7228, 7205, 10213, 10236, 10237, 10214
25065, 7205, 7228, 7229, 7206, 10214, 10237, 10238, 10215
25066, 7206, 7229, 7230, 7207, 10215, 10238, 10239, 10216
25067, 7207, 7230, 7231, 7208, 10216, 10239, 10240, 10217
25068, 7208, 7231, 7232, 7209, 10217, 10240, 10241, 10218
25069, 7209, 7232, 7233, 7210, 10218, 10241, 10242, 10219
25070, 7210, 7233, 7234, 7211, 10219, 10242, 10243, 10220
25071, 7211, 7234, 7235, 7212, 10220, 10243, 10244, 10221
25072, 7212, 7235, 7236, 7213, 10221, 10244, 10245, 10222
25073, 7213, 7236, 7237, 7214, 10222, 10245, 10246, 10223
25074, 7214, 7237, 7238, 7215, 10223, 10246, 10247, 10224
25075, 7215, 7238, 7239, 7216, 10224, 10247, 10248, 10225
25076, 7216, 7239, 7240, 7217, 10225, 10248, 10249, 10226
25077, 7217, 7240, 973, 972, 10226, 10249, 1511, 1510
25078, 813, 814, 7241, 7218, 1488, 1489, 10250, 10227
25079, 7218, 7241, 7242, 7219, 10227, 10250, 10251, 10228
25080, 7219, 7242, 7243, 7220, 10228, 10251, 10252, 10229
25081, 7220, 7243, 7244, 7221, 10229, 10252, 10253, 10230
25082, 7221, 7244, 7245, 7222, 10230, 10253, 10254, 10231
25083, 7222, 7245, 7246, 7223, 10231, 10254, 10255, 10232
25084, 7223, 7246, 7247, 7224, 10232, 10255, 10256, 10233
25085, 7224, 7247, 7248, 7225, 10233, 10256, 10257, 10234
25086, 7225, 7248, 7249, 7226, 10234, 10257, 10258, 10235
25087, 7226, 7249, 7250, 7227, 10235, 10258, 10259, 10236
25088, 7227, 7250, 7251, 7228, 10236, 10259, 10260, 10237
25089, 7228, 7251, 7252, 7229, 10237, 10260, 10261, 10238
25090, 7229, 7252, 7253, 7230, 10238, 10261, 10262, 10239
25091, 7230, 7253, 7254, 7231, 10239, 10262, 10263, 10240
25092, 7231, 7254, 7255, 7232, 10240, 10263, 10264, 10241
25093, 7232, 7255, 7256, 7233, 10241, 10264, 10265, 10242
25094, 7233, 7256, 7257, 7234, 10242, 10265, 10266, 10243
25095, 7234, 7257, 7258, 7235, 10243, 10266, 10267, 10244
25096, 7235, 7258, 7259, 7236, 10244, 10267, 10268, 10245
25097, 7236, 7259, 7260, 7237, 10245, 10268, 10269, 10246
25098, 7237, 7260, 7261, 7238, 10246, 10269, 10270, 10247
25099, 7238, 7261, 7262, 7239, 10247, 10270, 10271, 10248
25100, 7239, 7262, 7263, 7240, 10248, 10271, 10272, 10249
25101, 7240, 7263, 974, 973, 10249, 10272, 1512, 1511
25102, 814, 815, 7264, 7241, 1489, 1490, 10273, 10250
25103, 7241, 7264, 7265, 7242, 10250, 10273, 10274, 10251
25104, 7242, 7265, 7266, 7243, 10251, 10274, 10275, 10252
25105, 7243, 7266, 7267, 7244, 10252, 10275, 10276, 10253
25106, 7244, 7267, 7268, 7245, 10253, 10276, 10277, 10254
25107, 7245, 7268, 7269, 7246, 10254, 10277, 10278, 10255
25108, 7246, 7269, 7270, 7247, 10255, 10278, 10279, 10256
25109, 7247, 7270, 7271, 7248, 10256, 10279, 10280, 10257
25110, 7248, 7271, 7272, 7249, 10257, 10280, 10281, 10258
25111, 7249, 7272, 7273, 7250, 10258, 10281, 10282, 10259
25112, 7250, 7273, 7274, 7251, 10259, 10282, 10283, 10260
25113, 7251, 7274, 7275, 7252, 10260, 10283, 10284, 10261
25114, 7252, 7275, 7276, 7253, 10261, 10284, 10285, 10262
25115, 7253, 7276, 7277, 7254, 10262, 10285, 10286, 10263
25116, 7254, 7277, 7278, 7255, 10263, 10286, 10287, 10264
25117, 7255, 7278, 7279, 7256, 10264, 10287, 10288, 10265
25118, 7256, 7279, 7280, 7257, 10265, 10288, 10289, 10266
25119, 7257, 7280, 7281, 7258, 10266, 10289, 10290, 10267
25120, 7258, 7281, 7282, 7259, 10267, 10290, 10291, 10268
25121, 7259, 7282, 7283, 7260, 10268, 10291, 10292, 10269
25122, 7260, 7283, 7284, 7261, 10269, 10292, 10293, 10270
25123, 7261, 7284, 7285, 7262, 10270, 10293, 10294, 10271
25124, 7262, 7285, 7286, 7263, 10271, 10294, 10295, 10272
25125, 7263, 7286, 975, 974, 10272, 10295, 1513, 1512
25126, 815, 816, 7287, 7264, 1490, 1491, 10296, 10273
25127, 7264, 7287, 7288, 7265, 10273, 10296, 10297, 10274
25128, 7265, 7288, 7289, 7266, 10274, 10297, 10298, 10275
25129, 7266, 7289, 7290, 7267, 10275, 10298, 10299, 10276
25130, 7267, 7290, 7291, 7268, 10276, 10299, 10300, 10277
25131, 7268, 7291, 7292, 7269, 10277, 10300, 10301, 10278
25132, 7269, 7292, 7293, 7270, 10278, 10301, 10302, 10279
25133, 7270, 7293, 7294, 7271, 10279, 10302, 10303, 10280
25134, 7271, 7294, 7295, 7272, 10280, 10303, 10304, 10281
25135, 7272, 7295, 7296, 7273, 10281, 10304, 10305, 10282
25136, 7273, 7296, 7297, 7274, 10282, 10305, 10306, 10283
25137, 7274, 7297, 7298, 7275, 10283, 10306, 10307, 10284
25138, 7275, 7298, 7299, 7276, 10284, 10307, 10308, 10285
25139, 7276, 7299, 7300, 7277, 10285, 10308, 10309, 10286
25140, 7277, 7300, 7301, 7278, 10286, 10309, 10310, 10287
25141, 7278, 7301, 7302, 7279, 10287, 10310, 10311, 10288
25142, 7279, 7302, 7303, 7280, 10288, 10311, 10312, 10289
25143, 7280, 7303, 7304, 7281, 10289, 10312, 10313, 10290
25144, 7281, 7304, 7305, 7282, 10290, 10313, 10314, 10291
25145, 7282, 7305, 7306, 7283, 10291, 10314, 10315, 10292
25146, 7283, 7306, 7307, 7284, 10292, 10315, 10316, 10293
25147, 7284, 7307, 7308, 7285, 10293, 10316, 10317, 10294
25148, 7285, 7308, 7309, 7286, 10294, 10317, 10318, 10295
25149, 7286, 7309, 976, 975, 10295, 10318, 1514, 1513
25150, 816, 817, 7310, 7287, 1491, 1492, 10319, 10296
25151, 7287, 7310, 7311, 7288, 10296, 10319, 10320, 10297
25152, 7288, 7311, 7312, 7289, 10297, 10320, 10321, 10298
25153, 7289, 7312, 7313, 7290, 10298, 10321, 10322, 10299
25154, 7290, 7313, 7314, 7291, 10299, 10322, 10323, 10300
25155, 7291, 7314, 7315, 7292, 10300, 10323, 10324, 10301
25156, 7292, 7315, 7316, 7293, 10301, 10324, 10325, 10302
25157, 7293, 7316, 7317, 7294, 10302, 10325, 10326, 10303
25158, 7294, 7317, 7318, 7295, 10303, 10326, 10327, 10304
25159, 7295, 7318, 7319, 7296, 10304, 10327, 10328, 10305
25160, 7296, 7319, 7320, 7297, 10305, 10328, 10329, 10306
25161, 7297, 7320, 7321, 7298, 10306, 10329, 10330, 10307
25162, 7298, 7321, 7322, 7299, 10307, 10330, 10331, 10308
25163, 7299, 7322, 7323, 7300, 10308, 10331, 10332, 10309
25164, 7300, 7323, 7324, 7301, 10309, 10332, 10333, 10310
25165, 7301, 7324, 7325, 7302, 10310, 10333, 10334, 10311
25166, 7302, 7325, 7326, 7303, 10311, 10334, 10335, 10312
25167, 7303, 7326, 7327, 7304, 10312, 10335, 10336, 10313
25168, 7304, 7327, 7328, 7305, 10313, 10336, 10337, 10314
25169, 7305, 7328, 7329, 7306, 10314, 10337, 10338, 10315
25170, 7306, 7329, 7330, 7307, 10315, 10338, 10339, 10316
25171, 7307, 7330, 7331, 7308, 10316, 10339, 10340, 10317
25172, 7308, 7331, 7332, 7309, 10317, 10340, 10341, 10318
25173, 7309, 7332, 977, 976, 10318, 10341, 1515, 1514
25174, 817, 818, 7333, 7310, 1492, 1493, 10342, 10319
25175, 7310, 7333, 7334, 7311, 10319, 10342, 10343, 10320
25176, 7311, 7334, 7335, 7312, 10320, 10343, 10344, 10321
25177, 7312, 7335, 7336, 7313, 10321, 10344, 10345, 10322
25178, 7313, 7336, 7337, 7314, 10322, 10345, 10346, 10323
25179, 7314, 7337, 7338, 7315, 10323, 10346, 10347, 10324
25180, 7315, 7338, 7339, 7316, 10324, 10347, 10348, 10325
25181, 7316, 7339, 7340, 7317, 10325, 10348, 10349, 10326
25182, 7317, 7340, 7341, 7318, 10326, 10349, 10350, 10327
25183, 7318, 7341, 7342, 7319, 10327, 10350, 10351, 10328
25184, 7319, 7342, 7343, 7320, 10328, 10351, 10352, 10329
25185, 7320, 7343, 7344, 7321, 10329, 10352, 10353, 10330
25186, 7321, 7344, 7345, 7322, 10330, 10353, 10354, 10331
25187, 7322, 7345, 7346, 7323, 10331, 10354, 10355, 10332
25188, 7323, 7346, 7347, 7324, 10332, 10355, 10356, 10333
25189, 7324, 7347, 7348, 7325, 10333, 10356, 10357, 10334
25190, 7325, 7348, 7349, 7326, 10334, 10357, 10358, 10335
25191, 7326, 7349, 7350, 7327, 10335, 10358, 10359, 10336
25192, 7327, 7350, 7351, 7328, 10336, 10359, 10360, 10337
25193, 7328, 7351, 7352, 7329, 10337, 10360, 10361, 10338
25194, 7329, 7352, 7353, 7330, 10338, 10361, 10362, 10339
25195, 7330, 7353, 7354, 7331, 10339, 10362, 10363, 10340
25196, 7331, 7354, 7355, 7332, 10340, 10363, 10364, 10341
25197, 7332, 7355, 978, 977, 10341, 10364, 1516, 1515
25198, 818, 36, 933, 7333, 1493, 71, 1448, 10342
25199, 7333, 933, 934, 7334, 10342, 1448, 1449, 10343
25200, 7334, 934, 935, 7335, 10343, 1449, 1450, 10344
