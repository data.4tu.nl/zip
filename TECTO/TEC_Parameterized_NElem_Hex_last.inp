30586, 30587, 30588, 30589, 30590, 30591, 30592, 30593, 30594, 30595, 
30596, 30597, 30598, 30599, 30600, 30601, 30602, 30603, 30604, 30605, 
30606, 30607, 30608, 30609, 30610, 30611, 30612, 30613, 30614, 30615, 
30616, 30617, 30618, 30619, 30620, 30621, 30622, 30623, 30624, 30625, 
30626, 30627, 30628, 30629, 30630, 30631, 30632, 30633, 30634, 30635, 
30636, 30637, 30638, 30639, 30640, 30641, 30642, 30643, 30644, 30645, 
30646, 30647, 30648, 30649, 30650, 30651, 30652, 30653, 30654, 30655, 
30656, 30657, 30658, 30659, 30660, 30661, 30662, 30663, 30664, 30665, 
30666, 30667, 30668, 30669, 30670, 30671, 30672, 30673, 30674, 30675, 
30676, 30677, 30678, 30679, 30680, 30681, 30682, 30683, 30684, 30685, 
30686, 30687, 30688, 30689, 30690, 30691, 30692, 30693, 30694, 30695, 
30696, 30697, 30698, 30699, 30700, 30701, 30702, 30703, 30704, 30705, 
30706, 30707, 30708, 30709, 30710, 30711, 30712, 30713, 30714, 30715, 
30716, 30717, 30718, 30719, 30720, 30721, 30722, 30723, 30724, 30725, 
30726, 30727, 30728, 30729, 30730, 30731, 30732, 30733, 30734, 30735, 
30736, 30737, 30738, 30739, 30740, 30741, 30742, 30743, 30744, 30745, 
30746, 30747, 30748, 30749, 30750, 30751, 30752, 30753, 30754, 30755, 
30756, 30757, 30758, 30759, 30760, 30761, 30762, 30763, 30764, 30765, 
30766, 30767, 30768, 30769, 30770, 30771, 30772, 30773, 30774, 30775, 
30776, 30777, 30778, 30779, 30780, 30781, 30782, 30783, 30784, 30785, 
30786, 30787, 30788, 30789, 30790, 30791, 30792, 30793, 30794, 30795, 
30796, 30797, 30798, 30799, 30800, 30801, 30802, 30803, 30804, 30805, 
30806, 30807, 30808, 30809, 30810, 30811, 30812, 30813, 30814, 30815, 
30816, 30817, 30818, 30819, 30820, 30821, 30822, 30823, 30824, 30825, 
30826, 30827, 30828, 30829, 30830, 30831, 30832, 30833, 30834, 30835, 
30836, 30837, 30838, 30839, 30840, 30841, 30842, 30843, 30844, 30845, 
30846, 30847, 30848, 30849, 30850, 30851, 30852, 30853, 30854, 30855, 
30856, 30857, 30858, 30859, 30860, 30861, 30862, 30863, 30864, 30865, 
30866, 30867, 30868, 30869, 30870, 30871, 30872, 30873, 30874, 30875, 
30876, 30877, 30878, 30879, 30880, 30881, 30882, 30883, 30884, 30885, 
30886, 30887, 30888, 30889, 30890, 30891, 30892, 30893, 30894, 30895, 
30896, 30897, 30898, 30899, 30900, 30901, 30902, 30903, 30904, 30905, 
30906, 30907, 30908, 30909, 30910, 30911, 30912, 30913, 30914, 30915, 
30916, 30917, 30918, 30919, 30920, 30921, 30922, 30923, 30924, 30925, 
30926, 30927, 30928, 30929, 30930, 30931, 30932, 30933, 30934, 30935, 
30936, 30937, 30938, 30939, 30940, 30941, 30942, 30943, 30944, 30945, 
30946, 30947, 30948, 30949, 30950, 30951, 30952, 30953, 30954, 30955, 
30956, 30957, 30958, 30959, 30960, 30961, 30962, 30963, 30964, 30965, 
30966, 30967, 30968, 30969, 30970, 30971, 30972, 30973, 30974, 30975, 
30976, 30977, 30978, 30979, 30980, 30981, 30982, 30983, 30984, 30985, 
30986, 30987, 30988, 30989, 30990, 30991, 30992, 30993, 30994, 30995, 
30996, 30997, 30998, 30999, 31000, 31001, 31002, 31003, 31004, 31005, 
31006, 31007, 31008, 31009, 31010, 31011, 31012, 31013, 31014, 31015, 
31016, 31017, 31018, 31019, 31020, 31021, 31022, 31023, 31024, 31025, 
31026, 31027, 31028, 31029, 31030, 31031, 31032, 31033, 31034, 31035, 
31036, 31037, 31038, 31039, 31040, 31041, 31042, 31043, 31044, 31045, 
31046, 31047, 31048, 31049, 31050, 31051, 31052, 31053, 31054, 31055, 
31056, 31057, 31058, 31059, 31060, 31061, 31062, 31063, 31064, 31065, 
31066, 31067, 31068, 31069, 31070, 31071, 31072, 31073, 31074, 31075, 
31076, 31077, 31078, 31079, 31080, 31081, 31082, 31083, 31084, 31085, 
31086, 31087, 31088, 31089, 31090, 31091, 31092, 31093, 31094, 31095, 
31096, 31097, 31098, 31099, 31100, 31101, 31102, 31103, 31104, 31105, 
31106, 31107, 31108, 31109, 31110, 31111, 31112, 31113, 31114, 31115, 
31116, 31117, 31118, 31119, 31120, 31121, 31122, 31123, 31124, 31125, 
31126, 31127, 31128, 31129, 31130, 31131, 31132, 31133, 31134, 31135, 
31136, 31137, 31138, 31139, 31140, 31141, 31142, 31143, 31144, 31145, 
31146, 31147, 31148, 31149, 31150, 31151, 31152, 31153, 31154, 31155, 
31156, 31157, 31158, 31159, 31160, 31161, 31162, 31163, 31164, 31165, 
31166, 31167, 31168, 31169, 31170, 31171, 31172, 31173, 31174, 31175, 
31176, 31177, 31178, 31179, 31180, 31181, 31182, 31183, 31184, 31185, 
31186, 31187, 31188, 31189, 31190, 31191, 31192, 31193, 31194, 31195, 
31196, 31197, 31198, 31199, 31200, 31201, 31202, 31203, 31204, 31205, 
31206, 31207, 31208, 31209, 31210, 31211, 31212, 31213, 31214, 31215, 
31216, 31217, 31218, 31219, 31220, 31221, 31222, 31223, 31224, 31225, 
31226, 31227, 31228, 31229, 31230, 31231, 31232, 31233, 31234, 31235, 
31236, 31237, 31238, 31239, 31240, 31241, 31242, 31243, 31244, 31245, 
31246, 31247, 31248, 31249, 31250, 31251, 31252, 31253, 31254, 31255, 
31256, 31257, 31258, 31259, 31260, 31261, 31262, 31263, 31264, 31265, 
31266, 31267, 31268, 31269, 31270, 31271, 31272, 31273, 31274, 31275, 
31276, 31277, 31278, 31279, 31280, 31281, 31282, 31283, 31284, 31285, 
31286, 31287, 31288, 31289, 31290, 31291, 31292, 31293, 31294, 31295, 
31296, 31297, 31298, 31299, 31300, 31301, 31302, 31303, 31304, 31305, 
31306, 31307, 31308, 31309, 31310, 31311, 31312, 31313, 31314, 31315, 
31316, 31317, 31318, 31319, 31320, 31321, 31322, 31323, 31324, 31325, 
31326, 31327, 31328, 31329, 31330, 31331, 31332, 31333, 31334, 31335, 
31336, 31337, 31338, 31339, 31340, 31341, 31342, 31343, 31344, 31345, 
31346, 31347, 31348, 31349, 31350, 31351, 31352, 31353, 31354, 31355, 
31356, 31357, 31358, 31359, 31360, 31361, 31362, 31363, 31364, 31365, 
31366, 31367, 31368, 31369, 31370, 31371, 31372, 31373, 31374, 31375, 
31376, 31377, 31378, 31379, 31380, 31381, 31382, 31383, 31384, 31385, 
31386, 31387, 31388, 31389, 31390, 31391, 31392, 31393, 31394, 31395, 
31396, 31397, 31398, 31399, 31400, 31401, 31402, 31403, 31404, 31405, 
31406, 31407, 31408, 31409, 31410, 31411, 31412, 31413, 31414, 31415, 
31416, 31417, 31418, 31419, 31420, 31421, 31422, 31423, 31424, 31425, 
31426, 31427, 31428, 31429, 31430, 31431, 31432, 31433, 31434, 31435, 
31436, 31437, 31438, 31439, 31440, 31441, 31442, 31443, 31444, 31445, 
31446, 31447, 31448, 31449, 31450, 31451, 31452, 31453, 31454, 31455, 
31456, 31457, 31458, 31459, 31460, 31461, 31462, 31463, 31464, 31465, 
31466, 31467, 31468, 31469, 31470, 31471, 31472, 31473, 31474, 31475, 
31476, 31477, 31478, 31479, 31480, 31481, 31482, 31483, 31484, 31485, 
31486, 31487, 31488, 31489, 31490, 31491, 31492, 31493, 31494, 31495, 
31496, 31497, 31498, 31499, 31500, 31501, 31502, 31503, 31504, 31505, 
31506, 31507, 31508, 31509, 31510, 31511, 31512, 31513, 31514, 31515, 
31516, 31517, 31518, 31519, 31520, 31521, 31522, 31523, 31524, 31525, 
31526, 31527, 31528, 31529, 31530, 31531, 31532, 31533, 31534, 31535, 
31536, 31537, 31538, 31539, 31540, 31541, 31542, 31543, 31544, 31545, 
31546, 31547, 31548, 31549, 31550, 31551, 31552, 31553, 31554, 31555, 
31556, 31557, 31558, 31559, 31560, 31561, 31562, 31563, 31564, 31565, 
31566, 31567, 31568, 31569, 31570, 31571, 31572, 31573, 31574, 31575, 
31576, 31577, 31578, 31579, 31580, 31581, 31582, 31583, 31584, 31585, 
31586, 31587, 31588, 31589, 31590, 31591, 31592, 31593, 31594, 31595, 
31596, 31597, 31598, 31599, 31600, 31601, 31602, 31603, 31604, 31605, 
31606, 31607, 31608, 31609, 31610, 31611, 31612, 31613, 31614, 31615, 
31616, 31617, 31618, 31619, 31620, 31621, 31622, 31623, 31624, 31625, 
31626, 31627, 31628, 31629, 31630, 31631, 31632, 31633, 31634, 31635, 
31636, 31637, 31638, 31639, 31640, 31641, 31642, 31643, 31644, 31645, 
31646, 31647, 31648, 31649, 31650, 31651, 31652, 31653, 31654, 31655, 
31656, 31657, 31658, 31659, 31660, 31661, 31662, 31663, 31664, 31665, 
31666, 31667, 31668, 31669, 31670, 31671, 31672, 31673, 31674, 31675, 
31676, 31677, 31678, 31679, 31680, 31681, 31682, 31683, 31684, 31685, 
31686, 31687, 31688, 31689, 31690, 31691, 31692, 31693, 31694, 31695, 
31696, 31697, 31698, 31699, 31700, 31701, 31702, 31703, 31704, 31705, 
31706, 31707, 31708, 31709, 31710, 31711, 31712, 31713, 31714, 31715, 
31716, 31717, 31718, 31719, 31720, 31721, 31722, 31723, 31724, 31725, 
31726, 31727, 31728, 31729, 31730, 31731, 31732, 31733, 31734, 31735, 
31736, 31737, 31738, 31739, 31740, 31741, 31742, 31743, 31744, 31745, 
31746, 31747, 31748, 31749, 31750, 31751, 31752, 31753, 31754, 31755, 
31756, 31757, 31758, 31759, 31760, 31761, 31762, 31763, 31764, 31765, 
31766, 31767, 31768, 31769, 31770, 31771, 31772, 31773, 31774, 31775, 
31776, 31777, 31778, 31779, 31780, 31781, 31782, 31783, 31784, 31785, 
31786, 31787, 31788, 31789, 31790, 31791, 31792, 31793, 31794, 31795, 
31796, 31797, 31798, 31799, 31800, 31801, 31802, 31803, 31804, 31805, 
31806, 31807, 31808, 31809, 31810, 31811, 31812, 31813, 31814, 31815, 
31816, 31817, 31818, 31819, 31820, 31821, 31822, 31823, 31824, 31825, 
31826, 31827, 31828, 31829, 31830, 31831, 31832, 31833, 31834, 31835, 
31836, 31837, 31838, 31839, 31840, 31841, 31842, 31843, 31844, 31845, 
31846, 31847, 31848, 31849, 31850, 31851, 31852, 31853, 31854, 31855, 
31856, 31857, 31858, 31859, 31860, 31861, 31862, 31863, 31864, 31865, 
31866, 31867, 31868, 31869, 31870, 31871, 31872, 31873, 31874, 31875, 
31876, 31877, 31878, 31879, 31880, 31881, 31882, 31883, 31884, 31885, 
31886, 31887, 31888, 31889, 31890, 31891, 31892, 31893, 31894, 31895, 
31896, 31897, 31898, 31899, 31900, 31901, 31902, 31903, 31904, 31905, 
31906, 31907, 31908, 31909, 31910, 31911, 31912, 31913, 31914, 31915, 
31916, 31917, 31918, 31919, 31920, 31921, 31922, 31923, 31924, 31925, 
31926, 31927, 31928, 31929, 31930, 31931, 31932, 31933, 31934, 31935, 
31936, 31937, 31938, 31939, 31940, 31941, 31942, 31943, 31944, 31945, 
31946, 31947, 31948, 31949, 31950, 31951, 31952, 31953, 31954, 31955, 
31956, 31957, 31958, 31959, 31960, 31961, 31962, 31963, 31964, 31965, 
31966, 31967, 31968, 31969, 31970, 31971, 31972, 31973, 31974, 31975, 
31976, 31977, 31978, 31979, 31980, 31981, 31982, 31983, 31984, 31985, 
31986, 31987, 31988, 31989, 31990, 31991, 31992, 31993, 31994, 31995, 
31996, 31997, 31998, 31999, 32000, 32001, 32002, 32003, 32004, 32005, 
32006, 32007, 32008, 32009, 32010, 32011, 32012, 32013, 32014, 32015, 
32016, 32017, 32018, 32019, 32020, 32021, 32022, 32023, 32024, 32025, 
*NSET,NSET=VoltageL_2D
53, 55, 1182, 1183, 
*NSET,NSET=VoltageR_2D
49, 50, 1145, 1146, 
*NSET,NSET=TopCeramic_2D
79, 80, 81, 83, 1613, 1614, 1615, 1616, 1617, 1618, 
1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 
1629, 1630, 1631, 1632, 1633, 1634, 1635, 1651, 1652, 1653, 
1654, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 
1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 
1697, 1698, 1699, 1700, 
*NSET,NSET=BottomCeramic_2D
87, 88, 89, 91, 92, 95, 1789, 1790, 1791, 1792, 
1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 
1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1850, 
1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 
1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 1869, 1870, 
1871, 1872, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 617, 618, 619, 620, 
627, 628, 629, 630, 644, 645, 646, 647, 648, 649, 
650, 651, 652, 653, 654, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 
5054, 5055, 5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 
5064, 5065, 5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 
5074, 5075, 5076, 5077, 5078, 5079, 5080, 5081, 5082, 5083, 
5084, 5085, 5086, 5087, 5088, 5089, 5090, 5091, 5092, 5093, 
5094, 5095, 5096, 5097, 5098, 5099, 5100, 5101, 5102, 5103, 
5104, 5105, 5106, 5107, 5108, 5109, 5110, 5111, 5112, 5113, 
5114, 5115, 5116, 5117, 5118, 5119, 5120, 5121, 5122, 5123, 
5124, 5125, 5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 
5134, 5135, 5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 
5144, 5145, 5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 
5154, 5155, 5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 
5164, 5165, 5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 
5174, 5175, 5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 
5184, 5185, 5186, 5187, 5188, 5189, 5190, 5191, 5192, 5193, 
5194, 5195, 5196, 5197, 5198, 5199, 5200, 5201, 5202, 5203, 
5204, 5205, 5206, 5207, 5208, 5209, 5210, 5211, 5212, 5213, 
5214, 5215, 5216, 5217, 5218, 5219, 5220, 5221, 5222, 5223, 
5224, 5225, 5226, 5227, 5228, 5229, 5230, 5231, 5232, 5233, 
5234, 5235, 5236, 5237, 5238, 5239, 5240, 5241, 5242, 5243, 
5244, 5245, 5246, 5247, 5248, 5249, 5250, 5251, 5252, 5253, 
5254, 5255, 5256, 5257, 5258, 5259, 5260, 5261, 5262, 5263, 
5264, 5265, 5266, 5267, 5268, 5269, 5270, 5271, 5272, 5273, 
5274, 5275, 5276, 5277, 5278, 5279, 5280, 5281, 5282, 5283, 
5284, 5285, 5286, 5287, 5288, 5289, 5290, 5291, 5292, 5293, 
5294, 5295, 5296, 5297, 5298, 5359, 5360, 5361, 5362, 5363, 
5364, 5365, 5366, 5367, 5368, 5369, 5370, 5371, 5372, 5373, 
5374, 5375, 5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 
5384, 5385, 5386, 5387, 5388, 5389, 5390, 5391, 5392, 5393, 
5394, 5395, 5396, 5397, 5398, 5399, 5400, 5401, 5402, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 97, 98, 
99, 100, 101, 102, 103, 104, 105, 106, 107, 123, 
124, 125, 126, 127, 128, 129, 130, 131, 132, 133, 
149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 
159, 160, 161, 162, 163, 164, 165, 166, 167, 168, 
169, 170, 171, 172, 173, 174, 175, 176, 177, 178, 
179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 
189, 190, 191, 192, 193, 194, 1073, 1074, 1075, 1076, 
1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 
1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 1100, 
1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 
1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 
1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 
1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 
1141, 1142, 1143, 1144, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 8504, 8505, 8506, 
8507, 8508, 8509, 8510, 8511, 8512, 8513, 8514, 8515, 8516, 
8517, 8518, 8519, 8520, 8521, 8522, 8523, 8524, 8525, 8526, 
8527, 8528, 8529, 8530, 8531, 8532, 8533, 8534, 8535, 8536, 
8537, 8538, 8539, 8540, 8541, 8542, 8543, 8544, 8545, 8546, 
8547, 8548, 8549, 8550, 8551, 8552, 8553, 8554, 8555, 8556, 
8557, 8558, 8559, 8560, 8561, 8562, 8563, 8564, 8565, 8566, 
8567, 8568, 8569, 8570, 8571, 8572, 8573, 8574, 8575, 8576, 
8577, 8578, 8579, 8580, 8581, 8582, 8583, 8584, 8585, 8586, 
8587, 8588, 8589, 8590, 8591, 8592, 8593, 8594, 8595, 8596, 
8597, 8598, 8599, 8600, 8601, 8602, 8603, 8604, 8605, 8606, 
8607, 8608, 8609, 8610, 8611, 8612, 8613, 8614, 8615, 8616, 
8617, 8618, 8619, 8620, 8621, 8622, 8623, 8624, 8625, 8626, 
8627, 8628, 8629, 8630, 8631, 8632, 8633, 8634, 8635, 8636, 
8637, 8638, 8639, 8640, 8641, 8642, 8643, 8644, 8645, 8646, 
8647, 8648, 8649, 8650, 8651, 8652, 8653, 8654, 8655, 8656, 
8657, 8658, 8659, 8660, 8661, 8662, 8663, 8664, 8665, 8666, 
8667, 8668, 8669, 8670, 8671, 8672, 8673, 8674, 8675, 8676, 
8677, 8678, 8679, 8680, 8681, 8682, 8683, 8684, 8685, 8686, 
8687, 8688, 8689, 8690, 8691, 8692, 8693, 8694, 8695, 8696, 
8697, 8698, 8699, 8700, 8701, 8702, 8703, 8704, 8705, 8706, 
8707, 8708, 8709, 8710, 8711, 8712, 8713, 8714, 8715, 8716, 
8717, 8718, 8719, 8720, 8721, 8722, 8723, 8724, 8725, 8726, 
8727, 8728, 8729, 8730, 8731, 8732, 8733, 8734, 8735, 8736, 
8737, 8738, 8739, 8740, 8741, 8742, 8743, 8744, 8745, 8746, 
8747, 8748, 8749, 8750, 8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 1145, 1146, 1147, 1148, 1149, 1150, 
1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 
1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 
8757, 8758, 8759, 8760, 8761, 8762, 8763, 8764, 8765, 8766, 
8767, 8768, 8769, 8770, 8771, 8772, 8773, 8774, 8775, 8776, 
8777, 8778, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 1171, 1172, 1173, 1174, 1175, 1176, 
1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 
1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 
8779, 8780, 8781, 8782, 8783, 8784, 8785, 8786, 8787, 8788, 
8789, 8790, 8791, 8792, 8793, 8794, 8795, 8796, 8797, 8798, 
8799, 8800, 
*NSET,NSET=Force
18, 20, 22, 24, 526, 527, 528, 529, 530, 531, 
532, 533, 534, 535, 536, 539, 540, 577, 578, 602, 
603, 604, 605, 606, 607, 608, 609, 610, 611, 612, 
5024, 5025, 5026, 5027, 5028, 5029, 5030, 5031, 5032, 5033, 
5034, 5035, 5036, 5037, 5038, 5039, 5040, 5041, 5042, 5043, 
5044, 5045, 
*NSET,NSET=Ceramic_Top
77, 78, 79, 80, 81, 82, 83, 84, 1571, 1572, 
1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 
1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 
1593, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1651, 1652, 1653, 1654, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1678, 1679, 1680, 1681, 1682, 
1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 
1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 10637, 10638, 10639, 10640, 10641, 10642, 10643, 10644, 
10645, 10646, 10647, 10648, 10649, 10650, 10651, 10652, 10653, 10654, 
10655, 10656, 10657, 10658, 10659, 10660, 10661, 10662, 10663, 10664, 
10665, 10666, 10667, 10668, 10669, 10670, 10671, 10672, 10673, 10674, 
10675, 10676, 10677, 10678, 10679, 10680, 10681, 10682, 10683, 10684, 
10685, 10686, 10687, 10688, 10689, 10690, 10691, 10692, 10693, 10694, 
10695, 10696, 10697, 10698, 10699, 10700, 10701, 10702, 10703, 10704, 
10705, 10706, 10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 
10715, 10716, 10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 
10725, 10726, 10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 
10735, 10736, 10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 
10745, 10746, 10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 
10755, 10756, 10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 
10765, 10766, 10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 
10775, 10776, 10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 
10785, 10786, 10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 
10795, 10796, 10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 
10805, 10806, 10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 
10815, 10816, 10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 
10825, 10826, 10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 
10835, 10836, 10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 
10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 
10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 
10865, 10866, 10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 
10875, 10876, 10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 
10885, 10886, 10887, 10888, 10889, 10966, 10967, 10968, 10969, 10970, 
10971, 10972, 10973, 10974, 10975, 10976, 10977, 10978, 10979, 10980, 
10981, 10982, 10983, 10984, 10985, 10986, 10987, 10988, 10989, 10990, 
10991, 10992, 10993, 10994, 10995, 10996, 10997, 10998, 10999, 11000, 
11001, 11002, 11003, 11004, 11005, 11006, 11007, 11008, 11009, 11238, 
11239, 11240, 11241, 11242, 11243, 11244, 11245, 11246, 11247, 11248, 
11249, 11250, 11251, 11252, 11253, 11254, 11255, 11256, 11257, 11258, 
11259, 11260, 11261, 11262, 11263, 11264, 11265, 11266, 11267, 11268, 
11269, 11270, 11271, 11272, 11273, 11274, 11275, 11276, 11277, 11278, 
11279, 11280, 11281, 11282, 11283, 11284, 11285, 11286, 11287, 11288, 
11289, 11290, 11291, 11292, 11293, 11294, 11295, 11296, 11297, 11298, 
11299, 11300, 11301, 11302, 11303, 11304, 11305, 11306, 11307, 11308, 
11309, 11310, 11311, 11312, 11313, 11314, 11315, 11316, 11317, 11318, 
11319, 11320, 11321, 11322, 11323, 11324, 11325, 11326, 11327, 11328, 
11329, 11330, 11331, 11332, 11333, 11334, 11335, 11336, 11337, 11338, 
11339, 11340, 11341, 11342, 11343, 11344, 11345, 11346, 11347, 11348, 
11349, 11350, 11351, 11352, 11353, 11354, 11355, 11356, 11357, 11358, 
11359, 11360, 11361, 11362, 11363, 11364, 11365, 11366, 11367, 11368, 
11369, 11370, 11371, 11372, 11373, 11374, 11375, 11376, 11377, 11378, 
11379, 11380, 11381, 11382, 11383, 11384, 11385, 11386, 11387, 11388, 
11389, 11390, 11391, 11392, 11393, 11394, 11395, 11396, 11397, 11398, 
11399, 11400, 11401, 11402, 11403, 11404, 11405, 11406, 11407, 11408, 
11409, 11410, 11411, 11412, 11413, 11414, 11415, 11416, 11417, 11418, 
11419, 11420, 11421, 11422, 11423, 11424, 11425, 11426, 11427, 11428, 
11429, 11430, 11431, 11432, 11433, 11434, 11435, 11436, 11437, 11438, 
11439, 11440, 11441, 11442, 11443, 11444, 11445, 11446, 11447, 11448, 
11449, 11450, 11451, 11452, 11453, 11454, 11455, 11456, 11457, 11458, 
11459, 11460, 11461, 11462, 11463, 11464, 11465, 11466, 11467, 11468, 
11469, 11470, 11471, 11472, 11473, 11474, 11475, 11476, 11477, 11478, 
11479, 11480, 11481, 11482, 11483, 11484, 11485, 11486, 11487, 11488, 
11489, 11490, 
*NSET,NSET=Ceramic_Bottom
23, 26, 79, 81, 85, 86, 87, 88, 91, 92, 
93, 94, 617, 618, 619, 620, 1594, 1595, 1596, 1597, 
1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 1747, 1748, 
1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 
1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 
1769, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 
1783, 1784, 1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 
1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 
1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 1815, 1816, 
1817, 1818, 1819, 1820, 1821, 1822, 1850, 1851, 1852, 1853, 
1854, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 
1864, 1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1881, 
1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 1891, 
1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 1901, 
1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 
1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 1921, 
1922, 1923, 1924, 1925, 10890, 10891, 10892, 10893, 10894, 10895, 
10896, 10897, 10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 
11763, 11764, 11765, 11766, 11767, 11768, 11769, 11770, 11771, 11772, 
11773, 11774, 11775, 11776, 11777, 11778, 11779, 11780, 11781, 11782, 
11783, 11784, 11785, 11786, 11787, 11788, 11789, 11790, 11791, 11792, 
11793, 11794, 11795, 11796, 11797, 11798, 11799, 11800, 11801, 11802, 
11803, 11804, 11805, 11806, 11807, 11808, 11809, 11810, 11811, 11812, 
11813, 11814, 11815, 11816, 11817, 11818, 11819, 11820, 11821, 11822, 
11823, 11824, 11825, 11826, 11827, 11828, 11829, 11830, 11831, 11832, 
11833, 11834, 11835, 11836, 11837, 11838, 11839, 11840, 11841, 11842, 
11843, 11844, 11845, 11846, 11847, 11848, 11849, 11850, 11851, 11852, 
11853, 11854, 11855, 11856, 11857, 11858, 11859, 11860, 11861, 11862, 
11863, 11864, 11865, 11866, 11867, 11868, 11869, 11870, 11871, 11872, 
11873, 11874, 11875, 11876, 11877, 11878, 11879, 11880, 11881, 11882, 
11883, 11884, 11885, 11886, 11887, 11888, 11889, 11890, 11891, 11892, 
11893, 11894, 11895, 11896, 11897, 11898, 11899, 11900, 11901, 11902, 
11903, 11904, 11905, 11906, 11907, 11908, 11909, 11910, 11911, 11912, 
11913, 11914, 11915, 11916, 11917, 11918, 11919, 11920, 11921, 11922, 
11923, 11924, 11925, 11926, 11927, 11928, 11929, 11930, 11931, 11932, 
11933, 11934, 11935, 11936, 11937, 11938, 11939, 11940, 11941, 11942, 
11943, 11944, 11945, 11946, 11947, 11948, 11949, 11950, 11951, 11952, 
11953, 11954, 11955, 11956, 11957, 11958, 11959, 11960, 11961, 11962, 
11963, 11964, 11965, 11966, 11967, 11968, 11969, 11970, 11971, 11972, 
11973, 11974, 11975, 11976, 11977, 11978, 11979, 11980, 11981, 11982, 
11983, 11984, 11985, 11986, 11987, 11988, 11989, 11990, 11991, 11992, 
11993, 11994, 11995, 11996, 11997, 11998, 11999, 12000, 12001, 12002, 
12003, 12004, 12005, 12006, 12007, 12008, 12009, 12010, 12011, 12012, 
12013, 12014, 12015, 12332, 12333, 12334, 12335, 12336, 12337, 12338, 
12339, 12340, 12341, 12342, 12343, 12344, 12345, 12346, 12347, 12348, 
12349, 12350, 12351, 12352, 12353, 12354, 12355, 12356, 12357, 12358, 
12359, 12360, 12361, 12362, 12363, 12364, 12365, 12366, 12367, 12368, 
12369, 12370, 12371, 12372, 12373, 12374, 12375, 12376, 12377, 12378, 
12379, 12380, 12381, 12382, 12383, 12384, 12385, 12386, 12387, 12388, 
12389, 12390, 12391, 12392, 12393, 12394, 12395, 12396, 12397, 12398, 
12399, 12400, 12401, 12402, 12403, 12404, 12405, 12406, 12407, 12408, 
12409, 12410, 12411, 12412, 12413, 12414, 12415, 12416, 12417, 12418, 
12419, 12420, 12421, 12422, 12423, 12424, 12425, 12426, 12427, 12428, 
12429, 12430, 12431, 12432, 12433, 12434, 12435, 12436, 12437, 12438, 
12439, 12440, 12441, 12442, 12443, 12444, 12445, 12446, 12447, 12448, 
12449, 12450, 12451, 12452, 12453, 12454, 12455, 12456, 12457, 12458, 
12459, 12460, 12461, 12462, 12463, 12464, 12465, 12466, 12467, 12468, 
12469, 12470, 12471, 12472, 12473, 12474, 12475, 12476, 12477, 12478, 
12479, 12480, 12481, 12482, 12483, 12484, 12485, 12486, 12487, 12488, 
12489, 12490, 12491, 12492, 12493, 12494, 12495, 12496, 12497, 12498, 
12499, 12500, 12501, 12502, 12503, 12504, 12505, 12506, 12507, 12508, 
12509, 12510, 12511, 12512, 12513, 12514, 12515, 12516, 12517, 12518, 
12519, 12520, 12521, 12522, 12523, 12524, 12525, 12526, 12527, 12528, 
12529, 12530, 12531, 12532, 12533, 12534, 12535, 12536, 12537, 12538, 
12539, 12540, 12541, 12542, 12543, 12544, 12545, 12546, 12547, 12548, 
12549, 12550, 12551, 12552, 12553, 12554, 12555, 12556, 12557, 12558, 
12559, 12560, 12561, 12562, 12563, 12564, 12565, 12566, 12567, 12568, 
12569, 12570, 12571, 12572, 12573, 12574, 12575, 12576, 12577, 12578, 
12579, 12580, 12581, 12582, 12583, 12584, 
*NSET,NSET=Top_Semiconductors
13, 14, 15, 16, 33, 34, 35, 36, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 401, 402, 403, 404, 405, 406, 407, 408, 409, 
410, 411, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 773, 774, 775, 776, 
777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 
787, 788, 789, 790, 791, 792, 793, 794, 795, 796, 
797, 798, 799, 800, 801, 802, 803, 804, 805, 806, 
807, 808, 809, 810, 811, 812, 813, 814, 815, 816, 
817, 818, 819, 820, 821, 822, 823, 824, 825, 826, 
827, 828, 829, 830, 831, 832, 833, 834, 835, 836, 
837, 838, 839, 840, 4404, 4405, 4406, 4407, 4408, 4409, 
4410, 4411, 4412, 4413, 4414, 4415, 4416, 4417, 4418, 4419, 
4420, 4421, 4422, 4423, 4424, 4425, 4426, 4427, 4428, 4429, 
4430, 4431, 4432, 4433, 4434, 4435, 4436, 4437, 4438, 4439, 
4440, 4441, 4442, 4443, 4444, 4445, 4446, 4447, 4448, 4449, 
4450, 4451, 4452, 4453, 4454, 4455, 4456, 4457, 4458, 4459, 
4460, 4461, 4462, 4463, 4464, 4465, 4466, 4467, 4468, 4469, 
4470, 4471, 4472, 4473, 4474, 4475, 4476, 4477, 4478, 4479, 
4480, 4481, 4482, 4483, 4484, 4485, 4486, 4487, 4488, 4489, 
4490, 4491, 4492, 4493, 4494, 4495, 4496, 4497, 4498, 4499, 
4500, 4501, 4502, 4503, 4504, 4505, 4506, 4507, 4508, 4509, 
4510, 4511, 4512, 4513, 4514, 4515, 4516, 4517, 4518, 4519, 
4520, 4521, 4522, 4523, 4524, 4525, 4526, 4527, 4528, 4529, 
4530, 4531, 4532, 4533, 4534, 4535, 4536, 4537, 4538, 4539, 
4540, 4541, 4542, 4543, 4544, 4545, 4546, 4547, 4548, 4549, 
4550, 4551, 4552, 4553, 4554, 4555, 4556, 4557, 4558, 4559, 
4560, 4561, 4562, 4563, 4564, 4565, 4566, 4567, 4568, 4569, 
4570, 4571, 4572, 4573, 4574, 4575, 4576, 4577, 4578, 4579, 
4580, 4581, 4582, 4583, 4584, 4585, 4586, 4587, 4588, 4589, 
4590, 4591, 4592, 4593, 4594, 4595, 4596, 4597, 4598, 4599, 
4600, 4601, 4602, 4603, 4604, 4605, 4606, 4607, 4608, 4609, 
4610, 4611, 4612, 4613, 4614, 4615, 4616, 4617, 4618, 4619, 
4620, 4621, 4622, 4623, 4624, 4625, 4626, 4627, 4628, 4629, 
4630, 4631, 4632, 4633, 4634, 4635, 4636, 4637, 4638, 4639, 
4640, 4641, 4642, 4643, 4644, 4645, 4646, 4647, 4648, 4649, 
4650, 4651, 4652, 4653, 4654, 4655, 4656, 6045, 6046, 6047, 
6048, 6049, 6050, 6051, 6052, 6053, 6054, 6055, 6056, 6057, 
6058, 6059, 6060, 6061, 6062, 6063, 6064, 6065, 6066, 6067, 
6068, 6069, 6070, 6071, 6072, 6073, 6074, 6075, 6076, 6077, 
6078, 6079, 6080, 6081, 6082, 6083, 6084, 6085, 6086, 6087, 
6088, 6089, 6090, 6091, 6092, 6093, 6094, 6095, 6096, 6097, 
6098, 6099, 6100, 6101, 6102, 6103, 6104, 6105, 6106, 6107, 
6108, 6109, 6110, 6111, 6112, 6113, 6114, 6115, 6116, 6117, 
6118, 6119, 6120, 6121, 6122, 6123, 6124, 6125, 6126, 6127, 
6128, 6129, 6130, 6131, 6132, 6133, 6134, 6135, 6136, 6137, 
6138, 6139, 6140, 6141, 6142, 6143, 6144, 6145, 6146, 6147, 
6148, 6149, 6150, 6151, 6152, 6153, 6154, 6155, 6156, 6157, 
6158, 6159, 6160, 6161, 6162, 6163, 6164, 6165, 6166, 6167, 
6168, 6169, 6170, 6171, 6172, 6173, 6174, 6175, 6176, 6177, 
6178, 6179, 6180, 6181, 6182, 6183, 6184, 6185, 6186, 6187, 
6188, 6189, 6190, 6191, 6192, 6193, 6194, 6195, 6196, 6197, 
6198, 6199, 6200, 6201, 6202, 6203, 6204, 6205, 6206, 6207, 
6208, 6209, 6210, 6211, 6212, 6213, 6214, 6215, 6216, 6217, 
6218, 6219, 6220, 6221, 6222, 6223, 6224, 6225, 6226, 6227, 
6228, 6229, 6230, 6231, 6232, 6233, 6234, 6235, 6236, 6237, 
6238, 6239, 6240, 6241, 6242, 6243, 6244, 6245, 6246, 6247, 
6248, 6249, 6250, 6251, 6252, 6253, 6254, 6255, 6256, 6257, 
6258, 6259, 6260, 6261, 6262, 6263, 6264, 6265, 6266, 6267, 
6268, 6269, 6270, 6271, 6272, 6273, 6274, 6275, 6276, 6277, 
6278, 6279, 6280, 6281, 6282, 6283, 6284, 6285, 6286, 6287, 
6288, 6289, 6290, 6291, 6292, 6293, 6294, 6295, 6296, 6297, 
*NSET,NSET=top
77, 78, 79, 80, 81, 82, 83, 84, 1571, 1572, 
1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 
1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 
1593, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1651, 1652, 1653, 1654, 
1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 
1669, 1670, 1671, 1672, 1673, 1678, 1679, 1680, 1681, 1682, 
1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 
1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 10637, 10638, 10639, 10640, 10641, 10642, 10643, 10644, 
10645, 10646, 10647, 10648, 10649, 10650, 10651, 10652, 10653, 10654, 
10655, 10656, 10657, 10658, 10659, 10660, 10661, 10662, 10663, 10664, 
10665, 10666, 10667, 10668, 10669, 10670, 10671, 10672, 10673, 10674, 
10675, 10676, 10677, 10678, 10679, 10680, 10681, 10682, 10683, 10684, 
10685, 10686, 10687, 10688, 10689, 10690, 10691, 10692, 10693, 10694, 
10695, 10696, 10697, 10698, 10699, 10700, 10701, 10702, 10703, 10704, 
10705, 10706, 10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 
10715, 10716, 10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 
10725, 10726, 10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 
10735, 10736, 10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 
10745, 10746, 10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 
10755, 10756, 10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 
10765, 10766, 10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 
10775, 10776, 10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 
10785, 10786, 10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 
10795, 10796, 10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 
10805, 10806, 10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 
10815, 10816, 10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 
10825, 10826, 10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 
10835, 10836, 10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 
10845, 10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 
10855, 10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 
10865, 10866, 10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 
10875, 10876, 10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 
10885, 10886, 10887, 10888, 10889, 10966, 10967, 10968, 10969, 10970, 
10971, 10972, 10973, 10974, 10975, 10976, 10977, 10978, 10979, 10980, 
10981, 10982, 10983, 10984, 10985, 10986, 10987, 10988, 10989, 10990, 
10991, 10992, 10993, 10994, 10995, 10996, 10997, 10998, 10999, 11000, 
11001, 11002, 11003, 11004, 11005, 11006, 11007, 11008, 11009, 11238, 
11239, 11240, 11241, 11242, 11243, 11244, 11245, 11246, 11247, 11248, 
11249, 11250, 11251, 11252, 11253, 11254, 11255, 11256, 11257, 11258, 
11259, 11260, 11261, 11262, 11263, 11264, 11265, 11266, 11267, 11268, 
11269, 11270, 11271, 11272, 11273, 11274, 11275, 11276, 11277, 11278, 
11279, 11280, 11281, 11282, 11283, 11284, 11285, 11286, 11287, 11288, 
11289, 11290, 11291, 11292, 11293, 11294, 11295, 11296, 11297, 11298, 
11299, 11300, 11301, 11302, 11303, 11304, 11305, 11306, 11307, 11308, 
11309, 11310, 11311, 11312, 11313, 11314, 11315, 11316, 11317, 11318, 
11319, 11320, 11321, 11322, 11323, 11324, 11325, 11326, 11327, 11328, 
11329, 11330, 11331, 11332, 11333, 11334, 11335, 11336, 11337, 11338, 
11339, 11340, 11341, 11342, 11343, 11344, 11345, 11346, 11347, 11348, 
11349, 11350, 11351, 11352, 11353, 11354, 11355, 11356, 11357, 11358, 
11359, 11360, 11361, 11362, 11363, 11364, 11365, 11366, 11367, 11368, 
11369, 11370, 11371, 11372, 11373, 11374, 11375, 11376, 11377, 11378, 
11379, 11380, 11381, 11382, 11383, 11384, 11385, 11386, 11387, 11388, 
11389, 11390, 11391, 11392, 11393, 11394, 11395, 11396, 11397, 11398, 
11399, 11400, 11401, 11402, 11403, 11404, 11405, 11406, 11407, 11408, 
11409, 11410, 11411, 11412, 11413, 11414, 11415, 11416, 11417, 11418, 
11419, 11420, 11421, 11422, 11423, 11424, 11425, 11426, 11427, 11428, 
11429, 11430, 11431, 11432, 11433, 11434, 11435, 11436, 11437, 11438, 
11439, 11440, 11441, 11442, 11443, 11444, 11445, 11446, 11447, 11448, 
11449, 11450, 11451, 11452, 11453, 11454, 11455, 11456, 11457, 11458, 
11459, 11460, 11461, 11462, 11463, 11464, 11465, 11466, 11467, 11468, 
11469, 11470, 11471, 11472, 11473, 11474, 11475, 11476, 11477, 11478, 
11479, 11480, 11481, 11482, 11483, 11484, 11485, 11486, 11487, 11488, 
11489, 11490, 
*NSET,NSET=bottom
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 
1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 
1765, 1766, 1767, 1768, 1769, 1774, 1775, 1776, 1777, 1778, 
1779, 1780, 1781, 1782, 1783, 1784, 1789, 1790, 1791, 1792, 
1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 
1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 
1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 
1831, 1832, 1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 
1841, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 
1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 
1869, 1870, 1871, 1872, 1881, 1882, 1883, 1884, 1885, 1886, 
1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 1895, 1896, 
1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 1905, 1906, 
1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 1915, 1916, 
1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 1925, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
11763, 11764, 11765, 11766, 11767, 11768, 11769, 11770, 11771, 11772, 
11773, 11774, 11775, 11776, 11777, 11778, 11779, 11780, 11781, 11782, 
11783, 11784, 11785, 11786, 11787, 11788, 11789, 11790, 11791, 11792, 
11793, 11794, 11795, 11796, 11797, 11798, 11799, 11800, 11801, 11802, 
11803, 11804, 11805, 11806, 11807, 11808, 11809, 11810, 11811, 11812, 
11813, 11814, 11815, 11816, 11817, 11818, 11819, 11820, 11821, 11822, 
11823, 11824, 11825, 11826, 11827, 11828, 11829, 11830, 11831, 11832, 
11833, 11834, 11835, 11836, 11837, 11838, 11839, 11840, 11841, 11842, 
11843, 11844, 11845, 11846, 11847, 11848, 11849, 11850, 11851, 11852, 
11853, 11854, 11855, 11856, 11857, 11858, 11859, 11860, 11861, 11862, 
11863, 11864, 11865, 11866, 11867, 11868, 11869, 11870, 11871, 11872, 
11873, 11874, 11875, 11876, 11877, 11878, 11879, 11880, 11881, 11882, 
11883, 11884, 11885, 11886, 11887, 11888, 11889, 11890, 11891, 11892, 
11893, 11894, 11895, 11896, 11897, 11898, 11899, 11900, 11901, 11902, 
11903, 11904, 11905, 11906, 11907, 11908, 11909, 11910, 11911, 11912, 
11913, 11914, 11915, 11916, 11917, 11918, 11919, 11920, 11921, 11922, 
11923, 11924, 11925, 11926, 11927, 11928, 11929, 11930, 11931, 11932, 
11933, 11934, 11935, 11936, 11937, 11938, 11939, 11940, 11941, 11942, 
11943, 11944, 11945, 11946, 11947, 11948, 11949, 11950, 11951, 11952, 
11953, 11954, 11955, 11956, 11957, 11958, 11959, 11960, 11961, 11962, 
11963, 11964, 11965, 11966, 11967, 11968, 11969, 11970, 11971, 11972, 
11973, 11974, 11975, 11976, 11977, 11978, 11979, 11980, 11981, 11982, 
11983, 11984, 11985, 11986, 11987, 11988, 11989, 11990, 11991, 11992, 
11993, 11994, 11995, 11996, 11997, 11998, 11999, 12000, 12001, 12002, 
12003, 12004, 12005, 12006, 12007, 12008, 12009, 12010, 12011, 12012, 
12013, 12014, 12015, 12332, 12333, 12334, 12335, 12336, 12337, 12338, 
12339, 12340, 12341, 12342, 12343, 12344, 12345, 12346, 12347, 12348, 
12349, 12350, 12351, 12352, 12353, 12354, 12355, 12356, 12357, 12358, 
12359, 12360, 12361, 12362, 12363, 12364, 12365, 12366, 12367, 12368, 
12369, 12370, 12371, 12372, 12373, 12374, 12375, 12376, 12377, 12378, 
12379, 12380, 12381, 12382, 12383, 12384, 12385, 12386, 12387, 12388, 
12389, 12390, 12391, 12392, 12393, 12394, 12395, 12396, 12397, 12398, 
12399, 12400, 12401, 12402, 12403, 12404, 12405, 12406, 12407, 12408, 
12409, 12410, 12411, 12412, 12413, 12414, 12415, 12416, 12417, 12418, 
12419, 12420, 12421, 12422, 12423, 12424, 12425, 12426, 12427, 12428, 
12429, 12430, 12431, 12432, 12433, 12434, 12435, 12436, 12437, 12438, 
12439, 12440, 12441, 12442, 12443, 12444, 12445, 12446, 12447, 12448, 
12449, 12450, 12451, 12452, 12453, 12454, 12455, 12456, 12457, 12458, 
12459, 12460, 12461, 12462, 12463, 12464, 12465, 12466, 12467, 12468, 
12469, 12470, 12471, 12472, 12473, 12474, 12475, 12476, 12477, 12478, 
12479, 12480, 12481, 12482, 12483, 12484, 12485, 12486, 12487, 12488, 
12489, 12490, 12491, 12492, 12493, 12494, 12495, 12496, 12497, 12498, 
12499, 12500, 12501, 12502, 12503, 12504, 12505, 12506, 12507, 12508, 
12509, 12510, 12511, 12512, 12513, 12514, 12515, 12516, 12517, 12518, 
12519, 12520, 12521, 12522, 12523, 12524, 12525, 12526, 12527, 12528, 
12529, 12530, 12531, 12532, 12533, 12534, 12535, 12536, 12537, 12538, 
12539, 12540, 12541, 12542, 12543, 12544, 12545, 12546, 12547, 12548, 
12549, 12550, 12551, 12552, 12553, 12554, 12555, 12556, 12557, 12558, 
12559, 12560, 12561, 12562, 12563, 12564, 12565, 12566, 12567, 12568, 
12569, 12570, 12571, 12572, 12573, 12574, 12575, 12576, 12577, 12578, 
12579, 12580, 12581, 12582, 12583, 12584, 
*NSET,NSET=symmetry
1, 3, 5, 7, 11, 12, 15, 16, 19, 20, 
23, 24, 25, 26, 29, 30, 33, 34, 37, 38, 
41, 42, 45, 46, 49, 50, 53, 55, 57, 58, 
61, 62, 79, 80, 81, 83, 87, 88, 89, 91, 
92, 95, 108, 109, 134, 135, 172, 173, 174, 175, 
176, 177, 178, 179, 180, 181, 182, 183, 184, 185, 
186, 187, 188, 189, 190, 191, 192, 193, 194, 218, 
219, 220, 221, 222, 223, 224, 225, 226, 227, 228, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 275, 276, 277, 278, 279, 280, 281, 282, 
283, 284, 285, 286, 287, 288, 289, 290, 291, 292, 
293, 294, 295, 296, 297, 378, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 412, 413, 
414, 415, 416, 417, 418, 419, 420, 421, 422, 423, 
424, 425, 426, 427, 428, 429, 430, 431, 432, 433, 
434, 435, 436, 437, 438, 439, 440, 441, 442, 443, 
444, 445, 446, 447, 448, 449, 450, 451, 452, 453, 
454, 455, 456, 457, 503, 504, 505, 506, 507, 508, 
509, 510, 511, 512, 513, 514, 515, 516, 517, 518, 
519, 520, 521, 522, 523, 524, 525, 564, 565, 577, 
578, 579, 580, 581, 582, 583, 584, 585, 586, 587, 
588, 589, 590, 591, 592, 593, 594, 595, 596, 597, 
598, 599, 600, 601, 613, 614, 615, 616, 617, 618, 
619, 620, 621, 622, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 773, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 841, 842, 843, 844, 845, 
846, 847, 848, 849, 850, 851, 852, 853, 854, 855, 
856, 857, 858, 859, 860, 861, 862, 863, 864, 865, 
866, 867, 868, 869, 870, 871, 872, 873, 874, 875, 
876, 877, 878, 879, 880, 881, 882, 883, 884, 885, 
886, 887, 888, 889, 890, 891, 892, 893, 894, 895, 
896, 897, 898, 899, 900, 901, 902, 903, 904, 905, 
906, 907, 908, 909, 1001, 1002, 1003, 1004, 1005, 1006, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1019, 1020, 1021, 1022, 1023, 1069, 1070, 1071, 
1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 
1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 
1092, 1093, 1094, 1095, 1145, 1146, 1182, 1183, 1197, 1198, 
1199, 1200, 1201, 1202, 1203, 1204, 1205, 1206, 1207, 1208, 
1209, 1210, 1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218, 
1219, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 
1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 
1284, 1285, 1286, 1287, 1594, 1595, 1596, 1597, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1647, 1648, 1649, 1650, 1651, 
1652, 1653, 1654, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1770, 1771, 1772, 1773, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 
1811, 1823, 1824, 1825, 1826, 1842, 1843, 1844, 1845, 1846, 
1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 
1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 
1867, 1868, 1869, 1870, 1871, 1872, 1926, 1927, 1928, 1929, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 3622, 3623, 3624, 3625, 
3626, 3627, 3628, 3629, 3630, 3631, 3632, 3633, 3634, 3635, 
3636, 3637, 3638, 3639, 3640, 3641, 3642, 3643, 3644, 3645, 
3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 3655, 
3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 3665, 
3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 3675, 
3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 3685, 
3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 
3696, 3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 3705, 
3706, 3707, 3708, 3709, 3710, 3711, 3712, 3713, 3714, 3715, 
3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724, 3725, 
3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 3735, 
3736, 3737, 3738, 3739, 3740, 3741, 3742, 3743, 3744, 3745, 
3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 3755, 
3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 3765, 
3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 3775, 
3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 3785, 
3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 3795, 
3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 3805, 
3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 3815, 
3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 3825, 
3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 3835, 
3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 3845, 
3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 
3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 
3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 
3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 
3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 
3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 3905, 
3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 3915, 
3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 3925, 
3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 
3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 3945, 
3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 3955, 
3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 3965, 
3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 3975, 
3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 3985, 
3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 3995, 
3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 4005, 
4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 4015, 
4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 4025, 
4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 4035, 
4036, 4037, 4038, 4039, 4040, 4041, 4042, 4043, 4044, 4045, 
4046, 4047, 4048, 4049, 4050, 4051, 4052, 4053, 4054, 4055, 
4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 
4066, 4067, 4068, 4069, 4070, 4071, 4072, 4073, 4074, 4075, 
4076, 4077, 4078, 4079, 4080, 4081, 4082, 4083, 4084, 4085, 
4086, 4087, 4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 
4096, 4097, 4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 
4106, 4107, 4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 
4116, 4117, 4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 
4126, 4127, 4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 
4136, 4137, 4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 
4146, 4147, 4148, 4149, 4150, 4978, 4979, 4980, 4981, 4982, 
4983, 4984, 4985, 4986, 4987, 4988, 4989, 4990, 4991, 4992, 
4993, 4994, 4995, 4996, 4997, 4998, 4999, 5000, 5001, 5002, 
5003, 5004, 5005, 5006, 5007, 5008, 5009, 5010, 5011, 5012, 
5013, 5014, 5015, 5016, 5017, 5018, 5019, 5020, 5021, 5022, 
5023, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 5425, 
5426, 5427, 5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 
5436, 5437, 5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 
5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 
5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 
5466, 5467, 5468, 5469, 5470, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 6322, 
6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 6332, 
6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 6342, 
6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 6352, 
6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 6362, 
6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 
6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 
6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 
6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 
6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 
6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 
6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 6432, 
6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 
6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 
6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 
6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 
6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 6482, 
6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 6491, 6492, 
6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 6501, 6502, 
6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 6511, 6512, 
6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 6521, 6522, 
6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 6531, 6532, 
6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 6541, 6542, 
6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 6551, 6552, 
6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 6561, 6562, 
6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 6571, 6572, 
6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 6581, 6582, 
6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 6591, 6592, 
6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 6601, 6602, 
6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 6611, 6612, 
6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 6621, 6622, 
6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 6631, 6632, 
6633, 6634, 6635, 6636, 6637, 6638, 6639, 6640, 6641, 6642, 
6643, 6644, 6645, 6646, 6647, 6648, 6649, 6650, 6651, 6652, 
6653, 6654, 6655, 6656, 6657, 6658, 6659, 6660, 6661, 6662, 
6663, 6664, 6665, 6666, 6667, 6668, 6669, 6670, 6671, 6672, 
6673, 6674, 6675, 6676, 6677, 6678, 6679, 6680, 6681, 6682, 
6683, 6684, 6685, 6686, 6687, 6688, 6689, 6690, 6691, 6692, 
6693, 6694, 6695, 6696, 6697, 6698, 6699, 6700, 6701, 6702, 
6703, 6704, 6705, 6706, 6707, 6708, 6709, 6710, 6711, 6712, 
6713, 6714, 6715, 6716, 6717, 6718, 6719, 6720, 6721, 6722, 
6723, 6724, 6725, 6726, 6727, 6728, 6729, 6730, 6731, 6732, 
6733, 6734, 6735, 6736, 6737, 6738, 6739, 6740, 6741, 6742, 
6743, 6744, 6745, 6746, 6747, 6748, 6749, 6750, 6751, 6752, 
6753, 6754, 6755, 6756, 6757, 6758, 6759, 6760, 6761, 6762, 
6763, 6764, 6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 
6773, 6774, 6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 
6783, 6784, 6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 
6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 
6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 
6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 
6823, 6824, 6825, 6826, 8368, 8369, 8370, 8371, 8372, 8373, 
8374, 8375, 8376, 8377, 8378, 8379, 8380, 8381, 8382, 8383, 
8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 8392, 8393, 
8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 8402, 8403, 
8404, 8405, 8406, 8407, 8408, 8409, 8410, 8411, 8412, 8413, 
10501, 10502, 10503, 10504, 10505, 10506, 10507, 10508, 10509, 10510, 
10511, 10512, 10513, 10514, 10515, 10516, 10517, 10518, 10519, 10520, 
10521, 10522, 10523, 10524, 10525, 10526, 10527, 10528, 10529, 10530, 
10531, 10532, 10533, 10534, 10535, 10536, 10537, 10538, 10539, 10540, 
10541, 10542, 10543, 10544, 10545, 10546, 10547, 10548, 10549, 10550, 
10551, 10552, 10553, 10554, 10555, 10556, 10557, 10558, 10559, 10560, 
10561, 10562, 10563, 10564, 10565, 10566, 10567, 10568, 10569, 10570, 
10571, 10572, 10573, 10574, 10575, 10576, 10577, 10578, 10579, 10580, 
10581, 10582, 10583, 10584, 10585, 10586, 10587, 10588, 10589, 10590, 
10591, 10592, 10890, 10891, 10892, 10893, 10894, 10895, 10896, 10897, 
10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 11010, 11011, 
11012, 11013, 11014, 11015, 11016, 11017, 11018, 11019, 11020, 11021, 
11022, 11023, 11024, 11025, 11026, 11027, 11028, 11029, 11030, 11031, 
11032, 11033, 11034, 11035, 11036, 11037, 11038, 11039, 11040, 11041, 
11042, 11043, 11044, 11045, 11046, 11047, 11048, 11049, 11050, 11051, 
11052, 11053, 11054, 11055, 11056, 11057, 11058, 11059, 11060, 11061, 
11062, 11063, 11064, 11065, 11066, 11067, 11068, 11069, 11070, 11071, 
11072, 11073, 11074, 11075, 11076, 11077, 11078, 11079, 11080, 11081, 
11082, 11083, 11084, 11085, 11086, 11087, 11088, 11089, 11090, 11091, 
11092, 11093, 11094, 11095, 11096, 11097, 11098, 11099, 11100, 11101, 
11627, 11628, 11629, 11630, 11631, 11632, 11633, 11634, 11635, 11636, 
11637, 11638, 11639, 11640, 11641, 11642, 11643, 11644, 11645, 11646, 
11647, 11648, 11649, 11650, 11651, 11652, 11653, 11654, 11655, 11656, 
11657, 11658, 11659, 11660, 11661, 11662, 11663, 11664, 11665, 11666, 
11667, 11668, 11669, 11670, 11671, 11672, 11673, 11674, 11675, 11676, 
11677, 11678, 11679, 11680, 11681, 11682, 11683, 11684, 11685, 11686, 
11687, 11688, 11689, 11690, 11691, 11692, 11693, 11694, 11695, 11696, 
11697, 11698, 11699, 11700, 11701, 11702, 11703, 11704, 11705, 11706, 
11707, 11708, 11709, 11710, 11711, 11712, 11713, 11714, 11715, 11716, 
11717, 11718, 12060, 12061, 12062, 12063, 12064, 12065, 12066, 12067, 
12068, 12069, 12070, 12071, 12072, 12073, 12074, 12075, 12076, 12077, 
12078, 12079, 12080, 12081, 12082, 12083, 12084, 12085, 12086, 12087, 
12088, 12089, 12090, 12091, 12092, 12093, 12094, 12095, 12096, 12097, 
12098, 12099, 12100, 12101, 12102, 12103, 12104, 12105, 12106, 12107, 
12108, 12109, 12110, 12111, 12112, 12113, 12114, 12115, 12116, 12117, 
12118, 12119, 12120, 12121, 12122, 12123, 12124, 12125, 12126, 12127, 
12128, 12129, 12130, 12131, 12132, 12133, 12134, 12135, 12136, 12137, 
12138, 12139, 12140, 12141, 12142, 12143, 12144, 12145, 12146, 12147, 
12148, 12149, 12150, 12151, 
*NSET,NSET=Ceramic_Contact
1, 2, 5, 6, 21, 22, 23, 24, 26, 28, 
30, 32, 45, 46, 47, 48, 50, 52, 53, 54, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 123, 124, 125, 126, 127, 128, 129, 130, 131, 
132, 133, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 644, 645, 646, 647, 
648, 649, 650, 651, 652, 653, 654, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
726, 727, 728, 729, 730, 731, 732, 733, 734, 735, 
736, 737, 738, 739, 740, 741, 742, 743, 744, 745, 
746, 747, 748, 762, 763, 764, 765, 766, 767, 768, 
769, 770, 771, 772, 1073, 1074, 1075, 1076, 1077, 1078, 
1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 
1089, 1090, 1091, 1092, 1093, 1094, 1095, 1100, 1101, 1102, 
1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 
1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 
1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 
1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 
1143, 1144, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 
1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 1177, 
1178, 1179, 1180, 1181, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 5046, 5047, 5048, 
5049, 5050, 5051, 5052, 5053, 5054, 5055, 5056, 5057, 5058, 
5059, 5060, 5061, 5062, 5063, 5064, 5065, 5066, 5067, 5068, 
5069, 5070, 5071, 5072, 5073, 5074, 5075, 5076, 5077, 5078, 
5079, 5080, 5081, 5082, 5083, 5084, 5085, 5086, 5087, 5088, 
5089, 5090, 5091, 5092, 5093, 5094, 5095, 5096, 5097, 5098, 
5099, 5100, 5101, 5102, 5103, 5104, 5105, 5106, 5107, 5108, 
5109, 5110, 5111, 5112, 5113, 5114, 5115, 5116, 5117, 5118, 
5119, 5120, 5121, 5122, 5123, 5124, 5125, 5126, 5127, 5128, 
5129, 5130, 5131, 5132, 5133, 5134, 5135, 5136, 5137, 5138, 
5139, 5140, 5141, 5142, 5143, 5144, 5145, 5146, 5147, 5148, 
5149, 5150, 5151, 5152, 5153, 5154, 5155, 5156, 5157, 5158, 
5159, 5160, 5161, 5162, 5163, 5164, 5165, 5166, 5167, 5168, 
5169, 5170, 5171, 5172, 5173, 5174, 5175, 5176, 5177, 5178, 
5179, 5180, 5181, 5182, 5183, 5184, 5185, 5186, 5187, 5188, 
5189, 5190, 5191, 5192, 5193, 5194, 5195, 5196, 5197, 5198, 
5199, 5200, 5201, 5202, 5203, 5204, 5205, 5206, 5207, 5208, 
5209, 5210, 5211, 5212, 5213, 5214, 5215, 5216, 5217, 5218, 
5219, 5220, 5221, 5222, 5223, 5224, 5225, 5226, 5227, 5228, 
5229, 5230, 5231, 5232, 5233, 5234, 5235, 5236, 5237, 5238, 
5239, 5240, 5241, 5242, 5243, 5244, 5245, 5246, 5247, 5248, 
5249, 5250, 5251, 5252, 5253, 5254, 5255, 5256, 5257, 5258, 
5259, 5260, 5261, 5262, 5263, 5264, 5265, 5266, 5267, 5268, 
5269, 5270, 5271, 5272, 5273, 5274, 5275, 5276, 5277, 5278, 
5279, 5280, 5281, 5282, 5283, 5284, 5285, 5286, 5287, 5288, 
5289, 5290, 5291, 5292, 5293, 5294, 5295, 5296, 5297, 5298, 
5770, 5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 
5780, 5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 
5790, 5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 
5800, 5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 
5810, 5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 
5820, 5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 
5830, 5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 
5840, 5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 
5850, 5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 
5860, 5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 
5870, 5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 
5880, 5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 
5890, 5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 
5900, 5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 
5910, 5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 
5920, 5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 
5930, 5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 
5940, 5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 
5950, 5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 
5960, 5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 
5970, 5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 
5980, 5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 
5990, 5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 
6000, 6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 
6010, 6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 
6020, 6021, 6022, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 
8511, 8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 
8521, 8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 
8531, 8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 
8541, 8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 
8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 
8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 
8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 
8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 
8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 
8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 
8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 
8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 
8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 
8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 
8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 
8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 
8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 
8681, 8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 
8691, 8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 
8701, 8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 
8711, 8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 
8721, 8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 
8731, 8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 
8741, 8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 
8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=Contact_CeramicTop
21, 22, 23, 24, 26, 28, 30, 32, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 579, 580, 581, 582, 583, 584, 585, 586, 
587, 588, 589, 590, 591, 592, 593, 594, 595, 596, 
597, 598, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 608, 609, 610, 611, 612, 617, 618, 619, 620, 
627, 628, 629, 630, 644, 645, 646, 647, 648, 649, 
650, 651, 652, 653, 654, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 726, 727, 
728, 729, 730, 731, 732, 733, 734, 735, 736, 737, 
738, 739, 740, 741, 742, 743, 744, 745, 746, 747, 
748, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 5046, 5047, 5048, 5049, 5050, 5051, 5052, 5053, 
5054, 5055, 5056, 5057, 5058, 5059, 5060, 5061, 5062, 5063, 
5064, 5065, 5066, 5067, 5068, 5069, 5070, 5071, 5072, 5073, 
5074, 5075, 5076, 5077, 5078, 5079, 5080, 5081, 5082, 5083, 
5084, 5085, 5086, 5087, 5088, 5089, 5090, 5091, 5092, 5093, 
5094, 5095, 5096, 5097, 5098, 5099, 5100, 5101, 5102, 5103, 
5104, 5105, 5106, 5107, 5108, 5109, 5110, 5111, 5112, 5113, 
5114, 5115, 5116, 5117, 5118, 5119, 5120, 5121, 5122, 5123, 
5124, 5125, 5126, 5127, 5128, 5129, 5130, 5131, 5132, 5133, 
5134, 5135, 5136, 5137, 5138, 5139, 5140, 5141, 5142, 5143, 
5144, 5145, 5146, 5147, 5148, 5149, 5150, 5151, 5152, 5153, 
5154, 5155, 5156, 5157, 5158, 5159, 5160, 5161, 5162, 5163, 
5164, 5165, 5166, 5167, 5168, 5169, 5170, 5171, 5172, 5173, 
5174, 5175, 5176, 5177, 5178, 5179, 5180, 5181, 5182, 5183, 
5184, 5185, 5186, 5187, 5188, 5189, 5190, 5191, 5192, 5193, 
5194, 5195, 5196, 5197, 5198, 5199, 5200, 5201, 5202, 5203, 
5204, 5205, 5206, 5207, 5208, 5209, 5210, 5211, 5212, 5213, 
5214, 5215, 5216, 5217, 5218, 5219, 5220, 5221, 5222, 5223, 
5224, 5225, 5226, 5227, 5228, 5229, 5230, 5231, 5232, 5233, 
5234, 5235, 5236, 5237, 5238, 5239, 5240, 5241, 5242, 5243, 
5244, 5245, 5246, 5247, 5248, 5249, 5250, 5251, 5252, 5253, 
5254, 5255, 5256, 5257, 5258, 5259, 5260, 5261, 5262, 5263, 
5264, 5265, 5266, 5267, 5268, 5269, 5270, 5271, 5272, 5273, 
5274, 5275, 5276, 5277, 5278, 5279, 5280, 5281, 5282, 5283, 
5284, 5285, 5286, 5287, 5288, 5289, 5290, 5291, 5292, 5293, 
5294, 5295, 5296, 5297, 5298, 5359, 5360, 5361, 5362, 5363, 
5364, 5365, 5366, 5367, 5368, 5369, 5370, 5371, 5372, 5373, 
5374, 5375, 5376, 5377, 5378, 5379, 5380, 5381, 5382, 5383, 
5384, 5385, 5386, 5387, 5388, 5389, 5390, 5391, 5392, 5393, 
5394, 5395, 5396, 5397, 5398, 5399, 5400, 5401, 5402, 5770, 
5771, 5772, 5773, 5774, 5775, 5776, 5777, 5778, 5779, 5780, 
5781, 5782, 5783, 5784, 5785, 5786, 5787, 5788, 5789, 5790, 
5791, 5792, 5793, 5794, 5795, 5796, 5797, 5798, 5799, 5800, 
5801, 5802, 5803, 5804, 5805, 5806, 5807, 5808, 5809, 5810, 
5811, 5812, 5813, 5814, 5815, 5816, 5817, 5818, 5819, 5820, 
5821, 5822, 5823, 5824, 5825, 5826, 5827, 5828, 5829, 5830, 
5831, 5832, 5833, 5834, 5835, 5836, 5837, 5838, 5839, 5840, 
5841, 5842, 5843, 5844, 5845, 5846, 5847, 5848, 5849, 5850, 
5851, 5852, 5853, 5854, 5855, 5856, 5857, 5858, 5859, 5860, 
5861, 5862, 5863, 5864, 5865, 5866, 5867, 5868, 5869, 5870, 
5871, 5872, 5873, 5874, 5875, 5876, 5877, 5878, 5879, 5880, 
5881, 5882, 5883, 5884, 5885, 5886, 5887, 5888, 5889, 5890, 
5891, 5892, 5893, 5894, 5895, 5896, 5897, 5898, 5899, 5900, 
5901, 5902, 5903, 5904, 5905, 5906, 5907, 5908, 5909, 5910, 
5911, 5912, 5913, 5914, 5915, 5916, 5917, 5918, 5919, 5920, 
5921, 5922, 5923, 5924, 5925, 5926, 5927, 5928, 5929, 5930, 
5931, 5932, 5933, 5934, 5935, 5936, 5937, 5938, 5939, 5940, 
5941, 5942, 5943, 5944, 5945, 5946, 5947, 5948, 5949, 5950, 
5951, 5952, 5953, 5954, 5955, 5956, 5957, 5958, 5959, 5960, 
5961, 5962, 5963, 5964, 5965, 5966, 5967, 5968, 5969, 5970, 
5971, 5972, 5973, 5974, 5975, 5976, 5977, 5978, 5979, 5980, 
5981, 5982, 5983, 5984, 5985, 5986, 5987, 5988, 5989, 5990, 
5991, 5992, 5993, 5994, 5995, 5996, 5997, 5998, 5999, 6000, 
6001, 6002, 6003, 6004, 6005, 6006, 6007, 6008, 6009, 6010, 
6011, 6012, 6013, 6014, 6015, 6016, 6017, 6018, 6019, 6020, 
6021, 6022, 
*NSET,NSET=Contact_CeramicBottom
1, 2, 5, 6, 45, 46, 47, 48, 50, 52, 
53, 54, 97, 98, 99, 100, 101, 102, 103, 104, 
105, 106, 107, 123, 124, 125, 126, 127, 128, 129, 
130, 131, 132, 133, 149, 150, 151, 152, 153, 154, 
155, 156, 157, 158, 159, 160, 161, 162, 163, 164, 
165, 166, 167, 168, 169, 170, 171, 172, 173, 174, 
175, 176, 177, 178, 179, 180, 181, 182, 183, 184, 
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 
1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 
1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 1125, 1126, 
1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 
1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 1160, 1161, 
1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 
1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 
1989, 1990, 1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 
1999, 2000, 2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 
2009, 2010, 2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 
2019, 2020, 2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 
2029, 2030, 2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 
2039, 2040, 2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 
2049, 2050, 2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 
2059, 2060, 2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 
2069, 2070, 2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 
2079, 2080, 2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 
2089, 2090, 2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 
2099, 2100, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 
2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 
2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 
2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 
2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 
2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 
2159, 2160, 2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 
2169, 2170, 2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 
2179, 2180, 2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 
2189, 2190, 2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 
2199, 2200, 2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 
2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 
2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 
2239, 2240, 2241, 8504, 8505, 8506, 8507, 8508, 8509, 8510, 
8511, 8512, 8513, 8514, 8515, 8516, 8517, 8518, 8519, 8520, 
8521, 8522, 8523, 8524, 8525, 8526, 8527, 8528, 8529, 8530, 
8531, 8532, 8533, 8534, 8535, 8536, 8537, 8538, 8539, 8540, 
8541, 8542, 8543, 8544, 8545, 8546, 8547, 8548, 8549, 8550, 
8551, 8552, 8553, 8554, 8555, 8556, 8557, 8558, 8559, 8560, 
8561, 8562, 8563, 8564, 8565, 8566, 8567, 8568, 8569, 8570, 
8571, 8572, 8573, 8574, 8575, 8576, 8577, 8578, 8579, 8580, 
8581, 8582, 8583, 8584, 8585, 8586, 8587, 8588, 8589, 8590, 
8591, 8592, 8593, 8594, 8595, 8596, 8597, 8598, 8599, 8600, 
8601, 8602, 8603, 8604, 8605, 8606, 8607, 8608, 8609, 8610, 
8611, 8612, 8613, 8614, 8615, 8616, 8617, 8618, 8619, 8620, 
8621, 8622, 8623, 8624, 8625, 8626, 8627, 8628, 8629, 8630, 
8631, 8632, 8633, 8634, 8635, 8636, 8637, 8638, 8639, 8640, 
8641, 8642, 8643, 8644, 8645, 8646, 8647, 8648, 8649, 8650, 
8651, 8652, 8653, 8654, 8655, 8656, 8657, 8658, 8659, 8660, 
8661, 8662, 8663, 8664, 8665, 8666, 8667, 8668, 8669, 8670, 
8671, 8672, 8673, 8674, 8675, 8676, 8677, 8678, 8679, 8680, 
8681, 8682, 8683, 8684, 8685, 8686, 8687, 8688, 8689, 8690, 
8691, 8692, 8693, 8694, 8695, 8696, 8697, 8698, 8699, 8700, 
8701, 8702, 8703, 8704, 8705, 8706, 8707, 8708, 8709, 8710, 
8711, 8712, 8713, 8714, 8715, 8716, 8717, 8718, 8719, 8720, 
8721, 8722, 8723, 8724, 8725, 8726, 8727, 8728, 8729, 8730, 
8731, 8732, 8733, 8734, 8735, 8736, 8737, 8738, 8739, 8740, 
8741, 8742, 8743, 8744, 8745, 8746, 8747, 8748, 8749, 8750, 
8751, 8752, 8753, 8754, 8755, 8756, 
*NSET,NSET=Surface_2D
1, 3, 5, 7, 11, 12, 15, 16, 19, 20, 
23, 24, 25, 26, 29, 30, 33, 34, 37, 38, 
41, 42, 45, 46, 49, 50, 53, 55, 79, 80, 
81, 83, 87, 88, 89, 91, 92, 95, 108, 109, 
134, 135, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 218, 219, 220, 221, 222, 
223, 224, 225, 226, 227, 228, 229, 230, 231, 232, 
233, 234, 235, 236, 237, 238, 239, 240, 275, 276, 
277, 278, 279, 280, 281, 282, 283, 284, 285, 286, 
287, 288, 289, 290, 291, 292, 293, 294, 295, 296, 
297, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 412, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 
428, 429, 430, 431, 432, 433, 434, 435, 436, 437, 
438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 
448, 449, 450, 451, 452, 453, 454, 455, 456, 457, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 564, 565, 577, 578, 579, 580, 581, 
582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 
592, 593, 594, 595, 596, 597, 598, 599, 600, 601, 
613, 614, 615, 616, 617, 618, 619, 620, 621, 622, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 841, 842, 843, 844, 845, 846, 847, 848, 849, 
850, 851, 852, 853, 854, 855, 856, 857, 858, 859, 
860, 861, 862, 863, 864, 865, 866, 867, 868, 869, 
870, 871, 872, 873, 874, 875, 876, 877, 878, 879, 
880, 881, 882, 883, 884, 885, 886, 887, 888, 889, 
890, 891, 892, 893, 894, 895, 896, 897, 898, 899, 
900, 901, 902, 903, 904, 905, 906, 907, 908, 909, 
1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 
1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 
1021, 1022, 1023, 1069, 1070, 1071, 1072, 1073, 1074, 1075, 
1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 
1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 
1145, 1146, 1182, 1183, 1594, 1595, 1596, 1597, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1647, 1648, 1649, 1650, 1651, 
1652, 1653, 1654, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1770, 1771, 1772, 1773, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 
1811, 1823, 1824, 1825, 1826, 1842, 1843, 1844, 1845, 1846, 
1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 
1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 
1867, 1868, 1869, 1870, 1871, 1872, 1926, 1927, 1928, 1929, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 3622, 3623, 3624, 3625, 
3626, 3627, 3628, 3629, 3630, 3631, 3632, 3633, 3634, 3635, 
3636, 3637, 3638, 3639, 3640, 3641, 3642, 3643, 3644, 3645, 
3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 3655, 
3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 3665, 
3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 3675, 
3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 3685, 
3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 
3696, 3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 3705, 
3706, 3707, 3708, 3709, 3710, 3711, 3712, 3713, 3714, 3715, 
3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724, 3725, 
3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 3735, 
3736, 3737, 3738, 3739, 3740, 3741, 3742, 3743, 3744, 3745, 
3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 3755, 
3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 3765, 
3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 3775, 
3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 3785, 
3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 3795, 
3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 3805, 
3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 3815, 
3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 3825, 
3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 3835, 
3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 3845, 
3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 
3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 
3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 
3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 
3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 
3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 3905, 
3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 3915, 
3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 3925, 
3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 
3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 3945, 
3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 3955, 
3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 3965, 
3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 3975, 
3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 3985, 
3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 3995, 
3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 4005, 
4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 4015, 
4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 4025, 
4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 4035, 
4036, 4037, 4038, 4039, 4040, 4041, 4042, 4043, 4044, 4045, 
4046, 4047, 4048, 4049, 4050, 4051, 4052, 4053, 4054, 4055, 
4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 
4066, 4067, 4068, 4069, 4070, 4071, 4072, 4073, 4074, 4075, 
4076, 4077, 4078, 4079, 4080, 4081, 4082, 4083, 4084, 4085, 
4086, 4087, 4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 
4096, 4097, 4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 
4106, 4107, 4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 
4116, 4117, 4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 
4126, 4127, 4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 
4136, 4137, 4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 
4146, 4147, 4148, 4149, 4150, 4978, 4979, 4980, 4981, 4982, 
4983, 4984, 4985, 4986, 4987, 4988, 4989, 4990, 4991, 4992, 
4993, 4994, 4995, 4996, 4997, 4998, 4999, 5000, 5001, 5002, 
5003, 5004, 5005, 5006, 5007, 5008, 5009, 5010, 5011, 5012, 
5013, 5014, 5015, 5016, 5017, 5018, 5019, 5020, 5021, 5022, 
5023, 5299, 5300, 5301, 5302, 5303, 5304, 5305, 5306, 5425, 
5426, 5427, 5428, 5429, 5430, 5431, 5432, 5433, 5434, 5435, 
5436, 5437, 5438, 5439, 5440, 5441, 5442, 5443, 5444, 5445, 
5446, 5447, 5448, 5449, 5450, 5451, 5452, 5453, 5454, 5455, 
5456, 5457, 5458, 5459, 5460, 5461, 5462, 5463, 5464, 5465, 
5466, 5467, 5468, 5469, 5470, 6298, 6299, 6300, 6301, 6302, 
6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 6312, 
6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 6322, 
6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 6332, 
6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 6342, 
6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 6352, 
6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 6362, 
6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 6372, 
6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 6382, 
6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 6392, 
6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 6402, 
6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 6412, 
6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 6422, 
6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 6432, 
6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 
6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 
6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 
6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 
6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 6482, 
6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 6491, 6492, 
6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 6501, 6502, 
6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 6511, 6512, 
6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 6521, 6522, 
6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 6531, 6532, 
6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 6541, 6542, 
6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 6551, 6552, 
6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 6561, 6562, 
6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 6571, 6572, 
6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 6581, 6582, 
6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 6591, 6592, 
6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 6601, 6602, 
6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 6611, 6612, 
6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 6621, 6622, 
6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 6631, 6632, 
6633, 6634, 6635, 6636, 6637, 6638, 6639, 6640, 6641, 6642, 
6643, 6644, 6645, 6646, 6647, 6648, 6649, 6650, 6651, 6652, 
6653, 6654, 6655, 6656, 6657, 6658, 6659, 6660, 6661, 6662, 
6663, 6664, 6665, 6666, 6667, 6668, 6669, 6670, 6671, 6672, 
6673, 6674, 6675, 6676, 6677, 6678, 6679, 6680, 6681, 6682, 
6683, 6684, 6685, 6686, 6687, 6688, 6689, 6690, 6691, 6692, 
6693, 6694, 6695, 6696, 6697, 6698, 6699, 6700, 6701, 6702, 
6703, 6704, 6705, 6706, 6707, 6708, 6709, 6710, 6711, 6712, 
6713, 6714, 6715, 6716, 6717, 6718, 6719, 6720, 6721, 6722, 
6723, 6724, 6725, 6726, 6727, 6728, 6729, 6730, 6731, 6732, 
6733, 6734, 6735, 6736, 6737, 6738, 6739, 6740, 6741, 6742, 
6743, 6744, 6745, 6746, 6747, 6748, 6749, 6750, 6751, 6752, 
6753, 6754, 6755, 6756, 6757, 6758, 6759, 6760, 6761, 6762, 
6763, 6764, 6765, 6766, 6767, 6768, 6769, 6770, 6771, 6772, 
6773, 6774, 6775, 6776, 6777, 6778, 6779, 6780, 6781, 6782, 
6783, 6784, 6785, 6786, 6787, 6788, 6789, 6790, 6791, 6792, 
6793, 6794, 6795, 6796, 6797, 6798, 6799, 6800, 6801, 6802, 
6803, 6804, 6805, 6806, 6807, 6808, 6809, 6810, 6811, 6812, 
6813, 6814, 6815, 6816, 6817, 6818, 6819, 6820, 6821, 6822, 
6823, 6824, 6825, 6826, 8368, 8369, 8370, 8371, 8372, 8373, 
8374, 8375, 8376, 8377, 8378, 8379, 8380, 8381, 8382, 8383, 
8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 8392, 8393, 
8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 8402, 8403, 
8404, 8405, 8406, 8407, 8408, 8409, 8410, 8411, 8412, 8413, 
10501, 10502, 10503, 10504, 10505, 10506, 10507, 10508, 10509, 10510, 
10511, 10512, 10513, 10514, 10515, 10516, 10517, 10518, 10519, 10520, 
10521, 10522, 10523, 10524, 10525, 10526, 10527, 10528, 10529, 10530, 
10531, 10532, 10533, 10534, 10535, 10536, 10537, 10538, 10539, 10540, 
10541, 10542, 10543, 10544, 10545, 10546, 10547, 10548, 10549, 10550, 
10551, 10552, 10553, 10554, 10555, 10556, 10557, 10558, 10559, 10560, 
10561, 10562, 10563, 10564, 10565, 10566, 10567, 10568, 10569, 10570, 
10571, 10572, 10573, 10574, 10575, 10576, 10577, 10578, 10579, 10580, 
10581, 10582, 10583, 10584, 10585, 10586, 10587, 10588, 10589, 10590, 
10591, 10592, 10890, 10891, 10892, 10893, 10894, 10895, 10896, 10897, 
10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 11010, 11011, 
11012, 11013, 11014, 11015, 11016, 11017, 11018, 11019, 11020, 11021, 
11022, 11023, 11024, 11025, 11026, 11027, 11028, 11029, 11030, 11031, 
11032, 11033, 11034, 11035, 11036, 11037, 11038, 11039, 11040, 11041, 
11042, 11043, 11044, 11045, 11046, 11047, 11048, 11049, 11050, 11051, 
11052, 11053, 11054, 11055, 11056, 11057, 11058, 11059, 11060, 11061, 
11062, 11063, 11064, 11065, 11066, 11067, 11068, 11069, 11070, 11071, 
11072, 11073, 11074, 11075, 11076, 11077, 11078, 11079, 11080, 11081, 
11082, 11083, 11084, 11085, 11086, 11087, 11088, 11089, 11090, 11091, 
11092, 11093, 11094, 11095, 11096, 11097, 11098, 11099, 11100, 11101, 
11627, 11628, 11629, 11630, 11631, 11632, 11633, 11634, 11635, 11636, 
11637, 11638, 11639, 11640, 11641, 11642, 11643, 11644, 11645, 11646, 
11647, 11648, 11649, 11650, 11651, 11652, 11653, 11654, 11655, 11656, 
11657, 11658, 11659, 11660, 11661, 11662, 11663, 11664, 11665, 11666, 
11667, 11668, 11669, 11670, 11671, 11672, 11673, 11674, 11675, 11676, 
11677, 11678, 11679, 11680, 11681, 11682, 11683, 11684, 11685, 11686, 
11687, 11688, 11689, 11690, 11691, 11692, 11693, 11694, 11695, 11696, 
11697, 11698, 11699, 11700, 11701, 11702, 11703, 11704, 11705, 11706, 
11707, 11708, 11709, 11710, 11711, 11712, 11713, 11714, 11715, 11716, 
11717, 11718, 12060, 12061, 12062, 12063, 12064, 12065, 12066, 12067, 
12068, 12069, 12070, 12071, 12072, 12073, 12074, 12075, 12076, 12077, 
12078, 12079, 12080, 12081, 12082, 12083, 12084, 12085, 12086, 12087, 
12088, 12089, 12090, 12091, 12092, 12093, 12094, 12095, 12096, 12097, 
12098, 12099, 12100, 12101, 12102, 12103, 12104, 12105, 12106, 12107, 
12108, 12109, 12110, 12111, 12112, 12113, 12114, 12115, 12116, 12117, 
12118, 12119, 12120, 12121, 12122, 12123, 12124, 12125, 12126, 12127, 
12128, 12129, 12130, 12131, 12132, 12133, 12134, 12135, 12136, 12137, 
12138, 12139, 12140, 12141, 12142, 12143, 12144, 12145, 12146, 12147, 
12148, 12149, 12150, 12151, 
*NSET,NSET=Solder_2D
3, 7, 11, 12, 15, 16, 19, 20, 25, 29, 
33, 34, 37, 38, 41, 42, 218, 219, 220, 221, 
222, 223, 224, 225, 226, 227, 228, 229, 230, 231, 
232, 233, 234, 235, 236, 237, 238, 239, 240, 275, 
276, 277, 278, 279, 280, 281, 282, 283, 284, 285, 
286, 287, 288, 289, 290, 291, 292, 293, 294, 295, 
296, 297, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 503, 504, 505, 506, 507, 
508, 509, 510, 511, 512, 513, 514, 515, 516, 517, 
518, 519, 520, 521, 522, 523, 524, 525, 655, 656, 
657, 658, 659, 660, 661, 662, 663, 664, 665, 666, 
667, 668, 669, 670, 671, 672, 673, 674, 675, 676, 
677, 773, 774, 775, 776, 777, 778, 779, 780, 781, 
782, 783, 784, 785, 786, 787, 788, 789, 790, 791, 
792, 793, 794, 795, 887, 888, 889, 890, 891, 892, 
893, 894, 895, 896, 897, 898, 899, 900, 901, 902, 
903, 904, 905, 906, 907, 908, 909, 1001, 1002, 1003, 
1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 
1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 
*NSET,NSET=Copper_2D
1, 3, 5, 7, 19, 20, 23, 24, 25, 26, 
29, 30, 41, 42, 45, 46, 49, 50, 53, 55, 
108, 109, 134, 135, 172, 173, 174, 175, 176, 177, 
178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 
188, 189, 190, 191, 192, 193, 194, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 564, 565, 577, 578, 579, 580, 581, 
582, 583, 584, 585, 586, 587, 588, 589, 590, 591, 
592, 593, 594, 595, 596, 597, 598, 599, 600, 601, 
613, 614, 615, 616, 617, 618, 619, 620, 621, 622, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 1001, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1069, 1070, 1071, 1072, 1073, 1074, 1075, 1076, 1077, 
1078, 1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 
1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 1145, 1146, 
1182, 1183, 2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 
2549, 2550, 2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 
2559, 2560, 2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 
2569, 2570, 2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 
2579, 2580, 2581, 2582, 2583, 2584, 2585, 2586, 4978, 4979, 
4980, 4981, 4982, 4983, 4984, 4985, 4986, 4987, 4988, 4989, 
4990, 4991, 4992, 4993, 4994, 4995, 4996, 4997, 4998, 4999, 
5000, 5001, 5002, 5003, 5004, 5005, 5006, 5007, 5008, 5009, 
5010, 5011, 5012, 5013, 5014, 5015, 5016, 5017, 5018, 5019, 
5020, 5021, 5022, 5023, 5299, 5300, 5301, 5302, 5303, 5304, 
5305, 5306, 5425, 5426, 5427, 5428, 5429, 5430, 5431, 5432, 
5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 5441, 5442, 
5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 5451, 5452, 
5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 5461, 5462, 
5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 8368, 8369, 
8370, 8371, 8372, 8373, 8374, 8375, 8376, 8377, 8378, 8379, 
8380, 8381, 8382, 8383, 8384, 8385, 8386, 8387, 8388, 8389, 
8390, 8391, 8392, 8393, 8394, 8395, 8396, 8397, 8398, 8399, 
8400, 8401, 8402, 8403, 8404, 8405, 8406, 8407, 8408, 8409, 
8410, 8411, 8412, 8413, 
*NSET,NSET=Ceramic_2D
1, 5, 23, 24, 26, 30, 45, 46, 50, 53, 
79, 80, 81, 83, 87, 88, 89, 91, 92, 95, 
172, 173, 174, 175, 176, 177, 178, 179, 180, 181, 
182, 183, 184, 185, 186, 187, 188, 189, 190, 191, 
192, 193, 194, 579, 580, 581, 582, 583, 584, 585, 
586, 587, 588, 589, 590, 591, 592, 593, 594, 595, 
596, 597, 598, 599, 600, 601, 617, 618, 619, 620, 
678, 679, 680, 681, 682, 683, 684, 685, 686, 687, 
688, 689, 690, 691, 692, 693, 694, 695, 696, 697, 
698, 699, 700, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 
1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 
1090, 1091, 1092, 1093, 1094, 1095, 1594, 1595, 1596, 1597, 
1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 
1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 
1629, 1630, 1631, 1632, 1633, 1634, 1635, 1647, 1648, 1649, 
1650, 1651, 1652, 1653, 1654, 1674, 1675, 1676, 1677, 1678, 
1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 
1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 
1699, 1700, 1770, 1771, 1772, 1773, 1785, 1786, 1787, 1788, 
1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 
1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 
1809, 1810, 1811, 1823, 1824, 1825, 1826, 1842, 1843, 1844, 
1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 
1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 
1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1926, 1927, 
1928, 1929, 10501, 10502, 10503, 10504, 10505, 10506, 10507, 10508, 
10509, 10510, 10511, 10512, 10513, 10514, 10515, 10516, 10517, 10518, 
10519, 10520, 10521, 10522, 10523, 10524, 10525, 10526, 10527, 10528, 
10529, 10530, 10531, 10532, 10533, 10534, 10535, 10536, 10537, 10538, 
10539, 10540, 10541, 10542, 10543, 10544, 10545, 10546, 10547, 10548, 
10549, 10550, 10551, 10552, 10553, 10554, 10555, 10556, 10557, 10558, 
10559, 10560, 10561, 10562, 10563, 10564, 10565, 10566, 10567, 10568, 
10569, 10570, 10571, 10572, 10573, 10574, 10575, 10576, 10577, 10578, 
10579, 10580, 10581, 10582, 10583, 10584, 10585, 10586, 10587, 10588, 
10589, 10590, 10591, 10592, 10890, 10891, 10892, 10893, 10894, 10895, 
10896, 10897, 10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 
11010, 11011, 11012, 11013, 11014, 11015, 11016, 11017, 11018, 11019, 
11020, 11021, 11022, 11023, 11024, 11025, 11026, 11027, 11028, 11029, 
11030, 11031, 11032, 11033, 11034, 11035, 11036, 11037, 11038, 11039, 
11040, 11041, 11042, 11043, 11044, 11045, 11046, 11047, 11048, 11049, 
11050, 11051, 11052, 11053, 11054, 11055, 11056, 11057, 11058, 11059, 
11060, 11061, 11062, 11063, 11064, 11065, 11066, 11067, 11068, 11069, 
11070, 11071, 11072, 11073, 11074, 11075, 11076, 11077, 11078, 11079, 
11080, 11081, 11082, 11083, 11084, 11085, 11086, 11087, 11088, 11089, 
11090, 11091, 11092, 11093, 11094, 11095, 11096, 11097, 11098, 11099, 
11100, 11101, 11627, 11628, 11629, 11630, 11631, 11632, 11633, 11634, 
11635, 11636, 11637, 11638, 11639, 11640, 11641, 11642, 11643, 11644, 
11645, 11646, 11647, 11648, 11649, 11650, 11651, 11652, 11653, 11654, 
11655, 11656, 11657, 11658, 11659, 11660, 11661, 11662, 11663, 11664, 
11665, 11666, 11667, 11668, 11669, 11670, 11671, 11672, 11673, 11674, 
11675, 11676, 11677, 11678, 11679, 11680, 11681, 11682, 11683, 11684, 
11685, 11686, 11687, 11688, 11689, 11690, 11691, 11692, 11693, 11694, 
11695, 11696, 11697, 11698, 11699, 11700, 11701, 11702, 11703, 11704, 
11705, 11706, 11707, 11708, 11709, 11710, 11711, 11712, 11713, 11714, 
11715, 11716, 11717, 11718, 12060, 12061, 12062, 12063, 12064, 12065, 
12066, 12067, 12068, 12069, 12070, 12071, 12072, 12073, 12074, 12075, 
12076, 12077, 12078, 12079, 12080, 12081, 12082, 12083, 12084, 12085, 
12086, 12087, 12088, 12089, 12090, 12091, 12092, 12093, 12094, 12095, 
12096, 12097, 12098, 12099, 12100, 12101, 12102, 12103, 12104, 12105, 
12106, 12107, 12108, 12109, 12110, 12111, 12112, 12113, 12114, 12115, 
12116, 12117, 12118, 12119, 12120, 12121, 12122, 12123, 12124, 12125, 
12126, 12127, 12128, 12129, 12130, 12131, 12132, 12133, 12134, 12135, 
12136, 12137, 12138, 12139, 12140, 12141, 12142, 12143, 12144, 12145, 
12146, 12147, 12148, 12149, 12150, 12151, 
*NSET,NSET=SemiconductorL_2D
11, 12, 15, 16, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
412, 413, 414, 415, 416, 417, 418, 419, 420, 421, 
422, 423, 424, 425, 426, 427, 428, 429, 430, 431, 
432, 433, 434, 435, 436, 437, 438, 439, 440, 441, 
442, 443, 444, 445, 446, 447, 448, 449, 450, 451, 
452, 453, 454, 455, 456, 457, 3622, 3623, 3624, 3625, 
3626, 3627, 3628, 3629, 3630, 3631, 3632, 3633, 3634, 3635, 
3636, 3637, 3638, 3639, 3640, 3641, 3642, 3643, 3644, 3645, 
3646, 3647, 3648, 3649, 3650, 3651, 3652, 3653, 3654, 3655, 
3656, 3657, 3658, 3659, 3660, 3661, 3662, 3663, 3664, 3665, 
3666, 3667, 3668, 3669, 3670, 3671, 3672, 3673, 3674, 3675, 
3676, 3677, 3678, 3679, 3680, 3681, 3682, 3683, 3684, 3685, 
3686, 3687, 3688, 3689, 3690, 3691, 3692, 3693, 3694, 3695, 
3696, 3697, 3698, 3699, 3700, 3701, 3702, 3703, 3704, 3705, 
3706, 3707, 3708, 3709, 3710, 3711, 3712, 3713, 3714, 3715, 
3716, 3717, 3718, 3719, 3720, 3721, 3722, 3723, 3724, 3725, 
3726, 3727, 3728, 3729, 3730, 3731, 3732, 3733, 3734, 3735, 
3736, 3737, 3738, 3739, 3740, 3741, 3742, 3743, 3744, 3745, 
3746, 3747, 3748, 3749, 3750, 3751, 3752, 3753, 3754, 3755, 
3756, 3757, 3758, 3759, 3760, 3761, 3762, 3763, 3764, 3765, 
3766, 3767, 3768, 3769, 3770, 3771, 3772, 3773, 3774, 3775, 
3776, 3777, 3778, 3779, 3780, 3781, 3782, 3783, 3784, 3785, 
3786, 3787, 3788, 3789, 3790, 3791, 3792, 3793, 3794, 3795, 
3796, 3797, 3798, 3799, 3800, 3801, 3802, 3803, 3804, 3805, 
3806, 3807, 3808, 3809, 3810, 3811, 3812, 3813, 3814, 3815, 
3816, 3817, 3818, 3819, 3820, 3821, 3822, 3823, 3824, 3825, 
3826, 3827, 3828, 3829, 3830, 3831, 3832, 3833, 3834, 3835, 
3836, 3837, 3838, 3839, 3840, 3841, 3842, 3843, 3844, 3845, 
3846, 3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 
3856, 3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 
3866, 3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 
3876, 3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 
3886, 3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 
3896, 3897, 3898, 3899, 3900, 3901, 3902, 3903, 3904, 3905, 
3906, 3907, 3908, 3909, 3910, 3911, 3912, 3913, 3914, 3915, 
3916, 3917, 3918, 3919, 3920, 3921, 3922, 3923, 3924, 3925, 
3926, 3927, 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 
3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943, 3944, 3945, 
3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 3955, 
3956, 3957, 3958, 3959, 3960, 3961, 3962, 3963, 3964, 3965, 
3966, 3967, 3968, 3969, 3970, 3971, 3972, 3973, 3974, 3975, 
3976, 3977, 3978, 3979, 3980, 3981, 3982, 3983, 3984, 3985, 
3986, 3987, 3988, 3989, 3990, 3991, 3992, 3993, 3994, 3995, 
3996, 3997, 3998, 3999, 4000, 4001, 4002, 4003, 4004, 4005, 
4006, 4007, 4008, 4009, 4010, 4011, 4012, 4013, 4014, 4015, 
4016, 4017, 4018, 4019, 4020, 4021, 4022, 4023, 4024, 4025, 
4026, 4027, 4028, 4029, 4030, 4031, 4032, 4033, 4034, 4035, 
4036, 4037, 4038, 4039, 4040, 4041, 4042, 4043, 4044, 4045, 
4046, 4047, 4048, 4049, 4050, 4051, 4052, 4053, 4054, 4055, 
4056, 4057, 4058, 4059, 4060, 4061, 4062, 4063, 4064, 4065, 
4066, 4067, 4068, 4069, 4070, 4071, 4072, 4073, 4074, 4075, 
4076, 4077, 4078, 4079, 4080, 4081, 4082, 4083, 4084, 4085, 
4086, 4087, 4088, 4089, 4090, 4091, 4092, 4093, 4094, 4095, 
4096, 4097, 4098, 4099, 4100, 4101, 4102, 4103, 4104, 4105, 
4106, 4107, 4108, 4109, 4110, 4111, 4112, 4113, 4114, 4115, 
4116, 4117, 4118, 4119, 4120, 4121, 4122, 4123, 4124, 4125, 
4126, 4127, 4128, 4129, 4130, 4131, 4132, 4133, 4134, 4135, 
4136, 4137, 4138, 4139, 4140, 4141, 4142, 4143, 4144, 4145, 
4146, 4147, 4148, 4149, 4150, 
*NSET,NSET=SemiconductorR_2D
33, 34, 37, 38, 773, 774, 775, 776, 777, 778, 
779, 780, 781, 782, 783, 784, 785, 786, 787, 788, 
789, 790, 791, 792, 793, 794, 795, 841, 842, 843, 
844, 845, 846, 847, 848, 849, 850, 851, 852, 853, 
854, 855, 856, 857, 858, 859, 860, 861, 862, 863, 
864, 865, 866, 867, 868, 869, 870, 871, 872, 873, 
874, 875, 876, 877, 878, 879, 880, 881, 882, 883, 
884, 885, 886, 887, 888, 889, 890, 891, 892, 893, 
894, 895, 896, 897, 898, 899, 900, 901, 902, 903, 
904, 905, 906, 907, 908, 909, 6298, 6299, 6300, 6301, 
6302, 6303, 6304, 6305, 6306, 6307, 6308, 6309, 6310, 6311, 
6312, 6313, 6314, 6315, 6316, 6317, 6318, 6319, 6320, 6321, 
6322, 6323, 6324, 6325, 6326, 6327, 6328, 6329, 6330, 6331, 
6332, 6333, 6334, 6335, 6336, 6337, 6338, 6339, 6340, 6341, 
6342, 6343, 6344, 6345, 6346, 6347, 6348, 6349, 6350, 6351, 
6352, 6353, 6354, 6355, 6356, 6357, 6358, 6359, 6360, 6361, 
6362, 6363, 6364, 6365, 6366, 6367, 6368, 6369, 6370, 6371, 
6372, 6373, 6374, 6375, 6376, 6377, 6378, 6379, 6380, 6381, 
6382, 6383, 6384, 6385, 6386, 6387, 6388, 6389, 6390, 6391, 
6392, 6393, 6394, 6395, 6396, 6397, 6398, 6399, 6400, 6401, 
6402, 6403, 6404, 6405, 6406, 6407, 6408, 6409, 6410, 6411, 
6412, 6413, 6414, 6415, 6416, 6417, 6418, 6419, 6420, 6421, 
6422, 6423, 6424, 6425, 6426, 6427, 6428, 6429, 6430, 6431, 
6432, 6433, 6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 
6442, 6443, 6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 
6452, 6453, 6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 
6462, 6463, 6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 
6472, 6473, 6474, 6475, 6476, 6477, 6478, 6479, 6480, 6481, 
6482, 6483, 6484, 6485, 6486, 6487, 6488, 6489, 6490, 6491, 
6492, 6493, 6494, 6495, 6496, 6497, 6498, 6499, 6500, 6501, 
6502, 6503, 6504, 6505, 6506, 6507, 6508, 6509, 6510, 6511, 
6512, 6513, 6514, 6515, 6516, 6517, 6518, 6519, 6520, 6521, 
6522, 6523, 6524, 6525, 6526, 6527, 6528, 6529, 6530, 6531, 
6532, 6533, 6534, 6535, 6536, 6537, 6538, 6539, 6540, 6541, 
6542, 6543, 6544, 6545, 6546, 6547, 6548, 6549, 6550, 6551, 
6552, 6553, 6554, 6555, 6556, 6557, 6558, 6559, 6560, 6561, 
6562, 6563, 6564, 6565, 6566, 6567, 6568, 6569, 6570, 6571, 
6572, 6573, 6574, 6575, 6576, 6577, 6578, 6579, 6580, 6581, 
6582, 6583, 6584, 6585, 6586, 6587, 6588, 6589, 6590, 6591, 
6592, 6593, 6594, 6595, 6596, 6597, 6598, 6599, 6600, 6601, 
6602, 6603, 6604, 6605, 6606, 6607, 6608, 6609, 6610, 6611, 
6612, 6613, 6614, 6615, 6616, 6617, 6618, 6619, 6620, 6621, 
6622, 6623, 6624, 6625, 6626, 6627, 6628, 6629, 6630, 6631, 
