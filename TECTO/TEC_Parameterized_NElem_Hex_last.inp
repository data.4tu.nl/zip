37212, 7032, 7055, 7056, 7033
37213, 7033, 7056, 965, 964
37214, 805, 806, 7057, 7034
37215, 7034, 7057, 7058, 7035
37216, 7035, 7058, 7059, 7036
37217, 7036, 7059, 7060, 7037
37218, 7037, 7060, 7061, 7038
37219, 7038, 7061, 7062, 7039
37220, 7039, 7062, 7063, 7040
37221, 7040, 7063, 7064, 7041
37222, 7041, 7064, 7065, 7042
37223, 7042, 7065, 7066, 7043
37224, 7043, 7066, 7067, 7044
37225, 7044, 7067, 7068, 7045
37226, 7045, 7068, 7069, 7046
37227, 7046, 7069, 7070, 7047
37228, 7047, 7070, 7071, 7048
37229, 7048, 7071, 7072, 7049
37230, 7049, 7072, 7073, 7050
37231, 7050, 7073, 7074, 7051
37232, 7051, 7074, 7075, 7052
37233, 7052, 7075, 7076, 7053
37234, 7053, 7076, 7077, 7054
37235, 7054, 7077, 7078, 7055
37236, 7055, 7078, 7079, 7056
37237, 7056, 7079, 966, 965
37238, 806, 807, 7080, 7057
37239, 7057, 7080, 7081, 7058
37240, 7058, 7081, 7082, 7059
37241, 7059, 7082, 7083, 7060
37242, 7060, 7083, 7084, 7061
37243, 7061, 7084, 7085, 7062
37244, 7062, 7085, 7086, 7063
37245, 7063, 7086, 7087, 7064
37246, 7064, 7087, 7088, 7065
37247, 7065, 7088, 7089, 7066
37248, 7066, 7089, 7090, 7067
37249, 7067, 7090, 7091, 7068
37250, 7068, 7091, 7092, 7069
37251, 7069, 7092, 7093, 7070
37252, 7070, 7093, 7094, 7071
37253, 7071, 7094, 7095, 7072
37254, 7072, 7095, 7096, 7073
37255, 7073, 7096, 7097, 7074
37256, 7074, 7097, 7098, 7075
37257, 7075, 7098, 7099, 7076
37258, 7076, 7099, 7100, 7077
37259, 7077, 7100, 7101, 7078
37260, 7078, 7101, 7102, 7079
37261, 7079, 7102, 967, 966
37262, 807, 808, 7103, 7080
37263, 7080, 7103, 7104, 7081
37264, 7081, 7104, 7105, 7082
37265, 7082, 7105, 7106, 7083
37266, 7083, 7106, 7107, 7084
37267, 7084, 7107, 7108, 7085
37268, 7085, 7108, 7109, 7086
37269, 7086, 7109, 7110, 7087
37270, 7087, 7110, 7111, 7088
37271, 7088, 7111, 7112, 7089
37272, 7089, 7112, 7113, 7090
37273, 7090, 7113, 7114, 7091
37274, 7091, 7114, 7115, 7092
37275, 7092, 7115, 7116, 7093
37276, 7093, 7116, 7117, 7094
37277, 7094, 7117, 7118, 7095
37278, 7095, 7118, 7119, 7096
37279, 7096, 7119, 7120, 7097
37280, 7097, 7120, 7121, 7098
37281, 7098, 7121, 7122, 7099
37282, 7099, 7122, 7123, 7100
37283, 7100, 7123, 7124, 7101
37284, 7101, 7124, 7125, 7102
37285, 7102, 7125, 968, 967
37286, 808, 809, 7126, 7103
37287, 7103, 7126, 7127, 7104
37288, 7104, 7127, 7128, 7105
37289, 7105, 7128, 7129, 7106
37290, 7106, 7129, 7130, 7107
37291, 7107, 7130, 7131, 7108
37292, 7108, 7131, 7132, 7109
37293, 7109, 7132, 7133, 7110
37294, 7110, 7133, 7134, 7111
37295, 7111, 7134, 7135, 7112
37296, 7112, 7135, 7136, 7113
37297, 7113, 7136, 7137, 7114
37298, 7114, 7137, 7138, 7115
37299, 7115, 7138, 7139, 7116
37300, 7116, 7139, 7140, 7117
37301, 7117, 7140, 7141, 7118
37302, 7118, 7141, 7142, 7119
37303, 7119, 7142, 7143, 7120
37304, 7120, 7143, 7144, 7121
37305, 7121, 7144, 7145, 7122
37306, 7122, 7145, 7146, 7123
37307, 7123, 7146, 7147, 7124
37308, 7124, 7147, 7148, 7125
37309, 7125, 7148, 969, 968
37310, 809, 810, 7149, 7126
37311, 7126, 7149, 7150, 7127
37312, 7127, 7150, 7151, 7128
37313, 7128, 7151, 7152, 7129
37314, 7129, 7152, 7153, 7130
37315, 7130, 7153, 7154, 7131
37316, 7131, 7154, 7155, 7132
37317, 7132, 7155, 7156, 7133
37318, 7133, 7156, 7157, 7134
37319, 7134, 7157, 7158, 7135
37320, 7135, 7158, 7159, 7136
37321, 7136, 7159, 7160, 7137
37322, 7137, 7160, 7161, 7138
37323, 7138, 7161, 7162, 7139
37324, 7139, 7162, 7163, 7140
37325, 7140, 7163, 7164, 7141
37326, 7141, 7164, 7165, 7142
37327, 7142, 7165, 7166, 7143
37328, 7143, 7166, 7167, 7144
37329, 7144, 7167, 7168, 7145
37330, 7145, 7168, 7169, 7146
37331, 7146, 7169, 7170, 7147
37332, 7147, 7170, 7171, 7148
37333, 7148, 7171, 970, 969
37334, 810, 811, 7172, 7149
37335, 7149, 7172, 7173, 7150
37336, 7150, 7173, 7174, 7151
37337, 7151, 7174, 7175, 7152
37338, 7152, 7175, 7176, 7153
37339, 7153, 7176, 7177, 7154
37340, 7154, 7177, 7178, 7155
37341, 7155, 7178, 7179, 7156
37342, 7156, 7179, 7180, 7157
37343, 7157, 7180, 7181, 7158
37344, 7158, 7181, 7182, 7159
37345, 7159, 7182, 7183, 7160
37346, 7160, 7183, 7184, 7161
37347, 7161, 7184, 7185, 7162
37348, 7162, 7185, 7186, 7163
37349, 7163, 7186, 7187, 7164
37350, 7164, 7187, 7188, 7165
37351, 7165, 7188, 7189, 7166
37352, 7166, 7189, 7190, 7167
37353, 7167, 7190, 7191, 7168
37354, 7168, 7191, 7192, 7169
37355, 7169, 7192, 7193, 7170
37356, 7170, 7193, 7194, 7171
37357, 7171, 7194, 971, 970
37358, 811, 812, 7195, 7172
37359, 7172, 7195, 7196, 7173
37360, 7173, 7196, 7197, 7174
37361, 7174, 7197, 7198, 7175
37362, 7175, 7198, 7199, 7176
37363, 7176, 7199, 7200, 7177
37364, 7177, 7200, 7201, 7178
37365, 7178, 7201, 7202, 7179
37366, 7179, 7202, 7203, 7180
37367, 7180, 7203, 7204, 7181
37368, 7181, 7204, 7205, 7182
37369, 7182, 7205, 7206, 7183
37370, 7183, 7206, 7207, 7184
37371, 7184, 7207, 7208, 7185
37372, 7185, 7208, 7209, 7186
37373, 7186, 7209, 7210, 7187
37374, 7187, 7210, 7211, 7188
37375, 7188, 7211, 7212, 7189
37376, 7189, 7212, 7213, 7190
37377, 7190, 7213, 7214, 7191
37378, 7191, 7214, 7215, 7192
37379, 7192, 7215, 7216, 7193
37380, 7193, 7216, 7217, 7194
37381, 7194, 7217, 972, 971
37382, 812, 813, 7218, 7195
37383, 7195, 7218, 7219, 7196
37384, 7196, 7219, 7220, 7197
37385, 7197, 7220, 7221, 7198
37386, 7198, 7221, 7222, 7199
37387, 7199, 7222, 7223, 7200
37388, 7200, 7223, 7224, 7201
37389, 7201, 7224, 7225, 7202
37390, 7202, 7225, 7226, 7203
37391, 7203, 7226, 7227, 7204
37392, 7204, 7227, 7228, 7205
37393, 7205, 7228, 7229, 7206
37394, 7206, 7229, 7230, 7207
37395, 7207, 7230, 7231, 7208
37396, 7208, 7231, 7232, 7209
37397, 7209, 7232, 7233, 7210
37398, 7210, 7233, 7234, 7211
37399, 7211, 7234, 7235, 7212
37400, 7212, 7235, 7236, 7213
37401, 7213, 7236, 7237, 7214
37402, 7214, 7237, 7238, 7215
37403, 7215, 7238, 7239, 7216
37404, 7216, 7239, 7240, 7217
37405, 7217, 7240, 973, 972
37406, 813, 814, 7241, 7218
37407, 7218, 7241, 7242, 7219
37408, 7219, 7242, 7243, 7220
37409, 7220, 7243, 7244, 7221
37410, 7221, 7244, 7245, 7222
37411, 7222, 7245, 7246, 7223
37412, 7223, 7246, 7247, 7224
37413, 7224, 7247, 7248, 7225
37414, 7225, 7248, 7249, 7226
37415, 7226, 7249, 7250, 7227
37416, 7227, 7250, 7251, 7228
37417, 7228, 7251, 7252, 7229
37418, 7229, 7252, 7253, 7230
37419, 7230, 7253, 7254, 7231
37420, 7231, 7254, 7255, 7232
37421, 7232, 7255, 7256, 7233
37422, 7233, 7256, 7257, 7234
37423, 7234, 7257, 7258, 7235
37424, 7235, 7258, 7259, 7236
37425, 7236, 7259, 7260, 7237
37426, 7237, 7260, 7261, 7238
37427, 7238, 7261, 7262, 7239
37428, 7239, 7262, 7263, 7240
37429, 7240, 7263, 974, 973
37430, 814, 815, 7264, 7241
37431, 7241, 7264, 7265, 7242
37432, 7242, 7265, 7266, 7243
37433, 7243, 7266, 7267, 7244
37434, 7244, 7267, 7268, 7245
37435, 7245, 7268, 7269, 7246
37436, 7246, 7269, 7270, 7247
37437, 7247, 7270, 7271, 7248
37438, 7248, 7271, 7272, 7249
37439, 7249, 7272, 7273, 7250
37440, 7250, 7273, 7274, 7251
37441, 7251, 7274, 7275, 7252
37442, 7252, 7275, 7276, 7253
37443, 7253, 7276, 7277, 7254
37444, 7254, 7277, 7278, 7255
37445, 7255, 7278, 7279, 7256
37446, 7256, 7279, 7280, 7257
37447, 7257, 7280, 7281, 7258
37448, 7258, 7281, 7282, 7259
37449, 7259, 7282, 7283, 7260
37450, 7260, 7283, 7284, 7261
37451, 7261, 7284, 7285, 7262
37452, 7262, 7285, 7286, 7263
37453, 7263, 7286, 975, 974
37454, 815, 816, 7287, 7264
37455, 7264, 7287, 7288, 7265
37456, 7265, 7288, 7289, 7266
37457, 7266, 7289, 7290, 7267
37458, 7267, 7290, 7291, 7268
37459, 7268, 7291, 7292, 7269
37460, 7269, 7292, 7293, 7270
37461, 7270, 7293, 7294, 7271
37462, 7271, 7294, 7295, 7272
37463, 7272, 7295, 7296, 7273
37464, 7273, 7296, 7297, 7274
37465, 7274, 7297, 7298, 7275
37466, 7275, 7298, 7299, 7276
37467, 7276, 7299, 7300, 7277
37468, 7277, 7300, 7301, 7278
37469, 7278, 7301, 7302, 7279
37470, 7279, 7302, 7303, 7280
37471, 7280, 7303, 7304, 7281
37472, 7281, 7304, 7305, 7282
37473, 7282, 7305, 7306, 7283
37474, 7283, 7306, 7307, 7284
37475, 7284, 7307, 7308, 7285
37476, 7285, 7308, 7309, 7286
37477, 7286, 7309, 976, 975
37478, 816, 817, 7310, 7287
37479, 7287, 7310, 7311, 7288
37480, 7288, 7311, 7312, 7289
37481, 7289, 7312, 7313, 7290
37482, 7290, 7313, 7314, 7291
37483, 7291, 7314, 7315, 7292
37484, 7292, 7315, 7316, 7293
37485, 7293, 7316, 7317, 7294
37486, 7294, 7317, 7318, 7295
37487, 7295, 7318, 7319, 7296
37488, 7296, 7319, 7320, 7297
37489, 7297, 7320, 7321, 7298
37490, 7298, 7321, 7322, 7299
37491, 7299, 7322, 7323, 7300
37492, 7300, 7323, 7324, 7301
37493, 7301, 7324, 7325, 7302
37494, 7302, 7325, 7326, 7303
37495, 7303, 7326, 7327, 7304
37496, 7304, 7327, 7328, 7305
37497, 7305, 7328, 7329, 7306
37498, 7306, 7329, 7330, 7307
37499, 7307, 7330, 7331, 7308
37500, 7308, 7331, 7332, 7309
37501, 7309, 7332, 977, 976
37502, 817, 818, 7333, 7310
37503, 7310, 7333, 7334, 7311
37504, 7311, 7334, 7335, 7312
37505, 7312, 7335, 7336, 7313
37506, 7313, 7336, 7337, 7314
37507, 7314, 7337, 7338, 7315
37508, 7315, 7338, 7339, 7316
37509, 7316, 7339, 7340, 7317
37510, 7317, 7340, 7341, 7318
37511, 7318, 7341, 7342, 7319
37512, 7319, 7342, 7343, 7320
37513, 7320, 7343, 7344, 7321
37514, 7321, 7344, 7345, 7322
37515, 7322, 7345, 7346, 7323
37516, 7323, 7346, 7347, 7324
37517, 7324, 7347, 7348, 7325
37518, 7325, 7348, 7349, 7326
37519, 7326, 7349, 7350, 7327
37520, 7327, 7350, 7351, 7328
37521, 7328, 7351, 7352, 7329
37522, 7329, 7352, 7353, 7330
37523, 7330, 7353, 7354, 7331
37524, 7331, 7354, 7355, 7332
37525, 7332, 7355, 978, 977
37526, 818, 36, 933, 7333
37527, 7333, 933, 934, 7334
37528, 7334, 934, 935, 7335
37529, 7335, 935, 936, 7336
37530, 7336, 936, 937, 7337
37531, 7337, 937, 938, 7338
37532, 7338, 938, 939, 7339
37533, 7339, 939, 940, 7340
37534, 7340, 940, 941, 7341
37535, 7341, 941, 942, 7342
37536, 7342, 942, 943, 7343
37537, 7343, 943, 944, 7344
37538, 7344, 944, 945, 7345
37539, 7345, 945, 946, 7346
37540, 7346, 946, 947, 7347
37541, 7347, 947, 948, 7348
37542, 7348, 948, 949, 7349
37543, 7349, 949, 950, 7350
37544, 7350, 950, 951, 7351
37545, 7351, 951, 952, 7352
37546, 7352, 952, 953, 7353
37547, 7353, 953, 954, 7354
37548, 7354, 954, 955, 7355
37549, 7355, 955, 40, 978
*ELEMENT, type=CPS4, ELSET=Surface44
37550, 35, 910, 7356, 819
37551, 910, 911, 7357, 7356
37552, 911, 912, 7358, 7357
37553, 912, 913, 7359, 7358
37554, 913, 914, 7360, 7359
37555, 914, 915, 7361, 7360
37556, 915, 916, 7362, 7361
37557, 916, 917, 7363, 7362
37558, 917, 918, 7364, 7363
37559, 918, 919, 7365, 7364
37560, 919, 920, 7366, 7365
37561, 920, 921, 7367, 7366
37562, 921, 922, 7368, 7367
37563, 922, 923, 7369, 7368
37564, 923, 924, 7370, 7369
37565, 924, 925, 7371, 7370
37566, 925, 926, 7372, 7371
37567, 926, 927, 7373, 7372
37568, 927, 928, 7374, 7373
37569, 928, 929, 7375, 7374
37570, 929, 930, 7376, 7375
37571, 930, 931, 7377, 7376
37572, 931, 932, 7378, 7377
37573, 932, 39, 979, 7378
37574, 819, 7356, 7379, 820
37575, 7356, 7357, 7380, 7379
37576, 7357, 7358, 7381, 7380
37577, 7358, 7359, 7382, 7381
37578, 7359, 7360, 7383, 7382
37579, 7360, 7361, 7384, 7383
37580, 7361, 7362, 7385, 7384
37581, 7362, 7363, 7386, 7385
37582, 7363, 7364, 7387, 7386
37583, 7364, 7365, 7388, 7387
37584, 7365, 7366, 7389, 7388
37585, 7366, 7367, 7390, 7389
37586, 7367, 7368, 7391, 7390
37587, 7368, 7369, 7392, 7391
37588, 7369, 7370, 7393, 7392
37589, 7370, 7371, 7394, 7393
37590, 7371, 7372, 7395, 7394
37591, 7372, 7373, 7396, 7395
37592, 7373, 7374, 7397, 7396
37593, 7374, 7375, 7398, 7397
37594, 7375, 7376, 7399, 7398
37595, 7376, 7377, 7400, 7399
37596, 7377, 7378, 7401, 7400
37597, 7378, 979, 980, 7401
37598, 820, 7379, 7402, 821
37599, 7379, 7380, 7403, 7402
37600, 7380, 7381, 7404, 7403
37601, 7381, 7382, 7405, 7404
37602, 7382, 7383, 7406, 7405
37603, 7383, 7384, 7407, 7406
37604, 7384, 7385, 7408, 7407
37605, 7385, 7386, 7409, 7408
37606, 7386, 7387, 7410, 7409
37607, 7387, 7388, 7411, 7410
37608, 7388, 7389, 7412, 7411
37609, 7389, 7390, 7413, 7412
37610, 7390, 7391, 7414, 7413
37611, 7391, 7392, 7415, 7414
37612, 7392, 7393, 7416, 7415
37613, 7393, 7394, 7417, 7416
37614, 7394, 7395, 7418, 7417
37615, 7395, 7396, 7419, 7418
37616, 7396, 7397, 7420, 7419
37617, 7397, 7398, 7421, 7420
37618, 7398, 7399, 7422, 7421
37619, 7399, 7400, 7423, 7422
37620, 7400, 7401, 7424, 7423
37621, 7401, 980, 981, 7424
37622, 821, 7402, 7425, 822
37623, 7402, 7403, 7426, 7425
37624, 7403, 7404, 7427, 7426
37625, 7404, 7405, 7428, 7427
37626, 7405, 7406, 7429, 7428
37627, 7406, 7407, 7430, 7429
37628, 7407, 7408, 7431, 7430
37629, 7408, 7409, 7432, 7431
37630, 7409, 7410, 7433, 7432
37631, 7410, 7411, 7434, 7433
37632, 7411, 7412, 7435, 7434
37633, 7412, 7413, 7436, 7435
37634, 7413, 7414, 7437, 7436
37635, 7414, 7415, 7438, 7437
37636, 7415, 7416, 7439, 7438
37637, 7416, 7417, 7440, 7439
37638, 7417, 7418, 7441, 7440
37639, 7418, 7419, 7442, 7441
37640, 7419, 7420, 7443, 7442
37641, 7420, 7421, 7444, 7443
37642, 7421, 7422, 7445, 7444
37643, 7422, 7423, 7446, 7445
37644, 7423, 7424, 7447, 7446
37645, 7424, 981, 982, 7447
37646, 822, 7425, 7448, 823
37647, 7425, 7426, 7449, 7448
37648, 7426, 7427, 7450, 7449
37649, 7427, 7428, 7451, 7450
37650, 7428, 7429, 7452, 7451
37651, 7429, 7430, 7453, 7452
37652, 7430, 7431, 7454, 7453
37653, 7431, 7432, 7455, 7454
37654, 7432, 7433, 7456, 7455
37655, 7433, 7434, 7457, 7456
37656, 7434, 7435, 7458, 7457
37657, 7435, 7436, 7459, 7458
37658, 7436, 7437, 7460, 7459
37659, 7437, 7438, 7461, 7460
37660, 7438, 7439, 7462, 7461
37661, 7439, 7440, 7463, 7462
37662, 7440, 7441, 7464, 7463
37663, 7441, 7442, 7465, 7464
37664, 7442, 7443, 7466, 7465
37665, 7443, 7444, 7467, 7466
37666, 7444, 7445, 7468, 7467
37667, 7445, 7446, 7469, 7468
37668, 7446, 7447, 7470, 7469
37669, 7447, 982, 983, 7470
37670, 823, 7448, 7471, 824
37671, 7448, 7449, 7472, 7471
37672, 7449, 7450, 7473, 7472
37673, 7450, 7451, 7474, 7473
37674, 7451, 7452, 7475, 7474
37675, 7452, 7453, 7476, 7475
37676, 7453, 7454, 7477, 7476
37677, 7454, 7455, 7478, 7477
37678, 7455, 7456, 7479, 7478
37679, 7456, 7457, 7480, 7479
37680, 7457, 7458, 7481, 7480
37681, 7458, 7459, 7482, 7481
37682, 7459, 7460, 7483, 7482
37683, 7460, 7461, 7484, 7483
37684, 7461, 7462, 7485, 7484
37685, 7462, 7463, 7486, 7485
37686, 7463, 7464, 7487, 7486
37687, 7464, 7465, 7488, 7487
37688, 7465, 7466, 7489, 7488
37689, 7466, 7467, 7490, 7489
37690, 7467, 7468, 7491, 7490
37691, 7468, 7469, 7492, 7491
37692, 7469, 7470, 7493, 7492
37693, 7470, 983, 984, 7493
37694, 824, 7471, 7494, 825
37695, 7471, 7472, 7495, 7494
37696, 7472, 7473, 7496, 7495
37697, 7473, 7474, 7497, 7496
37698, 7474, 7475, 7498, 7497
37699, 7475, 7476, 7499, 7498
37700, 7476, 7477, 7500, 7499
37701, 7477, 7478, 7501, 7500
37702, 7478, 7479, 7502, 7501
37703, 7479, 7480, 7503, 7502
37704, 7480, 7481, 7504, 7503
37705, 7481, 7482, 7505, 7504
37706, 7482, 7483, 7506, 7505
37707, 7483, 7484, 7507, 7506
37708, 7484, 7485, 7508, 7507
37709, 7485, 7486, 7509, 7508
37710, 7486, 7487, 7510, 7509
37711, 7487, 7488, 7511, 7510
37712, 7488, 7489, 7512, 7511
37713, 7489, 7490, 7513, 7512
37714, 7490, 7491, 7514, 7513
37715, 7491, 7492, 7515, 7514
37716, 7492, 7493, 7516, 7515
37717, 7493, 984, 985, 7516
37718, 825, 7494, 7517, 826
37719, 7494, 7495, 7518, 7517
37720, 7495, 7496, 7519, 7518
37721, 7496, 7497, 7520, 7519
37722, 7497, 7498, 7521, 7520
37723, 7498, 7499, 7522, 7521
37724, 7499, 7500, 7523, 7522
37725, 7500, 7501, 7524, 7523
37726, 7501, 7502, 7525, 7524
37727, 7502, 7503, 7526, 7525
37728, 7503, 7504, 7527, 7526
37729, 7504, 7505, 7528, 7527
37730, 7505, 7506, 7529, 7528
37731, 7506, 7507, 7530, 7529
37732, 7507, 7508, 7531, 7530
37733, 7508, 7509, 7532, 7531
37734, 7509, 7510, 7533, 7532
37735, 7510, 7511, 7534, 7533
37736, 7511, 7512, 7535, 7534
37737, 7512, 7513, 7536, 7535
37738, 7513, 7514, 7537, 7536
37739, 7514, 7515, 7538, 7537
37740, 7515, 7516, 7539, 7538
37741, 7516, 985, 986, 7539
37742, 826, 7517, 7540, 827
37743, 7517, 7518, 7541, 7540
37744, 7518, 7519, 7542, 7541
37745, 7519, 7520, 7543, 7542
37746, 7520, 7521, 7544, 7543
37747, 7521, 7522, 7545, 7544
37748, 7522, 7523, 7546, 7545
37749, 7523, 7524, 7547, 7546
37750, 7524, 7525, 7548, 7547
37751, 7525, 7526, 7549, 7548
37752, 7526, 7527, 7550, 7549
37753, 7527, 7528, 7551, 7550
37754, 7528, 7529, 7552, 7551
37755, 7529, 7530, 7553, 7552
37756, 7530, 7531, 7554, 7553
37757, 7531, 7532, 7555, 7554
37758, 7532, 7533, 7556, 7555
37759, 7533, 7534, 7557, 7556
37760, 7534, 7535, 7558, 7557
37761, 7535, 7536, 7559, 7558
37762, 7536, 7537, 7560, 7559
37763, 7537, 7538, 7561, 7560
37764, 7538, 7539, 7562, 7561
37765, 7539, 986, 987, 7562
37766, 827, 7540, 7563, 828
37767, 7540, 7541, 7564, 7563
37768, 7541, 7542, 7565, 7564
37769, 7542, 7543, 7566, 7565
37770, 7543, 7544, 7567, 7566
37771, 7544, 7545, 7568, 7567
37772, 7545, 7546, 7569, 7568
37773, 7546, 7547, 7570, 7569
37774, 7547, 7548, 7571, 7570
37775, 7548, 7549, 7572, 7571
37776, 7549, 7550, 7573, 7572
37777, 7550, 7551, 7574, 7573
37778, 7551, 7552, 7575, 7574
37779, 7552, 7553, 7576, 7575
37780, 7553, 7554, 7577, 7576
37781, 7554, 7555, 7578, 7577
37782, 7555, 7556, 7579, 7578
37783, 7556, 7557, 7580, 7579
37784, 7557, 7558, 7581, 7580
37785, 7558, 7559, 7582, 7581
37786, 7559, 7560, 7583, 7582
37787, 7560, 7561, 7584, 7583
37788, 7561, 7562, 7585, 7584
37789, 7562, 987, 988, 7585
37790, 828, 7563, 7586, 829
37791, 7563, 7564, 7587, 7586
37792, 7564, 7565, 7588, 7587
37793, 7565, 7566, 7589, 7588
37794, 7566, 7567, 7590, 7589
37795, 7567, 7568, 7591, 7590
37796, 7568, 7569, 7592, 7591
37797, 7569, 7570, 7593, 7592
37798, 7570, 7571, 7594, 7593
37799, 7571, 7572, 7595, 7594
37800, 7572, 7573, 7596, 7595
37801, 7573, 7574, 7597, 7596
37802, 7574, 7575, 7598, 7597
37803, 7575, 7576, 7599, 7598
37804, 7576, 7577, 7600, 7599
37805, 7577, 7578, 7601, 7600
37806, 7578, 7579, 7602, 7601
37807, 7579, 7580, 7603, 7602
37808, 7580, 7581, 7604, 7603
37809, 7581, 7582, 7605, 7604
37810, 7582, 7583, 7606, 7605
37811, 7583, 7584, 7607, 7606
37812, 7584, 7585, 7608, 7607
37813, 7585, 988, 989, 7608
37814, 829, 7586, 841, 33
37815, 7586, 7587, 842, 841
37816, 7587, 7588, 843, 842
37817, 7588, 7589, 844, 843
37818, 7589, 7590, 845, 844
37819, 7590, 7591, 846, 845
37820, 7591, 7592, 847, 846
37821, 7592, 7593, 848, 847
37822, 7593, 7594, 849, 848
37823, 7594, 7595, 850, 849
37824, 7595, 7596, 851, 850
37825, 7596, 7597, 852, 851
37826, 7597, 7598, 853, 852
37827, 7598, 7599, 854, 853
37828, 7599, 7600, 855, 854
37829, 7600, 7601, 856, 855
37830, 7601, 7602, 857, 856
37831, 7602, 7603, 858, 857
37832, 7603, 7604, 859, 858
37833, 7604, 7605, 860, 859
37834, 7605, 7606, 861, 860
37835, 7606, 7607, 862, 861
37836, 7607, 7608, 863, 862
37837, 7608, 989, 37, 863
*ELEMENT, type=CPS4, ELSET=Surface45
37838, 36, 830, 7609, 933
37839, 933, 7609, 7610, 934
37840, 934, 7610, 7611, 935
37841, 935, 7611, 7612, 936
37842, 936, 7612, 7613, 937
37843, 937, 7613, 7614, 938
37844, 938, 7614, 7615, 939
37845, 939, 7615, 7616, 940
37846, 940, 7616, 7617, 941
37847, 941, 7617, 7618, 942
37848, 942, 7618, 7619, 943
37849, 943, 7619, 7620, 944
37850, 944, 7620, 7621, 945
37851, 945, 7621, 7622, 946
37852, 946, 7622, 7623, 947
37853, 947, 7623, 7624, 948
37854, 948, 7624, 7625, 949
37855, 949, 7625, 7626, 950
37856, 950, 7626, 7627, 951
37857, 951, 7627, 7628, 952
37858, 952, 7628, 7629, 953
37859, 953, 7629, 7630, 954
37860, 954, 7630, 7631, 955
37861, 955, 7631, 990, 40
37862, 830, 831, 7632, 7609
37863, 7609, 7632, 7633, 7610
37864, 7610, 7633, 7634, 7611
37865, 7611, 7634, 7635, 7612
37866, 7612, 7635, 7636, 7613
37867, 7613, 7636, 7637, 7614
37868, 7614, 7637, 7638, 7615
37869, 7615, 7638, 7639, 7616
37870, 7616, 7639, 7640, 7617
37871, 7617, 7640, 7641, 7618
37872, 7618, 7641, 7642, 7619
37873, 7619, 7642, 7643, 7620
37874, 7620, 7643, 7644, 7621
37875, 7621, 7644, 7645, 7622
37876, 7622, 7645, 7646, 7623
37877, 7623, 7646, 7647, 7624
37878, 7624, 7647, 7648, 7625
37879, 7625, 7648, 7649, 7626
37880, 7626, 7649, 7650, 7627
37881, 7627, 7650, 7651, 7628
37882, 7628, 7651, 7652, 7629
37883, 7629, 7652, 7653, 7630
37884, 7630, 7653, 7654, 7631
37885, 7631, 7654, 991, 990
37886, 831, 832, 7655, 7632
37887, 7632, 7655, 7656, 7633
37888, 7633, 7656, 7657, 7634
37889, 7634, 7657, 7658, 7635
37890, 7635, 7658, 7659, 7636
37891, 7636, 7659, 7660, 7637
37892, 7637, 7660, 7661, 7638
37893, 7638, 7661, 7662, 7639
37894, 7639, 7662, 7663, 7640
37895, 7640, 7663, 7664, 7641
37896, 7641, 7664, 7665, 7642
37897, 7642, 7665, 7666, 7643
37898, 7643, 7666, 7667, 7644
37899, 7644, 7667, 7668, 7645
37900, 7645, 7668, 7669, 7646
37901, 7646, 7669, 7670, 7647
37902, 7647, 7670, 7671, 7648
37903, 7648, 7671, 7672, 7649
37904, 7649, 7672, 7673, 7650
37905, 7650, 7673, 7674, 7651
37906, 7651, 7674, 7675, 7652
37907, 7652, 7675, 7676, 7653
37908, 7653, 7676, 7677, 7654
37909, 7654, 7677, 992, 991
37910, 832, 833, 7678, 7655
37911, 7655, 7678, 7679, 7656
37912, 7656, 7679, 7680, 7657
37913, 7657, 7680, 7681, 7658
37914, 7658, 7681, 7682, 7659
37915, 7659, 7682, 7683, 7660
37916, 7660, 7683, 7684, 7661
37917, 7661, 7684, 7685, 7662
37918, 7662, 7685, 7686, 7663
37919, 7663, 7686, 7687, 7664
37920, 7664, 7687, 7688, 7665
37921, 7665, 7688, 7689, 7666
37922, 7666, 7689, 7690, 7667
37923, 7667, 7690, 7691, 7668
37924, 7668, 7691, 7692, 7669
37925, 7669, 7692, 7693, 7670
37926, 7670, 7693, 7694, 7671
37927, 7671, 7694, 7695, 7672
37928, 7672, 7695, 7696, 7673
37929, 7673, 7696, 7697, 7674
37930, 7674, 7697, 7698, 7675
37931, 7675, 7698, 7699, 7676
37932, 7676, 7699, 7700, 7677
37933, 7677, 7700, 993, 992
37934, 833, 834, 7701, 7678
37935, 7678, 7701, 7702, 7679
37936, 7679, 7702, 7703, 7680
37937, 7680, 7703, 7704, 7681
37938, 7681, 7704, 7705, 7682
37939, 7682, 7705, 7706, 7683
37940, 7683, 7706, 7707, 7684
37941, 7684, 7707, 7708, 7685
37942, 7685, 7708, 7709, 7686
37943, 7686, 7709, 7710, 7687
37944, 7687, 7710, 7711, 7688
37945, 7688, 7711, 7712, 7689
37946, 7689, 7712, 7713, 7690
37947, 7690, 7713, 7714, 7691
37948, 7691, 7714, 7715, 7692
37949, 7692, 7715, 7716, 7693
37950, 7693, 7716, 7717, 7694
37951, 7694, 7717, 7718, 7695
37952, 7695, 7718, 7719, 7696
37953, 7696, 7719, 7720, 7697
37954, 7697, 7720, 7721, 7698
37955, 7698, 7721, 7722, 7699
37956, 7699, 7722, 7723, 7700
37957, 7700, 7723, 994, 993
37958, 834, 835, 7724, 7701
37959, 7701, 7724, 7725, 7702
37960, 7702, 7725, 7726, 7703
37961, 7703, 7726, 7727, 7704
37962, 7704, 7727, 7728, 7705
37963, 7705, 7728, 7729, 7706
37964, 7706, 7729, 7730, 7707
37965, 7707, 7730, 7731, 7708
37966, 7708, 7731, 7732, 7709
37967, 7709, 7732, 7733, 7710
37968, 7710, 7733, 7734, 7711
37969, 7711, 7734, 7735, 7712
37970, 7712, 7735, 7736, 7713
37971, 7713, 7736, 7737, 7714
37972, 7714, 7737, 7738, 7715
37973, 7715, 7738, 7739, 7716
37974, 7716, 7739, 7740, 7717
37975, 7717, 7740, 7741, 7718
37976, 7718, 7741, 7742, 7719
37977, 7719, 7742, 7743, 7720
37978, 7720, 7743, 7744, 7721
37979, 7721, 7744, 7745, 7722
37980, 7722, 7745, 7746, 7723
37981, 7723, 7746, 995, 994
37982, 835, 836, 7747, 7724
37983, 7724, 7747, 7748, 7725
37984, 7725, 7748, 7749, 7726
37985, 7726, 7749, 7750, 7727
37986, 7727, 7750, 7751, 7728
37987, 7728, 7751, 7752, 7729
37988, 7729, 7752, 7753, 7730
37989, 7730, 7753, 7754, 7731
37990, 7731, 7754, 7755, 7732
37991, 7732, 7755, 7756, 7733
37992, 7733, 7756, 7757, 7734
37993, 7734, 7757, 7758, 7735
37994, 7735, 7758, 7759, 7736
37995, 7736, 7759, 7760, 7737
37996, 7737, 7760, 7761, 7738
37997, 7738, 7761, 7762, 7739
37998, 7739, 7762, 7763, 7740
37999, 7740, 7763, 7764, 7741
38000, 7741, 7764, 7765, 7742
38001, 7742, 7765, 7766, 7743
38002, 7743, 7766, 7767, 7744
38003, 7744, 7767, 7768, 7745
38004, 7745, 7768, 7769, 7746
38005, 7746, 7769, 996, 995
38006, 836, 837, 7770, 7747
38007, 7747, 7770, 7771, 7748
38008, 7748, 7771, 7772, 7749
38009, 7749, 7772, 7773, 7750
38010, 7750, 7773, 7774, 7751
38011, 7751, 7774, 7775, 7752
38012, 7752, 7775, 7776, 7753
38013, 7753, 7776, 7777, 7754
38014, 7754, 7777, 7778, 7755
38015, 7755, 7778, 7779, 7756
38016, 7756, 7779, 7780, 7757
38017, 7757, 7780, 7781, 7758
38018, 7758, 7781, 7782, 7759
38019, 7759, 7782, 7783, 7760
38020, 7760, 7783, 7784, 7761
38021, 7761, 7784, 7785, 7762
38022, 7762, 7785, 7786, 7763
38023, 7763, 7786, 7787, 7764
38024, 7764, 7787, 7788, 7765
38025, 7765, 7788, 7789, 7766
38026, 7766, 7789, 7790, 7767
38027, 7767, 7790, 7791, 7768
38028, 7768, 7791, 7792, 7769
38029, 7769, 7792, 997, 996
38030, 837, 838, 7793, 7770
38031, 7770, 7793, 7794, 7771
38032, 7771, 7794, 7795, 7772
38033, 7772, 7795, 7796, 7773
38034, 7773, 7796, 7797, 7774
38035, 7774, 7797, 7798, 7775
38036, 7775, 7798, 7799, 7776
38037, 7776, 7799, 7800, 7777
38038, 7777, 7800, 7801, 7778
38039, 7778, 7801, 7802, 7779
38040, 7779, 7802, 7803, 7780
38041, 7780, 7803, 7804, 7781
38042, 7781, 7804, 7805, 7782
38043, 7782, 7805, 7806, 7783
38044, 7783, 7806, 7807, 7784
38045, 7784, 7807, 7808, 7785
38046, 7785, 7808, 7809, 7786
38047, 7786, 7809, 7810, 7787
38048, 7787, 7810, 7811, 7788
38049, 7788, 7811, 7812, 7789
38050, 7789, 7812, 7813, 7790
38051, 7790, 7813, 7814, 7791
38052, 7791, 7814, 7815, 7792
38053, 7792, 7815, 998, 997
38054, 838, 839, 7816, 7793
38055, 7793, 7816, 7817, 7794
38056, 7794, 7817, 7818, 7795
38057, 7795, 7818, 7819, 7796
38058, 7796, 7819, 7820, 7797
38059, 7797, 7820, 7821, 7798
38060, 7798, 7821, 7822, 7799
38061, 7799, 7822, 7823, 7800
38062, 7800, 7823, 7824, 7801
38063, 7801, 7824, 7825, 7802
38064, 7802, 7825, 7826, 7803
38065, 7803, 7826, 7827, 7804
38066, 7804, 7827, 7828, 7805
38067, 7805, 7828, 7829, 7806
38068, 7806, 7829, 7830, 7807
38069, 7807, 7830, 7831, 7808
38070, 7808, 7831, 7832, 7809
38071, 7809, 7832, 7833, 7810
38072, 7810, 7833, 7834, 7811
38073, 7811, 7834, 7835, 7812
38074, 7812, 7835, 7836, 7813
38075, 7813, 7836, 7837, 7814
38076, 7814, 7837, 7838, 7815
38077, 7815, 7838, 999, 998
38078, 839, 840, 7839, 7816
38079, 7816, 7839, 7840, 7817
38080, 7817, 7840, 7841, 7818
38081, 7818, 7841, 7842, 7819
38082, 7819, 7842, 7843, 7820
38083, 7820, 7843, 7844, 7821
38084, 7821, 7844, 7845, 7822
38085, 7822, 7845, 7846, 7823
38086, 7823, 7846, 7847, 7824
38087, 7824, 7847, 7848, 7825
38088, 7825, 7848, 7849, 7826
38089, 7826, 7849, 7850, 7827
38090, 7827, 7850, 7851, 7828
38091, 7828, 7851, 7852, 7829
38092, 7829, 7852, 7853, 7830
38093, 7830, 7853, 7854, 7831
38094, 7831, 7854, 7855, 7832
38095, 7832, 7855, 7856, 7833
38096, 7833, 7856, 7857, 7834
38097, 7834, 7857, 7858, 7835
38098, 7835, 7858, 7859, 7836
38099, 7836, 7859, 7860, 7837
38100, 7837, 7860, 7861, 7838
38101, 7838, 7861, 1000, 999
38102, 840, 34, 864, 7839
38103, 7839, 864, 865, 7840
38104, 7840, 865, 866, 7841
38105, 7841, 866, 867, 7842
38106, 7842, 867, 868, 7843
38107, 7843, 868, 869, 7844
38108, 7844, 869, 870, 7845
38109, 7845, 870, 871, 7846
38110, 7846, 871, 872, 7847
38111, 7847, 872, 873, 7848
38112, 7848, 873, 874, 7849
38113, 7849, 874, 875, 7850
38114, 7850, 875, 876, 7851
38115, 7851, 876, 877, 7852
38116, 7852, 877, 878, 7853
38117, 7853, 878, 879, 7854
38118, 7854, 879, 880, 7855
38119, 7855, 880, 881, 7856
38120, 7856, 881, 882, 7857
38121, 7857, 882, 883, 7858
38122, 7858, 883, 884, 7859
38123, 7859, 884, 885, 7860
38124, 7860, 885, 886, 7861
38125, 7861, 886, 38, 1000
*ELEMENT, type=CPS4, ELSET=Surface46
38126, 39, 956, 7862, 979
38127, 956, 957, 7863, 7862
38128, 957, 958, 7864, 7863
38129, 958, 959, 7865, 7864
38130, 959, 960, 7866, 7865
38131, 960, 961, 7867, 7866
38132, 961, 962, 7868, 7867
38133, 962, 963, 7869, 7868
38134, 963, 964, 7870, 7869
38135, 964, 965, 7871, 7870
38136, 965, 966, 7872, 7871
38137, 966, 967, 7873, 7872
38138, 967, 968, 7874, 7873
38139, 968, 969, 7875, 7874
38140, 969, 970, 7876, 7875
38141, 970, 971, 7877, 7876
38142, 971, 972, 7878, 7877
38143, 972, 973, 7879, 7878
38144, 973, 974, 7880, 7879
38145, 974, 975, 7881, 7880
38146, 975, 976, 7882, 7881
38147, 976, 977, 7883, 7882
38148, 977, 978, 7884, 7883
38149, 978, 40, 990, 7884
38150, 979, 7862, 7885, 980
38151, 7862, 7863, 7886, 7885
38152, 7863, 7864, 7887, 7886
38153, 7864, 7865, 7888, 7887
38154, 7865, 7866, 7889, 7888
38155, 7866, 7867, 7890, 7889
38156, 7867, 7868, 7891, 7890
38157, 7868, 7869, 7892, 7891
38158, 7869, 7870, 7893, 7892
38159, 7870, 7871, 7894, 7893
38160, 7871, 7872, 7895, 7894
38161, 7872, 7873, 7896, 7895
38162, 7873, 7874, 7897, 7896
38163, 7874, 7875, 7898, 7897
38164, 7875, 7876, 7899, 7898
38165, 7876, 7877, 7900, 7899
38166, 7877, 7878, 7901, 7900
38167, 7878, 7879, 7902, 7901
38168, 7879, 7880, 7903, 7902
38169, 7880, 7881, 7904, 7903
38170, 7881, 7882, 7905, 7904
38171, 7882, 7883, 7906, 7905
38172, 7883, 7884, 7907, 7906
38173, 7884, 990, 991, 7907
38174, 980, 7885, 7908, 981
38175, 7885, 7886, 7909, 7908
38176, 7886, 7887, 7910, 7909
38177, 7887, 7888, 7911, 7910
38178, 7888, 7889, 7912, 7911
38179, 7889, 7890, 7913, 7912
38180, 7890, 7891, 7914, 7913
38181, 7891, 7892, 7915, 7914
38182, 7892, 7893, 7916, 7915
38183, 7893, 7894, 7917, 7916
38184, 7894, 7895, 7918, 7917
38185, 7895, 7896, 7919, 7918
38186, 7896, 7897, 7920, 7919
38187, 7897, 7898, 7921, 7920
38188, 7898, 7899, 7922, 7921
38189, 7899, 7900, 7923, 7922
38190, 7900, 7901, 7924, 7923
38191, 7901, 7902, 7925, 7924
38192, 7902, 7903, 7926, 7925
38193, 7903, 7904, 7927, 7926
38194, 7904, 7905, 7928, 7927
38195, 7905, 7906, 7929, 7928
38196, 7906, 7907, 7930, 7929
38197, 7907, 991, 992, 7930
38198, 981, 7908, 7931, 982
38199, 7908, 7909, 7932, 7931
38200, 7909, 7910, 7933, 7932
38201, 7910, 7911, 7934, 7933
38202, 7911, 7912, 7935, 7934
38203, 7912, 7913, 7936, 7935
38204, 7913, 7914, 7937, 7936
38205, 7914, 7915, 7938, 7937
38206, 7915, 7916, 7939, 7938
38207, 7916, 7917, 7940, 7939
38208, 7917, 7918, 7941, 7940
38209, 7918, 7919, 7942, 7941
38210, 7919, 7920, 7943, 7942
38211, 7920, 7921, 7944, 7943
38212, 7921, 7922, 7945, 7944
38213, 7922, 7923, 7946, 7945
38214, 7923, 7924, 7947, 7946
38215, 7924, 7925, 7948, 7947
38216, 7925, 7926, 7949, 7948
38217, 7926, 7927, 7950, 7949
38218, 7927, 7928, 7951, 7950
38219, 7928, 7929, 7952, 7951
38220, 7929, 7930, 7953, 7952
38221, 7930, 992, 993, 7953
38222, 982, 7931, 7954, 983
38223, 7931, 7932, 7955, 7954
38224, 7932, 7933, 7956, 7955
38225, 7933, 7934, 7957, 7956
38226, 7934, 7935, 7958, 7957
38227, 7935, 7936, 7959, 7958
38228, 7936, 7937, 7960, 7959
38229, 7937, 7938, 7961, 7960
38230, 7938, 7939, 7962, 7961
38231, 7939, 7940, 7963, 7962
38232, 7940, 7941, 7964, 7963
38233, 7941, 7942, 7965, 7964
38234, 7942, 7943, 7966, 7965
38235, 7943, 7944, 7967, 7966
38236, 7944, 7945, 7968, 7967
38237, 7945, 7946, 7969, 7968
38238, 7946, 7947, 7970, 7969
38239, 7947, 7948, 7971, 7970
38240, 7948, 7949, 7972, 7971
38241, 7949, 7950, 7973, 7972
38242, 7950, 7951, 7974, 7973
38243, 7951, 7952, 7975, 7974
38244, 7952, 7953, 7976, 7975
38245, 7953, 993, 994, 7976
38246, 983, 7954, 7977, 984
38247, 7954, 7955, 7978, 7977
38248, 7955, 7956, 7979, 7978
38249, 7956, 7957, 7980, 7979
38250, 7957, 7958, 7981, 7980
38251, 7958, 7959, 7982, 7981
38252, 7959, 7960, 7983, 7982
38253, 7960, 7961, 7984, 7983
38254, 7961, 7962, 7985, 7984
38255, 7962, 7963, 7986, 7985
38256, 7963, 7964, 7987, 7986
38257, 7964, 7965, 7988, 7987
38258, 7965, 7966, 7989, 7988
38259, 7966, 7967, 7990, 7989
38260, 7967, 7968, 7991, 7990
38261, 7968, 7969, 7992, 7991
38262, 7969, 7970, 7993, 7992
38263, 7970, 7971, 7994, 7993
38264, 7971, 7972, 7995, 7994
38265, 7972, 7973, 7996, 7995
38266, 7973, 7974, 7997, 7996
38267, 7974, 7975, 7998, 7997
38268, 7975, 7976, 7999, 7998
38269, 7976, 994, 995, 7999
38270, 984, 7977, 8000, 985
38271, 7977, 7978, 8001, 8000
38272, 7978, 7979, 8002, 8001
38273, 7979, 7980, 8003, 8002
38274, 7980, 7981, 8004, 8003
38275, 7981, 7982, 8005, 8004
38276, 7982, 7983, 8006, 8005
38277, 7983, 7984, 8007, 8006
38278, 7984, 7985, 8008, 8007
38279, 7985, 7986, 8009, 8008
38280, 7986, 7987, 8010, 8009
38281, 7987, 7988, 8011, 8010
38282, 7988, 7989, 8012, 8011
38283, 7989, 7990, 8013, 8012
38284, 7990, 7991, 8014, 8013
38285, 7991, 7992, 8015, 8014
38286, 7992, 7993, 8016, 8015
38287, 7993, 7994, 8017, 8016
38288, 7994, 7995, 8018, 8017
38289, 7995, 7996, 8019, 8018
38290, 7996, 7997, 8020, 8019
38291, 7997, 7998, 8021, 8020
38292, 7998, 7999, 8022, 8021
38293, 7999, 995, 996, 8022
38294, 985, 8000, 8023, 986
38295, 8000, 8001, 8024, 8023
38296, 8001, 8002, 8025, 8024
38297, 8002, 8003, 8026, 8025
38298, 8003, 8004, 8027, 8026
38299, 8004, 8005, 8028, 8027
38300, 8005, 8006, 8029, 8028
38301, 8006, 8007, 8030, 8029
38302, 8007, 8008, 8031, 8030
38303, 8008, 8009, 8032, 8031
38304, 8009, 8010, 8033, 8032
38305, 8010, 8011, 8034, 8033
38306, 8011, 8012, 8035, 8034
38307, 8012, 8013, 8036, 8035
38308, 8013, 8014, 8037, 8036
38309, 8014, 8015, 8038, 8037
38310, 8015, 8016, 8039, 8038
38311, 8016, 8017, 8040, 8039
38312, 8017, 8018, 8041, 8040
38313, 8018, 8019, 8042, 8041
38314, 8019, 8020, 8043, 8042
38315, 8020, 8021, 8044, 8043
38316, 8021, 8022, 8045, 8044
38317, 8022, 996, 997, 8045
38318, 986, 8023, 8046, 987
38319, 8023, 8024, 8047, 8046
38320, 8024, 8025, 8048, 8047
38321, 8025, 8026, 8049, 8048
38322, 8026, 8027, 8050, 8049
38323, 8027, 8028, 8051, 8050
38324, 8028, 8029, 8052, 8051
38325, 8029, 8030, 8053, 8052
38326, 8030, 8031, 8054, 8053
38327, 8031, 8032, 8055, 8054
38328, 8032, 8033, 8056, 8055
38329, 8033, 8034, 8057, 8056
38330, 8034, 8035, 8058, 8057
38331, 8035, 8036, 8059, 8058
38332, 8036, 8037, 8060, 8059
38333, 8037, 8038, 8061, 8060
38334, 8038, 8039, 8062, 8061
38335, 8039, 8040, 8063, 8062
38336, 8040, 8041, 8064, 8063
38337, 8041, 8042, 8065, 8064
38338, 8042, 8043, 8066, 8065
38339, 8043, 8044, 8067, 8066
38340, 8044, 8045, 8068, 8067
38341, 8045, 997, 998, 8068
38342, 987, 8046, 8069, 988
38343, 8046, 8047, 8070, 8069
38344, 8047, 8048, 8071, 8070
38345, 8048, 8049, 8072, 8071
38346, 8049, 8050, 8073, 8072
38347, 8050, 8051, 8074, 8073
38348, 8051, 8052, 8075, 8074
38349, 8052, 8053, 8076, 8075
38350, 8053, 8054, 8077, 8076
38351, 8054, 8055, 8078, 8077
38352, 8055, 8056, 8079, 8078
38353, 8056, 8057, 8080, 8079
38354, 8057, 8058, 8081, 8080
38355, 8058, 8059, 8082, 8081
38356, 8059, 8060, 8083, 8082
38357, 8060, 8061, 8084, 8083
38358, 8061, 8062, 8085, 8084
38359, 8062, 8063, 8086, 8085
38360, 8063, 8064, 8087, 8086
38361, 8064, 8065, 8088, 8087
38362, 8065, 8066, 8089, 8088
38363, 8066, 8067, 8090, 8089
38364, 8067, 8068, 8091, 8090
38365, 8068, 998, 999, 8091
38366, 988, 8069, 8092, 989
38367, 8069, 8070, 8093, 8092
38368, 8070, 8071, 8094, 8093
38369, 8071, 8072, 8095, 8094
38370, 8072, 8073, 8096, 8095
38371, 8073, 8074, 8097, 8096
38372, 8074, 8075, 8098, 8097
38373, 8075, 8076, 8099, 8098
38374, 8076, 8077, 8100, 8099
38375, 8077, 8078, 8101, 8100
38376, 8078, 8079, 8102, 8101
38377, 8079, 8080, 8103, 8102
38378, 8080, 8081, 8104, 8103
38379, 8081, 8082, 8105, 8104
38380, 8082, 8083, 8106, 8105
38381, 8083, 8084, 8107, 8106
38382, 8084, 8085, 8108, 8107
38383, 8085, 8086, 8109, 8108
38384, 8086, 8087, 8110, 8109
38385, 8087, 8088, 8111, 8110
38386, 8088, 8089, 8112, 8111
38387, 8089, 8090, 8113, 8112
38388, 8090, 8091, 8114, 8113
38389, 8091, 999, 1000, 8114
38390, 989, 8092, 887, 37
38391, 8092, 8093, 888, 887
38392, 8093, 8094, 889, 888
38393, 8094, 8095, 890, 889
38394, 8095, 8096, 891, 890
38395, 8096, 8097, 892, 891
38396, 8097, 8098, 893, 892
38397, 8098, 8099, 894, 893
38398, 8099, 8100, 895, 894
38399, 8100, 8101, 896, 895
38400, 8101, 8102, 897, 896
38401, 8102, 8103, 898, 897
38402, 8103, 8104, 899, 898
38403, 8104, 8105, 900, 899
38404, 8105, 8106, 901, 900
38405, 8106, 8107, 902, 901
38406, 8107, 8108, 903, 902
38407, 8108, 8109, 904, 903
38408, 8109, 8110, 905, 904
38409, 8110, 8111, 906, 905
38410, 8111, 8112, 907, 906
38411, 8112, 8113, 908, 907
38412, 8113, 8114, 909, 908
38413, 8114, 1000, 38, 909
*ELEMENT, type=CPS4, ELSET=Surface47
3101, 37, 41, 1001, 887
3102, 887, 1001, 1002, 888
3103, 888, 1002, 1003, 889
3104, 889, 1003, 1004, 890
3105, 890, 1004, 1005, 891
3106, 891, 1005, 1006, 892
3107, 892, 1006, 1007, 893
3108, 893, 1007, 1008, 894
3109, 894, 1008, 1009, 895
3110, 895, 1009, 1010, 896
3111, 896, 1010, 1011, 897
3112, 897, 1011, 1012, 898
3113, 898, 1012, 1013, 899
3114, 899, 1013, 1014, 900
3115, 900, 1014, 1015, 901
3116, 901, 1015, 1016, 902
3117, 902, 1016, 1017, 903
3118, 903, 1017, 1018, 904
3119, 904, 1018, 1019, 905
3120, 905, 1019, 1020, 906
3121, 906, 1020, 1021, 907
3122, 907, 1021, 1022, 908
3123, 908, 1022, 1023, 909
3124, 909, 1023, 42, 38
*ELEMENT, type=CPS4, ELSET=Surface48
38414, 39, 956, 1024, 43
38415, 956, 957, 1025, 1024
38416, 957, 958, 1026, 1025
38417, 958, 959, 1027, 1026
38418, 959, 960, 1028, 1027
38419, 960, 961, 1029, 1028
38420, 961, 962, 1030, 1029
38421, 962, 963, 1031, 1030
38422, 963, 964, 1032, 1031
38423, 964, 965, 1033, 1032
38424, 965, 966, 1034, 1033
38425, 966, 967, 1035, 1034
38426, 967, 968, 1036, 1035
38427, 968, 969, 1037, 1036
38428, 969, 970, 1038, 1037
38429, 970, 971, 1039, 1038
38430, 971, 972, 1040, 1039
38431, 972, 973, 1041, 1040
38432, 973, 974, 1042, 1041
38433, 974, 975, 1043, 1042
38434, 975, 976, 1044, 1043
38435, 976, 977, 1045, 1044
38436, 977, 978, 1046, 1045
38437, 978, 40, 44, 1046
*ELEMENT, type=CPS4, ELSET=Surface49
38438, 39, 43, 1047, 979
38439, 979, 1047, 1048, 980
38440, 980, 1048, 1049, 981
38441, 981, 1049, 1050, 982
38442, 982, 1050, 1051, 983
38443, 983, 1051, 1052, 984
38444, 984, 1052, 1053, 985
38445, 985, 1053, 1054, 986
38446, 986, 1054, 1055, 987
38447, 987, 1055, 1056, 988
38448, 988, 1056, 1057, 989
38449, 989, 1057, 41, 37
*ELEMENT, type=CPS4, ELSET=Surface50
38450, 40, 990, 1058, 44
38451, 990, 991, 1059, 1058
38452, 991, 992, 1060, 1059
38453, 992, 993, 1061, 1060
38454, 993, 994, 1062, 1061
38455, 994, 995, 1063, 1062
38456, 995, 996, 1064, 1063
38457, 996, 997, 1065, 1064
38458, 997, 998, 1066, 1065
38459, 998, 999, 1067, 1066
38460, 999, 1000, 1068, 1067
38461, 1000, 38, 42, 1068
*ELEMENT, type=CPS4, ELSET=Surface51
38462, 43, 1024, 8115, 1047
38463, 1024, 1025, 8116, 8115
38464, 1025, 1026, 8117, 8116
38465, 1026, 1027, 8118, 8117
38466, 1027, 1028, 8119, 8118
38467, 1028, 1029, 8120, 8119
38468, 1029, 1030, 8121, 8120
38469, 1030, 1031, 8122, 8121
38470, 1031, 1032, 8123, 8122
38471, 1032, 1033, 8124, 8123
38472, 1033, 1034, 8125, 8124
38473, 1034, 1035, 8126, 8125
38474, 1035, 1036, 8127, 8126
38475, 1036, 1037, 8128, 8127
38476, 1037, 1038, 8129, 8128
38477, 1038, 1039, 8130, 8129
38478, 1039, 1040, 8131, 8130
38479, 1040, 1041, 8132, 8131
38480, 1041, 1042, 8133, 8132
38481, 1042, 1043, 8134, 8133
38482, 1043, 1044, 8135, 8134
38483, 1044, 1045, 8136, 8135
38484, 1045, 1046, 8137, 8136
38485, 1046, 44, 1058, 8137
38486, 1047, 8115, 8138, 1048
38487, 8115, 8116, 8139, 8138
38488, 8116, 8117, 8140, 8139
38489, 8117, 8118, 8141, 8140
38490, 8118, 8119, 8142, 8141
38491, 8119, 8120, 8143, 8142
38492, 8120, 8121, 8144, 8143
38493, 8121, 8122, 8145, 8144
38494, 8122, 8123, 8146, 8145
38495, 8123, 8124, 8147, 8146
38496, 8124, 8125, 8148, 8147
38497, 8125, 8126, 8149, 8148
38498, 8126, 8127, 8150, 8149
38499, 8127, 8128, 8151, 8150
38500, 8128, 8129, 8152, 8151
38501, 8129, 8130, 8153, 8152
38502, 8130, 8131, 8154, 8153
38503, 8131, 8132, 8155, 8154
38504, 8132, 8133, 8156, 8155
38505, 8133, 8134, 8157, 8156
38506, 8134, 8135, 8158, 8157
38507, 8135, 8136, 8159, 8158
38508, 8136, 8137, 8160, 8159
38509, 8137, 1058, 1059, 8160
38510, 1048, 8138, 8161, 1049
38511, 8138, 8139, 8162, 8161
38512, 8139, 8140, 8163, 8162
38513, 8140, 8141, 8164, 8163
38514, 8141, 8142, 8165, 8164
38515, 8142, 8143, 8166, 8165
38516, 8143, 8144, 8167, 8166
38517, 8144, 8145, 8168, 8167
38518, 8145, 8146, 8169, 8168
38519, 8146, 8147, 8170, 8169
38520, 8147, 8148, 8171, 8170
38521, 8148, 8149, 8172, 8171
38522, 8149, 8150, 8173, 8172
38523, 8150, 8151, 8174, 8173
38524, 8151, 8152, 8175, 8174
38525, 8152, 8153, 8176, 8175
38526, 8153, 8154, 8177, 8176
38527, 8154, 8155, 8178, 8177
38528, 8155, 8156, 8179, 8178
38529, 8156, 8157, 8180, 8179
38530, 8157, 8158, 8181, 8180
38531, 8158, 8159, 8182, 8181
38532, 8159, 8160, 8183, 8182
38533, 8160, 1059, 1060, 8183
38534, 1049, 8161, 8184, 1050
38535, 8161, 8162, 8185, 8184
38536, 8162, 8163, 8186, 8185
38537, 8163, 8164, 8187, 8186
38538, 8164, 8165, 8188, 8187
38539, 8165, 8166, 8189, 8188
38540, 8166, 8167, 8190, 8189
38541, 8167, 8168, 8191, 8190
38542, 8168, 8169, 8192, 8191
38543, 8169, 8170, 8193, 8192
38544, 8170, 8171, 8194, 8193
38545, 8171, 8172, 8195, 8194
38546, 8172, 8173, 8196, 8195
38547, 8173, 8174, 8197, 8196
38548, 8174, 8175, 8198, 8197
38549, 8175, 8176, 8199, 8198
38550, 8176, 8177, 8200, 8199
38551, 8177, 8178, 8201, 8200
38552, 8178, 8179, 8202, 8201
38553, 8179, 8180, 8203, 8202
38554, 8180, 8181, 8204, 8203
38555, 8181, 8182, 8205, 8204
38556, 8182, 8183, 8206, 8205
38557, 8183, 1060, 1061, 8206
38558, 1050, 8184, 8207, 1051
38559, 8184, 8185, 8208, 8207
38560, 8185, 8186, 8209, 8208
38561, 8186, 8187, 8210, 8209
38562, 8187, 8188, 8211, 8210
38563, 8188, 8189, 8212, 8211
38564, 8189, 8190, 8213, 8212
38565, 8190, 8191, 8214, 8213
38566, 8191, 8192, 8215, 8214
38567, 8192, 8193, 8216, 8215
38568, 8193, 8194, 8217, 8216
38569, 8194, 8195, 8218, 8217
38570, 8195, 8196, 8219, 8218
38571, 8196, 8197, 8220, 8219
38572, 8197, 8198, 8221, 8220
38573, 8198, 8199, 8222, 8221
38574, 8199, 8200, 8223, 8222
38575, 8200, 8201, 8224, 8223
38576, 8201, 8202, 8225, 8224
38577, 8202, 8203, 8226, 8225
38578, 8203, 8204, 8227, 8226
38579, 8204, 8205, 8228, 8227
38580, 8205, 8206, 8229, 8228
38581, 8206, 1061, 1062, 8229
38582, 1051, 8207, 8230, 1052
38583, 8207, 8208, 8231, 8230
38584, 8208, 8209, 8232, 8231
38585, 8209, 8210, 8233, 8232
38586, 8210, 8211, 8234, 8233
38587, 8211, 8212, 8235, 8234
38588, 8212, 8213, 8236, 8235
38589, 8213, 8214, 8237, 8236
38590, 8214, 8215, 8238, 8237
38591, 8215, 8216, 8239, 8238
38592, 8216, 8217, 8240, 8239
38593, 8217, 8218, 8241, 8240
38594, 8218, 8219, 8242, 8241
38595, 8219, 8220, 8243, 8242
38596, 8220, 8221, 8244, 8243
38597, 8221, 8222, 8245, 8244
38598, 8222, 8223, 8246, 8245
38599, 8223, 8224, 8247, 8246
38600, 8224, 8225, 8248, 8247
38601, 8225, 8226, 8249, 8248
38602, 8226, 8227, 8250, 8249
38603, 8227, 8228, 8251, 8250
38604, 8228, 8229, 8252, 8251
38605, 8229, 1062, 1063, 8252
38606, 1052, 8230, 8253, 1053
38607, 8230, 8231, 8254, 8253
38608, 8231, 8232, 8255, 8254
38609, 8232, 8233, 8256, 8255
38610, 8233, 8234, 8257, 8256
38611, 8234, 8235, 8258, 8257
38612, 8235, 8236, 8259, 8258
38613, 8236, 8237, 8260, 8259
38614, 8237, 8238, 8261, 8260
38615, 8238, 8239, 8262, 8261
38616, 8239, 8240, 8263, 8262
38617, 8240, 8241, 8264, 8263
38618, 8241, 8242, 8265, 8264
38619, 8242, 8243, 8266, 8265
38620, 8243, 8244, 8267, 8266
38621, 8244, 8245, 8268, 8267
38622, 8245, 8246, 8269, 8268
38623, 8246, 8247, 8270, 8269
38624, 8247, 8248, 8271, 8270
38625, 8248, 8249, 8272, 8271
38626, 8249, 8250, 8273, 8272
38627, 8250, 8251, 8274, 8273
38628, 8251, 8252, 8275, 8274
38629, 8252, 1063, 1064, 8275
38630, 1053, 8253, 8276, 1054
38631, 8253, 8254, 8277, 8276
38632, 8254, 8255, 8278, 8277
38633, 8255, 8256, 8279, 8278
38634, 8256, 8257, 8280, 8279
38635, 8257, 8258, 8281, 8280
38636, 8258, 8259, 8282, 8281
38637, 8259, 8260, 8283, 8282
38638, 8260, 8261, 8284, 8283
38639, 8261, 8262, 8285, 8284
38640, 8262, 8263, 8286, 8285
38641, 8263, 8264, 8287, 8286
38642, 8264, 8265, 8288, 8287
38643, 8265, 8266, 8289, 8288
38644, 8266, 8267, 8290, 8289
38645, 8267, 8268, 8291, 8290
38646, 8268, 8269, 8292, 8291
38647, 8269, 8270, 8293, 8292
38648, 8270, 8271, 8294, 8293
38649, 8271, 8272, 8295, 8294
38650, 8272, 8273, 8296, 8295
38651, 8273, 8274, 8297, 8296
38652, 8274, 8275, 8298, 8297
38653, 8275, 1064, 1065, 8298
38654, 1054, 8276, 8299, 1055
38655, 8276, 8277, 8300, 8299
38656, 8277, 8278, 8301, 8300
38657, 8278, 8279, 8302, 8301
38658, 8279, 8280, 8303, 8302
38659, 8280, 8281, 8304, 8303
38660, 8281, 8282, 8305, 8304
38661, 8282, 8283, 8306, 8305
38662, 8283, 8284, 8307, 8306
38663, 8284, 8285, 8308, 8307
38664, 8285, 8286, 8309, 8308
38665, 8286, 8287, 8310, 8309
38666, 8287, 8288, 8311, 8310
38667, 8288, 8289, 8312, 8311
38668, 8289, 8290, 8313, 8312
38669, 8290, 8291, 8314, 8313
38670, 8291, 8292, 8315, 8314
38671, 8292, 8293, 8316, 8315
38672, 8293, 8294, 8317, 8316
38673, 8294, 8295, 8318, 8317
38674, 8295, 8296, 8319, 8318
38675, 8296, 8297, 8320, 8319
38676, 8297, 8298, 8321, 8320
38677, 8298, 1065, 1066, 8321
38678, 1055, 8299, 8322, 1056
38679, 8299, 8300, 8323, 8322
38680, 8300, 8301, 8324, 8323
38681, 8301, 8302, 8325, 8324
38682, 8302, 8303, 8326, 8325
38683, 8303, 8304, 8327, 8326
38684, 8304, 8305, 8328, 8327
38685, 8305, 8306, 8329, 8328
38686, 8306, 8307, 8330, 8329
38687, 8307, 8308, 8331, 8330
38688, 8308, 8309, 8332, 8331
38689, 8309, 8310, 8333, 8332
38690, 8310, 8311, 8334, 8333
38691, 8311, 8312, 8335, 8334
38692, 8312, 8313, 8336, 8335
38693, 8313, 8314, 8337, 8336
38694, 8314, 8315, 8338, 8337
38695, 8315, 8316, 8339, 8338
38696, 8316, 8317, 8340, 8339
38697, 8317, 8318, 8341, 8340
38698, 8318, 8319, 8342, 8341
38699, 8319, 8320, 8343, 8342
38700, 8320, 8321, 8344, 8343
38701, 8321, 1066, 1067, 8344
38702, 1056, 8322, 8345, 1057
38703, 8322, 8323, 8346, 8345
38704, 8323, 8324, 8347, 8346
38705, 8324, 8325, 8348, 8347
38706, 8325, 8326, 8349, 8348
38707, 8326, 8327, 8350, 8349
38708, 8327, 8328, 8351, 8350
38709, 8328, 8329, 8352, 8351
38710, 8329, 8330, 8353, 8352
38711, 8330, 8331, 8354, 8353
38712, 8331, 8332, 8355, 8354
38713, 8332, 8333, 8356, 8355
38714, 8333, 8334, 8357, 8356
38715, 8334, 8335, 8358, 8357
38716, 8335, 8336, 8359, 8358
38717, 8336, 8337, 8360, 8359
38718, 8337, 8338, 8361, 8360
38719, 8338, 8339, 8362, 8361
38720, 8339, 8340, 8363, 8362
38721, 8340, 8341, 8364, 8363
38722, 8341, 8342, 8365, 8364
38723, 8342, 8343, 8366, 8365
38724, 8343, 8344, 8367, 8366
38725, 8344, 1067, 1068, 8367
38726, 1057, 8345, 1001, 41
38727, 8345, 8346, 1002, 1001
38728, 8346, 8347, 1003, 1002
38729, 8347, 8348, 1004, 1003
38730, 8348, 8349, 1005, 1004
38731, 8349, 8350, 1006, 1005
38732, 8350, 8351, 1007, 1006
38733, 8351, 8352, 1008, 1007
38734, 8352, 8353, 1009, 1008
38735, 8353, 8354, 1010, 1009
38736, 8354, 8355, 1011, 1010
38737, 8355, 8356, 1012, 1011
38738, 8356, 8357, 1013, 1012
38739, 8357, 8358, 1014, 1013
38740, 8358, 8359, 1015, 1014
38741, 8359, 8360, 1016, 1015
38742, 8360, 8361, 1017, 1016
38743, 8361, 8362, 1018, 1017
38744, 8362, 8363, 1019, 1018
38745, 8363, 8364, 1020, 1019
38746, 8364, 8365, 1021, 1020
38747, 8365, 8366, 1022, 1021
38748, 8366, 8367, 1023, 1022
38749, 8367, 1068, 42, 1023
*ELEMENT, type=CPS4, ELSET=Surface52
3125, 41, 1069, 8368, 1001
3126, 1069, 1070, 8369, 8368
3127, 1070, 45, 1073, 8369
3128, 1001, 8368, 8370, 1002
3129, 8368, 8369, 8371, 8370
3130, 8369, 1073, 1074, 8371
3131, 1002, 8370, 8372, 1003
3132, 8370, 8371, 8373, 8372
3133, 8371, 1074, 1075, 8373
3134, 1003, 8372, 8374, 1004
3135, 8372, 8373, 8375, 8374
3136, 8373, 1075, 1076, 8375
3137, 1004, 8374, 8376, 1005
3138, 8374, 8375, 8377, 8376
3139, 8375, 1076, 1077, 8377
3140, 1005, 8376, 8378, 1006
3141, 8376, 8377, 8379, 8378
3142, 8377, 1077, 1078, 8379
3143, 1006, 8378, 8380, 1007
3144, 8378, 8379, 8381, 8380
3145, 8379, 1078, 1079, 8381
3146, 1007, 8380, 8382, 1008
3147, 8380, 8381, 8383, 8382
3148, 8381, 1079, 1080, 8383
3149, 1008, 8382, 8384, 1009
3150, 8382, 8383, 8385, 8384
3151, 8383, 1080, 1081, 8385
3152, 1009, 8384, 8386, 1010
3153, 8384, 8385, 8387, 8386
3154, 8385, 1081, 1082, 8387
3155, 1010, 8386, 8388, 1011
3156, 8386, 8387, 8389, 8388
3157, 8387, 1082, 1083, 8389
3158, 1011, 8388, 8390, 1012
3159, 8388, 8389, 8391, 8390
3160, 8389, 1083, 1084, 8391
3161, 1012, 8390, 8392, 1013
3162, 8390, 8391, 8393, 8392
3163, 8391, 1084, 1085, 8393
3164, 1013, 8392, 8394, 1014
3165, 8392, 8393, 8395, 8394
3166, 8393, 1085, 1086, 8395
3167, 1014, 8394, 8396, 1015
3168, 8394, 8395, 8397, 8396
3169, 8395, 1086, 1087, 8397
3170, 1015, 8396, 8398, 1016
3171, 8396, 8397, 8399, 8398
3172, 8397, 1087, 1088, 8399
3173, 1016, 8398, 8400, 1017
3174, 8398, 8399, 8401, 8400
3175, 8399, 1088, 1089, 8401
3176, 1017, 8400, 8402, 1018
3177, 8400, 8401, 8403, 8402
3178, 8401, 1089, 1090, 8403
3179, 1018, 8402, 8404, 1019
3180, 8402, 8403, 8405, 8404
3181, 8403, 1090, 1091, 8405
3182, 1019, 8404, 8406, 1020
3183, 8404, 8405, 8407, 8406
3184, 8405, 1091, 1092, 8407
3185, 1020, 8406, 8408, 1021
3186, 8406, 8407, 8409, 8408
3187, 8407, 1092, 1093, 8409
3188, 1021, 8408, 8410, 1022
3189, 8408, 8409, 8411, 8410
3190, 8409, 1093, 1094, 8411
3191, 1022, 8410, 8412, 1023
3192, 8410, 8411, 8413, 8412
3193, 8411, 1094, 1095, 8413
3194, 1023, 8412, 1071, 42
3195, 8412, 8413, 1072, 1071
3196, 8413, 1095, 46, 1072
*ELEMENT, type=CPS4, ELSET=Surface53
38750, 43, 1024, 8414, 1096
38751, 1096, 8414, 8415, 1097
38752, 1097, 8415, 1100, 47
38753, 1024, 1025, 8416, 8414
38754, 8414, 8416, 8417, 8415
38755, 8415, 8417, 1101, 1100
38756, 1025, 1026, 8418, 8416
38757, 8416, 8418, 8419, 8417
38758, 8417, 8419, 1102, 1101
38759, 1026, 1027, 8420, 8418
38760, 8418, 8420, 8421, 8419
38761, 8419, 8421, 1103, 1102
38762, 1027, 1028, 8422, 8420
38763, 8420, 8422, 8423, 8421
38764, 8421, 8423, 1104, 1103
38765, 1028, 1029, 8424, 8422
38766, 8422, 8424, 8425, 8423
38767, 8423, 8425, 1105, 1104
38768, 1029, 1030, 8426, 8424
38769, 8424, 8426, 8427, 8425
38770, 8425, 8427, 1106, 1105
38771, 1030, 1031, 8428, 8426
38772, 8426, 8428, 8429, 8427
38773, 8427, 8429, 1107, 1106
38774, 1031, 1032, 8430, 8428
38775, 8428, 8430, 8431, 8429
38776, 8429, 8431, 1108, 1107
38777, 1032, 1033, 8432, 8430
38778, 8430, 8432, 8433, 8431
38779, 8431, 8433, 1109, 1108
38780, 1033, 1034, 8434, 8432
38781, 8432, 8434, 8435, 8433
38782, 8433, 8435, 1110, 1109
38783, 1034, 1035, 8436, 8434
38784, 8434, 8436, 8437, 8435
38785, 8435, 8437, 1111, 1110
38786, 1035, 1036, 8438, 8436
38787, 8436, 8438, 8439, 8437
38788, 8437, 8439, 1112, 1111
38789, 1036, 1037, 8440, 8438
38790, 8438, 8440, 8441, 8439
38791, 8439, 8441, 1113, 1112
38792, 1037, 1038, 8442, 8440
38793, 8440, 8442, 8443, 8441
38794, 8441, 8443, 1114, 1113
38795, 1038, 1039, 8444, 8442
38796, 8442, 8444, 8445, 8443
38797, 8443, 8445, 1115, 1114
38798, 1039, 1040, 8446, 8444
38799, 8444, 8446, 8447, 8445
38800, 8445, 8447, 1116, 1115
38801, 1040, 1041, 8448, 8446
38802, 8446, 8448, 8449, 8447
38803, 8447, 8449, 1117, 1116
38804, 1041, 1042, 8450, 8448
38805, 8448, 8450, 8451, 8449
38806, 8449, 8451, 1118, 1117
38807, 1042, 1043, 8452, 8450
38808, 8450, 8452, 8453, 8451
38809, 8451, 8453, 1119, 1118
38810, 1043, 1044, 8454, 8452
38811, 8452, 8454, 8455, 8453
38812, 8453, 8455, 1120, 1119
38813, 1044, 1045, 8456, 8454
38814, 8454, 8456, 8457, 8455
38815, 8455, 8457, 1121, 1120
38816, 1045, 1046, 8458, 8456
38817, 8456, 8458, 8459, 8457
38818, 8457, 8459, 1122, 1121
38819, 1046, 44, 1098, 8458
38820, 8458, 1098, 1099, 8459
38821, 8459, 1099, 48, 1122
*ELEMENT, type=CPS4, ELSET=Surface54
38822, 43, 1096, 8460, 1047
38823, 1096, 1097, 8461, 8460
38824, 1097, 47, 1123, 8461
38825, 1047, 8460, 8462, 1048
38826, 8460, 8461, 8463, 8462
38827, 8461, 1123, 1124, 8463
38828, 1048, 8462, 8464, 1049
38829, 8462, 8463, 8465, 8464
38830, 8463, 1124, 1125, 8465
38831, 1049, 8464, 8466, 1050
38832, 8464, 8465, 8467, 8466
38833, 8465, 1125, 1126, 8467
38834, 1050, 8466, 8468, 1051
38835, 8466, 8467, 8469, 8468
38836, 8467, 1126, 1127, 8469
38837, 1051, 8468, 8470, 1052
38838, 8468, 8469, 8471, 8470
38839, 8469, 1127, 1128, 8471
38840, 1052, 8470, 8472, 1053
38841, 8470, 8471, 8473, 8472
38842, 8471, 1128, 1129, 8473
38843, 1053, 8472, 8474, 1054
38844, 8472, 8473, 8475, 8474
38845, 8473, 1129, 1130, 8475
38846, 1054, 8474, 8476, 1055
38847, 8474, 8475, 8477, 8476
38848, 8475, 1130, 1131, 8477
38849, 1055, 8476, 8478, 1056
38850, 8476, 8477, 8479, 8478
38851, 8477, 1131, 1132, 8479
38852, 1056, 8478, 8480, 1057
38853, 8478, 8479, 8481, 8480
38854, 8479, 1132, 1133, 8481
38855, 1057, 8480, 1069, 41
38856, 8480, 8481, 1070, 1069
38857, 8481, 1133, 45, 1070
*ELEMENT, type=CPS4, ELSET=Surface55
38858, 44, 1058, 8482, 1098
38859, 1098, 8482, 8483, 1099
38860, 1099, 8483, 1134, 48
38861, 1058, 1059, 8484, 8482
38862, 8482, 8484, 8485, 8483
38863, 8483, 8485, 1135, 1134
38864, 1059, 1060, 8486, 8484
38865, 8484, 8486, 8487, 8485
38866, 8485, 8487, 1136, 1135
38867, 1060, 1061, 8488, 8486
38868, 8486, 8488, 8489, 8487
38869, 8487, 8489, 1137, 1136
38870, 1061, 1062, 8490, 8488
38871, 8488, 8490, 8491, 8489
38872, 8489, 8491, 1138, 1137
38873, 1062, 1063, 8492, 8490
38874, 8490, 8492, 8493, 8491
38875, 8491, 8493, 1139, 1138
38876, 1063, 1064, 8494, 8492
38877, 8492, 8494, 8495, 8493
38878, 8493, 8495, 1140, 1139
38879, 1064, 1065, 8496, 8494
38880, 8494, 8496, 8497, 8495
38881, 8495, 8497, 1141, 1140
38882, 1065, 1066, 8498, 8496
38883, 8496, 8498, 8499, 8497
38884, 8497, 8499, 1142, 1141
38885, 1066, 1067, 8500, 8498
38886, 8498, 8500, 8501, 8499
38887, 8499, 8501, 1143, 1142
38888, 1067, 1068, 8502, 8500
38889, 8500, 8502, 8503, 8501
38890, 8501, 8503, 1144, 1143
38891, 1068, 42, 1071, 8502
38892, 8502, 1071, 1072, 8503
38893, 8503, 1072, 46, 1144
*ELEMENT, type=CPS4, ELSET=Surface56
3197, 47, 1100, 8504, 1123
3198, 1100, 1101, 8505, 8504
3199, 1101, 1102, 8506, 8505
3200, 1102, 1103, 8507, 8506
3201, 1103, 1104, 8508, 8507
3202, 1104, 1105, 8509, 8508
3203, 1105, 1106, 8510, 8509
3204, 1106, 1107, 8511, 8510
3205, 1107, 1108, 8512, 8511
3206, 1108, 1109, 8513, 8512
3207, 1109, 1110, 8514, 8513
3208, 1110, 1111, 8515, 8514
3209, 1111, 1112, 8516, 8515
3210, 1112, 1113, 8517, 8516
3211, 1113, 1114, 8518, 8517
3212, 1114, 1115, 8519, 8518
3213, 1115, 1116, 8520, 8519
3214, 1116, 1117, 8521, 8520
3215, 1117, 1118, 8522, 8521
3216, 1118, 1119, 8523, 8522
3217, 1119, 1120, 8524, 8523
3218, 1120, 1121, 8525, 8524
3219, 1121, 1122, 8526, 8525
3220, 1122, 48, 1134, 8526
3221, 1123, 8504, 8527, 1124
3222, 8504, 8505, 8528, 8527
3223, 8505, 8506, 8529, 8528
3224, 8506, 8507, 8530, 8529
3225, 8507, 8508, 8531, 8530
3226, 8508, 8509, 8532, 8531
3227, 8509, 8510, 8533, 8532
3228, 8510, 8511, 8534, 8533
3229, 8511, 8512, 8535, 8534
3230, 8512, 8513, 8536, 8535
3231, 8513, 8514, 8537, 8536
3232, 8514, 8515, 8538, 8537
3233, 8515, 8516, 8539, 8538
3234, 8516, 8517, 8540, 8539
3235, 8517, 8518, 8541, 8540
3236, 8518, 8519, 8542, 8541
3237, 8519, 8520, 8543, 8542
3238, 8520, 8521, 8544, 8543
3239, 8521, 8522, 8545, 8544
3240, 8522, 8523, 8546, 8545
3241, 8523, 8524, 8547, 8546
3242, 8524, 8525, 8548, 8547
3243, 8525, 8526, 8549, 8548
3244, 8526, 1134, 1135, 8549
3245, 1124, 8527, 8550, 1125
3246, 8527, 8528, 8551, 8550
3247, 8528, 8529, 8552, 8551
3248, 8529, 8530, 8553, 8552
3249, 8530, 8531, 8554, 8553
3250, 8531, 8532, 8555, 8554
3251, 8532, 8533, 8556, 8555
3252, 8533, 8534, 8557, 8556
3253, 8534, 8535, 8558, 8557
3254, 8535, 8536, 8559, 8558
3255, 8536, 8537, 8560, 8559
3256, 8537, 8538, 8561, 8560
3257, 8538, 8539, 8562, 8561
3258, 8539, 8540, 8563, 8562
3259, 8540, 8541, 8564, 8563
3260, 8541, 8542, 8565, 8564
3261, 8542, 8543, 8566, 8565
3262, 8543, 8544, 8567, 8566
3263, 8544, 8545, 8568, 8567
3264, 8545, 8546, 8569, 8568
3265, 8546, 8547, 8570, 8569
3266, 8547, 8548, 8571, 8570
3267, 8548, 8549, 8572, 8571
3268, 8549, 1135, 1136, 8572
3269, 1125, 8550, 8573, 1126
3270, 8550, 8551, 8574, 8573
3271, 8551, 8552, 8575, 8574
3272, 8552, 8553, 8576, 8575
3273, 8553, 8554, 8577, 8576
3274, 8554, 8555, 8578, 8577
3275, 8555, 8556, 8579, 8578
3276, 8556, 8557, 8580, 8579
3277, 8557, 8558, 8581, 8580
3278, 8558, 8559, 8582, 8581
3279, 8559, 8560, 8583, 8582
3280, 8560, 8561, 8584, 8583
3281, 8561, 8562, 8585, 8584
3282, 8562, 8563, 8586, 8585
3283, 8563, 8564, 8587, 8586
3284, 8564, 8565, 8588, 8587
3285, 8565, 8566, 8589, 8588
3286, 8566, 8567, 8590, 8589
3287, 8567, 8568, 8591, 8590
3288, 8568, 8569, 8592, 8591
3289, 8569, 8570, 8593, 8592
3290, 8570, 8571, 8594, 8593
3291, 8571, 8572, 8595, 8594
3292, 8572, 1136, 1137, 8595
3293, 1126, 8573, 8596, 1127
3294, 8573, 8574, 8597, 8596
3295, 8574, 8575, 8598, 8597
3296, 8575, 8576, 8599, 8598
3297, 8576, 8577, 8600, 8599
3298, 8577, 8578, 8601, 8600
3299, 8578, 8579, 8602, 8601
3300, 8579, 8580, 8603, 8602
3301, 8580, 8581, 8604, 8603
3302, 8581, 8582, 8605, 8604
3303, 8582, 8583, 8606, 8605
3304, 8583, 8584, 8607, 8606
3305, 8584, 8585, 8608, 8607
3306, 8585, 8586, 8609, 8608
3307, 8586, 8587, 8610, 8609
3308, 8587, 8588, 8611, 8610
3309, 8588, 8589, 8612, 8611
3310, 8589, 8590, 8613, 8612
3311, 8590, 8591, 8614, 8613
3312, 8591, 8592, 8615, 8614
3313, 8592, 8593, 8616, 8615
3314, 8593, 8594, 8617, 8616
3315, 8594, 8595, 8618, 8617
3316, 8595, 1137, 1138, 8618
3317, 1127, 8596, 8619, 1128
3318, 8596, 8597, 8620, 8619
3319, 8597, 8598, 8621, 8620
3320, 8598, 8599, 8622, 8621
3321, 8599, 8600, 8623, 8622
3322, 8600, 8601, 8624, 8623
3323, 8601, 8602, 8625, 8624
3324, 8602, 8603, 8626, 8625
3325, 8603, 8604, 8627, 8626
3326, 8604, 8605, 8628, 8627
3327, 8605, 8606, 8629, 8628
3328, 8606, 8607, 8630, 8629
3329, 8607, 8608, 8631, 8630
3330, 8608, 8609, 8632, 8631
3331, 8609, 8610, 8633, 8632
3332, 8610, 8611, 8634, 8633
3333, 8611, 8612, 8635, 8634
3334, 8612, 8613, 8636, 8635
3335, 8613, 8614, 8637, 8636
3336, 8614, 8615, 8638, 8637
3337, 8615, 8616, 8639, 8638
3338, 8616, 8617, 8640, 8639
3339, 8617, 8618, 8641, 8640
3340, 8618, 1138, 1139, 8641
3341, 1128, 8619, 8642, 1129
3342, 8619, 8620, 8643, 8642
3343, 8620, 8621, 8644, 8643
3344, 8621, 8622, 8645, 8644
3345, 8622, 8623, 8646, 8645
3346, 8623, 8624, 8647, 8646
3347, 8624, 8625, 8648, 8647
3348, 8625, 8626, 8649, 8648
3349, 8626, 8627, 8650, 8649
3350, 8627, 8628, 8651, 8650
3351, 8628, 8629, 8652, 8651
3352, 8629, 8630, 8653, 8652
3353, 8630, 8631, 8654, 8653
3354, 8631, 8632, 8655, 8654
3355, 8632, 8633, 8656, 8655
3356, 8633, 8634, 8657, 8656
3357, 8634, 8635, 8658, 8657
3358, 8635, 8636, 8659, 8658
3359, 8636, 8637, 8660, 8659
3360, 8637, 8638, 8661, 8660
3361, 8638, 8639, 8662, 8661
3362, 8639, 8640, 8663, 8662
3363, 8640, 8641, 8664, 8663
3364, 8641, 1139, 1140, 8664
3365, 1129, 8642, 8665, 1130
3366, 8642, 8643, 8666, 8665
3367, 8643, 8644, 8667, 8666
3368, 8644, 8645, 8668, 8667
3369, 8645, 8646, 8669, 8668
3370, 8646, 8647, 8670, 8669
3371, 8647, 8648, 8671, 8670
3372, 8648, 8649, 8672, 8671
3373, 8649, 8650, 8673, 8672
3374, 8650, 8651, 8674, 8673
3375, 8651, 8652, 8675, 8674
3376, 8652, 8653, 8676, 8675
3377, 8653, 8654, 8677, 8676
3378, 8654, 8655, 8678, 8677
3379, 8655, 8656, 8679, 8678
3380, 8656, 8657, 8680, 8679
3381, 8657, 8658, 8681, 8680
3382, 8658, 8659, 8682, 8681
3383, 8659, 8660, 8683, 8682
3384, 8660, 8661, 8684, 8683
3385, 8661, 8662, 8685, 8684
3386, 8662, 8663, 8686, 8685
3387, 8663, 8664, 8687, 8686
3388, 8664, 1140, 1141, 8687
3389, 1130, 8665, 8688, 1131
3390, 8665, 8666, 8689, 8688
3391, 8666, 8667, 8690, 8689
3392, 8667, 8668, 8691, 8690
3393, 8668, 8669, 8692, 8691
3394, 8669, 8670, 8693, 8692
3395, 8670, 8671, 8694, 8693
3396, 8671, 8672, 8695, 8694
3397, 8672, 8673, 8696, 8695
3398, 8673, 8674, 8697, 8696
3399, 8674, 8675, 8698, 8697
3400, 8675, 8676, 8699, 8698
3401, 8676, 8677, 8700, 8699
3402, 8677, 8678, 8701, 8700
3403, 8678, 8679, 8702, 8701
3404, 8679, 8680, 8703, 8702
3405, 8680, 8681, 8704, 8703
3406, 8681, 8682, 8705, 8704
3407, 8682, 8683, 8706, 8705
3408, 8683, 8684, 8707, 8706
3409, 8684, 8685, 8708, 8707
3410, 8685, 8686, 8709, 8708
3411, 8686, 8687, 8710, 8709
3412, 8687, 1141, 1142, 8710
3413, 1131, 8688, 8711, 1132
3414, 8688, 8689, 8712, 8711
3415, 8689, 8690, 8713, 8712
3416, 8690, 8691, 8714, 8713
3417, 8691, 8692, 8715, 8714
3418, 8692, 8693, 8716, 8715
3419, 8693, 8694, 8717, 8716
3420, 8694, 8695, 8718, 8717
3421, 8695, 8696, 8719, 8718
3422, 8696, 8697, 8720, 8719
3423, 8697, 8698, 8721, 8720
3424, 8698, 8699, 8722, 8721
3425, 8699, 8700, 8723, 8722
3426, 8700, 8701, 8724, 8723
3427, 8701, 8702, 8725, 8724
3428, 8702, 8703, 8726, 8725
3429, 8703, 8704, 8727, 8726
3430, 8704, 8705, 8728, 8727
3431, 8705, 8706, 8729, 8728
3432, 8706, 8707, 8730, 8729
3433, 8707, 8708, 8731, 8730
3434, 8708, 8709, 8732, 8731
3435, 8709, 8710, 8733, 8732
3436, 8710, 1142, 1143, 8733
3437, 1132, 8711, 8734, 1133
3438, 8711, 8712, 8735, 8734
3439, 8712, 8713, 8736, 8735
3440, 8713, 8714, 8737, 8736
3441, 8714, 8715, 8738, 8737
3442, 8715, 8716, 8739, 8738
3443, 8716, 8717, 8740, 8739
3444, 8717, 8718, 8741, 8740
3445, 8718, 8719, 8742, 8741
3446, 8719, 8720, 8743, 8742
3447, 8720, 8721, 8744, 8743
3448, 8721, 8722, 8745, 8744
3449, 8722, 8723, 8746, 8745
3450, 8723, 8724, 8747, 8746
3451, 8724, 8725, 8748, 8747
3452, 8725, 8726, 8749, 8748
3453, 8726, 8727, 8750, 8749
3454, 8727, 8728, 8751, 8750
3455, 8728, 8729, 8752, 8751
3456, 8729, 8730, 8753, 8752
3457, 8730, 8731, 8754, 8753
3458, 8731, 8732, 8755, 8754
3459, 8732, 8733, 8756, 8755
3460, 8733, 1143, 1144, 8756
3461, 1133, 8734, 1073, 45
3462, 8734, 8735, 1074, 1073
3463, 8735, 8736, 1075, 1074
3464, 8736, 8737, 1076, 1075
3465, 8737, 8738, 1077, 1076
3466, 8738, 8739, 1078, 1077
3467, 8739, 8740, 1079, 1078
3468, 8740, 8741, 1080, 1079
3469, 8741, 8742, 1081, 1080
3470, 8742, 8743, 1082, 1081
3471, 8743, 8744, 1083, 1082
3472, 8744, 8745, 1084, 1083
3473, 8745, 8746, 1085, 1084
3474, 8746, 8747, 1086, 1085
3475, 8747, 8748, 1087, 1086
3476, 8748, 8749, 1088, 1087
3477, 8749, 8750, 1089, 1088
3478, 8750, 8751, 1090, 1089
3479, 8751, 8752, 1091, 1090
3480, 8752, 8753, 1092, 1091
3481, 8753, 8754, 1093, 1092
3482, 8754, 8755, 1094, 1093
3483, 8755, 8756, 1095, 1094
3484, 8756, 1144, 46, 1095
*ELEMENT, type=CPS4, ELSET=Surface57
3485, 42, 1071, 1145, 49
3486, 1071, 1072, 1146, 1145
3487, 1072, 46, 50, 1146
*ELEMENT, type=CPS4, ELSET=Surface58
38894, 44, 51, 1147, 1098
38895, 1098, 1147, 1148, 1099
38896, 1099, 1148, 52, 48
*ELEMENT, type=CPS4, ELSET=Surface59
38897, 44, 1058, 1149, 51
38898, 1058, 1059, 1150, 1149
38899, 1059, 1060, 1151, 1150
38900, 1060, 1061, 1152, 1151
38901, 1061, 1062, 1153, 1152
38902, 1062, 1063, 1154, 1153
38903, 1063, 1064, 1155, 1154
38904, 1064, 1065, 1156, 1155
38905, 1065, 1066, 1157, 1156
38906, 1066, 1067, 1158, 1157
38907, 1067, 1068, 1159, 1158
38908, 1068, 42, 49, 1159
*ELEMENT, type=CPS4, ELSET=Surface60
3488, 48, 52, 1160, 1134
3489, 1134, 1160, 1161, 1135
3490, 1135, 1161, 1162, 1136
3491, 1136, 1162, 1163, 1137
3492, 1137, 1163, 1164, 1138
3493, 1138, 1164, 1165, 1139
3494, 1139, 1165, 1166, 1140
3495, 1140, 1166, 1167, 1141
3496, 1141, 1167, 1168, 1142
3497, 1142, 1168, 1169, 1143
3498, 1143, 1169, 1170, 1144
3499, 1144, 1170, 50, 46
*ELEMENT, type=CPS4, ELSET=Surface61
3500, 51, 1149, 8757, 1147
3501, 1147, 8757, 8758, 1148
3502, 1148, 8758, 1160, 52
3503, 1149, 1150, 8759, 8757
3504, 8757, 8759, 8760, 8758
3505, 8758, 8760, 1161, 1160
3506, 1150, 1151, 8761, 8759
3507, 8759, 8761, 8762, 8760
3508, 8760, 8762, 1162, 1161
3509, 1151, 1152, 8763, 8761
3510, 8761, 8763, 8764, 8762
3511, 8762, 8764, 1163, 1162
3512, 1152, 1153, 8765, 8763
3513, 8763, 8765, 8766, 8764
3514, 8764, 8766, 1164, 1163
3515, 1153, 1154, 8767, 8765
3516, 8765, 8767, 8768, 8766
3517, 8766, 8768, 1165, 1164
3518, 1154, 1155, 8769, 8767
3519, 8767, 8769, 8770, 8768
3520, 8768, 8770, 1166, 1165
3521, 1155, 1156, 8771, 8769
3522, 8769, 8771, 8772, 8770
3523, 8770, 8772, 1167, 1166
3524, 1156, 1157, 8773, 8771
3525, 8771, 8773, 8774, 8772
3526, 8772, 8774, 1168, 1167
3527, 1157, 1158, 8775, 8773
3528, 8773, 8775, 8776, 8774
3529, 8774, 8776, 1169, 1168
3530, 1158, 1159, 8777, 8775
3531, 8775, 8777, 8778, 8776
3532, 8776, 8778, 1170, 1169
3533, 1159, 49, 1145, 8777
3534, 8777, 1145, 1146, 8778
3535, 8778, 1146, 50, 1170
*ELEMENT, type=CPS4, ELSET=Surface62
3536, 2, 97, 1171, 54
3537, 97, 98, 1172, 1171
3538, 98, 99, 1173, 1172
3539, 99, 100, 1174, 1173
3540, 100, 101, 1175, 1174
3541, 101, 102, 1176, 1175
3542, 102, 103, 1177, 1176
3543, 103, 104, 1178, 1177
3544, 104, 105, 1179, 1178
3545, 105, 106, 1180, 1179
3546, 106, 107, 1181, 1180
3547, 107, 1, 53, 1181
*ELEMENT, type=CPS4, ELSET=Surface63
3548, 1, 108, 1182, 53
3549, 108, 109, 1183, 1182
3550, 109, 3, 55, 1183
*ELEMENT, type=CPS4, ELSET=Surface64
38909, 4, 56, 1184, 110
38910, 110, 1184, 1185, 111
38911, 111, 1185, 1186, 112
38912, 112, 1186, 1187, 113
38913, 113, 1187, 1188, 114
38914, 114, 1188, 1189, 115
38915, 115, 1189, 1190, 116
38916, 116, 1190, 1191, 117
38917, 117, 1191, 1192, 118
38918, 118, 1192, 1193, 119
38919, 119, 1193, 1194, 120
38920, 120, 1194, 55, 3
*ELEMENT, type=CPS4, ELSET=Surface65
38921, 2, 54, 1195, 121
38922, 121, 1195, 1196, 122
38923, 122, 1196, 56, 4
*ELEMENT, type=CPS4, ELSET=Surface66
3551, 54, 1171, 8779, 1195
3552, 1195, 8779, 8780, 1196
3553, 1196, 8780, 1184, 56
3554, 1171, 1172, 8781, 8779
3555, 8779, 8781, 8782, 8780
3556, 8780, 8782, 1185, 1184
3557, 1172, 1173, 8783, 8781
3558, 8781, 8783, 8784, 8782
3559, 8782, 8784, 1186, 1185
3560, 1173, 1174, 8785, 8783
3561, 8783, 8785, 8786, 8784
3562, 8784, 8786, 1187, 1186
3563, 1174, 1175, 8787, 8785
3564, 8785, 8787, 8788, 8786
3565, 8786, 8788, 1188, 1187
3566, 1175, 1176, 8789, 8787
3567, 8787, 8789, 8790, 8788
3568, 8788, 8790, 1189, 1188
3569, 1176, 1177, 8791, 8789
3570, 8789, 8791, 8792, 8790
3571, 8790, 8792, 1190, 1189
3572, 1177, 1178, 8793, 8791
3573, 8791, 8793, 8794, 8792
3574, 8792, 8794, 1191, 1190
3575, 1178, 1179, 8795, 8793
3576, 8793, 8795, 8796, 8794
3577, 8794, 8796, 1192, 1191
3578, 1179, 1180, 8797, 8795
3579, 8795, 8797, 8798, 8796
3580, 8796, 8798, 1193, 1192
3581, 1180, 1181, 8799, 8797
3582, 8797, 8799, 8800, 8798
3583, 8798, 8800, 1194, 1193
3584, 1181, 53, 1182, 8799
3585, 8799, 1182, 1183, 8800
3586, 8800, 1183, 55, 1194
*ELEMENT, type=CPS4, ELSET=Surface77
3587, 11, 57, 1197, 378
3588, 378, 1197, 1198, 379
3589, 379, 1198, 1199, 380
3590, 380, 1199, 1200, 381
3591, 381, 1200, 1201, 382
3592, 382, 1201, 1202, 383
3593, 383, 1202, 1203, 384
3594, 384, 1203, 1204, 385
3595, 385, 1204, 1205, 386
3596, 386, 1205, 1206, 387
3597, 387, 1206, 1207, 388
3598, 388, 1207, 1208, 389
3599, 389, 1208, 1209, 390
3600, 390, 1209, 1210, 391
3601, 391, 1210, 1211, 392
3602, 392, 1211, 1212, 393
3603, 393, 1212, 1213, 394
3604, 394, 1213, 1214, 395
3605, 395, 1214, 1215, 396
3606, 396, 1215, 1216, 397
3607, 397, 1216, 1217, 398
3608, 398, 1217, 1218, 399
3609, 399, 1218, 1219, 400
3610, 400, 1219, 58, 15
*ELEMENT, type=CPS4, ELSET=Surface78
38924, 9, 309, 1220, 59
38925, 309, 310, 1221, 1220
38926, 310, 311, 1222, 1221
38927, 311, 312, 1223, 1222
38928, 312, 313, 1224, 1223
38929, 313, 314, 1225, 1224
38930, 314, 315, 1226, 1225
38931, 315, 316, 1227, 1226
38932, 316, 317, 1228, 1227
38933, 317, 318, 1229, 1228
38934, 318, 319, 1230, 1229
38935, 319, 320, 1231, 1230
38936, 320, 321, 1232, 1231
38937, 321, 322, 1233, 1232
38938, 322, 323, 1234, 1233
38939, 323, 324, 1235, 1234
38940, 324, 325, 1236, 1235
38941, 325, 326, 1237, 1236
38942, 326, 327, 1238, 1237
38943, 327, 328, 1239, 1238
38944, 328, 329, 1240, 1239
38945, 329, 330, 1241, 1240
38946, 330, 331, 1242, 1241
38947, 331, 13, 60, 1242
*ELEMENT, type=CPS4, ELSET=Surface79
38948, 9, 59, 1243, 264
38949, 264, 1243, 1244, 265
38950, 265, 1244, 1245, 266
38951, 266, 1245, 1246, 267
38952, 267, 1246, 1247, 268
38953, 268, 1247, 1248, 269
38954, 269, 1248, 1249, 270
38955, 270, 1249, 1250, 271
38956, 271, 1250, 1251, 272
38957, 272, 1251, 1252, 273
38958, 273, 1252, 1253, 274
38959, 274, 1253, 57, 11
*ELEMENT, type=CPS4, ELSET=Surface80
38960, 13, 401, 1254, 60
38961, 401, 402, 1255, 1254
38962, 402, 403, 1256, 1255
38963, 403, 404, 1257, 1256
38964, 404, 405, 1258, 1257
38965, 405, 406, 1259, 1258
38966, 406, 407, 1260, 1259
38967, 407, 408, 1261, 1260
38968, 408, 409, 1262, 1261
38969, 409, 410, 1263, 1262
38970, 410, 411, 1264, 1263
38971, 411, 15, 58, 1264
*ELEMENT, type=CPS4, ELSET=Surface81
38972, 59, 1220, 8801, 1243
38973, 1220, 1221, 8802, 8801
38974, 1221, 1222, 8803, 8802
38975, 1222, 1223, 8804, 8803
38976, 1223, 1224, 8805, 8804
38977, 1224, 1225, 8806, 8805
38978, 1225, 1226, 8807, 8806
38979, 1226, 1227, 8808, 8807
38980, 1227, 1228, 8809, 8808
38981, 1228, 1229, 8810, 8809
38982, 1229, 1230, 8811, 8810
38983, 1230, 1231, 8812, 8811
38984, 1231, 1232, 8813, 8812
38985, 1232, 1233, 8814, 8813
38986, 1233, 1234, 8815, 8814
38987, 1234, 1235, 8816, 8815
38988, 1235, 1236, 8817, 8816
38989, 1236, 1237, 8818, 8817
38990, 1237, 1238, 8819, 8818
38991, 1238, 1239, 8820, 8819
38992, 1239, 1240, 8821, 8820
38993, 1240, 1241, 8822, 8821
38994, 1241, 1242, 8823, 8822
38995, 1242, 60, 1254, 8823
38996, 1243, 8801, 8824, 1244
38997, 8801, 8802, 8825, 8824
38998, 8802, 8803, 8826, 8825
38999, 8803, 8804, 8827, 8826
39000, 8804, 8805, 8828, 8827
39001, 8805, 8806, 8829, 8828
39002, 8806, 8807, 8830, 8829
39003, 8807, 8808, 8831, 8830
39004, 8808, 8809, 8832, 8831
39005, 8809, 8810, 8833, 8832
39006, 8810, 8811, 8834, 8833
39007, 8811, 8812, 8835, 8834
39008, 8812, 8813, 8836, 8835
39009, 8813, 8814, 8837, 8836
39010, 8814, 8815, 8838, 8837
39011, 8815, 8816, 8839, 8838
39012, 8816, 8817, 8840, 8839
39013, 8817, 8818, 8841, 8840
39014, 8818, 8819, 8842, 8841
39015, 8819, 8820, 8843, 8842
39016, 8820, 8821, 8844, 8843
39017, 8821, 8822, 8845, 8844
39018, 8822, 8823, 8846, 8845
39019, 8823, 1254, 1255, 8846
39020, 1244, 8824, 8847, 1245
39021, 8824, 8825, 8848, 8847
39022, 8825, 8826, 8849, 8848
39023, 8826, 8827, 8850, 8849
39024, 8827, 8828, 8851, 8850
39025, 8828, 8829, 8852, 8851
39026, 8829, 8830, 8853, 8852
39027, 8830, 8831, 8854, 8853
39028, 8831, 8832, 8855, 8854
39029, 8832, 8833, 8856, 8855
39030, 8833, 8834, 8857, 8856
39031, 8834, 8835, 8858, 8857
39032, 8835, 8836, 8859, 8858
39033, 8836, 8837, 8860, 8859
39034, 8837, 8838, 8861, 8860
39035, 8838, 8839, 8862, 8861
39036, 8839, 8840, 8863, 8862
39037, 8840, 8841, 8864, 8863
39038, 8841, 8842, 8865, 8864
39039, 8842, 8843, 8866, 8865
39040, 8843, 8844, 8867, 8866
39041, 8844, 8845, 8868, 8867
39042, 8845, 8846, 8869, 8868
39043, 8846, 1255, 1256, 8869
39044, 1245, 8847, 8870, 1246
39045, 8847, 8848, 8871, 8870
39046, 8848, 8849, 8872, 8871
39047, 8849, 8850, 8873, 8872
39048, 8850, 8851, 8874, 8873
39049, 8851, 8852, 8875, 8874
39050, 8852, 8853, 8876, 8875
39051, 8853, 8854, 8877, 8876
39052, 8854, 8855, 8878, 8877
39053, 8855, 8856, 8879, 8878
39054, 8856, 8857, 8880, 8879
39055, 8857, 8858, 8881, 8880
39056, 8858, 8859, 8882, 8881
39057, 8859, 8860, 8883, 8882
39058, 8860, 8861, 8884, 8883
39059, 8861, 8862, 8885, 8884
39060, 8862, 8863, 8886, 8885
39061, 8863, 8864, 8887, 8886
39062, 8864, 8865, 8888, 8887
39063, 8865, 8866, 8889, 8888
39064, 8866, 8867, 8890, 8889
39065, 8867, 8868, 8891, 8890
39066, 8868, 8869, 8892, 8891
39067, 8869, 1256, 1257, 8892
39068, 1246, 8870, 8893, 1247
39069, 8870, 8871, 8894, 8893
39070, 8871, 8872, 8895, 8894
39071, 8872, 8873, 8896, 8895
39072, 8873, 8874, 8897, 8896
39073, 8874, 8875, 8898, 8897
39074, 8875, 8876, 8899, 8898
39075, 8876, 8877, 8900, 8899
39076, 8877, 8878, 8901, 8900
39077, 8878, 8879, 8902, 8901
39078, 8879, 8880, 8903, 8902
39079, 8880, 8881, 8904, 8903
39080, 8881, 8882, 8905, 8904
39081, 8882, 8883, 8906, 8905
39082, 8883, 8884, 8907, 8906
39083, 8884, 8885, 8908, 8907
39084, 8885, 8886, 8909, 8908
39085, 8886, 8887, 8910, 8909
39086, 8887, 8888, 8911, 8910
39087, 8888, 8889, 8912, 8911
39088, 8889, 8890, 8913, 8912
39089, 8890, 8891, 8914, 8913
39090, 8891, 8892, 8915, 8914
39091, 8892, 1257, 1258, 8915
39092, 1247, 8893, 8916, 1248
39093, 8893, 8894, 8917, 8916
39094, 8894, 8895, 8918, 8917
39095, 8895, 8896, 8919, 8918
39096, 8896, 8897, 8920, 8919
39097, 8897, 8898, 8921, 8920
39098, 8898, 8899, 8922, 8921
39099, 8899, 8900, 8923, 8922
39100, 8900, 8901, 8924, 8923
39101, 8901, 8902, 8925, 8924
39102, 8902, 8903, 8926, 8925
39103, 8903, 8904, 8927, 8926
39104, 8904, 8905, 8928, 8927
39105, 8905, 8906, 8929, 8928
39106, 8906, 8907, 8930, 8929
39107, 8907, 8908, 8931, 8930
39108, 8908, 8909, 8932, 8931
39109, 8909, 8910, 8933, 8932
39110, 8910, 8911, 8934, 8933
39111, 8911, 8912, 8935, 8934
39112, 8912, 8913, 8936, 8935
39113, 8913, 8914, 8937, 8936
39114, 8914, 8915, 8938, 8937
39115, 8915, 1258, 1259, 8938
39116, 1248, 8916, 8939, 1249
39117, 8916, 8917, 8940, 8939
39118, 8917, 8918, 8941, 8940
39119, 8918, 8919, 8942, 8941
39120, 8919, 8920, 8943, 8942
39121, 8920, 8921, 8944, 8943
39122, 8921, 8922, 8945, 8944
39123, 8922, 8923, 8946, 8945
39124, 8923, 8924, 8947, 8946
39125, 8924, 8925, 8948, 8947
39126, 8925, 8926, 8949, 8948
39127, 8926, 8927, 8950, 8949
39128, 8927, 8928, 8951, 8950
39129, 8928, 8929, 8952, 8951
39130, 8929, 8930, 8953, 8952
39131, 8930, 8931, 8954, 8953
39132, 8931, 8932, 8955, 8954
39133, 8932, 8933, 8956, 8955
39134, 8933, 8934, 8957, 8956
39135, 8934, 8935, 8958, 8957
39136, 8935, 8936, 8959, 8958
39137, 8936, 8937, 8960, 8959
39138, 8937, 8938, 8961, 8960
39139, 8938, 1259, 1260, 8961
39140, 1249, 8939, 8962, 1250
39141, 8939, 8940, 8963, 8962
39142, 8940, 8941, 8964, 8963
39143, 8941, 8942, 8965, 8964
39144, 8942, 8943, 8966, 8965
39145, 8943, 8944, 8967, 8966
39146, 8944, 8945, 8968, 8967
39147, 8945, 8946, 8969, 8968
39148, 8946, 8947, 8970, 8969
39149, 8947, 8948, 8971, 8970
39150, 8948, 8949, 8972, 8971
39151, 8949, 8950, 8973, 8972
39152, 8950, 8951, 8974, 8973
39153, 8951, 8952, 8975, 8974
39154, 8952, 8953, 8976, 8975
39155, 8953, 8954, 8977, 8976
39156, 8954, 8955, 8978, 8977
39157, 8955, 8956, 8979, 8978
39158, 8956, 8957, 8980, 8979
39159, 8957, 8958, 8981, 8980
39160, 8958, 8959, 8982, 8981
39161, 8959, 8960, 8983, 8982
39162, 8960, 8961, 8984, 8983
39163, 8961, 1260, 1261, 8984
39164, 1250, 8962, 8985, 1251
39165, 8962, 8963, 8986, 8985
39166, 8963, 8964, 8987, 8986
39167, 8964, 8965, 8988, 8987
39168, 8965, 8966, 8989, 8988
39169, 8966, 8967, 8990, 8989
39170, 8967, 8968, 8991, 8990
39171, 8968, 8969, 8992, 8991
39172, 8969, 8970, 8993, 8992
39173, 8970, 8971, 8994, 8993
39174, 8971, 8972, 8995, 8994
39175, 8972, 8973, 8996, 8995
39176, 8973, 8974, 8997, 8996
39177, 8974, 8975, 8998, 8997
39178, 8975, 8976, 8999, 8998
39179, 8976, 8977, 9000, 8999
39180, 8977, 8978, 9001, 9000
39181, 8978, 8979, 9002, 9001
39182, 8979, 8980, 9003, 9002
39183, 8980, 8981, 9004, 9003
39184, 8981, 8982, 9005, 9004
39185, 8982, 8983, 9006, 9005
39186, 8983, 8984, 9007, 9006
39187, 8984, 1261, 1262, 9007
39188, 1251, 8985, 9008, 1252
39189, 8985, 8986, 9009, 9008
39190, 8986, 8987, 9010, 9009
39191, 8987, 8988, 9011, 9010
39192, 8988, 8989, 9012, 9011
39193, 8989, 8990, 9013, 9012
39194, 8990, 8991, 9014, 9013
39195, 8991, 8992, 9015, 9014
39196, 8992, 8993, 9016, 9015
39197, 8993, 8994, 9017, 9016
39198, 8994, 8995, 9018, 9017
39199, 8995, 8996, 9019, 9018
39200, 8996, 8997, 9020, 9019
39201, 8997, 8998, 9021, 9020
39202, 8998, 8999, 9022, 9021
39203, 8999, 9000, 9023, 9022
39204, 9000, 9001, 9024, 9023
39205, 9001, 9002, 9025, 9024
39206, 9002, 9003, 9026, 9025
39207, 9003, 9004, 9027, 9026
39208, 9004, 9005, 9028, 9027
39209, 9005, 9006, 9029, 9028
39210, 9006, 9007, 9030, 9029
39211, 9007, 1262, 1263, 9030
39212, 1252, 9008, 9031, 1253
39213, 9008, 9009, 9032, 9031
39214, 9009, 9010, 9033, 9032
39215, 9010, 9011, 9034, 9033
39216, 9011, 9012, 9035, 9034
39217, 9012, 9013, 9036, 9035
39218, 9013, 9014, 9037, 9036
39219, 9014, 9015, 9038, 9037
39220, 9015, 9016, 9039, 9038
39221, 9016, 9017, 9040, 9039
39222, 9017, 9018, 9041, 9040
39223, 9018, 9019, 9042, 9041
39224, 9019, 9020, 9043, 9042
39225, 9020, 9021, 9044, 9043
39226, 9021, 9022, 9045, 9044
39227, 9022, 9023, 9046, 9045
39228, 9023, 9024, 9047, 9046
39229, 9024, 9025, 9048, 9047
39230, 9025, 9026, 9049, 9048
39231, 9026, 9027, 9050, 9049
39232, 9027, 9028, 9051, 9050
39233, 9028, 9029, 9052, 9051
39234, 9029, 9030, 9053, 9052
39235, 9030, 1263, 1264, 9053
39236, 1253, 9031, 1197, 57
39237, 9031, 9032, 1198, 1197
39238, 9032, 9033, 1199, 1198
39239, 9033, 9034, 1200, 1199
39240, 9034, 9035, 1201, 1200
39241, 9035, 9036, 1202, 1201
39242, 9036, 9037, 1203, 1202
39243, 9037, 9038, 1204, 1203
39244, 9038, 9039, 1205, 1204
39245, 9039, 9040, 1206, 1205
39246, 9040, 9041, 1207, 1206
39247, 9041, 9042, 1208, 1207
39248, 9042, 9043, 1209, 1208
39249, 9043, 9044, 1210, 1209
39250, 9044, 9045, 1211, 1210
39251, 9045, 9046, 1212, 1211
39252, 9046, 9047, 1213, 1212
39253, 9047, 9048, 1214, 1213
39254, 9048, 9049, 1215, 1214
39255, 9049, 9050, 1216, 1215
39256, 9050, 9051, 1217, 1216
39257, 9051, 9052, 1218, 1217
39258, 9052, 9053, 1219, 1218
39259, 9053, 1264, 58, 1219
*ELEMENT, type=CPS4, ELSET=Surface82
3611, 33, 61, 1265, 841
3612, 841, 1265, 1266, 842
3613, 842, 1266, 1267, 843
3614, 843, 1267, 1268, 844
3615, 844, 1268, 1269, 845
3616, 845, 1269, 1270, 846
3617, 846, 1270, 1271, 847
3618, 847, 1271, 1272, 848
3619, 848, 1272, 1273, 849
3620, 849, 1273, 1274, 850
3621, 850, 1274, 1275, 851
3622, 851, 1275, 1276, 852
3623, 852, 1276, 1277, 853
3624, 853, 1277, 1278, 854
3625, 854, 1278, 1279, 855
3626, 855, 1279, 1280, 856
3627, 856, 1280, 1281, 857
3628, 857, 1281, 1282, 858
3629, 858, 1282, 1283, 859
3630, 859, 1283, 1284, 860
3631, 860, 1284, 1285, 861
3632, 861, 1285, 1286, 862
3633, 862, 1286, 1287, 863
3634, 863, 1287, 62, 37
*ELEMENT, type=CPS4, ELSET=Surface83
39260, 35, 910, 1288, 63
39261, 910, 911, 1289, 1288
39262, 911, 912, 1290, 1289
39263, 912, 913, 1291, 1290
39264, 913, 914, 1292, 1291
39265, 914, 915, 1293, 1292
39266, 915, 916, 1294, 1293
39267, 916, 917, 1295, 1294
39268, 917, 918, 1296, 1295
39269, 918, 919, 1297, 1296
39270, 919, 920, 1298, 1297
39271, 920, 921, 1299, 1298
39272, 921, 922, 1300, 1299
39273, 922, 923, 1301, 1300
39274, 923, 924, 1302, 1301
39275, 924, 925, 1303, 1302
39276, 925, 926, 1304, 1303
39277, 926, 927, 1305, 1304
39278, 927, 928, 1306, 1305
39279, 928, 929, 1307, 1306
39280, 929, 930, 1308, 1307
39281, 930, 931, 1309, 1308
39282, 931, 932, 1310, 1309
39283, 932, 39, 64, 1310
*ELEMENT, type=CPS4, ELSET=Surface84
39284, 35, 63, 1311, 819
39285, 819, 1311, 1312, 820
39286, 820, 1312, 1313, 821
39287, 821, 1313, 1314, 822
39288, 822, 1314, 1315, 823
39289, 823, 1315, 1316, 824
39290, 824, 1316, 1317, 825
39291, 825, 1317, 1318, 826
39292, 826, 1318, 1319, 827
39293, 827, 1319, 1320, 828
39294, 828, 1320, 1321, 829
39295, 829, 1321, 61, 33
*ELEMENT, type=CPS4, ELSET=Surface85
39296, 39, 979, 1322, 64
39297, 979, 980, 1323, 1322
39298, 980, 981, 1324, 1323
39299, 981, 982, 1325, 1324
39300, 982, 983, 1326, 1325
39301, 983, 984, 1327, 1326
39302, 984, 985, 1328, 1327
39303, 985, 986, 1329, 1328
39304, 986, 987, 1330, 1329
39305, 987, 988, 1331, 1330
39306, 988, 989, 1332, 1331
39307, 989, 37, 62, 1332
*ELEMENT, type=CPS4, ELSET=Surface86
39308, 63, 1288, 9054, 1311
39309, 1288, 1289, 9055, 9054
39310, 1289, 1290, 9056, 9055
39311, 1290, 1291, 9057, 9056
39312, 1291, 1292, 9058, 9057
39313, 1292, 1293, 9059, 9058
39314, 1293, 1294, 9060, 9059
39315, 1294, 1295, 9061, 9060
39316, 1295, 1296, 9062, 9061
39317, 1296, 1297, 9063, 9062
39318, 1297, 1298, 9064, 9063
39319, 1298, 1299, 9065, 9064
39320, 1299, 1300, 9066, 9065
39321, 1300, 1301, 9067, 9066
39322, 1301, 1302, 9068, 9067
39323, 1302, 1303, 9069, 9068
39324, 1303, 1304, 9070, 9069
39325, 1304, 1305, 9071, 9070
39326, 1305, 1306, 9072, 9071
39327, 1306, 1307, 9073, 9072
39328, 1307, 1308, 9074, 9073
39329, 1308, 1309, 9075, 9074
39330, 1309, 1310, 9076, 9075
39331, 1310, 64, 1322, 9076
39332, 1311, 9054, 9077, 1312
39333, 9054, 9055, 9078, 9077
39334, 9055, 9056, 9079, 9078
39335, 9056, 9057, 9080, 9079
39336, 9057, 9058, 9081, 9080
39337, 9058, 9059, 9082, 9081
39338, 9059, 9060, 9083, 9082
39339, 9060, 9061, 9084, 9083
39340, 9061, 9062, 9085, 9084
39341, 9062, 9063, 9086, 9085
39342, 9063, 9064, 9087, 9086
39343, 9064, 9065, 9088, 9087
39344, 9065, 9066, 9089, 9088
39345, 9066, 9067, 9090, 9089
39346, 9067, 9068, 9091, 9090
39347, 9068, 9069, 9092, 9091
39348, 9069, 9070, 9093, 9092
39349, 9070, 9071, 9094, 9093
39350, 9071, 9072, 9095, 9094
39351, 9072, 9073, 9096, 9095
39352, 9073, 9074, 9097, 9096
39353, 9074, 9075, 9098, 9097
39354, 9075, 9076, 9099, 9098
39355, 9076, 1322, 1323, 9099
39356, 1312, 9077, 9100, 1313
39357, 9077, 9078, 9101, 9100
39358, 9078, 9079, 9102, 9101
39359, 9079, 9080, 9103, 9102
39360, 9080, 9081, 9104, 9103
39361, 9081, 9082, 9105, 9104
39362, 9082, 9083, 9106, 9105
39363, 9083, 9084, 9107, 9106
39364, 9084, 9085, 9108, 9107
39365, 9085, 9086, 9109, 9108
39366, 9086, 9087, 9110, 9109
39367, 9087, 9088, 9111, 9110
39368, 9088, 9089, 9112, 9111
39369, 9089, 9090, 9113, 9112
39370, 9090, 9091, 9114, 9113
39371, 9091, 9092, 9115, 9114
39372, 9092, 9093, 9116, 9115
39373, 9093, 9094, 9117, 9116
39374, 9094, 9095, 9118, 9117
39375, 9095, 9096, 9119, 9118
39376, 9096, 9097, 9120, 9119
39377, 9097, 9098, 9121, 9120
39378, 9098, 9099, 9122, 9121
39379, 9099, 1323, 1324, 9122
39380, 1313, 9100, 9123, 1314
39381, 9100, 9101, 9124, 9123
39382, 9101, 9102, 9125, 9124
39383, 9102, 9103, 9126, 9125
39384, 9103, 9104, 9127, 9126
39385, 9104, 9105, 9128, 9127
39386, 9105, 9106, 9129, 9128
39387, 9106, 9107, 9130, 9129
39388, 9107, 9108, 9131, 9130
39389, 9108, 9109, 9132, 9131
39390, 9109, 9110, 9133, 9132
39391, 9110, 9111, 9134, 9133
39392, 9111, 9112, 9135, 9134
39393, 9112, 9113, 9136, 9135
39394, 9113, 9114, 9137, 9136
39395, 9114, 9115, 9138, 9137
39396, 9115, 9116, 9139, 9138
39397, 9116, 9117, 9140, 9139
39398, 9117, 9118, 9141, 9140
39399, 9118, 9119, 9142, 9141
39400, 9119, 9120, 9143, 9142
39401, 9120, 9121, 9144, 9143
39402, 9121, 9122, 9145, 9144
39403, 9122, 1324, 1325, 9145
39404, 1314, 9123, 9146, 1315
39405, 9123, 9124, 9147, 9146
39406, 9124, 9125, 9148, 9147
39407, 9125, 9126, 9149, 9148
39408, 9126, 9127, 9150, 9149
39409, 9127, 9128, 9151, 9150
39410, 9128, 9129, 9152, 9151
39411, 9129, 9130, 9153, 9152
39412, 9130, 9131, 9154, 9153
39413, 9131, 9132, 9155, 9154
39414, 9132, 9133, 9156, 9155
39415, 9133, 9134, 9157, 9156
39416, 9134, 9135, 9158, 9157
39417, 9135, 9136, 9159, 9158
39418, 9136, 9137, 9160, 9159
39419, 9137, 9138, 9161, 9160
39420, 9138, 9139, 9162, 9161
39421, 9139, 9140, 9163, 9162
39422, 9140, 9141, 9164, 9163
39423, 9141, 9142, 9165, 9164
39424, 9142, 9143, 9166, 9165
39425, 9143, 9144, 9167, 9166
39426, 9144, 9145, 9168, 9167
39427, 9145, 1325, 1326, 9168
39428, 1315, 9146, 9169, 1316
39429, 9146, 9147, 9170, 9169
39430, 9147, 9148, 9171, 9170
39431, 9148, 9149, 9172, 9171
39432, 9149, 9150, 9173, 9172
39433, 9150, 9151, 9174, 9173
39434, 9151, 9152, 9175, 9174
39435, 9152, 9153, 9176, 9175
39436, 9153, 9154, 9177, 9176
39437, 9154, 9155, 9178, 9177
39438, 9155, 9156, 9179, 9178
39439, 9156, 9157, 9180, 9179
39440, 9157, 9158, 9181, 9180
39441, 9158, 9159, 9182, 9181
39442, 9159, 9160, 9183, 9182
39443, 9160, 9161, 9184, 9183
39444, 9161, 9162, 9185, 9184
39445, 9162, 9163, 9186, 9185
39446, 9163, 9164, 9187, 9186
39447, 9164, 9165, 9188, 9187
39448, 9165, 9166, 9189, 9188
39449, 9166, 9167, 9190, 9189
39450, 9167, 9168, 9191, 9190
39451, 9168, 1326, 1327, 9191
39452, 1316, 9169, 9192, 1317
39453, 9169, 9170, 9193, 9192
39454, 9170, 9171, 9194, 9193
39455, 9171, 9172, 9195, 9194
39456, 9172, 9173, 9196, 9195
39457, 9173, 9174, 9197, 9196
39458, 9174, 9175, 9198, 9197
39459, 9175, 9176, 9199, 9198
39460, 9176, 9177, 9200, 9199
39461, 9177, 9178, 9201, 9200
39462, 9178, 9179, 9202, 9201
39463, 9179, 9180, 9203, 9202
39464, 9180, 9181, 9204, 9203
39465, 9181, 9182, 9205, 9204
39466, 9182, 9183, 9206, 9205
39467, 9183, 9184, 9207, 9206
39468, 9184, 9185, 9208, 9207
39469, 9185, 9186, 9209, 9208
39470, 9186, 9187, 9210, 9209
39471, 9187, 9188, 9211, 9210
39472, 9188, 9189, 9212, 9211
39473, 9189, 9190, 9213, 9212
39474, 9190, 9191, 9214, 9213
39475, 9191, 1327, 1328, 9214
39476, 1317, 9192, 9215, 1318
39477, 9192, 9193, 9216, 9215
39478, 9193, 9194, 9217, 9216
39479, 9194, 9195, 9218, 9217
39480, 9195, 9196, 9219, 9218
39481, 9196, 9197, 9220, 9219
39482, 9197, 9198, 9221, 9220
39483, 9198, 9199, 9222, 9221
39484, 9199, 9200, 9223, 9222
39485, 9200, 9201, 9224, 9223
39486, 9201, 9202, 9225, 9224
39487, 9202, 9203, 9226, 9225
39488, 9203, 9204, 9227, 9226
39489, 9204, 9205, 9228, 9227
39490, 9205, 9206, 9229, 9228
39491, 9206, 9207, 9230, 9229
39492, 9207, 9208, 9231, 9230
39493, 9208, 9209, 9232, 9231
39494, 9209, 9210, 9233, 9232
39495, 9210, 9211, 9234, 9233
39496, 9211, 9212, 9235, 9234
39497, 9212, 9213, 9236, 9235
39498, 9213, 9214, 9237, 9236
39499, 9214, 1328, 1329, 9237
39500, 1318, 9215, 9238, 1319
39501, 9215, 9216, 9239, 9238
39502, 9216, 9217, 9240, 9239
39503, 9217, 9218, 9241, 9240
39504, 9218, 9219, 9242, 9241
39505, 9219, 9220, 9243, 9242
39506, 9220, 9221, 9244, 9243
39507, 9221, 9222, 9245, 9244
39508, 9222, 9223, 9246, 9245
39509, 9223, 9224, 9247, 9246
39510, 9224, 9225, 9248, 9247
39511, 9225, 9226, 9249, 9248
39512, 9226, 9227, 9250, 9249
39513, 9227, 9228, 9251, 9250
39514, 9228, 9229, 9252, 9251
39515, 9229, 9230, 9253, 9252
39516, 9230, 9231, 9254, 9253
39517, 9231, 9232, 9255, 9254
39518, 9232, 9233, 9256, 9255
39519, 9233, 9234, 9257, 9256
39520, 9234, 9235, 9258, 9257
39521, 9235, 9236, 9259, 9258
39522, 9236, 9237, 9260, 9259
39523, 9237, 1329, 1330, 9260
39524, 1319, 9238, 9261, 1320
39525, 9238, 9239, 9262, 9261
39526, 9239, 9240, 9263, 9262
39527, 9240, 9241, 9264, 9263
39528, 9241, 9242, 9265, 9264
39529, 9242, 9243, 9266, 9265
39530, 9243, 9244, 9267, 9266
39531, 9244, 9245, 9268, 9267
39532, 9245, 9246, 9269, 9268
39533, 9246, 9247, 9270, 9269
39534, 9247, 9248, 9271, 9270
39535, 9248, 9249, 9272, 9271
39536, 9249, 9250, 9273, 9272
39537, 9250, 9251, 9274, 9273
39538, 9251, 9252, 9275, 9274
39539, 9252, 9253, 9276, 9275
39540, 9253, 9254, 9277, 9276
39541, 9254, 9255, 9278, 9277
39542, 9255, 9256, 9279, 9278
39543, 9256, 9257, 9280, 9279
39544, 9257, 9258, 9281, 9280
39545, 9258, 9259, 9282, 9281
39546, 9259, 9260, 9283, 9282
39547, 9260, 1330, 1331, 9283
39548, 1320, 9261, 9284, 1321
39549, 9261, 9262, 9285, 9284
39550, 9262, 9263, 9286, 9285
39551, 9263, 9264, 9287, 9286
39552, 9264, 9265, 9288, 9287
39553, 9265, 9266, 9289, 9288
39554, 9266, 9267, 9290, 9289
39555, 9267, 9268, 9291, 9290
39556, 9268, 9269, 9292, 9291
39557, 9269, 9270, 9293, 9292
39558, 9270, 9271, 9294, 9293
39559, 9271, 9272, 9295, 9294
39560, 9272, 9273, 9296, 9295
39561, 9273, 9274, 9297, 9296
39562, 9274, 9275, 9298, 9297
39563, 9275, 9276, 9299, 9298
39564, 9276, 9277, 9300, 9299
39565, 9277, 9278, 9301, 9300
39566, 9278, 9279, 9302, 9301
39567, 9279, 9280, 9303, 9302
39568, 9280, 9281, 9304, 9303
39569, 9281, 9282, 9305, 9304
39570, 9282, 9283, 9306, 9305
39571, 9283, 1331, 1332, 9306
39572, 1321, 9284, 1265, 61
39573, 9284, 9285, 1266, 1265
39574, 9285, 9286, 1267, 1266
39575, 9286, 9287, 1268, 1267
39576, 9287, 9288, 1269, 1268
39577, 9288, 9289, 1270, 1269
39578, 9289, 9290, 1271, 1270
39579, 9290, 9291, 1272, 1271
39580, 9291, 9292, 1273, 1272
39581, 9292, 9293, 1274, 1273
39582, 9293, 9294, 1275, 1274
39583, 9294, 9295, 1276, 1275
39584, 9295, 9296, 1277, 1276
39585, 9296, 9297, 1278, 1277
39586, 9297, 9298, 1279, 1278
39587, 9298, 9299, 1280, 1279
39588, 9299, 9300, 1281, 1280
39589, 9300, 9301, 1282, 1281
39590, 9301, 9302, 1283, 1282
39591, 9302, 9303, 1284, 1283
39592, 9303, 9304, 1285, 1284
39593, 9304, 9305, 1286, 1285
39594, 9305, 9306, 1287, 1286
39595, 9306, 1332, 62, 1287
*ELEMENT, type=CPS4, ELSET=Surface87
39596, 9, 65, 1333, 309
39597, 309, 1333, 1334, 310
39598, 310, 1334, 1335, 311
39599, 311, 1335, 1336, 312
39600, 312, 1336, 1337, 313
39601, 313, 1337, 1338, 314
39602, 314, 1338, 1339, 315
39603, 315, 1339, 1340, 316
39604, 316, 1340, 1341, 317
39605, 317, 1341, 1342, 318
39606, 318, 1342, 1343, 319
39607, 319, 1343, 1344, 320
39608, 320, 1344, 1345, 321
39609, 321, 1345, 1346, 322
39610, 322, 1346, 1347, 323
39611, 323, 1347, 1348, 324
39612, 324, 1348, 1349, 325
39613, 325, 1349, 1350, 326
39614, 326, 1350, 1351, 327
39615, 327, 1351, 1352, 328
39616, 328, 1352, 1353, 329
39617, 329, 1353, 1354, 330
39618, 330, 1354, 1355, 331
39619, 331, 1355, 66, 13
*ELEMENT, type=CPS4, ELSET=Surface88
39620, 10, 332, 1356, 67
39621, 332, 333, 1357, 1356
39622, 333, 334, 1358, 1357
39623, 334, 335, 1359, 1358
39624, 335, 336, 1360, 1359
39625, 336, 337, 1361, 1360
39626, 337, 338, 1362, 1361
39627, 338, 339, 1363, 1362
39628, 339, 340, 1364, 1363
39629, 340, 341, 1365, 1364
39630, 341, 342, 1366, 1365
39631, 342, 343, 1367, 1366
39632, 343, 344, 1368, 1367
39633, 344, 345, 1369, 1368
39634, 345, 346, 1370, 1369
39635, 346, 347, 1371, 1370
39636, 347, 348, 1372, 1371
39637, 348, 349, 1373, 1372
39638, 349, 350, 1374, 1373
39639, 350, 351, 1375, 1374
39640, 351, 352, 1376, 1375
39641, 352, 353, 1377, 1376
39642, 353, 354, 1378, 1377
39643, 354, 14, 68, 1378
*ELEMENT, type=CPS4, ELSET=Surface89
39644, 10, 67, 1379, 241
39645, 241, 1379, 1380, 242
39646, 242, 1380, 1381, 243
39647, 243, 1381, 1382, 244
39648, 244, 1382, 1383, 245
39649, 245, 1383, 1384, 246
39650, 246, 1384, 1385, 247
39651, 247, 1385, 1386, 248
39652, 248, 1386, 1387, 249
39653, 249, 1387, 1388, 250
39654, 250, 1388, 1389, 251
39655, 251, 1389, 1390, 252
39656, 252, 1390, 1391, 253
39657, 253, 1391, 1392, 254
39658, 254, 1392, 1393, 255
39659, 255, 1393, 1394, 256
39660, 256, 1394, 1395, 257
39661, 257, 1395, 1396, 258
39662, 258, 1396, 1397, 259
39663, 259, 1397, 1398, 260
39664, 260, 1398, 1399, 261
39665, 261, 1399, 1400, 262
39666, 262, 1400, 1401, 263
39667, 263, 1401, 65, 9
*ELEMENT, type=CPS4, ELSET=Surface90
39668, 14, 355, 1402, 68
39669, 355, 356, 1403, 1402
39670, 356, 357, 1404, 1403
39671, 357, 358, 1405, 1404
39672, 358, 359, 1406, 1405
39673, 359, 360, 1407, 1406
39674, 360, 361, 1408, 1407
39675, 361, 362, 1409, 1408
39676, 362, 363, 1410, 1409
39677, 363, 364, 1411, 1410
39678, 364, 365, 1412, 1411
39679, 365, 366, 1413, 1412
39680, 366, 367, 1414, 1413
39681, 367, 368, 1415, 1414
39682, 368, 369, 1416, 1415
39683, 369, 370, 1417, 1416
39684, 370, 371, 1418, 1417
39685, 371, 372, 1419, 1418
39686, 372, 373, 1420, 1419
39687, 373, 374, 1421, 1420
39688, 374, 375, 1422, 1421
39689, 375, 376, 1423, 1422
39690, 376, 377, 1424, 1423
39691, 377, 13, 66, 1424
*ELEMENT, type=CPS4, ELSET=Surface91
39692, 67, 1356, 9307, 1379
39693, 1356, 1357, 9308, 9307
39694, 1357, 1358, 9309, 9308
39695, 1358, 1359, 9310, 9309
39696, 1359, 1360, 9311, 9310
39697, 1360, 1361, 9312, 9311
39698, 1361, 1362, 9313, 9312
39699, 1362, 1363, 9314, 9313
39700, 1363, 1364, 9315, 9314
39701, 1364, 1365, 9316, 9315
39702, 1365, 1366, 9317, 9316
39703, 1366, 1367, 9318, 9317
39704, 1367, 1368, 9319, 9318
39705, 1368, 1369, 9320, 9319
39706, 1369, 1370, 9321, 9320
39707, 1370, 1371, 9322, 9321
39708, 1371, 1372, 9323, 9322
39709, 1372, 1373, 9324, 9323
39710, 1373, 1374, 9325, 9324
39711, 1374, 1375, 9326, 9325
39712, 1375, 1376, 9327, 9326
39713, 1376, 1377, 9328, 9327
39714, 1377, 1378, 9329, 9328
39715, 1378, 68, 1402, 9329
39716, 1379, 9307, 9330, 1380
39717, 9307, 9308, 9331, 9330
39718, 9308, 9309, 9332, 9331
39719, 9309, 9310, 9333, 9332
39720, 9310, 9311, 9334, 9333
39721, 9311, 9312, 9335, 9334
39722, 9312, 9313, 9336, 9335
39723, 9313, 9314, 9337, 9336
39724, 9314, 9315, 9338, 9337
39725, 9315, 9316, 9339, 9338
39726, 9316, 9317, 9340, 9339
39727, 9317, 9318, 9341, 9340
39728, 9318, 9319, 9342, 9341
39729, 9319, 9320, 9343, 9342
39730, 9320, 9321, 9344, 9343
39731, 9321, 9322, 9345, 9344
39732, 9322, 9323, 9346, 9345
39733, 9323, 9324, 9347, 9346
39734, 9324, 9325, 9348, 9347
39735, 9325, 9326, 9349, 9348
39736, 9326, 9327, 9350, 9349
39737, 9327, 9328, 9351, 9350
39738, 9328, 9329, 9352, 9351
39739, 9329, 1402, 1403, 9352
39740, 1380, 9330, 9353, 1381
39741, 9330, 9331, 9354, 9353
39742, 9331, 9332, 9355, 9354
39743, 9332, 9333, 9356, 9355
39744, 9333, 9334, 9357, 9356
39745, 9334, 9335, 9358, 9357
39746, 9335, 9336, 9359, 9358
39747, 9336, 9337, 9360, 9359
39748, 9337, 9338, 9361, 9360
39749, 9338, 9339, 9362, 9361
39750, 9339, 9340, 9363, 9362
39751, 9340, 9341, 9364, 9363
39752, 9341, 9342, 9365, 9364
39753, 9342, 9343, 9366, 9365
39754, 9343, 9344, 9367, 9366
39755, 9344, 9345, 9368, 9367
39756, 9345, 9346, 9369, 9368
39757, 9346, 9347, 9370, 9369
39758, 9347, 9348, 9371, 9370
39759, 9348, 9349, 9372, 9371
39760, 9349, 9350, 9373, 9372
39761, 9350, 9351, 9374, 9373
39762, 9351, 9352, 9375, 9374
39763, 9352, 1403, 1404, 9375
39764, 1381, 9353, 9376, 1382
39765, 9353, 9354, 9377, 9376
39766, 9354, 9355, 9378, 9377
39767, 9355, 9356, 9379, 9378
39768, 9356, 9357, 9380, 9379
39769, 9357, 9358, 9381, 9380
39770, 9358, 9359, 9382, 9381
39771, 9359, 9360, 9383, 9382
39772, 9360, 9361, 9384, 9383
39773, 9361, 9362, 9385, 9384
39774, 9362, 9363, 9386, 9385
39775, 9363, 9364, 9387, 9386
39776, 9364, 9365, 9388, 9387
39777, 9365, 9366, 9389, 9388
39778, 9366, 9367, 9390, 9389
39779, 9367, 9368, 9391, 9390
39780, 9368, 9369, 9392, 9391
39781, 9369, 9370, 9393, 9392
39782, 9370, 9371, 9394, 9393
39783, 9371, 9372, 9395, 9394
39784, 9372, 9373, 9396, 9395
39785, 9373, 9374, 9397, 9396
39786, 9374, 9375, 9398, 9397
39787, 9375, 1404, 1405, 9398
39788, 1382, 9376, 9399, 1383
39789, 9376, 9377, 9400, 9399
39790, 9377, 9378, 9401, 9400
39791, 9378, 9379, 9402, 9401
39792, 9379, 9380, 9403, 9402
39793, 9380, 9381, 9404, 9403
39794, 9381, 9382, 9405, 9404
39795, 9382, 9383, 9406, 9405
39796, 9383, 9384, 9407, 9406
39797, 9384, 9385, 9408, 9407
39798, 9385, 9386, 9409, 9408
39799, 9386, 9387, 9410, 9409
39800, 9387, 9388, 9411, 9410
39801, 9388, 9389, 9412, 9411
39802, 9389, 9390, 9413, 9412
39803, 9390, 9391, 9414, 9413
39804, 9391, 9392, 9415, 9414
39805, 9392, 9393, 9416, 9415
39806, 9393, 9394, 9417, 9416
39807, 9394, 9395, 9418, 9417
39808, 9395, 9396, 9419, 9418
39809, 9396, 9397, 9420, 9419
39810, 9397, 9398, 9421, 9420
39811, 9398, 1405, 1406, 9421
39812, 1383, 9399, 9422, 1384
39813, 9399, 9400, 9423, 9422
39814, 9400, 9401, 9424, 9423
39815, 9401, 9402, 9425, 9424
39816, 9402, 9403, 9426, 9425
39817, 9403, 9404, 9427, 9426
39818, 9404, 9405, 9428, 9427
39819, 9405, 9406, 9429, 9428
39820, 9406, 9407, 9430, 9429
39821, 9407, 9408, 9431, 9430
39822, 9408, 9409, 9432, 9431
39823, 9409, 9410, 9433, 9432
39824, 9410, 9411, 9434, 9433
39825, 9411, 9412, 9435, 9434
39826, 9412, 9413, 9436, 9435
39827, 9413, 9414, 9437, 9436
39828, 9414, 9415, 9438, 9437
39829, 9415, 9416, 9439, 9438
39830, 9416, 9417, 9440, 9439
39831, 9417, 9418, 9441, 9440
39832, 9418, 9419, 9442, 9441
39833, 9419, 9420, 9443, 9442
39834, 9420, 9421, 9444, 9443
39835, 9421, 1406, 1407, 9444
39836, 1384, 9422, 9445, 1385
39837, 9422, 9423, 9446, 9445
39838, 9423, 9424, 9447, 9446
39839, 9424, 9425, 9448, 9447
39840, 9425, 9426, 9449, 9448
39841, 9426, 9427, 9450, 9449
39842, 9427, 9428, 9451, 9450
39843, 9428, 9429, 9452, 9451
39844, 9429, 9430, 9453, 9452
39845, 9430, 9431, 9454, 9453
39846, 9431, 9432, 9455, 9454
39847, 9432, 9433, 9456, 9455
39848, 9433, 9434, 9457, 9456
39849, 9434, 9435, 9458, 9457
39850, 9435, 9436, 9459, 9458
39851, 9436, 9437, 9460, 9459
39852, 9437, 9438, 9461, 9460
39853, 9438, 9439, 9462, 9461
39854, 9439, 9440, 9463, 9462
39855, 9440, 9441, 9464, 9463
39856, 9441, 9442, 9465, 9464
39857, 9442, 9443, 9466, 9465
39858, 9443, 9444, 9467, 9466
39859, 9444, 1407, 1408, 9467
39860, 1385, 9445, 9468, 1386
39861, 9445, 9446, 9469, 9468
39862, 9446, 9447, 9470, 9469
39863, 9447, 9448, 9471, 9470
39864, 9448, 9449, 9472, 9471
39865, 9449, 9450, 9473, 9472
39866, 9450, 9451, 9474, 9473
39867, 9451, 9452, 9475, 9474
39868, 9452, 9453, 9476, 9475
39869, 9453, 9454, 9477, 9476
39870, 9454, 9455, 9478, 9477
39871, 9455, 9456, 9479, 9478
39872, 9456, 9457, 9480, 9479
39873, 9457, 9458, 9481, 9480
39874, 9458, 9459, 9482, 9481
39875, 9459, 9460, 9483, 9482
39876, 9460, 9461, 9484, 9483
39877, 9461, 9462, 9485, 9484
39878, 9462, 9463, 9486, 9485
39879, 9463, 9464, 9487, 9486
39880, 9464, 9465, 9488, 9487
39881, 9465, 9466, 9489, 9488
39882, 9466, 9467, 9490, 9489
39883, 9467, 1408, 1409, 9490
39884, 1386, 9468, 9491, 1387
39885, 9468, 9469, 9492, 9491
39886, 9469, 9470, 9493, 9492
39887, 9470, 9471, 9494, 9493
39888, 9471, 9472, 9495, 9494
39889, 9472, 9473, 9496, 9495
39890, 9473, 9474, 9497, 9496
39891, 9474, 9475, 9498, 9497
39892, 9475, 9476, 9499, 9498
39893, 9476, 9477, 9500, 9499
39894, 9477, 9478, 9501, 9500
39895, 9478, 9479, 9502, 9501
39896, 9479, 9480, 9503, 9502
39897, 9480, 9481, 9504, 9503
39898, 9481, 9482, 9505, 9504
39899, 9482, 9483, 9506, 9505
39900, 9483, 9484, 9507, 9506
39901, 9484, 9485, 9508, 9507
39902, 9485, 9486, 9509, 9508
39903, 9486, 9487, 9510, 9509
39904, 9487, 9488, 9511, 9510
39905, 9488, 9489, 9512, 9511
39906, 9489, 9490, 9513, 9512
39907, 9490, 1409, 1410, 9513
39908, 1387, 9491, 9514, 1388
39909, 9491, 9492, 9515, 9514
39910, 9492, 9493, 9516, 9515
39911, 9493, 9494, 9517, 9516
39912, 9494, 9495, 9518, 9517
39913, 9495, 9496, 9519, 9518
39914, 9496, 9497, 9520, 9519
39915, 9497, 9498, 9521, 9520
39916, 9498, 9499, 9522, 9521
39917, 9499, 9500, 9523, 9522
39918, 9500, 9501, 9524, 9523
39919, 9501, 9502, 9525, 9524
39920, 9502, 9503, 9526, 9525
39921, 9503, 9504, 9527, 9526
39922, 9504, 9505, 9528, 9527
39923, 9505, 9506, 9529, 9528
39924, 9506, 9507, 9530, 9529
39925, 9507, 9508, 9531, 9530
39926, 9508, 9509, 9532, 9531
39927, 9509, 9510, 9533, 9532
39928, 9510, 9511, 9534, 9533
39929, 9511, 9512, 9535, 9534
39930, 9512, 9513, 9536, 9535
39931, 9513, 1410, 1411, 9536
39932, 1388, 9514, 9537, 1389
39933, 9514, 9515, 9538, 9537
39934, 9515, 9516, 9539, 9538
39935, 9516, 9517, 9540, 9539
39936, 9517, 9518, 9541, 9540
39937, 9518, 9519, 9542, 9541
39938, 9519, 9520, 9543, 9542
39939, 9520, 9521, 9544, 9543
39940, 9521, 9522, 9545, 9544
39941, 9522, 9523, 9546, 9545
39942, 9523, 9524, 9547, 9546
39943, 9524, 9525, 9548, 9547
39944, 9525, 9526, 9549, 9548
39945, 9526, 9527, 9550, 9549
39946, 9527, 9528, 9551, 9550
39947, 9528, 9529, 9552, 9551
39948, 9529, 9530, 9553, 9552
39949, 9530, 9531, 9554, 9553
39950, 9531, 9532, 9555, 9554
39951, 9532, 9533, 9556, 9555
39952, 9533, 9534, 9557, 9556
39953, 9534, 9535, 9558, 9557
39954, 9535, 9536, 9559, 9558
39955, 9536, 1411, 1412, 9559
39956, 1389, 9537, 9560, 1390
39957, 9537, 9538, 9561, 9560
39958, 9538, 9539, 9562, 9561
39959, 9539, 9540, 9563, 9562
39960, 9540, 9541, 9564, 9563
39961, 9541, 9542, 9565, 9564
39962, 9542, 9543, 9566, 9565
39963, 9543, 9544, 9567, 9566
39964, 9544, 9545, 9568, 9567
39965, 9545, 9546, 9569, 9568
39966, 9546, 9547, 9570, 9569
39967, 9547, 9548, 9571, 9570
39968, 9548, 9549, 9572, 9571
39969, 9549, 9550, 9573, 9572
39970, 9550, 9551, 9574, 9573
39971, 9551, 9552, 9575, 9574
39972, 9552, 9553, 9576, 9575
39973, 9553, 9554, 9577, 9576
39974, 9554, 9555, 9578, 9577
39975, 9555, 9556, 9579, 9578
39976, 9556, 9557, 9580, 9579
39977, 9557, 9558, 9581, 9580
39978, 9558, 9559, 9582, 9581
39979, 9559, 1412, 1413, 9582
39980, 1390, 9560, 9583, 1391
39981, 9560, 9561, 9584, 9583
39982, 9561, 9562, 9585, 9584
39983, 9562, 9563, 9586, 9585
39984, 9563, 9564, 9587, 9586
39985, 9564, 9565, 9588, 9587
39986, 9565, 9566, 9589, 9588
39987, 9566, 9567, 9590, 9589
39988, 9567, 9568, 9591, 9590
39989, 9568, 9569, 9592, 9591
39990, 9569, 9570, 9593, 9592
39991, 9570, 9571, 9594, 9593
39992, 9571, 9572, 9595, 9594
39993, 9572, 9573, 9596, 9595
39994, 9573, 9574, 9597, 9596
39995, 9574, 9575, 9598, 9597
39996, 9575, 9576, 9599, 9598
39997, 9576, 9577, 9600, 9599
39998, 9577, 9578, 9601, 9600
39999, 9578, 9579, 9602, 9601
40000, 9579, 9580, 9603, 9602
40001, 9580, 9581, 9604, 9603
40002, 9581, 9582, 9605, 9604
40003, 9582, 1413, 1414, 9605
40004, 1391, 9583, 9606, 1392
40005, 9583, 9584, 9607, 9606
40006, 9584, 9585, 9608, 9607
40007, 9585, 9586, 9609, 9608
40008, 9586, 9587, 9610, 9609
40009, 9587, 9588, 9611, 9610
40010, 9588, 9589, 9612, 9611
40011, 9589, 9590, 9613, 9612
40012, 9590, 9591, 9614, 9613
40013, 9591, 9592, 9615, 9614
40014, 9592, 9593, 9616, 9615
40015, 9593, 9594, 9617, 9616
40016, 9594, 9595, 9618, 9617
40017, 9595, 9596, 9619, 9618
40018, 9596, 9597, 9620, 9619
40019, 9597, 9598, 9621, 9620
40020, 9598, 9599, 9622, 9621
40021, 9599, 9600, 9623, 9622
40022, 9600, 9601, 9624, 9623
40023, 9601, 9602, 9625, 9624
40024, 9602, 9603, 9626, 9625
40025, 9603, 9604, 9627, 9626
40026, 9604, 9605, 9628, 9627
40027, 9605, 1414, 1415, 9628
40028, 1392, 9606, 9629, 1393
40029, 9606, 9607, 9630, 9629
40030, 9607, 9608, 9631, 9630
