21361, 1.6583333333333, 0.35, 0.125
21362, 1.6583333333333, 0.3, 0.125
21363, 1.6583333333333, 0.25, 0.125
21364, 1.6583333333333, 0.2, 0.125
21365, 1.7, 1.3, 0.125
21366, 1.7, 1.25, 0.125
21367, 1.7, 1.2, 0.125
21368, 1.7, 1.15, 0.125
21369, 1.7, 1.1, 0.125
21370, 1.7, 1.05, 0.125
21371, 1.7, 1, 0.125
21372, 1.7, 0.95, 0.125
21373, 1.7, 0.9, 0.125
21374, 1.7, 0.85, 0.125
21375, 1.7, 0.8, 0.125
21376, 1.7, 0.75, 0.125
21377, 1.7, 0.7, 0.125
21378, 1.7, 0.65, 0.125
21379, 1.7, 0.6, 0.125
21380, 1.7, 0.55, 0.125
21381, 1.7, 0.5, 0.125
21382, 1.7, 0.45, 0.125
21383, 1.7, 0.4, 0.125
21384, 1.7, 0.35, 0.125
21385, 1.7, 0.3, 0.125
21386, 1.7, 0.25, 0.125
21387, 1.7, 0.2, 0.125
21388, 1.7416666666667, 1.3, 0.125
21389, 1.7416666666667, 1.25, 0.125
21390, 1.7416666666667, 1.2, 0.125
21391, 1.7416666666667, 1.15, 0.125
21392, 1.7416666666667, 1.1, 0.125
21393, 1.7416666666667, 1.05, 0.125
21394, 1.7416666666667, 1, 0.125
21395, 1.7416666666667, 0.95, 0.125
21396, 1.7416666666667, 0.9, 0.125
21397, 1.7416666666667, 0.85, 0.125
21398, 1.7416666666667, 0.8, 0.125
21399, 1.7416666666667, 0.75, 0.125
21400, 1.7416666666667, 0.7, 0.125
21401, 1.7416666666667, 0.65, 0.125
21402, 1.7416666666667, 0.6, 0.125
21403, 1.7416666666667, 0.55, 0.125
21404, 1.7416666666667, 0.5, 0.125
21405, 1.7416666666667, 0.45, 0.125
21406, 1.7416666666667, 0.4, 0.125
21407, 1.7416666666667, 0.35, 0.125
21408, 1.7416666666667, 0.3, 0.125
21409, 1.7416666666667, 0.25, 0.125
21410, 1.7416666666667, 0.2, 0.125
21411, 1.7833333333333, 1.3, 0.125
21412, 1.7833333333333, 1.25, 0.125
21413, 1.7833333333333, 1.2, 0.125
21414, 1.7833333333333, 1.15, 0.125
21415, 1.7833333333333, 1.1, 0.125
21416, 1.7833333333333, 1.05, 0.125
21417, 1.7833333333333, 1, 0.125
21418, 1.7833333333333, 0.95, 0.125
21419, 1.7833333333333, 0.9, 0.125
21420, 1.7833333333333, 0.85, 0.125
21421, 1.7833333333333, 0.8, 0.125
21422, 1.7833333333333, 0.75, 0.125
21423, 1.7833333333333, 0.7, 0.125
21424, 1.7833333333333, 0.65, 0.125
21425, 1.7833333333333, 0.6, 0.125
21426, 1.7833333333333, 0.55, 0.125
21427, 1.7833333333333, 0.5, 0.125
21428, 1.7833333333333, 0.45, 0.125
21429, 1.7833333333333, 0.4, 0.125
21430, 1.7833333333333, 0.35, 0.125
21431, 1.7833333333333, 0.3, 0.125
21432, 1.7833333333333, 0.25, 0.125
21433, 1.7833333333333, 0.2, 0.125
21434, 1.825, 1.3, 0.125
21435, 1.825, 1.25, 0.125
21436, 1.825, 1.2, 0.125
21437, 1.825, 1.15, 0.125
21438, 1.825, 1.1, 0.125
21439, 1.825, 1.05, 0.125
21440, 1.825, 1, 0.125
21441, 1.825, 0.95, 0.125
21442, 1.825, 0.9, 0.125
21443, 1.825, 0.85, 0.125
21444, 1.825, 0.8, 0.125
21445, 1.825, 0.75, 0.125
21446, 1.825, 0.7, 0.125
21447, 1.825, 0.65, 0.125
21448, 1.825, 0.6, 0.125
21449, 1.825, 0.55, 0.125
21450, 1.825, 0.5, 0.125
21451, 1.825, 0.45, 0.125
21452, 1.825, 0.4, 0.125
21453, 1.825, 0.35, 0.125
21454, 1.825, 0.3, 0.125
21455, 1.825, 0.25, 0.125
21456, 1.825, 0.2, 0.125
21457, 1.8666666666667, 1.3, 0.125
21458, 1.8666666666667, 1.25, 0.125
21459, 1.8666666666667, 1.2, 0.125
21460, 1.8666666666667, 1.15, 0.125
21461, 1.8666666666667, 1.1, 0.125
21462, 1.8666666666667, 1.05, 0.125
21463, 1.8666666666667, 1, 0.125
21464, 1.8666666666667, 0.95, 0.125
21465, 1.8666666666667, 0.9, 0.125
21466, 1.8666666666667, 0.85, 0.125
21467, 1.8666666666667, 0.8, 0.125
21468, 1.8666666666667, 0.75, 0.125
21469, 1.8666666666667, 0.7, 0.125
21470, 1.8666666666667, 0.65, 0.125
21471, 1.8666666666667, 0.6, 0.125
21472, 1.8666666666667, 0.55, 0.125
21473, 1.8666666666667, 0.5, 0.125
21474, 1.8666666666667, 0.45, 0.125
21475, 1.8666666666667, 0.4, 0.125
21476, 1.8666666666667, 0.35, 0.125
21477, 1.8666666666667, 0.3, 0.125
21478, 1.8666666666667, 0.25, 0.125
21479, 1.8666666666667, 0.2, 0.125
21480, 1.9083333333333, 1.3, 0.125
21481, 1.9083333333333, 1.25, 0.125
21482, 1.9083333333333, 1.2, 0.125
21483, 1.9083333333333, 1.15, 0.125
21484, 1.9083333333333, 1.1, 0.125
21485, 1.9083333333333, 1.05, 0.125
21486, 1.9083333333333, 1, 0.125
21487, 1.9083333333333, 0.95, 0.125
21488, 1.9083333333333, 0.9, 0.125
21489, 1.9083333333333, 0.85, 0.125
21490, 1.9083333333333, 0.8, 0.125
21491, 1.9083333333333, 0.75, 0.125
21492, 1.9083333333333, 0.7, 0.125
21493, 1.9083333333333, 0.65, 0.125
21494, 1.9083333333333, 0.6, 0.125
21495, 1.9083333333333, 0.55, 0.125
21496, 1.9083333333333, 0.5, 0.125
21497, 1.9083333333333, 0.45, 0.125
21498, 1.9083333333333, 0.4, 0.125
21499, 1.9083333333333, 0.35, 0.125
21500, 1.9083333333333, 0.3, 0.125
21501, 1.9083333333333, 0.25, 0.125
21502, 1.9083333333333, 0.2, 0.125
21503, 1.95, 1.3, 0.125
21504, 1.95, 1.25, 0.125
21505, 1.95, 1.2, 0.125
21506, 1.95, 1.15, 0.125
21507, 1.95, 1.1, 0.125
21508, 1.95, 1.05, 0.125
21509, 1.95, 1, 0.125
21510, 1.95, 0.95, 0.125
21511, 1.95, 0.9, 0.125
21512, 1.95, 0.85, 0.125
21513, 1.95, 0.8, 0.125
21514, 1.95, 0.75, 0.125
21515, 1.95, 0.7, 0.125
21516, 1.95, 0.65, 0.125
21517, 1.95, 0.6, 0.125
21518, 1.95, 0.55, 0.125
21519, 1.95, 0.5, 0.125
21520, 1.95, 0.45, 0.125
21521, 1.95, 0.4, 0.125
21522, 1.95, 0.35, 0.125
21523, 1.95, 0.3, 0.125
21524, 1.95, 0.25, 0.125
21525, 1.95, 0.2, 0.125
21526, 1.9916666666667, 1.3, 0.125
21527, 1.9916666666667, 1.25, 0.125
21528, 1.9916666666667, 1.2, 0.125
21529, 1.9916666666667, 1.15, 0.125
21530, 1.9916666666667, 1.1, 0.125
21531, 1.9916666666667, 1.05, 0.125
21532, 1.9916666666667, 1, 0.125
21533, 1.9916666666667, 0.95, 0.125
21534, 1.9916666666667, 0.9, 0.125
21535, 1.9916666666667, 0.85, 0.125
21536, 1.9916666666667, 0.8, 0.125
21537, 1.9916666666667, 0.75, 0.125
21538, 1.9916666666667, 0.7, 0.125
21539, 1.9916666666667, 0.65, 0.125
21540, 1.9916666666667, 0.6, 0.125
21541, 1.9916666666667, 0.55, 0.125
21542, 1.9916666666667, 0.5, 0.125
21543, 1.9916666666667, 0.45, 0.125
21544, 1.9916666666667, 0.4, 0.125
21545, 1.9916666666667, 0.35, 0.125
21546, 1.9916666666667, 0.3, 0.125
21547, 1.9916666666667, 0.25, 0.125
21548, 1.9916666666667, 0.2, 0.125
21549, 2.0333333333333, 1.3, 0.125
21550, 2.0333333333333, 1.25, 0.125
21551, 2.0333333333333, 1.2, 0.125
21552, 2.0333333333333, 1.15, 0.125
21553, 2.0333333333333, 1.1, 0.125
21554, 2.0333333333333, 1.05, 0.125
21555, 2.0333333333333, 1, 0.125
21556, 2.0333333333333, 0.95, 0.125
21557, 2.0333333333333, 0.9, 0.125
21558, 2.0333333333333, 0.85, 0.125
21559, 2.0333333333333, 0.8, 0.125
21560, 2.0333333333333, 0.75, 0.125
21561, 2.0333333333333, 0.7, 0.125
21562, 2.0333333333333, 0.65, 0.125
21563, 2.0333333333333, 0.6, 0.125
21564, 2.0333333333333, 0.55, 0.125
21565, 2.0333333333333, 0.5, 0.125
21566, 2.0333333333333, 0.45, 0.125
21567, 2.0333333333333, 0.4, 0.125
21568, 2.0333333333333, 0.35, 0.125
21569, 2.0333333333333, 0.3, 0.125
21570, 2.0333333333333, 0.25, 0.125
21571, 2.0333333333333, 0.2, 0.125
21572, 2.075, 1.3, 0.125
21573, 2.075, 1.25, 0.125
21574, 2.075, 1.2, 0.125
21575, 2.075, 1.15, 0.125
21576, 2.075, 1.1, 0.125
21577, 2.075, 1.05, 0.125
21578, 2.075, 1, 0.125
21579, 2.075, 0.95, 0.125
21580, 2.075, 0.9, 0.125
21581, 2.075, 0.85, 0.125
21582, 2.075, 0.8, 0.125
21583, 2.075, 0.75, 0.125
21584, 2.075, 0.7, 0.125
21585, 2.075, 0.65, 0.125
21586, 2.075, 0.6, 0.125
21587, 2.075, 0.55, 0.125
21588, 2.075, 0.5, 0.125
21589, 2.075, 0.45, 0.125
21590, 2.075, 0.4, 0.125
21591, 2.075, 0.35, 0.125
21592, 2.075, 0.3, 0.125
21593, 2.075, 0.25, 0.125
21594, 2.075, 0.2, 0.125
21595, 2.1166666666667, 1.3, 0.125
21596, 2.1166666666667, 1.25, 0.125
21597, 2.1166666666667, 1.2, 0.125
21598, 2.1166666666667, 1.15, 0.125
21599, 2.1166666666667, 1.1, 0.125
21600, 2.1166666666667, 1.05, 0.125
21601, 2.1166666666667, 1, 0.125
21602, 2.1166666666667, 0.95, 0.125
21603, 2.1166666666667, 0.9, 0.125
21604, 2.1166666666667, 0.85, 0.125
21605, 2.1166666666667, 0.8, 0.125
21606, 2.1166666666667, 0.75, 0.125
21607, 2.1166666666667, 0.7, 0.125
21608, 2.1166666666667, 0.65, 0.125
21609, 2.1166666666667, 0.6, 0.125
21610, 2.1166666666667, 0.55, 0.125
21611, 2.1166666666667, 0.5, 0.125
21612, 2.1166666666667, 0.45, 0.125
21613, 2.1166666666667, 0.4, 0.125
21614, 2.1166666666667, 0.35, 0.125
21615, 2.1166666666667, 0.3, 0.125
21616, 2.1166666666667, 0.25, 0.125
21617, 2.1166666666667, 0.2, 0.125
21618, 2.1583333333333, 1.3, 0.125
21619, 2.1583333333333, 1.25, 0.125
21620, 2.1583333333333, 1.2, 0.125
21621, 2.1583333333333, 1.15, 0.125
21622, 2.1583333333333, 1.1, 0.125
21623, 2.1583333333333, 1.05, 0.125
21624, 2.1583333333333, 1, 0.125
21625, 2.1583333333333, 0.95, 0.125
21626, 2.1583333333333, 0.9, 0.125
21627, 2.1583333333333, 0.85, 0.125
21628, 2.1583333333333, 0.8, 0.125
21629, 2.1583333333333, 0.75, 0.125
21630, 2.1583333333333, 0.7, 0.125
21631, 2.1583333333333, 0.65, 0.125
21632, 2.1583333333333, 0.6, 0.125
21633, 2.1583333333333, 0.55, 0.125
21634, 2.1583333333333, 0.5, 0.125
21635, 2.1583333333333, 0.45, 0.125
21636, 2.1583333333333, 0.4, 0.125
21637, 2.1583333333333, 0.35, 0.125
21638, 2.1583333333333, 0.3, 0.125
21639, 2.1583333333333, 0.25, 0.125
21640, 2.1583333333333, 0.2, 0.125
21641, 1.2416666666667, 1.3, 0.16666666666667
21642, 1.2416666666667, 1.25, 0.16666666666667
21643, 1.2416666666667, 1.2, 0.16666666666667
21644, 1.2416666666667, 1.15, 0.16666666666667
21645, 1.2416666666667, 1.1, 0.16666666666667
21646, 1.2416666666667, 1.05, 0.16666666666667
21647, 1.2416666666667, 1, 0.16666666666667
21648, 1.2416666666667, 0.95, 0.16666666666667
21649, 1.2416666666667, 0.9, 0.16666666666667
21650, 1.2416666666667, 0.85, 0.16666666666667
21651, 1.2416666666667, 0.8, 0.16666666666667
21652, 1.2416666666667, 0.75, 0.16666666666667
21653, 1.2416666666667, 0.7, 0.16666666666667
21654, 1.2416666666667, 0.65, 0.16666666666667
21655, 1.2416666666667, 0.6, 0.16666666666667
21656, 1.2416666666667, 0.55, 0.16666666666667
21657, 1.2416666666667, 0.5, 0.16666666666667
21658, 1.2416666666667, 0.45, 0.16666666666667
21659, 1.2416666666667, 0.4, 0.16666666666667
21660, 1.2416666666667, 0.35, 0.16666666666667
21661, 1.2416666666667, 0.3, 0.16666666666667
21662, 1.2416666666667, 0.25, 0.16666666666667
21663, 1.2416666666667, 0.2, 0.16666666666667
21664, 1.2833333333333, 1.3, 0.16666666666667
21665, 1.2833333333333, 1.25, 0.16666666666667
21666, 1.2833333333333, 1.2, 0.16666666666667
21667, 1.2833333333333, 1.15, 0.16666666666667
21668, 1.2833333333333, 1.1, 0.16666666666667
21669, 1.2833333333333, 1.05, 0.16666666666667
21670, 1.2833333333333, 1, 0.16666666666667
21671, 1.2833333333333, 0.95, 0.16666666666667
21672, 1.2833333333333, 0.9, 0.16666666666667
21673, 1.2833333333333, 0.85, 0.16666666666667
21674, 1.2833333333333, 0.8, 0.16666666666667
21675, 1.2833333333333, 0.75, 0.16666666666667
21676, 1.2833333333333, 0.7, 0.16666666666667
21677, 1.2833333333333, 0.65, 0.16666666666667
21678, 1.2833333333333, 0.6, 0.16666666666667
21679, 1.2833333333333, 0.55, 0.16666666666667
21680, 1.2833333333333, 0.5, 0.16666666666667
21681, 1.2833333333333, 0.45, 0.16666666666667
21682, 1.2833333333333, 0.4, 0.16666666666667
21683, 1.2833333333333, 0.35, 0.16666666666667
21684, 1.2833333333333, 0.3, 0.16666666666667
21685, 1.2833333333333, 0.25, 0.16666666666667
21686, 1.2833333333333, 0.2, 0.16666666666667
21687, 1.325, 1.3, 0.16666666666667
21688, 1.325, 1.25, 0.16666666666667
21689, 1.325, 1.2, 0.16666666666667
21690, 1.325, 1.15, 0.16666666666667
21691, 1.325, 1.1, 0.16666666666667
21692, 1.325, 1.05, 0.16666666666667
21693, 1.325, 1, 0.16666666666667
21694, 1.325, 0.95, 0.16666666666667
21695, 1.325, 0.9, 0.16666666666667
21696, 1.325, 0.85, 0.16666666666667
21697, 1.325, 0.8, 0.16666666666667
21698, 1.325, 0.75, 0.16666666666667
21699, 1.325, 0.7, 0.16666666666667
21700, 1.325, 0.65, 0.16666666666667
21701, 1.325, 0.6, 0.16666666666667
21702, 1.325, 0.55, 0.16666666666667
21703, 1.325, 0.5, 0.16666666666667
21704, 1.325, 0.45, 0.16666666666667
21705, 1.325, 0.4, 0.16666666666667
21706, 1.325, 0.35, 0.16666666666667
21707, 1.325, 0.3, 0.16666666666667
21708, 1.325, 0.25, 0.16666666666667
21709, 1.325, 0.2, 0.16666666666667
21710, 1.3666666666667, 1.3, 0.16666666666667
21711, 1.3666666666667, 1.25, 0.16666666666667
21712, 1.3666666666667, 1.2, 0.16666666666667
21713, 1.3666666666667, 1.15, 0.16666666666667
21714, 1.3666666666667, 1.1, 0.16666666666667
21715, 1.3666666666667, 1.05, 0.16666666666667
21716, 1.3666666666667, 1, 0.16666666666667
21717, 1.3666666666667, 0.95, 0.16666666666667
21718, 1.3666666666667, 0.9, 0.16666666666667
21719, 1.3666666666667, 0.85, 0.16666666666667
21720, 1.3666666666667, 0.8, 0.16666666666667
21721, 1.3666666666667, 0.75, 0.16666666666667
21722, 1.3666666666667, 0.7, 0.16666666666667
21723, 1.3666666666667, 0.65, 0.16666666666667
21724, 1.3666666666667, 0.6, 0.16666666666667
21725, 1.3666666666667, 0.55, 0.16666666666667
21726, 1.3666666666667, 0.5, 0.16666666666667
21727, 1.3666666666667, 0.45, 0.16666666666667
21728, 1.3666666666667, 0.4, 0.16666666666667
21729, 1.3666666666667, 0.35, 0.16666666666667
21730, 1.3666666666667, 0.3, 0.16666666666667
21731, 1.3666666666667, 0.25, 0.16666666666667
21732, 1.3666666666667, 0.2, 0.16666666666667
21733, 1.4083333333333, 1.3, 0.16666666666667
21734, 1.4083333333333, 1.25, 0.16666666666667
21735, 1.4083333333333, 1.2, 0.16666666666667
21736, 1.4083333333333, 1.15, 0.16666666666667
21737, 1.4083333333333, 1.1, 0.16666666666667
21738, 1.4083333333333, 1.05, 0.16666666666667
21739, 1.4083333333333, 1, 0.16666666666667
21740, 1.4083333333333, 0.95, 0.16666666666667
21741, 1.4083333333333, 0.9, 0.16666666666667
21742, 1.4083333333333, 0.85, 0.16666666666667
21743, 1.4083333333333, 0.8, 0.16666666666667
21744, 1.4083333333333, 0.75, 0.16666666666667
21745, 1.4083333333333, 0.7, 0.16666666666667
21746, 1.4083333333333, 0.65, 0.16666666666667
21747, 1.4083333333333, 0.6, 0.16666666666667
21748, 1.4083333333333, 0.55, 0.16666666666667
21749, 1.4083333333333, 0.5, 0.16666666666667
21750, 1.4083333333333, 0.45, 0.16666666666667
21751, 1.4083333333333, 0.4, 0.16666666666667
21752, 1.4083333333333, 0.35, 0.16666666666667
21753, 1.4083333333333, 0.3, 0.16666666666667
21754, 1.4083333333333, 0.25, 0.16666666666667
21755, 1.4083333333333, 0.2, 0.16666666666667
21756, 1.45, 1.3, 0.16666666666667
21757, 1.45, 1.25, 0.16666666666667
21758, 1.45, 1.2, 0.16666666666667
21759, 1.45, 1.15, 0.16666666666667
21760, 1.45, 1.1, 0.16666666666667
21761, 1.45, 1.05, 0.16666666666667
21762, 1.45, 1, 0.16666666666667
21763, 1.45, 0.95, 0.16666666666667
21764, 1.45, 0.9, 0.16666666666667
21765, 1.45, 0.85, 0.16666666666667
21766, 1.45, 0.8, 0.16666666666667
21767, 1.45, 0.75, 0.16666666666667
21768, 1.45, 0.7, 0.16666666666667
21769, 1.45, 0.65, 0.16666666666667
21770, 1.45, 0.6, 0.16666666666667
21771, 1.45, 0.55, 0.16666666666667
21772, 1.45, 0.5, 0.16666666666667
21773, 1.45, 0.45, 0.16666666666667
21774, 1.45, 0.4, 0.16666666666667
21775, 1.45, 0.35, 0.16666666666667
21776, 1.45, 0.3, 0.16666666666667
21777, 1.45, 0.25, 0.16666666666667
21778, 1.45, 0.2, 0.16666666666667
21779, 1.4916666666667, 1.3, 0.16666666666667
21780, 1.4916666666667, 1.25, 0.16666666666667
21781, 1.4916666666667, 1.2, 0.16666666666667
21782, 1.4916666666667, 1.15, 0.16666666666667
21783, 1.4916666666667, 1.1, 0.16666666666667
21784, 1.4916666666667, 1.05, 0.16666666666667
21785, 1.4916666666667, 1, 0.16666666666667
21786, 1.4916666666667, 0.95, 0.16666666666667
21787, 1.4916666666667, 0.9, 0.16666666666667
21788, 1.4916666666667, 0.85, 0.16666666666667
21789, 1.4916666666667, 0.8, 0.16666666666667
21790, 1.4916666666667, 0.75, 0.16666666666667
21791, 1.4916666666667, 0.7, 0.16666666666667
21792, 1.4916666666667, 0.65, 0.16666666666667
21793, 1.4916666666667, 0.6, 0.16666666666667
21794, 1.4916666666667, 0.55, 0.16666666666667
21795, 1.4916666666667, 0.5, 0.16666666666667
21796, 1.4916666666667, 0.45, 0.16666666666667
21797, 1.4916666666667, 0.4, 0.16666666666667
21798, 1.4916666666667, 0.35, 0.16666666666667
21799, 1.4916666666667, 0.3, 0.16666666666667
21800, 1.4916666666667, 0.25, 0.16666666666667
21801, 1.4916666666667, 0.2, 0.16666666666667
21802, 1.5333333333333, 1.3, 0.16666666666667
21803, 1.5333333333333, 1.25, 0.16666666666667
21804, 1.5333333333333, 1.2, 0.16666666666667
21805, 1.5333333333333, 1.15, 0.16666666666667
21806, 1.5333333333333, 1.1, 0.16666666666667
21807, 1.5333333333333, 1.05, 0.16666666666667
21808, 1.5333333333333, 1, 0.16666666666667
21809, 1.5333333333333, 0.95, 0.16666666666667
21810, 1.5333333333333, 0.9, 0.16666666666667
21811, 1.5333333333333, 0.85, 0.16666666666667
21812, 1.5333333333333, 0.8, 0.16666666666667
21813, 1.5333333333333, 0.75, 0.16666666666667
21814, 1.5333333333333, 0.7, 0.16666666666667
21815, 1.5333333333333, 0.65, 0.16666666666667
21816, 1.5333333333333, 0.6, 0.16666666666667
21817, 1.5333333333333, 0.55, 0.16666666666667
21818, 1.5333333333333, 0.5, 0.16666666666667
21819, 1.5333333333333, 0.45, 0.16666666666667
21820, 1.5333333333333, 0.4, 0.16666666666667
21821, 1.5333333333333, 0.35, 0.16666666666667
21822, 1.5333333333333, 0.3, 0.16666666666667
21823, 1.5333333333333, 0.25, 0.16666666666667
21824, 1.5333333333333, 0.2, 0.16666666666667
21825, 1.575, 1.3, 0.16666666666667
21826, 1.575, 1.25, 0.16666666666667
21827, 1.575, 1.2, 0.16666666666667
21828, 1.575, 1.15, 0.16666666666667
21829, 1.575, 1.1, 0.16666666666667
21830, 1.575, 1.05, 0.16666666666667
21831, 1.575, 1, 0.16666666666667
21832, 1.575, 0.95, 0.16666666666667
21833, 1.575, 0.9, 0.16666666666667
21834, 1.575, 0.85, 0.16666666666667
21835, 1.575, 0.8, 0.16666666666667
21836, 1.575, 0.75, 0.16666666666667
21837, 1.575, 0.7, 0.16666666666667
21838, 1.575, 0.65, 0.16666666666667
21839, 1.575, 0.6, 0.16666666666667
21840, 1.575, 0.55, 0.16666666666667
21841, 1.575, 0.5, 0.16666666666667
21842, 1.575, 0.45, 0.16666666666667
21843, 1.575, 0.4, 0.16666666666667
21844, 1.575, 0.35, 0.16666666666667
21845, 1.575, 0.3, 0.16666666666667
21846, 1.575, 0.25, 0.16666666666667
21847, 1.575, 0.2, 0.16666666666667
21848, 1.6166666666667, 1.3, 0.16666666666667
21849, 1.6166666666667, 1.25, 0.16666666666667
21850, 1.6166666666667, 1.2, 0.16666666666667
21851, 1.6166666666667, 1.15, 0.16666666666667
21852, 1.6166666666667, 1.1, 0.16666666666667
21853, 1.6166666666667, 1.05, 0.16666666666667
21854, 1.6166666666667, 1, 0.16666666666667
21855, 1.6166666666667, 0.95, 0.16666666666667
21856, 1.6166666666667, 0.9, 0.16666666666667
21857, 1.6166666666667, 0.85, 0.16666666666667
21858, 1.6166666666667, 0.8, 0.16666666666667
21859, 1.6166666666667, 0.75, 0.16666666666667
21860, 1.6166666666667, 0.7, 0.16666666666667
21861, 1.6166666666667, 0.65, 0.16666666666667
21862, 1.6166666666667, 0.6, 0.16666666666667
21863, 1.6166666666667, 0.55, 0.16666666666667
21864, 1.6166666666667, 0.5, 0.16666666666667
21865, 1.6166666666667, 0.45, 0.16666666666667
21866, 1.6166666666667, 0.4, 0.16666666666667
21867, 1.6166666666667, 0.35, 0.16666666666667
21868, 1.6166666666667, 0.3, 0.16666666666667
21869, 1.6166666666667, 0.25, 0.16666666666667
21870, 1.6166666666667, 0.2, 0.16666666666667
21871, 1.6583333333333, 1.3, 0.16666666666667
21872, 1.6583333333333, 1.25, 0.16666666666667
21873, 1.6583333333333, 1.2, 0.16666666666667
21874, 1.6583333333333, 1.15, 0.16666666666667
21875, 1.6583333333333, 1.1, 0.16666666666667
21876, 1.6583333333333, 1.05, 0.16666666666667
21877, 1.6583333333333, 1, 0.16666666666667
21878, 1.6583333333333, 0.95, 0.16666666666667
21879, 1.6583333333333, 0.9, 0.16666666666667
21880, 1.6583333333333, 0.85, 0.16666666666667
21881, 1.6583333333333, 0.8, 0.16666666666667
21882, 1.6583333333333, 0.75, 0.16666666666667
21883, 1.6583333333333, 0.7, 0.16666666666667
21884, 1.6583333333333, 0.65, 0.16666666666667
21885, 1.6583333333333, 0.6, 0.16666666666667
21886, 1.6583333333333, 0.55, 0.16666666666667
21887, 1.6583333333333, 0.5, 0.16666666666667
21888, 1.6583333333333, 0.45, 0.16666666666667
21889, 1.6583333333333, 0.4, 0.16666666666667
21890, 1.6583333333333, 0.35, 0.16666666666667
21891, 1.6583333333333, 0.3, 0.16666666666667
21892, 1.6583333333333, 0.25, 0.16666666666667
21893, 1.6583333333333, 0.2, 0.16666666666667
21894, 1.7, 1.3, 0.16666666666667
21895, 1.7, 1.25, 0.16666666666667
21896, 1.7, 1.2, 0.16666666666667
21897, 1.7, 1.15, 0.16666666666667
21898, 1.7, 1.1, 0.16666666666667
21899, 1.7, 1.05, 0.16666666666667
21900, 1.7, 1, 0.16666666666667
21901, 1.7, 0.95, 0.16666666666667
21902, 1.7, 0.9, 0.16666666666667
21903, 1.7, 0.85, 0.16666666666667
21904, 1.7, 0.8, 0.16666666666667
21905, 1.7, 0.75, 0.16666666666667
21906, 1.7, 0.7, 0.16666666666667
21907, 1.7, 0.65, 0.16666666666667
21908, 1.7, 0.6, 0.16666666666667
21909, 1.7, 0.55, 0.16666666666667
21910, 1.7, 0.5, 0.16666666666667
21911, 1.7, 0.45, 0.16666666666667
21912, 1.7, 0.4, 0.16666666666667
21913, 1.7, 0.35, 0.16666666666667
21914, 1.7, 0.3, 0.16666666666667
21915, 1.7, 0.25, 0.16666666666667
21916, 1.7, 0.2, 0.16666666666667
21917, 1.7416666666667, 1.3, 0.16666666666667
21918, 1.7416666666667, 1.25, 0.16666666666667
21919, 1.7416666666667, 1.2, 0.16666666666667
21920, 1.7416666666667, 1.15, 0.16666666666667
21921, 1.7416666666667, 1.1, 0.16666666666667
21922, 1.7416666666667, 1.05, 0.16666666666667
21923, 1.7416666666667, 1, 0.16666666666667
21924, 1.7416666666667, 0.95, 0.16666666666667
21925, 1.7416666666667, 0.9, 0.16666666666667
21926, 1.7416666666667, 0.85, 0.16666666666667
21927, 1.7416666666667, 0.8, 0.16666666666667
21928, 1.7416666666667, 0.75, 0.16666666666667
21929, 1.7416666666667, 0.7, 0.16666666666667
21930, 1.7416666666667, 0.65, 0.16666666666667
21931, 1.7416666666667, 0.6, 0.16666666666667
21932, 1.7416666666667, 0.55, 0.16666666666667
21933, 1.7416666666667, 0.5, 0.16666666666667
21934, 1.7416666666667, 0.45, 0.16666666666667
21935, 1.7416666666667, 0.4, 0.16666666666667
21936, 1.7416666666667, 0.35, 0.16666666666667
21937, 1.7416666666667, 0.3, 0.16666666666667
21938, 1.7416666666667, 0.25, 0.16666666666667
21939, 1.7416666666667, 0.2, 0.16666666666667
21940, 1.7833333333333, 1.3, 0.16666666666667
21941, 1.7833333333333, 1.25, 0.16666666666667
21942, 1.7833333333333, 1.2, 0.16666666666667
21943, 1.7833333333333, 1.15, 0.16666666666667
21944, 1.7833333333333, 1.1, 0.16666666666667
21945, 1.7833333333333, 1.05, 0.16666666666667
21946, 1.7833333333333, 1, 0.16666666666667
21947, 1.7833333333333, 0.95, 0.16666666666667
21948, 1.7833333333333, 0.9, 0.16666666666667
21949, 1.7833333333333, 0.85, 0.16666666666667
21950, 1.7833333333333, 0.8, 0.16666666666667
21951, 1.7833333333333, 0.75, 0.16666666666667
21952, 1.7833333333333, 0.7, 0.16666666666667
21953, 1.7833333333333, 0.65, 0.16666666666667
21954, 1.7833333333333, 0.6, 0.16666666666667
21955, 1.7833333333333, 0.55, 0.16666666666667
21956, 1.7833333333333, 0.5, 0.16666666666667
21957, 1.7833333333333, 0.45, 0.16666666666667
21958, 1.7833333333333, 0.4, 0.16666666666667
21959, 1.7833333333333, 0.35, 0.16666666666667
21960, 1.7833333333333, 0.3, 0.16666666666667
21961, 1.7833333333333, 0.25, 0.16666666666667
21962, 1.7833333333333, 0.2, 0.16666666666667
21963, 1.825, 1.3, 0.16666666666667
21964, 1.825, 1.25, 0.16666666666667
21965, 1.825, 1.2, 0.16666666666667
21966, 1.825, 1.15, 0.16666666666667
21967, 1.825, 1.1, 0.16666666666667
21968, 1.825, 1.05, 0.16666666666667
21969, 1.825, 1, 0.16666666666667
21970, 1.825, 0.95, 0.16666666666667
21971, 1.825, 0.9, 0.16666666666667
21972, 1.825, 0.85, 0.16666666666667
21973, 1.825, 0.8, 0.16666666666667
21974, 1.825, 0.75, 0.16666666666667
21975, 1.825, 0.7, 0.16666666666667
21976, 1.825, 0.65, 0.16666666666667
21977, 1.825, 0.6, 0.16666666666667
21978, 1.825, 0.55, 0.16666666666667
21979, 1.825, 0.5, 0.16666666666667
21980, 1.825, 0.45, 0.16666666666667
21981, 1.825, 0.4, 0.16666666666667
21982, 1.825, 0.35, 0.16666666666667
21983, 1.825, 0.3, 0.16666666666667
21984, 1.825, 0.25, 0.16666666666667
21985, 1.825, 0.2, 0.16666666666667
21986, 1.8666666666667, 1.3, 0.16666666666667
21987, 1.8666666666667, 1.25, 0.16666666666667
21988, 1.8666666666667, 1.2, 0.16666666666667
21989, 1.8666666666667, 1.15, 0.16666666666667
21990, 1.8666666666667, 1.1, 0.16666666666667
21991, 1.8666666666667, 1.05, 0.16666666666667
21992, 1.8666666666667, 1, 0.16666666666667
21993, 1.8666666666667, 0.95, 0.16666666666667
21994, 1.8666666666667, 0.9, 0.16666666666667
21995, 1.8666666666667, 0.85, 0.16666666666667
21996, 1.8666666666667, 0.8, 0.16666666666667
21997, 1.8666666666667, 0.75, 0.16666666666667
21998, 1.8666666666667, 0.7, 0.16666666666667
21999, 1.8666666666667, 0.65, 0.16666666666667
22000, 1.8666666666667, 0.6, 0.16666666666667
22001, 1.8666666666667, 0.55, 0.16666666666667
22002, 1.8666666666667, 0.5, 0.16666666666667
22003, 1.8666666666667, 0.45, 0.16666666666667
22004, 1.8666666666667, 0.4, 0.16666666666667
22005, 1.8666666666667, 0.35, 0.16666666666667
22006, 1.8666666666667, 0.3, 0.16666666666667
22007, 1.8666666666667, 0.25, 0.16666666666667
22008, 1.8666666666667, 0.2, 0.16666666666667
22009, 1.9083333333333, 1.3, 0.16666666666667
22010, 1.9083333333333, 1.25, 0.16666666666667
22011, 1.9083333333333, 1.2, 0.16666666666667
22012, 1.9083333333333, 1.15, 0.16666666666667
22013, 1.9083333333333, 1.1, 0.16666666666667
22014, 1.9083333333333, 1.05, 0.16666666666667
22015, 1.9083333333333, 1, 0.16666666666667
22016, 1.9083333333333, 0.95, 0.16666666666667
22017, 1.9083333333333, 0.9, 0.16666666666667
22018, 1.9083333333333, 0.85, 0.16666666666667
22019, 1.9083333333333, 0.8, 0.16666666666667
22020, 1.9083333333333, 0.75, 0.16666666666667
22021, 1.9083333333333, 0.7, 0.16666666666667
22022, 1.9083333333333, 0.65, 0.16666666666667
22023, 1.9083333333333, 0.6, 0.16666666666667
22024, 1.9083333333333, 0.55, 0.16666666666667
22025, 1.9083333333333, 0.5, 0.16666666666667
22026, 1.9083333333333, 0.45, 0.16666666666667
22027, 1.9083333333333, 0.4, 0.16666666666667
22028, 1.9083333333333, 0.35, 0.16666666666667
22029, 1.9083333333333, 0.3, 0.16666666666667
22030, 1.9083333333333, 0.25, 0.16666666666667
22031, 1.9083333333333, 0.2, 0.16666666666667
22032, 1.95, 1.3, 0.16666666666667
22033, 1.95, 1.25, 0.16666666666667
22034, 1.95, 1.2, 0.16666666666667
22035, 1.95, 1.15, 0.16666666666667
22036, 1.95, 1.1, 0.16666666666667
22037, 1.95, 1.05, 0.16666666666667
22038, 1.95, 1, 0.16666666666667
22039, 1.95, 0.95, 0.16666666666667
22040, 1.95, 0.9, 0.16666666666667
22041, 1.95, 0.85, 0.16666666666667
22042, 1.95, 0.8, 0.16666666666667
22043, 1.95, 0.75, 0.16666666666667
22044, 1.95, 0.7, 0.16666666666667
22045, 1.95, 0.65, 0.16666666666667
22046, 1.95, 0.6, 0.16666666666667
22047, 1.95, 0.55, 0.16666666666667
22048, 1.95, 0.5, 0.16666666666667
22049, 1.95, 0.45, 0.16666666666667
22050, 1.95, 0.4, 0.16666666666667
22051, 1.95, 0.35, 0.16666666666667
22052, 1.95, 0.3, 0.16666666666667
22053, 1.95, 0.25, 0.16666666666667
22054, 1.95, 0.2, 0.16666666666667
22055, 1.9916666666667, 1.3, 0.16666666666667
22056, 1.9916666666667, 1.25, 0.16666666666667
22057, 1.9916666666667, 1.2, 0.16666666666667
22058, 1.9916666666667, 1.15, 0.16666666666667
22059, 1.9916666666667, 1.1, 0.16666666666667
22060, 1.9916666666667, 1.05, 0.16666666666667
22061, 1.9916666666667, 1, 0.16666666666667
22062, 1.9916666666667, 0.95, 0.16666666666667
22063, 1.9916666666667, 0.9, 0.16666666666667
22064, 1.9916666666667, 0.85, 0.16666666666667
22065, 1.9916666666667, 0.8, 0.16666666666667
22066, 1.9916666666667, 0.75, 0.16666666666667
22067, 1.9916666666667, 0.7, 0.16666666666667
22068, 1.9916666666667, 0.65, 0.16666666666667
22069, 1.9916666666667, 0.6, 0.16666666666667
22070, 1.9916666666667, 0.55, 0.16666666666667
22071, 1.9916666666667, 0.5, 0.16666666666667
22072, 1.9916666666667, 0.45, 0.16666666666667
22073, 1.9916666666667, 0.4, 0.16666666666667
22074, 1.9916666666667, 0.35, 0.16666666666667
22075, 1.9916666666667, 0.3, 0.16666666666667
22076, 1.9916666666667, 0.25, 0.16666666666667
22077, 1.9916666666667, 0.2, 0.16666666666667
22078, 2.0333333333333, 1.3, 0.16666666666667
22079, 2.0333333333333, 1.25, 0.16666666666667
22080, 2.0333333333333, 1.2, 0.16666666666667
22081, 2.0333333333333, 1.15, 0.16666666666667
22082, 2.0333333333333, 1.1, 0.16666666666667
22083, 2.0333333333333, 1.05, 0.16666666666667
22084, 2.0333333333333, 1, 0.16666666666667
22085, 2.0333333333333, 0.95, 0.16666666666667
22086, 2.0333333333333, 0.9, 0.16666666666667
22087, 2.0333333333333, 0.85, 0.16666666666667
22088, 2.0333333333333, 0.8, 0.16666666666667
22089, 2.0333333333333, 0.75, 0.16666666666667
22090, 2.0333333333333, 0.7, 0.16666666666667
22091, 2.0333333333333, 0.65, 0.16666666666667
22092, 2.0333333333333, 0.6, 0.16666666666667
22093, 2.0333333333333, 0.55, 0.16666666666667
22094, 2.0333333333333, 0.5, 0.16666666666667
22095, 2.0333333333333, 0.45, 0.16666666666667
22096, 2.0333333333333, 0.4, 0.16666666666667
22097, 2.0333333333333, 0.35, 0.16666666666667
22098, 2.0333333333333, 0.3, 0.16666666666667
22099, 2.0333333333333, 0.25, 0.16666666666667
22100, 2.0333333333333, 0.2, 0.16666666666667
22101, 2.075, 1.3, 0.16666666666667
22102, 2.075, 1.25, 0.16666666666667
22103, 2.075, 1.2, 0.16666666666667
22104, 2.075, 1.15, 0.16666666666667
22105, 2.075, 1.1, 0.16666666666667
22106, 2.075, 1.05, 0.16666666666667
22107, 2.075, 1, 0.16666666666667
22108, 2.075, 0.95, 0.16666666666667
22109, 2.075, 0.9, 0.16666666666667
22110, 2.075, 0.85, 0.16666666666667
22111, 2.075, 0.8, 0.16666666666667
22112, 2.075, 0.75, 0.16666666666667
22113, 2.075, 0.7, 0.16666666666667
22114, 2.075, 0.65, 0.16666666666667
22115, 2.075, 0.6, 0.16666666666667
22116, 2.075, 0.55, 0.16666666666667
22117, 2.075, 0.5, 0.16666666666667
22118, 2.075, 0.45, 0.16666666666667
22119, 2.075, 0.4, 0.16666666666667
22120, 2.075, 0.35, 0.16666666666667
22121, 2.075, 0.3, 0.16666666666667
22122, 2.075, 0.25, 0.16666666666667
22123, 2.075, 0.2, 0.16666666666667
22124, 2.1166666666667, 1.3, 0.16666666666667
22125, 2.1166666666667, 1.25, 0.16666666666667
22126, 2.1166666666667, 1.2, 0.16666666666667
22127, 2.1166666666667, 1.15, 0.16666666666667
22128, 2.1166666666667, 1.1, 0.16666666666667
22129, 2.1166666666667, 1.05, 0.16666666666667
22130, 2.1166666666667, 1, 0.16666666666667
22131, 2.1166666666667, 0.95, 0.16666666666667
22132, 2.1166666666667, 0.9, 0.16666666666667
22133, 2.1166666666667, 0.85, 0.16666666666667
22134, 2.1166666666667, 0.8, 0.16666666666667
22135, 2.1166666666667, 0.75, 0.16666666666667
22136, 2.1166666666667, 0.7, 0.16666666666667
22137, 2.1166666666667, 0.65, 0.16666666666667
22138, 2.1166666666667, 0.6, 0.16666666666667
22139, 2.1166666666667, 0.55, 0.16666666666667
22140, 2.1166666666667, 0.5, 0.16666666666667
22141, 2.1166666666667, 0.45, 0.16666666666667
22142, 2.1166666666667, 0.4, 0.16666666666667
22143, 2.1166666666667, 0.35, 0.16666666666667
22144, 2.1166666666667, 0.3, 0.16666666666667
22145, 2.1166666666667, 0.25, 0.16666666666667
22146, 2.1166666666667, 0.2, 0.16666666666667
22147, 2.1583333333333, 1.3, 0.16666666666667
22148, 2.1583333333333, 1.25, 0.16666666666667
22149, 2.1583333333333, 1.2, 0.16666666666667
22150, 2.1583333333333, 1.15, 0.16666666666667
22151, 2.1583333333333, 1.1, 0.16666666666667
22152, 2.1583333333333, 1.05, 0.16666666666667
22153, 2.1583333333333, 1, 0.16666666666667
22154, 2.1583333333333, 0.95, 0.16666666666667
22155, 2.1583333333333, 0.9, 0.16666666666667
22156, 2.1583333333333, 0.85, 0.16666666666667
22157, 2.1583333333333, 0.8, 0.16666666666667
22158, 2.1583333333333, 0.75, 0.16666666666667
22159, 2.1583333333333, 0.7, 0.16666666666667
22160, 2.1583333333333, 0.65, 0.16666666666667
22161, 2.1583333333333, 0.6, 0.16666666666667
22162, 2.1583333333333, 0.55, 0.16666666666667
22163, 2.1583333333333, 0.5, 0.16666666666667
22164, 2.1583333333333, 0.45, 0.16666666666667
22165, 2.1583333333333, 0.4, 0.16666666666667
22166, 2.1583333333333, 0.35, 0.16666666666667
22167, 2.1583333333333, 0.3, 0.16666666666667
22168, 2.1583333333333, 0.25, 0.16666666666667
22169, 2.1583333333333, 0.2, 0.16666666666667
22170, 1.2416666666667, 1.3, 0.20833333333333
22171, 1.2416666666667, 1.25, 0.20833333333333
22172, 1.2416666666667, 1.2, 0.20833333333333
22173, 1.2416666666667, 1.15, 0.20833333333333
22174, 1.2416666666667, 1.1, 0.20833333333333
22175, 1.2416666666667, 1.05, 0.20833333333333
22176, 1.2416666666667, 1, 0.20833333333333
22177, 1.2416666666667, 0.95, 0.20833333333333
22178, 1.2416666666667, 0.9, 0.20833333333333
22179, 1.2416666666667, 0.85, 0.20833333333333
22180, 1.2416666666667, 0.8, 0.20833333333333
22181, 1.2416666666667, 0.75, 0.20833333333333
22182, 1.2416666666667, 0.7, 0.20833333333333
22183, 1.2416666666667, 0.65, 0.20833333333333
22184, 1.2416666666667, 0.6, 0.20833333333333
22185, 1.2416666666667, 0.55, 0.20833333333333
22186, 1.2416666666667, 0.5, 0.20833333333333
22187, 1.2416666666667, 0.45, 0.20833333333333
22188, 1.2416666666667, 0.4, 0.20833333333333
22189, 1.2416666666667, 0.35, 0.20833333333333
22190, 1.2416666666667, 0.3, 0.20833333333333
22191, 1.2416666666667, 0.25, 0.20833333333333
22192, 1.2416666666667, 0.2, 0.20833333333333
22193, 1.2833333333333, 1.3, 0.20833333333333
22194, 1.2833333333333, 1.25, 0.20833333333333
22195, 1.2833333333333, 1.2, 0.20833333333333
22196, 1.2833333333333, 1.15, 0.20833333333333
22197, 1.2833333333333, 1.1, 0.20833333333333
22198, 1.2833333333333, 1.05, 0.20833333333333
22199, 1.2833333333333, 1, 0.20833333333333
22200, 1.2833333333333, 0.95, 0.20833333333333
22201, 1.2833333333333, 0.9, 0.20833333333333
22202, 1.2833333333333, 0.85, 0.20833333333333
22203, 1.2833333333333, 0.8, 0.20833333333333
22204, 1.2833333333333, 0.75, 0.20833333333333
22205, 1.2833333333333, 0.7, 0.20833333333333
22206, 1.2833333333333, 0.65, 0.20833333333333
22207, 1.2833333333333, 0.6, 0.20833333333333
22208, 1.2833333333333, 0.55, 0.20833333333333
22209, 1.2833333333333, 0.5, 0.20833333333333
22210, 1.2833333333333, 0.45, 0.20833333333333
22211, 1.2833333333333, 0.4, 0.20833333333333
22212, 1.2833333333333, 0.35, 0.20833333333333
22213, 1.2833333333333, 0.3, 0.20833333333333
22214, 1.2833333333333, 0.25, 0.20833333333333
22215, 1.2833333333333, 0.2, 0.20833333333333
22216, 1.325, 1.3, 0.20833333333333
22217, 1.325, 1.25, 0.20833333333333
22218, 1.325, 1.2, 0.20833333333333
22219, 1.325, 1.15, 0.20833333333333
22220, 1.325, 1.1, 0.20833333333333
22221, 1.325, 1.05, 0.20833333333333
22222, 1.325, 1, 0.20833333333333
22223, 1.325, 0.95, 0.20833333333333
22224, 1.325, 0.9, 0.20833333333333
22225, 1.325, 0.85, 0.20833333333333
22226, 1.325, 0.8, 0.20833333333333
22227, 1.325, 0.75, 0.20833333333333
22228, 1.325, 0.7, 0.20833333333333
22229, 1.325, 0.65, 0.20833333333333
22230, 1.325, 0.6, 0.20833333333333
22231, 1.325, 0.55, 0.20833333333333
22232, 1.325, 0.5, 0.20833333333333
22233, 1.325, 0.45, 0.20833333333333
22234, 1.325, 0.4, 0.20833333333333
22235, 1.325, 0.35, 0.20833333333333
22236, 1.325, 0.3, 0.20833333333333
22237, 1.325, 0.25, 0.20833333333333
22238, 1.325, 0.2, 0.20833333333333
22239, 1.3666666666667, 1.3, 0.20833333333333
22240, 1.3666666666667, 1.25, 0.20833333333333
22241, 1.3666666666667, 1.2, 0.20833333333333
22242, 1.3666666666667, 1.15, 0.20833333333333
22243, 1.3666666666667, 1.1, 0.20833333333333
22244, 1.3666666666667, 1.05, 0.20833333333333
22245, 1.3666666666667, 1, 0.20833333333333
22246, 1.3666666666667, 0.95, 0.20833333333333
22247, 1.3666666666667, 0.9, 0.20833333333333
22248, 1.3666666666667, 0.85, 0.20833333333333
22249, 1.3666666666667, 0.8, 0.20833333333333
22250, 1.3666666666667, 0.75, 0.20833333333333
22251, 1.3666666666667, 0.7, 0.20833333333333
22252, 1.3666666666667, 0.65, 0.20833333333333
22253, 1.3666666666667, 0.6, 0.20833333333333
22254, 1.3666666666667, 0.55, 0.20833333333333
22255, 1.3666666666667, 0.5, 0.20833333333333
22256, 1.3666666666667, 0.45, 0.20833333333333
22257, 1.3666666666667, 0.4, 0.20833333333333
22258, 1.3666666666667, 0.35, 0.20833333333333
22259, 1.3666666666667, 0.3, 0.20833333333333
22260, 1.3666666666667, 0.25, 0.20833333333333
22261, 1.3666666666667, 0.2, 0.20833333333333
22262, 1.4083333333333, 1.3, 0.20833333333333
22263, 1.4083333333333, 1.25, 0.20833333333333
22264, 1.4083333333333, 1.2, 0.20833333333333
22265, 1.4083333333333, 1.15, 0.20833333333333
22266, 1.4083333333333, 1.1, 0.20833333333333
22267, 1.4083333333333, 1.05, 0.20833333333333
22268, 1.4083333333333, 1, 0.20833333333333
22269, 1.4083333333333, 0.95, 0.20833333333333
22270, 1.4083333333333, 0.9, 0.20833333333333
22271, 1.4083333333333, 0.85, 0.20833333333333
22272, 1.4083333333333, 0.8, 0.20833333333333
22273, 1.4083333333333, 0.75, 0.20833333333333
22274, 1.4083333333333, 0.7, 0.20833333333333
22275, 1.4083333333333, 0.65, 0.20833333333333
22276, 1.4083333333333, 0.6, 0.20833333333333
22277, 1.4083333333333, 0.55, 0.20833333333333
22278, 1.4083333333333, 0.5, 0.20833333333333
22279, 1.4083333333333, 0.45, 0.20833333333333
22280, 1.4083333333333, 0.4, 0.20833333333333
22281, 1.4083333333333, 0.35, 0.20833333333333
22282, 1.4083333333333, 0.3, 0.20833333333333
22283, 1.4083333333333, 0.25, 0.20833333333333
22284, 1.4083333333333, 0.2, 0.20833333333333
22285, 1.45, 1.3, 0.20833333333333
22286, 1.45, 1.25, 0.20833333333333
22287, 1.45, 1.2, 0.20833333333333
22288, 1.45, 1.15, 0.20833333333333
22289, 1.45, 1.1, 0.20833333333333
22290, 1.45, 1.05, 0.20833333333333
22291, 1.45, 1, 0.20833333333333
22292, 1.45, 0.95, 0.20833333333333
22293, 1.45, 0.9, 0.20833333333333
22294, 1.45, 0.85, 0.20833333333333
22295, 1.45, 0.8, 0.20833333333333
22296, 1.45, 0.75, 0.20833333333333
22297, 1.45, 0.7, 0.20833333333333
22298, 1.45, 0.65, 0.20833333333333
22299, 1.45, 0.6, 0.20833333333333
22300, 1.45, 0.55, 0.20833333333333
22301, 1.45, 0.5, 0.20833333333333
22302, 1.45, 0.45, 0.20833333333333
22303, 1.45, 0.4, 0.20833333333333
22304, 1.45, 0.35, 0.20833333333333
22305, 1.45, 0.3, 0.20833333333333
22306, 1.45, 0.25, 0.20833333333333
22307, 1.45, 0.2, 0.20833333333333
22308, 1.4916666666667, 1.3, 0.20833333333333
22309, 1.4916666666667, 1.25, 0.20833333333333
22310, 1.4916666666667, 1.2, 0.20833333333333
22311, 1.4916666666667, 1.15, 0.20833333333333
22312, 1.4916666666667, 1.1, 0.20833333333333
22313, 1.4916666666667, 1.05, 0.20833333333333
22314, 1.4916666666667, 1, 0.20833333333333
22315, 1.4916666666667, 0.95, 0.20833333333333
22316, 1.4916666666667, 0.9, 0.20833333333333
22317, 1.4916666666667, 0.85, 0.20833333333333
22318, 1.4916666666667, 0.8, 0.20833333333333
22319, 1.4916666666667, 0.75, 0.20833333333333
22320, 1.4916666666667, 0.7, 0.20833333333333
22321, 1.4916666666667, 0.65, 0.20833333333333
22322, 1.4916666666667, 0.6, 0.20833333333333
22323, 1.4916666666667, 0.55, 0.20833333333333
22324, 1.4916666666667, 0.5, 0.20833333333333
22325, 1.4916666666667, 0.45, 0.20833333333333
22326, 1.4916666666667, 0.4, 0.20833333333333
22327, 1.4916666666667, 0.35, 0.20833333333333
22328, 1.4916666666667, 0.3, 0.20833333333333
22329, 1.4916666666667, 0.25, 0.20833333333333
22330, 1.4916666666667, 0.2, 0.20833333333333
22331, 1.5333333333333, 1.3, 0.20833333333333
22332, 1.5333333333333, 1.25, 0.20833333333333
22333, 1.5333333333333, 1.2, 0.20833333333333
22334, 1.5333333333333, 1.15, 0.20833333333333
22335, 1.5333333333333, 1.1, 0.20833333333333
22336, 1.5333333333333, 1.05, 0.20833333333333
22337, 1.5333333333333, 1, 0.20833333333333
22338, 1.5333333333333, 0.95, 0.20833333333333
22339, 1.5333333333333, 0.9, 0.20833333333333
22340, 1.5333333333333, 0.85, 0.20833333333333
22341, 1.5333333333333, 0.8, 0.20833333333333
22342, 1.5333333333333, 0.75, 0.20833333333333
22343, 1.5333333333333, 0.7, 0.20833333333333
22344, 1.5333333333333, 0.65, 0.20833333333333
22345, 1.5333333333333, 0.6, 0.20833333333333
22346, 1.5333333333333, 0.55, 0.20833333333333
22347, 1.5333333333333, 0.5, 0.20833333333333
22348, 1.5333333333333, 0.45, 0.20833333333333
22349, 1.5333333333333, 0.4, 0.20833333333333
22350, 1.5333333333333, 0.35, 0.20833333333333
22351, 1.5333333333333, 0.3, 0.20833333333333
22352, 1.5333333333333, 0.25, 0.20833333333333
22353, 1.5333333333333, 0.2, 0.20833333333333
22354, 1.575, 1.3, 0.20833333333333
22355, 1.575, 1.25, 0.20833333333333
22356, 1.575, 1.2, 0.20833333333333
22357, 1.575, 1.15, 0.20833333333333
22358, 1.575, 1.1, 0.20833333333333
22359, 1.575, 1.05, 0.20833333333333
22360, 1.575, 1, 0.20833333333333
22361, 1.575, 0.95, 0.20833333333333
22362, 1.575, 0.9, 0.20833333333333
22363, 1.575, 0.85, 0.20833333333333
22364, 1.575, 0.8, 0.20833333333333
22365, 1.575, 0.75, 0.20833333333333
22366, 1.575, 0.7, 0.20833333333333
22367, 1.575, 0.65, 0.20833333333333
22368, 1.575, 0.6, 0.20833333333333
22369, 1.575, 0.55, 0.20833333333333
22370, 1.575, 0.5, 0.20833333333333
22371, 1.575, 0.45, 0.20833333333333
22372, 1.575, 0.4, 0.20833333333333
22373, 1.575, 0.35, 0.20833333333333
22374, 1.575, 0.3, 0.20833333333333
22375, 1.575, 0.25, 0.20833333333333
22376, 1.575, 0.2, 0.20833333333333
22377, 1.6166666666667, 1.3, 0.20833333333333
22378, 1.6166666666667, 1.25, 0.20833333333333
22379, 1.6166666666667, 1.2, 0.20833333333333
22380, 1.6166666666667, 1.15, 0.20833333333333
22381, 1.6166666666667, 1.1, 0.20833333333333
22382, 1.6166666666667, 1.05, 0.20833333333333
22383, 1.6166666666667, 1, 0.20833333333333
22384, 1.6166666666667, 0.95, 0.20833333333333
22385, 1.6166666666667, 0.9, 0.20833333333333
22386, 1.6166666666667, 0.85, 0.20833333333333
22387, 1.6166666666667, 0.8, 0.20833333333333
22388, 1.6166666666667, 0.75, 0.20833333333333
22389, 1.6166666666667, 0.7, 0.20833333333333
22390, 1.6166666666667, 0.65, 0.20833333333333
22391, 1.6166666666667, 0.6, 0.20833333333333
22392, 1.6166666666667, 0.55, 0.20833333333333
22393, 1.6166666666667, 0.5, 0.20833333333333
22394, 1.6166666666667, 0.45, 0.20833333333333
22395, 1.6166666666667, 0.4, 0.20833333333333
22396, 1.6166666666667, 0.35, 0.20833333333333
22397, 1.6166666666667, 0.3, 0.20833333333333
22398, 1.6166666666667, 0.25, 0.20833333333333
22399, 1.6166666666667, 0.2, 0.20833333333333
22400, 1.6583333333333, 1.3, 0.20833333333333
22401, 1.6583333333333, 1.25, 0.20833333333333
22402, 1.6583333333333, 1.2, 0.20833333333333
22403, 1.6583333333333, 1.15, 0.20833333333333
22404, 1.6583333333333, 1.1, 0.20833333333333
22405, 1.6583333333333, 1.05, 0.20833333333333
22406, 1.6583333333333, 1, 0.20833333333333
22407, 1.6583333333333, 0.95, 0.20833333333333
22408, 1.6583333333333, 0.9, 0.20833333333333
22409, 1.6583333333333, 0.85, 0.20833333333333
22410, 1.6583333333333, 0.8, 0.20833333333333
22411, 1.6583333333333, 0.75, 0.20833333333333
22412, 1.6583333333333, 0.7, 0.20833333333333
22413, 1.6583333333333, 0.65, 0.20833333333333
22414, 1.6583333333333, 0.6, 0.20833333333333
22415, 1.6583333333333, 0.55, 0.20833333333333
22416, 1.6583333333333, 0.5, 0.20833333333333
22417, 1.6583333333333, 0.45, 0.20833333333333
22418, 1.6583333333333, 0.4, 0.20833333333333
22419, 1.6583333333333, 0.35, 0.20833333333333
22420, 1.6583333333333, 0.3, 0.20833333333333
22421, 1.6583333333333, 0.25, 0.20833333333333
22422, 1.6583333333333, 0.2, 0.20833333333333
22423, 1.7, 1.3, 0.20833333333333
22424, 1.7, 1.25, 0.20833333333333
22425, 1.7, 1.2, 0.20833333333333
22426, 1.7, 1.15, 0.20833333333333
22427, 1.7, 1.1, 0.20833333333333
22428, 1.7, 1.05, 0.20833333333333
22429, 1.7, 1, 0.20833333333333
22430, 1.7, 0.95, 0.20833333333333
22431, 1.7, 0.9, 0.20833333333333
22432, 1.7, 0.85, 0.20833333333333
22433, 1.7, 0.8, 0.20833333333333
22434, 1.7, 0.75, 0.20833333333333
22435, 1.7, 0.7, 0.20833333333333
22436, 1.7, 0.65, 0.20833333333333
22437, 1.7, 0.6, 0.20833333333333
22438, 1.7, 0.55, 0.20833333333333
22439, 1.7, 0.5, 0.20833333333333
22440, 1.7, 0.45, 0.20833333333333
22441, 1.7, 0.4, 0.20833333333333
22442, 1.7, 0.35, 0.20833333333333
22443, 1.7, 0.3, 0.20833333333333
22444, 1.7, 0.25, 0.20833333333333
22445, 1.7, 0.2, 0.20833333333333
22446, 1.7416666666667, 1.3, 0.20833333333333
22447, 1.7416666666667, 1.25, 0.20833333333333
22448, 1.7416666666667, 1.2, 0.20833333333333
22449, 1.7416666666667, 1.15, 0.20833333333333
22450, 1.7416666666667, 1.1, 0.20833333333333
22451, 1.7416666666667, 1.05, 0.20833333333333
22452, 1.7416666666667, 1, 0.20833333333333
22453, 1.7416666666667, 0.95, 0.20833333333333
22454, 1.7416666666667, 0.9, 0.20833333333333
22455, 1.7416666666667, 0.85, 0.20833333333333
22456, 1.7416666666667, 0.8, 0.20833333333333
22457, 1.7416666666667, 0.75, 0.20833333333333
22458, 1.7416666666667, 0.7, 0.20833333333333
22459, 1.7416666666667, 0.65, 0.20833333333333
22460, 1.7416666666667, 0.6, 0.20833333333333
22461, 1.7416666666667, 0.55, 0.20833333333333
22462, 1.7416666666667, 0.5, 0.20833333333333
22463, 1.7416666666667, 0.45, 0.20833333333333
22464, 1.7416666666667, 0.4, 0.20833333333333
22465, 1.7416666666667, 0.35, 0.20833333333333
22466, 1.7416666666667, 0.3, 0.20833333333333
22467, 1.7416666666667, 0.25, 0.20833333333333
22468, 1.7416666666667, 0.2, 0.20833333333333
22469, 1.7833333333333, 1.3, 0.20833333333333
22470, 1.7833333333333, 1.25, 0.20833333333333
22471, 1.7833333333333, 1.2, 0.20833333333333
22472, 1.7833333333333, 1.15, 0.20833333333333
22473, 1.7833333333333, 1.1, 0.20833333333333
22474, 1.7833333333333, 1.05, 0.20833333333333
22475, 1.7833333333333, 1, 0.20833333333333
22476, 1.7833333333333, 0.95, 0.20833333333333
22477, 1.7833333333333, 0.9, 0.20833333333333
22478, 1.7833333333333, 0.85, 0.20833333333333
22479, 1.7833333333333, 0.8, 0.20833333333333
22480, 1.7833333333333, 0.75, 0.20833333333333
22481, 1.7833333333333, 0.7, 0.20833333333333
22482, 1.7833333333333, 0.65, 0.20833333333333
22483, 1.7833333333333, 0.6, 0.20833333333333
22484, 1.7833333333333, 0.55, 0.20833333333333
22485, 1.7833333333333, 0.5, 0.20833333333333
22486, 1.7833333333333, 0.45, 0.20833333333333
22487, 1.7833333333333, 0.4, 0.20833333333333
22488, 1.7833333333333, 0.35, 0.20833333333333
22489, 1.7833333333333, 0.3, 0.20833333333333
22490, 1.7833333333333, 0.25, 0.20833333333333
22491, 1.7833333333333, 0.2, 0.20833333333333
22492, 1.825, 1.3, 0.20833333333333
22493, 1.825, 1.25, 0.20833333333333
22494, 1.825, 1.2, 0.20833333333333
22495, 1.825, 1.15, 0.20833333333333
22496, 1.825, 1.1, 0.20833333333333
22497, 1.825, 1.05, 0.20833333333333
22498, 1.825, 1, 0.20833333333333
22499, 1.825, 0.95, 0.20833333333333
22500, 1.825, 0.9, 0.20833333333333
22501, 1.825, 0.85, 0.20833333333333
22502, 1.825, 0.8, 0.20833333333333
22503, 1.825, 0.75, 0.20833333333333
22504, 1.825, 0.7, 0.20833333333333
22505, 1.825, 0.65, 0.20833333333333
22506, 1.825, 0.6, 0.20833333333333
22507, 1.825, 0.55, 0.20833333333333
22508, 1.825, 0.5, 0.20833333333333
22509, 1.825, 0.45, 0.20833333333333
22510, 1.825, 0.4, 0.20833333333333
22511, 1.825, 0.35, 0.20833333333333
22512, 1.825, 0.3, 0.20833333333333
22513, 1.825, 0.25, 0.20833333333333
22514, 1.825, 0.2, 0.20833333333333
22515, 1.8666666666667, 1.3, 0.20833333333333
22516, 1.8666666666667, 1.25, 0.20833333333333
22517, 1.8666666666667, 1.2, 0.20833333333333
22518, 1.8666666666667, 1.15, 0.20833333333333
22519, 1.8666666666667, 1.1, 0.20833333333333
22520, 1.8666666666667, 1.05, 0.20833333333333
22521, 1.8666666666667, 1, 0.20833333333333
22522, 1.8666666666667, 0.95, 0.20833333333333
22523, 1.8666666666667, 0.9, 0.20833333333333
22524, 1.8666666666667, 0.85, 0.20833333333333
22525, 1.8666666666667, 0.8, 0.20833333333333
22526, 1.8666666666667, 0.75, 0.20833333333333
22527, 1.8666666666667, 0.7, 0.20833333333333
22528, 1.8666666666667, 0.65, 0.20833333333333
22529, 1.8666666666667, 0.6, 0.20833333333333
22530, 1.8666666666667, 0.55, 0.20833333333333
22531, 1.8666666666667, 0.5, 0.20833333333333
22532, 1.8666666666667, 0.45, 0.20833333333333
22533, 1.8666666666667, 0.4, 0.20833333333333
22534, 1.8666666666667, 0.35, 0.20833333333333
22535, 1.8666666666667, 0.3, 0.20833333333333
22536, 1.8666666666667, 0.25, 0.20833333333333
22537, 1.8666666666667, 0.2, 0.20833333333333
22538, 1.9083333333333, 1.3, 0.20833333333333
22539, 1.9083333333333, 1.25, 0.20833333333333
22540, 1.9083333333333, 1.2, 0.20833333333333
22541, 1.9083333333333, 1.15, 0.20833333333333
22542, 1.9083333333333, 1.1, 0.20833333333333
22543, 1.9083333333333, 1.05, 0.20833333333333
22544, 1.9083333333333, 1, 0.20833333333333
22545, 1.9083333333333, 0.95, 0.20833333333333
22546, 1.9083333333333, 0.9, 0.20833333333333
22547, 1.9083333333333, 0.85, 0.20833333333333
22548, 1.9083333333333, 0.8, 0.20833333333333
22549, 1.9083333333333, 0.75, 0.20833333333333
22550, 1.9083333333333, 0.7, 0.20833333333333
22551, 1.9083333333333, 0.65, 0.20833333333333
22552, 1.9083333333333, 0.6, 0.20833333333333
22553, 1.9083333333333, 0.55, 0.20833333333333
22554, 1.9083333333333, 0.5, 0.20833333333333
22555, 1.9083333333333, 0.45, 0.20833333333333
22556, 1.9083333333333, 0.4, 0.20833333333333
22557, 1.9083333333333, 0.35, 0.20833333333333
22558, 1.9083333333333, 0.3, 0.20833333333333
22559, 1.9083333333333, 0.25, 0.20833333333333
22560, 1.9083333333333, 0.2, 0.20833333333333
22561, 1.95, 1.3, 0.20833333333333
22562, 1.95, 1.25, 0.20833333333333
22563, 1.95, 1.2, 0.20833333333333
22564, 1.95, 1.15, 0.20833333333333
22565, 1.95, 1.1, 0.20833333333333
22566, 1.95, 1.05, 0.20833333333333
22567, 1.95, 1, 0.20833333333333
22568, 1.95, 0.95, 0.20833333333333
22569, 1.95, 0.9, 0.20833333333333
22570, 1.95, 0.85, 0.20833333333333
22571, 1.95, 0.8, 0.20833333333333
22572, 1.95, 0.75, 0.20833333333333
22573, 1.95, 0.7, 0.20833333333333
22574, 1.95, 0.65, 0.20833333333333
22575, 1.95, 0.6, 0.20833333333333
22576, 1.95, 0.55, 0.20833333333333
22577, 1.95, 0.5, 0.20833333333333
22578, 1.95, 0.45, 0.20833333333333
22579, 1.95, 0.4, 0.20833333333333
22580, 1.95, 0.35, 0.20833333333333
22581, 1.95, 0.3, 0.20833333333333
22582, 1.95, 0.25, 0.20833333333333
22583, 1.95, 0.2, 0.20833333333333
22584, 1.9916666666667, 1.3, 0.20833333333333
22585, 1.9916666666667, 1.25, 0.20833333333333
22586, 1.9916666666667, 1.2, 0.20833333333333
22587, 1.9916666666667, 1.15, 0.20833333333333
22588, 1.9916666666667, 1.1, 0.20833333333333
22589, 1.9916666666667, 1.05, 0.20833333333333
22590, 1.9916666666667, 1, 0.20833333333333
22591, 1.9916666666667, 0.95, 0.20833333333333
22592, 1.9916666666667, 0.9, 0.20833333333333
22593, 1.9916666666667, 0.85, 0.20833333333333
22594, 1.9916666666667, 0.8, 0.20833333333333
22595, 1.9916666666667, 0.75, 0.20833333333333
22596, 1.9916666666667, 0.7, 0.20833333333333
22597, 1.9916666666667, 0.65, 0.20833333333333
22598, 1.9916666666667, 0.6, 0.20833333333333
22599, 1.9916666666667, 0.55, 0.20833333333333
22600, 1.9916666666667, 0.5, 0.20833333333333
22601, 1.9916666666667, 0.45, 0.20833333333333
22602, 1.9916666666667, 0.4, 0.20833333333333
22603, 1.9916666666667, 0.35, 0.20833333333333
22604, 1.9916666666667, 0.3, 0.20833333333333
22605, 1.9916666666667, 0.25, 0.20833333333333
22606, 1.9916666666667, 0.2, 0.20833333333333
22607, 2.0333333333333, 1.3, 0.20833333333333
22608, 2.0333333333333, 1.25, 0.20833333333333
22609, 2.0333333333333, 1.2, 0.20833333333333
22610, 2.0333333333333, 1.15, 0.20833333333333
22611, 2.0333333333333, 1.1, 0.20833333333333
22612, 2.0333333333333, 1.05, 0.20833333333333
22613, 2.0333333333333, 1, 0.20833333333333
22614, 2.0333333333333, 0.95, 0.20833333333333
22615, 2.0333333333333, 0.9, 0.20833333333333
22616, 2.0333333333333, 0.85, 0.20833333333333
22617, 2.0333333333333, 0.8, 0.20833333333333
22618, 2.0333333333333, 0.75, 0.20833333333333
22619, 2.0333333333333, 0.7, 0.20833333333333
22620, 2.0333333333333, 0.65, 0.20833333333333
22621, 2.0333333333333, 0.6, 0.20833333333333
22622, 2.0333333333333, 0.55, 0.20833333333333
22623, 2.0333333333333, 0.5, 0.20833333333333
22624, 2.0333333333333, 0.45, 0.20833333333333
22625, 2.0333333333333, 0.4, 0.20833333333333
22626, 2.0333333333333, 0.35, 0.20833333333333
22627, 2.0333333333333, 0.3, 0.20833333333333
22628, 2.0333333333333, 0.25, 0.20833333333333
22629, 2.0333333333333, 0.2, 0.20833333333333
22630, 2.075, 1.3, 0.20833333333333
22631, 2.075, 1.25, 0.20833333333333
22632, 2.075, 1.2, 0.20833333333333
22633, 2.075, 1.15, 0.20833333333333
22634, 2.075, 1.1, 0.20833333333333
22635, 2.075, 1.05, 0.20833333333333
22636, 2.075, 1, 0.20833333333333
22637, 2.075, 0.95, 0.20833333333333
22638, 2.075, 0.9, 0.20833333333333
22639, 2.075, 0.85, 0.20833333333333
22640, 2.075, 0.8, 0.20833333333333
22641, 2.075, 0.75, 0.20833333333333
22642, 2.075, 0.7, 0.20833333333333
22643, 2.075, 0.65, 0.20833333333333
22644, 2.075, 0.6, 0.20833333333333
22645, 2.075, 0.55, 0.20833333333333
22646, 2.075, 0.5, 0.20833333333333
22647, 2.075, 0.45, 0.20833333333333
22648, 2.075, 0.4, 0.20833333333333
22649, 2.075, 0.35, 0.20833333333333
22650, 2.075, 0.3, 0.20833333333333
22651, 2.075, 0.25, 0.20833333333333
22652, 2.075, 0.2, 0.20833333333333
22653, 2.1166666666667, 1.3, 0.20833333333333
22654, 2.1166666666667, 1.25, 0.20833333333333
22655, 2.1166666666667, 1.2, 0.20833333333333
22656, 2.1166666666667, 1.15, 0.20833333333333
22657, 2.1166666666667, 1.1, 0.20833333333333
22658, 2.1166666666667, 1.05, 0.20833333333333
22659, 2.1166666666667, 1, 0.20833333333333
22660, 2.1166666666667, 0.95, 0.20833333333333
22661, 2.1166666666667, 0.9, 0.20833333333333
22662, 2.1166666666667, 0.85, 0.20833333333333
22663, 2.1166666666667, 0.8, 0.20833333333333
22664, 2.1166666666667, 0.75, 0.20833333333333
22665, 2.1166666666667, 0.7, 0.20833333333333
22666, 2.1166666666667, 0.65, 0.20833333333333
22667, 2.1166666666667, 0.6, 0.20833333333333
22668, 2.1166666666667, 0.55, 0.20833333333333
22669, 2.1166666666667, 0.5, 0.20833333333333
22670, 2.1166666666667, 0.45, 0.20833333333333
22671, 2.1166666666667, 0.4, 0.20833333333333
22672, 2.1166666666667, 0.35, 0.20833333333333
22673, 2.1166666666667, 0.3, 0.20833333333333
22674, 2.1166666666667, 0.25, 0.20833333333333
22675, 2.1166666666667, 0.2, 0.20833333333333
22676, 2.1583333333333, 1.3, 0.20833333333333
22677, 2.1583333333333, 1.25, 0.20833333333333
22678, 2.1583333333333, 1.2, 0.20833333333333
22679, 2.1583333333333, 1.15, 0.20833333333333
22680, 2.1583333333333, 1.1, 0.20833333333333
22681, 2.1583333333333, 1.05, 0.20833333333333
22682, 2.1583333333333, 1, 0.20833333333333
22683, 2.1583333333333, 0.95, 0.20833333333333
22684, 2.1583333333333, 0.9, 0.20833333333333
22685, 2.1583333333333, 0.85, 0.20833333333333
22686, 2.1583333333333, 0.8, 0.20833333333333
22687, 2.1583333333333, 0.75, 0.20833333333333
22688, 2.1583333333333, 0.7, 0.20833333333333
22689, 2.1583333333333, 0.65, 0.20833333333333
22690, 2.1583333333333, 0.6, 0.20833333333333
22691, 2.1583333333333, 0.55, 0.20833333333333
22692, 2.1583333333333, 0.5, 0.20833333333333
22693, 2.1583333333333, 0.45, 0.20833333333333
22694, 2.1583333333333, 0.4, 0.20833333333333
22695, 2.1583333333333, 0.35, 0.20833333333333
22696, 2.1583333333333, 0.3, 0.20833333333333
22697, 2.1583333333333, 0.25, 0.20833333333333
22698, 2.1583333333333, 0.2, 0.20833333333333
22699, 1.2416666666667, 1.3, 0.25
22700, 1.2416666666667, 1.25, 0.25
22701, 1.2416666666667, 1.2, 0.25
22702, 1.2416666666667, 1.15, 0.25
22703, 1.2416666666667, 1.1, 0.25
22704, 1.2416666666667, 1.05, 0.25
22705, 1.2416666666667, 1, 0.25
22706, 1.2416666666667, 0.95, 0.25
22707, 1.2416666666667, 0.9, 0.25
22708, 1.2416666666667, 0.85, 0.25
22709, 1.2416666666667, 0.8, 0.25
22710, 1.2416666666667, 0.75, 0.25
22711, 1.2416666666667, 0.7, 0.25
22712, 1.2416666666667, 0.65, 0.25
22713, 1.2416666666667, 0.6, 0.25
22714, 1.2416666666667, 0.55, 0.25
22715, 1.2416666666667, 0.5, 0.25
22716, 1.2416666666667, 0.45, 0.25
22717, 1.2416666666667, 0.4, 0.25
22718, 1.2416666666667, 0.35, 0.25
22719, 1.2416666666667, 0.3, 0.25
22720, 1.2416666666667, 0.25, 0.25
22721, 1.2416666666667, 0.2, 0.25
22722, 1.2833333333333, 1.3, 0.25
22723, 1.2833333333333, 1.25, 0.25
22724, 1.2833333333333, 1.2, 0.25
22725, 1.2833333333333, 1.15, 0.25
22726, 1.2833333333333, 1.1, 0.25
22727, 1.2833333333333, 1.05, 0.25
22728, 1.2833333333333, 1, 0.25
22729, 1.2833333333333, 0.95, 0.25
22730, 1.2833333333333, 0.9, 0.25
22731, 1.2833333333333, 0.85, 0.25
22732, 1.2833333333333, 0.8, 0.25
22733, 1.2833333333333, 0.75, 0.25
22734, 1.2833333333333, 0.7, 0.25
22735, 1.2833333333333, 0.65, 0.25
22736, 1.2833333333333, 0.6, 0.25
22737, 1.2833333333333, 0.55, 0.25
22738, 1.2833333333333, 0.5, 0.25
22739, 1.2833333333333, 0.45, 0.25
22740, 1.2833333333333, 0.4, 0.25
22741, 1.2833333333333, 0.35, 0.25
22742, 1.2833333333333, 0.3, 0.25
22743, 1.2833333333333, 0.25, 0.25
22744, 1.2833333333333, 0.2, 0.25
22745, 1.325, 1.3, 0.25
22746, 1.325, 1.25, 0.25
22747, 1.325, 1.2, 0.25
22748, 1.325, 1.15, 0.25
22749, 1.325, 1.1, 0.25
22750, 1.325, 1.05, 0.25
22751, 1.325, 1, 0.25
22752, 1.325, 0.95, 0.25
22753, 1.325, 0.9, 0.25
22754, 1.325, 0.85, 0.25
22755, 1.325, 0.8, 0.25
22756, 1.325, 0.75, 0.25
22757, 1.325, 0.7, 0.25
22758, 1.325, 0.65, 0.25
22759, 1.325, 0.6, 0.25
22760, 1.325, 0.55, 0.25
22761, 1.325, 0.5, 0.25
22762, 1.325, 0.45, 0.25
22763, 1.325, 0.4, 0.25
22764, 1.325, 0.35, 0.25
22765, 1.325, 0.3, 0.25
22766, 1.325, 0.25, 0.25
22767, 1.325, 0.2, 0.25
22768, 1.3666666666667, 1.3, 0.25
22769, 1.3666666666667, 1.25, 0.25
22770, 1.3666666666667, 1.2, 0.25
22771, 1.3666666666667, 1.15, 0.25
22772, 1.3666666666667, 1.1, 0.25
22773, 1.3666666666667, 1.05, 0.25
22774, 1.3666666666667, 1, 0.25
22775, 1.3666666666667, 0.95, 0.25
22776, 1.3666666666667, 0.9, 0.25
22777, 1.3666666666667, 0.85, 0.25
22778, 1.3666666666667, 0.8, 0.25
22779, 1.3666666666667, 0.75, 0.25
22780, 1.3666666666667, 0.7, 0.25
22781, 1.3666666666667, 0.65, 0.25
22782, 1.3666666666667, 0.6, 0.25
22783, 1.3666666666667, 0.55, 0.25
22784, 1.3666666666667, 0.5, 0.25
22785, 1.3666666666667, 0.45, 0.25
22786, 1.3666666666667, 0.4, 0.25
22787, 1.3666666666667, 0.35, 0.25
22788, 1.3666666666667, 0.3, 0.25
22789, 1.3666666666667, 0.25, 0.25
22790, 1.3666666666667, 0.2, 0.25
22791, 1.4083333333333, 1.3, 0.25
22792, 1.4083333333333, 1.25, 0.25
22793, 1.4083333333333, 1.2, 0.25
22794, 1.4083333333333, 1.15, 0.25
22795, 1.4083333333333, 1.1, 0.25
22796, 1.4083333333333, 1.05, 0.25
22797, 1.4083333333333, 1, 0.25
22798, 1.4083333333333, 0.95, 0.25
22799, 1.4083333333333, 0.9, 0.25
22800, 1.4083333333333, 0.85, 0.25
22801, 1.4083333333333, 0.8, 0.25
22802, 1.4083333333333, 0.75, 0.25
22803, 1.4083333333333, 0.7, 0.25
22804, 1.4083333333333, 0.65, 0.25
22805, 1.4083333333333, 0.6, 0.25
22806, 1.4083333333333, 0.55, 0.25
22807, 1.4083333333333, 0.5, 0.25
22808, 1.4083333333333, 0.45, 0.25
22809, 1.4083333333333, 0.4, 0.25
22810, 1.4083333333333, 0.35, 0.25
22811, 1.4083333333333, 0.3, 0.25
22812, 1.4083333333333, 0.25, 0.25
22813, 1.4083333333333, 0.2, 0.25
22814, 1.45, 1.3, 0.25
22815, 1.45, 1.25, 0.25
22816, 1.45, 1.2, 0.25
22817, 1.45, 1.15, 0.25
22818, 1.45, 1.1, 0.25
22819, 1.45, 1.05, 0.25
22820, 1.45, 1, 0.25
22821, 1.45, 0.95, 0.25
22822, 1.45, 0.9, 0.25
22823, 1.45, 0.85, 0.25
22824, 1.45, 0.8, 0.25
22825, 1.45, 0.75, 0.25
22826, 1.45, 0.7, 0.25
22827, 1.45, 0.65, 0.25
22828, 1.45, 0.6, 0.25
22829, 1.45, 0.55, 0.25
22830, 1.45, 0.5, 0.25
22831, 1.45, 0.45, 0.25
22832, 1.45, 0.4, 0.25
22833, 1.45, 0.35, 0.25
22834, 1.45, 0.3, 0.25
22835, 1.45, 0.25, 0.25
22836, 1.45, 0.2, 0.25
22837, 1.4916666666667, 1.3, 0.25
22838, 1.4916666666667, 1.25, 0.25
22839, 1.4916666666667, 1.2, 0.25
22840, 1.4916666666667, 1.15, 0.25
22841, 1.4916666666667, 1.1, 0.25
22842, 1.4916666666667, 1.05, 0.25
22843, 1.4916666666667, 1, 0.25
22844, 1.4916666666667, 0.95, 0.25
22845, 1.4916666666667, 0.9, 0.25
22846, 1.4916666666667, 0.85, 0.25
22847, 1.4916666666667, 0.8, 0.25
22848, 1.4916666666667, 0.75, 0.25
22849, 1.4916666666667, 0.7, 0.25
22850, 1.4916666666667, 0.65, 0.25
22851, 1.4916666666667, 0.6, 0.25
22852, 1.4916666666667, 0.55, 0.25
22853, 1.4916666666667, 0.5, 0.25
22854, 1.4916666666667, 0.45, 0.25
22855, 1.4916666666667, 0.4, 0.25
22856, 1.4916666666667, 0.35, 0.25
22857, 1.4916666666667, 0.3, 0.25
22858, 1.4916666666667, 0.25, 0.25
22859, 1.4916666666667, 0.2, 0.25
22860, 1.5333333333333, 1.3, 0.25
22861, 1.5333333333333, 1.25, 0.25
22862, 1.5333333333333, 1.2, 0.25
22863, 1.5333333333333, 1.15, 0.25
22864, 1.5333333333333, 1.1, 0.25
22865, 1.5333333333333, 1.05, 0.25
22866, 1.5333333333333, 1, 0.25
22867, 1.5333333333333, 0.95, 0.25
22868, 1.5333333333333, 0.9, 0.25
22869, 1.5333333333333, 0.85, 0.25
22870, 1.5333333333333, 0.8, 0.25
22871, 1.5333333333333, 0.75, 0.25
22872, 1.5333333333333, 0.7, 0.25
22873, 1.5333333333333, 0.65, 0.25
22874, 1.5333333333333, 0.6, 0.25
22875, 1.5333333333333, 0.55, 0.25
22876, 1.5333333333333, 0.5, 0.25
22877, 1.5333333333333, 0.45, 0.25
22878, 1.5333333333333, 0.4, 0.25
22879, 1.5333333333333, 0.35, 0.25
22880, 1.5333333333333, 0.3, 0.25
22881, 1.5333333333333, 0.25, 0.25
22882, 1.5333333333333, 0.2, 0.25
22883, 1.575, 1.3, 0.25
22884, 1.575, 1.25, 0.25
22885, 1.575, 1.2, 0.25
22886, 1.575, 1.15, 0.25
22887, 1.575, 1.1, 0.25
22888, 1.575, 1.05, 0.25
22889, 1.575, 1, 0.25
22890, 1.575, 0.95, 0.25
22891, 1.575, 0.9, 0.25
22892, 1.575, 0.85, 0.25
22893, 1.575, 0.8, 0.25
22894, 1.575, 0.75, 0.25
22895, 1.575, 0.7, 0.25
22896, 1.575, 0.65, 0.25
22897, 1.575, 0.6, 0.25
22898, 1.575, 0.55, 0.25
22899, 1.575, 0.5, 0.25
22900, 1.575, 0.45, 0.25
22901, 1.575, 0.4, 0.25
22902, 1.575, 0.35, 0.25
22903, 1.575, 0.3, 0.25
22904, 1.575, 0.25, 0.25
22905, 1.575, 0.2, 0.25
22906, 1.6166666666667, 1.3, 0.25
22907, 1.6166666666667, 1.25, 0.25
22908, 1.6166666666667, 1.2, 0.25
22909, 1.6166666666667, 1.15, 0.25
22910, 1.6166666666667, 1.1, 0.25
22911, 1.6166666666667, 1.05, 0.25
22912, 1.6166666666667, 1, 0.25
22913, 1.6166666666667, 0.95, 0.25
22914, 1.6166666666667, 0.9, 0.25
22915, 1.6166666666667, 0.85, 0.25
22916, 1.6166666666667, 0.8, 0.25
22917, 1.6166666666667, 0.75, 0.25
22918, 1.6166666666667, 0.7, 0.25
22919, 1.6166666666667, 0.65, 0.25
22920, 1.6166666666667, 0.6, 0.25
22921, 1.6166666666667, 0.55, 0.25
22922, 1.6166666666667, 0.5, 0.25
22923, 1.6166666666667, 0.45, 0.25
22924, 1.6166666666667, 0.4, 0.25
22925, 1.6166666666667, 0.35, 0.25
22926, 1.6166666666667, 0.3, 0.25
22927, 1.6166666666667, 0.25, 0.25
22928, 1.6166666666667, 0.2, 0.25
22929, 1.6583333333333, 1.3, 0.25
22930, 1.6583333333333, 1.25, 0.25
22931, 1.6583333333333, 1.2, 0.25
22932, 1.6583333333333, 1.15, 0.25
22933, 1.6583333333333, 1.1, 0.25
22934, 1.6583333333333, 1.05, 0.25
22935, 1.6583333333333, 1, 0.25
22936, 1.6583333333333, 0.95, 0.25
22937, 1.6583333333333, 0.9, 0.25
22938, 1.6583333333333, 0.85, 0.25
22939, 1.6583333333333, 0.8, 0.25
22940, 1.6583333333333, 0.75, 0.25
22941, 1.6583333333333, 0.7, 0.25
22942, 1.6583333333333, 0.65, 0.25
22943, 1.6583333333333, 0.6, 0.25
22944, 1.6583333333333, 0.55, 0.25
22945, 1.6583333333333, 0.5, 0.25
22946, 1.6583333333333, 0.45, 0.25
22947, 1.6583333333333, 0.4, 0.25
22948, 1.6583333333333, 0.35, 0.25
22949, 1.6583333333333, 0.3, 0.25
22950, 1.6583333333333, 0.25, 0.25
22951, 1.6583333333333, 0.2, 0.25
22952, 1.7, 1.3, 0.25
22953, 1.7, 1.25, 0.25
22954, 1.7, 1.2, 0.25
22955, 1.7, 1.15, 0.25
22956, 1.7, 1.1, 0.25
22957, 1.7, 1.05, 0.25
22958, 1.7, 1, 0.25
22959, 1.7, 0.95, 0.25
22960, 1.7, 0.9, 0.25
22961, 1.7, 0.85, 0.25
22962, 1.7, 0.8, 0.25
22963, 1.7, 0.75, 0.25
22964, 1.7, 0.7, 0.25
22965, 1.7, 0.65, 0.25
22966, 1.7, 0.6, 0.25
22967, 1.7, 0.55, 0.25
22968, 1.7, 0.5, 0.25
22969, 1.7, 0.45, 0.25
22970, 1.7, 0.4, 0.25
22971, 1.7, 0.35, 0.25
22972, 1.7, 0.3, 0.25
22973, 1.7, 0.25, 0.25
22974, 1.7, 0.2, 0.25
22975, 1.7416666666667, 1.3, 0.25
22976, 1.7416666666667, 1.25, 0.25
22977, 1.7416666666667, 1.2, 0.25
22978, 1.7416666666667, 1.15, 0.25
22979, 1.7416666666667, 1.1, 0.25
22980, 1.7416666666667, 1.05, 0.25
22981, 1.7416666666667, 1, 0.25
22982, 1.7416666666667, 0.95, 0.25
22983, 1.7416666666667, 0.9, 0.25
22984, 1.7416666666667, 0.85, 0.25
22985, 1.7416666666667, 0.8, 0.25
22986, 1.7416666666667, 0.75, 0.25
22987, 1.7416666666667, 0.7, 0.25
22988, 1.7416666666667, 0.65, 0.25
22989, 1.7416666666667, 0.6, 0.25
22990, 1.7416666666667, 0.55, 0.25
22991, 1.7416666666667, 0.5, 0.25
22992, 1.7416666666667, 0.45, 0.25
22993, 1.7416666666667, 0.4, 0.25
22994, 1.7416666666667, 0.35, 0.25
22995, 1.7416666666667, 0.3, 0.25
22996, 1.7416666666667, 0.25, 0.25
22997, 1.7416666666667, 0.2, 0.25
22998, 1.7833333333333, 1.3, 0.25
22999, 1.7833333333333, 1.25, 0.25
23000, 1.7833333333333, 1.2, 0.25
23001, 1.7833333333333, 1.15, 0.25
23002, 1.7833333333333, 1.1, 0.25
23003, 1.7833333333333, 1.05, 0.25
23004, 1.7833333333333, 1, 0.25
23005, 1.7833333333333, 0.95, 0.25
23006, 1.7833333333333, 0.9, 0.25
23007, 1.7833333333333, 0.85, 0.25
23008, 1.7833333333333, 0.8, 0.25
23009, 1.7833333333333, 0.75, 0.25
23010, 1.7833333333333, 0.7, 0.25
23011, 1.7833333333333, 0.65, 0.25
23012, 1.7833333333333, 0.6, 0.25
23013, 1.7833333333333, 0.55, 0.25
23014, 1.7833333333333, 0.5, 0.25
23015, 1.7833333333333, 0.45, 0.25
23016, 1.7833333333333, 0.4, 0.25
23017, 1.7833333333333, 0.35, 0.25
23018, 1.7833333333333, 0.3, 0.25
23019, 1.7833333333333, 0.25, 0.25
23020, 1.7833333333333, 0.2, 0.25
23021, 1.825, 1.3, 0.25
23022, 1.825, 1.25, 0.25
23023, 1.825, 1.2, 0.25
23024, 1.825, 1.15, 0.25
23025, 1.825, 1.1, 0.25
23026, 1.825, 1.05, 0.25
23027, 1.825, 1, 0.25
23028, 1.825, 0.95, 0.25
23029, 1.825, 0.9, 0.25
23030, 1.825, 0.85, 0.25
23031, 1.825, 0.8, 0.25
23032, 1.825, 0.75, 0.25
23033, 1.825, 0.7, 0.25
23034, 1.825, 0.65, 0.25
23035, 1.825, 0.6, 0.25
23036, 1.825, 0.55, 0.25
23037, 1.825, 0.5, 0.25
23038, 1.825, 0.45, 0.25
23039, 1.825, 0.4, 0.25
23040, 1.825, 0.35, 0.25
23041, 1.825, 0.3, 0.25
23042, 1.825, 0.25, 0.25
23043, 1.825, 0.2, 0.25
23044, 1.8666666666667, 1.3, 0.25
23045, 1.8666666666667, 1.25, 0.25
23046, 1.8666666666667, 1.2, 0.25
23047, 1.8666666666667, 1.15, 0.25
23048, 1.8666666666667, 1.1, 0.25
23049, 1.8666666666667, 1.05, 0.25
23050, 1.8666666666667, 1, 0.25
23051, 1.8666666666667, 0.95, 0.25
23052, 1.8666666666667, 0.9, 0.25
23053, 1.8666666666667, 0.85, 0.25
23054, 1.8666666666667, 0.8, 0.25
23055, 1.8666666666667, 0.75, 0.25
23056, 1.8666666666667, 0.7, 0.25
23057, 1.8666666666667, 0.65, 0.25
23058, 1.8666666666667, 0.6, 0.25
23059, 1.8666666666667, 0.55, 0.25
23060, 1.8666666666667, 0.5, 0.25
23061, 1.8666666666667, 0.45, 0.25
23062, 1.8666666666667, 0.4, 0.25
23063, 1.8666666666667, 0.35, 0.25
23064, 1.8666666666667, 0.3, 0.25
23065, 1.8666666666667, 0.25, 0.25
23066, 1.8666666666667, 0.2, 0.25
23067, 1.9083333333333, 1.3, 0.25
23068, 1.9083333333333, 1.25, 0.25
23069, 1.9083333333333, 1.2, 0.25
23070, 1.9083333333333, 1.15, 0.25
23071, 1.9083333333333, 1.1, 0.25
23072, 1.9083333333333, 1.05, 0.25
23073, 1.9083333333333, 1, 0.25
23074, 1.9083333333333, 0.95, 0.25
23075, 1.9083333333333, 0.9, 0.25
23076, 1.9083333333333, 0.85, 0.25
23077, 1.9083333333333, 0.8, 0.25
23078, 1.9083333333333, 0.75, 0.25
23079, 1.9083333333333, 0.7, 0.25
23080, 1.9083333333333, 0.65, 0.25
23081, 1.9083333333333, 0.6, 0.25
23082, 1.9083333333333, 0.55, 0.25
23083, 1.9083333333333, 0.5, 0.25
23084, 1.9083333333333, 0.45, 0.25
23085, 1.9083333333333, 0.4, 0.25
23086, 1.9083333333333, 0.35, 0.25
23087, 1.9083333333333, 0.3, 0.25
23088, 1.9083333333333, 0.25, 0.25
23089, 1.9083333333333, 0.2, 0.25
23090, 1.95, 1.3, 0.25
23091, 1.95, 1.25, 0.25
23092, 1.95, 1.2, 0.25
23093, 1.95, 1.15, 0.25
23094, 1.95, 1.1, 0.25
23095, 1.95, 1.05, 0.25
23096, 1.95, 1, 0.25
23097, 1.95, 0.95, 0.25
23098, 1.95, 0.9, 0.25
23099, 1.95, 0.85, 0.25
23100, 1.95, 0.8, 0.25
23101, 1.95, 0.75, 0.25
23102, 1.95, 0.7, 0.25
23103, 1.95, 0.65, 0.25
23104, 1.95, 0.6, 0.25
23105, 1.95, 0.55, 0.25
23106, 1.95, 0.5, 0.25
23107, 1.95, 0.45, 0.25
23108, 1.95, 0.4, 0.25
23109, 1.95, 0.35, 0.25
23110, 1.95, 0.3, 0.25
23111, 1.95, 0.25, 0.25
23112, 1.95, 0.2, 0.25
23113, 1.9916666666667, 1.3, 0.25
23114, 1.9916666666667, 1.25, 0.25
23115, 1.9916666666667, 1.2, 0.25
23116, 1.9916666666667, 1.15, 0.25
23117, 1.9916666666667, 1.1, 0.25
23118, 1.9916666666667, 1.05, 0.25
23119, 1.9916666666667, 1, 0.25
23120, 1.9916666666667, 0.95, 0.25
23121, 1.9916666666667, 0.9, 0.25
23122, 1.9916666666667, 0.85, 0.25
23123, 1.9916666666667, 0.8, 0.25
23124, 1.9916666666667, 0.75, 0.25
23125, 1.9916666666667, 0.7, 0.25
23126, 1.9916666666667, 0.65, 0.25
23127, 1.9916666666667, 0.6, 0.25
23128, 1.9916666666667, 0.55, 0.25
23129, 1.9916666666667, 0.5, 0.25
23130, 1.9916666666667, 0.45, 0.25
23131, 1.9916666666667, 0.4, 0.25
23132, 1.9916666666667, 0.35, 0.25
23133, 1.9916666666667, 0.3, 0.25
23134, 1.9916666666667, 0.25, 0.25
23135, 1.9916666666667, 0.2, 0.25
23136, 2.0333333333333, 1.3, 0.25
23137, 2.0333333333333, 1.25, 0.25
23138, 2.0333333333333, 1.2, 0.25
23139, 2.0333333333333, 1.15, 0.25
23140, 2.0333333333333, 1.1, 0.25
23141, 2.0333333333333, 1.05, 0.25
23142, 2.0333333333333, 1, 0.25
23143, 2.0333333333333, 0.95, 0.25
23144, 2.0333333333333, 0.9, 0.25
23145, 2.0333333333333, 0.85, 0.25
23146, 2.0333333333333, 0.8, 0.25
23147, 2.0333333333333, 0.75, 0.25
23148, 2.0333333333333, 0.7, 0.25
23149, 2.0333333333333, 0.65, 0.25
23150, 2.0333333333333, 0.6, 0.25
23151, 2.0333333333333, 0.55, 0.25
23152, 2.0333333333333, 0.5, 0.25
23153, 2.0333333333333, 0.45, 0.25
23154, 2.0333333333333, 0.4, 0.25
23155, 2.0333333333333, 0.35, 0.25
23156, 2.0333333333333, 0.3, 0.25
23157, 2.0333333333333, 0.25, 0.25
23158, 2.0333333333333, 0.2, 0.25
23159, 2.075, 1.3, 0.25
23160, 2.075, 1.25, 0.25
23161, 2.075, 1.2, 0.25
23162, 2.075, 1.15, 0.25
23163, 2.075, 1.1, 0.25
23164, 2.075, 1.05, 0.25
23165, 2.075, 1, 0.25
23166, 2.075, 0.95, 0.25
23167, 2.075, 0.9, 0.25
23168, 2.075, 0.85, 0.25
23169, 2.075, 0.8, 0.25
23170, 2.075, 0.75, 0.25
23171, 2.075, 0.7, 0.25
23172, 2.075, 0.65, 0.25
23173, 2.075, 0.6, 0.25
23174, 2.075, 0.55, 0.25
23175, 2.075, 0.5, 0.25
23176, 2.075, 0.45, 0.25
23177, 2.075, 0.4, 0.25
23178, 2.075, 0.35, 0.25
23179, 2.075, 0.3, 0.25
23180, 2.075, 0.25, 0.25
23181, 2.075, 0.2, 0.25
23182, 2.1166666666667, 1.3, 0.25
23183, 2.1166666666667, 1.25, 0.25
23184, 2.1166666666667, 1.2, 0.25
23185, 2.1166666666667, 1.15, 0.25
23186, 2.1166666666667, 1.1, 0.25
23187, 2.1166666666667, 1.05, 0.25
23188, 2.1166666666667, 1, 0.25
23189, 2.1166666666667, 0.95, 0.25
23190, 2.1166666666667, 0.9, 0.25
23191, 2.1166666666667, 0.85, 0.25
23192, 2.1166666666667, 0.8, 0.25
23193, 2.1166666666667, 0.75, 0.25
23194, 2.1166666666667, 0.7, 0.25
23195, 2.1166666666667, 0.65, 0.25
23196, 2.1166666666667, 0.6, 0.25
23197, 2.1166666666667, 0.55, 0.25
23198, 2.1166666666667, 0.5, 0.25
23199, 2.1166666666667, 0.45, 0.25
23200, 2.1166666666667, 0.4, 0.25
23201, 2.1166666666667, 0.35, 0.25
23202, 2.1166666666667, 0.3, 0.25
23203, 2.1166666666667, 0.25, 0.25
23204, 2.1166666666667, 0.2, 0.25
23205, 2.1583333333333, 1.3, 0.25
23206, 2.1583333333333, 1.25, 0.25
23207, 2.1583333333333, 1.2, 0.25
23208, 2.1583333333333, 1.15, 0.25
23209, 2.1583333333333, 1.1, 0.25
23210, 2.1583333333333, 1.05, 0.25
23211, 2.1583333333333, 1, 0.25
23212, 2.1583333333333, 0.95, 0.25
23213, 2.1583333333333, 0.9, 0.25
23214, 2.1583333333333, 0.85, 0.25
23215, 2.1583333333333, 0.8, 0.25
23216, 2.1583333333333, 0.75, 0.25
23217, 2.1583333333333, 0.7, 0.25
23218, 2.1583333333333, 0.65, 0.25
23219, 2.1583333333333, 0.6, 0.25
23220, 2.1583333333333, 0.55, 0.25
23221, 2.1583333333333, 0.5, 0.25
23222, 2.1583333333333, 0.45, 0.25
23223, 2.1583333333333, 0.4, 0.25
23224, 2.1583333333333, 0.35, 0.25
23225, 2.1583333333333, 0.3, 0.25
23226, 2.1583333333333, 0.25, 0.25
23227, 2.1583333333333, 0.2, 0.25
23228, 1.2416666666667, 1.3, 0.29166666666667
23229, 1.2416666666667, 1.25, 0.29166666666667
23230, 1.2416666666667, 1.2, 0.29166666666667
23231, 1.2416666666667, 1.15, 0.29166666666667
23232, 1.2416666666667, 1.1, 0.29166666666667
23233, 1.2416666666667, 1.05, 0.29166666666667
23234, 1.2416666666667, 1, 0.29166666666667
23235, 1.2416666666667, 0.95, 0.29166666666667
23236, 1.2416666666667, 0.9, 0.29166666666667
23237, 1.2416666666667, 0.85, 0.29166666666667
23238, 1.2416666666667, 0.8, 0.29166666666667
23239, 1.2416666666667, 0.75, 0.29166666666667
23240, 1.2416666666667, 0.7, 0.29166666666667
23241, 1.2416666666667, 0.65, 0.29166666666667
23242, 1.2416666666667, 0.6, 0.29166666666667
23243, 1.2416666666667, 0.55, 0.29166666666667
23244, 1.2416666666667, 0.5, 0.29166666666667
23245, 1.2416666666667, 0.45, 0.29166666666667
23246, 1.2416666666667, 0.4, 0.29166666666667
23247, 1.2416666666667, 0.35, 0.29166666666667
23248, 1.2416666666667, 0.3, 0.29166666666667
23249, 1.2416666666667, 0.25, 0.29166666666667
23250, 1.2416666666667, 0.2, 0.29166666666667
23251, 1.2833333333333, 1.3, 0.29166666666667
23252, 1.2833333333333, 1.25, 0.29166666666667
23253, 1.2833333333333, 1.2, 0.29166666666667
23254, 1.2833333333333, 1.15, 0.29166666666667
23255, 1.2833333333333, 1.1, 0.29166666666667
23256, 1.2833333333333, 1.05, 0.29166666666667
23257, 1.2833333333333, 1, 0.29166666666667
23258, 1.2833333333333, 0.95, 0.29166666666667
23259, 1.2833333333333, 0.9, 0.29166666666667
23260, 1.2833333333333, 0.85, 0.29166666666667
23261, 1.2833333333333, 0.8, 0.29166666666667
23262, 1.2833333333333, 0.75, 0.29166666666667
23263, 1.2833333333333, 0.7, 0.29166666666667
23264, 1.2833333333333, 0.65, 0.29166666666667
23265, 1.2833333333333, 0.6, 0.29166666666667
23266, 1.2833333333333, 0.55, 0.29166666666667
23267, 1.2833333333333, 0.5, 0.29166666666667
23268, 1.2833333333333, 0.45, 0.29166666666667
23269, 1.2833333333333, 0.4, 0.29166666666667
23270, 1.2833333333333, 0.35, 0.29166666666667
23271, 1.2833333333333, 0.3, 0.29166666666667
23272, 1.2833333333333, 0.25, 0.29166666666667
23273, 1.2833333333333, 0.2, 0.29166666666667
23274, 1.325, 1.3, 0.29166666666667
23275, 1.325, 1.25, 0.29166666666667
23276, 1.325, 1.2, 0.29166666666667
23277, 1.325, 1.15, 0.29166666666667
23278, 1.325, 1.1, 0.29166666666667
23279, 1.325, 1.05, 0.29166666666667
23280, 1.325, 1, 0.29166666666667
23281, 1.325, 0.95, 0.29166666666667
23282, 1.325, 0.9, 0.29166666666667
23283, 1.325, 0.85, 0.29166666666667
23284, 1.325, 0.8, 0.29166666666667
23285, 1.325, 0.75, 0.29166666666667
23286, 1.325, 0.7, 0.29166666666667
23287, 1.325, 0.65, 0.29166666666667
23288, 1.325, 0.6, 0.29166666666667
23289, 1.325, 0.55, 0.29166666666667
23290, 1.325, 0.5, 0.29166666666667
23291, 1.325, 0.45, 0.29166666666667
23292, 1.325, 0.4, 0.29166666666667
23293, 1.325, 0.35, 0.29166666666667
23294, 1.325, 0.3, 0.29166666666667
23295, 1.325, 0.25, 0.29166666666667
23296, 1.325, 0.2, 0.29166666666667
23297, 1.3666666666667, 1.3, 0.29166666666667
23298, 1.3666666666667, 1.25, 0.29166666666667
23299, 1.3666666666667, 1.2, 0.29166666666667
23300, 1.3666666666667, 1.15, 0.29166666666667
23301, 1.3666666666667, 1.1, 0.29166666666667
23302, 1.3666666666667, 1.05, 0.29166666666667
23303, 1.3666666666667, 1, 0.29166666666667
23304, 1.3666666666667, 0.95, 0.29166666666667
23305, 1.3666666666667, 0.9, 0.29166666666667
23306, 1.3666666666667, 0.85, 0.29166666666667
23307, 1.3666666666667, 0.8, 0.29166666666667
23308, 1.3666666666667, 0.75, 0.29166666666667
23309, 1.3666666666667, 0.7, 0.29166666666667
23310, 1.3666666666667, 0.65, 0.29166666666667
23311, 1.3666666666667, 0.6, 0.29166666666667
23312, 1.3666666666667, 0.55, 0.29166666666667
23313, 1.3666666666667, 0.5, 0.29166666666667
23314, 1.3666666666667, 0.45, 0.29166666666667
23315, 1.3666666666667, 0.4, 0.29166666666667
23316, 1.3666666666667, 0.35, 0.29166666666667
23317, 1.3666666666667, 0.3, 0.29166666666667
23318, 1.3666666666667, 0.25, 0.29166666666667
23319, 1.3666666666667, 0.2, 0.29166666666667
23320, 1.4083333333333, 1.3, 0.29166666666667
23321, 1.4083333333333, 1.25, 0.29166666666667
23322, 1.4083333333333, 1.2, 0.29166666666667
23323, 1.4083333333333, 1.15, 0.29166666666667
23324, 1.4083333333333, 1.1, 0.29166666666667
23325, 1.4083333333333, 1.05, 0.29166666666667
23326, 1.4083333333333, 1, 0.29166666666667
23327, 1.4083333333333, 0.95, 0.29166666666667
23328, 1.4083333333333, 0.9, 0.29166666666667
23329, 1.4083333333333, 0.85, 0.29166666666667
23330, 1.4083333333333, 0.8, 0.29166666666667
23331, 1.4083333333333, 0.75, 0.29166666666667
23332, 1.4083333333333, 0.7, 0.29166666666667
23333, 1.4083333333333, 0.65, 0.29166666666667
23334, 1.4083333333333, 0.6, 0.29166666666667
23335, 1.4083333333333, 0.55, 0.29166666666667
23336, 1.4083333333333, 0.5, 0.29166666666667
23337, 1.4083333333333, 0.45, 0.29166666666667
23338, 1.4083333333333, 0.4, 0.29166666666667
23339, 1.4083333333333, 0.35, 0.29166666666667
23340, 1.4083333333333, 0.3, 0.29166666666667
23341, 1.4083333333333, 0.25, 0.29166666666667
23342, 1.4083333333333, 0.2, 0.29166666666667
23343, 1.45, 1.3, 0.29166666666667
23344, 1.45, 1.25, 0.29166666666667
23345, 1.45, 1.2, 0.29166666666667
23346, 1.45, 1.15, 0.29166666666667
23347, 1.45, 1.1, 0.29166666666667
23348, 1.45, 1.05, 0.29166666666667
23349, 1.45, 1, 0.29166666666667
23350, 1.45, 0.95, 0.29166666666667
23351, 1.45, 0.9, 0.29166666666667
23352, 1.45, 0.85, 0.29166666666667
23353, 1.45, 0.8, 0.29166666666667
23354, 1.45, 0.75, 0.29166666666667
23355, 1.45, 0.7, 0.29166666666667
23356, 1.45, 0.65, 0.29166666666667
23357, 1.45, 0.6, 0.29166666666667
23358, 1.45, 0.55, 0.29166666666667
23359, 1.45, 0.5, 0.29166666666667
23360, 1.45, 0.45, 0.29166666666667
23361, 1.45, 0.4, 0.29166666666667
23362, 1.45, 0.35, 0.29166666666667
23363, 1.45, 0.3, 0.29166666666667
23364, 1.45, 0.25, 0.29166666666667
23365, 1.45, 0.2, 0.29166666666667
23366, 1.4916666666667, 1.3, 0.29166666666667
23367, 1.4916666666667, 1.25, 0.29166666666667
23368, 1.4916666666667, 1.2, 0.29166666666667
23369, 1.4916666666667, 1.15, 0.29166666666667
23370, 1.4916666666667, 1.1, 0.29166666666667
23371, 1.4916666666667, 1.05, 0.29166666666667
23372, 1.4916666666667, 1, 0.29166666666667
23373, 1.4916666666667, 0.95, 0.29166666666667
23374, 1.4916666666667, 0.9, 0.29166666666667
23375, 1.4916666666667, 0.85, 0.29166666666667
23376, 1.4916666666667, 0.8, 0.29166666666667
23377, 1.4916666666667, 0.75, 0.29166666666667
23378, 1.4916666666667, 0.7, 0.29166666666667
23379, 1.4916666666667, 0.65, 0.29166666666667
23380, 1.4916666666667, 0.6, 0.29166666666667
23381, 1.4916666666667, 0.55, 0.29166666666667
23382, 1.4916666666667, 0.5, 0.29166666666667
23383, 1.4916666666667, 0.45, 0.29166666666667
23384, 1.4916666666667, 0.4, 0.29166666666667
23385, 1.4916666666667, 0.35, 0.29166666666667
23386, 1.4916666666667, 0.3, 0.29166666666667
23387, 1.4916666666667, 0.25, 0.29166666666667
23388, 1.4916666666667, 0.2, 0.29166666666667
23389, 1.5333333333333, 1.3, 0.29166666666667
23390, 1.5333333333333, 1.25, 0.29166666666667
23391, 1.5333333333333, 1.2, 0.29166666666667
23392, 1.5333333333333, 1.15, 0.29166666666667
23393, 1.5333333333333, 1.1, 0.29166666666667
23394, 1.5333333333333, 1.05, 0.29166666666667
23395, 1.5333333333333, 1, 0.29166666666667
23396, 1.5333333333333, 0.95, 0.29166666666667
23397, 1.5333333333333, 0.9, 0.29166666666667
23398, 1.5333333333333, 0.85, 0.29166666666667
23399, 1.5333333333333, 0.8, 0.29166666666667
23400, 1.5333333333333, 0.75, 0.29166666666667
23401, 1.5333333333333, 0.7, 0.29166666666667
23402, 1.5333333333333, 0.65, 0.29166666666667
23403, 1.5333333333333, 0.6, 0.29166666666667
23404, 1.5333333333333, 0.55, 0.29166666666667
23405, 1.5333333333333, 0.5, 0.29166666666667
23406, 1.5333333333333, 0.45, 0.29166666666667
23407, 1.5333333333333, 0.4, 0.29166666666667
23408, 1.5333333333333, 0.35, 0.29166666666667
23409, 1.5333333333333, 0.3, 0.29166666666667
23410, 1.5333333333333, 0.25, 0.29166666666667
23411, 1.5333333333333, 0.2, 0.29166666666667
23412, 1.575, 1.3, 0.29166666666667
23413, 1.575, 1.25, 0.29166666666667
23414, 1.575, 1.2, 0.29166666666667
23415, 1.575, 1.15, 0.29166666666667
23416, 1.575, 1.1, 0.29166666666667
23417, 1.575, 1.05, 0.29166666666667
23418, 1.575, 1, 0.29166666666667
23419, 1.575, 0.95, 0.29166666666667
23420, 1.575, 0.9, 0.29166666666667
23421, 1.575, 0.85, 0.29166666666667
23422, 1.575, 0.8, 0.29166666666667
23423, 1.575, 0.75, 0.29166666666667
23424, 1.575, 0.7, 0.29166666666667
23425, 1.575, 0.65, 0.29166666666667
23426, 1.575, 0.6, 0.29166666666667
23427, 1.575, 0.55, 0.29166666666667
23428, 1.575, 0.5, 0.29166666666667
23429, 1.575, 0.45, 0.29166666666667
23430, 1.575, 0.4, 0.29166666666667
23431, 1.575, 0.35, 0.29166666666667
23432, 1.575, 0.3, 0.29166666666667
23433, 1.575, 0.25, 0.29166666666667
23434, 1.575, 0.2, 0.29166666666667
23435, 1.6166666666667, 1.3, 0.29166666666667
23436, 1.6166666666667, 1.25, 0.29166666666667
23437, 1.6166666666667, 1.2, 0.29166666666667
23438, 1.6166666666667, 1.15, 0.29166666666667
23439, 1.6166666666667, 1.1, 0.29166666666667
23440, 1.6166666666667, 1.05, 0.29166666666667
23441, 1.6166666666667, 1, 0.29166666666667
23442, 1.6166666666667, 0.95, 0.29166666666667
23443, 1.6166666666667, 0.9, 0.29166666666667
23444, 1.6166666666667, 0.85, 0.29166666666667
23445, 1.6166666666667, 0.8, 0.29166666666667
23446, 1.6166666666667, 0.75, 0.29166666666667
23447, 1.6166666666667, 0.7, 0.29166666666667
23448, 1.6166666666667, 0.65, 0.29166666666667
23449, 1.6166666666667, 0.6, 0.29166666666667
23450, 1.6166666666667, 0.55, 0.29166666666667
23451, 1.6166666666667, 0.5, 0.29166666666667
23452, 1.6166666666667, 0.45, 0.29166666666667
23453, 1.6166666666667, 0.4, 0.29166666666667
23454, 1.6166666666667, 0.35, 0.29166666666667
23455, 1.6166666666667, 0.3, 0.29166666666667
23456, 1.6166666666667, 0.25, 0.29166666666667
23457, 1.6166666666667, 0.2, 0.29166666666667
23458, 1.6583333333333, 1.3, 0.29166666666667
23459, 1.6583333333333, 1.25, 0.29166666666667
23460, 1.6583333333333, 1.2, 0.29166666666667
23461, 1.6583333333333, 1.15, 0.29166666666667
23462, 1.6583333333333, 1.1, 0.29166666666667
23463, 1.6583333333333, 1.05, 0.29166666666667
23464, 1.6583333333333, 1, 0.29166666666667
23465, 1.6583333333333, 0.95, 0.29166666666667
23466, 1.6583333333333, 0.9, 0.29166666666667
23467, 1.6583333333333, 0.85, 0.29166666666667
23468, 1.6583333333333, 0.8, 0.29166666666667
23469, 1.6583333333333, 0.75, 0.29166666666667
23470, 1.6583333333333, 0.7, 0.29166666666667
23471, 1.6583333333333, 0.65, 0.29166666666667
23472, 1.6583333333333, 0.6, 0.29166666666667
23473, 1.6583333333333, 0.55, 0.29166666666667
23474, 1.6583333333333, 0.5, 0.29166666666667
23475, 1.6583333333333, 0.45, 0.29166666666667
23476, 1.6583333333333, 0.4, 0.29166666666667
23477, 1.6583333333333, 0.35, 0.29166666666667
23478, 1.6583333333333, 0.3, 0.29166666666667
23479, 1.6583333333333, 0.25, 0.29166666666667
23480, 1.6583333333333, 0.2, 0.29166666666667
23481, 1.7, 1.3, 0.29166666666667
23482, 1.7, 1.25, 0.29166666666667
23483, 1.7, 1.2, 0.29166666666667
23484, 1.7, 1.15, 0.29166666666667
23485, 1.7, 1.1, 0.29166666666667
23486, 1.7, 1.05, 0.29166666666667
23487, 1.7, 1, 0.29166666666667
23488, 1.7, 0.95, 0.29166666666667
23489, 1.7, 0.9, 0.29166666666667
23490, 1.7, 0.85, 0.29166666666667
23491, 1.7, 0.8, 0.29166666666667
23492, 1.7, 0.75, 0.29166666666667
23493, 1.7, 0.7, 0.29166666666667
23494, 1.7, 0.65, 0.29166666666667
23495, 1.7, 0.6, 0.29166666666667
23496, 1.7, 0.55, 0.29166666666667
23497, 1.7, 0.5, 0.29166666666667
23498, 1.7, 0.45, 0.29166666666667
23499, 1.7, 0.4, 0.29166666666667
23500, 1.7, 0.35, 0.29166666666667
23501, 1.7, 0.3, 0.29166666666667
23502, 1.7, 0.25, 0.29166666666667
23503, 1.7, 0.2, 0.29166666666667
23504, 1.7416666666667, 1.3, 0.29166666666667
23505, 1.7416666666667, 1.25, 0.29166666666667
23506, 1.7416666666667, 1.2, 0.29166666666667
23507, 1.7416666666667, 1.15, 0.29166666666667
23508, 1.7416666666667, 1.1, 0.29166666666667
23509, 1.7416666666667, 1.05, 0.29166666666667
23510, 1.7416666666667, 1, 0.29166666666667
23511, 1.7416666666667, 0.95, 0.29166666666667
23512, 1.7416666666667, 0.9, 0.29166666666667
23513, 1.7416666666667, 0.85, 0.29166666666667
23514, 1.7416666666667, 0.8, 0.29166666666667
23515, 1.7416666666667, 0.75, 0.29166666666667
23516, 1.7416666666667, 0.7, 0.29166666666667
23517, 1.7416666666667, 0.65, 0.29166666666667
23518, 1.7416666666667, 0.6, 0.29166666666667
23519, 1.7416666666667, 0.55, 0.29166666666667
23520, 1.7416666666667, 0.5, 0.29166666666667
23521, 1.7416666666667, 0.45, 0.29166666666667
23522, 1.7416666666667, 0.4, 0.29166666666667
23523, 1.7416666666667, 0.35, 0.29166666666667
23524, 1.7416666666667, 0.3, 0.29166666666667
23525, 1.7416666666667, 0.25, 0.29166666666667
23526, 1.7416666666667, 0.2, 0.29166666666667
23527, 1.7833333333333, 1.3, 0.29166666666667
23528, 1.7833333333333, 1.25, 0.29166666666667
23529, 1.7833333333333, 1.2, 0.29166666666667
23530, 1.7833333333333, 1.15, 0.29166666666667
23531, 1.7833333333333, 1.1, 0.29166666666667
23532, 1.7833333333333, 1.05, 0.29166666666667
23533, 1.7833333333333, 1, 0.29166666666667
23534, 1.7833333333333, 0.95, 0.29166666666667
23535, 1.7833333333333, 0.9, 0.29166666666667
23536, 1.7833333333333, 0.85, 0.29166666666667
23537, 1.7833333333333, 0.8, 0.29166666666667
23538, 1.7833333333333, 0.75, 0.29166666666667
23539, 1.7833333333333, 0.7, 0.29166666666667
23540, 1.7833333333333, 0.65, 0.29166666666667
23541, 1.7833333333333, 0.6, 0.29166666666667
23542, 1.7833333333333, 0.55, 0.29166666666667
23543, 1.7833333333333, 0.5, 0.29166666666667
23544, 1.7833333333333, 0.45, 0.29166666666667
23545, 1.7833333333333, 0.4, 0.29166666666667
23546, 1.7833333333333, 0.35, 0.29166666666667
23547, 1.7833333333333, 0.3, 0.29166666666667
23548, 1.7833333333333, 0.25, 0.29166666666667
23549, 1.7833333333333, 0.2, 0.29166666666667
23550, 1.825, 1.3, 0.29166666666667
23551, 1.825, 1.25, 0.29166666666667
23552, 1.825, 1.2, 0.29166666666667
23553, 1.825, 1.15, 0.29166666666667
23554, 1.825, 1.1, 0.29166666666667
23555, 1.825, 1.05, 0.29166666666667
23556, 1.825, 1, 0.29166666666667
23557, 1.825, 0.95, 0.29166666666667
23558, 1.825, 0.9, 0.29166666666667
23559, 1.825, 0.85, 0.29166666666667
23560, 1.825, 0.8, 0.29166666666667
23561, 1.825, 0.75, 0.29166666666667
23562, 1.825, 0.7, 0.29166666666667
23563, 1.825, 0.65, 0.29166666666667
23564, 1.825, 0.6, 0.29166666666667
23565, 1.825, 0.55, 0.29166666666667
23566, 1.825, 0.5, 0.29166666666667
23567, 1.825, 0.45, 0.29166666666667
23568, 1.825, 0.4, 0.29166666666667
23569, 1.825, 0.35, 0.29166666666667
23570, 1.825, 0.3, 0.29166666666667
23571, 1.825, 0.25, 0.29166666666667
23572, 1.825, 0.2, 0.29166666666667
23573, 1.8666666666667, 1.3, 0.29166666666667
23574, 1.8666666666667, 1.25, 0.29166666666667
23575, 1.8666666666667, 1.2, 0.29166666666667
23576, 1.8666666666667, 1.15, 0.29166666666667
23577, 1.8666666666667, 1.1, 0.29166666666667
23578, 1.8666666666667, 1.05, 0.29166666666667
23579, 1.8666666666667, 1, 0.29166666666667
23580, 1.8666666666667, 0.95, 0.29166666666667
23581, 1.8666666666667, 0.9, 0.29166666666667
23582, 1.8666666666667, 0.85, 0.29166666666667
23583, 1.8666666666667, 0.8, 0.29166666666667
23584, 1.8666666666667, 0.75, 0.29166666666667
23585, 1.8666666666667, 0.7, 0.29166666666667
23586, 1.8666666666667, 0.65, 0.29166666666667
23587, 1.8666666666667, 0.6, 0.29166666666667
23588, 1.8666666666667, 0.55, 0.29166666666667
23589, 1.8666666666667, 0.5, 0.29166666666667
23590, 1.8666666666667, 0.45, 0.29166666666667
23591, 1.8666666666667, 0.4, 0.29166666666667
23592, 1.8666666666667, 0.35, 0.29166666666667
23593, 1.8666666666667, 0.3, 0.29166666666667
23594, 1.8666666666667, 0.25, 0.29166666666667
23595, 1.8666666666667, 0.2, 0.29166666666667
23596, 1.9083333333333, 1.3, 0.29166666666667
23597, 1.9083333333333, 1.25, 0.29166666666667
23598, 1.9083333333333, 1.2, 0.29166666666667
23599, 1.9083333333333, 1.15, 0.29166666666667
23600, 1.9083333333333, 1.1, 0.29166666666667
23601, 1.9083333333333, 1.05, 0.29166666666667
23602, 1.9083333333333, 1, 0.29166666666667
23603, 1.9083333333333, 0.95, 0.29166666666667
23604, 1.9083333333333, 0.9, 0.29166666666667
23605, 1.9083333333333, 0.85, 0.29166666666667
23606, 1.9083333333333, 0.8, 0.29166666666667
23607, 1.9083333333333, 0.75, 0.29166666666667
23608, 1.9083333333333, 0.7, 0.29166666666667
23609, 1.9083333333333, 0.65, 0.29166666666667
23610, 1.9083333333333, 0.6, 0.29166666666667
23611, 1.9083333333333, 0.55, 0.29166666666667
23612, 1.9083333333333, 0.5, 0.29166666666667
23613, 1.9083333333333, 0.45, 0.29166666666667
23614, 1.9083333333333, 0.4, 0.29166666666667
23615, 1.9083333333333, 0.35, 0.29166666666667
23616, 1.9083333333333, 0.3, 0.29166666666667
23617, 1.9083333333333, 0.25, 0.29166666666667
23618, 1.9083333333333, 0.2, 0.29166666666667
23619, 1.95, 1.3, 0.29166666666667
23620, 1.95, 1.25, 0.29166666666667
23621, 1.95, 1.2, 0.29166666666667
23622, 1.95, 1.15, 0.29166666666667
23623, 1.95, 1.1, 0.29166666666667
23624, 1.95, 1.05, 0.29166666666667
23625, 1.95, 1, 0.29166666666667
23626, 1.95, 0.95, 0.29166666666667
23627, 1.95, 0.9, 0.29166666666667
23628, 1.95, 0.85, 0.29166666666667
23629, 1.95, 0.8, 0.29166666666667
23630, 1.95, 0.75, 0.29166666666667
23631, 1.95, 0.7, 0.29166666666667
23632, 1.95, 0.65, 0.29166666666667
23633, 1.95, 0.6, 0.29166666666667
23634, 1.95, 0.55, 0.29166666666667
23635, 1.95, 0.5, 0.29166666666667
23636, 1.95, 0.45, 0.29166666666667
23637, 1.95, 0.4, 0.29166666666667
23638, 1.95, 0.35, 0.29166666666667
23639, 1.95, 0.3, 0.29166666666667
23640, 1.95, 0.25, 0.29166666666667
23641, 1.95, 0.2, 0.29166666666667
23642, 1.9916666666667, 1.3, 0.29166666666667
23643, 1.9916666666667, 1.25, 0.29166666666667
23644, 1.9916666666667, 1.2, 0.29166666666667
23645, 1.9916666666667, 1.15, 0.29166666666667
23646, 1.9916666666667, 1.1, 0.29166666666667
23647, 1.9916666666667, 1.05, 0.29166666666667
23648, 1.9916666666667, 1, 0.29166666666667
23649, 1.9916666666667, 0.95, 0.29166666666667
23650, 1.9916666666667, 0.9, 0.29166666666667
23651, 1.9916666666667, 0.85, 0.29166666666667
23652, 1.9916666666667, 0.8, 0.29166666666667
23653, 1.9916666666667, 0.75, 0.29166666666667
23654, 1.9916666666667, 0.7, 0.29166666666667
23655, 1.9916666666667, 0.65, 0.29166666666667
23656, 1.9916666666667, 0.6, 0.29166666666667
23657, 1.9916666666667, 0.55, 0.29166666666667
23658, 1.9916666666667, 0.5, 0.29166666666667
23659, 1.9916666666667, 0.45, 0.29166666666667
23660, 1.9916666666667, 0.4, 0.29166666666667
23661, 1.9916666666667, 0.35, 0.29166666666667
23662, 1.9916666666667, 0.3, 0.29166666666667
23663, 1.9916666666667, 0.25, 0.29166666666667
23664, 1.9916666666667, 0.2, 0.29166666666667
23665, 2.0333333333333, 1.3, 0.29166666666667
23666, 2.0333333333333, 1.25, 0.29166666666667
23667, 2.0333333333333, 1.2, 0.29166666666667
23668, 2.0333333333333, 1.15, 0.29166666666667
23669, 2.0333333333333, 1.1, 0.29166666666667
23670, 2.0333333333333, 1.05, 0.29166666666667
23671, 2.0333333333333, 1, 0.29166666666667
23672, 2.0333333333333, 0.95, 0.29166666666667
23673, 2.0333333333333, 0.9, 0.29166666666667
23674, 2.0333333333333, 0.85, 0.29166666666667
23675, 2.0333333333333, 0.8, 0.29166666666667
23676, 2.0333333333333, 0.75, 0.29166666666667
23677, 2.0333333333333, 0.7, 0.29166666666667
23678, 2.0333333333333, 0.65, 0.29166666666667
23679, 2.0333333333333, 0.6, 0.29166666666667
23680, 2.0333333333333, 0.55, 0.29166666666667
23681, 2.0333333333333, 0.5, 0.29166666666667
23682, 2.0333333333333, 0.45, 0.29166666666667
23683, 2.0333333333333, 0.4, 0.29166666666667
23684, 2.0333333333333, 0.35, 0.29166666666667
23685, 2.0333333333333, 0.3, 0.29166666666667
23686, 2.0333333333333, 0.25, 0.29166666666667
23687, 2.0333333333333, 0.2, 0.29166666666667
23688, 2.075, 1.3, 0.29166666666667
23689, 2.075, 1.25, 0.29166666666667
23690, 2.075, 1.2, 0.29166666666667
23691, 2.075, 1.15, 0.29166666666667
23692, 2.075, 1.1, 0.29166666666667
23693, 2.075, 1.05, 0.29166666666667
23694, 2.075, 1, 0.29166666666667
23695, 2.075, 0.95, 0.29166666666667
23696, 2.075, 0.9, 0.29166666666667
23697, 2.075, 0.85, 0.29166666666667
23698, 2.075, 0.8, 0.29166666666667
23699, 2.075, 0.75, 0.29166666666667
23700, 2.075, 0.7, 0.29166666666667
23701, 2.075, 0.65, 0.29166666666667
23702, 2.075, 0.6, 0.29166666666667
23703, 2.075, 0.55, 0.29166666666667
23704, 2.075, 0.5, 0.29166666666667
23705, 2.075, 0.45, 0.29166666666667
23706, 2.075, 0.4, 0.29166666666667
23707, 2.075, 0.35, 0.29166666666667
23708, 2.075, 0.3, 0.29166666666667
23709, 2.075, 0.25, 0.29166666666667
23710, 2.075, 0.2, 0.29166666666667
23711, 2.1166666666667, 1.3, 0.29166666666667
23712, 2.1166666666667, 1.25, 0.29166666666667
23713, 2.1166666666667, 1.2, 0.29166666666667
23714, 2.1166666666667, 1.15, 0.29166666666667
23715, 2.1166666666667, 1.1, 0.29166666666667
23716, 2.1166666666667, 1.05, 0.29166666666667
23717, 2.1166666666667, 1, 0.29166666666667
23718, 2.1166666666667, 0.95, 0.29166666666667
23719, 2.1166666666667, 0.9, 0.29166666666667
23720, 2.1166666666667, 0.85, 0.29166666666667
23721, 2.1166666666667, 0.8, 0.29166666666667
23722, 2.1166666666667, 0.75, 0.29166666666667
23723, 2.1166666666667, 0.7, 0.29166666666667
23724, 2.1166666666667, 0.65, 0.29166666666667
23725, 2.1166666666667, 0.6, 0.29166666666667
23726, 2.1166666666667, 0.55, 0.29166666666667
23727, 2.1166666666667, 0.5, 0.29166666666667
23728, 2.1166666666667, 0.45, 0.29166666666667
23729, 2.1166666666667, 0.4, 0.29166666666667
23730, 2.1166666666667, 0.35, 0.29166666666667
23731, 2.1166666666667, 0.3, 0.29166666666667
23732, 2.1166666666667, 0.25, 0.29166666666667
23733, 2.1166666666667, 0.2, 0.29166666666667
23734, 2.1583333333333, 1.3, 0.29166666666667
23735, 2.1583333333333, 1.25, 0.29166666666667
23736, 2.1583333333333, 1.2, 0.29166666666667
23737, 2.1583333333333, 1.15, 0.29166666666667
23738, 2.1583333333333, 1.1, 0.29166666666667
23739, 2.1583333333333, 1.05, 0.29166666666667
23740, 2.1583333333333, 1, 0.29166666666667
23741, 2.1583333333333, 0.95, 0.29166666666667
23742, 2.1583333333333, 0.9, 0.29166666666667
23743, 2.1583333333333, 0.85, 0.29166666666667
23744, 2.1583333333333, 0.8, 0.29166666666667
23745, 2.1583333333333, 0.75, 0.29166666666667
23746, 2.1583333333333, 0.7, 0.29166666666667
23747, 2.1583333333333, 0.65, 0.29166666666667
23748, 2.1583333333333, 0.6, 0.29166666666667
23749, 2.1583333333333, 0.55, 0.29166666666667
23750, 2.1583333333333, 0.5, 0.29166666666667
23751, 2.1583333333333, 0.45, 0.29166666666667
23752, 2.1583333333333, 0.4, 0.29166666666667
23753, 2.1583333333333, 0.35, 0.29166666666667
23754, 2.1583333333333, 0.3, 0.29166666666667
23755, 2.1583333333333, 0.25, 0.29166666666667
23756, 2.1583333333333, 0.2, 0.29166666666667
23757, 1.2416666666667, 1.3, 0.33333333333333
23758, 1.2416666666667, 1.25, 0.33333333333333
23759, 1.2416666666667, 1.2, 0.33333333333333
23760, 1.2416666666667, 1.15, 0.33333333333333
23761, 1.2416666666667, 1.1, 0.33333333333333
23762, 1.2416666666667, 1.05, 0.33333333333333
23763, 1.2416666666667, 1, 0.33333333333333
23764, 1.2416666666667, 0.95, 0.33333333333333
23765, 1.2416666666667, 0.9, 0.33333333333333
23766, 1.2416666666667, 0.85, 0.33333333333333
23767, 1.2416666666667, 0.8, 0.33333333333333
23768, 1.2416666666667, 0.75, 0.33333333333333
23769, 1.2416666666667, 0.7, 0.33333333333333
23770, 1.2416666666667, 0.65, 0.33333333333333
23771, 1.2416666666667, 0.6, 0.33333333333333
23772, 1.2416666666667, 0.55, 0.33333333333333
23773, 1.2416666666667, 0.5, 0.33333333333333
23774, 1.2416666666667, 0.45, 0.33333333333333
23775, 1.2416666666667, 0.4, 0.33333333333333
23776, 1.2416666666667, 0.35, 0.33333333333333
23777, 1.2416666666667, 0.3, 0.33333333333333
23778, 1.2416666666667, 0.25, 0.33333333333333
23779, 1.2416666666667, 0.2, 0.33333333333333
23780, 1.2833333333333, 1.3, 0.33333333333333
23781, 1.2833333333333, 1.25, 0.33333333333333
23782, 1.2833333333333, 1.2, 0.33333333333333
23783, 1.2833333333333, 1.15, 0.33333333333333
23784, 1.2833333333333, 1.1, 0.33333333333333
23785, 1.2833333333333, 1.05, 0.33333333333333
23786, 1.2833333333333, 1, 0.33333333333333
23787, 1.2833333333333, 0.95, 0.33333333333333
23788, 1.2833333333333, 0.9, 0.33333333333333
23789, 1.2833333333333, 0.85, 0.33333333333333
23790, 1.2833333333333, 0.8, 0.33333333333333
23791, 1.2833333333333, 0.75, 0.33333333333333
23792, 1.2833333333333, 0.7, 0.33333333333333
23793, 1.2833333333333, 0.65, 0.33333333333333
23794, 1.2833333333333, 0.6, 0.33333333333333
23795, 1.2833333333333, 0.55, 0.33333333333333
23796, 1.2833333333333, 0.5, 0.33333333333333
23797, 1.2833333333333, 0.45, 0.33333333333333
23798, 1.2833333333333, 0.4, 0.33333333333333
23799, 1.2833333333333, 0.35, 0.33333333333333
23800, 1.2833333333333, 0.3, 0.33333333333333
23801, 1.2833333333333, 0.25, 0.33333333333333
23802, 1.2833333333333, 0.2, 0.33333333333333
23803, 1.325, 1.3, 0.33333333333333
23804, 1.325, 1.25, 0.33333333333333
23805, 1.325, 1.2, 0.33333333333333
23806, 1.325, 1.15, 0.33333333333333
23807, 1.325, 1.1, 0.33333333333333
23808, 1.325, 1.05, 0.33333333333333
23809, 1.325, 1, 0.33333333333333
23810, 1.325, 0.95, 0.33333333333333
23811, 1.325, 0.9, 0.33333333333333
23812, 1.325, 0.85, 0.33333333333333
23813, 1.325, 0.8, 0.33333333333333
23814, 1.325, 0.75, 0.33333333333333
23815, 1.325, 0.7, 0.33333333333333
23816, 1.325, 0.65, 0.33333333333333
23817, 1.325, 0.6, 0.33333333333333
23818, 1.325, 0.55, 0.33333333333333
23819, 1.325, 0.5, 0.33333333333333
23820, 1.325, 0.45, 0.33333333333333
23821, 1.325, 0.4, 0.33333333333333
23822, 1.325, 0.35, 0.33333333333333
23823, 1.325, 0.3, 0.33333333333333
23824, 1.325, 0.25, 0.33333333333333
23825, 1.325, 0.2, 0.33333333333333
23826, 1.3666666666667, 1.3, 0.33333333333333
23827, 1.3666666666667, 1.25, 0.33333333333333
23828, 1.3666666666667, 1.2, 0.33333333333333
23829, 1.3666666666667, 1.15, 0.33333333333333
23830, 1.3666666666667, 1.1, 0.33333333333333
23831, 1.3666666666667, 1.05, 0.33333333333333
23832, 1.3666666666667, 1, 0.33333333333333
23833, 1.3666666666667, 0.95, 0.33333333333333
23834, 1.3666666666667, 0.9, 0.33333333333333
23835, 1.3666666666667, 0.85, 0.33333333333333
23836, 1.3666666666667, 0.8, 0.33333333333333
23837, 1.3666666666667, 0.75, 0.33333333333333
23838, 1.3666666666667, 0.7, 0.33333333333333
23839, 1.3666666666667, 0.65, 0.33333333333333
23840, 1.3666666666667, 0.6, 0.33333333333333
23841, 1.3666666666667, 0.55, 0.33333333333333
23842, 1.3666666666667, 0.5, 0.33333333333333
23843, 1.3666666666667, 0.45, 0.33333333333333
23844, 1.3666666666667, 0.4, 0.33333333333333
23845, 1.3666666666667, 0.35, 0.33333333333333
23846, 1.3666666666667, 0.3, 0.33333333333333
23847, 1.3666666666667, 0.25, 0.33333333333333
23848, 1.3666666666667, 0.2, 0.33333333333333
23849, 1.4083333333333, 1.3, 0.33333333333333
23850, 1.4083333333333, 1.25, 0.33333333333333
23851, 1.4083333333333, 1.2, 0.33333333333333
23852, 1.4083333333333, 1.15, 0.33333333333333
23853, 1.4083333333333, 1.1, 0.33333333333333
23854, 1.4083333333333, 1.05, 0.33333333333333
23855, 1.4083333333333, 1, 0.33333333333333
23856, 1.4083333333333, 0.95, 0.33333333333333
23857, 1.4083333333333, 0.9, 0.33333333333333
23858, 1.4083333333333, 0.85, 0.33333333333333
23859, 1.4083333333333, 0.8, 0.33333333333333
23860, 1.4083333333333, 0.75, 0.33333333333333
23861, 1.4083333333333, 0.7, 0.33333333333333
23862, 1.4083333333333, 0.65, 0.33333333333333
23863, 1.4083333333333, 0.6, 0.33333333333333
23864, 1.4083333333333, 0.55, 0.33333333333333
23865, 1.4083333333333, 0.5, 0.33333333333333
23866, 1.4083333333333, 0.45, 0.33333333333333
23867, 1.4083333333333, 0.4, 0.33333333333333
23868, 1.4083333333333, 0.35, 0.33333333333333
23869, 1.4083333333333, 0.3, 0.33333333333333
23870, 1.4083333333333, 0.25, 0.33333333333333
23871, 1.4083333333333, 0.2, 0.33333333333333
23872, 1.45, 1.3, 0.33333333333333
23873, 1.45, 1.25, 0.33333333333333
23874, 1.45, 1.2, 0.33333333333333
23875, 1.45, 1.15, 0.33333333333333
23876, 1.45, 1.1, 0.33333333333333
23877, 1.45, 1.05, 0.33333333333333
23878, 1.45, 1, 0.33333333333333
23879, 1.45, 0.95, 0.33333333333333
23880, 1.45, 0.9, 0.33333333333333
23881, 1.45, 0.85, 0.33333333333333
23882, 1.45, 0.8, 0.33333333333333
23883, 1.45, 0.75, 0.33333333333333
23884, 1.45, 0.7, 0.33333333333333
23885, 1.45, 0.65, 0.33333333333333
23886, 1.45, 0.6, 0.33333333333333
23887, 1.45, 0.55, 0.33333333333333
23888, 1.45, 0.5, 0.33333333333333
23889, 1.45, 0.45, 0.33333333333333
23890, 1.45, 0.4, 0.33333333333333
23891, 1.45, 0.35, 0.33333333333333
23892, 1.45, 0.3, 0.33333333333333
23893, 1.45, 0.25, 0.33333333333333
23894, 1.45, 0.2, 0.33333333333333
23895, 1.4916666666667, 1.3, 0.33333333333333
23896, 1.4916666666667, 1.25, 0.33333333333333
23897, 1.4916666666667, 1.2, 0.33333333333333
