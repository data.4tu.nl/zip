3313, 0.875, 0.85, 0
3314, 0.875, 0.9, 0
3315, 0.875, 0.95, 0
3316, 0.875, 1, 0
3317, 0.875, 1.05, 0
3318, 0.875, 1.1, 0
3319, 0.875, 1.15, 0
3320, 0.875, 1.2, 0
3321, 0.875, 1.25, 0
3322, 0.875, 1.3, 0
3323, 0.91666666666667, 0.2, 0
3324, 0.91666666666667, 0.25, 0
3325, 0.91666666666667, 0.3, 0
3326, 0.91666666666667, 0.35, 0
3327, 0.91666666666667, 0.4, 0
3328, 0.91666666666667, 0.45, 0
3329, 0.91666666666667, 0.5, 0
3330, 0.91666666666667, 0.55, 0
3331, 0.91666666666667, 0.6, 0
3332, 0.91666666666667, 0.65, 0
3333, 0.91666666666667, 0.7, 0
3334, 0.91666666666667, 0.75, 0
3335, 0.91666666666667, 0.8, 0
3336, 0.91666666666667, 0.85, 0
3337, 0.91666666666667, 0.9, 0
3338, 0.91666666666667, 0.95, 0
3339, 0.91666666666667, 1, 0
3340, 0.91666666666667, 1.05, 0
3341, 0.91666666666667, 1.1, 0
3342, 0.91666666666667, 1.15, 0
3343, 0.91666666666667, 1.2, 0
3344, 0.91666666666667, 1.25, 0
3345, 0.91666666666667, 1.3, 0
3346, 0.95833333333333, 0.2, 0
3347, 0.95833333333333, 0.25, 0
3348, 0.95833333333333, 0.3, 0
3349, 0.95833333333333, 0.35, 0
3350, 0.95833333333333, 0.4, 0
3351, 0.95833333333333, 0.45, 0
3352, 0.95833333333333, 0.5, 0
3353, 0.95833333333333, 0.55, 0
3354, 0.95833333333333, 0.6, 0
3355, 0.95833333333333, 0.65, 0
3356, 0.95833333333333, 0.7, 0
3357, 0.95833333333333, 0.75, 0
3358, 0.95833333333333, 0.8, 0
3359, 0.95833333333333, 0.85, 0
3360, 0.95833333333333, 0.9, 0
3361, 0.95833333333333, 0.95, 0
3362, 0.95833333333333, 1, 0
3363, 0.95833333333333, 1.05, 0
3364, 0.95833333333333, 1.1, 0
3365, 0.95833333333333, 1.15, 0
3366, 0.95833333333333, 1.2, 0
3367, 0.95833333333333, 1.25, 0
3368, 0.95833333333333, 1.3, 0
3369, 1, 0.2, 0.041666666666667
3370, 1, 0.25, 0.041666666666667
3371, 1, 0.3, 0.041666666666667
3372, 1, 0.35, 0.041666666666667
3373, 1, 0.4, 0.041666666666667
3374, 1, 0.45, 0.041666666666667
3375, 1, 0.5, 0.041666666666667
3376, 1, 0.55, 0.041666666666667
3377, 1, 0.6, 0.041666666666667
3378, 1, 0.65, 0.041666666666667
3379, 1, 0.7, 0.041666666666667
3380, 1, 0.75, 0.041666666666667
3381, 1, 0.8, 0.041666666666667
3382, 1, 0.85, 0.041666666666667
3383, 1, 0.9, 0.041666666666667
3384, 1, 0.95, 0.041666666666667
3385, 1, 1, 0.041666666666667
3386, 1, 1.05, 0.041666666666667
3387, 1, 1.1, 0.041666666666667
3388, 1, 1.15, 0.041666666666667
3389, 1, 1.2, 0.041666666666667
3390, 1, 1.25, 0.041666666666667
3391, 1, 1.3, 0.041666666666667
3392, 1, 0.2, 0.083333333333333
3393, 1, 0.25, 0.083333333333333
3394, 1, 0.3, 0.083333333333333
3395, 1, 0.35, 0.083333333333333
3396, 1, 0.4, 0.083333333333333
3397, 1, 0.45, 0.083333333333333
3398, 1, 0.5, 0.083333333333333
3399, 1, 0.55, 0.083333333333333
3400, 1, 0.6, 0.083333333333333
3401, 1, 0.65, 0.083333333333333
3402, 1, 0.7, 0.083333333333333
3403, 1, 0.75, 0.083333333333333
3404, 1, 0.8, 0.083333333333333
3405, 1, 0.85, 0.083333333333333
3406, 1, 0.9, 0.083333333333333
3407, 1, 0.95, 0.083333333333333
3408, 1, 1, 0.083333333333333
3409, 1, 1.05, 0.083333333333333
3410, 1, 1.1, 0.083333333333333
3411, 1, 1.15, 0.083333333333333
3412, 1, 1.2, 0.083333333333333
3413, 1, 1.25, 0.083333333333333
3414, 1, 1.3, 0.083333333333333
3415, 1, 0.2, 0.125
3416, 1, 0.25, 0.125
3417, 1, 0.3, 0.125
3418, 1, 0.35, 0.125
3419, 1, 0.4, 0.125
3420, 1, 0.45, 0.125
3421, 1, 0.5, 0.125
3422, 1, 0.55, 0.125
3423, 1, 0.6, 0.125
3424, 1, 0.65, 0.125
3425, 1, 0.7, 0.125
3426, 1, 0.75, 0.125
3427, 1, 0.8, 0.125
3428, 1, 0.85, 0.125
3429, 1, 0.9, 0.125
3430, 1, 0.95, 0.125
3431, 1, 1, 0.125
3432, 1, 1.05, 0.125
3433, 1, 1.1, 0.125
3434, 1, 1.15, 0.125
3435, 1, 1.2, 0.125
3436, 1, 1.25, 0.125
3437, 1, 1.3, 0.125
3438, 1, 0.2, 0.16666666666667
3439, 1, 0.25, 0.16666666666667
3440, 1, 0.3, 0.16666666666667
3441, 1, 0.35, 0.16666666666667
3442, 1, 0.4, 0.16666666666667
3443, 1, 0.45, 0.16666666666667
3444, 1, 0.5, 0.16666666666667
3445, 1, 0.55, 0.16666666666667
3446, 1, 0.6, 0.16666666666667
3447, 1, 0.65, 0.16666666666667
3448, 1, 0.7, 0.16666666666667
3449, 1, 0.75, 0.16666666666667
3450, 1, 0.8, 0.16666666666667
3451, 1, 0.85, 0.16666666666667
3452, 1, 0.9, 0.16666666666667
3453, 1, 0.95, 0.16666666666667
3454, 1, 1, 0.16666666666667
3455, 1, 1.05, 0.16666666666667
3456, 1, 1.1, 0.16666666666667
3457, 1, 1.15, 0.16666666666667
3458, 1, 1.2, 0.16666666666667
3459, 1, 1.25, 0.16666666666667
3460, 1, 1.3, 0.16666666666667
3461, 1, 0.2, 0.20833333333333
3462, 1, 0.25, 0.20833333333333
3463, 1, 0.3, 0.20833333333333
3464, 1, 0.35, 0.20833333333333
3465, 1, 0.4, 0.20833333333333
3466, 1, 0.45, 0.20833333333333
3467, 1, 0.5, 0.20833333333333
3468, 1, 0.55, 0.20833333333333
3469, 1, 0.6, 0.20833333333333
3470, 1, 0.65, 0.20833333333333
3471, 1, 0.7, 0.20833333333333
3472, 1, 0.75, 0.20833333333333
3473, 1, 0.8, 0.20833333333333
3474, 1, 0.85, 0.20833333333333
3475, 1, 0.9, 0.20833333333333
3476, 1, 0.95, 0.20833333333333
3477, 1, 1, 0.20833333333333
3478, 1, 1.05, 0.20833333333333
3479, 1, 1.1, 0.20833333333333
3480, 1, 1.15, 0.20833333333333
3481, 1, 1.2, 0.20833333333333
3482, 1, 1.25, 0.20833333333333
3483, 1, 1.3, 0.20833333333333
3484, 1, 0.2, 0.25
3485, 1, 0.25, 0.25
3486, 1, 0.3, 0.25
3487, 1, 0.35, 0.25
3488, 1, 0.4, 0.25
3489, 1, 0.45, 0.25
3490, 1, 0.5, 0.25
3491, 1, 0.55, 0.25
3492, 1, 0.6, 0.25
3493, 1, 0.65, 0.25
3494, 1, 0.7, 0.25
3495, 1, 0.75, 0.25
3496, 1, 0.8, 0.25
3497, 1, 0.85, 0.25
3498, 1, 0.9, 0.25
3499, 1, 0.95, 0.25
3500, 1, 1, 0.25
3501, 1, 1.05, 0.25
3502, 1, 1.1, 0.25
3503, 1, 1.15, 0.25
3504, 1, 1.2, 0.25
3505, 1, 1.25, 0.25
3506, 1, 1.3, 0.25
3507, 1, 0.2, 0.29166666666667
3508, 1, 0.25, 0.29166666666667
3509, 1, 0.3, 0.29166666666667
3510, 1, 0.35, 0.29166666666667
3511, 1, 0.4, 0.29166666666667
3512, 1, 0.45, 0.29166666666667
3513, 1, 0.5, 0.29166666666667
3514, 1, 0.55, 0.29166666666667
3515, 1, 0.6, 0.29166666666667
3516, 1, 0.65, 0.29166666666667
3517, 1, 0.7, 0.29166666666667
3518, 1, 0.75, 0.29166666666667
3519, 1, 0.8, 0.29166666666667
3520, 1, 0.85, 0.29166666666667
3521, 1, 0.9, 0.29166666666667
3522, 1, 0.95, 0.29166666666667
3523, 1, 1, 0.29166666666667
3524, 1, 1.05, 0.29166666666667
3525, 1, 1.1, 0.29166666666667
3526, 1, 1.15, 0.29166666666667
3527, 1, 1.2, 0.29166666666667
3528, 1, 1.25, 0.29166666666667
3529, 1, 1.3, 0.29166666666667
3530, 1, 0.2, 0.33333333333333
3531, 1, 0.25, 0.33333333333333
3532, 1, 0.3, 0.33333333333333
3533, 1, 0.35, 0.33333333333333
3534, 1, 0.4, 0.33333333333333
3535, 1, 0.45, 0.33333333333333
3536, 1, 0.5, 0.33333333333333
3537, 1, 0.55, 0.33333333333333
3538, 1, 0.6, 0.33333333333333
3539, 1, 0.65, 0.33333333333333
3540, 1, 0.7, 0.33333333333333
3541, 1, 0.75, 0.33333333333333
3542, 1, 0.8, 0.33333333333333
3543, 1, 0.85, 0.33333333333333
3544, 1, 0.9, 0.33333333333333
3545, 1, 0.95, 0.33333333333333
3546, 1, 1, 0.33333333333333
3547, 1, 1.05, 0.33333333333333
3548, 1, 1.1, 0.33333333333333
3549, 1, 1.15, 0.33333333333333
3550, 1, 1.2, 0.33333333333333
3551, 1, 1.25, 0.33333333333333
3552, 1, 1.3, 0.33333333333333
3553, 1, 0.2, 0.375
3554, 1, 0.25, 0.375
3555, 1, 0.3, 0.375
3556, 1, 0.35, 0.375
3557, 1, 0.4, 0.375
3558, 1, 0.45, 0.375
3559, 1, 0.5, 0.375
3560, 1, 0.55, 0.375
3561, 1, 0.6, 0.375
3562, 1, 0.65, 0.375
3563, 1, 0.7, 0.375
3564, 1, 0.75, 0.375
3565, 1, 0.8, 0.375
3566, 1, 0.85, 0.375
3567, 1, 0.9, 0.375
3568, 1, 0.95, 0.375
3569, 1, 1, 0.375
3570, 1, 1.05, 0.375
3571, 1, 1.1, 0.375
3572, 1, 1.15, 0.375
3573, 1, 1.2, 0.375
3574, 1, 1.25, 0.375
3575, 1, 1.3, 0.375
3576, 1, 0.2, 0.41666666666667
3577, 1, 0.25, 0.41666666666667
3578, 1, 0.3, 0.41666666666667
3579, 1, 0.35, 0.41666666666667
3580, 1, 0.4, 0.41666666666667
3581, 1, 0.45, 0.41666666666667
3582, 1, 0.5, 0.41666666666667
3583, 1, 0.55, 0.41666666666667
3584, 1, 0.6, 0.41666666666667
3585, 1, 0.65, 0.41666666666667
3586, 1, 0.7, 0.41666666666667
3587, 1, 0.75, 0.41666666666667
3588, 1, 0.8, 0.41666666666667
3589, 1, 0.85, 0.41666666666667
3590, 1, 0.9, 0.41666666666667
3591, 1, 0.95, 0.41666666666667
3592, 1, 1, 0.41666666666667
3593, 1, 1.05, 0.41666666666667
3594, 1, 1.1, 0.41666666666667
3595, 1, 1.15, 0.41666666666667
3596, 1, 1.2, 0.41666666666667
3597, 1, 1.25, 0.41666666666667
3598, 1, 1.3, 0.41666666666667
3599, 1, 0.2, 0.45833333333333
3600, 1, 0.25, 0.45833333333333
3601, 1, 0.3, 0.45833333333333
3602, 1, 0.35, 0.45833333333333
3603, 1, 0.4, 0.45833333333333
3604, 1, 0.45, 0.45833333333333
3605, 1, 0.5, 0.45833333333333
3606, 1, 0.55, 0.45833333333333
3607, 1, 0.6, 0.45833333333333
3608, 1, 0.65, 0.45833333333333
3609, 1, 0.7, 0.45833333333333
3610, 1, 0.75, 0.45833333333333
3611, 1, 0.8, 0.45833333333333
3612, 1, 0.85, 0.45833333333333
3613, 1, 0.9, 0.45833333333333
3614, 1, 0.95, 0.45833333333333
3615, 1, 1, 0.45833333333333
3616, 1, 1.05, 0.45833333333333
3617, 1, 1.1, 0.45833333333333
3618, 1, 1.15, 0.45833333333333
3619, 1, 1.2, 0.45833333333333
3620, 1, 1.25, 0.45833333333333
3621, 1, 1.3, 0.45833333333333
3622, 0.041666666666667, 0.2, 0.5
3623, 0.041666666666667, 0.25, 0.5
3624, 0.041666666666667, 0.3, 0.5
3625, 0.041666666666667, 0.35, 0.5
3626, 0.041666666666667, 0.4, 0.5
3627, 0.041666666666667, 0.45, 0.5
3628, 0.041666666666667, 0.5, 0.5
3629, 0.041666666666667, 0.55, 0.5
3630, 0.041666666666667, 0.6, 0.5
3631, 0.041666666666667, 0.65, 0.5
3632, 0.041666666666667, 0.7, 0.5
3633, 0.041666666666667, 0.75, 0.5
3634, 0.041666666666667, 0.8, 0.5
3635, 0.041666666666667, 0.85, 0.5
3636, 0.041666666666667, 0.9, 0.5
3637, 0.041666666666667, 0.95, 0.5
3638, 0.041666666666667, 1, 0.5
3639, 0.041666666666667, 1.05, 0.5
3640, 0.041666666666667, 1.1, 0.5
3641, 0.041666666666667, 1.15, 0.5
3642, 0.041666666666667, 1.2, 0.5
3643, 0.041666666666667, 1.25, 0.5
3644, 0.041666666666667, 1.3, 0.5
3645, 0.083333333333333, 0.2, 0.5
3646, 0.083333333333333, 0.25, 0.5
3647, 0.083333333333333, 0.3, 0.5
3648, 0.083333333333333, 0.35, 0.5
3649, 0.083333333333333, 0.4, 0.5
3650, 0.083333333333333, 0.45, 0.5
3651, 0.083333333333333, 0.5, 0.5
3652, 0.083333333333333, 0.55, 0.5
3653, 0.083333333333333, 0.6, 0.5
3654, 0.083333333333333, 0.65, 0.5
3655, 0.083333333333333, 0.7, 0.5
3656, 0.083333333333333, 0.75, 0.5
3657, 0.083333333333333, 0.8, 0.5
3658, 0.083333333333333, 0.85, 0.5
3659, 0.083333333333333, 0.9, 0.5
3660, 0.083333333333333, 0.95, 0.5
3661, 0.083333333333333, 1, 0.5
3662, 0.083333333333333, 1.05, 0.5
3663, 0.083333333333333, 1.1, 0.5
3664, 0.083333333333333, 1.15, 0.5
3665, 0.083333333333333, 1.2, 0.5
3666, 0.083333333333333, 1.25, 0.5
3667, 0.083333333333333, 1.3, 0.5
3668, 0.125, 0.2, 0.5
3669, 0.125, 0.25, 0.5
3670, 0.125, 0.3, 0.5
3671, 0.125, 0.35, 0.5
3672, 0.125, 0.4, 0.5
3673, 0.125, 0.45, 0.5
3674, 0.125, 0.5, 0.5
3675, 0.125, 0.55, 0.5
3676, 0.125, 0.6, 0.5
3677, 0.125, 0.65, 0.5
3678, 0.125, 0.7, 0.5
3679, 0.125, 0.75, 0.5
3680, 0.125, 0.8, 0.5
3681, 0.125, 0.85, 0.5
3682, 0.125, 0.9, 0.5
3683, 0.125, 0.95, 0.5
3684, 0.125, 1, 0.5
3685, 0.125, 1.05, 0.5
3686, 0.125, 1.1, 0.5
3687, 0.125, 1.15, 0.5
3688, 0.125, 1.2, 0.5
3689, 0.125, 1.25, 0.5
3690, 0.125, 1.3, 0.5
3691, 0.16666666666667, 0.2, 0.5
3692, 0.16666666666667, 0.25, 0.5
3693, 0.16666666666667, 0.3, 0.5
3694, 0.16666666666667, 0.35, 0.5
3695, 0.16666666666667, 0.4, 0.5
3696, 0.16666666666667, 0.45, 0.5
3697, 0.16666666666667, 0.5, 0.5
3698, 0.16666666666667, 0.55, 0.5
3699, 0.16666666666667, 0.6, 0.5
3700, 0.16666666666667, 0.65, 0.5
3701, 0.16666666666667, 0.7, 0.5
3702, 0.16666666666667, 0.75, 0.5
3703, 0.16666666666667, 0.8, 0.5
3704, 0.16666666666667, 0.85, 0.5
3705, 0.16666666666667, 0.9, 0.5
3706, 0.16666666666667, 0.95, 0.5
3707, 0.16666666666667, 1, 0.5
3708, 0.16666666666667, 1.05, 0.5
3709, 0.16666666666667, 1.1, 0.5
3710, 0.16666666666667, 1.15, 0.5
3711, 0.16666666666667, 1.2, 0.5
3712, 0.16666666666667, 1.25, 0.5
3713, 0.16666666666667, 1.3, 0.5
3714, 0.20833333333333, 0.2, 0.5
3715, 0.20833333333333, 0.25, 0.5
3716, 0.20833333333333, 0.3, 0.5
3717, 0.20833333333333, 0.35, 0.5
3718, 0.20833333333333, 0.4, 0.5
3719, 0.20833333333333, 0.45, 0.5
3720, 0.20833333333333, 0.5, 0.5
3721, 0.20833333333333, 0.55, 0.5
3722, 0.20833333333333, 0.6, 0.5
3723, 0.20833333333333, 0.65, 0.5
3724, 0.20833333333333, 0.7, 0.5
3725, 0.20833333333333, 0.75, 0.5
3726, 0.20833333333333, 0.8, 0.5
3727, 0.20833333333333, 0.85, 0.5
3728, 0.20833333333333, 0.9, 0.5
3729, 0.20833333333333, 0.95, 0.5
3730, 0.20833333333333, 1, 0.5
3731, 0.20833333333333, 1.05, 0.5
3732, 0.20833333333333, 1.1, 0.5
3733, 0.20833333333333, 1.15, 0.5
3734, 0.20833333333333, 1.2, 0.5
3735, 0.20833333333333, 1.25, 0.5
3736, 0.20833333333333, 1.3, 0.5
3737, 0.25, 0.2, 0.5
3738, 0.25, 0.25, 0.5
3739, 0.25, 0.3, 0.5
3740, 0.25, 0.35, 0.5
3741, 0.25, 0.4, 0.5
3742, 0.25, 0.45, 0.5
3743, 0.25, 0.5, 0.5
3744, 0.25, 0.55, 0.5
3745, 0.25, 0.6, 0.5
3746, 0.25, 0.65, 0.5
3747, 0.25, 0.7, 0.5
3748, 0.25, 0.75, 0.5
3749, 0.25, 0.8, 0.5
3750, 0.25, 0.85, 0.5
3751, 0.25, 0.9, 0.5
3752, 0.25, 0.95, 0.5
3753, 0.25, 1, 0.5
3754, 0.25, 1.05, 0.5
3755, 0.25, 1.1, 0.5
3756, 0.25, 1.15, 0.5
3757, 0.25, 1.2, 0.5
3758, 0.25, 1.25, 0.5
3759, 0.25, 1.3, 0.5
3760, 0.29166666666667, 0.2, 0.5
3761, 0.29166666666667, 0.25, 0.5
3762, 0.29166666666667, 0.3, 0.5
3763, 0.29166666666667, 0.35, 0.5
3764, 0.29166666666667, 0.4, 0.5
3765, 0.29166666666667, 0.45, 0.5
3766, 0.29166666666667, 0.5, 0.5
3767, 0.29166666666667, 0.55, 0.5
3768, 0.29166666666667, 0.6, 0.5
3769, 0.29166666666667, 0.65, 0.5
3770, 0.29166666666667, 0.7, 0.5
3771, 0.29166666666667, 0.75, 0.5
3772, 0.29166666666667, 0.8, 0.5
3773, 0.29166666666667, 0.85, 0.5
3774, 0.29166666666667, 0.9, 0.5
3775, 0.29166666666667, 0.95, 0.5
3776, 0.29166666666667, 1, 0.5
3777, 0.29166666666667, 1.05, 0.5
3778, 0.29166666666667, 1.1, 0.5
3779, 0.29166666666667, 1.15, 0.5
3780, 0.29166666666667, 1.2, 0.5
3781, 0.29166666666667, 1.25, 0.5
3782, 0.29166666666667, 1.3, 0.5
3783, 0.33333333333333, 0.2, 0.5
3784, 0.33333333333333, 0.25, 0.5
3785, 0.33333333333333, 0.3, 0.5
3786, 0.33333333333333, 0.35, 0.5
3787, 0.33333333333333, 0.4, 0.5
3788, 0.33333333333333, 0.45, 0.5
3789, 0.33333333333333, 0.5, 0.5
3790, 0.33333333333333, 0.55, 0.5
3791, 0.33333333333333, 0.6, 0.5
3792, 0.33333333333333, 0.65, 0.5
3793, 0.33333333333333, 0.7, 0.5
3794, 0.33333333333333, 0.75, 0.5
3795, 0.33333333333333, 0.8, 0.5
3796, 0.33333333333333, 0.85, 0.5
3797, 0.33333333333333, 0.9, 0.5
3798, 0.33333333333333, 0.95, 0.5
3799, 0.33333333333333, 1, 0.5
3800, 0.33333333333333, 1.05, 0.5
3801, 0.33333333333333, 1.1, 0.5
3802, 0.33333333333333, 1.15, 0.5
3803, 0.33333333333333, 1.2, 0.5
3804, 0.33333333333333, 1.25, 0.5
3805, 0.33333333333333, 1.3, 0.5
3806, 0.375, 0.2, 0.5
3807, 0.375, 0.25, 0.5
3808, 0.375, 0.3, 0.5
3809, 0.375, 0.35, 0.5
3810, 0.375, 0.4, 0.5
3811, 0.375, 0.45, 0.5
3812, 0.375, 0.5, 0.5
3813, 0.375, 0.55, 0.5
3814, 0.375, 0.6, 0.5
3815, 0.375, 0.65, 0.5
3816, 0.375, 0.7, 0.5
3817, 0.375, 0.75, 0.5
3818, 0.375, 0.8, 0.5
3819, 0.375, 0.85, 0.5
3820, 0.375, 0.9, 0.5
3821, 0.375, 0.95, 0.5
3822, 0.375, 1, 0.5
3823, 0.375, 1.05, 0.5
3824, 0.375, 1.1, 0.5
3825, 0.375, 1.15, 0.5
3826, 0.375, 1.2, 0.5
3827, 0.375, 1.25, 0.5
3828, 0.375, 1.3, 0.5
3829, 0.41666666666667, 0.2, 0.5
3830, 0.41666666666667, 0.25, 0.5
3831, 0.41666666666667, 0.3, 0.5
3832, 0.41666666666667, 0.35, 0.5
3833, 0.41666666666667, 0.4, 0.5
3834, 0.41666666666667, 0.45, 0.5
3835, 0.41666666666667, 0.5, 0.5
3836, 0.41666666666667, 0.55, 0.5
3837, 0.41666666666667, 0.6, 0.5
3838, 0.41666666666667, 0.65, 0.5
3839, 0.41666666666667, 0.7, 0.5
3840, 0.41666666666667, 0.75, 0.5
3841, 0.41666666666667, 0.8, 0.5
3842, 0.41666666666667, 0.85, 0.5
3843, 0.41666666666667, 0.9, 0.5
3844, 0.41666666666667, 0.95, 0.5
3845, 0.41666666666667, 1, 0.5
3846, 0.41666666666667, 1.05, 0.5
3847, 0.41666666666667, 1.1, 0.5
3848, 0.41666666666667, 1.15, 0.5
3849, 0.41666666666667, 1.2, 0.5
3850, 0.41666666666667, 1.25, 0.5
3851, 0.41666666666667, 1.3, 0.5
3852, 0.45833333333333, 0.2, 0.5
3853, 0.45833333333333, 0.25, 0.5
3854, 0.45833333333333, 0.3, 0.5
3855, 0.45833333333333, 0.35, 0.5
3856, 0.45833333333333, 0.4, 0.5
3857, 0.45833333333333, 0.45, 0.5
3858, 0.45833333333333, 0.5, 0.5
3859, 0.45833333333333, 0.55, 0.5
3860, 0.45833333333333, 0.6, 0.5
3861, 0.45833333333333, 0.65, 0.5
3862, 0.45833333333333, 0.7, 0.5
3863, 0.45833333333333, 0.75, 0.5
3864, 0.45833333333333, 0.8, 0.5
3865, 0.45833333333333, 0.85, 0.5
3866, 0.45833333333333, 0.9, 0.5
3867, 0.45833333333333, 0.95, 0.5
3868, 0.45833333333333, 1, 0.5
3869, 0.45833333333333, 1.05, 0.5
3870, 0.45833333333333, 1.1, 0.5
3871, 0.45833333333333, 1.15, 0.5
3872, 0.45833333333333, 1.2, 0.5
3873, 0.45833333333333, 1.25, 0.5
3874, 0.45833333333333, 1.3, 0.5
3875, 0.5, 0.2, 0.5
3876, 0.5, 0.25, 0.5
3877, 0.5, 0.3, 0.5
3878, 0.5, 0.35, 0.5
3879, 0.5, 0.4, 0.5
3880, 0.5, 0.45, 0.5
3881, 0.5, 0.5, 0.5
3882, 0.5, 0.55, 0.5
3883, 0.5, 0.6, 0.5
3884, 0.5, 0.65, 0.5
3885, 0.5, 0.7, 0.5
3886, 0.5, 0.75, 0.5
3887, 0.5, 0.8, 0.5
3888, 0.5, 0.85, 0.5
3889, 0.5, 0.9, 0.5
3890, 0.5, 0.95, 0.5
3891, 0.5, 1, 0.5
3892, 0.5, 1.05, 0.5
3893, 0.5, 1.1, 0.5
3894, 0.5, 1.15, 0.5
3895, 0.5, 1.2, 0.5
3896, 0.5, 1.25, 0.5
3897, 0.5, 1.3, 0.5
3898, 0.54166666666667, 0.2, 0.5
3899, 0.54166666666667, 0.25, 0.5
3900, 0.54166666666667, 0.3, 0.5
3901, 0.54166666666667, 0.35, 0.5
3902, 0.54166666666667, 0.4, 0.5
3903, 0.54166666666667, 0.45, 0.5
3904, 0.54166666666667, 0.5, 0.5
3905, 0.54166666666667, 0.55, 0.5
3906, 0.54166666666667, 0.6, 0.5
3907, 0.54166666666667, 0.65, 0.5
3908, 0.54166666666667, 0.7, 0.5
3909, 0.54166666666667, 0.75, 0.5
3910, 0.54166666666667, 0.8, 0.5
3911, 0.54166666666667, 0.85, 0.5
3912, 0.54166666666667, 0.9, 0.5
3913, 0.54166666666667, 0.95, 0.5
3914, 0.54166666666667, 1, 0.5
3915, 0.54166666666667, 1.05, 0.5
3916, 0.54166666666667, 1.1, 0.5
3917, 0.54166666666667, 1.15, 0.5
3918, 0.54166666666667, 1.2, 0.5
3919, 0.54166666666667, 1.25, 0.5
3920, 0.54166666666667, 1.3, 0.5
3921, 0.58333333333333, 0.2, 0.5
3922, 0.58333333333333, 0.25, 0.5
3923, 0.58333333333333, 0.3, 0.5
3924, 0.58333333333333, 0.35, 0.5
3925, 0.58333333333333, 0.4, 0.5
3926, 0.58333333333333, 0.45, 0.5
3927, 0.58333333333333, 0.5, 0.5
3928, 0.58333333333333, 0.55, 0.5
3929, 0.58333333333333, 0.6, 0.5
3930, 0.58333333333333, 0.65, 0.5
3931, 0.58333333333333, 0.7, 0.5
3932, 0.58333333333333, 0.75, 0.5
3933, 0.58333333333333, 0.8, 0.5
3934, 0.58333333333333, 0.85, 0.5
3935, 0.58333333333333, 0.9, 0.5
3936, 0.58333333333333, 0.95, 0.5
3937, 0.58333333333333, 1, 0.5
3938, 0.58333333333333, 1.05, 0.5
3939, 0.58333333333333, 1.1, 0.5
3940, 0.58333333333333, 1.15, 0.5
3941, 0.58333333333333, 1.2, 0.5
3942, 0.58333333333333, 1.25, 0.5
3943, 0.58333333333333, 1.3, 0.5
3944, 0.625, 0.2, 0.5
3945, 0.625, 0.25, 0.5
3946, 0.625, 0.3, 0.5
3947, 0.625, 0.35, 0.5
3948, 0.625, 0.4, 0.5
3949, 0.625, 0.45, 0.5
3950, 0.625, 0.5, 0.5
3951, 0.625, 0.55, 0.5
3952, 0.625, 0.6, 0.5
3953, 0.625, 0.65, 0.5
3954, 0.625, 0.7, 0.5
3955, 0.625, 0.75, 0.5
3956, 0.625, 0.8, 0.5
3957, 0.625, 0.85, 0.5
3958, 0.625, 0.9, 0.5
3959, 0.625, 0.95, 0.5
3960, 0.625, 1, 0.5
3961, 0.625, 1.05, 0.5
3962, 0.625, 1.1, 0.5
3963, 0.625, 1.15, 0.5
3964, 0.625, 1.2, 0.5
3965, 0.625, 1.25, 0.5
3966, 0.625, 1.3, 0.5
3967, 0.66666666666667, 0.2, 0.5
3968, 0.66666666666667, 0.25, 0.5
3969, 0.66666666666667, 0.3, 0.5
3970, 0.66666666666667, 0.35, 0.5
3971, 0.66666666666667, 0.4, 0.5
3972, 0.66666666666667, 0.45, 0.5
3973, 0.66666666666667, 0.5, 0.5
3974, 0.66666666666667, 0.55, 0.5
3975, 0.66666666666667, 0.6, 0.5
3976, 0.66666666666667, 0.65, 0.5
3977, 0.66666666666667, 0.7, 0.5
3978, 0.66666666666667, 0.75, 0.5
3979, 0.66666666666667, 0.8, 0.5
3980, 0.66666666666667, 0.85, 0.5
3981, 0.66666666666667, 0.9, 0.5
3982, 0.66666666666667, 0.95, 0.5
3983, 0.66666666666667, 1, 0.5
3984, 0.66666666666667, 1.05, 0.5
3985, 0.66666666666667, 1.1, 0.5
3986, 0.66666666666667, 1.15, 0.5
3987, 0.66666666666667, 1.2, 0.5
3988, 0.66666666666667, 1.25, 0.5
3989, 0.66666666666667, 1.3, 0.5
3990, 0.70833333333333, 0.2, 0.5
3991, 0.70833333333333, 0.25, 0.5
3992, 0.70833333333333, 0.3, 0.5
3993, 0.70833333333333, 0.35, 0.5
3994, 0.70833333333333, 0.4, 0.5
3995, 0.70833333333333, 0.45, 0.5
3996, 0.70833333333333, 0.5, 0.5
3997, 0.70833333333333, 0.55, 0.5
3998, 0.70833333333333, 0.6, 0.5
3999, 0.70833333333333, 0.65, 0.5
4000, 0.70833333333333, 0.7, 0.5
4001, 0.70833333333333, 0.75, 0.5
4002, 0.70833333333333, 0.8, 0.5
4003, 0.70833333333333, 0.85, 0.5
4004, 0.70833333333333, 0.9, 0.5
4005, 0.70833333333333, 0.95, 0.5
4006, 0.70833333333333, 1, 0.5
4007, 0.70833333333333, 1.05, 0.5
4008, 0.70833333333333, 1.1, 0.5
4009, 0.70833333333333, 1.15, 0.5
4010, 0.70833333333333, 1.2, 0.5
4011, 0.70833333333333, 1.25, 0.5
4012, 0.70833333333333, 1.3, 0.5
4013, 0.75, 0.2, 0.5
4014, 0.75, 0.25, 0.5
4015, 0.75, 0.3, 0.5
4016, 0.75, 0.35, 0.5
4017, 0.75, 0.4, 0.5
4018, 0.75, 0.45, 0.5
4019, 0.75, 0.5, 0.5
4020, 0.75, 0.55, 0.5
4021, 0.75, 0.6, 0.5
4022, 0.75, 0.65, 0.5
4023, 0.75, 0.7, 0.5
4024, 0.75, 0.75, 0.5
4025, 0.75, 0.8, 0.5
4026, 0.75, 0.85, 0.5
4027, 0.75, 0.9, 0.5
4028, 0.75, 0.95, 0.5
4029, 0.75, 1, 0.5
4030, 0.75, 1.05, 0.5
4031, 0.75, 1.1, 0.5
4032, 0.75, 1.15, 0.5
4033, 0.75, 1.2, 0.5
4034, 0.75, 1.25, 0.5
4035, 0.75, 1.3, 0.5
4036, 0.79166666666667, 0.2, 0.5
4037, 0.79166666666667, 0.25, 0.5
4038, 0.79166666666667, 0.3, 0.5
4039, 0.79166666666667, 0.35, 0.5
4040, 0.79166666666667, 0.4, 0.5
4041, 0.79166666666667, 0.45, 0.5
4042, 0.79166666666667, 0.5, 0.5
4043, 0.79166666666667, 0.55, 0.5
4044, 0.79166666666667, 0.6, 0.5
4045, 0.79166666666667, 0.65, 0.5
4046, 0.79166666666667, 0.7, 0.5
4047, 0.79166666666667, 0.75, 0.5
4048, 0.79166666666667, 0.8, 0.5
4049, 0.79166666666667, 0.85, 0.5
4050, 0.79166666666667, 0.9, 0.5
4051, 0.79166666666667, 0.95, 0.5
4052, 0.79166666666667, 1, 0.5
4053, 0.79166666666667, 1.05, 0.5
4054, 0.79166666666667, 1.1, 0.5
4055, 0.79166666666667, 1.15, 0.5
4056, 0.79166666666667, 1.2, 0.5
4057, 0.79166666666667, 1.25, 0.5
4058, 0.79166666666667, 1.3, 0.5
4059, 0.83333333333333, 0.2, 0.5
4060, 0.83333333333333, 0.25, 0.5
4061, 0.83333333333333, 0.3, 0.5
4062, 0.83333333333333, 0.35, 0.5
4063, 0.83333333333333, 0.4, 0.5
4064, 0.83333333333333, 0.45, 0.5
4065, 0.83333333333333, 0.5, 0.5
4066, 0.83333333333333, 0.55, 0.5
4067, 0.83333333333333, 0.6, 0.5
4068, 0.83333333333333, 0.65, 0.5
4069, 0.83333333333333, 0.7, 0.5
4070, 0.83333333333333, 0.75, 0.5
4071, 0.83333333333333, 0.8, 0.5
4072, 0.83333333333333, 0.85, 0.5
4073, 0.83333333333333, 0.9, 0.5
4074, 0.83333333333333, 0.95, 0.5
4075, 0.83333333333333, 1, 0.5
4076, 0.83333333333333, 1.05, 0.5
4077, 0.83333333333333, 1.1, 0.5
4078, 0.83333333333333, 1.15, 0.5
4079, 0.83333333333333, 1.2, 0.5
4080, 0.83333333333333, 1.25, 0.5
4081, 0.83333333333333, 1.3, 0.5
4082, 0.875, 0.2, 0.5
4083, 0.875, 0.25, 0.5
4084, 0.875, 0.3, 0.5
4085, 0.875, 0.35, 0.5
4086, 0.875, 0.4, 0.5
4087, 0.875, 0.45, 0.5
4088, 0.875, 0.5, 0.5
4089, 0.875, 0.55, 0.5
4090, 0.875, 0.6, 0.5
4091, 0.875, 0.65, 0.5
4092, 0.875, 0.7, 0.5
4093, 0.875, 0.75, 0.5
4094, 0.875, 0.8, 0.5
4095, 0.875, 0.85, 0.5
4096, 0.875, 0.9, 0.5
4097, 0.875, 0.95, 0.5
4098, 0.875, 1, 0.5
4099, 0.875, 1.05, 0.5
4100, 0.875, 1.1, 0.5
4101, 0.875, 1.15, 0.5
4102, 0.875, 1.2, 0.5
4103, 0.875, 1.25, 0.5
4104, 0.875, 1.3, 0.5
4105, 0.91666666666667, 0.2, 0.5
4106, 0.91666666666667, 0.25, 0.5
4107, 0.91666666666667, 0.3, 0.5
4108, 0.91666666666667, 0.35, 0.5
4109, 0.91666666666667, 0.4, 0.5
4110, 0.91666666666667, 0.45, 0.5
4111, 0.91666666666667, 0.5, 0.5
4112, 0.91666666666667, 0.55, 0.5
4113, 0.91666666666667, 0.6, 0.5
4114, 0.91666666666667, 0.65, 0.5
4115, 0.91666666666667, 0.7, 0.5
4116, 0.91666666666667, 0.75, 0.5
4117, 0.91666666666667, 0.8, 0.5
4118, 0.91666666666667, 0.85, 0.5
4119, 0.91666666666667, 0.9, 0.5
4120, 0.91666666666667, 0.95, 0.5
4121, 0.91666666666667, 1, 0.5
4122, 0.91666666666667, 1.05, 0.5
4123, 0.91666666666667, 1.1, 0.5
4124, 0.91666666666667, 1.15, 0.5
4125, 0.91666666666667, 1.2, 0.5
4126, 0.91666666666667, 1.25, 0.5
4127, 0.91666666666667, 1.3, 0.5
4128, 0.95833333333333, 0.2, 0.5
4129, 0.95833333333333, 0.25, 0.5
4130, 0.95833333333333, 0.3, 0.5
4131, 0.95833333333333, 0.35, 0.5
4132, 0.95833333333333, 0.4, 0.5
4133, 0.95833333333333, 0.45, 0.5
4134, 0.95833333333333, 0.5, 0.5
4135, 0.95833333333333, 0.55, 0.5
4136, 0.95833333333333, 0.6, 0.5
4137, 0.95833333333333, 0.65, 0.5
4138, 0.95833333333333, 0.7, 0.5
4139, 0.95833333333333, 0.75, 0.5
4140, 0.95833333333333, 0.8, 0.5
4141, 0.95833333333333, 0.85, 0.5
4142, 0.95833333333333, 0.9, 0.5
4143, 0.95833333333333, 0.95, 0.5
4144, 0.95833333333333, 1, 0.5
4145, 0.95833333333333, 1.05, 0.5
4146, 0.95833333333333, 1.1, 0.5
4147, 0.95833333333333, 1.15, 0.5
4148, 0.95833333333333, 1.2, 0.5
4149, 0.95833333333333, 1.25, 0.5
4150, 0.95833333333333, 1.3, 0.5
4151, 0, 0.2, 0.041666666666667
4152, 0, 0.25, 0.041666666666667
4153, 0, 0.3, 0.041666666666667
4154, 0, 0.35, 0.041666666666667
4155, 0, 0.4, 0.041666666666667
4156, 0, 0.45, 0.041666666666667
4157, 0, 0.5, 0.041666666666667
4158, 0, 0.55, 0.041666666666667
4159, 0, 0.6, 0.041666666666667
4160, 0, 0.65, 0.041666666666667
4161, 0, 0.7, 0.041666666666667
4162, 0, 0.75, 0.041666666666667
4163, 0, 0.8, 0.041666666666667
4164, 0, 0.85, 0.041666666666667
4165, 0, 0.9, 0.041666666666667
4166, 0, 0.95, 0.041666666666667
4167, 0, 1, 0.041666666666667
4168, 0, 1.05, 0.041666666666667
4169, 0, 1.1, 0.041666666666667
4170, 0, 1.15, 0.041666666666667
4171, 0, 1.2, 0.041666666666667
4172, 0, 1.25, 0.041666666666667
4173, 0, 1.3, 0.041666666666667
4174, 0, 0.2, 0.083333333333333
4175, 0, 0.25, 0.083333333333333
4176, 0, 0.3, 0.083333333333333
4177, 0, 0.35, 0.083333333333333
4178, 0, 0.4, 0.083333333333333
4179, 0, 0.45, 0.083333333333333
4180, 0, 0.5, 0.083333333333333
4181, 0, 0.55, 0.083333333333333
4182, 0, 0.6, 0.083333333333333
4183, 0, 0.65, 0.083333333333333
4184, 0, 0.7, 0.083333333333333
4185, 0, 0.75, 0.083333333333333
4186, 0, 0.8, 0.083333333333333
4187, 0, 0.85, 0.083333333333333
4188, 0, 0.9, 0.083333333333333
4189, 0, 0.95, 0.083333333333333
4190, 0, 1, 0.083333333333333
4191, 0, 1.05, 0.083333333333333
4192, 0, 1.1, 0.083333333333333
4193, 0, 1.15, 0.083333333333333
4194, 0, 1.2, 0.083333333333333
4195, 0, 1.25, 0.083333333333333
4196, 0, 1.3, 0.083333333333333
4197, 0, 0.2, 0.125
4198, 0, 0.25, 0.125
4199, 0, 0.3, 0.125
4200, 0, 0.35, 0.125
4201, 0, 0.4, 0.125
4202, 0, 0.45, 0.125
4203, 0, 0.5, 0.125
4204, 0, 0.55, 0.125
4205, 0, 0.6, 0.125
4206, 0, 0.65, 0.125
4207, 0, 0.7, 0.125
4208, 0, 0.75, 0.125
4209, 0, 0.8, 0.125
4210, 0, 0.85, 0.125
4211, 0, 0.9, 0.125
4212, 0, 0.95, 0.125
4213, 0, 1, 0.125
4214, 0, 1.05, 0.125
4215, 0, 1.1, 0.125
4216, 0, 1.15, 0.125
4217, 0, 1.2, 0.125
4218, 0, 1.25, 0.125
4219, 0, 1.3, 0.125
4220, 0, 0.2, 0.16666666666667
4221, 0, 0.25, 0.16666666666667
4222, 0, 0.3, 0.16666666666667
4223, 0, 0.35, 0.16666666666667
4224, 0, 0.4, 0.16666666666667
4225, 0, 0.45, 0.16666666666667
4226, 0, 0.5, 0.16666666666667
4227, 0, 0.55, 0.16666666666667
4228, 0, 0.6, 0.16666666666667
4229, 0, 0.65, 0.16666666666667
4230, 0, 0.7, 0.16666666666667
4231, 0, 0.75, 0.16666666666667
4232, 0, 0.8, 0.16666666666667
4233, 0, 0.85, 0.16666666666667
4234, 0, 0.9, 0.16666666666667
4235, 0, 0.95, 0.16666666666667
4236, 0, 1, 0.16666666666667
4237, 0, 1.05, 0.16666666666667
4238, 0, 1.1, 0.16666666666667
4239, 0, 1.15, 0.16666666666667
4240, 0, 1.2, 0.16666666666667
4241, 0, 1.25, 0.16666666666667
4242, 0, 1.3, 0.16666666666667
4243, 0, 0.2, 0.20833333333333
4244, 0, 0.25, 0.20833333333333
4245, 0, 0.3, 0.20833333333333
4246, 0, 0.35, 0.20833333333333
4247, 0, 0.4, 0.20833333333333
4248, 0, 0.45, 0.20833333333333
4249, 0, 0.5, 0.20833333333333
4250, 0, 0.55, 0.20833333333333
4251, 0, 0.6, 0.20833333333333
4252, 0, 0.65, 0.20833333333333
4253, 0, 0.7, 0.20833333333333
4254, 0, 0.75, 0.20833333333333
4255, 0, 0.8, 0.20833333333333
4256, 0, 0.85, 0.20833333333333
4257, 0, 0.9, 0.20833333333333
4258, 0, 0.95, 0.20833333333333
4259, 0, 1, 0.20833333333333
4260, 0, 1.05, 0.20833333333333
4261, 0, 1.1, 0.20833333333333
4262, 0, 1.15, 0.20833333333333
4263, 0, 1.2, 0.20833333333333
4264, 0, 1.25, 0.20833333333333
4265, 0, 1.3, 0.20833333333333
4266, 0, 0.2, 0.25
4267, 0, 0.25, 0.25
4268, 0, 0.3, 0.25
4269, 0, 0.35, 0.25
4270, 0, 0.4, 0.25
4271, 0, 0.45, 0.25
4272, 0, 0.5, 0.25
4273, 0, 0.55, 0.25
4274, 0, 0.6, 0.25
4275, 0, 0.65, 0.25
4276, 0, 0.7, 0.25
4277, 0, 0.75, 0.25
4278, 0, 0.8, 0.25
4279, 0, 0.85, 0.25
4280, 0, 0.9, 0.25
4281, 0, 0.95, 0.25
4282, 0, 1, 0.25
4283, 0, 1.05, 0.25
4284, 0, 1.1, 0.25
4285, 0, 1.15, 0.25
4286, 0, 1.2, 0.25
4287, 0, 1.25, 0.25
4288, 0, 1.3, 0.25
4289, 0, 0.2, 0.29166666666667
4290, 0, 0.25, 0.29166666666667
4291, 0, 0.3, 0.29166666666667
4292, 0, 0.35, 0.29166666666667
4293, 0, 0.4, 0.29166666666667
4294, 0, 0.45, 0.29166666666667
4295, 0, 0.5, 0.29166666666667
4296, 0, 0.55, 0.29166666666667
4297, 0, 0.6, 0.29166666666667
4298, 0, 0.65, 0.29166666666667
4299, 0, 0.7, 0.29166666666667
4300, 0, 0.75, 0.29166666666667
4301, 0, 0.8, 0.29166666666667
4302, 0, 0.85, 0.29166666666667
4303, 0, 0.9, 0.29166666666667
4304, 0, 0.95, 0.29166666666667
4305, 0, 1, 0.29166666666667
4306, 0, 1.05, 0.29166666666667
4307, 0, 1.1, 0.29166666666667
4308, 0, 1.15, 0.29166666666667
4309, 0, 1.2, 0.29166666666667
4310, 0, 1.25, 0.29166666666667
4311, 0, 1.3, 0.29166666666667
4312, 0, 0.2, 0.33333333333333
4313, 0, 0.25, 0.33333333333333
4314, 0, 0.3, 0.33333333333333
4315, 0, 0.35, 0.33333333333333
4316, 0, 0.4, 0.33333333333333
4317, 0, 0.45, 0.33333333333333
4318, 0, 0.5, 0.33333333333333
4319, 0, 0.55, 0.33333333333333
4320, 0, 0.6, 0.33333333333333
4321, 0, 0.65, 0.33333333333333
4322, 0, 0.7, 0.33333333333333
4323, 0, 0.75, 0.33333333333333
4324, 0, 0.8, 0.33333333333333
4325, 0, 0.85, 0.33333333333333
4326, 0, 0.9, 0.33333333333333
4327, 0, 0.95, 0.33333333333333
4328, 0, 1, 0.33333333333333
4329, 0, 1.05, 0.33333333333333
4330, 0, 1.1, 0.33333333333333
4331, 0, 1.15, 0.33333333333333
4332, 0, 1.2, 0.33333333333333
4333, 0, 1.25, 0.33333333333333
4334, 0, 1.3, 0.33333333333333
4335, 0, 0.2, 0.375
4336, 0, 0.25, 0.375
4337, 0, 0.3, 0.375
4338, 0, 0.35, 0.375
4339, 0, 0.4, 0.375
4340, 0, 0.45, 0.375
4341, 0, 0.5, 0.375
4342, 0, 0.55, 0.375
4343, 0, 0.6, 0.375
4344, 0, 0.65, 0.375
4345, 0, 0.7, 0.375
4346, 0, 0.75, 0.375
4347, 0, 0.8, 0.375
4348, 0, 0.85, 0.375
4349, 0, 0.9, 0.375
4350, 0, 0.95, 0.375
4351, 0, 1, 0.375
4352, 0, 1.05, 0.375
4353, 0, 1.1, 0.375
4354, 0, 1.15, 0.375
4355, 0, 1.2, 0.375
4356, 0, 1.25, 0.375
4357, 0, 1.3, 0.375
4358, 0, 0.2, 0.41666666666667
4359, 0, 0.25, 0.41666666666667
4360, 0, 0.3, 0.41666666666667
4361, 0, 0.35, 0.41666666666667
4362, 0, 0.4, 0.41666666666667
4363, 0, 0.45, 0.41666666666667
4364, 0, 0.5, 0.41666666666667
4365, 0, 0.55, 0.41666666666667
4366, 0, 0.6, 0.41666666666667
4367, 0, 0.65, 0.41666666666667
4368, 0, 0.7, 0.41666666666667
4369, 0, 0.75, 0.41666666666667
4370, 0, 0.8, 0.41666666666667
4371, 0, 0.85, 0.41666666666667
4372, 0, 0.9, 0.41666666666667
4373, 0, 0.95, 0.41666666666667
4374, 0, 1, 0.41666666666667
4375, 0, 1.05, 0.41666666666667
4376, 0, 1.1, 0.41666666666667
4377, 0, 1.15, 0.41666666666667
4378, 0, 1.2, 0.41666666666667
4379, 0, 1.25, 0.41666666666667
4380, 0, 1.3, 0.41666666666667
4381, 0, 0.2, 0.45833333333333
4382, 0, 0.25, 0.45833333333333
4383, 0, 0.3, 0.45833333333333
4384, 0, 0.35, 0.45833333333333
4385, 0, 0.4, 0.45833333333333
4386, 0, 0.45, 0.45833333333333
4387, 0, 0.5, 0.45833333333333
4388, 0, 0.55, 0.45833333333333
4389, 0, 0.6, 0.45833333333333
4390, 0, 0.65, 0.45833333333333
4391, 0, 0.7, 0.45833333333333
4392, 0, 0.75, 0.45833333333333
4393, 0, 0.8, 0.45833333333333
4394, 0, 0.85, 0.45833333333333
4395, 0, 0.9, 0.45833333333333
4396, 0, 0.95, 0.45833333333333
4397, 0, 1, 0.45833333333333
4398, 0, 1.05, 0.45833333333333
4399, 0, 1.1, 0.45833333333333
4400, 0, 1.15, 0.45833333333333
4401, 0, 1.2, 0.45833333333333
4402, 0, 1.25, 0.45833333333333
4403, 0, 1.3, 0.45833333333333
4404, 0.041666666666667, 1.35, 0.041666666666667
4405, 0.041666666666667, 1.35, 0.083333333333333
4406, 0.041666666666667, 1.35, 0.125
4407, 0.041666666666667, 1.35, 0.16666666666667
4408, 0.041666666666667, 1.35, 0.20833333333333
4409, 0.041666666666667, 1.35, 0.25
4410, 0.041666666666667, 1.35, 0.29166666666667
4411, 0.041666666666667, 1.35, 0.33333333333333
4412, 0.041666666666667, 1.35, 0.375
4413, 0.041666666666667, 1.35, 0.41666666666667
4414, 0.041666666666667, 1.35, 0.45833333333333
4415, 0.083333333333333, 1.35, 0.041666666666667
4416, 0.083333333333333, 1.35, 0.083333333333333
4417, 0.083333333333333, 1.35, 0.125
4418, 0.083333333333333, 1.35, 0.16666666666667
4419, 0.083333333333333, 1.35, 0.20833333333333
4420, 0.083333333333333, 1.35, 0.25
4421, 0.083333333333333, 1.35, 0.29166666666667
4422, 0.083333333333333, 1.35, 0.33333333333333
4423, 0.083333333333333, 1.35, 0.375
4424, 0.083333333333333, 1.35, 0.41666666666667
4425, 0.083333333333333, 1.35, 0.45833333333333
4426, 0.125, 1.35, 0.041666666666667
4427, 0.125, 1.35, 0.083333333333333
4428, 0.125, 1.35, 0.125
4429, 0.125, 1.35, 0.16666666666667
4430, 0.125, 1.35, 0.20833333333333
4431, 0.125, 1.35, 0.25
4432, 0.125, 1.35, 0.29166666666667
4433, 0.125, 1.35, 0.33333333333333
4434, 0.125, 1.35, 0.375
4435, 0.125, 1.35, 0.41666666666667
4436, 0.125, 1.35, 0.45833333333333
4437, 0.16666666666667, 1.35, 0.041666666666667
4438, 0.16666666666667, 1.35, 0.083333333333333
4439, 0.16666666666667, 1.35, 0.125
4440, 0.16666666666667, 1.35, 0.16666666666667
4441, 0.16666666666667, 1.35, 0.20833333333333
4442, 0.16666666666667, 1.35, 0.25
4443, 0.16666666666667, 1.35, 0.29166666666667
4444, 0.16666666666667, 1.35, 0.33333333333333
4445, 0.16666666666667, 1.35, 0.375
4446, 0.16666666666667, 1.35, 0.41666666666667
4447, 0.16666666666667, 1.35, 0.45833333333333
4448, 0.20833333333333, 1.35, 0.041666666666667
4449, 0.20833333333333, 1.35, 0.083333333333333
4450, 0.20833333333333, 1.35, 0.125
4451, 0.20833333333333, 1.35, 0.16666666666667
4452, 0.20833333333333, 1.35, 0.20833333333333
4453, 0.20833333333333, 1.35, 0.25
4454, 0.20833333333333, 1.35, 0.29166666666667
4455, 0.20833333333333, 1.35, 0.33333333333333
4456, 0.20833333333333, 1.35, 0.375
4457, 0.20833333333333, 1.35, 0.41666666666667
4458, 0.20833333333333, 1.35, 0.45833333333333
4459, 0.25, 1.35, 0.041666666666667
4460, 0.25, 1.35, 0.083333333333333
4461, 0.25, 1.35, 0.125
4462, 0.25, 1.35, 0.16666666666667
4463, 0.25, 1.35, 0.20833333333333
4464, 0.25, 1.35, 0.25
4465, 0.25, 1.35, 0.29166666666667
4466, 0.25, 1.35, 0.33333333333333
4467, 0.25, 1.35, 0.375
4468, 0.25, 1.35, 0.41666666666667
4469, 0.25, 1.35, 0.45833333333333
4470, 0.29166666666667, 1.35, 0.041666666666667
4471, 0.29166666666667, 1.35, 0.083333333333333
4472, 0.29166666666667, 1.35, 0.125
4473, 0.29166666666667, 1.35, 0.16666666666667
4474, 0.29166666666667, 1.35, 0.20833333333333
4475, 0.29166666666667, 1.35, 0.25
4476, 0.29166666666667, 1.35, 0.29166666666667
4477, 0.29166666666667, 1.35, 0.33333333333333
4478, 0.29166666666667, 1.35, 0.375
4479, 0.29166666666667, 1.35, 0.41666666666667
4480, 0.29166666666667, 1.35, 0.45833333333333
4481, 0.33333333333333, 1.35, 0.041666666666667
4482, 0.33333333333333, 1.35, 0.083333333333333
4483, 0.33333333333333, 1.35, 0.125
4484, 0.33333333333333, 1.35, 0.16666666666667
4485, 0.33333333333333, 1.35, 0.20833333333333
4486, 0.33333333333333, 1.35, 0.25
4487, 0.33333333333333, 1.35, 0.29166666666667
4488, 0.33333333333333, 1.35, 0.33333333333333
4489, 0.33333333333333, 1.35, 0.375
4490, 0.33333333333333, 1.35, 0.41666666666667
4491, 0.33333333333333, 1.35, 0.45833333333333
4492, 0.375, 1.35, 0.041666666666667
4493, 0.375, 1.35, 0.083333333333333
4494, 0.375, 1.35, 0.125
4495, 0.375, 1.35, 0.16666666666667
4496, 0.375, 1.35, 0.20833333333333
4497, 0.375, 1.35, 0.25
4498, 0.375, 1.35, 0.29166666666667
4499, 0.375, 1.35, 0.33333333333333
4500, 0.375, 1.35, 0.375
4501, 0.375, 1.35, 0.41666666666667
4502, 0.375, 1.35, 0.45833333333333
4503, 0.41666666666667, 1.35, 0.041666666666667
4504, 0.41666666666667, 1.35, 0.083333333333333
4505, 0.41666666666667, 1.35, 0.125
4506, 0.41666666666667, 1.35, 0.16666666666667
4507, 0.41666666666667, 1.35, 0.20833333333333
4508, 0.41666666666667, 1.35, 0.25
4509, 0.41666666666667, 1.35, 0.29166666666667
4510, 0.41666666666667, 1.35, 0.33333333333333
4511, 0.41666666666667, 1.35, 0.375
4512, 0.41666666666667, 1.35, 0.41666666666667
4513, 0.41666666666667, 1.35, 0.45833333333333
4514, 0.45833333333333, 1.35, 0.041666666666667
4515, 0.45833333333333, 1.35, 0.083333333333333
4516, 0.45833333333333, 1.35, 0.125
4517, 0.45833333333333, 1.35, 0.16666666666667
4518, 0.45833333333333, 1.35, 0.20833333333333
4519, 0.45833333333333, 1.35, 0.25
4520, 0.45833333333333, 1.35, 0.29166666666667
4521, 0.45833333333333, 1.35, 0.33333333333333
4522, 0.45833333333333, 1.35, 0.375
4523, 0.45833333333333, 1.35, 0.41666666666667
4524, 0.45833333333333, 1.35, 0.45833333333333
4525, 0.5, 1.35, 0.041666666666667
4526, 0.5, 1.35, 0.083333333333333
4527, 0.5, 1.35, 0.125
4528, 0.5, 1.35, 0.16666666666667
4529, 0.5, 1.35, 0.20833333333333
4530, 0.5, 1.35, 0.25
4531, 0.5, 1.35, 0.29166666666667
4532, 0.5, 1.35, 0.33333333333333
4533, 0.5, 1.35, 0.375
4534, 0.5, 1.35, 0.41666666666667
4535, 0.5, 1.35, 0.45833333333333
4536, 0.54166666666667, 1.35, 0.041666666666667
4537, 0.54166666666667, 1.35, 0.083333333333333
4538, 0.54166666666667, 1.35, 0.125
4539, 0.54166666666667, 1.35, 0.16666666666667
4540, 0.54166666666667, 1.35, 0.20833333333333
4541, 0.54166666666667, 1.35, 0.25
4542, 0.54166666666667, 1.35, 0.29166666666667
4543, 0.54166666666667, 1.35, 0.33333333333333
4544, 0.54166666666667, 1.35, 0.375
4545, 0.54166666666667, 1.35, 0.41666666666667
4546, 0.54166666666667, 1.35, 0.45833333333333
4547, 0.58333333333333, 1.35, 0.041666666666667
4548, 0.58333333333333, 1.35, 0.083333333333333
4549, 0.58333333333333, 1.35, 0.125
4550, 0.58333333333333, 1.35, 0.16666666666667
4551, 0.58333333333333, 1.35, 0.20833333333333
4552, 0.58333333333333, 1.35, 0.25
4553, 0.58333333333333, 1.35, 0.29166666666667
4554, 0.58333333333333, 1.35, 0.33333333333333
4555, 0.58333333333333, 1.35, 0.375
4556, 0.58333333333333, 1.35, 0.41666666666667
4557, 0.58333333333333, 1.35, 0.45833333333333
4558, 0.625, 1.35, 0.041666666666667
4559, 0.625, 1.35, 0.083333333333333
4560, 0.625, 1.35, 0.125
4561, 0.625, 1.35, 0.16666666666667
4562, 0.625, 1.35, 0.20833333333333
4563, 0.625, 1.35, 0.25
4564, 0.625, 1.35, 0.29166666666667
4565, 0.625, 1.35, 0.33333333333333
4566, 0.625, 1.35, 0.375
4567, 0.625, 1.35, 0.41666666666667
4568, 0.625, 1.35, 0.45833333333333
4569, 0.66666666666667, 1.35, 0.041666666666667
4570, 0.66666666666667, 1.35, 0.083333333333333
4571, 0.66666666666667, 1.35, 0.125
4572, 0.66666666666667, 1.35, 0.16666666666667
4573, 0.66666666666667, 1.35, 0.20833333333333
4574, 0.66666666666667, 1.35, 0.25
4575, 0.66666666666667, 1.35, 0.29166666666667
4576, 0.66666666666667, 1.35, 0.33333333333333
4577, 0.66666666666667, 1.35, 0.375
4578, 0.66666666666667, 1.35, 0.41666666666667
4579, 0.66666666666667, 1.35, 0.45833333333333
4580, 0.70833333333333, 1.35, 0.041666666666667
4581, 0.70833333333333, 1.35, 0.083333333333333
4582, 0.70833333333333, 1.35, 0.125
4583, 0.70833333333333, 1.35, 0.16666666666667
4584, 0.70833333333333, 1.35, 0.20833333333333
4585, 0.70833333333333, 1.35, 0.25
4586, 0.70833333333333, 1.35, 0.29166666666667
4587, 0.70833333333333, 1.35, 0.33333333333333
4588, 0.70833333333333, 1.35, 0.375
4589, 0.70833333333333, 1.35, 0.41666666666667
4590, 0.70833333333333, 1.35, 0.45833333333333
4591, 0.75, 1.35, 0.041666666666667
4592, 0.75, 1.35, 0.083333333333333
4593, 0.75, 1.35, 0.125
4594, 0.75, 1.35, 0.16666666666667
4595, 0.75, 1.35, 0.20833333333333
4596, 0.75, 1.35, 0.25
4597, 0.75, 1.35, 0.29166666666667
4598, 0.75, 1.35, 0.33333333333333
4599, 0.75, 1.35, 0.375
4600, 0.75, 1.35, 0.41666666666667
4601, 0.75, 1.35, 0.45833333333333
4602, 0.79166666666667, 1.35, 0.041666666666667
4603, 0.79166666666667, 1.35, 0.083333333333333
4604, 0.79166666666667, 1.35, 0.125
4605, 0.79166666666667, 1.35, 0.16666666666667
4606, 0.79166666666667, 1.35, 0.20833333333333
4607, 0.79166666666667, 1.35, 0.25
4608, 0.79166666666667, 1.35, 0.29166666666667
4609, 0.79166666666667, 1.35, 0.33333333333333
4610, 0.79166666666667, 1.35, 0.375
4611, 0.79166666666667, 1.35, 0.41666666666667
4612, 0.79166666666667, 1.35, 0.45833333333333
4613, 0.83333333333333, 1.35, 0.041666666666667
4614, 0.83333333333333, 1.35, 0.083333333333333
4615, 0.83333333333333, 1.35, 0.125
4616, 0.83333333333333, 1.35, 0.16666666666667
4617, 0.83333333333333, 1.35, 0.20833333333333
4618, 0.83333333333333, 1.35, 0.25
4619, 0.83333333333333, 1.35, 0.29166666666667
4620, 0.83333333333333, 1.35, 0.33333333333333
4621, 0.83333333333333, 1.35, 0.375
4622, 0.83333333333333, 1.35, 0.41666666666667
4623, 0.83333333333333, 1.35, 0.45833333333333
4624, 0.875, 1.35, 0.041666666666667
4625, 0.875, 1.35, 0.083333333333333
4626, 0.875, 1.35, 0.125
4627, 0.875, 1.35, 0.16666666666667
4628, 0.875, 1.35, 0.20833333333333
4629, 0.875, 1.35, 0.25
4630, 0.875, 1.35, 0.29166666666667
4631, 0.875, 1.35, 0.33333333333333
4632, 0.875, 1.35, 0.375
4633, 0.875, 1.35, 0.41666666666667
4634, 0.875, 1.35, 0.45833333333333
4635, 0.91666666666667, 1.35, 0.041666666666667
4636, 0.91666666666667, 1.35, 0.083333333333333
4637, 0.91666666666667, 1.35, 0.125
4638, 0.91666666666667, 1.35, 0.16666666666667
4639, 0.91666666666667, 1.35, 0.20833333333333
4640, 0.91666666666667, 1.35, 0.25
4641, 0.91666666666667, 1.35, 0.29166666666667
4642, 0.91666666666667, 1.35, 0.33333333333333
4643, 0.91666666666667, 1.35, 0.375
4644, 0.91666666666667, 1.35, 0.41666666666667
4645, 0.91666666666667, 1.35, 0.45833333333333
4646, 0.95833333333333, 1.35, 0.041666666666667
4647, 0.95833333333333, 1.35, 0.083333333333333
4648, 0.95833333333333, 1.35, 0.125
4649, 0.95833333333333, 1.35, 0.16666666666667
4650, 0.95833333333333, 1.35, 0.20833333333333
4651, 0.95833333333333, 1.35, 0.25
4652, 0.95833333333333, 1.35, 0.29166666666667
4653, 0.95833333333333, 1.35, 0.33333333333333
4654, 0.95833333333333, 1.35, 0.375
4655, 0.95833333333333, 1.35, 0.41666666666667
4656, 0.95833333333333, 1.35, 0.45833333333333
4657, 0.041666666666667, 1.4, 0.041666666666667
4658, 0.041666666666667, 1.4, 0.083333333333333
4659, 0.041666666666667, 1.4, 0.125
4660, 0.041666666666667, 1.4, 0.16666666666667
4661, 0.041666666666667, 1.4, 0.20833333333333
4662, 0.041666666666667, 1.4, 0.25
4663, 0.041666666666667, 1.4, 0.29166666666667
4664, 0.041666666666667, 1.4, 0.33333333333333
4665, 0.041666666666667, 1.4, 0.375
4666, 0.041666666666667, 1.4, 0.41666666666667
4667, 0.041666666666667, 1.4, 0.45833333333333
4668, 0.083333333333333, 1.4, 0.041666666666667
4669, 0.083333333333333, 1.4, 0.083333333333333
4670, 0.083333333333333, 1.4, 0.125
4671, 0.083333333333333, 1.4, 0.16666666666667
4672, 0.083333333333333, 1.4, 0.20833333333333
4673, 0.083333333333333, 1.4, 0.25
4674, 0.083333333333333, 1.4, 0.29166666666667
4675, 0.083333333333333, 1.4, 0.33333333333333
4676, 0.083333333333333, 1.4, 0.375
4677, 0.083333333333333, 1.4, 0.41666666666667
4678, 0.083333333333333, 1.4, 0.45833333333333
4679, 0.125, 1.4, 0.041666666666667
4680, 0.125, 1.4, 0.083333333333333
4681, 0.125, 1.4, 0.125
4682, 0.125, 1.4, 0.16666666666667
4683, 0.125, 1.4, 0.20833333333333
4684, 0.125, 1.4, 0.25
4685, 0.125, 1.4, 0.29166666666667
4686, 0.125, 1.4, 0.33333333333333
4687, 0.125, 1.4, 0.375
4688, 0.125, 1.4, 0.41666666666667
4689, 0.125, 1.4, 0.45833333333333
4690, 0.16666666666667, 1.4, 0.041666666666667
4691, 0.16666666666667, 1.4, 0.083333333333333
4692, 0.16666666666667, 1.4, 0.125
4693, 0.16666666666667, 1.4, 0.16666666666667
4694, 0.16666666666667, 1.4, 0.20833333333333
4695, 0.16666666666667, 1.4, 0.25
4696, 0.16666666666667, 1.4, 0.29166666666667
4697, 0.16666666666667, 1.4, 0.33333333333333
4698, 0.16666666666667, 1.4, 0.375
4699, 0.16666666666667, 1.4, 0.41666666666667
4700, 0.16666666666667, 1.4, 0.45833333333333
4701, 0.20833333333333, 1.4, 0.041666666666667
4702, 0.20833333333333, 1.4, 0.083333333333333
4703, 0.20833333333333, 1.4, 0.125
4704, 0.20833333333333, 1.4, 0.16666666666667
4705, 0.20833333333333, 1.4, 0.20833333333333
4706, 0.20833333333333, 1.4, 0.25
4707, 0.20833333333333, 1.4, 0.29166666666667
4708, 0.20833333333333, 1.4, 0.33333333333333
4709, 0.20833333333333, 1.4, 0.375
4710, 0.20833333333333, 1.4, 0.41666666666667
4711, 0.20833333333333, 1.4, 0.45833333333333
4712, 0.25, 1.4, 0.041666666666667
4713, 0.25, 1.4, 0.083333333333333
4714, 0.25, 1.4, 0.125
4715, 0.25, 1.4, 0.16666666666667
4716, 0.25, 1.4, 0.20833333333333
4717, 0.25, 1.4, 0.25
4718, 0.25, 1.4, 0.29166666666667
4719, 0.25, 1.4, 0.33333333333333
4720, 0.25, 1.4, 0.375
4721, 0.25, 1.4, 0.41666666666667
4722, 0.25, 1.4, 0.45833333333333
4723, 0.29166666666667, 1.4, 0.041666666666667
4724, 0.29166666666667, 1.4, 0.083333333333333
4725, 0.29166666666667, 1.4, 0.125
4726, 0.29166666666667, 1.4, 0.16666666666667
4727, 0.29166666666667, 1.4, 0.20833333333333
4728, 0.29166666666667, 1.4, 0.25
4729, 0.29166666666667, 1.4, 0.29166666666667
4730, 0.29166666666667, 1.4, 0.33333333333333
4731, 0.29166666666667, 1.4, 0.375
4732, 0.29166666666667, 1.4, 0.41666666666667
4733, 0.29166666666667, 1.4, 0.45833333333333
4734, 0.33333333333333, 1.4, 0.041666666666667
4735, 0.33333333333333, 1.4, 0.083333333333333
4736, 0.33333333333333, 1.4, 0.125
4737, 0.33333333333333, 1.4, 0.16666666666667
4738, 0.33333333333333, 1.4, 0.20833333333333
4739, 0.33333333333333, 1.4, 0.25
4740, 0.33333333333333, 1.4, 0.29166666666667
4741, 0.33333333333333, 1.4, 0.33333333333333
4742, 0.33333333333333, 1.4, 0.375
4743, 0.33333333333333, 1.4, 0.41666666666667
4744, 0.33333333333333, 1.4, 0.45833333333333
4745, 0.375, 1.4, 0.041666666666667
4746, 0.375, 1.4, 0.083333333333333
4747, 0.375, 1.4, 0.125
4748, 0.375, 1.4, 0.16666666666667
4749, 0.375, 1.4, 0.20833333333333
4750, 0.375, 1.4, 0.25
4751, 0.375, 1.4, 0.29166666666667
4752, 0.375, 1.4, 0.33333333333333
4753, 0.375, 1.4, 0.375
4754, 0.375, 1.4, 0.41666666666667
4755, 0.375, 1.4, 0.45833333333333
4756, 0.41666666666667, 1.4, 0.041666666666667
4757, 0.41666666666667, 1.4, 0.083333333333333
4758, 0.41666666666667, 1.4, 0.125
4759, 0.41666666666667, 1.4, 0.16666666666667
4760, 0.41666666666667, 1.4, 0.20833333333333
4761, 0.41666666666667, 1.4, 0.25
4762, 0.41666666666667, 1.4, 0.29166666666667
4763, 0.41666666666667, 1.4, 0.33333333333333
4764, 0.41666666666667, 1.4, 0.375
4765, 0.41666666666667, 1.4, 0.41666666666667
4766, 0.41666666666667, 1.4, 0.45833333333333
4767, 0.45833333333333, 1.4, 0.041666666666667
4768, 0.45833333333333, 1.4, 0.083333333333333
4769, 0.45833333333333, 1.4, 0.125
4770, 0.45833333333333, 1.4, 0.16666666666667
4771, 0.45833333333333, 1.4, 0.20833333333333
4772, 0.45833333333333, 1.4, 0.25
4773, 0.45833333333333, 1.4, 0.29166666666667
4774, 0.45833333333333, 1.4, 0.33333333333333
4775, 0.45833333333333, 1.4, 0.375
4776, 0.45833333333333, 1.4, 0.41666666666667
4777, 0.45833333333333, 1.4, 0.45833333333333
4778, 0.5, 1.4, 0.041666666666667
4779, 0.5, 1.4, 0.083333333333333
4780, 0.5, 1.4, 0.125
4781, 0.5, 1.4, 0.16666666666667
4782, 0.5, 1.4, 0.20833333333333
4783, 0.5, 1.4, 0.25
4784, 0.5, 1.4, 0.29166666666667
4785, 0.5, 1.4, 0.33333333333333
4786, 0.5, 1.4, 0.375
4787, 0.5, 1.4, 0.41666666666667
4788, 0.5, 1.4, 0.45833333333333
4789, 0.54166666666667, 1.4, 0.041666666666667
4790, 0.54166666666667, 1.4, 0.083333333333333
4791, 0.54166666666667, 1.4, 0.125
4792, 0.54166666666667, 1.4, 0.16666666666667
4793, 0.54166666666667, 1.4, 0.20833333333333
4794, 0.54166666666667, 1.4, 0.25
4795, 0.54166666666667, 1.4, 0.29166666666667
4796, 0.54166666666667, 1.4, 0.33333333333333
4797, 0.54166666666667, 1.4, 0.375
4798, 0.54166666666667, 1.4, 0.41666666666667
4799, 0.54166666666667, 1.4, 0.45833333333333
4800, 0.58333333333333, 1.4, 0.041666666666667
4801, 0.58333333333333, 1.4, 0.083333333333333
4802, 0.58333333333333, 1.4, 0.125
4803, 0.58333333333333, 1.4, 0.16666666666667
4804, 0.58333333333333, 1.4, 0.20833333333333
4805, 0.58333333333333, 1.4, 0.25
4806, 0.58333333333333, 1.4, 0.29166666666667
4807, 0.58333333333333, 1.4, 0.33333333333333
4808, 0.58333333333333, 1.4, 0.375
4809, 0.58333333333333, 1.4, 0.41666666666667
4810, 0.58333333333333, 1.4, 0.45833333333333
4811, 0.625, 1.4, 0.041666666666667
4812, 0.625, 1.4, 0.083333333333333
4813, 0.625, 1.4, 0.125
4814, 0.625, 1.4, 0.16666666666667
4815, 0.625, 1.4, 0.20833333333333
4816, 0.625, 1.4, 0.25
4817, 0.625, 1.4, 0.29166666666667
4818, 0.625, 1.4, 0.33333333333333
4819, 0.625, 1.4, 0.375
4820, 0.625, 1.4, 0.41666666666667
4821, 0.625, 1.4, 0.45833333333333
4822, 0.66666666666667, 1.4, 0.041666666666667
4823, 0.66666666666667, 1.4, 0.083333333333333
4824, 0.66666666666667, 1.4, 0.125
4825, 0.66666666666667, 1.4, 0.16666666666667
4826, 0.66666666666667, 1.4, 0.20833333333333
4827, 0.66666666666667, 1.4, 0.25
4828, 0.66666666666667, 1.4, 0.29166666666667
4829, 0.66666666666667, 1.4, 0.33333333333333
4830, 0.66666666666667, 1.4, 0.375
4831, 0.66666666666667, 1.4, 0.41666666666667
4832, 0.66666666666667, 1.4, 0.45833333333333
4833, 0.70833333333333, 1.4, 0.041666666666667
4834, 0.70833333333333, 1.4, 0.083333333333333
4835, 0.70833333333333, 1.4, 0.125
4836, 0.70833333333333, 1.4, 0.16666666666667
4837, 0.70833333333333, 1.4, 0.20833333333333
4838, 0.70833333333333, 1.4, 0.25
4839, 0.70833333333333, 1.4, 0.29166666666667
4840, 0.70833333333333, 1.4, 0.33333333333333
4841, 0.70833333333333, 1.4, 0.375
4842, 0.70833333333333, 1.4, 0.41666666666667
4843, 0.70833333333333, 1.4, 0.45833333333333
4844, 0.75, 1.4, 0.041666666666667
4845, 0.75, 1.4, 0.083333333333333
4846, 0.75, 1.4, 0.125
4847, 0.75, 1.4, 0.16666666666667
4848, 0.75, 1.4, 0.20833333333333
4849, 0.75, 1.4, 0.25
4850, 0.75, 1.4, 0.29166666666667
4851, 0.75, 1.4, 0.33333333333333
4852, 0.75, 1.4, 0.375
4853, 0.75, 1.4, 0.41666666666667
4854, 0.75, 1.4, 0.45833333333333
4855, 0.79166666666667, 1.4, 0.041666666666667
4856, 0.79166666666667, 1.4, 0.083333333333333
4857, 0.79166666666667, 1.4, 0.125
4858, 0.79166666666667, 1.4, 0.16666666666667
4859, 0.79166666666667, 1.4, 0.20833333333333
4860, 0.79166666666667, 1.4, 0.25
4861, 0.79166666666667, 1.4, 0.29166666666667
4862, 0.79166666666667, 1.4, 0.33333333333333
4863, 0.79166666666667, 1.4, 0.375
4864, 0.79166666666667, 1.4, 0.41666666666667
4865, 0.79166666666667, 1.4, 0.45833333333333
4866, 0.83333333333333, 1.4, 0.041666666666667
4867, 0.83333333333333, 1.4, 0.083333333333333
4868, 0.83333333333333, 1.4, 0.125
4869, 0.83333333333333, 1.4, 0.16666666666667
4870, 0.83333333333333, 1.4, 0.20833333333333
4871, 0.83333333333333, 1.4, 0.25
4872, 0.83333333333333, 1.4, 0.29166666666667
4873, 0.83333333333333, 1.4, 0.33333333333333
4874, 0.83333333333333, 1.4, 0.375
4875, 0.83333333333333, 1.4, 0.41666666666667
4876, 0.83333333333333, 1.4, 0.45833333333333
4877, 0.875, 1.4, 0.041666666666667
4878, 0.875, 1.4, 0.083333333333333
4879, 0.875, 1.4, 0.125
4880, 0.875, 1.4, 0.16666666666667
4881, 0.875, 1.4, 0.20833333333333
4882, 0.875, 1.4, 0.25
4883, 0.875, 1.4, 0.29166666666667
4884, 0.875, 1.4, 0.33333333333333
4885, 0.875, 1.4, 0.375
4886, 0.875, 1.4, 0.41666666666667
4887, 0.875, 1.4, 0.45833333333333
4888, 0.91666666666667, 1.4, 0.041666666666667
4889, 0.91666666666667, 1.4, 0.083333333333333
4890, 0.91666666666667, 1.4, 0.125
4891, 0.91666666666667, 1.4, 0.16666666666667
4892, 0.91666666666667, 1.4, 0.20833333333333
4893, 0.91666666666667, 1.4, 0.25
4894, 0.91666666666667, 1.4, 0.29166666666667
4895, 0.91666666666667, 1.4, 0.33333333333333
4896, 0.91666666666667, 1.4, 0.375
4897, 0.91666666666667, 1.4, 0.41666666666667
4898, 0.91666666666667, 1.4, 0.45833333333333
4899, 0.95833333333333, 1.4, 0.041666666666667
4900, 0.95833333333333, 1.4, 0.083333333333333
4901, 0.95833333333333, 1.4, 0.125
4902, 0.95833333333333, 1.4, 0.16666666666667
4903, 0.95833333333333, 1.4, 0.20833333333333
4904, 0.95833333333333, 1.4, 0.25
4905, 0.95833333333333, 1.4, 0.29166666666667
4906, 0.95833333333333, 1.4, 0.33333333333333
4907, 0.95833333333333, 1.4, 0.375
4908, 0.95833333333333, 1.4, 0.41666666666667
4909, 0.95833333333333, 1.4, 0.45833333333333
4910, 0.041666666666667, 1.4333333333333, 0
4911, 0.041666666666667, 1.4666666666667, 0
4912, 0.083333333333333, 1.4333333333333, 0
4913, 0.083333333333333, 1.4666666666667, 0
4914, 0.125, 1.4333333333333, 0
4915, 0.125, 1.4666666666667, 0
4916, 0.16666666666667, 1.4333333333333, 0
4917, 0.16666666666667, 1.4666666666667, 0
4918, 0.20833333333333, 1.4333333333333, 0
4919, 0.20833333333333, 1.4666666666667, 0
4920, 0.25, 1.4333333333333, 0
4921, 0.25, 1.4666666666667, 0
4922, 0.29166666666667, 1.4333333333333, 0
4923, 0.29166666666667, 1.4666666666667, 0
4924, 0.33333333333333, 1.4333333333333, 0
4925, 0.33333333333333, 1.4666666666667, 0
4926, 0.375, 1.4333333333333, 0
4927, 0.375, 1.4666666666667, 0
4928, 0.41666666666667, 1.4333333333333, 0
4929, 0.41666666666667, 1.4666666666667, 0
4930, 0.45833333333333, 1.4333333333333, 0
4931, 0.45833333333333, 1.4666666666667, 0
4932, 0.5, 1.4333333333333, 0
4933, 0.5, 1.4666666666667, 0
4934, 0.54166666666667, 1.4333333333333, 0
4935, 0.54166666666667, 1.4666666666667, 0
4936, 0.58333333333333, 1.4333333333333, 0
4937, 0.58333333333333, 1.4666666666667, 0
4938, 0.625, 1.4333333333333, 0
4939, 0.625, 1.4666666666667, 0
4940, 0.66666666666667, 1.4333333333333, 0
4941, 0.66666666666667, 1.4666666666667, 0
4942, 0.70833333333333, 1.4333333333333, 0
4943, 0.70833333333333, 1.4666666666667, 0
4944, 0.75, 1.4333333333333, 0
4945, 0.75, 1.4666666666667, 0
4946, 0.79166666666667, 1.4333333333333, 0
4947, 0.79166666666667, 1.4666666666667, 0
4948, 0.83333333333333, 1.4333333333333, 0
4949, 0.83333333333333, 1.4666666666667, 0
4950, 0.875, 1.4333333333333, 0
4951, 0.875, 1.4666666666667, 0
4952, 0.91666666666667, 1.4333333333333, 0
4953, 0.91666666666667, 1.4666666666667, 0
4954, 0.95833333333333, 1.4333333333333, 0
4955, 0.95833333333333, 1.4666666666667, 0
4956, 1, 1.4333333333333, 0.041666666666667
4957, 1, 1.4666666666667, 0.041666666666667
4958, 1, 1.4333333333333, 0.083333333333333
4959, 1, 1.4666666666667, 0.083333333333333
4960, 1, 1.4333333333333, 0.125
4961, 1, 1.4666666666667, 0.125
4962, 1, 1.4333333333333, 0.16666666666667
4963, 1, 1.4666666666667, 0.16666666666667
4964, 1, 1.4333333333333, 0.20833333333333
4965, 1, 1.4666666666667, 0.20833333333333
4966, 1, 1.4333333333333, 0.25
4967, 1, 1.4666666666667, 0.25
4968, 1, 1.4333333333333, 0.29166666666667
4969, 1, 1.4666666666667, 0.29166666666667
4970, 1, 1.4333333333333, 0.33333333333333
4971, 1, 1.4666666666667, 0.33333333333333
4972, 1, 1.4333333333333, 0.375
4973, 1, 1.4666666666667, 0.375
4974, 1, 1.4333333333333, 0.41666666666667
4975, 1, 1.4666666666667, 0.41666666666667
4976, 1, 1.4333333333333, 0.45833333333333
4977, 1, 1.4666666666667, 0.45833333333333
4978, 0.041666666666667, 1.4333333333333, 0.5
4979, 0.041666666666667, 1.4666666666667, 0.5
4980, 0.083333333333333, 1.4333333333333, 0.5
4981, 0.083333333333333, 1.4666666666667, 0.5
4982, 0.125, 1.4333333333333, 0.5
4983, 0.125, 1.4666666666667, 0.5
4984, 0.16666666666667, 1.4333333333333, 0.5
4985, 0.16666666666667, 1.4666666666667, 0.5
4986, 0.20833333333333, 1.4333333333333, 0.5
4987, 0.20833333333333, 1.4666666666667, 0.5
4988, 0.25, 1.4333333333333, 0.5
4989, 0.25, 1.4666666666667, 0.5
4990, 0.29166666666667, 1.4333333333333, 0.5
4991, 0.29166666666667, 1.4666666666667, 0.5
4992, 0.33333333333333, 1.4333333333333, 0.5
4993, 0.33333333333333, 1.4666666666667, 0.5
4994, 0.375, 1.4333333333333, 0.5
4995, 0.375, 1.4666666666667, 0.5
4996, 0.41666666666667, 1.4333333333333, 0.5
4997, 0.41666666666667, 1.4666666666667, 0.5
4998, 0.45833333333333, 1.4333333333333, 0.5
4999, 0.45833333333333, 1.4666666666667, 0.5
5000, 0.5, 1.4333333333333, 0.5
5001, 0.5, 1.4666666666667, 0.5
5002, 0.54166666666667, 1.4333333333333, 0.5
5003, 0.54166666666667, 1.4666666666667, 0.5
5004, 0.58333333333333, 1.4333333333333, 0.5
5005, 0.58333333333333, 1.4666666666667, 0.5
5006, 0.625, 1.4333333333333, 0.5
5007, 0.625, 1.4666666666667, 0.5
5008, 0.66666666666667, 1.4333333333333, 0.5
5009, 0.66666666666667, 1.4666666666667, 0.5
5010, 0.70833333333333, 1.4333333333333, 0.5
5011, 0.70833333333333, 1.4666666666667, 0.5
5012, 0.75, 1.4333333333333, 0.5
5013, 0.75, 1.4666666666667, 0.5
5014, 0.79166666666667, 1.4333333333333, 0.5
5015, 0.79166666666667, 1.4666666666667, 0.5
5016, 0.83333333333333, 1.4333333333333, 0.5
5017, 0.83333333333333, 1.4666666666667, 0.5
5018, 0.875, 1.4333333333333, 0.5
5019, 0.875, 1.4666666666667, 0.5
5020, 0.91666666666667, 1.4333333333333, 0.5
5021, 0.91666666666667, 1.4666666666667, 0.5
5022, 0.95833333333333, 1.4333333333333, 0.5
5023, 0.95833333333333, 1.4666666666667, 0.5
5024, 0, 1.4333333333333, 0.041666666666667
5025, 0, 1.4666666666667, 0.041666666666667
5026, 0, 1.4333333333333, 0.083333333333333
5027, 0, 1.4666666666667, 0.083333333333333
5028, 0, 1.4333333333333, 0.125
5029, 0, 1.4666666666667, 0.125
5030, 0, 1.4333333333333, 0.16666666666667
5031, 0, 1.4666666666667, 0.16666666666667
5032, 0, 1.4333333333333, 0.20833333333333
5033, 0, 1.4666666666667, 0.20833333333333
5034, 0, 1.4333333333333, 0.25
5035, 0, 1.4666666666667, 0.25
5036, 0, 1.4333333333333, 0.29166666666667
5037, 0, 1.4666666666667, 0.29166666666667
5038, 0, 1.4333333333333, 0.33333333333333
5039, 0, 1.4666666666667, 0.33333333333333
5040, 0, 1.4333333333333, 0.375
5041, 0, 1.4666666666667, 0.375
5042, 0, 1.4333333333333, 0.41666666666667
5043, 0, 1.4666666666667, 0.41666666666667
5044, 0, 1.4333333333333, 0.45833333333333
5045, 0, 1.4666666666667, 0.45833333333333
5046, 0.041666666666667, 1.5, 0.041666666666667
5047, 0.041666666666667, 1.5, 0.083333333333333
5048, 0.041666666666667, 1.5, 0.125
5049, 0.041666666666667, 1.5, 0.16666666666667
5050, 0.041666666666667, 1.5, 0.20833333333333
5051, 0.041666666666667, 1.5, 0.25
5052, 0.041666666666667, 1.5, 0.29166666666667
5053, 0.041666666666667, 1.5, 0.33333333333333
5054, 0.041666666666667, 1.5, 0.375
5055, 0.041666666666667, 1.5, 0.41666666666667
5056, 0.041666666666667, 1.5, 0.45833333333333
5057, 0.083333333333333, 1.5, 0.041666666666667
5058, 0.083333333333333, 1.5, 0.083333333333333
5059, 0.083333333333333, 1.5, 0.125
5060, 0.083333333333333, 1.5, 0.16666666666667
5061, 0.083333333333333, 1.5, 0.20833333333333
5062, 0.083333333333333, 1.5, 0.25
5063, 0.083333333333333, 1.5, 0.29166666666667
5064, 0.083333333333333, 1.5, 0.33333333333333
5065, 0.083333333333333, 1.5, 0.375
5066, 0.083333333333333, 1.5, 0.41666666666667
5067, 0.083333333333333, 1.5, 0.45833333333333
5068, 0.125, 1.5, 0.041666666666667
5069, 0.125, 1.5, 0.083333333333333
5070, 0.125, 1.5, 0.125
5071, 0.125, 1.5, 0.16666666666667
5072, 0.125, 1.5, 0.20833333333333
5073, 0.125, 1.5, 0.25
5074, 0.125, 1.5, 0.29166666666667
5075, 0.125, 1.5, 0.33333333333333
5076, 0.125, 1.5, 0.375
5077, 0.125, 1.5, 0.41666666666667
5078, 0.125, 1.5, 0.45833333333333
5079, 0.16666666666667, 1.5, 0.041666666666667
5080, 0.16666666666667, 1.5, 0.083333333333333
5081, 0.16666666666667, 1.5, 0.125
5082, 0.16666666666667, 1.5, 0.16666666666667
5083, 0.16666666666667, 1.5, 0.20833333333333
5084, 0.16666666666667, 1.5, 0.25
5085, 0.16666666666667, 1.5, 0.29166666666667
5086, 0.16666666666667, 1.5, 0.33333333333333
5087, 0.16666666666667, 1.5, 0.375
5088, 0.16666666666667, 1.5, 0.41666666666667
5089, 0.16666666666667, 1.5, 0.45833333333333
5090, 0.20833333333333, 1.5, 0.041666666666667
5091, 0.20833333333333, 1.5, 0.083333333333333
5092, 0.20833333333333, 1.5, 0.125
5093, 0.20833333333333, 1.5, 0.16666666666667
5094, 0.20833333333333, 1.5, 0.20833333333333
5095, 0.20833333333333, 1.5, 0.25
5096, 0.20833333333333, 1.5, 0.29166666666667
5097, 0.20833333333333, 1.5, 0.33333333333333
5098, 0.20833333333333, 1.5, 0.375
5099, 0.20833333333333, 1.5, 0.41666666666667
5100, 0.20833333333333, 1.5, 0.45833333333333
5101, 0.25, 1.5, 0.041666666666667
5102, 0.25, 1.5, 0.083333333333333
5103, 0.25, 1.5, 0.125
5104, 0.25, 1.5, 0.16666666666667
5105, 0.25, 1.5, 0.20833333333333
5106, 0.25, 1.5, 0.25
5107, 0.25, 1.5, 0.29166666666667
5108, 0.25, 1.5, 0.33333333333333
5109, 0.25, 1.5, 0.375
5110, 0.25, 1.5, 0.41666666666667
5111, 0.25, 1.5, 0.45833333333333
5112, 0.29166666666667, 1.5, 0.041666666666667
5113, 0.29166666666667, 1.5, 0.083333333333333
5114, 0.29166666666667, 1.5, 0.125
5115, 0.29166666666667, 1.5, 0.16666666666667
5116, 0.29166666666667, 1.5, 0.20833333333333
5117, 0.29166666666667, 1.5, 0.25
5118, 0.29166666666667, 1.5, 0.29166666666667
5119, 0.29166666666667, 1.5, 0.33333333333333
5120, 0.29166666666667, 1.5, 0.375
5121, 0.29166666666667, 1.5, 0.41666666666667
5122, 0.29166666666667, 1.5, 0.45833333333333
5123, 0.33333333333333, 1.5, 0.041666666666667
5124, 0.33333333333333, 1.5, 0.083333333333333
5125, 0.33333333333333, 1.5, 0.125
5126, 0.33333333333333, 1.5, 0.16666666666667
5127, 0.33333333333333, 1.5, 0.20833333333333
5128, 0.33333333333333, 1.5, 0.25
5129, 0.33333333333333, 1.5, 0.29166666666667
5130, 0.33333333333333, 1.5, 0.33333333333333
5131, 0.33333333333333, 1.5, 0.375
5132, 0.33333333333333, 1.5, 0.41666666666667
5133, 0.33333333333333, 1.5, 0.45833333333333
5134, 0.375, 1.5, 0.041666666666667
5135, 0.375, 1.5, 0.083333333333333
5136, 0.375, 1.5, 0.125
5137, 0.375, 1.5, 0.16666666666667
5138, 0.375, 1.5, 0.20833333333333
5139, 0.375, 1.5, 0.25
5140, 0.375, 1.5, 0.29166666666667
5141, 0.375, 1.5, 0.33333333333333
5142, 0.375, 1.5, 0.375
5143, 0.375, 1.5, 0.41666666666667
5144, 0.375, 1.5, 0.45833333333333
5145, 0.41666666666667, 1.5, 0.041666666666667
5146, 0.41666666666667, 1.5, 0.083333333333333
5147, 0.41666666666667, 1.5, 0.125
5148, 0.41666666666667, 1.5, 0.16666666666667
5149, 0.41666666666667, 1.5, 0.20833333333333
5150, 0.41666666666667, 1.5, 0.25
5151, 0.41666666666667, 1.5, 0.29166666666667
5152, 0.41666666666667, 1.5, 0.33333333333333
5153, 0.41666666666667, 1.5, 0.375
5154, 0.41666666666667, 1.5, 0.41666666666667
5155, 0.41666666666667, 1.5, 0.45833333333333
5156, 0.45833333333333, 1.5, 0.041666666666667
5157, 0.45833333333333, 1.5, 0.083333333333333
5158, 0.45833333333333, 1.5, 0.125
5159, 0.45833333333333, 1.5, 0.16666666666667
5160, 0.45833333333333, 1.5, 0.20833333333333
5161, 0.45833333333333, 1.5, 0.25
5162, 0.45833333333333, 1.5, 0.29166666666667
5163, 0.45833333333333, 1.5, 0.33333333333333
5164, 0.45833333333333, 1.5, 0.375
5165, 0.45833333333333, 1.5, 0.41666666666667
5166, 0.45833333333333, 1.5, 0.45833333333333
5167, 0.5, 1.5, 0.041666666666667
5168, 0.5, 1.5, 0.083333333333333
5169, 0.5, 1.5, 0.125
5170, 0.5, 1.5, 0.16666666666667
5171, 0.5, 1.5, 0.20833333333333
5172, 0.5, 1.5, 0.25
5173, 0.5, 1.5, 0.29166666666667
5174, 0.5, 1.5, 0.33333333333333
5175, 0.5, 1.5, 0.375
5176, 0.5, 1.5, 0.41666666666667
5177, 0.5, 1.5, 0.45833333333333
5178, 0.54166666666667, 1.5, 0.041666666666667
5179, 0.54166666666667, 1.5, 0.083333333333333
5180, 0.54166666666667, 1.5, 0.125
5181, 0.54166666666667, 1.5, 0.16666666666667
5182, 0.54166666666667, 1.5, 0.20833333333333
5183, 0.54166666666667, 1.5, 0.25
5184, 0.54166666666667, 1.5, 0.29166666666667
5185, 0.54166666666667, 1.5, 0.33333333333333
5186, 0.54166666666667, 1.5, 0.375
5187, 0.54166666666667, 1.5, 0.41666666666667
5188, 0.54166666666667, 1.5, 0.45833333333333
5189, 0.58333333333333, 1.5, 0.041666666666667
5190, 0.58333333333333, 1.5, 0.083333333333333
5191, 0.58333333333333, 1.5, 0.125
5192, 0.58333333333333, 1.5, 0.16666666666667
5193, 0.58333333333333, 1.5, 0.20833333333333
5194, 0.58333333333333, 1.5, 0.25
5195, 0.58333333333333, 1.5, 0.29166666666667
5196, 0.58333333333333, 1.5, 0.33333333333333
5197, 0.58333333333333, 1.5, 0.375
5198, 0.58333333333333, 1.5, 0.41666666666667
5199, 0.58333333333333, 1.5, 0.45833333333333
5200, 0.625, 1.5, 0.041666666666667
5201, 0.625, 1.5, 0.083333333333333
5202, 0.625, 1.5, 0.125
5203, 0.625, 1.5, 0.16666666666667
5204, 0.625, 1.5, 0.20833333333333
5205, 0.625, 1.5, 0.25
5206, 0.625, 1.5, 0.29166666666667
5207, 0.625, 1.5, 0.33333333333333
5208, 0.625, 1.5, 0.375
5209, 0.625, 1.5, 0.41666666666667
5210, 0.625, 1.5, 0.45833333333333
5211, 0.66666666666667, 1.5, 0.041666666666667
5212, 0.66666666666667, 1.5, 0.083333333333333
5213, 0.66666666666667, 1.5, 0.125
5214, 0.66666666666667, 1.5, 0.16666666666667
5215, 0.66666666666667, 1.5, 0.20833333333333
5216, 0.66666666666667, 1.5, 0.25
5217, 0.66666666666667, 1.5, 0.29166666666667
5218, 0.66666666666667, 1.5, 0.33333333333333
5219, 0.66666666666667, 1.5, 0.375
5220, 0.66666666666667, 1.5, 0.41666666666667
5221, 0.66666666666667, 1.5, 0.45833333333333
5222, 0.70833333333333, 1.5, 0.041666666666667
5223, 0.70833333333333, 1.5, 0.083333333333333
5224, 0.70833333333333, 1.5, 0.125
5225, 0.70833333333333, 1.5, 0.16666666666667
5226, 0.70833333333333, 1.5, 0.20833333333333
5227, 0.70833333333333, 1.5, 0.25
5228, 0.70833333333333, 1.5, 0.29166666666667
5229, 0.70833333333333, 1.5, 0.33333333333333
5230, 0.70833333333333, 1.5, 0.375
5231, 0.70833333333333, 1.5, 0.41666666666667
5232, 0.70833333333333, 1.5, 0.45833333333333
5233, 0.75, 1.5, 0.041666666666667
5234, 0.75, 1.5, 0.083333333333333
5235, 0.75, 1.5, 0.125
5236, 0.75, 1.5, 0.16666666666667
5237, 0.75, 1.5, 0.20833333333333
5238, 0.75, 1.5, 0.25
5239, 0.75, 1.5, 0.29166666666667
5240, 0.75, 1.5, 0.33333333333333
5241, 0.75, 1.5, 0.375
5242, 0.75, 1.5, 0.41666666666667
5243, 0.75, 1.5, 0.45833333333333
5244, 0.79166666666667, 1.5, 0.041666666666667
5245, 0.79166666666667, 1.5, 0.083333333333333
5246, 0.79166666666667, 1.5, 0.125
5247, 0.79166666666667, 1.5, 0.16666666666667
5248, 0.79166666666667, 1.5, 0.20833333333333
5249, 0.79166666666667, 1.5, 0.25
5250, 0.79166666666667, 1.5, 0.29166666666667
5251, 0.79166666666667, 1.5, 0.33333333333333
5252, 0.79166666666667, 1.5, 0.375
5253, 0.79166666666667, 1.5, 0.41666666666667
5254, 0.79166666666667, 1.5, 0.45833333333333
5255, 0.83333333333333, 1.5, 0.041666666666667
5256, 0.83333333333333, 1.5, 0.083333333333333
5257, 0.83333333333333, 1.5, 0.125
5258, 0.83333333333333, 1.5, 0.16666666666667
5259, 0.83333333333333, 1.5, 0.20833333333333
5260, 0.83333333333333, 1.5, 0.25
5261, 0.83333333333333, 1.5, 0.29166666666667
5262, 0.83333333333333, 1.5, 0.33333333333333
5263, 0.83333333333333, 1.5, 0.375
5264, 0.83333333333333, 1.5, 0.41666666666667
5265, 0.83333333333333, 1.5, 0.45833333333333
5266, 0.875, 1.5, 0.041666666666667
5267, 0.875, 1.5, 0.083333333333333
5268, 0.875, 1.5, 0.125
5269, 0.875, 1.5, 0.16666666666667
5270, 0.875, 1.5, 0.20833333333333
5271, 0.875, 1.5, 0.25
5272, 0.875, 1.5, 0.29166666666667
5273, 0.875, 1.5, 0.33333333333333
5274, 0.875, 1.5, 0.375
5275, 0.875, 1.5, 0.41666666666667
5276, 0.875, 1.5, 0.45833333333333
5277, 0.91666666666667, 1.5, 0.041666666666667
5278, 0.91666666666667, 1.5, 0.083333333333333
5279, 0.91666666666667, 1.5, 0.125
5280, 0.91666666666667, 1.5, 0.16666666666667
5281, 0.91666666666667, 1.5, 0.20833333333333
5282, 0.91666666666667, 1.5, 0.25
5283, 0.91666666666667, 1.5, 0.29166666666667
5284, 0.91666666666667, 1.5, 0.33333333333333
5285, 0.91666666666667, 1.5, 0.375
5286, 0.91666666666667, 1.5, 0.41666666666667
5287, 0.91666666666667, 1.5, 0.45833333333333
5288, 0.95833333333333, 1.5, 0.041666666666667
5289, 0.95833333333333, 1.5, 0.083333333333333
5290, 0.95833333333333, 1.5, 0.125
5291, 0.95833333333333, 1.5, 0.16666666666667
5292, 0.95833333333333, 1.5, 0.20833333333333
5293, 0.95833333333333, 1.5, 0.25
5294, 0.95833333333333, 1.5, 0.29166666666667
5295, 0.95833333333333, 1.5, 0.33333333333333
5296, 0.95833333333333, 1.5, 0.375
5297, 0.95833333333333, 1.5, 0.41666666666667
5298, 0.95833333333333, 1.5, 0.45833333333333
5299, 1.04, 1.4333333333333, 0.5
5300, 1.08, 1.4333333333333, 0.5
5301, 1.12, 1.4333333333333, 0.5
5302, 1.16, 1.4333333333333, 0.5
5303, 1.04, 1.4666666666667, 0.5
5304, 1.08, 1.4666666666667, 0.5
5305, 1.12, 1.4666666666667, 0.5
5306, 1.16, 1.4666666666667, 0.5
5307, 1.04, 1.4333333333333, 0
5308, 1.08, 1.4333333333333, 0
5309, 1.12, 1.4333333333333, 0
5310, 1.16, 1.4333333333333, 0
5311, 1.04, 1.4666666666667, 0
5312, 1.08, 1.4666666666667, 0
5313, 1.12, 1.4666666666667, 0
5314, 1.16, 1.4666666666667, 0
5315, 1.04, 1.4, 0.041666666666667
5316, 1.08, 1.4, 0.041666666666667
5317, 1.12, 1.4, 0.041666666666667
5318, 1.16, 1.4, 0.041666666666667
5319, 1.04, 1.4, 0.083333333333333
5320, 1.08, 1.4, 0.083333333333333
5321, 1.12, 1.4, 0.083333333333333
5322, 1.16, 1.4, 0.083333333333333
5323, 1.04, 1.4, 0.125
5324, 1.08, 1.4, 0.125
5325, 1.12, 1.4, 0.125
5326, 1.16, 1.4, 0.125
5327, 1.04, 1.4, 0.16666666666667
5328, 1.08, 1.4, 0.16666666666667
5329, 1.12, 1.4, 0.16666666666667
5330, 1.16, 1.4, 0.16666666666667
5331, 1.04, 1.4, 0.20833333333333
5332, 1.08, 1.4, 0.20833333333333
5333, 1.12, 1.4, 0.20833333333333
5334, 1.16, 1.4, 0.20833333333333
5335, 1.04, 1.4, 0.25
5336, 1.08, 1.4, 0.25
5337, 1.12, 1.4, 0.25
5338, 1.16, 1.4, 0.25
5339, 1.04, 1.4, 0.29166666666667
5340, 1.08, 1.4, 0.29166666666667
5341, 1.12, 1.4, 0.29166666666667
5342, 1.16, 1.4, 0.29166666666667
5343, 1.04, 1.4, 0.33333333333333
5344, 1.08, 1.4, 0.33333333333333
5345, 1.12, 1.4, 0.33333333333333
5346, 1.16, 1.4, 0.33333333333333
5347, 1.04, 1.4, 0.375
5348, 1.08, 1.4, 0.375
5349, 1.12, 1.4, 0.375
5350, 1.16, 1.4, 0.375
5351, 1.04, 1.4, 0.41666666666667
5352, 1.08, 1.4, 0.41666666666667
5353, 1.12, 1.4, 0.41666666666667
5354, 1.16, 1.4, 0.41666666666667
5355, 1.04, 1.4, 0.45833333333333
5356, 1.08, 1.4, 0.45833333333333
5357, 1.12, 1.4, 0.45833333333333
5358, 1.16, 1.4, 0.45833333333333
5359, 1.04, 1.5, 0.041666666666667
5360, 1.08, 1.5, 0.041666666666667
5361, 1.12, 1.5, 0.041666666666667
5362, 1.16, 1.5, 0.041666666666667
5363, 1.04, 1.5, 0.083333333333333
5364, 1.08, 1.5, 0.083333333333333
5365, 1.12, 1.5, 0.083333333333333
5366, 1.16, 1.5, 0.083333333333333
5367, 1.04, 1.5, 0.125
5368, 1.08, 1.5, 0.125
5369, 1.12, 1.5, 0.125
5370, 1.16, 1.5, 0.125
5371, 1.04, 1.5, 0.16666666666667
5372, 1.08, 1.5, 0.16666666666667
5373, 1.12, 1.5, 0.16666666666667
5374, 1.16, 1.5, 0.16666666666667
5375, 1.04, 1.5, 0.20833333333333
5376, 1.08, 1.5, 0.20833333333333
5377, 1.12, 1.5, 0.20833333333333
5378, 1.16, 1.5, 0.20833333333333
5379, 1.04, 1.5, 0.25
5380, 1.08, 1.5, 0.25
5381, 1.12, 1.5, 0.25
5382, 1.16, 1.5, 0.25
5383, 1.04, 1.5, 0.29166666666667
5384, 1.08, 1.5, 0.29166666666667
5385, 1.12, 1.5, 0.29166666666667
5386, 1.16, 1.5, 0.29166666666667
5387, 1.04, 1.5, 0.33333333333333
5388, 1.08, 1.5, 0.33333333333333
5389, 1.12, 1.5, 0.33333333333333
5390, 1.16, 1.5, 0.33333333333333
5391, 1.04, 1.5, 0.375
5392, 1.08, 1.5, 0.375
5393, 1.12, 1.5, 0.375
5394, 1.16, 1.5, 0.375
5395, 1.04, 1.5, 0.41666666666667
5396, 1.08, 1.5, 0.41666666666667
5397, 1.12, 1.5, 0.41666666666667
5398, 1.16, 1.5, 0.41666666666667
5399, 1.04, 1.5, 0.45833333333333
5400, 1.08, 1.5, 0.45833333333333
5401, 1.12, 1.5, 0.45833333333333
5402, 1.16, 1.5, 0.45833333333333
5403, 1.2, 1.4333333333333, 0.041666666666667
5404, 1.2, 1.4666666666667, 0.041666666666667
5405, 1.2, 1.4333333333333, 0.083333333333333
5406, 1.2, 1.4666666666667, 0.083333333333333
5407, 1.2, 1.4333333333333, 0.125
5408, 1.2, 1.4666666666667, 0.125
5409, 1.2, 1.4333333333333, 0.16666666666667
5410, 1.2, 1.4666666666667, 0.16666666666667
5411, 1.2, 1.4333333333333, 0.20833333333333
5412, 1.2, 1.4666666666667, 0.20833333333333
5413, 1.2, 1.4333333333333, 0.25
5414, 1.2, 1.4666666666667, 0.25
5415, 1.2, 1.4333333333333, 0.29166666666667
5416, 1.2, 1.4666666666667, 0.29166666666667
5417, 1.2, 1.4333333333333, 0.33333333333333
5418, 1.2, 1.4666666666667, 0.33333333333333
5419, 1.2, 1.4333333333333, 0.375
5420, 1.2, 1.4666666666667, 0.375
5421, 1.2, 1.4333333333333, 0.41666666666667
5422, 1.2, 1.4666666666667, 0.41666666666667
5423, 1.2, 1.4333333333333, 0.45833333333333
5424, 1.2, 1.4666666666667, 0.45833333333333
5425, 1.2416666666667, 1.4333333333333, 0.5
5426, 1.2833333333333, 1.4333333333333, 0.5
5427, 1.325, 1.4333333333333, 0.5
5428, 1.3666666666667, 1.4333333333333, 0.5
5429, 1.4083333333333, 1.4333333333333, 0.5
5430, 1.45, 1.4333333333333, 0.5
5431, 1.4916666666667, 1.4333333333333, 0.5
5432, 1.5333333333333, 1.4333333333333, 0.5
5433, 1.575, 1.4333333333333, 0.5
5434, 1.6166666666667, 1.4333333333333, 0.5
5435, 1.6583333333333, 1.4333333333333, 0.5
5436, 1.7, 1.4333333333333, 0.5
5437, 1.7416666666667, 1.4333333333333, 0.5
5438, 1.7833333333333, 1.4333333333333, 0.5
5439, 1.825, 1.4333333333333, 0.5
5440, 1.8666666666667, 1.4333333333333, 0.5
5441, 1.9083333333333, 1.4333333333333, 0.5
5442, 1.95, 1.4333333333333, 0.5
5443, 1.9916666666667, 1.4333333333333, 0.5
5444, 2.0333333333333, 1.4333333333333, 0.5
5445, 2.075, 1.4333333333333, 0.5
5446, 2.1166666666667, 1.4333333333333, 0.5
5447, 2.1583333333333, 1.4333333333333, 0.5
5448, 1.2416666666667, 1.4666666666667, 0.5
5449, 1.2833333333333, 1.4666666666667, 0.5
5450, 1.325, 1.4666666666667, 0.5
5451, 1.3666666666667, 1.4666666666667, 0.5
5452, 1.4083333333333, 1.4666666666667, 0.5
5453, 1.45, 1.4666666666667, 0.5
5454, 1.4916666666667, 1.4666666666667, 0.5
5455, 1.5333333333333, 1.4666666666667, 0.5
5456, 1.575, 1.4666666666667, 0.5
5457, 1.6166666666667, 1.4666666666667, 0.5
5458, 1.6583333333333, 1.4666666666667, 0.5
5459, 1.7, 1.4666666666667, 0.5
5460, 1.7416666666667, 1.4666666666667, 0.5
5461, 1.7833333333333, 1.4666666666667, 0.5
5462, 1.825, 1.4666666666667, 0.5
5463, 1.8666666666667, 1.4666666666667, 0.5
5464, 1.9083333333333, 1.4666666666667, 0.5
5465, 1.95, 1.4666666666667, 0.5
5466, 1.9916666666667, 1.4666666666667, 0.5
5467, 2.0333333333333, 1.4666666666667, 0.5
5468, 2.075, 1.4666666666667, 0.5
5469, 2.1166666666667, 1.4666666666667, 0.5
5470, 2.1583333333333, 1.4666666666667, 0.5
5471, 1.2416666666667, 1.4333333333333, 0
5472, 1.2833333333333, 1.4333333333333, 0
5473, 1.325, 1.4333333333333, 0
5474, 1.3666666666667, 1.4333333333333, 0
5475, 1.4083333333333, 1.4333333333333, 0
5476, 1.45, 1.4333333333333, 0
5477, 1.4916666666667, 1.4333333333333, 0
5478, 1.5333333333333, 1.4333333333333, 0
5479, 1.575, 1.4333333333333, 0
5480, 1.6166666666667, 1.4333333333333, 0
5481, 1.6583333333333, 1.4333333333333, 0
5482, 1.7, 1.4333333333333, 0
5483, 1.7416666666667, 1.4333333333333, 0
5484, 1.7833333333333, 1.4333333333333, 0
5485, 1.825, 1.4333333333333, 0
5486, 1.8666666666667, 1.4333333333333, 0
5487, 1.9083333333333, 1.4333333333333, 0
5488, 1.95, 1.4333333333333, 0
5489, 1.9916666666667, 1.4333333333333, 0
5490, 2.0333333333333, 1.4333333333333, 0
5491, 2.075, 1.4333333333333, 0
5492, 2.1166666666667, 1.4333333333333, 0
5493, 2.1583333333333, 1.4333333333333, 0
5494, 1.2416666666667, 1.4666666666667, 0
5495, 1.2833333333333, 1.4666666666667, 0
5496, 1.325, 1.4666666666667, 0
5497, 1.3666666666667, 1.4666666666667, 0
5498, 1.4083333333333, 1.4666666666667, 0
5499, 1.45, 1.4666666666667, 0
5500, 1.4916666666667, 1.4666666666667, 0
5501, 1.5333333333333, 1.4666666666667, 0
5502, 1.575, 1.4666666666667, 0
5503, 1.6166666666667, 1.4666666666667, 0
5504, 1.6583333333333, 1.4666666666667, 0
5505, 1.7, 1.4666666666667, 0
5506, 1.7416666666667, 1.4666666666667, 0
5507, 1.7833333333333, 1.4666666666667, 0
5508, 1.825, 1.4666666666667, 0
5509, 1.8666666666667, 1.4666666666667, 0
5510, 1.9083333333333, 1.4666666666667, 0
5511, 1.95, 1.4666666666667, 0
5512, 1.9916666666667, 1.4666666666667, 0
5513, 2.0333333333333, 1.4666666666667, 0
5514, 2.075, 1.4666666666667, 0
5515, 2.1166666666667, 1.4666666666667, 0
5516, 2.1583333333333, 1.4666666666667, 0
5517, 1.2416666666667, 1.4, 0.041666666666667
5518, 1.2833333333333, 1.4, 0.041666666666667
5519, 1.325, 1.4, 0.041666666666667
5520, 1.3666666666667, 1.4, 0.041666666666667
5521, 1.4083333333333, 1.4, 0.041666666666667
5522, 1.45, 1.4, 0.041666666666667
5523, 1.4916666666667, 1.4, 0.041666666666667
5524, 1.5333333333333, 1.4, 0.041666666666667
5525, 1.575, 1.4, 0.041666666666667
5526, 1.6166666666667, 1.4, 0.041666666666667
5527, 1.6583333333333, 1.4, 0.041666666666667
5528, 1.7, 1.4, 0.041666666666667
5529, 1.7416666666667, 1.4, 0.041666666666667
5530, 1.7833333333333, 1.4, 0.041666666666667
5531, 1.825, 1.4, 0.041666666666667
5532, 1.8666666666667, 1.4, 0.041666666666667
5533, 1.9083333333333, 1.4, 0.041666666666667
5534, 1.95, 1.4, 0.041666666666667
5535, 1.9916666666667, 1.4, 0.041666666666667
5536, 2.0333333333333, 1.4, 0.041666666666667
5537, 2.075, 1.4, 0.041666666666667
5538, 2.1166666666667, 1.4, 0.041666666666667
5539, 2.1583333333333, 1.4, 0.041666666666667
5540, 1.2416666666667, 1.4, 0.083333333333333
5541, 1.2833333333333, 1.4, 0.083333333333333
5542, 1.325, 1.4, 0.083333333333333
5543, 1.3666666666667, 1.4, 0.083333333333333
5544, 1.4083333333333, 1.4, 0.083333333333333
5545, 1.45, 1.4, 0.083333333333333
5546, 1.4916666666667, 1.4, 0.083333333333333
5547, 1.5333333333333, 1.4, 0.083333333333333
5548, 1.575, 1.4, 0.083333333333333
5549, 1.6166666666667, 1.4, 0.083333333333333
5550, 1.6583333333333, 1.4, 0.083333333333333
5551, 1.7, 1.4, 0.083333333333333
5552, 1.7416666666667, 1.4, 0.083333333333333
5553, 1.7833333333333, 1.4, 0.083333333333333
5554, 1.825, 1.4, 0.083333333333333
5555, 1.8666666666667, 1.4, 0.083333333333333
5556, 1.9083333333333, 1.4, 0.083333333333333
5557, 1.95, 1.4, 0.083333333333333
5558, 1.9916666666667, 1.4, 0.083333333333333
5559, 2.0333333333333, 1.4, 0.083333333333333
5560, 2.075, 1.4, 0.083333333333333
5561, 2.1166666666667, 1.4, 0.083333333333333
5562, 2.1583333333333, 1.4, 0.083333333333333
5563, 1.2416666666667, 1.4, 0.125
5564, 1.2833333333333, 1.4, 0.125
5565, 1.325, 1.4, 0.125
5566, 1.3666666666667, 1.4, 0.125
5567, 1.4083333333333, 1.4, 0.125
5568, 1.45, 1.4, 0.125
5569, 1.4916666666667, 1.4, 0.125
5570, 1.5333333333333, 1.4, 0.125
5571, 1.575, 1.4, 0.125
5572, 1.6166666666667, 1.4, 0.125
5573, 1.6583333333333, 1.4, 0.125
5574, 1.7, 1.4, 0.125
5575, 1.7416666666667, 1.4, 0.125
5576, 1.7833333333333, 1.4, 0.125
5577, 1.825, 1.4, 0.125
5578, 1.8666666666667, 1.4, 0.125
5579, 1.9083333333333, 1.4, 0.125
5580, 1.95, 1.4, 0.125
5581, 1.9916666666667, 1.4, 0.125
5582, 2.0333333333333, 1.4, 0.125
5583, 2.075, 1.4, 0.125
5584, 2.1166666666667, 1.4, 0.125
5585, 2.1583333333333, 1.4, 0.125
5586, 1.2416666666667, 1.4, 0.16666666666667
5587, 1.2833333333333, 1.4, 0.16666666666667
5588, 1.325, 1.4, 0.16666666666667
5589, 1.3666666666667, 1.4, 0.16666666666667
5590, 1.4083333333333, 1.4, 0.16666666666667
5591, 1.45, 1.4, 0.16666666666667
5592, 1.4916666666667, 1.4, 0.16666666666667
5593, 1.5333333333333, 1.4, 0.16666666666667
5594, 1.575, 1.4, 0.16666666666667
5595, 1.6166666666667, 1.4, 0.16666666666667
5596, 1.6583333333333, 1.4, 0.16666666666667
5597, 1.7, 1.4, 0.16666666666667
5598, 1.7416666666667, 1.4, 0.16666666666667
5599, 1.7833333333333, 1.4, 0.16666666666667
5600, 1.825, 1.4, 0.16666666666667
5601, 1.8666666666667, 1.4, 0.16666666666667
5602, 1.9083333333333, 1.4, 0.16666666666667
5603, 1.95, 1.4, 0.16666666666667
5604, 1.9916666666667, 1.4, 0.16666666666667
5605, 2.0333333333333, 1.4, 0.16666666666667
5606, 2.075, 1.4, 0.16666666666667
5607, 2.1166666666667, 1.4, 0.16666666666667
5608, 2.1583333333333, 1.4, 0.16666666666667
5609, 1.2416666666667, 1.4, 0.20833333333333
5610, 1.2833333333333, 1.4, 0.20833333333333
5611, 1.325, 1.4, 0.20833333333333
5612, 1.3666666666667, 1.4, 0.20833333333333
5613, 1.4083333333333, 1.4, 0.20833333333333
5614, 1.45, 1.4, 0.20833333333333
5615, 1.4916666666667, 1.4, 0.20833333333333
5616, 1.5333333333333, 1.4, 0.20833333333333
5617, 1.575, 1.4, 0.20833333333333
5618, 1.6166666666667, 1.4, 0.20833333333333
5619, 1.6583333333333, 1.4, 0.20833333333333
5620, 1.7, 1.4, 0.20833333333333
5621, 1.7416666666667, 1.4, 0.20833333333333
5622, 1.7833333333333, 1.4, 0.20833333333333
5623, 1.825, 1.4, 0.20833333333333
5624, 1.8666666666667, 1.4, 0.20833333333333
5625, 1.9083333333333, 1.4, 0.20833333333333
5626, 1.95, 1.4, 0.20833333333333
5627, 1.9916666666667, 1.4, 0.20833333333333
5628, 2.0333333333333, 1.4, 0.20833333333333
5629, 2.075, 1.4, 0.20833333333333
5630, 2.1166666666667, 1.4, 0.20833333333333
5631, 2.1583333333333, 1.4, 0.20833333333333
5632, 1.2416666666667, 1.4, 0.25
5633, 1.2833333333333, 1.4, 0.25
5634, 1.325, 1.4, 0.25
5635, 1.3666666666667, 1.4, 0.25
5636, 1.4083333333333, 1.4, 0.25
5637, 1.45, 1.4, 0.25
5638, 1.4916666666667, 1.4, 0.25
5639, 1.5333333333333, 1.4, 0.25
5640, 1.575, 1.4, 0.25
5641, 1.6166666666667, 1.4, 0.25
5642, 1.6583333333333, 1.4, 0.25
5643, 1.7, 1.4, 0.25
5644, 1.7416666666667, 1.4, 0.25
5645, 1.7833333333333, 1.4, 0.25
5646, 1.825, 1.4, 0.25
5647, 1.8666666666667, 1.4, 0.25
5648, 1.9083333333333, 1.4, 0.25
5649, 1.95, 1.4, 0.25
5650, 1.9916666666667, 1.4, 0.25
5651, 2.0333333333333, 1.4, 0.25
5652, 2.075, 1.4, 0.25
5653, 2.1166666666667, 1.4, 0.25
5654, 2.1583333333333, 1.4, 0.25
5655, 1.2416666666667, 1.4, 0.29166666666667
5656, 1.2833333333333, 1.4, 0.29166666666667
5657, 1.325, 1.4, 0.29166666666667
5658, 1.3666666666667, 1.4, 0.29166666666667
5659, 1.4083333333333, 1.4, 0.29166666666667
5660, 1.45, 1.4, 0.29166666666667
5661, 1.4916666666667, 1.4, 0.29166666666667
5662, 1.5333333333333, 1.4, 0.29166666666667
5663, 1.575, 1.4, 0.29166666666667
5664, 1.6166666666667, 1.4, 0.29166666666667
5665, 1.6583333333333, 1.4, 0.29166666666667
5666, 1.7, 1.4, 0.29166666666667
5667, 1.7416666666667, 1.4, 0.29166666666667
5668, 1.7833333333333, 1.4, 0.29166666666667
5669, 1.825, 1.4, 0.29166666666667
5670, 1.8666666666667, 1.4, 0.29166666666667
5671, 1.9083333333333, 1.4, 0.29166666666667
5672, 1.95, 1.4, 0.29166666666667
5673, 1.9916666666667, 1.4, 0.29166666666667
5674, 2.0333333333333, 1.4, 0.29166666666667
5675, 2.075, 1.4, 0.29166666666667
5676, 2.1166666666667, 1.4, 0.29166666666667
5677, 2.1583333333333, 1.4, 0.29166666666667
5678, 1.2416666666667, 1.4, 0.33333333333333
5679, 1.2833333333333, 1.4, 0.33333333333333
5680, 1.325, 1.4, 0.33333333333333
5681, 1.3666666666667, 1.4, 0.33333333333333
5682, 1.4083333333333, 1.4, 0.33333333333333
5683, 1.45, 1.4, 0.33333333333333
5684, 1.4916666666667, 1.4, 0.33333333333333
5685, 1.5333333333333, 1.4, 0.33333333333333
5686, 1.575, 1.4, 0.33333333333333
5687, 1.6166666666667, 1.4, 0.33333333333333
5688, 1.6583333333333, 1.4, 0.33333333333333
5689, 1.7, 1.4, 0.33333333333333
5690, 1.7416666666667, 1.4, 0.33333333333333
5691, 1.7833333333333, 1.4, 0.33333333333333
5692, 1.825, 1.4, 0.33333333333333
5693, 1.8666666666667, 1.4, 0.33333333333333
5694, 1.9083333333333, 1.4, 0.33333333333333
5695, 1.95, 1.4, 0.33333333333333
5696, 1.9916666666667, 1.4, 0.33333333333333
5697, 2.0333333333333, 1.4, 0.33333333333333
5698, 2.075, 1.4, 0.33333333333333
5699, 2.1166666666667, 1.4, 0.33333333333333
5700, 2.1583333333333, 1.4, 0.33333333333333
5701, 1.2416666666667, 1.4, 0.375
5702, 1.2833333333333, 1.4, 0.375
5703, 1.325, 1.4, 0.375
5704, 1.3666666666667, 1.4, 0.375
5705, 1.4083333333333, 1.4, 0.375
5706, 1.45, 1.4, 0.375
5707, 1.4916666666667, 1.4, 0.375
5708, 1.5333333333333, 1.4, 0.375
5709, 1.575, 1.4, 0.375
5710, 1.6166666666667, 1.4, 0.375
5711, 1.6583333333333, 1.4, 0.375
5712, 1.7, 1.4, 0.375
5713, 1.7416666666667, 1.4, 0.375
5714, 1.7833333333333, 1.4, 0.375
5715, 1.825, 1.4, 0.375
5716, 1.8666666666667, 1.4, 0.375
5717, 1.9083333333333, 1.4, 0.375
5718, 1.95, 1.4, 0.375
5719, 1.9916666666667, 1.4, 0.375
5720, 2.0333333333333, 1.4, 0.375
5721, 2.075, 1.4, 0.375
5722, 2.1166666666667, 1.4, 0.375
5723, 2.1583333333333, 1.4, 0.375
5724, 1.2416666666667, 1.4, 0.41666666666667
5725, 1.2833333333333, 1.4, 0.41666666666667
5726, 1.325, 1.4, 0.41666666666667
5727, 1.3666666666667, 1.4, 0.41666666666667
5728, 1.4083333333333, 1.4, 0.41666666666667
5729, 1.45, 1.4, 0.41666666666667
5730, 1.4916666666667, 1.4, 0.41666666666667
5731, 1.5333333333333, 1.4, 0.41666666666667
5732, 1.575, 1.4, 0.41666666666667
5733, 1.6166666666667, 1.4, 0.41666666666667
5734, 1.6583333333333, 1.4, 0.41666666666667
5735, 1.7, 1.4, 0.41666666666667
5736, 1.7416666666667, 1.4, 0.41666666666667
5737, 1.7833333333333, 1.4, 0.41666666666667
5738, 1.825, 1.4, 0.41666666666667
5739, 1.8666666666667, 1.4, 0.41666666666667
5740, 1.9083333333333, 1.4, 0.41666666666667
5741, 1.95, 1.4, 0.41666666666667
5742, 1.9916666666667, 1.4, 0.41666666666667
5743, 2.0333333333333, 1.4, 0.41666666666667
5744, 2.075, 1.4, 0.41666666666667
5745, 2.1166666666667, 1.4, 0.41666666666667
5746, 2.1583333333333, 1.4, 0.41666666666667
5747, 1.2416666666667, 1.4, 0.45833333333333
5748, 1.2833333333333, 1.4, 0.45833333333333
5749, 1.325, 1.4, 0.45833333333333
5750, 1.3666666666667, 1.4, 0.45833333333333
5751, 1.4083333333333, 1.4, 0.45833333333333
5752, 1.45, 1.4, 0.45833333333333
5753, 1.4916666666667, 1.4, 0.45833333333333
5754, 1.5333333333333, 1.4, 0.45833333333333
5755, 1.575, 1.4, 0.45833333333333
5756, 1.6166666666667, 1.4, 0.45833333333333
5757, 1.6583333333333, 1.4, 0.45833333333333
5758, 1.7, 1.4, 0.45833333333333
5759, 1.7416666666667, 1.4, 0.45833333333333
5760, 1.7833333333333, 1.4, 0.45833333333333
5761, 1.825, 1.4, 0.45833333333333
5762, 1.8666666666667, 1.4, 0.45833333333333
5763, 1.9083333333333, 1.4, 0.45833333333333
5764, 1.95, 1.4, 0.45833333333333
5765, 1.9916666666667, 1.4, 0.45833333333333
5766, 2.0333333333333, 1.4, 0.45833333333333
5767, 2.075, 1.4, 0.45833333333333
5768, 2.1166666666667, 1.4, 0.45833333333333
5769, 2.1583333333333, 1.4, 0.45833333333333
5770, 1.2416666666667, 1.5, 0.041666666666667
5771, 1.2833333333333, 1.5, 0.041666666666667
5772, 1.325, 1.5, 0.041666666666667
5773, 1.3666666666667, 1.5, 0.041666666666667
5774, 1.4083333333333, 1.5, 0.041666666666667
5775, 1.45, 1.5, 0.041666666666667
5776, 1.4916666666667, 1.5, 0.041666666666667
5777, 1.5333333333333, 1.5, 0.041666666666667
5778, 1.575, 1.5, 0.041666666666667
5779, 1.6166666666667, 1.5, 0.041666666666667
5780, 1.6583333333333, 1.5, 0.041666666666667
5781, 1.7, 1.5, 0.041666666666667
5782, 1.7416666666667, 1.5, 0.041666666666667
5783, 1.7833333333333, 1.5, 0.041666666666667
5784, 1.825, 1.5, 0.041666666666667
5785, 1.8666666666667, 1.5, 0.041666666666667
5786, 1.9083333333333, 1.5, 0.041666666666667
5787, 1.95, 1.5, 0.041666666666667
5788, 1.9916666666667, 1.5, 0.041666666666667
5789, 2.0333333333333, 1.5, 0.041666666666667
5790, 2.075, 1.5, 0.041666666666667
5791, 2.1166666666667, 1.5, 0.041666666666667
5792, 2.1583333333333, 1.5, 0.041666666666667
5793, 1.2416666666667, 1.5, 0.083333333333333
5794, 1.2833333333333, 1.5, 0.083333333333333
5795, 1.325, 1.5, 0.083333333333333
5796, 1.3666666666667, 1.5, 0.083333333333333
5797, 1.4083333333333, 1.5, 0.083333333333333
5798, 1.45, 1.5, 0.083333333333333
5799, 1.4916666666667, 1.5, 0.083333333333333
5800, 1.5333333333333, 1.5, 0.083333333333333
5801, 1.575, 1.5, 0.083333333333333
5802, 1.6166666666667, 1.5, 0.083333333333333
5803, 1.6583333333333, 1.5, 0.083333333333333
5804, 1.7, 1.5, 0.083333333333333
5805, 1.7416666666667, 1.5, 0.083333333333333
5806, 1.7833333333333, 1.5, 0.083333333333333
5807, 1.825, 1.5, 0.083333333333333
5808, 1.8666666666667, 1.5, 0.083333333333333
5809, 1.9083333333333, 1.5, 0.083333333333333
5810, 1.95, 1.5, 0.083333333333333
5811, 1.9916666666667, 1.5, 0.083333333333333
5812, 2.0333333333333, 1.5, 0.083333333333333
5813, 2.075, 1.5, 0.083333333333333
5814, 2.1166666666667, 1.5, 0.083333333333333
5815, 2.1583333333333, 1.5, 0.083333333333333
5816, 1.2416666666667, 1.5, 0.125
5817, 1.2833333333333, 1.5, 0.125
5818, 1.325, 1.5, 0.125
5819, 1.3666666666667, 1.5, 0.125
5820, 1.4083333333333, 1.5, 0.125
5821, 1.45, 1.5, 0.125
5822, 1.4916666666667, 1.5, 0.125
5823, 1.5333333333333, 1.5, 0.125
5824, 1.575, 1.5, 0.125
5825, 1.6166666666667, 1.5, 0.125
5826, 1.6583333333333, 1.5, 0.125
5827, 1.7, 1.5, 0.125
5828, 1.7416666666667, 1.5, 0.125
5829, 1.7833333333333, 1.5, 0.125
5830, 1.825, 1.5, 0.125
5831, 1.8666666666667, 1.5, 0.125
5832, 1.9083333333333, 1.5, 0.125
5833, 1.95, 1.5, 0.125
5834, 1.9916666666667, 1.5, 0.125
5835, 2.0333333333333, 1.5, 0.125
5836, 2.075, 1.5, 0.125
5837, 2.1166666666667, 1.5, 0.125
5838, 2.1583333333333, 1.5, 0.125
5839, 1.2416666666667, 1.5, 0.16666666666667
5840, 1.2833333333333, 1.5, 0.16666666666667
5841, 1.325, 1.5, 0.16666666666667
5842, 1.3666666666667, 1.5, 0.16666666666667
5843, 1.4083333333333, 1.5, 0.16666666666667
5844, 1.45, 1.5, 0.16666666666667
5845, 1.4916666666667, 1.5, 0.16666666666667
5846, 1.5333333333333, 1.5, 0.16666666666667
5847, 1.575, 1.5, 0.16666666666667
5848, 1.6166666666667, 1.5, 0.16666666666667
5849, 1.6583333333333, 1.5, 0.16666666666667
5850, 1.7, 1.5, 0.16666666666667
5851, 1.7416666666667, 1.5, 0.16666666666667
5852, 1.7833333333333, 1.5, 0.16666666666667
5853, 1.825, 1.5, 0.16666666666667
5854, 1.8666666666667, 1.5, 0.16666666666667
5855, 1.9083333333333, 1.5, 0.16666666666667
5856, 1.95, 1.5, 0.16666666666667
5857, 1.9916666666667, 1.5, 0.16666666666667
5858, 2.0333333333333, 1.5, 0.16666666666667
5859, 2.075, 1.5, 0.16666666666667
5860, 2.1166666666667, 1.5, 0.16666666666667
5861, 2.1583333333333, 1.5, 0.16666666666667
5862, 1.2416666666667, 1.5, 0.20833333333333
5863, 1.2833333333333, 1.5, 0.20833333333333
5864, 1.325, 1.5, 0.20833333333333
5865, 1.3666666666667, 1.5, 0.20833333333333
5866, 1.4083333333333, 1.5, 0.20833333333333
5867, 1.45, 1.5, 0.20833333333333
5868, 1.4916666666667, 1.5, 0.20833333333333
5869, 1.5333333333333, 1.5, 0.20833333333333
5870, 1.575, 1.5, 0.20833333333333
5871, 1.6166666666667, 1.5, 0.20833333333333
5872, 1.6583333333333, 1.5, 0.20833333333333
5873, 1.7, 1.5, 0.20833333333333
5874, 1.7416666666667, 1.5, 0.20833333333333
5875, 1.7833333333333, 1.5, 0.20833333333333
5876, 1.825, 1.5, 0.20833333333333
5877, 1.8666666666667, 1.5, 0.20833333333333
5878, 1.9083333333333, 1.5, 0.20833333333333
5879, 1.95, 1.5, 0.20833333333333
5880, 1.9916666666667, 1.5, 0.20833333333333
5881, 2.0333333333333, 1.5, 0.20833333333333
5882, 2.075, 1.5, 0.20833333333333
5883, 2.1166666666667, 1.5, 0.20833333333333
5884, 2.1583333333333, 1.5, 0.20833333333333
5885, 1.2416666666667, 1.5, 0.25
5886, 1.2833333333333, 1.5, 0.25
5887, 1.325, 1.5, 0.25
5888, 1.3666666666667, 1.5, 0.25
5889, 1.4083333333333, 1.5, 0.25
5890, 1.45, 1.5, 0.25
5891, 1.4916666666667, 1.5, 0.25
5892, 1.5333333333333, 1.5, 0.25
5893, 1.575, 1.5, 0.25
5894, 1.6166666666667, 1.5, 0.25
5895, 1.6583333333333, 1.5, 0.25
5896, 1.7, 1.5, 0.25
5897, 1.7416666666667, 1.5, 0.25
5898, 1.7833333333333, 1.5, 0.25
5899, 1.825, 1.5, 0.25
5900, 1.8666666666667, 1.5, 0.25
5901, 1.9083333333333, 1.5, 0.25
5902, 1.95, 1.5, 0.25
5903, 1.9916666666667, 1.5, 0.25
5904, 2.0333333333333, 1.5, 0.25
5905, 2.075, 1.5, 0.25
5906, 2.1166666666667, 1.5, 0.25
5907, 2.1583333333333, 1.5, 0.25
5908, 1.2416666666667, 1.5, 0.29166666666667
5909, 1.2833333333333, 1.5, 0.29166666666667
5910, 1.325, 1.5, 0.29166666666667
5911, 1.3666666666667, 1.5, 0.29166666666667
5912, 1.4083333333333, 1.5, 0.29166666666667
5913, 1.45, 1.5, 0.29166666666667
5914, 1.4916666666667, 1.5, 0.29166666666667
5915, 1.5333333333333, 1.5, 0.29166666666667
5916, 1.575, 1.5, 0.29166666666667
5917, 1.6166666666667, 1.5, 0.29166666666667
5918, 1.6583333333333, 1.5, 0.29166666666667
5919, 1.7, 1.5, 0.29166666666667
5920, 1.7416666666667, 1.5, 0.29166666666667
5921, 1.7833333333333, 1.5, 0.29166666666667
5922, 1.825, 1.5, 0.29166666666667
5923, 1.8666666666667, 1.5, 0.29166666666667
5924, 1.9083333333333, 1.5, 0.29166666666667
5925, 1.95, 1.5, 0.29166666666667
5926, 1.9916666666667, 1.5, 0.29166666666667
5927, 2.0333333333333, 1.5, 0.29166666666667
5928, 2.075, 1.5, 0.29166666666667
5929, 2.1166666666667, 1.5, 0.29166666666667
5930, 2.1583333333333, 1.5, 0.29166666666667
5931, 1.2416666666667, 1.5, 0.33333333333333
5932, 1.2833333333333, 1.5, 0.33333333333333
5933, 1.325, 1.5, 0.33333333333333
5934, 1.3666666666667, 1.5, 0.33333333333333
5935, 1.4083333333333, 1.5, 0.33333333333333
5936, 1.45, 1.5, 0.33333333333333
5937, 1.4916666666667, 1.5, 0.33333333333333
5938, 1.5333333333333, 1.5, 0.33333333333333
5939, 1.575, 1.5, 0.33333333333333
5940, 1.6166666666667, 1.5, 0.33333333333333
5941, 1.6583333333333, 1.5, 0.33333333333333
5942, 1.7, 1.5, 0.33333333333333
5943, 1.7416666666667, 1.5, 0.33333333333333
5944, 1.7833333333333, 1.5, 0.33333333333333
5945, 1.825, 1.5, 0.33333333333333
5946, 1.8666666666667, 1.5, 0.33333333333333
5947, 1.9083333333333, 1.5, 0.33333333333333
5948, 1.95, 1.5, 0.33333333333333
5949, 1.9916666666667, 1.5, 0.33333333333333
5950, 2.0333333333333, 1.5, 0.33333333333333
5951, 2.075, 1.5, 0.33333333333333
5952, 2.1166666666667, 1.5, 0.33333333333333
5953, 2.1583333333333, 1.5, 0.33333333333333
5954, 1.2416666666667, 1.5, 0.375
5955, 1.2833333333333, 1.5, 0.375
5956, 1.325, 1.5, 0.375
5957, 1.3666666666667, 1.5, 0.375
5958, 1.4083333333333, 1.5, 0.375
5959, 1.45, 1.5, 0.375
5960, 1.4916666666667, 1.5, 0.375
5961, 1.5333333333333, 1.5, 0.375
5962, 1.575, 1.5, 0.375
5963, 1.6166666666667, 1.5, 0.375
5964, 1.6583333333333, 1.5, 0.375
5965, 1.7, 1.5, 0.375
5966, 1.7416666666667, 1.5, 0.375
5967, 1.7833333333333, 1.5, 0.375
5968, 1.825, 1.5, 0.375
5969, 1.8666666666667, 1.5, 0.375
5970, 1.9083333333333, 1.5, 0.375
5971, 1.95, 1.5, 0.375
5972, 1.9916666666667, 1.5, 0.375
5973, 2.0333333333333, 1.5, 0.375
5974, 2.075, 1.5, 0.375
5975, 2.1166666666667, 1.5, 0.375
5976, 2.1583333333333, 1.5, 0.375
5977, 1.2416666666667, 1.5, 0.41666666666667
5978, 1.2833333333333, 1.5, 0.41666666666667
5979, 1.325, 1.5, 0.41666666666667
5980, 1.3666666666667, 1.5, 0.41666666666667
5981, 1.4083333333333, 1.5, 0.41666666666667
5982, 1.45, 1.5, 0.41666666666667
5983, 1.4916666666667, 1.5, 0.41666666666667
5984, 1.5333333333333, 1.5, 0.41666666666667
5985, 1.575, 1.5, 0.41666666666667
5986, 1.6166666666667, 1.5, 0.41666666666667
5987, 1.6583333333333, 1.5, 0.41666666666667
5988, 1.7, 1.5, 0.41666666666667
5989, 1.7416666666667, 1.5, 0.41666666666667
5990, 1.7833333333333, 1.5, 0.41666666666667
5991, 1.825, 1.5, 0.41666666666667
5992, 1.8666666666667, 1.5, 0.41666666666667
5993, 1.9083333333333, 1.5, 0.41666666666667
5994, 1.95, 1.5, 0.41666666666667
5995, 1.9916666666667, 1.5, 0.41666666666667
5996, 2.0333333333333, 1.5, 0.41666666666667
5997, 2.075, 1.5, 0.41666666666667
5998, 2.1166666666667, 1.5, 0.41666666666667
5999, 2.1583333333333, 1.5, 0.41666666666667
6000, 1.2416666666667, 1.5, 0.45833333333333
6001, 1.2833333333333, 1.5, 0.45833333333333
6002, 1.325, 1.5, 0.45833333333333
6003, 1.3666666666667, 1.5, 0.45833333333333
6004, 1.4083333333333, 1.5, 0.45833333333333
6005, 1.45, 1.5, 0.45833333333333
6006, 1.4916666666667, 1.5, 0.45833333333333
6007, 1.5333333333333, 1.5, 0.45833333333333
6008, 1.575, 1.5, 0.45833333333333
6009, 1.6166666666667, 1.5, 0.45833333333333
6010, 1.6583333333333, 1.5, 0.45833333333333
6011, 1.7, 1.5, 0.45833333333333
6012, 1.7416666666667, 1.5, 0.45833333333333
6013, 1.7833333333333, 1.5, 0.45833333333333
6014, 1.825, 1.5, 0.45833333333333
6015, 1.8666666666667, 1.5, 0.45833333333333
6016, 1.9083333333333, 1.5, 0.45833333333333
6017, 1.95, 1.5, 0.45833333333333
6018, 1.9916666666667, 1.5, 0.45833333333333
6019, 2.0333333333333, 1.5, 0.45833333333333
6020, 2.075, 1.5, 0.45833333333333
6021, 2.1166666666667, 1.5, 0.45833333333333
6022, 2.1583333333333, 1.5, 0.45833333333333
6023, 2.2, 1.4333333333333, 0.041666666666667
6024, 2.2, 1.4666666666667, 0.041666666666667
6025, 2.2, 1.4333333333333, 0.083333333333333
6026, 2.2, 1.4666666666667, 0.083333333333333
6027, 2.2, 1.4333333333333, 0.125
6028, 2.2, 1.4666666666667, 0.125
6029, 2.2, 1.4333333333333, 0.16666666666667
6030, 2.2, 1.4666666666667, 0.16666666666667
6031, 2.2, 1.4333333333333, 0.20833333333333
6032, 2.2, 1.4666666666667, 0.20833333333333
6033, 2.2, 1.4333333333333, 0.25
6034, 2.2, 1.4666666666667, 0.25
6035, 2.2, 1.4333333333333, 0.29166666666667
6036, 2.2, 1.4666666666667, 0.29166666666667
6037, 2.2, 1.4333333333333, 0.33333333333333
6038, 2.2, 1.4666666666667, 0.33333333333333
6039, 2.2, 1.4333333333333, 0.375
6040, 2.2, 1.4666666666667, 0.375
6041, 2.2, 1.4333333333333, 0.41666666666667
6042, 2.2, 1.4666666666667, 0.41666666666667
6043, 2.2, 1.4333333333333, 0.45833333333333
6044, 2.2, 1.4666666666667, 0.45833333333333
6045, 1.2416666666667, 1.35, 0.041666666666667
6046, 1.2833333333333, 1.35, 0.041666666666667
6047, 1.325, 1.35, 0.041666666666667
6048, 1.3666666666667, 1.35, 0.041666666666667
6049, 1.4083333333333, 1.35, 0.041666666666667
6050, 1.45, 1.35, 0.041666666666667
6051, 1.4916666666667, 1.35, 0.041666666666667
6052, 1.5333333333333, 1.35, 0.041666666666667
6053, 1.575, 1.35, 0.041666666666667
6054, 1.6166666666667, 1.35, 0.041666666666667
6055, 1.6583333333333, 1.35, 0.041666666666667
6056, 1.7, 1.35, 0.041666666666667
6057, 1.7416666666667, 1.35, 0.041666666666667
6058, 1.7833333333333, 1.35, 0.041666666666667
6059, 1.825, 1.35, 0.041666666666667
6060, 1.8666666666667, 1.35, 0.041666666666667
6061, 1.9083333333333, 1.35, 0.041666666666667
6062, 1.95, 1.35, 0.041666666666667
6063, 1.9916666666667, 1.35, 0.041666666666667
6064, 2.0333333333333, 1.35, 0.041666666666667
6065, 2.075, 1.35, 0.041666666666667
6066, 2.1166666666667, 1.35, 0.041666666666667
6067, 2.1583333333333, 1.35, 0.041666666666667
6068, 1.2416666666667, 1.35, 0.083333333333333
6069, 1.2833333333333, 1.35, 0.083333333333333
6070, 1.325, 1.35, 0.083333333333333
6071, 1.3666666666667, 1.35, 0.083333333333333
6072, 1.4083333333333, 1.35, 0.083333333333333
6073, 1.45, 1.35, 0.083333333333333
6074, 1.4916666666667, 1.35, 0.083333333333333
6075, 1.5333333333333, 1.35, 0.083333333333333
6076, 1.575, 1.35, 0.083333333333333
6077, 1.6166666666667, 1.35, 0.083333333333333
6078, 1.6583333333333, 1.35, 0.083333333333333
6079, 1.7, 1.35, 0.083333333333333
6080, 1.7416666666667, 1.35, 0.083333333333333
6081, 1.7833333333333, 1.35, 0.083333333333333
6082, 1.825, 1.35, 0.083333333333333
6083, 1.8666666666667, 1.35, 0.083333333333333
6084, 1.9083333333333, 1.35, 0.083333333333333
6085, 1.95, 1.35, 0.083333333333333
6086, 1.9916666666667, 1.35, 0.083333333333333
6087, 2.0333333333333, 1.35, 0.083333333333333
6088, 2.075, 1.35, 0.083333333333333
6089, 2.1166666666667, 1.35, 0.083333333333333
6090, 2.1583333333333, 1.35, 0.083333333333333
6091, 1.2416666666667, 1.35, 0.125
6092, 1.2833333333333, 1.35, 0.125
6093, 1.325, 1.35, 0.125
6094, 1.3666666666667, 1.35, 0.125
6095, 1.4083333333333, 1.35, 0.125
6096, 1.45, 1.35, 0.125
6097, 1.4916666666667, 1.35, 0.125
6098, 1.5333333333333, 1.35, 0.125
6099, 1.575, 1.35, 0.125
6100, 1.6166666666667, 1.35, 0.125
6101, 1.6583333333333, 1.35, 0.125
6102, 1.7, 1.35, 0.125
6103, 1.7416666666667, 1.35, 0.125
6104, 1.7833333333333, 1.35, 0.125
6105, 1.825, 1.35, 0.125
6106, 1.8666666666667, 1.35, 0.125
6107, 1.9083333333333, 1.35, 0.125
6108, 1.95, 1.35, 0.125
6109, 1.9916666666667, 1.35, 0.125
6110, 2.0333333333333, 1.35, 0.125
6111, 2.075, 1.35, 0.125
6112, 2.1166666666667, 1.35, 0.125
6113, 2.1583333333333, 1.35, 0.125
6114, 1.2416666666667, 1.35, 0.16666666666667
6115, 1.2833333333333, 1.35, 0.16666666666667
6116, 1.325, 1.35, 0.16666666666667
6117, 1.3666666666667, 1.35, 0.16666666666667
6118, 1.4083333333333, 1.35, 0.16666666666667
6119, 1.45, 1.35, 0.16666666666667
6120, 1.4916666666667, 1.35, 0.16666666666667
6121, 1.5333333333333, 1.35, 0.16666666666667
6122, 1.575, 1.35, 0.16666666666667
6123, 1.6166666666667, 1.35, 0.16666666666667
6124, 1.6583333333333, 1.35, 0.16666666666667
6125, 1.7, 1.35, 0.16666666666667
6126, 1.7416666666667, 1.35, 0.16666666666667
6127, 1.7833333333333, 1.35, 0.16666666666667
6128, 1.825, 1.35, 0.16666666666667
6129, 1.8666666666667, 1.35, 0.16666666666667
6130, 1.9083333333333, 1.35, 0.16666666666667
6131, 1.95, 1.35, 0.16666666666667
6132, 1.9916666666667, 1.35, 0.16666666666667
6133, 2.0333333333333, 1.35, 0.16666666666667
6134, 2.075, 1.35, 0.16666666666667
6135, 2.1166666666667, 1.35, 0.16666666666667
6136, 2.1583333333333, 1.35, 0.16666666666667
6137, 1.2416666666667, 1.35, 0.20833333333333
