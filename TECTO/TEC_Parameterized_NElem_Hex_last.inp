35787, 4223, 4246, 4247, 4224
35788, 4224, 4247, 4248, 4225
35789, 4225, 4248, 4249, 4226
35790, 4226, 4249, 4250, 4227
35791, 4227, 4250, 4251, 4228
35792, 4228, 4251, 4252, 4229
35793, 4229, 4252, 4253, 4230
35794, 4230, 4253, 4254, 4231
35795, 4231, 4254, 4255, 4232
35796, 4232, 4255, 4256, 4233
35797, 4233, 4256, 4257, 4234
35798, 4234, 4257, 4258, 4235
35799, 4235, 4258, 4259, 4236
35800, 4236, 4259, 4260, 4237
35801, 4237, 4260, 4261, 4238
35802, 4238, 4261, 4262, 4239
35803, 4239, 4262, 4263, 4240
35804, 4240, 4263, 4264, 4241
35805, 4241, 4264, 4265, 4242
35806, 4242, 4265, 462, 461
35807, 302, 303, 4266, 4243
35808, 4243, 4266, 4267, 4244
35809, 4244, 4267, 4268, 4245
35810, 4245, 4268, 4269, 4246
35811, 4246, 4269, 4270, 4247
35812, 4247, 4270, 4271, 4248
35813, 4248, 4271, 4272, 4249
35814, 4249, 4272, 4273, 4250
35815, 4250, 4273, 4274, 4251
35816, 4251, 4274, 4275, 4252
35817, 4252, 4275, 4276, 4253
35818, 4253, 4276, 4277, 4254
35819, 4254, 4277, 4278, 4255
35820, 4255, 4278, 4279, 4256
35821, 4256, 4279, 4280, 4257
35822, 4257, 4280, 4281, 4258
35823, 4258, 4281, 4282, 4259
35824, 4259, 4282, 4283, 4260
35825, 4260, 4283, 4284, 4261
35826, 4261, 4284, 4285, 4262
35827, 4262, 4285, 4286, 4263
35828, 4263, 4286, 4287, 4264
35829, 4264, 4287, 4288, 4265
35830, 4265, 4288, 463, 462
35831, 303, 304, 4289, 4266
35832, 4266, 4289, 4290, 4267
35833, 4267, 4290, 4291, 4268
35834, 4268, 4291, 4292, 4269
35835, 4269, 4292, 4293, 4270
35836, 4270, 4293, 4294, 4271
35837, 4271, 4294, 4295, 4272
35838, 4272, 4295, 4296, 4273
35839, 4273, 4296, 4297, 4274
35840, 4274, 4297, 4298, 4275
35841, 4275, 4298, 4299, 4276
35842, 4276, 4299, 4300, 4277
35843, 4277, 4300, 4301, 4278
35844, 4278, 4301, 4302, 4279
35845, 4279, 4302, 4303, 4280
35846, 4280, 4303, 4304, 4281
35847, 4281, 4304, 4305, 4282
35848, 4282, 4305, 4306, 4283
35849, 4283, 4306, 4307, 4284
35850, 4284, 4307, 4308, 4285
35851, 4285, 4308, 4309, 4286
35852, 4286, 4309, 4310, 4287
35853, 4287, 4310, 4311, 4288
35854, 4288, 4311, 464, 463
35855, 304, 305, 4312, 4289
35856, 4289, 4312, 4313, 4290
35857, 4290, 4313, 4314, 4291
35858, 4291, 4314, 4315, 4292
35859, 4292, 4315, 4316, 4293
35860, 4293, 4316, 4317, 4294
35861, 4294, 4317, 4318, 4295
35862, 4295, 4318, 4319, 4296
35863, 4296, 4319, 4320, 4297
35864, 4297, 4320, 4321, 4298
35865, 4298, 4321, 4322, 4299
35866, 4299, 4322, 4323, 4300
35867, 4300, 4323, 4324, 4301
35868, 4301, 4324, 4325, 4302
35869, 4302, 4325, 4326, 4303
35870, 4303, 4326, 4327, 4304
35871, 4304, 4327, 4328, 4305
35872, 4305, 4328, 4329, 4306
35873, 4306, 4329, 4330, 4307
35874, 4307, 4330, 4331, 4308
35875, 4308, 4331, 4332, 4309
35876, 4309, 4332, 4333, 4310
35877, 4310, 4333, 4334, 4311
35878, 4311, 4334, 465, 464
35879, 305, 306, 4335, 4312
35880, 4312, 4335, 4336, 4313
35881, 4313, 4336, 4337, 4314
35882, 4314, 4337, 4338, 4315
35883, 4315, 4338, 4339, 4316
35884, 4316, 4339, 4340, 4317
35885, 4317, 4340, 4341, 4318
35886, 4318, 4341, 4342, 4319
35887, 4319, 4342, 4343, 4320
35888, 4320, 4343, 4344, 4321
35889, 4321, 4344, 4345, 4322
35890, 4322, 4345, 4346, 4323
35891, 4323, 4346, 4347, 4324
35892, 4324, 4347, 4348, 4325
35893, 4325, 4348, 4349, 4326
35894, 4326, 4349, 4350, 4327
35895, 4327, 4350, 4351, 4328
35896, 4328, 4351, 4352, 4329
35897, 4329, 4352, 4353, 4330
35898, 4330, 4353, 4354, 4331
35899, 4331, 4354, 4355, 4332
35900, 4332, 4355, 4356, 4333
35901, 4333, 4356, 4357, 4334
35902, 4334, 4357, 466, 465
35903, 306, 307, 4358, 4335
35904, 4335, 4358, 4359, 4336
35905, 4336, 4359, 4360, 4337
35906, 4337, 4360, 4361, 4338
35907, 4338, 4361, 4362, 4339
35908, 4339, 4362, 4363, 4340
35909, 4340, 4363, 4364, 4341
35910, 4341, 4364, 4365, 4342
35911, 4342, 4365, 4366, 4343
35912, 4343, 4366, 4367, 4344
35913, 4344, 4367, 4368, 4345
35914, 4345, 4368, 4369, 4346
35915, 4346, 4369, 4370, 4347
35916, 4347, 4370, 4371, 4348
35917, 4348, 4371, 4372, 4349
35918, 4349, 4372, 4373, 4350
35919, 4350, 4373, 4374, 4351
35920, 4351, 4374, 4375, 4352
35921, 4352, 4375, 4376, 4353
35922, 4353, 4376, 4377, 4354
35923, 4354, 4377, 4378, 4355
35924, 4355, 4378, 4379, 4356
35925, 4356, 4379, 4380, 4357
35926, 4357, 4380, 467, 466
35927, 307, 308, 4381, 4358
35928, 4358, 4381, 4382, 4359
35929, 4359, 4382, 4383, 4360
35930, 4360, 4383, 4384, 4361
35931, 4361, 4384, 4385, 4362
35932, 4362, 4385, 4386, 4363
35933, 4363, 4386, 4387, 4364
35934, 4364, 4387, 4388, 4365
35935, 4365, 4388, 4389, 4366
35936, 4366, 4389, 4390, 4367
35937, 4367, 4390, 4391, 4368
35938, 4368, 4391, 4392, 4369
35939, 4369, 4392, 4393, 4370
35940, 4370, 4393, 4394, 4371
35941, 4371, 4394, 4395, 4372
35942, 4372, 4395, 4396, 4373
35943, 4373, 4396, 4397, 4374
35944, 4374, 4397, 4398, 4375
35945, 4375, 4398, 4399, 4376
35946, 4376, 4399, 4400, 4377
35947, 4377, 4400, 4401, 4378
35948, 4378, 4401, 4402, 4379
35949, 4379, 4402, 4403, 4380
35950, 4380, 4403, 468, 467
35951, 308, 12, 412, 4381
35952, 4381, 412, 413, 4382
35953, 4382, 413, 414, 4383
35954, 4383, 414, 415, 4384
35955, 4384, 415, 416, 4385
35956, 4385, 416, 417, 4386
35957, 4386, 417, 418, 4387
35958, 4387, 418, 419, 4388
35959, 4388, 419, 420, 4389
35960, 4389, 420, 421, 4390
35961, 4390, 421, 422, 4391
35962, 4391, 422, 423, 4392
35963, 4392, 423, 424, 4393
35964, 4393, 424, 425, 4394
35965, 4394, 425, 426, 4395
35966, 4395, 426, 427, 4396
35967, 4396, 427, 428, 4397
35968, 4397, 428, 429, 4398
35969, 4398, 429, 430, 4399
35970, 4399, 430, 431, 4400
35971, 4400, 431, 432, 4401
35972, 4401, 432, 433, 4402
35973, 4402, 433, 434, 4403
35974, 4403, 434, 16, 468
*ELEMENT, type=CPS4, ELSET=Surface16
1070, 14, 458, 4404, 355
1071, 458, 459, 4405, 4404
1072, 459, 460, 4406, 4405
1073, 460, 461, 4407, 4406
1074, 461, 462, 4408, 4407
1075, 462, 463, 4409, 4408
1076, 463, 464, 4410, 4409
1077, 464, 465, 4411, 4410
1078, 465, 466, 4412, 4411
1079, 466, 467, 4413, 4412
1080, 467, 468, 4414, 4413
1081, 468, 16, 435, 4414
1082, 355, 4404, 4415, 356
1083, 4404, 4405, 4416, 4415
1084, 4405, 4406, 4417, 4416
1085, 4406, 4407, 4418, 4417
1086, 4407, 4408, 4419, 4418
1087, 4408, 4409, 4420, 4419
1088, 4409, 4410, 4421, 4420
1089, 4410, 4411, 4422, 4421
1090, 4411, 4412, 4423, 4422
1091, 4412, 4413, 4424, 4423
1092, 4413, 4414, 4425, 4424
1093, 4414, 435, 436, 4425
1094, 356, 4415, 4426, 357
1095, 4415, 4416, 4427, 4426
1096, 4416, 4417, 4428, 4427
1097, 4417, 4418, 4429, 4428
1098, 4418, 4419, 4430, 4429
1099, 4419, 4420, 4431, 4430
1100, 4420, 4421, 4432, 4431
1101, 4421, 4422, 4433, 4432
1102, 4422, 4423, 4434, 4433
1103, 4423, 4424, 4435, 4434
1104, 4424, 4425, 4436, 4435
1105, 4425, 436, 437, 4436
1106, 357, 4426, 4437, 358
1107, 4426, 4427, 4438, 4437
1108, 4427, 4428, 4439, 4438
1109, 4428, 4429, 4440, 4439
1110, 4429, 4430, 4441, 4440
1111, 4430, 4431, 4442, 4441
1112, 4431, 4432, 4443, 4442
1113, 4432, 4433, 4444, 4443
1114, 4433, 4434, 4445, 4444
1115, 4434, 4435, 4446, 4445
1116, 4435, 4436, 4447, 4446
1117, 4436, 437, 438, 4447
1118, 358, 4437, 4448, 359
1119, 4437, 4438, 4449, 4448
1120, 4438, 4439, 4450, 4449
1121, 4439, 4440, 4451, 4450
1122, 4440, 4441, 4452, 4451
1123, 4441, 4442, 4453, 4452
1124, 4442, 4443, 4454, 4453
1125, 4443, 4444, 4455, 4454
1126, 4444, 4445, 4456, 4455
1127, 4445, 4446, 4457, 4456
1128, 4446, 4447, 4458, 4457
1129, 4447, 438, 439, 4458
1130, 359, 4448, 4459, 360
1131, 4448, 4449, 4460, 4459
1132, 4449, 4450, 4461, 4460
1133, 4450, 4451, 4462, 4461
1134, 4451, 4452, 4463, 4462
1135, 4452, 4453, 4464, 4463
1136, 4453, 4454, 4465, 4464
1137, 4454, 4455, 4466, 4465
1138, 4455, 4456, 4467, 4466
1139, 4456, 4457, 4468, 4467
1140, 4457, 4458, 4469, 4468
1141, 4458, 439, 440, 4469
1142, 360, 4459, 4470, 361
1143, 4459, 4460, 4471, 4470
1144, 4460, 4461, 4472, 4471
1145, 4461, 4462, 4473, 4472
1146, 4462, 4463, 4474, 4473
1147, 4463, 4464, 4475, 4474
1148, 4464, 4465, 4476, 4475
1149, 4465, 4466, 4477, 4476
1150, 4466, 4467, 4478, 4477
1151, 4467, 4468, 4479, 4478
1152, 4468, 4469, 4480, 4479
1153, 4469, 440, 441, 4480
1154, 361, 4470, 4481, 362
1155, 4470, 4471, 4482, 4481
1156, 4471, 4472, 4483, 4482
1157, 4472, 4473, 4484, 4483
1158, 4473, 4474, 4485, 4484
1159, 4474, 4475, 4486, 4485
1160, 4475, 4476, 4487, 4486
1161, 4476, 4477, 4488, 4487
1162, 4477, 4478, 4489, 4488
1163, 4478, 4479, 4490, 4489
1164, 4479, 4480, 4491, 4490
1165, 4480, 441, 442, 4491
1166, 362, 4481, 4492, 363
1167, 4481, 4482, 4493, 4492
1168, 4482, 4483, 4494, 4493
1169, 4483, 4484, 4495, 4494
1170, 4484, 4485, 4496, 4495
1171, 4485, 4486, 4497, 4496
1172, 4486, 4487, 4498, 4497
1173, 4487, 4488, 4499, 4498
1174, 4488, 4489, 4500, 4499
1175, 4489, 4490, 4501, 4500
1176, 4490, 4491, 4502, 4501
1177, 4491, 442, 443, 4502
1178, 363, 4492, 4503, 364
1179, 4492, 4493, 4504, 4503
1180, 4493, 4494, 4505, 4504
1181, 4494, 4495, 4506, 4505
1182, 4495, 4496, 4507, 4506
1183, 4496, 4497, 4508, 4507
1184, 4497, 4498, 4509, 4508
1185, 4498, 4499, 4510, 4509
1186, 4499, 4500, 4511, 4510
1187, 4500, 4501, 4512, 4511
1188, 4501, 4502, 4513, 4512
1189, 4502, 443, 444, 4513
1190, 364, 4503, 4514, 365
1191, 4503, 4504, 4515, 4514
1192, 4504, 4505, 4516, 4515
1193, 4505, 4506, 4517, 4516
1194, 4506, 4507, 4518, 4517
1195, 4507, 4508, 4519, 4518
1196, 4508, 4509, 4520, 4519
1197, 4509, 4510, 4521, 4520
1198, 4510, 4511, 4522, 4521
1199, 4511, 4512, 4523, 4522
1200, 4512, 4513, 4524, 4523
1201, 4513, 444, 445, 4524
1202, 365, 4514, 4525, 366
1203, 4514, 4515, 4526, 4525
1204, 4515, 4516, 4527, 4526
1205, 4516, 4517, 4528, 4527
1206, 4517, 4518, 4529, 4528
1207, 4518, 4519, 4530, 4529
1208, 4519, 4520, 4531, 4530
1209, 4520, 4521, 4532, 4531
1210, 4521, 4522, 4533, 4532
1211, 4522, 4523, 4534, 4533
1212, 4523, 4524, 4535, 4534
1213, 4524, 445, 446, 4535
1214, 366, 4525, 4536, 367
1215, 4525, 4526, 4537, 4536
1216, 4526, 4527, 4538, 4537
1217, 4527, 4528, 4539, 4538
1218, 4528, 4529, 4540, 4539
1219, 4529, 4530, 4541, 4540
1220, 4530, 4531, 4542, 4541
1221, 4531, 4532, 4543, 4542
1222, 4532, 4533, 4544, 4543
1223, 4533, 4534, 4545, 4544
1224, 4534, 4535, 4546, 4545
1225, 4535, 446, 447, 4546
1226, 367, 4536, 4547, 368
1227, 4536, 4537, 4548, 4547
1228, 4537, 4538, 4549, 4548
1229, 4538, 4539, 4550, 4549
1230, 4539, 4540, 4551, 4550
1231, 4540, 4541, 4552, 4551
1232, 4541, 4542, 4553, 4552
1233, 4542, 4543, 4554, 4553
1234, 4543, 4544, 4555, 4554
1235, 4544, 4545, 4556, 4555
1236, 4545, 4546, 4557, 4556
1237, 4546, 447, 448, 4557
1238, 368, 4547, 4558, 369
1239, 4547, 4548, 4559, 4558
1240, 4548, 4549, 4560, 4559
1241, 4549, 4550, 4561, 4560
1242, 4550, 4551, 4562, 4561
1243, 4551, 4552, 4563, 4562
1244, 4552, 4553, 4564, 4563
1245, 4553, 4554, 4565, 4564
1246, 4554, 4555, 4566, 4565
1247, 4555, 4556, 4567, 4566
1248, 4556, 4557, 4568, 4567
1249, 4557, 448, 449, 4568
1250, 369, 4558, 4569, 370
1251, 4558, 4559, 4570, 4569
1252, 4559, 4560, 4571, 4570
1253, 4560, 4561, 4572, 4571
1254, 4561, 4562, 4573, 4572
1255, 4562, 4563, 4574, 4573
1256, 4563, 4564, 4575, 4574
1257, 4564, 4565, 4576, 4575
1258, 4565, 4566, 4577, 4576
1259, 4566, 4567, 4578, 4577
1260, 4567, 4568, 4579, 4578
1261, 4568, 449, 450, 4579
1262, 370, 4569, 4580, 371
1263, 4569, 4570, 4581, 4580
1264, 4570, 4571, 4582, 4581
1265, 4571, 4572, 4583, 4582
1266, 4572, 4573, 4584, 4583
1267, 4573, 4574, 4585, 4584
1268, 4574, 4575, 4586, 4585
1269, 4575, 4576, 4587, 4586
1270, 4576, 4577, 4588, 4587
1271, 4577, 4578, 4589, 4588
1272, 4578, 4579, 4590, 4589
1273, 4579, 450, 451, 4590
1274, 371, 4580, 4591, 372
1275, 4580, 4581, 4592, 4591
1276, 4581, 4582, 4593, 4592
1277, 4582, 4583, 4594, 4593
1278, 4583, 4584, 4595, 4594
1279, 4584, 4585, 4596, 4595
1280, 4585, 4586, 4597, 4596
1281, 4586, 4587, 4598, 4597
1282, 4587, 4588, 4599, 4598
1283, 4588, 4589, 4600, 4599
1284, 4589, 4590, 4601, 4600
1285, 4590, 451, 452, 4601
1286, 372, 4591, 4602, 373
1287, 4591, 4592, 4603, 4602
1288, 4592, 4593, 4604, 4603
1289, 4593, 4594, 4605, 4604
1290, 4594, 4595, 4606, 4605
1291, 4595, 4596, 4607, 4606
1292, 4596, 4597, 4608, 4607
1293, 4597, 4598, 4609, 4608
1294, 4598, 4599, 4610, 4609
1295, 4599, 4600, 4611, 4610
1296, 4600, 4601, 4612, 4611
1297, 4601, 452, 453, 4612
1298, 373, 4602, 4613, 374
1299, 4602, 4603, 4614, 4613
1300, 4603, 4604, 4615, 4614
1301, 4604, 4605, 4616, 4615
1302, 4605, 4606, 4617, 4616
1303, 4606, 4607, 4618, 4617
1304, 4607, 4608, 4619, 4618
1305, 4608, 4609, 4620, 4619
1306, 4609, 4610, 4621, 4620
1307, 4610, 4611, 4622, 4621
1308, 4611, 4612, 4623, 4622
1309, 4612, 453, 454, 4623
1310, 374, 4613, 4624, 375
1311, 4613, 4614, 4625, 4624
1312, 4614, 4615, 4626, 4625
1313, 4615, 4616, 4627, 4626
1314, 4616, 4617, 4628, 4627
1315, 4617, 4618, 4629, 4628
1316, 4618, 4619, 4630, 4629
1317, 4619, 4620, 4631, 4630
1318, 4620, 4621, 4632, 4631
1319, 4621, 4622, 4633, 4632
1320, 4622, 4623, 4634, 4633
1321, 4623, 454, 455, 4634
1322, 375, 4624, 4635, 376
1323, 4624, 4625, 4636, 4635
1324, 4625, 4626, 4637, 4636
1325, 4626, 4627, 4638, 4637
1326, 4627, 4628, 4639, 4638
1327, 4628, 4629, 4640, 4639
1328, 4629, 4630, 4641, 4640
1329, 4630, 4631, 4642, 4641
1330, 4631, 4632, 4643, 4642
1331, 4632, 4633, 4644, 4643
1332, 4633, 4634, 4645, 4644
1333, 4634, 455, 456, 4645
1334, 376, 4635, 4646, 377
1335, 4635, 4636, 4647, 4646
1336, 4636, 4637, 4648, 4647
1337, 4637, 4638, 4649, 4648
1338, 4638, 4639, 4650, 4649
1339, 4639, 4640, 4651, 4650
1340, 4640, 4641, 4652, 4651
1341, 4641, 4642, 4653, 4652
1342, 4642, 4643, 4654, 4653
1343, 4643, 4644, 4655, 4654
1344, 4644, 4645, 4656, 4655
1345, 4645, 456, 457, 4656
1346, 377, 4646, 401, 13
1347, 4646, 4647, 402, 401
1348, 4647, 4648, 403, 402
1349, 4648, 4649, 404, 403
1350, 4649, 4650, 405, 404
1351, 4650, 4651, 406, 405
1352, 4651, 4652, 407, 406
1353, 4652, 4653, 408, 407
1354, 4653, 4654, 409, 408
1355, 4654, 4655, 410, 409
1356, 4655, 4656, 411, 410
1357, 4656, 457, 15, 411
*ELEMENT, type=CPS4, ELSET=Surface17
35975, 14, 18, 469, 355
35976, 355, 469, 470, 356
35977, 356, 470, 471, 357
35978, 357, 471, 472, 358
35979, 358, 472, 473, 359
35980, 359, 473, 474, 360
35981, 360, 474, 475, 361
35982, 361, 475, 476, 362
35983, 362, 476, 477, 363
35984, 363, 477, 478, 364
35985, 364, 478, 479, 365
35986, 365, 479, 480, 366
35987, 366, 480, 481, 367
35988, 367, 481, 482, 368
35989, 368, 482, 483, 369
35990, 369, 483, 484, 370
35991, 370, 484, 485, 371
35992, 371, 485, 486, 372
35993, 372, 486, 487, 373
35994, 373, 487, 488, 374
35995, 374, 488, 489, 375
35996, 375, 489, 490, 376
35997, 376, 490, 491, 377
35998, 377, 491, 17, 13
*ELEMENT, type=CPS4, ELSET=Surface18
35999, 13, 17, 492, 401
36000, 401, 492, 493, 402
36001, 402, 493, 494, 403
36002, 403, 494, 495, 404
36003, 404, 495, 496, 405
36004, 405, 496, 497, 406
36005, 406, 497, 498, 407
36006, 407, 498, 499, 408
36007, 408, 499, 500, 409
36008, 409, 500, 501, 410
36009, 410, 501, 502, 411
36010, 411, 502, 19, 15
*ELEMENT, type=CPS4, ELSET=Surface19
1358, 16, 435, 503, 20
1359, 435, 436, 504, 503
1360, 436, 437, 505, 504
1361, 437, 438, 506, 505
1362, 438, 439, 507, 506
1363, 439, 440, 508, 507
1364, 440, 441, 509, 508
1365, 441, 442, 510, 509
1366, 442, 443, 511, 510
1367, 443, 444, 512, 511
1368, 444, 445, 513, 512
1369, 445, 446, 514, 513
1370, 446, 447, 515, 514
1371, 447, 448, 516, 515
1372, 448, 449, 517, 516
1373, 449, 450, 518, 517
1374, 450, 451, 519, 518
1375, 451, 452, 520, 519
1376, 452, 453, 521, 520
1377, 453, 454, 522, 521
1378, 454, 455, 523, 522
1379, 455, 456, 524, 523
1380, 456, 457, 525, 524
1381, 457, 15, 19, 525
*ELEMENT, type=CPS4, ELSET=Surface20
36011, 14, 458, 526, 18
36012, 458, 459, 527, 526
36013, 459, 460, 528, 527
36014, 460, 461, 529, 528
36015, 461, 462, 530, 529
36016, 462, 463, 531, 530
36017, 463, 464, 532, 531
36018, 464, 465, 533, 532
36019, 465, 466, 534, 533
36020, 466, 467, 535, 534
36021, 467, 468, 536, 535
36022, 468, 16, 20, 536
*ELEMENT, type=CPS4, ELSET=Surface21
36023, 18, 526, 4657, 469
36024, 526, 527, 4658, 4657
36025, 527, 528, 4659, 4658
36026, 528, 529, 4660, 4659
36027, 529, 530, 4661, 4660
36028, 530, 531, 4662, 4661
36029, 531, 532, 4663, 4662
36030, 532, 533, 4664, 4663
36031, 533, 534, 4665, 4664
36032, 534, 535, 4666, 4665
36033, 535, 536, 4667, 4666
36034, 536, 20, 503, 4667
36035, 469, 4657, 4668, 470
36036, 4657, 4658, 4669, 4668
36037, 4658, 4659, 4670, 4669
36038, 4659, 4660, 4671, 4670
36039, 4660, 4661, 4672, 4671
36040, 4661, 4662, 4673, 4672
36041, 4662, 4663, 4674, 4673
36042, 4663, 4664, 4675, 4674
36043, 4664, 4665, 4676, 4675
36044, 4665, 4666, 4677, 4676
36045, 4666, 4667, 4678, 4677
36046, 4667, 503, 504, 4678
36047, 470, 4668, 4679, 471
36048, 4668, 4669, 4680, 4679
36049, 4669, 4670, 4681, 4680
36050, 4670, 4671, 4682, 4681
36051, 4671, 4672, 4683, 4682
36052, 4672, 4673, 4684, 4683
36053, 4673, 4674, 4685, 4684
36054, 4674, 4675, 4686, 4685
36055, 4675, 4676, 4687, 4686
36056, 4676, 4677, 4688, 4687
36057, 4677, 4678, 4689, 4688
36058, 4678, 504, 505, 4689
36059, 471, 4679, 4690, 472
36060, 4679, 4680, 4691, 4690
36061, 4680, 4681, 4692, 4691
36062, 4681, 4682, 4693, 4692
36063, 4682, 4683, 4694, 4693
36064, 4683, 4684, 4695, 4694
36065, 4684, 4685, 4696, 4695
36066, 4685, 4686, 4697, 4696
36067, 4686, 4687, 4698, 4697
36068, 4687, 4688, 4699, 4698
36069, 4688, 4689, 4700, 4699
36070, 4689, 505, 506, 4700
36071, 472, 4690, 4701, 473
36072, 4690, 4691, 4702, 4701
36073, 4691, 4692, 4703, 4702
36074, 4692, 4693, 4704, 4703
36075, 4693, 4694, 4705, 4704
36076, 4694, 4695, 4706, 4705
36077, 4695, 4696, 4707, 4706
36078, 4696, 4697, 4708, 4707
36079, 4697, 4698, 4709, 4708
36080, 4698, 4699, 4710, 4709
36081, 4699, 4700, 4711, 4710
36082, 4700, 506, 507, 4711
36083, 473, 4701, 4712, 474
36084, 4701, 4702, 4713, 4712
36085, 4702, 4703, 4714, 4713
36086, 4703, 4704, 4715, 4714
36087, 4704, 4705, 4716, 4715
36088, 4705, 4706, 4717, 4716
36089, 4706, 4707, 4718, 4717
36090, 4707, 4708, 4719, 4718
36091, 4708, 4709, 4720, 4719
36092, 4709, 4710, 4721, 4720
36093, 4710, 4711, 4722, 4721
36094, 4711, 507, 508, 4722
36095, 474, 4712, 4723, 475
36096, 4712, 4713, 4724, 4723
36097, 4713, 4714, 4725, 4724
36098, 4714, 4715, 4726, 4725
36099, 4715, 4716, 4727, 4726
36100, 4716, 4717, 4728, 4727
36101, 4717, 4718, 4729, 4728
36102, 4718, 4719, 4730, 4729
36103, 4719, 4720, 4731, 4730
36104, 4720, 4721, 4732, 4731
36105, 4721, 4722, 4733, 4732
36106, 4722, 508, 509, 4733
36107, 475, 4723, 4734, 476
36108, 4723, 4724, 4735, 4734
36109, 4724, 4725, 4736, 4735
36110, 4725, 4726, 4737, 4736
36111, 4726, 4727, 4738, 4737
36112, 4727, 4728, 4739, 4738
36113, 4728, 4729, 4740, 4739
36114, 4729, 4730, 4741, 4740
36115, 4730, 4731, 4742, 4741
36116, 4731, 4732, 4743, 4742
36117, 4732, 4733, 4744, 4743
36118, 4733, 509, 510, 4744
36119, 476, 4734, 4745, 477
36120, 4734, 4735, 4746, 4745
36121, 4735, 4736, 4747, 4746
36122, 4736, 4737, 4748, 4747
36123, 4737, 4738, 4749, 4748
36124, 4738, 4739, 4750, 4749
36125, 4739, 4740, 4751, 4750
36126, 4740, 4741, 4752, 4751
36127, 4741, 4742, 4753, 4752
36128, 4742, 4743, 4754, 4753
36129, 4743, 4744, 4755, 4754
36130, 4744, 510, 511, 4755
36131, 477, 4745, 4756, 478
36132, 4745, 4746, 4757, 4756
36133, 4746, 4747, 4758, 4757
36134, 4747, 4748, 4759, 4758
36135, 4748, 4749, 4760, 4759
36136, 4749, 4750, 4761, 4760
36137, 4750, 4751, 4762, 4761
36138, 4751, 4752, 4763, 4762
36139, 4752, 4753, 4764, 4763
36140, 4753, 4754, 4765, 4764
36141, 4754, 4755, 4766, 4765
36142, 4755, 511, 512, 4766
36143, 478, 4756, 4767, 479
36144, 4756, 4757, 4768, 4767
36145, 4757, 4758, 4769, 4768
36146, 4758, 4759, 4770, 4769
36147, 4759, 4760, 4771, 4770
36148, 4760, 4761, 4772, 4771
36149, 4761, 4762, 4773, 4772
36150, 4762, 4763, 4774, 4773
36151, 4763, 4764, 4775, 4774
36152, 4764, 4765, 4776, 4775
36153, 4765, 4766, 4777, 4776
36154, 4766, 512, 513, 4777
36155, 479, 4767, 4778, 480
36156, 4767, 4768, 4779, 4778
36157, 4768, 4769, 4780, 4779
36158, 4769, 4770, 4781, 4780
36159, 4770, 4771, 4782, 4781
36160, 4771, 4772, 4783, 4782
36161, 4772, 4773, 4784, 4783
36162, 4773, 4774, 4785, 4784
36163, 4774, 4775, 4786, 4785
36164, 4775, 4776, 4787, 4786
36165, 4776, 4777, 4788, 4787
36166, 4777, 513, 514, 4788
36167, 480, 4778, 4789, 481
36168, 4778, 4779, 4790, 4789
36169, 4779, 4780, 4791, 4790
36170, 4780, 4781, 4792, 4791
36171, 4781, 4782, 4793, 4792
36172, 4782, 4783, 4794, 4793
36173, 4783, 4784, 4795, 4794
36174, 4784, 4785, 4796, 4795
36175, 4785, 4786, 4797, 4796
36176, 4786, 4787, 4798, 4797
36177, 4787, 4788, 4799, 4798
36178, 4788, 514, 515, 4799
36179, 481, 4789, 4800, 482
36180, 4789, 4790, 4801, 4800
36181, 4790, 4791, 4802, 4801
36182, 4791, 4792, 4803, 4802
36183, 4792, 4793, 4804, 4803
36184, 4793, 4794, 4805, 4804
36185, 4794, 4795, 4806, 4805
36186, 4795, 4796, 4807, 4806
36187, 4796, 4797, 4808, 4807
36188, 4797, 4798, 4809, 4808
36189, 4798, 4799, 4810, 4809
36190, 4799, 515, 516, 4810
36191, 482, 4800, 4811, 483
36192, 4800, 4801, 4812, 4811
36193, 4801, 4802, 4813, 4812
36194, 4802, 4803, 4814, 4813
36195, 4803, 4804, 4815, 4814
36196, 4804, 4805, 4816, 4815
36197, 4805, 4806, 4817, 4816
36198, 4806, 4807, 4818, 4817
36199, 4807, 4808, 4819, 4818
36200, 4808, 4809, 4820, 4819
36201, 4809, 4810, 4821, 4820
36202, 4810, 516, 517, 4821
36203, 483, 4811, 4822, 484
36204, 4811, 4812, 4823, 4822
36205, 4812, 4813, 4824, 4823
36206, 4813, 4814, 4825, 4824
36207, 4814, 4815, 4826, 4825
36208, 4815, 4816, 4827, 4826
36209, 4816, 4817, 4828, 4827
36210, 4817, 4818, 4829, 4828
36211, 4818, 4819, 4830, 4829
36212, 4819, 4820, 4831, 4830
36213, 4820, 4821, 4832, 4831
36214, 4821, 517, 518, 4832
36215, 484, 4822, 4833, 485
36216, 4822, 4823, 4834, 4833
36217, 4823, 4824, 4835, 4834
36218, 4824, 4825, 4836, 4835
36219, 4825, 4826, 4837, 4836
36220, 4826, 4827, 4838, 4837
36221, 4827, 4828, 4839, 4838
36222, 4828, 4829, 4840, 4839
36223, 4829, 4830, 4841, 4840
36224, 4830, 4831, 4842, 4841
36225, 4831, 4832, 4843, 4842
36226, 4832, 518, 519, 4843
36227, 485, 4833, 4844, 486
36228, 4833, 4834, 4845, 4844
36229, 4834, 4835, 4846, 4845
36230, 4835, 4836, 4847, 4846
36231, 4836, 4837, 4848, 4847
36232, 4837, 4838, 4849, 4848
36233, 4838, 4839, 4850, 4849
36234, 4839, 4840, 4851, 4850
36235, 4840, 4841, 4852, 4851
36236, 4841, 4842, 4853, 4852
36237, 4842, 4843, 4854, 4853
36238, 4843, 519, 520, 4854
36239, 486, 4844, 4855, 487
36240, 4844, 4845, 4856, 4855
36241, 4845, 4846, 4857, 4856
36242, 4846, 4847, 4858, 4857
36243, 4847, 4848, 4859, 4858
36244, 4848, 4849, 4860, 4859
36245, 4849, 4850, 4861, 4860
36246, 4850, 4851, 4862, 4861
36247, 4851, 4852, 4863, 4862
36248, 4852, 4853, 4864, 4863
36249, 4853, 4854, 4865, 4864
36250, 4854, 520, 521, 4865
36251, 487, 4855, 4866, 488
36252, 4855, 4856, 4867, 4866
36253, 4856, 4857, 4868, 4867
36254, 4857, 4858, 4869, 4868
36255, 4858, 4859, 4870, 4869
36256, 4859, 4860, 4871, 4870
36257, 4860, 4861, 4872, 4871
36258, 4861, 4862, 4873, 4872
36259, 4862, 4863, 4874, 4873
36260, 4863, 4864, 4875, 4874
36261, 4864, 4865, 4876, 4875
36262, 4865, 521, 522, 4876
36263, 488, 4866, 4877, 489
36264, 4866, 4867, 4878, 4877
36265, 4867, 4868, 4879, 4878
36266, 4868, 4869, 4880, 4879
36267, 4869, 4870, 4881, 4880
36268, 4870, 4871, 4882, 4881
36269, 4871, 4872, 4883, 4882
36270, 4872, 4873, 4884, 4883
36271, 4873, 4874, 4885, 4884
36272, 4874, 4875, 4886, 4885
36273, 4875, 4876, 4887, 4886
36274, 4876, 522, 523, 4887
36275, 489, 4877, 4888, 490
36276, 4877, 4878, 4889, 4888
36277, 4878, 4879, 4890, 4889
36278, 4879, 4880, 4891, 4890
36279, 4880, 4881, 4892, 4891
36280, 4881, 4882, 4893, 4892
36281, 4882, 4883, 4894, 4893
36282, 4883, 4884, 4895, 4894
36283, 4884, 4885, 4896, 4895
36284, 4885, 4886, 4897, 4896
36285, 4886, 4887, 4898, 4897
36286, 4887, 523, 524, 4898
36287, 490, 4888, 4899, 491
36288, 4888, 4889, 4900, 4899
36289, 4889, 4890, 4901, 4900
36290, 4890, 4891, 4902, 4901
36291, 4891, 4892, 4903, 4902
36292, 4892, 4893, 4904, 4903
36293, 4893, 4894, 4905, 4904
36294, 4894, 4895, 4906, 4905
36295, 4895, 4896, 4907, 4906
36296, 4896, 4897, 4908, 4907
36297, 4897, 4898, 4909, 4908
36298, 4898, 524, 525, 4909
36299, 491, 4899, 492, 17
36300, 4899, 4900, 493, 492
36301, 4900, 4901, 494, 493
36302, 4901, 4902, 495, 494
36303, 4902, 4903, 496, 495
36304, 4903, 4904, 497, 496
36305, 4904, 4905, 498, 497
36306, 4905, 4906, 499, 498
36307, 4906, 4907, 500, 499
36308, 4907, 4908, 501, 500
36309, 4908, 4909, 502, 501
36310, 4909, 525, 19, 502
*ELEMENT, type=CPS4, ELSET=Surface22
36311, 18, 539, 4910, 469
36312, 539, 540, 4911, 4910
36313, 540, 22, 541, 4911
36314, 469, 4910, 4912, 470
36315, 4910, 4911, 4913, 4912
36316, 4911, 541, 542, 4913
36317, 470, 4912, 4914, 471
36318, 4912, 4913, 4915, 4914
36319, 4913, 542, 543, 4915
36320, 471, 4914, 4916, 472
36321, 4914, 4915, 4917, 4916
36322, 4915, 543, 544, 4917
36323, 472, 4916, 4918, 473
36324, 4916, 4917, 4919, 4918
36325, 4917, 544, 545, 4919
36326, 473, 4918, 4920, 474
36327, 4918, 4919, 4921, 4920
36328, 4919, 545, 546, 4921
36329, 474, 4920, 4922, 475
36330, 4920, 4921, 4923, 4922
36331, 4921, 546, 547, 4923
36332, 475, 4922, 4924, 476
36333, 4922, 4923, 4925, 4924
36334, 4923, 547, 548, 4925
36335, 476, 4924, 4926, 477
36336, 4924, 4925, 4927, 4926
36337, 4925, 548, 549, 4927
36338, 477, 4926, 4928, 478
36339, 4926, 4927, 4929, 4928
36340, 4927, 549, 550, 4929
36341, 478, 4928, 4930, 479
36342, 4928, 4929, 4931, 4930
36343, 4929, 550, 551, 4931
36344, 479, 4930, 4932, 480
36345, 4930, 4931, 4933, 4932
36346, 4931, 551, 552, 4933
36347, 480, 4932, 4934, 481
36348, 4932, 4933, 4935, 4934
36349, 4933, 552, 553, 4935
36350, 481, 4934, 4936, 482
36351, 4934, 4935, 4937, 4936
36352, 4935, 553, 554, 4937
36353, 482, 4936, 4938, 483
36354, 4936, 4937, 4939, 4938
36355, 4937, 554, 555, 4939
36356, 483, 4938, 4940, 484
36357, 4938, 4939, 4941, 4940
36358, 4939, 555, 556, 4941
36359, 484, 4940, 4942, 485
36360, 4940, 4941, 4943, 4942
36361, 4941, 556, 557, 4943
36362, 485, 4942, 4944, 486
36363, 4942, 4943, 4945, 4944
36364, 4943, 557, 558, 4945
36365, 486, 4944, 4946, 487
36366, 4944, 4945, 4947, 4946
36367, 4945, 558, 559, 4947
36368, 487, 4946, 4948, 488
36369, 4946, 4947, 4949, 4948
36370, 4947, 559, 560, 4949
36371, 488, 4948, 4950, 489
36372, 4948, 4949, 4951, 4950
36373, 4949, 560, 561, 4951
36374, 489, 4950, 4952, 490
36375, 4950, 4951, 4953, 4952
36376, 4951, 561, 562, 4953
36377, 490, 4952, 4954, 491
36378, 4952, 4953, 4955, 4954
36379, 4953, 562, 563, 4955
36380, 491, 4954, 537, 17
36381, 4954, 4955, 538, 537
36382, 4955, 563, 21, 538
*ELEMENT, type=CPS4, ELSET=Surface23
36383, 17, 537, 4956, 492
36384, 537, 538, 4957, 4956
36385, 538, 21, 566, 4957
36386, 492, 4956, 4958, 493
36387, 4956, 4957, 4959, 4958
36388, 4957, 566, 567, 4959
36389, 493, 4958, 4960, 494
36390, 4958, 4959, 4961, 4960
36391, 4959, 567, 568, 4961
36392, 494, 4960, 4962, 495
36393, 4960, 4961, 4963, 4962
36394, 4961, 568, 569, 4963
36395, 495, 4962, 4964, 496
36396, 4962, 4963, 4965, 4964
36397, 4963, 569, 570, 4965
36398, 496, 4964, 4966, 497
36399, 4964, 4965, 4967, 4966
36400, 4965, 570, 571, 4967
36401, 497, 4966, 4968, 498
36402, 4966, 4967, 4969, 4968
36403, 4967, 571, 572, 4969
36404, 498, 4968, 4970, 499
36405, 4968, 4969, 4971, 4970
36406, 4969, 572, 573, 4971
36407, 499, 4970, 4972, 500
36408, 4970, 4971, 4973, 4972
36409, 4971, 573, 574, 4973
36410, 500, 4972, 4974, 501
36411, 4972, 4973, 4975, 4974
36412, 4973, 574, 575, 4975
36413, 501, 4974, 4976, 502
36414, 4974, 4975, 4977, 4976
36415, 4975, 575, 576, 4977
36416, 502, 4976, 564, 19
36417, 4976, 4977, 565, 564
36418, 4977, 576, 23, 565
*ELEMENT, type=CPS4, ELSET=Surface24
1382, 20, 503, 4978, 577
1383, 577, 4978, 4979, 578
1384, 578, 4979, 579, 24
1385, 503, 504, 4980, 4978
1386, 4978, 4980, 4981, 4979
1387, 4979, 4981, 580, 579
1388, 504, 505, 4982, 4980
1389, 4980, 4982, 4983, 4981
1390, 4981, 4983, 581, 580
1391, 505, 506, 4984, 4982
1392, 4982, 4984, 4985, 4983
1393, 4983, 4985, 582, 581
1394, 506, 507, 4986, 4984
1395, 4984, 4986, 4987, 4985
1396, 4985, 4987, 583, 582
1397, 507, 508, 4988, 4986
1398, 4986, 4988, 4989, 4987
1399, 4987, 4989, 584, 583
1400, 508, 509, 4990, 4988
1401, 4988, 4990, 4991, 4989
1402, 4989, 4991, 585, 584
1403, 509, 510, 4992, 4990
1404, 4990, 4992, 4993, 4991
1405, 4991, 4993, 586, 585
1406, 510, 511, 4994, 4992
1407, 4992, 4994, 4995, 4993
1408, 4993, 4995, 587, 586
1409, 511, 512, 4996, 4994
1410, 4994, 4996, 4997, 4995
1411, 4995, 4997, 588, 587
1412, 512, 513, 4998, 4996
1413, 4996, 4998, 4999, 4997
1414, 4997, 4999, 589, 588
1415, 513, 514, 5000, 4998
1416, 4998, 5000, 5001, 4999
1417, 4999, 5001, 590, 589
1418, 514, 515, 5002, 5000
1419, 5000, 5002, 5003, 5001
1420, 5001, 5003, 591, 590
1421, 515, 516, 5004, 5002
1422, 5002, 5004, 5005, 5003
1423, 5003, 5005, 592, 591
1424, 516, 517, 5006, 5004
1425, 5004, 5006, 5007, 5005
1426, 5005, 5007, 593, 592
1427, 517, 518, 5008, 5006
1428, 5006, 5008, 5009, 5007
1429, 5007, 5009, 594, 593
1430, 518, 519, 5010, 5008
1431, 5008, 5010, 5011, 5009
1432, 5009, 5011, 595, 594
1433, 519, 520, 5012, 5010
1434, 5010, 5012, 5013, 5011
1435, 5011, 5013, 596, 595
1436, 520, 521, 5014, 5012
1437, 5012, 5014, 5015, 5013
1438, 5013, 5015, 597, 596
1439, 521, 522, 5016, 5014
1440, 5014, 5016, 5017, 5015
1441, 5015, 5017, 598, 597
1442, 522, 523, 5018, 5016
1443, 5016, 5018, 5019, 5017
1444, 5017, 5019, 599, 598
1445, 523, 524, 5020, 5018
1446, 5018, 5020, 5021, 5019
1447, 5019, 5021, 600, 599
1448, 524, 525, 5022, 5020
1449, 5020, 5022, 5023, 5021
1450, 5021, 5023, 601, 600
1451, 525, 19, 564, 5022
1452, 5022, 564, 565, 5023
1453, 5023, 565, 23, 601
*ELEMENT, type=CPS4, ELSET=Surface25
1454, 18, 526, 5024, 539
1455, 539, 5024, 5025, 540
1456, 540, 5025, 602, 22
1457, 526, 527, 5026, 5024
1458, 5024, 5026, 5027, 5025
1459, 5025, 5027, 603, 602
1460, 527, 528, 5028, 5026
1461, 5026, 5028, 5029, 5027
1462, 5027, 5029, 604, 603
1463, 528, 529, 5030, 5028
1464, 5028, 5030, 5031, 5029
1465, 5029, 5031, 605, 604
1466, 529, 530, 5032, 5030
1467, 5030, 5032, 5033, 5031
1468, 5031, 5033, 606, 605
1469, 530, 531, 5034, 5032
1470, 5032, 5034, 5035, 5033
1471, 5033, 5035, 607, 606
1472, 531, 532, 5036, 5034
1473, 5034, 5036, 5037, 5035
1474, 5035, 5037, 608, 607
1475, 532, 533, 5038, 5036
1476, 5036, 5038, 5039, 5037
1477, 5037, 5039, 609, 608
1478, 533, 534, 5040, 5038
1479, 5038, 5040, 5041, 5039
1480, 5039, 5041, 610, 609
1481, 534, 535, 5042, 5040
1482, 5040, 5042, 5043, 5041
1483, 5041, 5043, 611, 610
1484, 535, 536, 5044, 5042
1485, 5042, 5044, 5045, 5043
1486, 5043, 5045, 612, 611
1487, 536, 20, 577, 5044
1488, 5044, 577, 578, 5045
1489, 5045, 578, 24, 612
*ELEMENT, type=CPS4, ELSET=Surface26
1490, 22, 602, 5046, 541
1491, 602, 603, 5047, 5046
1492, 603, 604, 5048, 5047
1493, 604, 605, 5049, 5048
1494, 605, 606, 5050, 5049
1495, 606, 607, 5051, 5050
1496, 607, 608, 5052, 5051
1497, 608, 609, 5053, 5052
1498, 609, 610, 5054, 5053
1499, 610, 611, 5055, 5054
1500, 611, 612, 5056, 5055
1501, 612, 24, 579, 5056
1502, 541, 5046, 5057, 542
1503, 5046, 5047, 5058, 5057
1504, 5047, 5048, 5059, 5058
1505, 5048, 5049, 5060, 5059
1506, 5049, 5050, 5061, 5060
1507, 5050, 5051, 5062, 5061
1508, 5051, 5052, 5063, 5062
1509, 5052, 5053, 5064, 5063
1510, 5053, 5054, 5065, 5064
1511, 5054, 5055, 5066, 5065
1512, 5055, 5056, 5067, 5066
1513, 5056, 579, 580, 5067
1514, 542, 5057, 5068, 543
1515, 5057, 5058, 5069, 5068
1516, 5058, 5059, 5070, 5069
1517, 5059, 5060, 5071, 5070
1518, 5060, 5061, 5072, 5071
1519, 5061, 5062, 5073, 5072
1520, 5062, 5063, 5074, 5073
1521, 5063, 5064, 5075, 5074
1522, 5064, 5065, 5076, 5075
1523, 5065, 5066, 5077, 5076
1524, 5066, 5067, 5078, 5077
1525, 5067, 580, 581, 5078
1526, 543, 5068, 5079, 544
1527, 5068, 5069, 5080, 5079
1528, 5069, 5070, 5081, 5080
1529, 5070, 5071, 5082, 5081
1530, 5071, 5072, 5083, 5082
1531, 5072, 5073, 5084, 5083
1532, 5073, 5074, 5085, 5084
1533, 5074, 5075, 5086, 5085
1534, 5075, 5076, 5087, 5086
1535, 5076, 5077, 5088, 5087
1536, 5077, 5078, 5089, 5088
1537, 5078, 581, 582, 5089
1538, 544, 5079, 5090, 545
1539, 5079, 5080, 5091, 5090
1540, 5080, 5081, 5092, 5091
1541, 5081, 5082, 5093, 5092
1542, 5082, 5083, 5094, 5093
1543, 5083, 5084, 5095, 5094
1544, 5084, 5085, 5096, 5095
1545, 5085, 5086, 5097, 5096
1546, 5086, 5087, 5098, 5097
1547, 5087, 5088, 5099, 5098
1548, 5088, 5089, 5100, 5099
1549, 5089, 582, 583, 5100
1550, 545, 5090, 5101, 546
1551, 5090, 5091, 5102, 5101
1552, 5091, 5092, 5103, 5102
1553, 5092, 5093, 5104, 5103
1554, 5093, 5094, 5105, 5104
1555, 5094, 5095, 5106, 5105
1556, 5095, 5096, 5107, 5106
1557, 5096, 5097, 5108, 5107
1558, 5097, 5098, 5109, 5108
1559, 5098, 5099, 5110, 5109
1560, 5099, 5100, 5111, 5110
1561, 5100, 583, 584, 5111
1562, 546, 5101, 5112, 547
1563, 5101, 5102, 5113, 5112
1564, 5102, 5103, 5114, 5113
1565, 5103, 5104, 5115, 5114
1566, 5104, 5105, 5116, 5115
1567, 5105, 5106, 5117, 5116
1568, 5106, 5107, 5118, 5117
1569, 5107, 5108, 5119, 5118
1570, 5108, 5109, 5120, 5119
1571, 5109, 5110, 5121, 5120
1572, 5110, 5111, 5122, 5121
1573, 5111, 584, 585, 5122
1574, 547, 5112, 5123, 548
1575, 5112, 5113, 5124, 5123
1576, 5113, 5114, 5125, 5124
1577, 5114, 5115, 5126, 5125
1578, 5115, 5116, 5127, 5126
1579, 5116, 5117, 5128, 5127
1580, 5117, 5118, 5129, 5128
1581, 5118, 5119, 5130, 5129
1582, 5119, 5120, 5131, 5130
1583, 5120, 5121, 5132, 5131
1584, 5121, 5122, 5133, 5132
1585, 5122, 585, 586, 5133
1586, 548, 5123, 5134, 549
1587, 5123, 5124, 5135, 5134
1588, 5124, 5125, 5136, 5135
1589, 5125, 5126, 5137, 5136
1590, 5126, 5127, 5138, 5137
1591, 5127, 5128, 5139, 5138
1592, 5128, 5129, 5140, 5139
1593, 5129, 5130, 5141, 5140
1594, 5130, 5131, 5142, 5141
1595, 5131, 5132, 5143, 5142
1596, 5132, 5133, 5144, 5143
1597, 5133, 586, 587, 5144
1598, 549, 5134, 5145, 550
1599, 5134, 5135, 5146, 5145
1600, 5135, 5136, 5147, 5146
1601, 5136, 5137, 5148, 5147
1602, 5137, 5138, 5149, 5148
1603, 5138, 5139, 5150, 5149
1604, 5139, 5140, 5151, 5150
1605, 5140, 5141, 5152, 5151
1606, 5141, 5142, 5153, 5152
1607, 5142, 5143, 5154, 5153
1608, 5143, 5144, 5155, 5154
1609, 5144, 587, 588, 5155
1610, 550, 5145, 5156, 551
1611, 5145, 5146, 5157, 5156
1612, 5146, 5147, 5158, 5157
1613, 5147, 5148, 5159, 5158
1614, 5148, 5149, 5160, 5159
1615, 5149, 5150, 5161, 5160
1616, 5150, 5151, 5162, 5161
1617, 5151, 5152, 5163, 5162
1618, 5152, 5153, 5164, 5163
1619, 5153, 5154, 5165, 5164
1620, 5154, 5155, 5166, 5165
1621, 5155, 588, 589, 5166
1622, 551, 5156, 5167, 552
1623, 5156, 5157, 5168, 5167
1624, 5157, 5158, 5169, 5168
1625, 5158, 5159, 5170, 5169
1626, 5159, 5160, 5171, 5170
1627, 5160, 5161, 5172, 5171
1628, 5161, 5162, 5173, 5172
1629, 5162, 5163, 5174, 5173
1630, 5163, 5164, 5175, 5174
1631, 5164, 5165, 5176, 5175
1632, 5165, 5166, 5177, 5176
1633, 5166, 589, 590, 5177
1634, 552, 5167, 5178, 553
1635, 5167, 5168, 5179, 5178
1636, 5168, 5169, 5180, 5179
1637, 5169, 5170, 5181, 5180
1638, 5170, 5171, 5182, 5181
1639, 5171, 5172, 5183, 5182
1640, 5172, 5173, 5184, 5183
1641, 5173, 5174, 5185, 5184
1642, 5174, 5175, 5186, 5185
1643, 5175, 5176, 5187, 5186
1644, 5176, 5177, 5188, 5187
1645, 5177, 590, 591, 5188
1646, 553, 5178, 5189, 554
1647, 5178, 5179, 5190, 5189
1648, 5179, 5180, 5191, 5190
1649, 5180, 5181, 5192, 5191
1650, 5181, 5182, 5193, 5192
1651, 5182, 5183, 5194, 5193
1652, 5183, 5184, 5195, 5194
1653, 5184, 5185, 5196, 5195
1654, 5185, 5186, 5197, 5196
1655, 5186, 5187, 5198, 5197
1656, 5187, 5188, 5199, 5198
1657, 5188, 591, 592, 5199
1658, 554, 5189, 5200, 555
1659, 5189, 5190, 5201, 5200
1660, 5190, 5191, 5202, 5201
1661, 5191, 5192, 5203, 5202
1662, 5192, 5193, 5204, 5203
1663, 5193, 5194, 5205, 5204
1664, 5194, 5195, 5206, 5205
1665, 5195, 5196, 5207, 5206
1666, 5196, 5197, 5208, 5207
1667, 5197, 5198, 5209, 5208
1668, 5198, 5199, 5210, 5209
1669, 5199, 592, 593, 5210
1670, 555, 5200, 5211, 556
1671, 5200, 5201, 5212, 5211
1672, 5201, 5202, 5213, 5212
1673, 5202, 5203, 5214, 5213
1674, 5203, 5204, 5215, 5214
1675, 5204, 5205, 5216, 5215
1676, 5205, 5206, 5217, 5216
1677, 5206, 5207, 5218, 5217
1678, 5207, 5208, 5219, 5218
1679, 5208, 5209, 5220, 5219
1680, 5209, 5210, 5221, 5220
1681, 5210, 593, 594, 5221
1682, 556, 5211, 5222, 557
1683, 5211, 5212, 5223, 5222
1684, 5212, 5213, 5224, 5223
1685, 5213, 5214, 5225, 5224
1686, 5214, 5215, 5226, 5225
1687, 5215, 5216, 5227, 5226
1688, 5216, 5217, 5228, 5227
1689, 5217, 5218, 5229, 5228
1690, 5218, 5219, 5230, 5229
1691, 5219, 5220, 5231, 5230
1692, 5220, 5221, 5232, 5231
1693, 5221, 594, 595, 5232
1694, 557, 5222, 5233, 558
1695, 5222, 5223, 5234, 5233
1696, 5223, 5224, 5235, 5234
1697, 5224, 5225, 5236, 5235
1698, 5225, 5226, 5237, 5236
1699, 5226, 5227, 5238, 5237
1700, 5227, 5228, 5239, 5238
1701, 5228, 5229, 5240, 5239
1702, 5229, 5230, 5241, 5240
1703, 5230, 5231, 5242, 5241
1704, 5231, 5232, 5243, 5242
1705, 5232, 595, 596, 5243
1706, 558, 5233, 5244, 559
1707, 5233, 5234, 5245, 5244
1708, 5234, 5235, 5246, 5245
1709, 5235, 5236, 5247, 5246
1710, 5236, 5237, 5248, 5247
1711, 5237, 5238, 5249, 5248
1712, 5238, 5239, 5250, 5249
1713, 5239, 5240, 5251, 5250
1714, 5240, 5241, 5252, 5251
1715, 5241, 5242, 5253, 5252
1716, 5242, 5243, 5254, 5253
1717, 5243, 596, 597, 5254
1718, 559, 5244, 5255, 560
1719, 5244, 5245, 5256, 5255
1720, 5245, 5246, 5257, 5256
1721, 5246, 5247, 5258, 5257
1722, 5247, 5248, 5259, 5258
1723, 5248, 5249, 5260, 5259
1724, 5249, 5250, 5261, 5260
1725, 5250, 5251, 5262, 5261
1726, 5251, 5252, 5263, 5262
1727, 5252, 5253, 5264, 5263
1728, 5253, 5254, 5265, 5264
1729, 5254, 597, 598, 5265
1730, 560, 5255, 5266, 561
1731, 5255, 5256, 5267, 5266
1732, 5256, 5257, 5268, 5267
1733, 5257, 5258, 5269, 5268
1734, 5258, 5259, 5270, 5269
1735, 5259, 5260, 5271, 5270
1736, 5260, 5261, 5272, 5271
1737, 5261, 5262, 5273, 5272
1738, 5262, 5263, 5274, 5273
1739, 5263, 5264, 5275, 5274
1740, 5264, 5265, 5276, 5275
1741, 5265, 598, 599, 5276
1742, 561, 5266, 5277, 562
1743, 5266, 5267, 5278, 5277
1744, 5267, 5268, 5279, 5278
1745, 5268, 5269, 5280, 5279
1746, 5269, 5270, 5281, 5280
1747, 5270, 5271, 5282, 5281
1748, 5271, 5272, 5283, 5282
1749, 5272, 5273, 5284, 5283
1750, 5273, 5274, 5285, 5284
1751, 5274, 5275, 5286, 5285
1752, 5275, 5276, 5287, 5286
1753, 5276, 599, 600, 5287
1754, 562, 5277, 5288, 563
1755, 5277, 5278, 5289, 5288
1756, 5278, 5279, 5290, 5289
1757, 5279, 5280, 5291, 5290
1758, 5280, 5281, 5292, 5291
1759, 5281, 5282, 5293, 5292
1760, 5282, 5283, 5294, 5293
1761, 5283, 5284, 5295, 5294
1762, 5284, 5285, 5296, 5295
1763, 5285, 5286, 5297, 5296
1764, 5286, 5287, 5298, 5297
1765, 5287, 600, 601, 5298
1766, 563, 5288, 566, 21
1767, 5288, 5289, 567, 566
1768, 5289, 5290, 568, 567
1769, 5290, 5291, 569, 568
1770, 5291, 5292, 570, 569
1771, 5292, 5293, 571, 570
1772, 5293, 5294, 572, 571
1773, 5294, 5295, 573, 572
1774, 5295, 5296, 574, 573
1775, 5296, 5297, 575, 574
1776, 5297, 5298, 576, 575
1777, 5298, 601, 23, 576
*ELEMENT, type=CPS4, ELSET=Surface27
1778, 19, 613, 5299, 564
1779, 613, 614, 5300, 5299
1780, 614, 615, 5301, 5300
1781, 615, 616, 5302, 5301
1782, 616, 25, 621, 5302
1783, 564, 5299, 5303, 565
1784, 5299, 5300, 5304, 5303
1785, 5300, 5301, 5305, 5304
1786, 5301, 5302, 5306, 5305
1787, 5302, 621, 622, 5306
1788, 565, 5303, 617, 23
1789, 5303, 5304, 618, 617
1790, 5304, 5305, 619, 618
1791, 5305, 5306, 620, 619
1792, 5306, 622, 26, 620
*ELEMENT, type=CPS4, ELSET=Surface28
36419, 17, 537, 5307, 623
36420, 623, 5307, 5308, 624
36421, 624, 5308, 5309, 625
36422, 625, 5309, 5310, 626
36423, 626, 5310, 631, 27
36424, 537, 538, 5311, 5307
36425, 5307, 5311, 5312, 5308
36426, 5308, 5312, 5313, 5309
36427, 5309, 5313, 5314, 5310
36428, 5310, 5314, 632, 631
36429, 538, 21, 627, 5311
36430, 5311, 627, 628, 5312
36431, 5312, 628, 629, 5313
36432, 5313, 629, 630, 5314
36433, 5314, 630, 28, 632
*ELEMENT, type=CPS4, ELSET=Surface29
36434, 17, 623, 5315, 492
36435, 623, 624, 5316, 5315
36436, 624, 625, 5317, 5316
36437, 625, 626, 5318, 5317
36438, 626, 27, 633, 5318
36439, 492, 5315, 5319, 493
36440, 5315, 5316, 5320, 5319
36441, 5316, 5317, 5321, 5320
36442, 5317, 5318, 5322, 5321
36443, 5318, 633, 634, 5322
36444, 493, 5319, 5323, 494
36445, 5319, 5320, 5324, 5323
36446, 5320, 5321, 5325, 5324
36447, 5321, 5322, 5326, 5325
36448, 5322, 634, 635, 5326
36449, 494, 5323, 5327, 495
36450, 5323, 5324, 5328, 5327
36451, 5324, 5325, 5329, 5328
36452, 5325, 5326, 5330, 5329
36453, 5326, 635, 636, 5330
36454, 495, 5327, 5331, 496
36455, 5327, 5328, 5332, 5331
36456, 5328, 5329, 5333, 5332
36457, 5329, 5330, 5334, 5333
36458, 5330, 636, 637, 5334
36459, 496, 5331, 5335, 497
36460, 5331, 5332, 5336, 5335
36461, 5332, 5333, 5337, 5336
36462, 5333, 5334, 5338, 5337
36463, 5334, 637, 638, 5338
36464, 497, 5335, 5339, 498
36465, 5335, 5336, 5340, 5339
36466, 5336, 5337, 5341, 5340
36467, 5337, 5338, 5342, 5341
36468, 5338, 638, 639, 5342
36469, 498, 5339, 5343, 499
36470, 5339, 5340, 5344, 5343
36471, 5340, 5341, 5345, 5344
36472, 5341, 5342, 5346, 5345
36473, 5342, 639, 640, 5346
36474, 499, 5343, 5347, 500
36475, 5343, 5344, 5348, 5347
36476, 5344, 5345, 5349, 5348
36477, 5345, 5346, 5350, 5349
36478, 5346, 640, 641, 5350
36479, 500, 5347, 5351, 501
36480, 5347, 5348, 5352, 5351
36481, 5348, 5349, 5353, 5352
36482, 5349, 5350, 5354, 5353
36483, 5350, 641, 642, 5354
36484, 501, 5351, 5355, 502
36485, 5351, 5352, 5356, 5355
36486, 5352, 5353, 5357, 5356
36487, 5353, 5354, 5358, 5357
36488, 5354, 642, 643, 5358
36489, 502, 5355, 613, 19
36490, 5355, 5356, 614, 613
36491, 5356, 5357, 615, 614
36492, 5357, 5358, 616, 615
36493, 5358, 643, 25, 616
*ELEMENT, type=CPS4, ELSET=Surface30
1793, 21, 566, 5359, 627
1794, 627, 5359, 5360, 628
1795, 628, 5360, 5361, 629
1796, 629, 5361, 5362, 630
1797, 630, 5362, 644, 28
1798, 566, 567, 5363, 5359
1799, 5359, 5363, 5364, 5360
1800, 5360, 5364, 5365, 5361
1801, 5361, 5365, 5366, 5362
1802, 5362, 5366, 645, 644
1803, 567, 568, 5367, 5363
1804, 5363, 5367, 5368, 5364
1805, 5364, 5368, 5369, 5365
1806, 5365, 5369, 5370, 5366
1807, 5366, 5370, 646, 645
1808, 568, 569, 5371, 5367
1809, 5367, 5371, 5372, 5368
1810, 5368, 5372, 5373, 5369
1811, 5369, 5373, 5374, 5370
1812, 5370, 5374, 647, 646
1813, 569, 570, 5375, 5371
1814, 5371, 5375, 5376, 5372
1815, 5372, 5376, 5377, 5373
1816, 5373, 5377, 5378, 5374
1817, 5374, 5378, 648, 647
1818, 570, 571, 5379, 5375
1819, 5375, 5379, 5380, 5376
1820, 5376, 5380, 5381, 5377
1821, 5377, 5381, 5382, 5378
1822, 5378, 5382, 649, 648
1823, 571, 572, 5383, 5379
1824, 5379, 5383, 5384, 5380
1825, 5380, 5384, 5385, 5381
1826, 5381, 5385, 5386, 5382
1827, 5382, 5386, 650, 649
1828, 572, 573, 5387, 5383
1829, 5383, 5387, 5388, 5384
1830, 5384, 5388, 5389, 5385
1831, 5385, 5389, 5390, 5386
1832, 5386, 5390, 651, 650
1833, 573, 574, 5391, 5387
1834, 5387, 5391, 5392, 5388
1835, 5388, 5392, 5393, 5389
1836, 5389, 5393, 5394, 5390
1837, 5390, 5394, 652, 651
1838, 574, 575, 5395, 5391
1839, 5391, 5395, 5396, 5392
1840, 5392, 5396, 5397, 5393
1841, 5393, 5397, 5398, 5394
1842, 5394, 5398, 653, 652
1843, 575, 576, 5399, 5395
1844, 5395, 5399, 5400, 5396
1845, 5396, 5400, 5401, 5397
1846, 5397, 5401, 5402, 5398
1847, 5398, 5402, 654, 653
1848, 576, 23, 617, 5399
1849, 5399, 617, 618, 5400
1850, 5400, 618, 619, 5401
1851, 5401, 619, 620, 5402
1852, 5402, 620, 26, 654
*ELEMENT, type=CPS4, ELSET=Surface31
36494, 27, 631, 5403, 633
36495, 631, 632, 5404, 5403
36496, 632, 28, 644, 5404
36497, 633, 5403, 5405, 634
36498, 5403, 5404, 5406, 5405
36499, 5404, 644, 645, 5406
36500, 634, 5405, 5407, 635
36501, 5405, 5406, 5408, 5407
36502, 5406, 645, 646, 5408
36503, 635, 5407, 5409, 636
36504, 5407, 5408, 5410, 5409
36505, 5408, 646, 647, 5410
36506, 636, 5409, 5411, 637
36507, 5409, 5410, 5412, 5411
36508, 5410, 647, 648, 5412
36509, 637, 5411, 5413, 638
36510, 5411, 5412, 5414, 5413
36511, 5412, 648, 649, 5414
36512, 638, 5413, 5415, 639
36513, 5413, 5414, 5416, 5415
36514, 5414, 649, 650, 5416
36515, 639, 5415, 5417, 640
36516, 5415, 5416, 5418, 5417
36517, 5416, 650, 651, 5418
36518, 640, 5417, 5419, 641
36519, 5417, 5418, 5420, 5419
36520, 5418, 651, 652, 5420
36521, 641, 5419, 5421, 642
36522, 5419, 5420, 5422, 5421
36523, 5420, 652, 653, 5422
36524, 642, 5421, 5423, 643
36525, 5421, 5422, 5424, 5423
36526, 5422, 653, 654, 5424
36527, 643, 5423, 621, 25
36528, 5423, 5424, 622, 621
36529, 5424, 654, 26, 622
*ELEMENT, type=CPS4, ELSET=Surface32
1853, 25, 655, 5425, 621
1854, 655, 656, 5426, 5425
1855, 656, 657, 5427, 5426
1856, 657, 658, 5428, 5427
1857, 658, 659, 5429, 5428
1858, 659, 660, 5430, 5429
1859, 660, 661, 5431, 5430
1860, 661, 662, 5432, 5431
1861, 662, 663, 5433, 5432
1862, 663, 664, 5434, 5433
1863, 664, 665, 5435, 5434
1864, 665, 666, 5436, 5435
1865, 666, 667, 5437, 5436
1866, 667, 668, 5438, 5437
1867, 668, 669, 5439, 5438
1868, 669, 670, 5440, 5439
1869, 670, 671, 5441, 5440
1870, 671, 672, 5442, 5441
1871, 672, 673, 5443, 5442
1872, 673, 674, 5444, 5443
1873, 674, 675, 5445, 5444
1874, 675, 676, 5446, 5445
1875, 676, 677, 5447, 5446
1876, 677, 29, 701, 5447
1877, 621, 5425, 5448, 622
1878, 5425, 5426, 5449, 5448
1879, 5426, 5427, 5450, 5449
1880, 5427, 5428, 5451, 5450
1881, 5428, 5429, 5452, 5451
1882, 5429, 5430, 5453, 5452
1883, 5430, 5431, 5454, 5453
1884, 5431, 5432, 5455, 5454
1885, 5432, 5433, 5456, 5455
1886, 5433, 5434, 5457, 5456
1887, 5434, 5435, 5458, 5457
1888, 5435, 5436, 5459, 5458
1889, 5436, 5437, 5460, 5459
1890, 5437, 5438, 5461, 5460
1891, 5438, 5439, 5462, 5461
1892, 5439, 5440, 5463, 5462
1893, 5440, 5441, 5464, 5463
1894, 5441, 5442, 5465, 5464
1895, 5442, 5443, 5466, 5465
1896, 5443, 5444, 5467, 5466
1897, 5444, 5445, 5468, 5467
1898, 5445, 5446, 5469, 5468
1899, 5446, 5447, 5470, 5469
1900, 5447, 701, 702, 5470
1901, 622, 5448, 678, 26
1902, 5448, 5449, 679, 678
1903, 5449, 5450, 680, 679
1904, 5450, 5451, 681, 680
1905, 5451, 5452, 682, 681
1906, 5452, 5453, 683, 682
1907, 5453, 5454, 684, 683
1908, 5454, 5455, 685, 684
1909, 5455, 5456, 686, 685
1910, 5456, 5457, 687, 686
1911, 5457, 5458, 688, 687
1912, 5458, 5459, 689, 688
1913, 5459, 5460, 690, 689
1914, 5460, 5461, 691, 690
1915, 5461, 5462, 692, 691
1916, 5462, 5463, 693, 692
1917, 5463, 5464, 694, 693
1918, 5464, 5465, 695, 694
1919, 5465, 5466, 696, 695
1920, 5466, 5467, 697, 696
1921, 5467, 5468, 698, 697
1922, 5468, 5469, 699, 698
1923, 5469, 5470, 700, 699
1924, 5470, 702, 30, 700
*ELEMENT, type=CPS4, ELSET=Surface33
36530, 27, 631, 5471, 703
36531, 703, 5471, 5472, 704
36532, 704, 5472, 5473, 705
36533, 705, 5473, 5474, 706
36534, 706, 5474, 5475, 707
36535, 707, 5475, 5476, 708
36536, 708, 5476, 5477, 709
36537, 709, 5477, 5478, 710
36538, 710, 5478, 5479, 711
36539, 711, 5479, 5480, 712
36540, 712, 5480, 5481, 713
36541, 713, 5481, 5482, 714
36542, 714, 5482, 5483, 715
36543, 715, 5483, 5484, 716
36544, 716, 5484, 5485, 717
36545, 717, 5485, 5486, 718
36546, 718, 5486, 5487, 719
36547, 719, 5487, 5488, 720
36548, 720, 5488, 5489, 721
36549, 721, 5489, 5490, 722
36550, 722, 5490, 5491, 723
36551, 723, 5491, 5492, 724
36552, 724, 5492, 5493, 725
36553, 725, 5493, 749, 31
36554, 631, 632, 5494, 5471
36555, 5471, 5494, 5495, 5472
36556, 5472, 5495, 5496, 5473
36557, 5473, 5496, 5497, 5474
36558, 5474, 5497, 5498, 5475
36559, 5475, 5498, 5499, 5476
36560, 5476, 5499, 5500, 5477
36561, 5477, 5500, 5501, 5478
36562, 5478, 5501, 5502, 5479
36563, 5479, 5502, 5503, 5480
36564, 5480, 5503, 5504, 5481
36565, 5481, 5504, 5505, 5482
36566, 5482, 5505, 5506, 5483
36567, 5483, 5506, 5507, 5484
36568, 5484, 5507, 5508, 5485
36569, 5485, 5508, 5509, 5486
36570, 5486, 5509, 5510, 5487
36571, 5487, 5510, 5511, 5488
36572, 5488, 5511, 5512, 5489
36573, 5489, 5512, 5513, 5490
36574, 5490, 5513, 5514, 5491
36575, 5491, 5514, 5515, 5492
36576, 5492, 5515, 5516, 5493
36577, 5493, 5516, 750, 749
36578, 632, 28, 726, 5494
36579, 5494, 726, 727, 5495
36580, 5495, 727, 728, 5496
36581, 5496, 728, 729, 5497
36582, 5497, 729, 730, 5498
36583, 5498, 730, 731, 5499
36584, 5499, 731, 732, 5500
36585, 5500, 732, 733, 5501
36586, 5501, 733, 734, 5502
36587, 5502, 734, 735, 5503
36588, 5503, 735, 736, 5504
36589, 5504, 736, 737, 5505
36590, 5505, 737, 738, 5506
36591, 5506, 738, 739, 5507
36592, 5507, 739, 740, 5508
36593, 5508, 740, 741, 5509
36594, 5509, 741, 742, 5510
36595, 5510, 742, 743, 5511
36596, 5511, 743, 744, 5512
36597, 5512, 744, 745, 5513
36598, 5513, 745, 746, 5514
36599, 5514, 746, 747, 5515
36600, 5515, 747, 748, 5516
36601, 5516, 748, 32, 750
*ELEMENT, type=CPS4, ELSET=Surface34
36602, 27, 703, 5517, 633
36603, 703, 704, 5518, 5517
36604, 704, 705, 5519, 5518
36605, 705, 706, 5520, 5519
36606, 706, 707, 5521, 5520
36607, 707, 708, 5522, 5521
36608, 708, 709, 5523, 5522
36609, 709, 710, 5524, 5523
36610, 710, 711, 5525, 5524
36611, 711, 712, 5526, 5525
36612, 712, 713, 5527, 5526
36613, 713, 714, 5528, 5527
36614, 714, 715, 5529, 5528
36615, 715, 716, 5530, 5529
36616, 716, 717, 5531, 5530
36617, 717, 718, 5532, 5531
36618, 718, 719, 5533, 5532
36619, 719, 720, 5534, 5533
36620, 720, 721, 5535, 5534
36621, 721, 722, 5536, 5535
36622, 722, 723, 5537, 5536
36623, 723, 724, 5538, 5537
36624, 724, 725, 5539, 5538
36625, 725, 31, 751, 5539
36626, 633, 5517, 5540, 634
36627, 5517, 5518, 5541, 5540
36628, 5518, 5519, 5542, 5541
36629, 5519, 5520, 5543, 5542
36630, 5520, 5521, 5544, 5543
36631, 5521, 5522, 5545, 5544
36632, 5522, 5523, 5546, 5545
36633, 5523, 5524, 5547, 5546
36634, 5524, 5525, 5548, 5547
36635, 5525, 5526, 5549, 5548
36636, 5526, 5527, 5550, 5549
36637, 5527, 5528, 5551, 5550
36638, 5528, 5529, 5552, 5551
36639, 5529, 5530, 5553, 5552
36640, 5530, 5531, 5554, 5553
36641, 5531, 5532, 5555, 5554
36642, 5532, 5533, 5556, 5555
36643, 5533, 5534, 5557, 5556
36644, 5534, 5535, 5558, 5557
36645, 5535, 5536, 5559, 5558
36646, 5536, 5537, 5560, 5559
36647, 5537, 5538, 5561, 5560
36648, 5538, 5539, 5562, 5561
36649, 5539, 751, 752, 5562
36650, 634, 5540, 5563, 635
36651, 5540, 5541, 5564, 5563
36652, 5541, 5542, 5565, 5564
36653, 5542, 5543, 5566, 5565
36654, 5543, 5544, 5567, 5566
36655, 5544, 5545, 5568, 5567
36656, 5545, 5546, 5569, 5568
36657, 5546, 5547, 5570, 5569
36658, 5547, 5548, 5571, 5570
36659, 5548, 5549, 5572, 5571
36660, 5549, 5550, 5573, 5572
36661, 5550, 5551, 5574, 5573
36662, 5551, 5552, 5575, 5574
36663, 5552, 5553, 5576, 5575
36664, 5553, 5554, 5577, 5576
36665, 5554, 5555, 5578, 5577
36666, 5555, 5556, 5579, 5578
36667, 5556, 5557, 5580, 5579
36668, 5557, 5558, 5581, 5580
36669, 5558, 5559, 5582, 5581
36670, 5559, 5560, 5583, 5582
36671, 5560, 5561, 5584, 5583
36672, 5561, 5562, 5585, 5584
36673, 5562, 752, 753, 5585
36674, 635, 5563, 5586, 636
36675, 5563, 5564, 5587, 5586
36676, 5564, 5565, 5588, 5587
36677, 5565, 5566, 5589, 5588
36678, 5566, 5567, 5590, 5589
36679, 5567, 5568, 5591, 5590
36680, 5568, 5569, 5592, 5591
36681, 5569, 5570, 5593, 5592
36682, 5570, 5571, 5594, 5593
36683, 5571, 5572, 5595, 5594
36684, 5572, 5573, 5596, 5595
36685, 5573, 5574, 5597, 5596
36686, 5574, 5575, 5598, 5597
36687, 5575, 5576, 5599, 5598
36688, 5576, 5577, 5600, 5599
36689, 5577, 5578, 5601, 5600
36690, 5578, 5579, 5602, 5601
36691, 5579, 5580, 5603, 5602
36692, 5580, 5581, 5604, 5603
36693, 5581, 5582, 5605, 5604
36694, 5582, 5583, 5606, 5605
36695, 5583, 5584, 5607, 5606
36696, 5584, 5585, 5608, 5607
36697, 5585, 753, 754, 5608
36698, 636, 5586, 5609, 637
36699, 5586, 5587, 5610, 5609
36700, 5587, 5588, 5611, 5610
36701, 5588, 5589, 5612, 5611
36702, 5589, 5590, 5613, 5612
36703, 5590, 5591, 5614, 5613
36704, 5591, 5592, 5615, 5614
36705, 5592, 5593, 5616, 5615
36706, 5593, 5594, 5617, 5616
36707, 5594, 5595, 5618, 5617
36708, 5595, 5596, 5619, 5618
36709, 5596, 5597, 5620, 5619
36710, 5597, 5598, 5621, 5620
36711, 5598, 5599, 5622, 5621
36712, 5599, 5600, 5623, 5622
36713, 5600, 5601, 5624, 5623
36714, 5601, 5602, 5625, 5624
36715, 5602, 5603, 5626, 5625
36716, 5603, 5604, 5627, 5626
36717, 5604, 5605, 5628, 5627
36718, 5605, 5606, 5629, 5628
36719, 5606, 5607, 5630, 5629
36720, 5607, 5608, 5631, 5630
36721, 5608, 754, 755, 5631
36722, 637, 5609, 5632, 638
36723, 5609, 5610, 5633, 5632
36724, 5610, 5611, 5634, 5633
36725, 5611, 5612, 5635, 5634
36726, 5612, 5613, 5636, 5635
36727, 5613, 5614, 5637, 5636
36728, 5614, 5615, 5638, 5637
36729, 5615, 5616, 5639, 5638
36730, 5616, 5617, 5640, 5639
36731, 5617, 5618, 5641, 5640
36732, 5618, 5619, 5642, 5641
36733, 5619, 5620, 5643, 5642
36734, 5620, 5621, 5644, 5643
36735, 5621, 5622, 5645, 5644
36736, 5622, 5623, 5646, 5645
36737, 5623, 5624, 5647, 5646
36738, 5624, 5625, 5648, 5647
36739, 5625, 5626, 5649, 5648
36740, 5626, 5627, 5650, 5649
36741, 5627, 5628, 5651, 5650
36742, 5628, 5629, 5652, 5651
36743, 5629, 5630, 5653, 5652
36744, 5630, 5631, 5654, 5653
36745, 5631, 755, 756, 5654
36746, 638, 5632, 5655, 639
36747, 5632, 5633, 5656, 5655
36748, 5633, 5634, 5657, 5656
36749, 5634, 5635, 5658, 5657
36750, 5635, 5636, 5659, 5658
36751, 5636, 5637, 5660, 5659
36752, 5637, 5638, 5661, 5660
36753, 5638, 5639, 5662, 5661
36754, 5639, 5640, 5663, 5662
36755, 5640, 5641, 5664, 5663
36756, 5641, 5642, 5665, 5664
36757, 5642, 5643, 5666, 5665
36758, 5643, 5644, 5667, 5666
36759, 5644, 5645, 5668, 5667
36760, 5645, 5646, 5669, 5668
36761, 5646, 5647, 5670, 5669
36762, 5647, 5648, 5671, 5670
36763, 5648, 5649, 5672, 5671
36764, 5649, 5650, 5673, 5672
36765, 5650, 5651, 5674, 5673
36766, 5651, 5652, 5675, 5674
36767, 5652, 5653, 5676, 5675
36768, 5653, 5654, 5677, 5676
36769, 5654, 756, 757, 5677
36770, 639, 5655, 5678, 640
36771, 5655, 5656, 5679, 5678
36772, 5656, 5657, 5680, 5679
36773, 5657, 5658, 5681, 5680
36774, 5658, 5659, 5682, 5681
36775, 5659, 5660, 5683, 5682
36776, 5660, 5661, 5684, 5683
36777, 5661, 5662, 5685, 5684
36778, 5662, 5663, 5686, 5685
36779, 5663, 5664, 5687, 5686
36780, 5664, 5665, 5688, 5687
36781, 5665, 5666, 5689, 5688
36782, 5666, 5667, 5690, 5689
36783, 5667, 5668, 5691, 5690
36784, 5668, 5669, 5692, 5691
36785, 5669, 5670, 5693, 5692
36786, 5670, 5671, 5694, 5693
36787, 5671, 5672, 5695, 5694
36788, 5672, 5673, 5696, 5695
36789, 5673, 5674, 5697, 5696
36790, 5674, 5675, 5698, 5697
36791, 5675, 5676, 5699, 5698
36792, 5676, 5677, 5700, 5699
36793, 5677, 757, 758, 5700
36794, 640, 5678, 5701, 641
36795, 5678, 5679, 5702, 5701
36796, 5679, 5680, 5703, 5702
36797, 5680, 5681, 5704, 5703
36798, 5681, 5682, 5705, 5704
36799, 5682, 5683, 5706, 5705
36800, 5683, 5684, 5707, 5706
36801, 5684, 5685, 5708, 5707
36802, 5685, 5686, 5709, 5708
36803, 5686, 5687, 5710, 5709
36804, 5687, 5688, 5711, 5710
36805, 5688, 5689, 5712, 5711
36806, 5689, 5690, 5713, 5712
36807, 5690, 5691, 5714, 5713
36808, 5691, 5692, 5715, 5714
36809, 5692, 5693, 5716, 5715
36810, 5693, 5694, 5717, 5716
36811, 5694, 5695, 5718, 5717
36812, 5695, 5696, 5719, 5718
36813, 5696, 5697, 5720, 5719
36814, 5697, 5698, 5721, 5720
36815, 5698, 5699, 5722, 5721
36816, 5699, 5700, 5723, 5722
36817, 5700, 758, 759, 5723
36818, 641, 5701, 5724, 642
36819, 5701, 5702, 5725, 5724
36820, 5702, 5703, 5726, 5725
36821, 5703, 5704, 5727, 5726
36822, 5704, 5705, 5728, 5727
36823, 5705, 5706, 5729, 5728
36824, 5706, 5707, 5730, 5729
36825, 5707, 5708, 5731, 5730
36826, 5708, 5709, 5732, 5731
36827, 5709, 5710, 5733, 5732
36828, 5710, 5711, 5734, 5733
36829, 5711, 5712, 5735, 5734
36830, 5712, 5713, 5736, 5735
36831, 5713, 5714, 5737, 5736
36832, 5714, 5715, 5738, 5737
36833, 5715, 5716, 5739, 5738
36834, 5716, 5717, 5740, 5739
36835, 5717, 5718, 5741, 5740
36836, 5718, 5719, 5742, 5741
36837, 5719, 5720, 5743, 5742
36838, 5720, 5721, 5744, 5743
36839, 5721, 5722, 5745, 5744
36840, 5722, 5723, 5746, 5745
36841, 5723, 759, 760, 5746
36842, 642, 5724, 5747, 643
36843, 5724, 5725, 5748, 5747
36844, 5725, 5726, 5749, 5748
36845, 5726, 5727, 5750, 5749
36846, 5727, 5728, 5751, 5750
36847, 5728, 5729, 5752, 5751
36848, 5729, 5730, 5753, 5752
36849, 5730, 5731, 5754, 5753
36850, 5731, 5732, 5755, 5754
36851, 5732, 5733, 5756, 5755
36852, 5733, 5734, 5757, 5756
36853, 5734, 5735, 5758, 5757
36854, 5735, 5736, 5759, 5758
36855, 5736, 5737, 5760, 5759
36856, 5737, 5738, 5761, 5760
36857, 5738, 5739, 5762, 5761
36858, 5739, 5740, 5763, 5762
36859, 5740, 5741, 5764, 5763
36860, 5741, 5742, 5765, 5764
36861, 5742, 5743, 5766, 5765
36862, 5743, 5744, 5767, 5766
36863, 5744, 5745, 5768, 5767
36864, 5745, 5746, 5769, 5768
36865, 5746, 760, 761, 5769
36866, 643, 5747, 655, 25
36867, 5747, 5748, 656, 655
36868, 5748, 5749, 657, 656
36869, 5749, 5750, 658, 657
36870, 5750, 5751, 659, 658
36871, 5751, 5752, 660, 659
36872, 5752, 5753, 661, 660
36873, 5753, 5754, 662, 661
36874, 5754, 5755, 663, 662
36875, 5755, 5756, 664, 663
36876, 5756, 5757, 665, 664
36877, 5757, 5758, 666, 665
36878, 5758, 5759, 667, 666
36879, 5759, 5760, 668, 667
36880, 5760, 5761, 669, 668
36881, 5761, 5762, 670, 669
36882, 5762, 5763, 671, 670
36883, 5763, 5764, 672, 671
36884, 5764, 5765, 673, 672
36885, 5765, 5766, 674, 673
36886, 5766, 5767, 675, 674
36887, 5767, 5768, 676, 675
36888, 5768, 5769, 677, 676
36889, 5769, 761, 29, 677
*ELEMENT, type=CPS4, ELSET=Surface35
1925, 28, 644, 5770, 726
1926, 726, 5770, 5771, 727
1927, 727, 5771, 5772, 728
1928, 728, 5772, 5773, 729
1929, 729, 5773, 5774, 730
1930, 730, 5774, 5775, 731
1931, 731, 5775, 5776, 732
1932, 732, 5776, 5777, 733
1933, 733, 5777, 5778, 734
1934, 734, 5778, 5779, 735
1935, 735, 5779, 5780, 736
1936, 736, 5780, 5781, 737
1937, 737, 5781, 5782, 738
1938, 738, 5782, 5783, 739
1939, 739, 5783, 5784, 740
1940, 740, 5784, 5785, 741
1941, 741, 5785, 5786, 742
1942, 742, 5786, 5787, 743
1943, 743, 5787, 5788, 744
1944, 744, 5788, 5789, 745
1945, 745, 5789, 5790, 746
1946, 746, 5790, 5791, 747
1947, 747, 5791, 5792, 748
1948, 748, 5792, 762, 32
1949, 644, 645, 5793, 5770
1950, 5770, 5793, 5794, 5771
1951, 5771, 5794, 5795, 5772
1952, 5772, 5795, 5796, 5773
1953, 5773, 5796, 5797, 5774
1954, 5774, 5797, 5798, 5775
1955, 5775, 5798, 5799, 5776
1956, 5776, 5799, 5800, 5777
1957, 5777, 5800, 5801, 5778
1958, 5778, 5801, 5802, 5779
1959, 5779, 5802, 5803, 5780
1960, 5780, 5803, 5804, 5781
1961, 5781, 5804, 5805, 5782
1962, 5782, 5805, 5806, 5783
1963, 5783, 5806, 5807, 5784
1964, 5784, 5807, 5808, 5785
1965, 5785, 5808, 5809, 5786
1966, 5786, 5809, 5810, 5787
1967, 5787, 5810, 5811, 5788
1968, 5788, 5811, 5812, 5789
1969, 5789, 5812, 5813, 5790
1970, 5790, 5813, 5814, 5791
1971, 5791, 5814, 5815, 5792
1972, 5792, 5815, 763, 762
1973, 645, 646, 5816, 5793
1974, 5793, 5816, 5817, 5794
1975, 5794, 5817, 5818, 5795
1976, 5795, 5818, 5819, 5796
1977, 5796, 5819, 5820, 5797
1978, 5797, 5820, 5821, 5798
1979, 5798, 5821, 5822, 5799
1980, 5799, 5822, 5823, 5800
1981, 5800, 5823, 5824, 5801
1982, 5801, 5824, 5825, 5802
1983, 5802, 5825, 5826, 5803
1984, 5803, 5826, 5827, 5804
1985, 5804, 5827, 5828, 5805
1986, 5805, 5828, 5829, 5806
1987, 5806, 5829, 5830, 5807
1988, 5807, 5830, 5831, 5808
1989, 5808, 5831, 5832, 5809
1990, 5809, 5832, 5833, 5810
1991, 5810, 5833, 5834, 5811
1992, 5811, 5834, 5835, 5812
1993, 5812, 5835, 5836, 5813
1994, 5813, 5836, 5837, 5814
1995, 5814, 5837, 5838, 5815
1996, 5815, 5838, 764, 763
1997, 646, 647, 5839, 5816
1998, 5816, 5839, 5840, 5817
1999, 5817, 5840, 5841, 5818
2000, 5818, 5841, 5842, 5819
2001, 5819, 5842, 5843, 5820
2002, 5820, 5843, 5844, 5821
2003, 5821, 5844, 5845, 5822
2004, 5822, 5845, 5846, 5823
2005, 5823, 5846, 5847, 5824
2006, 5824, 5847, 5848, 5825
2007, 5825, 5848, 5849, 5826
2008, 5826, 5849, 5850, 5827
2009, 5827, 5850, 5851, 5828
2010, 5828, 5851, 5852, 5829
2011, 5829, 5852, 5853, 5830
2012, 5830, 5853, 5854, 5831
2013, 5831, 5854, 5855, 5832
2014, 5832, 5855, 5856, 5833
2015, 5833, 5856, 5857, 5834
2016, 5834, 5857, 5858, 5835
2017, 5835, 5858, 5859, 5836
2018, 5836, 5859, 5860, 5837
2019, 5837, 5860, 5861, 5838
2020, 5838, 5861, 765, 764
2021, 647, 648, 5862, 5839
2022, 5839, 5862, 5863, 5840
2023, 5840, 5863, 5864, 5841
2024, 5841, 5864, 5865, 5842
2025, 5842, 5865, 5866, 5843
2026, 5843, 5866, 5867, 5844
2027, 5844, 5867, 5868, 5845
2028, 5845, 5868, 5869, 5846
2029, 5846, 5869, 5870, 5847
2030, 5847, 5870, 5871, 5848
2031, 5848, 5871, 5872, 5849
2032, 5849, 5872, 5873, 5850
2033, 5850, 5873, 5874, 5851
2034, 5851, 5874, 5875, 5852
2035, 5852, 5875, 5876, 5853
2036, 5853, 5876, 5877, 5854
2037, 5854, 5877, 5878, 5855
2038, 5855, 5878, 5879, 5856
2039, 5856, 5879, 5880, 5857
2040, 5857, 5880, 5881, 5858
2041, 5858, 5881, 5882, 5859
2042, 5859, 5882, 5883, 5860
2043, 5860, 5883, 5884, 5861
2044, 5861, 5884, 766, 765
2045, 648, 649, 5885, 5862
2046, 5862, 5885, 5886, 5863
2047, 5863, 5886, 5887, 5864
2048, 5864, 5887, 5888, 5865
2049, 5865, 5888, 5889, 5866
2050, 5866, 5889, 5890, 5867
2051, 5867, 5890, 5891, 5868
2052, 5868, 5891, 5892, 5869
2053, 5869, 5892, 5893, 5870
2054, 5870, 5893, 5894, 5871
2055, 5871, 5894, 5895, 5872
2056, 5872, 5895, 5896, 5873
2057, 5873, 5896, 5897, 5874
2058, 5874, 5897, 5898, 5875
2059, 5875, 5898, 5899, 5876
2060, 5876, 5899, 5900, 5877
2061, 5877, 5900, 5901, 5878
2062, 5878, 5901, 5902, 5879
2063, 5879, 5902, 5903, 5880
2064, 5880, 5903, 5904, 5881
2065, 5881, 5904, 5905, 5882
2066, 5882, 5905, 5906, 5883
2067, 5883, 5906, 5907, 5884
2068, 5884, 5907, 767, 766
2069, 649, 650, 5908, 5885
2070, 5885, 5908, 5909, 5886
2071, 5886, 5909, 5910, 5887
2072, 5887, 5910, 5911, 5888
2073, 5888, 5911, 5912, 5889
2074, 5889, 5912, 5913, 5890
2075, 5890, 5913, 5914, 5891
2076, 5891, 5914, 5915, 5892
2077, 5892, 5915, 5916, 5893
2078, 5893, 5916, 5917, 5894
2079, 5894, 5917, 5918, 5895
2080, 5895, 5918, 5919, 5896
2081, 5896, 5919, 5920, 5897
2082, 5897, 5920, 5921, 5898
2083, 5898, 5921, 5922, 5899
2084, 5899, 5922, 5923, 5900
2085, 5900, 5923, 5924, 5901
2086, 5901, 5924, 5925, 5902
2087, 5902, 5925, 5926, 5903
2088, 5903, 5926, 5927, 5904
2089, 5904, 5927, 5928, 5905
2090, 5905, 5928, 5929, 5906
2091, 5906, 5929, 5930, 5907
2092, 5907, 5930, 768, 767
2093, 650, 651, 5931, 5908
2094, 5908, 5931, 5932, 5909
2095, 5909, 5932, 5933, 5910
2096, 5910, 5933, 5934, 5911
2097, 5911, 5934, 5935, 5912
2098, 5912, 5935, 5936, 5913
2099, 5913, 5936, 5937, 5914
2100, 5914, 5937, 5938, 5915
2101, 5915, 5938, 5939, 5916
2102, 5916, 5939, 5940, 5917
2103, 5917, 5940, 5941, 5918
2104, 5918, 5941, 5942, 5919
2105, 5919, 5942, 5943, 5920
2106, 5920, 5943, 5944, 5921
2107, 5921, 5944, 5945, 5922
2108, 5922, 5945, 5946, 5923
2109, 5923, 5946, 5947, 5924
2110, 5924, 5947, 5948, 5925
2111, 5925, 5948, 5949, 5926
2112, 5926, 5949, 5950, 5927
2113, 5927, 5950, 5951, 5928
2114, 5928, 5951, 5952, 5929
2115, 5929, 5952, 5953, 5930
2116, 5930, 5953, 769, 768
2117, 651, 652, 5954, 5931
2118, 5931, 5954, 5955, 5932
2119, 5932, 5955, 5956, 5933
2120, 5933, 5956, 5957, 5934
2121, 5934, 5957, 5958, 5935
2122, 5935, 5958, 5959, 5936
2123, 5936, 5959, 5960, 5937
2124, 5937, 5960, 5961, 5938
2125, 5938, 5961, 5962, 5939
2126, 5939, 5962, 5963, 5940
2127, 5940, 5963, 5964, 5941
2128, 5941, 5964, 5965, 5942
2129, 5942, 5965, 5966, 5943
2130, 5943, 5966, 5967, 5944
2131, 5944, 5967, 5968, 5945
2132, 5945, 5968, 5969, 5946
2133, 5946, 5969, 5970, 5947
2134, 5947, 5970, 5971, 5948
2135, 5948, 5971, 5972, 5949
2136, 5949, 5972, 5973, 5950
2137, 5950, 5973, 5974, 5951
2138, 5951, 5974, 5975, 5952
2139, 5952, 5975, 5976, 5953
2140, 5953, 5976, 770, 769
2141, 652, 653, 5977, 5954
2142, 5954, 5977, 5978, 5955
2143, 5955, 5978, 5979, 5956
2144, 5956, 5979, 5980, 5957
2145, 5957, 5980, 5981, 5958
2146, 5958, 5981, 5982, 5959
2147, 5959, 5982, 5983, 5960
2148, 5960, 5983, 5984, 5961
2149, 5961, 5984, 5985, 5962
2150, 5962, 5985, 5986, 5963
2151, 5963, 5986, 5987, 5964
2152, 5964, 5987, 5988, 5965
2153, 5965, 5988, 5989, 5966
2154, 5966, 5989, 5990, 5967
2155, 5967, 5990, 5991, 5968
2156, 5968, 5991, 5992, 5969
2157, 5969, 5992, 5993, 5970
2158, 5970, 5993, 5994, 5971
2159, 5971, 5994, 5995, 5972
2160, 5972, 5995, 5996, 5973
2161, 5973, 5996, 5997, 5974
2162, 5974, 5997, 5998, 5975
2163, 5975, 5998, 5999, 5976
2164, 5976, 5999, 771, 770
2165, 653, 654, 6000, 5977
2166, 5977, 6000, 6001, 5978
2167, 5978, 6001, 6002, 5979
2168, 5979, 6002, 6003, 5980
2169, 5980, 6003, 6004, 5981
2170, 5981, 6004, 6005, 5982
2171, 5982, 6005, 6006, 5983
2172, 5983, 6006, 6007, 5984
2173, 5984, 6007, 6008, 5985
2174, 5985, 6008, 6009, 5986
2175, 5986, 6009, 6010, 5987
2176, 5987, 6010, 6011, 5988
2177, 5988, 6011, 6012, 5989
2178, 5989, 6012, 6013, 5990
2179, 5990, 6013, 6014, 5991
2180, 5991, 6014, 6015, 5992
2181, 5992, 6015, 6016, 5993
2182, 5993, 6016, 6017, 5994
2183, 5994, 6017, 6018, 5995
2184, 5995, 6018, 6019, 5996
2185, 5996, 6019, 6020, 5997
2186, 5997, 6020, 6021, 5998
2187, 5998, 6021, 6022, 5999
2188, 5999, 6022, 772, 771
2189, 654, 26, 678, 6000
2190, 6000, 678, 679, 6001
2191, 6001, 679, 680, 6002
2192, 6002, 680, 681, 6003
2193, 6003, 681, 682, 6004
2194, 6004, 682, 683, 6005
2195, 6005, 683, 684, 6006
2196, 6006, 684, 685, 6007
2197, 6007, 685, 686, 6008
2198, 6008, 686, 687, 6009
2199, 6009, 687, 688, 6010
2200, 6010, 688, 689, 6011
2201, 6011, 689, 690, 6012
2202, 6012, 690, 691, 6013
2203, 6013, 691, 692, 6014
2204, 6014, 692, 693, 6015
2205, 6015, 693, 694, 6016
2206, 6016, 694, 695, 6017
2207, 6017, 695, 696, 6018
2208, 6018, 696, 697, 6019
2209, 6019, 697, 698, 6020
2210, 6020, 698, 699, 6021
2211, 6021, 699, 700, 6022
2212, 6022, 700, 30, 772
*ELEMENT, type=CPS4, ELSET=Surface36
36890, 31, 749, 6023, 751
36891, 749, 750, 6024, 6023
36892, 750, 32, 762, 6024
36893, 751, 6023, 6025, 752
36894, 6023, 6024, 6026, 6025
36895, 6024, 762, 763, 6026
36896, 752, 6025, 6027, 753
36897, 6025, 6026, 6028, 6027
36898, 6026, 763, 764, 6028
36899, 753, 6027, 6029, 754
36900, 6027, 6028, 6030, 6029
36901, 6028, 764, 765, 6030
36902, 754, 6029, 6031, 755
36903, 6029, 6030, 6032, 6031
36904, 6030, 765, 766, 6032
36905, 755, 6031, 6033, 756
36906, 6031, 6032, 6034, 6033
36907, 6032, 766, 767, 6034
36908, 756, 6033, 6035, 757
36909, 6033, 6034, 6036, 6035
36910, 6034, 767, 768, 6036
36911, 757, 6035, 6037, 758
36912, 6035, 6036, 6038, 6037
36913, 6036, 768, 769, 6038
36914, 758, 6037, 6039, 759
36915, 6037, 6038, 6040, 6039
36916, 6038, 769, 770, 6040
36917, 759, 6039, 6041, 760
36918, 6039, 6040, 6042, 6041
36919, 6040, 770, 771, 6042
36920, 760, 6041, 6043, 761
36921, 6041, 6042, 6044, 6043
36922, 6042, 771, 772, 6044
36923, 761, 6043, 701, 29
36924, 6043, 6044, 702, 701
36925, 6044, 772, 30, 702
*ELEMENT, type=CPS4, ELSET=Surface37
2213, 25, 33, 773, 655
2214, 655, 773, 774, 656
2215, 656, 774, 775, 657
2216, 657, 775, 776, 658
2217, 658, 776, 777, 659
2218, 659, 777, 778, 660
2219, 660, 778, 779, 661
2220, 661, 779, 780, 662
2221, 662, 780, 781, 663
2222, 663, 781, 782, 664
2223, 664, 782, 783, 665
2224, 665, 783, 784, 666
2225, 666, 784, 785, 667
2226, 667, 785, 786, 668
2227, 668, 786, 787, 669
2228, 669, 787, 788, 670
2229, 670, 788, 789, 671
2230, 671, 789, 790, 672
2231, 672, 790, 791, 673
2232, 673, 791, 792, 674
2233, 674, 792, 793, 675
2234, 675, 793, 794, 676
2235, 676, 794, 795, 677
2236, 677, 795, 34, 29
*ELEMENT, type=CPS4, ELSET=Surface38
36926, 27, 703, 796, 35
36927, 703, 704, 797, 796
36928, 704, 705, 798, 797
36929, 705, 706, 799, 798
36930, 706, 707, 800, 799
36931, 707, 708, 801, 800
36932, 708, 709, 802, 801
36933, 709, 710, 803, 802
36934, 710, 711, 804, 803
36935, 711, 712, 805, 804
36936, 712, 713, 806, 805
36937, 713, 714, 807, 806
36938, 714, 715, 808, 807
36939, 715, 716, 809, 808
36940, 716, 717, 810, 809
36941, 717, 718, 811, 810
36942, 718, 719, 812, 811
36943, 719, 720, 813, 812
36944, 720, 721, 814, 813
36945, 721, 722, 815, 814
36946, 722, 723, 816, 815
36947, 723, 724, 817, 816
36948, 724, 725, 818, 817
36949, 725, 31, 36, 818
*ELEMENT, type=CPS4, ELSET=Surface39
36950, 27, 35, 819, 633
36951, 633, 819, 820, 634
36952, 634, 820, 821, 635
36953, 635, 821, 822, 636
36954, 636, 822, 823, 637
36955, 637, 823, 824, 638
36956, 638, 824, 825, 639
36957, 639, 825, 826, 640
36958, 640, 826, 827, 641
36959, 641, 827, 828, 642
36960, 642, 828, 829, 643
36961, 643, 829, 33, 25
*ELEMENT, type=CPS4, ELSET=Surface40
36962, 31, 751, 830, 36
36963, 751, 752, 831, 830
36964, 752, 753, 832, 831
36965, 753, 754, 833, 832
36966, 754, 755, 834, 833
36967, 755, 756, 835, 834
36968, 756, 757, 836, 835
36969, 757, 758, 837, 836
36970, 758, 759, 838, 837
36971, 759, 760, 839, 838
36972, 760, 761, 840, 839
36973, 761, 29, 34, 840
*ELEMENT, type=CPS4, ELSET=Surface41
2237, 35, 796, 6045, 819
2238, 796, 797, 6046, 6045
2239, 797, 798, 6047, 6046
2240, 798, 799, 6048, 6047
2241, 799, 800, 6049, 6048
2242, 800, 801, 6050, 6049
2243, 801, 802, 6051, 6050
2244, 802, 803, 6052, 6051
2245, 803, 804, 6053, 6052
2246, 804, 805, 6054, 6053
2247, 805, 806, 6055, 6054
2248, 806, 807, 6056, 6055
2249, 807, 808, 6057, 6056
2250, 808, 809, 6058, 6057
2251, 809, 810, 6059, 6058
2252, 810, 811, 6060, 6059
2253, 811, 812, 6061, 6060
2254, 812, 813, 6062, 6061
2255, 813, 814, 6063, 6062
2256, 814, 815, 6064, 6063
2257, 815, 816, 6065, 6064
2258, 816, 817, 6066, 6065
2259, 817, 818, 6067, 6066
2260, 818, 36, 830, 6067
2261, 819, 6045, 6068, 820
2262, 6045, 6046, 6069, 6068
2263, 6046, 6047, 6070, 6069
2264, 6047, 6048, 6071, 6070
2265, 6048, 6049, 6072, 6071
2266, 6049, 6050, 6073, 6072
2267, 6050, 6051, 6074, 6073
2268, 6051, 6052, 6075, 6074
2269, 6052, 6053, 6076, 6075
2270, 6053, 6054, 6077, 6076
2271, 6054, 6055, 6078, 6077
2272, 6055, 6056, 6079, 6078
2273, 6056, 6057, 6080, 6079
2274, 6057, 6058, 6081, 6080
2275, 6058, 6059, 6082, 6081
2276, 6059, 6060, 6083, 6082
2277, 6060, 6061, 6084, 6083
2278, 6061, 6062, 6085, 6084
2279, 6062, 6063, 6086, 6085
2280, 6063, 6064, 6087, 6086
2281, 6064, 6065, 6088, 6087
2282, 6065, 6066, 6089, 6088
2283, 6066, 6067, 6090, 6089
2284, 6067, 830, 831, 6090
2285, 820, 6068, 6091, 821
2286, 6068, 6069, 6092, 6091
2287, 6069, 6070, 6093, 6092
2288, 6070, 6071, 6094, 6093
2289, 6071, 6072, 6095, 6094
2290, 6072, 6073, 6096, 6095
2291, 6073, 6074, 6097, 6096
2292, 6074, 6075, 6098, 6097
2293, 6075, 6076, 6099, 6098
2294, 6076, 6077, 6100, 6099
2295, 6077, 6078, 6101, 6100
2296, 6078, 6079, 6102, 6101
2297, 6079, 6080, 6103, 6102
2298, 6080, 6081, 6104, 6103
2299, 6081, 6082, 6105, 6104
2300, 6082, 6083, 6106, 6105
2301, 6083, 6084, 6107, 6106
2302, 6084, 6085, 6108, 6107
2303, 6085, 6086, 6109, 6108
2304, 6086, 6087, 6110, 6109
2305, 6087, 6088, 6111, 6110
2306, 6088, 6089, 6112, 6111
2307, 6089, 6090, 6113, 6112
2308, 6090, 831, 832, 6113
2309, 821, 6091, 6114, 822
2310, 6091, 6092, 6115, 6114
2311, 6092, 6093, 6116, 6115
2312, 6093, 6094, 6117, 6116
2313, 6094, 6095, 6118, 6117
2314, 6095, 6096, 6119, 6118
2315, 6096, 6097, 6120, 6119
2316, 6097, 6098, 6121, 6120
2317, 6098, 6099, 6122, 6121
2318, 6099, 6100, 6123, 6122
2319, 6100, 6101, 6124, 6123
2320, 6101, 6102, 6125, 6124
2321, 6102, 6103, 6126, 6125
2322, 6103, 6104, 6127, 6126
2323, 6104, 6105, 6128, 6127
2324, 6105, 6106, 6129, 6128
2325, 6106, 6107, 6130, 6129
2326, 6107, 6108, 6131, 6130
2327, 6108, 6109, 6132, 6131
2328, 6109, 6110, 6133, 6132
2329, 6110, 6111, 6134, 6133
2330, 6111, 6112, 6135, 6134
2331, 6112, 6113, 6136, 6135
2332, 6113, 832, 833, 6136
2333, 822, 6114, 6137, 823
2334, 6114, 6115, 6138, 6137
2335, 6115, 6116, 6139, 6138
2336, 6116, 6117, 6140, 6139
2337, 6117, 6118, 6141, 6140
2338, 6118, 6119, 6142, 6141
2339, 6119, 6120, 6143, 6142
2340, 6120, 6121, 6144, 6143
2341, 6121, 6122, 6145, 6144
2342, 6122, 6123, 6146, 6145
2343, 6123, 6124, 6147, 6146
2344, 6124, 6125, 6148, 6147
2345, 6125, 6126, 6149, 6148
2346, 6126, 6127, 6150, 6149
2347, 6127, 6128, 6151, 6150
2348, 6128, 6129, 6152, 6151
2349, 6129, 6130, 6153, 6152
2350, 6130, 6131, 6154, 6153
2351, 6131, 6132, 6155, 6154
2352, 6132, 6133, 6156, 6155
2353, 6133, 6134, 6157, 6156
2354, 6134, 6135, 6158, 6157
2355, 6135, 6136, 6159, 6158
2356, 6136, 833, 834, 6159
2357, 823, 6137, 6160, 824
2358, 6137, 6138, 6161, 6160
2359, 6138, 6139, 6162, 6161
2360, 6139, 6140, 6163, 6162
2361, 6140, 6141, 6164, 6163
2362, 6141, 6142, 6165, 6164
2363, 6142, 6143, 6166, 6165
2364, 6143, 6144, 6167, 6166
2365, 6144, 6145, 6168, 6167
2366, 6145, 6146, 6169, 6168
2367, 6146, 6147, 6170, 6169
2368, 6147, 6148, 6171, 6170
2369, 6148, 6149, 6172, 6171
2370, 6149, 6150, 6173, 6172
2371, 6150, 6151, 6174, 6173
2372, 6151, 6152, 6175, 6174
2373, 6152, 6153, 6176, 6175
2374, 6153, 6154, 6177, 6176
2375, 6154, 6155, 6178, 6177
2376, 6155, 6156, 6179, 6178
2377, 6156, 6157, 6180, 6179
2378, 6157, 6158, 6181, 6180
2379, 6158, 6159, 6182, 6181
2380, 6159, 834, 835, 6182
2381, 824, 6160, 6183, 825
2382, 6160, 6161, 6184, 6183
2383, 6161, 6162, 6185, 6184
2384, 6162, 6163, 6186, 6185
2385, 6163, 6164, 6187, 6186
2386, 6164, 6165, 6188, 6187
2387, 6165, 6166, 6189, 6188
2388, 6166, 6167, 6190, 6189
2389, 6167, 6168, 6191, 6190
2390, 6168, 6169, 6192, 6191
2391, 6169, 6170, 6193, 6192
2392, 6170, 6171, 6194, 6193
2393, 6171, 6172, 6195, 6194
2394, 6172, 6173, 6196, 6195
2395, 6173, 6174, 6197, 6196
2396, 6174, 6175, 6198, 6197
2397, 6175, 6176, 6199, 6198
2398, 6176, 6177, 6200, 6199
2399, 6177, 6178, 6201, 6200
2400, 6178, 6179, 6202, 6201
2401, 6179, 6180, 6203, 6202
2402, 6180, 6181, 6204, 6203
2403, 6181, 6182, 6205, 6204
2404, 6182, 835, 836, 6205
2405, 825, 6183, 6206, 826
2406, 6183, 6184, 6207, 6206
2407, 6184, 6185, 6208, 6207
2408, 6185, 6186, 6209, 6208
2409, 6186, 6187, 6210, 6209
2410, 6187, 6188, 6211, 6210
2411, 6188, 6189, 6212, 6211
2412, 6189, 6190, 6213, 6212
2413, 6190, 6191, 6214, 6213
2414, 6191, 6192, 6215, 6214
2415, 6192, 6193, 6216, 6215
2416, 6193, 6194, 6217, 6216
2417, 6194, 6195, 6218, 6217
2418, 6195, 6196, 6219, 6218
2419, 6196, 6197, 6220, 6219
2420, 6197, 6198, 6221, 6220
2421, 6198, 6199, 6222, 6221
2422, 6199, 6200, 6223, 6222
2423, 6200, 6201, 6224, 6223
2424, 6201, 6202, 6225, 6224
2425, 6202, 6203, 6226, 6225
2426, 6203, 6204, 6227, 6226
2427, 6204, 6205, 6228, 6227
2428, 6205, 836, 837, 6228
2429, 826, 6206, 6229, 827
2430, 6206, 6207, 6230, 6229
2431, 6207, 6208, 6231, 6230
2432, 6208, 6209, 6232, 6231
2433, 6209, 6210, 6233, 6232
2434, 6210, 6211, 6234, 6233
2435, 6211, 6212, 6235, 6234
2436, 6212, 6213, 6236, 6235
2437, 6213, 6214, 6237, 6236
2438, 6214, 6215, 6238, 6237
2439, 6215, 6216, 6239, 6238
2440, 6216, 6217, 6240, 6239
2441, 6217, 6218, 6241, 6240
2442, 6218, 6219, 6242, 6241
2443, 6219, 6220, 6243, 6242
2444, 6220, 6221, 6244, 6243
2445, 6221, 6222, 6245, 6244
2446, 6222, 6223, 6246, 6245
2447, 6223, 6224, 6247, 6246
2448, 6224, 6225, 6248, 6247
2449, 6225, 6226, 6249, 6248
2450, 6226, 6227, 6250, 6249
2451, 6227, 6228, 6251, 6250
2452, 6228, 837, 838, 6251
2453, 827, 6229, 6252, 828
2454, 6229, 6230, 6253, 6252
2455, 6230, 6231, 6254, 6253
2456, 6231, 6232, 6255, 6254
2457, 6232, 6233, 6256, 6255
2458, 6233, 6234, 6257, 6256
2459, 6234, 6235, 6258, 6257
2460, 6235, 6236, 6259, 6258
2461, 6236, 6237, 6260, 6259
2462, 6237, 6238, 6261, 6260
2463, 6238, 6239, 6262, 6261
2464, 6239, 6240, 6263, 6262
2465, 6240, 6241, 6264, 6263
2466, 6241, 6242, 6265, 6264
2467, 6242, 6243, 6266, 6265
2468, 6243, 6244, 6267, 6266
2469, 6244, 6245, 6268, 6267
2470, 6245, 6246, 6269, 6268
2471, 6246, 6247, 6270, 6269
2472, 6247, 6248, 6271, 6270
2473, 6248, 6249, 6272, 6271
2474, 6249, 6250, 6273, 6272
2475, 6250, 6251, 6274, 6273
2476, 6251, 838, 839, 6274
2477, 828, 6252, 6275, 829
2478, 6252, 6253, 6276, 6275
2479, 6253, 6254, 6277, 6276
2480, 6254, 6255, 6278, 6277
2481, 6255, 6256, 6279, 6278
2482, 6256, 6257, 6280, 6279
2483, 6257, 6258, 6281, 6280
2484, 6258, 6259, 6282, 6281
2485, 6259, 6260, 6283, 6282
2486, 6260, 6261, 6284, 6283
2487, 6261, 6262, 6285, 6284
2488, 6262, 6263, 6286, 6285
2489, 6263, 6264, 6287, 6286
2490, 6264, 6265, 6288, 6287
2491, 6265, 6266, 6289, 6288
2492, 6266, 6267, 6290, 6289
2493, 6267, 6268, 6291, 6290
2494, 6268, 6269, 6292, 6291
2495, 6269, 6270, 6293, 6292
2496, 6270, 6271, 6294, 6293
2497, 6271, 6272, 6295, 6294
2498, 6272, 6273, 6296, 6295
2499, 6273, 6274, 6297, 6296
2500, 6274, 839, 840, 6297
2501, 829, 6275, 773, 33
2502, 6275, 6276, 774, 773
2503, 6276, 6277, 775, 774
2504, 6277, 6278, 776, 775
2505, 6278, 6279, 777, 776
2506, 6279, 6280, 778, 777
2507, 6280, 6281, 779, 778
2508, 6281, 6282, 780, 779
2509, 6282, 6283, 781, 780
2510, 6283, 6284, 782, 781
2511, 6284, 6285, 783, 782
2512, 6285, 6286, 784, 783
2513, 6286, 6287, 785, 784
2514, 6287, 6288, 786, 785
2515, 6288, 6289, 787, 786
2516, 6289, 6290, 788, 787
2517, 6290, 6291, 789, 788
2518, 6291, 6292, 790, 789
2519, 6292, 6293, 791, 790
2520, 6293, 6294, 792, 791
2521, 6294, 6295, 793, 792
2522, 6295, 6296, 794, 793
2523, 6296, 6297, 795, 794
2524, 6297, 840, 34, 795
*ELEMENT, type=CPS4, ELSET=Surface42
2525, 33, 841, 6298, 773
2526, 841, 842, 6299, 6298
2527, 842, 843, 6300, 6299
2528, 843, 844, 6301, 6300
2529, 844, 845, 6302, 6301
2530, 845, 846, 6303, 6302
2531, 846, 847, 6304, 6303
2532, 847, 848, 6305, 6304
2533, 848, 849, 6306, 6305
2534, 849, 850, 6307, 6306
2535, 850, 851, 6308, 6307
2536, 851, 852, 6309, 6308
2537, 852, 853, 6310, 6309
2538, 853, 854, 6311, 6310
2539, 854, 855, 6312, 6311
2540, 855, 856, 6313, 6312
2541, 856, 857, 6314, 6313
2542, 857, 858, 6315, 6314
2543, 858, 859, 6316, 6315
2544, 859, 860, 6317, 6316
2545, 860, 861, 6318, 6317
2546, 861, 862, 6319, 6318
2547, 862, 863, 6320, 6319
2548, 863, 37, 887, 6320
2549, 773, 6298, 6321, 774
2550, 6298, 6299, 6322, 6321
2551, 6299, 6300, 6323, 6322
2552, 6300, 6301, 6324, 6323
2553, 6301, 6302, 6325, 6324
2554, 6302, 6303, 6326, 6325
2555, 6303, 6304, 6327, 6326
2556, 6304, 6305, 6328, 6327
2557, 6305, 6306, 6329, 6328
2558, 6306, 6307, 6330, 6329
2559, 6307, 6308, 6331, 6330
2560, 6308, 6309, 6332, 6331
2561, 6309, 6310, 6333, 6332
2562, 6310, 6311, 6334, 6333
2563, 6311, 6312, 6335, 6334
2564, 6312, 6313, 6336, 6335
2565, 6313, 6314, 6337, 6336
2566, 6314, 6315, 6338, 6337
2567, 6315, 6316, 6339, 6338
2568, 6316, 6317, 6340, 6339
2569, 6317, 6318, 6341, 6340
2570, 6318, 6319, 6342, 6341
2571, 6319, 6320, 6343, 6342
2572, 6320, 887, 888, 6343
2573, 774, 6321, 6344, 775
2574, 6321, 6322, 6345, 6344
2575, 6322, 6323, 6346, 6345
2576, 6323, 6324, 6347, 6346
2577, 6324, 6325, 6348, 6347
2578, 6325, 6326, 6349, 6348
2579, 6326, 6327, 6350, 6349
2580, 6327, 6328, 6351, 6350
2581, 6328, 6329, 6352, 6351
2582, 6329, 6330, 6353, 6352
2583, 6330, 6331, 6354, 6353
2584, 6331, 6332, 6355, 6354
2585, 6332, 6333, 6356, 6355
2586, 6333, 6334, 6357, 6356
2587, 6334, 6335, 6358, 6357
2588, 6335, 6336, 6359, 6358
2589, 6336, 6337, 6360, 6359
2590, 6337, 6338, 6361, 6360
2591, 6338, 6339, 6362, 6361
2592, 6339, 6340, 6363, 6362
2593, 6340, 6341, 6364, 6363
2594, 6341, 6342, 6365, 6364
2595, 6342, 6343, 6366, 6365
2596, 6343, 888, 889, 6366
2597, 775, 6344, 6367, 776
2598, 6344, 6345, 6368, 6367
2599, 6345, 6346, 6369, 6368
2600, 6346, 6347, 6370, 6369
2601, 6347, 6348, 6371, 6370
2602, 6348, 6349, 6372, 6371
2603, 6349, 6350, 6373, 6372
2604, 6350, 6351, 6374, 6373
2605, 6351, 6352, 6375, 6374
2606, 6352, 6353, 6376, 6375
2607, 6353, 6354, 6377, 6376
2608, 6354, 6355, 6378, 6377
2609, 6355, 6356, 6379, 6378
2610, 6356, 6357, 6380, 6379
2611, 6357, 6358, 6381, 6380
2612, 6358, 6359, 6382, 6381
2613, 6359, 6360, 6383, 6382
2614, 6360, 6361, 6384, 6383
2615, 6361, 6362, 6385, 6384
2616, 6362, 6363, 6386, 6385
2617, 6363, 6364, 6387, 6386
2618, 6364, 6365, 6388, 6387
2619, 6365, 6366, 6389, 6388
2620, 6366, 889, 890, 6389
2621, 776, 6367, 6390, 777
2622, 6367, 6368, 6391, 6390
2623, 6368, 6369, 6392, 6391
2624, 6369, 6370, 6393, 6392
2625, 6370, 6371, 6394, 6393
2626, 6371, 6372, 6395, 6394
2627, 6372, 6373, 6396, 6395
2628, 6373, 6374, 6397, 6396
2629, 6374, 6375, 6398, 6397
2630, 6375, 6376, 6399, 6398
2631, 6376, 6377, 6400, 6399
2632, 6377, 6378, 6401, 6400
2633, 6378, 6379, 6402, 6401
2634, 6379, 6380, 6403, 6402
2635, 6380, 6381, 6404, 6403
2636, 6381, 6382, 6405, 6404
2637, 6382, 6383, 6406, 6405
2638, 6383, 6384, 6407, 6406
2639, 6384, 6385, 6408, 6407
2640, 6385, 6386, 6409, 6408
2641, 6386, 6387, 6410, 6409
2642, 6387, 6388, 6411, 6410
2643, 6388, 6389, 6412, 6411
2644, 6389, 890, 891, 6412
2645, 777, 6390, 6413, 778
2646, 6390, 6391, 6414, 6413
2647, 6391, 6392, 6415, 6414
2648, 6392, 6393, 6416, 6415
2649, 6393, 6394, 6417, 6416
2650, 6394, 6395, 6418, 6417
2651, 6395, 6396, 6419, 6418
2652, 6396, 6397, 6420, 6419
2653, 6397, 6398, 6421, 6420
2654, 6398, 6399, 6422, 6421
2655, 6399, 6400, 6423, 6422
2656, 6400, 6401, 6424, 6423
2657, 6401, 6402, 6425, 6424
2658, 6402, 6403, 6426, 6425
2659, 6403, 6404, 6427, 6426
2660, 6404, 6405, 6428, 6427
2661, 6405, 6406, 6429, 6428
2662, 6406, 6407, 6430, 6429
2663, 6407, 6408, 6431, 6430
2664, 6408, 6409, 6432, 6431
2665, 6409, 6410, 6433, 6432
2666, 6410, 6411, 6434, 6433
2667, 6411, 6412, 6435, 6434
2668, 6412, 891, 892, 6435
2669, 778, 6413, 6436, 779
2670, 6413, 6414, 6437, 6436
2671, 6414, 6415, 6438, 6437
2672, 6415, 6416, 6439, 6438
2673, 6416, 6417, 6440, 6439
2674, 6417, 6418, 6441, 6440
2675, 6418, 6419, 6442, 6441
2676, 6419, 6420, 6443, 6442
2677, 6420, 6421, 6444, 6443
2678, 6421, 6422, 6445, 6444
2679, 6422, 6423, 6446, 6445
2680, 6423, 6424, 6447, 6446
2681, 6424, 6425, 6448, 6447
2682, 6425, 6426, 6449, 6448
2683, 6426, 6427, 6450, 6449
2684, 6427, 6428, 6451, 6450
2685, 6428, 6429, 6452, 6451
2686, 6429, 6430, 6453, 6452
2687, 6430, 6431, 6454, 6453
2688, 6431, 6432, 6455, 6454
2689, 6432, 6433, 6456, 6455
2690, 6433, 6434, 6457, 6456
2691, 6434, 6435, 6458, 6457
2692, 6435, 892, 893, 6458
2693, 779, 6436, 6459, 780
2694, 6436, 6437, 6460, 6459
2695, 6437, 6438, 6461, 6460
2696, 6438, 6439, 6462, 6461
2697, 6439, 6440, 6463, 6462
2698, 6440, 6441, 6464, 6463
2699, 6441, 6442, 6465, 6464
2700, 6442, 6443, 6466, 6465
2701, 6443, 6444, 6467, 6466
2702, 6444, 6445, 6468, 6467
2703, 6445, 6446, 6469, 6468
2704, 6446, 6447, 6470, 6469
2705, 6447, 6448, 6471, 6470
2706, 6448, 6449, 6472, 6471
2707, 6449, 6450, 6473, 6472
2708, 6450, 6451, 6474, 6473
2709, 6451, 6452, 6475, 6474
2710, 6452, 6453, 6476, 6475
2711, 6453, 6454, 6477, 6476
2712, 6454, 6455, 6478, 6477
2713, 6455, 6456, 6479, 6478
2714, 6456, 6457, 6480, 6479
2715, 6457, 6458, 6481, 6480
2716, 6458, 893, 894, 6481
2717, 780, 6459, 6482, 781
2718, 6459, 6460, 6483, 6482
2719, 6460, 6461, 6484, 6483
2720, 6461, 6462, 6485, 6484
2721, 6462, 6463, 6486, 6485
2722, 6463, 6464, 6487, 6486
2723, 6464, 6465, 6488, 6487
2724, 6465, 6466, 6489, 6488
2725, 6466, 6467, 6490, 6489
2726, 6467, 6468, 6491, 6490
2727, 6468, 6469, 6492, 6491
2728, 6469, 6470, 6493, 6492
2729, 6470, 6471, 6494, 6493
2730, 6471, 6472, 6495, 6494
2731, 6472, 6473, 6496, 6495
2732, 6473, 6474, 6497, 6496
2733, 6474, 6475, 6498, 6497
2734, 6475, 6476, 6499, 6498
2735, 6476, 6477, 6500, 6499
2736, 6477, 6478, 6501, 6500
2737, 6478, 6479, 6502, 6501
2738, 6479, 6480, 6503, 6502
2739, 6480, 6481, 6504, 6503
2740, 6481, 894, 895, 6504
2741, 781, 6482, 6505, 782
2742, 6482, 6483, 6506, 6505
2743, 6483, 6484, 6507, 6506
2744, 6484, 6485, 6508, 6507
2745, 6485, 6486, 6509, 6508
2746, 6486, 6487, 6510, 6509
2747, 6487, 6488, 6511, 6510
2748, 6488, 6489, 6512, 6511
2749, 6489, 6490, 6513, 6512
2750, 6490, 6491, 6514, 6513
2751, 6491, 6492, 6515, 6514
2752, 6492, 6493, 6516, 6515
2753, 6493, 6494, 6517, 6516
2754, 6494, 6495, 6518, 6517
2755, 6495, 6496, 6519, 6518
2756, 6496, 6497, 6520, 6519
2757, 6497, 6498, 6521, 6520
2758, 6498, 6499, 6522, 6521
2759, 6499, 6500, 6523, 6522
2760, 6500, 6501, 6524, 6523
2761, 6501, 6502, 6525, 6524
2762, 6502, 6503, 6526, 6525
2763, 6503, 6504, 6527, 6526
2764, 6504, 895, 896, 6527
2765, 782, 6505, 6528, 783
2766, 6505, 6506, 6529, 6528
2767, 6506, 6507, 6530, 6529
2768, 6507, 6508, 6531, 6530
2769, 6508, 6509, 6532, 6531
2770, 6509, 6510, 6533, 6532
2771, 6510, 6511, 6534, 6533
2772, 6511, 6512, 6535, 6534
2773, 6512, 6513, 6536, 6535
2774, 6513, 6514, 6537, 6536
2775, 6514, 6515, 6538, 6537
2776, 6515, 6516, 6539, 6538
2777, 6516, 6517, 6540, 6539
2778, 6517, 6518, 6541, 6540
2779, 6518, 6519, 6542, 6541
2780, 6519, 6520, 6543, 6542
2781, 6520, 6521, 6544, 6543
2782, 6521, 6522, 6545, 6544
2783, 6522, 6523, 6546, 6545
2784, 6523, 6524, 6547, 6546
2785, 6524, 6525, 6548, 6547
2786, 6525, 6526, 6549, 6548
2787, 6526, 6527, 6550, 6549
2788, 6527, 896, 897, 6550
2789, 783, 6528, 6551, 784
2790, 6528, 6529, 6552, 6551
2791, 6529, 6530, 6553, 6552
2792, 6530, 6531, 6554, 6553
2793, 6531, 6532, 6555, 6554
2794, 6532, 6533, 6556, 6555
2795, 6533, 6534, 6557, 6556
2796, 6534, 6535, 6558, 6557
2797, 6535, 6536, 6559, 6558
2798, 6536, 6537, 6560, 6559
2799, 6537, 6538, 6561, 6560
2800, 6538, 6539, 6562, 6561
2801, 6539, 6540, 6563, 6562
2802, 6540, 6541, 6564, 6563
2803, 6541, 6542, 6565, 6564
2804, 6542, 6543, 6566, 6565
2805, 6543, 6544, 6567, 6566
2806, 6544, 6545, 6568, 6567
2807, 6545, 6546, 6569, 6568
2808, 6546, 6547, 6570, 6569
2809, 6547, 6548, 6571, 6570
2810, 6548, 6549, 6572, 6571
2811, 6549, 6550, 6573, 6572
2812, 6550, 897, 898, 6573
2813, 784, 6551, 6574, 785
2814, 6551, 6552, 6575, 6574
2815, 6552, 6553, 6576, 6575
2816, 6553, 6554, 6577, 6576
2817, 6554, 6555, 6578, 6577
2818, 6555, 6556, 6579, 6578
2819, 6556, 6557, 6580, 6579
2820, 6557, 6558, 6581, 6580
2821, 6558, 6559, 6582, 6581
2822, 6559, 6560, 6583, 6582
2823, 6560, 6561, 6584, 6583
2824, 6561, 6562, 6585, 6584
2825, 6562, 6563, 6586, 6585
2826, 6563, 6564, 6587, 6586
2827, 6564, 6565, 6588, 6587
2828, 6565, 6566, 6589, 6588
2829, 6566, 6567, 6590, 6589
2830, 6567, 6568, 6591, 6590
2831, 6568, 6569, 6592, 6591
2832, 6569, 6570, 6593, 6592
2833, 6570, 6571, 6594, 6593
2834, 6571, 6572, 6595, 6594
2835, 6572, 6573, 6596, 6595
2836, 6573, 898, 899, 6596
2837, 785, 6574, 6597, 786
2838, 6574, 6575, 6598, 6597
2839, 6575, 6576, 6599, 6598
2840, 6576, 6577, 6600, 6599
2841, 6577, 6578, 6601, 6600
2842, 6578, 6579, 6602, 6601
2843, 6579, 6580, 6603, 6602
2844, 6580, 6581, 6604, 6603
2845, 6581, 6582, 6605, 6604
2846, 6582, 6583, 6606, 6605
2847, 6583, 6584, 6607, 6606
2848, 6584, 6585, 6608, 6607
2849, 6585, 6586, 6609, 6608
2850, 6586, 6587, 6610, 6609
2851, 6587, 6588, 6611, 6610
2852, 6588, 6589, 6612, 6611
2853, 6589, 6590, 6613, 6612
2854, 6590, 6591, 6614, 6613
2855, 6591, 6592, 6615, 6614
2856, 6592, 6593, 6616, 6615
2857, 6593, 6594, 6617, 6616
2858, 6594, 6595, 6618, 6617
2859, 6595, 6596, 6619, 6618
2860, 6596, 899, 900, 6619
2861, 786, 6597, 6620, 787
2862, 6597, 6598, 6621, 6620
2863, 6598, 6599, 6622, 6621
2864, 6599, 6600, 6623, 6622
2865, 6600, 6601, 6624, 6623
2866, 6601, 6602, 6625, 6624
2867, 6602, 6603, 6626, 6625
2868, 6603, 6604, 6627, 6626
2869, 6604, 6605, 6628, 6627
2870, 6605, 6606, 6629, 6628
2871, 6606, 6607, 6630, 6629
2872, 6607, 6608, 6631, 6630
2873, 6608, 6609, 6632, 6631
2874, 6609, 6610, 6633, 6632
2875, 6610, 6611, 6634, 6633
2876, 6611, 6612, 6635, 6634
2877, 6612, 6613, 6636, 6635
2878, 6613, 6614, 6637, 6636
2879, 6614, 6615, 6638, 6637
2880, 6615, 6616, 6639, 6638
2881, 6616, 6617, 6640, 6639
2882, 6617, 6618, 6641, 6640
2883, 6618, 6619, 6642, 6641
2884, 6619, 900, 901, 6642
2885, 787, 6620, 6643, 788
2886, 6620, 6621, 6644, 6643
2887, 6621, 6622, 6645, 6644
2888, 6622, 6623, 6646, 6645
2889, 6623, 6624, 6647, 6646
2890, 6624, 6625, 6648, 6647
2891, 6625, 6626, 6649, 6648
2892, 6626, 6627, 6650, 6649
2893, 6627, 6628, 6651, 6650
2894, 6628, 6629, 6652, 6651
2895, 6629, 6630, 6653, 6652
2896, 6630, 6631, 6654, 6653
2897, 6631, 6632, 6655, 6654
2898, 6632, 6633, 6656, 6655
2899, 6633, 6634, 6657, 6656
2900, 6634, 6635, 6658, 6657
2901, 6635, 6636, 6659, 6658
2902, 6636, 6637, 6660, 6659
2903, 6637, 6638, 6661, 6660
2904, 6638, 6639, 6662, 6661
2905, 6639, 6640, 6663, 6662
2906, 6640, 6641, 6664, 6663
2907, 6641, 6642, 6665, 6664
2908, 6642, 901, 902, 6665
2909, 788, 6643, 6666, 789
2910, 6643, 6644, 6667, 6666
2911, 6644, 6645, 6668, 6667
2912, 6645, 6646, 6669, 6668
2913, 6646, 6647, 6670, 6669
2914, 6647, 6648, 6671, 6670
2915, 6648, 6649, 6672, 6671
2916, 6649, 6650, 6673, 6672
2917, 6650, 6651, 6674, 6673
2918, 6651, 6652, 6675, 6674
2919, 6652, 6653, 6676, 6675
2920, 6653, 6654, 6677, 6676
2921, 6654, 6655, 6678, 6677
2922, 6655, 6656, 6679, 6678
2923, 6656, 6657, 6680, 6679
2924, 6657, 6658, 6681, 6680
2925, 6658, 6659, 6682, 6681
2926, 6659, 6660, 6683, 6682
2927, 6660, 6661, 6684, 6683
2928, 6661, 6662, 6685, 6684
2929, 6662, 6663, 6686, 6685
2930, 6663, 6664, 6687, 6686
2931, 6664, 6665, 6688, 6687
2932, 6665, 902, 903, 6688
2933, 789, 6666, 6689, 790
2934, 6666, 6667, 6690, 6689
2935, 6667, 6668, 6691, 6690
2936, 6668, 6669, 6692, 6691
2937, 6669, 6670, 6693, 6692
2938, 6670, 6671, 6694, 6693
2939, 6671, 6672, 6695, 6694
2940, 6672, 6673, 6696, 6695
2941, 6673, 6674, 6697, 6696
2942, 6674, 6675, 6698, 6697
2943, 6675, 6676, 6699, 6698
2944, 6676, 6677, 6700, 6699
2945, 6677, 6678, 6701, 6700
2946, 6678, 6679, 6702, 6701
2947, 6679, 6680, 6703, 6702
2948, 6680, 6681, 6704, 6703
2949, 6681, 6682, 6705, 6704
2950, 6682, 6683, 6706, 6705
2951, 6683, 6684, 6707, 6706
2952, 6684, 6685, 6708, 6707
2953, 6685, 6686, 6709, 6708
2954, 6686, 6687, 6710, 6709
2955, 6687, 6688, 6711, 6710
2956, 6688, 903, 904, 6711
2957, 790, 6689, 6712, 791
2958, 6689, 6690, 6713, 6712
2959, 6690, 6691, 6714, 6713
2960, 6691, 6692, 6715, 6714
2961, 6692, 6693, 6716, 6715
2962, 6693, 6694, 6717, 6716
2963, 6694, 6695, 6718, 6717
2964, 6695, 6696, 6719, 6718
2965, 6696, 6697, 6720, 6719
2966, 6697, 6698, 6721, 6720
2967, 6698, 6699, 6722, 6721
2968, 6699, 6700, 6723, 6722
2969, 6700, 6701, 6724, 6723
2970, 6701, 6702, 6725, 6724
2971, 6702, 6703, 6726, 6725
2972, 6703, 6704, 6727, 6726
2973, 6704, 6705, 6728, 6727
2974, 6705, 6706, 6729, 6728
2975, 6706, 6707, 6730, 6729
2976, 6707, 6708, 6731, 6730
2977, 6708, 6709, 6732, 6731
2978, 6709, 6710, 6733, 6732
2979, 6710, 6711, 6734, 6733
2980, 6711, 904, 905, 6734
2981, 791, 6712, 6735, 792
2982, 6712, 6713, 6736, 6735
2983, 6713, 6714, 6737, 6736
2984, 6714, 6715, 6738, 6737
2985, 6715, 6716, 6739, 6738
2986, 6716, 6717, 6740, 6739
2987, 6717, 6718, 6741, 6740
2988, 6718, 6719, 6742, 6741
2989, 6719, 6720, 6743, 6742
2990, 6720, 6721, 6744, 6743
2991, 6721, 6722, 6745, 6744
2992, 6722, 6723, 6746, 6745
2993, 6723, 6724, 6747, 6746
2994, 6724, 6725, 6748, 6747
2995, 6725, 6726, 6749, 6748
2996, 6726, 6727, 6750, 6749
2997, 6727, 6728, 6751, 6750
2998, 6728, 6729, 6752, 6751
2999, 6729, 6730, 6753, 6752
3000, 6730, 6731, 6754, 6753
3001, 6731, 6732, 6755, 6754
3002, 6732, 6733, 6756, 6755
3003, 6733, 6734, 6757, 6756
3004, 6734, 905, 906, 6757
3005, 792, 6735, 6758, 793
3006, 6735, 6736, 6759, 6758
3007, 6736, 6737, 6760, 6759
3008, 6737, 6738, 6761, 6760
3009, 6738, 6739, 6762, 6761
3010, 6739, 6740, 6763, 6762
3011, 6740, 6741, 6764, 6763
3012, 6741, 6742, 6765, 6764
3013, 6742, 6743, 6766, 6765
3014, 6743, 6744, 6767, 6766
3015, 6744, 6745, 6768, 6767
3016, 6745, 6746, 6769, 6768
3017, 6746, 6747, 6770, 6769
3018, 6747, 6748, 6771, 6770
3019, 6748, 6749, 6772, 6771
3020, 6749, 6750, 6773, 6772
3021, 6750, 6751, 6774, 6773
3022, 6751, 6752, 6775, 6774
3023, 6752, 6753, 6776, 6775
3024, 6753, 6754, 6777, 6776
3025, 6754, 6755, 6778, 6777
3026, 6755, 6756, 6779, 6778
3027, 6756, 6757, 6780, 6779
3028, 6757, 906, 907, 6780
3029, 793, 6758, 6781, 794
3030, 6758, 6759, 6782, 6781
3031, 6759, 6760, 6783, 6782
3032, 6760, 6761, 6784, 6783
3033, 6761, 6762, 6785, 6784
3034, 6762, 6763, 6786, 6785
3035, 6763, 6764, 6787, 6786
3036, 6764, 6765, 6788, 6787
3037, 6765, 6766, 6789, 6788
3038, 6766, 6767, 6790, 6789
3039, 6767, 6768, 6791, 6790
3040, 6768, 6769, 6792, 6791
3041, 6769, 6770, 6793, 6792
3042, 6770, 6771, 6794, 6793
3043, 6771, 6772, 6795, 6794
3044, 6772, 6773, 6796, 6795
3045, 6773, 6774, 6797, 6796
3046, 6774, 6775, 6798, 6797
3047, 6775, 6776, 6799, 6798
3048, 6776, 6777, 6800, 6799
3049, 6777, 6778, 6801, 6800
3050, 6778, 6779, 6802, 6801
3051, 6779, 6780, 6803, 6802
3052, 6780, 907, 908, 6803
3053, 794, 6781, 6804, 795
3054, 6781, 6782, 6805, 6804
3055, 6782, 6783, 6806, 6805
3056, 6783, 6784, 6807, 6806
3057, 6784, 6785, 6808, 6807
3058, 6785, 6786, 6809, 6808
3059, 6786, 6787, 6810, 6809
3060, 6787, 6788, 6811, 6810
3061, 6788, 6789, 6812, 6811
3062, 6789, 6790, 6813, 6812
3063, 6790, 6791, 6814, 6813
3064, 6791, 6792, 6815, 6814
3065, 6792, 6793, 6816, 6815
3066, 6793, 6794, 6817, 6816
3067, 6794, 6795, 6818, 6817
3068, 6795, 6796, 6819, 6818
3069, 6796, 6797, 6820, 6819
3070, 6797, 6798, 6821, 6820
3071, 6798, 6799, 6822, 6821
3072, 6799, 6800, 6823, 6822
3073, 6800, 6801, 6824, 6823
3074, 6801, 6802, 6825, 6824
3075, 6802, 6803, 6826, 6825
3076, 6803, 908, 909, 6826
3077, 795, 6804, 864, 34
3078, 6804, 6805, 865, 864
3079, 6805, 6806, 866, 865
3080, 6806, 6807, 867, 866
3081, 6807, 6808, 868, 867
3082, 6808, 6809, 869, 868
3083, 6809, 6810, 870, 869
3084, 6810, 6811, 871, 870
3085, 6811, 6812, 872, 871
3086, 6812, 6813, 873, 872
3087, 6813, 6814, 874, 873
3088, 6814, 6815, 875, 874
3089, 6815, 6816, 876, 875
3090, 6816, 6817, 877, 876
3091, 6817, 6818, 878, 877
3092, 6818, 6819, 879, 878
3093, 6819, 6820, 880, 879
3094, 6820, 6821, 881, 880
3095, 6821, 6822, 882, 881
3096, 6822, 6823, 883, 882
3097, 6823, 6824, 884, 883
3098, 6824, 6825, 885, 884
3099, 6825, 6826, 886, 885
3100, 6826, 909, 38, 886
*ELEMENT, type=CPS4, ELSET=Surface43
36974, 35, 796, 6827, 910
36975, 910, 6827, 6828, 911
36976, 911, 6828, 6829, 912
36977, 912, 6829, 6830, 913
36978, 913, 6830, 6831, 914
36979, 914, 6831, 6832, 915
36980, 915, 6832, 6833, 916
36981, 916, 6833, 6834, 917
36982, 917, 6834, 6835, 918
36983, 918, 6835, 6836, 919
36984, 919, 6836, 6837, 920
36985, 920, 6837, 6838, 921
36986, 921, 6838, 6839, 922
36987, 922, 6839, 6840, 923
36988, 923, 6840, 6841, 924
36989, 924, 6841, 6842, 925
36990, 925, 6842, 6843, 926
36991, 926, 6843, 6844, 927
36992, 927, 6844, 6845, 928
36993, 928, 6845, 6846, 929
36994, 929, 6846, 6847, 930
36995, 930, 6847, 6848, 931
36996, 931, 6848, 6849, 932
36997, 932, 6849, 956, 39
36998, 796, 797, 6850, 6827
36999, 6827, 6850, 6851, 6828
37000, 6828, 6851, 6852, 6829
37001, 6829, 6852, 6853, 6830
37002, 6830, 6853, 6854, 6831
37003, 6831, 6854, 6855, 6832
37004, 6832, 6855, 6856, 6833
37005, 6833, 6856, 6857, 6834
37006, 6834, 6857, 6858, 6835
37007, 6835, 6858, 6859, 6836
37008, 6836, 6859, 6860, 6837
37009, 6837, 6860, 6861, 6838
37010, 6838, 6861, 6862, 6839
37011, 6839, 6862, 6863, 6840
37012, 6840, 6863, 6864, 6841
37013, 6841, 6864, 6865, 6842
37014, 6842, 6865, 6866, 6843
37015, 6843, 6866, 6867, 6844
37016, 6844, 6867, 6868, 6845
37017, 6845, 6868, 6869, 6846
37018, 6846, 6869, 6870, 6847
37019, 6847, 6870, 6871, 6848
37020, 6848, 6871, 6872, 6849
37021, 6849, 6872, 957, 956
37022, 797, 798, 6873, 6850
37023, 6850, 6873, 6874, 6851
37024, 6851, 6874, 6875, 6852
37025, 6852, 6875, 6876, 6853
37026, 6853, 6876, 6877, 6854
37027, 6854, 6877, 6878, 6855
37028, 6855, 6878, 6879, 6856
37029, 6856, 6879, 6880, 6857
37030, 6857, 6880, 6881, 6858
37031, 6858, 6881, 6882, 6859
37032, 6859, 6882, 6883, 6860
37033, 6860, 6883, 6884, 6861
37034, 6861, 6884, 6885, 6862
37035, 6862, 6885, 6886, 6863
37036, 6863, 6886, 6887, 6864
37037, 6864, 6887, 6888, 6865
37038, 6865, 6888, 6889, 6866
37039, 6866, 6889, 6890, 6867
37040, 6867, 6890, 6891, 6868
37041, 6868, 6891, 6892, 6869
37042, 6869, 6892, 6893, 6870
37043, 6870, 6893, 6894, 6871
37044, 6871, 6894, 6895, 6872
37045, 6872, 6895, 958, 957
37046, 798, 799, 6896, 6873
37047, 6873, 6896, 6897, 6874
37048, 6874, 6897, 6898, 6875
37049, 6875, 6898, 6899, 6876
37050, 6876, 6899, 6900, 6877
37051, 6877, 6900, 6901, 6878
37052, 6878, 6901, 6902, 6879
37053, 6879, 6902, 6903, 6880
37054, 6880, 6903, 6904, 6881
37055, 6881, 6904, 6905, 6882
37056, 6882, 6905, 6906, 6883
37057, 6883, 6906, 6907, 6884
37058, 6884, 6907, 6908, 6885
37059, 6885, 6908, 6909, 6886
37060, 6886, 6909, 6910, 6887
37061, 6887, 6910, 6911, 6888
37062, 6888, 6911, 6912, 6889
37063, 6889, 6912, 6913, 6890
37064, 6890, 6913, 6914, 6891
37065, 6891, 6914, 6915, 6892
37066, 6892, 6915, 6916, 6893
37067, 6893, 6916, 6917, 6894
37068, 6894, 6917, 6918, 6895
37069, 6895, 6918, 959, 958
37070, 799, 800, 6919, 6896
37071, 6896, 6919, 6920, 6897
37072, 6897, 6920, 6921, 6898
37073, 6898, 6921, 6922, 6899
37074, 6899, 6922, 6923, 6900
37075, 6900, 6923, 6924, 6901
37076, 6901, 6924, 6925, 6902
37077, 6902, 6925, 6926, 6903
37078, 6903, 6926, 6927, 6904
37079, 6904, 6927, 6928, 6905
37080, 6905, 6928, 6929, 6906
37081, 6906, 6929, 6930, 6907
37082, 6907, 6930, 6931, 6908
37083, 6908, 6931, 6932, 6909
37084, 6909, 6932, 6933, 6910
37085, 6910, 6933, 6934, 6911
37086, 6911, 6934, 6935, 6912
37087, 6912, 6935, 6936, 6913
37088, 6913, 6936, 6937, 6914
37089, 6914, 6937, 6938, 6915
37090, 6915, 6938, 6939, 6916
37091, 6916, 6939, 6940, 6917
37092, 6917, 6940, 6941, 6918
37093, 6918, 6941, 960, 959
37094, 800, 801, 6942, 6919
37095, 6919, 6942, 6943, 6920
37096, 6920, 6943, 6944, 6921
37097, 6921, 6944, 6945, 6922
37098, 6922, 6945, 6946, 6923
37099, 6923, 6946, 6947, 6924
37100, 6924, 6947, 6948, 6925
37101, 6925, 6948, 6949, 6926
37102, 6926, 6949, 6950, 6927
37103, 6927, 6950, 6951, 6928
37104, 6928, 6951, 6952, 6929
37105, 6929, 6952, 6953, 6930
37106, 6930, 6953, 6954, 6931
37107, 6931, 6954, 6955, 6932
37108, 6932, 6955, 6956, 6933
37109, 6933, 6956, 6957, 6934
37110, 6934, 6957, 6958, 6935
37111, 6935, 6958, 6959, 6936
37112, 6936, 6959, 6960, 6937
37113, 6937, 6960, 6961, 6938
37114, 6938, 6961, 6962, 6939
37115, 6939, 6962, 6963, 6940
37116, 6940, 6963, 6964, 6941
37117, 6941, 6964, 961, 960
37118, 801, 802, 6965, 6942
37119, 6942, 6965, 6966, 6943
37120, 6943, 6966, 6967, 6944
37121, 6944, 6967, 6968, 6945
37122, 6945, 6968, 6969, 6946
37123, 6946, 6969, 6970, 6947
37124, 6947, 6970, 6971, 6948
37125, 6948, 6971, 6972, 6949
37126, 6949, 6972, 6973, 6950
37127, 6950, 6973, 6974, 6951
37128, 6951, 6974, 6975, 6952
37129, 6952, 6975, 6976, 6953
37130, 6953, 6976, 6977, 6954
37131, 6954, 6977, 6978, 6955
37132, 6955, 6978, 6979, 6956
37133, 6956, 6979, 6980, 6957
37134, 6957, 6980, 6981, 6958
37135, 6958, 6981, 6982, 6959
37136, 6959, 6982, 6983, 6960
37137, 6960, 6983, 6984, 6961
37138, 6961, 6984, 6985, 6962
37139, 6962, 6985, 6986, 6963
37140, 6963, 6986, 6987, 6964
37141, 6964, 6987, 962, 961
37142, 802, 803, 6988, 6965
37143, 6965, 6988, 6989, 6966
37144, 6966, 6989, 6990, 6967
37145, 6967, 6990, 6991, 6968
37146, 6968, 6991, 6992, 6969
37147, 6969, 6992, 6993, 6970
37148, 6970, 6993, 6994, 6971
37149, 6971, 6994, 6995, 6972
37150, 6972, 6995, 6996, 6973
37151, 6973, 6996, 6997, 6974
37152, 6974, 6997, 6998, 6975
37153, 6975, 6998, 6999, 6976
37154, 6976, 6999, 7000, 6977
37155, 6977, 7000, 7001, 6978
37156, 6978, 7001, 7002, 6979
37157, 6979, 7002, 7003, 6980
37158, 6980, 7003, 7004, 6981
37159, 6981, 7004, 7005, 6982
37160, 6982, 7005, 7006, 6983
37161, 6983, 7006, 7007, 6984
37162, 6984, 7007, 7008, 6985
37163, 6985, 7008, 7009, 6986
37164, 6986, 7009, 7010, 6987
37165, 6987, 7010, 963, 962
37166, 803, 804, 7011, 6988
37167, 6988, 7011, 7012, 6989
37168, 6989, 7012, 7013, 6990
37169, 6990, 7013, 7014, 6991
37170, 6991, 7014, 7015, 6992
37171, 6992, 7015, 7016, 6993
37172, 6993, 7016, 7017, 6994
37173, 6994, 7017, 7018, 6995
37174, 6995, 7018, 7019, 6996
37175, 6996, 7019, 7020, 6997
37176, 6997, 7020, 7021, 6998
37177, 6998, 7021, 7022, 6999
37178, 6999, 7022, 7023, 7000
37179, 7000, 7023, 7024, 7001
37180, 7001, 7024, 7025, 7002
37181, 7002, 7025, 7026, 7003
37182, 7003, 7026, 7027, 7004
37183, 7004, 7027, 7028, 7005
37184, 7005, 7028, 7029, 7006
37185, 7006, 7029, 7030, 7007
37186, 7007, 7030, 7031, 7008
37187, 7008, 7031, 7032, 7009
37188, 7009, 7032, 7033, 7010
37189, 7010, 7033, 964, 963
37190, 804, 805, 7034, 7011
37191, 7011, 7034, 7035, 7012
37192, 7012, 7035, 7036, 7013
37193, 7013, 7036, 7037, 7014
37194, 7014, 7037, 7038, 7015
37195, 7015, 7038, 7039, 7016
37196, 7016, 7039, 7040, 7017
37197, 7017, 7040, 7041, 7018
37198, 7018, 7041, 7042, 7019
37199, 7019, 7042, 7043, 7020
37200, 7020, 7043, 7044, 7021
37201, 7021, 7044, 7045, 7022
37202, 7022, 7045, 7046, 7023
37203, 7023, 7046, 7047, 7024
37204, 7024, 7047, 7048, 7025
37205, 7025, 7048, 7049, 7026
37206, 7026, 7049, 7050, 7027
37207, 7027, 7050, 7051, 7028
37208, 7028, 7051, 7052, 7029
37209, 7029, 7052, 7053, 7030
37210, 7030, 7053, 7054, 7031
37211, 7031, 7054, 7055, 7032
