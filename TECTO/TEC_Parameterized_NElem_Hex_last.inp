9023, 1.05, 0.95, 0.41666666666667
9024, 1.05, 1, 0.41666666666667
9025, 1.05, 1.05, 0.41666666666667
9026, 1.05, 1.1, 0.41666666666667
9027, 1.05, 1.15, 0.41666666666667
9028, 1.05, 1.2, 0.41666666666667
9029, 1.05, 1.25, 0.41666666666667
9030, 1.05, 1.3, 0.41666666666667
9031, 1.05, 0.2, 0.45833333333333
9032, 1.05, 0.25, 0.45833333333333
9033, 1.05, 0.3, 0.45833333333333
9034, 1.05, 0.35, 0.45833333333333
9035, 1.05, 0.4, 0.45833333333333
9036, 1.05, 0.45, 0.45833333333333
9037, 1.05, 0.5, 0.45833333333333
9038, 1.05, 0.55, 0.45833333333333
9039, 1.05, 0.6, 0.45833333333333
9040, 1.05, 0.65, 0.45833333333333
9041, 1.05, 0.7, 0.45833333333333
9042, 1.05, 0.75, 0.45833333333333
9043, 1.05, 0.8, 0.45833333333333
9044, 1.05, 0.85, 0.45833333333333
9045, 1.05, 0.9, 0.45833333333333
9046, 1.05, 0.95, 0.45833333333333
9047, 1.05, 1, 0.45833333333333
9048, 1.05, 1.05, 0.45833333333333
9049, 1.05, 1.1, 0.45833333333333
9050, 1.05, 1.15, 0.45833333333333
9051, 1.05, 1.2, 0.45833333333333
9052, 1.05, 1.25, 0.45833333333333
9053, 1.05, 1.3, 0.45833333333333
9054, 1.15, 1.3, 0.041666666666667
9055, 1.15, 1.25, 0.041666666666667
9056, 1.15, 1.2, 0.041666666666667
9057, 1.15, 1.15, 0.041666666666667
9058, 1.15, 1.1, 0.041666666666667
9059, 1.15, 1.05, 0.041666666666667
9060, 1.15, 1, 0.041666666666667
9061, 1.15, 0.95, 0.041666666666667
9062, 1.15, 0.9, 0.041666666666667
9063, 1.15, 0.85, 0.041666666666667
9064, 1.15, 0.8, 0.041666666666667
9065, 1.15, 0.75, 0.041666666666667
9066, 1.15, 0.7, 0.041666666666667
9067, 1.15, 0.65, 0.041666666666667
9068, 1.15, 0.6, 0.041666666666667
9069, 1.15, 0.55, 0.041666666666667
9070, 1.15, 0.5, 0.041666666666667
9071, 1.15, 0.45, 0.041666666666667
9072, 1.15, 0.4, 0.041666666666667
9073, 1.15, 0.35, 0.041666666666667
9074, 1.15, 0.3, 0.041666666666667
9075, 1.15, 0.25, 0.041666666666667
9076, 1.15, 0.2, 0.041666666666667
9077, 1.15, 1.3, 0.083333333333333
9078, 1.15, 1.25, 0.083333333333333
9079, 1.15, 1.2, 0.083333333333333
9080, 1.15, 1.15, 0.083333333333333
9081, 1.15, 1.1, 0.083333333333333
9082, 1.15, 1.05, 0.083333333333333
9083, 1.15, 1, 0.083333333333333
9084, 1.15, 0.95, 0.083333333333333
9085, 1.15, 0.9, 0.083333333333333
9086, 1.15, 0.85, 0.083333333333333
9087, 1.15, 0.8, 0.083333333333333
9088, 1.15, 0.75, 0.083333333333333
9089, 1.15, 0.7, 0.083333333333333
9090, 1.15, 0.65, 0.083333333333333
9091, 1.15, 0.6, 0.083333333333333
9092, 1.15, 0.55, 0.083333333333333
9093, 1.15, 0.5, 0.083333333333333
9094, 1.15, 0.45, 0.083333333333333
9095, 1.15, 0.4, 0.083333333333333
9096, 1.15, 0.35, 0.083333333333333
9097, 1.15, 0.3, 0.083333333333333
9098, 1.15, 0.25, 0.083333333333333
9099, 1.15, 0.2, 0.083333333333333
9100, 1.15, 1.3, 0.125
9101, 1.15, 1.25, 0.125
9102, 1.15, 1.2, 0.125
9103, 1.15, 1.15, 0.125
9104, 1.15, 1.1, 0.125
9105, 1.15, 1.05, 0.125
9106, 1.15, 1, 0.125
9107, 1.15, 0.95, 0.125
9108, 1.15, 0.9, 0.125
9109, 1.15, 0.85, 0.125
9110, 1.15, 0.8, 0.125
9111, 1.15, 0.75, 0.125
9112, 1.15, 0.7, 0.125
9113, 1.15, 0.65, 0.125
9114, 1.15, 0.6, 0.125
9115, 1.15, 0.55, 0.125
9116, 1.15, 0.5, 0.125
9117, 1.15, 0.45, 0.125
9118, 1.15, 0.4, 0.125
9119, 1.15, 0.35, 0.125
9120, 1.15, 0.3, 0.125
9121, 1.15, 0.25, 0.125
9122, 1.15, 0.2, 0.125
9123, 1.15, 1.3, 0.16666666666667
9124, 1.15, 1.25, 0.16666666666667
9125, 1.15, 1.2, 0.16666666666667
9126, 1.15, 1.15, 0.16666666666667
9127, 1.15, 1.1, 0.16666666666667
9128, 1.15, 1.05, 0.16666666666667
9129, 1.15, 1, 0.16666666666667
9130, 1.15, 0.95, 0.16666666666667
9131, 1.15, 0.9, 0.16666666666667
9132, 1.15, 0.85, 0.16666666666667
9133, 1.15, 0.8, 0.16666666666667
9134, 1.15, 0.75, 0.16666666666667
9135, 1.15, 0.7, 0.16666666666667
9136, 1.15, 0.65, 0.16666666666667
9137, 1.15, 0.6, 0.16666666666667
9138, 1.15, 0.55, 0.16666666666667
9139, 1.15, 0.5, 0.16666666666667
9140, 1.15, 0.45, 0.16666666666667
9141, 1.15, 0.4, 0.16666666666667
9142, 1.15, 0.35, 0.16666666666667
9143, 1.15, 0.3, 0.16666666666667
9144, 1.15, 0.25, 0.16666666666667
9145, 1.15, 0.2, 0.16666666666667
9146, 1.15, 1.3, 0.20833333333333
9147, 1.15, 1.25, 0.20833333333333
9148, 1.15, 1.2, 0.20833333333333
9149, 1.15, 1.15, 0.20833333333333
9150, 1.15, 1.1, 0.20833333333333
9151, 1.15, 1.05, 0.20833333333333
9152, 1.15, 1, 0.20833333333333
9153, 1.15, 0.95, 0.20833333333333
9154, 1.15, 0.9, 0.20833333333333
9155, 1.15, 0.85, 0.20833333333333
9156, 1.15, 0.8, 0.20833333333333
9157, 1.15, 0.75, 0.20833333333333
9158, 1.15, 0.7, 0.20833333333333
9159, 1.15, 0.65, 0.20833333333333
9160, 1.15, 0.6, 0.20833333333333
9161, 1.15, 0.55, 0.20833333333333
9162, 1.15, 0.5, 0.20833333333333
9163, 1.15, 0.45, 0.20833333333333
9164, 1.15, 0.4, 0.20833333333333
9165, 1.15, 0.35, 0.20833333333333
9166, 1.15, 0.3, 0.20833333333333
9167, 1.15, 0.25, 0.20833333333333
9168, 1.15, 0.2, 0.20833333333333
9169, 1.15, 1.3, 0.25
9170, 1.15, 1.25, 0.25
9171, 1.15, 1.2, 0.25
9172, 1.15, 1.15, 0.25
9173, 1.15, 1.1, 0.25
9174, 1.15, 1.05, 0.25
9175, 1.15, 1, 0.25
9176, 1.15, 0.95, 0.25
9177, 1.15, 0.9, 0.25
9178, 1.15, 0.85, 0.25
9179, 1.15, 0.8, 0.25
9180, 1.15, 0.75, 0.25
9181, 1.15, 0.7, 0.25
9182, 1.15, 0.65, 0.25
9183, 1.15, 0.6, 0.25
9184, 1.15, 0.55, 0.25
9185, 1.15, 0.5, 0.25
9186, 1.15, 0.45, 0.25
9187, 1.15, 0.4, 0.25
9188, 1.15, 0.35, 0.25
9189, 1.15, 0.3, 0.25
9190, 1.15, 0.25, 0.25
9191, 1.15, 0.2, 0.25
9192, 1.15, 1.3, 0.29166666666667
9193, 1.15, 1.25, 0.29166666666667
9194, 1.15, 1.2, 0.29166666666667
9195, 1.15, 1.15, 0.29166666666667
9196, 1.15, 1.1, 0.29166666666667
9197, 1.15, 1.05, 0.29166666666667
9198, 1.15, 1, 0.29166666666667
9199, 1.15, 0.95, 0.29166666666667
9200, 1.15, 0.9, 0.29166666666667
9201, 1.15, 0.85, 0.29166666666667
9202, 1.15, 0.8, 0.29166666666667
9203, 1.15, 0.75, 0.29166666666667
9204, 1.15, 0.7, 0.29166666666667
9205, 1.15, 0.65, 0.29166666666667
9206, 1.15, 0.6, 0.29166666666667
9207, 1.15, 0.55, 0.29166666666667
9208, 1.15, 0.5, 0.29166666666667
9209, 1.15, 0.45, 0.29166666666667
9210, 1.15, 0.4, 0.29166666666667
9211, 1.15, 0.35, 0.29166666666667
9212, 1.15, 0.3, 0.29166666666667
9213, 1.15, 0.25, 0.29166666666667
9214, 1.15, 0.2, 0.29166666666667
9215, 1.15, 1.3, 0.33333333333333
9216, 1.15, 1.25, 0.33333333333333
9217, 1.15, 1.2, 0.33333333333333
9218, 1.15, 1.15, 0.33333333333333
9219, 1.15, 1.1, 0.33333333333333
9220, 1.15, 1.05, 0.33333333333333
9221, 1.15, 1, 0.33333333333333
9222, 1.15, 0.95, 0.33333333333333
9223, 1.15, 0.9, 0.33333333333333
9224, 1.15, 0.85, 0.33333333333333
9225, 1.15, 0.8, 0.33333333333333
9226, 1.15, 0.75, 0.33333333333333
9227, 1.15, 0.7, 0.33333333333333
9228, 1.15, 0.65, 0.33333333333333
9229, 1.15, 0.6, 0.33333333333333
9230, 1.15, 0.55, 0.33333333333333
9231, 1.15, 0.5, 0.33333333333333
9232, 1.15, 0.45, 0.33333333333333
9233, 1.15, 0.4, 0.33333333333333
9234, 1.15, 0.35, 0.33333333333333
9235, 1.15, 0.3, 0.33333333333333
9236, 1.15, 0.25, 0.33333333333333
9237, 1.15, 0.2, 0.33333333333333
9238, 1.15, 1.3, 0.375
9239, 1.15, 1.25, 0.375
9240, 1.15, 1.2, 0.375
9241, 1.15, 1.15, 0.375
9242, 1.15, 1.1, 0.375
9243, 1.15, 1.05, 0.375
9244, 1.15, 1, 0.375
9245, 1.15, 0.95, 0.375
9246, 1.15, 0.9, 0.375
9247, 1.15, 0.85, 0.375
9248, 1.15, 0.8, 0.375
9249, 1.15, 0.75, 0.375
9250, 1.15, 0.7, 0.375
9251, 1.15, 0.65, 0.375
9252, 1.15, 0.6, 0.375
9253, 1.15, 0.55, 0.375
9254, 1.15, 0.5, 0.375
9255, 1.15, 0.45, 0.375
9256, 1.15, 0.4, 0.375
9257, 1.15, 0.35, 0.375
9258, 1.15, 0.3, 0.375
9259, 1.15, 0.25, 0.375
9260, 1.15, 0.2, 0.375
9261, 1.15, 1.3, 0.41666666666667
9262, 1.15, 1.25, 0.41666666666667
9263, 1.15, 1.2, 0.41666666666667
9264, 1.15, 1.15, 0.41666666666667
9265, 1.15, 1.1, 0.41666666666667
9266, 1.15, 1.05, 0.41666666666667
9267, 1.15, 1, 0.41666666666667
9268, 1.15, 0.95, 0.41666666666667
9269, 1.15, 0.9, 0.41666666666667
9270, 1.15, 0.85, 0.41666666666667
9271, 1.15, 0.8, 0.41666666666667
9272, 1.15, 0.75, 0.41666666666667
9273, 1.15, 0.7, 0.41666666666667
9274, 1.15, 0.65, 0.41666666666667
9275, 1.15, 0.6, 0.41666666666667
9276, 1.15, 0.55, 0.41666666666667
9277, 1.15, 0.5, 0.41666666666667
9278, 1.15, 0.45, 0.41666666666667
9279, 1.15, 0.4, 0.41666666666667
9280, 1.15, 0.35, 0.41666666666667
9281, 1.15, 0.3, 0.41666666666667
9282, 1.15, 0.25, 0.41666666666667
9283, 1.15, 0.2, 0.41666666666667
9284, 1.15, 1.3, 0.45833333333333
9285, 1.15, 1.25, 0.45833333333333
9286, 1.15, 1.2, 0.45833333333333
9287, 1.15, 1.15, 0.45833333333333
9288, 1.15, 1.1, 0.45833333333333
9289, 1.15, 1.05, 0.45833333333333
9290, 1.15, 1, 0.45833333333333
9291, 1.15, 0.95, 0.45833333333333
9292, 1.15, 0.9, 0.45833333333333
9293, 1.15, 0.85, 0.45833333333333
9294, 1.15, 0.8, 0.45833333333333
9295, 1.15, 0.75, 0.45833333333333
9296, 1.15, 0.7, 0.45833333333333
9297, 1.15, 0.65, 0.45833333333333
9298, 1.15, 0.6, 0.45833333333333
9299, 1.15, 0.55, 0.45833333333333
9300, 1.15, 0.5, 0.45833333333333
9301, 1.15, 0.45, 0.45833333333333
9302, 1.15, 0.4, 0.45833333333333
9303, 1.15, 0.35, 0.45833333333333
9304, 1.15, 0.3, 0.45833333333333
9305, 1.15, 0.25, 0.45833333333333
9306, 1.15, 0.2, 0.45833333333333
9307, 0.041666666666667, 0.2, -0.1
9308, 0.041666666666667, 0.25, -0.1
9309, 0.041666666666667, 0.3, -0.1
9310, 0.041666666666667, 0.35, -0.1
9311, 0.041666666666667, 0.4, -0.1
9312, 0.041666666666667, 0.45, -0.1
9313, 0.041666666666667, 0.5, -0.1
9314, 0.041666666666667, 0.55, -0.1
9315, 0.041666666666667, 0.6, -0.1
9316, 0.041666666666667, 0.65, -0.1
9317, 0.041666666666667, 0.7, -0.1
9318, 0.041666666666667, 0.75, -0.1
9319, 0.041666666666667, 0.8, -0.1
9320, 0.041666666666667, 0.85, -0.1
9321, 0.041666666666667, 0.9, -0.1
9322, 0.041666666666667, 0.95, -0.1
9323, 0.041666666666667, 1, -0.1
9324, 0.041666666666667, 1.05, -0.1
9325, 0.041666666666667, 1.1, -0.1
9326, 0.041666666666667, 1.15, -0.1
9327, 0.041666666666667, 1.2, -0.1
9328, 0.041666666666667, 1.25, -0.1
9329, 0.041666666666667, 1.3, -0.1
9330, 0.083333333333333, 0.2, -0.1
9331, 0.083333333333333, 0.25, -0.1
9332, 0.083333333333333, 0.3, -0.1
9333, 0.083333333333333, 0.35, -0.1
9334, 0.083333333333333, 0.4, -0.1
9335, 0.083333333333333, 0.45, -0.1
9336, 0.083333333333333, 0.5, -0.1
9337, 0.083333333333333, 0.55, -0.1
9338, 0.083333333333333, 0.6, -0.1
9339, 0.083333333333333, 0.65, -0.1
9340, 0.083333333333333, 0.7, -0.1
9341, 0.083333333333333, 0.75, -0.1
9342, 0.083333333333333, 0.8, -0.1
9343, 0.083333333333333, 0.85, -0.1
9344, 0.083333333333333, 0.9, -0.1
9345, 0.083333333333333, 0.95, -0.1
9346, 0.083333333333333, 1, -0.1
9347, 0.083333333333333, 1.05, -0.1
9348, 0.083333333333333, 1.1, -0.1
9349, 0.083333333333333, 1.15, -0.1
9350, 0.083333333333333, 1.2, -0.1
9351, 0.083333333333333, 1.25, -0.1
9352, 0.083333333333333, 1.3, -0.1
9353, 0.125, 0.2, -0.1
9354, 0.125, 0.25, -0.1
9355, 0.125, 0.3, -0.1
9356, 0.125, 0.35, -0.1
9357, 0.125, 0.4, -0.1
9358, 0.125, 0.45, -0.1
9359, 0.125, 0.5, -0.1
9360, 0.125, 0.55, -0.1
9361, 0.125, 0.6, -0.1
9362, 0.125, 0.65, -0.1
9363, 0.125, 0.7, -0.1
9364, 0.125, 0.75, -0.1
9365, 0.125, 0.8, -0.1
9366, 0.125, 0.85, -0.1
9367, 0.125, 0.9, -0.1
9368, 0.125, 0.95, -0.1
9369, 0.125, 1, -0.1
9370, 0.125, 1.05, -0.1
9371, 0.125, 1.1, -0.1
9372, 0.125, 1.15, -0.1
9373, 0.125, 1.2, -0.1
9374, 0.125, 1.25, -0.1
9375, 0.125, 1.3, -0.1
9376, 0.16666666666667, 0.2, -0.1
9377, 0.16666666666667, 0.25, -0.1
9378, 0.16666666666667, 0.3, -0.1
9379, 0.16666666666667, 0.35, -0.1
9380, 0.16666666666667, 0.4, -0.1
9381, 0.16666666666667, 0.45, -0.1
9382, 0.16666666666667, 0.5, -0.1
9383, 0.16666666666667, 0.55, -0.1
9384, 0.16666666666667, 0.6, -0.1
9385, 0.16666666666667, 0.65, -0.1
9386, 0.16666666666667, 0.7, -0.1
9387, 0.16666666666667, 0.75, -0.1
9388, 0.16666666666667, 0.8, -0.1
9389, 0.16666666666667, 0.85, -0.1
9390, 0.16666666666667, 0.9, -0.1
9391, 0.16666666666667, 0.95, -0.1
9392, 0.16666666666667, 1, -0.1
9393, 0.16666666666667, 1.05, -0.1
9394, 0.16666666666667, 1.1, -0.1
9395, 0.16666666666667, 1.15, -0.1
9396, 0.16666666666667, 1.2, -0.1
9397, 0.16666666666667, 1.25, -0.1
9398, 0.16666666666667, 1.3, -0.1
9399, 0.20833333333333, 0.2, -0.1
9400, 0.20833333333333, 0.25, -0.1
9401, 0.20833333333333, 0.3, -0.1
9402, 0.20833333333333, 0.35, -0.1
9403, 0.20833333333333, 0.4, -0.1
9404, 0.20833333333333, 0.45, -0.1
9405, 0.20833333333333, 0.5, -0.1
9406, 0.20833333333333, 0.55, -0.1
9407, 0.20833333333333, 0.6, -0.1
9408, 0.20833333333333, 0.65, -0.1
9409, 0.20833333333333, 0.7, -0.1
9410, 0.20833333333333, 0.75, -0.1
9411, 0.20833333333333, 0.8, -0.1
9412, 0.20833333333333, 0.85, -0.1
9413, 0.20833333333333, 0.9, -0.1
9414, 0.20833333333333, 0.95, -0.1
9415, 0.20833333333333, 1, -0.1
9416, 0.20833333333333, 1.05, -0.1
9417, 0.20833333333333, 1.1, -0.1
9418, 0.20833333333333, 1.15, -0.1
9419, 0.20833333333333, 1.2, -0.1
9420, 0.20833333333333, 1.25, -0.1
9421, 0.20833333333333, 1.3, -0.1
9422, 0.25, 0.2, -0.1
9423, 0.25, 0.25, -0.1
9424, 0.25, 0.3, -0.1
9425, 0.25, 0.35, -0.1
9426, 0.25, 0.4, -0.1
9427, 0.25, 0.45, -0.1
9428, 0.25, 0.5, -0.1
9429, 0.25, 0.55, -0.1
9430, 0.25, 0.6, -0.1
9431, 0.25, 0.65, -0.1
9432, 0.25, 0.7, -0.1
9433, 0.25, 0.75, -0.1
9434, 0.25, 0.8, -0.1
9435, 0.25, 0.85, -0.1
9436, 0.25, 0.9, -0.1
9437, 0.25, 0.95, -0.1
9438, 0.25, 1, -0.1
9439, 0.25, 1.05, -0.1
9440, 0.25, 1.1, -0.1
9441, 0.25, 1.15, -0.1
9442, 0.25, 1.2, -0.1
9443, 0.25, 1.25, -0.1
9444, 0.25, 1.3, -0.1
9445, 0.29166666666667, 0.2, -0.1
9446, 0.29166666666667, 0.25, -0.1
9447, 0.29166666666667, 0.3, -0.1
9448, 0.29166666666667, 0.35, -0.1
9449, 0.29166666666667, 0.4, -0.1
9450, 0.29166666666667, 0.45, -0.1
9451, 0.29166666666667, 0.5, -0.1
9452, 0.29166666666667, 0.55, -0.1
9453, 0.29166666666667, 0.6, -0.1
9454, 0.29166666666667, 0.65, -0.1
9455, 0.29166666666667, 0.7, -0.1
9456, 0.29166666666667, 0.75, -0.1
9457, 0.29166666666667, 0.8, -0.1
9458, 0.29166666666667, 0.85, -0.1
9459, 0.29166666666667, 0.9, -0.1
9460, 0.29166666666667, 0.95, -0.1
9461, 0.29166666666667, 1, -0.1
9462, 0.29166666666667, 1.05, -0.1
9463, 0.29166666666667, 1.1, -0.1
9464, 0.29166666666667, 1.15, -0.1
9465, 0.29166666666667, 1.2, -0.1
9466, 0.29166666666667, 1.25, -0.1
9467, 0.29166666666667, 1.3, -0.1
9468, 0.33333333333333, 0.2, -0.1
9469, 0.33333333333333, 0.25, -0.1
9470, 0.33333333333333, 0.3, -0.1
9471, 0.33333333333333, 0.35, -0.1
9472, 0.33333333333333, 0.4, -0.1
9473, 0.33333333333333, 0.45, -0.1
9474, 0.33333333333333, 0.5, -0.1
9475, 0.33333333333333, 0.55, -0.1
9476, 0.33333333333333, 0.6, -0.1
9477, 0.33333333333333, 0.65, -0.1
9478, 0.33333333333333, 0.7, -0.1
9479, 0.33333333333333, 0.75, -0.1
9480, 0.33333333333333, 0.8, -0.1
9481, 0.33333333333333, 0.85, -0.1
9482, 0.33333333333333, 0.9, -0.1
9483, 0.33333333333333, 0.95, -0.1
9484, 0.33333333333333, 1, -0.1
9485, 0.33333333333333, 1.05, -0.1
9486, 0.33333333333333, 1.1, -0.1
9487, 0.33333333333333, 1.15, -0.1
9488, 0.33333333333333, 1.2, -0.1
9489, 0.33333333333333, 1.25, -0.1
9490, 0.33333333333333, 1.3, -0.1
9491, 0.375, 0.2, -0.1
9492, 0.375, 0.25, -0.1
9493, 0.375, 0.3, -0.1
9494, 0.375, 0.35, -0.1
9495, 0.375, 0.4, -0.1
9496, 0.375, 0.45, -0.1
9497, 0.375, 0.5, -0.1
9498, 0.375, 0.55, -0.1
9499, 0.375, 0.6, -0.1
9500, 0.375, 0.65, -0.1
9501, 0.375, 0.7, -0.1
9502, 0.375, 0.75, -0.1
9503, 0.375, 0.8, -0.1
9504, 0.375, 0.85, -0.1
9505, 0.375, 0.9, -0.1
9506, 0.375, 0.95, -0.1
9507, 0.375, 1, -0.1
9508, 0.375, 1.05, -0.1
9509, 0.375, 1.1, -0.1
9510, 0.375, 1.15, -0.1
9511, 0.375, 1.2, -0.1
9512, 0.375, 1.25, -0.1
9513, 0.375, 1.3, -0.1
9514, 0.41666666666667, 0.2, -0.1
9515, 0.41666666666667, 0.25, -0.1
9516, 0.41666666666667, 0.3, -0.1
9517, 0.41666666666667, 0.35, -0.1
9518, 0.41666666666667, 0.4, -0.1
9519, 0.41666666666667, 0.45, -0.1
9520, 0.41666666666667, 0.5, -0.1
9521, 0.41666666666667, 0.55, -0.1
9522, 0.41666666666667, 0.6, -0.1
9523, 0.41666666666667, 0.65, -0.1
9524, 0.41666666666667, 0.7, -0.1
9525, 0.41666666666667, 0.75, -0.1
9526, 0.41666666666667, 0.8, -0.1
9527, 0.41666666666667, 0.85, -0.1
9528, 0.41666666666667, 0.9, -0.1
9529, 0.41666666666667, 0.95, -0.1
9530, 0.41666666666667, 1, -0.1
9531, 0.41666666666667, 1.05, -0.1
9532, 0.41666666666667, 1.1, -0.1
9533, 0.41666666666667, 1.15, -0.1
9534, 0.41666666666667, 1.2, -0.1
9535, 0.41666666666667, 1.25, -0.1
9536, 0.41666666666667, 1.3, -0.1
9537, 0.45833333333333, 0.2, -0.1
9538, 0.45833333333333, 0.25, -0.1
9539, 0.45833333333333, 0.3, -0.1
9540, 0.45833333333333, 0.35, -0.1
9541, 0.45833333333333, 0.4, -0.1
9542, 0.45833333333333, 0.45, -0.1
9543, 0.45833333333333, 0.5, -0.1
9544, 0.45833333333333, 0.55, -0.1
9545, 0.45833333333333, 0.6, -0.1
9546, 0.45833333333333, 0.65, -0.1
9547, 0.45833333333333, 0.7, -0.1
9548, 0.45833333333333, 0.75, -0.1
9549, 0.45833333333333, 0.8, -0.1
9550, 0.45833333333333, 0.85, -0.1
9551, 0.45833333333333, 0.9, -0.1
9552, 0.45833333333333, 0.95, -0.1
9553, 0.45833333333333, 1, -0.1
9554, 0.45833333333333, 1.05, -0.1
9555, 0.45833333333333, 1.1, -0.1
9556, 0.45833333333333, 1.15, -0.1
9557, 0.45833333333333, 1.2, -0.1
9558, 0.45833333333333, 1.25, -0.1
9559, 0.45833333333333, 1.3, -0.1
9560, 0.5, 0.2, -0.1
9561, 0.5, 0.25, -0.1
9562, 0.5, 0.3, -0.1
9563, 0.5, 0.35, -0.1
9564, 0.5, 0.4, -0.1
9565, 0.5, 0.45, -0.1
9566, 0.5, 0.5, -0.1
9567, 0.5, 0.55, -0.1
9568, 0.5, 0.6, -0.1
9569, 0.5, 0.65, -0.1
9570, 0.5, 0.7, -0.1
9571, 0.5, 0.75, -0.1
9572, 0.5, 0.8, -0.1
9573, 0.5, 0.85, -0.1
9574, 0.5, 0.9, -0.1
9575, 0.5, 0.95, -0.1
9576, 0.5, 1, -0.1
9577, 0.5, 1.05, -0.1
9578, 0.5, 1.1, -0.1
9579, 0.5, 1.15, -0.1
9580, 0.5, 1.2, -0.1
9581, 0.5, 1.25, -0.1
9582, 0.5, 1.3, -0.1
9583, 0.54166666666667, 0.2, -0.1
9584, 0.54166666666667, 0.25, -0.1
9585, 0.54166666666667, 0.3, -0.1
9586, 0.54166666666667, 0.35, -0.1
9587, 0.54166666666667, 0.4, -0.1
9588, 0.54166666666667, 0.45, -0.1
9589, 0.54166666666667, 0.5, -0.1
9590, 0.54166666666667, 0.55, -0.1
9591, 0.54166666666667, 0.6, -0.1
9592, 0.54166666666667, 0.65, -0.1
9593, 0.54166666666667, 0.7, -0.1
9594, 0.54166666666667, 0.75, -0.1
9595, 0.54166666666667, 0.8, -0.1
9596, 0.54166666666667, 0.85, -0.1
9597, 0.54166666666667, 0.9, -0.1
9598, 0.54166666666667, 0.95, -0.1
9599, 0.54166666666667, 1, -0.1
9600, 0.54166666666667, 1.05, -0.1
9601, 0.54166666666667, 1.1, -0.1
9602, 0.54166666666667, 1.15, -0.1
9603, 0.54166666666667, 1.2, -0.1
9604, 0.54166666666667, 1.25, -0.1
9605, 0.54166666666667, 1.3, -0.1
9606, 0.58333333333333, 0.2, -0.1
9607, 0.58333333333333, 0.25, -0.1
9608, 0.58333333333333, 0.3, -0.1
9609, 0.58333333333333, 0.35, -0.1
9610, 0.58333333333333, 0.4, -0.1
9611, 0.58333333333333, 0.45, -0.1
9612, 0.58333333333333, 0.5, -0.1
9613, 0.58333333333333, 0.55, -0.1
9614, 0.58333333333333, 0.6, -0.1
9615, 0.58333333333333, 0.65, -0.1
9616, 0.58333333333333, 0.7, -0.1
9617, 0.58333333333333, 0.75, -0.1
9618, 0.58333333333333, 0.8, -0.1
9619, 0.58333333333333, 0.85, -0.1
9620, 0.58333333333333, 0.9, -0.1
9621, 0.58333333333333, 0.95, -0.1
9622, 0.58333333333333, 1, -0.1
9623, 0.58333333333333, 1.05, -0.1
9624, 0.58333333333333, 1.1, -0.1
9625, 0.58333333333333, 1.15, -0.1
9626, 0.58333333333333, 1.2, -0.1
9627, 0.58333333333333, 1.25, -0.1
9628, 0.58333333333333, 1.3, -0.1
9629, 0.625, 0.2, -0.1
9630, 0.625, 0.25, -0.1
9631, 0.625, 0.3, -0.1
9632, 0.625, 0.35, -0.1
9633, 0.625, 0.4, -0.1
9634, 0.625, 0.45, -0.1
9635, 0.625, 0.5, -0.1
9636, 0.625, 0.55, -0.1
9637, 0.625, 0.6, -0.1
9638, 0.625, 0.65, -0.1
9639, 0.625, 0.7, -0.1
9640, 0.625, 0.75, -0.1
9641, 0.625, 0.8, -0.1
9642, 0.625, 0.85, -0.1
9643, 0.625, 0.9, -0.1
9644, 0.625, 0.95, -0.1
9645, 0.625, 1, -0.1
9646, 0.625, 1.05, -0.1
9647, 0.625, 1.1, -0.1
9648, 0.625, 1.15, -0.1
9649, 0.625, 1.2, -0.1
9650, 0.625, 1.25, -0.1
9651, 0.625, 1.3, -0.1
9652, 0.66666666666667, 0.2, -0.1
9653, 0.66666666666667, 0.25, -0.1
9654, 0.66666666666667, 0.3, -0.1
9655, 0.66666666666667, 0.35, -0.1
9656, 0.66666666666667, 0.4, -0.1
9657, 0.66666666666667, 0.45, -0.1
9658, 0.66666666666667, 0.5, -0.1
9659, 0.66666666666667, 0.55, -0.1
9660, 0.66666666666667, 0.6, -0.1
9661, 0.66666666666667, 0.65, -0.1
9662, 0.66666666666667, 0.7, -0.1
9663, 0.66666666666667, 0.75, -0.1
9664, 0.66666666666667, 0.8, -0.1
9665, 0.66666666666667, 0.85, -0.1
9666, 0.66666666666667, 0.9, -0.1
9667, 0.66666666666667, 0.95, -0.1
9668, 0.66666666666667, 1, -0.1
9669, 0.66666666666667, 1.05, -0.1
9670, 0.66666666666667, 1.1, -0.1
9671, 0.66666666666667, 1.15, -0.1
9672, 0.66666666666667, 1.2, -0.1
9673, 0.66666666666667, 1.25, -0.1
9674, 0.66666666666667, 1.3, -0.1
9675, 0.70833333333333, 0.2, -0.1
9676, 0.70833333333333, 0.25, -0.1
9677, 0.70833333333333, 0.3, -0.1
9678, 0.70833333333333, 0.35, -0.1
9679, 0.70833333333333, 0.4, -0.1
9680, 0.70833333333333, 0.45, -0.1
9681, 0.70833333333333, 0.5, -0.1
9682, 0.70833333333333, 0.55, -0.1
9683, 0.70833333333333, 0.6, -0.1
9684, 0.70833333333333, 0.65, -0.1
9685, 0.70833333333333, 0.7, -0.1
9686, 0.70833333333333, 0.75, -0.1
9687, 0.70833333333333, 0.8, -0.1
9688, 0.70833333333333, 0.85, -0.1
9689, 0.70833333333333, 0.9, -0.1
9690, 0.70833333333333, 0.95, -0.1
9691, 0.70833333333333, 1, -0.1
9692, 0.70833333333333, 1.05, -0.1
9693, 0.70833333333333, 1.1, -0.1
9694, 0.70833333333333, 1.15, -0.1
9695, 0.70833333333333, 1.2, -0.1
9696, 0.70833333333333, 1.25, -0.1
9697, 0.70833333333333, 1.3, -0.1
9698, 0.75, 0.2, -0.1
9699, 0.75, 0.25, -0.1
9700, 0.75, 0.3, -0.1
9701, 0.75, 0.35, -0.1
9702, 0.75, 0.4, -0.1
9703, 0.75, 0.45, -0.1
9704, 0.75, 0.5, -0.1
9705, 0.75, 0.55, -0.1
9706, 0.75, 0.6, -0.1
9707, 0.75, 0.65, -0.1
9708, 0.75, 0.7, -0.1
9709, 0.75, 0.75, -0.1
9710, 0.75, 0.8, -0.1
9711, 0.75, 0.85, -0.1
9712, 0.75, 0.9, -0.1
9713, 0.75, 0.95, -0.1
9714, 0.75, 1, -0.1
9715, 0.75, 1.05, -0.1
9716, 0.75, 1.1, -0.1
9717, 0.75, 1.15, -0.1
9718, 0.75, 1.2, -0.1
9719, 0.75, 1.25, -0.1
9720, 0.75, 1.3, -0.1
9721, 0.79166666666667, 0.2, -0.1
9722, 0.79166666666667, 0.25, -0.1
9723, 0.79166666666667, 0.3, -0.1
9724, 0.79166666666667, 0.35, -0.1
9725, 0.79166666666667, 0.4, -0.1
9726, 0.79166666666667, 0.45, -0.1
9727, 0.79166666666667, 0.5, -0.1
9728, 0.79166666666667, 0.55, -0.1
9729, 0.79166666666667, 0.6, -0.1
9730, 0.79166666666667, 0.65, -0.1
9731, 0.79166666666667, 0.7, -0.1
9732, 0.79166666666667, 0.75, -0.1
9733, 0.79166666666667, 0.8, -0.1
9734, 0.79166666666667, 0.85, -0.1
9735, 0.79166666666667, 0.9, -0.1
9736, 0.79166666666667, 0.95, -0.1
9737, 0.79166666666667, 1, -0.1
9738, 0.79166666666667, 1.05, -0.1
9739, 0.79166666666667, 1.1, -0.1
9740, 0.79166666666667, 1.15, -0.1
9741, 0.79166666666667, 1.2, -0.1
9742, 0.79166666666667, 1.25, -0.1
9743, 0.79166666666667, 1.3, -0.1
9744, 0.83333333333333, 0.2, -0.1
9745, 0.83333333333333, 0.25, -0.1
9746, 0.83333333333333, 0.3, -0.1
9747, 0.83333333333333, 0.35, -0.1
9748, 0.83333333333333, 0.4, -0.1
9749, 0.83333333333333, 0.45, -0.1
9750, 0.83333333333333, 0.5, -0.1
9751, 0.83333333333333, 0.55, -0.1
9752, 0.83333333333333, 0.6, -0.1
9753, 0.83333333333333, 0.65, -0.1
9754, 0.83333333333333, 0.7, -0.1
9755, 0.83333333333333, 0.75, -0.1
9756, 0.83333333333333, 0.8, -0.1
9757, 0.83333333333333, 0.85, -0.1
9758, 0.83333333333333, 0.9, -0.1
9759, 0.83333333333333, 0.95, -0.1
9760, 0.83333333333333, 1, -0.1
9761, 0.83333333333333, 1.05, -0.1
9762, 0.83333333333333, 1.1, -0.1
9763, 0.83333333333333, 1.15, -0.1
9764, 0.83333333333333, 1.2, -0.1
9765, 0.83333333333333, 1.25, -0.1
9766, 0.83333333333333, 1.3, -0.1
9767, 0.875, 0.2, -0.1
9768, 0.875, 0.25, -0.1
9769, 0.875, 0.3, -0.1
9770, 0.875, 0.35, -0.1
9771, 0.875, 0.4, -0.1
9772, 0.875, 0.45, -0.1
9773, 0.875, 0.5, -0.1
9774, 0.875, 0.55, -0.1
9775, 0.875, 0.6, -0.1
9776, 0.875, 0.65, -0.1
9777, 0.875, 0.7, -0.1
9778, 0.875, 0.75, -0.1
9779, 0.875, 0.8, -0.1
9780, 0.875, 0.85, -0.1
9781, 0.875, 0.9, -0.1
9782, 0.875, 0.95, -0.1
9783, 0.875, 1, -0.1
9784, 0.875, 1.05, -0.1
9785, 0.875, 1.1, -0.1
9786, 0.875, 1.15, -0.1
9787, 0.875, 1.2, -0.1
9788, 0.875, 1.25, -0.1
9789, 0.875, 1.3, -0.1
9790, 0.91666666666667, 0.2, -0.1
9791, 0.91666666666667, 0.25, -0.1
9792, 0.91666666666667, 0.3, -0.1
9793, 0.91666666666667, 0.35, -0.1
9794, 0.91666666666667, 0.4, -0.1
9795, 0.91666666666667, 0.45, -0.1
9796, 0.91666666666667, 0.5, -0.1
9797, 0.91666666666667, 0.55, -0.1
9798, 0.91666666666667, 0.6, -0.1
9799, 0.91666666666667, 0.65, -0.1
9800, 0.91666666666667, 0.7, -0.1
9801, 0.91666666666667, 0.75, -0.1
9802, 0.91666666666667, 0.8, -0.1
9803, 0.91666666666667, 0.85, -0.1
9804, 0.91666666666667, 0.9, -0.1
9805, 0.91666666666667, 0.95, -0.1
9806, 0.91666666666667, 1, -0.1
9807, 0.91666666666667, 1.05, -0.1
9808, 0.91666666666667, 1.1, -0.1
9809, 0.91666666666667, 1.15, -0.1
9810, 0.91666666666667, 1.2, -0.1
9811, 0.91666666666667, 1.25, -0.1
9812, 0.91666666666667, 1.3, -0.1
9813, 0.95833333333333, 0.2, -0.1
9814, 0.95833333333333, 0.25, -0.1
9815, 0.95833333333333, 0.3, -0.1
9816, 0.95833333333333, 0.35, -0.1
9817, 0.95833333333333, 0.4, -0.1
9818, 0.95833333333333, 0.45, -0.1
9819, 0.95833333333333, 0.5, -0.1
9820, 0.95833333333333, 0.55, -0.1
9821, 0.95833333333333, 0.6, -0.1
9822, 0.95833333333333, 0.65, -0.1
9823, 0.95833333333333, 0.7, -0.1
9824, 0.95833333333333, 0.75, -0.1
9825, 0.95833333333333, 0.8, -0.1
9826, 0.95833333333333, 0.85, -0.1
9827, 0.95833333333333, 0.9, -0.1
9828, 0.95833333333333, 0.95, -0.1
9829, 0.95833333333333, 1, -0.1
9830, 0.95833333333333, 1.05, -0.1
9831, 0.95833333333333, 1.1, -0.1
9832, 0.95833333333333, 1.15, -0.1
9833, 0.95833333333333, 1.2, -0.1
9834, 0.95833333333333, 1.25, -0.1
9835, 0.95833333333333, 1.3, -0.1
9836, 1.2416666666667, 1.3, -0.1
9837, 1.2416666666667, 1.25, -0.1
9838, 1.2416666666667, 1.2, -0.1
9839, 1.2416666666667, 1.15, -0.1
9840, 1.2416666666667, 1.1, -0.1
9841, 1.2416666666667, 1.05, -0.1
9842, 1.2416666666667, 1, -0.1
9843, 1.2416666666667, 0.95, -0.1
9844, 1.2416666666667, 0.9, -0.1
9845, 1.2416666666667, 0.85, -0.1
9846, 1.2416666666667, 0.8, -0.1
9847, 1.2416666666667, 0.75, -0.1
9848, 1.2416666666667, 0.7, -0.1
9849, 1.2416666666667, 0.65, -0.1
9850, 1.2416666666667, 0.6, -0.1
9851, 1.2416666666667, 0.55, -0.1
9852, 1.2416666666667, 0.5, -0.1
9853, 1.2416666666667, 0.45, -0.1
9854, 1.2416666666667, 0.4, -0.1
9855, 1.2416666666667, 0.35, -0.1
9856, 1.2416666666667, 0.3, -0.1
9857, 1.2416666666667, 0.25, -0.1
9858, 1.2416666666667, 0.2, -0.1
9859, 1.2833333333333, 1.3, -0.1
9860, 1.2833333333333, 1.25, -0.1
9861, 1.2833333333333, 1.2, -0.1
9862, 1.2833333333333, 1.15, -0.1
9863, 1.2833333333333, 1.1, -0.1
9864, 1.2833333333333, 1.05, -0.1
9865, 1.2833333333333, 1, -0.1
9866, 1.2833333333333, 0.95, -0.1
9867, 1.2833333333333, 0.9, -0.1
9868, 1.2833333333333, 0.85, -0.1
9869, 1.2833333333333, 0.8, -0.1
9870, 1.2833333333333, 0.75, -0.1
9871, 1.2833333333333, 0.7, -0.1
9872, 1.2833333333333, 0.65, -0.1
9873, 1.2833333333333, 0.6, -0.1
9874, 1.2833333333333, 0.55, -0.1
9875, 1.2833333333333, 0.5, -0.1
9876, 1.2833333333333, 0.45, -0.1
9877, 1.2833333333333, 0.4, -0.1
9878, 1.2833333333333, 0.35, -0.1
9879, 1.2833333333333, 0.3, -0.1
9880, 1.2833333333333, 0.25, -0.1
9881, 1.2833333333333, 0.2, -0.1
9882, 1.325, 1.3, -0.1
9883, 1.325, 1.25, -0.1
9884, 1.325, 1.2, -0.1
9885, 1.325, 1.15, -0.1
9886, 1.325, 1.1, -0.1
9887, 1.325, 1.05, -0.1
9888, 1.325, 1, -0.1
9889, 1.325, 0.95, -0.1
9890, 1.325, 0.9, -0.1
9891, 1.325, 0.85, -0.1
9892, 1.325, 0.8, -0.1
9893, 1.325, 0.75, -0.1
9894, 1.325, 0.7, -0.1
9895, 1.325, 0.65, -0.1
9896, 1.325, 0.6, -0.1
9897, 1.325, 0.55, -0.1
9898, 1.325, 0.5, -0.1
9899, 1.325, 0.45, -0.1
9900, 1.325, 0.4, -0.1
9901, 1.325, 0.35, -0.1
9902, 1.325, 0.3, -0.1
9903, 1.325, 0.25, -0.1
9904, 1.325, 0.2, -0.1
9905, 1.3666666666667, 1.3, -0.1
9906, 1.3666666666667, 1.25, -0.1
9907, 1.3666666666667, 1.2, -0.1
9908, 1.3666666666667, 1.15, -0.1
9909, 1.3666666666667, 1.1, -0.1
9910, 1.3666666666667, 1.05, -0.1
9911, 1.3666666666667, 1, -0.1
9912, 1.3666666666667, 0.95, -0.1
9913, 1.3666666666667, 0.9, -0.1
9914, 1.3666666666667, 0.85, -0.1
9915, 1.3666666666667, 0.8, -0.1
9916, 1.3666666666667, 0.75, -0.1
9917, 1.3666666666667, 0.7, -0.1
9918, 1.3666666666667, 0.65, -0.1
9919, 1.3666666666667, 0.6, -0.1
9920, 1.3666666666667, 0.55, -0.1
9921, 1.3666666666667, 0.5, -0.1
9922, 1.3666666666667, 0.45, -0.1
9923, 1.3666666666667, 0.4, -0.1
9924, 1.3666666666667, 0.35, -0.1
9925, 1.3666666666667, 0.3, -0.1
9926, 1.3666666666667, 0.25, -0.1
9927, 1.3666666666667, 0.2, -0.1
9928, 1.4083333333333, 1.3, -0.1
9929, 1.4083333333333, 1.25, -0.1
9930, 1.4083333333333, 1.2, -0.1
9931, 1.4083333333333, 1.15, -0.1
9932, 1.4083333333333, 1.1, -0.1
9933, 1.4083333333333, 1.05, -0.1
9934, 1.4083333333333, 1, -0.1
9935, 1.4083333333333, 0.95, -0.1
9936, 1.4083333333333, 0.9, -0.1
9937, 1.4083333333333, 0.85, -0.1
9938, 1.4083333333333, 0.8, -0.1
9939, 1.4083333333333, 0.75, -0.1
9940, 1.4083333333333, 0.7, -0.1
9941, 1.4083333333333, 0.65, -0.1
9942, 1.4083333333333, 0.6, -0.1
9943, 1.4083333333333, 0.55, -0.1
9944, 1.4083333333333, 0.5, -0.1
9945, 1.4083333333333, 0.45, -0.1
9946, 1.4083333333333, 0.4, -0.1
9947, 1.4083333333333, 0.35, -0.1
9948, 1.4083333333333, 0.3, -0.1
9949, 1.4083333333333, 0.25, -0.1
9950, 1.4083333333333, 0.2, -0.1
9951, 1.45, 1.3, -0.1
9952, 1.45, 1.25, -0.1
9953, 1.45, 1.2, -0.1
9954, 1.45, 1.15, -0.1
9955, 1.45, 1.1, -0.1
9956, 1.45, 1.05, -0.1
9957, 1.45, 1, -0.1
9958, 1.45, 0.95, -0.1
9959, 1.45, 0.9, -0.1
9960, 1.45, 0.85, -0.1
9961, 1.45, 0.8, -0.1
9962, 1.45, 0.75, -0.1
9963, 1.45, 0.7, -0.1
9964, 1.45, 0.65, -0.1
9965, 1.45, 0.6, -0.1
9966, 1.45, 0.55, -0.1
9967, 1.45, 0.5, -0.1
9968, 1.45, 0.45, -0.1
9969, 1.45, 0.4, -0.1
9970, 1.45, 0.35, -0.1
9971, 1.45, 0.3, -0.1
9972, 1.45, 0.25, -0.1
9973, 1.45, 0.2, -0.1
9974, 1.4916666666667, 1.3, -0.1
9975, 1.4916666666667, 1.25, -0.1
9976, 1.4916666666667, 1.2, -0.1
9977, 1.4916666666667, 1.15, -0.1
9978, 1.4916666666667, 1.1, -0.1
9979, 1.4916666666667, 1.05, -0.1
9980, 1.4916666666667, 1, -0.1
9981, 1.4916666666667, 0.95, -0.1
9982, 1.4916666666667, 0.9, -0.1
9983, 1.4916666666667, 0.85, -0.1
9984, 1.4916666666667, 0.8, -0.1
9985, 1.4916666666667, 0.75, -0.1
9986, 1.4916666666667, 0.7, -0.1
9987, 1.4916666666667, 0.65, -0.1
9988, 1.4916666666667, 0.6, -0.1
9989, 1.4916666666667, 0.55, -0.1
9990, 1.4916666666667, 0.5, -0.1
9991, 1.4916666666667, 0.45, -0.1
9992, 1.4916666666667, 0.4, -0.1
9993, 1.4916666666667, 0.35, -0.1
9994, 1.4916666666667, 0.3, -0.1
9995, 1.4916666666667, 0.25, -0.1
9996, 1.4916666666667, 0.2, -0.1
9997, 1.5333333333333, 1.3, -0.1
9998, 1.5333333333333, 1.25, -0.1
9999, 1.5333333333333, 1.2, -0.1
10000, 1.5333333333333, 1.15, -0.1
10001, 1.5333333333333, 1.1, -0.1
10002, 1.5333333333333, 1.05, -0.1
10003, 1.5333333333333, 1, -0.1
10004, 1.5333333333333, 0.95, -0.1
10005, 1.5333333333333, 0.9, -0.1
10006, 1.5333333333333, 0.85, -0.1
10007, 1.5333333333333, 0.8, -0.1
10008, 1.5333333333333, 0.75, -0.1
10009, 1.5333333333333, 0.7, -0.1
10010, 1.5333333333333, 0.65, -0.1
10011, 1.5333333333333, 0.6, -0.1
10012, 1.5333333333333, 0.55, -0.1
10013, 1.5333333333333, 0.5, -0.1
10014, 1.5333333333333, 0.45, -0.1
10015, 1.5333333333333, 0.4, -0.1
10016, 1.5333333333333, 0.35, -0.1
10017, 1.5333333333333, 0.3, -0.1
10018, 1.5333333333333, 0.25, -0.1
10019, 1.5333333333333, 0.2, -0.1
10020, 1.575, 1.3, -0.1
10021, 1.575, 1.25, -0.1
10022, 1.575, 1.2, -0.1
10023, 1.575, 1.15, -0.1
10024, 1.575, 1.1, -0.1
10025, 1.575, 1.05, -0.1
10026, 1.575, 1, -0.1
10027, 1.575, 0.95, -0.1
10028, 1.575, 0.9, -0.1
10029, 1.575, 0.85, -0.1
10030, 1.575, 0.8, -0.1
10031, 1.575, 0.75, -0.1
10032, 1.575, 0.7, -0.1
10033, 1.575, 0.65, -0.1
10034, 1.575, 0.6, -0.1
10035, 1.575, 0.55, -0.1
10036, 1.575, 0.5, -0.1
10037, 1.575, 0.45, -0.1
10038, 1.575, 0.4, -0.1
10039, 1.575, 0.35, -0.1
10040, 1.575, 0.3, -0.1
10041, 1.575, 0.25, -0.1
10042, 1.575, 0.2, -0.1
10043, 1.6166666666667, 1.3, -0.1
10044, 1.6166666666667, 1.25, -0.1
10045, 1.6166666666667, 1.2, -0.1
10046, 1.6166666666667, 1.15, -0.1
10047, 1.6166666666667, 1.1, -0.1
10048, 1.6166666666667, 1.05, -0.1
10049, 1.6166666666667, 1, -0.1
10050, 1.6166666666667, 0.95, -0.1
10051, 1.6166666666667, 0.9, -0.1
10052, 1.6166666666667, 0.85, -0.1
10053, 1.6166666666667, 0.8, -0.1
10054, 1.6166666666667, 0.75, -0.1
10055, 1.6166666666667, 0.7, -0.1
10056, 1.6166666666667, 0.65, -0.1
10057, 1.6166666666667, 0.6, -0.1
10058, 1.6166666666667, 0.55, -0.1
10059, 1.6166666666667, 0.5, -0.1
10060, 1.6166666666667, 0.45, -0.1
10061, 1.6166666666667, 0.4, -0.1
10062, 1.6166666666667, 0.35, -0.1
10063, 1.6166666666667, 0.3, -0.1
10064, 1.6166666666667, 0.25, -0.1
10065, 1.6166666666667, 0.2, -0.1
10066, 1.6583333333333, 1.3, -0.1
10067, 1.6583333333333, 1.25, -0.1
10068, 1.6583333333333, 1.2, -0.1
10069, 1.6583333333333, 1.15, -0.1
10070, 1.6583333333333, 1.1, -0.1
10071, 1.6583333333333, 1.05, -0.1
10072, 1.6583333333333, 1, -0.1
10073, 1.6583333333333, 0.95, -0.1
10074, 1.6583333333333, 0.9, -0.1
10075, 1.6583333333333, 0.85, -0.1
10076, 1.6583333333333, 0.8, -0.1
10077, 1.6583333333333, 0.75, -0.1
10078, 1.6583333333333, 0.7, -0.1
10079, 1.6583333333333, 0.65, -0.1
10080, 1.6583333333333, 0.6, -0.1
10081, 1.6583333333333, 0.55, -0.1
10082, 1.6583333333333, 0.5, -0.1
10083, 1.6583333333333, 0.45, -0.1
10084, 1.6583333333333, 0.4, -0.1
10085, 1.6583333333333, 0.35, -0.1
10086, 1.6583333333333, 0.3, -0.1
10087, 1.6583333333333, 0.25, -0.1
10088, 1.6583333333333, 0.2, -0.1
10089, 1.7, 1.3, -0.1
10090, 1.7, 1.25, -0.1
10091, 1.7, 1.2, -0.1
10092, 1.7, 1.15, -0.1
10093, 1.7, 1.1, -0.1
10094, 1.7, 1.05, -0.1
10095, 1.7, 1, -0.1
10096, 1.7, 0.95, -0.1
10097, 1.7, 0.9, -0.1
10098, 1.7, 0.85, -0.1
10099, 1.7, 0.8, -0.1
10100, 1.7, 0.75, -0.1
10101, 1.7, 0.7, -0.1
10102, 1.7, 0.65, -0.1
10103, 1.7, 0.6, -0.1
10104, 1.7, 0.55, -0.1
10105, 1.7, 0.5, -0.1
10106, 1.7, 0.45, -0.1
10107, 1.7, 0.4, -0.1
10108, 1.7, 0.35, -0.1
10109, 1.7, 0.3, -0.1
10110, 1.7, 0.25, -0.1
10111, 1.7, 0.2, -0.1
10112, 1.7416666666667, 1.3, -0.1
10113, 1.7416666666667, 1.25, -0.1
10114, 1.7416666666667, 1.2, -0.1
10115, 1.7416666666667, 1.15, -0.1
10116, 1.7416666666667, 1.1, -0.1
10117, 1.7416666666667, 1.05, -0.1
10118, 1.7416666666667, 1, -0.1
10119, 1.7416666666667, 0.95, -0.1
10120, 1.7416666666667, 0.9, -0.1
10121, 1.7416666666667, 0.85, -0.1
10122, 1.7416666666667, 0.8, -0.1
10123, 1.7416666666667, 0.75, -0.1
10124, 1.7416666666667, 0.7, -0.1
10125, 1.7416666666667, 0.65, -0.1
10126, 1.7416666666667, 0.6, -0.1
10127, 1.7416666666667, 0.55, -0.1
10128, 1.7416666666667, 0.5, -0.1
10129, 1.7416666666667, 0.45, -0.1
10130, 1.7416666666667, 0.4, -0.1
10131, 1.7416666666667, 0.35, -0.1
10132, 1.7416666666667, 0.3, -0.1
10133, 1.7416666666667, 0.25, -0.1
10134, 1.7416666666667, 0.2, -0.1
10135, 1.7833333333333, 1.3, -0.1
10136, 1.7833333333333, 1.25, -0.1
10137, 1.7833333333333, 1.2, -0.1
10138, 1.7833333333333, 1.15, -0.1
10139, 1.7833333333333, 1.1, -0.1
10140, 1.7833333333333, 1.05, -0.1
10141, 1.7833333333333, 1, -0.1
10142, 1.7833333333333, 0.95, -0.1
10143, 1.7833333333333, 0.9, -0.1
10144, 1.7833333333333, 0.85, -0.1
10145, 1.7833333333333, 0.8, -0.1
10146, 1.7833333333333, 0.75, -0.1
10147, 1.7833333333333, 0.7, -0.1
10148, 1.7833333333333, 0.65, -0.1
10149, 1.7833333333333, 0.6, -0.1
10150, 1.7833333333333, 0.55, -0.1
10151, 1.7833333333333, 0.5, -0.1
10152, 1.7833333333333, 0.45, -0.1
10153, 1.7833333333333, 0.4, -0.1
10154, 1.7833333333333, 0.35, -0.1
10155, 1.7833333333333, 0.3, -0.1
10156, 1.7833333333333, 0.25, -0.1
10157, 1.7833333333333, 0.2, -0.1
10158, 1.825, 1.3, -0.1
10159, 1.825, 1.25, -0.1
10160, 1.825, 1.2, -0.1
10161, 1.825, 1.15, -0.1
10162, 1.825, 1.1, -0.1
10163, 1.825, 1.05, -0.1
10164, 1.825, 1, -0.1
10165, 1.825, 0.95, -0.1
10166, 1.825, 0.9, -0.1
10167, 1.825, 0.85, -0.1
10168, 1.825, 0.8, -0.1
10169, 1.825, 0.75, -0.1
10170, 1.825, 0.7, -0.1
10171, 1.825, 0.65, -0.1
10172, 1.825, 0.6, -0.1
10173, 1.825, 0.55, -0.1
10174, 1.825, 0.5, -0.1
10175, 1.825, 0.45, -0.1
10176, 1.825, 0.4, -0.1
10177, 1.825, 0.35, -0.1
10178, 1.825, 0.3, -0.1
10179, 1.825, 0.25, -0.1
10180, 1.825, 0.2, -0.1
10181, 1.8666666666667, 1.3, -0.1
10182, 1.8666666666667, 1.25, -0.1
10183, 1.8666666666667, 1.2, -0.1
10184, 1.8666666666667, 1.15, -0.1
10185, 1.8666666666667, 1.1, -0.1
10186, 1.8666666666667, 1.05, -0.1
10187, 1.8666666666667, 1, -0.1
10188, 1.8666666666667, 0.95, -0.1
10189, 1.8666666666667, 0.9, -0.1
10190, 1.8666666666667, 0.85, -0.1
10191, 1.8666666666667, 0.8, -0.1
10192, 1.8666666666667, 0.75, -0.1
10193, 1.8666666666667, 0.7, -0.1
10194, 1.8666666666667, 0.65, -0.1
10195, 1.8666666666667, 0.6, -0.1
10196, 1.8666666666667, 0.55, -0.1
10197, 1.8666666666667, 0.5, -0.1
10198, 1.8666666666667, 0.45, -0.1
10199, 1.8666666666667, 0.4, -0.1
10200, 1.8666666666667, 0.35, -0.1
10201, 1.8666666666667, 0.3, -0.1
10202, 1.8666666666667, 0.25, -0.1
10203, 1.8666666666667, 0.2, -0.1
10204, 1.9083333333333, 1.3, -0.1
10205, 1.9083333333333, 1.25, -0.1
10206, 1.9083333333333, 1.2, -0.1
10207, 1.9083333333333, 1.15, -0.1
10208, 1.9083333333333, 1.1, -0.1
10209, 1.9083333333333, 1.05, -0.1
10210, 1.9083333333333, 1, -0.1
10211, 1.9083333333333, 0.95, -0.1
10212, 1.9083333333333, 0.9, -0.1
10213, 1.9083333333333, 0.85, -0.1
10214, 1.9083333333333, 0.8, -0.1
10215, 1.9083333333333, 0.75, -0.1
10216, 1.9083333333333, 0.7, -0.1
10217, 1.9083333333333, 0.65, -0.1
10218, 1.9083333333333, 0.6, -0.1
10219, 1.9083333333333, 0.55, -0.1
10220, 1.9083333333333, 0.5, -0.1
10221, 1.9083333333333, 0.45, -0.1
10222, 1.9083333333333, 0.4, -0.1
10223, 1.9083333333333, 0.35, -0.1
10224, 1.9083333333333, 0.3, -0.1
10225, 1.9083333333333, 0.25, -0.1
10226, 1.9083333333333, 0.2, -0.1
10227, 1.95, 1.3, -0.1
10228, 1.95, 1.25, -0.1
10229, 1.95, 1.2, -0.1
10230, 1.95, 1.15, -0.1
10231, 1.95, 1.1, -0.1
10232, 1.95, 1.05, -0.1
10233, 1.95, 1, -0.1
10234, 1.95, 0.95, -0.1
10235, 1.95, 0.9, -0.1
10236, 1.95, 0.85, -0.1
10237, 1.95, 0.8, -0.1
10238, 1.95, 0.75, -0.1
10239, 1.95, 0.7, -0.1
10240, 1.95, 0.65, -0.1
10241, 1.95, 0.6, -0.1
10242, 1.95, 0.55, -0.1
10243, 1.95, 0.5, -0.1
10244, 1.95, 0.45, -0.1
10245, 1.95, 0.4, -0.1
10246, 1.95, 0.35, -0.1
10247, 1.95, 0.3, -0.1
10248, 1.95, 0.25, -0.1
10249, 1.95, 0.2, -0.1
10250, 1.9916666666667, 1.3, -0.1
10251, 1.9916666666667, 1.25, -0.1
10252, 1.9916666666667, 1.2, -0.1
10253, 1.9916666666667, 1.15, -0.1
10254, 1.9916666666667, 1.1, -0.1
10255, 1.9916666666667, 1.05, -0.1
10256, 1.9916666666667, 1, -0.1
10257, 1.9916666666667, 0.95, -0.1
10258, 1.9916666666667, 0.9, -0.1
10259, 1.9916666666667, 0.85, -0.1
10260, 1.9916666666667, 0.8, -0.1
10261, 1.9916666666667, 0.75, -0.1
10262, 1.9916666666667, 0.7, -0.1
10263, 1.9916666666667, 0.65, -0.1
10264, 1.9916666666667, 0.6, -0.1
10265, 1.9916666666667, 0.55, -0.1
10266, 1.9916666666667, 0.5, -0.1
10267, 1.9916666666667, 0.45, -0.1
10268, 1.9916666666667, 0.4, -0.1
10269, 1.9916666666667, 0.35, -0.1
10270, 1.9916666666667, 0.3, -0.1
10271, 1.9916666666667, 0.25, -0.1
10272, 1.9916666666667, 0.2, -0.1
10273, 2.0333333333333, 1.3, -0.1
10274, 2.0333333333333, 1.25, -0.1
10275, 2.0333333333333, 1.2, -0.1
10276, 2.0333333333333, 1.15, -0.1
10277, 2.0333333333333, 1.1, -0.1
10278, 2.0333333333333, 1.05, -0.1
10279, 2.0333333333333, 1, -0.1
10280, 2.0333333333333, 0.95, -0.1
10281, 2.0333333333333, 0.9, -0.1
10282, 2.0333333333333, 0.85, -0.1
10283, 2.0333333333333, 0.8, -0.1
10284, 2.0333333333333, 0.75, -0.1
10285, 2.0333333333333, 0.7, -0.1
10286, 2.0333333333333, 0.65, -0.1
10287, 2.0333333333333, 0.6, -0.1
10288, 2.0333333333333, 0.55, -0.1
10289, 2.0333333333333, 0.5, -0.1
10290, 2.0333333333333, 0.45, -0.1
10291, 2.0333333333333, 0.4, -0.1
10292, 2.0333333333333, 0.35, -0.1
10293, 2.0333333333333, 0.3, -0.1
10294, 2.0333333333333, 0.25, -0.1
10295, 2.0333333333333, 0.2, -0.1
10296, 2.075, 1.3, -0.1
10297, 2.075, 1.25, -0.1
10298, 2.075, 1.2, -0.1
10299, 2.075, 1.15, -0.1
10300, 2.075, 1.1, -0.1
10301, 2.075, 1.05, -0.1
10302, 2.075, 1, -0.1
10303, 2.075, 0.95, -0.1
10304, 2.075, 0.9, -0.1
10305, 2.075, 0.85, -0.1
10306, 2.075, 0.8, -0.1
10307, 2.075, 0.75, -0.1
10308, 2.075, 0.7, -0.1
10309, 2.075, 0.65, -0.1
10310, 2.075, 0.6, -0.1
10311, 2.075, 0.55, -0.1
10312, 2.075, 0.5, -0.1
10313, 2.075, 0.45, -0.1
10314, 2.075, 0.4, -0.1
10315, 2.075, 0.35, -0.1
10316, 2.075, 0.3, -0.1
10317, 2.075, 0.25, -0.1
10318, 2.075, 0.2, -0.1
10319, 2.1166666666667, 1.3, -0.1
10320, 2.1166666666667, 1.25, -0.1
10321, 2.1166666666667, 1.2, -0.1
10322, 2.1166666666667, 1.15, -0.1
10323, 2.1166666666667, 1.1, -0.1
10324, 2.1166666666667, 1.05, -0.1
10325, 2.1166666666667, 1, -0.1
10326, 2.1166666666667, 0.95, -0.1
10327, 2.1166666666667, 0.9, -0.1
10328, 2.1166666666667, 0.85, -0.1
10329, 2.1166666666667, 0.8, -0.1
10330, 2.1166666666667, 0.75, -0.1
10331, 2.1166666666667, 0.7, -0.1
10332, 2.1166666666667, 0.65, -0.1
10333, 2.1166666666667, 0.6, -0.1
10334, 2.1166666666667, 0.55, -0.1
10335, 2.1166666666667, 0.5, -0.1
10336, 2.1166666666667, 0.45, -0.1
10337, 2.1166666666667, 0.4, -0.1
10338, 2.1166666666667, 0.35, -0.1
10339, 2.1166666666667, 0.3, -0.1
10340, 2.1166666666667, 0.25, -0.1
10341, 2.1166666666667, 0.2, -0.1
10342, 2.1583333333333, 1.3, -0.1
10343, 2.1583333333333, 1.25, -0.1
10344, 2.1583333333333, 1.2, -0.1
10345, 2.1583333333333, 1.15, -0.1
10346, 2.1583333333333, 1.1, -0.1
10347, 2.1583333333333, 1.05, -0.1
10348, 2.1583333333333, 1, -0.1
10349, 2.1583333333333, 0.95, -0.1
10350, 2.1583333333333, 0.9, -0.1
10351, 2.1583333333333, 0.85, -0.1
10352, 2.1583333333333, 0.8, -0.1
10353, 2.1583333333333, 0.75, -0.1
10354, 2.1583333333333, 0.7, -0.1
10355, 2.1583333333333, 0.65, -0.1
10356, 2.1583333333333, 0.6, -0.1
10357, 2.1583333333333, 0.55, -0.1
10358, 2.1583333333333, 0.5, -0.1
10359, 2.1583333333333, 0.45, -0.1
10360, 2.1583333333333, 0.4, -0.1
10361, 2.1583333333333, 0.35, -0.1
10362, 2.1583333333333, 0.3, -0.1
10363, 2.1583333333333, 0.25, -0.1
10364, 2.1583333333333, 0.2, -0.1
10365, 0.041666666666667, 1.54, 0
10366, 0.041666666666667, 1.58, 0
10367, 0.041666666666667, 1.62, 0
10368, 0.041666666666667, 1.66, 0
10369, 0.083333333333333, 1.54, 0
10370, 0.083333333333333, 1.58, 0
10371, 0.083333333333333, 1.62, 0
10372, 0.083333333333333, 1.66, 0
10373, 0.125, 1.54, 0
10374, 0.125, 1.58, 0
10375, 0.125, 1.62, 0
10376, 0.125, 1.66, 0
10377, 0.16666666666667, 1.54, 0
10378, 0.16666666666667, 1.58, 0
10379, 0.16666666666667, 1.62, 0
10380, 0.16666666666667, 1.66, 0
10381, 0.20833333333333, 1.54, 0
10382, 0.20833333333333, 1.58, 0
10383, 0.20833333333333, 1.62, 0
10384, 0.20833333333333, 1.66, 0
10385, 0.25, 1.54, 0
10386, 0.25, 1.58, 0
10387, 0.25, 1.62, 0
10388, 0.25, 1.66, 0
10389, 0.29166666666667, 1.54, 0
10390, 0.29166666666667, 1.58, 0
10391, 0.29166666666667, 1.62, 0
10392, 0.29166666666667, 1.66, 0
10393, 0.33333333333333, 1.54, 0
10394, 0.33333333333333, 1.58, 0
10395, 0.33333333333333, 1.62, 0
10396, 0.33333333333333, 1.66, 0
10397, 0.375, 1.54, 0
10398, 0.375, 1.58, 0
10399, 0.375, 1.62, 0
10400, 0.375, 1.66, 0
10401, 0.41666666666667, 1.54, 0
10402, 0.41666666666667, 1.58, 0
10403, 0.41666666666667, 1.62, 0
10404, 0.41666666666667, 1.66, 0
10405, 0.45833333333333, 1.54, 0
10406, 0.45833333333333, 1.58, 0
10407, 0.45833333333333, 1.62, 0
10408, 0.45833333333333, 1.66, 0
10409, 0.5, 1.54, 0
10410, 0.5, 1.58, 0
10411, 0.5, 1.62, 0
10412, 0.5, 1.66, 0
10413, 0.54166666666667, 1.54, 0
10414, 0.54166666666667, 1.58, 0
10415, 0.54166666666667, 1.62, 0
10416, 0.54166666666667, 1.66, 0
10417, 0.58333333333333, 1.54, 0
10418, 0.58333333333333, 1.58, 0
10419, 0.58333333333333, 1.62, 0
10420, 0.58333333333333, 1.66, 0
10421, 0.625, 1.54, 0
10422, 0.625, 1.58, 0
10423, 0.625, 1.62, 0
10424, 0.625, 1.66, 0
10425, 0.66666666666667, 1.54, 0
10426, 0.66666666666667, 1.58, 0
10427, 0.66666666666667, 1.62, 0
10428, 0.66666666666667, 1.66, 0
10429, 0.70833333333333, 1.54, 0
10430, 0.70833333333333, 1.58, 0
10431, 0.70833333333333, 1.62, 0
10432, 0.70833333333333, 1.66, 0
10433, 0.75, 1.54, 0
10434, 0.75, 1.58, 0
10435, 0.75, 1.62, 0
10436, 0.75, 1.66, 0
10437, 0.79166666666667, 1.54, 0
10438, 0.79166666666667, 1.58, 0
10439, 0.79166666666667, 1.62, 0
10440, 0.79166666666667, 1.66, 0
10441, 0.83333333333333, 1.54, 0
10442, 0.83333333333333, 1.58, 0
10443, 0.83333333333333, 1.62, 0
10444, 0.83333333333333, 1.66, 0
10445, 0.875, 1.54, 0
10446, 0.875, 1.58, 0
10447, 0.875, 1.62, 0
10448, 0.875, 1.66, 0
10449, 0.91666666666667, 1.54, 0
10450, 0.91666666666667, 1.58, 0
10451, 0.91666666666667, 1.62, 0
10452, 0.91666666666667, 1.66, 0
10453, 0.95833333333333, 1.54, 0
10454, 0.95833333333333, 1.58, 0
10455, 0.95833333333333, 1.62, 0
10456, 0.95833333333333, 1.66, 0
10457, 1, 1.54, 0.041666666666667
10458, 1, 1.58, 0.041666666666667
10459, 1, 1.62, 0.041666666666667
10460, 1, 1.66, 0.041666666666667
10461, 1, 1.54, 0.083333333333333
10462, 1, 1.58, 0.083333333333333
10463, 1, 1.62, 0.083333333333333
10464, 1, 1.66, 0.083333333333333
10465, 1, 1.54, 0.125
10466, 1, 1.58, 0.125
10467, 1, 1.62, 0.125
10468, 1, 1.66, 0.125
10469, 1, 1.54, 0.16666666666667
10470, 1, 1.58, 0.16666666666667
10471, 1, 1.62, 0.16666666666667
10472, 1, 1.66, 0.16666666666667
10473, 1, 1.54, 0.20833333333333
10474, 1, 1.58, 0.20833333333333
10475, 1, 1.62, 0.20833333333333
10476, 1, 1.66, 0.20833333333333
10477, 1, 1.54, 0.25
10478, 1, 1.58, 0.25
10479, 1, 1.62, 0.25
10480, 1, 1.66, 0.25
10481, 1, 1.54, 0.29166666666667
10482, 1, 1.58, 0.29166666666667
10483, 1, 1.62, 0.29166666666667
10484, 1, 1.66, 0.29166666666667
10485, 1, 1.54, 0.33333333333333
10486, 1, 1.58, 0.33333333333333
10487, 1, 1.62, 0.33333333333333
10488, 1, 1.66, 0.33333333333333
10489, 1, 1.54, 0.375
10490, 1, 1.58, 0.375
10491, 1, 1.62, 0.375
10492, 1, 1.66, 0.375
10493, 1, 1.54, 0.41666666666667
10494, 1, 1.58, 0.41666666666667
10495, 1, 1.62, 0.41666666666667
10496, 1, 1.66, 0.41666666666667
10497, 1, 1.54, 0.45833333333333
10498, 1, 1.58, 0.45833333333333
10499, 1, 1.62, 0.45833333333333
10500, 1, 1.66, 0.45833333333333
10501, 0.041666666666667, 1.54, 0.5
10502, 0.041666666666667, 1.58, 0.5
10503, 0.041666666666667, 1.62, 0.5
10504, 0.041666666666667, 1.66, 0.5
10505, 0.083333333333333, 1.54, 0.5
10506, 0.083333333333333, 1.58, 0.5
10507, 0.083333333333333, 1.62, 0.5
10508, 0.083333333333333, 1.66, 0.5
10509, 0.125, 1.54, 0.5
10510, 0.125, 1.58, 0.5
10511, 0.125, 1.62, 0.5
10512, 0.125, 1.66, 0.5
10513, 0.16666666666667, 1.54, 0.5
10514, 0.16666666666667, 1.58, 0.5
10515, 0.16666666666667, 1.62, 0.5
10516, 0.16666666666667, 1.66, 0.5
10517, 0.20833333333333, 1.54, 0.5
10518, 0.20833333333333, 1.58, 0.5
10519, 0.20833333333333, 1.62, 0.5
10520, 0.20833333333333, 1.66, 0.5
10521, 0.25, 1.54, 0.5
10522, 0.25, 1.58, 0.5
10523, 0.25, 1.62, 0.5
10524, 0.25, 1.66, 0.5
10525, 0.29166666666667, 1.54, 0.5
10526, 0.29166666666667, 1.58, 0.5
10527, 0.29166666666667, 1.62, 0.5
10528, 0.29166666666667, 1.66, 0.5
10529, 0.33333333333333, 1.54, 0.5
10530, 0.33333333333333, 1.58, 0.5
10531, 0.33333333333333, 1.62, 0.5
10532, 0.33333333333333, 1.66, 0.5
10533, 0.375, 1.54, 0.5
10534, 0.375, 1.58, 0.5
10535, 0.375, 1.62, 0.5
10536, 0.375, 1.66, 0.5
10537, 0.41666666666667, 1.54, 0.5
10538, 0.41666666666667, 1.58, 0.5
10539, 0.41666666666667, 1.62, 0.5
10540, 0.41666666666667, 1.66, 0.5
10541, 0.45833333333333, 1.54, 0.5
10542, 0.45833333333333, 1.58, 0.5
10543, 0.45833333333333, 1.62, 0.5
10544, 0.45833333333333, 1.66, 0.5
10545, 0.5, 1.54, 0.5
10546, 0.5, 1.58, 0.5
10547, 0.5, 1.62, 0.5
10548, 0.5, 1.66, 0.5
10549, 0.54166666666667, 1.54, 0.5
10550, 0.54166666666667, 1.58, 0.5
10551, 0.54166666666667, 1.62, 0.5
10552, 0.54166666666667, 1.66, 0.5
10553, 0.58333333333333, 1.54, 0.5
10554, 0.58333333333333, 1.58, 0.5
10555, 0.58333333333333, 1.62, 0.5
10556, 0.58333333333333, 1.66, 0.5
10557, 0.625, 1.54, 0.5
10558, 0.625, 1.58, 0.5
10559, 0.625, 1.62, 0.5
10560, 0.625, 1.66, 0.5
10561, 0.66666666666667, 1.54, 0.5
10562, 0.66666666666667, 1.58, 0.5
10563, 0.66666666666667, 1.62, 0.5
10564, 0.66666666666667, 1.66, 0.5
10565, 0.70833333333333, 1.54, 0.5
10566, 0.70833333333333, 1.58, 0.5
10567, 0.70833333333333, 1.62, 0.5
10568, 0.70833333333333, 1.66, 0.5
10569, 0.75, 1.54, 0.5
10570, 0.75, 1.58, 0.5
10571, 0.75, 1.62, 0.5
10572, 0.75, 1.66, 0.5
10573, 0.79166666666667, 1.54, 0.5
10574, 0.79166666666667, 1.58, 0.5
10575, 0.79166666666667, 1.62, 0.5
10576, 0.79166666666667, 1.66, 0.5
10577, 0.83333333333333, 1.54, 0.5
10578, 0.83333333333333, 1.58, 0.5
10579, 0.83333333333333, 1.62, 0.5
10580, 0.83333333333333, 1.66, 0.5
10581, 0.875, 1.54, 0.5
10582, 0.875, 1.58, 0.5
10583, 0.875, 1.62, 0.5
10584, 0.875, 1.66, 0.5
10585, 0.91666666666667, 1.54, 0.5
10586, 0.91666666666667, 1.58, 0.5
10587, 0.91666666666667, 1.62, 0.5
10588, 0.91666666666667, 1.66, 0.5
10589, 0.95833333333333, 1.54, 0.5
10590, 0.95833333333333, 1.58, 0.5
10591, 0.95833333333333, 1.62, 0.5
10592, 0.95833333333333, 1.66, 0.5
10593, 0, 1.54, 0.041666666666667
10594, 0, 1.58, 0.041666666666667
10595, 0, 1.62, 0.041666666666667
10596, 0, 1.66, 0.041666666666667
10597, 0, 1.54, 0.083333333333333
10598, 0, 1.58, 0.083333333333333
10599, 0, 1.62, 0.083333333333333
10600, 0, 1.66, 0.083333333333333
10601, 0, 1.54, 0.125
10602, 0, 1.58, 0.125
10603, 0, 1.62, 0.125
10604, 0, 1.66, 0.125
10605, 0, 1.54, 0.16666666666667
10606, 0, 1.58, 0.16666666666667
10607, 0, 1.62, 0.16666666666667
10608, 0, 1.66, 0.16666666666667
10609, 0, 1.54, 0.20833333333333
10610, 0, 1.58, 0.20833333333333
10611, 0, 1.62, 0.20833333333333
10612, 0, 1.66, 0.20833333333333
10613, 0, 1.54, 0.25
10614, 0, 1.58, 0.25
10615, 0, 1.62, 0.25
10616, 0, 1.66, 0.25
10617, 0, 1.54, 0.29166666666667
10618, 0, 1.58, 0.29166666666667
10619, 0, 1.62, 0.29166666666667
10620, 0, 1.66, 0.29166666666667
10621, 0, 1.54, 0.33333333333333
10622, 0, 1.58, 0.33333333333333
10623, 0, 1.62, 0.33333333333333
10624, 0, 1.66, 0.33333333333333
10625, 0, 1.54, 0.375
10626, 0, 1.58, 0.375
10627, 0, 1.62, 0.375
10628, 0, 1.66, 0.375
10629, 0, 1.54, 0.41666666666667
10630, 0, 1.58, 0.41666666666667
10631, 0, 1.62, 0.41666666666667
10632, 0, 1.66, 0.41666666666667
10633, 0, 1.54, 0.45833333333333
10634, 0, 1.58, 0.45833333333333
10635, 0, 1.62, 0.45833333333333
10636, 0, 1.66, 0.45833333333333
10637, 0.041666666666667, 1.7, 0.041666666666667
10638, 0.041666666666667, 1.7, 0.083333333333333
10639, 0.041666666666667, 1.7, 0.125
10640, 0.041666666666667, 1.7, 0.16666666666667
10641, 0.041666666666667, 1.7, 0.20833333333333
10642, 0.041666666666667, 1.7, 0.25
10643, 0.041666666666667, 1.7, 0.29166666666667
10644, 0.041666666666667, 1.7, 0.33333333333333
10645, 0.041666666666667, 1.7, 0.375
10646, 0.041666666666667, 1.7, 0.41666666666667
10647, 0.041666666666667, 1.7, 0.45833333333333
10648, 0.083333333333333, 1.7, 0.041666666666667
10649, 0.083333333333333, 1.7, 0.083333333333333
10650, 0.083333333333333, 1.7, 0.125
10651, 0.083333333333333, 1.7, 0.16666666666667
10652, 0.083333333333333, 1.7, 0.20833333333333
10653, 0.083333333333333, 1.7, 0.25
10654, 0.083333333333333, 1.7, 0.29166666666667
10655, 0.083333333333333, 1.7, 0.33333333333333
10656, 0.083333333333333, 1.7, 0.375
10657, 0.083333333333333, 1.7, 0.41666666666667
10658, 0.083333333333333, 1.7, 0.45833333333333
10659, 0.125, 1.7, 0.041666666666667
10660, 0.125, 1.7, 0.083333333333333
10661, 0.125, 1.7, 0.125
10662, 0.125, 1.7, 0.16666666666667
10663, 0.125, 1.7, 0.20833333333333
10664, 0.125, 1.7, 0.25
10665, 0.125, 1.7, 0.29166666666667
10666, 0.125, 1.7, 0.33333333333333
10667, 0.125, 1.7, 0.375
10668, 0.125, 1.7, 0.41666666666667
10669, 0.125, 1.7, 0.45833333333333
10670, 0.16666666666667, 1.7, 0.041666666666667
10671, 0.16666666666667, 1.7, 0.083333333333333
10672, 0.16666666666667, 1.7, 0.125
10673, 0.16666666666667, 1.7, 0.16666666666667
10674, 0.16666666666667, 1.7, 0.20833333333333
10675, 0.16666666666667, 1.7, 0.25
10676, 0.16666666666667, 1.7, 0.29166666666667
10677, 0.16666666666667, 1.7, 0.33333333333333
10678, 0.16666666666667, 1.7, 0.375
10679, 0.16666666666667, 1.7, 0.41666666666667
10680, 0.16666666666667, 1.7, 0.45833333333333
10681, 0.20833333333333, 1.7, 0.041666666666667
10682, 0.20833333333333, 1.7, 0.083333333333333
10683, 0.20833333333333, 1.7, 0.125
10684, 0.20833333333333, 1.7, 0.16666666666667
10685, 0.20833333333333, 1.7, 0.20833333333333
10686, 0.20833333333333, 1.7, 0.25
10687, 0.20833333333333, 1.7, 0.29166666666667
10688, 0.20833333333333, 1.7, 0.33333333333333
10689, 0.20833333333333, 1.7, 0.375
10690, 0.20833333333333, 1.7, 0.41666666666667
10691, 0.20833333333333, 1.7, 0.45833333333333
10692, 0.25, 1.7, 0.041666666666667
10693, 0.25, 1.7, 0.083333333333333
10694, 0.25, 1.7, 0.125
10695, 0.25, 1.7, 0.16666666666667
10696, 0.25, 1.7, 0.20833333333333
10697, 0.25, 1.7, 0.25
10698, 0.25, 1.7, 0.29166666666667
10699, 0.25, 1.7, 0.33333333333333
10700, 0.25, 1.7, 0.375
10701, 0.25, 1.7, 0.41666666666667
10702, 0.25, 1.7, 0.45833333333333
10703, 0.29166666666667, 1.7, 0.041666666666667
10704, 0.29166666666667, 1.7, 0.083333333333333
10705, 0.29166666666667, 1.7, 0.125
10706, 0.29166666666667, 1.7, 0.16666666666667
10707, 0.29166666666667, 1.7, 0.20833333333333
10708, 0.29166666666667, 1.7, 0.25
10709, 0.29166666666667, 1.7, 0.29166666666667
10710, 0.29166666666667, 1.7, 0.33333333333333
10711, 0.29166666666667, 1.7, 0.375
10712, 0.29166666666667, 1.7, 0.41666666666667
10713, 0.29166666666667, 1.7, 0.45833333333333
10714, 0.33333333333333, 1.7, 0.041666666666667
10715, 0.33333333333333, 1.7, 0.083333333333333
10716, 0.33333333333333, 1.7, 0.125
10717, 0.33333333333333, 1.7, 0.16666666666667
10718, 0.33333333333333, 1.7, 0.20833333333333
10719, 0.33333333333333, 1.7, 0.25
10720, 0.33333333333333, 1.7, 0.29166666666667
10721, 0.33333333333333, 1.7, 0.33333333333333
10722, 0.33333333333333, 1.7, 0.375
10723, 0.33333333333333, 1.7, 0.41666666666667
10724, 0.33333333333333, 1.7, 0.45833333333333
10725, 0.375, 1.7, 0.041666666666667
10726, 0.375, 1.7, 0.083333333333333
10727, 0.375, 1.7, 0.125
10728, 0.375, 1.7, 0.16666666666667
10729, 0.375, 1.7, 0.20833333333333
10730, 0.375, 1.7, 0.25
10731, 0.375, 1.7, 0.29166666666667
10732, 0.375, 1.7, 0.33333333333333
10733, 0.375, 1.7, 0.375
10734, 0.375, 1.7, 0.41666666666667
10735, 0.375, 1.7, 0.45833333333333
10736, 0.41666666666667, 1.7, 0.041666666666667
10737, 0.41666666666667, 1.7, 0.083333333333333
10738, 0.41666666666667, 1.7, 0.125
10739, 0.41666666666667, 1.7, 0.16666666666667
10740, 0.41666666666667, 1.7, 0.20833333333333
10741, 0.41666666666667, 1.7, 0.25
10742, 0.41666666666667, 1.7, 0.29166666666667
10743, 0.41666666666667, 1.7, 0.33333333333333
10744, 0.41666666666667, 1.7, 0.375
10745, 0.41666666666667, 1.7, 0.41666666666667
10746, 0.41666666666667, 1.7, 0.45833333333333
10747, 0.45833333333333, 1.7, 0.041666666666667
10748, 0.45833333333333, 1.7, 0.083333333333333
10749, 0.45833333333333, 1.7, 0.125
10750, 0.45833333333333, 1.7, 0.16666666666667
10751, 0.45833333333333, 1.7, 0.20833333333333
10752, 0.45833333333333, 1.7, 0.25
10753, 0.45833333333333, 1.7, 0.29166666666667
10754, 0.45833333333333, 1.7, 0.33333333333333
10755, 0.45833333333333, 1.7, 0.375
10756, 0.45833333333333, 1.7, 0.41666666666667
10757, 0.45833333333333, 1.7, 0.45833333333333
10758, 0.5, 1.7, 0.041666666666667
10759, 0.5, 1.7, 0.083333333333333
10760, 0.5, 1.7, 0.125
10761, 0.5, 1.7, 0.16666666666667
10762, 0.5, 1.7, 0.20833333333333
10763, 0.5, 1.7, 0.25
10764, 0.5, 1.7, 0.29166666666667
10765, 0.5, 1.7, 0.33333333333333
10766, 0.5, 1.7, 0.375
10767, 0.5, 1.7, 0.41666666666667
10768, 0.5, 1.7, 0.45833333333333
10769, 0.54166666666667, 1.7, 0.041666666666667
10770, 0.54166666666667, 1.7, 0.083333333333333
10771, 0.54166666666667, 1.7, 0.125
10772, 0.54166666666667, 1.7, 0.16666666666667
10773, 0.54166666666667, 1.7, 0.20833333333333
10774, 0.54166666666667, 1.7, 0.25
10775, 0.54166666666667, 1.7, 0.29166666666667
10776, 0.54166666666667, 1.7, 0.33333333333333
10777, 0.54166666666667, 1.7, 0.375
10778, 0.54166666666667, 1.7, 0.41666666666667
10779, 0.54166666666667, 1.7, 0.45833333333333
10780, 0.58333333333333, 1.7, 0.041666666666667
10781, 0.58333333333333, 1.7, 0.083333333333333
10782, 0.58333333333333, 1.7, 0.125
10783, 0.58333333333333, 1.7, 0.16666666666667
10784, 0.58333333333333, 1.7, 0.20833333333333
10785, 0.58333333333333, 1.7, 0.25
10786, 0.58333333333333, 1.7, 0.29166666666667
10787, 0.58333333333333, 1.7, 0.33333333333333
10788, 0.58333333333333, 1.7, 0.375
10789, 0.58333333333333, 1.7, 0.41666666666667
10790, 0.58333333333333, 1.7, 0.45833333333333
10791, 0.625, 1.7, 0.041666666666667
10792, 0.625, 1.7, 0.083333333333333
10793, 0.625, 1.7, 0.125
10794, 0.625, 1.7, 0.16666666666667
10795, 0.625, 1.7, 0.20833333333333
10796, 0.625, 1.7, 0.25
10797, 0.625, 1.7, 0.29166666666667
10798, 0.625, 1.7, 0.33333333333333
10799, 0.625, 1.7, 0.375
10800, 0.625, 1.7, 0.41666666666667
10801, 0.625, 1.7, 0.45833333333333
10802, 0.66666666666667, 1.7, 0.041666666666667
10803, 0.66666666666667, 1.7, 0.083333333333333
10804, 0.66666666666667, 1.7, 0.125
10805, 0.66666666666667, 1.7, 0.16666666666667
10806, 0.66666666666667, 1.7, 0.20833333333333
10807, 0.66666666666667, 1.7, 0.25
10808, 0.66666666666667, 1.7, 0.29166666666667
10809, 0.66666666666667, 1.7, 0.33333333333333
10810, 0.66666666666667, 1.7, 0.375
10811, 0.66666666666667, 1.7, 0.41666666666667
10812, 0.66666666666667, 1.7, 0.45833333333333
10813, 0.70833333333333, 1.7, 0.041666666666667
10814, 0.70833333333333, 1.7, 0.083333333333333
10815, 0.70833333333333, 1.7, 0.125
10816, 0.70833333333333, 1.7, 0.16666666666667
10817, 0.70833333333333, 1.7, 0.20833333333333
10818, 0.70833333333333, 1.7, 0.25
10819, 0.70833333333333, 1.7, 0.29166666666667
10820, 0.70833333333333, 1.7, 0.33333333333333
10821, 0.70833333333333, 1.7, 0.375
10822, 0.70833333333333, 1.7, 0.41666666666667
10823, 0.70833333333333, 1.7, 0.45833333333333
10824, 0.75, 1.7, 0.041666666666667
10825, 0.75, 1.7, 0.083333333333333
10826, 0.75, 1.7, 0.125
10827, 0.75, 1.7, 0.16666666666667
10828, 0.75, 1.7, 0.20833333333333
10829, 0.75, 1.7, 0.25
10830, 0.75, 1.7, 0.29166666666667
10831, 0.75, 1.7, 0.33333333333333
10832, 0.75, 1.7, 0.375
10833, 0.75, 1.7, 0.41666666666667
10834, 0.75, 1.7, 0.45833333333333
10835, 0.79166666666667, 1.7, 0.041666666666667
10836, 0.79166666666667, 1.7, 0.083333333333333
10837, 0.79166666666667, 1.7, 0.125
10838, 0.79166666666667, 1.7, 0.16666666666667
10839, 0.79166666666667, 1.7, 0.20833333333333
10840, 0.79166666666667, 1.7, 0.25
10841, 0.79166666666667, 1.7, 0.29166666666667
10842, 0.79166666666667, 1.7, 0.33333333333333
10843, 0.79166666666667, 1.7, 0.375
10844, 0.79166666666667, 1.7, 0.41666666666667
10845, 0.79166666666667, 1.7, 0.45833333333333
10846, 0.83333333333333, 1.7, 0.041666666666667
10847, 0.83333333333333, 1.7, 0.083333333333333
10848, 0.83333333333333, 1.7, 0.125
10849, 0.83333333333333, 1.7, 0.16666666666667
10850, 0.83333333333333, 1.7, 0.20833333333333
10851, 0.83333333333333, 1.7, 0.25
10852, 0.83333333333333, 1.7, 0.29166666666667
10853, 0.83333333333333, 1.7, 0.33333333333333
10854, 0.83333333333333, 1.7, 0.375
10855, 0.83333333333333, 1.7, 0.41666666666667
10856, 0.83333333333333, 1.7, 0.45833333333333
10857, 0.875, 1.7, 0.041666666666667
10858, 0.875, 1.7, 0.083333333333333
10859, 0.875, 1.7, 0.125
10860, 0.875, 1.7, 0.16666666666667
10861, 0.875, 1.7, 0.20833333333333
10862, 0.875, 1.7, 0.25
10863, 0.875, 1.7, 0.29166666666667
10864, 0.875, 1.7, 0.33333333333333
10865, 0.875, 1.7, 0.375
10866, 0.875, 1.7, 0.41666666666667
10867, 0.875, 1.7, 0.45833333333333
10868, 0.91666666666667, 1.7, 0.041666666666667
10869, 0.91666666666667, 1.7, 0.083333333333333
10870, 0.91666666666667, 1.7, 0.125
10871, 0.91666666666667, 1.7, 0.16666666666667
10872, 0.91666666666667, 1.7, 0.20833333333333
10873, 0.91666666666667, 1.7, 0.25
10874, 0.91666666666667, 1.7, 0.29166666666667
10875, 0.91666666666667, 1.7, 0.33333333333333
10876, 0.91666666666667, 1.7, 0.375
10877, 0.91666666666667, 1.7, 0.41666666666667
10878, 0.91666666666667, 1.7, 0.45833333333333
10879, 0.95833333333333, 1.7, 0.041666666666667
10880, 0.95833333333333, 1.7, 0.083333333333333
10881, 0.95833333333333, 1.7, 0.125
10882, 0.95833333333333, 1.7, 0.16666666666667
10883, 0.95833333333333, 1.7, 0.20833333333333
10884, 0.95833333333333, 1.7, 0.25
10885, 0.95833333333333, 1.7, 0.29166666666667
10886, 0.95833333333333, 1.7, 0.33333333333333
10887, 0.95833333333333, 1.7, 0.375
10888, 0.95833333333333, 1.7, 0.41666666666667
10889, 0.95833333333333, 1.7, 0.45833333333333
10890, 1.04, 1.54, 0.5
10891, 1.04, 1.58, 0.5
10892, 1.04, 1.62, 0.5
10893, 1.04, 1.66, 0.5
10894, 1.08, 1.54, 0.5
10895, 1.08, 1.58, 0.5
10896, 1.08, 1.62, 0.5
10897, 1.08, 1.66, 0.5
10898, 1.12, 1.54, 0.5
10899, 1.12, 1.58, 0.5
10900, 1.12, 1.62, 0.5
10901, 1.12, 1.66, 0.5
10902, 1.16, 1.54, 0.5
10903, 1.16, 1.58, 0.5
10904, 1.16, 1.62, 0.5
10905, 1.16, 1.66, 0.5
10906, 1.04, 1.54, 0
10907, 1.04, 1.58, 0
10908, 1.04, 1.62, 0
10909, 1.04, 1.66, 0
10910, 1.08, 1.54, 0
10911, 1.08, 1.58, 0
10912, 1.08, 1.62, 0
10913, 1.08, 1.66, 0
10914, 1.12, 1.54, 0
10915, 1.12, 1.58, 0
10916, 1.12, 1.62, 0
10917, 1.12, 1.66, 0
10918, 1.16, 1.54, 0
10919, 1.16, 1.58, 0
10920, 1.16, 1.62, 0
10921, 1.16, 1.66, 0
10922, 1.2, 1.54, 0.041666666666667
10923, 1.2, 1.58, 0.041666666666667
10924, 1.2, 1.62, 0.041666666666667
10925, 1.2, 1.66, 0.041666666666667
10926, 1.2, 1.54, 0.083333333333333
10927, 1.2, 1.58, 0.083333333333333
10928, 1.2, 1.62, 0.083333333333333
10929, 1.2, 1.66, 0.083333333333333
10930, 1.2, 1.54, 0.125
10931, 1.2, 1.58, 0.125
10932, 1.2, 1.62, 0.125
10933, 1.2, 1.66, 0.125
10934, 1.2, 1.54, 0.16666666666667
10935, 1.2, 1.58, 0.16666666666667
10936, 1.2, 1.62, 0.16666666666667
10937, 1.2, 1.66, 0.16666666666667
10938, 1.2, 1.54, 0.20833333333333
10939, 1.2, 1.58, 0.20833333333333
10940, 1.2, 1.62, 0.20833333333333
10941, 1.2, 1.66, 0.20833333333333
10942, 1.2, 1.54, 0.25
10943, 1.2, 1.58, 0.25
10944, 1.2, 1.62, 0.25
10945, 1.2, 1.66, 0.25
10946, 1.2, 1.54, 0.29166666666667
10947, 1.2, 1.58, 0.29166666666667
10948, 1.2, 1.62, 0.29166666666667
10949, 1.2, 1.66, 0.29166666666667
10950, 1.2, 1.54, 0.33333333333333
10951, 1.2, 1.58, 0.33333333333333
10952, 1.2, 1.62, 0.33333333333333
10953, 1.2, 1.66, 0.33333333333333
10954, 1.2, 1.54, 0.375
10955, 1.2, 1.58, 0.375
10956, 1.2, 1.62, 0.375
10957, 1.2, 1.66, 0.375
10958, 1.2, 1.54, 0.41666666666667
10959, 1.2, 1.58, 0.41666666666667
10960, 1.2, 1.62, 0.41666666666667
10961, 1.2, 1.66, 0.41666666666667
10962, 1.2, 1.54, 0.45833333333333
10963, 1.2, 1.58, 0.45833333333333
10964, 1.2, 1.62, 0.45833333333333
10965, 1.2, 1.66, 0.45833333333333
10966, 1.04, 1.7, 0.041666666666667
10967, 1.08, 1.7, 0.041666666666667
10968, 1.12, 1.7, 0.041666666666667
10969, 1.16, 1.7, 0.041666666666667
10970, 1.04, 1.7, 0.083333333333333
10971, 1.08, 1.7, 0.083333333333333
10972, 1.12, 1.7, 0.083333333333333
10973, 1.16, 1.7, 0.083333333333333
10974, 1.04, 1.7, 0.125
10975, 1.08, 1.7, 0.125
10976, 1.12, 1.7, 0.125
10977, 1.16, 1.7, 0.125
10978, 1.04, 1.7, 0.16666666666667
10979, 1.08, 1.7, 0.16666666666667
10980, 1.12, 1.7, 0.16666666666667
10981, 1.16, 1.7, 0.16666666666667
10982, 1.04, 1.7, 0.20833333333333
10983, 1.08, 1.7, 0.20833333333333
10984, 1.12, 1.7, 0.20833333333333
10985, 1.16, 1.7, 0.20833333333333
10986, 1.04, 1.7, 0.25
10987, 1.08, 1.7, 0.25
10988, 1.12, 1.7, 0.25
10989, 1.16, 1.7, 0.25
10990, 1.04, 1.7, 0.29166666666667
10991, 1.08, 1.7, 0.29166666666667
10992, 1.12, 1.7, 0.29166666666667
10993, 1.16, 1.7, 0.29166666666667
10994, 1.04, 1.7, 0.33333333333333
10995, 1.08, 1.7, 0.33333333333333
10996, 1.12, 1.7, 0.33333333333333
10997, 1.16, 1.7, 0.33333333333333
10998, 1.04, 1.7, 0.375
10999, 1.08, 1.7, 0.375
11000, 1.12, 1.7, 0.375
11001, 1.16, 1.7, 0.375
11002, 1.04, 1.7, 0.41666666666667
11003, 1.08, 1.7, 0.41666666666667
11004, 1.12, 1.7, 0.41666666666667
11005, 1.16, 1.7, 0.41666666666667
11006, 1.04, 1.7, 0.45833333333333
11007, 1.08, 1.7, 0.45833333333333
11008, 1.12, 1.7, 0.45833333333333
11009, 1.16, 1.7, 0.45833333333333
11010, 1.2416666666667, 1.54, 0.5
11011, 1.2416666666667, 1.58, 0.5
11012, 1.2416666666667, 1.62, 0.5
11013, 1.2416666666667, 1.66, 0.5
11014, 1.2833333333333, 1.54, 0.5
11015, 1.2833333333333, 1.58, 0.5
11016, 1.2833333333333, 1.62, 0.5
11017, 1.2833333333333, 1.66, 0.5
11018, 1.325, 1.54, 0.5
11019, 1.325, 1.58, 0.5
11020, 1.325, 1.62, 0.5
11021, 1.325, 1.66, 0.5
11022, 1.3666666666667, 1.54, 0.5
11023, 1.3666666666667, 1.58, 0.5
11024, 1.3666666666667, 1.62, 0.5
11025, 1.3666666666667, 1.66, 0.5
11026, 1.4083333333333, 1.54, 0.5
11027, 1.4083333333333, 1.58, 0.5
11028, 1.4083333333333, 1.62, 0.5
11029, 1.4083333333333, 1.66, 0.5
11030, 1.45, 1.54, 0.5
11031, 1.45, 1.58, 0.5
11032, 1.45, 1.62, 0.5
11033, 1.45, 1.66, 0.5
11034, 1.4916666666667, 1.54, 0.5
11035, 1.4916666666667, 1.58, 0.5
11036, 1.4916666666667, 1.62, 0.5
11037, 1.4916666666667, 1.66, 0.5
11038, 1.5333333333333, 1.54, 0.5
11039, 1.5333333333333, 1.58, 0.5
11040, 1.5333333333333, 1.62, 0.5
11041, 1.5333333333333, 1.66, 0.5
11042, 1.575, 1.54, 0.5
11043, 1.575, 1.58, 0.5
11044, 1.575, 1.62, 0.5
11045, 1.575, 1.66, 0.5
11046, 1.6166666666667, 1.54, 0.5
11047, 1.6166666666667, 1.58, 0.5
11048, 1.6166666666667, 1.62, 0.5
11049, 1.6166666666667, 1.66, 0.5
11050, 1.6583333333333, 1.54, 0.5
11051, 1.6583333333333, 1.58, 0.5
11052, 1.6583333333333, 1.62, 0.5
11053, 1.6583333333333, 1.66, 0.5
11054, 1.7, 1.54, 0.5
11055, 1.7, 1.58, 0.5
11056, 1.7, 1.62, 0.5
11057, 1.7, 1.66, 0.5
11058, 1.7416666666667, 1.54, 0.5
11059, 1.7416666666667, 1.58, 0.5
11060, 1.7416666666667, 1.62, 0.5
11061, 1.7416666666667, 1.66, 0.5
11062, 1.7833333333333, 1.54, 0.5
11063, 1.7833333333333, 1.58, 0.5
11064, 1.7833333333333, 1.62, 0.5
11065, 1.7833333333333, 1.66, 0.5
11066, 1.825, 1.54, 0.5
11067, 1.825, 1.58, 0.5
11068, 1.825, 1.62, 0.5
11069, 1.825, 1.66, 0.5
11070, 1.8666666666667, 1.54, 0.5
11071, 1.8666666666667, 1.58, 0.5
11072, 1.8666666666667, 1.62, 0.5
11073, 1.8666666666667, 1.66, 0.5
11074, 1.9083333333333, 1.54, 0.5
11075, 1.9083333333333, 1.58, 0.5
11076, 1.9083333333333, 1.62, 0.5
11077, 1.9083333333333, 1.66, 0.5
11078, 1.95, 1.54, 0.5
11079, 1.95, 1.58, 0.5
11080, 1.95, 1.62, 0.5
11081, 1.95, 1.66, 0.5
11082, 1.9916666666667, 1.54, 0.5
11083, 1.9916666666667, 1.58, 0.5
11084, 1.9916666666667, 1.62, 0.5
11085, 1.9916666666667, 1.66, 0.5
11086, 2.0333333333333, 1.54, 0.5
11087, 2.0333333333333, 1.58, 0.5
11088, 2.0333333333333, 1.62, 0.5
11089, 2.0333333333333, 1.66, 0.5
11090, 2.075, 1.54, 0.5
11091, 2.075, 1.58, 0.5
11092, 2.075, 1.62, 0.5
11093, 2.075, 1.66, 0.5
11094, 2.1166666666667, 1.54, 0.5
11095, 2.1166666666667, 1.58, 0.5
11096, 2.1166666666667, 1.62, 0.5
11097, 2.1166666666667, 1.66, 0.5
11098, 2.1583333333333, 1.54, 0.5
11099, 2.1583333333333, 1.58, 0.5
11100, 2.1583333333333, 1.62, 0.5
11101, 2.1583333333333, 1.66, 0.5
11102, 1.2416666666667, 1.54, 0
11103, 1.2416666666667, 1.58, 0
11104, 1.2416666666667, 1.62, 0
11105, 1.2416666666667, 1.66, 0
11106, 1.2833333333333, 1.54, 0
11107, 1.2833333333333, 1.58, 0
11108, 1.2833333333333, 1.62, 0
11109, 1.2833333333333, 1.66, 0
11110, 1.325, 1.54, 0
11111, 1.325, 1.58, 0
11112, 1.325, 1.62, 0
11113, 1.325, 1.66, 0
11114, 1.3666666666667, 1.54, 0
11115, 1.3666666666667, 1.58, 0
11116, 1.3666666666667, 1.62, 0
11117, 1.3666666666667, 1.66, 0
11118, 1.4083333333333, 1.54, 0
11119, 1.4083333333333, 1.58, 0
11120, 1.4083333333333, 1.62, 0
11121, 1.4083333333333, 1.66, 0
11122, 1.45, 1.54, 0
11123, 1.45, 1.58, 0
11124, 1.45, 1.62, 0
11125, 1.45, 1.66, 0
11126, 1.4916666666667, 1.54, 0
11127, 1.4916666666667, 1.58, 0
11128, 1.4916666666667, 1.62, 0
11129, 1.4916666666667, 1.66, 0
11130, 1.5333333333333, 1.54, 0
11131, 1.5333333333333, 1.58, 0
11132, 1.5333333333333, 1.62, 0
11133, 1.5333333333333, 1.66, 0
11134, 1.575, 1.54, 0
11135, 1.575, 1.58, 0
11136, 1.575, 1.62, 0
11137, 1.575, 1.66, 0
11138, 1.6166666666667, 1.54, 0
11139, 1.6166666666667, 1.58, 0
11140, 1.6166666666667, 1.62, 0
11141, 1.6166666666667, 1.66, 0
11142, 1.6583333333333, 1.54, 0
11143, 1.6583333333333, 1.58, 0
11144, 1.6583333333333, 1.62, 0
11145, 1.6583333333333, 1.66, 0
11146, 1.7, 1.54, 0
11147, 1.7, 1.58, 0
11148, 1.7, 1.62, 0
11149, 1.7, 1.66, 0
11150, 1.7416666666667, 1.54, 0
11151, 1.7416666666667, 1.58, 0
11152, 1.7416666666667, 1.62, 0
11153, 1.7416666666667, 1.66, 0
11154, 1.7833333333333, 1.54, 0
11155, 1.7833333333333, 1.58, 0
11156, 1.7833333333333, 1.62, 0
11157, 1.7833333333333, 1.66, 0
11158, 1.825, 1.54, 0
11159, 1.825, 1.58, 0
11160, 1.825, 1.62, 0
11161, 1.825, 1.66, 0
11162, 1.8666666666667, 1.54, 0
11163, 1.8666666666667, 1.58, 0
11164, 1.8666666666667, 1.62, 0
11165, 1.8666666666667, 1.66, 0
11166, 1.9083333333333, 1.54, 0
11167, 1.9083333333333, 1.58, 0
11168, 1.9083333333333, 1.62, 0
11169, 1.9083333333333, 1.66, 0
11170, 1.95, 1.54, 0
11171, 1.95, 1.58, 0
11172, 1.95, 1.62, 0
11173, 1.95, 1.66, 0
11174, 1.9916666666667, 1.54, 0
11175, 1.9916666666667, 1.58, 0
11176, 1.9916666666667, 1.62, 0
11177, 1.9916666666667, 1.66, 0
11178, 2.0333333333333, 1.54, 0
11179, 2.0333333333333, 1.58, 0
11180, 2.0333333333333, 1.62, 0
11181, 2.0333333333333, 1.66, 0
11182, 2.075, 1.54, 0
11183, 2.075, 1.58, 0
11184, 2.075, 1.62, 0
11185, 2.075, 1.66, 0
11186, 2.1166666666667, 1.54, 0
11187, 2.1166666666667, 1.58, 0
11188, 2.1166666666667, 1.62, 0
11189, 2.1166666666667, 1.66, 0
11190, 2.1583333333333, 1.54, 0
11191, 2.1583333333333, 1.58, 0
11192, 2.1583333333333, 1.62, 0
11193, 2.1583333333333, 1.66, 0
11194, 2.2, 1.54, 0.041666666666667
11195, 2.2, 1.58, 0.041666666666667
11196, 2.2, 1.62, 0.041666666666667
11197, 2.2, 1.66, 0.041666666666667
11198, 2.2, 1.54, 0.083333333333333
11199, 2.2, 1.58, 0.083333333333333
11200, 2.2, 1.62, 0.083333333333333
11201, 2.2, 1.66, 0.083333333333333
11202, 2.2, 1.54, 0.125
11203, 2.2, 1.58, 0.125
11204, 2.2, 1.62, 0.125
11205, 2.2, 1.66, 0.125
11206, 2.2, 1.54, 0.16666666666667
11207, 2.2, 1.58, 0.16666666666667
11208, 2.2, 1.62, 0.16666666666667
11209, 2.2, 1.66, 0.16666666666667
11210, 2.2, 1.54, 0.20833333333333
11211, 2.2, 1.58, 0.20833333333333
11212, 2.2, 1.62, 0.20833333333333
11213, 2.2, 1.66, 0.20833333333333
11214, 2.2, 1.54, 0.25
11215, 2.2, 1.58, 0.25
11216, 2.2, 1.62, 0.25
11217, 2.2, 1.66, 0.25
11218, 2.2, 1.54, 0.29166666666667
11219, 2.2, 1.58, 0.29166666666667
11220, 2.2, 1.62, 0.29166666666667
11221, 2.2, 1.66, 0.29166666666667
11222, 2.2, 1.54, 0.33333333333333
11223, 2.2, 1.58, 0.33333333333333
11224, 2.2, 1.62, 0.33333333333333
11225, 2.2, 1.66, 0.33333333333333
11226, 2.2, 1.54, 0.375
11227, 2.2, 1.58, 0.375
11228, 2.2, 1.62, 0.375
11229, 2.2, 1.66, 0.375
11230, 2.2, 1.54, 0.41666666666667
11231, 2.2, 1.58, 0.41666666666667
11232, 2.2, 1.62, 0.41666666666667
11233, 2.2, 1.66, 0.41666666666667
11234, 2.2, 1.54, 0.45833333333333
11235, 2.2, 1.58, 0.45833333333333
11236, 2.2, 1.62, 0.45833333333333
11237, 2.2, 1.66, 0.45833333333333
11238, 1.2416666666667, 1.7, 0.041666666666667
11239, 1.2833333333333, 1.7, 0.041666666666667
11240, 1.325, 1.7, 0.041666666666667
11241, 1.3666666666667, 1.7, 0.041666666666667
11242, 1.4083333333333, 1.7, 0.041666666666667
11243, 1.45, 1.7, 0.041666666666667
11244, 1.4916666666667, 1.7, 0.041666666666667
11245, 1.5333333333333, 1.7, 0.041666666666667
11246, 1.575, 1.7, 0.041666666666667
11247, 1.6166666666667, 1.7, 0.041666666666667
11248, 1.6583333333333, 1.7, 0.041666666666667
11249, 1.7, 1.7, 0.041666666666667
11250, 1.7416666666667, 1.7, 0.041666666666667
11251, 1.7833333333333, 1.7, 0.041666666666667
11252, 1.825, 1.7, 0.041666666666667
11253, 1.8666666666667, 1.7, 0.041666666666667
11254, 1.9083333333333, 1.7, 0.041666666666667
11255, 1.95, 1.7, 0.041666666666667
11256, 1.9916666666667, 1.7, 0.041666666666667
11257, 2.0333333333333, 1.7, 0.041666666666667
11258, 2.075, 1.7, 0.041666666666667
11259, 2.1166666666667, 1.7, 0.041666666666667
11260, 2.1583333333333, 1.7, 0.041666666666667
11261, 1.2416666666667, 1.7, 0.083333333333333
11262, 1.2833333333333, 1.7, 0.083333333333333
11263, 1.325, 1.7, 0.083333333333333
11264, 1.3666666666667, 1.7, 0.083333333333333
11265, 1.4083333333333, 1.7, 0.083333333333333
11266, 1.45, 1.7, 0.083333333333333
11267, 1.4916666666667, 1.7, 0.083333333333333
11268, 1.5333333333333, 1.7, 0.083333333333333
11269, 1.575, 1.7, 0.083333333333333
11270, 1.6166666666667, 1.7, 0.083333333333333
11271, 1.6583333333333, 1.7, 0.083333333333333
11272, 1.7, 1.7, 0.083333333333333
11273, 1.7416666666667, 1.7, 0.083333333333333
11274, 1.7833333333333, 1.7, 0.083333333333333
11275, 1.825, 1.7, 0.083333333333333
11276, 1.8666666666667, 1.7, 0.083333333333333
11277, 1.9083333333333, 1.7, 0.083333333333333
11278, 1.95, 1.7, 0.083333333333333
11279, 1.9916666666667, 1.7, 0.083333333333333
11280, 2.0333333333333, 1.7, 0.083333333333333
11281, 2.075, 1.7, 0.083333333333333
11282, 2.1166666666667, 1.7, 0.083333333333333
11283, 2.1583333333333, 1.7, 0.083333333333333
11284, 1.2416666666667, 1.7, 0.125
11285, 1.2833333333333, 1.7, 0.125
11286, 1.325, 1.7, 0.125
11287, 1.3666666666667, 1.7, 0.125
11288, 1.4083333333333, 1.7, 0.125
11289, 1.45, 1.7, 0.125
11290, 1.4916666666667, 1.7, 0.125
11291, 1.5333333333333, 1.7, 0.125
11292, 1.575, 1.7, 0.125
11293, 1.6166666666667, 1.7, 0.125
11294, 1.6583333333333, 1.7, 0.125
11295, 1.7, 1.7, 0.125
11296, 1.7416666666667, 1.7, 0.125
11297, 1.7833333333333, 1.7, 0.125
11298, 1.825, 1.7, 0.125
11299, 1.8666666666667, 1.7, 0.125
11300, 1.9083333333333, 1.7, 0.125
11301, 1.95, 1.7, 0.125
11302, 1.9916666666667, 1.7, 0.125
11303, 2.0333333333333, 1.7, 0.125
11304, 2.075, 1.7, 0.125
11305, 2.1166666666667, 1.7, 0.125
11306, 2.1583333333333, 1.7, 0.125
11307, 1.2416666666667, 1.7, 0.16666666666667
11308, 1.2833333333333, 1.7, 0.16666666666667
11309, 1.325, 1.7, 0.16666666666667
11310, 1.3666666666667, 1.7, 0.16666666666667
11311, 1.4083333333333, 1.7, 0.16666666666667
11312, 1.45, 1.7, 0.16666666666667
11313, 1.4916666666667, 1.7, 0.16666666666667
11314, 1.5333333333333, 1.7, 0.16666666666667
11315, 1.575, 1.7, 0.16666666666667
11316, 1.6166666666667, 1.7, 0.16666666666667
11317, 1.6583333333333, 1.7, 0.16666666666667
11318, 1.7, 1.7, 0.16666666666667
11319, 1.7416666666667, 1.7, 0.16666666666667
11320, 1.7833333333333, 1.7, 0.16666666666667
11321, 1.825, 1.7, 0.16666666666667
11322, 1.8666666666667, 1.7, 0.16666666666667
11323, 1.9083333333333, 1.7, 0.16666666666667
11324, 1.95, 1.7, 0.16666666666667
11325, 1.9916666666667, 1.7, 0.16666666666667
11326, 2.0333333333333, 1.7, 0.16666666666667
11327, 2.075, 1.7, 0.16666666666667
11328, 2.1166666666667, 1.7, 0.16666666666667
11329, 2.1583333333333, 1.7, 0.16666666666667
11330, 1.2416666666667, 1.7, 0.20833333333333
11331, 1.2833333333333, 1.7, 0.20833333333333
11332, 1.325, 1.7, 0.20833333333333
11333, 1.3666666666667, 1.7, 0.20833333333333
11334, 1.4083333333333, 1.7, 0.20833333333333
11335, 1.45, 1.7, 0.20833333333333
11336, 1.4916666666667, 1.7, 0.20833333333333
11337, 1.5333333333333, 1.7, 0.20833333333333
11338, 1.575, 1.7, 0.20833333333333
11339, 1.6166666666667, 1.7, 0.20833333333333
11340, 1.6583333333333, 1.7, 0.20833333333333
11341, 1.7, 1.7, 0.20833333333333
11342, 1.7416666666667, 1.7, 0.20833333333333
11343, 1.7833333333333, 1.7, 0.20833333333333
11344, 1.825, 1.7, 0.20833333333333
11345, 1.8666666666667, 1.7, 0.20833333333333
11346, 1.9083333333333, 1.7, 0.20833333333333
11347, 1.95, 1.7, 0.20833333333333
11348, 1.9916666666667, 1.7, 0.20833333333333
11349, 2.0333333333333, 1.7, 0.20833333333333
11350, 2.075, 1.7, 0.20833333333333
11351, 2.1166666666667, 1.7, 0.20833333333333
11352, 2.1583333333333, 1.7, 0.20833333333333
11353, 1.2416666666667, 1.7, 0.25
11354, 1.2833333333333, 1.7, 0.25
11355, 1.325, 1.7, 0.25
11356, 1.3666666666667, 1.7, 0.25
11357, 1.4083333333333, 1.7, 0.25
11358, 1.45, 1.7, 0.25
11359, 1.4916666666667, 1.7, 0.25
11360, 1.5333333333333, 1.7, 0.25
11361, 1.575, 1.7, 0.25
11362, 1.6166666666667, 1.7, 0.25
11363, 1.6583333333333, 1.7, 0.25
11364, 1.7, 1.7, 0.25
11365, 1.7416666666667, 1.7, 0.25
11366, 1.7833333333333, 1.7, 0.25
11367, 1.825, 1.7, 0.25
11368, 1.8666666666667, 1.7, 0.25
11369, 1.9083333333333, 1.7, 0.25
11370, 1.95, 1.7, 0.25
11371, 1.9916666666667, 1.7, 0.25
11372, 2.0333333333333, 1.7, 0.25
11373, 2.075, 1.7, 0.25
11374, 2.1166666666667, 1.7, 0.25
11375, 2.1583333333333, 1.7, 0.25
11376, 1.2416666666667, 1.7, 0.29166666666667
11377, 1.2833333333333, 1.7, 0.29166666666667
11378, 1.325, 1.7, 0.29166666666667
11379, 1.3666666666667, 1.7, 0.29166666666667
11380, 1.4083333333333, 1.7, 0.29166666666667
11381, 1.45, 1.7, 0.29166666666667
11382, 1.4916666666667, 1.7, 0.29166666666667
11383, 1.5333333333333, 1.7, 0.29166666666667
11384, 1.575, 1.7, 0.29166666666667
11385, 1.6166666666667, 1.7, 0.29166666666667
11386, 1.6583333333333, 1.7, 0.29166666666667
11387, 1.7, 1.7, 0.29166666666667
11388, 1.7416666666667, 1.7, 0.29166666666667
11389, 1.7833333333333, 1.7, 0.29166666666667
11390, 1.825, 1.7, 0.29166666666667
11391, 1.8666666666667, 1.7, 0.29166666666667
11392, 1.9083333333333, 1.7, 0.29166666666667
11393, 1.95, 1.7, 0.29166666666667
11394, 1.9916666666667, 1.7, 0.29166666666667
11395, 2.0333333333333, 1.7, 0.29166666666667
11396, 2.075, 1.7, 0.29166666666667
11397, 2.1166666666667, 1.7, 0.29166666666667
11398, 2.1583333333333, 1.7, 0.29166666666667
11399, 1.2416666666667, 1.7, 0.33333333333333
11400, 1.2833333333333, 1.7, 0.33333333333333
11401, 1.325, 1.7, 0.33333333333333
11402, 1.3666666666667, 1.7, 0.33333333333333
11403, 1.4083333333333, 1.7, 0.33333333333333
11404, 1.45, 1.7, 0.33333333333333
11405, 1.4916666666667, 1.7, 0.33333333333333
11406, 1.5333333333333, 1.7, 0.33333333333333
11407, 1.575, 1.7, 0.33333333333333
11408, 1.6166666666667, 1.7, 0.33333333333333
11409, 1.6583333333333, 1.7, 0.33333333333333
11410, 1.7, 1.7, 0.33333333333333
11411, 1.7416666666667, 1.7, 0.33333333333333
11412, 1.7833333333333, 1.7, 0.33333333333333
11413, 1.825, 1.7, 0.33333333333333
11414, 1.8666666666667, 1.7, 0.33333333333333
11415, 1.9083333333333, 1.7, 0.33333333333333
11416, 1.95, 1.7, 0.33333333333333
11417, 1.9916666666667, 1.7, 0.33333333333333
11418, 2.0333333333333, 1.7, 0.33333333333333
11419, 2.075, 1.7, 0.33333333333333
11420, 2.1166666666667, 1.7, 0.33333333333333
11421, 2.1583333333333, 1.7, 0.33333333333333
11422, 1.2416666666667, 1.7, 0.375
11423, 1.2833333333333, 1.7, 0.375
11424, 1.325, 1.7, 0.375
11425, 1.3666666666667, 1.7, 0.375
11426, 1.4083333333333, 1.7, 0.375
11427, 1.45, 1.7, 0.375
11428, 1.4916666666667, 1.7, 0.375
11429, 1.5333333333333, 1.7, 0.375
11430, 1.575, 1.7, 0.375
11431, 1.6166666666667, 1.7, 0.375
11432, 1.6583333333333, 1.7, 0.375
11433, 1.7, 1.7, 0.375
11434, 1.7416666666667, 1.7, 0.375
11435, 1.7833333333333, 1.7, 0.375
11436, 1.825, 1.7, 0.375
11437, 1.8666666666667, 1.7, 0.375
11438, 1.9083333333333, 1.7, 0.375
11439, 1.95, 1.7, 0.375
11440, 1.9916666666667, 1.7, 0.375
11441, 2.0333333333333, 1.7, 0.375
11442, 2.075, 1.7, 0.375
11443, 2.1166666666667, 1.7, 0.375
11444, 2.1583333333333, 1.7, 0.375
11445, 1.2416666666667, 1.7, 0.41666666666667
11446, 1.2833333333333, 1.7, 0.41666666666667
11447, 1.325, 1.7, 0.41666666666667
11448, 1.3666666666667, 1.7, 0.41666666666667
11449, 1.4083333333333, 1.7, 0.41666666666667
11450, 1.45, 1.7, 0.41666666666667
11451, 1.4916666666667, 1.7, 0.41666666666667
11452, 1.5333333333333, 1.7, 0.41666666666667
11453, 1.575, 1.7, 0.41666666666667
11454, 1.6166666666667, 1.7, 0.41666666666667
11455, 1.6583333333333, 1.7, 0.41666666666667
11456, 1.7, 1.7, 0.41666666666667
11457, 1.7416666666667, 1.7, 0.41666666666667
11458, 1.7833333333333, 1.7, 0.41666666666667
11459, 1.825, 1.7, 0.41666666666667
11460, 1.8666666666667, 1.7, 0.41666666666667
11461, 1.9083333333333, 1.7, 0.41666666666667
11462, 1.95, 1.7, 0.41666666666667
11463, 1.9916666666667, 1.7, 0.41666666666667
11464, 2.0333333333333, 1.7, 0.41666666666667
11465, 2.075, 1.7, 0.41666666666667
11466, 2.1166666666667, 1.7, 0.41666666666667
11467, 2.1583333333333, 1.7, 0.41666666666667
11468, 1.2416666666667, 1.7, 0.45833333333333
11469, 1.2833333333333, 1.7, 0.45833333333333
11470, 1.325, 1.7, 0.45833333333333
11471, 1.3666666666667, 1.7, 0.45833333333333
11472, 1.4083333333333, 1.7, 0.45833333333333
11473, 1.45, 1.7, 0.45833333333333
11474, 1.4916666666667, 1.7, 0.45833333333333
11475, 1.5333333333333, 1.7, 0.45833333333333
11476, 1.575, 1.7, 0.45833333333333
11477, 1.6166666666667, 1.7, 0.45833333333333
11478, 1.6583333333333, 1.7, 0.45833333333333
11479, 1.7, 1.7, 0.45833333333333
11480, 1.7416666666667, 1.7, 0.45833333333333
11481, 1.7833333333333, 1.7, 0.45833333333333
11482, 1.825, 1.7, 0.45833333333333
11483, 1.8666666666667, 1.7, 0.45833333333333
11484, 1.9083333333333, 1.7, 0.45833333333333
11485, 1.95, 1.7, 0.45833333333333
11486, 1.9916666666667, 1.7, 0.45833333333333
11487, 2.0333333333333, 1.7, 0.45833333333333
11488, 2.075, 1.7, 0.45833333333333
11489, 2.1166666666667, 1.7, 0.45833333333333
11490, 2.1583333333333, 1.7, 0.45833333333333
11491, 0.041666666666667, -0.04, 0
11492, 0.041666666666667, -0.08, 0
11493, 0.041666666666667, -0.12, 0
11494, 0.041666666666667, -0.16, 0
11495, 0.083333333333333, -0.04, 0
11496, 0.083333333333333, -0.08, 0
11497, 0.083333333333333, -0.12, 0
11498, 0.083333333333333, -0.16, 0
11499, 0.125, -0.04, 0
11500, 0.125, -0.08, 0
11501, 0.125, -0.12, 0
11502, 0.125, -0.16, 0
11503, 0.16666666666667, -0.04, 0
11504, 0.16666666666667, -0.08, 0
11505, 0.16666666666667, -0.12, 0
11506, 0.16666666666667, -0.16, 0
11507, 0.20833333333333, -0.04, 0
11508, 0.20833333333333, -0.08, 0
11509, 0.20833333333333, -0.12, 0
11510, 0.20833333333333, -0.16, 0
11511, 0.25, -0.04, 0
11512, 0.25, -0.08, 0
11513, 0.25, -0.12, 0
11514, 0.25, -0.16, 0
11515, 0.29166666666667, -0.04, 0
11516, 0.29166666666667, -0.08, 0
11517, 0.29166666666667, -0.12, 0
11518, 0.29166666666667, -0.16, 0
11519, 0.33333333333333, -0.04, 0
11520, 0.33333333333333, -0.08, 0
11521, 0.33333333333333, -0.12, 0
11522, 0.33333333333333, -0.16, 0
11523, 0.375, -0.04, 0
11524, 0.375, -0.08, 0
11525, 0.375, -0.12, 0
11526, 0.375, -0.16, 0
11527, 0.41666666666667, -0.04, 0
11528, 0.41666666666667, -0.08, 0
11529, 0.41666666666667, -0.12, 0
11530, 0.41666666666667, -0.16, 0
11531, 0.45833333333333, -0.04, 0
11532, 0.45833333333333, -0.08, 0
11533, 0.45833333333333, -0.12, 0
11534, 0.45833333333333, -0.16, 0
11535, 0.5, -0.04, 0
11536, 0.5, -0.08, 0
11537, 0.5, -0.12, 0
11538, 0.5, -0.16, 0
11539, 0.54166666666667, -0.04, 0
11540, 0.54166666666667, -0.08, 0
11541, 0.54166666666667, -0.12, 0
11542, 0.54166666666667, -0.16, 0
11543, 0.58333333333333, -0.04, 0
11544, 0.58333333333333, -0.08, 0
11545, 0.58333333333333, -0.12, 0
11546, 0.58333333333333, -0.16, 0
11547, 0.625, -0.04, 0
11548, 0.625, -0.08, 0
11549, 0.625, -0.12, 0
11550, 0.625, -0.16, 0
11551, 0.66666666666667, -0.04, 0
11552, 0.66666666666667, -0.08, 0
11553, 0.66666666666667, -0.12, 0
11554, 0.66666666666667, -0.16, 0
11555, 0.70833333333333, -0.04, 0
11556, 0.70833333333333, -0.08, 0
11557, 0.70833333333333, -0.12, 0
11558, 0.70833333333333, -0.16, 0
11559, 0.75, -0.04, 0
11560, 0.75, -0.08, 0
11561, 0.75, -0.12, 0
11562, 0.75, -0.16, 0
11563, 0.79166666666667, -0.04, 0
11564, 0.79166666666667, -0.08, 0
11565, 0.79166666666667, -0.12, 0
11566, 0.79166666666667, -0.16, 0
11567, 0.83333333333333, -0.04, 0
11568, 0.83333333333333, -0.08, 0
11569, 0.83333333333333, -0.12, 0
11570, 0.83333333333333, -0.16, 0
11571, 0.875, -0.04, 0
11572, 0.875, -0.08, 0
11573, 0.875, -0.12, 0
11574, 0.875, -0.16, 0
11575, 0.91666666666667, -0.04, 0
11576, 0.91666666666667, -0.08, 0
11577, 0.91666666666667, -0.12, 0
11578, 0.91666666666667, -0.16, 0
11579, 0.95833333333333, -0.04, 0
11580, 0.95833333333333, -0.08, 0
11581, 0.95833333333333, -0.12, 0
11582, 0.95833333333333, -0.16, 0
11583, 1, -0.04, 0.041666666666667
11584, 1, -0.08, 0.041666666666667
11585, 1, -0.12, 0.041666666666667
11586, 1, -0.16, 0.041666666666667
11587, 1, -0.04, 0.083333333333333
11588, 1, -0.08, 0.083333333333333
11589, 1, -0.12, 0.083333333333333
11590, 1, -0.16, 0.083333333333333
11591, 1, -0.04, 0.125
11592, 1, -0.08, 0.125
11593, 1, -0.12, 0.125
11594, 1, -0.16, 0.125
11595, 1, -0.04, 0.16666666666667
11596, 1, -0.08, 0.16666666666667
11597, 1, -0.12, 0.16666666666667
11598, 1, -0.16, 0.16666666666667
11599, 1, -0.04, 0.20833333333333
11600, 1, -0.08, 0.20833333333333
11601, 1, -0.12, 0.20833333333333
11602, 1, -0.16, 0.20833333333333
11603, 1, -0.04, 0.25
11604, 1, -0.08, 0.25
11605, 1, -0.12, 0.25
11606, 1, -0.16, 0.25
11607, 1, -0.04, 0.29166666666667
11608, 1, -0.08, 0.29166666666667
11609, 1, -0.12, 0.29166666666667
11610, 1, -0.16, 0.29166666666667
11611, 1, -0.04, 0.33333333333333
11612, 1, -0.08, 0.33333333333333
11613, 1, -0.12, 0.33333333333333
11614, 1, -0.16, 0.33333333333333
11615, 1, -0.04, 0.375
11616, 1, -0.08, 0.375
11617, 1, -0.12, 0.375
11618, 1, -0.16, 0.375
11619, 1, -0.04, 0.41666666666667
11620, 1, -0.08, 0.41666666666667
11621, 1, -0.12, 0.41666666666667
11622, 1, -0.16, 0.41666666666667
11623, 1, -0.04, 0.45833333333333
11624, 1, -0.08, 0.45833333333333
11625, 1, -0.12, 0.45833333333333
11626, 1, -0.16, 0.45833333333333
11627, 0.041666666666667, -0.04, 0.5
11628, 0.041666666666667, -0.08, 0.5
11629, 0.041666666666667, -0.12, 0.5
11630, 0.041666666666667, -0.16, 0.5
11631, 0.083333333333333, -0.04, 0.5
11632, 0.083333333333333, -0.08, 0.5
11633, 0.083333333333333, -0.12, 0.5
11634, 0.083333333333333, -0.16, 0.5
11635, 0.125, -0.04, 0.5
11636, 0.125, -0.08, 0.5
11637, 0.125, -0.12, 0.5
11638, 0.125, -0.16, 0.5
11639, 0.16666666666667, -0.04, 0.5
11640, 0.16666666666667, -0.08, 0.5
11641, 0.16666666666667, -0.12, 0.5
11642, 0.16666666666667, -0.16, 0.5
11643, 0.20833333333333, -0.04, 0.5
11644, 0.20833333333333, -0.08, 0.5
11645, 0.20833333333333, -0.12, 0.5
11646, 0.20833333333333, -0.16, 0.5
11647, 0.25, -0.04, 0.5
11648, 0.25, -0.08, 0.5
11649, 0.25, -0.12, 0.5
11650, 0.25, -0.16, 0.5
11651, 0.29166666666667, -0.04, 0.5
11652, 0.29166666666667, -0.08, 0.5
11653, 0.29166666666667, -0.12, 0.5
11654, 0.29166666666667, -0.16, 0.5
11655, 0.33333333333333, -0.04, 0.5
11656, 0.33333333333333, -0.08, 0.5
11657, 0.33333333333333, -0.12, 0.5
11658, 0.33333333333333, -0.16, 0.5
11659, 0.375, -0.04, 0.5
11660, 0.375, -0.08, 0.5
11661, 0.375, -0.12, 0.5
11662, 0.375, -0.16, 0.5
11663, 0.41666666666667, -0.04, 0.5
11664, 0.41666666666667, -0.08, 0.5
11665, 0.41666666666667, -0.12, 0.5
11666, 0.41666666666667, -0.16, 0.5
11667, 0.45833333333333, -0.04, 0.5
11668, 0.45833333333333, -0.08, 0.5
11669, 0.45833333333333, -0.12, 0.5
11670, 0.45833333333333, -0.16, 0.5
11671, 0.5, -0.04, 0.5
11672, 0.5, -0.08, 0.5
11673, 0.5, -0.12, 0.5
11674, 0.5, -0.16, 0.5
11675, 0.54166666666667, -0.04, 0.5
11676, 0.54166666666667, -0.08, 0.5
11677, 0.54166666666667, -0.12, 0.5
11678, 0.54166666666667, -0.16, 0.5
11679, 0.58333333333333, -0.04, 0.5
11680, 0.58333333333333, -0.08, 0.5
11681, 0.58333333333333, -0.12, 0.5
11682, 0.58333333333333, -0.16, 0.5
11683, 0.625, -0.04, 0.5
11684, 0.625, -0.08, 0.5
11685, 0.625, -0.12, 0.5
11686, 0.625, -0.16, 0.5
11687, 0.66666666666667, -0.04, 0.5
11688, 0.66666666666667, -0.08, 0.5
11689, 0.66666666666667, -0.12, 0.5
11690, 0.66666666666667, -0.16, 0.5
11691, 0.70833333333333, -0.04, 0.5
11692, 0.70833333333333, -0.08, 0.5
11693, 0.70833333333333, -0.12, 0.5
11694, 0.70833333333333, -0.16, 0.5
11695, 0.75, -0.04, 0.5
11696, 0.75, -0.08, 0.5
11697, 0.75, -0.12, 0.5
11698, 0.75, -0.16, 0.5
11699, 0.79166666666667, -0.04, 0.5
11700, 0.79166666666667, -0.08, 0.5
11701, 0.79166666666667, -0.12, 0.5
11702, 0.79166666666667, -0.16, 0.5
11703, 0.83333333333333, -0.04, 0.5
11704, 0.83333333333333, -0.08, 0.5
11705, 0.83333333333333, -0.12, 0.5
11706, 0.83333333333333, -0.16, 0.5
11707, 0.875, -0.04, 0.5
11708, 0.875, -0.08, 0.5
11709, 0.875, -0.12, 0.5
11710, 0.875, -0.16, 0.5
11711, 0.91666666666667, -0.04, 0.5
11712, 0.91666666666667, -0.08, 0.5
11713, 0.91666666666667, -0.12, 0.5
11714, 0.91666666666667, -0.16, 0.5
11715, 0.95833333333333, -0.04, 0.5
11716, 0.95833333333333, -0.08, 0.5
11717, 0.95833333333333, -0.12, 0.5
11718, 0.95833333333333, -0.16, 0.5
11719, 0, -0.04, 0.041666666666667
11720, 0, -0.08, 0.041666666666667
11721, 0, -0.12, 0.041666666666667
11722, 0, -0.16, 0.041666666666667
11723, 0, -0.04, 0.083333333333333
11724, 0, -0.08, 0.083333333333333
11725, 0, -0.12, 0.083333333333333
11726, 0, -0.16, 0.083333333333333
11727, 0, -0.04, 0.125
11728, 0, -0.08, 0.125
11729, 0, -0.12, 0.125
11730, 0, -0.16, 0.125
11731, 0, -0.04, 0.16666666666667
11732, 0, -0.08, 0.16666666666667
11733, 0, -0.12, 0.16666666666667
11734, 0, -0.16, 0.16666666666667
11735, 0, -0.04, 0.20833333333333
11736, 0, -0.08, 0.20833333333333
11737, 0, -0.12, 0.20833333333333
11738, 0, -0.16, 0.20833333333333
11739, 0, -0.04, 0.25
11740, 0, -0.08, 0.25
11741, 0, -0.12, 0.25
11742, 0, -0.16, 0.25
11743, 0, -0.04, 0.29166666666667
11744, 0, -0.08, 0.29166666666667
11745, 0, -0.12, 0.29166666666667
11746, 0, -0.16, 0.29166666666667
11747, 0, -0.04, 0.33333333333333
11748, 0, -0.08, 0.33333333333333
11749, 0, -0.12, 0.33333333333333
11750, 0, -0.16, 0.33333333333333
11751, 0, -0.04, 0.375
11752, 0, -0.08, 0.375
11753, 0, -0.12, 0.375
11754, 0, -0.16, 0.375
11755, 0, -0.04, 0.41666666666667
11756, 0, -0.08, 0.41666666666667
11757, 0, -0.12, 0.41666666666667
11758, 0, -0.16, 0.41666666666667
11759, 0, -0.04, 0.45833333333333
11760, 0, -0.08, 0.45833333333333
11761, 0, -0.12, 0.45833333333333
11762, 0, -0.16, 0.45833333333333
11763, 0.041666666666667, -0.2, 0.041666666666667
11764, 0.041666666666667, -0.2, 0.083333333333333
11765, 0.041666666666667, -0.2, 0.125
11766, 0.041666666666667, -0.2, 0.16666666666667
11767, 0.041666666666667, -0.2, 0.20833333333333
11768, 0.041666666666667, -0.2, 0.25
11769, 0.041666666666667, -0.2, 0.29166666666667
11770, 0.041666666666667, -0.2, 0.33333333333333
11771, 0.041666666666667, -0.2, 0.375
11772, 0.041666666666667, -0.2, 0.41666666666667
11773, 0.041666666666667, -0.2, 0.45833333333333
11774, 0.083333333333333, -0.2, 0.041666666666667
11775, 0.083333333333333, -0.2, 0.083333333333333
11776, 0.083333333333333, -0.2, 0.125
11777, 0.083333333333333, -0.2, 0.16666666666667
11778, 0.083333333333333, -0.2, 0.20833333333333
11779, 0.083333333333333, -0.2, 0.25
11780, 0.083333333333333, -0.2, 0.29166666666667
11781, 0.083333333333333, -0.2, 0.33333333333333
11782, 0.083333333333333, -0.2, 0.375
11783, 0.083333333333333, -0.2, 0.41666666666667
11784, 0.083333333333333, -0.2, 0.45833333333333
11785, 0.125, -0.2, 0.041666666666667
11786, 0.125, -0.2, 0.083333333333333
11787, 0.125, -0.2, 0.125
11788, 0.125, -0.2, 0.16666666666667
11789, 0.125, -0.2, 0.20833333333333
11790, 0.125, -0.2, 0.25
11791, 0.125, -0.2, 0.29166666666667
11792, 0.125, -0.2, 0.33333333333333
11793, 0.125, -0.2, 0.375
11794, 0.125, -0.2, 0.41666666666667
11795, 0.125, -0.2, 0.45833333333333
11796, 0.16666666666667, -0.2, 0.041666666666667
11797, 0.16666666666667, -0.2, 0.083333333333333
11798, 0.16666666666667, -0.2, 0.125
11799, 0.16666666666667, -0.2, 0.16666666666667
11800, 0.16666666666667, -0.2, 0.20833333333333
11801, 0.16666666666667, -0.2, 0.25
11802, 0.16666666666667, -0.2, 0.29166666666667
11803, 0.16666666666667, -0.2, 0.33333333333333
11804, 0.16666666666667, -0.2, 0.375
11805, 0.16666666666667, -0.2, 0.41666666666667
11806, 0.16666666666667, -0.2, 0.45833333333333
11807, 0.20833333333333, -0.2, 0.041666666666667
11808, 0.20833333333333, -0.2, 0.083333333333333
11809, 0.20833333333333, -0.2, 0.125
11810, 0.20833333333333, -0.2, 0.16666666666667
11811, 0.20833333333333, -0.2, 0.20833333333333
11812, 0.20833333333333, -0.2, 0.25
11813, 0.20833333333333, -0.2, 0.29166666666667
11814, 0.20833333333333, -0.2, 0.33333333333333
11815, 0.20833333333333, -0.2, 0.375
11816, 0.20833333333333, -0.2, 0.41666666666667
11817, 0.20833333333333, -0.2, 0.45833333333333
11818, 0.25, -0.2, 0.041666666666667
11819, 0.25, -0.2, 0.083333333333333
11820, 0.25, -0.2, 0.125
11821, 0.25, -0.2, 0.16666666666667
11822, 0.25, -0.2, 0.20833333333333
11823, 0.25, -0.2, 0.25
11824, 0.25, -0.2, 0.29166666666667
11825, 0.25, -0.2, 0.33333333333333
11826, 0.25, -0.2, 0.375
11827, 0.25, -0.2, 0.41666666666667
11828, 0.25, -0.2, 0.45833333333333
11829, 0.29166666666667, -0.2, 0.041666666666667
11830, 0.29166666666667, -0.2, 0.083333333333333
11831, 0.29166666666667, -0.2, 0.125
11832, 0.29166666666667, -0.2, 0.16666666666667
11833, 0.29166666666667, -0.2, 0.20833333333333
11834, 0.29166666666667, -0.2, 0.25
11835, 0.29166666666667, -0.2, 0.29166666666667
11836, 0.29166666666667, -0.2, 0.33333333333333
11837, 0.29166666666667, -0.2, 0.375
11838, 0.29166666666667, -0.2, 0.41666666666667
11839, 0.29166666666667, -0.2, 0.45833333333333
11840, 0.33333333333333, -0.2, 0.041666666666667
11841, 0.33333333333333, -0.2, 0.083333333333333
11842, 0.33333333333333, -0.2, 0.125
11843, 0.33333333333333, -0.2, 0.16666666666667
11844, 0.33333333333333, -0.2, 0.20833333333333
11845, 0.33333333333333, -0.2, 0.25
11846, 0.33333333333333, -0.2, 0.29166666666667
11847, 0.33333333333333, -0.2, 0.33333333333333
11848, 0.33333333333333, -0.2, 0.375
11849, 0.33333333333333, -0.2, 0.41666666666667
11850, 0.33333333333333, -0.2, 0.45833333333333
11851, 0.375, -0.2, 0.041666666666667
11852, 0.375, -0.2, 0.083333333333333
11853, 0.375, -0.2, 0.125
11854, 0.375, -0.2, 0.16666666666667
11855, 0.375, -0.2, 0.20833333333333
11856, 0.375, -0.2, 0.25
11857, 0.375, -0.2, 0.29166666666667
11858, 0.375, -0.2, 0.33333333333333
11859, 0.375, -0.2, 0.375
11860, 0.375, -0.2, 0.41666666666667
11861, 0.375, -0.2, 0.45833333333333
11862, 0.41666666666667, -0.2, 0.041666666666667
11863, 0.41666666666667, -0.2, 0.083333333333333
11864, 0.41666666666667, -0.2, 0.125
11865, 0.41666666666667, -0.2, 0.16666666666667
11866, 0.41666666666667, -0.2, 0.20833333333333
11867, 0.41666666666667, -0.2, 0.25
11868, 0.41666666666667, -0.2, 0.29166666666667
11869, 0.41666666666667, -0.2, 0.33333333333333
11870, 0.41666666666667, -0.2, 0.375
11871, 0.41666666666667, -0.2, 0.41666666666667
11872, 0.41666666666667, -0.2, 0.45833333333333
11873, 0.45833333333333, -0.2, 0.041666666666667
11874, 0.45833333333333, -0.2, 0.083333333333333
11875, 0.45833333333333, -0.2, 0.125
11876, 0.45833333333333, -0.2, 0.16666666666667
11877, 0.45833333333333, -0.2, 0.20833333333333
11878, 0.45833333333333, -0.2, 0.25
11879, 0.45833333333333, -0.2, 0.29166666666667
11880, 0.45833333333333, -0.2, 0.33333333333333
11881, 0.45833333333333, -0.2, 0.375
11882, 0.45833333333333, -0.2, 0.41666666666667
11883, 0.45833333333333, -0.2, 0.45833333333333
11884, 0.5, -0.2, 0.041666666666667
11885, 0.5, -0.2, 0.083333333333333
11886, 0.5, -0.2, 0.125
11887, 0.5, -0.2, 0.16666666666667
11888, 0.5, -0.2, 0.20833333333333
11889, 0.5, -0.2, 0.25
11890, 0.5, -0.2, 0.29166666666667
11891, 0.5, -0.2, 0.33333333333333
11892, 0.5, -0.2, 0.375
11893, 0.5, -0.2, 0.41666666666667
11894, 0.5, -0.2, 0.45833333333333
11895, 0.54166666666667, -0.2, 0.041666666666667
11896, 0.54166666666667, -0.2, 0.083333333333333
11897, 0.54166666666667, -0.2, 0.125
11898, 0.54166666666667, -0.2, 0.16666666666667
11899, 0.54166666666667, -0.2, 0.20833333333333
11900, 0.54166666666667, -0.2, 0.25
11901, 0.54166666666667, -0.2, 0.29166666666667
11902, 0.54166666666667, -0.2, 0.33333333333333
11903, 0.54166666666667, -0.2, 0.375
11904, 0.54166666666667, -0.2, 0.41666666666667
11905, 0.54166666666667, -0.2, 0.45833333333333
11906, 0.58333333333333, -0.2, 0.041666666666667
11907, 0.58333333333333, -0.2, 0.083333333333333
11908, 0.58333333333333, -0.2, 0.125
11909, 0.58333333333333, -0.2, 0.16666666666667
11910, 0.58333333333333, -0.2, 0.20833333333333
11911, 0.58333333333333, -0.2, 0.25
11912, 0.58333333333333, -0.2, 0.29166666666667
11913, 0.58333333333333, -0.2, 0.33333333333333
11914, 0.58333333333333, -0.2, 0.375
11915, 0.58333333333333, -0.2, 0.41666666666667
11916, 0.58333333333333, -0.2, 0.45833333333333
11917, 0.625, -0.2, 0.041666666666667
11918, 0.625, -0.2, 0.083333333333333
11919, 0.625, -0.2, 0.125
11920, 0.625, -0.2, 0.16666666666667
11921, 0.625, -0.2, 0.20833333333333
11922, 0.625, -0.2, 0.25
11923, 0.625, -0.2, 0.29166666666667
11924, 0.625, -0.2, 0.33333333333333
11925, 0.625, -0.2, 0.375
11926, 0.625, -0.2, 0.41666666666667
11927, 0.625, -0.2, 0.45833333333333
11928, 0.66666666666667, -0.2, 0.041666666666667
11929, 0.66666666666667, -0.2, 0.083333333333333
11930, 0.66666666666667, -0.2, 0.125
11931, 0.66666666666667, -0.2, 0.16666666666667
11932, 0.66666666666667, -0.2, 0.20833333333333
11933, 0.66666666666667, -0.2, 0.25
11934, 0.66666666666667, -0.2, 0.29166666666667
11935, 0.66666666666667, -0.2, 0.33333333333333
11936, 0.66666666666667, -0.2, 0.375
11937, 0.66666666666667, -0.2, 0.41666666666667
11938, 0.66666666666667, -0.2, 0.45833333333333
11939, 0.70833333333333, -0.2, 0.041666666666667
11940, 0.70833333333333, -0.2, 0.083333333333333
11941, 0.70833333333333, -0.2, 0.125
11942, 0.70833333333333, -0.2, 0.16666666666667
11943, 0.70833333333333, -0.2, 0.20833333333333
11944, 0.70833333333333, -0.2, 0.25
11945, 0.70833333333333, -0.2, 0.29166666666667
11946, 0.70833333333333, -0.2, 0.33333333333333
11947, 0.70833333333333, -0.2, 0.375
11948, 0.70833333333333, -0.2, 0.41666666666667
11949, 0.70833333333333, -0.2, 0.45833333333333
11950, 0.75, -0.2, 0.041666666666667
11951, 0.75, -0.2, 0.083333333333333
11952, 0.75, -0.2, 0.125
11953, 0.75, -0.2, 0.16666666666667
11954, 0.75, -0.2, 0.20833333333333
11955, 0.75, -0.2, 0.25
11956, 0.75, -0.2, 0.29166666666667
11957, 0.75, -0.2, 0.33333333333333
11958, 0.75, -0.2, 0.375
11959, 0.75, -0.2, 0.41666666666667
11960, 0.75, -0.2, 0.45833333333333
11961, 0.79166666666667, -0.2, 0.041666666666667
11962, 0.79166666666667, -0.2, 0.083333333333333
11963, 0.79166666666667, -0.2, 0.125
11964, 0.79166666666667, -0.2, 0.16666666666667
11965, 0.79166666666667, -0.2, 0.20833333333333
11966, 0.79166666666667, -0.2, 0.25
11967, 0.79166666666667, -0.2, 0.29166666666667
11968, 0.79166666666667, -0.2, 0.33333333333333
11969, 0.79166666666667, -0.2, 0.375
11970, 0.79166666666667, -0.2, 0.41666666666667
11971, 0.79166666666667, -0.2, 0.45833333333333
11972, 0.83333333333333, -0.2, 0.041666666666667
11973, 0.83333333333333, -0.2, 0.083333333333333
11974, 0.83333333333333, -0.2, 0.125
11975, 0.83333333333333, -0.2, 0.16666666666667
11976, 0.83333333333333, -0.2, 0.20833333333333
11977, 0.83333333333333, -0.2, 0.25
11978, 0.83333333333333, -0.2, 0.29166666666667
11979, 0.83333333333333, -0.2, 0.33333333333333
11980, 0.83333333333333, -0.2, 0.375
11981, 0.83333333333333, -0.2, 0.41666666666667
11982, 0.83333333333333, -0.2, 0.45833333333333
11983, 0.875, -0.2, 0.041666666666667
11984, 0.875, -0.2, 0.083333333333333
11985, 0.875, -0.2, 0.125
11986, 0.875, -0.2, 0.16666666666667
11987, 0.875, -0.2, 0.20833333333333
11988, 0.875, -0.2, 0.25
11989, 0.875, -0.2, 0.29166666666667
11990, 0.875, -0.2, 0.33333333333333
11991, 0.875, -0.2, 0.375
11992, 0.875, -0.2, 0.41666666666667
11993, 0.875, -0.2, 0.45833333333333
11994, 0.91666666666667, -0.2, 0.041666666666667
11995, 0.91666666666667, -0.2, 0.083333333333333
11996, 0.91666666666667, -0.2, 0.125
11997, 0.91666666666667, -0.2, 0.16666666666667
11998, 0.91666666666667, -0.2, 0.20833333333333
11999, 0.91666666666667, -0.2, 0.25
12000, 0.91666666666667, -0.2, 0.29166666666667
12001, 0.91666666666667, -0.2, 0.33333333333333
12002, 0.91666666666667, -0.2, 0.375
12003, 0.91666666666667, -0.2, 0.41666666666667
12004, 0.91666666666667, -0.2, 0.45833333333333
12005, 0.95833333333333, -0.2, 0.041666666666667
12006, 0.95833333333333, -0.2, 0.083333333333333
12007, 0.95833333333333, -0.2, 0.125
12008, 0.95833333333333, -0.2, 0.16666666666667
12009, 0.95833333333333, -0.2, 0.20833333333333
12010, 0.95833333333333, -0.2, 0.25
12011, 0.95833333333333, -0.2, 0.29166666666667
12012, 0.95833333333333, -0.2, 0.33333333333333
12013, 0.95833333333333, -0.2, 0.375
12014, 0.95833333333333, -0.2, 0.41666666666667
12015, 0.95833333333333, -0.2, 0.45833333333333
12016, -0.1, -0.04, 0.041666666666667
12017, -0.1, -0.08, 0.041666666666667
12018, -0.1, -0.12, 0.041666666666667
