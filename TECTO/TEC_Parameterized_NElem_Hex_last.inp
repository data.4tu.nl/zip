16808, 0.625, 1, 0.25
16809, 0.625, 1.05, 0.25
16810, 0.625, 1.1, 0.25
16811, 0.625, 1.15, 0.25
16812, 0.625, 1.2, 0.25
16813, 0.625, 1.25, 0.25
16814, 0.625, 1.3, 0.25
16815, 0.625, 0.2, 0.29166666666667
16816, 0.625, 0.25, 0.29166666666667
16817, 0.625, 0.3, 0.29166666666667
16818, 0.625, 0.35, 0.29166666666667
16819, 0.625, 0.4, 0.29166666666667
16820, 0.625, 0.45, 0.29166666666667
16821, 0.625, 0.5, 0.29166666666667
16822, 0.625, 0.55, 0.29166666666667
16823, 0.625, 0.6, 0.29166666666667
16824, 0.625, 0.65, 0.29166666666667
16825, 0.625, 0.7, 0.29166666666667
16826, 0.625, 0.75, 0.29166666666667
16827, 0.625, 0.8, 0.29166666666667
16828, 0.625, 0.85, 0.29166666666667
16829, 0.625, 0.9, 0.29166666666667
16830, 0.625, 0.95, 0.29166666666667
16831, 0.625, 1, 0.29166666666667
16832, 0.625, 1.05, 0.29166666666667
16833, 0.625, 1.1, 0.29166666666667
16834, 0.625, 1.15, 0.29166666666667
16835, 0.625, 1.2, 0.29166666666667
16836, 0.625, 1.25, 0.29166666666667
16837, 0.625, 1.3, 0.29166666666667
16838, 0.625, 0.2, 0.33333333333333
16839, 0.625, 0.25, 0.33333333333333
16840, 0.625, 0.3, 0.33333333333333
16841, 0.625, 0.35, 0.33333333333333
16842, 0.625, 0.4, 0.33333333333333
16843, 0.625, 0.45, 0.33333333333333
16844, 0.625, 0.5, 0.33333333333333
16845, 0.625, 0.55, 0.33333333333333
16846, 0.625, 0.6, 0.33333333333333
16847, 0.625, 0.65, 0.33333333333333
16848, 0.625, 0.7, 0.33333333333333
16849, 0.625, 0.75, 0.33333333333333
16850, 0.625, 0.8, 0.33333333333333
16851, 0.625, 0.85, 0.33333333333333
16852, 0.625, 0.9, 0.33333333333333
16853, 0.625, 0.95, 0.33333333333333
16854, 0.625, 1, 0.33333333333333
16855, 0.625, 1.05, 0.33333333333333
16856, 0.625, 1.1, 0.33333333333333
16857, 0.625, 1.15, 0.33333333333333
16858, 0.625, 1.2, 0.33333333333333
16859, 0.625, 1.25, 0.33333333333333
16860, 0.625, 1.3, 0.33333333333333
16861, 0.625, 0.2, 0.375
16862, 0.625, 0.25, 0.375
16863, 0.625, 0.3, 0.375
16864, 0.625, 0.35, 0.375
16865, 0.625, 0.4, 0.375
16866, 0.625, 0.45, 0.375
16867, 0.625, 0.5, 0.375
16868, 0.625, 0.55, 0.375
16869, 0.625, 0.6, 0.375
16870, 0.625, 0.65, 0.375
16871, 0.625, 0.7, 0.375
16872, 0.625, 0.75, 0.375
16873, 0.625, 0.8, 0.375
16874, 0.625, 0.85, 0.375
16875, 0.625, 0.9, 0.375
16876, 0.625, 0.95, 0.375
16877, 0.625, 1, 0.375
16878, 0.625, 1.05, 0.375
16879, 0.625, 1.1, 0.375
16880, 0.625, 1.15, 0.375
16881, 0.625, 1.2, 0.375
16882, 0.625, 1.25, 0.375
16883, 0.625, 1.3, 0.375
16884, 0.625, 0.2, 0.41666666666667
16885, 0.625, 0.25, 0.41666666666667
16886, 0.625, 0.3, 0.41666666666667
16887, 0.625, 0.35, 0.41666666666667
16888, 0.625, 0.4, 0.41666666666667
16889, 0.625, 0.45, 0.41666666666667
16890, 0.625, 0.5, 0.41666666666667
16891, 0.625, 0.55, 0.41666666666667
16892, 0.625, 0.6, 0.41666666666667
16893, 0.625, 0.65, 0.41666666666667
16894, 0.625, 0.7, 0.41666666666667
16895, 0.625, 0.75, 0.41666666666667
16896, 0.625, 0.8, 0.41666666666667
16897, 0.625, 0.85, 0.41666666666667
16898, 0.625, 0.9, 0.41666666666667
16899, 0.625, 0.95, 0.41666666666667
16900, 0.625, 1, 0.41666666666667
16901, 0.625, 1.05, 0.41666666666667
16902, 0.625, 1.1, 0.41666666666667
16903, 0.625, 1.15, 0.41666666666667
16904, 0.625, 1.2, 0.41666666666667
16905, 0.625, 1.25, 0.41666666666667
16906, 0.625, 1.3, 0.41666666666667
16907, 0.625, 0.2, 0.45833333333333
16908, 0.625, 0.25, 0.45833333333333
16909, 0.625, 0.3, 0.45833333333333
16910, 0.625, 0.35, 0.45833333333333
16911, 0.625, 0.4, 0.45833333333333
16912, 0.625, 0.45, 0.45833333333333
16913, 0.625, 0.5, 0.45833333333333
16914, 0.625, 0.55, 0.45833333333333
16915, 0.625, 0.6, 0.45833333333333
16916, 0.625, 0.65, 0.45833333333333
16917, 0.625, 0.7, 0.45833333333333
16918, 0.625, 0.75, 0.45833333333333
16919, 0.625, 0.8, 0.45833333333333
16920, 0.625, 0.85, 0.45833333333333
16921, 0.625, 0.9, 0.45833333333333
16922, 0.625, 0.95, 0.45833333333333
16923, 0.625, 1, 0.45833333333333
16924, 0.625, 1.05, 0.45833333333333
16925, 0.625, 1.1, 0.45833333333333
16926, 0.625, 1.15, 0.45833333333333
16927, 0.625, 1.2, 0.45833333333333
16928, 0.625, 1.25, 0.45833333333333
16929, 0.625, 1.3, 0.45833333333333
16930, 0.66666666666667, 0.2, 0.041666666666667
16931, 0.66666666666667, 0.25, 0.041666666666667
16932, 0.66666666666667, 0.3, 0.041666666666667
16933, 0.66666666666667, 0.35, 0.041666666666667
16934, 0.66666666666667, 0.4, 0.041666666666667
16935, 0.66666666666667, 0.45, 0.041666666666667
16936, 0.66666666666667, 0.5, 0.041666666666667
16937, 0.66666666666667, 0.55, 0.041666666666667
16938, 0.66666666666667, 0.6, 0.041666666666667
16939, 0.66666666666667, 0.65, 0.041666666666667
16940, 0.66666666666667, 0.7, 0.041666666666667
16941, 0.66666666666667, 0.75, 0.041666666666667
16942, 0.66666666666667, 0.8, 0.041666666666667
16943, 0.66666666666667, 0.85, 0.041666666666667
16944, 0.66666666666667, 0.9, 0.041666666666667
16945, 0.66666666666667, 0.95, 0.041666666666667
16946, 0.66666666666667, 1, 0.041666666666667
16947, 0.66666666666667, 1.05, 0.041666666666667
16948, 0.66666666666667, 1.1, 0.041666666666667
16949, 0.66666666666667, 1.15, 0.041666666666667
16950, 0.66666666666667, 1.2, 0.041666666666667
16951, 0.66666666666667, 1.25, 0.041666666666667
16952, 0.66666666666667, 1.3, 0.041666666666667
16953, 0.66666666666667, 0.2, 0.083333333333333
16954, 0.66666666666667, 0.25, 0.083333333333333
16955, 0.66666666666667, 0.3, 0.083333333333333
16956, 0.66666666666667, 0.35, 0.083333333333333
16957, 0.66666666666667, 0.4, 0.083333333333333
16958, 0.66666666666667, 0.45, 0.083333333333333
16959, 0.66666666666667, 0.5, 0.083333333333333
16960, 0.66666666666667, 0.55, 0.083333333333333
16961, 0.66666666666667, 0.6, 0.083333333333333
16962, 0.66666666666667, 0.65, 0.083333333333333
16963, 0.66666666666667, 0.7, 0.083333333333333
16964, 0.66666666666667, 0.75, 0.083333333333333
16965, 0.66666666666667, 0.8, 0.083333333333333
16966, 0.66666666666667, 0.85, 0.083333333333333
16967, 0.66666666666667, 0.9, 0.083333333333333
16968, 0.66666666666667, 0.95, 0.083333333333333
16969, 0.66666666666667, 1, 0.083333333333333
16970, 0.66666666666667, 1.05, 0.083333333333333
16971, 0.66666666666667, 1.1, 0.083333333333333
16972, 0.66666666666667, 1.15, 0.083333333333333
16973, 0.66666666666667, 1.2, 0.083333333333333
16974, 0.66666666666667, 1.25, 0.083333333333333
16975, 0.66666666666667, 1.3, 0.083333333333333
16976, 0.66666666666667, 0.2, 0.125
16977, 0.66666666666667, 0.25, 0.125
16978, 0.66666666666667, 0.3, 0.125
16979, 0.66666666666667, 0.35, 0.125
16980, 0.66666666666667, 0.4, 0.125
16981, 0.66666666666667, 0.45, 0.125
16982, 0.66666666666667, 0.5, 0.125
16983, 0.66666666666667, 0.55, 0.125
16984, 0.66666666666667, 0.6, 0.125
16985, 0.66666666666667, 0.65, 0.125
16986, 0.66666666666667, 0.7, 0.125
16987, 0.66666666666667, 0.75, 0.125
16988, 0.66666666666667, 0.8, 0.125
16989, 0.66666666666667, 0.85, 0.125
16990, 0.66666666666667, 0.9, 0.125
16991, 0.66666666666667, 0.95, 0.125
16992, 0.66666666666667, 1, 0.125
16993, 0.66666666666667, 1.05, 0.125
16994, 0.66666666666667, 1.1, 0.125
16995, 0.66666666666667, 1.15, 0.125
16996, 0.66666666666667, 1.2, 0.125
16997, 0.66666666666667, 1.25, 0.125
16998, 0.66666666666667, 1.3, 0.125
16999, 0.66666666666667, 0.2, 0.16666666666667
17000, 0.66666666666667, 0.25, 0.16666666666667
17001, 0.66666666666667, 0.3, 0.16666666666667
17002, 0.66666666666667, 0.35, 0.16666666666667
17003, 0.66666666666667, 0.4, 0.16666666666667
17004, 0.66666666666667, 0.45, 0.16666666666667
17005, 0.66666666666667, 0.5, 0.16666666666667
17006, 0.66666666666667, 0.55, 0.16666666666667
17007, 0.66666666666667, 0.6, 0.16666666666667
17008, 0.66666666666667, 0.65, 0.16666666666667
17009, 0.66666666666667, 0.7, 0.16666666666667
17010, 0.66666666666667, 0.75, 0.16666666666667
17011, 0.66666666666667, 0.8, 0.16666666666667
17012, 0.66666666666667, 0.85, 0.16666666666667
17013, 0.66666666666667, 0.9, 0.16666666666667
17014, 0.66666666666667, 0.95, 0.16666666666667
17015, 0.66666666666667, 1, 0.16666666666667
17016, 0.66666666666667, 1.05, 0.16666666666667
17017, 0.66666666666667, 1.1, 0.16666666666667
17018, 0.66666666666667, 1.15, 0.16666666666667
17019, 0.66666666666667, 1.2, 0.16666666666667
17020, 0.66666666666667, 1.25, 0.16666666666667
17021, 0.66666666666667, 1.3, 0.16666666666667
17022, 0.66666666666667, 0.2, 0.20833333333333
17023, 0.66666666666667, 0.25, 0.20833333333333
17024, 0.66666666666667, 0.3, 0.20833333333333
17025, 0.66666666666667, 0.35, 0.20833333333333
17026, 0.66666666666667, 0.4, 0.20833333333333
17027, 0.66666666666667, 0.45, 0.20833333333333
17028, 0.66666666666667, 0.5, 0.20833333333333
17029, 0.66666666666667, 0.55, 0.20833333333333
17030, 0.66666666666667, 0.6, 0.20833333333333
17031, 0.66666666666667, 0.65, 0.20833333333333
17032, 0.66666666666667, 0.7, 0.20833333333333
17033, 0.66666666666667, 0.75, 0.20833333333333
17034, 0.66666666666667, 0.8, 0.20833333333333
17035, 0.66666666666667, 0.85, 0.20833333333333
17036, 0.66666666666667, 0.9, 0.20833333333333
17037, 0.66666666666667, 0.95, 0.20833333333333
17038, 0.66666666666667, 1, 0.20833333333333
17039, 0.66666666666667, 1.05, 0.20833333333333
17040, 0.66666666666667, 1.1, 0.20833333333333
17041, 0.66666666666667, 1.15, 0.20833333333333
17042, 0.66666666666667, 1.2, 0.20833333333333
17043, 0.66666666666667, 1.25, 0.20833333333333
17044, 0.66666666666667, 1.3, 0.20833333333333
17045, 0.66666666666667, 0.2, 0.25
17046, 0.66666666666667, 0.25, 0.25
17047, 0.66666666666667, 0.3, 0.25
17048, 0.66666666666667, 0.35, 0.25
17049, 0.66666666666667, 0.4, 0.25
17050, 0.66666666666667, 0.45, 0.25
17051, 0.66666666666667, 0.5, 0.25
17052, 0.66666666666667, 0.55, 0.25
17053, 0.66666666666667, 0.6, 0.25
17054, 0.66666666666667, 0.65, 0.25
17055, 0.66666666666667, 0.7, 0.25
17056, 0.66666666666667, 0.75, 0.25
17057, 0.66666666666667, 0.8, 0.25
17058, 0.66666666666667, 0.85, 0.25
17059, 0.66666666666667, 0.9, 0.25
17060, 0.66666666666667, 0.95, 0.25
17061, 0.66666666666667, 1, 0.25
17062, 0.66666666666667, 1.05, 0.25
17063, 0.66666666666667, 1.1, 0.25
17064, 0.66666666666667, 1.15, 0.25
17065, 0.66666666666667, 1.2, 0.25
17066, 0.66666666666667, 1.25, 0.25
17067, 0.66666666666667, 1.3, 0.25
17068, 0.66666666666667, 0.2, 0.29166666666667
17069, 0.66666666666667, 0.25, 0.29166666666667
17070, 0.66666666666667, 0.3, 0.29166666666667
17071, 0.66666666666667, 0.35, 0.29166666666667
17072, 0.66666666666667, 0.4, 0.29166666666667
17073, 0.66666666666667, 0.45, 0.29166666666667
17074, 0.66666666666667, 0.5, 0.29166666666667
17075, 0.66666666666667, 0.55, 0.29166666666667
17076, 0.66666666666667, 0.6, 0.29166666666667
17077, 0.66666666666667, 0.65, 0.29166666666667
17078, 0.66666666666667, 0.7, 0.29166666666667
17079, 0.66666666666667, 0.75, 0.29166666666667
17080, 0.66666666666667, 0.8, 0.29166666666667
17081, 0.66666666666667, 0.85, 0.29166666666667
17082, 0.66666666666667, 0.9, 0.29166666666667
17083, 0.66666666666667, 0.95, 0.29166666666667
17084, 0.66666666666667, 1, 0.29166666666667
17085, 0.66666666666667, 1.05, 0.29166666666667
17086, 0.66666666666667, 1.1, 0.29166666666667
17087, 0.66666666666667, 1.15, 0.29166666666667
17088, 0.66666666666667, 1.2, 0.29166666666667
17089, 0.66666666666667, 1.25, 0.29166666666667
17090, 0.66666666666667, 1.3, 0.29166666666667
17091, 0.66666666666667, 0.2, 0.33333333333333
17092, 0.66666666666667, 0.25, 0.33333333333333
17093, 0.66666666666667, 0.3, 0.33333333333333
17094, 0.66666666666667, 0.35, 0.33333333333333
17095, 0.66666666666667, 0.4, 0.33333333333333
17096, 0.66666666666667, 0.45, 0.33333333333333
17097, 0.66666666666667, 0.5, 0.33333333333333
17098, 0.66666666666667, 0.55, 0.33333333333333
17099, 0.66666666666667, 0.6, 0.33333333333333
17100, 0.66666666666667, 0.65, 0.33333333333333
17101, 0.66666666666667, 0.7, 0.33333333333333
17102, 0.66666666666667, 0.75, 0.33333333333333
17103, 0.66666666666667, 0.8, 0.33333333333333
17104, 0.66666666666667, 0.85, 0.33333333333333
17105, 0.66666666666667, 0.9, 0.33333333333333
17106, 0.66666666666667, 0.95, 0.33333333333333
17107, 0.66666666666667, 1, 0.33333333333333
17108, 0.66666666666667, 1.05, 0.33333333333333
17109, 0.66666666666667, 1.1, 0.33333333333333
17110, 0.66666666666667, 1.15, 0.33333333333333
17111, 0.66666666666667, 1.2, 0.33333333333333
17112, 0.66666666666667, 1.25, 0.33333333333333
17113, 0.66666666666667, 1.3, 0.33333333333333
17114, 0.66666666666667, 0.2, 0.375
17115, 0.66666666666667, 0.25, 0.375
17116, 0.66666666666667, 0.3, 0.375
17117, 0.66666666666667, 0.35, 0.375
17118, 0.66666666666667, 0.4, 0.375
17119, 0.66666666666667, 0.45, 0.375
17120, 0.66666666666667, 0.5, 0.375
17121, 0.66666666666667, 0.55, 0.375
17122, 0.66666666666667, 0.6, 0.375
17123, 0.66666666666667, 0.65, 0.375
17124, 0.66666666666667, 0.7, 0.375
17125, 0.66666666666667, 0.75, 0.375
17126, 0.66666666666667, 0.8, 0.375
17127, 0.66666666666667, 0.85, 0.375
17128, 0.66666666666667, 0.9, 0.375
17129, 0.66666666666667, 0.95, 0.375
17130, 0.66666666666667, 1, 0.375
17131, 0.66666666666667, 1.05, 0.375
17132, 0.66666666666667, 1.1, 0.375
17133, 0.66666666666667, 1.15, 0.375
17134, 0.66666666666667, 1.2, 0.375
17135, 0.66666666666667, 1.25, 0.375
17136, 0.66666666666667, 1.3, 0.375
17137, 0.66666666666667, 0.2, 0.41666666666667
17138, 0.66666666666667, 0.25, 0.41666666666667
17139, 0.66666666666667, 0.3, 0.41666666666667
17140, 0.66666666666667, 0.35, 0.41666666666667
17141, 0.66666666666667, 0.4, 0.41666666666667
17142, 0.66666666666667, 0.45, 0.41666666666667
17143, 0.66666666666667, 0.5, 0.41666666666667
17144, 0.66666666666667, 0.55, 0.41666666666667
17145, 0.66666666666667, 0.6, 0.41666666666667
17146, 0.66666666666667, 0.65, 0.41666666666667
17147, 0.66666666666667, 0.7, 0.41666666666667
17148, 0.66666666666667, 0.75, 0.41666666666667
17149, 0.66666666666667, 0.8, 0.41666666666667
17150, 0.66666666666667, 0.85, 0.41666666666667
17151, 0.66666666666667, 0.9, 0.41666666666667
17152, 0.66666666666667, 0.95, 0.41666666666667
17153, 0.66666666666667, 1, 0.41666666666667
17154, 0.66666666666667, 1.05, 0.41666666666667
17155, 0.66666666666667, 1.1, 0.41666666666667
17156, 0.66666666666667, 1.15, 0.41666666666667
17157, 0.66666666666667, 1.2, 0.41666666666667
17158, 0.66666666666667, 1.25, 0.41666666666667
17159, 0.66666666666667, 1.3, 0.41666666666667
17160, 0.66666666666667, 0.2, 0.45833333333333
17161, 0.66666666666667, 0.25, 0.45833333333333
17162, 0.66666666666667, 0.3, 0.45833333333333
17163, 0.66666666666667, 0.35, 0.45833333333333
17164, 0.66666666666667, 0.4, 0.45833333333333
17165, 0.66666666666667, 0.45, 0.45833333333333
17166, 0.66666666666667, 0.5, 0.45833333333333
17167, 0.66666666666667, 0.55, 0.45833333333333
17168, 0.66666666666667, 0.6, 0.45833333333333
17169, 0.66666666666667, 0.65, 0.45833333333333
17170, 0.66666666666667, 0.7, 0.45833333333333
17171, 0.66666666666667, 0.75, 0.45833333333333
17172, 0.66666666666667, 0.8, 0.45833333333333
17173, 0.66666666666667, 0.85, 0.45833333333333
17174, 0.66666666666667, 0.9, 0.45833333333333
17175, 0.66666666666667, 0.95, 0.45833333333333
17176, 0.66666666666667, 1, 0.45833333333333
17177, 0.66666666666667, 1.05, 0.45833333333333
17178, 0.66666666666667, 1.1, 0.45833333333333
17179, 0.66666666666667, 1.15, 0.45833333333333
17180, 0.66666666666667, 1.2, 0.45833333333333
17181, 0.66666666666667, 1.25, 0.45833333333333
17182, 0.66666666666667, 1.3, 0.45833333333333
17183, 0.70833333333333, 0.2, 0.041666666666667
17184, 0.70833333333333, 0.25, 0.041666666666667
17185, 0.70833333333333, 0.3, 0.041666666666667
17186, 0.70833333333333, 0.35, 0.041666666666667
17187, 0.70833333333333, 0.4, 0.041666666666667
17188, 0.70833333333333, 0.45, 0.041666666666667
17189, 0.70833333333333, 0.5, 0.041666666666667
17190, 0.70833333333333, 0.55, 0.041666666666667
17191, 0.70833333333333, 0.6, 0.041666666666667
17192, 0.70833333333333, 0.65, 0.041666666666667
17193, 0.70833333333333, 0.7, 0.041666666666667
17194, 0.70833333333333, 0.75, 0.041666666666667
17195, 0.70833333333333, 0.8, 0.041666666666667
17196, 0.70833333333333, 0.85, 0.041666666666667
17197, 0.70833333333333, 0.9, 0.041666666666667
17198, 0.70833333333333, 0.95, 0.041666666666667
17199, 0.70833333333333, 1, 0.041666666666667
17200, 0.70833333333333, 1.05, 0.041666666666667
17201, 0.70833333333333, 1.1, 0.041666666666667
17202, 0.70833333333333, 1.15, 0.041666666666667
17203, 0.70833333333333, 1.2, 0.041666666666667
17204, 0.70833333333333, 1.25, 0.041666666666667
17205, 0.70833333333333, 1.3, 0.041666666666667
17206, 0.70833333333333, 0.2, 0.083333333333333
17207, 0.70833333333333, 0.25, 0.083333333333333
17208, 0.70833333333333, 0.3, 0.083333333333333
17209, 0.70833333333333, 0.35, 0.083333333333333
17210, 0.70833333333333, 0.4, 0.083333333333333
17211, 0.70833333333333, 0.45, 0.083333333333333
17212, 0.70833333333333, 0.5, 0.083333333333333
17213, 0.70833333333333, 0.55, 0.083333333333333
17214, 0.70833333333333, 0.6, 0.083333333333333
17215, 0.70833333333333, 0.65, 0.083333333333333
17216, 0.70833333333333, 0.7, 0.083333333333333
17217, 0.70833333333333, 0.75, 0.083333333333333
17218, 0.70833333333333, 0.8, 0.083333333333333
17219, 0.70833333333333, 0.85, 0.083333333333333
17220, 0.70833333333333, 0.9, 0.083333333333333
17221, 0.70833333333333, 0.95, 0.083333333333333
17222, 0.70833333333333, 1, 0.083333333333333
17223, 0.70833333333333, 1.05, 0.083333333333333
17224, 0.70833333333333, 1.1, 0.083333333333333
17225, 0.70833333333333, 1.15, 0.083333333333333
17226, 0.70833333333333, 1.2, 0.083333333333333
17227, 0.70833333333333, 1.25, 0.083333333333333
17228, 0.70833333333333, 1.3, 0.083333333333333
17229, 0.70833333333333, 0.2, 0.125
17230, 0.70833333333333, 0.25, 0.125
17231, 0.70833333333333, 0.3, 0.125
17232, 0.70833333333333, 0.35, 0.125
17233, 0.70833333333333, 0.4, 0.125
17234, 0.70833333333333, 0.45, 0.125
17235, 0.70833333333333, 0.5, 0.125
17236, 0.70833333333333, 0.55, 0.125
17237, 0.70833333333333, 0.6, 0.125
17238, 0.70833333333333, 0.65, 0.125
17239, 0.70833333333333, 0.7, 0.125
17240, 0.70833333333333, 0.75, 0.125
17241, 0.70833333333333, 0.8, 0.125
17242, 0.70833333333333, 0.85, 0.125
17243, 0.70833333333333, 0.9, 0.125
17244, 0.70833333333333, 0.95, 0.125
17245, 0.70833333333333, 1, 0.125
17246, 0.70833333333333, 1.05, 0.125
17247, 0.70833333333333, 1.1, 0.125
17248, 0.70833333333333, 1.15, 0.125
17249, 0.70833333333333, 1.2, 0.125
17250, 0.70833333333333, 1.25, 0.125
17251, 0.70833333333333, 1.3, 0.125
17252, 0.70833333333333, 0.2, 0.16666666666667
17253, 0.70833333333333, 0.25, 0.16666666666667
17254, 0.70833333333333, 0.3, 0.16666666666667
17255, 0.70833333333333, 0.35, 0.16666666666667
17256, 0.70833333333333, 0.4, 0.16666666666667
17257, 0.70833333333333, 0.45, 0.16666666666667
17258, 0.70833333333333, 0.5, 0.16666666666667
17259, 0.70833333333333, 0.55, 0.16666666666667
17260, 0.70833333333333, 0.6, 0.16666666666667
17261, 0.70833333333333, 0.65, 0.16666666666667
17262, 0.70833333333333, 0.7, 0.16666666666667
17263, 0.70833333333333, 0.75, 0.16666666666667
17264, 0.70833333333333, 0.8, 0.16666666666667
17265, 0.70833333333333, 0.85, 0.16666666666667
17266, 0.70833333333333, 0.9, 0.16666666666667
17267, 0.70833333333333, 0.95, 0.16666666666667
17268, 0.70833333333333, 1, 0.16666666666667
17269, 0.70833333333333, 1.05, 0.16666666666667
17270, 0.70833333333333, 1.1, 0.16666666666667
17271, 0.70833333333333, 1.15, 0.16666666666667
17272, 0.70833333333333, 1.2, 0.16666666666667
17273, 0.70833333333333, 1.25, 0.16666666666667
17274, 0.70833333333333, 1.3, 0.16666666666667
17275, 0.70833333333333, 0.2, 0.20833333333333
17276, 0.70833333333333, 0.25, 0.20833333333333
17277, 0.70833333333333, 0.3, 0.20833333333333
17278, 0.70833333333333, 0.35, 0.20833333333333
17279, 0.70833333333333, 0.4, 0.20833333333333
17280, 0.70833333333333, 0.45, 0.20833333333333
17281, 0.70833333333333, 0.5, 0.20833333333333
17282, 0.70833333333333, 0.55, 0.20833333333333
17283, 0.70833333333333, 0.6, 0.20833333333333
17284, 0.70833333333333, 0.65, 0.20833333333333
17285, 0.70833333333333, 0.7, 0.20833333333333
17286, 0.70833333333333, 0.75, 0.20833333333333
17287, 0.70833333333333, 0.8, 0.20833333333333
17288, 0.70833333333333, 0.85, 0.20833333333333
17289, 0.70833333333333, 0.9, 0.20833333333333
17290, 0.70833333333333, 0.95, 0.20833333333333
17291, 0.70833333333333, 1, 0.20833333333333
17292, 0.70833333333333, 1.05, 0.20833333333333
17293, 0.70833333333333, 1.1, 0.20833333333333
17294, 0.70833333333333, 1.15, 0.20833333333333
17295, 0.70833333333333, 1.2, 0.20833333333333
17296, 0.70833333333333, 1.25, 0.20833333333333
17297, 0.70833333333333, 1.3, 0.20833333333333
17298, 0.70833333333333, 0.2, 0.25
17299, 0.70833333333333, 0.25, 0.25
17300, 0.70833333333333, 0.3, 0.25
17301, 0.70833333333333, 0.35, 0.25
17302, 0.70833333333333, 0.4, 0.25
17303, 0.70833333333333, 0.45, 0.25
17304, 0.70833333333333, 0.5, 0.25
17305, 0.70833333333333, 0.55, 0.25
17306, 0.70833333333333, 0.6, 0.25
17307, 0.70833333333333, 0.65, 0.25
17308, 0.70833333333333, 0.7, 0.25
17309, 0.70833333333333, 0.75, 0.25
17310, 0.70833333333333, 0.8, 0.25
17311, 0.70833333333333, 0.85, 0.25
17312, 0.70833333333333, 0.9, 0.25
17313, 0.70833333333333, 0.95, 0.25
17314, 0.70833333333333, 1, 0.25
17315, 0.70833333333333, 1.05, 0.25
17316, 0.70833333333333, 1.1, 0.25
17317, 0.70833333333333, 1.15, 0.25
17318, 0.70833333333333, 1.2, 0.25
17319, 0.70833333333333, 1.25, 0.25
17320, 0.70833333333333, 1.3, 0.25
17321, 0.70833333333333, 0.2, 0.29166666666667
17322, 0.70833333333333, 0.25, 0.29166666666667
17323, 0.70833333333333, 0.3, 0.29166666666667
17324, 0.70833333333333, 0.35, 0.29166666666667
17325, 0.70833333333333, 0.4, 0.29166666666667
17326, 0.70833333333333, 0.45, 0.29166666666667
17327, 0.70833333333333, 0.5, 0.29166666666667
17328, 0.70833333333333, 0.55, 0.29166666666667
17329, 0.70833333333333, 0.6, 0.29166666666667
17330, 0.70833333333333, 0.65, 0.29166666666667
17331, 0.70833333333333, 0.7, 0.29166666666667
17332, 0.70833333333333, 0.75, 0.29166666666667
17333, 0.70833333333333, 0.8, 0.29166666666667
17334, 0.70833333333333, 0.85, 0.29166666666667
17335, 0.70833333333333, 0.9, 0.29166666666667
17336, 0.70833333333333, 0.95, 0.29166666666667
17337, 0.70833333333333, 1, 0.29166666666667
17338, 0.70833333333333, 1.05, 0.29166666666667
17339, 0.70833333333333, 1.1, 0.29166666666667
17340, 0.70833333333333, 1.15, 0.29166666666667
17341, 0.70833333333333, 1.2, 0.29166666666667
17342, 0.70833333333333, 1.25, 0.29166666666667
17343, 0.70833333333333, 1.3, 0.29166666666667
17344, 0.70833333333333, 0.2, 0.33333333333333
17345, 0.70833333333333, 0.25, 0.33333333333333
17346, 0.70833333333333, 0.3, 0.33333333333333
17347, 0.70833333333333, 0.35, 0.33333333333333
17348, 0.70833333333333, 0.4, 0.33333333333333
17349, 0.70833333333333, 0.45, 0.33333333333333
17350, 0.70833333333333, 0.5, 0.33333333333333
17351, 0.70833333333333, 0.55, 0.33333333333333
17352, 0.70833333333333, 0.6, 0.33333333333333
17353, 0.70833333333333, 0.65, 0.33333333333333
17354, 0.70833333333333, 0.7, 0.33333333333333
17355, 0.70833333333333, 0.75, 0.33333333333333
17356, 0.70833333333333, 0.8, 0.33333333333333
17357, 0.70833333333333, 0.85, 0.33333333333333
17358, 0.70833333333333, 0.9, 0.33333333333333
17359, 0.70833333333333, 0.95, 0.33333333333333
17360, 0.70833333333333, 1, 0.33333333333333
17361, 0.70833333333333, 1.05, 0.33333333333333
17362, 0.70833333333333, 1.1, 0.33333333333333
17363, 0.70833333333333, 1.15, 0.33333333333333
17364, 0.70833333333333, 1.2, 0.33333333333333
17365, 0.70833333333333, 1.25, 0.33333333333333
17366, 0.70833333333333, 1.3, 0.33333333333333
17367, 0.70833333333333, 0.2, 0.375
17368, 0.70833333333333, 0.25, 0.375
17369, 0.70833333333333, 0.3, 0.375
17370, 0.70833333333333, 0.35, 0.375
17371, 0.70833333333333, 0.4, 0.375
17372, 0.70833333333333, 0.45, 0.375
17373, 0.70833333333333, 0.5, 0.375
17374, 0.70833333333333, 0.55, 0.375
17375, 0.70833333333333, 0.6, 0.375
17376, 0.70833333333333, 0.65, 0.375
17377, 0.70833333333333, 0.7, 0.375
17378, 0.70833333333333, 0.75, 0.375
17379, 0.70833333333333, 0.8, 0.375
17380, 0.70833333333333, 0.85, 0.375
17381, 0.70833333333333, 0.9, 0.375
17382, 0.70833333333333, 0.95, 0.375
17383, 0.70833333333333, 1, 0.375
17384, 0.70833333333333, 1.05, 0.375
17385, 0.70833333333333, 1.1, 0.375
17386, 0.70833333333333, 1.15, 0.375
17387, 0.70833333333333, 1.2, 0.375
17388, 0.70833333333333, 1.25, 0.375
17389, 0.70833333333333, 1.3, 0.375
17390, 0.70833333333333, 0.2, 0.41666666666667
17391, 0.70833333333333, 0.25, 0.41666666666667
17392, 0.70833333333333, 0.3, 0.41666666666667
17393, 0.70833333333333, 0.35, 0.41666666666667
17394, 0.70833333333333, 0.4, 0.41666666666667
17395, 0.70833333333333, 0.45, 0.41666666666667
17396, 0.70833333333333, 0.5, 0.41666666666667
17397, 0.70833333333333, 0.55, 0.41666666666667
17398, 0.70833333333333, 0.6, 0.41666666666667
17399, 0.70833333333333, 0.65, 0.41666666666667
17400, 0.70833333333333, 0.7, 0.41666666666667
17401, 0.70833333333333, 0.75, 0.41666666666667
17402, 0.70833333333333, 0.8, 0.41666666666667
17403, 0.70833333333333, 0.85, 0.41666666666667
17404, 0.70833333333333, 0.9, 0.41666666666667
17405, 0.70833333333333, 0.95, 0.41666666666667
17406, 0.70833333333333, 1, 0.41666666666667
17407, 0.70833333333333, 1.05, 0.41666666666667
17408, 0.70833333333333, 1.1, 0.41666666666667
17409, 0.70833333333333, 1.15, 0.41666666666667
17410, 0.70833333333333, 1.2, 0.41666666666667
17411, 0.70833333333333, 1.25, 0.41666666666667
17412, 0.70833333333333, 1.3, 0.41666666666667
17413, 0.70833333333333, 0.2, 0.45833333333333
17414, 0.70833333333333, 0.25, 0.45833333333333
17415, 0.70833333333333, 0.3, 0.45833333333333
17416, 0.70833333333333, 0.35, 0.45833333333333
17417, 0.70833333333333, 0.4, 0.45833333333333
17418, 0.70833333333333, 0.45, 0.45833333333333
17419, 0.70833333333333, 0.5, 0.45833333333333
17420, 0.70833333333333, 0.55, 0.45833333333333
17421, 0.70833333333333, 0.6, 0.45833333333333
17422, 0.70833333333333, 0.65, 0.45833333333333
17423, 0.70833333333333, 0.7, 0.45833333333333
17424, 0.70833333333333, 0.75, 0.45833333333333
17425, 0.70833333333333, 0.8, 0.45833333333333
17426, 0.70833333333333, 0.85, 0.45833333333333
17427, 0.70833333333333, 0.9, 0.45833333333333
17428, 0.70833333333333, 0.95, 0.45833333333333
17429, 0.70833333333333, 1, 0.45833333333333
17430, 0.70833333333333, 1.05, 0.45833333333333
17431, 0.70833333333333, 1.1, 0.45833333333333
17432, 0.70833333333333, 1.15, 0.45833333333333
17433, 0.70833333333333, 1.2, 0.45833333333333
17434, 0.70833333333333, 1.25, 0.45833333333333
17435, 0.70833333333333, 1.3, 0.45833333333333
17436, 0.75, 0.2, 0.041666666666667
17437, 0.75, 0.25, 0.041666666666667
17438, 0.75, 0.3, 0.041666666666667
17439, 0.75, 0.35, 0.041666666666667
17440, 0.75, 0.4, 0.041666666666667
17441, 0.75, 0.45, 0.041666666666667
17442, 0.75, 0.5, 0.041666666666667
17443, 0.75, 0.55, 0.041666666666667
17444, 0.75, 0.6, 0.041666666666667
17445, 0.75, 0.65, 0.041666666666667
17446, 0.75, 0.7, 0.041666666666667
17447, 0.75, 0.75, 0.041666666666667
17448, 0.75, 0.8, 0.041666666666667
17449, 0.75, 0.85, 0.041666666666667
17450, 0.75, 0.9, 0.041666666666667
17451, 0.75, 0.95, 0.041666666666667
17452, 0.75, 1, 0.041666666666667
17453, 0.75, 1.05, 0.041666666666667
17454, 0.75, 1.1, 0.041666666666667
17455, 0.75, 1.15, 0.041666666666667
17456, 0.75, 1.2, 0.041666666666667
17457, 0.75, 1.25, 0.041666666666667
17458, 0.75, 1.3, 0.041666666666667
17459, 0.75, 0.2, 0.083333333333333
17460, 0.75, 0.25, 0.083333333333333
17461, 0.75, 0.3, 0.083333333333333
17462, 0.75, 0.35, 0.083333333333333
17463, 0.75, 0.4, 0.083333333333333
17464, 0.75, 0.45, 0.083333333333333
17465, 0.75, 0.5, 0.083333333333333
17466, 0.75, 0.55, 0.083333333333333
17467, 0.75, 0.6, 0.083333333333333
17468, 0.75, 0.65, 0.083333333333333
17469, 0.75, 0.7, 0.083333333333333
17470, 0.75, 0.75, 0.083333333333333
17471, 0.75, 0.8, 0.083333333333333
17472, 0.75, 0.85, 0.083333333333333
17473, 0.75, 0.9, 0.083333333333333
17474, 0.75, 0.95, 0.083333333333333
17475, 0.75, 1, 0.083333333333333
17476, 0.75, 1.05, 0.083333333333333
17477, 0.75, 1.1, 0.083333333333333
17478, 0.75, 1.15, 0.083333333333333
17479, 0.75, 1.2, 0.083333333333333
17480, 0.75, 1.25, 0.083333333333333
17481, 0.75, 1.3, 0.083333333333333
17482, 0.75, 0.2, 0.125
17483, 0.75, 0.25, 0.125
17484, 0.75, 0.3, 0.125
17485, 0.75, 0.35, 0.125
17486, 0.75, 0.4, 0.125
17487, 0.75, 0.45, 0.125
17488, 0.75, 0.5, 0.125
17489, 0.75, 0.55, 0.125
17490, 0.75, 0.6, 0.125
17491, 0.75, 0.65, 0.125
17492, 0.75, 0.7, 0.125
17493, 0.75, 0.75, 0.125
17494, 0.75, 0.8, 0.125
17495, 0.75, 0.85, 0.125
17496, 0.75, 0.9, 0.125
17497, 0.75, 0.95, 0.125
17498, 0.75, 1, 0.125
17499, 0.75, 1.05, 0.125
17500, 0.75, 1.1, 0.125
17501, 0.75, 1.15, 0.125
17502, 0.75, 1.2, 0.125
17503, 0.75, 1.25, 0.125
17504, 0.75, 1.3, 0.125
17505, 0.75, 0.2, 0.16666666666667
17506, 0.75, 0.25, 0.16666666666667
17507, 0.75, 0.3, 0.16666666666667
17508, 0.75, 0.35, 0.16666666666667
17509, 0.75, 0.4, 0.16666666666667
17510, 0.75, 0.45, 0.16666666666667
17511, 0.75, 0.5, 0.16666666666667
17512, 0.75, 0.55, 0.16666666666667
17513, 0.75, 0.6, 0.16666666666667
17514, 0.75, 0.65, 0.16666666666667
17515, 0.75, 0.7, 0.16666666666667
17516, 0.75, 0.75, 0.16666666666667
17517, 0.75, 0.8, 0.16666666666667
17518, 0.75, 0.85, 0.16666666666667
17519, 0.75, 0.9, 0.16666666666667
17520, 0.75, 0.95, 0.16666666666667
17521, 0.75, 1, 0.16666666666667
17522, 0.75, 1.05, 0.16666666666667
17523, 0.75, 1.1, 0.16666666666667
17524, 0.75, 1.15, 0.16666666666667
17525, 0.75, 1.2, 0.16666666666667
17526, 0.75, 1.25, 0.16666666666667
17527, 0.75, 1.3, 0.16666666666667
17528, 0.75, 0.2, 0.20833333333333
17529, 0.75, 0.25, 0.20833333333333
17530, 0.75, 0.3, 0.20833333333333
17531, 0.75, 0.35, 0.20833333333333
17532, 0.75, 0.4, 0.20833333333333
17533, 0.75, 0.45, 0.20833333333333
17534, 0.75, 0.5, 0.20833333333333
17535, 0.75, 0.55, 0.20833333333333
17536, 0.75, 0.6, 0.20833333333333
17537, 0.75, 0.65, 0.20833333333333
17538, 0.75, 0.7, 0.20833333333333
17539, 0.75, 0.75, 0.20833333333333
17540, 0.75, 0.8, 0.20833333333333
17541, 0.75, 0.85, 0.20833333333333
17542, 0.75, 0.9, 0.20833333333333
17543, 0.75, 0.95, 0.20833333333333
17544, 0.75, 1, 0.20833333333333
17545, 0.75, 1.05, 0.20833333333333
17546, 0.75, 1.1, 0.20833333333333
17547, 0.75, 1.15, 0.20833333333333
17548, 0.75, 1.2, 0.20833333333333
17549, 0.75, 1.25, 0.20833333333333
17550, 0.75, 1.3, 0.20833333333333
17551, 0.75, 0.2, 0.25
17552, 0.75, 0.25, 0.25
17553, 0.75, 0.3, 0.25
17554, 0.75, 0.35, 0.25
17555, 0.75, 0.4, 0.25
17556, 0.75, 0.45, 0.25
17557, 0.75, 0.5, 0.25
17558, 0.75, 0.55, 0.25
17559, 0.75, 0.6, 0.25
17560, 0.75, 0.65, 0.25
17561, 0.75, 0.7, 0.25
17562, 0.75, 0.75, 0.25
17563, 0.75, 0.8, 0.25
17564, 0.75, 0.85, 0.25
17565, 0.75, 0.9, 0.25
17566, 0.75, 0.95, 0.25
17567, 0.75, 1, 0.25
17568, 0.75, 1.05, 0.25
17569, 0.75, 1.1, 0.25
17570, 0.75, 1.15, 0.25
17571, 0.75, 1.2, 0.25
17572, 0.75, 1.25, 0.25
17573, 0.75, 1.3, 0.25
17574, 0.75, 0.2, 0.29166666666667
17575, 0.75, 0.25, 0.29166666666667
17576, 0.75, 0.3, 0.29166666666667
17577, 0.75, 0.35, 0.29166666666667
17578, 0.75, 0.4, 0.29166666666667
17579, 0.75, 0.45, 0.29166666666667
17580, 0.75, 0.5, 0.29166666666667
17581, 0.75, 0.55, 0.29166666666667
17582, 0.75, 0.6, 0.29166666666667
17583, 0.75, 0.65, 0.29166666666667
17584, 0.75, 0.7, 0.29166666666667
17585, 0.75, 0.75, 0.29166666666667
17586, 0.75, 0.8, 0.29166666666667
17587, 0.75, 0.85, 0.29166666666667
17588, 0.75, 0.9, 0.29166666666667
17589, 0.75, 0.95, 0.29166666666667
17590, 0.75, 1, 0.29166666666667
17591, 0.75, 1.05, 0.29166666666667
17592, 0.75, 1.1, 0.29166666666667
17593, 0.75, 1.15, 0.29166666666667
17594, 0.75, 1.2, 0.29166666666667
17595, 0.75, 1.25, 0.29166666666667
17596, 0.75, 1.3, 0.29166666666667
17597, 0.75, 0.2, 0.33333333333333
17598, 0.75, 0.25, 0.33333333333333
17599, 0.75, 0.3, 0.33333333333333
17600, 0.75, 0.35, 0.33333333333333
17601, 0.75, 0.4, 0.33333333333333
17602, 0.75, 0.45, 0.33333333333333
17603, 0.75, 0.5, 0.33333333333333
17604, 0.75, 0.55, 0.33333333333333
17605, 0.75, 0.6, 0.33333333333333
17606, 0.75, 0.65, 0.33333333333333
17607, 0.75, 0.7, 0.33333333333333
17608, 0.75, 0.75, 0.33333333333333
17609, 0.75, 0.8, 0.33333333333333
17610, 0.75, 0.85, 0.33333333333333
17611, 0.75, 0.9, 0.33333333333333
17612, 0.75, 0.95, 0.33333333333333
17613, 0.75, 1, 0.33333333333333
17614, 0.75, 1.05, 0.33333333333333
17615, 0.75, 1.1, 0.33333333333333
17616, 0.75, 1.15, 0.33333333333333
17617, 0.75, 1.2, 0.33333333333333
17618, 0.75, 1.25, 0.33333333333333
17619, 0.75, 1.3, 0.33333333333333
17620, 0.75, 0.2, 0.375
17621, 0.75, 0.25, 0.375
17622, 0.75, 0.3, 0.375
17623, 0.75, 0.35, 0.375
17624, 0.75, 0.4, 0.375
17625, 0.75, 0.45, 0.375
17626, 0.75, 0.5, 0.375
17627, 0.75, 0.55, 0.375
17628, 0.75, 0.6, 0.375
17629, 0.75, 0.65, 0.375
17630, 0.75, 0.7, 0.375
17631, 0.75, 0.75, 0.375
17632, 0.75, 0.8, 0.375
17633, 0.75, 0.85, 0.375
17634, 0.75, 0.9, 0.375
17635, 0.75, 0.95, 0.375
17636, 0.75, 1, 0.375
17637, 0.75, 1.05, 0.375
17638, 0.75, 1.1, 0.375
17639, 0.75, 1.15, 0.375
17640, 0.75, 1.2, 0.375
17641, 0.75, 1.25, 0.375
17642, 0.75, 1.3, 0.375
17643, 0.75, 0.2, 0.41666666666667
17644, 0.75, 0.25, 0.41666666666667
17645, 0.75, 0.3, 0.41666666666667
17646, 0.75, 0.35, 0.41666666666667
17647, 0.75, 0.4, 0.41666666666667
17648, 0.75, 0.45, 0.41666666666667
17649, 0.75, 0.5, 0.41666666666667
17650, 0.75, 0.55, 0.41666666666667
17651, 0.75, 0.6, 0.41666666666667
17652, 0.75, 0.65, 0.41666666666667
17653, 0.75, 0.7, 0.41666666666667
17654, 0.75, 0.75, 0.41666666666667
17655, 0.75, 0.8, 0.41666666666667
17656, 0.75, 0.85, 0.41666666666667
17657, 0.75, 0.9, 0.41666666666667
17658, 0.75, 0.95, 0.41666666666667
17659, 0.75, 1, 0.41666666666667
17660, 0.75, 1.05, 0.41666666666667
17661, 0.75, 1.1, 0.41666666666667
17662, 0.75, 1.15, 0.41666666666667
17663, 0.75, 1.2, 0.41666666666667
17664, 0.75, 1.25, 0.41666666666667
17665, 0.75, 1.3, 0.41666666666667
17666, 0.75, 0.2, 0.45833333333333
17667, 0.75, 0.25, 0.45833333333333
17668, 0.75, 0.3, 0.45833333333333
17669, 0.75, 0.35, 0.45833333333333
17670, 0.75, 0.4, 0.45833333333333
17671, 0.75, 0.45, 0.45833333333333
17672, 0.75, 0.5, 0.45833333333333
17673, 0.75, 0.55, 0.45833333333333
17674, 0.75, 0.6, 0.45833333333333
17675, 0.75, 0.65, 0.45833333333333
17676, 0.75, 0.7, 0.45833333333333
17677, 0.75, 0.75, 0.45833333333333
17678, 0.75, 0.8, 0.45833333333333
17679, 0.75, 0.85, 0.45833333333333
17680, 0.75, 0.9, 0.45833333333333
17681, 0.75, 0.95, 0.45833333333333
17682, 0.75, 1, 0.45833333333333
17683, 0.75, 1.05, 0.45833333333333
17684, 0.75, 1.1, 0.45833333333333
17685, 0.75, 1.15, 0.45833333333333
17686, 0.75, 1.2, 0.45833333333333
17687, 0.75, 1.25, 0.45833333333333
17688, 0.75, 1.3, 0.45833333333333
17689, 0.79166666666667, 0.2, 0.041666666666667
17690, 0.79166666666667, 0.25, 0.041666666666667
17691, 0.79166666666667, 0.3, 0.041666666666667
17692, 0.79166666666667, 0.35, 0.041666666666667
17693, 0.79166666666667, 0.4, 0.041666666666667
17694, 0.79166666666667, 0.45, 0.041666666666667
17695, 0.79166666666667, 0.5, 0.041666666666667
17696, 0.79166666666667, 0.55, 0.041666666666667
17697, 0.79166666666667, 0.6, 0.041666666666667
17698, 0.79166666666667, 0.65, 0.041666666666667
17699, 0.79166666666667, 0.7, 0.041666666666667
17700, 0.79166666666667, 0.75, 0.041666666666667
17701, 0.79166666666667, 0.8, 0.041666666666667
17702, 0.79166666666667, 0.85, 0.041666666666667
17703, 0.79166666666667, 0.9, 0.041666666666667
17704, 0.79166666666667, 0.95, 0.041666666666667
17705, 0.79166666666667, 1, 0.041666666666667
17706, 0.79166666666667, 1.05, 0.041666666666667
17707, 0.79166666666667, 1.1, 0.041666666666667
17708, 0.79166666666667, 1.15, 0.041666666666667
17709, 0.79166666666667, 1.2, 0.041666666666667
17710, 0.79166666666667, 1.25, 0.041666666666667
17711, 0.79166666666667, 1.3, 0.041666666666667
17712, 0.79166666666667, 0.2, 0.083333333333333
17713, 0.79166666666667, 0.25, 0.083333333333333
17714, 0.79166666666667, 0.3, 0.083333333333333
17715, 0.79166666666667, 0.35, 0.083333333333333
17716, 0.79166666666667, 0.4, 0.083333333333333
17717, 0.79166666666667, 0.45, 0.083333333333333
17718, 0.79166666666667, 0.5, 0.083333333333333
17719, 0.79166666666667, 0.55, 0.083333333333333
17720, 0.79166666666667, 0.6, 0.083333333333333
17721, 0.79166666666667, 0.65, 0.083333333333333
17722, 0.79166666666667, 0.7, 0.083333333333333
17723, 0.79166666666667, 0.75, 0.083333333333333
17724, 0.79166666666667, 0.8, 0.083333333333333
17725, 0.79166666666667, 0.85, 0.083333333333333
17726, 0.79166666666667, 0.9, 0.083333333333333
17727, 0.79166666666667, 0.95, 0.083333333333333
17728, 0.79166666666667, 1, 0.083333333333333
17729, 0.79166666666667, 1.05, 0.083333333333333
17730, 0.79166666666667, 1.1, 0.083333333333333
17731, 0.79166666666667, 1.15, 0.083333333333333
17732, 0.79166666666667, 1.2, 0.083333333333333
17733, 0.79166666666667, 1.25, 0.083333333333333
17734, 0.79166666666667, 1.3, 0.083333333333333
17735, 0.79166666666667, 0.2, 0.125
17736, 0.79166666666667, 0.25, 0.125
17737, 0.79166666666667, 0.3, 0.125
17738, 0.79166666666667, 0.35, 0.125
17739, 0.79166666666667, 0.4, 0.125
17740, 0.79166666666667, 0.45, 0.125
17741, 0.79166666666667, 0.5, 0.125
17742, 0.79166666666667, 0.55, 0.125
17743, 0.79166666666667, 0.6, 0.125
17744, 0.79166666666667, 0.65, 0.125
17745, 0.79166666666667, 0.7, 0.125
17746, 0.79166666666667, 0.75, 0.125
17747, 0.79166666666667, 0.8, 0.125
17748, 0.79166666666667, 0.85, 0.125
17749, 0.79166666666667, 0.9, 0.125
17750, 0.79166666666667, 0.95, 0.125
17751, 0.79166666666667, 1, 0.125
17752, 0.79166666666667, 1.05, 0.125
17753, 0.79166666666667, 1.1, 0.125
17754, 0.79166666666667, 1.15, 0.125
17755, 0.79166666666667, 1.2, 0.125
17756, 0.79166666666667, 1.25, 0.125
17757, 0.79166666666667, 1.3, 0.125
17758, 0.79166666666667, 0.2, 0.16666666666667
17759, 0.79166666666667, 0.25, 0.16666666666667
17760, 0.79166666666667, 0.3, 0.16666666666667
17761, 0.79166666666667, 0.35, 0.16666666666667
17762, 0.79166666666667, 0.4, 0.16666666666667
17763, 0.79166666666667, 0.45, 0.16666666666667
17764, 0.79166666666667, 0.5, 0.16666666666667
17765, 0.79166666666667, 0.55, 0.16666666666667
17766, 0.79166666666667, 0.6, 0.16666666666667
17767, 0.79166666666667, 0.65, 0.16666666666667
17768, 0.79166666666667, 0.7, 0.16666666666667
17769, 0.79166666666667, 0.75, 0.16666666666667
17770, 0.79166666666667, 0.8, 0.16666666666667
17771, 0.79166666666667, 0.85, 0.16666666666667
17772, 0.79166666666667, 0.9, 0.16666666666667
17773, 0.79166666666667, 0.95, 0.16666666666667
17774, 0.79166666666667, 1, 0.16666666666667
17775, 0.79166666666667, 1.05, 0.16666666666667
17776, 0.79166666666667, 1.1, 0.16666666666667
17777, 0.79166666666667, 1.15, 0.16666666666667
17778, 0.79166666666667, 1.2, 0.16666666666667
17779, 0.79166666666667, 1.25, 0.16666666666667
17780, 0.79166666666667, 1.3, 0.16666666666667
17781, 0.79166666666667, 0.2, 0.20833333333333
17782, 0.79166666666667, 0.25, 0.20833333333333
17783, 0.79166666666667, 0.3, 0.20833333333333
17784, 0.79166666666667, 0.35, 0.20833333333333
17785, 0.79166666666667, 0.4, 0.20833333333333
17786, 0.79166666666667, 0.45, 0.20833333333333
17787, 0.79166666666667, 0.5, 0.20833333333333
17788, 0.79166666666667, 0.55, 0.20833333333333
17789, 0.79166666666667, 0.6, 0.20833333333333
17790, 0.79166666666667, 0.65, 0.20833333333333
17791, 0.79166666666667, 0.7, 0.20833333333333
17792, 0.79166666666667, 0.75, 0.20833333333333
17793, 0.79166666666667, 0.8, 0.20833333333333
17794, 0.79166666666667, 0.85, 0.20833333333333
17795, 0.79166666666667, 0.9, 0.20833333333333
17796, 0.79166666666667, 0.95, 0.20833333333333
17797, 0.79166666666667, 1, 0.20833333333333
17798, 0.79166666666667, 1.05, 0.20833333333333
17799, 0.79166666666667, 1.1, 0.20833333333333
17800, 0.79166666666667, 1.15, 0.20833333333333
17801, 0.79166666666667, 1.2, 0.20833333333333
17802, 0.79166666666667, 1.25, 0.20833333333333
17803, 0.79166666666667, 1.3, 0.20833333333333
17804, 0.79166666666667, 0.2, 0.25
17805, 0.79166666666667, 0.25, 0.25
17806, 0.79166666666667, 0.3, 0.25
17807, 0.79166666666667, 0.35, 0.25
17808, 0.79166666666667, 0.4, 0.25
17809, 0.79166666666667, 0.45, 0.25
17810, 0.79166666666667, 0.5, 0.25
17811, 0.79166666666667, 0.55, 0.25
17812, 0.79166666666667, 0.6, 0.25
17813, 0.79166666666667, 0.65, 0.25
17814, 0.79166666666667, 0.7, 0.25
17815, 0.79166666666667, 0.75, 0.25
17816, 0.79166666666667, 0.8, 0.25
17817, 0.79166666666667, 0.85, 0.25
17818, 0.79166666666667, 0.9, 0.25
17819, 0.79166666666667, 0.95, 0.25
17820, 0.79166666666667, 1, 0.25
17821, 0.79166666666667, 1.05, 0.25
17822, 0.79166666666667, 1.1, 0.25
17823, 0.79166666666667, 1.15, 0.25
17824, 0.79166666666667, 1.2, 0.25
17825, 0.79166666666667, 1.25, 0.25
17826, 0.79166666666667, 1.3, 0.25
17827, 0.79166666666667, 0.2, 0.29166666666667
17828, 0.79166666666667, 0.25, 0.29166666666667
17829, 0.79166666666667, 0.3, 0.29166666666667
17830, 0.79166666666667, 0.35, 0.29166666666667
17831, 0.79166666666667, 0.4, 0.29166666666667
17832, 0.79166666666667, 0.45, 0.29166666666667
17833, 0.79166666666667, 0.5, 0.29166666666667
17834, 0.79166666666667, 0.55, 0.29166666666667
17835, 0.79166666666667, 0.6, 0.29166666666667
17836, 0.79166666666667, 0.65, 0.29166666666667
17837, 0.79166666666667, 0.7, 0.29166666666667
17838, 0.79166666666667, 0.75, 0.29166666666667
17839, 0.79166666666667, 0.8, 0.29166666666667
17840, 0.79166666666667, 0.85, 0.29166666666667
17841, 0.79166666666667, 0.9, 0.29166666666667
17842, 0.79166666666667, 0.95, 0.29166666666667
17843, 0.79166666666667, 1, 0.29166666666667
17844, 0.79166666666667, 1.05, 0.29166666666667
17845, 0.79166666666667, 1.1, 0.29166666666667
17846, 0.79166666666667, 1.15, 0.29166666666667
17847, 0.79166666666667, 1.2, 0.29166666666667
17848, 0.79166666666667, 1.25, 0.29166666666667
17849, 0.79166666666667, 1.3, 0.29166666666667
17850, 0.79166666666667, 0.2, 0.33333333333333
17851, 0.79166666666667, 0.25, 0.33333333333333
17852, 0.79166666666667, 0.3, 0.33333333333333
17853, 0.79166666666667, 0.35, 0.33333333333333
17854, 0.79166666666667, 0.4, 0.33333333333333
17855, 0.79166666666667, 0.45, 0.33333333333333
17856, 0.79166666666667, 0.5, 0.33333333333333
17857, 0.79166666666667, 0.55, 0.33333333333333
17858, 0.79166666666667, 0.6, 0.33333333333333
17859, 0.79166666666667, 0.65, 0.33333333333333
17860, 0.79166666666667, 0.7, 0.33333333333333
17861, 0.79166666666667, 0.75, 0.33333333333333
17862, 0.79166666666667, 0.8, 0.33333333333333
17863, 0.79166666666667, 0.85, 0.33333333333333
17864, 0.79166666666667, 0.9, 0.33333333333333
17865, 0.79166666666667, 0.95, 0.33333333333333
17866, 0.79166666666667, 1, 0.33333333333333
17867, 0.79166666666667, 1.05, 0.33333333333333
17868, 0.79166666666667, 1.1, 0.33333333333333
17869, 0.79166666666667, 1.15, 0.33333333333333
17870, 0.79166666666667, 1.2, 0.33333333333333
17871, 0.79166666666667, 1.25, 0.33333333333333
17872, 0.79166666666667, 1.3, 0.33333333333333
17873, 0.79166666666667, 0.2, 0.375
17874, 0.79166666666667, 0.25, 0.375
17875, 0.79166666666667, 0.3, 0.375
17876, 0.79166666666667, 0.35, 0.375
17877, 0.79166666666667, 0.4, 0.375
17878, 0.79166666666667, 0.45, 0.375
17879, 0.79166666666667, 0.5, 0.375
17880, 0.79166666666667, 0.55, 0.375
17881, 0.79166666666667, 0.6, 0.375
17882, 0.79166666666667, 0.65, 0.375
17883, 0.79166666666667, 0.7, 0.375
17884, 0.79166666666667, 0.75, 0.375
17885, 0.79166666666667, 0.8, 0.375
17886, 0.79166666666667, 0.85, 0.375
17887, 0.79166666666667, 0.9, 0.375
17888, 0.79166666666667, 0.95, 0.375
17889, 0.79166666666667, 1, 0.375
17890, 0.79166666666667, 1.05, 0.375
17891, 0.79166666666667, 1.1, 0.375
17892, 0.79166666666667, 1.15, 0.375
17893, 0.79166666666667, 1.2, 0.375
17894, 0.79166666666667, 1.25, 0.375
17895, 0.79166666666667, 1.3, 0.375
17896, 0.79166666666667, 0.2, 0.41666666666667
17897, 0.79166666666667, 0.25, 0.41666666666667
17898, 0.79166666666667, 0.3, 0.41666666666667
17899, 0.79166666666667, 0.35, 0.41666666666667
17900, 0.79166666666667, 0.4, 0.41666666666667
17901, 0.79166666666667, 0.45, 0.41666666666667
17902, 0.79166666666667, 0.5, 0.41666666666667
17903, 0.79166666666667, 0.55, 0.41666666666667
17904, 0.79166666666667, 0.6, 0.41666666666667
17905, 0.79166666666667, 0.65, 0.41666666666667
17906, 0.79166666666667, 0.7, 0.41666666666667
17907, 0.79166666666667, 0.75, 0.41666666666667
17908, 0.79166666666667, 0.8, 0.41666666666667
17909, 0.79166666666667, 0.85, 0.41666666666667
17910, 0.79166666666667, 0.9, 0.41666666666667
17911, 0.79166666666667, 0.95, 0.41666666666667
17912, 0.79166666666667, 1, 0.41666666666667
17913, 0.79166666666667, 1.05, 0.41666666666667
17914, 0.79166666666667, 1.1, 0.41666666666667
17915, 0.79166666666667, 1.15, 0.41666666666667
17916, 0.79166666666667, 1.2, 0.41666666666667
17917, 0.79166666666667, 1.25, 0.41666666666667
17918, 0.79166666666667, 1.3, 0.41666666666667
17919, 0.79166666666667, 0.2, 0.45833333333333
17920, 0.79166666666667, 0.25, 0.45833333333333
17921, 0.79166666666667, 0.3, 0.45833333333333
17922, 0.79166666666667, 0.35, 0.45833333333333
17923, 0.79166666666667, 0.4, 0.45833333333333
17924, 0.79166666666667, 0.45, 0.45833333333333
17925, 0.79166666666667, 0.5, 0.45833333333333
17926, 0.79166666666667, 0.55, 0.45833333333333
17927, 0.79166666666667, 0.6, 0.45833333333333
17928, 0.79166666666667, 0.65, 0.45833333333333
17929, 0.79166666666667, 0.7, 0.45833333333333
17930, 0.79166666666667, 0.75, 0.45833333333333
17931, 0.79166666666667, 0.8, 0.45833333333333
17932, 0.79166666666667, 0.85, 0.45833333333333
17933, 0.79166666666667, 0.9, 0.45833333333333
17934, 0.79166666666667, 0.95, 0.45833333333333
17935, 0.79166666666667, 1, 0.45833333333333
17936, 0.79166666666667, 1.05, 0.45833333333333
17937, 0.79166666666667, 1.1, 0.45833333333333
17938, 0.79166666666667, 1.15, 0.45833333333333
17939, 0.79166666666667, 1.2, 0.45833333333333
17940, 0.79166666666667, 1.25, 0.45833333333333
17941, 0.79166666666667, 1.3, 0.45833333333333
17942, 0.83333333333333, 0.2, 0.041666666666667
17943, 0.83333333333333, 0.25, 0.041666666666667
17944, 0.83333333333333, 0.3, 0.041666666666667
17945, 0.83333333333333, 0.35, 0.041666666666667
17946, 0.83333333333333, 0.4, 0.041666666666667
17947, 0.83333333333333, 0.45, 0.041666666666667
17948, 0.83333333333333, 0.5, 0.041666666666667
17949, 0.83333333333333, 0.55, 0.041666666666667
17950, 0.83333333333333, 0.6, 0.041666666666667
17951, 0.83333333333333, 0.65, 0.041666666666667
17952, 0.83333333333333, 0.7, 0.041666666666667
17953, 0.83333333333333, 0.75, 0.041666666666667
17954, 0.83333333333333, 0.8, 0.041666666666667
17955, 0.83333333333333, 0.85, 0.041666666666667
17956, 0.83333333333333, 0.9, 0.041666666666667
17957, 0.83333333333333, 0.95, 0.041666666666667
17958, 0.83333333333333, 1, 0.041666666666667
17959, 0.83333333333333, 1.05, 0.041666666666667
17960, 0.83333333333333, 1.1, 0.041666666666667
17961, 0.83333333333333, 1.15, 0.041666666666667
17962, 0.83333333333333, 1.2, 0.041666666666667
17963, 0.83333333333333, 1.25, 0.041666666666667
17964, 0.83333333333333, 1.3, 0.041666666666667
17965, 0.83333333333333, 0.2, 0.083333333333333
17966, 0.83333333333333, 0.25, 0.083333333333333
17967, 0.83333333333333, 0.3, 0.083333333333333
17968, 0.83333333333333, 0.35, 0.083333333333333
17969, 0.83333333333333, 0.4, 0.083333333333333
17970, 0.83333333333333, 0.45, 0.083333333333333
17971, 0.83333333333333, 0.5, 0.083333333333333
17972, 0.83333333333333, 0.55, 0.083333333333333
17973, 0.83333333333333, 0.6, 0.083333333333333
17974, 0.83333333333333, 0.65, 0.083333333333333
17975, 0.83333333333333, 0.7, 0.083333333333333
17976, 0.83333333333333, 0.75, 0.083333333333333
17977, 0.83333333333333, 0.8, 0.083333333333333
17978, 0.83333333333333, 0.85, 0.083333333333333
17979, 0.83333333333333, 0.9, 0.083333333333333
17980, 0.83333333333333, 0.95, 0.083333333333333
17981, 0.83333333333333, 1, 0.083333333333333
17982, 0.83333333333333, 1.05, 0.083333333333333
17983, 0.83333333333333, 1.1, 0.083333333333333
17984, 0.83333333333333, 1.15, 0.083333333333333
17985, 0.83333333333333, 1.2, 0.083333333333333
17986, 0.83333333333333, 1.25, 0.083333333333333
17987, 0.83333333333333, 1.3, 0.083333333333333
17988, 0.83333333333333, 0.2, 0.125
17989, 0.83333333333333, 0.25, 0.125
17990, 0.83333333333333, 0.3, 0.125
17991, 0.83333333333333, 0.35, 0.125
17992, 0.83333333333333, 0.4, 0.125
17993, 0.83333333333333, 0.45, 0.125
17994, 0.83333333333333, 0.5, 0.125
17995, 0.83333333333333, 0.55, 0.125
17996, 0.83333333333333, 0.6, 0.125
17997, 0.83333333333333, 0.65, 0.125
17998, 0.83333333333333, 0.7, 0.125
17999, 0.83333333333333, 0.75, 0.125
18000, 0.83333333333333, 0.8, 0.125
18001, 0.83333333333333, 0.85, 0.125
18002, 0.83333333333333, 0.9, 0.125
18003, 0.83333333333333, 0.95, 0.125
18004, 0.83333333333333, 1, 0.125
18005, 0.83333333333333, 1.05, 0.125
18006, 0.83333333333333, 1.1, 0.125
18007, 0.83333333333333, 1.15, 0.125
18008, 0.83333333333333, 1.2, 0.125
18009, 0.83333333333333, 1.25, 0.125
18010, 0.83333333333333, 1.3, 0.125
18011, 0.83333333333333, 0.2, 0.16666666666667
18012, 0.83333333333333, 0.25, 0.16666666666667
18013, 0.83333333333333, 0.3, 0.16666666666667
18014, 0.83333333333333, 0.35, 0.16666666666667
18015, 0.83333333333333, 0.4, 0.16666666666667
18016, 0.83333333333333, 0.45, 0.16666666666667
18017, 0.83333333333333, 0.5, 0.16666666666667
18018, 0.83333333333333, 0.55, 0.16666666666667
18019, 0.83333333333333, 0.6, 0.16666666666667
18020, 0.83333333333333, 0.65, 0.16666666666667
18021, 0.83333333333333, 0.7, 0.16666666666667
18022, 0.83333333333333, 0.75, 0.16666666666667
18023, 0.83333333333333, 0.8, 0.16666666666667
18024, 0.83333333333333, 0.85, 0.16666666666667
18025, 0.83333333333333, 0.9, 0.16666666666667
18026, 0.83333333333333, 0.95, 0.16666666666667
18027, 0.83333333333333, 1, 0.16666666666667
18028, 0.83333333333333, 1.05, 0.16666666666667
18029, 0.83333333333333, 1.1, 0.16666666666667
18030, 0.83333333333333, 1.15, 0.16666666666667
18031, 0.83333333333333, 1.2, 0.16666666666667
18032, 0.83333333333333, 1.25, 0.16666666666667
18033, 0.83333333333333, 1.3, 0.16666666666667
18034, 0.83333333333333, 0.2, 0.20833333333333
18035, 0.83333333333333, 0.25, 0.20833333333333
18036, 0.83333333333333, 0.3, 0.20833333333333
18037, 0.83333333333333, 0.35, 0.20833333333333
18038, 0.83333333333333, 0.4, 0.20833333333333
18039, 0.83333333333333, 0.45, 0.20833333333333
18040, 0.83333333333333, 0.5, 0.20833333333333
18041, 0.83333333333333, 0.55, 0.20833333333333
18042, 0.83333333333333, 0.6, 0.20833333333333
18043, 0.83333333333333, 0.65, 0.20833333333333
18044, 0.83333333333333, 0.7, 0.20833333333333
18045, 0.83333333333333, 0.75, 0.20833333333333
18046, 0.83333333333333, 0.8, 0.20833333333333
18047, 0.83333333333333, 0.85, 0.20833333333333
18048, 0.83333333333333, 0.9, 0.20833333333333
18049, 0.83333333333333, 0.95, 0.20833333333333
18050, 0.83333333333333, 1, 0.20833333333333
18051, 0.83333333333333, 1.05, 0.20833333333333
18052, 0.83333333333333, 1.1, 0.20833333333333
18053, 0.83333333333333, 1.15, 0.20833333333333
18054, 0.83333333333333, 1.2, 0.20833333333333
18055, 0.83333333333333, 1.25, 0.20833333333333
18056, 0.83333333333333, 1.3, 0.20833333333333
18057, 0.83333333333333, 0.2, 0.25
18058, 0.83333333333333, 0.25, 0.25
18059, 0.83333333333333, 0.3, 0.25
18060, 0.83333333333333, 0.35, 0.25
18061, 0.83333333333333, 0.4, 0.25
18062, 0.83333333333333, 0.45, 0.25
18063, 0.83333333333333, 0.5, 0.25
18064, 0.83333333333333, 0.55, 0.25
18065, 0.83333333333333, 0.6, 0.25
18066, 0.83333333333333, 0.65, 0.25
18067, 0.83333333333333, 0.7, 0.25
18068, 0.83333333333333, 0.75, 0.25
18069, 0.83333333333333, 0.8, 0.25
18070, 0.83333333333333, 0.85, 0.25
18071, 0.83333333333333, 0.9, 0.25
18072, 0.83333333333333, 0.95, 0.25
18073, 0.83333333333333, 1, 0.25
18074, 0.83333333333333, 1.05, 0.25
18075, 0.83333333333333, 1.1, 0.25
18076, 0.83333333333333, 1.15, 0.25
18077, 0.83333333333333, 1.2, 0.25
18078, 0.83333333333333, 1.25, 0.25
18079, 0.83333333333333, 1.3, 0.25
18080, 0.83333333333333, 0.2, 0.29166666666667
18081, 0.83333333333333, 0.25, 0.29166666666667
18082, 0.83333333333333, 0.3, 0.29166666666667
18083, 0.83333333333333, 0.35, 0.29166666666667
18084, 0.83333333333333, 0.4, 0.29166666666667
18085, 0.83333333333333, 0.45, 0.29166666666667
18086, 0.83333333333333, 0.5, 0.29166666666667
18087, 0.83333333333333, 0.55, 0.29166666666667
18088, 0.83333333333333, 0.6, 0.29166666666667
18089, 0.83333333333333, 0.65, 0.29166666666667
18090, 0.83333333333333, 0.7, 0.29166666666667
18091, 0.83333333333333, 0.75, 0.29166666666667
18092, 0.83333333333333, 0.8, 0.29166666666667
18093, 0.83333333333333, 0.85, 0.29166666666667
18094, 0.83333333333333, 0.9, 0.29166666666667
18095, 0.83333333333333, 0.95, 0.29166666666667
18096, 0.83333333333333, 1, 0.29166666666667
18097, 0.83333333333333, 1.05, 0.29166666666667
18098, 0.83333333333333, 1.1, 0.29166666666667
18099, 0.83333333333333, 1.15, 0.29166666666667
18100, 0.83333333333333, 1.2, 0.29166666666667
18101, 0.83333333333333, 1.25, 0.29166666666667
18102, 0.83333333333333, 1.3, 0.29166666666667
18103, 0.83333333333333, 0.2, 0.33333333333333
18104, 0.83333333333333, 0.25, 0.33333333333333
18105, 0.83333333333333, 0.3, 0.33333333333333
18106, 0.83333333333333, 0.35, 0.33333333333333
18107, 0.83333333333333, 0.4, 0.33333333333333
18108, 0.83333333333333, 0.45, 0.33333333333333
18109, 0.83333333333333, 0.5, 0.33333333333333
18110, 0.83333333333333, 0.55, 0.33333333333333
18111, 0.83333333333333, 0.6, 0.33333333333333
18112, 0.83333333333333, 0.65, 0.33333333333333
18113, 0.83333333333333, 0.7, 0.33333333333333
18114, 0.83333333333333, 0.75, 0.33333333333333
18115, 0.83333333333333, 0.8, 0.33333333333333
18116, 0.83333333333333, 0.85, 0.33333333333333
18117, 0.83333333333333, 0.9, 0.33333333333333
18118, 0.83333333333333, 0.95, 0.33333333333333
18119, 0.83333333333333, 1, 0.33333333333333
18120, 0.83333333333333, 1.05, 0.33333333333333
18121, 0.83333333333333, 1.1, 0.33333333333333
18122, 0.83333333333333, 1.15, 0.33333333333333
18123, 0.83333333333333, 1.2, 0.33333333333333
18124, 0.83333333333333, 1.25, 0.33333333333333
18125, 0.83333333333333, 1.3, 0.33333333333333
18126, 0.83333333333333, 0.2, 0.375
18127, 0.83333333333333, 0.25, 0.375
18128, 0.83333333333333, 0.3, 0.375
18129, 0.83333333333333, 0.35, 0.375
18130, 0.83333333333333, 0.4, 0.375
18131, 0.83333333333333, 0.45, 0.375
18132, 0.83333333333333, 0.5, 0.375
18133, 0.83333333333333, 0.55, 0.375
18134, 0.83333333333333, 0.6, 0.375
18135, 0.83333333333333, 0.65, 0.375
18136, 0.83333333333333, 0.7, 0.375
18137, 0.83333333333333, 0.75, 0.375
18138, 0.83333333333333, 0.8, 0.375
18139, 0.83333333333333, 0.85, 0.375
18140, 0.83333333333333, 0.9, 0.375
18141, 0.83333333333333, 0.95, 0.375
18142, 0.83333333333333, 1, 0.375
18143, 0.83333333333333, 1.05, 0.375
18144, 0.83333333333333, 1.1, 0.375
18145, 0.83333333333333, 1.15, 0.375
18146, 0.83333333333333, 1.2, 0.375
18147, 0.83333333333333, 1.25, 0.375
18148, 0.83333333333333, 1.3, 0.375
18149, 0.83333333333333, 0.2, 0.41666666666667
18150, 0.83333333333333, 0.25, 0.41666666666667
18151, 0.83333333333333, 0.3, 0.41666666666667
18152, 0.83333333333333, 0.35, 0.41666666666667
18153, 0.83333333333333, 0.4, 0.41666666666667
18154, 0.83333333333333, 0.45, 0.41666666666667
18155, 0.83333333333333, 0.5, 0.41666666666667
18156, 0.83333333333333, 0.55, 0.41666666666667
18157, 0.83333333333333, 0.6, 0.41666666666667
18158, 0.83333333333333, 0.65, 0.41666666666667
18159, 0.83333333333333, 0.7, 0.41666666666667
18160, 0.83333333333333, 0.75, 0.41666666666667
18161, 0.83333333333333, 0.8, 0.41666666666667
18162, 0.83333333333333, 0.85, 0.41666666666667
18163, 0.83333333333333, 0.9, 0.41666666666667
18164, 0.83333333333333, 0.95, 0.41666666666667
18165, 0.83333333333333, 1, 0.41666666666667
18166, 0.83333333333333, 1.05, 0.41666666666667
18167, 0.83333333333333, 1.1, 0.41666666666667
18168, 0.83333333333333, 1.15, 0.41666666666667
18169, 0.83333333333333, 1.2, 0.41666666666667
18170, 0.83333333333333, 1.25, 0.41666666666667
18171, 0.83333333333333, 1.3, 0.41666666666667
18172, 0.83333333333333, 0.2, 0.45833333333333
18173, 0.83333333333333, 0.25, 0.45833333333333
18174, 0.83333333333333, 0.3, 0.45833333333333
18175, 0.83333333333333, 0.35, 0.45833333333333
18176, 0.83333333333333, 0.4, 0.45833333333333
18177, 0.83333333333333, 0.45, 0.45833333333333
18178, 0.83333333333333, 0.5, 0.45833333333333
18179, 0.83333333333333, 0.55, 0.45833333333333
18180, 0.83333333333333, 0.6, 0.45833333333333
18181, 0.83333333333333, 0.65, 0.45833333333333
18182, 0.83333333333333, 0.7, 0.45833333333333
18183, 0.83333333333333, 0.75, 0.45833333333333
18184, 0.83333333333333, 0.8, 0.45833333333333
18185, 0.83333333333333, 0.85, 0.45833333333333
18186, 0.83333333333333, 0.9, 0.45833333333333
18187, 0.83333333333333, 0.95, 0.45833333333333
18188, 0.83333333333333, 1, 0.45833333333333
18189, 0.83333333333333, 1.05, 0.45833333333333
18190, 0.83333333333333, 1.1, 0.45833333333333
18191, 0.83333333333333, 1.15, 0.45833333333333
18192, 0.83333333333333, 1.2, 0.45833333333333
18193, 0.83333333333333, 1.25, 0.45833333333333
18194, 0.83333333333333, 1.3, 0.45833333333333
18195, 0.875, 0.2, 0.041666666666667
18196, 0.875, 0.25, 0.041666666666667
18197, 0.875, 0.3, 0.041666666666667
18198, 0.875, 0.35, 0.041666666666667
18199, 0.875, 0.4, 0.041666666666667
18200, 0.875, 0.45, 0.041666666666667
18201, 0.875, 0.5, 0.041666666666667
18202, 0.875, 0.55, 0.041666666666667
18203, 0.875, 0.6, 0.041666666666667
18204, 0.875, 0.65, 0.041666666666667
18205, 0.875, 0.7, 0.041666666666667
18206, 0.875, 0.75, 0.041666666666667
18207, 0.875, 0.8, 0.041666666666667
18208, 0.875, 0.85, 0.041666666666667
18209, 0.875, 0.9, 0.041666666666667
18210, 0.875, 0.95, 0.041666666666667
18211, 0.875, 1, 0.041666666666667
18212, 0.875, 1.05, 0.041666666666667
18213, 0.875, 1.1, 0.041666666666667
18214, 0.875, 1.15, 0.041666666666667
18215, 0.875, 1.2, 0.041666666666667
18216, 0.875, 1.25, 0.041666666666667
18217, 0.875, 1.3, 0.041666666666667
18218, 0.875, 0.2, 0.083333333333333
18219, 0.875, 0.25, 0.083333333333333
18220, 0.875, 0.3, 0.083333333333333
18221, 0.875, 0.35, 0.083333333333333
18222, 0.875, 0.4, 0.083333333333333
18223, 0.875, 0.45, 0.083333333333333
18224, 0.875, 0.5, 0.083333333333333
18225, 0.875, 0.55, 0.083333333333333
18226, 0.875, 0.6, 0.083333333333333
18227, 0.875, 0.65, 0.083333333333333
18228, 0.875, 0.7, 0.083333333333333
18229, 0.875, 0.75, 0.083333333333333
18230, 0.875, 0.8, 0.083333333333333
18231, 0.875, 0.85, 0.083333333333333
18232, 0.875, 0.9, 0.083333333333333
18233, 0.875, 0.95, 0.083333333333333
18234, 0.875, 1, 0.083333333333333
18235, 0.875, 1.05, 0.083333333333333
18236, 0.875, 1.1, 0.083333333333333
18237, 0.875, 1.15, 0.083333333333333
18238, 0.875, 1.2, 0.083333333333333
18239, 0.875, 1.25, 0.083333333333333
18240, 0.875, 1.3, 0.083333333333333
18241, 0.875, 0.2, 0.125
18242, 0.875, 0.25, 0.125
18243, 0.875, 0.3, 0.125
18244, 0.875, 0.35, 0.125
18245, 0.875, 0.4, 0.125
18246, 0.875, 0.45, 0.125
18247, 0.875, 0.5, 0.125
18248, 0.875, 0.55, 0.125
18249, 0.875, 0.6, 0.125
18250, 0.875, 0.65, 0.125
18251, 0.875, 0.7, 0.125
18252, 0.875, 0.75, 0.125
18253, 0.875, 0.8, 0.125
18254, 0.875, 0.85, 0.125
18255, 0.875, 0.9, 0.125
18256, 0.875, 0.95, 0.125
18257, 0.875, 1, 0.125
18258, 0.875, 1.05, 0.125
18259, 0.875, 1.1, 0.125
18260, 0.875, 1.15, 0.125
18261, 0.875, 1.2, 0.125
18262, 0.875, 1.25, 0.125
18263, 0.875, 1.3, 0.125
18264, 0.875, 0.2, 0.16666666666667
18265, 0.875, 0.25, 0.16666666666667
18266, 0.875, 0.3, 0.16666666666667
18267, 0.875, 0.35, 0.16666666666667
18268, 0.875, 0.4, 0.16666666666667
18269, 0.875, 0.45, 0.16666666666667
18270, 0.875, 0.5, 0.16666666666667
18271, 0.875, 0.55, 0.16666666666667
18272, 0.875, 0.6, 0.16666666666667
18273, 0.875, 0.65, 0.16666666666667
18274, 0.875, 0.7, 0.16666666666667
18275, 0.875, 0.75, 0.16666666666667
18276, 0.875, 0.8, 0.16666666666667
18277, 0.875, 0.85, 0.16666666666667
18278, 0.875, 0.9, 0.16666666666667
18279, 0.875, 0.95, 0.16666666666667
18280, 0.875, 1, 0.16666666666667
18281, 0.875, 1.05, 0.16666666666667
18282, 0.875, 1.1, 0.16666666666667
18283, 0.875, 1.15, 0.16666666666667
18284, 0.875, 1.2, 0.16666666666667
18285, 0.875, 1.25, 0.16666666666667
18286, 0.875, 1.3, 0.16666666666667
18287, 0.875, 0.2, 0.20833333333333
18288, 0.875, 0.25, 0.20833333333333
18289, 0.875, 0.3, 0.20833333333333
18290, 0.875, 0.35, 0.20833333333333
18291, 0.875, 0.4, 0.20833333333333
18292, 0.875, 0.45, 0.20833333333333
18293, 0.875, 0.5, 0.20833333333333
18294, 0.875, 0.55, 0.20833333333333
18295, 0.875, 0.6, 0.20833333333333
18296, 0.875, 0.65, 0.20833333333333
18297, 0.875, 0.7, 0.20833333333333
18298, 0.875, 0.75, 0.20833333333333
18299, 0.875, 0.8, 0.20833333333333
18300, 0.875, 0.85, 0.20833333333333
18301, 0.875, 0.9, 0.20833333333333
18302, 0.875, 0.95, 0.20833333333333
18303, 0.875, 1, 0.20833333333333
18304, 0.875, 1.05, 0.20833333333333
18305, 0.875, 1.1, 0.20833333333333
18306, 0.875, 1.15, 0.20833333333333
18307, 0.875, 1.2, 0.20833333333333
18308, 0.875, 1.25, 0.20833333333333
18309, 0.875, 1.3, 0.20833333333333
18310, 0.875, 0.2, 0.25
18311, 0.875, 0.25, 0.25
18312, 0.875, 0.3, 0.25
18313, 0.875, 0.35, 0.25
18314, 0.875, 0.4, 0.25
18315, 0.875, 0.45, 0.25
18316, 0.875, 0.5, 0.25
18317, 0.875, 0.55, 0.25
18318, 0.875, 0.6, 0.25
18319, 0.875, 0.65, 0.25
18320, 0.875, 0.7, 0.25
18321, 0.875, 0.75, 0.25
18322, 0.875, 0.8, 0.25
18323, 0.875, 0.85, 0.25
18324, 0.875, 0.9, 0.25
18325, 0.875, 0.95, 0.25
18326, 0.875, 1, 0.25
18327, 0.875, 1.05, 0.25
18328, 0.875, 1.1, 0.25
18329, 0.875, 1.15, 0.25
18330, 0.875, 1.2, 0.25
18331, 0.875, 1.25, 0.25
18332, 0.875, 1.3, 0.25
18333, 0.875, 0.2, 0.29166666666667
18334, 0.875, 0.25, 0.29166666666667
18335, 0.875, 0.3, 0.29166666666667
18336, 0.875, 0.35, 0.29166666666667
18337, 0.875, 0.4, 0.29166666666667
18338, 0.875, 0.45, 0.29166666666667
18339, 0.875, 0.5, 0.29166666666667
18340, 0.875, 0.55, 0.29166666666667
18341, 0.875, 0.6, 0.29166666666667
18342, 0.875, 0.65, 0.29166666666667
18343, 0.875, 0.7, 0.29166666666667
18344, 0.875, 0.75, 0.29166666666667
18345, 0.875, 0.8, 0.29166666666667
18346, 0.875, 0.85, 0.29166666666667
18347, 0.875, 0.9, 0.29166666666667
18348, 0.875, 0.95, 0.29166666666667
18349, 0.875, 1, 0.29166666666667
18350, 0.875, 1.05, 0.29166666666667
18351, 0.875, 1.1, 0.29166666666667
18352, 0.875, 1.15, 0.29166666666667
18353, 0.875, 1.2, 0.29166666666667
18354, 0.875, 1.25, 0.29166666666667
18355, 0.875, 1.3, 0.29166666666667
18356, 0.875, 0.2, 0.33333333333333
18357, 0.875, 0.25, 0.33333333333333
18358, 0.875, 0.3, 0.33333333333333
18359, 0.875, 0.35, 0.33333333333333
18360, 0.875, 0.4, 0.33333333333333
18361, 0.875, 0.45, 0.33333333333333
18362, 0.875, 0.5, 0.33333333333333
18363, 0.875, 0.55, 0.33333333333333
18364, 0.875, 0.6, 0.33333333333333
18365, 0.875, 0.65, 0.33333333333333
18366, 0.875, 0.7, 0.33333333333333
18367, 0.875, 0.75, 0.33333333333333
18368, 0.875, 0.8, 0.33333333333333
18369, 0.875, 0.85, 0.33333333333333
18370, 0.875, 0.9, 0.33333333333333
18371, 0.875, 0.95, 0.33333333333333
18372, 0.875, 1, 0.33333333333333
18373, 0.875, 1.05, 0.33333333333333
18374, 0.875, 1.1, 0.33333333333333
18375, 0.875, 1.15, 0.33333333333333
18376, 0.875, 1.2, 0.33333333333333
18377, 0.875, 1.25, 0.33333333333333
18378, 0.875, 1.3, 0.33333333333333
18379, 0.875, 0.2, 0.375
18380, 0.875, 0.25, 0.375
18381, 0.875, 0.3, 0.375
18382, 0.875, 0.35, 0.375
18383, 0.875, 0.4, 0.375
18384, 0.875, 0.45, 0.375
18385, 0.875, 0.5, 0.375
18386, 0.875, 0.55, 0.375
18387, 0.875, 0.6, 0.375
18388, 0.875, 0.65, 0.375
18389, 0.875, 0.7, 0.375
18390, 0.875, 0.75, 0.375
18391, 0.875, 0.8, 0.375
18392, 0.875, 0.85, 0.375
18393, 0.875, 0.9, 0.375
18394, 0.875, 0.95, 0.375
18395, 0.875, 1, 0.375
18396, 0.875, 1.05, 0.375
18397, 0.875, 1.1, 0.375
18398, 0.875, 1.15, 0.375
18399, 0.875, 1.2, 0.375
18400, 0.875, 1.25, 0.375
18401, 0.875, 1.3, 0.375
18402, 0.875, 0.2, 0.41666666666667
18403, 0.875, 0.25, 0.41666666666667
18404, 0.875, 0.3, 0.41666666666667
18405, 0.875, 0.35, 0.41666666666667
18406, 0.875, 0.4, 0.41666666666667
18407, 0.875, 0.45, 0.41666666666667
18408, 0.875, 0.5, 0.41666666666667
18409, 0.875, 0.55, 0.41666666666667
18410, 0.875, 0.6, 0.41666666666667
18411, 0.875, 0.65, 0.41666666666667
18412, 0.875, 0.7, 0.41666666666667
18413, 0.875, 0.75, 0.41666666666667
18414, 0.875, 0.8, 0.41666666666667
18415, 0.875, 0.85, 0.41666666666667
18416, 0.875, 0.9, 0.41666666666667
18417, 0.875, 0.95, 0.41666666666667
18418, 0.875, 1, 0.41666666666667
18419, 0.875, 1.05, 0.41666666666667
18420, 0.875, 1.1, 0.41666666666667
18421, 0.875, 1.15, 0.41666666666667
18422, 0.875, 1.2, 0.41666666666667
18423, 0.875, 1.25, 0.41666666666667
18424, 0.875, 1.3, 0.41666666666667
18425, 0.875, 0.2, 0.45833333333333
18426, 0.875, 0.25, 0.45833333333333
18427, 0.875, 0.3, 0.45833333333333
18428, 0.875, 0.35, 0.45833333333333
18429, 0.875, 0.4, 0.45833333333333
18430, 0.875, 0.45, 0.45833333333333
18431, 0.875, 0.5, 0.45833333333333
18432, 0.875, 0.55, 0.45833333333333
18433, 0.875, 0.6, 0.45833333333333
18434, 0.875, 0.65, 0.45833333333333
18435, 0.875, 0.7, 0.45833333333333
18436, 0.875, 0.75, 0.45833333333333
18437, 0.875, 0.8, 0.45833333333333
18438, 0.875, 0.85, 0.45833333333333
18439, 0.875, 0.9, 0.45833333333333
18440, 0.875, 0.95, 0.45833333333333
18441, 0.875, 1, 0.45833333333333
18442, 0.875, 1.05, 0.45833333333333
18443, 0.875, 1.1, 0.45833333333333
18444, 0.875, 1.15, 0.45833333333333
18445, 0.875, 1.2, 0.45833333333333
18446, 0.875, 1.25, 0.45833333333333
18447, 0.875, 1.3, 0.45833333333333
18448, 0.91666666666667, 0.2, 0.041666666666667
18449, 0.91666666666667, 0.25, 0.041666666666667
18450, 0.91666666666667, 0.3, 0.041666666666667
18451, 0.91666666666667, 0.35, 0.041666666666667
18452, 0.91666666666667, 0.4, 0.041666666666667
18453, 0.91666666666667, 0.45, 0.041666666666667
18454, 0.91666666666667, 0.5, 0.041666666666667
18455, 0.91666666666667, 0.55, 0.041666666666667
18456, 0.91666666666667, 0.6, 0.041666666666667
18457, 0.91666666666667, 0.65, 0.041666666666667
18458, 0.91666666666667, 0.7, 0.041666666666667
18459, 0.91666666666667, 0.75, 0.041666666666667
18460, 0.91666666666667, 0.8, 0.041666666666667
18461, 0.91666666666667, 0.85, 0.041666666666667
18462, 0.91666666666667, 0.9, 0.041666666666667
18463, 0.91666666666667, 0.95, 0.041666666666667
18464, 0.91666666666667, 1, 0.041666666666667
18465, 0.91666666666667, 1.05, 0.041666666666667
18466, 0.91666666666667, 1.1, 0.041666666666667
18467, 0.91666666666667, 1.15, 0.041666666666667
18468, 0.91666666666667, 1.2, 0.041666666666667
18469, 0.91666666666667, 1.25, 0.041666666666667
18470, 0.91666666666667, 1.3, 0.041666666666667
18471, 0.91666666666667, 0.2, 0.083333333333333
18472, 0.91666666666667, 0.25, 0.083333333333333
18473, 0.91666666666667, 0.3, 0.083333333333333
18474, 0.91666666666667, 0.35, 0.083333333333333
18475, 0.91666666666667, 0.4, 0.083333333333333
18476, 0.91666666666667, 0.45, 0.083333333333333
18477, 0.91666666666667, 0.5, 0.083333333333333
18478, 0.91666666666667, 0.55, 0.083333333333333
18479, 0.91666666666667, 0.6, 0.083333333333333
18480, 0.91666666666667, 0.65, 0.083333333333333
18481, 0.91666666666667, 0.7, 0.083333333333333
18482, 0.91666666666667, 0.75, 0.083333333333333
18483, 0.91666666666667, 0.8, 0.083333333333333
18484, 0.91666666666667, 0.85, 0.083333333333333
18485, 0.91666666666667, 0.9, 0.083333333333333
18486, 0.91666666666667, 0.95, 0.083333333333333
18487, 0.91666666666667, 1, 0.083333333333333
18488, 0.91666666666667, 1.05, 0.083333333333333
18489, 0.91666666666667, 1.1, 0.083333333333333
18490, 0.91666666666667, 1.15, 0.083333333333333
18491, 0.91666666666667, 1.2, 0.083333333333333
18492, 0.91666666666667, 1.25, 0.083333333333333
18493, 0.91666666666667, 1.3, 0.083333333333333
18494, 0.91666666666667, 0.2, 0.125
18495, 0.91666666666667, 0.25, 0.125
18496, 0.91666666666667, 0.3, 0.125
18497, 0.91666666666667, 0.35, 0.125
18498, 0.91666666666667, 0.4, 0.125
18499, 0.91666666666667, 0.45, 0.125
18500, 0.91666666666667, 0.5, 0.125
18501, 0.91666666666667, 0.55, 0.125
18502, 0.91666666666667, 0.6, 0.125
18503, 0.91666666666667, 0.65, 0.125
18504, 0.91666666666667, 0.7, 0.125
18505, 0.91666666666667, 0.75, 0.125
18506, 0.91666666666667, 0.8, 0.125
18507, 0.91666666666667, 0.85, 0.125
18508, 0.91666666666667, 0.9, 0.125
18509, 0.91666666666667, 0.95, 0.125
18510, 0.91666666666667, 1, 0.125
18511, 0.91666666666667, 1.05, 0.125
18512, 0.91666666666667, 1.1, 0.125
18513, 0.91666666666667, 1.15, 0.125
18514, 0.91666666666667, 1.2, 0.125
18515, 0.91666666666667, 1.25, 0.125
18516, 0.91666666666667, 1.3, 0.125
18517, 0.91666666666667, 0.2, 0.16666666666667
18518, 0.91666666666667, 0.25, 0.16666666666667
18519, 0.91666666666667, 0.3, 0.16666666666667
18520, 0.91666666666667, 0.35, 0.16666666666667
18521, 0.91666666666667, 0.4, 0.16666666666667
18522, 0.91666666666667, 0.45, 0.16666666666667
18523, 0.91666666666667, 0.5, 0.16666666666667
18524, 0.91666666666667, 0.55, 0.16666666666667
18525, 0.91666666666667, 0.6, 0.16666666666667
18526, 0.91666666666667, 0.65, 0.16666666666667
18527, 0.91666666666667, 0.7, 0.16666666666667
18528, 0.91666666666667, 0.75, 0.16666666666667
18529, 0.91666666666667, 0.8, 0.16666666666667
18530, 0.91666666666667, 0.85, 0.16666666666667
18531, 0.91666666666667, 0.9, 0.16666666666667
18532, 0.91666666666667, 0.95, 0.16666666666667
18533, 0.91666666666667, 1, 0.16666666666667
18534, 0.91666666666667, 1.05, 0.16666666666667
18535, 0.91666666666667, 1.1, 0.16666666666667
18536, 0.91666666666667, 1.15, 0.16666666666667
18537, 0.91666666666667, 1.2, 0.16666666666667
18538, 0.91666666666667, 1.25, 0.16666666666667
18539, 0.91666666666667, 1.3, 0.16666666666667
18540, 0.91666666666667, 0.2, 0.20833333333333
18541, 0.91666666666667, 0.25, 0.20833333333333
18542, 0.91666666666667, 0.3, 0.20833333333333
18543, 0.91666666666667, 0.35, 0.20833333333333
18544, 0.91666666666667, 0.4, 0.20833333333333
18545, 0.91666666666667, 0.45, 0.20833333333333
18546, 0.91666666666667, 0.5, 0.20833333333333
18547, 0.91666666666667, 0.55, 0.20833333333333
18548, 0.91666666666667, 0.6, 0.20833333333333
18549, 0.91666666666667, 0.65, 0.20833333333333
18550, 0.91666666666667, 0.7, 0.20833333333333
18551, 0.91666666666667, 0.75, 0.20833333333333
18552, 0.91666666666667, 0.8, 0.20833333333333
18553, 0.91666666666667, 0.85, 0.20833333333333
18554, 0.91666666666667, 0.9, 0.20833333333333
18555, 0.91666666666667, 0.95, 0.20833333333333
18556, 0.91666666666667, 1, 0.20833333333333
18557, 0.91666666666667, 1.05, 0.20833333333333
18558, 0.91666666666667, 1.1, 0.20833333333333
18559, 0.91666666666667, 1.15, 0.20833333333333
18560, 0.91666666666667, 1.2, 0.20833333333333
18561, 0.91666666666667, 1.25, 0.20833333333333
18562, 0.91666666666667, 1.3, 0.20833333333333
18563, 0.91666666666667, 0.2, 0.25
18564, 0.91666666666667, 0.25, 0.25
18565, 0.91666666666667, 0.3, 0.25
18566, 0.91666666666667, 0.35, 0.25
18567, 0.91666666666667, 0.4, 0.25
18568, 0.91666666666667, 0.45, 0.25
18569, 0.91666666666667, 0.5, 0.25
18570, 0.91666666666667, 0.55, 0.25
18571, 0.91666666666667, 0.6, 0.25
18572, 0.91666666666667, 0.65, 0.25
18573, 0.91666666666667, 0.7, 0.25
18574, 0.91666666666667, 0.75, 0.25
18575, 0.91666666666667, 0.8, 0.25
18576, 0.91666666666667, 0.85, 0.25
18577, 0.91666666666667, 0.9, 0.25
18578, 0.91666666666667, 0.95, 0.25
18579, 0.91666666666667, 1, 0.25
18580, 0.91666666666667, 1.05, 0.25
18581, 0.91666666666667, 1.1, 0.25
18582, 0.91666666666667, 1.15, 0.25
18583, 0.91666666666667, 1.2, 0.25
18584, 0.91666666666667, 1.25, 0.25
18585, 0.91666666666667, 1.3, 0.25
18586, 0.91666666666667, 0.2, 0.29166666666667
18587, 0.91666666666667, 0.25, 0.29166666666667
18588, 0.91666666666667, 0.3, 0.29166666666667
18589, 0.91666666666667, 0.35, 0.29166666666667
18590, 0.91666666666667, 0.4, 0.29166666666667
18591, 0.91666666666667, 0.45, 0.29166666666667
18592, 0.91666666666667, 0.5, 0.29166666666667
18593, 0.91666666666667, 0.55, 0.29166666666667
18594, 0.91666666666667, 0.6, 0.29166666666667
18595, 0.91666666666667, 0.65, 0.29166666666667
18596, 0.91666666666667, 0.7, 0.29166666666667
18597, 0.91666666666667, 0.75, 0.29166666666667
18598, 0.91666666666667, 0.8, 0.29166666666667
18599, 0.91666666666667, 0.85, 0.29166666666667
18600, 0.91666666666667, 0.9, 0.29166666666667
18601, 0.91666666666667, 0.95, 0.29166666666667
18602, 0.91666666666667, 1, 0.29166666666667
18603, 0.91666666666667, 1.05, 0.29166666666667
18604, 0.91666666666667, 1.1, 0.29166666666667
18605, 0.91666666666667, 1.15, 0.29166666666667
18606, 0.91666666666667, 1.2, 0.29166666666667
18607, 0.91666666666667, 1.25, 0.29166666666667
18608, 0.91666666666667, 1.3, 0.29166666666667
18609, 0.91666666666667, 0.2, 0.33333333333333
18610, 0.91666666666667, 0.25, 0.33333333333333
18611, 0.91666666666667, 0.3, 0.33333333333333
18612, 0.91666666666667, 0.35, 0.33333333333333
18613, 0.91666666666667, 0.4, 0.33333333333333
18614, 0.91666666666667, 0.45, 0.33333333333333
18615, 0.91666666666667, 0.5, 0.33333333333333
18616, 0.91666666666667, 0.55, 0.33333333333333
18617, 0.91666666666667, 0.6, 0.33333333333333
18618, 0.91666666666667, 0.65, 0.33333333333333
18619, 0.91666666666667, 0.7, 0.33333333333333
18620, 0.91666666666667, 0.75, 0.33333333333333
18621, 0.91666666666667, 0.8, 0.33333333333333
18622, 0.91666666666667, 0.85, 0.33333333333333
18623, 0.91666666666667, 0.9, 0.33333333333333
18624, 0.91666666666667, 0.95, 0.33333333333333
18625, 0.91666666666667, 1, 0.33333333333333
18626, 0.91666666666667, 1.05, 0.33333333333333
18627, 0.91666666666667, 1.1, 0.33333333333333
18628, 0.91666666666667, 1.15, 0.33333333333333
18629, 0.91666666666667, 1.2, 0.33333333333333
18630, 0.91666666666667, 1.25, 0.33333333333333
18631, 0.91666666666667, 1.3, 0.33333333333333
18632, 0.91666666666667, 0.2, 0.375
18633, 0.91666666666667, 0.25, 0.375
18634, 0.91666666666667, 0.3, 0.375
18635, 0.91666666666667, 0.35, 0.375
18636, 0.91666666666667, 0.4, 0.375
18637, 0.91666666666667, 0.45, 0.375
18638, 0.91666666666667, 0.5, 0.375
18639, 0.91666666666667, 0.55, 0.375
18640, 0.91666666666667, 0.6, 0.375
18641, 0.91666666666667, 0.65, 0.375
18642, 0.91666666666667, 0.7, 0.375
18643, 0.91666666666667, 0.75, 0.375
18644, 0.91666666666667, 0.8, 0.375
18645, 0.91666666666667, 0.85, 0.375
18646, 0.91666666666667, 0.9, 0.375
18647, 0.91666666666667, 0.95, 0.375
18648, 0.91666666666667, 1, 0.375
18649, 0.91666666666667, 1.05, 0.375
18650, 0.91666666666667, 1.1, 0.375
18651, 0.91666666666667, 1.15, 0.375
18652, 0.91666666666667, 1.2, 0.375
18653, 0.91666666666667, 1.25, 0.375
18654, 0.91666666666667, 1.3, 0.375
18655, 0.91666666666667, 0.2, 0.41666666666667
18656, 0.91666666666667, 0.25, 0.41666666666667
18657, 0.91666666666667, 0.3, 0.41666666666667
18658, 0.91666666666667, 0.35, 0.41666666666667
18659, 0.91666666666667, 0.4, 0.41666666666667
18660, 0.91666666666667, 0.45, 0.41666666666667
18661, 0.91666666666667, 0.5, 0.41666666666667
18662, 0.91666666666667, 0.55, 0.41666666666667
18663, 0.91666666666667, 0.6, 0.41666666666667
18664, 0.91666666666667, 0.65, 0.41666666666667
18665, 0.91666666666667, 0.7, 0.41666666666667
18666, 0.91666666666667, 0.75, 0.41666666666667
18667, 0.91666666666667, 0.8, 0.41666666666667
18668, 0.91666666666667, 0.85, 0.41666666666667
18669, 0.91666666666667, 0.9, 0.41666666666667
18670, 0.91666666666667, 0.95, 0.41666666666667
18671, 0.91666666666667, 1, 0.41666666666667
18672, 0.91666666666667, 1.05, 0.41666666666667
18673, 0.91666666666667, 1.1, 0.41666666666667
18674, 0.91666666666667, 1.15, 0.41666666666667
18675, 0.91666666666667, 1.2, 0.41666666666667
18676, 0.91666666666667, 1.25, 0.41666666666667
18677, 0.91666666666667, 1.3, 0.41666666666667
18678, 0.91666666666667, 0.2, 0.45833333333333
18679, 0.91666666666667, 0.25, 0.45833333333333
18680, 0.91666666666667, 0.3, 0.45833333333333
18681, 0.91666666666667, 0.35, 0.45833333333333
18682, 0.91666666666667, 0.4, 0.45833333333333
18683, 0.91666666666667, 0.45, 0.45833333333333
18684, 0.91666666666667, 0.5, 0.45833333333333
18685, 0.91666666666667, 0.55, 0.45833333333333
18686, 0.91666666666667, 0.6, 0.45833333333333
18687, 0.91666666666667, 0.65, 0.45833333333333
18688, 0.91666666666667, 0.7, 0.45833333333333
18689, 0.91666666666667, 0.75, 0.45833333333333
18690, 0.91666666666667, 0.8, 0.45833333333333
18691, 0.91666666666667, 0.85, 0.45833333333333
18692, 0.91666666666667, 0.9, 0.45833333333333
18693, 0.91666666666667, 0.95, 0.45833333333333
18694, 0.91666666666667, 1, 0.45833333333333
18695, 0.91666666666667, 1.05, 0.45833333333333
18696, 0.91666666666667, 1.1, 0.45833333333333
18697, 0.91666666666667, 1.15, 0.45833333333333
18698, 0.91666666666667, 1.2, 0.45833333333333
18699, 0.91666666666667, 1.25, 0.45833333333333
18700, 0.91666666666667, 1.3, 0.45833333333333
18701, 0.95833333333333, 0.2, 0.041666666666667
18702, 0.95833333333333, 0.25, 0.041666666666667
18703, 0.95833333333333, 0.3, 0.041666666666667
18704, 0.95833333333333, 0.35, 0.041666666666667
18705, 0.95833333333333, 0.4, 0.041666666666667
18706, 0.95833333333333, 0.45, 0.041666666666667
18707, 0.95833333333333, 0.5, 0.041666666666667
18708, 0.95833333333333, 0.55, 0.041666666666667
18709, 0.95833333333333, 0.6, 0.041666666666667
18710, 0.95833333333333, 0.65, 0.041666666666667
18711, 0.95833333333333, 0.7, 0.041666666666667
18712, 0.95833333333333, 0.75, 0.041666666666667
18713, 0.95833333333333, 0.8, 0.041666666666667
18714, 0.95833333333333, 0.85, 0.041666666666667
18715, 0.95833333333333, 0.9, 0.041666666666667
18716, 0.95833333333333, 0.95, 0.041666666666667
18717, 0.95833333333333, 1, 0.041666666666667
18718, 0.95833333333333, 1.05, 0.041666666666667
18719, 0.95833333333333, 1.1, 0.041666666666667
18720, 0.95833333333333, 1.15, 0.041666666666667
18721, 0.95833333333333, 1.2, 0.041666666666667
18722, 0.95833333333333, 1.25, 0.041666666666667
18723, 0.95833333333333, 1.3, 0.041666666666667
18724, 0.95833333333333, 0.2, 0.083333333333333
18725, 0.95833333333333, 0.25, 0.083333333333333
18726, 0.95833333333333, 0.3, 0.083333333333333
18727, 0.95833333333333, 0.35, 0.083333333333333
18728, 0.95833333333333, 0.4, 0.083333333333333
18729, 0.95833333333333, 0.45, 0.083333333333333
18730, 0.95833333333333, 0.5, 0.083333333333333
18731, 0.95833333333333, 0.55, 0.083333333333333
18732, 0.95833333333333, 0.6, 0.083333333333333
18733, 0.95833333333333, 0.65, 0.083333333333333
18734, 0.95833333333333, 0.7, 0.083333333333333
18735, 0.95833333333333, 0.75, 0.083333333333333
18736, 0.95833333333333, 0.8, 0.083333333333333
18737, 0.95833333333333, 0.85, 0.083333333333333
18738, 0.95833333333333, 0.9, 0.083333333333333
18739, 0.95833333333333, 0.95, 0.083333333333333
18740, 0.95833333333333, 1, 0.083333333333333
18741, 0.95833333333333, 1.05, 0.083333333333333
18742, 0.95833333333333, 1.1, 0.083333333333333
18743, 0.95833333333333, 1.15, 0.083333333333333
18744, 0.95833333333333, 1.2, 0.083333333333333
18745, 0.95833333333333, 1.25, 0.083333333333333
18746, 0.95833333333333, 1.3, 0.083333333333333
18747, 0.95833333333333, 0.2, 0.125
18748, 0.95833333333333, 0.25, 0.125
18749, 0.95833333333333, 0.3, 0.125
18750, 0.95833333333333, 0.35, 0.125
18751, 0.95833333333333, 0.4, 0.125
18752, 0.95833333333333, 0.45, 0.125
18753, 0.95833333333333, 0.5, 0.125
18754, 0.95833333333333, 0.55, 0.125
18755, 0.95833333333333, 0.6, 0.125
18756, 0.95833333333333, 0.65, 0.125
18757, 0.95833333333333, 0.7, 0.125
18758, 0.95833333333333, 0.75, 0.125
18759, 0.95833333333333, 0.8, 0.125
18760, 0.95833333333333, 0.85, 0.125
18761, 0.95833333333333, 0.9, 0.125
18762, 0.95833333333333, 0.95, 0.125
18763, 0.95833333333333, 1, 0.125
18764, 0.95833333333333, 1.05, 0.125
18765, 0.95833333333333, 1.1, 0.125
18766, 0.95833333333333, 1.15, 0.125
18767, 0.95833333333333, 1.2, 0.125
18768, 0.95833333333333, 1.25, 0.125
18769, 0.95833333333333, 1.3, 0.125
18770, 0.95833333333333, 0.2, 0.16666666666667
18771, 0.95833333333333, 0.25, 0.16666666666667
18772, 0.95833333333333, 0.3, 0.16666666666667
18773, 0.95833333333333, 0.35, 0.16666666666667
18774, 0.95833333333333, 0.4, 0.16666666666667
18775, 0.95833333333333, 0.45, 0.16666666666667
18776, 0.95833333333333, 0.5, 0.16666666666667
18777, 0.95833333333333, 0.55, 0.16666666666667
18778, 0.95833333333333, 0.6, 0.16666666666667
18779, 0.95833333333333, 0.65, 0.16666666666667
18780, 0.95833333333333, 0.7, 0.16666666666667
18781, 0.95833333333333, 0.75, 0.16666666666667
18782, 0.95833333333333, 0.8, 0.16666666666667
18783, 0.95833333333333, 0.85, 0.16666666666667
18784, 0.95833333333333, 0.9, 0.16666666666667
18785, 0.95833333333333, 0.95, 0.16666666666667
18786, 0.95833333333333, 1, 0.16666666666667
18787, 0.95833333333333, 1.05, 0.16666666666667
18788, 0.95833333333333, 1.1, 0.16666666666667
18789, 0.95833333333333, 1.15, 0.16666666666667
18790, 0.95833333333333, 1.2, 0.16666666666667
18791, 0.95833333333333, 1.25, 0.16666666666667
18792, 0.95833333333333, 1.3, 0.16666666666667
18793, 0.95833333333333, 0.2, 0.20833333333333
18794, 0.95833333333333, 0.25, 0.20833333333333
18795, 0.95833333333333, 0.3, 0.20833333333333
18796, 0.95833333333333, 0.35, 0.20833333333333
18797, 0.95833333333333, 0.4, 0.20833333333333
18798, 0.95833333333333, 0.45, 0.20833333333333
18799, 0.95833333333333, 0.5, 0.20833333333333
18800, 0.95833333333333, 0.55, 0.20833333333333
18801, 0.95833333333333, 0.6, 0.20833333333333
18802, 0.95833333333333, 0.65, 0.20833333333333
18803, 0.95833333333333, 0.7, 0.20833333333333
18804, 0.95833333333333, 0.75, 0.20833333333333
18805, 0.95833333333333, 0.8, 0.20833333333333
18806, 0.95833333333333, 0.85, 0.20833333333333
18807, 0.95833333333333, 0.9, 0.20833333333333
18808, 0.95833333333333, 0.95, 0.20833333333333
18809, 0.95833333333333, 1, 0.20833333333333
18810, 0.95833333333333, 1.05, 0.20833333333333
18811, 0.95833333333333, 1.1, 0.20833333333333
18812, 0.95833333333333, 1.15, 0.20833333333333
18813, 0.95833333333333, 1.2, 0.20833333333333
18814, 0.95833333333333, 1.25, 0.20833333333333
18815, 0.95833333333333, 1.3, 0.20833333333333
18816, 0.95833333333333, 0.2, 0.25
18817, 0.95833333333333, 0.25, 0.25
18818, 0.95833333333333, 0.3, 0.25
18819, 0.95833333333333, 0.35, 0.25
18820, 0.95833333333333, 0.4, 0.25
18821, 0.95833333333333, 0.45, 0.25
18822, 0.95833333333333, 0.5, 0.25
18823, 0.95833333333333, 0.55, 0.25
18824, 0.95833333333333, 0.6, 0.25
18825, 0.95833333333333, 0.65, 0.25
18826, 0.95833333333333, 0.7, 0.25
18827, 0.95833333333333, 0.75, 0.25
18828, 0.95833333333333, 0.8, 0.25
18829, 0.95833333333333, 0.85, 0.25
18830, 0.95833333333333, 0.9, 0.25
18831, 0.95833333333333, 0.95, 0.25
18832, 0.95833333333333, 1, 0.25
18833, 0.95833333333333, 1.05, 0.25
18834, 0.95833333333333, 1.1, 0.25
18835, 0.95833333333333, 1.15, 0.25
18836, 0.95833333333333, 1.2, 0.25
18837, 0.95833333333333, 1.25, 0.25
18838, 0.95833333333333, 1.3, 0.25
18839, 0.95833333333333, 0.2, 0.29166666666667
18840, 0.95833333333333, 0.25, 0.29166666666667
18841, 0.95833333333333, 0.3, 0.29166666666667
18842, 0.95833333333333, 0.35, 0.29166666666667
18843, 0.95833333333333, 0.4, 0.29166666666667
18844, 0.95833333333333, 0.45, 0.29166666666667
18845, 0.95833333333333, 0.5, 0.29166666666667
18846, 0.95833333333333, 0.55, 0.29166666666667
18847, 0.95833333333333, 0.6, 0.29166666666667
18848, 0.95833333333333, 0.65, 0.29166666666667
18849, 0.95833333333333, 0.7, 0.29166666666667
18850, 0.95833333333333, 0.75, 0.29166666666667
18851, 0.95833333333333, 0.8, 0.29166666666667
18852, 0.95833333333333, 0.85, 0.29166666666667
18853, 0.95833333333333, 0.9, 0.29166666666667
18854, 0.95833333333333, 0.95, 0.29166666666667
18855, 0.95833333333333, 1, 0.29166666666667
18856, 0.95833333333333, 1.05, 0.29166666666667
18857, 0.95833333333333, 1.1, 0.29166666666667
18858, 0.95833333333333, 1.15, 0.29166666666667
18859, 0.95833333333333, 1.2, 0.29166666666667
18860, 0.95833333333333, 1.25, 0.29166666666667
18861, 0.95833333333333, 1.3, 0.29166666666667
18862, 0.95833333333333, 0.2, 0.33333333333333
18863, 0.95833333333333, 0.25, 0.33333333333333
18864, 0.95833333333333, 0.3, 0.33333333333333
18865, 0.95833333333333, 0.35, 0.33333333333333
18866, 0.95833333333333, 0.4, 0.33333333333333
18867, 0.95833333333333, 0.45, 0.33333333333333
18868, 0.95833333333333, 0.5, 0.33333333333333
18869, 0.95833333333333, 0.55, 0.33333333333333
18870, 0.95833333333333, 0.6, 0.33333333333333
18871, 0.95833333333333, 0.65, 0.33333333333333
18872, 0.95833333333333, 0.7, 0.33333333333333
18873, 0.95833333333333, 0.75, 0.33333333333333
18874, 0.95833333333333, 0.8, 0.33333333333333
18875, 0.95833333333333, 0.85, 0.33333333333333
18876, 0.95833333333333, 0.9, 0.33333333333333
18877, 0.95833333333333, 0.95, 0.33333333333333
18878, 0.95833333333333, 1, 0.33333333333333
18879, 0.95833333333333, 1.05, 0.33333333333333
18880, 0.95833333333333, 1.1, 0.33333333333333
18881, 0.95833333333333, 1.15, 0.33333333333333
18882, 0.95833333333333, 1.2, 0.33333333333333
18883, 0.95833333333333, 1.25, 0.33333333333333
18884, 0.95833333333333, 1.3, 0.33333333333333
18885, 0.95833333333333, 0.2, 0.375
18886, 0.95833333333333, 0.25, 0.375
18887, 0.95833333333333, 0.3, 0.375
18888, 0.95833333333333, 0.35, 0.375
18889, 0.95833333333333, 0.4, 0.375
18890, 0.95833333333333, 0.45, 0.375
18891, 0.95833333333333, 0.5, 0.375
18892, 0.95833333333333, 0.55, 0.375
18893, 0.95833333333333, 0.6, 0.375
18894, 0.95833333333333, 0.65, 0.375
18895, 0.95833333333333, 0.7, 0.375
18896, 0.95833333333333, 0.75, 0.375
18897, 0.95833333333333, 0.8, 0.375
18898, 0.95833333333333, 0.85, 0.375
18899, 0.95833333333333, 0.9, 0.375
18900, 0.95833333333333, 0.95, 0.375
18901, 0.95833333333333, 1, 0.375
18902, 0.95833333333333, 1.05, 0.375
18903, 0.95833333333333, 1.1, 0.375
18904, 0.95833333333333, 1.15, 0.375
18905, 0.95833333333333, 1.2, 0.375
18906, 0.95833333333333, 1.25, 0.375
18907, 0.95833333333333, 1.3, 0.375
18908, 0.95833333333333, 0.2, 0.41666666666667
18909, 0.95833333333333, 0.25, 0.41666666666667
18910, 0.95833333333333, 0.3, 0.41666666666667
18911, 0.95833333333333, 0.35, 0.41666666666667
18912, 0.95833333333333, 0.4, 0.41666666666667
18913, 0.95833333333333, 0.45, 0.41666666666667
18914, 0.95833333333333, 0.5, 0.41666666666667
18915, 0.95833333333333, 0.55, 0.41666666666667
18916, 0.95833333333333, 0.6, 0.41666666666667
18917, 0.95833333333333, 0.65, 0.41666666666667
18918, 0.95833333333333, 0.7, 0.41666666666667
18919, 0.95833333333333, 0.75, 0.41666666666667
18920, 0.95833333333333, 0.8, 0.41666666666667
18921, 0.95833333333333, 0.85, 0.41666666666667
18922, 0.95833333333333, 0.9, 0.41666666666667
18923, 0.95833333333333, 0.95, 0.41666666666667
18924, 0.95833333333333, 1, 0.41666666666667
18925, 0.95833333333333, 1.05, 0.41666666666667
18926, 0.95833333333333, 1.1, 0.41666666666667
18927, 0.95833333333333, 1.15, 0.41666666666667
18928, 0.95833333333333, 1.2, 0.41666666666667
18929, 0.95833333333333, 1.25, 0.41666666666667
18930, 0.95833333333333, 1.3, 0.41666666666667
18931, 0.95833333333333, 0.2, 0.45833333333333
18932, 0.95833333333333, 0.25, 0.45833333333333
18933, 0.95833333333333, 0.3, 0.45833333333333
18934, 0.95833333333333, 0.35, 0.45833333333333
18935, 0.95833333333333, 0.4, 0.45833333333333
18936, 0.95833333333333, 0.45, 0.45833333333333
18937, 0.95833333333333, 0.5, 0.45833333333333
18938, 0.95833333333333, 0.55, 0.45833333333333
18939, 0.95833333333333, 0.6, 0.45833333333333
18940, 0.95833333333333, 0.65, 0.45833333333333
18941, 0.95833333333333, 0.7, 0.45833333333333
18942, 0.95833333333333, 0.75, 0.45833333333333
18943, 0.95833333333333, 0.8, 0.45833333333333
18944, 0.95833333333333, 0.85, 0.45833333333333
18945, 0.95833333333333, 0.9, 0.45833333333333
18946, 0.95833333333333, 0.95, 0.45833333333333
18947, 0.95833333333333, 1, 0.45833333333333
18948, 0.95833333333333, 1.05, 0.45833333333333
18949, 0.95833333333333, 1.1, 0.45833333333333
18950, 0.95833333333333, 1.15, 0.45833333333333
18951, 0.95833333333333, 1.2, 0.45833333333333
18952, 0.95833333333333, 1.25, 0.45833333333333
18953, 0.95833333333333, 1.3, 0.45833333333333
18954, 0.041666666666667, 1.4333333333333, 0.041666666666667
18955, 0.041666666666667, 1.4666666666667, 0.041666666666667
18956, 0.041666666666667, 1.4333333333333, 0.083333333333333
18957, 0.041666666666667, 1.4666666666667, 0.083333333333333
18958, 0.041666666666667, 1.4333333333333, 0.125
18959, 0.041666666666667, 1.4666666666667, 0.125
18960, 0.041666666666667, 1.4333333333333, 0.16666666666667
18961, 0.041666666666667, 1.4666666666667, 0.16666666666667
18962, 0.041666666666667, 1.4333333333333, 0.20833333333333
18963, 0.041666666666667, 1.4666666666667, 0.20833333333333
18964, 0.041666666666667, 1.4333333333333, 0.25
18965, 0.041666666666667, 1.4666666666667, 0.25
18966, 0.041666666666667, 1.4333333333333, 0.29166666666667
18967, 0.041666666666667, 1.4666666666667, 0.29166666666667
18968, 0.041666666666667, 1.4333333333333, 0.33333333333333
18969, 0.041666666666667, 1.4666666666667, 0.33333333333333
18970, 0.041666666666667, 1.4333333333333, 0.375
18971, 0.041666666666667, 1.4666666666667, 0.375
18972, 0.041666666666667, 1.4333333333333, 0.41666666666667
18973, 0.041666666666667, 1.4666666666667, 0.41666666666667
18974, 0.041666666666667, 1.4333333333333, 0.45833333333333
18975, 0.041666666666667, 1.4666666666667, 0.45833333333333
18976, 0.083333333333333, 1.4333333333333, 0.041666666666667
18977, 0.083333333333333, 1.4666666666667, 0.041666666666667
18978, 0.083333333333333, 1.4333333333333, 0.083333333333333
18979, 0.083333333333333, 1.4666666666667, 0.083333333333333
18980, 0.083333333333333, 1.4333333333333, 0.125
18981, 0.083333333333333, 1.4666666666667, 0.125
18982, 0.083333333333333, 1.4333333333333, 0.16666666666667
18983, 0.083333333333333, 1.4666666666667, 0.16666666666667
18984, 0.083333333333333, 1.4333333333333, 0.20833333333333
18985, 0.083333333333333, 1.4666666666667, 0.20833333333333
18986, 0.083333333333333, 1.4333333333333, 0.25
18987, 0.083333333333333, 1.4666666666667, 0.25
18988, 0.083333333333333, 1.4333333333333, 0.29166666666667
18989, 0.083333333333333, 1.4666666666667, 0.29166666666667
18990, 0.083333333333333, 1.4333333333333, 0.33333333333333
18991, 0.083333333333333, 1.4666666666667, 0.33333333333333
18992, 0.083333333333333, 1.4333333333333, 0.375
18993, 0.083333333333333, 1.4666666666667, 0.375
18994, 0.083333333333333, 1.4333333333333, 0.41666666666667
18995, 0.083333333333333, 1.4666666666667, 0.41666666666667
18996, 0.083333333333333, 1.4333333333333, 0.45833333333333
18997, 0.083333333333333, 1.4666666666667, 0.45833333333333
18998, 0.125, 1.4333333333333, 0.041666666666667
18999, 0.125, 1.4666666666667, 0.041666666666667
19000, 0.125, 1.4333333333333, 0.083333333333333
19001, 0.125, 1.4666666666667, 0.083333333333333
19002, 0.125, 1.4333333333333, 0.125
19003, 0.125, 1.4666666666667, 0.125
19004, 0.125, 1.4333333333333, 0.16666666666667
19005, 0.125, 1.4666666666667, 0.16666666666667
19006, 0.125, 1.4333333333333, 0.20833333333333
19007, 0.125, 1.4666666666667, 0.20833333333333
19008, 0.125, 1.4333333333333, 0.25
19009, 0.125, 1.4666666666667, 0.25
19010, 0.125, 1.4333333333333, 0.29166666666667
19011, 0.125, 1.4666666666667, 0.29166666666667
19012, 0.125, 1.4333333333333, 0.33333333333333
19013, 0.125, 1.4666666666667, 0.33333333333333
19014, 0.125, 1.4333333333333, 0.375
19015, 0.125, 1.4666666666667, 0.375
19016, 0.125, 1.4333333333333, 0.41666666666667
19017, 0.125, 1.4666666666667, 0.41666666666667
19018, 0.125, 1.4333333333333, 0.45833333333333
19019, 0.125, 1.4666666666667, 0.45833333333333
19020, 0.16666666666667, 1.4333333333333, 0.041666666666667
19021, 0.16666666666667, 1.4666666666667, 0.041666666666667
19022, 0.16666666666667, 1.4333333333333, 0.083333333333333
19023, 0.16666666666667, 1.4666666666667, 0.083333333333333
19024, 0.16666666666667, 1.4333333333333, 0.125
19025, 0.16666666666667, 1.4666666666667, 0.125
19026, 0.16666666666667, 1.4333333333333, 0.16666666666667
19027, 0.16666666666667, 1.4666666666667, 0.16666666666667
19028, 0.16666666666667, 1.4333333333333, 0.20833333333333
19029, 0.16666666666667, 1.4666666666667, 0.20833333333333
19030, 0.16666666666667, 1.4333333333333, 0.25
19031, 0.16666666666667, 1.4666666666667, 0.25
19032, 0.16666666666667, 1.4333333333333, 0.29166666666667
19033, 0.16666666666667, 1.4666666666667, 0.29166666666667
19034, 0.16666666666667, 1.4333333333333, 0.33333333333333
19035, 0.16666666666667, 1.4666666666667, 0.33333333333333
19036, 0.16666666666667, 1.4333333333333, 0.375
19037, 0.16666666666667, 1.4666666666667, 0.375
19038, 0.16666666666667, 1.4333333333333, 0.41666666666667
19039, 0.16666666666667, 1.4666666666667, 0.41666666666667
19040, 0.16666666666667, 1.4333333333333, 0.45833333333333
19041, 0.16666666666667, 1.4666666666667, 0.45833333333333
19042, 0.20833333333333, 1.4333333333333, 0.041666666666667
19043, 0.20833333333333, 1.4666666666667, 0.041666666666667
19044, 0.20833333333333, 1.4333333333333, 0.083333333333333
19045, 0.20833333333333, 1.4666666666667, 0.083333333333333
19046, 0.20833333333333, 1.4333333333333, 0.125
19047, 0.20833333333333, 1.4666666666667, 0.125
19048, 0.20833333333333, 1.4333333333333, 0.16666666666667
19049, 0.20833333333333, 1.4666666666667, 0.16666666666667
19050, 0.20833333333333, 1.4333333333333, 0.20833333333333
19051, 0.20833333333333, 1.4666666666667, 0.20833333333333
19052, 0.20833333333333, 1.4333333333333, 0.25
19053, 0.20833333333333, 1.4666666666667, 0.25
19054, 0.20833333333333, 1.4333333333333, 0.29166666666667
19055, 0.20833333333333, 1.4666666666667, 0.29166666666667
19056, 0.20833333333333, 1.4333333333333, 0.33333333333333
19057, 0.20833333333333, 1.4666666666667, 0.33333333333333
19058, 0.20833333333333, 1.4333333333333, 0.375
19059, 0.20833333333333, 1.4666666666667, 0.375
19060, 0.20833333333333, 1.4333333333333, 0.41666666666667
19061, 0.20833333333333, 1.4666666666667, 0.41666666666667
19062, 0.20833333333333, 1.4333333333333, 0.45833333333333
19063, 0.20833333333333, 1.4666666666667, 0.45833333333333
19064, 0.25, 1.4333333333333, 0.041666666666667
19065, 0.25, 1.4666666666667, 0.041666666666667
19066, 0.25, 1.4333333333333, 0.083333333333333
19067, 0.25, 1.4666666666667, 0.083333333333333
19068, 0.25, 1.4333333333333, 0.125
19069, 0.25, 1.4666666666667, 0.125
19070, 0.25, 1.4333333333333, 0.16666666666667
19071, 0.25, 1.4666666666667, 0.16666666666667
19072, 0.25, 1.4333333333333, 0.20833333333333
19073, 0.25, 1.4666666666667, 0.20833333333333
19074, 0.25, 1.4333333333333, 0.25
19075, 0.25, 1.4666666666667, 0.25
19076, 0.25, 1.4333333333333, 0.29166666666667
19077, 0.25, 1.4666666666667, 0.29166666666667
19078, 0.25, 1.4333333333333, 0.33333333333333
19079, 0.25, 1.4666666666667, 0.33333333333333
19080, 0.25, 1.4333333333333, 0.375
19081, 0.25, 1.4666666666667, 0.375
19082, 0.25, 1.4333333333333, 0.41666666666667
19083, 0.25, 1.4666666666667, 0.41666666666667
19084, 0.25, 1.4333333333333, 0.45833333333333
19085, 0.25, 1.4666666666667, 0.45833333333333
19086, 0.29166666666667, 1.4333333333333, 0.041666666666667
19087, 0.29166666666667, 1.4666666666667, 0.041666666666667
19088, 0.29166666666667, 1.4333333333333, 0.083333333333333
19089, 0.29166666666667, 1.4666666666667, 0.083333333333333
19090, 0.29166666666667, 1.4333333333333, 0.125
19091, 0.29166666666667, 1.4666666666667, 0.125
19092, 0.29166666666667, 1.4333333333333, 0.16666666666667
19093, 0.29166666666667, 1.4666666666667, 0.16666666666667
19094, 0.29166666666667, 1.4333333333333, 0.20833333333333
19095, 0.29166666666667, 1.4666666666667, 0.20833333333333
19096, 0.29166666666667, 1.4333333333333, 0.25
19097, 0.29166666666667, 1.4666666666667, 0.25
19098, 0.29166666666667, 1.4333333333333, 0.29166666666667
19099, 0.29166666666667, 1.4666666666667, 0.29166666666667
19100, 0.29166666666667, 1.4333333333333, 0.33333333333333
19101, 0.29166666666667, 1.4666666666667, 0.33333333333333
19102, 0.29166666666667, 1.4333333333333, 0.375
19103, 0.29166666666667, 1.4666666666667, 0.375
19104, 0.29166666666667, 1.4333333333333, 0.41666666666667
19105, 0.29166666666667, 1.4666666666667, 0.41666666666667
19106, 0.29166666666667, 1.4333333333333, 0.45833333333333
19107, 0.29166666666667, 1.4666666666667, 0.45833333333333
19108, 0.33333333333333, 1.4333333333333, 0.041666666666667
19109, 0.33333333333333, 1.4666666666667, 0.041666666666667
19110, 0.33333333333333, 1.4333333333333, 0.083333333333333
19111, 0.33333333333333, 1.4666666666667, 0.083333333333333
19112, 0.33333333333333, 1.4333333333333, 0.125
19113, 0.33333333333333, 1.4666666666667, 0.125
19114, 0.33333333333333, 1.4333333333333, 0.16666666666667
19115, 0.33333333333333, 1.4666666666667, 0.16666666666667
19116, 0.33333333333333, 1.4333333333333, 0.20833333333333
19117, 0.33333333333333, 1.4666666666667, 0.20833333333333
19118, 0.33333333333333, 1.4333333333333, 0.25
19119, 0.33333333333333, 1.4666666666667, 0.25
19120, 0.33333333333333, 1.4333333333333, 0.29166666666667
19121, 0.33333333333333, 1.4666666666667, 0.29166666666667
19122, 0.33333333333333, 1.4333333333333, 0.33333333333333
19123, 0.33333333333333, 1.4666666666667, 0.33333333333333
19124, 0.33333333333333, 1.4333333333333, 0.375
19125, 0.33333333333333, 1.4666666666667, 0.375
19126, 0.33333333333333, 1.4333333333333, 0.41666666666667
19127, 0.33333333333333, 1.4666666666667, 0.41666666666667
19128, 0.33333333333333, 1.4333333333333, 0.45833333333333
19129, 0.33333333333333, 1.4666666666667, 0.45833333333333
19130, 0.375, 1.4333333333333, 0.041666666666667
19131, 0.375, 1.4666666666667, 0.041666666666667
19132, 0.375, 1.4333333333333, 0.083333333333333
19133, 0.375, 1.4666666666667, 0.083333333333333
19134, 0.375, 1.4333333333333, 0.125
19135, 0.375, 1.4666666666667, 0.125
19136, 0.375, 1.4333333333333, 0.16666666666667
19137, 0.375, 1.4666666666667, 0.16666666666667
19138, 0.375, 1.4333333333333, 0.20833333333333
19139, 0.375, 1.4666666666667, 0.20833333333333
19140, 0.375, 1.4333333333333, 0.25
19141, 0.375, 1.4666666666667, 0.25
19142, 0.375, 1.4333333333333, 0.29166666666667
19143, 0.375, 1.4666666666667, 0.29166666666667
19144, 0.375, 1.4333333333333, 0.33333333333333
19145, 0.375, 1.4666666666667, 0.33333333333333
19146, 0.375, 1.4333333333333, 0.375
19147, 0.375, 1.4666666666667, 0.375
19148, 0.375, 1.4333333333333, 0.41666666666667
19149, 0.375, 1.4666666666667, 0.41666666666667
19150, 0.375, 1.4333333333333, 0.45833333333333
19151, 0.375, 1.4666666666667, 0.45833333333333
19152, 0.41666666666667, 1.4333333333333, 0.041666666666667
19153, 0.41666666666667, 1.4666666666667, 0.041666666666667
19154, 0.41666666666667, 1.4333333333333, 0.083333333333333
19155, 0.41666666666667, 1.4666666666667, 0.083333333333333
19156, 0.41666666666667, 1.4333333333333, 0.125
19157, 0.41666666666667, 1.4666666666667, 0.125
19158, 0.41666666666667, 1.4333333333333, 0.16666666666667
19159, 0.41666666666667, 1.4666666666667, 0.16666666666667
19160, 0.41666666666667, 1.4333333333333, 0.20833333333333
19161, 0.41666666666667, 1.4666666666667, 0.20833333333333
19162, 0.41666666666667, 1.4333333333333, 0.25
19163, 0.41666666666667, 1.4666666666667, 0.25
19164, 0.41666666666667, 1.4333333333333, 0.29166666666667
19165, 0.41666666666667, 1.4666666666667, 0.29166666666667
19166, 0.41666666666667, 1.4333333333333, 0.33333333333333
19167, 0.41666666666667, 1.4666666666667, 0.33333333333333
19168, 0.41666666666667, 1.4333333333333, 0.375
19169, 0.41666666666667, 1.4666666666667, 0.375
19170, 0.41666666666667, 1.4333333333333, 0.41666666666667
19171, 0.41666666666667, 1.4666666666667, 0.41666666666667
19172, 0.41666666666667, 1.4333333333333, 0.45833333333333
19173, 0.41666666666667, 1.4666666666667, 0.45833333333333
