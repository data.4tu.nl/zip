19174, 0.45833333333333, 1.4333333333333, 0.041666666666667
19175, 0.45833333333333, 1.4666666666667, 0.041666666666667
19176, 0.45833333333333, 1.4333333333333, 0.083333333333333
19177, 0.45833333333333, 1.4666666666667, 0.083333333333333
19178, 0.45833333333333, 1.4333333333333, 0.125
19179, 0.45833333333333, 1.4666666666667, 0.125
19180, 0.45833333333333, 1.4333333333333, 0.16666666666667
19181, 0.45833333333333, 1.4666666666667, 0.16666666666667
19182, 0.45833333333333, 1.4333333333333, 0.20833333333333
19183, 0.45833333333333, 1.4666666666667, 0.20833333333333
19184, 0.45833333333333, 1.4333333333333, 0.25
19185, 0.45833333333333, 1.4666666666667, 0.25
19186, 0.45833333333333, 1.4333333333333, 0.29166666666667
19187, 0.45833333333333, 1.4666666666667, 0.29166666666667
19188, 0.45833333333333, 1.4333333333333, 0.33333333333333
19189, 0.45833333333333, 1.4666666666667, 0.33333333333333
19190, 0.45833333333333, 1.4333333333333, 0.375
19191, 0.45833333333333, 1.4666666666667, 0.375
19192, 0.45833333333333, 1.4333333333333, 0.41666666666667
19193, 0.45833333333333, 1.4666666666667, 0.41666666666667
19194, 0.45833333333333, 1.4333333333333, 0.45833333333333
19195, 0.45833333333333, 1.4666666666667, 0.45833333333333
19196, 0.5, 1.4333333333333, 0.041666666666667
19197, 0.5, 1.4666666666667, 0.041666666666667
19198, 0.5, 1.4333333333333, 0.083333333333333
19199, 0.5, 1.4666666666667, 0.083333333333333
19200, 0.5, 1.4333333333333, 0.125
19201, 0.5, 1.4666666666667, 0.125
19202, 0.5, 1.4333333333333, 0.16666666666667
19203, 0.5, 1.4666666666667, 0.16666666666667
19204, 0.5, 1.4333333333333, 0.20833333333333
19205, 0.5, 1.4666666666667, 0.20833333333333
19206, 0.5, 1.4333333333333, 0.25
19207, 0.5, 1.4666666666667, 0.25
19208, 0.5, 1.4333333333333, 0.29166666666667
19209, 0.5, 1.4666666666667, 0.29166666666667
19210, 0.5, 1.4333333333333, 0.33333333333333
19211, 0.5, 1.4666666666667, 0.33333333333333
19212, 0.5, 1.4333333333333, 0.375
19213, 0.5, 1.4666666666667, 0.375
19214, 0.5, 1.4333333333333, 0.41666666666667
19215, 0.5, 1.4666666666667, 0.41666666666667
19216, 0.5, 1.4333333333333, 0.45833333333333
19217, 0.5, 1.4666666666667, 0.45833333333333
19218, 0.54166666666667, 1.4333333333333, 0.041666666666667
19219, 0.54166666666667, 1.4666666666667, 0.041666666666667
19220, 0.54166666666667, 1.4333333333333, 0.083333333333333
19221, 0.54166666666667, 1.4666666666667, 0.083333333333333
19222, 0.54166666666667, 1.4333333333333, 0.125
19223, 0.54166666666667, 1.4666666666667, 0.125
19224, 0.54166666666667, 1.4333333333333, 0.16666666666667
19225, 0.54166666666667, 1.4666666666667, 0.16666666666667
19226, 0.54166666666667, 1.4333333333333, 0.20833333333333
19227, 0.54166666666667, 1.4666666666667, 0.20833333333333
19228, 0.54166666666667, 1.4333333333333, 0.25
19229, 0.54166666666667, 1.4666666666667, 0.25
19230, 0.54166666666667, 1.4333333333333, 0.29166666666667
19231, 0.54166666666667, 1.4666666666667, 0.29166666666667
19232, 0.54166666666667, 1.4333333333333, 0.33333333333333
19233, 0.54166666666667, 1.4666666666667, 0.33333333333333
19234, 0.54166666666667, 1.4333333333333, 0.375
19235, 0.54166666666667, 1.4666666666667, 0.375
19236, 0.54166666666667, 1.4333333333333, 0.41666666666667
19237, 0.54166666666667, 1.4666666666667, 0.41666666666667
19238, 0.54166666666667, 1.4333333333333, 0.45833333333333
19239, 0.54166666666667, 1.4666666666667, 0.45833333333333
19240, 0.58333333333333, 1.4333333333333, 0.041666666666667
19241, 0.58333333333333, 1.4666666666667, 0.041666666666667
19242, 0.58333333333333, 1.4333333333333, 0.083333333333333
19243, 0.58333333333333, 1.4666666666667, 0.083333333333333
19244, 0.58333333333333, 1.4333333333333, 0.125
19245, 0.58333333333333, 1.4666666666667, 0.125
19246, 0.58333333333333, 1.4333333333333, 0.16666666666667
19247, 0.58333333333333, 1.4666666666667, 0.16666666666667
19248, 0.58333333333333, 1.4333333333333, 0.20833333333333
19249, 0.58333333333333, 1.4666666666667, 0.20833333333333
19250, 0.58333333333333, 1.4333333333333, 0.25
19251, 0.58333333333333, 1.4666666666667, 0.25
19252, 0.58333333333333, 1.4333333333333, 0.29166666666667
19253, 0.58333333333333, 1.4666666666667, 0.29166666666667
19254, 0.58333333333333, 1.4333333333333, 0.33333333333333
19255, 0.58333333333333, 1.4666666666667, 0.33333333333333
19256, 0.58333333333333, 1.4333333333333, 0.375
19257, 0.58333333333333, 1.4666666666667, 0.375
19258, 0.58333333333333, 1.4333333333333, 0.41666666666667
19259, 0.58333333333333, 1.4666666666667, 0.41666666666667
19260, 0.58333333333333, 1.4333333333333, 0.45833333333333
19261, 0.58333333333333, 1.4666666666667, 0.45833333333333
19262, 0.625, 1.4333333333333, 0.041666666666667
19263, 0.625, 1.4666666666667, 0.041666666666667
19264, 0.625, 1.4333333333333, 0.083333333333333
19265, 0.625, 1.4666666666667, 0.083333333333333
19266, 0.625, 1.4333333333333, 0.125
19267, 0.625, 1.4666666666667, 0.125
19268, 0.625, 1.4333333333333, 0.16666666666667
19269, 0.625, 1.4666666666667, 0.16666666666667
19270, 0.625, 1.4333333333333, 0.20833333333333
19271, 0.625, 1.4666666666667, 0.20833333333333
19272, 0.625, 1.4333333333333, 0.25
19273, 0.625, 1.4666666666667, 0.25
19274, 0.625, 1.4333333333333, 0.29166666666667
19275, 0.625, 1.4666666666667, 0.29166666666667
19276, 0.625, 1.4333333333333, 0.33333333333333
19277, 0.625, 1.4666666666667, 0.33333333333333
19278, 0.625, 1.4333333333333, 0.375
19279, 0.625, 1.4666666666667, 0.375
19280, 0.625, 1.4333333333333, 0.41666666666667
19281, 0.625, 1.4666666666667, 0.41666666666667
19282, 0.625, 1.4333333333333, 0.45833333333333
19283, 0.625, 1.4666666666667, 0.45833333333333
19284, 0.66666666666667, 1.4333333333333, 0.041666666666667
19285, 0.66666666666667, 1.4666666666667, 0.041666666666667
19286, 0.66666666666667, 1.4333333333333, 0.083333333333333
19287, 0.66666666666667, 1.4666666666667, 0.083333333333333
19288, 0.66666666666667, 1.4333333333333, 0.125
19289, 0.66666666666667, 1.4666666666667, 0.125
19290, 0.66666666666667, 1.4333333333333, 0.16666666666667
19291, 0.66666666666667, 1.4666666666667, 0.16666666666667
19292, 0.66666666666667, 1.4333333333333, 0.20833333333333
19293, 0.66666666666667, 1.4666666666667, 0.20833333333333
19294, 0.66666666666667, 1.4333333333333, 0.25
19295, 0.66666666666667, 1.4666666666667, 0.25
19296, 0.66666666666667, 1.4333333333333, 0.29166666666667
19297, 0.66666666666667, 1.4666666666667, 0.29166666666667
19298, 0.66666666666667, 1.4333333333333, 0.33333333333333
19299, 0.66666666666667, 1.4666666666667, 0.33333333333333
19300, 0.66666666666667, 1.4333333333333, 0.375
19301, 0.66666666666667, 1.4666666666667, 0.375
19302, 0.66666666666667, 1.4333333333333, 0.41666666666667
19303, 0.66666666666667, 1.4666666666667, 0.41666666666667
19304, 0.66666666666667, 1.4333333333333, 0.45833333333333
19305, 0.66666666666667, 1.4666666666667, 0.45833333333333
19306, 0.70833333333333, 1.4333333333333, 0.041666666666667
19307, 0.70833333333333, 1.4666666666667, 0.041666666666667
19308, 0.70833333333333, 1.4333333333333, 0.083333333333333
19309, 0.70833333333333, 1.4666666666667, 0.083333333333333
19310, 0.70833333333333, 1.4333333333333, 0.125
19311, 0.70833333333333, 1.4666666666667, 0.125
19312, 0.70833333333333, 1.4333333333333, 0.16666666666667
19313, 0.70833333333333, 1.4666666666667, 0.16666666666667
19314, 0.70833333333333, 1.4333333333333, 0.20833333333333
19315, 0.70833333333333, 1.4666666666667, 0.20833333333333
19316, 0.70833333333333, 1.4333333333333, 0.25
19317, 0.70833333333333, 1.4666666666667, 0.25
19318, 0.70833333333333, 1.4333333333333, 0.29166666666667
19319, 0.70833333333333, 1.4666666666667, 0.29166666666667
19320, 0.70833333333333, 1.4333333333333, 0.33333333333333
19321, 0.70833333333333, 1.4666666666667, 0.33333333333333
19322, 0.70833333333333, 1.4333333333333, 0.375
19323, 0.70833333333333, 1.4666666666667, 0.375
19324, 0.70833333333333, 1.4333333333333, 0.41666666666667
19325, 0.70833333333333, 1.4666666666667, 0.41666666666667
19326, 0.70833333333333, 1.4333333333333, 0.45833333333333
19327, 0.70833333333333, 1.4666666666667, 0.45833333333333
19328, 0.75, 1.4333333333333, 0.041666666666667
19329, 0.75, 1.4666666666667, 0.041666666666667
19330, 0.75, 1.4333333333333, 0.083333333333333
19331, 0.75, 1.4666666666667, 0.083333333333333
19332, 0.75, 1.4333333333333, 0.125
19333, 0.75, 1.4666666666667, 0.125
19334, 0.75, 1.4333333333333, 0.16666666666667
19335, 0.75, 1.4666666666667, 0.16666666666667
19336, 0.75, 1.4333333333333, 0.20833333333333
19337, 0.75, 1.4666666666667, 0.20833333333333
19338, 0.75, 1.4333333333333, 0.25
19339, 0.75, 1.4666666666667, 0.25
19340, 0.75, 1.4333333333333, 0.29166666666667
19341, 0.75, 1.4666666666667, 0.29166666666667
19342, 0.75, 1.4333333333333, 0.33333333333333
19343, 0.75, 1.4666666666667, 0.33333333333333
19344, 0.75, 1.4333333333333, 0.375
19345, 0.75, 1.4666666666667, 0.375
19346, 0.75, 1.4333333333333, 0.41666666666667
19347, 0.75, 1.4666666666667, 0.41666666666667
19348, 0.75, 1.4333333333333, 0.45833333333333
19349, 0.75, 1.4666666666667, 0.45833333333333
19350, 0.79166666666667, 1.4333333333333, 0.041666666666667
19351, 0.79166666666667, 1.4666666666667, 0.041666666666667
19352, 0.79166666666667, 1.4333333333333, 0.083333333333333
19353, 0.79166666666667, 1.4666666666667, 0.083333333333333
19354, 0.79166666666667, 1.4333333333333, 0.125
19355, 0.79166666666667, 1.4666666666667, 0.125
19356, 0.79166666666667, 1.4333333333333, 0.16666666666667
19357, 0.79166666666667, 1.4666666666667, 0.16666666666667
19358, 0.79166666666667, 1.4333333333333, 0.20833333333333
19359, 0.79166666666667, 1.4666666666667, 0.20833333333333
19360, 0.79166666666667, 1.4333333333333, 0.25
19361, 0.79166666666667, 1.4666666666667, 0.25
19362, 0.79166666666667, 1.4333333333333, 0.29166666666667
19363, 0.79166666666667, 1.4666666666667, 0.29166666666667
19364, 0.79166666666667, 1.4333333333333, 0.33333333333333
19365, 0.79166666666667, 1.4666666666667, 0.33333333333333
19366, 0.79166666666667, 1.4333333333333, 0.375
19367, 0.79166666666667, 1.4666666666667, 0.375
19368, 0.79166666666667, 1.4333333333333, 0.41666666666667
19369, 0.79166666666667, 1.4666666666667, 0.41666666666667
19370, 0.79166666666667, 1.4333333333333, 0.45833333333333
19371, 0.79166666666667, 1.4666666666667, 0.45833333333333
19372, 0.83333333333333, 1.4333333333333, 0.041666666666667
19373, 0.83333333333333, 1.4666666666667, 0.041666666666667
19374, 0.83333333333333, 1.4333333333333, 0.083333333333333
19375, 0.83333333333333, 1.4666666666667, 0.083333333333333
19376, 0.83333333333333, 1.4333333333333, 0.125
19377, 0.83333333333333, 1.4666666666667, 0.125
19378, 0.83333333333333, 1.4333333333333, 0.16666666666667
19379, 0.83333333333333, 1.4666666666667, 0.16666666666667
19380, 0.83333333333333, 1.4333333333333, 0.20833333333333
19381, 0.83333333333333, 1.4666666666667, 0.20833333333333
19382, 0.83333333333333, 1.4333333333333, 0.25
19383, 0.83333333333333, 1.4666666666667, 0.25
19384, 0.83333333333333, 1.4333333333333, 0.29166666666667
19385, 0.83333333333333, 1.4666666666667, 0.29166666666667
19386, 0.83333333333333, 1.4333333333333, 0.33333333333333
19387, 0.83333333333333, 1.4666666666667, 0.33333333333333
19388, 0.83333333333333, 1.4333333333333, 0.375
19389, 0.83333333333333, 1.4666666666667, 0.375
19390, 0.83333333333333, 1.4333333333333, 0.41666666666667
19391, 0.83333333333333, 1.4666666666667, 0.41666666666667
19392, 0.83333333333333, 1.4333333333333, 0.45833333333333
19393, 0.83333333333333, 1.4666666666667, 0.45833333333333
19394, 0.875, 1.4333333333333, 0.041666666666667
19395, 0.875, 1.4666666666667, 0.041666666666667
19396, 0.875, 1.4333333333333, 0.083333333333333
19397, 0.875, 1.4666666666667, 0.083333333333333
19398, 0.875, 1.4333333333333, 0.125
19399, 0.875, 1.4666666666667, 0.125
19400, 0.875, 1.4333333333333, 0.16666666666667
19401, 0.875, 1.4666666666667, 0.16666666666667
19402, 0.875, 1.4333333333333, 0.20833333333333
19403, 0.875, 1.4666666666667, 0.20833333333333
19404, 0.875, 1.4333333333333, 0.25
19405, 0.875, 1.4666666666667, 0.25
19406, 0.875, 1.4333333333333, 0.29166666666667
19407, 0.875, 1.4666666666667, 0.29166666666667
19408, 0.875, 1.4333333333333, 0.33333333333333
19409, 0.875, 1.4666666666667, 0.33333333333333
19410, 0.875, 1.4333333333333, 0.375
19411, 0.875, 1.4666666666667, 0.375
19412, 0.875, 1.4333333333333, 0.41666666666667
19413, 0.875, 1.4666666666667, 0.41666666666667
19414, 0.875, 1.4333333333333, 0.45833333333333
19415, 0.875, 1.4666666666667, 0.45833333333333
19416, 0.91666666666667, 1.4333333333333, 0.041666666666667
19417, 0.91666666666667, 1.4666666666667, 0.041666666666667
19418, 0.91666666666667, 1.4333333333333, 0.083333333333333
19419, 0.91666666666667, 1.4666666666667, 0.083333333333333
19420, 0.91666666666667, 1.4333333333333, 0.125
19421, 0.91666666666667, 1.4666666666667, 0.125
19422, 0.91666666666667, 1.4333333333333, 0.16666666666667
19423, 0.91666666666667, 1.4666666666667, 0.16666666666667
19424, 0.91666666666667, 1.4333333333333, 0.20833333333333
19425, 0.91666666666667, 1.4666666666667, 0.20833333333333
19426, 0.91666666666667, 1.4333333333333, 0.25
19427, 0.91666666666667, 1.4666666666667, 0.25
19428, 0.91666666666667, 1.4333333333333, 0.29166666666667
19429, 0.91666666666667, 1.4666666666667, 0.29166666666667
19430, 0.91666666666667, 1.4333333333333, 0.33333333333333
19431, 0.91666666666667, 1.4666666666667, 0.33333333333333
19432, 0.91666666666667, 1.4333333333333, 0.375
19433, 0.91666666666667, 1.4666666666667, 0.375
19434, 0.91666666666667, 1.4333333333333, 0.41666666666667
19435, 0.91666666666667, 1.4666666666667, 0.41666666666667
19436, 0.91666666666667, 1.4333333333333, 0.45833333333333
19437, 0.91666666666667, 1.4666666666667, 0.45833333333333
19438, 0.95833333333333, 1.4333333333333, 0.041666666666667
19439, 0.95833333333333, 1.4666666666667, 0.041666666666667
19440, 0.95833333333333, 1.4333333333333, 0.083333333333333
19441, 0.95833333333333, 1.4666666666667, 0.083333333333333
19442, 0.95833333333333, 1.4333333333333, 0.125
19443, 0.95833333333333, 1.4666666666667, 0.125
19444, 0.95833333333333, 1.4333333333333, 0.16666666666667
19445, 0.95833333333333, 1.4666666666667, 0.16666666666667
19446, 0.95833333333333, 1.4333333333333, 0.20833333333333
19447, 0.95833333333333, 1.4666666666667, 0.20833333333333
19448, 0.95833333333333, 1.4333333333333, 0.25
19449, 0.95833333333333, 1.4666666666667, 0.25
19450, 0.95833333333333, 1.4333333333333, 0.29166666666667
19451, 0.95833333333333, 1.4666666666667, 0.29166666666667
19452, 0.95833333333333, 1.4333333333333, 0.33333333333333
19453, 0.95833333333333, 1.4666666666667, 0.33333333333333
19454, 0.95833333333333, 1.4333333333333, 0.375
19455, 0.95833333333333, 1.4666666666667, 0.375
19456, 0.95833333333333, 1.4333333333333, 0.41666666666667
19457, 0.95833333333333, 1.4666666666667, 0.41666666666667
19458, 0.95833333333333, 1.4333333333333, 0.45833333333333
19459, 0.95833333333333, 1.4666666666667, 0.45833333333333
19460, 1.04, 1.4333333333333, 0.041666666666667
19461, 1.08, 1.4333333333333, 0.041666666666667
19462, 1.12, 1.4333333333333, 0.041666666666667
19463, 1.16, 1.4333333333333, 0.041666666666667
19464, 1.04, 1.4666666666667, 0.041666666666667
19465, 1.08, 1.4666666666667, 0.041666666666667
19466, 1.12, 1.4666666666667, 0.041666666666667
19467, 1.16, 1.4666666666667, 0.041666666666667
19468, 1.04, 1.4333333333333, 0.083333333333333
19469, 1.08, 1.4333333333333, 0.083333333333333
19470, 1.12, 1.4333333333333, 0.083333333333333
19471, 1.16, 1.4333333333333, 0.083333333333333
19472, 1.04, 1.4666666666667, 0.083333333333333
19473, 1.08, 1.4666666666667, 0.083333333333333
19474, 1.12, 1.4666666666667, 0.083333333333333
19475, 1.16, 1.4666666666667, 0.083333333333333
19476, 1.04, 1.4333333333333, 0.125
19477, 1.08, 1.4333333333333, 0.125
19478, 1.12, 1.4333333333333, 0.125
19479, 1.16, 1.4333333333333, 0.125
19480, 1.04, 1.4666666666667, 0.125
19481, 1.08, 1.4666666666667, 0.125
19482, 1.12, 1.4666666666667, 0.125
19483, 1.16, 1.4666666666667, 0.125
19484, 1.04, 1.4333333333333, 0.16666666666667
19485, 1.08, 1.4333333333333, 0.16666666666667
19486, 1.12, 1.4333333333333, 0.16666666666667
19487, 1.16, 1.4333333333333, 0.16666666666667
19488, 1.04, 1.4666666666667, 0.16666666666667
19489, 1.08, 1.4666666666667, 0.16666666666667
19490, 1.12, 1.4666666666667, 0.16666666666667
19491, 1.16, 1.4666666666667, 0.16666666666667
19492, 1.04, 1.4333333333333, 0.20833333333333
19493, 1.08, 1.4333333333333, 0.20833333333333
19494, 1.12, 1.4333333333333, 0.20833333333333
19495, 1.16, 1.4333333333333, 0.20833333333333
19496, 1.04, 1.4666666666667, 0.20833333333333
19497, 1.08, 1.4666666666667, 0.20833333333333
19498, 1.12, 1.4666666666667, 0.20833333333333
19499, 1.16, 1.4666666666667, 0.20833333333333
19500, 1.04, 1.4333333333333, 0.25
19501, 1.08, 1.4333333333333, 0.25
19502, 1.12, 1.4333333333333, 0.25
19503, 1.16, 1.4333333333333, 0.25
19504, 1.04, 1.4666666666667, 0.25
19505, 1.08, 1.4666666666667, 0.25
19506, 1.12, 1.4666666666667, 0.25
19507, 1.16, 1.4666666666667, 0.25
19508, 1.04, 1.4333333333333, 0.29166666666667
19509, 1.08, 1.4333333333333, 0.29166666666667
19510, 1.12, 1.4333333333333, 0.29166666666667
19511, 1.16, 1.4333333333333, 0.29166666666667
19512, 1.04, 1.4666666666667, 0.29166666666667
19513, 1.08, 1.4666666666667, 0.29166666666667
19514, 1.12, 1.4666666666667, 0.29166666666667
19515, 1.16, 1.4666666666667, 0.29166666666667
19516, 1.04, 1.4333333333333, 0.33333333333333
19517, 1.08, 1.4333333333333, 0.33333333333333
19518, 1.12, 1.4333333333333, 0.33333333333333
19519, 1.16, 1.4333333333333, 0.33333333333333
19520, 1.04, 1.4666666666667, 0.33333333333333
19521, 1.08, 1.4666666666667, 0.33333333333333
19522, 1.12, 1.4666666666667, 0.33333333333333
19523, 1.16, 1.4666666666667, 0.33333333333333
19524, 1.04, 1.4333333333333, 0.375
19525, 1.08, 1.4333333333333, 0.375
19526, 1.12, 1.4333333333333, 0.375
19527, 1.16, 1.4333333333333, 0.375
19528, 1.04, 1.4666666666667, 0.375
19529, 1.08, 1.4666666666667, 0.375
19530, 1.12, 1.4666666666667, 0.375
19531, 1.16, 1.4666666666667, 0.375
19532, 1.04, 1.4333333333333, 0.41666666666667
19533, 1.08, 1.4333333333333, 0.41666666666667
19534, 1.12, 1.4333333333333, 0.41666666666667
19535, 1.16, 1.4333333333333, 0.41666666666667
19536, 1.04, 1.4666666666667, 0.41666666666667
19537, 1.08, 1.4666666666667, 0.41666666666667
19538, 1.12, 1.4666666666667, 0.41666666666667
19539, 1.16, 1.4666666666667, 0.41666666666667
19540, 1.04, 1.4333333333333, 0.45833333333333
19541, 1.08, 1.4333333333333, 0.45833333333333
19542, 1.12, 1.4333333333333, 0.45833333333333
19543, 1.16, 1.4333333333333, 0.45833333333333
19544, 1.04, 1.4666666666667, 0.45833333333333
19545, 1.08, 1.4666666666667, 0.45833333333333
19546, 1.12, 1.4666666666667, 0.45833333333333
19547, 1.16, 1.4666666666667, 0.45833333333333
19548, 1.2416666666667, 1.4333333333333, 0.041666666666667
19549, 1.2833333333333, 1.4333333333333, 0.041666666666667
19550, 1.325, 1.4333333333333, 0.041666666666667
19551, 1.3666666666667, 1.4333333333333, 0.041666666666667
19552, 1.4083333333333, 1.4333333333333, 0.041666666666667
19553, 1.45, 1.4333333333333, 0.041666666666667
19554, 1.4916666666667, 1.4333333333333, 0.041666666666667
19555, 1.5333333333333, 1.4333333333333, 0.041666666666667
19556, 1.575, 1.4333333333333, 0.041666666666667
19557, 1.6166666666667, 1.4333333333333, 0.041666666666667
19558, 1.6583333333333, 1.4333333333333, 0.041666666666667
19559, 1.7, 1.4333333333333, 0.041666666666667
19560, 1.7416666666667, 1.4333333333333, 0.041666666666667
19561, 1.7833333333333, 1.4333333333333, 0.041666666666667
19562, 1.825, 1.4333333333333, 0.041666666666667
19563, 1.8666666666667, 1.4333333333333, 0.041666666666667
19564, 1.9083333333333, 1.4333333333333, 0.041666666666667
19565, 1.95, 1.4333333333333, 0.041666666666667
19566, 1.9916666666667, 1.4333333333333, 0.041666666666667
19567, 2.0333333333333, 1.4333333333333, 0.041666666666667
19568, 2.075, 1.4333333333333, 0.041666666666667
19569, 2.1166666666667, 1.4333333333333, 0.041666666666667
19570, 2.1583333333333, 1.4333333333333, 0.041666666666667
19571, 1.2416666666667, 1.4666666666667, 0.041666666666667
19572, 1.2833333333333, 1.4666666666667, 0.041666666666667
19573, 1.325, 1.4666666666667, 0.041666666666667
19574, 1.3666666666667, 1.4666666666667, 0.041666666666667
19575, 1.4083333333333, 1.4666666666667, 0.041666666666667
19576, 1.45, 1.4666666666667, 0.041666666666667
19577, 1.4916666666667, 1.4666666666667, 0.041666666666667
19578, 1.5333333333333, 1.4666666666667, 0.041666666666667
19579, 1.575, 1.4666666666667, 0.041666666666667
19580, 1.6166666666667, 1.4666666666667, 0.041666666666667
19581, 1.6583333333333, 1.4666666666667, 0.041666666666667
19582, 1.7, 1.4666666666667, 0.041666666666667
19583, 1.7416666666667, 1.4666666666667, 0.041666666666667
19584, 1.7833333333333, 1.4666666666667, 0.041666666666667
19585, 1.825, 1.4666666666667, 0.041666666666667
19586, 1.8666666666667, 1.4666666666667, 0.041666666666667
19587, 1.9083333333333, 1.4666666666667, 0.041666666666667
19588, 1.95, 1.4666666666667, 0.041666666666667
19589, 1.9916666666667, 1.4666666666667, 0.041666666666667
19590, 2.0333333333333, 1.4666666666667, 0.041666666666667
19591, 2.075, 1.4666666666667, 0.041666666666667
19592, 2.1166666666667, 1.4666666666667, 0.041666666666667
19593, 2.1583333333333, 1.4666666666667, 0.041666666666667
19594, 1.2416666666667, 1.4333333333333, 0.083333333333333
19595, 1.2833333333333, 1.4333333333333, 0.083333333333333
19596, 1.325, 1.4333333333333, 0.083333333333333
19597, 1.3666666666667, 1.4333333333333, 0.083333333333333
19598, 1.4083333333333, 1.4333333333333, 0.083333333333333
19599, 1.45, 1.4333333333333, 0.083333333333333
19600, 1.4916666666667, 1.4333333333333, 0.083333333333333
19601, 1.5333333333333, 1.4333333333333, 0.083333333333333
19602, 1.575, 1.4333333333333, 0.083333333333333
19603, 1.6166666666667, 1.4333333333333, 0.083333333333333
19604, 1.6583333333333, 1.4333333333333, 0.083333333333333
19605, 1.7, 1.4333333333333, 0.083333333333333
19606, 1.7416666666667, 1.4333333333333, 0.083333333333333
19607, 1.7833333333333, 1.4333333333333, 0.083333333333333
19608, 1.825, 1.4333333333333, 0.083333333333333
19609, 1.8666666666667, 1.4333333333333, 0.083333333333333
19610, 1.9083333333333, 1.4333333333333, 0.083333333333333
19611, 1.95, 1.4333333333333, 0.083333333333333
19612, 1.9916666666667, 1.4333333333333, 0.083333333333333
19613, 2.0333333333333, 1.4333333333333, 0.083333333333333
19614, 2.075, 1.4333333333333, 0.083333333333333
19615, 2.1166666666667, 1.4333333333333, 0.083333333333333
19616, 2.1583333333333, 1.4333333333333, 0.083333333333333
19617, 1.2416666666667, 1.4666666666667, 0.083333333333333
19618, 1.2833333333333, 1.4666666666667, 0.083333333333333
19619, 1.325, 1.4666666666667, 0.083333333333333
19620, 1.3666666666667, 1.4666666666667, 0.083333333333333
19621, 1.4083333333333, 1.4666666666667, 0.083333333333333
19622, 1.45, 1.4666666666667, 0.083333333333333
19623, 1.4916666666667, 1.4666666666667, 0.083333333333333
19624, 1.5333333333333, 1.4666666666667, 0.083333333333333
19625, 1.575, 1.4666666666667, 0.083333333333333
19626, 1.6166666666667, 1.4666666666667, 0.083333333333333
19627, 1.6583333333333, 1.4666666666667, 0.083333333333333
19628, 1.7, 1.4666666666667, 0.083333333333333
19629, 1.7416666666667, 1.4666666666667, 0.083333333333333
19630, 1.7833333333333, 1.4666666666667, 0.083333333333333
19631, 1.825, 1.4666666666667, 0.083333333333333
19632, 1.8666666666667, 1.4666666666667, 0.083333333333333
19633, 1.9083333333333, 1.4666666666667, 0.083333333333333
19634, 1.95, 1.4666666666667, 0.083333333333333
19635, 1.9916666666667, 1.4666666666667, 0.083333333333333
19636, 2.0333333333333, 1.4666666666667, 0.083333333333333
19637, 2.075, 1.4666666666667, 0.083333333333333
19638, 2.1166666666667, 1.4666666666667, 0.083333333333333
19639, 2.1583333333333, 1.4666666666667, 0.083333333333333
19640, 1.2416666666667, 1.4333333333333, 0.125
19641, 1.2833333333333, 1.4333333333333, 0.125
19642, 1.325, 1.4333333333333, 0.125
19643, 1.3666666666667, 1.4333333333333, 0.125
19644, 1.4083333333333, 1.4333333333333, 0.125
19645, 1.45, 1.4333333333333, 0.125
19646, 1.4916666666667, 1.4333333333333, 0.125
19647, 1.5333333333333, 1.4333333333333, 0.125
19648, 1.575, 1.4333333333333, 0.125
19649, 1.6166666666667, 1.4333333333333, 0.125
19650, 1.6583333333333, 1.4333333333333, 0.125
19651, 1.7, 1.4333333333333, 0.125
19652, 1.7416666666667, 1.4333333333333, 0.125
19653, 1.7833333333333, 1.4333333333333, 0.125
19654, 1.825, 1.4333333333333, 0.125
19655, 1.8666666666667, 1.4333333333333, 0.125
19656, 1.9083333333333, 1.4333333333333, 0.125
19657, 1.95, 1.4333333333333, 0.125
19658, 1.9916666666667, 1.4333333333333, 0.125
19659, 2.0333333333333, 1.4333333333333, 0.125
19660, 2.075, 1.4333333333333, 0.125
19661, 2.1166666666667, 1.4333333333333, 0.125
19662, 2.1583333333333, 1.4333333333333, 0.125
19663, 1.2416666666667, 1.4666666666667, 0.125
19664, 1.2833333333333, 1.4666666666667, 0.125
19665, 1.325, 1.4666666666667, 0.125
19666, 1.3666666666667, 1.4666666666667, 0.125
19667, 1.4083333333333, 1.4666666666667, 0.125
19668, 1.45, 1.4666666666667, 0.125
19669, 1.4916666666667, 1.4666666666667, 0.125
19670, 1.5333333333333, 1.4666666666667, 0.125
19671, 1.575, 1.4666666666667, 0.125
19672, 1.6166666666667, 1.4666666666667, 0.125
19673, 1.6583333333333, 1.4666666666667, 0.125
19674, 1.7, 1.4666666666667, 0.125
19675, 1.7416666666667, 1.4666666666667, 0.125
19676, 1.7833333333333, 1.4666666666667, 0.125
19677, 1.825, 1.4666666666667, 0.125
19678, 1.8666666666667, 1.4666666666667, 0.125
19679, 1.9083333333333, 1.4666666666667, 0.125
19680, 1.95, 1.4666666666667, 0.125
19681, 1.9916666666667, 1.4666666666667, 0.125
19682, 2.0333333333333, 1.4666666666667, 0.125
19683, 2.075, 1.4666666666667, 0.125
19684, 2.1166666666667, 1.4666666666667, 0.125
19685, 2.1583333333333, 1.4666666666667, 0.125
19686, 1.2416666666667, 1.4333333333333, 0.16666666666667
19687, 1.2833333333333, 1.4333333333333, 0.16666666666667
19688, 1.325, 1.4333333333333, 0.16666666666667
19689, 1.3666666666667, 1.4333333333333, 0.16666666666667
19690, 1.4083333333333, 1.4333333333333, 0.16666666666667
19691, 1.45, 1.4333333333333, 0.16666666666667
19692, 1.4916666666667, 1.4333333333333, 0.16666666666667
19693, 1.5333333333333, 1.4333333333333, 0.16666666666667
19694, 1.575, 1.4333333333333, 0.16666666666667
19695, 1.6166666666667, 1.4333333333333, 0.16666666666667
19696, 1.6583333333333, 1.4333333333333, 0.16666666666667
19697, 1.7, 1.4333333333333, 0.16666666666667
19698, 1.7416666666667, 1.4333333333333, 0.16666666666667
19699, 1.7833333333333, 1.4333333333333, 0.16666666666667
19700, 1.825, 1.4333333333333, 0.16666666666667
19701, 1.8666666666667, 1.4333333333333, 0.16666666666667
19702, 1.9083333333333, 1.4333333333333, 0.16666666666667
19703, 1.95, 1.4333333333333, 0.16666666666667
19704, 1.9916666666667, 1.4333333333333, 0.16666666666667
19705, 2.0333333333333, 1.4333333333333, 0.16666666666667
19706, 2.075, 1.4333333333333, 0.16666666666667
19707, 2.1166666666667, 1.4333333333333, 0.16666666666667
19708, 2.1583333333333, 1.4333333333333, 0.16666666666667
19709, 1.2416666666667, 1.4666666666667, 0.16666666666667
19710, 1.2833333333333, 1.4666666666667, 0.16666666666667
19711, 1.325, 1.4666666666667, 0.16666666666667
19712, 1.3666666666667, 1.4666666666667, 0.16666666666667
19713, 1.4083333333333, 1.4666666666667, 0.16666666666667
19714, 1.45, 1.4666666666667, 0.16666666666667
19715, 1.4916666666667, 1.4666666666667, 0.16666666666667
19716, 1.5333333333333, 1.4666666666667, 0.16666666666667
19717, 1.575, 1.4666666666667, 0.16666666666667
19718, 1.6166666666667, 1.4666666666667, 0.16666666666667
19719, 1.6583333333333, 1.4666666666667, 0.16666666666667
19720, 1.7, 1.4666666666667, 0.16666666666667
19721, 1.7416666666667, 1.4666666666667, 0.16666666666667
19722, 1.7833333333333, 1.4666666666667, 0.16666666666667
19723, 1.825, 1.4666666666667, 0.16666666666667
19724, 1.8666666666667, 1.4666666666667, 0.16666666666667
19725, 1.9083333333333, 1.4666666666667, 0.16666666666667
19726, 1.95, 1.4666666666667, 0.16666666666667
19727, 1.9916666666667, 1.4666666666667, 0.16666666666667
19728, 2.0333333333333, 1.4666666666667, 0.16666666666667
19729, 2.075, 1.4666666666667, 0.16666666666667
19730, 2.1166666666667, 1.4666666666667, 0.16666666666667
19731, 2.1583333333333, 1.4666666666667, 0.16666666666667
19732, 1.2416666666667, 1.4333333333333, 0.20833333333333
19733, 1.2833333333333, 1.4333333333333, 0.20833333333333
19734, 1.325, 1.4333333333333, 0.20833333333333
19735, 1.3666666666667, 1.4333333333333, 0.20833333333333
19736, 1.4083333333333, 1.4333333333333, 0.20833333333333
19737, 1.45, 1.4333333333333, 0.20833333333333
19738, 1.4916666666667, 1.4333333333333, 0.20833333333333
19739, 1.5333333333333, 1.4333333333333, 0.20833333333333
19740, 1.575, 1.4333333333333, 0.20833333333333
19741, 1.6166666666667, 1.4333333333333, 0.20833333333333
19742, 1.6583333333333, 1.4333333333333, 0.20833333333333
19743, 1.7, 1.4333333333333, 0.20833333333333
19744, 1.7416666666667, 1.4333333333333, 0.20833333333333
19745, 1.7833333333333, 1.4333333333333, 0.20833333333333
19746, 1.825, 1.4333333333333, 0.20833333333333
19747, 1.8666666666667, 1.4333333333333, 0.20833333333333
19748, 1.9083333333333, 1.4333333333333, 0.20833333333333
19749, 1.95, 1.4333333333333, 0.20833333333333
19750, 1.9916666666667, 1.4333333333333, 0.20833333333333
19751, 2.0333333333333, 1.4333333333333, 0.20833333333333
19752, 2.075, 1.4333333333333, 0.20833333333333
19753, 2.1166666666667, 1.4333333333333, 0.20833333333333
19754, 2.1583333333333, 1.4333333333333, 0.20833333333333
19755, 1.2416666666667, 1.4666666666667, 0.20833333333333
19756, 1.2833333333333, 1.4666666666667, 0.20833333333333
19757, 1.325, 1.4666666666667, 0.20833333333333
19758, 1.3666666666667, 1.4666666666667, 0.20833333333333
19759, 1.4083333333333, 1.4666666666667, 0.20833333333333
19760, 1.45, 1.4666666666667, 0.20833333333333
19761, 1.4916666666667, 1.4666666666667, 0.20833333333333
19762, 1.5333333333333, 1.4666666666667, 0.20833333333333
19763, 1.575, 1.4666666666667, 0.20833333333333
19764, 1.6166666666667, 1.4666666666667, 0.20833333333333
19765, 1.6583333333333, 1.4666666666667, 0.20833333333333
19766, 1.7, 1.4666666666667, 0.20833333333333
19767, 1.7416666666667, 1.4666666666667, 0.20833333333333
19768, 1.7833333333333, 1.4666666666667, 0.20833333333333
19769, 1.825, 1.4666666666667, 0.20833333333333
19770, 1.8666666666667, 1.4666666666667, 0.20833333333333
19771, 1.9083333333333, 1.4666666666667, 0.20833333333333
19772, 1.95, 1.4666666666667, 0.20833333333333
19773, 1.9916666666667, 1.4666666666667, 0.20833333333333
19774, 2.0333333333333, 1.4666666666667, 0.20833333333333
19775, 2.075, 1.4666666666667, 0.20833333333333
19776, 2.1166666666667, 1.4666666666667, 0.20833333333333
19777, 2.1583333333333, 1.4666666666667, 0.20833333333333
19778, 1.2416666666667, 1.4333333333333, 0.25
19779, 1.2833333333333, 1.4333333333333, 0.25
19780, 1.325, 1.4333333333333, 0.25
19781, 1.3666666666667, 1.4333333333333, 0.25
19782, 1.4083333333333, 1.4333333333333, 0.25
19783, 1.45, 1.4333333333333, 0.25
19784, 1.4916666666667, 1.4333333333333, 0.25
19785, 1.5333333333333, 1.4333333333333, 0.25
19786, 1.575, 1.4333333333333, 0.25
19787, 1.6166666666667, 1.4333333333333, 0.25
19788, 1.6583333333333, 1.4333333333333, 0.25
19789, 1.7, 1.4333333333333, 0.25
19790, 1.7416666666667, 1.4333333333333, 0.25
19791, 1.7833333333333, 1.4333333333333, 0.25
19792, 1.825, 1.4333333333333, 0.25
19793, 1.8666666666667, 1.4333333333333, 0.25
19794, 1.9083333333333, 1.4333333333333, 0.25
19795, 1.95, 1.4333333333333, 0.25
19796, 1.9916666666667, 1.4333333333333, 0.25
19797, 2.0333333333333, 1.4333333333333, 0.25
19798, 2.075, 1.4333333333333, 0.25
19799, 2.1166666666667, 1.4333333333333, 0.25
19800, 2.1583333333333, 1.4333333333333, 0.25
19801, 1.2416666666667, 1.4666666666667, 0.25
19802, 1.2833333333333, 1.4666666666667, 0.25
19803, 1.325, 1.4666666666667, 0.25
19804, 1.3666666666667, 1.4666666666667, 0.25
19805, 1.4083333333333, 1.4666666666667, 0.25
19806, 1.45, 1.4666666666667, 0.25
19807, 1.4916666666667, 1.4666666666667, 0.25
19808, 1.5333333333333, 1.4666666666667, 0.25
19809, 1.575, 1.4666666666667, 0.25
19810, 1.6166666666667, 1.4666666666667, 0.25
19811, 1.6583333333333, 1.4666666666667, 0.25
19812, 1.7, 1.4666666666667, 0.25
19813, 1.7416666666667, 1.4666666666667, 0.25
19814, 1.7833333333333, 1.4666666666667, 0.25
19815, 1.825, 1.4666666666667, 0.25
19816, 1.8666666666667, 1.4666666666667, 0.25
19817, 1.9083333333333, 1.4666666666667, 0.25
19818, 1.95, 1.4666666666667, 0.25
19819, 1.9916666666667, 1.4666666666667, 0.25
19820, 2.0333333333333, 1.4666666666667, 0.25
19821, 2.075, 1.4666666666667, 0.25
19822, 2.1166666666667, 1.4666666666667, 0.25
19823, 2.1583333333333, 1.4666666666667, 0.25
19824, 1.2416666666667, 1.4333333333333, 0.29166666666667
19825, 1.2833333333333, 1.4333333333333, 0.29166666666667
19826, 1.325, 1.4333333333333, 0.29166666666667
19827, 1.3666666666667, 1.4333333333333, 0.29166666666667
19828, 1.4083333333333, 1.4333333333333, 0.29166666666667
19829, 1.45, 1.4333333333333, 0.29166666666667
19830, 1.4916666666667, 1.4333333333333, 0.29166666666667
19831, 1.5333333333333, 1.4333333333333, 0.29166666666667
19832, 1.575, 1.4333333333333, 0.29166666666667
19833, 1.6166666666667, 1.4333333333333, 0.29166666666667
19834, 1.6583333333333, 1.4333333333333, 0.29166666666667
19835, 1.7, 1.4333333333333, 0.29166666666667
19836, 1.7416666666667, 1.4333333333333, 0.29166666666667
19837, 1.7833333333333, 1.4333333333333, 0.29166666666667
19838, 1.825, 1.4333333333333, 0.29166666666667
19839, 1.8666666666667, 1.4333333333333, 0.29166666666667
19840, 1.9083333333333, 1.4333333333333, 0.29166666666667
19841, 1.95, 1.4333333333333, 0.29166666666667
19842, 1.9916666666667, 1.4333333333333, 0.29166666666667
19843, 2.0333333333333, 1.4333333333333, 0.29166666666667
19844, 2.075, 1.4333333333333, 0.29166666666667
19845, 2.1166666666667, 1.4333333333333, 0.29166666666667
19846, 2.1583333333333, 1.4333333333333, 0.29166666666667
19847, 1.2416666666667, 1.4666666666667, 0.29166666666667
19848, 1.2833333333333, 1.4666666666667, 0.29166666666667
19849, 1.325, 1.4666666666667, 0.29166666666667
19850, 1.3666666666667, 1.4666666666667, 0.29166666666667
19851, 1.4083333333333, 1.4666666666667, 0.29166666666667
19852, 1.45, 1.4666666666667, 0.29166666666667
19853, 1.4916666666667, 1.4666666666667, 0.29166666666667
19854, 1.5333333333333, 1.4666666666667, 0.29166666666667
19855, 1.575, 1.4666666666667, 0.29166666666667
19856, 1.6166666666667, 1.4666666666667, 0.29166666666667
19857, 1.6583333333333, 1.4666666666667, 0.29166666666667
19858, 1.7, 1.4666666666667, 0.29166666666667
19859, 1.7416666666667, 1.4666666666667, 0.29166666666667
19860, 1.7833333333333, 1.4666666666667, 0.29166666666667
19861, 1.825, 1.4666666666667, 0.29166666666667
19862, 1.8666666666667, 1.4666666666667, 0.29166666666667
19863, 1.9083333333333, 1.4666666666667, 0.29166666666667
19864, 1.95, 1.4666666666667, 0.29166666666667
19865, 1.9916666666667, 1.4666666666667, 0.29166666666667
19866, 2.0333333333333, 1.4666666666667, 0.29166666666667
19867, 2.075, 1.4666666666667, 0.29166666666667
19868, 2.1166666666667, 1.4666666666667, 0.29166666666667
19869, 2.1583333333333, 1.4666666666667, 0.29166666666667
19870, 1.2416666666667, 1.4333333333333, 0.33333333333333
19871, 1.2833333333333, 1.4333333333333, 0.33333333333333
19872, 1.325, 1.4333333333333, 0.33333333333333
19873, 1.3666666666667, 1.4333333333333, 0.33333333333333
19874, 1.4083333333333, 1.4333333333333, 0.33333333333333
19875, 1.45, 1.4333333333333, 0.33333333333333
19876, 1.4916666666667, 1.4333333333333, 0.33333333333333
19877, 1.5333333333333, 1.4333333333333, 0.33333333333333
19878, 1.575, 1.4333333333333, 0.33333333333333
19879, 1.6166666666667, 1.4333333333333, 0.33333333333333
19880, 1.6583333333333, 1.4333333333333, 0.33333333333333
19881, 1.7, 1.4333333333333, 0.33333333333333
19882, 1.7416666666667, 1.4333333333333, 0.33333333333333
19883, 1.7833333333333, 1.4333333333333, 0.33333333333333
19884, 1.825, 1.4333333333333, 0.33333333333333
19885, 1.8666666666667, 1.4333333333333, 0.33333333333333
19886, 1.9083333333333, 1.4333333333333, 0.33333333333333
19887, 1.95, 1.4333333333333, 0.33333333333333
19888, 1.9916666666667, 1.4333333333333, 0.33333333333333
19889, 2.0333333333333, 1.4333333333333, 0.33333333333333
19890, 2.075, 1.4333333333333, 0.33333333333333
19891, 2.1166666666667, 1.4333333333333, 0.33333333333333
19892, 2.1583333333333, 1.4333333333333, 0.33333333333333
19893, 1.2416666666667, 1.4666666666667, 0.33333333333333
19894, 1.2833333333333, 1.4666666666667, 0.33333333333333
19895, 1.325, 1.4666666666667, 0.33333333333333
19896, 1.3666666666667, 1.4666666666667, 0.33333333333333
19897, 1.4083333333333, 1.4666666666667, 0.33333333333333
19898, 1.45, 1.4666666666667, 0.33333333333333
19899, 1.4916666666667, 1.4666666666667, 0.33333333333333
19900, 1.5333333333333, 1.4666666666667, 0.33333333333333
19901, 1.575, 1.4666666666667, 0.33333333333333
19902, 1.6166666666667, 1.4666666666667, 0.33333333333333
19903, 1.6583333333333, 1.4666666666667, 0.33333333333333
19904, 1.7, 1.4666666666667, 0.33333333333333
19905, 1.7416666666667, 1.4666666666667, 0.33333333333333
19906, 1.7833333333333, 1.4666666666667, 0.33333333333333
19907, 1.825, 1.4666666666667, 0.33333333333333
19908, 1.8666666666667, 1.4666666666667, 0.33333333333333
19909, 1.9083333333333, 1.4666666666667, 0.33333333333333
19910, 1.95, 1.4666666666667, 0.33333333333333
19911, 1.9916666666667, 1.4666666666667, 0.33333333333333
19912, 2.0333333333333, 1.4666666666667, 0.33333333333333
19913, 2.075, 1.4666666666667, 0.33333333333333
19914, 2.1166666666667, 1.4666666666667, 0.33333333333333
19915, 2.1583333333333, 1.4666666666667, 0.33333333333333
19916, 1.2416666666667, 1.4333333333333, 0.375
19917, 1.2833333333333, 1.4333333333333, 0.375
19918, 1.325, 1.4333333333333, 0.375
19919, 1.3666666666667, 1.4333333333333, 0.375
19920, 1.4083333333333, 1.4333333333333, 0.375
19921, 1.45, 1.4333333333333, 0.375
19922, 1.4916666666667, 1.4333333333333, 0.375
19923, 1.5333333333333, 1.4333333333333, 0.375
19924, 1.575, 1.4333333333333, 0.375
19925, 1.6166666666667, 1.4333333333333, 0.375
19926, 1.6583333333333, 1.4333333333333, 0.375
19927, 1.7, 1.4333333333333, 0.375
19928, 1.7416666666667, 1.4333333333333, 0.375
19929, 1.7833333333333, 1.4333333333333, 0.375
19930, 1.825, 1.4333333333333, 0.375
19931, 1.8666666666667, 1.4333333333333, 0.375
19932, 1.9083333333333, 1.4333333333333, 0.375
19933, 1.95, 1.4333333333333, 0.375
19934, 1.9916666666667, 1.4333333333333, 0.375
19935, 2.0333333333333, 1.4333333333333, 0.375
19936, 2.075, 1.4333333333333, 0.375
19937, 2.1166666666667, 1.4333333333333, 0.375
19938, 2.1583333333333, 1.4333333333333, 0.375
19939, 1.2416666666667, 1.4666666666667, 0.375
19940, 1.2833333333333, 1.4666666666667, 0.375
19941, 1.325, 1.4666666666667, 0.375
19942, 1.3666666666667, 1.4666666666667, 0.375
19943, 1.4083333333333, 1.4666666666667, 0.375
19944, 1.45, 1.4666666666667, 0.375
19945, 1.4916666666667, 1.4666666666667, 0.375
19946, 1.5333333333333, 1.4666666666667, 0.375
19947, 1.575, 1.4666666666667, 0.375
19948, 1.6166666666667, 1.4666666666667, 0.375
19949, 1.6583333333333, 1.4666666666667, 0.375
19950, 1.7, 1.4666666666667, 0.375
19951, 1.7416666666667, 1.4666666666667, 0.375
19952, 1.7833333333333, 1.4666666666667, 0.375
19953, 1.825, 1.4666666666667, 0.375
19954, 1.8666666666667, 1.4666666666667, 0.375
19955, 1.9083333333333, 1.4666666666667, 0.375
19956, 1.95, 1.4666666666667, 0.375
19957, 1.9916666666667, 1.4666666666667, 0.375
19958, 2.0333333333333, 1.4666666666667, 0.375
19959, 2.075, 1.4666666666667, 0.375
19960, 2.1166666666667, 1.4666666666667, 0.375
19961, 2.1583333333333, 1.4666666666667, 0.375
19962, 1.2416666666667, 1.4333333333333, 0.41666666666667
19963, 1.2833333333333, 1.4333333333333, 0.41666666666667
19964, 1.325, 1.4333333333333, 0.41666666666667
19965, 1.3666666666667, 1.4333333333333, 0.41666666666667
19966, 1.4083333333333, 1.4333333333333, 0.41666666666667
19967, 1.45, 1.4333333333333, 0.41666666666667
19968, 1.4916666666667, 1.4333333333333, 0.41666666666667
19969, 1.5333333333333, 1.4333333333333, 0.41666666666667
19970, 1.575, 1.4333333333333, 0.41666666666667
19971, 1.6166666666667, 1.4333333333333, 0.41666666666667
19972, 1.6583333333333, 1.4333333333333, 0.41666666666667
19973, 1.7, 1.4333333333333, 0.41666666666667
19974, 1.7416666666667, 1.4333333333333, 0.41666666666667
19975, 1.7833333333333, 1.4333333333333, 0.41666666666667
19976, 1.825, 1.4333333333333, 0.41666666666667
19977, 1.8666666666667, 1.4333333333333, 0.41666666666667
19978, 1.9083333333333, 1.4333333333333, 0.41666666666667
19979, 1.95, 1.4333333333333, 0.41666666666667
19980, 1.9916666666667, 1.4333333333333, 0.41666666666667
19981, 2.0333333333333, 1.4333333333333, 0.41666666666667
19982, 2.075, 1.4333333333333, 0.41666666666667
19983, 2.1166666666667, 1.4333333333333, 0.41666666666667
19984, 2.1583333333333, 1.4333333333333, 0.41666666666667
19985, 1.2416666666667, 1.4666666666667, 0.41666666666667
19986, 1.2833333333333, 1.4666666666667, 0.41666666666667
19987, 1.325, 1.4666666666667, 0.41666666666667
19988, 1.3666666666667, 1.4666666666667, 0.41666666666667
19989, 1.4083333333333, 1.4666666666667, 0.41666666666667
19990, 1.45, 1.4666666666667, 0.41666666666667
19991, 1.4916666666667, 1.4666666666667, 0.41666666666667
19992, 1.5333333333333, 1.4666666666667, 0.41666666666667
19993, 1.575, 1.4666666666667, 0.41666666666667
19994, 1.6166666666667, 1.4666666666667, 0.41666666666667
19995, 1.6583333333333, 1.4666666666667, 0.41666666666667
19996, 1.7, 1.4666666666667, 0.41666666666667
19997, 1.7416666666667, 1.4666666666667, 0.41666666666667
19998, 1.7833333333333, 1.4666666666667, 0.41666666666667
19999, 1.825, 1.4666666666667, 0.41666666666667
20000, 1.8666666666667, 1.4666666666667, 0.41666666666667
20001, 1.9083333333333, 1.4666666666667, 0.41666666666667
20002, 1.95, 1.4666666666667, 0.41666666666667
20003, 1.9916666666667, 1.4666666666667, 0.41666666666667
20004, 2.0333333333333, 1.4666666666667, 0.41666666666667
20005, 2.075, 1.4666666666667, 0.41666666666667
20006, 2.1166666666667, 1.4666666666667, 0.41666666666667
20007, 2.1583333333333, 1.4666666666667, 0.41666666666667
20008, 1.2416666666667, 1.4333333333333, 0.45833333333333
20009, 1.2833333333333, 1.4333333333333, 0.45833333333333
20010, 1.325, 1.4333333333333, 0.45833333333333
20011, 1.3666666666667, 1.4333333333333, 0.45833333333333
20012, 1.4083333333333, 1.4333333333333, 0.45833333333333
20013, 1.45, 1.4333333333333, 0.45833333333333
20014, 1.4916666666667, 1.4333333333333, 0.45833333333333
20015, 1.5333333333333, 1.4333333333333, 0.45833333333333
20016, 1.575, 1.4333333333333, 0.45833333333333
20017, 1.6166666666667, 1.4333333333333, 0.45833333333333
20018, 1.6583333333333, 1.4333333333333, 0.45833333333333
20019, 1.7, 1.4333333333333, 0.45833333333333
20020, 1.7416666666667, 1.4333333333333, 0.45833333333333
20021, 1.7833333333333, 1.4333333333333, 0.45833333333333
20022, 1.825, 1.4333333333333, 0.45833333333333
20023, 1.8666666666667, 1.4333333333333, 0.45833333333333
20024, 1.9083333333333, 1.4333333333333, 0.45833333333333
20025, 1.95, 1.4333333333333, 0.45833333333333
20026, 1.9916666666667, 1.4333333333333, 0.45833333333333
20027, 2.0333333333333, 1.4333333333333, 0.45833333333333
20028, 2.075, 1.4333333333333, 0.45833333333333
20029, 2.1166666666667, 1.4333333333333, 0.45833333333333
20030, 2.1583333333333, 1.4333333333333, 0.45833333333333
20031, 1.2416666666667, 1.4666666666667, 0.45833333333333
20032, 1.2833333333333, 1.4666666666667, 0.45833333333333
20033, 1.325, 1.4666666666667, 0.45833333333333
20034, 1.3666666666667, 1.4666666666667, 0.45833333333333
20035, 1.4083333333333, 1.4666666666667, 0.45833333333333
20036, 1.45, 1.4666666666667, 0.45833333333333
20037, 1.4916666666667, 1.4666666666667, 0.45833333333333
20038, 1.5333333333333, 1.4666666666667, 0.45833333333333
20039, 1.575, 1.4666666666667, 0.45833333333333
20040, 1.6166666666667, 1.4666666666667, 0.45833333333333
20041, 1.6583333333333, 1.4666666666667, 0.45833333333333
20042, 1.7, 1.4666666666667, 0.45833333333333
20043, 1.7416666666667, 1.4666666666667, 0.45833333333333
20044, 1.7833333333333, 1.4666666666667, 0.45833333333333
20045, 1.825, 1.4666666666667, 0.45833333333333
20046, 1.8666666666667, 1.4666666666667, 0.45833333333333
20047, 1.9083333333333, 1.4666666666667, 0.45833333333333
20048, 1.95, 1.4666666666667, 0.45833333333333
20049, 1.9916666666667, 1.4666666666667, 0.45833333333333
20050, 2.0333333333333, 1.4666666666667, 0.45833333333333
20051, 2.075, 1.4666666666667, 0.45833333333333
20052, 2.1166666666667, 1.4666666666667, 0.45833333333333
20053, 2.1583333333333, 1.4666666666667, 0.45833333333333
20054, 1.2416666666667, 1.3, 0.041666666666667
20055, 1.2416666666667, 1.25, 0.041666666666667
20056, 1.2416666666667, 1.2, 0.041666666666667
20057, 1.2416666666667, 1.15, 0.041666666666667
20058, 1.2416666666667, 1.1, 0.041666666666667
20059, 1.2416666666667, 1.05, 0.041666666666667
20060, 1.2416666666667, 1, 0.041666666666667
20061, 1.2416666666667, 0.95, 0.041666666666667
20062, 1.2416666666667, 0.9, 0.041666666666667
20063, 1.2416666666667, 0.85, 0.041666666666667
20064, 1.2416666666667, 0.8, 0.041666666666667
20065, 1.2416666666667, 0.75, 0.041666666666667
20066, 1.2416666666667, 0.7, 0.041666666666667
20067, 1.2416666666667, 0.65, 0.041666666666667
20068, 1.2416666666667, 0.6, 0.041666666666667
20069, 1.2416666666667, 0.55, 0.041666666666667
20070, 1.2416666666667, 0.5, 0.041666666666667
20071, 1.2416666666667, 0.45, 0.041666666666667
20072, 1.2416666666667, 0.4, 0.041666666666667
20073, 1.2416666666667, 0.35, 0.041666666666667
20074, 1.2416666666667, 0.3, 0.041666666666667
20075, 1.2416666666667, 0.25, 0.041666666666667
20076, 1.2416666666667, 0.2, 0.041666666666667
20077, 1.2833333333333, 1.3, 0.041666666666667
20078, 1.2833333333333, 1.25, 0.041666666666667
20079, 1.2833333333333, 1.2, 0.041666666666667
20080, 1.2833333333333, 1.15, 0.041666666666667
20081, 1.2833333333333, 1.1, 0.041666666666667
20082, 1.2833333333333, 1.05, 0.041666666666667
20083, 1.2833333333333, 1, 0.041666666666667
20084, 1.2833333333333, 0.95, 0.041666666666667
20085, 1.2833333333333, 0.9, 0.041666666666667
20086, 1.2833333333333, 0.85, 0.041666666666667
20087, 1.2833333333333, 0.8, 0.041666666666667
20088, 1.2833333333333, 0.75, 0.041666666666667
20089, 1.2833333333333, 0.7, 0.041666666666667
20090, 1.2833333333333, 0.65, 0.041666666666667
20091, 1.2833333333333, 0.6, 0.041666666666667
20092, 1.2833333333333, 0.55, 0.041666666666667
20093, 1.2833333333333, 0.5, 0.041666666666667
20094, 1.2833333333333, 0.45, 0.041666666666667
20095, 1.2833333333333, 0.4, 0.041666666666667
20096, 1.2833333333333, 0.35, 0.041666666666667
20097, 1.2833333333333, 0.3, 0.041666666666667
20098, 1.2833333333333, 0.25, 0.041666666666667
20099, 1.2833333333333, 0.2, 0.041666666666667
20100, 1.325, 1.3, 0.041666666666667
20101, 1.325, 1.25, 0.041666666666667
20102, 1.325, 1.2, 0.041666666666667
20103, 1.325, 1.15, 0.041666666666667
20104, 1.325, 1.1, 0.041666666666667
20105, 1.325, 1.05, 0.041666666666667
20106, 1.325, 1, 0.041666666666667
20107, 1.325, 0.95, 0.041666666666667
20108, 1.325, 0.9, 0.041666666666667
20109, 1.325, 0.85, 0.041666666666667
20110, 1.325, 0.8, 0.041666666666667
20111, 1.325, 0.75, 0.041666666666667
20112, 1.325, 0.7, 0.041666666666667
20113, 1.325, 0.65, 0.041666666666667
20114, 1.325, 0.6, 0.041666666666667
20115, 1.325, 0.55, 0.041666666666667
20116, 1.325, 0.5, 0.041666666666667
20117, 1.325, 0.45, 0.041666666666667
20118, 1.325, 0.4, 0.041666666666667
20119, 1.325, 0.35, 0.041666666666667
20120, 1.325, 0.3, 0.041666666666667
20121, 1.325, 0.25, 0.041666666666667
20122, 1.325, 0.2, 0.041666666666667
20123, 1.3666666666667, 1.3, 0.041666666666667
20124, 1.3666666666667, 1.25, 0.041666666666667
20125, 1.3666666666667, 1.2, 0.041666666666667
20126, 1.3666666666667, 1.15, 0.041666666666667
20127, 1.3666666666667, 1.1, 0.041666666666667
20128, 1.3666666666667, 1.05, 0.041666666666667
20129, 1.3666666666667, 1, 0.041666666666667
20130, 1.3666666666667, 0.95, 0.041666666666667
20131, 1.3666666666667, 0.9, 0.041666666666667
20132, 1.3666666666667, 0.85, 0.041666666666667
20133, 1.3666666666667, 0.8, 0.041666666666667
20134, 1.3666666666667, 0.75, 0.041666666666667
20135, 1.3666666666667, 0.7, 0.041666666666667
20136, 1.3666666666667, 0.65, 0.041666666666667
20137, 1.3666666666667, 0.6, 0.041666666666667
20138, 1.3666666666667, 0.55, 0.041666666666667
20139, 1.3666666666667, 0.5, 0.041666666666667
20140, 1.3666666666667, 0.45, 0.041666666666667
20141, 1.3666666666667, 0.4, 0.041666666666667
20142, 1.3666666666667, 0.35, 0.041666666666667
20143, 1.3666666666667, 0.3, 0.041666666666667
20144, 1.3666666666667, 0.25, 0.041666666666667
20145, 1.3666666666667, 0.2, 0.041666666666667
20146, 1.4083333333333, 1.3, 0.041666666666667
20147, 1.4083333333333, 1.25, 0.041666666666667
20148, 1.4083333333333, 1.2, 0.041666666666667
20149, 1.4083333333333, 1.15, 0.041666666666667
20150, 1.4083333333333, 1.1, 0.041666666666667
20151, 1.4083333333333, 1.05, 0.041666666666667
20152, 1.4083333333333, 1, 0.041666666666667
20153, 1.4083333333333, 0.95, 0.041666666666667
20154, 1.4083333333333, 0.9, 0.041666666666667
20155, 1.4083333333333, 0.85, 0.041666666666667
20156, 1.4083333333333, 0.8, 0.041666666666667
20157, 1.4083333333333, 0.75, 0.041666666666667
20158, 1.4083333333333, 0.7, 0.041666666666667
20159, 1.4083333333333, 0.65, 0.041666666666667
20160, 1.4083333333333, 0.6, 0.041666666666667
20161, 1.4083333333333, 0.55, 0.041666666666667
20162, 1.4083333333333, 0.5, 0.041666666666667
20163, 1.4083333333333, 0.45, 0.041666666666667
20164, 1.4083333333333, 0.4, 0.041666666666667
20165, 1.4083333333333, 0.35, 0.041666666666667
20166, 1.4083333333333, 0.3, 0.041666666666667
20167, 1.4083333333333, 0.25, 0.041666666666667
20168, 1.4083333333333, 0.2, 0.041666666666667
20169, 1.45, 1.3, 0.041666666666667
20170, 1.45, 1.25, 0.041666666666667
20171, 1.45, 1.2, 0.041666666666667
20172, 1.45, 1.15, 0.041666666666667
20173, 1.45, 1.1, 0.041666666666667
20174, 1.45, 1.05, 0.041666666666667
20175, 1.45, 1, 0.041666666666667
20176, 1.45, 0.95, 0.041666666666667
20177, 1.45, 0.9, 0.041666666666667
20178, 1.45, 0.85, 0.041666666666667
20179, 1.45, 0.8, 0.041666666666667
20180, 1.45, 0.75, 0.041666666666667
20181, 1.45, 0.7, 0.041666666666667
20182, 1.45, 0.65, 0.041666666666667
20183, 1.45, 0.6, 0.041666666666667
20184, 1.45, 0.55, 0.041666666666667
20185, 1.45, 0.5, 0.041666666666667
20186, 1.45, 0.45, 0.041666666666667
20187, 1.45, 0.4, 0.041666666666667
20188, 1.45, 0.35, 0.041666666666667
20189, 1.45, 0.3, 0.041666666666667
20190, 1.45, 0.25, 0.041666666666667
20191, 1.45, 0.2, 0.041666666666667
20192, 1.4916666666667, 1.3, 0.041666666666667
20193, 1.4916666666667, 1.25, 0.041666666666667
20194, 1.4916666666667, 1.2, 0.041666666666667
20195, 1.4916666666667, 1.15, 0.041666666666667
20196, 1.4916666666667, 1.1, 0.041666666666667
20197, 1.4916666666667, 1.05, 0.041666666666667
20198, 1.4916666666667, 1, 0.041666666666667
20199, 1.4916666666667, 0.95, 0.041666666666667
20200, 1.4916666666667, 0.9, 0.041666666666667
20201, 1.4916666666667, 0.85, 0.041666666666667
20202, 1.4916666666667, 0.8, 0.041666666666667
20203, 1.4916666666667, 0.75, 0.041666666666667
20204, 1.4916666666667, 0.7, 0.041666666666667
20205, 1.4916666666667, 0.65, 0.041666666666667
20206, 1.4916666666667, 0.6, 0.041666666666667
20207, 1.4916666666667, 0.55, 0.041666666666667
20208, 1.4916666666667, 0.5, 0.041666666666667
20209, 1.4916666666667, 0.45, 0.041666666666667
20210, 1.4916666666667, 0.4, 0.041666666666667
20211, 1.4916666666667, 0.35, 0.041666666666667
20212, 1.4916666666667, 0.3, 0.041666666666667
20213, 1.4916666666667, 0.25, 0.041666666666667
20214, 1.4916666666667, 0.2, 0.041666666666667
20215, 1.5333333333333, 1.3, 0.041666666666667
20216, 1.5333333333333, 1.25, 0.041666666666667
20217, 1.5333333333333, 1.2, 0.041666666666667
20218, 1.5333333333333, 1.15, 0.041666666666667
20219, 1.5333333333333, 1.1, 0.041666666666667
20220, 1.5333333333333, 1.05, 0.041666666666667
20221, 1.5333333333333, 1, 0.041666666666667
20222, 1.5333333333333, 0.95, 0.041666666666667
20223, 1.5333333333333, 0.9, 0.041666666666667
20224, 1.5333333333333, 0.85, 0.041666666666667
20225, 1.5333333333333, 0.8, 0.041666666666667
20226, 1.5333333333333, 0.75, 0.041666666666667
20227, 1.5333333333333, 0.7, 0.041666666666667
20228, 1.5333333333333, 0.65, 0.041666666666667
20229, 1.5333333333333, 0.6, 0.041666666666667
20230, 1.5333333333333, 0.55, 0.041666666666667
20231, 1.5333333333333, 0.5, 0.041666666666667
20232, 1.5333333333333, 0.45, 0.041666666666667
20233, 1.5333333333333, 0.4, 0.041666666666667
20234, 1.5333333333333, 0.35, 0.041666666666667
20235, 1.5333333333333, 0.3, 0.041666666666667
20236, 1.5333333333333, 0.25, 0.041666666666667
20237, 1.5333333333333, 0.2, 0.041666666666667
20238, 1.575, 1.3, 0.041666666666667
20239, 1.575, 1.25, 0.041666666666667
20240, 1.575, 1.2, 0.041666666666667
20241, 1.575, 1.15, 0.041666666666667
20242, 1.575, 1.1, 0.041666666666667
20243, 1.575, 1.05, 0.041666666666667
20244, 1.575, 1, 0.041666666666667
20245, 1.575, 0.95, 0.041666666666667
20246, 1.575, 0.9, 0.041666666666667
20247, 1.575, 0.85, 0.041666666666667
20248, 1.575, 0.8, 0.041666666666667
20249, 1.575, 0.75, 0.041666666666667
20250, 1.575, 0.7, 0.041666666666667
20251, 1.575, 0.65, 0.041666666666667
20252, 1.575, 0.6, 0.041666666666667
20253, 1.575, 0.55, 0.041666666666667
20254, 1.575, 0.5, 0.041666666666667
20255, 1.575, 0.45, 0.041666666666667
20256, 1.575, 0.4, 0.041666666666667
20257, 1.575, 0.35, 0.041666666666667
20258, 1.575, 0.3, 0.041666666666667
20259, 1.575, 0.25, 0.041666666666667
20260, 1.575, 0.2, 0.041666666666667
20261, 1.6166666666667, 1.3, 0.041666666666667
20262, 1.6166666666667, 1.25, 0.041666666666667
20263, 1.6166666666667, 1.2, 0.041666666666667
20264, 1.6166666666667, 1.15, 0.041666666666667
20265, 1.6166666666667, 1.1, 0.041666666666667
20266, 1.6166666666667, 1.05, 0.041666666666667
20267, 1.6166666666667, 1, 0.041666666666667
20268, 1.6166666666667, 0.95, 0.041666666666667
20269, 1.6166666666667, 0.9, 0.041666666666667
20270, 1.6166666666667, 0.85, 0.041666666666667
20271, 1.6166666666667, 0.8, 0.041666666666667
20272, 1.6166666666667, 0.75, 0.041666666666667
20273, 1.6166666666667, 0.7, 0.041666666666667
20274, 1.6166666666667, 0.65, 0.041666666666667
20275, 1.6166666666667, 0.6, 0.041666666666667
20276, 1.6166666666667, 0.55, 0.041666666666667
20277, 1.6166666666667, 0.5, 0.041666666666667
20278, 1.6166666666667, 0.45, 0.041666666666667
20279, 1.6166666666667, 0.4, 0.041666666666667
20280, 1.6166666666667, 0.35, 0.041666666666667
20281, 1.6166666666667, 0.3, 0.041666666666667
20282, 1.6166666666667, 0.25, 0.041666666666667
20283, 1.6166666666667, 0.2, 0.041666666666667
20284, 1.6583333333333, 1.3, 0.041666666666667
20285, 1.6583333333333, 1.25, 0.041666666666667
20286, 1.6583333333333, 1.2, 0.041666666666667
20287, 1.6583333333333, 1.15, 0.041666666666667
20288, 1.6583333333333, 1.1, 0.041666666666667
20289, 1.6583333333333, 1.05, 0.041666666666667
20290, 1.6583333333333, 1, 0.041666666666667
20291, 1.6583333333333, 0.95, 0.041666666666667
20292, 1.6583333333333, 0.9, 0.041666666666667
20293, 1.6583333333333, 0.85, 0.041666666666667
20294, 1.6583333333333, 0.8, 0.041666666666667
20295, 1.6583333333333, 0.75, 0.041666666666667
20296, 1.6583333333333, 0.7, 0.041666666666667
20297, 1.6583333333333, 0.65, 0.041666666666667
20298, 1.6583333333333, 0.6, 0.041666666666667
20299, 1.6583333333333, 0.55, 0.041666666666667
20300, 1.6583333333333, 0.5, 0.041666666666667
20301, 1.6583333333333, 0.45, 0.041666666666667
20302, 1.6583333333333, 0.4, 0.041666666666667
20303, 1.6583333333333, 0.35, 0.041666666666667
20304, 1.6583333333333, 0.3, 0.041666666666667
20305, 1.6583333333333, 0.25, 0.041666666666667
20306, 1.6583333333333, 0.2, 0.041666666666667
20307, 1.7, 1.3, 0.041666666666667
20308, 1.7, 1.25, 0.041666666666667
20309, 1.7, 1.2, 0.041666666666667
20310, 1.7, 1.15, 0.041666666666667
20311, 1.7, 1.1, 0.041666666666667
20312, 1.7, 1.05, 0.041666666666667
20313, 1.7, 1, 0.041666666666667
20314, 1.7, 0.95, 0.041666666666667
20315, 1.7, 0.9, 0.041666666666667
20316, 1.7, 0.85, 0.041666666666667
20317, 1.7, 0.8, 0.041666666666667
20318, 1.7, 0.75, 0.041666666666667
20319, 1.7, 0.7, 0.041666666666667
20320, 1.7, 0.65, 0.041666666666667
20321, 1.7, 0.6, 0.041666666666667
20322, 1.7, 0.55, 0.041666666666667
20323, 1.7, 0.5, 0.041666666666667
20324, 1.7, 0.45, 0.041666666666667
20325, 1.7, 0.4, 0.041666666666667
20326, 1.7, 0.35, 0.041666666666667
20327, 1.7, 0.3, 0.041666666666667
20328, 1.7, 0.25, 0.041666666666667
20329, 1.7, 0.2, 0.041666666666667
20330, 1.7416666666667, 1.3, 0.041666666666667
20331, 1.7416666666667, 1.25, 0.041666666666667
20332, 1.7416666666667, 1.2, 0.041666666666667
20333, 1.7416666666667, 1.15, 0.041666666666667
20334, 1.7416666666667, 1.1, 0.041666666666667
20335, 1.7416666666667, 1.05, 0.041666666666667
20336, 1.7416666666667, 1, 0.041666666666667
20337, 1.7416666666667, 0.95, 0.041666666666667
20338, 1.7416666666667, 0.9, 0.041666666666667
20339, 1.7416666666667, 0.85, 0.041666666666667
20340, 1.7416666666667, 0.8, 0.041666666666667
20341, 1.7416666666667, 0.75, 0.041666666666667
20342, 1.7416666666667, 0.7, 0.041666666666667
20343, 1.7416666666667, 0.65, 0.041666666666667
20344, 1.7416666666667, 0.6, 0.041666666666667
20345, 1.7416666666667, 0.55, 0.041666666666667
20346, 1.7416666666667, 0.5, 0.041666666666667
20347, 1.7416666666667, 0.45, 0.041666666666667
20348, 1.7416666666667, 0.4, 0.041666666666667
20349, 1.7416666666667, 0.35, 0.041666666666667
20350, 1.7416666666667, 0.3, 0.041666666666667
20351, 1.7416666666667, 0.25, 0.041666666666667
20352, 1.7416666666667, 0.2, 0.041666666666667
20353, 1.7833333333333, 1.3, 0.041666666666667
20354, 1.7833333333333, 1.25, 0.041666666666667
20355, 1.7833333333333, 1.2, 0.041666666666667
20356, 1.7833333333333, 1.15, 0.041666666666667
20357, 1.7833333333333, 1.1, 0.041666666666667
20358, 1.7833333333333, 1.05, 0.041666666666667
20359, 1.7833333333333, 1, 0.041666666666667
20360, 1.7833333333333, 0.95, 0.041666666666667
20361, 1.7833333333333, 0.9, 0.041666666666667
20362, 1.7833333333333, 0.85, 0.041666666666667
20363, 1.7833333333333, 0.8, 0.041666666666667
20364, 1.7833333333333, 0.75, 0.041666666666667
20365, 1.7833333333333, 0.7, 0.041666666666667
20366, 1.7833333333333, 0.65, 0.041666666666667
20367, 1.7833333333333, 0.6, 0.041666666666667
20368, 1.7833333333333, 0.55, 0.041666666666667
20369, 1.7833333333333, 0.5, 0.041666666666667
20370, 1.7833333333333, 0.45, 0.041666666666667
20371, 1.7833333333333, 0.4, 0.041666666666667
20372, 1.7833333333333, 0.35, 0.041666666666667
20373, 1.7833333333333, 0.3, 0.041666666666667
20374, 1.7833333333333, 0.25, 0.041666666666667
20375, 1.7833333333333, 0.2, 0.041666666666667
20376, 1.825, 1.3, 0.041666666666667
20377, 1.825, 1.25, 0.041666666666667
20378, 1.825, 1.2, 0.041666666666667
20379, 1.825, 1.15, 0.041666666666667
20380, 1.825, 1.1, 0.041666666666667
20381, 1.825, 1.05, 0.041666666666667
20382, 1.825, 1, 0.041666666666667
20383, 1.825, 0.95, 0.041666666666667
20384, 1.825, 0.9, 0.041666666666667
20385, 1.825, 0.85, 0.041666666666667
20386, 1.825, 0.8, 0.041666666666667
20387, 1.825, 0.75, 0.041666666666667
20388, 1.825, 0.7, 0.041666666666667
20389, 1.825, 0.65, 0.041666666666667
20390, 1.825, 0.6, 0.041666666666667
20391, 1.825, 0.55, 0.041666666666667
20392, 1.825, 0.5, 0.041666666666667
20393, 1.825, 0.45, 0.041666666666667
20394, 1.825, 0.4, 0.041666666666667
20395, 1.825, 0.35, 0.041666666666667
20396, 1.825, 0.3, 0.041666666666667
20397, 1.825, 0.25, 0.041666666666667
20398, 1.825, 0.2, 0.041666666666667
20399, 1.8666666666667, 1.3, 0.041666666666667
20400, 1.8666666666667, 1.25, 0.041666666666667
20401, 1.8666666666667, 1.2, 0.041666666666667
20402, 1.8666666666667, 1.15, 0.041666666666667
20403, 1.8666666666667, 1.1, 0.041666666666667
20404, 1.8666666666667, 1.05, 0.041666666666667
20405, 1.8666666666667, 1, 0.041666666666667
20406, 1.8666666666667, 0.95, 0.041666666666667
20407, 1.8666666666667, 0.9, 0.041666666666667
20408, 1.8666666666667, 0.85, 0.041666666666667
20409, 1.8666666666667, 0.8, 0.041666666666667
20410, 1.8666666666667, 0.75, 0.041666666666667
20411, 1.8666666666667, 0.7, 0.041666666666667
20412, 1.8666666666667, 0.65, 0.041666666666667
20413, 1.8666666666667, 0.6, 0.041666666666667
20414, 1.8666666666667, 0.55, 0.041666666666667
20415, 1.8666666666667, 0.5, 0.041666666666667
20416, 1.8666666666667, 0.45, 0.041666666666667
20417, 1.8666666666667, 0.4, 0.041666666666667
20418, 1.8666666666667, 0.35, 0.041666666666667
20419, 1.8666666666667, 0.3, 0.041666666666667
20420, 1.8666666666667, 0.25, 0.041666666666667
20421, 1.8666666666667, 0.2, 0.041666666666667
20422, 1.9083333333333, 1.3, 0.041666666666667
20423, 1.9083333333333, 1.25, 0.041666666666667
20424, 1.9083333333333, 1.2, 0.041666666666667
20425, 1.9083333333333, 1.15, 0.041666666666667
20426, 1.9083333333333, 1.1, 0.041666666666667
20427, 1.9083333333333, 1.05, 0.041666666666667
20428, 1.9083333333333, 1, 0.041666666666667
20429, 1.9083333333333, 0.95, 0.041666666666667
20430, 1.9083333333333, 0.9, 0.041666666666667
20431, 1.9083333333333, 0.85, 0.041666666666667
20432, 1.9083333333333, 0.8, 0.041666666666667
20433, 1.9083333333333, 0.75, 0.041666666666667
20434, 1.9083333333333, 0.7, 0.041666666666667
20435, 1.9083333333333, 0.65, 0.041666666666667
20436, 1.9083333333333, 0.6, 0.041666666666667
20437, 1.9083333333333, 0.55, 0.041666666666667
20438, 1.9083333333333, 0.5, 0.041666666666667
20439, 1.9083333333333, 0.45, 0.041666666666667
20440, 1.9083333333333, 0.4, 0.041666666666667
20441, 1.9083333333333, 0.35, 0.041666666666667
20442, 1.9083333333333, 0.3, 0.041666666666667
20443, 1.9083333333333, 0.25, 0.041666666666667
20444, 1.9083333333333, 0.2, 0.041666666666667
20445, 1.95, 1.3, 0.041666666666667
20446, 1.95, 1.25, 0.041666666666667
20447, 1.95, 1.2, 0.041666666666667
20448, 1.95, 1.15, 0.041666666666667
20449, 1.95, 1.1, 0.041666666666667
20450, 1.95, 1.05, 0.041666666666667
20451, 1.95, 1, 0.041666666666667
20452, 1.95, 0.95, 0.041666666666667
20453, 1.95, 0.9, 0.041666666666667
20454, 1.95, 0.85, 0.041666666666667
20455, 1.95, 0.8, 0.041666666666667
20456, 1.95, 0.75, 0.041666666666667
20457, 1.95, 0.7, 0.041666666666667
20458, 1.95, 0.65, 0.041666666666667
20459, 1.95, 0.6, 0.041666666666667
20460, 1.95, 0.55, 0.041666666666667
20461, 1.95, 0.5, 0.041666666666667
20462, 1.95, 0.45, 0.041666666666667
20463, 1.95, 0.4, 0.041666666666667
20464, 1.95, 0.35, 0.041666666666667
20465, 1.95, 0.3, 0.041666666666667
20466, 1.95, 0.25, 0.041666666666667
20467, 1.95, 0.2, 0.041666666666667
20468, 1.9916666666667, 1.3, 0.041666666666667
20469, 1.9916666666667, 1.25, 0.041666666666667
20470, 1.9916666666667, 1.2, 0.041666666666667
20471, 1.9916666666667, 1.15, 0.041666666666667
20472, 1.9916666666667, 1.1, 0.041666666666667
20473, 1.9916666666667, 1.05, 0.041666666666667
20474, 1.9916666666667, 1, 0.041666666666667
20475, 1.9916666666667, 0.95, 0.041666666666667
20476, 1.9916666666667, 0.9, 0.041666666666667
20477, 1.9916666666667, 0.85, 0.041666666666667
20478, 1.9916666666667, 0.8, 0.041666666666667
20479, 1.9916666666667, 0.75, 0.041666666666667
20480, 1.9916666666667, 0.7, 0.041666666666667
20481, 1.9916666666667, 0.65, 0.041666666666667
20482, 1.9916666666667, 0.6, 0.041666666666667
20483, 1.9916666666667, 0.55, 0.041666666666667
20484, 1.9916666666667, 0.5, 0.041666666666667
20485, 1.9916666666667, 0.45, 0.041666666666667
20486, 1.9916666666667, 0.4, 0.041666666666667
20487, 1.9916666666667, 0.35, 0.041666666666667
20488, 1.9916666666667, 0.3, 0.041666666666667
20489, 1.9916666666667, 0.25, 0.041666666666667
20490, 1.9916666666667, 0.2, 0.041666666666667
20491, 2.0333333333333, 1.3, 0.041666666666667
20492, 2.0333333333333, 1.25, 0.041666666666667
20493, 2.0333333333333, 1.2, 0.041666666666667
20494, 2.0333333333333, 1.15, 0.041666666666667
20495, 2.0333333333333, 1.1, 0.041666666666667
20496, 2.0333333333333, 1.05, 0.041666666666667
20497, 2.0333333333333, 1, 0.041666666666667
20498, 2.0333333333333, 0.95, 0.041666666666667
20499, 2.0333333333333, 0.9, 0.041666666666667
20500, 2.0333333333333, 0.85, 0.041666666666667
20501, 2.0333333333333, 0.8, 0.041666666666667
20502, 2.0333333333333, 0.75, 0.041666666666667
20503, 2.0333333333333, 0.7, 0.041666666666667
20504, 2.0333333333333, 0.65, 0.041666666666667
20505, 2.0333333333333, 0.6, 0.041666666666667
20506, 2.0333333333333, 0.55, 0.041666666666667
20507, 2.0333333333333, 0.5, 0.041666666666667
20508, 2.0333333333333, 0.45, 0.041666666666667
20509, 2.0333333333333, 0.4, 0.041666666666667
20510, 2.0333333333333, 0.35, 0.041666666666667
20511, 2.0333333333333, 0.3, 0.041666666666667
20512, 2.0333333333333, 0.25, 0.041666666666667
20513, 2.0333333333333, 0.2, 0.041666666666667
20514, 2.075, 1.3, 0.041666666666667
20515, 2.075, 1.25, 0.041666666666667
20516, 2.075, 1.2, 0.041666666666667
20517, 2.075, 1.15, 0.041666666666667
20518, 2.075, 1.1, 0.041666666666667
20519, 2.075, 1.05, 0.041666666666667
20520, 2.075, 1, 0.041666666666667
20521, 2.075, 0.95, 0.041666666666667
20522, 2.075, 0.9, 0.041666666666667
20523, 2.075, 0.85, 0.041666666666667
20524, 2.075, 0.8, 0.041666666666667
20525, 2.075, 0.75, 0.041666666666667
20526, 2.075, 0.7, 0.041666666666667
20527, 2.075, 0.65, 0.041666666666667
20528, 2.075, 0.6, 0.041666666666667
20529, 2.075, 0.55, 0.041666666666667
20530, 2.075, 0.5, 0.041666666666667
20531, 2.075, 0.45, 0.041666666666667
20532, 2.075, 0.4, 0.041666666666667
20533, 2.075, 0.35, 0.041666666666667
20534, 2.075, 0.3, 0.041666666666667
20535, 2.075, 0.25, 0.041666666666667
20536, 2.075, 0.2, 0.041666666666667
20537, 2.1166666666667, 1.3, 0.041666666666667
20538, 2.1166666666667, 1.25, 0.041666666666667
20539, 2.1166666666667, 1.2, 0.041666666666667
20540, 2.1166666666667, 1.15, 0.041666666666667
20541, 2.1166666666667, 1.1, 0.041666666666667
20542, 2.1166666666667, 1.05, 0.041666666666667
20543, 2.1166666666667, 1, 0.041666666666667
20544, 2.1166666666667, 0.95, 0.041666666666667
20545, 2.1166666666667, 0.9, 0.041666666666667
20546, 2.1166666666667, 0.85, 0.041666666666667
20547, 2.1166666666667, 0.8, 0.041666666666667
20548, 2.1166666666667, 0.75, 0.041666666666667
20549, 2.1166666666667, 0.7, 0.041666666666667
20550, 2.1166666666667, 0.65, 0.041666666666667
20551, 2.1166666666667, 0.6, 0.041666666666667
20552, 2.1166666666667, 0.55, 0.041666666666667
20553, 2.1166666666667, 0.5, 0.041666666666667
20554, 2.1166666666667, 0.45, 0.041666666666667
20555, 2.1166666666667, 0.4, 0.041666666666667
20556, 2.1166666666667, 0.35, 0.041666666666667
20557, 2.1166666666667, 0.3, 0.041666666666667
20558, 2.1166666666667, 0.25, 0.041666666666667
20559, 2.1166666666667, 0.2, 0.041666666666667
20560, 2.1583333333333, 1.3, 0.041666666666667
20561, 2.1583333333333, 1.25, 0.041666666666667
20562, 2.1583333333333, 1.2, 0.041666666666667
20563, 2.1583333333333, 1.15, 0.041666666666667
20564, 2.1583333333333, 1.1, 0.041666666666667
20565, 2.1583333333333, 1.05, 0.041666666666667
20566, 2.1583333333333, 1, 0.041666666666667
20567, 2.1583333333333, 0.95, 0.041666666666667
20568, 2.1583333333333, 0.9, 0.041666666666667
20569, 2.1583333333333, 0.85, 0.041666666666667
20570, 2.1583333333333, 0.8, 0.041666666666667
20571, 2.1583333333333, 0.75, 0.041666666666667
20572, 2.1583333333333, 0.7, 0.041666666666667
20573, 2.1583333333333, 0.65, 0.041666666666667
20574, 2.1583333333333, 0.6, 0.041666666666667
20575, 2.1583333333333, 0.55, 0.041666666666667
20576, 2.1583333333333, 0.5, 0.041666666666667
20577, 2.1583333333333, 0.45, 0.041666666666667
20578, 2.1583333333333, 0.4, 0.041666666666667
20579, 2.1583333333333, 0.35, 0.041666666666667
20580, 2.1583333333333, 0.3, 0.041666666666667
20581, 2.1583333333333, 0.25, 0.041666666666667
20582, 2.1583333333333, 0.2, 0.041666666666667
20583, 1.2416666666667, 1.3, 0.083333333333333
20584, 1.2416666666667, 1.25, 0.083333333333333
20585, 1.2416666666667, 1.2, 0.083333333333333
20586, 1.2416666666667, 1.15, 0.083333333333333
20587, 1.2416666666667, 1.1, 0.083333333333333
20588, 1.2416666666667, 1.05, 0.083333333333333
20589, 1.2416666666667, 1, 0.083333333333333
20590, 1.2416666666667, 0.95, 0.083333333333333
20591, 1.2416666666667, 0.9, 0.083333333333333
20592, 1.2416666666667, 0.85, 0.083333333333333
20593, 1.2416666666667, 0.8, 0.083333333333333
20594, 1.2416666666667, 0.75, 0.083333333333333
20595, 1.2416666666667, 0.7, 0.083333333333333
20596, 1.2416666666667, 0.65, 0.083333333333333
20597, 1.2416666666667, 0.6, 0.083333333333333
20598, 1.2416666666667, 0.55, 0.083333333333333
20599, 1.2416666666667, 0.5, 0.083333333333333
20600, 1.2416666666667, 0.45, 0.083333333333333
20601, 1.2416666666667, 0.4, 0.083333333333333
20602, 1.2416666666667, 0.35, 0.083333333333333
20603, 1.2416666666667, 0.3, 0.083333333333333
20604, 1.2416666666667, 0.25, 0.083333333333333
20605, 1.2416666666667, 0.2, 0.083333333333333
20606, 1.2833333333333, 1.3, 0.083333333333333
20607, 1.2833333333333, 1.25, 0.083333333333333
20608, 1.2833333333333, 1.2, 0.083333333333333
20609, 1.2833333333333, 1.15, 0.083333333333333
20610, 1.2833333333333, 1.1, 0.083333333333333
20611, 1.2833333333333, 1.05, 0.083333333333333
20612, 1.2833333333333, 1, 0.083333333333333
20613, 1.2833333333333, 0.95, 0.083333333333333
20614, 1.2833333333333, 0.9, 0.083333333333333
20615, 1.2833333333333, 0.85, 0.083333333333333
20616, 1.2833333333333, 0.8, 0.083333333333333
20617, 1.2833333333333, 0.75, 0.083333333333333
20618, 1.2833333333333, 0.7, 0.083333333333333
20619, 1.2833333333333, 0.65, 0.083333333333333
20620, 1.2833333333333, 0.6, 0.083333333333333
20621, 1.2833333333333, 0.55, 0.083333333333333
20622, 1.2833333333333, 0.5, 0.083333333333333
20623, 1.2833333333333, 0.45, 0.083333333333333
20624, 1.2833333333333, 0.4, 0.083333333333333
20625, 1.2833333333333, 0.35, 0.083333333333333
20626, 1.2833333333333, 0.3, 0.083333333333333
20627, 1.2833333333333, 0.25, 0.083333333333333
20628, 1.2833333333333, 0.2, 0.083333333333333
20629, 1.325, 1.3, 0.083333333333333
20630, 1.325, 1.25, 0.083333333333333
20631, 1.325, 1.2, 0.083333333333333
20632, 1.325, 1.15, 0.083333333333333
20633, 1.325, 1.1, 0.083333333333333
20634, 1.325, 1.05, 0.083333333333333
20635, 1.325, 1, 0.083333333333333
20636, 1.325, 0.95, 0.083333333333333
20637, 1.325, 0.9, 0.083333333333333
20638, 1.325, 0.85, 0.083333333333333
20639, 1.325, 0.8, 0.083333333333333
20640, 1.325, 0.75, 0.083333333333333
20641, 1.325, 0.7, 0.083333333333333
20642, 1.325, 0.65, 0.083333333333333
20643, 1.325, 0.6, 0.083333333333333
20644, 1.325, 0.55, 0.083333333333333
20645, 1.325, 0.5, 0.083333333333333
20646, 1.325, 0.45, 0.083333333333333
20647, 1.325, 0.4, 0.083333333333333
20648, 1.325, 0.35, 0.083333333333333
20649, 1.325, 0.3, 0.083333333333333
20650, 1.325, 0.25, 0.083333333333333
20651, 1.325, 0.2, 0.083333333333333
20652, 1.3666666666667, 1.3, 0.083333333333333
20653, 1.3666666666667, 1.25, 0.083333333333333
20654, 1.3666666666667, 1.2, 0.083333333333333
20655, 1.3666666666667, 1.15, 0.083333333333333
20656, 1.3666666666667, 1.1, 0.083333333333333
20657, 1.3666666666667, 1.05, 0.083333333333333
20658, 1.3666666666667, 1, 0.083333333333333
20659, 1.3666666666667, 0.95, 0.083333333333333
20660, 1.3666666666667, 0.9, 0.083333333333333
20661, 1.3666666666667, 0.85, 0.083333333333333
20662, 1.3666666666667, 0.8, 0.083333333333333
20663, 1.3666666666667, 0.75, 0.083333333333333
20664, 1.3666666666667, 0.7, 0.083333333333333
20665, 1.3666666666667, 0.65, 0.083333333333333
20666, 1.3666666666667, 0.6, 0.083333333333333
20667, 1.3666666666667, 0.55, 0.083333333333333
20668, 1.3666666666667, 0.5, 0.083333333333333
20669, 1.3666666666667, 0.45, 0.083333333333333
20670, 1.3666666666667, 0.4, 0.083333333333333
20671, 1.3666666666667, 0.35, 0.083333333333333
20672, 1.3666666666667, 0.3, 0.083333333333333
20673, 1.3666666666667, 0.25, 0.083333333333333
20674, 1.3666666666667, 0.2, 0.083333333333333
20675, 1.4083333333333, 1.3, 0.083333333333333
20676, 1.4083333333333, 1.25, 0.083333333333333
20677, 1.4083333333333, 1.2, 0.083333333333333
20678, 1.4083333333333, 1.15, 0.083333333333333
20679, 1.4083333333333, 1.1, 0.083333333333333
20680, 1.4083333333333, 1.05, 0.083333333333333
20681, 1.4083333333333, 1, 0.083333333333333
20682, 1.4083333333333, 0.95, 0.083333333333333
20683, 1.4083333333333, 0.9, 0.083333333333333
20684, 1.4083333333333, 0.85, 0.083333333333333
20685, 1.4083333333333, 0.8, 0.083333333333333
20686, 1.4083333333333, 0.75, 0.083333333333333
20687, 1.4083333333333, 0.7, 0.083333333333333
20688, 1.4083333333333, 0.65, 0.083333333333333
20689, 1.4083333333333, 0.6, 0.083333333333333
20690, 1.4083333333333, 0.55, 0.083333333333333
20691, 1.4083333333333, 0.5, 0.083333333333333
20692, 1.4083333333333, 0.45, 0.083333333333333
20693, 1.4083333333333, 0.4, 0.083333333333333
20694, 1.4083333333333, 0.35, 0.083333333333333
20695, 1.4083333333333, 0.3, 0.083333333333333
20696, 1.4083333333333, 0.25, 0.083333333333333
20697, 1.4083333333333, 0.2, 0.083333333333333
20698, 1.45, 1.3, 0.083333333333333
20699, 1.45, 1.25, 0.083333333333333
20700, 1.45, 1.2, 0.083333333333333
20701, 1.45, 1.15, 0.083333333333333
20702, 1.45, 1.1, 0.083333333333333
20703, 1.45, 1.05, 0.083333333333333
20704, 1.45, 1, 0.083333333333333
20705, 1.45, 0.95, 0.083333333333333
20706, 1.45, 0.9, 0.083333333333333
20707, 1.45, 0.85, 0.083333333333333
20708, 1.45, 0.8, 0.083333333333333
20709, 1.45, 0.75, 0.083333333333333
20710, 1.45, 0.7, 0.083333333333333
20711, 1.45, 0.65, 0.083333333333333
20712, 1.45, 0.6, 0.083333333333333
20713, 1.45, 0.55, 0.083333333333333
20714, 1.45, 0.5, 0.083333333333333
20715, 1.45, 0.45, 0.083333333333333
20716, 1.45, 0.4, 0.083333333333333
20717, 1.45, 0.35, 0.083333333333333
20718, 1.45, 0.3, 0.083333333333333
20719, 1.45, 0.25, 0.083333333333333
20720, 1.45, 0.2, 0.083333333333333
20721, 1.4916666666667, 1.3, 0.083333333333333
20722, 1.4916666666667, 1.25, 0.083333333333333
20723, 1.4916666666667, 1.2, 0.083333333333333
20724, 1.4916666666667, 1.15, 0.083333333333333
20725, 1.4916666666667, 1.1, 0.083333333333333
20726, 1.4916666666667, 1.05, 0.083333333333333
20727, 1.4916666666667, 1, 0.083333333333333
20728, 1.4916666666667, 0.95, 0.083333333333333
20729, 1.4916666666667, 0.9, 0.083333333333333
20730, 1.4916666666667, 0.85, 0.083333333333333
20731, 1.4916666666667, 0.8, 0.083333333333333
20732, 1.4916666666667, 0.75, 0.083333333333333
20733, 1.4916666666667, 0.7, 0.083333333333333
20734, 1.4916666666667, 0.65, 0.083333333333333
20735, 1.4916666666667, 0.6, 0.083333333333333
20736, 1.4916666666667, 0.55, 0.083333333333333
20737, 1.4916666666667, 0.5, 0.083333333333333
20738, 1.4916666666667, 0.45, 0.083333333333333
20739, 1.4916666666667, 0.4, 0.083333333333333
20740, 1.4916666666667, 0.35, 0.083333333333333
20741, 1.4916666666667, 0.3, 0.083333333333333
20742, 1.4916666666667, 0.25, 0.083333333333333
20743, 1.4916666666667, 0.2, 0.083333333333333
20744, 1.5333333333333, 1.3, 0.083333333333333
20745, 1.5333333333333, 1.25, 0.083333333333333
20746, 1.5333333333333, 1.2, 0.083333333333333
20747, 1.5333333333333, 1.15, 0.083333333333333
20748, 1.5333333333333, 1.1, 0.083333333333333
20749, 1.5333333333333, 1.05, 0.083333333333333
20750, 1.5333333333333, 1, 0.083333333333333
20751, 1.5333333333333, 0.95, 0.083333333333333
20752, 1.5333333333333, 0.9, 0.083333333333333
20753, 1.5333333333333, 0.85, 0.083333333333333
20754, 1.5333333333333, 0.8, 0.083333333333333
20755, 1.5333333333333, 0.75, 0.083333333333333
20756, 1.5333333333333, 0.7, 0.083333333333333
20757, 1.5333333333333, 0.65, 0.083333333333333
20758, 1.5333333333333, 0.6, 0.083333333333333
20759, 1.5333333333333, 0.55, 0.083333333333333
20760, 1.5333333333333, 0.5, 0.083333333333333
20761, 1.5333333333333, 0.45, 0.083333333333333
20762, 1.5333333333333, 0.4, 0.083333333333333
20763, 1.5333333333333, 0.35, 0.083333333333333
20764, 1.5333333333333, 0.3, 0.083333333333333
20765, 1.5333333333333, 0.25, 0.083333333333333
20766, 1.5333333333333, 0.2, 0.083333333333333
20767, 1.575, 1.3, 0.083333333333333
20768, 1.575, 1.25, 0.083333333333333
20769, 1.575, 1.2, 0.083333333333333
20770, 1.575, 1.15, 0.083333333333333
20771, 1.575, 1.1, 0.083333333333333
20772, 1.575, 1.05, 0.083333333333333
20773, 1.575, 1, 0.083333333333333
20774, 1.575, 0.95, 0.083333333333333
20775, 1.575, 0.9, 0.083333333333333
20776, 1.575, 0.85, 0.083333333333333
20777, 1.575, 0.8, 0.083333333333333
20778, 1.575, 0.75, 0.083333333333333
20779, 1.575, 0.7, 0.083333333333333
20780, 1.575, 0.65, 0.083333333333333
20781, 1.575, 0.6, 0.083333333333333
20782, 1.575, 0.55, 0.083333333333333
20783, 1.575, 0.5, 0.083333333333333
20784, 1.575, 0.45, 0.083333333333333
20785, 1.575, 0.4, 0.083333333333333
20786, 1.575, 0.35, 0.083333333333333
20787, 1.575, 0.3, 0.083333333333333
20788, 1.575, 0.25, 0.083333333333333
20789, 1.575, 0.2, 0.083333333333333
20790, 1.6166666666667, 1.3, 0.083333333333333
20791, 1.6166666666667, 1.25, 0.083333333333333
20792, 1.6166666666667, 1.2, 0.083333333333333
20793, 1.6166666666667, 1.15, 0.083333333333333
20794, 1.6166666666667, 1.1, 0.083333333333333
20795, 1.6166666666667, 1.05, 0.083333333333333
20796, 1.6166666666667, 1, 0.083333333333333
20797, 1.6166666666667, 0.95, 0.083333333333333
20798, 1.6166666666667, 0.9, 0.083333333333333
20799, 1.6166666666667, 0.85, 0.083333333333333
20800, 1.6166666666667, 0.8, 0.083333333333333
20801, 1.6166666666667, 0.75, 0.083333333333333
20802, 1.6166666666667, 0.7, 0.083333333333333
20803, 1.6166666666667, 0.65, 0.083333333333333
20804, 1.6166666666667, 0.6, 0.083333333333333
20805, 1.6166666666667, 0.55, 0.083333333333333
20806, 1.6166666666667, 0.5, 0.083333333333333
20807, 1.6166666666667, 0.45, 0.083333333333333
20808, 1.6166666666667, 0.4, 0.083333333333333
20809, 1.6166666666667, 0.35, 0.083333333333333
20810, 1.6166666666667, 0.3, 0.083333333333333
20811, 1.6166666666667, 0.25, 0.083333333333333
20812, 1.6166666666667, 0.2, 0.083333333333333
20813, 1.6583333333333, 1.3, 0.083333333333333
20814, 1.6583333333333, 1.25, 0.083333333333333
20815, 1.6583333333333, 1.2, 0.083333333333333
20816, 1.6583333333333, 1.15, 0.083333333333333
20817, 1.6583333333333, 1.1, 0.083333333333333
20818, 1.6583333333333, 1.05, 0.083333333333333
20819, 1.6583333333333, 1, 0.083333333333333
20820, 1.6583333333333, 0.95, 0.083333333333333
20821, 1.6583333333333, 0.9, 0.083333333333333
20822, 1.6583333333333, 0.85, 0.083333333333333
20823, 1.6583333333333, 0.8, 0.083333333333333
20824, 1.6583333333333, 0.75, 0.083333333333333
20825, 1.6583333333333, 0.7, 0.083333333333333
20826, 1.6583333333333, 0.65, 0.083333333333333
20827, 1.6583333333333, 0.6, 0.083333333333333
20828, 1.6583333333333, 0.55, 0.083333333333333
20829, 1.6583333333333, 0.5, 0.083333333333333
20830, 1.6583333333333, 0.45, 0.083333333333333
20831, 1.6583333333333, 0.4, 0.083333333333333
20832, 1.6583333333333, 0.35, 0.083333333333333
20833, 1.6583333333333, 0.3, 0.083333333333333
20834, 1.6583333333333, 0.25, 0.083333333333333
20835, 1.6583333333333, 0.2, 0.083333333333333
20836, 1.7, 1.3, 0.083333333333333
20837, 1.7, 1.25, 0.083333333333333
20838, 1.7, 1.2, 0.083333333333333
20839, 1.7, 1.15, 0.083333333333333
20840, 1.7, 1.1, 0.083333333333333
20841, 1.7, 1.05, 0.083333333333333
20842, 1.7, 1, 0.083333333333333
20843, 1.7, 0.95, 0.083333333333333
20844, 1.7, 0.9, 0.083333333333333
20845, 1.7, 0.85, 0.083333333333333
20846, 1.7, 0.8, 0.083333333333333
20847, 1.7, 0.75, 0.083333333333333
20848, 1.7, 0.7, 0.083333333333333
20849, 1.7, 0.65, 0.083333333333333
20850, 1.7, 0.6, 0.083333333333333
20851, 1.7, 0.55, 0.083333333333333
20852, 1.7, 0.5, 0.083333333333333
20853, 1.7, 0.45, 0.083333333333333
20854, 1.7, 0.4, 0.083333333333333
20855, 1.7, 0.35, 0.083333333333333
20856, 1.7, 0.3, 0.083333333333333
20857, 1.7, 0.25, 0.083333333333333
20858, 1.7, 0.2, 0.083333333333333
20859, 1.7416666666667, 1.3, 0.083333333333333
20860, 1.7416666666667, 1.25, 0.083333333333333
20861, 1.7416666666667, 1.2, 0.083333333333333
20862, 1.7416666666667, 1.15, 0.083333333333333
20863, 1.7416666666667, 1.1, 0.083333333333333
20864, 1.7416666666667, 1.05, 0.083333333333333
20865, 1.7416666666667, 1, 0.083333333333333
20866, 1.7416666666667, 0.95, 0.083333333333333
20867, 1.7416666666667, 0.9, 0.083333333333333
20868, 1.7416666666667, 0.85, 0.083333333333333
20869, 1.7416666666667, 0.8, 0.083333333333333
20870, 1.7416666666667, 0.75, 0.083333333333333
20871, 1.7416666666667, 0.7, 0.083333333333333
20872, 1.7416666666667, 0.65, 0.083333333333333
20873, 1.7416666666667, 0.6, 0.083333333333333
20874, 1.7416666666667, 0.55, 0.083333333333333
20875, 1.7416666666667, 0.5, 0.083333333333333
20876, 1.7416666666667, 0.45, 0.083333333333333
20877, 1.7416666666667, 0.4, 0.083333333333333
20878, 1.7416666666667, 0.35, 0.083333333333333
20879, 1.7416666666667, 0.3, 0.083333333333333
20880, 1.7416666666667, 0.25, 0.083333333333333
20881, 1.7416666666667, 0.2, 0.083333333333333
20882, 1.7833333333333, 1.3, 0.083333333333333
20883, 1.7833333333333, 1.25, 0.083333333333333
20884, 1.7833333333333, 1.2, 0.083333333333333
20885, 1.7833333333333, 1.15, 0.083333333333333
20886, 1.7833333333333, 1.1, 0.083333333333333
20887, 1.7833333333333, 1.05, 0.083333333333333
20888, 1.7833333333333, 1, 0.083333333333333
20889, 1.7833333333333, 0.95, 0.083333333333333
20890, 1.7833333333333, 0.9, 0.083333333333333
20891, 1.7833333333333, 0.85, 0.083333333333333
20892, 1.7833333333333, 0.8, 0.083333333333333
20893, 1.7833333333333, 0.75, 0.083333333333333
20894, 1.7833333333333, 0.7, 0.083333333333333
20895, 1.7833333333333, 0.65, 0.083333333333333
20896, 1.7833333333333, 0.6, 0.083333333333333
20897, 1.7833333333333, 0.55, 0.083333333333333
20898, 1.7833333333333, 0.5, 0.083333333333333
20899, 1.7833333333333, 0.45, 0.083333333333333
20900, 1.7833333333333, 0.4, 0.083333333333333
20901, 1.7833333333333, 0.35, 0.083333333333333
20902, 1.7833333333333, 0.3, 0.083333333333333
20903, 1.7833333333333, 0.25, 0.083333333333333
20904, 1.7833333333333, 0.2, 0.083333333333333
20905, 1.825, 1.3, 0.083333333333333
20906, 1.825, 1.25, 0.083333333333333
20907, 1.825, 1.2, 0.083333333333333
20908, 1.825, 1.15, 0.083333333333333
20909, 1.825, 1.1, 0.083333333333333
20910, 1.825, 1.05, 0.083333333333333
20911, 1.825, 1, 0.083333333333333
20912, 1.825, 0.95, 0.083333333333333
20913, 1.825, 0.9, 0.083333333333333
20914, 1.825, 0.85, 0.083333333333333
20915, 1.825, 0.8, 0.083333333333333
20916, 1.825, 0.75, 0.083333333333333
20917, 1.825, 0.7, 0.083333333333333
20918, 1.825, 0.65, 0.083333333333333
20919, 1.825, 0.6, 0.083333333333333
20920, 1.825, 0.55, 0.083333333333333
20921, 1.825, 0.5, 0.083333333333333
20922, 1.825, 0.45, 0.083333333333333
20923, 1.825, 0.4, 0.083333333333333
20924, 1.825, 0.35, 0.083333333333333
20925, 1.825, 0.3, 0.083333333333333
20926, 1.825, 0.25, 0.083333333333333
20927, 1.825, 0.2, 0.083333333333333
20928, 1.8666666666667, 1.3, 0.083333333333333
20929, 1.8666666666667, 1.25, 0.083333333333333
20930, 1.8666666666667, 1.2, 0.083333333333333
20931, 1.8666666666667, 1.15, 0.083333333333333
20932, 1.8666666666667, 1.1, 0.083333333333333
20933, 1.8666666666667, 1.05, 0.083333333333333
20934, 1.8666666666667, 1, 0.083333333333333
20935, 1.8666666666667, 0.95, 0.083333333333333
20936, 1.8666666666667, 0.9, 0.083333333333333
20937, 1.8666666666667, 0.85, 0.083333333333333
20938, 1.8666666666667, 0.8, 0.083333333333333
20939, 1.8666666666667, 0.75, 0.083333333333333
20940, 1.8666666666667, 0.7, 0.083333333333333
20941, 1.8666666666667, 0.65, 0.083333333333333
20942, 1.8666666666667, 0.6, 0.083333333333333
20943, 1.8666666666667, 0.55, 0.083333333333333
20944, 1.8666666666667, 0.5, 0.083333333333333
20945, 1.8666666666667, 0.45, 0.083333333333333
20946, 1.8666666666667, 0.4, 0.083333333333333
20947, 1.8666666666667, 0.35, 0.083333333333333
20948, 1.8666666666667, 0.3, 0.083333333333333
20949, 1.8666666666667, 0.25, 0.083333333333333
20950, 1.8666666666667, 0.2, 0.083333333333333
20951, 1.9083333333333, 1.3, 0.083333333333333
20952, 1.9083333333333, 1.25, 0.083333333333333
20953, 1.9083333333333, 1.2, 0.083333333333333
20954, 1.9083333333333, 1.15, 0.083333333333333
20955, 1.9083333333333, 1.1, 0.083333333333333
20956, 1.9083333333333, 1.05, 0.083333333333333
20957, 1.9083333333333, 1, 0.083333333333333
20958, 1.9083333333333, 0.95, 0.083333333333333
20959, 1.9083333333333, 0.9, 0.083333333333333
20960, 1.9083333333333, 0.85, 0.083333333333333
20961, 1.9083333333333, 0.8, 0.083333333333333
20962, 1.9083333333333, 0.75, 0.083333333333333
20963, 1.9083333333333, 0.7, 0.083333333333333
20964, 1.9083333333333, 0.65, 0.083333333333333
20965, 1.9083333333333, 0.6, 0.083333333333333
20966, 1.9083333333333, 0.55, 0.083333333333333
20967, 1.9083333333333, 0.5, 0.083333333333333
20968, 1.9083333333333, 0.45, 0.083333333333333
20969, 1.9083333333333, 0.4, 0.083333333333333
20970, 1.9083333333333, 0.35, 0.083333333333333
20971, 1.9083333333333, 0.3, 0.083333333333333
20972, 1.9083333333333, 0.25, 0.083333333333333
20973, 1.9083333333333, 0.2, 0.083333333333333
20974, 1.95, 1.3, 0.083333333333333
20975, 1.95, 1.25, 0.083333333333333
20976, 1.95, 1.2, 0.083333333333333
20977, 1.95, 1.15, 0.083333333333333
20978, 1.95, 1.1, 0.083333333333333
20979, 1.95, 1.05, 0.083333333333333
20980, 1.95, 1, 0.083333333333333
20981, 1.95, 0.95, 0.083333333333333
20982, 1.95, 0.9, 0.083333333333333
20983, 1.95, 0.85, 0.083333333333333
20984, 1.95, 0.8, 0.083333333333333
20985, 1.95, 0.75, 0.083333333333333
20986, 1.95, 0.7, 0.083333333333333
20987, 1.95, 0.65, 0.083333333333333
20988, 1.95, 0.6, 0.083333333333333
20989, 1.95, 0.55, 0.083333333333333
20990, 1.95, 0.5, 0.083333333333333
20991, 1.95, 0.45, 0.083333333333333
20992, 1.95, 0.4, 0.083333333333333
20993, 1.95, 0.35, 0.083333333333333
20994, 1.95, 0.3, 0.083333333333333
20995, 1.95, 0.25, 0.083333333333333
20996, 1.95, 0.2, 0.083333333333333
20997, 1.9916666666667, 1.3, 0.083333333333333
20998, 1.9916666666667, 1.25, 0.083333333333333
20999, 1.9916666666667, 1.2, 0.083333333333333
21000, 1.9916666666667, 1.15, 0.083333333333333
21001, 1.9916666666667, 1.1, 0.083333333333333
21002, 1.9916666666667, 1.05, 0.083333333333333
21003, 1.9916666666667, 1, 0.083333333333333
21004, 1.9916666666667, 0.95, 0.083333333333333
21005, 1.9916666666667, 0.9, 0.083333333333333
21006, 1.9916666666667, 0.85, 0.083333333333333
21007, 1.9916666666667, 0.8, 0.083333333333333
21008, 1.9916666666667, 0.75, 0.083333333333333
21009, 1.9916666666667, 0.7, 0.083333333333333
21010, 1.9916666666667, 0.65, 0.083333333333333
21011, 1.9916666666667, 0.6, 0.083333333333333
21012, 1.9916666666667, 0.55, 0.083333333333333
21013, 1.9916666666667, 0.5, 0.083333333333333
21014, 1.9916666666667, 0.45, 0.083333333333333
21015, 1.9916666666667, 0.4, 0.083333333333333
21016, 1.9916666666667, 0.35, 0.083333333333333
21017, 1.9916666666667, 0.3, 0.083333333333333
21018, 1.9916666666667, 0.25, 0.083333333333333
21019, 1.9916666666667, 0.2, 0.083333333333333
21020, 2.0333333333333, 1.3, 0.083333333333333
21021, 2.0333333333333, 1.25, 0.083333333333333
21022, 2.0333333333333, 1.2, 0.083333333333333
21023, 2.0333333333333, 1.15, 0.083333333333333
21024, 2.0333333333333, 1.1, 0.083333333333333
21025, 2.0333333333333, 1.05, 0.083333333333333
21026, 2.0333333333333, 1, 0.083333333333333
21027, 2.0333333333333, 0.95, 0.083333333333333
21028, 2.0333333333333, 0.9, 0.083333333333333
21029, 2.0333333333333, 0.85, 0.083333333333333
21030, 2.0333333333333, 0.8, 0.083333333333333
21031, 2.0333333333333, 0.75, 0.083333333333333
21032, 2.0333333333333, 0.7, 0.083333333333333
21033, 2.0333333333333, 0.65, 0.083333333333333
21034, 2.0333333333333, 0.6, 0.083333333333333
21035, 2.0333333333333, 0.55, 0.083333333333333
21036, 2.0333333333333, 0.5, 0.083333333333333
21037, 2.0333333333333, 0.45, 0.083333333333333
21038, 2.0333333333333, 0.4, 0.083333333333333
21039, 2.0333333333333, 0.35, 0.083333333333333
21040, 2.0333333333333, 0.3, 0.083333333333333
21041, 2.0333333333333, 0.25, 0.083333333333333
21042, 2.0333333333333, 0.2, 0.083333333333333
21043, 2.075, 1.3, 0.083333333333333
21044, 2.075, 1.25, 0.083333333333333
21045, 2.075, 1.2, 0.083333333333333
21046, 2.075, 1.15, 0.083333333333333
21047, 2.075, 1.1, 0.083333333333333
21048, 2.075, 1.05, 0.083333333333333
21049, 2.075, 1, 0.083333333333333
21050, 2.075, 0.95, 0.083333333333333
21051, 2.075, 0.9, 0.083333333333333
21052, 2.075, 0.85, 0.083333333333333
21053, 2.075, 0.8, 0.083333333333333
21054, 2.075, 0.75, 0.083333333333333
21055, 2.075, 0.7, 0.083333333333333
21056, 2.075, 0.65, 0.083333333333333
21057, 2.075, 0.6, 0.083333333333333
21058, 2.075, 0.55, 0.083333333333333
21059, 2.075, 0.5, 0.083333333333333
21060, 2.075, 0.45, 0.083333333333333
21061, 2.075, 0.4, 0.083333333333333
21062, 2.075, 0.35, 0.083333333333333
21063, 2.075, 0.3, 0.083333333333333
21064, 2.075, 0.25, 0.083333333333333
21065, 2.075, 0.2, 0.083333333333333
21066, 2.1166666666667, 1.3, 0.083333333333333
21067, 2.1166666666667, 1.25, 0.083333333333333
21068, 2.1166666666667, 1.2, 0.083333333333333
21069, 2.1166666666667, 1.15, 0.083333333333333
21070, 2.1166666666667, 1.1, 0.083333333333333
21071, 2.1166666666667, 1.05, 0.083333333333333
21072, 2.1166666666667, 1, 0.083333333333333
21073, 2.1166666666667, 0.95, 0.083333333333333
21074, 2.1166666666667, 0.9, 0.083333333333333
21075, 2.1166666666667, 0.85, 0.083333333333333
21076, 2.1166666666667, 0.8, 0.083333333333333
21077, 2.1166666666667, 0.75, 0.083333333333333
21078, 2.1166666666667, 0.7, 0.083333333333333
21079, 2.1166666666667, 0.65, 0.083333333333333
21080, 2.1166666666667, 0.6, 0.083333333333333
21081, 2.1166666666667, 0.55, 0.083333333333333
21082, 2.1166666666667, 0.5, 0.083333333333333
21083, 2.1166666666667, 0.45, 0.083333333333333
21084, 2.1166666666667, 0.4, 0.083333333333333
21085, 2.1166666666667, 0.35, 0.083333333333333
21086, 2.1166666666667, 0.3, 0.083333333333333
21087, 2.1166666666667, 0.25, 0.083333333333333
21088, 2.1166666666667, 0.2, 0.083333333333333
21089, 2.1583333333333, 1.3, 0.083333333333333
21090, 2.1583333333333, 1.25, 0.083333333333333
21091, 2.1583333333333, 1.2, 0.083333333333333
21092, 2.1583333333333, 1.15, 0.083333333333333
21093, 2.1583333333333, 1.1, 0.083333333333333
21094, 2.1583333333333, 1.05, 0.083333333333333
21095, 2.1583333333333, 1, 0.083333333333333
21096, 2.1583333333333, 0.95, 0.083333333333333
21097, 2.1583333333333, 0.9, 0.083333333333333
21098, 2.1583333333333, 0.85, 0.083333333333333
21099, 2.1583333333333, 0.8, 0.083333333333333
21100, 2.1583333333333, 0.75, 0.083333333333333
21101, 2.1583333333333, 0.7, 0.083333333333333
21102, 2.1583333333333, 0.65, 0.083333333333333
21103, 2.1583333333333, 0.6, 0.083333333333333
21104, 2.1583333333333, 0.55, 0.083333333333333
21105, 2.1583333333333, 0.5, 0.083333333333333
21106, 2.1583333333333, 0.45, 0.083333333333333
21107, 2.1583333333333, 0.4, 0.083333333333333
21108, 2.1583333333333, 0.35, 0.083333333333333
21109, 2.1583333333333, 0.3, 0.083333333333333
21110, 2.1583333333333, 0.25, 0.083333333333333
21111, 2.1583333333333, 0.2, 0.083333333333333
21112, 1.2416666666667, 1.3, 0.125
21113, 1.2416666666667, 1.25, 0.125
21114, 1.2416666666667, 1.2, 0.125
21115, 1.2416666666667, 1.15, 0.125
21116, 1.2416666666667, 1.1, 0.125
21117, 1.2416666666667, 1.05, 0.125
21118, 1.2416666666667, 1, 0.125
21119, 1.2416666666667, 0.95, 0.125
21120, 1.2416666666667, 0.9, 0.125
21121, 1.2416666666667, 0.85, 0.125
21122, 1.2416666666667, 0.8, 0.125
21123, 1.2416666666667, 0.75, 0.125
21124, 1.2416666666667, 0.7, 0.125
21125, 1.2416666666667, 0.65, 0.125
21126, 1.2416666666667, 0.6, 0.125
21127, 1.2416666666667, 0.55, 0.125
21128, 1.2416666666667, 0.5, 0.125
21129, 1.2416666666667, 0.45, 0.125
21130, 1.2416666666667, 0.4, 0.125
21131, 1.2416666666667, 0.35, 0.125
21132, 1.2416666666667, 0.3, 0.125
21133, 1.2416666666667, 0.25, 0.125
21134, 1.2416666666667, 0.2, 0.125
21135, 1.2833333333333, 1.3, 0.125
21136, 1.2833333333333, 1.25, 0.125
21137, 1.2833333333333, 1.2, 0.125
21138, 1.2833333333333, 1.15, 0.125
21139, 1.2833333333333, 1.1, 0.125
21140, 1.2833333333333, 1.05, 0.125
21141, 1.2833333333333, 1, 0.125
21142, 1.2833333333333, 0.95, 0.125
21143, 1.2833333333333, 0.9, 0.125
21144, 1.2833333333333, 0.85, 0.125
21145, 1.2833333333333, 0.8, 0.125
21146, 1.2833333333333, 0.75, 0.125
21147, 1.2833333333333, 0.7, 0.125
21148, 1.2833333333333, 0.65, 0.125
21149, 1.2833333333333, 0.6, 0.125
21150, 1.2833333333333, 0.55, 0.125
21151, 1.2833333333333, 0.5, 0.125
21152, 1.2833333333333, 0.45, 0.125
21153, 1.2833333333333, 0.4, 0.125
21154, 1.2833333333333, 0.35, 0.125
21155, 1.2833333333333, 0.3, 0.125
21156, 1.2833333333333, 0.25, 0.125
21157, 1.2833333333333, 0.2, 0.125
21158, 1.325, 1.3, 0.125
21159, 1.325, 1.25, 0.125
21160, 1.325, 1.2, 0.125
21161, 1.325, 1.15, 0.125
21162, 1.325, 1.1, 0.125
21163, 1.325, 1.05, 0.125
21164, 1.325, 1, 0.125
21165, 1.325, 0.95, 0.125
21166, 1.325, 0.9, 0.125
21167, 1.325, 0.85, 0.125
21168, 1.325, 0.8, 0.125
21169, 1.325, 0.75, 0.125
21170, 1.325, 0.7, 0.125
21171, 1.325, 0.65, 0.125
21172, 1.325, 0.6, 0.125
21173, 1.325, 0.55, 0.125
21174, 1.325, 0.5, 0.125
21175, 1.325, 0.45, 0.125
21176, 1.325, 0.4, 0.125
21177, 1.325, 0.35, 0.125
21178, 1.325, 0.3, 0.125
21179, 1.325, 0.25, 0.125
21180, 1.325, 0.2, 0.125
21181, 1.3666666666667, 1.3, 0.125
21182, 1.3666666666667, 1.25, 0.125
21183, 1.3666666666667, 1.2, 0.125
21184, 1.3666666666667, 1.15, 0.125
21185, 1.3666666666667, 1.1, 0.125
21186, 1.3666666666667, 1.05, 0.125
21187, 1.3666666666667, 1, 0.125
21188, 1.3666666666667, 0.95, 0.125
21189, 1.3666666666667, 0.9, 0.125
21190, 1.3666666666667, 0.85, 0.125
21191, 1.3666666666667, 0.8, 0.125
21192, 1.3666666666667, 0.75, 0.125
21193, 1.3666666666667, 0.7, 0.125
21194, 1.3666666666667, 0.65, 0.125
21195, 1.3666666666667, 0.6, 0.125
21196, 1.3666666666667, 0.55, 0.125
21197, 1.3666666666667, 0.5, 0.125
21198, 1.3666666666667, 0.45, 0.125
21199, 1.3666666666667, 0.4, 0.125
21200, 1.3666666666667, 0.35, 0.125
21201, 1.3666666666667, 0.3, 0.125
21202, 1.3666666666667, 0.25, 0.125
21203, 1.3666666666667, 0.2, 0.125
21204, 1.4083333333333, 1.3, 0.125
21205, 1.4083333333333, 1.25, 0.125
21206, 1.4083333333333, 1.2, 0.125
21207, 1.4083333333333, 1.15, 0.125
21208, 1.4083333333333, 1.1, 0.125
21209, 1.4083333333333, 1.05, 0.125
21210, 1.4083333333333, 1, 0.125
21211, 1.4083333333333, 0.95, 0.125
21212, 1.4083333333333, 0.9, 0.125
21213, 1.4083333333333, 0.85, 0.125
21214, 1.4083333333333, 0.8, 0.125
21215, 1.4083333333333, 0.75, 0.125
21216, 1.4083333333333, 0.7, 0.125
21217, 1.4083333333333, 0.65, 0.125
21218, 1.4083333333333, 0.6, 0.125
21219, 1.4083333333333, 0.55, 0.125
21220, 1.4083333333333, 0.5, 0.125
21221, 1.4083333333333, 0.45, 0.125
21222, 1.4083333333333, 0.4, 0.125
21223, 1.4083333333333, 0.35, 0.125
21224, 1.4083333333333, 0.3, 0.125
21225, 1.4083333333333, 0.25, 0.125
21226, 1.4083333333333, 0.2, 0.125
21227, 1.45, 1.3, 0.125
21228, 1.45, 1.25, 0.125
21229, 1.45, 1.2, 0.125
21230, 1.45, 1.15, 0.125
21231, 1.45, 1.1, 0.125
21232, 1.45, 1.05, 0.125
21233, 1.45, 1, 0.125
21234, 1.45, 0.95, 0.125
21235, 1.45, 0.9, 0.125
21236, 1.45, 0.85, 0.125
21237, 1.45, 0.8, 0.125
21238, 1.45, 0.75, 0.125
21239, 1.45, 0.7, 0.125
21240, 1.45, 0.65, 0.125
21241, 1.45, 0.6, 0.125
21242, 1.45, 0.55, 0.125
21243, 1.45, 0.5, 0.125
21244, 1.45, 0.45, 0.125
21245, 1.45, 0.4, 0.125
21246, 1.45, 0.35, 0.125
21247, 1.45, 0.3, 0.125
21248, 1.45, 0.25, 0.125
21249, 1.45, 0.2, 0.125
21250, 1.4916666666667, 1.3, 0.125
21251, 1.4916666666667, 1.25, 0.125
21252, 1.4916666666667, 1.2, 0.125
21253, 1.4916666666667, 1.15, 0.125
21254, 1.4916666666667, 1.1, 0.125
21255, 1.4916666666667, 1.05, 0.125
21256, 1.4916666666667, 1, 0.125
21257, 1.4916666666667, 0.95, 0.125
21258, 1.4916666666667, 0.9, 0.125
21259, 1.4916666666667, 0.85, 0.125
21260, 1.4916666666667, 0.8, 0.125
21261, 1.4916666666667, 0.75, 0.125
21262, 1.4916666666667, 0.7, 0.125
21263, 1.4916666666667, 0.65, 0.125
21264, 1.4916666666667, 0.6, 0.125
21265, 1.4916666666667, 0.55, 0.125
21266, 1.4916666666667, 0.5, 0.125
21267, 1.4916666666667, 0.45, 0.125
21268, 1.4916666666667, 0.4, 0.125
21269, 1.4916666666667, 0.35, 0.125
21270, 1.4916666666667, 0.3, 0.125
21271, 1.4916666666667, 0.25, 0.125
21272, 1.4916666666667, 0.2, 0.125
21273, 1.5333333333333, 1.3, 0.125
21274, 1.5333333333333, 1.25, 0.125
21275, 1.5333333333333, 1.2, 0.125
21276, 1.5333333333333, 1.15, 0.125
21277, 1.5333333333333, 1.1, 0.125
21278, 1.5333333333333, 1.05, 0.125
21279, 1.5333333333333, 1, 0.125
21280, 1.5333333333333, 0.95, 0.125
21281, 1.5333333333333, 0.9, 0.125
21282, 1.5333333333333, 0.85, 0.125
21283, 1.5333333333333, 0.8, 0.125
21284, 1.5333333333333, 0.75, 0.125
21285, 1.5333333333333, 0.7, 0.125
21286, 1.5333333333333, 0.65, 0.125
21287, 1.5333333333333, 0.6, 0.125
21288, 1.5333333333333, 0.55, 0.125
21289, 1.5333333333333, 0.5, 0.125
21290, 1.5333333333333, 0.45, 0.125
21291, 1.5333333333333, 0.4, 0.125
21292, 1.5333333333333, 0.35, 0.125
21293, 1.5333333333333, 0.3, 0.125
21294, 1.5333333333333, 0.25, 0.125
21295, 1.5333333333333, 0.2, 0.125
21296, 1.575, 1.3, 0.125
21297, 1.575, 1.25, 0.125
21298, 1.575, 1.2, 0.125
21299, 1.575, 1.15, 0.125
21300, 1.575, 1.1, 0.125
21301, 1.575, 1.05, 0.125
21302, 1.575, 1, 0.125
21303, 1.575, 0.95, 0.125
21304, 1.575, 0.9, 0.125
21305, 1.575, 0.85, 0.125
21306, 1.575, 0.8, 0.125
21307, 1.575, 0.75, 0.125
21308, 1.575, 0.7, 0.125
21309, 1.575, 0.65, 0.125
21310, 1.575, 0.6, 0.125
21311, 1.575, 0.55, 0.125
21312, 1.575, 0.5, 0.125
21313, 1.575, 0.45, 0.125
21314, 1.575, 0.4, 0.125
21315, 1.575, 0.35, 0.125
21316, 1.575, 0.3, 0.125
21317, 1.575, 0.25, 0.125
21318, 1.575, 0.2, 0.125
21319, 1.6166666666667, 1.3, 0.125
21320, 1.6166666666667, 1.25, 0.125
21321, 1.6166666666667, 1.2, 0.125
21322, 1.6166666666667, 1.15, 0.125
21323, 1.6166666666667, 1.1, 0.125
21324, 1.6166666666667, 1.05, 0.125
21325, 1.6166666666667, 1, 0.125
21326, 1.6166666666667, 0.95, 0.125
21327, 1.6166666666667, 0.9, 0.125
21328, 1.6166666666667, 0.85, 0.125
21329, 1.6166666666667, 0.8, 0.125
21330, 1.6166666666667, 0.75, 0.125
21331, 1.6166666666667, 0.7, 0.125
21332, 1.6166666666667, 0.65, 0.125
21333, 1.6166666666667, 0.6, 0.125
21334, 1.6166666666667, 0.55, 0.125
21335, 1.6166666666667, 0.5, 0.125
21336, 1.6166666666667, 0.45, 0.125
21337, 1.6166666666667, 0.4, 0.125
21338, 1.6166666666667, 0.35, 0.125
21339, 1.6166666666667, 0.3, 0.125
21340, 1.6166666666667, 0.25, 0.125
21341, 1.6166666666667, 0.2, 0.125
21342, 1.6583333333333, 1.3, 0.125
21343, 1.6583333333333, 1.25, 0.125
21344, 1.6583333333333, 1.2, 0.125
21345, 1.6583333333333, 1.15, 0.125
21346, 1.6583333333333, 1.1, 0.125
21347, 1.6583333333333, 1.05, 0.125
21348, 1.6583333333333, 1, 0.125
21349, 1.6583333333333, 0.95, 0.125
21350, 1.6583333333333, 0.9, 0.125
21351, 1.6583333333333, 0.85, 0.125
21352, 1.6583333333333, 0.8, 0.125
21353, 1.6583333333333, 0.75, 0.125
21354, 1.6583333333333, 0.7, 0.125
21355, 1.6583333333333, 0.65, 0.125
21356, 1.6583333333333, 0.6, 0.125
21357, 1.6583333333333, 0.55, 0.125
21358, 1.6583333333333, 0.5, 0.125
21359, 1.6583333333333, 0.45, 0.125
21360, 1.6583333333333, 0.4, 0.125
