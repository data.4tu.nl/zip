6138, 1.2833333333333, 1.35, 0.20833333333333
6139, 1.325, 1.35, 0.20833333333333
6140, 1.3666666666667, 1.35, 0.20833333333333
6141, 1.4083333333333, 1.35, 0.20833333333333
6142, 1.45, 1.35, 0.20833333333333
6143, 1.4916666666667, 1.35, 0.20833333333333
6144, 1.5333333333333, 1.35, 0.20833333333333
6145, 1.575, 1.35, 0.20833333333333
6146, 1.6166666666667, 1.35, 0.20833333333333
6147, 1.6583333333333, 1.35, 0.20833333333333
6148, 1.7, 1.35, 0.20833333333333
6149, 1.7416666666667, 1.35, 0.20833333333333
6150, 1.7833333333333, 1.35, 0.20833333333333
6151, 1.825, 1.35, 0.20833333333333
6152, 1.8666666666667, 1.35, 0.20833333333333
6153, 1.9083333333333, 1.35, 0.20833333333333
6154, 1.95, 1.35, 0.20833333333333
6155, 1.9916666666667, 1.35, 0.20833333333333
6156, 2.0333333333333, 1.35, 0.20833333333333
6157, 2.075, 1.35, 0.20833333333333
6158, 2.1166666666667, 1.35, 0.20833333333333
6159, 2.1583333333333, 1.35, 0.20833333333333
6160, 1.2416666666667, 1.35, 0.25
6161, 1.2833333333333, 1.35, 0.25
6162, 1.325, 1.35, 0.25
6163, 1.3666666666667, 1.35, 0.25
6164, 1.4083333333333, 1.35, 0.25
6165, 1.45, 1.35, 0.25
6166, 1.4916666666667, 1.35, 0.25
6167, 1.5333333333333, 1.35, 0.25
6168, 1.575, 1.35, 0.25
6169, 1.6166666666667, 1.35, 0.25
6170, 1.6583333333333, 1.35, 0.25
6171, 1.7, 1.35, 0.25
6172, 1.7416666666667, 1.35, 0.25
6173, 1.7833333333333, 1.35, 0.25
6174, 1.825, 1.35, 0.25
6175, 1.8666666666667, 1.35, 0.25
6176, 1.9083333333333, 1.35, 0.25
6177, 1.95, 1.35, 0.25
6178, 1.9916666666667, 1.35, 0.25
6179, 2.0333333333333, 1.35, 0.25
6180, 2.075, 1.35, 0.25
6181, 2.1166666666667, 1.35, 0.25
6182, 2.1583333333333, 1.35, 0.25
6183, 1.2416666666667, 1.35, 0.29166666666667
6184, 1.2833333333333, 1.35, 0.29166666666667
6185, 1.325, 1.35, 0.29166666666667
6186, 1.3666666666667, 1.35, 0.29166666666667
6187, 1.4083333333333, 1.35, 0.29166666666667
6188, 1.45, 1.35, 0.29166666666667
6189, 1.4916666666667, 1.35, 0.29166666666667
6190, 1.5333333333333, 1.35, 0.29166666666667
6191, 1.575, 1.35, 0.29166666666667
6192, 1.6166666666667, 1.35, 0.29166666666667
6193, 1.6583333333333, 1.35, 0.29166666666667
6194, 1.7, 1.35, 0.29166666666667
6195, 1.7416666666667, 1.35, 0.29166666666667
6196, 1.7833333333333, 1.35, 0.29166666666667
6197, 1.825, 1.35, 0.29166666666667
6198, 1.8666666666667, 1.35, 0.29166666666667
6199, 1.9083333333333, 1.35, 0.29166666666667
6200, 1.95, 1.35, 0.29166666666667
6201, 1.9916666666667, 1.35, 0.29166666666667
6202, 2.0333333333333, 1.35, 0.29166666666667
6203, 2.075, 1.35, 0.29166666666667
6204, 2.1166666666667, 1.35, 0.29166666666667
6205, 2.1583333333333, 1.35, 0.29166666666667
6206, 1.2416666666667, 1.35, 0.33333333333333
6207, 1.2833333333333, 1.35, 0.33333333333333
6208, 1.325, 1.35, 0.33333333333333
6209, 1.3666666666667, 1.35, 0.33333333333333
6210, 1.4083333333333, 1.35, 0.33333333333333
6211, 1.45, 1.35, 0.33333333333333
6212, 1.4916666666667, 1.35, 0.33333333333333
6213, 1.5333333333333, 1.35, 0.33333333333333
6214, 1.575, 1.35, 0.33333333333333
6215, 1.6166666666667, 1.35, 0.33333333333333
6216, 1.6583333333333, 1.35, 0.33333333333333
6217, 1.7, 1.35, 0.33333333333333
6218, 1.7416666666667, 1.35, 0.33333333333333
6219, 1.7833333333333, 1.35, 0.33333333333333
6220, 1.825, 1.35, 0.33333333333333
6221, 1.8666666666667, 1.35, 0.33333333333333
6222, 1.9083333333333, 1.35, 0.33333333333333
6223, 1.95, 1.35, 0.33333333333333
6224, 1.9916666666667, 1.35, 0.33333333333333
6225, 2.0333333333333, 1.35, 0.33333333333333
6226, 2.075, 1.35, 0.33333333333333
6227, 2.1166666666667, 1.35, 0.33333333333333
6228, 2.1583333333333, 1.35, 0.33333333333333
6229, 1.2416666666667, 1.35, 0.375
6230, 1.2833333333333, 1.35, 0.375
6231, 1.325, 1.35, 0.375
6232, 1.3666666666667, 1.35, 0.375
6233, 1.4083333333333, 1.35, 0.375
6234, 1.45, 1.35, 0.375
6235, 1.4916666666667, 1.35, 0.375
6236, 1.5333333333333, 1.35, 0.375
6237, 1.575, 1.35, 0.375
6238, 1.6166666666667, 1.35, 0.375
6239, 1.6583333333333, 1.35, 0.375
6240, 1.7, 1.35, 0.375
6241, 1.7416666666667, 1.35, 0.375
6242, 1.7833333333333, 1.35, 0.375
6243, 1.825, 1.35, 0.375
6244, 1.8666666666667, 1.35, 0.375
6245, 1.9083333333333, 1.35, 0.375
6246, 1.95, 1.35, 0.375
6247, 1.9916666666667, 1.35, 0.375
6248, 2.0333333333333, 1.35, 0.375
6249, 2.075, 1.35, 0.375
6250, 2.1166666666667, 1.35, 0.375
6251, 2.1583333333333, 1.35, 0.375
6252, 1.2416666666667, 1.35, 0.41666666666667
6253, 1.2833333333333, 1.35, 0.41666666666667
6254, 1.325, 1.35, 0.41666666666667
6255, 1.3666666666667, 1.35, 0.41666666666667
6256, 1.4083333333333, 1.35, 0.41666666666667
6257, 1.45, 1.35, 0.41666666666667
6258, 1.4916666666667, 1.35, 0.41666666666667
6259, 1.5333333333333, 1.35, 0.41666666666667
6260, 1.575, 1.35, 0.41666666666667
6261, 1.6166666666667, 1.35, 0.41666666666667
6262, 1.6583333333333, 1.35, 0.41666666666667
6263, 1.7, 1.35, 0.41666666666667
6264, 1.7416666666667, 1.35, 0.41666666666667
6265, 1.7833333333333, 1.35, 0.41666666666667
6266, 1.825, 1.35, 0.41666666666667
6267, 1.8666666666667, 1.35, 0.41666666666667
6268, 1.9083333333333, 1.35, 0.41666666666667
6269, 1.95, 1.35, 0.41666666666667
6270, 1.9916666666667, 1.35, 0.41666666666667
6271, 2.0333333333333, 1.35, 0.41666666666667
6272, 2.075, 1.35, 0.41666666666667
6273, 2.1166666666667, 1.35, 0.41666666666667
6274, 2.1583333333333, 1.35, 0.41666666666667
6275, 1.2416666666667, 1.35, 0.45833333333333
6276, 1.2833333333333, 1.35, 0.45833333333333
6277, 1.325, 1.35, 0.45833333333333
6278, 1.3666666666667, 1.35, 0.45833333333333
6279, 1.4083333333333, 1.35, 0.45833333333333
6280, 1.45, 1.35, 0.45833333333333
6281, 1.4916666666667, 1.35, 0.45833333333333
6282, 1.5333333333333, 1.35, 0.45833333333333
6283, 1.575, 1.35, 0.45833333333333
6284, 1.6166666666667, 1.35, 0.45833333333333
6285, 1.6583333333333, 1.35, 0.45833333333333
6286, 1.7, 1.35, 0.45833333333333
6287, 1.7416666666667, 1.35, 0.45833333333333
6288, 1.7833333333333, 1.35, 0.45833333333333
6289, 1.825, 1.35, 0.45833333333333
6290, 1.8666666666667, 1.35, 0.45833333333333
6291, 1.9083333333333, 1.35, 0.45833333333333
6292, 1.95, 1.35, 0.45833333333333
6293, 1.9916666666667, 1.35, 0.45833333333333
6294, 2.0333333333333, 1.35, 0.45833333333333
6295, 2.075, 1.35, 0.45833333333333
6296, 2.1166666666667, 1.35, 0.45833333333333
6297, 2.1583333333333, 1.35, 0.45833333333333
6298, 1.2416666666667, 1.3, 0.5
6299, 1.2416666666667, 1.25, 0.5
6300, 1.2416666666667, 1.2, 0.5
6301, 1.2416666666667, 1.15, 0.5
6302, 1.2416666666667, 1.1, 0.5
6303, 1.2416666666667, 1.05, 0.5
6304, 1.2416666666667, 1, 0.5
6305, 1.2416666666667, 0.95, 0.5
6306, 1.2416666666667, 0.9, 0.5
6307, 1.2416666666667, 0.85, 0.5
6308, 1.2416666666667, 0.8, 0.5
6309, 1.2416666666667, 0.75, 0.5
6310, 1.2416666666667, 0.7, 0.5
6311, 1.2416666666667, 0.65, 0.5
6312, 1.2416666666667, 0.6, 0.5
6313, 1.2416666666667, 0.55, 0.5
6314, 1.2416666666667, 0.5, 0.5
6315, 1.2416666666667, 0.45, 0.5
6316, 1.2416666666667, 0.4, 0.5
6317, 1.2416666666667, 0.35, 0.5
6318, 1.2416666666667, 0.3, 0.5
6319, 1.2416666666667, 0.25, 0.5
6320, 1.2416666666667, 0.2, 0.5
6321, 1.2833333333333, 1.3, 0.5
6322, 1.2833333333333, 1.25, 0.5
6323, 1.2833333333333, 1.2, 0.5
6324, 1.2833333333333, 1.15, 0.5
6325, 1.2833333333333, 1.1, 0.5
6326, 1.2833333333333, 1.05, 0.5
6327, 1.2833333333333, 1, 0.5
6328, 1.2833333333333, 0.95, 0.5
6329, 1.2833333333333, 0.9, 0.5
6330, 1.2833333333333, 0.85, 0.5
6331, 1.2833333333333, 0.8, 0.5
6332, 1.2833333333333, 0.75, 0.5
6333, 1.2833333333333, 0.7, 0.5
6334, 1.2833333333333, 0.65, 0.5
6335, 1.2833333333333, 0.6, 0.5
6336, 1.2833333333333, 0.55, 0.5
6337, 1.2833333333333, 0.5, 0.5
6338, 1.2833333333333, 0.45, 0.5
6339, 1.2833333333333, 0.4, 0.5
6340, 1.2833333333333, 0.35, 0.5
6341, 1.2833333333333, 0.3, 0.5
6342, 1.2833333333333, 0.25, 0.5
6343, 1.2833333333333, 0.2, 0.5
6344, 1.325, 1.3, 0.5
6345, 1.325, 1.25, 0.5
6346, 1.325, 1.2, 0.5
6347, 1.325, 1.15, 0.5
6348, 1.325, 1.1, 0.5
6349, 1.325, 1.05, 0.5
6350, 1.325, 1, 0.5
6351, 1.325, 0.95, 0.5
6352, 1.325, 0.9, 0.5
6353, 1.325, 0.85, 0.5
6354, 1.325, 0.8, 0.5
6355, 1.325, 0.75, 0.5
6356, 1.325, 0.7, 0.5
6357, 1.325, 0.65, 0.5
6358, 1.325, 0.6, 0.5
6359, 1.325, 0.55, 0.5
6360, 1.325, 0.5, 0.5
6361, 1.325, 0.45, 0.5
6362, 1.325, 0.4, 0.5
6363, 1.325, 0.35, 0.5
6364, 1.325, 0.3, 0.5
6365, 1.325, 0.25, 0.5
6366, 1.325, 0.2, 0.5
6367, 1.3666666666667, 1.3, 0.5
6368, 1.3666666666667, 1.25, 0.5
6369, 1.3666666666667, 1.2, 0.5
6370, 1.3666666666667, 1.15, 0.5
6371, 1.3666666666667, 1.1, 0.5
6372, 1.3666666666667, 1.05, 0.5
6373, 1.3666666666667, 1, 0.5
6374, 1.3666666666667, 0.95, 0.5
6375, 1.3666666666667, 0.9, 0.5
6376, 1.3666666666667, 0.85, 0.5
6377, 1.3666666666667, 0.8, 0.5
6378, 1.3666666666667, 0.75, 0.5
6379, 1.3666666666667, 0.7, 0.5
6380, 1.3666666666667, 0.65, 0.5
6381, 1.3666666666667, 0.6, 0.5
6382, 1.3666666666667, 0.55, 0.5
6383, 1.3666666666667, 0.5, 0.5
6384, 1.3666666666667, 0.45, 0.5
6385, 1.3666666666667, 0.4, 0.5
6386, 1.3666666666667, 0.35, 0.5
6387, 1.3666666666667, 0.3, 0.5
6388, 1.3666666666667, 0.25, 0.5
6389, 1.3666666666667, 0.2, 0.5
6390, 1.4083333333333, 1.3, 0.5
6391, 1.4083333333333, 1.25, 0.5
6392, 1.4083333333333, 1.2, 0.5
6393, 1.4083333333333, 1.15, 0.5
6394, 1.4083333333333, 1.1, 0.5
6395, 1.4083333333333, 1.05, 0.5
6396, 1.4083333333333, 1, 0.5
6397, 1.4083333333333, 0.95, 0.5
6398, 1.4083333333333, 0.9, 0.5
6399, 1.4083333333333, 0.85, 0.5
6400, 1.4083333333333, 0.8, 0.5
6401, 1.4083333333333, 0.75, 0.5
6402, 1.4083333333333, 0.7, 0.5
6403, 1.4083333333333, 0.65, 0.5
6404, 1.4083333333333, 0.6, 0.5
6405, 1.4083333333333, 0.55, 0.5
6406, 1.4083333333333, 0.5, 0.5
6407, 1.4083333333333, 0.45, 0.5
6408, 1.4083333333333, 0.4, 0.5
6409, 1.4083333333333, 0.35, 0.5
6410, 1.4083333333333, 0.3, 0.5
6411, 1.4083333333333, 0.25, 0.5
6412, 1.4083333333333, 0.2, 0.5
6413, 1.45, 1.3, 0.5
6414, 1.45, 1.25, 0.5
6415, 1.45, 1.2, 0.5
6416, 1.45, 1.15, 0.5
6417, 1.45, 1.1, 0.5
6418, 1.45, 1.05, 0.5
6419, 1.45, 1, 0.5
6420, 1.45, 0.95, 0.5
6421, 1.45, 0.9, 0.5
6422, 1.45, 0.85, 0.5
6423, 1.45, 0.8, 0.5
6424, 1.45, 0.75, 0.5
6425, 1.45, 0.7, 0.5
6426, 1.45, 0.65, 0.5
6427, 1.45, 0.6, 0.5
6428, 1.45, 0.55, 0.5
6429, 1.45, 0.5, 0.5
6430, 1.45, 0.45, 0.5
6431, 1.45, 0.4, 0.5
6432, 1.45, 0.35, 0.5
6433, 1.45, 0.3, 0.5
6434, 1.45, 0.25, 0.5
6435, 1.45, 0.2, 0.5
6436, 1.4916666666667, 1.3, 0.5
6437, 1.4916666666667, 1.25, 0.5
6438, 1.4916666666667, 1.2, 0.5
6439, 1.4916666666667, 1.15, 0.5
6440, 1.4916666666667, 1.1, 0.5
6441, 1.4916666666667, 1.05, 0.5
6442, 1.4916666666667, 1, 0.5
6443, 1.4916666666667, 0.95, 0.5
6444, 1.4916666666667, 0.9, 0.5
6445, 1.4916666666667, 0.85, 0.5
6446, 1.4916666666667, 0.8, 0.5
6447, 1.4916666666667, 0.75, 0.5
6448, 1.4916666666667, 0.7, 0.5
6449, 1.4916666666667, 0.65, 0.5
6450, 1.4916666666667, 0.6, 0.5
6451, 1.4916666666667, 0.55, 0.5
6452, 1.4916666666667, 0.5, 0.5
6453, 1.4916666666667, 0.45, 0.5
6454, 1.4916666666667, 0.4, 0.5
6455, 1.4916666666667, 0.35, 0.5
6456, 1.4916666666667, 0.3, 0.5
6457, 1.4916666666667, 0.25, 0.5
6458, 1.4916666666667, 0.2, 0.5
6459, 1.5333333333333, 1.3, 0.5
6460, 1.5333333333333, 1.25, 0.5
6461, 1.5333333333333, 1.2, 0.5
6462, 1.5333333333333, 1.15, 0.5
6463, 1.5333333333333, 1.1, 0.5
6464, 1.5333333333333, 1.05, 0.5
6465, 1.5333333333333, 1, 0.5
6466, 1.5333333333333, 0.95, 0.5
6467, 1.5333333333333, 0.9, 0.5
6468, 1.5333333333333, 0.85, 0.5
6469, 1.5333333333333, 0.8, 0.5
6470, 1.5333333333333, 0.75, 0.5
6471, 1.5333333333333, 0.7, 0.5
6472, 1.5333333333333, 0.65, 0.5
6473, 1.5333333333333, 0.6, 0.5
6474, 1.5333333333333, 0.55, 0.5
6475, 1.5333333333333, 0.5, 0.5
6476, 1.5333333333333, 0.45, 0.5
6477, 1.5333333333333, 0.4, 0.5
6478, 1.5333333333333, 0.35, 0.5
6479, 1.5333333333333, 0.3, 0.5
6480, 1.5333333333333, 0.25, 0.5
6481, 1.5333333333333, 0.2, 0.5
6482, 1.575, 1.3, 0.5
6483, 1.575, 1.25, 0.5
6484, 1.575, 1.2, 0.5
6485, 1.575, 1.15, 0.5
6486, 1.575, 1.1, 0.5
6487, 1.575, 1.05, 0.5
6488, 1.575, 1, 0.5
6489, 1.575, 0.95, 0.5
6490, 1.575, 0.9, 0.5
6491, 1.575, 0.85, 0.5
6492, 1.575, 0.8, 0.5
6493, 1.575, 0.75, 0.5
6494, 1.575, 0.7, 0.5
6495, 1.575, 0.65, 0.5
6496, 1.575, 0.6, 0.5
6497, 1.575, 0.55, 0.5
6498, 1.575, 0.5, 0.5
6499, 1.575, 0.45, 0.5
6500, 1.575, 0.4, 0.5
6501, 1.575, 0.35, 0.5
6502, 1.575, 0.3, 0.5
6503, 1.575, 0.25, 0.5
6504, 1.575, 0.2, 0.5
6505, 1.6166666666667, 1.3, 0.5
6506, 1.6166666666667, 1.25, 0.5
6507, 1.6166666666667, 1.2, 0.5
6508, 1.6166666666667, 1.15, 0.5
6509, 1.6166666666667, 1.1, 0.5
6510, 1.6166666666667, 1.05, 0.5
6511, 1.6166666666667, 1, 0.5
6512, 1.6166666666667, 0.95, 0.5
6513, 1.6166666666667, 0.9, 0.5
6514, 1.6166666666667, 0.85, 0.5
6515, 1.6166666666667, 0.8, 0.5
6516, 1.6166666666667, 0.75, 0.5
6517, 1.6166666666667, 0.7, 0.5
6518, 1.6166666666667, 0.65, 0.5
6519, 1.6166666666667, 0.6, 0.5
6520, 1.6166666666667, 0.55, 0.5
6521, 1.6166666666667, 0.5, 0.5
6522, 1.6166666666667, 0.45, 0.5
6523, 1.6166666666667, 0.4, 0.5
6524, 1.6166666666667, 0.35, 0.5
6525, 1.6166666666667, 0.3, 0.5
6526, 1.6166666666667, 0.25, 0.5
6527, 1.6166666666667, 0.2, 0.5
6528, 1.6583333333333, 1.3, 0.5
6529, 1.6583333333333, 1.25, 0.5
6530, 1.6583333333333, 1.2, 0.5
6531, 1.6583333333333, 1.15, 0.5
6532, 1.6583333333333, 1.1, 0.5
6533, 1.6583333333333, 1.05, 0.5
6534, 1.6583333333333, 1, 0.5
6535, 1.6583333333333, 0.95, 0.5
6536, 1.6583333333333, 0.9, 0.5
6537, 1.6583333333333, 0.85, 0.5
6538, 1.6583333333333, 0.8, 0.5
6539, 1.6583333333333, 0.75, 0.5
6540, 1.6583333333333, 0.7, 0.5
6541, 1.6583333333333, 0.65, 0.5
6542, 1.6583333333333, 0.6, 0.5
6543, 1.6583333333333, 0.55, 0.5
6544, 1.6583333333333, 0.5, 0.5
6545, 1.6583333333333, 0.45, 0.5
6546, 1.6583333333333, 0.4, 0.5
6547, 1.6583333333333, 0.35, 0.5
6548, 1.6583333333333, 0.3, 0.5
6549, 1.6583333333333, 0.25, 0.5
6550, 1.6583333333333, 0.2, 0.5
6551, 1.7, 1.3, 0.5
6552, 1.7, 1.25, 0.5
6553, 1.7, 1.2, 0.5
6554, 1.7, 1.15, 0.5
6555, 1.7, 1.1, 0.5
6556, 1.7, 1.05, 0.5
6557, 1.7, 1, 0.5
6558, 1.7, 0.95, 0.5
6559, 1.7, 0.9, 0.5
6560, 1.7, 0.85, 0.5
6561, 1.7, 0.8, 0.5
6562, 1.7, 0.75, 0.5
6563, 1.7, 0.7, 0.5
6564, 1.7, 0.65, 0.5
6565, 1.7, 0.6, 0.5
6566, 1.7, 0.55, 0.5
6567, 1.7, 0.5, 0.5
6568, 1.7, 0.45, 0.5
6569, 1.7, 0.4, 0.5
6570, 1.7, 0.35, 0.5
6571, 1.7, 0.3, 0.5
6572, 1.7, 0.25, 0.5
6573, 1.7, 0.2, 0.5
6574, 1.7416666666667, 1.3, 0.5
6575, 1.7416666666667, 1.25, 0.5
6576, 1.7416666666667, 1.2, 0.5
6577, 1.7416666666667, 1.15, 0.5
6578, 1.7416666666667, 1.1, 0.5
6579, 1.7416666666667, 1.05, 0.5
6580, 1.7416666666667, 1, 0.5
6581, 1.7416666666667, 0.95, 0.5
6582, 1.7416666666667, 0.9, 0.5
6583, 1.7416666666667, 0.85, 0.5
6584, 1.7416666666667, 0.8, 0.5
6585, 1.7416666666667, 0.75, 0.5
6586, 1.7416666666667, 0.7, 0.5
6587, 1.7416666666667, 0.65, 0.5
6588, 1.7416666666667, 0.6, 0.5
6589, 1.7416666666667, 0.55, 0.5
6590, 1.7416666666667, 0.5, 0.5
6591, 1.7416666666667, 0.45, 0.5
6592, 1.7416666666667, 0.4, 0.5
6593, 1.7416666666667, 0.35, 0.5
6594, 1.7416666666667, 0.3, 0.5
6595, 1.7416666666667, 0.25, 0.5
6596, 1.7416666666667, 0.2, 0.5
6597, 1.7833333333333, 1.3, 0.5
6598, 1.7833333333333, 1.25, 0.5
6599, 1.7833333333333, 1.2, 0.5
6600, 1.7833333333333, 1.15, 0.5
6601, 1.7833333333333, 1.1, 0.5
6602, 1.7833333333333, 1.05, 0.5
6603, 1.7833333333333, 1, 0.5
6604, 1.7833333333333, 0.95, 0.5
6605, 1.7833333333333, 0.9, 0.5
6606, 1.7833333333333, 0.85, 0.5
6607, 1.7833333333333, 0.8, 0.5
6608, 1.7833333333333, 0.75, 0.5
6609, 1.7833333333333, 0.7, 0.5
6610, 1.7833333333333, 0.65, 0.5
6611, 1.7833333333333, 0.6, 0.5
6612, 1.7833333333333, 0.55, 0.5
6613, 1.7833333333333, 0.5, 0.5
6614, 1.7833333333333, 0.45, 0.5
6615, 1.7833333333333, 0.4, 0.5
6616, 1.7833333333333, 0.35, 0.5
6617, 1.7833333333333, 0.3, 0.5
6618, 1.7833333333333, 0.25, 0.5
6619, 1.7833333333333, 0.2, 0.5
6620, 1.825, 1.3, 0.5
6621, 1.825, 1.25, 0.5
6622, 1.825, 1.2, 0.5
6623, 1.825, 1.15, 0.5
6624, 1.825, 1.1, 0.5
6625, 1.825, 1.05, 0.5
6626, 1.825, 1, 0.5
6627, 1.825, 0.95, 0.5
6628, 1.825, 0.9, 0.5
6629, 1.825, 0.85, 0.5
6630, 1.825, 0.8, 0.5
6631, 1.825, 0.75, 0.5
6632, 1.825, 0.7, 0.5
6633, 1.825, 0.65, 0.5
6634, 1.825, 0.6, 0.5
6635, 1.825, 0.55, 0.5
6636, 1.825, 0.5, 0.5
6637, 1.825, 0.45, 0.5
6638, 1.825, 0.4, 0.5
6639, 1.825, 0.35, 0.5
6640, 1.825, 0.3, 0.5
6641, 1.825, 0.25, 0.5
6642, 1.825, 0.2, 0.5
6643, 1.8666666666667, 1.3, 0.5
6644, 1.8666666666667, 1.25, 0.5
6645, 1.8666666666667, 1.2, 0.5
6646, 1.8666666666667, 1.15, 0.5
6647, 1.8666666666667, 1.1, 0.5
6648, 1.8666666666667, 1.05, 0.5
6649, 1.8666666666667, 1, 0.5
6650, 1.8666666666667, 0.95, 0.5
6651, 1.8666666666667, 0.9, 0.5
6652, 1.8666666666667, 0.85, 0.5
6653, 1.8666666666667, 0.8, 0.5
6654, 1.8666666666667, 0.75, 0.5
6655, 1.8666666666667, 0.7, 0.5
6656, 1.8666666666667, 0.65, 0.5
6657, 1.8666666666667, 0.6, 0.5
6658, 1.8666666666667, 0.55, 0.5
6659, 1.8666666666667, 0.5, 0.5
6660, 1.8666666666667, 0.45, 0.5
6661, 1.8666666666667, 0.4, 0.5
6662, 1.8666666666667, 0.35, 0.5
6663, 1.8666666666667, 0.3, 0.5
6664, 1.8666666666667, 0.25, 0.5
6665, 1.8666666666667, 0.2, 0.5
6666, 1.9083333333333, 1.3, 0.5
6667, 1.9083333333333, 1.25, 0.5
6668, 1.9083333333333, 1.2, 0.5
6669, 1.9083333333333, 1.15, 0.5
6670, 1.9083333333333, 1.1, 0.5
6671, 1.9083333333333, 1.05, 0.5
6672, 1.9083333333333, 1, 0.5
6673, 1.9083333333333, 0.95, 0.5
6674, 1.9083333333333, 0.9, 0.5
6675, 1.9083333333333, 0.85, 0.5
6676, 1.9083333333333, 0.8, 0.5
6677, 1.9083333333333, 0.75, 0.5
6678, 1.9083333333333, 0.7, 0.5
6679, 1.9083333333333, 0.65, 0.5
6680, 1.9083333333333, 0.6, 0.5
6681, 1.9083333333333, 0.55, 0.5
6682, 1.9083333333333, 0.5, 0.5
6683, 1.9083333333333, 0.45, 0.5
6684, 1.9083333333333, 0.4, 0.5
6685, 1.9083333333333, 0.35, 0.5
6686, 1.9083333333333, 0.3, 0.5
6687, 1.9083333333333, 0.25, 0.5
6688, 1.9083333333333, 0.2, 0.5
6689, 1.95, 1.3, 0.5
6690, 1.95, 1.25, 0.5
6691, 1.95, 1.2, 0.5
6692, 1.95, 1.15, 0.5
6693, 1.95, 1.1, 0.5
6694, 1.95, 1.05, 0.5
6695, 1.95, 1, 0.5
6696, 1.95, 0.95, 0.5
6697, 1.95, 0.9, 0.5
6698, 1.95, 0.85, 0.5
6699, 1.95, 0.8, 0.5
6700, 1.95, 0.75, 0.5
6701, 1.95, 0.7, 0.5
6702, 1.95, 0.65, 0.5
6703, 1.95, 0.6, 0.5
6704, 1.95, 0.55, 0.5
6705, 1.95, 0.5, 0.5
6706, 1.95, 0.45, 0.5
6707, 1.95, 0.4, 0.5
6708, 1.95, 0.35, 0.5
6709, 1.95, 0.3, 0.5
6710, 1.95, 0.25, 0.5
6711, 1.95, 0.2, 0.5
6712, 1.9916666666667, 1.3, 0.5
6713, 1.9916666666667, 1.25, 0.5
6714, 1.9916666666667, 1.2, 0.5
6715, 1.9916666666667, 1.15, 0.5
6716, 1.9916666666667, 1.1, 0.5
6717, 1.9916666666667, 1.05, 0.5
6718, 1.9916666666667, 1, 0.5
6719, 1.9916666666667, 0.95, 0.5
6720, 1.9916666666667, 0.9, 0.5
6721, 1.9916666666667, 0.85, 0.5
6722, 1.9916666666667, 0.8, 0.5
6723, 1.9916666666667, 0.75, 0.5
6724, 1.9916666666667, 0.7, 0.5
6725, 1.9916666666667, 0.65, 0.5
6726, 1.9916666666667, 0.6, 0.5
6727, 1.9916666666667, 0.55, 0.5
6728, 1.9916666666667, 0.5, 0.5
6729, 1.9916666666667, 0.45, 0.5
6730, 1.9916666666667, 0.4, 0.5
6731, 1.9916666666667, 0.35, 0.5
6732, 1.9916666666667, 0.3, 0.5
6733, 1.9916666666667, 0.25, 0.5
6734, 1.9916666666667, 0.2, 0.5
6735, 2.0333333333333, 1.3, 0.5
6736, 2.0333333333333, 1.25, 0.5
6737, 2.0333333333333, 1.2, 0.5
6738, 2.0333333333333, 1.15, 0.5
6739, 2.0333333333333, 1.1, 0.5
6740, 2.0333333333333, 1.05, 0.5
6741, 2.0333333333333, 1, 0.5
6742, 2.0333333333333, 0.95, 0.5
6743, 2.0333333333333, 0.9, 0.5
6744, 2.0333333333333, 0.85, 0.5
6745, 2.0333333333333, 0.8, 0.5
6746, 2.0333333333333, 0.75, 0.5
6747, 2.0333333333333, 0.7, 0.5
6748, 2.0333333333333, 0.65, 0.5
6749, 2.0333333333333, 0.6, 0.5
6750, 2.0333333333333, 0.55, 0.5
6751, 2.0333333333333, 0.5, 0.5
6752, 2.0333333333333, 0.45, 0.5
6753, 2.0333333333333, 0.4, 0.5
6754, 2.0333333333333, 0.35, 0.5
6755, 2.0333333333333, 0.3, 0.5
6756, 2.0333333333333, 0.25, 0.5
6757, 2.0333333333333, 0.2, 0.5
6758, 2.075, 1.3, 0.5
6759, 2.075, 1.25, 0.5
6760, 2.075, 1.2, 0.5
6761, 2.075, 1.15, 0.5
6762, 2.075, 1.1, 0.5
6763, 2.075, 1.05, 0.5
6764, 2.075, 1, 0.5
6765, 2.075, 0.95, 0.5
6766, 2.075, 0.9, 0.5
6767, 2.075, 0.85, 0.5
6768, 2.075, 0.8, 0.5
6769, 2.075, 0.75, 0.5
6770, 2.075, 0.7, 0.5
6771, 2.075, 0.65, 0.5
6772, 2.075, 0.6, 0.5
6773, 2.075, 0.55, 0.5
6774, 2.075, 0.5, 0.5
6775, 2.075, 0.45, 0.5
6776, 2.075, 0.4, 0.5
6777, 2.075, 0.35, 0.5
6778, 2.075, 0.3, 0.5
6779, 2.075, 0.25, 0.5
6780, 2.075, 0.2, 0.5
6781, 2.1166666666667, 1.3, 0.5
6782, 2.1166666666667, 1.25, 0.5
6783, 2.1166666666667, 1.2, 0.5
6784, 2.1166666666667, 1.15, 0.5
6785, 2.1166666666667, 1.1, 0.5
6786, 2.1166666666667, 1.05, 0.5
6787, 2.1166666666667, 1, 0.5
6788, 2.1166666666667, 0.95, 0.5
6789, 2.1166666666667, 0.9, 0.5
6790, 2.1166666666667, 0.85, 0.5
6791, 2.1166666666667, 0.8, 0.5
6792, 2.1166666666667, 0.75, 0.5
6793, 2.1166666666667, 0.7, 0.5
6794, 2.1166666666667, 0.65, 0.5
6795, 2.1166666666667, 0.6, 0.5
6796, 2.1166666666667, 0.55, 0.5
6797, 2.1166666666667, 0.5, 0.5
6798, 2.1166666666667, 0.45, 0.5
6799, 2.1166666666667, 0.4, 0.5
6800, 2.1166666666667, 0.35, 0.5
6801, 2.1166666666667, 0.3, 0.5
6802, 2.1166666666667, 0.25, 0.5
6803, 2.1166666666667, 0.2, 0.5
6804, 2.1583333333333, 1.3, 0.5
6805, 2.1583333333333, 1.25, 0.5
6806, 2.1583333333333, 1.2, 0.5
6807, 2.1583333333333, 1.15, 0.5
6808, 2.1583333333333, 1.1, 0.5
6809, 2.1583333333333, 1.05, 0.5
6810, 2.1583333333333, 1, 0.5
6811, 2.1583333333333, 0.95, 0.5
6812, 2.1583333333333, 0.9, 0.5
6813, 2.1583333333333, 0.85, 0.5
6814, 2.1583333333333, 0.8, 0.5
6815, 2.1583333333333, 0.75, 0.5
6816, 2.1583333333333, 0.7, 0.5
6817, 2.1583333333333, 0.65, 0.5
6818, 2.1583333333333, 0.6, 0.5
6819, 2.1583333333333, 0.55, 0.5
6820, 2.1583333333333, 0.5, 0.5
6821, 2.1583333333333, 0.45, 0.5
6822, 2.1583333333333, 0.4, 0.5
6823, 2.1583333333333, 0.35, 0.5
6824, 2.1583333333333, 0.3, 0.5
6825, 2.1583333333333, 0.25, 0.5
6826, 2.1583333333333, 0.2, 0.5
6827, 1.2416666666667, 1.3, 0
6828, 1.2416666666667, 1.25, 0
6829, 1.2416666666667, 1.2, 0
6830, 1.2416666666667, 1.15, 0
6831, 1.2416666666667, 1.1, 0
6832, 1.2416666666667, 1.05, 0
6833, 1.2416666666667, 1, 0
6834, 1.2416666666667, 0.95, 0
6835, 1.2416666666667, 0.9, 0
6836, 1.2416666666667, 0.85, 0
6837, 1.2416666666667, 0.8, 0
6838, 1.2416666666667, 0.75, 0
6839, 1.2416666666667, 0.7, 0
6840, 1.2416666666667, 0.65, 0
6841, 1.2416666666667, 0.6, 0
6842, 1.2416666666667, 0.55, 0
6843, 1.2416666666667, 0.5, 0
6844, 1.2416666666667, 0.45, 0
6845, 1.2416666666667, 0.4, 0
6846, 1.2416666666667, 0.35, 0
6847, 1.2416666666667, 0.3, 0
6848, 1.2416666666667, 0.25, 0
6849, 1.2416666666667, 0.2, 0
6850, 1.2833333333333, 1.3, 0
6851, 1.2833333333333, 1.25, 0
6852, 1.2833333333333, 1.2, 0
6853, 1.2833333333333, 1.15, 0
6854, 1.2833333333333, 1.1, 0
6855, 1.2833333333333, 1.05, 0
6856, 1.2833333333333, 1, 0
6857, 1.2833333333333, 0.95, 0
6858, 1.2833333333333, 0.9, 0
6859, 1.2833333333333, 0.85, 0
6860, 1.2833333333333, 0.8, 0
6861, 1.2833333333333, 0.75, 0
6862, 1.2833333333333, 0.7, 0
6863, 1.2833333333333, 0.65, 0
6864, 1.2833333333333, 0.6, 0
6865, 1.2833333333333, 0.55, 0
6866, 1.2833333333333, 0.5, 0
6867, 1.2833333333333, 0.45, 0
6868, 1.2833333333333, 0.4, 0
6869, 1.2833333333333, 0.35, 0
6870, 1.2833333333333, 0.3, 0
6871, 1.2833333333333, 0.25, 0
6872, 1.2833333333333, 0.2, 0
6873, 1.325, 1.3, 0
6874, 1.325, 1.25, 0
6875, 1.325, 1.2, 0
6876, 1.325, 1.15, 0
6877, 1.325, 1.1, 0
6878, 1.325, 1.05, 0
6879, 1.325, 1, 0
6880, 1.325, 0.95, 0
6881, 1.325, 0.9, 0
6882, 1.325, 0.85, 0
6883, 1.325, 0.8, 0
6884, 1.325, 0.75, 0
6885, 1.325, 0.7, 0
6886, 1.325, 0.65, 0
6887, 1.325, 0.6, 0
6888, 1.325, 0.55, 0
6889, 1.325, 0.5, 0
6890, 1.325, 0.45, 0
6891, 1.325, 0.4, 0
6892, 1.325, 0.35, 0
6893, 1.325, 0.3, 0
6894, 1.325, 0.25, 0
6895, 1.325, 0.2, 0
6896, 1.3666666666667, 1.3, 0
6897, 1.3666666666667, 1.25, 0
6898, 1.3666666666667, 1.2, 0
6899, 1.3666666666667, 1.15, 0
6900, 1.3666666666667, 1.1, 0
6901, 1.3666666666667, 1.05, 0
6902, 1.3666666666667, 1, 0
6903, 1.3666666666667, 0.95, 0
6904, 1.3666666666667, 0.9, 0
6905, 1.3666666666667, 0.85, 0
6906, 1.3666666666667, 0.8, 0
6907, 1.3666666666667, 0.75, 0
6908, 1.3666666666667, 0.7, 0
6909, 1.3666666666667, 0.65, 0
6910, 1.3666666666667, 0.6, 0
6911, 1.3666666666667, 0.55, 0
6912, 1.3666666666667, 0.5, 0
6913, 1.3666666666667, 0.45, 0
6914, 1.3666666666667, 0.4, 0
6915, 1.3666666666667, 0.35, 0
6916, 1.3666666666667, 0.3, 0
6917, 1.3666666666667, 0.25, 0
6918, 1.3666666666667, 0.2, 0
6919, 1.4083333333333, 1.3, 0
6920, 1.4083333333333, 1.25, 0
6921, 1.4083333333333, 1.2, 0
6922, 1.4083333333333, 1.15, 0
6923, 1.4083333333333, 1.1, 0
6924, 1.4083333333333, 1.05, 0
6925, 1.4083333333333, 1, 0
6926, 1.4083333333333, 0.95, 0
6927, 1.4083333333333, 0.9, 0
6928, 1.4083333333333, 0.85, 0
6929, 1.4083333333333, 0.8, 0
6930, 1.4083333333333, 0.75, 0
6931, 1.4083333333333, 0.7, 0
6932, 1.4083333333333, 0.65, 0
6933, 1.4083333333333, 0.6, 0
6934, 1.4083333333333, 0.55, 0
6935, 1.4083333333333, 0.5, 0
6936, 1.4083333333333, 0.45, 0
6937, 1.4083333333333, 0.4, 0
6938, 1.4083333333333, 0.35, 0
6939, 1.4083333333333, 0.3, 0
6940, 1.4083333333333, 0.25, 0
6941, 1.4083333333333, 0.2, 0
6942, 1.45, 1.3, 0
6943, 1.45, 1.25, 0
6944, 1.45, 1.2, 0
6945, 1.45, 1.15, 0
6946, 1.45, 1.1, 0
6947, 1.45, 1.05, 0
6948, 1.45, 1, 0
6949, 1.45, 0.95, 0
6950, 1.45, 0.9, 0
6951, 1.45, 0.85, 0
6952, 1.45, 0.8, 0
6953, 1.45, 0.75, 0
6954, 1.45, 0.7, 0
6955, 1.45, 0.65, 0
6956, 1.45, 0.6, 0
6957, 1.45, 0.55, 0
6958, 1.45, 0.5, 0
6959, 1.45, 0.45, 0
6960, 1.45, 0.4, 0
6961, 1.45, 0.35, 0
6962, 1.45, 0.3, 0
6963, 1.45, 0.25, 0
6964, 1.45, 0.2, 0
6965, 1.4916666666667, 1.3, 0
6966, 1.4916666666667, 1.25, 0
6967, 1.4916666666667, 1.2, 0
6968, 1.4916666666667, 1.15, 0
6969, 1.4916666666667, 1.1, 0
6970, 1.4916666666667, 1.05, 0
6971, 1.4916666666667, 1, 0
6972, 1.4916666666667, 0.95, 0
6973, 1.4916666666667, 0.9, 0
6974, 1.4916666666667, 0.85, 0
6975, 1.4916666666667, 0.8, 0
6976, 1.4916666666667, 0.75, 0
6977, 1.4916666666667, 0.7, 0
6978, 1.4916666666667, 0.65, 0
6979, 1.4916666666667, 0.6, 0
6980, 1.4916666666667, 0.55, 0
6981, 1.4916666666667, 0.5, 0
6982, 1.4916666666667, 0.45, 0
6983, 1.4916666666667, 0.4, 0
6984, 1.4916666666667, 0.35, 0
6985, 1.4916666666667, 0.3, 0
6986, 1.4916666666667, 0.25, 0
6987, 1.4916666666667, 0.2, 0
6988, 1.5333333333333, 1.3, 0
6989, 1.5333333333333, 1.25, 0
6990, 1.5333333333333, 1.2, 0
6991, 1.5333333333333, 1.15, 0
6992, 1.5333333333333, 1.1, 0
6993, 1.5333333333333, 1.05, 0
6994, 1.5333333333333, 1, 0
6995, 1.5333333333333, 0.95, 0
6996, 1.5333333333333, 0.9, 0
6997, 1.5333333333333, 0.85, 0
6998, 1.5333333333333, 0.8, 0
6999, 1.5333333333333, 0.75, 0
7000, 1.5333333333333, 0.7, 0
7001, 1.5333333333333, 0.65, 0
7002, 1.5333333333333, 0.6, 0
7003, 1.5333333333333, 0.55, 0
7004, 1.5333333333333, 0.5, 0
7005, 1.5333333333333, 0.45, 0
7006, 1.5333333333333, 0.4, 0
7007, 1.5333333333333, 0.35, 0
7008, 1.5333333333333, 0.3, 0
7009, 1.5333333333333, 0.25, 0
7010, 1.5333333333333, 0.2, 0
7011, 1.575, 1.3, 0
7012, 1.575, 1.25, 0
7013, 1.575, 1.2, 0
7014, 1.575, 1.15, 0
7015, 1.575, 1.1, 0
7016, 1.575, 1.05, 0
7017, 1.575, 1, 0
7018, 1.575, 0.95, 0
7019, 1.575, 0.9, 0
7020, 1.575, 0.85, 0
7021, 1.575, 0.8, 0
7022, 1.575, 0.75, 0
7023, 1.575, 0.7, 0
7024, 1.575, 0.65, 0
7025, 1.575, 0.6, 0
7026, 1.575, 0.55, 0
7027, 1.575, 0.5, 0
7028, 1.575, 0.45, 0
7029, 1.575, 0.4, 0
7030, 1.575, 0.35, 0
7031, 1.575, 0.3, 0
7032, 1.575, 0.25, 0
7033, 1.575, 0.2, 0
7034, 1.6166666666667, 1.3, 0
7035, 1.6166666666667, 1.25, 0
7036, 1.6166666666667, 1.2, 0
7037, 1.6166666666667, 1.15, 0
7038, 1.6166666666667, 1.1, 0
7039, 1.6166666666667, 1.05, 0
7040, 1.6166666666667, 1, 0
7041, 1.6166666666667, 0.95, 0
7042, 1.6166666666667, 0.9, 0
7043, 1.6166666666667, 0.85, 0
7044, 1.6166666666667, 0.8, 0
7045, 1.6166666666667, 0.75, 0
7046, 1.6166666666667, 0.7, 0
7047, 1.6166666666667, 0.65, 0
7048, 1.6166666666667, 0.6, 0
7049, 1.6166666666667, 0.55, 0
7050, 1.6166666666667, 0.5, 0
7051, 1.6166666666667, 0.45, 0
7052, 1.6166666666667, 0.4, 0
7053, 1.6166666666667, 0.35, 0
7054, 1.6166666666667, 0.3, 0
7055, 1.6166666666667, 0.25, 0
7056, 1.6166666666667, 0.2, 0
7057, 1.6583333333333, 1.3, 0
7058, 1.6583333333333, 1.25, 0
7059, 1.6583333333333, 1.2, 0
7060, 1.6583333333333, 1.15, 0
7061, 1.6583333333333, 1.1, 0
7062, 1.6583333333333, 1.05, 0
7063, 1.6583333333333, 1, 0
7064, 1.6583333333333, 0.95, 0
7065, 1.6583333333333, 0.9, 0
7066, 1.6583333333333, 0.85, 0
7067, 1.6583333333333, 0.8, 0
7068, 1.6583333333333, 0.75, 0
7069, 1.6583333333333, 0.7, 0
7070, 1.6583333333333, 0.65, 0
7071, 1.6583333333333, 0.6, 0
7072, 1.6583333333333, 0.55, 0
7073, 1.6583333333333, 0.5, 0
7074, 1.6583333333333, 0.45, 0
7075, 1.6583333333333, 0.4, 0
7076, 1.6583333333333, 0.35, 0
7077, 1.6583333333333, 0.3, 0
7078, 1.6583333333333, 0.25, 0
7079, 1.6583333333333, 0.2, 0
7080, 1.7, 1.3, 0
7081, 1.7, 1.25, 0
7082, 1.7, 1.2, 0
7083, 1.7, 1.15, 0
7084, 1.7, 1.1, 0
7085, 1.7, 1.05, 0
7086, 1.7, 1, 0
7087, 1.7, 0.95, 0
7088, 1.7, 0.9, 0
7089, 1.7, 0.85, 0
7090, 1.7, 0.8, 0
7091, 1.7, 0.75, 0
7092, 1.7, 0.7, 0
7093, 1.7, 0.65, 0
7094, 1.7, 0.6, 0
7095, 1.7, 0.55, 0
7096, 1.7, 0.5, 0
7097, 1.7, 0.45, 0
7098, 1.7, 0.4, 0
7099, 1.7, 0.35, 0
7100, 1.7, 0.3, 0
7101, 1.7, 0.25, 0
7102, 1.7, 0.2, 0
7103, 1.7416666666667, 1.3, 0
7104, 1.7416666666667, 1.25, 0
7105, 1.7416666666667, 1.2, 0
7106, 1.7416666666667, 1.15, 0
7107, 1.7416666666667, 1.1, 0
7108, 1.7416666666667, 1.05, 0
7109, 1.7416666666667, 1, 0
7110, 1.7416666666667, 0.95, 0
7111, 1.7416666666667, 0.9, 0
7112, 1.7416666666667, 0.85, 0
7113, 1.7416666666667, 0.8, 0
7114, 1.7416666666667, 0.75, 0
7115, 1.7416666666667, 0.7, 0
7116, 1.7416666666667, 0.65, 0
7117, 1.7416666666667, 0.6, 0
7118, 1.7416666666667, 0.55, 0
7119, 1.7416666666667, 0.5, 0
7120, 1.7416666666667, 0.45, 0
7121, 1.7416666666667, 0.4, 0
7122, 1.7416666666667, 0.35, 0
7123, 1.7416666666667, 0.3, 0
7124, 1.7416666666667, 0.25, 0
7125, 1.7416666666667, 0.2, 0
7126, 1.7833333333333, 1.3, 0
7127, 1.7833333333333, 1.25, 0
7128, 1.7833333333333, 1.2, 0
7129, 1.7833333333333, 1.15, 0
7130, 1.7833333333333, 1.1, 0
7131, 1.7833333333333, 1.05, 0
7132, 1.7833333333333, 1, 0
7133, 1.7833333333333, 0.95, 0
7134, 1.7833333333333, 0.9, 0
7135, 1.7833333333333, 0.85, 0
7136, 1.7833333333333, 0.8, 0
7137, 1.7833333333333, 0.75, 0
7138, 1.7833333333333, 0.7, 0
7139, 1.7833333333333, 0.65, 0
7140, 1.7833333333333, 0.6, 0
7141, 1.7833333333333, 0.55, 0
7142, 1.7833333333333, 0.5, 0
7143, 1.7833333333333, 0.45, 0
7144, 1.7833333333333, 0.4, 0
7145, 1.7833333333333, 0.35, 0
7146, 1.7833333333333, 0.3, 0
7147, 1.7833333333333, 0.25, 0
7148, 1.7833333333333, 0.2, 0
7149, 1.825, 1.3, 0
7150, 1.825, 1.25, 0
7151, 1.825, 1.2, 0
7152, 1.825, 1.15, 0
7153, 1.825, 1.1, 0
7154, 1.825, 1.05, 0
7155, 1.825, 1, 0
7156, 1.825, 0.95, 0
7157, 1.825, 0.9, 0
7158, 1.825, 0.85, 0
7159, 1.825, 0.8, 0
7160, 1.825, 0.75, 0
7161, 1.825, 0.7, 0
7162, 1.825, 0.65, 0
7163, 1.825, 0.6, 0
7164, 1.825, 0.55, 0
7165, 1.825, 0.5, 0
7166, 1.825, 0.45, 0
7167, 1.825, 0.4, 0
7168, 1.825, 0.35, 0
7169, 1.825, 0.3, 0
7170, 1.825, 0.25, 0
7171, 1.825, 0.2, 0
7172, 1.8666666666667, 1.3, 0
7173, 1.8666666666667, 1.25, 0
7174, 1.8666666666667, 1.2, 0
7175, 1.8666666666667, 1.15, 0
7176, 1.8666666666667, 1.1, 0
7177, 1.8666666666667, 1.05, 0
7178, 1.8666666666667, 1, 0
7179, 1.8666666666667, 0.95, 0
7180, 1.8666666666667, 0.9, 0
7181, 1.8666666666667, 0.85, 0
7182, 1.8666666666667, 0.8, 0
7183, 1.8666666666667, 0.75, 0
7184, 1.8666666666667, 0.7, 0
7185, 1.8666666666667, 0.65, 0
7186, 1.8666666666667, 0.6, 0
7187, 1.8666666666667, 0.55, 0
7188, 1.8666666666667, 0.5, 0
7189, 1.8666666666667, 0.45, 0
7190, 1.8666666666667, 0.4, 0
7191, 1.8666666666667, 0.35, 0
7192, 1.8666666666667, 0.3, 0
7193, 1.8666666666667, 0.25, 0
7194, 1.8666666666667, 0.2, 0
7195, 1.9083333333333, 1.3, 0
7196, 1.9083333333333, 1.25, 0
7197, 1.9083333333333, 1.2, 0
7198, 1.9083333333333, 1.15, 0
7199, 1.9083333333333, 1.1, 0
7200, 1.9083333333333, 1.05, 0
7201, 1.9083333333333, 1, 0
7202, 1.9083333333333, 0.95, 0
7203, 1.9083333333333, 0.9, 0
7204, 1.9083333333333, 0.85, 0
7205, 1.9083333333333, 0.8, 0
7206, 1.9083333333333, 0.75, 0
7207, 1.9083333333333, 0.7, 0
7208, 1.9083333333333, 0.65, 0
7209, 1.9083333333333, 0.6, 0
7210, 1.9083333333333, 0.55, 0
7211, 1.9083333333333, 0.5, 0
7212, 1.9083333333333, 0.45, 0
7213, 1.9083333333333, 0.4, 0
7214, 1.9083333333333, 0.35, 0
7215, 1.9083333333333, 0.3, 0
7216, 1.9083333333333, 0.25, 0
7217, 1.9083333333333, 0.2, 0
7218, 1.95, 1.3, 0
7219, 1.95, 1.25, 0
7220, 1.95, 1.2, 0
7221, 1.95, 1.15, 0
7222, 1.95, 1.1, 0
7223, 1.95, 1.05, 0
7224, 1.95, 1, 0
7225, 1.95, 0.95, 0
7226, 1.95, 0.9, 0
7227, 1.95, 0.85, 0
7228, 1.95, 0.8, 0
7229, 1.95, 0.75, 0
7230, 1.95, 0.7, 0
7231, 1.95, 0.65, 0
7232, 1.95, 0.6, 0
7233, 1.95, 0.55, 0
7234, 1.95, 0.5, 0
7235, 1.95, 0.45, 0
7236, 1.95, 0.4, 0
7237, 1.95, 0.35, 0
7238, 1.95, 0.3, 0
7239, 1.95, 0.25, 0
7240, 1.95, 0.2, 0
7241, 1.9916666666667, 1.3, 0
7242, 1.9916666666667, 1.25, 0
7243, 1.9916666666667, 1.2, 0
7244, 1.9916666666667, 1.15, 0
7245, 1.9916666666667, 1.1, 0
7246, 1.9916666666667, 1.05, 0
7247, 1.9916666666667, 1, 0
7248, 1.9916666666667, 0.95, 0
7249, 1.9916666666667, 0.9, 0
7250, 1.9916666666667, 0.85, 0
7251, 1.9916666666667, 0.8, 0
7252, 1.9916666666667, 0.75, 0
7253, 1.9916666666667, 0.7, 0
7254, 1.9916666666667, 0.65, 0
7255, 1.9916666666667, 0.6, 0
7256, 1.9916666666667, 0.55, 0
7257, 1.9916666666667, 0.5, 0
7258, 1.9916666666667, 0.45, 0
7259, 1.9916666666667, 0.4, 0
7260, 1.9916666666667, 0.35, 0
7261, 1.9916666666667, 0.3, 0
7262, 1.9916666666667, 0.25, 0
7263, 1.9916666666667, 0.2, 0
7264, 2.0333333333333, 1.3, 0
7265, 2.0333333333333, 1.25, 0
7266, 2.0333333333333, 1.2, 0
7267, 2.0333333333333, 1.15, 0
7268, 2.0333333333333, 1.1, 0
7269, 2.0333333333333, 1.05, 0
7270, 2.0333333333333, 1, 0
7271, 2.0333333333333, 0.95, 0
7272, 2.0333333333333, 0.9, 0
7273, 2.0333333333333, 0.85, 0
7274, 2.0333333333333, 0.8, 0
7275, 2.0333333333333, 0.75, 0
7276, 2.0333333333333, 0.7, 0
7277, 2.0333333333333, 0.65, 0
7278, 2.0333333333333, 0.6, 0
7279, 2.0333333333333, 0.55, 0
7280, 2.0333333333333, 0.5, 0
7281, 2.0333333333333, 0.45, 0
7282, 2.0333333333333, 0.4, 0
7283, 2.0333333333333, 0.35, 0
7284, 2.0333333333333, 0.3, 0
7285, 2.0333333333333, 0.25, 0
7286, 2.0333333333333, 0.2, 0
7287, 2.075, 1.3, 0
7288, 2.075, 1.25, 0
7289, 2.075, 1.2, 0
7290, 2.075, 1.15, 0
7291, 2.075, 1.1, 0
7292, 2.075, 1.05, 0
7293, 2.075, 1, 0
7294, 2.075, 0.95, 0
7295, 2.075, 0.9, 0
7296, 2.075, 0.85, 0
7297, 2.075, 0.8, 0
7298, 2.075, 0.75, 0
7299, 2.075, 0.7, 0
7300, 2.075, 0.65, 0
7301, 2.075, 0.6, 0
7302, 2.075, 0.55, 0
7303, 2.075, 0.5, 0
7304, 2.075, 0.45, 0
7305, 2.075, 0.4, 0
7306, 2.075, 0.35, 0
7307, 2.075, 0.3, 0
7308, 2.075, 0.25, 0
7309, 2.075, 0.2, 0
7310, 2.1166666666667, 1.3, 0
7311, 2.1166666666667, 1.25, 0
7312, 2.1166666666667, 1.2, 0
7313, 2.1166666666667, 1.15, 0
7314, 2.1166666666667, 1.1, 0
7315, 2.1166666666667, 1.05, 0
7316, 2.1166666666667, 1, 0
7317, 2.1166666666667, 0.95, 0
7318, 2.1166666666667, 0.9, 0
7319, 2.1166666666667, 0.85, 0
7320, 2.1166666666667, 0.8, 0
7321, 2.1166666666667, 0.75, 0
7322, 2.1166666666667, 0.7, 0
7323, 2.1166666666667, 0.65, 0
7324, 2.1166666666667, 0.6, 0
7325, 2.1166666666667, 0.55, 0
7326, 2.1166666666667, 0.5, 0
7327, 2.1166666666667, 0.45, 0
7328, 2.1166666666667, 0.4, 0
7329, 2.1166666666667, 0.35, 0
7330, 2.1166666666667, 0.3, 0
7331, 2.1166666666667, 0.25, 0
7332, 2.1166666666667, 0.2, 0
7333, 2.1583333333333, 1.3, 0
7334, 2.1583333333333, 1.25, 0
7335, 2.1583333333333, 1.2, 0
7336, 2.1583333333333, 1.15, 0
7337, 2.1583333333333, 1.1, 0
7338, 2.1583333333333, 1.05, 0
7339, 2.1583333333333, 1, 0
7340, 2.1583333333333, 0.95, 0
7341, 2.1583333333333, 0.9, 0
7342, 2.1583333333333, 0.85, 0
7343, 2.1583333333333, 0.8, 0
7344, 2.1583333333333, 0.75, 0
7345, 2.1583333333333, 0.7, 0
7346, 2.1583333333333, 0.65, 0
7347, 2.1583333333333, 0.6, 0
7348, 2.1583333333333, 0.55, 0
7349, 2.1583333333333, 0.5, 0
7350, 2.1583333333333, 0.45, 0
7351, 2.1583333333333, 0.4, 0
7352, 2.1583333333333, 0.35, 0
7353, 2.1583333333333, 0.3, 0
7354, 2.1583333333333, 0.25, 0
7355, 2.1583333333333, 0.2, 0
7356, 1.2, 1.3, 0.041666666666667
7357, 1.2, 1.25, 0.041666666666667
7358, 1.2, 1.2, 0.041666666666667
7359, 1.2, 1.15, 0.041666666666667
7360, 1.2, 1.1, 0.041666666666667
7361, 1.2, 1.05, 0.041666666666667
7362, 1.2, 1, 0.041666666666667
7363, 1.2, 0.95, 0.041666666666667
7364, 1.2, 0.9, 0.041666666666667
7365, 1.2, 0.85, 0.041666666666667
7366, 1.2, 0.8, 0.041666666666667
7367, 1.2, 0.75, 0.041666666666667
7368, 1.2, 0.7, 0.041666666666667
7369, 1.2, 0.65, 0.041666666666667
7370, 1.2, 0.6, 0.041666666666667
7371, 1.2, 0.55, 0.041666666666667
7372, 1.2, 0.5, 0.041666666666667
7373, 1.2, 0.45, 0.041666666666667
7374, 1.2, 0.4, 0.041666666666667
7375, 1.2, 0.35, 0.041666666666667
7376, 1.2, 0.3, 0.041666666666667
7377, 1.2, 0.25, 0.041666666666667
7378, 1.2, 0.2, 0.041666666666667
7379, 1.2, 1.3, 0.083333333333333
7380, 1.2, 1.25, 0.083333333333333
7381, 1.2, 1.2, 0.083333333333333
7382, 1.2, 1.15, 0.083333333333333
7383, 1.2, 1.1, 0.083333333333333
7384, 1.2, 1.05, 0.083333333333333
7385, 1.2, 1, 0.083333333333333
7386, 1.2, 0.95, 0.083333333333333
7387, 1.2, 0.9, 0.083333333333333
7388, 1.2, 0.85, 0.083333333333333
7389, 1.2, 0.8, 0.083333333333333
7390, 1.2, 0.75, 0.083333333333333
7391, 1.2, 0.7, 0.083333333333333
7392, 1.2, 0.65, 0.083333333333333
7393, 1.2, 0.6, 0.083333333333333
7394, 1.2, 0.55, 0.083333333333333
7395, 1.2, 0.5, 0.083333333333333
7396, 1.2, 0.45, 0.083333333333333
7397, 1.2, 0.4, 0.083333333333333
7398, 1.2, 0.35, 0.083333333333333
7399, 1.2, 0.3, 0.083333333333333
7400, 1.2, 0.25, 0.083333333333333
7401, 1.2, 0.2, 0.083333333333333
7402, 1.2, 1.3, 0.125
7403, 1.2, 1.25, 0.125
7404, 1.2, 1.2, 0.125
7405, 1.2, 1.15, 0.125
7406, 1.2, 1.1, 0.125
7407, 1.2, 1.05, 0.125
7408, 1.2, 1, 0.125
7409, 1.2, 0.95, 0.125
7410, 1.2, 0.9, 0.125
7411, 1.2, 0.85, 0.125
7412, 1.2, 0.8, 0.125
7413, 1.2, 0.75, 0.125
7414, 1.2, 0.7, 0.125
7415, 1.2, 0.65, 0.125
7416, 1.2, 0.6, 0.125
7417, 1.2, 0.55, 0.125
7418, 1.2, 0.5, 0.125
7419, 1.2, 0.45, 0.125
7420, 1.2, 0.4, 0.125
7421, 1.2, 0.35, 0.125
7422, 1.2, 0.3, 0.125
7423, 1.2, 0.25, 0.125
7424, 1.2, 0.2, 0.125
7425, 1.2, 1.3, 0.16666666666667
7426, 1.2, 1.25, 0.16666666666667
7427, 1.2, 1.2, 0.16666666666667
7428, 1.2, 1.15, 0.16666666666667
7429, 1.2, 1.1, 0.16666666666667
7430, 1.2, 1.05, 0.16666666666667
7431, 1.2, 1, 0.16666666666667
7432, 1.2, 0.95, 0.16666666666667
7433, 1.2, 0.9, 0.16666666666667
7434, 1.2, 0.85, 0.16666666666667
7435, 1.2, 0.8, 0.16666666666667
7436, 1.2, 0.75, 0.16666666666667
7437, 1.2, 0.7, 0.16666666666667
7438, 1.2, 0.65, 0.16666666666667
7439, 1.2, 0.6, 0.16666666666667
7440, 1.2, 0.55, 0.16666666666667
7441, 1.2, 0.5, 0.16666666666667
7442, 1.2, 0.45, 0.16666666666667
7443, 1.2, 0.4, 0.16666666666667
7444, 1.2, 0.35, 0.16666666666667
7445, 1.2, 0.3, 0.16666666666667
7446, 1.2, 0.25, 0.16666666666667
7447, 1.2, 0.2, 0.16666666666667
7448, 1.2, 1.3, 0.20833333333333
7449, 1.2, 1.25, 0.20833333333333
7450, 1.2, 1.2, 0.20833333333333
7451, 1.2, 1.15, 0.20833333333333
7452, 1.2, 1.1, 0.20833333333333
7453, 1.2, 1.05, 0.20833333333333
7454, 1.2, 1, 0.20833333333333
7455, 1.2, 0.95, 0.20833333333333
7456, 1.2, 0.9, 0.20833333333333
7457, 1.2, 0.85, 0.20833333333333
7458, 1.2, 0.8, 0.20833333333333
7459, 1.2, 0.75, 0.20833333333333
7460, 1.2, 0.7, 0.20833333333333
7461, 1.2, 0.65, 0.20833333333333
7462, 1.2, 0.6, 0.20833333333333
7463, 1.2, 0.55, 0.20833333333333
7464, 1.2, 0.5, 0.20833333333333
7465, 1.2, 0.45, 0.20833333333333
7466, 1.2, 0.4, 0.20833333333333
7467, 1.2, 0.35, 0.20833333333333
7468, 1.2, 0.3, 0.20833333333333
7469, 1.2, 0.25, 0.20833333333333
7470, 1.2, 0.2, 0.20833333333333
7471, 1.2, 1.3, 0.25
7472, 1.2, 1.25, 0.25
7473, 1.2, 1.2, 0.25
7474, 1.2, 1.15, 0.25
7475, 1.2, 1.1, 0.25
7476, 1.2, 1.05, 0.25
7477, 1.2, 1, 0.25
7478, 1.2, 0.95, 0.25
7479, 1.2, 0.9, 0.25
7480, 1.2, 0.85, 0.25
7481, 1.2, 0.8, 0.25
7482, 1.2, 0.75, 0.25
7483, 1.2, 0.7, 0.25
7484, 1.2, 0.65, 0.25
7485, 1.2, 0.6, 0.25
7486, 1.2, 0.55, 0.25
7487, 1.2, 0.5, 0.25
7488, 1.2, 0.45, 0.25
7489, 1.2, 0.4, 0.25
7490, 1.2, 0.35, 0.25
7491, 1.2, 0.3, 0.25
7492, 1.2, 0.25, 0.25
7493, 1.2, 0.2, 0.25
7494, 1.2, 1.3, 0.29166666666667
7495, 1.2, 1.25, 0.29166666666667
7496, 1.2, 1.2, 0.29166666666667
7497, 1.2, 1.15, 0.29166666666667
7498, 1.2, 1.1, 0.29166666666667
7499, 1.2, 1.05, 0.29166666666667
7500, 1.2, 1, 0.29166666666667
7501, 1.2, 0.95, 0.29166666666667
7502, 1.2, 0.9, 0.29166666666667
7503, 1.2, 0.85, 0.29166666666667
7504, 1.2, 0.8, 0.29166666666667
7505, 1.2, 0.75, 0.29166666666667
7506, 1.2, 0.7, 0.29166666666667
7507, 1.2, 0.65, 0.29166666666667
7508, 1.2, 0.6, 0.29166666666667
7509, 1.2, 0.55, 0.29166666666667
7510, 1.2, 0.5, 0.29166666666667
7511, 1.2, 0.45, 0.29166666666667
7512, 1.2, 0.4, 0.29166666666667
7513, 1.2, 0.35, 0.29166666666667
7514, 1.2, 0.3, 0.29166666666667
7515, 1.2, 0.25, 0.29166666666667
7516, 1.2, 0.2, 0.29166666666667
7517, 1.2, 1.3, 0.33333333333333
7518, 1.2, 1.25, 0.33333333333333
7519, 1.2, 1.2, 0.33333333333333
7520, 1.2, 1.15, 0.33333333333333
7521, 1.2, 1.1, 0.33333333333333
7522, 1.2, 1.05, 0.33333333333333
7523, 1.2, 1, 0.33333333333333
7524, 1.2, 0.95, 0.33333333333333
7525, 1.2, 0.9, 0.33333333333333
7526, 1.2, 0.85, 0.33333333333333
7527, 1.2, 0.8, 0.33333333333333
7528, 1.2, 0.75, 0.33333333333333
7529, 1.2, 0.7, 0.33333333333333
7530, 1.2, 0.65, 0.33333333333333
7531, 1.2, 0.6, 0.33333333333333
7532, 1.2, 0.55, 0.33333333333333
7533, 1.2, 0.5, 0.33333333333333
7534, 1.2, 0.45, 0.33333333333333
7535, 1.2, 0.4, 0.33333333333333
7536, 1.2, 0.35, 0.33333333333333
7537, 1.2, 0.3, 0.33333333333333
7538, 1.2, 0.25, 0.33333333333333
7539, 1.2, 0.2, 0.33333333333333
7540, 1.2, 1.3, 0.375
7541, 1.2, 1.25, 0.375
7542, 1.2, 1.2, 0.375
7543, 1.2, 1.15, 0.375
7544, 1.2, 1.1, 0.375
7545, 1.2, 1.05, 0.375
7546, 1.2, 1, 0.375
7547, 1.2, 0.95, 0.375
7548, 1.2, 0.9, 0.375
7549, 1.2, 0.85, 0.375
7550, 1.2, 0.8, 0.375
7551, 1.2, 0.75, 0.375
7552, 1.2, 0.7, 0.375
7553, 1.2, 0.65, 0.375
7554, 1.2, 0.6, 0.375
7555, 1.2, 0.55, 0.375
7556, 1.2, 0.5, 0.375
7557, 1.2, 0.45, 0.375
7558, 1.2, 0.4, 0.375
7559, 1.2, 0.35, 0.375
7560, 1.2, 0.3, 0.375
7561, 1.2, 0.25, 0.375
7562, 1.2, 0.2, 0.375
7563, 1.2, 1.3, 0.41666666666667
7564, 1.2, 1.25, 0.41666666666667
7565, 1.2, 1.2, 0.41666666666667
7566, 1.2, 1.15, 0.41666666666667
7567, 1.2, 1.1, 0.41666666666667
7568, 1.2, 1.05, 0.41666666666667
7569, 1.2, 1, 0.41666666666667
7570, 1.2, 0.95, 0.41666666666667
7571, 1.2, 0.9, 0.41666666666667
7572, 1.2, 0.85, 0.41666666666667
7573, 1.2, 0.8, 0.41666666666667
7574, 1.2, 0.75, 0.41666666666667
7575, 1.2, 0.7, 0.41666666666667
7576, 1.2, 0.65, 0.41666666666667
7577, 1.2, 0.6, 0.41666666666667
7578, 1.2, 0.55, 0.41666666666667
7579, 1.2, 0.5, 0.41666666666667
7580, 1.2, 0.45, 0.41666666666667
7581, 1.2, 0.4, 0.41666666666667
7582, 1.2, 0.35, 0.41666666666667
7583, 1.2, 0.3, 0.41666666666667
7584, 1.2, 0.25, 0.41666666666667
7585, 1.2, 0.2, 0.41666666666667
7586, 1.2, 1.3, 0.45833333333333
7587, 1.2, 1.25, 0.45833333333333
7588, 1.2, 1.2, 0.45833333333333
7589, 1.2, 1.15, 0.45833333333333
7590, 1.2, 1.1, 0.45833333333333
7591, 1.2, 1.05, 0.45833333333333
7592, 1.2, 1, 0.45833333333333
7593, 1.2, 0.95, 0.45833333333333
7594, 1.2, 0.9, 0.45833333333333
7595, 1.2, 0.85, 0.45833333333333
7596, 1.2, 0.8, 0.45833333333333
7597, 1.2, 0.75, 0.45833333333333
7598, 1.2, 0.7, 0.45833333333333
7599, 1.2, 0.65, 0.45833333333333
7600, 1.2, 0.6, 0.45833333333333
7601, 1.2, 0.55, 0.45833333333333
7602, 1.2, 0.5, 0.45833333333333
7603, 1.2, 0.45, 0.45833333333333
7604, 1.2, 0.4, 0.45833333333333
7605, 1.2, 0.35, 0.45833333333333
7606, 1.2, 0.3, 0.45833333333333
7607, 1.2, 0.25, 0.45833333333333
7608, 1.2, 0.2, 0.45833333333333
7609, 2.2, 1.3, 0.041666666666667
7610, 2.2, 1.25, 0.041666666666667
7611, 2.2, 1.2, 0.041666666666667
7612, 2.2, 1.15, 0.041666666666667
7613, 2.2, 1.1, 0.041666666666667
7614, 2.2, 1.05, 0.041666666666667
7615, 2.2, 1, 0.041666666666667
7616, 2.2, 0.95, 0.041666666666667
7617, 2.2, 0.9, 0.041666666666667
7618, 2.2, 0.85, 0.041666666666667
7619, 2.2, 0.8, 0.041666666666667
7620, 2.2, 0.75, 0.041666666666667
7621, 2.2, 0.7, 0.041666666666667
7622, 2.2, 0.65, 0.041666666666667
7623, 2.2, 0.6, 0.041666666666667
7624, 2.2, 0.55, 0.041666666666667
7625, 2.2, 0.5, 0.041666666666667
7626, 2.2, 0.45, 0.041666666666667
7627, 2.2, 0.4, 0.041666666666667
7628, 2.2, 0.35, 0.041666666666667
7629, 2.2, 0.3, 0.041666666666667
7630, 2.2, 0.25, 0.041666666666667
7631, 2.2, 0.2, 0.041666666666667
7632, 2.2, 1.3, 0.083333333333333
7633, 2.2, 1.25, 0.083333333333333
7634, 2.2, 1.2, 0.083333333333333
7635, 2.2, 1.15, 0.083333333333333
7636, 2.2, 1.1, 0.083333333333333
7637, 2.2, 1.05, 0.083333333333333
7638, 2.2, 1, 0.083333333333333
7639, 2.2, 0.95, 0.083333333333333
7640, 2.2, 0.9, 0.083333333333333
7641, 2.2, 0.85, 0.083333333333333
7642, 2.2, 0.8, 0.083333333333333
7643, 2.2, 0.75, 0.083333333333333
7644, 2.2, 0.7, 0.083333333333333
7645, 2.2, 0.65, 0.083333333333333
7646, 2.2, 0.6, 0.083333333333333
7647, 2.2, 0.55, 0.083333333333333
7648, 2.2, 0.5, 0.083333333333333
7649, 2.2, 0.45, 0.083333333333333
7650, 2.2, 0.4, 0.083333333333333
7651, 2.2, 0.35, 0.083333333333333
7652, 2.2, 0.3, 0.083333333333333
7653, 2.2, 0.25, 0.083333333333333
7654, 2.2, 0.2, 0.083333333333333
7655, 2.2, 1.3, 0.125
7656, 2.2, 1.25, 0.125
7657, 2.2, 1.2, 0.125
7658, 2.2, 1.15, 0.125
7659, 2.2, 1.1, 0.125
7660, 2.2, 1.05, 0.125
7661, 2.2, 1, 0.125
7662, 2.2, 0.95, 0.125
7663, 2.2, 0.9, 0.125
7664, 2.2, 0.85, 0.125
7665, 2.2, 0.8, 0.125
7666, 2.2, 0.75, 0.125
7667, 2.2, 0.7, 0.125
7668, 2.2, 0.65, 0.125
7669, 2.2, 0.6, 0.125
7670, 2.2, 0.55, 0.125
7671, 2.2, 0.5, 0.125
7672, 2.2, 0.45, 0.125
7673, 2.2, 0.4, 0.125
7674, 2.2, 0.35, 0.125
7675, 2.2, 0.3, 0.125
7676, 2.2, 0.25, 0.125
7677, 2.2, 0.2, 0.125
7678, 2.2, 1.3, 0.16666666666667
7679, 2.2, 1.25, 0.16666666666667
7680, 2.2, 1.2, 0.16666666666667
7681, 2.2, 1.15, 0.16666666666667
7682, 2.2, 1.1, 0.16666666666667
7683, 2.2, 1.05, 0.16666666666667
7684, 2.2, 1, 0.16666666666667
7685, 2.2, 0.95, 0.16666666666667
7686, 2.2, 0.9, 0.16666666666667
7687, 2.2, 0.85, 0.16666666666667
7688, 2.2, 0.8, 0.16666666666667
7689, 2.2, 0.75, 0.16666666666667
7690, 2.2, 0.7, 0.16666666666667
7691, 2.2, 0.65, 0.16666666666667
7692, 2.2, 0.6, 0.16666666666667
7693, 2.2, 0.55, 0.16666666666667
7694, 2.2, 0.5, 0.16666666666667
7695, 2.2, 0.45, 0.16666666666667
7696, 2.2, 0.4, 0.16666666666667
7697, 2.2, 0.35, 0.16666666666667
7698, 2.2, 0.3, 0.16666666666667
7699, 2.2, 0.25, 0.16666666666667
7700, 2.2, 0.2, 0.16666666666667
7701, 2.2, 1.3, 0.20833333333333
7702, 2.2, 1.25, 0.20833333333333
7703, 2.2, 1.2, 0.20833333333333
7704, 2.2, 1.15, 0.20833333333333
7705, 2.2, 1.1, 0.20833333333333
7706, 2.2, 1.05, 0.20833333333333
7707, 2.2, 1, 0.20833333333333
7708, 2.2, 0.95, 0.20833333333333
7709, 2.2, 0.9, 0.20833333333333
7710, 2.2, 0.85, 0.20833333333333
7711, 2.2, 0.8, 0.20833333333333
7712, 2.2, 0.75, 0.20833333333333
7713, 2.2, 0.7, 0.20833333333333
7714, 2.2, 0.65, 0.20833333333333
7715, 2.2, 0.6, 0.20833333333333
7716, 2.2, 0.55, 0.20833333333333
7717, 2.2, 0.5, 0.20833333333333
7718, 2.2, 0.45, 0.20833333333333
7719, 2.2, 0.4, 0.20833333333333
7720, 2.2, 0.35, 0.20833333333333
7721, 2.2, 0.3, 0.20833333333333
7722, 2.2, 0.25, 0.20833333333333
7723, 2.2, 0.2, 0.20833333333333
7724, 2.2, 1.3, 0.25
7725, 2.2, 1.25, 0.25
7726, 2.2, 1.2, 0.25
7727, 2.2, 1.15, 0.25
7728, 2.2, 1.1, 0.25
7729, 2.2, 1.05, 0.25
7730, 2.2, 1, 0.25
7731, 2.2, 0.95, 0.25
7732, 2.2, 0.9, 0.25
7733, 2.2, 0.85, 0.25
7734, 2.2, 0.8, 0.25
7735, 2.2, 0.75, 0.25
7736, 2.2, 0.7, 0.25
7737, 2.2, 0.65, 0.25
7738, 2.2, 0.6, 0.25
7739, 2.2, 0.55, 0.25
7740, 2.2, 0.5, 0.25
7741, 2.2, 0.45, 0.25
7742, 2.2, 0.4, 0.25
7743, 2.2, 0.35, 0.25
7744, 2.2, 0.3, 0.25
7745, 2.2, 0.25, 0.25
7746, 2.2, 0.2, 0.25
7747, 2.2, 1.3, 0.29166666666667
7748, 2.2, 1.25, 0.29166666666667
7749, 2.2, 1.2, 0.29166666666667
7750, 2.2, 1.15, 0.29166666666667
7751, 2.2, 1.1, 0.29166666666667
7752, 2.2, 1.05, 0.29166666666667
7753, 2.2, 1, 0.29166666666667
7754, 2.2, 0.95, 0.29166666666667
7755, 2.2, 0.9, 0.29166666666667
7756, 2.2, 0.85, 0.29166666666667
7757, 2.2, 0.8, 0.29166666666667
7758, 2.2, 0.75, 0.29166666666667
7759, 2.2, 0.7, 0.29166666666667
7760, 2.2, 0.65, 0.29166666666667
7761, 2.2, 0.6, 0.29166666666667
7762, 2.2, 0.55, 0.29166666666667
7763, 2.2, 0.5, 0.29166666666667
7764, 2.2, 0.45, 0.29166666666667
7765, 2.2, 0.4, 0.29166666666667
7766, 2.2, 0.35, 0.29166666666667
7767, 2.2, 0.3, 0.29166666666667
7768, 2.2, 0.25, 0.29166666666667
7769, 2.2, 0.2, 0.29166666666667
7770, 2.2, 1.3, 0.33333333333333
7771, 2.2, 1.25, 0.33333333333333
7772, 2.2, 1.2, 0.33333333333333
7773, 2.2, 1.15, 0.33333333333333
7774, 2.2, 1.1, 0.33333333333333
7775, 2.2, 1.05, 0.33333333333333
7776, 2.2, 1, 0.33333333333333
7777, 2.2, 0.95, 0.33333333333333
7778, 2.2, 0.9, 0.33333333333333
7779, 2.2, 0.85, 0.33333333333333
7780, 2.2, 0.8, 0.33333333333333
7781, 2.2, 0.75, 0.33333333333333
7782, 2.2, 0.7, 0.33333333333333
7783, 2.2, 0.65, 0.33333333333333
7784, 2.2, 0.6, 0.33333333333333
7785, 2.2, 0.55, 0.33333333333333
7786, 2.2, 0.5, 0.33333333333333
7787, 2.2, 0.45, 0.33333333333333
7788, 2.2, 0.4, 0.33333333333333
7789, 2.2, 0.35, 0.33333333333333
7790, 2.2, 0.3, 0.33333333333333
7791, 2.2, 0.25, 0.33333333333333
7792, 2.2, 0.2, 0.33333333333333
7793, 2.2, 1.3, 0.375
7794, 2.2, 1.25, 0.375
7795, 2.2, 1.2, 0.375
7796, 2.2, 1.15, 0.375
7797, 2.2, 1.1, 0.375
7798, 2.2, 1.05, 0.375
7799, 2.2, 1, 0.375
7800, 2.2, 0.95, 0.375
7801, 2.2, 0.9, 0.375
7802, 2.2, 0.85, 0.375
7803, 2.2, 0.8, 0.375
7804, 2.2, 0.75, 0.375
7805, 2.2, 0.7, 0.375
7806, 2.2, 0.65, 0.375
7807, 2.2, 0.6, 0.375
7808, 2.2, 0.55, 0.375
7809, 2.2, 0.5, 0.375
7810, 2.2, 0.45, 0.375
7811, 2.2, 0.4, 0.375
7812, 2.2, 0.35, 0.375
7813, 2.2, 0.3, 0.375
7814, 2.2, 0.25, 0.375
7815, 2.2, 0.2, 0.375
7816, 2.2, 1.3, 0.41666666666667
7817, 2.2, 1.25, 0.41666666666667
7818, 2.2, 1.2, 0.41666666666667
7819, 2.2, 1.15, 0.41666666666667
7820, 2.2, 1.1, 0.41666666666667
7821, 2.2, 1.05, 0.41666666666667
7822, 2.2, 1, 0.41666666666667
7823, 2.2, 0.95, 0.41666666666667
7824, 2.2, 0.9, 0.41666666666667
7825, 2.2, 0.85, 0.41666666666667
7826, 2.2, 0.8, 0.41666666666667
7827, 2.2, 0.75, 0.41666666666667
7828, 2.2, 0.7, 0.41666666666667
7829, 2.2, 0.65, 0.41666666666667
7830, 2.2, 0.6, 0.41666666666667
7831, 2.2, 0.55, 0.41666666666667
7832, 2.2, 0.5, 0.41666666666667
7833, 2.2, 0.45, 0.41666666666667
7834, 2.2, 0.4, 0.41666666666667
7835, 2.2, 0.35, 0.41666666666667
7836, 2.2, 0.3, 0.41666666666667
7837, 2.2, 0.25, 0.41666666666667
7838, 2.2, 0.2, 0.41666666666667
7839, 2.2, 1.3, 0.45833333333333
7840, 2.2, 1.25, 0.45833333333333
7841, 2.2, 1.2, 0.45833333333333
7842, 2.2, 1.15, 0.45833333333333
7843, 2.2, 1.1, 0.45833333333333
7844, 2.2, 1.05, 0.45833333333333
7845, 2.2, 1, 0.45833333333333
7846, 2.2, 0.95, 0.45833333333333
7847, 2.2, 0.9, 0.45833333333333
7848, 2.2, 0.85, 0.45833333333333
7849, 2.2, 0.8, 0.45833333333333
7850, 2.2, 0.75, 0.45833333333333
7851, 2.2, 0.7, 0.45833333333333
7852, 2.2, 0.65, 0.45833333333333
7853, 2.2, 0.6, 0.45833333333333
7854, 2.2, 0.55, 0.45833333333333
7855, 2.2, 0.5, 0.45833333333333
7856, 2.2, 0.45, 0.45833333333333
7857, 2.2, 0.4, 0.45833333333333
7858, 2.2, 0.35, 0.45833333333333
7859, 2.2, 0.3, 0.45833333333333
7860, 2.2, 0.25, 0.45833333333333
7861, 2.2, 0.2, 0.45833333333333
7862, 1.2416666666667, 0.15, 0.041666666666667
7863, 1.2833333333333, 0.15, 0.041666666666667
7864, 1.325, 0.15, 0.041666666666667
7865, 1.3666666666667, 0.15, 0.041666666666667
7866, 1.4083333333333, 0.15, 0.041666666666667
7867, 1.45, 0.15, 0.041666666666667
7868, 1.4916666666667, 0.15, 0.041666666666667
7869, 1.5333333333333, 0.15, 0.041666666666667
7870, 1.575, 0.15, 0.041666666666667
7871, 1.6166666666667, 0.15, 0.041666666666667
7872, 1.6583333333333, 0.15, 0.041666666666667
7873, 1.7, 0.15, 0.041666666666667
7874, 1.7416666666667, 0.15, 0.041666666666667
7875, 1.7833333333333, 0.15, 0.041666666666667
7876, 1.825, 0.15, 0.041666666666667
7877, 1.8666666666667, 0.15, 0.041666666666667
7878, 1.9083333333333, 0.15, 0.041666666666667
7879, 1.95, 0.15, 0.041666666666667
7880, 1.9916666666667, 0.15, 0.041666666666667
7881, 2.0333333333333, 0.15, 0.041666666666667
7882, 2.075, 0.15, 0.041666666666667
7883, 2.1166666666667, 0.15, 0.041666666666667
7884, 2.1583333333333, 0.15, 0.041666666666667
7885, 1.2416666666667, 0.15, 0.083333333333333
7886, 1.2833333333333, 0.15, 0.083333333333333
7887, 1.325, 0.15, 0.083333333333333
7888, 1.3666666666667, 0.15, 0.083333333333333
7889, 1.4083333333333, 0.15, 0.083333333333333
7890, 1.45, 0.15, 0.083333333333333
7891, 1.4916666666667, 0.15, 0.083333333333333
7892, 1.5333333333333, 0.15, 0.083333333333333
7893, 1.575, 0.15, 0.083333333333333
7894, 1.6166666666667, 0.15, 0.083333333333333
7895, 1.6583333333333, 0.15, 0.083333333333333
7896, 1.7, 0.15, 0.083333333333333
7897, 1.7416666666667, 0.15, 0.083333333333333
7898, 1.7833333333333, 0.15, 0.083333333333333
7899, 1.825, 0.15, 0.083333333333333
7900, 1.8666666666667, 0.15, 0.083333333333333
7901, 1.9083333333333, 0.15, 0.083333333333333
7902, 1.95, 0.15, 0.083333333333333
7903, 1.9916666666667, 0.15, 0.083333333333333
7904, 2.0333333333333, 0.15, 0.083333333333333
7905, 2.075, 0.15, 0.083333333333333
7906, 2.1166666666667, 0.15, 0.083333333333333
7907, 2.1583333333333, 0.15, 0.083333333333333
7908, 1.2416666666667, 0.15, 0.125
7909, 1.2833333333333, 0.15, 0.125
7910, 1.325, 0.15, 0.125
7911, 1.3666666666667, 0.15, 0.125
7912, 1.4083333333333, 0.15, 0.125
7913, 1.45, 0.15, 0.125
7914, 1.4916666666667, 0.15, 0.125
7915, 1.5333333333333, 0.15, 0.125
7916, 1.575, 0.15, 0.125
7917, 1.6166666666667, 0.15, 0.125
7918, 1.6583333333333, 0.15, 0.125
7919, 1.7, 0.15, 0.125
7920, 1.7416666666667, 0.15, 0.125
7921, 1.7833333333333, 0.15, 0.125
7922, 1.825, 0.15, 0.125
7923, 1.8666666666667, 0.15, 0.125
7924, 1.9083333333333, 0.15, 0.125
7925, 1.95, 0.15, 0.125
7926, 1.9916666666667, 0.15, 0.125
7927, 2.0333333333333, 0.15, 0.125
7928, 2.075, 0.15, 0.125
7929, 2.1166666666667, 0.15, 0.125
7930, 2.1583333333333, 0.15, 0.125
7931, 1.2416666666667, 0.15, 0.16666666666667
7932, 1.2833333333333, 0.15, 0.16666666666667
7933, 1.325, 0.15, 0.16666666666667
7934, 1.3666666666667, 0.15, 0.16666666666667
7935, 1.4083333333333, 0.15, 0.16666666666667
7936, 1.45, 0.15, 0.16666666666667
7937, 1.4916666666667, 0.15, 0.16666666666667
7938, 1.5333333333333, 0.15, 0.16666666666667
7939, 1.575, 0.15, 0.16666666666667
7940, 1.6166666666667, 0.15, 0.16666666666667
7941, 1.6583333333333, 0.15, 0.16666666666667
7942, 1.7, 0.15, 0.16666666666667
7943, 1.7416666666667, 0.15, 0.16666666666667
7944, 1.7833333333333, 0.15, 0.16666666666667
7945, 1.825, 0.15, 0.16666666666667
7946, 1.8666666666667, 0.15, 0.16666666666667
7947, 1.9083333333333, 0.15, 0.16666666666667
7948, 1.95, 0.15, 0.16666666666667
7949, 1.9916666666667, 0.15, 0.16666666666667
7950, 2.0333333333333, 0.15, 0.16666666666667
7951, 2.075, 0.15, 0.16666666666667
7952, 2.1166666666667, 0.15, 0.16666666666667
7953, 2.1583333333333, 0.15, 0.16666666666667
7954, 1.2416666666667, 0.15, 0.20833333333333
7955, 1.2833333333333, 0.15, 0.20833333333333
7956, 1.325, 0.15, 0.20833333333333
7957, 1.3666666666667, 0.15, 0.20833333333333
7958, 1.4083333333333, 0.15, 0.20833333333333
7959, 1.45, 0.15, 0.20833333333333
7960, 1.4916666666667, 0.15, 0.20833333333333
7961, 1.5333333333333, 0.15, 0.20833333333333
7962, 1.575, 0.15, 0.20833333333333
7963, 1.6166666666667, 0.15, 0.20833333333333
7964, 1.6583333333333, 0.15, 0.20833333333333
7965, 1.7, 0.15, 0.20833333333333
7966, 1.7416666666667, 0.15, 0.20833333333333
7967, 1.7833333333333, 0.15, 0.20833333333333
7968, 1.825, 0.15, 0.20833333333333
7969, 1.8666666666667, 0.15, 0.20833333333333
7970, 1.9083333333333, 0.15, 0.20833333333333
7971, 1.95, 0.15, 0.20833333333333
7972, 1.9916666666667, 0.15, 0.20833333333333
7973, 2.0333333333333, 0.15, 0.20833333333333
7974, 2.075, 0.15, 0.20833333333333
7975, 2.1166666666667, 0.15, 0.20833333333333
7976, 2.1583333333333, 0.15, 0.20833333333333
7977, 1.2416666666667, 0.15, 0.25
7978, 1.2833333333333, 0.15, 0.25
7979, 1.325, 0.15, 0.25
7980, 1.3666666666667, 0.15, 0.25
7981, 1.4083333333333, 0.15, 0.25
7982, 1.45, 0.15, 0.25
7983, 1.4916666666667, 0.15, 0.25
7984, 1.5333333333333, 0.15, 0.25
7985, 1.575, 0.15, 0.25
7986, 1.6166666666667, 0.15, 0.25
7987, 1.6583333333333, 0.15, 0.25
7988, 1.7, 0.15, 0.25
7989, 1.7416666666667, 0.15, 0.25
7990, 1.7833333333333, 0.15, 0.25
7991, 1.825, 0.15, 0.25
7992, 1.8666666666667, 0.15, 0.25
7993, 1.9083333333333, 0.15, 0.25
7994, 1.95, 0.15, 0.25
7995, 1.9916666666667, 0.15, 0.25
7996, 2.0333333333333, 0.15, 0.25
7997, 2.075, 0.15, 0.25
7998, 2.1166666666667, 0.15, 0.25
7999, 2.1583333333333, 0.15, 0.25
8000, 1.2416666666667, 0.15, 0.29166666666667
8001, 1.2833333333333, 0.15, 0.29166666666667
8002, 1.325, 0.15, 0.29166666666667
8003, 1.3666666666667, 0.15, 0.29166666666667
8004, 1.4083333333333, 0.15, 0.29166666666667
8005, 1.45, 0.15, 0.29166666666667
8006, 1.4916666666667, 0.15, 0.29166666666667
8007, 1.5333333333333, 0.15, 0.29166666666667
8008, 1.575, 0.15, 0.29166666666667
8009, 1.6166666666667, 0.15, 0.29166666666667
8010, 1.6583333333333, 0.15, 0.29166666666667
8011, 1.7, 0.15, 0.29166666666667
8012, 1.7416666666667, 0.15, 0.29166666666667
8013, 1.7833333333333, 0.15, 0.29166666666667
8014, 1.825, 0.15, 0.29166666666667
8015, 1.8666666666667, 0.15, 0.29166666666667
8016, 1.9083333333333, 0.15, 0.29166666666667
8017, 1.95, 0.15, 0.29166666666667
8018, 1.9916666666667, 0.15, 0.29166666666667
8019, 2.0333333333333, 0.15, 0.29166666666667
8020, 2.075, 0.15, 0.29166666666667
8021, 2.1166666666667, 0.15, 0.29166666666667
8022, 2.1583333333333, 0.15, 0.29166666666667
8023, 1.2416666666667, 0.15, 0.33333333333333
8024, 1.2833333333333, 0.15, 0.33333333333333
8025, 1.325, 0.15, 0.33333333333333
8026, 1.3666666666667, 0.15, 0.33333333333333
8027, 1.4083333333333, 0.15, 0.33333333333333
8028, 1.45, 0.15, 0.33333333333333
8029, 1.4916666666667, 0.15, 0.33333333333333
8030, 1.5333333333333, 0.15, 0.33333333333333
8031, 1.575, 0.15, 0.33333333333333
8032, 1.6166666666667, 0.15, 0.33333333333333
8033, 1.6583333333333, 0.15, 0.33333333333333
8034, 1.7, 0.15, 0.33333333333333
8035, 1.7416666666667, 0.15, 0.33333333333333
8036, 1.7833333333333, 0.15, 0.33333333333333
8037, 1.825, 0.15, 0.33333333333333
8038, 1.8666666666667, 0.15, 0.33333333333333
8039, 1.9083333333333, 0.15, 0.33333333333333
8040, 1.95, 0.15, 0.33333333333333
8041, 1.9916666666667, 0.15, 0.33333333333333
8042, 2.0333333333333, 0.15, 0.33333333333333
8043, 2.075, 0.15, 0.33333333333333
8044, 2.1166666666667, 0.15, 0.33333333333333
8045, 2.1583333333333, 0.15, 0.33333333333333
8046, 1.2416666666667, 0.15, 0.375
8047, 1.2833333333333, 0.15, 0.375
8048, 1.325, 0.15, 0.375
8049, 1.3666666666667, 0.15, 0.375
8050, 1.4083333333333, 0.15, 0.375
8051, 1.45, 0.15, 0.375
8052, 1.4916666666667, 0.15, 0.375
8053, 1.5333333333333, 0.15, 0.375
8054, 1.575, 0.15, 0.375
8055, 1.6166666666667, 0.15, 0.375
8056, 1.6583333333333, 0.15, 0.375
8057, 1.7, 0.15, 0.375
8058, 1.7416666666667, 0.15, 0.375
8059, 1.7833333333333, 0.15, 0.375
8060, 1.825, 0.15, 0.375
8061, 1.8666666666667, 0.15, 0.375
8062, 1.9083333333333, 0.15, 0.375
8063, 1.95, 0.15, 0.375
8064, 1.9916666666667, 0.15, 0.375
8065, 2.0333333333333, 0.15, 0.375
8066, 2.075, 0.15, 0.375
8067, 2.1166666666667, 0.15, 0.375
8068, 2.1583333333333, 0.15, 0.375
8069, 1.2416666666667, 0.15, 0.41666666666667
8070, 1.2833333333333, 0.15, 0.41666666666667
8071, 1.325, 0.15, 0.41666666666667
8072, 1.3666666666667, 0.15, 0.41666666666667
8073, 1.4083333333333, 0.15, 0.41666666666667
8074, 1.45, 0.15, 0.41666666666667
8075, 1.4916666666667, 0.15, 0.41666666666667
8076, 1.5333333333333, 0.15, 0.41666666666667
8077, 1.575, 0.15, 0.41666666666667
8078, 1.6166666666667, 0.15, 0.41666666666667
8079, 1.6583333333333, 0.15, 0.41666666666667
8080, 1.7, 0.15, 0.41666666666667
8081, 1.7416666666667, 0.15, 0.41666666666667
8082, 1.7833333333333, 0.15, 0.41666666666667
8083, 1.825, 0.15, 0.41666666666667
8084, 1.8666666666667, 0.15, 0.41666666666667
8085, 1.9083333333333, 0.15, 0.41666666666667
8086, 1.95, 0.15, 0.41666666666667
8087, 1.9916666666667, 0.15, 0.41666666666667
8088, 2.0333333333333, 0.15, 0.41666666666667
8089, 2.075, 0.15, 0.41666666666667
8090, 2.1166666666667, 0.15, 0.41666666666667
8091, 2.1583333333333, 0.15, 0.41666666666667
8092, 1.2416666666667, 0.15, 0.45833333333333
8093, 1.2833333333333, 0.15, 0.45833333333333
8094, 1.325, 0.15, 0.45833333333333
8095, 1.3666666666667, 0.15, 0.45833333333333
8096, 1.4083333333333, 0.15, 0.45833333333333
8097, 1.45, 0.15, 0.45833333333333
8098, 1.4916666666667, 0.15, 0.45833333333333
8099, 1.5333333333333, 0.15, 0.45833333333333
8100, 1.575, 0.15, 0.45833333333333
8101, 1.6166666666667, 0.15, 0.45833333333333
8102, 1.6583333333333, 0.15, 0.45833333333333
8103, 1.7, 0.15, 0.45833333333333
8104, 1.7416666666667, 0.15, 0.45833333333333
8105, 1.7833333333333, 0.15, 0.45833333333333
8106, 1.825, 0.15, 0.45833333333333
8107, 1.8666666666667, 0.15, 0.45833333333333
8108, 1.9083333333333, 0.15, 0.45833333333333
8109, 1.95, 0.15, 0.45833333333333
8110, 1.9916666666667, 0.15, 0.45833333333333
8111, 2.0333333333333, 0.15, 0.45833333333333
8112, 2.075, 0.15, 0.45833333333333
8113, 2.1166666666667, 0.15, 0.45833333333333
8114, 2.1583333333333, 0.15, 0.45833333333333
8115, 1.2416666666667, 0.1, 0.041666666666667
8116, 1.2833333333333, 0.1, 0.041666666666667
8117, 1.325, 0.1, 0.041666666666667
8118, 1.3666666666667, 0.1, 0.041666666666667
8119, 1.4083333333333, 0.1, 0.041666666666667
8120, 1.45, 0.1, 0.041666666666667
8121, 1.4916666666667, 0.1, 0.041666666666667
8122, 1.5333333333333, 0.1, 0.041666666666667
8123, 1.575, 0.1, 0.041666666666667
8124, 1.6166666666667, 0.1, 0.041666666666667
8125, 1.6583333333333, 0.1, 0.041666666666667
8126, 1.7, 0.1, 0.041666666666667
8127, 1.7416666666667, 0.1, 0.041666666666667
8128, 1.7833333333333, 0.1, 0.041666666666667
8129, 1.825, 0.1, 0.041666666666667
8130, 1.8666666666667, 0.1, 0.041666666666667
8131, 1.9083333333333, 0.1, 0.041666666666667
8132, 1.95, 0.1, 0.041666666666667
8133, 1.9916666666667, 0.1, 0.041666666666667
8134, 2.0333333333333, 0.1, 0.041666666666667
8135, 2.075, 0.1, 0.041666666666667
8136, 2.1166666666667, 0.1, 0.041666666666667
8137, 2.1583333333333, 0.1, 0.041666666666667
8138, 1.2416666666667, 0.1, 0.083333333333333
8139, 1.2833333333333, 0.1, 0.083333333333333
8140, 1.325, 0.1, 0.083333333333333
8141, 1.3666666666667, 0.1, 0.083333333333333
8142, 1.4083333333333, 0.1, 0.083333333333333
8143, 1.45, 0.1, 0.083333333333333
8144, 1.4916666666667, 0.1, 0.083333333333333
8145, 1.5333333333333, 0.1, 0.083333333333333
8146, 1.575, 0.1, 0.083333333333333
8147, 1.6166666666667, 0.1, 0.083333333333333
8148, 1.6583333333333, 0.1, 0.083333333333333
8149, 1.7, 0.1, 0.083333333333333
8150, 1.7416666666667, 0.1, 0.083333333333333
8151, 1.7833333333333, 0.1, 0.083333333333333
8152, 1.825, 0.1, 0.083333333333333
8153, 1.8666666666667, 0.1, 0.083333333333333
8154, 1.9083333333333, 0.1, 0.083333333333333
8155, 1.95, 0.1, 0.083333333333333
8156, 1.9916666666667, 0.1, 0.083333333333333
8157, 2.0333333333333, 0.1, 0.083333333333333
8158, 2.075, 0.1, 0.083333333333333
8159, 2.1166666666667, 0.1, 0.083333333333333
8160, 2.1583333333333, 0.1, 0.083333333333333
8161, 1.2416666666667, 0.1, 0.125
8162, 1.2833333333333, 0.1, 0.125
8163, 1.325, 0.1, 0.125
8164, 1.3666666666667, 0.1, 0.125
8165, 1.4083333333333, 0.1, 0.125
8166, 1.45, 0.1, 0.125
8167, 1.4916666666667, 0.1, 0.125
8168, 1.5333333333333, 0.1, 0.125
8169, 1.575, 0.1, 0.125
8170, 1.6166666666667, 0.1, 0.125
8171, 1.6583333333333, 0.1, 0.125
8172, 1.7, 0.1, 0.125
8173, 1.7416666666667, 0.1, 0.125
8174, 1.7833333333333, 0.1, 0.125
8175, 1.825, 0.1, 0.125
8176, 1.8666666666667, 0.1, 0.125
8177, 1.9083333333333, 0.1, 0.125
8178, 1.95, 0.1, 0.125
8179, 1.9916666666667, 0.1, 0.125
8180, 2.0333333333333, 0.1, 0.125
8181, 2.075, 0.1, 0.125
8182, 2.1166666666667, 0.1, 0.125
8183, 2.1583333333333, 0.1, 0.125
8184, 1.2416666666667, 0.1, 0.16666666666667
8185, 1.2833333333333, 0.1, 0.16666666666667
8186, 1.325, 0.1, 0.16666666666667
8187, 1.3666666666667, 0.1, 0.16666666666667
8188, 1.4083333333333, 0.1, 0.16666666666667
8189, 1.45, 0.1, 0.16666666666667
8190, 1.4916666666667, 0.1, 0.16666666666667
8191, 1.5333333333333, 0.1, 0.16666666666667
8192, 1.575, 0.1, 0.16666666666667
8193, 1.6166666666667, 0.1, 0.16666666666667
8194, 1.6583333333333, 0.1, 0.16666666666667
8195, 1.7, 0.1, 0.16666666666667
8196, 1.7416666666667, 0.1, 0.16666666666667
8197, 1.7833333333333, 0.1, 0.16666666666667
8198, 1.825, 0.1, 0.16666666666667
8199, 1.8666666666667, 0.1, 0.16666666666667
8200, 1.9083333333333, 0.1, 0.16666666666667
8201, 1.95, 0.1, 0.16666666666667
8202, 1.9916666666667, 0.1, 0.16666666666667
8203, 2.0333333333333, 0.1, 0.16666666666667
8204, 2.075, 0.1, 0.16666666666667
8205, 2.1166666666667, 0.1, 0.16666666666667
8206, 2.1583333333333, 0.1, 0.16666666666667
8207, 1.2416666666667, 0.1, 0.20833333333333
8208, 1.2833333333333, 0.1, 0.20833333333333
8209, 1.325, 0.1, 0.20833333333333
8210, 1.3666666666667, 0.1, 0.20833333333333
8211, 1.4083333333333, 0.1, 0.20833333333333
8212, 1.45, 0.1, 0.20833333333333
8213, 1.4916666666667, 0.1, 0.20833333333333
8214, 1.5333333333333, 0.1, 0.20833333333333
8215, 1.575, 0.1, 0.20833333333333
8216, 1.6166666666667, 0.1, 0.20833333333333
8217, 1.6583333333333, 0.1, 0.20833333333333
8218, 1.7, 0.1, 0.20833333333333
8219, 1.7416666666667, 0.1, 0.20833333333333
8220, 1.7833333333333, 0.1, 0.20833333333333
8221, 1.825, 0.1, 0.20833333333333
8222, 1.8666666666667, 0.1, 0.20833333333333
8223, 1.9083333333333, 0.1, 0.20833333333333
8224, 1.95, 0.1, 0.20833333333333
8225, 1.9916666666667, 0.1, 0.20833333333333
8226, 2.0333333333333, 0.1, 0.20833333333333
8227, 2.075, 0.1, 0.20833333333333
8228, 2.1166666666667, 0.1, 0.20833333333333
8229, 2.1583333333333, 0.1, 0.20833333333333
8230, 1.2416666666667, 0.1, 0.25
8231, 1.2833333333333, 0.1, 0.25
8232, 1.325, 0.1, 0.25
8233, 1.3666666666667, 0.1, 0.25
8234, 1.4083333333333, 0.1, 0.25
8235, 1.45, 0.1, 0.25
8236, 1.4916666666667, 0.1, 0.25
8237, 1.5333333333333, 0.1, 0.25
8238, 1.575, 0.1, 0.25
8239, 1.6166666666667, 0.1, 0.25
8240, 1.6583333333333, 0.1, 0.25
8241, 1.7, 0.1, 0.25
8242, 1.7416666666667, 0.1, 0.25
8243, 1.7833333333333, 0.1, 0.25
8244, 1.825, 0.1, 0.25
8245, 1.8666666666667, 0.1, 0.25
8246, 1.9083333333333, 0.1, 0.25
8247, 1.95, 0.1, 0.25
8248, 1.9916666666667, 0.1, 0.25
8249, 2.0333333333333, 0.1, 0.25
8250, 2.075, 0.1, 0.25
8251, 2.1166666666667, 0.1, 0.25
8252, 2.1583333333333, 0.1, 0.25
8253, 1.2416666666667, 0.1, 0.29166666666667
8254, 1.2833333333333, 0.1, 0.29166666666667
8255, 1.325, 0.1, 0.29166666666667
8256, 1.3666666666667, 0.1, 0.29166666666667
8257, 1.4083333333333, 0.1, 0.29166666666667
8258, 1.45, 0.1, 0.29166666666667
8259, 1.4916666666667, 0.1, 0.29166666666667
8260, 1.5333333333333, 0.1, 0.29166666666667
8261, 1.575, 0.1, 0.29166666666667
8262, 1.6166666666667, 0.1, 0.29166666666667
8263, 1.6583333333333, 0.1, 0.29166666666667
8264, 1.7, 0.1, 0.29166666666667
8265, 1.7416666666667, 0.1, 0.29166666666667
8266, 1.7833333333333, 0.1, 0.29166666666667
8267, 1.825, 0.1, 0.29166666666667
8268, 1.8666666666667, 0.1, 0.29166666666667
8269, 1.9083333333333, 0.1, 0.29166666666667
8270, 1.95, 0.1, 0.29166666666667
8271, 1.9916666666667, 0.1, 0.29166666666667
8272, 2.0333333333333, 0.1, 0.29166666666667
8273, 2.075, 0.1, 0.29166666666667
8274, 2.1166666666667, 0.1, 0.29166666666667
8275, 2.1583333333333, 0.1, 0.29166666666667
8276, 1.2416666666667, 0.1, 0.33333333333333
8277, 1.2833333333333, 0.1, 0.33333333333333
8278, 1.325, 0.1, 0.33333333333333
8279, 1.3666666666667, 0.1, 0.33333333333333
8280, 1.4083333333333, 0.1, 0.33333333333333
8281, 1.45, 0.1, 0.33333333333333
8282, 1.4916666666667, 0.1, 0.33333333333333
8283, 1.5333333333333, 0.1, 0.33333333333333
8284, 1.575, 0.1, 0.33333333333333
8285, 1.6166666666667, 0.1, 0.33333333333333
8286, 1.6583333333333, 0.1, 0.33333333333333
8287, 1.7, 0.1, 0.33333333333333
8288, 1.7416666666667, 0.1, 0.33333333333333
8289, 1.7833333333333, 0.1, 0.33333333333333
8290, 1.825, 0.1, 0.33333333333333
8291, 1.8666666666667, 0.1, 0.33333333333333
8292, 1.9083333333333, 0.1, 0.33333333333333
8293, 1.95, 0.1, 0.33333333333333
8294, 1.9916666666667, 0.1, 0.33333333333333
8295, 2.0333333333333, 0.1, 0.33333333333333
8296, 2.075, 0.1, 0.33333333333333
8297, 2.1166666666667, 0.1, 0.33333333333333
8298, 2.1583333333333, 0.1, 0.33333333333333
8299, 1.2416666666667, 0.1, 0.375
8300, 1.2833333333333, 0.1, 0.375
8301, 1.325, 0.1, 0.375
8302, 1.3666666666667, 0.1, 0.375
8303, 1.4083333333333, 0.1, 0.375
8304, 1.45, 0.1, 0.375
8305, 1.4916666666667, 0.1, 0.375
8306, 1.5333333333333, 0.1, 0.375
8307, 1.575, 0.1, 0.375
8308, 1.6166666666667, 0.1, 0.375
8309, 1.6583333333333, 0.1, 0.375
8310, 1.7, 0.1, 0.375
8311, 1.7416666666667, 0.1, 0.375
8312, 1.7833333333333, 0.1, 0.375
8313, 1.825, 0.1, 0.375
8314, 1.8666666666667, 0.1, 0.375
8315, 1.9083333333333, 0.1, 0.375
8316, 1.95, 0.1, 0.375
8317, 1.9916666666667, 0.1, 0.375
8318, 2.0333333333333, 0.1, 0.375
8319, 2.075, 0.1, 0.375
8320, 2.1166666666667, 0.1, 0.375
8321, 2.1583333333333, 0.1, 0.375
8322, 1.2416666666667, 0.1, 0.41666666666667
8323, 1.2833333333333, 0.1, 0.41666666666667
8324, 1.325, 0.1, 0.41666666666667
8325, 1.3666666666667, 0.1, 0.41666666666667
8326, 1.4083333333333, 0.1, 0.41666666666667
8327, 1.45, 0.1, 0.41666666666667
8328, 1.4916666666667, 0.1, 0.41666666666667
8329, 1.5333333333333, 0.1, 0.41666666666667
8330, 1.575, 0.1, 0.41666666666667
8331, 1.6166666666667, 0.1, 0.41666666666667
8332, 1.6583333333333, 0.1, 0.41666666666667
8333, 1.7, 0.1, 0.41666666666667
8334, 1.7416666666667, 0.1, 0.41666666666667
8335, 1.7833333333333, 0.1, 0.41666666666667
8336, 1.825, 0.1, 0.41666666666667
8337, 1.8666666666667, 0.1, 0.41666666666667
8338, 1.9083333333333, 0.1, 0.41666666666667
8339, 1.95, 0.1, 0.41666666666667
8340, 1.9916666666667, 0.1, 0.41666666666667
8341, 2.0333333333333, 0.1, 0.41666666666667
8342, 2.075, 0.1, 0.41666666666667
8343, 2.1166666666667, 0.1, 0.41666666666667
8344, 2.1583333333333, 0.1, 0.41666666666667
8345, 1.2416666666667, 0.1, 0.45833333333333
8346, 1.2833333333333, 0.1, 0.45833333333333
8347, 1.325, 0.1, 0.45833333333333
8348, 1.3666666666667, 0.1, 0.45833333333333
8349, 1.4083333333333, 0.1, 0.45833333333333
8350, 1.45, 0.1, 0.45833333333333
8351, 1.4916666666667, 0.1, 0.45833333333333
8352, 1.5333333333333, 0.1, 0.45833333333333
8353, 1.575, 0.1, 0.45833333333333
8354, 1.6166666666667, 0.1, 0.45833333333333
8355, 1.6583333333333, 0.1, 0.45833333333333
8356, 1.7, 0.1, 0.45833333333333
8357, 1.7416666666667, 0.1, 0.45833333333333
8358, 1.7833333333333, 0.1, 0.45833333333333
8359, 1.825, 0.1, 0.45833333333333
8360, 1.8666666666667, 0.1, 0.45833333333333
8361, 1.9083333333333, 0.1, 0.45833333333333
8362, 1.95, 0.1, 0.45833333333333
8363, 1.9916666666667, 0.1, 0.45833333333333
8364, 2.0333333333333, 0.1, 0.45833333333333
8365, 2.075, 0.1, 0.45833333333333
8366, 2.1166666666667, 0.1, 0.45833333333333
8367, 2.1583333333333, 0.1, 0.45833333333333
8368, 1.2416666666667, 0.066666666666667, 0.5
8369, 1.2416666666667, 0.033333333333333, 0.5
8370, 1.2833333333333, 0.066666666666667, 0.5
8371, 1.2833333333333, 0.033333333333333, 0.5
8372, 1.325, 0.066666666666667, 0.5
8373, 1.325, 0.033333333333333, 0.5
8374, 1.3666666666667, 0.066666666666667, 0.5
8375, 1.3666666666667, 0.033333333333333, 0.5
8376, 1.4083333333333, 0.066666666666667, 0.5
8377, 1.4083333333333, 0.033333333333333, 0.5
8378, 1.45, 0.066666666666667, 0.5
8379, 1.45, 0.033333333333333, 0.5
8380, 1.4916666666667, 0.066666666666667, 0.5
8381, 1.4916666666667, 0.033333333333333, 0.5
8382, 1.5333333333333, 0.066666666666667, 0.5
8383, 1.5333333333333, 0.033333333333333, 0.5
8384, 1.575, 0.066666666666667, 0.5
8385, 1.575, 0.033333333333333, 0.5
8386, 1.6166666666667, 0.066666666666667, 0.5
8387, 1.6166666666667, 0.033333333333333, 0.5
8388, 1.6583333333333, 0.066666666666667, 0.5
8389, 1.6583333333333, 0.033333333333333, 0.5
8390, 1.7, 0.066666666666667, 0.5
8391, 1.7, 0.033333333333333, 0.5
8392, 1.7416666666667, 0.066666666666667, 0.5
8393, 1.7416666666667, 0.033333333333333, 0.5
8394, 1.7833333333333, 0.066666666666667, 0.5
8395, 1.7833333333333, 0.033333333333333, 0.5
8396, 1.825, 0.066666666666667, 0.5
8397, 1.825, 0.033333333333333, 0.5
8398, 1.8666666666667, 0.066666666666667, 0.5
8399, 1.8666666666667, 0.033333333333333, 0.5
8400, 1.9083333333333, 0.066666666666667, 0.5
8401, 1.9083333333333, 0.033333333333333, 0.5
8402, 1.95, 0.066666666666667, 0.5
8403, 1.95, 0.033333333333333, 0.5
8404, 1.9916666666667, 0.066666666666667, 0.5
8405, 1.9916666666667, 0.033333333333333, 0.5
8406, 2.0333333333333, 0.066666666666667, 0.5
8407, 2.0333333333333, 0.033333333333333, 0.5
8408, 2.075, 0.066666666666667, 0.5
8409, 2.075, 0.033333333333333, 0.5
8410, 2.1166666666667, 0.066666666666667, 0.5
8411, 2.1166666666667, 0.033333333333333, 0.5
8412, 2.1583333333333, 0.066666666666667, 0.5
8413, 2.1583333333333, 0.033333333333333, 0.5
8414, 1.2416666666667, 0.066666666666667, 0
8415, 1.2416666666667, 0.033333333333333, 0
8416, 1.2833333333333, 0.066666666666667, 0
8417, 1.2833333333333, 0.033333333333333, 0
8418, 1.325, 0.066666666666667, 0
8419, 1.325, 0.033333333333333, 0
8420, 1.3666666666667, 0.066666666666667, 0
8421, 1.3666666666667, 0.033333333333333, 0
8422, 1.4083333333333, 0.066666666666667, 0
8423, 1.4083333333333, 0.033333333333333, 0
8424, 1.45, 0.066666666666667, 0
8425, 1.45, 0.033333333333333, 0
8426, 1.4916666666667, 0.066666666666667, 0
8427, 1.4916666666667, 0.033333333333333, 0
8428, 1.5333333333333, 0.066666666666667, 0
8429, 1.5333333333333, 0.033333333333333, 0
8430, 1.575, 0.066666666666667, 0
8431, 1.575, 0.033333333333333, 0
8432, 1.6166666666667, 0.066666666666667, 0
8433, 1.6166666666667, 0.033333333333333, 0
8434, 1.6583333333333, 0.066666666666667, 0
8435, 1.6583333333333, 0.033333333333333, 0
8436, 1.7, 0.066666666666667, 0
8437, 1.7, 0.033333333333333, 0
8438, 1.7416666666667, 0.066666666666667, 0
8439, 1.7416666666667, 0.033333333333333, 0
8440, 1.7833333333333, 0.066666666666667, 0
8441, 1.7833333333333, 0.033333333333333, 0
8442, 1.825, 0.066666666666667, 0
8443, 1.825, 0.033333333333333, 0
8444, 1.8666666666667, 0.066666666666667, 0
8445, 1.8666666666667, 0.033333333333333, 0
8446, 1.9083333333333, 0.066666666666667, 0
8447, 1.9083333333333, 0.033333333333333, 0
8448, 1.95, 0.066666666666667, 0
8449, 1.95, 0.033333333333333, 0
8450, 1.9916666666667, 0.066666666666667, 0
8451, 1.9916666666667, 0.033333333333333, 0
8452, 2.0333333333333, 0.066666666666667, 0
8453, 2.0333333333333, 0.033333333333333, 0
8454, 2.075, 0.066666666666667, 0
8455, 2.075, 0.033333333333333, 0
8456, 2.1166666666667, 0.066666666666667, 0
8457, 2.1166666666667, 0.033333333333333, 0
8458, 2.1583333333333, 0.066666666666667, 0
8459, 2.1583333333333, 0.033333333333333, 0
8460, 1.2, 0.066666666666667, 0.041666666666667
8461, 1.2, 0.033333333333333, 0.041666666666667
8462, 1.2, 0.066666666666667, 0.083333333333333
8463, 1.2, 0.033333333333333, 0.083333333333333
8464, 1.2, 0.066666666666667, 0.125
8465, 1.2, 0.033333333333333, 0.125
8466, 1.2, 0.066666666666667, 0.16666666666667
8467, 1.2, 0.033333333333333, 0.16666666666667
8468, 1.2, 0.066666666666667, 0.20833333333333
8469, 1.2, 0.033333333333333, 0.20833333333333
8470, 1.2, 0.066666666666667, 0.25
8471, 1.2, 0.033333333333333, 0.25
8472, 1.2, 0.066666666666667, 0.29166666666667
8473, 1.2, 0.033333333333333, 0.29166666666667
8474, 1.2, 0.066666666666667, 0.33333333333333
8475, 1.2, 0.033333333333333, 0.33333333333333
8476, 1.2, 0.066666666666667, 0.375
8477, 1.2, 0.033333333333333, 0.375
8478, 1.2, 0.066666666666667, 0.41666666666667
8479, 1.2, 0.033333333333333, 0.41666666666667
8480, 1.2, 0.066666666666667, 0.45833333333333
8481, 1.2, 0.033333333333333, 0.45833333333333
8482, 2.2, 0.066666666666667, 0.041666666666667
8483, 2.2, 0.033333333333333, 0.041666666666667
8484, 2.2, 0.066666666666667, 0.083333333333333
8485, 2.2, 0.033333333333333, 0.083333333333333
8486, 2.2, 0.066666666666667, 0.125
8487, 2.2, 0.033333333333333, 0.125
8488, 2.2, 0.066666666666667, 0.16666666666667
8489, 2.2, 0.033333333333333, 0.16666666666667
8490, 2.2, 0.066666666666667, 0.20833333333333
8491, 2.2, 0.033333333333333, 0.20833333333333
8492, 2.2, 0.066666666666667, 0.25
8493, 2.2, 0.033333333333333, 0.25
8494, 2.2, 0.066666666666667, 0.29166666666667
8495, 2.2, 0.033333333333333, 0.29166666666667
8496, 2.2, 0.066666666666667, 0.33333333333333
8497, 2.2, 0.033333333333333, 0.33333333333333
8498, 2.2, 0.066666666666667, 0.375
8499, 2.2, 0.033333333333333, 0.375
8500, 2.2, 0.066666666666667, 0.41666666666667
8501, 2.2, 0.033333333333333, 0.41666666666667
8502, 2.2, 0.066666666666667, 0.45833333333333
8503, 2.2, 0.033333333333333, 0.45833333333333
8504, 1.2416666666667, 1.2490009027033e-16, 0.041666666666667
8505, 1.2833333333333, 1.2490009027033e-16, 0.041666666666667
8506, 1.325, 1.2490009027033e-16, 0.041666666666667
8507, 1.3666666666667, 1.2490009027033e-16, 0.041666666666667
8508, 1.4083333333333, 1.2490009027033e-16, 0.041666666666667
8509, 1.45, 1.2490009027033e-16, 0.041666666666667
8510, 1.4916666666667, 1.2490009027033e-16, 0.041666666666667
8511, 1.5333333333333, 1.2490009027033e-16, 0.041666666666667
8512, 1.575, 1.2490009027033e-16, 0.041666666666667
8513, 1.6166666666667, 1.2490009027033e-16, 0.041666666666667
8514, 1.6583333333333, 1.2490009027033e-16, 0.041666666666667
8515, 1.7, 1.2490009027033e-16, 0.041666666666667
8516, 1.7416666666667, 1.2490009027033e-16, 0.041666666666667
8517, 1.7833333333333, 1.2490009027033e-16, 0.041666666666667
8518, 1.825, 1.2490009027033e-16, 0.041666666666667
8519, 1.8666666666667, 1.2490009027033e-16, 0.041666666666667
8520, 1.9083333333333, 1.2490009027033e-16, 0.041666666666667
8521, 1.95, 1.2490009027033e-16, 0.041666666666667
8522, 1.9916666666667, 1.2490009027033e-16, 0.041666666666667
8523, 2.0333333333333, 1.2490009027033e-16, 0.041666666666667
8524, 2.075, 1.2490009027033e-16, 0.041666666666667
8525, 2.1166666666667, 1.2490009027033e-16, 0.041666666666667
8526, 2.1583333333333, 1.2490009027033e-16, 0.041666666666667
8527, 1.2416666666667, 1.2490009027033e-16, 0.083333333333333
8528, 1.2833333333333, 1.2490009027033e-16, 0.083333333333333
8529, 1.325, 1.2490009027033e-16, 0.083333333333333
8530, 1.3666666666667, 1.2490009027033e-16, 0.083333333333333
8531, 1.4083333333333, 1.2490009027033e-16, 0.083333333333333
8532, 1.45, 1.2490009027033e-16, 0.083333333333333
8533, 1.4916666666667, 1.2490009027033e-16, 0.083333333333333
8534, 1.5333333333333, 1.2490009027033e-16, 0.083333333333333
8535, 1.575, 1.2490009027033e-16, 0.083333333333333
8536, 1.6166666666667, 1.2490009027033e-16, 0.083333333333333
8537, 1.6583333333333, 1.2490009027033e-16, 0.083333333333333
8538, 1.7, 1.2490009027033e-16, 0.083333333333333
8539, 1.7416666666667, 1.2490009027033e-16, 0.083333333333333
8540, 1.7833333333333, 1.2490009027033e-16, 0.083333333333333
8541, 1.825, 1.2490009027033e-16, 0.083333333333333
8542, 1.8666666666667, 1.2490009027033e-16, 0.083333333333333
8543, 1.9083333333333, 1.2490009027033e-16, 0.083333333333333
8544, 1.95, 1.2490009027033e-16, 0.083333333333333
8545, 1.9916666666667, 1.2490009027033e-16, 0.083333333333333
8546, 2.0333333333333, 1.2490009027033e-16, 0.083333333333333
8547, 2.075, 1.2490009027033e-16, 0.083333333333333
8548, 2.1166666666667, 1.2490009027033e-16, 0.083333333333333
8549, 2.1583333333333, 1.2490009027033e-16, 0.083333333333333
8550, 1.2416666666667, 1.2490009027033e-16, 0.125
8551, 1.2833333333333, 1.2490009027033e-16, 0.125
8552, 1.325, 1.2490009027033e-16, 0.125
8553, 1.3666666666667, 1.2490009027033e-16, 0.125
8554, 1.4083333333333, 1.2490009027033e-16, 0.125
8555, 1.45, 1.2490009027033e-16, 0.125
8556, 1.4916666666667, 1.2490009027033e-16, 0.125
8557, 1.5333333333333, 1.2490009027033e-16, 0.125
8558, 1.575, 1.2490009027033e-16, 0.125
8559, 1.6166666666667, 1.2490009027033e-16, 0.125
8560, 1.6583333333333, 1.2490009027033e-16, 0.125
8561, 1.7, 1.2490009027033e-16, 0.125
8562, 1.7416666666667, 1.2490009027033e-16, 0.125
8563, 1.7833333333333, 1.2490009027033e-16, 0.125
8564, 1.825, 1.2490009027033e-16, 0.125
8565, 1.8666666666667, 1.2490009027033e-16, 0.125
8566, 1.9083333333333, 1.2490009027033e-16, 0.125
8567, 1.95, 1.2490009027033e-16, 0.125
8568, 1.9916666666667, 1.2490009027033e-16, 0.125
8569, 2.0333333333333, 1.2490009027033e-16, 0.125
8570, 2.075, 1.2490009027033e-16, 0.125
8571, 2.1166666666667, 1.2490009027033e-16, 0.125
8572, 2.1583333333333, 1.2490009027033e-16, 0.125
8573, 1.2416666666667, 1.2490009027033e-16, 0.16666666666667
8574, 1.2833333333333, 1.2490009027033e-16, 0.16666666666667
8575, 1.325, 1.2490009027033e-16, 0.16666666666667
8576, 1.3666666666667, 1.2490009027033e-16, 0.16666666666667
8577, 1.4083333333333, 1.2490009027033e-16, 0.16666666666667
8578, 1.45, 1.2490009027033e-16, 0.16666666666667
8579, 1.4916666666667, 1.2490009027033e-16, 0.16666666666667
8580, 1.5333333333333, 1.2490009027033e-16, 0.16666666666667
8581, 1.575, 1.2490009027033e-16, 0.16666666666667
8582, 1.6166666666667, 1.2490009027033e-16, 0.16666666666667
8583, 1.6583333333333, 1.2490009027033e-16, 0.16666666666667
8584, 1.7, 1.2490009027033e-16, 0.16666666666667
8585, 1.7416666666667, 1.2490009027033e-16, 0.16666666666667
8586, 1.7833333333333, 1.2490009027033e-16, 0.16666666666667
8587, 1.825, 1.2490009027033e-16, 0.16666666666667
8588, 1.8666666666667, 1.2490009027033e-16, 0.16666666666667
8589, 1.9083333333333, 1.2490009027033e-16, 0.16666666666667
8590, 1.95, 1.2490009027033e-16, 0.16666666666667
8591, 1.9916666666667, 1.2490009027033e-16, 0.16666666666667
8592, 2.0333333333333, 1.2490009027033e-16, 0.16666666666667
8593, 2.075, 1.2490009027033e-16, 0.16666666666667
8594, 2.1166666666667, 1.2490009027033e-16, 0.16666666666667
8595, 2.1583333333333, 1.2490009027033e-16, 0.16666666666667
8596, 1.2416666666667, 1.2490009027033e-16, 0.20833333333333
8597, 1.2833333333333, 1.2490009027033e-16, 0.20833333333333
8598, 1.325, 1.2490009027033e-16, 0.20833333333333
8599, 1.3666666666667, 1.2490009027033e-16, 0.20833333333333
8600, 1.4083333333333, 1.2490009027033e-16, 0.20833333333333
8601, 1.45, 1.2490009027033e-16, 0.20833333333333
8602, 1.4916666666667, 1.2490009027033e-16, 0.20833333333333
8603, 1.5333333333333, 1.2490009027033e-16, 0.20833333333333
8604, 1.575, 1.2490009027033e-16, 0.20833333333333
8605, 1.6166666666667, 1.2490009027033e-16, 0.20833333333333
8606, 1.6583333333333, 1.2490009027033e-16, 0.20833333333333
8607, 1.7, 1.2490009027033e-16, 0.20833333333333
8608, 1.7416666666667, 1.2490009027033e-16, 0.20833333333333
8609, 1.7833333333333, 1.2490009027033e-16, 0.20833333333333
8610, 1.825, 1.2490009027033e-16, 0.20833333333333
8611, 1.8666666666667, 1.2490009027033e-16, 0.20833333333333
8612, 1.9083333333333, 1.2490009027033e-16, 0.20833333333333
8613, 1.95, 1.2490009027033e-16, 0.20833333333333
8614, 1.9916666666667, 1.2490009027033e-16, 0.20833333333333
8615, 2.0333333333333, 1.2490009027033e-16, 0.20833333333333
8616, 2.075, 1.2490009027033e-16, 0.20833333333333
8617, 2.1166666666667, 1.2490009027033e-16, 0.20833333333333
8618, 2.1583333333333, 1.2490009027033e-16, 0.20833333333333
8619, 1.2416666666667, 1.2490009027033e-16, 0.25
8620, 1.2833333333333, 1.2490009027033e-16, 0.25
8621, 1.325, 1.2490009027033e-16, 0.25
8622, 1.3666666666667, 1.2490009027033e-16, 0.25
8623, 1.4083333333333, 1.2490009027033e-16, 0.25
8624, 1.45, 1.2490009027033e-16, 0.25
8625, 1.4916666666667, 1.2490009027033e-16, 0.25
8626, 1.5333333333333, 1.2490009027033e-16, 0.25
8627, 1.575, 1.2490009027033e-16, 0.25
8628, 1.6166666666667, 1.2490009027033e-16, 0.25
8629, 1.6583333333333, 1.2490009027033e-16, 0.25
8630, 1.7, 1.2490009027033e-16, 0.25
8631, 1.7416666666667, 1.2490009027033e-16, 0.25
8632, 1.7833333333333, 1.2490009027033e-16, 0.25
8633, 1.825, 1.2490009027033e-16, 0.25
8634, 1.8666666666667, 1.2490009027033e-16, 0.25
8635, 1.9083333333333, 1.2490009027033e-16, 0.25
8636, 1.95, 1.2490009027033e-16, 0.25
8637, 1.9916666666667, 1.2490009027033e-16, 0.25
8638, 2.0333333333333, 1.2490009027033e-16, 0.25
8639, 2.075, 1.2490009027033e-16, 0.25
8640, 2.1166666666667, 1.2490009027033e-16, 0.25
8641, 2.1583333333333, 1.2490009027033e-16, 0.25
8642, 1.2416666666667, 1.2490009027033e-16, 0.29166666666667
8643, 1.2833333333333, 1.2490009027033e-16, 0.29166666666667
8644, 1.325, 1.2490009027033e-16, 0.29166666666667
8645, 1.3666666666667, 1.2490009027033e-16, 0.29166666666667
8646, 1.4083333333333, 1.2490009027033e-16, 0.29166666666667
8647, 1.45, 1.2490009027033e-16, 0.29166666666667
8648, 1.4916666666667, 1.2490009027033e-16, 0.29166666666667
8649, 1.5333333333333, 1.2490009027033e-16, 0.29166666666667
8650, 1.575, 1.2490009027033e-16, 0.29166666666667
8651, 1.6166666666667, 1.2490009027033e-16, 0.29166666666667
8652, 1.6583333333333, 1.2490009027033e-16, 0.29166666666667
8653, 1.7, 1.2490009027033e-16, 0.29166666666667
8654, 1.7416666666667, 1.2490009027033e-16, 0.29166666666667
8655, 1.7833333333333, 1.2490009027033e-16, 0.29166666666667
8656, 1.825, 1.2490009027033e-16, 0.29166666666667
8657, 1.8666666666667, 1.2490009027033e-16, 0.29166666666667
8658, 1.9083333333333, 1.2490009027033e-16, 0.29166666666667
8659, 1.95, 1.2490009027033e-16, 0.29166666666667
8660, 1.9916666666667, 1.2490009027033e-16, 0.29166666666667
8661, 2.0333333333333, 1.2490009027033e-16, 0.29166666666667
8662, 2.075, 1.2490009027033e-16, 0.29166666666667
8663, 2.1166666666667, 1.2490009027033e-16, 0.29166666666667
8664, 2.1583333333333, 1.2490009027033e-16, 0.29166666666667
8665, 1.2416666666667, 1.2490009027033e-16, 0.33333333333333
8666, 1.2833333333333, 1.2490009027033e-16, 0.33333333333333
8667, 1.325, 1.2490009027033e-16, 0.33333333333333
8668, 1.3666666666667, 1.2490009027033e-16, 0.33333333333333
8669, 1.4083333333333, 1.2490009027033e-16, 0.33333333333333
8670, 1.45, 1.2490009027033e-16, 0.33333333333333
8671, 1.4916666666667, 1.2490009027033e-16, 0.33333333333333
8672, 1.5333333333333, 1.2490009027033e-16, 0.33333333333333
8673, 1.575, 1.2490009027033e-16, 0.33333333333333
8674, 1.6166666666667, 1.2490009027033e-16, 0.33333333333333
8675, 1.6583333333333, 1.2490009027033e-16, 0.33333333333333
8676, 1.7, 1.2490009027033e-16, 0.33333333333333
8677, 1.7416666666667, 1.2490009027033e-16, 0.33333333333333
8678, 1.7833333333333, 1.2490009027033e-16, 0.33333333333333
8679, 1.825, 1.2490009027033e-16, 0.33333333333333
8680, 1.8666666666667, 1.2490009027033e-16, 0.33333333333333
8681, 1.9083333333333, 1.2490009027033e-16, 0.33333333333333
8682, 1.95, 1.2490009027033e-16, 0.33333333333333
8683, 1.9916666666667, 1.2490009027033e-16, 0.33333333333333
8684, 2.0333333333333, 1.2490009027033e-16, 0.33333333333333
8685, 2.075, 1.2490009027033e-16, 0.33333333333333
8686, 2.1166666666667, 1.2490009027033e-16, 0.33333333333333
8687, 2.1583333333333, 1.2490009027033e-16, 0.33333333333333
8688, 1.2416666666667, 1.2490009027033e-16, 0.375
8689, 1.2833333333333, 1.2490009027033e-16, 0.375
8690, 1.325, 1.2490009027033e-16, 0.375
8691, 1.3666666666667, 1.2490009027033e-16, 0.375
8692, 1.4083333333333, 1.2490009027033e-16, 0.375
8693, 1.45, 1.2490009027033e-16, 0.375
8694, 1.4916666666667, 1.2490009027033e-16, 0.375
8695, 1.5333333333333, 1.2490009027033e-16, 0.375
8696, 1.575, 1.2490009027033e-16, 0.375
8697, 1.6166666666667, 1.2490009027033e-16, 0.375
8698, 1.6583333333333, 1.2490009027033e-16, 0.375
8699, 1.7, 1.2490009027033e-16, 0.375
8700, 1.7416666666667, 1.2490009027033e-16, 0.375
8701, 1.7833333333333, 1.2490009027033e-16, 0.375
8702, 1.825, 1.2490009027033e-16, 0.375
8703, 1.8666666666667, 1.2490009027033e-16, 0.375
8704, 1.9083333333333, 1.2490009027033e-16, 0.375
8705, 1.95, 1.2490009027033e-16, 0.375
8706, 1.9916666666667, 1.2490009027033e-16, 0.375
8707, 2.0333333333333, 1.2490009027033e-16, 0.375
8708, 2.075, 1.2490009027033e-16, 0.375
8709, 2.1166666666667, 1.2490009027033e-16, 0.375
8710, 2.1583333333333, 1.2490009027033e-16, 0.375
8711, 1.2416666666667, 1.2490009027033e-16, 0.41666666666667
8712, 1.2833333333333, 1.2490009027033e-16, 0.41666666666667
8713, 1.325, 1.2490009027033e-16, 0.41666666666667
8714, 1.3666666666667, 1.2490009027033e-16, 0.41666666666667
8715, 1.4083333333333, 1.2490009027033e-16, 0.41666666666667
8716, 1.45, 1.2490009027033e-16, 0.41666666666667
8717, 1.4916666666667, 1.2490009027033e-16, 0.41666666666667
8718, 1.5333333333333, 1.2490009027033e-16, 0.41666666666667
8719, 1.575, 1.2490009027033e-16, 0.41666666666667
8720, 1.6166666666667, 1.2490009027033e-16, 0.41666666666667
8721, 1.6583333333333, 1.2490009027033e-16, 0.41666666666667
8722, 1.7, 1.2490009027033e-16, 0.41666666666667
8723, 1.7416666666667, 1.2490009027033e-16, 0.41666666666667
8724, 1.7833333333333, 1.2490009027033e-16, 0.41666666666667
8725, 1.825, 1.2490009027033e-16, 0.41666666666667
8726, 1.8666666666667, 1.2490009027033e-16, 0.41666666666667
8727, 1.9083333333333, 1.2490009027033e-16, 0.41666666666667
8728, 1.95, 1.2490009027033e-16, 0.41666666666667
8729, 1.9916666666667, 1.2490009027033e-16, 0.41666666666667
8730, 2.0333333333333, 1.2490009027033e-16, 0.41666666666667
8731, 2.075, 1.2490009027033e-16, 0.41666666666667
8732, 2.1166666666667, 1.2490009027033e-16, 0.41666666666667
8733, 2.1583333333333, 1.2490009027033e-16, 0.41666666666667
8734, 1.2416666666667, 1.2490009027033e-16, 0.45833333333333
8735, 1.2833333333333, 1.2490009027033e-16, 0.45833333333333
8736, 1.325, 1.2490009027033e-16, 0.45833333333333
8737, 1.3666666666667, 1.2490009027033e-16, 0.45833333333333
8738, 1.4083333333333, 1.2490009027033e-16, 0.45833333333333
8739, 1.45, 1.2490009027033e-16, 0.45833333333333
8740, 1.4916666666667, 1.2490009027033e-16, 0.45833333333333
8741, 1.5333333333333, 1.2490009027033e-16, 0.45833333333333
8742, 1.575, 1.2490009027033e-16, 0.45833333333333
8743, 1.6166666666667, 1.2490009027033e-16, 0.45833333333333
8744, 1.6583333333333, 1.2490009027033e-16, 0.45833333333333
8745, 1.7, 1.2490009027033e-16, 0.45833333333333
8746, 1.7416666666667, 1.2490009027033e-16, 0.45833333333333
8747, 1.7833333333333, 1.2490009027033e-16, 0.45833333333333
8748, 1.825, 1.2490009027033e-16, 0.45833333333333
8749, 1.8666666666667, 1.2490009027033e-16, 0.45833333333333
8750, 1.9083333333333, 1.2490009027033e-16, 0.45833333333333
8751, 1.95, 1.2490009027033e-16, 0.45833333333333
8752, 1.9916666666667, 1.2490009027033e-16, 0.45833333333333
8753, 2.0333333333333, 1.2490009027033e-16, 0.45833333333333
8754, 2.075, 1.2490009027033e-16, 0.45833333333333
8755, 2.1166666666667, 1.2490009027033e-16, 0.45833333333333
8756, 2.1583333333333, 1.2490009027033e-16, 0.45833333333333
8757, 2.3, 0.066666666666667, 0.041666666666667
8758, 2.3, 0.033333333333333, 0.041666666666667
8759, 2.3, 0.066666666666667, 0.083333333333333
8760, 2.3, 0.033333333333333, 0.083333333333333
8761, 2.3, 0.066666666666667, 0.125
8762, 2.3, 0.033333333333333, 0.125
8763, 2.3, 0.066666666666667, 0.16666666666667
8764, 2.3, 0.033333333333333, 0.16666666666667
8765, 2.3, 0.066666666666667, 0.20833333333333
8766, 2.3, 0.033333333333333, 0.20833333333333
8767, 2.3, 0.066666666666667, 0.25
8768, 2.3, 0.033333333333333, 0.25
8769, 2.3, 0.066666666666667, 0.29166666666667
8770, 2.3, 0.033333333333333, 0.29166666666667
8771, 2.3, 0.066666666666667, 0.33333333333333
8772, 2.3, 0.033333333333333, 0.33333333333333
8773, 2.3, 0.066666666666667, 0.375
8774, 2.3, 0.033333333333333, 0.375
8775, 2.3, 0.066666666666667, 0.41666666666667
8776, 2.3, 0.033333333333333, 0.41666666666667
8777, 2.3, 0.066666666666667, 0.45833333333333
8778, 2.3, 0.033333333333333, 0.45833333333333
8779, -0.1, 0.033333333333333, 0.041666666666667
8780, -0.1, 0.066666666666667, 0.041666666666667
8781, -0.1, 0.033333333333333, 0.083333333333333
8782, -0.1, 0.066666666666667, 0.083333333333333
8783, -0.1, 0.033333333333333, 0.125
8784, -0.1, 0.066666666666667, 0.125
8785, -0.1, 0.033333333333333, 0.16666666666667
8786, -0.1, 0.066666666666667, 0.16666666666667
8787, -0.1, 0.033333333333333, 0.20833333333333
8788, -0.1, 0.066666666666667, 0.20833333333333
8789, -0.1, 0.033333333333333, 0.25
8790, -0.1, 0.066666666666667, 0.25
8791, -0.1, 0.033333333333333, 0.29166666666667
8792, -0.1, 0.066666666666667, 0.29166666666667
8793, -0.1, 0.033333333333333, 0.33333333333333
8794, -0.1, 0.066666666666667, 0.33333333333333
8795, -0.1, 0.033333333333333, 0.375
8796, -0.1, 0.066666666666667, 0.375
8797, -0.1, 0.033333333333333, 0.41666666666667
8798, -0.1, 0.066666666666667, 0.41666666666667
8799, -0.1, 0.033333333333333, 0.45833333333333
8800, -0.1, 0.066666666666667, 0.45833333333333
8801, 1.05, 0.2, 0.041666666666667
8802, 1.05, 0.25, 0.041666666666667
8803, 1.05, 0.3, 0.041666666666667
8804, 1.05, 0.35, 0.041666666666667
8805, 1.05, 0.4, 0.041666666666667
8806, 1.05, 0.45, 0.041666666666667
8807, 1.05, 0.5, 0.041666666666667
8808, 1.05, 0.55, 0.041666666666667
8809, 1.05, 0.6, 0.041666666666667
8810, 1.05, 0.65, 0.041666666666667
8811, 1.05, 0.7, 0.041666666666667
8812, 1.05, 0.75, 0.041666666666667
8813, 1.05, 0.8, 0.041666666666667
8814, 1.05, 0.85, 0.041666666666667
8815, 1.05, 0.9, 0.041666666666667
8816, 1.05, 0.95, 0.041666666666667
8817, 1.05, 1, 0.041666666666667
8818, 1.05, 1.05, 0.041666666666667
8819, 1.05, 1.1, 0.041666666666667
8820, 1.05, 1.15, 0.041666666666667
8821, 1.05, 1.2, 0.041666666666667
8822, 1.05, 1.25, 0.041666666666667
8823, 1.05, 1.3, 0.041666666666667
8824, 1.05, 0.2, 0.083333333333333
8825, 1.05, 0.25, 0.083333333333333
8826, 1.05, 0.3, 0.083333333333333
8827, 1.05, 0.35, 0.083333333333333
8828, 1.05, 0.4, 0.083333333333333
8829, 1.05, 0.45, 0.083333333333333
8830, 1.05, 0.5, 0.083333333333333
8831, 1.05, 0.55, 0.083333333333333
8832, 1.05, 0.6, 0.083333333333333
8833, 1.05, 0.65, 0.083333333333333
8834, 1.05, 0.7, 0.083333333333333
8835, 1.05, 0.75, 0.083333333333333
8836, 1.05, 0.8, 0.083333333333333
8837, 1.05, 0.85, 0.083333333333333
8838, 1.05, 0.9, 0.083333333333333
8839, 1.05, 0.95, 0.083333333333333
8840, 1.05, 1, 0.083333333333333
8841, 1.05, 1.05, 0.083333333333333
8842, 1.05, 1.1, 0.083333333333333
8843, 1.05, 1.15, 0.083333333333333
8844, 1.05, 1.2, 0.083333333333333
8845, 1.05, 1.25, 0.083333333333333
8846, 1.05, 1.3, 0.083333333333333
8847, 1.05, 0.2, 0.125
8848, 1.05, 0.25, 0.125
8849, 1.05, 0.3, 0.125
8850, 1.05, 0.35, 0.125
8851, 1.05, 0.4, 0.125
8852, 1.05, 0.45, 0.125
8853, 1.05, 0.5, 0.125
8854, 1.05, 0.55, 0.125
8855, 1.05, 0.6, 0.125
8856, 1.05, 0.65, 0.125
8857, 1.05, 0.7, 0.125
8858, 1.05, 0.75, 0.125
8859, 1.05, 0.8, 0.125
8860, 1.05, 0.85, 0.125
8861, 1.05, 0.9, 0.125
8862, 1.05, 0.95, 0.125
8863, 1.05, 1, 0.125
8864, 1.05, 1.05, 0.125
8865, 1.05, 1.1, 0.125
8866, 1.05, 1.15, 0.125
8867, 1.05, 1.2, 0.125
8868, 1.05, 1.25, 0.125
8869, 1.05, 1.3, 0.125
8870, 1.05, 0.2, 0.16666666666667
8871, 1.05, 0.25, 0.16666666666667
8872, 1.05, 0.3, 0.16666666666667
8873, 1.05, 0.35, 0.16666666666667
8874, 1.05, 0.4, 0.16666666666667
8875, 1.05, 0.45, 0.16666666666667
8876, 1.05, 0.5, 0.16666666666667
8877, 1.05, 0.55, 0.16666666666667
8878, 1.05, 0.6, 0.16666666666667
8879, 1.05, 0.65, 0.16666666666667
8880, 1.05, 0.7, 0.16666666666667
8881, 1.05, 0.75, 0.16666666666667
8882, 1.05, 0.8, 0.16666666666667
8883, 1.05, 0.85, 0.16666666666667
8884, 1.05, 0.9, 0.16666666666667
8885, 1.05, 0.95, 0.16666666666667
8886, 1.05, 1, 0.16666666666667
8887, 1.05, 1.05, 0.16666666666667
8888, 1.05, 1.1, 0.16666666666667
8889, 1.05, 1.15, 0.16666666666667
8890, 1.05, 1.2, 0.16666666666667
8891, 1.05, 1.25, 0.16666666666667
8892, 1.05, 1.3, 0.16666666666667
8893, 1.05, 0.2, 0.20833333333333
8894, 1.05, 0.25, 0.20833333333333
8895, 1.05, 0.3, 0.20833333333333
8896, 1.05, 0.35, 0.20833333333333
8897, 1.05, 0.4, 0.20833333333333
8898, 1.05, 0.45, 0.20833333333333
8899, 1.05, 0.5, 0.20833333333333
8900, 1.05, 0.55, 0.20833333333333
8901, 1.05, 0.6, 0.20833333333333
8902, 1.05, 0.65, 0.20833333333333
8903, 1.05, 0.7, 0.20833333333333
8904, 1.05, 0.75, 0.20833333333333
8905, 1.05, 0.8, 0.20833333333333
8906, 1.05, 0.85, 0.20833333333333
8907, 1.05, 0.9, 0.20833333333333
8908, 1.05, 0.95, 0.20833333333333
8909, 1.05, 1, 0.20833333333333
8910, 1.05, 1.05, 0.20833333333333
8911, 1.05, 1.1, 0.20833333333333
8912, 1.05, 1.15, 0.20833333333333
8913, 1.05, 1.2, 0.20833333333333
8914, 1.05, 1.25, 0.20833333333333
8915, 1.05, 1.3, 0.20833333333333
8916, 1.05, 0.2, 0.25
8917, 1.05, 0.25, 0.25
8918, 1.05, 0.3, 0.25
8919, 1.05, 0.35, 0.25
8920, 1.05, 0.4, 0.25
8921, 1.05, 0.45, 0.25
8922, 1.05, 0.5, 0.25
8923, 1.05, 0.55, 0.25
8924, 1.05, 0.6, 0.25
8925, 1.05, 0.65, 0.25
8926, 1.05, 0.7, 0.25
8927, 1.05, 0.75, 0.25
8928, 1.05, 0.8, 0.25
8929, 1.05, 0.85, 0.25
8930, 1.05, 0.9, 0.25
8931, 1.05, 0.95, 0.25
8932, 1.05, 1, 0.25
8933, 1.05, 1.05, 0.25
8934, 1.05, 1.1, 0.25
8935, 1.05, 1.15, 0.25
8936, 1.05, 1.2, 0.25
8937, 1.05, 1.25, 0.25
8938, 1.05, 1.3, 0.25
8939, 1.05, 0.2, 0.29166666666667
8940, 1.05, 0.25, 0.29166666666667
8941, 1.05, 0.3, 0.29166666666667
8942, 1.05, 0.35, 0.29166666666667
8943, 1.05, 0.4, 0.29166666666667
8944, 1.05, 0.45, 0.29166666666667
8945, 1.05, 0.5, 0.29166666666667
8946, 1.05, 0.55, 0.29166666666667
8947, 1.05, 0.6, 0.29166666666667
8948, 1.05, 0.65, 0.29166666666667
8949, 1.05, 0.7, 0.29166666666667
8950, 1.05, 0.75, 0.29166666666667
8951, 1.05, 0.8, 0.29166666666667
8952, 1.05, 0.85, 0.29166666666667
8953, 1.05, 0.9, 0.29166666666667
8954, 1.05, 0.95, 0.29166666666667
8955, 1.05, 1, 0.29166666666667
8956, 1.05, 1.05, 0.29166666666667
8957, 1.05, 1.1, 0.29166666666667
8958, 1.05, 1.15, 0.29166666666667
8959, 1.05, 1.2, 0.29166666666667
8960, 1.05, 1.25, 0.29166666666667
8961, 1.05, 1.3, 0.29166666666667
8962, 1.05, 0.2, 0.33333333333333
8963, 1.05, 0.25, 0.33333333333333
8964, 1.05, 0.3, 0.33333333333333
8965, 1.05, 0.35, 0.33333333333333
8966, 1.05, 0.4, 0.33333333333333
8967, 1.05, 0.45, 0.33333333333333
8968, 1.05, 0.5, 0.33333333333333
8969, 1.05, 0.55, 0.33333333333333
8970, 1.05, 0.6, 0.33333333333333
8971, 1.05, 0.65, 0.33333333333333
8972, 1.05, 0.7, 0.33333333333333
8973, 1.05, 0.75, 0.33333333333333
8974, 1.05, 0.8, 0.33333333333333
8975, 1.05, 0.85, 0.33333333333333
8976, 1.05, 0.9, 0.33333333333333
8977, 1.05, 0.95, 0.33333333333333
8978, 1.05, 1, 0.33333333333333
8979, 1.05, 1.05, 0.33333333333333
8980, 1.05, 1.1, 0.33333333333333
8981, 1.05, 1.15, 0.33333333333333
8982, 1.05, 1.2, 0.33333333333333
8983, 1.05, 1.25, 0.33333333333333
8984, 1.05, 1.3, 0.33333333333333
8985, 1.05, 0.2, 0.375
8986, 1.05, 0.25, 0.375
8987, 1.05, 0.3, 0.375
8988, 1.05, 0.35, 0.375
8989, 1.05, 0.4, 0.375
8990, 1.05, 0.45, 0.375
8991, 1.05, 0.5, 0.375
8992, 1.05, 0.55, 0.375
8993, 1.05, 0.6, 0.375
8994, 1.05, 0.65, 0.375
8995, 1.05, 0.7, 0.375
8996, 1.05, 0.75, 0.375
8997, 1.05, 0.8, 0.375
8998, 1.05, 0.85, 0.375
8999, 1.05, 0.9, 0.375
9000, 1.05, 0.95, 0.375
9001, 1.05, 1, 0.375
9002, 1.05, 1.05, 0.375
9003, 1.05, 1.1, 0.375
9004, 1.05, 1.15, 0.375
9005, 1.05, 1.2, 0.375
9006, 1.05, 1.25, 0.375
9007, 1.05, 1.3, 0.375
9008, 1.05, 0.2, 0.41666666666667
9009, 1.05, 0.25, 0.41666666666667
9010, 1.05, 0.3, 0.41666666666667
9011, 1.05, 0.35, 0.41666666666667
9012, 1.05, 0.4, 0.41666666666667
9013, 1.05, 0.45, 0.41666666666667
9014, 1.05, 0.5, 0.41666666666667
9015, 1.05, 0.55, 0.41666666666667
9016, 1.05, 0.6, 0.41666666666667
9017, 1.05, 0.65, 0.41666666666667
9018, 1.05, 0.7, 0.41666666666667
9019, 1.05, 0.75, 0.41666666666667
9020, 1.05, 0.8, 0.41666666666667
9021, 1.05, 0.85, 0.41666666666667
9022, 1.05, 0.9, 0.41666666666667
