40031, 9608, 9609, 9632, 9631
40032, 9609, 9610, 9633, 9632
40033, 9610, 9611, 9634, 9633
40034, 9611, 9612, 9635, 9634
40035, 9612, 9613, 9636, 9635
40036, 9613, 9614, 9637, 9636
40037, 9614, 9615, 9638, 9637
40038, 9615, 9616, 9639, 9638
40039, 9616, 9617, 9640, 9639
40040, 9617, 9618, 9641, 9640
40041, 9618, 9619, 9642, 9641
40042, 9619, 9620, 9643, 9642
40043, 9620, 9621, 9644, 9643
40044, 9621, 9622, 9645, 9644
40045, 9622, 9623, 9646, 9645
40046, 9623, 9624, 9647, 9646
40047, 9624, 9625, 9648, 9647
40048, 9625, 9626, 9649, 9648
40049, 9626, 9627, 9650, 9649
40050, 9627, 9628, 9651, 9650
40051, 9628, 1415, 1416, 9651
40052, 1393, 9629, 9652, 1394
40053, 9629, 9630, 9653, 9652
40054, 9630, 9631, 9654, 9653
40055, 9631, 9632, 9655, 9654
40056, 9632, 9633, 9656, 9655
40057, 9633, 9634, 9657, 9656
40058, 9634, 9635, 9658, 9657
40059, 9635, 9636, 9659, 9658
40060, 9636, 9637, 9660, 9659
40061, 9637, 9638, 9661, 9660
40062, 9638, 9639, 9662, 9661
40063, 9639, 9640, 9663, 9662
40064, 9640, 9641, 9664, 9663
40065, 9641, 9642, 9665, 9664
40066, 9642, 9643, 9666, 9665
40067, 9643, 9644, 9667, 9666
40068, 9644, 9645, 9668, 9667
40069, 9645, 9646, 9669, 9668
40070, 9646, 9647, 9670, 9669
40071, 9647, 9648, 9671, 9670
40072, 9648, 9649, 9672, 9671
40073, 9649, 9650, 9673, 9672
40074, 9650, 9651, 9674, 9673
40075, 9651, 1416, 1417, 9674
40076, 1394, 9652, 9675, 1395
40077, 9652, 9653, 9676, 9675
40078, 9653, 9654, 9677, 9676
40079, 9654, 9655, 9678, 9677
40080, 9655, 9656, 9679, 9678
40081, 9656, 9657, 9680, 9679
40082, 9657, 9658, 9681, 9680
40083, 9658, 9659, 9682, 9681
40084, 9659, 9660, 9683, 9682
40085, 9660, 9661, 9684, 9683
40086, 9661, 9662, 9685, 9684
40087, 9662, 9663, 9686, 9685
40088, 9663, 9664, 9687, 9686
40089, 9664, 9665, 9688, 9687
40090, 9665, 9666, 9689, 9688
40091, 9666, 9667, 9690, 9689
40092, 9667, 9668, 9691, 9690
40093, 9668, 9669, 9692, 9691
40094, 9669, 9670, 9693, 9692
40095, 9670, 9671, 9694, 9693
40096, 9671, 9672, 9695, 9694
40097, 9672, 9673, 9696, 9695
40098, 9673, 9674, 9697, 9696
40099, 9674, 1417, 1418, 9697
40100, 1395, 9675, 9698, 1396
40101, 9675, 9676, 9699, 9698
40102, 9676, 9677, 9700, 9699
40103, 9677, 9678, 9701, 9700
40104, 9678, 9679, 9702, 9701
40105, 9679, 9680, 9703, 9702
40106, 9680, 9681, 9704, 9703
40107, 9681, 9682, 9705, 9704
40108, 9682, 9683, 9706, 9705
40109, 9683, 9684, 9707, 9706
40110, 9684, 9685, 9708, 9707
40111, 9685, 9686, 9709, 9708
40112, 9686, 9687, 9710, 9709
40113, 9687, 9688, 9711, 9710
40114, 9688, 9689, 9712, 9711
40115, 9689, 9690, 9713, 9712
40116, 9690, 9691, 9714, 9713
40117, 9691, 9692, 9715, 9714
40118, 9692, 9693, 9716, 9715
40119, 9693, 9694, 9717, 9716
40120, 9694, 9695, 9718, 9717
40121, 9695, 9696, 9719, 9718
40122, 9696, 9697, 9720, 9719
40123, 9697, 1418, 1419, 9720
40124, 1396, 9698, 9721, 1397
40125, 9698, 9699, 9722, 9721
40126, 9699, 9700, 9723, 9722
40127, 9700, 9701, 9724, 9723
40128, 9701, 9702, 9725, 9724
40129, 9702, 9703, 9726, 9725
40130, 9703, 9704, 9727, 9726
40131, 9704, 9705, 9728, 9727
40132, 9705, 9706, 9729, 9728
40133, 9706, 9707, 9730, 9729
40134, 9707, 9708, 9731, 9730
40135, 9708, 9709, 9732, 9731
40136, 9709, 9710, 9733, 9732
40137, 9710, 9711, 9734, 9733
40138, 9711, 9712, 9735, 9734
40139, 9712, 9713, 9736, 9735
40140, 9713, 9714, 9737, 9736
40141, 9714, 9715, 9738, 9737
40142, 9715, 9716, 9739, 9738
40143, 9716, 9717, 9740, 9739
40144, 9717, 9718, 9741, 9740
40145, 9718, 9719, 9742, 9741
40146, 9719, 9720, 9743, 9742
40147, 9720, 1419, 1420, 9743
40148, 1397, 9721, 9744, 1398
40149, 9721, 9722, 9745, 9744
40150, 9722, 9723, 9746, 9745
40151, 9723, 9724, 9747, 9746
40152, 9724, 9725, 9748, 9747
40153, 9725, 9726, 9749, 9748
40154, 9726, 9727, 9750, 9749
40155, 9727, 9728, 9751, 9750
40156, 9728, 9729, 9752, 9751
40157, 9729, 9730, 9753, 9752
40158, 9730, 9731, 9754, 9753
40159, 9731, 9732, 9755, 9754
40160, 9732, 9733, 9756, 9755
40161, 9733, 9734, 9757, 9756
40162, 9734, 9735, 9758, 9757
40163, 9735, 9736, 9759, 9758
40164, 9736, 9737, 9760, 9759
40165, 9737, 9738, 9761, 9760
40166, 9738, 9739, 9762, 9761
40167, 9739, 9740, 9763, 9762
40168, 9740, 9741, 9764, 9763
40169, 9741, 9742, 9765, 9764
40170, 9742, 9743, 9766, 9765
40171, 9743, 1420, 1421, 9766
40172, 1398, 9744, 9767, 1399
40173, 9744, 9745, 9768, 9767
40174, 9745, 9746, 9769, 9768
40175, 9746, 9747, 9770, 9769
40176, 9747, 9748, 9771, 9770
40177, 9748, 9749, 9772, 9771
40178, 9749, 9750, 9773, 9772
40179, 9750, 9751, 9774, 9773
40180, 9751, 9752, 9775, 9774
40181, 9752, 9753, 9776, 9775
40182, 9753, 9754, 9777, 9776
40183, 9754, 9755, 9778, 9777
40184, 9755, 9756, 9779, 9778
40185, 9756, 9757, 9780, 9779
40186, 9757, 9758, 9781, 9780
40187, 9758, 9759, 9782, 9781
40188, 9759, 9760, 9783, 9782
40189, 9760, 9761, 9784, 9783
40190, 9761, 9762, 9785, 9784
40191, 9762, 9763, 9786, 9785
40192, 9763, 9764, 9787, 9786
40193, 9764, 9765, 9788, 9787
40194, 9765, 9766, 9789, 9788
40195, 9766, 1421, 1422, 9789
40196, 1399, 9767, 9790, 1400
40197, 9767, 9768, 9791, 9790
40198, 9768, 9769, 9792, 9791
40199, 9769, 9770, 9793, 9792
40200, 9770, 9771, 9794, 9793
40201, 9771, 9772, 9795, 9794
40202, 9772, 9773, 9796, 9795
40203, 9773, 9774, 9797, 9796
40204, 9774, 9775, 9798, 9797
40205, 9775, 9776, 9799, 9798
40206, 9776, 9777, 9800, 9799
40207, 9777, 9778, 9801, 9800
40208, 9778, 9779, 9802, 9801
40209, 9779, 9780, 9803, 9802
40210, 9780, 9781, 9804, 9803
40211, 9781, 9782, 9805, 9804
40212, 9782, 9783, 9806, 9805
40213, 9783, 9784, 9807, 9806
40214, 9784, 9785, 9808, 9807
40215, 9785, 9786, 9809, 9808
40216, 9786, 9787, 9810, 9809
40217, 9787, 9788, 9811, 9810
40218, 9788, 9789, 9812, 9811
40219, 9789, 1422, 1423, 9812
40220, 1400, 9790, 9813, 1401
40221, 9790, 9791, 9814, 9813
40222, 9791, 9792, 9815, 9814
40223, 9792, 9793, 9816, 9815
40224, 9793, 9794, 9817, 9816
40225, 9794, 9795, 9818, 9817
40226, 9795, 9796, 9819, 9818
40227, 9796, 9797, 9820, 9819
40228, 9797, 9798, 9821, 9820
40229, 9798, 9799, 9822, 9821
40230, 9799, 9800, 9823, 9822
40231, 9800, 9801, 9824, 9823
40232, 9801, 9802, 9825, 9824
40233, 9802, 9803, 9826, 9825
40234, 9803, 9804, 9827, 9826
40235, 9804, 9805, 9828, 9827
40236, 9805, 9806, 9829, 9828
40237, 9806, 9807, 9830, 9829
40238, 9807, 9808, 9831, 9830
40239, 9808, 9809, 9832, 9831
40240, 9809, 9810, 9833, 9832
40241, 9810, 9811, 9834, 9833
40242, 9811, 9812, 9835, 9834
40243, 9812, 1423, 1424, 9835
40244, 1401, 9813, 1333, 65
40245, 9813, 9814, 1334, 1333
40246, 9814, 9815, 1335, 1334
40247, 9815, 9816, 1336, 1335
40248, 9816, 9817, 1337, 1336
40249, 9817, 9818, 1338, 1337
40250, 9818, 9819, 1339, 1338
40251, 9819, 9820, 1340, 1339
40252, 9820, 9821, 1341, 1340
40253, 9821, 9822, 1342, 1341
40254, 9822, 9823, 1343, 1342
40255, 9823, 9824, 1344, 1343
40256, 9824, 9825, 1345, 1344
40257, 9825, 9826, 1346, 1345
40258, 9826, 9827, 1347, 1346
40259, 9827, 9828, 1348, 1347
40260, 9828, 9829, 1349, 1348
40261, 9829, 9830, 1350, 1349
40262, 9830, 9831, 1351, 1350
40263, 9831, 9832, 1352, 1351
40264, 9832, 9833, 1353, 1352
40265, 9833, 9834, 1354, 1353
40266, 9834, 9835, 1355, 1354
40267, 9835, 1424, 66, 1355
*ELEMENT, type=CPS4, ELSET=Surface92
40268, 35, 69, 1425, 910
40269, 910, 1425, 1426, 911
40270, 911, 1426, 1427, 912
40271, 912, 1427, 1428, 913
40272, 913, 1428, 1429, 914
40273, 914, 1429, 1430, 915
40274, 915, 1430, 1431, 916
40275, 916, 1431, 1432, 917
40276, 917, 1432, 1433, 918
40277, 918, 1433, 1434, 919
40278, 919, 1434, 1435, 920
40279, 920, 1435, 1436, 921
40280, 921, 1436, 1437, 922
40281, 922, 1437, 1438, 923
40282, 923, 1438, 1439, 924
40283, 924, 1439, 1440, 925
40284, 925, 1440, 1441, 926
40285, 926, 1441, 1442, 927
40286, 927, 1442, 1443, 928
40287, 928, 1443, 1444, 929
40288, 929, 1444, 1445, 930
40289, 930, 1445, 1446, 931
40290, 931, 1446, 1447, 932
40291, 932, 1447, 70, 39
*ELEMENT, type=CPS4, ELSET=Surface93
40292, 36, 933, 1448, 71
40293, 933, 934, 1449, 1448
40294, 934, 935, 1450, 1449
40295, 935, 936, 1451, 1450
40296, 936, 937, 1452, 1451
40297, 937, 938, 1453, 1452
40298, 938, 939, 1454, 1453
40299, 939, 940, 1455, 1454
40300, 940, 941, 1456, 1455
40301, 941, 942, 1457, 1456
40302, 942, 943, 1458, 1457
40303, 943, 944, 1459, 1458
40304, 944, 945, 1460, 1459
40305, 945, 946, 1461, 1460
40306, 946, 947, 1462, 1461
40307, 947, 948, 1463, 1462
40308, 948, 949, 1464, 1463
40309, 949, 950, 1465, 1464
40310, 950, 951, 1466, 1465
40311, 951, 952, 1467, 1466
40312, 952, 953, 1468, 1467
40313, 953, 954, 1469, 1468
40314, 954, 955, 1470, 1469
40315, 955, 40, 72, 1470
*ELEMENT, type=CPS4, ELSET=Surface94
40316, 35, 796, 1471, 69
40317, 796, 797, 1472, 1471
40318, 797, 798, 1473, 1472
40319, 798, 799, 1474, 1473
40320, 799, 800, 1475, 1474
40321, 800, 801, 1476, 1475
40322, 801, 802, 1477, 1476
40323, 802, 803, 1478, 1477
40324, 803, 804, 1479, 1478
40325, 804, 805, 1480, 1479
40326, 805, 806, 1481, 1480
40327, 806, 807, 1482, 1481
40328, 807, 808, 1483, 1482
40329, 808, 809, 1484, 1483
40330, 809, 810, 1485, 1484
40331, 810, 811, 1486, 1485
40332, 811, 812, 1487, 1486
40333, 812, 813, 1488, 1487
40334, 813, 814, 1489, 1488
40335, 814, 815, 1490, 1489
40336, 815, 816, 1491, 1490
40337, 816, 817, 1492, 1491
40338, 817, 818, 1493, 1492
40339, 818, 36, 71, 1493
*ELEMENT, type=CPS4, ELSET=Surface95
40340, 39, 70, 1494, 956
40341, 956, 1494, 1495, 957
40342, 957, 1495, 1496, 958
40343, 958, 1496, 1497, 959
40344, 959, 1497, 1498, 960
40345, 960, 1498, 1499, 961
40346, 961, 1499, 1500, 962
40347, 962, 1500, 1501, 963
40348, 963, 1501, 1502, 964
40349, 964, 1502, 1503, 965
40350, 965, 1503, 1504, 966
40351, 966, 1504, 1505, 967
40352, 967, 1505, 1506, 968
40353, 968, 1506, 1507, 969
40354, 969, 1507, 1508, 970
40355, 970, 1508, 1509, 971
40356, 971, 1509, 1510, 972
40357, 972, 1510, 1511, 973
40358, 973, 1511, 1512, 974
40359, 974, 1512, 1513, 975
40360, 975, 1513, 1514, 976
40361, 976, 1514, 1515, 977
40362, 977, 1515, 1516, 978
40363, 978, 1516, 72, 40
*ELEMENT, type=CPS4, ELSET=Surface96
40364, 69, 1471, 9836, 1425
40365, 1425, 9836, 9837, 1426
40366, 1426, 9837, 9838, 1427
40367, 1427, 9838, 9839, 1428
40368, 1428, 9839, 9840, 1429
40369, 1429, 9840, 9841, 1430
40370, 1430, 9841, 9842, 1431
40371, 1431, 9842, 9843, 1432
40372, 1432, 9843, 9844, 1433
40373, 1433, 9844, 9845, 1434
40374, 1434, 9845, 9846, 1435
40375, 1435, 9846, 9847, 1436
40376, 1436, 9847, 9848, 1437
40377, 1437, 9848, 9849, 1438
40378, 1438, 9849, 9850, 1439
40379, 1439, 9850, 9851, 1440
40380, 1440, 9851, 9852, 1441
40381, 1441, 9852, 9853, 1442
40382, 1442, 9853, 9854, 1443
40383, 1443, 9854, 9855, 1444
40384, 1444, 9855, 9856, 1445
40385, 1445, 9856, 9857, 1446
40386, 1446, 9857, 9858, 1447
40387, 1447, 9858, 1494, 70
40388, 1471, 1472, 9859, 9836
40389, 9836, 9859, 9860, 9837
40390, 9837, 9860, 9861, 9838
40391, 9838, 9861, 9862, 9839
40392, 9839, 9862, 9863, 9840
40393, 9840, 9863, 9864, 9841
40394, 9841, 9864, 9865, 9842
40395, 9842, 9865, 9866, 9843
40396, 9843, 9866, 9867, 9844
40397, 9844, 9867, 9868, 9845
40398, 9845, 9868, 9869, 9846
40399, 9846, 9869, 9870, 9847
40400, 9847, 9870, 9871, 9848
40401, 9848, 9871, 9872, 9849
40402, 9849, 9872, 9873, 9850
40403, 9850, 9873, 9874, 9851
40404, 9851, 9874, 9875, 9852
40405, 9852, 9875, 9876, 9853
40406, 9853, 9876, 9877, 9854
40407, 9854, 9877, 9878, 9855
40408, 9855, 9878, 9879, 9856
40409, 9856, 9879, 9880, 9857
40410, 9857, 9880, 9881, 9858
40411, 9858, 9881, 1495, 1494
40412, 1472, 1473, 9882, 9859
40413, 9859, 9882, 9883, 9860
40414, 9860, 9883, 9884, 9861
40415, 9861, 9884, 9885, 9862
40416, 9862, 9885, 9886, 9863
40417, 9863, 9886, 9887, 9864
40418, 9864, 9887, 9888, 9865
40419, 9865, 9888, 9889, 9866
40420, 9866, 9889, 9890, 9867
40421, 9867, 9890, 9891, 9868
40422, 9868, 9891, 9892, 9869
40423, 9869, 9892, 9893, 9870
40424, 9870, 9893, 9894, 9871
40425, 9871, 9894, 9895, 9872
40426, 9872, 9895, 9896, 9873
40427, 9873, 9896, 9897, 9874
40428, 9874, 9897, 9898, 9875
40429, 9875, 9898, 9899, 9876
40430, 9876, 9899, 9900, 9877
40431, 9877, 9900, 9901, 9878
40432, 9878, 9901, 9902, 9879
40433, 9879, 9902, 9903, 9880
40434, 9880, 9903, 9904, 9881
40435, 9881, 9904, 1496, 1495
40436, 1473, 1474, 9905, 9882
40437, 9882, 9905, 9906, 9883
40438, 9883, 9906, 9907, 9884
40439, 9884, 9907, 9908, 9885
40440, 9885, 9908, 9909, 9886
40441, 9886, 9909, 9910, 9887
40442, 9887, 9910, 9911, 9888
40443, 9888, 9911, 9912, 9889
40444, 9889, 9912, 9913, 9890
40445, 9890, 9913, 9914, 9891
40446, 9891, 9914, 9915, 9892
40447, 9892, 9915, 9916, 9893
40448, 9893, 9916, 9917, 9894
40449, 9894, 9917, 9918, 9895
40450, 9895, 9918, 9919, 9896
40451, 9896, 9919, 9920, 9897
40452, 9897, 9920, 9921, 9898
40453, 9898, 9921, 9922, 9899
40454, 9899, 9922, 9923, 9900
40455, 9900, 9923, 9924, 9901
40456, 9901, 9924, 9925, 9902
40457, 9902, 9925, 9926, 9903
40458, 9903, 9926, 9927, 9904
40459, 9904, 9927, 1497, 1496
40460, 1474, 1475, 9928, 9905
40461, 9905, 9928, 9929, 9906
40462, 9906, 9929, 9930, 9907
40463, 9907, 9930, 9931, 9908
40464, 9908, 9931, 9932, 9909
40465, 9909, 9932, 9933, 9910
40466, 9910, 9933, 9934, 9911
40467, 9911, 9934, 9935, 9912
40468, 9912, 9935, 9936, 9913
40469, 9913, 9936, 9937, 9914
40470, 9914, 9937, 9938, 9915
40471, 9915, 9938, 9939, 9916
40472, 9916, 9939, 9940, 9917
40473, 9917, 9940, 9941, 9918
40474, 9918, 9941, 9942, 9919
40475, 9919, 9942, 9943, 9920
40476, 9920, 9943, 9944, 9921
40477, 9921, 9944, 9945, 9922
40478, 9922, 9945, 9946, 9923
40479, 9923, 9946, 9947, 9924
40480, 9924, 9947, 9948, 9925
40481, 9925, 9948, 9949, 9926
40482, 9926, 9949, 9950, 9927
40483, 9927, 9950, 1498, 1497
40484, 1475, 1476, 9951, 9928
40485, 9928, 9951, 9952, 9929
40486, 9929, 9952, 9953, 9930
40487, 9930, 9953, 9954, 9931
40488, 9931, 9954, 9955, 9932
40489, 9932, 9955, 9956, 9933
40490, 9933, 9956, 9957, 9934
40491, 9934, 9957, 9958, 9935
40492, 9935, 9958, 9959, 9936
40493, 9936, 9959, 9960, 9937
40494, 9937, 9960, 9961, 9938
40495, 9938, 9961, 9962, 9939
40496, 9939, 9962, 9963, 9940
40497, 9940, 9963, 9964, 9941
40498, 9941, 9964, 9965, 9942
40499, 9942, 9965, 9966, 9943
40500, 9943, 9966, 9967, 9944
40501, 9944, 9967, 9968, 9945
40502, 9945, 9968, 9969, 9946
40503, 9946, 9969, 9970, 9947
40504, 9947, 9970, 9971, 9948
40505, 9948, 9971, 9972, 9949
40506, 9949, 9972, 9973, 9950
40507, 9950, 9973, 1499, 1498
40508, 1476, 1477, 9974, 9951
40509, 9951, 9974, 9975, 9952
40510, 9952, 9975, 9976, 9953
40511, 9953, 9976, 9977, 9954
40512, 9954, 9977, 9978, 9955
40513, 9955, 9978, 9979, 9956
40514, 9956, 9979, 9980, 9957
40515, 9957, 9980, 9981, 9958
40516, 9958, 9981, 9982, 9959
40517, 9959, 9982, 9983, 9960
40518, 9960, 9983, 9984, 9961
40519, 9961, 9984, 9985, 9962
40520, 9962, 9985, 9986, 9963
40521, 9963, 9986, 9987, 9964
40522, 9964, 9987, 9988, 9965
40523, 9965, 9988, 9989, 9966
40524, 9966, 9989, 9990, 9967
40525, 9967, 9990, 9991, 9968
40526, 9968, 9991, 9992, 9969
40527, 9969, 9992, 9993, 9970
40528, 9970, 9993, 9994, 9971
40529, 9971, 9994, 9995, 9972
40530, 9972, 9995, 9996, 9973
40531, 9973, 9996, 1500, 1499
40532, 1477, 1478, 9997, 9974
40533, 9974, 9997, 9998, 9975
40534, 9975, 9998, 9999, 9976
40535, 9976, 9999, 10000, 9977
40536, 9977, 10000, 10001, 9978
40537, 9978, 10001, 10002, 9979
40538, 9979, 10002, 10003, 9980
40539, 9980, 10003, 10004, 9981
40540, 9981, 10004, 10005, 9982
40541, 9982, 10005, 10006, 9983
40542, 9983, 10006, 10007, 9984
40543, 9984, 10007, 10008, 9985
40544, 9985, 10008, 10009, 9986
40545, 9986, 10009, 10010, 9987
40546, 9987, 10010, 10011, 9988
40547, 9988, 10011, 10012, 9989
40548, 9989, 10012, 10013, 9990
40549, 9990, 10013, 10014, 9991
40550, 9991, 10014, 10015, 9992
40551, 9992, 10015, 10016, 9993
40552, 9993, 10016, 10017, 9994
40553, 9994, 10017, 10018, 9995
40554, 9995, 10018, 10019, 9996
40555, 9996, 10019, 1501, 1500
40556, 1478, 1479, 10020, 9997
40557, 9997, 10020, 10021, 9998
40558, 9998, 10021, 10022, 9999
40559, 9999, 10022, 10023, 10000
40560, 10000, 10023, 10024, 10001
40561, 10001, 10024, 10025, 10002
40562, 10002, 10025, 10026, 10003
40563, 10003, 10026, 10027, 10004
40564, 10004, 10027, 10028, 10005
40565, 10005, 10028, 10029, 10006
40566, 10006, 10029, 10030, 10007
40567, 10007, 10030, 10031, 10008
40568, 10008, 10031, 10032, 10009
40569, 10009, 10032, 10033, 10010
40570, 10010, 10033, 10034, 10011
40571, 10011, 10034, 10035, 10012
40572, 10012, 10035, 10036, 10013
40573, 10013, 10036, 10037, 10014
40574, 10014, 10037, 10038, 10015
40575, 10015, 10038, 10039, 10016
40576, 10016, 10039, 10040, 10017
40577, 10017, 10040, 10041, 10018
40578, 10018, 10041, 10042, 10019
40579, 10019, 10042, 1502, 1501
40580, 1479, 1480, 10043, 10020
40581, 10020, 10043, 10044, 10021
40582, 10021, 10044, 10045, 10022
40583, 10022, 10045, 10046, 10023
40584, 10023, 10046, 10047, 10024
40585, 10024, 10047, 10048, 10025
40586, 10025, 10048, 10049, 10026
40587, 10026, 10049, 10050, 10027
40588, 10027, 10050, 10051, 10028
40589, 10028, 10051, 10052, 10029
40590, 10029, 10052, 10053, 10030
40591, 10030, 10053, 10054, 10031
40592, 10031, 10054, 10055, 10032
40593, 10032, 10055, 10056, 10033
40594, 10033, 10056, 10057, 10034
40595, 10034, 10057, 10058, 10035
40596, 10035, 10058, 10059, 10036
40597, 10036, 10059, 10060, 10037
40598, 10037, 10060, 10061, 10038
40599, 10038, 10061, 10062, 10039
40600, 10039, 10062, 10063, 10040
40601, 10040, 10063, 10064, 10041
40602, 10041, 10064, 10065, 10042
40603, 10042, 10065, 1503, 1502
40604, 1480, 1481, 10066, 10043
40605, 10043, 10066, 10067, 10044
40606, 10044, 10067, 10068, 10045
40607, 10045, 10068, 10069, 10046
40608, 10046, 10069, 10070, 10047
40609, 10047, 10070, 10071, 10048
40610, 10048, 10071, 10072, 10049
40611, 10049, 10072, 10073, 10050
40612, 10050, 10073, 10074, 10051
40613, 10051, 10074, 10075, 10052
40614, 10052, 10075, 10076, 10053
40615, 10053, 10076, 10077, 10054
40616, 10054, 10077, 10078, 10055
40617, 10055, 10078, 10079, 10056
40618, 10056, 10079, 10080, 10057
40619, 10057, 10080, 10081, 10058
40620, 10058, 10081, 10082, 10059
40621, 10059, 10082, 10083, 10060
40622, 10060, 10083, 10084, 10061
40623, 10061, 10084, 10085, 10062
40624, 10062, 10085, 10086, 10063
40625, 10063, 10086, 10087, 10064
40626, 10064, 10087, 10088, 10065
40627, 10065, 10088, 1504, 1503
40628, 1481, 1482, 10089, 10066
40629, 10066, 10089, 10090, 10067
40630, 10067, 10090, 10091, 10068
40631, 10068, 10091, 10092, 10069
40632, 10069, 10092, 10093, 10070
40633, 10070, 10093, 10094, 10071
40634, 10071, 10094, 10095, 10072
40635, 10072, 10095, 10096, 10073
40636, 10073, 10096, 10097, 10074
40637, 10074, 10097, 10098, 10075
40638, 10075, 10098, 10099, 10076
40639, 10076, 10099, 10100, 10077
40640, 10077, 10100, 10101, 10078
40641, 10078, 10101, 10102, 10079
40642, 10079, 10102, 10103, 10080
40643, 10080, 10103, 10104, 10081
40644, 10081, 10104, 10105, 10082
40645, 10082, 10105, 10106, 10083
40646, 10083, 10106, 10107, 10084
40647, 10084, 10107, 10108, 10085
40648, 10085, 10108, 10109, 10086
40649, 10086, 10109, 10110, 10087
40650, 10087, 10110, 10111, 10088
40651, 10088, 10111, 1505, 1504
40652, 1482, 1483, 10112, 10089
40653, 10089, 10112, 10113, 10090
40654, 10090, 10113, 10114, 10091
40655, 10091, 10114, 10115, 10092
40656, 10092, 10115, 10116, 10093
40657, 10093, 10116, 10117, 10094
40658, 10094, 10117, 10118, 10095
40659, 10095, 10118, 10119, 10096
40660, 10096, 10119, 10120, 10097
40661, 10097, 10120, 10121, 10098
40662, 10098, 10121, 10122, 10099
40663, 10099, 10122, 10123, 10100
40664, 10100, 10123, 10124, 10101
40665, 10101, 10124, 10125, 10102
40666, 10102, 10125, 10126, 10103
40667, 10103, 10126, 10127, 10104
40668, 10104, 10127, 10128, 10105
40669, 10105, 10128, 10129, 10106
40670, 10106, 10129, 10130, 10107
40671, 10107, 10130, 10131, 10108
40672, 10108, 10131, 10132, 10109
40673, 10109, 10132, 10133, 10110
40674, 10110, 10133, 10134, 10111
40675, 10111, 10134, 1506, 1505
40676, 1483, 1484, 10135, 10112
40677, 10112, 10135, 10136, 10113
40678, 10113, 10136, 10137, 10114
40679, 10114, 10137, 10138, 10115
40680, 10115, 10138, 10139, 10116
40681, 10116, 10139, 10140, 10117
40682, 10117, 10140, 10141, 10118
40683, 10118, 10141, 10142, 10119
40684, 10119, 10142, 10143, 10120
40685, 10120, 10143, 10144, 10121
40686, 10121, 10144, 10145, 10122
40687, 10122, 10145, 10146, 10123
40688, 10123, 10146, 10147, 10124
40689, 10124, 10147, 10148, 10125
40690, 10125, 10148, 10149, 10126
40691, 10126, 10149, 10150, 10127
40692, 10127, 10150, 10151, 10128
40693, 10128, 10151, 10152, 10129
40694, 10129, 10152, 10153, 10130
40695, 10130, 10153, 10154, 10131
40696, 10131, 10154, 10155, 10132
40697, 10132, 10155, 10156, 10133
40698, 10133, 10156, 10157, 10134
40699, 10134, 10157, 1507, 1506
40700, 1484, 1485, 10158, 10135
40701, 10135, 10158, 10159, 10136
40702, 10136, 10159, 10160, 10137
40703, 10137, 10160, 10161, 10138
40704, 10138, 10161, 10162, 10139
40705, 10139, 10162, 10163, 10140
40706, 10140, 10163, 10164, 10141
40707, 10141, 10164, 10165, 10142
40708, 10142, 10165, 10166, 10143
40709, 10143, 10166, 10167, 10144
40710, 10144, 10167, 10168, 10145
40711, 10145, 10168, 10169, 10146
40712, 10146, 10169, 10170, 10147
40713, 10147, 10170, 10171, 10148
40714, 10148, 10171, 10172, 10149
40715, 10149, 10172, 10173, 10150
40716, 10150, 10173, 10174, 10151
40717, 10151, 10174, 10175, 10152
40718, 10152, 10175, 10176, 10153
40719, 10153, 10176, 10177, 10154
40720, 10154, 10177, 10178, 10155
40721, 10155, 10178, 10179, 10156
40722, 10156, 10179, 10180, 10157
40723, 10157, 10180, 1508, 1507
40724, 1485, 1486, 10181, 10158
40725, 10158, 10181, 10182, 10159
40726, 10159, 10182, 10183, 10160
40727, 10160, 10183, 10184, 10161
40728, 10161, 10184, 10185, 10162
40729, 10162, 10185, 10186, 10163
40730, 10163, 10186, 10187, 10164
40731, 10164, 10187, 10188, 10165
40732, 10165, 10188, 10189, 10166
40733, 10166, 10189, 10190, 10167
40734, 10167, 10190, 10191, 10168
40735, 10168, 10191, 10192, 10169
40736, 10169, 10192, 10193, 10170
40737, 10170, 10193, 10194, 10171
40738, 10171, 10194, 10195, 10172
40739, 10172, 10195, 10196, 10173
40740, 10173, 10196, 10197, 10174
40741, 10174, 10197, 10198, 10175
40742, 10175, 10198, 10199, 10176
40743, 10176, 10199, 10200, 10177
40744, 10177, 10200, 10201, 10178
40745, 10178, 10201, 10202, 10179
40746, 10179, 10202, 10203, 10180
40747, 10180, 10203, 1509, 1508
40748, 1486, 1487, 10204, 10181
40749, 10181, 10204, 10205, 10182
40750, 10182, 10205, 10206, 10183
40751, 10183, 10206, 10207, 10184
40752, 10184, 10207, 10208, 10185
40753, 10185, 10208, 10209, 10186
40754, 10186, 10209, 10210, 10187
40755, 10187, 10210, 10211, 10188
40756, 10188, 10211, 10212, 10189
40757, 10189, 10212, 10213, 10190
40758, 10190, 10213, 10214, 10191
40759, 10191, 10214, 10215, 10192
40760, 10192, 10215, 10216, 10193
40761, 10193, 10216, 10217, 10194
40762, 10194, 10217, 10218, 10195
40763, 10195, 10218, 10219, 10196
40764, 10196, 10219, 10220, 10197
40765, 10197, 10220, 10221, 10198
40766, 10198, 10221, 10222, 10199
40767, 10199, 10222, 10223, 10200
40768, 10200, 10223, 10224, 10201
40769, 10201, 10224, 10225, 10202
40770, 10202, 10225, 10226, 10203
40771, 10203, 10226, 1510, 1509
40772, 1487, 1488, 10227, 10204
40773, 10204, 10227, 10228, 10205
40774, 10205, 10228, 10229, 10206
40775, 10206, 10229, 10230, 10207
40776, 10207, 10230, 10231, 10208
40777, 10208, 10231, 10232, 10209
40778, 10209, 10232, 10233, 10210
40779, 10210, 10233, 10234, 10211
40780, 10211, 10234, 10235, 10212
40781, 10212, 10235, 10236, 10213
40782, 10213, 10236, 10237, 10214
40783, 10214, 10237, 10238, 10215
40784, 10215, 10238, 10239, 10216
40785, 10216, 10239, 10240, 10217
40786, 10217, 10240, 10241, 10218
40787, 10218, 10241, 10242, 10219
40788, 10219, 10242, 10243, 10220
40789, 10220, 10243, 10244, 10221
40790, 10221, 10244, 10245, 10222
40791, 10222, 10245, 10246, 10223
40792, 10223, 10246, 10247, 10224
40793, 10224, 10247, 10248, 10225
40794, 10225, 10248, 10249, 10226
40795, 10226, 10249, 1511, 1510
40796, 1488, 1489, 10250, 10227
40797, 10227, 10250, 10251, 10228
40798, 10228, 10251, 10252, 10229
40799, 10229, 10252, 10253, 10230
40800, 10230, 10253, 10254, 10231
40801, 10231, 10254, 10255, 10232
40802, 10232, 10255, 10256, 10233
40803, 10233, 10256, 10257, 10234
40804, 10234, 10257, 10258, 10235
40805, 10235, 10258, 10259, 10236
40806, 10236, 10259, 10260, 10237
40807, 10237, 10260, 10261, 10238
40808, 10238, 10261, 10262, 10239
40809, 10239, 10262, 10263, 10240
40810, 10240, 10263, 10264, 10241
40811, 10241, 10264, 10265, 10242
40812, 10242, 10265, 10266, 10243
40813, 10243, 10266, 10267, 10244
40814, 10244, 10267, 10268, 10245
40815, 10245, 10268, 10269, 10246
40816, 10246, 10269, 10270, 10247
40817, 10247, 10270, 10271, 10248
40818, 10248, 10271, 10272, 10249
40819, 10249, 10272, 1512, 1511
40820, 1489, 1490, 10273, 10250
40821, 10250, 10273, 10274, 10251
40822, 10251, 10274, 10275, 10252
40823, 10252, 10275, 10276, 10253
40824, 10253, 10276, 10277, 10254
40825, 10254, 10277, 10278, 10255
40826, 10255, 10278, 10279, 10256
40827, 10256, 10279, 10280, 10257
40828, 10257, 10280, 10281, 10258
40829, 10258, 10281, 10282, 10259
40830, 10259, 10282, 10283, 10260
40831, 10260, 10283, 10284, 10261
40832, 10261, 10284, 10285, 10262
40833, 10262, 10285, 10286, 10263
40834, 10263, 10286, 10287, 10264
40835, 10264, 10287, 10288, 10265
40836, 10265, 10288, 10289, 10266
40837, 10266, 10289, 10290, 10267
40838, 10267, 10290, 10291, 10268
40839, 10268, 10291, 10292, 10269
40840, 10269, 10292, 10293, 10270
40841, 10270, 10293, 10294, 10271
40842, 10271, 10294, 10295, 10272
40843, 10272, 10295, 1513, 1512
40844, 1490, 1491, 10296, 10273
40845, 10273, 10296, 10297, 10274
40846, 10274, 10297, 10298, 10275
40847, 10275, 10298, 10299, 10276
40848, 10276, 10299, 10300, 10277
40849, 10277, 10300, 10301, 10278
40850, 10278, 10301, 10302, 10279
40851, 10279, 10302, 10303, 10280
40852, 10280, 10303, 10304, 10281
40853, 10281, 10304, 10305, 10282
40854, 10282, 10305, 10306, 10283
40855, 10283, 10306, 10307, 10284
40856, 10284, 10307, 10308, 10285
40857, 10285, 10308, 10309, 10286
40858, 10286, 10309, 10310, 10287
40859, 10287, 10310, 10311, 10288
40860, 10288, 10311, 10312, 10289
40861, 10289, 10312, 10313, 10290
40862, 10290, 10313, 10314, 10291
40863, 10291, 10314, 10315, 10292
40864, 10292, 10315, 10316, 10293
40865, 10293, 10316, 10317, 10294
40866, 10294, 10317, 10318, 10295
40867, 10295, 10318, 1514, 1513
40868, 1491, 1492, 10319, 10296
40869, 10296, 10319, 10320, 10297
40870, 10297, 10320, 10321, 10298
40871, 10298, 10321, 10322, 10299
40872, 10299, 10322, 10323, 10300
40873, 10300, 10323, 10324, 10301
40874, 10301, 10324, 10325, 10302
40875, 10302, 10325, 10326, 10303
40876, 10303, 10326, 10327, 10304
40877, 10304, 10327, 10328, 10305
40878, 10305, 10328, 10329, 10306
40879, 10306, 10329, 10330, 10307
40880, 10307, 10330, 10331, 10308
40881, 10308, 10331, 10332, 10309
40882, 10309, 10332, 10333, 10310
40883, 10310, 10333, 10334, 10311
40884, 10311, 10334, 10335, 10312
40885, 10312, 10335, 10336, 10313
40886, 10313, 10336, 10337, 10314
40887, 10314, 10337, 10338, 10315
40888, 10315, 10338, 10339, 10316
40889, 10316, 10339, 10340, 10317
40890, 10317, 10340, 10341, 10318
40891, 10318, 10341, 1515, 1514
40892, 1492, 1493, 10342, 10319
40893, 10319, 10342, 10343, 10320
40894, 10320, 10343, 10344, 10321
40895, 10321, 10344, 10345, 10322
40896, 10322, 10345, 10346, 10323
40897, 10323, 10346, 10347, 10324
40898, 10324, 10347, 10348, 10325
40899, 10325, 10348, 10349, 10326
40900, 10326, 10349, 10350, 10327
40901, 10327, 10350, 10351, 10328
40902, 10328, 10351, 10352, 10329
40903, 10329, 10352, 10353, 10330
40904, 10330, 10353, 10354, 10331
40905, 10331, 10354, 10355, 10332
40906, 10332, 10355, 10356, 10333
40907, 10333, 10356, 10357, 10334
40908, 10334, 10357, 10358, 10335
40909, 10335, 10358, 10359, 10336
40910, 10336, 10359, 10360, 10337
40911, 10337, 10360, 10361, 10338
40912, 10338, 10361, 10362, 10339
40913, 10339, 10362, 10363, 10340
40914, 10340, 10363, 10364, 10341
40915, 10341, 10364, 1516, 1515
40916, 1493, 71, 1448, 10342
40917, 10342, 1448, 1449, 10343
40918, 10343, 1449, 1450, 10344
40919, 10344, 1450, 1451, 10345
40920, 10345, 1451, 1452, 10346
40921, 10346, 1452, 1453, 10347
40922, 10347, 1453, 1454, 10348
40923, 10348, 1454, 1455, 10349
40924, 10349, 1455, 1456, 10350
40925, 10350, 1456, 1457, 10351
40926, 10351, 1457, 1458, 10352
40927, 10352, 1458, 1459, 10353
40928, 10353, 1459, 1460, 10354
40929, 10354, 1460, 1461, 10355
40930, 10355, 1461, 1462, 10356
40931, 10356, 1462, 1463, 10357
40932, 10357, 1463, 1464, 10358
40933, 10358, 1464, 1465, 10359
40934, 10359, 1465, 1466, 10360
40935, 10360, 1466, 1467, 10361
40936, 10361, 1467, 1468, 10362
40937, 10362, 1468, 1469, 10363
40938, 10363, 1469, 1470, 10364
40939, 10364, 1470, 72, 1516
*ELEMENT, type=CPS4, ELSET=Surface97
40940, 35, 69, 73, 63
*ELEMENT, type=CPS4, ELSET=Surface98
40941, 39, 64, 74, 70
*ELEMENT, type=CPS4, ELSET=Surface99
40942, 63, 73, 1517, 1288
40943, 1288, 1517, 1518, 1289
40944, 1289, 1518, 1519, 1290
40945, 1290, 1519, 1520, 1291
40946, 1291, 1520, 1521, 1292
40947, 1292, 1521, 1522, 1293
40948, 1293, 1522, 1523, 1294
40949, 1294, 1523, 1524, 1295
40950, 1295, 1524, 1525, 1296
40951, 1296, 1525, 1526, 1297
40952, 1297, 1526, 1527, 1298
40953, 1298, 1527, 1528, 1299
40954, 1299, 1528, 1529, 1300
40955, 1300, 1529, 1530, 1301
40956, 1301, 1530, 1531, 1302
40957, 1302, 1531, 1532, 1303
40958, 1303, 1532, 1533, 1304
40959, 1304, 1533, 1534, 1305
40960, 1305, 1534, 1535, 1306
40961, 1306, 1535, 1536, 1307
40962, 1307, 1536, 1537, 1308
40963, 1308, 1537, 1538, 1309
40964, 1309, 1538, 1539, 1310
40965, 1310, 1539, 74, 64
*ELEMENT, type=CPS4, ELSET=Surface100
40966, 69, 1425, 1517, 73
40967, 1425, 1426, 1518, 1517
40968, 1426, 1427, 1519, 1518
40969, 1427, 1428, 1520, 1519
40970, 1428, 1429, 1521, 1520
40971, 1429, 1430, 1522, 1521
40972, 1430, 1431, 1523, 1522
40973, 1431, 1432, 1524, 1523
40974, 1432, 1433, 1525, 1524
40975, 1433, 1434, 1526, 1525
40976, 1434, 1435, 1527, 1526
40977, 1435, 1436, 1528, 1527
40978, 1436, 1437, 1529, 1528
40979, 1437, 1438, 1530, 1529
40980, 1438, 1439, 1531, 1530
40981, 1439, 1440, 1532, 1531
40982, 1440, 1441, 1533, 1532
40983, 1441, 1442, 1534, 1533
40984, 1442, 1443, 1535, 1534
40985, 1443, 1444, 1536, 1535
40986, 1444, 1445, 1537, 1536
40987, 1445, 1446, 1538, 1537
40988, 1446, 1447, 1539, 1538
40989, 1447, 70, 74, 1539
*ELEMENT, type=CPS4, ELSET=Surface101
40990, 9, 65, 75, 59
*ELEMENT, type=CPS4, ELSET=Surface102
40991, 13, 60, 76, 66
*ELEMENT, type=CPS4, ELSET=Surface103
40992, 59, 75, 1540, 1220
40993, 1220, 1540, 1541, 1221
40994, 1221, 1541, 1542, 1222
40995, 1222, 1542, 1543, 1223
40996, 1223, 1543, 1544, 1224
40997, 1224, 1544, 1545, 1225
40998, 1225, 1545, 1546, 1226
40999, 1226, 1546, 1547, 1227
41000, 1227, 1547, 1548, 1228
41001, 1228, 1548, 1549, 1229
41002, 1229, 1549, 1550, 1230
41003, 1230, 1550, 1551, 1231
41004, 1231, 1551, 1552, 1232
41005, 1232, 1552, 1553, 1233
41006, 1233, 1553, 1554, 1234
41007, 1234, 1554, 1555, 1235
41008, 1235, 1555, 1556, 1236
41009, 1236, 1556, 1557, 1237
41010, 1237, 1557, 1558, 1238
41011, 1238, 1558, 1559, 1239
41012, 1239, 1559, 1560, 1240
41013, 1240, 1560, 1561, 1241
41014, 1241, 1561, 1562, 1242
41015, 1242, 1562, 76, 60
*ELEMENT, type=CPS4, ELSET=Surface104
41016, 65, 1333, 1540, 75
41017, 1333, 1334, 1541, 1540
41018, 1334, 1335, 1542, 1541
41019, 1335, 1336, 1543, 1542
41020, 1336, 1337, 1544, 1543
41021, 1337, 1338, 1545, 1544
41022, 1338, 1339, 1546, 1545
41023, 1339, 1340, 1547, 1546
41024, 1340, 1341, 1548, 1547
41025, 1341, 1342, 1549, 1548
41026, 1342, 1343, 1550, 1549
41027, 1343, 1344, 1551, 1550
41028, 1344, 1345, 1552, 1551
41029, 1345, 1346, 1553, 1552
41030, 1346, 1347, 1554, 1553
41031, 1347, 1348, 1555, 1554
41032, 1348, 1349, 1556, 1555
41033, 1349, 1350, 1557, 1556
41034, 1350, 1351, 1558, 1557
41035, 1351, 1352, 1559, 1558
41036, 1352, 1353, 1560, 1559
41037, 1353, 1354, 1561, 1560
41038, 1354, 1355, 1562, 1561
41039, 1355, 66, 76, 1562
*ELEMENT, type=CPS4, ELSET=Surface105
41040, 22, 1567, 10365, 541
41041, 1567, 1568, 10366, 10365
41042, 1568, 1569, 10367, 10366
41043, 1569, 1570, 10368, 10367
41044, 1570, 78, 1571, 10368
41045, 541, 10365, 10369, 542
41046, 10365, 10366, 10370, 10369
41047, 10366, 10367, 10371, 10370
41048, 10367, 10368, 10372, 10371
41049, 10368, 1571, 1572, 10372
41050, 542, 10369, 10373, 543
41051, 10369, 10370, 10374, 10373
41052, 10370, 10371, 10375, 10374
41053, 10371, 10372, 10376, 10375
41054, 10372, 1572, 1573, 10376
41055, 543, 10373, 10377, 544
41056, 10373, 10374, 10378, 10377
41057, 10374, 10375, 10379, 10378
41058, 10375, 10376, 10380, 10379
41059, 10376, 1573, 1574, 10380
41060, 544, 10377, 10381, 545
41061, 10377, 10378, 10382, 10381
41062, 10378, 10379, 10383, 10382
41063, 10379, 10380, 10384, 10383
41064, 10380, 1574, 1575, 10384
41065, 545, 10381, 10385, 546
41066, 10381, 10382, 10386, 10385
41067, 10382, 10383, 10387, 10386
41068, 10383, 10384, 10388, 10387
41069, 10384, 1575, 1576, 10388
41070, 546, 10385, 10389, 547
41071, 10385, 10386, 10390, 10389
41072, 10386, 10387, 10391, 10390
41073, 10387, 10388, 10392, 10391
41074, 10388, 1576, 1577, 10392
41075, 547, 10389, 10393, 548
41076, 10389, 10390, 10394, 10393
41077, 10390, 10391, 10395, 10394
41078, 10391, 10392, 10396, 10395
41079, 10392, 1577, 1578, 10396
41080, 548, 10393, 10397, 549
41081, 10393, 10394, 10398, 10397
41082, 10394, 10395, 10399, 10398
41083, 10395, 10396, 10400, 10399
41084, 10396, 1578, 1579, 10400
41085, 549, 10397, 10401, 550
41086, 10397, 10398, 10402, 10401
41087, 10398, 10399, 10403, 10402
41088, 10399, 10400, 10404, 10403
41089, 10400, 1579, 1580, 10404
41090, 550, 10401, 10405, 551
41091, 10401, 10402, 10406, 10405
41092, 10402, 10403, 10407, 10406
41093, 10403, 10404, 10408, 10407
41094, 10404, 1580, 1581, 10408
41095, 551, 10405, 10409, 552
41096, 10405, 10406, 10410, 10409
41097, 10406, 10407, 10411, 10410
41098, 10407, 10408, 10412, 10411
41099, 10408, 1581, 1582, 10412
41100, 552, 10409, 10413, 553
41101, 10409, 10410, 10414, 10413
41102, 10410, 10411, 10415, 10414
41103, 10411, 10412, 10416, 10415
41104, 10412, 1582, 1583, 10416
41105, 553, 10413, 10417, 554
41106, 10413, 10414, 10418, 10417
41107, 10414, 10415, 10419, 10418
41108, 10415, 10416, 10420, 10419
41109, 10416, 1583, 1584, 10420
41110, 554, 10417, 10421, 555
41111, 10417, 10418, 10422, 10421
41112, 10418, 10419, 10423, 10422
41113, 10419, 10420, 10424, 10423
41114, 10420, 1584, 1585, 10424
41115, 555, 10421, 10425, 556
41116, 10421, 10422, 10426, 10425
41117, 10422, 10423, 10427, 10426
41118, 10423, 10424, 10428, 10427
41119, 10424, 1585, 1586, 10428
41120, 556, 10425, 10429, 557
41121, 10425, 10426, 10430, 10429
41122, 10426, 10427, 10431, 10430
41123, 10427, 10428, 10432, 10431
41124, 10428, 1586, 1587, 10432
41125, 557, 10429, 10433, 558
41126, 10429, 10430, 10434, 10433
41127, 10430, 10431, 10435, 10434
41128, 10431, 10432, 10436, 10435
41129, 10432, 1587, 1588, 10436
41130, 558, 10433, 10437, 559
41131, 10433, 10434, 10438, 10437
41132, 10434, 10435, 10439, 10438
41133, 10435, 10436, 10440, 10439
41134, 10436, 1588, 1589, 10440
41135, 559, 10437, 10441, 560
41136, 10437, 10438, 10442, 10441
41137, 10438, 10439, 10443, 10442
41138, 10439, 10440, 10444, 10443
41139, 10440, 1589, 1590, 10444
41140, 560, 10441, 10445, 561
41141, 10441, 10442, 10446, 10445
41142, 10442, 10443, 10447, 10446
41143, 10443, 10444, 10448, 10447
41144, 10444, 1590, 1591, 10448
41145, 561, 10445, 10449, 562
41146, 10445, 10446, 10450, 10449
41147, 10446, 10447, 10451, 10450
41148, 10447, 10448, 10452, 10451
41149, 10448, 1591, 1592, 10452
41150, 562, 10449, 10453, 563
41151, 10449, 10450, 10454, 10453
41152, 10450, 10451, 10455, 10454
41153, 10451, 10452, 10456, 10455
41154, 10452, 1592, 1593, 10456
41155, 563, 10453, 1563, 21
41156, 10453, 10454, 1564, 1563
41157, 10454, 10455, 1565, 1564
41158, 10455, 10456, 1566, 1565
41159, 10456, 1593, 77, 1566
*ELEMENT, type=CPS4, ELSET=Surface106
41160, 21, 1563, 10457, 566
41161, 1563, 1564, 10458, 10457
41162, 1564, 1565, 10459, 10458
41163, 1565, 1566, 10460, 10459
41164, 1566, 77, 1598, 10460
41165, 566, 10457, 10461, 567
41166, 10457, 10458, 10462, 10461
41167, 10458, 10459, 10463, 10462
41168, 10459, 10460, 10464, 10463
41169, 10460, 1598, 1599, 10464
41170, 567, 10461, 10465, 568
41171, 10461, 10462, 10466, 10465
41172, 10462, 10463, 10467, 10466
41173, 10463, 10464, 10468, 10467
41174, 10464, 1599, 1600, 10468
41175, 568, 10465, 10469, 569
41176, 10465, 10466, 10470, 10469
41177, 10466, 10467, 10471, 10470
41178, 10467, 10468, 10472, 10471
41179, 10468, 1600, 1601, 10472
41180, 569, 10469, 10473, 570
41181, 10469, 10470, 10474, 10473
41182, 10470, 10471, 10475, 10474
41183, 10471, 10472, 10476, 10475
41184, 10472, 1601, 1602, 10476
41185, 570, 10473, 10477, 571
41186, 10473, 10474, 10478, 10477
41187, 10474, 10475, 10479, 10478
41188, 10475, 10476, 10480, 10479
41189, 10476, 1602, 1603, 10480
41190, 571, 10477, 10481, 572
41191, 10477, 10478, 10482, 10481
41192, 10478, 10479, 10483, 10482
41193, 10479, 10480, 10484, 10483
41194, 10480, 1603, 1604, 10484
41195, 572, 10481, 10485, 573
41196, 10481, 10482, 10486, 10485
41197, 10482, 10483, 10487, 10486
41198, 10483, 10484, 10488, 10487
41199, 10484, 1604, 1605, 10488
41200, 573, 10485, 10489, 574
41201, 10485, 10486, 10490, 10489
41202, 10486, 10487, 10491, 10490
41203, 10487, 10488, 10492, 10491
41204, 10488, 1605, 1606, 10492
41205, 574, 10489, 10493, 575
41206, 10489, 10490, 10494, 10493
41207, 10490, 10491, 10495, 10494
41208, 10491, 10492, 10496, 10495
41209, 10492, 1606, 1607, 10496
41210, 575, 10493, 10497, 576
41211, 10493, 10494, 10498, 10497
41212, 10494, 10495, 10499, 10498
41213, 10495, 10496, 10500, 10499
41214, 10496, 1607, 1608, 10500
41215, 576, 10497, 1594, 23
41216, 10497, 10498, 1595, 1594
41217, 10498, 10499, 1596, 1595
41218, 10499, 10500, 1597, 1596
41219, 10500, 1608, 79, 1597
*ELEMENT, type=CPS4, ELSET=Surface107
3635, 24, 579, 10501, 1609
3636, 1609, 10501, 10502, 1610
3637, 1610, 10502, 10503, 1611
3638, 1611, 10503, 10504, 1612
3639, 1612, 10504, 1613, 80
3640, 579, 580, 10505, 10501
3641, 10501, 10505, 10506, 10502
3642, 10502, 10506, 10507, 10503
3643, 10503, 10507, 10508, 10504
3644, 10504, 10508, 1614, 1613
3645, 580, 581, 10509, 10505
3646, 10505, 10509, 10510, 10506
3647, 10506, 10510, 10511, 10507
3648, 10507, 10511, 10512, 10508
3649, 10508, 10512, 1615, 1614
3650, 581, 582, 10513, 10509
3651, 10509, 10513, 10514, 10510
3652, 10510, 10514, 10515, 10511
3653, 10511, 10515, 10516, 10512
3654, 10512, 10516, 1616, 1615
3655, 582, 583, 10517, 10513
3656, 10513, 10517, 10518, 10514
3657, 10514, 10518, 10519, 10515
3658, 10515, 10519, 10520, 10516
3659, 10516, 10520, 1617, 1616
3660, 583, 584, 10521, 10517
3661, 10517, 10521, 10522, 10518
3662, 10518, 10522, 10523, 10519
3663, 10519, 10523, 10524, 10520
3664, 10520, 10524, 1618, 1617
3665, 584, 585, 10525, 10521
3666, 10521, 10525, 10526, 10522
3667, 10522, 10526, 10527, 10523
3668, 10523, 10527, 10528, 10524
3669, 10524, 10528, 1619, 1618
3670, 585, 586, 10529, 10525
3671, 10525, 10529, 10530, 10526
3672, 10526, 10530, 10531, 10527
3673, 10527, 10531, 10532, 10528
3674, 10528, 10532, 1620, 1619
3675, 586, 587, 10533, 10529
3676, 10529, 10533, 10534, 10530
3677, 10530, 10534, 10535, 10531
3678, 10531, 10535, 10536, 10532
3679, 10532, 10536, 1621, 1620
3680, 587, 588, 10537, 10533
3681, 10533, 10537, 10538, 10534
3682, 10534, 10538, 10539, 10535
3683, 10535, 10539, 10540, 10536
3684, 10536, 10540, 1622, 1621
3685, 588, 589, 10541, 10537
3686, 10537, 10541, 10542, 10538
3687, 10538, 10542, 10543, 10539
3688, 10539, 10543, 10544, 10540
3689, 10540, 10544, 1623, 1622
3690, 589, 590, 10545, 10541
3691, 10541, 10545, 10546, 10542
3692, 10542, 10546, 10547, 10543
3693, 10543, 10547, 10548, 10544
3694, 10544, 10548, 1624, 1623
3695, 590, 591, 10549, 10545
3696, 10545, 10549, 10550, 10546
3697, 10546, 10550, 10551, 10547
3698, 10547, 10551, 10552, 10548
3699, 10548, 10552, 1625, 1624
3700, 591, 592, 10553, 10549
3701, 10549, 10553, 10554, 10550
3702, 10550, 10554, 10555, 10551
3703, 10551, 10555, 10556, 10552
3704, 10552, 10556, 1626, 1625
3705, 592, 593, 10557, 10553
3706, 10553, 10557, 10558, 10554
3707, 10554, 10558, 10559, 10555
3708, 10555, 10559, 10560, 10556
3709, 10556, 10560, 1627, 1626
3710, 593, 594, 10561, 10557
3711, 10557, 10561, 10562, 10558
3712, 10558, 10562, 10563, 10559
3713, 10559, 10563, 10564, 10560
3714, 10560, 10564, 1628, 1627
3715, 594, 595, 10565, 10561
3716, 10561, 10565, 10566, 10562
3717, 10562, 10566, 10567, 10563
3718, 10563, 10567, 10568, 10564
3719, 10564, 10568, 1629, 1628
3720, 595, 596, 10569, 10565
3721, 10565, 10569, 10570, 10566
3722, 10566, 10570, 10571, 10567
3723, 10567, 10571, 10572, 10568
3724, 10568, 10572, 1630, 1629
3725, 596, 597, 10573, 10569
3726, 10569, 10573, 10574, 10570
3727, 10570, 10574, 10575, 10571
3728, 10571, 10575, 10576, 10572
3729, 10572, 10576, 1631, 1630
3730, 597, 598, 10577, 10573
3731, 10573, 10577, 10578, 10574
3732, 10574, 10578, 10579, 10575
3733, 10575, 10579, 10580, 10576
3734, 10576, 10580, 1632, 1631
3735, 598, 599, 10581, 10577
3736, 10577, 10581, 10582, 10578
3737, 10578, 10582, 10583, 10579
3738, 10579, 10583, 10584, 10580
3739, 10580, 10584, 1633, 1632
3740, 599, 600, 10585, 10581
3741, 10581, 10585, 10586, 10582
3742, 10582, 10586, 10587, 10583
3743, 10583, 10587, 10588, 10584
3744, 10584, 10588, 1634, 1633
3745, 600, 601, 10589, 10585
3746, 10585, 10589, 10590, 10586
3747, 10586, 10590, 10591, 10587
3748, 10587, 10591, 10592, 10588
3749, 10588, 10592, 1635, 1634
3750, 601, 23, 1594, 10589
3751, 10589, 1594, 1595, 10590
3752, 10590, 1595, 1596, 10591
3753, 10591, 1596, 1597, 10592
3754, 10592, 1597, 79, 1635
*ELEMENT, type=CPS4, ELSET=Surface108
41220, 22, 602, 10593, 1567
41221, 1567, 10593, 10594, 1568
41222, 1568, 10594, 10595, 1569
41223, 1569, 10595, 10596, 1570
41224, 1570, 10596, 1636, 78
41225, 602, 603, 10597, 10593
41226, 10593, 10597, 10598, 10594
41227, 10594, 10598, 10599, 10595
41228, 10595, 10599, 10600, 10596
41229, 10596, 10600, 1637, 1636
41230, 603, 604, 10601, 10597
41231, 10597, 10601, 10602, 10598
41232, 10598, 10602, 10603, 10599
41233, 10599, 10603, 10604, 10600
41234, 10600, 10604, 1638, 1637
41235, 604, 605, 10605, 10601
41236, 10601, 10605, 10606, 10602
41237, 10602, 10606, 10607, 10603
41238, 10603, 10607, 10608, 10604
41239, 10604, 10608, 1639, 1638
41240, 605, 606, 10609, 10605
41241, 10605, 10609, 10610, 10606
41242, 10606, 10610, 10611, 10607
41243, 10607, 10611, 10612, 10608
41244, 10608, 10612, 1640, 1639
41245, 606, 607, 10613, 10609
41246, 10609, 10613, 10614, 10610
41247, 10610, 10614, 10615, 10611
41248, 10611, 10615, 10616, 10612
41249, 10612, 10616, 1641, 1640
41250, 607, 608, 10617, 10613
41251, 10613, 10617, 10618, 10614
41252, 10614, 10618, 10619, 10615
41253, 10615, 10619, 10620, 10616
41254, 10616, 10620, 1642, 1641
41255, 608, 609, 10621, 10617
41256, 10617, 10621, 10622, 10618
41257, 10618, 10622, 10623, 10619
41258, 10619, 10623, 10624, 10620
41259, 10620, 10624, 1643, 1642
41260, 609, 610, 10625, 10621
41261, 10621, 10625, 10626, 10622
41262, 10622, 10626, 10627, 10623
41263, 10623, 10627, 10628, 10624
41264, 10624, 10628, 1644, 1643
41265, 610, 611, 10629, 10625
41266, 10625, 10629, 10630, 10626
41267, 10626, 10630, 10631, 10627
41268, 10627, 10631, 10632, 10628
41269, 10628, 10632, 1645, 1644
41270, 611, 612, 10633, 10629
41271, 10629, 10633, 10634, 10630
41272, 10630, 10634, 10635, 10631
41273, 10631, 10635, 10636, 10632
41274, 10632, 10636, 1646, 1645
41275, 612, 24, 1609, 10633
41276, 10633, 1609, 1610, 10634
41277, 10634, 1610, 1611, 10635
41278, 10635, 1611, 1612, 10636
41279, 10636, 1612, 80, 1646
*ELEMENT, type=CPS4, ELSET=Surface109
3755, 78, 1636, 10637, 1571
3756, 1636, 1637, 10638, 10637
3757, 1637, 1638, 10639, 10638
3758, 1638, 1639, 10640, 10639
3759, 1639, 1640, 10641, 10640
3760, 1640, 1641, 10642, 10641
3761, 1641, 1642, 10643, 10642
3762, 1642, 1643, 10644, 10643
3763, 1643, 1644, 10645, 10644
3764, 1644, 1645, 10646, 10645
3765, 1645, 1646, 10647, 10646
3766, 1646, 80, 1613, 10647
3767, 1571, 10637, 10648, 1572
3768, 10637, 10638, 10649, 10648
3769, 10638, 10639, 10650, 10649
3770, 10639, 10640, 10651, 10650
3771, 10640, 10641, 10652, 10651
3772, 10641, 10642, 10653, 10652
3773, 10642, 10643, 10654, 10653
3774, 10643, 10644, 10655, 10654
3775, 10644, 10645, 10656, 10655
3776, 10645, 10646, 10657, 10656
3777, 10646, 10647, 10658, 10657
3778, 10647, 1613, 1614, 10658
3779, 1572, 10648, 10659, 1573
3780, 10648, 10649, 10660, 10659
3781, 10649, 10650, 10661, 10660
3782, 10650, 10651, 10662, 10661
3783, 10651, 10652, 10663, 10662
3784, 10652, 10653, 10664, 10663
3785, 10653, 10654, 10665, 10664
3786, 10654, 10655, 10666, 10665
3787, 10655, 10656, 10667, 10666
3788, 10656, 10657, 10668, 10667
3789, 10657, 10658, 10669, 10668
3790, 10658, 1614, 1615, 10669
3791, 1573, 10659, 10670, 1574
3792, 10659, 10660, 10671, 10670
3793, 10660, 10661, 10672, 10671
3794, 10661, 10662, 10673, 10672
3795, 10662, 10663, 10674, 10673
3796, 10663, 10664, 10675, 10674
3797, 10664, 10665, 10676, 10675
3798, 10665, 10666, 10677, 10676
3799, 10666, 10667, 10678, 10677
3800, 10667, 10668, 10679, 10678
3801, 10668, 10669, 10680, 10679
3802, 10669, 1615, 1616, 10680
3803, 1574, 10670, 10681, 1575
3804, 10670, 10671, 10682, 10681
3805, 10671, 10672, 10683, 10682
3806, 10672, 10673, 10684, 10683
3807, 10673, 10674, 10685, 10684
3808, 10674, 10675, 10686, 10685
3809, 10675, 10676, 10687, 10686
3810, 10676, 10677, 10688, 10687
3811, 10677, 10678, 10689, 10688
3812, 10678, 10679, 10690, 10689
3813, 10679, 10680, 10691, 10690
3814, 10680, 1616, 1617, 10691
3815, 1575, 10681, 10692, 1576
3816, 10681, 10682, 10693, 10692
3817, 10682, 10683, 10694, 10693
3818, 10683, 10684, 10695, 10694
3819, 10684, 10685, 10696, 10695
3820, 10685, 10686, 10697, 10696
3821, 10686, 10687, 10698, 10697
3822, 10687, 10688, 10699, 10698
3823, 10688, 10689, 10700, 10699
3824, 10689, 10690, 10701, 10700
3825, 10690, 10691, 10702, 10701
3826, 10691, 1617, 1618, 10702
3827, 1576, 10692, 10703, 1577
3828, 10692, 10693, 10704, 10703
3829, 10693, 10694, 10705, 10704
3830, 10694, 10695, 10706, 10705
3831, 10695, 10696, 10707, 10706
3832, 10696, 10697, 10708, 10707
3833, 10697, 10698, 10709, 10708
3834, 10698, 10699, 10710, 10709
3835, 10699, 10700, 10711, 10710
3836, 10700, 10701, 10712, 10711
3837, 10701, 10702, 10713, 10712
3838, 10702, 1618, 1619, 10713
3839, 1577, 10703, 10714, 1578
3840, 10703, 10704, 10715, 10714
3841, 10704, 10705, 10716, 10715
3842, 10705, 10706, 10717, 10716
3843, 10706, 10707, 10718, 10717
3844, 10707, 10708, 10719, 10718
3845, 10708, 10709, 10720, 10719
3846, 10709, 10710, 10721, 10720
3847, 10710, 10711, 10722, 10721
3848, 10711, 10712, 10723, 10722
3849, 10712, 10713, 10724, 10723
3850, 10713, 1619, 1620, 10724
3851, 1578, 10714, 10725, 1579
3852, 10714, 10715, 10726, 10725
3853, 10715, 10716, 10727, 10726
3854, 10716, 10717, 10728, 10727
3855, 10717, 10718, 10729, 10728
3856, 10718, 10719, 10730, 10729
3857, 10719, 10720, 10731, 10730
3858, 10720, 10721, 10732, 10731
3859, 10721, 10722, 10733, 10732
3860, 10722, 10723, 10734, 10733
3861, 10723, 10724, 10735, 10734
3862, 10724, 1620, 1621, 10735
3863, 1579, 10725, 10736, 1580
3864, 10725, 10726, 10737, 10736
3865, 10726, 10727, 10738, 10737
3866, 10727, 10728, 10739, 10738
3867, 10728, 10729, 10740, 10739
3868, 10729, 10730, 10741, 10740
3869, 10730, 10731, 10742, 10741
3870, 10731, 10732, 10743, 10742
3871, 10732, 10733, 10744, 10743
3872, 10733, 10734, 10745, 10744
3873, 10734, 10735, 10746, 10745
3874, 10735, 1621, 1622, 10746
3875, 1580, 10736, 10747, 1581
3876, 10736, 10737, 10748, 10747
3877, 10737, 10738, 10749, 10748
3878, 10738, 10739, 10750, 10749
3879, 10739, 10740, 10751, 10750
3880, 10740, 10741, 10752, 10751
3881, 10741, 10742, 10753, 10752
3882, 10742, 10743, 10754, 10753
3883, 10743, 10744, 10755, 10754
3884, 10744, 10745, 10756, 10755
3885, 10745, 10746, 10757, 10756
3886, 10746, 1622, 1623, 10757
3887, 1581, 10747, 10758, 1582
3888, 10747, 10748, 10759, 10758
3889, 10748, 10749, 10760, 10759
3890, 10749, 10750, 10761, 10760
3891, 10750, 10751, 10762, 10761
3892, 10751, 10752, 10763, 10762
3893, 10752, 10753, 10764, 10763
3894, 10753, 10754, 10765, 10764
3895, 10754, 10755, 10766, 10765
3896, 10755, 10756, 10767, 10766
3897, 10756, 10757, 10768, 10767
3898, 10757, 1623, 1624, 10768
3899, 1582, 10758, 10769, 1583
3900, 10758, 10759, 10770, 10769
3901, 10759, 10760, 10771, 10770
3902, 10760, 10761, 10772, 10771
3903, 10761, 10762, 10773, 10772
3904, 10762, 10763, 10774, 10773
3905, 10763, 10764, 10775, 10774
3906, 10764, 10765, 10776, 10775
3907, 10765, 10766, 10777, 10776
3908, 10766, 10767, 10778, 10777
3909, 10767, 10768, 10779, 10778
3910, 10768, 1624, 1625, 10779
3911, 1583, 10769, 10780, 1584
3912, 10769, 10770, 10781, 10780
3913, 10770, 10771, 10782, 10781
3914, 10771, 10772, 10783, 10782
3915, 10772, 10773, 10784, 10783
3916, 10773, 10774, 10785, 10784
3917, 10774, 10775, 10786, 10785
3918, 10775, 10776, 10787, 10786
3919, 10776, 10777, 10788, 10787
3920, 10777, 10778, 10789, 10788
3921, 10778, 10779, 10790, 10789
3922, 10779, 1625, 1626, 10790
3923, 1584, 10780, 10791, 1585
3924, 10780, 10781, 10792, 10791
3925, 10781, 10782, 10793, 10792
3926, 10782, 10783, 10794, 10793
3927, 10783, 10784, 10795, 10794
3928, 10784, 10785, 10796, 10795
3929, 10785, 10786, 10797, 10796
3930, 10786, 10787, 10798, 10797
3931, 10787, 10788, 10799, 10798
3932, 10788, 10789, 10800, 10799
3933, 10789, 10790, 10801, 10800
3934, 10790, 1626, 1627, 10801
3935, 1585, 10791, 10802, 1586
3936, 10791, 10792, 10803, 10802
3937, 10792, 10793, 10804, 10803
3938, 10793, 10794, 10805, 10804
3939, 10794, 10795, 10806, 10805
3940, 10795, 10796, 10807, 10806
3941, 10796, 10797, 10808, 10807
3942, 10797, 10798, 10809, 10808
3943, 10798, 10799, 10810, 10809
3944, 10799, 10800, 10811, 10810
3945, 10800, 10801, 10812, 10811
3946, 10801, 1627, 1628, 10812
3947, 1586, 10802, 10813, 1587
3948, 10802, 10803, 10814, 10813
3949, 10803, 10804, 10815, 10814
3950, 10804, 10805, 10816, 10815
3951, 10805, 10806, 10817, 10816
3952, 10806, 10807, 10818, 10817
3953, 10807, 10808, 10819, 10818
3954, 10808, 10809, 10820, 10819
3955, 10809, 10810, 10821, 10820
3956, 10810, 10811, 10822, 10821
3957, 10811, 10812, 10823, 10822
3958, 10812, 1628, 1629, 10823
3959, 1587, 10813, 10824, 1588
3960, 10813, 10814, 10825, 10824
3961, 10814, 10815, 10826, 10825
3962, 10815, 10816, 10827, 10826
3963, 10816, 10817, 10828, 10827
3964, 10817, 10818, 10829, 10828
3965, 10818, 10819, 10830, 10829
3966, 10819, 10820, 10831, 10830
3967, 10820, 10821, 10832, 10831
3968, 10821, 10822, 10833, 10832
3969, 10822, 10823, 10834, 10833
3970, 10823, 1629, 1630, 10834
3971, 1588, 10824, 10835, 1589
3972, 10824, 10825, 10836, 10835
3973, 10825, 10826, 10837, 10836
3974, 10826, 10827, 10838, 10837
3975, 10827, 10828, 10839, 10838
3976, 10828, 10829, 10840, 10839
3977, 10829, 10830, 10841, 10840
3978, 10830, 10831, 10842, 10841
3979, 10831, 10832, 10843, 10842
3980, 10832, 10833, 10844, 10843
3981, 10833, 10834, 10845, 10844
3982, 10834, 1630, 1631, 10845
3983, 1589, 10835, 10846, 1590
3984, 10835, 10836, 10847, 10846
3985, 10836, 10837, 10848, 10847
3986, 10837, 10838, 10849, 10848
3987, 10838, 10839, 10850, 10849
3988, 10839, 10840, 10851, 10850
3989, 10840, 10841, 10852, 10851
3990, 10841, 10842, 10853, 10852
3991, 10842, 10843, 10854, 10853
3992, 10843, 10844, 10855, 10854
3993, 10844, 10845, 10856, 10855
3994, 10845, 1631, 1632, 10856
3995, 1590, 10846, 10857, 1591
3996, 10846, 10847, 10858, 10857
3997, 10847, 10848, 10859, 10858
3998, 10848, 10849, 10860, 10859
3999, 10849, 10850, 10861, 10860
4000, 10850, 10851, 10862, 10861
4001, 10851, 10852, 10863, 10862
4002, 10852, 10853, 10864, 10863
4003, 10853, 10854, 10865, 10864
4004, 10854, 10855, 10866, 10865
4005, 10855, 10856, 10867, 10866
4006, 10856, 1632, 1633, 10867
4007, 1591, 10857, 10868, 1592
4008, 10857, 10858, 10869, 10868
4009, 10858, 10859, 10870, 10869
4010, 10859, 10860, 10871, 10870
4011, 10860, 10861, 10872, 10871
4012, 10861, 10862, 10873, 10872
4013, 10862, 10863, 10874, 10873
4014, 10863, 10864, 10875, 10874
4015, 10864, 10865, 10876, 10875
4016, 10865, 10866, 10877, 10876
4017, 10866, 10867, 10878, 10877
4018, 10867, 1633, 1634, 10878
4019, 1592, 10868, 10879, 1593
4020, 10868, 10869, 10880, 10879
4021, 10869, 10870, 10881, 10880
4022, 10870, 10871, 10882, 10881
4023, 10871, 10872, 10883, 10882
4024, 10872, 10873, 10884, 10883
4025, 10873, 10874, 10885, 10884
4026, 10874, 10875, 10886, 10885
4027, 10875, 10876, 10887, 10886
4028, 10876, 10877, 10888, 10887
4029, 10877, 10878, 10889, 10888
4030, 10878, 1634, 1635, 10889
4031, 1593, 10879, 1598, 77
4032, 10879, 10880, 1599, 1598
4033, 10880, 10881, 1600, 1599
4034, 10881, 10882, 1601, 1600
4035, 10882, 10883, 1602, 1601
4036, 10883, 10884, 1603, 1602
4037, 10884, 10885, 1604, 1603
4038, 10885, 10886, 1605, 1604
4039, 10886, 10887, 1606, 1605
4040, 10887, 10888, 1607, 1606
4041, 10888, 10889, 1608, 1607
4042, 10889, 1635, 79, 1608
*ELEMENT, type=CPS4, ELSET=Surface110
4043, 23, 617, 10890, 1594
4044, 1594, 10890, 10891, 1595
4045, 1595, 10891, 10892, 1596
4046, 1596, 10892, 10893, 1597
4047, 1597, 10893, 1651, 79
4048, 617, 618, 10894, 10890
4049, 10890, 10894, 10895, 10891
4050, 10891, 10895, 10896, 10892
4051, 10892, 10896, 10897, 10893
4052, 10893, 10897, 1652, 1651
4053, 618, 619, 10898, 10894
4054, 10894, 10898, 10899, 10895
4055, 10895, 10899, 10900, 10896
4056, 10896, 10900, 10901, 10897
4057, 10897, 10901, 1653, 1652
4058, 619, 620, 10902, 10898
4059, 10898, 10902, 10903, 10899
4060, 10899, 10903, 10904, 10900
4061, 10900, 10904, 10905, 10901
4062, 10901, 10905, 1654, 1653
4063, 620, 26, 1647, 10902
4064, 10902, 1647, 1648, 10903
4065, 10903, 1648, 1649, 10904
4066, 10904, 1649, 1650, 10905
4067, 10905, 1650, 81, 1654
*ELEMENT, type=CPS4, ELSET=Surface111
41280, 21, 1563, 10906, 627
41281, 1563, 1564, 10907, 10906
41282, 1564, 1565, 10908, 10907
41283, 1565, 1566, 10909, 10908
41284, 1566, 77, 1659, 10909
41285, 627, 10906, 10910, 628
41286, 10906, 10907, 10911, 10910
41287, 10907, 10908, 10912, 10911
41288, 10908, 10909, 10913, 10912
41289, 10909, 1659, 1660, 10913
41290, 628, 10910, 10914, 629
41291, 10910, 10911, 10915, 10914
41292, 10911, 10912, 10916, 10915
41293, 10912, 10913, 10917, 10916
41294, 10913, 1660, 1661, 10917
41295, 629, 10914, 10918, 630
41296, 10914, 10915, 10919, 10918
41297, 10915, 10916, 10920, 10919
41298, 10916, 10917, 10921, 10920
41299, 10917, 1661, 1662, 10921
41300, 630, 10918, 1655, 28
41301, 10918, 10919, 1656, 1655
41302, 10919, 10920, 1657, 1656
41303, 10920, 10921, 1658, 1657
41304, 10921, 1662, 82, 1658
*ELEMENT, type=CPS4, ELSET=Surface112
41305, 28, 1655, 10922, 644
41306, 1655, 1656, 10923, 10922
41307, 1656, 1657, 10924, 10923
41308, 1657, 1658, 10925, 10924
41309, 1658, 82, 1663, 10925
41310, 644, 10922, 10926, 645
41311, 10922, 10923, 10927, 10926
41312, 10923, 10924, 10928, 10927
41313, 10924, 10925, 10929, 10928
41314, 10925, 1663, 1664, 10929
41315, 645, 10926, 10930, 646
41316, 10926, 10927, 10931, 10930
41317, 10927, 10928, 10932, 10931
41318, 10928, 10929, 10933, 10932
41319, 10929, 1664, 1665, 10933
41320, 646, 10930, 10934, 647
41321, 10930, 10931, 10935, 10934
41322, 10931, 10932, 10936, 10935
41323, 10932, 10933, 10937, 10936
41324, 10933, 1665, 1666, 10937
41325, 647, 10934, 10938, 648
41326, 10934, 10935, 10939, 10938
41327, 10935, 10936, 10940, 10939
41328, 10936, 10937, 10941, 10940
41329, 10937, 1666, 1667, 10941
41330, 648, 10938, 10942, 649
41331, 10938, 10939, 10943, 10942
41332, 10939, 10940, 10944, 10943
41333, 10940, 10941, 10945, 10944
41334, 10941, 1667, 1668, 10945
41335, 649, 10942, 10946, 650
41336, 10942, 10943, 10947, 10946
41337, 10943, 10944, 10948, 10947
41338, 10944, 10945, 10949, 10948
41339, 10945, 1668, 1669, 10949
41340, 650, 10946, 10950, 651
41341, 10946, 10947, 10951, 10950
41342, 10947, 10948, 10952, 10951
41343, 10948, 10949, 10953, 10952
41344, 10949, 1669, 1670, 10953
41345, 651, 10950, 10954, 652
41346, 10950, 10951, 10955, 10954
41347, 10951, 10952, 10956, 10955
41348, 10952, 10953, 10957, 10956
41349, 10953, 1670, 1671, 10957
41350, 652, 10954, 10958, 653
41351, 10954, 10955, 10959, 10958
41352, 10955, 10956, 10960, 10959
41353, 10956, 10957, 10961, 10960
41354, 10957, 1671, 1672, 10961
41355, 653, 10958, 10962, 654
41356, 10958, 10959, 10963, 10962
41357, 10959, 10960, 10964, 10963
41358, 10960, 10961, 10965, 10964
41359, 10961, 1672, 1673, 10965
41360, 654, 10962, 1647, 26
41361, 10962, 10963, 1648, 1647
41362, 10963, 10964, 1649, 1648
41363, 10964, 10965, 1650, 1649
41364, 10965, 1673, 81, 1650
*ELEMENT, type=CPS4, ELSET=Surface113
4068, 77, 1598, 10966, 1659
4069, 1659, 10966, 10967, 1660
4070, 1660, 10967, 10968, 1661
4071, 1661, 10968, 10969, 1662
4072, 1662, 10969, 1663, 82
4073, 1598, 1599, 10970, 10966
4074, 10966, 10970, 10971, 10967
4075, 10967, 10971, 10972, 10968
4076, 10968, 10972, 10973, 10969
4077, 10969, 10973, 1664, 1663
4078, 1599, 1600, 10974, 10970
4079, 10970, 10974, 10975, 10971
4080, 10971, 10975, 10976, 10972
4081, 10972, 10976, 10977, 10973
4082, 10973, 10977, 1665, 1664
4083, 1600, 1601, 10978, 10974
4084, 10974, 10978, 10979, 10975
4085, 10975, 10979, 10980, 10976
4086, 10976, 10980, 10981, 10977
4087, 10977, 10981, 1666, 1665
4088, 1601, 1602, 10982, 10978
4089, 10978, 10982, 10983, 10979
4090, 10979, 10983, 10984, 10980
4091, 10980, 10984, 10985, 10981
4092, 10981, 10985, 1667, 1666
4093, 1602, 1603, 10986, 10982
4094, 10982, 10986, 10987, 10983
4095, 10983, 10987, 10988, 10984
4096, 10984, 10988, 10989, 10985
4097, 10985, 10989, 1668, 1667
4098, 1603, 1604, 10990, 10986
4099, 10986, 10990, 10991, 10987
4100, 10987, 10991, 10992, 10988
4101, 10988, 10992, 10993, 10989
4102, 10989, 10993, 1669, 1668
4103, 1604, 1605, 10994, 10990
4104, 10990, 10994, 10995, 10991
4105, 10991, 10995, 10996, 10992
4106, 10992, 10996, 10997, 10993
4107, 10993, 10997, 1670, 1669
4108, 1605, 1606, 10998, 10994
4109, 10994, 10998, 10999, 10995
4110, 10995, 10999, 11000, 10996
4111, 10996, 11000, 11001, 10997
4112, 10997, 11001, 1671, 1670
4113, 1606, 1607, 11002, 10998
4114, 10998, 11002, 11003, 10999
4115, 10999, 11003, 11004, 11000
4116, 11000, 11004, 11005, 11001
4117, 11001, 11005, 1672, 1671
4118, 1607, 1608, 11006, 11002
4119, 11002, 11006, 11007, 11003
4120, 11003, 11007, 11008, 11004
4121, 11004, 11008, 11009, 11005
4122, 11005, 11009, 1673, 1672
4123, 1608, 79, 1651, 11006
4124, 11006, 1651, 1652, 11007
4125, 11007, 1652, 1653, 11008
4126, 11008, 1653, 1654, 11009
4127, 11009, 1654, 81, 1673
*ELEMENT, type=CPS4, ELSET=Surface114
4128, 26, 678, 11010, 1647
4129, 1647, 11010, 11011, 1648
4130, 1648, 11011, 11012, 1649
4131, 1649, 11012, 11013, 1650
4132, 1650, 11013, 1678, 81
4133, 678, 679, 11014, 11010
4134, 11010, 11014, 11015, 11011
4135, 11011, 11015, 11016, 11012
4136, 11012, 11016, 11017, 11013
4137, 11013, 11017, 1679, 1678
4138, 679, 680, 11018, 11014
4139, 11014, 11018, 11019, 11015
4140, 11015, 11019, 11020, 11016
4141, 11016, 11020, 11021, 11017
4142, 11017, 11021, 1680, 1679
4143, 680, 681, 11022, 11018
4144, 11018, 11022, 11023, 11019
4145, 11019, 11023, 11024, 11020
4146, 11020, 11024, 11025, 11021
4147, 11021, 11025, 1681, 1680
4148, 681, 682, 11026, 11022
4149, 11022, 11026, 11027, 11023
4150, 11023, 11027, 11028, 11024
4151, 11024, 11028, 11029, 11025
4152, 11025, 11029, 1682, 1681
4153, 682, 683, 11030, 11026
4154, 11026, 11030, 11031, 11027
4155, 11027, 11031, 11032, 11028
4156, 11028, 11032, 11033, 11029
4157, 11029, 11033, 1683, 1682
4158, 683, 684, 11034, 11030
4159, 11030, 11034, 11035, 11031
4160, 11031, 11035, 11036, 11032
4161, 11032, 11036, 11037, 11033
4162, 11033, 11037, 1684, 1683
4163, 684, 685, 11038, 11034
4164, 11034, 11038, 11039, 11035
4165, 11035, 11039, 11040, 11036
4166, 11036, 11040, 11041, 11037
4167, 11037, 11041, 1685, 1684
4168, 685, 686, 11042, 11038
4169, 11038, 11042, 11043, 11039
4170, 11039, 11043, 11044, 11040
4171, 11040, 11044, 11045, 11041
4172, 11041, 11045, 1686, 1685
4173, 686, 687, 11046, 11042
4174, 11042, 11046, 11047, 11043
4175, 11043, 11047, 11048, 11044
4176, 11044, 11048, 11049, 11045
4177, 11045, 11049, 1687, 1686
4178, 687, 688, 11050, 11046
4179, 11046, 11050, 11051, 11047
4180, 11047, 11051, 11052, 11048
4181, 11048, 11052, 11053, 11049
4182, 11049, 11053, 1688, 1687
4183, 688, 689, 11054, 11050
4184, 11050, 11054, 11055, 11051
4185, 11051, 11055, 11056, 11052
4186, 11052, 11056, 11057, 11053
4187, 11053, 11057, 1689, 1688
4188, 689, 690, 11058, 11054
4189, 11054, 11058, 11059, 11055
4190, 11055, 11059, 11060, 11056
4191, 11056, 11060, 11061, 11057
4192, 11057, 11061, 1690, 1689
4193, 690, 691, 11062, 11058
4194, 11058, 11062, 11063, 11059
4195, 11059, 11063, 11064, 11060
4196, 11060, 11064, 11065, 11061
4197, 11061, 11065, 1691, 1690
4198, 691, 692, 11066, 11062
4199, 11062, 11066, 11067, 11063
4200, 11063, 11067, 11068, 11064
4201, 11064, 11068, 11069, 11065
4202, 11065, 11069, 1692, 1691
4203, 692, 693, 11070, 11066
4204, 11066, 11070, 11071, 11067
4205, 11067, 11071, 11072, 11068
4206, 11068, 11072, 11073, 11069
4207, 11069, 11073, 1693, 1692
4208, 693, 694, 11074, 11070
4209, 11070, 11074, 11075, 11071
4210, 11071, 11075, 11076, 11072
4211, 11072, 11076, 11077, 11073
4212, 11073, 11077, 1694, 1693
4213, 694, 695, 11078, 11074
4214, 11074, 11078, 11079, 11075
4215, 11075, 11079, 11080, 11076
4216, 11076, 11080, 11081, 11077
4217, 11077, 11081, 1695, 1694
4218, 695, 696, 11082, 11078
4219, 11078, 11082, 11083, 11079
4220, 11079, 11083, 11084, 11080
4221, 11080, 11084, 11085, 11081
4222, 11081, 11085, 1696, 1695
4223, 696, 697, 11086, 11082
4224, 11082, 11086, 11087, 11083
4225, 11083, 11087, 11088, 11084
4226, 11084, 11088, 11089, 11085
4227, 11085, 11089, 1697, 1696
4228, 697, 698, 11090, 11086
4229, 11086, 11090, 11091, 11087
4230, 11087, 11091, 11092, 11088
4231, 11088, 11092, 11093, 11089
4232, 11089, 11093, 1698, 1697
4233, 698, 699, 11094, 11090
4234, 11090, 11094, 11095, 11091
4235, 11091, 11095, 11096, 11092
4236, 11092, 11096, 11097, 11093
4237, 11093, 11097, 1699, 1698
4238, 699, 700, 11098, 11094
4239, 11094, 11098, 11099, 11095
4240, 11095, 11099, 11100, 11096
4241, 11096, 11100, 11101, 11097
4242, 11097, 11101, 1700, 1699
4243, 700, 30, 1674, 11098
4244, 11098, 1674, 1675, 11099
4245, 11099, 1675, 1676, 11100
4246, 11100, 1676, 1677, 11101
4247, 11101, 1677, 83, 1700
*ELEMENT, type=CPS4, ELSET=Surface115
41365, 28, 1655, 11102, 726
41366, 1655, 1656, 11103, 11102
41367, 1656, 1657, 11104, 11103
41368, 1657, 1658, 11105, 11104
41369, 1658, 82, 1705, 11105
41370, 726, 11102, 11106, 727
41371, 11102, 11103, 11107, 11106
41372, 11103, 11104, 11108, 11107
41373, 11104, 11105, 11109, 11108
41374, 11105, 1705, 1706, 11109
41375, 727, 11106, 11110, 728
41376, 11106, 11107, 11111, 11110
41377, 11107, 11108, 11112, 11111
41378, 11108, 11109, 11113, 11112
41379, 11109, 1706, 1707, 11113
41380, 728, 11110, 11114, 729
41381, 11110, 11111, 11115, 11114
41382, 11111, 11112, 11116, 11115
41383, 11112, 11113, 11117, 11116
41384, 11113, 1707, 1708, 11117
41385, 729, 11114, 11118, 730
41386, 11114, 11115, 11119, 11118
41387, 11115, 11116, 11120, 11119
41388, 11116, 11117, 11121, 11120
41389, 11117, 1708, 1709, 11121
41390, 730, 11118, 11122, 731
41391, 11118, 11119, 11123, 11122
41392, 11119, 11120, 11124, 11123
41393, 11120, 11121, 11125, 11124
41394, 11121, 1709, 1710, 11125
41395, 731, 11122, 11126, 732
41396, 11122, 11123, 11127, 11126
41397, 11123, 11124, 11128, 11127
41398, 11124, 11125, 11129, 11128
41399, 11125, 1710, 1711, 11129
41400, 732, 11126, 11130, 733
41401, 11126, 11127, 11131, 11130
41402, 11127, 11128, 11132, 11131
41403, 11128, 11129, 11133, 11132
41404, 11129, 1711, 1712, 11133
41405, 733, 11130, 11134, 734
41406, 11130, 11131, 11135, 11134
41407, 11131, 11132, 11136, 11135
41408, 11132, 11133, 11137, 11136
41409, 11133, 1712, 1713, 11137
41410, 734, 11134, 11138, 735
41411, 11134, 11135, 11139, 11138
41412, 11135, 11136, 11140, 11139
41413, 11136, 11137, 11141, 11140
41414, 11137, 1713, 1714, 11141
41415, 735, 11138, 11142, 736
41416, 11138, 11139, 11143, 11142
41417, 11139, 11140, 11144, 11143
41418, 11140, 11141, 11145, 11144
41419, 11141, 1714, 1715, 11145
41420, 736, 11142, 11146, 737
41421, 11142, 11143, 11147, 11146
41422, 11143, 11144, 11148, 11147
41423, 11144, 11145, 11149, 11148
41424, 11145, 1715, 1716, 11149
41425, 737, 11146, 11150, 738
41426, 11146, 11147, 11151, 11150
41427, 11147, 11148, 11152, 11151
41428, 11148, 11149, 11153, 11152
41429, 11149, 1716, 1717, 11153
41430, 738, 11150, 11154, 739
41431, 11150, 11151, 11155, 11154
41432, 11151, 11152, 11156, 11155
41433, 11152, 11153, 11157, 11156
41434, 11153, 1717, 1718, 11157
41435, 739, 11154, 11158, 740
41436, 11154, 11155, 11159, 11158
41437, 11155, 11156, 11160, 11159
41438, 11156, 11157, 11161, 11160
41439, 11157, 1718, 1719, 11161
41440, 740, 11158, 11162, 741
41441, 11158, 11159, 11163, 11162
41442, 11159, 11160, 11164, 11163
41443, 11160, 11161, 11165, 11164
41444, 11161, 1719, 1720, 11165
41445, 741, 11162, 11166, 742
41446, 11162, 11163, 11167, 11166
41447, 11163, 11164, 11168, 11167
41448, 11164, 11165, 11169, 11168
41449, 11165, 1720, 1721, 11169
41450, 742, 11166, 11170, 743
41451, 11166, 11167, 11171, 11170
41452, 11167, 11168, 11172, 11171
41453, 11168, 11169, 11173, 11172
41454, 11169, 1721, 1722, 11173
41455, 743, 11170, 11174, 744
41456, 11170, 11171, 11175, 11174
41457, 11171, 11172, 11176, 11175
41458, 11172, 11173, 11177, 11176
41459, 11173, 1722, 1723, 11177
41460, 744, 11174, 11178, 745
41461, 11174, 11175, 11179, 11178
41462, 11175, 11176, 11180, 11179
41463, 11176, 11177, 11181, 11180
41464, 11177, 1723, 1724, 11181
41465, 745, 11178, 11182, 746
41466, 11178, 11179, 11183, 11182
41467, 11179, 11180, 11184, 11183
41468, 11180, 11181, 11185, 11184
41469, 11181, 1724, 1725, 11185
41470, 746, 11182, 11186, 747
41471, 11182, 11183, 11187, 11186
41472, 11183, 11184, 11188, 11187
41473, 11184, 11185, 11189, 11188
41474, 11185, 1725, 1726, 11189
41475, 747, 11186, 11190, 748
41476, 11186, 11187, 11191, 11190
41477, 11187, 11188, 11192, 11191
41478, 11188, 11189, 11193, 11192
41479, 11189, 1726, 1727, 11193
41480, 748, 11190, 1701, 32
41481, 11190, 11191, 1702, 1701
41482, 11191, 11192, 1703, 1702
41483, 11192, 11193, 1704, 1703
41484, 11193, 1727, 84, 1704
*ELEMENT, type=CPS4, ELSET=Surface116
41485, 32, 1701, 11194, 762
41486, 1701, 1702, 11195, 11194
41487, 1702, 1703, 11196, 11195
41488, 1703, 1704, 11197, 11196
41489, 1704, 84, 1728, 11197
41490, 762, 11194, 11198, 763
41491, 11194, 11195, 11199, 11198
41492, 11195, 11196, 11200, 11199
41493, 11196, 11197, 11201, 11200
41494, 11197, 1728, 1729, 11201
41495, 763, 11198, 11202, 764
41496, 11198, 11199, 11203, 11202
41497, 11199, 11200, 11204, 11203
41498, 11200, 11201, 11205, 11204
41499, 11201, 1729, 1730, 11205
41500, 764, 11202, 11206, 765
41501, 11202, 11203, 11207, 11206
41502, 11203, 11204, 11208, 11207
41503, 11204, 11205, 11209, 11208
41504, 11205, 1730, 1731, 11209
41505, 765, 11206, 11210, 766
41506, 11206, 11207, 11211, 11210
41507, 11207, 11208, 11212, 11211
41508, 11208, 11209, 11213, 11212
41509, 11209, 1731, 1732, 11213
41510, 766, 11210, 11214, 767
41511, 11210, 11211, 11215, 11214
41512, 11211, 11212, 11216, 11215
41513, 11212, 11213, 11217, 11216
41514, 11213, 1732, 1733, 11217
41515, 767, 11214, 11218, 768
41516, 11214, 11215, 11219, 11218
41517, 11215, 11216, 11220, 11219
41518, 11216, 11217, 11221, 11220
41519, 11217, 1733, 1734, 11221
41520, 768, 11218, 11222, 769
41521, 11218, 11219, 11223, 11222
41522, 11219, 11220, 11224, 11223
41523, 11220, 11221, 11225, 11224
41524, 11221, 1734, 1735, 11225
41525, 769, 11222, 11226, 770
41526, 11222, 11223, 11227, 11226
41527, 11223, 11224, 11228, 11227
41528, 11224, 11225, 11229, 11228
41529, 11225, 1735, 1736, 11229
41530, 770, 11226, 11230, 771
41531, 11226, 11227, 11231, 11230
41532, 11227, 11228, 11232, 11231
41533, 11228, 11229, 11233, 11232
41534, 11229, 1736, 1737, 11233
41535, 771, 11230, 11234, 772
41536, 11230, 11231, 11235, 11234
41537, 11231, 11232, 11236, 11235
41538, 11232, 11233, 11237, 11236
41539, 11233, 1737, 1738, 11237
41540, 772, 11234, 1674, 30
41541, 11234, 11235, 1675, 1674
41542, 11235, 11236, 1676, 1675
41543, 11236, 11237, 1677, 1676
41544, 11237, 1738, 83, 1677
*ELEMENT, type=CPS4, ELSET=Surface117
4248, 82, 1663, 11238, 1705
4249, 1705, 11238, 11239, 1706
4250, 1706, 11239, 11240, 1707
4251, 1707, 11240, 11241, 1708
4252, 1708, 11241, 11242, 1709
4253, 1709, 11242, 11243, 1710
4254, 1710, 11243, 11244, 1711
4255, 1711, 11244, 11245, 1712
4256, 1712, 11245, 11246, 1713
4257, 1713, 11246, 11247, 1714
4258, 1714, 11247, 11248, 1715
4259, 1715, 11248, 11249, 1716
4260, 1716, 11249, 11250, 1717
4261, 1717, 11250, 11251, 1718
4262, 1718, 11251, 11252, 1719
4263, 1719, 11252, 11253, 1720
4264, 1720, 11253, 11254, 1721
4265, 1721, 11254, 11255, 1722
4266, 1722, 11255, 11256, 1723
4267, 1723, 11256, 11257, 1724
4268, 1724, 11257, 11258, 1725
4269, 1725, 11258, 11259, 1726
4270, 1726, 11259, 11260, 1727
4271, 1727, 11260, 1728, 84
4272, 1663, 1664, 11261, 11238
4273, 11238, 11261, 11262, 11239
4274, 11239, 11262, 11263, 11240
4275, 11240, 11263, 11264, 11241
4276, 11241, 11264, 11265, 11242
4277, 11242, 11265, 11266, 11243
4278, 11243, 11266, 11267, 11244
4279, 11244, 11267, 11268, 11245
4280, 11245, 11268, 11269, 11246
4281, 11246, 11269, 11270, 11247
4282, 11247, 11270, 11271, 11248
4283, 11248, 11271, 11272, 11249
4284, 11249, 11272, 11273, 11250
4285, 11250, 11273, 11274, 11251
4286, 11251, 11274, 11275, 11252
4287, 11252, 11275, 11276, 11253
4288, 11253, 11276, 11277, 11254
4289, 11254, 11277, 11278, 11255
4290, 11255, 11278, 11279, 11256
4291, 11256, 11279, 11280, 11257
4292, 11257, 11280, 11281, 11258
4293, 11258, 11281, 11282, 11259
4294, 11259, 11282, 11283, 11260
4295, 11260, 11283, 1729, 1728
4296, 1664, 1665, 11284, 11261
4297, 11261, 11284, 11285, 11262
4298, 11262, 11285, 11286, 11263
4299, 11263, 11286, 11287, 11264
4300, 11264, 11287, 11288, 11265
4301, 11265, 11288, 11289, 11266
4302, 11266, 11289, 11290, 11267
4303, 11267, 11290, 11291, 11268
4304, 11268, 11291, 11292, 11269
4305, 11269, 11292, 11293, 11270
4306, 11270, 11293, 11294, 11271
4307, 11271, 11294, 11295, 11272
4308, 11272, 11295, 11296, 11273
4309, 11273, 11296, 11297, 11274
4310, 11274, 11297, 11298, 11275
4311, 11275, 11298, 11299, 11276
4312, 11276, 11299, 11300, 11277
4313, 11277, 11300, 11301, 11278
4314, 11278, 11301, 11302, 11279
4315, 11279, 11302, 11303, 11280
4316, 11280, 11303, 11304, 11281
4317, 11281, 11304, 11305, 11282
4318, 11282, 11305, 11306, 11283
4319, 11283, 11306, 1730, 1729
4320, 1665, 1666, 11307, 11284
4321, 11284, 11307, 11308, 11285
4322, 11285, 11308, 11309, 11286
4323, 11286, 11309, 11310, 11287
4324, 11287, 11310, 11311, 11288
4325, 11288, 11311, 11312, 11289
4326, 11289, 11312, 11313, 11290
4327, 11290, 11313, 11314, 11291
4328, 11291, 11314, 11315, 11292
4329, 11292, 11315, 11316, 11293
4330, 11293, 11316, 11317, 11294
4331, 11294, 11317, 11318, 11295
4332, 11295, 11318, 11319, 11296
4333, 11296, 11319, 11320, 11297
4334, 11297, 11320, 11321, 11298
4335, 11298, 11321, 11322, 11299
4336, 11299, 11322, 11323, 11300
4337, 11300, 11323, 11324, 11301
4338, 11301, 11324, 11325, 11302
4339, 11302, 11325, 11326, 11303
4340, 11303, 11326, 11327, 11304
4341, 11304, 11327, 11328, 11305
4342, 11305, 11328, 11329, 11306
4343, 11306, 11329, 1731, 1730
4344, 1666, 1667, 11330, 11307
4345, 11307, 11330, 11331, 11308
4346, 11308, 11331, 11332, 11309
4347, 11309, 11332, 11333, 11310
4348, 11310, 11333, 11334, 11311
4349, 11311, 11334, 11335, 11312
4350, 11312, 11335, 11336, 11313
4351, 11313, 11336, 11337, 11314
4352, 11314, 11337, 11338, 11315
4353, 11315, 11338, 11339, 11316
4354, 11316, 11339, 11340, 11317
4355, 11317, 11340, 11341, 11318
4356, 11318, 11341, 11342, 11319
4357, 11319, 11342, 11343, 11320
4358, 11320, 11343, 11344, 11321
4359, 11321, 11344, 11345, 11322
4360, 11322, 11345, 11346, 11323
4361, 11323, 11346, 11347, 11324
4362, 11324, 11347, 11348, 11325
4363, 11325, 11348, 11349, 11326
4364, 11326, 11349, 11350, 11327
4365, 11327, 11350, 11351, 11328
4366, 11328, 11351, 11352, 11329
4367, 11329, 11352, 1732, 1731
4368, 1667, 1668, 11353, 11330
4369, 11330, 11353, 11354, 11331
4370, 11331, 11354, 11355, 11332
4371, 11332, 11355, 11356, 11333
4372, 11333, 11356, 11357, 11334
4373, 11334, 11357, 11358, 11335
4374, 11335, 11358, 11359, 11336
4375, 11336, 11359, 11360, 11337
4376, 11337, 11360, 11361, 11338
4377, 11338, 11361, 11362, 11339
4378, 11339, 11362, 11363, 11340
4379, 11340, 11363, 11364, 11341
4380, 11341, 11364, 11365, 11342
4381, 11342, 11365, 11366, 11343
4382, 11343, 11366, 11367, 11344
4383, 11344, 11367, 11368, 11345
4384, 11345, 11368, 11369, 11346
4385, 11346, 11369, 11370, 11347
4386, 11347, 11370, 11371, 11348
4387, 11348, 11371, 11372, 11349
4388, 11349, 11372, 11373, 11350
4389, 11350, 11373, 11374, 11351
4390, 11351, 11374, 11375, 11352
4391, 11352, 11375, 1733, 1732
4392, 1668, 1669, 11376, 11353
4393, 11353, 11376, 11377, 11354
4394, 11354, 11377, 11378, 11355
4395, 11355, 11378, 11379, 11356
4396, 11356, 11379, 11380, 11357
4397, 11357, 11380, 11381, 11358
4398, 11358, 11381, 11382, 11359
4399, 11359, 11382, 11383, 11360
4400, 11360, 11383, 11384, 11361
4401, 11361, 11384, 11385, 11362
4402, 11362, 11385, 11386, 11363
4403, 11363, 11386, 11387, 11364
4404, 11364, 11387, 11388, 11365
4405, 11365, 11388, 11389, 11366
4406, 11366, 11389, 11390, 11367
4407, 11367, 11390, 11391, 11368
4408, 11368, 11391, 11392, 11369
4409, 11369, 11392, 11393, 11370
4410, 11370, 11393, 11394, 11371
4411, 11371, 11394, 11395, 11372
4412, 11372, 11395, 11396, 11373
4413, 11373, 11396, 11397, 11374
4414, 11374, 11397, 11398, 11375
4415, 11375, 11398, 1734, 1733
4416, 1669, 1670, 11399, 11376
4417, 11376, 11399, 11400, 11377
4418, 11377, 11400, 11401, 11378
4419, 11378, 11401, 11402, 11379
4420, 11379, 11402, 11403, 11380
4421, 11380, 11403, 11404, 11381
4422, 11381, 11404, 11405, 11382
4423, 11382, 11405, 11406, 11383
4424, 11383, 11406, 11407, 11384
4425, 11384, 11407, 11408, 11385
4426, 11385, 11408, 11409, 11386
4427, 11386, 11409, 11410, 11387
4428, 11387, 11410, 11411, 11388
4429, 11388, 11411, 11412, 11389
4430, 11389, 11412, 11413, 11390
4431, 11390, 11413, 11414, 11391
4432, 11391, 11414, 11415, 11392
4433, 11392, 11415, 11416, 11393
4434, 11393, 11416, 11417, 11394
4435, 11394, 11417, 11418, 11395
4436, 11395, 11418, 11419, 11396
4437, 11396, 11419, 11420, 11397
4438, 11397, 11420, 11421, 11398
4439, 11398, 11421, 1735, 1734
4440, 1670, 1671, 11422, 11399
4441, 11399, 11422, 11423, 11400
4442, 11400, 11423, 11424, 11401
4443, 11401, 11424, 11425, 11402
4444, 11402, 11425, 11426, 11403
4445, 11403, 11426, 11427, 11404
4446, 11404, 11427, 11428, 11405
4447, 11405, 11428, 11429, 11406
4448, 11406, 11429, 11430, 11407
4449, 11407, 11430, 11431, 11408
4450, 11408, 11431, 11432, 11409
4451, 11409, 11432, 11433, 11410
4452, 11410, 11433, 11434, 11411
4453, 11411, 11434, 11435, 11412
4454, 11412, 11435, 11436, 11413
4455, 11413, 11436, 11437, 11414
4456, 11414, 11437, 11438, 11415
4457, 11415, 11438, 11439, 11416
4458, 11416, 11439, 11440, 11417
4459, 11417, 11440, 11441, 11418
4460, 11418, 11441, 11442, 11419
4461, 11419, 11442, 11443, 11420
4462, 11420, 11443, 11444, 11421
4463, 11421, 11444, 1736, 1735
4464, 1671, 1672, 11445, 11422
4465, 11422, 11445, 11446, 11423
4466, 11423, 11446, 11447, 11424
4467, 11424, 11447, 11448, 11425
4468, 11425, 11448, 11449, 11426
4469, 11426, 11449, 11450, 11427
4470, 11427, 11450, 11451, 11428
4471, 11428, 11451, 11452, 11429
4472, 11429, 11452, 11453, 11430
4473, 11430, 11453, 11454, 11431
4474, 11431, 11454, 11455, 11432
4475, 11432, 11455, 11456, 11433
4476, 11433, 11456, 11457, 11434
4477, 11434, 11457, 11458, 11435
4478, 11435, 11458, 11459, 11436
4479, 11436, 11459, 11460, 11437
4480, 11437, 11460, 11461, 11438
4481, 11438, 11461, 11462, 11439
4482, 11439, 11462, 11463, 11440
4483, 11440, 11463, 11464, 11441
4484, 11441, 11464, 11465, 11442
4485, 11442, 11465, 11466, 11443
4486, 11443, 11466, 11467, 11444
4487, 11444, 11467, 1737, 1736
4488, 1672, 1673, 11468, 11445
4489, 11445, 11468, 11469, 11446
4490, 11446, 11469, 11470, 11447
4491, 11447, 11470, 11471, 11448
4492, 11448, 11471, 11472, 11449
4493, 11449, 11472, 11473, 11450
4494, 11450, 11473, 11474, 11451
4495, 11451, 11474, 11475, 11452
4496, 11452, 11475, 11476, 11453
4497, 11453, 11476, 11477, 11454
4498, 11454, 11477, 11478, 11455
4499, 11455, 11478, 11479, 11456
4500, 11456, 11479, 11480, 11457
4501, 11457, 11480, 11481, 11458
4502, 11458, 11481, 11482, 11459
4503, 11459, 11482, 11483, 11460
4504, 11460, 11483, 11484, 11461
4505, 11461, 11484, 11485, 11462
4506, 11462, 11485, 11486, 11463
4507, 11463, 11486, 11487, 11464
4508, 11464, 11487, 11488, 11465
4509, 11465, 11488, 11489, 11466
4510, 11466, 11489, 11490, 11467
4511, 11467, 11490, 1738, 1737
4512, 1673, 81, 1678, 11468
4513, 11468, 1678, 1679, 11469
4514, 11469, 1679, 1680, 11470
4515, 11470, 1680, 1681, 11471
4516, 11471, 1681, 1682, 11472
4517, 11472, 1682, 1683, 11473
4518, 11473, 1683, 1684, 11474
4519, 11474, 1684, 1685, 11475
4520, 11475, 1685, 1686, 11476
4521, 11476, 1686, 1687, 11477
4522, 11477, 1687, 1688, 11478
4523, 11478, 1688, 1689, 11479
4524, 11479, 1689, 1690, 11480
4525, 11480, 1690, 1691, 11481
4526, 11481, 1691, 1692, 11482
4527, 11482, 1692, 1693, 11483
4528, 11483, 1693, 1694, 11484
4529, 11484, 1694, 1695, 11485
4530, 11485, 1695, 1696, 11486
4531, 11486, 1696, 1697, 11487
4532, 11487, 1697, 1698, 11488
4533, 11488, 1698, 1699, 11489
4534, 11489, 1699, 1700, 11490
4535, 11490, 1700, 83, 1738
*ELEMENT, type=CPS4, ELSET=Surface118
41545, 2, 149, 11491, 1743
41546, 1743, 11491, 11492, 1744
41547, 1744, 11492, 11493, 1745
41548, 1745, 11493, 11494, 1746
41549, 1746, 11494, 1747, 86
41550, 149, 150, 11495, 11491
41551, 11491, 11495, 11496, 11492
41552, 11492, 11496, 11497, 11493
41553, 11493, 11497, 11498, 11494
41554, 11494, 11498, 1748, 1747
41555, 150, 151, 11499, 11495
41556, 11495, 11499, 11500, 11496
41557, 11496, 11500, 11501, 11497
41558, 11497, 11501, 11502, 11498
41559, 11498, 11502, 1749, 1748
41560, 151, 152, 11503, 11499
41561, 11499, 11503, 11504, 11500
41562, 11500, 11504, 11505, 11501
41563, 11501, 11505, 11506, 11502
41564, 11502, 11506, 1750, 1749
41565, 152, 153, 11507, 11503
41566, 11503, 11507, 11508, 11504
41567, 11504, 11508, 11509, 11505
41568, 11505, 11509, 11510, 11506
41569, 11506, 11510, 1751, 1750
41570, 153, 154, 11511, 11507
41571, 11507, 11511, 11512, 11508
41572, 11508, 11512, 11513, 11509
41573, 11509, 11513, 11514, 11510
41574, 11510, 11514, 1752, 1751
41575, 154, 155, 11515, 11511
41576, 11511, 11515, 11516, 11512
41577, 11512, 11516, 11517, 11513
41578, 11513, 11517, 11518, 11514
41579, 11514, 11518, 1753, 1752
41580, 155, 156, 11519, 11515
41581, 11515, 11519, 11520, 11516
41582, 11516, 11520, 11521, 11517
41583, 11517, 11521, 11522, 11518
41584, 11518, 11522, 1754, 1753
41585, 156, 157, 11523, 11519
41586, 11519, 11523, 11524, 11520
41587, 11520, 11524, 11525, 11521
41588, 11521, 11525, 11526, 11522
41589, 11522, 11526, 1755, 1754
41590, 157, 158, 11527, 11523
41591, 11523, 11527, 11528, 11524
41592, 11524, 11528, 11529, 11525
41593, 11525, 11529, 11530, 11526
41594, 11526, 11530, 1756, 1755
41595, 158, 159, 11531, 11527
41596, 11527, 11531, 11532, 11528
41597, 11528, 11532, 11533, 11529
41598, 11529, 11533, 11534, 11530
41599, 11530, 11534, 1757, 1756
41600, 159, 160, 11535, 11531
41601, 11531, 11535, 11536, 11532
41602, 11532, 11536, 11537, 11533
41603, 11533, 11537, 11538, 11534
41604, 11534, 11538, 1758, 1757
41605, 160, 161, 11539, 11535
41606, 11535, 11539, 11540, 11536
41607, 11536, 11540, 11541, 11537
41608, 11537, 11541, 11542, 11538
41609, 11538, 11542, 1759, 1758
41610, 161, 162, 11543, 11539
41611, 11539, 11543, 11544, 11540
41612, 11540, 11544, 11545, 11541
41613, 11541, 11545, 11546, 11542
41614, 11542, 11546, 1760, 1759
41615, 162, 163, 11547, 11543
41616, 11543, 11547, 11548, 11544
41617, 11544, 11548, 11549, 11545
41618, 11545, 11549, 11550, 11546
41619, 11546, 11550, 1761, 1760
41620, 163, 164, 11551, 11547
41621, 11547, 11551, 11552, 11548
41622, 11548, 11552, 11553, 11549
41623, 11549, 11553, 11554, 11550
41624, 11550, 11554, 1762, 1761
41625, 164, 165, 11555, 11551
41626, 11551, 11555, 11556, 11552
41627, 11552, 11556, 11557, 11553
41628, 11553, 11557, 11558, 11554
41629, 11554, 11558, 1763, 1762
41630, 165, 166, 11559, 11555
41631, 11555, 11559, 11560, 11556
41632, 11556, 11560, 11561, 11557
41633, 11557, 11561, 11562, 11558
41634, 11558, 11562, 1764, 1763
41635, 166, 167, 11563, 11559
41636, 11559, 11563, 11564, 11560
41637, 11560, 11564, 11565, 11561
41638, 11561, 11565, 11566, 11562
41639, 11562, 11566, 1765, 1764
41640, 167, 168, 11567, 11563
41641, 11563, 11567, 11568, 11564
41642, 11564, 11568, 11569, 11565
41643, 11565, 11569, 11570, 11566
41644, 11566, 11570, 1766, 1765
41645, 168, 169, 11571, 11567
41646, 11567, 11571, 11572, 11568
41647, 11568, 11572, 11573, 11569
41648, 11569, 11573, 11574, 11570
41649, 11570, 11574, 1767, 1766
41650, 169, 170, 11575, 11571
41651, 11571, 11575, 11576, 11572
41652, 11572, 11576, 11577, 11573
41653, 11573, 11577, 11578, 11574
41654, 11574, 11578, 1768, 1767
41655, 170, 171, 11579, 11575
41656, 11575, 11579, 11580, 11576
41657, 11576, 11580, 11581, 11577
41658, 11577, 11581, 11582, 11578
41659, 11578, 11582, 1769, 1768
41660, 171, 6, 1739, 11579
41661, 11579, 1739, 1740, 11580
41662, 11580, 1740, 1741, 11581
41663, 11581, 1741, 1742, 11582
41664, 11582, 1742, 85, 1769
*ELEMENT, type=CPS4, ELSET=Surface119
41665, 6, 123, 11583, 1739
41666, 1739, 11583, 11584, 1740
41667, 1740, 11584, 11585, 1741
41668, 1741, 11585, 11586, 1742
41669, 1742, 11586, 1774, 85
41670, 123, 124, 11587, 11583
41671, 11583, 11587, 11588, 11584
41672, 11584, 11588, 11589, 11585
41673, 11585, 11589, 11590, 11586
41674, 11586, 11590, 1775, 1774
41675, 124, 125, 11591, 11587
41676, 11587, 11591, 11592, 11588
41677, 11588, 11592, 11593, 11589
41678, 11589, 11593, 11594, 11590
41679, 11590, 11594, 1776, 1775
41680, 125, 126, 11595, 11591
41681, 11591, 11595, 11596, 11592
41682, 11592, 11596, 11597, 11593
41683, 11593, 11597, 11598, 11594
41684, 11594, 11598, 1777, 1776
41685, 126, 127, 11599, 11595
41686, 11595, 11599, 11600, 11596
41687, 11596, 11600, 11601, 11597
41688, 11597, 11601, 11602, 11598
41689, 11598, 11602, 1778, 1777
41690, 127, 128, 11603, 11599
41691, 11599, 11603, 11604, 11600
41692, 11600, 11604, 11605, 11601
41693, 11601, 11605, 11606, 11602
41694, 11602, 11606, 1779, 1778
41695, 128, 129, 11607, 11603
41696, 11603, 11607, 11608, 11604
41697, 11604, 11608, 11609, 11605
41698, 11605, 11609, 11610, 11606
41699, 11606, 11610, 1780, 1779
41700, 129, 130, 11611, 11607
41701, 11607, 11611, 11612, 11608
41702, 11608, 11612, 11613, 11609
41703, 11609, 11613, 11614, 11610
41704, 11610, 11614, 1781, 1780
41705, 130, 131, 11615, 11611
41706, 11611, 11615, 11616, 11612
41707, 11612, 11616, 11617, 11613
41708, 11613, 11617, 11618, 11614
41709, 11614, 11618, 1782, 1781
41710, 131, 132, 11619, 11615
41711, 11615, 11619, 11620, 11616
41712, 11616, 11620, 11621, 11617
41713, 11617, 11621, 11622, 11618
41714, 11618, 11622, 1783, 1782
41715, 132, 133, 11623, 11619
41716, 11619, 11623, 11624, 11620
41717, 11620, 11624, 11625, 11621
41718, 11621, 11625, 11626, 11622
41719, 11622, 11626, 1784, 1783
41720, 133, 5, 1770, 11623
41721, 11623, 1770, 1771, 11624
41722, 11624, 1771, 1772, 11625
41723, 11625, 1772, 1773, 11626
41724, 11626, 1773, 87, 1784
*ELEMENT, type=CPS4, ELSET=Surface120
4536, 1, 1785, 11627, 172
4537, 1785, 1786, 11628, 11627
4538, 1786, 1787, 11629, 11628
4539, 1787, 1788, 11630, 11629
4540, 1788, 88, 1789, 11630
4541, 172, 11627, 11631, 173
4542, 11627, 11628, 11632, 11631
4543, 11628, 11629, 11633, 11632
4544, 11629, 11630, 11634, 11633
4545, 11630, 1789, 1790, 11634
4546, 173, 11631, 11635, 174
4547, 11631, 11632, 11636, 11635
4548, 11632, 11633, 11637, 11636
4549, 11633, 11634, 11638, 11637
4550, 11634, 1790, 1791, 11638
4551, 174, 11635, 11639, 175
4552, 11635, 11636, 11640, 11639
4553, 11636, 11637, 11641, 11640
4554, 11637, 11638, 11642, 11641
4555, 11638, 1791, 1792, 11642
4556, 175, 11639, 11643, 176
4557, 11639, 11640, 11644, 11643
4558, 11640, 11641, 11645, 11644
4559, 11641, 11642, 11646, 11645
4560, 11642, 1792, 1793, 11646
4561, 176, 11643, 11647, 177
4562, 11643, 11644, 11648, 11647
4563, 11644, 11645, 11649, 11648
4564, 11645, 11646, 11650, 11649
4565, 11646, 1793, 1794, 11650
4566, 177, 11647, 11651, 178
4567, 11647, 11648, 11652, 11651
4568, 11648, 11649, 11653, 11652
4569, 11649, 11650, 11654, 11653
4570, 11650, 1794, 1795, 11654
4571, 178, 11651, 11655, 179
4572, 11651, 11652, 11656, 11655
4573, 11652, 11653, 11657, 11656
4574, 11653, 11654, 11658, 11657
4575, 11654, 1795, 1796, 11658
4576, 179, 11655, 11659, 180
4577, 11655, 11656, 11660, 11659
4578, 11656, 11657, 11661, 11660
4579, 11657, 11658, 11662, 11661
4580, 11658, 1796, 1797, 11662
4581, 180, 11659, 11663, 181
4582, 11659, 11660, 11664, 11663
4583, 11660, 11661, 11665, 11664
4584, 11661, 11662, 11666, 11665
4585, 11662, 1797, 1798, 11666
4586, 181, 11663, 11667, 182
4587, 11663, 11664, 11668, 11667
4588, 11664, 11665, 11669, 11668
4589, 11665, 11666, 11670, 11669
4590, 11666, 1798, 1799, 11670
4591, 182, 11667, 11671, 183
4592, 11667, 11668, 11672, 11671
4593, 11668, 11669, 11673, 11672
4594, 11669, 11670, 11674, 11673
4595, 11670, 1799, 1800, 11674
4596, 183, 11671, 11675, 184
4597, 11671, 11672, 11676, 11675
4598, 11672, 11673, 11677, 11676
4599, 11673, 11674, 11678, 11677
4600, 11674, 1800, 1801, 11678
4601, 184, 11675, 11679, 185
4602, 11675, 11676, 11680, 11679
4603, 11676, 11677, 11681, 11680
4604, 11677, 11678, 11682, 11681
4605, 11678, 1801, 1802, 11682
4606, 185, 11679, 11683, 186
4607, 11679, 11680, 11684, 11683
4608, 11680, 11681, 11685, 11684
4609, 11681, 11682, 11686, 11685
4610, 11682, 1802, 1803, 11686
4611, 186, 11683, 11687, 187
4612, 11683, 11684, 11688, 11687
4613, 11684, 11685, 11689, 11688
4614, 11685, 11686, 11690, 11689
4615, 11686, 1803, 1804, 11690
4616, 187, 11687, 11691, 188
4617, 11687, 11688, 11692, 11691
4618, 11688, 11689, 11693, 11692
4619, 11689, 11690, 11694, 11693
4620, 11690, 1804, 1805, 11694
4621, 188, 11691, 11695, 189
4622, 11691, 11692, 11696, 11695
4623, 11692, 11693, 11697, 11696
4624, 11693, 11694, 11698, 11697
4625, 11694, 1805, 1806, 11698
4626, 189, 11695, 11699, 190
4627, 11695, 11696, 11700, 11699
4628, 11696, 11697, 11701, 11700
4629, 11697, 11698, 11702, 11701
4630, 11698, 1806, 1807, 11702
4631, 190, 11699, 11703, 191
4632, 11699, 11700, 11704, 11703
4633, 11700, 11701, 11705, 11704
4634, 11701, 11702, 11706, 11705
4635, 11702, 1807, 1808, 11706
4636, 191, 11703, 11707, 192
4637, 11703, 11704, 11708, 11707
4638, 11704, 11705, 11709, 11708
4639, 11705, 11706, 11710, 11709
4640, 11706, 1808, 1809, 11710
4641, 192, 11707, 11711, 193
4642, 11707, 11708, 11712, 11711
4643, 11708, 11709, 11713, 11712
4644, 11709, 11710, 11714, 11713
4645, 11710, 1809, 1810, 11714
4646, 193, 11711, 11715, 194
4647, 11711, 11712, 11716, 11715
4648, 11712, 11713, 11717, 11716
4649, 11713, 11714, 11718, 11717
4650, 11714, 1810, 1811, 11718
4651, 194, 11715, 1770, 5
4652, 11715, 11716, 1771, 1770
4653, 11716, 11717, 1772, 1771
4654, 11717, 11718, 1773, 1772
4655, 11718, 1811, 87, 1773
*ELEMENT, type=CPS4, ELSET=Surface121
41725, 2, 1743, 11719, 97
41726, 1743, 1744, 11720, 11719
41727, 1744, 1745, 11721, 11720
41728, 1745, 1746, 11722, 11721
41729, 1746, 86, 1812, 11722
41730, 97, 11719, 11723, 98
41731, 11719, 11720, 11724, 11723
41732, 11720, 11721, 11725, 11724
41733, 11721, 11722, 11726, 11725
41734, 11722, 1812, 1813, 11726
41735, 98, 11723, 11727, 99
41736, 11723, 11724, 11728, 11727
41737, 11724, 11725, 11729, 11728
41738, 11725, 11726, 11730, 11729
41739, 11726, 1813, 1814, 11730
41740, 99, 11727, 11731, 100
41741, 11727, 11728, 11732, 11731
41742, 11728, 11729, 11733, 11732
41743, 11729, 11730, 11734, 11733
41744, 11730, 1814, 1815, 11734
41745, 100, 11731, 11735, 101
41746, 11731, 11732, 11736, 11735
41747, 11732, 11733, 11737, 11736
41748, 11733, 11734, 11738, 11737
41749, 11734, 1815, 1816, 11738
41750, 101, 11735, 11739, 102
41751, 11735, 11736, 11740, 11739
41752, 11736, 11737, 11741, 11740
41753, 11737, 11738, 11742, 11741
41754, 11738, 1816, 1817, 11742
41755, 102, 11739, 11743, 103
41756, 11739, 11740, 11744, 11743
41757, 11740, 11741, 11745, 11744
41758, 11741, 11742, 11746, 11745
41759, 11742, 1817, 1818, 11746
41760, 103, 11743, 11747, 104
41761, 11743, 11744, 11748, 11747
41762, 11744, 11745, 11749, 11748
41763, 11745, 11746, 11750, 11749
41764, 11746, 1818, 1819, 11750
41765, 104, 11747, 11751, 105
41766, 11747, 11748, 11752, 11751
41767, 11748, 11749, 11753, 11752
41768, 11749, 11750, 11754, 11753
41769, 11750, 1819, 1820, 11754
41770, 105, 11751, 11755, 106
41771, 11751, 11752, 11756, 11755
41772, 11752, 11753, 11757, 11756
41773, 11753, 11754, 11758, 11757
41774, 11754, 1820, 1821, 11758
41775, 106, 11755, 11759, 107
41776, 11755, 11756, 11760, 11759
41777, 11756, 11757, 11761, 11760
41778, 11757, 11758, 11762, 11761
41779, 11758, 1821, 1822, 11762
41780, 107, 11759, 1785, 1
41781, 11759, 11760, 1786, 1785
41782, 11760, 11761, 1787, 1786
41783, 11761, 11762, 1788, 1787
41784, 11762, 1822, 88, 1788
*ELEMENT, type=CPS4, ELSET=Surface122
4656, 86, 1747, 11763, 1812
4657, 1812, 11763, 11764, 1813
4658, 1813, 11764, 11765, 1814
4659, 1814, 11765, 11766, 1815
4660, 1815, 11766, 11767, 1816
4661, 1816, 11767, 11768, 1817
4662, 1817, 11768, 11769, 1818
4663, 1818, 11769, 11770, 1819
4664, 1819, 11770, 11771, 1820
4665, 1820, 11771, 11772, 1821
4666, 1821, 11772, 11773, 1822
4667, 1822, 11773, 1789, 88
4668, 1747, 1748, 11774, 11763
4669, 11763, 11774, 11775, 11764
4670, 11764, 11775, 11776, 11765
4671, 11765, 11776, 11777, 11766
4672, 11766, 11777, 11778, 11767
4673, 11767, 11778, 11779, 11768
4674, 11768, 11779, 11780, 11769
4675, 11769, 11780, 11781, 11770
4676, 11770, 11781, 11782, 11771
4677, 11771, 11782, 11783, 11772
4678, 11772, 11783, 11784, 11773
4679, 11773, 11784, 1790, 1789
4680, 1748, 1749, 11785, 11774
4681, 11774, 11785, 11786, 11775
4682, 11775, 11786, 11787, 11776
4683, 11776, 11787, 11788, 11777
4684, 11777, 11788, 11789, 11778
4685, 11778, 11789, 11790, 11779
4686, 11779, 11790, 11791, 11780
4687, 11780, 11791, 11792, 11781
4688, 11781, 11792, 11793, 11782
4689, 11782, 11793, 11794, 11783
4690, 11783, 11794, 11795, 11784
4691, 11784, 11795, 1791, 1790
4692, 1749, 1750, 11796, 11785
4693, 11785, 11796, 11797, 11786
4694, 11786, 11797, 11798, 11787
4695, 11787, 11798, 11799, 11788
4696, 11788, 11799, 11800, 11789
4697, 11789, 11800, 11801, 11790
4698, 11790, 11801, 11802, 11791
4699, 11791, 11802, 11803, 11792
4700, 11792, 11803, 11804, 11793
4701, 11793, 11804, 11805, 11794
4702, 11794, 11805, 11806, 11795
4703, 11795, 11806, 1792, 1791
4704, 1750, 1751, 11807, 11796
4705, 11796, 11807, 11808, 11797
4706, 11797, 11808, 11809, 11798
4707, 11798, 11809, 11810, 11799
4708, 11799, 11810, 11811, 11800
4709, 11800, 11811, 11812, 11801
4710, 11801, 11812, 11813, 11802
4711, 11802, 11813, 11814, 11803
4712, 11803, 11814, 11815, 11804
4713, 11804, 11815, 11816, 11805
4714, 11805, 11816, 11817, 11806
4715, 11806, 11817, 1793, 1792
4716, 1751, 1752, 11818, 11807
4717, 11807, 11818, 11819, 11808
4718, 11808, 11819, 11820, 11809
4719, 11809, 11820, 11821, 11810
4720, 11810, 11821, 11822, 11811
4721, 11811, 11822, 11823, 11812
4722, 11812, 11823, 11824, 11813
4723, 11813, 11824, 11825, 11814
4724, 11814, 11825, 11826, 11815
4725, 11815, 11826, 11827, 11816
4726, 11816, 11827, 11828, 11817
4727, 11817, 11828, 1794, 1793
4728, 1752, 1753, 11829, 11818
4729, 11818, 11829, 11830, 11819
4730, 11819, 11830, 11831, 11820
4731, 11820, 11831, 11832, 11821
4732, 11821, 11832, 11833, 11822
4733, 11822, 11833, 11834, 11823
4734, 11823, 11834, 11835, 11824
4735, 11824, 11835, 11836, 11825
4736, 11825, 11836, 11837, 11826
4737, 11826, 11837, 11838, 11827
4738, 11827, 11838, 11839, 11828
4739, 11828, 11839, 1795, 1794
4740, 1753, 1754, 11840, 11829
4741, 11829, 11840, 11841, 11830
4742, 11830, 11841, 11842, 11831
4743, 11831, 11842, 11843, 11832
4744, 11832, 11843, 11844, 11833
4745, 11833, 11844, 11845, 11834
4746, 11834, 11845, 11846, 11835
4747, 11835, 11846, 11847, 11836
4748, 11836, 11847, 11848, 11837
4749, 11837, 11848, 11849, 11838
4750, 11838, 11849, 11850, 11839
4751, 11839, 11850, 1796, 1795
4752, 1754, 1755, 11851, 11840
4753, 11840, 11851, 11852, 11841
4754, 11841, 11852, 11853, 11842
4755, 11842, 11853, 11854, 11843
4756, 11843, 11854, 11855, 11844
4757, 11844, 11855, 11856, 11845
4758, 11845, 11856, 11857, 11846
4759, 11846, 11857, 11858, 11847
4760, 11847, 11858, 11859, 11848
4761, 11848, 11859, 11860, 11849
4762, 11849, 11860, 11861, 11850
4763, 11850, 11861, 1797, 1796
4764, 1755, 1756, 11862, 11851
4765, 11851, 11862, 11863, 11852
4766, 11852, 11863, 11864, 11853
4767, 11853, 11864, 11865, 11854
4768, 11854, 11865, 11866, 11855
4769, 11855, 11866, 11867, 11856
4770, 11856, 11867, 11868, 11857
4771, 11857, 11868, 11869, 11858
4772, 11858, 11869, 11870, 11859
4773, 11859, 11870, 11871, 11860
4774, 11860, 11871, 11872, 11861
4775, 11861, 11872, 1798, 1797
4776, 1756, 1757, 11873, 11862
4777, 11862, 11873, 11874, 11863
4778, 11863, 11874, 11875, 11864
4779, 11864, 11875, 11876, 11865
4780, 11865, 11876, 11877, 11866
4781, 11866, 11877, 11878, 11867
4782, 11867, 11878, 11879, 11868
4783, 11868, 11879, 11880, 11869
4784, 11869, 11880, 11881, 11870
4785, 11870, 11881, 11882, 11871
4786, 11871, 11882, 11883, 11872
4787, 11872, 11883, 1799, 1798
4788, 1757, 1758, 11884, 11873
4789, 11873, 11884, 11885, 11874
4790, 11874, 11885, 11886, 11875
4791, 11875, 11886, 11887, 11876
4792, 11876, 11887, 11888, 11877
4793, 11877, 11888, 11889, 11878
4794, 11878, 11889, 11890, 11879
4795, 11879, 11890, 11891, 11880
4796, 11880, 11891, 11892, 11881
4797, 11881, 11892, 11893, 11882
4798, 11882, 11893, 11894, 11883
4799, 11883, 11894, 1800, 1799
4800, 1758, 1759, 11895, 11884
4801, 11884, 11895, 11896, 11885
4802, 11885, 11896, 11897, 11886
4803, 11886, 11897, 11898, 11887
4804, 11887, 11898, 11899, 11888
4805, 11888, 11899, 11900, 11889
4806, 11889, 11900, 11901, 11890
4807, 11890, 11901, 11902, 11891
4808, 11891, 11902, 11903, 11892
4809, 11892, 11903, 11904, 11893
4810, 11893, 11904, 11905, 11894
4811, 11894, 11905, 1801, 1800
4812, 1759, 1760, 11906, 11895
4813, 11895, 11906, 11907, 11896
4814, 11896, 11907, 11908, 11897
4815, 11897, 11908, 11909, 11898
4816, 11898, 11909, 11910, 11899
4817, 11899, 11910, 11911, 11900
4818, 11900, 11911, 11912, 11901
4819, 11901, 11912, 11913, 11902
4820, 11902, 11913, 11914, 11903
4821, 11903, 11914, 11915, 11904
4822, 11904, 11915, 11916, 11905
4823, 11905, 11916, 1802, 1801
4824, 1760, 1761, 11917, 11906
4825, 11906, 11917, 11918, 11907
4826, 11907, 11918, 11919, 11908
4827, 11908, 11919, 11920, 11909
4828, 11909, 11920, 11921, 11910
4829, 11910, 11921, 11922, 11911
4830, 11911, 11922, 11923, 11912
4831, 11912, 11923, 11924, 11913
4832, 11913, 11924, 11925, 11914
4833, 11914, 11925, 11926, 11915
4834, 11915, 11926, 11927, 11916
4835, 11916, 11927, 1803, 1802
4836, 1761, 1762, 11928, 11917
4837, 11917, 11928, 11929, 11918
4838, 11918, 11929, 11930, 11919
4839, 11919, 11930, 11931, 11920
4840, 11920, 11931, 11932, 11921
4841, 11921, 11932, 11933, 11922
4842, 11922, 11933, 11934, 11923
4843, 11923, 11934, 11935, 11924
4844, 11924, 11935, 11936, 11925
4845, 11925, 11936, 11937, 11926
4846, 11926, 11937, 11938, 11927
4847, 11927, 11938, 1804, 1803
4848, 1762, 1763, 11939, 11928
4849, 11928, 11939, 11940, 11929
4850, 11929, 11940, 11941, 11930
4851, 11930, 11941, 11942, 11931
4852, 11931, 11942, 11943, 11932
4853, 11932, 11943, 11944, 11933
4854, 11933, 11944, 11945, 11934
4855, 11934, 11945, 11946, 11935
4856, 11935, 11946, 11947, 11936
4857, 11936, 11947, 11948, 11937
4858, 11937, 11948, 11949, 11938
4859, 11938, 11949, 1805, 1804
4860, 1763, 1764, 11950, 11939
4861, 11939, 11950, 11951, 11940
4862, 11940, 11951, 11952, 11941
4863, 11941, 11952, 11953, 11942
4864, 11942, 11953, 11954, 11943
4865, 11943, 11954, 11955, 11944
4866, 11944, 11955, 11956, 11945
4867, 11945, 11956, 11957, 11946
4868, 11946, 11957, 11958, 11947
4869, 11947, 11958, 11959, 11948
4870, 11948, 11959, 11960, 11949
4871, 11949, 11960, 1806, 1805
4872, 1764, 1765, 11961, 11950
4873, 11950, 11961, 11962, 11951
4874, 11951, 11962, 11963, 11952
4875, 11952, 11963, 11964, 11953
4876, 11953, 11964, 11965, 11954
4877, 11954, 11965, 11966, 11955
4878, 11955, 11966, 11967, 11956
4879, 11956, 11967, 11968, 11957
4880, 11957, 11968, 11969, 11958
4881, 11958, 11969, 11970, 11959
4882, 11959, 11970, 11971, 11960
4883, 11960, 11971, 1807, 1806
4884, 1765, 1766, 11972, 11961
4885, 11961, 11972, 11973, 11962
4886, 11962, 11973, 11974, 11963
4887, 11963, 11974, 11975, 11964
4888, 11964, 11975, 11976, 11965
4889, 11965, 11976, 11977, 11966
4890, 11966, 11977, 11978, 11967
4891, 11967, 11978, 11979, 11968
4892, 11968, 11979, 11980, 11969
4893, 11969, 11980, 11981, 11970
4894, 11970, 11981, 11982, 11971
4895, 11971, 11982, 1808, 1807
4896, 1766, 1767, 11983, 11972
4897, 11972, 11983, 11984, 11973
4898, 11973, 11984, 11985, 11974
4899, 11974, 11985, 11986, 11975
4900, 11975, 11986, 11987, 11976
4901, 11976, 11987, 11988, 11977
4902, 11977, 11988, 11989, 11978
4903, 11978, 11989, 11990, 11979
4904, 11979, 11990, 11991, 11980
4905, 11980, 11991, 11992, 11981
4906, 11981, 11992, 11993, 11982
4907, 11982, 11993, 1809, 1808
4908, 1767, 1768, 11994, 11983
4909, 11983, 11994, 11995, 11984
4910, 11984, 11995, 11996, 11985
4911, 11985, 11996, 11997, 11986
4912, 11986, 11997, 11998, 11987
4913, 11987, 11998, 11999, 11988
4914, 11988, 11999, 12000, 11989
4915, 11989, 12000, 12001, 11990
4916, 11990, 12001, 12002, 11991
4917, 11991, 12002, 12003, 11992
4918, 11992, 12003, 12004, 11993
4919, 11993, 12004, 1810, 1809
4920, 1768, 1769, 12005, 11994
4921, 11994, 12005, 12006, 11995
4922, 11995, 12006, 12007, 11996
4923, 11996, 12007, 12008, 11997
4924, 11997, 12008, 12009, 11998
4925, 11998, 12009, 12010, 11999
4926, 11999, 12010, 12011, 12000
4927, 12000, 12011, 12012, 12001
4928, 12001, 12012, 12013, 12002
4929, 12002, 12013, 12014, 12003
4930, 12003, 12014, 12015, 12004
4931, 12004, 12015, 1811, 1810
4932, 1769, 85, 1774, 12005
4933, 12005, 1774, 1775, 12006
4934, 12006, 1775, 1776, 12007
4935, 12007, 1776, 1777, 12008
4936, 12008, 1777, 1778, 12009
4937, 12009, 1778, 1779, 12010
4938, 12010, 1779, 1780, 12011
4939, 12011, 1780, 1781, 12012
4940, 12012, 1781, 1782, 12013
4941, 12013, 1782, 1783, 12014
4942, 12014, 1783, 1784, 12015
4943, 12015, 1784, 87, 1811
*ELEMENT, type=CPS4, ELSET=Surface123
4944, 1, 53, 1823, 1785
4945, 1785, 1823, 1824, 1786
4946, 1786, 1824, 1825, 1787
4947, 1787, 1825, 1826, 1788
4948, 1788, 1826, 89, 88
*ELEMENT, type=CPS4, ELSET=Surface124
41785, 2, 1743, 1827, 54
41786, 1743, 1744, 1828, 1827
41787, 1744, 1745, 1829, 1828
41788, 1745, 1746, 1830, 1829
41789, 1746, 86, 90, 1830
*ELEMENT, type=CPS4, ELSET=Surface125
41790, 54, 1827, 12016, 1171
41791, 1827, 1828, 12017, 12016
41792, 1828, 1829, 12018, 12017
41793, 1829, 1830, 12019, 12018
41794, 1830, 90, 1831, 12019
41795, 1171, 12016, 12020, 1172
41796, 12016, 12017, 12021, 12020
41797, 12017, 12018, 12022, 12021
41798, 12018, 12019, 12023, 12022
41799, 12019, 1831, 1832, 12023
41800, 1172, 12020, 12024, 1173
41801, 12020, 12021, 12025, 12024
41802, 12021, 12022, 12026, 12025
41803, 12022, 12023, 12027, 12026
41804, 12023, 1832, 1833, 12027
41805, 1173, 12024, 12028, 1174
41806, 12024, 12025, 12029, 12028
41807, 12025, 12026, 12030, 12029
41808, 12026, 12027, 12031, 12030
41809, 12027, 1833, 1834, 12031
