25201, 7335, 935, 936, 7336, 10344, 1450, 1451, 10345
25202, 7336, 936, 937, 7337, 10345, 1451, 1452, 10346
25203, 7337, 937, 938, 7338, 10346, 1452, 1453, 10347
25204, 7338, 938, 939, 7339, 10347, 1453, 1454, 10348
25205, 7339, 939, 940, 7340, 10348, 1454, 1455, 10349
25206, 7340, 940, 941, 7341, 10349, 1455, 1456, 10350
25207, 7341, 941, 942, 7342, 10350, 1456, 1457, 10351
25208, 7342, 942, 943, 7343, 10351, 1457, 1458, 10352
25209, 7343, 943, 944, 7344, 10352, 1458, 1459, 10353
25210, 7344, 944, 945, 7345, 10353, 1459, 1460, 10354
25211, 7345, 945, 946, 7346, 10354, 1460, 1461, 10355
25212, 7346, 946, 947, 7347, 10355, 1461, 1462, 10356
25213, 7347, 947, 948, 7348, 10356, 1462, 1463, 10357
25214, 7348, 948, 949, 7349, 10357, 1463, 1464, 10358
25215, 7349, 949, 950, 7350, 10358, 1464, 1465, 10359
25216, 7350, 950, 951, 7351, 10359, 1465, 1466, 10360
25217, 7351, 951, 952, 7352, 10360, 1466, 1467, 10361
25218, 7352, 952, 953, 7353, 10361, 1467, 1468, 10362
25219, 7353, 953, 954, 7354, 10362, 1468, 1469, 10363
25220, 7354, 954, 955, 7355, 10363, 1469, 1470, 10364
25221, 7355, 955, 40, 978, 10364, 1470, 72, 1516
*ELEMENT, type=C3D8, ELSET=Volume16
25222, 9, 309, 3369, 264, 59, 1220, 8801, 1243
25223, 309, 310, 3370, 3369, 1220, 1221, 8802, 8801
25224, 310, 311, 3371, 3370, 1221, 1222, 8803, 8802
25225, 311, 312, 3372, 3371, 1222, 1223, 8804, 8803
25226, 312, 313, 3373, 3372, 1223, 1224, 8805, 8804
25227, 313, 314, 3374, 3373, 1224, 1225, 8806, 8805
25228, 314, 315, 3375, 3374, 1225, 1226, 8807, 8806
25229, 315, 316, 3376, 3375, 1226, 1227, 8808, 8807
25230, 316, 317, 3377, 3376, 1227, 1228, 8809, 8808
25231, 317, 318, 3378, 3377, 1228, 1229, 8810, 8809
25232, 318, 319, 3379, 3378, 1229, 1230, 8811, 8810
25233, 319, 320, 3380, 3379, 1230, 1231, 8812, 8811
25234, 320, 321, 3381, 3380, 1231, 1232, 8813, 8812
25235, 321, 322, 3382, 3381, 1232, 1233, 8814, 8813
25236, 322, 323, 3383, 3382, 1233, 1234, 8815, 8814
25237, 323, 324, 3384, 3383, 1234, 1235, 8816, 8815
25238, 324, 325, 3385, 3384, 1235, 1236, 8817, 8816
25239, 325, 326, 3386, 3385, 1236, 1237, 8818, 8817
25240, 326, 327, 3387, 3386, 1237, 1238, 8819, 8818
25241, 327, 328, 3388, 3387, 1238, 1239, 8820, 8819
25242, 328, 329, 3389, 3388, 1239, 1240, 8821, 8820
25243, 329, 330, 3390, 3389, 1240, 1241, 8822, 8821
25244, 330, 331, 3391, 3390, 1241, 1242, 8823, 8822
25245, 331, 13, 401, 3391, 1242, 60, 1254, 8823
25246, 264, 3369, 3392, 265, 1243, 8801, 8824, 1244
25247, 3369, 3370, 3393, 3392, 8801, 8802, 8825, 8824
25248, 3370, 3371, 3394, 3393, 8802, 8803, 8826, 8825
25249, 3371, 3372, 3395, 3394, 8803, 8804, 8827, 8826
25250, 3372, 3373, 3396, 3395, 8804, 8805, 8828, 8827
25251, 3373, 3374, 3397, 3396, 8805, 8806, 8829, 8828
25252, 3374, 3375, 3398, 3397, 8806, 8807, 8830, 8829
25253, 3375, 3376, 3399, 3398, 8807, 8808, 8831, 8830
25254, 3376, 3377, 3400, 3399, 8808, 8809, 8832, 8831
25255, 3377, 3378, 3401, 3400, 8809, 8810, 8833, 8832
25256, 3378, 3379, 3402, 3401, 8810, 8811, 8834, 8833
25257, 3379, 3380, 3403, 3402, 8811, 8812, 8835, 8834
25258, 3380, 3381, 3404, 3403, 8812, 8813, 8836, 8835
25259, 3381, 3382, 3405, 3404, 8813, 8814, 8837, 8836
25260, 3382, 3383, 3406, 3405, 8814, 8815, 8838, 8837
25261, 3383, 3384, 3407, 3406, 8815, 8816, 8839, 8838
25262, 3384, 3385, 3408, 3407, 8816, 8817, 8840, 8839
25263, 3385, 3386, 3409, 3408, 8817, 8818, 8841, 8840
25264, 3386, 3387, 3410, 3409, 8818, 8819, 8842, 8841
25265, 3387, 3388, 3411, 3410, 8819, 8820, 8843, 8842
25266, 3388, 3389, 3412, 3411, 8820, 8821, 8844, 8843
25267, 3389, 3390, 3413, 3412, 8821, 8822, 8845, 8844
25268, 3390, 3391, 3414, 3413, 8822, 8823, 8846, 8845
25269, 3391, 401, 402, 3414, 8823, 1254, 1255, 8846
25270, 265, 3392, 3415, 266, 1244, 8824, 8847, 1245
25271, 3392, 3393, 3416, 3415, 8824, 8825, 8848, 8847
25272, 3393, 3394, 3417, 3416, 8825, 8826, 8849, 8848
25273, 3394, 3395, 3418, 3417, 8826, 8827, 8850, 8849
25274, 3395, 3396, 3419, 3418, 8827, 8828, 8851, 8850
25275, 3396, 3397, 3420, 3419, 8828, 8829, 8852, 8851
25276, 3397, 3398, 3421, 3420, 8829, 8830, 8853, 8852
25277, 3398, 3399, 3422, 3421, 8830, 8831, 8854, 8853
25278, 3399, 3400, 3423, 3422, 8831, 8832, 8855, 8854
25279, 3400, 3401, 3424, 3423, 8832, 8833, 8856, 8855
25280, 3401, 3402, 3425, 3424, 8833, 8834, 8857, 8856
25281, 3402, 3403, 3426, 3425, 8834, 8835, 8858, 8857
25282, 3403, 3404, 3427, 3426, 8835, 8836, 8859, 8858
25283, 3404, 3405, 3428, 3427, 8836, 8837, 8860, 8859
25284, 3405, 3406, 3429, 3428, 8837, 8838, 8861, 8860
25285, 3406, 3407, 3430, 3429, 8838, 8839, 8862, 8861
25286, 3407, 3408, 3431, 3430, 8839, 8840, 8863, 8862
25287, 3408, 3409, 3432, 3431, 8840, 8841, 8864, 8863
25288, 3409, 3410, 3433, 3432, 8841, 8842, 8865, 8864
25289, 3410, 3411, 3434, 3433, 8842, 8843, 8866, 8865
25290, 3411, 3412, 3435, 3434, 8843, 8844, 8867, 8866
25291, 3412, 3413, 3436, 3435, 8844, 8845, 8868, 8867
25292, 3413, 3414, 3437, 3436, 8845, 8846, 8869, 8868
25293, 3414, 402, 403, 3437, 8846, 1255, 1256, 8869
25294, 266, 3415, 3438, 267, 1245, 8847, 8870, 1246
25295, 3415, 3416, 3439, 3438, 8847, 8848, 8871, 8870
25296, 3416, 3417, 3440, 3439, 8848, 8849, 8872, 8871
25297, 3417, 3418, 3441, 3440, 8849, 8850, 8873, 8872
25298, 3418, 3419, 3442, 3441, 8850, 8851, 8874, 8873
25299, 3419, 3420, 3443, 3442, 8851, 8852, 8875, 8874
25300, 3420, 3421, 3444, 3443, 8852, 8853, 8876, 8875
25301, 3421, 3422, 3445, 3444, 8853, 8854, 8877, 8876
25302, 3422, 3423, 3446, 3445, 8854, 8855, 8878, 8877
25303, 3423, 3424, 3447, 3446, 8855, 8856, 8879, 8878
25304, 3424, 3425, 3448, 3447, 8856, 8857, 8880, 8879
25305, 3425, 3426, 3449, 3448, 8857, 8858, 8881, 8880
25306, 3426, 3427, 3450, 3449, 8858, 8859, 8882, 8881
25307, 3427, 3428, 3451, 3450, 8859, 8860, 8883, 8882
25308, 3428, 3429, 3452, 3451, 8860, 8861, 8884, 8883
25309, 3429, 3430, 3453, 3452, 8861, 8862, 8885, 8884
25310, 3430, 3431, 3454, 3453, 8862, 8863, 8886, 8885
25311, 3431, 3432, 3455, 3454, 8863, 8864, 8887, 8886
25312, 3432, 3433, 3456, 3455, 8864, 8865, 8888, 8887
25313, 3433, 3434, 3457, 3456, 8865, 8866, 8889, 8888
25314, 3434, 3435, 3458, 3457, 8866, 8867, 8890, 8889
25315, 3435, 3436, 3459, 3458, 8867, 8868, 8891, 8890
25316, 3436, 3437, 3460, 3459, 8868, 8869, 8892, 8891
25317, 3437, 403, 404, 3460, 8869, 1256, 1257, 8892
25318, 267, 3438, 3461, 268, 1246, 8870, 8893, 1247
25319, 3438, 3439, 3462, 3461, 8870, 8871, 8894, 8893
25320, 3439, 3440, 3463, 3462, 8871, 8872, 8895, 8894
25321, 3440, 3441, 3464, 3463, 8872, 8873, 8896, 8895
25322, 3441, 3442, 3465, 3464, 8873, 8874, 8897, 8896
25323, 3442, 3443, 3466, 3465, 8874, 8875, 8898, 8897
25324, 3443, 3444, 3467, 3466, 8875, 8876, 8899, 8898
25325, 3444, 3445, 3468, 3467, 8876, 8877, 8900, 8899
25326, 3445, 3446, 3469, 3468, 8877, 8878, 8901, 8900
25327, 3446, 3447, 3470, 3469, 8878, 8879, 8902, 8901
25328, 3447, 3448, 3471, 3470, 8879, 8880, 8903, 8902
25329, 3448, 3449, 3472, 3471, 8880, 8881, 8904, 8903
25330, 3449, 3450, 3473, 3472, 8881, 8882, 8905, 8904
25331, 3450, 3451, 3474, 3473, 8882, 8883, 8906, 8905
25332, 3451, 3452, 3475, 3474, 8883, 8884, 8907, 8906
25333, 3452, 3453, 3476, 3475, 8884, 8885, 8908, 8907
25334, 3453, 3454, 3477, 3476, 8885, 8886, 8909, 8908
25335, 3454, 3455, 3478, 3477, 8886, 8887, 8910, 8909
25336, 3455, 3456, 3479, 3478, 8887, 8888, 8911, 8910
25337, 3456, 3457, 3480, 3479, 8888, 8889, 8912, 8911
25338, 3457, 3458, 3481, 3480, 8889, 8890, 8913, 8912
25339, 3458, 3459, 3482, 3481, 8890, 8891, 8914, 8913
25340, 3459, 3460, 3483, 3482, 8891, 8892, 8915, 8914
25341, 3460, 404, 405, 3483, 8892, 1257, 1258, 8915
25342, 268, 3461, 3484, 269, 1247, 8893, 8916, 1248
25343, 3461, 3462, 3485, 3484, 8893, 8894, 8917, 8916
25344, 3462, 3463, 3486, 3485, 8894, 8895, 8918, 8917
25345, 3463, 3464, 3487, 3486, 8895, 8896, 8919, 8918
25346, 3464, 3465, 3488, 3487, 8896, 8897, 8920, 8919
25347, 3465, 3466, 3489, 3488, 8897, 8898, 8921, 8920
25348, 3466, 3467, 3490, 3489, 8898, 8899, 8922, 8921
25349, 3467, 3468, 3491, 3490, 8899, 8900, 8923, 8922
25350, 3468, 3469, 3492, 3491, 8900, 8901, 8924, 8923
25351, 3469, 3470, 3493, 3492, 8901, 8902, 8925, 8924
25352, 3470, 3471, 3494, 3493, 8902, 8903, 8926, 8925
25353, 3471, 3472, 3495, 3494, 8903, 8904, 8927, 8926
25354, 3472, 3473, 3496, 3495, 8904, 8905, 8928, 8927
25355, 3473, 3474, 3497, 3496, 8905, 8906, 8929, 8928
25356, 3474, 3475, 3498, 3497, 8906, 8907, 8930, 8929
25357, 3475, 3476, 3499, 3498, 8907, 8908, 8931, 8930
25358, 3476, 3477, 3500, 3499, 8908, 8909, 8932, 8931
25359, 3477, 3478, 3501, 3500, 8909, 8910, 8933, 8932
25360, 3478, 3479, 3502, 3501, 8910, 8911, 8934, 8933
25361, 3479, 3480, 3503, 3502, 8911, 8912, 8935, 8934
25362, 3480, 3481, 3504, 3503, 8912, 8913, 8936, 8935
25363, 3481, 3482, 3505, 3504, 8913, 8914, 8937, 8936
25364, 3482, 3483, 3506, 3505, 8914, 8915, 8938, 8937
25365, 3483, 405, 406, 3506, 8915, 1258, 1259, 8938
25366, 269, 3484, 3507, 270, 1248, 8916, 8939, 1249
25367, 3484, 3485, 3508, 3507, 8916, 8917, 8940, 8939
25368, 3485, 3486, 3509, 3508, 8917, 8918, 8941, 8940
25369, 3486, 3487, 3510, 3509, 8918, 8919, 8942, 8941
25370, 3487, 3488, 3511, 3510, 8919, 8920, 8943, 8942
25371, 3488, 3489, 3512, 3511, 8920, 8921, 8944, 8943
25372, 3489, 3490, 3513, 3512, 8921, 8922, 8945, 8944
25373, 3490, 3491, 3514, 3513, 8922, 8923, 8946, 8945
25374, 3491, 3492, 3515, 3514, 8923, 8924, 8947, 8946
25375, 3492, 3493, 3516, 3515, 8924, 8925, 8948, 8947
25376, 3493, 3494, 3517, 3516, 8925, 8926, 8949, 8948
25377, 3494, 3495, 3518, 3517, 8926, 8927, 8950, 8949
25378, 3495, 3496, 3519, 3518, 8927, 8928, 8951, 8950
25379, 3496, 3497, 3520, 3519, 8928, 8929, 8952, 8951
25380, 3497, 3498, 3521, 3520, 8929, 8930, 8953, 8952
25381, 3498, 3499, 3522, 3521, 8930, 8931, 8954, 8953
25382, 3499, 3500, 3523, 3522, 8931, 8932, 8955, 8954
25383, 3500, 3501, 3524, 3523, 8932, 8933, 8956, 8955
25384, 3501, 3502, 3525, 3524, 8933, 8934, 8957, 8956
25385, 3502, 3503, 3526, 3525, 8934, 8935, 8958, 8957
25386, 3503, 3504, 3527, 3526, 8935, 8936, 8959, 8958
25387, 3504, 3505, 3528, 3527, 8936, 8937, 8960, 8959
25388, 3505, 3506, 3529, 3528, 8937, 8938, 8961, 8960
25389, 3506, 406, 407, 3529, 8938, 1259, 1260, 8961
25390, 270, 3507, 3530, 271, 1249, 8939, 8962, 1250
25391, 3507, 3508, 3531, 3530, 8939, 8940, 8963, 8962
25392, 3508, 3509, 3532, 3531, 8940, 8941, 8964, 8963
25393, 3509, 3510, 3533, 3532, 8941, 8942, 8965, 8964
25394, 3510, 3511, 3534, 3533, 8942, 8943, 8966, 8965
25395, 3511, 3512, 3535, 3534, 8943, 8944, 8967, 8966
25396, 3512, 3513, 3536, 3535, 8944, 8945, 8968, 8967
25397, 3513, 3514, 3537, 3536, 8945, 8946, 8969, 8968
25398, 3514, 3515, 3538, 3537, 8946, 8947, 8970, 8969
25399, 3515, 3516, 3539, 3538, 8947, 8948, 8971, 8970
25400, 3516, 3517, 3540, 3539, 8948, 8949, 8972, 8971
25401, 3517, 3518, 3541, 3540, 8949, 8950, 8973, 8972
25402, 3518, 3519, 3542, 3541, 8950, 8951, 8974, 8973
25403, 3519, 3520, 3543, 3542, 8951, 8952, 8975, 8974
25404, 3520, 3521, 3544, 3543, 8952, 8953, 8976, 8975
25405, 3521, 3522, 3545, 3544, 8953, 8954, 8977, 8976
25406, 3522, 3523, 3546, 3545, 8954, 8955, 8978, 8977
25407, 3523, 3524, 3547, 3546, 8955, 8956, 8979, 8978
25408, 3524, 3525, 3548, 3547, 8956, 8957, 8980, 8979
25409, 3525, 3526, 3549, 3548, 8957, 8958, 8981, 8980
25410, 3526, 3527, 3550, 3549, 8958, 8959, 8982, 8981
25411, 3527, 3528, 3551, 3550, 8959, 8960, 8983, 8982
25412, 3528, 3529, 3552, 3551, 8960, 8961, 8984, 8983
25413, 3529, 407, 408, 3552, 8961, 1260, 1261, 8984
25414, 271, 3530, 3553, 272, 1250, 8962, 8985, 1251
25415, 3530, 3531, 3554, 3553, 8962, 8963, 8986, 8985
25416, 3531, 3532, 3555, 3554, 8963, 8964, 8987, 8986
25417, 3532, 3533, 3556, 3555, 8964, 8965, 8988, 8987
25418, 3533, 3534, 3557, 3556, 8965, 8966, 8989, 8988
25419, 3534, 3535, 3558, 3557, 8966, 8967, 8990, 8989
25420, 3535, 3536, 3559, 3558, 8967, 8968, 8991, 8990
25421, 3536, 3537, 3560, 3559, 8968, 8969, 8992, 8991
25422, 3537, 3538, 3561, 3560, 8969, 8970, 8993, 8992
25423, 3538, 3539, 3562, 3561, 8970, 8971, 8994, 8993
25424, 3539, 3540, 3563, 3562, 8971, 8972, 8995, 8994
25425, 3540, 3541, 3564, 3563, 8972, 8973, 8996, 8995
25426, 3541, 3542, 3565, 3564, 8973, 8974, 8997, 8996
25427, 3542, 3543, 3566, 3565, 8974, 8975, 8998, 8997
25428, 3543, 3544, 3567, 3566, 8975, 8976, 8999, 8998
25429, 3544, 3545, 3568, 3567, 8976, 8977, 9000, 8999
25430, 3545, 3546, 3569, 3568, 8977, 8978, 9001, 9000
25431, 3546, 3547, 3570, 3569, 8978, 8979, 9002, 9001
25432, 3547, 3548, 3571, 3570, 8979, 8980, 9003, 9002
25433, 3548, 3549, 3572, 3571, 8980, 8981, 9004, 9003
25434, 3549, 3550, 3573, 3572, 8981, 8982, 9005, 9004
25435, 3550, 3551, 3574, 3573, 8982, 8983, 9006, 9005
25436, 3551, 3552, 3575, 3574, 8983, 8984, 9007, 9006
25437, 3552, 408, 409, 3575, 8984, 1261, 1262, 9007
25438, 272, 3553, 3576, 273, 1251, 8985, 9008, 1252
25439, 3553, 3554, 3577, 3576, 8985, 8986, 9009, 9008
25440, 3554, 3555, 3578, 3577, 8986, 8987, 9010, 9009
25441, 3555, 3556, 3579, 3578, 8987, 8988, 9011, 9010
25442, 3556, 3557, 3580, 3579, 8988, 8989, 9012, 9011
25443, 3557, 3558, 3581, 3580, 8989, 8990, 9013, 9012
25444, 3558, 3559, 3582, 3581, 8990, 8991, 9014, 9013
25445, 3559, 3560, 3583, 3582, 8991, 8992, 9015, 9014
25446, 3560, 3561, 3584, 3583, 8992, 8993, 9016, 9015
25447, 3561, 3562, 3585, 3584, 8993, 8994, 9017, 9016
25448, 3562, 3563, 3586, 3585, 8994, 8995, 9018, 9017
25449, 3563, 3564, 3587, 3586, 8995, 8996, 9019, 9018
25450, 3564, 3565, 3588, 3587, 8996, 8997, 9020, 9019
25451, 3565, 3566, 3589, 3588, 8997, 8998, 9021, 9020
25452, 3566, 3567, 3590, 3589, 8998, 8999, 9022, 9021
25453, 3567, 3568, 3591, 3590, 8999, 9000, 9023, 9022
25454, 3568, 3569, 3592, 3591, 9000, 9001, 9024, 9023
25455, 3569, 3570, 3593, 3592, 9001, 9002, 9025, 9024
25456, 3570, 3571, 3594, 3593, 9002, 9003, 9026, 9025
25457, 3571, 3572, 3595, 3594, 9003, 9004, 9027, 9026
25458, 3572, 3573, 3596, 3595, 9004, 9005, 9028, 9027
25459, 3573, 3574, 3597, 3596, 9005, 9006, 9029, 9028
25460, 3574, 3575, 3598, 3597, 9006, 9007, 9030, 9029
25461, 3575, 409, 410, 3598, 9007, 1262, 1263, 9030
25462, 273, 3576, 3599, 274, 1252, 9008, 9031, 1253
25463, 3576, 3577, 3600, 3599, 9008, 9009, 9032, 9031
25464, 3577, 3578, 3601, 3600, 9009, 9010, 9033, 9032
25465, 3578, 3579, 3602, 3601, 9010, 9011, 9034, 9033
25466, 3579, 3580, 3603, 3602, 9011, 9012, 9035, 9034
25467, 3580, 3581, 3604, 3603, 9012, 9013, 9036, 9035
25468, 3581, 3582, 3605, 3604, 9013, 9014, 9037, 9036
25469, 3582, 3583, 3606, 3605, 9014, 9015, 9038, 9037
25470, 3583, 3584, 3607, 3606, 9015, 9016, 9039, 9038
25471, 3584, 3585, 3608, 3607, 9016, 9017, 9040, 9039
25472, 3585, 3586, 3609, 3608, 9017, 9018, 9041, 9040
25473, 3586, 3587, 3610, 3609, 9018, 9019, 9042, 9041
25474, 3587, 3588, 3611, 3610, 9019, 9020, 9043, 9042
25475, 3588, 3589, 3612, 3611, 9020, 9021, 9044, 9043
25476, 3589, 3590, 3613, 3612, 9021, 9022, 9045, 9044
25477, 3590, 3591, 3614, 3613, 9022, 9023, 9046, 9045
25478, 3591, 3592, 3615, 3614, 9023, 9024, 9047, 9046
25479, 3592, 3593, 3616, 3615, 9024, 9025, 9048, 9047
25480, 3593, 3594, 3617, 3616, 9025, 9026, 9049, 9048
25481, 3594, 3595, 3618, 3617, 9026, 9027, 9050, 9049
25482, 3595, 3596, 3619, 3618, 9027, 9028, 9051, 9050
25483, 3596, 3597, 3620, 3619, 9028, 9029, 9052, 9051
25484, 3597, 3598, 3621, 3620, 9029, 9030, 9053, 9052
25485, 3598, 410, 411, 3621, 9030, 1263, 1264, 9053
25486, 274, 3599, 378, 11, 1253, 9031, 1197, 57
25487, 3599, 3600, 379, 378, 9031, 9032, 1198, 1197
25488, 3600, 3601, 380, 379, 9032, 9033, 1199, 1198
25489, 3601, 3602, 381, 380, 9033, 9034, 1200, 1199
25490, 3602, 3603, 382, 381, 9034, 9035, 1201, 1200
25491, 3603, 3604, 383, 382, 9035, 9036, 1202, 1201
25492, 3604, 3605, 384, 383, 9036, 9037, 1203, 1202
25493, 3605, 3606, 385, 384, 9037, 9038, 1204, 1203
25494, 3606, 3607, 386, 385, 9038, 9039, 1205, 1204
25495, 3607, 3608, 387, 386, 9039, 9040, 1206, 1205
25496, 3608, 3609, 388, 387, 9040, 9041, 1207, 1206
25497, 3609, 3610, 389, 388, 9041, 9042, 1208, 1207
25498, 3610, 3611, 390, 389, 9042, 9043, 1209, 1208
25499, 3611, 3612, 391, 390, 9043, 9044, 1210, 1209
25500, 3612, 3613, 392, 391, 9044, 9045, 1211, 1210
25501, 3613, 3614, 393, 392, 9045, 9046, 1212, 1211
25502, 3614, 3615, 394, 393, 9046, 9047, 1213, 1212
25503, 3615, 3616, 395, 394, 9047, 9048, 1214, 1213
25504, 3616, 3617, 396, 395, 9048, 9049, 1215, 1214
25505, 3617, 3618, 397, 396, 9049, 9050, 1216, 1215
25506, 3618, 3619, 398, 397, 9050, 9051, 1217, 1216
25507, 3619, 3620, 399, 398, 9051, 9052, 1218, 1217
25508, 3620, 3621, 400, 399, 9052, 9053, 1219, 1218
25509, 3621, 411, 15, 400, 9053, 1264, 58, 1219
*ELEMENT, type=C3D8, ELSET=Volume17
25510, 35, 910, 7356, 819, 63, 1288, 9054, 1311
25511, 910, 911, 7357, 7356, 1288, 1289, 9055, 9054
25512, 911, 912, 7358, 7357, 1289, 1290, 9056, 9055
25513, 912, 913, 7359, 7358, 1290, 1291, 9057, 9056
25514, 913, 914, 7360, 7359, 1291, 1292, 9058, 9057
25515, 914, 915, 7361, 7360, 1292, 1293, 9059, 9058
25516, 915, 916, 7362, 7361, 1293, 1294, 9060, 9059
25517, 916, 917, 7363, 7362, 1294, 1295, 9061, 9060
25518, 917, 918, 7364, 7363, 1295, 1296, 9062, 9061
25519, 918, 919, 7365, 7364, 1296, 1297, 9063, 9062
25520, 919, 920, 7366, 7365, 1297, 1298, 9064, 9063
25521, 920, 921, 7367, 7366, 1298, 1299, 9065, 9064
25522, 921, 922, 7368, 7367, 1299, 1300, 9066, 9065
25523, 922, 923, 7369, 7368, 1300, 1301, 9067, 9066
25524, 923, 924, 7370, 7369, 1301, 1302, 9068, 9067
25525, 924, 925, 7371, 7370, 1302, 1303, 9069, 9068
25526, 925, 926, 7372, 7371, 1303, 1304, 9070, 9069
25527, 926, 927, 7373, 7372, 1304, 1305, 9071, 9070
25528, 927, 928, 7374, 7373, 1305, 1306, 9072, 9071
25529, 928, 929, 7375, 7374, 1306, 1307, 9073, 9072
25530, 929, 930, 7376, 7375, 1307, 1308, 9074, 9073
25531, 930, 931, 7377, 7376, 1308, 1309, 9075, 9074
25532, 931, 932, 7378, 7377, 1309, 1310, 9076, 9075
25533, 932, 39, 979, 7378, 1310, 64, 1322, 9076
25534, 819, 7356, 7379, 820, 1311, 9054, 9077, 1312
25535, 7356, 7357, 7380, 7379, 9054, 9055, 9078, 9077
25536, 7357, 7358, 7381, 7380, 9055, 9056, 9079, 9078
25537, 7358, 7359, 7382, 7381, 9056, 9057, 9080, 9079
25538, 7359, 7360, 7383, 7382, 9057, 9058, 9081, 9080
25539, 7360, 7361, 7384, 7383, 9058, 9059, 9082, 9081
25540, 7361, 7362, 7385, 7384, 9059, 9060, 9083, 9082
25541, 7362, 7363, 7386, 7385, 9060, 9061, 9084, 9083
25542, 7363, 7364, 7387, 7386, 9061, 9062, 9085, 9084
25543, 7364, 7365, 7388, 7387, 9062, 9063, 9086, 9085
25544, 7365, 7366, 7389, 7388, 9063, 9064, 9087, 9086
25545, 7366, 7367, 7390, 7389, 9064, 9065, 9088, 9087
25546, 7367, 7368, 7391, 7390, 9065, 9066, 9089, 9088
25547, 7368, 7369, 7392, 7391, 9066, 9067, 9090, 9089
25548, 7369, 7370, 7393, 7392, 9067, 9068, 9091, 9090
25549, 7370, 7371, 7394, 7393, 9068, 9069, 9092, 9091
25550, 7371, 7372, 7395, 7394, 9069, 9070, 9093, 9092
25551, 7372, 7373, 7396, 7395, 9070, 9071, 9094, 9093
25552, 7373, 7374, 7397, 7396, 9071, 9072, 9095, 9094
25553, 7374, 7375, 7398, 7397, 9072, 9073, 9096, 9095
25554, 7375, 7376, 7399, 7398, 9073, 9074, 9097, 9096
25555, 7376, 7377, 7400, 7399, 9074, 9075, 9098, 9097
25556, 7377, 7378, 7401, 7400, 9075, 9076, 9099, 9098
25557, 7378, 979, 980, 7401, 9076, 1322, 1323, 9099
25558, 820, 7379, 7402, 821, 1312, 9077, 9100, 1313
25559, 7379, 7380, 7403, 7402, 9077, 9078, 9101, 9100
25560, 7380, 7381, 7404, 7403, 9078, 9079, 9102, 9101
25561, 7381, 7382, 7405, 7404, 9079, 9080, 9103, 9102
25562, 7382, 7383, 7406, 7405, 9080, 9081, 9104, 9103
25563, 7383, 7384, 7407, 7406, 9081, 9082, 9105, 9104
25564, 7384, 7385, 7408, 7407, 9082, 9083, 9106, 9105
25565, 7385, 7386, 7409, 7408, 9083, 9084, 9107, 9106
25566, 7386, 7387, 7410, 7409, 9084, 9085, 9108, 9107
25567, 7387, 7388, 7411, 7410, 9085, 9086, 9109, 9108
25568, 7388, 7389, 7412, 7411, 9086, 9087, 9110, 9109
25569, 7389, 7390, 7413, 7412, 9087, 9088, 9111, 9110
25570, 7390, 7391, 7414, 7413, 9088, 9089, 9112, 9111
25571, 7391, 7392, 7415, 7414, 9089, 9090, 9113, 9112
25572, 7392, 7393, 7416, 7415, 9090, 9091, 9114, 9113
25573, 7393, 7394, 7417, 7416, 9091, 9092, 9115, 9114
25574, 7394, 7395, 7418, 7417, 9092, 9093, 9116, 9115
25575, 7395, 7396, 7419, 7418, 9093, 9094, 9117, 9116
25576, 7396, 7397, 7420, 7419, 9094, 9095, 9118, 9117
25577, 7397, 7398, 7421, 7420, 9095, 9096, 9119, 9118
25578, 7398, 7399, 7422, 7421, 9096, 9097, 9120, 9119
25579, 7399, 7400, 7423, 7422, 9097, 9098, 9121, 9120
25580, 7400, 7401, 7424, 7423, 9098, 9099, 9122, 9121
25581, 7401, 980, 981, 7424, 9099, 1323, 1324, 9122
25582, 821, 7402, 7425, 822, 1313, 9100, 9123, 1314
25583, 7402, 7403, 7426, 7425, 9100, 9101, 9124, 9123
25584, 7403, 7404, 7427, 7426, 9101, 9102, 9125, 9124
25585, 7404, 7405, 7428, 7427, 9102, 9103, 9126, 9125
25586, 7405, 7406, 7429, 7428, 9103, 9104, 9127, 9126
25587, 7406, 7407, 7430, 7429, 9104, 9105, 9128, 9127
25588, 7407, 7408, 7431, 7430, 9105, 9106, 9129, 9128
25589, 7408, 7409, 7432, 7431, 9106, 9107, 9130, 9129
25590, 7409, 7410, 7433, 7432, 9107, 9108, 9131, 9130
25591, 7410, 7411, 7434, 7433, 9108, 9109, 9132, 9131
25592, 7411, 7412, 7435, 7434, 9109, 9110, 9133, 9132
25593, 7412, 7413, 7436, 7435, 9110, 9111, 9134, 9133
25594, 7413, 7414, 7437, 7436, 9111, 9112, 9135, 9134
25595, 7414, 7415, 7438, 7437, 9112, 9113, 9136, 9135
25596, 7415, 7416, 7439, 7438, 9113, 9114, 9137, 9136
25597, 7416, 7417, 7440, 7439, 9114, 9115, 9138, 9137
25598, 7417, 7418, 7441, 7440, 9115, 9116, 9139, 9138
25599, 7418, 7419, 7442, 7441, 9116, 9117, 9140, 9139
25600, 7419, 7420, 7443, 7442, 9117, 9118, 9141, 9140
25601, 7420, 7421, 7444, 7443, 9118, 9119, 9142, 9141
25602, 7421, 7422, 7445, 7444, 9119, 9120, 9143, 9142
25603, 7422, 7423, 7446, 7445, 9120, 9121, 9144, 9143
25604, 7423, 7424, 7447, 7446, 9121, 9122, 9145, 9144
25605, 7424, 981, 982, 7447, 9122, 1324, 1325, 9145
25606, 822, 7425, 7448, 823, 1314, 9123, 9146, 1315
25607, 7425, 7426, 7449, 7448, 9123, 9124, 9147, 9146
25608, 7426, 7427, 7450, 7449, 9124, 9125, 9148, 9147
25609, 7427, 7428, 7451, 7450, 9125, 9126, 9149, 9148
25610, 7428, 7429, 7452, 7451, 9126, 9127, 9150, 9149
25611, 7429, 7430, 7453, 7452, 9127, 9128, 9151, 9150
25612, 7430, 7431, 7454, 7453, 9128, 9129, 9152, 9151
25613, 7431, 7432, 7455, 7454, 9129, 9130, 9153, 9152
25614, 7432, 7433, 7456, 7455, 9130, 9131, 9154, 9153
25615, 7433, 7434, 7457, 7456, 9131, 9132, 9155, 9154
25616, 7434, 7435, 7458, 7457, 9132, 9133, 9156, 9155
25617, 7435, 7436, 7459, 7458, 9133, 9134, 9157, 9156
25618, 7436, 7437, 7460, 7459, 9134, 9135, 9158, 9157
25619, 7437, 7438, 7461, 7460, 9135, 9136, 9159, 9158
25620, 7438, 7439, 7462, 7461, 9136, 9137, 9160, 9159
25621, 7439, 7440, 7463, 7462, 9137, 9138, 9161, 9160
25622, 7440, 7441, 7464, 7463, 9138, 9139, 9162, 9161
25623, 7441, 7442, 7465, 7464, 9139, 9140, 9163, 9162
25624, 7442, 7443, 7466, 7465, 9140, 9141, 9164, 9163
25625, 7443, 7444, 7467, 7466, 9141, 9142, 9165, 9164
25626, 7444, 7445, 7468, 7467, 9142, 9143, 9166, 9165
25627, 7445, 7446, 7469, 7468, 9143, 9144, 9167, 9166
25628, 7446, 7447, 7470, 7469, 9144, 9145, 9168, 9167
25629, 7447, 982, 983, 7470, 9145, 1325, 1326, 9168
25630, 823, 7448, 7471, 824, 1315, 9146, 9169, 1316
25631, 7448, 7449, 7472, 7471, 9146, 9147, 9170, 9169
25632, 7449, 7450, 7473, 7472, 9147, 9148, 9171, 9170
25633, 7450, 7451, 7474, 7473, 9148, 9149, 9172, 9171
25634, 7451, 7452, 7475, 7474, 9149, 9150, 9173, 9172
25635, 7452, 7453, 7476, 7475, 9150, 9151, 9174, 9173
25636, 7453, 7454, 7477, 7476, 9151, 9152, 9175, 9174
25637, 7454, 7455, 7478, 7477, 9152, 9153, 9176, 9175
25638, 7455, 7456, 7479, 7478, 9153, 9154, 9177, 9176
25639, 7456, 7457, 7480, 7479, 9154, 9155, 9178, 9177
25640, 7457, 7458, 7481, 7480, 9155, 9156, 9179, 9178
25641, 7458, 7459, 7482, 7481, 9156, 9157, 9180, 9179
25642, 7459, 7460, 7483, 7482, 9157, 9158, 9181, 9180
25643, 7460, 7461, 7484, 7483, 9158, 9159, 9182, 9181
25644, 7461, 7462, 7485, 7484, 9159, 9160, 9183, 9182
25645, 7462, 7463, 7486, 7485, 9160, 9161, 9184, 9183
25646, 7463, 7464, 7487, 7486, 9161, 9162, 9185, 9184
25647, 7464, 7465, 7488, 7487, 9162, 9163, 9186, 9185
25648, 7465, 7466, 7489, 7488, 9163, 9164, 9187, 9186
25649, 7466, 7467, 7490, 7489, 9164, 9165, 9188, 9187
25650, 7467, 7468, 7491, 7490, 9165, 9166, 9189, 9188
25651, 7468, 7469, 7492, 7491, 9166, 9167, 9190, 9189
25652, 7469, 7470, 7493, 7492, 9167, 9168, 9191, 9190
25653, 7470, 983, 984, 7493, 9168, 1326, 1327, 9191
25654, 824, 7471, 7494, 825, 1316, 9169, 9192, 1317
25655, 7471, 7472, 7495, 7494, 9169, 9170, 9193, 9192
25656, 7472, 7473, 7496, 7495, 9170, 9171, 9194, 9193
25657, 7473, 7474, 7497, 7496, 9171, 9172, 9195, 9194
25658, 7474, 7475, 7498, 7497, 9172, 9173, 9196, 9195
25659, 7475, 7476, 7499, 7498, 9173, 9174, 9197, 9196
25660, 7476, 7477, 7500, 7499, 9174, 9175, 9198, 9197
25661, 7477, 7478, 7501, 7500, 9175, 9176, 9199, 9198
25662, 7478, 7479, 7502, 7501, 9176, 9177, 9200, 9199
25663, 7479, 7480, 7503, 7502, 9177, 9178, 9201, 9200
25664, 7480, 7481, 7504, 7503, 9178, 9179, 9202, 9201
25665, 7481, 7482, 7505, 7504, 9179, 9180, 9203, 9202
25666, 7482, 7483, 7506, 7505, 9180, 9181, 9204, 9203
25667, 7483, 7484, 7507, 7506, 9181, 9182, 9205, 9204
25668, 7484, 7485, 7508, 7507, 9182, 9183, 9206, 9205
25669, 7485, 7486, 7509, 7508, 9183, 9184, 9207, 9206
25670, 7486, 7487, 7510, 7509, 9184, 9185, 9208, 9207
25671, 7487, 7488, 7511, 7510, 9185, 9186, 9209, 9208
25672, 7488, 7489, 7512, 7511, 9186, 9187, 9210, 9209
25673, 7489, 7490, 7513, 7512, 9187, 9188, 9211, 9210
25674, 7490, 7491, 7514, 7513, 9188, 9189, 9212, 9211
25675, 7491, 7492, 7515, 7514, 9189, 9190, 9213, 9212
25676, 7492, 7493, 7516, 7515, 9190, 9191, 9214, 9213
25677, 7493, 984, 985, 7516, 9191, 1327, 1328, 9214
25678, 825, 7494, 7517, 826, 1317, 9192, 9215, 1318
25679, 7494, 7495, 7518, 7517, 9192, 9193, 9216, 9215
25680, 7495, 7496, 7519, 7518, 9193, 9194, 9217, 9216
25681, 7496, 7497, 7520, 7519, 9194, 9195, 9218, 9217
25682, 7497, 7498, 7521, 7520, 9195, 9196, 9219, 9218
25683, 7498, 7499, 7522, 7521, 9196, 9197, 9220, 9219
25684, 7499, 7500, 7523, 7522, 9197, 9198, 9221, 9220
25685, 7500, 7501, 7524, 7523, 9198, 9199, 9222, 9221
25686, 7501, 7502, 7525, 7524, 9199, 9200, 9223, 9222
25687, 7502, 7503, 7526, 7525, 9200, 9201, 9224, 9223
25688, 7503, 7504, 7527, 7526, 9201, 9202, 9225, 9224
25689, 7504, 7505, 7528, 7527, 9202, 9203, 9226, 9225
25690, 7505, 7506, 7529, 7528, 9203, 9204, 9227, 9226
25691, 7506, 7507, 7530, 7529, 9204, 9205, 9228, 9227
25692, 7507, 7508, 7531, 7530, 9205, 9206, 9229, 9228
25693, 7508, 7509, 7532, 7531, 9206, 9207, 9230, 9229
25694, 7509, 7510, 7533, 7532, 9207, 9208, 9231, 9230
25695, 7510, 7511, 7534, 7533, 9208, 9209, 9232, 9231
25696, 7511, 7512, 7535, 7534, 9209, 9210, 9233, 9232
25697, 7512, 7513, 7536, 7535, 9210, 9211, 9234, 9233
25698, 7513, 7514, 7537, 7536, 9211, 9212, 9235, 9234
25699, 7514, 7515, 7538, 7537, 9212, 9213, 9236, 9235
25700, 7515, 7516, 7539, 7538, 9213, 9214, 9237, 9236
25701, 7516, 985, 986, 7539, 9214, 1328, 1329, 9237
25702, 826, 7517, 7540, 827, 1318, 9215, 9238, 1319
25703, 7517, 7518, 7541, 7540, 9215, 9216, 9239, 9238
25704, 7518, 7519, 7542, 7541, 9216, 9217, 9240, 9239
25705, 7519, 7520, 7543, 7542, 9217, 9218, 9241, 9240
25706, 7520, 7521, 7544, 7543, 9218, 9219, 9242, 9241
25707, 7521, 7522, 7545, 7544, 9219, 9220, 9243, 9242
25708, 7522, 7523, 7546, 7545, 9220, 9221, 9244, 9243
25709, 7523, 7524, 7547, 7546, 9221, 9222, 9245, 9244
25710, 7524, 7525, 7548, 7547, 9222, 9223, 9246, 9245
25711, 7525, 7526, 7549, 7548, 9223, 9224, 9247, 9246
25712, 7526, 7527, 7550, 7549, 9224, 9225, 9248, 9247
25713, 7527, 7528, 7551, 7550, 9225, 9226, 9249, 9248
25714, 7528, 7529, 7552, 7551, 9226, 9227, 9250, 9249
25715, 7529, 7530, 7553, 7552, 9227, 9228, 9251, 9250
25716, 7530, 7531, 7554, 7553, 9228, 9229, 9252, 9251
25717, 7531, 7532, 7555, 7554, 9229, 9230, 9253, 9252
25718, 7532, 7533, 7556, 7555, 9230, 9231, 9254, 9253
25719, 7533, 7534, 7557, 7556, 9231, 9232, 9255, 9254
25720, 7534, 7535, 7558, 7557, 9232, 9233, 9256, 9255
25721, 7535, 7536, 7559, 7558, 9233, 9234, 9257, 9256
25722, 7536, 7537, 7560, 7559, 9234, 9235, 9258, 9257
25723, 7537, 7538, 7561, 7560, 9235, 9236, 9259, 9258
25724, 7538, 7539, 7562, 7561, 9236, 9237, 9260, 9259
25725, 7539, 986, 987, 7562, 9237, 1329, 1330, 9260
25726, 827, 7540, 7563, 828, 1319, 9238, 9261, 1320
25727, 7540, 7541, 7564, 7563, 9238, 9239, 9262, 9261
25728, 7541, 7542, 7565, 7564, 9239, 9240, 9263, 9262
25729, 7542, 7543, 7566, 7565, 9240, 9241, 9264, 9263
25730, 7543, 7544, 7567, 7566, 9241, 9242, 9265, 9264
25731, 7544, 7545, 7568, 7567, 9242, 9243, 9266, 9265
25732, 7545, 7546, 7569, 7568, 9243, 9244, 9267, 9266
25733, 7546, 7547, 7570, 7569, 9244, 9245, 9268, 9267
25734, 7547, 7548, 7571, 7570, 9245, 9246, 9269, 9268
25735, 7548, 7549, 7572, 7571, 9246, 9247, 9270, 9269
25736, 7549, 7550, 7573, 7572, 9247, 9248, 9271, 9270
25737, 7550, 7551, 7574, 7573, 9248, 9249, 9272, 9271
25738, 7551, 7552, 7575, 7574, 9249, 9250, 9273, 9272
25739, 7552, 7553, 7576, 7575, 9250, 9251, 9274, 9273
25740, 7553, 7554, 7577, 7576, 9251, 9252, 9275, 9274
25741, 7554, 7555, 7578, 7577, 9252, 9253, 9276, 9275
25742, 7555, 7556, 7579, 7578, 9253, 9254, 9277, 9276
25743, 7556, 7557, 7580, 7579, 9254, 9255, 9278, 9277
25744, 7557, 7558, 7581, 7580, 9255, 9256, 9279, 9278
25745, 7558, 7559, 7582, 7581, 9256, 9257, 9280, 9279
25746, 7559, 7560, 7583, 7582, 9257, 9258, 9281, 9280
25747, 7560, 7561, 7584, 7583, 9258, 9259, 9282, 9281
25748, 7561, 7562, 7585, 7584, 9259, 9260, 9283, 9282
25749, 7562, 987, 988, 7585, 9260, 1330, 1331, 9283
25750, 828, 7563, 7586, 829, 1320, 9261, 9284, 1321
25751, 7563, 7564, 7587, 7586, 9261, 9262, 9285, 9284
25752, 7564, 7565, 7588, 7587, 9262, 9263, 9286, 9285
25753, 7565, 7566, 7589, 7588, 9263, 9264, 9287, 9286
25754, 7566, 7567, 7590, 7589, 9264, 9265, 9288, 9287
25755, 7567, 7568, 7591, 7590, 9265, 9266, 9289, 9288
25756, 7568, 7569, 7592, 7591, 9266, 9267, 9290, 9289
25757, 7569, 7570, 7593, 7592, 9267, 9268, 9291, 9290
25758, 7570, 7571, 7594, 7593, 9268, 9269, 9292, 9291
25759, 7571, 7572, 7595, 7594, 9269, 9270, 9293, 9292
25760, 7572, 7573, 7596, 7595, 9270, 9271, 9294, 9293
25761, 7573, 7574, 7597, 7596, 9271, 9272, 9295, 9294
25762, 7574, 7575, 7598, 7597, 9272, 9273, 9296, 9295
25763, 7575, 7576, 7599, 7598, 9273, 9274, 9297, 9296
25764, 7576, 7577, 7600, 7599, 9274, 9275, 9298, 9297
25765, 7577, 7578, 7601, 7600, 9275, 9276, 9299, 9298
25766, 7578, 7579, 7602, 7601, 9276, 9277, 9300, 9299
25767, 7579, 7580, 7603, 7602, 9277, 9278, 9301, 9300
25768, 7580, 7581, 7604, 7603, 9278, 9279, 9302, 9301
25769, 7581, 7582, 7605, 7604, 9279, 9280, 9303, 9302
25770, 7582, 7583, 7606, 7605, 9280, 9281, 9304, 9303
25771, 7583, 7584, 7607, 7606, 9281, 9282, 9305, 9304
25772, 7584, 7585, 7608, 7607, 9282, 9283, 9306, 9305
25773, 7585, 988, 989, 7608, 9283, 1331, 1332, 9306
25774, 829, 7586, 841, 33, 1321, 9284, 1265, 61
25775, 7586, 7587, 842, 841, 9284, 9285, 1266, 1265
25776, 7587, 7588, 843, 842, 9285, 9286, 1267, 1266
25777, 7588, 7589, 844, 843, 9286, 9287, 1268, 1267
25778, 7589, 7590, 845, 844, 9287, 9288, 1269, 1268
25779, 7590, 7591, 846, 845, 9288, 9289, 1270, 1269
25780, 7591, 7592, 847, 846, 9289, 9290, 1271, 1270
25781, 7592, 7593, 848, 847, 9290, 9291, 1272, 1271
25782, 7593, 7594, 849, 848, 9291, 9292, 1273, 1272
25783, 7594, 7595, 850, 849, 9292, 9293, 1274, 1273
25784, 7595, 7596, 851, 850, 9293, 9294, 1275, 1274
25785, 7596, 7597, 852, 851, 9294, 9295, 1276, 1275
25786, 7597, 7598, 853, 852, 9295, 9296, 1277, 1276
25787, 7598, 7599, 854, 853, 9296, 9297, 1278, 1277
25788, 7599, 7600, 855, 854, 9297, 9298, 1279, 1278
25789, 7600, 7601, 856, 855, 9298, 9299, 1280, 1279
25790, 7601, 7602, 857, 856, 9299, 9300, 1281, 1280
25791, 7602, 7603, 858, 857, 9300, 9301, 1282, 1281
25792, 7603, 7604, 859, 858, 9301, 9302, 1283, 1282
25793, 7604, 7605, 860, 859, 9302, 9303, 1284, 1283
25794, 7605, 7606, 861, 860, 9303, 9304, 1285, 1284
25795, 7606, 7607, 862, 861, 9304, 9305, 1286, 1285
25796, 7607, 7608, 863, 862, 9305, 9306, 1287, 1286
25797, 7608, 989, 37, 863, 9306, 1332, 62, 1287
*ELEMENT, type=C3D8, ELSET=Volume18
25798, 35, 910, 1288, 63, 69, 1425, 1517, 73
25799, 910, 911, 1289, 1288, 1425, 1426, 1518, 1517
25800, 911, 912, 1290, 1289, 1426, 1427, 1519, 1518
25801, 912, 913, 1291, 1290, 1427, 1428, 1520, 1519
25802, 913, 914, 1292, 1291, 1428, 1429, 1521, 1520
25803, 914, 915, 1293, 1292, 1429, 1430, 1522, 1521
25804, 915, 916, 1294, 1293, 1430, 1431, 1523, 1522
25805, 916, 917, 1295, 1294, 1431, 1432, 1524, 1523
25806, 917, 918, 1296, 1295, 1432, 1433, 1525, 1524
25807, 918, 919, 1297, 1296, 1433, 1434, 1526, 1525
25808, 919, 920, 1298, 1297, 1434, 1435, 1527, 1526
25809, 920, 921, 1299, 1298, 1435, 1436, 1528, 1527
25810, 921, 922, 1300, 1299, 1436, 1437, 1529, 1528
25811, 922, 923, 1301, 1300, 1437, 1438, 1530, 1529
25812, 923, 924, 1302, 1301, 1438, 1439, 1531, 1530
25813, 924, 925, 1303, 1302, 1439, 1440, 1532, 1531
25814, 925, 926, 1304, 1303, 1440, 1441, 1533, 1532
25815, 926, 927, 1305, 1304, 1441, 1442, 1534, 1533
25816, 927, 928, 1306, 1305, 1442, 1443, 1535, 1534
25817, 928, 929, 1307, 1306, 1443, 1444, 1536, 1535
25818, 929, 930, 1308, 1307, 1444, 1445, 1537, 1536
25819, 930, 931, 1309, 1308, 1445, 1446, 1538, 1537
25820, 931, 932, 1310, 1309, 1446, 1447, 1539, 1538
25821, 932, 39, 64, 1310, 1447, 70, 74, 1539
*ELEMENT, type=C3D8, ELSET=Volume19
25822, 9, 309, 1220, 59, 65, 1333, 1540, 75
25823, 309, 310, 1221, 1220, 1333, 1334, 1541, 1540
25824, 310, 311, 1222, 1221, 1334, 1335, 1542, 1541
25825, 311, 312, 1223, 1222, 1335, 1336, 1543, 1542
25826, 312, 313, 1224, 1223, 1336, 1337, 1544, 1543
25827, 313, 314, 1225, 1224, 1337, 1338, 1545, 1544
25828, 314, 315, 1226, 1225, 1338, 1339, 1546, 1545
25829, 315, 316, 1227, 1226, 1339, 1340, 1547, 1546
25830, 316, 317, 1228, 1227, 1340, 1341, 1548, 1547
25831, 317, 318, 1229, 1228, 1341, 1342, 1549, 1548
25832, 318, 319, 1230, 1229, 1342, 1343, 1550, 1549
25833, 319, 320, 1231, 1230, 1343, 1344, 1551, 1550
25834, 320, 321, 1232, 1231, 1344, 1345, 1552, 1551
25835, 321, 322, 1233, 1232, 1345, 1346, 1553, 1552
25836, 322, 323, 1234, 1233, 1346, 1347, 1554, 1553
25837, 323, 324, 1235, 1234, 1347, 1348, 1555, 1554
25838, 324, 325, 1236, 1235, 1348, 1349, 1556, 1555
25839, 325, 326, 1237, 1236, 1349, 1350, 1557, 1556
25840, 326, 327, 1238, 1237, 1350, 1351, 1558, 1557
25841, 327, 328, 1239, 1238, 1351, 1352, 1559, 1558
25842, 328, 329, 1240, 1239, 1352, 1353, 1560, 1559
25843, 329, 330, 1241, 1240, 1353, 1354, 1561, 1560
25844, 330, 331, 1242, 1241, 1354, 1355, 1562, 1561
25845, 331, 13, 60, 1242, 1355, 66, 76, 1562
*ELEMENT, type=C3D8, ELSET=Volume20
25846, 22, 602, 5046, 541, 1567, 10593, 26379, 10365
25847, 1567, 10593, 26379, 10365, 1568, 10594, 26380, 10366
25848, 1568, 10594, 26380, 10366, 1569, 10595, 26381, 10367
25849, 1569, 10595, 26381, 10367, 1570, 10596, 26382, 10368
25850, 1570, 10596, 26382, 10368, 78, 1636, 10637, 1571
25851, 602, 603, 5047, 5046, 10593, 10597, 26383, 26379
25852, 10593, 10597, 26383, 26379, 10594, 10598, 26384, 26380
25853, 10594, 10598, 26384, 26380, 10595, 10599, 26385, 26381
25854, 10595, 10599, 26385, 26381, 10596, 10600, 26386, 26382
25855, 10596, 10600, 26386, 26382, 1636, 1637, 10638, 10637
25856, 603, 604, 5048, 5047, 10597, 10601, 26387, 26383
25857, 10597, 10601, 26387, 26383, 10598, 10602, 26388, 26384
25858, 10598, 10602, 26388, 26384, 10599, 10603, 26389, 26385
25859, 10599, 10603, 26389, 26385, 10600, 10604, 26390, 26386
25860, 10600, 10604, 26390, 26386, 1637, 1638, 10639, 10638
25861, 604, 605, 5049, 5048, 10601, 10605, 26391, 26387
25862, 10601, 10605, 26391, 26387, 10602, 10606, 26392, 26388
25863, 10602, 10606, 26392, 26388, 10603, 10607, 26393, 26389
25864, 10603, 10607, 26393, 26389, 10604, 10608, 26394, 26390
25865, 10604, 10608, 26394, 26390, 1638, 1639, 10640, 10639
25866, 605, 606, 5050, 5049, 10605, 10609, 26395, 26391
25867, 10605, 10609, 26395, 26391, 10606, 10610, 26396, 26392
25868, 10606, 10610, 26396, 26392, 10607, 10611, 26397, 26393
25869, 10607, 10611, 26397, 26393, 10608, 10612, 26398, 26394
25870, 10608, 10612, 26398, 26394, 1639, 1640, 10641, 10640
25871, 606, 607, 5051, 5050, 10609, 10613, 26399, 26395
25872, 10609, 10613, 26399, 26395, 10610, 10614, 26400, 26396
25873, 10610, 10614, 26400, 26396, 10611, 10615, 26401, 26397
25874, 10611, 10615, 26401, 26397, 10612, 10616, 26402, 26398
25875, 10612, 10616, 26402, 26398, 1640, 1641, 10642, 10641
25876, 607, 608, 5052, 5051, 10613, 10617, 26403, 26399
25877, 10613, 10617, 26403, 26399, 10614, 10618, 26404, 26400
25878, 10614, 10618, 26404, 26400, 10615, 10619, 26405, 26401
25879, 10615, 10619, 26405, 26401, 10616, 10620, 26406, 26402
25880, 10616, 10620, 26406, 26402, 1641, 1642, 10643, 10642
25881, 608, 609, 5053, 5052, 10617, 10621, 26407, 26403
25882, 10617, 10621, 26407, 26403, 10618, 10622, 26408, 26404
25883, 10618, 10622, 26408, 26404, 10619, 10623, 26409, 26405
25884, 10619, 10623, 26409, 26405, 10620, 10624, 26410, 26406
25885, 10620, 10624, 26410, 26406, 1642, 1643, 10644, 10643
25886, 609, 610, 5054, 5053, 10621, 10625, 26411, 26407
25887, 10621, 10625, 26411, 26407, 10622, 10626, 26412, 26408
25888, 10622, 10626, 26412, 26408, 10623, 10627, 26413, 26409
25889, 10623, 10627, 26413, 26409, 10624, 10628, 26414, 26410
25890, 10624, 10628, 26414, 26410, 1643, 1644, 10645, 10644
25891, 610, 611, 5055, 5054, 10625, 10629, 26415, 26411
25892, 10625, 10629, 26415, 26411, 10626, 10630, 26416, 26412
25893, 10626, 10630, 26416, 26412, 10627, 10631, 26417, 26413
25894, 10627, 10631, 26417, 26413, 10628, 10632, 26418, 26414
25895, 10628, 10632, 26418, 26414, 1644, 1645, 10646, 10645
25896, 611, 612, 5056, 5055, 10629, 10633, 26419, 26415
25897, 10629, 10633, 26419, 26415, 10630, 10634, 26420, 26416
25898, 10630, 10634, 26420, 26416, 10631, 10635, 26421, 26417
25899, 10631, 10635, 26421, 26417, 10632, 10636, 26422, 26418
25900, 10632, 10636, 26422, 26418, 1645, 1646, 10647, 10646
25901, 612, 24, 579, 5056, 10633, 1609, 10501, 26419
25902, 10633, 1609, 10501, 26419, 10634, 1610, 10502, 26420
25903, 10634, 1610, 10502, 26420, 10635, 1611, 10503, 26421
25904, 10635, 1611, 10503, 26421, 10636, 1612, 10504, 26422
25905, 10636, 1612, 10504, 26422, 1646, 80, 1613, 10647
25906, 541, 5046, 5057, 542, 10365, 26379, 26423, 10369
25907, 10365, 26379, 26423, 10369, 10366, 26380, 26424, 10370
25908, 10366, 26380, 26424, 10370, 10367, 26381, 26425, 10371
25909, 10367, 26381, 26425, 10371, 10368, 26382, 26426, 10372
25910, 10368, 26382, 26426, 10372, 1571, 10637, 10648, 1572
25911, 5046, 5047, 5058, 5057, 26379, 26383, 26427, 26423
25912, 26379, 26383, 26427, 26423, 26380, 26384, 26428, 26424
25913, 26380, 26384, 26428, 26424, 26381, 26385, 26429, 26425
25914, 26381, 26385, 26429, 26425, 26382, 26386, 26430, 26426
25915, 26382, 26386, 26430, 26426, 10637, 10638, 10649, 10648
25916, 5047, 5048, 5059, 5058, 26383, 26387, 26431, 26427
25917, 26383, 26387, 26431, 26427, 26384, 26388, 26432, 26428
25918, 26384, 26388, 26432, 26428, 26385, 26389, 26433, 26429
25919, 26385, 26389, 26433, 26429, 26386, 26390, 26434, 26430
25920, 26386, 26390, 26434, 26430, 10638, 10639, 10650, 10649
25921, 5048, 5049, 5060, 5059, 26387, 26391, 26435, 26431
25922, 26387, 26391, 26435, 26431, 26388, 26392, 26436, 26432
25923, 26388, 26392, 26436, 26432, 26389, 26393, 26437, 26433
25924, 26389, 26393, 26437, 26433, 26390, 26394, 26438, 26434
25925, 26390, 26394, 26438, 26434, 10639, 10640, 10651, 10650
25926, 5049, 5050, 5061, 5060, 26391, 26395, 26439, 26435
25927, 26391, 26395, 26439, 26435, 26392, 26396, 26440, 26436
25928, 26392, 26396, 26440, 26436, 26393, 26397, 26441, 26437
25929, 26393, 26397, 26441, 26437, 26394, 26398, 26442, 26438
25930, 26394, 26398, 26442, 26438, 10640, 10641, 10652, 10651
25931, 5050, 5051, 5062, 5061, 26395, 26399, 26443, 26439
25932, 26395, 26399, 26443, 26439, 26396, 26400, 26444, 26440
25933, 26396, 26400, 26444, 26440, 26397, 26401, 26445, 26441
25934, 26397, 26401, 26445, 26441, 26398, 26402, 26446, 26442
25935, 26398, 26402, 26446, 26442, 10641, 10642, 10653, 10652
25936, 5051, 5052, 5063, 5062, 26399, 26403, 26447, 26443
25937, 26399, 26403, 26447, 26443, 26400, 26404, 26448, 26444
25938, 26400, 26404, 26448, 26444, 26401, 26405, 26449, 26445
25939, 26401, 26405, 26449, 26445, 26402, 26406, 26450, 26446
25940, 26402, 26406, 26450, 26446, 10642, 10643, 10654, 10653
25941, 5052, 5053, 5064, 5063, 26403, 26407, 26451, 26447
25942, 26403, 26407, 26451, 26447, 26404, 26408, 26452, 26448
25943, 26404, 26408, 26452, 26448, 26405, 26409, 26453, 26449
25944, 26405, 26409, 26453, 26449, 26406, 26410, 26454, 26450
25945, 26406, 26410, 26454, 26450, 10643, 10644, 10655, 10654
25946, 5053, 5054, 5065, 5064, 26407, 26411, 26455, 26451
25947, 26407, 26411, 26455, 26451, 26408, 26412, 26456, 26452
25948, 26408, 26412, 26456, 26452, 26409, 26413, 26457, 26453
25949, 26409, 26413, 26457, 26453, 26410, 26414, 26458, 26454
25950, 26410, 26414, 26458, 26454, 10644, 10645, 10656, 10655
25951, 5054, 5055, 5066, 5065, 26411, 26415, 26459, 26455
25952, 26411, 26415, 26459, 26455, 26412, 26416, 26460, 26456
25953, 26412, 26416, 26460, 26456, 26413, 26417, 26461, 26457
25954, 26413, 26417, 26461, 26457, 26414, 26418, 26462, 26458
25955, 26414, 26418, 26462, 26458, 10645, 10646, 10657, 10656
25956, 5055, 5056, 5067, 5066, 26415, 26419, 26463, 26459
25957, 26415, 26419, 26463, 26459, 26416, 26420, 26464, 26460
25958, 26416, 26420, 26464, 26460, 26417, 26421, 26465, 26461
25959, 26417, 26421, 26465, 26461, 26418, 26422, 26466, 26462
25960, 26418, 26422, 26466, 26462, 10646, 10647, 10658, 10657
25961, 5056, 579, 580, 5067, 26419, 10501, 10505, 26463
25962, 26419, 10501, 10505, 26463, 26420, 10502, 10506, 26464
25963, 26420, 10502, 10506, 26464, 26421, 10503, 10507, 26465
25964, 26421, 10503, 10507, 26465, 26422, 10504, 10508, 26466
25965, 26422, 10504, 10508, 26466, 10647, 1613, 1614, 10658
25966, 542, 5057, 5068, 543, 10369, 26423, 26467, 10373
25967, 10369, 26423, 26467, 10373, 10370, 26424, 26468, 10374
25968, 10370, 26424, 26468, 10374, 10371, 26425, 26469, 10375
25969, 10371, 26425, 26469, 10375, 10372, 26426, 26470, 10376
25970, 10372, 26426, 26470, 10376, 1572, 10648, 10659, 1573
25971, 5057, 5058, 5069, 5068, 26423, 26427, 26471, 26467
25972, 26423, 26427, 26471, 26467, 26424, 26428, 26472, 26468
25973, 26424, 26428, 26472, 26468, 26425, 26429, 26473, 26469
25974, 26425, 26429, 26473, 26469, 26426, 26430, 26474, 26470
25975, 26426, 26430, 26474, 26470, 10648, 10649, 10660, 10659
25976, 5058, 5059, 5070, 5069, 26427, 26431, 26475, 26471
25977, 26427, 26431, 26475, 26471, 26428, 26432, 26476, 26472
25978, 26428, 26432, 26476, 26472, 26429, 26433, 26477, 26473
25979, 26429, 26433, 26477, 26473, 26430, 26434, 26478, 26474
25980, 26430, 26434, 26478, 26474, 10649, 10650, 10661, 10660
25981, 5059, 5060, 5071, 5070, 26431, 26435, 26479, 26475
25982, 26431, 26435, 26479, 26475, 26432, 26436, 26480, 26476
25983, 26432, 26436, 26480, 26476, 26433, 26437, 26481, 26477
25984, 26433, 26437, 26481, 26477, 26434, 26438, 26482, 26478
25985, 26434, 26438, 26482, 26478, 10650, 10651, 10662, 10661
25986, 5060, 5061, 5072, 5071, 26435, 26439, 26483, 26479
25987, 26435, 26439, 26483, 26479, 26436, 26440, 26484, 26480
25988, 26436, 26440, 26484, 26480, 26437, 26441, 26485, 26481
25989, 26437, 26441, 26485, 26481, 26438, 26442, 26486, 26482
25990, 26438, 26442, 26486, 26482, 10651, 10652, 10663, 10662
25991, 5061, 5062, 5073, 5072, 26439, 26443, 26487, 26483
25992, 26439, 26443, 26487, 26483, 26440, 26444, 26488, 26484
25993, 26440, 26444, 26488, 26484, 26441, 26445, 26489, 26485
25994, 26441, 26445, 26489, 26485, 26442, 26446, 26490, 26486
25995, 26442, 26446, 26490, 26486, 10652, 10653, 10664, 10663
25996, 5062, 5063, 5074, 5073, 26443, 26447, 26491, 26487
25997, 26443, 26447, 26491, 26487, 26444, 26448, 26492, 26488
25998, 26444, 26448, 26492, 26488, 26445, 26449, 26493, 26489
25999, 26445, 26449, 26493, 26489, 26446, 26450, 26494, 26490
26000, 26446, 26450, 26494, 26490, 10653, 10654, 10665, 10664
26001, 5063, 5064, 5075, 5074, 26447, 26451, 26495, 26491
26002, 26447, 26451, 26495, 26491, 26448, 26452, 26496, 26492
26003, 26448, 26452, 26496, 26492, 26449, 26453, 26497, 26493
26004, 26449, 26453, 26497, 26493, 26450, 26454, 26498, 26494
26005, 26450, 26454, 26498, 26494, 10654, 10655, 10666, 10665
26006, 5064, 5065, 5076, 5075, 26451, 26455, 26499, 26495
26007, 26451, 26455, 26499, 26495, 26452, 26456, 26500, 26496
26008, 26452, 26456, 26500, 26496, 26453, 26457, 26501, 26497
26009, 26453, 26457, 26501, 26497, 26454, 26458, 26502, 26498
26010, 26454, 26458, 26502, 26498, 10655, 10656, 10667, 10666
26011, 5065, 5066, 5077, 5076, 26455, 26459, 26503, 26499
26012, 26455, 26459, 26503, 26499, 26456, 26460, 26504, 26500
26013, 26456, 26460, 26504, 26500, 26457, 26461, 26505, 26501
26014, 26457, 26461, 26505, 26501, 26458, 26462, 26506, 26502
26015, 26458, 26462, 26506, 26502, 10656, 10657, 10668, 10667
26016, 5066, 5067, 5078, 5077, 26459, 26463, 26507, 26503
26017, 26459, 26463, 26507, 26503, 26460, 26464, 26508, 26504
26018, 26460, 26464, 26508, 26504, 26461, 26465, 26509, 26505
26019, 26461, 26465, 26509, 26505, 26462, 26466, 26510, 26506
26020, 26462, 26466, 26510, 26506, 10657, 10658, 10669, 10668
26021, 5067, 580, 581, 5078, 26463, 10505, 10509, 26507
26022, 26463, 10505, 10509, 26507, 26464, 10506, 10510, 26508
26023, 26464, 10506, 10510, 26508, 26465, 10507, 10511, 26509
26024, 26465, 10507, 10511, 26509, 26466, 10508, 10512, 26510
26025, 26466, 10508, 10512, 26510, 10658, 1614, 1615, 10669
26026, 543, 5068, 5079, 544, 10373, 26467, 26511, 10377
26027, 10373, 26467, 26511, 10377, 10374, 26468, 26512, 10378
26028, 10374, 26468, 26512, 10378, 10375, 26469, 26513, 10379
26029, 10375, 26469, 26513, 10379, 10376, 26470, 26514, 10380
26030, 10376, 26470, 26514, 10380, 1573, 10659, 10670, 1574
26031, 5068, 5069, 5080, 5079, 26467, 26471, 26515, 26511
26032, 26467, 26471, 26515, 26511, 26468, 26472, 26516, 26512
26033, 26468, 26472, 26516, 26512, 26469, 26473, 26517, 26513
26034, 26469, 26473, 26517, 26513, 26470, 26474, 26518, 26514
26035, 26470, 26474, 26518, 26514, 10659, 10660, 10671, 10670
26036, 5069, 5070, 5081, 5080, 26471, 26475, 26519, 26515
26037, 26471, 26475, 26519, 26515, 26472, 26476, 26520, 26516
26038, 26472, 26476, 26520, 26516, 26473, 26477, 26521, 26517
26039, 26473, 26477, 26521, 26517, 26474, 26478, 26522, 26518
26040, 26474, 26478, 26522, 26518, 10660, 10661, 10672, 10671
26041, 5070, 5071, 5082, 5081, 26475, 26479, 26523, 26519
26042, 26475, 26479, 26523, 26519, 26476, 26480, 26524, 26520
26043, 26476, 26480, 26524, 26520, 26477, 26481, 26525, 26521
26044, 26477, 26481, 26525, 26521, 26478, 26482, 26526, 26522
26045, 26478, 26482, 26526, 26522, 10661, 10662, 10673, 10672
26046, 5071, 5072, 5083, 5082, 26479, 26483, 26527, 26523
26047, 26479, 26483, 26527, 26523, 26480, 26484, 26528, 26524
26048, 26480, 26484, 26528, 26524, 26481, 26485, 26529, 26525
26049, 26481, 26485, 26529, 26525, 26482, 26486, 26530, 26526
26050, 26482, 26486, 26530, 26526, 10662, 10663, 10674, 10673
26051, 5072, 5073, 5084, 5083, 26483, 26487, 26531, 26527
26052, 26483, 26487, 26531, 26527, 26484, 26488, 26532, 26528
26053, 26484, 26488, 26532, 26528, 26485, 26489, 26533, 26529
26054, 26485, 26489, 26533, 26529, 26486, 26490, 26534, 26530
26055, 26486, 26490, 26534, 26530, 10663, 10664, 10675, 10674
26056, 5073, 5074, 5085, 5084, 26487, 26491, 26535, 26531
26057, 26487, 26491, 26535, 26531, 26488, 26492, 26536, 26532
26058, 26488, 26492, 26536, 26532, 26489, 26493, 26537, 26533
26059, 26489, 26493, 26537, 26533, 26490, 26494, 26538, 26534
26060, 26490, 26494, 26538, 26534, 10664, 10665, 10676, 10675
26061, 5074, 5075, 5086, 5085, 26491, 26495, 26539, 26535
26062, 26491, 26495, 26539, 26535, 26492, 26496, 26540, 26536
26063, 26492, 26496, 26540, 26536, 26493, 26497, 26541, 26537
26064, 26493, 26497, 26541, 26537, 26494, 26498, 26542, 26538
26065, 26494, 26498, 26542, 26538, 10665, 10666, 10677, 10676
26066, 5075, 5076, 5087, 5086, 26495, 26499, 26543, 26539
26067, 26495, 26499, 26543, 26539, 26496, 26500, 26544, 26540
26068, 26496, 26500, 26544, 26540, 26497, 26501, 26545, 26541
26069, 26497, 26501, 26545, 26541, 26498, 26502, 26546, 26542
26070, 26498, 26502, 26546, 26542, 10666, 10667, 10678, 10677
26071, 5076, 5077, 5088, 5087, 26499, 26503, 26547, 26543
26072, 26499, 26503, 26547, 26543, 26500, 26504, 26548, 26544
26073, 26500, 26504, 26548, 26544, 26501, 26505, 26549, 26545
26074, 26501, 26505, 26549, 26545, 26502, 26506, 26550, 26546
26075, 26502, 26506, 26550, 26546, 10667, 10668, 10679, 10678
26076, 5077, 5078, 5089, 5088, 26503, 26507, 26551, 26547
26077, 26503, 26507, 26551, 26547, 26504, 26508, 26552, 26548
26078, 26504, 26508, 26552, 26548, 26505, 26509, 26553, 26549
26079, 26505, 26509, 26553, 26549, 26506, 26510, 26554, 26550
26080, 26506, 26510, 26554, 26550, 10668, 10669, 10680, 10679
26081, 5078, 581, 582, 5089, 26507, 10509, 10513, 26551
26082, 26507, 10509, 10513, 26551, 26508, 10510, 10514, 26552
26083, 26508, 10510, 10514, 26552, 26509, 10511, 10515, 26553
26084, 26509, 10511, 10515, 26553, 26510, 10512, 10516, 26554
26085, 26510, 10512, 10516, 26554, 10669, 1615, 1616, 10680
26086, 544, 5079, 5090, 545, 10377, 26511, 26555, 10381
26087, 10377, 26511, 26555, 10381, 10378, 26512, 26556, 10382
26088, 10378, 26512, 26556, 10382, 10379, 26513, 26557, 10383
26089, 10379, 26513, 26557, 10383, 10380, 26514, 26558, 10384
26090, 10380, 26514, 26558, 10384, 1574, 10670, 10681, 1575
26091, 5079, 5080, 5091, 5090, 26511, 26515, 26559, 26555
26092, 26511, 26515, 26559, 26555, 26512, 26516, 26560, 26556
26093, 26512, 26516, 26560, 26556, 26513, 26517, 26561, 26557
26094, 26513, 26517, 26561, 26557, 26514, 26518, 26562, 26558
26095, 26514, 26518, 26562, 26558, 10670, 10671, 10682, 10681
26096, 5080, 5081, 5092, 5091, 26515, 26519, 26563, 26559
26097, 26515, 26519, 26563, 26559, 26516, 26520, 26564, 26560
26098, 26516, 26520, 26564, 26560, 26517, 26521, 26565, 26561
26099, 26517, 26521, 26565, 26561, 26518, 26522, 26566, 26562
26100, 26518, 26522, 26566, 26562, 10671, 10672, 10683, 10682
26101, 5081, 5082, 5093, 5092, 26519, 26523, 26567, 26563
26102, 26519, 26523, 26567, 26563, 26520, 26524, 26568, 26564
26103, 26520, 26524, 26568, 26564, 26521, 26525, 26569, 26565
26104, 26521, 26525, 26569, 26565, 26522, 26526, 26570, 26566
26105, 26522, 26526, 26570, 26566, 10672, 10673, 10684, 10683
26106, 5082, 5083, 5094, 5093, 26523, 26527, 26571, 26567
26107, 26523, 26527, 26571, 26567, 26524, 26528, 26572, 26568
26108, 26524, 26528, 26572, 26568, 26525, 26529, 26573, 26569
26109, 26525, 26529, 26573, 26569, 26526, 26530, 26574, 26570
26110, 26526, 26530, 26574, 26570, 10673, 10674, 10685, 10684
26111, 5083, 5084, 5095, 5094, 26527, 26531, 26575, 26571
26112, 26527, 26531, 26575, 26571, 26528, 26532, 26576, 26572
26113, 26528, 26532, 26576, 26572, 26529, 26533, 26577, 26573
26114, 26529, 26533, 26577, 26573, 26530, 26534, 26578, 26574
26115, 26530, 26534, 26578, 26574, 10674, 10675, 10686, 10685
26116, 5084, 5085, 5096, 5095, 26531, 26535, 26579, 26575
26117, 26531, 26535, 26579, 26575, 26532, 26536, 26580, 26576
26118, 26532, 26536, 26580, 26576, 26533, 26537, 26581, 26577
26119, 26533, 26537, 26581, 26577, 26534, 26538, 26582, 26578
26120, 26534, 26538, 26582, 26578, 10675, 10676, 10687, 10686
26121, 5085, 5086, 5097, 5096, 26535, 26539, 26583, 26579
26122, 26535, 26539, 26583, 26579, 26536, 26540, 26584, 26580
26123, 26536, 26540, 26584, 26580, 26537, 26541, 26585, 26581
26124, 26537, 26541, 26585, 26581, 26538, 26542, 26586, 26582
26125, 26538, 26542, 26586, 26582, 10676, 10677, 10688, 10687
26126, 5086, 5087, 5098, 5097, 26539, 26543, 26587, 26583
26127, 26539, 26543, 26587, 26583, 26540, 26544, 26588, 26584
26128, 26540, 26544, 26588, 26584, 26541, 26545, 26589, 26585
26129, 26541, 26545, 26589, 26585, 26542, 26546, 26590, 26586
26130, 26542, 26546, 26590, 26586, 10677, 10678, 10689, 10688
26131, 5087, 5088, 5099, 5098, 26543, 26547, 26591, 26587
26132, 26543, 26547, 26591, 26587, 26544, 26548, 26592, 26588
26133, 26544, 26548, 26592, 26588, 26545, 26549, 26593, 26589
26134, 26545, 26549, 26593, 26589, 26546, 26550, 26594, 26590
26135, 26546, 26550, 26594, 26590, 10678, 10679, 10690, 10689
26136, 5088, 5089, 5100, 5099, 26547, 26551, 26595, 26591
26137, 26547, 26551, 26595, 26591, 26548, 26552, 26596, 26592
26138, 26548, 26552, 26596, 26592, 26549, 26553, 26597, 26593
26139, 26549, 26553, 26597, 26593, 26550, 26554, 26598, 26594
26140, 26550, 26554, 26598, 26594, 10679, 10680, 10691, 10690
26141, 5089, 582, 583, 5100, 26551, 10513, 10517, 26595
26142, 26551, 10513, 10517, 26595, 26552, 10514, 10518, 26596
26143, 26552, 10514, 10518, 26596, 26553, 10515, 10519, 26597
26144, 26553, 10515, 10519, 26597, 26554, 10516, 10520, 26598
26145, 26554, 10516, 10520, 26598, 10680, 1616, 1617, 10691
26146, 545, 5090, 5101, 546, 10381, 26555, 26599, 10385
26147, 10381, 26555, 26599, 10385, 10382, 26556, 26600, 10386
26148, 10382, 26556, 26600, 10386, 10383, 26557, 26601, 10387
26149, 10383, 26557, 26601, 10387, 10384, 26558, 26602, 10388
26150, 10384, 26558, 26602, 10388, 1575, 10681, 10692, 1576
26151, 5090, 5091, 5102, 5101, 26555, 26559, 26603, 26599
26152, 26555, 26559, 26603, 26599, 26556, 26560, 26604, 26600
26153, 26556, 26560, 26604, 26600, 26557, 26561, 26605, 26601
26154, 26557, 26561, 26605, 26601, 26558, 26562, 26606, 26602
26155, 26558, 26562, 26606, 26602, 10681, 10682, 10693, 10692
26156, 5091, 5092, 5103, 5102, 26559, 26563, 26607, 26603
26157, 26559, 26563, 26607, 26603, 26560, 26564, 26608, 26604
26158, 26560, 26564, 26608, 26604, 26561, 26565, 26609, 26605
26159, 26561, 26565, 26609, 26605, 26562, 26566, 26610, 26606
26160, 26562, 26566, 26610, 26606, 10682, 10683, 10694, 10693
26161, 5092, 5093, 5104, 5103, 26563, 26567, 26611, 26607
26162, 26563, 26567, 26611, 26607, 26564, 26568, 26612, 26608
26163, 26564, 26568, 26612, 26608, 26565, 26569, 26613, 26609
26164, 26565, 26569, 26613, 26609, 26566, 26570, 26614, 26610
26165, 26566, 26570, 26614, 26610, 10683, 10684, 10695, 10694
26166, 5093, 5094, 5105, 5104, 26567, 26571, 26615, 26611
26167, 26567, 26571, 26615, 26611, 26568, 26572, 26616, 26612
26168, 26568, 26572, 26616, 26612, 26569, 26573, 26617, 26613
26169, 26569, 26573, 26617, 26613, 26570, 26574, 26618, 26614
26170, 26570, 26574, 26618, 26614, 10684, 10685, 10696, 10695
26171, 5094, 5095, 5106, 5105, 26571, 26575, 26619, 26615
26172, 26571, 26575, 26619, 26615, 26572, 26576, 26620, 26616
26173, 26572, 26576, 26620, 26616, 26573, 26577, 26621, 26617
26174, 26573, 26577, 26621, 26617, 26574, 26578, 26622, 26618
26175, 26574, 26578, 26622, 26618, 10685, 10686, 10697, 10696
26176, 5095, 5096, 5107, 5106, 26575, 26579, 26623, 26619
26177, 26575, 26579, 26623, 26619, 26576, 26580, 26624, 26620
26178, 26576, 26580, 26624, 26620, 26577, 26581, 26625, 26621
26179, 26577, 26581, 26625, 26621, 26578, 26582, 26626, 26622
26180, 26578, 26582, 26626, 26622, 10686, 10687, 10698, 10697
26181, 5096, 5097, 5108, 5107, 26579, 26583, 26627, 26623
26182, 26579, 26583, 26627, 26623, 26580, 26584, 26628, 26624
26183, 26580, 26584, 26628, 26624, 26581, 26585, 26629, 26625
26184, 26581, 26585, 26629, 26625, 26582, 26586, 26630, 26626
26185, 26582, 26586, 26630, 26626, 10687, 10688, 10699, 10698
26186, 5097, 5098, 5109, 5108, 26583, 26587, 26631, 26627
26187, 26583, 26587, 26631, 26627, 26584, 26588, 26632, 26628
26188, 26584, 26588, 26632, 26628, 26585, 26589, 26633, 26629
26189, 26585, 26589, 26633, 26629, 26586, 26590, 26634, 26630
26190, 26586, 26590, 26634, 26630, 10688, 10689, 10700, 10699
26191, 5098, 5099, 5110, 5109, 26587, 26591, 26635, 26631
26192, 26587, 26591, 26635, 26631, 26588, 26592, 26636, 26632
26193, 26588, 26592, 26636, 26632, 26589, 26593, 26637, 26633
26194, 26589, 26593, 26637, 26633, 26590, 26594, 26638, 26634
26195, 26590, 26594, 26638, 26634, 10689, 10690, 10701, 10700
26196, 5099, 5100, 5111, 5110, 26591, 26595, 26639, 26635
26197, 26591, 26595, 26639, 26635, 26592, 26596, 26640, 26636
26198, 26592, 26596, 26640, 26636, 26593, 26597, 26641, 26637
26199, 26593, 26597, 26641, 26637, 26594, 26598, 26642, 26638
26200, 26594, 26598, 26642, 26638, 10690, 10691, 10702, 10701
26201, 5100, 583, 584, 5111, 26595, 10517, 10521, 26639
26202, 26595, 10517, 10521, 26639, 26596, 10518, 10522, 26640
26203, 26596, 10518, 10522, 26640, 26597, 10519, 10523, 26641
26204, 26597, 10519, 10523, 26641, 26598, 10520, 10524, 26642
26205, 26598, 10520, 10524, 26642, 10691, 1617, 1618, 10702
26206, 546, 5101, 5112, 547, 10385, 26599, 26643, 10389
26207, 10385, 26599, 26643, 10389, 10386, 26600, 26644, 10390
26208, 10386, 26600, 26644, 10390, 10387, 26601, 26645, 10391
26209, 10387, 26601, 26645, 10391, 10388, 26602, 26646, 10392
26210, 10388, 26602, 26646, 10392, 1576, 10692, 10703, 1577
26211, 5101, 5102, 5113, 5112, 26599, 26603, 26647, 26643
26212, 26599, 26603, 26647, 26643, 26600, 26604, 26648, 26644
26213, 26600, 26604, 26648, 26644, 26601, 26605, 26649, 26645
26214, 26601, 26605, 26649, 26645, 26602, 26606, 26650, 26646
26215, 26602, 26606, 26650, 26646, 10692, 10693, 10704, 10703
26216, 5102, 5103, 5114, 5113, 26603, 26607, 26651, 26647
26217, 26603, 26607, 26651, 26647, 26604, 26608, 26652, 26648
26218, 26604, 26608, 26652, 26648, 26605, 26609, 26653, 26649
26219, 26605, 26609, 26653, 26649, 26606, 26610, 26654, 26650
26220, 26606, 26610, 26654, 26650, 10693, 10694, 10705, 10704
26221, 5103, 5104, 5115, 5114, 26607, 26611, 26655, 26651
26222, 26607, 26611, 26655, 26651, 26608, 26612, 26656, 26652
26223, 26608, 26612, 26656, 26652, 26609, 26613, 26657, 26653
26224, 26609, 26613, 26657, 26653, 26610, 26614, 26658, 26654
26225, 26610, 26614, 26658, 26654, 10694, 10695, 10706, 10705
26226, 5104, 5105, 5116, 5115, 26611, 26615, 26659, 26655
26227, 26611, 26615, 26659, 26655, 26612, 26616, 26660, 26656
26228, 26612, 26616, 26660, 26656, 26613, 26617, 26661, 26657
26229, 26613, 26617, 26661, 26657, 26614, 26618, 26662, 26658
26230, 26614, 26618, 26662, 26658, 10695, 10696, 10707, 10706
26231, 5105, 5106, 5117, 5116, 26615, 26619, 26663, 26659
26232, 26615, 26619, 26663, 26659, 26616, 26620, 26664, 26660
26233, 26616, 26620, 26664, 26660, 26617, 26621, 26665, 26661
26234, 26617, 26621, 26665, 26661, 26618, 26622, 26666, 26662
26235, 26618, 26622, 26666, 26662, 10696, 10697, 10708, 10707
26236, 5106, 5107, 5118, 5117, 26619, 26623, 26667, 26663
26237, 26619, 26623, 26667, 26663, 26620, 26624, 26668, 26664
26238, 26620, 26624, 26668, 26664, 26621, 26625, 26669, 26665
26239, 26621, 26625, 26669, 26665, 26622, 26626, 26670, 26666
26240, 26622, 26626, 26670, 26666, 10697, 10698, 10709, 10708
26241, 5107, 5108, 5119, 5118, 26623, 26627, 26671, 26667
26242, 26623, 26627, 26671, 26667, 26624, 26628, 26672, 26668
26243, 26624, 26628, 26672, 26668, 26625, 26629, 26673, 26669
26244, 26625, 26629, 26673, 26669, 26626, 26630, 26674, 26670
26245, 26626, 26630, 26674, 26670, 10698, 10699, 10710, 10709
26246, 5108, 5109, 5120, 5119, 26627, 26631, 26675, 26671
26247, 26627, 26631, 26675, 26671, 26628, 26632, 26676, 26672
26248, 26628, 26632, 26676, 26672, 26629, 26633, 26677, 26673
26249, 26629, 26633, 26677, 26673, 26630, 26634, 26678, 26674
26250, 26630, 26634, 26678, 26674, 10699, 10700, 10711, 10710
26251, 5109, 5110, 5121, 5120, 26631, 26635, 26679, 26675
26252, 26631, 26635, 26679, 26675, 26632, 26636, 26680, 26676
26253, 26632, 26636, 26680, 26676, 26633, 26637, 26681, 26677
26254, 26633, 26637, 26681, 26677, 26634, 26638, 26682, 26678
26255, 26634, 26638, 26682, 26678, 10700, 10701, 10712, 10711
26256, 5110, 5111, 5122, 5121, 26635, 26639, 26683, 26679
26257, 26635, 26639, 26683, 26679, 26636, 26640, 26684, 26680
26258, 26636, 26640, 26684, 26680, 26637, 26641, 26685, 26681
26259, 26637, 26641, 26685, 26681, 26638, 26642, 26686, 26682
26260, 26638, 26642, 26686, 26682, 10701, 10702, 10713, 10712
26261, 5111, 584, 585, 5122, 26639, 10521, 10525, 26683
26262, 26639, 10521, 10525, 26683, 26640, 10522, 10526, 26684
26263, 26640, 10522, 10526, 26684, 26641, 10523, 10527, 26685
26264, 26641, 10523, 10527, 26685, 26642, 10524, 10528, 26686
26265, 26642, 10524, 10528, 26686, 10702, 1618, 1619, 10713
26266, 547, 5112, 5123, 548, 10389, 26643, 26687, 10393
26267, 10389, 26643, 26687, 10393, 10390, 26644, 26688, 10394
26268, 10390, 26644, 26688, 10394, 10391, 26645, 26689, 10395
26269, 10391, 26645, 26689, 10395, 10392, 26646, 26690, 10396
26270, 10392, 26646, 26690, 10396, 1577, 10703, 10714, 1578
26271, 5112, 5113, 5124, 5123, 26643, 26647, 26691, 26687
26272, 26643, 26647, 26691, 26687, 26644, 26648, 26692, 26688
26273, 26644, 26648, 26692, 26688, 26645, 26649, 26693, 26689
26274, 26645, 26649, 26693, 26689, 26646, 26650, 26694, 26690
26275, 26646, 26650, 26694, 26690, 10703, 10704, 10715, 10714
26276, 5113, 5114, 5125, 5124, 26647, 26651, 26695, 26691
26277, 26647, 26651, 26695, 26691, 26648, 26652, 26696, 26692
26278, 26648, 26652, 26696, 26692, 26649, 26653, 26697, 26693
26279, 26649, 26653, 26697, 26693, 26650, 26654, 26698, 26694
26280, 26650, 26654, 26698, 26694, 10704, 10705, 10716, 10715
26281, 5114, 5115, 5126, 5125, 26651, 26655, 26699, 26695
26282, 26651, 26655, 26699, 26695, 26652, 26656, 26700, 26696
26283, 26652, 26656, 26700, 26696, 26653, 26657, 26701, 26697
26284, 26653, 26657, 26701, 26697, 26654, 26658, 26702, 26698
26285, 26654, 26658, 26702, 26698, 10705, 10706, 10717, 10716
26286, 5115, 5116, 5127, 5126, 26655, 26659, 26703, 26699
26287, 26655, 26659, 26703, 26699, 26656, 26660, 26704, 26700
26288, 26656, 26660, 26704, 26700, 26657, 26661, 26705, 26701
26289, 26657, 26661, 26705, 26701, 26658, 26662, 26706, 26702
26290, 26658, 26662, 26706, 26702, 10706, 10707, 10718, 10717
26291, 5116, 5117, 5128, 5127, 26659, 26663, 26707, 26703
26292, 26659, 26663, 26707, 26703, 26660, 26664, 26708, 26704
26293, 26660, 26664, 26708, 26704, 26661, 26665, 26709, 26705
26294, 26661, 26665, 26709, 26705, 26662, 26666, 26710, 26706
26295, 26662, 26666, 26710, 26706, 10707, 10708, 10719, 10718
26296, 5117, 5118, 5129, 5128, 26663, 26667, 26711, 26707
26297, 26663, 26667, 26711, 26707, 26664, 26668, 26712, 26708
26298, 26664, 26668, 26712, 26708, 26665, 26669, 26713, 26709
26299, 26665, 26669, 26713, 26709, 26666, 26670, 26714, 26710
26300, 26666, 26670, 26714, 26710, 10708, 10709, 10720, 10719
26301, 5118, 5119, 5130, 5129, 26667, 26671, 26715, 26711
26302, 26667, 26671, 26715, 26711, 26668, 26672, 26716, 26712
26303, 26668, 26672, 26716, 26712, 26669, 26673, 26717, 26713
26304, 26669, 26673, 26717, 26713, 26670, 26674, 26718, 26714
26305, 26670, 26674, 26718, 26714, 10709, 10710, 10721, 10720
26306, 5119, 5120, 5131, 5130, 26671, 26675, 26719, 26715
26307, 26671, 26675, 26719, 26715, 26672, 26676, 26720, 26716
26308, 26672, 26676, 26720, 26716, 26673, 26677, 26721, 26717
26309, 26673, 26677, 26721, 26717, 26674, 26678, 26722, 26718
26310, 26674, 26678, 26722, 26718, 10710, 10711, 10722, 10721
26311, 5120, 5121, 5132, 5131, 26675, 26679, 26723, 26719
26312, 26675, 26679, 26723, 26719, 26676, 26680, 26724, 26720
26313, 26676, 26680, 26724, 26720, 26677, 26681, 26725, 26721
26314, 26677, 26681, 26725, 26721, 26678, 26682, 26726, 26722
26315, 26678, 26682, 26726, 26722, 10711, 10712, 10723, 10722
26316, 5121, 5122, 5133, 5132, 26679, 26683, 26727, 26723
26317, 26679, 26683, 26727, 26723, 26680, 26684, 26728, 26724
26318, 26680, 26684, 26728, 26724, 26681, 26685, 26729, 26725
26319, 26681, 26685, 26729, 26725, 26682, 26686, 26730, 26726
26320, 26682, 26686, 26730, 26726, 10712, 10713, 10724, 10723
26321, 5122, 585, 586, 5133, 26683, 10525, 10529, 26727
26322, 26683, 10525, 10529, 26727, 26684, 10526, 10530, 26728
26323, 26684, 10526, 10530, 26728, 26685, 10527, 10531, 26729
26324, 26685, 10527, 10531, 26729, 26686, 10528, 10532, 26730
26325, 26686, 10528, 10532, 26730, 10713, 1619, 1620, 10724
26326, 548, 5123, 5134, 549, 10393, 26687, 26731, 10397
26327, 10393, 26687, 26731, 10397, 10394, 26688, 26732, 10398
26328, 10394, 26688, 26732, 10398, 10395, 26689, 26733, 10399
26329, 10395, 26689, 26733, 10399, 10396, 26690, 26734, 10400
26330, 10396, 26690, 26734, 10400, 1578, 10714, 10725, 1579
26331, 5123, 5124, 5135, 5134, 26687, 26691, 26735, 26731
26332, 26687, 26691, 26735, 26731, 26688, 26692, 26736, 26732
26333, 26688, 26692, 26736, 26732, 26689, 26693, 26737, 26733
26334, 26689, 26693, 26737, 26733, 26690, 26694, 26738, 26734
26335, 26690, 26694, 26738, 26734, 10714, 10715, 10726, 10725
26336, 5124, 5125, 5136, 5135, 26691, 26695, 26739, 26735
26337, 26691, 26695, 26739, 26735, 26692, 26696, 26740, 26736
26338, 26692, 26696, 26740, 26736, 26693, 26697, 26741, 26737
26339, 26693, 26697, 26741, 26737, 26694, 26698, 26742, 26738
26340, 26694, 26698, 26742, 26738, 10715, 10716, 10727, 10726
26341, 5125, 5126, 5137, 5136, 26695, 26699, 26743, 26739
26342, 26695, 26699, 26743, 26739, 26696, 26700, 26744, 26740
26343, 26696, 26700, 26744, 26740, 26697, 26701, 26745, 26741
26344, 26697, 26701, 26745, 26741, 26698, 26702, 26746, 26742
26345, 26698, 26702, 26746, 26742, 10716, 10717, 10728, 10727
26346, 5126, 5127, 5138, 5137, 26699, 26703, 26747, 26743
26347, 26699, 26703, 26747, 26743, 26700, 26704, 26748, 26744
26348, 26700, 26704, 26748, 26744, 26701, 26705, 26749, 26745
26349, 26701, 26705, 26749, 26745, 26702, 26706, 26750, 26746
26350, 26702, 26706, 26750, 26746, 10717, 10718, 10729, 10728
26351, 5127, 5128, 5139, 5138, 26703, 26707, 26751, 26747
26352, 26703, 26707, 26751, 26747, 26704, 26708, 26752, 26748
26353, 26704, 26708, 26752, 26748, 26705, 26709, 26753, 26749
26354, 26705, 26709, 26753, 26749, 26706, 26710, 26754, 26750
26355, 26706, 26710, 26754, 26750, 10718, 10719, 10730, 10729
26356, 5128, 5129, 5140, 5139, 26707, 26711, 26755, 26751
26357, 26707, 26711, 26755, 26751, 26708, 26712, 26756, 26752
26358, 26708, 26712, 26756, 26752, 26709, 26713, 26757, 26753
26359, 26709, 26713, 26757, 26753, 26710, 26714, 26758, 26754
26360, 26710, 26714, 26758, 26754, 10719, 10720, 10731, 10730
26361, 5129, 5130, 5141, 5140, 26711, 26715, 26759, 26755
26362, 26711, 26715, 26759, 26755, 26712, 26716, 26760, 26756
26363, 26712, 26716, 26760, 26756, 26713, 26717, 26761, 26757
26364, 26713, 26717, 26761, 26757, 26714, 26718, 26762, 26758
26365, 26714, 26718, 26762, 26758, 10720, 10721, 10732, 10731
26366, 5130, 5131, 5142, 5141, 26715, 26719, 26763, 26759
26367, 26715, 26719, 26763, 26759, 26716, 26720, 26764, 26760
26368, 26716, 26720, 26764, 26760, 26717, 26721, 26765, 26761
26369, 26717, 26721, 26765, 26761, 26718, 26722, 26766, 26762
26370, 26718, 26722, 26766, 26762, 10721, 10722, 10733, 10732
26371, 5131, 5132, 5143, 5142, 26719, 26723, 26767, 26763
26372, 26719, 26723, 26767, 26763, 26720, 26724, 26768, 26764
26373, 26720, 26724, 26768, 26764, 26721, 26725, 26769, 26765
26374, 26721, 26725, 26769, 26765, 26722, 26726, 26770, 26766
26375, 26722, 26726, 26770, 26766, 10722, 10723, 10734, 10733
26376, 5132, 5133, 5144, 5143, 26723, 26727, 26771, 26767
26377, 26723, 26727, 26771, 26767, 26724, 26728, 26772, 26768
26378, 26724, 26728, 26772, 26768, 26725, 26729, 26773, 26769
26379, 26725, 26729, 26773, 26769, 26726, 26730, 26774, 26770
26380, 26726, 26730, 26774, 26770, 10723, 10724, 10735, 10734
26381, 5133, 586, 587, 5144, 26727, 10529, 10533, 26771
26382, 26727, 10529, 10533, 26771, 26728, 10530, 10534, 26772
26383, 26728, 10530, 10534, 26772, 26729, 10531, 10535, 26773
26384, 26729, 10531, 10535, 26773, 26730, 10532, 10536, 26774
26385, 26730, 10532, 10536, 26774, 10724, 1620, 1621, 10735
26386, 549, 5134, 5145, 550, 10397, 26731, 26775, 10401
26387, 10397, 26731, 26775, 10401, 10398, 26732, 26776, 10402
26388, 10398, 26732, 26776, 10402, 10399, 26733, 26777, 10403
26389, 10399, 26733, 26777, 10403, 10400, 26734, 26778, 10404
26390, 10400, 26734, 26778, 10404, 1579, 10725, 10736, 1580
26391, 5134, 5135, 5146, 5145, 26731, 26735, 26779, 26775
26392, 26731, 26735, 26779, 26775, 26732, 26736, 26780, 26776
26393, 26732, 26736, 26780, 26776, 26733, 26737, 26781, 26777
26394, 26733, 26737, 26781, 26777, 26734, 26738, 26782, 26778
26395, 26734, 26738, 26782, 26778, 10725, 10726, 10737, 10736
26396, 5135, 5136, 5147, 5146, 26735, 26739, 26783, 26779
26397, 26735, 26739, 26783, 26779, 26736, 26740, 26784, 26780
26398, 26736, 26740, 26784, 26780, 26737, 26741, 26785, 26781
26399, 26737, 26741, 26785, 26781, 26738, 26742, 26786, 26782
26400, 26738, 26742, 26786, 26782, 10726, 10727, 10738, 10737
26401, 5136, 5137, 5148, 5147, 26739, 26743, 26787, 26783
26402, 26739, 26743, 26787, 26783, 26740, 26744, 26788, 26784
26403, 26740, 26744, 26788, 26784, 26741, 26745, 26789, 26785
26404, 26741, 26745, 26789, 26785, 26742, 26746, 26790, 26786
26405, 26742, 26746, 26790, 26786, 10727, 10728, 10739, 10738
26406, 5137, 5138, 5149, 5148, 26743, 26747, 26791, 26787
26407, 26743, 26747, 26791, 26787, 26744, 26748, 26792, 26788
26408, 26744, 26748, 26792, 26788, 26745, 26749, 26793, 26789
26409, 26745, 26749, 26793, 26789, 26746, 26750, 26794, 26790
26410, 26746, 26750, 26794, 26790, 10728, 10729, 10740, 10739
26411, 5138, 5139, 5150, 5149, 26747, 26751, 26795, 26791
26412, 26747, 26751, 26795, 26791, 26748, 26752, 26796, 26792
26413, 26748, 26752, 26796, 26792, 26749, 26753, 26797, 26793
26414, 26749, 26753, 26797, 26793, 26750, 26754, 26798, 26794
26415, 26750, 26754, 26798, 26794, 10729, 10730, 10741, 10740
26416, 5139, 5140, 5151, 5150, 26751, 26755, 26799, 26795
26417, 26751, 26755, 26799, 26795, 26752, 26756, 26800, 26796
26418, 26752, 26756, 26800, 26796, 26753, 26757, 26801, 26797
26419, 26753, 26757, 26801, 26797, 26754, 26758, 26802, 26798
26420, 26754, 26758, 26802, 26798, 10730, 10731, 10742, 10741
26421, 5140, 5141, 5152, 5151, 26755, 26759, 26803, 26799
26422, 26755, 26759, 26803, 26799, 26756, 26760, 26804, 26800
26423, 26756, 26760, 26804, 26800, 26757, 26761, 26805, 26801
26424, 26757, 26761, 26805, 26801, 26758, 26762, 26806, 26802
26425, 26758, 26762, 26806, 26802, 10731, 10732, 10743, 10742
26426, 5141, 5142, 5153, 5152, 26759, 26763, 26807, 26803
26427, 26759, 26763, 26807, 26803, 26760, 26764, 26808, 26804
26428, 26760, 26764, 26808, 26804, 26761, 26765, 26809, 26805
26429, 26761, 26765, 26809, 26805, 26762, 26766, 26810, 26806
26430, 26762, 26766, 26810, 26806, 10732, 10733, 10744, 10743
26431, 5142, 5143, 5154, 5153, 26763, 26767, 26811, 26807
26432, 26763, 26767, 26811, 26807, 26764, 26768, 26812, 26808
26433, 26764, 26768, 26812, 26808, 26765, 26769, 26813, 26809
26434, 26765, 26769, 26813, 26809, 26766, 26770, 26814, 26810
26435, 26766, 26770, 26814, 26810, 10733, 10734, 10745, 10744
26436, 5143, 5144, 5155, 5154, 26767, 26771, 26815, 26811
26437, 26767, 26771, 26815, 26811, 26768, 26772, 26816, 26812
26438, 26768, 26772, 26816, 26812, 26769, 26773, 26817, 26813
26439, 26769, 26773, 26817, 26813, 26770, 26774, 26818, 26814
26440, 26770, 26774, 26818, 26814, 10734, 10735, 10746, 10745
26441, 5144, 587, 588, 5155, 26771, 10533, 10537, 26815
26442, 26771, 10533, 10537, 26815, 26772, 10534, 10538, 26816
26443, 26772, 10534, 10538, 26816, 26773, 10535, 10539, 26817
26444, 26773, 10535, 10539, 26817, 26774, 10536, 10540, 26818
26445, 26774, 10536, 10540, 26818, 10735, 1621, 1622, 10746
26446, 550, 5145, 5156, 551, 10401, 26775, 26819, 10405
26447, 10401, 26775, 26819, 10405, 10402, 26776, 26820, 10406
26448, 10402, 26776, 26820, 10406, 10403, 26777, 26821, 10407
26449, 10403, 26777, 26821, 10407, 10404, 26778, 26822, 10408
26450, 10404, 26778, 26822, 10408, 1580, 10736, 10747, 1581
26451, 5145, 5146, 5157, 5156, 26775, 26779, 26823, 26819
26452, 26775, 26779, 26823, 26819, 26776, 26780, 26824, 26820
26453, 26776, 26780, 26824, 26820, 26777, 26781, 26825, 26821
26454, 26777, 26781, 26825, 26821, 26778, 26782, 26826, 26822
26455, 26778, 26782, 26826, 26822, 10736, 10737, 10748, 10747
26456, 5146, 5147, 5158, 5157, 26779, 26783, 26827, 26823
26457, 26779, 26783, 26827, 26823, 26780, 26784, 26828, 26824
26458, 26780, 26784, 26828, 26824, 26781, 26785, 26829, 26825
26459, 26781, 26785, 26829, 26825, 26782, 26786, 26830, 26826
26460, 26782, 26786, 26830, 26826, 10737, 10738, 10749, 10748
26461, 5147, 5148, 5159, 5158, 26783, 26787, 26831, 26827
26462, 26783, 26787, 26831, 26827, 26784, 26788, 26832, 26828
26463, 26784, 26788, 26832, 26828, 26785, 26789, 26833, 26829
26464, 26785, 26789, 26833, 26829, 26786, 26790, 26834, 26830
26465, 26786, 26790, 26834, 26830, 10738, 10739, 10750, 10749
26466, 5148, 5149, 5160, 5159, 26787, 26791, 26835, 26831
26467, 26787, 26791, 26835, 26831, 26788, 26792, 26836, 26832
26468, 26788, 26792, 26836, 26832, 26789, 26793, 26837, 26833
26469, 26789, 26793, 26837, 26833, 26790, 26794, 26838, 26834
26470, 26790, 26794, 26838, 26834, 10739, 10740, 10751, 10750
26471, 5149, 5150, 5161, 5160, 26791, 26795, 26839, 26835
26472, 26791, 26795, 26839, 26835, 26792, 26796, 26840, 26836
26473, 26792, 26796, 26840, 26836, 26793, 26797, 26841, 26837
26474, 26793, 26797, 26841, 26837, 26794, 26798, 26842, 26838
26475, 26794, 26798, 26842, 26838, 10740, 10741, 10752, 10751
26476, 5150, 5151, 5162, 5161, 26795, 26799, 26843, 26839
26477, 26795, 26799, 26843, 26839, 26796, 26800, 26844, 26840
26478, 26796, 26800, 26844, 26840, 26797, 26801, 26845, 26841
26479, 26797, 26801, 26845, 26841, 26798, 26802, 26846, 26842
26480, 26798, 26802, 26846, 26842, 10741, 10742, 10753, 10752
26481, 5151, 5152, 5163, 5162, 26799, 26803, 26847, 26843
26482, 26799, 26803, 26847, 26843, 26800, 26804, 26848, 26844
26483, 26800, 26804, 26848, 26844, 26801, 26805, 26849, 26845
26484, 26801, 26805, 26849, 26845, 26802, 26806, 26850, 26846
26485, 26802, 26806, 26850, 26846, 10742, 10743, 10754, 10753
26486, 5152, 5153, 5164, 5163, 26803, 26807, 26851, 26847
26487, 26803, 26807, 26851, 26847, 26804, 26808, 26852, 26848
26488, 26804, 26808, 26852, 26848, 26805, 26809, 26853, 26849
26489, 26805, 26809, 26853, 26849, 26806, 26810, 26854, 26850
26490, 26806, 26810, 26854, 26850, 10743, 10744, 10755, 10754
26491, 5153, 5154, 5165, 5164, 26807, 26811, 26855, 26851
26492, 26807, 26811, 26855, 26851, 26808, 26812, 26856, 26852
26493, 26808, 26812, 26856, 26852, 26809, 26813, 26857, 26853
26494, 26809, 26813, 26857, 26853, 26810, 26814, 26858, 26854
26495, 26810, 26814, 26858, 26854, 10744, 10745, 10756, 10755
26496, 5154, 5155, 5166, 5165, 26811, 26815, 26859, 26855
26497, 26811, 26815, 26859, 26855, 26812, 26816, 26860, 26856
26498, 26812, 26816, 26860, 26856, 26813, 26817, 26861, 26857
26499, 26813, 26817, 26861, 26857, 26814, 26818, 26862, 26858
26500, 26814, 26818, 26862, 26858, 10745, 10746, 10757, 10756
26501, 5155, 588, 589, 5166, 26815, 10537, 10541, 26859
26502, 26815, 10537, 10541, 26859, 26816, 10538, 10542, 26860
26503, 26816, 10538, 10542, 26860, 26817, 10539, 10543, 26861
26504, 26817, 10539, 10543, 26861, 26818, 10540, 10544, 26862
26505, 26818, 10540, 10544, 26862, 10746, 1622, 1623, 10757
26506, 551, 5156, 5167, 552, 10405, 26819, 26863, 10409
26507, 10405, 26819, 26863, 10409, 10406, 26820, 26864, 10410
26508, 10406, 26820, 26864, 10410, 10407, 26821, 26865, 10411
26509, 10407, 26821, 26865, 10411, 10408, 26822, 26866, 10412
26510, 10408, 26822, 26866, 10412, 1581, 10747, 10758, 1582
26511, 5156, 5157, 5168, 5167, 26819, 26823, 26867, 26863
26512, 26819, 26823, 26867, 26863, 26820, 26824, 26868, 26864
26513, 26820, 26824, 26868, 26864, 26821, 26825, 26869, 26865
26514, 26821, 26825, 26869, 26865, 26822, 26826, 26870, 26866
26515, 26822, 26826, 26870, 26866, 10747, 10748, 10759, 10758
26516, 5157, 5158, 5169, 5168, 26823, 26827, 26871, 26867
26517, 26823, 26827, 26871, 26867, 26824, 26828, 26872, 26868
26518, 26824, 26828, 26872, 26868, 26825, 26829, 26873, 26869
26519, 26825, 26829, 26873, 26869, 26826, 26830, 26874, 26870
26520, 26826, 26830, 26874, 26870, 10748, 10749, 10760, 10759
26521, 5158, 5159, 5170, 5169, 26827, 26831, 26875, 26871
26522, 26827, 26831, 26875, 26871, 26828, 26832, 26876, 26872
26523, 26828, 26832, 26876, 26872, 26829, 26833, 26877, 26873
26524, 26829, 26833, 26877, 26873, 26830, 26834, 26878, 26874
26525, 26830, 26834, 26878, 26874, 10749, 10750, 10761, 10760
26526, 5159, 5160, 5171, 5170, 26831, 26835, 26879, 26875
26527, 26831, 26835, 26879, 26875, 26832, 26836, 26880, 26876
26528, 26832, 26836, 26880, 26876, 26833, 26837, 26881, 26877
26529, 26833, 26837, 26881, 26877, 26834, 26838, 26882, 26878
26530, 26834, 26838, 26882, 26878, 10750, 10751, 10762, 10761
26531, 5160, 5161, 5172, 5171, 26835, 26839, 26883, 26879
26532, 26835, 26839, 26883, 26879, 26836, 26840, 26884, 26880
26533, 26836, 26840, 26884, 26880, 26837, 26841, 26885, 26881
26534, 26837, 26841, 26885, 26881, 26838, 26842, 26886, 26882
26535, 26838, 26842, 26886, 26882, 10751, 10752, 10763, 10762
26536, 5161, 5162, 5173, 5172, 26839, 26843, 26887, 26883
26537, 26839, 26843, 26887, 26883, 26840, 26844, 26888, 26884
26538, 26840, 26844, 26888, 26884, 26841, 26845, 26889, 26885
26539, 26841, 26845, 26889, 26885, 26842, 26846, 26890, 26886
26540, 26842, 26846, 26890, 26886, 10752, 10753, 10764, 10763
26541, 5162, 5163, 5174, 5173, 26843, 26847, 26891, 26887
26542, 26843, 26847, 26891, 26887, 26844, 26848, 26892, 26888
26543, 26844, 26848, 26892, 26888, 26845, 26849, 26893, 26889
26544, 26845, 26849, 26893, 26889, 26846, 26850, 26894, 26890
26545, 26846, 26850, 26894, 26890, 10753, 10754, 10765, 10764
26546, 5163, 5164, 5175, 5174, 26847, 26851, 26895, 26891
26547, 26847, 26851, 26895, 26891, 26848, 26852, 26896, 26892
26548, 26848, 26852, 26896, 26892, 26849, 26853, 26897, 26893
26549, 26849, 26853, 26897, 26893, 26850, 26854, 26898, 26894
26550, 26850, 26854, 26898, 26894, 10754, 10755, 10766, 10765
26551, 5164, 5165, 5176, 5175, 26851, 26855, 26899, 26895
26552, 26851, 26855, 26899, 26895, 26852, 26856, 26900, 26896
26553, 26852, 26856, 26900, 26896, 26853, 26857, 26901, 26897
26554, 26853, 26857, 26901, 26897, 26854, 26858, 26902, 26898
26555, 26854, 26858, 26902, 26898, 10755, 10756, 10767, 10766
26556, 5165, 5166, 5177, 5176, 26855, 26859, 26903, 26899
26557, 26855, 26859, 26903, 26899, 26856, 26860, 26904, 26900
26558, 26856, 26860, 26904, 26900, 26857, 26861, 26905, 26901
26559, 26857, 26861, 26905, 26901, 26858, 26862, 26906, 26902
26560, 26858, 26862, 26906, 26902, 10756, 10757, 10768, 10767
26561, 5166, 589, 590, 5177, 26859, 10541, 10545, 26903
26562, 26859, 10541, 10545, 26903, 26860, 10542, 10546, 26904
26563, 26860, 10542, 10546, 26904, 26861, 10543, 10547, 26905
26564, 26861, 10543, 10547, 26905, 26862, 10544, 10548, 26906
26565, 26862, 10544, 10548, 26906, 10757, 1623, 1624, 10768
26566, 552, 5167, 5178, 553, 10409, 26863, 26907, 10413
26567, 10409, 26863, 26907, 10413, 10410, 26864, 26908, 10414
26568, 10410, 26864, 26908, 10414, 10411, 26865, 26909, 10415
26569, 10411, 26865, 26909, 10415, 10412, 26866, 26910, 10416
26570, 10412, 26866, 26910, 10416, 1582, 10758, 10769, 1583
26571, 5167, 5168, 5179, 5178, 26863, 26867, 26911, 26907
26572, 26863, 26867, 26911, 26907, 26864, 26868, 26912, 26908
26573, 26864, 26868, 26912, 26908, 26865, 26869, 26913, 26909
26574, 26865, 26869, 26913, 26909, 26866, 26870, 26914, 26910
26575, 26866, 26870, 26914, 26910, 10758, 10759, 10770, 10769
26576, 5168, 5169, 5180, 5179, 26867, 26871, 26915, 26911
26577, 26867, 26871, 26915, 26911, 26868, 26872, 26916, 26912
26578, 26868, 26872, 26916, 26912, 26869, 26873, 26917, 26913
26579, 26869, 26873, 26917, 26913, 26870, 26874, 26918, 26914
26580, 26870, 26874, 26918, 26914, 10759, 10760, 10771, 10770
26581, 5169, 5170, 5181, 5180, 26871, 26875, 26919, 26915
26582, 26871, 26875, 26919, 26915, 26872, 26876, 26920, 26916
26583, 26872, 26876, 26920, 26916, 26873, 26877, 26921, 26917
26584, 26873, 26877, 26921, 26917, 26874, 26878, 26922, 26918
26585, 26874, 26878, 26922, 26918, 10760, 10761, 10772, 10771
26586, 5170, 5171, 5182, 5181, 26875, 26879, 26923, 26919
26587, 26875, 26879, 26923, 26919, 26876, 26880, 26924, 26920
26588, 26876, 26880, 26924, 26920, 26877, 26881, 26925, 26921
26589, 26877, 26881, 26925, 26921, 26878, 26882, 26926, 26922
26590, 26878, 26882, 26926, 26922, 10761, 10762, 10773, 10772
26591, 5171, 5172, 5183, 5182, 26879, 26883, 26927, 26923
26592, 26879, 26883, 26927, 26923, 26880, 26884, 26928, 26924
26593, 26880, 26884, 26928, 26924, 26881, 26885, 26929, 26925
26594, 26881, 26885, 26929, 26925, 26882, 26886, 26930, 26926
26595, 26882, 26886, 26930, 26926, 10762, 10763, 10774, 10773
26596, 5172, 5173, 5184, 5183, 26883, 26887, 26931, 26927
26597, 26883, 26887, 26931, 26927, 26884, 26888, 26932, 26928
26598, 26884, 26888, 26932, 26928, 26885, 26889, 26933, 26929
26599, 26885, 26889, 26933, 26929, 26886, 26890, 26934, 26930
26600, 26886, 26890, 26934, 26930, 10763, 10764, 10775, 10774
26601, 5173, 5174, 5185, 5184, 26887, 26891, 26935, 26931
26602, 26887, 26891, 26935, 26931, 26888, 26892, 26936, 26932
26603, 26888, 26892, 26936, 26932, 26889, 26893, 26937, 26933
26604, 26889, 26893, 26937, 26933, 26890, 26894, 26938, 26934
26605, 26890, 26894, 26938, 26934, 10764, 10765, 10776, 10775
26606, 5174, 5175, 5186, 5185, 26891, 26895, 26939, 26935
26607, 26891, 26895, 26939, 26935, 26892, 26896, 26940, 26936
26608, 26892, 26896, 26940, 26936, 26893, 26897, 26941, 26937
26609, 26893, 26897, 26941, 26937, 26894, 26898, 26942, 26938
26610, 26894, 26898, 26942, 26938, 10765, 10766, 10777, 10776
26611, 5175, 5176, 5187, 5186, 26895, 26899, 26943, 26939
26612, 26895, 26899, 26943, 26939, 26896, 26900, 26944, 26940
26613, 26896, 26900, 26944, 26940, 26897, 26901, 26945, 26941
26614, 26897, 26901, 26945, 26941, 26898, 26902, 26946, 26942
26615, 26898, 26902, 26946, 26942, 10766, 10767, 10778, 10777
26616, 5176, 5177, 5188, 5187, 26899, 26903, 26947, 26943
26617, 26899, 26903, 26947, 26943, 26900, 26904, 26948, 26944
26618, 26900, 26904, 26948, 26944, 26901, 26905, 26949, 26945
26619, 26901, 26905, 26949, 26945, 26902, 26906, 26950, 26946
26620, 26902, 26906, 26950, 26946, 10767, 10768, 10779, 10778
26621, 5177, 590, 591, 5188, 26903, 10545, 10549, 26947
26622, 26903, 10545, 10549, 26947, 26904, 10546, 10550, 26948
26623, 26904, 10546, 10550, 26948, 26905, 10547, 10551, 26949
26624, 26905, 10547, 10551, 26949, 26906, 10548, 10552, 26950
26625, 26906, 10548, 10552, 26950, 10768, 1624, 1625, 10779
26626, 553, 5178, 5189, 554, 10413, 26907, 26951, 10417
26627, 10413, 26907, 26951, 10417, 10414, 26908, 26952, 10418
26628, 10414, 26908, 26952, 10418, 10415, 26909, 26953, 10419
26629, 10415, 26909, 26953, 10419, 10416, 26910, 26954, 10420
26630, 10416, 26910, 26954, 10420, 1583, 10769, 10780, 1584
26631, 5178, 5179, 5190, 5189, 26907, 26911, 26955, 26951
26632, 26907, 26911, 26955, 26951, 26908, 26912, 26956, 26952
26633, 26908, 26912, 26956, 26952, 26909, 26913, 26957, 26953
26634, 26909, 26913, 26957, 26953, 26910, 26914, 26958, 26954
26635, 26910, 26914, 26958, 26954, 10769, 10770, 10781, 10780
26636, 5179, 5180, 5191, 5190, 26911, 26915, 26959, 26955
26637, 26911, 26915, 26959, 26955, 26912, 26916, 26960, 26956
26638, 26912, 26916, 26960, 26956, 26913, 26917, 26961, 26957
26639, 26913, 26917, 26961, 26957, 26914, 26918, 26962, 26958
26640, 26914, 26918, 26962, 26958, 10770, 10771, 10782, 10781
26641, 5180, 5181, 5192, 5191, 26915, 26919, 26963, 26959
26642, 26915, 26919, 26963, 26959, 26916, 26920, 26964, 26960
26643, 26916, 26920, 26964, 26960, 26917, 26921, 26965, 26961
26644, 26917, 26921, 26965, 26961, 26918, 26922, 26966, 26962
26645, 26918, 26922, 26966, 26962, 10771, 10772, 10783, 10782
26646, 5181, 5182, 5193, 5192, 26919, 26923, 26967, 26963
26647, 26919, 26923, 26967, 26963, 26920, 26924, 26968, 26964
26648, 26920, 26924, 26968, 26964, 26921, 26925, 26969, 26965
26649, 26921, 26925, 26969, 26965, 26922, 26926, 26970, 26966
26650, 26922, 26926, 26970, 26966, 10772, 10773, 10784, 10783
26651, 5182, 5183, 5194, 5193, 26923, 26927, 26971, 26967
26652, 26923, 26927, 26971, 26967, 26924, 26928, 26972, 26968
26653, 26924, 26928, 26972, 26968, 26925, 26929, 26973, 26969
26654, 26925, 26929, 26973, 26969, 26926, 26930, 26974, 26970
26655, 26926, 26930, 26974, 26970, 10773, 10774, 10785, 10784
26656, 5183, 5184, 5195, 5194, 26927, 26931, 26975, 26971
26657, 26927, 26931, 26975, 26971, 26928, 26932, 26976, 26972
26658, 26928, 26932, 26976, 26972, 26929, 26933, 26977, 26973
26659, 26929, 26933, 26977, 26973, 26930, 26934, 26978, 26974
26660, 26930, 26934, 26978, 26974, 10774, 10775, 10786, 10785
26661, 5184, 5185, 5196, 5195, 26931, 26935, 26979, 26975
26662, 26931, 26935, 26979, 26975, 26932, 26936, 26980, 26976
26663, 26932, 26936, 26980, 26976, 26933, 26937, 26981, 26977
26664, 26933, 26937, 26981, 26977, 26934, 26938, 26982, 26978
26665, 26934, 26938, 26982, 26978, 10775, 10776, 10787, 10786
26666, 5185, 5186, 5197, 5196, 26935, 26939, 26983, 26979
26667, 26935, 26939, 26983, 26979, 26936, 26940, 26984, 26980
26668, 26936, 26940, 26984, 26980, 26937, 26941, 26985, 26981
26669, 26937, 26941, 26985, 26981, 26938, 26942, 26986, 26982
26670, 26938, 26942, 26986, 26982, 10776, 10777, 10788, 10787
26671, 5186, 5187, 5198, 5197, 26939, 26943, 26987, 26983
26672, 26939, 26943, 26987, 26983, 26940, 26944, 26988, 26984
26673, 26940, 26944, 26988, 26984, 26941, 26945, 26989, 26985
26674, 26941, 26945, 26989, 26985, 26942, 26946, 26990, 26986
26675, 26942, 26946, 26990, 26986, 10777, 10778, 10789, 10788
26676, 5187, 5188, 5199, 5198, 26943, 26947, 26991, 26987
26677, 26943, 26947, 26991, 26987, 26944, 26948, 26992, 26988
26678, 26944, 26948, 26992, 26988, 26945, 26949, 26993, 26989
26679, 26945, 26949, 26993, 26989, 26946, 26950, 26994, 26990
26680, 26946, 26950, 26994, 26990, 10778, 10779, 10790, 10789
26681, 5188, 591, 592, 5199, 26947, 10549, 10553, 26991
26682, 26947, 10549, 10553, 26991, 26948, 10550, 10554, 26992
26683, 26948, 10550, 10554, 26992, 26949, 10551, 10555, 26993
26684, 26949, 10551, 10555, 26993, 26950, 10552, 10556, 26994
26685, 26950, 10552, 10556, 26994, 10779, 1625, 1626, 10790
26686, 554, 5189, 5200, 555, 10417, 26951, 26995, 10421
26687, 10417, 26951, 26995, 10421, 10418, 26952, 26996, 10422
26688, 10418, 26952, 26996, 10422, 10419, 26953, 26997, 10423
26689, 10419, 26953, 26997, 10423, 10420, 26954, 26998, 10424
26690, 10420, 26954, 26998, 10424, 1584, 10780, 10791, 1585
26691, 5189, 5190, 5201, 5200, 26951, 26955, 26999, 26995
26692, 26951, 26955, 26999, 26995, 26952, 26956, 27000, 26996
26693, 26952, 26956, 27000, 26996, 26953, 26957, 27001, 26997
26694, 26953, 26957, 27001, 26997, 26954, 26958, 27002, 26998
26695, 26954, 26958, 27002, 26998, 10780, 10781, 10792, 10791
26696, 5190, 5191, 5202, 5201, 26955, 26959, 27003, 26999
26697, 26955, 26959, 27003, 26999, 26956, 26960, 27004, 27000
26698, 26956, 26960, 27004, 27000, 26957, 26961, 27005, 27001
26699, 26957, 26961, 27005, 27001, 26958, 26962, 27006, 27002
26700, 26958, 26962, 27006, 27002, 10781, 10782, 10793, 10792
26701, 5191, 5192, 5203, 5202, 26959, 26963, 27007, 27003
26702, 26959, 26963, 27007, 27003, 26960, 26964, 27008, 27004
26703, 26960, 26964, 27008, 27004, 26961, 26965, 27009, 27005
26704, 26961, 26965, 27009, 27005, 26962, 26966, 27010, 27006
26705, 26962, 26966, 27010, 27006, 10782, 10783, 10794, 10793
26706, 5192, 5193, 5204, 5203, 26963, 26967, 27011, 27007
26707, 26963, 26967, 27011, 27007, 26964, 26968, 27012, 27008
26708, 26964, 26968, 27012, 27008, 26965, 26969, 27013, 27009
26709, 26965, 26969, 27013, 27009, 26966, 26970, 27014, 27010
26710, 26966, 26970, 27014, 27010, 10783, 10784, 10795, 10794
26711, 5193, 5194, 5205, 5204, 26967, 26971, 27015, 27011
26712, 26967, 26971, 27015, 27011, 26968, 26972, 27016, 27012
26713, 26968, 26972, 27016, 27012, 26969, 26973, 27017, 27013
26714, 26969, 26973, 27017, 27013, 26970, 26974, 27018, 27014
26715, 26970, 26974, 27018, 27014, 10784, 10785, 10796, 10795
26716, 5194, 5195, 5206, 5205, 26971, 26975, 27019, 27015
26717, 26971, 26975, 27019, 27015, 26972, 26976, 27020, 27016
26718, 26972, 26976, 27020, 27016, 26973, 26977, 27021, 27017
26719, 26973, 26977, 27021, 27017, 26974, 26978, 27022, 27018
26720, 26974, 26978, 27022, 27018, 10785, 10786, 10797, 10796
26721, 5195, 5196, 5207, 5206, 26975, 26979, 27023, 27019
26722, 26975, 26979, 27023, 27019, 26976, 26980, 27024, 27020
26723, 26976, 26980, 27024, 27020, 26977, 26981, 27025, 27021
26724, 26977, 26981, 27025, 27021, 26978, 26982, 27026, 27022
26725, 26978, 26982, 27026, 27022, 10786, 10787, 10798, 10797
26726, 5196, 5197, 5208, 5207, 26979, 26983, 27027, 27023
26727, 26979, 26983, 27027, 27023, 26980, 26984, 27028, 27024
26728, 26980, 26984, 27028, 27024, 26981, 26985, 27029, 27025
26729, 26981, 26985, 27029, 27025, 26982, 26986, 27030, 27026
26730, 26982, 26986, 27030, 27026, 10787, 10788, 10799, 10798
26731, 5197, 5198, 5209, 5208, 26983, 26987, 27031, 27027
26732, 26983, 26987, 27031, 27027, 26984, 26988, 27032, 27028
26733, 26984, 26988, 27032, 27028, 26985, 26989, 27033, 27029
26734, 26985, 26989, 27033, 27029, 26986, 26990, 27034, 27030
26735, 26986, 26990, 27034, 27030, 10788, 10789, 10800, 10799
26736, 5198, 5199, 5210, 5209, 26987, 26991, 27035, 27031
26737, 26987, 26991, 27035, 27031, 26988, 26992, 27036, 27032
26738, 26988, 26992, 27036, 27032, 26989, 26993, 27037, 27033
26739, 26989, 26993, 27037, 27033, 26990, 26994, 27038, 27034
26740, 26990, 26994, 27038, 27034, 10789, 10790, 10801, 10800
26741, 5199, 592, 593, 5210, 26991, 10553, 10557, 27035
26742, 26991, 10553, 10557, 27035, 26992, 10554, 10558, 27036
26743, 26992, 10554, 10558, 27036, 26993, 10555, 10559, 27037
26744, 26993, 10555, 10559, 27037, 26994, 10556, 10560, 27038
26745, 26994, 10556, 10560, 27038, 10790, 1626, 1627, 10801
26746, 555, 5200, 5211, 556, 10421, 26995, 27039, 10425
26747, 10421, 26995, 27039, 10425, 10422, 26996, 27040, 10426
26748, 10422, 26996, 27040, 10426, 10423, 26997, 27041, 10427
26749, 10423, 26997, 27041, 10427, 10424, 26998, 27042, 10428
26750, 10424, 26998, 27042, 10428, 1585, 10791, 10802, 1586
26751, 5200, 5201, 5212, 5211, 26995, 26999, 27043, 27039
26752, 26995, 26999, 27043, 27039, 26996, 27000, 27044, 27040
26753, 26996, 27000, 27044, 27040, 26997, 27001, 27045, 27041
26754, 26997, 27001, 27045, 27041, 26998, 27002, 27046, 27042
26755, 26998, 27002, 27046, 27042, 10791, 10792, 10803, 10802
26756, 5201, 5202, 5213, 5212, 26999, 27003, 27047, 27043
26757, 26999, 27003, 27047, 27043, 27000, 27004, 27048, 27044
26758, 27000, 27004, 27048, 27044, 27001, 27005, 27049, 27045
26759, 27001, 27005, 27049, 27045, 27002, 27006, 27050, 27046
26760, 27002, 27006, 27050, 27046, 10792, 10793, 10804, 10803
26761, 5202, 5203, 5214, 5213, 27003, 27007, 27051, 27047
26762, 27003, 27007, 27051, 27047, 27004, 27008, 27052, 27048
26763, 27004, 27008, 27052, 27048, 27005, 27009, 27053, 27049
26764, 27005, 27009, 27053, 27049, 27006, 27010, 27054, 27050
26765, 27006, 27010, 27054, 27050, 10793, 10794, 10805, 10804
26766, 5203, 5204, 5215, 5214, 27007, 27011, 27055, 27051
26767, 27007, 27011, 27055, 27051, 27008, 27012, 27056, 27052
26768, 27008, 27012, 27056, 27052, 27009, 27013, 27057, 27053
26769, 27009, 27013, 27057, 27053, 27010, 27014, 27058, 27054
26770, 27010, 27014, 27058, 27054, 10794, 10795, 10806, 10805
26771, 5204, 5205, 5216, 5215, 27011, 27015, 27059, 27055
26772, 27011, 27015, 27059, 27055, 27012, 27016, 27060, 27056
26773, 27012, 27016, 27060, 27056, 27013, 27017, 27061, 27057
26774, 27013, 27017, 27061, 27057, 27014, 27018, 27062, 27058
26775, 27014, 27018, 27062, 27058, 10795, 10796, 10807, 10806
26776, 5205, 5206, 5217, 5216, 27015, 27019, 27063, 27059
26777, 27015, 27019, 27063, 27059, 27016, 27020, 27064, 27060
26778, 27016, 27020, 27064, 27060, 27017, 27021, 27065, 27061
26779, 27017, 27021, 27065, 27061, 27018, 27022, 27066, 27062
26780, 27018, 27022, 27066, 27062, 10796, 10797, 10808, 10807
26781, 5206, 5207, 5218, 5217, 27019, 27023, 27067, 27063
26782, 27019, 27023, 27067, 27063, 27020, 27024, 27068, 27064
26783, 27020, 27024, 27068, 27064, 27021, 27025, 27069, 27065
26784, 27021, 27025, 27069, 27065, 27022, 27026, 27070, 27066
26785, 27022, 27026, 27070, 27066, 10797, 10798, 10809, 10808
26786, 5207, 5208, 5219, 5218, 27023, 27027, 27071, 27067
26787, 27023, 27027, 27071, 27067, 27024, 27028, 27072, 27068
26788, 27024, 27028, 27072, 27068, 27025, 27029, 27073, 27069
26789, 27025, 27029, 27073, 27069, 27026, 27030, 27074, 27070
26790, 27026, 27030, 27074, 27070, 10798, 10799, 10810, 10809
26791, 5208, 5209, 5220, 5219, 27027, 27031, 27075, 27071
26792, 27027, 27031, 27075, 27071, 27028, 27032, 27076, 27072
26793, 27028, 27032, 27076, 27072, 27029, 27033, 27077, 27073
26794, 27029, 27033, 27077, 27073, 27030, 27034, 27078, 27074
26795, 27030, 27034, 27078, 27074, 10799, 10800, 10811, 10810
26796, 5209, 5210, 5221, 5220, 27031, 27035, 27079, 27075
26797, 27031, 27035, 27079, 27075, 27032, 27036, 27080, 27076
26798, 27032, 27036, 27080, 27076, 27033, 27037, 27081, 27077
26799, 27033, 27037, 27081, 27077, 27034, 27038, 27082, 27078
26800, 27034, 27038, 27082, 27078, 10800, 10801, 10812, 10811
26801, 5210, 593, 594, 5221, 27035, 10557, 10561, 27079
26802, 27035, 10557, 10561, 27079, 27036, 10558, 10562, 27080
26803, 27036, 10558, 10562, 27080, 27037, 10559, 10563, 27081
26804, 27037, 10559, 10563, 27081, 27038, 10560, 10564, 27082
26805, 27038, 10560, 10564, 27082, 10801, 1627, 1628, 10812
26806, 556, 5211, 5222, 557, 10425, 27039, 27083, 10429
26807, 10425, 27039, 27083, 10429, 10426, 27040, 27084, 10430
26808, 10426, 27040, 27084, 10430, 10427, 27041, 27085, 10431
26809, 10427, 27041, 27085, 10431, 10428, 27042, 27086, 10432
26810, 10428, 27042, 27086, 10432, 1586, 10802, 10813, 1587
26811, 5211, 5212, 5223, 5222, 27039, 27043, 27087, 27083
26812, 27039, 27043, 27087, 27083, 27040, 27044, 27088, 27084
26813, 27040, 27044, 27088, 27084, 27041, 27045, 27089, 27085
26814, 27041, 27045, 27089, 27085, 27042, 27046, 27090, 27086
26815, 27042, 27046, 27090, 27086, 10802, 10803, 10814, 10813
26816, 5212, 5213, 5224, 5223, 27043, 27047, 27091, 27087
26817, 27043, 27047, 27091, 27087, 27044, 27048, 27092, 27088
26818, 27044, 27048, 27092, 27088, 27045, 27049, 27093, 27089
26819, 27045, 27049, 27093, 27089, 27046, 27050, 27094, 27090
26820, 27046, 27050, 27094, 27090, 10803, 10804, 10815, 10814
26821, 5213, 5214, 5225, 5224, 27047, 27051, 27095, 27091
26822, 27047, 27051, 27095, 27091, 27048, 27052, 27096, 27092
26823, 27048, 27052, 27096, 27092, 27049, 27053, 27097, 27093
26824, 27049, 27053, 27097, 27093, 27050, 27054, 27098, 27094
26825, 27050, 27054, 27098, 27094, 10804, 10805, 10816, 10815
26826, 5214, 5215, 5226, 5225, 27051, 27055, 27099, 27095
26827, 27051, 27055, 27099, 27095, 27052, 27056, 27100, 27096
26828, 27052, 27056, 27100, 27096, 27053, 27057, 27101, 27097
26829, 27053, 27057, 27101, 27097, 27054, 27058, 27102, 27098
26830, 27054, 27058, 27102, 27098, 10805, 10806, 10817, 10816
26831, 5215, 5216, 5227, 5226, 27055, 27059, 27103, 27099
26832, 27055, 27059, 27103, 27099, 27056, 27060, 27104, 27100
26833, 27056, 27060, 27104, 27100, 27057, 27061, 27105, 27101
26834, 27057, 27061, 27105, 27101, 27058, 27062, 27106, 27102
26835, 27058, 27062, 27106, 27102, 10806, 10807, 10818, 10817
26836, 5216, 5217, 5228, 5227, 27059, 27063, 27107, 27103
26837, 27059, 27063, 27107, 27103, 27060, 27064, 27108, 27104
26838, 27060, 27064, 27108, 27104, 27061, 27065, 27109, 27105
26839, 27061, 27065, 27109, 27105, 27062, 27066, 27110, 27106
26840, 27062, 27066, 27110, 27106, 10807, 10808, 10819, 10818
26841, 5217, 5218, 5229, 5228, 27063, 27067, 27111, 27107
26842, 27063, 27067, 27111, 27107, 27064, 27068, 27112, 27108
26843, 27064, 27068, 27112, 27108, 27065, 27069, 27113, 27109
26844, 27065, 27069, 27113, 27109, 27066, 27070, 27114, 27110
26845, 27066, 27070, 27114, 27110, 10808, 10809, 10820, 10819
26846, 5218, 5219, 5230, 5229, 27067, 27071, 27115, 27111
26847, 27067, 27071, 27115, 27111, 27068, 27072, 27116, 27112
26848, 27068, 27072, 27116, 27112, 27069, 27073, 27117, 27113
26849, 27069, 27073, 27117, 27113, 27070, 27074, 27118, 27114
26850, 27070, 27074, 27118, 27114, 10809, 10810, 10821, 10820
26851, 5219, 5220, 5231, 5230, 27071, 27075, 27119, 27115
26852, 27071, 27075, 27119, 27115, 27072, 27076, 27120, 27116
26853, 27072, 27076, 27120, 27116, 27073, 27077, 27121, 27117
26854, 27073, 27077, 27121, 27117, 27074, 27078, 27122, 27118
26855, 27074, 27078, 27122, 27118, 10810, 10811, 10822, 10821
26856, 5220, 5221, 5232, 5231, 27075, 27079, 27123, 27119
26857, 27075, 27079, 27123, 27119, 27076, 27080, 27124, 27120
26858, 27076, 27080, 27124, 27120, 27077, 27081, 27125, 27121
26859, 27077, 27081, 27125, 27121, 27078, 27082, 27126, 27122
26860, 27078, 27082, 27126, 27122, 10811, 10812, 10823, 10822
26861, 5221, 594, 595, 5232, 27079, 10561, 10565, 27123
26862, 27079, 10561, 10565, 27123, 27080, 10562, 10566, 27124
26863, 27080, 10562, 10566, 27124, 27081, 10563, 10567, 27125
26864, 27081, 10563, 10567, 27125, 27082, 10564, 10568, 27126
26865, 27082, 10564, 10568, 27126, 10812, 1628, 1629, 10823
26866, 557, 5222, 5233, 558, 10429, 27083, 27127, 10433
26867, 10429, 27083, 27127, 10433, 10430, 27084, 27128, 10434
26868, 10430, 27084, 27128, 10434, 10431, 27085, 27129, 10435
26869, 10431, 27085, 27129, 10435, 10432, 27086, 27130, 10436
26870, 10432, 27086, 27130, 10436, 1587, 10813, 10824, 1588
26871, 5222, 5223, 5234, 5233, 27083, 27087, 27131, 27127
26872, 27083, 27087, 27131, 27127, 27084, 27088, 27132, 27128
26873, 27084, 27088, 27132, 27128, 27085, 27089, 27133, 27129
26874, 27085, 27089, 27133, 27129, 27086, 27090, 27134, 27130
26875, 27086, 27090, 27134, 27130, 10813, 10814, 10825, 10824
26876, 5223, 5224, 5235, 5234, 27087, 27091, 27135, 27131
26877, 27087, 27091, 27135, 27131, 27088, 27092, 27136, 27132
26878, 27088, 27092, 27136, 27132, 27089, 27093, 27137, 27133
26879, 27089, 27093, 27137, 27133, 27090, 27094, 27138, 27134
26880, 27090, 27094, 27138, 27134, 10814, 10815, 10826, 10825
26881, 5224, 5225, 5236, 5235, 27091, 27095, 27139, 27135
26882, 27091, 27095, 27139, 27135, 27092, 27096, 27140, 27136
26883, 27092, 27096, 27140, 27136, 27093, 27097, 27141, 27137
26884, 27093, 27097, 27141, 27137, 27094, 27098, 27142, 27138
26885, 27094, 27098, 27142, 27138, 10815, 10816, 10827, 10826
26886, 5225, 5226, 5237, 5236, 27095, 27099, 27143, 27139
26887, 27095, 27099, 27143, 27139, 27096, 27100, 27144, 27140
26888, 27096, 27100, 27144, 27140, 27097, 27101, 27145, 27141
26889, 27097, 27101, 27145, 27141, 27098, 27102, 27146, 27142
26890, 27098, 27102, 27146, 27142, 10816, 10817, 10828, 10827
26891, 5226, 5227, 5238, 5237, 27099, 27103, 27147, 27143
26892, 27099, 27103, 27147, 27143, 27100, 27104, 27148, 27144
26893, 27100, 27104, 27148, 27144, 27101, 27105, 27149, 27145
26894, 27101, 27105, 27149, 27145, 27102, 27106, 27150, 27146
26895, 27102, 27106, 27150, 27146, 10817, 10818, 10829, 10828
26896, 5227, 5228, 5239, 5238, 27103, 27107, 27151, 27147
26897, 27103, 27107, 27151, 27147, 27104, 27108, 27152, 27148
26898, 27104, 27108, 27152, 27148, 27105, 27109, 27153, 27149
26899, 27105, 27109, 27153, 27149, 27106, 27110, 27154, 27150
26900, 27106, 27110, 27154, 27150, 10818, 10819, 10830, 10829
26901, 5228, 5229, 5240, 5239, 27107, 27111, 27155, 27151
26902, 27107, 27111, 27155, 27151, 27108, 27112, 27156, 27152
26903, 27108, 27112, 27156, 27152, 27109, 27113, 27157, 27153
26904, 27109, 27113, 27157, 27153, 27110, 27114, 27158, 27154
26905, 27110, 27114, 27158, 27154, 10819, 10820, 10831, 10830
26906, 5229, 5230, 5241, 5240, 27111, 27115, 27159, 27155
26907, 27111, 27115, 27159, 27155, 27112, 27116, 27160, 27156
26908, 27112, 27116, 27160, 27156, 27113, 27117, 27161, 27157
26909, 27113, 27117, 27161, 27157, 27114, 27118, 27162, 27158
26910, 27114, 27118, 27162, 27158, 10820, 10821, 10832, 10831
26911, 5230, 5231, 5242, 5241, 27115, 27119, 27163, 27159
26912, 27115, 27119, 27163, 27159, 27116, 27120, 27164, 27160
26913, 27116, 27120, 27164, 27160, 27117, 27121, 27165, 27161
26914, 27117, 27121, 27165, 27161, 27118, 27122, 27166, 27162
26915, 27118, 27122, 27166, 27162, 10821, 10822, 10833, 10832
26916, 5231, 5232, 5243, 5242, 27119, 27123, 27167, 27163
26917, 27119, 27123, 27167, 27163, 27120, 27124, 27168, 27164
