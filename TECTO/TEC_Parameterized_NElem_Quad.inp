*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Quad.inp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1.2, 0
4, 0, 1.2, 0
5, 1, 1.3, 0
6, 0, 1.3, 0
7, 1.1, 1.2, 0
8, 1.1, 1.3, 0
9, 2.1, 1.2, 0
10, 2.1, 1.3, 0
11, 1.1, 0, 0
12, 2.1, 0, 0
13, 1.1, -0.2, 0
14, 2.1, -0.2, 0
15, 0, -0.2, 0
16, 1, -0.2, 0
17, 2.2, 0, 0
18, 2.2, -0.2, 0
19, -0.1, 0, 0
20, -0.1, -0.2, 0
21, 0, -0.4, 0
22, 1, -0.4, 0
23, -0.1, -0.4, 0
24, 1.1, -0.4, 0
25, 2.1, -0.4, 0
26, 2.2, -0.4, 0
27, 1, 1.5, 0
28, 0, 1.5, 0
29, 1.1, 1.5, 0
30, 2.1, 1.5, 0
31, 0.14285714285714, 0, 0
32, 0.28571428571429, 0, 0
33, 0.42857142857143, 0, 0
34, 0.57142857142857, 0, 0
35, 0.71428571428571, 0, 0
36, 0.85714285714286, 0, 0
37, 1, 0.13333333333333, 0
38, 1, 0.26666666666667, 0
39, 1, 0.4, 0
40, 1, 0.53333333333333, 0
41, 1, 0.66666666666667, 0
42, 1, 0.8, 0
43, 1, 0.93333333333333, 0
44, 1, 1.0666666666667, 0
45, 0.85714285714286, 1.2, 0
46, 0.71428571428571, 1.2, 0
47, 0.57142857142857, 1.2, 0
48, 0.42857142857143, 1.2, 0
49, 0.28571428571429, 1.2, 0
50, 0.14285714285714, 1.2, 0
51, 0, 1.0666666666667, 0
52, 0, 0.93333333333333, 0
53, 0, 0.8, 0
54, 0, 0.66666666666667, 0
55, 0, 0.53333333333333, 0
56, 0, 0.4, 0
57, 0, 0.26666666666667, 0
58, 0, 0.13333333333333, 0
59, 1, 1.25, 0
60, 0, 1.25, 0
61, 0.85714285714286, 1.3, 0
62, 0.71428571428571, 1.3, 0
63, 0.57142857142857, 1.3, 0
64, 0.42857142857143, 1.3, 0
65, 0.28571428571429, 1.3, 0
66, 0.14285714285714, 1.3, 0
67, 1.1, 1.25, 0
68, 1.2428571428571, 1.2, 0
69, 1.3857142857143, 1.2, 0
70, 1.5285714285714, 1.2, 0
71, 1.6714285714286, 1.2, 0
72, 1.8142857142857, 1.2, 0
73, 1.9571428571429, 1.2, 0
74, 1.2428571428571, 1.3, 0
75, 1.3857142857143, 1.3, 0
76, 1.5285714285714, 1.3, 0
77, 1.6714285714286, 1.3, 0
78, 1.8142857142857, 1.3, 0
79, 1.9571428571429, 1.3, 0
80, 2.1, 1.25, 0
81, 1.1, 1.0666666666667, 0
82, 1.1, 0.93333333333333, 0
83, 1.1, 0.8, 0
84, 1.1, 0.66666666666667, 0
85, 1.1, 0.53333333333333, 0
86, 1.1, 0.4, 0
87, 1.1, 0.26666666666667, 0
88, 1.1, 0.13333333333333, 0
89, 2.1, 1.0666666666667, 0
90, 2.1, 0.93333333333333, 0
91, 2.1, 0.8, 0
92, 2.1, 0.66666666666667, 0
93, 2.1, 0.53333333333333, 0
94, 2.1, 0.4, 0
95, 2.1, 0.26666666666667, 0
96, 2.1, 0.13333333333333, 0
97, 1.2428571428571, 0, 0
98, 1.3857142857143, 0, 0
99, 1.5285714285714, 0, 0
100, 1.6714285714286, 0, 0
101, 1.8142857142857, 0, 0
102, 1.9571428571429, 0, 0
103, 1.1, -0.1, 0
104, 2.1, -0.1, 0
105, 1.2428571428571, -0.2, 0
106, 1.3857142857143, -0.2, 0
107, 1.5285714285714, -0.2, 0
108, 1.6714285714286, -0.2, 0
109, 1.8142857142857, -0.2, 0
110, 1.9571428571429, -0.2, 0
111, 0, -0.1, 0
112, 1, -0.1, 0
113, 0.14285714285714, -0.2, 0
114, 0.28571428571429, -0.2, 0
115, 0.42857142857143, -0.2, 0
116, 0.57142857142857, -0.2, 0
117, 0.71428571428571, -0.2, 0
118, 0.85714285714286, -0.2, 0
119, 2.15, 0, 0
120, 2.15, -0.2, 0
121, 2.2, -0.1, 0
122, -0.05, 0, 0
123, -0.05, -0.2, 0
124, -0.1, -0.1, 0
125, 0, -0.26666666666667, 0
126, 0, -0.33333333333333, 0
127, 1, -0.26666666666667, 0
128, 1, -0.33333333333333, 0
129, 0.14285714285714, -0.4, 0
130, 0.28571428571429, -0.4, 0
131, 0.42857142857143, -0.4, 0
132, 0.57142857142857, -0.4, 0
133, 0.71428571428571, -0.4, 0
134, 0.85714285714286, -0.4, 0
135, -0.1, -0.26666666666667, 0
136, -0.1, -0.33333333333333, 0
137, -0.05, -0.4, 0
138, 1.1, -0.26666666666667, 0
139, 1.1, -0.33333333333333, 0
140, 2.1, -0.26666666666667, 0
141, 2.1, -0.33333333333333, 0
142, 1.2428571428571, -0.4, 0
143, 1.3857142857143, -0.4, 0
144, 1.5285714285714, -0.4, 0
145, 1.6714285714286, -0.4, 0
146, 1.8142857142857, -0.4, 0
147, 1.9571428571429, -0.4, 0
148, 2.2, -0.26666666666667, 0
149, 2.2, -0.33333333333333, 0
150, 2.15, -0.4, 0
151, 1, 1.3666666666667, 0
152, 1, 1.4333333333333, 0
153, 0, 1.3666666666667, 0
154, 0, 1.4333333333333, 0
155, 0.85714285714286, 1.5, 0
156, 0.71428571428571, 1.5, 0
157, 0.57142857142857, 1.5, 0
158, 0.42857142857143, 1.5, 0
159, 0.28571428571429, 1.5, 0
160, 0.14285714285714, 1.5, 0
161, 1.1, 1.3666666666667, 0
162, 1.1, 1.4333333333333, 0
163, 2.1, 1.3666666666667, 0
164, 2.1, 1.4333333333333, 0
165, 1.2428571428571, 1.5, 0
166, 1.3857142857143, 1.5, 0
167, 1.5285714285714, 1.5, 0
168, 1.6714285714286, 1.5, 0
169, 1.8142857142857, 1.5, 0
170, 1.9571428571429, 1.5, 0
171, 0.14285714285714, 0.13333333333333, 0
172, 0.14285714285714, 0.26666666666667, 0
173, 0.14285714285714, 0.4, 0
174, 0.14285714285714, 0.53333333333333, 0
175, 0.14285714285714, 0.66666666666667, 0
176, 0.14285714285714, 0.8, 0
177, 0.14285714285714, 0.93333333333333, 0
178, 0.14285714285714, 1.0666666666667, 0
179, 0.28571428571429, 0.13333333333333, 0
180, 0.28571428571429, 0.26666666666667, 0
181, 0.28571428571429, 0.4, 0
182, 0.28571428571429, 0.53333333333333, 0
183, 0.28571428571429, 0.66666666666667, 0
184, 0.28571428571429, 0.8, 0
185, 0.28571428571429, 0.93333333333333, 0
186, 0.28571428571429, 1.0666666666667, 0
187, 0.42857142857143, 0.13333333333333, 0
188, 0.42857142857143, 0.26666666666667, 0
189, 0.42857142857143, 0.4, 0
190, 0.42857142857143, 0.53333333333333, 0
191, 0.42857142857143, 0.66666666666667, 0
192, 0.42857142857143, 0.8, 0
193, 0.42857142857143, 0.93333333333333, 0
194, 0.42857142857143, 1.0666666666667, 0
195, 0.57142857142857, 0.13333333333333, 0
196, 0.57142857142857, 0.26666666666667, 0
197, 0.57142857142857, 0.4, 0
198, 0.57142857142857, 0.53333333333333, 0
199, 0.57142857142857, 0.66666666666667, 0
200, 0.57142857142857, 0.8, 0
201, 0.57142857142857, 0.93333333333333, 0
202, 0.57142857142857, 1.0666666666667, 0
203, 0.71428571428571, 0.13333333333333, 0
204, 0.71428571428571, 0.26666666666667, 0
205, 0.71428571428571, 0.4, 0
206, 0.71428571428571, 0.53333333333333, 0
207, 0.71428571428571, 0.66666666666667, 0
208, 0.71428571428571, 0.8, 0
209, 0.71428571428571, 0.93333333333333, 0
210, 0.71428571428571, 1.0666666666667, 0
211, 0.85714285714286, 0.13333333333333, 0
212, 0.85714285714286, 0.26666666666667, 0
213, 0.85714285714286, 0.4, 0
214, 0.85714285714286, 0.53333333333333, 0
215, 0.85714285714286, 0.66666666666667, 0
216, 0.85714285714286, 0.8, 0
217, 0.85714285714286, 0.93333333333333, 0
218, 0.85714285714286, 1.0666666666667, 0
219, 0.85714285714286, 1.25, 0
220, 0.71428571428571, 1.25, 0
221, 0.57142857142857, 1.25, 0
222, 0.42857142857143, 1.25, 0
223, 0.28571428571429, 1.25, 0
224, 0.14285714285714, 1.25, 0
225, 1.2428571428571, 1.25, 0
226, 1.3857142857143, 1.25, 0
227, 1.5285714285714, 1.25, 0
228, 1.6714285714286, 1.25, 0
229, 1.8142857142857, 1.25, 0
230, 1.9571428571429, 1.25, 0
231, 1.2428571428571, 1.0666666666667, 0
232, 1.3857142857143, 1.0666666666667, 0
233, 1.5285714285714, 1.0666666666667, 0
234, 1.6714285714286, 1.0666666666667, 0
235, 1.8142857142857, 1.0666666666667, 0
236, 1.9571428571429, 1.0666666666667, 0
237, 1.2428571428571, 0.93333333333333, 0
238, 1.3857142857143, 0.93333333333333, 0
239, 1.5285714285714, 0.93333333333333, 0
240, 1.6714285714286, 0.93333333333333, 0
241, 1.8142857142857, 0.93333333333333, 0
242, 1.9571428571429, 0.93333333333333, 0
243, 1.2428571428571, 0.8, 0
244, 1.3857142857143, 0.8, 0
245, 1.5285714285714, 0.8, 0
246, 1.6714285714286, 0.8, 0
247, 1.8142857142857, 0.8, 0
248, 1.9571428571429, 0.8, 0
249, 1.2428571428571, 0.66666666666667, 0
250, 1.3857142857143, 0.66666666666667, 0
251, 1.5285714285714, 0.66666666666667, 0
252, 1.6714285714286, 0.66666666666667, 0
253, 1.8142857142857, 0.66666666666667, 0
254, 1.9571428571429, 0.66666666666667, 0
255, 1.2428571428571, 0.53333333333333, 0
256, 1.3857142857143, 0.53333333333333, 0
257, 1.5285714285714, 0.53333333333333, 0
258, 1.6714285714286, 0.53333333333333, 0
259, 1.8142857142857, 0.53333333333333, 0
260, 1.9571428571429, 0.53333333333333, 0
261, 1.2428571428571, 0.4, 0
262, 1.3857142857143, 0.4, 0
263, 1.5285714285714, 0.4, 0
264, 1.6714285714286, 0.4, 0
265, 1.8142857142857, 0.4, 0
266, 1.9571428571429, 0.4, 0
267, 1.2428571428571, 0.26666666666667, 0
268, 1.3857142857143, 0.26666666666667, 0
269, 1.5285714285714, 0.26666666666667, 0
270, 1.6714285714286, 0.26666666666667, 0
271, 1.8142857142857, 0.26666666666667, 0
272, 1.9571428571429, 0.26666666666667, 0
273, 1.2428571428571, 0.13333333333333, 0
274, 1.3857142857143, 0.13333333333333, 0
275, 1.5285714285714, 0.13333333333333, 0
276, 1.6714285714286, 0.13333333333333, 0
277, 1.8142857142857, 0.13333333333333, 0
278, 1.9571428571429, 0.13333333333333, 0
279, 1.2428571428571, -0.1, 0
280, 1.3857142857143, -0.1, 0
281, 1.5285714285714, -0.1, 0
282, 1.6714285714286, -0.1, 0
283, 1.8142857142857, -0.1, 0
284, 1.9571428571429, -0.1, 0
285, 0.14285714285714, -0.1, 0
286, 0.28571428571429, -0.1, 0
287, 0.42857142857143, -0.1, 0
288, 0.57142857142857, -0.1, 0
289, 0.71428571428571, -0.1, 0
290, 0.85714285714286, -0.1, 0
291, 2.15, -0.1, 0
292, -0.05, -0.1, 0
293, 0.14285714285714, -0.26666666666667, 0
294, 0.28571428571429, -0.26666666666667, 0
295, 0.42857142857143, -0.26666666666667, 0
296, 0.57142857142857, -0.26666666666667, 0
297, 0.71428571428571, -0.26666666666667, 0
298, 0.85714285714286, -0.26666666666667, 0
299, 0.14285714285714, -0.33333333333333, 0
300, 0.28571428571429, -0.33333333333333, 0
301, 0.42857142857143, -0.33333333333333, 0
302, 0.57142857142857, -0.33333333333333, 0
303, 0.71428571428571, -0.33333333333333, 0
304, 0.85714285714286, -0.33333333333333, 0
305, -0.05, -0.26666666666667, 0
306, -0.05, -0.33333333333333, 0
307, 1.2428571428571, -0.26666666666667, 0
308, 1.3857142857143, -0.26666666666667, 0
309, 1.5285714285714, -0.26666666666667, 0
310, 1.6714285714286, -0.26666666666667, 0
311, 1.8142857142857, -0.26666666666667, 0
312, 1.9571428571429, -0.26666666666667, 0
313, 1.2428571428571, -0.33333333333333, 0
314, 1.3857142857143, -0.33333333333333, 0
315, 1.5285714285714, -0.33333333333333, 0
316, 1.6714285714286, -0.33333333333333, 0
317, 1.8142857142857, -0.33333333333333, 0
318, 1.9571428571429, -0.33333333333333, 0
319, 2.15, -0.26666666666667, 0
320, 2.15, -0.33333333333333, 0
321, 0.85714285714286, 1.3666666666667, 0
322, 0.71428571428571, 1.3666666666667, 0
323, 0.57142857142857, 1.3666666666667, 0
324, 0.42857142857143, 1.3666666666667, 0
325, 0.28571428571429, 1.3666666666667, 0
326, 0.14285714285714, 1.3666666666667, 0
327, 0.85714285714286, 1.4333333333333, 0
328, 0.71428571428571, 1.4333333333333, 0
329, 0.57142857142857, 1.4333333333333, 0
330, 0.42857142857143, 1.4333333333333, 0
331, 0.28571428571429, 1.4333333333333, 0
332, 0.14285714285714, 1.4333333333333, 0
333, 1.2428571428571, 1.3666666666667, 0
334, 1.3857142857143, 1.3666666666667, 0
335, 1.5285714285714, 1.3666666666667, 0
336, 1.6714285714286, 1.3666666666667, 0
337, 1.8142857142857, 1.3666666666667, 0
338, 1.9571428571429, 1.3666666666667, 0
339, 1.2428571428571, 1.4333333333333, 0
340, 1.3857142857143, 1.4333333333333, 0
341, 1.5285714285714, 1.4333333333333, 0
342, 1.6714285714286, 1.4333333333333, 0
343, 1.8142857142857, 1.4333333333333, 0
344, 1.9571428571429, 1.4333333333333, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
31, 1, 31
32, 31, 32
33, 32, 33
34, 33, 34
35, 34, 35
36, 35, 36
37, 36, 2
*ELEMENT, type=T3D2, ELSET=Line2
38, 2, 37
39, 37, 38
40, 38, 39
41, 39, 40
42, 40, 41
43, 41, 42
44, 42, 43
45, 43, 44
46, 44, 3
*ELEMENT, type=T3D2, ELSET=Line3
47, 3, 45
48, 45, 46
49, 46, 47
50, 47, 48
51, 48, 49
52, 49, 50
53, 50, 4
*ELEMENT, type=T3D2, ELSET=Line4
54, 4, 51
55, 51, 52
56, 52, 53
57, 53, 54
58, 54, 55
59, 55, 56
60, 56, 57
61, 57, 58
62, 58, 1
*ELEMENT, type=T3D2, ELSET=Line5
63, 3, 59
64, 59, 5
*ELEMENT, type=T3D2, ELSET=Line6
65, 4, 60
66, 60, 6
*ELEMENT, type=T3D2, ELSET=Line7
67, 5, 61
68, 61, 62
69, 62, 63
70, 63, 64
71, 64, 65
72, 65, 66
73, 66, 6
*ELEMENT, type=T3D2, ELSET=Line8
74, 3, 7
*ELEMENT, type=T3D2, ELSET=Line9
75, 5, 8
*ELEMENT, type=T3D2, ELSET=Line10
76, 7, 67
77, 67, 8
*ELEMENT, type=T3D2, ELSET=Line11
78, 7, 68
79, 68, 69
80, 69, 70
81, 70, 71
82, 71, 72
83, 72, 73
84, 73, 9
*ELEMENT, type=T3D2, ELSET=Line12
85, 8, 74
86, 74, 75
87, 75, 76
88, 76, 77
89, 77, 78
90, 78, 79
91, 79, 10
*ELEMENT, type=T3D2, ELSET=Line13
92, 9, 80
93, 80, 10
*ELEMENT, type=T3D2, ELSET=Line14
94, 7, 81
95, 81, 82
96, 82, 83
97, 83, 84
98, 84, 85
99, 85, 86
100, 86, 87
101, 87, 88
102, 88, 11
*ELEMENT, type=T3D2, ELSET=Line15
103, 9, 89
104, 89, 90
105, 90, 91
106, 91, 92
107, 92, 93
108, 93, 94
109, 94, 95
110, 95, 96
111, 96, 12
*ELEMENT, type=T3D2, ELSET=Line16
112, 11, 97
113, 97, 98
114, 98, 99
115, 99, 100
116, 100, 101
117, 101, 102
118, 102, 12
*ELEMENT, type=T3D2, ELSET=Line17
119, 11, 103
120, 103, 13
*ELEMENT, type=T3D2, ELSET=Line18
121, 12, 104
122, 104, 14
*ELEMENT, type=T3D2, ELSET=Line19
123, 13, 105
124, 105, 106
125, 106, 107
126, 107, 108
127, 108, 109
128, 109, 110
129, 110, 14
*ELEMENT, type=T3D2, ELSET=Line20
130, 1, 111
131, 111, 15
*ELEMENT, type=T3D2, ELSET=Line21
132, 2, 112
133, 112, 16
*ELEMENT, type=T3D2, ELSET=Line22
134, 15, 113
135, 113, 114
136, 114, 115
137, 115, 116
138, 116, 117
139, 117, 118
140, 118, 16
*ELEMENT, type=T3D2, ELSET=Line23
141, 12, 119
142, 119, 17
*ELEMENT, type=T3D2, ELSET=Line24
143, 14, 120
144, 120, 18
*ELEMENT, type=T3D2, ELSET=Line25
145, 17, 121
146, 121, 18
*ELEMENT, type=T3D2, ELSET=Line26
147, 1, 122
148, 122, 19
*ELEMENT, type=T3D2, ELSET=Line27
149, 15, 123
150, 123, 20
*ELEMENT, type=T3D2, ELSET=Line28
151, 19, 124
152, 124, 20
*ELEMENT, type=T3D2, ELSET=Line29
153, 15, 125
154, 125, 126
155, 126, 21
*ELEMENT, type=T3D2, ELSET=Line30
156, 16, 127
157, 127, 128
158, 128, 22
*ELEMENT, type=T3D2, ELSET=Line31
159, 21, 129
160, 129, 130
161, 130, 131
162, 131, 132
163, 132, 133
164, 133, 134
165, 134, 22
*ELEMENT, type=T3D2, ELSET=Line32
166, 20, 135
167, 135, 136
168, 136, 23
*ELEMENT, type=T3D2, ELSET=Line33
169, 21, 137
170, 137, 23
*ELEMENT, type=T3D2, ELSET=Line34
171, 13, 138
172, 138, 139
173, 139, 24
*ELEMENT, type=T3D2, ELSET=Line35
174, 14, 140
175, 140, 141
176, 141, 25
*ELEMENT, type=T3D2, ELSET=Line36
177, 24, 142
178, 142, 143
179, 143, 144
180, 144, 145
181, 145, 146
182, 146, 147
183, 147, 25
*ELEMENT, type=T3D2, ELSET=Line37
184, 18, 148
185, 148, 149
186, 149, 26
*ELEMENT, type=T3D2, ELSET=Line38
187, 25, 150
188, 150, 26
*ELEMENT, type=T3D2, ELSET=Line39
189, 5, 151
190, 151, 152
191, 152, 27
*ELEMENT, type=T3D2, ELSET=Line40
192, 6, 153
193, 153, 154
194, 154, 28
*ELEMENT, type=T3D2, ELSET=Line41
195, 27, 155
196, 155, 156
197, 156, 157
198, 157, 158
199, 158, 159
200, 159, 160
201, 160, 28
*ELEMENT, type=T3D2, ELSET=Line42
202, 8, 161
203, 161, 162
204, 162, 29
*ELEMENT, type=T3D2, ELSET=Line43
205, 27, 29
*ELEMENT, type=T3D2, ELSET=Line44
206, 10, 163
207, 163, 164
208, 164, 30
*ELEMENT, type=T3D2, ELSET=Line45
209, 29, 165
210, 165, 166
211, 166, 167
212, 167, 168
213, 168, 169
214, 169, 170
215, 170, 30
*ELEMENT, type=CPS4, ELSET=Surface1
216, 1, 31, 171, 58
217, 58, 171, 172, 57
218, 57, 172, 173, 56
219, 56, 173, 174, 55
220, 55, 174, 175, 54
221, 54, 175, 176, 53
222, 53, 176, 177, 52
223, 52, 177, 178, 51
224, 51, 178, 50, 4
225, 31, 32, 179, 171
226, 171, 179, 180, 172
227, 172, 180, 181, 173
228, 173, 181, 182, 174
229, 174, 182, 183, 175
230, 175, 183, 184, 176
231, 176, 184, 185, 177
232, 177, 185, 186, 178
233, 178, 186, 49, 50
234, 32, 33, 187, 179
235, 179, 187, 188, 180
236, 180, 188, 189, 181
237, 181, 189, 190, 182
238, 182, 190, 191, 183
239, 183, 191, 192, 184
240, 184, 192, 193, 185
241, 185, 193, 194, 186
242, 186, 194, 48, 49
243, 33, 34, 195, 187
244, 187, 195, 196, 188
245, 188, 196, 197, 189
246, 189, 197, 198, 190
247, 190, 198, 199, 191
248, 191, 199, 200, 192
249, 192, 200, 201, 193
250, 193, 201, 202, 194
251, 194, 202, 47, 48
252, 34, 35, 203, 195
253, 195, 203, 204, 196
254, 196, 204, 205, 197
255, 197, 205, 206, 198
256, 198, 206, 207, 199
257, 199, 207, 208, 200
258, 200, 208, 209, 201
259, 201, 209, 210, 202
260, 202, 210, 46, 47
261, 35, 36, 211, 203
262, 203, 211, 212, 204
263, 204, 212, 213, 205
264, 205, 213, 214, 206
265, 206, 214, 215, 207
266, 207, 215, 216, 208
267, 208, 216, 217, 209
268, 209, 217, 218, 210
269, 210, 218, 45, 46
270, 36, 2, 37, 211
271, 211, 37, 38, 212
272, 212, 38, 39, 213
273, 213, 39, 40, 214
274, 214, 40, 41, 215
275, 215, 41, 42, 216
276, 216, 42, 43, 217
277, 217, 43, 44, 218
278, 218, 44, 3, 45
*ELEMENT, type=CPS4, ELSET=Surface2
279, 3, 59, 219, 45
280, 45, 219, 220, 46
281, 46, 220, 221, 47
282, 47, 221, 222, 48
283, 48, 222, 223, 49
284, 49, 223, 224, 50
285, 50, 224, 60, 4
286, 59, 5, 61, 219
287, 219, 61, 62, 220
288, 220, 62, 63, 221
289, 221, 63, 64, 222
290, 222, 64, 65, 223
291, 223, 65, 66, 224
292, 224, 66, 6, 60
*ELEMENT, type=CPS4, ELSET=Surface3
293, 3, 7, 67, 59
294, 59, 67, 8, 5
*ELEMENT, type=CPS4, ELSET=Surface4
295, 7, 68, 225, 67
296, 67, 225, 74, 8
297, 68, 69, 226, 225
298, 225, 226, 75, 74
299, 69, 70, 227, 226
300, 226, 227, 76, 75
301, 70, 71, 228, 227
302, 227, 228, 77, 76
303, 71, 72, 229, 228
304, 228, 229, 78, 77
305, 72, 73, 230, 229
306, 229, 230, 79, 78
307, 73, 9, 80, 230
308, 230, 80, 10, 79
*ELEMENT, type=CPS4, ELSET=Surface5
309, 7, 81, 231, 68
310, 68, 231, 232, 69
311, 69, 232, 233, 70
312, 70, 233, 234, 71
313, 71, 234, 235, 72
314, 72, 235, 236, 73
315, 73, 236, 89, 9
316, 81, 82, 237, 231
317, 231, 237, 238, 232
318, 232, 238, 239, 233
319, 233, 239, 240, 234
320, 234, 240, 241, 235
321, 235, 241, 242, 236
322, 236, 242, 90, 89
323, 82, 83, 243, 237
324, 237, 243, 244, 238
325, 238, 244, 245, 239
326, 239, 245, 246, 240
327, 240, 246, 247, 241
328, 241, 247, 248, 242
329, 242, 248, 91, 90
330, 83, 84, 249, 243
331, 243, 249, 250, 244
332, 244, 250, 251, 245
333, 245, 251, 252, 246
334, 246, 252, 253, 247
335, 247, 253, 254, 248
336, 248, 254, 92, 91
337, 84, 85, 255, 249
338, 249, 255, 256, 250
339, 250, 256, 257, 251
340, 251, 257, 258, 252
341, 252, 258, 259, 253
342, 253, 259, 260, 254
343, 254, 260, 93, 92
344, 85, 86, 261, 255
345, 255, 261, 262, 256
346, 256, 262, 263, 257
347, 257, 263, 264, 258
348, 258, 264, 265, 259
349, 259, 265, 266, 260
350, 260, 266, 94, 93
351, 86, 87, 267, 261
352, 261, 267, 268, 262
353, 262, 268, 269, 263
354, 263, 269, 270, 264
355, 264, 270, 271, 265
356, 265, 271, 272, 266
357, 266, 272, 95, 94
358, 87, 88, 273, 267
359, 267, 273, 274, 268
360, 268, 274, 275, 269
361, 269, 275, 276, 270
362, 270, 276, 277, 271
363, 271, 277, 278, 272
364, 272, 278, 96, 95
365, 88, 11, 97, 273
366, 273, 97, 98, 274
367, 274, 98, 99, 275
368, 275, 99, 100, 276
369, 276, 100, 101, 277
370, 277, 101, 102, 278
371, 278, 102, 12, 96
*ELEMENT, type=CPS4, ELSET=Surface6
372, 11, 103, 279, 97
373, 97, 279, 280, 98
374, 98, 280, 281, 99
375, 99, 281, 282, 100
376, 100, 282, 283, 101
377, 101, 283, 284, 102
378, 102, 284, 104, 12
379, 103, 13, 105, 279
380, 279, 105, 106, 280
381, 280, 106, 107, 281
382, 281, 107, 108, 282
383, 282, 108, 109, 283
384, 283, 109, 110, 284
385, 284, 110, 14, 104
*ELEMENT, type=CPS4, ELSET=Surface7
386, 1, 111, 285, 31
387, 31, 285, 286, 32
388, 32, 286, 287, 33
389, 33, 287, 288, 34
390, 34, 288, 289, 35
391, 35, 289, 290, 36
392, 36, 290, 112, 2
393, 111, 15, 113, 285
394, 285, 113, 114, 286
395, 286, 114, 115, 287
396, 287, 115, 116, 288
397, 288, 116, 117, 289
398, 289, 117, 118, 290
399, 290, 118, 16, 112
*ELEMENT, type=CPS4, ELSET=Surface8
400, 12, 119, 291, 104
401, 104, 291, 120, 14
402, 119, 17, 121, 291
403, 291, 121, 18, 120
*ELEMENT, type=CPS4, ELSET=Surface9
404, 1, 122, 292, 111
405, 111, 292, 123, 15
406, 122, 19, 124, 292
407, 292, 124, 20, 123
*ELEMENT, type=CPS4, ELSET=Surface10
408, 15, 125, 293, 113
409, 113, 293, 294, 114
410, 114, 294, 295, 115
411, 115, 295, 296, 116
412, 116, 296, 297, 117
413, 117, 297, 298, 118
414, 118, 298, 127, 16
415, 125, 126, 299, 293
416, 293, 299, 300, 294
417, 294, 300, 301, 295
418, 295, 301, 302, 296
419, 296, 302, 303, 297
420, 297, 303, 304, 298
421, 298, 304, 128, 127
422, 126, 21, 129, 299
423, 299, 129, 130, 300
424, 300, 130, 131, 301
425, 301, 131, 132, 302
426, 302, 132, 133, 303
427, 303, 133, 134, 304
428, 304, 134, 22, 128
*ELEMENT, type=CPS4, ELSET=Surface11
429, 15, 125, 305, 123
430, 123, 305, 135, 20
431, 125, 126, 306, 305
432, 305, 306, 136, 135
433, 126, 21, 137, 306
434, 306, 137, 23, 136
*ELEMENT, type=CPS4, ELSET=Surface12
435, 13, 138, 307, 105
436, 105, 307, 308, 106
437, 106, 308, 309, 107
438, 107, 309, 310, 108
439, 108, 310, 311, 109
440, 109, 311, 312, 110
441, 110, 312, 140, 14
442, 138, 139, 313, 307
443, 307, 313, 314, 308
444, 308, 314, 315, 309
445, 309, 315, 316, 310
446, 310, 316, 317, 311
447, 311, 317, 318, 312
448, 312, 318, 141, 140
449, 139, 24, 142, 313
450, 313, 142, 143, 314
451, 314, 143, 144, 315
452, 315, 144, 145, 316
453, 316, 145, 146, 317
454, 317, 146, 147, 318
455, 318, 147, 25, 141
*ELEMENT, type=CPS4, ELSET=Surface13
456, 14, 140, 319, 120
457, 120, 319, 148, 18
458, 140, 141, 320, 319
459, 319, 320, 149, 148
460, 141, 25, 150, 320
461, 320, 150, 26, 149
*ELEMENT, type=CPS4, ELSET=Surface14
462, 5, 151, 321, 61
463, 61, 321, 322, 62
464, 62, 322, 323, 63
465, 63, 323, 324, 64
466, 64, 324, 325, 65
467, 65, 325, 326, 66
468, 66, 326, 153, 6
469, 151, 152, 327, 321
470, 321, 327, 328, 322
471, 322, 328, 329, 323
472, 323, 329, 330, 324
473, 324, 330, 331, 325
474, 325, 331, 332, 326
475, 326, 332, 154, 153
476, 152, 27, 155, 327
477, 327, 155, 156, 328
478, 328, 156, 157, 329
479, 329, 157, 158, 330
480, 330, 158, 159, 331
481, 331, 159, 160, 332
482, 332, 160, 28, 154
*ELEMENT, type=CPS4, ELSET=Surface15
483, 5, 151, 161, 8
484, 151, 152, 162, 161
485, 152, 27, 29, 162
*ELEMENT, type=CPS4, ELSET=Surface16
486, 8, 161, 333, 74
487, 74, 333, 334, 75
488, 75, 334, 335, 76
489, 76, 335, 336, 77
490, 77, 336, 337, 78
491, 78, 337, 338, 79
492, 79, 338, 163, 10
493, 161, 162, 339, 333
494, 333, 339, 340, 334
495, 334, 340, 341, 335
496, 335, 341, 342, 336
497, 336, 342, 343, 337
498, 337, 343, 344, 338
499, 338, 344, 164, 163
500, 162, 29, 165, 339
501, 339, 165, 166, 340
502, 340, 166, 167, 341
503, 341, 167, 168, 342
504, 342, 168, 169, 343
505, 343, 169, 170, 344
506, 344, 170, 30, 164
*ELSET,ELSET=Ceramic_Top
195, 196, 197, 198, 199, 200, 201, 205, 209, 210, 
211, 212, 213, 214, 215, 
*ELSET,ELSET=Ceramic_Bottom
159, 160, 161, 162, 163, 164, 165, 169, 170, 177, 
178, 179, 180, 181, 182, 183, 187, 188, 
*ELSET,ELSET=Electrode_MinX
151, 152, 
*ELSET,ELSET=Electrode_MaxX
145, 146, 
*ELSET,ELSET=Contact_Ceramic
67, 68, 69, 70, 71, 72, 73, 75, 85, 86, 
87, 88, 89, 90, 91, 123, 124, 125, 126, 127, 
128, 129, 134, 135, 136, 137, 138, 139, 140, 143, 
144, 149, 150, 
*ELSET,ELSET=Copper
279, 280, 281, 282, 283, 284, 285, 286, 287, 288, 
289, 290, 291, 292, 293, 294, 295, 296, 297, 298, 
299, 300, 301, 302, 303, 304, 305, 306, 307, 308, 
372, 373, 374, 375, 376, 377, 378, 379, 380, 381, 
382, 383, 384, 385, 386, 387, 388, 389, 390, 391, 
392, 393, 394, 395, 396, 397, 398, 399, 400, 401, 
402, 403, 404, 405, 406, 407, 
*ELSET,ELSET=SemiconductorL
216, 217, 218, 219, 220, 221, 222, 223, 224, 225, 
226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 
236, 237, 238, 239, 240, 241, 242, 243, 244, 245, 
246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 
256, 257, 258, 259, 260, 261, 262, 263, 264, 265, 
266, 267, 268, 269, 270, 271, 272, 273, 274, 275, 
276, 277, 278, 
*ELSET,ELSET=SemiconductorR
309, 310, 311, 312, 313, 314, 315, 316, 317, 318, 
319, 320, 321, 322, 323, 324, 325, 326, 327, 328, 
329, 330, 331, 332, 333, 334, 335, 336, 337, 338, 
339, 340, 341, 342, 343, 344, 345, 346, 347, 348, 
349, 350, 351, 352, 353, 354, 355, 356, 357, 358, 
359, 360, 361, 362, 363, 364, 365, 366, 367, 368, 
369, 370, 371, 
*ELSET,ELSET=Ceramic
408, 409, 410, 411, 412, 413, 414, 415, 416, 417, 
418, 419, 420, 421, 422, 423, 424, 425, 426, 427, 
428, 429, 430, 431, 432, 433, 434, 435, 436, 437, 
438, 439, 440, 441, 442, 443, 444, 445, 446, 447, 
448, 449, 450, 451, 452, 453, 454, 455, 456, 457, 
458, 459, 460, 461, 462, 463, 464, 465, 466, 467, 
468, 469, 470, 471, 472, 473, 474, 475, 476, 477, 
478, 479, 480, 481, 482, 483, 484, 485, 486, 487, 
488, 489, 490, 491, 492, 493, 494, 495, 496, 497, 
498, 499, 500, 501, 502, 503, 504, 505, 506, 
*ELSET,ELSET=Surface
216, 217, 218, 219, 220, 221, 222, 223, 224, 225, 
226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 
236, 237, 238, 239, 240, 241, 242, 243, 244, 245, 
246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 
256, 257, 258, 259, 260, 261, 262, 263, 264, 265, 
266, 267, 268, 269, 270, 271, 272, 273, 274, 275, 
276, 277, 278, 279, 280, 281, 282, 283, 284, 285, 
286, 287, 288, 289, 290, 291, 292, 293, 294, 295, 
296, 297, 298, 299, 300, 301, 302, 303, 304, 305, 
306, 307, 308, 309, 310, 311, 312, 313, 314, 315, 
316, 317, 318, 319, 320, 321, 322, 323, 324, 325, 
326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 
336, 337, 338, 339, 340, 341, 342, 343, 344, 345, 
346, 347, 348, 349, 350, 351, 352, 353, 354, 355, 
356, 357, 358, 359, 360, 361, 362, 363, 364, 365, 
366, 367, 368, 369, 370, 371, 372, 373, 374, 375, 
376, 377, 378, 379, 380, 381, 382, 383, 384, 385, 
386, 387, 388, 389, 390, 391, 392, 393, 394, 395, 
396, 397, 398, 399, 400, 401, 402, 403, 404, 405, 
406, 407, 408, 409, 410, 411, 412, 413, 414, 415, 
416, 417, 418, 419, 420, 421, 422, 423, 424, 425, 
426, 427, 428, 429, 430, 431, 432, 433, 434, 435, 
436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 
446, 447, 448, 449, 450, 451, 452, 453, 454, 455, 
456, 457, 458, 459, 460, 461, 462, 463, 464, 465, 
466, 467, 468, 469, 470, 471, 472, 473, 474, 475, 
476, 477, 478, 479, 480, 481, 482, 483, 484, 485, 
486, 487, 488, 489, 490, 491, 492, 493, 494, 495, 
496, 497, 498, 499, 500, 501, 502, 503, 504, 505, 
506, 
*ELSET,ELSET=TO
216, 217, 218, 219, 220, 221, 222, 223, 224, 225, 
226, 227, 228, 229, 230, 231, 232, 233, 234, 235, 
236, 237, 238, 239, 240, 241, 242, 243, 244, 245, 
246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 
256, 257, 258, 259, 260, 261, 262, 263, 264, 265, 
266, 267, 268, 269, 270, 271, 272, 273, 274, 275, 
276, 277, 278, 309, 310, 311, 312, 313, 314, 315, 
316, 317, 318, 319, 320, 321, 322, 323, 324, 325, 
326, 327, 328, 329, 330, 331, 332, 333, 334, 335, 
336, 337, 338, 339, 340, 341, 342, 343, 344, 345, 
346, 347, 348, 349, 350, 351, 352, 353, 354, 355, 
356, 357, 358, 359, 360, 361, 362, 363, 364, 365, 
366, 367, 368, 369, 370, 371, 
*NSET,NSET=Ceramic_Top
27, 28, 29, 30, 155, 156, 157, 158, 159, 160, 
165, 166, 167, 168, 169, 170, 
*NSET,NSET=Ceramic_Bottom
21, 22, 23, 24, 25, 26, 129, 130, 131, 132, 
133, 134, 137, 142, 143, 144, 145, 146, 147, 150, 
*NSET,NSET=Electrode_MinX
19, 20, 124, 
*NSET,NSET=Electrode_MaxX
17, 18, 121, 
*NSET,NSET=Contact_Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
61, 62, 63, 64, 65, 66, 74, 75, 76, 77, 
78, 79, 105, 106, 107, 108, 109, 110, 113, 114, 
115, 116, 117, 118, 120, 123, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
31, 32, 33, 34, 35, 36, 45, 46, 47, 48, 
49, 50, 59, 60, 61, 62, 63, 64, 65, 66, 
67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 
77, 78, 79, 80, 97, 98, 99, 100, 101, 102, 
103, 104, 105, 106, 107, 108, 109, 110, 111, 112, 
113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 
123, 124, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 
*NSET,NSET=SemiconductorL
1, 2, 3, 4, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 171, 172, 173, 174, 175, 176, 177, 178, 
179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 
189, 190, 191, 192, 193, 194, 195, 196, 197, 198, 
199, 200, 201, 202, 203, 204, 205, 206, 207, 208, 
209, 210, 211, 212, 213, 214, 215, 216, 217, 218, 
*NSET,NSET=SemiconductorR
7, 9, 11, 12, 68, 69, 70, 71, 72, 73, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
*NSET,NSET=Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
61, 62, 63, 64, 65, 66, 74, 75, 76, 77, 
78, 79, 105, 106, 107, 108, 109, 110, 113, 114, 
115, 116, 117, 118, 120, 123, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 141, 142, 143, 144, 145, 146, 147, 148, 
149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 
159, 160, 161, 162, 163, 164, 165, 166, 167, 168, 
169, 170, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 
*NSET,NSET=Surface
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 
*NSET,NSET=TO
1, 2, 3, 4, 7, 9, 11, 12, 31, 32, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 
53, 54, 55, 56, 57, 58, 68, 69, 70, 71, 
72, 73, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 
99, 100, 101, 102, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
