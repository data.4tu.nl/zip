*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_QuadFine.inp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1.2, 0
4, 0, 1.2, 0
5, 1, 1.3, 0
6, 0, 1.3, 0
7, 1.2, 1.2, 0
8, 1.2, 1.3, 0
9, 2.2, 1.2, 0
10, 2.2, 1.3, 0
11, 1.2, 0, 0
12, 2.2, 0, 0
13, 1.2, -0.1, 0
14, 2.2, -0.1, 0
15, 0, -0.1, 0
16, 1, -0.1, 0
17, 2.3, 0, 0
18, 2.3, -0.1, 0
19, -0.1, 0, 0
20, -0.1, -0.1, 0
21, 0, -0.3, 0
22, 1, -0.3, 0
23, -0.1, -0.3, 0
24, 1.2, -0.3, 0
25, 2.2, -0.3, 0
26, 2.3, -0.3, 0
27, 1, 1.5, 0
28, 0, 1.5, 0
29, 1.2, 1.5, 0
30, 2.2, 1.5, 0
31, 0.05, 0, 0
32, 0.1, 0, 0
33, 0.15, 0, 0
34, 0.2, 0, 0
35, 0.25, 0, 0
36, 0.3, 0, 0
37, 0.35, 0, 0
38, 0.4, 0, 0
39, 0.45, 0, 0
40, 0.5, 0, 0
41, 0.55, 0, 0
42, 0.6, 0, 0
43, 0.65, 0, 0
44, 0.7, 0, 0
45, 0.75, 0, 0
46, 0.8, 0, 0
47, 0.85, 0, 0
48, 0.9, 0, 0
49, 0.95, 0, 0
50, 1, 0.06, 0
51, 1, 0.12, 0
52, 1, 0.18, 0
53, 1, 0.24, 0
54, 1, 0.3, 0
55, 1, 0.36, 0
56, 1, 0.42, 0
57, 1, 0.48, 0
58, 1, 0.54, 0
59, 1, 0.6, 0
60, 1, 0.66, 0
61, 1, 0.72, 0
62, 1, 0.78, 0
63, 1, 0.84, 0
64, 1, 0.9, 0
65, 1, 0.96, 0
66, 1, 1.02, 0
67, 1, 1.08, 0
68, 1, 1.14, 0
69, 0.95, 1.2, 0
70, 0.9, 1.2, 0
71, 0.85, 1.2, 0
72, 0.8, 1.2, 0
73, 0.75, 1.2, 0
74, 0.7, 1.2, 0
75, 0.65, 1.2, 0
76, 0.6, 1.2, 0
77, 0.55, 1.2, 0
78, 0.5, 1.2, 0
79, 0.45, 1.2, 0
80, 0.4, 1.2, 0
81, 0.35, 1.2, 0
82, 0.3, 1.2, 0
83, 0.25, 1.2, 0
84, 0.2, 1.2, 0
85, 0.15, 1.2, 0
86, 0.1, 1.2, 0
87, 0.05, 1.2, 0
88, 0, 1.14, 0
89, 0, 1.08, 0
90, 0, 1.02, 0
91, 0, 0.96, 0
92, 0, 0.9, 0
93, 0, 0.84, 0
94, 0, 0.78, 0
95, 0, 0.72, 0
96, 0, 0.66, 0
97, 0, 0.6, 0
98, 0, 0.54, 0
99, 0, 0.48, 0
100, 0, 0.42, 0
101, 0, 0.36, 0
102, 0, 0.3, 0
103, 0, 0.24, 0
104, 0, 0.18, 0
105, 0, 0.12, 0
106, 0, 0.06, 0
107, 1, 1.2333333333333, 0
108, 1, 1.2666666666667, 0
109, 0, 1.2333333333333, 0
110, 0, 1.2666666666667, 0
111, 0.95, 1.3, 0
112, 0.9, 1.3, 0
113, 0.85, 1.3, 0
114, 0.8, 1.3, 0
115, 0.75, 1.3, 0
116, 0.7, 1.3, 0
117, 0.65, 1.3, 0
118, 0.6, 1.3, 0
119, 0.55, 1.3, 0
120, 0.5, 1.3, 0
121, 0.45, 1.3, 0
122, 0.4, 1.3, 0
123, 0.35, 1.3, 0
124, 0.3, 1.3, 0
125, 0.25, 1.3, 0
126, 0.2, 1.3, 0
127, 0.15, 1.3, 0
128, 0.1, 1.3, 0
129, 0.05, 1.3, 0
130, 1.04, 1.2, 0
131, 1.08, 1.2, 0
132, 1.12, 1.2, 0
133, 1.16, 1.2, 0
134, 1.04, 1.3, 0
135, 1.08, 1.3, 0
136, 1.12, 1.3, 0
137, 1.16, 1.3, 0
138, 1.2, 1.2333333333333, 0
139, 1.2, 1.2666666666667, 0
140, 1.25, 1.2, 0
141, 1.3, 1.2, 0
142, 1.35, 1.2, 0
143, 1.4, 1.2, 0
144, 1.45, 1.2, 0
145, 1.5, 1.2, 0
146, 1.55, 1.2, 0
147, 1.6, 1.2, 0
148, 1.65, 1.2, 0
149, 1.7, 1.2, 0
150, 1.75, 1.2, 0
151, 1.8, 1.2, 0
152, 1.85, 1.2, 0
153, 1.9, 1.2, 0
154, 1.95, 1.2, 0
155, 2, 1.2, 0
156, 2.05, 1.2, 0
157, 2.1, 1.2, 0
158, 2.15, 1.2, 0
159, 1.25, 1.3, 0
160, 1.3, 1.3, 0
161, 1.35, 1.3, 0
162, 1.4, 1.3, 0
163, 1.45, 1.3, 0
164, 1.5, 1.3, 0
165, 1.55, 1.3, 0
166, 1.6, 1.3, 0
167, 1.65, 1.3, 0
168, 1.7, 1.3, 0
169, 1.75, 1.3, 0
170, 1.8, 1.3, 0
171, 1.85, 1.3, 0
172, 1.9, 1.3, 0
173, 1.95, 1.3, 0
174, 2, 1.3, 0
175, 2.05, 1.3, 0
176, 2.1, 1.3, 0
177, 2.15, 1.3, 0
178, 2.2, 1.2333333333333, 0
179, 2.2, 1.2666666666667, 0
180, 1.2, 1.14, 0
181, 1.2, 1.08, 0
182, 1.2, 1.02, 0
183, 1.2, 0.96, 0
184, 1.2, 0.9, 0
185, 1.2, 0.84, 0
186, 1.2, 0.78, 0
187, 1.2, 0.72, 0
188, 1.2, 0.66, 0
189, 1.2, 0.6, 0
190, 1.2, 0.54, 0
191, 1.2, 0.48, 0
192, 1.2, 0.42, 0
193, 1.2, 0.36, 0
194, 1.2, 0.3, 0
195, 1.2, 0.24, 0
196, 1.2, 0.18, 0
197, 1.2, 0.12, 0
198, 1.2, 0.06, 0
199, 2.2, 1.14, 0
200, 2.2, 1.08, 0
201, 2.2, 1.02, 0
202, 2.2, 0.96, 0
203, 2.2, 0.9, 0
204, 2.2, 0.84, 0
205, 2.2, 0.78, 0
206, 2.2, 0.72, 0
207, 2.2, 0.66, 0
208, 2.2, 0.6, 0
209, 2.2, 0.54, 0
210, 2.2, 0.48, 0
211, 2.2, 0.42, 0
212, 2.2, 0.36, 0
213, 2.2, 0.3, 0
214, 2.2, 0.24, 0
215, 2.2, 0.18, 0
216, 2.2, 0.12, 0
217, 2.2, 0.06, 0
218, 1.25, 0, 0
219, 1.3, 0, 0
220, 1.35, 0, 0
221, 1.4, 0, 0
222, 1.45, 0, 0
223, 1.5, 0, 0
224, 1.55, 0, 0
225, 1.6, 0, 0
226, 1.65, 0, 0
227, 1.7, 0, 0
228, 1.75, 0, 0
229, 1.8, 0, 0
230, 1.85, 0, 0
231, 1.9, 0, 0
232, 1.95, 0, 0
233, 2, 0, 0
234, 2.05, 0, 0
235, 2.1, 0, 0
236, 2.15, 0, 0
237, 1.2, -0.033333333333333, 0
238, 1.2, -0.066666666666667, 0
239, 2.2, -0.033333333333333, 0
240, 2.2, -0.066666666666667, 0
241, 1.25, -0.1, 0
242, 1.3, -0.1, 0
243, 1.35, -0.1, 0
244, 1.4, -0.1, 0
245, 1.45, -0.1, 0
246, 1.5, -0.1, 0
247, 1.55, -0.1, 0
248, 1.6, -0.1, 0
249, 1.65, -0.1, 0
250, 1.7, -0.1, 0
251, 1.75, -0.1, 0
252, 1.8, -0.1, 0
253, 1.85, -0.1, 0
254, 1.9, -0.1, 0
255, 1.95, -0.1, 0
256, 2, -0.1, 0
257, 2.05, -0.1, 0
258, 2.1, -0.1, 0
259, 2.15, -0.1, 0
260, 0, -0.033333333333333, 0
261, 0, -0.066666666666667, 0
262, 1, -0.033333333333333, 0
263, 1, -0.066666666666667, 0
264, 0.05, -0.1, 0
265, 0.1, -0.1, 0
266, 0.15, -0.1, 0
267, 0.2, -0.1, 0
268, 0.25, -0.1, 0
269, 0.3, -0.1, 0
270, 0.35, -0.1, 0
271, 0.4, -0.1, 0
272, 0.45, -0.1, 0
273, 0.5, -0.1, 0
274, 0.55, -0.1, 0
275, 0.6, -0.1, 0
276, 0.65, -0.1, 0
277, 0.7, -0.1, 0
278, 0.75, -0.1, 0
279, 0.8, -0.1, 0
280, 0.85, -0.1, 0
281, 0.9, -0.1, 0
282, 0.95, -0.1, 0
283, 2.25, 0, 0
284, 2.25, -0.1, 0
285, 2.3, -0.033333333333333, 0
286, 2.3, -0.066666666666667, 0
287, -0.05, 0, 0
288, -0.05, -0.1, 0
289, -0.1, -0.033333333333333, 0
290, -0.1, -0.066666666666667, 0
291, 0, -0.14, 0
292, 0, -0.18, 0
293, 0, -0.22, 0
294, 0, -0.26, 0
295, 1, -0.14, 0
296, 1, -0.18, 0
297, 1, -0.22, 0
298, 1, -0.26, 0
299, 0.05, -0.3, 0
300, 0.1, -0.3, 0
301, 0.15, -0.3, 0
302, 0.2, -0.3, 0
303, 0.25, -0.3, 0
304, 0.3, -0.3, 0
305, 0.35, -0.3, 0
306, 0.4, -0.3, 0
307, 0.45, -0.3, 0
308, 0.5, -0.3, 0
309, 0.55, -0.3, 0
310, 0.6, -0.3, 0
311, 0.65, -0.3, 0
312, 0.7, -0.3, 0
313, 0.75, -0.3, 0
314, 0.8, -0.3, 0
315, 0.85, -0.3, 0
316, 0.9, -0.3, 0
317, 0.95, -0.3, 0
318, -0.1, -0.14, 0
319, -0.1, -0.18, 0
320, -0.1, -0.22, 0
321, -0.1, -0.26, 0
322, -0.05, -0.3, 0
323, 1.2, -0.14, 0
324, 1.2, -0.18, 0
325, 1.2, -0.22, 0
326, 1.2, -0.26, 0
327, 2.2, -0.14, 0
328, 2.2, -0.18, 0
329, 2.2, -0.22, 0
330, 2.2, -0.26, 0
331, 1.25, -0.3, 0
332, 1.3, -0.3, 0
333, 1.35, -0.3, 0
334, 1.4, -0.3, 0
335, 1.45, -0.3, 0
336, 1.5, -0.3, 0
337, 1.55, -0.3, 0
338, 1.6, -0.3, 0
339, 1.65, -0.3, 0
340, 1.7, -0.3, 0
341, 1.75, -0.3, 0
342, 1.8, -0.3, 0
343, 1.85, -0.3, 0
344, 1.9, -0.3, 0
345, 1.95, -0.3, 0
346, 2, -0.3, 0
347, 2.05, -0.3, 0
348, 2.1, -0.3, 0
349, 2.15, -0.3, 0
350, 2.3, -0.14, 0
351, 2.3, -0.18, 0
352, 2.3, -0.22, 0
353, 2.3, -0.26, 0
354, 2.25, -0.3, 0
355, 1, 1.34, 0
356, 1, 1.38, 0
357, 1, 1.42, 0
358, 1, 1.46, 0
359, 0, 1.34, 0
360, 0, 1.38, 0
361, 0, 1.42, 0
362, 0, 1.46, 0
363, 0.95, 1.5, 0
364, 0.9, 1.5, 0
365, 0.85, 1.5, 0
366, 0.8, 1.5, 0
367, 0.75, 1.5, 0
368, 0.7, 1.5, 0
369, 0.65, 1.5, 0
370, 0.6, 1.5, 0
371, 0.55, 1.5, 0
372, 0.5, 1.5, 0
373, 0.45, 1.5, 0
374, 0.4, 1.5, 0
375, 0.35, 1.5, 0
376, 0.3, 1.5, 0
377, 0.25, 1.5, 0
378, 0.2, 1.5, 0
379, 0.15, 1.5, 0
380, 0.1, 1.5, 0
381, 0.05, 1.5, 0
382, 1.2, 1.34, 0
383, 1.2, 1.38, 0
384, 1.2, 1.42, 0
385, 1.2, 1.46, 0
386, 1.04, 1.5, 0
387, 1.08, 1.5, 0
388, 1.12, 1.5, 0
389, 1.16, 1.5, 0
390, 2.2, 1.34, 0
391, 2.2, 1.38, 0
392, 2.2, 1.42, 0
393, 2.2, 1.46, 0
394, 1.25, 1.5, 0
395, 1.3, 1.5, 0
396, 1.35, 1.5, 0
397, 1.4, 1.5, 0
398, 1.45, 1.5, 0
399, 1.5, 1.5, 0
400, 1.55, 1.5, 0
401, 1.6, 1.5, 0
402, 1.65, 1.5, 0
403, 1.7, 1.5, 0
404, 1.75, 1.5, 0
405, 1.8, 1.5, 0
406, 1.85, 1.5, 0
407, 1.9, 1.5, 0
408, 1.95, 1.5, 0
409, 2, 1.5, 0
410, 2.05, 1.5, 0
411, 2.1, 1.5, 0
412, 2.15, 1.5, 0
413, 0.05, 0.06, 0
414, 0.05, 0.12, 0
415, 0.05, 0.18, 0
416, 0.05, 0.24, 0
417, 0.05, 0.3, 0
418, 0.05, 0.36, 0
419, 0.05, 0.42, 0
420, 0.05, 0.48, 0
421, 0.05, 0.54, 0
422, 0.05, 0.6, 0
423, 0.05, 0.66, 0
424, 0.05, 0.72, 0
425, 0.05, 0.78, 0
426, 0.05, 0.84, 0
427, 0.05, 0.9, 0
428, 0.05, 0.96, 0
429, 0.05, 1.02, 0
430, 0.05, 1.08, 0
431, 0.05, 1.14, 0
432, 0.1, 0.06, 0
433, 0.1, 0.12, 0
434, 0.1, 0.18, 0
435, 0.1, 0.24, 0
436, 0.1, 0.3, 0
437, 0.1, 0.36, 0
438, 0.1, 0.42, 0
439, 0.1, 0.48, 0
440, 0.1, 0.54, 0
441, 0.1, 0.6, 0
442, 0.1, 0.66, 0
443, 0.1, 0.72, 0
444, 0.1, 0.78, 0
445, 0.1, 0.84, 0
446, 0.1, 0.9, 0
447, 0.1, 0.96, 0
448, 0.1, 1.02, 0
449, 0.1, 1.08, 0
450, 0.1, 1.14, 0
451, 0.15, 0.06, 0
452, 0.15, 0.12, 0
453, 0.15, 0.18, 0
454, 0.15, 0.24, 0
455, 0.15, 0.3, 0
456, 0.15, 0.36, 0
457, 0.15, 0.42, 0
458, 0.15, 0.48, 0
459, 0.15, 0.54, 0
460, 0.15, 0.6, 0
461, 0.15, 0.66, 0
462, 0.15, 0.72, 0
463, 0.15, 0.78, 0
464, 0.15, 0.84, 0
465, 0.15, 0.9, 0
466, 0.15, 0.96, 0
467, 0.15, 1.02, 0
468, 0.15, 1.08, 0
469, 0.15, 1.14, 0
470, 0.2, 0.06, 0
471, 0.2, 0.12, 0
472, 0.2, 0.18, 0
473, 0.2, 0.24, 0
474, 0.2, 0.3, 0
475, 0.2, 0.36, 0
476, 0.2, 0.42, 0
477, 0.2, 0.48, 0
478, 0.2, 0.54, 0
479, 0.2, 0.6, 0
480, 0.2, 0.66, 0
481, 0.2, 0.72, 0
482, 0.2, 0.78, 0
483, 0.2, 0.84, 0
484, 0.2, 0.9, 0
485, 0.2, 0.96, 0
486, 0.2, 1.02, 0
487, 0.2, 1.08, 0
488, 0.2, 1.14, 0
489, 0.25, 0.06, 0
490, 0.25, 0.12, 0
491, 0.25, 0.18, 0
492, 0.25, 0.24, 0
493, 0.25, 0.3, 0
494, 0.25, 0.36, 0
495, 0.25, 0.42, 0
496, 0.25, 0.48, 0
497, 0.25, 0.54, 0
498, 0.25, 0.6, 0
499, 0.25, 0.66, 0
500, 0.25, 0.72, 0
501, 0.25, 0.78, 0
502, 0.25, 0.84, 0
503, 0.25, 0.9, 0
504, 0.25, 0.96, 0
505, 0.25, 1.02, 0
506, 0.25, 1.08, 0
507, 0.25, 1.14, 0
508, 0.3, 0.06, 0
509, 0.3, 0.12, 0
510, 0.3, 0.18, 0
511, 0.3, 0.24, 0
512, 0.3, 0.3, 0
513, 0.3, 0.36, 0
514, 0.3, 0.42, 0
515, 0.3, 0.48, 0
516, 0.3, 0.54, 0
517, 0.3, 0.6, 0
518, 0.3, 0.66, 0
519, 0.3, 0.72, 0
520, 0.3, 0.78, 0
521, 0.3, 0.84, 0
522, 0.3, 0.9, 0
523, 0.3, 0.96, 0
524, 0.3, 1.02, 0
525, 0.3, 1.08, 0
526, 0.3, 1.14, 0
527, 0.35, 0.06, 0
528, 0.35, 0.12, 0
529, 0.35, 0.18, 0
530, 0.35, 0.24, 0
531, 0.35, 0.3, 0
532, 0.35, 0.36, 0
533, 0.35, 0.42, 0
534, 0.35, 0.48, 0
535, 0.35, 0.54, 0
536, 0.35, 0.6, 0
537, 0.35, 0.66, 0
538, 0.35, 0.72, 0
539, 0.35, 0.78, 0
540, 0.35, 0.84, 0
541, 0.35, 0.9, 0
542, 0.35, 0.96, 0
543, 0.35, 1.02, 0
544, 0.35, 1.08, 0
545, 0.35, 1.14, 0
546, 0.4, 0.06, 0
547, 0.4, 0.12, 0
548, 0.4, 0.18, 0
549, 0.4, 0.24, 0
550, 0.4, 0.3, 0
551, 0.4, 0.36, 0
552, 0.4, 0.42, 0
553, 0.4, 0.48, 0
554, 0.4, 0.54, 0
555, 0.4, 0.6, 0
556, 0.4, 0.66, 0
557, 0.4, 0.72, 0
558, 0.4, 0.78, 0
559, 0.4, 0.84, 0
560, 0.4, 0.9, 0
561, 0.4, 0.96, 0
562, 0.4, 1.02, 0
563, 0.4, 1.08, 0
564, 0.4, 1.14, 0
565, 0.45, 0.06, 0
566, 0.45, 0.12, 0
567, 0.45, 0.18, 0
568, 0.45, 0.24, 0
569, 0.45, 0.3, 0
570, 0.45, 0.36, 0
571, 0.45, 0.42, 0
572, 0.45, 0.48, 0
573, 0.45, 0.54, 0
574, 0.45, 0.6, 0
575, 0.45, 0.66, 0
576, 0.45, 0.72, 0
577, 0.45, 0.78, 0
578, 0.45, 0.84, 0
579, 0.45, 0.9, 0
580, 0.45, 0.96, 0
581, 0.45, 1.02, 0
582, 0.45, 1.08, 0
583, 0.45, 1.14, 0
584, 0.5, 0.06, 0
585, 0.5, 0.12, 0
586, 0.5, 0.18, 0
587, 0.5, 0.24, 0
588, 0.5, 0.3, 0
589, 0.5, 0.36, 0
590, 0.5, 0.42, 0
591, 0.5, 0.48, 0
592, 0.5, 0.54, 0
593, 0.5, 0.6, 0
594, 0.5, 0.66, 0
595, 0.5, 0.72, 0
596, 0.5, 0.78, 0
597, 0.5, 0.84, 0
598, 0.5, 0.9, 0
599, 0.5, 0.96, 0
600, 0.5, 1.02, 0
601, 0.5, 1.08, 0
602, 0.5, 1.14, 0
603, 0.55, 0.06, 0
604, 0.55, 0.12, 0
605, 0.55, 0.18, 0
606, 0.55, 0.24, 0
607, 0.55, 0.3, 0
608, 0.55, 0.36, 0
609, 0.55, 0.42, 0
610, 0.55, 0.48, 0
611, 0.55, 0.54, 0
612, 0.55, 0.6, 0
613, 0.55, 0.66, 0
614, 0.55, 0.72, 0
615, 0.55, 0.78, 0
616, 0.55, 0.84, 0
617, 0.55, 0.9, 0
618, 0.55, 0.96, 0
619, 0.55, 1.02, 0
620, 0.55, 1.08, 0
621, 0.55, 1.14, 0
622, 0.6, 0.06, 0
623, 0.6, 0.12, 0
624, 0.6, 0.18, 0
625, 0.6, 0.24, 0
626, 0.6, 0.3, 0
627, 0.6, 0.36, 0
628, 0.6, 0.42, 0
629, 0.6, 0.48, 0
630, 0.6, 0.54, 0
631, 0.6, 0.6, 0
632, 0.6, 0.66, 0
633, 0.6, 0.72, 0
634, 0.6, 0.78, 0
635, 0.6, 0.84, 0
636, 0.6, 0.9, 0
637, 0.6, 0.96, 0
638, 0.6, 1.02, 0
639, 0.6, 1.08, 0
640, 0.6, 1.14, 0
641, 0.65, 0.06, 0
642, 0.65, 0.12, 0
643, 0.65, 0.18, 0
644, 0.65, 0.24, 0
645, 0.65, 0.3, 0
646, 0.65, 0.36, 0
647, 0.65, 0.42, 0
648, 0.65, 0.48, 0
649, 0.65, 0.54, 0
650, 0.65, 0.6, 0
651, 0.65, 0.66, 0
652, 0.65, 0.72, 0
653, 0.65, 0.78, 0
654, 0.65, 0.84, 0
655, 0.65, 0.9, 0
656, 0.65, 0.96, 0
657, 0.65, 1.02, 0
658, 0.65, 1.08, 0
659, 0.65, 1.14, 0
660, 0.7, 0.06, 0
661, 0.7, 0.12, 0
662, 0.7, 0.18, 0
663, 0.7, 0.24, 0
664, 0.7, 0.3, 0
665, 0.7, 0.36, 0
666, 0.7, 0.42, 0
667, 0.7, 0.48, 0
668, 0.7, 0.54, 0
669, 0.7, 0.6, 0
670, 0.7, 0.66, 0
671, 0.7, 0.72, 0
672, 0.7, 0.78, 0
673, 0.7, 0.84, 0
674, 0.7, 0.9, 0
675, 0.7, 0.96, 0
676, 0.7, 1.02, 0
677, 0.7, 1.08, 0
678, 0.7, 1.14, 0
679, 0.75, 0.06, 0
680, 0.75, 0.12, 0
681, 0.75, 0.18, 0
682, 0.75, 0.24, 0
683, 0.75, 0.3, 0
684, 0.75, 0.36, 0
685, 0.75, 0.42, 0
686, 0.75, 0.48, 0
687, 0.75, 0.54, 0
688, 0.75, 0.6, 0
689, 0.75, 0.66, 0
690, 0.75, 0.72, 0
691, 0.75, 0.78, 0
692, 0.75, 0.84, 0
693, 0.75, 0.9, 0
694, 0.75, 0.96, 0
695, 0.75, 1.02, 0
696, 0.75, 1.08, 0
697, 0.75, 1.14, 0
698, 0.8, 0.06, 0
699, 0.8, 0.12, 0
700, 0.8, 0.18, 0
701, 0.8, 0.24, 0
702, 0.8, 0.3, 0
703, 0.8, 0.36, 0
704, 0.8, 0.42, 0
705, 0.8, 0.48, 0
706, 0.8, 0.54, 0
707, 0.8, 0.6, 0
708, 0.8, 0.66, 0
709, 0.8, 0.72, 0
710, 0.8, 0.78, 0
711, 0.8, 0.84, 0
712, 0.8, 0.9, 0
713, 0.8, 0.96, 0
714, 0.8, 1.02, 0
715, 0.8, 1.08, 0
716, 0.8, 1.14, 0
717, 0.85, 0.06, 0
718, 0.85, 0.12, 0
719, 0.85, 0.18, 0
720, 0.85, 0.24, 0
721, 0.85, 0.3, 0
722, 0.85, 0.36, 0
723, 0.85, 0.42, 0
724, 0.85, 0.48, 0
725, 0.85, 0.54, 0
726, 0.85, 0.6, 0
727, 0.85, 0.66, 0
728, 0.85, 0.72, 0
729, 0.85, 0.78, 0
730, 0.85, 0.84, 0
731, 0.85, 0.9, 0
732, 0.85, 0.96, 0
733, 0.85, 1.02, 0
734, 0.85, 1.08, 0
735, 0.85, 1.14, 0
736, 0.9, 0.06, 0
737, 0.9, 0.12, 0
738, 0.9, 0.18, 0
739, 0.9, 0.24, 0
740, 0.9, 0.3, 0
741, 0.9, 0.36, 0
742, 0.9, 0.42, 0
743, 0.9, 0.48, 0
744, 0.9, 0.54, 0
745, 0.9, 0.6, 0
746, 0.9, 0.66, 0
747, 0.9, 0.72, 0
748, 0.9, 0.78, 0
749, 0.9, 0.84, 0
750, 0.9, 0.9, 0
751, 0.9, 0.96, 0
752, 0.9, 1.02, 0
753, 0.9, 1.08, 0
754, 0.9, 1.14, 0
755, 0.95, 0.06, 0
756, 0.95, 0.12, 0
757, 0.95, 0.18, 0
758, 0.95, 0.24, 0
759, 0.95, 0.3, 0
760, 0.95, 0.36, 0
761, 0.95, 0.42, 0
762, 0.95, 0.48, 0
763, 0.95, 0.54, 0
764, 0.95, 0.6, 0
765, 0.95, 0.66, 0
766, 0.95, 0.72, 0
767, 0.95, 0.78, 0
768, 0.95, 0.84, 0
769, 0.95, 0.9, 0
770, 0.95, 0.96, 0
771, 0.95, 1.02, 0
772, 0.95, 1.08, 0
773, 0.95, 1.14, 0
774, 0.95, 1.2333333333333, 0
775, 0.9, 1.2333333333333, 0
776, 0.85, 1.2333333333333, 0
777, 0.8, 1.2333333333333, 0
778, 0.75, 1.2333333333333, 0
779, 0.7, 1.2333333333333, 0
780, 0.65, 1.2333333333333, 0
781, 0.6, 1.2333333333333, 0
782, 0.55, 1.2333333333333, 0
783, 0.5, 1.2333333333333, 0
784, 0.45, 1.2333333333333, 0
785, 0.4, 1.2333333333333, 0
786, 0.35, 1.2333333333333, 0
787, 0.3, 1.2333333333333, 0
788, 0.25, 1.2333333333333, 0
789, 0.2, 1.2333333333333, 0
790, 0.15, 1.2333333333333, 0
791, 0.1, 1.2333333333333, 0
792, 0.05, 1.2333333333333, 0
793, 0.95, 1.2666666666667, 0
794, 0.9, 1.2666666666667, 0
795, 0.85, 1.2666666666667, 0
796, 0.8, 1.2666666666667, 0
797, 0.75, 1.2666666666667, 0
798, 0.7, 1.2666666666667, 0
799, 0.65, 1.2666666666667, 0
800, 0.6, 1.2666666666667, 0
801, 0.55, 1.2666666666667, 0
802, 0.5, 1.2666666666667, 0
803, 0.45, 1.2666666666667, 0
804, 0.4, 1.2666666666667, 0
805, 0.35, 1.2666666666667, 0
806, 0.3, 1.2666666666667, 0
807, 0.25, 1.2666666666667, 0
808, 0.2, 1.2666666666667, 0
809, 0.15, 1.2666666666667, 0
810, 0.1, 1.2666666666667, 0
811, 0.05, 1.2666666666667, 0
812, 1.04, 1.2333333333333, 0
813, 1.04, 1.2666666666667, 0
814, 1.08, 1.2333333333333, 0
815, 1.08, 1.2666666666667, 0
816, 1.12, 1.2333333333333, 0
817, 1.12, 1.2666666666667, 0
818, 1.16, 1.2333333333333, 0
819, 1.16, 1.2666666666667, 0
820, 1.25, 1.2333333333333, 0
821, 1.25, 1.2666666666667, 0
822, 1.3, 1.2333333333333, 0
823, 1.3, 1.2666666666667, 0
824, 1.35, 1.2333333333333, 0
825, 1.35, 1.2666666666667, 0
826, 1.4, 1.2333333333333, 0
827, 1.4, 1.2666666666667, 0
828, 1.45, 1.2333333333333, 0
829, 1.45, 1.2666666666667, 0
830, 1.5, 1.2333333333333, 0
831, 1.5, 1.2666666666667, 0
832, 1.55, 1.2333333333333, 0
833, 1.55, 1.2666666666667, 0
834, 1.6, 1.2333333333333, 0
835, 1.6, 1.2666666666667, 0
836, 1.65, 1.2333333333333, 0
837, 1.65, 1.2666666666667, 0
838, 1.7, 1.2333333333333, 0
839, 1.7, 1.2666666666667, 0
840, 1.75, 1.2333333333333, 0
841, 1.75, 1.2666666666667, 0
842, 1.8, 1.2333333333333, 0
843, 1.8, 1.2666666666667, 0
844, 1.85, 1.2333333333333, 0
845, 1.85, 1.2666666666667, 0
846, 1.9, 1.2333333333333, 0
847, 1.9, 1.2666666666667, 0
848, 1.95, 1.2333333333333, 0
849, 1.95, 1.2666666666667, 0
850, 2, 1.2333333333333, 0
851, 2, 1.2666666666667, 0
852, 2.05, 1.2333333333333, 0
853, 2.05, 1.2666666666667, 0
854, 2.1, 1.2333333333333, 0
855, 2.1, 1.2666666666667, 0
856, 2.15, 1.2333333333333, 0
857, 2.15, 1.2666666666667, 0
858, 1.25, 1.14, 0
859, 1.3, 1.14, 0
860, 1.35, 1.14, 0
861, 1.4, 1.14, 0
862, 1.45, 1.14, 0
863, 1.5, 1.14, 0
864, 1.55, 1.14, 0
865, 1.6, 1.14, 0
866, 1.65, 1.14, 0
867, 1.7, 1.14, 0
868, 1.75, 1.14, 0
869, 1.8, 1.14, 0
870, 1.85, 1.14, 0
871, 1.9, 1.14, 0
872, 1.95, 1.14, 0
873, 2, 1.14, 0
874, 2.05, 1.14, 0
875, 2.1, 1.14, 0
876, 2.15, 1.14, 0
877, 1.25, 1.08, 0
878, 1.3, 1.08, 0
879, 1.35, 1.08, 0
880, 1.4, 1.08, 0
881, 1.45, 1.08, 0
882, 1.5, 1.08, 0
883, 1.55, 1.08, 0
884, 1.6, 1.08, 0
885, 1.65, 1.08, 0
886, 1.7, 1.08, 0
887, 1.75, 1.08, 0
888, 1.8, 1.08, 0
889, 1.85, 1.08, 0
890, 1.9, 1.08, 0
891, 1.95, 1.08, 0
892, 2, 1.08, 0
893, 2.05, 1.08, 0
894, 2.1, 1.08, 0
895, 2.15, 1.08, 0
896, 1.25, 1.02, 0
897, 1.3, 1.02, 0
898, 1.35, 1.02, 0
899, 1.4, 1.02, 0
900, 1.45, 1.02, 0
901, 1.5, 1.02, 0
902, 1.55, 1.02, 0
903, 1.6, 1.02, 0
904, 1.65, 1.02, 0
905, 1.7, 1.02, 0
906, 1.75, 1.02, 0
907, 1.8, 1.02, 0
908, 1.85, 1.02, 0
909, 1.9, 1.02, 0
910, 1.95, 1.02, 0
911, 2, 1.02, 0
912, 2.05, 1.02, 0
913, 2.1, 1.02, 0
914, 2.15, 1.02, 0
915, 1.25, 0.96, 0
916, 1.3, 0.96, 0
917, 1.35, 0.96, 0
918, 1.4, 0.96, 0
919, 1.45, 0.96, 0
920, 1.5, 0.96, 0
921, 1.55, 0.96, 0
922, 1.6, 0.96, 0
923, 1.65, 0.96, 0
924, 1.7, 0.96, 0
925, 1.75, 0.96, 0
926, 1.8, 0.96, 0
927, 1.85, 0.96, 0
928, 1.9, 0.96, 0
929, 1.95, 0.96, 0
930, 2, 0.96, 0
931, 2.05, 0.96, 0
932, 2.1, 0.96, 0
933, 2.15, 0.96, 0
934, 1.25, 0.9, 0
935, 1.3, 0.9, 0
936, 1.35, 0.9, 0
937, 1.4, 0.9, 0
938, 1.45, 0.9, 0
939, 1.5, 0.9, 0
940, 1.55, 0.9, 0
941, 1.6, 0.9, 0
942, 1.65, 0.9, 0
943, 1.7, 0.9, 0
944, 1.75, 0.9, 0
945, 1.8, 0.9, 0
946, 1.85, 0.9, 0
947, 1.9, 0.9, 0
948, 1.95, 0.9, 0
949, 2, 0.9, 0
950, 2.05, 0.9, 0
951, 2.1, 0.9, 0
952, 2.15, 0.9, 0
953, 1.25, 0.84, 0
954, 1.3, 0.84, 0
955, 1.35, 0.84, 0
956, 1.4, 0.84, 0
957, 1.45, 0.84, 0
958, 1.5, 0.84, 0
959, 1.55, 0.84, 0
960, 1.6, 0.84, 0
961, 1.65, 0.84, 0
962, 1.7, 0.84, 0
963, 1.75, 0.84, 0
964, 1.8, 0.84, 0
965, 1.85, 0.84, 0
966, 1.9, 0.84, 0
967, 1.95, 0.84, 0
968, 2, 0.84, 0
969, 2.05, 0.84, 0
970, 2.1, 0.84, 0
971, 2.15, 0.84, 0
972, 1.25, 0.78, 0
973, 1.3, 0.78, 0
974, 1.35, 0.78, 0
975, 1.4, 0.78, 0
976, 1.45, 0.78, 0
977, 1.5, 0.78, 0
978, 1.55, 0.78, 0
979, 1.6, 0.78, 0
980, 1.65, 0.78, 0
981, 1.7, 0.78, 0
982, 1.75, 0.78, 0
983, 1.8, 0.78, 0
984, 1.85, 0.78, 0
985, 1.9, 0.78, 0
986, 1.95, 0.78, 0
987, 2, 0.78, 0
988, 2.05, 0.78, 0
989, 2.1, 0.78, 0
990, 2.15, 0.78, 0
991, 1.25, 0.72, 0
992, 1.3, 0.72, 0
993, 1.35, 0.72, 0
994, 1.4, 0.72, 0
995, 1.45, 0.72, 0
996, 1.5, 0.72, 0
997, 1.55, 0.72, 0
998, 1.6, 0.72, 0
999, 1.65, 0.72, 0
1000, 1.7, 0.72, 0
1001, 1.75, 0.72, 0
1002, 1.8, 0.72, 0
1003, 1.85, 0.72, 0
1004, 1.9, 0.72, 0
1005, 1.95, 0.72, 0
1006, 2, 0.72, 0
1007, 2.05, 0.72, 0
1008, 2.1, 0.72, 0
1009, 2.15, 0.72, 0
1010, 1.25, 0.66, 0
1011, 1.3, 0.66, 0
1012, 1.35, 0.66, 0
1013, 1.4, 0.66, 0
1014, 1.45, 0.66, 0
1015, 1.5, 0.66, 0
1016, 1.55, 0.66, 0
1017, 1.6, 0.66, 0
1018, 1.65, 0.66, 0
1019, 1.7, 0.66, 0
1020, 1.75, 0.66, 0
1021, 1.8, 0.66, 0
1022, 1.85, 0.66, 0
1023, 1.9, 0.66, 0
1024, 1.95, 0.66, 0
1025, 2, 0.66, 0
1026, 2.05, 0.66, 0
1027, 2.1, 0.66, 0
1028, 2.15, 0.66, 0
1029, 1.25, 0.6, 0
1030, 1.3, 0.6, 0
1031, 1.35, 0.6, 0
1032, 1.4, 0.6, 0
1033, 1.45, 0.6, 0
1034, 1.5, 0.6, 0
1035, 1.55, 0.6, 0
1036, 1.6, 0.6, 0
1037, 1.65, 0.6, 0
1038, 1.7, 0.6, 0
1039, 1.75, 0.6, 0
1040, 1.8, 0.6, 0
1041, 1.85, 0.6, 0
1042, 1.9, 0.6, 0
1043, 1.95, 0.6, 0
1044, 2, 0.6, 0
1045, 2.05, 0.6, 0
1046, 2.1, 0.6, 0
1047, 2.15, 0.6, 0
1048, 1.25, 0.54, 0
1049, 1.3, 0.54, 0
1050, 1.35, 0.54, 0
1051, 1.4, 0.54, 0
1052, 1.45, 0.54, 0
1053, 1.5, 0.54, 0
1054, 1.55, 0.54, 0
1055, 1.6, 0.54, 0
1056, 1.65, 0.54, 0
1057, 1.7, 0.54, 0
1058, 1.75, 0.54, 0
1059, 1.8, 0.54, 0
1060, 1.85, 0.54, 0
1061, 1.9, 0.54, 0
1062, 1.95, 0.54, 0
1063, 2, 0.54, 0
1064, 2.05, 0.54, 0
1065, 2.1, 0.54, 0
1066, 2.15, 0.54, 0
1067, 1.25, 0.48, 0
1068, 1.3, 0.48, 0
1069, 1.35, 0.48, 0
1070, 1.4, 0.48, 0
1071, 1.45, 0.48, 0
1072, 1.5, 0.48, 0
1073, 1.55, 0.48, 0
1074, 1.6, 0.48, 0
1075, 1.65, 0.48, 0
1076, 1.7, 0.48, 0
1077, 1.75, 0.48, 0
1078, 1.8, 0.48, 0
1079, 1.85, 0.48, 0
1080, 1.9, 0.48, 0
1081, 1.95, 0.48, 0
1082, 2, 0.48, 0
1083, 2.05, 0.48, 0
1084, 2.1, 0.48, 0
1085, 2.15, 0.48, 0
1086, 1.25, 0.42, 0
1087, 1.3, 0.42, 0
1088, 1.35, 0.42, 0
1089, 1.4, 0.42, 0
1090, 1.45, 0.42, 0
1091, 1.5, 0.42, 0
1092, 1.55, 0.42, 0
1093, 1.6, 0.42, 0
1094, 1.65, 0.42, 0
1095, 1.7, 0.42, 0
1096, 1.75, 0.42, 0
1097, 1.8, 0.42, 0
1098, 1.85, 0.42, 0
1099, 1.9, 0.42, 0
1100, 1.95, 0.42, 0
1101, 2, 0.42, 0
1102, 2.05, 0.42, 0
1103, 2.1, 0.42, 0
1104, 2.15, 0.42, 0
1105, 1.25, 0.36, 0
1106, 1.3, 0.36, 0
1107, 1.35, 0.36, 0
1108, 1.4, 0.36, 0
1109, 1.45, 0.36, 0
1110, 1.5, 0.36, 0
1111, 1.55, 0.36, 0
1112, 1.6, 0.36, 0
1113, 1.65, 0.36, 0
1114, 1.7, 0.36, 0
1115, 1.75, 0.36, 0
1116, 1.8, 0.36, 0
1117, 1.85, 0.36, 0
1118, 1.9, 0.36, 0
1119, 1.95, 0.36, 0
1120, 2, 0.36, 0
1121, 2.05, 0.36, 0
1122, 2.1, 0.36, 0
1123, 2.15, 0.36, 0
1124, 1.25, 0.3, 0
1125, 1.3, 0.3, 0
1126, 1.35, 0.3, 0
1127, 1.4, 0.3, 0
1128, 1.45, 0.3, 0
1129, 1.5, 0.3, 0
1130, 1.55, 0.3, 0
1131, 1.6, 0.3, 0
1132, 1.65, 0.3, 0
1133, 1.7, 0.3, 0
1134, 1.75, 0.3, 0
1135, 1.8, 0.3, 0
1136, 1.85, 0.3, 0
1137, 1.9, 0.3, 0
1138, 1.95, 0.3, 0
1139, 2, 0.3, 0
1140, 2.05, 0.3, 0
1141, 2.1, 0.3, 0
1142, 2.15, 0.3, 0
1143, 1.25, 0.24, 0
1144, 1.3, 0.24, 0
1145, 1.35, 0.24, 0
1146, 1.4, 0.24, 0
1147, 1.45, 0.24, 0
1148, 1.5, 0.24, 0
1149, 1.55, 0.24, 0
1150, 1.6, 0.24, 0
1151, 1.65, 0.24, 0
1152, 1.7, 0.24, 0
1153, 1.75, 0.24, 0
1154, 1.8, 0.24, 0
1155, 1.85, 0.24, 0
1156, 1.9, 0.24, 0
1157, 1.95, 0.24, 0
1158, 2, 0.24, 0
1159, 2.05, 0.24, 0
1160, 2.1, 0.24, 0
1161, 2.15, 0.24, 0
1162, 1.25, 0.18, 0
1163, 1.3, 0.18, 0
1164, 1.35, 0.18, 0
1165, 1.4, 0.18, 0
1166, 1.45, 0.18, 0
1167, 1.5, 0.18, 0
1168, 1.55, 0.18, 0
1169, 1.6, 0.18, 0
1170, 1.65, 0.18, 0
1171, 1.7, 0.18, 0
1172, 1.75, 0.18, 0
1173, 1.8, 0.18, 0
1174, 1.85, 0.18, 0
1175, 1.9, 0.18, 0
1176, 1.95, 0.18, 0
1177, 2, 0.18, 0
1178, 2.05, 0.18, 0
1179, 2.1, 0.18, 0
1180, 2.15, 0.18, 0
1181, 1.25, 0.12, 0
1182, 1.3, 0.12, 0
1183, 1.35, 0.12, 0
1184, 1.4, 0.12, 0
1185, 1.45, 0.12, 0
1186, 1.5, 0.12, 0
1187, 1.55, 0.12, 0
1188, 1.6, 0.12, 0
1189, 1.65, 0.12, 0
1190, 1.7, 0.12, 0
1191, 1.75, 0.12, 0
1192, 1.8, 0.12, 0
1193, 1.85, 0.12, 0
1194, 1.9, 0.12, 0
1195, 1.95, 0.12, 0
1196, 2, 0.12, 0
1197, 2.05, 0.12, 0
1198, 2.1, 0.12, 0
1199, 2.15, 0.12, 0
1200, 1.25, 0.06, 0
1201, 1.3, 0.06, 0
1202, 1.35, 0.06, 0
1203, 1.4, 0.06, 0
1204, 1.45, 0.06, 0
1205, 1.5, 0.06, 0
1206, 1.55, 0.06, 0
1207, 1.6, 0.06, 0
1208, 1.65, 0.06, 0
1209, 1.7, 0.06, 0
1210, 1.75, 0.06, 0
1211, 1.8, 0.06, 0
1212, 1.85, 0.06, 0
1213, 1.9, 0.06, 0
1214, 1.95, 0.06, 0
1215, 2, 0.06, 0
1216, 2.05, 0.06, 0
1217, 2.1, 0.06, 0
1218, 2.15, 0.06, 0
1219, 1.25, -0.033333333333333, 0
1220, 1.3, -0.033333333333333, 0
1221, 1.35, -0.033333333333333, 0
1222, 1.4, -0.033333333333333, 0
1223, 1.45, -0.033333333333333, 0
1224, 1.5, -0.033333333333333, 0
1225, 1.55, -0.033333333333333, 0
1226, 1.6, -0.033333333333333, 0
1227, 1.65, -0.033333333333333, 0
1228, 1.7, -0.033333333333333, 0
1229, 1.75, -0.033333333333333, 0
1230, 1.8, -0.033333333333333, 0
1231, 1.85, -0.033333333333333, 0
1232, 1.9, -0.033333333333333, 0
1233, 1.95, -0.033333333333333, 0
1234, 2, -0.033333333333333, 0
1235, 2.05, -0.033333333333333, 0
1236, 2.1, -0.033333333333333, 0
1237, 2.15, -0.033333333333333, 0
1238, 1.25, -0.066666666666667, 0
1239, 1.3, -0.066666666666667, 0
1240, 1.35, -0.066666666666667, 0
1241, 1.4, -0.066666666666667, 0
1242, 1.45, -0.066666666666667, 0
1243, 1.5, -0.066666666666667, 0
1244, 1.55, -0.066666666666667, 0
1245, 1.6, -0.066666666666667, 0
1246, 1.65, -0.066666666666667, 0
1247, 1.7, -0.066666666666667, 0
1248, 1.75, -0.066666666666667, 0
1249, 1.8, -0.066666666666667, 0
1250, 1.85, -0.066666666666667, 0
1251, 1.9, -0.066666666666667, 0
1252, 1.95, -0.066666666666667, 0
1253, 2, -0.066666666666667, 0
1254, 2.05, -0.066666666666667, 0
1255, 2.1, -0.066666666666667, 0
1256, 2.15, -0.066666666666667, 0
1257, 0.05, -0.033333333333333, 0
1258, 0.1, -0.033333333333333, 0
1259, 0.15, -0.033333333333333, 0
1260, 0.2, -0.033333333333333, 0
1261, 0.25, -0.033333333333333, 0
1262, 0.3, -0.033333333333333, 0
1263, 0.35, -0.033333333333333, 0
1264, 0.4, -0.033333333333333, 0
1265, 0.45, -0.033333333333333, 0
1266, 0.5, -0.033333333333333, 0
1267, 0.55, -0.033333333333333, 0
1268, 0.6, -0.033333333333333, 0
1269, 0.65, -0.033333333333333, 0
1270, 0.7, -0.033333333333333, 0
1271, 0.75, -0.033333333333333, 0
1272, 0.8, -0.033333333333333, 0
1273, 0.85, -0.033333333333333, 0
1274, 0.9, -0.033333333333333, 0
1275, 0.95, -0.033333333333333, 0
1276, 0.05, -0.066666666666667, 0
1277, 0.1, -0.066666666666667, 0
1278, 0.15, -0.066666666666667, 0
1279, 0.2, -0.066666666666667, 0
1280, 0.25, -0.066666666666667, 0
1281, 0.3, -0.066666666666667, 0
1282, 0.35, -0.066666666666667, 0
1283, 0.4, -0.066666666666667, 0
1284, 0.45, -0.066666666666667, 0
1285, 0.5, -0.066666666666667, 0
1286, 0.55, -0.066666666666667, 0
1287, 0.6, -0.066666666666667, 0
1288, 0.65, -0.066666666666667, 0
1289, 0.7, -0.066666666666667, 0
1290, 0.75, -0.066666666666667, 0
1291, 0.8, -0.066666666666667, 0
1292, 0.85, -0.066666666666667, 0
1293, 0.9, -0.066666666666667, 0
1294, 0.95, -0.066666666666667, 0
1295, 2.25, -0.033333333333333, 0
1296, 2.25, -0.066666666666667, 0
1297, -0.05, -0.033333333333333, 0
1298, -0.05, -0.066666666666667, 0
1299, 0.05, -0.14, 0
1300, 0.1, -0.14, 0
1301, 0.15, -0.14, 0
1302, 0.2, -0.14, 0
1303, 0.25, -0.14, 0
1304, 0.3, -0.14, 0
1305, 0.35, -0.14, 0
1306, 0.4, -0.14, 0
1307, 0.45, -0.14, 0
1308, 0.5, -0.14, 0
1309, 0.55, -0.14, 0
1310, 0.6, -0.14, 0
1311, 0.65, -0.14, 0
1312, 0.7, -0.14, 0
1313, 0.75, -0.14, 0
1314, 0.8, -0.14, 0
1315, 0.85, -0.14, 0
1316, 0.9, -0.14, 0
1317, 0.95, -0.14, 0
1318, 0.05, -0.18, 0
1319, 0.1, -0.18, 0
1320, 0.15, -0.18, 0
1321, 0.2, -0.18, 0
1322, 0.25, -0.18, 0
1323, 0.3, -0.18, 0
1324, 0.35, -0.18, 0
1325, 0.4, -0.18, 0
1326, 0.45, -0.18, 0
1327, 0.5, -0.18, 0
1328, 0.55, -0.18, 0
1329, 0.6, -0.18, 0
1330, 0.65, -0.18, 0
1331, 0.7, -0.18, 0
1332, 0.75, -0.18, 0
1333, 0.8, -0.18, 0
1334, 0.85, -0.18, 0
1335, 0.9, -0.18, 0
1336, 0.95, -0.18, 0
1337, 0.05, -0.22, 0
1338, 0.1, -0.22, 0
1339, 0.15, -0.22, 0
1340, 0.2, -0.22, 0
1341, 0.25, -0.22, 0
1342, 0.3, -0.22, 0
1343, 0.35, -0.22, 0
1344, 0.4, -0.22, 0
1345, 0.45, -0.22, 0
1346, 0.5, -0.22, 0
1347, 0.55, -0.22, 0
1348, 0.6, -0.22, 0
1349, 0.65, -0.22, 0
1350, 0.7, -0.22, 0
1351, 0.75, -0.22, 0
1352, 0.8, -0.22, 0
1353, 0.85, -0.22, 0
1354, 0.9, -0.22, 0
1355, 0.95, -0.22, 0
1356, 0.05, -0.26, 0
1357, 0.1, -0.26, 0
1358, 0.15, -0.26, 0
1359, 0.2, -0.26, 0
1360, 0.25, -0.26, 0
1361, 0.3, -0.26, 0
1362, 0.35, -0.26, 0
1363, 0.4, -0.26, 0
1364, 0.45, -0.26, 0
1365, 0.5, -0.26, 0
1366, 0.55, -0.26, 0
1367, 0.6, -0.26, 0
1368, 0.65, -0.26, 0
1369, 0.7, -0.26, 0
1370, 0.75, -0.26, 0
1371, 0.8, -0.26, 0
1372, 0.85, -0.26, 0
1373, 0.9, -0.26, 0
1374, 0.95, -0.26, 0
1375, -0.05, -0.14, 0
1376, -0.05, -0.18, 0
1377, -0.05, -0.22, 0
1378, -0.05, -0.26, 0
1379, 1.25, -0.14, 0
1380, 1.3, -0.14, 0
1381, 1.35, -0.14, 0
1382, 1.4, -0.14, 0
1383, 1.45, -0.14, 0
1384, 1.5, -0.14, 0
1385, 1.55, -0.14, 0
1386, 1.6, -0.14, 0
1387, 1.65, -0.14, 0
1388, 1.7, -0.14, 0
1389, 1.75, -0.14, 0
1390, 1.8, -0.14, 0
1391, 1.85, -0.14, 0
1392, 1.9, -0.14, 0
1393, 1.95, -0.14, 0
1394, 2, -0.14, 0
1395, 2.05, -0.14, 0
1396, 2.1, -0.14, 0
1397, 2.15, -0.14, 0
1398, 1.25, -0.18, 0
1399, 1.3, -0.18, 0
1400, 1.35, -0.18, 0
1401, 1.4, -0.18, 0
1402, 1.45, -0.18, 0
1403, 1.5, -0.18, 0
1404, 1.55, -0.18, 0
1405, 1.6, -0.18, 0
1406, 1.65, -0.18, 0
1407, 1.7, -0.18, 0
1408, 1.75, -0.18, 0
1409, 1.8, -0.18, 0
1410, 1.85, -0.18, 0
1411, 1.9, -0.18, 0
1412, 1.95, -0.18, 0
1413, 2, -0.18, 0
1414, 2.05, -0.18, 0
1415, 2.1, -0.18, 0
1416, 2.15, -0.18, 0
1417, 1.25, -0.22, 0
1418, 1.3, -0.22, 0
1419, 1.35, -0.22, 0
1420, 1.4, -0.22, 0
1421, 1.45, -0.22, 0
1422, 1.5, -0.22, 0
1423, 1.55, -0.22, 0
1424, 1.6, -0.22, 0
1425, 1.65, -0.22, 0
1426, 1.7, -0.22, 0
1427, 1.75, -0.22, 0
1428, 1.8, -0.22, 0
1429, 1.85, -0.22, 0
1430, 1.9, -0.22, 0
1431, 1.95, -0.22, 0
1432, 2, -0.22, 0
1433, 2.05, -0.22, 0
1434, 2.1, -0.22, 0
1435, 2.15, -0.22, 0
1436, 1.25, -0.26, 0
1437, 1.3, -0.26, 0
1438, 1.35, -0.26, 0
1439, 1.4, -0.26, 0
1440, 1.45, -0.26, 0
1441, 1.5, -0.26, 0
1442, 1.55, -0.26, 0
1443, 1.6, -0.26, 0
1444, 1.65, -0.26, 0
1445, 1.7, -0.26, 0
1446, 1.75, -0.26, 0
1447, 1.8, -0.26, 0
1448, 1.85, -0.26, 0
1449, 1.9, -0.26, 0
1450, 1.95, -0.26, 0
1451, 2, -0.26, 0
1452, 2.05, -0.26, 0
1453, 2.1, -0.26, 0
1454, 2.15, -0.26, 0
1455, 2.25, -0.14, 0
1456, 2.25, -0.18, 0
1457, 2.25, -0.22, 0
1458, 2.25, -0.26, 0
1459, 0.95, 1.34, 0
1460, 0.9, 1.34, 0
1461, 0.85, 1.34, 0
1462, 0.8, 1.34, 0
1463, 0.75, 1.34, 0
1464, 0.7, 1.34, 0
1465, 0.65, 1.34, 0
1466, 0.6, 1.34, 0
1467, 0.55, 1.34, 0
1468, 0.5, 1.34, 0
1469, 0.45, 1.34, 0
1470, 0.4, 1.34, 0
1471, 0.35, 1.34, 0
1472, 0.3, 1.34, 0
1473, 0.25, 1.34, 0
1474, 0.2, 1.34, 0
1475, 0.15, 1.34, 0
1476, 0.1, 1.34, 0
1477, 0.05, 1.34, 0
1478, 0.95, 1.38, 0
1479, 0.9, 1.38, 0
1480, 0.85, 1.38, 0
1481, 0.8, 1.38, 0
1482, 0.75, 1.38, 0
1483, 0.7, 1.38, 0
1484, 0.65, 1.38, 0
1485, 0.6, 1.38, 0
1486, 0.55, 1.38, 0
1487, 0.5, 1.38, 0
1488, 0.45, 1.38, 0
1489, 0.4, 1.38, 0
1490, 0.35, 1.38, 0
1491, 0.3, 1.38, 0
1492, 0.25, 1.38, 0
1493, 0.2, 1.38, 0
1494, 0.15, 1.38, 0
1495, 0.1, 1.38, 0
1496, 0.05, 1.38, 0
1497, 0.95, 1.42, 0
1498, 0.9, 1.42, 0
1499, 0.85, 1.42, 0
1500, 0.8, 1.42, 0
1501, 0.75, 1.42, 0
1502, 0.7, 1.42, 0
1503, 0.65, 1.42, 0
1504, 0.6, 1.42, 0
1505, 0.55, 1.42, 0
1506, 0.5, 1.42, 0
1507, 0.45, 1.42, 0
1508, 0.4, 1.42, 0
1509, 0.35, 1.42, 0
1510, 0.3, 1.42, 0
1511, 0.25, 1.42, 0
1512, 0.2, 1.42, 0
1513, 0.15, 1.42, 0
1514, 0.1, 1.42, 0
1515, 0.05, 1.42, 0
1516, 0.95, 1.46, 0
1517, 0.9, 1.46, 0
1518, 0.85, 1.46, 0
1519, 0.8, 1.46, 0
1520, 0.75, 1.46, 0
1521, 0.7, 1.46, 0
1522, 0.65, 1.46, 0
1523, 0.6, 1.46, 0
1524, 0.55, 1.46, 0
1525, 0.5, 1.46, 0
1526, 0.45, 1.46, 0
1527, 0.4, 1.46, 0
1528, 0.35, 1.46, 0
1529, 0.3, 1.46, 0
1530, 0.25, 1.46, 0
1531, 0.2, 1.46, 0
1532, 0.15, 1.46, 0
1533, 0.1, 1.46, 0
1534, 0.05, 1.46, 0
1535, 1.04, 1.34, 0
1536, 1.08, 1.34, 0
1537, 1.12, 1.34, 0
1538, 1.16, 1.34, 0
1539, 1.04, 1.38, 0
1540, 1.08, 1.38, 0
1541, 1.12, 1.38, 0
1542, 1.16, 1.38, 0
1543, 1.04, 1.42, 0
1544, 1.08, 1.42, 0
1545, 1.12, 1.42, 0
1546, 1.16, 1.42, 0
1547, 1.04, 1.46, 0
1548, 1.08, 1.46, 0
1549, 1.12, 1.46, 0
1550, 1.16, 1.46, 0
1551, 1.25, 1.34, 0
1552, 1.3, 1.34, 0
1553, 1.35, 1.34, 0
1554, 1.4, 1.34, 0
1555, 1.45, 1.34, 0
1556, 1.5, 1.34, 0
1557, 1.55, 1.34, 0
1558, 1.6, 1.34, 0
1559, 1.65, 1.34, 0
1560, 1.7, 1.34, 0
1561, 1.75, 1.34, 0
1562, 1.8, 1.34, 0
1563, 1.85, 1.34, 0
1564, 1.9, 1.34, 0
1565, 1.95, 1.34, 0
1566, 2, 1.34, 0
1567, 2.05, 1.34, 0
1568, 2.1, 1.34, 0
1569, 2.15, 1.34, 0
1570, 1.25, 1.38, 0
1571, 1.3, 1.38, 0
1572, 1.35, 1.38, 0
1573, 1.4, 1.38, 0
1574, 1.45, 1.38, 0
1575, 1.5, 1.38, 0
1576, 1.55, 1.38, 0
1577, 1.6, 1.38, 0
1578, 1.65, 1.38, 0
1579, 1.7, 1.38, 0
1580, 1.75, 1.38, 0
1581, 1.8, 1.38, 0
1582, 1.85, 1.38, 0
1583, 1.9, 1.38, 0
1584, 1.95, 1.38, 0
1585, 2, 1.38, 0
1586, 2.05, 1.38, 0
1587, 2.1, 1.38, 0
1588, 2.15, 1.38, 0
1589, 1.25, 1.42, 0
1590, 1.3, 1.42, 0
1591, 1.35, 1.42, 0
1592, 1.4, 1.42, 0
1593, 1.45, 1.42, 0
1594, 1.5, 1.42, 0
1595, 1.55, 1.42, 0
1596, 1.6, 1.42, 0
1597, 1.65, 1.42, 0
1598, 1.7, 1.42, 0
1599, 1.75, 1.42, 0
1600, 1.8, 1.42, 0
1601, 1.85, 1.42, 0
1602, 1.9, 1.42, 0
1603, 1.95, 1.42, 0
1604, 2, 1.42, 0
1605, 2.05, 1.42, 0
1606, 2.1, 1.42, 0
1607, 2.15, 1.42, 0
1608, 1.25, 1.46, 0
1609, 1.3, 1.46, 0
1610, 1.35, 1.46, 0
1611, 1.4, 1.46, 0
1612, 1.45, 1.46, 0
1613, 1.5, 1.46, 0
1614, 1.55, 1.46, 0
1615, 1.6, 1.46, 0
1616, 1.65, 1.46, 0
1617, 1.7, 1.46, 0
1618, 1.75, 1.46, 0
1619, 1.8, 1.46, 0
1620, 1.85, 1.46, 0
1621, 1.9, 1.46, 0
1622, 1.95, 1.46, 0
1623, 2, 1.46, 0
1624, 2.05, 1.46, 0
1625, 2.1, 1.46, 0
1626, 2.15, 1.46, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
1727, 1, 31
1728, 31, 32
1729, 32, 33
1730, 33, 34
1731, 34, 35
1732, 35, 36
1733, 36, 37
1734, 37, 38
1735, 38, 39
1736, 39, 40
1737, 40, 41
1738, 41, 42
1739, 42, 43
1740, 43, 44
1741, 44, 45
1742, 45, 46
1743, 46, 47
1744, 47, 48
1745, 48, 49
1746, 49, 2
*ELEMENT, type=T3D2, ELSET=Line2
1747, 2, 50
1748, 50, 51
1749, 51, 52
1750, 52, 53
1751, 53, 54
1752, 54, 55
1753, 55, 56
1754, 56, 57
1755, 57, 58
1756, 58, 59
1757, 59, 60
1758, 60, 61
1759, 61, 62
1760, 62, 63
1761, 63, 64
1762, 64, 65
1763, 65, 66
1764, 66, 67
1765, 67, 68
1766, 68, 3
*ELEMENT, type=T3D2, ELSET=Line3
1767, 3, 69
1768, 69, 70
1769, 70, 71
1770, 71, 72
1771, 72, 73
1772, 73, 74
1773, 74, 75
1774, 75, 76
1775, 76, 77
1776, 77, 78
1777, 78, 79
1778, 79, 80
1779, 80, 81
1780, 81, 82
1781, 82, 83
1782, 83, 84
1783, 84, 85
1784, 85, 86
1785, 86, 87
1786, 87, 4
*ELEMENT, type=T3D2, ELSET=Line4
1787, 4, 88
1788, 88, 89
1789, 89, 90
1790, 90, 91
1791, 91, 92
1792, 92, 93
1793, 93, 94
1794, 94, 95
1795, 95, 96
1796, 96, 97
1797, 97, 98
1798, 98, 99
1799, 99, 100
1800, 100, 101
1801, 101, 102
1802, 102, 103
1803, 103, 104
1804, 104, 105
1805, 105, 106
1806, 106, 1
*ELEMENT, type=T3D2, ELSET=Line5
1807, 3, 107
1808, 107, 108
1809, 108, 5
*ELEMENT, type=T3D2, ELSET=Line6
1810, 4, 109
1811, 109, 110
1812, 110, 6
*ELEMENT, type=T3D2, ELSET=Line7
1, 5, 111
2, 111, 112
3, 112, 113
4, 113, 114
5, 114, 115
6, 115, 116
7, 116, 117
8, 117, 118
9, 118, 119
10, 119, 120
11, 120, 121
12, 121, 122
13, 122, 123
14, 123, 124
15, 124, 125
16, 125, 126
17, 126, 127
18, 127, 128
19, 128, 129
20, 129, 6
*ELEMENT, type=T3D2, ELSET=Line8
1813, 3, 130
1814, 130, 131
1815, 131, 132
1816, 132, 133
1817, 133, 7
*ELEMENT, type=T3D2, ELSET=Line9
21, 5, 134
22, 134, 135
23, 135, 136
24, 136, 137
25, 137, 8
*ELEMENT, type=T3D2, ELSET=Line10
1818, 7, 138
1819, 138, 139
1820, 139, 8
*ELEMENT, type=T3D2, ELSET=Line11
1821, 7, 140
1822, 140, 141
1823, 141, 142
1824, 142, 143
1825, 143, 144
1826, 144, 145
1827, 145, 146
1828, 146, 147
1829, 147, 148
1830, 148, 149
1831, 149, 150
1832, 150, 151
1833, 151, 152
1834, 152, 153
1835, 153, 154
1836, 154, 155
1837, 155, 156
1838, 156, 157
1839, 157, 158
1840, 158, 9
*ELEMENT, type=T3D2, ELSET=Line12
26, 8, 159
27, 159, 160
28, 160, 161
29, 161, 162
30, 162, 163
31, 163, 164
32, 164, 165
33, 165, 166
34, 166, 167
35, 167, 168
36, 168, 169
37, 169, 170
38, 170, 171
39, 171, 172
40, 172, 173
41, 173, 174
42, 174, 175
43, 175, 176
44, 176, 177
45, 177, 10
*ELEMENT, type=T3D2, ELSET=Line13
1841, 9, 178
1842, 178, 179
1843, 179, 10
*ELEMENT, type=T3D2, ELSET=Line14
1844, 7, 180
1845, 180, 181
1846, 181, 182
1847, 182, 183
1848, 183, 184
1849, 184, 185
1850, 185, 186
1851, 186, 187
1852, 187, 188
1853, 188, 189
1854, 189, 190
1855, 190, 191
1856, 191, 192
1857, 192, 193
1858, 193, 194
1859, 194, 195
1860, 195, 196
1861, 196, 197
1862, 197, 198
1863, 198, 11
*ELEMENT, type=T3D2, ELSET=Line15
1864, 9, 199
1865, 199, 200
1866, 200, 201
1867, 201, 202
1868, 202, 203
1869, 203, 204
1870, 204, 205
1871, 205, 206
1872, 206, 207
1873, 207, 208
1874, 208, 209
1875, 209, 210
1876, 210, 211
1877, 211, 212
1878, 212, 213
1879, 213, 214
1880, 214, 215
1881, 215, 216
1882, 216, 217
1883, 217, 12
*ELEMENT, type=T3D2, ELSET=Line16
1884, 11, 218
1885, 218, 219
1886, 219, 220
1887, 220, 221
1888, 221, 222
1889, 222, 223
1890, 223, 224
1891, 224, 225
1892, 225, 226
1893, 226, 227
1894, 227, 228
1895, 228, 229
1896, 229, 230
1897, 230, 231
1898, 231, 232
1899, 232, 233
1900, 233, 234
1901, 234, 235
1902, 235, 236
1903, 236, 12
*ELEMENT, type=T3D2, ELSET=Line17
1904, 11, 237
1905, 237, 238
1906, 238, 13
*ELEMENT, type=T3D2, ELSET=Line18
1907, 12, 239
1908, 239, 240
1909, 240, 14
*ELEMENT, type=T3D2, ELSET=Line19
46, 13, 241
47, 241, 242
48, 242, 243
49, 243, 244
50, 244, 245
51, 245, 246
52, 246, 247
53, 247, 248
54, 248, 249
55, 249, 250
56, 250, 251
57, 251, 252
58, 252, 253
59, 253, 254
60, 254, 255
61, 255, 256
62, 256, 257
63, 257, 258
64, 258, 259
65, 259, 14
*ELEMENT, type=T3D2, ELSET=Line20
1910, 1, 260
1911, 260, 261
1912, 261, 15
*ELEMENT, type=T3D2, ELSET=Line21
1913, 2, 262
1914, 262, 263
1915, 263, 16
*ELEMENT, type=T3D2, ELSET=Line22
66, 15, 264
67, 264, 265
68, 265, 266
69, 266, 267
70, 267, 268
71, 268, 269
72, 269, 270
73, 270, 271
74, 271, 272
75, 272, 273
76, 273, 274
77, 274, 275
78, 275, 276
79, 276, 277
80, 277, 278
81, 278, 279
82, 279, 280
83, 280, 281
84, 281, 282
85, 282, 16
*ELEMENT, type=T3D2, ELSET=Line23
1916, 12, 283
1917, 283, 17
*ELEMENT, type=T3D2, ELSET=Line24
86, 14, 284
87, 284, 18
*ELEMENT, type=T3D2, ELSET=Line25
88, 17, 285
89, 285, 286
90, 286, 18
*ELEMENT, type=T3D2, ELSET=Line26
1918, 1, 287
1919, 287, 19
*ELEMENT, type=T3D2, ELSET=Line27
91, 15, 288
92, 288, 20
*ELEMENT, type=T3D2, ELSET=Line28
93, 19, 289
94, 289, 290
95, 290, 20
*ELEMENT, type=T3D2, ELSET=Line29
1920, 15, 291
1921, 291, 292
1922, 292, 293
1923, 293, 294
1924, 294, 21
*ELEMENT, type=T3D2, ELSET=Line30
1925, 16, 295
1926, 295, 296
1927, 296, 297
1928, 297, 298
1929, 298, 22
*ELEMENT, type=T3D2, ELSET=Line31
96, 21, 299
97, 299, 300
98, 300, 301
99, 301, 302
100, 302, 303
101, 303, 304
102, 304, 305
103, 305, 306
104, 306, 307
105, 307, 308
106, 308, 309
107, 309, 310
108, 310, 311
109, 311, 312
110, 312, 313
111, 313, 314
112, 314, 315
113, 315, 316
114, 316, 317
115, 317, 22
*ELEMENT, type=T3D2, ELSET=Line32
1930, 20, 318
1931, 318, 319
1932, 319, 320
1933, 320, 321
1934, 321, 23
*ELEMENT, type=T3D2, ELSET=Line33
116, 21, 322
117, 322, 23
*ELEMENT, type=T3D2, ELSET=Line34
1935, 13, 323
1936, 323, 324
1937, 324, 325
1938, 325, 326
1939, 326, 24
*ELEMENT, type=T3D2, ELSET=Line35
1940, 14, 327
1941, 327, 328
1942, 328, 329
1943, 329, 330
1944, 330, 25
*ELEMENT, type=T3D2, ELSET=Line36
118, 24, 331
119, 331, 332
120, 332, 333
121, 333, 334
122, 334, 335
123, 335, 336
124, 336, 337
125, 337, 338
126, 338, 339
127, 339, 340
128, 340, 341
129, 341, 342
130, 342, 343
131, 343, 344
132, 344, 345
133, 345, 346
134, 346, 347
135, 347, 348
136, 348, 349
137, 349, 25
*ELEMENT, type=T3D2, ELSET=Line37
1945, 18, 350
1946, 350, 351
1947, 351, 352
1948, 352, 353
1949, 353, 26
*ELEMENT, type=T3D2, ELSET=Line38
138, 25, 354
139, 354, 26
*ELEMENT, type=T3D2, ELSET=Line39
1950, 5, 355
1951, 355, 356
1952, 356, 357
1953, 357, 358
1954, 358, 27
*ELEMENT, type=T3D2, ELSET=Line40
1955, 6, 359
1956, 359, 360
1957, 360, 361
1958, 361, 362
1959, 362, 28
*ELEMENT, type=T3D2, ELSET=Line41
140, 27, 363
141, 363, 364
142, 364, 365
143, 365, 366
144, 366, 367
145, 367, 368
146, 368, 369
147, 369, 370
148, 370, 371
149, 371, 372
150, 372, 373
151, 373, 374
152, 374, 375
153, 375, 376
154, 376, 377
155, 377, 378
156, 378, 379
157, 379, 380
158, 380, 381
159, 381, 28
*ELEMENT, type=T3D2, ELSET=Line42
1960, 8, 382
1961, 382, 383
1962, 383, 384
1963, 384, 385
1964, 385, 29
*ELEMENT, type=T3D2, ELSET=Line43
160, 27, 386
161, 386, 387
162, 387, 388
163, 388, 389
164, 389, 29
*ELEMENT, type=T3D2, ELSET=Line44
1965, 10, 390
1966, 390, 391
1967, 391, 392
1968, 392, 393
1969, 393, 30
*ELEMENT, type=T3D2, ELSET=Line45
165, 29, 394
166, 394, 395
167, 395, 396
168, 396, 397
169, 397, 398
170, 398, 399
171, 399, 400
172, 400, 401
173, 401, 402
174, 402, 403
175, 403, 404
176, 404, 405
177, 405, 406
178, 406, 407
179, 407, 408
180, 408, 409
181, 409, 410
182, 410, 411
183, 411, 412
184, 412, 30
*ELEMENT, type=CPS4, ELSET=Surface1
185, 1, 31, 413, 106
186, 106, 413, 414, 105
187, 105, 414, 415, 104
188, 104, 415, 416, 103
189, 103, 416, 417, 102
190, 102, 417, 418, 101
191, 101, 418, 419, 100
192, 100, 419, 420, 99
193, 99, 420, 421, 98
194, 98, 421, 422, 97
195, 97, 422, 423, 96
196, 96, 423, 424, 95
197, 95, 424, 425, 94
198, 94, 425, 426, 93
199, 93, 426, 427, 92
200, 92, 427, 428, 91
201, 91, 428, 429, 90
202, 90, 429, 430, 89
203, 89, 430, 431, 88
204, 88, 431, 87, 4
205, 31, 32, 432, 413
206, 413, 432, 433, 414
207, 414, 433, 434, 415
208, 415, 434, 435, 416
209, 416, 435, 436, 417
210, 417, 436, 437, 418
211, 418, 437, 438, 419
212, 419, 438, 439, 420
213, 420, 439, 440, 421
214, 421, 440, 441, 422
215, 422, 441, 442, 423
216, 423, 442, 443, 424
217, 424, 443, 444, 425
218, 425, 444, 445, 426
219, 426, 445, 446, 427
220, 427, 446, 447, 428
221, 428, 447, 448, 429
222, 429, 448, 449, 430
223, 430, 449, 450, 431
224, 431, 450, 86, 87
225, 32, 33, 451, 432
226, 432, 451, 452, 433
227, 433, 452, 453, 434
228, 434, 453, 454, 435
229, 435, 454, 455, 436
230, 436, 455, 456, 437
231, 437, 456, 457, 438
232, 438, 457, 458, 439
233, 439, 458, 459, 440
234, 440, 459, 460, 441
235, 441, 460, 461, 442
236, 442, 461, 462, 443
237, 443, 462, 463, 444
238, 444, 463, 464, 445
239, 445, 464, 465, 446
240, 446, 465, 466, 447
241, 447, 466, 467, 448
242, 448, 467, 468, 449
243, 449, 468, 469, 450
244, 450, 469, 85, 86
245, 33, 34, 470, 451
246, 451, 470, 471, 452
247, 452, 471, 472, 453
248, 453, 472, 473, 454
249, 454, 473, 474, 455
250, 455, 474, 475, 456
251, 456, 475, 476, 457
252, 457, 476, 477, 458
253, 458, 477, 478, 459
254, 459, 478, 479, 460
255, 460, 479, 480, 461
256, 461, 480, 481, 462
257, 462, 481, 482, 463
258, 463, 482, 483, 464
259, 464, 483, 484, 465
260, 465, 484, 485, 466
261, 466, 485, 486, 467
262, 467, 486, 487, 468
263, 468, 487, 488, 469
264, 469, 488, 84, 85
265, 34, 35, 489, 470
266, 470, 489, 490, 471
267, 471, 490, 491, 472
268, 472, 491, 492, 473
269, 473, 492, 493, 474
270, 474, 493, 494, 475
271, 475, 494, 495, 476
272, 476, 495, 496, 477
273, 477, 496, 497, 478
274, 478, 497, 498, 479
275, 479, 498, 499, 480
276, 480, 499, 500, 481
277, 481, 500, 501, 482
278, 482, 501, 502, 483
279, 483, 502, 503, 484
280, 484, 503, 504, 485
281, 485, 504, 505, 486
282, 486, 505, 506, 487
283, 487, 506, 507, 488
284, 488, 507, 83, 84
285, 35, 36, 508, 489
286, 489, 508, 509, 490
287, 490, 509, 510, 491
288, 491, 510, 511, 492
289, 492, 511, 512, 493
290, 493, 512, 513, 494
291, 494, 513, 514, 495
292, 495, 514, 515, 496
293, 496, 515, 516, 497
294, 497, 516, 517, 498
295, 498, 517, 518, 499
296, 499, 518, 519, 500
297, 500, 519, 520, 501
298, 501, 520, 521, 502
299, 502, 521, 522, 503
300, 503, 522, 523, 504
301, 504, 523, 524, 505
302, 505, 524, 525, 506
303, 506, 525, 526, 507
304, 507, 526, 82, 83
305, 36, 37, 527, 508
306, 508, 527, 528, 509
307, 509, 528, 529, 510
308, 510, 529, 530, 511
309, 511, 530, 531, 512
310, 512, 531, 532, 513
311, 513, 532, 533, 514
312, 514, 533, 534, 515
313, 515, 534, 535, 516
314, 516, 535, 536, 517
315, 517, 536, 537, 518
316, 518, 537, 538, 519
317, 519, 538, 539, 520
318, 520, 539, 540, 521
319, 521, 540, 541, 522
320, 522, 541, 542, 523
321, 523, 542, 543, 524
322, 524, 543, 544, 525
323, 525, 544, 545, 526
324, 526, 545, 81, 82
325, 37, 38, 546, 527
326, 527, 546, 547, 528
327, 528, 547, 548, 529
328, 529, 548, 549, 530
329, 530, 549, 550, 531
330, 531, 550, 551, 532
331, 532, 551, 552, 533
332, 533, 552, 553, 534
333, 534, 553, 554, 535
334, 535, 554, 555, 536
335, 536, 555, 556, 537
336, 537, 556, 557, 538
337, 538, 557, 558, 539
338, 539, 558, 559, 540
339, 540, 559, 560, 541
340, 541, 560, 561, 542
341, 542, 561, 562, 543
342, 543, 562, 563, 544
343, 544, 563, 564, 545
344, 545, 564, 80, 81
345, 38, 39, 565, 546
346, 546, 565, 566, 547
347, 547, 566, 567, 548
348, 548, 567, 568, 549
349, 549, 568, 569, 550
350, 550, 569, 570, 551
351, 551, 570, 571, 552
352, 552, 571, 572, 553
353, 553, 572, 573, 554
354, 554, 573, 574, 555
355, 555, 574, 575, 556
356, 556, 575, 576, 557
357, 557, 576, 577, 558
358, 558, 577, 578, 559
359, 559, 578, 579, 560
360, 560, 579, 580, 561
361, 561, 580, 581, 562
362, 562, 581, 582, 563
363, 563, 582, 583, 564
364, 564, 583, 79, 80
365, 39, 40, 584, 565
366, 565, 584, 585, 566
367, 566, 585, 586, 567
368, 567, 586, 587, 568
369, 568, 587, 588, 569
370, 569, 588, 589, 570
371, 570, 589, 590, 571
372, 571, 590, 591, 572
373, 572, 591, 592, 573
374, 573, 592, 593, 574
375, 574, 593, 594, 575
376, 575, 594, 595, 576
377, 576, 595, 596, 577
378, 577, 596, 597, 578
379, 578, 597, 598, 579
380, 579, 598, 599, 580
381, 580, 599, 600, 581
382, 581, 600, 601, 582
383, 582, 601, 602, 583
384, 583, 602, 78, 79
385, 40, 41, 603, 584
386, 584, 603, 604, 585
387, 585, 604, 605, 586
388, 586, 605, 606, 587
389, 587, 606, 607, 588
390, 588, 607, 608, 589
391, 589, 608, 609, 590
392, 590, 609, 610, 591
393, 591, 610, 611, 592
394, 592, 611, 612, 593
395, 593, 612, 613, 594
396, 594, 613, 614, 595
397, 595, 614, 615, 596
398, 596, 615, 616, 597
399, 597, 616, 617, 598
400, 598, 617, 618, 599
401, 599, 618, 619, 600
402, 600, 619, 620, 601
403, 601, 620, 621, 602
404, 602, 621, 77, 78
405, 41, 42, 622, 603
406, 603, 622, 623, 604
407, 604, 623, 624, 605
408, 605, 624, 625, 606
409, 606, 625, 626, 607
410, 607, 626, 627, 608
411, 608, 627, 628, 609
412, 609, 628, 629, 610
413, 610, 629, 630, 611
414, 611, 630, 631, 612
415, 612, 631, 632, 613
416, 613, 632, 633, 614
417, 614, 633, 634, 615
418, 615, 634, 635, 616
419, 616, 635, 636, 617
420, 617, 636, 637, 618
421, 618, 637, 638, 619
422, 619, 638, 639, 620
423, 620, 639, 640, 621
424, 621, 640, 76, 77
425, 42, 43, 641, 622
426, 622, 641, 642, 623
427, 623, 642, 643, 624
428, 624, 643, 644, 625
429, 625, 644, 645, 626
430, 626, 645, 646, 627
431, 627, 646, 647, 628
432, 628, 647, 648, 629
433, 629, 648, 649, 630
434, 630, 649, 650, 631
435, 631, 650, 651, 632
436, 632, 651, 652, 633
437, 633, 652, 653, 634
438, 634, 653, 654, 635
439, 635, 654, 655, 636
440, 636, 655, 656, 637
441, 637, 656, 657, 638
442, 638, 657, 658, 639
443, 639, 658, 659, 640
444, 640, 659, 75, 76
445, 43, 44, 660, 641
446, 641, 660, 661, 642
447, 642, 661, 662, 643
448, 643, 662, 663, 644
449, 644, 663, 664, 645
450, 645, 664, 665, 646
451, 646, 665, 666, 647
452, 647, 666, 667, 648
453, 648, 667, 668, 649
454, 649, 668, 669, 650
455, 650, 669, 670, 651
456, 651, 670, 671, 652
457, 652, 671, 672, 653
458, 653, 672, 673, 654
459, 654, 673, 674, 655
460, 655, 674, 675, 656
461, 656, 675, 676, 657
462, 657, 676, 677, 658
463, 658, 677, 678, 659
464, 659, 678, 74, 75
465, 44, 45, 679, 660
466, 660, 679, 680, 661
467, 661, 680, 681, 662
468, 662, 681, 682, 663
469, 663, 682, 683, 664
470, 664, 683, 684, 665
471, 665, 684, 685, 666
472, 666, 685, 686, 667
473, 667, 686, 687, 668
474, 668, 687, 688, 669
475, 669, 688, 689, 670
476, 670, 689, 690, 671
477, 671, 690, 691, 672
478, 672, 691, 692, 673
479, 673, 692, 693, 674
480, 674, 693, 694, 675
481, 675, 694, 695, 676
482, 676, 695, 696, 677
483, 677, 696, 697, 678
484, 678, 697, 73, 74
485, 45, 46, 698, 679
486, 679, 698, 699, 680
487, 680, 699, 700, 681
488, 681, 700, 701, 682
489, 682, 701, 702, 683
490, 683, 702, 703, 684
491, 684, 703, 704, 685
492, 685, 704, 705, 686
493, 686, 705, 706, 687
494, 687, 706, 707, 688
495, 688, 707, 708, 689
496, 689, 708, 709, 690
497, 690, 709, 710, 691
498, 691, 710, 711, 692
499, 692, 711, 712, 693
500, 693, 712, 713, 694
501, 694, 713, 714, 695
502, 695, 714, 715, 696
503, 696, 715, 716, 697
504, 697, 716, 72, 73
505, 46, 47, 717, 698
506, 698, 717, 718, 699
507, 699, 718, 719, 700
508, 700, 719, 720, 701
509, 701, 720, 721, 702
510, 702, 721, 722, 703
511, 703, 722, 723, 704
512, 704, 723, 724, 705
513, 705, 724, 725, 706
514, 706, 725, 726, 707
515, 707, 726, 727, 708
516, 708, 727, 728, 709
517, 709, 728, 729, 710
518, 710, 729, 730, 711
519, 711, 730, 731, 712
520, 712, 731, 732, 713
521, 713, 732, 733, 714
522, 714, 733, 734, 715
523, 715, 734, 735, 716
524, 716, 735, 71, 72
525, 47, 48, 736, 717
526, 717, 736, 737, 718
527, 718, 737, 738, 719
528, 719, 738, 739, 720
529, 720, 739, 740, 721
530, 721, 740, 741, 722
531, 722, 741, 742, 723
532, 723, 742, 743, 724
533, 724, 743, 744, 725
534, 725, 744, 745, 726
535, 726, 745, 746, 727
536, 727, 746, 747, 728
537, 728, 747, 748, 729
538, 729, 748, 749, 730
539, 730, 749, 750, 731
540, 731, 750, 751, 732
541, 732, 751, 752, 733
542, 733, 752, 753, 734
543, 734, 753, 754, 735
544, 735, 754, 70, 71
545, 48, 49, 755, 736
546, 736, 755, 756, 737
547, 737, 756, 757, 738
548, 738, 757, 758, 739
549, 739, 758, 759, 740
550, 740, 759, 760, 741
551, 741, 760, 761, 742
552, 742, 761, 762, 743
553, 743, 762, 763, 744
554, 744, 763, 764, 745
555, 745, 764, 765, 746
556, 746, 765, 766, 747
557, 747, 766, 767, 748
558, 748, 767, 768, 749
559, 749, 768, 769, 750
560, 750, 769, 770, 751
561, 751, 770, 771, 752
562, 752, 771, 772, 753
563, 753, 772, 773, 754
564, 754, 773, 69, 70
565, 49, 2, 50, 755
566, 755, 50, 51, 756
567, 756, 51, 52, 757
568, 757, 52, 53, 758
569, 758, 53, 54, 759
570, 759, 54, 55, 760
571, 760, 55, 56, 761
572, 761, 56, 57, 762
573, 762, 57, 58, 763
574, 763, 58, 59, 764
575, 764, 59, 60, 765
576, 765, 60, 61, 766
577, 766, 61, 62, 767
578, 767, 62, 63, 768
579, 768, 63, 64, 769
580, 769, 64, 65, 770
581, 770, 65, 66, 771
582, 771, 66, 67, 772
583, 772, 67, 68, 773
584, 773, 68, 3, 69
*ELEMENT, type=CPS4, ELSET=Surface2
585, 3, 107, 774, 69
586, 69, 774, 775, 70
587, 70, 775, 776, 71
588, 71, 776, 777, 72
589, 72, 777, 778, 73
590, 73, 778, 779, 74
591, 74, 779, 780, 75
592, 75, 780, 781, 76
593, 76, 781, 782, 77
594, 77, 782, 783, 78
595, 78, 783, 784, 79
596, 79, 784, 785, 80
597, 80, 785, 786, 81
598, 81, 786, 787, 82
599, 82, 787, 788, 83
600, 83, 788, 789, 84
601, 84, 789, 790, 85
602, 85, 790, 791, 86
603, 86, 791, 792, 87
604, 87, 792, 109, 4
605, 107, 108, 793, 774
606, 774, 793, 794, 775
607, 775, 794, 795, 776
608, 776, 795, 796, 777
609, 777, 796, 797, 778
610, 778, 797, 798, 779
611, 779, 798, 799, 780
612, 780, 799, 800, 781
613, 781, 800, 801, 782
614, 782, 801, 802, 783
615, 783, 802, 803, 784
616, 784, 803, 804, 785
617, 785, 804, 805, 786
618, 786, 805, 806, 787
619, 787, 806, 807, 788
620, 788, 807, 808, 789
621, 789, 808, 809, 790
622, 790, 809, 810, 791
623, 791, 810, 811, 792
624, 792, 811, 110, 109
625, 108, 5, 111, 793
626, 793, 111, 112, 794
627, 794, 112, 113, 795
628, 795, 113, 114, 796
629, 796, 114, 115, 797
630, 797, 115, 116, 798
631, 798, 116, 117, 799
632, 799, 117, 118, 800
633, 800, 118, 119, 801
634, 801, 119, 120, 802
635, 802, 120, 121, 803
636, 803, 121, 122, 804
637, 804, 122, 123, 805
638, 805, 123, 124, 806
639, 806, 124, 125, 807
640, 807, 125, 126, 808
641, 808, 126, 127, 809
642, 809, 127, 128, 810
643, 810, 128, 129, 811
644, 811, 129, 6, 110
*ELEMENT, type=CPS4, ELSET=Surface3
645, 3, 130, 812, 107
646, 107, 812, 813, 108
647, 108, 813, 134, 5
648, 130, 131, 814, 812
649, 812, 814, 815, 813
650, 813, 815, 135, 134
651, 131, 132, 816, 814
652, 814, 816, 817, 815
653, 815, 817, 136, 135
654, 132, 133, 818, 816
655, 816, 818, 819, 817
656, 817, 819, 137, 136
657, 133, 7, 138, 818
658, 818, 138, 139, 819
659, 819, 139, 8, 137
*ELEMENT, type=CPS4, ELSET=Surface4
660, 7, 140, 820, 138
661, 138, 820, 821, 139
662, 139, 821, 159, 8
663, 140, 141, 822, 820
664, 820, 822, 823, 821
665, 821, 823, 160, 159
666, 141, 142, 824, 822
667, 822, 824, 825, 823
668, 823, 825, 161, 160
669, 142, 143, 826, 824
670, 824, 826, 827, 825
671, 825, 827, 162, 161
672, 143, 144, 828, 826
673, 826, 828, 829, 827
674, 827, 829, 163, 162
675, 144, 145, 830, 828
676, 828, 830, 831, 829
677, 829, 831, 164, 163
678, 145, 146, 832, 830
679, 830, 832, 833, 831
680, 831, 833, 165, 164
681, 146, 147, 834, 832
682, 832, 834, 835, 833
683, 833, 835, 166, 165
684, 147, 148, 836, 834
685, 834, 836, 837, 835
686, 835, 837, 167, 166
687, 148, 149, 838, 836
688, 836, 838, 839, 837
689, 837, 839, 168, 167
690, 149, 150, 840, 838
691, 838, 840, 841, 839
692, 839, 841, 169, 168
693, 150, 151, 842, 840
694, 840, 842, 843, 841
695, 841, 843, 170, 169
696, 151, 152, 844, 842
697, 842, 844, 845, 843
698, 843, 845, 171, 170
699, 152, 153, 846, 844
700, 844, 846, 847, 845
701, 845, 847, 172, 171
702, 153, 154, 848, 846
703, 846, 848, 849, 847
704, 847, 849, 173, 172
705, 154, 155, 850, 848
706, 848, 850, 851, 849
707, 849, 851, 174, 173
708, 155, 156, 852, 850
709, 850, 852, 853, 851
710, 851, 853, 175, 174
711, 156, 157, 854, 852
712, 852, 854, 855, 853
713, 853, 855, 176, 175
714, 157, 158, 856, 854
715, 854, 856, 857, 855
716, 855, 857, 177, 176
717, 158, 9, 178, 856
718, 856, 178, 179, 857
719, 857, 179, 10, 177
*ELEMENT, type=CPS4, ELSET=Surface5
720, 7, 180, 858, 140
721, 140, 858, 859, 141
722, 141, 859, 860, 142
723, 142, 860, 861, 143
724, 143, 861, 862, 144
725, 144, 862, 863, 145
726, 145, 863, 864, 146
727, 146, 864, 865, 147
728, 147, 865, 866, 148
729, 148, 866, 867, 149
730, 149, 867, 868, 150
731, 150, 868, 869, 151
732, 151, 869, 870, 152
733, 152, 870, 871, 153
734, 153, 871, 872, 154
735, 154, 872, 873, 155
736, 155, 873, 874, 156
737, 156, 874, 875, 157
738, 157, 875, 876, 158
739, 158, 876, 199, 9
740, 180, 181, 877, 858
741, 858, 877, 878, 859
742, 859, 878, 879, 860
743, 860, 879, 880, 861
744, 861, 880, 881, 862
745, 862, 881, 882, 863
746, 863, 882, 883, 864
747, 864, 883, 884, 865
748, 865, 884, 885, 866
749, 866, 885, 886, 867
750, 867, 886, 887, 868
751, 868, 887, 888, 869
752, 869, 888, 889, 870
753, 870, 889, 890, 871
754, 871, 890, 891, 872
755, 872, 891, 892, 873
756, 873, 892, 893, 874
757, 874, 893, 894, 875
758, 875, 894, 895, 876
759, 876, 895, 200, 199
760, 181, 182, 896, 877
761, 877, 896, 897, 878
762, 878, 897, 898, 879
763, 879, 898, 899, 880
764, 880, 899, 900, 881
765, 881, 900, 901, 882
766, 882, 901, 902, 883
767, 883, 902, 903, 884
768, 884, 903, 904, 885
769, 885, 904, 905, 886
770, 886, 905, 906, 887
771, 887, 906, 907, 888
772, 888, 907, 908, 889
773, 889, 908, 909, 890
774, 890, 909, 910, 891
775, 891, 910, 911, 892
776, 892, 911, 912, 893
777, 893, 912, 913, 894
778, 894, 913, 914, 895
779, 895, 914, 201, 200
780, 182, 183, 915, 896
781, 896, 915, 916, 897
782, 897, 916, 917, 898
783, 898, 917, 918, 899
784, 899, 918, 919, 900
785, 900, 919, 920, 901
786, 901, 920, 921, 902
787, 902, 921, 922, 903
788, 903, 922, 923, 904
789, 904, 923, 924, 905
790, 905, 924, 925, 906
791, 906, 925, 926, 907
792, 907, 926, 927, 908
793, 908, 927, 928, 909
794, 909, 928, 929, 910
795, 910, 929, 930, 911
796, 911, 930, 931, 912
797, 912, 931, 932, 913
798, 913, 932, 933, 914
799, 914, 933, 202, 201
800, 183, 184, 934, 915
801, 915, 934, 935, 916
802, 916, 935, 936, 917
803, 917, 936, 937, 918
804, 918, 937, 938, 919
805, 919, 938, 939, 920
806, 920, 939, 940, 921
807, 921, 940, 941, 922
808, 922, 941, 942, 923
809, 923, 942, 943, 924
810, 924, 943, 944, 925
811, 925, 944, 945, 926
812, 926, 945, 946, 927
813, 927, 946, 947, 928
814, 928, 947, 948, 929
815, 929, 948, 949, 930
816, 930, 949, 950, 931
817, 931, 950, 951, 932
818, 932, 951, 952, 933
819, 933, 952, 203, 202
820, 184, 185, 953, 934
821, 934, 953, 954, 935
822, 935, 954, 955, 936
823, 936, 955, 956, 937
824, 937, 956, 957, 938
825, 938, 957, 958, 939
826, 939, 958, 959, 940
827, 940, 959, 960, 941
828, 941, 960, 961, 942
829, 942, 961, 962, 943
830, 943, 962, 963, 944
831, 944, 963, 964, 945
832, 945, 964, 965, 946
833, 946, 965, 966, 947
834, 947, 966, 967, 948
835, 948, 967, 968, 949
836, 949, 968, 969, 950
837, 950, 969, 970, 951
838, 951, 970, 971, 952
839, 952, 971, 204, 203
840, 185, 186, 972, 953
841, 953, 972, 973, 954
842, 954, 973, 974, 955
843, 955, 974, 975, 956
844, 956, 975, 976, 957
845, 957, 976, 977, 958
846, 958, 977, 978, 959
847, 959, 978, 979, 960
848, 960, 979, 980, 961
849, 961, 980, 981, 962
850, 962, 981, 982, 963
851, 963, 982, 983, 964
852, 964, 983, 984, 965
853, 965, 984, 985, 966
854, 966, 985, 986, 967
855, 967, 986, 987, 968
856, 968, 987, 988, 969
857, 969, 988, 989, 970
858, 970, 989, 990, 971
859, 971, 990, 205, 204
860, 186, 187, 991, 972
861, 972, 991, 992, 973
862, 973, 992, 993, 974
863, 974, 993, 994, 975
864, 975, 994, 995, 976
865, 976, 995, 996, 977
866, 977, 996, 997, 978
867, 978, 997, 998, 979
868, 979, 998, 999, 980
869, 980, 999, 1000, 981
870, 981, 1000, 1001, 982
871, 982, 1001, 1002, 983
872, 983, 1002, 1003, 984
873, 984, 1003, 1004, 985
874, 985, 1004, 1005, 986
875, 986, 1005, 1006, 987
876, 987, 1006, 1007, 988
877, 988, 1007, 1008, 989
878, 989, 1008, 1009, 990
879, 990, 1009, 206, 205
880, 187, 188, 1010, 991
881, 991, 1010, 1011, 992
882, 992, 1011, 1012, 993
883, 993, 1012, 1013, 994
884, 994, 1013, 1014, 995
885, 995, 1014, 1015, 996
886, 996, 1015, 1016, 997
887, 997, 1016, 1017, 998
888, 998, 1017, 1018, 999
889, 999, 1018, 1019, 1000
890, 1000, 1019, 1020, 1001
891, 1001, 1020, 1021, 1002
892, 1002, 1021, 1022, 1003
893, 1003, 1022, 1023, 1004
894, 1004, 1023, 1024, 1005
895, 1005, 1024, 1025, 1006
896, 1006, 1025, 1026, 1007
897, 1007, 1026, 1027, 1008
898, 1008, 1027, 1028, 1009
899, 1009, 1028, 207, 206
900, 188, 189, 1029, 1010
901, 1010, 1029, 1030, 1011
902, 1011, 1030, 1031, 1012
903, 1012, 1031, 1032, 1013
904, 1013, 1032, 1033, 1014
905, 1014, 1033, 1034, 1015
906, 1015, 1034, 1035, 1016
907, 1016, 1035, 1036, 1017
908, 1017, 1036, 1037, 1018
909, 1018, 1037, 1038, 1019
910, 1019, 1038, 1039, 1020
911, 1020, 1039, 1040, 1021
912, 1021, 1040, 1041, 1022
913, 1022, 1041, 1042, 1023
914, 1023, 1042, 1043, 1024
915, 1024, 1043, 1044, 1025
916, 1025, 1044, 1045, 1026
917, 1026, 1045, 1046, 1027
918, 1027, 1046, 1047, 1028
919, 1028, 1047, 208, 207
920, 189, 190, 1048, 1029
921, 1029, 1048, 1049, 1030
922, 1030, 1049, 1050, 1031
923, 1031, 1050, 1051, 1032
924, 1032, 1051, 1052, 1033
925, 1033, 1052, 1053, 1034
926, 1034, 1053, 1054, 1035
927, 1035, 1054, 1055, 1036
928, 1036, 1055, 1056, 1037
929, 1037, 1056, 1057, 1038
930, 1038, 1057, 1058, 1039
931, 1039, 1058, 1059, 1040
932, 1040, 1059, 1060, 1041
933, 1041, 1060, 1061, 1042
934, 1042, 1061, 1062, 1043
935, 1043, 1062, 1063, 1044
936, 1044, 1063, 1064, 1045
937, 1045, 1064, 1065, 1046
938, 1046, 1065, 1066, 1047
939, 1047, 1066, 209, 208
940, 190, 191, 1067, 1048
941, 1048, 1067, 1068, 1049
942, 1049, 1068, 1069, 1050
943, 1050, 1069, 1070, 1051
944, 1051, 1070, 1071, 1052
945, 1052, 1071, 1072, 1053
946, 1053, 1072, 1073, 1054
947, 1054, 1073, 1074, 1055
948, 1055, 1074, 1075, 1056
949, 1056, 1075, 1076, 1057
950, 1057, 1076, 1077, 1058
951, 1058, 1077, 1078, 1059
952, 1059, 1078, 1079, 1060
953, 1060, 1079, 1080, 1061
954, 1061, 1080, 1081, 1062
955, 1062, 1081, 1082, 1063
956, 1063, 1082, 1083, 1064
957, 1064, 1083, 1084, 1065
958, 1065, 1084, 1085, 1066
959, 1066, 1085, 210, 209
960, 191, 192, 1086, 1067
961, 1067, 1086, 1087, 1068
962, 1068, 1087, 1088, 1069
963, 1069, 1088, 1089, 1070
964, 1070, 1089, 1090, 1071
965, 1071, 1090, 1091, 1072
966, 1072, 1091, 1092, 1073
967, 1073, 1092, 1093, 1074
968, 1074, 1093, 1094, 1075
969, 1075, 1094, 1095, 1076
970, 1076, 1095, 1096, 1077
971, 1077, 1096, 1097, 1078
972, 1078, 1097, 1098, 1079
973, 1079, 1098, 1099, 1080
974, 1080, 1099, 1100, 1081
975, 1081, 1100, 1101, 1082
976, 1082, 1101, 1102, 1083
977, 1083, 1102, 1103, 1084
978, 1084, 1103, 1104, 1085
979, 1085, 1104, 211, 210
980, 192, 193, 1105, 1086
981, 1086, 1105, 1106, 1087
982, 1087, 1106, 1107, 1088
983, 1088, 1107, 1108, 1089
984, 1089, 1108, 1109, 1090
985, 1090, 1109, 1110, 1091
986, 1091, 1110, 1111, 1092
987, 1092, 1111, 1112, 1093
988, 1093, 1112, 1113, 1094
989, 1094, 1113, 1114, 1095
990, 1095, 1114, 1115, 1096
991, 1096, 1115, 1116, 1097
992, 1097, 1116, 1117, 1098
993, 1098, 1117, 1118, 1099
994, 1099, 1118, 1119, 1100
995, 1100, 1119, 1120, 1101
996, 1101, 1120, 1121, 1102
997, 1102, 1121, 1122, 1103
998, 1103, 1122, 1123, 1104
999, 1104, 1123, 212, 211
1000, 193, 194, 1124, 1105
1001, 1105, 1124, 1125, 1106
1002, 1106, 1125, 1126, 1107
1003, 1107, 1126, 1127, 1108
1004, 1108, 1127, 1128, 1109
1005, 1109, 1128, 1129, 1110
1006, 1110, 1129, 1130, 1111
1007, 1111, 1130, 1131, 1112
1008, 1112, 1131, 1132, 1113
1009, 1113, 1132, 1133, 1114
1010, 1114, 1133, 1134, 1115
1011, 1115, 1134, 1135, 1116
1012, 1116, 1135, 1136, 1117
1013, 1117, 1136, 1137, 1118
1014, 1118, 1137, 1138, 1119
1015, 1119, 1138, 1139, 1120
1016, 1120, 1139, 1140, 1121
1017, 1121, 1140, 1141, 1122
1018, 1122, 1141, 1142, 1123
1019, 1123, 1142, 213, 212
1020, 194, 195, 1143, 1124
1021, 1124, 1143, 1144, 1125
1022, 1125, 1144, 1145, 1126
1023, 1126, 1145, 1146, 1127
1024, 1127, 1146, 1147, 1128
1025, 1128, 1147, 1148, 1129
1026, 1129, 1148, 1149, 1130
1027, 1130, 1149, 1150, 1131
1028, 1131, 1150, 1151, 1132
1029, 1132, 1151, 1152, 1133
1030, 1133, 1152, 1153, 1134
1031, 1134, 1153, 1154, 1135
1032, 1135, 1154, 1155, 1136
1033, 1136, 1155, 1156, 1137
1034, 1137, 1156, 1157, 1138
1035, 1138, 1157, 1158, 1139
1036, 1139, 1158, 1159, 1140
1037, 1140, 1159, 1160, 1141
1038, 1141, 1160, 1161, 1142
1039, 1142, 1161, 214, 213
1040, 195, 196, 1162, 1143
1041, 1143, 1162, 1163, 1144
1042, 1144, 1163, 1164, 1145
1043, 1145, 1164, 1165, 1146
1044, 1146, 1165, 1166, 1147
1045, 1147, 1166, 1167, 1148
1046, 1148, 1167, 1168, 1149
1047, 1149, 1168, 1169, 1150
1048, 1150, 1169, 1170, 1151
1049, 1151, 1170, 1171, 1152
1050, 1152, 1171, 1172, 1153
1051, 1153, 1172, 1173, 1154
1052, 1154, 1173, 1174, 1155
1053, 1155, 1174, 1175, 1156
1054, 1156, 1175, 1176, 1157
1055, 1157, 1176, 1177, 1158
1056, 1158, 1177, 1178, 1159
1057, 1159, 1178, 1179, 1160
1058, 1160, 1179, 1180, 1161
1059, 1161, 1180, 215, 214
1060, 196, 197, 1181, 1162
1061, 1162, 1181, 1182, 1163
1062, 1163, 1182, 1183, 1164
1063, 1164, 1183, 1184, 1165
1064, 1165, 1184, 1185, 1166
1065, 1166, 1185, 1186, 1167
1066, 1167, 1186, 1187, 1168
1067, 1168, 1187, 1188, 1169
1068, 1169, 1188, 1189, 1170
1069, 1170, 1189, 1190, 1171
1070, 1171, 1190, 1191, 1172
1071, 1172, 1191, 1192, 1173
1072, 1173, 1192, 1193, 1174
1073, 1174, 1193, 1194, 1175
1074, 1175, 1194, 1195, 1176
1075, 1176, 1195, 1196, 1177
1076, 1177, 1196, 1197, 1178
1077, 1178, 1197, 1198, 1179
1078, 1179, 1198, 1199, 1180
1079, 1180, 1199, 216, 215
1080, 197, 198, 1200, 1181
1081, 1181, 1200, 1201, 1182
1082, 1182, 1201, 1202, 1183
1083, 1183, 1202, 1203, 1184
1084, 1184, 1203, 1204, 1185
1085, 1185, 1204, 1205, 1186
1086, 1186, 1205, 1206, 1187
1087, 1187, 1206, 1207, 1188
1088, 1188, 1207, 1208, 1189
1089, 1189, 1208, 1209, 1190
1090, 1190, 1209, 1210, 1191
1091, 1191, 1210, 1211, 1192
1092, 1192, 1211, 1212, 1193
1093, 1193, 1212, 1213, 1194
1094, 1194, 1213, 1214, 1195
1095, 1195, 1214, 1215, 1196
1096, 1196, 1215, 1216, 1197
1097, 1197, 1216, 1217, 1198
1098, 1198, 1217, 1218, 1199
1099, 1199, 1218, 217, 216
1100, 198, 11, 218, 1200
1101, 1200, 218, 219, 1201
1102, 1201, 219, 220, 1202
1103, 1202, 220, 221, 1203
1104, 1203, 221, 222, 1204
1105, 1204, 222, 223, 1205
1106, 1205, 223, 224, 1206
1107, 1206, 224, 225, 1207
1108, 1207, 225, 226, 1208
1109, 1208, 226, 227, 1209
1110, 1209, 227, 228, 1210
1111, 1210, 228, 229, 1211
1112, 1211, 229, 230, 1212
1113, 1212, 230, 231, 1213
1114, 1213, 231, 232, 1214
1115, 1214, 232, 233, 1215
1116, 1215, 233, 234, 1216
1117, 1216, 234, 235, 1217
1118, 1217, 235, 236, 1218
1119, 1218, 236, 12, 217
*ELEMENT, type=CPS4, ELSET=Surface6
1120, 11, 237, 1219, 218
1121, 218, 1219, 1220, 219
1122, 219, 1220, 1221, 220
1123, 220, 1221, 1222, 221
1124, 221, 1222, 1223, 222
1125, 222, 1223, 1224, 223
1126, 223, 1224, 1225, 224
1127, 224, 1225, 1226, 225
1128, 225, 1226, 1227, 226
1129, 226, 1227, 1228, 227
1130, 227, 1228, 1229, 228
1131, 228, 1229, 1230, 229
1132, 229, 1230, 1231, 230
1133, 230, 1231, 1232, 231
1134, 231, 1232, 1233, 232
1135, 232, 1233, 1234, 233
1136, 233, 1234, 1235, 234
1137, 234, 1235, 1236, 235
1138, 235, 1236, 1237, 236
1139, 236, 1237, 239, 12
1140, 237, 238, 1238, 1219
1141, 1219, 1238, 1239, 1220
1142, 1220, 1239, 1240, 1221
1143, 1221, 1240, 1241, 1222
1144, 1222, 1241, 1242, 1223
1145, 1223, 1242, 1243, 1224
1146, 1224, 1243, 1244, 1225
1147, 1225, 1244, 1245, 1226
1148, 1226, 1245, 1246, 1227
1149, 1227, 1246, 1247, 1228
1150, 1228, 1247, 1248, 1229
1151, 1229, 1248, 1249, 1230
1152, 1230, 1249, 1250, 1231
1153, 1231, 1250, 1251, 1232
1154, 1232, 1251, 1252, 1233
1155, 1233, 1252, 1253, 1234
1156, 1234, 1253, 1254, 1235
1157, 1235, 1254, 1255, 1236
1158, 1236, 1255, 1256, 1237
1159, 1237, 1256, 240, 239
1160, 238, 13, 241, 1238
1161, 1238, 241, 242, 1239
1162, 1239, 242, 243, 1240
1163, 1240, 243, 244, 1241
1164, 1241, 244, 245, 1242
1165, 1242, 245, 246, 1243
1166, 1243, 246, 247, 1244
1167, 1244, 247, 248, 1245
1168, 1245, 248, 249, 1246
1169, 1246, 249, 250, 1247
1170, 1247, 250, 251, 1248
1171, 1248, 251, 252, 1249
1172, 1249, 252, 253, 1250
1173, 1250, 253, 254, 1251
1174, 1251, 254, 255, 1252
1175, 1252, 255, 256, 1253
1176, 1253, 256, 257, 1254
1177, 1254, 257, 258, 1255
1178, 1255, 258, 259, 1256
1179, 1256, 259, 14, 240
*ELEMENT, type=CPS4, ELSET=Surface7
1180, 1, 260, 1257, 31
1181, 31, 1257, 1258, 32
1182, 32, 1258, 1259, 33
1183, 33, 1259, 1260, 34
1184, 34, 1260, 1261, 35
1185, 35, 1261, 1262, 36
1186, 36, 1262, 1263, 37
1187, 37, 1263, 1264, 38
1188, 38, 1264, 1265, 39
1189, 39, 1265, 1266, 40
1190, 40, 1266, 1267, 41
1191, 41, 1267, 1268, 42
1192, 42, 1268, 1269, 43
1193, 43, 1269, 1270, 44
1194, 44, 1270, 1271, 45
1195, 45, 1271, 1272, 46
1196, 46, 1272, 1273, 47
1197, 47, 1273, 1274, 48
1198, 48, 1274, 1275, 49
1199, 49, 1275, 262, 2
1200, 260, 261, 1276, 1257
1201, 1257, 1276, 1277, 1258
1202, 1258, 1277, 1278, 1259
1203, 1259, 1278, 1279, 1260
1204, 1260, 1279, 1280, 1261
1205, 1261, 1280, 1281, 1262
1206, 1262, 1281, 1282, 1263
1207, 1263, 1282, 1283, 1264
1208, 1264, 1283, 1284, 1265
1209, 1265, 1284, 1285, 1266
1210, 1266, 1285, 1286, 1267
1211, 1267, 1286, 1287, 1268
1212, 1268, 1287, 1288, 1269
1213, 1269, 1288, 1289, 1270
1214, 1270, 1289, 1290, 1271
1215, 1271, 1290, 1291, 1272
1216, 1272, 1291, 1292, 1273
1217, 1273, 1292, 1293, 1274
1218, 1274, 1293, 1294, 1275
1219, 1275, 1294, 263, 262
1220, 261, 15, 264, 1276
1221, 1276, 264, 265, 1277
1222, 1277, 265, 266, 1278
1223, 1278, 266, 267, 1279
1224, 1279, 267, 268, 1280
1225, 1280, 268, 269, 1281
1226, 1281, 269, 270, 1282
1227, 1282, 270, 271, 1283
1228, 1283, 271, 272, 1284
1229, 1284, 272, 273, 1285
1230, 1285, 273, 274, 1286
1231, 1286, 274, 275, 1287
1232, 1287, 275, 276, 1288
1233, 1288, 276, 277, 1289
1234, 1289, 277, 278, 1290
1235, 1290, 278, 279, 1291
1236, 1291, 279, 280, 1292
1237, 1292, 280, 281, 1293
1238, 1293, 281, 282, 1294
1239, 1294, 282, 16, 263
*ELEMENT, type=CPS4, ELSET=Surface8
1240, 12, 283, 1295, 239
1241, 239, 1295, 1296, 240
1242, 240, 1296, 284, 14
1243, 283, 17, 285, 1295
1244, 1295, 285, 286, 1296
1245, 1296, 286, 18, 284
*ELEMENT, type=CPS4, ELSET=Surface9
1246, 1, 287, 1297, 260
1247, 260, 1297, 1298, 261
1248, 261, 1298, 288, 15
1249, 287, 19, 289, 1297
1250, 1297, 289, 290, 1298
1251, 1298, 290, 20, 288
*ELEMENT, type=CPS4, ELSET=Surface10
1252, 15, 291, 1299, 264
1253, 264, 1299, 1300, 265
1254, 265, 1300, 1301, 266
1255, 266, 1301, 1302, 267
1256, 267, 1302, 1303, 268
1257, 268, 1303, 1304, 269
1258, 269, 1304, 1305, 270
1259, 270, 1305, 1306, 271
1260, 271, 1306, 1307, 272
1261, 272, 1307, 1308, 273
1262, 273, 1308, 1309, 274
1263, 274, 1309, 1310, 275
1264, 275, 1310, 1311, 276
1265, 276, 1311, 1312, 277
1266, 277, 1312, 1313, 278
1267, 278, 1313, 1314, 279
1268, 279, 1314, 1315, 280
1269, 280, 1315, 1316, 281
1270, 281, 1316, 1317, 282
1271, 282, 1317, 295, 16
1272, 291, 292, 1318, 1299
1273, 1299, 1318, 1319, 1300
1274, 1300, 1319, 1320, 1301
1275, 1301, 1320, 1321, 1302
1276, 1302, 1321, 1322, 1303
1277, 1303, 1322, 1323, 1304
1278, 1304, 1323, 1324, 1305
1279, 1305, 1324, 1325, 1306
1280, 1306, 1325, 1326, 1307
1281, 1307, 1326, 1327, 1308
1282, 1308, 1327, 1328, 1309
1283, 1309, 1328, 1329, 1310
1284, 1310, 1329, 1330, 1311
1285, 1311, 1330, 1331, 1312
1286, 1312, 1331, 1332, 1313
1287, 1313, 1332, 1333, 1314
1288, 1314, 1333, 1334, 1315
1289, 1315, 1334, 1335, 1316
1290, 1316, 1335, 1336, 1317
1291, 1317, 1336, 296, 295
1292, 292, 293, 1337, 1318
1293, 1318, 1337, 1338, 1319
1294, 1319, 1338, 1339, 1320
1295, 1320, 1339, 1340, 1321
1296, 1321, 1340, 1341, 1322
1297, 1322, 1341, 1342, 1323
1298, 1323, 1342, 1343, 1324
1299, 1324, 1343, 1344, 1325
1300, 1325, 1344, 1345, 1326
1301, 1326, 1345, 1346, 1327
1302, 1327, 1346, 1347, 1328
1303, 1328, 1347, 1348, 1329
1304, 1329, 1348, 1349, 1330
1305, 1330, 1349, 1350, 1331
1306, 1331, 1350, 1351, 1332
1307, 1332, 1351, 1352, 1333
1308, 1333, 1352, 1353, 1334
1309, 1334, 1353, 1354, 1335
1310, 1335, 1354, 1355, 1336
1311, 1336, 1355, 297, 296
1312, 293, 294, 1356, 1337
1313, 1337, 1356, 1357, 1338
1314, 1338, 1357, 1358, 1339
1315, 1339, 1358, 1359, 1340
1316, 1340, 1359, 1360, 1341
1317, 1341, 1360, 1361, 1342
1318, 1342, 1361, 1362, 1343
1319, 1343, 1362, 1363, 1344
1320, 1344, 1363, 1364, 1345
1321, 1345, 1364, 1365, 1346
1322, 1346, 1365, 1366, 1347
1323, 1347, 1366, 1367, 1348
1324, 1348, 1367, 1368, 1349
1325, 1349, 1368, 1369, 1350
1326, 1350, 1369, 1370, 1351
1327, 1351, 1370, 1371, 1352
1328, 1352, 1371, 1372, 1353
1329, 1353, 1372, 1373, 1354
1330, 1354, 1373, 1374, 1355
1331, 1355, 1374, 298, 297
1332, 294, 21, 299, 1356
1333, 1356, 299, 300, 1357
1334, 1357, 300, 301, 1358
1335, 1358, 301, 302, 1359
1336, 1359, 302, 303, 1360
1337, 1360, 303, 304, 1361
1338, 1361, 304, 305, 1362
1339, 1362, 305, 306, 1363
1340, 1363, 306, 307, 1364
1341, 1364, 307, 308, 1365
1342, 1365, 308, 309, 1366
1343, 1366, 309, 310, 1367
1344, 1367, 310, 311, 1368
1345, 1368, 311, 312, 1369
1346, 1369, 312, 313, 1370
1347, 1370, 313, 314, 1371
1348, 1371, 314, 315, 1372
1349, 1372, 315, 316, 1373
1350, 1373, 316, 317, 1374
1351, 1374, 317, 22, 298
*ELEMENT, type=CPS4, ELSET=Surface11
1352, 15, 291, 1375, 288
1353, 288, 1375, 318, 20
1354, 291, 292, 1376, 1375
1355, 1375, 1376, 319, 318
1356, 292, 293, 1377, 1376
1357, 1376, 1377, 320, 319
1358, 293, 294, 1378, 1377
1359, 1377, 1378, 321, 320
1360, 294, 21, 322, 1378
1361, 1378, 322, 23, 321
*ELEMENT, type=CPS4, ELSET=Surface12
1362, 13, 323, 1379, 241
1363, 241, 1379, 1380, 242
1364, 242, 1380, 1381, 243
1365, 243, 1381, 1382, 244
1366, 244, 1382, 1383, 245
1367, 245, 1383, 1384, 246
1368, 246, 1384, 1385, 247
1369, 247, 1385, 1386, 248
1370, 248, 1386, 1387, 249
1371, 249, 1387, 1388, 250
1372, 250, 1388, 1389, 251
1373, 251, 1389, 1390, 252
1374, 252, 1390, 1391, 253
1375, 253, 1391, 1392, 254
1376, 254, 1392, 1393, 255
1377, 255, 1393, 1394, 256
1378, 256, 1394, 1395, 257
1379, 257, 1395, 1396, 258
1380, 258, 1396, 1397, 259
1381, 259, 1397, 327, 14
1382, 323, 324, 1398, 1379
1383, 1379, 1398, 1399, 1380
1384, 1380, 1399, 1400, 1381
1385, 1381, 1400, 1401, 1382
1386, 1382, 1401, 1402, 1383
1387, 1383, 1402, 1403, 1384
1388, 1384, 1403, 1404, 1385
1389, 1385, 1404, 1405, 1386
1390, 1386, 1405, 1406, 1387
1391, 1387, 1406, 1407, 1388
1392, 1388, 1407, 1408, 1389
1393, 1389, 1408, 1409, 1390
1394, 1390, 1409, 1410, 1391
1395, 1391, 1410, 1411, 1392
1396, 1392, 1411, 1412, 1393
1397, 1393, 1412, 1413, 1394
1398, 1394, 1413, 1414, 1395
1399, 1395, 1414, 1415, 1396
1400, 1396, 1415, 1416, 1397
1401, 1397, 1416, 328, 327
1402, 324, 325, 1417, 1398
1403, 1398, 1417, 1418, 1399
1404, 1399, 1418, 1419, 1400
1405, 1400, 1419, 1420, 1401
1406, 1401, 1420, 1421, 1402
1407, 1402, 1421, 1422, 1403
1408, 1403, 1422, 1423, 1404
1409, 1404, 1423, 1424, 1405
1410, 1405, 1424, 1425, 1406
1411, 1406, 1425, 1426, 1407
1412, 1407, 1426, 1427, 1408
1413, 1408, 1427, 1428, 1409
1414, 1409, 1428, 1429, 1410
1415, 1410, 1429, 1430, 1411
1416, 1411, 1430, 1431, 1412
1417, 1412, 1431, 1432, 1413
1418, 1413, 1432, 1433, 1414
1419, 1414, 1433, 1434, 1415
1420, 1415, 1434, 1435, 1416
1421, 1416, 1435, 329, 328
1422, 325, 326, 1436, 1417
1423, 1417, 1436, 1437, 1418
1424, 1418, 1437, 1438, 1419
1425, 1419, 1438, 1439, 1420
1426, 1420, 1439, 1440, 1421
1427, 1421, 1440, 1441, 1422
1428, 1422, 1441, 1442, 1423
1429, 1423, 1442, 1443, 1424
1430, 1424, 1443, 1444, 1425
1431, 1425, 1444, 1445, 1426
1432, 1426, 1445, 1446, 1427
1433, 1427, 1446, 1447, 1428
1434, 1428, 1447, 1448, 1429
1435, 1429, 1448, 1449, 1430
1436, 1430, 1449, 1450, 1431
1437, 1431, 1450, 1451, 1432
1438, 1432, 1451, 1452, 1433
1439, 1433, 1452, 1453, 1434
1440, 1434, 1453, 1454, 1435
1441, 1435, 1454, 330, 329
1442, 326, 24, 331, 1436
1443, 1436, 331, 332, 1437
1444, 1437, 332, 333, 1438
1445, 1438, 333, 334, 1439
1446, 1439, 334, 335, 1440
1447, 1440, 335, 336, 1441
1448, 1441, 336, 337, 1442
1449, 1442, 337, 338, 1443
1450, 1443, 338, 339, 1444
1451, 1444, 339, 340, 1445
1452, 1445, 340, 341, 1446
1453, 1446, 341, 342, 1447
1454, 1447, 342, 343, 1448
1455, 1448, 343, 344, 1449
1456, 1449, 344, 345, 1450
1457, 1450, 345, 346, 1451
1458, 1451, 346, 347, 1452
1459, 1452, 347, 348, 1453
1460, 1453, 348, 349, 1454
1461, 1454, 349, 25, 330
*ELEMENT, type=CPS4, ELSET=Surface13
1462, 14, 327, 1455, 284
1463, 284, 1455, 350, 18
1464, 327, 328, 1456, 1455
1465, 1455, 1456, 351, 350
1466, 328, 329, 1457, 1456
1467, 1456, 1457, 352, 351
1468, 329, 330, 1458, 1457
1469, 1457, 1458, 353, 352
1470, 330, 25, 354, 1458
1471, 1458, 354, 26, 353
*ELEMENT, type=CPS4, ELSET=Surface14
1472, 5, 355, 1459, 111
1473, 111, 1459, 1460, 112
1474, 112, 1460, 1461, 113
1475, 113, 1461, 1462, 114
1476, 114, 1462, 1463, 115
1477, 115, 1463, 1464, 116
1478, 116, 1464, 1465, 117
1479, 117, 1465, 1466, 118
1480, 118, 1466, 1467, 119
1481, 119, 1467, 1468, 120
1482, 120, 1468, 1469, 121
1483, 121, 1469, 1470, 122
1484, 122, 1470, 1471, 123
1485, 123, 1471, 1472, 124
1486, 124, 1472, 1473, 125
1487, 125, 1473, 1474, 126
1488, 126, 1474, 1475, 127
1489, 127, 1475, 1476, 128
1490, 128, 1476, 1477, 129
1491, 129, 1477, 359, 6
1492, 355, 356, 1478, 1459
1493, 1459, 1478, 1479, 1460
1494, 1460, 1479, 1480, 1461
1495, 1461, 1480, 1481, 1462
1496, 1462, 1481, 1482, 1463
1497, 1463, 1482, 1483, 1464
1498, 1464, 1483, 1484, 1465
1499, 1465, 1484, 1485, 1466
1500, 1466, 1485, 1486, 1467
1501, 1467, 1486, 1487, 1468
1502, 1468, 1487, 1488, 1469
1503, 1469, 1488, 1489, 1470
1504, 1470, 1489, 1490, 1471
1505, 1471, 1490, 1491, 1472
1506, 1472, 1491, 1492, 1473
1507, 1473, 1492, 1493, 1474
1508, 1474, 1493, 1494, 1475
1509, 1475, 1494, 1495, 1476
1510, 1476, 1495, 1496, 1477
1511, 1477, 1496, 360, 359
1512, 356, 357, 1497, 1478
1513, 1478, 1497, 1498, 1479
1514, 1479, 1498, 1499, 1480
1515, 1480, 1499, 1500, 1481
1516, 1481, 1500, 1501, 1482
1517, 1482, 1501, 1502, 1483
1518, 1483, 1502, 1503, 1484
1519, 1484, 1503, 1504, 1485
1520, 1485, 1504, 1505, 1486
1521, 1486, 1505, 1506, 1487
1522, 1487, 1506, 1507, 1488
1523, 1488, 1507, 1508, 1489
1524, 1489, 1508, 1509, 1490
1525, 1490, 1509, 1510, 1491
1526, 1491, 1510, 1511, 1492
1527, 1492, 1511, 1512, 1493
1528, 1493, 1512, 1513, 1494
1529, 1494, 1513, 1514, 1495
1530, 1495, 1514, 1515, 1496
1531, 1496, 1515, 361, 360
1532, 357, 358, 1516, 1497
1533, 1497, 1516, 1517, 1498
1534, 1498, 1517, 1518, 1499
1535, 1499, 1518, 1519, 1500
1536, 1500, 1519, 1520, 1501
1537, 1501, 1520, 1521, 1502
1538, 1502, 1521, 1522, 1503
1539, 1503, 1522, 1523, 1504
1540, 1504, 1523, 1524, 1505
1541, 1505, 1524, 1525, 1506
1542, 1506, 1525, 1526, 1507
1543, 1507, 1526, 1527, 1508
1544, 1508, 1527, 1528, 1509
1545, 1509, 1528, 1529, 1510
1546, 1510, 1529, 1530, 1511
1547, 1511, 1530, 1531, 1512
1548, 1512, 1531, 1532, 1513
1549, 1513, 1532, 1533, 1514
1550, 1514, 1533, 1534, 1515
1551, 1515, 1534, 362, 361
1552, 358, 27, 363, 1516
1553, 1516, 363, 364, 1517
1554, 1517, 364, 365, 1518
1555, 1518, 365, 366, 1519
1556, 1519, 366, 367, 1520
1557, 1520, 367, 368, 1521
1558, 1521, 368, 369, 1522
1559, 1522, 369, 370, 1523
1560, 1523, 370, 371, 1524
1561, 1524, 371, 372, 1525
1562, 1525, 372, 373, 1526
1563, 1526, 373, 374, 1527
1564, 1527, 374, 375, 1528
1565, 1528, 375, 376, 1529
1566, 1529, 376, 377, 1530
1567, 1530, 377, 378, 1531
1568, 1531, 378, 379, 1532
1569, 1532, 379, 380, 1533
1570, 1533, 380, 381, 1534
1571, 1534, 381, 28, 362
*ELEMENT, type=CPS4, ELSET=Surface15
1572, 5, 355, 1535, 134
1573, 134, 1535, 1536, 135
1574, 135, 1536, 1537, 136
1575, 136, 1537, 1538, 137
1576, 137, 1538, 382, 8
1577, 355, 356, 1539, 1535
1578, 1535, 1539, 1540, 1536
1579, 1536, 1540, 1541, 1537
1580, 1537, 1541, 1542, 1538
1581, 1538, 1542, 383, 382
1582, 356, 357, 1543, 1539
1583, 1539, 1543, 1544, 1540
1584, 1540, 1544, 1545, 1541
1585, 1541, 1545, 1546, 1542
1586, 1542, 1546, 384, 383
1587, 357, 358, 1547, 1543
1588, 1543, 1547, 1548, 1544
1589, 1544, 1548, 1549, 1545
1590, 1545, 1549, 1550, 1546
1591, 1546, 1550, 385, 384
1592, 358, 27, 386, 1547
1593, 1547, 386, 387, 1548
1594, 1548, 387, 388, 1549
1595, 1549, 388, 389, 1550
1596, 1550, 389, 29, 385
*ELEMENT, type=CPS4, ELSET=Surface16
1597, 8, 382, 1551, 159
1598, 159, 1551, 1552, 160
1599, 160, 1552, 1553, 161
1600, 161, 1553, 1554, 162
1601, 162, 1554, 1555, 163
1602, 163, 1555, 1556, 164
1603, 164, 1556, 1557, 165
1604, 165, 1557, 1558, 166
1605, 166, 1558, 1559, 167
1606, 167, 1559, 1560, 168
1607, 168, 1560, 1561, 169
1608, 169, 1561, 1562, 170
1609, 170, 1562, 1563, 171
1610, 171, 1563, 1564, 172
1611, 172, 1564, 1565, 173
1612, 173, 1565, 1566, 174
1613, 174, 1566, 1567, 175
1614, 175, 1567, 1568, 176
1615, 176, 1568, 1569, 177
1616, 177, 1569, 390, 10
1617, 382, 383, 1570, 1551
1618, 1551, 1570, 1571, 1552
1619, 1552, 1571, 1572, 1553
1620, 1553, 1572, 1573, 1554
1621, 1554, 1573, 1574, 1555
1622, 1555, 1574, 1575, 1556
1623, 1556, 1575, 1576, 1557
1624, 1557, 1576, 1577, 1558
1625, 1558, 1577, 1578, 1559
1626, 1559, 1578, 1579, 1560
1627, 1560, 1579, 1580, 1561
1628, 1561, 1580, 1581, 1562
1629, 1562, 1581, 1582, 1563
1630, 1563, 1582, 1583, 1564
1631, 1564, 1583, 1584, 1565
1632, 1565, 1584, 1585, 1566
1633, 1566, 1585, 1586, 1567
1634, 1567, 1586, 1587, 1568
1635, 1568, 1587, 1588, 1569
1636, 1569, 1588, 391, 390
1637, 383, 384, 1589, 1570
1638, 1570, 1589, 1590, 1571
1639, 1571, 1590, 1591, 1572
1640, 1572, 1591, 1592, 1573
1641, 1573, 1592, 1593, 1574
1642, 1574, 1593, 1594, 1575
1643, 1575, 1594, 1595, 1576
1644, 1576, 1595, 1596, 1577
1645, 1577, 1596, 1597, 1578
1646, 1578, 1597, 1598, 1579
1647, 1579, 1598, 1599, 1580
1648, 1580, 1599, 1600, 1581
1649, 1581, 1600, 1601, 1582
1650, 1582, 1601, 1602, 1583
1651, 1583, 1602, 1603, 1584
1652, 1584, 1603, 1604, 1585
1653, 1585, 1604, 1605, 1586
1654, 1586, 1605, 1606, 1587
1655, 1587, 1606, 1607, 1588
1656, 1588, 1607, 392, 391
1657, 384, 385, 1608, 1589
1658, 1589, 1608, 1609, 1590
1659, 1590, 1609, 1610, 1591
1660, 1591, 1610, 1611, 1592
1661, 1592, 1611, 1612, 1593
1662, 1593, 1612, 1613, 1594
1663, 1594, 1613, 1614, 1595
1664, 1595, 1614, 1615, 1596
1665, 1596, 1615, 1616, 1597
1666, 1597, 1616, 1617, 1598
1667, 1598, 1617, 1618, 1599
1668, 1599, 1618, 1619, 1600
1669, 1600, 1619, 1620, 1601
1670, 1601, 1620, 1621, 1602
1671, 1602, 1621, 1622, 1603
1672, 1603, 1622, 1623, 1604
1673, 1604, 1623, 1624, 1605
1674, 1605, 1624, 1625, 1606
1675, 1606, 1625, 1626, 1607
1676, 1607, 1626, 393, 392
1677, 385, 29, 394, 1608
1678, 1608, 394, 395, 1609
1679, 1609, 395, 396, 1610
1680, 1610, 396, 397, 1611
1681, 1611, 397, 398, 1612
1682, 1612, 398, 399, 1613
1683, 1613, 399, 400, 1614
1684, 1614, 400, 401, 1615
1685, 1615, 401, 402, 1616
1686, 1616, 402, 403, 1617
1687, 1617, 403, 404, 1618
1688, 1618, 404, 405, 1619
1689, 1619, 405, 406, 1620
1690, 1620, 406, 407, 1621
1691, 1621, 407, 408, 1622
1692, 1622, 408, 409, 1623
1693, 1623, 409, 410, 1624
1694, 1624, 410, 411, 1625
1695, 1625, 411, 412, 1626
1696, 1626, 412, 30, 393
*ELSET,ELSET=Ceramic_Top
140, 141, 142, 143, 144, 145, 146, 147, 148, 149, 
150, 151, 152, 153, 154, 155, 156, 157, 158, 159, 
160, 161, 162, 163, 164, 165, 166, 167, 168, 169, 
170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 
*ELSET,ELSET=Ceramic_Bottom
96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 
106, 107, 108, 109, 110, 111, 112, 113, 114, 115, 
116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 
126, 127, 128, 129, 130, 131, 132, 133, 134, 135, 
136, 137, 138, 139, 
*ELSET,ELSET=Electrode_MinX
93, 94, 95, 
*ELSET,ELSET=Electrode_MaxX
88, 89, 90, 
*ELSET,ELSET=Contact_Ceramic
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 91, 92, 
*ELSET,ELSET=Copper
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 
615, 616, 617, 618, 619, 620, 621, 622, 623, 624, 
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 
645, 646, 647, 648, 649, 650, 651, 652, 653, 654, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 713, 714, 
715, 716, 717, 718, 719, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 
*ELSET,ELSET=SemiconductorL
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
365, 366, 367, 368, 369, 370, 371, 372, 373, 374, 
375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391, 392, 393, 394, 
395, 396, 397, 398, 399, 400, 401, 402, 403, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 
495, 496, 497, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
*ELSET,ELSET=SemiconductorR
720, 721, 722, 723, 724, 725, 726, 727, 728, 729, 
730, 731, 732, 733, 734, 735, 736, 737, 738, 739, 
740, 741, 742, 743, 744, 745, 746, 747, 748, 749, 
750, 751, 752, 753, 754, 755, 756, 757, 758, 759, 
760, 761, 762, 763, 764, 765, 766, 767, 768, 769, 
770, 771, 772, 773, 774, 775, 776, 777, 778, 779, 
780, 781, 782, 783, 784, 785, 786, 787, 788, 789, 
790, 791, 792, 793, 794, 795, 796, 797, 798, 799, 
800, 801, 802, 803, 804, 805, 806, 807, 808, 809, 
810, 811, 812, 813, 814, 815, 816, 817, 818, 819, 
820, 821, 822, 823, 824, 825, 826, 827, 828, 829, 
830, 831, 832, 833, 834, 835, 836, 837, 838, 839, 
840, 841, 842, 843, 844, 845, 846, 847, 848, 849, 
850, 851, 852, 853, 854, 855, 856, 857, 858, 859, 
860, 861, 862, 863, 864, 865, 866, 867, 868, 869, 
870, 871, 872, 873, 874, 875, 876, 877, 878, 879, 
880, 881, 882, 883, 884, 885, 886, 887, 888, 889, 
890, 891, 892, 893, 894, 895, 896, 897, 898, 899, 
900, 901, 902, 903, 904, 905, 906, 907, 908, 909, 
910, 911, 912, 913, 914, 915, 916, 917, 918, 919, 
920, 921, 922, 923, 924, 925, 926, 927, 928, 929, 
930, 931, 932, 933, 934, 935, 936, 937, 938, 939, 
940, 941, 942, 943, 944, 945, 946, 947, 948, 949, 
950, 951, 952, 953, 954, 955, 956, 957, 958, 959, 
960, 961, 962, 963, 964, 965, 966, 967, 968, 969, 
970, 971, 972, 973, 974, 975, 976, 977, 978, 979, 
980, 981, 982, 983, 984, 985, 986, 987, 988, 989, 
990, 991, 992, 993, 994, 995, 996, 997, 998, 999, 
1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 
1010, 1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 
1020, 1021, 1022, 1023, 1024, 1025, 1026, 1027, 1028, 1029, 
1030, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 1039, 
1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 1049, 
1050, 1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 
1060, 1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 1069, 
1070, 1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 
1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 
1090, 1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 
1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 
1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 
*ELSET,ELSET=Ceramic
1252, 1253, 1254, 1255, 1256, 1257, 1258, 1259, 1260, 1261, 
1262, 1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 
1272, 1273, 1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 
1282, 1283, 1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 
1292, 1293, 1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 
1302, 1303, 1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 
1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 
1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 
1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 
1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 
1352, 1353, 1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 
1362, 1363, 1364, 1365, 1366, 1367, 1368, 1369, 1370, 1371, 
1372, 1373, 1374, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 
1382, 1383, 1384, 1385, 1386, 1387, 1388, 1389, 1390, 1391, 
1392, 1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 
1402, 1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 
1412, 1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 
1422, 1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 
1432, 1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 1441, 
1442, 1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 
1452, 1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 
1462, 1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 
1472, 1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 
1482, 1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 
1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 
1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 
1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 
1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 
1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 
1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 
1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 
1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 
1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 
1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 
1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 
1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 1611, 
1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 1621, 
1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 1631, 
1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 1641, 
1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 1651, 
1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 
1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 
1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 
1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 
1692, 1693, 1694, 1695, 1696, 
*ELSET,ELSET=Surface
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
365, 366, 367, 368, 369, 370, 371, 372, 373, 374, 
375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391, 392, 393, 394, 
395, 396, 397, 398, 399, 400, 401, 402, 403, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 
495, 496, 497, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 610, 611, 612, 613, 614, 
615, 616, 617, 618, 619, 620, 621, 622, 623, 624, 
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 
645, 646, 647, 648, 649, 650, 651, 652, 653, 654, 
655, 656, 657, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 713, 714, 
715, 716, 717, 718, 719, 720, 721, 722, 723, 724, 
725, 726, 727, 728, 729, 730, 731, 732, 733, 734, 
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 
1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 
1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 
1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 
1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 
1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 
1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 
1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 
1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 
1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 
1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 
1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 
1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 
1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 
1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 
1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 
1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 
1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 
1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 
1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 
1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 
1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 
1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 
1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 
1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 
1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 
1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 
1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 
1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 
1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 
1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 
1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 
1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 
1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 
1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 
1695, 1696, 
*ELSET,ELSET=TO
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
365, 366, 367, 368, 369, 370, 371, 372, 373, 374, 
375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391, 392, 393, 394, 
395, 396, 397, 398, 399, 400, 401, 402, 403, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 
495, 496, 497, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
720, 721, 722, 723, 724, 725, 726, 727, 728, 729, 
730, 731, 732, 733, 734, 735, 736, 737, 738, 739, 
740, 741, 742, 743, 744, 745, 746, 747, 748, 749, 
750, 751, 752, 753, 754, 755, 756, 757, 758, 759, 
760, 761, 762, 763, 764, 765, 766, 767, 768, 769, 
