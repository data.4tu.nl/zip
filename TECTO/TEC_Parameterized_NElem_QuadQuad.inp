14125, 0.575, 1.46, 0
14126, 0.55, 1.46, 0
14127, 0.525, 1.46, 0
14128, 0.5, 1.46, 0
14129, 0.475, 1.46, 0
14130, 0.45, 1.46, 0
14131, 0.425, 1.46, 0
14132, 0.4, 1.46, 0
14133, 0.375, 1.46, 0
14134, 0.35, 1.46, 0
14135, 0.325, 1.46, 0
14136, 0.3, 1.46, 0
14137, 0.275, 1.46, 0
14138, 0.25, 1.46, 0
14139, 0.225, 1.46, 0
14140, 0.2, 1.46, 0
14141, 0.175, 1.46, 0
14142, 0.15, 1.46, 0
14143, 0.125, 1.46, 0
14144, 0.1, 1.46, 0
14145, 0.075, 1.46, 0
14146, 0.05, 1.46, 0
14147, 0.025, 1.46, 0
14148, 0.9875, 1.34, 0
14149, 0.975, 1.32, 0
14150, 0.9625, 1.34, 0
14151, 0.95, 1.32, 0
14152, 0.9375, 1.34, 0
14153, 0.925, 1.32, 0
14154, 0.9125, 1.34, 0
14155, 0.9, 1.32, 0
14156, 0.8875, 1.34, 0
14157, 0.875, 1.32, 0
14158, 0.8625, 1.34, 0
14159, 0.85, 1.32, 0
14160, 0.8375, 1.34, 0
14161, 0.825, 1.32, 0
14162, 0.8125, 1.34, 0
14163, 0.8, 1.32, 0
14164, 0.7875, 1.34, 0
14165, 0.775, 1.32, 0
14166, 0.7625, 1.34, 0
14167, 0.75, 1.32, 0
14168, 0.7375, 1.34, 0
14169, 0.725, 1.32, 0
14170, 0.7125, 1.34, 0
14171, 0.7, 1.32, 0
14172, 0.6875, 1.34, 0
14173, 0.675, 1.32, 0
14174, 0.6625, 1.34, 0
14175, 0.65, 1.32, 0
14176, 0.6375, 1.34, 0
14177, 0.625, 1.32, 0
14178, 0.6125, 1.34, 0
14179, 0.6, 1.32, 0
14180, 0.5875, 1.34, 0
14181, 0.575, 1.32, 0
14182, 0.5625, 1.34, 0
14183, 0.55, 1.32, 0
14184, 0.5375, 1.34, 0
14185, 0.525, 1.32, 0
14186, 0.5125, 1.34, 0
14187, 0.5, 1.32, 0
14188, 0.4875, 1.34, 0
14189, 0.475, 1.32, 0
14190, 0.4625, 1.34, 0
14191, 0.45, 1.32, 0
14192, 0.4375, 1.34, 0
14193, 0.425, 1.32, 0
14194, 0.4125, 1.34, 0
14195, 0.4, 1.32, 0
14196, 0.3875, 1.34, 0
14197, 0.375, 1.32, 0
14198, 0.3625, 1.34, 0
14199, 0.35, 1.32, 0
14200, 0.3375, 1.34, 0
14201, 0.325, 1.32, 0
14202, 0.3125, 1.34, 0
14203, 0.3, 1.32, 0
14204, 0.2875, 1.34, 0
14205, 0.275, 1.32, 0
14206, 0.2625, 1.34, 0
14207, 0.25, 1.32, 0
14208, 0.2375, 1.34, 0
14209, 0.225, 1.32, 0
14210, 0.2125, 1.34, 0
14211, 0.2, 1.32, 0
14212, 0.1875, 1.34, 0
14213, 0.175, 1.32, 0
14214, 0.1625, 1.34, 0
14215, 0.15, 1.32, 0
14216, 0.1375, 1.34, 0
14217, 0.125, 1.32, 0
14218, 0.1125, 1.34, 0
14219, 0.1, 1.32, 0
14220, 0.0875, 1.34, 0
14221, 0.075, 1.32, 0
14222, 0.0625, 1.34, 0
14223, 0.05, 1.32, 0
14224, 0.0375, 1.34, 0
14225, 0.025, 1.32, 0
14226, 0.0125, 1.34, 0
14227, 0.9875, 1.38, 0
14228, 0.975, 1.36, 0
14229, 0.9625, 1.38, 0
14230, 0.95, 1.36, 0
14231, 0.9375, 1.38, 0
14232, 0.925, 1.36, 0
14233, 0.9125, 1.38, 0
14234, 0.9, 1.36, 0
14235, 0.8875, 1.38, 0
14236, 0.875, 1.36, 0
14237, 0.8625, 1.38, 0
14238, 0.85, 1.36, 0
14239, 0.8375, 1.38, 0
14240, 0.825, 1.36, 0
14241, 0.8125, 1.38, 0
14242, 0.8, 1.36, 0
14243, 0.7875, 1.38, 0
14244, 0.775, 1.36, 0
14245, 0.7625, 1.38, 0
14246, 0.75, 1.36, 0
14247, 0.7375, 1.38, 0
14248, 0.725, 1.36, 0
14249, 0.7125, 1.38, 0
14250, 0.7, 1.36, 0
14251, 0.6875, 1.38, 0
14252, 0.675, 1.36, 0
14253, 0.6625, 1.38, 0
14254, 0.65, 1.36, 0
14255, 0.6375, 1.38, 0
14256, 0.625, 1.36, 0
14257, 0.6125, 1.38, 0
14258, 0.6, 1.36, 0
14259, 0.5875, 1.38, 0
14260, 0.575, 1.36, 0
14261, 0.5625, 1.38, 0
14262, 0.55, 1.36, 0
14263, 0.5375, 1.38, 0
14264, 0.525, 1.36, 0
14265, 0.5125, 1.38, 0
14266, 0.5, 1.36, 0
14267, 0.4875, 1.38, 0
14268, 0.475, 1.36, 0
14269, 0.4625, 1.38, 0
14270, 0.45, 1.36, 0
14271, 0.4375, 1.38, 0
14272, 0.425, 1.36, 0
14273, 0.4125, 1.38, 0
14274, 0.4, 1.36, 0
14275, 0.3875, 1.38, 0
14276, 0.375, 1.36, 0
14277, 0.3625, 1.38, 0
14278, 0.35, 1.36, 0
14279, 0.3375, 1.38, 0
14280, 0.325, 1.36, 0
14281, 0.3125, 1.38, 0
14282, 0.3, 1.36, 0
14283, 0.2875, 1.38, 0
14284, 0.275, 1.36, 0
14285, 0.2625, 1.38, 0
14286, 0.25, 1.36, 0
14287, 0.2375, 1.38, 0
14288, 0.225, 1.36, 0
14289, 0.2125, 1.38, 0
14290, 0.2, 1.36, 0
14291, 0.1875, 1.38, 0
14292, 0.175, 1.36, 0
14293, 0.1625, 1.38, 0
14294, 0.15, 1.36, 0
14295, 0.1375, 1.38, 0
14296, 0.125, 1.36, 0
14297, 0.1125, 1.38, 0
14298, 0.1, 1.36, 0
14299, 0.0875, 1.38, 0
14300, 0.075, 1.36, 0
14301, 0.0625, 1.38, 0
14302, 0.05, 1.36, 0
14303, 0.0375, 1.38, 0
14304, 0.025, 1.36, 0
14305, 0.0125, 1.38, 0
14306, 0.9875, 1.42, 0
14307, 0.975, 1.4, 0
14308, 0.9625, 1.42, 0
14309, 0.95, 1.4, 0
14310, 0.9375, 1.42, 0
14311, 0.925, 1.4, 0
14312, 0.9125, 1.42, 0
14313, 0.9, 1.4, 0
14314, 0.8875, 1.42, 0
14315, 0.875, 1.4, 0
14316, 0.8625, 1.42, 0
14317, 0.85, 1.4, 0
14318, 0.8375, 1.42, 0
14319, 0.825, 1.4, 0
14320, 0.8125, 1.42, 0
14321, 0.8, 1.4, 0
14322, 0.7875, 1.42, 0
14323, 0.775, 1.4, 0
14324, 0.7625, 1.42, 0
14325, 0.75, 1.4, 0
14326, 0.7375, 1.42, 0
14327, 0.725, 1.4, 0
14328, 0.7125, 1.42, 0
14329, 0.7, 1.4, 0
14330, 0.6875, 1.42, 0
14331, 0.675, 1.4, 0
14332, 0.6625, 1.42, 0
14333, 0.65, 1.4, 0
14334, 0.6375, 1.42, 0
14335, 0.625, 1.4, 0
14336, 0.6125, 1.42, 0
14337, 0.6, 1.4, 0
14338, 0.5875, 1.42, 0
14339, 0.575, 1.4, 0
14340, 0.5625, 1.42, 0
14341, 0.55, 1.4, 0
14342, 0.5375, 1.42, 0
14343, 0.525, 1.4, 0
14344, 0.5125, 1.42, 0
14345, 0.5, 1.4, 0
14346, 0.4875, 1.42, 0
14347, 0.475, 1.4, 0
14348, 0.4625, 1.42, 0
14349, 0.45, 1.4, 0
14350, 0.4375, 1.42, 0
14351, 0.425, 1.4, 0
14352, 0.4125, 1.42, 0
14353, 0.4, 1.4, 0
14354, 0.3875, 1.42, 0
14355, 0.375, 1.4, 0
14356, 0.3625, 1.42, 0
14357, 0.35, 1.4, 0
14358, 0.3375, 1.42, 0
14359, 0.325, 1.4, 0
14360, 0.3125, 1.42, 0
14361, 0.3, 1.4, 0
14362, 0.2875, 1.42, 0
14363, 0.275, 1.4, 0
14364, 0.2625, 1.42, 0
14365, 0.25, 1.4, 0
14366, 0.2375, 1.42, 0
14367, 0.225, 1.4, 0
14368, 0.2125, 1.42, 0
14369, 0.2, 1.4, 0
14370, 0.1875, 1.42, 0
14371, 0.175, 1.4, 0
14372, 0.1625, 1.42, 0
14373, 0.15, 1.4, 0
14374, 0.1375, 1.42, 0
14375, 0.125, 1.4, 0
14376, 0.1125, 1.42, 0
14377, 0.1, 1.4, 0
14378, 0.0875, 1.42, 0
14379, 0.075, 1.4, 0
14380, 0.0625, 1.42, 0
14381, 0.05, 1.4, 0
14382, 0.0375, 1.42, 0
14383, 0.025, 1.4, 0
14384, 0.0125, 1.42, 0
14385, 0.9875, 1.46, 0
14386, 0.975, 1.44, 0
14387, 0.9625, 1.46, 0
14388, 0.95, 1.44, 0
14389, 0.9375, 1.46, 0
14390, 0.925, 1.44, 0
14391, 0.9125, 1.46, 0
14392, 0.9, 1.44, 0
14393, 0.8875, 1.46, 0
14394, 0.875, 1.44, 0
14395, 0.8625, 1.46, 0
14396, 0.85, 1.44, 0
14397, 0.8375, 1.46, 0
14398, 0.825, 1.44, 0
14399, 0.8125, 1.46, 0
14400, 0.8, 1.44, 0
14401, 0.7875, 1.46, 0
14402, 0.775, 1.44, 0
14403, 0.7625, 1.46, 0
14404, 0.75, 1.44, 0
14405, 0.7375, 1.46, 0
14406, 0.725, 1.44, 0
14407, 0.7125, 1.46, 0
14408, 0.7, 1.44, 0
14409, 0.6875, 1.46, 0
14410, 0.675, 1.44, 0
14411, 0.6625, 1.46, 0
14412, 0.65, 1.44, 0
14413, 0.6375, 1.46, 0
14414, 0.625, 1.44, 0
14415, 0.6125, 1.46, 0
14416, 0.6, 1.44, 0
14417, 0.5875, 1.46, 0
14418, 0.575, 1.44, 0
14419, 0.5625, 1.46, 0
14420, 0.55, 1.44, 0
14421, 0.5375, 1.46, 0
14422, 0.525, 1.44, 0
14423, 0.5125, 1.46, 0
14424, 0.5, 1.44, 0
14425, 0.4875, 1.46, 0
14426, 0.475, 1.44, 0
14427, 0.4625, 1.46, 0
14428, 0.45, 1.44, 0
14429, 0.4375, 1.46, 0
14430, 0.425, 1.44, 0
14431, 0.4125, 1.46, 0
14432, 0.4, 1.44, 0
14433, 0.3875, 1.46, 0
14434, 0.375, 1.44, 0
14435, 0.3625, 1.46, 0
14436, 0.35, 1.44, 0
14437, 0.3375, 1.46, 0
14438, 0.325, 1.44, 0
14439, 0.3125, 1.46, 0
14440, 0.3, 1.44, 0
14441, 0.2875, 1.46, 0
14442, 0.275, 1.44, 0
14443, 0.2625, 1.46, 0
14444, 0.25, 1.44, 0
14445, 0.2375, 1.46, 0
14446, 0.225, 1.44, 0
14447, 0.2125, 1.46, 0
14448, 0.2, 1.44, 0
14449, 0.1875, 1.46, 0
14450, 0.175, 1.44, 0
14451, 0.1625, 1.46, 0
14452, 0.15, 1.44, 0
14453, 0.1375, 1.46, 0
14454, 0.125, 1.44, 0
14455, 0.1125, 1.46, 0
14456, 0.1, 1.44, 0
14457, 0.0875, 1.46, 0
14458, 0.075, 1.44, 0
14459, 0.0625, 1.46, 0
14460, 0.05, 1.44, 0
14461, 0.0375, 1.46, 0
14462, 0.025, 1.44, 0
14463, 0.0125, 1.46, 0
14464, 0.975, 1.48, 0
14465, 0.95, 1.48, 0
14466, 0.925, 1.48, 0
14467, 0.9, 1.48, 0
14468, 0.875, 1.48, 0
14469, 0.85, 1.48, 0
14470, 0.825, 1.48, 0
14471, 0.8, 1.48, 0
14472, 0.775, 1.48, 0
14473, 0.75, 1.48, 0
14474, 0.725, 1.48, 0
14475, 0.7, 1.48, 0
14476, 0.675, 1.48, 0
14477, 0.65, 1.48, 0
14478, 0.625, 1.48, 0
14479, 0.6, 1.48, 0
14480, 0.575, 1.48, 0
14481, 0.55, 1.48, 0
14482, 0.525, 1.48, 0
14483, 0.5, 1.48, 0
14484, 0.475, 1.48, 0
14485, 0.45, 1.48, 0
14486, 0.425, 1.48, 0
14487, 0.4, 1.48, 0
14488, 0.375, 1.48, 0
14489, 0.35, 1.48, 0
14490, 0.325, 1.48, 0
14491, 0.3, 1.48, 0
14492, 0.275, 1.48, 0
14493, 0.25, 1.48, 0
14494, 0.225, 1.48, 0
14495, 0.2, 1.48, 0
14496, 0.175, 1.48, 0
14497, 0.15, 1.48, 0
14498, 0.125, 1.48, 0
14499, 0.1, 1.48, 0
14500, 0.075, 1.48, 0
14501, 0.05, 1.48, 0
14502, 0.025, 1.48, 0
14503, 1.04, 1.34, 0
14504, 1.08, 1.34, 0
14505, 1.12, 1.34, 0
14506, 1.16, 1.34, 0
14507, 1.04, 1.38, 0
14508, 1.08, 1.38, 0
14509, 1.12, 1.38, 0
14510, 1.16, 1.38, 0
14511, 1.04, 1.42, 0
14512, 1.08, 1.42, 0
14513, 1.12, 1.42, 0
14514, 1.16, 1.42, 0
14515, 1.04, 1.46, 0
14516, 1.08, 1.46, 0
14517, 1.12, 1.46, 0
14518, 1.16, 1.46, 0
14519, 1.02, 1.34, 0
14520, 1.04, 1.32, 0
14521, 1.06, 1.34, 0
14522, 1.08, 1.32, 0
14523, 1.1, 1.34, 0
14524, 1.12, 1.32, 0
14525, 1.14, 1.34, 0
14526, 1.16, 1.32, 0
14527, 1.18, 1.34, 0
14528, 1.02, 1.38, 0
14529, 1.04, 1.36, 0
14530, 1.06, 1.38, 0
14531, 1.08, 1.36, 0
14532, 1.1, 1.38, 0
14533, 1.12, 1.36, 0
14534, 1.14, 1.38, 0
14535, 1.16, 1.36, 0
14536, 1.18, 1.38, 0
14537, 1.02, 1.42, 0
14538, 1.04, 1.4, 0
14539, 1.06, 1.42, 0
14540, 1.08, 1.4, 0
14541, 1.1, 1.42, 0
14542, 1.12, 1.4, 0
14543, 1.14, 1.42, 0
14544, 1.16, 1.4, 0
14545, 1.18, 1.42, 0
14546, 1.02, 1.46, 0
14547, 1.04, 1.44, 0
14548, 1.06, 1.46, 0
14549, 1.08, 1.44, 0
14550, 1.1, 1.46, 0
14551, 1.12, 1.44, 0
14552, 1.14, 1.46, 0
14553, 1.16, 1.44, 0
14554, 1.18, 1.46, 0
14555, 1.04, 1.48, 0
14556, 1.08, 1.48, 0
14557, 1.12, 1.48, 0
14558, 1.16, 1.48, 0
14559, 1.225, 1.34, 0
14560, 1.25, 1.34, 0
14561, 1.275, 1.34, 0
14562, 1.3, 1.34, 0
14563, 1.325, 1.34, 0
14564, 1.35, 1.34, 0
14565, 1.375, 1.34, 0
14566, 1.4, 1.34, 0
14567, 1.425, 1.34, 0
14568, 1.45, 1.34, 0
14569, 1.475, 1.34, 0
14570, 1.5, 1.34, 0
14571, 1.525, 1.34, 0
14572, 1.55, 1.34, 0
14573, 1.575, 1.34, 0
14574, 1.6, 1.34, 0
14575, 1.625, 1.34, 0
14576, 1.65, 1.34, 0
14577, 1.675, 1.34, 0
14578, 1.7, 1.34, 0
14579, 1.725, 1.34, 0
14580, 1.75, 1.34, 0
14581, 1.775, 1.34, 0
14582, 1.8, 1.34, 0
14583, 1.825, 1.34, 0
14584, 1.85, 1.34, 0
14585, 1.875, 1.34, 0
14586, 1.9, 1.34, 0
14587, 1.925, 1.34, 0
14588, 1.95, 1.34, 0
14589, 1.975, 1.34, 0
14590, 2, 1.34, 0
14591, 2.025, 1.34, 0
14592, 2.05, 1.34, 0
14593, 2.075, 1.34, 0
14594, 2.1, 1.34, 0
14595, 2.125, 1.34, 0
14596, 2.15, 1.34, 0
14597, 2.175, 1.34, 0
14598, 1.225, 1.38, 0
14599, 1.25, 1.38, 0
14600, 1.275, 1.38, 0
14601, 1.3, 1.38, 0
14602, 1.325, 1.38, 0
14603, 1.35, 1.38, 0
14604, 1.375, 1.38, 0
14605, 1.4, 1.38, 0
14606, 1.425, 1.38, 0
14607, 1.45, 1.38, 0
14608, 1.475, 1.38, 0
14609, 1.5, 1.38, 0
14610, 1.525, 1.38, 0
14611, 1.55, 1.38, 0
14612, 1.575, 1.38, 0
14613, 1.6, 1.38, 0
14614, 1.625, 1.38, 0
14615, 1.65, 1.38, 0
14616, 1.675, 1.38, 0
14617, 1.7, 1.38, 0
14618, 1.725, 1.38, 0
14619, 1.75, 1.38, 0
14620, 1.775, 1.38, 0
14621, 1.8, 1.38, 0
14622, 1.825, 1.38, 0
14623, 1.85, 1.38, 0
14624, 1.875, 1.38, 0
14625, 1.9, 1.38, 0
14626, 1.925, 1.38, 0
14627, 1.95, 1.38, 0
14628, 1.975, 1.38, 0
14629, 2, 1.38, 0
14630, 2.025, 1.38, 0
14631, 2.05, 1.38, 0
14632, 2.075, 1.38, 0
14633, 2.1, 1.38, 0
14634, 2.125, 1.38, 0
14635, 2.15, 1.38, 0
14636, 2.175, 1.38, 0
14637, 1.225, 1.42, 0
14638, 1.25, 1.42, 0
14639, 1.275, 1.42, 0
14640, 1.3, 1.42, 0
14641, 1.325, 1.42, 0
14642, 1.35, 1.42, 0
14643, 1.375, 1.42, 0
14644, 1.4, 1.42, 0
14645, 1.425, 1.42, 0
14646, 1.45, 1.42, 0
14647, 1.475, 1.42, 0
14648, 1.5, 1.42, 0
14649, 1.525, 1.42, 0
14650, 1.55, 1.42, 0
14651, 1.575, 1.42, 0
14652, 1.6, 1.42, 0
14653, 1.625, 1.42, 0
14654, 1.65, 1.42, 0
14655, 1.675, 1.42, 0
14656, 1.7, 1.42, 0
14657, 1.725, 1.42, 0
14658, 1.75, 1.42, 0
14659, 1.775, 1.42, 0
14660, 1.8, 1.42, 0
14661, 1.825, 1.42, 0
14662, 1.85, 1.42, 0
14663, 1.875, 1.42, 0
14664, 1.9, 1.42, 0
14665, 1.925, 1.42, 0
14666, 1.95, 1.42, 0
14667, 1.975, 1.42, 0
14668, 2, 1.42, 0
14669, 2.025, 1.42, 0
14670, 2.05, 1.42, 0
14671, 2.075, 1.42, 0
14672, 2.1, 1.42, 0
14673, 2.125, 1.42, 0
14674, 2.15, 1.42, 0
14675, 2.175, 1.42, 0
14676, 1.225, 1.46, 0
14677, 1.25, 1.46, 0
14678, 1.275, 1.46, 0
14679, 1.3, 1.46, 0
14680, 1.325, 1.46, 0
14681, 1.35, 1.46, 0
14682, 1.375, 1.46, 0
14683, 1.4, 1.46, 0
14684, 1.425, 1.46, 0
14685, 1.45, 1.46, 0
14686, 1.475, 1.46, 0
14687, 1.5, 1.46, 0
14688, 1.525, 1.46, 0
14689, 1.55, 1.46, 0
14690, 1.575, 1.46, 0
14691, 1.6, 1.46, 0
14692, 1.625, 1.46, 0
14693, 1.65, 1.46, 0
14694, 1.675, 1.46, 0
14695, 1.7, 1.46, 0
14696, 1.725, 1.46, 0
14697, 1.75, 1.46, 0
14698, 1.775, 1.46, 0
14699, 1.8, 1.46, 0
14700, 1.825, 1.46, 0
14701, 1.85, 1.46, 0
14702, 1.875, 1.46, 0
14703, 1.9, 1.46, 0
14704, 1.925, 1.46, 0
14705, 1.95, 1.46, 0
14706, 1.975, 1.46, 0
14707, 2, 1.46, 0
14708, 2.025, 1.46, 0
14709, 2.05, 1.46, 0
14710, 2.075, 1.46, 0
14711, 2.1, 1.46, 0
14712, 2.125, 1.46, 0
14713, 2.15, 1.46, 0
14714, 2.175, 1.46, 0
14715, 1.2125, 1.34, 0
14716, 1.225, 1.32, 0
14717, 1.2375, 1.34, 0
14718, 1.25, 1.32, 0
14719, 1.2625, 1.34, 0
14720, 1.275, 1.32, 0
14721, 1.2875, 1.34, 0
14722, 1.3, 1.32, 0
14723, 1.3125, 1.34, 0
14724, 1.325, 1.32, 0
14725, 1.3375, 1.34, 0
14726, 1.35, 1.32, 0
14727, 1.3625, 1.34, 0
14728, 1.375, 1.32, 0
14729, 1.3875, 1.34, 0
14730, 1.4, 1.32, 0
14731, 1.4125, 1.34, 0
14732, 1.425, 1.32, 0
14733, 1.4375, 1.34, 0
14734, 1.45, 1.32, 0
14735, 1.4625, 1.34, 0
14736, 1.475, 1.32, 0
14737, 1.4875, 1.34, 0
14738, 1.5, 1.32, 0
14739, 1.5125, 1.34, 0
14740, 1.525, 1.32, 0
14741, 1.5375, 1.34, 0
14742, 1.55, 1.32, 0
14743, 1.5625, 1.34, 0
14744, 1.575, 1.32, 0
14745, 1.5875, 1.34, 0
14746, 1.6, 1.32, 0
14747, 1.6125, 1.34, 0
14748, 1.625, 1.32, 0
14749, 1.6375, 1.34, 0
14750, 1.65, 1.32, 0
14751, 1.6625, 1.34, 0
14752, 1.675, 1.32, 0
14753, 1.6875, 1.34, 0
14754, 1.7, 1.32, 0
14755, 1.7125, 1.34, 0
14756, 1.725, 1.32, 0
14757, 1.7375, 1.34, 0
14758, 1.75, 1.32, 0
14759, 1.7625, 1.34, 0
14760, 1.775, 1.32, 0
14761, 1.7875, 1.34, 0
14762, 1.8, 1.32, 0
14763, 1.8125, 1.34, 0
14764, 1.825, 1.32, 0
14765, 1.8375, 1.34, 0
14766, 1.85, 1.32, 0
14767, 1.8625, 1.34, 0
14768, 1.875, 1.32, 0
14769, 1.8875, 1.34, 0
14770, 1.9, 1.32, 0
14771, 1.9125, 1.34, 0
14772, 1.925, 1.32, 0
14773, 1.9375, 1.34, 0
14774, 1.95, 1.32, 0
14775, 1.9625, 1.34, 0
14776, 1.975, 1.32, 0
14777, 1.9875, 1.34, 0
14778, 2, 1.32, 0
14779, 2.0125, 1.34, 0
14780, 2.025, 1.32, 0
14781, 2.0375, 1.34, 0
14782, 2.05, 1.32, 0
14783, 2.0625, 1.34, 0
14784, 2.075, 1.32, 0
14785, 2.0875, 1.34, 0
14786, 2.1, 1.32, 0
14787, 2.1125, 1.34, 0
14788, 2.125, 1.32, 0
14789, 2.1375, 1.34, 0
14790, 2.15, 1.32, 0
14791, 2.1625, 1.34, 0
14792, 2.175, 1.32, 0
14793, 2.1875, 1.34, 0
14794, 1.2125, 1.38, 0
14795, 1.225, 1.36, 0
14796, 1.2375, 1.38, 0
14797, 1.25, 1.36, 0
14798, 1.2625, 1.38, 0
14799, 1.275, 1.36, 0
14800, 1.2875, 1.38, 0
14801, 1.3, 1.36, 0
14802, 1.3125, 1.38, 0
14803, 1.325, 1.36, 0
14804, 1.3375, 1.38, 0
14805, 1.35, 1.36, 0
14806, 1.3625, 1.38, 0
14807, 1.375, 1.36, 0
14808, 1.3875, 1.38, 0
14809, 1.4, 1.36, 0
14810, 1.4125, 1.38, 0
14811, 1.425, 1.36, 0
14812, 1.4375, 1.38, 0
14813, 1.45, 1.36, 0
14814, 1.4625, 1.38, 0
14815, 1.475, 1.36, 0
14816, 1.4875, 1.38, 0
14817, 1.5, 1.36, 0
14818, 1.5125, 1.38, 0
14819, 1.525, 1.36, 0
14820, 1.5375, 1.38, 0
14821, 1.55, 1.36, 0
14822, 1.5625, 1.38, 0
14823, 1.575, 1.36, 0
14824, 1.5875, 1.38, 0
14825, 1.6, 1.36, 0
14826, 1.6125, 1.38, 0
14827, 1.625, 1.36, 0
14828, 1.6375, 1.38, 0
14829, 1.65, 1.36, 0
14830, 1.6625, 1.38, 0
14831, 1.675, 1.36, 0
14832, 1.6875, 1.38, 0
14833, 1.7, 1.36, 0
14834, 1.7125, 1.38, 0
14835, 1.725, 1.36, 0
14836, 1.7375, 1.38, 0
14837, 1.75, 1.36, 0
14838, 1.7625, 1.38, 0
14839, 1.775, 1.36, 0
14840, 1.7875, 1.38, 0
14841, 1.8, 1.36, 0
14842, 1.8125, 1.38, 0
14843, 1.825, 1.36, 0
14844, 1.8375, 1.38, 0
14845, 1.85, 1.36, 0
14846, 1.8625, 1.38, 0
14847, 1.875, 1.36, 0
14848, 1.8875, 1.38, 0
14849, 1.9, 1.36, 0
14850, 1.9125, 1.38, 0
14851, 1.925, 1.36, 0
14852, 1.9375, 1.38, 0
14853, 1.95, 1.36, 0
14854, 1.9625, 1.38, 0
14855, 1.975, 1.36, 0
14856, 1.9875, 1.38, 0
14857, 2, 1.36, 0
14858, 2.0125, 1.38, 0
14859, 2.025, 1.36, 0
14860, 2.0375, 1.38, 0
14861, 2.05, 1.36, 0
14862, 2.0625, 1.38, 0
14863, 2.075, 1.36, 0
14864, 2.0875, 1.38, 0
14865, 2.1, 1.36, 0
14866, 2.1125, 1.38, 0
14867, 2.125, 1.36, 0
14868, 2.1375, 1.38, 0
14869, 2.15, 1.36, 0
14870, 2.1625, 1.38, 0
14871, 2.175, 1.36, 0
14872, 2.1875, 1.38, 0
14873, 1.2125, 1.42, 0
14874, 1.225, 1.4, 0
14875, 1.2375, 1.42, 0
14876, 1.25, 1.4, 0
14877, 1.2625, 1.42, 0
14878, 1.275, 1.4, 0
14879, 1.2875, 1.42, 0
14880, 1.3, 1.4, 0
14881, 1.3125, 1.42, 0
14882, 1.325, 1.4, 0
14883, 1.3375, 1.42, 0
14884, 1.35, 1.4, 0
14885, 1.3625, 1.42, 0
14886, 1.375, 1.4, 0
14887, 1.3875, 1.42, 0
14888, 1.4, 1.4, 0
14889, 1.4125, 1.42, 0
14890, 1.425, 1.4, 0
14891, 1.4375, 1.42, 0
14892, 1.45, 1.4, 0
14893, 1.4625, 1.42, 0
14894, 1.475, 1.4, 0
14895, 1.4875, 1.42, 0
14896, 1.5, 1.4, 0
14897, 1.5125, 1.42, 0
14898, 1.525, 1.4, 0
14899, 1.5375, 1.42, 0
14900, 1.55, 1.4, 0
14901, 1.5625, 1.42, 0
14902, 1.575, 1.4, 0
14903, 1.5875, 1.42, 0
14904, 1.6, 1.4, 0
14905, 1.6125, 1.42, 0
14906, 1.625, 1.4, 0
14907, 1.6375, 1.42, 0
14908, 1.65, 1.4, 0
14909, 1.6625, 1.42, 0
14910, 1.675, 1.4, 0
14911, 1.6875, 1.42, 0
14912, 1.7, 1.4, 0
14913, 1.7125, 1.42, 0
14914, 1.725, 1.4, 0
14915, 1.7375, 1.42, 0
14916, 1.75, 1.4, 0
14917, 1.7625, 1.42, 0
14918, 1.775, 1.4, 0
14919, 1.7875, 1.42, 0
14920, 1.8, 1.4, 0
14921, 1.8125, 1.42, 0
14922, 1.825, 1.4, 0
14923, 1.8375, 1.42, 0
14924, 1.85, 1.4, 0
14925, 1.8625, 1.42, 0
14926, 1.875, 1.4, 0
14927, 1.8875, 1.42, 0
14928, 1.9, 1.4, 0
14929, 1.9125, 1.42, 0
14930, 1.925, 1.4, 0
14931, 1.9375, 1.42, 0
14932, 1.95, 1.4, 0
14933, 1.9625, 1.42, 0
14934, 1.975, 1.4, 0
14935, 1.9875, 1.42, 0
14936, 2, 1.4, 0
14937, 2.0125, 1.42, 0
14938, 2.025, 1.4, 0
14939, 2.0375, 1.42, 0
14940, 2.05, 1.4, 0
14941, 2.0625, 1.42, 0
14942, 2.075, 1.4, 0
14943, 2.0875, 1.42, 0
14944, 2.1, 1.4, 0
14945, 2.1125, 1.42, 0
14946, 2.125, 1.4, 0
14947, 2.1375, 1.42, 0
14948, 2.15, 1.4, 0
14949, 2.1625, 1.42, 0
14950, 2.175, 1.4, 0
14951, 2.1875, 1.42, 0
14952, 1.2125, 1.46, 0
14953, 1.225, 1.44, 0
14954, 1.2375, 1.46, 0
14955, 1.25, 1.44, 0
14956, 1.2625, 1.46, 0
14957, 1.275, 1.44, 0
14958, 1.2875, 1.46, 0
14959, 1.3, 1.44, 0
14960, 1.3125, 1.46, 0
14961, 1.325, 1.44, 0
14962, 1.3375, 1.46, 0
14963, 1.35, 1.44, 0
14964, 1.3625, 1.46, 0
14965, 1.375, 1.44, 0
14966, 1.3875, 1.46, 0
14967, 1.4, 1.44, 0
14968, 1.4125, 1.46, 0
14969, 1.425, 1.44, 0
14970, 1.4375, 1.46, 0
14971, 1.45, 1.44, 0
14972, 1.4625, 1.46, 0
14973, 1.475, 1.44, 0
14974, 1.4875, 1.46, 0
14975, 1.5, 1.44, 0
14976, 1.5125, 1.46, 0
14977, 1.525, 1.44, 0
14978, 1.5375, 1.46, 0
14979, 1.55, 1.44, 0
14980, 1.5625, 1.46, 0
14981, 1.575, 1.44, 0
14982, 1.5875, 1.46, 0
14983, 1.6, 1.44, 0
14984, 1.6125, 1.46, 0
14985, 1.625, 1.44, 0
14986, 1.6375, 1.46, 0
14987, 1.65, 1.44, 0
14988, 1.6625, 1.46, 0
14989, 1.675, 1.44, 0
14990, 1.6875, 1.46, 0
14991, 1.7, 1.44, 0
14992, 1.7125, 1.46, 0
14993, 1.725, 1.44, 0
14994, 1.7375, 1.46, 0
14995, 1.75, 1.44, 0
14996, 1.7625, 1.46, 0
14997, 1.775, 1.44, 0
14998, 1.7875, 1.46, 0
14999, 1.8, 1.44, 0
15000, 1.8125, 1.46, 0
15001, 1.825, 1.44, 0
15002, 1.8375, 1.46, 0
15003, 1.85, 1.44, 0
15004, 1.8625, 1.46, 0
15005, 1.875, 1.44, 0
15006, 1.8875, 1.46, 0
15007, 1.9, 1.44, 0
15008, 1.9125, 1.46, 0
15009, 1.925, 1.44, 0
15010, 1.9375, 1.46, 0
15011, 1.95, 1.44, 0
15012, 1.9625, 1.46, 0
15013, 1.975, 1.44, 0
15014, 1.9875, 1.46, 0
15015, 2, 1.44, 0
15016, 2.0125, 1.46, 0
15017, 2.025, 1.44, 0
15018, 2.0375, 1.46, 0
15019, 2.05, 1.44, 0
15020, 2.0625, 1.46, 0
15021, 2.075, 1.44, 0
15022, 2.0875, 1.46, 0
15023, 2.1, 1.44, 0
15024, 2.1125, 1.46, 0
15025, 2.125, 1.44, 0
15026, 2.1375, 1.46, 0
15027, 2.15, 1.44, 0
15028, 2.1625, 1.46, 0
15029, 2.175, 1.44, 0
15030, 2.1875, 1.46, 0
15031, 1.225, 1.48, 0
15032, 1.25, 1.48, 0
15033, 1.275, 1.48, 0
15034, 1.3, 1.48, 0
15035, 1.325, 1.48, 0
15036, 1.35, 1.48, 0
15037, 1.375, 1.48, 0
15038, 1.4, 1.48, 0
15039, 1.425, 1.48, 0
15040, 1.45, 1.48, 0
15041, 1.475, 1.48, 0
15042, 1.5, 1.48, 0
15043, 1.525, 1.48, 0
15044, 1.55, 1.48, 0
15045, 1.575, 1.48, 0
15046, 1.6, 1.48, 0
15047, 1.625, 1.48, 0
15048, 1.65, 1.48, 0
15049, 1.675, 1.48, 0
15050, 1.7, 1.48, 0
15051, 1.725, 1.48, 0
15052, 1.75, 1.48, 0
15053, 1.775, 1.48, 0
15054, 1.8, 1.48, 0
15055, 1.825, 1.48, 0
15056, 1.85, 1.48, 0
15057, 1.875, 1.48, 0
15058, 1.9, 1.48, 0
15059, 1.925, 1.48, 0
15060, 1.95, 1.48, 0
15061, 1.975, 1.48, 0
15062, 2, 1.48, 0
15063, 2.025, 1.48, 0
15064, 2.05, 1.48, 0
15065, 2.075, 1.48, 0
15066, 2.1, 1.48, 0
15067, 2.125, 1.48, 0
15068, 2.15, 1.48, 0
15069, 2.175, 1.48, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
31, 1, 70, 31
32, 31, 71, 32
33, 32, 72, 33
34, 33, 73, 34
35, 34, 74, 35
36, 35, 75, 36
37, 36, 76, 37
38, 37, 77, 38
39, 38, 78, 39
40, 39, 79, 40
41, 40, 80, 41
42, 41, 81, 42
43, 42, 82, 43
44, 43, 83, 44
45, 44, 84, 45
46, 45, 85, 46
47, 46, 86, 47
48, 47, 87, 48
49, 48, 88, 49
50, 49, 89, 50
51, 50, 90, 51
52, 51, 91, 52
53, 52, 92, 53
54, 53, 93, 54
55, 54, 94, 55
56, 55, 95, 56
57, 56, 96, 57
58, 57, 97, 58
59, 58, 98, 59
60, 59, 99, 60
61, 60, 100, 61
62, 61, 101, 62
63, 62, 102, 63
64, 63, 103, 64
65, 64, 104, 65
66, 65, 105, 66
67, 66, 106, 67
68, 67, 107, 68
69, 68, 108, 69
70, 69, 109, 2
*ELEMENT, type=T3D3, ELSET=Line2
71, 2, 149, 110
72, 110, 150, 111
73, 111, 151, 112
74, 112, 152, 113
75, 113, 153, 114
76, 114, 154, 115
77, 115, 155, 116
78, 116, 156, 117
79, 117, 157, 118
80, 118, 158, 119
81, 119, 159, 120
82, 120, 160, 121
83, 121, 161, 122
84, 122, 162, 123
85, 123, 163, 124
86, 124, 164, 125
87, 125, 165, 126
88, 126, 166, 127
89, 127, 167, 128
90, 128, 168, 129
91, 129, 169, 130
92, 130, 170, 131
93, 131, 171, 132
94, 132, 172, 133
95, 133, 173, 134
96, 134, 174, 135
97, 135, 175, 136
98, 136, 176, 137
99, 137, 177, 138
100, 138, 178, 139
101, 139, 179, 140
102, 140, 180, 141
103, 141, 181, 142
104, 142, 182, 143
105, 143, 183, 144
106, 144, 184, 145
107, 145, 185, 146
108, 146, 186, 147
109, 147, 187, 148
110, 148, 188, 3
*ELEMENT, type=T3D3, ELSET=Line3
111, 3, 228, 189
112, 189, 229, 190
113, 190, 230, 191
114, 191, 231, 192
115, 192, 232, 193
116, 193, 233, 194
117, 194, 234, 195
118, 195, 235, 196
119, 196, 236, 197
120, 197, 237, 198
121, 198, 238, 199
122, 199, 239, 200
123, 200, 240, 201
124, 201, 241, 202
125, 202, 242, 203
126, 203, 243, 204
127, 204, 244, 205
128, 205, 245, 206
129, 206, 246, 207
130, 207, 247, 208
131, 208, 248, 209
132, 209, 249, 210
133, 210, 250, 211
134, 211, 251, 212
135, 212, 252, 213
136, 213, 253, 214
137, 214, 254, 215
138, 215, 255, 216
139, 216, 256, 217
140, 217, 257, 218
141, 218, 258, 219
142, 219, 259, 220
143, 220, 260, 221
144, 221, 261, 222
145, 222, 262, 223
146, 223, 263, 224
147, 224, 264, 225
148, 225, 265, 226
149, 226, 266, 227
150, 227, 267, 4
*ELEMENT, type=T3D3, ELSET=Line4
151, 4, 307, 268
152, 268, 308, 269
153, 269, 309, 270
154, 270, 310, 271
155, 271, 311, 272
156, 272, 312, 273
157, 273, 313, 274
158, 274, 314, 275
159, 275, 315, 276
160, 276, 316, 277
161, 277, 317, 278
162, 278, 318, 279
163, 279, 319, 280
164, 280, 320, 281
165, 281, 321, 282
166, 282, 322, 283
167, 283, 323, 284
168, 284, 324, 285
169, 285, 325, 286
170, 286, 326, 287
171, 287, 327, 288
172, 288, 328, 289
173, 289, 329, 290
174, 290, 330, 291
175, 291, 331, 292
176, 292, 332, 293
177, 293, 333, 294
178, 294, 334, 295
179, 295, 335, 296
180, 296, 336, 297
181, 297, 337, 298
182, 298, 338, 299
183, 299, 339, 300
184, 300, 340, 301
185, 301, 341, 302
186, 302, 342, 303
187, 303, 343, 304
188, 304, 344, 305
189, 305, 345, 306
190, 306, 346, 1
*ELEMENT, type=T3D3, ELSET=Line5
191, 3, 351, 347
192, 347, 352, 348
193, 348, 353, 349
194, 349, 354, 350
195, 350, 355, 5
*ELEMENT, type=T3D3, ELSET=Line6
196, 4, 360, 356
197, 356, 361, 357
198, 357, 362, 358
199, 358, 363, 359
200, 359, 364, 6
*ELEMENT, type=T3D3, ELSET=Line7
201, 5, 404, 365
202, 365, 405, 366
203, 366, 406, 367
204, 367, 407, 368
205, 368, 408, 369
206, 369, 409, 370
207, 370, 410, 371
208, 371, 411, 372
209, 372, 412, 373
210, 373, 413, 374
211, 374, 414, 375
212, 375, 415, 376
213, 376, 416, 377
214, 377, 417, 378
215, 378, 418, 379
216, 379, 419, 380
217, 380, 420, 381
218, 381, 421, 382
219, 382, 422, 383
220, 383, 423, 384
221, 384, 424, 385
222, 385, 425, 386
223, 386, 426, 387
224, 387, 427, 388
225, 388, 428, 389
226, 389, 429, 390
227, 390, 430, 391
228, 391, 431, 392
229, 392, 432, 393
230, 393, 433, 394
231, 394, 434, 395
232, 395, 435, 396
233, 396, 436, 397
234, 397, 437, 398
235, 398, 438, 399
236, 399, 439, 400
237, 400, 440, 401
238, 401, 441, 402
239, 402, 442, 403
240, 403, 443, 6
*ELEMENT, type=T3D3, ELSET=Line8
241, 3, 448, 444
242, 444, 449, 445
243, 445, 450, 446
244, 446, 451, 447
245, 447, 452, 7
*ELEMENT, type=T3D3, ELSET=Line9
246, 5, 457, 453
247, 453, 458, 454
248, 454, 459, 455
249, 455, 460, 456
250, 456, 461, 8
*ELEMENT, type=T3D3, ELSET=Line10
251, 7, 466, 462
252, 462, 467, 463
253, 463, 468, 464
254, 464, 469, 465
255, 465, 470, 8
*ELEMENT, type=T3D3, ELSET=Line11
256, 7, 510, 471
257, 471, 511, 472
258, 472, 512, 473
259, 473, 513, 474
260, 474, 514, 475
261, 475, 515, 476
262, 476, 516, 477
263, 477, 517, 478
264, 478, 518, 479
265, 479, 519, 480
266, 480, 520, 481
267, 481, 521, 482
268, 482, 522, 483
269, 483, 523, 484
270, 484, 524, 485
271, 485, 525, 486
272, 486, 526, 487
273, 487, 527, 488
274, 488, 528, 489
275, 489, 529, 490
276, 490, 530, 491
277, 491, 531, 492
278, 492, 532, 493
279, 493, 533, 494
280, 494, 534, 495
281, 495, 535, 496
282, 496, 536, 497
283, 497, 537, 498
284, 498, 538, 499
285, 499, 539, 500
286, 500, 540, 501
287, 501, 541, 502
288, 502, 542, 503
289, 503, 543, 504
290, 504, 544, 505
291, 505, 545, 506
292, 506, 546, 507
293, 507, 547, 508
294, 508, 548, 509
295, 509, 549, 9
*ELEMENT, type=T3D3, ELSET=Line12
296, 8, 589, 550
297, 550, 590, 551
298, 551, 591, 552
299, 552, 592, 553
300, 553, 593, 554
301, 554, 594, 555
302, 555, 595, 556
303, 556, 596, 557
304, 557, 597, 558
305, 558, 598, 559
306, 559, 599, 560
307, 560, 600, 561
308, 561, 601, 562
309, 562, 602, 563
310, 563, 603, 564
311, 564, 604, 565
312, 565, 605, 566
313, 566, 606, 567
314, 567, 607, 568
315, 568, 608, 569
316, 569, 609, 570
317, 570, 610, 571
318, 571, 611, 572
319, 572, 612, 573
320, 573, 613, 574
321, 574, 614, 575
322, 575, 615, 576
323, 576, 616, 577
324, 577, 617, 578
325, 578, 618, 579
326, 579, 619, 580
327, 580, 620, 581
328, 581, 621, 582
329, 582, 622, 583
330, 583, 623, 584
331, 584, 624, 585
332, 585, 625, 586
333, 586, 626, 587
334, 587, 627, 588
335, 588, 628, 10
*ELEMENT, type=T3D3, ELSET=Line13
336, 9, 633, 629
337, 629, 634, 630
338, 630, 635, 631
339, 631, 636, 632
340, 632, 637, 10
*ELEMENT, type=T3D3, ELSET=Line14
341, 7, 677, 638
342, 638, 678, 639
343, 639, 679, 640
344, 640, 680, 641
345, 641, 681, 642
346, 642, 682, 643
347, 643, 683, 644
348, 644, 684, 645
349, 645, 685, 646
350, 646, 686, 647
351, 647, 687, 648
352, 648, 688, 649
353, 649, 689, 650
354, 650, 690, 651
355, 651, 691, 652
356, 652, 692, 653
357, 653, 693, 654
358, 654, 694, 655
359, 655, 695, 656
360, 656, 696, 657
361, 657, 697, 658
362, 658, 698, 659
363, 659, 699, 660
364, 660, 700, 661
365, 661, 701, 662
366, 662, 702, 663
367, 663, 703, 664
368, 664, 704, 665
369, 665, 705, 666
370, 666, 706, 667
371, 667, 707, 668
372, 668, 708, 669
373, 669, 709, 670
374, 670, 710, 671
375, 671, 711, 672
376, 672, 712, 673
377, 673, 713, 674
378, 674, 714, 675
379, 675, 715, 676
380, 676, 716, 11
*ELEMENT, type=T3D3, ELSET=Line15
381, 9, 756, 717
382, 717, 757, 718
383, 718, 758, 719
384, 719, 759, 720
385, 720, 760, 721
386, 721, 761, 722
387, 722, 762, 723
388, 723, 763, 724
389, 724, 764, 725
390, 725, 765, 726
391, 726, 766, 727
392, 727, 767, 728
393, 728, 768, 729
394, 729, 769, 730
395, 730, 770, 731
396, 731, 771, 732
397, 732, 772, 733
398, 733, 773, 734
399, 734, 774, 735
400, 735, 775, 736
401, 736, 776, 737
402, 737, 777, 738
403, 738, 778, 739
404, 739, 779, 740
405, 740, 780, 741
406, 741, 781, 742
407, 742, 782, 743
408, 743, 783, 744
409, 744, 784, 745
410, 745, 785, 746
411, 746, 786, 747
412, 747, 787, 748
413, 748, 788, 749
414, 749, 789, 750
415, 750, 790, 751
416, 751, 791, 752
417, 752, 792, 753
418, 753, 793, 754
419, 754, 794, 755
420, 755, 795, 12
*ELEMENT, type=T3D3, ELSET=Line16
421, 11, 835, 796
422, 796, 836, 797
423, 797, 837, 798
424, 798, 838, 799
425, 799, 839, 800
426, 800, 840, 801
427, 801, 841, 802
428, 802, 842, 803
429, 803, 843, 804
430, 804, 844, 805
431, 805, 845, 806
432, 806, 846, 807
433, 807, 847, 808
434, 808, 848, 809
435, 809, 849, 810
436, 810, 850, 811
437, 811, 851, 812
438, 812, 852, 813
439, 813, 853, 814
440, 814, 854, 815
441, 815, 855, 816
442, 816, 856, 817
443, 817, 857, 818
444, 818, 858, 819
445, 819, 859, 820
446, 820, 860, 821
447, 821, 861, 822
448, 822, 862, 823
449, 823, 863, 824
450, 824, 864, 825
451, 825, 865, 826
452, 826, 866, 827
453, 827, 867, 828
454, 828, 868, 829
455, 829, 869, 830
456, 830, 870, 831
457, 831, 871, 832
458, 832, 872, 833
459, 833, 873, 834
460, 834, 874, 12
*ELEMENT, type=T3D3, ELSET=Line17
461, 11, 879, 875
462, 875, 880, 876
463, 876, 881, 877
464, 877, 882, 878
465, 878, 883, 13
*ELEMENT, type=T3D3, ELSET=Line18
466, 12, 888, 884
467, 884, 889, 885
468, 885, 890, 886
469, 886, 891, 887
470, 887, 892, 14
*ELEMENT, type=T3D3, ELSET=Line19
471, 13, 932, 893
472, 893, 933, 894
473, 894, 934, 895
474, 895, 935, 896
475, 896, 936, 897
476, 897, 937, 898
477, 898, 938, 899
478, 899, 939, 900
479, 900, 940, 901
480, 901, 941, 902
481, 902, 942, 903
482, 903, 943, 904
483, 904, 944, 905
484, 905, 945, 906
485, 906, 946, 907
486, 907, 947, 908
487, 908, 948, 909
488, 909, 949, 910
489, 910, 950, 911
490, 911, 951, 912
491, 912, 952, 913
492, 913, 953, 914
493, 914, 954, 915
494, 915, 955, 916
495, 916, 956, 917
496, 917, 957, 918
497, 918, 958, 919
498, 919, 959, 920
499, 920, 960, 921
500, 921, 961, 922
501, 922, 962, 923
502, 923, 963, 924
503, 924, 964, 925
504, 925, 965, 926
505, 926, 966, 927
506, 927, 967, 928
507, 928, 968, 929
508, 929, 969, 930
509, 930, 970, 931
510, 931, 971, 14
*ELEMENT, type=T3D3, ELSET=Line20
511, 1, 976, 972
512, 972, 977, 973
513, 973, 978, 974
514, 974, 979, 975
515, 975, 980, 15
*ELEMENT, type=T3D3, ELSET=Line21
516, 2, 985, 981
517, 981, 986, 982
518, 982, 987, 983
519, 983, 988, 984
520, 984, 989, 16
*ELEMENT, type=T3D3, ELSET=Line22
521, 15, 1029, 990
522, 990, 1030, 991
523, 991, 1031, 992
524, 992, 1032, 993
525, 993, 1033, 994
526, 994, 1034, 995
527, 995, 1035, 996
528, 996, 1036, 997
529, 997, 1037, 998
530, 998, 1038, 999
531, 999, 1039, 1000
532, 1000, 1040, 1001
533, 1001, 1041, 1002
534, 1002, 1042, 1003
535, 1003, 1043, 1004
536, 1004, 1044, 1005
537, 1005, 1045, 1006
538, 1006, 1046, 1007
539, 1007, 1047, 1008
540, 1008, 1048, 1009
541, 1009, 1049, 1010
542, 1010, 1050, 1011
543, 1011, 1051, 1012
544, 1012, 1052, 1013
545, 1013, 1053, 1014
546, 1014, 1054, 1015
547, 1015, 1055, 1016
548, 1016, 1056, 1017
549, 1017, 1057, 1018
550, 1018, 1058, 1019
551, 1019, 1059, 1020
552, 1020, 1060, 1021
553, 1021, 1061, 1022
554, 1022, 1062, 1023
555, 1023, 1063, 1024
556, 1024, 1064, 1025
557, 1025, 1065, 1026
558, 1026, 1066, 1027
559, 1027, 1067, 1028
560, 1028, 1068, 16
*ELEMENT, type=T3D3, ELSET=Line23
561, 12, 1070, 1069
562, 1069, 1071, 17
*ELEMENT, type=T3D3, ELSET=Line24
563, 14, 1073, 1072
564, 1072, 1074, 18
*ELEMENT, type=T3D3, ELSET=Line25
565, 17, 1079, 1075
566, 1075, 1080, 1076
567, 1076, 1081, 1077
568, 1077, 1082, 1078
569, 1078, 1083, 18
*ELEMENT, type=T3D3, ELSET=Line26
570, 1, 1085, 1084
571, 1084, 1086, 19
*ELEMENT, type=T3D3, ELSET=Line27
572, 15, 1088, 1087
573, 1087, 1089, 20
*ELEMENT, type=T3D3, ELSET=Line28
574, 19, 1094, 1090
575, 1090, 1095, 1091
576, 1091, 1096, 1092
577, 1092, 1097, 1093
578, 1093, 1098, 20
*ELEMENT, type=T3D3, ELSET=Line29
579, 15, 1103, 1099
580, 1099, 1104, 1100
581, 1100, 1105, 1101
582, 1101, 1106, 1102
583, 1102, 1107, 21
*ELEMENT, type=T3D3, ELSET=Line30
584, 16, 1112, 1108
585, 1108, 1113, 1109
586, 1109, 1114, 1110
587, 1110, 1115, 1111
588, 1111, 1116, 22
*ELEMENT, type=T3D3, ELSET=Line31
589, 21, 1156, 1117
590, 1117, 1157, 1118
591, 1118, 1158, 1119
592, 1119, 1159, 1120
593, 1120, 1160, 1121
594, 1121, 1161, 1122
595, 1122, 1162, 1123
596, 1123, 1163, 1124
597, 1124, 1164, 1125
598, 1125, 1165, 1126
599, 1126, 1166, 1127
600, 1127, 1167, 1128
601, 1128, 1168, 1129
602, 1129, 1169, 1130
603, 1130, 1170, 1131
604, 1131, 1171, 1132
605, 1132, 1172, 1133
606, 1133, 1173, 1134
607, 1134, 1174, 1135
608, 1135, 1175, 1136
609, 1136, 1176, 1137
610, 1137, 1177, 1138
611, 1138, 1178, 1139
612, 1139, 1179, 1140
613, 1140, 1180, 1141
614, 1141, 1181, 1142
615, 1142, 1182, 1143
616, 1143, 1183, 1144
617, 1144, 1184, 1145
618, 1145, 1185, 1146
619, 1146, 1186, 1147
620, 1147, 1187, 1148
621, 1148, 1188, 1149
622, 1149, 1189, 1150
623, 1150, 1190, 1151
624, 1151, 1191, 1152
625, 1152, 1192, 1153
626, 1153, 1193, 1154
627, 1154, 1194, 1155
628, 1155, 1195, 22
*ELEMENT, type=T3D3, ELSET=Line32
629, 20, 1200, 1196
630, 1196, 1201, 1197
631, 1197, 1202, 1198
632, 1198, 1203, 1199
633, 1199, 1204, 23
*ELEMENT, type=T3D3, ELSET=Line33
634, 21, 1206, 1205
635, 1205, 1207, 23
*ELEMENT, type=T3D3, ELSET=Line34
636, 13, 1212, 1208
637, 1208, 1213, 1209
638, 1209, 1214, 1210
639, 1210, 1215, 1211
640, 1211, 1216, 24
*ELEMENT, type=T3D3, ELSET=Line35
641, 14, 1221, 1217
642, 1217, 1222, 1218
643, 1218, 1223, 1219
644, 1219, 1224, 1220
645, 1220, 1225, 25
*ELEMENT, type=T3D3, ELSET=Line36
646, 24, 1265, 1226
647, 1226, 1266, 1227
648, 1227, 1267, 1228
649, 1228, 1268, 1229
650, 1229, 1269, 1230
651, 1230, 1270, 1231
652, 1231, 1271, 1232
653, 1232, 1272, 1233
654, 1233, 1273, 1234
655, 1234, 1274, 1235
656, 1235, 1275, 1236
657, 1236, 1276, 1237
658, 1237, 1277, 1238
659, 1238, 1278, 1239
660, 1239, 1279, 1240
661, 1240, 1280, 1241
662, 1241, 1281, 1242
663, 1242, 1282, 1243
664, 1243, 1283, 1244
665, 1244, 1284, 1245
666, 1245, 1285, 1246
667, 1246, 1286, 1247
668, 1247, 1287, 1248
669, 1248, 1288, 1249
670, 1249, 1289, 1250
671, 1250, 1290, 1251
672, 1251, 1291, 1252
673, 1252, 1292, 1253
674, 1253, 1293, 1254
675, 1254, 1294, 1255
676, 1255, 1295, 1256
677, 1256, 1296, 1257
678, 1257, 1297, 1258
679, 1258, 1298, 1259
680, 1259, 1299, 1260
681, 1260, 1300, 1261
682, 1261, 1301, 1262
683, 1262, 1302, 1263
684, 1263, 1303, 1264
685, 1264, 1304, 25
*ELEMENT, type=T3D3, ELSET=Line37
686, 18, 1309, 1305
687, 1305, 1310, 1306
688, 1306, 1311, 1307
689, 1307, 1312, 1308
690, 1308, 1313, 26
*ELEMENT, type=T3D3, ELSET=Line38
691, 25, 1315, 1314
692, 1314, 1316, 26
*ELEMENT, type=T3D3, ELSET=Line39
693, 5, 1321, 1317
694, 1317, 1322, 1318
695, 1318, 1323, 1319
696, 1319, 1324, 1320
697, 1320, 1325, 27
*ELEMENT, type=T3D3, ELSET=Line40
698, 6, 1330, 1326
699, 1326, 1331, 1327
700, 1327, 1332, 1328
701, 1328, 1333, 1329
702, 1329, 1334, 28
*ELEMENT, type=T3D3, ELSET=Line41
703, 27, 1374, 1335
704, 1335, 1375, 1336
705, 1336, 1376, 1337
706, 1337, 1377, 1338
707, 1338, 1378, 1339
708, 1339, 1379, 1340
709, 1340, 1380, 1341
710, 1341, 1381, 1342
711, 1342, 1382, 1343
712, 1343, 1383, 1344
713, 1344, 1384, 1345
714, 1345, 1385, 1346
715, 1346, 1386, 1347
716, 1347, 1387, 1348
717, 1348, 1388, 1349
718, 1349, 1389, 1350
719, 1350, 1390, 1351
720, 1351, 1391, 1352
721, 1352, 1392, 1353
722, 1353, 1393, 1354
723, 1354, 1394, 1355
724, 1355, 1395, 1356
725, 1356, 1396, 1357
726, 1357, 1397, 1358
727, 1358, 1398, 1359
728, 1359, 1399, 1360
729, 1360, 1400, 1361
730, 1361, 1401, 1362
731, 1362, 1402, 1363
732, 1363, 1403, 1364
733, 1364, 1404, 1365
734, 1365, 1405, 1366
735, 1366, 1406, 1367
736, 1367, 1407, 1368
737, 1368, 1408, 1369
738, 1369, 1409, 1370
739, 1370, 1410, 1371
740, 1371, 1411, 1372
741, 1372, 1412, 1373
742, 1373, 1413, 28
*ELEMENT, type=T3D3, ELSET=Line42
743, 8, 1418, 1414
744, 1414, 1419, 1415
745, 1415, 1420, 1416
746, 1416, 1421, 1417
747, 1417, 1422, 29
*ELEMENT, type=T3D3, ELSET=Line43
748, 27, 1427, 1423
749, 1423, 1428, 1424
750, 1424, 1429, 1425
751, 1425, 1430, 1426
752, 1426, 1431, 29
*ELEMENT, type=T3D3, ELSET=Line44
753, 10, 1436, 1432
754, 1432, 1437, 1433
755, 1433, 1438, 1434
756, 1434, 1439, 1435
757, 1435, 1440, 30
*ELEMENT, type=T3D3, ELSET=Line45
758, 29, 1480, 1441
759, 1441, 1481, 1442
760, 1442, 1482, 1443
761, 1443, 1483, 1444
762, 1444, 1484, 1445
763, 1445, 1485, 1446
764, 1446, 1486, 1447
765, 1447, 1487, 1448
766, 1448, 1488, 1449
767, 1449, 1489, 1450
768, 1450, 1490, 1451
769, 1451, 1491, 1452
770, 1452, 1492, 1453
771, 1453, 1493, 1454
772, 1454, 1494, 1455
773, 1455, 1495, 1456
774, 1456, 1496, 1457
775, 1457, 1497, 1458
776, 1458, 1498, 1459
777, 1459, 1499, 1460
778, 1460, 1500, 1461
779, 1461, 1501, 1462
780, 1462, 1502, 1463
781, 1463, 1503, 1464
782, 1464, 1504, 1465
783, 1465, 1505, 1466
784, 1466, 1506, 1467
785, 1467, 1507, 1468
786, 1468, 1508, 1469
787, 1469, 1509, 1470
788, 1470, 1510, 1471
789, 1471, 1511, 1472
790, 1472, 1512, 1473
791, 1473, 1513, 1474
792, 1474, 1514, 1475
793, 1475, 1515, 1476
794, 1476, 1516, 1477
795, 1477, 1517, 1478
796, 1478, 1518, 1479
797, 1479, 1519, 30
*ELEMENT, type=CPS8, ELSET=Surface1
798, 1, 31, 1520, 306, 70, 3041, 3042, 346
799, 306, 1520, 1521, 305, 3042, 3043, 3044, 345
800, 305, 1521, 1522, 304, 3044, 3045, 3046, 344
801, 304, 1522, 1523, 303, 3046, 3047, 3048, 343
802, 303, 1523, 1524, 302, 3048, 3049, 3050, 342
803, 302, 1524, 1525, 301, 3050, 3051, 3052, 341
804, 301, 1525, 1526, 300, 3052, 3053, 3054, 340
805, 300, 1526, 1527, 299, 3054, 3055, 3056, 339
806, 299, 1527, 1528, 298, 3056, 3057, 3058, 338
807, 298, 1528, 1529, 297, 3058, 3059, 3060, 337
808, 297, 1529, 1530, 296, 3060, 3061, 3062, 336
809, 296, 1530, 1531, 295, 3062, 3063, 3064, 335
810, 295, 1531, 1532, 294, 3064, 3065, 3066, 334
811, 294, 1532, 1533, 293, 3066, 3067, 3068, 333
812, 293, 1533, 1534, 292, 3068, 3069, 3070, 332
813, 292, 1534, 1535, 291, 3070, 3071, 3072, 331
814, 291, 1535, 1536, 290, 3072, 3073, 3074, 330
815, 290, 1536, 1537, 289, 3074, 3075, 3076, 329
816, 289, 1537, 1538, 288, 3076, 3077, 3078, 328
817, 288, 1538, 1539, 287, 3078, 3079, 3080, 327
818, 287, 1539, 1540, 286, 3080, 3081, 3082, 326
819, 286, 1540, 1541, 285, 3082, 3083, 3084, 325
820, 285, 1541, 1542, 284, 3084, 3085, 3086, 324
821, 284, 1542, 1543, 283, 3086, 3087, 3088, 323
822, 283, 1543, 1544, 282, 3088, 3089, 3090, 322
823, 282, 1544, 1545, 281, 3090, 3091, 3092, 321
824, 281, 1545, 1546, 280, 3092, 3093, 3094, 320
825, 280, 1546, 1547, 279, 3094, 3095, 3096, 319
826, 279, 1547, 1548, 278, 3096, 3097, 3098, 318
827, 278, 1548, 1549, 277, 3098, 3099, 3100, 317
828, 277, 1549, 1550, 276, 3100, 3101, 3102, 316
829, 276, 1550, 1551, 275, 3102, 3103, 3104, 315
830, 275, 1551, 1552, 274, 3104, 3105, 3106, 314
831, 274, 1552, 1553, 273, 3106, 3107, 3108, 313
832, 273, 1553, 1554, 272, 3108, 3109, 3110, 312
833, 272, 1554, 1555, 271, 3110, 3111, 3112, 311
834, 271, 1555, 1556, 270, 3112, 3113, 3114, 310
835, 270, 1556, 1557, 269, 3114, 3115, 3116, 309
836, 269, 1557, 1558, 268, 3116, 3117, 3118, 308
837, 268, 1558, 227, 4, 3118, 3119, 267, 307
838, 31, 32, 1559, 1520, 71, 3120, 3121, 3041
839, 1520, 1559, 1560, 1521, 3121, 3122, 3123, 3043
840, 1521, 1560, 1561, 1522, 3123, 3124, 3125, 3045
841, 1522, 1561, 1562, 1523, 3125, 3126, 3127, 3047
842, 1523, 1562, 1563, 1524, 3127, 3128, 3129, 3049
843, 1524, 1563, 1564, 1525, 3129, 3130, 3131, 3051
844, 1525, 1564, 1565, 1526, 3131, 3132, 3133, 3053
845, 1526, 1565, 1566, 1527, 3133, 3134, 3135, 3055
846, 1527, 1566, 1567, 1528, 3135, 3136, 3137, 3057
847, 1528, 1567, 1568, 1529, 3137, 3138, 3139, 3059
848, 1529, 1568, 1569, 1530, 3139, 3140, 3141, 3061
849, 1530, 1569, 1570, 1531, 3141, 3142, 3143, 3063
850, 1531, 1570, 1571, 1532, 3143, 3144, 3145, 3065
851, 1532, 1571, 1572, 1533, 3145, 3146, 3147, 3067
852, 1533, 1572, 1573, 1534, 3147, 3148, 3149, 3069
853, 1534, 1573, 1574, 1535, 3149, 3150, 3151, 3071
854, 1535, 1574, 1575, 1536, 3151, 3152, 3153, 3073
855, 1536, 1575, 1576, 1537, 3153, 3154, 3155, 3075
856, 1537, 1576, 1577, 1538, 3155, 3156, 3157, 3077
857, 1538, 1577, 1578, 1539, 3157, 3158, 3159, 3079
858, 1539, 1578, 1579, 1540, 3159, 3160, 3161, 3081
859, 1540, 1579, 1580, 1541, 3161, 3162, 3163, 3083
860, 1541, 1580, 1581, 1542, 3163, 3164, 3165, 3085
861, 1542, 1581, 1582, 1543, 3165, 3166, 3167, 3087
862, 1543, 1582, 1583, 1544, 3167, 3168, 3169, 3089
863, 1544, 1583, 1584, 1545, 3169, 3170, 3171, 3091
864, 1545, 1584, 1585, 1546, 3171, 3172, 3173, 3093
865, 1546, 1585, 1586, 1547, 3173, 3174, 3175, 3095
866, 1547, 1586, 1587, 1548, 3175, 3176, 3177, 3097
867, 1548, 1587, 1588, 1549, 3177, 3178, 3179, 3099
868, 1549, 1588, 1589, 1550, 3179, 3180, 3181, 3101
869, 1550, 1589, 1590, 1551, 3181, 3182, 3183, 3103
870, 1551, 1590, 1591, 1552, 3183, 3184, 3185, 3105
871, 1552, 1591, 1592, 1553, 3185, 3186, 3187, 3107
872, 1553, 1592, 1593, 1554, 3187, 3188, 3189, 3109
873, 1554, 1593, 1594, 1555, 3189, 3190, 3191, 3111
874, 1555, 1594, 1595, 1556, 3191, 3192, 3193, 3113
875, 1556, 1595, 1596, 1557, 3193, 3194, 3195, 3115
876, 1557, 1596, 1597, 1558, 3195, 3196, 3197, 3117
877, 1558, 1597, 226, 227, 3197, 3198, 266, 3119
878, 32, 33, 1598, 1559, 72, 3199, 3200, 3120
879, 1559, 1598, 1599, 1560, 3200, 3201, 3202, 3122
880, 1560, 1599, 1600, 1561, 3202, 3203, 3204, 3124
881, 1561, 1600, 1601, 1562, 3204, 3205, 3206, 3126
882, 1562, 1601, 1602, 1563, 3206, 3207, 3208, 3128
883, 1563, 1602, 1603, 1564, 3208, 3209, 3210, 3130
884, 1564, 1603, 1604, 1565, 3210, 3211, 3212, 3132
885, 1565, 1604, 1605, 1566, 3212, 3213, 3214, 3134
886, 1566, 1605, 1606, 1567, 3214, 3215, 3216, 3136
887, 1567, 1606, 1607, 1568, 3216, 3217, 3218, 3138
888, 1568, 1607, 1608, 1569, 3218, 3219, 3220, 3140
889, 1569, 1608, 1609, 1570, 3220, 3221, 3222, 3142
890, 1570, 1609, 1610, 1571, 3222, 3223, 3224, 3144
891, 1571, 1610, 1611, 1572, 3224, 3225, 3226, 3146
892, 1572, 1611, 1612, 1573, 3226, 3227, 3228, 3148
893, 1573, 1612, 1613, 1574, 3228, 3229, 3230, 3150
894, 1574, 1613, 1614, 1575, 3230, 3231, 3232, 3152
895, 1575, 1614, 1615, 1576, 3232, 3233, 3234, 3154
896, 1576, 1615, 1616, 1577, 3234, 3235, 3236, 3156
897, 1577, 1616, 1617, 1578, 3236, 3237, 3238, 3158
898, 1578, 1617, 1618, 1579, 3238, 3239, 3240, 3160
899, 1579, 1618, 1619, 1580, 3240, 3241, 3242, 3162
900, 1580, 1619, 1620, 1581, 3242, 3243, 3244, 3164
901, 1581, 1620, 1621, 1582, 3244, 3245, 3246, 3166
902, 1582, 1621, 1622, 1583, 3246, 3247, 3248, 3168
903, 1583, 1622, 1623, 1584, 3248, 3249, 3250, 3170
904, 1584, 1623, 1624, 1585, 3250, 3251, 3252, 3172
905, 1585, 1624, 1625, 1586, 3252, 3253, 3254, 3174
906, 1586, 1625, 1626, 1587, 3254, 3255, 3256, 3176
907, 1587, 1626, 1627, 1588, 3256, 3257, 3258, 3178
908, 1588, 1627, 1628, 1589, 3258, 3259, 3260, 3180
909, 1589, 1628, 1629, 1590, 3260, 3261, 3262, 3182
910, 1590, 1629, 1630, 1591, 3262, 3263, 3264, 3184
911, 1591, 1630, 1631, 1592, 3264, 3265, 3266, 3186
912, 1592, 1631, 1632, 1593, 3266, 3267, 3268, 3188
913, 1593, 1632, 1633, 1594, 3268, 3269, 3270, 3190
914, 1594, 1633, 1634, 1595, 3270, 3271, 3272, 3192
915, 1595, 1634, 1635, 1596, 3272, 3273, 3274, 3194
916, 1596, 1635, 1636, 1597, 3274, 3275, 3276, 3196
917, 1597, 1636, 225, 226, 3276, 3277, 265, 3198
918, 33, 34, 1637, 1598, 73, 3278, 3279, 3199
919, 1598, 1637, 1638, 1599, 3279, 3280, 3281, 3201
920, 1599, 1638, 1639, 1600, 3281, 3282, 3283, 3203
921, 1600, 1639, 1640, 1601, 3283, 3284, 3285, 3205
922, 1601, 1640, 1641, 1602, 3285, 3286, 3287, 3207
923, 1602, 1641, 1642, 1603, 3287, 3288, 3289, 3209
924, 1603, 1642, 1643, 1604, 3289, 3290, 3291, 3211
925, 1604, 1643, 1644, 1605, 3291, 3292, 3293, 3213
926, 1605, 1644, 1645, 1606, 3293, 3294, 3295, 3215
927, 1606, 1645, 1646, 1607, 3295, 3296, 3297, 3217
928, 1607, 1646, 1647, 1608, 3297, 3298, 3299, 3219
929, 1608, 1647, 1648, 1609, 3299, 3300, 3301, 3221
930, 1609, 1648, 1649, 1610, 3301, 3302, 3303, 3223
931, 1610, 1649, 1650, 1611, 3303, 3304, 3305, 3225
932, 1611, 1650, 1651, 1612, 3305, 3306, 3307, 3227
933, 1612, 1651, 1652, 1613, 3307, 3308, 3309, 3229
934, 1613, 1652, 1653, 1614, 3309, 3310, 3311, 3231
935, 1614, 1653, 1654, 1615, 3311, 3312, 3313, 3233
936, 1615, 1654, 1655, 1616, 3313, 3314, 3315, 3235
937, 1616, 1655, 1656, 1617, 3315, 3316, 3317, 3237
938, 1617, 1656, 1657, 1618, 3317, 3318, 3319, 3239
939, 1618, 1657, 1658, 1619, 3319, 3320, 3321, 3241
940, 1619, 1658, 1659, 1620, 3321, 3322, 3323, 3243
941, 1620, 1659, 1660, 1621, 3323, 3324, 3325, 3245
942, 1621, 1660, 1661, 1622, 3325, 3326, 3327, 3247
943, 1622, 1661, 1662, 1623, 3327, 3328, 3329, 3249
944, 1623, 1662, 1663, 1624, 3329, 3330, 3331, 3251
945, 1624, 1663, 1664, 1625, 3331, 3332, 3333, 3253
946, 1625, 1664, 1665, 1626, 3333, 3334, 3335, 3255
947, 1626, 1665, 1666, 1627, 3335, 3336, 3337, 3257
948, 1627, 1666, 1667, 1628, 3337, 3338, 3339, 3259
949, 1628, 1667, 1668, 1629, 3339, 3340, 3341, 3261
950, 1629, 1668, 1669, 1630, 3341, 3342, 3343, 3263
951, 1630, 1669, 1670, 1631, 3343, 3344, 3345, 3265
952, 1631, 1670, 1671, 1632, 3345, 3346, 3347, 3267
953, 1632, 1671, 1672, 1633, 3347, 3348, 3349, 3269
954, 1633, 1672, 1673, 1634, 3349, 3350, 3351, 3271
955, 1634, 1673, 1674, 1635, 3351, 3352, 3353, 3273
956, 1635, 1674, 1675, 1636, 3353, 3354, 3355, 3275
957, 1636, 1675, 224, 225, 3355, 3356, 264, 3277
958, 34, 35, 1676, 1637, 74, 3357, 3358, 3278
959, 1637, 1676, 1677, 1638, 3358, 3359, 3360, 3280
960, 1638, 1677, 1678, 1639, 3360, 3361, 3362, 3282
961, 1639, 1678, 1679, 1640, 3362, 3363, 3364, 3284
962, 1640, 1679, 1680, 1641, 3364, 3365, 3366, 3286
963, 1641, 1680, 1681, 1642, 3366, 3367, 3368, 3288
964, 1642, 1681, 1682, 1643, 3368, 3369, 3370, 3290
965, 1643, 1682, 1683, 1644, 3370, 3371, 3372, 3292
966, 1644, 1683, 1684, 1645, 3372, 3373, 3374, 3294
967, 1645, 1684, 1685, 1646, 3374, 3375, 3376, 3296
968, 1646, 1685, 1686, 1647, 3376, 3377, 3378, 3298
969, 1647, 1686, 1687, 1648, 3378, 3379, 3380, 3300
970, 1648, 1687, 1688, 1649, 3380, 3381, 3382, 3302
971, 1649, 1688, 1689, 1650, 3382, 3383, 3384, 3304
972, 1650, 1689, 1690, 1651, 3384, 3385, 3386, 3306
973, 1651, 1690, 1691, 1652, 3386, 3387, 3388, 3308
974, 1652, 1691, 1692, 1653, 3388, 3389, 3390, 3310
975, 1653, 1692, 1693, 1654, 3390, 3391, 3392, 3312
976, 1654, 1693, 1694, 1655, 3392, 3393, 3394, 3314
977, 1655, 1694, 1695, 1656, 3394, 3395, 3396, 3316
978, 1656, 1695, 1696, 1657, 3396, 3397, 3398, 3318
979, 1657, 1696, 1697, 1658, 3398, 3399, 3400, 3320
980, 1658, 1697, 1698, 1659, 3400, 3401, 3402, 3322
981, 1659, 1698, 1699, 1660, 3402, 3403, 3404, 3324
982, 1660, 1699, 1700, 1661, 3404, 3405, 3406, 3326
983, 1661, 1700, 1701, 1662, 3406, 3407, 3408, 3328
984, 1662, 1701, 1702, 1663, 3408, 3409, 3410, 3330
985, 1663, 1702, 1703, 1664, 3410, 3411, 3412, 3332
986, 1664, 1703, 1704, 1665, 3412, 3413, 3414, 3334
987, 1665, 1704, 1705, 1666, 3414, 3415, 3416, 3336
988, 1666, 1705, 1706, 1667, 3416, 3417, 3418, 3338
989, 1667, 1706, 1707, 1668, 3418, 3419, 3420, 3340
990, 1668, 1707, 1708, 1669, 3420, 3421, 3422, 3342
991, 1669, 1708, 1709, 1670, 3422, 3423, 3424, 3344
992, 1670, 1709, 1710, 1671, 3424, 3425, 3426, 3346
993, 1671, 1710, 1711, 1672, 3426, 3427, 3428, 3348
994, 1672, 1711, 1712, 1673, 3428, 3429, 3430, 3350
995, 1673, 1712, 1713, 1674, 3430, 3431, 3432, 3352
996, 1674, 1713, 1714, 1675, 3432, 3433, 3434, 3354
997, 1675, 1714, 223, 224, 3434, 3435, 263, 3356
998, 35, 36, 1715, 1676, 75, 3436, 3437, 3357
999, 1676, 1715, 1716, 1677, 3437, 3438, 3439, 3359
1000, 1677, 1716, 1717, 1678, 3439, 3440, 3441, 3361
1001, 1678, 1717, 1718, 1679, 3441, 3442, 3443, 3363
1002, 1679, 1718, 1719, 1680, 3443, 3444, 3445, 3365
1003, 1680, 1719, 1720, 1681, 3445, 3446, 3447, 3367
1004, 1681, 1720, 1721, 1682, 3447, 3448, 3449, 3369
1005, 1682, 1721, 1722, 1683, 3449, 3450, 3451, 3371
1006, 1683, 1722, 1723, 1684, 3451, 3452, 3453, 3373
1007, 1684, 1723, 1724, 1685, 3453, 3454, 3455, 3375
1008, 1685, 1724, 1725, 1686, 3455, 3456, 3457, 3377
1009, 1686, 1725, 1726, 1687, 3457, 3458, 3459, 3379
1010, 1687, 1726, 1727, 1688, 3459, 3460, 3461, 3381
1011, 1688, 1727, 1728, 1689, 3461, 3462, 3463, 3383
1012, 1689, 1728, 1729, 1690, 3463, 3464, 3465, 3385
1013, 1690, 1729, 1730, 1691, 3465, 3466, 3467, 3387
1014, 1691, 1730, 1731, 1692, 3467, 3468, 3469, 3389
1015, 1692, 1731, 1732, 1693, 3469, 3470, 3471, 3391
1016, 1693, 1732, 1733, 1694, 3471, 3472, 3473, 3393
1017, 1694, 1733, 1734, 1695, 3473, 3474, 3475, 3395
1018, 1695, 1734, 1735, 1696, 3475, 3476, 3477, 3397
1019, 1696, 1735, 1736, 1697, 3477, 3478, 3479, 3399
1020, 1697, 1736, 1737, 1698, 3479, 3480, 3481, 3401
1021, 1698, 1737, 1738, 1699, 3481, 3482, 3483, 3403
1022, 1699, 1738, 1739, 1700, 3483, 3484, 3485, 3405
1023, 1700, 1739, 1740, 1701, 3485, 3486, 3487, 3407
1024, 1701, 1740, 1741, 1702, 3487, 3488, 3489, 3409
1025, 1702, 1741, 1742, 1703, 3489, 3490, 3491, 3411
1026, 1703, 1742, 1743, 1704, 3491, 3492, 3493, 3413
1027, 1704, 1743, 1744, 1705, 3493, 3494, 3495, 3415
1028, 1705, 1744, 1745, 1706, 3495, 3496, 3497, 3417
1029, 1706, 1745, 1746, 1707, 3497, 3498, 3499, 3419
1030, 1707, 1746, 1747, 1708, 3499, 3500, 3501, 3421
1031, 1708, 1747, 1748, 1709, 3501, 3502, 3503, 3423
1032, 1709, 1748, 1749, 1710, 3503, 3504, 3505, 3425
1033, 1710, 1749, 1750, 1711, 3505, 3506, 3507, 3427
1034, 1711, 1750, 1751, 1712, 3507, 3508, 3509, 3429
1035, 1712, 1751, 1752, 1713, 3509, 3510, 3511, 3431
1036, 1713, 1752, 1753, 1714, 3511, 3512, 3513, 3433
1037, 1714, 1753, 222, 223, 3513, 3514, 262, 3435
1038, 36, 37, 1754, 1715, 76, 3515, 3516, 3436
1039, 1715, 1754, 1755, 1716, 3516, 3517, 3518, 3438
1040, 1716, 1755, 1756, 1717, 3518, 3519, 3520, 3440
1041, 1717, 1756, 1757, 1718, 3520, 3521, 3522, 3442
1042, 1718, 1757, 1758, 1719, 3522, 3523, 3524, 3444
1043, 1719, 1758, 1759, 1720, 3524, 3525, 3526, 3446
1044, 1720, 1759, 1760, 1721, 3526, 3527, 3528, 3448
1045, 1721, 1760, 1761, 1722, 3528, 3529, 3530, 3450
1046, 1722, 1761, 1762, 1723, 3530, 3531, 3532, 3452
1047, 1723, 1762, 1763, 1724, 3532, 3533, 3534, 3454
1048, 1724, 1763, 1764, 1725, 3534, 3535, 3536, 3456
1049, 1725, 1764, 1765, 1726, 3536, 3537, 3538, 3458
1050, 1726, 1765, 1766, 1727, 3538, 3539, 3540, 3460
1051, 1727, 1766, 1767, 1728, 3540, 3541, 3542, 3462
1052, 1728, 1767, 1768, 1729, 3542, 3543, 3544, 3464
1053, 1729, 1768, 1769, 1730, 3544, 3545, 3546, 3466
1054, 1730, 1769, 1770, 1731, 3546, 3547, 3548, 3468
1055, 1731, 1770, 1771, 1732, 3548, 3549, 3550, 3470
1056, 1732, 1771, 1772, 1733, 3550, 3551, 3552, 3472
1057, 1733, 1772, 1773, 1734, 3552, 3553, 3554, 3474
1058, 1734, 1773, 1774, 1735, 3554, 3555, 3556, 3476
1059, 1735, 1774, 1775, 1736, 3556, 3557, 3558, 3478
1060, 1736, 1775, 1776, 1737, 3558, 3559, 3560, 3480
1061, 1737, 1776, 1777, 1738, 3560, 3561, 3562, 3482
1062, 1738, 1777, 1778, 1739, 3562, 3563, 3564, 3484
1063, 1739, 1778, 1779, 1740, 3564, 3565, 3566, 3486
1064, 1740, 1779, 1780, 1741, 3566, 3567, 3568, 3488
1065, 1741, 1780, 1781, 1742, 3568, 3569, 3570, 3490
1066, 1742, 1781, 1782, 1743, 3570, 3571, 3572, 3492
1067, 1743, 1782, 1783, 1744, 3572, 3573, 3574, 3494
1068, 1744, 1783, 1784, 1745, 3574, 3575, 3576, 3496
1069, 1745, 1784, 1785, 1746, 3576, 3577, 3578, 3498
1070, 1746, 1785, 1786, 1747, 3578, 3579, 3580, 3500
1071, 1747, 1786, 1787, 1748, 3580, 3581, 3582, 3502
1072, 1748, 1787, 1788, 1749, 3582, 3583, 3584, 3504
1073, 1749, 1788, 1789, 1750, 3584, 3585, 3586, 3506
1074, 1750, 1789, 1790, 1751, 3586, 3587, 3588, 3508
1075, 1751, 1790, 1791, 1752, 3588, 3589, 3590, 3510
1076, 1752, 1791, 1792, 1753, 3590, 3591, 3592, 3512
1077, 1753, 1792, 221, 222, 3592, 3593, 261, 3514
1078, 37, 38, 1793, 1754, 77, 3594, 3595, 3515
1079, 1754, 1793, 1794, 1755, 3595, 3596, 3597, 3517
1080, 1755, 1794, 1795, 1756, 3597, 3598, 3599, 3519
1081, 1756, 1795, 1796, 1757, 3599, 3600, 3601, 3521
1082, 1757, 1796, 1797, 1758, 3601, 3602, 3603, 3523
1083, 1758, 1797, 1798, 1759, 3603, 3604, 3605, 3525
1084, 1759, 1798, 1799, 1760, 3605, 3606, 3607, 3527
1085, 1760, 1799, 1800, 1761, 3607, 3608, 3609, 3529
1086, 1761, 1800, 1801, 1762, 3609, 3610, 3611, 3531
1087, 1762, 1801, 1802, 1763, 3611, 3612, 3613, 3533
1088, 1763, 1802, 1803, 1764, 3613, 3614, 3615, 3535
1089, 1764, 1803, 1804, 1765, 3615, 3616, 3617, 3537
1090, 1765, 1804, 1805, 1766, 3617, 3618, 3619, 3539
1091, 1766, 1805, 1806, 1767, 3619, 3620, 3621, 3541
1092, 1767, 1806, 1807, 1768, 3621, 3622, 3623, 3543
1093, 1768, 1807, 1808, 1769, 3623, 3624, 3625, 3545
1094, 1769, 1808, 1809, 1770, 3625, 3626, 3627, 3547
1095, 1770, 1809, 1810, 1771, 3627, 3628, 3629, 3549
1096, 1771, 1810, 1811, 1772, 3629, 3630, 3631, 3551
1097, 1772, 1811, 1812, 1773, 3631, 3632, 3633, 3553
1098, 1773, 1812, 1813, 1774, 3633, 3634, 3635, 3555
1099, 1774, 1813, 1814, 1775, 3635, 3636, 3637, 3557
1100, 1775, 1814, 1815, 1776, 3637, 3638, 3639, 3559
1101, 1776, 1815, 1816, 1777, 3639, 3640, 3641, 3561
1102, 1777, 1816, 1817, 1778, 3641, 3642, 3643, 3563
1103, 1778, 1817, 1818, 1779, 3643, 3644, 3645, 3565
1104, 1779, 1818, 1819, 1780, 3645, 3646, 3647, 3567
1105, 1780, 1819, 1820, 1781, 3647, 3648, 3649, 3569
1106, 1781, 1820, 1821, 1782, 3649, 3650, 3651, 3571
1107, 1782, 1821, 1822, 1783, 3651, 3652, 3653, 3573
1108, 1783, 1822, 1823, 1784, 3653, 3654, 3655, 3575
1109, 1784, 1823, 1824, 1785, 3655, 3656, 3657, 3577
1110, 1785, 1824, 1825, 1786, 3657, 3658, 3659, 3579
1111, 1786, 1825, 1826, 1787, 3659, 3660, 3661, 3581
1112, 1787, 1826, 1827, 1788, 3661, 3662, 3663, 3583
1113, 1788, 1827, 1828, 1789, 3663, 3664, 3665, 3585
1114, 1789, 1828, 1829, 1790, 3665, 3666, 3667, 3587
1115, 1790, 1829, 1830, 1791, 3667, 3668, 3669, 3589
1116, 1791, 1830, 1831, 1792, 3669, 3670, 3671, 3591
1117, 1792, 1831, 220, 221, 3671, 3672, 260, 3593
1118, 38, 39, 1832, 1793, 78, 3673, 3674, 3594
1119, 1793, 1832, 1833, 1794, 3674, 3675, 3676, 3596
1120, 1794, 1833, 1834, 1795, 3676, 3677, 3678, 3598
1121, 1795, 1834, 1835, 1796, 3678, 3679, 3680, 3600
1122, 1796, 1835, 1836, 1797, 3680, 3681, 3682, 3602
1123, 1797, 1836, 1837, 1798, 3682, 3683, 3684, 3604
1124, 1798, 1837, 1838, 1799, 3684, 3685, 3686, 3606
1125, 1799, 1838, 1839, 1800, 3686, 3687, 3688, 3608
1126, 1800, 1839, 1840, 1801, 3688, 3689, 3690, 3610
1127, 1801, 1840, 1841, 1802, 3690, 3691, 3692, 3612
1128, 1802, 1841, 1842, 1803, 3692, 3693, 3694, 3614
1129, 1803, 1842, 1843, 1804, 3694, 3695, 3696, 3616
1130, 1804, 1843, 1844, 1805, 3696, 3697, 3698, 3618
1131, 1805, 1844, 1845, 1806, 3698, 3699, 3700, 3620
1132, 1806, 1845, 1846, 1807, 3700, 3701, 3702, 3622
1133, 1807, 1846, 1847, 1808, 3702, 3703, 3704, 3624
1134, 1808, 1847, 1848, 1809, 3704, 3705, 3706, 3626
1135, 1809, 1848, 1849, 1810, 3706, 3707, 3708, 3628
1136, 1810, 1849, 1850, 1811, 3708, 3709, 3710, 3630
1137, 1811, 1850, 1851, 1812, 3710, 3711, 3712, 3632
1138, 1812, 1851, 1852, 1813, 3712, 3713, 3714, 3634
1139, 1813, 1852, 1853, 1814, 3714, 3715, 3716, 3636
1140, 1814, 1853, 1854, 1815, 3716, 3717, 3718, 3638
1141, 1815, 1854, 1855, 1816, 3718, 3719, 3720, 3640
1142, 1816, 1855, 1856, 1817, 3720, 3721, 3722, 3642
1143, 1817, 1856, 1857, 1818, 3722, 3723, 3724, 3644
1144, 1818, 1857, 1858, 1819, 3724, 3725, 3726, 3646
1145, 1819, 1858, 1859, 1820, 3726, 3727, 3728, 3648
1146, 1820, 1859, 1860, 1821, 3728, 3729, 3730, 3650
1147, 1821, 1860, 1861, 1822, 3730, 3731, 3732, 3652
1148, 1822, 1861, 1862, 1823, 3732, 3733, 3734, 3654
1149, 1823, 1862, 1863, 1824, 3734, 3735, 3736, 3656
1150, 1824, 1863, 1864, 1825, 3736, 3737, 3738, 3658
1151, 1825, 1864, 1865, 1826, 3738, 3739, 3740, 3660
1152, 1826, 1865, 1866, 1827, 3740, 3741, 3742, 3662
1153, 1827, 1866, 1867, 1828, 3742, 3743, 3744, 3664
1154, 1828, 1867, 1868, 1829, 3744, 3745, 3746, 3666
1155, 1829, 1868, 1869, 1830, 3746, 3747, 3748, 3668
1156, 1830, 1869, 1870, 1831, 3748, 3749, 3750, 3670
1157, 1831, 1870, 219, 220, 3750, 3751, 259, 3672
1158, 39, 40, 1871, 1832, 79, 3752, 3753, 3673
1159, 1832, 1871, 1872, 1833, 3753, 3754, 3755, 3675
1160, 1833, 1872, 1873, 1834, 3755, 3756, 3757, 3677
1161, 1834, 1873, 1874, 1835, 3757, 3758, 3759, 3679
1162, 1835, 1874, 1875, 1836, 3759, 3760, 3761, 3681
1163, 1836, 1875, 1876, 1837, 3761, 3762, 3763, 3683
1164, 1837, 1876, 1877, 1838, 3763, 3764, 3765, 3685
1165, 1838, 1877, 1878, 1839, 3765, 3766, 3767, 3687
1166, 1839, 1878, 1879, 1840, 3767, 3768, 3769, 3689
1167, 1840, 1879, 1880, 1841, 3769, 3770, 3771, 3691
1168, 1841, 1880, 1881, 1842, 3771, 3772, 3773, 3693
1169, 1842, 1881, 1882, 1843, 3773, 3774, 3775, 3695
1170, 1843, 1882, 1883, 1844, 3775, 3776, 3777, 3697
1171, 1844, 1883, 1884, 1845, 3777, 3778, 3779, 3699
1172, 1845, 1884, 1885, 1846, 3779, 3780, 3781, 3701
1173, 1846, 1885, 1886, 1847, 3781, 3782, 3783, 3703
1174, 1847, 1886, 1887, 1848, 3783, 3784, 3785, 3705
1175, 1848, 1887, 1888, 1849, 3785, 3786, 3787, 3707
1176, 1849, 1888, 1889, 1850, 3787, 3788, 3789, 3709
1177, 1850, 1889, 1890, 1851, 3789, 3790, 3791, 3711
1178, 1851, 1890, 1891, 1852, 3791, 3792, 3793, 3713
1179, 1852, 1891, 1892, 1853, 3793, 3794, 3795, 3715
1180, 1853, 1892, 1893, 1854, 3795, 3796, 3797, 3717
1181, 1854, 1893, 1894, 1855, 3797, 3798, 3799, 3719
1182, 1855, 1894, 1895, 1856, 3799, 3800, 3801, 3721
1183, 1856, 1895, 1896, 1857, 3801, 3802, 3803, 3723
1184, 1857, 1896, 1897, 1858, 3803, 3804, 3805, 3725
1185, 1858, 1897, 1898, 1859, 3805, 3806, 3807, 3727
1186, 1859, 1898, 1899, 1860, 3807, 3808, 3809, 3729
1187, 1860, 1899, 1900, 1861, 3809, 3810, 3811, 3731
1188, 1861, 1900, 1901, 1862, 3811, 3812, 3813, 3733
1189, 1862, 1901, 1902, 1863, 3813, 3814, 3815, 3735
1190, 1863, 1902, 1903, 1864, 3815, 3816, 3817, 3737
1191, 1864, 1903, 1904, 1865, 3817, 3818, 3819, 3739
1192, 1865, 1904, 1905, 1866, 3819, 3820, 3821, 3741
1193, 1866, 1905, 1906, 1867, 3821, 3822, 3823, 3743
1194, 1867, 1906, 1907, 1868, 3823, 3824, 3825, 3745
1195, 1868, 1907, 1908, 1869, 3825, 3826, 3827, 3747
1196, 1869, 1908, 1909, 1870, 3827, 3828, 3829, 3749
1197, 1870, 1909, 218, 219, 3829, 3830, 258, 3751
1198, 40, 41, 1910, 1871, 80, 3831, 3832, 3752
1199, 1871, 1910, 1911, 1872, 3832, 3833, 3834, 3754
1200, 1872, 1911, 1912, 1873, 3834, 3835, 3836, 3756
1201, 1873, 1912, 1913, 1874, 3836, 3837, 3838, 3758
1202, 1874, 1913, 1914, 1875, 3838, 3839, 3840, 3760
1203, 1875, 1914, 1915, 1876, 3840, 3841, 3842, 3762
1204, 1876, 1915, 1916, 1877, 3842, 3843, 3844, 3764
1205, 1877, 1916, 1917, 1878, 3844, 3845, 3846, 3766
1206, 1878, 1917, 1918, 1879, 3846, 3847, 3848, 3768
1207, 1879, 1918, 1919, 1880, 3848, 3849, 3850, 3770
1208, 1880, 1919, 1920, 1881, 3850, 3851, 3852, 3772
1209, 1881, 1920, 1921, 1882, 3852, 3853, 3854, 3774
1210, 1882, 1921, 1922, 1883, 3854, 3855, 3856, 3776
1211, 1883, 1922, 1923, 1884, 3856, 3857, 3858, 3778
1212, 1884, 1923, 1924, 1885, 3858, 3859, 3860, 3780
1213, 1885, 1924, 1925, 1886, 3860, 3861, 3862, 3782
1214, 1886, 1925, 1926, 1887, 3862, 3863, 3864, 3784
1215, 1887, 1926, 1927, 1888, 3864, 3865, 3866, 3786
1216, 1888, 1927, 1928, 1889, 3866, 3867, 3868, 3788
1217, 1889, 1928, 1929, 1890, 3868, 3869, 3870, 3790
1218, 1890, 1929, 1930, 1891, 3870, 3871, 3872, 3792
1219, 1891, 1930, 1931, 1892, 3872, 3873, 3874, 3794
1220, 1892, 1931, 1932, 1893, 3874, 3875, 3876, 3796
1221, 1893, 1932, 1933, 1894, 3876, 3877, 3878, 3798
1222, 1894, 1933, 1934, 1895, 3878, 3879, 3880, 3800
1223, 1895, 1934, 1935, 1896, 3880, 3881, 3882, 3802
1224, 1896, 1935, 1936, 1897, 3882, 3883, 3884, 3804
1225, 1897, 1936, 1937, 1898, 3884, 3885, 3886, 3806
1226, 1898, 1937, 1938, 1899, 3886, 3887, 3888, 3808
1227, 1899, 1938, 1939, 1900, 3888, 3889, 3890, 3810
1228, 1900, 1939, 1940, 1901, 3890, 3891, 3892, 3812
1229, 1901, 1940, 1941, 1902, 3892, 3893, 3894, 3814
1230, 1902, 1941, 1942, 1903, 3894, 3895, 3896, 3816
1231, 1903, 1942, 1943, 1904, 3896, 3897, 3898, 3818
1232, 1904, 1943, 1944, 1905, 3898, 3899, 3900, 3820
1233, 1905, 1944, 1945, 1906, 3900, 3901, 3902, 3822
1234, 1906, 1945, 1946, 1907, 3902, 3903, 3904, 3824
1235, 1907, 1946, 1947, 1908, 3904, 3905, 3906, 3826
1236, 1908, 1947, 1948, 1909, 3906, 3907, 3908, 3828
1237, 1909, 1948, 217, 218, 3908, 3909, 257, 3830
1238, 41, 42, 1949, 1910, 81, 3910, 3911, 3831
1239, 1910, 1949, 1950, 1911, 3911, 3912, 3913, 3833
1240, 1911, 1950, 1951, 1912, 3913, 3914, 3915, 3835
1241, 1912, 1951, 1952, 1913, 3915, 3916, 3917, 3837
1242, 1913, 1952, 1953, 1914, 3917, 3918, 3919, 3839
1243, 1914, 1953, 1954, 1915, 3919, 3920, 3921, 3841
1244, 1915, 1954, 1955, 1916, 3921, 3922, 3923, 3843
1245, 1916, 1955, 1956, 1917, 3923, 3924, 3925, 3845
1246, 1917, 1956, 1957, 1918, 3925, 3926, 3927, 3847
1247, 1918, 1957, 1958, 1919, 3927, 3928, 3929, 3849
1248, 1919, 1958, 1959, 1920, 3929, 3930, 3931, 3851
1249, 1920, 1959, 1960, 1921, 3931, 3932, 3933, 3853
1250, 1921, 1960, 1961, 1922, 3933, 3934, 3935, 3855
1251, 1922, 1961, 1962, 1923, 3935, 3936, 3937, 3857
1252, 1923, 1962, 1963, 1924, 3937, 3938, 3939, 3859
1253, 1924, 1963, 1964, 1925, 3939, 3940, 3941, 3861
1254, 1925, 1964, 1965, 1926, 3941, 3942, 3943, 3863
1255, 1926, 1965, 1966, 1927, 3943, 3944, 3945, 3865
1256, 1927, 1966, 1967, 1928, 3945, 3946, 3947, 3867
1257, 1928, 1967, 1968, 1929, 3947, 3948, 3949, 3869
1258, 1929, 1968, 1969, 1930, 3949, 3950, 3951, 3871
1259, 1930, 1969, 1970, 1931, 3951, 3952, 3953, 3873
1260, 1931, 1970, 1971, 1932, 3953, 3954, 3955, 3875
1261, 1932, 1971, 1972, 1933, 3955, 3956, 3957, 3877
1262, 1933, 1972, 1973, 1934, 3957, 3958, 3959, 3879
1263, 1934, 1973, 1974, 1935, 3959, 3960, 3961, 3881
1264, 1935, 1974, 1975, 1936, 3961, 3962, 3963, 3883
1265, 1936, 1975, 1976, 1937, 3963, 3964, 3965, 3885
1266, 1937, 1976, 1977, 1938, 3965, 3966, 3967, 3887
1267, 1938, 1977, 1978, 1939, 3967, 3968, 3969, 3889
1268, 1939, 1978, 1979, 1940, 3969, 3970, 3971, 3891
1269, 1940, 1979, 1980, 1941, 3971, 3972, 3973, 3893
1270, 1941, 1980, 1981, 1942, 3973, 3974, 3975, 3895
1271, 1942, 1981, 1982, 1943, 3975, 3976, 3977, 3897
1272, 1943, 1982, 1983, 1944, 3977, 3978, 3979, 3899
1273, 1944, 1983, 1984, 1945, 3979, 3980, 3981, 3901
1274, 1945, 1984, 1985, 1946, 3981, 3982, 3983, 3903
1275, 1946, 1985, 1986, 1947, 3983, 3984, 3985, 3905
1276, 1947, 1986, 1987, 1948, 3985, 3986, 3987, 3907
1277, 1948, 1987, 216, 217, 3987, 3988, 256, 3909
1278, 42, 43, 1988, 1949, 82, 3989, 3990, 3910
1279, 1949, 1988, 1989, 1950, 3990, 3991, 3992, 3912
1280, 1950, 1989, 1990, 1951, 3992, 3993, 3994, 3914
1281, 1951, 1990, 1991, 1952, 3994, 3995, 3996, 3916
1282, 1952, 1991, 1992, 1953, 3996, 3997, 3998, 3918
1283, 1953, 1992, 1993, 1954, 3998, 3999, 4000, 3920
1284, 1954, 1993, 1994, 1955, 4000, 4001, 4002, 3922
1285, 1955, 1994, 1995, 1956, 4002, 4003, 4004, 3924
1286, 1956, 1995, 1996, 1957, 4004, 4005, 4006, 3926
1287, 1957, 1996, 1997, 1958, 4006, 4007, 4008, 3928
1288, 1958, 1997, 1998, 1959, 4008, 4009, 4010, 3930
1289, 1959, 1998, 1999, 1960, 4010, 4011, 4012, 3932
1290, 1960, 1999, 2000, 1961, 4012, 4013, 4014, 3934
1291, 1961, 2000, 2001, 1962, 4014, 4015, 4016, 3936
1292, 1962, 2001, 2002, 1963, 4016, 4017, 4018, 3938
1293, 1963, 2002, 2003, 1964, 4018, 4019, 4020, 3940
1294, 1964, 2003, 2004, 1965, 4020, 4021, 4022, 3942
1295, 1965, 2004, 2005, 1966, 4022, 4023, 4024, 3944
1296, 1966, 2005, 2006, 1967, 4024, 4025, 4026, 3946
1297, 1967, 2006, 2007, 1968, 4026, 4027, 4028, 3948
1298, 1968, 2007, 2008, 1969, 4028, 4029, 4030, 3950
1299, 1969, 2008, 2009, 1970, 4030, 4031, 4032, 3952
1300, 1970, 2009, 2010, 1971, 4032, 4033, 4034, 3954
1301, 1971, 2010, 2011, 1972, 4034, 4035, 4036, 3956
1302, 1972, 2011, 2012, 1973, 4036, 4037, 4038, 3958
1303, 1973, 2012, 2013, 1974, 4038, 4039, 4040, 3960
1304, 1974, 2013, 2014, 1975, 4040, 4041, 4042, 3962
1305, 1975, 2014, 2015, 1976, 4042, 4043, 4044, 3964
1306, 1976, 2015, 2016, 1977, 4044, 4045, 4046, 3966
1307, 1977, 2016, 2017, 1978, 4046, 4047, 4048, 3968
1308, 1978, 2017, 2018, 1979, 4048, 4049, 4050, 3970
1309, 1979, 2018, 2019, 1980, 4050, 4051, 4052, 3972
1310, 1980, 2019, 2020, 1981, 4052, 4053, 4054, 3974
1311, 1981, 2020, 2021, 1982, 4054, 4055, 4056, 3976
1312, 1982, 2021, 2022, 1983, 4056, 4057, 4058, 3978
1313, 1983, 2022, 2023, 1984, 4058, 4059, 4060, 3980
1314, 1984, 2023, 2024, 1985, 4060, 4061, 4062, 3982
1315, 1985, 2024, 2025, 1986, 4062, 4063, 4064, 3984
1316, 1986, 2025, 2026, 1987, 4064, 4065, 4066, 3986
1317, 1987, 2026, 215, 216, 4066, 4067, 255, 3988
1318, 43, 44, 2027, 1988, 83, 4068, 4069, 3989
1319, 1988, 2027, 2028, 1989, 4069, 4070, 4071, 3991
1320, 1989, 2028, 2029, 1990, 4071, 4072, 4073, 3993
1321, 1990, 2029, 2030, 1991, 4073, 4074, 4075, 3995
1322, 1991, 2030, 2031, 1992, 4075, 4076, 4077, 3997
1323, 1992, 2031, 2032, 1993, 4077, 4078, 4079, 3999
1324, 1993, 2032, 2033, 1994, 4079, 4080, 4081, 4001
1325, 1994, 2033, 2034, 1995, 4081, 4082, 4083, 4003
1326, 1995, 2034, 2035, 1996, 4083, 4084, 4085, 4005
1327, 1996, 2035, 2036, 1997, 4085, 4086, 4087, 4007
1328, 1997, 2036, 2037, 1998, 4087, 4088, 4089, 4009
1329, 1998, 2037, 2038, 1999, 4089, 4090, 4091, 4011
1330, 1999, 2038, 2039, 2000, 4091, 4092, 4093, 4013
1331, 2000, 2039, 2040, 2001, 4093, 4094, 4095, 4015
1332, 2001, 2040, 2041, 2002, 4095, 4096, 4097, 4017
1333, 2002, 2041, 2042, 2003, 4097, 4098, 4099, 4019
1334, 2003, 2042, 2043, 2004, 4099, 4100, 4101, 4021
1335, 2004, 2043, 2044, 2005, 4101, 4102, 4103, 4023
1336, 2005, 2044, 2045, 2006, 4103, 4104, 4105, 4025
1337, 2006, 2045, 2046, 2007, 4105, 4106, 4107, 4027
1338, 2007, 2046, 2047, 2008, 4107, 4108, 4109, 4029
1339, 2008, 2047, 2048, 2009, 4109, 4110, 4111, 4031
1340, 2009, 2048, 2049, 2010, 4111, 4112, 4113, 4033
1341, 2010, 2049, 2050, 2011, 4113, 4114, 4115, 4035
1342, 2011, 2050, 2051, 2012, 4115, 4116, 4117, 4037
1343, 2012, 2051, 2052, 2013, 4117, 4118, 4119, 4039
1344, 2013, 2052, 2053, 2014, 4119, 4120, 4121, 4041
1345, 2014, 2053, 2054, 2015, 4121, 4122, 4123, 4043
1346, 2015, 2054, 2055, 2016, 4123, 4124, 4125, 4045
1347, 2016, 2055, 2056, 2017, 4125, 4126, 4127, 4047
1348, 2017, 2056, 2057, 2018, 4127, 4128, 4129, 4049
1349, 2018, 2057, 2058, 2019, 4129, 4130, 4131, 4051
1350, 2019, 2058, 2059, 2020, 4131, 4132, 4133, 4053
1351, 2020, 2059, 2060, 2021, 4133, 4134, 4135, 4055
1352, 2021, 2060, 2061, 2022, 4135, 4136, 4137, 4057
1353, 2022, 2061, 2062, 2023, 4137, 4138, 4139, 4059
1354, 2023, 2062, 2063, 2024, 4139, 4140, 4141, 4061
1355, 2024, 2063, 2064, 2025, 4141, 4142, 4143, 4063
1356, 2025, 2064, 2065, 2026, 4143, 4144, 4145, 4065
1357, 2026, 2065, 214, 215, 4145, 4146, 254, 4067
1358, 44, 45, 2066, 2027, 84, 4147, 4148, 4068
1359, 2027, 2066, 2067, 2028, 4148, 4149, 4150, 4070
1360, 2028, 2067, 2068, 2029, 4150, 4151, 4152, 4072
1361, 2029, 2068, 2069, 2030, 4152, 4153, 4154, 4074
1362, 2030, 2069, 2070, 2031, 4154, 4155, 4156, 4076
1363, 2031, 2070, 2071, 2032, 4156, 4157, 4158, 4078
1364, 2032, 2071, 2072, 2033, 4158, 4159, 4160, 4080
1365, 2033, 2072, 2073, 2034, 4160, 4161, 4162, 4082
1366, 2034, 2073, 2074, 2035, 4162, 4163, 4164, 4084
1367, 2035, 2074, 2075, 2036, 4164, 4165, 4166, 4086
1368, 2036, 2075, 2076, 2037, 4166, 4167, 4168, 4088
1369, 2037, 2076, 2077, 2038, 4168, 4169, 4170, 4090
1370, 2038, 2077, 2078, 2039, 4170, 4171, 4172, 4092
1371, 2039, 2078, 2079, 2040, 4172, 4173, 4174, 4094
1372, 2040, 2079, 2080, 2041, 4174, 4175, 4176, 4096
1373, 2041, 2080, 2081, 2042, 4176, 4177, 4178, 4098
1374, 2042, 2081, 2082, 2043, 4178, 4179, 4180, 4100
1375, 2043, 2082, 2083, 2044, 4180, 4181, 4182, 4102
1376, 2044, 2083, 2084, 2045, 4182, 4183, 4184, 4104
1377, 2045, 2084, 2085, 2046, 4184, 4185, 4186, 4106
1378, 2046, 2085, 2086, 2047, 4186, 4187, 4188, 4108
1379, 2047, 2086, 2087, 2048, 4188, 4189, 4190, 4110
1380, 2048, 2087, 2088, 2049, 4190, 4191, 4192, 4112
1381, 2049, 2088, 2089, 2050, 4192, 4193, 4194, 4114
1382, 2050, 2089, 2090, 2051, 4194, 4195, 4196, 4116
1383, 2051, 2090, 2091, 2052, 4196, 4197, 4198, 4118
1384, 2052, 2091, 2092, 2053, 4198, 4199, 4200, 4120
1385, 2053, 2092, 2093, 2054, 4200, 4201, 4202, 4122
1386, 2054, 2093, 2094, 2055, 4202, 4203, 4204, 4124
1387, 2055, 2094, 2095, 2056, 4204, 4205, 4206, 4126
1388, 2056, 2095, 2096, 2057, 4206, 4207, 4208, 4128
1389, 2057, 2096, 2097, 2058, 4208, 4209, 4210, 4130
1390, 2058, 2097, 2098, 2059, 4210, 4211, 4212, 4132
1391, 2059, 2098, 2099, 2060, 4212, 4213, 4214, 4134
1392, 2060, 2099, 2100, 2061, 4214, 4215, 4216, 4136
1393, 2061, 2100, 2101, 2062, 4216, 4217, 4218, 4138
1394, 2062, 2101, 2102, 2063, 4218, 4219, 4220, 4140
1395, 2063, 2102, 2103, 2064, 4220, 4221, 4222, 4142
1396, 2064, 2103, 2104, 2065, 4222, 4223, 4224, 4144
1397, 2065, 2104, 213, 214, 4224, 4225, 253, 4146
1398, 45, 46, 2105, 2066, 85, 4226, 4227, 4147
1399, 2066, 2105, 2106, 2067, 4227, 4228, 4229, 4149
1400, 2067, 2106, 2107, 2068, 4229, 4230, 4231, 4151
1401, 2068, 2107, 2108, 2069, 4231, 4232, 4233, 4153
1402, 2069, 2108, 2109, 2070, 4233, 4234, 4235, 4155
1403, 2070, 2109, 2110, 2071, 4235, 4236, 4237, 4157
1404, 2071, 2110, 2111, 2072, 4237, 4238, 4239, 4159
1405, 2072, 2111, 2112, 2073, 4239, 4240, 4241, 4161
1406, 2073, 2112, 2113, 2074, 4241, 4242, 4243, 4163
1407, 2074, 2113, 2114, 2075, 4243, 4244, 4245, 4165
1408, 2075, 2114, 2115, 2076, 4245, 4246, 4247, 4167
1409, 2076, 2115, 2116, 2077, 4247, 4248, 4249, 4169
1410, 2077, 2116, 2117, 2078, 4249, 4250, 4251, 4171
1411, 2078, 2117, 2118, 2079, 4251, 4252, 4253, 4173
1412, 2079, 2118, 2119, 2080, 4253, 4254, 4255, 4175
1413, 2080, 2119, 2120, 2081, 4255, 4256, 4257, 4177
1414, 2081, 2120, 2121, 2082, 4257, 4258, 4259, 4179
1415, 2082, 2121, 2122, 2083, 4259, 4260, 4261, 4181
1416, 2083, 2122, 2123, 2084, 4261, 4262, 4263, 4183
1417, 2084, 2123, 2124, 2085, 4263, 4264, 4265, 4185
1418, 2085, 2124, 2125, 2086, 4265, 4266, 4267, 4187
1419, 2086, 2125, 2126, 2087, 4267, 4268, 4269, 4189
1420, 2087, 2126, 2127, 2088, 4269, 4270, 4271, 4191
1421, 2088, 2127, 2128, 2089, 4271, 4272, 4273, 4193
1422, 2089, 2128, 2129, 2090, 4273, 4274, 4275, 4195
1423, 2090, 2129, 2130, 2091, 4275, 4276, 4277, 4197
1424, 2091, 2130, 2131, 2092, 4277, 4278, 4279, 4199
1425, 2092, 2131, 2132, 2093, 4279, 4280, 4281, 4201
1426, 2093, 2132, 2133, 2094, 4281, 4282, 4283, 4203
1427, 2094, 2133, 2134, 2095, 4283, 4284, 4285, 4205
1428, 2095, 2134, 2135, 2096, 4285, 4286, 4287, 4207
1429, 2096, 2135, 2136, 2097, 4287, 4288, 4289, 4209
1430, 2097, 2136, 2137, 2098, 4289, 4290, 4291, 4211
1431, 2098, 2137, 2138, 2099, 4291, 4292, 4293, 4213
1432, 2099, 2138, 2139, 2100, 4293, 4294, 4295, 4215
1433, 2100, 2139, 2140, 2101, 4295, 4296, 4297, 4217
1434, 2101, 2140, 2141, 2102, 4297, 4298, 4299, 4219
1435, 2102, 2141, 2142, 2103, 4299, 4300, 4301, 4221
1436, 2103, 2142, 2143, 2104, 4301, 4302, 4303, 4223
1437, 2104, 2143, 212, 213, 4303, 4304, 252, 4225
1438, 46, 47, 2144, 2105, 86, 4305, 4306, 4226
1439, 2105, 2144, 2145, 2106, 4306, 4307, 4308, 4228
1440, 2106, 2145, 2146, 2107, 4308, 4309, 4310, 4230
1441, 2107, 2146, 2147, 2108, 4310, 4311, 4312, 4232
1442, 2108, 2147, 2148, 2109, 4312, 4313, 4314, 4234
1443, 2109, 2148, 2149, 2110, 4314, 4315, 4316, 4236
1444, 2110, 2149, 2150, 2111, 4316, 4317, 4318, 4238
1445, 2111, 2150, 2151, 2112, 4318, 4319, 4320, 4240
1446, 2112, 2151, 2152, 2113, 4320, 4321, 4322, 4242
1447, 2113, 2152, 2153, 2114, 4322, 4323, 4324, 4244
1448, 2114, 2153, 2154, 2115, 4324, 4325, 4326, 4246
1449, 2115, 2154, 2155, 2116, 4326, 4327, 4328, 4248
1450, 2116, 2155, 2156, 2117, 4328, 4329, 4330, 4250
1451, 2117, 2156, 2157, 2118, 4330, 4331, 4332, 4252
1452, 2118, 2157, 2158, 2119, 4332, 4333, 4334, 4254
1453, 2119, 2158, 2159, 2120, 4334, 4335, 4336, 4256
1454, 2120, 2159, 2160, 2121, 4336, 4337, 4338, 4258
1455, 2121, 2160, 2161, 2122, 4338, 4339, 4340, 4260
1456, 2122, 2161, 2162, 2123, 4340, 4341, 4342, 4262
1457, 2123, 2162, 2163, 2124, 4342, 4343, 4344, 4264
1458, 2124, 2163, 2164, 2125, 4344, 4345, 4346, 4266
1459, 2125, 2164, 2165, 2126, 4346, 4347, 4348, 4268
1460, 2126, 2165, 2166, 2127, 4348, 4349, 4350, 4270
1461, 2127, 2166, 2167, 2128, 4350, 4351, 4352, 4272
1462, 2128, 2167, 2168, 2129, 4352, 4353, 4354, 4274
1463, 2129, 2168, 2169, 2130, 4354, 4355, 4356, 4276
1464, 2130, 2169, 2170, 2131, 4356, 4357, 4358, 4278
1465, 2131, 2170, 2171, 2132, 4358, 4359, 4360, 4280
1466, 2132, 2171, 2172, 2133, 4360, 4361, 4362, 4282
1467, 2133, 2172, 2173, 2134, 4362, 4363, 4364, 4284
1468, 2134, 2173, 2174, 2135, 4364, 4365, 4366, 4286
1469, 2135, 2174, 2175, 2136, 4366, 4367, 4368, 4288
1470, 2136, 2175, 2176, 2137, 4368, 4369, 4370, 4290
1471, 2137, 2176, 2177, 2138, 4370, 4371, 4372, 4292
1472, 2138, 2177, 2178, 2139, 4372, 4373, 4374, 4294
1473, 2139, 2178, 2179, 2140, 4374, 4375, 4376, 4296
1474, 2140, 2179, 2180, 2141, 4376, 4377, 4378, 4298
1475, 2141, 2180, 2181, 2142, 4378, 4379, 4380, 4300
1476, 2142, 2181, 2182, 2143, 4380, 4381, 4382, 4302
1477, 2143, 2182, 211, 212, 4382, 4383, 251, 4304
1478, 47, 48, 2183, 2144, 87, 4384, 4385, 4305
1479, 2144, 2183, 2184, 2145, 4385, 4386, 4387, 4307
1480, 2145, 2184, 2185, 2146, 4387, 4388, 4389, 4309
1481, 2146, 2185, 2186, 2147, 4389, 4390, 4391, 4311
1482, 2147, 2186, 2187, 2148, 4391, 4392, 4393, 4313
1483, 2148, 2187, 2188, 2149, 4393, 4394, 4395, 4315
1484, 2149, 2188, 2189, 2150, 4395, 4396, 4397, 4317
1485, 2150, 2189, 2190, 2151, 4397, 4398, 4399, 4319
1486, 2151, 2190, 2191, 2152, 4399, 4400, 4401, 4321
1487, 2152, 2191, 2192, 2153, 4401, 4402, 4403, 4323
1488, 2153, 2192, 2193, 2154, 4403, 4404, 4405, 4325
1489, 2154, 2193, 2194, 2155, 4405, 4406, 4407, 4327
1490, 2155, 2194, 2195, 2156, 4407, 4408, 4409, 4329
1491, 2156, 2195, 2196, 2157, 4409, 4410, 4411, 4331
1492, 2157, 2196, 2197, 2158, 4411, 4412, 4413, 4333
1493, 2158, 2197, 2198, 2159, 4413, 4414, 4415, 4335
1494, 2159, 2198, 2199, 2160, 4415, 4416, 4417, 4337
1495, 2160, 2199, 2200, 2161, 4417, 4418, 4419, 4339
1496, 2161, 2200, 2201, 2162, 4419, 4420, 4421, 4341
1497, 2162, 2201, 2202, 2163, 4421, 4422, 4423, 4343
1498, 2163, 2202, 2203, 2164, 4423, 4424, 4425, 4345
1499, 2164, 2203, 2204, 2165, 4425, 4426, 4427, 4347
1500, 2165, 2204, 2205, 2166, 4427, 4428, 4429, 4349
1501, 2166, 2205, 2206, 2167, 4429, 4430, 4431, 4351
1502, 2167, 2206, 2207, 2168, 4431, 4432, 4433, 4353
1503, 2168, 2207, 2208, 2169, 4433, 4434, 4435, 4355
1504, 2169, 2208, 2209, 2170, 4435, 4436, 4437, 4357
1505, 2170, 2209, 2210, 2171, 4437, 4438, 4439, 4359
1506, 2171, 2210, 2211, 2172, 4439, 4440, 4441, 4361
1507, 2172, 2211, 2212, 2173, 4441, 4442, 4443, 4363
1508, 2173, 2212, 2213, 2174, 4443, 4444, 4445, 4365
1509, 2174, 2213, 2214, 2175, 4445, 4446, 4447, 4367
1510, 2175, 2214, 2215, 2176, 4447, 4448, 4449, 4369
1511, 2176, 2215, 2216, 2177, 4449, 4450, 4451, 4371
1512, 2177, 2216, 2217, 2178, 4451, 4452, 4453, 4373
1513, 2178, 2217, 2218, 2179, 4453, 4454, 4455, 4375
1514, 2179, 2218, 2219, 2180, 4455, 4456, 4457, 4377
1515, 2180, 2219, 2220, 2181, 4457, 4458, 4459, 4379
1516, 2181, 2220, 2221, 2182, 4459, 4460, 4461, 4381
1517, 2182, 2221, 210, 211, 4461, 4462, 250, 4383
1518, 48, 49, 2222, 2183, 88, 4463, 4464, 4384
1519, 2183, 2222, 2223, 2184, 4464, 4465, 4466, 4386
1520, 2184, 2223, 2224, 2185, 4466, 4467, 4468, 4388
1521, 2185, 2224, 2225, 2186, 4468, 4469, 4470, 4390
1522, 2186, 2225, 2226, 2187, 4470, 4471, 4472, 4392
1523, 2187, 2226, 2227, 2188, 4472, 4473, 4474, 4394
1524, 2188, 2227, 2228, 2189, 4474, 4475, 4476, 4396
1525, 2189, 2228, 2229, 2190, 4476, 4477, 4478, 4398
1526, 2190, 2229, 2230, 2191, 4478, 4479, 4480, 4400
1527, 2191, 2230, 2231, 2192, 4480, 4481, 4482, 4402
1528, 2192, 2231, 2232, 2193, 4482, 4483, 4484, 4404
1529, 2193, 2232, 2233, 2194, 4484, 4485, 4486, 4406
1530, 2194, 2233, 2234, 2195, 4486, 4487, 4488, 4408
1531, 2195, 2234, 2235, 2196, 4488, 4489, 4490, 4410
1532, 2196, 2235, 2236, 2197, 4490, 4491, 4492, 4412
1533, 2197, 2236, 2237, 2198, 4492, 4493, 4494, 4414
1534, 2198, 2237, 2238, 2199, 4494, 4495, 4496, 4416
1535, 2199, 2238, 2239, 2200, 4496, 4497, 4498, 4418
1536, 2200, 2239, 2240, 2201, 4498, 4499, 4500, 4420
1537, 2201, 2240, 2241, 2202, 4500, 4501, 4502, 4422
1538, 2202, 2241, 2242, 2203, 4502, 4503, 4504, 4424
1539, 2203, 2242, 2243, 2204, 4504, 4505, 4506, 4426
1540, 2204, 2243, 2244, 2205, 4506, 4507, 4508, 4428
1541, 2205, 2244, 2245, 2206, 4508, 4509, 4510, 4430
1542, 2206, 2245, 2246, 2207, 4510, 4511, 4512, 4432
1543, 2207, 2246, 2247, 2208, 4512, 4513, 4514, 4434
1544, 2208, 2247, 2248, 2209, 4514, 4515, 4516, 4436
1545, 2209, 2248, 2249, 2210, 4516, 4517, 4518, 4438
1546, 2210, 2249, 2250, 2211, 4518, 4519, 4520, 4440
1547, 2211, 2250, 2251, 2212, 4520, 4521, 4522, 4442
1548, 2212, 2251, 2252, 2213, 4522, 4523, 4524, 4444
1549, 2213, 2252, 2253, 2214, 4524, 4525, 4526, 4446
1550, 2214, 2253, 2254, 2215, 4526, 4527, 4528, 4448
1551, 2215, 2254, 2255, 2216, 4528, 4529, 4530, 4450
1552, 2216, 2255, 2256, 2217, 4530, 4531, 4532, 4452
1553, 2217, 2256, 2257, 2218, 4532, 4533, 4534, 4454
1554, 2218, 2257, 2258, 2219, 4534, 4535, 4536, 4456
1555, 2219, 2258, 2259, 2220, 4536, 4537, 4538, 4458
1556, 2220, 2259, 2260, 2221, 4538, 4539, 4540, 4460
1557, 2221, 2260, 209, 210, 4540, 4541, 249, 4462
1558, 49, 50, 2261, 2222, 89, 4542, 4543, 4463
1559, 2222, 2261, 2262, 2223, 4543, 4544, 4545, 4465
1560, 2223, 2262, 2263, 2224, 4545, 4546, 4547, 4467
1561, 2224, 2263, 2264, 2225, 4547, 4548, 4549, 4469
1562, 2225, 2264, 2265, 2226, 4549, 4550, 4551, 4471
1563, 2226, 2265, 2266, 2227, 4551, 4552, 4553, 4473
1564, 2227, 2266, 2267, 2228, 4553, 4554, 4555, 4475
1565, 2228, 2267, 2268, 2229, 4555, 4556, 4557, 4477
1566, 2229, 2268, 2269, 2230, 4557, 4558, 4559, 4479
1567, 2230, 2269, 2270, 2231, 4559, 4560, 4561, 4481
1568, 2231, 2270, 2271, 2232, 4561, 4562, 4563, 4483
1569, 2232, 2271, 2272, 2233, 4563, 4564, 4565, 4485
1570, 2233, 2272, 2273, 2234, 4565, 4566, 4567, 4487
1571, 2234, 2273, 2274, 2235, 4567, 4568, 4569, 4489
1572, 2235, 2274, 2275, 2236, 4569, 4570, 4571, 4491
1573, 2236, 2275, 2276, 2237, 4571, 4572, 4573, 4493
1574, 2237, 2276, 2277, 2238, 4573, 4574, 4575, 4495
1575, 2238, 2277, 2278, 2239, 4575, 4576, 4577, 4497
1576, 2239, 2278, 2279, 2240, 4577, 4578, 4579, 4499
1577, 2240, 2279, 2280, 2241, 4579, 4580, 4581, 4501
1578, 2241, 2280, 2281, 2242, 4581, 4582, 4583, 4503
1579, 2242, 2281, 2282, 2243, 4583, 4584, 4585, 4505
1580, 2243, 2282, 2283, 2244, 4585, 4586, 4587, 4507
1581, 2244, 2283, 2284, 2245, 4587, 4588, 4589, 4509
1582, 2245, 2284, 2285, 2246, 4589, 4590, 4591, 4511
1583, 2246, 2285, 2286, 2247, 4591, 4592, 4593, 4513
1584, 2247, 2286, 2287, 2248, 4593, 4594, 4595, 4515
1585, 2248, 2287, 2288, 2249, 4595, 4596, 4597, 4517
1586, 2249, 2288, 2289, 2250, 4597, 4598, 4599, 4519
1587, 2250, 2289, 2290, 2251, 4599, 4600, 4601, 4521
1588, 2251, 2290, 2291, 2252, 4601, 4602, 4603, 4523
1589, 2252, 2291, 2292, 2253, 4603, 4604, 4605, 4525
1590, 2253, 2292, 2293, 2254, 4605, 4606, 4607, 4527
1591, 2254, 2293, 2294, 2255, 4607, 4608, 4609, 4529
1592, 2255, 2294, 2295, 2256, 4609, 4610, 4611, 4531
1593, 2256, 2295, 2296, 2257, 4611, 4612, 4613, 4533
1594, 2257, 2296, 2297, 2258, 4613, 4614, 4615, 4535
1595, 2258, 2297, 2298, 2259, 4615, 4616, 4617, 4537
1596, 2259, 2298, 2299, 2260, 4617, 4618, 4619, 4539
1597, 2260, 2299, 208, 209, 4619, 4620, 248, 4541
1598, 50, 51, 2300, 2261, 90, 4621, 4622, 4542
1599, 2261, 2300, 2301, 2262, 4622, 4623, 4624, 4544
1600, 2262, 2301, 2302, 2263, 4624, 4625, 4626, 4546
1601, 2263, 2302, 2303, 2264, 4626, 4627, 4628, 4548
1602, 2264, 2303, 2304, 2265, 4628, 4629, 4630, 4550
1603, 2265, 2304, 2305, 2266, 4630, 4631, 4632, 4552
1604, 2266, 2305, 2306, 2267, 4632, 4633, 4634, 4554
1605, 2267, 2306, 2307, 2268, 4634, 4635, 4636, 4556
1606, 2268, 2307, 2308, 2269, 4636, 4637, 4638, 4558
1607, 2269, 2308, 2309, 2270, 4638, 4639, 4640, 4560
1608, 2270, 2309, 2310, 2271, 4640, 4641, 4642, 4562
1609, 2271, 2310, 2311, 2272, 4642, 4643, 4644, 4564
1610, 2272, 2311, 2312, 2273, 4644, 4645, 4646, 4566
1611, 2273, 2312, 2313, 2274, 4646, 4647, 4648, 4568
1612, 2274, 2313, 2314, 2275, 4648, 4649, 4650, 4570
1613, 2275, 2314, 2315, 2276, 4650, 4651, 4652, 4572
1614, 2276, 2315, 2316, 2277, 4652, 4653, 4654, 4574
1615, 2277, 2316, 2317, 2278, 4654, 4655, 4656, 4576
1616, 2278, 2317, 2318, 2279, 4656, 4657, 4658, 4578
1617, 2279, 2318, 2319, 2280, 4658, 4659, 4660, 4580
1618, 2280, 2319, 2320, 2281, 4660, 4661, 4662, 4582
1619, 2281, 2320, 2321, 2282, 4662, 4663, 4664, 4584
1620, 2282, 2321, 2322, 2283, 4664, 4665, 4666, 4586
1621, 2283, 2322, 2323, 2284, 4666, 4667, 4668, 4588
1622, 2284, 2323, 2324, 2285, 4668, 4669, 4670, 4590
1623, 2285, 2324, 2325, 2286, 4670, 4671, 4672, 4592
1624, 2286, 2325, 2326, 2287, 4672, 4673, 4674, 4594
1625, 2287, 2326, 2327, 2288, 4674, 4675, 4676, 4596
1626, 2288, 2327, 2328, 2289, 4676, 4677, 4678, 4598
1627, 2289, 2328, 2329, 2290, 4678, 4679, 4680, 4600
1628, 2290, 2329, 2330, 2291, 4680, 4681, 4682, 4602
1629, 2291, 2330, 2331, 2292, 4682, 4683, 4684, 4604
1630, 2292, 2331, 2332, 2293, 4684, 4685, 4686, 4606
1631, 2293, 2332, 2333, 2294, 4686, 4687, 4688, 4608
1632, 2294, 2333, 2334, 2295, 4688, 4689, 4690, 4610
1633, 2295, 2334, 2335, 2296, 4690, 4691, 4692, 4612
1634, 2296, 2335, 2336, 2297, 4692, 4693, 4694, 4614
1635, 2297, 2336, 2337, 2298, 4694, 4695, 4696, 4616
1636, 2298, 2337, 2338, 2299, 4696, 4697, 4698, 4618
1637, 2299, 2338, 207, 208, 4698, 4699, 247, 4620
1638, 51, 52, 2339, 2300, 91, 4700, 4701, 4621
1639, 2300, 2339, 2340, 2301, 4701, 4702, 4703, 4623
1640, 2301, 2340, 2341, 2302, 4703, 4704, 4705, 4625
1641, 2302, 2341, 2342, 2303, 4705, 4706, 4707, 4627
1642, 2303, 2342, 2343, 2304, 4707, 4708, 4709, 4629
1643, 2304, 2343, 2344, 2305, 4709, 4710, 4711, 4631
1644, 2305, 2344, 2345, 2306, 4711, 4712, 4713, 4633
1645, 2306, 2345, 2346, 2307, 4713, 4714, 4715, 4635
1646, 2307, 2346, 2347, 2308, 4715, 4716, 4717, 4637
1647, 2308, 2347, 2348, 2309, 4717, 4718, 4719, 4639
1648, 2309, 2348, 2349, 2310, 4719, 4720, 4721, 4641
1649, 2310, 2349, 2350, 2311, 4721, 4722, 4723, 4643
1650, 2311, 2350, 2351, 2312, 4723, 4724, 4725, 4645
1651, 2312, 2351, 2352, 2313, 4725, 4726, 4727, 4647
1652, 2313, 2352, 2353, 2314, 4727, 4728, 4729, 4649
1653, 2314, 2353, 2354, 2315, 4729, 4730, 4731, 4651
1654, 2315, 2354, 2355, 2316, 4731, 4732, 4733, 4653
1655, 2316, 2355, 2356, 2317, 4733, 4734, 4735, 4655
1656, 2317, 2356, 2357, 2318, 4735, 4736, 4737, 4657
1657, 2318, 2357, 2358, 2319, 4737, 4738, 4739, 4659
1658, 2319, 2358, 2359, 2320, 4739, 4740, 4741, 4661
1659, 2320, 2359, 2360, 2321, 4741, 4742, 4743, 4663
1660, 2321, 2360, 2361, 2322, 4743, 4744, 4745, 4665
1661, 2322, 2361, 2362, 2323, 4745, 4746, 4747, 4667
1662, 2323, 2362, 2363, 2324, 4747, 4748, 4749, 4669
1663, 2324, 2363, 2364, 2325, 4749, 4750, 4751, 4671
1664, 2325, 2364, 2365, 2326, 4751, 4752, 4753, 4673
1665, 2326, 2365, 2366, 2327, 4753, 4754, 4755, 4675
1666, 2327, 2366, 2367, 2328, 4755, 4756, 4757, 4677
1667, 2328, 2367, 2368, 2329, 4757, 4758, 4759, 4679
1668, 2329, 2368, 2369, 2330, 4759, 4760, 4761, 4681
1669, 2330, 2369, 2370, 2331, 4761, 4762, 4763, 4683
1670, 2331, 2370, 2371, 2332, 4763, 4764, 4765, 4685
1671, 2332, 2371, 2372, 2333, 4765, 4766, 4767, 4687
1672, 2333, 2372, 2373, 2334, 4767, 4768, 4769, 4689
1673, 2334, 2373, 2374, 2335, 4769, 4770, 4771, 4691
1674, 2335, 2374, 2375, 2336, 4771, 4772, 4773, 4693
1675, 2336, 2375, 2376, 2337, 4773, 4774, 4775, 4695
1676, 2337, 2376, 2377, 2338, 4775, 4776, 4777, 4697
1677, 2338, 2377, 206, 207, 4777, 4778, 246, 4699
1678, 52, 53, 2378, 2339, 92, 4779, 4780, 4700
1679, 2339, 2378, 2379, 2340, 4780, 4781, 4782, 4702
1680, 2340, 2379, 2380, 2341, 4782, 4783, 4784, 4704
1681, 2341, 2380, 2381, 2342, 4784, 4785, 4786, 4706
1682, 2342, 2381, 2382, 2343, 4786, 4787, 4788, 4708
1683, 2343, 2382, 2383, 2344, 4788, 4789, 4790, 4710
1684, 2344, 2383, 2384, 2345, 4790, 4791, 4792, 4712
1685, 2345, 2384, 2385, 2346, 4792, 4793, 4794, 4714
1686, 2346, 2385, 2386, 2347, 4794, 4795, 4796, 4716
1687, 2347, 2386, 2387, 2348, 4796, 4797, 4798, 4718
1688, 2348, 2387, 2388, 2349, 4798, 4799, 4800, 4720
1689, 2349, 2388, 2389, 2350, 4800, 4801, 4802, 4722
1690, 2350, 2389, 2390, 2351, 4802, 4803, 4804, 4724
1691, 2351, 2390, 2391, 2352, 4804, 4805, 4806, 4726
1692, 2352, 2391, 2392, 2353, 4806, 4807, 4808, 4728
1693, 2353, 2392, 2393, 2354, 4808, 4809, 4810, 4730
1694, 2354, 2393, 2394, 2355, 4810, 4811, 4812, 4732
1695, 2355, 2394, 2395, 2356, 4812, 4813, 4814, 4734
1696, 2356, 2395, 2396, 2357, 4814, 4815, 4816, 4736
1697, 2357, 2396, 2397, 2358, 4816, 4817, 4818, 4738
1698, 2358, 2397, 2398, 2359, 4818, 4819, 4820, 4740
1699, 2359, 2398, 2399, 2360, 4820, 4821, 4822, 4742
1700, 2360, 2399, 2400, 2361, 4822, 4823, 4824, 4744
1701, 2361, 2400, 2401, 2362, 4824, 4825, 4826, 4746
1702, 2362, 2401, 2402, 2363, 4826, 4827, 4828, 4748
1703, 2363, 2402, 2403, 2364, 4828, 4829, 4830, 4750
1704, 2364, 2403, 2404, 2365, 4830, 4831, 4832, 4752
1705, 2365, 2404, 2405, 2366, 4832, 4833, 4834, 4754
1706, 2366, 2405, 2406, 2367, 4834, 4835, 4836, 4756
1707, 2367, 2406, 2407, 2368, 4836, 4837, 4838, 4758
1708, 2368, 2407, 2408, 2369, 4838, 4839, 4840, 4760
1709, 2369, 2408, 2409, 2370, 4840, 4841, 4842, 4762
1710, 2370, 2409, 2410, 2371, 4842, 4843, 4844, 4764
1711, 2371, 2410, 2411, 2372, 4844, 4845, 4846, 4766
1712, 2372, 2411, 2412, 2373, 4846, 4847, 4848, 4768
1713, 2373, 2412, 2413, 2374, 4848, 4849, 4850, 4770
1714, 2374, 2413, 2414, 2375, 4850, 4851, 4852, 4772
1715, 2375, 2414, 2415, 2376, 4852, 4853, 4854, 4774
1716, 2376, 2415, 2416, 2377, 4854, 4855, 4856, 4776
1717, 2377, 2416, 205, 206, 4856, 4857, 245, 4778
1718, 53, 54, 2417, 2378, 93, 4858, 4859, 4779
1719, 2378, 2417, 2418, 2379, 4859, 4860, 4861, 4781
1720, 2379, 2418, 2419, 2380, 4861, 4862, 4863, 4783
1721, 2380, 2419, 2420, 2381, 4863, 4864, 4865, 4785
1722, 2381, 2420, 2421, 2382, 4865, 4866, 4867, 4787
1723, 2382, 2421, 2422, 2383, 4867, 4868, 4869, 4789
1724, 2383, 2422, 2423, 2384, 4869, 4870, 4871, 4791
1725, 2384, 2423, 2424, 2385, 4871, 4872, 4873, 4793
1726, 2385, 2424, 2425, 2386, 4873, 4874, 4875, 4795
1727, 2386, 2425, 2426, 2387, 4875, 4876, 4877, 4797
1728, 2387, 2426, 2427, 2388, 4877, 4878, 4879, 4799
1729, 2388, 2427, 2428, 2389, 4879, 4880, 4881, 4801
1730, 2389, 2428, 2429, 2390, 4881, 4882, 4883, 4803
1731, 2390, 2429, 2430, 2391, 4883, 4884, 4885, 4805
1732, 2391, 2430, 2431, 2392, 4885, 4886, 4887, 4807
1733, 2392, 2431, 2432, 2393, 4887, 4888, 4889, 4809
1734, 2393, 2432, 2433, 2394, 4889, 4890, 4891, 4811
1735, 2394, 2433, 2434, 2395, 4891, 4892, 4893, 4813
1736, 2395, 2434, 2435, 2396, 4893, 4894, 4895, 4815
1737, 2396, 2435, 2436, 2397, 4895, 4896, 4897, 4817
1738, 2397, 2436, 2437, 2398, 4897, 4898, 4899, 4819
1739, 2398, 2437, 2438, 2399, 4899, 4900, 4901, 4821
1740, 2399, 2438, 2439, 2400, 4901, 4902, 4903, 4823
1741, 2400, 2439, 2440, 2401, 4903, 4904, 4905, 4825
1742, 2401, 2440, 2441, 2402, 4905, 4906, 4907, 4827
1743, 2402, 2441, 2442, 2403, 4907, 4908, 4909, 4829
1744, 2403, 2442, 2443, 2404, 4909, 4910, 4911, 4831
1745, 2404, 2443, 2444, 2405, 4911, 4912, 4913, 4833
1746, 2405, 2444, 2445, 2406, 4913, 4914, 4915, 4835
1747, 2406, 2445, 2446, 2407, 4915, 4916, 4917, 4837
1748, 2407, 2446, 2447, 2408, 4917, 4918, 4919, 4839
1749, 2408, 2447, 2448, 2409, 4919, 4920, 4921, 4841
1750, 2409, 2448, 2449, 2410, 4921, 4922, 4923, 4843
1751, 2410, 2449, 2450, 2411, 4923, 4924, 4925, 4845
1752, 2411, 2450, 2451, 2412, 4925, 4926, 4927, 4847
1753, 2412, 2451, 2452, 2413, 4927, 4928, 4929, 4849
1754, 2413, 2452, 2453, 2414, 4929, 4930, 4931, 4851
1755, 2414, 2453, 2454, 2415, 4931, 4932, 4933, 4853
1756, 2415, 2454, 2455, 2416, 4933, 4934, 4935, 4855
1757, 2416, 2455, 204, 205, 4935, 4936, 244, 4857
1758, 54, 55, 2456, 2417, 94, 4937, 4938, 4858
1759, 2417, 2456, 2457, 2418, 4938, 4939, 4940, 4860
1760, 2418, 2457, 2458, 2419, 4940, 4941, 4942, 4862
1761, 2419, 2458, 2459, 2420, 4942, 4943, 4944, 4864
1762, 2420, 2459, 2460, 2421, 4944, 4945, 4946, 4866
1763, 2421, 2460, 2461, 2422, 4946, 4947, 4948, 4868
1764, 2422, 2461, 2462, 2423, 4948, 4949, 4950, 4870
1765, 2423, 2462, 2463, 2424, 4950, 4951, 4952, 4872
1766, 2424, 2463, 2464, 2425, 4952, 4953, 4954, 4874
1767, 2425, 2464, 2465, 2426, 4954, 4955, 4956, 4876
1768, 2426, 2465, 2466, 2427, 4956, 4957, 4958, 4878
1769, 2427, 2466, 2467, 2428, 4958, 4959, 4960, 4880
1770, 2428, 2467, 2468, 2429, 4960, 4961, 4962, 4882
1771, 2429, 2468, 2469, 2430, 4962, 4963, 4964, 4884
1772, 2430, 2469, 2470, 2431, 4964, 4965, 4966, 4886
1773, 2431, 2470, 2471, 2432, 4966, 4967, 4968, 4888
1774, 2432, 2471, 2472, 2433, 4968, 4969, 4970, 4890
1775, 2433, 2472, 2473, 2434, 4970, 4971, 4972, 4892
1776, 2434, 2473, 2474, 2435, 4972, 4973, 4974, 4894
1777, 2435, 2474, 2475, 2436, 4974, 4975, 4976, 4896
1778, 2436, 2475, 2476, 2437, 4976, 4977, 4978, 4898
1779, 2437, 2476, 2477, 2438, 4978, 4979, 4980, 4900
1780, 2438, 2477, 2478, 2439, 4980, 4981, 4982, 4902
1781, 2439, 2478, 2479, 2440, 4982, 4983, 4984, 4904
1782, 2440, 2479, 2480, 2441, 4984, 4985, 4986, 4906
1783, 2441, 2480, 2481, 2442, 4986, 4987, 4988, 4908
1784, 2442, 2481, 2482, 2443, 4988, 4989, 4990, 4910
1785, 2443, 2482, 2483, 2444, 4990, 4991, 4992, 4912
1786, 2444, 2483, 2484, 2445, 4992, 4993, 4994, 4914
1787, 2445, 2484, 2485, 2446, 4994, 4995, 4996, 4916
1788, 2446, 2485, 2486, 2447, 4996, 4997, 4998, 4918
1789, 2447, 2486, 2487, 2448, 4998, 4999, 5000, 4920
1790, 2448, 2487, 2488, 2449, 5000, 5001, 5002, 4922
1791, 2449, 2488, 2489, 2450, 5002, 5003, 5004, 4924
1792, 2450, 2489, 2490, 2451, 5004, 5005, 5006, 4926
1793, 2451, 2490, 2491, 2452, 5006, 5007, 5008, 4928
1794, 2452, 2491, 2492, 2453, 5008, 5009, 5010, 4930
1795, 2453, 2492, 2493, 2454, 5010, 5011, 5012, 4932
1796, 2454, 2493, 2494, 2455, 5012, 5013, 5014, 4934
1797, 2455, 2494, 203, 204, 5014, 5015, 243, 4936
1798, 55, 56, 2495, 2456, 95, 5016, 5017, 4937
1799, 2456, 2495, 2496, 2457, 5017, 5018, 5019, 4939
1800, 2457, 2496, 2497, 2458, 5019, 5020, 5021, 4941
1801, 2458, 2497, 2498, 2459, 5021, 5022, 5023, 4943
1802, 2459, 2498, 2499, 2460, 5023, 5024, 5025, 4945
1803, 2460, 2499, 2500, 2461, 5025, 5026, 5027, 4947
1804, 2461, 2500, 2501, 2462, 5027, 5028, 5029, 4949
1805, 2462, 2501, 2502, 2463, 5029, 5030, 5031, 4951
1806, 2463, 2502, 2503, 2464, 5031, 5032, 5033, 4953
1807, 2464, 2503, 2504, 2465, 5033, 5034, 5035, 4955
1808, 2465, 2504, 2505, 2466, 5035, 5036, 5037, 4957
1809, 2466, 2505, 2506, 2467, 5037, 5038, 5039, 4959
1810, 2467, 2506, 2507, 2468, 5039, 5040, 5041, 4961
1811, 2468, 2507, 2508, 2469, 5041, 5042, 5043, 4963
1812, 2469, 2508, 2509, 2470, 5043, 5044, 5045, 4965
1813, 2470, 2509, 2510, 2471, 5045, 5046, 5047, 4967
1814, 2471, 2510, 2511, 2472, 5047, 5048, 5049, 4969
1815, 2472, 2511, 2512, 2473, 5049, 5050, 5051, 4971
1816, 2473, 2512, 2513, 2474, 5051, 5052, 5053, 4973
1817, 2474, 2513, 2514, 2475, 5053, 5054, 5055, 4975
1818, 2475, 2514, 2515, 2476, 5055, 5056, 5057, 4977
1819, 2476, 2515, 2516, 2477, 5057, 5058, 5059, 4979
1820, 2477, 2516, 2517, 2478, 5059, 5060, 5061, 4981
1821, 2478, 2517, 2518, 2479, 5061, 5062, 5063, 4983
1822, 2479, 2518, 2519, 2480, 5063, 5064, 5065, 4985
1823, 2480, 2519, 2520, 2481, 5065, 5066, 5067, 4987
1824, 2481, 2520, 2521, 2482, 5067, 5068, 5069, 4989
1825, 2482, 2521, 2522, 2483, 5069, 5070, 5071, 4991
1826, 2483, 2522, 2523, 2484, 5071, 5072, 5073, 4993
1827, 2484, 2523, 2524, 2485, 5073, 5074, 5075, 4995
1828, 2485, 2524, 2525, 2486, 5075, 5076, 5077, 4997
1829, 2486, 2525, 2526, 2487, 5077, 5078, 5079, 4999
1830, 2487, 2526, 2527, 2488, 5079, 5080, 5081, 5001
1831, 2488, 2527, 2528, 2489, 5081, 5082, 5083, 5003
1832, 2489, 2528, 2529, 2490, 5083, 5084, 5085, 5005
1833, 2490, 2529, 2530, 2491, 5085, 5086, 5087, 5007
1834, 2491, 2530, 2531, 2492, 5087, 5088, 5089, 5009
1835, 2492, 2531, 2532, 2493, 5089, 5090, 5091, 5011
1836, 2493, 2532, 2533, 2494, 5091, 5092, 5093, 5013
1837, 2494, 2533, 202, 203, 5093, 5094, 242, 5015
1838, 56, 57, 2534, 2495, 96, 5095, 5096, 5016
1839, 2495, 2534, 2535, 2496, 5096, 5097, 5098, 5018
1840, 2496, 2535, 2536, 2497, 5098, 5099, 5100, 5020
1841, 2497, 2536, 2537, 2498, 5100, 5101, 5102, 5022
1842, 2498, 2537, 2538, 2499, 5102, 5103, 5104, 5024
1843, 2499, 2538, 2539, 2500, 5104, 5105, 5106, 5026
1844, 2500, 2539, 2540, 2501, 5106, 5107, 5108, 5028
1845, 2501, 2540, 2541, 2502, 5108, 5109, 5110, 5030
1846, 2502, 2541, 2542, 2503, 5110, 5111, 5112, 5032
1847, 2503, 2542, 2543, 2504, 5112, 5113, 5114, 5034
1848, 2504, 2543, 2544, 2505, 5114, 5115, 5116, 5036
1849, 2505, 2544, 2545, 2506, 5116, 5117, 5118, 5038
1850, 2506, 2545, 2546, 2507, 5118, 5119, 5120, 5040
1851, 2507, 2546, 2547, 2508, 5120, 5121, 5122, 5042
1852, 2508, 2547, 2548, 2509, 5122, 5123, 5124, 5044
1853, 2509, 2548, 2549, 2510, 5124, 5125, 5126, 5046
1854, 2510, 2549, 2550, 2511, 5126, 5127, 5128, 5048
1855, 2511, 2550, 2551, 2512, 5128, 5129, 5130, 5050
1856, 2512, 2551, 2552, 2513, 5130, 5131, 5132, 5052
1857, 2513, 2552, 2553, 2514, 5132, 5133, 5134, 5054
1858, 2514, 2553, 2554, 2515, 5134, 5135, 5136, 5056
1859, 2515, 2554, 2555, 2516, 5136, 5137, 5138, 5058
1860, 2516, 2555, 2556, 2517, 5138, 5139, 5140, 5060
1861, 2517, 2556, 2557, 2518, 5140, 5141, 5142, 5062
1862, 2518, 2557, 2558, 2519, 5142, 5143, 5144, 5064
1863, 2519, 2558, 2559, 2520, 5144, 5145, 5146, 5066
1864, 2520, 2559, 2560, 2521, 5146, 5147, 5148, 5068
1865, 2521, 2560, 2561, 2522, 5148, 5149, 5150, 5070
1866, 2522, 2561, 2562, 2523, 5150, 5151, 5152, 5072
1867, 2523, 2562, 2563, 2524, 5152, 5153, 5154, 5074
1868, 2524, 2563, 2564, 2525, 5154, 5155, 5156, 5076
1869, 2525, 2564, 2565, 2526, 5156, 5157, 5158, 5078
1870, 2526, 2565, 2566, 2527, 5158, 5159, 5160, 5080
1871, 2527, 2566, 2567, 2528, 5160, 5161, 5162, 5082
1872, 2528, 2567, 2568, 2529, 5162, 5163, 5164, 5084
1873, 2529, 2568, 2569, 2530, 5164, 5165, 5166, 5086
1874, 2530, 2569, 2570, 2531, 5166, 5167, 5168, 5088
1875, 2531, 2570, 2571, 2532, 5168, 5169, 5170, 5090
1876, 2532, 2571, 2572, 2533, 5170, 5171, 5172, 5092
1877, 2533, 2572, 201, 202, 5172, 5173, 241, 5094
1878, 57, 58, 2573, 2534, 97, 5174, 5175, 5095
1879, 2534, 2573, 2574, 2535, 5175, 5176, 5177, 5097
1880, 2535, 2574, 2575, 2536, 5177, 5178, 5179, 5099
1881, 2536, 2575, 2576, 2537, 5179, 5180, 5181, 5101
1882, 2537, 2576, 2577, 2538, 5181, 5182, 5183, 5103
1883, 2538, 2577, 2578, 2539, 5183, 5184, 5185, 5105
1884, 2539, 2578, 2579, 2540, 5185, 5186, 5187, 5107
1885, 2540, 2579, 2580, 2541, 5187, 5188, 5189, 5109
1886, 2541, 2580, 2581, 2542, 5189, 5190, 5191, 5111
1887, 2542, 2581, 2582, 2543, 5191, 5192, 5193, 5113
1888, 2543, 2582, 2583, 2544, 5193, 5194, 5195, 5115
1889, 2544, 2583, 2584, 2545, 5195, 5196, 5197, 5117
1890, 2545, 2584, 2585, 2546, 5197, 5198, 5199, 5119
1891, 2546, 2585, 2586, 2547, 5199, 5200, 5201, 5121
1892, 2547, 2586, 2587, 2548, 5201, 5202, 5203, 5123
1893, 2548, 2587, 2588, 2549, 5203, 5204, 5205, 5125
1894, 2549, 2588, 2589, 2550, 5205, 5206, 5207, 5127
1895, 2550, 2589, 2590, 2551, 5207, 5208, 5209, 5129
1896, 2551, 2590, 2591, 2552, 5209, 5210, 5211, 5131
1897, 2552, 2591, 2592, 2553, 5211, 5212, 5213, 5133
1898, 2553, 2592, 2593, 2554, 5213, 5214, 5215, 5135
1899, 2554, 2593, 2594, 2555, 5215, 5216, 5217, 5137
1900, 2555, 2594, 2595, 2556, 5217, 5218, 5219, 5139
1901, 2556, 2595, 2596, 2557, 5219, 5220, 5221, 5141
1902, 2557, 2596, 2597, 2558, 5221, 5222, 5223, 5143
1903, 2558, 2597, 2598, 2559, 5223, 5224, 5225, 5145
1904, 2559, 2598, 2599, 2560, 5225, 5226, 5227, 5147
1905, 2560, 2599, 2600, 2561, 5227, 5228, 5229, 5149
1906, 2561, 2600, 2601, 2562, 5229, 5230, 5231, 5151
1907, 2562, 2601, 2602, 2563, 5231, 5232, 5233, 5153
1908, 2563, 2602, 2603, 2564, 5233, 5234, 5235, 5155
1909, 2564, 2603, 2604, 2565, 5235, 5236, 5237, 5157
1910, 2565, 2604, 2605, 2566, 5237, 5238, 5239, 5159
1911, 2566, 2605, 2606, 2567, 5239, 5240, 5241, 5161
1912, 2567, 2606, 2607, 2568, 5241, 5242, 5243, 5163
1913, 2568, 2607, 2608, 2569, 5243, 5244, 5245, 5165
1914, 2569, 2608, 2609, 2570, 5245, 5246, 5247, 5167
1915, 2570, 2609, 2610, 2571, 5247, 5248, 5249, 5169
1916, 2571, 2610, 2611, 2572, 5249, 5250, 5251, 5171
1917, 2572, 2611, 200, 201, 5251, 5252, 240, 5173
1918, 58, 59, 2612, 2573, 98, 5253, 5254, 5174
1919, 2573, 2612, 2613, 2574, 5254, 5255, 5256, 5176
1920, 2574, 2613, 2614, 2575, 5256, 5257, 5258, 5178
1921, 2575, 2614, 2615, 2576, 5258, 5259, 5260, 5180
1922, 2576, 2615, 2616, 2577, 5260, 5261, 5262, 5182
1923, 2577, 2616, 2617, 2578, 5262, 5263, 5264, 5184
1924, 2578, 2617, 2618, 2579, 5264, 5265, 5266, 5186
1925, 2579, 2618, 2619, 2580, 5266, 5267, 5268, 5188
1926, 2580, 2619, 2620, 2581, 5268, 5269, 5270, 5190
1927, 2581, 2620, 2621, 2582, 5270, 5271, 5272, 5192
1928, 2582, 2621, 2622, 2583, 5272, 5273, 5274, 5194
1929, 2583, 2622, 2623, 2584, 5274, 5275, 5276, 5196
1930, 2584, 2623, 2624, 2585, 5276, 5277, 5278, 5198
1931, 2585, 2624, 2625, 2586, 5278, 5279, 5280, 5200
1932, 2586, 2625, 2626, 2587, 5280, 5281, 5282, 5202
1933, 2587, 2626, 2627, 2588, 5282, 5283, 5284, 5204
1934, 2588, 2627, 2628, 2589, 5284, 5285, 5286, 5206
1935, 2589, 2628, 2629, 2590, 5286, 5287, 5288, 5208
1936, 2590, 2629, 2630, 2591, 5288, 5289, 5290, 5210
1937, 2591, 2630, 2631, 2592, 5290, 5291, 5292, 5212
1938, 2592, 2631, 2632, 2593, 5292, 5293, 5294, 5214
1939, 2593, 2632, 2633, 2594, 5294, 5295, 5296, 5216
1940, 2594, 2633, 2634, 2595, 5296, 5297, 5298, 5218
1941, 2595, 2634, 2635, 2596, 5298, 5299, 5300, 5220
1942, 2596, 2635, 2636, 2597, 5300, 5301, 5302, 5222
1943, 2597, 2636, 2637, 2598, 5302, 5303, 5304, 5224
1944, 2598, 2637, 2638, 2599, 5304, 5305, 5306, 5226
1945, 2599, 2638, 2639, 2600, 5306, 5307, 5308, 5228
1946, 2600, 2639, 2640, 2601, 5308, 5309, 5310, 5230
1947, 2601, 2640, 2641, 2602, 5310, 5311, 5312, 5232
1948, 2602, 2641, 2642, 2603, 5312, 5313, 5314, 5234
1949, 2603, 2642, 2643, 2604, 5314, 5315, 5316, 5236
1950, 2604, 2643, 2644, 2605, 5316, 5317, 5318, 5238
1951, 2605, 2644, 2645, 2606, 5318, 5319, 5320, 5240
1952, 2606, 2645, 2646, 2607, 5320, 5321, 5322, 5242
1953, 2607, 2646, 2647, 2608, 5322, 5323, 5324, 5244
1954, 2608, 2647, 2648, 2609, 5324, 5325, 5326, 5246
1955, 2609, 2648, 2649, 2610, 5326, 5327, 5328, 5248
1956, 2610, 2649, 2650, 2611, 5328, 5329, 5330, 5250
1957, 2611, 2650, 199, 200, 5330, 5331, 239, 5252
1958, 59, 60, 2651, 2612, 99, 5332, 5333, 5253
1959, 2612, 2651, 2652, 2613, 5333, 5334, 5335, 5255
1960, 2613, 2652, 2653, 2614, 5335, 5336, 5337, 5257
1961, 2614, 2653, 2654, 2615, 5337, 5338, 5339, 5259
1962, 2615, 2654, 2655, 2616, 5339, 5340, 5341, 5261
1963, 2616, 2655, 2656, 2617, 5341, 5342, 5343, 5263
1964, 2617, 2656, 2657, 2618, 5343, 5344, 5345, 5265
1965, 2618, 2657, 2658, 2619, 5345, 5346, 5347, 5267
1966, 2619, 2658, 2659, 2620, 5347, 5348, 5349, 5269
1967, 2620, 2659, 2660, 2621, 5349, 5350, 5351, 5271
1968, 2621, 2660, 2661, 2622, 5351, 5352, 5353, 5273
1969, 2622, 2661, 2662, 2623, 5353, 5354, 5355, 5275
1970, 2623, 2662, 2663, 2624, 5355, 5356, 5357, 5277
1971, 2624, 2663, 2664, 2625, 5357, 5358, 5359, 5279
1972, 2625, 2664, 2665, 2626, 5359, 5360, 5361, 5281
1973, 2626, 2665, 2666, 2627, 5361, 5362, 5363, 5283
1974, 2627, 2666, 2667, 2628, 5363, 5364, 5365, 5285
1975, 2628, 2667, 2668, 2629, 5365, 5366, 5367, 5287
1976, 2629, 2668, 2669, 2630, 5367, 5368, 5369, 5289
1977, 2630, 2669, 2670, 2631, 5369, 5370, 5371, 5291
1978, 2631, 2670, 2671, 2632, 5371, 5372, 5373, 5293
1979, 2632, 2671, 2672, 2633, 5373, 5374, 5375, 5295
1980, 2633, 2672, 2673, 2634, 5375, 5376, 5377, 5297
1981, 2634, 2673, 2674, 2635, 5377, 5378, 5379, 5299
1982, 2635, 2674, 2675, 2636, 5379, 5380, 5381, 5301
1983, 2636, 2675, 2676, 2637, 5381, 5382, 5383, 5303
1984, 2637, 2676, 2677, 2638, 5383, 5384, 5385, 5305
1985, 2638, 2677, 2678, 2639, 5385, 5386, 5387, 5307
1986, 2639, 2678, 2679, 2640, 5387, 5388, 5389, 5309
1987, 2640, 2679, 2680, 2641, 5389, 5390, 5391, 5311
1988, 2641, 2680, 2681, 2642, 5391, 5392, 5393, 5313
1989, 2642, 2681, 2682, 2643, 5393, 5394, 5395, 5315
1990, 2643, 2682, 2683, 2644, 5395, 5396, 5397, 5317
1991, 2644, 2683, 2684, 2645, 5397, 5398, 5399, 5319
1992, 2645, 2684, 2685, 2646, 5399, 5400, 5401, 5321
1993, 2646, 2685, 2686, 2647, 5401, 5402, 5403, 5323
