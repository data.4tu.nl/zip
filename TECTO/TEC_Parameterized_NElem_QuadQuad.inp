1994, 2647, 2686, 2687, 2648, 5403, 5404, 5405, 5325
1995, 2648, 2687, 2688, 2649, 5405, 5406, 5407, 5327
1996, 2649, 2688, 2689, 2650, 5407, 5408, 5409, 5329
1997, 2650, 2689, 198, 199, 5409, 5410, 238, 5331
1998, 60, 61, 2690, 2651, 100, 5411, 5412, 5332
1999, 2651, 2690, 2691, 2652, 5412, 5413, 5414, 5334
2000, 2652, 2691, 2692, 2653, 5414, 5415, 5416, 5336
2001, 2653, 2692, 2693, 2654, 5416, 5417, 5418, 5338
2002, 2654, 2693, 2694, 2655, 5418, 5419, 5420, 5340
2003, 2655, 2694, 2695, 2656, 5420, 5421, 5422, 5342
2004, 2656, 2695, 2696, 2657, 5422, 5423, 5424, 5344
2005, 2657, 2696, 2697, 2658, 5424, 5425, 5426, 5346
2006, 2658, 2697, 2698, 2659, 5426, 5427, 5428, 5348
2007, 2659, 2698, 2699, 2660, 5428, 5429, 5430, 5350
2008, 2660, 2699, 2700, 2661, 5430, 5431, 5432, 5352
2009, 2661, 2700, 2701, 2662, 5432, 5433, 5434, 5354
2010, 2662, 2701, 2702, 2663, 5434, 5435, 5436, 5356
2011, 2663, 2702, 2703, 2664, 5436, 5437, 5438, 5358
2012, 2664, 2703, 2704, 2665, 5438, 5439, 5440, 5360
2013, 2665, 2704, 2705, 2666, 5440, 5441, 5442, 5362
2014, 2666, 2705, 2706, 2667, 5442, 5443, 5444, 5364
2015, 2667, 2706, 2707, 2668, 5444, 5445, 5446, 5366
2016, 2668, 2707, 2708, 2669, 5446, 5447, 5448, 5368
2017, 2669, 2708, 2709, 2670, 5448, 5449, 5450, 5370
2018, 2670, 2709, 2710, 2671, 5450, 5451, 5452, 5372
2019, 2671, 2710, 2711, 2672, 5452, 5453, 5454, 5374
2020, 2672, 2711, 2712, 2673, 5454, 5455, 5456, 5376
2021, 2673, 2712, 2713, 2674, 5456, 5457, 5458, 5378
2022, 2674, 2713, 2714, 2675, 5458, 5459, 5460, 5380
2023, 2675, 2714, 2715, 2676, 5460, 5461, 5462, 5382
2024, 2676, 2715, 2716, 2677, 5462, 5463, 5464, 5384
2025, 2677, 2716, 2717, 2678, 5464, 5465, 5466, 5386
2026, 2678, 2717, 2718, 2679, 5466, 5467, 5468, 5388
2027, 2679, 2718, 2719, 2680, 5468, 5469, 5470, 5390
2028, 2680, 2719, 2720, 2681, 5470, 5471, 5472, 5392
2029, 2681, 2720, 2721, 2682, 5472, 5473, 5474, 5394
2030, 2682, 2721, 2722, 2683, 5474, 5475, 5476, 5396
2031, 2683, 2722, 2723, 2684, 5476, 5477, 5478, 5398
2032, 2684, 2723, 2724, 2685, 5478, 5479, 5480, 5400
2033, 2685, 2724, 2725, 2686, 5480, 5481, 5482, 5402
2034, 2686, 2725, 2726, 2687, 5482, 5483, 5484, 5404
2035, 2687, 2726, 2727, 2688, 5484, 5485, 5486, 5406
2036, 2688, 2727, 2728, 2689, 5486, 5487, 5488, 5408
2037, 2689, 2728, 197, 198, 5488, 5489, 237, 5410
2038, 61, 62, 2729, 2690, 101, 5490, 5491, 5411
2039, 2690, 2729, 2730, 2691, 5491, 5492, 5493, 5413
2040, 2691, 2730, 2731, 2692, 5493, 5494, 5495, 5415
2041, 2692, 2731, 2732, 2693, 5495, 5496, 5497, 5417
2042, 2693, 2732, 2733, 2694, 5497, 5498, 5499, 5419
2043, 2694, 2733, 2734, 2695, 5499, 5500, 5501, 5421
2044, 2695, 2734, 2735, 2696, 5501, 5502, 5503, 5423
2045, 2696, 2735, 2736, 2697, 5503, 5504, 5505, 5425
2046, 2697, 2736, 2737, 2698, 5505, 5506, 5507, 5427
2047, 2698, 2737, 2738, 2699, 5507, 5508, 5509, 5429
2048, 2699, 2738, 2739, 2700, 5509, 5510, 5511, 5431
2049, 2700, 2739, 2740, 2701, 5511, 5512, 5513, 5433
2050, 2701, 2740, 2741, 2702, 5513, 5514, 5515, 5435
2051, 2702, 2741, 2742, 2703, 5515, 5516, 5517, 5437
2052, 2703, 2742, 2743, 2704, 5517, 5518, 5519, 5439
2053, 2704, 2743, 2744, 2705, 5519, 5520, 5521, 5441
2054, 2705, 2744, 2745, 2706, 5521, 5522, 5523, 5443
2055, 2706, 2745, 2746, 2707, 5523, 5524, 5525, 5445
2056, 2707, 2746, 2747, 2708, 5525, 5526, 5527, 5447
2057, 2708, 2747, 2748, 2709, 5527, 5528, 5529, 5449
2058, 2709, 2748, 2749, 2710, 5529, 5530, 5531, 5451
2059, 2710, 2749, 2750, 2711, 5531, 5532, 5533, 5453
2060, 2711, 2750, 2751, 2712, 5533, 5534, 5535, 5455
2061, 2712, 2751, 2752, 2713, 5535, 5536, 5537, 5457
2062, 2713, 2752, 2753, 2714, 5537, 5538, 5539, 5459
2063, 2714, 2753, 2754, 2715, 5539, 5540, 5541, 5461
2064, 2715, 2754, 2755, 2716, 5541, 5542, 5543, 5463
2065, 2716, 2755, 2756, 2717, 5543, 5544, 5545, 5465
2066, 2717, 2756, 2757, 2718, 5545, 5546, 5547, 5467
2067, 2718, 2757, 2758, 2719, 5547, 5548, 5549, 5469
2068, 2719, 2758, 2759, 2720, 5549, 5550, 5551, 5471
2069, 2720, 2759, 2760, 2721, 5551, 5552, 5553, 5473
2070, 2721, 2760, 2761, 2722, 5553, 5554, 5555, 5475
2071, 2722, 2761, 2762, 2723, 5555, 5556, 5557, 5477
2072, 2723, 2762, 2763, 2724, 5557, 5558, 5559, 5479
2073, 2724, 2763, 2764, 2725, 5559, 5560, 5561, 5481
2074, 2725, 2764, 2765, 2726, 5561, 5562, 5563, 5483
2075, 2726, 2765, 2766, 2727, 5563, 5564, 5565, 5485
2076, 2727, 2766, 2767, 2728, 5565, 5566, 5567, 5487
2077, 2728, 2767, 196, 197, 5567, 5568, 236, 5489
2078, 62, 63, 2768, 2729, 102, 5569, 5570, 5490
2079, 2729, 2768, 2769, 2730, 5570, 5571, 5572, 5492
2080, 2730, 2769, 2770, 2731, 5572, 5573, 5574, 5494
2081, 2731, 2770, 2771, 2732, 5574, 5575, 5576, 5496
2082, 2732, 2771, 2772, 2733, 5576, 5577, 5578, 5498
2083, 2733, 2772, 2773, 2734, 5578, 5579, 5580, 5500
2084, 2734, 2773, 2774, 2735, 5580, 5581, 5582, 5502
2085, 2735, 2774, 2775, 2736, 5582, 5583, 5584, 5504
2086, 2736, 2775, 2776, 2737, 5584, 5585, 5586, 5506
2087, 2737, 2776, 2777, 2738, 5586, 5587, 5588, 5508
2088, 2738, 2777, 2778, 2739, 5588, 5589, 5590, 5510
2089, 2739, 2778, 2779, 2740, 5590, 5591, 5592, 5512
2090, 2740, 2779, 2780, 2741, 5592, 5593, 5594, 5514
2091, 2741, 2780, 2781, 2742, 5594, 5595, 5596, 5516
2092, 2742, 2781, 2782, 2743, 5596, 5597, 5598, 5518
2093, 2743, 2782, 2783, 2744, 5598, 5599, 5600, 5520
2094, 2744, 2783, 2784, 2745, 5600, 5601, 5602, 5522
2095, 2745, 2784, 2785, 2746, 5602, 5603, 5604, 5524
2096, 2746, 2785, 2786, 2747, 5604, 5605, 5606, 5526
2097, 2747, 2786, 2787, 2748, 5606, 5607, 5608, 5528
2098, 2748, 2787, 2788, 2749, 5608, 5609, 5610, 5530
2099, 2749, 2788, 2789, 2750, 5610, 5611, 5612, 5532
2100, 2750, 2789, 2790, 2751, 5612, 5613, 5614, 5534
2101, 2751, 2790, 2791, 2752, 5614, 5615, 5616, 5536
2102, 2752, 2791, 2792, 2753, 5616, 5617, 5618, 5538
2103, 2753, 2792, 2793, 2754, 5618, 5619, 5620, 5540
2104, 2754, 2793, 2794, 2755, 5620, 5621, 5622, 5542
2105, 2755, 2794, 2795, 2756, 5622, 5623, 5624, 5544
2106, 2756, 2795, 2796, 2757, 5624, 5625, 5626, 5546
2107, 2757, 2796, 2797, 2758, 5626, 5627, 5628, 5548
2108, 2758, 2797, 2798, 2759, 5628, 5629, 5630, 5550
2109, 2759, 2798, 2799, 2760, 5630, 5631, 5632, 5552
2110, 2760, 2799, 2800, 2761, 5632, 5633, 5634, 5554
2111, 2761, 2800, 2801, 2762, 5634, 5635, 5636, 5556
2112, 2762, 2801, 2802, 2763, 5636, 5637, 5638, 5558
2113, 2763, 2802, 2803, 2764, 5638, 5639, 5640, 5560
2114, 2764, 2803, 2804, 2765, 5640, 5641, 5642, 5562
2115, 2765, 2804, 2805, 2766, 5642, 5643, 5644, 5564
2116, 2766, 2805, 2806, 2767, 5644, 5645, 5646, 5566
2117, 2767, 2806, 195, 196, 5646, 5647, 235, 5568
2118, 63, 64, 2807, 2768, 103, 5648, 5649, 5569
2119, 2768, 2807, 2808, 2769, 5649, 5650, 5651, 5571
2120, 2769, 2808, 2809, 2770, 5651, 5652, 5653, 5573
2121, 2770, 2809, 2810, 2771, 5653, 5654, 5655, 5575
2122, 2771, 2810, 2811, 2772, 5655, 5656, 5657, 5577
2123, 2772, 2811, 2812, 2773, 5657, 5658, 5659, 5579
2124, 2773, 2812, 2813, 2774, 5659, 5660, 5661, 5581
2125, 2774, 2813, 2814, 2775, 5661, 5662, 5663, 5583
2126, 2775, 2814, 2815, 2776, 5663, 5664, 5665, 5585
2127, 2776, 2815, 2816, 2777, 5665, 5666, 5667, 5587
2128, 2777, 2816, 2817, 2778, 5667, 5668, 5669, 5589
2129, 2778, 2817, 2818, 2779, 5669, 5670, 5671, 5591
2130, 2779, 2818, 2819, 2780, 5671, 5672, 5673, 5593
2131, 2780, 2819, 2820, 2781, 5673, 5674, 5675, 5595
2132, 2781, 2820, 2821, 2782, 5675, 5676, 5677, 5597
2133, 2782, 2821, 2822, 2783, 5677, 5678, 5679, 5599
2134, 2783, 2822, 2823, 2784, 5679, 5680, 5681, 5601
2135, 2784, 2823, 2824, 2785, 5681, 5682, 5683, 5603
2136, 2785, 2824, 2825, 2786, 5683, 5684, 5685, 5605
2137, 2786, 2825, 2826, 2787, 5685, 5686, 5687, 5607
2138, 2787, 2826, 2827, 2788, 5687, 5688, 5689, 5609
2139, 2788, 2827, 2828, 2789, 5689, 5690, 5691, 5611
2140, 2789, 2828, 2829, 2790, 5691, 5692, 5693, 5613
2141, 2790, 2829, 2830, 2791, 5693, 5694, 5695, 5615
2142, 2791, 2830, 2831, 2792, 5695, 5696, 5697, 5617
2143, 2792, 2831, 2832, 2793, 5697, 5698, 5699, 5619
2144, 2793, 2832, 2833, 2794, 5699, 5700, 5701, 5621
2145, 2794, 2833, 2834, 2795, 5701, 5702, 5703, 5623
2146, 2795, 2834, 2835, 2796, 5703, 5704, 5705, 5625
2147, 2796, 2835, 2836, 2797, 5705, 5706, 5707, 5627
2148, 2797, 2836, 2837, 2798, 5707, 5708, 5709, 5629
2149, 2798, 2837, 2838, 2799, 5709, 5710, 5711, 5631
2150, 2799, 2838, 2839, 2800, 5711, 5712, 5713, 5633
2151, 2800, 2839, 2840, 2801, 5713, 5714, 5715, 5635
2152, 2801, 2840, 2841, 2802, 5715, 5716, 5717, 5637
2153, 2802, 2841, 2842, 2803, 5717, 5718, 5719, 5639
2154, 2803, 2842, 2843, 2804, 5719, 5720, 5721, 5641
2155, 2804, 2843, 2844, 2805, 5721, 5722, 5723, 5643
2156, 2805, 2844, 2845, 2806, 5723, 5724, 5725, 5645
2157, 2806, 2845, 194, 195, 5725, 5726, 234, 5647
2158, 64, 65, 2846, 2807, 104, 5727, 5728, 5648
2159, 2807, 2846, 2847, 2808, 5728, 5729, 5730, 5650
2160, 2808, 2847, 2848, 2809, 5730, 5731, 5732, 5652
2161, 2809, 2848, 2849, 2810, 5732, 5733, 5734, 5654
2162, 2810, 2849, 2850, 2811, 5734, 5735, 5736, 5656
2163, 2811, 2850, 2851, 2812, 5736, 5737, 5738, 5658
2164, 2812, 2851, 2852, 2813, 5738, 5739, 5740, 5660
2165, 2813, 2852, 2853, 2814, 5740, 5741, 5742, 5662
2166, 2814, 2853, 2854, 2815, 5742, 5743, 5744, 5664
2167, 2815, 2854, 2855, 2816, 5744, 5745, 5746, 5666
2168, 2816, 2855, 2856, 2817, 5746, 5747, 5748, 5668
2169, 2817, 2856, 2857, 2818, 5748, 5749, 5750, 5670
2170, 2818, 2857, 2858, 2819, 5750, 5751, 5752, 5672
2171, 2819, 2858, 2859, 2820, 5752, 5753, 5754, 5674
2172, 2820, 2859, 2860, 2821, 5754, 5755, 5756, 5676
2173, 2821, 2860, 2861, 2822, 5756, 5757, 5758, 5678
2174, 2822, 2861, 2862, 2823, 5758, 5759, 5760, 5680
2175, 2823, 2862, 2863, 2824, 5760, 5761, 5762, 5682
2176, 2824, 2863, 2864, 2825, 5762, 5763, 5764, 5684
2177, 2825, 2864, 2865, 2826, 5764, 5765, 5766, 5686
2178, 2826, 2865, 2866, 2827, 5766, 5767, 5768, 5688
2179, 2827, 2866, 2867, 2828, 5768, 5769, 5770, 5690
2180, 2828, 2867, 2868, 2829, 5770, 5771, 5772, 5692
2181, 2829, 2868, 2869, 2830, 5772, 5773, 5774, 5694
2182, 2830, 2869, 2870, 2831, 5774, 5775, 5776, 5696
2183, 2831, 2870, 2871, 2832, 5776, 5777, 5778, 5698
2184, 2832, 2871, 2872, 2833, 5778, 5779, 5780, 5700
2185, 2833, 2872, 2873, 2834, 5780, 5781, 5782, 5702
2186, 2834, 2873, 2874, 2835, 5782, 5783, 5784, 5704
2187, 2835, 2874, 2875, 2836, 5784, 5785, 5786, 5706
2188, 2836, 2875, 2876, 2837, 5786, 5787, 5788, 5708
2189, 2837, 2876, 2877, 2838, 5788, 5789, 5790, 5710
2190, 2838, 2877, 2878, 2839, 5790, 5791, 5792, 5712
2191, 2839, 2878, 2879, 2840, 5792, 5793, 5794, 5714
2192, 2840, 2879, 2880, 2841, 5794, 5795, 5796, 5716
2193, 2841, 2880, 2881, 2842, 5796, 5797, 5798, 5718
2194, 2842, 2881, 2882, 2843, 5798, 5799, 5800, 5720
2195, 2843, 2882, 2883, 2844, 5800, 5801, 5802, 5722
2196, 2844, 2883, 2884, 2845, 5802, 5803, 5804, 5724
2197, 2845, 2884, 193, 194, 5804, 5805, 233, 5726
2198, 65, 66, 2885, 2846, 105, 5806, 5807, 5727
2199, 2846, 2885, 2886, 2847, 5807, 5808, 5809, 5729
2200, 2847, 2886, 2887, 2848, 5809, 5810, 5811, 5731
2201, 2848, 2887, 2888, 2849, 5811, 5812, 5813, 5733
2202, 2849, 2888, 2889, 2850, 5813, 5814, 5815, 5735
2203, 2850, 2889, 2890, 2851, 5815, 5816, 5817, 5737
2204, 2851, 2890, 2891, 2852, 5817, 5818, 5819, 5739
2205, 2852, 2891, 2892, 2853, 5819, 5820, 5821, 5741
2206, 2853, 2892, 2893, 2854, 5821, 5822, 5823, 5743
2207, 2854, 2893, 2894, 2855, 5823, 5824, 5825, 5745
2208, 2855, 2894, 2895, 2856, 5825, 5826, 5827, 5747
2209, 2856, 2895, 2896, 2857, 5827, 5828, 5829, 5749
2210, 2857, 2896, 2897, 2858, 5829, 5830, 5831, 5751
2211, 2858, 2897, 2898, 2859, 5831, 5832, 5833, 5753
2212, 2859, 2898, 2899, 2860, 5833, 5834, 5835, 5755
2213, 2860, 2899, 2900, 2861, 5835, 5836, 5837, 5757
2214, 2861, 2900, 2901, 2862, 5837, 5838, 5839, 5759
2215, 2862, 2901, 2902, 2863, 5839, 5840, 5841, 5761
2216, 2863, 2902, 2903, 2864, 5841, 5842, 5843, 5763
2217, 2864, 2903, 2904, 2865, 5843, 5844, 5845, 5765
2218, 2865, 2904, 2905, 2866, 5845, 5846, 5847, 5767
2219, 2866, 2905, 2906, 2867, 5847, 5848, 5849, 5769
2220, 2867, 2906, 2907, 2868, 5849, 5850, 5851, 5771
2221, 2868, 2907, 2908, 2869, 5851, 5852, 5853, 5773
2222, 2869, 2908, 2909, 2870, 5853, 5854, 5855, 5775
2223, 2870, 2909, 2910, 2871, 5855, 5856, 5857, 5777
2224, 2871, 2910, 2911, 2872, 5857, 5858, 5859, 5779
2225, 2872, 2911, 2912, 2873, 5859, 5860, 5861, 5781
2226, 2873, 2912, 2913, 2874, 5861, 5862, 5863, 5783
2227, 2874, 2913, 2914, 2875, 5863, 5864, 5865, 5785
2228, 2875, 2914, 2915, 2876, 5865, 5866, 5867, 5787
2229, 2876, 2915, 2916, 2877, 5867, 5868, 5869, 5789
2230, 2877, 2916, 2917, 2878, 5869, 5870, 5871, 5791
2231, 2878, 2917, 2918, 2879, 5871, 5872, 5873, 5793
2232, 2879, 2918, 2919, 2880, 5873, 5874, 5875, 5795
2233, 2880, 2919, 2920, 2881, 5875, 5876, 5877, 5797
2234, 2881, 2920, 2921, 2882, 5877, 5878, 5879, 5799
2235, 2882, 2921, 2922, 2883, 5879, 5880, 5881, 5801
2236, 2883, 2922, 2923, 2884, 5881, 5882, 5883, 5803
2237, 2884, 2923, 192, 193, 5883, 5884, 232, 5805
2238, 66, 67, 2924, 2885, 106, 5885, 5886, 5806
2239, 2885, 2924, 2925, 2886, 5886, 5887, 5888, 5808
2240, 2886, 2925, 2926, 2887, 5888, 5889, 5890, 5810
2241, 2887, 2926, 2927, 2888, 5890, 5891, 5892, 5812
2242, 2888, 2927, 2928, 2889, 5892, 5893, 5894, 5814
2243, 2889, 2928, 2929, 2890, 5894, 5895, 5896, 5816
2244, 2890, 2929, 2930, 2891, 5896, 5897, 5898, 5818
2245, 2891, 2930, 2931, 2892, 5898, 5899, 5900, 5820
2246, 2892, 2931, 2932, 2893, 5900, 5901, 5902, 5822
2247, 2893, 2932, 2933, 2894, 5902, 5903, 5904, 5824
2248, 2894, 2933, 2934, 2895, 5904, 5905, 5906, 5826
2249, 2895, 2934, 2935, 2896, 5906, 5907, 5908, 5828
2250, 2896, 2935, 2936, 2897, 5908, 5909, 5910, 5830
2251, 2897, 2936, 2937, 2898, 5910, 5911, 5912, 5832
2252, 2898, 2937, 2938, 2899, 5912, 5913, 5914, 5834
2253, 2899, 2938, 2939, 2900, 5914, 5915, 5916, 5836
2254, 2900, 2939, 2940, 2901, 5916, 5917, 5918, 5838
2255, 2901, 2940, 2941, 2902, 5918, 5919, 5920, 5840
2256, 2902, 2941, 2942, 2903, 5920, 5921, 5922, 5842
2257, 2903, 2942, 2943, 2904, 5922, 5923, 5924, 5844
2258, 2904, 2943, 2944, 2905, 5924, 5925, 5926, 5846
2259, 2905, 2944, 2945, 2906, 5926, 5927, 5928, 5848
2260, 2906, 2945, 2946, 2907, 5928, 5929, 5930, 5850
2261, 2907, 2946, 2947, 2908, 5930, 5931, 5932, 5852
2262, 2908, 2947, 2948, 2909, 5932, 5933, 5934, 5854
2263, 2909, 2948, 2949, 2910, 5934, 5935, 5936, 5856
2264, 2910, 2949, 2950, 2911, 5936, 5937, 5938, 5858
2265, 2911, 2950, 2951, 2912, 5938, 5939, 5940, 5860
2266, 2912, 2951, 2952, 2913, 5940, 5941, 5942, 5862
2267, 2913, 2952, 2953, 2914, 5942, 5943, 5944, 5864
2268, 2914, 2953, 2954, 2915, 5944, 5945, 5946, 5866
2269, 2915, 2954, 2955, 2916, 5946, 5947, 5948, 5868
2270, 2916, 2955, 2956, 2917, 5948, 5949, 5950, 5870
2271, 2917, 2956, 2957, 2918, 5950, 5951, 5952, 5872
2272, 2918, 2957, 2958, 2919, 5952, 5953, 5954, 5874
2273, 2919, 2958, 2959, 2920, 5954, 5955, 5956, 5876
2274, 2920, 2959, 2960, 2921, 5956, 5957, 5958, 5878
2275, 2921, 2960, 2961, 2922, 5958, 5959, 5960, 5880
2276, 2922, 2961, 2962, 2923, 5960, 5961, 5962, 5882
2277, 2923, 2962, 191, 192, 5962, 5963, 231, 5884
2278, 67, 68, 2963, 2924, 107, 5964, 5965, 5885
2279, 2924, 2963, 2964, 2925, 5965, 5966, 5967, 5887
2280, 2925, 2964, 2965, 2926, 5967, 5968, 5969, 5889
2281, 2926, 2965, 2966, 2927, 5969, 5970, 5971, 5891
2282, 2927, 2966, 2967, 2928, 5971, 5972, 5973, 5893
2283, 2928, 2967, 2968, 2929, 5973, 5974, 5975, 5895
2284, 2929, 2968, 2969, 2930, 5975, 5976, 5977, 5897
2285, 2930, 2969, 2970, 2931, 5977, 5978, 5979, 5899
2286, 2931, 2970, 2971, 2932, 5979, 5980, 5981, 5901
2287, 2932, 2971, 2972, 2933, 5981, 5982, 5983, 5903
2288, 2933, 2972, 2973, 2934, 5983, 5984, 5985, 5905
2289, 2934, 2973, 2974, 2935, 5985, 5986, 5987, 5907
2290, 2935, 2974, 2975, 2936, 5987, 5988, 5989, 5909
2291, 2936, 2975, 2976, 2937, 5989, 5990, 5991, 5911
2292, 2937, 2976, 2977, 2938, 5991, 5992, 5993, 5913
2293, 2938, 2977, 2978, 2939, 5993, 5994, 5995, 5915
2294, 2939, 2978, 2979, 2940, 5995, 5996, 5997, 5917
2295, 2940, 2979, 2980, 2941, 5997, 5998, 5999, 5919
2296, 2941, 2980, 2981, 2942, 5999, 6000, 6001, 5921
2297, 2942, 2981, 2982, 2943, 6001, 6002, 6003, 5923
2298, 2943, 2982, 2983, 2944, 6003, 6004, 6005, 5925
2299, 2944, 2983, 2984, 2945, 6005, 6006, 6007, 5927
2300, 2945, 2984, 2985, 2946, 6007, 6008, 6009, 5929
2301, 2946, 2985, 2986, 2947, 6009, 6010, 6011, 5931
2302, 2947, 2986, 2987, 2948, 6011, 6012, 6013, 5933
2303, 2948, 2987, 2988, 2949, 6013, 6014, 6015, 5935
2304, 2949, 2988, 2989, 2950, 6015, 6016, 6017, 5937
2305, 2950, 2989, 2990, 2951, 6017, 6018, 6019, 5939
2306, 2951, 2990, 2991, 2952, 6019, 6020, 6021, 5941
2307, 2952, 2991, 2992, 2953, 6021, 6022, 6023, 5943
2308, 2953, 2992, 2993, 2954, 6023, 6024, 6025, 5945
2309, 2954, 2993, 2994, 2955, 6025, 6026, 6027, 5947
2310, 2955, 2994, 2995, 2956, 6027, 6028, 6029, 5949
2311, 2956, 2995, 2996, 2957, 6029, 6030, 6031, 5951
2312, 2957, 2996, 2997, 2958, 6031, 6032, 6033, 5953
2313, 2958, 2997, 2998, 2959, 6033, 6034, 6035, 5955
2314, 2959, 2998, 2999, 2960, 6035, 6036, 6037, 5957
2315, 2960, 2999, 3000, 2961, 6037, 6038, 6039, 5959
2316, 2961, 3000, 3001, 2962, 6039, 6040, 6041, 5961
2317, 2962, 3001, 190, 191, 6041, 6042, 230, 5963
2318, 68, 69, 3002, 2963, 108, 6043, 6044, 5964
2319, 2963, 3002, 3003, 2964, 6044, 6045, 6046, 5966
2320, 2964, 3003, 3004, 2965, 6046, 6047, 6048, 5968
2321, 2965, 3004, 3005, 2966, 6048, 6049, 6050, 5970
2322, 2966, 3005, 3006, 2967, 6050, 6051, 6052, 5972
2323, 2967, 3006, 3007, 2968, 6052, 6053, 6054, 5974
2324, 2968, 3007, 3008, 2969, 6054, 6055, 6056, 5976
2325, 2969, 3008, 3009, 2970, 6056, 6057, 6058, 5978
2326, 2970, 3009, 3010, 2971, 6058, 6059, 6060, 5980
2327, 2971, 3010, 3011, 2972, 6060, 6061, 6062, 5982
2328, 2972, 3011, 3012, 2973, 6062, 6063, 6064, 5984
2329, 2973, 3012, 3013, 2974, 6064, 6065, 6066, 5986
2330, 2974, 3013, 3014, 2975, 6066, 6067, 6068, 5988
2331, 2975, 3014, 3015, 2976, 6068, 6069, 6070, 5990
2332, 2976, 3015, 3016, 2977, 6070, 6071, 6072, 5992
2333, 2977, 3016, 3017, 2978, 6072, 6073, 6074, 5994
2334, 2978, 3017, 3018, 2979, 6074, 6075, 6076, 5996
2335, 2979, 3018, 3019, 2980, 6076, 6077, 6078, 5998
2336, 2980, 3019, 3020, 2981, 6078, 6079, 6080, 6000
2337, 2981, 3020, 3021, 2982, 6080, 6081, 6082, 6002
2338, 2982, 3021, 3022, 2983, 6082, 6083, 6084, 6004
2339, 2983, 3022, 3023, 2984, 6084, 6085, 6086, 6006
2340, 2984, 3023, 3024, 2985, 6086, 6087, 6088, 6008
2341, 2985, 3024, 3025, 2986, 6088, 6089, 6090, 6010
2342, 2986, 3025, 3026, 2987, 6090, 6091, 6092, 6012
2343, 2987, 3026, 3027, 2988, 6092, 6093, 6094, 6014
2344, 2988, 3027, 3028, 2989, 6094, 6095, 6096, 6016
2345, 2989, 3028, 3029, 2990, 6096, 6097, 6098, 6018
2346, 2990, 3029, 3030, 2991, 6098, 6099, 6100, 6020
2347, 2991, 3030, 3031, 2992, 6100, 6101, 6102, 6022
2348, 2992, 3031, 3032, 2993, 6102, 6103, 6104, 6024
2349, 2993, 3032, 3033, 2994, 6104, 6105, 6106, 6026
2350, 2994, 3033, 3034, 2995, 6106, 6107, 6108, 6028
2351, 2995, 3034, 3035, 2996, 6108, 6109, 6110, 6030
2352, 2996, 3035, 3036, 2997, 6110, 6111, 6112, 6032
2353, 2997, 3036, 3037, 2998, 6112, 6113, 6114, 6034
2354, 2998, 3037, 3038, 2999, 6114, 6115, 6116, 6036
2355, 2999, 3038, 3039, 3000, 6116, 6117, 6118, 6038
2356, 3000, 3039, 3040, 3001, 6118, 6119, 6120, 6040
2357, 3001, 3040, 189, 190, 6120, 6121, 229, 6042
2358, 69, 2, 110, 3002, 109, 149, 6122, 6043
2359, 3002, 110, 111, 3003, 6122, 150, 6123, 6045
2360, 3003, 111, 112, 3004, 6123, 151, 6124, 6047
2361, 3004, 112, 113, 3005, 6124, 152, 6125, 6049
2362, 3005, 113, 114, 3006, 6125, 153, 6126, 6051
2363, 3006, 114, 115, 3007, 6126, 154, 6127, 6053
2364, 3007, 115, 116, 3008, 6127, 155, 6128, 6055
2365, 3008, 116, 117, 3009, 6128, 156, 6129, 6057
2366, 3009, 117, 118, 3010, 6129, 157, 6130, 6059
2367, 3010, 118, 119, 3011, 6130, 158, 6131, 6061
2368, 3011, 119, 120, 3012, 6131, 159, 6132, 6063
2369, 3012, 120, 121, 3013, 6132, 160, 6133, 6065
2370, 3013, 121, 122, 3014, 6133, 161, 6134, 6067
2371, 3014, 122, 123, 3015, 6134, 162, 6135, 6069
2372, 3015, 123, 124, 3016, 6135, 163, 6136, 6071
2373, 3016, 124, 125, 3017, 6136, 164, 6137, 6073
2374, 3017, 125, 126, 3018, 6137, 165, 6138, 6075
2375, 3018, 126, 127, 3019, 6138, 166, 6139, 6077
2376, 3019, 127, 128, 3020, 6139, 167, 6140, 6079
2377, 3020, 128, 129, 3021, 6140, 168, 6141, 6081
2378, 3021, 129, 130, 3022, 6141, 169, 6142, 6083
2379, 3022, 130, 131, 3023, 6142, 170, 6143, 6085
2380, 3023, 131, 132, 3024, 6143, 171, 6144, 6087
2381, 3024, 132, 133, 3025, 6144, 172, 6145, 6089
2382, 3025, 133, 134, 3026, 6145, 173, 6146, 6091
2383, 3026, 134, 135, 3027, 6146, 174, 6147, 6093
2384, 3027, 135, 136, 3028, 6147, 175, 6148, 6095
2385, 3028, 136, 137, 3029, 6148, 176, 6149, 6097
2386, 3029, 137, 138, 3030, 6149, 177, 6150, 6099
2387, 3030, 138, 139, 3031, 6150, 178, 6151, 6101
2388, 3031, 139, 140, 3032, 6151, 179, 6152, 6103
2389, 3032, 140, 141, 3033, 6152, 180, 6153, 6105
2390, 3033, 141, 142, 3034, 6153, 181, 6154, 6107
2391, 3034, 142, 143, 3035, 6154, 182, 6155, 6109
2392, 3035, 143, 144, 3036, 6155, 183, 6156, 6111
2393, 3036, 144, 145, 3037, 6156, 184, 6157, 6113
2394, 3037, 145, 146, 3038, 6157, 185, 6158, 6115
2395, 3038, 146, 147, 3039, 6158, 186, 6159, 6117
2396, 3039, 147, 148, 3040, 6159, 187, 6160, 6119
2397, 3040, 148, 3, 189, 6160, 188, 228, 6121
*ELEMENT, type=CPS8, ELSET=Surface2
2398, 3, 347, 6161, 189, 351, 6317, 6318, 228
2399, 189, 6161, 6162, 190, 6318, 6319, 6320, 229
2400, 190, 6162, 6163, 191, 6320, 6321, 6322, 230
2401, 191, 6163, 6164, 192, 6322, 6323, 6324, 231
2402, 192, 6164, 6165, 193, 6324, 6325, 6326, 232
2403, 193, 6165, 6166, 194, 6326, 6327, 6328, 233
2404, 194, 6166, 6167, 195, 6328, 6329, 6330, 234
2405, 195, 6167, 6168, 196, 6330, 6331, 6332, 235
2406, 196, 6168, 6169, 197, 6332, 6333, 6334, 236
2407, 197, 6169, 6170, 198, 6334, 6335, 6336, 237
2408, 198, 6170, 6171, 199, 6336, 6337, 6338, 238
2409, 199, 6171, 6172, 200, 6338, 6339, 6340, 239
2410, 200, 6172, 6173, 201, 6340, 6341, 6342, 240
2411, 201, 6173, 6174, 202, 6342, 6343, 6344, 241
2412, 202, 6174, 6175, 203, 6344, 6345, 6346, 242
2413, 203, 6175, 6176, 204, 6346, 6347, 6348, 243
2414, 204, 6176, 6177, 205, 6348, 6349, 6350, 244
2415, 205, 6177, 6178, 206, 6350, 6351, 6352, 245
2416, 206, 6178, 6179, 207, 6352, 6353, 6354, 246
2417, 207, 6179, 6180, 208, 6354, 6355, 6356, 247
2418, 208, 6180, 6181, 209, 6356, 6357, 6358, 248
2419, 209, 6181, 6182, 210, 6358, 6359, 6360, 249
2420, 210, 6182, 6183, 211, 6360, 6361, 6362, 250
2421, 211, 6183, 6184, 212, 6362, 6363, 6364, 251
2422, 212, 6184, 6185, 213, 6364, 6365, 6366, 252
2423, 213, 6185, 6186, 214, 6366, 6367, 6368, 253
2424, 214, 6186, 6187, 215, 6368, 6369, 6370, 254
2425, 215, 6187, 6188, 216, 6370, 6371, 6372, 255
2426, 216, 6188, 6189, 217, 6372, 6373, 6374, 256
2427, 217, 6189, 6190, 218, 6374, 6375, 6376, 257
2428, 218, 6190, 6191, 219, 6376, 6377, 6378, 258
2429, 219, 6191, 6192, 220, 6378, 6379, 6380, 259
2430, 220, 6192, 6193, 221, 6380, 6381, 6382, 260
2431, 221, 6193, 6194, 222, 6382, 6383, 6384, 261
2432, 222, 6194, 6195, 223, 6384, 6385, 6386, 262
2433, 223, 6195, 6196, 224, 6386, 6387, 6388, 263
2434, 224, 6196, 6197, 225, 6388, 6389, 6390, 264
2435, 225, 6197, 6198, 226, 6390, 6391, 6392, 265
2436, 226, 6198, 6199, 227, 6392, 6393, 6394, 266
2437, 227, 6199, 356, 4, 6394, 6395, 360, 267
2438, 347, 348, 6200, 6161, 352, 6396, 6397, 6317
2439, 6161, 6200, 6201, 6162, 6397, 6398, 6399, 6319
2440, 6162, 6201, 6202, 6163, 6399, 6400, 6401, 6321
2441, 6163, 6202, 6203, 6164, 6401, 6402, 6403, 6323
2442, 6164, 6203, 6204, 6165, 6403, 6404, 6405, 6325
2443, 6165, 6204, 6205, 6166, 6405, 6406, 6407, 6327
2444, 6166, 6205, 6206, 6167, 6407, 6408, 6409, 6329
2445, 6167, 6206, 6207, 6168, 6409, 6410, 6411, 6331
2446, 6168, 6207, 6208, 6169, 6411, 6412, 6413, 6333
2447, 6169, 6208, 6209, 6170, 6413, 6414, 6415, 6335
2448, 6170, 6209, 6210, 6171, 6415, 6416, 6417, 6337
2449, 6171, 6210, 6211, 6172, 6417, 6418, 6419, 6339
2450, 6172, 6211, 6212, 6173, 6419, 6420, 6421, 6341
2451, 6173, 6212, 6213, 6174, 6421, 6422, 6423, 6343
2452, 6174, 6213, 6214, 6175, 6423, 6424, 6425, 6345
2453, 6175, 6214, 6215, 6176, 6425, 6426, 6427, 6347
2454, 6176, 6215, 6216, 6177, 6427, 6428, 6429, 6349
2455, 6177, 6216, 6217, 6178, 6429, 6430, 6431, 6351
2456, 6178, 6217, 6218, 6179, 6431, 6432, 6433, 6353
2457, 6179, 6218, 6219, 6180, 6433, 6434, 6435, 6355
2458, 6180, 6219, 6220, 6181, 6435, 6436, 6437, 6357
2459, 6181, 6220, 6221, 6182, 6437, 6438, 6439, 6359
2460, 6182, 6221, 6222, 6183, 6439, 6440, 6441, 6361
2461, 6183, 6222, 6223, 6184, 6441, 6442, 6443, 6363
2462, 6184, 6223, 6224, 6185, 6443, 6444, 6445, 6365
2463, 6185, 6224, 6225, 6186, 6445, 6446, 6447, 6367
2464, 6186, 6225, 6226, 6187, 6447, 6448, 6449, 6369
2465, 6187, 6226, 6227, 6188, 6449, 6450, 6451, 6371
2466, 6188, 6227, 6228, 6189, 6451, 6452, 6453, 6373
2467, 6189, 6228, 6229, 6190, 6453, 6454, 6455, 6375
2468, 6190, 6229, 6230, 6191, 6455, 6456, 6457, 6377
2469, 6191, 6230, 6231, 6192, 6457, 6458, 6459, 6379
2470, 6192, 6231, 6232, 6193, 6459, 6460, 6461, 6381
2471, 6193, 6232, 6233, 6194, 6461, 6462, 6463, 6383
2472, 6194, 6233, 6234, 6195, 6463, 6464, 6465, 6385
2473, 6195, 6234, 6235, 6196, 6465, 6466, 6467, 6387
2474, 6196, 6235, 6236, 6197, 6467, 6468, 6469, 6389
2475, 6197, 6236, 6237, 6198, 6469, 6470, 6471, 6391
2476, 6198, 6237, 6238, 6199, 6471, 6472, 6473, 6393
2477, 6199, 6238, 357, 356, 6473, 6474, 361, 6395
2478, 348, 349, 6239, 6200, 353, 6475, 6476, 6396
2479, 6200, 6239, 6240, 6201, 6476, 6477, 6478, 6398
2480, 6201, 6240, 6241, 6202, 6478, 6479, 6480, 6400
2481, 6202, 6241, 6242, 6203, 6480, 6481, 6482, 6402
2482, 6203, 6242, 6243, 6204, 6482, 6483, 6484, 6404
2483, 6204, 6243, 6244, 6205, 6484, 6485, 6486, 6406
2484, 6205, 6244, 6245, 6206, 6486, 6487, 6488, 6408
2485, 6206, 6245, 6246, 6207, 6488, 6489, 6490, 6410
2486, 6207, 6246, 6247, 6208, 6490, 6491, 6492, 6412
2487, 6208, 6247, 6248, 6209, 6492, 6493, 6494, 6414
2488, 6209, 6248, 6249, 6210, 6494, 6495, 6496, 6416
2489, 6210, 6249, 6250, 6211, 6496, 6497, 6498, 6418
2490, 6211, 6250, 6251, 6212, 6498, 6499, 6500, 6420
2491, 6212, 6251, 6252, 6213, 6500, 6501, 6502, 6422
2492, 6213, 6252, 6253, 6214, 6502, 6503, 6504, 6424
2493, 6214, 6253, 6254, 6215, 6504, 6505, 6506, 6426
2494, 6215, 6254, 6255, 6216, 6506, 6507, 6508, 6428
2495, 6216, 6255, 6256, 6217, 6508, 6509, 6510, 6430
2496, 6217, 6256, 6257, 6218, 6510, 6511, 6512, 6432
2497, 6218, 6257, 6258, 6219, 6512, 6513, 6514, 6434
2498, 6219, 6258, 6259, 6220, 6514, 6515, 6516, 6436
2499, 6220, 6259, 6260, 6221, 6516, 6517, 6518, 6438
2500, 6221, 6260, 6261, 6222, 6518, 6519, 6520, 6440
2501, 6222, 6261, 6262, 6223, 6520, 6521, 6522, 6442
2502, 6223, 6262, 6263, 6224, 6522, 6523, 6524, 6444
2503, 6224, 6263, 6264, 6225, 6524, 6525, 6526, 6446
2504, 6225, 6264, 6265, 6226, 6526, 6527, 6528, 6448
2505, 6226, 6265, 6266, 6227, 6528, 6529, 6530, 6450
2506, 6227, 6266, 6267, 6228, 6530, 6531, 6532, 6452
2507, 6228, 6267, 6268, 6229, 6532, 6533, 6534, 6454
2508, 6229, 6268, 6269, 6230, 6534, 6535, 6536, 6456
2509, 6230, 6269, 6270, 6231, 6536, 6537, 6538, 6458
2510, 6231, 6270, 6271, 6232, 6538, 6539, 6540, 6460
2511, 6232, 6271, 6272, 6233, 6540, 6541, 6542, 6462
2512, 6233, 6272, 6273, 6234, 6542, 6543, 6544, 6464
2513, 6234, 6273, 6274, 6235, 6544, 6545, 6546, 6466
2514, 6235, 6274, 6275, 6236, 6546, 6547, 6548, 6468
2515, 6236, 6275, 6276, 6237, 6548, 6549, 6550, 6470
2516, 6237, 6276, 6277, 6238, 6550, 6551, 6552, 6472
2517, 6238, 6277, 358, 357, 6552, 6553, 362, 6474
2518, 349, 350, 6278, 6239, 354, 6554, 6555, 6475
2519, 6239, 6278, 6279, 6240, 6555, 6556, 6557, 6477
2520, 6240, 6279, 6280, 6241, 6557, 6558, 6559, 6479
2521, 6241, 6280, 6281, 6242, 6559, 6560, 6561, 6481
2522, 6242, 6281, 6282, 6243, 6561, 6562, 6563, 6483
2523, 6243, 6282, 6283, 6244, 6563, 6564, 6565, 6485
2524, 6244, 6283, 6284, 6245, 6565, 6566, 6567, 6487
2525, 6245, 6284, 6285, 6246, 6567, 6568, 6569, 6489
2526, 6246, 6285, 6286, 6247, 6569, 6570, 6571, 6491
2527, 6247, 6286, 6287, 6248, 6571, 6572, 6573, 6493
2528, 6248, 6287, 6288, 6249, 6573, 6574, 6575, 6495
2529, 6249, 6288, 6289, 6250, 6575, 6576, 6577, 6497
2530, 6250, 6289, 6290, 6251, 6577, 6578, 6579, 6499
2531, 6251, 6290, 6291, 6252, 6579, 6580, 6581, 6501
2532, 6252, 6291, 6292, 6253, 6581, 6582, 6583, 6503
2533, 6253, 6292, 6293, 6254, 6583, 6584, 6585, 6505
2534, 6254, 6293, 6294, 6255, 6585, 6586, 6587, 6507
2535, 6255, 6294, 6295, 6256, 6587, 6588, 6589, 6509
2536, 6256, 6295, 6296, 6257, 6589, 6590, 6591, 6511
2537, 6257, 6296, 6297, 6258, 6591, 6592, 6593, 6513
2538, 6258, 6297, 6298, 6259, 6593, 6594, 6595, 6515
2539, 6259, 6298, 6299, 6260, 6595, 6596, 6597, 6517
2540, 6260, 6299, 6300, 6261, 6597, 6598, 6599, 6519
2541, 6261, 6300, 6301, 6262, 6599, 6600, 6601, 6521
2542, 6262, 6301, 6302, 6263, 6601, 6602, 6603, 6523
2543, 6263, 6302, 6303, 6264, 6603, 6604, 6605, 6525
2544, 6264, 6303, 6304, 6265, 6605, 6606, 6607, 6527
2545, 6265, 6304, 6305, 6266, 6607, 6608, 6609, 6529
2546, 6266, 6305, 6306, 6267, 6609, 6610, 6611, 6531
2547, 6267, 6306, 6307, 6268, 6611, 6612, 6613, 6533
2548, 6268, 6307, 6308, 6269, 6613, 6614, 6615, 6535
2549, 6269, 6308, 6309, 6270, 6615, 6616, 6617, 6537
2550, 6270, 6309, 6310, 6271, 6617, 6618, 6619, 6539
2551, 6271, 6310, 6311, 6272, 6619, 6620, 6621, 6541
2552, 6272, 6311, 6312, 6273, 6621, 6622, 6623, 6543
2553, 6273, 6312, 6313, 6274, 6623, 6624, 6625, 6545
2554, 6274, 6313, 6314, 6275, 6625, 6626, 6627, 6547
2555, 6275, 6314, 6315, 6276, 6627, 6628, 6629, 6549
2556, 6276, 6315, 6316, 6277, 6629, 6630, 6631, 6551
2557, 6277, 6316, 359, 358, 6631, 6632, 363, 6553
2558, 350, 5, 365, 6278, 355, 404, 6633, 6554
2559, 6278, 365, 366, 6279, 6633, 405, 6634, 6556
2560, 6279, 366, 367, 6280, 6634, 406, 6635, 6558
2561, 6280, 367, 368, 6281, 6635, 407, 6636, 6560
2562, 6281, 368, 369, 6282, 6636, 408, 6637, 6562
2563, 6282, 369, 370, 6283, 6637, 409, 6638, 6564
2564, 6283, 370, 371, 6284, 6638, 410, 6639, 6566
2565, 6284, 371, 372, 6285, 6639, 411, 6640, 6568
2566, 6285, 372, 373, 6286, 6640, 412, 6641, 6570
2567, 6286, 373, 374, 6287, 6641, 413, 6642, 6572
2568, 6287, 374, 375, 6288, 6642, 414, 6643, 6574
2569, 6288, 375, 376, 6289, 6643, 415, 6644, 6576
2570, 6289, 376, 377, 6290, 6644, 416, 6645, 6578
2571, 6290, 377, 378, 6291, 6645, 417, 6646, 6580
2572, 6291, 378, 379, 6292, 6646, 418, 6647, 6582
2573, 6292, 379, 380, 6293, 6647, 419, 6648, 6584
2574, 6293, 380, 381, 6294, 6648, 420, 6649, 6586
2575, 6294, 381, 382, 6295, 6649, 421, 6650, 6588
2576, 6295, 382, 383, 6296, 6650, 422, 6651, 6590
2577, 6296, 383, 384, 6297, 6651, 423, 6652, 6592
2578, 6297, 384, 385, 6298, 6652, 424, 6653, 6594
2579, 6298, 385, 386, 6299, 6653, 425, 6654, 6596
2580, 6299, 386, 387, 6300, 6654, 426, 6655, 6598
2581, 6300, 387, 388, 6301, 6655, 427, 6656, 6600
2582, 6301, 388, 389, 6302, 6656, 428, 6657, 6602
2583, 6302, 389, 390, 6303, 6657, 429, 6658, 6604
2584, 6303, 390, 391, 6304, 6658, 430, 6659, 6606
2585, 6304, 391, 392, 6305, 6659, 431, 6660, 6608
2586, 6305, 392, 393, 6306, 6660, 432, 6661, 6610
2587, 6306, 393, 394, 6307, 6661, 433, 6662, 6612
2588, 6307, 394, 395, 6308, 6662, 434, 6663, 6614
2589, 6308, 395, 396, 6309, 6663, 435, 6664, 6616
2590, 6309, 396, 397, 6310, 6664, 436, 6665, 6618
2591, 6310, 397, 398, 6311, 6665, 437, 6666, 6620
2592, 6311, 398, 399, 6312, 6666, 438, 6667, 6622
2593, 6312, 399, 400, 6313, 6667, 439, 6668, 6624
2594, 6313, 400, 401, 6314, 6668, 440, 6669, 6626
2595, 6314, 401, 402, 6315, 6669, 441, 6670, 6628
2596, 6315, 402, 403, 6316, 6670, 442, 6671, 6630
2597, 6316, 403, 6, 359, 6671, 443, 364, 6632
*ELEMENT, type=CPS8, ELSET=Surface3
2598, 3, 444, 6672, 347, 448, 6688, 6689, 351
2599, 347, 6672, 6673, 348, 6689, 6690, 6691, 352
2600, 348, 6673, 6674, 349, 6691, 6692, 6693, 353
2601, 349, 6674, 6675, 350, 6693, 6694, 6695, 354
2602, 350, 6675, 453, 5, 6695, 6696, 457, 355
2603, 444, 445, 6676, 6672, 449, 6697, 6698, 6688
2604, 6672, 6676, 6677, 6673, 6698, 6699, 6700, 6690
2605, 6673, 6677, 6678, 6674, 6700, 6701, 6702, 6692
2606, 6674, 6678, 6679, 6675, 6702, 6703, 6704, 6694
2607, 6675, 6679, 454, 453, 6704, 6705, 458, 6696
2608, 445, 446, 6680, 6676, 450, 6706, 6707, 6697
2609, 6676, 6680, 6681, 6677, 6707, 6708, 6709, 6699
2610, 6677, 6681, 6682, 6678, 6709, 6710, 6711, 6701
2611, 6678, 6682, 6683, 6679, 6711, 6712, 6713, 6703
2612, 6679, 6683, 455, 454, 6713, 6714, 459, 6705
2613, 446, 447, 6684, 6680, 451, 6715, 6716, 6706
2614, 6680, 6684, 6685, 6681, 6716, 6717, 6718, 6708
2615, 6681, 6685, 6686, 6682, 6718, 6719, 6720, 6710
2616, 6682, 6686, 6687, 6683, 6720, 6721, 6722, 6712
2617, 6683, 6687, 456, 455, 6722, 6723, 460, 6714
2618, 447, 7, 462, 6684, 452, 466, 6724, 6715
2619, 6684, 462, 463, 6685, 6724, 467, 6725, 6717
2620, 6685, 463, 464, 6686, 6725, 468, 6726, 6719
2621, 6686, 464, 465, 6687, 6726, 469, 6727, 6721
2622, 6687, 465, 8, 456, 6727, 470, 461, 6723
*ELEMENT, type=CPS8, ELSET=Surface4
2623, 7, 471, 6728, 462, 510, 6884, 6885, 466
2624, 462, 6728, 6729, 463, 6885, 6886, 6887, 467
2625, 463, 6729, 6730, 464, 6887, 6888, 6889, 468
2626, 464, 6730, 6731, 465, 6889, 6890, 6891, 469
2627, 465, 6731, 550, 8, 6891, 6892, 589, 470
2628, 471, 472, 6732, 6728, 511, 6893, 6894, 6884
2629, 6728, 6732, 6733, 6729, 6894, 6895, 6896, 6886
2630, 6729, 6733, 6734, 6730, 6896, 6897, 6898, 6888
2631, 6730, 6734, 6735, 6731, 6898, 6899, 6900, 6890
2632, 6731, 6735, 551, 550, 6900, 6901, 590, 6892
2633, 472, 473, 6736, 6732, 512, 6902, 6903, 6893
2634, 6732, 6736, 6737, 6733, 6903, 6904, 6905, 6895
2635, 6733, 6737, 6738, 6734, 6905, 6906, 6907, 6897
2636, 6734, 6738, 6739, 6735, 6907, 6908, 6909, 6899
2637, 6735, 6739, 552, 551, 6909, 6910, 591, 6901
2638, 473, 474, 6740, 6736, 513, 6911, 6912, 6902
2639, 6736, 6740, 6741, 6737, 6912, 6913, 6914, 6904
2640, 6737, 6741, 6742, 6738, 6914, 6915, 6916, 6906
2641, 6738, 6742, 6743, 6739, 6916, 6917, 6918, 6908
2642, 6739, 6743, 553, 552, 6918, 6919, 592, 6910
2643, 474, 475, 6744, 6740, 514, 6920, 6921, 6911
2644, 6740, 6744, 6745, 6741, 6921, 6922, 6923, 6913
2645, 6741, 6745, 6746, 6742, 6923, 6924, 6925, 6915
2646, 6742, 6746, 6747, 6743, 6925, 6926, 6927, 6917
2647, 6743, 6747, 554, 553, 6927, 6928, 593, 6919
2648, 475, 476, 6748, 6744, 515, 6929, 6930, 6920
2649, 6744, 6748, 6749, 6745, 6930, 6931, 6932, 6922
2650, 6745, 6749, 6750, 6746, 6932, 6933, 6934, 6924
2651, 6746, 6750, 6751, 6747, 6934, 6935, 6936, 6926
2652, 6747, 6751, 555, 554, 6936, 6937, 594, 6928
2653, 476, 477, 6752, 6748, 516, 6938, 6939, 6929
2654, 6748, 6752, 6753, 6749, 6939, 6940, 6941, 6931
2655, 6749, 6753, 6754, 6750, 6941, 6942, 6943, 6933
2656, 6750, 6754, 6755, 6751, 6943, 6944, 6945, 6935
2657, 6751, 6755, 556, 555, 6945, 6946, 595, 6937
2658, 477, 478, 6756, 6752, 517, 6947, 6948, 6938
2659, 6752, 6756, 6757, 6753, 6948, 6949, 6950, 6940
2660, 6753, 6757, 6758, 6754, 6950, 6951, 6952, 6942
2661, 6754, 6758, 6759, 6755, 6952, 6953, 6954, 6944
2662, 6755, 6759, 557, 556, 6954, 6955, 596, 6946
2663, 478, 479, 6760, 6756, 518, 6956, 6957, 6947
2664, 6756, 6760, 6761, 6757, 6957, 6958, 6959, 6949
2665, 6757, 6761, 6762, 6758, 6959, 6960, 6961, 6951
2666, 6758, 6762, 6763, 6759, 6961, 6962, 6963, 6953
2667, 6759, 6763, 558, 557, 6963, 6964, 597, 6955
2668, 479, 480, 6764, 6760, 519, 6965, 6966, 6956
2669, 6760, 6764, 6765, 6761, 6966, 6967, 6968, 6958
2670, 6761, 6765, 6766, 6762, 6968, 6969, 6970, 6960
2671, 6762, 6766, 6767, 6763, 6970, 6971, 6972, 6962
2672, 6763, 6767, 559, 558, 6972, 6973, 598, 6964
2673, 480, 481, 6768, 6764, 520, 6974, 6975, 6965
2674, 6764, 6768, 6769, 6765, 6975, 6976, 6977, 6967
2675, 6765, 6769, 6770, 6766, 6977, 6978, 6979, 6969
2676, 6766, 6770, 6771, 6767, 6979, 6980, 6981, 6971
2677, 6767, 6771, 560, 559, 6981, 6982, 599, 6973
2678, 481, 482, 6772, 6768, 521, 6983, 6984, 6974
2679, 6768, 6772, 6773, 6769, 6984, 6985, 6986, 6976
2680, 6769, 6773, 6774, 6770, 6986, 6987, 6988, 6978
2681, 6770, 6774, 6775, 6771, 6988, 6989, 6990, 6980
2682, 6771, 6775, 561, 560, 6990, 6991, 600, 6982
2683, 482, 483, 6776, 6772, 522, 6992, 6993, 6983
2684, 6772, 6776, 6777, 6773, 6993, 6994, 6995, 6985
2685, 6773, 6777, 6778, 6774, 6995, 6996, 6997, 6987
2686, 6774, 6778, 6779, 6775, 6997, 6998, 6999, 6989
2687, 6775, 6779, 562, 561, 6999, 7000, 601, 6991
2688, 483, 484, 6780, 6776, 523, 7001, 7002, 6992
2689, 6776, 6780, 6781, 6777, 7002, 7003, 7004, 6994
2690, 6777, 6781, 6782, 6778, 7004, 7005, 7006, 6996
2691, 6778, 6782, 6783, 6779, 7006, 7007, 7008, 6998
2692, 6779, 6783, 563, 562, 7008, 7009, 602, 7000
2693, 484, 485, 6784, 6780, 524, 7010, 7011, 7001
2694, 6780, 6784, 6785, 6781, 7011, 7012, 7013, 7003
2695, 6781, 6785, 6786, 6782, 7013, 7014, 7015, 7005
2696, 6782, 6786, 6787, 6783, 7015, 7016, 7017, 7007
2697, 6783, 6787, 564, 563, 7017, 7018, 603, 7009
2698, 485, 486, 6788, 6784, 525, 7019, 7020, 7010
2699, 6784, 6788, 6789, 6785, 7020, 7021, 7022, 7012
2700, 6785, 6789, 6790, 6786, 7022, 7023, 7024, 7014
2701, 6786, 6790, 6791, 6787, 7024, 7025, 7026, 7016
2702, 6787, 6791, 565, 564, 7026, 7027, 604, 7018
2703, 486, 487, 6792, 6788, 526, 7028, 7029, 7019
2704, 6788, 6792, 6793, 6789, 7029, 7030, 7031, 7021
2705, 6789, 6793, 6794, 6790, 7031, 7032, 7033, 7023
2706, 6790, 6794, 6795, 6791, 7033, 7034, 7035, 7025
2707, 6791, 6795, 566, 565, 7035, 7036, 605, 7027
2708, 487, 488, 6796, 6792, 527, 7037, 7038, 7028
2709, 6792, 6796, 6797, 6793, 7038, 7039, 7040, 7030
2710, 6793, 6797, 6798, 6794, 7040, 7041, 7042, 7032
2711, 6794, 6798, 6799, 6795, 7042, 7043, 7044, 7034
2712, 6795, 6799, 567, 566, 7044, 7045, 606, 7036
2713, 488, 489, 6800, 6796, 528, 7046, 7047, 7037
2714, 6796, 6800, 6801, 6797, 7047, 7048, 7049, 7039
2715, 6797, 6801, 6802, 6798, 7049, 7050, 7051, 7041
2716, 6798, 6802, 6803, 6799, 7051, 7052, 7053, 7043
2717, 6799, 6803, 568, 567, 7053, 7054, 607, 7045
2718, 489, 490, 6804, 6800, 529, 7055, 7056, 7046
2719, 6800, 6804, 6805, 6801, 7056, 7057, 7058, 7048
2720, 6801, 6805, 6806, 6802, 7058, 7059, 7060, 7050
2721, 6802, 6806, 6807, 6803, 7060, 7061, 7062, 7052
2722, 6803, 6807, 569, 568, 7062, 7063, 608, 7054
2723, 490, 491, 6808, 6804, 530, 7064, 7065, 7055
2724, 6804, 6808, 6809, 6805, 7065, 7066, 7067, 7057
2725, 6805, 6809, 6810, 6806, 7067, 7068, 7069, 7059
2726, 6806, 6810, 6811, 6807, 7069, 7070, 7071, 7061
2727, 6807, 6811, 570, 569, 7071, 7072, 609, 7063
2728, 491, 492, 6812, 6808, 531, 7073, 7074, 7064
2729, 6808, 6812, 6813, 6809, 7074, 7075, 7076, 7066
2730, 6809, 6813, 6814, 6810, 7076, 7077, 7078, 7068
2731, 6810, 6814, 6815, 6811, 7078, 7079, 7080, 7070
2732, 6811, 6815, 571, 570, 7080, 7081, 610, 7072
2733, 492, 493, 6816, 6812, 532, 7082, 7083, 7073
2734, 6812, 6816, 6817, 6813, 7083, 7084, 7085, 7075
2735, 6813, 6817, 6818, 6814, 7085, 7086, 7087, 7077
2736, 6814, 6818, 6819, 6815, 7087, 7088, 7089, 7079
2737, 6815, 6819, 572, 571, 7089, 7090, 611, 7081
2738, 493, 494, 6820, 6816, 533, 7091, 7092, 7082
2739, 6816, 6820, 6821, 6817, 7092, 7093, 7094, 7084
2740, 6817, 6821, 6822, 6818, 7094, 7095, 7096, 7086
2741, 6818, 6822, 6823, 6819, 7096, 7097, 7098, 7088
2742, 6819, 6823, 573, 572, 7098, 7099, 612, 7090
2743, 494, 495, 6824, 6820, 534, 7100, 7101, 7091
2744, 6820, 6824, 6825, 6821, 7101, 7102, 7103, 7093
2745, 6821, 6825, 6826, 6822, 7103, 7104, 7105, 7095
2746, 6822, 6826, 6827, 6823, 7105, 7106, 7107, 7097
2747, 6823, 6827, 574, 573, 7107, 7108, 613, 7099
2748, 495, 496, 6828, 6824, 535, 7109, 7110, 7100
2749, 6824, 6828, 6829, 6825, 7110, 7111, 7112, 7102
2750, 6825, 6829, 6830, 6826, 7112, 7113, 7114, 7104
2751, 6826, 6830, 6831, 6827, 7114, 7115, 7116, 7106
2752, 6827, 6831, 575, 574, 7116, 7117, 614, 7108
2753, 496, 497, 6832, 6828, 536, 7118, 7119, 7109
2754, 6828, 6832, 6833, 6829, 7119, 7120, 7121, 7111
2755, 6829, 6833, 6834, 6830, 7121, 7122, 7123, 7113
2756, 6830, 6834, 6835, 6831, 7123, 7124, 7125, 7115
2757, 6831, 6835, 576, 575, 7125, 7126, 615, 7117
2758, 497, 498, 6836, 6832, 537, 7127, 7128, 7118
2759, 6832, 6836, 6837, 6833, 7128, 7129, 7130, 7120
2760, 6833, 6837, 6838, 6834, 7130, 7131, 7132, 7122
2761, 6834, 6838, 6839, 6835, 7132, 7133, 7134, 7124
2762, 6835, 6839, 577, 576, 7134, 7135, 616, 7126
2763, 498, 499, 6840, 6836, 538, 7136, 7137, 7127
2764, 6836, 6840, 6841, 6837, 7137, 7138, 7139, 7129
2765, 6837, 6841, 6842, 6838, 7139, 7140, 7141, 7131
2766, 6838, 6842, 6843, 6839, 7141, 7142, 7143, 7133
2767, 6839, 6843, 578, 577, 7143, 7144, 617, 7135
2768, 499, 500, 6844, 6840, 539, 7145, 7146, 7136
2769, 6840, 6844, 6845, 6841, 7146, 7147, 7148, 7138
2770, 6841, 6845, 6846, 6842, 7148, 7149, 7150, 7140
2771, 6842, 6846, 6847, 6843, 7150, 7151, 7152, 7142
2772, 6843, 6847, 579, 578, 7152, 7153, 618, 7144
2773, 500, 501, 6848, 6844, 540, 7154, 7155, 7145
2774, 6844, 6848, 6849, 6845, 7155, 7156, 7157, 7147
2775, 6845, 6849, 6850, 6846, 7157, 7158, 7159, 7149
2776, 6846, 6850, 6851, 6847, 7159, 7160, 7161, 7151
2777, 6847, 6851, 580, 579, 7161, 7162, 619, 7153
2778, 501, 502, 6852, 6848, 541, 7163, 7164, 7154
2779, 6848, 6852, 6853, 6849, 7164, 7165, 7166, 7156
2780, 6849, 6853, 6854, 6850, 7166, 7167, 7168, 7158
2781, 6850, 6854, 6855, 6851, 7168, 7169, 7170, 7160
2782, 6851, 6855, 581, 580, 7170, 7171, 620, 7162
2783, 502, 503, 6856, 6852, 542, 7172, 7173, 7163
2784, 6852, 6856, 6857, 6853, 7173, 7174, 7175, 7165
2785, 6853, 6857, 6858, 6854, 7175, 7176, 7177, 7167
2786, 6854, 6858, 6859, 6855, 7177, 7178, 7179, 7169
2787, 6855, 6859, 582, 581, 7179, 7180, 621, 7171
2788, 503, 504, 6860, 6856, 543, 7181, 7182, 7172
2789, 6856, 6860, 6861, 6857, 7182, 7183, 7184, 7174
2790, 6857, 6861, 6862, 6858, 7184, 7185, 7186, 7176
2791, 6858, 6862, 6863, 6859, 7186, 7187, 7188, 7178
2792, 6859, 6863, 583, 582, 7188, 7189, 622, 7180
2793, 504, 505, 6864, 6860, 544, 7190, 7191, 7181
2794, 6860, 6864, 6865, 6861, 7191, 7192, 7193, 7183
2795, 6861, 6865, 6866, 6862, 7193, 7194, 7195, 7185
2796, 6862, 6866, 6867, 6863, 7195, 7196, 7197, 7187
2797, 6863, 6867, 584, 583, 7197, 7198, 623, 7189
2798, 505, 506, 6868, 6864, 545, 7199, 7200, 7190
2799, 6864, 6868, 6869, 6865, 7200, 7201, 7202, 7192
2800, 6865, 6869, 6870, 6866, 7202, 7203, 7204, 7194
2801, 6866, 6870, 6871, 6867, 7204, 7205, 7206, 7196
2802, 6867, 6871, 585, 584, 7206, 7207, 624, 7198
2803, 506, 507, 6872, 6868, 546, 7208, 7209, 7199
2804, 6868, 6872, 6873, 6869, 7209, 7210, 7211, 7201
2805, 6869, 6873, 6874, 6870, 7211, 7212, 7213, 7203
2806, 6870, 6874, 6875, 6871, 7213, 7214, 7215, 7205
2807, 6871, 6875, 586, 585, 7215, 7216, 625, 7207
2808, 507, 508, 6876, 6872, 547, 7217, 7218, 7208
2809, 6872, 6876, 6877, 6873, 7218, 7219, 7220, 7210
2810, 6873, 6877, 6878, 6874, 7220, 7221, 7222, 7212
2811, 6874, 6878, 6879, 6875, 7222, 7223, 7224, 7214
2812, 6875, 6879, 587, 586, 7224, 7225, 626, 7216
2813, 508, 509, 6880, 6876, 548, 7226, 7227, 7217
2814, 6876, 6880, 6881, 6877, 7227, 7228, 7229, 7219
2815, 6877, 6881, 6882, 6878, 7229, 7230, 7231, 7221
2816, 6878, 6882, 6883, 6879, 7231, 7232, 7233, 7223
2817, 6879, 6883, 588, 587, 7233, 7234, 627, 7225
2818, 509, 9, 629, 6880, 549, 633, 7235, 7226
2819, 6880, 629, 630, 6881, 7235, 634, 7236, 7228
2820, 6881, 630, 631, 6882, 7236, 635, 7237, 7230
2821, 6882, 631, 632, 6883, 7237, 636, 7238, 7232
2822, 6883, 632, 10, 588, 7238, 637, 628, 7234
*ELEMENT, type=CPS8, ELSET=Surface5
2823, 7, 638, 7239, 471, 677, 8760, 8761, 510
2824, 471, 7239, 7240, 472, 8761, 8762, 8763, 511
2825, 472, 7240, 7241, 473, 8763, 8764, 8765, 512
2826, 473, 7241, 7242, 474, 8765, 8766, 8767, 513
2827, 474, 7242, 7243, 475, 8767, 8768, 8769, 514
2828, 475, 7243, 7244, 476, 8769, 8770, 8771, 515
2829, 476, 7244, 7245, 477, 8771, 8772, 8773, 516
2830, 477, 7245, 7246, 478, 8773, 8774, 8775, 517
2831, 478, 7246, 7247, 479, 8775, 8776, 8777, 518
2832, 479, 7247, 7248, 480, 8777, 8778, 8779, 519
2833, 480, 7248, 7249, 481, 8779, 8780, 8781, 520
2834, 481, 7249, 7250, 482, 8781, 8782, 8783, 521
2835, 482, 7250, 7251, 483, 8783, 8784, 8785, 522
2836, 483, 7251, 7252, 484, 8785, 8786, 8787, 523
2837, 484, 7252, 7253, 485, 8787, 8788, 8789, 524
2838, 485, 7253, 7254, 486, 8789, 8790, 8791, 525
2839, 486, 7254, 7255, 487, 8791, 8792, 8793, 526
2840, 487, 7255, 7256, 488, 8793, 8794, 8795, 527
2841, 488, 7256, 7257, 489, 8795, 8796, 8797, 528
2842, 489, 7257, 7258, 490, 8797, 8798, 8799, 529
2843, 490, 7258, 7259, 491, 8799, 8800, 8801, 530
2844, 491, 7259, 7260, 492, 8801, 8802, 8803, 531
2845, 492, 7260, 7261, 493, 8803, 8804, 8805, 532
2846, 493, 7261, 7262, 494, 8805, 8806, 8807, 533
2847, 494, 7262, 7263, 495, 8807, 8808, 8809, 534
2848, 495, 7263, 7264, 496, 8809, 8810, 8811, 535
2849, 496, 7264, 7265, 497, 8811, 8812, 8813, 536
2850, 497, 7265, 7266, 498, 8813, 8814, 8815, 537
2851, 498, 7266, 7267, 499, 8815, 8816, 8817, 538
2852, 499, 7267, 7268, 500, 8817, 8818, 8819, 539
2853, 500, 7268, 7269, 501, 8819, 8820, 8821, 540
2854, 501, 7269, 7270, 502, 8821, 8822, 8823, 541
2855, 502, 7270, 7271, 503, 8823, 8824, 8825, 542
2856, 503, 7271, 7272, 504, 8825, 8826, 8827, 543
2857, 504, 7272, 7273, 505, 8827, 8828, 8829, 544
2858, 505, 7273, 7274, 506, 8829, 8830, 8831, 545
2859, 506, 7274, 7275, 507, 8831, 8832, 8833, 546
2860, 507, 7275, 7276, 508, 8833, 8834, 8835, 547
2861, 508, 7276, 7277, 509, 8835, 8836, 8837, 548
2862, 509, 7277, 717, 9, 8837, 8838, 756, 549
2863, 638, 639, 7278, 7239, 678, 8839, 8840, 8760
2864, 7239, 7278, 7279, 7240, 8840, 8841, 8842, 8762
2865, 7240, 7279, 7280, 7241, 8842, 8843, 8844, 8764
2866, 7241, 7280, 7281, 7242, 8844, 8845, 8846, 8766
2867, 7242, 7281, 7282, 7243, 8846, 8847, 8848, 8768
2868, 7243, 7282, 7283, 7244, 8848, 8849, 8850, 8770
2869, 7244, 7283, 7284, 7245, 8850, 8851, 8852, 8772
2870, 7245, 7284, 7285, 7246, 8852, 8853, 8854, 8774
2871, 7246, 7285, 7286, 7247, 8854, 8855, 8856, 8776
2872, 7247, 7286, 7287, 7248, 8856, 8857, 8858, 8778
2873, 7248, 7287, 7288, 7249, 8858, 8859, 8860, 8780
2874, 7249, 7288, 7289, 7250, 8860, 8861, 8862, 8782
2875, 7250, 7289, 7290, 7251, 8862, 8863, 8864, 8784
2876, 7251, 7290, 7291, 7252, 8864, 8865, 8866, 8786
2877, 7252, 7291, 7292, 7253, 8866, 8867, 8868, 8788
2878, 7253, 7292, 7293, 7254, 8868, 8869, 8870, 8790
2879, 7254, 7293, 7294, 7255, 8870, 8871, 8872, 8792
2880, 7255, 7294, 7295, 7256, 8872, 8873, 8874, 8794
2881, 7256, 7295, 7296, 7257, 8874, 8875, 8876, 8796
2882, 7257, 7296, 7297, 7258, 8876, 8877, 8878, 8798
2883, 7258, 7297, 7298, 7259, 8878, 8879, 8880, 8800
2884, 7259, 7298, 7299, 7260, 8880, 8881, 8882, 8802
2885, 7260, 7299, 7300, 7261, 8882, 8883, 8884, 8804
2886, 7261, 7300, 7301, 7262, 8884, 8885, 8886, 8806
2887, 7262, 7301, 7302, 7263, 8886, 8887, 8888, 8808
2888, 7263, 7302, 7303, 7264, 8888, 8889, 8890, 8810
2889, 7264, 7303, 7304, 7265, 8890, 8891, 8892, 8812
2890, 7265, 7304, 7305, 7266, 8892, 8893, 8894, 8814
2891, 7266, 7305, 7306, 7267, 8894, 8895, 8896, 8816
2892, 7267, 7306, 7307, 7268, 8896, 8897, 8898, 8818
2893, 7268, 7307, 7308, 7269, 8898, 8899, 8900, 8820
2894, 7269, 7308, 7309, 7270, 8900, 8901, 8902, 8822
2895, 7270, 7309, 7310, 7271, 8902, 8903, 8904, 8824
2896, 7271, 7310, 7311, 7272, 8904, 8905, 8906, 8826
2897, 7272, 7311, 7312, 7273, 8906, 8907, 8908, 8828
2898, 7273, 7312, 7313, 7274, 8908, 8909, 8910, 8830
2899, 7274, 7313, 7314, 7275, 8910, 8911, 8912, 8832
2900, 7275, 7314, 7315, 7276, 8912, 8913, 8914, 8834
2901, 7276, 7315, 7316, 7277, 8914, 8915, 8916, 8836
2902, 7277, 7316, 718, 717, 8916, 8917, 757, 8838
2903, 639, 640, 7317, 7278, 679, 8918, 8919, 8839
2904, 7278, 7317, 7318, 7279, 8919, 8920, 8921, 8841
2905, 7279, 7318, 7319, 7280, 8921, 8922, 8923, 8843
2906, 7280, 7319, 7320, 7281, 8923, 8924, 8925, 8845
2907, 7281, 7320, 7321, 7282, 8925, 8926, 8927, 8847
2908, 7282, 7321, 7322, 7283, 8927, 8928, 8929, 8849
2909, 7283, 7322, 7323, 7284, 8929, 8930, 8931, 8851
2910, 7284, 7323, 7324, 7285, 8931, 8932, 8933, 8853
2911, 7285, 7324, 7325, 7286, 8933, 8934, 8935, 8855
2912, 7286, 7325, 7326, 7287, 8935, 8936, 8937, 8857
2913, 7287, 7326, 7327, 7288, 8937, 8938, 8939, 8859
2914, 7288, 7327, 7328, 7289, 8939, 8940, 8941, 8861
2915, 7289, 7328, 7329, 7290, 8941, 8942, 8943, 8863
2916, 7290, 7329, 7330, 7291, 8943, 8944, 8945, 8865
2917, 7291, 7330, 7331, 7292, 8945, 8946, 8947, 8867
2918, 7292, 7331, 7332, 7293, 8947, 8948, 8949, 8869
2919, 7293, 7332, 7333, 7294, 8949, 8950, 8951, 8871
2920, 7294, 7333, 7334, 7295, 8951, 8952, 8953, 8873
2921, 7295, 7334, 7335, 7296, 8953, 8954, 8955, 8875
2922, 7296, 7335, 7336, 7297, 8955, 8956, 8957, 8877
2923, 7297, 7336, 7337, 7298, 8957, 8958, 8959, 8879
2924, 7298, 7337, 7338, 7299, 8959, 8960, 8961, 8881
2925, 7299, 7338, 7339, 7300, 8961, 8962, 8963, 8883
2926, 7300, 7339, 7340, 7301, 8963, 8964, 8965, 8885
2927, 7301, 7340, 7341, 7302, 8965, 8966, 8967, 8887
2928, 7302, 7341, 7342, 7303, 8967, 8968, 8969, 8889
2929, 7303, 7342, 7343, 7304, 8969, 8970, 8971, 8891
2930, 7304, 7343, 7344, 7305, 8971, 8972, 8973, 8893
2931, 7305, 7344, 7345, 7306, 8973, 8974, 8975, 8895
2932, 7306, 7345, 7346, 7307, 8975, 8976, 8977, 8897
2933, 7307, 7346, 7347, 7308, 8977, 8978, 8979, 8899
2934, 7308, 7347, 7348, 7309, 8979, 8980, 8981, 8901
2935, 7309, 7348, 7349, 7310, 8981, 8982, 8983, 8903
2936, 7310, 7349, 7350, 7311, 8983, 8984, 8985, 8905
2937, 7311, 7350, 7351, 7312, 8985, 8986, 8987, 8907
2938, 7312, 7351, 7352, 7313, 8987, 8988, 8989, 8909
2939, 7313, 7352, 7353, 7314, 8989, 8990, 8991, 8911
2940, 7314, 7353, 7354, 7315, 8991, 8992, 8993, 8913
2941, 7315, 7354, 7355, 7316, 8993, 8994, 8995, 8915
2942, 7316, 7355, 719, 718, 8995, 8996, 758, 8917
2943, 640, 641, 7356, 7317, 680, 8997, 8998, 8918
2944, 7317, 7356, 7357, 7318, 8998, 8999, 9000, 8920
2945, 7318, 7357, 7358, 7319, 9000, 9001, 9002, 8922
2946, 7319, 7358, 7359, 7320, 9002, 9003, 9004, 8924
2947, 7320, 7359, 7360, 7321, 9004, 9005, 9006, 8926
2948, 7321, 7360, 7361, 7322, 9006, 9007, 9008, 8928
2949, 7322, 7361, 7362, 7323, 9008, 9009, 9010, 8930
2950, 7323, 7362, 7363, 7324, 9010, 9011, 9012, 8932
2951, 7324, 7363, 7364, 7325, 9012, 9013, 9014, 8934
2952, 7325, 7364, 7365, 7326, 9014, 9015, 9016, 8936
2953, 7326, 7365, 7366, 7327, 9016, 9017, 9018, 8938
2954, 7327, 7366, 7367, 7328, 9018, 9019, 9020, 8940
2955, 7328, 7367, 7368, 7329, 9020, 9021, 9022, 8942
2956, 7329, 7368, 7369, 7330, 9022, 9023, 9024, 8944
2957, 7330, 7369, 7370, 7331, 9024, 9025, 9026, 8946
2958, 7331, 7370, 7371, 7332, 9026, 9027, 9028, 8948
2959, 7332, 7371, 7372, 7333, 9028, 9029, 9030, 8950
2960, 7333, 7372, 7373, 7334, 9030, 9031, 9032, 8952
2961, 7334, 7373, 7374, 7335, 9032, 9033, 9034, 8954
2962, 7335, 7374, 7375, 7336, 9034, 9035, 9036, 8956
2963, 7336, 7375, 7376, 7337, 9036, 9037, 9038, 8958
2964, 7337, 7376, 7377, 7338, 9038, 9039, 9040, 8960
2965, 7338, 7377, 7378, 7339, 9040, 9041, 9042, 8962
2966, 7339, 7378, 7379, 7340, 9042, 9043, 9044, 8964
2967, 7340, 7379, 7380, 7341, 9044, 9045, 9046, 8966
2968, 7341, 7380, 7381, 7342, 9046, 9047, 9048, 8968
2969, 7342, 7381, 7382, 7343, 9048, 9049, 9050, 8970
2970, 7343, 7382, 7383, 7344, 9050, 9051, 9052, 8972
2971, 7344, 7383, 7384, 7345, 9052, 9053, 9054, 8974
2972, 7345, 7384, 7385, 7346, 9054, 9055, 9056, 8976
2973, 7346, 7385, 7386, 7347, 9056, 9057, 9058, 8978
2974, 7347, 7386, 7387, 7348, 9058, 9059, 9060, 8980
2975, 7348, 7387, 7388, 7349, 9060, 9061, 9062, 8982
2976, 7349, 7388, 7389, 7350, 9062, 9063, 9064, 8984
2977, 7350, 7389, 7390, 7351, 9064, 9065, 9066, 8986
2978, 7351, 7390, 7391, 7352, 9066, 9067, 9068, 8988
2979, 7352, 7391, 7392, 7353, 9068, 9069, 9070, 8990
2980, 7353, 7392, 7393, 7354, 9070, 9071, 9072, 8992
2981, 7354, 7393, 7394, 7355, 9072, 9073, 9074, 8994
2982, 7355, 7394, 720, 719, 9074, 9075, 759, 8996
2983, 641, 642, 7395, 7356, 681, 9076, 9077, 8997
2984, 7356, 7395, 7396, 7357, 9077, 9078, 9079, 8999
2985, 7357, 7396, 7397, 7358, 9079, 9080, 9081, 9001
2986, 7358, 7397, 7398, 7359, 9081, 9082, 9083, 9003
2987, 7359, 7398, 7399, 7360, 9083, 9084, 9085, 9005
2988, 7360, 7399, 7400, 7361, 9085, 9086, 9087, 9007
2989, 7361, 7400, 7401, 7362, 9087, 9088, 9089, 9009
2990, 7362, 7401, 7402, 7363, 9089, 9090, 9091, 9011
2991, 7363, 7402, 7403, 7364, 9091, 9092, 9093, 9013
2992, 7364, 7403, 7404, 7365, 9093, 9094, 9095, 9015
2993, 7365, 7404, 7405, 7366, 9095, 9096, 9097, 9017
2994, 7366, 7405, 7406, 7367, 9097, 9098, 9099, 9019
2995, 7367, 7406, 7407, 7368, 9099, 9100, 9101, 9021
2996, 7368, 7407, 7408, 7369, 9101, 9102, 9103, 9023
2997, 7369, 7408, 7409, 7370, 9103, 9104, 9105, 9025
2998, 7370, 7409, 7410, 7371, 9105, 9106, 9107, 9027
2999, 7371, 7410, 7411, 7372, 9107, 9108, 9109, 9029
3000, 7372, 7411, 7412, 7373, 9109, 9110, 9111, 9031
3001, 7373, 7412, 7413, 7374, 9111, 9112, 9113, 9033
3002, 7374, 7413, 7414, 7375, 9113, 9114, 9115, 9035
3003, 7375, 7414, 7415, 7376, 9115, 9116, 9117, 9037
3004, 7376, 7415, 7416, 7377, 9117, 9118, 9119, 9039
3005, 7377, 7416, 7417, 7378, 9119, 9120, 9121, 9041
3006, 7378, 7417, 7418, 7379, 9121, 9122, 9123, 9043
3007, 7379, 7418, 7419, 7380, 9123, 9124, 9125, 9045
3008, 7380, 7419, 7420, 7381, 9125, 9126, 9127, 9047
3009, 7381, 7420, 7421, 7382, 9127, 9128, 9129, 9049
3010, 7382, 7421, 7422, 7383, 9129, 9130, 9131, 9051
3011, 7383, 7422, 7423, 7384, 9131, 9132, 9133, 9053
3012, 7384, 7423, 7424, 7385, 9133, 9134, 9135, 9055
3013, 7385, 7424, 7425, 7386, 9135, 9136, 9137, 9057
3014, 7386, 7425, 7426, 7387, 9137, 9138, 9139, 9059
3015, 7387, 7426, 7427, 7388, 9139, 9140, 9141, 9061
3016, 7388, 7427, 7428, 7389, 9141, 9142, 9143, 9063
3017, 7389, 7428, 7429, 7390, 9143, 9144, 9145, 9065
3018, 7390, 7429, 7430, 7391, 9145, 9146, 9147, 9067
3019, 7391, 7430, 7431, 7392, 9147, 9148, 9149, 9069
3020, 7392, 7431, 7432, 7393, 9149, 9150, 9151, 9071
3021, 7393, 7432, 7433, 7394, 9151, 9152, 9153, 9073
3022, 7394, 7433, 721, 720, 9153, 9154, 760, 9075
3023, 642, 643, 7434, 7395, 682, 9155, 9156, 9076
3024, 7395, 7434, 7435, 7396, 9156, 9157, 9158, 9078
3025, 7396, 7435, 7436, 7397, 9158, 9159, 9160, 9080
3026, 7397, 7436, 7437, 7398, 9160, 9161, 9162, 9082
3027, 7398, 7437, 7438, 7399, 9162, 9163, 9164, 9084
3028, 7399, 7438, 7439, 7400, 9164, 9165, 9166, 9086
3029, 7400, 7439, 7440, 7401, 9166, 9167, 9168, 9088
3030, 7401, 7440, 7441, 7402, 9168, 9169, 9170, 9090
3031, 7402, 7441, 7442, 7403, 9170, 9171, 9172, 9092
3032, 7403, 7442, 7443, 7404, 9172, 9173, 9174, 9094
3033, 7404, 7443, 7444, 7405, 9174, 9175, 9176, 9096
3034, 7405, 7444, 7445, 7406, 9176, 9177, 9178, 9098
3035, 7406, 7445, 7446, 7407, 9178, 9179, 9180, 9100
3036, 7407, 7446, 7447, 7408, 9180, 9181, 9182, 9102
3037, 7408, 7447, 7448, 7409, 9182, 9183, 9184, 9104
3038, 7409, 7448, 7449, 7410, 9184, 9185, 9186, 9106
3039, 7410, 7449, 7450, 7411, 9186, 9187, 9188, 9108
3040, 7411, 7450, 7451, 7412, 9188, 9189, 9190, 9110
3041, 7412, 7451, 7452, 7413, 9190, 9191, 9192, 9112
3042, 7413, 7452, 7453, 7414, 9192, 9193, 9194, 9114
3043, 7414, 7453, 7454, 7415, 9194, 9195, 9196, 9116
3044, 7415, 7454, 7455, 7416, 9196, 9197, 9198, 9118
3045, 7416, 7455, 7456, 7417, 9198, 9199, 9200, 9120
3046, 7417, 7456, 7457, 7418, 9200, 9201, 9202, 9122
3047, 7418, 7457, 7458, 7419, 9202, 9203, 9204, 9124
3048, 7419, 7458, 7459, 7420, 9204, 9205, 9206, 9126
3049, 7420, 7459, 7460, 7421, 9206, 9207, 9208, 9128
3050, 7421, 7460, 7461, 7422, 9208, 9209, 9210, 9130
3051, 7422, 7461, 7462, 7423, 9210, 9211, 9212, 9132
3052, 7423, 7462, 7463, 7424, 9212, 9213, 9214, 9134
3053, 7424, 7463, 7464, 7425, 9214, 9215, 9216, 9136
3054, 7425, 7464, 7465, 7426, 9216, 9217, 9218, 9138
3055, 7426, 7465, 7466, 7427, 9218, 9219, 9220, 9140
3056, 7427, 7466, 7467, 7428, 9220, 9221, 9222, 9142
3057, 7428, 7467, 7468, 7429, 9222, 9223, 9224, 9144
3058, 7429, 7468, 7469, 7430, 9224, 9225, 9226, 9146
3059, 7430, 7469, 7470, 7431, 9226, 9227, 9228, 9148
3060, 7431, 7470, 7471, 7432, 9228, 9229, 9230, 9150
3061, 7432, 7471, 7472, 7433, 9230, 9231, 9232, 9152
3062, 7433, 7472, 722, 721, 9232, 9233, 761, 9154
3063, 643, 644, 7473, 7434, 683, 9234, 9235, 9155
3064, 7434, 7473, 7474, 7435, 9235, 9236, 9237, 9157
3065, 7435, 7474, 7475, 7436, 9237, 9238, 9239, 9159
3066, 7436, 7475, 7476, 7437, 9239, 9240, 9241, 9161
3067, 7437, 7476, 7477, 7438, 9241, 9242, 9243, 9163
3068, 7438, 7477, 7478, 7439, 9243, 9244, 9245, 9165
3069, 7439, 7478, 7479, 7440, 9245, 9246, 9247, 9167
3070, 7440, 7479, 7480, 7441, 9247, 9248, 9249, 9169
3071, 7441, 7480, 7481, 7442, 9249, 9250, 9251, 9171
3072, 7442, 7481, 7482, 7443, 9251, 9252, 9253, 9173
3073, 7443, 7482, 7483, 7444, 9253, 9254, 9255, 9175
3074, 7444, 7483, 7484, 7445, 9255, 9256, 9257, 9177
3075, 7445, 7484, 7485, 7446, 9257, 9258, 9259, 9179
3076, 7446, 7485, 7486, 7447, 9259, 9260, 9261, 9181
3077, 7447, 7486, 7487, 7448, 9261, 9262, 9263, 9183
3078, 7448, 7487, 7488, 7449, 9263, 9264, 9265, 9185
3079, 7449, 7488, 7489, 7450, 9265, 9266, 9267, 9187
3080, 7450, 7489, 7490, 7451, 9267, 9268, 9269, 9189
3081, 7451, 7490, 7491, 7452, 9269, 9270, 9271, 9191
3082, 7452, 7491, 7492, 7453, 9271, 9272, 9273, 9193
3083, 7453, 7492, 7493, 7454, 9273, 9274, 9275, 9195
3084, 7454, 7493, 7494, 7455, 9275, 9276, 9277, 9197
3085, 7455, 7494, 7495, 7456, 9277, 9278, 9279, 9199
3086, 7456, 7495, 7496, 7457, 9279, 9280, 9281, 9201
3087, 7457, 7496, 7497, 7458, 9281, 9282, 9283, 9203
3088, 7458, 7497, 7498, 7459, 9283, 9284, 9285, 9205
3089, 7459, 7498, 7499, 7460, 9285, 9286, 9287, 9207
3090, 7460, 7499, 7500, 7461, 9287, 9288, 9289, 9209
3091, 7461, 7500, 7501, 7462, 9289, 9290, 9291, 9211
3092, 7462, 7501, 7502, 7463, 9291, 9292, 9293, 9213
3093, 7463, 7502, 7503, 7464, 9293, 9294, 9295, 9215
3094, 7464, 7503, 7504, 7465, 9295, 9296, 9297, 9217
3095, 7465, 7504, 7505, 7466, 9297, 9298, 9299, 9219
3096, 7466, 7505, 7506, 7467, 9299, 9300, 9301, 9221
3097, 7467, 7506, 7507, 7468, 9301, 9302, 9303, 9223
3098, 7468, 7507, 7508, 7469, 9303, 9304, 9305, 9225
3099, 7469, 7508, 7509, 7470, 9305, 9306, 9307, 9227
3100, 7470, 7509, 7510, 7471, 9307, 9308, 9309, 9229
3101, 7471, 7510, 7511, 7472, 9309, 9310, 9311, 9231
3102, 7472, 7511, 723, 722, 9311, 9312, 762, 9233
3103, 644, 645, 7512, 7473, 684, 9313, 9314, 9234
3104, 7473, 7512, 7513, 7474, 9314, 9315, 9316, 9236
3105, 7474, 7513, 7514, 7475, 9316, 9317, 9318, 9238
3106, 7475, 7514, 7515, 7476, 9318, 9319, 9320, 9240
3107, 7476, 7515, 7516, 7477, 9320, 9321, 9322, 9242
3108, 7477, 7516, 7517, 7478, 9322, 9323, 9324, 9244
3109, 7478, 7517, 7518, 7479, 9324, 9325, 9326, 9246
3110, 7479, 7518, 7519, 7480, 9326, 9327, 9328, 9248
3111, 7480, 7519, 7520, 7481, 9328, 9329, 9330, 9250
3112, 7481, 7520, 7521, 7482, 9330, 9331, 9332, 9252
3113, 7482, 7521, 7522, 7483, 9332, 9333, 9334, 9254
3114, 7483, 7522, 7523, 7484, 9334, 9335, 9336, 9256
3115, 7484, 7523, 7524, 7485, 9336, 9337, 9338, 9258
3116, 7485, 7524, 7525, 7486, 9338, 9339, 9340, 9260
3117, 7486, 7525, 7526, 7487, 9340, 9341, 9342, 9262
3118, 7487, 7526, 7527, 7488, 9342, 9343, 9344, 9264
3119, 7488, 7527, 7528, 7489, 9344, 9345, 9346, 9266
3120, 7489, 7528, 7529, 7490, 9346, 9347, 9348, 9268
3121, 7490, 7529, 7530, 7491, 9348, 9349, 9350, 9270
3122, 7491, 7530, 7531, 7492, 9350, 9351, 9352, 9272
3123, 7492, 7531, 7532, 7493, 9352, 9353, 9354, 9274
3124, 7493, 7532, 7533, 7494, 9354, 9355, 9356, 9276
3125, 7494, 7533, 7534, 7495, 9356, 9357, 9358, 9278
3126, 7495, 7534, 7535, 7496, 9358, 9359, 9360, 9280
3127, 7496, 7535, 7536, 7497, 9360, 9361, 9362, 9282
3128, 7497, 7536, 7537, 7498, 9362, 9363, 9364, 9284
3129, 7498, 7537, 7538, 7499, 9364, 9365, 9366, 9286
3130, 7499, 7538, 7539, 7500, 9366, 9367, 9368, 9288
3131, 7500, 7539, 7540, 7501, 9368, 9369, 9370, 9290
3132, 7501, 7540, 7541, 7502, 9370, 9371, 9372, 9292
3133, 7502, 7541, 7542, 7503, 9372, 9373, 9374, 9294
3134, 7503, 7542, 7543, 7504, 9374, 9375, 9376, 9296
3135, 7504, 7543, 7544, 7505, 9376, 9377, 9378, 9298
3136, 7505, 7544, 7545, 7506, 9378, 9379, 9380, 9300
3137, 7506, 7545, 7546, 7507, 9380, 9381, 9382, 9302
3138, 7507, 7546, 7547, 7508, 9382, 9383, 9384, 9304
3139, 7508, 7547, 7548, 7509, 9384, 9385, 9386, 9306
3140, 7509, 7548, 7549, 7510, 9386, 9387, 9388, 9308
3141, 7510, 7549, 7550, 7511, 9388, 9389, 9390, 9310
3142, 7511, 7550, 724, 723, 9390, 9391, 763, 9312
3143, 645, 646, 7551, 7512, 685, 9392, 9393, 9313
3144, 7512, 7551, 7552, 7513, 9393, 9394, 9395, 9315
3145, 7513, 7552, 7553, 7514, 9395, 9396, 9397, 9317
3146, 7514, 7553, 7554, 7515, 9397, 9398, 9399, 9319
3147, 7515, 7554, 7555, 7516, 9399, 9400, 9401, 9321
3148, 7516, 7555, 7556, 7517, 9401, 9402, 9403, 9323
3149, 7517, 7556, 7557, 7518, 9403, 9404, 9405, 9325
3150, 7518, 7557, 7558, 7519, 9405, 9406, 9407, 9327
3151, 7519, 7558, 7559, 7520, 9407, 9408, 9409, 9329
3152, 7520, 7559, 7560, 7521, 9409, 9410, 9411, 9331
3153, 7521, 7560, 7561, 7522, 9411, 9412, 9413, 9333
3154, 7522, 7561, 7562, 7523, 9413, 9414, 9415, 9335
3155, 7523, 7562, 7563, 7524, 9415, 9416, 9417, 9337
3156, 7524, 7563, 7564, 7525, 9417, 9418, 9419, 9339
3157, 7525, 7564, 7565, 7526, 9419, 9420, 9421, 9341
3158, 7526, 7565, 7566, 7527, 9421, 9422, 9423, 9343
3159, 7527, 7566, 7567, 7528, 9423, 9424, 9425, 9345
3160, 7528, 7567, 7568, 7529, 9425, 9426, 9427, 9347
3161, 7529, 7568, 7569, 7530, 9427, 9428, 9429, 9349
3162, 7530, 7569, 7570, 7531, 9429, 9430, 9431, 9351
3163, 7531, 7570, 7571, 7532, 9431, 9432, 9433, 9353
3164, 7532, 7571, 7572, 7533, 9433, 9434, 9435, 9355
3165, 7533, 7572, 7573, 7534, 9435, 9436, 9437, 9357
3166, 7534, 7573, 7574, 7535, 9437, 9438, 9439, 9359
3167, 7535, 7574, 7575, 7536, 9439, 9440, 9441, 9361
3168, 7536, 7575, 7576, 7537, 9441, 9442, 9443, 9363
3169, 7537, 7576, 7577, 7538, 9443, 9444, 9445, 9365
3170, 7538, 7577, 7578, 7539, 9445, 9446, 9447, 9367
3171, 7539, 7578, 7579, 7540, 9447, 9448, 9449, 9369
3172, 7540, 7579, 7580, 7541, 9449, 9450, 9451, 9371
3173, 7541, 7580, 7581, 7542, 9451, 9452, 9453, 9373
3174, 7542, 7581, 7582, 7543, 9453, 9454, 9455, 9375
3175, 7543, 7582, 7583, 7544, 9455, 9456, 9457, 9377
3176, 7544, 7583, 7584, 7545, 9457, 9458, 9459, 9379
3177, 7545, 7584, 7585, 7546, 9459, 9460, 9461, 9381
3178, 7546, 7585, 7586, 7547, 9461, 9462, 9463, 9383
3179, 7547, 7586, 7587, 7548, 9463, 9464, 9465, 9385
3180, 7548, 7587, 7588, 7549, 9465, 9466, 9467, 9387
3181, 7549, 7588, 7589, 7550, 9467, 9468, 9469, 9389
3182, 7550, 7589, 725, 724, 9469, 9470, 764, 9391
3183, 646, 647, 7590, 7551, 686, 9471, 9472, 9392
3184, 7551, 7590, 7591, 7552, 9472, 9473, 9474, 9394
3185, 7552, 7591, 7592, 7553, 9474, 9475, 9476, 9396
3186, 7553, 7592, 7593, 7554, 9476, 9477, 9478, 9398
3187, 7554, 7593, 7594, 7555, 9478, 9479, 9480, 9400
3188, 7555, 7594, 7595, 7556, 9480, 9481, 9482, 9402
3189, 7556, 7595, 7596, 7557, 9482, 9483, 9484, 9404
3190, 7557, 7596, 7597, 7558, 9484, 9485, 9486, 9406
3191, 7558, 7597, 7598, 7559, 9486, 9487, 9488, 9408
3192, 7559, 7598, 7599, 7560, 9488, 9489, 9490, 9410
3193, 7560, 7599, 7600, 7561, 9490, 9491, 9492, 9412
3194, 7561, 7600, 7601, 7562, 9492, 9493, 9494, 9414
3195, 7562, 7601, 7602, 7563, 9494, 9495, 9496, 9416
3196, 7563, 7602, 7603, 7564, 9496, 9497, 9498, 9418
3197, 7564, 7603, 7604, 7565, 9498, 9499, 9500, 9420
3198, 7565, 7604, 7605, 7566, 9500, 9501, 9502, 9422
3199, 7566, 7605, 7606, 7567, 9502, 9503, 9504, 9424
3200, 7567, 7606, 7607, 7568, 9504, 9505, 9506, 9426
3201, 7568, 7607, 7608, 7569, 9506, 9507, 9508, 9428
3202, 7569, 7608, 7609, 7570, 9508, 9509, 9510, 9430
3203, 7570, 7609, 7610, 7571, 9510, 9511, 9512, 9432
3204, 7571, 7610, 7611, 7572, 9512, 9513, 9514, 9434
3205, 7572, 7611, 7612, 7573, 9514, 9515, 9516, 9436
3206, 7573, 7612, 7613, 7574, 9516, 9517, 9518, 9438
3207, 7574, 7613, 7614, 7575, 9518, 9519, 9520, 9440
3208, 7575, 7614, 7615, 7576, 9520, 9521, 9522, 9442
3209, 7576, 7615, 7616, 7577, 9522, 9523, 9524, 9444
3210, 7577, 7616, 7617, 7578, 9524, 9525, 9526, 9446
3211, 7578, 7617, 7618, 7579, 9526, 9527, 9528, 9448
3212, 7579, 7618, 7619, 7580, 9528, 9529, 9530, 9450
3213, 7580, 7619, 7620, 7581, 9530, 9531, 9532, 9452
3214, 7581, 7620, 7621, 7582, 9532, 9533, 9534, 9454
3215, 7582, 7621, 7622, 7583, 9534, 9535, 9536, 9456
3216, 7583, 7622, 7623, 7584, 9536, 9537, 9538, 9458
3217, 7584, 7623, 7624, 7585, 9538, 9539, 9540, 9460
3218, 7585, 7624, 7625, 7586, 9540, 9541, 9542, 9462
3219, 7586, 7625, 7626, 7587, 9542, 9543, 9544, 9464
3220, 7587, 7626, 7627, 7588, 9544, 9545, 9546, 9466
3221, 7588, 7627, 7628, 7589, 9546, 9547, 9548, 9468
3222, 7589, 7628, 726, 725, 9548, 9549, 765, 9470
3223, 647, 648, 7629, 7590, 687, 9550, 9551, 9471
3224, 7590, 7629, 7630, 7591, 9551, 9552, 9553, 9473
3225, 7591, 7630, 7631, 7592, 9553, 9554, 9555, 9475
3226, 7592, 7631, 7632, 7593, 9555, 9556, 9557, 9477
3227, 7593, 7632, 7633, 7594, 9557, 9558, 9559, 9479
3228, 7594, 7633, 7634, 7595, 9559, 9560, 9561, 9481
3229, 7595, 7634, 7635, 7596, 9561, 9562, 9563, 9483
3230, 7596, 7635, 7636, 7597, 9563, 9564, 9565, 9485
3231, 7597, 7636, 7637, 7598, 9565, 9566, 9567, 9487
3232, 7598, 7637, 7638, 7599, 9567, 9568, 9569, 9489
3233, 7599, 7638, 7639, 7600, 9569, 9570, 9571, 9491
3234, 7600, 7639, 7640, 7601, 9571, 9572, 9573, 9493
3235, 7601, 7640, 7641, 7602, 9573, 9574, 9575, 9495
3236, 7602, 7641, 7642, 7603, 9575, 9576, 9577, 9497
3237, 7603, 7642, 7643, 7604, 9577, 9578, 9579, 9499
3238, 7604, 7643, 7644, 7605, 9579, 9580, 9581, 9501
3239, 7605, 7644, 7645, 7606, 9581, 9582, 9583, 9503
3240, 7606, 7645, 7646, 7607, 9583, 9584, 9585, 9505
3241, 7607, 7646, 7647, 7608, 9585, 9586, 9587, 9507
3242, 7608, 7647, 7648, 7609, 9587, 9588, 9589, 9509
3243, 7609, 7648, 7649, 7610, 9589, 9590, 9591, 9511
3244, 7610, 7649, 7650, 7611, 9591, 9592, 9593, 9513
3245, 7611, 7650, 7651, 7612, 9593, 9594, 9595, 9515
3246, 7612, 7651, 7652, 7613, 9595, 9596, 9597, 9517
3247, 7613, 7652, 7653, 7614, 9597, 9598, 9599, 9519
3248, 7614, 7653, 7654, 7615, 9599, 9600, 9601, 9521
3249, 7615, 7654, 7655, 7616, 9601, 9602, 9603, 9523
3250, 7616, 7655, 7656, 7617, 9603, 9604, 9605, 9525
3251, 7617, 7656, 7657, 7618, 9605, 9606, 9607, 9527
3252, 7618, 7657, 7658, 7619, 9607, 9608, 9609, 9529
3253, 7619, 7658, 7659, 7620, 9609, 9610, 9611, 9531
3254, 7620, 7659, 7660, 7621, 9611, 9612, 9613, 9533
3255, 7621, 7660, 7661, 7622, 9613, 9614, 9615, 9535
3256, 7622, 7661, 7662, 7623, 9615, 9616, 9617, 9537
3257, 7623, 7662, 7663, 7624, 9617, 9618, 9619, 9539
3258, 7624, 7663, 7664, 7625, 9619, 9620, 9621, 9541
3259, 7625, 7664, 7665, 7626, 9621, 9622, 9623, 9543
3260, 7626, 7665, 7666, 7627, 9623, 9624, 9625, 9545
3261, 7627, 7666, 7667, 7628, 9625, 9626, 9627, 9547
3262, 7628, 7667, 727, 726, 9627, 9628, 766, 9549
3263, 648, 649, 7668, 7629, 688, 9629, 9630, 9550
3264, 7629, 7668, 7669, 7630, 9630, 9631, 9632, 9552
3265, 7630, 7669, 7670, 7631, 9632, 9633, 9634, 9554
3266, 7631, 7670, 7671, 7632, 9634, 9635, 9636, 9556
3267, 7632, 7671, 7672, 7633, 9636, 9637, 9638, 9558
3268, 7633, 7672, 7673, 7634, 9638, 9639, 9640, 9560
3269, 7634, 7673, 7674, 7635, 9640, 9641, 9642, 9562
3270, 7635, 7674, 7675, 7636, 9642, 9643, 9644, 9564
3271, 7636, 7675, 7676, 7637, 9644, 9645, 9646, 9566
3272, 7637, 7676, 7677, 7638, 9646, 9647, 9648, 9568
3273, 7638, 7677, 7678, 7639, 9648, 9649, 9650, 9570
3274, 7639, 7678, 7679, 7640, 9650, 9651, 9652, 9572
3275, 7640, 7679, 7680, 7641, 9652, 9653, 9654, 9574
3276, 7641, 7680, 7681, 7642, 9654, 9655, 9656, 9576
3277, 7642, 7681, 7682, 7643, 9656, 9657, 9658, 9578
3278, 7643, 7682, 7683, 7644, 9658, 9659, 9660, 9580
3279, 7644, 7683, 7684, 7645, 9660, 9661, 9662, 9582
3280, 7645, 7684, 7685, 7646, 9662, 9663, 9664, 9584
3281, 7646, 7685, 7686, 7647, 9664, 9665, 9666, 9586
3282, 7647, 7686, 7687, 7648, 9666, 9667, 9668, 9588
3283, 7648, 7687, 7688, 7649, 9668, 9669, 9670, 9590
3284, 7649, 7688, 7689, 7650, 9670, 9671, 9672, 9592
3285, 7650, 7689, 7690, 7651, 9672, 9673, 9674, 9594
3286, 7651, 7690, 7691, 7652, 9674, 9675, 9676, 9596
3287, 7652, 7691, 7692, 7653, 9676, 9677, 9678, 9598
3288, 7653, 7692, 7693, 7654, 9678, 9679, 9680, 9600
3289, 7654, 7693, 7694, 7655, 9680, 9681, 9682, 9602
3290, 7655, 7694, 7695, 7656, 9682, 9683, 9684, 9604
3291, 7656, 7695, 7696, 7657, 9684, 9685, 9686, 9606
3292, 7657, 7696, 7697, 7658, 9686, 9687, 9688, 9608
3293, 7658, 7697, 7698, 7659, 9688, 9689, 9690, 9610
3294, 7659, 7698, 7699, 7660, 9690, 9691, 9692, 9612
3295, 7660, 7699, 7700, 7661, 9692, 9693, 9694, 9614
3296, 7661, 7700, 7701, 7662, 9694, 9695, 9696, 9616
3297, 7662, 7701, 7702, 7663, 9696, 9697, 9698, 9618
3298, 7663, 7702, 7703, 7664, 9698, 9699, 9700, 9620
3299, 7664, 7703, 7704, 7665, 9700, 9701, 9702, 9622
3300, 7665, 7704, 7705, 7666, 9702, 9703, 9704, 9624
3301, 7666, 7705, 7706, 7667, 9704, 9705, 9706, 9626
3302, 7667, 7706, 728, 727, 9706, 9707, 767, 9628
3303, 649, 650, 7707, 7668, 689, 9708, 9709, 9629
3304, 7668, 7707, 7708, 7669, 9709, 9710, 9711, 9631
3305, 7669, 7708, 7709, 7670, 9711, 9712, 9713, 9633
3306, 7670, 7709, 7710, 7671, 9713, 9714, 9715, 9635
3307, 7671, 7710, 7711, 7672, 9715, 9716, 9717, 9637
3308, 7672, 7711, 7712, 7673, 9717, 9718, 9719, 9639
3309, 7673, 7712, 7713, 7674, 9719, 9720, 9721, 9641
3310, 7674, 7713, 7714, 7675, 9721, 9722, 9723, 9643
3311, 7675, 7714, 7715, 7676, 9723, 9724, 9725, 9645
3312, 7676, 7715, 7716, 7677, 9725, 9726, 9727, 9647
3313, 7677, 7716, 7717, 7678, 9727, 9728, 9729, 9649
3314, 7678, 7717, 7718, 7679, 9729, 9730, 9731, 9651
3315, 7679, 7718, 7719, 7680, 9731, 9732, 9733, 9653
3316, 7680, 7719, 7720, 7681, 9733, 9734, 9735, 9655
3317, 7681, 7720, 7721, 7682, 9735, 9736, 9737, 9657
3318, 7682, 7721, 7722, 7683, 9737, 9738, 9739, 9659
3319, 7683, 7722, 7723, 7684, 9739, 9740, 9741, 9661
3320, 7684, 7723, 7724, 7685, 9741, 9742, 9743, 9663
3321, 7685, 7724, 7725, 7686, 9743, 9744, 9745, 9665
3322, 7686, 7725, 7726, 7687, 9745, 9746, 9747, 9667
3323, 7687, 7726, 7727, 7688, 9747, 9748, 9749, 9669
3324, 7688, 7727, 7728, 7689, 9749, 9750, 9751, 9671
3325, 7689, 7728, 7729, 7690, 9751, 9752, 9753, 9673
3326, 7690, 7729, 7730, 7691, 9753, 9754, 9755, 9675
3327, 7691, 7730, 7731, 7692, 9755, 9756, 9757, 9677
3328, 7692, 7731, 7732, 7693, 9757, 9758, 9759, 9679
3329, 7693, 7732, 7733, 7694, 9759, 9760, 9761, 9681
3330, 7694, 7733, 7734, 7695, 9761, 9762, 9763, 9683
3331, 7695, 7734, 7735, 7696, 9763, 9764, 9765, 9685
3332, 7696, 7735, 7736, 7697, 9765, 9766, 9767, 9687
3333, 7697, 7736, 7737, 7698, 9767, 9768, 9769, 9689
3334, 7698, 7737, 7738, 7699, 9769, 9770, 9771, 9691
3335, 7699, 7738, 7739, 7700, 9771, 9772, 9773, 9693
3336, 7700, 7739, 7740, 7701, 9773, 9774, 9775, 9695
3337, 7701, 7740, 7741, 7702, 9775, 9776, 9777, 9697
3338, 7702, 7741, 7742, 7703, 9777, 9778, 9779, 9699
3339, 7703, 7742, 7743, 7704, 9779, 9780, 9781, 9701
3340, 7704, 7743, 7744, 7705, 9781, 9782, 9783, 9703
3341, 7705, 7744, 7745, 7706, 9783, 9784, 9785, 9705
3342, 7706, 7745, 729, 728, 9785, 9786, 768, 9707
3343, 650, 651, 7746, 7707, 690, 9787, 9788, 9708
3344, 7707, 7746, 7747, 7708, 9788, 9789, 9790, 9710
3345, 7708, 7747, 7748, 7709, 9790, 9791, 9792, 9712
3346, 7709, 7748, 7749, 7710, 9792, 9793, 9794, 9714
3347, 7710, 7749, 7750, 7711, 9794, 9795, 9796, 9716
3348, 7711, 7750, 7751, 7712, 9796, 9797, 9798, 9718
3349, 7712, 7751, 7752, 7713, 9798, 9799, 9800, 9720
3350, 7713, 7752, 7753, 7714, 9800, 9801, 9802, 9722
3351, 7714, 7753, 7754, 7715, 9802, 9803, 9804, 9724
3352, 7715, 7754, 7755, 7716, 9804, 9805, 9806, 9726
3353, 7716, 7755, 7756, 7717, 9806, 9807, 9808, 9728
3354, 7717, 7756, 7757, 7718, 9808, 9809, 9810, 9730
3355, 7718, 7757, 7758, 7719, 9810, 9811, 9812, 9732
3356, 7719, 7758, 7759, 7720, 9812, 9813, 9814, 9734
3357, 7720, 7759, 7760, 7721, 9814, 9815, 9816, 9736
3358, 7721, 7760, 7761, 7722, 9816, 9817, 9818, 9738
3359, 7722, 7761, 7762, 7723, 9818, 9819, 9820, 9740
3360, 7723, 7762, 7763, 7724, 9820, 9821, 9822, 9742
3361, 7724, 7763, 7764, 7725, 9822, 9823, 9824, 9744
3362, 7725, 7764, 7765, 7726, 9824, 9825, 9826, 9746
3363, 7726, 7765, 7766, 7727, 9826, 9827, 9828, 9748
3364, 7727, 7766, 7767, 7728, 9828, 9829, 9830, 9750
3365, 7728, 7767, 7768, 7729, 9830, 9831, 9832, 9752
3366, 7729, 7768, 7769, 7730, 9832, 9833, 9834, 9754
3367, 7730, 7769, 7770, 7731, 9834, 9835, 9836, 9756
3368, 7731, 7770, 7771, 7732, 9836, 9837, 9838, 9758
3369, 7732, 7771, 7772, 7733, 9838, 9839, 9840, 9760
3370, 7733, 7772, 7773, 7734, 9840, 9841, 9842, 9762
3371, 7734, 7773, 7774, 7735, 9842, 9843, 9844, 9764
3372, 7735, 7774, 7775, 7736, 9844, 9845, 9846, 9766
3373, 7736, 7775, 7776, 7737, 9846, 9847, 9848, 9768
3374, 7737, 7776, 7777, 7738, 9848, 9849, 9850, 9770
3375, 7738, 7777, 7778, 7739, 9850, 9851, 9852, 9772
3376, 7739, 7778, 7779, 7740, 9852, 9853, 9854, 9774
3377, 7740, 7779, 7780, 7741, 9854, 9855, 9856, 9776
3378, 7741, 7780, 7781, 7742, 9856, 9857, 9858, 9778
3379, 7742, 7781, 7782, 7743, 9858, 9859, 9860, 9780
3380, 7743, 7782, 7783, 7744, 9860, 9861, 9862, 9782
3381, 7744, 7783, 7784, 7745, 9862, 9863, 9864, 9784
3382, 7745, 7784, 730, 729, 9864, 9865, 769, 9786
3383, 651, 652, 7785, 7746, 691, 9866, 9867, 9787
3384, 7746, 7785, 7786, 7747, 9867, 9868, 9869, 9789
3385, 7747, 7786, 7787, 7748, 9869, 9870, 9871, 9791
3386, 7748, 7787, 7788, 7749, 9871, 9872, 9873, 9793
3387, 7749, 7788, 7789, 7750, 9873, 9874, 9875, 9795
3388, 7750, 7789, 7790, 7751, 9875, 9876, 9877, 9797
3389, 7751, 7790, 7791, 7752, 9877, 9878, 9879, 9799
3390, 7752, 7791, 7792, 7753, 9879, 9880, 9881, 9801
3391, 7753, 7792, 7793, 7754, 9881, 9882, 9883, 9803
3392, 7754, 7793, 7794, 7755, 9883, 9884, 9885, 9805
3393, 7755, 7794, 7795, 7756, 9885, 9886, 9887, 9807
3394, 7756, 7795, 7796, 7757, 9887, 9888, 9889, 9809
3395, 7757, 7796, 7797, 7758, 9889, 9890, 9891, 9811
3396, 7758, 7797, 7798, 7759, 9891, 9892, 9893, 9813
3397, 7759, 7798, 7799, 7760, 9893, 9894, 9895, 9815
3398, 7760, 7799, 7800, 7761, 9895, 9896, 9897, 9817
3399, 7761, 7800, 7801, 7762, 9897, 9898, 9899, 9819
3400, 7762, 7801, 7802, 7763, 9899, 9900, 9901, 9821
3401, 7763, 7802, 7803, 7764, 9901, 9902, 9903, 9823
3402, 7764, 7803, 7804, 7765, 9903, 9904, 9905, 9825
3403, 7765, 7804, 7805, 7766, 9905, 9906, 9907, 9827
3404, 7766, 7805, 7806, 7767, 9907, 9908, 9909, 9829
3405, 7767, 7806, 7807, 7768, 9909, 9910, 9911, 9831
3406, 7768, 7807, 7808, 7769, 9911, 9912, 9913, 9833
3407, 7769, 7808, 7809, 7770, 9913, 9914, 9915, 9835
3408, 7770, 7809, 7810, 7771, 9915, 9916, 9917, 9837
3409, 7771, 7810, 7811, 7772, 9917, 9918, 9919, 9839
3410, 7772, 7811, 7812, 7773, 9919, 9920, 9921, 9841
3411, 7773, 7812, 7813, 7774, 9921, 9922, 9923, 9843
3412, 7774, 7813, 7814, 7775, 9923, 9924, 9925, 9845
3413, 7775, 7814, 7815, 7776, 9925, 9926, 9927, 9847
3414, 7776, 7815, 7816, 7777, 9927, 9928, 9929, 9849
3415, 7777, 7816, 7817, 7778, 9929, 9930, 9931, 9851
3416, 7778, 7817, 7818, 7779, 9931, 9932, 9933, 9853
3417, 7779, 7818, 7819, 7780, 9933, 9934, 9935, 9855
3418, 7780, 7819, 7820, 7781, 9935, 9936, 9937, 9857
3419, 7781, 7820, 7821, 7782, 9937, 9938, 9939, 9859
3420, 7782, 7821, 7822, 7783, 9939, 9940, 9941, 9861
3421, 7783, 7822, 7823, 7784, 9941, 9942, 9943, 9863
3422, 7784, 7823, 731, 730, 9943, 9944, 770, 9865
3423, 652, 653, 7824, 7785, 692, 9945, 9946, 9866
3424, 7785, 7824, 7825, 7786, 9946, 9947, 9948, 9868
3425, 7786, 7825, 7826, 7787, 9948, 9949, 9950, 9870
3426, 7787, 7826, 7827, 7788, 9950, 9951, 9952, 9872
3427, 7788, 7827, 7828, 7789, 9952, 9953, 9954, 9874
3428, 7789, 7828, 7829, 7790, 9954, 9955, 9956, 9876
3429, 7790, 7829, 7830, 7791, 9956, 9957, 9958, 9878
3430, 7791, 7830, 7831, 7792, 9958, 9959, 9960, 9880
3431, 7792, 7831, 7832, 7793, 9960, 9961, 9962, 9882
3432, 7793, 7832, 7833, 7794, 9962, 9963, 9964, 9884
3433, 7794, 7833, 7834, 7795, 9964, 9965, 9966, 9886
3434, 7795, 7834, 7835, 7796, 9966, 9967, 9968, 9888
3435, 7796, 7835, 7836, 7797, 9968, 9969, 9970, 9890
3436, 7797, 7836, 7837, 7798, 9970, 9971, 9972, 9892
3437, 7798, 7837, 7838, 7799, 9972, 9973, 9974, 9894
3438, 7799, 7838, 7839, 7800, 9974, 9975, 9976, 9896
3439, 7800, 7839, 7840, 7801, 9976, 9977, 9978, 9898
3440, 7801, 7840, 7841, 7802, 9978, 9979, 9980, 9900
3441, 7802, 7841, 7842, 7803, 9980, 9981, 9982, 9902
3442, 7803, 7842, 7843, 7804, 9982, 9983, 9984, 9904
3443, 7804, 7843, 7844, 7805, 9984, 9985, 9986, 9906
3444, 7805, 7844, 7845, 7806, 9986, 9987, 9988, 9908
3445, 7806, 7845, 7846, 7807, 9988, 9989, 9990, 9910
3446, 7807, 7846, 7847, 7808, 9990, 9991, 9992, 9912
3447, 7808, 7847, 7848, 7809, 9992, 9993, 9994, 9914
3448, 7809, 7848, 7849, 7810, 9994, 9995, 9996, 9916
3449, 7810, 7849, 7850, 7811, 9996, 9997, 9998, 9918
3450, 7811, 7850, 7851, 7812, 9998, 9999, 10000, 9920
3451, 7812, 7851, 7852, 7813, 10000, 10001, 10002, 9922
3452, 7813, 7852, 7853, 7814, 10002, 10003, 10004, 9924
3453, 7814, 7853, 7854, 7815, 10004, 10005, 10006, 9926
3454, 7815, 7854, 7855, 7816, 10006, 10007, 10008, 9928
3455, 7816, 7855, 7856, 7817, 10008, 10009, 10010, 9930
3456, 7817, 7856, 7857, 7818, 10010, 10011, 10012, 9932
3457, 7818, 7857, 7858, 7819, 10012, 10013, 10014, 9934
3458, 7819, 7858, 7859, 7820, 10014, 10015, 10016, 9936
3459, 7820, 7859, 7860, 7821, 10016, 10017, 10018, 9938
3460, 7821, 7860, 7861, 7822, 10018, 10019, 10020, 9940
3461, 7822, 7861, 7862, 7823, 10020, 10021, 10022, 9942
3462, 7823, 7862, 732, 731, 10022, 10023, 771, 9944
3463, 653, 654, 7863, 7824, 693, 10024, 10025, 9945
3464, 7824, 7863, 7864, 7825, 10025, 10026, 10027, 9947
3465, 7825, 7864, 7865, 7826, 10027, 10028, 10029, 9949
3466, 7826, 7865, 7866, 7827, 10029, 10030, 10031, 9951
3467, 7827, 7866, 7867, 7828, 10031, 10032, 10033, 9953
3468, 7828, 7867, 7868, 7829, 10033, 10034, 10035, 9955
3469, 7829, 7868, 7869, 7830, 10035, 10036, 10037, 9957
3470, 7830, 7869, 7870, 7831, 10037, 10038, 10039, 9959
3471, 7831, 7870, 7871, 7832, 10039, 10040, 10041, 9961
3472, 7832, 7871, 7872, 7833, 10041, 10042, 10043, 9963
3473, 7833, 7872, 7873, 7834, 10043, 10044, 10045, 9965
3474, 7834, 7873, 7874, 7835, 10045, 10046, 10047, 9967
3475, 7835, 7874, 7875, 7836, 10047, 10048, 10049, 9969
3476, 7836, 7875, 7876, 7837, 10049, 10050, 10051, 9971
3477, 7837, 7876, 7877, 7838, 10051, 10052, 10053, 9973
3478, 7838, 7877, 7878, 7839, 10053, 10054, 10055, 9975
3479, 7839, 7878, 7879, 7840, 10055, 10056, 10057, 9977
3480, 7840, 7879, 7880, 7841, 10057, 10058, 10059, 9979
3481, 7841, 7880, 7881, 7842, 10059, 10060, 10061, 9981
3482, 7842, 7881, 7882, 7843, 10061, 10062, 10063, 9983
3483, 7843, 7882, 7883, 7844, 10063, 10064, 10065, 9985
3484, 7844, 7883, 7884, 7845, 10065, 10066, 10067, 9987
3485, 7845, 7884, 7885, 7846, 10067, 10068, 10069, 9989
3486, 7846, 7885, 7886, 7847, 10069, 10070, 10071, 9991
3487, 7847, 7886, 7887, 7848, 10071, 10072, 10073, 9993
3488, 7848, 7887, 7888, 7849, 10073, 10074, 10075, 9995
3489, 7849, 7888, 7889, 7850, 10075, 10076, 10077, 9997
3490, 7850, 7889, 7890, 7851, 10077, 10078, 10079, 9999
3491, 7851, 7890, 7891, 7852, 10079, 10080, 10081, 10001
3492, 7852, 7891, 7892, 7853, 10081, 10082, 10083, 10003
3493, 7853, 7892, 7893, 7854, 10083, 10084, 10085, 10005
3494, 7854, 7893, 7894, 7855, 10085, 10086, 10087, 10007
3495, 7855, 7894, 7895, 7856, 10087, 10088, 10089, 10009
3496, 7856, 7895, 7896, 7857, 10089, 10090, 10091, 10011
3497, 7857, 7896, 7897, 7858, 10091, 10092, 10093, 10013
3498, 7858, 7897, 7898, 7859, 10093, 10094, 10095, 10015
3499, 7859, 7898, 7899, 7860, 10095, 10096, 10097, 10017
3500, 7860, 7899, 7900, 7861, 10097, 10098, 10099, 10019
3501, 7861, 7900, 7901, 7862, 10099, 10100, 10101, 10021
3502, 7862, 7901, 733, 732, 10101, 10102, 772, 10023
3503, 654, 655, 7902, 7863, 694, 10103, 10104, 10024
3504, 7863, 7902, 7903, 7864, 10104, 10105, 10106, 10026
3505, 7864, 7903, 7904, 7865, 10106, 10107, 10108, 10028
3506, 7865, 7904, 7905, 7866, 10108, 10109, 10110, 10030
3507, 7866, 7905, 7906, 7867, 10110, 10111, 10112, 10032
3508, 7867, 7906, 7907, 7868, 10112, 10113, 10114, 10034
3509, 7868, 7907, 7908, 7869, 10114, 10115, 10116, 10036
3510, 7869, 7908, 7909, 7870, 10116, 10117, 10118, 10038
3511, 7870, 7909, 7910, 7871, 10118, 10119, 10120, 10040
3512, 7871, 7910, 7911, 7872, 10120, 10121, 10122, 10042
3513, 7872, 7911, 7912, 7873, 10122, 10123, 10124, 10044
3514, 7873, 7912, 7913, 7874, 10124, 10125, 10126, 10046
3515, 7874, 7913, 7914, 7875, 10126, 10127, 10128, 10048
3516, 7875, 7914, 7915, 7876, 10128, 10129, 10130, 10050
3517, 7876, 7915, 7916, 7877, 10130, 10131, 10132, 10052
3518, 7877, 7916, 7917, 7878, 10132, 10133, 10134, 10054
3519, 7878, 7917, 7918, 7879, 10134, 10135, 10136, 10056
3520, 7879, 7918, 7919, 7880, 10136, 10137, 10138, 10058
3521, 7880, 7919, 7920, 7881, 10138, 10139, 10140, 10060
3522, 7881, 7920, 7921, 7882, 10140, 10141, 10142, 10062
3523, 7882, 7921, 7922, 7883, 10142, 10143, 10144, 10064
3524, 7883, 7922, 7923, 7884, 10144, 10145, 10146, 10066
3525, 7884, 7923, 7924, 7885, 10146, 10147, 10148, 10068
3526, 7885, 7924, 7925, 7886, 10148, 10149, 10150, 10070
3527, 7886, 7925, 7926, 7887, 10150, 10151, 10152, 10072
3528, 7887, 7926, 7927, 7888, 10152, 10153, 10154, 10074
3529, 7888, 7927, 7928, 7889, 10154, 10155, 10156, 10076
3530, 7889, 7928, 7929, 7890, 10156, 10157, 10158, 10078
3531, 7890, 7929, 7930, 7891, 10158, 10159, 10160, 10080
3532, 7891, 7930, 7931, 7892, 10160, 10161, 10162, 10082
3533, 7892, 7931, 7932, 7893, 10162, 10163, 10164, 10084
3534, 7893, 7932, 7933, 7894, 10164, 10165, 10166, 10086
3535, 7894, 7933, 7934, 7895, 10166, 10167, 10168, 10088
3536, 7895, 7934, 7935, 7896, 10168, 10169, 10170, 10090
3537, 7896, 7935, 7936, 7897, 10170, 10171, 10172, 10092
3538, 7897, 7936, 7937, 7898, 10172, 10173, 10174, 10094
3539, 7898, 7937, 7938, 7899, 10174, 10175, 10176, 10096
3540, 7899, 7938, 7939, 7900, 10176, 10177, 10178, 10098
3541, 7900, 7939, 7940, 7901, 10178, 10179, 10180, 10100
3542, 7901, 7940, 734, 733, 10180, 10181, 773, 10102
3543, 655, 656, 7941, 7902, 695, 10182, 10183, 10103
3544, 7902, 7941, 7942, 7903, 10183, 10184, 10185, 10105
3545, 7903, 7942, 7943, 7904, 10185, 10186, 10187, 10107
3546, 7904, 7943, 7944, 7905, 10187, 10188, 10189, 10109
3547, 7905, 7944, 7945, 7906, 10189, 10190, 10191, 10111
3548, 7906, 7945, 7946, 7907, 10191, 10192, 10193, 10113
3549, 7907, 7946, 7947, 7908, 10193, 10194, 10195, 10115
3550, 7908, 7947, 7948, 7909, 10195, 10196, 10197, 10117
3551, 7909, 7948, 7949, 7910, 10197, 10198, 10199, 10119
3552, 7910, 7949, 7950, 7911, 10199, 10200, 10201, 10121
3553, 7911, 7950, 7951, 7912, 10201, 10202, 10203, 10123
3554, 7912, 7951, 7952, 7913, 10203, 10204, 10205, 10125
3555, 7913, 7952, 7953, 7914, 10205, 10206, 10207, 10127
3556, 7914, 7953, 7954, 7915, 10207, 10208, 10209, 10129
3557, 7915, 7954, 7955, 7916, 10209, 10210, 10211, 10131
3558, 7916, 7955, 7956, 7917, 10211, 10212, 10213, 10133
3559, 7917, 7956, 7957, 7918, 10213, 10214, 10215, 10135
3560, 7918, 7957, 7958, 7919, 10215, 10216, 10217, 10137
3561, 7919, 7958, 7959, 7920, 10217, 10218, 10219, 10139
3562, 7920, 7959, 7960, 7921, 10219, 10220, 10221, 10141
3563, 7921, 7960, 7961, 7922, 10221, 10222, 10223, 10143
3564, 7922, 7961, 7962, 7923, 10223, 10224, 10225, 10145
3565, 7923, 7962, 7963, 7924, 10225, 10226, 10227, 10147
3566, 7924, 7963, 7964, 7925, 10227, 10228, 10229, 10149
3567, 7925, 7964, 7965, 7926, 10229, 10230, 10231, 10151
3568, 7926, 7965, 7966, 7927, 10231, 10232, 10233, 10153
3569, 7927, 7966, 7967, 7928, 10233, 10234, 10235, 10155
3570, 7928, 7967, 7968, 7929, 10235, 10236, 10237, 10157
3571, 7929, 7968, 7969, 7930, 10237, 10238, 10239, 10159
3572, 7930, 7969, 7970, 7931, 10239, 10240, 10241, 10161
3573, 7931, 7970, 7971, 7932, 10241, 10242, 10243, 10163
3574, 7932, 7971, 7972, 7933, 10243, 10244, 10245, 10165
3575, 7933, 7972, 7973, 7934, 10245, 10246, 10247, 10167
3576, 7934, 7973, 7974, 7935, 10247, 10248, 10249, 10169
3577, 7935, 7974, 7975, 7936, 10249, 10250, 10251, 10171
3578, 7936, 7975, 7976, 7937, 10251, 10252, 10253, 10173
3579, 7937, 7976, 7977, 7938, 10253, 10254, 10255, 10175
3580, 7938, 7977, 7978, 7939, 10255, 10256, 10257, 10177
3581, 7939, 7978, 7979, 7940, 10257, 10258, 10259, 10179
3582, 7940, 7979, 735, 734, 10259, 10260, 774, 10181
3583, 656, 657, 7980, 7941, 696, 10261, 10262, 10182
3584, 7941, 7980, 7981, 7942, 10262, 10263, 10264, 10184
3585, 7942, 7981, 7982, 7943, 10264, 10265, 10266, 10186
3586, 7943, 7982, 7983, 7944, 10266, 10267, 10268, 10188
3587, 7944, 7983, 7984, 7945, 10268, 10269, 10270, 10190
3588, 7945, 7984, 7985, 7946, 10270, 10271, 10272, 10192
3589, 7946, 7985, 7986, 7947, 10272, 10273, 10274, 10194
3590, 7947, 7986, 7987, 7948, 10274, 10275, 10276, 10196
3591, 7948, 7987, 7988, 7949, 10276, 10277, 10278, 10198
3592, 7949, 7988, 7989, 7950, 10278, 10279, 10280, 10200
3593, 7950, 7989, 7990, 7951, 10280, 10281, 10282, 10202
3594, 7951, 7990, 7991, 7952, 10282, 10283, 10284, 10204
3595, 7952, 7991, 7992, 7953, 10284, 10285, 10286, 10206
3596, 7953, 7992, 7993, 7954, 10286, 10287, 10288, 10208
3597, 7954, 7993, 7994, 7955, 10288, 10289, 10290, 10210
3598, 7955, 7994, 7995, 7956, 10290, 10291, 10292, 10212
3599, 7956, 7995, 7996, 7957, 10292, 10293, 10294, 10214
3600, 7957, 7996, 7997, 7958, 10294, 10295, 10296, 10216
3601, 7958, 7997, 7998, 7959, 10296, 10297, 10298, 10218
3602, 7959, 7998, 7999, 7960, 10298, 10299, 10300, 10220
3603, 7960, 7999, 8000, 7961, 10300, 10301, 10302, 10222
3604, 7961, 8000, 8001, 7962, 10302, 10303, 10304, 10224
3605, 7962, 8001, 8002, 7963, 10304, 10305, 10306, 10226
3606, 7963, 8002, 8003, 7964, 10306, 10307, 10308, 10228
3607, 7964, 8003, 8004, 7965, 10308, 10309, 10310, 10230
3608, 7965, 8004, 8005, 7966, 10310, 10311, 10312, 10232
3609, 7966, 8005, 8006, 7967, 10312, 10313, 10314, 10234
3610, 7967, 8006, 8007, 7968, 10314, 10315, 10316, 10236
3611, 7968, 8007, 8008, 7969, 10316, 10317, 10318, 10238
3612, 7969, 8008, 8009, 7970, 10318, 10319, 10320, 10240
3613, 7970, 8009, 8010, 7971, 10320, 10321, 10322, 10242
3614, 7971, 8010, 8011, 7972, 10322, 10323, 10324, 10244
3615, 7972, 8011, 8012, 7973, 10324, 10325, 10326, 10246
3616, 7973, 8012, 8013, 7974, 10326, 10327, 10328, 10248
3617, 7974, 8013, 8014, 7975, 10328, 10329, 10330, 10250
3618, 7975, 8014, 8015, 7976, 10330, 10331, 10332, 10252
3619, 7976, 8015, 8016, 7977, 10332, 10333, 10334, 10254
3620, 7977, 8016, 8017, 7978, 10334, 10335, 10336, 10256
3621, 7978, 8017, 8018, 7979, 10336, 10337, 10338, 10258
3622, 7979, 8018, 736, 735, 10338, 10339, 775, 10260
3623, 657, 658, 8019, 7980, 697, 10340, 10341, 10261
3624, 7980, 8019, 8020, 7981, 10341, 10342, 10343, 10263
3625, 7981, 8020, 8021, 7982, 10343, 10344, 10345, 10265
3626, 7982, 8021, 8022, 7983, 10345, 10346, 10347, 10267
3627, 7983, 8022, 8023, 7984, 10347, 10348, 10349, 10269
3628, 7984, 8023, 8024, 7985, 10349, 10350, 10351, 10271
3629, 7985, 8024, 8025, 7986, 10351, 10352, 10353, 10273
3630, 7986, 8025, 8026, 7987, 10353, 10354, 10355, 10275
3631, 7987, 8026, 8027, 7988, 10355, 10356, 10357, 10277
3632, 7988, 8027, 8028, 7989, 10357, 10358, 10359, 10279
3633, 7989, 8028, 8029, 7990, 10359, 10360, 10361, 10281
3634, 7990, 8029, 8030, 7991, 10361, 10362, 10363, 10283
3635, 7991, 8030, 8031, 7992, 10363, 10364, 10365, 10285
3636, 7992, 8031, 8032, 7993, 10365, 10366, 10367, 10287
3637, 7993, 8032, 8033, 7994, 10367, 10368, 10369, 10289
3638, 7994, 8033, 8034, 7995, 10369, 10370, 10371, 10291
3639, 7995, 8034, 8035, 7996, 10371, 10372, 10373, 10293
3640, 7996, 8035, 8036, 7997, 10373, 10374, 10375, 10295
3641, 7997, 8036, 8037, 7998, 10375, 10376, 10377, 10297
3642, 7998, 8037, 8038, 7999, 10377, 10378, 10379, 10299
3643, 7999, 8038, 8039, 8000, 10379, 10380, 10381, 10301
3644, 8000, 8039, 8040, 8001, 10381, 10382, 10383, 10303
3645, 8001, 8040, 8041, 8002, 10383, 10384, 10385, 10305
3646, 8002, 8041, 8042, 8003, 10385, 10386, 10387, 10307
3647, 8003, 8042, 8043, 8004, 10387, 10388, 10389, 10309
3648, 8004, 8043, 8044, 8005, 10389, 10390, 10391, 10311
3649, 8005, 8044, 8045, 8006, 10391, 10392, 10393, 10313
3650, 8006, 8045, 8046, 8007, 10393, 10394, 10395, 10315
3651, 8007, 8046, 8047, 8008, 10395, 10396, 10397, 10317
3652, 8008, 8047, 8048, 8009, 10397, 10398, 10399, 10319
3653, 8009, 8048, 8049, 8010, 10399, 10400, 10401, 10321
3654, 8010, 8049, 8050, 8011, 10401, 10402, 10403, 10323
3655, 8011, 8050, 8051, 8012, 10403, 10404, 10405, 10325
3656, 8012, 8051, 8052, 8013, 10405, 10406, 10407, 10327
3657, 8013, 8052, 8053, 8014, 10407, 10408, 10409, 10329
3658, 8014, 8053, 8054, 8015, 10409, 10410, 10411, 10331
3659, 8015, 8054, 8055, 8016, 10411, 10412, 10413, 10333
3660, 8016, 8055, 8056, 8017, 10413, 10414, 10415, 10335
3661, 8017, 8056, 8057, 8018, 10415, 10416, 10417, 10337
3662, 8018, 8057, 737, 736, 10417, 10418, 776, 10339
3663, 658, 659, 8058, 8019, 698, 10419, 10420, 10340
3664, 8019, 8058, 8059, 8020, 10420, 10421, 10422, 10342
3665, 8020, 8059, 8060, 8021, 10422, 10423, 10424, 10344
3666, 8021, 8060, 8061, 8022, 10424, 10425, 10426, 10346
3667, 8022, 8061, 8062, 8023, 10426, 10427, 10428, 10348
3668, 8023, 8062, 8063, 8024, 10428, 10429, 10430, 10350
3669, 8024, 8063, 8064, 8025, 10430, 10431, 10432, 10352
3670, 8025, 8064, 8065, 8026, 10432, 10433, 10434, 10354
3671, 8026, 8065, 8066, 8027, 10434, 10435, 10436, 10356
3672, 8027, 8066, 8067, 8028, 10436, 10437, 10438, 10358
3673, 8028, 8067, 8068, 8029, 10438, 10439, 10440, 10360
3674, 8029, 8068, 8069, 8030, 10440, 10441, 10442, 10362
3675, 8030, 8069, 8070, 8031, 10442, 10443, 10444, 10364
3676, 8031, 8070, 8071, 8032, 10444, 10445, 10446, 10366
3677, 8032, 8071, 8072, 8033, 10446, 10447, 10448, 10368
3678, 8033, 8072, 8073, 8034, 10448, 10449, 10450, 10370
3679, 8034, 8073, 8074, 8035, 10450, 10451, 10452, 10372
3680, 8035, 8074, 8075, 8036, 10452, 10453, 10454, 10374
3681, 8036, 8075, 8076, 8037, 10454, 10455, 10456, 10376
3682, 8037, 8076, 8077, 8038, 10456, 10457, 10458, 10378
3683, 8038, 8077, 8078, 8039, 10458, 10459, 10460, 10380
3684, 8039, 8078, 8079, 8040, 10460, 10461, 10462, 10382
3685, 8040, 8079, 8080, 8041, 10462, 10463, 10464, 10384
3686, 8041, 8080, 8081, 8042, 10464, 10465, 10466, 10386
3687, 8042, 8081, 8082, 8043, 10466, 10467, 10468, 10388
3688, 8043, 8082, 8083, 8044, 10468, 10469, 10470, 10390
3689, 8044, 8083, 8084, 8045, 10470, 10471, 10472, 10392
3690, 8045, 8084, 8085, 8046, 10472, 10473, 10474, 10394
3691, 8046, 8085, 8086, 8047, 10474, 10475, 10476, 10396
3692, 8047, 8086, 8087, 8048, 10476, 10477, 10478, 10398
3693, 8048, 8087, 8088, 8049, 10478, 10479, 10480, 10400
3694, 8049, 8088, 8089, 8050, 10480, 10481, 10482, 10402
3695, 8050, 8089, 8090, 8051, 10482, 10483, 10484, 10404
3696, 8051, 8090, 8091, 8052, 10484, 10485, 10486, 10406
3697, 8052, 8091, 8092, 8053, 10486, 10487, 10488, 10408
3698, 8053, 8092, 8093, 8054, 10488, 10489, 10490, 10410
3699, 8054, 8093, 8094, 8055, 10490, 10491, 10492, 10412
3700, 8055, 8094, 8095, 8056, 10492, 10493, 10494, 10414
3701, 8056, 8095, 8096, 8057, 10494, 10495, 10496, 10416
3702, 8057, 8096, 738, 737, 10496, 10497, 777, 10418
3703, 659, 660, 8097, 8058, 699, 10498, 10499, 10419
3704, 8058, 8097, 8098, 8059, 10499, 10500, 10501, 10421
3705, 8059, 8098, 8099, 8060, 10501, 10502, 10503, 10423
3706, 8060, 8099, 8100, 8061, 10503, 10504, 10505, 10425
3707, 8061, 8100, 8101, 8062, 10505, 10506, 10507, 10427
3708, 8062, 8101, 8102, 8063, 10507, 10508, 10509, 10429
3709, 8063, 8102, 8103, 8064, 10509, 10510, 10511, 10431
3710, 8064, 8103, 8104, 8065, 10511, 10512, 10513, 10433
3711, 8065, 8104, 8105, 8066, 10513, 10514, 10515, 10435
3712, 8066, 8105, 8106, 8067, 10515, 10516, 10517, 10437
3713, 8067, 8106, 8107, 8068, 10517, 10518, 10519, 10439
3714, 8068, 8107, 8108, 8069, 10519, 10520, 10521, 10441
3715, 8069, 8108, 8109, 8070, 10521, 10522, 10523, 10443
3716, 8070, 8109, 8110, 8071, 10523, 10524, 10525, 10445
3717, 8071, 8110, 8111, 8072, 10525, 10526, 10527, 10447
3718, 8072, 8111, 8112, 8073, 10527, 10528, 10529, 10449
3719, 8073, 8112, 8113, 8074, 10529, 10530, 10531, 10451
3720, 8074, 8113, 8114, 8075, 10531, 10532, 10533, 10453
3721, 8075, 8114, 8115, 8076, 10533, 10534, 10535, 10455
3722, 8076, 8115, 8116, 8077, 10535, 10536, 10537, 10457
3723, 8077, 8116, 8117, 8078, 10537, 10538, 10539, 10459
3724, 8078, 8117, 8118, 8079, 10539, 10540, 10541, 10461
3725, 8079, 8118, 8119, 8080, 10541, 10542, 10543, 10463
3726, 8080, 8119, 8120, 8081, 10543, 10544, 10545, 10465
3727, 8081, 8120, 8121, 8082, 10545, 10546, 10547, 10467
3728, 8082, 8121, 8122, 8083, 10547, 10548, 10549, 10469
3729, 8083, 8122, 8123, 8084, 10549, 10550, 10551, 10471
3730, 8084, 8123, 8124, 8085, 10551, 10552, 10553, 10473
3731, 8085, 8124, 8125, 8086, 10553, 10554, 10555, 10475
3732, 8086, 8125, 8126, 8087, 10555, 10556, 10557, 10477
3733, 8087, 8126, 8127, 8088, 10557, 10558, 10559, 10479
3734, 8088, 8127, 8128, 8089, 10559, 10560, 10561, 10481
3735, 8089, 8128, 8129, 8090, 10561, 10562, 10563, 10483
3736, 8090, 8129, 8130, 8091, 10563, 10564, 10565, 10485
3737, 8091, 8130, 8131, 8092, 10565, 10566, 10567, 10487
3738, 8092, 8131, 8132, 8093, 10567, 10568, 10569, 10489
3739, 8093, 8132, 8133, 8094, 10569, 10570, 10571, 10491
3740, 8094, 8133, 8134, 8095, 10571, 10572, 10573, 10493
3741, 8095, 8134, 8135, 8096, 10573, 10574, 10575, 10495
3742, 8096, 8135, 739, 738, 10575, 10576, 778, 10497
3743, 660, 661, 8136, 8097, 700, 10577, 10578, 10498
3744, 8097, 8136, 8137, 8098, 10578, 10579, 10580, 10500
3745, 8098, 8137, 8138, 8099, 10580, 10581, 10582, 10502
3746, 8099, 8138, 8139, 8100, 10582, 10583, 10584, 10504
3747, 8100, 8139, 8140, 8101, 10584, 10585, 10586, 10506
3748, 8101, 8140, 8141, 8102, 10586, 10587, 10588, 10508
3749, 8102, 8141, 8142, 8103, 10588, 10589, 10590, 10510
3750, 8103, 8142, 8143, 8104, 10590, 10591, 10592, 10512
3751, 8104, 8143, 8144, 8105, 10592, 10593, 10594, 10514
3752, 8105, 8144, 8145, 8106, 10594, 10595, 10596, 10516
3753, 8106, 8145, 8146, 8107, 10596, 10597, 10598, 10518
3754, 8107, 8146, 8147, 8108, 10598, 10599, 10600, 10520
3755, 8108, 8147, 8148, 8109, 10600, 10601, 10602, 10522
3756, 8109, 8148, 8149, 8110, 10602, 10603, 10604, 10524
3757, 8110, 8149, 8150, 8111, 10604, 10605, 10606, 10526
3758, 8111, 8150, 8151, 8112, 10606, 10607, 10608, 10528
3759, 8112, 8151, 8152, 8113, 10608, 10609, 10610, 10530
3760, 8113, 8152, 8153, 8114, 10610, 10611, 10612, 10532
3761, 8114, 8153, 8154, 8115, 10612, 10613, 10614, 10534
3762, 8115, 8154, 8155, 8116, 10614, 10615, 10616, 10536
3763, 8116, 8155, 8156, 8117, 10616, 10617, 10618, 10538
3764, 8117, 8156, 8157, 8118, 10618, 10619, 10620, 10540
3765, 8118, 8157, 8158, 8119, 10620, 10621, 10622, 10542
3766, 8119, 8158, 8159, 8120, 10622, 10623, 10624, 10544
3767, 8120, 8159, 8160, 8121, 10624, 10625, 10626, 10546
3768, 8121, 8160, 8161, 8122, 10626, 10627, 10628, 10548
3769, 8122, 8161, 8162, 8123, 10628, 10629, 10630, 10550
3770, 8123, 8162, 8163, 8124, 10630, 10631, 10632, 10552
3771, 8124, 8163, 8164, 8125, 10632, 10633, 10634, 10554
3772, 8125, 8164, 8165, 8126, 10634, 10635, 10636, 10556
3773, 8126, 8165, 8166, 8127, 10636, 10637, 10638, 10558
3774, 8127, 8166, 8167, 8128, 10638, 10639, 10640, 10560
3775, 8128, 8167, 8168, 8129, 10640, 10641, 10642, 10562
3776, 8129, 8168, 8169, 8130, 10642, 10643, 10644, 10564
3777, 8130, 8169, 8170, 8131, 10644, 10645, 10646, 10566
3778, 8131, 8170, 8171, 8132, 10646, 10647, 10648, 10568
3779, 8132, 8171, 8172, 8133, 10648, 10649, 10650, 10570
3780, 8133, 8172, 8173, 8134, 10650, 10651, 10652, 10572
3781, 8134, 8173, 8174, 8135, 10652, 10653, 10654, 10574
3782, 8135, 8174, 740, 739, 10654, 10655, 779, 10576
3783, 661, 662, 8175, 8136, 701, 10656, 10657, 10577
3784, 8136, 8175, 8176, 8137, 10657, 10658, 10659, 10579
3785, 8137, 8176, 8177, 8138, 10659, 10660, 10661, 10581
3786, 8138, 8177, 8178, 8139, 10661, 10662, 10663, 10583
3787, 8139, 8178, 8179, 8140, 10663, 10664, 10665, 10585
3788, 8140, 8179, 8180, 8141, 10665, 10666, 10667, 10587
3789, 8141, 8180, 8181, 8142, 10667, 10668, 10669, 10589
3790, 8142, 8181, 8182, 8143, 10669, 10670, 10671, 10591
3791, 8143, 8182, 8183, 8144, 10671, 10672, 10673, 10593
3792, 8144, 8183, 8184, 8145, 10673, 10674, 10675, 10595
3793, 8145, 8184, 8185, 8146, 10675, 10676, 10677, 10597
3794, 8146, 8185, 8186, 8147, 10677, 10678, 10679, 10599
3795, 8147, 8186, 8187, 8148, 10679, 10680, 10681, 10601
3796, 8148, 8187, 8188, 8149, 10681, 10682, 10683, 10603
3797, 8149, 8188, 8189, 8150, 10683, 10684, 10685, 10605
3798, 8150, 8189, 8190, 8151, 10685, 10686, 10687, 10607
3799, 8151, 8190, 8191, 8152, 10687, 10688, 10689, 10609
3800, 8152, 8191, 8192, 8153, 10689, 10690, 10691, 10611
3801, 8153, 8192, 8193, 8154, 10691, 10692, 10693, 10613
3802, 8154, 8193, 8194, 8155, 10693, 10694, 10695, 10615
3803, 8155, 8194, 8195, 8156, 10695, 10696, 10697, 10617
3804, 8156, 8195, 8196, 8157, 10697, 10698, 10699, 10619
3805, 8157, 8196, 8197, 8158, 10699, 10700, 10701, 10621
3806, 8158, 8197, 8198, 8159, 10701, 10702, 10703, 10623
3807, 8159, 8198, 8199, 8160, 10703, 10704, 10705, 10625
3808, 8160, 8199, 8200, 8161, 10705, 10706, 10707, 10627
3809, 8161, 8200, 8201, 8162, 10707, 10708, 10709, 10629
3810, 8162, 8201, 8202, 8163, 10709, 10710, 10711, 10631
3811, 8163, 8202, 8203, 8164, 10711, 10712, 10713, 10633
3812, 8164, 8203, 8204, 8165, 10713, 10714, 10715, 10635
3813, 8165, 8204, 8205, 8166, 10715, 10716, 10717, 10637
3814, 8166, 8205, 8206, 8167, 10717, 10718, 10719, 10639
3815, 8167, 8206, 8207, 8168, 10719, 10720, 10721, 10641
3816, 8168, 8207, 8208, 8169, 10721, 10722, 10723, 10643
3817, 8169, 8208, 8209, 8170, 10723, 10724, 10725, 10645
3818, 8170, 8209, 8210, 8171, 10725, 10726, 10727, 10647
3819, 8171, 8210, 8211, 8172, 10727, 10728, 10729, 10649
3820, 8172, 8211, 8212, 8173, 10729, 10730, 10731, 10651
3821, 8173, 8212, 8213, 8174, 10731, 10732, 10733, 10653
3822, 8174, 8213, 741, 740, 10733, 10734, 780, 10655
3823, 662, 663, 8214, 8175, 702, 10735, 10736, 10656
3824, 8175, 8214, 8215, 8176, 10736, 10737, 10738, 10658
3825, 8176, 8215, 8216, 8177, 10738, 10739, 10740, 10660
3826, 8177, 8216, 8217, 8178, 10740, 10741, 10742, 10662
3827, 8178, 8217, 8218, 8179, 10742, 10743, 10744, 10664
3828, 8179, 8218, 8219, 8180, 10744, 10745, 10746, 10666
3829, 8180, 8219, 8220, 8181, 10746, 10747, 10748, 10668
3830, 8181, 8220, 8221, 8182, 10748, 10749, 10750, 10670
3831, 8182, 8221, 8222, 8183, 10750, 10751, 10752, 10672
3832, 8183, 8222, 8223, 8184, 10752, 10753, 10754, 10674
3833, 8184, 8223, 8224, 8185, 10754, 10755, 10756, 10676
3834, 8185, 8224, 8225, 8186, 10756, 10757, 10758, 10678
3835, 8186, 8225, 8226, 8187, 10758, 10759, 10760, 10680
3836, 8187, 8226, 8227, 8188, 10760, 10761, 10762, 10682
3837, 8188, 8227, 8228, 8189, 10762, 10763, 10764, 10684
3838, 8189, 8228, 8229, 8190, 10764, 10765, 10766, 10686
3839, 8190, 8229, 8230, 8191, 10766, 10767, 10768, 10688
3840, 8191, 8230, 8231, 8192, 10768, 10769, 10770, 10690
3841, 8192, 8231, 8232, 8193, 10770, 10771, 10772, 10692
3842, 8193, 8232, 8233, 8194, 10772, 10773, 10774, 10694
3843, 8194, 8233, 8234, 8195, 10774, 10775, 10776, 10696
3844, 8195, 8234, 8235, 8196, 10776, 10777, 10778, 10698
3845, 8196, 8235, 8236, 8197, 10778, 10779, 10780, 10700
3846, 8197, 8236, 8237, 8198, 10780, 10781, 10782, 10702
3847, 8198, 8237, 8238, 8199, 10782, 10783, 10784, 10704
3848, 8199, 8238, 8239, 8200, 10784, 10785, 10786, 10706
3849, 8200, 8239, 8240, 8201, 10786, 10787, 10788, 10708
3850, 8201, 8240, 8241, 8202, 10788, 10789, 10790, 10710
3851, 8202, 8241, 8242, 8203, 10790, 10791, 10792, 10712
3852, 8203, 8242, 8243, 8204, 10792, 10793, 10794, 10714
3853, 8204, 8243, 8244, 8205, 10794, 10795, 10796, 10716
3854, 8205, 8244, 8245, 8206, 10796, 10797, 10798, 10718
3855, 8206, 8245, 8246, 8207, 10798, 10799, 10800, 10720
3856, 8207, 8246, 8247, 8208, 10800, 10801, 10802, 10722
3857, 8208, 8247, 8248, 8209, 10802, 10803, 10804, 10724
3858, 8209, 8248, 8249, 8210, 10804, 10805, 10806, 10726
3859, 8210, 8249, 8250, 8211, 10806, 10807, 10808, 10728
3860, 8211, 8250, 8251, 8212, 10808, 10809, 10810, 10730
3861, 8212, 8251, 8252, 8213, 10810, 10811, 10812, 10732
3862, 8213, 8252, 742, 741, 10812, 10813, 781, 10734
3863, 663, 664, 8253, 8214, 703, 10814, 10815, 10735
3864, 8214, 8253, 8254, 8215, 10815, 10816, 10817, 10737
3865, 8215, 8254, 8255, 8216, 10817, 10818, 10819, 10739
3866, 8216, 8255, 8256, 8217, 10819, 10820, 10821, 10741
3867, 8217, 8256, 8257, 8218, 10821, 10822, 10823, 10743
