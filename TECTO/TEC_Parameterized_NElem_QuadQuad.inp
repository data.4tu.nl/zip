3868, 8218, 8257, 8258, 8219, 10823, 10824, 10825, 10745
3869, 8219, 8258, 8259, 8220, 10825, 10826, 10827, 10747
3870, 8220, 8259, 8260, 8221, 10827, 10828, 10829, 10749
3871, 8221, 8260, 8261, 8222, 10829, 10830, 10831, 10751
3872, 8222, 8261, 8262, 8223, 10831, 10832, 10833, 10753
3873, 8223, 8262, 8263, 8224, 10833, 10834, 10835, 10755
3874, 8224, 8263, 8264, 8225, 10835, 10836, 10837, 10757
3875, 8225, 8264, 8265, 8226, 10837, 10838, 10839, 10759
3876, 8226, 8265, 8266, 8227, 10839, 10840, 10841, 10761
3877, 8227, 8266, 8267, 8228, 10841, 10842, 10843, 10763
3878, 8228, 8267, 8268, 8229, 10843, 10844, 10845, 10765
3879, 8229, 8268, 8269, 8230, 10845, 10846, 10847, 10767
3880, 8230, 8269, 8270, 8231, 10847, 10848, 10849, 10769
3881, 8231, 8270, 8271, 8232, 10849, 10850, 10851, 10771
3882, 8232, 8271, 8272, 8233, 10851, 10852, 10853, 10773
3883, 8233, 8272, 8273, 8234, 10853, 10854, 10855, 10775
3884, 8234, 8273, 8274, 8235, 10855, 10856, 10857, 10777
3885, 8235, 8274, 8275, 8236, 10857, 10858, 10859, 10779
3886, 8236, 8275, 8276, 8237, 10859, 10860, 10861, 10781
3887, 8237, 8276, 8277, 8238, 10861, 10862, 10863, 10783
3888, 8238, 8277, 8278, 8239, 10863, 10864, 10865, 10785
3889, 8239, 8278, 8279, 8240, 10865, 10866, 10867, 10787
3890, 8240, 8279, 8280, 8241, 10867, 10868, 10869, 10789
3891, 8241, 8280, 8281, 8242, 10869, 10870, 10871, 10791
3892, 8242, 8281, 8282, 8243, 10871, 10872, 10873, 10793
3893, 8243, 8282, 8283, 8244, 10873, 10874, 10875, 10795
3894, 8244, 8283, 8284, 8245, 10875, 10876, 10877, 10797
3895, 8245, 8284, 8285, 8246, 10877, 10878, 10879, 10799
3896, 8246, 8285, 8286, 8247, 10879, 10880, 10881, 10801
3897, 8247, 8286, 8287, 8248, 10881, 10882, 10883, 10803
3898, 8248, 8287, 8288, 8249, 10883, 10884, 10885, 10805
3899, 8249, 8288, 8289, 8250, 10885, 10886, 10887, 10807
3900, 8250, 8289, 8290, 8251, 10887, 10888, 10889, 10809
3901, 8251, 8290, 8291, 8252, 10889, 10890, 10891, 10811
3902, 8252, 8291, 743, 742, 10891, 10892, 782, 10813
3903, 664, 665, 8292, 8253, 704, 10893, 10894, 10814
3904, 8253, 8292, 8293, 8254, 10894, 10895, 10896, 10816
3905, 8254, 8293, 8294, 8255, 10896, 10897, 10898, 10818
3906, 8255, 8294, 8295, 8256, 10898, 10899, 10900, 10820
3907, 8256, 8295, 8296, 8257, 10900, 10901, 10902, 10822
3908, 8257, 8296, 8297, 8258, 10902, 10903, 10904, 10824
3909, 8258, 8297, 8298, 8259, 10904, 10905, 10906, 10826
3910, 8259, 8298, 8299, 8260, 10906, 10907, 10908, 10828
3911, 8260, 8299, 8300, 8261, 10908, 10909, 10910, 10830
3912, 8261, 8300, 8301, 8262, 10910, 10911, 10912, 10832
3913, 8262, 8301, 8302, 8263, 10912, 10913, 10914, 10834
3914, 8263, 8302, 8303, 8264, 10914, 10915, 10916, 10836
3915, 8264, 8303, 8304, 8265, 10916, 10917, 10918, 10838
3916, 8265, 8304, 8305, 8266, 10918, 10919, 10920, 10840
3917, 8266, 8305, 8306, 8267, 10920, 10921, 10922, 10842
3918, 8267, 8306, 8307, 8268, 10922, 10923, 10924, 10844
3919, 8268, 8307, 8308, 8269, 10924, 10925, 10926, 10846
3920, 8269, 8308, 8309, 8270, 10926, 10927, 10928, 10848
3921, 8270, 8309, 8310, 8271, 10928, 10929, 10930, 10850
3922, 8271, 8310, 8311, 8272, 10930, 10931, 10932, 10852
3923, 8272, 8311, 8312, 8273, 10932, 10933, 10934, 10854
3924, 8273, 8312, 8313, 8274, 10934, 10935, 10936, 10856
3925, 8274, 8313, 8314, 8275, 10936, 10937, 10938, 10858
3926, 8275, 8314, 8315, 8276, 10938, 10939, 10940, 10860
3927, 8276, 8315, 8316, 8277, 10940, 10941, 10942, 10862
3928, 8277, 8316, 8317, 8278, 10942, 10943, 10944, 10864
3929, 8278, 8317, 8318, 8279, 10944, 10945, 10946, 10866
3930, 8279, 8318, 8319, 8280, 10946, 10947, 10948, 10868
3931, 8280, 8319, 8320, 8281, 10948, 10949, 10950, 10870
3932, 8281, 8320, 8321, 8282, 10950, 10951, 10952, 10872
3933, 8282, 8321, 8322, 8283, 10952, 10953, 10954, 10874
3934, 8283, 8322, 8323, 8284, 10954, 10955, 10956, 10876
3935, 8284, 8323, 8324, 8285, 10956, 10957, 10958, 10878
3936, 8285, 8324, 8325, 8286, 10958, 10959, 10960, 10880
3937, 8286, 8325, 8326, 8287, 10960, 10961, 10962, 10882
3938, 8287, 8326, 8327, 8288, 10962, 10963, 10964, 10884
3939, 8288, 8327, 8328, 8289, 10964, 10965, 10966, 10886
3940, 8289, 8328, 8329, 8290, 10966, 10967, 10968, 10888
3941, 8290, 8329, 8330, 8291, 10968, 10969, 10970, 10890
3942, 8291, 8330, 744, 743, 10970, 10971, 783, 10892
3943, 665, 666, 8331, 8292, 705, 10972, 10973, 10893
3944, 8292, 8331, 8332, 8293, 10973, 10974, 10975, 10895
3945, 8293, 8332, 8333, 8294, 10975, 10976, 10977, 10897
3946, 8294, 8333, 8334, 8295, 10977, 10978, 10979, 10899
3947, 8295, 8334, 8335, 8296, 10979, 10980, 10981, 10901
3948, 8296, 8335, 8336, 8297, 10981, 10982, 10983, 10903
3949, 8297, 8336, 8337, 8298, 10983, 10984, 10985, 10905
3950, 8298, 8337, 8338, 8299, 10985, 10986, 10987, 10907
3951, 8299, 8338, 8339, 8300, 10987, 10988, 10989, 10909
3952, 8300, 8339, 8340, 8301, 10989, 10990, 10991, 10911
3953, 8301, 8340, 8341, 8302, 10991, 10992, 10993, 10913
3954, 8302, 8341, 8342, 8303, 10993, 10994, 10995, 10915
3955, 8303, 8342, 8343, 8304, 10995, 10996, 10997, 10917
3956, 8304, 8343, 8344, 8305, 10997, 10998, 10999, 10919
3957, 8305, 8344, 8345, 8306, 10999, 11000, 11001, 10921
3958, 8306, 8345, 8346, 8307, 11001, 11002, 11003, 10923
3959, 8307, 8346, 8347, 8308, 11003, 11004, 11005, 10925
3960, 8308, 8347, 8348, 8309, 11005, 11006, 11007, 10927
3961, 8309, 8348, 8349, 8310, 11007, 11008, 11009, 10929
3962, 8310, 8349, 8350, 8311, 11009, 11010, 11011, 10931
3963, 8311, 8350, 8351, 8312, 11011, 11012, 11013, 10933
3964, 8312, 8351, 8352, 8313, 11013, 11014, 11015, 10935
3965, 8313, 8352, 8353, 8314, 11015, 11016, 11017, 10937
3966, 8314, 8353, 8354, 8315, 11017, 11018, 11019, 10939
3967, 8315, 8354, 8355, 8316, 11019, 11020, 11021, 10941
3968, 8316, 8355, 8356, 8317, 11021, 11022, 11023, 10943
3969, 8317, 8356, 8357, 8318, 11023, 11024, 11025, 10945
3970, 8318, 8357, 8358, 8319, 11025, 11026, 11027, 10947
3971, 8319, 8358, 8359, 8320, 11027, 11028, 11029, 10949
3972, 8320, 8359, 8360, 8321, 11029, 11030, 11031, 10951
3973, 8321, 8360, 8361, 8322, 11031, 11032, 11033, 10953
3974, 8322, 8361, 8362, 8323, 11033, 11034, 11035, 10955
3975, 8323, 8362, 8363, 8324, 11035, 11036, 11037, 10957
3976, 8324, 8363, 8364, 8325, 11037, 11038, 11039, 10959
3977, 8325, 8364, 8365, 8326, 11039, 11040, 11041, 10961
3978, 8326, 8365, 8366, 8327, 11041, 11042, 11043, 10963
3979, 8327, 8366, 8367, 8328, 11043, 11044, 11045, 10965
3980, 8328, 8367, 8368, 8329, 11045, 11046, 11047, 10967
3981, 8329, 8368, 8369, 8330, 11047, 11048, 11049, 10969
3982, 8330, 8369, 745, 744, 11049, 11050, 784, 10971
3983, 666, 667, 8370, 8331, 706, 11051, 11052, 10972
3984, 8331, 8370, 8371, 8332, 11052, 11053, 11054, 10974
3985, 8332, 8371, 8372, 8333, 11054, 11055, 11056, 10976
3986, 8333, 8372, 8373, 8334, 11056, 11057, 11058, 10978
3987, 8334, 8373, 8374, 8335, 11058, 11059, 11060, 10980
3988, 8335, 8374, 8375, 8336, 11060, 11061, 11062, 10982
3989, 8336, 8375, 8376, 8337, 11062, 11063, 11064, 10984
3990, 8337, 8376, 8377, 8338, 11064, 11065, 11066, 10986
3991, 8338, 8377, 8378, 8339, 11066, 11067, 11068, 10988
3992, 8339, 8378, 8379, 8340, 11068, 11069, 11070, 10990
3993, 8340, 8379, 8380, 8341, 11070, 11071, 11072, 10992
3994, 8341, 8380, 8381, 8342, 11072, 11073, 11074, 10994
3995, 8342, 8381, 8382, 8343, 11074, 11075, 11076, 10996
3996, 8343, 8382, 8383, 8344, 11076, 11077, 11078, 10998
3997, 8344, 8383, 8384, 8345, 11078, 11079, 11080, 11000
3998, 8345, 8384, 8385, 8346, 11080, 11081, 11082, 11002
3999, 8346, 8385, 8386, 8347, 11082, 11083, 11084, 11004
4000, 8347, 8386, 8387, 8348, 11084, 11085, 11086, 11006
4001, 8348, 8387, 8388, 8349, 11086, 11087, 11088, 11008
4002, 8349, 8388, 8389, 8350, 11088, 11089, 11090, 11010
4003, 8350, 8389, 8390, 8351, 11090, 11091, 11092, 11012
4004, 8351, 8390, 8391, 8352, 11092, 11093, 11094, 11014
4005, 8352, 8391, 8392, 8353, 11094, 11095, 11096, 11016
4006, 8353, 8392, 8393, 8354, 11096, 11097, 11098, 11018
4007, 8354, 8393, 8394, 8355, 11098, 11099, 11100, 11020
4008, 8355, 8394, 8395, 8356, 11100, 11101, 11102, 11022
4009, 8356, 8395, 8396, 8357, 11102, 11103, 11104, 11024
4010, 8357, 8396, 8397, 8358, 11104, 11105, 11106, 11026
4011, 8358, 8397, 8398, 8359, 11106, 11107, 11108, 11028
4012, 8359, 8398, 8399, 8360, 11108, 11109, 11110, 11030
4013, 8360, 8399, 8400, 8361, 11110, 11111, 11112, 11032
4014, 8361, 8400, 8401, 8362, 11112, 11113, 11114, 11034
4015, 8362, 8401, 8402, 8363, 11114, 11115, 11116, 11036
4016, 8363, 8402, 8403, 8364, 11116, 11117, 11118, 11038
4017, 8364, 8403, 8404, 8365, 11118, 11119, 11120, 11040
4018, 8365, 8404, 8405, 8366, 11120, 11121, 11122, 11042
4019, 8366, 8405, 8406, 8367, 11122, 11123, 11124, 11044
4020, 8367, 8406, 8407, 8368, 11124, 11125, 11126, 11046
4021, 8368, 8407, 8408, 8369, 11126, 11127, 11128, 11048
4022, 8369, 8408, 746, 745, 11128, 11129, 785, 11050
4023, 667, 668, 8409, 8370, 707, 11130, 11131, 11051
4024, 8370, 8409, 8410, 8371, 11131, 11132, 11133, 11053
4025, 8371, 8410, 8411, 8372, 11133, 11134, 11135, 11055
4026, 8372, 8411, 8412, 8373, 11135, 11136, 11137, 11057
4027, 8373, 8412, 8413, 8374, 11137, 11138, 11139, 11059
4028, 8374, 8413, 8414, 8375, 11139, 11140, 11141, 11061
4029, 8375, 8414, 8415, 8376, 11141, 11142, 11143, 11063
4030, 8376, 8415, 8416, 8377, 11143, 11144, 11145, 11065
4031, 8377, 8416, 8417, 8378, 11145, 11146, 11147, 11067
4032, 8378, 8417, 8418, 8379, 11147, 11148, 11149, 11069
4033, 8379, 8418, 8419, 8380, 11149, 11150, 11151, 11071
4034, 8380, 8419, 8420, 8381, 11151, 11152, 11153, 11073
4035, 8381, 8420, 8421, 8382, 11153, 11154, 11155, 11075
4036, 8382, 8421, 8422, 8383, 11155, 11156, 11157, 11077
4037, 8383, 8422, 8423, 8384, 11157, 11158, 11159, 11079
4038, 8384, 8423, 8424, 8385, 11159, 11160, 11161, 11081
4039, 8385, 8424, 8425, 8386, 11161, 11162, 11163, 11083
4040, 8386, 8425, 8426, 8387, 11163, 11164, 11165, 11085
4041, 8387, 8426, 8427, 8388, 11165, 11166, 11167, 11087
4042, 8388, 8427, 8428, 8389, 11167, 11168, 11169, 11089
4043, 8389, 8428, 8429, 8390, 11169, 11170, 11171, 11091
4044, 8390, 8429, 8430, 8391, 11171, 11172, 11173, 11093
4045, 8391, 8430, 8431, 8392, 11173, 11174, 11175, 11095
4046, 8392, 8431, 8432, 8393, 11175, 11176, 11177, 11097
4047, 8393, 8432, 8433, 8394, 11177, 11178, 11179, 11099
4048, 8394, 8433, 8434, 8395, 11179, 11180, 11181, 11101
4049, 8395, 8434, 8435, 8396, 11181, 11182, 11183, 11103
4050, 8396, 8435, 8436, 8397, 11183, 11184, 11185, 11105
4051, 8397, 8436, 8437, 8398, 11185, 11186, 11187, 11107
4052, 8398, 8437, 8438, 8399, 11187, 11188, 11189, 11109
4053, 8399, 8438, 8439, 8400, 11189, 11190, 11191, 11111
4054, 8400, 8439, 8440, 8401, 11191, 11192, 11193, 11113
4055, 8401, 8440, 8441, 8402, 11193, 11194, 11195, 11115
4056, 8402, 8441, 8442, 8403, 11195, 11196, 11197, 11117
4057, 8403, 8442, 8443, 8404, 11197, 11198, 11199, 11119
4058, 8404, 8443, 8444, 8405, 11199, 11200, 11201, 11121
4059, 8405, 8444, 8445, 8406, 11201, 11202, 11203, 11123
4060, 8406, 8445, 8446, 8407, 11203, 11204, 11205, 11125
4061, 8407, 8446, 8447, 8408, 11205, 11206, 11207, 11127
4062, 8408, 8447, 747, 746, 11207, 11208, 786, 11129
4063, 668, 669, 8448, 8409, 708, 11209, 11210, 11130
4064, 8409, 8448, 8449, 8410, 11210, 11211, 11212, 11132
4065, 8410, 8449, 8450, 8411, 11212, 11213, 11214, 11134
4066, 8411, 8450, 8451, 8412, 11214, 11215, 11216, 11136
4067, 8412, 8451, 8452, 8413, 11216, 11217, 11218, 11138
4068, 8413, 8452, 8453, 8414, 11218, 11219, 11220, 11140
4069, 8414, 8453, 8454, 8415, 11220, 11221, 11222, 11142
4070, 8415, 8454, 8455, 8416, 11222, 11223, 11224, 11144
4071, 8416, 8455, 8456, 8417, 11224, 11225, 11226, 11146
4072, 8417, 8456, 8457, 8418, 11226, 11227, 11228, 11148
4073, 8418, 8457, 8458, 8419, 11228, 11229, 11230, 11150
4074, 8419, 8458, 8459, 8420, 11230, 11231, 11232, 11152
4075, 8420, 8459, 8460, 8421, 11232, 11233, 11234, 11154
4076, 8421, 8460, 8461, 8422, 11234, 11235, 11236, 11156
4077, 8422, 8461, 8462, 8423, 11236, 11237, 11238, 11158
4078, 8423, 8462, 8463, 8424, 11238, 11239, 11240, 11160
4079, 8424, 8463, 8464, 8425, 11240, 11241, 11242, 11162
4080, 8425, 8464, 8465, 8426, 11242, 11243, 11244, 11164
4081, 8426, 8465, 8466, 8427, 11244, 11245, 11246, 11166
4082, 8427, 8466, 8467, 8428, 11246, 11247, 11248, 11168
4083, 8428, 8467, 8468, 8429, 11248, 11249, 11250, 11170
4084, 8429, 8468, 8469, 8430, 11250, 11251, 11252, 11172
4085, 8430, 8469, 8470, 8431, 11252, 11253, 11254, 11174
4086, 8431, 8470, 8471, 8432, 11254, 11255, 11256, 11176
4087, 8432, 8471, 8472, 8433, 11256, 11257, 11258, 11178
4088, 8433, 8472, 8473, 8434, 11258, 11259, 11260, 11180
4089, 8434, 8473, 8474, 8435, 11260, 11261, 11262, 11182
4090, 8435, 8474, 8475, 8436, 11262, 11263, 11264, 11184
4091, 8436, 8475, 8476, 8437, 11264, 11265, 11266, 11186
4092, 8437, 8476, 8477, 8438, 11266, 11267, 11268, 11188
4093, 8438, 8477, 8478, 8439, 11268, 11269, 11270, 11190
4094, 8439, 8478, 8479, 8440, 11270, 11271, 11272, 11192
4095, 8440, 8479, 8480, 8441, 11272, 11273, 11274, 11194
4096, 8441, 8480, 8481, 8442, 11274, 11275, 11276, 11196
4097, 8442, 8481, 8482, 8443, 11276, 11277, 11278, 11198
4098, 8443, 8482, 8483, 8444, 11278, 11279, 11280, 11200
4099, 8444, 8483, 8484, 8445, 11280, 11281, 11282, 11202
4100, 8445, 8484, 8485, 8446, 11282, 11283, 11284, 11204
4101, 8446, 8485, 8486, 8447, 11284, 11285, 11286, 11206
4102, 8447, 8486, 748, 747, 11286, 11287, 787, 11208
4103, 669, 670, 8487, 8448, 709, 11288, 11289, 11209
4104, 8448, 8487, 8488, 8449, 11289, 11290, 11291, 11211
4105, 8449, 8488, 8489, 8450, 11291, 11292, 11293, 11213
4106, 8450, 8489, 8490, 8451, 11293, 11294, 11295, 11215
4107, 8451, 8490, 8491, 8452, 11295, 11296, 11297, 11217
4108, 8452, 8491, 8492, 8453, 11297, 11298, 11299, 11219
4109, 8453, 8492, 8493, 8454, 11299, 11300, 11301, 11221
4110, 8454, 8493, 8494, 8455, 11301, 11302, 11303, 11223
4111, 8455, 8494, 8495, 8456, 11303, 11304, 11305, 11225
4112, 8456, 8495, 8496, 8457, 11305, 11306, 11307, 11227
4113, 8457, 8496, 8497, 8458, 11307, 11308, 11309, 11229
4114, 8458, 8497, 8498, 8459, 11309, 11310, 11311, 11231
4115, 8459, 8498, 8499, 8460, 11311, 11312, 11313, 11233
4116, 8460, 8499, 8500, 8461, 11313, 11314, 11315, 11235
4117, 8461, 8500, 8501, 8462, 11315, 11316, 11317, 11237
4118, 8462, 8501, 8502, 8463, 11317, 11318, 11319, 11239
4119, 8463, 8502, 8503, 8464, 11319, 11320, 11321, 11241
4120, 8464, 8503, 8504, 8465, 11321, 11322, 11323, 11243
4121, 8465, 8504, 8505, 8466, 11323, 11324, 11325, 11245
4122, 8466, 8505, 8506, 8467, 11325, 11326, 11327, 11247
4123, 8467, 8506, 8507, 8468, 11327, 11328, 11329, 11249
4124, 8468, 8507, 8508, 8469, 11329, 11330, 11331, 11251
4125, 8469, 8508, 8509, 8470, 11331, 11332, 11333, 11253
4126, 8470, 8509, 8510, 8471, 11333, 11334, 11335, 11255
4127, 8471, 8510, 8511, 8472, 11335, 11336, 11337, 11257
4128, 8472, 8511, 8512, 8473, 11337, 11338, 11339, 11259
4129, 8473, 8512, 8513, 8474, 11339, 11340, 11341, 11261
4130, 8474, 8513, 8514, 8475, 11341, 11342, 11343, 11263
4131, 8475, 8514, 8515, 8476, 11343, 11344, 11345, 11265
4132, 8476, 8515, 8516, 8477, 11345, 11346, 11347, 11267
4133, 8477, 8516, 8517, 8478, 11347, 11348, 11349, 11269
4134, 8478, 8517, 8518, 8479, 11349, 11350, 11351, 11271
4135, 8479, 8518, 8519, 8480, 11351, 11352, 11353, 11273
4136, 8480, 8519, 8520, 8481, 11353, 11354, 11355, 11275
4137, 8481, 8520, 8521, 8482, 11355, 11356, 11357, 11277
4138, 8482, 8521, 8522, 8483, 11357, 11358, 11359, 11279
4139, 8483, 8522, 8523, 8484, 11359, 11360, 11361, 11281
4140, 8484, 8523, 8524, 8485, 11361, 11362, 11363, 11283
4141, 8485, 8524, 8525, 8486, 11363, 11364, 11365, 11285
4142, 8486, 8525, 749, 748, 11365, 11366, 788, 11287
4143, 670, 671, 8526, 8487, 710, 11367, 11368, 11288
4144, 8487, 8526, 8527, 8488, 11368, 11369, 11370, 11290
4145, 8488, 8527, 8528, 8489, 11370, 11371, 11372, 11292
4146, 8489, 8528, 8529, 8490, 11372, 11373, 11374, 11294
4147, 8490, 8529, 8530, 8491, 11374, 11375, 11376, 11296
4148, 8491, 8530, 8531, 8492, 11376, 11377, 11378, 11298
4149, 8492, 8531, 8532, 8493, 11378, 11379, 11380, 11300
4150, 8493, 8532, 8533, 8494, 11380, 11381, 11382, 11302
4151, 8494, 8533, 8534, 8495, 11382, 11383, 11384, 11304
4152, 8495, 8534, 8535, 8496, 11384, 11385, 11386, 11306
4153, 8496, 8535, 8536, 8497, 11386, 11387, 11388, 11308
4154, 8497, 8536, 8537, 8498, 11388, 11389, 11390, 11310
4155, 8498, 8537, 8538, 8499, 11390, 11391, 11392, 11312
4156, 8499, 8538, 8539, 8500, 11392, 11393, 11394, 11314
4157, 8500, 8539, 8540, 8501, 11394, 11395, 11396, 11316
4158, 8501, 8540, 8541, 8502, 11396, 11397, 11398, 11318
4159, 8502, 8541, 8542, 8503, 11398, 11399, 11400, 11320
4160, 8503, 8542, 8543, 8504, 11400, 11401, 11402, 11322
4161, 8504, 8543, 8544, 8505, 11402, 11403, 11404, 11324
4162, 8505, 8544, 8545, 8506, 11404, 11405, 11406, 11326
4163, 8506, 8545, 8546, 8507, 11406, 11407, 11408, 11328
4164, 8507, 8546, 8547, 8508, 11408, 11409, 11410, 11330
4165, 8508, 8547, 8548, 8509, 11410, 11411, 11412, 11332
4166, 8509, 8548, 8549, 8510, 11412, 11413, 11414, 11334
4167, 8510, 8549, 8550, 8511, 11414, 11415, 11416, 11336
4168, 8511, 8550, 8551, 8512, 11416, 11417, 11418, 11338
4169, 8512, 8551, 8552, 8513, 11418, 11419, 11420, 11340
4170, 8513, 8552, 8553, 8514, 11420, 11421, 11422, 11342
4171, 8514, 8553, 8554, 8515, 11422, 11423, 11424, 11344
4172, 8515, 8554, 8555, 8516, 11424, 11425, 11426, 11346
4173, 8516, 8555, 8556, 8517, 11426, 11427, 11428, 11348
4174, 8517, 8556, 8557, 8518, 11428, 11429, 11430, 11350
4175, 8518, 8557, 8558, 8519, 11430, 11431, 11432, 11352
4176, 8519, 8558, 8559, 8520, 11432, 11433, 11434, 11354
4177, 8520, 8559, 8560, 8521, 11434, 11435, 11436, 11356
4178, 8521, 8560, 8561, 8522, 11436, 11437, 11438, 11358
4179, 8522, 8561, 8562, 8523, 11438, 11439, 11440, 11360
4180, 8523, 8562, 8563, 8524, 11440, 11441, 11442, 11362
4181, 8524, 8563, 8564, 8525, 11442, 11443, 11444, 11364
4182, 8525, 8564, 750, 749, 11444, 11445, 789, 11366
4183, 671, 672, 8565, 8526, 711, 11446, 11447, 11367
4184, 8526, 8565, 8566, 8527, 11447, 11448, 11449, 11369
4185, 8527, 8566, 8567, 8528, 11449, 11450, 11451, 11371
4186, 8528, 8567, 8568, 8529, 11451, 11452, 11453, 11373
4187, 8529, 8568, 8569, 8530, 11453, 11454, 11455, 11375
4188, 8530, 8569, 8570, 8531, 11455, 11456, 11457, 11377
4189, 8531, 8570, 8571, 8532, 11457, 11458, 11459, 11379
4190, 8532, 8571, 8572, 8533, 11459, 11460, 11461, 11381
4191, 8533, 8572, 8573, 8534, 11461, 11462, 11463, 11383
4192, 8534, 8573, 8574, 8535, 11463, 11464, 11465, 11385
4193, 8535, 8574, 8575, 8536, 11465, 11466, 11467, 11387
4194, 8536, 8575, 8576, 8537, 11467, 11468, 11469, 11389
4195, 8537, 8576, 8577, 8538, 11469, 11470, 11471, 11391
4196, 8538, 8577, 8578, 8539, 11471, 11472, 11473, 11393
4197, 8539, 8578, 8579, 8540, 11473, 11474, 11475, 11395
4198, 8540, 8579, 8580, 8541, 11475, 11476, 11477, 11397
4199, 8541, 8580, 8581, 8542, 11477, 11478, 11479, 11399
4200, 8542, 8581, 8582, 8543, 11479, 11480, 11481, 11401
4201, 8543, 8582, 8583, 8544, 11481, 11482, 11483, 11403
4202, 8544, 8583, 8584, 8545, 11483, 11484, 11485, 11405
4203, 8545, 8584, 8585, 8546, 11485, 11486, 11487, 11407
4204, 8546, 8585, 8586, 8547, 11487, 11488, 11489, 11409
4205, 8547, 8586, 8587, 8548, 11489, 11490, 11491, 11411
4206, 8548, 8587, 8588, 8549, 11491, 11492, 11493, 11413
4207, 8549, 8588, 8589, 8550, 11493, 11494, 11495, 11415
4208, 8550, 8589, 8590, 8551, 11495, 11496, 11497, 11417
4209, 8551, 8590, 8591, 8552, 11497, 11498, 11499, 11419
4210, 8552, 8591, 8592, 8553, 11499, 11500, 11501, 11421
4211, 8553, 8592, 8593, 8554, 11501, 11502, 11503, 11423
4212, 8554, 8593, 8594, 8555, 11503, 11504, 11505, 11425
4213, 8555, 8594, 8595, 8556, 11505, 11506, 11507, 11427
4214, 8556, 8595, 8596, 8557, 11507, 11508, 11509, 11429
4215, 8557, 8596, 8597, 8558, 11509, 11510, 11511, 11431
4216, 8558, 8597, 8598, 8559, 11511, 11512, 11513, 11433
4217, 8559, 8598, 8599, 8560, 11513, 11514, 11515, 11435
4218, 8560, 8599, 8600, 8561, 11515, 11516, 11517, 11437
4219, 8561, 8600, 8601, 8562, 11517, 11518, 11519, 11439
4220, 8562, 8601, 8602, 8563, 11519, 11520, 11521, 11441
4221, 8563, 8602, 8603, 8564, 11521, 11522, 11523, 11443
4222, 8564, 8603, 751, 750, 11523, 11524, 790, 11445
4223, 672, 673, 8604, 8565, 712, 11525, 11526, 11446
4224, 8565, 8604, 8605, 8566, 11526, 11527, 11528, 11448
4225, 8566, 8605, 8606, 8567, 11528, 11529, 11530, 11450
4226, 8567, 8606, 8607, 8568, 11530, 11531, 11532, 11452
4227, 8568, 8607, 8608, 8569, 11532, 11533, 11534, 11454
4228, 8569, 8608, 8609, 8570, 11534, 11535, 11536, 11456
4229, 8570, 8609, 8610, 8571, 11536, 11537, 11538, 11458
4230, 8571, 8610, 8611, 8572, 11538, 11539, 11540, 11460
4231, 8572, 8611, 8612, 8573, 11540, 11541, 11542, 11462
4232, 8573, 8612, 8613, 8574, 11542, 11543, 11544, 11464
4233, 8574, 8613, 8614, 8575, 11544, 11545, 11546, 11466
4234, 8575, 8614, 8615, 8576, 11546, 11547, 11548, 11468
4235, 8576, 8615, 8616, 8577, 11548, 11549, 11550, 11470
4236, 8577, 8616, 8617, 8578, 11550, 11551, 11552, 11472
4237, 8578, 8617, 8618, 8579, 11552, 11553, 11554, 11474
4238, 8579, 8618, 8619, 8580, 11554, 11555, 11556, 11476
4239, 8580, 8619, 8620, 8581, 11556, 11557, 11558, 11478
4240, 8581, 8620, 8621, 8582, 11558, 11559, 11560, 11480
4241, 8582, 8621, 8622, 8583, 11560, 11561, 11562, 11482
4242, 8583, 8622, 8623, 8584, 11562, 11563, 11564, 11484
4243, 8584, 8623, 8624, 8585, 11564, 11565, 11566, 11486
4244, 8585, 8624, 8625, 8586, 11566, 11567, 11568, 11488
4245, 8586, 8625, 8626, 8587, 11568, 11569, 11570, 11490
4246, 8587, 8626, 8627, 8588, 11570, 11571, 11572, 11492
4247, 8588, 8627, 8628, 8589, 11572, 11573, 11574, 11494
4248, 8589, 8628, 8629, 8590, 11574, 11575, 11576, 11496
4249, 8590, 8629, 8630, 8591, 11576, 11577, 11578, 11498
4250, 8591, 8630, 8631, 8592, 11578, 11579, 11580, 11500
4251, 8592, 8631, 8632, 8593, 11580, 11581, 11582, 11502
4252, 8593, 8632, 8633, 8594, 11582, 11583, 11584, 11504
4253, 8594, 8633, 8634, 8595, 11584, 11585, 11586, 11506
4254, 8595, 8634, 8635, 8596, 11586, 11587, 11588, 11508
4255, 8596, 8635, 8636, 8597, 11588, 11589, 11590, 11510
4256, 8597, 8636, 8637, 8598, 11590, 11591, 11592, 11512
4257, 8598, 8637, 8638, 8599, 11592, 11593, 11594, 11514
4258, 8599, 8638, 8639, 8600, 11594, 11595, 11596, 11516
4259, 8600, 8639, 8640, 8601, 11596, 11597, 11598, 11518
4260, 8601, 8640, 8641, 8602, 11598, 11599, 11600, 11520
4261, 8602, 8641, 8642, 8603, 11600, 11601, 11602, 11522
4262, 8603, 8642, 752, 751, 11602, 11603, 791, 11524
4263, 673, 674, 8643, 8604, 713, 11604, 11605, 11525
4264, 8604, 8643, 8644, 8605, 11605, 11606, 11607, 11527
4265, 8605, 8644, 8645, 8606, 11607, 11608, 11609, 11529
4266, 8606, 8645, 8646, 8607, 11609, 11610, 11611, 11531
4267, 8607, 8646, 8647, 8608, 11611, 11612, 11613, 11533
4268, 8608, 8647, 8648, 8609, 11613, 11614, 11615, 11535
4269, 8609, 8648, 8649, 8610, 11615, 11616, 11617, 11537
4270, 8610, 8649, 8650, 8611, 11617, 11618, 11619, 11539
4271, 8611, 8650, 8651, 8612, 11619, 11620, 11621, 11541
4272, 8612, 8651, 8652, 8613, 11621, 11622, 11623, 11543
4273, 8613, 8652, 8653, 8614, 11623, 11624, 11625, 11545
4274, 8614, 8653, 8654, 8615, 11625, 11626, 11627, 11547
4275, 8615, 8654, 8655, 8616, 11627, 11628, 11629, 11549
4276, 8616, 8655, 8656, 8617, 11629, 11630, 11631, 11551
4277, 8617, 8656, 8657, 8618, 11631, 11632, 11633, 11553
4278, 8618, 8657, 8658, 8619, 11633, 11634, 11635, 11555
4279, 8619, 8658, 8659, 8620, 11635, 11636, 11637, 11557
4280, 8620, 8659, 8660, 8621, 11637, 11638, 11639, 11559
4281, 8621, 8660, 8661, 8622, 11639, 11640, 11641, 11561
4282, 8622, 8661, 8662, 8623, 11641, 11642, 11643, 11563
4283, 8623, 8662, 8663, 8624, 11643, 11644, 11645, 11565
4284, 8624, 8663, 8664, 8625, 11645, 11646, 11647, 11567
4285, 8625, 8664, 8665, 8626, 11647, 11648, 11649, 11569
4286, 8626, 8665, 8666, 8627, 11649, 11650, 11651, 11571
4287, 8627, 8666, 8667, 8628, 11651, 11652, 11653, 11573
4288, 8628, 8667, 8668, 8629, 11653, 11654, 11655, 11575
4289, 8629, 8668, 8669, 8630, 11655, 11656, 11657, 11577
4290, 8630, 8669, 8670, 8631, 11657, 11658, 11659, 11579
4291, 8631, 8670, 8671, 8632, 11659, 11660, 11661, 11581
4292, 8632, 8671, 8672, 8633, 11661, 11662, 11663, 11583
4293, 8633, 8672, 8673, 8634, 11663, 11664, 11665, 11585
4294, 8634, 8673, 8674, 8635, 11665, 11666, 11667, 11587
4295, 8635, 8674, 8675, 8636, 11667, 11668, 11669, 11589
4296, 8636, 8675, 8676, 8637, 11669, 11670, 11671, 11591
4297, 8637, 8676, 8677, 8638, 11671, 11672, 11673, 11593
4298, 8638, 8677, 8678, 8639, 11673, 11674, 11675, 11595
4299, 8639, 8678, 8679, 8640, 11675, 11676, 11677, 11597
4300, 8640, 8679, 8680, 8641, 11677, 11678, 11679, 11599
4301, 8641, 8680, 8681, 8642, 11679, 11680, 11681, 11601
4302, 8642, 8681, 753, 752, 11681, 11682, 792, 11603
4303, 674, 675, 8682, 8643, 714, 11683, 11684, 11604
4304, 8643, 8682, 8683, 8644, 11684, 11685, 11686, 11606
4305, 8644, 8683, 8684, 8645, 11686, 11687, 11688, 11608
4306, 8645, 8684, 8685, 8646, 11688, 11689, 11690, 11610
4307, 8646, 8685, 8686, 8647, 11690, 11691, 11692, 11612
4308, 8647, 8686, 8687, 8648, 11692, 11693, 11694, 11614
4309, 8648, 8687, 8688, 8649, 11694, 11695, 11696, 11616
4310, 8649, 8688, 8689, 8650, 11696, 11697, 11698, 11618
4311, 8650, 8689, 8690, 8651, 11698, 11699, 11700, 11620
4312, 8651, 8690, 8691, 8652, 11700, 11701, 11702, 11622
4313, 8652, 8691, 8692, 8653, 11702, 11703, 11704, 11624
4314, 8653, 8692, 8693, 8654, 11704, 11705, 11706, 11626
4315, 8654, 8693, 8694, 8655, 11706, 11707, 11708, 11628
4316, 8655, 8694, 8695, 8656, 11708, 11709, 11710, 11630
4317, 8656, 8695, 8696, 8657, 11710, 11711, 11712, 11632
4318, 8657, 8696, 8697, 8658, 11712, 11713, 11714, 11634
4319, 8658, 8697, 8698, 8659, 11714, 11715, 11716, 11636
4320, 8659, 8698, 8699, 8660, 11716, 11717, 11718, 11638
4321, 8660, 8699, 8700, 8661, 11718, 11719, 11720, 11640
4322, 8661, 8700, 8701, 8662, 11720, 11721, 11722, 11642
4323, 8662, 8701, 8702, 8663, 11722, 11723, 11724, 11644
4324, 8663, 8702, 8703, 8664, 11724, 11725, 11726, 11646
4325, 8664, 8703, 8704, 8665, 11726, 11727, 11728, 11648
4326, 8665, 8704, 8705, 8666, 11728, 11729, 11730, 11650
4327, 8666, 8705, 8706, 8667, 11730, 11731, 11732, 11652
4328, 8667, 8706, 8707, 8668, 11732, 11733, 11734, 11654
4329, 8668, 8707, 8708, 8669, 11734, 11735, 11736, 11656
4330, 8669, 8708, 8709, 8670, 11736, 11737, 11738, 11658
4331, 8670, 8709, 8710, 8671, 11738, 11739, 11740, 11660
4332, 8671, 8710, 8711, 8672, 11740, 11741, 11742, 11662
4333, 8672, 8711, 8712, 8673, 11742, 11743, 11744, 11664
4334, 8673, 8712, 8713, 8674, 11744, 11745, 11746, 11666
4335, 8674, 8713, 8714, 8675, 11746, 11747, 11748, 11668
4336, 8675, 8714, 8715, 8676, 11748, 11749, 11750, 11670
4337, 8676, 8715, 8716, 8677, 11750, 11751, 11752, 11672
4338, 8677, 8716, 8717, 8678, 11752, 11753, 11754, 11674
4339, 8678, 8717, 8718, 8679, 11754, 11755, 11756, 11676
4340, 8679, 8718, 8719, 8680, 11756, 11757, 11758, 11678
4341, 8680, 8719, 8720, 8681, 11758, 11759, 11760, 11680
4342, 8681, 8720, 754, 753, 11760, 11761, 793, 11682
4343, 675, 676, 8721, 8682, 715, 11762, 11763, 11683
4344, 8682, 8721, 8722, 8683, 11763, 11764, 11765, 11685
4345, 8683, 8722, 8723, 8684, 11765, 11766, 11767, 11687
4346, 8684, 8723, 8724, 8685, 11767, 11768, 11769, 11689
4347, 8685, 8724, 8725, 8686, 11769, 11770, 11771, 11691
4348, 8686, 8725, 8726, 8687, 11771, 11772, 11773, 11693
4349, 8687, 8726, 8727, 8688, 11773, 11774, 11775, 11695
4350, 8688, 8727, 8728, 8689, 11775, 11776, 11777, 11697
4351, 8689, 8728, 8729, 8690, 11777, 11778, 11779, 11699
4352, 8690, 8729, 8730, 8691, 11779, 11780, 11781, 11701
4353, 8691, 8730, 8731, 8692, 11781, 11782, 11783, 11703
4354, 8692, 8731, 8732, 8693, 11783, 11784, 11785, 11705
4355, 8693, 8732, 8733, 8694, 11785, 11786, 11787, 11707
4356, 8694, 8733, 8734, 8695, 11787, 11788, 11789, 11709
4357, 8695, 8734, 8735, 8696, 11789, 11790, 11791, 11711
4358, 8696, 8735, 8736, 8697, 11791, 11792, 11793, 11713
4359, 8697, 8736, 8737, 8698, 11793, 11794, 11795, 11715
4360, 8698, 8737, 8738, 8699, 11795, 11796, 11797, 11717
4361, 8699, 8738, 8739, 8700, 11797, 11798, 11799, 11719
4362, 8700, 8739, 8740, 8701, 11799, 11800, 11801, 11721
4363, 8701, 8740, 8741, 8702, 11801, 11802, 11803, 11723
4364, 8702, 8741, 8742, 8703, 11803, 11804, 11805, 11725
4365, 8703, 8742, 8743, 8704, 11805, 11806, 11807, 11727
4366, 8704, 8743, 8744, 8705, 11807, 11808, 11809, 11729
4367, 8705, 8744, 8745, 8706, 11809, 11810, 11811, 11731
4368, 8706, 8745, 8746, 8707, 11811, 11812, 11813, 11733
4369, 8707, 8746, 8747, 8708, 11813, 11814, 11815, 11735
4370, 8708, 8747, 8748, 8709, 11815, 11816, 11817, 11737
4371, 8709, 8748, 8749, 8710, 11817, 11818, 11819, 11739
4372, 8710, 8749, 8750, 8711, 11819, 11820, 11821, 11741
4373, 8711, 8750, 8751, 8712, 11821, 11822, 11823, 11743
4374, 8712, 8751, 8752, 8713, 11823, 11824, 11825, 11745
4375, 8713, 8752, 8753, 8714, 11825, 11826, 11827, 11747
4376, 8714, 8753, 8754, 8715, 11827, 11828, 11829, 11749
4377, 8715, 8754, 8755, 8716, 11829, 11830, 11831, 11751
4378, 8716, 8755, 8756, 8717, 11831, 11832, 11833, 11753
4379, 8717, 8756, 8757, 8718, 11833, 11834, 11835, 11755
4380, 8718, 8757, 8758, 8719, 11835, 11836, 11837, 11757
4381, 8719, 8758, 8759, 8720, 11837, 11838, 11839, 11759
4382, 8720, 8759, 755, 754, 11839, 11840, 794, 11761
4383, 676, 11, 796, 8721, 716, 835, 11841, 11762
4384, 8721, 796, 797, 8722, 11841, 836, 11842, 11764
4385, 8722, 797, 798, 8723, 11842, 837, 11843, 11766
4386, 8723, 798, 799, 8724, 11843, 838, 11844, 11768
4387, 8724, 799, 800, 8725, 11844, 839, 11845, 11770
4388, 8725, 800, 801, 8726, 11845, 840, 11846, 11772
4389, 8726, 801, 802, 8727, 11846, 841, 11847, 11774
4390, 8727, 802, 803, 8728, 11847, 842, 11848, 11776
4391, 8728, 803, 804, 8729, 11848, 843, 11849, 11778
4392, 8729, 804, 805, 8730, 11849, 844, 11850, 11780
4393, 8730, 805, 806, 8731, 11850, 845, 11851, 11782
4394, 8731, 806, 807, 8732, 11851, 846, 11852, 11784
4395, 8732, 807, 808, 8733, 11852, 847, 11853, 11786
4396, 8733, 808, 809, 8734, 11853, 848, 11854, 11788
4397, 8734, 809, 810, 8735, 11854, 849, 11855, 11790
4398, 8735, 810, 811, 8736, 11855, 850, 11856, 11792
4399, 8736, 811, 812, 8737, 11856, 851, 11857, 11794
4400, 8737, 812, 813, 8738, 11857, 852, 11858, 11796
4401, 8738, 813, 814, 8739, 11858, 853, 11859, 11798
4402, 8739, 814, 815, 8740, 11859, 854, 11860, 11800
4403, 8740, 815, 816, 8741, 11860, 855, 11861, 11802
4404, 8741, 816, 817, 8742, 11861, 856, 11862, 11804
4405, 8742, 817, 818, 8743, 11862, 857, 11863, 11806
4406, 8743, 818, 819, 8744, 11863, 858, 11864, 11808
4407, 8744, 819, 820, 8745, 11864, 859, 11865, 11810
4408, 8745, 820, 821, 8746, 11865, 860, 11866, 11812
4409, 8746, 821, 822, 8747, 11866, 861, 11867, 11814
4410, 8747, 822, 823, 8748, 11867, 862, 11868, 11816
4411, 8748, 823, 824, 8749, 11868, 863, 11869, 11818
4412, 8749, 824, 825, 8750, 11869, 864, 11870, 11820
4413, 8750, 825, 826, 8751, 11870, 865, 11871, 11822
4414, 8751, 826, 827, 8752, 11871, 866, 11872, 11824
4415, 8752, 827, 828, 8753, 11872, 867, 11873, 11826
4416, 8753, 828, 829, 8754, 11873, 868, 11874, 11828
4417, 8754, 829, 830, 8755, 11874, 869, 11875, 11830
4418, 8755, 830, 831, 8756, 11875, 870, 11876, 11832
4419, 8756, 831, 832, 8757, 11876, 871, 11877, 11834
4420, 8757, 832, 833, 8758, 11877, 872, 11878, 11836
4421, 8758, 833, 834, 8759, 11878, 873, 11879, 11838
4422, 8759, 834, 12, 755, 11879, 874, 795, 11840
*ELEMENT, type=CPS8, ELSET=Surface6
4423, 11, 875, 11880, 796, 879, 12036, 12037, 835
4424, 796, 11880, 11881, 797, 12037, 12038, 12039, 836
4425, 797, 11881, 11882, 798, 12039, 12040, 12041, 837
4426, 798, 11882, 11883, 799, 12041, 12042, 12043, 838
4427, 799, 11883, 11884, 800, 12043, 12044, 12045, 839
4428, 800, 11884, 11885, 801, 12045, 12046, 12047, 840
4429, 801, 11885, 11886, 802, 12047, 12048, 12049, 841
4430, 802, 11886, 11887, 803, 12049, 12050, 12051, 842
4431, 803, 11887, 11888, 804, 12051, 12052, 12053, 843
4432, 804, 11888, 11889, 805, 12053, 12054, 12055, 844
4433, 805, 11889, 11890, 806, 12055, 12056, 12057, 845
4434, 806, 11890, 11891, 807, 12057, 12058, 12059, 846
4435, 807, 11891, 11892, 808, 12059, 12060, 12061, 847
4436, 808, 11892, 11893, 809, 12061, 12062, 12063, 848
4437, 809, 11893, 11894, 810, 12063, 12064, 12065, 849
4438, 810, 11894, 11895, 811, 12065, 12066, 12067, 850
4439, 811, 11895, 11896, 812, 12067, 12068, 12069, 851
4440, 812, 11896, 11897, 813, 12069, 12070, 12071, 852
4441, 813, 11897, 11898, 814, 12071, 12072, 12073, 853
4442, 814, 11898, 11899, 815, 12073, 12074, 12075, 854
4443, 815, 11899, 11900, 816, 12075, 12076, 12077, 855
4444, 816, 11900, 11901, 817, 12077, 12078, 12079, 856
4445, 817, 11901, 11902, 818, 12079, 12080, 12081, 857
4446, 818, 11902, 11903, 819, 12081, 12082, 12083, 858
4447, 819, 11903, 11904, 820, 12083, 12084, 12085, 859
4448, 820, 11904, 11905, 821, 12085, 12086, 12087, 860
4449, 821, 11905, 11906, 822, 12087, 12088, 12089, 861
4450, 822, 11906, 11907, 823, 12089, 12090, 12091, 862
4451, 823, 11907, 11908, 824, 12091, 12092, 12093, 863
4452, 824, 11908, 11909, 825, 12093, 12094, 12095, 864
4453, 825, 11909, 11910, 826, 12095, 12096, 12097, 865
4454, 826, 11910, 11911, 827, 12097, 12098, 12099, 866
4455, 827, 11911, 11912, 828, 12099, 12100, 12101, 867
4456, 828, 11912, 11913, 829, 12101, 12102, 12103, 868
4457, 829, 11913, 11914, 830, 12103, 12104, 12105, 869
4458, 830, 11914, 11915, 831, 12105, 12106, 12107, 870
4459, 831, 11915, 11916, 832, 12107, 12108, 12109, 871
4460, 832, 11916, 11917, 833, 12109, 12110, 12111, 872
4461, 833, 11917, 11918, 834, 12111, 12112, 12113, 873
4462, 834, 11918, 884, 12, 12113, 12114, 888, 874
4463, 875, 876, 11919, 11880, 880, 12115, 12116, 12036
4464, 11880, 11919, 11920, 11881, 12116, 12117, 12118, 12038
4465, 11881, 11920, 11921, 11882, 12118, 12119, 12120, 12040
4466, 11882, 11921, 11922, 11883, 12120, 12121, 12122, 12042
4467, 11883, 11922, 11923, 11884, 12122, 12123, 12124, 12044
4468, 11884, 11923, 11924, 11885, 12124, 12125, 12126, 12046
4469, 11885, 11924, 11925, 11886, 12126, 12127, 12128, 12048
4470, 11886, 11925, 11926, 11887, 12128, 12129, 12130, 12050
4471, 11887, 11926, 11927, 11888, 12130, 12131, 12132, 12052
4472, 11888, 11927, 11928, 11889, 12132, 12133, 12134, 12054
4473, 11889, 11928, 11929, 11890, 12134, 12135, 12136, 12056
4474, 11890, 11929, 11930, 11891, 12136, 12137, 12138, 12058
4475, 11891, 11930, 11931, 11892, 12138, 12139, 12140, 12060
4476, 11892, 11931, 11932, 11893, 12140, 12141, 12142, 12062
4477, 11893, 11932, 11933, 11894, 12142, 12143, 12144, 12064
4478, 11894, 11933, 11934, 11895, 12144, 12145, 12146, 12066
4479, 11895, 11934, 11935, 11896, 12146, 12147, 12148, 12068
4480, 11896, 11935, 11936, 11897, 12148, 12149, 12150, 12070
4481, 11897, 11936, 11937, 11898, 12150, 12151, 12152, 12072
4482, 11898, 11937, 11938, 11899, 12152, 12153, 12154, 12074
4483, 11899, 11938, 11939, 11900, 12154, 12155, 12156, 12076
4484, 11900, 11939, 11940, 11901, 12156, 12157, 12158, 12078
4485, 11901, 11940, 11941, 11902, 12158, 12159, 12160, 12080
4486, 11902, 11941, 11942, 11903, 12160, 12161, 12162, 12082
4487, 11903, 11942, 11943, 11904, 12162, 12163, 12164, 12084
4488, 11904, 11943, 11944, 11905, 12164, 12165, 12166, 12086
4489, 11905, 11944, 11945, 11906, 12166, 12167, 12168, 12088
4490, 11906, 11945, 11946, 11907, 12168, 12169, 12170, 12090
4491, 11907, 11946, 11947, 11908, 12170, 12171, 12172, 12092
4492, 11908, 11947, 11948, 11909, 12172, 12173, 12174, 12094
4493, 11909, 11948, 11949, 11910, 12174, 12175, 12176, 12096
4494, 11910, 11949, 11950, 11911, 12176, 12177, 12178, 12098
4495, 11911, 11950, 11951, 11912, 12178, 12179, 12180, 12100
4496, 11912, 11951, 11952, 11913, 12180, 12181, 12182, 12102
4497, 11913, 11952, 11953, 11914, 12182, 12183, 12184, 12104
4498, 11914, 11953, 11954, 11915, 12184, 12185, 12186, 12106
4499, 11915, 11954, 11955, 11916, 12186, 12187, 12188, 12108
4500, 11916, 11955, 11956, 11917, 12188, 12189, 12190, 12110
4501, 11917, 11956, 11957, 11918, 12190, 12191, 12192, 12112
4502, 11918, 11957, 885, 884, 12192, 12193, 889, 12114
4503, 876, 877, 11958, 11919, 881, 12194, 12195, 12115
4504, 11919, 11958, 11959, 11920, 12195, 12196, 12197, 12117
4505, 11920, 11959, 11960, 11921, 12197, 12198, 12199, 12119
4506, 11921, 11960, 11961, 11922, 12199, 12200, 12201, 12121
4507, 11922, 11961, 11962, 11923, 12201, 12202, 12203, 12123
4508, 11923, 11962, 11963, 11924, 12203, 12204, 12205, 12125
4509, 11924, 11963, 11964, 11925, 12205, 12206, 12207, 12127
4510, 11925, 11964, 11965, 11926, 12207, 12208, 12209, 12129
4511, 11926, 11965, 11966, 11927, 12209, 12210, 12211, 12131
4512, 11927, 11966, 11967, 11928, 12211, 12212, 12213, 12133
4513, 11928, 11967, 11968, 11929, 12213, 12214, 12215, 12135
4514, 11929, 11968, 11969, 11930, 12215, 12216, 12217, 12137
4515, 11930, 11969, 11970, 11931, 12217, 12218, 12219, 12139
4516, 11931, 11970, 11971, 11932, 12219, 12220, 12221, 12141
4517, 11932, 11971, 11972, 11933, 12221, 12222, 12223, 12143
4518, 11933, 11972, 11973, 11934, 12223, 12224, 12225, 12145
4519, 11934, 11973, 11974, 11935, 12225, 12226, 12227, 12147
4520, 11935, 11974, 11975, 11936, 12227, 12228, 12229, 12149
4521, 11936, 11975, 11976, 11937, 12229, 12230, 12231, 12151
4522, 11937, 11976, 11977, 11938, 12231, 12232, 12233, 12153
4523, 11938, 11977, 11978, 11939, 12233, 12234, 12235, 12155
4524, 11939, 11978, 11979, 11940, 12235, 12236, 12237, 12157
4525, 11940, 11979, 11980, 11941, 12237, 12238, 12239, 12159
4526, 11941, 11980, 11981, 11942, 12239, 12240, 12241, 12161
4527, 11942, 11981, 11982, 11943, 12241, 12242, 12243, 12163
4528, 11943, 11982, 11983, 11944, 12243, 12244, 12245, 12165
4529, 11944, 11983, 11984, 11945, 12245, 12246, 12247, 12167
4530, 11945, 11984, 11985, 11946, 12247, 12248, 12249, 12169
4531, 11946, 11985, 11986, 11947, 12249, 12250, 12251, 12171
4532, 11947, 11986, 11987, 11948, 12251, 12252, 12253, 12173
4533, 11948, 11987, 11988, 11949, 12253, 12254, 12255, 12175
4534, 11949, 11988, 11989, 11950, 12255, 12256, 12257, 12177
4535, 11950, 11989, 11990, 11951, 12257, 12258, 12259, 12179
4536, 11951, 11990, 11991, 11952, 12259, 12260, 12261, 12181
4537, 11952, 11991, 11992, 11953, 12261, 12262, 12263, 12183
4538, 11953, 11992, 11993, 11954, 12263, 12264, 12265, 12185
4539, 11954, 11993, 11994, 11955, 12265, 12266, 12267, 12187
4540, 11955, 11994, 11995, 11956, 12267, 12268, 12269, 12189
4541, 11956, 11995, 11996, 11957, 12269, 12270, 12271, 12191
4542, 11957, 11996, 886, 885, 12271, 12272, 890, 12193
4543, 877, 878, 11997, 11958, 882, 12273, 12274, 12194
4544, 11958, 11997, 11998, 11959, 12274, 12275, 12276, 12196
4545, 11959, 11998, 11999, 11960, 12276, 12277, 12278, 12198
4546, 11960, 11999, 12000, 11961, 12278, 12279, 12280, 12200
4547, 11961, 12000, 12001, 11962, 12280, 12281, 12282, 12202
4548, 11962, 12001, 12002, 11963, 12282, 12283, 12284, 12204
4549, 11963, 12002, 12003, 11964, 12284, 12285, 12286, 12206
4550, 11964, 12003, 12004, 11965, 12286, 12287, 12288, 12208
4551, 11965, 12004, 12005, 11966, 12288, 12289, 12290, 12210
4552, 11966, 12005, 12006, 11967, 12290, 12291, 12292, 12212
4553, 11967, 12006, 12007, 11968, 12292, 12293, 12294, 12214
4554, 11968, 12007, 12008, 11969, 12294, 12295, 12296, 12216
4555, 11969, 12008, 12009, 11970, 12296, 12297, 12298, 12218
4556, 11970, 12009, 12010, 11971, 12298, 12299, 12300, 12220
4557, 11971, 12010, 12011, 11972, 12300, 12301, 12302, 12222
4558, 11972, 12011, 12012, 11973, 12302, 12303, 12304, 12224
4559, 11973, 12012, 12013, 11974, 12304, 12305, 12306, 12226
4560, 11974, 12013, 12014, 11975, 12306, 12307, 12308, 12228
4561, 11975, 12014, 12015, 11976, 12308, 12309, 12310, 12230
4562, 11976, 12015, 12016, 11977, 12310, 12311, 12312, 12232
4563, 11977, 12016, 12017, 11978, 12312, 12313, 12314, 12234
4564, 11978, 12017, 12018, 11979, 12314, 12315, 12316, 12236
4565, 11979, 12018, 12019, 11980, 12316, 12317, 12318, 12238
4566, 11980, 12019, 12020, 11981, 12318, 12319, 12320, 12240
4567, 11981, 12020, 12021, 11982, 12320, 12321, 12322, 12242
4568, 11982, 12021, 12022, 11983, 12322, 12323, 12324, 12244
4569, 11983, 12022, 12023, 11984, 12324, 12325, 12326, 12246
4570, 11984, 12023, 12024, 11985, 12326, 12327, 12328, 12248
4571, 11985, 12024, 12025, 11986, 12328, 12329, 12330, 12250
4572, 11986, 12025, 12026, 11987, 12330, 12331, 12332, 12252
4573, 11987, 12026, 12027, 11988, 12332, 12333, 12334, 12254
4574, 11988, 12027, 12028, 11989, 12334, 12335, 12336, 12256
4575, 11989, 12028, 12029, 11990, 12336, 12337, 12338, 12258
4576, 11990, 12029, 12030, 11991, 12338, 12339, 12340, 12260
4577, 11991, 12030, 12031, 11992, 12340, 12341, 12342, 12262
4578, 11992, 12031, 12032, 11993, 12342, 12343, 12344, 12264
4579, 11993, 12032, 12033, 11994, 12344, 12345, 12346, 12266
4580, 11994, 12033, 12034, 11995, 12346, 12347, 12348, 12268
4581, 11995, 12034, 12035, 11996, 12348, 12349, 12350, 12270
4582, 11996, 12035, 887, 886, 12350, 12351, 891, 12272
4583, 878, 13, 893, 11997, 883, 932, 12352, 12273
4584, 11997, 893, 894, 11998, 12352, 933, 12353, 12275
4585, 11998, 894, 895, 11999, 12353, 934, 12354, 12277
4586, 11999, 895, 896, 12000, 12354, 935, 12355, 12279
4587, 12000, 896, 897, 12001, 12355, 936, 12356, 12281
4588, 12001, 897, 898, 12002, 12356, 937, 12357, 12283
4589, 12002, 898, 899, 12003, 12357, 938, 12358, 12285
4590, 12003, 899, 900, 12004, 12358, 939, 12359, 12287
4591, 12004, 900, 901, 12005, 12359, 940, 12360, 12289
4592, 12005, 901, 902, 12006, 12360, 941, 12361, 12291
4593, 12006, 902, 903, 12007, 12361, 942, 12362, 12293
4594, 12007, 903, 904, 12008, 12362, 943, 12363, 12295
4595, 12008, 904, 905, 12009, 12363, 944, 12364, 12297
4596, 12009, 905, 906, 12010, 12364, 945, 12365, 12299
4597, 12010, 906, 907, 12011, 12365, 946, 12366, 12301
4598, 12011, 907, 908, 12012, 12366, 947, 12367, 12303
4599, 12012, 908, 909, 12013, 12367, 948, 12368, 12305
4600, 12013, 909, 910, 12014, 12368, 949, 12369, 12307
4601, 12014, 910, 911, 12015, 12369, 950, 12370, 12309
4602, 12015, 911, 912, 12016, 12370, 951, 12371, 12311
4603, 12016, 912, 913, 12017, 12371, 952, 12372, 12313
4604, 12017, 913, 914, 12018, 12372, 953, 12373, 12315
4605, 12018, 914, 915, 12019, 12373, 954, 12374, 12317
4606, 12019, 915, 916, 12020, 12374, 955, 12375, 12319
4607, 12020, 916, 917, 12021, 12375, 956, 12376, 12321
4608, 12021, 917, 918, 12022, 12376, 957, 12377, 12323
4609, 12022, 918, 919, 12023, 12377, 958, 12378, 12325
4610, 12023, 919, 920, 12024, 12378, 959, 12379, 12327
4611, 12024, 920, 921, 12025, 12379, 960, 12380, 12329
4612, 12025, 921, 922, 12026, 12380, 961, 12381, 12331
4613, 12026, 922, 923, 12027, 12381, 962, 12382, 12333
4614, 12027, 923, 924, 12028, 12382, 963, 12383, 12335
4615, 12028, 924, 925, 12029, 12383, 964, 12384, 12337
4616, 12029, 925, 926, 12030, 12384, 965, 12385, 12339
4617, 12030, 926, 927, 12031, 12385, 966, 12386, 12341
4618, 12031, 927, 928, 12032, 12386, 967, 12387, 12343
4619, 12032, 928, 929, 12033, 12387, 968, 12388, 12345
4620, 12033, 929, 930, 12034, 12388, 969, 12389, 12347
4621, 12034, 930, 931, 12035, 12389, 970, 12390, 12349
4622, 12035, 931, 14, 887, 12390, 971, 892, 12351
*ELEMENT, type=CPS8, ELSET=Surface7
4623, 1, 972, 12391, 31, 976, 12547, 12548, 70
4624, 31, 12391, 12392, 32, 12548, 12549, 12550, 71
4625, 32, 12392, 12393, 33, 12550, 12551, 12552, 72
4626, 33, 12393, 12394, 34, 12552, 12553, 12554, 73
4627, 34, 12394, 12395, 35, 12554, 12555, 12556, 74
4628, 35, 12395, 12396, 36, 12556, 12557, 12558, 75
4629, 36, 12396, 12397, 37, 12558, 12559, 12560, 76
4630, 37, 12397, 12398, 38, 12560, 12561, 12562, 77
4631, 38, 12398, 12399, 39, 12562, 12563, 12564, 78
4632, 39, 12399, 12400, 40, 12564, 12565, 12566, 79
4633, 40, 12400, 12401, 41, 12566, 12567, 12568, 80
4634, 41, 12401, 12402, 42, 12568, 12569, 12570, 81
4635, 42, 12402, 12403, 43, 12570, 12571, 12572, 82
4636, 43, 12403, 12404, 44, 12572, 12573, 12574, 83
4637, 44, 12404, 12405, 45, 12574, 12575, 12576, 84
4638, 45, 12405, 12406, 46, 12576, 12577, 12578, 85
4639, 46, 12406, 12407, 47, 12578, 12579, 12580, 86
4640, 47, 12407, 12408, 48, 12580, 12581, 12582, 87
4641, 48, 12408, 12409, 49, 12582, 12583, 12584, 88
4642, 49, 12409, 12410, 50, 12584, 12585, 12586, 89
4643, 50, 12410, 12411, 51, 12586, 12587, 12588, 90
4644, 51, 12411, 12412, 52, 12588, 12589, 12590, 91
4645, 52, 12412, 12413, 53, 12590, 12591, 12592, 92
4646, 53, 12413, 12414, 54, 12592, 12593, 12594, 93
4647, 54, 12414, 12415, 55, 12594, 12595, 12596, 94
4648, 55, 12415, 12416, 56, 12596, 12597, 12598, 95
4649, 56, 12416, 12417, 57, 12598, 12599, 12600, 96
4650, 57, 12417, 12418, 58, 12600, 12601, 12602, 97
4651, 58, 12418, 12419, 59, 12602, 12603, 12604, 98
4652, 59, 12419, 12420, 60, 12604, 12605, 12606, 99
4653, 60, 12420, 12421, 61, 12606, 12607, 12608, 100
4654, 61, 12421, 12422, 62, 12608, 12609, 12610, 101
4655, 62, 12422, 12423, 63, 12610, 12611, 12612, 102
4656, 63, 12423, 12424, 64, 12612, 12613, 12614, 103
4657, 64, 12424, 12425, 65, 12614, 12615, 12616, 104
4658, 65, 12425, 12426, 66, 12616, 12617, 12618, 105
4659, 66, 12426, 12427, 67, 12618, 12619, 12620, 106
4660, 67, 12427, 12428, 68, 12620, 12621, 12622, 107
4661, 68, 12428, 12429, 69, 12622, 12623, 12624, 108
4662, 69, 12429, 981, 2, 12624, 12625, 985, 109
4663, 972, 973, 12430, 12391, 977, 12626, 12627, 12547
4664, 12391, 12430, 12431, 12392, 12627, 12628, 12629, 12549
4665, 12392, 12431, 12432, 12393, 12629, 12630, 12631, 12551
4666, 12393, 12432, 12433, 12394, 12631, 12632, 12633, 12553
4667, 12394, 12433, 12434, 12395, 12633, 12634, 12635, 12555
4668, 12395, 12434, 12435, 12396, 12635, 12636, 12637, 12557
4669, 12396, 12435, 12436, 12397, 12637, 12638, 12639, 12559
4670, 12397, 12436, 12437, 12398, 12639, 12640, 12641, 12561
4671, 12398, 12437, 12438, 12399, 12641, 12642, 12643, 12563
4672, 12399, 12438, 12439, 12400, 12643, 12644, 12645, 12565
4673, 12400, 12439, 12440, 12401, 12645, 12646, 12647, 12567
4674, 12401, 12440, 12441, 12402, 12647, 12648, 12649, 12569
4675, 12402, 12441, 12442, 12403, 12649, 12650, 12651, 12571
4676, 12403, 12442, 12443, 12404, 12651, 12652, 12653, 12573
4677, 12404, 12443, 12444, 12405, 12653, 12654, 12655, 12575
4678, 12405, 12444, 12445, 12406, 12655, 12656, 12657, 12577
4679, 12406, 12445, 12446, 12407, 12657, 12658, 12659, 12579
4680, 12407, 12446, 12447, 12408, 12659, 12660, 12661, 12581
4681, 12408, 12447, 12448, 12409, 12661, 12662, 12663, 12583
4682, 12409, 12448, 12449, 12410, 12663, 12664, 12665, 12585
4683, 12410, 12449, 12450, 12411, 12665, 12666, 12667, 12587
4684, 12411, 12450, 12451, 12412, 12667, 12668, 12669, 12589
4685, 12412, 12451, 12452, 12413, 12669, 12670, 12671, 12591
4686, 12413, 12452, 12453, 12414, 12671, 12672, 12673, 12593
4687, 12414, 12453, 12454, 12415, 12673, 12674, 12675, 12595
4688, 12415, 12454, 12455, 12416, 12675, 12676, 12677, 12597
4689, 12416, 12455, 12456, 12417, 12677, 12678, 12679, 12599
4690, 12417, 12456, 12457, 12418, 12679, 12680, 12681, 12601
4691, 12418, 12457, 12458, 12419, 12681, 12682, 12683, 12603
4692, 12419, 12458, 12459, 12420, 12683, 12684, 12685, 12605
4693, 12420, 12459, 12460, 12421, 12685, 12686, 12687, 12607
4694, 12421, 12460, 12461, 12422, 12687, 12688, 12689, 12609
4695, 12422, 12461, 12462, 12423, 12689, 12690, 12691, 12611
4696, 12423, 12462, 12463, 12424, 12691, 12692, 12693, 12613
4697, 12424, 12463, 12464, 12425, 12693, 12694, 12695, 12615
4698, 12425, 12464, 12465, 12426, 12695, 12696, 12697, 12617
4699, 12426, 12465, 12466, 12427, 12697, 12698, 12699, 12619
4700, 12427, 12466, 12467, 12428, 12699, 12700, 12701, 12621
4701, 12428, 12467, 12468, 12429, 12701, 12702, 12703, 12623
4702, 12429, 12468, 982, 981, 12703, 12704, 986, 12625
4703, 973, 974, 12469, 12430, 978, 12705, 12706, 12626
4704, 12430, 12469, 12470, 12431, 12706, 12707, 12708, 12628
4705, 12431, 12470, 12471, 12432, 12708, 12709, 12710, 12630
4706, 12432, 12471, 12472, 12433, 12710, 12711, 12712, 12632
4707, 12433, 12472, 12473, 12434, 12712, 12713, 12714, 12634
4708, 12434, 12473, 12474, 12435, 12714, 12715, 12716, 12636
4709, 12435, 12474, 12475, 12436, 12716, 12717, 12718, 12638
4710, 12436, 12475, 12476, 12437, 12718, 12719, 12720, 12640
4711, 12437, 12476, 12477, 12438, 12720, 12721, 12722, 12642
4712, 12438, 12477, 12478, 12439, 12722, 12723, 12724, 12644
4713, 12439, 12478, 12479, 12440, 12724, 12725, 12726, 12646
4714, 12440, 12479, 12480, 12441, 12726, 12727, 12728, 12648
4715, 12441, 12480, 12481, 12442, 12728, 12729, 12730, 12650
4716, 12442, 12481, 12482, 12443, 12730, 12731, 12732, 12652
4717, 12443, 12482, 12483, 12444, 12732, 12733, 12734, 12654
4718, 12444, 12483, 12484, 12445, 12734, 12735, 12736, 12656
4719, 12445, 12484, 12485, 12446, 12736, 12737, 12738, 12658
4720, 12446, 12485, 12486, 12447, 12738, 12739, 12740, 12660
4721, 12447, 12486, 12487, 12448, 12740, 12741, 12742, 12662
4722, 12448, 12487, 12488, 12449, 12742, 12743, 12744, 12664
4723, 12449, 12488, 12489, 12450, 12744, 12745, 12746, 12666
4724, 12450, 12489, 12490, 12451, 12746, 12747, 12748, 12668
4725, 12451, 12490, 12491, 12452, 12748, 12749, 12750, 12670
4726, 12452, 12491, 12492, 12453, 12750, 12751, 12752, 12672
4727, 12453, 12492, 12493, 12454, 12752, 12753, 12754, 12674
4728, 12454, 12493, 12494, 12455, 12754, 12755, 12756, 12676
4729, 12455, 12494, 12495, 12456, 12756, 12757, 12758, 12678
4730, 12456, 12495, 12496, 12457, 12758, 12759, 12760, 12680
4731, 12457, 12496, 12497, 12458, 12760, 12761, 12762, 12682
4732, 12458, 12497, 12498, 12459, 12762, 12763, 12764, 12684
4733, 12459, 12498, 12499, 12460, 12764, 12765, 12766, 12686
4734, 12460, 12499, 12500, 12461, 12766, 12767, 12768, 12688
4735, 12461, 12500, 12501, 12462, 12768, 12769, 12770, 12690
4736, 12462, 12501, 12502, 12463, 12770, 12771, 12772, 12692
4737, 12463, 12502, 12503, 12464, 12772, 12773, 12774, 12694
4738, 12464, 12503, 12504, 12465, 12774, 12775, 12776, 12696
4739, 12465, 12504, 12505, 12466, 12776, 12777, 12778, 12698
4740, 12466, 12505, 12506, 12467, 12778, 12779, 12780, 12700
4741, 12467, 12506, 12507, 12468, 12780, 12781, 12782, 12702
4742, 12468, 12507, 983, 982, 12782, 12783, 987, 12704
4743, 974, 975, 12508, 12469, 979, 12784, 12785, 12705
4744, 12469, 12508, 12509, 12470, 12785, 12786, 12787, 12707
4745, 12470, 12509, 12510, 12471, 12787, 12788, 12789, 12709
4746, 12471, 12510, 12511, 12472, 12789, 12790, 12791, 12711
4747, 12472, 12511, 12512, 12473, 12791, 12792, 12793, 12713
4748, 12473, 12512, 12513, 12474, 12793, 12794, 12795, 12715
4749, 12474, 12513, 12514, 12475, 12795, 12796, 12797, 12717
4750, 12475, 12514, 12515, 12476, 12797, 12798, 12799, 12719
4751, 12476, 12515, 12516, 12477, 12799, 12800, 12801, 12721
4752, 12477, 12516, 12517, 12478, 12801, 12802, 12803, 12723
4753, 12478, 12517, 12518, 12479, 12803, 12804, 12805, 12725
4754, 12479, 12518, 12519, 12480, 12805, 12806, 12807, 12727
4755, 12480, 12519, 12520, 12481, 12807, 12808, 12809, 12729
4756, 12481, 12520, 12521, 12482, 12809, 12810, 12811, 12731
4757, 12482, 12521, 12522, 12483, 12811, 12812, 12813, 12733
4758, 12483, 12522, 12523, 12484, 12813, 12814, 12815, 12735
4759, 12484, 12523, 12524, 12485, 12815, 12816, 12817, 12737
4760, 12485, 12524, 12525, 12486, 12817, 12818, 12819, 12739
4761, 12486, 12525, 12526, 12487, 12819, 12820, 12821, 12741
4762, 12487, 12526, 12527, 12488, 12821, 12822, 12823, 12743
4763, 12488, 12527, 12528, 12489, 12823, 12824, 12825, 12745
4764, 12489, 12528, 12529, 12490, 12825, 12826, 12827, 12747
4765, 12490, 12529, 12530, 12491, 12827, 12828, 12829, 12749
4766, 12491, 12530, 12531, 12492, 12829, 12830, 12831, 12751
4767, 12492, 12531, 12532, 12493, 12831, 12832, 12833, 12753
4768, 12493, 12532, 12533, 12494, 12833, 12834, 12835, 12755
4769, 12494, 12533, 12534, 12495, 12835, 12836, 12837, 12757
4770, 12495, 12534, 12535, 12496, 12837, 12838, 12839, 12759
4771, 12496, 12535, 12536, 12497, 12839, 12840, 12841, 12761
4772, 12497, 12536, 12537, 12498, 12841, 12842, 12843, 12763
4773, 12498, 12537, 12538, 12499, 12843, 12844, 12845, 12765
4774, 12499, 12538, 12539, 12500, 12845, 12846, 12847, 12767
4775, 12500, 12539, 12540, 12501, 12847, 12848, 12849, 12769
4776, 12501, 12540, 12541, 12502, 12849, 12850, 12851, 12771
4777, 12502, 12541, 12542, 12503, 12851, 12852, 12853, 12773
4778, 12503, 12542, 12543, 12504, 12853, 12854, 12855, 12775
4779, 12504, 12543, 12544, 12505, 12855, 12856, 12857, 12777
4780, 12505, 12544, 12545, 12506, 12857, 12858, 12859, 12779
4781, 12506, 12545, 12546, 12507, 12859, 12860, 12861, 12781
4782, 12507, 12546, 984, 983, 12861, 12862, 988, 12783
4783, 975, 15, 990, 12508, 980, 1029, 12863, 12784
4784, 12508, 990, 991, 12509, 12863, 1030, 12864, 12786
4785, 12509, 991, 992, 12510, 12864, 1031, 12865, 12788
4786, 12510, 992, 993, 12511, 12865, 1032, 12866, 12790
4787, 12511, 993, 994, 12512, 12866, 1033, 12867, 12792
4788, 12512, 994, 995, 12513, 12867, 1034, 12868, 12794
4789, 12513, 995, 996, 12514, 12868, 1035, 12869, 12796
4790, 12514, 996, 997, 12515, 12869, 1036, 12870, 12798
4791, 12515, 997, 998, 12516, 12870, 1037, 12871, 12800
4792, 12516, 998, 999, 12517, 12871, 1038, 12872, 12802
4793, 12517, 999, 1000, 12518, 12872, 1039, 12873, 12804
4794, 12518, 1000, 1001, 12519, 12873, 1040, 12874, 12806
4795, 12519, 1001, 1002, 12520, 12874, 1041, 12875, 12808
4796, 12520, 1002, 1003, 12521, 12875, 1042, 12876, 12810
4797, 12521, 1003, 1004, 12522, 12876, 1043, 12877, 12812
4798, 12522, 1004, 1005, 12523, 12877, 1044, 12878, 12814
4799, 12523, 1005, 1006, 12524, 12878, 1045, 12879, 12816
4800, 12524, 1006, 1007, 12525, 12879, 1046, 12880, 12818
4801, 12525, 1007, 1008, 12526, 12880, 1047, 12881, 12820
4802, 12526, 1008, 1009, 12527, 12881, 1048, 12882, 12822
4803, 12527, 1009, 1010, 12528, 12882, 1049, 12883, 12824
4804, 12528, 1010, 1011, 12529, 12883, 1050, 12884, 12826
4805, 12529, 1011, 1012, 12530, 12884, 1051, 12885, 12828
4806, 12530, 1012, 1013, 12531, 12885, 1052, 12886, 12830
4807, 12531, 1013, 1014, 12532, 12886, 1053, 12887, 12832
4808, 12532, 1014, 1015, 12533, 12887, 1054, 12888, 12834
4809, 12533, 1015, 1016, 12534, 12888, 1055, 12889, 12836
4810, 12534, 1016, 1017, 12535, 12889, 1056, 12890, 12838
4811, 12535, 1017, 1018, 12536, 12890, 1057, 12891, 12840
4812, 12536, 1018, 1019, 12537, 12891, 1058, 12892, 12842
4813, 12537, 1019, 1020, 12538, 12892, 1059, 12893, 12844
4814, 12538, 1020, 1021, 12539, 12893, 1060, 12894, 12846
4815, 12539, 1021, 1022, 12540, 12894, 1061, 12895, 12848
4816, 12540, 1022, 1023, 12541, 12895, 1062, 12896, 12850
4817, 12541, 1023, 1024, 12542, 12896, 1063, 12897, 12852
4818, 12542, 1024, 1025, 12543, 12897, 1064, 12898, 12854
4819, 12543, 1025, 1026, 12544, 12898, 1065, 12899, 12856
4820, 12544, 1026, 1027, 12545, 12899, 1066, 12900, 12858
4821, 12545, 1027, 1028, 12546, 12900, 1067, 12901, 12860
4822, 12546, 1028, 16, 984, 12901, 1068, 989, 12862
*ELEMENT, type=CPS8, ELSET=Surface8
4823, 12, 1069, 12902, 884, 1070, 12906, 12907, 888
4824, 884, 12902, 12903, 885, 12907, 12908, 12909, 889
4825, 885, 12903, 12904, 886, 12909, 12910, 12911, 890
4826, 886, 12904, 12905, 887, 12911, 12912, 12913, 891
4827, 887, 12905, 1072, 14, 12913, 12914, 1073, 892
4828, 1069, 17, 1075, 12902, 1071, 1079, 12915, 12906
4829, 12902, 1075, 1076, 12903, 12915, 1080, 12916, 12908
4830, 12903, 1076, 1077, 12904, 12916, 1081, 12917, 12910
4831, 12904, 1077, 1078, 12905, 12917, 1082, 12918, 12912
4832, 12905, 1078, 18, 1072, 12918, 1083, 1074, 12914
*ELEMENT, type=CPS8, ELSET=Surface9
4833, 1, 1084, 12919, 972, 1085, 12923, 12924, 976
4834, 972, 12919, 12920, 973, 12924, 12925, 12926, 977
4835, 973, 12920, 12921, 974, 12926, 12927, 12928, 978
4836, 974, 12921, 12922, 975, 12928, 12929, 12930, 979
4837, 975, 12922, 1087, 15, 12930, 12931, 1088, 980
4838, 1084, 19, 1090, 12919, 1086, 1094, 12932, 12923
4839, 12919, 1090, 1091, 12920, 12932, 1095, 12933, 12925
4840, 12920, 1091, 1092, 12921, 12933, 1096, 12934, 12927
4841, 12921, 1092, 1093, 12922, 12934, 1097, 12935, 12929
4842, 12922, 1093, 20, 1087, 12935, 1098, 1089, 12931
*ELEMENT, type=CPS8, ELSET=Surface10
4843, 15, 1099, 12936, 990, 1103, 13092, 13093, 1029
4844, 990, 12936, 12937, 991, 13093, 13094, 13095, 1030
4845, 991, 12937, 12938, 992, 13095, 13096, 13097, 1031
4846, 992, 12938, 12939, 993, 13097, 13098, 13099, 1032
4847, 993, 12939, 12940, 994, 13099, 13100, 13101, 1033
4848, 994, 12940, 12941, 995, 13101, 13102, 13103, 1034
4849, 995, 12941, 12942, 996, 13103, 13104, 13105, 1035
4850, 996, 12942, 12943, 997, 13105, 13106, 13107, 1036
4851, 997, 12943, 12944, 998, 13107, 13108, 13109, 1037
4852, 998, 12944, 12945, 999, 13109, 13110, 13111, 1038
4853, 999, 12945, 12946, 1000, 13111, 13112, 13113, 1039
4854, 1000, 12946, 12947, 1001, 13113, 13114, 13115, 1040
4855, 1001, 12947, 12948, 1002, 13115, 13116, 13117, 1041
4856, 1002, 12948, 12949, 1003, 13117, 13118, 13119, 1042
4857, 1003, 12949, 12950, 1004, 13119, 13120, 13121, 1043
4858, 1004, 12950, 12951, 1005, 13121, 13122, 13123, 1044
4859, 1005, 12951, 12952, 1006, 13123, 13124, 13125, 1045
4860, 1006, 12952, 12953, 1007, 13125, 13126, 13127, 1046
4861, 1007, 12953, 12954, 1008, 13127, 13128, 13129, 1047
4862, 1008, 12954, 12955, 1009, 13129, 13130, 13131, 1048
4863, 1009, 12955, 12956, 1010, 13131, 13132, 13133, 1049
4864, 1010, 12956, 12957, 1011, 13133, 13134, 13135, 1050
4865, 1011, 12957, 12958, 1012, 13135, 13136, 13137, 1051
4866, 1012, 12958, 12959, 1013, 13137, 13138, 13139, 1052
4867, 1013, 12959, 12960, 1014, 13139, 13140, 13141, 1053
4868, 1014, 12960, 12961, 1015, 13141, 13142, 13143, 1054
4869, 1015, 12961, 12962, 1016, 13143, 13144, 13145, 1055
4870, 1016, 12962, 12963, 1017, 13145, 13146, 13147, 1056
4871, 1017, 12963, 12964, 1018, 13147, 13148, 13149, 1057
4872, 1018, 12964, 12965, 1019, 13149, 13150, 13151, 1058
4873, 1019, 12965, 12966, 1020, 13151, 13152, 13153, 1059
4874, 1020, 12966, 12967, 1021, 13153, 13154, 13155, 1060
4875, 1021, 12967, 12968, 1022, 13155, 13156, 13157, 1061
4876, 1022, 12968, 12969, 1023, 13157, 13158, 13159, 1062
4877, 1023, 12969, 12970, 1024, 13159, 13160, 13161, 1063
4878, 1024, 12970, 12971, 1025, 13161, 13162, 13163, 1064
4879, 1025, 12971, 12972, 1026, 13163, 13164, 13165, 1065
4880, 1026, 12972, 12973, 1027, 13165, 13166, 13167, 1066
4881, 1027, 12973, 12974, 1028, 13167, 13168, 13169, 1067
4882, 1028, 12974, 1108, 16, 13169, 13170, 1112, 1068
4883, 1099, 1100, 12975, 12936, 1104, 13171, 13172, 13092
4884, 12936, 12975, 12976, 12937, 13172, 13173, 13174, 13094
4885, 12937, 12976, 12977, 12938, 13174, 13175, 13176, 13096
4886, 12938, 12977, 12978, 12939, 13176, 13177, 13178, 13098
4887, 12939, 12978, 12979, 12940, 13178, 13179, 13180, 13100
4888, 12940, 12979, 12980, 12941, 13180, 13181, 13182, 13102
4889, 12941, 12980, 12981, 12942, 13182, 13183, 13184, 13104
4890, 12942, 12981, 12982, 12943, 13184, 13185, 13186, 13106
4891, 12943, 12982, 12983, 12944, 13186, 13187, 13188, 13108
4892, 12944, 12983, 12984, 12945, 13188, 13189, 13190, 13110
4893, 12945, 12984, 12985, 12946, 13190, 13191, 13192, 13112
4894, 12946, 12985, 12986, 12947, 13192, 13193, 13194, 13114
4895, 12947, 12986, 12987, 12948, 13194, 13195, 13196, 13116
4896, 12948, 12987, 12988, 12949, 13196, 13197, 13198, 13118
4897, 12949, 12988, 12989, 12950, 13198, 13199, 13200, 13120
4898, 12950, 12989, 12990, 12951, 13200, 13201, 13202, 13122
4899, 12951, 12990, 12991, 12952, 13202, 13203, 13204, 13124
4900, 12952, 12991, 12992, 12953, 13204, 13205, 13206, 13126
4901, 12953, 12992, 12993, 12954, 13206, 13207, 13208, 13128
4902, 12954, 12993, 12994, 12955, 13208, 13209, 13210, 13130
4903, 12955, 12994, 12995, 12956, 13210, 13211, 13212, 13132
4904, 12956, 12995, 12996, 12957, 13212, 13213, 13214, 13134
4905, 12957, 12996, 12997, 12958, 13214, 13215, 13216, 13136
4906, 12958, 12997, 12998, 12959, 13216, 13217, 13218, 13138
4907, 12959, 12998, 12999, 12960, 13218, 13219, 13220, 13140
4908, 12960, 12999, 13000, 12961, 13220, 13221, 13222, 13142
4909, 12961, 13000, 13001, 12962, 13222, 13223, 13224, 13144
4910, 12962, 13001, 13002, 12963, 13224, 13225, 13226, 13146
4911, 12963, 13002, 13003, 12964, 13226, 13227, 13228, 13148
4912, 12964, 13003, 13004, 12965, 13228, 13229, 13230, 13150
4913, 12965, 13004, 13005, 12966, 13230, 13231, 13232, 13152
4914, 12966, 13005, 13006, 12967, 13232, 13233, 13234, 13154
4915, 12967, 13006, 13007, 12968, 13234, 13235, 13236, 13156
4916, 12968, 13007, 13008, 12969, 13236, 13237, 13238, 13158
4917, 12969, 13008, 13009, 12970, 13238, 13239, 13240, 13160
4918, 12970, 13009, 13010, 12971, 13240, 13241, 13242, 13162
4919, 12971, 13010, 13011, 12972, 13242, 13243, 13244, 13164
4920, 12972, 13011, 13012, 12973, 13244, 13245, 13246, 13166
4921, 12973, 13012, 13013, 12974, 13246, 13247, 13248, 13168
4922, 12974, 13013, 1109, 1108, 13248, 13249, 1113, 13170
4923, 1100, 1101, 13014, 12975, 1105, 13250, 13251, 13171
4924, 12975, 13014, 13015, 12976, 13251, 13252, 13253, 13173
4925, 12976, 13015, 13016, 12977, 13253, 13254, 13255, 13175
4926, 12977, 13016, 13017, 12978, 13255, 13256, 13257, 13177
4927, 12978, 13017, 13018, 12979, 13257, 13258, 13259, 13179
4928, 12979, 13018, 13019, 12980, 13259, 13260, 13261, 13181
4929, 12980, 13019, 13020, 12981, 13261, 13262, 13263, 13183
4930, 12981, 13020, 13021, 12982, 13263, 13264, 13265, 13185
4931, 12982, 13021, 13022, 12983, 13265, 13266, 13267, 13187
4932, 12983, 13022, 13023, 12984, 13267, 13268, 13269, 13189
4933, 12984, 13023, 13024, 12985, 13269, 13270, 13271, 13191
4934, 12985, 13024, 13025, 12986, 13271, 13272, 13273, 13193
4935, 12986, 13025, 13026, 12987, 13273, 13274, 13275, 13195
4936, 12987, 13026, 13027, 12988, 13275, 13276, 13277, 13197
4937, 12988, 13027, 13028, 12989, 13277, 13278, 13279, 13199
4938, 12989, 13028, 13029, 12990, 13279, 13280, 13281, 13201
4939, 12990, 13029, 13030, 12991, 13281, 13282, 13283, 13203
4940, 12991, 13030, 13031, 12992, 13283, 13284, 13285, 13205
4941, 12992, 13031, 13032, 12993, 13285, 13286, 13287, 13207
4942, 12993, 13032, 13033, 12994, 13287, 13288, 13289, 13209
4943, 12994, 13033, 13034, 12995, 13289, 13290, 13291, 13211
4944, 12995, 13034, 13035, 12996, 13291, 13292, 13293, 13213
4945, 12996, 13035, 13036, 12997, 13293, 13294, 13295, 13215
4946, 12997, 13036, 13037, 12998, 13295, 13296, 13297, 13217
4947, 12998, 13037, 13038, 12999, 13297, 13298, 13299, 13219
4948, 12999, 13038, 13039, 13000, 13299, 13300, 13301, 13221
4949, 13000, 13039, 13040, 13001, 13301, 13302, 13303, 13223
4950, 13001, 13040, 13041, 13002, 13303, 13304, 13305, 13225
4951, 13002, 13041, 13042, 13003, 13305, 13306, 13307, 13227
4952, 13003, 13042, 13043, 13004, 13307, 13308, 13309, 13229
4953, 13004, 13043, 13044, 13005, 13309, 13310, 13311, 13231
4954, 13005, 13044, 13045, 13006, 13311, 13312, 13313, 13233
4955, 13006, 13045, 13046, 13007, 13313, 13314, 13315, 13235
4956, 13007, 13046, 13047, 13008, 13315, 13316, 13317, 13237
4957, 13008, 13047, 13048, 13009, 13317, 13318, 13319, 13239
4958, 13009, 13048, 13049, 13010, 13319, 13320, 13321, 13241
4959, 13010, 13049, 13050, 13011, 13321, 13322, 13323, 13243
4960, 13011, 13050, 13051, 13012, 13323, 13324, 13325, 13245
4961, 13012, 13051, 13052, 13013, 13325, 13326, 13327, 13247
4962, 13013, 13052, 1110, 1109, 13327, 13328, 1114, 13249
4963, 1101, 1102, 13053, 13014, 1106, 13329, 13330, 13250
4964, 13014, 13053, 13054, 13015, 13330, 13331, 13332, 13252
4965, 13015, 13054, 13055, 13016, 13332, 13333, 13334, 13254
4966, 13016, 13055, 13056, 13017, 13334, 13335, 13336, 13256
4967, 13017, 13056, 13057, 13018, 13336, 13337, 13338, 13258
4968, 13018, 13057, 13058, 13019, 13338, 13339, 13340, 13260
4969, 13019, 13058, 13059, 13020, 13340, 13341, 13342, 13262
4970, 13020, 13059, 13060, 13021, 13342, 13343, 13344, 13264
4971, 13021, 13060, 13061, 13022, 13344, 13345, 13346, 13266
4972, 13022, 13061, 13062, 13023, 13346, 13347, 13348, 13268
4973, 13023, 13062, 13063, 13024, 13348, 13349, 13350, 13270
4974, 13024, 13063, 13064, 13025, 13350, 13351, 13352, 13272
4975, 13025, 13064, 13065, 13026, 13352, 13353, 13354, 13274
4976, 13026, 13065, 13066, 13027, 13354, 13355, 13356, 13276
4977, 13027, 13066, 13067, 13028, 13356, 13357, 13358, 13278
4978, 13028, 13067, 13068, 13029, 13358, 13359, 13360, 13280
4979, 13029, 13068, 13069, 13030, 13360, 13361, 13362, 13282
4980, 13030, 13069, 13070, 13031, 13362, 13363, 13364, 13284
4981, 13031, 13070, 13071, 13032, 13364, 13365, 13366, 13286
4982, 13032, 13071, 13072, 13033, 13366, 13367, 13368, 13288
4983, 13033, 13072, 13073, 13034, 13368, 13369, 13370, 13290
4984, 13034, 13073, 13074, 13035, 13370, 13371, 13372, 13292
4985, 13035, 13074, 13075, 13036, 13372, 13373, 13374, 13294
4986, 13036, 13075, 13076, 13037, 13374, 13375, 13376, 13296
4987, 13037, 13076, 13077, 13038, 13376, 13377, 13378, 13298
4988, 13038, 13077, 13078, 13039, 13378, 13379, 13380, 13300
4989, 13039, 13078, 13079, 13040, 13380, 13381, 13382, 13302
4990, 13040, 13079, 13080, 13041, 13382, 13383, 13384, 13304
4991, 13041, 13080, 13081, 13042, 13384, 13385, 13386, 13306
4992, 13042, 13081, 13082, 13043, 13386, 13387, 13388, 13308
4993, 13043, 13082, 13083, 13044, 13388, 13389, 13390, 13310
4994, 13044, 13083, 13084, 13045, 13390, 13391, 13392, 13312
4995, 13045, 13084, 13085, 13046, 13392, 13393, 13394, 13314
4996, 13046, 13085, 13086, 13047, 13394, 13395, 13396, 13316
4997, 13047, 13086, 13087, 13048, 13396, 13397, 13398, 13318
4998, 13048, 13087, 13088, 13049, 13398, 13399, 13400, 13320
4999, 13049, 13088, 13089, 13050, 13400, 13401, 13402, 13322
5000, 13050, 13089, 13090, 13051, 13402, 13403, 13404, 13324
5001, 13051, 13090, 13091, 13052, 13404, 13405, 13406, 13326
5002, 13052, 13091, 1111, 1110, 13406, 13407, 1115, 13328
5003, 1102, 21, 1117, 13053, 1107, 1156, 13408, 13329
5004, 13053, 1117, 1118, 13054, 13408, 1157, 13409, 13331
5005, 13054, 1118, 1119, 13055, 13409, 1158, 13410, 13333
5006, 13055, 1119, 1120, 13056, 13410, 1159, 13411, 13335
5007, 13056, 1120, 1121, 13057, 13411, 1160, 13412, 13337
5008, 13057, 1121, 1122, 13058, 13412, 1161, 13413, 13339
5009, 13058, 1122, 1123, 13059, 13413, 1162, 13414, 13341
5010, 13059, 1123, 1124, 13060, 13414, 1163, 13415, 13343
5011, 13060, 1124, 1125, 13061, 13415, 1164, 13416, 13345
5012, 13061, 1125, 1126, 13062, 13416, 1165, 13417, 13347
5013, 13062, 1126, 1127, 13063, 13417, 1166, 13418, 13349
5014, 13063, 1127, 1128, 13064, 13418, 1167, 13419, 13351
5015, 13064, 1128, 1129, 13065, 13419, 1168, 13420, 13353
5016, 13065, 1129, 1130, 13066, 13420, 1169, 13421, 13355
5017, 13066, 1130, 1131, 13067, 13421, 1170, 13422, 13357
5018, 13067, 1131, 1132, 13068, 13422, 1171, 13423, 13359
5019, 13068, 1132, 1133, 13069, 13423, 1172, 13424, 13361
5020, 13069, 1133, 1134, 13070, 13424, 1173, 13425, 13363
5021, 13070, 1134, 1135, 13071, 13425, 1174, 13426, 13365
5022, 13071, 1135, 1136, 13072, 13426, 1175, 13427, 13367
5023, 13072, 1136, 1137, 13073, 13427, 1176, 13428, 13369
5024, 13073, 1137, 1138, 13074, 13428, 1177, 13429, 13371
5025, 13074, 1138, 1139, 13075, 13429, 1178, 13430, 13373
5026, 13075, 1139, 1140, 13076, 13430, 1179, 13431, 13375
5027, 13076, 1140, 1141, 13077, 13431, 1180, 13432, 13377
5028, 13077, 1141, 1142, 13078, 13432, 1181, 13433, 13379
5029, 13078, 1142, 1143, 13079, 13433, 1182, 13434, 13381
5030, 13079, 1143, 1144, 13080, 13434, 1183, 13435, 13383
5031, 13080, 1144, 1145, 13081, 13435, 1184, 13436, 13385
5032, 13081, 1145, 1146, 13082, 13436, 1185, 13437, 13387
5033, 13082, 1146, 1147, 13083, 13437, 1186, 13438, 13389
5034, 13083, 1147, 1148, 13084, 13438, 1187, 13439, 13391
5035, 13084, 1148, 1149, 13085, 13439, 1188, 13440, 13393
5036, 13085, 1149, 1150, 13086, 13440, 1189, 13441, 13395
5037, 13086, 1150, 1151, 13087, 13441, 1190, 13442, 13397
5038, 13087, 1151, 1152, 13088, 13442, 1191, 13443, 13399
5039, 13088, 1152, 1153, 13089, 13443, 1192, 13444, 13401
5040, 13089, 1153, 1154, 13090, 13444, 1193, 13445, 13403
5041, 13090, 1154, 1155, 13091, 13445, 1194, 13446, 13405
5042, 13091, 1155, 22, 1111, 13446, 1195, 1116, 13407
*ELEMENT, type=CPS8, ELSET=Surface11
5043, 15, 1099, 13447, 1087, 1103, 13451, 13452, 1088
5044, 1087, 13447, 1196, 20, 13452, 13453, 1200, 1089
5045, 1099, 1100, 13448, 13447, 1104, 13454, 13455, 13451
5046, 13447, 13448, 1197, 1196, 13455, 13456, 1201, 13453
5047, 1100, 1101, 13449, 13448, 1105, 13457, 13458, 13454
5048, 13448, 13449, 1198, 1197, 13458, 13459, 1202, 13456
5049, 1101, 1102, 13450, 13449, 1106, 13460, 13461, 13457
5050, 13449, 13450, 1199, 1198, 13461, 13462, 1203, 13459
5051, 1102, 21, 1205, 13450, 1107, 1206, 13463, 13460
5052, 13450, 1205, 23, 1199, 13463, 1207, 1204, 13462
*ELEMENT, type=CPS8, ELSET=Surface12
5053, 13, 1208, 13464, 893, 1212, 13620, 13621, 932
5054, 893, 13464, 13465, 894, 13621, 13622, 13623, 933
5055, 894, 13465, 13466, 895, 13623, 13624, 13625, 934
5056, 895, 13466, 13467, 896, 13625, 13626, 13627, 935
5057, 896, 13467, 13468, 897, 13627, 13628, 13629, 936
5058, 897, 13468, 13469, 898, 13629, 13630, 13631, 937
5059, 898, 13469, 13470, 899, 13631, 13632, 13633, 938
5060, 899, 13470, 13471, 900, 13633, 13634, 13635, 939
5061, 900, 13471, 13472, 901, 13635, 13636, 13637, 940
5062, 901, 13472, 13473, 902, 13637, 13638, 13639, 941
5063, 902, 13473, 13474, 903, 13639, 13640, 13641, 942
5064, 903, 13474, 13475, 904, 13641, 13642, 13643, 943
5065, 904, 13475, 13476, 905, 13643, 13644, 13645, 944
5066, 905, 13476, 13477, 906, 13645, 13646, 13647, 945
5067, 906, 13477, 13478, 907, 13647, 13648, 13649, 946
5068, 907, 13478, 13479, 908, 13649, 13650, 13651, 947
5069, 908, 13479, 13480, 909, 13651, 13652, 13653, 948
5070, 909, 13480, 13481, 910, 13653, 13654, 13655, 949
5071, 910, 13481, 13482, 911, 13655, 13656, 13657, 950
5072, 911, 13482, 13483, 912, 13657, 13658, 13659, 951
5073, 912, 13483, 13484, 913, 13659, 13660, 13661, 952
5074, 913, 13484, 13485, 914, 13661, 13662, 13663, 953
5075, 914, 13485, 13486, 915, 13663, 13664, 13665, 954
5076, 915, 13486, 13487, 916, 13665, 13666, 13667, 955
5077, 916, 13487, 13488, 917, 13667, 13668, 13669, 956
5078, 917, 13488, 13489, 918, 13669, 13670, 13671, 957
5079, 918, 13489, 13490, 919, 13671, 13672, 13673, 958
5080, 919, 13490, 13491, 920, 13673, 13674, 13675, 959
5081, 920, 13491, 13492, 921, 13675, 13676, 13677, 960
5082, 921, 13492, 13493, 922, 13677, 13678, 13679, 961
5083, 922, 13493, 13494, 923, 13679, 13680, 13681, 962
5084, 923, 13494, 13495, 924, 13681, 13682, 13683, 963
5085, 924, 13495, 13496, 925, 13683, 13684, 13685, 964
5086, 925, 13496, 13497, 926, 13685, 13686, 13687, 965
5087, 926, 13497, 13498, 927, 13687, 13688, 13689, 966
5088, 927, 13498, 13499, 928, 13689, 13690, 13691, 967
5089, 928, 13499, 13500, 929, 13691, 13692, 13693, 968
5090, 929, 13500, 13501, 930, 13693, 13694, 13695, 969
5091, 930, 13501, 13502, 931, 13695, 13696, 13697, 970
5092, 931, 13502, 1217, 14, 13697, 13698, 1221, 971
5093, 1208, 1209, 13503, 13464, 1213, 13699, 13700, 13620
5094, 13464, 13503, 13504, 13465, 13700, 13701, 13702, 13622
5095, 13465, 13504, 13505, 13466, 13702, 13703, 13704, 13624
5096, 13466, 13505, 13506, 13467, 13704, 13705, 13706, 13626
5097, 13467, 13506, 13507, 13468, 13706, 13707, 13708, 13628
5098, 13468, 13507, 13508, 13469, 13708, 13709, 13710, 13630
5099, 13469, 13508, 13509, 13470, 13710, 13711, 13712, 13632
5100, 13470, 13509, 13510, 13471, 13712, 13713, 13714, 13634
5101, 13471, 13510, 13511, 13472, 13714, 13715, 13716, 13636
5102, 13472, 13511, 13512, 13473, 13716, 13717, 13718, 13638
5103, 13473, 13512, 13513, 13474, 13718, 13719, 13720, 13640
5104, 13474, 13513, 13514, 13475, 13720, 13721, 13722, 13642
5105, 13475, 13514, 13515, 13476, 13722, 13723, 13724, 13644
5106, 13476, 13515, 13516, 13477, 13724, 13725, 13726, 13646
5107, 13477, 13516, 13517, 13478, 13726, 13727, 13728, 13648
5108, 13478, 13517, 13518, 13479, 13728, 13729, 13730, 13650
5109, 13479, 13518, 13519, 13480, 13730, 13731, 13732, 13652
5110, 13480, 13519, 13520, 13481, 13732, 13733, 13734, 13654
5111, 13481, 13520, 13521, 13482, 13734, 13735, 13736, 13656
5112, 13482, 13521, 13522, 13483, 13736, 13737, 13738, 13658
5113, 13483, 13522, 13523, 13484, 13738, 13739, 13740, 13660
5114, 13484, 13523, 13524, 13485, 13740, 13741, 13742, 13662
5115, 13485, 13524, 13525, 13486, 13742, 13743, 13744, 13664
5116, 13486, 13525, 13526, 13487, 13744, 13745, 13746, 13666
5117, 13487, 13526, 13527, 13488, 13746, 13747, 13748, 13668
5118, 13488, 13527, 13528, 13489, 13748, 13749, 13750, 13670
5119, 13489, 13528, 13529, 13490, 13750, 13751, 13752, 13672
5120, 13490, 13529, 13530, 13491, 13752, 13753, 13754, 13674
5121, 13491, 13530, 13531, 13492, 13754, 13755, 13756, 13676
5122, 13492, 13531, 13532, 13493, 13756, 13757, 13758, 13678
5123, 13493, 13532, 13533, 13494, 13758, 13759, 13760, 13680
5124, 13494, 13533, 13534, 13495, 13760, 13761, 13762, 13682
5125, 13495, 13534, 13535, 13496, 13762, 13763, 13764, 13684
5126, 13496, 13535, 13536, 13497, 13764, 13765, 13766, 13686
5127, 13497, 13536, 13537, 13498, 13766, 13767, 13768, 13688
5128, 13498, 13537, 13538, 13499, 13768, 13769, 13770, 13690
5129, 13499, 13538, 13539, 13500, 13770, 13771, 13772, 13692
5130, 13500, 13539, 13540, 13501, 13772, 13773, 13774, 13694
5131, 13501, 13540, 13541, 13502, 13774, 13775, 13776, 13696
5132, 13502, 13541, 1218, 1217, 13776, 13777, 1222, 13698
5133, 1209, 1210, 13542, 13503, 1214, 13778, 13779, 13699
5134, 13503, 13542, 13543, 13504, 13779, 13780, 13781, 13701
5135, 13504, 13543, 13544, 13505, 13781, 13782, 13783, 13703
5136, 13505, 13544, 13545, 13506, 13783, 13784, 13785, 13705
5137, 13506, 13545, 13546, 13507, 13785, 13786, 13787, 13707
5138, 13507, 13546, 13547, 13508, 13787, 13788, 13789, 13709
5139, 13508, 13547, 13548, 13509, 13789, 13790, 13791, 13711
5140, 13509, 13548, 13549, 13510, 13791, 13792, 13793, 13713
5141, 13510, 13549, 13550, 13511, 13793, 13794, 13795, 13715
5142, 13511, 13550, 13551, 13512, 13795, 13796, 13797, 13717
5143, 13512, 13551, 13552, 13513, 13797, 13798, 13799, 13719
5144, 13513, 13552, 13553, 13514, 13799, 13800, 13801, 13721
5145, 13514, 13553, 13554, 13515, 13801, 13802, 13803, 13723
5146, 13515, 13554, 13555, 13516, 13803, 13804, 13805, 13725
5147, 13516, 13555, 13556, 13517, 13805, 13806, 13807, 13727
5148, 13517, 13556, 13557, 13518, 13807, 13808, 13809, 13729
5149, 13518, 13557, 13558, 13519, 13809, 13810, 13811, 13731
5150, 13519, 13558, 13559, 13520, 13811, 13812, 13813, 13733
5151, 13520, 13559, 13560, 13521, 13813, 13814, 13815, 13735
5152, 13521, 13560, 13561, 13522, 13815, 13816, 13817, 13737
5153, 13522, 13561, 13562, 13523, 13817, 13818, 13819, 13739
5154, 13523, 13562, 13563, 13524, 13819, 13820, 13821, 13741
5155, 13524, 13563, 13564, 13525, 13821, 13822, 13823, 13743
5156, 13525, 13564, 13565, 13526, 13823, 13824, 13825, 13745
5157, 13526, 13565, 13566, 13527, 13825, 13826, 13827, 13747
5158, 13527, 13566, 13567, 13528, 13827, 13828, 13829, 13749
5159, 13528, 13567, 13568, 13529, 13829, 13830, 13831, 13751
5160, 13529, 13568, 13569, 13530, 13831, 13832, 13833, 13753
5161, 13530, 13569, 13570, 13531, 13833, 13834, 13835, 13755
5162, 13531, 13570, 13571, 13532, 13835, 13836, 13837, 13757
5163, 13532, 13571, 13572, 13533, 13837, 13838, 13839, 13759
5164, 13533, 13572, 13573, 13534, 13839, 13840, 13841, 13761
5165, 13534, 13573, 13574, 13535, 13841, 13842, 13843, 13763
5166, 13535, 13574, 13575, 13536, 13843, 13844, 13845, 13765
5167, 13536, 13575, 13576, 13537, 13845, 13846, 13847, 13767
5168, 13537, 13576, 13577, 13538, 13847, 13848, 13849, 13769
5169, 13538, 13577, 13578, 13539, 13849, 13850, 13851, 13771
5170, 13539, 13578, 13579, 13540, 13851, 13852, 13853, 13773
5171, 13540, 13579, 13580, 13541, 13853, 13854, 13855, 13775
5172, 13541, 13580, 1219, 1218, 13855, 13856, 1223, 13777
5173, 1210, 1211, 13581, 13542, 1215, 13857, 13858, 13778
5174, 13542, 13581, 13582, 13543, 13858, 13859, 13860, 13780
5175, 13543, 13582, 13583, 13544, 13860, 13861, 13862, 13782
5176, 13544, 13583, 13584, 13545, 13862, 13863, 13864, 13784
5177, 13545, 13584, 13585, 13546, 13864, 13865, 13866, 13786
5178, 13546, 13585, 13586, 13547, 13866, 13867, 13868, 13788
5179, 13547, 13586, 13587, 13548, 13868, 13869, 13870, 13790
5180, 13548, 13587, 13588, 13549, 13870, 13871, 13872, 13792
5181, 13549, 13588, 13589, 13550, 13872, 13873, 13874, 13794
5182, 13550, 13589, 13590, 13551, 13874, 13875, 13876, 13796
5183, 13551, 13590, 13591, 13552, 13876, 13877, 13878, 13798
5184, 13552, 13591, 13592, 13553, 13878, 13879, 13880, 13800
5185, 13553, 13592, 13593, 13554, 13880, 13881, 13882, 13802
5186, 13554, 13593, 13594, 13555, 13882, 13883, 13884, 13804
5187, 13555, 13594, 13595, 13556, 13884, 13885, 13886, 13806
5188, 13556, 13595, 13596, 13557, 13886, 13887, 13888, 13808
5189, 13557, 13596, 13597, 13558, 13888, 13889, 13890, 13810
5190, 13558, 13597, 13598, 13559, 13890, 13891, 13892, 13812
5191, 13559, 13598, 13599, 13560, 13892, 13893, 13894, 13814
5192, 13560, 13599, 13600, 13561, 13894, 13895, 13896, 13816
5193, 13561, 13600, 13601, 13562, 13896, 13897, 13898, 13818
5194, 13562, 13601, 13602, 13563, 13898, 13899, 13900, 13820
5195, 13563, 13602, 13603, 13564, 13900, 13901, 13902, 13822
5196, 13564, 13603, 13604, 13565, 13902, 13903, 13904, 13824
5197, 13565, 13604, 13605, 13566, 13904, 13905, 13906, 13826
5198, 13566, 13605, 13606, 13567, 13906, 13907, 13908, 13828
5199, 13567, 13606, 13607, 13568, 13908, 13909, 13910, 13830
5200, 13568, 13607, 13608, 13569, 13910, 13911, 13912, 13832
5201, 13569, 13608, 13609, 13570, 13912, 13913, 13914, 13834
5202, 13570, 13609, 13610, 13571, 13914, 13915, 13916, 13836
5203, 13571, 13610, 13611, 13572, 13916, 13917, 13918, 13838
5204, 13572, 13611, 13612, 13573, 13918, 13919, 13920, 13840
5205, 13573, 13612, 13613, 13574, 13920, 13921, 13922, 13842
5206, 13574, 13613, 13614, 13575, 13922, 13923, 13924, 13844
5207, 13575, 13614, 13615, 13576, 13924, 13925, 13926, 13846
5208, 13576, 13615, 13616, 13577, 13926, 13927, 13928, 13848
5209, 13577, 13616, 13617, 13578, 13928, 13929, 13930, 13850
5210, 13578, 13617, 13618, 13579, 13930, 13931, 13932, 13852
5211, 13579, 13618, 13619, 13580, 13932, 13933, 13934, 13854
5212, 13580, 13619, 1220, 1219, 13934, 13935, 1224, 13856
5213, 1211, 24, 1226, 13581, 1216, 1265, 13936, 13857
5214, 13581, 1226, 1227, 13582, 13936, 1266, 13937, 13859
5215, 13582, 1227, 1228, 13583, 13937, 1267, 13938, 13861
5216, 13583, 1228, 1229, 13584, 13938, 1268, 13939, 13863
5217, 13584, 1229, 1230, 13585, 13939, 1269, 13940, 13865
5218, 13585, 1230, 1231, 13586, 13940, 1270, 13941, 13867
5219, 13586, 1231, 1232, 13587, 13941, 1271, 13942, 13869
5220, 13587, 1232, 1233, 13588, 13942, 1272, 13943, 13871
5221, 13588, 1233, 1234, 13589, 13943, 1273, 13944, 13873
5222, 13589, 1234, 1235, 13590, 13944, 1274, 13945, 13875
5223, 13590, 1235, 1236, 13591, 13945, 1275, 13946, 13877
5224, 13591, 1236, 1237, 13592, 13946, 1276, 13947, 13879
5225, 13592, 1237, 1238, 13593, 13947, 1277, 13948, 13881
5226, 13593, 1238, 1239, 13594, 13948, 1278, 13949, 13883
5227, 13594, 1239, 1240, 13595, 13949, 1279, 13950, 13885
5228, 13595, 1240, 1241, 13596, 13950, 1280, 13951, 13887
5229, 13596, 1241, 1242, 13597, 13951, 1281, 13952, 13889
5230, 13597, 1242, 1243, 13598, 13952, 1282, 13953, 13891
5231, 13598, 1243, 1244, 13599, 13953, 1283, 13954, 13893
5232, 13599, 1244, 1245, 13600, 13954, 1284, 13955, 13895
5233, 13600, 1245, 1246, 13601, 13955, 1285, 13956, 13897
5234, 13601, 1246, 1247, 13602, 13956, 1286, 13957, 13899
5235, 13602, 1247, 1248, 13603, 13957, 1287, 13958, 13901
5236, 13603, 1248, 1249, 13604, 13958, 1288, 13959, 13903
5237, 13604, 1249, 1250, 13605, 13959, 1289, 13960, 13905
5238, 13605, 1250, 1251, 13606, 13960, 1290, 13961, 13907
5239, 13606, 1251, 1252, 13607, 13961, 1291, 13962, 13909
5240, 13607, 1252, 1253, 13608, 13962, 1292, 13963, 13911
5241, 13608, 1253, 1254, 13609, 13963, 1293, 13964, 13913
5242, 13609, 1254, 1255, 13610, 13964, 1294, 13965, 13915
5243, 13610, 1255, 1256, 13611, 13965, 1295, 13966, 13917
5244, 13611, 1256, 1257, 13612, 13966, 1296, 13967, 13919
5245, 13612, 1257, 1258, 13613, 13967, 1297, 13968, 13921
5246, 13613, 1258, 1259, 13614, 13968, 1298, 13969, 13923
5247, 13614, 1259, 1260, 13615, 13969, 1299, 13970, 13925
5248, 13615, 1260, 1261, 13616, 13970, 1300, 13971, 13927
5249, 13616, 1261, 1262, 13617, 13971, 1301, 13972, 13929
5250, 13617, 1262, 1263, 13618, 13972, 1302, 13973, 13931
5251, 13618, 1263, 1264, 13619, 13973, 1303, 13974, 13933
5252, 13619, 1264, 25, 1220, 13974, 1304, 1225, 13935
*ELEMENT, type=CPS8, ELSET=Surface13
5253, 14, 1217, 13975, 1072, 1221, 13979, 13980, 1073
5254, 1072, 13975, 1305, 18, 13980, 13981, 1309, 1074
5255, 1217, 1218, 13976, 13975, 1222, 13982, 13983, 13979
5256, 13975, 13976, 1306, 1305, 13983, 13984, 1310, 13981
5257, 1218, 1219, 13977, 13976, 1223, 13985, 13986, 13982
5258, 13976, 13977, 1307, 1306, 13986, 13987, 1311, 13984
5259, 1219, 1220, 13978, 13977, 1224, 13988, 13989, 13985
5260, 13977, 13978, 1308, 1307, 13989, 13990, 1312, 13987
5261, 1220, 25, 1314, 13978, 1225, 1315, 13991, 13988
5262, 13978, 1314, 26, 1308, 13991, 1316, 1313, 13990
*ELEMENT, type=CPS8, ELSET=Surface14
5263, 5, 1317, 13992, 365, 1321, 14148, 14149, 404
5264, 365, 13992, 13993, 366, 14149, 14150, 14151, 405
5265, 366, 13993, 13994, 367, 14151, 14152, 14153, 406
5266, 367, 13994, 13995, 368, 14153, 14154, 14155, 407
5267, 368, 13995, 13996, 369, 14155, 14156, 14157, 408
5268, 369, 13996, 13997, 370, 14157, 14158, 14159, 409
5269, 370, 13997, 13998, 371, 14159, 14160, 14161, 410
5270, 371, 13998, 13999, 372, 14161, 14162, 14163, 411
5271, 372, 13999, 14000, 373, 14163, 14164, 14165, 412
5272, 373, 14000, 14001, 374, 14165, 14166, 14167, 413
5273, 374, 14001, 14002, 375, 14167, 14168, 14169, 414
5274, 375, 14002, 14003, 376, 14169, 14170, 14171, 415
5275, 376, 14003, 14004, 377, 14171, 14172, 14173, 416
5276, 377, 14004, 14005, 378, 14173, 14174, 14175, 417
5277, 378, 14005, 14006, 379, 14175, 14176, 14177, 418
5278, 379, 14006, 14007, 380, 14177, 14178, 14179, 419
5279, 380, 14007, 14008, 381, 14179, 14180, 14181, 420
5280, 381, 14008, 14009, 382, 14181, 14182, 14183, 421
5281, 382, 14009, 14010, 383, 14183, 14184, 14185, 422
5282, 383, 14010, 14011, 384, 14185, 14186, 14187, 423
5283, 384, 14011, 14012, 385, 14187, 14188, 14189, 424
5284, 385, 14012, 14013, 386, 14189, 14190, 14191, 425
5285, 386, 14013, 14014, 387, 14191, 14192, 14193, 426
5286, 387, 14014, 14015, 388, 14193, 14194, 14195, 427
5287, 388, 14015, 14016, 389, 14195, 14196, 14197, 428
5288, 389, 14016, 14017, 390, 14197, 14198, 14199, 429
5289, 390, 14017, 14018, 391, 14199, 14200, 14201, 430
5290, 391, 14018, 14019, 392, 14201, 14202, 14203, 431
5291, 392, 14019, 14020, 393, 14203, 14204, 14205, 432
5292, 393, 14020, 14021, 394, 14205, 14206, 14207, 433
5293, 394, 14021, 14022, 395, 14207, 14208, 14209, 434
5294, 395, 14022, 14023, 396, 14209, 14210, 14211, 435
5295, 396, 14023, 14024, 397, 14211, 14212, 14213, 436
5296, 397, 14024, 14025, 398, 14213, 14214, 14215, 437
5297, 398, 14025, 14026, 399, 14215, 14216, 14217, 438
5298, 399, 14026, 14027, 400, 14217, 14218, 14219, 439
5299, 400, 14027, 14028, 401, 14219, 14220, 14221, 440
5300, 401, 14028, 14029, 402, 14221, 14222, 14223, 441
5301, 402, 14029, 14030, 403, 14223, 14224, 14225, 442
5302, 403, 14030, 1326, 6, 14225, 14226, 1330, 443
5303, 1317, 1318, 14031, 13992, 1322, 14227, 14228, 14148
5304, 13992, 14031, 14032, 13993, 14228, 14229, 14230, 14150
5305, 13993, 14032, 14033, 13994, 14230, 14231, 14232, 14152
5306, 13994, 14033, 14034, 13995, 14232, 14233, 14234, 14154
5307, 13995, 14034, 14035, 13996, 14234, 14235, 14236, 14156
5308, 13996, 14035, 14036, 13997, 14236, 14237, 14238, 14158
5309, 13997, 14036, 14037, 13998, 14238, 14239, 14240, 14160
5310, 13998, 14037, 14038, 13999, 14240, 14241, 14242, 14162
5311, 13999, 14038, 14039, 14000, 14242, 14243, 14244, 14164
5312, 14000, 14039, 14040, 14001, 14244, 14245, 14246, 14166
5313, 14001, 14040, 14041, 14002, 14246, 14247, 14248, 14168
5314, 14002, 14041, 14042, 14003, 14248, 14249, 14250, 14170
5315, 14003, 14042, 14043, 14004, 14250, 14251, 14252, 14172
5316, 14004, 14043, 14044, 14005, 14252, 14253, 14254, 14174
5317, 14005, 14044, 14045, 14006, 14254, 14255, 14256, 14176
5318, 14006, 14045, 14046, 14007, 14256, 14257, 14258, 14178
5319, 14007, 14046, 14047, 14008, 14258, 14259, 14260, 14180
5320, 14008, 14047, 14048, 14009, 14260, 14261, 14262, 14182
5321, 14009, 14048, 14049, 14010, 14262, 14263, 14264, 14184
5322, 14010, 14049, 14050, 14011, 14264, 14265, 14266, 14186
5323, 14011, 14050, 14051, 14012, 14266, 14267, 14268, 14188
5324, 14012, 14051, 14052, 14013, 14268, 14269, 14270, 14190
5325, 14013, 14052, 14053, 14014, 14270, 14271, 14272, 14192
5326, 14014, 14053, 14054, 14015, 14272, 14273, 14274, 14194
5327, 14015, 14054, 14055, 14016, 14274, 14275, 14276, 14196
5328, 14016, 14055, 14056, 14017, 14276, 14277, 14278, 14198
5329, 14017, 14056, 14057, 14018, 14278, 14279, 14280, 14200
5330, 14018, 14057, 14058, 14019, 14280, 14281, 14282, 14202
5331, 14019, 14058, 14059, 14020, 14282, 14283, 14284, 14204
5332, 14020, 14059, 14060, 14021, 14284, 14285, 14286, 14206
5333, 14021, 14060, 14061, 14022, 14286, 14287, 14288, 14208
5334, 14022, 14061, 14062, 14023, 14288, 14289, 14290, 14210
5335, 14023, 14062, 14063, 14024, 14290, 14291, 14292, 14212
5336, 14024, 14063, 14064, 14025, 14292, 14293, 14294, 14214
5337, 14025, 14064, 14065, 14026, 14294, 14295, 14296, 14216
5338, 14026, 14065, 14066, 14027, 14296, 14297, 14298, 14218
5339, 14027, 14066, 14067, 14028, 14298, 14299, 14300, 14220
5340, 14028, 14067, 14068, 14029, 14300, 14301, 14302, 14222
5341, 14029, 14068, 14069, 14030, 14302, 14303, 14304, 14224
5342, 14030, 14069, 1327, 1326, 14304, 14305, 1331, 14226
5343, 1318, 1319, 14070, 14031, 1323, 14306, 14307, 14227
5344, 14031, 14070, 14071, 14032, 14307, 14308, 14309, 14229
5345, 14032, 14071, 14072, 14033, 14309, 14310, 14311, 14231
5346, 14033, 14072, 14073, 14034, 14311, 14312, 14313, 14233
5347, 14034, 14073, 14074, 14035, 14313, 14314, 14315, 14235
5348, 14035, 14074, 14075, 14036, 14315, 14316, 14317, 14237
5349, 14036, 14075, 14076, 14037, 14317, 14318, 14319, 14239
5350, 14037, 14076, 14077, 14038, 14319, 14320, 14321, 14241
5351, 14038, 14077, 14078, 14039, 14321, 14322, 14323, 14243
5352, 14039, 14078, 14079, 14040, 14323, 14324, 14325, 14245
5353, 14040, 14079, 14080, 14041, 14325, 14326, 14327, 14247
5354, 14041, 14080, 14081, 14042, 14327, 14328, 14329, 14249
5355, 14042, 14081, 14082, 14043, 14329, 14330, 14331, 14251
5356, 14043, 14082, 14083, 14044, 14331, 14332, 14333, 14253
5357, 14044, 14083, 14084, 14045, 14333, 14334, 14335, 14255
5358, 14045, 14084, 14085, 14046, 14335, 14336, 14337, 14257
5359, 14046, 14085, 14086, 14047, 14337, 14338, 14339, 14259
5360, 14047, 14086, 14087, 14048, 14339, 14340, 14341, 14261
5361, 14048, 14087, 14088, 14049, 14341, 14342, 14343, 14263
5362, 14049, 14088, 14089, 14050, 14343, 14344, 14345, 14265
5363, 14050, 14089, 14090, 14051, 14345, 14346, 14347, 14267
5364, 14051, 14090, 14091, 14052, 14347, 14348, 14349, 14269
5365, 14052, 14091, 14092, 14053, 14349, 14350, 14351, 14271
5366, 14053, 14092, 14093, 14054, 14351, 14352, 14353, 14273
5367, 14054, 14093, 14094, 14055, 14353, 14354, 14355, 14275
5368, 14055, 14094, 14095, 14056, 14355, 14356, 14357, 14277
5369, 14056, 14095, 14096, 14057, 14357, 14358, 14359, 14279
5370, 14057, 14096, 14097, 14058, 14359, 14360, 14361, 14281
5371, 14058, 14097, 14098, 14059, 14361, 14362, 14363, 14283
5372, 14059, 14098, 14099, 14060, 14363, 14364, 14365, 14285
5373, 14060, 14099, 14100, 14061, 14365, 14366, 14367, 14287
5374, 14061, 14100, 14101, 14062, 14367, 14368, 14369, 14289
5375, 14062, 14101, 14102, 14063, 14369, 14370, 14371, 14291
5376, 14063, 14102, 14103, 14064, 14371, 14372, 14373, 14293
5377, 14064, 14103, 14104, 14065, 14373, 14374, 14375, 14295
5378, 14065, 14104, 14105, 14066, 14375, 14376, 14377, 14297
5379, 14066, 14105, 14106, 14067, 14377, 14378, 14379, 14299
5380, 14067, 14106, 14107, 14068, 14379, 14380, 14381, 14301
5381, 14068, 14107, 14108, 14069, 14381, 14382, 14383, 14303
5382, 14069, 14108, 1328, 1327, 14383, 14384, 1332, 14305
5383, 1319, 1320, 14109, 14070, 1324, 14385, 14386, 14306
5384, 14070, 14109, 14110, 14071, 14386, 14387, 14388, 14308
5385, 14071, 14110, 14111, 14072, 14388, 14389, 14390, 14310
5386, 14072, 14111, 14112, 14073, 14390, 14391, 14392, 14312
5387, 14073, 14112, 14113, 14074, 14392, 14393, 14394, 14314
5388, 14074, 14113, 14114, 14075, 14394, 14395, 14396, 14316
5389, 14075, 14114, 14115, 14076, 14396, 14397, 14398, 14318
5390, 14076, 14115, 14116, 14077, 14398, 14399, 14400, 14320
5391, 14077, 14116, 14117, 14078, 14400, 14401, 14402, 14322
5392, 14078, 14117, 14118, 14079, 14402, 14403, 14404, 14324
5393, 14079, 14118, 14119, 14080, 14404, 14405, 14406, 14326
5394, 14080, 14119, 14120, 14081, 14406, 14407, 14408, 14328
5395, 14081, 14120, 14121, 14082, 14408, 14409, 14410, 14330
5396, 14082, 14121, 14122, 14083, 14410, 14411, 14412, 14332
5397, 14083, 14122, 14123, 14084, 14412, 14413, 14414, 14334
5398, 14084, 14123, 14124, 14085, 14414, 14415, 14416, 14336
5399, 14085, 14124, 14125, 14086, 14416, 14417, 14418, 14338
5400, 14086, 14125, 14126, 14087, 14418, 14419, 14420, 14340
5401, 14087, 14126, 14127, 14088, 14420, 14421, 14422, 14342
5402, 14088, 14127, 14128, 14089, 14422, 14423, 14424, 14344
5403, 14089, 14128, 14129, 14090, 14424, 14425, 14426, 14346
5404, 14090, 14129, 14130, 14091, 14426, 14427, 14428, 14348
5405, 14091, 14130, 14131, 14092, 14428, 14429, 14430, 14350
5406, 14092, 14131, 14132, 14093, 14430, 14431, 14432, 14352
5407, 14093, 14132, 14133, 14094, 14432, 14433, 14434, 14354
5408, 14094, 14133, 14134, 14095, 14434, 14435, 14436, 14356
5409, 14095, 14134, 14135, 14096, 14436, 14437, 14438, 14358
5410, 14096, 14135, 14136, 14097, 14438, 14439, 14440, 14360
5411, 14097, 14136, 14137, 14098, 14440, 14441, 14442, 14362
5412, 14098, 14137, 14138, 14099, 14442, 14443, 14444, 14364
5413, 14099, 14138, 14139, 14100, 14444, 14445, 14446, 14366
5414, 14100, 14139, 14140, 14101, 14446, 14447, 14448, 14368
5415, 14101, 14140, 14141, 14102, 14448, 14449, 14450, 14370
5416, 14102, 14141, 14142, 14103, 14450, 14451, 14452, 14372
5417, 14103, 14142, 14143, 14104, 14452, 14453, 14454, 14374
5418, 14104, 14143, 14144, 14105, 14454, 14455, 14456, 14376
5419, 14105, 14144, 14145, 14106, 14456, 14457, 14458, 14378
5420, 14106, 14145, 14146, 14107, 14458, 14459, 14460, 14380
5421, 14107, 14146, 14147, 14108, 14460, 14461, 14462, 14382
5422, 14108, 14147, 1329, 1328, 14462, 14463, 1333, 14384
5423, 1320, 27, 1335, 14109, 1325, 1374, 14464, 14385
5424, 14109, 1335, 1336, 14110, 14464, 1375, 14465, 14387
5425, 14110, 1336, 1337, 14111, 14465, 1376, 14466, 14389
5426, 14111, 1337, 1338, 14112, 14466, 1377, 14467, 14391
5427, 14112, 1338, 1339, 14113, 14467, 1378, 14468, 14393
5428, 14113, 1339, 1340, 14114, 14468, 1379, 14469, 14395
5429, 14114, 1340, 1341, 14115, 14469, 1380, 14470, 14397
5430, 14115, 1341, 1342, 14116, 14470, 1381, 14471, 14399
5431, 14116, 1342, 1343, 14117, 14471, 1382, 14472, 14401
5432, 14117, 1343, 1344, 14118, 14472, 1383, 14473, 14403
5433, 14118, 1344, 1345, 14119, 14473, 1384, 14474, 14405
5434, 14119, 1345, 1346, 14120, 14474, 1385, 14475, 14407
5435, 14120, 1346, 1347, 14121, 14475, 1386, 14476, 14409
5436, 14121, 1347, 1348, 14122, 14476, 1387, 14477, 14411
5437, 14122, 1348, 1349, 14123, 14477, 1388, 14478, 14413
5438, 14123, 1349, 1350, 14124, 14478, 1389, 14479, 14415
5439, 14124, 1350, 1351, 14125, 14479, 1390, 14480, 14417
5440, 14125, 1351, 1352, 14126, 14480, 1391, 14481, 14419
5441, 14126, 1352, 1353, 14127, 14481, 1392, 14482, 14421
5442, 14127, 1353, 1354, 14128, 14482, 1393, 14483, 14423
5443, 14128, 1354, 1355, 14129, 14483, 1394, 14484, 14425
5444, 14129, 1355, 1356, 14130, 14484, 1395, 14485, 14427
5445, 14130, 1356, 1357, 14131, 14485, 1396, 14486, 14429
5446, 14131, 1357, 1358, 14132, 14486, 1397, 14487, 14431
5447, 14132, 1358, 1359, 14133, 14487, 1398, 14488, 14433
5448, 14133, 1359, 1360, 14134, 14488, 1399, 14489, 14435
5449, 14134, 1360, 1361, 14135, 14489, 1400, 14490, 14437
5450, 14135, 1361, 1362, 14136, 14490, 1401, 14491, 14439
5451, 14136, 1362, 1363, 14137, 14491, 1402, 14492, 14441
5452, 14137, 1363, 1364, 14138, 14492, 1403, 14493, 14443
5453, 14138, 1364, 1365, 14139, 14493, 1404, 14494, 14445
5454, 14139, 1365, 1366, 14140, 14494, 1405, 14495, 14447
5455, 14140, 1366, 1367, 14141, 14495, 1406, 14496, 14449
5456, 14141, 1367, 1368, 14142, 14496, 1407, 14497, 14451
5457, 14142, 1368, 1369, 14143, 14497, 1408, 14498, 14453
5458, 14143, 1369, 1370, 14144, 14498, 1409, 14499, 14455
5459, 14144, 1370, 1371, 14145, 14499, 1410, 14500, 14457
5460, 14145, 1371, 1372, 14146, 14500, 1411, 14501, 14459
5461, 14146, 1372, 1373, 14147, 14501, 1412, 14502, 14461
5462, 14147, 1373, 28, 1329, 14502, 1413, 1334, 14463
*ELEMENT, type=CPS8, ELSET=Surface15
5463, 5, 1317, 14503, 453, 1321, 14519, 14520, 457
5464, 453, 14503, 14504, 454, 14520, 14521, 14522, 458
5465, 454, 14504, 14505, 455, 14522, 14523, 14524, 459
5466, 455, 14505, 14506, 456, 14524, 14525, 14526, 460
5467, 456, 14506, 1414, 8, 14526, 14527, 1418, 461
5468, 1317, 1318, 14507, 14503, 1322, 14528, 14529, 14519
5469, 14503, 14507, 14508, 14504, 14529, 14530, 14531, 14521
5470, 14504, 14508, 14509, 14505, 14531, 14532, 14533, 14523
5471, 14505, 14509, 14510, 14506, 14533, 14534, 14535, 14525
5472, 14506, 14510, 1415, 1414, 14535, 14536, 1419, 14527
5473, 1318, 1319, 14511, 14507, 1323, 14537, 14538, 14528
5474, 14507, 14511, 14512, 14508, 14538, 14539, 14540, 14530
5475, 14508, 14512, 14513, 14509, 14540, 14541, 14542, 14532
5476, 14509, 14513, 14514, 14510, 14542, 14543, 14544, 14534
5477, 14510, 14514, 1416, 1415, 14544, 14545, 1420, 14536
5478, 1319, 1320, 14515, 14511, 1324, 14546, 14547, 14537
5479, 14511, 14515, 14516, 14512, 14547, 14548, 14549, 14539
5480, 14512, 14516, 14517, 14513, 14549, 14550, 14551, 14541
5481, 14513, 14517, 14518, 14514, 14551, 14552, 14553, 14543
5482, 14514, 14518, 1417, 1416, 14553, 14554, 1421, 14545
5483, 1320, 27, 1423, 14515, 1325, 1427, 14555, 14546
5484, 14515, 1423, 1424, 14516, 14555, 1428, 14556, 14548
5485, 14516, 1424, 1425, 14517, 14556, 1429, 14557, 14550
5486, 14517, 1425, 1426, 14518, 14557, 1430, 14558, 14552
5487, 14518, 1426, 29, 1417, 14558, 1431, 1422, 14554
*ELEMENT, type=CPS8, ELSET=Surface16
5488, 8, 1414, 14559, 550, 1418, 14715, 14716, 589
5489, 550, 14559, 14560, 551, 14716, 14717, 14718, 590
5490, 551, 14560, 14561, 552, 14718, 14719, 14720, 591
5491, 552, 14561, 14562, 553, 14720, 14721, 14722, 592
5492, 553, 14562, 14563, 554, 14722, 14723, 14724, 593
5493, 554, 14563, 14564, 555, 14724, 14725, 14726, 594
5494, 555, 14564, 14565, 556, 14726, 14727, 14728, 595
5495, 556, 14565, 14566, 557, 14728, 14729, 14730, 596
5496, 557, 14566, 14567, 558, 14730, 14731, 14732, 597
5497, 558, 14567, 14568, 559, 14732, 14733, 14734, 598
5498, 559, 14568, 14569, 560, 14734, 14735, 14736, 599
5499, 560, 14569, 14570, 561, 14736, 14737, 14738, 600
5500, 561, 14570, 14571, 562, 14738, 14739, 14740, 601
5501, 562, 14571, 14572, 563, 14740, 14741, 14742, 602
5502, 563, 14572, 14573, 564, 14742, 14743, 14744, 603
5503, 564, 14573, 14574, 565, 14744, 14745, 14746, 604
5504, 565, 14574, 14575, 566, 14746, 14747, 14748, 605
5505, 566, 14575, 14576, 567, 14748, 14749, 14750, 606
5506, 567, 14576, 14577, 568, 14750, 14751, 14752, 607
5507, 568, 14577, 14578, 569, 14752, 14753, 14754, 608
5508, 569, 14578, 14579, 570, 14754, 14755, 14756, 609
5509, 570, 14579, 14580, 571, 14756, 14757, 14758, 610
5510, 571, 14580, 14581, 572, 14758, 14759, 14760, 611
5511, 572, 14581, 14582, 573, 14760, 14761, 14762, 612
5512, 573, 14582, 14583, 574, 14762, 14763, 14764, 613
5513, 574, 14583, 14584, 575, 14764, 14765, 14766, 614
5514, 575, 14584, 14585, 576, 14766, 14767, 14768, 615
5515, 576, 14585, 14586, 577, 14768, 14769, 14770, 616
5516, 577, 14586, 14587, 578, 14770, 14771, 14772, 617
5517, 578, 14587, 14588, 579, 14772, 14773, 14774, 618
5518, 579, 14588, 14589, 580, 14774, 14775, 14776, 619
5519, 580, 14589, 14590, 581, 14776, 14777, 14778, 620
5520, 581, 14590, 14591, 582, 14778, 14779, 14780, 621
5521, 582, 14591, 14592, 583, 14780, 14781, 14782, 622
5522, 583, 14592, 14593, 584, 14782, 14783, 14784, 623
5523, 584, 14593, 14594, 585, 14784, 14785, 14786, 624
5524, 585, 14594, 14595, 586, 14786, 14787, 14788, 625
5525, 586, 14595, 14596, 587, 14788, 14789, 14790, 626
5526, 587, 14596, 14597, 588, 14790, 14791, 14792, 627
5527, 588, 14597, 1432, 10, 14792, 14793, 1436, 628
5528, 1414, 1415, 14598, 14559, 1419, 14794, 14795, 14715
5529, 14559, 14598, 14599, 14560, 14795, 14796, 14797, 14717
5530, 14560, 14599, 14600, 14561, 14797, 14798, 14799, 14719
5531, 14561, 14600, 14601, 14562, 14799, 14800, 14801, 14721
5532, 14562, 14601, 14602, 14563, 14801, 14802, 14803, 14723
5533, 14563, 14602, 14603, 14564, 14803, 14804, 14805, 14725
5534, 14564, 14603, 14604, 14565, 14805, 14806, 14807, 14727
5535, 14565, 14604, 14605, 14566, 14807, 14808, 14809, 14729
5536, 14566, 14605, 14606, 14567, 14809, 14810, 14811, 14731
5537, 14567, 14606, 14607, 14568, 14811, 14812, 14813, 14733
5538, 14568, 14607, 14608, 14569, 14813, 14814, 14815, 14735
5539, 14569, 14608, 14609, 14570, 14815, 14816, 14817, 14737
5540, 14570, 14609, 14610, 14571, 14817, 14818, 14819, 14739
5541, 14571, 14610, 14611, 14572, 14819, 14820, 14821, 14741
5542, 14572, 14611, 14612, 14573, 14821, 14822, 14823, 14743
5543, 14573, 14612, 14613, 14574, 14823, 14824, 14825, 14745
5544, 14574, 14613, 14614, 14575, 14825, 14826, 14827, 14747
5545, 14575, 14614, 14615, 14576, 14827, 14828, 14829, 14749
5546, 14576, 14615, 14616, 14577, 14829, 14830, 14831, 14751
5547, 14577, 14616, 14617, 14578, 14831, 14832, 14833, 14753
5548, 14578, 14617, 14618, 14579, 14833, 14834, 14835, 14755
5549, 14579, 14618, 14619, 14580, 14835, 14836, 14837, 14757
5550, 14580, 14619, 14620, 14581, 14837, 14838, 14839, 14759
5551, 14581, 14620, 14621, 14582, 14839, 14840, 14841, 14761
5552, 14582, 14621, 14622, 14583, 14841, 14842, 14843, 14763
5553, 14583, 14622, 14623, 14584, 14843, 14844, 14845, 14765
5554, 14584, 14623, 14624, 14585, 14845, 14846, 14847, 14767
5555, 14585, 14624, 14625, 14586, 14847, 14848, 14849, 14769
5556, 14586, 14625, 14626, 14587, 14849, 14850, 14851, 14771
5557, 14587, 14626, 14627, 14588, 14851, 14852, 14853, 14773
5558, 14588, 14627, 14628, 14589, 14853, 14854, 14855, 14775
5559, 14589, 14628, 14629, 14590, 14855, 14856, 14857, 14777
5560, 14590, 14629, 14630, 14591, 14857, 14858, 14859, 14779
5561, 14591, 14630, 14631, 14592, 14859, 14860, 14861, 14781
5562, 14592, 14631, 14632, 14593, 14861, 14862, 14863, 14783
5563, 14593, 14632, 14633, 14594, 14863, 14864, 14865, 14785
5564, 14594, 14633, 14634, 14595, 14865, 14866, 14867, 14787
5565, 14595, 14634, 14635, 14596, 14867, 14868, 14869, 14789
5566, 14596, 14635, 14636, 14597, 14869, 14870, 14871, 14791
5567, 14597, 14636, 1433, 1432, 14871, 14872, 1437, 14793
5568, 1415, 1416, 14637, 14598, 1420, 14873, 14874, 14794
5569, 14598, 14637, 14638, 14599, 14874, 14875, 14876, 14796
5570, 14599, 14638, 14639, 14600, 14876, 14877, 14878, 14798
5571, 14600, 14639, 14640, 14601, 14878, 14879, 14880, 14800
5572, 14601, 14640, 14641, 14602, 14880, 14881, 14882, 14802
5573, 14602, 14641, 14642, 14603, 14882, 14883, 14884, 14804
5574, 14603, 14642, 14643, 14604, 14884, 14885, 14886, 14806
5575, 14604, 14643, 14644, 14605, 14886, 14887, 14888, 14808
5576, 14605, 14644, 14645, 14606, 14888, 14889, 14890, 14810
5577, 14606, 14645, 14646, 14607, 14890, 14891, 14892, 14812
5578, 14607, 14646, 14647, 14608, 14892, 14893, 14894, 14814
5579, 14608, 14647, 14648, 14609, 14894, 14895, 14896, 14816
5580, 14609, 14648, 14649, 14610, 14896, 14897, 14898, 14818
5581, 14610, 14649, 14650, 14611, 14898, 14899, 14900, 14820
5582, 14611, 14650, 14651, 14612, 14900, 14901, 14902, 14822
5583, 14612, 14651, 14652, 14613, 14902, 14903, 14904, 14824
5584, 14613, 14652, 14653, 14614, 14904, 14905, 14906, 14826
