*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_QuadQuad.inp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1.2, 0
4, 0, 1.2, 0
5, 1, 1.3, 0
6, 0, 1.3, 0
7, 1.2, 1.2, 0
8, 1.2, 1.3, 0
9, 2.2, 1.2, 0
10, 2.2, 1.3, 0
11, 1.2, 0, 0
12, 2.2, 0, 0
13, 1.2, -0.1, 0
14, 2.2, -0.1, 0
15, 0, -0.1, 0
16, 1, -0.1, 0
17, 2.3, 0, 0
18, 2.3, -0.1, 0
19, -0.1, 0, 0
20, -0.1, -0.1, 0
21, 0, -0.3, 0
22, 1, -0.3, 0
23, -0.1, -0.3, 0
24, 1.2, -0.3, 0
25, 2.2, -0.3, 0
26, 2.3, -0.3, 0
27, 1, 1.5, 0
28, 0, 1.5, 0
29, 1.2, 1.5, 0
30, 2.2, 1.5, 0
31, 0.025, 0, 0
32, 0.05, 0, 0
33, 0.075, 0, 0
34, 0.1, 0, 0
35, 0.125, 0, 0
36, 0.15, 0, 0
37, 0.175, 0, 0
38, 0.2, 0, 0
39, 0.225, 0, 0
40, 0.25, 0, 0
41, 0.275, 0, 0
42, 0.3, 0, 0
43, 0.325, 0, 0
44, 0.35, 0, 0
45, 0.375, 0, 0
46, 0.4, 0, 0
47, 0.425, 0, 0
48, 0.45, 0, 0
49, 0.475, 0, 0
50, 0.5, 0, 0
51, 0.525, 0, 0
52, 0.55, 0, 0
53, 0.575, 0, 0
54, 0.6, 0, 0
55, 0.625, 0, 0
56, 0.65, 0, 0
57, 0.675, 0, 0
58, 0.7, 0, 0
59, 0.725, 0, 0
60, 0.75, 0, 0
61, 0.775, 0, 0
62, 0.8, 0, 0
63, 0.825, 0, 0
64, 0.85, 0, 0
65, 0.875, 0, 0
66, 0.9, 0, 0
67, 0.925, 0, 0
68, 0.95, 0, 0
69, 0.975, 0, 0
70, 0.0125, 0, 0
71, 0.0375, 0, 0
72, 0.0625, 0, 0
73, 0.0875, 0, 0
74, 0.1125, 0, 0
75, 0.1375, 0, 0
76, 0.1625, 0, 0
77, 0.1875, 0, 0
78, 0.2125, 0, 0
79, 0.2375, 0, 0
80, 0.2625, 0, 0
81, 0.2875, 0, 0
82, 0.3125, 0, 0
83, 0.3375, 0, 0
84, 0.3625, 0, 0
85, 0.3875, 0, 0
86, 0.4125, 0, 0
87, 0.4375, 0, 0
88, 0.4625, 0, 0
89, 0.4875, 0, 0
90, 0.5125, 0, 0
91, 0.5375, 0, 0
92, 0.5625, 0, 0
93, 0.5875, 0, 0
94, 0.6125, 0, 0
95, 0.6375, 0, 0
96, 0.6625, 0, 0
97, 0.6875, 0, 0
98, 0.7125, 0, 0
99, 0.7375, 0, 0
100, 0.7625, 0, 0
101, 0.7875, 0, 0
102, 0.8125, 0, 0
103, 0.8375, 0, 0
104, 0.8625, 0, 0
105, 0.8875, 0, 0
106, 0.9125, 0, 0
107, 0.9375, 0, 0
108, 0.9625, 0, 0
109, 0.9875, 0, 0
110, 1, 0.03, 0
111, 1, 0.06, 0
112, 1, 0.09, 0
113, 1, 0.12, 0
114, 1, 0.15, 0
115, 1, 0.18, 0
116, 1, 0.21, 0
117, 1, 0.24, 0
118, 1, 0.27, 0
119, 1, 0.3, 0
120, 1, 0.33, 0
121, 1, 0.36, 0
122, 1, 0.39, 0
123, 1, 0.42, 0
124, 1, 0.45, 0
125, 1, 0.48, 0
126, 1, 0.51, 0
127, 1, 0.54, 0
128, 1, 0.57, 0
129, 1, 0.6, 0
130, 1, 0.63, 0
131, 1, 0.66, 0
132, 1, 0.69, 0
133, 1, 0.72, 0
134, 1, 0.75, 0
135, 1, 0.78, 0
136, 1, 0.81, 0
137, 1, 0.84, 0
138, 1, 0.87, 0
139, 1, 0.9, 0
140, 1, 0.93, 0
141, 1, 0.96, 0
142, 1, 0.99, 0
143, 1, 1.02, 0
144, 1, 1.05, 0
145, 1, 1.08, 0
146, 1, 1.11, 0
147, 1, 1.14, 0
148, 1, 1.17, 0
149, 1, 0.015, 0
150, 1, 0.045, 0
151, 1, 0.075, 0
152, 1, 0.105, 0
153, 1, 0.135, 0
154, 1, 0.165, 0
155, 1, 0.195, 0
156, 1, 0.225, 0
157, 1, 0.255, 0
158, 1, 0.285, 0
159, 1, 0.315, 0
160, 1, 0.345, 0
161, 1, 0.375, 0
162, 1, 0.405, 0
163, 1, 0.435, 0
164, 1, 0.465, 0
165, 1, 0.495, 0
166, 1, 0.525, 0
167, 1, 0.555, 0
168, 1, 0.585, 0
169, 1, 0.615, 0
170, 1, 0.645, 0
171, 1, 0.675, 0
172, 1, 0.705, 0
173, 1, 0.735, 0
174, 1, 0.765, 0
175, 1, 0.795, 0
176, 1, 0.825, 0
177, 1, 0.855, 0
178, 1, 0.885, 0
179, 1, 0.915, 0
180, 1, 0.945, 0
181, 1, 0.975, 0
182, 1, 1.005, 0
183, 1, 1.035, 0
184, 1, 1.065, 0
185, 1, 1.095, 0
186, 1, 1.125, 0
187, 1, 1.155, 0
188, 1, 1.185, 0
189, 0.975, 1.2, 0
190, 0.95, 1.2, 0
191, 0.925, 1.2, 0
192, 0.9, 1.2, 0
193, 0.875, 1.2, 0
194, 0.85, 1.2, 0
195, 0.825, 1.2, 0
196, 0.8, 1.2, 0
197, 0.775, 1.2, 0
198, 0.75, 1.2, 0
199, 0.725, 1.2, 0
200, 0.7, 1.2, 0
201, 0.675, 1.2, 0
202, 0.65, 1.2, 0
203, 0.625, 1.2, 0
204, 0.6, 1.2, 0
205, 0.575, 1.2, 0
206, 0.55, 1.2, 0
207, 0.525, 1.2, 0
208, 0.5, 1.2, 0
209, 0.475, 1.2, 0
210, 0.45, 1.2, 0
211, 0.425, 1.2, 0
212, 0.4, 1.2, 0
213, 0.375, 1.2, 0
214, 0.35, 1.2, 0
215, 0.325, 1.2, 0
216, 0.3, 1.2, 0
217, 0.275, 1.2, 0
218, 0.25, 1.2, 0
219, 0.225, 1.2, 0
220, 0.2, 1.2, 0
221, 0.175, 1.2, 0
222, 0.15, 1.2, 0
223, 0.125, 1.2, 0
224, 0.1, 1.2, 0
225, 0.075, 1.2, 0
226, 0.05, 1.2, 0
227, 0.025, 1.2, 0
228, 0.9875, 1.2, 0
229, 0.9625, 1.2, 0
230, 0.9375, 1.2, 0
231, 0.9125, 1.2, 0
232, 0.8875, 1.2, 0
233, 0.8625, 1.2, 0
234, 0.8375, 1.2, 0
235, 0.8125, 1.2, 0
236, 0.7875, 1.2, 0
237, 0.7625, 1.2, 0
238, 0.7375, 1.2, 0
239, 0.7125, 1.2, 0
240, 0.6875, 1.2, 0
241, 0.6625, 1.2, 0
242, 0.6375, 1.2, 0
243, 0.6125, 1.2, 0
244, 0.5875, 1.2, 0
245, 0.5625, 1.2, 0
246, 0.5375, 1.2, 0
247, 0.5125, 1.2, 0
248, 0.4875, 1.2, 0
249, 0.4625, 1.2, 0
250, 0.4375, 1.2, 0
251, 0.4125, 1.2, 0
252, 0.3875, 1.2, 0
253, 0.3625, 1.2, 0
254, 0.3375, 1.2, 0
255, 0.3125, 1.2, 0
256, 0.2875, 1.2, 0
257, 0.2625, 1.2, 0
258, 0.2375, 1.2, 0
259, 0.2125, 1.2, 0
260, 0.1875, 1.2, 0
261, 0.1625, 1.2, 0
262, 0.1375, 1.2, 0
263, 0.1125, 1.2, 0
264, 0.0875, 1.2, 0
265, 0.0625, 1.2, 0
266, 0.0375, 1.2, 0
267, 0.0125, 1.2, 0
268, 0, 1.17, 0
269, 0, 1.14, 0
270, 0, 1.11, 0
271, 0, 1.08, 0
272, 0, 1.05, 0
273, 0, 1.02, 0
274, 0, 0.99, 0
275, 0, 0.96, 0
276, 0, 0.93, 0
277, 0, 0.9, 0
278, 0, 0.87, 0
279, 0, 0.84, 0
280, 0, 0.81, 0
281, 0, 0.78, 0
282, 0, 0.75, 0
283, 0, 0.72, 0
284, 0, 0.69, 0
285, 0, 0.66, 0
286, 0, 0.63, 0
287, 0, 0.6, 0
288, 0, 0.57, 0
289, 0, 0.54, 0
290, 0, 0.51, 0
291, 0, 0.48, 0
292, 0, 0.45, 0
293, 0, 0.42, 0
294, 0, 0.39, 0
295, 0, 0.36, 0
296, 0, 0.33, 0
297, 0, 0.3, 0
298, 0, 0.27, 0
299, 0, 0.24, 0
300, 0, 0.21, 0
301, 0, 0.18, 0
302, 0, 0.15, 0
303, 0, 0.12, 0
304, 0, 0.09, 0
305, 0, 0.06, 0
306, 0, 0.03, 0
307, 0, 1.185, 0
308, 0, 1.155, 0
309, 0, 1.125, 0
310, 0, 1.095, 0
311, 0, 1.065, 0
312, 0, 1.035, 0
313, 0, 1.005, 0
314, 0, 0.975, 0
315, 0, 0.945, 0
316, 0, 0.915, 0
317, 0, 0.885, 0
318, 0, 0.855, 0
319, 0, 0.825, 0
320, 0, 0.795, 0
321, 0, 0.765, 0
322, 0, 0.735, 0
323, 0, 0.705, 0
324, 0, 0.675, 0
325, 0, 0.645, 0
326, 0, 0.615, 0
327, 0, 0.585, 0
328, 0, 0.555, 0
329, 0, 0.525, 0
330, 0, 0.495, 0
331, 0, 0.465, 0
332, 0, 0.435, 0
333, 0, 0.405, 0
334, 0, 0.375, 0
335, 0, 0.345, 0
336, 0, 0.315, 0
337, 0, 0.285, 0
338, 0, 0.255, 0
339, 0, 0.225, 0
340, 0, 0.195, 0
341, 0, 0.165, 0
342, 0, 0.135, 0
343, 0, 0.105, 0
344, 0, 0.075, 0
345, 0, 0.045, 0
346, 0, 0.015, 0
347, 1, 1.22, 0
348, 1, 1.24, 0
349, 1, 1.26, 0
350, 1, 1.28, 0
351, 1, 1.21, 0
352, 1, 1.23, 0
353, 1, 1.25, 0
354, 1, 1.27, 0
355, 1, 1.29, 0
356, 0, 1.22, 0
357, 0, 1.24, 0
358, 0, 1.26, 0
359, 0, 1.28, 0
360, 0, 1.21, 0
361, 0, 1.23, 0
362, 0, 1.25, 0
363, 0, 1.27, 0
364, 0, 1.29, 0
365, 0.975, 1.3, 0
366, 0.95, 1.3, 0
367, 0.925, 1.3, 0
368, 0.9, 1.3, 0
369, 0.875, 1.3, 0
370, 0.85, 1.3, 0
371, 0.825, 1.3, 0
372, 0.8, 1.3, 0
373, 0.775, 1.3, 0
374, 0.75, 1.3, 0
375, 0.725, 1.3, 0
376, 0.7, 1.3, 0
377, 0.675, 1.3, 0
378, 0.65, 1.3, 0
379, 0.625, 1.3, 0
380, 0.6, 1.3, 0
381, 0.575, 1.3, 0
382, 0.55, 1.3, 0
383, 0.525, 1.3, 0
384, 0.5, 1.3, 0
385, 0.475, 1.3, 0
386, 0.45, 1.3, 0
387, 0.425, 1.3, 0
388, 0.4, 1.3, 0
389, 0.375, 1.3, 0
390, 0.35, 1.3, 0
391, 0.325, 1.3, 0
392, 0.3, 1.3, 0
393, 0.275, 1.3, 0
394, 0.25, 1.3, 0
395, 0.225, 1.3, 0
396, 0.2, 1.3, 0
397, 0.175, 1.3, 0
398, 0.15, 1.3, 0
399, 0.125, 1.3, 0
400, 0.1, 1.3, 0
401, 0.075, 1.3, 0
402, 0.05, 1.3, 0
403, 0.025, 1.3, 0
404, 0.9875, 1.3, 0
405, 0.9625, 1.3, 0
406, 0.9375, 1.3, 0
407, 0.9125, 1.3, 0
408, 0.8875, 1.3, 0
409, 0.8625, 1.3, 0
410, 0.8375, 1.3, 0
411, 0.8125, 1.3, 0
412, 0.7875, 1.3, 0
413, 0.7625, 1.3, 0
414, 0.7375, 1.3, 0
415, 0.7125, 1.3, 0
416, 0.6875, 1.3, 0
417, 0.6625, 1.3, 0
418, 0.6375, 1.3, 0
419, 0.6125, 1.3, 0
420, 0.5875, 1.3, 0
421, 0.5625, 1.3, 0
422, 0.5375, 1.3, 0
423, 0.5125, 1.3, 0
424, 0.4875, 1.3, 0
425, 0.4625, 1.3, 0
426, 0.4375, 1.3, 0
427, 0.4125, 1.3, 0
428, 0.3875, 1.3, 0
429, 0.3625, 1.3, 0
430, 0.3375, 1.3, 0
431, 0.3125, 1.3, 0
432, 0.2875, 1.3, 0
433, 0.2625, 1.3, 0
434, 0.2375, 1.3, 0
435, 0.2125, 1.3, 0
436, 0.1875, 1.3, 0
437, 0.1625, 1.3, 0
438, 0.1375, 1.3, 0
439, 0.1125, 1.3, 0
440, 0.0875, 1.3, 0
441, 0.0625, 1.3, 0
442, 0.0375, 1.3, 0
443, 0.0125, 1.3, 0
444, 1.04, 1.2, 0
445, 1.08, 1.2, 0
446, 1.12, 1.2, 0
447, 1.16, 1.2, 0
448, 1.02, 1.2, 0
449, 1.06, 1.2, 0
450, 1.1, 1.2, 0
451, 1.14, 1.2, 0
452, 1.18, 1.2, 0
453, 1.04, 1.3, 0
454, 1.08, 1.3, 0
455, 1.12, 1.3, 0
456, 1.16, 1.3, 0
457, 1.02, 1.3, 0
458, 1.06, 1.3, 0
459, 1.1, 1.3, 0
460, 1.14, 1.3, 0
461, 1.18, 1.3, 0
462, 1.2, 1.22, 0
463, 1.2, 1.24, 0
464, 1.2, 1.26, 0
465, 1.2, 1.28, 0
466, 1.2, 1.21, 0
467, 1.2, 1.23, 0
468, 1.2, 1.25, 0
469, 1.2, 1.27, 0
470, 1.2, 1.29, 0
471, 1.225, 1.2, 0
472, 1.25, 1.2, 0
473, 1.275, 1.2, 0
474, 1.3, 1.2, 0
475, 1.325, 1.2, 0
476, 1.35, 1.2, 0
477, 1.375, 1.2, 0
478, 1.4, 1.2, 0
479, 1.425, 1.2, 0
480, 1.45, 1.2, 0
481, 1.475, 1.2, 0
482, 1.5, 1.2, 0
483, 1.525, 1.2, 0
484, 1.55, 1.2, 0
485, 1.575, 1.2, 0
486, 1.6, 1.2, 0
487, 1.625, 1.2, 0
488, 1.65, 1.2, 0
489, 1.675, 1.2, 0
490, 1.7, 1.2, 0
491, 1.725, 1.2, 0
492, 1.75, 1.2, 0
493, 1.775, 1.2, 0
494, 1.8, 1.2, 0
495, 1.825, 1.2, 0
496, 1.85, 1.2, 0
497, 1.875, 1.2, 0
498, 1.9, 1.2, 0
499, 1.925, 1.2, 0
500, 1.95, 1.2, 0
501, 1.975, 1.2, 0
502, 2, 1.2, 0
503, 2.025, 1.2, 0
504, 2.05, 1.2, 0
505, 2.075, 1.2, 0
506, 2.1, 1.2, 0
507, 2.125, 1.2, 0
508, 2.15, 1.2, 0
509, 2.175, 1.2, 0
510, 1.2125, 1.2, 0
511, 1.2375, 1.2, 0
512, 1.2625, 1.2, 0
513, 1.2875, 1.2, 0
514, 1.3125, 1.2, 0
515, 1.3375, 1.2, 0
516, 1.3625, 1.2, 0
517, 1.3875, 1.2, 0
518, 1.4125, 1.2, 0
519, 1.4375, 1.2, 0
520, 1.4625, 1.2, 0
521, 1.4875, 1.2, 0
522, 1.5125, 1.2, 0
523, 1.5375, 1.2, 0
524, 1.5625, 1.2, 0
525, 1.5875, 1.2, 0
526, 1.6125, 1.2, 0
527, 1.6375, 1.2, 0
528, 1.6625, 1.2, 0
529, 1.6875, 1.2, 0
530, 1.7125, 1.2, 0
531, 1.7375, 1.2, 0
532, 1.7625, 1.2, 0
533, 1.7875, 1.2, 0
534, 1.8125, 1.2, 0
535, 1.8375, 1.2, 0
536, 1.8625, 1.2, 0
537, 1.8875, 1.2, 0
538, 1.9125, 1.2, 0
539, 1.9375, 1.2, 0
540, 1.9625, 1.2, 0
541, 1.9875, 1.2, 0
542, 2.0125, 1.2, 0
543, 2.0375, 1.2, 0
544, 2.0625, 1.2, 0
545, 2.0875, 1.2, 0
546, 2.1125, 1.2, 0
547, 2.1375, 1.2, 0
548, 2.1625, 1.2, 0
549, 2.1875, 1.2, 0
550, 1.225, 1.3, 0
551, 1.25, 1.3, 0
552, 1.275, 1.3, 0
553, 1.3, 1.3, 0
554, 1.325, 1.3, 0
555, 1.35, 1.3, 0
556, 1.375, 1.3, 0
557, 1.4, 1.3, 0
558, 1.425, 1.3, 0
559, 1.45, 1.3, 0
560, 1.475, 1.3, 0
561, 1.5, 1.3, 0
562, 1.525, 1.3, 0
563, 1.55, 1.3, 0
564, 1.575, 1.3, 0
565, 1.6, 1.3, 0
566, 1.625, 1.3, 0
567, 1.65, 1.3, 0
568, 1.675, 1.3, 0
569, 1.7, 1.3, 0
570, 1.725, 1.3, 0
571, 1.75, 1.3, 0
572, 1.775, 1.3, 0
573, 1.8, 1.3, 0
574, 1.825, 1.3, 0
575, 1.85, 1.3, 0
576, 1.875, 1.3, 0
577, 1.9, 1.3, 0
578, 1.925, 1.3, 0
579, 1.95, 1.3, 0
580, 1.975, 1.3, 0
581, 2, 1.3, 0
582, 2.025, 1.3, 0
583, 2.05, 1.3, 0
584, 2.075, 1.3, 0
585, 2.1, 1.3, 0
586, 2.125, 1.3, 0
587, 2.15, 1.3, 0
588, 2.175, 1.3, 0
589, 1.2125, 1.3, 0
590, 1.2375, 1.3, 0
591, 1.2625, 1.3, 0
592, 1.2875, 1.3, 0
593, 1.3125, 1.3, 0
594, 1.3375, 1.3, 0
595, 1.3625, 1.3, 0
596, 1.3875, 1.3, 0
597, 1.4125, 1.3, 0
598, 1.4375, 1.3, 0
599, 1.4625, 1.3, 0
600, 1.4875, 1.3, 0
601, 1.5125, 1.3, 0
602, 1.5375, 1.3, 0
603, 1.5625, 1.3, 0
604, 1.5875, 1.3, 0
605, 1.6125, 1.3, 0
606, 1.6375, 1.3, 0
607, 1.6625, 1.3, 0
608, 1.6875, 1.3, 0
609, 1.7125, 1.3, 0
610, 1.7375, 1.3, 0
611, 1.7625, 1.3, 0
612, 1.7875, 1.3, 0
613, 1.8125, 1.3, 0
614, 1.8375, 1.3, 0
615, 1.8625, 1.3, 0
616, 1.8875, 1.3, 0
617, 1.9125, 1.3, 0
618, 1.9375, 1.3, 0
619, 1.9625, 1.3, 0
620, 1.9875, 1.3, 0
621, 2.0125, 1.3, 0
622, 2.0375, 1.3, 0
623, 2.0625, 1.3, 0
624, 2.0875, 1.3, 0
625, 2.1125, 1.3, 0
626, 2.1375, 1.3, 0
627, 2.1625, 1.3, 0
628, 2.1875, 1.3, 0
629, 2.2, 1.22, 0
630, 2.2, 1.24, 0
631, 2.2, 1.26, 0
632, 2.2, 1.28, 0
633, 2.2, 1.21, 0
634, 2.2, 1.23, 0
635, 2.2, 1.25, 0
636, 2.2, 1.27, 0
637, 2.2, 1.29, 0
638, 1.2, 1.17, 0
639, 1.2, 1.14, 0
640, 1.2, 1.11, 0
641, 1.2, 1.08, 0
642, 1.2, 1.05, 0
643, 1.2, 1.02, 0
644, 1.2, 0.99, 0
645, 1.2, 0.96, 0
646, 1.2, 0.93, 0
647, 1.2, 0.9, 0
648, 1.2, 0.87, 0
649, 1.2, 0.84, 0
650, 1.2, 0.81, 0
651, 1.2, 0.78, 0
652, 1.2, 0.75, 0
653, 1.2, 0.72, 0
654, 1.2, 0.69, 0
655, 1.2, 0.66, 0
656, 1.2, 0.63, 0
657, 1.2, 0.6, 0
658, 1.2, 0.57, 0
659, 1.2, 0.54, 0
660, 1.2, 0.51, 0
661, 1.2, 0.48, 0
662, 1.2, 0.45, 0
663, 1.2, 0.42, 0
664, 1.2, 0.39, 0
665, 1.2, 0.36, 0
666, 1.2, 0.33, 0
667, 1.2, 0.3, 0
668, 1.2, 0.27, 0
669, 1.2, 0.24, 0
670, 1.2, 0.21, 0
671, 1.2, 0.18, 0
672, 1.2, 0.15, 0
673, 1.2, 0.12, 0
674, 1.2, 0.09, 0
675, 1.2, 0.06, 0
676, 1.2, 0.03, 0
677, 1.2, 1.185, 0
678, 1.2, 1.155, 0
679, 1.2, 1.125, 0
680, 1.2, 1.095, 0
681, 1.2, 1.065, 0
682, 1.2, 1.035, 0
683, 1.2, 1.005, 0
684, 1.2, 0.975, 0
685, 1.2, 0.945, 0
686, 1.2, 0.915, 0
687, 1.2, 0.885, 0
688, 1.2, 0.855, 0
689, 1.2, 0.825, 0
690, 1.2, 0.795, 0
691, 1.2, 0.765, 0
692, 1.2, 0.735, 0
693, 1.2, 0.705, 0
694, 1.2, 0.675, 0
695, 1.2, 0.645, 0
696, 1.2, 0.615, 0
697, 1.2, 0.585, 0
698, 1.2, 0.555, 0
699, 1.2, 0.525, 0
700, 1.2, 0.495, 0
701, 1.2, 0.465, 0
702, 1.2, 0.435, 0
703, 1.2, 0.405, 0
704, 1.2, 0.375, 0
705, 1.2, 0.345, 0
706, 1.2, 0.315, 0
707, 1.2, 0.285, 0
708, 1.2, 0.255, 0
709, 1.2, 0.225, 0
710, 1.2, 0.195, 0
711, 1.2, 0.165, 0
712, 1.2, 0.135, 0
713, 1.2, 0.105, 0
714, 1.2, 0.075, 0
715, 1.2, 0.045, 0
716, 1.2, 0.015, 0
717, 2.2, 1.17, 0
718, 2.2, 1.14, 0
719, 2.2, 1.11, 0
720, 2.2, 1.08, 0
721, 2.2, 1.05, 0
722, 2.2, 1.02, 0
723, 2.2, 0.99, 0
724, 2.2, 0.96, 0
725, 2.2, 0.93, 0
726, 2.2, 0.9, 0
727, 2.2, 0.87, 0
728, 2.2, 0.84, 0
729, 2.2, 0.81, 0
730, 2.2, 0.78, 0
731, 2.2, 0.75, 0
732, 2.2, 0.72, 0
733, 2.2, 0.69, 0
734, 2.2, 0.66, 0
735, 2.2, 0.63, 0
736, 2.2, 0.6, 0
737, 2.2, 0.57, 0
738, 2.2, 0.54, 0
739, 2.2, 0.51, 0
740, 2.2, 0.48, 0
741, 2.2, 0.45, 0
742, 2.2, 0.42, 0
743, 2.2, 0.39, 0
744, 2.2, 0.36, 0
745, 2.2, 0.33, 0
746, 2.2, 0.3, 0
747, 2.2, 0.27, 0
748, 2.2, 0.24, 0
749, 2.2, 0.21, 0
750, 2.2, 0.18, 0
751, 2.2, 0.15, 0
752, 2.2, 0.12, 0
753, 2.2, 0.09, 0
754, 2.2, 0.06, 0
755, 2.2, 0.03, 0
756, 2.2, 1.185, 0
757, 2.2, 1.155, 0
758, 2.2, 1.125, 0
759, 2.2, 1.095, 0
760, 2.2, 1.065, 0
761, 2.2, 1.035, 0
762, 2.2, 1.005, 0
763, 2.2, 0.975, 0
764, 2.2, 0.945, 0
765, 2.2, 0.915, 0
766, 2.2, 0.885, 0
767, 2.2, 0.855, 0
768, 2.2, 0.825, 0
769, 2.2, 0.795, 0
770, 2.2, 0.765, 0
771, 2.2, 0.735, 0
772, 2.2, 0.705, 0
773, 2.2, 0.675, 0
774, 2.2, 0.645, 0
775, 2.2, 0.615, 0
776, 2.2, 0.585, 0
777, 2.2, 0.555, 0
778, 2.2, 0.525, 0
779, 2.2, 0.495, 0
780, 2.2, 0.465, 0
781, 2.2, 0.435, 0
782, 2.2, 0.405, 0
783, 2.2, 0.375, 0
784, 2.2, 0.345, 0
785, 2.2, 0.315, 0
786, 2.2, 0.285, 0
787, 2.2, 0.255, 0
788, 2.2, 0.225, 0
789, 2.2, 0.195, 0
790, 2.2, 0.165, 0
791, 2.2, 0.135, 0
792, 2.2, 0.105, 0
793, 2.2, 0.075, 0
794, 2.2, 0.045, 0
795, 2.2, 0.015, 0
796, 1.225, 0, 0
797, 1.25, 0, 0
798, 1.275, 0, 0
799, 1.3, 0, 0
800, 1.325, 0, 0
801, 1.35, 0, 0
802, 1.375, 0, 0
803, 1.4, 0, 0
804, 1.425, 0, 0
805, 1.45, 0, 0
806, 1.475, 0, 0
807, 1.5, 0, 0
808, 1.525, 0, 0
809, 1.55, 0, 0
810, 1.575, 0, 0
811, 1.6, 0, 0
812, 1.625, 0, 0
813, 1.65, 0, 0
814, 1.675, 0, 0
815, 1.7, 0, 0
816, 1.725, 0, 0
817, 1.75, 0, 0
818, 1.775, 0, 0
819, 1.8, 0, 0
820, 1.825, 0, 0
821, 1.85, 0, 0
822, 1.875, 0, 0
823, 1.9, 0, 0
824, 1.925, 0, 0
825, 1.95, 0, 0
826, 1.975, 0, 0
827, 2, 0, 0
828, 2.025, 0, 0
829, 2.05, 0, 0
830, 2.075, 0, 0
831, 2.1, 0, 0
832, 2.125, 0, 0
833, 2.15, 0, 0
834, 2.175, 0, 0
835, 1.2125, 0, 0
836, 1.2375, 0, 0
837, 1.2625, 0, 0
838, 1.2875, 0, 0
839, 1.3125, 0, 0
840, 1.3375, 0, 0
841, 1.3625, 0, 0
842, 1.3875, 0, 0
843, 1.4125, 0, 0
844, 1.4375, 0, 0
845, 1.4625, 0, 0
846, 1.4875, 0, 0
847, 1.5125, 0, 0
848, 1.5375, 0, 0
849, 1.5625, 0, 0
850, 1.5875, 0, 0
851, 1.6125, 0, 0
852, 1.6375, 0, 0
853, 1.6625, 0, 0
854, 1.6875, 0, 0
855, 1.7125, 0, 0
856, 1.7375, 0, 0
857, 1.7625, 0, 0
858, 1.7875, 0, 0
859, 1.8125, 0, 0
860, 1.8375, 0, 0
861, 1.8625, 0, 0
862, 1.8875, 0, 0
863, 1.9125, 0, 0
864, 1.9375, 0, 0
865, 1.9625, 0, 0
866, 1.9875, 0, 0
867, 2.0125, 0, 0
868, 2.0375, 0, 0
869, 2.0625, 0, 0
870, 2.0875, 0, 0
871, 2.1125, 0, 0
872, 2.1375, 0, 0
873, 2.1625, 0, 0
874, 2.1875, 0, 0
875, 1.2, -0.02, 0
876, 1.2, -0.04, 0
877, 1.2, -0.06, 0
878, 1.2, -0.08, 0
879, 1.2, -0.01, 0
880, 1.2, -0.03, 0
881, 1.2, -0.05, 0
882, 1.2, -0.07, 0
883, 1.2, -0.09, 0
884, 2.2, -0.02, 0
885, 2.2, -0.04, 0
886, 2.2, -0.06, 0
887, 2.2, -0.08, 0
888, 2.2, -0.01, 0
889, 2.2, -0.03, 0
890, 2.2, -0.05, 0
891, 2.2, -0.07, 0
892, 2.2, -0.09, 0
893, 1.225, -0.1, 0
894, 1.25, -0.1, 0
895, 1.275, -0.1, 0
896, 1.3, -0.1, 0
897, 1.325, -0.1, 0
898, 1.35, -0.1, 0
899, 1.375, -0.1, 0
900, 1.4, -0.1, 0
901, 1.425, -0.1, 0
902, 1.45, -0.1, 0
903, 1.475, -0.1, 0
904, 1.5, -0.1, 0
905, 1.525, -0.1, 0
906, 1.55, -0.1, 0
907, 1.575, -0.1, 0
908, 1.6, -0.1, 0
909, 1.625, -0.1, 0
910, 1.65, -0.1, 0
911, 1.675, -0.1, 0
912, 1.7, -0.1, 0
913, 1.725, -0.1, 0
914, 1.75, -0.1, 0
915, 1.775, -0.1, 0
916, 1.8, -0.1, 0
917, 1.825, -0.1, 0
918, 1.85, -0.1, 0
919, 1.875, -0.1, 0
920, 1.9, -0.1, 0
921, 1.925, -0.1, 0
922, 1.95, -0.1, 0
923, 1.975, -0.1, 0
924, 2, -0.1, 0
925, 2.025, -0.1, 0
926, 2.05, -0.1, 0
927, 2.075, -0.1, 0
928, 2.1, -0.1, 0
929, 2.125, -0.1, 0
930, 2.15, -0.1, 0
931, 2.175, -0.1, 0
932, 1.2125, -0.1, 0
933, 1.2375, -0.1, 0
934, 1.2625, -0.1, 0
935, 1.2875, -0.1, 0
936, 1.3125, -0.1, 0
937, 1.3375, -0.1, 0
938, 1.3625, -0.1, 0
939, 1.3875, -0.1, 0
940, 1.4125, -0.1, 0
941, 1.4375, -0.1, 0
942, 1.4625, -0.1, 0
943, 1.4875, -0.1, 0
944, 1.5125, -0.1, 0
945, 1.5375, -0.1, 0
946, 1.5625, -0.1, 0
947, 1.5875, -0.1, 0
948, 1.6125, -0.1, 0
949, 1.6375, -0.1, 0
950, 1.6625, -0.1, 0
951, 1.6875, -0.1, 0
952, 1.7125, -0.1, 0
953, 1.7375, -0.1, 0
954, 1.7625, -0.1, 0
955, 1.7875, -0.1, 0
956, 1.8125, -0.1, 0
957, 1.8375, -0.1, 0
958, 1.8625, -0.1, 0
959, 1.8875, -0.1, 0
960, 1.9125, -0.1, 0
961, 1.9375, -0.1, 0
962, 1.9625, -0.1, 0
963, 1.9875, -0.1, 0
964, 2.0125, -0.1, 0
965, 2.0375, -0.1, 0
966, 2.0625, -0.1, 0
967, 2.0875, -0.1, 0
968, 2.1125, -0.1, 0
969, 2.1375, -0.1, 0
970, 2.1625, -0.1, 0
971, 2.1875, -0.1, 0
972, 0, -0.02, 0
973, 0, -0.04, 0
974, 0, -0.06, 0
975, 0, -0.08, 0
976, 0, -0.01, 0
977, 0, -0.03, 0
978, 0, -0.05, 0
979, 0, -0.07, 0
980, 0, -0.09, 0
981, 1, -0.02, 0
982, 1, -0.04, 0
983, 1, -0.06, 0
984, 1, -0.08, 0
985, 1, -0.01, 0
986, 1, -0.03, 0
987, 1, -0.05, 0
988, 1, -0.07, 0
989, 1, -0.09, 0
990, 0.025, -0.1, 0
991, 0.05, -0.1, 0
992, 0.075, -0.1, 0
993, 0.1, -0.1, 0
994, 0.125, -0.1, 0
995, 0.15, -0.1, 0
996, 0.175, -0.1, 0
997, 0.2, -0.1, 0
998, 0.225, -0.1, 0
999, 0.25, -0.1, 0
1000, 0.275, -0.1, 0
1001, 0.3, -0.1, 0
1002, 0.325, -0.1, 0
1003, 0.35, -0.1, 0
1004, 0.375, -0.1, 0
1005, 0.4, -0.1, 0
1006, 0.425, -0.1, 0
1007, 0.45, -0.1, 0
1008, 0.475, -0.1, 0
1009, 0.5, -0.1, 0
1010, 0.525, -0.1, 0
1011, 0.55, -0.1, 0
1012, 0.575, -0.1, 0
1013, 0.6, -0.1, 0
1014, 0.625, -0.1, 0
1015, 0.65, -0.1, 0
1016, 0.675, -0.1, 0
1017, 0.7, -0.1, 0
1018, 0.725, -0.1, 0
1019, 0.75, -0.1, 0
1020, 0.775, -0.1, 0
1021, 0.8, -0.1, 0
1022, 0.825, -0.1, 0
1023, 0.85, -0.1, 0
1024, 0.875, -0.1, 0
1025, 0.9, -0.1, 0
1026, 0.925, -0.1, 0
1027, 0.95, -0.1, 0
1028, 0.975, -0.1, 0
1029, 0.0125, -0.1, 0
1030, 0.0375, -0.1, 0
1031, 0.0625, -0.1, 0
1032, 0.0875, -0.1, 0
1033, 0.1125, -0.1, 0
1034, 0.1375, -0.1, 0
1035, 0.1625, -0.1, 0
1036, 0.1875, -0.1, 0
1037, 0.2125, -0.1, 0
1038, 0.2375, -0.1, 0
1039, 0.2625, -0.1, 0
1040, 0.2875, -0.1, 0
1041, 0.3125, -0.1, 0
1042, 0.3375, -0.1, 0
1043, 0.3625, -0.1, 0
1044, 0.3875, -0.1, 0
1045, 0.4125, -0.1, 0
1046, 0.4375, -0.1, 0
1047, 0.4625, -0.1, 0
1048, 0.4875, -0.1, 0
1049, 0.5125, -0.1, 0
1050, 0.5375, -0.1, 0
1051, 0.5625, -0.1, 0
1052, 0.5875, -0.1, 0
1053, 0.6125, -0.1, 0
1054, 0.6375, -0.1, 0
1055, 0.6625, -0.1, 0
1056, 0.6875, -0.1, 0
1057, 0.7125, -0.1, 0
1058, 0.7375, -0.1, 0
1059, 0.7625, -0.1, 0
1060, 0.7875, -0.1, 0
1061, 0.8125, -0.1, 0
1062, 0.8375, -0.1, 0
1063, 0.8625, -0.1, 0
1064, 0.8875, -0.1, 0
1065, 0.9125, -0.1, 0
1066, 0.9375, -0.1, 0
1067, 0.9625, -0.1, 0
1068, 0.9875, -0.1, 0
1069, 2.25, 0, 0
1070, 2.225, 0, 0
1071, 2.275, 0, 0
1072, 2.25, -0.1, 0
1073, 2.225, -0.1, 0
1074, 2.275, -0.1, 0
1075, 2.3, -0.02, 0
1076, 2.3, -0.04, 0
1077, 2.3, -0.06, 0
1078, 2.3, -0.08, 0
1079, 2.3, -0.01, 0
1080, 2.3, -0.03, 0
1081, 2.3, -0.05, 0
1082, 2.3, -0.07, 0
1083, 2.3, -0.09, 0
1084, -0.05, 0, 0
1085, -0.025, 0, 0
1086, -0.075, 0, 0
1087, -0.05, -0.1, 0
1088, -0.025, -0.1, 0
1089, -0.075, -0.1, 0
1090, -0.1, -0.02, 0
1091, -0.1, -0.04, 0
1092, -0.1, -0.06, 0
1093, -0.1, -0.08, 0
1094, -0.1, -0.01, 0
1095, -0.1, -0.03, 0
1096, -0.1, -0.05, 0
1097, -0.1, -0.07, 0
1098, -0.1, -0.09, 0
1099, 0, -0.14, 0
1100, 0, -0.18, 0
1101, 0, -0.22, 0
1102, 0, -0.26, 0
1103, 0, -0.12, 0
1104, 0, -0.16, 0
1105, 0, -0.2, 0
1106, 0, -0.24, 0
1107, 0, -0.28, 0
1108, 1, -0.14, 0
1109, 1, -0.18, 0
1110, 1, -0.22, 0
1111, 1, -0.26, 0
1112, 1, -0.12, 0
1113, 1, -0.16, 0
1114, 1, -0.2, 0
1115, 1, -0.24, 0
1116, 1, -0.28, 0
1117, 0.025, -0.3, 0
1118, 0.05, -0.3, 0
1119, 0.075, -0.3, 0
1120, 0.1, -0.3, 0
1121, 0.125, -0.3, 0
1122, 0.15, -0.3, 0
1123, 0.175, -0.3, 0
1124, 0.2, -0.3, 0
1125, 0.225, -0.3, 0
1126, 0.25, -0.3, 0
1127, 0.275, -0.3, 0
1128, 0.3, -0.3, 0
1129, 0.325, -0.3, 0
1130, 0.35, -0.3, 0
1131, 0.375, -0.3, 0
1132, 0.4, -0.3, 0
1133, 0.425, -0.3, 0
1134, 0.45, -0.3, 0
1135, 0.475, -0.3, 0
1136, 0.5, -0.3, 0
1137, 0.525, -0.3, 0
1138, 0.55, -0.3, 0
1139, 0.575, -0.3, 0
1140, 0.6, -0.3, 0
1141, 0.625, -0.3, 0
1142, 0.65, -0.3, 0
1143, 0.675, -0.3, 0
1144, 0.7, -0.3, 0
1145, 0.725, -0.3, 0
1146, 0.75, -0.3, 0
1147, 0.775, -0.3, 0
1148, 0.8, -0.3, 0
1149, 0.825, -0.3, 0
1150, 0.85, -0.3, 0
1151, 0.875, -0.3, 0
1152, 0.9, -0.3, 0
1153, 0.925, -0.3, 0
1154, 0.95, -0.3, 0
1155, 0.975, -0.3, 0
1156, 0.0125, -0.3, 0
1157, 0.0375, -0.3, 0
1158, 0.0625, -0.3, 0
1159, 0.0875, -0.3, 0
1160, 0.1125, -0.3, 0
1161, 0.1375, -0.3, 0
1162, 0.1625, -0.3, 0
1163, 0.1875, -0.3, 0
1164, 0.2125, -0.3, 0
1165, 0.2375, -0.3, 0
1166, 0.2625, -0.3, 0
1167, 0.2875, -0.3, 0
1168, 0.3125, -0.3, 0
1169, 0.3375, -0.3, 0
1170, 0.3625, -0.3, 0
1171, 0.3875, -0.3, 0
1172, 0.4125, -0.3, 0
1173, 0.4375, -0.3, 0
1174, 0.4625, -0.3, 0
1175, 0.4875, -0.3, 0
1176, 0.5125, -0.3, 0
1177, 0.5375, -0.3, 0
1178, 0.5625, -0.3, 0
1179, 0.5875, -0.3, 0
1180, 0.6125, -0.3, 0
1181, 0.6375, -0.3, 0
1182, 0.6625, -0.3, 0
1183, 0.6875, -0.3, 0
1184, 0.7125, -0.3, 0
1185, 0.7375, -0.3, 0
1186, 0.7625, -0.3, 0
1187, 0.7875, -0.3, 0
1188, 0.8125, -0.3, 0
1189, 0.8375, -0.3, 0
1190, 0.8625, -0.3, 0
1191, 0.8875, -0.3, 0
1192, 0.9125, -0.3, 0
1193, 0.9375, -0.3, 0
1194, 0.9625, -0.3, 0
1195, 0.9875, -0.3, 0
1196, -0.1, -0.14, 0
1197, -0.1, -0.18, 0
1198, -0.1, -0.22, 0
1199, -0.1, -0.26, 0
1200, -0.1, -0.12, 0
1201, -0.1, -0.16, 0
1202, -0.1, -0.2, 0
1203, -0.1, -0.24, 0
1204, -0.1, -0.28, 0
1205, -0.05, -0.3, 0
1206, -0.025, -0.3, 0
1207, -0.075, -0.3, 0
1208, 1.2, -0.14, 0
1209, 1.2, -0.18, 0
1210, 1.2, -0.22, 0
1211, 1.2, -0.26, 0
1212, 1.2, -0.12, 0
1213, 1.2, -0.16, 0
1214, 1.2, -0.2, 0
1215, 1.2, -0.24, 0
1216, 1.2, -0.28, 0
1217, 2.2, -0.14, 0
1218, 2.2, -0.18, 0
1219, 2.2, -0.22, 0
1220, 2.2, -0.26, 0
1221, 2.2, -0.12, 0
1222, 2.2, -0.16, 0
1223, 2.2, -0.2, 0
1224, 2.2, -0.24, 0
1225, 2.2, -0.28, 0
1226, 1.225, -0.3, 0
1227, 1.25, -0.3, 0
1228, 1.275, -0.3, 0
1229, 1.3, -0.3, 0
1230, 1.325, -0.3, 0
1231, 1.35, -0.3, 0
1232, 1.375, -0.3, 0
1233, 1.4, -0.3, 0
1234, 1.425, -0.3, 0
1235, 1.45, -0.3, 0
1236, 1.475, -0.3, 0
1237, 1.5, -0.3, 0
1238, 1.525, -0.3, 0
1239, 1.55, -0.3, 0
1240, 1.575, -0.3, 0
1241, 1.6, -0.3, 0
1242, 1.625, -0.3, 0
1243, 1.65, -0.3, 0
1244, 1.675, -0.3, 0
1245, 1.7, -0.3, 0
1246, 1.725, -0.3, 0
1247, 1.75, -0.3, 0
1248, 1.775, -0.3, 0
1249, 1.8, -0.3, 0
1250, 1.825, -0.3, 0
1251, 1.85, -0.3, 0
1252, 1.875, -0.3, 0
1253, 1.9, -0.3, 0
1254, 1.925, -0.3, 0
1255, 1.95, -0.3, 0
1256, 1.975, -0.3, 0
1257, 2, -0.3, 0
1258, 2.025, -0.3, 0
1259, 2.05, -0.3, 0
1260, 2.075, -0.3, 0
1261, 2.1, -0.3, 0
1262, 2.125, -0.3, 0
1263, 2.15, -0.3, 0
1264, 2.175, -0.3, 0
1265, 1.2125, -0.3, 0
1266, 1.2375, -0.3, 0
1267, 1.2625, -0.3, 0
1268, 1.2875, -0.3, 0
1269, 1.3125, -0.3, 0
1270, 1.3375, -0.3, 0
1271, 1.3625, -0.3, 0
1272, 1.3875, -0.3, 0
1273, 1.4125, -0.3, 0
1274, 1.4375, -0.3, 0
1275, 1.4625, -0.3, 0
1276, 1.4875, -0.3, 0
1277, 1.5125, -0.3, 0
1278, 1.5375, -0.3, 0
1279, 1.5625, -0.3, 0
1280, 1.5875, -0.3, 0
1281, 1.6125, -0.3, 0
1282, 1.6375, -0.3, 0
1283, 1.6625, -0.3, 0
1284, 1.6875, -0.3, 0
1285, 1.7125, -0.3, 0
1286, 1.7375, -0.3, 0
1287, 1.7625, -0.3, 0
1288, 1.7875, -0.3, 0
1289, 1.8125, -0.3, 0
1290, 1.8375, -0.3, 0
1291, 1.8625, -0.3, 0
1292, 1.8875, -0.3, 0
1293, 1.9125, -0.3, 0
1294, 1.9375, -0.3, 0
1295, 1.9625, -0.3, 0
1296, 1.9875, -0.3, 0
1297, 2.0125, -0.3, 0
1298, 2.0375, -0.3, 0
1299, 2.0625, -0.3, 0
1300, 2.0875, -0.3, 0
1301, 2.1125, -0.3, 0
1302, 2.1375, -0.3, 0
1303, 2.1625, -0.3, 0
1304, 2.1875, -0.3, 0
1305, 2.3, -0.14, 0
1306, 2.3, -0.18, 0
1307, 2.3, -0.22, 0
1308, 2.3, -0.26, 0
1309, 2.3, -0.12, 0
1310, 2.3, -0.16, 0
1311, 2.3, -0.2, 0
1312, 2.3, -0.24, 0
1313, 2.3, -0.28, 0
1314, 2.25, -0.3, 0
1315, 2.225, -0.3, 0
1316, 2.275, -0.3, 0
1317, 1, 1.34, 0
1318, 1, 1.38, 0
1319, 1, 1.42, 0
1320, 1, 1.46, 0
1321, 1, 1.32, 0
1322, 1, 1.36, 0
1323, 1, 1.4, 0
1324, 1, 1.44, 0
1325, 1, 1.48, 0
1326, 0, 1.34, 0
1327, 0, 1.38, 0
1328, 0, 1.42, 0
1329, 0, 1.46, 0
1330, 0, 1.32, 0
1331, 0, 1.36, 0
1332, 0, 1.4, 0
1333, 0, 1.44, 0
1334, 0, 1.48, 0
1335, 0.975, 1.5, 0
1336, 0.95, 1.5, 0
1337, 0.925, 1.5, 0
1338, 0.9, 1.5, 0
1339, 0.875, 1.5, 0
1340, 0.85, 1.5, 0
1341, 0.825, 1.5, 0
1342, 0.8, 1.5, 0
1343, 0.775, 1.5, 0
1344, 0.75, 1.5, 0
1345, 0.725, 1.5, 0
1346, 0.7, 1.5, 0
1347, 0.675, 1.5, 0
1348, 0.65, 1.5, 0
1349, 0.625, 1.5, 0
1350, 0.6, 1.5, 0
1351, 0.575, 1.5, 0
1352, 0.55, 1.5, 0
1353, 0.525, 1.5, 0
1354, 0.5, 1.5, 0
1355, 0.475, 1.5, 0
1356, 0.45, 1.5, 0
1357, 0.425, 1.5, 0
1358, 0.4, 1.5, 0
1359, 0.375, 1.5, 0
1360, 0.35, 1.5, 0
1361, 0.325, 1.5, 0
1362, 0.3, 1.5, 0
1363, 0.275, 1.5, 0
1364, 0.25, 1.5, 0
1365, 0.225, 1.5, 0
1366, 0.2, 1.5, 0
1367, 0.175, 1.5, 0
1368, 0.15, 1.5, 0
1369, 0.125, 1.5, 0
1370, 0.1, 1.5, 0
1371, 0.075, 1.5, 0
1372, 0.05, 1.5, 0
1373, 0.025, 1.5, 0
1374, 0.9875, 1.5, 0
1375, 0.9625, 1.5, 0
1376, 0.9375, 1.5, 0
1377, 0.9125, 1.5, 0
1378, 0.8875, 1.5, 0
1379, 0.8625, 1.5, 0
1380, 0.8375, 1.5, 0
1381, 0.8125, 1.5, 0
1382, 0.7875, 1.5, 0
1383, 0.7625, 1.5, 0
1384, 0.7375, 1.5, 0
1385, 0.7125, 1.5, 0
1386, 0.6875, 1.5, 0
1387, 0.6625, 1.5, 0
1388, 0.6375, 1.5, 0
1389, 0.6125, 1.5, 0
1390, 0.5875, 1.5, 0
1391, 0.5625, 1.5, 0
1392, 0.5375, 1.5, 0
1393, 0.5125, 1.5, 0
1394, 0.4875, 1.5, 0
1395, 0.4625, 1.5, 0
1396, 0.4375, 1.5, 0
1397, 0.4125, 1.5, 0
1398, 0.3875, 1.5, 0
1399, 0.3625, 1.5, 0
1400, 0.3375, 1.5, 0
1401, 0.3125, 1.5, 0
1402, 0.2875, 1.5, 0
1403, 0.2625, 1.5, 0
1404, 0.2375, 1.5, 0
1405, 0.2125, 1.5, 0
1406, 0.1875, 1.5, 0
1407, 0.1625, 1.5, 0
1408, 0.1375, 1.5, 0
1409, 0.1125, 1.5, 0
1410, 0.0875, 1.5, 0
1411, 0.0625, 1.5, 0
1412, 0.0375, 1.5, 0
1413, 0.0125, 1.5, 0
1414, 1.2, 1.34, 0
1415, 1.2, 1.38, 0
1416, 1.2, 1.42, 0
1417, 1.2, 1.46, 0
1418, 1.2, 1.32, 0
1419, 1.2, 1.36, 0
1420, 1.2, 1.4, 0
1421, 1.2, 1.44, 0
1422, 1.2, 1.48, 0
1423, 1.04, 1.5, 0
1424, 1.08, 1.5, 0
1425, 1.12, 1.5, 0
1426, 1.16, 1.5, 0
1427, 1.02, 1.5, 0
1428, 1.06, 1.5, 0
1429, 1.1, 1.5, 0
1430, 1.14, 1.5, 0
1431, 1.18, 1.5, 0
1432, 2.2, 1.34, 0
1433, 2.2, 1.38, 0
1434, 2.2, 1.42, 0
1435, 2.2, 1.46, 0
1436, 2.2, 1.32, 0
1437, 2.2, 1.36, 0
1438, 2.2, 1.4, 0
1439, 2.2, 1.44, 0
1440, 2.2, 1.48, 0
1441, 1.225, 1.5, 0
1442, 1.25, 1.5, 0
1443, 1.275, 1.5, 0
1444, 1.3, 1.5, 0
1445, 1.325, 1.5, 0
1446, 1.35, 1.5, 0
1447, 1.375, 1.5, 0
1448, 1.4, 1.5, 0
1449, 1.425, 1.5, 0
1450, 1.45, 1.5, 0
1451, 1.475, 1.5, 0
1452, 1.5, 1.5, 0
1453, 1.525, 1.5, 0
1454, 1.55, 1.5, 0
1455, 1.575, 1.5, 0
1456, 1.6, 1.5, 0
1457, 1.625, 1.5, 0
1458, 1.65, 1.5, 0
1459, 1.675, 1.5, 0
1460, 1.7, 1.5, 0
1461, 1.725, 1.5, 0
1462, 1.75, 1.5, 0
1463, 1.775, 1.5, 0
1464, 1.8, 1.5, 0
1465, 1.825, 1.5, 0
1466, 1.85, 1.5, 0
1467, 1.875, 1.5, 0
1468, 1.9, 1.5, 0
1469, 1.925, 1.5, 0
1470, 1.95, 1.5, 0
1471, 1.975, 1.5, 0
1472, 2, 1.5, 0
1473, 2.025, 1.5, 0
1474, 2.05, 1.5, 0
1475, 2.075, 1.5, 0
1476, 2.1, 1.5, 0
1477, 2.125, 1.5, 0
1478, 2.15, 1.5, 0
1479, 2.175, 1.5, 0
1480, 1.2125, 1.5, 0
1481, 1.2375, 1.5, 0
1482, 1.2625, 1.5, 0
1483, 1.2875, 1.5, 0
1484, 1.3125, 1.5, 0
1485, 1.3375, 1.5, 0
1486, 1.3625, 1.5, 0
1487, 1.3875, 1.5, 0
1488, 1.4125, 1.5, 0
1489, 1.4375, 1.5, 0
1490, 1.4625, 1.5, 0
1491, 1.4875, 1.5, 0
1492, 1.5125, 1.5, 0
1493, 1.5375, 1.5, 0
1494, 1.5625, 1.5, 0
1495, 1.5875, 1.5, 0
1496, 1.6125, 1.5, 0
1497, 1.6375, 1.5, 0
1498, 1.6625, 1.5, 0
1499, 1.6875, 1.5, 0
1500, 1.7125, 1.5, 0
1501, 1.7375, 1.5, 0
1502, 1.7625, 1.5, 0
1503, 1.7875, 1.5, 0
1504, 1.8125, 1.5, 0
1505, 1.8375, 1.5, 0
1506, 1.8625, 1.5, 0
1507, 1.8875, 1.5, 0
1508, 1.9125, 1.5, 0
1509, 1.9375, 1.5, 0
1510, 1.9625, 1.5, 0
1511, 1.9875, 1.5, 0
1512, 2.0125, 1.5, 0
1513, 2.0375, 1.5, 0
1514, 2.0625, 1.5, 0
1515, 2.0875, 1.5, 0
1516, 2.1125, 1.5, 0
1517, 2.1375, 1.5, 0
1518, 2.1625, 1.5, 0
1519, 2.1875, 1.5, 0
1520, 0.025, 0.03, 0
1521, 0.025, 0.06, 0
1522, 0.025, 0.09, 0
1523, 0.025, 0.12, 0
1524, 0.025, 0.15, 0
1525, 0.025, 0.18, 0
1526, 0.025, 0.21, 0
1527, 0.025, 0.24, 0
1528, 0.025, 0.27, 0
1529, 0.025, 0.3, 0
1530, 0.025, 0.33, 0
1531, 0.025, 0.36, 0
1532, 0.025, 0.39, 0
1533, 0.025, 0.42, 0
1534, 0.025, 0.45, 0
1535, 0.025, 0.48, 0
1536, 0.025, 0.51, 0
1537, 0.025, 0.54, 0
1538, 0.025, 0.57, 0
1539, 0.025, 0.6, 0
1540, 0.025, 0.63, 0
1541, 0.025, 0.66, 0
1542, 0.025, 0.69, 0
1543, 0.025, 0.72, 0
1544, 0.025, 0.75, 0
1545, 0.025, 0.78, 0
1546, 0.025, 0.81, 0
1547, 0.025, 0.84, 0
1548, 0.025, 0.87, 0
1549, 0.025, 0.9, 0
1550, 0.025, 0.93, 0
1551, 0.025, 0.96, 0
1552, 0.025, 0.99, 0
1553, 0.025, 1.02, 0
1554, 0.025, 1.05, 0
1555, 0.025, 1.08, 0
1556, 0.025, 1.11, 0
1557, 0.025, 1.14, 0
1558, 0.025, 1.17, 0
1559, 0.05, 0.03, 0
1560, 0.05, 0.06, 0
1561, 0.05, 0.09, 0
1562, 0.05, 0.12, 0
1563, 0.05, 0.15, 0
1564, 0.05, 0.18, 0
1565, 0.05, 0.21, 0
1566, 0.05, 0.24, 0
1567, 0.05, 0.27, 0
1568, 0.05, 0.3, 0
1569, 0.05, 0.33, 0
1570, 0.05, 0.36, 0
1571, 0.05, 0.39, 0
1572, 0.05, 0.42, 0
1573, 0.05, 0.45, 0
1574, 0.05, 0.48, 0
1575, 0.05, 0.51, 0
1576, 0.05, 0.54, 0
1577, 0.05, 0.57, 0
1578, 0.05, 0.6, 0
1579, 0.05, 0.63, 0
1580, 0.05, 0.66, 0
1581, 0.05, 0.69, 0
1582, 0.05, 0.72, 0
1583, 0.05, 0.75, 0
1584, 0.05, 0.78, 0
1585, 0.05, 0.81, 0
1586, 0.05, 0.84, 0
1587, 0.05, 0.87, 0
1588, 0.05, 0.9, 0
1589, 0.05, 0.93, 0
1590, 0.05, 0.96, 0
1591, 0.05, 0.99, 0
1592, 0.05, 1.02, 0
1593, 0.05, 1.05, 0
1594, 0.05, 1.08, 0
1595, 0.05, 1.11, 0
1596, 0.05, 1.14, 0
1597, 0.05, 1.17, 0
1598, 0.075, 0.03, 0
1599, 0.075, 0.06, 0
1600, 0.075, 0.09, 0
1601, 0.075, 0.12, 0
1602, 0.075, 0.15, 0
1603, 0.075, 0.18, 0
1604, 0.075, 0.21, 0
1605, 0.075, 0.24, 0
1606, 0.075, 0.27, 0
1607, 0.075, 0.3, 0
1608, 0.075, 0.33, 0
1609, 0.075, 0.36, 0
1610, 0.075, 0.39, 0
1611, 0.075, 0.42, 0
1612, 0.075, 0.45, 0
1613, 0.075, 0.48, 0
1614, 0.075, 0.51, 0
1615, 0.075, 0.54, 0
1616, 0.075, 0.57, 0
1617, 0.075, 0.6, 0
1618, 0.075, 0.63, 0
1619, 0.075, 0.66, 0
1620, 0.075, 0.69, 0
1621, 0.075, 0.72, 0
1622, 0.075, 0.75, 0
1623, 0.075, 0.78, 0
1624, 0.075, 0.81, 0
1625, 0.075, 0.84, 0
1626, 0.075, 0.87, 0
1627, 0.075, 0.9, 0
1628, 0.075, 0.93, 0
1629, 0.075, 0.96, 0
1630, 0.075, 0.99, 0
1631, 0.075, 1.02, 0
1632, 0.075, 1.05, 0
1633, 0.075, 1.08, 0
1634, 0.075, 1.11, 0
1635, 0.075, 1.14, 0
1636, 0.075, 1.17, 0
1637, 0.1, 0.03, 0
1638, 0.1, 0.06, 0
1639, 0.1, 0.09, 0
1640, 0.1, 0.12, 0
1641, 0.1, 0.15, 0
1642, 0.1, 0.18, 0
1643, 0.1, 0.21, 0
1644, 0.1, 0.24, 0
1645, 0.1, 0.27, 0
1646, 0.1, 0.3, 0
1647, 0.1, 0.33, 0
1648, 0.1, 0.36, 0
1649, 0.1, 0.39, 0
1650, 0.1, 0.42, 0
1651, 0.1, 0.45, 0
1652, 0.1, 0.48, 0
1653, 0.1, 0.51, 0
1654, 0.1, 0.54, 0
1655, 0.1, 0.57, 0
1656, 0.1, 0.6, 0
1657, 0.1, 0.63, 0
1658, 0.1, 0.66, 0
1659, 0.1, 0.69, 0
1660, 0.1, 0.72, 0
1661, 0.1, 0.75, 0
1662, 0.1, 0.78, 0
1663, 0.1, 0.81, 0
1664, 0.1, 0.84, 0
1665, 0.1, 0.87, 0
1666, 0.1, 0.9, 0
1667, 0.1, 0.93, 0
1668, 0.1, 0.96, 0
1669, 0.1, 0.99, 0
1670, 0.1, 1.02, 0
1671, 0.1, 1.05, 0
1672, 0.1, 1.08, 0
1673, 0.1, 1.11, 0
1674, 0.1, 1.14, 0
1675, 0.1, 1.17, 0
1676, 0.125, 0.03, 0
1677, 0.125, 0.06, 0
1678, 0.125, 0.09, 0
1679, 0.125, 0.12, 0
1680, 0.125, 0.15, 0
1681, 0.125, 0.18, 0
1682, 0.125, 0.21, 0
1683, 0.125, 0.24, 0
1684, 0.125, 0.27, 0
1685, 0.125, 0.3, 0
1686, 0.125, 0.33, 0
1687, 0.125, 0.36, 0
1688, 0.125, 0.39, 0
1689, 0.125, 0.42, 0
1690, 0.125, 0.45, 0
1691, 0.125, 0.48, 0
1692, 0.125, 0.51, 0
1693, 0.125, 0.54, 0
1694, 0.125, 0.57, 0
1695, 0.125, 0.6, 0
1696, 0.125, 0.63, 0
1697, 0.125, 0.66, 0
1698, 0.125, 0.69, 0
1699, 0.125, 0.72, 0
1700, 0.125, 0.75, 0
1701, 0.125, 0.78, 0
1702, 0.125, 0.81, 0
1703, 0.125, 0.84, 0
1704, 0.125, 0.87, 0
1705, 0.125, 0.9, 0
1706, 0.125, 0.93, 0
1707, 0.125, 0.96, 0
1708, 0.125, 0.99, 0
1709, 0.125, 1.02, 0
1710, 0.125, 1.05, 0
1711, 0.125, 1.08, 0
1712, 0.125, 1.11, 0
1713, 0.125, 1.14, 0
1714, 0.125, 1.17, 0
1715, 0.15, 0.03, 0
1716, 0.15, 0.06, 0
1717, 0.15, 0.09, 0
1718, 0.15, 0.12, 0
1719, 0.15, 0.15, 0
1720, 0.15, 0.18, 0
1721, 0.15, 0.21, 0
1722, 0.15, 0.24, 0
1723, 0.15, 0.27, 0
1724, 0.15, 0.3, 0
1725, 0.15, 0.33, 0
1726, 0.15, 0.36, 0
1727, 0.15, 0.39, 0
1728, 0.15, 0.42, 0
1729, 0.15, 0.45, 0
1730, 0.15, 0.48, 0
1731, 0.15, 0.51, 0
1732, 0.15, 0.54, 0
1733, 0.15, 0.57, 0
1734, 0.15, 0.6, 0
1735, 0.15, 0.63, 0
1736, 0.15, 0.66, 0
1737, 0.15, 0.69, 0
1738, 0.15, 0.72, 0
1739, 0.15, 0.75, 0
1740, 0.15, 0.78, 0
1741, 0.15, 0.81, 0
1742, 0.15, 0.84, 0
1743, 0.15, 0.87, 0
1744, 0.15, 0.9, 0
1745, 0.15, 0.93, 0
1746, 0.15, 0.96, 0
1747, 0.15, 0.99, 0
1748, 0.15, 1.02, 0
1749, 0.15, 1.05, 0
1750, 0.15, 1.08, 0
1751, 0.15, 1.11, 0
1752, 0.15, 1.14, 0
1753, 0.15, 1.17, 0
1754, 0.175, 0.03, 0
1755, 0.175, 0.06, 0
1756, 0.175, 0.09, 0
1757, 0.175, 0.12, 0
1758, 0.175, 0.15, 0
1759, 0.175, 0.18, 0
1760, 0.175, 0.21, 0
1761, 0.175, 0.24, 0
1762, 0.175, 0.27, 0
1763, 0.175, 0.3, 0
1764, 0.175, 0.33, 0
1765, 0.175, 0.36, 0
1766, 0.175, 0.39, 0
1767, 0.175, 0.42, 0
1768, 0.175, 0.45, 0
1769, 0.175, 0.48, 0
1770, 0.175, 0.51, 0
1771, 0.175, 0.54, 0
1772, 0.175, 0.57, 0
1773, 0.175, 0.6, 0
1774, 0.175, 0.63, 0
1775, 0.175, 0.66, 0
1776, 0.175, 0.69, 0
1777, 0.175, 0.72, 0
1778, 0.175, 0.75, 0
1779, 0.175, 0.78, 0
1780, 0.175, 0.81, 0
1781, 0.175, 0.84, 0
1782, 0.175, 0.87, 0
1783, 0.175, 0.9, 0
1784, 0.175, 0.93, 0
1785, 0.175, 0.96, 0
1786, 0.175, 0.99, 0
1787, 0.175, 1.02, 0
1788, 0.175, 1.05, 0
1789, 0.175, 1.08, 0
1790, 0.175, 1.11, 0
1791, 0.175, 1.14, 0
1792, 0.175, 1.17, 0
1793, 0.2, 0.03, 0
1794, 0.2, 0.06, 0
1795, 0.2, 0.09, 0
1796, 0.2, 0.12, 0
1797, 0.2, 0.15, 0
1798, 0.2, 0.18, 0
1799, 0.2, 0.21, 0
1800, 0.2, 0.24, 0
1801, 0.2, 0.27, 0
1802, 0.2, 0.3, 0
1803, 0.2, 0.33, 0
1804, 0.2, 0.36, 0
1805, 0.2, 0.39, 0
1806, 0.2, 0.42, 0
1807, 0.2, 0.45, 0
1808, 0.2, 0.48, 0
1809, 0.2, 0.51, 0
1810, 0.2, 0.54, 0
1811, 0.2, 0.57, 0
1812, 0.2, 0.6, 0
1813, 0.2, 0.63, 0
1814, 0.2, 0.66, 0
1815, 0.2, 0.69, 0
1816, 0.2, 0.72, 0
1817, 0.2, 0.75, 0
1818, 0.2, 0.78, 0
1819, 0.2, 0.81, 0
1820, 0.2, 0.84, 0
1821, 0.2, 0.87, 0
1822, 0.2, 0.9, 0
1823, 0.2, 0.93, 0
1824, 0.2, 0.96, 0
1825, 0.2, 0.99, 0
1826, 0.2, 1.02, 0
1827, 0.2, 1.05, 0
1828, 0.2, 1.08, 0
1829, 0.2, 1.11, 0
1830, 0.2, 1.14, 0
1831, 0.2, 1.17, 0
1832, 0.225, 0.03, 0
1833, 0.225, 0.06, 0
1834, 0.225, 0.09, 0
1835, 0.225, 0.12, 0
1836, 0.225, 0.15, 0
1837, 0.225, 0.18, 0
1838, 0.225, 0.21, 0
1839, 0.225, 0.24, 0
1840, 0.225, 0.27, 0
1841, 0.225, 0.3, 0
1842, 0.225, 0.33, 0
1843, 0.225, 0.36, 0
1844, 0.225, 0.39, 0
1845, 0.225, 0.42, 0
1846, 0.225, 0.45, 0
1847, 0.225, 0.48, 0
1848, 0.225, 0.51, 0
1849, 0.225, 0.54, 0
1850, 0.225, 0.57, 0
1851, 0.225, 0.6, 0
1852, 0.225, 0.63, 0
1853, 0.225, 0.66, 0
1854, 0.225, 0.69, 0
1855, 0.225, 0.72, 0
1856, 0.225, 0.75, 0
1857, 0.225, 0.78, 0
1858, 0.225, 0.81, 0
1859, 0.225, 0.84, 0
1860, 0.225, 0.87, 0
1861, 0.225, 0.9, 0
1862, 0.225, 0.93, 0
1863, 0.225, 0.96, 0
1864, 0.225, 0.99, 0
1865, 0.225, 1.02, 0
1866, 0.225, 1.05, 0
1867, 0.225, 1.08, 0
1868, 0.225, 1.11, 0
1869, 0.225, 1.14, 0
1870, 0.225, 1.17, 0
1871, 0.25, 0.03, 0
1872, 0.25, 0.06, 0
1873, 0.25, 0.09, 0
1874, 0.25, 0.12, 0
1875, 0.25, 0.15, 0
1876, 0.25, 0.18, 0
1877, 0.25, 0.21, 0
1878, 0.25, 0.24, 0
1879, 0.25, 0.27, 0
1880, 0.25, 0.3, 0
1881, 0.25, 0.33, 0
1882, 0.25, 0.36, 0
1883, 0.25, 0.39, 0
1884, 0.25, 0.42, 0
1885, 0.25, 0.45, 0
1886, 0.25, 0.48, 0
1887, 0.25, 0.51, 0
1888, 0.25, 0.54, 0
1889, 0.25, 0.57, 0
1890, 0.25, 0.6, 0
1891, 0.25, 0.63, 0
1892, 0.25, 0.66, 0
1893, 0.25, 0.69, 0
1894, 0.25, 0.72, 0
1895, 0.25, 0.75, 0
1896, 0.25, 0.78, 0
1897, 0.25, 0.81, 0
1898, 0.25, 0.84, 0
1899, 0.25, 0.87, 0
1900, 0.25, 0.9, 0
1901, 0.25, 0.93, 0
1902, 0.25, 0.96, 0
1903, 0.25, 0.99, 0
1904, 0.25, 1.02, 0
1905, 0.25, 1.05, 0
1906, 0.25, 1.08, 0
1907, 0.25, 1.11, 0
1908, 0.25, 1.14, 0
1909, 0.25, 1.17, 0
1910, 0.275, 0.03, 0
1911, 0.275, 0.06, 0
1912, 0.275, 0.09, 0
1913, 0.275, 0.12, 0
1914, 0.275, 0.15, 0
1915, 0.275, 0.18, 0
1916, 0.275, 0.21, 0
1917, 0.275, 0.24, 0
1918, 0.275, 0.27, 0
1919, 0.275, 0.3, 0
1920, 0.275, 0.33, 0
1921, 0.275, 0.36, 0
1922, 0.275, 0.39, 0
1923, 0.275, 0.42, 0
1924, 0.275, 0.45, 0
1925, 0.275, 0.48, 0
1926, 0.275, 0.51, 0
1927, 0.275, 0.54, 0
1928, 0.275, 0.57, 0
1929, 0.275, 0.6, 0
1930, 0.275, 0.63, 0
1931, 0.275, 0.66, 0
1932, 0.275, 0.69, 0
1933, 0.275, 0.72, 0
1934, 0.275, 0.75, 0
1935, 0.275, 0.78, 0
1936, 0.275, 0.81, 0
1937, 0.275, 0.84, 0
1938, 0.275, 0.87, 0
1939, 0.275, 0.9, 0
1940, 0.275, 0.93, 0
1941, 0.275, 0.96, 0
1942, 0.275, 0.99, 0
1943, 0.275, 1.02, 0
1944, 0.275, 1.05, 0
1945, 0.275, 1.08, 0
1946, 0.275, 1.11, 0
1947, 0.275, 1.14, 0
1948, 0.275, 1.17, 0
1949, 0.3, 0.03, 0
1950, 0.3, 0.06, 0
1951, 0.3, 0.09, 0
1952, 0.3, 0.12, 0
1953, 0.3, 0.15, 0
1954, 0.3, 0.18, 0
1955, 0.3, 0.21, 0
1956, 0.3, 0.24, 0
1957, 0.3, 0.27, 0
1958, 0.3, 0.3, 0
1959, 0.3, 0.33, 0
1960, 0.3, 0.36, 0
1961, 0.3, 0.39, 0
1962, 0.3, 0.42, 0
1963, 0.3, 0.45, 0
1964, 0.3, 0.48, 0
1965, 0.3, 0.51, 0
1966, 0.3, 0.54, 0
1967, 0.3, 0.57, 0
1968, 0.3, 0.6, 0
1969, 0.3, 0.63, 0
1970, 0.3, 0.66, 0
1971, 0.3, 0.69, 0
1972, 0.3, 0.72, 0
1973, 0.3, 0.75, 0
1974, 0.3, 0.78, 0
1975, 0.3, 0.81, 0
1976, 0.3, 0.84, 0
1977, 0.3, 0.87, 0
1978, 0.3, 0.9, 0
1979, 0.3, 0.93, 0
1980, 0.3, 0.96, 0
1981, 0.3, 0.99, 0
1982, 0.3, 1.02, 0
1983, 0.3, 1.05, 0
1984, 0.3, 1.08, 0
1985, 0.3, 1.11, 0
1986, 0.3, 1.14, 0
1987, 0.3, 1.17, 0
1988, 0.325, 0.03, 0
1989, 0.325, 0.06, 0
1990, 0.325, 0.09, 0
1991, 0.325, 0.12, 0
1992, 0.325, 0.15, 0
1993, 0.325, 0.18, 0
1994, 0.325, 0.21, 0
1995, 0.325, 0.24, 0
1996, 0.325, 0.27, 0
1997, 0.325, 0.3, 0
1998, 0.325, 0.33, 0
1999, 0.325, 0.36, 0
2000, 0.325, 0.39, 0
2001, 0.325, 0.42, 0
2002, 0.325, 0.45, 0
2003, 0.325, 0.48, 0
2004, 0.325, 0.51, 0
2005, 0.325, 0.54, 0
2006, 0.325, 0.57, 0
2007, 0.325, 0.6, 0
2008, 0.325, 0.63, 0
2009, 0.325, 0.66, 0
2010, 0.325, 0.69, 0
2011, 0.325, 0.72, 0
2012, 0.325, 0.75, 0
2013, 0.325, 0.78, 0
2014, 0.325, 0.81, 0
2015, 0.325, 0.84, 0
2016, 0.325, 0.87, 0
2017, 0.325, 0.9, 0
2018, 0.325, 0.93, 0
2019, 0.325, 0.96, 0
2020, 0.325, 0.99, 0
2021, 0.325, 1.02, 0
2022, 0.325, 1.05, 0
2023, 0.325, 1.08, 0
2024, 0.325, 1.11, 0
2025, 0.325, 1.14, 0
2026, 0.325, 1.17, 0
2027, 0.35, 0.03, 0
2028, 0.35, 0.06, 0
2029, 0.35, 0.09, 0
2030, 0.35, 0.12, 0
2031, 0.35, 0.15, 0
2032, 0.35, 0.18, 0
2033, 0.35, 0.21, 0
2034, 0.35, 0.24, 0
2035, 0.35, 0.27, 0
2036, 0.35, 0.3, 0
2037, 0.35, 0.33, 0
2038, 0.35, 0.36, 0
2039, 0.35, 0.39, 0
2040, 0.35, 0.42, 0
2041, 0.35, 0.45, 0
2042, 0.35, 0.48, 0
2043, 0.35, 0.51, 0
2044, 0.35, 0.54, 0
2045, 0.35, 0.57, 0
2046, 0.35, 0.6, 0
2047, 0.35, 0.63, 0
2048, 0.35, 0.66, 0
2049, 0.35, 0.69, 0
2050, 0.35, 0.72, 0
2051, 0.35, 0.75, 0
2052, 0.35, 0.78, 0
2053, 0.35, 0.81, 0
2054, 0.35, 0.84, 0
2055, 0.35, 0.87, 0
2056, 0.35, 0.9, 0
2057, 0.35, 0.93, 0
2058, 0.35, 0.96, 0
2059, 0.35, 0.99, 0
2060, 0.35, 1.02, 0
2061, 0.35, 1.05, 0
2062, 0.35, 1.08, 0
2063, 0.35, 1.11, 0
2064, 0.35, 1.14, 0
2065, 0.35, 1.17, 0
2066, 0.375, 0.03, 0
2067, 0.375, 0.06, 0
2068, 0.375, 0.09, 0
2069, 0.375, 0.12, 0
2070, 0.375, 0.15, 0
2071, 0.375, 0.18, 0
2072, 0.375, 0.21, 0
2073, 0.375, 0.24, 0
2074, 0.375, 0.27, 0
2075, 0.375, 0.3, 0
2076, 0.375, 0.33, 0
2077, 0.375, 0.36, 0
2078, 0.375, 0.39, 0
2079, 0.375, 0.42, 0
2080, 0.375, 0.45, 0
2081, 0.375, 0.48, 0
2082, 0.375, 0.51, 0
2083, 0.375, 0.54, 0
2084, 0.375, 0.57, 0
2085, 0.375, 0.6, 0
2086, 0.375, 0.63, 0
2087, 0.375, 0.66, 0
2088, 0.375, 0.69, 0
2089, 0.375, 0.72, 0
2090, 0.375, 0.75, 0
2091, 0.375, 0.78, 0
2092, 0.375, 0.81, 0
2093, 0.375, 0.84, 0
2094, 0.375, 0.87, 0
2095, 0.375, 0.9, 0
2096, 0.375, 0.93, 0
2097, 0.375, 0.96, 0
2098, 0.375, 0.99, 0
2099, 0.375, 1.02, 0
2100, 0.375, 1.05, 0
2101, 0.375, 1.08, 0
2102, 0.375, 1.11, 0
2103, 0.375, 1.14, 0
2104, 0.375, 1.17, 0
2105, 0.4, 0.03, 0
2106, 0.4, 0.06, 0
2107, 0.4, 0.09, 0
2108, 0.4, 0.12, 0
2109, 0.4, 0.15, 0
2110, 0.4, 0.18, 0
2111, 0.4, 0.21, 0
2112, 0.4, 0.24, 0
2113, 0.4, 0.27, 0
2114, 0.4, 0.3, 0
2115, 0.4, 0.33, 0
2116, 0.4, 0.36, 0
2117, 0.4, 0.39, 0
2118, 0.4, 0.42, 0
2119, 0.4, 0.45, 0
2120, 0.4, 0.48, 0
2121, 0.4, 0.51, 0
2122, 0.4, 0.54, 0
2123, 0.4, 0.57, 0
2124, 0.4, 0.6, 0
2125, 0.4, 0.63, 0
2126, 0.4, 0.66, 0
2127, 0.4, 0.69, 0
2128, 0.4, 0.72, 0
2129, 0.4, 0.75, 0
2130, 0.4, 0.78, 0
2131, 0.4, 0.81, 0
2132, 0.4, 0.84, 0
2133, 0.4, 0.87, 0
2134, 0.4, 0.9, 0
2135, 0.4, 0.93, 0
2136, 0.4, 0.96, 0
2137, 0.4, 0.99, 0
2138, 0.4, 1.02, 0
2139, 0.4, 1.05, 0
2140, 0.4, 1.08, 0
2141, 0.4, 1.11, 0
2142, 0.4, 1.14, 0
2143, 0.4, 1.17, 0
2144, 0.425, 0.03, 0
2145, 0.425, 0.06, 0
2146, 0.425, 0.09, 0
2147, 0.425, 0.12, 0
2148, 0.425, 0.15, 0
2149, 0.425, 0.18, 0
2150, 0.425, 0.21, 0
2151, 0.425, 0.24, 0
2152, 0.425, 0.27, 0
2153, 0.425, 0.3, 0
2154, 0.425, 0.33, 0
2155, 0.425, 0.36, 0
2156, 0.425, 0.39, 0
2157, 0.425, 0.42, 0
2158, 0.425, 0.45, 0
2159, 0.425, 0.48, 0
2160, 0.425, 0.51, 0
2161, 0.425, 0.54, 0
2162, 0.425, 0.57, 0
2163, 0.425, 0.6, 0
2164, 0.425, 0.63, 0
2165, 0.425, 0.66, 0
2166, 0.425, 0.69, 0
2167, 0.425, 0.72, 0
2168, 0.425, 0.75, 0
2169, 0.425, 0.78, 0
2170, 0.425, 0.81, 0
2171, 0.425, 0.84, 0
2172, 0.425, 0.87, 0
2173, 0.425, 0.9, 0
2174, 0.425, 0.93, 0
2175, 0.425, 0.96, 0
2176, 0.425, 0.99, 0
2177, 0.425, 1.02, 0
2178, 0.425, 1.05, 0
2179, 0.425, 1.08, 0
2180, 0.425, 1.11, 0
2181, 0.425, 1.14, 0
2182, 0.425, 1.17, 0
2183, 0.45, 0.03, 0
2184, 0.45, 0.06, 0
2185, 0.45, 0.09, 0
2186, 0.45, 0.12, 0
2187, 0.45, 0.15, 0
2188, 0.45, 0.18, 0
2189, 0.45, 0.21, 0
2190, 0.45, 0.24, 0
2191, 0.45, 0.27, 0
2192, 0.45, 0.3, 0
2193, 0.45, 0.33, 0
2194, 0.45, 0.36, 0
2195, 0.45, 0.39, 0
2196, 0.45, 0.42, 0
2197, 0.45, 0.45, 0
2198, 0.45, 0.48, 0
2199, 0.45, 0.51, 0
2200, 0.45, 0.54, 0
2201, 0.45, 0.57, 0
2202, 0.45, 0.6, 0
2203, 0.45, 0.63, 0
2204, 0.45, 0.66, 0
2205, 0.45, 0.69, 0
2206, 0.45, 0.72, 0
2207, 0.45, 0.75, 0
2208, 0.45, 0.78, 0
2209, 0.45, 0.81, 0
2210, 0.45, 0.84, 0
2211, 0.45, 0.87, 0
2212, 0.45, 0.9, 0
2213, 0.45, 0.93, 0
2214, 0.45, 0.96, 0
2215, 0.45, 0.99, 0
2216, 0.45, 1.02, 0
2217, 0.45, 1.05, 0
2218, 0.45, 1.08, 0
2219, 0.45, 1.11, 0
2220, 0.45, 1.14, 0
2221, 0.45, 1.17, 0
2222, 0.475, 0.03, 0
2223, 0.475, 0.06, 0
2224, 0.475, 0.09, 0
2225, 0.475, 0.12, 0
2226, 0.475, 0.15, 0
2227, 0.475, 0.18, 0
2228, 0.475, 0.21, 0
2229, 0.475, 0.24, 0
2230, 0.475, 0.27, 0
2231, 0.475, 0.3, 0
2232, 0.475, 0.33, 0
2233, 0.475, 0.36, 0
2234, 0.475, 0.39, 0
2235, 0.475, 0.42, 0
2236, 0.475, 0.45, 0
2237, 0.475, 0.48, 0
2238, 0.475, 0.51, 0
2239, 0.475, 0.54, 0
2240, 0.475, 0.57, 0
2241, 0.475, 0.6, 0
2242, 0.475, 0.63, 0
2243, 0.475, 0.66, 0
2244, 0.475, 0.69, 0
2245, 0.475, 0.72, 0
2246, 0.475, 0.75, 0
2247, 0.475, 0.78, 0
2248, 0.475, 0.81, 0
2249, 0.475, 0.84, 0
2250, 0.475, 0.87, 0
2251, 0.475, 0.9, 0
2252, 0.475, 0.93, 0
2253, 0.475, 0.96, 0
2254, 0.475, 0.99, 0
2255, 0.475, 1.02, 0
2256, 0.475, 1.05, 0
2257, 0.475, 1.08, 0
2258, 0.475, 1.11, 0
2259, 0.475, 1.14, 0
2260, 0.475, 1.17, 0
2261, 0.5, 0.03, 0
2262, 0.5, 0.06, 0
2263, 0.5, 0.09, 0
2264, 0.5, 0.12, 0
2265, 0.5, 0.15, 0
2266, 0.5, 0.18, 0
2267, 0.5, 0.21, 0
2268, 0.5, 0.24, 0
2269, 0.5, 0.27, 0
2270, 0.5, 0.3, 0
2271, 0.5, 0.33, 0
2272, 0.5, 0.36, 0
2273, 0.5, 0.39, 0
2274, 0.5, 0.42, 0
2275, 0.5, 0.45, 0
2276, 0.5, 0.48, 0
2277, 0.5, 0.51, 0
2278, 0.5, 0.54, 0
2279, 0.5, 0.57, 0
2280, 0.5, 0.6, 0
2281, 0.5, 0.63, 0
2282, 0.5, 0.66, 0
2283, 0.5, 0.69, 0
2284, 0.5, 0.72, 0
2285, 0.5, 0.75, 0
2286, 0.5, 0.78, 0
2287, 0.5, 0.81, 0
2288, 0.5, 0.84, 0
2289, 0.5, 0.87, 0
2290, 0.5, 0.9, 0
2291, 0.5, 0.93, 0
2292, 0.5, 0.96, 0
2293, 0.5, 0.99, 0
2294, 0.5, 1.02, 0
2295, 0.5, 1.05, 0
2296, 0.5, 1.08, 0
2297, 0.5, 1.11, 0
2298, 0.5, 1.14, 0
2299, 0.5, 1.17, 0
2300, 0.525, 0.03, 0
2301, 0.525, 0.06, 0
2302, 0.525, 0.09, 0
2303, 0.525, 0.12, 0
2304, 0.525, 0.15, 0
2305, 0.525, 0.18, 0
2306, 0.525, 0.21, 0
2307, 0.525, 0.24, 0
2308, 0.525, 0.27, 0
2309, 0.525, 0.3, 0
2310, 0.525, 0.33, 0
2311, 0.525, 0.36, 0
2312, 0.525, 0.39, 0
2313, 0.525, 0.42, 0
2314, 0.525, 0.45, 0
2315, 0.525, 0.48, 0
2316, 0.525, 0.51, 0
2317, 0.525, 0.54, 0
2318, 0.525, 0.57, 0
2319, 0.525, 0.6, 0
2320, 0.525, 0.63, 0
2321, 0.525, 0.66, 0
2322, 0.525, 0.69, 0
2323, 0.525, 0.72, 0
2324, 0.525, 0.75, 0
2325, 0.525, 0.78, 0
2326, 0.525, 0.81, 0
2327, 0.525, 0.84, 0
2328, 0.525, 0.87, 0
2329, 0.525, 0.9, 0
2330, 0.525, 0.93, 0
2331, 0.525, 0.96, 0
2332, 0.525, 0.99, 0
2333, 0.525, 1.02, 0
2334, 0.525, 1.05, 0
2335, 0.525, 1.08, 0
2336, 0.525, 1.11, 0
2337, 0.525, 1.14, 0
2338, 0.525, 1.17, 0
2339, 0.55, 0.03, 0
2340, 0.55, 0.06, 0
2341, 0.55, 0.09, 0
2342, 0.55, 0.12, 0
2343, 0.55, 0.15, 0
2344, 0.55, 0.18, 0
2345, 0.55, 0.21, 0
2346, 0.55, 0.24, 0
2347, 0.55, 0.27, 0
2348, 0.55, 0.3, 0
2349, 0.55, 0.33, 0
2350, 0.55, 0.36, 0
2351, 0.55, 0.39, 0
2352, 0.55, 0.42, 0
2353, 0.55, 0.45, 0
2354, 0.55, 0.48, 0
2355, 0.55, 0.51, 0
2356, 0.55, 0.54, 0
2357, 0.55, 0.57, 0
2358, 0.55, 0.6, 0
2359, 0.55, 0.63, 0
2360, 0.55, 0.66, 0
2361, 0.55, 0.69, 0
2362, 0.55, 0.72, 0
2363, 0.55, 0.75, 0
2364, 0.55, 0.78, 0
2365, 0.55, 0.81, 0
2366, 0.55, 0.84, 0
2367, 0.55, 0.87, 0
2368, 0.55, 0.9, 0
2369, 0.55, 0.93, 0
2370, 0.55, 0.96, 0
2371, 0.55, 0.99, 0
2372, 0.55, 1.02, 0
2373, 0.55, 1.05, 0
2374, 0.55, 1.08, 0
2375, 0.55, 1.11, 0
2376, 0.55, 1.14, 0
2377, 0.55, 1.17, 0
2378, 0.575, 0.03, 0
2379, 0.575, 0.06, 0
2380, 0.575, 0.09, 0
2381, 0.575, 0.12, 0
2382, 0.575, 0.15, 0
2383, 0.575, 0.18, 0
2384, 0.575, 0.21, 0
2385, 0.575, 0.24, 0
2386, 0.575, 0.27, 0
2387, 0.575, 0.3, 0
2388, 0.575, 0.33, 0
2389, 0.575, 0.36, 0
2390, 0.575, 0.39, 0
2391, 0.575, 0.42, 0
2392, 0.575, 0.45, 0
2393, 0.575, 0.48, 0
2394, 0.575, 0.51, 0
2395, 0.575, 0.54, 0
2396, 0.575, 0.57, 0
2397, 0.575, 0.6, 0
2398, 0.575, 0.63, 0
2399, 0.575, 0.66, 0
2400, 0.575, 0.69, 0
2401, 0.575, 0.72, 0
2402, 0.575, 0.75, 0
2403, 0.575, 0.78, 0
2404, 0.575, 0.81, 0
2405, 0.575, 0.84, 0
2406, 0.575, 0.87, 0
2407, 0.575, 0.9, 0
2408, 0.575, 0.93, 0
2409, 0.575, 0.96, 0
2410, 0.575, 0.99, 0
2411, 0.575, 1.02, 0
2412, 0.575, 1.05, 0
2413, 0.575, 1.08, 0
2414, 0.575, 1.11, 0
2415, 0.575, 1.14, 0
2416, 0.575, 1.17, 0
2417, 0.6, 0.03, 0
2418, 0.6, 0.06, 0
2419, 0.6, 0.09, 0
2420, 0.6, 0.12, 0
2421, 0.6, 0.15, 0
2422, 0.6, 0.18, 0
2423, 0.6, 0.21, 0
2424, 0.6, 0.24, 0
2425, 0.6, 0.27, 0
2426, 0.6, 0.3, 0
2427, 0.6, 0.33, 0
2428, 0.6, 0.36, 0
2429, 0.6, 0.39, 0
2430, 0.6, 0.42, 0
2431, 0.6, 0.45, 0
2432, 0.6, 0.48, 0
2433, 0.6, 0.51, 0
2434, 0.6, 0.54, 0
2435, 0.6, 0.57, 0
2436, 0.6, 0.6, 0
2437, 0.6, 0.63, 0
2438, 0.6, 0.66, 0
2439, 0.6, 0.69, 0
2440, 0.6, 0.72, 0
2441, 0.6, 0.75, 0
2442, 0.6, 0.78, 0
2443, 0.6, 0.81, 0
2444, 0.6, 0.84, 0
2445, 0.6, 0.87, 0
2446, 0.6, 0.9, 0
2447, 0.6, 0.93, 0
2448, 0.6, 0.96, 0
2449, 0.6, 0.99, 0
2450, 0.6, 1.02, 0
2451, 0.6, 1.05, 0
2452, 0.6, 1.08, 0
2453, 0.6, 1.11, 0
2454, 0.6, 1.14, 0
2455, 0.6, 1.17, 0
2456, 0.625, 0.03, 0
2457, 0.625, 0.06, 0
2458, 0.625, 0.09, 0
2459, 0.625, 0.12, 0
2460, 0.625, 0.15, 0
2461, 0.625, 0.18, 0
2462, 0.625, 0.21, 0
2463, 0.625, 0.24, 0
2464, 0.625, 0.27, 0
2465, 0.625, 0.3, 0
2466, 0.625, 0.33, 0
2467, 0.625, 0.36, 0
2468, 0.625, 0.39, 0
2469, 0.625, 0.42, 0
2470, 0.625, 0.45, 0
2471, 0.625, 0.48, 0
2472, 0.625, 0.51, 0
2473, 0.625, 0.54, 0
2474, 0.625, 0.57, 0
2475, 0.625, 0.6, 0
2476, 0.625, 0.63, 0
2477, 0.625, 0.66, 0
2478, 0.625, 0.69, 0
2479, 0.625, 0.72, 0
2480, 0.625, 0.75, 0
2481, 0.625, 0.78, 0
2482, 0.625, 0.81, 0
2483, 0.625, 0.84, 0
2484, 0.625, 0.87, 0
2485, 0.625, 0.9, 0
2486, 0.625, 0.93, 0
2487, 0.625, 0.96, 0
2488, 0.625, 0.99, 0
2489, 0.625, 1.02, 0
2490, 0.625, 1.05, 0
2491, 0.625, 1.08, 0
2492, 0.625, 1.11, 0
2493, 0.625, 1.14, 0
2494, 0.625, 1.17, 0
2495, 0.65, 0.03, 0
2496, 0.65, 0.06, 0
2497, 0.65, 0.09, 0
2498, 0.65, 0.12, 0
2499, 0.65, 0.15, 0
2500, 0.65, 0.18, 0
2501, 0.65, 0.21, 0
2502, 0.65, 0.24, 0
2503, 0.65, 0.27, 0
2504, 0.65, 0.3, 0
2505, 0.65, 0.33, 0
2506, 0.65, 0.36, 0
2507, 0.65, 0.39, 0
2508, 0.65, 0.42, 0
2509, 0.65, 0.45, 0
2510, 0.65, 0.48, 0
2511, 0.65, 0.51, 0
2512, 0.65, 0.54, 0
2513, 0.65, 0.57, 0
2514, 0.65, 0.6, 0
2515, 0.65, 0.63, 0
2516, 0.65, 0.66, 0
2517, 0.65, 0.69, 0
2518, 0.65, 0.72, 0
2519, 0.65, 0.75, 0
2520, 0.65, 0.78, 0
2521, 0.65, 0.81, 0
2522, 0.65, 0.84, 0
2523, 0.65, 0.87, 0
2524, 0.65, 0.9, 0
2525, 0.65, 0.93, 0
2526, 0.65, 0.96, 0
2527, 0.65, 0.99, 0
2528, 0.65, 1.02, 0
2529, 0.65, 1.05, 0
2530, 0.65, 1.08, 0
2531, 0.65, 1.11, 0
2532, 0.65, 1.14, 0
2533, 0.65, 1.17, 0
2534, 0.675, 0.03, 0
2535, 0.675, 0.06, 0
2536, 0.675, 0.09, 0
2537, 0.675, 0.12, 0
2538, 0.675, 0.15, 0
2539, 0.675, 0.18, 0
2540, 0.675, 0.21, 0
2541, 0.675, 0.24, 0
2542, 0.675, 0.27, 0
2543, 0.675, 0.3, 0
2544, 0.675, 0.33, 0
2545, 0.675, 0.36, 0
2546, 0.675, 0.39, 0
2547, 0.675, 0.42, 0
2548, 0.675, 0.45, 0
2549, 0.675, 0.48, 0
2550, 0.675, 0.51, 0
2551, 0.675, 0.54, 0
2552, 0.675, 0.57, 0
2553, 0.675, 0.6, 0
2554, 0.675, 0.63, 0
2555, 0.675, 0.66, 0
2556, 0.675, 0.69, 0
2557, 0.675, 0.72, 0
2558, 0.675, 0.75, 0
2559, 0.675, 0.78, 0
2560, 0.675, 0.81, 0
2561, 0.675, 0.84, 0
2562, 0.675, 0.87, 0
2563, 0.675, 0.9, 0
2564, 0.675, 0.93, 0
2565, 0.675, 0.96, 0
2566, 0.675, 0.99, 0
2567, 0.675, 1.02, 0
2568, 0.675, 1.05, 0
2569, 0.675, 1.08, 0
2570, 0.675, 1.11, 0
2571, 0.675, 1.14, 0
2572, 0.675, 1.17, 0
2573, 0.7, 0.03, 0
2574, 0.7, 0.06, 0
2575, 0.7, 0.09, 0
2576, 0.7, 0.12, 0
2577, 0.7, 0.15, 0
2578, 0.7, 0.18, 0
2579, 0.7, 0.21, 0
2580, 0.7, 0.24, 0
2581, 0.7, 0.27, 0
2582, 0.7, 0.3, 0
2583, 0.7, 0.33, 0
2584, 0.7, 0.36, 0
2585, 0.7, 0.39, 0
2586, 0.7, 0.42, 0
2587, 0.7, 0.45, 0
2588, 0.7, 0.48, 0
2589, 0.7, 0.51, 0
2590, 0.7, 0.54, 0
2591, 0.7, 0.57, 0
2592, 0.7, 0.6, 0
2593, 0.7, 0.63, 0
2594, 0.7, 0.66, 0
2595, 0.7, 0.69, 0
2596, 0.7, 0.72, 0
2597, 0.7, 0.75, 0
2598, 0.7, 0.78, 0
2599, 0.7, 0.81, 0
2600, 0.7, 0.84, 0
2601, 0.7, 0.87, 0
2602, 0.7, 0.9, 0
2603, 0.7, 0.93, 0
2604, 0.7, 0.96, 0
2605, 0.7, 0.99, 0
2606, 0.7, 1.02, 0
2607, 0.7, 1.05, 0
2608, 0.7, 1.08, 0
2609, 0.7, 1.11, 0
2610, 0.7, 1.14, 0
2611, 0.7, 1.17, 0
2612, 0.725, 0.03, 0
2613, 0.725, 0.06, 0
2614, 0.725, 0.09, 0
2615, 0.725, 0.12, 0
2616, 0.725, 0.15, 0
2617, 0.725, 0.18, 0
2618, 0.725, 0.21, 0
2619, 0.725, 0.24, 0
2620, 0.725, 0.27, 0
2621, 0.725, 0.3, 0
2622, 0.725, 0.33, 0
2623, 0.725, 0.36, 0
2624, 0.725, 0.39, 0
2625, 0.725, 0.42, 0
2626, 0.725, 0.45, 0
2627, 0.725, 0.48, 0
2628, 0.725, 0.51, 0
2629, 0.725, 0.54, 0
2630, 0.725, 0.57, 0
2631, 0.725, 0.6, 0
2632, 0.725, 0.63, 0
2633, 0.725, 0.66, 0
2634, 0.725, 0.69, 0
2635, 0.725, 0.72, 0
2636, 0.725, 0.75, 0
2637, 0.725, 0.78, 0
2638, 0.725, 0.81, 0
2639, 0.725, 0.84, 0
2640, 0.725, 0.87, 0
2641, 0.725, 0.9, 0
2642, 0.725, 0.93, 0
2643, 0.725, 0.96, 0
2644, 0.725, 0.99, 0
2645, 0.725, 1.02, 0
2646, 0.725, 1.05, 0
2647, 0.725, 1.08, 0
2648, 0.725, 1.11, 0
2649, 0.725, 1.14, 0
2650, 0.725, 1.17, 0
2651, 0.75, 0.03, 0
2652, 0.75, 0.06, 0
2653, 0.75, 0.09, 0
2654, 0.75, 0.12, 0
2655, 0.75, 0.15, 0
2656, 0.75, 0.18, 0
2657, 0.75, 0.21, 0
2658, 0.75, 0.24, 0
2659, 0.75, 0.27, 0
2660, 0.75, 0.3, 0
2661, 0.75, 0.33, 0
2662, 0.75, 0.36, 0
2663, 0.75, 0.39, 0
2664, 0.75, 0.42, 0
2665, 0.75, 0.45, 0
2666, 0.75, 0.48, 0
2667, 0.75, 0.51, 0
2668, 0.75, 0.54, 0
2669, 0.75, 0.57, 0
2670, 0.75, 0.6, 0
2671, 0.75, 0.63, 0
2672, 0.75, 0.66, 0
2673, 0.75, 0.69, 0
2674, 0.75, 0.72, 0
2675, 0.75, 0.75, 0
2676, 0.75, 0.78, 0
2677, 0.75, 0.81, 0
2678, 0.75, 0.84, 0
2679, 0.75, 0.87, 0
2680, 0.75, 0.9, 0
2681, 0.75, 0.93, 0
2682, 0.75, 0.96, 0
2683, 0.75, 0.99, 0
2684, 0.75, 1.02, 0
2685, 0.75, 1.05, 0
2686, 0.75, 1.08, 0
2687, 0.75, 1.11, 0
2688, 0.75, 1.14, 0
2689, 0.75, 1.17, 0
2690, 0.775, 0.03, 0
2691, 0.775, 0.06, 0
2692, 0.775, 0.09, 0
2693, 0.775, 0.12, 0
2694, 0.775, 0.15, 0
2695, 0.775, 0.18, 0
2696, 0.775, 0.21, 0
2697, 0.775, 0.24, 0
2698, 0.775, 0.27, 0
2699, 0.775, 0.3, 0
2700, 0.775, 0.33, 0
2701, 0.775, 0.36, 0
2702, 0.775, 0.39, 0
2703, 0.775, 0.42, 0
2704, 0.775, 0.45, 0
2705, 0.775, 0.48, 0
2706, 0.775, 0.51, 0
2707, 0.775, 0.54, 0
2708, 0.775, 0.57, 0
2709, 0.775, 0.6, 0
2710, 0.775, 0.63, 0
2711, 0.775, 0.66, 0
2712, 0.775, 0.69, 0
2713, 0.775, 0.72, 0
2714, 0.775, 0.75, 0
2715, 0.775, 0.78, 0
2716, 0.775, 0.81, 0
2717, 0.775, 0.84, 0
2718, 0.775, 0.87, 0
2719, 0.775, 0.9, 0
2720, 0.775, 0.93, 0
2721, 0.775, 0.96, 0
2722, 0.775, 0.99, 0
2723, 0.775, 1.02, 0
2724, 0.775, 1.05, 0
2725, 0.775, 1.08, 0
2726, 0.775, 1.11, 0
2727, 0.775, 1.14, 0
2728, 0.775, 1.17, 0
2729, 0.8, 0.03, 0
2730, 0.8, 0.06, 0
2731, 0.8, 0.09, 0
2732, 0.8, 0.12, 0
2733, 0.8, 0.15, 0
2734, 0.8, 0.18, 0
2735, 0.8, 0.21, 0
2736, 0.8, 0.24, 0
2737, 0.8, 0.27, 0
2738, 0.8, 0.3, 0
2739, 0.8, 0.33, 0
2740, 0.8, 0.36, 0
2741, 0.8, 0.39, 0
2742, 0.8, 0.42, 0
2743, 0.8, 0.45, 0
2744, 0.8, 0.48, 0
2745, 0.8, 0.51, 0
2746, 0.8, 0.54, 0
2747, 0.8, 0.57, 0
2748, 0.8, 0.6, 0
2749, 0.8, 0.63, 0
2750, 0.8, 0.66, 0
2751, 0.8, 0.69, 0
2752, 0.8, 0.72, 0
2753, 0.8, 0.75, 0
2754, 0.8, 0.78, 0
2755, 0.8, 0.81, 0
2756, 0.8, 0.84, 0
2757, 0.8, 0.87, 0
2758, 0.8, 0.9, 0
2759, 0.8, 0.93, 0
2760, 0.8, 0.96, 0
2761, 0.8, 0.99, 0
2762, 0.8, 1.02, 0
2763, 0.8, 1.05, 0
2764, 0.8, 1.08, 0
2765, 0.8, 1.11, 0
2766, 0.8, 1.14, 0
2767, 0.8, 1.17, 0
2768, 0.825, 0.03, 0
2769, 0.825, 0.06, 0
2770, 0.825, 0.09, 0
2771, 0.825, 0.12, 0
2772, 0.825, 0.15, 0
2773, 0.825, 0.18, 0
2774, 0.825, 0.21, 0
2775, 0.825, 0.24, 0
2776, 0.825, 0.27, 0
2777, 0.825, 0.3, 0
2778, 0.825, 0.33, 0
2779, 0.825, 0.36, 0
2780, 0.825, 0.39, 0
2781, 0.825, 0.42, 0
2782, 0.825, 0.45, 0
2783, 0.825, 0.48, 0
2784, 0.825, 0.51, 0
2785, 0.825, 0.54, 0
2786, 0.825, 0.57, 0
2787, 0.825, 0.6, 0
2788, 0.825, 0.63, 0
2789, 0.825, 0.66, 0
2790, 0.825, 0.69, 0
2791, 0.825, 0.72, 0
2792, 0.825, 0.75, 0
2793, 0.825, 0.78, 0
2794, 0.825, 0.81, 0
2795, 0.825, 0.84, 0
2796, 0.825, 0.87, 0
2797, 0.825, 0.9, 0
2798, 0.825, 0.93, 0
2799, 0.825, 0.96, 0
2800, 0.825, 0.99, 0
2801, 0.825, 1.02, 0
2802, 0.825, 1.05, 0
2803, 0.825, 1.08, 0
2804, 0.825, 1.11, 0
2805, 0.825, 1.14, 0
2806, 0.825, 1.17, 0
2807, 0.85, 0.03, 0
2808, 0.85, 0.06, 0
2809, 0.85, 0.09, 0
2810, 0.85, 0.12, 0
2811, 0.85, 0.15, 0
2812, 0.85, 0.18, 0
2813, 0.85, 0.21, 0
2814, 0.85, 0.24, 0
2815, 0.85, 0.27, 0
2816, 0.85, 0.3, 0
2817, 0.85, 0.33, 0
2818, 0.85, 0.36, 0
2819, 0.85, 0.39, 0
2820, 0.85, 0.42, 0
2821, 0.85, 0.45, 0
2822, 0.85, 0.48, 0
2823, 0.85, 0.51, 0
2824, 0.85, 0.54, 0
2825, 0.85, 0.57, 0
2826, 0.85, 0.6, 0
2827, 0.85, 0.63, 0
2828, 0.85, 0.66, 0
2829, 0.85, 0.69, 0
2830, 0.85, 0.72, 0
2831, 0.85, 0.75, 0
2832, 0.85, 0.78, 0
2833, 0.85, 0.81, 0
2834, 0.85, 0.84, 0
2835, 0.85, 0.87, 0
2836, 0.85, 0.9, 0
2837, 0.85, 0.93, 0
2838, 0.85, 0.96, 0
2839, 0.85, 0.99, 0
2840, 0.85, 1.02, 0
2841, 0.85, 1.05, 0
2842, 0.85, 1.08, 0
2843, 0.85, 1.11, 0
2844, 0.85, 1.14, 0
2845, 0.85, 1.17, 0
2846, 0.875, 0.03, 0
2847, 0.875, 0.06, 0
2848, 0.875, 0.09, 0
2849, 0.875, 0.12, 0
2850, 0.875, 0.15, 0
2851, 0.875, 0.18, 0
2852, 0.875, 0.21, 0
2853, 0.875, 0.24, 0
2854, 0.875, 0.27, 0
2855, 0.875, 0.3, 0
2856, 0.875, 0.33, 0
2857, 0.875, 0.36, 0
2858, 0.875, 0.39, 0
2859, 0.875, 0.42, 0
2860, 0.875, 0.45, 0
2861, 0.875, 0.48, 0
2862, 0.875, 0.51, 0
2863, 0.875, 0.54, 0
2864, 0.875, 0.57, 0
2865, 0.875, 0.6, 0
2866, 0.875, 0.63, 0
2867, 0.875, 0.66, 0
2868, 0.875, 0.69, 0
2869, 0.875, 0.72, 0
2870, 0.875, 0.75, 0
2871, 0.875, 0.78, 0
2872, 0.875, 0.81, 0
2873, 0.875, 0.84, 0
2874, 0.875, 0.87, 0
2875, 0.875, 0.9, 0
2876, 0.875, 0.93, 0
2877, 0.875, 0.96, 0
2878, 0.875, 0.99, 0
2879, 0.875, 1.02, 0
2880, 0.875, 1.05, 0
2881, 0.875, 1.08, 0
2882, 0.875, 1.11, 0
2883, 0.875, 1.14, 0
2884, 0.875, 1.17, 0
2885, 0.9, 0.03, 0
2886, 0.9, 0.06, 0
2887, 0.9, 0.09, 0
2888, 0.9, 0.12, 0
2889, 0.9, 0.15, 0
2890, 0.9, 0.18, 0
2891, 0.9, 0.21, 0
2892, 0.9, 0.24, 0
2893, 0.9, 0.27, 0
2894, 0.9, 0.3, 0
2895, 0.9, 0.33, 0
2896, 0.9, 0.36, 0
2897, 0.9, 0.39, 0
2898, 0.9, 0.42, 0
2899, 0.9, 0.45, 0
2900, 0.9, 0.48, 0
2901, 0.9, 0.51, 0
2902, 0.9, 0.54, 0
2903, 0.9, 0.57, 0
2904, 0.9, 0.6, 0
2905, 0.9, 0.63, 0
2906, 0.9, 0.66, 0
2907, 0.9, 0.69, 0
2908, 0.9, 0.72, 0
2909, 0.9, 0.75, 0
2910, 0.9, 0.78, 0
2911, 0.9, 0.81, 0
2912, 0.9, 0.84, 0
2913, 0.9, 0.87, 0
2914, 0.9, 0.9, 0
2915, 0.9, 0.93, 0
2916, 0.9, 0.96, 0
2917, 0.9, 0.99, 0
2918, 0.9, 1.02, 0
2919, 0.9, 1.05, 0
2920, 0.9, 1.08, 0
2921, 0.9, 1.11, 0
2922, 0.9, 1.14, 0
2923, 0.9, 1.17, 0
2924, 0.925, 0.03, 0
2925, 0.925, 0.06, 0
2926, 0.925, 0.09, 0
2927, 0.925, 0.12, 0
2928, 0.925, 0.15, 0
2929, 0.925, 0.18, 0
2930, 0.925, 0.21, 0
2931, 0.925, 0.24, 0
2932, 0.925, 0.27, 0
2933, 0.925, 0.3, 0
2934, 0.925, 0.33, 0
2935, 0.925, 0.36, 0
2936, 0.925, 0.39, 0
2937, 0.925, 0.42, 0
2938, 0.925, 0.45, 0
2939, 0.925, 0.48, 0
2940, 0.925, 0.51, 0
2941, 0.925, 0.54, 0
2942, 0.925, 0.57, 0
2943, 0.925, 0.6, 0
2944, 0.925, 0.63, 0
2945, 0.925, 0.66, 0
2946, 0.925, 0.69, 0
2947, 0.925, 0.72, 0
2948, 0.925, 0.75, 0
2949, 0.925, 0.78, 0
2950, 0.925, 0.81, 0
2951, 0.925, 0.84, 0
2952, 0.925, 0.87, 0
2953, 0.925, 0.9, 0
2954, 0.925, 0.93, 0
2955, 0.925, 0.96, 0
2956, 0.925, 0.99, 0
2957, 0.925, 1.02, 0
2958, 0.925, 1.05, 0
2959, 0.925, 1.08, 0
2960, 0.925, 1.11, 0
2961, 0.925, 1.14, 0
2962, 0.925, 1.17, 0
2963, 0.95, 0.03, 0
2964, 0.95, 0.06, 0
2965, 0.95, 0.09, 0
2966, 0.95, 0.12, 0
2967, 0.95, 0.15, 0
2968, 0.95, 0.18, 0
2969, 0.95, 0.21, 0
2970, 0.95, 0.24, 0
2971, 0.95, 0.27, 0
2972, 0.95, 0.3, 0
2973, 0.95, 0.33, 0
2974, 0.95, 0.36, 0
2975, 0.95, 0.39, 0
2976, 0.95, 0.42, 0
2977, 0.95, 0.45, 0
2978, 0.95, 0.48, 0
2979, 0.95, 0.51, 0
2980, 0.95, 0.54, 0
2981, 0.95, 0.57, 0
2982, 0.95, 0.6, 0
2983, 0.95, 0.63, 0
2984, 0.95, 0.66, 0
2985, 0.95, 0.69, 0
2986, 0.95, 0.72, 0
2987, 0.95, 0.75, 0
2988, 0.95, 0.78, 0
2989, 0.95, 0.81, 0
2990, 0.95, 0.84, 0
2991, 0.95, 0.87, 0
2992, 0.95, 0.9, 0
2993, 0.95, 0.93, 0
2994, 0.95, 0.96, 0
2995, 0.95, 0.99, 0
2996, 0.95, 1.02, 0
2997, 0.95, 1.05, 0
2998, 0.95, 1.08, 0
2999, 0.95, 1.11, 0
3000, 0.95, 1.14, 0
3001, 0.95, 1.17, 0
3002, 0.975, 0.03, 0
3003, 0.975, 0.06, 0
3004, 0.975, 0.09, 0
3005, 0.975, 0.12, 0
3006, 0.975, 0.15, 0
3007, 0.975, 0.18, 0
3008, 0.975, 0.21, 0
3009, 0.975, 0.24, 0
3010, 0.975, 0.27, 0
3011, 0.975, 0.3, 0
3012, 0.975, 0.33, 0
3013, 0.975, 0.36, 0
3014, 0.975, 0.39, 0
3015, 0.975, 0.42, 0
3016, 0.975, 0.45, 0
3017, 0.975, 0.48, 0
3018, 0.975, 0.51, 0
3019, 0.975, 0.54, 0
3020, 0.975, 0.57, 0
3021, 0.975, 0.6, 0
3022, 0.975, 0.63, 0
3023, 0.975, 0.66, 0
3024, 0.975, 0.69, 0
3025, 0.975, 0.72, 0
3026, 0.975, 0.75, 0
3027, 0.975, 0.78, 0
3028, 0.975, 0.81, 0
3029, 0.975, 0.84, 0
3030, 0.975, 0.87, 0
3031, 0.975, 0.9, 0
3032, 0.975, 0.93, 0
3033, 0.975, 0.96, 0
3034, 0.975, 0.99, 0
3035, 0.975, 1.02, 0
3036, 0.975, 1.05, 0
3037, 0.975, 1.08, 0
3038, 0.975, 1.11, 0
3039, 0.975, 1.14, 0
3040, 0.975, 1.17, 0
3041, 0.025, 0.015, 0
3042, 0.0125, 0.03, 0
3043, 0.025, 0.045, 0
3044, 0.0125, 0.06, 0
3045, 0.025, 0.075, 0
3046, 0.0125, 0.09, 0
3047, 0.025, 0.105, 0
3048, 0.0125, 0.12, 0
3049, 0.025, 0.135, 0
3050, 0.0125, 0.15, 0
3051, 0.025, 0.165, 0
3052, 0.0125, 0.18, 0
3053, 0.025, 0.195, 0
3054, 0.0125, 0.21, 0
3055, 0.025, 0.225, 0
3056, 0.0125, 0.24, 0
3057, 0.025, 0.255, 0
3058, 0.0125, 0.27, 0
3059, 0.025, 0.285, 0
3060, 0.0125, 0.3, 0
3061, 0.025, 0.315, 0
3062, 0.0125, 0.33, 0
3063, 0.025, 0.345, 0
3064, 0.0125, 0.36, 0
3065, 0.025, 0.375, 0
3066, 0.0125, 0.39, 0
3067, 0.025, 0.405, 0
3068, 0.0125, 0.42, 0
3069, 0.025, 0.435, 0
3070, 0.0125, 0.45, 0
3071, 0.025, 0.465, 0
3072, 0.0125, 0.48, 0
3073, 0.025, 0.495, 0
3074, 0.0125, 0.51, 0
3075, 0.025, 0.525, 0
3076, 0.0125, 0.54, 0
3077, 0.025, 0.555, 0
3078, 0.0125, 0.57, 0
3079, 0.025, 0.585, 0
3080, 0.0125, 0.6, 0
3081, 0.025, 0.615, 0
3082, 0.0125, 0.63, 0
3083, 0.025, 0.645, 0
3084, 0.0125, 0.66, 0
3085, 0.025, 0.675, 0
3086, 0.0125, 0.69, 0
3087, 0.025, 0.705, 0
3088, 0.0125, 0.72, 0
3089, 0.025, 0.735, 0
3090, 0.0125, 0.75, 0
3091, 0.025, 0.765, 0
3092, 0.0125, 0.78, 0
3093, 0.025, 0.795, 0
3094, 0.0125, 0.81, 0
3095, 0.025, 0.825, 0
3096, 0.0125, 0.84, 0
3097, 0.025, 0.855, 0
3098, 0.0125, 0.87, 0
3099, 0.025, 0.885, 0
3100, 0.0125, 0.9, 0
3101, 0.025, 0.915, 0
3102, 0.0125, 0.93, 0
3103, 0.025, 0.945, 0
3104, 0.0125, 0.96, 0
3105, 0.025, 0.975, 0
3106, 0.0125, 0.99, 0
3107, 0.025, 1.005, 0
3108, 0.0125, 1.02, 0
3109, 0.025, 1.035, 0
3110, 0.0125, 1.05, 0
3111, 0.025, 1.065, 0
3112, 0.0125, 1.08, 0
3113, 0.025, 1.095, 0
3114, 0.0125, 1.11, 0
3115, 0.025, 1.125, 0
3116, 0.0125, 1.14, 0
3117, 0.025, 1.155, 0
3118, 0.0125, 1.17, 0
3119, 0.025, 1.185, 0
3120, 0.05, 0.015, 0
3121, 0.0375, 0.03, 0
3122, 0.05, 0.045, 0
3123, 0.0375, 0.06, 0
3124, 0.05, 0.075, 0
3125, 0.0375, 0.09, 0
3126, 0.05, 0.105, 0
3127, 0.0375, 0.12, 0
3128, 0.05, 0.135, 0
3129, 0.0375, 0.15, 0
3130, 0.05, 0.165, 0
3131, 0.0375, 0.18, 0
3132, 0.05, 0.195, 0
3133, 0.0375, 0.21, 0
3134, 0.05, 0.225, 0
3135, 0.0375, 0.24, 0
3136, 0.05, 0.255, 0
3137, 0.0375, 0.27, 0
3138, 0.05, 0.285, 0
3139, 0.0375, 0.3, 0
3140, 0.05, 0.315, 0
3141, 0.0375, 0.33, 0
3142, 0.05, 0.345, 0
3143, 0.0375, 0.36, 0
3144, 0.05, 0.375, 0
3145, 0.0375, 0.39, 0
3146, 0.05, 0.405, 0
3147, 0.0375, 0.42, 0
3148, 0.05, 0.435, 0
3149, 0.0375, 0.45, 0
3150, 0.05, 0.465, 0
3151, 0.0375, 0.48, 0
3152, 0.05, 0.495, 0
3153, 0.0375, 0.51, 0
3154, 0.05, 0.525, 0
3155, 0.0375, 0.54, 0
3156, 0.05, 0.555, 0
3157, 0.0375, 0.57, 0
3158, 0.05, 0.585, 0
3159, 0.0375, 0.6, 0
3160, 0.05, 0.615, 0
3161, 0.0375, 0.63, 0
3162, 0.05, 0.645, 0
3163, 0.0375, 0.66, 0
3164, 0.05, 0.675, 0
3165, 0.0375, 0.69, 0
3166, 0.05, 0.705, 0
3167, 0.0375, 0.72, 0
3168, 0.05, 0.735, 0
3169, 0.0375, 0.75, 0
3170, 0.05, 0.765, 0
3171, 0.0375, 0.78, 0
3172, 0.05, 0.795, 0
3173, 0.0375, 0.81, 0
3174, 0.05, 0.825, 0
3175, 0.0375, 0.84, 0
3176, 0.05, 0.855, 0
3177, 0.0375, 0.87, 0
3178, 0.05, 0.885, 0
3179, 0.0375, 0.9, 0
3180, 0.05, 0.915, 0
3181, 0.0375, 0.93, 0
3182, 0.05, 0.945, 0
3183, 0.0375, 0.96, 0
3184, 0.05, 0.975, 0
3185, 0.0375, 0.99, 0
3186, 0.05, 1.005, 0
3187, 0.0375, 1.02, 0
3188, 0.05, 1.035, 0
3189, 0.0375, 1.05, 0
3190, 0.05, 1.065, 0
3191, 0.0375, 1.08, 0
3192, 0.05, 1.095, 0
3193, 0.0375, 1.11, 0
3194, 0.05, 1.125, 0
3195, 0.0375, 1.14, 0
3196, 0.05, 1.155, 0
3197, 0.0375, 1.17, 0
3198, 0.05, 1.185, 0
3199, 0.075, 0.015, 0
3200, 0.0625, 0.03, 0
3201, 0.075, 0.045, 0
3202, 0.0625, 0.06, 0
3203, 0.075, 0.075, 0
3204, 0.0625, 0.09, 0
3205, 0.075, 0.105, 0
3206, 0.0625, 0.12, 0
3207, 0.075, 0.135, 0
3208, 0.0625, 0.15, 0
3209, 0.075, 0.165, 0
3210, 0.0625, 0.18, 0
3211, 0.075, 0.195, 0
3212, 0.0625, 0.21, 0
3213, 0.075, 0.225, 0
3214, 0.0625, 0.24, 0
3215, 0.075, 0.255, 0
3216, 0.0625, 0.27, 0
3217, 0.075, 0.285, 0
3218, 0.0625, 0.3, 0
3219, 0.075, 0.315, 0
3220, 0.0625, 0.33, 0
3221, 0.075, 0.345, 0
3222, 0.0625, 0.36, 0
3223, 0.075, 0.375, 0
3224, 0.0625, 0.39, 0
3225, 0.075, 0.405, 0
3226, 0.0625, 0.42, 0
3227, 0.075, 0.435, 0
3228, 0.0625, 0.45, 0
3229, 0.075, 0.465, 0
3230, 0.0625, 0.48, 0
3231, 0.075, 0.495, 0
3232, 0.0625, 0.51, 0
3233, 0.075, 0.525, 0
3234, 0.0625, 0.54, 0
3235, 0.075, 0.555, 0
3236, 0.0625, 0.57, 0
3237, 0.075, 0.585, 0
3238, 0.0625, 0.6, 0
3239, 0.075, 0.615, 0
3240, 0.0625, 0.63, 0
3241, 0.075, 0.645, 0
3242, 0.0625, 0.66, 0
3243, 0.075, 0.675, 0
3244, 0.0625, 0.69, 0
3245, 0.075, 0.705, 0
3246, 0.0625, 0.72, 0
3247, 0.075, 0.735, 0
3248, 0.0625, 0.75, 0
3249, 0.075, 0.765, 0
3250, 0.0625, 0.78, 0
3251, 0.075, 0.795, 0
3252, 0.0625, 0.81, 0
3253, 0.075, 0.825, 0
3254, 0.0625, 0.84, 0
3255, 0.075, 0.855, 0
3256, 0.0625, 0.87, 0
3257, 0.075, 0.885, 0
3258, 0.0625, 0.9, 0
3259, 0.075, 0.915, 0
3260, 0.0625, 0.93, 0
3261, 0.075, 0.945, 0
3262, 0.0625, 0.96, 0
3263, 0.075, 0.975, 0
3264, 0.0625, 0.99, 0
3265, 0.075, 1.005, 0
3266, 0.0625, 1.02, 0
3267, 0.075, 1.035, 0
3268, 0.0625, 1.05, 0
3269, 0.075, 1.065, 0
3270, 0.0625, 1.08, 0
3271, 0.075, 1.095, 0
3272, 0.0625, 1.11, 0
3273, 0.075, 1.125, 0
3274, 0.0625, 1.14, 0
3275, 0.075, 1.155, 0
3276, 0.0625, 1.17, 0
3277, 0.075, 1.185, 0
3278, 0.1, 0.015, 0
3279, 0.0875, 0.03, 0
3280, 0.1, 0.045, 0
3281, 0.0875, 0.06, 0
3282, 0.1, 0.075, 0
3283, 0.0875, 0.09, 0
3284, 0.1, 0.105, 0
3285, 0.0875, 0.12, 0
3286, 0.1, 0.135, 0
3287, 0.0875, 0.15, 0
3288, 0.1, 0.165, 0
3289, 0.0875, 0.18, 0
3290, 0.1, 0.195, 0
3291, 0.0875, 0.21, 0
3292, 0.1, 0.225, 0
3293, 0.0875, 0.24, 0
3294, 0.1, 0.255, 0
3295, 0.0875, 0.27, 0
3296, 0.1, 0.285, 0
3297, 0.0875, 0.3, 0
3298, 0.1, 0.315, 0
3299, 0.0875, 0.33, 0
3300, 0.1, 0.345, 0
3301, 0.0875, 0.36, 0
3302, 0.1, 0.375, 0
3303, 0.0875, 0.39, 0
3304, 0.1, 0.405, 0
3305, 0.0875, 0.42, 0
3306, 0.1, 0.435, 0
3307, 0.0875, 0.45, 0
3308, 0.1, 0.465, 0
3309, 0.0875, 0.48, 0
3310, 0.1, 0.495, 0
3311, 0.0875, 0.51, 0
3312, 0.1, 0.525, 0
3313, 0.0875, 0.54, 0
3314, 0.1, 0.555, 0
3315, 0.0875, 0.57, 0
3316, 0.1, 0.585, 0
3317, 0.0875, 0.6, 0
3318, 0.1, 0.615, 0
3319, 0.0875, 0.63, 0
3320, 0.1, 0.645, 0
3321, 0.0875, 0.66, 0
3322, 0.1, 0.675, 0
3323, 0.0875, 0.69, 0
3324, 0.1, 0.705, 0
3325, 0.0875, 0.72, 0
3326, 0.1, 0.735, 0
3327, 0.0875, 0.75, 0
3328, 0.1, 0.765, 0
3329, 0.0875, 0.78, 0
3330, 0.1, 0.795, 0
3331, 0.0875, 0.81, 0
3332, 0.1, 0.825, 0
3333, 0.0875, 0.84, 0
3334, 0.1, 0.855, 0
3335, 0.0875, 0.87, 0
3336, 0.1, 0.885, 0
3337, 0.0875, 0.9, 0
3338, 0.1, 0.915, 0
3339, 0.0875, 0.93, 0
3340, 0.1, 0.945, 0
3341, 0.0875, 0.96, 0
3342, 0.1, 0.975, 0
3343, 0.0875, 0.99, 0
3344, 0.1, 1.005, 0
3345, 0.0875, 1.02, 0
3346, 0.1, 1.035, 0
3347, 0.0875, 1.05, 0
3348, 0.1, 1.065, 0
3349, 0.0875, 1.08, 0
3350, 0.1, 1.095, 0
3351, 0.0875, 1.11, 0
3352, 0.1, 1.125, 0
3353, 0.0875, 1.14, 0
3354, 0.1, 1.155, 0
3355, 0.0875, 1.17, 0
3356, 0.1, 1.185, 0
3357, 0.125, 0.015, 0
3358, 0.1125, 0.03, 0
3359, 0.125, 0.045, 0
3360, 0.1125, 0.06, 0
3361, 0.125, 0.075, 0
3362, 0.1125, 0.09, 0
3363, 0.125, 0.105, 0
3364, 0.1125, 0.12, 0
3365, 0.125, 0.135, 0
3366, 0.1125, 0.15, 0
3367, 0.125, 0.165, 0
3368, 0.1125, 0.18, 0
3369, 0.125, 0.195, 0
3370, 0.1125, 0.21, 0
3371, 0.125, 0.225, 0
3372, 0.1125, 0.24, 0
3373, 0.125, 0.255, 0
3374, 0.1125, 0.27, 0
3375, 0.125, 0.285, 0
3376, 0.1125, 0.3, 0
3377, 0.125, 0.315, 0
3378, 0.1125, 0.33, 0
3379, 0.125, 0.345, 0
3380, 0.1125, 0.36, 0
3381, 0.125, 0.375, 0
3382, 0.1125, 0.39, 0
3383, 0.125, 0.405, 0
3384, 0.1125, 0.42, 0
3385, 0.125, 0.435, 0
3386, 0.1125, 0.45, 0
3387, 0.125, 0.465, 0
3388, 0.1125, 0.48, 0
3389, 0.125, 0.495, 0
3390, 0.1125, 0.51, 0
3391, 0.125, 0.525, 0
3392, 0.1125, 0.54, 0
3393, 0.125, 0.555, 0
3394, 0.1125, 0.57, 0
3395, 0.125, 0.585, 0
3396, 0.1125, 0.6, 0
3397, 0.125, 0.615, 0
3398, 0.1125, 0.63, 0
3399, 0.125, 0.645, 0
3400, 0.1125, 0.66, 0
3401, 0.125, 0.675, 0
3402, 0.1125, 0.69, 0
3403, 0.125, 0.705, 0
3404, 0.1125, 0.72, 0
3405, 0.125, 0.735, 0
3406, 0.1125, 0.75, 0
3407, 0.125, 0.765, 0
3408, 0.1125, 0.78, 0
3409, 0.125, 0.795, 0
3410, 0.1125, 0.81, 0
3411, 0.125, 0.825, 0
3412, 0.1125, 0.84, 0
3413, 0.125, 0.855, 0
3414, 0.1125, 0.87, 0
3415, 0.125, 0.885, 0
3416, 0.1125, 0.9, 0
3417, 0.125, 0.915, 0
3418, 0.1125, 0.93, 0
3419, 0.125, 0.945, 0
3420, 0.1125, 0.96, 0
3421, 0.125, 0.975, 0
3422, 0.1125, 0.99, 0
3423, 0.125, 1.005, 0
3424, 0.1125, 1.02, 0
3425, 0.125, 1.035, 0
3426, 0.1125, 1.05, 0
3427, 0.125, 1.065, 0
3428, 0.1125, 1.08, 0
3429, 0.125, 1.095, 0
3430, 0.1125, 1.11, 0
3431, 0.125, 1.125, 0
3432, 0.1125, 1.14, 0
3433, 0.125, 1.155, 0
3434, 0.1125, 1.17, 0
3435, 0.125, 1.185, 0
3436, 0.15, 0.015, 0
3437, 0.1375, 0.03, 0
3438, 0.15, 0.045, 0
3439, 0.1375, 0.06, 0
3440, 0.15, 0.075, 0
3441, 0.1375, 0.09, 0
3442, 0.15, 0.105, 0
3443, 0.1375, 0.12, 0
3444, 0.15, 0.135, 0
3445, 0.1375, 0.15, 0
3446, 0.15, 0.165, 0
3447, 0.1375, 0.18, 0
3448, 0.15, 0.195, 0
3449, 0.1375, 0.21, 0
3450, 0.15, 0.225, 0
3451, 0.1375, 0.24, 0
3452, 0.15, 0.255, 0
3453, 0.1375, 0.27, 0
3454, 0.15, 0.285, 0
3455, 0.1375, 0.3, 0
3456, 0.15, 0.315, 0
3457, 0.1375, 0.33, 0
3458, 0.15, 0.345, 0
3459, 0.1375, 0.36, 0
3460, 0.15, 0.375, 0
3461, 0.1375, 0.39, 0
3462, 0.15, 0.405, 0
3463, 0.1375, 0.42, 0
3464, 0.15, 0.435, 0
3465, 0.1375, 0.45, 0
3466, 0.15, 0.465, 0
3467, 0.1375, 0.48, 0
3468, 0.15, 0.495, 0
3469, 0.1375, 0.51, 0
3470, 0.15, 0.525, 0
3471, 0.1375, 0.54, 0
3472, 0.15, 0.555, 0
3473, 0.1375, 0.57, 0
3474, 0.15, 0.585, 0
3475, 0.1375, 0.6, 0
3476, 0.15, 0.615, 0
3477, 0.1375, 0.63, 0
3478, 0.15, 0.645, 0
3479, 0.1375, 0.66, 0
3480, 0.15, 0.675, 0
3481, 0.1375, 0.69, 0
3482, 0.15, 0.705, 0
3483, 0.1375, 0.72, 0
3484, 0.15, 0.735, 0
3485, 0.1375, 0.75, 0
3486, 0.15, 0.765, 0
3487, 0.1375, 0.78, 0
3488, 0.15, 0.795, 0
3489, 0.1375, 0.81, 0
3490, 0.15, 0.825, 0
3491, 0.1375, 0.84, 0
3492, 0.15, 0.855, 0
3493, 0.1375, 0.87, 0
3494, 0.15, 0.885, 0
3495, 0.1375, 0.9, 0
3496, 0.15, 0.915, 0
3497, 0.1375, 0.93, 0
3498, 0.15, 0.945, 0
3499, 0.1375, 0.96, 0
3500, 0.15, 0.975, 0
3501, 0.1375, 0.99, 0
3502, 0.15, 1.005, 0
3503, 0.1375, 1.02, 0
3504, 0.15, 1.035, 0
3505, 0.1375, 1.05, 0
3506, 0.15, 1.065, 0
3507, 0.1375, 1.08, 0
3508, 0.15, 1.095, 0
3509, 0.1375, 1.11, 0
3510, 0.15, 1.125, 0
3511, 0.1375, 1.14, 0
3512, 0.15, 1.155, 0
3513, 0.1375, 1.17, 0
3514, 0.15, 1.185, 0
3515, 0.175, 0.015, 0
3516, 0.1625, 0.03, 0
3517, 0.175, 0.045, 0
3518, 0.1625, 0.06, 0
3519, 0.175, 0.075, 0
3520, 0.1625, 0.09, 0
3521, 0.175, 0.105, 0
3522, 0.1625, 0.12, 0
3523, 0.175, 0.135, 0
3524, 0.1625, 0.15, 0
3525, 0.175, 0.165, 0
3526, 0.1625, 0.18, 0
3527, 0.175, 0.195, 0
3528, 0.1625, 0.21, 0
3529, 0.175, 0.225, 0
3530, 0.1625, 0.24, 0
3531, 0.175, 0.255, 0
3532, 0.1625, 0.27, 0
3533, 0.175, 0.285, 0
3534, 0.1625, 0.3, 0
3535, 0.175, 0.315, 0
3536, 0.1625, 0.33, 0
3537, 0.175, 0.345, 0
3538, 0.1625, 0.36, 0
3539, 0.175, 0.375, 0
3540, 0.1625, 0.39, 0
3541, 0.175, 0.405, 0
3542, 0.1625, 0.42, 0
3543, 0.175, 0.435, 0
3544, 0.1625, 0.45, 0
3545, 0.175, 0.465, 0
3546, 0.1625, 0.48, 0
3547, 0.175, 0.495, 0
3548, 0.1625, 0.51, 0
3549, 0.175, 0.525, 0
3550, 0.1625, 0.54, 0
3551, 0.175, 0.555, 0
3552, 0.1625, 0.57, 0
3553, 0.175, 0.585, 0
3554, 0.1625, 0.6, 0
3555, 0.175, 0.615, 0
3556, 0.1625, 0.63, 0
3557, 0.175, 0.645, 0
3558, 0.1625, 0.66, 0
3559, 0.175, 0.675, 0
3560, 0.1625, 0.69, 0
3561, 0.175, 0.705, 0
3562, 0.1625, 0.72, 0
3563, 0.175, 0.735, 0
3564, 0.1625, 0.75, 0
3565, 0.175, 0.765, 0
3566, 0.1625, 0.78, 0
3567, 0.175, 0.795, 0
3568, 0.1625, 0.81, 0
3569, 0.175, 0.825, 0
3570, 0.1625, 0.84, 0
3571, 0.175, 0.855, 0
3572, 0.1625, 0.87, 0
3573, 0.175, 0.885, 0
3574, 0.1625, 0.9, 0
3575, 0.175, 0.915, 0
3576, 0.1625, 0.93, 0
3577, 0.175, 0.945, 0
3578, 0.1625, 0.96, 0
3579, 0.175, 0.975, 0
3580, 0.1625, 0.99, 0
3581, 0.175, 1.005, 0
3582, 0.1625, 1.02, 0
3583, 0.175, 1.035, 0
3584, 0.1625, 1.05, 0
3585, 0.175, 1.065, 0
3586, 0.1625, 1.08, 0
3587, 0.175, 1.095, 0
3588, 0.1625, 1.11, 0
3589, 0.175, 1.125, 0
3590, 0.1625, 1.14, 0
3591, 0.175, 1.155, 0
3592, 0.1625, 1.17, 0
3593, 0.175, 1.185, 0
3594, 0.2, 0.015, 0
3595, 0.1875, 0.03, 0
3596, 0.2, 0.045, 0
3597, 0.1875, 0.06, 0
3598, 0.2, 0.075, 0
3599, 0.1875, 0.09, 0
3600, 0.2, 0.105, 0
3601, 0.1875, 0.12, 0
3602, 0.2, 0.135, 0
3603, 0.1875, 0.15, 0
3604, 0.2, 0.165, 0
3605, 0.1875, 0.18, 0
3606, 0.2, 0.195, 0
3607, 0.1875, 0.21, 0
3608, 0.2, 0.225, 0
3609, 0.1875, 0.24, 0
3610, 0.2, 0.255, 0
3611, 0.1875, 0.27, 0
3612, 0.2, 0.285, 0
3613, 0.1875, 0.3, 0
3614, 0.2, 0.315, 0
3615, 0.1875, 0.33, 0
3616, 0.2, 0.345, 0
3617, 0.1875, 0.36, 0
3618, 0.2, 0.375, 0
3619, 0.1875, 0.39, 0
3620, 0.2, 0.405, 0
3621, 0.1875, 0.42, 0
3622, 0.2, 0.435, 0
3623, 0.1875, 0.45, 0
3624, 0.2, 0.465, 0
3625, 0.1875, 0.48, 0
3626, 0.2, 0.495, 0
3627, 0.1875, 0.51, 0
3628, 0.2, 0.525, 0
3629, 0.1875, 0.54, 0
3630, 0.2, 0.555, 0
3631, 0.1875, 0.57, 0
3632, 0.2, 0.585, 0
3633, 0.1875, 0.6, 0
3634, 0.2, 0.615, 0
3635, 0.1875, 0.63, 0
3636, 0.2, 0.645, 0
3637, 0.1875, 0.66, 0
3638, 0.2, 0.675, 0
3639, 0.1875, 0.69, 0
3640, 0.2, 0.705, 0
3641, 0.1875, 0.72, 0
3642, 0.2, 0.735, 0
3643, 0.1875, 0.75, 0
3644, 0.2, 0.765, 0
3645, 0.1875, 0.78, 0
3646, 0.2, 0.795, 0
3647, 0.1875, 0.81, 0
3648, 0.2, 0.825, 0
3649, 0.1875, 0.84, 0
3650, 0.2, 0.855, 0
3651, 0.1875, 0.87, 0
3652, 0.2, 0.885, 0
3653, 0.1875, 0.9, 0
3654, 0.2, 0.915, 0
3655, 0.1875, 0.93, 0
3656, 0.2, 0.945, 0
3657, 0.1875, 0.96, 0
3658, 0.2, 0.975, 0
3659, 0.1875, 0.99, 0
3660, 0.2, 1.005, 0
3661, 0.1875, 1.02, 0
3662, 0.2, 1.035, 0
3663, 0.1875, 1.05, 0
3664, 0.2, 1.065, 0
3665, 0.1875, 1.08, 0
3666, 0.2, 1.095, 0
3667, 0.1875, 1.11, 0
3668, 0.2, 1.125, 0
3669, 0.1875, 1.14, 0
3670, 0.2, 1.155, 0
3671, 0.1875, 1.17, 0
3672, 0.2, 1.185, 0
3673, 0.225, 0.015, 0
3674, 0.2125, 0.03, 0
3675, 0.225, 0.045, 0
3676, 0.2125, 0.06, 0
3677, 0.225, 0.075, 0
3678, 0.2125, 0.09, 0
3679, 0.225, 0.105, 0
3680, 0.2125, 0.12, 0
3681, 0.225, 0.135, 0
3682, 0.2125, 0.15, 0
3683, 0.225, 0.165, 0
3684, 0.2125, 0.18, 0
3685, 0.225, 0.195, 0
3686, 0.2125, 0.21, 0
3687, 0.225, 0.225, 0
3688, 0.2125, 0.24, 0
3689, 0.225, 0.255, 0
3690, 0.2125, 0.27, 0
3691, 0.225, 0.285, 0
3692, 0.2125, 0.3, 0
3693, 0.225, 0.315, 0
3694, 0.2125, 0.33, 0
3695, 0.225, 0.345, 0
3696, 0.2125, 0.36, 0
3697, 0.225, 0.375, 0
3698, 0.2125, 0.39, 0
3699, 0.225, 0.405, 0
3700, 0.2125, 0.42, 0
3701, 0.225, 0.435, 0
3702, 0.2125, 0.45, 0
3703, 0.225, 0.465, 0
3704, 0.2125, 0.48, 0
3705, 0.225, 0.495, 0
3706, 0.2125, 0.51, 0
3707, 0.225, 0.525, 0
3708, 0.2125, 0.54, 0
3709, 0.225, 0.555, 0
3710, 0.2125, 0.57, 0
3711, 0.225, 0.585, 0
3712, 0.2125, 0.6, 0
3713, 0.225, 0.615, 0
3714, 0.2125, 0.63, 0
3715, 0.225, 0.645, 0
3716, 0.2125, 0.66, 0
3717, 0.225, 0.675, 0
3718, 0.2125, 0.69, 0
3719, 0.225, 0.705, 0
3720, 0.2125, 0.72, 0
3721, 0.225, 0.735, 0
3722, 0.2125, 0.75, 0
3723, 0.225, 0.765, 0
3724, 0.2125, 0.78, 0
3725, 0.225, 0.795, 0
3726, 0.2125, 0.81, 0
3727, 0.225, 0.825, 0
3728, 0.2125, 0.84, 0
3729, 0.225, 0.855, 0
3730, 0.2125, 0.87, 0
3731, 0.225, 0.885, 0
3732, 0.2125, 0.9, 0
3733, 0.225, 0.915, 0
3734, 0.2125, 0.93, 0
3735, 0.225, 0.945, 0
3736, 0.2125, 0.96, 0
3737, 0.225, 0.975, 0
3738, 0.2125, 0.99, 0
3739, 0.225, 1.005, 0
3740, 0.2125, 1.02, 0
3741, 0.225, 1.035, 0
3742, 0.2125, 1.05, 0
3743, 0.225, 1.065, 0
3744, 0.2125, 1.08, 0
3745, 0.225, 1.095, 0
3746, 0.2125, 1.11, 0
3747, 0.225, 1.125, 0
3748, 0.2125, 1.14, 0
3749, 0.225, 1.155, 0
3750, 0.2125, 1.17, 0
3751, 0.225, 1.185, 0
3752, 0.25, 0.015, 0
3753, 0.2375, 0.03, 0
3754, 0.25, 0.045, 0
3755, 0.2375, 0.06, 0
3756, 0.25, 0.075, 0
3757, 0.2375, 0.09, 0
3758, 0.25, 0.105, 0
3759, 0.2375, 0.12, 0
3760, 0.25, 0.135, 0
3761, 0.2375, 0.15, 0
3762, 0.25, 0.165, 0
3763, 0.2375, 0.18, 0
3764, 0.25, 0.195, 0
3765, 0.2375, 0.21, 0
3766, 0.25, 0.225, 0
3767, 0.2375, 0.24, 0
3768, 0.25, 0.255, 0
3769, 0.2375, 0.27, 0
3770, 0.25, 0.285, 0
3771, 0.2375, 0.3, 0
3772, 0.25, 0.315, 0
3773, 0.2375, 0.33, 0
3774, 0.25, 0.345, 0
3775, 0.2375, 0.36, 0
3776, 0.25, 0.375, 0
3777, 0.2375, 0.39, 0
3778, 0.25, 0.405, 0
3779, 0.2375, 0.42, 0
3780, 0.25, 0.435, 0
3781, 0.2375, 0.45, 0
3782, 0.25, 0.465, 0
3783, 0.2375, 0.48, 0
3784, 0.25, 0.495, 0
3785, 0.2375, 0.51, 0
3786, 0.25, 0.525, 0
3787, 0.2375, 0.54, 0
3788, 0.25, 0.555, 0
3789, 0.2375, 0.57, 0
3790, 0.25, 0.585, 0
3791, 0.2375, 0.6, 0
3792, 0.25, 0.615, 0
3793, 0.2375, 0.63, 0
3794, 0.25, 0.645, 0
3795, 0.2375, 0.66, 0
3796, 0.25, 0.675, 0
3797, 0.2375, 0.69, 0
3798, 0.25, 0.705, 0
3799, 0.2375, 0.72, 0
3800, 0.25, 0.735, 0
3801, 0.2375, 0.75, 0
3802, 0.25, 0.765, 0
3803, 0.2375, 0.78, 0
3804, 0.25, 0.795, 0
3805, 0.2375, 0.81, 0
3806, 0.25, 0.825, 0
3807, 0.2375, 0.84, 0
3808, 0.25, 0.855, 0
3809, 0.2375, 0.87, 0
3810, 0.25, 0.885, 0
3811, 0.2375, 0.9, 0
3812, 0.25, 0.915, 0
3813, 0.2375, 0.93, 0
3814, 0.25, 0.945, 0
3815, 0.2375, 0.96, 0
3816, 0.25, 0.975, 0
3817, 0.2375, 0.99, 0
3818, 0.25, 1.005, 0
3819, 0.2375, 1.02, 0
3820, 0.25, 1.035, 0
3821, 0.2375, 1.05, 0
3822, 0.25, 1.065, 0
3823, 0.2375, 1.08, 0
3824, 0.25, 1.095, 0
3825, 0.2375, 1.11, 0
3826, 0.25, 1.125, 0
3827, 0.2375, 1.14, 0
3828, 0.25, 1.155, 0
3829, 0.2375, 1.17, 0
3830, 0.25, 1.185, 0
3831, 0.275, 0.015, 0
3832, 0.2625, 0.03, 0
3833, 0.275, 0.045, 0
3834, 0.2625, 0.06, 0
3835, 0.275, 0.075, 0
3836, 0.2625, 0.09, 0
3837, 0.275, 0.105, 0
3838, 0.2625, 0.12, 0
3839, 0.275, 0.135, 0
3840, 0.2625, 0.15, 0
3841, 0.275, 0.165, 0
3842, 0.2625, 0.18, 0
3843, 0.275, 0.195, 0
3844, 0.2625, 0.21, 0
3845, 0.275, 0.225, 0
3846, 0.2625, 0.24, 0
3847, 0.275, 0.255, 0
3848, 0.2625, 0.27, 0
3849, 0.275, 0.285, 0
3850, 0.2625, 0.3, 0
3851, 0.275, 0.315, 0
3852, 0.2625, 0.33, 0
3853, 0.275, 0.345, 0
3854, 0.2625, 0.36, 0
3855, 0.275, 0.375, 0
3856, 0.2625, 0.39, 0
3857, 0.275, 0.405, 0
3858, 0.2625, 0.42, 0
3859, 0.275, 0.435, 0
3860, 0.2625, 0.45, 0
3861, 0.275, 0.465, 0
3862, 0.2625, 0.48, 0
3863, 0.275, 0.495, 0
3864, 0.2625, 0.51, 0
3865, 0.275, 0.525, 0
3866, 0.2625, 0.54, 0
3867, 0.275, 0.555, 0
3868, 0.2625, 0.57, 0
3869, 0.275, 0.585, 0
3870, 0.2625, 0.6, 0
3871, 0.275, 0.615, 0
3872, 0.2625, 0.63, 0
3873, 0.275, 0.645, 0
3874, 0.2625, 0.66, 0
3875, 0.275, 0.675, 0
3876, 0.2625, 0.69, 0
3877, 0.275, 0.705, 0
3878, 0.2625, 0.72, 0
3879, 0.275, 0.735, 0
3880, 0.2625, 0.75, 0
3881, 0.275, 0.765, 0
3882, 0.2625, 0.78, 0
3883, 0.275, 0.795, 0
3884, 0.2625, 0.81, 0
3885, 0.275, 0.825, 0
3886, 0.2625, 0.84, 0
3887, 0.275, 0.855, 0
3888, 0.2625, 0.87, 0
3889, 0.275, 0.885, 0
3890, 0.2625, 0.9, 0
3891, 0.275, 0.915, 0
3892, 0.2625, 0.93, 0
3893, 0.275, 0.945, 0
3894, 0.2625, 0.96, 0
3895, 0.275, 0.975, 0
3896, 0.2625, 0.99, 0
3897, 0.275, 1.005, 0
3898, 0.2625, 1.02, 0
3899, 0.275, 1.035, 0
3900, 0.2625, 1.05, 0
3901, 0.275, 1.065, 0
3902, 0.2625, 1.08, 0
3903, 0.275, 1.095, 0
3904, 0.2625, 1.11, 0
3905, 0.275, 1.125, 0
3906, 0.2625, 1.14, 0
3907, 0.275, 1.155, 0
3908, 0.2625, 1.17, 0
3909, 0.275, 1.185, 0
3910, 0.3, 0.015, 0
3911, 0.2875, 0.03, 0
3912, 0.3, 0.045, 0
3913, 0.2875, 0.06, 0
3914, 0.3, 0.075, 0
3915, 0.2875, 0.09, 0
3916, 0.3, 0.105, 0
3917, 0.2875, 0.12, 0
3918, 0.3, 0.135, 0
3919, 0.2875, 0.15, 0
3920, 0.3, 0.165, 0
3921, 0.2875, 0.18, 0
3922, 0.3, 0.195, 0
3923, 0.2875, 0.21, 0
3924, 0.3, 0.225, 0
3925, 0.2875, 0.24, 0
3926, 0.3, 0.255, 0
3927, 0.2875, 0.27, 0
3928, 0.3, 0.285, 0
3929, 0.2875, 0.3, 0
3930, 0.3, 0.315, 0
3931, 0.2875, 0.33, 0
3932, 0.3, 0.345, 0
3933, 0.2875, 0.36, 0
3934, 0.3, 0.375, 0
3935, 0.2875, 0.39, 0
3936, 0.3, 0.405, 0
3937, 0.2875, 0.42, 0
3938, 0.3, 0.435, 0
3939, 0.2875, 0.45, 0
3940, 0.3, 0.465, 0
3941, 0.2875, 0.48, 0
3942, 0.3, 0.495, 0
3943, 0.2875, 0.51, 0
3944, 0.3, 0.525, 0
3945, 0.2875, 0.54, 0
3946, 0.3, 0.555, 0
3947, 0.2875, 0.57, 0
3948, 0.3, 0.585, 0
3949, 0.2875, 0.6, 0
3950, 0.3, 0.615, 0
3951, 0.2875, 0.63, 0
3952, 0.3, 0.645, 0
3953, 0.2875, 0.66, 0
3954, 0.3, 0.675, 0
3955, 0.2875, 0.69, 0
3956, 0.3, 0.705, 0
3957, 0.2875, 0.72, 0
3958, 0.3, 0.735, 0
3959, 0.2875, 0.75, 0
3960, 0.3, 0.765, 0
3961, 0.2875, 0.78, 0
3962, 0.3, 0.795, 0
3963, 0.2875, 0.81, 0
3964, 0.3, 0.825, 0
3965, 0.2875, 0.84, 0
3966, 0.3, 0.855, 0
3967, 0.2875, 0.87, 0
3968, 0.3, 0.885, 0
3969, 0.2875, 0.9, 0
3970, 0.3, 0.915, 0
3971, 0.2875, 0.93, 0
3972, 0.3, 0.945, 0
3973, 0.2875, 0.96, 0
3974, 0.3, 0.975, 0
3975, 0.2875, 0.99, 0
3976, 0.3, 1.005, 0
3977, 0.2875, 1.02, 0
3978, 0.3, 1.035, 0
3979, 0.2875, 1.05, 0
3980, 0.3, 1.065, 0
3981, 0.2875, 1.08, 0
3982, 0.3, 1.095, 0
3983, 0.2875, 1.11, 0
3984, 0.3, 1.125, 0
3985, 0.2875, 1.14, 0
3986, 0.3, 1.155, 0
3987, 0.2875, 1.17, 0
3988, 0.3, 1.185, 0
3989, 0.325, 0.015, 0
3990, 0.3125, 0.03, 0
3991, 0.325, 0.045, 0
3992, 0.3125, 0.06, 0
3993, 0.325, 0.075, 0
3994, 0.3125, 0.09, 0
3995, 0.325, 0.105, 0
3996, 0.3125, 0.12, 0
3997, 0.325, 0.135, 0
3998, 0.3125, 0.15, 0
3999, 0.325, 0.165, 0
4000, 0.3125, 0.18, 0
4001, 0.325, 0.195, 0
4002, 0.3125, 0.21, 0
4003, 0.325, 0.225, 0
4004, 0.3125, 0.24, 0
4005, 0.325, 0.255, 0
4006, 0.3125, 0.27, 0
4007, 0.325, 0.285, 0
4008, 0.3125, 0.3, 0
4009, 0.325, 0.315, 0
4010, 0.3125, 0.33, 0
4011, 0.325, 0.345, 0
4012, 0.3125, 0.36, 0
4013, 0.325, 0.375, 0
4014, 0.3125, 0.39, 0
4015, 0.325, 0.405, 0
4016, 0.3125, 0.42, 0
4017, 0.325, 0.435, 0
4018, 0.3125, 0.45, 0
4019, 0.325, 0.465, 0
4020, 0.3125, 0.48, 0
4021, 0.325, 0.495, 0
4022, 0.3125, 0.51, 0
4023, 0.325, 0.525, 0
4024, 0.3125, 0.54, 0
4025, 0.325, 0.555, 0
4026, 0.3125, 0.57, 0
4027, 0.325, 0.585, 0
4028, 0.3125, 0.6, 0
4029, 0.325, 0.615, 0
4030, 0.3125, 0.63, 0
4031, 0.325, 0.645, 0
4032, 0.3125, 0.66, 0
4033, 0.325, 0.675, 0
4034, 0.3125, 0.69, 0
4035, 0.325, 0.705, 0
4036, 0.3125, 0.72, 0
4037, 0.325, 0.735, 0
4038, 0.3125, 0.75, 0
4039, 0.325, 0.765, 0
4040, 0.3125, 0.78, 0
4041, 0.325, 0.795, 0
4042, 0.3125, 0.81, 0
4043, 0.325, 0.825, 0
4044, 0.3125, 0.84, 0
4045, 0.325, 0.855, 0
4046, 0.3125, 0.87, 0
4047, 0.325, 0.885, 0
4048, 0.3125, 0.9, 0
4049, 0.325, 0.915, 0
4050, 0.3125, 0.93, 0
4051, 0.325, 0.945, 0
4052, 0.3125, 0.96, 0
4053, 0.325, 0.975, 0
4054, 0.3125, 0.99, 0
4055, 0.325, 1.005, 0
4056, 0.3125, 1.02, 0
4057, 0.325, 1.035, 0
4058, 0.3125, 1.05, 0
4059, 0.325, 1.065, 0
4060, 0.3125, 1.08, 0
4061, 0.325, 1.095, 0
4062, 0.3125, 1.11, 0
4063, 0.325, 1.125, 0
4064, 0.3125, 1.14, 0
4065, 0.325, 1.155, 0
4066, 0.3125, 1.17, 0
4067, 0.325, 1.185, 0
4068, 0.35, 0.015, 0
4069, 0.3375, 0.03, 0
4070, 0.35, 0.045, 0
4071, 0.3375, 0.06, 0
4072, 0.35, 0.075, 0
4073, 0.3375, 0.09, 0
4074, 0.35, 0.105, 0
4075, 0.3375, 0.12, 0
4076, 0.35, 0.135, 0
4077, 0.3375, 0.15, 0
4078, 0.35, 0.165, 0
4079, 0.3375, 0.18, 0
4080, 0.35, 0.195, 0
4081, 0.3375, 0.21, 0
4082, 0.35, 0.225, 0
4083, 0.3375, 0.24, 0
4084, 0.35, 0.255, 0
4085, 0.3375, 0.27, 0
4086, 0.35, 0.285, 0
4087, 0.3375, 0.3, 0
4088, 0.35, 0.315, 0
4089, 0.3375, 0.33, 0
4090, 0.35, 0.345, 0
4091, 0.3375, 0.36, 0
4092, 0.35, 0.375, 0
4093, 0.3375, 0.39, 0
4094, 0.35, 0.405, 0
4095, 0.3375, 0.42, 0
4096, 0.35, 0.435, 0
4097, 0.3375, 0.45, 0
4098, 0.35, 0.465, 0
4099, 0.3375, 0.48, 0
4100, 0.35, 0.495, 0
4101, 0.3375, 0.51, 0
4102, 0.35, 0.525, 0
4103, 0.3375, 0.54, 0
4104, 0.35, 0.555, 0
4105, 0.3375, 0.57, 0
4106, 0.35, 0.585, 0
4107, 0.3375, 0.6, 0
4108, 0.35, 0.615, 0
4109, 0.3375, 0.63, 0
4110, 0.35, 0.645, 0
4111, 0.3375, 0.66, 0
4112, 0.35, 0.675, 0
4113, 0.3375, 0.69, 0
4114, 0.35, 0.705, 0
4115, 0.3375, 0.72, 0
4116, 0.35, 0.735, 0
4117, 0.3375, 0.75, 0
4118, 0.35, 0.765, 0
4119, 0.3375, 0.78, 0
4120, 0.35, 0.795, 0
4121, 0.3375, 0.81, 0
4122, 0.35, 0.825, 0
4123, 0.3375, 0.84, 0
4124, 0.35, 0.855, 0
4125, 0.3375, 0.87, 0
4126, 0.35, 0.885, 0
4127, 0.3375, 0.9, 0
4128, 0.35, 0.915, 0
4129, 0.3375, 0.93, 0
4130, 0.35, 0.945, 0
4131, 0.3375, 0.96, 0
4132, 0.35, 0.975, 0
4133, 0.3375, 0.99, 0
4134, 0.35, 1.005, 0
4135, 0.3375, 1.02, 0
4136, 0.35, 1.035, 0
4137, 0.3375, 1.05, 0
4138, 0.35, 1.065, 0
4139, 0.3375, 1.08, 0
4140, 0.35, 1.095, 0
4141, 0.3375, 1.11, 0
4142, 0.35, 1.125, 0
4143, 0.3375, 1.14, 0
4144, 0.35, 1.155, 0
4145, 0.3375, 1.17, 0
4146, 0.35, 1.185, 0
4147, 0.375, 0.015, 0
4148, 0.3625, 0.03, 0
4149, 0.375, 0.045, 0
4150, 0.3625, 0.06, 0
4151, 0.375, 0.075, 0
4152, 0.3625, 0.09, 0
4153, 0.375, 0.105, 0
4154, 0.3625, 0.12, 0
4155, 0.375, 0.135, 0
4156, 0.3625, 0.15, 0
4157, 0.375, 0.165, 0
4158, 0.3625, 0.18, 0
4159, 0.375, 0.195, 0
4160, 0.3625, 0.21, 0
4161, 0.375, 0.225, 0
4162, 0.3625, 0.24, 0
4163, 0.375, 0.255, 0
4164, 0.3625, 0.27, 0
4165, 0.375, 0.285, 0
4166, 0.3625, 0.3, 0
4167, 0.375, 0.315, 0
4168, 0.3625, 0.33, 0
4169, 0.375, 0.345, 0
4170, 0.3625, 0.36, 0
4171, 0.375, 0.375, 0
4172, 0.3625, 0.39, 0
4173, 0.375, 0.405, 0
4174, 0.3625, 0.42, 0
4175, 0.375, 0.435, 0
4176, 0.3625, 0.45, 0
4177, 0.375, 0.465, 0
4178, 0.3625, 0.48, 0
4179, 0.375, 0.495, 0
4180, 0.3625, 0.51, 0
4181, 0.375, 0.525, 0
4182, 0.3625, 0.54, 0
4183, 0.375, 0.555, 0
4184, 0.3625, 0.57, 0
4185, 0.375, 0.585, 0
4186, 0.3625, 0.6, 0
4187, 0.375, 0.615, 0
4188, 0.3625, 0.63, 0
4189, 0.375, 0.645, 0
4190, 0.3625, 0.66, 0
4191, 0.375, 0.675, 0
4192, 0.3625, 0.69, 0
4193, 0.375, 0.705, 0
4194, 0.3625, 0.72, 0
4195, 0.375, 0.735, 0
4196, 0.3625, 0.75, 0
4197, 0.375, 0.765, 0
4198, 0.3625, 0.78, 0
4199, 0.375, 0.795, 0
4200, 0.3625, 0.81, 0
4201, 0.375, 0.825, 0
4202, 0.3625, 0.84, 0
4203, 0.375, 0.855, 0
4204, 0.3625, 0.87, 0
4205, 0.375, 0.885, 0
4206, 0.3625, 0.9, 0
4207, 0.375, 0.915, 0
4208, 0.3625, 0.93, 0
4209, 0.375, 0.945, 0
4210, 0.3625, 0.96, 0
4211, 0.375, 0.975, 0
4212, 0.3625, 0.99, 0
4213, 0.375, 1.005, 0
4214, 0.3625, 1.02, 0
4215, 0.375, 1.035, 0
4216, 0.3625, 1.05, 0
4217, 0.375, 1.065, 0
4218, 0.3625, 1.08, 0
4219, 0.375, 1.095, 0
4220, 0.3625, 1.11, 0
4221, 0.375, 1.125, 0
4222, 0.3625, 1.14, 0
4223, 0.375, 1.155, 0
4224, 0.3625, 1.17, 0
4225, 0.375, 1.185, 0
4226, 0.4, 0.015, 0
4227, 0.3875, 0.03, 0
4228, 0.4, 0.045, 0
4229, 0.3875, 0.06, 0
4230, 0.4, 0.075, 0
4231, 0.3875, 0.09, 0
4232, 0.4, 0.105, 0
4233, 0.3875, 0.12, 0
4234, 0.4, 0.135, 0
4235, 0.3875, 0.15, 0
4236, 0.4, 0.165, 0
4237, 0.3875, 0.18, 0
4238, 0.4, 0.195, 0
4239, 0.3875, 0.21, 0
4240, 0.4, 0.225, 0
4241, 0.3875, 0.24, 0
4242, 0.4, 0.255, 0
4243, 0.3875, 0.27, 0
4244, 0.4, 0.285, 0
4245, 0.3875, 0.3, 0
4246, 0.4, 0.315, 0
4247, 0.3875, 0.33, 0
4248, 0.4, 0.345, 0
4249, 0.3875, 0.36, 0
4250, 0.4, 0.375, 0
4251, 0.3875, 0.39, 0
4252, 0.4, 0.405, 0
4253, 0.3875, 0.42, 0
4254, 0.4, 0.435, 0
4255, 0.3875, 0.45, 0
4256, 0.4, 0.465, 0
4257, 0.3875, 0.48, 0
4258, 0.4, 0.495, 0
4259, 0.3875, 0.51, 0
4260, 0.4, 0.525, 0
4261, 0.3875, 0.54, 0
4262, 0.4, 0.555, 0
4263, 0.3875, 0.57, 0
4264, 0.4, 0.585, 0
4265, 0.3875, 0.6, 0
4266, 0.4, 0.615, 0
4267, 0.3875, 0.63, 0
4268, 0.4, 0.645, 0
4269, 0.3875, 0.66, 0
4270, 0.4, 0.675, 0
4271, 0.3875, 0.69, 0
4272, 0.4, 0.705, 0
4273, 0.3875, 0.72, 0
4274, 0.4, 0.735, 0
4275, 0.3875, 0.75, 0
4276, 0.4, 0.765, 0
4277, 0.3875, 0.78, 0
4278, 0.4, 0.795, 0
4279, 0.3875, 0.81, 0
4280, 0.4, 0.825, 0
4281, 0.3875, 0.84, 0
4282, 0.4, 0.855, 0
4283, 0.3875, 0.87, 0
4284, 0.4, 0.885, 0
4285, 0.3875, 0.9, 0
4286, 0.4, 0.915, 0
4287, 0.3875, 0.93, 0
4288, 0.4, 0.945, 0
4289, 0.3875, 0.96, 0
4290, 0.4, 0.975, 0
4291, 0.3875, 0.99, 0
4292, 0.4, 1.005, 0
4293, 0.3875, 1.02, 0
4294, 0.4, 1.035, 0
4295, 0.3875, 1.05, 0
4296, 0.4, 1.065, 0
4297, 0.3875, 1.08, 0
4298, 0.4, 1.095, 0
4299, 0.3875, 1.11, 0
4300, 0.4, 1.125, 0
4301, 0.3875, 1.14, 0
4302, 0.4, 1.155, 0
4303, 0.3875, 1.17, 0
4304, 0.4, 1.185, 0
4305, 0.425, 0.015, 0
4306, 0.4125, 0.03, 0
4307, 0.425, 0.045, 0
4308, 0.4125, 0.06, 0
4309, 0.425, 0.075, 0
4310, 0.4125, 0.09, 0
4311, 0.425, 0.105, 0
4312, 0.4125, 0.12, 0
4313, 0.425, 0.135, 0
4314, 0.4125, 0.15, 0
4315, 0.425, 0.165, 0
4316, 0.4125, 0.18, 0
4317, 0.425, 0.195, 0
4318, 0.4125, 0.21, 0
4319, 0.425, 0.225, 0
4320, 0.4125, 0.24, 0
4321, 0.425, 0.255, 0
4322, 0.4125, 0.27, 0
4323, 0.425, 0.285, 0
4324, 0.4125, 0.3, 0
4325, 0.425, 0.315, 0
4326, 0.4125, 0.33, 0
4327, 0.425, 0.345, 0
4328, 0.4125, 0.36, 0
4329, 0.425, 0.375, 0
4330, 0.4125, 0.39, 0
4331, 0.425, 0.405, 0
4332, 0.4125, 0.42, 0
4333, 0.425, 0.435, 0
4334, 0.4125, 0.45, 0
4335, 0.425, 0.465, 0
4336, 0.4125, 0.48, 0
4337, 0.425, 0.495, 0
4338, 0.4125, 0.51, 0
4339, 0.425, 0.525, 0
4340, 0.4125, 0.54, 0
4341, 0.425, 0.555, 0
4342, 0.4125, 0.57, 0
4343, 0.425, 0.585, 0
4344, 0.4125, 0.6, 0
4345, 0.425, 0.615, 0
4346, 0.4125, 0.63, 0
4347, 0.425, 0.645, 0
4348, 0.4125, 0.66, 0
4349, 0.425, 0.675, 0
4350, 0.4125, 0.69, 0
4351, 0.425, 0.705, 0
4352, 0.4125, 0.72, 0
4353, 0.425, 0.735, 0
4354, 0.4125, 0.75, 0
4355, 0.425, 0.765, 0
4356, 0.4125, 0.78, 0
4357, 0.425, 0.795, 0
4358, 0.4125, 0.81, 0
4359, 0.425, 0.825, 0
4360, 0.4125, 0.84, 0
4361, 0.425, 0.855, 0
4362, 0.4125, 0.87, 0
4363, 0.425, 0.885, 0
4364, 0.4125, 0.9, 0
4365, 0.425, 0.915, 0
4366, 0.4125, 0.93, 0
4367, 0.425, 0.945, 0
4368, 0.4125, 0.96, 0
4369, 0.425, 0.975, 0
4370, 0.4125, 0.99, 0
4371, 0.425, 1.005, 0
4372, 0.4125, 1.02, 0
4373, 0.425, 1.035, 0
4374, 0.4125, 1.05, 0
4375, 0.425, 1.065, 0
4376, 0.4125, 1.08, 0
4377, 0.425, 1.095, 0
4378, 0.4125, 1.11, 0
4379, 0.425, 1.125, 0
4380, 0.4125, 1.14, 0
4381, 0.425, 1.155, 0
4382, 0.4125, 1.17, 0
4383, 0.425, 1.185, 0
4384, 0.45, 0.015, 0
4385, 0.4375, 0.03, 0
4386, 0.45, 0.045, 0
4387, 0.4375, 0.06, 0
4388, 0.45, 0.075, 0
4389, 0.4375, 0.09, 0
4390, 0.45, 0.105, 0
4391, 0.4375, 0.12, 0
4392, 0.45, 0.135, 0
4393, 0.4375, 0.15, 0
4394, 0.45, 0.165, 0
4395, 0.4375, 0.18, 0
4396, 0.45, 0.195, 0
4397, 0.4375, 0.21, 0
4398, 0.45, 0.225, 0
4399, 0.4375, 0.24, 0
4400, 0.45, 0.255, 0
4401, 0.4375, 0.27, 0
4402, 0.45, 0.285, 0
4403, 0.4375, 0.3, 0
4404, 0.45, 0.315, 0
4405, 0.4375, 0.33, 0
4406, 0.45, 0.345, 0
4407, 0.4375, 0.36, 0
4408, 0.45, 0.375, 0
4409, 0.4375, 0.39, 0
4410, 0.45, 0.405, 0
4411, 0.4375, 0.42, 0
4412, 0.45, 0.435, 0
4413, 0.4375, 0.45, 0
4414, 0.45, 0.465, 0
4415, 0.4375, 0.48, 0
4416, 0.45, 0.495, 0
4417, 0.4375, 0.51, 0
4418, 0.45, 0.525, 0
4419, 0.4375, 0.54, 0
4420, 0.45, 0.555, 0
4421, 0.4375, 0.57, 0
4422, 0.45, 0.585, 0
4423, 0.4375, 0.6, 0
4424, 0.45, 0.615, 0
4425, 0.4375, 0.63, 0
4426, 0.45, 0.645, 0
4427, 0.4375, 0.66, 0
4428, 0.45, 0.675, 0
4429, 0.4375, 0.69, 0
4430, 0.45, 0.705, 0
4431, 0.4375, 0.72, 0
4432, 0.45, 0.735, 0
4433, 0.4375, 0.75, 0
4434, 0.45, 0.765, 0
4435, 0.4375, 0.78, 0
4436, 0.45, 0.795, 0
4437, 0.4375, 0.81, 0
4438, 0.45, 0.825, 0
4439, 0.4375, 0.84, 0
4440, 0.45, 0.855, 0
4441, 0.4375, 0.87, 0
4442, 0.45, 0.885, 0
4443, 0.4375, 0.9, 0
4444, 0.45, 0.915, 0
4445, 0.4375, 0.93, 0
4446, 0.45, 0.945, 0
4447, 0.4375, 0.96, 0
4448, 0.45, 0.975, 0
4449, 0.4375, 0.99, 0
4450, 0.45, 1.005, 0
4451, 0.4375, 1.02, 0
4452, 0.45, 1.035, 0
4453, 0.4375, 1.05, 0
4454, 0.45, 1.065, 0
4455, 0.4375, 1.08, 0
4456, 0.45, 1.095, 0
4457, 0.4375, 1.11, 0
4458, 0.45, 1.125, 0
4459, 0.4375, 1.14, 0
4460, 0.45, 1.155, 0
4461, 0.4375, 1.17, 0
4462, 0.45, 1.185, 0
4463, 0.475, 0.015, 0
4464, 0.4625, 0.03, 0
4465, 0.475, 0.045, 0
4466, 0.4625, 0.06, 0
4467, 0.475, 0.075, 0
4468, 0.4625, 0.09, 0
4469, 0.475, 0.105, 0
4470, 0.4625, 0.12, 0
4471, 0.475, 0.135, 0
4472, 0.4625, 0.15, 0
4473, 0.475, 0.165, 0
4474, 0.4625, 0.18, 0
4475, 0.475, 0.195, 0
4476, 0.4625, 0.21, 0
4477, 0.475, 0.225, 0
4478, 0.4625, 0.24, 0
4479, 0.475, 0.255, 0
4480, 0.4625, 0.27, 0
4481, 0.475, 0.285, 0
4482, 0.4625, 0.3, 0
4483, 0.475, 0.315, 0
4484, 0.4625, 0.33, 0
4485, 0.475, 0.345, 0
4486, 0.4625, 0.36, 0
4487, 0.475, 0.375, 0
4488, 0.4625, 0.39, 0
4489, 0.475, 0.405, 0
4490, 0.4625, 0.42, 0
4491, 0.475, 0.435, 0
4492, 0.4625, 0.45, 0
4493, 0.475, 0.465, 0
4494, 0.4625, 0.48, 0
4495, 0.475, 0.495, 0
4496, 0.4625, 0.51, 0
4497, 0.475, 0.525, 0
4498, 0.4625, 0.54, 0
4499, 0.475, 0.555, 0
4500, 0.4625, 0.57, 0
4501, 0.475, 0.585, 0
4502, 0.4625, 0.6, 0
4503, 0.475, 0.615, 0
4504, 0.4625, 0.63, 0
4505, 0.475, 0.645, 0
4506, 0.4625, 0.66, 0
4507, 0.475, 0.675, 0
4508, 0.4625, 0.69, 0
4509, 0.475, 0.705, 0
4510, 0.4625, 0.72, 0
4511, 0.475, 0.735, 0
4512, 0.4625, 0.75, 0
4513, 0.475, 0.765, 0
4514, 0.4625, 0.78, 0
4515, 0.475, 0.795, 0
4516, 0.4625, 0.81, 0
4517, 0.475, 0.825, 0
4518, 0.4625, 0.84, 0
4519, 0.475, 0.855, 0
4520, 0.4625, 0.87, 0
4521, 0.475, 0.885, 0
4522, 0.4625, 0.9, 0
4523, 0.475, 0.915, 0
4524, 0.4625, 0.93, 0
4525, 0.475, 0.945, 0
4526, 0.4625, 0.96, 0
4527, 0.475, 0.975, 0
4528, 0.4625, 0.99, 0
4529, 0.475, 1.005, 0
4530, 0.4625, 1.02, 0
4531, 0.475, 1.035, 0
4532, 0.4625, 1.05, 0
4533, 0.475, 1.065, 0
4534, 0.4625, 1.08, 0
4535, 0.475, 1.095, 0
4536, 0.4625, 1.11, 0
4537, 0.475, 1.125, 0
4538, 0.4625, 1.14, 0
4539, 0.475, 1.155, 0
4540, 0.4625, 1.17, 0
4541, 0.475, 1.185, 0
4542, 0.5, 0.015, 0
4543, 0.4875, 0.03, 0
4544, 0.5, 0.045, 0
4545, 0.4875, 0.06, 0
4546, 0.5, 0.075, 0
4547, 0.4875, 0.09, 0
4548, 0.5, 0.105, 0
4549, 0.4875, 0.12, 0
4550, 0.5, 0.135, 0
4551, 0.4875, 0.15, 0
4552, 0.5, 0.165, 0
4553, 0.4875, 0.18, 0
4554, 0.5, 0.195, 0
4555, 0.4875, 0.21, 0
4556, 0.5, 0.225, 0
4557, 0.4875, 0.24, 0
4558, 0.5, 0.255, 0
4559, 0.4875, 0.27, 0
4560, 0.5, 0.285, 0
4561, 0.4875, 0.3, 0
4562, 0.5, 0.315, 0
4563, 0.4875, 0.33, 0
4564, 0.5, 0.345, 0
4565, 0.4875, 0.36, 0
4566, 0.5, 0.375, 0
4567, 0.4875, 0.39, 0
4568, 0.5, 0.405, 0
4569, 0.4875, 0.42, 0
4570, 0.5, 0.435, 0
4571, 0.4875, 0.45, 0
4572, 0.5, 0.465, 0
4573, 0.4875, 0.48, 0
4574, 0.5, 0.495, 0
4575, 0.4875, 0.51, 0
4576, 0.5, 0.525, 0
4577, 0.4875, 0.54, 0
4578, 0.5, 0.555, 0
4579, 0.4875, 0.57, 0
4580, 0.5, 0.585, 0
4581, 0.4875, 0.6, 0
4582, 0.5, 0.615, 0
4583, 0.4875, 0.63, 0
4584, 0.5, 0.645, 0
4585, 0.4875, 0.66, 0
4586, 0.5, 0.675, 0
4587, 0.4875, 0.69, 0
4588, 0.5, 0.705, 0
4589, 0.4875, 0.72, 0
4590, 0.5, 0.735, 0
4591, 0.4875, 0.75, 0
4592, 0.5, 0.765, 0
4593, 0.4875, 0.78, 0
4594, 0.5, 0.795, 0
4595, 0.4875, 0.81, 0
4596, 0.5, 0.825, 0
4597, 0.4875, 0.84, 0
4598, 0.5, 0.855, 0
4599, 0.4875, 0.87, 0
4600, 0.5, 0.885, 0
4601, 0.4875, 0.9, 0
4602, 0.5, 0.915, 0
4603, 0.4875, 0.93, 0
4604, 0.5, 0.945, 0
4605, 0.4875, 0.96, 0
4606, 0.5, 0.975, 0
4607, 0.4875, 0.99, 0
4608, 0.5, 1.005, 0
4609, 0.4875, 1.02, 0
4610, 0.5, 1.035, 0
4611, 0.4875, 1.05, 0
4612, 0.5, 1.065, 0
4613, 0.4875, 1.08, 0
4614, 0.5, 1.095, 0
4615, 0.4875, 1.11, 0
4616, 0.5, 1.125, 0
4617, 0.4875, 1.14, 0
4618, 0.5, 1.155, 0
4619, 0.4875, 1.17, 0
4620, 0.5, 1.185, 0
4621, 0.525, 0.015, 0
4622, 0.5125, 0.03, 0
4623, 0.525, 0.045, 0
4624, 0.5125, 0.06, 0
4625, 0.525, 0.075, 0
4626, 0.5125, 0.09, 0
4627, 0.525, 0.105, 0
4628, 0.5125, 0.12, 0
4629, 0.525, 0.135, 0
4630, 0.5125, 0.15, 0
4631, 0.525, 0.165, 0
4632, 0.5125, 0.18, 0
4633, 0.525, 0.195, 0
4634, 0.5125, 0.21, 0
4635, 0.525, 0.225, 0
4636, 0.5125, 0.24, 0
4637, 0.525, 0.255, 0
4638, 0.5125, 0.27, 0
4639, 0.525, 0.285, 0
4640, 0.5125, 0.3, 0
4641, 0.525, 0.315, 0
4642, 0.5125, 0.33, 0
4643, 0.525, 0.345, 0
4644, 0.5125, 0.36, 0
4645, 0.525, 0.375, 0
4646, 0.5125, 0.39, 0
4647, 0.525, 0.405, 0
4648, 0.5125, 0.42, 0
4649, 0.525, 0.435, 0
4650, 0.5125, 0.45, 0
4651, 0.525, 0.465, 0
4652, 0.5125, 0.48, 0
4653, 0.525, 0.495, 0
4654, 0.5125, 0.51, 0
4655, 0.525, 0.525, 0
4656, 0.5125, 0.54, 0
4657, 0.525, 0.555, 0
4658, 0.5125, 0.57, 0
4659, 0.525, 0.585, 0
4660, 0.5125, 0.6, 0
4661, 0.525, 0.615, 0
4662, 0.5125, 0.63, 0
4663, 0.525, 0.645, 0
4664, 0.5125, 0.66, 0
4665, 0.525, 0.675, 0
4666, 0.5125, 0.69, 0
4667, 0.525, 0.705, 0
4668, 0.5125, 0.72, 0
4669, 0.525, 0.735, 0
4670, 0.5125, 0.75, 0
4671, 0.525, 0.765, 0
4672, 0.5125, 0.78, 0
4673, 0.525, 0.795, 0
4674, 0.5125, 0.81, 0
4675, 0.525, 0.825, 0
4676, 0.5125, 0.84, 0
4677, 0.525, 0.855, 0
4678, 0.5125, 0.87, 0
4679, 0.525, 0.885, 0
4680, 0.5125, 0.9, 0
4681, 0.525, 0.915, 0
4682, 0.5125, 0.93, 0
4683, 0.525, 0.945, 0
4684, 0.5125, 0.96, 0
4685, 0.525, 0.975, 0
4686, 0.5125, 0.99, 0
4687, 0.525, 1.005, 0
4688, 0.5125, 1.02, 0
4689, 0.525, 1.035, 0
4690, 0.5125, 1.05, 0
4691, 0.525, 1.065, 0
4692, 0.5125, 1.08, 0
4693, 0.525, 1.095, 0
4694, 0.5125, 1.11, 0
4695, 0.525, 1.125, 0
4696, 0.5125, 1.14, 0
4697, 0.525, 1.155, 0
4698, 0.5125, 1.17, 0
4699, 0.525, 1.185, 0
4700, 0.55, 0.015, 0
4701, 0.5375, 0.03, 0
4702, 0.55, 0.045, 0
4703, 0.5375, 0.06, 0
4704, 0.55, 0.075, 0
4705, 0.5375, 0.09, 0
4706, 0.55, 0.105, 0
4707, 0.5375, 0.12, 0
4708, 0.55, 0.135, 0
4709, 0.5375, 0.15, 0
4710, 0.55, 0.165, 0
4711, 0.5375, 0.18, 0
4712, 0.55, 0.195, 0
4713, 0.5375, 0.21, 0
4714, 0.55, 0.225, 0
4715, 0.5375, 0.24, 0
4716, 0.55, 0.255, 0
4717, 0.5375, 0.27, 0
4718, 0.55, 0.285, 0
4719, 0.5375, 0.3, 0
4720, 0.55, 0.315, 0
4721, 0.5375, 0.33, 0
4722, 0.55, 0.345, 0
4723, 0.5375, 0.36, 0
4724, 0.55, 0.375, 0
4725, 0.5375, 0.39, 0
4726, 0.55, 0.405, 0
4727, 0.5375, 0.42, 0
4728, 0.55, 0.435, 0
4729, 0.5375, 0.45, 0
4730, 0.55, 0.465, 0
4731, 0.5375, 0.48, 0
4732, 0.55, 0.495, 0
4733, 0.5375, 0.51, 0
4734, 0.55, 0.525, 0
4735, 0.5375, 0.54, 0
4736, 0.55, 0.555, 0
4737, 0.5375, 0.57, 0
4738, 0.55, 0.585, 0
4739, 0.5375, 0.6, 0
4740, 0.55, 0.615, 0
4741, 0.5375, 0.63, 0
4742, 0.55, 0.645, 0
4743, 0.5375, 0.66, 0
4744, 0.55, 0.675, 0
4745, 0.5375, 0.69, 0
4746, 0.55, 0.705, 0
4747, 0.5375, 0.72, 0
4748, 0.55, 0.735, 0
4749, 0.5375, 0.75, 0
4750, 0.55, 0.765, 0
4751, 0.5375, 0.78, 0
4752, 0.55, 0.795, 0
4753, 0.5375, 0.81, 0
4754, 0.55, 0.825, 0
4755, 0.5375, 0.84, 0
4756, 0.55, 0.855, 0
4757, 0.5375, 0.87, 0
4758, 0.55, 0.885, 0
4759, 0.5375, 0.9, 0
4760, 0.55, 0.915, 0
4761, 0.5375, 0.93, 0
4762, 0.55, 0.945, 0
4763, 0.5375, 0.96, 0
4764, 0.55, 0.975, 0
4765, 0.5375, 0.99, 0
4766, 0.55, 1.005, 0
4767, 0.5375, 1.02, 0
4768, 0.55, 1.035, 0
4769, 0.5375, 1.05, 0
4770, 0.55, 1.065, 0
4771, 0.5375, 1.08, 0
4772, 0.55, 1.095, 0
4773, 0.5375, 1.11, 0
4774, 0.55, 1.125, 0
4775, 0.5375, 1.14, 0
4776, 0.55, 1.155, 0
4777, 0.5375, 1.17, 0
4778, 0.55, 1.185, 0
4779, 0.575, 0.015, 0
4780, 0.5625, 0.03, 0
4781, 0.575, 0.045, 0
4782, 0.5625, 0.06, 0
4783, 0.575, 0.075, 0
4784, 0.5625, 0.09, 0
4785, 0.575, 0.105, 0
4786, 0.5625, 0.12, 0
4787, 0.575, 0.135, 0
4788, 0.5625, 0.15, 0
4789, 0.575, 0.165, 0
4790, 0.5625, 0.18, 0
4791, 0.575, 0.195, 0
4792, 0.5625, 0.21, 0
4793, 0.575, 0.225, 0
4794, 0.5625, 0.24, 0
4795, 0.575, 0.255, 0
4796, 0.5625, 0.27, 0
4797, 0.575, 0.285, 0
4798, 0.5625, 0.3, 0
4799, 0.575, 0.315, 0
4800, 0.5625, 0.33, 0
4801, 0.575, 0.345, 0
4802, 0.5625, 0.36, 0
4803, 0.575, 0.375, 0
4804, 0.5625, 0.39, 0
4805, 0.575, 0.405, 0
4806, 0.5625, 0.42, 0
4807, 0.575, 0.435, 0
4808, 0.5625, 0.45, 0
4809, 0.575, 0.465, 0
4810, 0.5625, 0.48, 0
4811, 0.575, 0.495, 0
4812, 0.5625, 0.51, 0
4813, 0.575, 0.525, 0
4814, 0.5625, 0.54, 0
4815, 0.575, 0.555, 0
4816, 0.5625, 0.57, 0
4817, 0.575, 0.585, 0
4818, 0.5625, 0.6, 0
4819, 0.575, 0.615, 0
4820, 0.5625, 0.63, 0
4821, 0.575, 0.645, 0
4822, 0.5625, 0.66, 0
4823, 0.575, 0.675, 0
4824, 0.5625, 0.69, 0
4825, 0.575, 0.705, 0
4826, 0.5625, 0.72, 0
4827, 0.575, 0.735, 0
4828, 0.5625, 0.75, 0
4829, 0.575, 0.765, 0
4830, 0.5625, 0.78, 0
4831, 0.575, 0.795, 0
4832, 0.5625, 0.81, 0
4833, 0.575, 0.825, 0
4834, 0.5625, 0.84, 0
4835, 0.575, 0.855, 0
4836, 0.5625, 0.87, 0
4837, 0.575, 0.885, 0
4838, 0.5625, 0.9, 0
4839, 0.575, 0.915, 0
4840, 0.5625, 0.93, 0
4841, 0.575, 0.945, 0
4842, 0.5625, 0.96, 0
4843, 0.575, 0.975, 0
4844, 0.5625, 0.99, 0
4845, 0.575, 1.005, 0
4846, 0.5625, 1.02, 0
4847, 0.575, 1.035, 0
4848, 0.5625, 1.05, 0
4849, 0.575, 1.065, 0
4850, 0.5625, 1.08, 0
4851, 0.575, 1.095, 0
4852, 0.5625, 1.11, 0
4853, 0.575, 1.125, 0
4854, 0.5625, 1.14, 0
4855, 0.575, 1.155, 0
4856, 0.5625, 1.17, 0
4857, 0.575, 1.185, 0
4858, 0.6, 0.015, 0
4859, 0.5875, 0.03, 0
4860, 0.6, 0.045, 0
4861, 0.5875, 0.06, 0
4862, 0.6, 0.075, 0
4863, 0.5875, 0.09, 0
4864, 0.6, 0.105, 0
4865, 0.5875, 0.12, 0
4866, 0.6, 0.135, 0
4867, 0.5875, 0.15, 0
4868, 0.6, 0.165, 0
4869, 0.5875, 0.18, 0
4870, 0.6, 0.195, 0
4871, 0.5875, 0.21, 0
4872, 0.6, 0.225, 0
4873, 0.5875, 0.24, 0
4874, 0.6, 0.255, 0
4875, 0.5875, 0.27, 0
4876, 0.6, 0.285, 0
4877, 0.5875, 0.3, 0
4878, 0.6, 0.315, 0
4879, 0.5875, 0.33, 0
4880, 0.6, 0.345, 0
4881, 0.5875, 0.36, 0
4882, 0.6, 0.375, 0
4883, 0.5875, 0.39, 0
4884, 0.6, 0.405, 0
4885, 0.5875, 0.42, 0
4886, 0.6, 0.435, 0
4887, 0.5875, 0.45, 0
4888, 0.6, 0.465, 0
4889, 0.5875, 0.48, 0
4890, 0.6, 0.495, 0
4891, 0.5875, 0.51, 0
4892, 0.6, 0.525, 0
4893, 0.5875, 0.54, 0
4894, 0.6, 0.555, 0
4895, 0.5875, 0.57, 0
4896, 0.6, 0.585, 0
4897, 0.5875, 0.6, 0
4898, 0.6, 0.615, 0
4899, 0.5875, 0.63, 0
4900, 0.6, 0.645, 0
4901, 0.5875, 0.66, 0
4902, 0.6, 0.675, 0
4903, 0.5875, 0.69, 0
4904, 0.6, 0.705, 0
4905, 0.5875, 0.72, 0
4906, 0.6, 0.735, 0
4907, 0.5875, 0.75, 0
4908, 0.6, 0.765, 0
4909, 0.5875, 0.78, 0
4910, 0.6, 0.795, 0
4911, 0.5875, 0.81, 0
4912, 0.6, 0.825, 0
4913, 0.5875, 0.84, 0
4914, 0.6, 0.855, 0
4915, 0.5875, 0.87, 0
4916, 0.6, 0.885, 0
4917, 0.5875, 0.9, 0
4918, 0.6, 0.915, 0
4919, 0.5875, 0.93, 0
