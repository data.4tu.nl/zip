2379, 180, 1887, 1888, 181
2380, 181, 1888, 1889, 182
2381, 182, 1889, 1890, 183
2382, 183, 1890, 1891, 184
2383, 184, 1891, 1892, 185
2384, 185, 1892, 1893, 186
2385, 186, 1893, 1894, 187
2386, 187, 1894, 1895, 188
2387, 188, 1895, 1896, 189
2388, 189, 1896, 1897, 190
2389, 190, 1897, 1898, 191
2390, 191, 1898, 557, 10
2391, 553, 554, 1899, 1880
2392, 1880, 1899, 1900, 1881
2393, 1881, 1900, 1901, 1882
2394, 1882, 1901, 1902, 1883
2395, 1883, 1902, 1903, 1884
2396, 1884, 1903, 1904, 1885
2397, 1885, 1904, 1905, 1886
2398, 1886, 1905, 1906, 1887
2399, 1887, 1906, 1907, 1888
2400, 1888, 1907, 1908, 1889
2401, 1889, 1908, 1909, 1890
2402, 1890, 1909, 1910, 1891
2403, 1891, 1910, 1911, 1892
2404, 1892, 1911, 1912, 1893
2405, 1893, 1912, 1913, 1894
2406, 1894, 1913, 1914, 1895
2407, 1895, 1914, 1915, 1896
2408, 1896, 1915, 1916, 1897
2409, 1897, 1916, 1917, 1898
2410, 1898, 1917, 558, 557
2411, 554, 555, 1918, 1899
2412, 1899, 1918, 1919, 1900
2413, 1900, 1919, 1920, 1901
2414, 1901, 1920, 1921, 1902
2415, 1902, 1921, 1922, 1903
2416, 1903, 1922, 1923, 1904
2417, 1904, 1923, 1924, 1905
2418, 1905, 1924, 1925, 1906
2419, 1906, 1925, 1926, 1907
2420, 1907, 1926, 1927, 1908
2421, 1908, 1927, 1928, 1909
2422, 1909, 1928, 1929, 1910
2423, 1910, 1929, 1930, 1911
2424, 1911, 1930, 1931, 1912
2425, 1912, 1931, 1932, 1913
2426, 1913, 1932, 1933, 1914
2427, 1914, 1933, 1934, 1915
2428, 1915, 1934, 1935, 1916
2429, 1916, 1935, 1936, 1917
2430, 1917, 1936, 559, 558
2431, 555, 556, 1937, 1918
2432, 1918, 1937, 1938, 1919
2433, 1919, 1938, 1939, 1920
2434, 1920, 1939, 1940, 1921
2435, 1921, 1940, 1941, 1922
2436, 1922, 1941, 1942, 1923
2437, 1923, 1942, 1943, 1924
2438, 1924, 1943, 1944, 1925
2439, 1925, 1944, 1945, 1926
2440, 1926, 1945, 1946, 1927
2441, 1927, 1946, 1947, 1928
2442, 1928, 1947, 1948, 1929
2443, 1929, 1948, 1949, 1930
2444, 1930, 1949, 1950, 1931
2445, 1931, 1950, 1951, 1932
2446, 1932, 1951, 1952, 1933
2447, 1933, 1952, 1953, 1934
2448, 1934, 1953, 1954, 1935
2449, 1935, 1954, 1955, 1936
2450, 1936, 1955, 560, 559
2451, 556, 43, 561, 1937
2452, 1937, 561, 562, 1938
2453, 1938, 562, 563, 1939
2454, 1939, 563, 564, 1940
2455, 1940, 564, 565, 1941
2456, 1941, 565, 566, 1942
2457, 1942, 566, 567, 1943
2458, 1943, 567, 568, 1944
2459, 1944, 568, 569, 1945
2460, 1945, 569, 570, 1946
2461, 1946, 570, 571, 1947
2462, 1947, 571, 572, 1948
2463, 1948, 572, 573, 1949
2464, 1949, 573, 574, 1950
2465, 1950, 574, 575, 1951
2466, 1951, 575, 576, 1952
2467, 1952, 576, 577, 1953
2468, 1953, 577, 578, 1954
2469, 1954, 578, 579, 1955
2470, 1955, 579, 44, 560
*ELEMENT, type=CPS4, ELSET=Surface23
2471, 9, 553, 1956, 195
2472, 195, 1956, 1957, 196
2473, 196, 1957, 1958, 197
2474, 197, 1958, 580, 12
2475, 553, 554, 1959, 1956
2476, 1956, 1959, 1960, 1957
2477, 1957, 1960, 1961, 1958
2478, 1958, 1961, 581, 580
2479, 554, 555, 1962, 1959
2480, 1959, 1962, 1963, 1960
2481, 1960, 1963, 1964, 1961
2482, 1961, 1964, 582, 581
2483, 555, 556, 1965, 1962
2484, 1962, 1965, 1966, 1963
2485, 1963, 1966, 1967, 1964
2486, 1964, 1967, 583, 582
2487, 556, 43, 584, 1965
2488, 1965, 584, 585, 1966
2489, 1966, 585, 586, 1967
2490, 1967, 586, 45, 583
*ELEMENT, type=CPS4, ELSET=Surface24
2491, 12, 580, 1968, 219
2492, 219, 1968, 1969, 220
2493, 220, 1969, 1970, 221
2494, 221, 1970, 1971, 222
2495, 222, 1971, 1972, 223
2496, 223, 1972, 1973, 224
2497, 224, 1973, 1974, 225
2498, 225, 1974, 1975, 226
2499, 226, 1975, 1976, 227
2500, 227, 1976, 1977, 228
2501, 228, 1977, 1978, 229
2502, 229, 1978, 1979, 230
2503, 230, 1979, 1980, 231
2504, 231, 1980, 1981, 232
2505, 232, 1981, 1982, 233
2506, 233, 1982, 1983, 234
2507, 234, 1983, 1984, 235
2508, 235, 1984, 1985, 236
2509, 236, 1985, 1986, 237
2510, 237, 1986, 587, 14
2511, 580, 581, 1987, 1968
2512, 1968, 1987, 1988, 1969
2513, 1969, 1988, 1989, 1970
2514, 1970, 1989, 1990, 1971
2515, 1971, 1990, 1991, 1972
2516, 1972, 1991, 1992, 1973
2517, 1973, 1992, 1993, 1974
2518, 1974, 1993, 1994, 1975
2519, 1975, 1994, 1995, 1976
2520, 1976, 1995, 1996, 1977
2521, 1977, 1996, 1997, 1978
2522, 1978, 1997, 1998, 1979
2523, 1979, 1998, 1999, 1980
2524, 1980, 1999, 2000, 1981
2525, 1981, 2000, 2001, 1982
2526, 1982, 2001, 2002, 1983
2527, 1983, 2002, 2003, 1984
2528, 1984, 2003, 2004, 1985
2529, 1985, 2004, 2005, 1986
2530, 1986, 2005, 588, 587
2531, 581, 582, 2006, 1987
2532, 1987, 2006, 2007, 1988
2533, 1988, 2007, 2008, 1989
2534, 1989, 2008, 2009, 1990
2535, 1990, 2009, 2010, 1991
2536, 1991, 2010, 2011, 1992
2537, 1992, 2011, 2012, 1993
2538, 1993, 2012, 2013, 1994
2539, 1994, 2013, 2014, 1995
2540, 1995, 2014, 2015, 1996
2541, 1996, 2015, 2016, 1997
2542, 1997, 2016, 2017, 1998
2543, 1998, 2017, 2018, 1999
2544, 1999, 2018, 2019, 2000
2545, 2000, 2019, 2020, 2001
2546, 2001, 2020, 2021, 2002
2547, 2002, 2021, 2022, 2003
2548, 2003, 2022, 2023, 2004
2549, 2004, 2023, 2024, 2005
2550, 2005, 2024, 589, 588
2551, 582, 583, 2025, 2006
2552, 2006, 2025, 2026, 2007
2553, 2007, 2026, 2027, 2008
2554, 2008, 2027, 2028, 2009
2555, 2009, 2028, 2029, 2010
2556, 2010, 2029, 2030, 2011
2557, 2011, 2030, 2031, 2012
2558, 2012, 2031, 2032, 2013
2559, 2013, 2032, 2033, 2014
2560, 2014, 2033, 2034, 2015
2561, 2015, 2034, 2035, 2016
2562, 2016, 2035, 2036, 2017
2563, 2017, 2036, 2037, 2018
2564, 2018, 2037, 2038, 2019
2565, 2019, 2038, 2039, 2020
2566, 2020, 2039, 2040, 2021
2567, 2021, 2040, 2041, 2022
2568, 2022, 2041, 2042, 2023
2569, 2023, 2042, 2043, 2024
2570, 2024, 2043, 590, 589
2571, 583, 45, 591, 2025
2572, 2025, 591, 592, 2026
2573, 2026, 592, 593, 2027
2574, 2027, 593, 594, 2028
2575, 2028, 594, 595, 2029
2576, 2029, 595, 596, 2030
2577, 2030, 596, 597, 2031
2578, 2031, 597, 598, 2032
2579, 2032, 598, 599, 2033
2580, 2033, 599, 600, 2034
2581, 2034, 600, 601, 2035
2582, 2035, 601, 602, 2036
2583, 2036, 602, 603, 2037
2584, 2037, 603, 604, 2038
2585, 2038, 604, 605, 2039
2586, 2039, 605, 606, 2040
2587, 2040, 606, 607, 2041
2588, 2041, 607, 608, 2042
2589, 2042, 608, 609, 2043
2590, 2043, 609, 46, 590
*ELEMENT, type=CPS4, ELSET=Surface25
2591, 4, 610, 2044, 108
2592, 108, 2044, 2045, 109
2593, 109, 2045, 2046, 110
2594, 110, 2046, 2047, 111
2595, 111, 2047, 2048, 112
2596, 112, 2048, 2049, 113
2597, 113, 2049, 2050, 114
2598, 114, 2050, 2051, 115
2599, 115, 2051, 2052, 116
2600, 116, 2052, 2053, 117
2601, 117, 2053, 2054, 118
2602, 118, 2054, 2055, 119
2603, 119, 2055, 2056, 120
2604, 120, 2056, 2057, 121
2605, 121, 2057, 2058, 122
2606, 122, 2058, 2059, 123
2607, 123, 2059, 2060, 124
2608, 124, 2060, 2061, 125
2609, 125, 2061, 2062, 126
2610, 126, 2062, 613, 1
2611, 610, 611, 2063, 2044
2612, 2044, 2063, 2064, 2045
2613, 2045, 2064, 2065, 2046
2614, 2046, 2065, 2066, 2047
2615, 2047, 2066, 2067, 2048
2616, 2048, 2067, 2068, 2049
2617, 2049, 2068, 2069, 2050
2618, 2050, 2069, 2070, 2051
2619, 2051, 2070, 2071, 2052
2620, 2052, 2071, 2072, 2053
2621, 2053, 2072, 2073, 2054
2622, 2054, 2073, 2074, 2055
2623, 2055, 2074, 2075, 2056
2624, 2056, 2075, 2076, 2057
2625, 2057, 2076, 2077, 2058
2626, 2058, 2077, 2078, 2059
2627, 2059, 2078, 2079, 2060
2628, 2060, 2079, 2080, 2061
2629, 2061, 2080, 2081, 2062
2630, 2062, 2081, 614, 613
2631, 611, 612, 2082, 2063
2632, 2063, 2082, 2083, 2064
2633, 2064, 2083, 2084, 2065
2634, 2065, 2084, 2085, 2066
2635, 2066, 2085, 2086, 2067
2636, 2067, 2086, 2087, 2068
2637, 2068, 2087, 2088, 2069
2638, 2069, 2088, 2089, 2070
2639, 2070, 2089, 2090, 2071
2640, 2071, 2090, 2091, 2072
2641, 2072, 2091, 2092, 2073
2642, 2073, 2092, 2093, 2074
2643, 2074, 2093, 2094, 2075
2644, 2075, 2094, 2095, 2076
2645, 2076, 2095, 2096, 2077
2646, 2077, 2096, 2097, 2078
2647, 2078, 2097, 2098, 2079
2648, 2079, 2098, 2099, 2080
2649, 2080, 2099, 2100, 2081
2650, 2081, 2100, 615, 614
2651, 612, 47, 616, 2082
2652, 2082, 616, 617, 2083
2653, 2083, 617, 618, 2084
2654, 2084, 618, 619, 2085
2655, 2085, 619, 620, 2086
2656, 2086, 620, 621, 2087
2657, 2087, 621, 622, 2088
2658, 2088, 622, 623, 2089
2659, 2089, 623, 624, 2090
2660, 2090, 624, 625, 2091
2661, 2091, 625, 626, 2092
2662, 2092, 626, 627, 2093
2663, 2093, 627, 628, 2094
2664, 2094, 628, 629, 2095
2665, 2095, 629, 630, 2096
2666, 2096, 630, 631, 2097
2667, 2097, 631, 632, 2098
2668, 2098, 632, 633, 2099
2669, 2099, 633, 634, 2100
2670, 2100, 634, 48, 615
*ELEMENT, type=CPS4, ELSET=Surface26
2671, 18, 635, 2101, 301
2672, 301, 2101, 2102, 302
2673, 302, 2102, 2103, 303
2674, 303, 2103, 2104, 304
2675, 304, 2104, 2105, 305
2676, 305, 2105, 2106, 306
2677, 306, 2106, 2107, 307
2678, 307, 2107, 2108, 308
2679, 308, 2108, 2109, 309
2680, 309, 2109, 2110, 310
2681, 310, 2110, 2111, 311
2682, 311, 2111, 2112, 312
2683, 312, 2112, 2113, 313
2684, 313, 2113, 2114, 314
2685, 314, 2114, 2115, 315
2686, 315, 2115, 2116, 316
2687, 316, 2116, 2117, 317
2688, 317, 2117, 2118, 318
2689, 318, 2118, 2119, 319
2690, 319, 2119, 638, 20
2691, 635, 636, 2120, 2101
2692, 2101, 2120, 2121, 2102
2693, 2102, 2121, 2122, 2103
2694, 2103, 2122, 2123, 2104
2695, 2104, 2123, 2124, 2105
2696, 2105, 2124, 2125, 2106
2697, 2106, 2125, 2126, 2107
2698, 2107, 2126, 2127, 2108
2699, 2108, 2127, 2128, 2109
2700, 2109, 2128, 2129, 2110
2701, 2110, 2129, 2130, 2111
2702, 2111, 2130, 2131, 2112
2703, 2112, 2131, 2132, 2113
2704, 2113, 2132, 2133, 2114
2705, 2114, 2133, 2134, 2115
2706, 2115, 2134, 2135, 2116
2707, 2116, 2135, 2136, 2117
2708, 2117, 2136, 2137, 2118
2709, 2118, 2137, 2138, 2119
2710, 2119, 2138, 639, 638
2711, 636, 637, 2139, 2120
2712, 2120, 2139, 2140, 2121
2713, 2121, 2140, 2141, 2122
2714, 2122, 2141, 2142, 2123
2715, 2123, 2142, 2143, 2124
2716, 2124, 2143, 2144, 2125
2717, 2125, 2144, 2145, 2126
2718, 2126, 2145, 2146, 2127
2719, 2127, 2146, 2147, 2128
2720, 2128, 2147, 2148, 2129
2721, 2129, 2148, 2149, 2130
2722, 2130, 2149, 2150, 2131
2723, 2131, 2150, 2151, 2132
2724, 2132, 2151, 2152, 2133
2725, 2133, 2152, 2153, 2134
2726, 2134, 2153, 2154, 2135
2727, 2135, 2154, 2155, 2136
2728, 2136, 2155, 2156, 2137
2729, 2137, 2156, 2157, 2138
2730, 2138, 2157, 640, 639
2731, 637, 49, 641, 2139
2732, 2139, 641, 642, 2140
2733, 2140, 642, 643, 2141
2734, 2141, 643, 644, 2142
2735, 2142, 644, 645, 2143
2736, 2143, 645, 646, 2144
2737, 2144, 646, 647, 2145
2738, 2145, 647, 648, 2146
2739, 2146, 648, 649, 2147
2740, 2147, 649, 650, 2148
2741, 2148, 650, 651, 2149
2742, 2149, 651, 652, 2150
2743, 2150, 652, 653, 2151
2744, 2151, 653, 654, 2152
2745, 2152, 654, 655, 2153
2746, 2153, 655, 656, 2154
2747, 2154, 656, 657, 2155
2748, 2155, 657, 658, 2156
2749, 2156, 658, 659, 2157
2750, 2157, 659, 50, 640
*ELSET,ELSET=Ceramic_Bottom
547, 548, 549, 550, 556, 557, 558, 559, 560, 561, 
562, 563, 564, 565, 566, 567, 568, 569, 570, 571, 
572, 573, 574, 575, 586, 587, 588, 589, 590, 591, 
592, 593, 594, 595, 596, 597, 598, 599, 600, 601, 
602, 603, 604, 605, 611, 612, 613, 614, 
*ELSET,ELSET=Ceramic_Top
625, 626, 627, 628, 629, 630, 631, 632, 633, 634, 
635, 636, 637, 638, 639, 640, 641, 642, 643, 644, 
650, 651, 652, 653, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 
*ELSET,ELSET=Electrode_MaxX
534, 535, 536, 
*ELSET,ELSET=Electrode_MinX
523, 524, 525, 
*ELSET,ELSET=Contact_Ceramic
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
209, 210, 211, 212, 236, 237, 238, 239, 240, 241, 
242, 243, 244, 245, 246, 247, 248, 249, 250, 251, 
252, 253, 254, 255, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 519, 520, 521, 522, 530, 531, 
532, 533, 
*ELSET,ELSET=SemiconductorL
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 1875, 1876, 
1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 1885, 1886, 
1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 1895, 1896, 
1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 1905, 1906, 
2591, 2592, 2593, 2594, 2595, 2596, 2597, 2598, 2599, 2600, 
2601, 2602, 2603, 2604, 2605, 2606, 2607, 2608, 2609, 2610, 
2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 2619, 2620, 
2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 2629, 2630, 
2631, 2632, 2633, 2634, 2635, 2636, 2637, 2638, 2639, 2640, 
2641, 2642, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 2650, 
2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 2660, 
2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 2670, 
*ELSET,ELSET=SemiconductorR
1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 1396, 
1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 1406, 
1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 1416, 
1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 1426, 
1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 1435, 1436, 
1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 1445, 1446, 
1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 1455, 1456, 
1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 1465, 1466, 
1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 1475, 1476, 
1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 1485, 1486, 
1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 1495, 1496, 
1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 
1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 
1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 1565, 1566, 
1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 
1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 1585, 1586, 
1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 1595, 1596, 
1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 
1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 
1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 1635, 1636, 
1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 1645, 1646, 
1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 1655, 1656, 
1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 
1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 1675, 1676, 
1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 
1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 
1697, 1698, 1699, 1700, 1701, 1702, 1703, 1704, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 1739, 1740, 1741, 1742, 1743, 1744, 1745, 1746, 
1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 
1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 
1767, 1768, 1769, 1770, 1771, 1772, 1773, 1774, 1775, 1776, 
1777, 1778, 1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 
1787, 1788, 1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 
1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 
1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 1815, 1816, 
1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 1825, 1826, 
1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 1835, 1836, 
1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 1845, 1846, 
1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 
1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 
2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 2680, 
2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 2690, 
2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 2700, 
2701, 2702, 2703, 2704, 2705, 2706, 2707, 2708, 2709, 2710, 
2711, 2712, 2713, 2714, 2715, 2716, 2717, 2718, 2719, 2720, 
2721, 2722, 2723, 2724, 2725, 2726, 2727, 2728, 2729, 2730, 
2731, 2732, 2733, 2734, 2735, 2736, 2737, 2738, 2739, 2740, 
2741, 2742, 2743, 2744, 2745, 2746, 2747, 2748, 2749, 2750, 
*ELSET,ELSET=Solder
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 1355, 1356, 
1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 1366, 
1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 1376, 
1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 1386, 
1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 1915, 1916, 
1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 1925, 1926, 
1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 1935, 1936, 
1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 1945, 1946, 
1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 1955, 1956, 
1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 
1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 
1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 1985, 1986, 
*ELSET,ELSET=Copper
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 
*ELSET,ELSET=Ceramic
2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 
2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 
2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 
2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 
2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 
2181, 2182, 2183, 2184, 2185, 2186, 2187, 2188, 2189, 2190, 
2191, 2192, 2193, 2194, 2195, 2196, 2197, 2198, 2199, 2200, 
2201, 2202, 2203, 2204, 2205, 2206, 2207, 2208, 2209, 2210, 
2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 
2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 
2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 
2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 
2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 
2261, 2262, 2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 
2271, 2272, 2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 2499, 2500, 
2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 2509, 2510, 
2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 2519, 2520, 
2521, 2522, 2523, 2524, 2525, 2526, 2527, 2528, 2529, 2530, 
2531, 2532, 2533, 2534, 2535, 2536, 2537, 2538, 2539, 2540, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2586, 2587, 2588, 2589, 2590, 
*ELSET,ELSET=Surface
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 
1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 
1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 
1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 
1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 
1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 
1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 
1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 
1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 
1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 
1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 
1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 
1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 
1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 
1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 
1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 
1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 
1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 
1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 
1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 
1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 
1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 
1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 
1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 
1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 
1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 
1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 
1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 
1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 
1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 
1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 
1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 
1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 
1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 
1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 
1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 1703, 1704, 
1705, 1706, 1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 
1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 
1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 
1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 1743, 1744, 
1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 
1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 
1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 1773, 1774, 
1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 1783, 1784, 
1785, 1786, 1787, 1788, 1789, 1790, 1791, 1792, 1793, 1794, 
1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 
1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 
1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 
1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 
1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 
1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 
1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 
1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 
1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 
1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 
1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 
1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 
1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 
1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
1945, 1946, 1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 
1955, 1956, 1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 
1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 
1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 
1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 2243, 2244, 
2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 2253, 2254, 
2255, 2256, 2257, 2258, 2259, 2260, 2261, 2262, 2263, 2264, 
2265, 2266, 2267, 2268, 2269, 2270, 2271, 2272, 2273, 2274, 
2275, 2276, 2277, 2278, 2279, 2280, 2281, 2282, 2283, 2284, 
2285, 2286, 2287, 2288, 2289, 2290, 2291, 2292, 2293, 2294, 
2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 2304, 
2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 2314, 
2315, 2316, 2317, 2318, 2319, 2320, 2321, 2322, 2323, 2324, 
2325, 2326, 2327, 2328, 2329, 2330, 2331, 2332, 2333, 2334, 
2335, 2336, 2337, 2338, 2339, 2340, 2341, 2342, 2343, 2344, 
2345, 2346, 2347, 2348, 2349, 2350, 2351, 2352, 2353, 2354, 
2355, 2356, 2357, 2358, 2359, 2360, 2361, 2362, 2363, 2364, 
2365, 2366, 2367, 2368, 2369, 2370, 2371, 2372, 2373, 2374, 
2375, 2376, 2377, 2378, 2379, 2380, 2381, 2382, 2383, 2384, 
2385, 2386, 2387, 2388, 2389, 2390, 2391, 2392, 2393, 2394, 
2395, 2396, 2397, 2398, 2399, 2400, 2401, 2402, 2403, 2404, 
2405, 2406, 2407, 2408, 2409, 2410, 2411, 2412, 2413, 2414, 
2415, 2416, 2417, 2418, 2419, 2420, 2421, 2422, 2423, 2424, 
2425, 2426, 2427, 2428, 2429, 2430, 2431, 2432, 2433, 2434, 
2435, 2436, 2437, 2438, 2439, 2440, 2441, 2442, 2443, 2444, 
2445, 2446, 2447, 2448, 2449, 2450, 2451, 2452, 2453, 2454, 
2455, 2456, 2457, 2458, 2459, 2460, 2461, 2462, 2463, 2464, 
2465, 2466, 2467, 2468, 2469, 2470, 2471, 2472, 2473, 2474, 
2475, 2476, 2477, 2478, 2479, 2480, 2481, 2482, 2483, 2484, 
2485, 2486, 2487, 2488, 2489, 2490, 2491, 2492, 2493, 2494, 
2495, 2496, 2497, 2498, 2499, 2500, 2501, 2502, 2503, 2504, 
2505, 2506, 2507, 2508, 2509, 2510, 2511, 2512, 2513, 2514, 
2515, 2516, 2517, 2518, 2519, 2520, 2521, 2522, 2523, 2524, 
2525, 2526, 2527, 2528, 2529, 2530, 2531, 2532, 2533, 2534, 
2535, 2536, 2537, 2538, 2539, 2540, 2541, 2542, 2543, 2544, 
2545, 2546, 2547, 2548, 2549, 2550, 2551, 2552, 2553, 2554, 
2555, 2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 
2565, 2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 
2575, 2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 
2585, 2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 
2595, 2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 2604, 
2605, 2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 2614, 
2615, 2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 2624, 
2625, 2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 2634, 
2635, 2636, 2637, 2638, 2639, 2640, 2641, 2642, 2643, 2644, 
2645, 2646, 2647, 2648, 2649, 2650, 2651, 2652, 2653, 2654, 
2655, 2656, 2657, 2658, 2659, 2660, 2661, 2662, 2663, 2664, 
2665, 2666, 2667, 2668, 2669, 2670, 2671, 2672, 2673, 2674, 
2675, 2676, 2677, 2678, 2679, 2680, 2681, 2682, 2683, 2684, 
2685, 2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 
2695, 2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 
2705, 2706, 2707, 2708, 2709, 2710, 2711, 2712, 2713, 2714, 
2715, 2716, 2717, 2718, 2719, 2720, 2721, 2722, 2723, 2724, 
2725, 2726, 2727, 2728, 2729, 2730, 2731, 2732, 2733, 2734, 
2735, 2736, 2737, 2738, 2739, 2740, 2741, 2742, 2743, 2744, 
2745, 2746, 2747, 2748, 2749, 2750, 
*ELSET,ELSET=TO
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 1396, 
1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 1406, 
1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 1416, 
1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 1426, 
1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 1435, 1436, 
1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 1445, 1446, 
1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 1455, 1456, 
1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 1465, 1466, 
1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 1475, 1476, 
1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 1485, 1486, 
1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 1495, 1496, 
1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 
1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 
1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 1565, 1566, 
1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 
1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 1585, 1586, 
1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 1595, 1596, 
1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 1605, 1606, 
1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 1615, 1616, 
1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 1625, 1626, 
1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 1635, 1636, 
1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 1645, 1646, 
1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 1655, 1656, 
1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 1665, 1666, 
1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 1675, 1676, 
1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 
1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 
1697, 1698, 1699, 1700, 1701, 1702, 1703, 1704, 1705, 1706, 
1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 
1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 
1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 1735, 1736, 
1737, 1738, 1739, 1740, 1741, 1742, 1743, 1744, 1745, 1746, 
1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 1755, 1756, 
1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 1765, 1766, 
1767, 1768, 1769, 1770, 1771, 1772, 1773, 1774, 1775, 1776, 
1777, 1778, 1779, 1780, 1781, 1782, 1783, 1784, 1785, 1786, 
1787, 1788, 1789, 1790, 1791, 1792, 1793, 1794, 1795, 1796, 
1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 
1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 1815, 1816, 
1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 1825, 1826, 
1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 1835, 1836, 
1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 1845, 1846, 
1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 1855, 1856, 
1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 1865, 1866, 
1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 1875, 1876, 
1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 1885, 1886, 
1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 1895, 1896, 
1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 1905, 1906, 
2591, 2592, 2593, 2594, 2595, 2596, 2597, 2598, 2599, 2600, 
2601, 2602, 2603, 2604, 2605, 2606, 2607, 2608, 2609, 2610, 
2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 2619, 2620, 
2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 2629, 2630, 
2631, 2632, 2633, 2634, 2635, 2636, 2637, 2638, 2639, 2640, 
2641, 2642, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 2650, 
2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 2660, 
2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 2670, 
2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 2680, 
2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 2690, 
2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 2700, 
2701, 2702, 2703, 2704, 2705, 2706, 2707, 2708, 2709, 2710, 
2711, 2712, 2713, 2714, 2715, 2716, 2717, 2718, 2719, 2720, 
2721, 2722, 2723, 2724, 2725, 2726, 2727, 2728, 2729, 2730, 
2731, 2732, 2733, 2734, 2735, 2736, 2737, 2738, 2739, 2740, 
2741, 2742, 2743, 2744, 2745, 2746, 2747, 2748, 2749, 2750, 
*ELSET,ELSET=Surface1
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 
1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 
1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 
1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 
1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 
1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 
1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 
1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 
1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 
1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 
1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 
1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 
1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 
1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 
1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 
1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 
1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 
1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 
1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 
1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 
1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 
1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 
1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 
1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 
1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 
1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 
1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 
1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 
1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 
1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 
1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 
1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 
1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 
1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 
1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 
1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 1703, 1704, 
1705, 1706, 1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 
1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 
1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 
1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 1743, 1744, 
1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 
1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 
1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 1773, 1774, 
1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 1783, 1784, 
1785, 1786, 1787, 1788, 1789, 1790, 1791, 1792, 1793, 1794, 
1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 
1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 
1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 
1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 
1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 
1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 
1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 
1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 
1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 
1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 
1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 
1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 
1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 
1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
1945, 1946, 1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 
1955, 1956, 1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 
1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 
1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 
1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 2073, 2074, 
2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 2083, 2084, 
2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 2093, 2094, 
2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 2103, 2104, 
2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 2113, 2114, 
2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 2123, 2124, 
2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 2133, 2134, 
2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 2143, 2144, 
2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 2153, 2154, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 2183, 2184, 
2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 2193, 2194, 
2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 2203, 2204, 
2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 
2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 
2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 
2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 2243, 2244, 
2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 2253, 2254, 
2255, 2256, 2257, 2258, 2259, 2260, 2261, 2262, 2263, 2264, 
2265, 2266, 2267, 2268, 2269, 2270, 2271, 2272, 2273, 2274, 
2275, 2276, 2277, 2278, 2279, 2280, 2281, 2282, 2283, 2284, 
2285, 2286, 2287, 2288, 2289, 2290, 2291, 2292, 2293, 2294, 
2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 2304, 
2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 2314, 
2315, 2316, 2317, 2318, 2319, 2320, 2321, 2322, 2323, 2324, 
2325, 2326, 2327, 2328, 2329, 2330, 2331, 2332, 2333, 2334, 
2335, 2336, 2337, 2338, 2339, 2340, 2341, 2342, 2343, 2344, 
2345, 2346, 2347, 2348, 2349, 2350, 2351, 2352, 2353, 2354, 
2355, 2356, 2357, 2358, 2359, 2360, 2361, 2362, 2363, 2364, 
2365, 2366, 2367, 2368, 2369, 2370, 2371, 2372, 2373, 2374, 
2375, 2376, 2377, 2378, 2379, 2380, 2381, 2382, 2383, 2384, 
2385, 2386, 2387, 2388, 2389, 2390, 2391, 2392, 2393, 2394, 
2395, 2396, 2397, 2398, 2399, 2400, 2401, 2402, 2403, 2404, 
2405, 2406, 2407, 2408, 2409, 2410, 2411, 2412, 2413, 2414, 
2415, 2416, 2417, 2418, 2419, 2420, 2421, 2422, 2423, 2424, 
2425, 2426, 2427, 2428, 2429, 2430, 2431, 2432, 2433, 2434, 
2435, 2436, 2437, 2438, 2439, 2440, 2441, 2442, 2443, 2444, 
2445, 2446, 2447, 2448, 2449, 2450, 2451, 2452, 2453, 2454, 
2455, 2456, 2457, 2458, 2459, 2460, 2461, 2462, 2463, 2464, 
2465, 2466, 2467, 2468, 2469, 2470, 2471, 2472, 2473, 2474, 
2475, 2476, 2477, 2478, 2479, 2480, 2481, 2482, 2483, 2484, 
2485, 2486, 2487, 2488, 2489, 2490, 2491, 2492, 2493, 2494, 
2495, 2496, 2497, 2498, 2499, 2500, 2501, 2502, 2503, 2504, 
2505, 2506, 2507, 2508, 2509, 2510, 2511, 2512, 2513, 2514, 
2515, 2516, 2517, 2518, 2519, 2520, 2521, 2522, 2523, 2524, 
2525, 2526, 2527, 2528, 2529, 2530, 2531, 2532, 2533, 2534, 
2535, 2536, 2537, 2538, 2539, 2540, 2541, 2542, 2543, 2544, 
2545, 2546, 2547, 2548, 2549, 2550, 2551, 2552, 2553, 2554, 
2555, 2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 
2565, 2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 
2575, 2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 
2585, 2586, 2587, 2588, 2589, 2590, 
*NSET,NSET=Ceramic_Bottom
37, 38, 39, 40, 41, 42, 493, 494, 495, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 527, 528, 
529, 530, 531, 532, 533, 534, 535, 536, 537, 538, 
539, 540, 541, 542, 543, 544, 545, 550, 551, 552, 
*NSET,NSET=Ceramic_Top
43, 44, 45, 46, 561, 562, 563, 564, 565, 566, 
567, 568, 569, 570, 571, 572, 573, 574, 575, 576, 
577, 578, 579, 584, 585, 586, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 
*NSET,NSET=Electrode_MaxX
35, 36, 483, 484, 
*NSET,NSET=Electrode_MinX
33, 34, 475, 476, 
*NSET,NSET=Contact_Ceramic
9, 10, 12, 14, 29, 30, 31, 32, 34, 36, 
173, 174, 175, 176, 177, 178, 179, 180, 181, 182, 
183, 184, 185, 186, 187, 188, 189, 190, 191, 195, 
196, 197, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 427, 428, 429, 430, 431, 432, 433, 434, 435, 
436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 
450, 451, 452, 453, 454, 455, 456, 457, 458, 459, 
460, 461, 462, 463, 464, 465, 466, 467, 468, 472, 
473, 474, 480, 481, 482, 
*NSET,NSET=SemiconductorL
1, 2, 3, 4, 5, 6, 23, 24, 47, 48, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 360, 361, 362, 
363, 364, 365, 366, 367, 368, 369, 370, 371, 372, 
373, 374, 375, 376, 377, 378, 379, 380, 610, 611, 
612, 613, 614, 615, 616, 617, 618, 619, 620, 621, 
622, 623, 624, 625, 626, 627, 628, 629, 630, 631, 
632, 633, 634, 660, 661, 662, 663, 664, 665, 666, 
667, 668, 669, 670, 671, 672, 673, 674, 675, 676, 
677, 678, 679, 680, 681, 682, 683, 684, 685, 686, 
687, 688, 689, 690, 691, 692, 693, 694, 695, 696, 
697, 698, 699, 700, 701, 702, 703, 704, 705, 706, 
707, 708, 709, 710, 711, 712, 713, 714, 715, 716, 
717, 718, 719, 720, 721, 722, 723, 724, 725, 726, 
727, 728, 729, 730, 731, 732, 733, 734, 735, 736, 
737, 738, 739, 740, 741, 742, 743, 744, 745, 746, 
747, 748, 749, 750, 751, 752, 753, 754, 755, 756, 
757, 758, 759, 760, 761, 762, 763, 764, 765, 766, 
767, 768, 769, 770, 771, 772, 773, 774, 775, 776, 
777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 
787, 788, 789, 790, 791, 792, 793, 794, 795, 796, 
797, 798, 799, 800, 801, 802, 803, 804, 805, 806, 
807, 808, 809, 810, 811, 812, 813, 814, 815, 816, 
817, 818, 819, 820, 821, 822, 823, 824, 825, 826, 
827, 828, 829, 830, 831, 832, 833, 834, 835, 836, 
837, 838, 839, 840, 841, 842, 843, 844, 845, 846, 
847, 848, 849, 850, 851, 852, 853, 854, 855, 856, 
857, 858, 859, 860, 861, 862, 863, 864, 865, 866, 
867, 868, 869, 870, 871, 872, 873, 874, 875, 876, 
877, 878, 879, 880, 881, 882, 883, 884, 885, 886, 
887, 888, 889, 890, 891, 892, 893, 894, 895, 896, 
897, 898, 899, 900, 901, 902, 903, 904, 905, 906, 
907, 908, 909, 910, 911, 912, 913, 914, 915, 916, 
917, 918, 919, 920, 921, 922, 923, 924, 925, 926, 
927, 928, 929, 930, 931, 932, 933, 934, 935, 936, 
937, 938, 939, 940, 941, 942, 943, 944, 945, 946, 
947, 948, 949, 950, 951, 952, 953, 954, 955, 956, 
957, 958, 959, 960, 961, 962, 963, 964, 965, 966, 
967, 968, 969, 970, 971, 972, 973, 974, 975, 976, 
977, 978, 979, 980, 981, 982, 983, 984, 985, 986, 
987, 988, 989, 990, 991, 992, 993, 994, 995, 996, 
997, 998, 999, 1000, 1001, 1002, 1003, 1004, 1005, 1006, 
1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 1015, 1016, 
1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 1025, 1026, 
1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 1035, 1036, 
1037, 1038, 1039, 1559, 1560, 1561, 1562, 1563, 1564, 1565, 
1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 
1576, 1577, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 
2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 2061, 
2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 2071, 
2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 2081, 
2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 2091, 
2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
*NSET,NSET=SemiconductorR
15, 16, 17, 18, 19, 20, 21, 22, 49, 50, 
242, 243, 244, 245, 246, 247, 248, 249, 250, 251, 
252, 253, 254, 255, 256, 257, 258, 259, 260, 261, 
262, 263, 264, 265, 266, 267, 268, 269, 270, 271, 
272, 273, 274, 275, 276, 277, 278, 279, 280, 281, 
282, 283, 284, 285, 286, 287, 288, 289, 290, 291, 
292, 293, 294, 295, 296, 297, 298, 299, 300, 301, 
302, 303, 304, 305, 306, 307, 308, 309, 310, 311, 
312, 313, 314, 315, 316, 317, 318, 319, 320, 321, 
322, 323, 324, 325, 326, 327, 328, 329, 330, 331, 
332, 333, 334, 335, 336, 337, 338, 339, 340, 341, 
342, 343, 344, 345, 346, 347, 348, 349, 350, 351, 
352, 353, 354, 355, 356, 357, 358, 359, 635, 636, 
637, 638, 639, 640, 641, 642, 643, 644, 645, 646, 
647, 648, 649, 650, 651, 652, 653, 654, 655, 656, 
657, 658, 659, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 
1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 
1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 1185, 1186, 
1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 1195, 1196, 
1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 1205, 1206, 
1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 1215, 1216, 
1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 1225, 1226, 
1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 1235, 1236, 
1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 1245, 1246, 
1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 1255, 1256, 
1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 
1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 1275, 1276, 
1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 1285, 1286, 
1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 1295, 1296, 
1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 1305, 1306, 
1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 1315, 1316, 
1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 1325, 1326, 
1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 1335, 1336, 
1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 1345, 1346, 
1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 1355, 1356, 
1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 1365, 1366, 
1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 1375, 1376, 
1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1385, 1386, 
1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 1395, 1396, 
1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 1405, 1406, 
1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 1415, 1416, 
1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 1425, 1426, 
1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 1435, 1436, 
1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 1445, 1446, 
1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 1455, 1456, 
1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 1465, 1466, 
1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 1475, 1476, 
1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 1485, 1486, 
1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 1495, 1496, 
1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 1505, 1506, 
1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 
1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 
1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 1535, 1536, 
1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 1545, 1546, 
1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 1555, 1556, 
1557, 1558, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 
2109, 2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 
2119, 2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 
2129, 2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 
2139, 2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 
2149, 2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 
*NSET,NSET=Solder
5, 6, 7, 8, 11, 13, 15, 16, 21, 22, 
23, 24, 25, 26, 27, 28, 129, 130, 131, 132, 
133, 134, 135, 136, 137, 138, 139, 140, 141, 142, 
143, 144, 145, 146, 147, 148, 149, 150, 151, 152, 
153, 154, 155, 156, 157, 158, 159, 160, 161, 162, 
163, 164, 165, 166, 167, 168, 200, 201, 202, 203, 
204, 205, 206, 207, 208, 209, 210, 211, 212, 213, 
214, 215, 216, 217, 218, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 385, 386, 
387, 388, 389, 390, 391, 392, 393, 394, 395, 396, 
397, 398, 399, 400, 401, 402, 403, 404, 405, 406, 
407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 1040, 1041, 1042, 1043, 
1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 
1054, 1055, 1056, 1057, 1058, 1141, 1142, 1143, 1144, 1145, 
1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 1155, 
1156, 1157, 1158, 1159, 1578, 1579, 1580, 1581, 1582, 1583, 
1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 
1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 
1604, 1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 
1614, 1615, 
*NSET,NSET=Copper
7, 8, 9, 10, 11, 12, 13, 14, 25, 26, 
27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 
150, 151, 152, 153, 154, 155, 156, 157, 158, 159, 
160, 161, 162, 163, 164, 165, 166, 167, 168, 169, 
170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 195, 196, 197, 198, 199, 
200, 201, 202, 203, 204, 205, 206, 207, 208, 209, 
210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 
220, 221, 222, 223, 224, 225, 226, 227, 228, 229, 
230, 231, 232, 233, 234, 235, 236, 237, 238, 239, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 401, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
1059, 1060, 1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 
1069, 1070, 1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 
1079, 1080, 1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 
1089, 1090, 1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 
1099, 1100, 1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 
1109, 1110, 1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 
1119, 1120, 1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 
1129, 1130, 1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 
1139, 1140, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 
1624, 1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 
1634, 1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 
1644, 1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 
1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 
1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 
1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 
1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 
1694, 1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 1703, 
*NSET,NSET=Ceramic
9, 10, 12, 14, 29, 30, 31, 32, 34, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
173, 174, 175, 176, 177, 178, 179, 180, 181, 182, 
183, 184, 185, 186, 187, 188, 189, 190, 191, 195, 
196, 197, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 427, 428, 429, 430, 431, 432, 433, 434, 435, 
436, 437, 438, 439, 440, 441, 442, 443, 444, 445, 
450, 451, 452, 453, 454, 455, 456, 457, 458, 459, 
460, 461, 462, 463, 464, 465, 466, 467, 468, 472, 
473, 474, 480, 481, 482, 485, 486, 487, 488, 489, 
490, 491, 492, 493, 494, 495, 496, 497, 498, 499, 
500, 501, 502, 503, 504, 505, 506, 507, 508, 509, 
510, 511, 512, 513, 514, 515, 516, 517, 518, 519, 
520, 521, 522, 523, 524, 525, 526, 527, 528, 529, 
530, 531, 532, 533, 534, 535, 536, 537, 538, 539, 
540, 541, 542, 543, 544, 545, 546, 547, 548, 549, 
550, 551, 552, 553, 554, 555, 556, 557, 558, 559, 
560, 561, 562, 563, 564, 565, 566, 567, 568, 569, 
570, 571, 572, 573, 574, 575, 576, 577, 578, 579, 
580, 581, 582, 583, 584, 585, 586, 587, 588, 589, 
590, 591, 592, 593, 594, 595, 596, 597, 598, 599, 
600, 601, 602, 603, 604, 605, 606, 607, 608, 609, 
1704, 1705, 1706, 1707, 1708, 1709, 1710, 1711, 1712, 1713, 
1714, 1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 1723, 
1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 1733, 
1734, 1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 1743, 
1744, 1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 
1754, 1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 
1764, 1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 1773, 
1774, 1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 1783, 
1784, 1785, 1786, 1787, 1788, 1789, 1790, 1791, 1792, 1793, 
1794, 1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 1803, 
1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 1813, 
1814, 1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 
1824, 1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 1833, 
1834, 1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 1843, 
1844, 1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1853, 
1854, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 
1864, 1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1873, 
1874, 1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 1883, 
1884, 1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 1893, 
1894, 1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 1903, 
1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 
1914, 1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 1923, 
1924, 1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 1933, 
1934, 1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 
1944, 1945, 1946, 1947, 1948, 1949, 1950, 1951, 1952, 1953, 
1954, 1955, 1956, 1957, 1958, 1959, 1960, 1961, 1962, 1963, 
1964, 1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 1973, 
1974, 1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 1983, 
1984, 1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 1993, 
1994, 1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 
2004, 2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 
2014, 2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 
2024, 2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 
2034, 2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 
*NSET,NSET=Surface
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 592, 593, 594, 595, 596, 597, 598, 599, 600, 
601, 602, 603, 604, 605, 606, 607, 608, 609, 610, 
611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 
621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 
631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 704, 705, 706, 707, 708, 709, 710, 
711, 712, 713, 714, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 724, 725, 726, 727, 728, 729, 730, 
731, 732, 733, 734, 735, 736, 737, 738, 739, 740, 
741, 742, 743, 744, 745, 746, 747, 748, 749, 750, 
751, 752, 753, 754, 755, 756, 757, 758, 759, 760, 
761, 762, 763, 764, 765, 766, 767, 768, 769, 770, 
771, 772, 773, 774, 775, 776, 777, 778, 779, 780, 
781, 782, 783, 784, 785, 786, 787, 788, 789, 790, 
791, 792, 793, 794, 795, 796, 797, 798, 799, 800, 
801, 802, 803, 804, 805, 806, 807, 808, 809, 810, 
811, 812, 813, 814, 815, 816, 817, 818, 819, 820, 
821, 822, 823, 824, 825, 826, 827, 828, 829, 830, 
831, 832, 833, 834, 835, 836, 837, 838, 839, 840, 
841, 842, 843, 844, 845, 846, 847, 848, 849, 850, 
851, 852, 853, 854, 855, 856, 857, 858, 859, 860, 
861, 862, 863, 864, 865, 866, 867, 868, 869, 870, 
871, 872, 873, 874, 875, 876, 877, 878, 879, 880, 
881, 882, 883, 884, 885, 886, 887, 888, 889, 890, 
891, 892, 893, 894, 895, 896, 897, 898, 899, 900, 
901, 902, 903, 904, 905, 906, 907, 908, 909, 910, 
911, 912, 913, 914, 915, 916, 917, 918, 919, 920, 
921, 922, 923, 924, 925, 926, 927, 928, 929, 930, 
931, 932, 933, 934, 935, 936, 937, 938, 939, 940, 
941, 942, 943, 944, 945, 946, 947, 948, 949, 950, 
951, 952, 953, 954, 955, 956, 957, 958, 959, 960, 
961, 962, 963, 964, 965, 966, 967, 968, 969, 970, 
971, 972, 973, 974, 975, 976, 977, 978, 979, 980, 
981, 982, 983, 984, 985, 986, 987, 988, 989, 990, 
991, 992, 993, 994, 995, 996, 997, 998, 999, 1000, 
1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 
1011, 1012, 1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 
1021, 1022, 1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 
1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 
1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 
1051, 1052, 1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 
1061, 1062, 1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 
1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 
1081, 1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 
1091, 1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 
1101, 1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 
1111, 1112, 1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 
1121, 1122, 1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 
1131, 1132, 1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 
1141, 1142, 1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 
1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 
1161, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 
1171, 1172, 1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 
1181, 1182, 1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 
1191, 1192, 1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200, 
1201, 1202, 1203, 1204, 1205, 1206, 1207, 1208, 1209, 1210, 
1211, 1212, 1213, 1214, 1215, 1216, 1217, 1218, 1219, 1220, 
1221, 1222, 1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 
1231, 1232, 1233, 1234, 1235, 1236, 1237, 1238, 1239, 1240, 
1241, 1242, 1243, 1244, 1245, 1246, 1247, 1248, 1249, 1250, 
1251, 1252, 1253, 1254, 1255, 1256, 1257, 1258, 1259, 1260, 
1261, 1262, 1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270, 
1271, 1272, 1273, 1274, 1275, 1276, 1277, 1278, 1279, 1280, 
1281, 1282, 1283, 1284, 1285, 1286, 1287, 1288, 1289, 1290, 
1291, 1292, 1293, 1294, 1295, 1296, 1297, 1298, 1299, 1300, 
1301, 1302, 1303, 1304, 1305, 1306, 1307, 1308, 1309, 1310, 
1311, 1312, 1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 
1321, 1322, 1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 
1331, 1332, 1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 
1341, 1342, 1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 
1351, 1352, 1353, 1354, 1355, 1356, 1357, 1358, 1359, 1360, 
1361, 1362, 1363, 1364, 1365, 1366, 1367, 1368, 1369, 1370, 
1371, 1372, 1373, 1374, 1375, 1376, 1377, 1378, 1379, 1380, 
1381, 1382, 1383, 1384, 1385, 1386, 1387, 1388, 1389, 1390, 
1391, 1392, 1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 
1401, 1402, 1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 
1411, 1412, 1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 
1421, 1422, 1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 
1431, 1432, 1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 
1441, 1442, 1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 
1451, 1452, 1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 
1461, 1462, 1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 
1471, 1472, 1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 
1481, 1482, 1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 
1491, 1492, 1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 
1501, 1502, 1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 
1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 
1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 
1531, 1532, 1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 
1541, 1542, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 
1551, 1552, 1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 
1561, 1562, 1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 
1571, 1572, 1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 
1581, 1582, 1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 
1591, 1592, 1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 
1601, 1602, 1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 
1611, 1612, 1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 
1621, 1622, 1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 
1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 
1641, 1642, 1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 
1651, 1652, 1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 
1661, 1662, 1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 
1671, 1672, 1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 
1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 
1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 
1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 
1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 
1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 
1731, 1732, 1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 
1741, 1742, 1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 
1751, 1752, 1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 
1761, 1762, 1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 
1771, 1772, 1773, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 
1781, 1782, 1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790, 
1791, 1792, 1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 
1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 
1811, 1812, 1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 
1821, 1822, 1823, 1824, 1825, 1826, 1827, 1828, 1829, 1830, 
1831, 1832, 1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 
1841, 1842, 1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 
1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 
1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 1869, 1870, 
1871, 1872, 1873, 1874, 1875, 1876, 1877, 1878, 1879, 1880, 
1881, 1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 
1891, 1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 
1901, 1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 
1911, 1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 
1921, 1922, 1923, 1924, 1925, 1926, 1927, 1928, 1929, 1930, 
1931, 1932, 1933, 1934, 1935, 1936, 1937, 1938, 1939, 1940, 
1941, 1942, 1943, 1944, 1945, 1946, 1947, 1948, 1949, 1950, 
1951, 1952, 1953, 1954, 1955, 1956, 1957, 1958, 1959, 1960, 
1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 
1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 
1981, 1982, 1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 
1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 
2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 
2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 
2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 
2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 
2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 
2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 
2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 
2151, 2152, 2153, 2154, 2155, 2156, 2157, 
*NSET,NSET=TO
1, 2, 3, 4, 5, 6, 15, 16, 17, 18, 
19, 20, 21, 22, 23, 24, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
365, 366, 367, 368, 369, 370, 371, 372, 373, 374, 
375, 376, 377, 378, 379, 380, 610, 611, 612, 613, 
614, 615, 616, 617, 618, 619, 620, 621, 622, 623, 
624, 625, 626, 627, 628, 629, 630, 631, 632, 633, 
634, 635, 636, 637, 638, 639, 640, 641, 642, 643, 
644, 645, 646, 647, 648, 649, 650, 651, 652, 653, 
654, 655, 656, 657, 658, 659, 660, 661, 662, 663, 
664, 665, 666, 667, 668, 669, 670, 671, 672, 673, 
674, 675, 676, 677, 678, 679, 680, 681, 682, 683, 
684, 685, 686, 687, 688, 689, 690, 691, 692, 693, 
694, 695, 696, 697, 698, 699, 700, 701, 702, 703, 
704, 705, 706, 707, 708, 709, 710, 711, 712, 713, 
714, 715, 716, 717, 718, 719, 720, 721, 722, 723, 
724, 725, 726, 727, 728, 729, 730, 731, 732, 733, 
734, 735, 736, 737, 738, 739, 740, 741, 742, 743, 
744, 745, 746, 747, 748, 749, 750, 751, 752, 753, 
754, 755, 756, 757, 758, 759, 760, 761, 762, 763, 
764, 765, 766, 767, 768, 769, 770, 771, 772, 773, 
774, 775, 776, 777, 778, 779, 780, 781, 782, 783, 
784, 785, 786, 787, 788, 789, 790, 791, 792, 793, 
794, 795, 796, 797, 798, 799, 800, 801, 802, 803, 
804, 805, 806, 807, 808, 809, 810, 811, 812, 813, 
814, 815, 816, 817, 818, 819, 820, 821, 822, 823, 
824, 825, 826, 827, 828, 829, 830, 831, 832, 833, 
834, 835, 836, 837, 838, 839, 840, 841, 842, 843, 
844, 845, 846, 847, 848, 849, 850, 851, 852, 853, 
854, 855, 856, 857, 858, 859, 860, 861, 862, 863, 
864, 865, 866, 867, 868, 869, 870, 871, 872, 873, 
874, 875, 876, 877, 878, 879, 880, 881, 882, 883, 
884, 885, 886, 887, 888, 889, 890, 891, 892, 893, 
894, 895, 896, 897, 898, 899, 900, 901, 902, 903, 
904, 905, 906, 907, 908, 909, 910, 911, 912, 913, 
914, 915, 916, 917, 918, 919, 920, 921, 922, 923, 
924, 925, 926, 927, 928, 929, 930, 931, 932, 933, 
934, 935, 936, 937, 938, 939, 940, 941, 942, 943, 
944, 945, 946, 947, 948, 949, 950, 951, 952, 953, 
954, 955, 956, 957, 958, 959, 960, 961, 962, 963, 
964, 965, 966, 967, 968, 969, 970, 971, 972, 973, 
974, 975, 976, 977, 978, 979, 980, 981, 982, 983, 
984, 985, 986, 987, 988, 989, 990, 991, 992, 993, 
994, 995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 
1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 
1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 
1024, 1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 
1034, 1035, 1036, 1037, 1038, 1039, 1160, 1161, 1162, 1163, 
1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 
1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 
1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 
1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 
1204, 1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 
1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 
1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 
1234, 1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 
1244, 1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 
1254, 1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 
1264, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 
1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 
1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 
1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 
1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 
1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 
1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 
1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 
1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 
1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 
1364, 1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 
1374, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 
1384, 1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 
1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 
1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 
1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 
1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 
1434, 1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 
1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 
1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 
1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 
1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 
1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 
1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 
1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 
1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 
1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 
1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 
1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 
1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 
1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 
1574, 1575, 1576, 1577, 2044, 2045, 2046, 2047, 2048, 2049, 
2050, 2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 
2060, 2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 
2070, 2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 
2080, 2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 
2090, 2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 
2100, 2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 
2110, 2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 
2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 
2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 
2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 
2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 
*NSET,NSET=Surface1
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 51, 52, 53, 54, 
55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 
65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 
75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 
105, 106, 107, 108, 109, 110, 111, 112, 113, 114, 
115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 
125, 126, 127, 128, 129, 130, 131, 132, 133, 134, 
135, 136, 137, 138, 139, 140, 141, 142, 143, 144, 
145, 146, 147, 148, 149, 150, 151, 152, 153, 154, 
155, 156, 157, 158, 159, 160, 161, 162, 163, 164, 
165, 166, 167, 168, 169, 170, 171, 172, 173, 174, 
175, 176, 177, 178, 179, 180, 181, 182, 183, 184, 
185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 
245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 
255, 256, 257, 258, 259, 260, 261, 262, 263, 264, 
265, 266, 267, 268, 269, 270, 271, 272, 273, 274, 
275, 276, 277, 278, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 341, 342, 343, 344, 
345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 
355, 356, 357, 358, 359, 360, 361, 362, 363, 364, 
365, 366, 367, 368, 369, 370, 371, 372, 373, 374, 
375, 376, 377, 378, 379, 380, 381, 382, 383, 384, 
385, 386, 387, 388, 389, 390, 391, 392, 393, 394, 
395, 396, 397, 398, 399, 400, 401, 402, 403, 404, 
405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 
415, 416, 417, 418, 419, 420, 421, 422, 423, 424, 
425, 426, 427, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 437, 438, 439, 440, 441, 442, 443, 444, 
445, 446, 447, 448, 449, 450, 451, 452, 453, 454, 
455, 456, 457, 458, 459, 460, 461, 462, 463, 464, 
465, 466, 467, 468, 469, 470, 471, 472, 473, 474, 
475, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
485, 486, 487, 488, 489, 490, 491, 492, 493, 494, 
495, 496, 497, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 529, 530, 531, 532, 533, 534, 
535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 
545, 546, 547, 548, 549, 550, 551, 552, 553, 554, 
555, 556, 557, 558, 559, 560, 561, 562, 563, 564, 
565, 566, 567, 568, 569, 570, 571, 572, 573, 574, 
575, 576, 577, 578, 579, 580, 581, 582, 583, 584, 
585, 586, 587, 588, 589, 590, 591, 592, 593, 594, 
595, 596, 597, 598, 599, 600, 601, 602, 603, 604, 
605, 606, 607, 608, 609, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
685, 686, 687, 688, 689, 690, 691, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 713, 714, 
715, 716, 717, 718, 719, 720, 721, 722, 723, 724, 
725, 726, 727, 728, 729, 730, 731, 732, 733, 734, 
735, 736, 737, 738, 739, 740, 741, 742, 743, 744, 
745, 746, 747, 748, 749, 750, 751, 752, 753, 754, 
755, 756, 757, 758, 759, 760, 761, 762, 763, 764, 
765, 766, 767, 768, 769, 770, 771, 772, 773, 774, 
775, 776, 777, 778, 779, 780, 781, 782, 783, 784, 
785, 786, 787, 788, 789, 790, 791, 792, 793, 794, 
795, 796, 797, 798, 799, 800, 801, 802, 803, 804, 
805, 806, 807, 808, 809, 810, 811, 812, 813, 814, 
815, 816, 817, 818, 819, 820, 821, 822, 823, 824, 
825, 826, 827, 828, 829, 830, 831, 832, 833, 834, 
835, 836, 837, 838, 839, 840, 841, 842, 843, 844, 
845, 846, 847, 848, 849, 850, 851, 852, 853, 854, 
855, 856, 857, 858, 859, 860, 861, 862, 863, 864, 
865, 866, 867, 868, 869, 870, 871, 872, 873, 874, 
875, 876, 877, 878, 879, 880, 881, 882, 883, 884, 
885, 886, 887, 888, 889, 890, 891, 892, 893, 894, 
895, 896, 897, 898, 899, 900, 901, 902, 903, 904, 
905, 906, 907, 908, 909, 910, 911, 912, 913, 914, 
915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 
925, 926, 927, 928, 929, 930, 931, 932, 933, 934, 
935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 
945, 946, 947, 948, 949, 950, 951, 952, 953, 954, 
955, 956, 957, 958, 959, 960, 961, 962, 963, 964, 
965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 
975, 976, 977, 978, 979, 980, 981, 982, 983, 984, 
985, 986, 987, 988, 989, 990, 991, 992, 993, 994, 
995, 996, 997, 998, 999, 1000, 1001, 1002, 1003, 1004, 
1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 1013, 1014, 
1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 1024, 
1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 1033, 1034, 
1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 1043, 1044, 
1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053, 1054, 
1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 1063, 1064, 
1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 
1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 1083, 1084, 
1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 
1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 
1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 1113, 1114, 
1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 
1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 1133, 1134, 
1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 
1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 1153, 1154, 
1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 
1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 
1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 1183, 1184, 
1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 1193, 1194, 
1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 1203, 1204, 
1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 1213, 1214, 
1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 1224, 
1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 1234, 
1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 
1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 
1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 
1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 
1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 
1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 1294, 
1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 1303, 1304, 
1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 1313, 1314, 
1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 1323, 1324, 
1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 1333, 1334, 
1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 1343, 1344, 
1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 1353, 1354, 
1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 1363, 1364, 
1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 1373, 1374, 
1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 
1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 1393, 1394, 
1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 1403, 1404, 
1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 1413, 1414, 
1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 1423, 1424, 
1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 1433, 1434, 
1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 1443, 1444, 
1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453, 1454, 
1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 
1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 1473, 1474, 
1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 1483, 1484, 
1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 1493, 1494, 
1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 1503, 1504, 
1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 1513, 1514, 
1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 1523, 1524, 
1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 1533, 1534, 
1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 1543, 1544, 
1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1553, 1554, 
1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 1563, 1564, 
1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 
1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 1583, 1584, 
1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 1593, 1594, 
1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 1603, 1604, 
1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 1613, 1614, 
1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 1623, 1624, 
1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 1633, 1634, 
1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 1643, 1644, 
1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 1653, 1654, 
1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 1663, 1664, 
1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 1673, 1674, 
1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 1683, 1684, 
1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 1693, 1694, 
1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 1703, 1704, 
1705, 1706, 1707, 1708, 1709, 1710, 1711, 1712, 1713, 1714, 
1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 1723, 1724, 
1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 1733, 1734, 
1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 1743, 1744, 
1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 1753, 1754, 
1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 1763, 1764, 
1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 1773, 1774, 
1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 1783, 1784, 
1785, 1786, 1787, 1788, 1789, 1790, 1791, 1792, 1793, 1794, 
1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 
1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 1813, 1814, 
1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824, 
1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 1833, 1834, 
1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 1843, 1844, 
1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 1853, 1854, 
1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 1863, 1864, 
1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 
1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 
1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 
1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 
1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 
1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 
1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 1933, 1934, 
1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 1943, 1944, 
1945, 1946, 1947, 1948, 1949, 1950, 1951, 1952, 1953, 1954, 
1955, 1956, 1957, 1958, 1959, 1960, 1961, 1962, 1963, 1964, 
1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 1973, 1974, 
1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 1983, 1984, 
1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 1993, 1994, 
1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 2003, 2004, 
2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 2013, 2014, 
2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 2023, 2024, 
2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 2033, 2034, 
2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 2043, 
