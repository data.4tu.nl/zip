*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_QuadV2.inp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1, 0
4, 0, 1, 0
5, 1, 1.1, 0
6, 0, 1.1, 0
7, 1, 1.15, 0
8, 0, 1.15, 0
9, 1, 1.25, 0
10, 0, 1.25, 0
11, 1.2, 1.15, 0
12, 1.2, 1.25, 0
13, 2.2, 1.15, 0
14, 2.2, 1.25, 0
15, 1.2, 1.1, 0
16, 2.2, 1.1, 0
17, 1.2, 1, 0
18, 2.2, 1, 0
19, 1.2, 0, 0
20, 2.2, 0, 0
21, 1.2, -0.1, 0
22, 2.2, -0.1, 0
23, 0, -0.1, 0
24, 1, -0.1, 0
25, 0, -0.15, 0
26, 1, -0.15, 0
27, 1.2, -0.15, 0
28, 2.2, -0.15, 0
29, 0, -0.25, 0
30, 1, -0.25, 0
31, 1.2, -0.25, 0
32, 2.2, -0.25, 0
33, -0.2, -0.15, 0
34, -0.2, -0.25, 0
35, 2.4, -0.15, 0
36, 2.4, -0.25, 0
37, 0, -0.45, 0
38, -0.2, -0.45, 0
39, 1, -0.45, 0
40, 1.2, -0.45, 0
41, 2.2, -0.45, 0
42, 2.4, -0.45, 0
43, 1, 1.45, 0
44, 0, 1.45, 0
45, 1.2, 1.45, 0
46, 2.2, 1.45, 0
47, -0.2, 1, 0
48, -0.2, 0, 0
49, 2.4, 1, 0
50, 2.4, 0, 0
51, 0.05, 0, 0
52, 0.1, 0, 0
53, 0.15, 0, 0
54, 0.2, 0, 0
55, 0.25, 0, 0
56, 0.3, 0, 0
57, 0.35, 0, 0
58, 0.4, 0, 0
59, 0.45, 0, 0
60, 0.5, 0, 0
61, 0.55, 0, 0
62, 0.6, 0, 0
63, 0.65, 0, 0
64, 0.7, 0, 0
65, 0.75, 0, 0
66, 0.8, 0, 0
67, 0.85, 0, 0
68, 0.9, 0, 0
69, 0.95, 0, 0
70, 1, 0.05, 0
71, 1, 0.1, 0
72, 1, 0.15, 0
73, 1, 0.2, 0
74, 1, 0.25, 0
75, 1, 0.3, 0
76, 1, 0.35, 0
77, 1, 0.4, 0
78, 1, 0.45, 0
79, 1, 0.5, 0
80, 1, 0.55, 0
81, 1, 0.6, 0
82, 1, 0.65, 0
83, 1, 0.7, 0
84, 1, 0.75, 0
85, 1, 0.8, 0
86, 1, 0.85, 0
87, 1, 0.9, 0
88, 1, 0.95, 0
89, 0.95, 1, 0
90, 0.9, 1, 0
91, 0.85, 1, 0
92, 0.8, 1, 0
93, 0.75, 1, 0
94, 0.7, 1, 0
95, 0.65, 1, 0
96, 0.6, 1, 0
97, 0.55, 1, 0
98, 0.5, 1, 0
99, 0.45, 1, 0
100, 0.4, 1, 0
101, 0.35, 1, 0
102, 0.3, 1, 0
103, 0.25, 1, 0
104, 0.2, 1, 0
105, 0.15, 1, 0
106, 0.1, 1, 0
107, 0.05, 1, 0
108, 0, 0.95, 0
109, 0, 0.9, 0
110, 0, 0.85, 0
111, 0, 0.8, 0
112, 0, 0.75, 0
113, 0, 0.7, 0
114, 0, 0.65, 0
115, 0, 0.6, 0
116, 0, 0.55, 0
117, 0, 0.5, 0
118, 0, 0.45, 0
119, 0, 0.4, 0
120, 0, 0.35, 0
121, 0, 0.3, 0
122, 0, 0.25, 0
123, 0, 0.2, 0
124, 0, 0.15, 0
125, 0, 0.1, 0
126, 0, 0.05, 0
127, 1, 1.05, 0
128, 0, 1.05, 0
129, 0.95, 1.1, 0
130, 0.9, 1.1, 0
131, 0.85, 1.1, 0
132, 0.8, 1.1, 0
133, 0.75, 1.1, 0
134, 0.7, 1.1, 0
135, 0.65, 1.1, 0
136, 0.6, 1.1, 0
137, 0.55, 1.1, 0
138, 0.5, 1.1, 0
139, 0.45, 1.1, 0
140, 0.4, 1.1, 0
141, 0.35, 1.1, 0
142, 0.3, 1.1, 0
143, 0.25, 1.1, 0
144, 0.2, 1.1, 0
145, 0.15, 1.1, 0
146, 0.1, 1.1, 0
147, 0.05, 1.1, 0
148, 1, 1.125, 0
149, 0, 1.125, 0
150, 0.95, 1.15, 0
151, 0.9, 1.15, 0
152, 0.85, 1.15, 0
153, 0.8, 1.15, 0
154, 0.75, 1.15, 0
155, 0.7, 1.15, 0
156, 0.65, 1.15, 0
157, 0.6, 1.15, 0
158, 0.55, 1.15, 0
159, 0.5, 1.15, 0
160, 0.45, 1.15, 0
161, 0.4, 1.15, 0
162, 0.35, 1.15, 0
163, 0.3, 1.15, 0
164, 0.25, 1.15, 0
165, 0.2, 1.15, 0
166, 0.15, 1.15, 0
167, 0.1, 1.15, 0
168, 0.05, 1.15, 0
169, 1, 1.1833333333333, 0
170, 1, 1.2166666666667, 0
171, 0, 1.1833333333333, 0
172, 0, 1.2166666666667, 0
173, 0.95, 1.25, 0
174, 0.9, 1.25, 0
175, 0.85, 1.25, 0
176, 0.8, 1.25, 0
177, 0.75, 1.25, 0
178, 0.7, 1.25, 0
179, 0.65, 1.25, 0
180, 0.6, 1.25, 0
181, 0.55, 1.25, 0
182, 0.5, 1.25, 0
183, 0.45, 1.25, 0
184, 0.4, 1.25, 0
185, 0.35, 1.25, 0
186, 0.3, 1.25, 0
187, 0.25, 1.25, 0
188, 0.2, 1.25, 0
189, 0.15, 1.25, 0
190, 0.1, 1.25, 0
191, 0.05, 1.25, 0
192, 1.05, 1.15, 0
193, 1.1, 1.15, 0
194, 1.15, 1.15, 0
195, 1.05, 1.25, 0
196, 1.1, 1.25, 0
197, 1.15, 1.25, 0
198, 1.2, 1.1833333333333, 0
199, 1.2, 1.2166666666667, 0
200, 1.25, 1.15, 0
201, 1.3, 1.15, 0
202, 1.35, 1.15, 0
203, 1.4, 1.15, 0
204, 1.45, 1.15, 0
205, 1.5, 1.15, 0
206, 1.55, 1.15, 0
207, 1.6, 1.15, 0
208, 1.65, 1.15, 0
209, 1.7, 1.15, 0
210, 1.75, 1.15, 0
211, 1.8, 1.15, 0
212, 1.85, 1.15, 0
213, 1.9, 1.15, 0
214, 1.95, 1.15, 0
215, 2, 1.15, 0
216, 2.05, 1.15, 0
217, 2.1, 1.15, 0
218, 2.15, 1.15, 0
219, 1.25, 1.25, 0
220, 1.3, 1.25, 0
221, 1.35, 1.25, 0
222, 1.4, 1.25, 0
223, 1.45, 1.25, 0
224, 1.5, 1.25, 0
225, 1.55, 1.25, 0
226, 1.6, 1.25, 0
227, 1.65, 1.25, 0
228, 1.7, 1.25, 0
229, 1.75, 1.25, 0
230, 1.8, 1.25, 0
231, 1.85, 1.25, 0
232, 1.9, 1.25, 0
233, 1.95, 1.25, 0
234, 2, 1.25, 0
235, 2.05, 1.25, 0
236, 2.1, 1.25, 0
237, 2.15, 1.25, 0
238, 2.2, 1.1833333333333, 0
239, 2.2, 1.2166666666667, 0
240, 1.2, 1.125, 0
241, 2.2, 1.125, 0
242, 1.25, 1.1, 0
243, 1.3, 1.1, 0
244, 1.35, 1.1, 0
245, 1.4, 1.1, 0
246, 1.45, 1.1, 0
247, 1.5, 1.1, 0
248, 1.55, 1.1, 0
249, 1.6, 1.1, 0
250, 1.65, 1.1, 0
251, 1.7, 1.1, 0
252, 1.75, 1.1, 0
253, 1.8, 1.1, 0
254, 1.85, 1.1, 0
255, 1.9, 1.1, 0
256, 1.95, 1.1, 0
257, 2, 1.1, 0
258, 2.05, 1.1, 0
259, 2.1, 1.1, 0
260, 2.15, 1.1, 0
261, 1.2, 1.05, 0
262, 2.2, 1.05, 0
263, 1.25, 1, 0
264, 1.3, 1, 0
265, 1.35, 1, 0
266, 1.4, 1, 0
267, 1.45, 1, 0
268, 1.5, 1, 0
269, 1.55, 1, 0
270, 1.6, 1, 0
271, 1.65, 1, 0
272, 1.7, 1, 0
273, 1.75, 1, 0
274, 1.8, 1, 0
275, 1.85, 1, 0
276, 1.9, 1, 0
277, 1.95, 1, 0
278, 2, 1, 0
279, 2.05, 1, 0
280, 2.1, 1, 0
281, 2.15, 1, 0
282, 1.2, 0.95, 0
283, 1.2, 0.9, 0
284, 1.2, 0.85, 0
285, 1.2, 0.8, 0
286, 1.2, 0.75, 0
287, 1.2, 0.7, 0
288, 1.2, 0.65, 0
289, 1.2, 0.6, 0
290, 1.2, 0.55, 0
291, 1.2, 0.5, 0
292, 1.2, 0.45, 0
293, 1.2, 0.4, 0
294, 1.2, 0.35, 0
295, 1.2, 0.3, 0
296, 1.2, 0.25, 0
297, 1.2, 0.2, 0
298, 1.2, 0.15, 0
299, 1.2, 0.1, 0
300, 1.2, 0.05, 0
301, 2.2, 0.95, 0
302, 2.2, 0.9, 0
303, 2.2, 0.85, 0
304, 2.2, 0.8, 0
305, 2.2, 0.75, 0
306, 2.2, 0.7, 0
307, 2.2, 0.65, 0
308, 2.2, 0.6, 0
309, 2.2, 0.55, 0
310, 2.2, 0.5, 0
311, 2.2, 0.45, 0
312, 2.2, 0.4, 0
313, 2.2, 0.35, 0
314, 2.2, 0.3, 0
315, 2.2, 0.25, 0
316, 2.2, 0.2, 0
317, 2.2, 0.15, 0
318, 2.2, 0.1, 0
319, 2.2, 0.05, 0
320, 1.25, -2.2204460492503e-16, 0
321, 1.3, -2.2204460492503e-16, 0
322, 1.35, -2.2204460492503e-16, 0
323, 1.4, -2.2204460492503e-16, 0
324, 1.45, -2.2204460492503e-16, 0
325, 1.5, -2.2204460492503e-16, 0
326, 1.55, -2.2204460492503e-16, 0
327, 1.6, -2.2204460492503e-16, 0
328, 1.65, -2.2204460492503e-16, 0
329, 1.7, -2.2204460492503e-16, 0
330, 1.75, -2.2204460492503e-16, 0
331, 1.8, -2.2204460492503e-16, 0
332, 1.85, -2.2204460492503e-16, 0
333, 1.9, -2.2204460492503e-16, 0
334, 1.95, -2.2204460492503e-16, 0
335, 2, -2.2204460492503e-16, 0
336, 2.05, -2.2204460492503e-16, 0
337, 2.1, -2.2204460492503e-16, 0
338, 2.15, -2.2204460492503e-16, 0
339, 1.2, -0.05, 0
340, 2.2, -0.05, 0
341, 1.25, -0.1, 0
342, 1.3, -0.1, 0
343, 1.35, -0.1, 0
344, 1.4, -0.1, 0
345, 1.45, -0.1, 0
346, 1.5, -0.1, 0
347, 1.55, -0.1, 0
348, 1.6, -0.1, 0
349, 1.65, -0.1, 0
350, 1.7, -0.1, 0
351, 1.75, -0.1, 0
352, 1.8, -0.1, 0
353, 1.85, -0.1, 0
354, 1.9, -0.1, 0
355, 1.95, -0.1, 0
356, 2, -0.1, 0
357, 2.05, -0.1, 0
358, 2.1, -0.1, 0
359, 2.15, -0.1, 0
360, 0, -0.05, 0
361, 1, -0.05, 0
362, 0.05, -0.1, 0
363, 0.1, -0.1, 0
364, 0.15, -0.1, 0
365, 0.2, -0.1, 0
366, 0.25, -0.1, 0
367, 0.3, -0.1, 0
368, 0.35, -0.1, 0
369, 0.4, -0.1, 0
370, 0.45, -0.1, 0
371, 0.5, -0.1, 0
372, 0.55, -0.1, 0
373, 0.6, -0.1, 0
374, 0.65, -0.1, 0
375, 0.7, -0.1, 0
376, 0.75, -0.1, 0
377, 0.8, -0.1, 0
378, 0.85, -0.1, 0
379, 0.9, -0.1, 0
380, 0.95, -0.1, 0
381, 0, -0.125, 0
382, 1, -0.125, 0
383, 0.05, -0.15, 0
384, 0.1, -0.15, 0
385, 0.15, -0.15, 0
386, 0.2, -0.15, 0
387, 0.25, -0.15, 0
388, 0.3, -0.15, 0
389, 0.35, -0.15, 0
390, 0.4, -0.15, 0
391, 0.45, -0.15, 0
392, 0.5, -0.15, 0
393, 0.55, -0.15, 0
394, 0.6, -0.15, 0
395, 0.65, -0.15, 0
396, 0.7, -0.15, 0
397, 0.75, -0.15, 0
398, 0.8, -0.15, 0
399, 0.85, -0.15, 0
400, 0.9, -0.15, 0
401, 0.95, -0.15, 0
402, 1.2, -0.125, 0
403, 2.2, -0.125, 0
404, 1.25, -0.15, 0
405, 1.3, -0.15, 0
406, 1.35, -0.15, 0
407, 1.4, -0.15, 0
408, 1.45, -0.15, 0
409, 1.5, -0.15, 0
410, 1.55, -0.15, 0
411, 1.6, -0.15, 0
412, 1.65, -0.15, 0
413, 1.7, -0.15, 0
414, 1.75, -0.15, 0
415, 1.8, -0.15, 0
416, 1.85, -0.15, 0
417, 1.9, -0.15, 0
418, 1.95, -0.15, 0
419, 2, -0.15, 0
420, 2.05, -0.15, 0
421, 2.1, -0.15, 0
422, 2.15, -0.15, 0
423, 0, -0.18333333333333, 0
424, 0, -0.21666666666667, 0
425, 1, -0.18333333333333, 0
426, 1, -0.21666666666667, 0
427, 0.05, -0.25, 0
428, 0.1, -0.25, 0
429, 0.15, -0.25, 0
430, 0.2, -0.25, 0
431, 0.25, -0.25, 0
432, 0.3, -0.25, 0
433, 0.35, -0.25, 0
434, 0.4, -0.25, 0
435, 0.45, -0.25, 0
436, 0.5, -0.25, 0
437, 0.55, -0.25, 0
438, 0.6, -0.25, 0
439, 0.65, -0.25, 0
440, 0.7, -0.25, 0
441, 0.75, -0.25, 0
442, 0.8, -0.25, 0
443, 0.85, -0.25, 0
444, 0.9, -0.25, 0
445, 0.95, -0.25, 0
446, 1.2, -0.18333333333333, 0
447, 1.2, -0.21666666666667, 0
448, 2.2, -0.18333333333333, 0
449, 2.2, -0.21666666666667, 0
450, 1.25, -0.25, 0
451, 1.3, -0.25, 0
452, 1.35, -0.25, 0
453, 1.4, -0.25, 0
454, 1.45, -0.25, 0
455, 1.5, -0.25, 0
456, 1.55, -0.25, 0
457, 1.6, -0.25, 0
458, 1.65, -0.25, 0
459, 1.7, -0.25, 0
460, 1.75, -0.25, 0
461, 1.8, -0.25, 0
462, 1.85, -0.25, 0
463, 1.9, -0.25, 0
464, 1.95, -0.25, 0
465, 2, -0.25, 0
466, 2.05, -0.25, 0
467, 2.1, -0.25, 0
468, 2.15, -0.25, 0
469, -0.05, -0.15, 0
470, -0.1, -0.15, 0
471, -0.15, -0.15, 0
472, -0.05, -0.25, 0
473, -0.1, -0.25, 0
474, -0.15, -0.25, 0
475, -0.2, -0.18333333333333, 0
476, -0.2, -0.21666666666667, 0
477, 2.25, -0.15, 0
478, 2.3, -0.15, 0
479, 2.35, -0.15, 0
480, 2.25, -0.25, 0
481, 2.3, -0.25, 0
482, 2.35, -0.25, 0
483, 2.4, -0.18333333333333, 0
484, 2.4, -0.21666666666667, 0
485, 0, -0.29, 0
486, 0, -0.33, 0
487, 0, -0.37, 0
488, 0, -0.41, 0
489, -0.2, -0.29, 0
490, -0.2, -0.33, 0
491, -0.2, -0.37, 0
492, -0.2, -0.41, 0
493, -0.05, -0.45, 0
494, -0.1, -0.45, 0
495, -0.15, -0.45, 0
496, 1, -0.29, 0
497, 1, -0.33, 0
498, 1, -0.37, 0
499, 1, -0.41, 0
500, 0.05, -0.45, 0
501, 0.1, -0.45, 0
502, 0.15, -0.45, 0
503, 0.2, -0.45, 0
504, 0.25, -0.45, 0
505, 0.3, -0.45, 0
506, 0.35, -0.45, 0
507, 0.4, -0.45, 0
508, 0.45, -0.45, 0
509, 0.5, -0.45, 0
510, 0.55, -0.45, 0
511, 0.6, -0.45, 0
512, 0.65, -0.45, 0
513, 0.7, -0.45, 0
514, 0.75, -0.45, 0
515, 0.8, -0.45, 0
516, 0.85, -0.45, 0
517, 0.9, -0.45, 0
518, 0.95, -0.45, 0
519, 1.2, -0.29, 0
520, 1.2, -0.33, 0
521, 1.2, -0.37, 0
522, 1.2, -0.41, 0
523, 2.2, -0.29, 0
524, 2.2, -0.33, 0
525, 2.2, -0.37, 0
526, 2.2, -0.41, 0
527, 1.25, -0.45, 0
528, 1.3, -0.45, 0
529, 1.35, -0.45, 0
530, 1.4, -0.45, 0
531, 1.45, -0.45, 0
532, 1.5, -0.45, 0
533, 1.55, -0.45, 0
534, 1.6, -0.45, 0
535, 1.65, -0.45, 0
536, 1.7, -0.45, 0
537, 1.75, -0.45, 0
538, 1.8, -0.45, 0
539, 1.85, -0.45, 0
540, 1.9, -0.45, 0
541, 1.95, -0.45, 0
542, 2, -0.45, 0
543, 2.05, -0.45, 0
544, 2.1, -0.45, 0
545, 2.15, -0.45, 0
546, 2.4, -0.29, 0
547, 2.4, -0.33, 0
548, 2.4, -0.37, 0
549, 2.4, -0.41, 0
550, 2.25, -0.45, 0
551, 2.3, -0.45, 0
552, 2.35, -0.45, 0
553, 1, 1.29, 0
554, 1, 1.33, 0
555, 1, 1.37, 0
556, 1, 1.41, 0
557, 0, 1.29, 0
558, 0, 1.33, 0
559, 0, 1.37, 0
560, 0, 1.41, 0
561, 0.95, 1.45, 0
562, 0.9, 1.45, 0
563, 0.85, 1.45, 0
564, 0.8, 1.45, 0
565, 0.75, 1.45, 0
566, 0.7, 1.45, 0
567, 0.65, 1.45, 0
568, 0.6, 1.45, 0
569, 0.55, 1.45, 0
570, 0.5, 1.45, 0
571, 0.45, 1.45, 0
572, 0.4, 1.45, 0
573, 0.35, 1.45, 0
574, 0.3, 1.45, 0
575, 0.25, 1.45, 0
576, 0.2, 1.45, 0
577, 0.15, 1.45, 0
578, 0.1, 1.45, 0
579, 0.05, 1.45, 0
580, 1.2, 1.29, 0
581, 1.2, 1.33, 0
582, 1.2, 1.37, 0
583, 1.2, 1.41, 0
584, 1.05, 1.45, 0
585, 1.1, 1.45, 0
586, 1.15, 1.45, 0
587, 2.2, 1.29, 0
588, 2.2, 1.33, 0
589, 2.2, 1.37, 0
590, 2.2, 1.41, 0
591, 1.25, 1.45, 0
592, 1.3, 1.45, 0
593, 1.35, 1.45, 0
594, 1.4, 1.45, 0
595, 1.45, 1.45, 0
596, 1.5, 1.45, 0
597, 1.55, 1.45, 0
598, 1.6, 1.45, 0
599, 1.65, 1.45, 0
600, 1.7, 1.45, 0
601, 1.75, 1.45, 0
602, 1.8, 1.45, 0
603, 1.85, 1.45, 0
604, 1.9, 1.45, 0
605, 1.95, 1.45, 0
606, 2, 1.45, 0
607, 2.05, 1.45, 0
608, 2.1, 1.45, 0
609, 2.15, 1.45, 0
610, -0.05, 1, 0
611, -0.1, 1, 0
612, -0.15, 1, 0
613, -0.05, 0, 0
614, -0.1, 0, 0
615, -0.15, 0, 0
616, -0.2, 0.95, 0
617, -0.2, 0.9, 0
618, -0.2, 0.85, 0
619, -0.2, 0.8, 0
620, -0.2, 0.75, 0
621, -0.2, 0.7, 0
622, -0.2, 0.65, 0
623, -0.2, 0.6, 0
624, -0.2, 0.55, 0
625, -0.2, 0.5, 0
626, -0.2, 0.45, 0
627, -0.2, 0.4, 0
628, -0.2, 0.35, 0
629, -0.2, 0.3, 0
630, -0.2, 0.25, 0
631, -0.2, 0.2, 0
632, -0.2, 0.15, 0
633, -0.2, 0.1, 0
634, -0.2, 0.05, 0
635, 2.25, 1, 0
636, 2.3, 1, 0
637, 2.35, 1, 0
638, 2.25, 0, 0
639, 2.3, 0, 0
640, 2.35, 0, 0
641, 2.4, 0.95, 0
642, 2.4, 0.9, 0
643, 2.4, 0.85, 0
644, 2.4, 0.8, 0
645, 2.4, 0.75, 0
646, 2.4, 0.7, 0
647, 2.4, 0.65, 0
648, 2.4, 0.6, 0
649, 2.4, 0.55, 0
650, 2.4, 0.5, 0
651, 2.4, 0.45, 0
652, 2.4, 0.4, 0
653, 2.4, 0.35, 0
654, 2.4, 0.3, 0
655, 2.4, 0.25, 0
656, 2.4, 0.2, 0
657, 2.4, 0.15, 0
658, 2.4, 0.1, 0
659, 2.4, 0.05, 0
660, 0.05, 0.05, 0
661, 0.05, 0.1, 0
662, 0.05, 0.15, 0
663, 0.05, 0.2, 0
664, 0.05, 0.25, 0
665, 0.05, 0.3, 0
666, 0.05, 0.35, 0
667, 0.05, 0.4, 0
668, 0.05, 0.45, 0
669, 0.05, 0.5, 0
670, 0.05, 0.55, 0
671, 0.05, 0.6, 0
672, 0.05, 0.65, 0
673, 0.05, 0.7, 0
674, 0.05, 0.75, 0
675, 0.05, 0.8, 0
676, 0.05, 0.85, 0
677, 0.05, 0.9, 0
678, 0.05, 0.95, 0
679, 0.1, 0.05, 0
680, 0.1, 0.1, 0
681, 0.1, 0.15, 0
682, 0.1, 0.2, 0
683, 0.1, 0.25, 0
684, 0.1, 0.3, 0
685, 0.1, 0.35, 0
686, 0.1, 0.4, 0
687, 0.1, 0.45, 0
688, 0.1, 0.5, 0
689, 0.1, 0.55, 0
690, 0.1, 0.6, 0
691, 0.1, 0.65, 0
692, 0.1, 0.7, 0
693, 0.1, 0.75, 0
694, 0.1, 0.8, 0
695, 0.1, 0.85, 0
696, 0.1, 0.9, 0
697, 0.1, 0.95, 0
698, 0.15, 0.05, 0
699, 0.15, 0.1, 0
700, 0.15, 0.15, 0
701, 0.15, 0.2, 0
702, 0.15, 0.25, 0
703, 0.15, 0.3, 0
704, 0.15, 0.35, 0
705, 0.15, 0.4, 0
706, 0.15, 0.45, 0
707, 0.15, 0.5, 0
708, 0.15, 0.55, 0
709, 0.15, 0.6, 0
710, 0.15, 0.65, 0
711, 0.15, 0.7, 0
712, 0.15, 0.75, 0
713, 0.15, 0.8, 0
714, 0.15, 0.85, 0
715, 0.15, 0.9, 0
716, 0.15, 0.95, 0
717, 0.2, 0.05, 0
718, 0.2, 0.1, 0
719, 0.2, 0.15, 0
720, 0.2, 0.2, 0
721, 0.2, 0.25, 0
722, 0.2, 0.3, 0
723, 0.2, 0.35, 0
724, 0.2, 0.4, 0
725, 0.2, 0.45, 0
726, 0.2, 0.5, 0
727, 0.2, 0.55, 0
728, 0.2, 0.6, 0
729, 0.2, 0.65, 0
730, 0.2, 0.7, 0
731, 0.2, 0.75, 0
732, 0.2, 0.8, 0
733, 0.2, 0.85, 0
734, 0.2, 0.9, 0
735, 0.2, 0.95, 0
736, 0.25, 0.05, 0
737, 0.25, 0.1, 0
738, 0.25, 0.15, 0
739, 0.25, 0.2, 0
740, 0.25, 0.25, 0
741, 0.25, 0.3, 0
742, 0.25, 0.35, 0
743, 0.25, 0.4, 0
744, 0.25, 0.45, 0
745, 0.25, 0.5, 0
746, 0.25, 0.55, 0
747, 0.25, 0.6, 0
748, 0.25, 0.65, 0
749, 0.25, 0.7, 0
750, 0.25, 0.75, 0
751, 0.25, 0.8, 0
752, 0.25, 0.85, 0
753, 0.25, 0.9, 0
754, 0.25, 0.95, 0
755, 0.3, 0.05, 0
756, 0.3, 0.1, 0
757, 0.3, 0.15, 0
758, 0.3, 0.2, 0
759, 0.3, 0.25, 0
760, 0.3, 0.3, 0
761, 0.3, 0.35, 0
762, 0.3, 0.4, 0
763, 0.3, 0.45, 0
764, 0.3, 0.5, 0
765, 0.3, 0.55, 0
766, 0.3, 0.6, 0
767, 0.3, 0.65, 0
768, 0.3, 0.7, 0
769, 0.3, 0.75, 0
770, 0.3, 0.8, 0
771, 0.3, 0.85, 0
772, 0.3, 0.9, 0
773, 0.3, 0.95, 0
774, 0.35, 0.05, 0
775, 0.35, 0.1, 0
776, 0.35, 0.15, 0
777, 0.35, 0.2, 0
778, 0.35, 0.25, 0
779, 0.35, 0.3, 0
780, 0.35, 0.35, 0
781, 0.35, 0.4, 0
782, 0.35, 0.45, 0
783, 0.35, 0.5, 0
784, 0.35, 0.55, 0
785, 0.35, 0.6, 0
786, 0.35, 0.65, 0
787, 0.35, 0.7, 0
788, 0.35, 0.75, 0
789, 0.35, 0.8, 0
790, 0.35, 0.85, 0
791, 0.35, 0.9, 0
792, 0.35, 0.95, 0
793, 0.4, 0.05, 0
794, 0.4, 0.1, 0
795, 0.4, 0.15, 0
796, 0.4, 0.2, 0
797, 0.4, 0.25, 0
798, 0.4, 0.3, 0
799, 0.4, 0.35, 0
800, 0.4, 0.4, 0
801, 0.4, 0.45, 0
802, 0.4, 0.5, 0
803, 0.4, 0.55, 0
804, 0.4, 0.6, 0
805, 0.4, 0.65, 0
806, 0.4, 0.7, 0
807, 0.4, 0.75, 0
808, 0.4, 0.8, 0
809, 0.4, 0.85, 0
810, 0.4, 0.9, 0
811, 0.4, 0.95, 0
812, 0.45, 0.05, 0
813, 0.45, 0.1, 0
814, 0.45, 0.15, 0
815, 0.45, 0.2, 0
816, 0.45, 0.25, 0
817, 0.45, 0.3, 0
818, 0.45, 0.35, 0
819, 0.45, 0.4, 0
820, 0.45, 0.45, 0
821, 0.45, 0.5, 0
822, 0.45, 0.55, 0
823, 0.45, 0.6, 0
824, 0.45, 0.65, 0
825, 0.45, 0.7, 0
826, 0.45, 0.75, 0
827, 0.45, 0.8, 0
828, 0.45, 0.85, 0
829, 0.45, 0.9, 0
830, 0.45, 0.95, 0
831, 0.5, 0.05, 0
832, 0.5, 0.1, 0
833, 0.5, 0.15, 0
834, 0.5, 0.2, 0
835, 0.5, 0.25, 0
836, 0.5, 0.3, 0
837, 0.5, 0.35, 0
838, 0.5, 0.4, 0
839, 0.5, 0.45, 0
840, 0.5, 0.5, 0
841, 0.5, 0.55, 0
842, 0.5, 0.6, 0
843, 0.5, 0.65, 0
844, 0.5, 0.7, 0
845, 0.5, 0.75, 0
846, 0.5, 0.8, 0
847, 0.5, 0.85, 0
848, 0.5, 0.9, 0
849, 0.5, 0.95, 0
850, 0.55, 0.05, 0
851, 0.55, 0.1, 0
852, 0.55, 0.15, 0
853, 0.55, 0.2, 0
854, 0.55, 0.25, 0
855, 0.55, 0.3, 0
856, 0.55, 0.35, 0
857, 0.55, 0.4, 0
858, 0.55, 0.45, 0
859, 0.55, 0.5, 0
860, 0.55, 0.55, 0
861, 0.55, 0.6, 0
862, 0.55, 0.65, 0
863, 0.55, 0.7, 0
864, 0.55, 0.75, 0
865, 0.55, 0.8, 0
866, 0.55, 0.85, 0
867, 0.55, 0.9, 0
868, 0.55, 0.95, 0
869, 0.6, 0.05, 0
870, 0.6, 0.1, 0
871, 0.6, 0.15, 0
872, 0.6, 0.2, 0
873, 0.6, 0.25, 0
874, 0.6, 0.3, 0
875, 0.6, 0.35, 0
876, 0.6, 0.4, 0
877, 0.6, 0.45, 0
878, 0.6, 0.5, 0
879, 0.6, 0.55, 0
880, 0.6, 0.6, 0
881, 0.6, 0.65, 0
882, 0.6, 0.7, 0
883, 0.6, 0.75, 0
884, 0.6, 0.8, 0
885, 0.6, 0.85, 0
886, 0.6, 0.9, 0
887, 0.6, 0.95, 0
888, 0.65, 0.05, 0
889, 0.65, 0.1, 0
890, 0.65, 0.15, 0
891, 0.65, 0.2, 0
892, 0.65, 0.25, 0
893, 0.65, 0.3, 0
894, 0.65, 0.35, 0
895, 0.65, 0.4, 0
896, 0.65, 0.45, 0
897, 0.65, 0.5, 0
898, 0.65, 0.55, 0
899, 0.65, 0.6, 0
900, 0.65, 0.65, 0
901, 0.65, 0.7, 0
902, 0.65, 0.75, 0
903, 0.65, 0.8, 0
904, 0.65, 0.85, 0
905, 0.65, 0.9, 0
906, 0.65, 0.95, 0
907, 0.7, 0.05, 0
908, 0.7, 0.1, 0
909, 0.7, 0.15, 0
910, 0.7, 0.2, 0
911, 0.7, 0.25, 0
912, 0.7, 0.3, 0
913, 0.7, 0.35, 0
914, 0.7, 0.4, 0
915, 0.7, 0.45, 0
916, 0.7, 0.5, 0
917, 0.7, 0.55, 0
918, 0.7, 0.6, 0
919, 0.7, 0.65, 0
920, 0.7, 0.7, 0
921, 0.7, 0.75, 0
922, 0.7, 0.8, 0
923, 0.7, 0.85, 0
924, 0.7, 0.9, 0
925, 0.7, 0.95, 0
926, 0.75, 0.05, 0
927, 0.75, 0.1, 0
928, 0.75, 0.15, 0
929, 0.75, 0.2, 0
930, 0.75, 0.25, 0
931, 0.75, 0.3, 0
932, 0.75, 0.35, 0
933, 0.75, 0.4, 0
934, 0.75, 0.45, 0
935, 0.75, 0.5, 0
936, 0.75, 0.55, 0
937, 0.75, 0.6, 0
938, 0.75, 0.65, 0
939, 0.75, 0.7, 0
940, 0.75, 0.75, 0
941, 0.75, 0.8, 0
942, 0.75, 0.85, 0
943, 0.75, 0.9, 0
944, 0.75, 0.95, 0
945, 0.8, 0.05, 0
946, 0.8, 0.1, 0
947, 0.8, 0.15, 0
948, 0.8, 0.2, 0
949, 0.8, 0.25, 0
950, 0.8, 0.3, 0
951, 0.8, 0.35, 0
952, 0.8, 0.4, 0
953, 0.8, 0.45, 0
954, 0.8, 0.5, 0
955, 0.8, 0.55, 0
956, 0.8, 0.6, 0
957, 0.8, 0.65, 0
958, 0.8, 0.7, 0
959, 0.8, 0.75, 0
960, 0.8, 0.8, 0
961, 0.8, 0.85, 0
962, 0.8, 0.9, 0
963, 0.8, 0.95, 0
964, 0.85, 0.05, 0
965, 0.85, 0.1, 0
966, 0.85, 0.15, 0
967, 0.85, 0.2, 0
968, 0.85, 0.25, 0
969, 0.85, 0.3, 0
970, 0.85, 0.35, 0
971, 0.85, 0.4, 0
972, 0.85, 0.45, 0
973, 0.85, 0.5, 0
974, 0.85, 0.55, 0
975, 0.85, 0.6, 0
976, 0.85, 0.65, 0
977, 0.85, 0.7, 0
978, 0.85, 0.75, 0
979, 0.85, 0.8, 0
980, 0.85, 0.85, 0
981, 0.85, 0.9, 0
982, 0.85, 0.95, 0
983, 0.9, 0.05, 0
984, 0.9, 0.1, 0
985, 0.9, 0.15, 0
986, 0.9, 0.2, 0
987, 0.9, 0.25, 0
988, 0.9, 0.3, 0
989, 0.9, 0.35, 0
990, 0.9, 0.4, 0
991, 0.9, 0.45, 0
992, 0.9, 0.5, 0
993, 0.9, 0.55, 0
994, 0.9, 0.6, 0
995, 0.9, 0.65, 0
996, 0.9, 0.7, 0
997, 0.9, 0.75, 0
998, 0.9, 0.8, 0
999, 0.9, 0.85, 0
1000, 0.9, 0.9, 0
1001, 0.9, 0.95, 0
1002, 0.95, 0.05, 0
1003, 0.95, 0.1, 0
1004, 0.95, 0.15, 0
1005, 0.95, 0.2, 0
1006, 0.95, 0.25, 0
1007, 0.95, 0.3, 0
1008, 0.95, 0.35, 0
1009, 0.95, 0.4, 0
1010, 0.95, 0.45, 0
1011, 0.95, 0.5, 0
1012, 0.95, 0.55, 0
1013, 0.95, 0.6, 0
1014, 0.95, 0.65, 0
1015, 0.95, 0.7, 0
1016, 0.95, 0.75, 0
1017, 0.95, 0.8, 0
1018, 0.95, 0.85, 0
1019, 0.95, 0.9, 0
1020, 0.95, 0.95, 0
1021, 0.95, 1.05, 0
1022, 0.9, 1.05, 0
1023, 0.85, 1.05, 0
1024, 0.8, 1.05, 0
1025, 0.75, 1.05, 0
1026, 0.7, 1.05, 0
1027, 0.65, 1.05, 0
1028, 0.6, 1.05, 0
1029, 0.55, 1.05, 0
1030, 0.5, 1.05, 0
1031, 0.45, 1.05, 0
1032, 0.4, 1.05, 0
1033, 0.35, 1.05, 0
1034, 0.3, 1.05, 0
1035, 0.25, 1.05, 0
1036, 0.2, 1.05, 0
1037, 0.15, 1.05, 0
1038, 0.1, 1.05, 0
1039, 0.05, 1.05, 0
1040, 0.95, 1.125, 0
1041, 0.9, 1.125, 0
1042, 0.85, 1.125, 0
1043, 0.8, 1.125, 0
1044, 0.75, 1.125, 0
1045, 0.7, 1.125, 0
1046, 0.65, 1.125, 0
1047, 0.6, 1.125, 0
1048, 0.55, 1.125, 0
1049, 0.5, 1.125, 0
1050, 0.45, 1.125, 0
1051, 0.4, 1.125, 0
1052, 0.35, 1.125, 0
1053, 0.3, 1.125, 0
1054, 0.25, 1.125, 0
1055, 0.2, 1.125, 0
1056, 0.15, 1.125, 0
1057, 0.1, 1.125, 0
1058, 0.05, 1.125, 0
1059, 0.95, 1.1833333333333, 0
1060, 0.9, 1.1833333333333, 0
1061, 0.85, 1.1833333333333, 0
1062, 0.8, 1.1833333333333, 0
1063, 0.75, 1.1833333333333, 0
1064, 0.7, 1.1833333333333, 0
1065, 0.65, 1.1833333333333, 0
1066, 0.6, 1.1833333333333, 0
1067, 0.55, 1.1833333333333, 0
1068, 0.5, 1.1833333333333, 0
1069, 0.45, 1.1833333333333, 0
1070, 0.4, 1.1833333333333, 0
1071, 0.35, 1.1833333333333, 0
1072, 0.3, 1.1833333333333, 0
1073, 0.25, 1.1833333333333, 0
1074, 0.2, 1.1833333333333, 0
1075, 0.15, 1.1833333333333, 0
1076, 0.1, 1.1833333333333, 0
1077, 0.05, 1.1833333333333, 0
1078, 0.95, 1.2166666666667, 0
1079, 0.9, 1.2166666666667, 0
1080, 0.85, 1.2166666666667, 0
1081, 0.8, 1.2166666666667, 0
1082, 0.75, 1.2166666666667, 0
1083, 0.7, 1.2166666666667, 0
1084, 0.65, 1.2166666666667, 0
1085, 0.6, 1.2166666666667, 0
1086, 0.55, 1.2166666666667, 0
1087, 0.5, 1.2166666666667, 0
1088, 0.45, 1.2166666666667, 0
1089, 0.4, 1.2166666666667, 0
1090, 0.35, 1.2166666666667, 0
1091, 0.3, 1.2166666666667, 0
1092, 0.25, 1.2166666666667, 0
1093, 0.2, 1.2166666666667, 0
1094, 0.15, 1.2166666666667, 0
1095, 0.1, 1.2166666666667, 0
1096, 0.05, 1.2166666666667, 0
1097, 1.05, 1.1833333333333, 0
1098, 1.05, 1.2166666666667, 0
1099, 1.1, 1.1833333333333, 0
1100, 1.1, 1.2166666666667, 0
1101, 1.15, 1.1833333333333, 0
1102, 1.15, 1.2166666666667, 0
1103, 1.25, 1.1833333333333, 0
1104, 1.25, 1.2166666666667, 0
1105, 1.3, 1.1833333333333, 0
1106, 1.3, 1.2166666666667, 0
1107, 1.35, 1.1833333333333, 0
1108, 1.35, 1.2166666666667, 0
1109, 1.4, 1.1833333333333, 0
1110, 1.4, 1.2166666666667, 0
1111, 1.45, 1.1833333333333, 0
1112, 1.45, 1.2166666666667, 0
1113, 1.5, 1.1833333333333, 0
1114, 1.5, 1.2166666666667, 0
1115, 1.55, 1.1833333333333, 0
1116, 1.55, 1.2166666666667, 0
1117, 1.6, 1.1833333333333, 0
1118, 1.6, 1.2166666666667, 0
1119, 1.65, 1.1833333333333, 0
1120, 1.65, 1.2166666666667, 0
1121, 1.7, 1.1833333333333, 0
1122, 1.7, 1.2166666666667, 0
1123, 1.75, 1.1833333333333, 0
1124, 1.75, 1.2166666666667, 0
1125, 1.8, 1.1833333333333, 0
1126, 1.8, 1.2166666666667, 0
1127, 1.85, 1.1833333333333, 0
1128, 1.85, 1.2166666666667, 0
1129, 1.9, 1.1833333333333, 0
1130, 1.9, 1.2166666666667, 0
1131, 1.95, 1.1833333333333, 0
1132, 1.95, 1.2166666666667, 0
1133, 2, 1.1833333333333, 0
1134, 2, 1.2166666666667, 0
1135, 2.05, 1.1833333333333, 0
1136, 2.05, 1.2166666666667, 0
1137, 2.1, 1.1833333333333, 0
1138, 2.1, 1.2166666666667, 0
1139, 2.15, 1.1833333333333, 0
1140, 2.15, 1.2166666666667, 0
1141, 1.25, 1.125, 0
1142, 1.3, 1.125, 0
1143, 1.35, 1.125, 0
1144, 1.4, 1.125, 0
1145, 1.45, 1.125, 0
1146, 1.5, 1.125, 0
1147, 1.55, 1.125, 0
1148, 1.6, 1.125, 0
1149, 1.65, 1.125, 0
1150, 1.7, 1.125, 0
1151, 1.75, 1.125, 0
1152, 1.8, 1.125, 0
1153, 1.85, 1.125, 0
1154, 1.9, 1.125, 0
1155, 1.95, 1.125, 0
1156, 2, 1.125, 0
1157, 2.05, 1.125, 0
1158, 2.1, 1.125, 0
1159, 2.15, 1.125, 0
1160, 1.25, 1.05, 0
1161, 1.3, 1.05, 0
1162, 1.35, 1.05, 0
1163, 1.4, 1.05, 0
1164, 1.45, 1.05, 0
1165, 1.5, 1.05, 0
1166, 1.55, 1.05, 0
1167, 1.6, 1.05, 0
1168, 1.65, 1.05, 0
1169, 1.7, 1.05, 0
1170, 1.75, 1.05, 0
1171, 1.8, 1.05, 0
1172, 1.85, 1.05, 0
1173, 1.9, 1.05, 0
1174, 1.95, 1.05, 0
1175, 2, 1.05, 0
1176, 2.05, 1.05, 0
1177, 2.1, 1.05, 0
1178, 2.15, 1.05, 0
1179, 1.25, 0.95, 0
1180, 1.3, 0.95, 0
1181, 1.35, 0.95, 0
1182, 1.4, 0.95, 0
1183, 1.45, 0.95, 0
1184, 1.5, 0.95, 0
1185, 1.55, 0.95, 0
1186, 1.6, 0.95, 0
1187, 1.65, 0.95, 0
1188, 1.7, 0.95, 0
1189, 1.75, 0.95, 0
1190, 1.8, 0.95, 0
1191, 1.85, 0.95, 0
1192, 1.9, 0.95, 0
1193, 1.95, 0.95, 0
1194, 2, 0.95, 0
1195, 2.05, 0.95, 0
1196, 2.1, 0.95, 0
1197, 2.15, 0.95, 0
1198, 1.25, 0.9, 0
1199, 1.3, 0.9, 0
1200, 1.35, 0.9, 0
1201, 1.4, 0.9, 0
1202, 1.45, 0.9, 0
1203, 1.5, 0.9, 0
1204, 1.55, 0.9, 0
1205, 1.6, 0.9, 0
1206, 1.65, 0.9, 0
1207, 1.7, 0.9, 0
1208, 1.75, 0.9, 0
1209, 1.8, 0.9, 0
1210, 1.85, 0.9, 0
1211, 1.9, 0.9, 0
1212, 1.95, 0.9, 0
1213, 2, 0.9, 0
1214, 2.05, 0.9, 0
1215, 2.1, 0.9, 0
1216, 2.15, 0.9, 0
1217, 1.25, 0.85, 0
1218, 1.3, 0.85, 0
1219, 1.35, 0.85, 0
1220, 1.4, 0.85, 0
1221, 1.45, 0.85, 0
1222, 1.5, 0.85, 0
1223, 1.55, 0.85, 0
1224, 1.6, 0.85, 0
1225, 1.65, 0.85, 0
1226, 1.7, 0.85, 0
1227, 1.75, 0.85, 0
1228, 1.8, 0.85, 0
1229, 1.85, 0.85, 0
1230, 1.9, 0.85, 0
1231, 1.95, 0.85, 0
1232, 2, 0.85, 0
1233, 2.05, 0.85, 0
1234, 2.1, 0.85, 0
1235, 2.15, 0.85, 0
1236, 1.25, 0.8, 0
1237, 1.3, 0.8, 0
1238, 1.35, 0.8, 0
1239, 1.4, 0.8, 0
1240, 1.45, 0.8, 0
1241, 1.5, 0.8, 0
1242, 1.55, 0.8, 0
1243, 1.6, 0.8, 0
1244, 1.65, 0.8, 0
1245, 1.7, 0.8, 0
1246, 1.75, 0.8, 0
1247, 1.8, 0.8, 0
1248, 1.85, 0.8, 0
1249, 1.9, 0.8, 0
1250, 1.95, 0.8, 0
1251, 2, 0.8, 0
1252, 2.05, 0.8, 0
1253, 2.1, 0.8, 0
1254, 2.15, 0.8, 0
1255, 1.25, 0.75, 0
1256, 1.3, 0.75, 0
1257, 1.35, 0.75, 0
1258, 1.4, 0.75, 0
1259, 1.45, 0.75, 0
1260, 1.5, 0.75, 0
1261, 1.55, 0.75, 0
1262, 1.6, 0.75, 0
1263, 1.65, 0.75, 0
1264, 1.7, 0.75, 0
1265, 1.75, 0.75, 0
1266, 1.8, 0.75, 0
1267, 1.85, 0.75, 0
1268, 1.9, 0.75, 0
1269, 1.95, 0.75, 0
1270, 2, 0.75, 0
1271, 2.05, 0.75, 0
1272, 2.1, 0.75, 0
1273, 2.15, 0.75, 0
1274, 1.25, 0.7, 0
1275, 1.3, 0.7, 0
1276, 1.35, 0.7, 0
1277, 1.4, 0.7, 0
1278, 1.45, 0.7, 0
1279, 1.5, 0.7, 0
1280, 1.55, 0.7, 0
1281, 1.6, 0.7, 0
1282, 1.65, 0.7, 0
1283, 1.7, 0.7, 0
1284, 1.75, 0.7, 0
1285, 1.8, 0.7, 0
1286, 1.85, 0.7, 0
1287, 1.9, 0.7, 0
1288, 1.95, 0.7, 0
1289, 2, 0.7, 0
1290, 2.05, 0.7, 0
1291, 2.1, 0.7, 0
1292, 2.15, 0.7, 0
1293, 1.25, 0.65, 0
1294, 1.3, 0.65, 0
1295, 1.35, 0.65, 0
1296, 1.4, 0.65, 0
1297, 1.45, 0.65, 0
1298, 1.5, 0.65, 0
1299, 1.55, 0.65, 0
1300, 1.6, 0.65, 0
1301, 1.65, 0.65, 0
1302, 1.7, 0.65, 0
1303, 1.75, 0.65, 0
1304, 1.8, 0.65, 0
1305, 1.85, 0.65, 0
1306, 1.9, 0.65, 0
1307, 1.95, 0.65, 0
1308, 2, 0.65, 0
1309, 2.05, 0.65, 0
1310, 2.1, 0.65, 0
1311, 2.15, 0.65, 0
1312, 1.25, 0.6, 0
1313, 1.3, 0.6, 0
1314, 1.35, 0.6, 0
1315, 1.4, 0.6, 0
1316, 1.45, 0.6, 0
1317, 1.5, 0.6, 0
1318, 1.55, 0.6, 0
1319, 1.6, 0.6, 0
1320, 1.65, 0.6, 0
1321, 1.7, 0.6, 0
1322, 1.75, 0.6, 0
1323, 1.8, 0.6, 0
1324, 1.85, 0.6, 0
1325, 1.9, 0.6, 0
1326, 1.95, 0.6, 0
1327, 2, 0.6, 0
1328, 2.05, 0.6, 0
1329, 2.1, 0.6, 0
1330, 2.15, 0.6, 0
1331, 1.25, 0.55, 0
1332, 1.3, 0.55, 0
1333, 1.35, 0.55, 0
1334, 1.4, 0.55, 0
1335, 1.45, 0.55, 0
1336, 1.5, 0.55, 0
1337, 1.55, 0.55, 0
1338, 1.6, 0.55, 0
1339, 1.65, 0.55, 0
1340, 1.7, 0.55, 0
1341, 1.75, 0.55, 0
1342, 1.8, 0.55, 0
1343, 1.85, 0.55, 0
1344, 1.9, 0.55, 0
1345, 1.95, 0.55, 0
1346, 2, 0.55, 0
1347, 2.05, 0.55, 0
1348, 2.1, 0.55, 0
1349, 2.15, 0.55, 0
1350, 1.25, 0.5, 0
1351, 1.3, 0.5, 0
1352, 1.35, 0.5, 0
1353, 1.4, 0.5, 0
1354, 1.45, 0.5, 0
1355, 1.5, 0.5, 0
1356, 1.55, 0.5, 0
1357, 1.6, 0.5, 0
1358, 1.65, 0.5, 0
1359, 1.7, 0.5, 0
1360, 1.75, 0.5, 0
1361, 1.8, 0.5, 0
1362, 1.85, 0.5, 0
1363, 1.9, 0.5, 0
1364, 1.95, 0.5, 0
1365, 2, 0.5, 0
1366, 2.05, 0.5, 0
1367, 2.1, 0.5, 0
1368, 2.15, 0.5, 0
1369, 1.25, 0.45, 0
1370, 1.3, 0.45, 0
1371, 1.35, 0.45, 0
1372, 1.4, 0.45, 0
1373, 1.45, 0.45, 0
1374, 1.5, 0.45, 0
1375, 1.55, 0.45, 0
1376, 1.6, 0.45, 0
1377, 1.65, 0.45, 0
1378, 1.7, 0.45, 0
1379, 1.75, 0.45, 0
1380, 1.8, 0.45, 0
1381, 1.85, 0.45, 0
1382, 1.9, 0.45, 0
1383, 1.95, 0.45, 0
1384, 2, 0.45, 0
1385, 2.05, 0.45, 0
1386, 2.1, 0.45, 0
1387, 2.15, 0.45, 0
1388, 1.25, 0.4, 0
1389, 1.3, 0.4, 0
1390, 1.35, 0.4, 0
1391, 1.4, 0.4, 0
1392, 1.45, 0.4, 0
1393, 1.5, 0.4, 0
1394, 1.55, 0.4, 0
1395, 1.6, 0.4, 0
1396, 1.65, 0.4, 0
1397, 1.7, 0.4, 0
1398, 1.75, 0.4, 0
1399, 1.8, 0.4, 0
1400, 1.85, 0.4, 0
1401, 1.9, 0.4, 0
1402, 1.95, 0.4, 0
1403, 2, 0.4, 0
1404, 2.05, 0.4, 0
1405, 2.1, 0.4, 0
1406, 2.15, 0.4, 0
1407, 1.25, 0.35, 0
1408, 1.3, 0.35, 0
1409, 1.35, 0.35, 0
1410, 1.4, 0.35, 0
1411, 1.45, 0.35, 0
1412, 1.5, 0.35, 0
1413, 1.55, 0.35, 0
1414, 1.6, 0.35, 0
1415, 1.65, 0.35, 0
1416, 1.7, 0.35, 0
1417, 1.75, 0.35, 0
1418, 1.8, 0.35, 0
1419, 1.85, 0.35, 0
1420, 1.9, 0.35, 0
1421, 1.95, 0.35, 0
1422, 2, 0.35, 0
1423, 2.05, 0.35, 0
1424, 2.1, 0.35, 0
1425, 2.15, 0.35, 0
1426, 1.25, 0.3, 0
1427, 1.3, 0.3, 0
1428, 1.35, 0.3, 0
1429, 1.4, 0.3, 0
1430, 1.45, 0.3, 0
1431, 1.5, 0.3, 0
1432, 1.55, 0.3, 0
1433, 1.6, 0.3, 0
1434, 1.65, 0.3, 0
1435, 1.7, 0.3, 0
1436, 1.75, 0.3, 0
1437, 1.8, 0.3, 0
1438, 1.85, 0.3, 0
1439, 1.9, 0.3, 0
1440, 1.95, 0.3, 0
1441, 2, 0.3, 0
1442, 2.05, 0.3, 0
1443, 2.1, 0.3, 0
1444, 2.15, 0.3, 0
1445, 1.25, 0.25, 0
1446, 1.3, 0.25, 0
1447, 1.35, 0.25, 0
1448, 1.4, 0.25, 0
1449, 1.45, 0.25, 0
1450, 1.5, 0.25, 0
1451, 1.55, 0.25, 0
1452, 1.6, 0.25, 0
1453, 1.65, 0.25, 0
1454, 1.7, 0.25, 0
1455, 1.75, 0.25, 0
1456, 1.8, 0.25, 0
1457, 1.85, 0.25, 0
1458, 1.9, 0.25, 0
1459, 1.95, 0.25, 0
1460, 2, 0.25, 0
1461, 2.05, 0.25, 0
1462, 2.1, 0.25, 0
1463, 2.15, 0.25, 0
1464, 1.25, 0.2, 0
1465, 1.3, 0.2, 0
1466, 1.35, 0.2, 0
1467, 1.4, 0.2, 0
1468, 1.45, 0.2, 0
1469, 1.5, 0.2, 0
1470, 1.55, 0.2, 0
1471, 1.6, 0.2, 0
1472, 1.65, 0.2, 0
1473, 1.7, 0.2, 0
1474, 1.75, 0.2, 0
1475, 1.8, 0.2, 0
1476, 1.85, 0.2, 0
1477, 1.9, 0.2, 0
1478, 1.95, 0.2, 0
1479, 2, 0.2, 0
1480, 2.05, 0.2, 0
1481, 2.1, 0.2, 0
1482, 2.15, 0.2, 0
1483, 1.25, 0.15, 0
1484, 1.3, 0.15, 0
1485, 1.35, 0.15, 0
1486, 1.4, 0.15, 0
1487, 1.45, 0.15, 0
1488, 1.5, 0.15, 0
1489, 1.55, 0.15, 0
1490, 1.6, 0.15, 0
1491, 1.65, 0.15, 0
1492, 1.7, 0.15, 0
1493, 1.75, 0.15, 0
1494, 1.8, 0.15, 0
1495, 1.85, 0.15, 0
1496, 1.9, 0.15, 0
1497, 1.95, 0.15, 0
1498, 2, 0.15, 0
1499, 2.05, 0.15, 0
1500, 2.1, 0.15, 0
1501, 2.15, 0.15, 0
1502, 1.25, 0.1, 0
1503, 1.3, 0.1, 0
1504, 1.35, 0.1, 0
1505, 1.4, 0.1, 0
1506, 1.45, 0.1, 0
1507, 1.5, 0.1, 0
1508, 1.55, 0.1, 0
1509, 1.6, 0.1, 0
1510, 1.65, 0.1, 0
1511, 1.7, 0.1, 0
1512, 1.75, 0.1, 0
1513, 1.8, 0.1, 0
1514, 1.85, 0.1, 0
1515, 1.9, 0.1, 0
1516, 1.95, 0.1, 0
1517, 2, 0.1, 0
1518, 2.05, 0.1, 0
1519, 2.1, 0.1, 0
1520, 2.15, 0.1, 0
1521, 1.25, 0.05, 0
1522, 1.3, 0.05, 0
1523, 1.35, 0.05, 0
1524, 1.4, 0.05, 0
1525, 1.45, 0.05, 0
1526, 1.5, 0.05, 0
1527, 1.55, 0.05, 0
1528, 1.6, 0.05, 0
1529, 1.65, 0.05, 0
1530, 1.7, 0.05, 0
1531, 1.75, 0.05, 0
1532, 1.8, 0.05, 0
1533, 1.85, 0.05, 0
1534, 1.9, 0.05, 0
1535, 1.95, 0.05, 0
1536, 2, 0.05, 0
1537, 2.05, 0.05, 0
1538, 2.1, 0.05, 0
1539, 2.15, 0.05, 0
1540, 1.25, -0.05, 0
1541, 1.3, -0.05, 0
1542, 1.35, -0.05, 0
1543, 1.4, -0.05, 0
1544, 1.45, -0.05, 0
1545, 1.5, -0.05, 0
1546, 1.55, -0.05, 0
1547, 1.6, -0.05, 0
1548, 1.65, -0.05, 0
1549, 1.7, -0.05, 0
1550, 1.75, -0.05, 0
1551, 1.8, -0.05, 0
1552, 1.85, -0.05, 0
1553, 1.9, -0.05, 0
1554, 1.95, -0.05, 0
1555, 2, -0.05, 0
1556, 2.05, -0.05, 0
1557, 2.1, -0.05, 0
1558, 2.15, -0.05, 0
1559, 0.05, -0.05, 0
1560, 0.1, -0.05, 0
1561, 0.15, -0.05, 0
1562, 0.2, -0.05, 0
1563, 0.25, -0.05, 0
1564, 0.3, -0.05, 0
1565, 0.35, -0.05, 0
1566, 0.4, -0.05, 0
1567, 0.45, -0.05, 0
1568, 0.5, -0.05, 0
1569, 0.55, -0.05, 0
1570, 0.6, -0.05, 0
1571, 0.65, -0.05, 0
1572, 0.7, -0.05, 0
1573, 0.75, -0.05, 0
1574, 0.8, -0.05, 0
1575, 0.85, -0.05, 0
1576, 0.9, -0.05, 0
1577, 0.95, -0.05, 0
1578, 0.05, -0.125, 0
1579, 0.1, -0.125, 0
1580, 0.15, -0.125, 0
1581, 0.2, -0.125, 0
1582, 0.25, -0.125, 0
1583, 0.3, -0.125, 0
1584, 0.35, -0.125, 0
1585, 0.4, -0.125, 0
1586, 0.45, -0.125, 0
1587, 0.5, -0.125, 0
1588, 0.55, -0.125, 0
1589, 0.6, -0.125, 0
1590, 0.65, -0.125, 0
1591, 0.7, -0.125, 0
1592, 0.75, -0.125, 0
1593, 0.8, -0.125, 0
1594, 0.85, -0.125, 0
1595, 0.9, -0.125, 0
1596, 0.95, -0.125, 0
1597, 1.25, -0.125, 0
1598, 1.3, -0.125, 0
1599, 1.35, -0.125, 0
1600, 1.4, -0.125, 0
1601, 1.45, -0.125, 0
1602, 1.5, -0.125, 0
1603, 1.55, -0.125, 0
1604, 1.6, -0.125, 0
1605, 1.65, -0.125, 0
1606, 1.7, -0.125, 0
1607, 1.75, -0.125, 0
1608, 1.8, -0.125, 0
1609, 1.85, -0.125, 0
1610, 1.9, -0.125, 0
1611, 1.95, -0.125, 0
1612, 2, -0.125, 0
1613, 2.05, -0.125, 0
1614, 2.1, -0.125, 0
1615, 2.15, -0.125, 0
1616, 0.05, -0.18333333333333, 0
1617, 0.1, -0.18333333333333, 0
1618, 0.15, -0.18333333333333, 0
1619, 0.2, -0.18333333333333, 0
1620, 0.25, -0.18333333333333, 0
1621, 0.3, -0.18333333333333, 0
1622, 0.35, -0.18333333333333, 0
1623, 0.4, -0.18333333333333, 0
1624, 0.45, -0.18333333333333, 0
1625, 0.5, -0.18333333333333, 0
1626, 0.55, -0.18333333333333, 0
1627, 0.6, -0.18333333333333, 0
1628, 0.65, -0.18333333333333, 0
1629, 0.7, -0.18333333333333, 0
1630, 0.75, -0.18333333333333, 0
1631, 0.8, -0.18333333333333, 0
1632, 0.85, -0.18333333333333, 0
1633, 0.9, -0.18333333333333, 0
1634, 0.95, -0.18333333333333, 0
1635, 0.05, -0.21666666666667, 0
1636, 0.1, -0.21666666666667, 0
1637, 0.15, -0.21666666666667, 0
1638, 0.2, -0.21666666666667, 0
1639, 0.25, -0.21666666666667, 0
1640, 0.3, -0.21666666666667, 0
1641, 0.35, -0.21666666666667, 0
1642, 0.4, -0.21666666666667, 0
1643, 0.45, -0.21666666666667, 0
1644, 0.5, -0.21666666666667, 0
1645, 0.55, -0.21666666666667, 0
1646, 0.6, -0.21666666666667, 0
1647, 0.65, -0.21666666666667, 0
1648, 0.7, -0.21666666666667, 0
1649, 0.75, -0.21666666666667, 0
1650, 0.8, -0.21666666666667, 0
1651, 0.85, -0.21666666666667, 0
1652, 0.9, -0.21666666666667, 0
1653, 0.95, -0.21666666666667, 0
1654, 1.25, -0.18333333333333, 0
1655, 1.3, -0.18333333333333, 0
1656, 1.35, -0.18333333333333, 0
1657, 1.4, -0.18333333333333, 0
1658, 1.45, -0.18333333333333, 0
1659, 1.5, -0.18333333333333, 0
1660, 1.55, -0.18333333333333, 0
1661, 1.6, -0.18333333333333, 0
1662, 1.65, -0.18333333333333, 0
1663, 1.7, -0.18333333333333, 0
1664, 1.75, -0.18333333333333, 0
1665, 1.8, -0.18333333333333, 0
1666, 1.85, -0.18333333333333, 0
1667, 1.9, -0.18333333333333, 0
1668, 1.95, -0.18333333333333, 0
1669, 2, -0.18333333333333, 0
1670, 2.05, -0.18333333333333, 0
1671, 2.1, -0.18333333333333, 0
1672, 2.15, -0.18333333333333, 0
1673, 1.25, -0.21666666666667, 0
1674, 1.3, -0.21666666666667, 0
1675, 1.35, -0.21666666666667, 0
1676, 1.4, -0.21666666666667, 0
1677, 1.45, -0.21666666666667, 0
1678, 1.5, -0.21666666666667, 0
1679, 1.55, -0.21666666666667, 0
1680, 1.6, -0.21666666666667, 0
1681, 1.65, -0.21666666666667, 0
1682, 1.7, -0.21666666666667, 0
1683, 1.75, -0.21666666666667, 0
1684, 1.8, -0.21666666666667, 0
1685, 1.85, -0.21666666666667, 0
1686, 1.9, -0.21666666666667, 0
1687, 1.95, -0.21666666666667, 0
1688, 2, -0.21666666666667, 0
1689, 2.05, -0.21666666666667, 0
1690, 2.1, -0.21666666666667, 0
1691, 2.15, -0.21666666666667, 0
1692, -0.05, -0.18333333333333, 0
1693, -0.05, -0.21666666666667, 0
1694, -0.1, -0.18333333333333, 0
1695, -0.1, -0.21666666666667, 0
1696, -0.15, -0.18333333333333, 0
1697, -0.15, -0.21666666666667, 0
1698, 2.25, -0.18333333333333, 0
1699, 2.25, -0.21666666666667, 0
1700, 2.3, -0.18333333333333, 0
1701, 2.3, -0.21666666666667, 0
1702, 2.35, -0.18333333333333, 0
1703, 2.35, -0.21666666666667, 0
1704, -0.05, -0.29, 0
1705, -0.1, -0.29, 0
1706, -0.15, -0.29, 0
1707, -0.05, -0.33, 0
1708, -0.1, -0.33, 0
1709, -0.15, -0.33, 0
1710, -0.05, -0.37, 0
1711, -0.1, -0.37, 0
1712, -0.15, -0.37, 0
1713, -0.05, -0.41, 0
1714, -0.1, -0.41, 0
1715, -0.15, -0.41, 0
1716, 0.05, -0.29, 0
1717, 0.1, -0.29, 0
1718, 0.15, -0.29, 0
1719, 0.2, -0.29, 0
1720, 0.25, -0.29, 0
1721, 0.3, -0.29, 0
1722, 0.35, -0.29, 0
1723, 0.4, -0.29, 0
1724, 0.45, -0.29, 0
1725, 0.5, -0.29, 0
1726, 0.55, -0.29, 0
1727, 0.6, -0.29, 0
1728, 0.65, -0.29, 0
1729, 0.7, -0.29, 0
1730, 0.75, -0.29, 0
1731, 0.8, -0.29, 0
1732, 0.85, -0.29, 0
1733, 0.9, -0.29, 0
1734, 0.95, -0.29, 0
1735, 0.05, -0.33, 0
1736, 0.1, -0.33, 0
1737, 0.15, -0.33, 0
1738, 0.2, -0.33, 0
1739, 0.25, -0.33, 0
1740, 0.3, -0.33, 0
1741, 0.35, -0.33, 0
1742, 0.4, -0.33, 0
1743, 0.45, -0.33, 0
1744, 0.5, -0.33, 0
1745, 0.55, -0.33, 0
1746, 0.6, -0.33, 0
1747, 0.65, -0.33, 0
1748, 0.7, -0.33, 0
1749, 0.75, -0.33, 0
1750, 0.8, -0.33, 0
1751, 0.85, -0.33, 0
1752, 0.9, -0.33, 0
1753, 0.95, -0.33, 0
1754, 0.05, -0.37, 0
1755, 0.1, -0.37, 0
1756, 0.15, -0.37, 0
1757, 0.2, -0.37, 0
1758, 0.25, -0.37, 0
1759, 0.3, -0.37, 0
1760, 0.35, -0.37, 0
1761, 0.4, -0.37, 0
1762, 0.45, -0.37, 0
1763, 0.5, -0.37, 0
1764, 0.55, -0.37, 0
1765, 0.6, -0.37, 0
1766, 0.65, -0.37, 0
1767, 0.7, -0.37, 0
1768, 0.75, -0.37, 0
1769, 0.8, -0.37, 0
1770, 0.85, -0.37, 0
1771, 0.9, -0.37, 0
1772, 0.95, -0.37, 0
1773, 0.05, -0.41, 0
1774, 0.1, -0.41, 0
1775, 0.15, -0.41, 0
1776, 0.2, -0.41, 0
1777, 0.25, -0.41, 0
1778, 0.3, -0.41, 0
1779, 0.35, -0.41, 0
1780, 0.4, -0.41, 0
1781, 0.45, -0.41, 0
1782, 0.5, -0.41, 0
1783, 0.55, -0.41, 0
1784, 0.6, -0.41, 0
1785, 0.65, -0.41, 0
1786, 0.7, -0.41, 0
1787, 0.75, -0.41, 0
1788, 0.8, -0.41, 0
1789, 0.85, -0.41, 0
1790, 0.9, -0.41, 0
1791, 0.95, -0.41, 0
1792, 1.25, -0.29, 0
1793, 1.3, -0.29, 0
1794, 1.35, -0.29, 0
1795, 1.4, -0.29, 0
1796, 1.45, -0.29, 0
1797, 1.5, -0.29, 0
1798, 1.55, -0.29, 0
1799, 1.6, -0.29, 0
1800, 1.65, -0.29, 0
1801, 1.7, -0.29, 0
1802, 1.75, -0.29, 0
1803, 1.8, -0.29, 0
1804, 1.85, -0.29, 0
1805, 1.9, -0.29, 0
1806, 1.95, -0.29, 0
1807, 2, -0.29, 0
1808, 2.05, -0.29, 0
1809, 2.1, -0.29, 0
1810, 2.15, -0.29, 0
1811, 1.25, -0.33, 0
1812, 1.3, -0.33, 0
1813, 1.35, -0.33, 0
1814, 1.4, -0.33, 0
1815, 1.45, -0.33, 0
1816, 1.5, -0.33, 0
1817, 1.55, -0.33, 0
1818, 1.6, -0.33, 0
1819, 1.65, -0.33, 0
1820, 1.7, -0.33, 0
1821, 1.75, -0.33, 0
1822, 1.8, -0.33, 0
1823, 1.85, -0.33, 0
1824, 1.9, -0.33, 0
1825, 1.95, -0.33, 0
1826, 2, -0.33, 0
1827, 2.05, -0.33, 0
1828, 2.1, -0.33, 0
1829, 2.15, -0.33, 0
1830, 1.25, -0.37, 0
1831, 1.3, -0.37, 0
1832, 1.35, -0.37, 0
1833, 1.4, -0.37, 0
1834, 1.45, -0.37, 0
1835, 1.5, -0.37, 0
1836, 1.55, -0.37, 0
1837, 1.6, -0.37, 0
1838, 1.65, -0.37, 0
1839, 1.7, -0.37, 0
1840, 1.75, -0.37, 0
1841, 1.8, -0.37, 0
1842, 1.85, -0.37, 0
1843, 1.9, -0.37, 0
1844, 1.95, -0.37, 0
1845, 2, -0.37, 0
1846, 2.05, -0.37, 0
1847, 2.1, -0.37, 0
1848, 2.15, -0.37, 0
1849, 1.25, -0.41, 0
1850, 1.3, -0.41, 0
1851, 1.35, -0.41, 0
1852, 1.4, -0.41, 0
1853, 1.45, -0.41, 0
1854, 1.5, -0.41, 0
1855, 1.55, -0.41, 0
1856, 1.6, -0.41, 0
1857, 1.65, -0.41, 0
1858, 1.7, -0.41, 0
1859, 1.75, -0.41, 0
1860, 1.8, -0.41, 0
1861, 1.85, -0.41, 0
1862, 1.9, -0.41, 0
1863, 1.95, -0.41, 0
1864, 2, -0.41, 0
1865, 2.05, -0.41, 0
1866, 2.1, -0.41, 0
1867, 2.15, -0.41, 0
1868, 2.25, -0.29, 0
1869, 2.3, -0.29, 0
1870, 2.35, -0.29, 0
1871, 2.25, -0.33, 0
1872, 2.3, -0.33, 0
1873, 2.35, -0.33, 0
1874, 2.25, -0.37, 0
1875, 2.3, -0.37, 0
1876, 2.35, -0.37, 0
1877, 2.25, -0.41, 0
1878, 2.3, -0.41, 0
1879, 2.35, -0.41, 0
1880, 0.95, 1.29, 0
1881, 0.9, 1.29, 0
1882, 0.85, 1.29, 0
1883, 0.8, 1.29, 0
1884, 0.75, 1.29, 0
1885, 0.7, 1.29, 0
1886, 0.65, 1.29, 0
1887, 0.6, 1.29, 0
1888, 0.55, 1.29, 0
1889, 0.5, 1.29, 0
1890, 0.45, 1.29, 0
1891, 0.4, 1.29, 0
1892, 0.35, 1.29, 0
1893, 0.3, 1.29, 0
1894, 0.25, 1.29, 0
1895, 0.2, 1.29, 0
1896, 0.15, 1.29, 0
1897, 0.1, 1.29, 0
1898, 0.05, 1.29, 0
1899, 0.95, 1.33, 0
1900, 0.9, 1.33, 0
1901, 0.85, 1.33, 0
1902, 0.8, 1.33, 0
1903, 0.75, 1.33, 0
1904, 0.7, 1.33, 0
1905, 0.65, 1.33, 0
1906, 0.6, 1.33, 0
1907, 0.55, 1.33, 0
1908, 0.5, 1.33, 0
1909, 0.45, 1.33, 0
1910, 0.4, 1.33, 0
1911, 0.35, 1.33, 0
1912, 0.3, 1.33, 0
1913, 0.25, 1.33, 0
1914, 0.2, 1.33, 0
1915, 0.15, 1.33, 0
1916, 0.1, 1.33, 0
1917, 0.05, 1.33, 0
1918, 0.95, 1.37, 0
1919, 0.9, 1.37, 0
1920, 0.85, 1.37, 0
1921, 0.8, 1.37, 0
1922, 0.75, 1.37, 0
1923, 0.7, 1.37, 0
1924, 0.65, 1.37, 0
1925, 0.6, 1.37, 0
1926, 0.55, 1.37, 0
1927, 0.5, 1.37, 0
1928, 0.45, 1.37, 0
1929, 0.4, 1.37, 0
1930, 0.35, 1.37, 0
1931, 0.3, 1.37, 0
1932, 0.25, 1.37, 0
1933, 0.2, 1.37, 0
1934, 0.15, 1.37, 0
1935, 0.1, 1.37, 0
1936, 0.05, 1.37, 0
1937, 0.95, 1.41, 0
1938, 0.9, 1.41, 0
1939, 0.85, 1.41, 0
1940, 0.8, 1.41, 0
1941, 0.75, 1.41, 0
1942, 0.7, 1.41, 0
1943, 0.65, 1.41, 0
1944, 0.6, 1.41, 0
1945, 0.55, 1.41, 0
1946, 0.5, 1.41, 0
1947, 0.45, 1.41, 0
1948, 0.4, 1.41, 0
1949, 0.35, 1.41, 0
1950, 0.3, 1.41, 0
1951, 0.25, 1.41, 0
1952, 0.2, 1.41, 0
1953, 0.15, 1.41, 0
1954, 0.1, 1.41, 0
1955, 0.05, 1.41, 0
1956, 1.05, 1.29, 0
1957, 1.1, 1.29, 0
1958, 1.15, 1.29, 0
1959, 1.05, 1.33, 0
1960, 1.1, 1.33, 0
1961, 1.15, 1.33, 0
1962, 1.05, 1.37, 0
1963, 1.1, 1.37, 0
1964, 1.15, 1.37, 0
1965, 1.05, 1.41, 0
1966, 1.1, 1.41, 0
1967, 1.15, 1.41, 0
1968, 1.25, 1.29, 0
1969, 1.3, 1.29, 0
1970, 1.35, 1.29, 0
1971, 1.4, 1.29, 0
1972, 1.45, 1.29, 0
1973, 1.5, 1.29, 0
1974, 1.55, 1.29, 0
1975, 1.6, 1.29, 0
1976, 1.65, 1.29, 0
1977, 1.7, 1.29, 0
1978, 1.75, 1.29, 0
1979, 1.8, 1.29, 0
1980, 1.85, 1.29, 0
1981, 1.9, 1.29, 0
1982, 1.95, 1.29, 0
1983, 2, 1.29, 0
1984, 2.05, 1.29, 0
1985, 2.1, 1.29, 0
1986, 2.15, 1.29, 0
1987, 1.25, 1.33, 0
1988, 1.3, 1.33, 0
1989, 1.35, 1.33, 0
1990, 1.4, 1.33, 0
1991, 1.45, 1.33, 0
1992, 1.5, 1.33, 0
1993, 1.55, 1.33, 0
1994, 1.6, 1.33, 0
1995, 1.65, 1.33, 0
1996, 1.7, 1.33, 0
1997, 1.75, 1.33, 0
1998, 1.8, 1.33, 0
1999, 1.85, 1.33, 0
2000, 1.9, 1.33, 0
2001, 1.95, 1.33, 0
2002, 2, 1.33, 0
2003, 2.05, 1.33, 0
2004, 2.1, 1.33, 0
2005, 2.15, 1.33, 0
2006, 1.25, 1.37, 0
2007, 1.3, 1.37, 0
2008, 1.35, 1.37, 0
2009, 1.4, 1.37, 0
2010, 1.45, 1.37, 0
2011, 1.5, 1.37, 0
2012, 1.55, 1.37, 0
2013, 1.6, 1.37, 0
2014, 1.65, 1.37, 0
2015, 1.7, 1.37, 0
2016, 1.75, 1.37, 0
2017, 1.8, 1.37, 0
2018, 1.85, 1.37, 0
2019, 1.9, 1.37, 0
2020, 1.95, 1.37, 0
2021, 2, 1.37, 0
2022, 2.05, 1.37, 0
2023, 2.1, 1.37, 0
2024, 2.15, 1.37, 0
2025, 1.25, 1.41, 0
2026, 1.3, 1.41, 0
2027, 1.35, 1.41, 0
2028, 1.4, 1.41, 0
2029, 1.45, 1.41, 0
2030, 1.5, 1.41, 0
2031, 1.55, 1.41, 0
2032, 1.6, 1.41, 0
2033, 1.65, 1.41, 0
2034, 1.7, 1.41, 0
2035, 1.75, 1.41, 0
2036, 1.8, 1.41, 0
2037, 1.85, 1.41, 0
2038, 1.9, 1.41, 0
2039, 1.95, 1.41, 0
2040, 2, 1.41, 0
2041, 2.05, 1.41, 0
2042, 2.1, 1.41, 0
2043, 2.15, 1.41, 0
2044, -0.05, 0.95, 0
2045, -0.05, 0.9, 0
2046, -0.05, 0.85, 0
2047, -0.05, 0.8, 0
2048, -0.05, 0.75, 0
2049, -0.05, 0.7, 0
2050, -0.05, 0.65, 0
2051, -0.05, 0.6, 0
2052, -0.05, 0.55, 0
2053, -0.05, 0.5, 0
2054, -0.05, 0.45, 0
2055, -0.05, 0.4, 0
2056, -0.05, 0.35, 0
2057, -0.05, 0.3, 0
2058, -0.05, 0.25, 0
2059, -0.05, 0.2, 0
2060, -0.05, 0.15, 0
2061, -0.05, 0.1, 0
2062, -0.05, 0.05, 0
2063, -0.1, 0.95, 0
2064, -0.1, 0.9, 0
2065, -0.1, 0.85, 0
2066, -0.1, 0.8, 0
2067, -0.1, 0.75, 0
2068, -0.1, 0.7, 0
2069, -0.1, 0.65, 0
2070, -0.1, 0.6, 0
2071, -0.1, 0.55, 0
2072, -0.1, 0.5, 0
2073, -0.1, 0.45, 0
2074, -0.1, 0.4, 0
2075, -0.1, 0.35, 0
2076, -0.1, 0.3, 0
2077, -0.1, 0.25, 0
2078, -0.1, 0.2, 0
2079, -0.1, 0.15, 0
2080, -0.1, 0.1, 0
2081, -0.1, 0.05, 0
2082, -0.15, 0.95, 0
2083, -0.15, 0.9, 0
2084, -0.15, 0.85, 0
2085, -0.15, 0.8, 0
2086, -0.15, 0.75, 0
2087, -0.15, 0.7, 0
2088, -0.15, 0.65, 0
2089, -0.15, 0.6, 0
2090, -0.15, 0.55, 0
2091, -0.15, 0.5, 0
2092, -0.15, 0.45, 0
2093, -0.15, 0.4, 0
2094, -0.15, 0.35, 0
2095, -0.15, 0.3, 0
2096, -0.15, 0.25, 0
2097, -0.15, 0.2, 0
2098, -0.15, 0.15, 0
2099, -0.15, 0.1, 0
2100, -0.15, 0.05, 0
2101, 2.25, 0.95, 0
2102, 2.25, 0.9, 0
2103, 2.25, 0.85, 0
2104, 2.25, 0.8, 0
2105, 2.25, 0.75, 0
2106, 2.25, 0.7, 0
2107, 2.25, 0.65, 0
2108, 2.25, 0.6, 0
2109, 2.25, 0.55, 0
2110, 2.25, 0.5, 0
2111, 2.25, 0.45, 0
2112, 2.25, 0.4, 0
2113, 2.25, 0.35, 0
2114, 2.25, 0.3, 0
2115, 2.25, 0.25, 0
2116, 2.25, 0.2, 0
2117, 2.25, 0.15, 0
2118, 2.25, 0.1, 0
2119, 2.25, 0.05, 0
2120, 2.3, 0.95, 0
2121, 2.3, 0.9, 0
2122, 2.3, 0.85, 0
2123, 2.3, 0.8, 0
2124, 2.3, 0.75, 0
2125, 2.3, 0.7, 0
2126, 2.3, 0.65, 0
2127, 2.3, 0.6, 0
2128, 2.3, 0.55, 0
2129, 2.3, 0.5, 0
2130, 2.3, 0.45, 0
2131, 2.3, 0.4, 0
2132, 2.3, 0.35, 0
2133, 2.3, 0.3, 0
2134, 2.3, 0.25, 0
2135, 2.3, 0.2, 0
2136, 2.3, 0.15, 0
2137, 2.3, 0.1, 0
2138, 2.3, 0.05, 0
2139, 2.35, 0.95, 0
2140, 2.35, 0.9, 0
2141, 2.35, 0.85, 0
2142, 2.35, 0.8, 0
2143, 2.35, 0.75, 0
2144, 2.35, 0.7, 0
2145, 2.35, 0.65, 0
2146, 2.35, 0.6, 0
2147, 2.35, 0.55, 0
2148, 2.35, 0.5, 0
2149, 2.35, 0.45, 0
2150, 2.35, 0.4, 0
2151, 2.35, 0.35, 0
2152, 2.35, 0.3, 0
2153, 2.35, 0.25, 0
2154, 2.35, 0.2, 0
2155, 2.35, 0.15, 0
2156, 2.35, 0.1, 0
2157, 2.35, 0.05, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
51, 1, 51
52, 51, 52
53, 52, 53
54, 53, 54
55, 54, 55
56, 55, 56
57, 56, 57
58, 57, 58
59, 58, 59
60, 59, 60
61, 60, 61
62, 61, 62
63, 62, 63
64, 63, 64
65, 64, 65
66, 65, 66
67, 66, 67
68, 67, 68
69, 68, 69
70, 69, 2
*ELEMENT, type=T3D2, ELSET=Line2
71, 2, 70
72, 70, 71
73, 71, 72
74, 72, 73
75, 73, 74
76, 74, 75
77, 75, 76
78, 76, 77
79, 77, 78
80, 78, 79
81, 79, 80
82, 80, 81
83, 81, 82
84, 82, 83
85, 83, 84
86, 84, 85
87, 85, 86
88, 86, 87
89, 87, 88
90, 88, 3
*ELEMENT, type=T3D2, ELSET=Line3
91, 3, 89
92, 89, 90
93, 90, 91
94, 91, 92
95, 92, 93
96, 93, 94
97, 94, 95
98, 95, 96
99, 96, 97
100, 97, 98
101, 98, 99
102, 99, 100
103, 100, 101
104, 101, 102
105, 102, 103
106, 103, 104
107, 104, 105
108, 105, 106
109, 106, 107
110, 107, 4
*ELEMENT, type=T3D2, ELSET=Line4
111, 4, 108
112, 108, 109
113, 109, 110
114, 110, 111
115, 111, 112
116, 112, 113
117, 113, 114
118, 114, 115
119, 115, 116
120, 116, 117
121, 117, 118
122, 118, 119
123, 119, 120
124, 120, 121
125, 121, 122
126, 122, 123
127, 123, 124
128, 124, 125
129, 125, 126
130, 126, 1
*ELEMENT, type=T3D2, ELSET=Line5
131, 3, 127
132, 127, 5
*ELEMENT, type=T3D2, ELSET=Line6
133, 4, 128
134, 128, 6
*ELEMENT, type=T3D2, ELSET=Line7
135, 5, 129
136, 129, 130
137, 130, 131
138, 131, 132
139, 132, 133
140, 133, 134
141, 134, 135
142, 135, 136
143, 136, 137
144, 137, 138
145, 138, 139
146, 139, 140
147, 140, 141
148, 141, 142
149, 142, 143
150, 143, 144
151, 144, 145
152, 145, 146
153, 146, 147
154, 147, 6
*ELEMENT, type=T3D2, ELSET=Line8
155, 5, 148
156, 148, 7
*ELEMENT, type=T3D2, ELSET=Line9
157, 6, 149
158, 149, 8
*ELEMENT, type=T3D2, ELSET=Line10
159, 7, 150
160, 150, 151
161, 151, 152
162, 152, 153
163, 153, 154
164, 154, 155
165, 155, 156
166, 156, 157
167, 157, 158
168, 158, 159
169, 159, 160
170, 160, 161
171, 161, 162
172, 162, 163
173, 163, 164
174, 164, 165
175, 165, 166
176, 166, 167
177, 167, 168
178, 168, 8
*ELEMENT, type=T3D2, ELSET=Line11
179, 7, 169
180, 169, 170
181, 170, 9
*ELEMENT, type=T3D2, ELSET=Line12
182, 8, 171
183, 171, 172
184, 172, 10
*ELEMENT, type=T3D2, ELSET=Line13
185, 9, 173
186, 173, 174
187, 174, 175
188, 175, 176
189, 176, 177
190, 177, 178
191, 178, 179
192, 179, 180
193, 180, 181
194, 181, 182
195, 182, 183
196, 183, 184
197, 184, 185
198, 185, 186
199, 186, 187
200, 187, 188
201, 188, 189
202, 189, 190
203, 190, 191
204, 191, 10
*ELEMENT, type=T3D2, ELSET=Line14
205, 7, 192
206, 192, 193
207, 193, 194
208, 194, 11
*ELEMENT, type=T3D2, ELSET=Line15
209, 9, 195
210, 195, 196
211, 196, 197
212, 197, 12
*ELEMENT, type=T3D2, ELSET=Line16
213, 11, 198
214, 198, 199
215, 199, 12
*ELEMENT, type=T3D2, ELSET=Line17
216, 11, 200
217, 200, 201
218, 201, 202
219, 202, 203
220, 203, 204
221, 204, 205
222, 205, 206
223, 206, 207
224, 207, 208
225, 208, 209
226, 209, 210
227, 210, 211
228, 211, 212
229, 212, 213
230, 213, 214
231, 214, 215
232, 215, 216
233, 216, 217
234, 217, 218
235, 218, 13
*ELEMENT, type=T3D2, ELSET=Line18
236, 12, 219
237, 219, 220
238, 220, 221
239, 221, 222
240, 222, 223
241, 223, 224
242, 224, 225
243, 225, 226
244, 226, 227
245, 227, 228
246, 228, 229
247, 229, 230
248, 230, 231
249, 231, 232
250, 232, 233
251, 233, 234
252, 234, 235
253, 235, 236
254, 236, 237
255, 237, 14
*ELEMENT, type=T3D2, ELSET=Line19
256, 13, 238
257, 238, 239
258, 239, 14
*ELEMENT, type=T3D2, ELSET=Line20
259, 11, 240
260, 240, 15
*ELEMENT, type=T3D2, ELSET=Line21
261, 13, 241
262, 241, 16
*ELEMENT, type=T3D2, ELSET=Line22
263, 15, 242
264, 242, 243
265, 243, 244
266, 244, 245
267, 245, 246
268, 246, 247
269, 247, 248
270, 248, 249
271, 249, 250
272, 250, 251
273, 251, 252
274, 252, 253
275, 253, 254
276, 254, 255
277, 255, 256
278, 256, 257
279, 257, 258
280, 258, 259
281, 259, 260
282, 260, 16
*ELEMENT, type=T3D2, ELSET=Line23
283, 15, 261
284, 261, 17
*ELEMENT, type=T3D2, ELSET=Line24
285, 16, 262
286, 262, 18
*ELEMENT, type=T3D2, ELSET=Line25
287, 17, 263
288, 263, 264
289, 264, 265
290, 265, 266
291, 266, 267
292, 267, 268
293, 268, 269
294, 269, 270
295, 270, 271
296, 271, 272
297, 272, 273
298, 273, 274
299, 274, 275
300, 275, 276
301, 276, 277
302, 277, 278
303, 278, 279
304, 279, 280
305, 280, 281
306, 281, 18
*ELEMENT, type=T3D2, ELSET=Line26
307, 17, 282
308, 282, 283
309, 283, 284
310, 284, 285
311, 285, 286
312, 286, 287
313, 287, 288
314, 288, 289
315, 289, 290
316, 290, 291
317, 291, 292
318, 292, 293
319, 293, 294
320, 294, 295
321, 295, 296
322, 296, 297
323, 297, 298
324, 298, 299
325, 299, 300
326, 300, 19
*ELEMENT, type=T3D2, ELSET=Line27
327, 18, 301
328, 301, 302
329, 302, 303
330, 303, 304
331, 304, 305
332, 305, 306
333, 306, 307
334, 307, 308
335, 308, 309
336, 309, 310
337, 310, 311
338, 311, 312
339, 312, 313
340, 313, 314
341, 314, 315
342, 315, 316
343, 316, 317
344, 317, 318
345, 318, 319
346, 319, 20
*ELEMENT, type=T3D2, ELSET=Line28
347, 19, 320
348, 320, 321
349, 321, 322
350, 322, 323
351, 323, 324
352, 324, 325
353, 325, 326
354, 326, 327
355, 327, 328
356, 328, 329
357, 329, 330
358, 330, 331
359, 331, 332
360, 332, 333
361, 333, 334
362, 334, 335
363, 335, 336
364, 336, 337
365, 337, 338
366, 338, 20
*ELEMENT, type=T3D2, ELSET=Line29
367, 19, 339
368, 339, 21
*ELEMENT, type=T3D2, ELSET=Line30
369, 20, 340
370, 340, 22
*ELEMENT, type=T3D2, ELSET=Line31
371, 21, 341
372, 341, 342
373, 342, 343
374, 343, 344
375, 344, 345
376, 345, 346
377, 346, 347
378, 347, 348
379, 348, 349
380, 349, 350
381, 350, 351
382, 351, 352
383, 352, 353
384, 353, 354
385, 354, 355
386, 355, 356
387, 356, 357
388, 357, 358
389, 358, 359
390, 359, 22
*ELEMENT, type=T3D2, ELSET=Line32
391, 1, 360
392, 360, 23
*ELEMENT, type=T3D2, ELSET=Line33
393, 2, 361
394, 361, 24
*ELEMENT, type=T3D2, ELSET=Line34
395, 23, 362
396, 362, 363
397, 363, 364
398, 364, 365
399, 365, 366
400, 366, 367
401, 367, 368
402, 368, 369
403, 369, 370
404, 370, 371
405, 371, 372
406, 372, 373
407, 373, 374
408, 374, 375
409, 375, 376
410, 376, 377
411, 377, 378
412, 378, 379
413, 379, 380
414, 380, 24
*ELEMENT, type=T3D2, ELSET=Line35
415, 23, 381
416, 381, 25
*ELEMENT, type=T3D2, ELSET=Line36
417, 24, 382
418, 382, 26
*ELEMENT, type=T3D2, ELSET=Line37
419, 25, 383
420, 383, 384
421, 384, 385
422, 385, 386
423, 386, 387
424, 387, 388
425, 388, 389
426, 389, 390
427, 390, 391
428, 391, 392
429, 392, 393
430, 393, 394
431, 394, 395
432, 395, 396
433, 396, 397
434, 397, 398
435, 398, 399
436, 399, 400
437, 400, 401
438, 401, 26
*ELEMENT, type=T3D2, ELSET=Line38
439, 21, 402
440, 402, 27
*ELEMENT, type=T3D2, ELSET=Line39
441, 22, 403
442, 403, 28
*ELEMENT, type=T3D2, ELSET=Line40
443, 27, 404
444, 404, 405
445, 405, 406
446, 406, 407
447, 407, 408
448, 408, 409
449, 409, 410
450, 410, 411
451, 411, 412
452, 412, 413
453, 413, 414
454, 414, 415
455, 415, 416
456, 416, 417
457, 417, 418
458, 418, 419
459, 419, 420
460, 420, 421
461, 421, 422
462, 422, 28
*ELEMENT, type=T3D2, ELSET=Line41
463, 25, 423
464, 423, 424
465, 424, 29
*ELEMENT, type=T3D2, ELSET=Line42
466, 26, 425
467, 425, 426
468, 426, 30
*ELEMENT, type=T3D2, ELSET=Line43
469, 29, 427
470, 427, 428
471, 428, 429
472, 429, 430
473, 430, 431
474, 431, 432
475, 432, 433
476, 433, 434
477, 434, 435
478, 435, 436
479, 436, 437
480, 437, 438
481, 438, 439
482, 439, 440
483, 440, 441
484, 441, 442
485, 442, 443
486, 443, 444
487, 444, 445
488, 445, 30
*ELEMENT, type=T3D2, ELSET=Line44
489, 27, 446
490, 446, 447
491, 447, 31
*ELEMENT, type=T3D2, ELSET=Line45
492, 28, 448
493, 448, 449
494, 449, 32
*ELEMENT, type=T3D2, ELSET=Line46
495, 31, 450
496, 450, 451
497, 451, 452
498, 452, 453
499, 453, 454
500, 454, 455
501, 455, 456
502, 456, 457
503, 457, 458
504, 458, 459
505, 459, 460
506, 460, 461
507, 461, 462
508, 462, 463
509, 463, 464
510, 464, 465
511, 465, 466
512, 466, 467
513, 467, 468
514, 468, 32
*ELEMENT, type=T3D2, ELSET=Line47
515, 25, 469
516, 469, 470
517, 470, 471
518, 471, 33
*ELEMENT, type=T3D2, ELSET=Line48
519, 29, 472
520, 472, 473
521, 473, 474
522, 474, 34
*ELEMENT, type=T3D2, ELSET=Line49
523, 33, 475
524, 475, 476
525, 476, 34
*ELEMENT, type=T3D2, ELSET=Line50
526, 28, 477
527, 477, 478
528, 478, 479
529, 479, 35
*ELEMENT, type=T3D2, ELSET=Line51
530, 32, 480
531, 480, 481
532, 481, 482
533, 482, 36
*ELEMENT, type=T3D2, ELSET=Line52
534, 35, 483
535, 483, 484
536, 484, 36
*ELEMENT, type=T3D2, ELSET=Line53
537, 29, 485
538, 485, 486
539, 486, 487
540, 487, 488
541, 488, 37
*ELEMENT, type=T3D2, ELSET=Line54
542, 34, 489
543, 489, 490
544, 490, 491
545, 491, 492
546, 492, 38
*ELEMENT, type=T3D2, ELSET=Line55
547, 37, 493
548, 493, 494
549, 494, 495
550, 495, 38
*ELEMENT, type=T3D2, ELSET=Line56
551, 30, 496
552, 496, 497
553, 497, 498
554, 498, 499
555, 499, 39
*ELEMENT, type=T3D2, ELSET=Line57
556, 37, 500
557, 500, 501
558, 501, 502
559, 502, 503
560, 503, 504
561, 504, 505
562, 505, 506
563, 506, 507
564, 507, 508
565, 508, 509
566, 509, 510
567, 510, 511
568, 511, 512
569, 512, 513
570, 513, 514
571, 514, 515
572, 515, 516
573, 516, 517
574, 517, 518
575, 518, 39
*ELEMENT, type=T3D2, ELSET=Line58
576, 31, 519
577, 519, 520
578, 520, 521
579, 521, 522
580, 522, 40
*ELEMENT, type=T3D2, ELSET=Line59
581, 32, 523
582, 523, 524
583, 524, 525
584, 525, 526
585, 526, 41
*ELEMENT, type=T3D2, ELSET=Line60
586, 40, 527
587, 527, 528
588, 528, 529
589, 529, 530
590, 530, 531
591, 531, 532
592, 532, 533
593, 533, 534
594, 534, 535
595, 535, 536
596, 536, 537
597, 537, 538
598, 538, 539
599, 539, 540
600, 540, 541
601, 541, 542
602, 542, 543
603, 543, 544
604, 544, 545
605, 545, 41
*ELEMENT, type=T3D2, ELSET=Line61
606, 36, 546
607, 546, 547
608, 547, 548
609, 548, 549
610, 549, 42
*ELEMENT, type=T3D2, ELSET=Line62
611, 41, 550
612, 550, 551
613, 551, 552
614, 552, 42
*ELEMENT, type=T3D2, ELSET=Line63
615, 9, 553
616, 553, 554
617, 554, 555
618, 555, 556
619, 556, 43
*ELEMENT, type=T3D2, ELSET=Line64
620, 10, 557
621, 557, 558
622, 558, 559
623, 559, 560
624, 560, 44
*ELEMENT, type=T3D2, ELSET=Line65
625, 43, 561
626, 561, 562
627, 562, 563
628, 563, 564
629, 564, 565
630, 565, 566
631, 566, 567
632, 567, 568
633, 568, 569
634, 569, 570
635, 570, 571
636, 571, 572
637, 572, 573
638, 573, 574
639, 574, 575
640, 575, 576
641, 576, 577
642, 577, 578
643, 578, 579
644, 579, 44
*ELEMENT, type=T3D2, ELSET=Line66
645, 12, 580
646, 580, 581
647, 581, 582
648, 582, 583
649, 583, 45
*ELEMENT, type=T3D2, ELSET=Line67
650, 43, 584
651, 584, 585
652, 585, 586
653, 586, 45
*ELEMENT, type=T3D2, ELSET=Line68
654, 14, 587
655, 587, 588
656, 588, 589
657, 589, 590
658, 590, 46
*ELEMENT, type=T3D2, ELSET=Line69
659, 45, 591
660, 591, 592
661, 592, 593
662, 593, 594
663, 594, 595
664, 595, 596
665, 596, 597
666, 597, 598
667, 598, 599
668, 599, 600
669, 600, 601
670, 601, 602
671, 602, 603
672, 603, 604
673, 604, 605
674, 605, 606
675, 606, 607
676, 607, 608
677, 608, 609
678, 609, 46
*ELEMENT, type=T3D2, ELSET=Line70
679, 4, 610
680, 610, 611
681, 611, 612
682, 612, 47
*ELEMENT, type=T3D2, ELSET=Line71
683, 1, 613
684, 613, 614
685, 614, 615
686, 615, 48
*ELEMENT, type=T3D2, ELSET=Line72
687, 47, 616
688, 616, 617
689, 617, 618
690, 618, 619
691, 619, 620
692, 620, 621
693, 621, 622
694, 622, 623
695, 623, 624
696, 624, 625
697, 625, 626
698, 626, 627
699, 627, 628
700, 628, 629
701, 629, 630
702, 630, 631
703, 631, 632
704, 632, 633
705, 633, 634
706, 634, 48
*ELEMENT, type=T3D2, ELSET=Line73
707, 18, 635
708, 635, 636
709, 636, 637
710, 637, 49
*ELEMENT, type=T3D2, ELSET=Line74
711, 20, 638
712, 638, 639
713, 639, 640
714, 640, 50
*ELEMENT, type=T3D2, ELSET=Line75
715, 49, 641
716, 641, 642
717, 642, 643
718, 643, 644
719, 644, 645
720, 645, 646
721, 646, 647
722, 647, 648
723, 648, 649
724, 649, 650
725, 650, 651
726, 651, 652
727, 652, 653
728, 653, 654
729, 654, 655
730, 655, 656
731, 656, 657
732, 657, 658
733, 658, 659
734, 659, 50
*ELEMENT, type=CPS4, ELSET=Surface1
735, 1, 51, 660, 126
736, 126, 660, 661, 125
737, 125, 661, 662, 124
738, 124, 662, 663, 123
739, 123, 663, 664, 122
740, 122, 664, 665, 121
741, 121, 665, 666, 120
742, 120, 666, 667, 119
743, 119, 667, 668, 118
744, 118, 668, 669, 117
745, 117, 669, 670, 116
746, 116, 670, 671, 115
747, 115, 671, 672, 114
748, 114, 672, 673, 113
749, 113, 673, 674, 112
750, 112, 674, 675, 111
751, 111, 675, 676, 110
752, 110, 676, 677, 109
753, 109, 677, 678, 108
754, 108, 678, 107, 4
755, 51, 52, 679, 660
756, 660, 679, 680, 661
757, 661, 680, 681, 662
758, 662, 681, 682, 663
759, 663, 682, 683, 664
760, 664, 683, 684, 665
761, 665, 684, 685, 666
762, 666, 685, 686, 667
763, 667, 686, 687, 668
764, 668, 687, 688, 669
765, 669, 688, 689, 670
766, 670, 689, 690, 671
767, 671, 690, 691, 672
768, 672, 691, 692, 673
769, 673, 692, 693, 674
770, 674, 693, 694, 675
771, 675, 694, 695, 676
772, 676, 695, 696, 677
773, 677, 696, 697, 678
774, 678, 697, 106, 107
775, 52, 53, 698, 679
776, 679, 698, 699, 680
777, 680, 699, 700, 681
778, 681, 700, 701, 682
779, 682, 701, 702, 683
780, 683, 702, 703, 684
781, 684, 703, 704, 685
782, 685, 704, 705, 686
783, 686, 705, 706, 687
784, 687, 706, 707, 688
785, 688, 707, 708, 689
786, 689, 708, 709, 690
787, 690, 709, 710, 691
788, 691, 710, 711, 692
789, 692, 711, 712, 693
790, 693, 712, 713, 694
791, 694, 713, 714, 695
792, 695, 714, 715, 696
793, 696, 715, 716, 697
794, 697, 716, 105, 106
795, 53, 54, 717, 698
796, 698, 717, 718, 699
797, 699, 718, 719, 700
798, 700, 719, 720, 701
799, 701, 720, 721, 702
800, 702, 721, 722, 703
801, 703, 722, 723, 704
802, 704, 723, 724, 705
803, 705, 724, 725, 706
804, 706, 725, 726, 707
805, 707, 726, 727, 708
806, 708, 727, 728, 709
807, 709, 728, 729, 710
808, 710, 729, 730, 711
809, 711, 730, 731, 712
810, 712, 731, 732, 713
811, 713, 732, 733, 714
812, 714, 733, 734, 715
813, 715, 734, 735, 716
814, 716, 735, 104, 105
815, 54, 55, 736, 717
816, 717, 736, 737, 718
817, 718, 737, 738, 719
818, 719, 738, 739, 720
819, 720, 739, 740, 721
820, 721, 740, 741, 722
821, 722, 741, 742, 723
822, 723, 742, 743, 724
823, 724, 743, 744, 725
824, 725, 744, 745, 726
825, 726, 745, 746, 727
826, 727, 746, 747, 728
827, 728, 747, 748, 729
828, 729, 748, 749, 730
829, 730, 749, 750, 731
830, 731, 750, 751, 732
831, 732, 751, 752, 733
832, 733, 752, 753, 734
833, 734, 753, 754, 735
834, 735, 754, 103, 104
835, 55, 56, 755, 736
836, 736, 755, 756, 737
837, 737, 756, 757, 738
838, 738, 757, 758, 739
839, 739, 758, 759, 740
840, 740, 759, 760, 741
841, 741, 760, 761, 742
842, 742, 761, 762, 743
843, 743, 762, 763, 744
844, 744, 763, 764, 745
845, 745, 764, 765, 746
846, 746, 765, 766, 747
847, 747, 766, 767, 748
848, 748, 767, 768, 749
849, 749, 768, 769, 750
850, 750, 769, 770, 751
851, 751, 770, 771, 752
852, 752, 771, 772, 753
853, 753, 772, 773, 754
854, 754, 773, 102, 103
855, 56, 57, 774, 755
856, 755, 774, 775, 756
857, 756, 775, 776, 757
858, 757, 776, 777, 758
859, 758, 777, 778, 759
860, 759, 778, 779, 760
861, 760, 779, 780, 761
862, 761, 780, 781, 762
863, 762, 781, 782, 763
864, 763, 782, 783, 764
865, 764, 783, 784, 765
866, 765, 784, 785, 766
867, 766, 785, 786, 767
868, 767, 786, 787, 768
869, 768, 787, 788, 769
870, 769, 788, 789, 770
871, 770, 789, 790, 771
872, 771, 790, 791, 772
873, 772, 791, 792, 773
874, 773, 792, 101, 102
875, 57, 58, 793, 774
876, 774, 793, 794, 775
877, 775, 794, 795, 776
878, 776, 795, 796, 777
879, 777, 796, 797, 778
880, 778, 797, 798, 779
881, 779, 798, 799, 780
882, 780, 799, 800, 781
883, 781, 800, 801, 782
884, 782, 801, 802, 783
885, 783, 802, 803, 784
886, 784, 803, 804, 785
887, 785, 804, 805, 786
888, 786, 805, 806, 787
889, 787, 806, 807, 788
890, 788, 807, 808, 789
891, 789, 808, 809, 790
892, 790, 809, 810, 791
893, 791, 810, 811, 792
894, 792, 811, 100, 101
895, 58, 59, 812, 793
896, 793, 812, 813, 794
897, 794, 813, 814, 795
898, 795, 814, 815, 796
899, 796, 815, 816, 797
900, 797, 816, 817, 798
901, 798, 817, 818, 799
902, 799, 818, 819, 800
903, 800, 819, 820, 801
904, 801, 820, 821, 802
905, 802, 821, 822, 803
906, 803, 822, 823, 804
907, 804, 823, 824, 805
908, 805, 824, 825, 806
909, 806, 825, 826, 807
910, 807, 826, 827, 808
911, 808, 827, 828, 809
912, 809, 828, 829, 810
913, 810, 829, 830, 811
914, 811, 830, 99, 100
915, 59, 60, 831, 812
916, 812, 831, 832, 813
917, 813, 832, 833, 814
918, 814, 833, 834, 815
919, 815, 834, 835, 816
920, 816, 835, 836, 817
921, 817, 836, 837, 818
922, 818, 837, 838, 819
923, 819, 838, 839, 820
924, 820, 839, 840, 821
925, 821, 840, 841, 822
926, 822, 841, 842, 823
927, 823, 842, 843, 824
928, 824, 843, 844, 825
929, 825, 844, 845, 826
930, 826, 845, 846, 827
931, 827, 846, 847, 828
932, 828, 847, 848, 829
933, 829, 848, 849, 830
934, 830, 849, 98, 99
935, 60, 61, 850, 831
936, 831, 850, 851, 832
937, 832, 851, 852, 833
938, 833, 852, 853, 834
939, 834, 853, 854, 835
940, 835, 854, 855, 836
941, 836, 855, 856, 837
942, 837, 856, 857, 838
943, 838, 857, 858, 839
944, 839, 858, 859, 840
945, 840, 859, 860, 841
946, 841, 860, 861, 842
947, 842, 861, 862, 843
948, 843, 862, 863, 844
949, 844, 863, 864, 845
950, 845, 864, 865, 846
951, 846, 865, 866, 847
952, 847, 866, 867, 848
953, 848, 867, 868, 849
954, 849, 868, 97, 98
955, 61, 62, 869, 850
956, 850, 869, 870, 851
957, 851, 870, 871, 852
958, 852, 871, 872, 853
959, 853, 872, 873, 854
960, 854, 873, 874, 855
961, 855, 874, 875, 856
962, 856, 875, 876, 857
963, 857, 876, 877, 858
964, 858, 877, 878, 859
965, 859, 878, 879, 860
966, 860, 879, 880, 861
967, 861, 880, 881, 862
968, 862, 881, 882, 863
969, 863, 882, 883, 864
970, 864, 883, 884, 865
971, 865, 884, 885, 866
972, 866, 885, 886, 867
973, 867, 886, 887, 868
974, 868, 887, 96, 97
975, 62, 63, 888, 869
976, 869, 888, 889, 870
977, 870, 889, 890, 871
978, 871, 890, 891, 872
979, 872, 891, 892, 873
980, 873, 892, 893, 874
981, 874, 893, 894, 875
982, 875, 894, 895, 876
983, 876, 895, 896, 877
984, 877, 896, 897, 878
985, 878, 897, 898, 879
986, 879, 898, 899, 880
987, 880, 899, 900, 881
988, 881, 900, 901, 882
989, 882, 901, 902, 883
990, 883, 902, 903, 884
991, 884, 903, 904, 885
992, 885, 904, 905, 886
993, 886, 905, 906, 887
994, 887, 906, 95, 96
995, 63, 64, 907, 888
996, 888, 907, 908, 889
997, 889, 908, 909, 890
998, 890, 909, 910, 891
999, 891, 910, 911, 892
1000, 892, 911, 912, 893
1001, 893, 912, 913, 894
1002, 894, 913, 914, 895
1003, 895, 914, 915, 896
1004, 896, 915, 916, 897
1005, 897, 916, 917, 898
1006, 898, 917, 918, 899
1007, 899, 918, 919, 900
1008, 900, 919, 920, 901
1009, 901, 920, 921, 902
1010, 902, 921, 922, 903
1011, 903, 922, 923, 904
1012, 904, 923, 924, 905
1013, 905, 924, 925, 906
1014, 906, 925, 94, 95
1015, 64, 65, 926, 907
1016, 907, 926, 927, 908
1017, 908, 927, 928, 909
1018, 909, 928, 929, 910
1019, 910, 929, 930, 911
1020, 911, 930, 931, 912
1021, 912, 931, 932, 913
1022, 913, 932, 933, 914
1023, 914, 933, 934, 915
1024, 915, 934, 935, 916
1025, 916, 935, 936, 917
1026, 917, 936, 937, 918
1027, 918, 937, 938, 919
1028, 919, 938, 939, 920
1029, 920, 939, 940, 921
1030, 921, 940, 941, 922
1031, 922, 941, 942, 923
1032, 923, 942, 943, 924
1033, 924, 943, 944, 925
1034, 925, 944, 93, 94
1035, 65, 66, 945, 926
1036, 926, 945, 946, 927
1037, 927, 946, 947, 928
1038, 928, 947, 948, 929
1039, 929, 948, 949, 930
1040, 930, 949, 950, 931
1041, 931, 950, 951, 932
1042, 932, 951, 952, 933
1043, 933, 952, 953, 934
1044, 934, 953, 954, 935
1045, 935, 954, 955, 936
1046, 936, 955, 956, 937
1047, 937, 956, 957, 938
1048, 938, 957, 958, 939
1049, 939, 958, 959, 940
1050, 940, 959, 960, 941
1051, 941, 960, 961, 942
1052, 942, 961, 962, 943
1053, 943, 962, 963, 944
1054, 944, 963, 92, 93
1055, 66, 67, 964, 945
1056, 945, 964, 965, 946
1057, 946, 965, 966, 947
1058, 947, 966, 967, 948
1059, 948, 967, 968, 949
1060, 949, 968, 969, 950
1061, 950, 969, 970, 951
1062, 951, 970, 971, 952
1063, 952, 971, 972, 953
1064, 953, 972, 973, 954
1065, 954, 973, 974, 955
1066, 955, 974, 975, 956
1067, 956, 975, 976, 957
1068, 957, 976, 977, 958
1069, 958, 977, 978, 959
1070, 959, 978, 979, 960
1071, 960, 979, 980, 961
1072, 961, 980, 981, 962
1073, 962, 981, 982, 963
1074, 963, 982, 91, 92
1075, 67, 68, 983, 964
1076, 964, 983, 984, 965
1077, 965, 984, 985, 966
1078, 966, 985, 986, 967
1079, 967, 986, 987, 968
1080, 968, 987, 988, 969
1081, 969, 988, 989, 970
1082, 970, 989, 990, 971
1083, 971, 990, 991, 972
1084, 972, 991, 992, 973
1085, 973, 992, 993, 974
1086, 974, 993, 994, 975
1087, 975, 994, 995, 976
1088, 976, 995, 996, 977
1089, 977, 996, 997, 978
1090, 978, 997, 998, 979
1091, 979, 998, 999, 980
1092, 980, 999, 1000, 981
1093, 981, 1000, 1001, 982
1094, 982, 1001, 90, 91
1095, 68, 69, 1002, 983
1096, 983, 1002, 1003, 984
1097, 984, 1003, 1004, 985
1098, 985, 1004, 1005, 986
1099, 986, 1005, 1006, 987
1100, 987, 1006, 1007, 988
1101, 988, 1007, 1008, 989
1102, 989, 1008, 1009, 990
1103, 990, 1009, 1010, 991
1104, 991, 1010, 1011, 992
1105, 992, 1011, 1012, 993
1106, 993, 1012, 1013, 994
1107, 994, 1013, 1014, 995
1108, 995, 1014, 1015, 996
1109, 996, 1015, 1016, 997
1110, 997, 1016, 1017, 998
1111, 998, 1017, 1018, 999
1112, 999, 1018, 1019, 1000
1113, 1000, 1019, 1020, 1001
1114, 1001, 1020, 89, 90
1115, 69, 2, 70, 1002
1116, 1002, 70, 71, 1003
1117, 1003, 71, 72, 1004
1118, 1004, 72, 73, 1005
1119, 1005, 73, 74, 1006
1120, 1006, 74, 75, 1007
1121, 1007, 75, 76, 1008
1122, 1008, 76, 77, 1009
1123, 1009, 77, 78, 1010
1124, 1010, 78, 79, 1011
1125, 1011, 79, 80, 1012
1126, 1012, 80, 81, 1013
1127, 1013, 81, 82, 1014
1128, 1014, 82, 83, 1015
1129, 1015, 83, 84, 1016
1130, 1016, 84, 85, 1017
1131, 1017, 85, 86, 1018
1132, 1018, 86, 87, 1019
1133, 1019, 87, 88, 1020
1134, 1020, 88, 3, 89
*ELEMENT, type=CPS4, ELSET=Surface2
1135, 3, 127, 1021, 89
1136, 89, 1021, 1022, 90
1137, 90, 1022, 1023, 91
1138, 91, 1023, 1024, 92
1139, 92, 1024, 1025, 93
1140, 93, 1025, 1026, 94
1141, 94, 1026, 1027, 95
1142, 95, 1027, 1028, 96
1143, 96, 1028, 1029, 97
1144, 97, 1029, 1030, 98
1145, 98, 1030, 1031, 99
1146, 99, 1031, 1032, 100
1147, 100, 1032, 1033, 101
1148, 101, 1033, 1034, 102
1149, 102, 1034, 1035, 103
1150, 103, 1035, 1036, 104
1151, 104, 1036, 1037, 105
1152, 105, 1037, 1038, 106
1153, 106, 1038, 1039, 107
1154, 107, 1039, 128, 4
1155, 127, 5, 129, 1021
1156, 1021, 129, 130, 1022
1157, 1022, 130, 131, 1023
1158, 1023, 131, 132, 1024
1159, 1024, 132, 133, 1025
1160, 1025, 133, 134, 1026
1161, 1026, 134, 135, 1027
1162, 1027, 135, 136, 1028
1163, 1028, 136, 137, 1029
1164, 1029, 137, 138, 1030
1165, 1030, 138, 139, 1031
1166, 1031, 139, 140, 1032
1167, 1032, 140, 141, 1033
1168, 1033, 141, 142, 1034
1169, 1034, 142, 143, 1035
1170, 1035, 143, 144, 1036
1171, 1036, 144, 145, 1037
1172, 1037, 145, 146, 1038
1173, 1038, 146, 147, 1039
1174, 1039, 147, 6, 128
*ELEMENT, type=CPS4, ELSET=Surface3
1175, 5, 148, 1040, 129
1176, 129, 1040, 1041, 130
1177, 130, 1041, 1042, 131
1178, 131, 1042, 1043, 132
1179, 132, 1043, 1044, 133
1180, 133, 1044, 1045, 134
1181, 134, 1045, 1046, 135
1182, 135, 1046, 1047, 136
1183, 136, 1047, 1048, 137
1184, 137, 1048, 1049, 138
1185, 138, 1049, 1050, 139
1186, 139, 1050, 1051, 140
1187, 140, 1051, 1052, 141
1188, 141, 1052, 1053, 142
1189, 142, 1053, 1054, 143
1190, 143, 1054, 1055, 144
1191, 144, 1055, 1056, 145
1192, 145, 1056, 1057, 146
1193, 146, 1057, 1058, 147
1194, 147, 1058, 149, 6
1195, 148, 7, 150, 1040
1196, 1040, 150, 151, 1041
1197, 1041, 151, 152, 1042
1198, 1042, 152, 153, 1043
1199, 1043, 153, 154, 1044
1200, 1044, 154, 155, 1045
1201, 1045, 155, 156, 1046
1202, 1046, 156, 157, 1047
1203, 1047, 157, 158, 1048
1204, 1048, 158, 159, 1049
1205, 1049, 159, 160, 1050
1206, 1050, 160, 161, 1051
1207, 1051, 161, 162, 1052
1208, 1052, 162, 163, 1053
1209, 1053, 163, 164, 1054
1210, 1054, 164, 165, 1055
1211, 1055, 165, 166, 1056
1212, 1056, 166, 167, 1057
1213, 1057, 167, 168, 1058
1214, 1058, 168, 8, 149
*ELEMENT, type=CPS4, ELSET=Surface4
1215, 7, 169, 1059, 150
1216, 150, 1059, 1060, 151
1217, 151, 1060, 1061, 152
1218, 152, 1061, 1062, 153
1219, 153, 1062, 1063, 154
1220, 154, 1063, 1064, 155
1221, 155, 1064, 1065, 156
1222, 156, 1065, 1066, 157
1223, 157, 1066, 1067, 158
1224, 158, 1067, 1068, 159
1225, 159, 1068, 1069, 160
1226, 160, 1069, 1070, 161
1227, 161, 1070, 1071, 162
1228, 162, 1071, 1072, 163
1229, 163, 1072, 1073, 164
1230, 164, 1073, 1074, 165
1231, 165, 1074, 1075, 166
1232, 166, 1075, 1076, 167
1233, 167, 1076, 1077, 168
1234, 168, 1077, 171, 8
1235, 169, 170, 1078, 1059
1236, 1059, 1078, 1079, 1060
1237, 1060, 1079, 1080, 1061
1238, 1061, 1080, 1081, 1062
1239, 1062, 1081, 1082, 1063
1240, 1063, 1082, 1083, 1064
1241, 1064, 1083, 1084, 1065
1242, 1065, 1084, 1085, 1066
1243, 1066, 1085, 1086, 1067
1244, 1067, 1086, 1087, 1068
1245, 1068, 1087, 1088, 1069
1246, 1069, 1088, 1089, 1070
1247, 1070, 1089, 1090, 1071
1248, 1071, 1090, 1091, 1072
1249, 1072, 1091, 1092, 1073
1250, 1073, 1092, 1093, 1074
1251, 1074, 1093, 1094, 1075
1252, 1075, 1094, 1095, 1076
1253, 1076, 1095, 1096, 1077
1254, 1077, 1096, 172, 171
1255, 170, 9, 173, 1078
1256, 1078, 173, 174, 1079
1257, 1079, 174, 175, 1080
1258, 1080, 175, 176, 1081
1259, 1081, 176, 177, 1082
1260, 1082, 177, 178, 1083
1261, 1083, 178, 179, 1084
1262, 1084, 179, 180, 1085
1263, 1085, 180, 181, 1086
1264, 1086, 181, 182, 1087
1265, 1087, 182, 183, 1088
1266, 1088, 183, 184, 1089
1267, 1089, 184, 185, 1090
1268, 1090, 185, 186, 1091
1269, 1091, 186, 187, 1092
1270, 1092, 187, 188, 1093
1271, 1093, 188, 189, 1094
1272, 1094, 189, 190, 1095
1273, 1095, 190, 191, 1096
1274, 1096, 191, 10, 172
*ELEMENT, type=CPS4, ELSET=Surface5
1275, 7, 192, 1097, 169
1276, 169, 1097, 1098, 170
1277, 170, 1098, 195, 9
1278, 192, 193, 1099, 1097
1279, 1097, 1099, 1100, 1098
1280, 1098, 1100, 196, 195
1281, 193, 194, 1101, 1099
1282, 1099, 1101, 1102, 1100
1283, 1100, 1102, 197, 196
1284, 194, 11, 198, 1101
1285, 1101, 198, 199, 1102
1286, 1102, 199, 12, 197
*ELEMENT, type=CPS4, ELSET=Surface6
1287, 11, 200, 1103, 198
1288, 198, 1103, 1104, 199
1289, 199, 1104, 219, 12
1290, 200, 201, 1105, 1103
1291, 1103, 1105, 1106, 1104
1292, 1104, 1106, 220, 219
1293, 201, 202, 1107, 1105
1294, 1105, 1107, 1108, 1106
1295, 1106, 1108, 221, 220
1296, 202, 203, 1109, 1107
1297, 1107, 1109, 1110, 1108
1298, 1108, 1110, 222, 221
1299, 203, 204, 1111, 1109
1300, 1109, 1111, 1112, 1110
1301, 1110, 1112, 223, 222
1302, 204, 205, 1113, 1111
1303, 1111, 1113, 1114, 1112
1304, 1112, 1114, 224, 223
1305, 205, 206, 1115, 1113
1306, 1113, 1115, 1116, 1114
1307, 1114, 1116, 225, 224
1308, 206, 207, 1117, 1115
1309, 1115, 1117, 1118, 1116
1310, 1116, 1118, 226, 225
1311, 207, 208, 1119, 1117
1312, 1117, 1119, 1120, 1118
1313, 1118, 1120, 227, 226
1314, 208, 209, 1121, 1119
1315, 1119, 1121, 1122, 1120
1316, 1120, 1122, 228, 227
1317, 209, 210, 1123, 1121
1318, 1121, 1123, 1124, 1122
1319, 1122, 1124, 229, 228
1320, 210, 211, 1125, 1123
1321, 1123, 1125, 1126, 1124
1322, 1124, 1126, 230, 229
1323, 211, 212, 1127, 1125
1324, 1125, 1127, 1128, 1126
1325, 1126, 1128, 231, 230
1326, 212, 213, 1129, 1127
1327, 1127, 1129, 1130, 1128
1328, 1128, 1130, 232, 231
1329, 213, 214, 1131, 1129
1330, 1129, 1131, 1132, 1130
1331, 1130, 1132, 233, 232
1332, 214, 215, 1133, 1131
1333, 1131, 1133, 1134, 1132
1334, 1132, 1134, 234, 233
1335, 215, 216, 1135, 1133
1336, 1133, 1135, 1136, 1134
1337, 1134, 1136, 235, 234
1338, 216, 217, 1137, 1135
1339, 1135, 1137, 1138, 1136
1340, 1136, 1138, 236, 235
1341, 217, 218, 1139, 1137
1342, 1137, 1139, 1140, 1138
1343, 1138, 1140, 237, 236
1344, 218, 13, 238, 1139
1345, 1139, 238, 239, 1140
1346, 1140, 239, 14, 237
*ELEMENT, type=CPS4, ELSET=Surface7
1347, 11, 240, 1141, 200
1348, 200, 1141, 1142, 201
1349, 201, 1142, 1143, 202
1350, 202, 1143, 1144, 203
1351, 203, 1144, 1145, 204
1352, 204, 1145, 1146, 205
1353, 205, 1146, 1147, 206
1354, 206, 1147, 1148, 207
1355, 207, 1148, 1149, 208
1356, 208, 1149, 1150, 209
1357, 209, 1150, 1151, 210
1358, 210, 1151, 1152, 211
1359, 211, 1152, 1153, 212
1360, 212, 1153, 1154, 213
1361, 213, 1154, 1155, 214
1362, 214, 1155, 1156, 215
1363, 215, 1156, 1157, 216
1364, 216, 1157, 1158, 217
1365, 217, 1158, 1159, 218
1366, 218, 1159, 241, 13
1367, 240, 15, 242, 1141
1368, 1141, 242, 243, 1142
1369, 1142, 243, 244, 1143
1370, 1143, 244, 245, 1144
1371, 1144, 245, 246, 1145
1372, 1145, 246, 247, 1146
1373, 1146, 247, 248, 1147
1374, 1147, 248, 249, 1148
1375, 1148, 249, 250, 1149
1376, 1149, 250, 251, 1150
1377, 1150, 251, 252, 1151
1378, 1151, 252, 253, 1152
1379, 1152, 253, 254, 1153
1380, 1153, 254, 255, 1154
1381, 1154, 255, 256, 1155
1382, 1155, 256, 257, 1156
1383, 1156, 257, 258, 1157
1384, 1157, 258, 259, 1158
1385, 1158, 259, 260, 1159
1386, 1159, 260, 16, 241
*ELEMENT, type=CPS4, ELSET=Surface8
1387, 15, 261, 1160, 242
1388, 242, 1160, 1161, 243
1389, 243, 1161, 1162, 244
1390, 244, 1162, 1163, 245
1391, 245, 1163, 1164, 246
1392, 246, 1164, 1165, 247
1393, 247, 1165, 1166, 248
1394, 248, 1166, 1167, 249
1395, 249, 1167, 1168, 250
1396, 250, 1168, 1169, 251
1397, 251, 1169, 1170, 252
1398, 252, 1170, 1171, 253
1399, 253, 1171, 1172, 254
1400, 254, 1172, 1173, 255
1401, 255, 1173, 1174, 256
1402, 256, 1174, 1175, 257
1403, 257, 1175, 1176, 258
1404, 258, 1176, 1177, 259
1405, 259, 1177, 1178, 260
1406, 260, 1178, 262, 16
1407, 261, 17, 263, 1160
1408, 1160, 263, 264, 1161
1409, 1161, 264, 265, 1162
1410, 1162, 265, 266, 1163
1411, 1163, 266, 267, 1164
1412, 1164, 267, 268, 1165
1413, 1165, 268, 269, 1166
1414, 1166, 269, 270, 1167
1415, 1167, 270, 271, 1168
1416, 1168, 271, 272, 1169
1417, 1169, 272, 273, 1170
1418, 1170, 273, 274, 1171
1419, 1171, 274, 275, 1172
1420, 1172, 275, 276, 1173
1421, 1173, 276, 277, 1174
1422, 1174, 277, 278, 1175
1423, 1175, 278, 279, 1176
1424, 1176, 279, 280, 1177
1425, 1177, 280, 281, 1178
1426, 1178, 281, 18, 262
*ELEMENT, type=CPS4, ELSET=Surface9
1427, 17, 282, 1179, 263
1428, 263, 1179, 1180, 264
1429, 264, 1180, 1181, 265
1430, 265, 1181, 1182, 266
1431, 266, 1182, 1183, 267
1432, 267, 1183, 1184, 268
1433, 268, 1184, 1185, 269
1434, 269, 1185, 1186, 270
1435, 270, 1186, 1187, 271
1436, 271, 1187, 1188, 272
1437, 272, 1188, 1189, 273
1438, 273, 1189, 1190, 274
1439, 274, 1190, 1191, 275
1440, 275, 1191, 1192, 276
1441, 276, 1192, 1193, 277
1442, 277, 1193, 1194, 278
1443, 278, 1194, 1195, 279
1444, 279, 1195, 1196, 280
1445, 280, 1196, 1197, 281
1446, 281, 1197, 301, 18
1447, 282, 283, 1198, 1179
1448, 1179, 1198, 1199, 1180
1449, 1180, 1199, 1200, 1181
1450, 1181, 1200, 1201, 1182
1451, 1182, 1201, 1202, 1183
1452, 1183, 1202, 1203, 1184
1453, 1184, 1203, 1204, 1185
1454, 1185, 1204, 1205, 1186
1455, 1186, 1205, 1206, 1187
1456, 1187, 1206, 1207, 1188
1457, 1188, 1207, 1208, 1189
1458, 1189, 1208, 1209, 1190
1459, 1190, 1209, 1210, 1191
1460, 1191, 1210, 1211, 1192
1461, 1192, 1211, 1212, 1193
1462, 1193, 1212, 1213, 1194
1463, 1194, 1213, 1214, 1195
1464, 1195, 1214, 1215, 1196
1465, 1196, 1215, 1216, 1197
1466, 1197, 1216, 302, 301
1467, 283, 284, 1217, 1198
1468, 1198, 1217, 1218, 1199
1469, 1199, 1218, 1219, 1200
1470, 1200, 1219, 1220, 1201
1471, 1201, 1220, 1221, 1202
1472, 1202, 1221, 1222, 1203
1473, 1203, 1222, 1223, 1204
1474, 1204, 1223, 1224, 1205
1475, 1205, 1224, 1225, 1206
1476, 1206, 1225, 1226, 1207
1477, 1207, 1226, 1227, 1208
1478, 1208, 1227, 1228, 1209
1479, 1209, 1228, 1229, 1210
1480, 1210, 1229, 1230, 1211
1481, 1211, 1230, 1231, 1212
1482, 1212, 1231, 1232, 1213
1483, 1213, 1232, 1233, 1214
1484, 1214, 1233, 1234, 1215
1485, 1215, 1234, 1235, 1216
1486, 1216, 1235, 303, 302
1487, 284, 285, 1236, 1217
1488, 1217, 1236, 1237, 1218
1489, 1218, 1237, 1238, 1219
1490, 1219, 1238, 1239, 1220
1491, 1220, 1239, 1240, 1221
1492, 1221, 1240, 1241, 1222
1493, 1222, 1241, 1242, 1223
1494, 1223, 1242, 1243, 1224
1495, 1224, 1243, 1244, 1225
1496, 1225, 1244, 1245, 1226
1497, 1226, 1245, 1246, 1227
1498, 1227, 1246, 1247, 1228
1499, 1228, 1247, 1248, 1229
1500, 1229, 1248, 1249, 1230
1501, 1230, 1249, 1250, 1231
1502, 1231, 1250, 1251, 1232
1503, 1232, 1251, 1252, 1233
1504, 1233, 1252, 1253, 1234
1505, 1234, 1253, 1254, 1235
1506, 1235, 1254, 304, 303
1507, 285, 286, 1255, 1236
1508, 1236, 1255, 1256, 1237
1509, 1237, 1256, 1257, 1238
1510, 1238, 1257, 1258, 1239
1511, 1239, 1258, 1259, 1240
1512, 1240, 1259, 1260, 1241
1513, 1241, 1260, 1261, 1242
1514, 1242, 1261, 1262, 1243
1515, 1243, 1262, 1263, 1244
1516, 1244, 1263, 1264, 1245
1517, 1245, 1264, 1265, 1246
1518, 1246, 1265, 1266, 1247
1519, 1247, 1266, 1267, 1248
1520, 1248, 1267, 1268, 1249
1521, 1249, 1268, 1269, 1250
1522, 1250, 1269, 1270, 1251
1523, 1251, 1270, 1271, 1252
1524, 1252, 1271, 1272, 1253
1525, 1253, 1272, 1273, 1254
1526, 1254, 1273, 305, 304
1527, 286, 287, 1274, 1255
1528, 1255, 1274, 1275, 1256
1529, 1256, 1275, 1276, 1257
1530, 1257, 1276, 1277, 1258
1531, 1258, 1277, 1278, 1259
1532, 1259, 1278, 1279, 1260
1533, 1260, 1279, 1280, 1261
1534, 1261, 1280, 1281, 1262
1535, 1262, 1281, 1282, 1263
1536, 1263, 1282, 1283, 1264
1537, 1264, 1283, 1284, 1265
1538, 1265, 1284, 1285, 1266
1539, 1266, 1285, 1286, 1267
1540, 1267, 1286, 1287, 1268
1541, 1268, 1287, 1288, 1269
1542, 1269, 1288, 1289, 1270
1543, 1270, 1289, 1290, 1271
1544, 1271, 1290, 1291, 1272
1545, 1272, 1291, 1292, 1273
1546, 1273, 1292, 306, 305
1547, 287, 288, 1293, 1274
1548, 1274, 1293, 1294, 1275
1549, 1275, 1294, 1295, 1276
1550, 1276, 1295, 1296, 1277
1551, 1277, 1296, 1297, 1278
1552, 1278, 1297, 1298, 1279
1553, 1279, 1298, 1299, 1280
1554, 1280, 1299, 1300, 1281
1555, 1281, 1300, 1301, 1282
1556, 1282, 1301, 1302, 1283
1557, 1283, 1302, 1303, 1284
1558, 1284, 1303, 1304, 1285
1559, 1285, 1304, 1305, 1286
1560, 1286, 1305, 1306, 1287
1561, 1287, 1306, 1307, 1288
1562, 1288, 1307, 1308, 1289
1563, 1289, 1308, 1309, 1290
1564, 1290, 1309, 1310, 1291
1565, 1291, 1310, 1311, 1292
1566, 1292, 1311, 307, 306
1567, 288, 289, 1312, 1293
1568, 1293, 1312, 1313, 1294
1569, 1294, 1313, 1314, 1295
1570, 1295, 1314, 1315, 1296
1571, 1296, 1315, 1316, 1297
1572, 1297, 1316, 1317, 1298
1573, 1298, 1317, 1318, 1299
1574, 1299, 1318, 1319, 1300
1575, 1300, 1319, 1320, 1301
1576, 1301, 1320, 1321, 1302
1577, 1302, 1321, 1322, 1303
1578, 1303, 1322, 1323, 1304
1579, 1304, 1323, 1324, 1305
1580, 1305, 1324, 1325, 1306
1581, 1306, 1325, 1326, 1307
1582, 1307, 1326, 1327, 1308
1583, 1308, 1327, 1328, 1309
1584, 1309, 1328, 1329, 1310
1585, 1310, 1329, 1330, 1311
1586, 1311, 1330, 308, 307
1587, 289, 290, 1331, 1312
1588, 1312, 1331, 1332, 1313
1589, 1313, 1332, 1333, 1314
1590, 1314, 1333, 1334, 1315
1591, 1315, 1334, 1335, 1316
1592, 1316, 1335, 1336, 1317
1593, 1317, 1336, 1337, 1318
1594, 1318, 1337, 1338, 1319
1595, 1319, 1338, 1339, 1320
1596, 1320, 1339, 1340, 1321
1597, 1321, 1340, 1341, 1322
1598, 1322, 1341, 1342, 1323
1599, 1323, 1342, 1343, 1324
1600, 1324, 1343, 1344, 1325
1601, 1325, 1344, 1345, 1326
1602, 1326, 1345, 1346, 1327
1603, 1327, 1346, 1347, 1328
1604, 1328, 1347, 1348, 1329
1605, 1329, 1348, 1349, 1330
1606, 1330, 1349, 309, 308
1607, 290, 291, 1350, 1331
1608, 1331, 1350, 1351, 1332
1609, 1332, 1351, 1352, 1333
1610, 1333, 1352, 1353, 1334
1611, 1334, 1353, 1354, 1335
1612, 1335, 1354, 1355, 1336
1613, 1336, 1355, 1356, 1337
1614, 1337, 1356, 1357, 1338
1615, 1338, 1357, 1358, 1339
1616, 1339, 1358, 1359, 1340
1617, 1340, 1359, 1360, 1341
1618, 1341, 1360, 1361, 1342
1619, 1342, 1361, 1362, 1343
1620, 1343, 1362, 1363, 1344
1621, 1344, 1363, 1364, 1345
1622, 1345, 1364, 1365, 1346
1623, 1346, 1365, 1366, 1347
1624, 1347, 1366, 1367, 1348
1625, 1348, 1367, 1368, 1349
1626, 1349, 1368, 310, 309
1627, 291, 292, 1369, 1350
1628, 1350, 1369, 1370, 1351
1629, 1351, 1370, 1371, 1352
1630, 1352, 1371, 1372, 1353
1631, 1353, 1372, 1373, 1354
1632, 1354, 1373, 1374, 1355
1633, 1355, 1374, 1375, 1356
1634, 1356, 1375, 1376, 1357
1635, 1357, 1376, 1377, 1358
1636, 1358, 1377, 1378, 1359
1637, 1359, 1378, 1379, 1360
1638, 1360, 1379, 1380, 1361
1639, 1361, 1380, 1381, 1362
1640, 1362, 1381, 1382, 1363
1641, 1363, 1382, 1383, 1364
1642, 1364, 1383, 1384, 1365
1643, 1365, 1384, 1385, 1366
1644, 1366, 1385, 1386, 1367
1645, 1367, 1386, 1387, 1368
1646, 1368, 1387, 311, 310
1647, 292, 293, 1388, 1369
1648, 1369, 1388, 1389, 1370
1649, 1370, 1389, 1390, 1371
1650, 1371, 1390, 1391, 1372
1651, 1372, 1391, 1392, 1373
1652, 1373, 1392, 1393, 1374
1653, 1374, 1393, 1394, 1375
1654, 1375, 1394, 1395, 1376
1655, 1376, 1395, 1396, 1377
1656, 1377, 1396, 1397, 1378
1657, 1378, 1397, 1398, 1379
1658, 1379, 1398, 1399, 1380
1659, 1380, 1399, 1400, 1381
1660, 1381, 1400, 1401, 1382
1661, 1382, 1401, 1402, 1383
1662, 1383, 1402, 1403, 1384
1663, 1384, 1403, 1404, 1385
1664, 1385, 1404, 1405, 1386
1665, 1386, 1405, 1406, 1387
1666, 1387, 1406, 312, 311
1667, 293, 294, 1407, 1388
1668, 1388, 1407, 1408, 1389
1669, 1389, 1408, 1409, 1390
1670, 1390, 1409, 1410, 1391
1671, 1391, 1410, 1411, 1392
1672, 1392, 1411, 1412, 1393
1673, 1393, 1412, 1413, 1394
1674, 1394, 1413, 1414, 1395
1675, 1395, 1414, 1415, 1396
1676, 1396, 1415, 1416, 1397
1677, 1397, 1416, 1417, 1398
1678, 1398, 1417, 1418, 1399
1679, 1399, 1418, 1419, 1400
1680, 1400, 1419, 1420, 1401
1681, 1401, 1420, 1421, 1402
1682, 1402, 1421, 1422, 1403
1683, 1403, 1422, 1423, 1404
1684, 1404, 1423, 1424, 1405
1685, 1405, 1424, 1425, 1406
1686, 1406, 1425, 313, 312
1687, 294, 295, 1426, 1407
1688, 1407, 1426, 1427, 1408
1689, 1408, 1427, 1428, 1409
1690, 1409, 1428, 1429, 1410
1691, 1410, 1429, 1430, 1411
1692, 1411, 1430, 1431, 1412
1693, 1412, 1431, 1432, 1413
1694, 1413, 1432, 1433, 1414
1695, 1414, 1433, 1434, 1415
1696, 1415, 1434, 1435, 1416
1697, 1416, 1435, 1436, 1417
1698, 1417, 1436, 1437, 1418
1699, 1418, 1437, 1438, 1419
1700, 1419, 1438, 1439, 1420
1701, 1420, 1439, 1440, 1421
1702, 1421, 1440, 1441, 1422
1703, 1422, 1441, 1442, 1423
1704, 1423, 1442, 1443, 1424
1705, 1424, 1443, 1444, 1425
1706, 1425, 1444, 314, 313
1707, 295, 296, 1445, 1426
1708, 1426, 1445, 1446, 1427
1709, 1427, 1446, 1447, 1428
1710, 1428, 1447, 1448, 1429
1711, 1429, 1448, 1449, 1430
1712, 1430, 1449, 1450, 1431
1713, 1431, 1450, 1451, 1432
1714, 1432, 1451, 1452, 1433
1715, 1433, 1452, 1453, 1434
1716, 1434, 1453, 1454, 1435
1717, 1435, 1454, 1455, 1436
1718, 1436, 1455, 1456, 1437
1719, 1437, 1456, 1457, 1438
1720, 1438, 1457, 1458, 1439
1721, 1439, 1458, 1459, 1440
1722, 1440, 1459, 1460, 1441
1723, 1441, 1460, 1461, 1442
1724, 1442, 1461, 1462, 1443
1725, 1443, 1462, 1463, 1444
1726, 1444, 1463, 315, 314
1727, 296, 297, 1464, 1445
1728, 1445, 1464, 1465, 1446
1729, 1446, 1465, 1466, 1447
1730, 1447, 1466, 1467, 1448
1731, 1448, 1467, 1468, 1449
1732, 1449, 1468, 1469, 1450
1733, 1450, 1469, 1470, 1451
1734, 1451, 1470, 1471, 1452
1735, 1452, 1471, 1472, 1453
1736, 1453, 1472, 1473, 1454
1737, 1454, 1473, 1474, 1455
1738, 1455, 1474, 1475, 1456
1739, 1456, 1475, 1476, 1457
1740, 1457, 1476, 1477, 1458
1741, 1458, 1477, 1478, 1459
1742, 1459, 1478, 1479, 1460
1743, 1460, 1479, 1480, 1461
1744, 1461, 1480, 1481, 1462
1745, 1462, 1481, 1482, 1463
1746, 1463, 1482, 316, 315
1747, 297, 298, 1483, 1464
1748, 1464, 1483, 1484, 1465
1749, 1465, 1484, 1485, 1466
1750, 1466, 1485, 1486, 1467
1751, 1467, 1486, 1487, 1468
1752, 1468, 1487, 1488, 1469
1753, 1469, 1488, 1489, 1470
1754, 1470, 1489, 1490, 1471
1755, 1471, 1490, 1491, 1472
1756, 1472, 1491, 1492, 1473
1757, 1473, 1492, 1493, 1474
1758, 1474, 1493, 1494, 1475
1759, 1475, 1494, 1495, 1476
1760, 1476, 1495, 1496, 1477
1761, 1477, 1496, 1497, 1478
1762, 1478, 1497, 1498, 1479
1763, 1479, 1498, 1499, 1480
1764, 1480, 1499, 1500, 1481
1765, 1481, 1500, 1501, 1482
1766, 1482, 1501, 317, 316
1767, 298, 299, 1502, 1483
1768, 1483, 1502, 1503, 1484
1769, 1484, 1503, 1504, 1485
1770, 1485, 1504, 1505, 1486
1771, 1486, 1505, 1506, 1487
1772, 1487, 1506, 1507, 1488
1773, 1488, 1507, 1508, 1489
1774, 1489, 1508, 1509, 1490
1775, 1490, 1509, 1510, 1491
1776, 1491, 1510, 1511, 1492
1777, 1492, 1511, 1512, 1493
1778, 1493, 1512, 1513, 1494
1779, 1494, 1513, 1514, 1495
1780, 1495, 1514, 1515, 1496
1781, 1496, 1515, 1516, 1497
1782, 1497, 1516, 1517, 1498
1783, 1498, 1517, 1518, 1499
1784, 1499, 1518, 1519, 1500
1785, 1500, 1519, 1520, 1501
1786, 1501, 1520, 318, 317
1787, 299, 300, 1521, 1502
1788, 1502, 1521, 1522, 1503
1789, 1503, 1522, 1523, 1504
1790, 1504, 1523, 1524, 1505
1791, 1505, 1524, 1525, 1506
1792, 1506, 1525, 1526, 1507
1793, 1507, 1526, 1527, 1508
1794, 1508, 1527, 1528, 1509
1795, 1509, 1528, 1529, 1510
1796, 1510, 1529, 1530, 1511
1797, 1511, 1530, 1531, 1512
1798, 1512, 1531, 1532, 1513
1799, 1513, 1532, 1533, 1514
1800, 1514, 1533, 1534, 1515
1801, 1515, 1534, 1535, 1516
1802, 1516, 1535, 1536, 1517
1803, 1517, 1536, 1537, 1518
1804, 1518, 1537, 1538, 1519
1805, 1519, 1538, 1539, 1520
1806, 1520, 1539, 319, 318
1807, 300, 19, 320, 1521
1808, 1521, 320, 321, 1522
1809, 1522, 321, 322, 1523
1810, 1523, 322, 323, 1524
1811, 1524, 323, 324, 1525
1812, 1525, 324, 325, 1526
1813, 1526, 325, 326, 1527
1814, 1527, 326, 327, 1528
1815, 1528, 327, 328, 1529
1816, 1529, 328, 329, 1530
1817, 1530, 329, 330, 1531
1818, 1531, 330, 331, 1532
1819, 1532, 331, 332, 1533
1820, 1533, 332, 333, 1534
1821, 1534, 333, 334, 1535
1822, 1535, 334, 335, 1536
1823, 1536, 335, 336, 1537
1824, 1537, 336, 337, 1538
1825, 1538, 337, 338, 1539
1826, 1539, 338, 20, 319
*ELEMENT, type=CPS4, ELSET=Surface10
1827, 19, 339, 1540, 320
1828, 320, 1540, 1541, 321
1829, 321, 1541, 1542, 322
1830, 322, 1542, 1543, 323
1831, 323, 1543, 1544, 324
1832, 324, 1544, 1545, 325
1833, 325, 1545, 1546, 326
1834, 326, 1546, 1547, 327
1835, 327, 1547, 1548, 328
1836, 328, 1548, 1549, 329
1837, 329, 1549, 1550, 330
1838, 330, 1550, 1551, 331
1839, 331, 1551, 1552, 332
1840, 332, 1552, 1553, 333
1841, 333, 1553, 1554, 334
1842, 334, 1554, 1555, 335
1843, 335, 1555, 1556, 336
1844, 336, 1556, 1557, 337
1845, 337, 1557, 1558, 338
1846, 338, 1558, 340, 20
1847, 339, 21, 341, 1540
1848, 1540, 341, 342, 1541
1849, 1541, 342, 343, 1542
1850, 1542, 343, 344, 1543
1851, 1543, 344, 345, 1544
1852, 1544, 345, 346, 1545
1853, 1545, 346, 347, 1546
1854, 1546, 347, 348, 1547
1855, 1547, 348, 349, 1548
1856, 1548, 349, 350, 1549
1857, 1549, 350, 351, 1550
1858, 1550, 351, 352, 1551
1859, 1551, 352, 353, 1552
1860, 1552, 353, 354, 1553
1861, 1553, 354, 355, 1554
1862, 1554, 355, 356, 1555
1863, 1555, 356, 357, 1556
1864, 1556, 357, 358, 1557
1865, 1557, 358, 359, 1558
1866, 1558, 359, 22, 340
*ELEMENT, type=CPS4, ELSET=Surface11
1867, 1, 360, 1559, 51
1868, 51, 1559, 1560, 52
1869, 52, 1560, 1561, 53
1870, 53, 1561, 1562, 54
1871, 54, 1562, 1563, 55
1872, 55, 1563, 1564, 56
1873, 56, 1564, 1565, 57
1874, 57, 1565, 1566, 58
1875, 58, 1566, 1567, 59
1876, 59, 1567, 1568, 60
1877, 60, 1568, 1569, 61
1878, 61, 1569, 1570, 62
1879, 62, 1570, 1571, 63
1880, 63, 1571, 1572, 64
1881, 64, 1572, 1573, 65
1882, 65, 1573, 1574, 66
1883, 66, 1574, 1575, 67
1884, 67, 1575, 1576, 68
1885, 68, 1576, 1577, 69
1886, 69, 1577, 361, 2
1887, 360, 23, 362, 1559
1888, 1559, 362, 363, 1560
1889, 1560, 363, 364, 1561
1890, 1561, 364, 365, 1562
1891, 1562, 365, 366, 1563
1892, 1563, 366, 367, 1564
1893, 1564, 367, 368, 1565
1894, 1565, 368, 369, 1566
1895, 1566, 369, 370, 1567
1896, 1567, 370, 371, 1568
1897, 1568, 371, 372, 1569
1898, 1569, 372, 373, 1570
1899, 1570, 373, 374, 1571
1900, 1571, 374, 375, 1572
1901, 1572, 375, 376, 1573
1902, 1573, 376, 377, 1574
1903, 1574, 377, 378, 1575
1904, 1575, 378, 379, 1576
1905, 1576, 379, 380, 1577
1906, 1577, 380, 24, 361
*ELEMENT, type=CPS4, ELSET=Surface12
1907, 23, 381, 1578, 362
1908, 362, 1578, 1579, 363
1909, 363, 1579, 1580, 364
1910, 364, 1580, 1581, 365
1911, 365, 1581, 1582, 366
1912, 366, 1582, 1583, 367
1913, 367, 1583, 1584, 368
1914, 368, 1584, 1585, 369
1915, 369, 1585, 1586, 370
1916, 370, 1586, 1587, 371
1917, 371, 1587, 1588, 372
1918, 372, 1588, 1589, 373
1919, 373, 1589, 1590, 374
1920, 374, 1590, 1591, 375
1921, 375, 1591, 1592, 376
1922, 376, 1592, 1593, 377
1923, 377, 1593, 1594, 378
1924, 378, 1594, 1595, 379
1925, 379, 1595, 1596, 380
1926, 380, 1596, 382, 24
1927, 381, 25, 383, 1578
1928, 1578, 383, 384, 1579
1929, 1579, 384, 385, 1580
1930, 1580, 385, 386, 1581
1931, 1581, 386, 387, 1582
1932, 1582, 387, 388, 1583
1933, 1583, 388, 389, 1584
1934, 1584, 389, 390, 1585
1935, 1585, 390, 391, 1586
1936, 1586, 391, 392, 1587
1937, 1587, 392, 393, 1588
1938, 1588, 393, 394, 1589
1939, 1589, 394, 395, 1590
1940, 1590, 395, 396, 1591
1941, 1591, 396, 397, 1592
1942, 1592, 397, 398, 1593
1943, 1593, 398, 399, 1594
1944, 1594, 399, 400, 1595
1945, 1595, 400, 401, 1596
1946, 1596, 401, 26, 382
*ELEMENT, type=CPS4, ELSET=Surface13
1947, 21, 402, 1597, 341
1948, 341, 1597, 1598, 342
1949, 342, 1598, 1599, 343
1950, 343, 1599, 1600, 344
1951, 344, 1600, 1601, 345
1952, 345, 1601, 1602, 346
1953, 346, 1602, 1603, 347
1954, 347, 1603, 1604, 348
1955, 348, 1604, 1605, 349
1956, 349, 1605, 1606, 350
1957, 350, 1606, 1607, 351
1958, 351, 1607, 1608, 352
1959, 352, 1608, 1609, 353
1960, 353, 1609, 1610, 354
1961, 354, 1610, 1611, 355
1962, 355, 1611, 1612, 356
1963, 356, 1612, 1613, 357
1964, 357, 1613, 1614, 358
1965, 358, 1614, 1615, 359
1966, 359, 1615, 403, 22
1967, 402, 27, 404, 1597
1968, 1597, 404, 405, 1598
1969, 1598, 405, 406, 1599
1970, 1599, 406, 407, 1600
1971, 1600, 407, 408, 1601
1972, 1601, 408, 409, 1602
1973, 1602, 409, 410, 1603
1974, 1603, 410, 411, 1604
1975, 1604, 411, 412, 1605
1976, 1605, 412, 413, 1606
1977, 1606, 413, 414, 1607
1978, 1607, 414, 415, 1608
1979, 1608, 415, 416, 1609
1980, 1609, 416, 417, 1610
1981, 1610, 417, 418, 1611
1982, 1611, 418, 419, 1612
1983, 1612, 419, 420, 1613
1984, 1613, 420, 421, 1614
1985, 1614, 421, 422, 1615
1986, 1615, 422, 28, 403
*ELEMENT, type=CPS4, ELSET=Surface14
1987, 25, 423, 1616, 383
1988, 383, 1616, 1617, 384
1989, 384, 1617, 1618, 385
1990, 385, 1618, 1619, 386
1991, 386, 1619, 1620, 387
1992, 387, 1620, 1621, 388
1993, 388, 1621, 1622, 389
1994, 389, 1622, 1623, 390
1995, 390, 1623, 1624, 391
1996, 391, 1624, 1625, 392
1997, 392, 1625, 1626, 393
1998, 393, 1626, 1627, 394
1999, 394, 1627, 1628, 395
2000, 395, 1628, 1629, 396
2001, 396, 1629, 1630, 397
2002, 397, 1630, 1631, 398
2003, 398, 1631, 1632, 399
2004, 399, 1632, 1633, 400
2005, 400, 1633, 1634, 401
2006, 401, 1634, 425, 26
2007, 423, 424, 1635, 1616
2008, 1616, 1635, 1636, 1617
2009, 1617, 1636, 1637, 1618
2010, 1618, 1637, 1638, 1619
2011, 1619, 1638, 1639, 1620
2012, 1620, 1639, 1640, 1621
2013, 1621, 1640, 1641, 1622
2014, 1622, 1641, 1642, 1623
2015, 1623, 1642, 1643, 1624
2016, 1624, 1643, 1644, 1625
2017, 1625, 1644, 1645, 1626
2018, 1626, 1645, 1646, 1627
2019, 1627, 1646, 1647, 1628
2020, 1628, 1647, 1648, 1629
2021, 1629, 1648, 1649, 1630
2022, 1630, 1649, 1650, 1631
2023, 1631, 1650, 1651, 1632
2024, 1632, 1651, 1652, 1633
2025, 1633, 1652, 1653, 1634
2026, 1634, 1653, 426, 425
2027, 424, 29, 427, 1635
2028, 1635, 427, 428, 1636
2029, 1636, 428, 429, 1637
2030, 1637, 429, 430, 1638
2031, 1638, 430, 431, 1639
2032, 1639, 431, 432, 1640
2033, 1640, 432, 433, 1641
2034, 1641, 433, 434, 1642
2035, 1642, 434, 435, 1643
2036, 1643, 435, 436, 1644
2037, 1644, 436, 437, 1645
2038, 1645, 437, 438, 1646
2039, 1646, 438, 439, 1647
2040, 1647, 439, 440, 1648
2041, 1648, 440, 441, 1649
2042, 1649, 441, 442, 1650
2043, 1650, 442, 443, 1651
2044, 1651, 443, 444, 1652
2045, 1652, 444, 445, 1653
2046, 1653, 445, 30, 426
*ELEMENT, type=CPS4, ELSET=Surface15
2047, 27, 446, 1654, 404
2048, 404, 1654, 1655, 405
2049, 405, 1655, 1656, 406
2050, 406, 1656, 1657, 407
2051, 407, 1657, 1658, 408
2052, 408, 1658, 1659, 409
2053, 409, 1659, 1660, 410
2054, 410, 1660, 1661, 411
2055, 411, 1661, 1662, 412
2056, 412, 1662, 1663, 413
2057, 413, 1663, 1664, 414
2058, 414, 1664, 1665, 415
2059, 415, 1665, 1666, 416
2060, 416, 1666, 1667, 417
2061, 417, 1667, 1668, 418
2062, 418, 1668, 1669, 419
2063, 419, 1669, 1670, 420
2064, 420, 1670, 1671, 421
2065, 421, 1671, 1672, 422
2066, 422, 1672, 448, 28
2067, 446, 447, 1673, 1654
2068, 1654, 1673, 1674, 1655
2069, 1655, 1674, 1675, 1656
2070, 1656, 1675, 1676, 1657
2071, 1657, 1676, 1677, 1658
2072, 1658, 1677, 1678, 1659
2073, 1659, 1678, 1679, 1660
2074, 1660, 1679, 1680, 1661
2075, 1661, 1680, 1681, 1662
2076, 1662, 1681, 1682, 1663
2077, 1663, 1682, 1683, 1664
2078, 1664, 1683, 1684, 1665
2079, 1665, 1684, 1685, 1666
2080, 1666, 1685, 1686, 1667
2081, 1667, 1686, 1687, 1668
2082, 1668, 1687, 1688, 1669
2083, 1669, 1688, 1689, 1670
2084, 1670, 1689, 1690, 1671
2085, 1671, 1690, 1691, 1672
2086, 1672, 1691, 449, 448
2087, 447, 31, 450, 1673
2088, 1673, 450, 451, 1674
2089, 1674, 451, 452, 1675
2090, 1675, 452, 453, 1676
2091, 1676, 453, 454, 1677
2092, 1677, 454, 455, 1678
2093, 1678, 455, 456, 1679
2094, 1679, 456, 457, 1680
2095, 1680, 457, 458, 1681
2096, 1681, 458, 459, 1682
2097, 1682, 459, 460, 1683
2098, 1683, 460, 461, 1684
2099, 1684, 461, 462, 1685
2100, 1685, 462, 463, 1686
2101, 1686, 463, 464, 1687
2102, 1687, 464, 465, 1688
2103, 1688, 465, 466, 1689
2104, 1689, 466, 467, 1690
2105, 1690, 467, 468, 1691
2106, 1691, 468, 32, 449
*ELEMENT, type=CPS4, ELSET=Surface16
2107, 25, 469, 1692, 423
2108, 423, 1692, 1693, 424
2109, 424, 1693, 472, 29
2110, 469, 470, 1694, 1692
2111, 1692, 1694, 1695, 1693
2112, 1693, 1695, 473, 472
2113, 470, 471, 1696, 1694
2114, 1694, 1696, 1697, 1695
2115, 1695, 1697, 474, 473
2116, 471, 33, 475, 1696
2117, 1696, 475, 476, 1697
2118, 1697, 476, 34, 474
*ELEMENT, type=CPS4, ELSET=Surface17
2119, 28, 477, 1698, 448
2120, 448, 1698, 1699, 449
2121, 449, 1699, 480, 32
2122, 477, 478, 1700, 1698
2123, 1698, 1700, 1701, 1699
2124, 1699, 1701, 481, 480
2125, 478, 479, 1702, 1700
2126, 1700, 1702, 1703, 1701
2127, 1701, 1703, 482, 481
2128, 479, 35, 483, 1702
2129, 1702, 483, 484, 1703
2130, 1703, 484, 36, 482
*ELEMENT, type=CPS4, ELSET=Surface18
2131, 29, 485, 1704, 472
2132, 472, 1704, 1705, 473
2133, 473, 1705, 1706, 474
2134, 474, 1706, 489, 34
2135, 485, 486, 1707, 1704
2136, 1704, 1707, 1708, 1705
2137, 1705, 1708, 1709, 1706
2138, 1706, 1709, 490, 489
2139, 486, 487, 1710, 1707
2140, 1707, 1710, 1711, 1708
2141, 1708, 1711, 1712, 1709
2142, 1709, 1712, 491, 490
2143, 487, 488, 1713, 1710
2144, 1710, 1713, 1714, 1711
2145, 1711, 1714, 1715, 1712
2146, 1712, 1715, 492, 491
2147, 488, 37, 493, 1713
2148, 1713, 493, 494, 1714
2149, 1714, 494, 495, 1715
2150, 1715, 495, 38, 492
*ELEMENT, type=CPS4, ELSET=Surface19
2151, 29, 485, 1716, 427
2152, 427, 1716, 1717, 428
2153, 428, 1717, 1718, 429
2154, 429, 1718, 1719, 430
2155, 430, 1719, 1720, 431
2156, 431, 1720, 1721, 432
2157, 432, 1721, 1722, 433
2158, 433, 1722, 1723, 434
2159, 434, 1723, 1724, 435
2160, 435, 1724, 1725, 436
2161, 436, 1725, 1726, 437
2162, 437, 1726, 1727, 438
2163, 438, 1727, 1728, 439
2164, 439, 1728, 1729, 440
2165, 440, 1729, 1730, 441
2166, 441, 1730, 1731, 442
2167, 442, 1731, 1732, 443
2168, 443, 1732, 1733, 444
2169, 444, 1733, 1734, 445
2170, 445, 1734, 496, 30
2171, 485, 486, 1735, 1716
2172, 1716, 1735, 1736, 1717
2173, 1717, 1736, 1737, 1718
2174, 1718, 1737, 1738, 1719
2175, 1719, 1738, 1739, 1720
2176, 1720, 1739, 1740, 1721
2177, 1721, 1740, 1741, 1722
2178, 1722, 1741, 1742, 1723
2179, 1723, 1742, 1743, 1724
2180, 1724, 1743, 1744, 1725
2181, 1725, 1744, 1745, 1726
2182, 1726, 1745, 1746, 1727
2183, 1727, 1746, 1747, 1728
2184, 1728, 1747, 1748, 1729
2185, 1729, 1748, 1749, 1730
2186, 1730, 1749, 1750, 1731
2187, 1731, 1750, 1751, 1732
2188, 1732, 1751, 1752, 1733
2189, 1733, 1752, 1753, 1734
2190, 1734, 1753, 497, 496
2191, 486, 487, 1754, 1735
2192, 1735, 1754, 1755, 1736
2193, 1736, 1755, 1756, 1737
2194, 1737, 1756, 1757, 1738
2195, 1738, 1757, 1758, 1739
2196, 1739, 1758, 1759, 1740
2197, 1740, 1759, 1760, 1741
2198, 1741, 1760, 1761, 1742
2199, 1742, 1761, 1762, 1743
2200, 1743, 1762, 1763, 1744
2201, 1744, 1763, 1764, 1745
2202, 1745, 1764, 1765, 1746
2203, 1746, 1765, 1766, 1747
2204, 1747, 1766, 1767, 1748
2205, 1748, 1767, 1768, 1749
2206, 1749, 1768, 1769, 1750
2207, 1750, 1769, 1770, 1751
2208, 1751, 1770, 1771, 1752
2209, 1752, 1771, 1772, 1753
2210, 1753, 1772, 498, 497
2211, 487, 488, 1773, 1754
2212, 1754, 1773, 1774, 1755
2213, 1755, 1774, 1775, 1756
2214, 1756, 1775, 1776, 1757
2215, 1757, 1776, 1777, 1758
2216, 1758, 1777, 1778, 1759
2217, 1759, 1778, 1779, 1760
2218, 1760, 1779, 1780, 1761
2219, 1761, 1780, 1781, 1762
2220, 1762, 1781, 1782, 1763
2221, 1763, 1782, 1783, 1764
2222, 1764, 1783, 1784, 1765
2223, 1765, 1784, 1785, 1766
2224, 1766, 1785, 1786, 1767
2225, 1767, 1786, 1787, 1768
2226, 1768, 1787, 1788, 1769
2227, 1769, 1788, 1789, 1770
2228, 1770, 1789, 1790, 1771
2229, 1771, 1790, 1791, 1772
2230, 1772, 1791, 499, 498
2231, 488, 37, 500, 1773
2232, 1773, 500, 501, 1774
2233, 1774, 501, 502, 1775
2234, 1775, 502, 503, 1776
2235, 1776, 503, 504, 1777
2236, 1777, 504, 505, 1778
2237, 1778, 505, 506, 1779
2238, 1779, 506, 507, 1780
2239, 1780, 507, 508, 1781
2240, 1781, 508, 509, 1782
2241, 1782, 509, 510, 1783
2242, 1783, 510, 511, 1784
2243, 1784, 511, 512, 1785
2244, 1785, 512, 513, 1786
2245, 1786, 513, 514, 1787
2246, 1787, 514, 515, 1788
2247, 1788, 515, 516, 1789
2248, 1789, 516, 517, 1790
2249, 1790, 517, 518, 1791
2250, 1791, 518, 39, 499
*ELEMENT, type=CPS4, ELSET=Surface20
2251, 31, 519, 1792, 450
2252, 450, 1792, 1793, 451
2253, 451, 1793, 1794, 452
2254, 452, 1794, 1795, 453
2255, 453, 1795, 1796, 454
2256, 454, 1796, 1797, 455
2257, 455, 1797, 1798, 456
2258, 456, 1798, 1799, 457
2259, 457, 1799, 1800, 458
2260, 458, 1800, 1801, 459
2261, 459, 1801, 1802, 460
2262, 460, 1802, 1803, 461
2263, 461, 1803, 1804, 462
2264, 462, 1804, 1805, 463
2265, 463, 1805, 1806, 464
2266, 464, 1806, 1807, 465
2267, 465, 1807, 1808, 466
2268, 466, 1808, 1809, 467
2269, 467, 1809, 1810, 468
2270, 468, 1810, 523, 32
2271, 519, 520, 1811, 1792
2272, 1792, 1811, 1812, 1793
2273, 1793, 1812, 1813, 1794
2274, 1794, 1813, 1814, 1795
2275, 1795, 1814, 1815, 1796
2276, 1796, 1815, 1816, 1797
2277, 1797, 1816, 1817, 1798
2278, 1798, 1817, 1818, 1799
2279, 1799, 1818, 1819, 1800
2280, 1800, 1819, 1820, 1801
2281, 1801, 1820, 1821, 1802
2282, 1802, 1821, 1822, 1803
2283, 1803, 1822, 1823, 1804
2284, 1804, 1823, 1824, 1805
2285, 1805, 1824, 1825, 1806
2286, 1806, 1825, 1826, 1807
2287, 1807, 1826, 1827, 1808
2288, 1808, 1827, 1828, 1809
2289, 1809, 1828, 1829, 1810
2290, 1810, 1829, 524, 523
2291, 520, 521, 1830, 1811
2292, 1811, 1830, 1831, 1812
2293, 1812, 1831, 1832, 1813
2294, 1813, 1832, 1833, 1814
2295, 1814, 1833, 1834, 1815
2296, 1815, 1834, 1835, 1816
2297, 1816, 1835, 1836, 1817
2298, 1817, 1836, 1837, 1818
2299, 1818, 1837, 1838, 1819
2300, 1819, 1838, 1839, 1820
2301, 1820, 1839, 1840, 1821
2302, 1821, 1840, 1841, 1822
2303, 1822, 1841, 1842, 1823
2304, 1823, 1842, 1843, 1824
2305, 1824, 1843, 1844, 1825
2306, 1825, 1844, 1845, 1826
2307, 1826, 1845, 1846, 1827
2308, 1827, 1846, 1847, 1828
2309, 1828, 1847, 1848, 1829
2310, 1829, 1848, 525, 524
2311, 521, 522, 1849, 1830
2312, 1830, 1849, 1850, 1831
2313, 1831, 1850, 1851, 1832
2314, 1832, 1851, 1852, 1833
2315, 1833, 1852, 1853, 1834
2316, 1834, 1853, 1854, 1835
2317, 1835, 1854, 1855, 1836
2318, 1836, 1855, 1856, 1837
2319, 1837, 1856, 1857, 1838
2320, 1838, 1857, 1858, 1839
2321, 1839, 1858, 1859, 1840
2322, 1840, 1859, 1860, 1841
2323, 1841, 1860, 1861, 1842
2324, 1842, 1861, 1862, 1843
2325, 1843, 1862, 1863, 1844
2326, 1844, 1863, 1864, 1845
2327, 1845, 1864, 1865, 1846
2328, 1846, 1865, 1866, 1847
2329, 1847, 1866, 1867, 1848
2330, 1848, 1867, 526, 525
2331, 522, 40, 527, 1849
2332, 1849, 527, 528, 1850
2333, 1850, 528, 529, 1851
2334, 1851, 529, 530, 1852
2335, 1852, 530, 531, 1853
2336, 1853, 531, 532, 1854
2337, 1854, 532, 533, 1855
2338, 1855, 533, 534, 1856
2339, 1856, 534, 535, 1857
2340, 1857, 535, 536, 1858
2341, 1858, 536, 537, 1859
2342, 1859, 537, 538, 1860
2343, 1860, 538, 539, 1861
2344, 1861, 539, 540, 1862
2345, 1862, 540, 541, 1863
2346, 1863, 541, 542, 1864
2347, 1864, 542, 543, 1865
2348, 1865, 543, 544, 1866
2349, 1866, 544, 545, 1867
2350, 1867, 545, 41, 526
*ELEMENT, type=CPS4, ELSET=Surface21
2351, 32, 523, 1868, 480
2352, 480, 1868, 1869, 481
2353, 481, 1869, 1870, 482
2354, 482, 1870, 546, 36
2355, 523, 524, 1871, 1868
2356, 1868, 1871, 1872, 1869
2357, 1869, 1872, 1873, 1870
2358, 1870, 1873, 547, 546
2359, 524, 525, 1874, 1871
2360, 1871, 1874, 1875, 1872
2361, 1872, 1875, 1876, 1873
2362, 1873, 1876, 548, 547
2363, 525, 526, 1877, 1874
2364, 1874, 1877, 1878, 1875
2365, 1875, 1878, 1879, 1876
2366, 1876, 1879, 549, 548
2367, 526, 41, 550, 1877
2368, 1877, 550, 551, 1878
2369, 1878, 551, 552, 1879
2370, 1879, 552, 42, 549
*ELEMENT, type=CPS4, ELSET=Surface22
2371, 9, 553, 1880, 173
2372, 173, 1880, 1881, 174
2373, 174, 1881, 1882, 175
2374, 175, 1882, 1883, 176
2375, 176, 1883, 1884, 177
2376, 177, 1884, 1885, 178
2377, 178, 1885, 1886, 179
2378, 179, 1886, 1887, 180
