*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Quad_Coarse.inp
*NODE
1, 0, 0, 0
2, 1, 0, 0
3, 1, 1.2, 0
4, 0, 1.2, 0
5, 1, 1.3, 0
6, 0, 1.3, 0
7, 1.2, 1.2, 0
8, 1.2, 1.3, 0
9, 2.2, 1.2, 0
10, 2.2, 1.3, 0
11, 1.2, 0, 0
12, 2.2, 0, 0
13, 1.2, -0.1, 0
14, 2.2, -0.1, 0
15, 0, -0.1, 0
16, 1, -0.1, 0
17, 2.3, 0, 0
18, 2.3, -0.1, 0
19, -0.1, 0, 0
20, -0.1, -0.1, 0
21, 0, -0.3, 0
22, 1, -0.3, 0
23, -0.1, -0.3, 0
24, 1.2, -0.3, 0
25, 2.2, -0.3, 0
26, 2.3, -0.3, 0
27, 1, 1.5, 0
28, 0, 1.5, 0
29, 1.2, 1.5, 0
30, 2.2, 1.5, 0
31, 0.5, 0, 0
32, 1, 0.6, 0
33, 0.5, 1.2, 0
34, 0, 0.6, 0
35, 1, 1.2333333333333, 0
36, 1, 1.2666666666667, 0
37, 0, 1.2333333333333, 0
38, 0, 1.2666666666667, 0
39, 0.5, 1.3, 0
40, 1.04, 1.2, 0
41, 1.08, 1.2, 0
42, 1.12, 1.2, 0
43, 1.16, 1.2, 0
44, 1.04, 1.3, 0
45, 1.08, 1.3, 0
46, 1.12, 1.3, 0
47, 1.16, 1.3, 0
48, 1.2, 1.2333333333333, 0
49, 1.2, 1.2666666666667, 0
50, 1.7, 1.2, 0
51, 1.7, 1.3, 0
52, 2.2, 1.2333333333333, 0
53, 2.2, 1.2666666666667, 0
54, 1.2, 0.6, 0
55, 2.2, 0.6, 0
56, 1.7, 0, 0
57, 1.2, -0.033333333333333, 0
58, 1.2, -0.066666666666667, 0
59, 2.2, -0.033333333333333, 0
60, 2.2, -0.066666666666667, 0
61, 1.7, -0.1, 0
62, 0, -0.033333333333333, 0
63, 0, -0.066666666666667, 0
64, 1, -0.033333333333333, 0
65, 1, -0.066666666666667, 0
66, 0.5, -0.1, 0
67, 2.25, 0, 0
68, 2.25, -0.1, 0
69, 2.3, -0.033333333333333, 0
70, 2.3, -0.066666666666667, 0
71, -0.05, 0, 0
72, -0.05, -0.1, 0
73, -0.1, -0.033333333333333, 0
74, -0.1, -0.066666666666667, 0
75, 0, -0.14, 0
76, 0, -0.18, 0
77, 0, -0.22, 0
78, 0, -0.26, 0
79, 1, -0.14, 0
80, 1, -0.18, 0
81, 1, -0.22, 0
82, 1, -0.26, 0
83, 0.5, -0.3, 0
84, -0.1, -0.14, 0
85, -0.1, -0.18, 0
86, -0.1, -0.22, 0
87, -0.1, -0.26, 0
88, -0.05, -0.3, 0
89, 1.2, -0.14, 0
90, 1.2, -0.18, 0
91, 1.2, -0.22, 0
92, 1.2, -0.26, 0
93, 2.2, -0.14, 0
94, 2.2, -0.18, 0
95, 2.2, -0.22, 0
96, 2.2, -0.26, 0
97, 1.7, -0.3, 0
98, 2.3, -0.14, 0
99, 2.3, -0.18, 0
100, 2.3, -0.22, 0
101, 2.3, -0.26, 0
102, 2.25, -0.3, 0
103, 1, 1.34, 0
104, 1, 1.38, 0
105, 1, 1.42, 0
106, 1, 1.46, 0
107, 0, 1.34, 0
108, 0, 1.38, 0
109, 0, 1.42, 0
110, 0, 1.46, 0
111, 0.5, 1.5, 0
112, 1.2, 1.34, 0
113, 1.2, 1.38, 0
114, 1.2, 1.42, 0
115, 1.2, 1.46, 0
116, 1.04, 1.5, 0
117, 1.08, 1.5, 0
118, 1.12, 1.5, 0
119, 1.16, 1.5, 0
120, 2.2, 1.34, 0
121, 2.2, 1.38, 0
122, 2.2, 1.42, 0
123, 2.2, 1.46, 0
124, 1.7, 1.5, 0
125, 0.5, 0.6, 0
126, 0.5, 1.2333333333333, 0
127, 0.5, 1.2666666666667, 0
128, 1.04, 1.2333333333333, 0
129, 1.04, 1.2666666666667, 0
130, 1.08, 1.2333333333333, 0
131, 1.08, 1.2666666666667, 0
132, 1.12, 1.2333333333333, 0
133, 1.12, 1.2666666666667, 0
134, 1.16, 1.2333333333333, 0
135, 1.16, 1.2666666666667, 0
136, 1.7, 1.2333333333333, 0
137, 1.7, 1.2666666666667, 0
138, 1.7, 0.6, 0
139, 1.7, -0.033333333333333, 0
140, 1.7, -0.066666666666667, 0
141, 0.5, -0.033333333333333, 0
142, 0.5, -0.066666666666667, 0
143, 2.25, -0.033333333333333, 0
144, 2.25, -0.066666666666667, 0
145, -0.05, -0.033333333333333, 0
146, -0.05, -0.066666666666667, 0
147, 0.5, -0.14, 0
148, 0.5, -0.18, 0
149, 0.5, -0.22, 0
150, 0.5, -0.26, 0
151, -0.05, -0.14, 0
152, -0.05, -0.18, 0
153, -0.05, -0.22, 0
154, -0.05, -0.26, 0
155, 1.7, -0.14, 0
156, 1.7, -0.18, 0
157, 1.7, -0.22, 0
158, 1.7, -0.26, 0
159, 2.25, -0.14, 0
160, 2.25, -0.18, 0
161, 2.25, -0.22, 0
162, 2.25, -0.26, 0
163, 0.5, 1.34, 0
164, 0.5, 1.38, 0
165, 0.5, 1.42, 0
166, 0.5, 1.46, 0
167, 1.04, 1.34, 0
168, 1.08, 1.34, 0
169, 1.12, 1.34, 0
170, 1.16, 1.34, 0
171, 1.04, 1.38, 0
172, 1.08, 1.38, 0
173, 1.12, 1.38, 0
174, 1.16, 1.38, 0
175, 1.04, 1.42, 0
176, 1.08, 1.42, 0
177, 1.12, 1.42, 0
178, 1.16, 1.42, 0
179, 1.04, 1.46, 0
180, 1.08, 1.46, 0
181, 1.12, 1.46, 0
182, 1.16, 1.46, 0
183, 1.7, 1.34, 0
184, 1.7, 1.38, 0
185, 1.7, 1.42, 0
186, 1.7, 1.46, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
31, 1, 31
32, 31, 2
*ELEMENT, type=T3D2, ELSET=Line2
33, 2, 32
34, 32, 3
*ELEMENT, type=T3D2, ELSET=Line3
35, 3, 33
36, 33, 4
*ELEMENT, type=T3D2, ELSET=Line4
37, 4, 34
38, 34, 1
*ELEMENT, type=T3D2, ELSET=Line5
39, 3, 35
40, 35, 36
41, 36, 5
*ELEMENT, type=T3D2, ELSET=Line6
42, 4, 37
43, 37, 38
44, 38, 6
*ELEMENT, type=T3D2, ELSET=Line7
45, 5, 39
46, 39, 6
*ELEMENT, type=T3D2, ELSET=Line8
47, 3, 40
48, 40, 41
49, 41, 42
50, 42, 43
51, 43, 7
*ELEMENT, type=T3D2, ELSET=Line9
52, 5, 44
53, 44, 45
54, 45, 46
55, 46, 47
56, 47, 8
*ELEMENT, type=T3D2, ELSET=Line10
57, 7, 48
58, 48, 49
59, 49, 8
*ELEMENT, type=T3D2, ELSET=Line11
60, 7, 50
61, 50, 9
*ELEMENT, type=T3D2, ELSET=Line12
62, 8, 51
63, 51, 10
*ELEMENT, type=T3D2, ELSET=Line13
64, 9, 52
65, 52, 53
66, 53, 10
*ELEMENT, type=T3D2, ELSET=Line14
67, 7, 54
68, 54, 11
*ELEMENT, type=T3D2, ELSET=Line15
69, 9, 55
70, 55, 12
*ELEMENT, type=T3D2, ELSET=Line16
71, 11, 56
72, 56, 12
*ELEMENT, type=T3D2, ELSET=Line17
73, 11, 57
74, 57, 58
75, 58, 13
*ELEMENT, type=T3D2, ELSET=Line18
76, 12, 59
77, 59, 60
78, 60, 14
*ELEMENT, type=T3D2, ELSET=Line19
79, 13, 61
80, 61, 14
*ELEMENT, type=T3D2, ELSET=Line20
81, 1, 62
82, 62, 63
83, 63, 15
*ELEMENT, type=T3D2, ELSET=Line21
84, 2, 64
85, 64, 65
86, 65, 16
*ELEMENT, type=T3D2, ELSET=Line22
87, 15, 66
88, 66, 16
*ELEMENT, type=T3D2, ELSET=Line23
89, 12, 67
90, 67, 17
*ELEMENT, type=T3D2, ELSET=Line24
91, 14, 68
92, 68, 18
*ELEMENT, type=T3D2, ELSET=Line25
93, 17, 69
94, 69, 70
95, 70, 18
*ELEMENT, type=T3D2, ELSET=Line26
96, 1, 71
97, 71, 19
*ELEMENT, type=T3D2, ELSET=Line27
98, 15, 72
99, 72, 20
*ELEMENT, type=T3D2, ELSET=Line28
100, 19, 73
101, 73, 74
102, 74, 20
*ELEMENT, type=T3D2, ELSET=Line29
103, 15, 75
104, 75, 76
105, 76, 77
106, 77, 78
107, 78, 21
*ELEMENT, type=T3D2, ELSET=Line30
108, 16, 79
109, 79, 80
110, 80, 81
111, 81, 82
112, 82, 22
*ELEMENT, type=T3D2, ELSET=Line31
113, 21, 83
114, 83, 22
*ELEMENT, type=T3D2, ELSET=Line32
115, 20, 84
116, 84, 85
117, 85, 86
118, 86, 87
119, 87, 23
*ELEMENT, type=T3D2, ELSET=Line33
120, 21, 88
121, 88, 23
*ELEMENT, type=T3D2, ELSET=Line34
122, 13, 89
123, 89, 90
124, 90, 91
125, 91, 92
126, 92, 24
*ELEMENT, type=T3D2, ELSET=Line35
127, 14, 93
128, 93, 94
129, 94, 95
130, 95, 96
131, 96, 25
*ELEMENT, type=T3D2, ELSET=Line36
132, 24, 97
133, 97, 25
*ELEMENT, type=T3D2, ELSET=Line37
134, 18, 98
135, 98, 99
136, 99, 100
137, 100, 101
138, 101, 26
*ELEMENT, type=T3D2, ELSET=Line38
139, 25, 102
140, 102, 26
*ELEMENT, type=T3D2, ELSET=Line39
141, 5, 103
142, 103, 104
143, 104, 105
144, 105, 106
145, 106, 27
*ELEMENT, type=T3D2, ELSET=Line40
146, 6, 107
147, 107, 108
148, 108, 109
149, 109, 110
150, 110, 28
*ELEMENT, type=T3D2, ELSET=Line41
151, 27, 111
152, 111, 28
*ELEMENT, type=T3D2, ELSET=Line42
153, 8, 112
154, 112, 113
155, 113, 114
156, 114, 115
157, 115, 29
*ELEMENT, type=T3D2, ELSET=Line43
158, 27, 116
159, 116, 117
160, 117, 118
161, 118, 119
162, 119, 29
*ELEMENT, type=T3D2, ELSET=Line44
163, 10, 120
164, 120, 121
165, 121, 122
166, 122, 123
167, 123, 30
*ELEMENT, type=T3D2, ELSET=Line45
168, 29, 124
169, 124, 30
*ELEMENT, type=CPS4, ELSET=Surface1
170, 1, 31, 125, 34
171, 34, 125, 33, 4
172, 31, 2, 32, 125
173, 125, 32, 3, 33
*ELEMENT, type=CPS4, ELSET=Surface2
174, 3, 35, 126, 33
175, 33, 126, 37, 4
176, 35, 36, 127, 126
177, 126, 127, 38, 37
178, 36, 5, 39, 127
179, 127, 39, 6, 38
*ELEMENT, type=CPS4, ELSET=Surface3
180, 3, 40, 128, 35
181, 35, 128, 129, 36
182, 36, 129, 44, 5
183, 40, 41, 130, 128
184, 128, 130, 131, 129
185, 129, 131, 45, 44
186, 41, 42, 132, 130
187, 130, 132, 133, 131
188, 131, 133, 46, 45
189, 42, 43, 134, 132
190, 132, 134, 135, 133
191, 133, 135, 47, 46
192, 43, 7, 48, 134
193, 134, 48, 49, 135
194, 135, 49, 8, 47
*ELEMENT, type=CPS4, ELSET=Surface4
195, 7, 50, 136, 48
196, 48, 136, 137, 49
197, 49, 137, 51, 8
198, 50, 9, 52, 136
199, 136, 52, 53, 137
200, 137, 53, 10, 51
*ELEMENT, type=CPS4, ELSET=Surface5
201, 7, 54, 138, 50
202, 50, 138, 55, 9
203, 54, 11, 56, 138
204, 138, 56, 12, 55
*ELEMENT, type=CPS4, ELSET=Surface6
205, 11, 57, 139, 56
206, 56, 139, 59, 12
207, 57, 58, 140, 139
208, 139, 140, 60, 59
209, 58, 13, 61, 140
210, 140, 61, 14, 60
*ELEMENT, type=CPS4, ELSET=Surface7
211, 1, 62, 141, 31
212, 31, 141, 64, 2
213, 62, 63, 142, 141
214, 141, 142, 65, 64
215, 63, 15, 66, 142
216, 142, 66, 16, 65
*ELEMENT, type=CPS4, ELSET=Surface8
217, 12, 67, 143, 59
218, 59, 143, 144, 60
219, 60, 144, 68, 14
220, 67, 17, 69, 143
221, 143, 69, 70, 144
222, 144, 70, 18, 68
*ELEMENT, type=CPS4, ELSET=Surface9
223, 1, 71, 145, 62
224, 62, 145, 146, 63
225, 63, 146, 72, 15
226, 71, 19, 73, 145
227, 145, 73, 74, 146
228, 146, 74, 20, 72
*ELEMENT, type=CPS4, ELSET=Surface10
229, 15, 75, 147, 66
230, 66, 147, 79, 16
231, 75, 76, 148, 147
232, 147, 148, 80, 79
233, 76, 77, 149, 148
234, 148, 149, 81, 80
235, 77, 78, 150, 149
236, 149, 150, 82, 81
237, 78, 21, 83, 150
238, 150, 83, 22, 82
*ELEMENT, type=CPS4, ELSET=Surface11
239, 15, 75, 151, 72
240, 72, 151, 84, 20
241, 75, 76, 152, 151
242, 151, 152, 85, 84
243, 76, 77, 153, 152
244, 152, 153, 86, 85
245, 77, 78, 154, 153
246, 153, 154, 87, 86
247, 78, 21, 88, 154
248, 154, 88, 23, 87
*ELEMENT, type=CPS4, ELSET=Surface12
249, 13, 89, 155, 61
250, 61, 155, 93, 14
251, 89, 90, 156, 155
252, 155, 156, 94, 93
253, 90, 91, 157, 156
254, 156, 157, 95, 94
255, 91, 92, 158, 157
256, 157, 158, 96, 95
257, 92, 24, 97, 158
258, 158, 97, 25, 96
*ELEMENT, type=CPS4, ELSET=Surface13
259, 14, 93, 159, 68
260, 68, 159, 98, 18
261, 93, 94, 160, 159
262, 159, 160, 99, 98
263, 94, 95, 161, 160
264, 160, 161, 100, 99
265, 95, 96, 162, 161
266, 161, 162, 101, 100
267, 96, 25, 102, 162
268, 162, 102, 26, 101
*ELEMENT, type=CPS4, ELSET=Surface14
269, 5, 103, 163, 39
270, 39, 163, 107, 6
271, 103, 104, 164, 163
272, 163, 164, 108, 107
273, 104, 105, 165, 164
274, 164, 165, 109, 108
275, 105, 106, 166, 165
276, 165, 166, 110, 109
277, 106, 27, 111, 166
278, 166, 111, 28, 110
*ELEMENT, type=CPS4, ELSET=Surface15
279, 5, 103, 167, 44
280, 44, 167, 168, 45
281, 45, 168, 169, 46
282, 46, 169, 170, 47
283, 47, 170, 112, 8
284, 103, 104, 171, 167
285, 167, 171, 172, 168
286, 168, 172, 173, 169
287, 169, 173, 174, 170
288, 170, 174, 113, 112
289, 104, 105, 175, 171
290, 171, 175, 176, 172
291, 172, 176, 177, 173
292, 173, 177, 178, 174
293, 174, 178, 114, 113
294, 105, 106, 179, 175
295, 175, 179, 180, 176
296, 176, 180, 181, 177
297, 177, 181, 182, 178
298, 178, 182, 115, 114
299, 106, 27, 116, 179
300, 179, 116, 117, 180
301, 180, 117, 118, 181
302, 181, 118, 119, 182
303, 182, 119, 29, 115
*ELEMENT, type=CPS4, ELSET=Surface16
304, 8, 112, 183, 51
305, 51, 183, 120, 10
306, 112, 113, 184, 183
307, 183, 184, 121, 120
308, 113, 114, 185, 184
309, 184, 185, 122, 121
310, 114, 115, 186, 185
311, 185, 186, 123, 122
312, 115, 29, 124, 186
313, 186, 124, 30, 123
*ELSET,ELSET=Ceramic_Top
151, 152, 158, 159, 160, 161, 162, 168, 169, 
*ELSET,ELSET=Ceramic_Bottom
113, 114, 120, 121, 132, 133, 139, 140, 
*ELSET,ELSET=Electrode_MinX
100, 101, 102, 
*ELSET,ELSET=Electrode_MaxX
93, 94, 95, 
*ELSET,ELSET=Contact_Ceramic
45, 46, 52, 53, 54, 55, 56, 62, 63, 79, 
80, 87, 88, 91, 92, 98, 99, 
*ELSET,ELSET=Copper
174, 175, 176, 177, 178, 179, 180, 181, 182, 183, 
184, 185, 186, 187, 188, 189, 190, 191, 192, 193, 
194, 195, 196, 197, 198, 199, 200, 205, 206, 207, 
208, 209, 210, 211, 212, 213, 214, 215, 216, 217, 
218, 219, 220, 221, 222, 223, 224, 225, 226, 227, 
228, 
*ELSET,ELSET=SemiconductorL
170, 171, 172, 173, 
*ELSET,ELSET=SemiconductorR
201, 202, 203, 204, 
*ELSET,ELSET=Ceramic
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
279, 280, 281, 282, 283, 284, 285, 286, 287, 288, 
289, 290, 291, 292, 293, 294, 295, 296, 297, 298, 
299, 300, 301, 302, 303, 304, 305, 306, 307, 308, 
309, 310, 311, 312, 313, 
*ELSET,ELSET=Surface
170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 
180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 
190, 191, 192, 193, 194, 195, 196, 197, 198, 199, 
200, 201, 202, 203, 204, 205, 206, 207, 208, 209, 
210, 211, 212, 213, 214, 215, 216, 217, 218, 219, 
220, 221, 222, 223, 224, 225, 226, 227, 228, 229, 
230, 231, 232, 233, 234, 235, 236, 237, 238, 239, 
240, 241, 242, 243, 244, 245, 246, 247, 248, 249, 
250, 251, 252, 253, 254, 255, 256, 257, 258, 259, 
260, 261, 262, 263, 264, 265, 266, 267, 268, 269, 
270, 271, 272, 273, 274, 275, 276, 277, 278, 279, 
280, 281, 282, 283, 284, 285, 286, 287, 288, 289, 
290, 291, 292, 293, 294, 295, 296, 297, 298, 299, 
300, 301, 302, 303, 304, 305, 306, 307, 308, 309, 
310, 311, 312, 313, 
*ELSET,ELSET=TO
170, 171, 172, 173, 201, 202, 203, 204, 
*NSET,NSET=Ceramic_Top
27, 28, 29, 30, 111, 116, 117, 118, 119, 124, 
*NSET,NSET=Ceramic_Bottom
21, 22, 23, 24, 25, 26, 83, 88, 97, 102, 
*NSET,NSET=Electrode_MinX
19, 20, 73, 74, 
*NSET,NSET=Electrode_MaxX
17, 18, 69, 70, 
*NSET,NSET=Contact_Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
39, 44, 45, 46, 47, 51, 61, 66, 68, 72, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
31, 33, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 
53, 56, 57, 58, 59, 60, 61, 62, 63, 64, 
65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 
126, 127, 128, 129, 130, 131, 132, 133, 134, 135, 
136, 137, 139, 140, 141, 142, 143, 144, 145, 146, 
*NSET,NSET=SemiconductorL
1, 2, 3, 4, 31, 32, 33, 34, 125, 
*NSET,NSET=SemiconductorR
7, 9, 11, 12, 50, 54, 55, 56, 138, 
*NSET,NSET=Ceramic
5, 6, 8, 10, 13, 14, 15, 16, 18, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
39, 44, 45, 46, 47, 51, 61, 66, 68, 72, 
75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 
105, 106, 107, 108, 109, 110, 111, 112, 113, 114, 
115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 181, 182, 183, 184, 185, 186, 
*NSET,NSET=Surface
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 
*NSET,NSET=TO
1, 2, 3, 4, 7, 9, 11, 12, 31, 32, 
33, 34, 50, 54, 55, 56, 125, 138, 
