2728, 2494, 2495, 2499, 2498, 2566, 2567, 2571, 2570, 2524, 2532, 2533, 2530, 2596, 2604, 2605, 
2602, 4912, 4913, 4917, 4916
2729, 2495, 2496, 2500, 2499, 2567, 2568, 2572, 2571, 2526, 2534, 2535, 2532, 2598, 2606, 2607, 
2604, 4913, 4914, 4918, 4917
2730, 2496, 590, 591, 2500, 2568, 630, 631, 2572, 2527, 595, 2536, 2534, 2599, 635, 2608, 
2606, 4914, 2555, 2556, 4918
2731, 582, 2497, 543, 37, 622, 2569, 599, 41, 2529, 2537, 547, 587, 2601, 2609, 603, 
627, 2552, 4915, 2541, 597
2732, 2497, 2498, 544, 543, 2569, 2570, 600, 599, 2531, 2538, 548, 2537, 2603, 2610, 604, 
2609, 4915, 4916, 2542, 2541
2733, 2498, 2499, 545, 544, 2570, 2571, 601, 600, 2533, 2539, 549, 2538, 2605, 2611, 605, 
2610, 4916, 4917, 2543, 2542
2734, 2499, 2500, 546, 545, 2571, 2572, 602, 601, 2535, 2540, 550, 2539, 2607, 2612, 606, 
2611, 4917, 4918, 2544, 2543
2735, 2500, 591, 38, 546, 2572, 631, 42, 602, 2536, 596, 551, 2540, 2608, 636, 607, 
2612, 4918, 2556, 598, 2544
*ELEMENT, type=C3D20, ELSET=Volume11
2736, 43, 610, 2557, 619, 652, 2630, 4919, 2647, 614, 2573, 2574, 623, 2635, 4936, 4937, 
2651, 653, 2634, 4935, 2652
2737, 652, 2630, 4919, 2647, 47, 658, 2681, 667, 2635, 4936, 4937, 2651, 662, 2697, 2698, 
671, 654, 2636, 4938, 2653
2738, 610, 611, 2558, 2557, 2630, 2631, 4920, 4919, 615, 2575, 2576, 2573, 2638, 4940, 4941, 
4936, 2634, 2637, 4939, 4935
2739, 2630, 2631, 4920, 4919, 658, 659, 2682, 2681, 2638, 4940, 4941, 4936, 663, 2699, 2700, 
2697, 2636, 2639, 4942, 4938
2740, 611, 612, 2559, 2558, 2631, 2632, 4921, 4920, 616, 2577, 2578, 2575, 2641, 4944, 4945, 
4940, 2637, 2640, 4943, 4939
2741, 2631, 2632, 4921, 4920, 659, 660, 2683, 2682, 2641, 4944, 4945, 4940, 664, 2701, 2702, 
2699, 2639, 2642, 4946, 4942
2742, 612, 613, 2560, 2559, 2632, 2633, 4922, 4921, 617, 2579, 2580, 2577, 2644, 4948, 4949, 
4944, 2640, 2643, 4947, 4943
2743, 2632, 2633, 4922, 4921, 660, 661, 2684, 2683, 2644, 4948, 4949, 4944, 665, 2703, 2704, 
2701, 2642, 2645, 4950, 4946
2744, 613, 44, 628, 2560, 2633, 655, 2664, 4922, 618, 632, 2581, 2579, 2646, 2669, 4951, 
4948, 2643, 656, 2668, 4947
2745, 2633, 655, 2664, 4922, 661, 48, 676, 2684, 2646, 2669, 4951, 4948, 666, 680, 2705, 
2703, 2645, 657, 2670, 4950
2746, 619, 2557, 2561, 620, 2647, 4919, 4923, 2648, 2574, 2582, 2583, 624, 4937, 4953, 4954, 
2654, 2652, 4935, 4952, 2655
2747, 2647, 4919, 4923, 2648, 667, 2681, 2685, 668, 4937, 4953, 4954, 2654, 2698, 2706, 2707, 
672, 2653, 4938, 4955, 2656
2748, 2557, 2558, 2562, 2561, 4919, 4920, 4924, 4923, 2576, 2584, 2585, 2582, 4941, 4957, 4958, 
4953, 4935, 4939, 4956, 4952
2749, 4919, 4920, 4924, 4923, 2681, 2682, 2686, 2685, 4941, 4957, 4958, 4953, 2700, 2708, 2709, 
2706, 4938, 4942, 4959, 4955
2750, 2558, 2559, 2563, 2562, 4920, 4921, 4925, 4924, 2578, 2586, 2587, 2584, 4945, 4961, 4962, 
4957, 4939, 4943, 4960, 4956
2751, 4920, 4921, 4925, 4924, 2682, 2683, 2687, 2686, 4945, 4961, 4962, 4957, 2702, 2710, 2711, 
2708, 4942, 4946, 4963, 4959
2752, 2559, 2560, 2564, 2563, 4921, 4922, 4926, 4925, 2580, 2588, 2589, 2586, 4949, 4965, 4966, 
4961, 4943, 4947, 4964, 4960
2753, 4921, 4922, 4926, 4925, 2683, 2684, 2688, 2687, 4949, 4965, 4966, 4961, 2704, 2712, 2713, 
2710, 4946, 4950, 4967, 4963
2754, 2560, 628, 629, 2564, 4922, 2664, 2665, 4926, 2581, 633, 2590, 2588, 4951, 2672, 4968, 
4965, 4947, 2668, 2671, 4964
2755, 4922, 2664, 2665, 4926, 2684, 676, 677, 2688, 4951, 2672, 4968, 4965, 2705, 681, 2714, 
2712, 4950, 2670, 2673, 4967
2756, 620, 2561, 2565, 621, 2648, 4923, 4927, 2649, 2583, 2591, 2592, 625, 4954, 4970, 4971, 
2657, 2655, 4952, 4969, 2658
2757, 2648, 4923, 4927, 2649, 668, 2685, 2689, 669, 4954, 4970, 4971, 2657, 2707, 2715, 2716, 
673, 2656, 4955, 4972, 2659
2758, 2561, 2562, 2566, 2565, 4923, 4924, 4928, 4927, 2585, 2593, 2594, 2591, 4958, 4974, 4975, 
4970, 4952, 4956, 4973, 4969
2759, 4923, 4924, 4928, 4927, 2685, 2686, 2690, 2689, 4958, 4974, 4975, 4970, 2709, 2717, 2718, 
2715, 4955, 4959, 4976, 4972
2760, 2562, 2563, 2567, 2566, 4924, 4925, 4929, 4928, 2587, 2595, 2596, 2593, 4962, 4978, 4979, 
4974, 4956, 4960, 4977, 4973
2761, 4924, 4925, 4929, 4928, 2686, 2687, 2691, 2690, 4962, 4978, 4979, 4974, 2711, 2719, 2720, 
2717, 4959, 4963, 4980, 4976
2762, 2563, 2564, 2568, 2567, 4925, 4926, 4930, 4929, 2589, 2597, 2598, 2595, 4966, 4982, 4983, 
4978, 4960, 4964, 4981, 4977
2763, 4925, 4926, 4930, 4929, 2687, 2688, 2692, 2691, 4966, 4982, 4983, 4978, 2713, 2721, 2722, 
2719, 4963, 4967, 4984, 4980
2764, 2564, 629, 630, 2568, 4926, 2665, 2666, 4930, 2590, 634, 2599, 2597, 4968, 2675, 4985, 
4982, 4964, 2671, 2674, 4981
2765, 4926, 2665, 2666, 4930, 2688, 677, 678, 2692, 4968, 2675, 4985, 4982, 2714, 682, 2723, 
2721, 4967, 2673, 2676, 4984
2766, 621, 2565, 2569, 622, 2649, 4927, 4931, 2650, 2592, 2600, 2601, 626, 4971, 4987, 4988, 
2660, 2658, 4969, 4986, 2661
2767, 2649, 4927, 4931, 2650, 669, 2689, 2693, 670, 4971, 4987, 4988, 2660, 2716, 2724, 2725, 
674, 2659, 4972, 4989, 2662
2768, 2565, 2566, 2570, 2569, 4927, 4928, 4932, 4931, 2594, 2602, 2603, 2600, 4975, 4991, 4992, 
4987, 4969, 4973, 4990, 4986
2769, 4927, 4928, 4932, 4931, 2689, 2690, 2694, 2693, 4975, 4991, 4992, 4987, 2718, 2726, 2727, 
2724, 4972, 4976, 4993, 4989
2770, 2566, 2567, 2571, 2570, 4928, 4929, 4933, 4932, 2596, 2604, 2605, 2602, 4979, 4995, 4996, 
4991, 4973, 4977, 4994, 4990
2771, 4928, 4929, 4933, 4932, 2690, 2691, 2695, 2694, 4979, 4995, 4996, 4991, 2720, 2728, 2729, 
2726, 4976, 4980, 4997, 4993
2772, 2567, 2568, 2572, 2571, 4929, 4930, 4934, 4933, 2598, 2606, 2607, 2604, 4983, 4999, 5000, 
4995, 4977, 4981, 4998, 4994
2773, 4929, 4930, 4934, 4933, 2691, 2692, 2696, 2695, 4983, 4999, 5000, 4995, 2722, 2730, 2731, 
2728, 4980, 4984, 5001, 4997
2774, 2568, 630, 631, 2572, 4930, 2666, 2667, 4934, 2599, 635, 2608, 2606, 4985, 2678, 5002, 
4999, 4981, 2674, 2677, 4998
2775, 4930, 2666, 2667, 4934, 2692, 678, 679, 2696, 4985, 2678, 5002, 4999, 2723, 683, 2732, 
2730, 4984, 2676, 2679, 5001
2776, 622, 2569, 599, 41, 2650, 4931, 2613, 637, 2601, 2609, 603, 627, 4988, 5003, 2617, 
2663, 2661, 4986, 2618, 638
2777, 2650, 4931, 2613, 637, 670, 2693, 643, 45, 4988, 5003, 2617, 2663, 2725, 2733, 647, 
675, 2662, 4989, 2619, 639
2778, 2569, 2570, 600, 599, 4931, 4932, 2614, 2613, 2603, 2610, 604, 2609, 4992, 5004, 2620, 
5003, 4986, 4990, 2621, 2618
2779, 4931, 4932, 2614, 2613, 2693, 2694, 644, 643, 4992, 5004, 2620, 5003, 2727, 2734, 648, 
2733, 4989, 4993, 2622, 2619
2780, 2570, 2571, 601, 600, 4932, 4933, 2615, 2614, 2605, 2611, 605, 2610, 4996, 5005, 2623, 
5004, 4990, 4994, 2624, 2621
2781, 4932, 4933, 2615, 2614, 2694, 2695, 645, 644, 4996, 5005, 2623, 5004, 2729, 2735, 649, 
2734, 4993, 4997, 2625, 2622
2782, 2571, 2572, 602, 601, 4933, 4934, 2616, 2615, 2607, 2612, 606, 2611, 5000, 5006, 2626, 
5005, 4994, 4998, 2627, 2624
2783, 4933, 4934, 2616, 2615, 2695, 2696, 646, 645, 5000, 5006, 2626, 5005, 2731, 2736, 650, 
2735, 4997, 5001, 2628, 2625
2784, 2572, 631, 42, 602, 4934, 2667, 640, 2616, 2608, 636, 607, 2612, 5002, 2680, 2629, 
5006, 4998, 2677, 641, 2627
2785, 4934, 2667, 640, 2616, 2696, 679, 46, 646, 5002, 2680, 2629, 5006, 2732, 684, 651, 
2736, 5001, 2679, 642, 2628
*ELEMENT, type=C3D20, ELSET=Volume12
2786, 44, 628, 2664, 655, 51, 695, 2747, 692, 632, 2668, 2669, 656, 699, 2751, 2752, 
693, 690, 2739, 5007, 2738
2787, 655, 2664, 676, 48, 692, 2747, 704, 52, 2669, 2670, 680, 657, 2752, 2753, 708, 
694, 2738, 5007, 2743, 691
2788, 628, 629, 2665, 2664, 695, 696, 2748, 2747, 633, 2671, 2672, 2668, 700, 2754, 2755, 
2751, 2739, 2740, 5008, 5007
2789, 2664, 2665, 677, 676, 2747, 2748, 705, 704, 2672, 2673, 681, 2670, 2755, 2756, 709, 
2753, 5007, 5008, 2744, 2743
2790, 629, 630, 2666, 2665, 696, 697, 2749, 2748, 634, 2674, 2675, 2671, 701, 2757, 2758, 
2754, 2740, 2741, 5009, 5008
2791, 2665, 2666, 678, 677, 2748, 2749, 706, 705, 2675, 2676, 682, 2673, 2758, 2759, 710, 
2756, 5008, 5009, 2745, 2744
2792, 630, 631, 2667, 2666, 697, 698, 2750, 2749, 635, 2677, 2678, 2674, 702, 2760, 2761, 
2757, 2741, 2742, 5010, 5009
2793, 2666, 2667, 679, 678, 2749, 2750, 707, 706, 2678, 2679, 683, 2676, 2761, 2762, 711, 
2759, 5009, 5010, 2746, 2745
2794, 631, 42, 640, 2667, 698, 49, 687, 2750, 636, 641, 2680, 2677, 703, 688, 2763, 
2760, 2742, 685, 2737, 5010
2795, 2667, 640, 46, 679, 2750, 687, 50, 707, 2680, 642, 684, 2679, 2763, 689, 712, 
2762, 5010, 2737, 686, 2746
*ELEMENT, type=C3D20, ELSET=Volume13
2796, 2, 97, 1203, 118, 54, 715, 2774, 738, 101, 1207, 1208, 119, 719, 2778, 2779, 
739, 714, 2764, 5011, 2773
2797, 118, 1203, 109, 4, 738, 2774, 729, 56, 1208, 1209, 113, 120, 2779, 2780, 733, 
740, 2773, 5011, 2769, 728
2798, 97, 98, 1204, 1203, 715, 716, 2775, 2774, 102, 1210, 1211, 1207, 720, 2781, 2782, 
2778, 2764, 2765, 5012, 5011
2799, 1203, 1204, 110, 109, 2774, 2775, 730, 729, 1211, 1212, 114, 1209, 2782, 2783, 734, 
2780, 5011, 5012, 2770, 2769
2800, 98, 99, 1205, 1204, 716, 717, 2776, 2775, 103, 1213, 1214, 1210, 721, 2784, 2785, 
2781, 2765, 2766, 5013, 5012
2801, 1204, 1205, 111, 110, 2775, 2776, 731, 730, 1214, 1215, 115, 1212, 2785, 2786, 735, 
2783, 5012, 5013, 2771, 2770
2802, 99, 100, 1206, 1205, 717, 718, 2777, 2776, 104, 1216, 1217, 1213, 722, 2787, 2788, 
2784, 2766, 2767, 5014, 5013
2803, 1205, 1206, 112, 111, 2776, 2777, 732, 731, 1217, 1218, 116, 1215, 2788, 2789, 736, 
2786, 5013, 5014, 2772, 2771
2804, 100, 1, 106, 1206, 718, 53, 725, 2777, 105, 107, 1219, 1216, 723, 726, 2790, 
2787, 2767, 713, 2768, 5014
2805, 1206, 106, 3, 112, 2777, 725, 55, 732, 1219, 108, 117, 1218, 2790, 727, 737, 
2789, 5014, 2768, 724, 2772
*ELEMENT, type=C3D20, ELSET=Volume14
2806, 10, 230, 1455, 183, 67, 834, 2951, 843, 234, 1471, 1472, 187, 838, 2967, 2968, 
847, 832, 2939, 5015, 2943
2807, 230, 231, 1456, 1455, 834, 835, 2952, 2951, 235, 1473, 1474, 1471, 839, 2969, 2970, 
2967, 2939, 2940, 5016, 5015
2808, 231, 232, 1457, 1456, 835, 836, 2953, 2952, 236, 1475, 1476, 1473, 840, 2971, 2972, 
2969, 2940, 2941, 5017, 5016
2809, 232, 233, 1458, 1457, 836, 837, 2954, 2953, 237, 1477, 1478, 1475, 841, 2973, 2974, 
2971, 2941, 2942, 5018, 5017
2810, 233, 14, 239, 1458, 837, 68, 852, 2954, 238, 243, 1479, 1477, 842, 856, 2975, 
2973, 2942, 833, 2947, 5018
2811, 183, 1455, 1459, 184, 843, 2951, 2955, 844, 1472, 1480, 1481, 188, 2968, 2976, 2977, 
848, 2943, 5015, 5019, 2944
2812, 1455, 1456, 1460, 1459, 2951, 2952, 2956, 2955, 1474, 1482, 1483, 1480, 2970, 2978, 2979, 
2976, 5015, 5016, 5020, 5019
2813, 1456, 1457, 1461, 1460, 2952, 2953, 2957, 2956, 1476, 1484, 1485, 1482, 2972, 2980, 2981, 
2978, 5016, 5017, 5021, 5020
2814, 1457, 1458, 1462, 1461, 2953, 2954, 2958, 2957, 1478, 1486, 1487, 1484, 2974, 2982, 2983, 
2980, 5017, 5018, 5022, 5021
2815, 1458, 239, 240, 1462, 2954, 852, 853, 2958, 1479, 244, 1488, 1486, 2975, 857, 2984, 
2982, 5018, 2947, 2948, 5022
2816, 184, 1459, 1463, 185, 844, 2955, 2959, 845, 1481, 1489, 1490, 189, 2977, 2985, 2986, 
849, 2944, 5019, 5023, 2945
2817, 1459, 1460, 1464, 1463, 2955, 2956, 2960, 2959, 1483, 1491, 1492, 1489, 2979, 2987, 2988, 
2985, 5019, 5020, 5024, 5023
2818, 1460, 1461, 1465, 1464, 2956, 2957, 2961, 2960, 1485, 1493, 1494, 1491, 2981, 2989, 2990, 
2987, 5020, 5021, 5025, 5024
2819, 1461, 1462, 1466, 1465, 2957, 2958, 2962, 2961, 1487, 1495, 1496, 1493, 2983, 2991, 2992, 
2989, 5021, 5022, 5026, 5025
2820, 1462, 240, 241, 1466, 2958, 853, 854, 2962, 1488, 245, 1497, 1495, 2984, 858, 2993, 
2991, 5022, 2948, 2949, 5026
2821, 185, 1463, 1467, 186, 845, 2959, 2963, 846, 1490, 1498, 1499, 190, 2986, 2994, 2995, 
850, 2945, 5023, 5027, 2946
2822, 1463, 1464, 1468, 1467, 2959, 2960, 2964, 2963, 1492, 1500, 1501, 1498, 2988, 2996, 2997, 
2994, 5023, 5024, 5028, 5027
2823, 1464, 1465, 1469, 1468, 2960, 2961, 2965, 2964, 1494, 1502, 1503, 1500, 2990, 2998, 2999, 
2996, 5024, 5025, 5029, 5028
2824, 1465, 1466, 1470, 1469, 2961, 2962, 2966, 2965, 1496, 1504, 1505, 1502, 2992, 3000, 3001, 
2998, 5025, 5026, 5030, 5029
2825, 1466, 241, 242, 1470, 2962, 854, 855, 2966, 1497, 246, 1506, 1504, 2993, 859, 3002, 
3000, 5026, 2949, 2950, 5030
2826, 186, 1467, 221, 9, 846, 2963, 823, 65, 1499, 1507, 225, 191, 2995, 3003, 827, 
851, 2946, 5027, 2935, 821
2827, 1467, 1468, 222, 221, 2963, 2964, 824, 823, 1501, 1508, 226, 1507, 2997, 3004, 828, 
3003, 5027, 5028, 2936, 2935
2828, 1468, 1469, 223, 222, 2964, 2965, 825, 824, 1503, 1509, 227, 1508, 2999, 3005, 829, 
3004, 5028, 5029, 2937, 2936
2829, 1469, 1470, 224, 223, 2965, 2966, 826, 825, 1505, 1510, 228, 1509, 3001, 3006, 830, 
3005, 5029, 5030, 2938, 2937
2830, 1470, 242, 13, 224, 2966, 855, 66, 826, 1506, 247, 229, 1510, 3002, 860, 831, 
3006, 5030, 2950, 822, 2938
*ELEMENT, type=C3D20, ELSET=Volume15
2831, 35, 498, 2317, 552, 69, 883, 3023, 863, 502, 2333, 2334, 556, 887, 3039, 3040, 
867, 861, 3015, 5031, 3007
2832, 552, 2317, 2318, 553, 863, 3023, 3024, 864, 2334, 2335, 2336, 557, 3040, 3041, 3042, 
868, 3007, 5031, 5032, 3008
2833, 553, 2318, 2319, 554, 864, 3024, 3025, 865, 2336, 2337, 2338, 558, 3042, 3043, 3044, 
869, 3008, 5032, 5033, 3009
2834, 554, 2319, 2320, 555, 865, 3025, 3026, 866, 2338, 2339, 2340, 559, 3044, 3045, 3046, 
870, 3009, 5033, 5034, 3010
2835, 555, 2320, 570, 39, 866, 3026, 892, 70, 2340, 2341, 574, 560, 3046, 3047, 896, 
871, 3010, 5034, 3019, 862
2836, 498, 499, 2321, 2317, 883, 884, 3027, 3023, 503, 2342, 2343, 2333, 888, 3048, 3049, 
3039, 3015, 3016, 5035, 5031
2837, 2317, 2321, 2322, 2318, 3023, 3027, 3028, 3024, 2343, 2344, 2345, 2335, 3049, 3050, 3051, 
3041, 5031, 5035, 5036, 5032
2838, 2318, 2322, 2323, 2319, 3024, 3028, 3029, 3025, 2345, 2346, 2347, 2337, 3051, 3052, 3053, 
3043, 5032, 5036, 5037, 5033
2839, 2319, 2323, 2324, 2320, 3025, 3029, 3030, 3026, 2347, 2348, 2349, 2339, 3053, 3054, 3055, 
3045, 5033, 5037, 5038, 5034
2840, 2320, 2324, 571, 570, 3026, 3030, 893, 892, 2349, 2350, 575, 2341, 3055, 3056, 897, 
3047, 5034, 5038, 3020, 3019
2841, 499, 500, 2325, 2321, 884, 885, 3031, 3027, 504, 2351, 2352, 2342, 889, 3057, 3058, 
3048, 3016, 3017, 5039, 5035
2842, 2321, 2325, 2326, 2322, 3027, 3031, 3032, 3028, 2352, 2353, 2354, 2344, 3058, 3059, 3060, 
3050, 5035, 5039, 5040, 5036
2843, 2322, 2326, 2327, 2323, 3028, 3032, 3033, 3029, 2354, 2355, 2356, 2346, 3060, 3061, 3062, 
3052, 5036, 5040, 5041, 5037
2844, 2323, 2327, 2328, 2324, 3029, 3033, 3034, 3030, 2356, 2357, 2358, 2348, 3062, 3063, 3064, 
3054, 5037, 5041, 5042, 5038
2845, 2324, 2328, 572, 571, 3030, 3034, 894, 893, 2358, 2359, 576, 2350, 3064, 3065, 898, 
3056, 5038, 5042, 3021, 3020
2846, 500, 501, 2329, 2325, 885, 886, 3035, 3031, 505, 2360, 2361, 2351, 890, 3066, 3067, 
3057, 3017, 3018, 5043, 5039
2847, 2325, 2329, 2330, 2326, 3031, 3035, 3036, 3032, 2361, 2362, 2363, 2353, 3067, 3068, 3069, 
3059, 5039, 5043, 5044, 5040
2848, 2326, 2330, 2331, 2327, 3032, 3036, 3037, 3033, 2363, 2364, 2365, 2355, 3069, 3070, 3071, 
3061, 5040, 5044, 5045, 5041
2849, 2327, 2331, 2332, 2328, 3033, 3037, 3038, 3034, 2365, 2366, 2367, 2357, 3071, 3072, 3073, 
3063, 5041, 5045, 5046, 5042
2850, 2328, 2332, 573, 572, 3034, 3038, 895, 894, 2367, 2368, 577, 2359, 3073, 3074, 899, 
3065, 5042, 5046, 3022, 3021
2851, 501, 36, 561, 2329, 886, 71, 874, 3035, 506, 565, 2369, 2360, 891, 878, 3075, 
3066, 3018, 872, 3011, 5043
2852, 2329, 561, 562, 2330, 3035, 874, 875, 3036, 2369, 566, 2370, 2362, 3075, 879, 3076, 
3068, 5043, 3011, 3012, 5044
2853, 2330, 562, 563, 2331, 3036, 875, 876, 3037, 2370, 567, 2371, 2364, 3076, 880, 3077, 
3070, 5044, 3012, 3013, 5045
2854, 2331, 563, 564, 2332, 3037, 876, 877, 3038, 2371, 568, 2372, 2366, 3077, 881, 3078, 
3072, 5045, 3013, 3014, 5046
2855, 2332, 564, 40, 573, 3038, 877, 72, 895, 2372, 569, 578, 2368, 3078, 882, 900, 
3074, 5046, 3014, 873, 3022
*ELEMENT, type=C3D20, ELSET=Volume16
2856, 9, 221, 1511, 193, 59, 754, 2807, 763, 225, 1527, 1528, 197, 758, 2823, 2824, 
767, 752, 2795, 5047, 2799
2857, 221, 222, 1512, 1511, 754, 755, 2808, 2807, 226, 1529, 1530, 1527, 759, 2825, 2826, 
2823, 2795, 2796, 5048, 5047
2858, 222, 223, 1513, 1512, 755, 756, 2809, 2808, 227, 1531, 1532, 1529, 760, 2827, 2828, 
2825, 2796, 2797, 5049, 5048
2859, 223, 224, 1514, 1513, 756, 757, 2810, 2809, 228, 1533, 1534, 1531, 761, 2829, 2830, 
2827, 2797, 2798, 5050, 5049
2860, 224, 13, 257, 1514, 757, 60, 772, 2810, 229, 261, 1535, 1533, 762, 776, 2831, 
2829, 2798, 753, 2803, 5050
2861, 193, 1511, 1515, 194, 763, 2807, 2811, 764, 1528, 1536, 1537, 198, 2824, 2832, 2833, 
768, 2799, 5047, 5051, 2800
2862, 1511, 1512, 1516, 1515, 2807, 2808, 2812, 2811, 1530, 1538, 1539, 1536, 2826, 2834, 2835, 
2832, 5047, 5048, 5052, 5051
2863, 1512, 1513, 1517, 1516, 2808, 2809, 2813, 2812, 1532, 1540, 1541, 1538, 2828, 2836, 2837, 
2834, 5048, 5049, 5053, 5052
2864, 1513, 1514, 1518, 1517, 2809, 2810, 2814, 2813, 1534, 1542, 1543, 1540, 2830, 2838, 2839, 
2836, 5049, 5050, 5054, 5053
2865, 1514, 257, 258, 1518, 2810, 772, 773, 2814, 1535, 262, 1544, 1542, 2831, 777, 2840, 
2838, 5050, 2803, 2804, 5054
2866, 194, 1515, 1519, 195, 764, 2811, 2815, 765, 1537, 1545, 1546, 199, 2833, 2841, 2842, 
769, 2800, 5051, 5055, 2801
2867, 1515, 1516, 1520, 1519, 2811, 2812, 2816, 2815, 1539, 1547, 1548, 1545, 2835, 2843, 2844, 
2841, 5051, 5052, 5056, 5055
2868, 1516, 1517, 1521, 1520, 2812, 2813, 2817, 2816, 1541, 1549, 1550, 1547, 2837, 2845, 2846, 
2843, 5052, 5053, 5057, 5056
2869, 1517, 1518, 1522, 1521, 2813, 2814, 2818, 2817, 1543, 1551, 1552, 1549, 2839, 2847, 2848, 
2845, 5053, 5054, 5058, 5057
2870, 1518, 258, 259, 1522, 2814, 773, 774, 2818, 1544, 263, 1553, 1551, 2840, 778, 2849, 
2847, 5054, 2804, 2805, 5058
2871, 195, 1519, 1523, 196, 765, 2815, 2819, 766, 1546, 1554, 1555, 200, 2842, 2850, 2851, 
770, 2801, 5055, 5059, 2802
2872, 1519, 1520, 1524, 1523, 2815, 2816, 2820, 2819, 1548, 1556, 1557, 1554, 2844, 2852, 2853, 
2850, 5055, 5056, 5060, 5059
2873, 1520, 1521, 1525, 1524, 2816, 2817, 2821, 2820, 1550, 1558, 1559, 1556, 2846, 2854, 2855, 
2852, 5056, 5057, 5061, 5060
2874, 1521, 1522, 1526, 1525, 2817, 2818, 2822, 2821, 1552, 1560, 1561, 1558, 2848, 2856, 2857, 
2854, 5057, 5058, 5062, 5061
2875, 1522, 259, 260, 1526, 2818, 774, 775, 2822, 1553, 264, 1562, 1560, 2849, 779, 2858, 
2856, 5058, 2805, 2806, 5062
2876, 196, 1523, 248, 11, 766, 2819, 743, 57, 1555, 1563, 252, 201, 2851, 2859, 747, 
771, 2802, 5059, 2791, 741
2877, 1523, 1524, 249, 248, 2819, 2820, 744, 743, 1557, 1564, 253, 1563, 2853, 2860, 748, 
2859, 5059, 5060, 2792, 2791
2878, 1524, 1525, 250, 249, 2820, 2821, 745, 744, 1559, 1565, 254, 1564, 2855, 2861, 749, 
2860, 5060, 5061, 2793, 2792
2879, 1525, 1526, 251, 250, 2821, 2822, 746, 745, 1561, 1566, 255, 1565, 2857, 2862, 750, 
2861, 5061, 5062, 2794, 2793
2880, 1526, 260, 15, 251, 2822, 775, 58, 746, 1562, 265, 256, 1566, 2858, 780, 751, 
2862, 5062, 2806, 742, 2794
*ELEMENT, type=C3D20, ELSET=Volume17
2881, 35, 552, 2373, 507, 63, 794, 2879, 803, 556, 2389, 2390, 511, 798, 2895, 2896, 
807, 792, 2867, 5063, 2871
2882, 552, 553, 2374, 2373, 794, 795, 2880, 2879, 557, 2391, 2392, 2389, 799, 2897, 2898, 
2895, 2867, 2868, 5064, 5063
2883, 553, 554, 2375, 2374, 795, 796, 2881, 2880, 558, 2393, 2394, 2391, 800, 2899, 2900, 
2897, 2868, 2869, 5065, 5064
2884, 554, 555, 2376, 2375, 796, 797, 2882, 2881, 559, 2395, 2396, 2393, 801, 2901, 2902, 
2899, 2869, 2870, 5066, 5065
2885, 555, 39, 579, 2376, 797, 64, 812, 2882, 560, 583, 2397, 2395, 802, 816, 2903, 
2901, 2870, 793, 2875, 5066
2886, 507, 2373, 2377, 508, 803, 2879, 2883, 804, 2390, 2398, 2399, 512, 2896, 2904, 2905, 
808, 2871, 5063, 5067, 2872
2887, 2373, 2374, 2378, 2377, 2879, 2880, 2884, 2883, 2392, 2400, 2401, 2398, 2898, 2906, 2907, 
2904, 5063, 5064, 5068, 5067
2888, 2374, 2375, 2379, 2378, 2880, 2881, 2885, 2884, 2394, 2402, 2403, 2400, 2900, 2908, 2909, 
2906, 5064, 5065, 5069, 5068
2889, 2375, 2376, 2380, 2379, 2881, 2882, 2886, 2885, 2396, 2404, 2405, 2402, 2902, 2910, 2911, 
2908, 5065, 5066, 5070, 5069
2890, 2376, 579, 580, 2380, 2882, 812, 813, 2886, 2397, 584, 2406, 2404, 2903, 817, 2912, 
2910, 5066, 2875, 2876, 5070
2891, 508, 2377, 2381, 509, 804, 2883, 2887, 805, 2399, 2407, 2408, 513, 2905, 2913, 2914, 
809, 2872, 5067, 5071, 2873
2892, 2377, 2378, 2382, 2381, 2883, 2884, 2888, 2887, 2401, 2409, 2410, 2407, 2907, 2915, 2916, 
2913, 5067, 5068, 5072, 5071
2893, 2378, 2379, 2383, 2382, 2884, 2885, 2889, 2888, 2403, 2411, 2412, 2409, 2909, 2917, 2918, 
2915, 5068, 5069, 5073, 5072
2894, 2379, 2380, 2384, 2383, 2885, 2886, 2890, 2889, 2405, 2413, 2414, 2411, 2911, 2919, 2920, 
2917, 5069, 5070, 5074, 5073
2895, 2380, 580, 581, 2384, 2886, 813, 814, 2890, 2406, 585, 2415, 2413, 2912, 818, 2921, 
2919, 5070, 2876, 2877, 5074
2896, 509, 2381, 2385, 510, 805, 2887, 2891, 806, 2408, 2416, 2417, 514, 2914, 2922, 2923, 
810, 2873, 5071, 5075, 2874
2897, 2381, 2382, 2386, 2385, 2887, 2888, 2892, 2891, 2410, 2418, 2419, 2416, 2916, 2924, 2925, 
2922, 5071, 5072, 5076, 5075
2898, 2382, 2383, 2387, 2386, 2888, 2889, 2893, 2892, 2412, 2420, 2421, 2418, 2918, 2926, 2927, 
2924, 5072, 5073, 5077, 5076
2899, 2383, 2384, 2388, 2387, 2889, 2890, 2894, 2893, 2414, 2422, 2423, 2420, 2920, 2928, 2929, 
2926, 5073, 5074, 5078, 5077
2900, 2384, 581, 582, 2388, 2890, 814, 815, 2894, 2415, 586, 2424, 2422, 2921, 819, 2930, 
2928, 5074, 2877, 2878, 5078
2901, 510, 2385, 525, 33, 806, 2891, 783, 61, 2417, 2425, 529, 515, 2923, 2931, 787, 
811, 2874, 5075, 2863, 781
2902, 2385, 2386, 526, 525, 2891, 2892, 784, 783, 2419, 2426, 530, 2425, 2925, 2932, 788, 
2931, 5075, 5076, 2864, 2863
2903, 2386, 2387, 527, 526, 2892, 2893, 785, 784, 2421, 2427, 531, 2426, 2927, 2933, 789, 
2932, 5076, 5077, 2865, 2864
2904, 2387, 2388, 528, 527, 2893, 2894, 786, 785, 2423, 2428, 532, 2427, 2929, 2934, 790, 
2933, 5077, 5078, 2866, 2865
2905, 2388, 582, 37, 528, 2894, 815, 62, 786, 2424, 587, 533, 2428, 2930, 820, 791, 
2934, 5078, 2878, 782, 2866
*ELEMENT, type=C3D20, ELSET=Volume18
2906, 35, 552, 794, 63, 69, 863, 905, 73, 556, 2867, 798, 792, 867, 3083, 909, 
902, 861, 3007, 3079, 901
2907, 552, 553, 795, 794, 863, 864, 906, 905, 557, 2868, 799, 2867, 868, 3084, 910, 
3083, 3007, 3008, 3080, 3079
2908, 553, 554, 796, 795, 864, 865, 907, 906, 558, 2869, 800, 2868, 869, 3085, 911, 
3084, 3008, 3009, 3081, 3080
2909, 554, 555, 797, 796, 865, 866, 908, 907, 559, 2870, 801, 2869, 870, 3086, 912, 
3085, 3009, 3010, 3082, 3081
2910, 555, 39, 64, 797, 866, 70, 74, 908, 560, 793, 802, 2870, 871, 904, 913, 
3086, 3010, 862, 903, 3082
*ELEMENT, type=C3D20, ELSET=Volume19
2911, 9, 221, 754, 59, 65, 823, 918, 75, 225, 2795, 758, 752, 827, 3091, 922, 
915, 821, 2935, 3087, 914
2912, 221, 222, 755, 754, 823, 824, 919, 918, 226, 2796, 759, 2795, 828, 3092, 923, 
3091, 2935, 2936, 3088, 3087
2913, 222, 223, 756, 755, 824, 825, 920, 919, 227, 2797, 760, 2796, 829, 3093, 924, 
3092, 2936, 2937, 3089, 3088
2914, 223, 224, 757, 756, 825, 826, 921, 920, 228, 2798, 761, 2797, 830, 3094, 925, 
3093, 2937, 2938, 3090, 3089
2915, 224, 13, 60, 757, 826, 66, 76, 921, 229, 753, 762, 2798, 831, 917, 926, 
3094, 2938, 822, 916, 3090
*ELEMENT, type=C3D20, ELSET=Volume20
2916, 22, 372, 1875, 339, 932, 3185, 5079, 3095, 376, 1891, 1892, 343, 3194, 5112, 5113, 
3103, 934, 3193, 5111, 3104
2917, 932, 3185, 5079, 3095, 933, 3186, 5080, 3096, 3194, 5112, 5113, 3103, 3196, 5115, 5116, 
3105, 935, 3195, 5114, 3106
2918, 933, 3186, 5080, 3096, 78, 974, 3215, 937, 3196, 5115, 5116, 3105, 978, 3231, 3232, 
941, 936, 3197, 5117, 3107
2919, 372, 373, 1876, 1875, 3185, 3187, 5081, 5079, 377, 1893, 1894, 1891, 3199, 5119, 5120, 
5112, 3193, 3198, 5118, 5111
2920, 3185, 3187, 5081, 5079, 3186, 3188, 5082, 5080, 3199, 5119, 5120, 5112, 3201, 5122, 5123, 
5115, 3195, 3200, 5121, 5114
2921, 3186, 3188, 5082, 5080, 974, 975, 3216, 3215, 3201, 5122, 5123, 5115, 979, 3233, 3234, 
3231, 3197, 3202, 5124, 5117
2922, 373, 374, 1877, 1876, 3187, 3189, 5083, 5081, 378, 1895, 1896, 1893, 3204, 5126, 5127, 
5119, 3198, 3203, 5125, 5118
2923, 3187, 3189, 5083, 5081, 3188, 3190, 5084, 5082, 3204, 5126, 5127, 5119, 3206, 5129, 5130, 
5122, 3200, 3205, 5128, 5121
2924, 3188, 3190, 5084, 5082, 975, 976, 3217, 3216, 3206, 5129, 5130, 5122, 980, 3235, 3236, 
3233, 3202, 3207, 5131, 5124
2925, 374, 375, 1878, 1877, 3189, 3191, 5085, 5083, 379, 1897, 1898, 1895, 3209, 5133, 5134, 
5126, 3203, 3208, 5132, 5125
2926, 3189, 3191, 5085, 5083, 3190, 3192, 5086, 5084, 3209, 5133, 5134, 5126, 3211, 5136, 5137, 
5129, 3205, 3210, 5135, 5128
2927, 3190, 3192, 5086, 5084, 976, 977, 3218, 3217, 3211, 5136, 5137, 5129, 981, 3237, 3238, 
3235, 3207, 3212, 5138, 5131
2928, 375, 24, 363, 1878, 3191, 960, 3155, 5085, 380, 367, 1899, 1897, 3213, 3164, 5139, 
5133, 3208, 962, 3163, 5132
2929, 3191, 960, 3155, 5085, 3192, 961, 3156, 5086, 3213, 3164, 5139, 5133, 3214, 3166, 5140, 
5136, 3210, 963, 3165, 5135
2930, 3192, 961, 3156, 5086, 977, 80, 965, 3218, 3214, 3166, 5140, 5136, 982, 969, 3239, 
3237, 3212, 964, 3167, 5138
2931, 339, 1875, 1879, 340, 3095, 5079, 5087, 3097, 1892, 1900, 1901, 344, 5113, 5142, 5143, 
3108, 3104, 5111, 5141, 3109
2932, 3095, 5079, 5087, 3097, 3096, 5080, 5088, 3098, 5113, 5142, 5143, 3108, 5116, 5145, 5146, 
3110, 3106, 5114, 5144, 3111
2933, 3096, 5080, 5088, 3098, 937, 3215, 3219, 938, 5116, 5145, 5146, 3110, 3232, 3240, 3241, 
942, 3107, 5117, 5147, 3112
2934, 1875, 1876, 1880, 1879, 5079, 5081, 5089, 5087, 1894, 1902, 1903, 1900, 5120, 5149, 5150, 
5142, 5111, 5118, 5148, 5141
2935, 5079, 5081, 5089, 5087, 5080, 5082, 5090, 5088, 5120, 5149, 5150, 5142, 5123, 5152, 5153, 
5145, 5114, 5121, 5151, 5144
2936, 5080, 5082, 5090, 5088, 3215, 3216, 3220, 3219, 5123, 5152, 5153, 5145, 3234, 3242, 3243, 
3240, 5117, 5124, 5154, 5147
2937, 1876, 1877, 1881, 1880, 5081, 5083, 5091, 5089, 1896, 1904, 1905, 1902, 5127, 5156, 5157, 
5149, 5118, 5125, 5155, 5148
2938, 5081, 5083, 5091, 5089, 5082, 5084, 5092, 5090, 5127, 5156, 5157, 5149, 5130, 5159, 5160, 
5152, 5121, 5128, 5158, 5151
2939, 5082, 5084, 5092, 5090, 3216, 3217, 3221, 3220, 5130, 5159, 5160, 5152, 3236, 3244, 3245, 
3242, 5124, 5131, 5161, 5154
2940, 1877, 1878, 1882, 1881, 5083, 5085, 5093, 5091, 1898, 1906, 1907, 1904, 5134, 5163, 5164, 
5156, 5125, 5132, 5162, 5155
2941, 5083, 5085, 5093, 5091, 5084, 5086, 5094, 5092, 5134, 5163, 5164, 5156, 5137, 5166, 5167, 
5159, 5128, 5135, 5165, 5158
2942, 5084, 5086, 5094, 5092, 3217, 3218, 3222, 3221, 5137, 5166, 5167, 5159, 3238, 3246, 3247, 
3244, 5131, 5138, 5168, 5161
2943, 1878, 363, 364, 1882, 5085, 3155, 3157, 5093, 1899, 368, 1908, 1906, 5139, 3169, 5169, 
5163, 5132, 3163, 3168, 5162
2944, 5085, 3155, 3157, 5093, 5086, 3156, 3158, 5094, 5139, 3169, 5169, 5163, 5140, 3171, 5170, 
5166, 5135, 3165, 3170, 5165
2945, 5086, 3156, 3158, 5094, 3218, 965, 966, 3222, 5140, 3171, 5170, 5166, 3239, 970, 3248, 
3246, 5138, 3167, 3172, 5168
2946, 340, 1879, 1883, 341, 3097, 5087, 5095, 3099, 1901, 1909, 1910, 345, 5143, 5172, 5173, 
3113, 3109, 5141, 5171, 3114
2947, 3097, 5087, 5095, 3099, 3098, 5088, 5096, 3100, 5143, 5172, 5173, 3113, 5146, 5175, 5176, 
3115, 3111, 5144, 5174, 3116
2948, 3098, 5088, 5096, 3100, 938, 3219, 3223, 939, 5146, 5175, 5176, 3115, 3241, 3249, 3250, 
943, 3112, 5147, 5177, 3117
2949, 1879, 1880, 1884, 1883, 5087, 5089, 5097, 5095, 1903, 1911, 1912, 1909, 5150, 5179, 5180, 
5172, 5141, 5148, 5178, 5171
2950, 5087, 5089, 5097, 5095, 5088, 5090, 5098, 5096, 5150, 5179, 5180, 5172, 5153, 5182, 5183, 
5175, 5144, 5151, 5181, 5174
2951, 5088, 5090, 5098, 5096, 3219, 3220, 3224, 3223, 5153, 5182, 5183, 5175, 3243, 3251, 3252, 
3249, 5147, 5154, 5184, 5177
2952, 1880, 1881, 1885, 1884, 5089, 5091, 5099, 5097, 1905, 1913, 1914, 1911, 5157, 5186, 5187, 
5179, 5148, 5155, 5185, 5178
2953, 5089, 5091, 5099, 5097, 5090, 5092, 5100, 5098, 5157, 5186, 5187, 5179, 5160, 5189, 5190, 
5182, 5151, 5158, 5188, 5181
2954, 5090, 5092, 5100, 5098, 3220, 3221, 3225, 3224, 5160, 5189, 5190, 5182, 3245, 3253, 3254, 
3251, 5154, 5161, 5191, 5184
2955, 1881, 1882, 1886, 1885, 5091, 5093, 5101, 5099, 1907, 1915, 1916, 1913, 5164, 5193, 5194, 
5186, 5155, 5162, 5192, 5185
2956, 5091, 5093, 5101, 5099, 5092, 5094, 5102, 5100, 5164, 5193, 5194, 5186, 5167, 5196, 5197, 
5189, 5158, 5165, 5195, 5188
2957, 5092, 5094, 5102, 5100, 3221, 3222, 3226, 3225, 5167, 5196, 5197, 5189, 3247, 3255, 3256, 
3253, 5161, 5168, 5198, 5191
2958, 1882, 364, 365, 1886, 5093, 3157, 3159, 5101, 1908, 369, 1917, 1915, 5169, 3174, 5199, 
5193, 5162, 3168, 3173, 5192
2959, 5093, 3157, 3159, 5101, 5094, 3158, 3160, 5102, 5169, 3174, 5199, 5193, 5170, 3176, 5200, 
5196, 5165, 3170, 3175, 5195
2960, 5094, 3158, 3160, 5102, 3222, 966, 967, 3226, 5170, 3176, 5200, 5196, 3248, 971, 3257, 
3255, 5168, 3172, 3177, 5198
2961, 341, 1883, 1887, 342, 3099, 5095, 5103, 3101, 1910, 1918, 1919, 346, 5173, 5202, 5203, 
3118, 3114, 5171, 5201, 3119
2962, 3099, 5095, 5103, 3101, 3100, 5096, 5104, 3102, 5173, 5202, 5203, 3118, 5176, 5205, 5206, 
3120, 3116, 5174, 5204, 3121
2963, 3100, 5096, 5104, 3102, 939, 3223, 3227, 940, 5176, 5205, 5206, 3120, 3250, 3258, 3259, 
944, 3117, 5177, 5207, 3122
2964, 1883, 1884, 1888, 1887, 5095, 5097, 5105, 5103, 1912, 1920, 1921, 1918, 5180, 5209, 5210, 
5202, 5171, 5178, 5208, 5201
2965, 5095, 5097, 5105, 5103, 5096, 5098, 5106, 5104, 5180, 5209, 5210, 5202, 5183, 5212, 5213, 
5205, 5174, 5181, 5211, 5204
2966, 5096, 5098, 5106, 5104, 3223, 3224, 3228, 3227, 5183, 5212, 5213, 5205, 3252, 3260, 3261, 
3258, 5177, 5184, 5214, 5207
2967, 1884, 1885, 1889, 1888, 5097, 5099, 5107, 5105, 1914, 1922, 1923, 1920, 5187, 5216, 5217, 
5209, 5178, 5185, 5215, 5208
2968, 5097, 5099, 5107, 5105, 5098, 5100, 5108, 5106, 5187, 5216, 5217, 5209, 5190, 5219, 5220, 
5212, 5181, 5188, 5218, 5211
2969, 5098, 5100, 5108, 5106, 3224, 3225, 3229, 3228, 5190, 5219, 5220, 5212, 3254, 3262, 3263, 
3260, 5184, 5191, 5221, 5214
2970, 1885, 1886, 1890, 1889, 5099, 5101, 5109, 5107, 1916, 1924, 1925, 1922, 5194, 5223, 5224, 
5216, 5185, 5192, 5222, 5215
2971, 5099, 5101, 5109, 5107, 5100, 5102, 5110, 5108, 5194, 5223, 5224, 5216, 5197, 5226, 5227, 
5219, 5188, 5195, 5225, 5218
2972, 5100, 5102, 5110, 5108, 3225, 3226, 3230, 3229, 5197, 5226, 5227, 5219, 3256, 3264, 3265, 
3262, 5191, 5198, 5228, 5221
2973, 1886, 365, 366, 1890, 5101, 3159, 3161, 5109, 1917, 370, 1926, 1924, 5199, 3179, 5229, 
5223, 5192, 3173, 3178, 5222
2974, 5101, 3159, 3161, 5109, 5102, 3160, 3162, 5110, 5199, 3179, 5229, 5223, 5200, 3181, 5230, 
5226, 5195, 3175, 3180, 5225
2975, 5102, 3160, 3162, 5110, 3226, 967, 968, 3230, 5200, 3181, 5230, 5226, 3257, 972, 3266, 
3264, 5198, 3177, 3182, 5228
2976, 342, 1887, 351, 21, 3101, 5103, 3125, 927, 1919, 1927, 355, 347, 5203, 5231, 3133, 
3123, 3119, 5201, 3134, 929
2977, 3101, 5103, 3125, 927, 3102, 5104, 3126, 928, 5203, 5231, 3133, 3123, 5206, 5232, 3135, 
3124, 3121, 5204, 3136, 930
2978, 3102, 5104, 3126, 928, 940, 3227, 951, 77, 5206, 5232, 3135, 3124, 3259, 3267, 955, 
945, 3122, 5207, 3137, 931
2979, 1887, 1888, 352, 351, 5103, 5105, 3127, 3125, 1921, 1928, 356, 1927, 5210, 5233, 3138, 
5231, 5201, 5208, 3139, 3134
2980, 5103, 5105, 3127, 3125, 5104, 5106, 3128, 3126, 5210, 5233, 3138, 5231, 5213, 5234, 3140, 
5232, 5204, 5211, 3141, 3136
2981, 5104, 5106, 3128, 3126, 3227, 3228, 952, 951, 5213, 5234, 3140, 5232, 3261, 3268, 956, 
3267, 5207, 5214, 3142, 3137
2982, 1888, 1889, 353, 352, 5105, 5107, 3129, 3127, 1923, 1929, 357, 1928, 5217, 5235, 3143, 
5233, 5208, 5215, 3144, 3139
2983, 5105, 5107, 3129, 3127, 5106, 5108, 3130, 3128, 5217, 5235, 3143, 5233, 5220, 5236, 3145, 
5234, 5211, 5218, 3146, 3141
2984, 5106, 5108, 3130, 3128, 3228, 3229, 953, 952, 5220, 5236, 3145, 5234, 3263, 3269, 957, 
3268, 5214, 5221, 3147, 3142
2985, 1889, 1890, 354, 353, 5107, 5109, 3131, 3129, 1925, 1930, 358, 1929, 5224, 5237, 3148, 
5235, 5215, 5222, 3149, 3144
2986, 5107, 5109, 3131, 3129, 5108, 5110, 3132, 3130, 5224, 5237, 3148, 5235, 5227, 5238, 3150, 
5236, 5218, 5225, 3151, 3146
2987, 5108, 5110, 3132, 3130, 3229, 3230, 954, 953, 5227, 5238, 3150, 5236, 3265, 3270, 958, 
3269, 5221, 5228, 3152, 3147
2988, 1890, 366, 23, 354, 5109, 3161, 946, 3131, 1926, 371, 359, 1930, 5229, 3183, 3153, 
5237, 5222, 3178, 948, 3149
2989, 5109, 3161, 946, 3131, 5110, 3162, 947, 3132, 5229, 3183, 3153, 5237, 5230, 3184, 3154, 
5238, 5225, 3180, 949, 3151
2990, 5110, 3162, 947, 3132, 3230, 968, 79, 954, 5230, 3184, 3154, 5238, 3266, 973, 959, 
3270, 5228, 3182, 950, 3152
*ELEMENT, type=C3D20, ELSET=Volume21
2991, 21, 351, 1979, 399, 927, 3125, 5239, 3287, 355, 1987, 1988, 401, 3133, 5256, 5257, 
3291, 929, 3134, 5255, 3292
2992, 927, 3125, 5239, 3287, 928, 3126, 5240, 3288, 3133, 5256, 5257, 3291, 3135, 5259, 5260, 
3293, 930, 3136, 5258, 3294
2993, 928, 3126, 5240, 3288, 77, 951, 3333, 998, 3135, 5259, 5260, 3293, 955, 3341, 3342, 
1000, 931, 3137, 5261, 3295
2994, 399, 1979, 1980, 400, 3287, 5239, 5241, 3289, 1988, 1989, 1990, 402, 5257, 5263, 5264, 
3296, 3292, 5255, 5262, 3297
2995, 3287, 5239, 5241, 3289, 3288, 5240, 5242, 3290, 5257, 5263, 5264, 3296, 5260, 5266, 5267, 
3298, 3294, 5258, 5265, 3299
2996, 3288, 5240, 5242, 3290, 998, 3333, 3334, 999, 5260, 5266, 5267, 3298, 3342, 3343, 3344, 
1001, 3295, 5261, 5268, 3300
2997, 400, 1980, 416, 28, 3289, 5241, 3303, 993, 1990, 1991, 420, 403, 5264, 5269, 3311, 
3301, 3297, 5262, 3312, 995
2998, 3289, 5241, 3303, 993, 3290, 5242, 3304, 994, 5264, 5269, 3311, 3301, 5267, 5270, 3313, 
3302, 3299, 5265, 3314, 996
2999, 3290, 5242, 3304, 994, 999, 3334, 1003, 82, 5267, 5270, 3313, 3302, 3344, 3345, 1007, 
1002, 3300, 5268, 3315, 997
3000, 351, 352, 1981, 1979, 3125, 3127, 5243, 5239, 356, 1992, 1993, 1987, 3138, 5272, 5273, 
5256, 3134, 3139, 5271, 5255
3001, 3125, 3127, 5243, 5239, 3126, 3128, 5244, 5240, 3138, 5272, 5273, 5256, 3140, 5275, 5276, 
5259, 3136, 3141, 5274, 5258
3002, 3126, 3128, 5244, 5240, 951, 952, 3335, 3333, 3140, 5275, 5276, 5259, 956, 3346, 3347, 
3341, 3137, 3142, 5277, 5261
3003, 1979, 1981, 1982, 1980, 5239, 5243, 5245, 5241, 1993, 1994, 1995, 1989, 5273, 5279, 5280, 
5263, 5255, 5271, 5278, 5262
3004, 5239, 5243, 5245, 5241, 5240, 5244, 5246, 5242, 5273, 5279, 5280, 5263, 5276, 5282, 5283, 
5266, 5258, 5274, 5281, 5265
3005, 5240, 5244, 5246, 5242, 3333, 3335, 3336, 3334, 5276, 5282, 5283, 5266, 3347, 3348, 3349, 
3343, 5261, 5277, 5284, 5268
3006, 1980, 1982, 417, 416, 5241, 5245, 3305, 3303, 1995, 1996, 421, 1991, 5280, 5285, 3316, 
5269, 5262, 5278, 3317, 3312
3007, 5241, 5245, 3305, 3303, 5242, 5246, 3306, 3304, 5280, 5285, 3316, 5269, 5283, 5286, 3318, 
5270, 5265, 5281, 3319, 3314
3008, 5242, 5246, 3306, 3304, 3334, 3336, 1004, 1003, 5283, 5286, 3318, 5270, 3349, 3350, 1008, 
3345, 5268, 5284, 3320, 3315
3009, 352, 353, 1983, 1981, 3127, 3129, 5247, 5243, 357, 1997, 1998, 1992, 3143, 5288, 5289, 
5272, 3139, 3144, 5287, 5271
3010, 3127, 3129, 5247, 5243, 3128, 3130, 5248, 5244, 3143, 5288, 5289, 5272, 3145, 5291, 5292, 
5275, 3141, 3146, 5290, 5274
3011, 3128, 3130, 5248, 5244, 952, 953, 3337, 3335, 3145, 5291, 5292, 5275, 957, 3351, 3352, 
3346, 3142, 3147, 5293, 5277
3012, 1981, 1983, 1984, 1982, 5243, 5247, 5249, 5245, 1998, 1999, 2000, 1994, 5289, 5295, 5296, 
5279, 5271, 5287, 5294, 5278
3013, 5243, 5247, 5249, 5245, 5244, 5248, 5250, 5246, 5289, 5295, 5296, 5279, 5292, 5298, 5299, 
5282, 5274, 5290, 5297, 5281
3014, 5244, 5248, 5250, 5246, 3335, 3337, 3338, 3336, 5292, 5298, 5299, 5282, 3352, 3353, 3354, 
3348, 5277, 5293, 5300, 5284
3015, 1982, 1984, 418, 417, 5245, 5249, 3307, 3305, 2000, 2001, 422, 1996, 5296, 5301, 3321, 
5285, 5278, 5294, 3322, 3317
3016, 5245, 5249, 3307, 3305, 5246, 5250, 3308, 3306, 5296, 5301, 3321, 5285, 5299, 5302, 3323, 
5286, 5281, 5297, 3324, 3319
3017, 5246, 5250, 3308, 3306, 3336, 3338, 1005, 1004, 5299, 5302, 3323, 5286, 3354, 3355, 1009, 
3350, 5284, 5300, 3325, 3320
3018, 353, 354, 1985, 1983, 3129, 3131, 5251, 5247, 358, 2002, 2003, 1997, 3148, 5304, 5305, 
5288, 3144, 3149, 5303, 5287
3019, 3129, 3131, 5251, 5247, 3130, 3132, 5252, 5248, 3148, 5304, 5305, 5288, 3150, 5307, 5308, 
5291, 3146, 3151, 5306, 5290
3020, 3130, 3132, 5252, 5248, 953, 954, 3339, 3337, 3150, 5307, 5308, 5291, 958, 3356, 3357, 
3351, 3147, 3152, 5309, 5293
3021, 1983, 1985, 1986, 1984, 5247, 5251, 5253, 5249, 2003, 2004, 2005, 1999, 5305, 5311, 5312, 
5295, 5287, 5303, 5310, 5294
3022, 5247, 5251, 5253, 5249, 5248, 5252, 5254, 5250, 5305, 5311, 5312, 5295, 5308, 5314, 5315, 
5298, 5290, 5306, 5313, 5297
3023, 5248, 5252, 5254, 5250, 3337, 3339, 3340, 3338, 5308, 5314, 5315, 5298, 3357, 3358, 3359, 
3353, 5293, 5309, 5316, 5300
3024, 1984, 1986, 419, 418, 5249, 5253, 3309, 3307, 2005, 2006, 423, 2001, 5312, 5317, 3326, 
5301, 5294, 5310, 3327, 3322
3025, 5249, 5253, 3309, 3307, 5250, 5254, 3310, 3308, 5312, 5317, 3326, 5301, 5315, 5318, 3328, 
5302, 5297, 5313, 3329, 3324
3026, 5250, 5254, 3310, 3308, 3338, 3340, 1006, 1005, 5315, 5318, 3328, 5302, 3359, 3360, 1010, 
3355, 5300, 5316, 3330, 3325
3027, 354, 23, 386, 1985, 3131, 946, 3271, 5251, 359, 388, 2007, 2002, 3153, 3276, 5319, 
5304, 3149, 948, 3275, 5303
3028, 3131, 946, 3271, 5251, 3132, 947, 3272, 5252, 3153, 3276, 5319, 5304, 3154, 3278, 5320, 
5307, 3151, 949, 3277, 5306
3029, 3132, 947, 3272, 5252, 954, 79, 988, 3339, 3154, 3278, 5320, 5307, 959, 990, 3361, 
3356, 3152, 950, 3279, 5309
3030, 1985, 386, 387, 1986, 5251, 3271, 3273, 5253, 2007, 389, 2008, 2004, 5319, 3281, 5321, 
5311, 5303, 3275, 3280, 5310
3031, 5251, 3271, 3273, 5253, 5252, 3272, 3274, 5254, 5319, 3281, 5321, 5311, 5320, 3283, 5322, 
5314, 5306, 3277, 3282, 5313
3032, 5252, 3272, 3274, 5254, 3339, 988, 989, 3340, 5320, 3283, 5322, 5314, 3361, 991, 3362, 
3358, 5309, 3279, 3284, 5316
3033, 1986, 387, 26, 419, 5253, 3273, 983, 3309, 2008, 390, 424, 2006, 5321, 3285, 3331, 
5317, 5310, 3280, 985, 3327
3034, 5253, 3273, 983, 3309, 5254, 3274, 984, 3310, 5321, 3285, 3331, 5317, 5322, 3286, 3332, 
5318, 5313, 3282, 986, 3329
3035, 5254, 3274, 984, 3310, 3340, 989, 81, 1006, 5322, 3286, 3332, 5318, 3362, 992, 1011, 
3360, 5316, 3284, 987, 3330
*ELEMENT, type=C3D20, ELSET=Volume22
3036, 28, 416, 2116, 455, 993, 3303, 5323, 3393, 420, 2132, 2133, 459, 3311, 5356, 5357, 
3401, 995, 3312, 5355, 3402
3037, 993, 3303, 5323, 3393, 994, 3304, 5324, 3394, 3311, 5356, 5357, 3401, 3313, 5359, 5360, 
3403, 996, 3314, 5358, 3404
3038, 994, 3304, 5324, 3394, 82, 1003, 3453, 1031, 3313, 5359, 5360, 3403, 1007, 3469, 3470, 
1035, 997, 3315, 5361, 3405
3039, 455, 2116, 2117, 456, 3393, 5323, 5325, 3395, 2133, 2134, 2135, 460, 5357, 5363, 5364, 
3406, 3402, 5355, 5362, 3407
3040, 3393, 5323, 5325, 3395, 3394, 5324, 5326, 3396, 5357, 5363, 5364, 3406, 5360, 5366, 5367, 
3408, 3404, 5358, 5365, 3409
3041, 3394, 5324, 5326, 3396, 1031, 3453, 3454, 1032, 5360, 5366, 5367, 3408, 3470, 3471, 3472, 
1036, 3405, 5361, 5368, 3410
3042, 456, 2117, 2118, 457, 3395, 5325, 5327, 3397, 2135, 2136, 2137, 461, 5364, 5370, 5371, 
3411, 3407, 5362, 5369, 3412
3043, 3395, 5325, 5327, 3397, 3396, 5326, 5328, 3398, 5364, 5370, 5371, 3411, 5367, 5373, 5374, 
3413, 3409, 5365, 5372, 3414
3044, 3396, 5326, 5328, 3398, 1032, 3454, 3455, 1033, 5367, 5373, 5374, 3413, 3472, 3473, 3474, 
1037, 3410, 5368, 5375, 3415
3045, 457, 2118, 2119, 458, 3397, 5327, 5329, 3399, 2137, 2138, 2139, 462, 5371, 5377, 5378, 
3416, 3412, 5369, 5376, 3417
3046, 3397, 5327, 5329, 3399, 3398, 5328, 5330, 3400, 5371, 5377, 5378, 3416, 5374, 5380, 5381, 
3418, 3414, 5372, 5379, 3419
3047, 3398, 5328, 5330, 3400, 1033, 3455, 3456, 1034, 5374, 5380, 5381, 3418, 3474, 3475, 3476, 
1038, 3415, 5375, 5382, 3420
3048, 458, 2119, 476, 32, 3399, 5329, 3423, 1026, 2139, 2140, 480, 463, 5378, 5383, 3431, 
3421, 3417, 5376, 3432, 1028
3049, 3399, 5329, 3423, 1026, 3400, 5330, 3424, 1027, 5378, 5383, 3431, 3421, 5381, 5384, 3433, 
3422, 3419, 5379, 3434, 1029
3050, 3400, 5330, 3424, 1027, 1034, 3456, 1040, 84, 5381, 5384, 3433, 3422, 3476, 3477, 1044, 
1039, 3420, 5382, 3435, 1030
3051, 416, 417, 2120, 2116, 3303, 3305, 5331, 5323, 421, 2141, 2142, 2132, 3316, 5386, 5387, 
5356, 3312, 3317, 5385, 5355
3052, 3303, 3305, 5331, 5323, 3304, 3306, 5332, 5324, 3316, 5386, 5387, 5356, 3318, 5389, 5390, 
5359, 3314, 3319, 5388, 5358
3053, 3304, 3306, 5332, 5324, 1003, 1004, 3457, 3453, 3318, 5389, 5390, 5359, 1008, 3478, 3479, 
3469, 3315, 3320, 5391, 5361
3054, 2116, 2120, 2121, 2117, 5323, 5331, 5333, 5325, 2142, 2143, 2144, 2134, 5387, 5393, 5394, 
5363, 5355, 5385, 5392, 5362
3055, 5323, 5331, 5333, 5325, 5324, 5332, 5334, 5326, 5387, 5393, 5394, 5363, 5390, 5396, 5397, 
5366, 5358, 5388, 5395, 5365
3056, 5324, 5332, 5334, 5326, 3453, 3457, 3458, 3454, 5390, 5396, 5397, 5366, 3479, 3480, 3481, 
3471, 5361, 5391, 5398, 5368
3057, 2117, 2121, 2122, 2118, 5325, 5333, 5335, 5327, 2144, 2145, 2146, 2136, 5394, 5400, 5401, 
5370, 5362, 5392, 5399, 5369
3058, 5325, 5333, 5335, 5327, 5326, 5334, 5336, 5328, 5394, 5400, 5401, 5370, 5397, 5403, 5404, 
5373, 5365, 5395, 5402, 5372
3059, 5326, 5334, 5336, 5328, 3454, 3458, 3459, 3455, 5397, 5403, 5404, 5373, 3481, 3482, 3483, 
3473, 5368, 5398, 5405, 5375
3060, 2118, 2122, 2123, 2119, 5327, 5335, 5337, 5329, 2146, 2147, 2148, 2138, 5401, 5407, 5408, 
5377, 5369, 5399, 5406, 5376
3061, 5327, 5335, 5337, 5329, 5328, 5336, 5338, 5330, 5401, 5407, 5408, 5377, 5404, 5410, 5411, 
5380, 5372, 5402, 5409, 5379
3062, 5328, 5336, 5338, 5330, 3455, 3459, 3460, 3456, 5404, 5410, 5411, 5380, 3483, 3484, 3485, 
3475, 5375, 5405, 5412, 5382
3063, 2119, 2123, 477, 476, 5329, 5337, 3425, 3423, 2148, 2149, 481, 2140, 5408, 5413, 3436, 
5383, 5376, 5406, 3437, 3432
3064, 5329, 5337, 3425, 3423, 5330, 5338, 3426, 3424, 5408, 5413, 3436, 5383, 5411, 5414, 3438, 
5384, 5379, 5409, 3439, 3434
3065, 5330, 5338, 3426, 3424, 3456, 3460, 1041, 1040, 5411, 5414, 3438, 5384, 3485, 3486, 1045, 
3477, 5382, 5412, 3440, 3435
3066, 417, 418, 2124, 2120, 3305, 3307, 5339, 5331, 422, 2150, 2151, 2141, 3321, 5416, 5417, 
5386, 3317, 3322, 5415, 5385
3067, 3305, 3307, 5339, 5331, 3306, 3308, 5340, 5332, 3321, 5416, 5417, 5386, 3323, 5419, 5420, 
5389, 3319, 3324, 5418, 5388
3068, 3306, 3308, 5340, 5332, 1004, 1005, 3461, 3457, 3323, 5419, 5420, 5389, 1009, 3487, 3488, 
3478, 3320, 3325, 5421, 5391
3069, 2120, 2124, 2125, 2121, 5331, 5339, 5341, 5333, 2151, 2152, 2153, 2143, 5417, 5423, 5424, 
5393, 5385, 5415, 5422, 5392
3070, 5331, 5339, 5341, 5333, 5332, 5340, 5342, 5334, 5417, 5423, 5424, 5393, 5420, 5426, 5427, 
5396, 5388, 5418, 5425, 5395
3071, 5332, 5340, 5342, 5334, 3457, 3461, 3462, 3458, 5420, 5426, 5427, 5396, 3488, 3489, 3490, 
3480, 5391, 5421, 5428, 5398
3072, 2121, 2125, 2126, 2122, 5333, 5341, 5343, 5335, 2153, 2154, 2155, 2145, 5424, 5430, 5431, 
5400, 5392, 5422, 5429, 5399
3073, 5333, 5341, 5343, 5335, 5334, 5342, 5344, 5336, 5424, 5430, 5431, 5400, 5427, 5433, 5434, 
5403, 5395, 5425, 5432, 5402
3074, 5334, 5342, 5344, 5336, 3458, 3462, 3463, 3459, 5427, 5433, 5434, 5403, 3490, 3491, 3492, 
3482, 5398, 5428, 5435, 5405
3075, 2122, 2126, 2127, 2123, 5335, 5343, 5345, 5337, 2155, 2156, 2157, 2147, 5431, 5437, 5438, 
5407, 5399, 5429, 5436, 5406
3076, 5335, 5343, 5345, 5337, 5336, 5344, 5346, 5338, 5431, 5437, 5438, 5407, 5434, 5440, 5441, 
5410, 5402, 5432, 5439, 5409
3077, 5336, 5344, 5346, 5338, 3459, 3463, 3464, 3460, 5434, 5440, 5441, 5410, 3492, 3493, 3494, 
3484, 5405, 5435, 5442, 5412
3078, 2123, 2127, 478, 477, 5337, 5345, 3427, 3425, 2157, 2158, 482, 2149, 5438, 5443, 3441, 
5413, 5406, 5436, 3442, 3437
3079, 5337, 5345, 3427, 3425, 5338, 5346, 3428, 3426, 5438, 5443, 3441, 5413, 5441, 5444, 3443, 
5414, 5409, 5439, 3444, 3439
3080, 5338, 5346, 3428, 3426, 3460, 3464, 1042, 1041, 5441, 5444, 3443, 5414, 3494, 3495, 1046, 
3486, 5412, 5442, 3445, 3440
3081, 418, 419, 2128, 2124, 3307, 3309, 5347, 5339, 423, 2159, 2160, 2150, 3326, 5446, 5447, 
5416, 3322, 3327, 5445, 5415
3082, 3307, 3309, 5347, 5339, 3308, 3310, 5348, 5340, 3326, 5446, 5447, 5416, 3328, 5449, 5450, 
5419, 3324, 3329, 5448, 5418
3083, 3308, 3310, 5348, 5340, 1005, 1006, 3465, 3461, 3328, 5449, 5450, 5419, 1010, 3496, 3497, 
3487, 3325, 3330, 5451, 5421
3084, 2124, 2128, 2129, 2125, 5339, 5347, 5349, 5341, 2160, 2161, 2162, 2152, 5447, 5453, 5454, 
5423, 5415, 5445, 5452, 5422
3085, 5339, 5347, 5349, 5341, 5340, 5348, 5350, 5342, 5447, 5453, 5454, 5423, 5450, 5456, 5457, 
5426, 5418, 5448, 5455, 5425
3086, 5340, 5348, 5350, 5342, 3461, 3465, 3466, 3462, 5450, 5456, 5457, 5426, 3497, 3498, 3499, 
3489, 5421, 5451, 5458, 5428
3087, 2125, 2129, 2130, 2126, 5341, 5349, 5351, 5343, 2162, 2163, 2164, 2154, 5454, 5460, 5461, 
5430, 5422, 5452, 5459, 5429
3088, 5341, 5349, 5351, 5343, 5342, 5350, 5352, 5344, 5454, 5460, 5461, 5430, 5457, 5463, 5464, 
5433, 5425, 5455, 5462, 5432
3089, 5342, 5350, 5352, 5344, 3462, 3466, 3467, 3463, 5457, 5463, 5464, 5433, 3499, 3500, 3501, 
3491, 5428, 5458, 5465, 5435
3090, 2126, 2130, 2131, 2127, 5343, 5351, 5353, 5345, 2164, 2165, 2166, 2156, 5461, 5467, 5468, 
5437, 5429, 5459, 5466, 5436
3091, 5343, 5351, 5353, 5345, 5344, 5352, 5354, 5346, 5461, 5467, 5468, 5437, 5464, 5470, 5471, 
5440, 5432, 5462, 5469, 5439
3092, 5344, 5352, 5354, 5346, 3463, 3467, 3468, 3464, 5464, 5470, 5471, 5440, 3501, 3502, 3503, 
3493, 5435, 5465, 5472, 5442
3093, 2127, 2131, 479, 478, 5345, 5353, 3429, 3427, 2166, 2167, 483, 2158, 5468, 5473, 3446, 
5443, 5436, 5466, 3447, 3442
3094, 5345, 5353, 3429, 3427, 5346, 5354, 3430, 3428, 5468, 5473, 3446, 5443, 5471, 5474, 3448, 
5444, 5439, 5469, 3449, 3444
3095, 5346, 5354, 3430, 3428, 3464, 3468, 1043, 1042, 5471, 5474, 3448, 5444, 3503, 3504, 1047, 
3495, 5442, 5472, 3450, 3445
3096, 419, 26, 434, 2128, 3309, 983, 3363, 5347, 424, 438, 2168, 2159, 3331, 3372, 5475, 
5446, 3327, 985, 3371, 5445
3097, 3309, 983, 3363, 5347, 3310, 984, 3364, 5348, 3331, 3372, 5475, 5446, 3332, 3374, 5476, 
5449, 3329, 986, 3373, 5448
3098, 3310, 984, 3364, 5348, 1006, 81, 1017, 3465, 3332, 3374, 5476, 5449, 1011, 1021, 3505, 
3496, 3330, 987, 3375, 5451
3099, 2128, 434, 435, 2129, 5347, 3363, 3365, 5349, 2168, 439, 2169, 2161, 5475, 3377, 5477, 
5453, 5445, 3371, 3376, 5452
3100, 5347, 3363, 3365, 5349, 5348, 3364, 3366, 5350, 5475, 3377, 5477, 5453, 5476, 3379, 5478, 
5456, 5448, 3373, 3378, 5455
3101, 5348, 3364, 3366, 5350, 3465, 1017, 1018, 3466, 5476, 3379, 5478, 5456, 3505, 1022, 3506, 
3498, 5451, 3375, 3380, 5458
3102, 2129, 435, 436, 2130, 5349, 3365, 3367, 5351, 2169, 440, 2170, 2163, 5477, 3382, 5479, 
5460, 5452, 3376, 3381, 5459
3103, 5349, 3365, 3367, 5351, 5350, 3366, 3368, 5352, 5477, 3382, 5479, 5460, 5478, 3384, 5480, 
5463, 5455, 3378, 3383, 5462
3104, 5350, 3366, 3368, 5352, 3466, 1018, 1019, 3467, 5478, 3384, 5480, 5463, 3506, 1023, 3507, 
3500, 5458, 3380, 3385, 5465
3105, 2130, 436, 437, 2131, 5351, 3367, 3369, 5353, 2170, 441, 2171, 2165, 5479, 3387, 5481, 
5467, 5459, 3381, 3386, 5466
3106, 5351, 3367, 3369, 5353, 5352, 3368, 3370, 5354, 5479, 3387, 5481, 5467, 5480, 3389, 5482, 
5470, 5462, 3383, 3388, 5469
3107, 5352, 3368, 3370, 5354, 3467, 1019, 1020, 3468, 5480, 3389, 5482, 5470, 3507, 1024, 3508, 
3502, 5465, 3385, 3390, 5472
3108, 2131, 437, 30, 479, 5353, 3369, 1012, 3429, 2171, 442, 484, 2167, 5481, 3391, 3451, 
5473, 5466, 3386, 1014, 3447
3109, 5353, 3369, 1012, 3429, 5354, 3370, 1013, 3430, 5481, 3391, 3451, 5473, 5482, 3392, 3452, 
5474, 5469, 3388, 1015, 3449
3110, 5354, 3370, 1013, 3430, 3468, 1020, 83, 1043, 5482, 3392, 3452, 5474, 3508, 1025, 1048, 
3504, 5472, 3390, 1016, 3450
*ELEMENT, type=C3D20, ELSET=Volume23
3111, 2, 145, 1237, 97, 1054, 3509, 5483, 3599, 149, 1253, 1254, 101, 3518, 5516, 5517, 
3607, 1056, 3517, 5515, 3608
3112, 1054, 3509, 5483, 3599, 1055, 3510, 5484, 3600, 3518, 5516, 5517, 3607, 3520, 5519, 5520, 
3609, 1057, 3519, 5518, 3610
3113, 1055, 3510, 5484, 3600, 86, 1059, 3629, 1096, 3520, 5519, 5520, 3609, 1063, 3645, 3646, 
1100, 1058, 3521, 5521, 3611
3114, 97, 1237, 1238, 98, 3599, 5483, 5485, 3601, 1254, 1255, 1256, 102, 5517, 5523, 5524, 
3612, 3608, 5515, 5522, 3613
3115, 3599, 5483, 5485, 3601, 3600, 5484, 5486, 3602, 5517, 5523, 5524, 3612, 5520, 5526, 5527, 
3614, 3610, 5518, 5525, 3615
3116, 3600, 5484, 5486, 3602, 1096, 3629, 3630, 1097, 5520, 5526, 5527, 3614, 3646, 3647, 3648, 
1101, 3611, 5521, 5528, 3616
3117, 98, 1238, 1239, 99, 3601, 5485, 5487, 3603, 1256, 1257, 1258, 103, 5524, 5530, 5531, 
3617, 3613, 5522, 5529, 3618
3118, 3601, 5485, 5487, 3603, 3602, 5486, 5488, 3604, 5524, 5530, 5531, 3617, 5527, 5533, 5534, 
3619, 3615, 5525, 5532, 3620
3119, 3602, 5486, 5488, 3604, 1097, 3630, 3631, 1098, 5527, 5533, 5534, 3619, 3648, 3649, 3650, 
1102, 3616, 5528, 5535, 3621
3120, 99, 1239, 1240, 100, 3603, 5487, 5489, 3605, 1258, 1259, 1260, 104, 5531, 5537, 5538, 
3622, 3618, 5529, 5536, 3623
3121, 3603, 5487, 5489, 3605, 3604, 5488, 5490, 3606, 5531, 5537, 5538, 3622, 5534, 5540, 5541, 
3624, 3620, 5532, 5539, 3625
3122, 3604, 5488, 5490, 3606, 1098, 3631, 3632, 1099, 5534, 5540, 5541, 3624, 3650, 3651, 3652, 
1103, 3621, 5535, 5542, 3626
3123, 100, 1240, 154, 1, 3605, 5489, 3569, 1082, 1260, 1261, 158, 105, 5538, 5543, 3577, 
3627, 3623, 5536, 3578, 1084
3124, 3605, 5489, 3569, 1082, 3606, 5490, 3570, 1083, 5538, 5543, 3577, 3627, 5541, 5544, 3579, 
3628, 3625, 5539, 3580, 1085
3125, 3606, 5490, 3570, 1083, 1099, 3632, 1087, 88, 5541, 5544, 3579, 3628, 3652, 3653, 1091, 
1104, 3626, 5542, 3581, 1086
3126, 145, 146, 1241, 1237, 3509, 3511, 5491, 5483, 150, 1262, 1263, 1253, 3523, 5546, 5547, 
5516, 3517, 3522, 5545, 5515
3127, 3509, 3511, 5491, 5483, 3510, 3512, 5492, 5484, 3523, 5546, 5547, 5516, 3525, 5549, 5550, 
5519, 3519, 3524, 5548, 5518
3128, 3510, 3512, 5492, 5484, 1059, 1060, 3633, 3629, 3525, 5549, 5550, 5519, 1064, 3654, 3655, 
3645, 3521, 3526, 5551, 5521
3129, 1237, 1241, 1242, 1238, 5483, 5491, 5493, 5485, 1263, 1264, 1265, 1255, 5547, 5553, 5554, 
5523, 5515, 5545, 5552, 5522
3130, 5483, 5491, 5493, 5485, 5484, 5492, 5494, 5486, 5547, 5553, 5554, 5523, 5550, 5556, 5557, 
5526, 5518, 5548, 5555, 5525
3131, 5484, 5492, 5494, 5486, 3629, 3633, 3634, 3630, 5550, 5556, 5557, 5526, 3655, 3656, 3657, 
3647, 5521, 5551, 5558, 5528
3132, 1238, 1242, 1243, 1239, 5485, 5493, 5495, 5487, 1265, 1266, 1267, 1257, 5554, 5560, 5561, 
5530, 5522, 5552, 5559, 5529
3133, 5485, 5493, 5495, 5487, 5486, 5494, 5496, 5488, 5554, 5560, 5561, 5530, 5557, 5563, 5564, 
5533, 5525, 5555, 5562, 5532
3134, 5486, 5494, 5496, 5488, 3630, 3634, 3635, 3631, 5557, 5563, 5564, 5533, 3657, 3658, 3659, 
3649, 5528, 5558, 5565, 5535
3135, 1239, 1243, 1244, 1240, 5487, 5495, 5497, 5489, 1267, 1268, 1269, 1259, 5561, 5567, 5568, 
5537, 5529, 5559, 5566, 5536
3136, 5487, 5495, 5497, 5489, 5488, 5496, 5498, 5490, 5561, 5567, 5568, 5537, 5564, 5570, 5571, 
5540, 5532, 5562, 5569, 5539
3137, 5488, 5496, 5498, 5490, 3631, 3635, 3636, 3632, 5564, 5570, 5571, 5540, 3659, 3660, 3661, 
3651, 5535, 5565, 5572, 5542
3138, 1240, 1244, 155, 154, 5489, 5497, 3571, 3569, 1269, 1270, 159, 1261, 5568, 5573, 3582, 
5543, 5536, 5566, 3583, 3578
3139, 5489, 5497, 3571, 3569, 5490, 5498, 3572, 3570, 5568, 5573, 3582, 5543, 5571, 5574, 3584, 
5544, 5539, 5569, 3585, 3580
3140, 5490, 5498, 3572, 3570, 3632, 3636, 1088, 1087, 5571, 5574, 3584, 5544, 3661, 3662, 1092, 
3653, 5542, 5572, 3586, 3581
3141, 146, 147, 1245, 1241, 3511, 3513, 5499, 5491, 151, 1271, 1272, 1262, 3528, 5576, 5577, 
5546, 3522, 3527, 5575, 5545
3142, 3511, 3513, 5499, 5491, 3512, 3514, 5500, 5492, 3528, 5576, 5577, 5546, 3530, 5579, 5580, 
5549, 3524, 3529, 5578, 5548
3143, 3512, 3514, 5500, 5492, 1060, 1061, 3637, 3633, 3530, 5579, 5580, 5549, 1065, 3663, 3664, 
3654, 3526, 3531, 5581, 5551
3144, 1241, 1245, 1246, 1242, 5491, 5499, 5501, 5493, 1272, 1273, 1274, 1264, 5577, 5583, 5584, 
5553, 5545, 5575, 5582, 5552
3145, 5491, 5499, 5501, 5493, 5492, 5500, 5502, 5494, 5577, 5583, 5584, 5553, 5580, 5586, 5587, 
5556, 5548, 5578, 5585, 5555
3146, 5492, 5500, 5502, 5494, 3633, 3637, 3638, 3634, 5580, 5586, 5587, 5556, 3664, 3665, 3666, 
3656, 5551, 5581, 5588, 5558
3147, 1242, 1246, 1247, 1243, 5493, 5501, 5503, 5495, 1274, 1275, 1276, 1266, 5584, 5590, 5591, 
5560, 5552, 5582, 5589, 5559
3148, 5493, 5501, 5503, 5495, 5494, 5502, 5504, 5496, 5584, 5590, 5591, 5560, 5587, 5593, 5594, 
5563, 5555, 5585, 5592, 5562
3149, 5494, 5502, 5504, 5496, 3634, 3638, 3639, 3635, 5587, 5593, 5594, 5563, 3666, 3667, 3668, 
3658, 5558, 5588, 5595, 5565
3150, 1243, 1247, 1248, 1244, 5495, 5503, 5505, 5497, 1276, 1277, 1278, 1268, 5591, 5597, 5598, 
5567, 5559, 5589, 5596, 5566
3151, 5495, 5503, 5505, 5497, 5496, 5504, 5506, 5498, 5591, 5597, 5598, 5567, 5594, 5600, 5601, 
5570, 5562, 5592, 5599, 5569
3152, 5496, 5504, 5506, 5498, 3635, 3639, 3640, 3636, 5594, 5600, 5601, 5570, 3668, 3669, 3670, 
3660, 5565, 5595, 5602, 5572
3153, 1244, 1248, 156, 155, 5497, 5505, 3573, 3571, 1278, 1279, 160, 1270, 5598, 5603, 3587, 
5573, 5566, 5596, 3588, 3583
3154, 5497, 5505, 3573, 3571, 5498, 5506, 3574, 3572, 5598, 5603, 3587, 5573, 5601, 5604, 3589, 
5574, 5569, 5599, 3590, 3585
3155, 5498, 5506, 3574, 3572, 3636, 3640, 1089, 1088, 5601, 5604, 3589, 5574, 3670, 3671, 1093, 
3662, 5572, 5602, 3591, 3586
3156, 147, 148, 1249, 1245, 3513, 3515, 5507, 5499, 152, 1280, 1281, 1271, 3533, 5606, 5607, 
5576, 3527, 3532, 5605, 5575
3157, 3513, 3515, 5507, 5499, 3514, 3516, 5508, 5500, 3533, 5606, 5607, 5576, 3535, 5609, 5610, 
5579, 3529, 3534, 5608, 5578
3158, 3514, 3516, 5508, 5500, 1061, 1062, 3641, 3637, 3535, 5609, 5610, 5579, 1066, 3672, 3673, 
3663, 3531, 3536, 5611, 5581
3159, 1245, 1249, 1250, 1246, 5499, 5507, 5509, 5501, 1281, 1282, 1283, 1273, 5607, 5613, 5614, 
5583, 5575, 5605, 5612, 5582
3160, 5499, 5507, 5509, 5501, 5500, 5508, 5510, 5502, 5607, 5613, 5614, 5583, 5610, 5616, 5617, 
5586, 5578, 5608, 5615, 5585
3161, 5500, 5508, 5510, 5502, 3637, 3641, 3642, 3638, 5610, 5616, 5617, 5586, 3673, 3674, 3675, 
3665, 5581, 5611, 5618, 5588
3162, 1246, 1250, 1251, 1247, 5501, 5509, 5511, 5503, 1283, 1284, 1285, 1275, 5614, 5620, 5621, 
5590, 5582, 5612, 5619, 5589
3163, 5501, 5509, 5511, 5503, 5502, 5510, 5512, 5504, 5614, 5620, 5621, 5590, 5617, 5623, 5624, 
5593, 5585, 5615, 5622, 5592
3164, 5502, 5510, 5512, 5504, 3638, 3642, 3643, 3639, 5617, 5623, 5624, 5593, 3675, 3676, 3677, 
3667, 5588, 5618, 5625, 5595
3165, 1247, 1251, 1252, 1248, 5503, 5511, 5513, 5505, 1285, 1286, 1287, 1277, 5621, 5627, 5628, 
5597, 5589, 5619, 5626, 5596
3166, 5503, 5511, 5513, 5505, 5504, 5512, 5514, 5506, 5621, 5627, 5628, 5597, 5624, 5630, 5631, 
5600, 5592, 5622, 5629, 5599
3167, 5504, 5512, 5514, 5506, 3639, 3643, 3644, 3640, 5624, 5630, 5631, 5600, 3677, 3678, 3679, 
3669, 5595, 5625, 5632, 5602
3168, 1248, 1252, 157, 156, 5505, 5513, 3575, 3573, 1287, 1288, 161, 1279, 5628, 5633, 3592, 
5603, 5596, 5626, 3593, 3588
3169, 5505, 5513, 3575, 3573, 5506, 5514, 3576, 3574, 5628, 5633, 3592, 5603, 5631, 5634, 3594, 
5604, 5599, 5629, 3595, 3590
3170, 5506, 5514, 3576, 3574, 3640, 3644, 1090, 1089, 5631, 5634, 3594, 5604, 3679, 3680, 1094, 
3671, 5602, 5632, 3596, 3591
3171, 148, 6, 121, 1249, 3515, 1049, 3539, 5507, 153, 125, 1289, 1280, 3537, 3548, 5635, 
5606, 3532, 1051, 3547, 5605
3172, 3515, 1049, 3539, 5507, 3516, 1050, 3540, 5508, 3537, 3548, 5635, 5606, 3538, 3550, 5636, 
5609, 3534, 1052, 3549, 5608
3173, 3516, 1050, 3540, 5508, 1062, 85, 1073, 3641, 3538, 3550, 5636, 5609, 1067, 1077, 3681, 
3672, 3536, 1053, 3551, 5611
3174, 1249, 121, 122, 1250, 5507, 3539, 3541, 5509, 1289, 126, 1290, 1282, 5635, 3553, 5637, 
5613, 5605, 3547, 3552, 5612
3175, 5507, 3539, 3541, 5509, 5508, 3540, 3542, 5510, 5635, 3553, 5637, 5613, 5636, 3555, 5638, 
5616, 5608, 3549, 3554, 5615
3176, 5508, 3540, 3542, 5510, 3641, 1073, 1074, 3642, 5636, 3555, 5638, 5616, 3681, 1078, 3682, 
3674, 5611, 3551, 3556, 5618
3177, 1250, 122, 123, 1251, 5509, 3541, 3543, 5511, 1290, 127, 1291, 1284, 5637, 3558, 5639, 
5620, 5612, 3552, 3557, 5619
3178, 5509, 3541, 3543, 5511, 5510, 3542, 3544, 5512, 5637, 3558, 5639, 5620, 5638, 3560, 5640, 
5623, 5615, 3554, 3559, 5622
3179, 5510, 3542, 3544, 5512, 3642, 1074, 1075, 3643, 5638, 3560, 5640, 5623, 3682, 1079, 3683, 
3676, 5618, 3556, 3561, 5625
3180, 1251, 123, 124, 1252, 5511, 3543, 3545, 5513, 1291, 128, 1292, 1286, 5639, 3563, 5641, 
5627, 5619, 3557, 3562, 5626
3181, 5511, 3543, 3545, 5513, 5512, 3544, 3546, 5514, 5639, 3563, 5641, 5627, 5640, 3565, 5642, 
5630, 5622, 3559, 3564, 5629
3182, 5512, 3544, 3546, 5514, 3643, 1075, 1076, 3644, 5640, 3565, 5642, 5630, 3683, 1080, 3684, 
3678, 5625, 3561, 3566, 5632
3183, 1252, 124, 5, 157, 5513, 3545, 1068, 3575, 1292, 129, 162, 1288, 5641, 3567, 3597, 
5633, 5626, 3562, 1070, 3593
3184, 5513, 3545, 1068, 3575, 5514, 3546, 1069, 3576, 5641, 3567, 3597, 5633, 5642, 3568, 3598, 
5634, 5629, 3564, 1071, 3595
3185, 5514, 3546, 1069, 3576, 3644, 1076, 87, 1090, 5642, 3568, 3598, 5634, 3684, 1081, 1095, 
3680, 5632, 3566, 1072, 3596
*ELEMENT, type=C3D20, ELSET=Volume24
3186, 2, 97, 715, 54, 1054, 3599, 3689, 1111, 101, 2764, 719, 714, 3607, 5643, 3697, 
3687, 1056, 3608, 3698, 1113
3187, 1054, 3599, 3689, 1111, 1055, 3600, 3690, 1112, 3607, 5643, 3697, 3687, 3609, 5644, 3699, 
3688, 1057, 3610, 3700, 1114
3188, 1055, 3600, 3690, 1112, 86, 1096, 1117, 90, 3609, 5644, 3699, 3688, 1100, 3719, 1121, 
1116, 1058, 3611, 3701, 1115
3189, 97, 98, 716, 715, 3599, 3601, 3691, 3689, 102, 2765, 720, 2764, 3612, 5645, 3702, 
5643, 3608, 3613, 3703, 3698
3190, 3599, 3601, 3691, 3689, 3600, 3602, 3692, 3690, 3612, 5645, 3702, 5643, 3614, 5646, 3704, 
5644, 3610, 3615, 3705, 3700
3191, 3600, 3602, 3692, 3690, 1096, 1097, 1118, 1117, 3614, 5646, 3704, 5644, 1101, 3720, 1122, 
3719, 3611, 3616, 3706, 3701
3192, 98, 99, 717, 716, 3601, 3603, 3693, 3691, 103, 2766, 721, 2765, 3617, 5647, 3707, 
5645, 3613, 3618, 3708, 3703
3193, 3601, 3603, 3693, 3691, 3602, 3604, 3694, 3692, 3617, 5647, 3707, 5645, 3619, 5648, 3709, 
5646, 3615, 3620, 3710, 3705
3194, 3602, 3604, 3694, 3692, 1097, 1098, 1119, 1118, 3619, 5648, 3709, 5646, 1102, 3721, 1123, 
3720, 3616, 3621, 3711, 3706
3195, 99, 100, 718, 717, 3603, 3605, 3695, 3693, 104, 2767, 722, 2766, 3622, 5649, 3712, 
5647, 3618, 3623, 3713, 3708
3196, 3603, 3605, 3695, 3693, 3604, 3606, 3696, 3694, 3622, 5649, 3712, 5647, 3624, 5650, 3714, 
5648, 3620, 3625, 3715, 3710
3197, 3604, 3606, 3696, 3694, 1098, 1099, 1120, 1119, 3624, 5650, 3714, 5648, 1103, 3722, 1124, 
3721, 3621, 3626, 3716, 3711
3198, 100, 1, 53, 718, 3605, 1082, 1105, 3695, 105, 713, 723, 2767, 3627, 3685, 3717, 
5649, 3623, 1084, 1107, 3713
3199, 3605, 1082, 1105, 3695, 3606, 1083, 1106, 3696, 3627, 3685, 3717, 5649, 3628, 3686, 3718, 
5650, 3625, 1085, 1108, 3715
3200, 3606, 1083, 1106, 3696, 1099, 88, 89, 1120, 3628, 3686, 3718, 5650, 1104, 1110, 1125, 
3722, 3626, 1086, 1109, 3716
*ELEMENT, type=C3D20, ELSET=Volume25
3201, 47, 658, 2681, 667, 1145, 3753, 5651, 3783, 662, 2697, 2698, 671, 3762, 5684, 5685, 
3791, 1147, 3761, 5683, 3792
3202, 1145, 3753, 5651, 3783, 1146, 3754, 5652, 3784, 3762, 5684, 5685, 3791, 3764, 5687, 5688, 
3793, 1148, 3763, 5686, 3794
3203, 1146, 3754, 5652, 3784, 93, 1155, 3843, 1164, 3764, 5687, 5688, 3793, 1159, 3859, 3860, 
1168, 1149, 3765, 5689, 3795
3204, 658, 659, 2682, 2681, 3753, 3755, 5653, 5651, 663, 2699, 2700, 2697, 3767, 5691, 5692, 
5684, 3761, 3766, 5690, 5683
3205, 3753, 3755, 5653, 5651, 3754, 3756, 5654, 5652, 3767, 5691, 5692, 5684, 3769, 5694, 5695, 
5687, 3763, 3768, 5693, 5686
3206, 3754, 3756, 5654, 5652, 1155, 1156, 3844, 3843, 3769, 5694, 5695, 5687, 1160, 3861, 3862, 
3859, 3765, 3770, 5696, 5689
3207, 659, 660, 2683, 2682, 3755, 3757, 5655, 5653, 664, 2701, 2702, 2699, 3772, 5698, 5699, 
5691, 3766, 3771, 5697, 5690
3208, 3755, 3757, 5655, 5653, 3756, 3758, 5656, 5654, 3772, 5698, 5699, 5691, 3774, 5701, 5702, 
5694, 3768, 3773, 5700, 5693
3209, 3756, 3758, 5656, 5654, 1156, 1157, 3845, 3844, 3774, 5701, 5702, 5694, 1161, 3863, 3864, 
3861, 3770, 3775, 5703, 5696
3210, 660, 661, 2684, 2683, 3757, 3759, 5657, 5655, 665, 2703, 2704, 2701, 3777, 5705, 5706, 
5698, 3771, 3776, 5704, 5697
3211, 3757, 3759, 5657, 5655, 3758, 3760, 5658, 5656, 3777, 5705, 5706, 5698, 3779, 5708, 5709, 
5701, 3773, 3778, 5707, 5700
3212, 3758, 3760, 5658, 5656, 1157, 1158, 3846, 3845, 3779, 5708, 5709, 5701, 1162, 3865, 3866, 
3863, 3775, 3780, 5710, 5703
3213, 661, 48, 676, 2684, 3759, 1150, 3813, 5657, 666, 680, 2705, 2703, 3781, 3822, 5711, 
5705, 3776, 1152, 3821, 5704
3214, 3759, 1150, 3813, 5657, 3760, 1151, 3814, 5658, 3781, 3822, 5711, 5705, 3782, 3824, 5712, 
5708, 3778, 1153, 3823, 5707
3215, 3760, 1151, 3814, 5658, 1158, 94, 1173, 3846, 3782, 3824, 5712, 5708, 1163, 1177, 3867, 
3865, 3780, 1154, 3825, 5710
3216, 667, 2681, 2685, 668, 3783, 5651, 5659, 3785, 2698, 2706, 2707, 672, 5685, 5714, 5715, 
3796, 3792, 5683, 5713, 3797
3217, 3783, 5651, 5659, 3785, 3784, 5652, 5660, 3786, 5685, 5714, 5715, 3796, 5688, 5717, 5718, 
3798, 3794, 5686, 5716, 3799
3218, 3784, 5652, 5660, 3786, 1164, 3843, 3847, 1165, 5688, 5717, 5718, 3798, 3860, 3868, 3869, 
1169, 3795, 5689, 5719, 3800
3219, 2681, 2682, 2686, 2685, 5651, 5653, 5661, 5659, 2700, 2708, 2709, 2706, 5692, 5721, 5722, 
5714, 5683, 5690, 5720, 5713
3220, 5651, 5653, 5661, 5659, 5652, 5654, 5662, 5660, 5692, 5721, 5722, 5714, 5695, 5724, 5725, 
5717, 5686, 5693, 5723, 5716
3221, 5652, 5654, 5662, 5660, 3843, 3844, 3848, 3847, 5695, 5724, 5725, 5717, 3862, 3870, 3871, 
3868, 5689, 5696, 5726, 5719
3222, 2682, 2683, 2687, 2686, 5653, 5655, 5663, 5661, 2702, 2710, 2711, 2708, 5699, 5728, 5729, 
5721, 5690, 5697, 5727, 5720
3223, 5653, 5655, 5663, 5661, 5654, 5656, 5664, 5662, 5699, 5728, 5729, 5721, 5702, 5731, 5732, 
5724, 5693, 5700, 5730, 5723
3224, 5654, 5656, 5664, 5662, 3844, 3845, 3849, 3848, 5702, 5731, 5732, 5724, 3864, 3872, 3873, 
3870, 5696, 5703, 5733, 5726
3225, 2683, 2684, 2688, 2687, 5655, 5657, 5665, 5663, 2704, 2712, 2713, 2710, 5706, 5735, 5736, 
5728, 5697, 5704, 5734, 5727
3226, 5655, 5657, 5665, 5663, 5656, 5658, 5666, 5664, 5706, 5735, 5736, 5728, 5709, 5738, 5739, 
5731, 5700, 5707, 5737, 5730
3227, 5656, 5658, 5666, 5664, 3845, 3846, 3850, 3849, 5709, 5738, 5739, 5731, 3866, 3874, 3875, 
3872, 5703, 5710, 5740, 5733
3228, 2684, 676, 677, 2688, 5657, 3813, 3815, 5665, 2705, 681, 2714, 2712, 5711, 3827, 5741, 
5735, 5704, 3821, 3826, 5734
3229, 5657, 3813, 3815, 5665, 5658, 3814, 3816, 5666, 5711, 3827, 5741, 5735, 5712, 3829, 5742, 
5738, 5707, 3823, 3828, 5737
3230, 5658, 3814, 3816, 5666, 3846, 1173, 1174, 3850, 5712, 3829, 5742, 5738, 3867, 1178, 3876, 
3874, 5710, 3825, 3830, 5740
3231, 668, 2685, 2689, 669, 3785, 5659, 5667, 3787, 2707, 2715, 2716, 673, 5715, 5744, 5745, 
3801, 3797, 5713, 5743, 3802
3232, 3785, 5659, 5667, 3787, 3786, 5660, 5668, 3788, 5715, 5744, 5745, 3801, 5718, 5747, 5748, 
3803, 3799, 5716, 5746, 3804
3233, 3786, 5660, 5668, 3788, 1165, 3847, 3851, 1166, 5718, 5747, 5748, 3803, 3869, 3877, 3878, 
1170, 3800, 5719, 5749, 3805
3234, 2685, 2686, 2690, 2689, 5659, 5661, 5669, 5667, 2709, 2717, 2718, 2715, 5722, 5751, 5752, 
5744, 5713, 5720, 5750, 5743
3235, 5659, 5661, 5669, 5667, 5660, 5662, 5670, 5668, 5722, 5751, 5752, 5744, 5725, 5754, 5755, 
5747, 5716, 5723, 5753, 5746
3236, 5660, 5662, 5670, 5668, 3847, 3848, 3852, 3851, 5725, 5754, 5755, 5747, 3871, 3879, 3880, 
3877, 5719, 5726, 5756, 5749
3237, 2686, 2687, 2691, 2690, 5661, 5663, 5671, 5669, 2711, 2719, 2720, 2717, 5729, 5758, 5759, 
5751, 5720, 5727, 5757, 5750
3238, 5661, 5663, 5671, 5669, 5662, 5664, 5672, 5670, 5729, 5758, 5759, 5751, 5732, 5761, 5762, 
5754, 5723, 5730, 5760, 5753
3239, 5662, 5664, 5672, 5670, 3848, 3849, 3853, 3852, 5732, 5761, 5762, 5754, 3873, 3881, 3882, 
3879, 5726, 5733, 5763, 5756
3240, 2687, 2688, 2692, 2691, 5663, 5665, 5673, 5671, 2713, 2721, 2722, 2719, 5736, 5765, 5766, 
5758, 5727, 5734, 5764, 5757
3241, 5663, 5665, 5673, 5671, 5664, 5666, 5674, 5672, 5736, 5765, 5766, 5758, 5739, 5768, 5769, 
5761, 5730, 5737, 5767, 5760
3242, 5664, 5666, 5674, 5672, 3849, 3850, 3854, 3853, 5739, 5768, 5769, 5761, 3875, 3883, 3884, 
3881, 5733, 5740, 5770, 5763
3243, 2688, 677, 678, 2692, 5665, 3815, 3817, 5673, 2714, 682, 2723, 2721, 5741, 3832, 5771, 
5765, 5734, 3826, 3831, 5764
3244, 5665, 3815, 3817, 5673, 5666, 3816, 3818, 5674, 5741, 3832, 5771, 5765, 5742, 3834, 5772, 
5768, 5737, 3828, 3833, 5767
3245, 5666, 3816, 3818, 5674, 3850, 1174, 1175, 3854, 5742, 3834, 5772, 5768, 3876, 1179, 3885, 
3883, 5740, 3830, 3835, 5770
3246, 669, 2689, 2693, 670, 3787, 5667, 5675, 3789, 2716, 2724, 2725, 674, 5745, 5774, 5775, 
3806, 3802, 5743, 5773, 3807
3247, 3787, 5667, 5675, 3789, 3788, 5668, 5676, 3790, 5745, 5774, 5775, 3806, 5748, 5777, 5778, 
3808, 3804, 5746, 5776, 3809
3248, 3788, 5668, 5676, 3790, 1166, 3851, 3855, 1167, 5748, 5777, 5778, 3808, 3878, 3886, 3887, 
1171, 3805, 5749, 5779, 3810
3249, 2689, 2690, 2694, 2693, 5667, 5669, 5677, 5675, 2718, 2726, 2727, 2724, 5752, 5781, 5782, 
5774, 5743, 5750, 5780, 5773
3250, 5667, 5669, 5677, 5675, 5668, 5670, 5678, 5676, 5752, 5781, 5782, 5774, 5755, 5784, 5785, 
5777, 5746, 5753, 5783, 5776
3251, 5668, 5670, 5678, 5676, 3851, 3852, 3856, 3855, 5755, 5784, 5785, 5777, 3880, 3888, 3889, 
3886, 5749, 5756, 5786, 5779
3252, 2690, 2691, 2695, 2694, 5669, 5671, 5679, 5677, 2720, 2728, 2729, 2726, 5759, 5788, 5789, 
5781, 5750, 5757, 5787, 5780
3253, 5669, 5671, 5679, 5677, 5670, 5672, 5680, 5678, 5759, 5788, 5789, 5781, 5762, 5791, 5792, 
5784, 5753, 5760, 5790, 5783
3254, 5670, 5672, 5680, 5678, 3852, 3853, 3857, 3856, 5762, 5791, 5792, 5784, 3882, 3890, 3891, 
3888, 5756, 5763, 5793, 5786
3255, 2691, 2692, 2696, 2695, 5671, 5673, 5681, 5679, 2722, 2730, 2731, 2728, 5766, 5795, 5796, 
5788, 5757, 5764, 5794, 5787
3256, 5671, 5673, 5681, 5679, 5672, 5674, 5682, 5680, 5766, 5795, 5796, 5788, 5769, 5798, 5799, 
5791, 5760, 5767, 5797, 5790
3257, 5672, 5674, 5682, 5680, 3853, 3854, 3858, 3857, 5769, 5798, 5799, 5791, 3884, 3892, 3893, 
3890, 5763, 5770, 5800, 5793
3258, 2692, 678, 679, 2696, 5673, 3817, 3819, 5681, 2723, 683, 2732, 2730, 5771, 3837, 5801, 
5795, 5764, 3831, 3836, 5794
3259, 5673, 3817, 3819, 5681, 5674, 3818, 3820, 5682, 5771, 3837, 5801, 5795, 5772, 3839, 5802, 
5798, 5767, 3833, 3838, 5797
3260, 5674, 3818, 3820, 5682, 3854, 1175, 1176, 3858, 5772, 3839, 5802, 5798, 3885, 1180, 3894, 
3892, 5770, 3835, 3840, 5800
3261, 670, 2693, 643, 45, 3789, 5675, 3723, 1126, 2725, 2733, 647, 675, 5775, 5803, 3731, 
3811, 3807, 5773, 3732, 1128
3262, 3789, 5675, 3723, 1126, 3790, 5676, 3724, 1127, 5775, 5803, 3731, 3811, 5778, 5804, 3733, 
3812, 3809, 5776, 3734, 1129
3263, 3790, 5676, 3724, 1127, 1167, 3855, 1136, 91, 5778, 5804, 3733, 3812, 3887, 3895, 1140, 
1172, 3810, 5779, 3735, 1130
3264, 2693, 2694, 644, 643, 5675, 5677, 3725, 3723, 2727, 2734, 648, 2733, 5782, 5805, 3736, 
5803, 5773, 5780, 3737, 3732
3265, 5675, 5677, 3725, 3723, 5676, 5678, 3726, 3724, 5782, 5805, 3736, 5803, 5785, 5806, 3738, 
5804, 5776, 5783, 3739, 3734
3266, 5676, 5678, 3726, 3724, 3855, 3856, 1137, 1136, 5785, 5806, 3738, 5804, 3889, 3896, 1141, 
3895, 5779, 5786, 3740, 3735
3267, 2694, 2695, 645, 644, 5677, 5679, 3727, 3725, 2729, 2735, 649, 2734, 5789, 5807, 3741, 
5805, 5780, 5787, 3742, 3737
3268, 5677, 5679, 3727, 3725, 5678, 5680, 3728, 3726, 5789, 5807, 3741, 5805, 5792, 5808, 3743, 
5806, 5783, 5790, 3744, 3739
3269, 5678, 5680, 3728, 3726, 3856, 3857, 1138, 1137, 5792, 5808, 3743, 5806, 3891, 3897, 1142, 
3896, 5786, 5793, 3745, 3740
3270, 2695, 2696, 646, 645, 5679, 5681, 3729, 3727, 2731, 2736, 650, 2735, 5796, 5809, 3746, 
5807, 5787, 5794, 3747, 3742
3271, 5679, 5681, 3729, 3727, 5680, 5682, 3730, 3728, 5796, 5809, 3746, 5807, 5799, 5810, 3748, 
5808, 5790, 5797, 3749, 3744
3272, 5680, 5682, 3730, 3728, 3857, 3858, 1139, 1138, 5799, 5810, 3748, 5808, 3893, 3898, 1143, 
3897, 5793, 5800, 3750, 3745
3273, 2696, 679, 46, 646, 5681, 3819, 1131, 3729, 2732, 684, 651, 2736, 5801, 3841, 3751, 
5809, 5794, 3836, 1133, 3747
3274, 5681, 3819, 1131, 3729, 5682, 3820, 1132, 3730, 5801, 3841, 3751, 5809, 5802, 3842, 3752, 
5810, 5797, 3838, 1134, 3749
3275, 5682, 3820, 1132, 3730, 3858, 1176, 92, 1139, 5802, 3842, 3752, 5810, 3894, 1181, 1144, 
3898, 5800, 3840, 1135, 3750
*ELEMENT, type=C3D20, ELSET=Volume26
3276, 48, 52, 704, 676, 1150, 1188, 3903, 3813, 691, 708, 2743, 680, 3901, 3912, 5811, 
3822, 1152, 1190, 3911, 3821
3277, 1150, 1188, 3903, 3813, 1151, 1189, 3904, 3814, 3901, 3912, 5811, 3822, 3902, 3914, 5812, 
3824, 1153, 1191, 3913, 3823
3278, 1151, 1189, 3904, 3814, 94, 96, 1194, 1173, 3902, 3914, 5812, 3824, 1193, 1198, 3933, 
1177, 1154, 1192, 3915, 3825
3279, 676, 704, 705, 677, 3813, 3903, 3905, 3815, 2743, 709, 2744, 681, 5811, 3917, 5813, 
3827, 3821, 3911, 3916, 3826
3280, 3813, 3903, 3905, 3815, 3814, 3904, 3906, 3816, 5811, 3917, 5813, 3827, 5812, 3919, 5814, 
3829, 3823, 3913, 3918, 3828
3281, 3814, 3904, 3906, 3816, 1173, 1194, 1195, 1174, 5812, 3919, 5814, 3829, 3933, 1199, 3934, 
1178, 3825, 3915, 3920, 3830
3282, 677, 705, 706, 678, 3815, 3905, 3907, 3817, 2744, 710, 2745, 682, 5813, 3922, 5815, 
3832, 3826, 3916, 3921, 3831
3283, 3815, 3905, 3907, 3817, 3816, 3906, 3908, 3818, 5813, 3922, 5815, 3832, 5814, 3924, 5816, 
3834, 3828, 3918, 3923, 3833
3284, 3816, 3906, 3908, 3818, 1174, 1195, 1196, 1175, 5814, 3924, 5816, 3834, 3934, 1200, 3935, 
1179, 3830, 3920, 3925, 3835
3285, 678, 706, 707, 679, 3817, 3907, 3909, 3819, 2745, 711, 2746, 683, 5815, 3927, 5817, 
3837, 3831, 3921, 3926, 3836
3286, 3817, 3907, 3909, 3819, 3818, 3908, 3910, 3820, 5815, 3927, 5817, 3837, 5816, 3929, 5818, 
3839, 3833, 3923, 3928, 3838
3287, 3818, 3908, 3910, 3820, 1175, 1196, 1197, 1176, 5816, 3929, 5818, 3839, 3935, 1201, 3936, 
1180, 3835, 3925, 3930, 3840
3288, 679, 707, 50, 46, 3819, 3909, 1182, 1131, 2746, 712, 686, 684, 5817, 3931, 3899, 
3841, 3836, 3926, 1184, 1133
3289, 3819, 3909, 1182, 1131, 3820, 3910, 1183, 1132, 5817, 3931, 3899, 3841, 5818, 3932, 3900, 
3842, 3838, 3928, 1185, 1134
3290, 3820, 3910, 1183, 1132, 1176, 1197, 95, 92, 5818, 3932, 3900, 3842, 3936, 1202, 1187, 
1181, 3840, 3930, 1186, 1135
*ELSET,ELSET=Qin
1092, 1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 
1102, 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 
1112, 1113, 1114, 1115, 1116, 1144, 1145, 1146, 1147, 1148, 
1149, 1150, 1151, 1152, 1153, 1154, 1155, 1156, 1157, 1158, 
1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 1223, 
1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 1233, 
1234, 1235, 1236, 1237, 1238, 
*ELSET,ELSET=HeatSink
767, 768, 769, 770, 771, 772, 773, 774, 775, 776, 
777, 778, 779, 780, 781, 782, 783, 784, 785, 786, 
787, 788, 789, 790, 791, 1504, 1505, 1506, 1507, 1508, 
1509, 1510, 1511, 1512, 1513, 1514, 1515, 1516, 1517, 1518, 
1519, 1520, 1521, 1522, 1523, 1524, 1525, 1526, 1527, 1528, 
*ELSET,ELSET=ElectrodeMaxX
1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 
*ELSET,ELSET=ElectrodeMinX
1567, 1568, 1569, 1570, 1571, 1572, 1573, 1574, 1575, 1576, 
*ELSET,ELSET=Force
1082, 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 
*ELSET,ELSET=Ceramic_Top
1841, 1842, 1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 
1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 
1861, 1862, 1863, 1864, 1865, 1899, 1900, 1901, 1902, 1903, 
1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 
1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 
1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 
1979, 1980, 1981, 1982, 1983, 
*ELSET,ELSET=Ceramic_Bottom
1866, 1867, 1868, 1869, 1870, 1871, 1872, 1873, 1874, 2044, 
2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 2054, 
2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 2064, 
2065, 2066, 2067, 2068, 2155, 2156, 2157, 2158, 2159, 2160, 
2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 
2171, 2172, 2173, 2174, 2175, 2176, 2177, 2178, 2179, 
*ELSET,ELSET=Top_Semiconductors
982, 983, 984, 985, 986, 987, 988, 989, 990, 991, 
992, 993, 994, 995, 996, 997, 998, 999, 1000, 1001, 
1002, 1003, 1004, 1005, 1006, 1269, 1270, 1271, 1272, 1273, 
1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 1283, 
1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 1293, 
*ELSET,ELSET=top
1841, 1842, 1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 
1851, 1852, 1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 
1861, 1862, 1863, 1864, 1865, 1899, 1900, 1901, 1902, 1903, 
1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 
1959, 1960, 1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 
1969, 1970, 1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 
1979, 1980, 1981, 1982, 1983, 
*ELSET,ELSET=bottom
2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 2053, 
2054, 2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 2063, 
2064, 2065, 2066, 2067, 2068, 2090, 2091, 2092, 2093, 2094, 
2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 2163, 2164, 
2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 2173, 2174, 
2175, 2176, 2177, 2178, 2179, 2201, 2202, 2203, 2204, 2205, 
*ELSET,ELSET=Copper
2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 2215, 
2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 2225, 
2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 2235, 
2236, 2237, 2238, 2239, 2240, 2241, 2242, 2243, 2244, 2245, 
2246, 2247, 2248, 2249, 2250, 2251, 2252, 2253, 2254, 2255, 
2431, 2432, 2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 
2441, 2442, 2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 
2451, 2452, 2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 
2461, 2462, 2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 
2471, 2472, 2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 
2481, 2482, 2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 
2491, 2492, 2493, 2494, 2495, 2496, 2497, 2498, 2499, 2500, 
2501, 2502, 2503, 2504, 2505, 2506, 2507, 2508, 2509, 2510, 
2511, 2512, 2513, 2514, 2515, 2516, 2517, 2518, 2519, 2520, 
2521, 2522, 2523, 2524, 2525, 2526, 2527, 2528, 2529, 2530, 
2531, 2532, 2533, 2534, 2535, 2536, 2537, 2538, 2539, 2540, 
2541, 2542, 2543, 2544, 2545, 2546, 2547, 2548, 2549, 2550, 
2551, 2552, 2553, 2554, 2555, 2556, 2557, 2558, 2559, 2560, 
2736, 2737, 2738, 2739, 2740, 2741, 2742, 2743, 2744, 2745, 
2746, 2747, 2748, 2749, 2750, 2751, 2752, 2753, 2754, 2755, 
2756, 2757, 2758, 2759, 2760, 2761, 2762, 2763, 2764, 2765, 
2766, 2767, 2768, 2769, 2770, 2771, 2772, 2773, 2774, 2775, 
2776, 2777, 2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 
2786, 2787, 2788, 2789, 2790, 2791, 2792, 2793, 2794, 2795, 
2796, 2797, 2798, 2799, 2800, 2801, 2802, 2803, 2804, 2805, 
*ELSET,ELSET=SemiconductorN-
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2806, 2807, 2808, 2809, 2810, 
2811, 2812, 2813, 2814, 2815, 2816, 2817, 2818, 2819, 2820, 
2821, 2822, 2823, 2824, 2825, 2826, 2827, 2828, 2829, 2830, 
2856, 2857, 2858, 2859, 2860, 2861, 2862, 2863, 2864, 2865, 
2866, 2867, 2868, 2869, 2870, 2871, 2872, 2873, 2874, 2875, 
2876, 2877, 2878, 2879, 2880, 2911, 2912, 2913, 2914, 2915, 
*ELSET,ELSET=SemiconductorP+
2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 
2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 2604, 2605, 
2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 2614, 2615, 
2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 2624, 2625, 
2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 2634, 2635, 
2636, 2637, 2638, 2639, 2640, 2641, 2642, 2643, 2644, 2645, 
2646, 2647, 2648, 2649, 2650, 2651, 2652, 2653, 2654, 2655, 
2656, 2657, 2658, 2659, 2660, 2661, 2662, 2663, 2664, 2665, 
2666, 2667, 2668, 2669, 2670, 2671, 2672, 2673, 2674, 2675, 
2676, 2677, 2678, 2679, 2680, 2681, 2682, 2683, 2684, 2685, 
2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 2695, 
2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 2705, 
2706, 2707, 2708, 2709, 2710, 2831, 2832, 2833, 2834, 2835, 
2836, 2837, 2838, 2839, 2840, 2841, 2842, 2843, 2844, 2845, 
2846, 2847, 2848, 2849, 2850, 2851, 2852, 2853, 2854, 2855, 
2881, 2882, 2883, 2884, 2885, 2886, 2887, 2888, 2889, 2890, 
2891, 2892, 2893, 2894, 2895, 2896, 2897, 2898, 2899, 2900, 
2901, 2902, 2903, 2904, 2905, 2906, 2907, 2908, 2909, 2910, 
*ELSET,ELSET=Solder
2256, 2257, 2258, 2259, 2260, 2261, 2262, 2263, 2264, 2265, 
2266, 2267, 2268, 2269, 2270, 2271, 2272, 2273, 2274, 2275, 
2276, 2277, 2278, 2279, 2280, 2406, 2407, 2408, 2409, 2410, 
2411, 2412, 2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 
2421, 2422, 2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 
2561, 2562, 2563, 2564, 2565, 2566, 2567, 2568, 2569, 2570, 
2571, 2572, 2573, 2574, 2575, 2576, 2577, 2578, 2579, 2580, 
2581, 2582, 2583, 2584, 2585, 2711, 2712, 2713, 2714, 2715, 
2716, 2717, 2718, 2719, 2720, 2721, 2722, 2723, 2724, 2725, 
2726, 2727, 2728, 2729, 2730, 2731, 2732, 2733, 2734, 2735, 
*ELSET,ELSET=Volume
2206, 2207, 2208, 2209, 2210, 2211, 2212, 2213, 2214, 2215, 
2216, 2217, 2218, 2219, 2220, 2221, 2222, 2223, 2224, 2225, 
2226, 2227, 2228, 2229, 2230, 2231, 2232, 2233, 2234, 2235, 
2236, 2237, 2238, 2239, 2240, 2241, 2242, 2243, 2244, 2245, 
2246, 2247, 2248, 2249, 2250, 2251, 2252, 2253, 2254, 2255, 
2256, 2257, 2258, 2259, 2260, 2261, 2262, 2263, 2264, 2265, 
2266, 2267, 2268, 2269, 2270, 2271, 2272, 2273, 2274, 2275, 
2276, 2277, 2278, 2279, 2280, 2281, 2282, 2283, 2284, 2285, 
2286, 2287, 2288, 2289, 2290, 2291, 2292, 2293, 2294, 2295, 
2296, 2297, 2298, 2299, 2300, 2301, 2302, 2303, 2304, 2305, 
2306, 2307, 2308, 2309, 2310, 2311, 2312, 2313, 2314, 2315, 
2316, 2317, 2318, 2319, 2320, 2321, 2322, 2323, 2324, 2325, 
2326, 2327, 2328, 2329, 2330, 2331, 2332, 2333, 2334, 2335, 
2336, 2337, 2338, 2339, 2340, 2341, 2342, 2343, 2344, 2345, 
2346, 2347, 2348, 2349, 2350, 2351, 2352, 2353, 2354, 2355, 
2356, 2357, 2358, 2359, 2360, 2361, 2362, 2363, 2364, 2365, 
2366, 2367, 2368, 2369, 2370, 2371, 2372, 2373, 2374, 2375, 
2376, 2377, 2378, 2379, 2380, 2381, 2382, 2383, 2384, 2385, 
2386, 2387, 2388, 2389, 2390, 2391, 2392, 2393, 2394, 2395, 
2396, 2397, 2398, 2399, 2400, 2401, 2402, 2403, 2404, 2405, 
2406, 2407, 2408, 2409, 2410, 2411, 2412, 2413, 2414, 2415, 
2416, 2417, 2418, 2419, 2420, 2421, 2422, 2423, 2424, 2425, 
2426, 2427, 2428, 2429, 2430, 2431, 2432, 2433, 2434, 2435, 
2436, 2437, 2438, 2439, 2440, 2441, 2442, 2443, 2444, 2445, 
2446, 2447, 2448, 2449, 2450, 2451, 2452, 2453, 2454, 2455, 
2456, 2457, 2458, 2459, 2460, 2461, 2462, 2463, 2464, 2465, 
2466, 2467, 2468, 2469, 2470, 2471, 2472, 2473, 2474, 2475, 
2476, 2477, 2478, 2479, 2480, 2481, 2482, 2483, 2484, 2485, 
2486, 2487, 2488, 2489, 2490, 2491, 2492, 2493, 2494, 2495, 
2496, 2497, 2498, 2499, 2500, 2501, 2502, 2503, 2504, 2505, 
2506, 2507, 2508, 2509, 2510, 2511, 2512, 2513, 2514, 2515, 
2516, 2517, 2518, 2519, 2520, 2521, 2522, 2523, 2524, 2525, 
2526, 2527, 2528, 2529, 2530, 2531, 2532, 2533, 2534, 2535, 
2536, 2537, 2538, 2539, 2540, 2541, 2542, 2543, 2544, 2545, 
2546, 2547, 2548, 2549, 2550, 2551, 2552, 2553, 2554, 2555, 
2556, 2557, 2558, 2559, 2560, 2561, 2562, 2563, 2564, 2565, 
2566, 2567, 2568, 2569, 2570, 2571, 2572, 2573, 2574, 2575, 
2576, 2577, 2578, 2579, 2580, 2581, 2582, 2583, 2584, 2585, 
2586, 2587, 2588, 2589, 2590, 2591, 2592, 2593, 2594, 2595, 
2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 2604, 2605, 
2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 2614, 2615, 
2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 2624, 2625, 
2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 2634, 2635, 
2636, 2637, 2638, 2639, 2640, 2641, 2642, 2643, 2644, 2645, 
2646, 2647, 2648, 2649, 2650, 2651, 2652, 2653, 2654, 2655, 
2656, 2657, 2658, 2659, 2660, 2661, 2662, 2663, 2664, 2665, 
2666, 2667, 2668, 2669, 2670, 2671, 2672, 2673, 2674, 2675, 
2676, 2677, 2678, 2679, 2680, 2681, 2682, 2683, 2684, 2685, 
2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 2695, 
2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 2705, 
2706, 2707, 2708, 2709, 2710, 2711, 2712, 2713, 2714, 2715, 
2716, 2717, 2718, 2719, 2720, 2721, 2722, 2723, 2724, 2725, 
2726, 2727, 2728, 2729, 2730, 2731, 2732, 2733, 2734, 2735, 
2736, 2737, 2738, 2739, 2740, 2741, 2742, 2743, 2744, 2745, 
2746, 2747, 2748, 2749, 2750, 2751, 2752, 2753, 2754, 2755, 
2756, 2757, 2758, 2759, 2760, 2761, 2762, 2763, 2764, 2765, 
2766, 2767, 2768, 2769, 2770, 2771, 2772, 2773, 2774, 2775, 
2776, 2777, 2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 
2786, 2787, 2788, 2789, 2790, 2791, 2792, 2793, 2794, 2795, 
2796, 2797, 2798, 2799, 2800, 2801, 2802, 2803, 2804, 2805, 
2806, 2807, 2808, 2809, 2810, 2811, 2812, 2813, 2814, 2815, 
2816, 2817, 2818, 2819, 2820, 2821, 2822, 2823, 2824, 2825, 
2826, 2827, 2828, 2829, 2830, 2831, 2832, 2833, 2834, 2835, 
2836, 2837, 2838, 2839, 2840, 2841, 2842, 2843, 2844, 2845, 
2846, 2847, 2848, 2849, 2850, 2851, 2852, 2853, 2854, 2855, 
2856, 2857, 2858, 2859, 2860, 2861, 2862, 2863, 2864, 2865, 
2866, 2867, 2868, 2869, 2870, 2871, 2872, 2873, 2874, 2875, 
2876, 2877, 2878, 2879, 2880, 2881, 2882, 2883, 2884, 2885, 
2886, 2887, 2888, 2889, 2890, 2891, 2892, 2893, 2894, 2895, 
2896, 2897, 2898, 2899, 2900, 2901, 2902, 2903, 2904, 2905, 
2906, 2907, 2908, 2909, 2910, 2911, 2912, 2913, 2914, 2915, 
2916, 2917, 2918, 2919, 2920, 2921, 2922, 2923, 2924, 2925, 
2926, 2927, 2928, 2929, 2930, 2931, 2932, 2933, 2934, 2935, 
2936, 2937, 2938, 2939, 2940, 2941, 2942, 2943, 2944, 2945, 
2946, 2947, 2948, 2949, 2950, 2951, 2952, 2953, 2954, 2955, 
2956, 2957, 2958, 2959, 2960, 2961, 2962, 2963, 2964, 2965, 
2966, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 2975, 
2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 2985, 
2986, 2987, 2988, 2989, 2990, 2991, 2992, 2993, 2994, 2995, 
2996, 2997, 2998, 2999, 3000, 3001, 3002, 3003, 3004, 3005, 
3006, 3007, 3008, 3009, 3010, 3011, 3012, 3013, 3014, 3015, 
3016, 3017, 3018, 3019, 3020, 3021, 3022, 3023, 3024, 3025, 
3026, 3027, 3028, 3029, 3030, 3031, 3032, 3033, 3034, 3035, 
3036, 3037, 3038, 3039, 3040, 3041, 3042, 3043, 3044, 3045, 
3046, 3047, 3048, 3049, 3050, 3051, 3052, 3053, 3054, 3055, 
3056, 3057, 3058, 3059, 3060, 3061, 3062, 3063, 3064, 3065, 
3066, 3067, 3068, 3069, 3070, 3071, 3072, 3073, 3074, 3075, 
3076, 3077, 3078, 3079, 3080, 3081, 3082, 3083, 3084, 3085, 
3086, 3087, 3088, 3089, 3090, 3091, 3092, 3093, 3094, 3095, 
3096, 3097, 3098, 3099, 3100, 3101, 3102, 3103, 3104, 3105, 
3106, 3107, 3108, 3109, 3110, 3111, 3112, 3113, 3114, 3115, 
3116, 3117, 3118, 3119, 3120, 3121, 3122, 3123, 3124, 3125, 
3126, 3127, 3128, 3129, 3130, 3131, 3132, 3133, 3134, 3135, 
3136, 3137, 3138, 3139, 3140, 3141, 3142, 3143, 3144, 3145, 
3146, 3147, 3148, 3149, 3150, 3151, 3152, 3153, 3154, 3155, 
3156, 3157, 3158, 3159, 3160, 3161, 3162, 3163, 3164, 3165, 
3166, 3167, 3168, 3169, 3170, 3171, 3172, 3173, 3174, 3175, 
3176, 3177, 3178, 3179, 3180, 3181, 3182, 3183, 3184, 3185, 
3186, 3187, 3188, 3189, 3190, 3191, 3192, 3193, 3194, 3195, 
3196, 3197, 3198, 3199, 3200, 3201, 3202, 3203, 3204, 3205, 
3206, 3207, 3208, 3209, 3210, 3211, 3212, 3213, 3214, 3215, 
3216, 3217, 3218, 3219, 3220, 3221, 3222, 3223, 3224, 3225, 
3226, 3227, 3228, 3229, 3230, 3231, 3232, 3233, 3234, 3235, 
3236, 3237, 3238, 3239, 3240, 3241, 3242, 3243, 3244, 3245, 
3246, 3247, 3248, 3249, 3250, 3251, 3252, 3253, 3254, 3255, 
3256, 3257, 3258, 3259, 3260, 3261, 3262, 3263, 3264, 3265, 
3266, 3267, 3268, 3269, 3270, 3271, 3272, 3273, 3274, 3275, 
3276, 3277, 3278, 3279, 3280, 3281, 3282, 3283, 3284, 3285, 
3286, 3287, 3288, 3289, 3290, 
*ELSET,ELSET=TO
2281, 2282, 2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 
2291, 2292, 2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 
2301, 2302, 2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 
2311, 2312, 2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 
2321, 2322, 2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 
2331, 2332, 2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 
2341, 2342, 2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 
2351, 2352, 2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 
2361, 2362, 2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 
2371, 2372, 2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 
2381, 2382, 2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 
2391, 2392, 2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 
2401, 2402, 2403, 2404, 2405, 2586, 2587, 2588, 2589, 2590, 
2591, 2592, 2593, 2594, 2595, 2596, 2597, 2598, 2599, 2600, 
2601, 2602, 2603, 2604, 2605, 2606, 2607, 2608, 2609, 2610, 
2611, 2612, 2613, 2614, 2615, 2616, 2617, 2618, 2619, 2620, 
2621, 2622, 2623, 2624, 2625, 2626, 2627, 2628, 2629, 2630, 
2631, 2632, 2633, 2634, 2635, 2636, 2637, 2638, 2639, 2640, 
2641, 2642, 2643, 2644, 2645, 2646, 2647, 2648, 2649, 2650, 
2651, 2652, 2653, 2654, 2655, 2656, 2657, 2658, 2659, 2660, 
2661, 2662, 2663, 2664, 2665, 2666, 2667, 2668, 2669, 2670, 
2671, 2672, 2673, 2674, 2675, 2676, 2677, 2678, 2679, 2680, 
2681, 2682, 2683, 2684, 2685, 2686, 2687, 2688, 2689, 2690, 
2691, 2692, 2693, 2694, 2695, 2696, 2697, 2698, 2699, 2700, 
2701, 2702, 2703, 2704, 2705, 2706, 2707, 2708, 2709, 2710, 
2806, 2807, 2808, 2809, 2810, 2811, 2812, 2813, 2814, 2815, 
2816, 2817, 2818, 2819, 2820, 2821, 2822, 2823, 2824, 2825, 
2826, 2827, 2828, 2829, 2830, 2831, 2832, 2833, 2834, 2835, 
2836, 2837, 2838, 2839, 2840, 2841, 2842, 2843, 2844, 2845, 
2846, 2847, 2848, 2849, 2850, 2851, 2852, 2853, 2854, 2855, 
2856, 2857, 2858, 2859, 2860, 2861, 2862, 2863, 2864, 2865, 
2866, 2867, 2868, 2869, 2870, 2871, 2872, 2873, 2874, 2875, 
2876, 2877, 2878, 2879, 2880, 2881, 2882, 2883, 2884, 2885, 
2886, 2887, 2888, 2889, 2890, 2891, 2892, 2893, 2894, 2895, 
2896, 2897, 2898, 2899, 2900, 2901, 2902, 2903, 2904, 2905, 
2906, 2907, 2908, 2909, 2910, 2911, 2912, 2913, 2914, 2915, 
*ELSET,ELSET=Ceramic
2916, 2917, 2918, 2919, 2920, 2921, 2922, 2923, 2924, 2925, 
2926, 2927, 2928, 2929, 2930, 2931, 2932, 2933, 2934, 2935, 
2936, 2937, 2938, 2939, 2940, 2941, 2942, 2943, 2944, 2945, 
2946, 2947, 2948, 2949, 2950, 2951, 2952, 2953, 2954, 2955, 
2956, 2957, 2958, 2959, 2960, 2961, 2962, 2963, 2964, 2965, 
2966, 2967, 2968, 2969, 2970, 2971, 2972, 2973, 2974, 2975, 
2976, 2977, 2978, 2979, 2980, 2981, 2982, 2983, 2984, 2985, 
2986, 2987, 2988, 2989, 2990, 2991, 2992, 2993, 2994, 2995, 
2996, 2997, 2998, 2999, 3000, 3001, 3002, 3003, 3004, 3005, 
3006, 3007, 3008, 3009, 3010, 3011, 3012, 3013, 3014, 3015, 
3016, 3017, 3018, 3019, 3020, 3021, 3022, 3023, 3024, 3025, 
3026, 3027, 3028, 3029, 3030, 3031, 3032, 3033, 3034, 3035, 
3036, 3037, 3038, 3039, 3040, 3041, 3042, 3043, 3044, 3045, 
3046, 3047, 3048, 3049, 3050, 3051, 3052, 3053, 3054, 3055, 
3056, 3057, 3058, 3059, 3060, 3061, 3062, 3063, 3064, 3065, 
3066, 3067, 3068, 3069, 3070, 3071, 3072, 3073, 3074, 3075, 
3076, 3077, 3078, 3079, 3080, 3081, 3082, 3083, 3084, 3085, 
3086, 3087, 3088, 3089, 3090, 3091, 3092, 3093, 3094, 3095, 
3096, 3097, 3098, 3099, 3100, 3101, 3102, 3103, 3104, 3105, 
3106, 3107, 3108, 3109, 3110, 3111, 3112, 3113, 3114, 3115, 
3116, 3117, 3118, 3119, 3120, 3121, 3122, 3123, 3124, 3125, 
3126, 3127, 3128, 3129, 3130, 3131, 3132, 3133, 3134, 3135, 
3136, 3137, 3138, 3139, 3140, 3141, 3142, 3143, 3144, 3145, 
3146, 3147, 3148, 3149, 3150, 3151, 3152, 3153, 3154, 3155, 
3156, 3157, 3158, 3159, 3160, 3161, 3162, 3163, 3164, 3165, 
3166, 3167, 3168, 3169, 3170, 3171, 3172, 3173, 3174, 3175, 
3176, 3177, 3178, 3179, 3180, 3181, 3182, 3183, 3184, 3185, 
3186, 3187, 3188, 3189, 3190, 3191, 3192, 3193, 3194, 3195, 
3196, 3197, 3198, 3199, 3200, 3201, 3202, 3203, 3204, 3205, 
3206, 3207, 3208, 3209, 3210, 3211, 3212, 3213, 3214, 3215, 
3216, 3217, 3218, 3219, 3220, 3221, 3222, 3223, 3224, 3225, 
3226, 3227, 3228, 3229, 3230, 3231, 3232, 3233, 3234, 3235, 
3236, 3237, 3238, 3239, 3240, 3241, 3242, 3243, 3244, 3245, 
3246, 3247, 3248, 3249, 3250, 3251, 3252, 3253, 3254, 3255, 
3256, 3257, 3258, 3259, 3260, 3261, 3262, 3263, 3264, 3265, 
3266, 3267, 3268, 3269, 3270, 3271, 3272, 3273, 3274, 3275, 
3276, 3277, 3278, 3279, 3280, 3281, 3282, 3283, 3284, 3285, 
3286, 3287, 3288, 3289, 3290, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 351, 352, 353, 
354, 355, 356, 357, 358, 359, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 386, 387, 388, 389, 390, 399, 
400, 401, 402, 403, 416, 417, 418, 419, 420, 421, 
422, 423, 424, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 476, 477, 478, 479, 480, 481, 482, 483, 484, 
1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 1883, 1884, 
1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 1893, 1894, 
1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 1903, 1904, 
1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 1913, 1914, 
1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 1923, 1924, 
1925, 1926, 1927, 1928, 1929, 1930, 1979, 1980, 1981, 1982, 
1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 
1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 
2003, 2004, 2005, 2006, 2007, 2008, 2116, 2117, 2118, 2119, 
2120, 2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 
2130, 2131, 2132, 2133, 2134, 2135, 2136, 2137, 2138, 2139, 
2140, 2141, 2142, 2143, 2144, 2145, 2146, 2147, 2148, 2149, 
2150, 2151, 2152, 2153, 2154, 2155, 2156, 2157, 2158, 2159, 
2160, 2161, 2162, 2163, 2164, 2165, 2166, 2167, 2168, 2169, 
2170, 2171, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 97, 98, 
99, 100, 101, 102, 103, 104, 105, 121, 122, 123, 
124, 125, 126, 127, 128, 129, 145, 146, 147, 148, 
149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 
159, 160, 161, 162, 643, 644, 645, 646, 647, 648, 
649, 650, 651, 658, 659, 660, 661, 662, 663, 664, 
665, 666, 667, 668, 669, 670, 671, 672, 673, 674, 
675, 676, 677, 678, 679, 680, 681, 682, 683, 684, 
1237, 1238, 1239, 1240, 1241, 1242, 1243, 1244, 1245, 1246, 
1247, 1248, 1249, 1250, 1251, 1252, 1253, 1254, 1255, 1256, 
1257, 1258, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 
1267, 1268, 1269, 1270, 1271, 1272, 1273, 1274, 1275, 1276, 
1277, 1278, 1279, 1280, 1281, 1282, 1283, 1284, 1285, 1286, 
1287, 1288, 1289, 1290, 1291, 1292, 2681, 2682, 2683, 2684, 
2685, 2686, 2687, 2688, 2689, 2690, 2691, 2692, 2693, 2694, 
2695, 2696, 2697, 2698, 2699, 2700, 2701, 2702, 2703, 2704, 
2705, 2706, 2707, 2708, 2709, 2710, 2711, 2712, 2713, 2714, 
2715, 2716, 2717, 2718, 2719, 2720, 2721, 2722, 2723, 2724, 
2725, 2726, 2727, 2728, 2729, 2730, 2731, 2732, 2733, 2734, 
2735, 2736, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 687, 688, 689, 692, 693, 694, 
695, 696, 697, 698, 699, 700, 701, 702, 703, 704, 
705, 706, 707, 708, 709, 710, 711, 712, 2747, 2748, 
2749, 2750, 2751, 2752, 2753, 2754, 2755, 2756, 2757, 2758, 
2759, 2760, 2761, 2762, 2763, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 725, 726, 727, 729, 730, 731, 732, 
733, 734, 735, 736, 737, 738, 739, 740, 2774, 2775, 
2776, 2777, 2778, 2779, 2780, 2781, 2782, 2783, 2784, 2785, 
2786, 2787, 2788, 2789, 2790, 
*NSET,NSET=Force
18, 20, 22, 24, 324, 325, 326, 327, 328, 329, 
330, 331, 332, 336, 337, 338, 360, 361, 362, 372, 
373, 374, 375, 376, 377, 378, 379, 380, 1858, 1859, 
1860, 1861, 1862, 1863, 1864, 1865, 1866, 1867, 1868, 1869, 
1870, 1871, 1872, 1873, 1874, 
*NSET,NSET=Ceramic_Top
77, 78, 79, 80, 81, 82, 83, 84, 937, 938, 
939, 940, 941, 942, 943, 944, 945, 951, 952, 953, 
954, 955, 956, 957, 958, 959, 965, 966, 967, 968, 
969, 970, 971, 972, 973, 974, 975, 976, 977, 978, 
979, 980, 981, 982, 988, 989, 990, 991, 992, 998, 
999, 1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 
1009, 1010, 1011, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 
1024, 1025, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 
1039, 1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 
3215, 3216, 3217, 3218, 3219, 3220, 3221, 3222, 3223, 3224, 
3225, 3226, 3227, 3228, 3229, 3230, 3231, 3232, 3233, 3234, 
3235, 3236, 3237, 3238, 3239, 3240, 3241, 3242, 3243, 3244, 
3245, 3246, 3247, 3248, 3249, 3250, 3251, 3252, 3253, 3254, 
3255, 3256, 3257, 3258, 3259, 3260, 3261, 3262, 3263, 3264, 
3265, 3266, 3267, 3268, 3269, 3270, 3333, 3334, 3335, 3336, 
3337, 3338, 3339, 3340, 3341, 3342, 3343, 3344, 3345, 3346, 
3347, 3348, 3349, 3350, 3351, 3352, 3353, 3354, 3355, 3356, 
3357, 3358, 3359, 3360, 3361, 3362, 3453, 3454, 3455, 3456, 
3457, 3458, 3459, 3460, 3461, 3462, 3463, 3464, 3465, 3466, 
3467, 3468, 3469, 3470, 3471, 3472, 3473, 3474, 3475, 3476, 
3477, 3478, 3479, 3480, 3481, 3482, 3483, 3484, 3485, 3486, 
3487, 3488, 3489, 3490, 3491, 3492, 3493, 3494, 3495, 3496, 
3497, 3498, 3499, 3500, 3501, 3502, 3503, 3504, 3505, 3506, 
3507, 3508, 
*NSET,NSET=Ceramic_Bottom
23, 26, 79, 81, 85, 86, 87, 88, 91, 92, 
93, 94, 386, 387, 388, 389, 390, 946, 947, 948, 
949, 950, 983, 984, 985, 986, 987, 988, 989, 990, 
991, 992, 1059, 1060, 1061, 1062, 1063, 1064, 1065, 1066, 
1067, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 
1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 1096, 
1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 1136, 1137, 
1138, 1139, 1140, 1141, 1142, 1143, 1144, 1155, 1156, 1157, 
1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 1167, 
1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 1177, 
1178, 1179, 1180, 1181, 3271, 3272, 3273, 3274, 3275, 3276, 
3277, 3278, 3279, 3280, 3281, 3282, 3283, 3284, 3285, 3286, 
3629, 3630, 3631, 3632, 3633, 3634, 3635, 3636, 3637, 3638, 
3639, 3640, 3641, 3642, 3643, 3644, 3645, 3646, 3647, 3648, 
3649, 3650, 3651, 3652, 3653, 3654, 3655, 3656, 3657, 3658, 
3659, 3660, 3661, 3662, 3663, 3664, 3665, 3666, 3667, 3668, 
3669, 3670, 3671, 3672, 3673, 3674, 3675, 3676, 3677, 3678, 
3679, 3680, 3681, 3682, 3683, 3684, 3843, 3844, 3845, 3846, 
3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 3856, 
3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 3866, 
3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 3876, 
3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 3886, 
3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 3896, 
3897, 3898, 
*NSET,NSET=Top_Semiconductors
13, 14, 15, 16, 33, 34, 35, 36, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 257, 258, 259, 
260, 261, 262, 263, 264, 265, 275, 276, 277, 278, 
279, 280, 281, 282, 283, 284, 285, 286, 287, 288, 
289, 290, 291, 292, 487, 488, 489, 490, 491, 492, 
493, 494, 495, 498, 499, 500, 501, 502, 503, 504, 
505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 
515, 516, 517, 518, 519, 520, 521, 522, 523, 524, 
1679, 1680, 1681, 1682, 1683, 1684, 1685, 1686, 1687, 1688, 
1689, 1690, 1691, 1692, 1693, 1694, 1695, 1696, 1697, 1698, 
1699, 1700, 1701, 1702, 1703, 1704, 1705, 1706, 1707, 1708, 
1709, 1710, 1711, 1712, 1713, 1714, 1715, 1716, 1717, 1718, 
1719, 1720, 1721, 1722, 1723, 1724, 1725, 1726, 1727, 1728, 
1729, 1730, 1731, 1732, 1733, 1734, 2205, 2206, 2207, 2208, 
2209, 2210, 2211, 2212, 2213, 2214, 2215, 2216, 2217, 2218, 
2219, 2220, 2221, 2222, 2223, 2224, 2225, 2226, 2227, 2228, 
2229, 2230, 2231, 2232, 2233, 2234, 2235, 2236, 2237, 2238, 
2239, 2240, 2241, 2242, 2243, 2244, 2245, 2246, 2247, 2248, 
2249, 2250, 2251, 2252, 2253, 2254, 2255, 2256, 2257, 2258, 
2259, 2260, 
*NSET,NSET=top
77, 78, 79, 80, 81, 82, 83, 84, 937, 938, 
939, 940, 941, 942, 943, 944, 945, 951, 952, 953, 
954, 955, 956, 957, 958, 959, 965, 966, 967, 968, 
969, 970, 971, 972, 973, 974, 975, 976, 977, 978, 
979, 980, 981, 982, 988, 989, 990, 991, 992, 998, 
999, 1000, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008, 
1009, 1010, 1011, 1017, 1018, 1019, 1020, 1021, 1022, 1023, 
1024, 1025, 1031, 1032, 1033, 1034, 1035, 1036, 1037, 1038, 
1039, 1040, 1041, 1042, 1043, 1044, 1045, 1046, 1047, 1048, 
3215, 3216, 3217, 3218, 3219, 3220, 3221, 3222, 3223, 3224, 
3225, 3226, 3227, 3228, 3229, 3230, 3231, 3232, 3233, 3234, 
3235, 3236, 3237, 3238, 3239, 3240, 3241, 3242, 3243, 3244, 
3245, 3246, 3247, 3248, 3249, 3250, 3251, 3252, 3253, 3254, 
3255, 3256, 3257, 3258, 3259, 3260, 3261, 3262, 3263, 3264, 
3265, 3266, 3267, 3268, 3269, 3270, 3333, 3334, 3335, 3336, 
3337, 3338, 3339, 3340, 3341, 3342, 3343, 3344, 3345, 3346, 
3347, 3348, 3349, 3350, 3351, 3352, 3353, 3354, 3355, 3356, 
3357, 3358, 3359, 3360, 3361, 3362, 3453, 3454, 3455, 3456, 
3457, 3458, 3459, 3460, 3461, 3462, 3463, 3464, 3465, 3466, 
3467, 3468, 3469, 3470, 3471, 3472, 3473, 3474, 3475, 3476, 
3477, 3478, 3479, 3480, 3481, 3482, 3483, 3484, 3485, 3486, 
3487, 3488, 3489, 3490, 3491, 3492, 3493, 3494, 3495, 3496, 
3497, 3498, 3499, 3500, 3501, 3502, 3503, 3504, 3505, 3506, 
3507, 3508, 
*NSET,NSET=bottom
85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 
95, 96, 1059, 1060, 1061, 1062, 1063, 1064, 1065, 1066, 
1067, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 
1087, 1088, 1089, 1090, 1091, 1092, 1093, 1094, 1095, 1096, 
1097, 1098, 1099, 1100, 1101, 1102, 1103, 1104, 1110, 1116, 
1117, 1118, 1119, 1120, 1121, 1122, 1123, 1124, 1125, 1136, 
1137, 1138, 1139, 1140, 1141, 1142, 1143, 1144, 1155, 1156, 
1157, 1158, 1159, 1160, 1161, 1162, 1163, 1164, 1165, 1166, 
1167, 1168, 1169, 1170, 1171, 1172, 1173, 1174, 1175, 1176, 
1177, 1178, 1179, 1180, 1181, 1187, 1193, 1194, 1195, 1196, 
1197, 1198, 1199, 1200, 1201, 1202, 3629, 3630, 3631, 3632, 
3633, 3634, 3635, 3636, 3637, 3638, 3639, 3640, 3641, 3642, 
3643, 3644, 3645, 3646, 3647, 3648, 3649, 3650, 3651, 3652, 
3653, 3654, 3655, 3656, 3657, 3658, 3659, 3660, 3661, 3662, 
3663, 3664, 3665, 3666, 3667, 3668, 3669, 3670, 3671, 3672, 
3673, 3674, 3675, 3676, 3677, 3678, 3679, 3680, 3681, 3682, 
3683, 3684, 3719, 3720, 3721, 3722, 3843, 3844, 3845, 3846, 
3847, 3848, 3849, 3850, 3851, 3852, 3853, 3854, 3855, 3856, 
3857, 3858, 3859, 3860, 3861, 3862, 3863, 3864, 3865, 3866, 
3867, 3868, 3869, 3870, 3871, 3872, 3873, 3874, 3875, 3876, 
3877, 3878, 3879, 3880, 3881, 3882, 3883, 3884, 3885, 3886, 
3887, 3888, 3889, 3890, 3891, 3892, 3893, 3894, 3895, 3896, 
3897, 3898, 3933, 3934, 3935, 3936, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 
177, 178, 179, 180, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 305, 306, 307, 308, 309, 310, 311, 
312, 313, 315, 316, 317, 318, 319, 320, 321, 322, 
323, 324, 325, 326, 327, 328, 329, 330, 331, 332, 
333, 334, 335, 336, 337, 338, 339, 340, 341, 342, 
343, 344, 345, 346, 347, 348, 349, 350, 351, 352, 
353, 354, 355, 356, 357, 358, 359, 360, 361, 362, 
363, 364, 365, 366, 367, 368, 369, 370, 371, 372, 
373, 374, 375, 376, 377, 378, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 401, 402, 
403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 
413, 414, 415, 416, 417, 418, 419, 420, 421, 422, 
423, 424, 425, 426, 427, 428, 429, 430, 431, 432, 
433, 434, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 471, 472, 
473, 474, 475, 476, 477, 478, 479, 480, 481, 482, 
483, 484, 599, 600, 601, 602, 603, 604, 605, 606, 
607, 610, 611, 612, 613, 614, 615, 616, 617, 618, 
619, 620, 621, 622, 623, 624, 625, 626, 627, 628, 
