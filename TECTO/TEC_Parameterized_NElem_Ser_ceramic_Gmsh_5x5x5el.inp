*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Ser_ceramic_Gmsh_5x5x5el.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.05, 0.5
4, 0, 0.05, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.05, 0.5
8, 1, 0.05, 0
9, 1, 0.1, 0
10, 0, 0.1, 0
11, 1, 0.1, 0.5
12, 0, 0.1, 0.5
13, 1, 1.3, 0
14, 0, 1.3, 0
15, 1, 1.3, 0.5
16, 0, 1.3, 0.5
17, 1, 1.35, 0
18, 0, 1.35, 0
19, 1, 1.35, 0.5
20, 0, 1.35, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.35, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.35, 0
28, 1.2, 1.4, 0
29, 2.2, 1.35, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.35, 0
32, 2.2, 1.4, 0
33, 1.2, 1.3, 0.5
34, 2.2, 1.3, 0.5
35, 1.2, 1.3, 0
36, 2.2, 1.3, 0
37, 1.2, 0.1, 0.5
38, 2.2, 0.1, 0.5
39, 1.2, 0.1, 0
40, 2.2, 0.1, 0
41, 1.2, 0.05, 0.5
42, 2.2, 0.05, 0.5
43, 1.2, 0.05, 0
44, 2.2, 0.05, 0
45, 1.2, -8.3266726846887e-17, 0.5
46, 2.2, -8.3266726846887e-17, 0.5
47, 1.2, -8.3266726846887e-17, 0
48, 2.2, -8.3266726846887e-17, 0
49, 2.3, 0.05, 0.5
50, 2.3, -8.3266726846887e-17, 0.5
51, 2.3, 0.05, 0
52, 2.3, -8.3266726846887e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.05, 0.5
56, -0.1, 0.05, 0
57, 1.05, 0.1, 0.5
58, 1.05, 1.3, 0.5
59, 1.05, 0.1, 0
60, 1.05, 1.3, 0
61, 1.15, 1.3, 0.5
62, 1.15, 0.1, 0.5
63, 1.15, 1.3, 0
64, 1.15, 0.1, 0
65, 1, 0.1, -0.1
66, 1, 1.3, -0.1
67, 0, 0.1, -0.1
68, 0, 1.3, -0.1
69, 1.2, 1.3, -0.1
70, 1.2, 0.1, -0.1
71, 2.2, 1.3, -0.1
72, 2.2, 0.1, -0.1
73, 1.15, 1.3, -0.1
74, 1.15, 0.1, -0.1
75, 1.05, 0.1, -0.1
76, 1.05, 1.3, -0.1
77, 1, 1.6, 0
78, 0, 1.6, 0
79, 1, 1.6, 0.5
80, 0, 1.6, 0.5
81, 1.2, 1.6, 0.5
82, 1.2, 1.6, 0
83, 2.2, 1.6, 0.5
84, 2.2, 1.6, 0
85, 1, -0.2, 0
86, 0, -0.2, 0
87, 1, -0.2, 0.5
88, 0, -0.2, 0.5
89, -0.1, -0.2, 0.5
90, -0.1, -0.2, 0
91, 1.2, -0.2, 0.5
92, 2.2, -0.2, 0.5
93, 1.2, -0.2, 0
94, 2.2, -0.2, 0
95, 2.3, -0.2, 0.5
96, 2.3, -0.2, 0
97, 0, 0, 0.1
98, 0, 0, 0.2
99, 0, 0, 0.3
100, 0, 0, 0.4
101, 0, 0, 0.05
102, 0, 0, 0.15
103, 0, 0, 0.25
104, 0, 0, 0.35
105, 0, 0, 0.45
106, 0, 0.025, 0.5
107, 0, 0.0125, 0.5
108, 0, 0.0375, 0.5
109, 0, 0.05, 0.1
110, 0, 0.05, 0.2
111, 0, 0.05, 0.3
112, 0, 0.05, 0.4
113, 0, 0.05, 0.05
114, 0, 0.05, 0.15
115, 0, 0.05, 0.25
116, 0, 0.05, 0.35
117, 0, 0.05, 0.45
118, 0, 0.025, 0
119, 0, 0.0125, 0
120, 0, 0.0375, 0
121, 1, 0, 0.1
122, 1, 0, 0.2
123, 1, 0, 0.3
124, 1, 0, 0.4
125, 1, 0, 0.05
126, 1, 0, 0.15
127, 1, 0, 0.25
128, 1, 0, 0.35
129, 1, 0, 0.45
130, 1, 0.025, 0.5
131, 1, 0.0125, 0.5
132, 1, 0.0375, 0.5
133, 1, 0.05, 0.1
134, 1, 0.05, 0.2
135, 1, 0.05, 0.3
136, 1, 0.05, 0.4
137, 1, 0.05, 0.05
138, 1, 0.05, 0.15
139, 1, 0.05, 0.25
140, 1, 0.05, 0.35
141, 1, 0.05, 0.45
142, 1, 0.025, 0
143, 1, 0.0125, 0
144, 1, 0.0375, 0
145, 0.2, 0, 0
146, 0.4, 0, 0
147, 0.6, 0, 0
148, 0.8, 0, 0
149, 0.1, 0, 0
150, 0.3, 0, 0
151, 0.5, 0, 0
152, 0.7, 0, 0
153, 0.9, 0, 0
154, 0.2, 0, 0.5
155, 0.4, 0, 0.5
156, 0.6, 0, 0.5
157, 0.8, 0, 0.5
158, 0.1, 0, 0.5
159, 0.3, 0, 0.5
160, 0.5, 0, 0.5
161, 0.7, 0, 0.5
162, 0.9, 0, 0.5
163, 0.2, 0.05, 0
164, 0.4, 0.05, 0
165, 0.6, 0.05, 0
166, 0.8, 0.05, 0
167, 0.1, 0.05, 0
168, 0.3, 0.05, 0
169, 0.5, 0.05, 0
170, 0.7, 0.05, 0
171, 0.9, 0.05, 0
172, 0.2, 0.05, 0.5
173, 0.4, 0.05, 0.5
174, 0.6, 0.05, 0.5
175, 0.8, 0.05, 0.5
176, 0.1, 0.05, 0.5
177, 0.3, 0.05, 0.5
178, 0.5, 0.05, 0.5
179, 0.7, 0.05, 0.5
180, 0.9, 0.05, 0.5
181, 1, 0.075, 0
182, 0, 0.075, 0
183, 0.2, 0.1, 0
184, 0.4, 0.1, 0
185, 0.6, 0.1, 0
186, 0.8, 0.1, 0
187, 0.1, 0.1, 0
188, 0.3, 0.1, 0
189, 0.5, 0.1, 0
190, 0.7, 0.1, 0
191, 0.9, 0.1, 0
192, 1, 0.075, 0.5
193, 1, 0.1, 0.1
194, 1, 0.1, 0.2
195, 1, 0.1, 0.3
196, 1, 0.1, 0.4
197, 1, 0.1, 0.05
198, 1, 0.1, 0.15
199, 1, 0.1, 0.25
200, 1, 0.1, 0.35
201, 1, 0.1, 0.45
202, 0, 0.075, 0.5
203, 0.2, 0.1, 0.5
204, 0.4, 0.1, 0.5
205, 0.6, 0.1, 0.5
206, 0.8, 0.1, 0.5
207, 0.1, 0.1, 0.5
208, 0.3, 0.1, 0.5
209, 0.5, 0.1, 0.5
210, 0.7, 0.1, 0.5
211, 0.9, 0.1, 0.5
212, 0, 0.1, 0.1
213, 0, 0.1, 0.2
214, 0, 0.1, 0.3
215, 0, 0.1, 0.4
216, 0, 0.1, 0.05
217, 0, 0.1, 0.15
218, 0, 0.1, 0.25
219, 0, 0.1, 0.35
220, 0, 0.1, 0.45
221, 1, 0.34, 0
222, 1, 0.58, 0
223, 1, 0.82, 0
224, 1, 1.06, 0
225, 1, 0.22, 0
226, 1, 0.46, 0
227, 1, 0.7, 0
228, 1, 0.94, 0
229, 1, 1.18, 0
230, 0, 0.34, 0
231, 0, 0.58, 0
232, 0, 0.82, 0
233, 0, 1.06, 0
234, 0, 0.22, 0
235, 0, 0.46, 0
236, 0, 0.7, 0
237, 0, 0.94, 0
238, 0, 1.18, 0
239, 0.2, 1.3, 0
240, 0.4, 1.3, 0
241, 0.6, 1.3, 0
242, 0.8, 1.3, 0
243, 0.1, 1.3, 0
244, 0.3, 1.3, 0
245, 0.5, 1.3, 0
246, 0.7, 1.3, 0
247, 0.9, 1.3, 0
248, 1, 0.34, 0.5
249, 1, 0.58, 0.5
250, 1, 0.82, 0.5
251, 1, 1.06, 0.5
252, 1, 0.22, 0.5
253, 1, 0.46, 0.5
254, 1, 0.7, 0.5
255, 1, 0.94, 0.5
256, 1, 1.18, 0.5
257, 1, 1.3, 0.1
258, 1, 1.3, 0.2
259, 1, 1.3, 0.3
260, 1, 1.3, 0.4
261, 1, 1.3, 0.05
262, 1, 1.3, 0.15
263, 1, 1.3, 0.25
264, 1, 1.3, 0.35
265, 1, 1.3, 0.45
266, 0, 0.34, 0.5
267, 0, 0.58, 0.5
268, 0, 0.82, 0.5
269, 0, 1.06, 0.5
270, 0, 0.22, 0.5
271, 0, 0.46, 0.5
272, 0, 0.7, 0.5
273, 0, 0.94, 0.5
274, 0, 1.18, 0.5
275, 0.2, 1.3, 0.5
276, 0.4, 1.3, 0.5
277, 0.6, 1.3, 0.5
278, 0.8, 1.3, 0.5
279, 0.1, 1.3, 0.5
280, 0.3, 1.3, 0.5
281, 0.5, 1.3, 0.5
282, 0.7, 1.3, 0.5
283, 0.9, 1.3, 0.5
284, 0, 1.3, 0.1
285, 0, 1.3, 0.2
286, 0, 1.3, 0.3
287, 0, 1.3, 0.4
288, 0, 1.3, 0.05
289, 0, 1.3, 0.15
290, 0, 1.3, 0.25
291, 0, 1.3, 0.35
292, 0, 1.3, 0.45
293, 1, 1.325, 0
294, 0, 1.325, 0
295, 0.2, 1.35, 0
296, 0.4, 1.35, 0
297, 0.6, 1.35, 0
298, 0.8, 1.35, 0
299, 0.1, 1.35, 0
300, 0.3, 1.35, 0
301, 0.5, 1.35, 0
302, 0.7, 1.35, 0
303, 0.9, 1.35, 0
304, 1, 1.325, 0.5
305, 1, 1.35, 0.1
306, 1, 1.35, 0.2
307, 1, 1.35, 0.3
308, 1, 1.35, 0.4
309, 1, 1.35, 0.05
310, 1, 1.35, 0.15
311, 1, 1.35, 0.25
312, 1, 1.35, 0.35
313, 1, 1.35, 0.45
314, 0, 1.325, 0.5
315, 0.2, 1.35, 0.5
316, 0.4, 1.35, 0.5
317, 0.6, 1.35, 0.5
318, 0.8, 1.35, 0.5
319, 0.1, 1.35, 0.5
320, 0.3, 1.35, 0.5
321, 0.5, 1.35, 0.5
322, 0.7, 1.35, 0.5
323, 0.9, 1.35, 0.5
324, 0, 1.35, 0.1
325, 0, 1.35, 0.2
326, 0, 1.35, 0.3
327, 0, 1.35, 0.4
328, 0, 1.35, 0.05
329, 0, 1.35, 0.15
330, 0, 1.35, 0.25
331, 0, 1.35, 0.35
332, 0, 1.35, 0.45
333, 1, 1.375, 0
334, 1, 1.3625, 0
335, 1, 1.3875, 0
336, 0, 1.375, 0
337, 0, 1.3625, 0
338, 0, 1.3875, 0
339, 0.2, 1.4, 0
340, 0.4, 1.4, 0
341, 0.6, 1.4, 0
342, 0.8, 1.4, 0
343, 0.1, 1.4, 0
344, 0.3, 1.4, 0
345, 0.5, 1.4, 0
346, 0.7, 1.4, 0
347, 0.9, 1.4, 0
348, 1, 1.375, 0.5
349, 1, 1.3625, 0.5
350, 1, 1.3875, 0.5
351, 1, 1.4, 0.1
352, 1, 1.4, 0.2
353, 1, 1.4, 0.3
354, 1, 1.4, 0.4
355, 1, 1.4, 0.05
356, 1, 1.4, 0.15
357, 1, 1.4, 0.25
358, 1, 1.4, 0.35
359, 1, 1.4, 0.45
360, 0, 1.375, 0.5
361, 0, 1.3625, 0.5
362, 0, 1.3875, 0.5
363, 0.2, 1.4, 0.5
364, 0.4, 1.4, 0.5
365, 0.6, 1.4, 0.5
366, 0.8, 1.4, 0.5
367, 0.1, 1.4, 0.5
368, 0.3, 1.4, 0.5
369, 0.5, 1.4, 0.5
370, 0.7, 1.4, 0.5
371, 0.9, 1.4, 0.5
372, 0, 1.4, 0.1
373, 0, 1.4, 0.2
374, 0, 1.4, 0.3
375, 0, 1.4, 0.4
376, 0, 1.4, 0.05
377, 0, 1.4, 0.15
378, 0, 1.4, 0.25
379, 0, 1.4, 0.35
380, 0, 1.4, 0.45
381, 1.0666666666667, 1.35, 0.5
382, 1.1333333333333, 1.35, 0.5
383, 1.0333333333333, 1.35, 0.5
384, 1.1, 1.35, 0.5
385, 1.1666666666667, 1.35, 0.5
386, 1.0666666666667, 1.4, 0.5
387, 1.1333333333333, 1.4, 0.5
388, 1.0333333333333, 1.4, 0.5
389, 1.1, 1.4, 0.5
390, 1.1666666666667, 1.4, 0.5
391, 1.2, 1.375, 0.5
392, 1.2, 1.3625, 0.5
393, 1.2, 1.3875, 0.5
394, 1.0666666666667, 1.35, 0
395, 1.1333333333333, 1.35, 0
396, 1.0333333333333, 1.35, 0
397, 1.1, 1.35, 0
398, 1.1666666666667, 1.35, 0
399, 1.0666666666667, 1.4, 0
400, 1.1333333333333, 1.4, 0
401, 1.0333333333333, 1.4, 0
402, 1.1, 1.4, 0
403, 1.1666666666667, 1.4, 0
404, 1.2, 1.375, 0
405, 1.2, 1.3625, 0
406, 1.2, 1.3875, 0
407, 1.2, 1.35, 0.1
408, 1.2, 1.35, 0.2
409, 1.2, 1.35, 0.3
410, 1.2, 1.35, 0.4
411, 1.2, 1.35, 0.05
412, 1.2, 1.35, 0.15
413, 1.2, 1.35, 0.25
414, 1.2, 1.35, 0.35
415, 1.2, 1.35, 0.45
416, 1.2, 1.4, 0.1
417, 1.2, 1.4, 0.2
418, 1.2, 1.4, 0.3
419, 1.2, 1.4, 0.4
420, 1.2, 1.4, 0.05
421, 1.2, 1.4, 0.15
422, 1.2, 1.4, 0.25
423, 1.2, 1.4, 0.35
424, 1.2, 1.4, 0.45
425, 1.4, 1.35, 0.5
426, 1.6, 1.35, 0.5
427, 1.8, 1.35, 0.5
428, 2, 1.35, 0.5
429, 1.3, 1.35, 0.5
430, 1.5, 1.35, 0.5
431, 1.7, 1.35, 0.5
432, 1.9, 1.35, 0.5
433, 2.1, 1.35, 0.5
434, 1.4, 1.4, 0.5
435, 1.6, 1.4, 0.5
436, 1.8, 1.4, 0.5
437, 2, 1.4, 0.5
438, 1.3, 1.4, 0.5
439, 1.5, 1.4, 0.5
440, 1.7, 1.4, 0.5
441, 1.9, 1.4, 0.5
442, 2.1, 1.4, 0.5
443, 2.2, 1.375, 0.5
444, 2.2, 1.3625, 0.5
445, 2.2, 1.3875, 0.5
446, 1.4, 1.35, 0
447, 1.6, 1.35, 0
448, 1.8, 1.35, 0
449, 2, 1.35, 0
450, 1.3, 1.35, 0
451, 1.5, 1.35, 0
452, 1.7, 1.35, 0
453, 1.9, 1.35, 0
454, 2.1, 1.35, 0
455, 1.4, 1.4, 0
456, 1.6, 1.4, 0
457, 1.8, 1.4, 0
458, 2, 1.4, 0
459, 1.3, 1.4, 0
460, 1.5, 1.4, 0
461, 1.7, 1.4, 0
462, 1.9, 1.4, 0
463, 2.1, 1.4, 0
464, 2.2, 1.375, 0
465, 2.2, 1.3625, 0
466, 2.2, 1.3875, 0
467, 2.2, 1.35, 0.1
468, 2.2, 1.35, 0.2
469, 2.2, 1.35, 0.3
470, 2.2, 1.35, 0.4
471, 2.2, 1.35, 0.05
472, 2.2, 1.35, 0.15
473, 2.2, 1.35, 0.25
474, 2.2, 1.35, 0.35
475, 2.2, 1.35, 0.45
476, 2.2, 1.4, 0.1
477, 2.2, 1.4, 0.2
478, 2.2, 1.4, 0.3
479, 2.2, 1.4, 0.4
480, 2.2, 1.4, 0.05
481, 2.2, 1.4, 0.15
482, 2.2, 1.4, 0.25
483, 2.2, 1.4, 0.35
484, 2.2, 1.4, 0.45
485, 1.2, 1.325, 0.5
486, 2.2, 1.325, 0.5
487, 1.4, 1.3, 0.5
488, 1.6, 1.3, 0.5
489, 1.8, 1.3, 0.5
490, 2, 1.3, 0.5
491, 1.3, 1.3, 0.5
492, 1.5, 1.3, 0.5
493, 1.7, 1.3, 0.5
494, 1.9, 1.3, 0.5
495, 2.1, 1.3, 0.5
496, 1.2, 1.325, 0
497, 2.2, 1.325, 0
498, 1.4, 1.3, 0
499, 1.6, 1.3, 0
500, 1.8, 1.3, 0
501, 2, 1.3, 0
502, 1.3, 1.3, 0
503, 1.5, 1.3, 0
504, 1.7, 1.3, 0
505, 1.9, 1.3, 0
506, 2.1, 1.3, 0
507, 1.2, 1.3, 0.1
508, 1.2, 1.3, 0.2
509, 1.2, 1.3, 0.3
510, 1.2, 1.3, 0.4
511, 1.2, 1.3, 0.05
512, 1.2, 1.3, 0.15
513, 1.2, 1.3, 0.25
514, 1.2, 1.3, 0.35
515, 1.2, 1.3, 0.45
516, 2.2, 1.3, 0.1
517, 2.2, 1.3, 0.2
518, 2.2, 1.3, 0.3
519, 2.2, 1.3, 0.4
520, 2.2, 1.3, 0.05
521, 2.2, 1.3, 0.15
522, 2.2, 1.3, 0.25
523, 2.2, 1.3, 0.35
524, 2.2, 1.3, 0.45
525, 1.2, 1.06, 0.5
526, 1.2, 0.82, 0.5
527, 1.2, 0.58, 0.5
528, 1.2, 0.34, 0.5
529, 1.2, 1.18, 0.5
530, 1.2, 0.94, 0.5
531, 1.2, 0.7, 0.5
532, 1.2, 0.46, 0.5
533, 1.2, 0.22, 0.5
534, 2.2, 1.06, 0.5
535, 2.2, 0.82, 0.5
536, 2.2, 0.58, 0.5
537, 2.2, 0.34, 0.5
538, 2.2, 1.18, 0.5
539, 2.2, 0.94, 0.5
540, 2.2, 0.7, 0.5
541, 2.2, 0.46, 0.5
542, 2.2, 0.22, 0.5
543, 1.4, 0.1, 0.5
544, 1.6, 0.1, 0.5
545, 1.8, 0.1, 0.5
546, 2, 0.1, 0.5
547, 1.3, 0.1, 0.5
548, 1.5, 0.1, 0.5
549, 1.7, 0.1, 0.5
550, 1.9, 0.1, 0.5
551, 2.1, 0.1, 0.5
552, 1.2, 1.06, 0
553, 1.2, 0.82, 0
554, 1.2, 0.58, 0
555, 1.2, 0.34, 0
556, 1.2, 1.18, 0
557, 1.2, 0.94, 0
558, 1.2, 0.7, 0
559, 1.2, 0.46, 0
560, 1.2, 0.22, 0
561, 2.2, 1.06, 0
562, 2.2, 0.82, 0
563, 2.2, 0.58, 0
564, 2.2, 0.34, 0
565, 2.2, 1.18, 0
566, 2.2, 0.94, 0
567, 2.2, 0.7, 0
568, 2.2, 0.46, 0
569, 2.2, 0.22, 0
570, 1.4, 0.1, 0
571, 1.6, 0.1, 0
572, 1.8, 0.1, 0
573, 2, 0.1, 0
574, 1.3, 0.1, 0
575, 1.5, 0.1, 0
576, 1.7, 0.1, 0
577, 1.9, 0.1, 0
578, 2.1, 0.1, 0
579, 1.2, 0.1, 0.1
580, 1.2, 0.1, 0.2
581, 1.2, 0.1, 0.3
582, 1.2, 0.1, 0.4
583, 1.2, 0.1, 0.05
584, 1.2, 0.1, 0.15
585, 1.2, 0.1, 0.25
586, 1.2, 0.1, 0.35
587, 1.2, 0.1, 0.45
588, 2.2, 0.1, 0.1
589, 2.2, 0.1, 0.2
590, 2.2, 0.1, 0.3
591, 2.2, 0.1, 0.4
592, 2.2, 0.1, 0.05
593, 2.2, 0.1, 0.15
594, 2.2, 0.1, 0.25
595, 2.2, 0.1, 0.35
596, 2.2, 0.1, 0.45
597, 1.2, 0.075, 0.5
598, 2.2, 0.075, 0.5
599, 1.4, 0.05, 0.5
600, 1.6, 0.05, 0.5
601, 1.8, 0.05, 0.5
602, 2, 0.05, 0.5
603, 1.3, 0.05, 0.5
604, 1.5, 0.05, 0.5
605, 1.7, 0.05, 0.5
606, 1.9, 0.05, 0.5
607, 2.1, 0.05, 0.5
608, 1.2, 0.075, 0
609, 2.2, 0.075, 0
610, 1.4, 0.05, 0
611, 1.6, 0.05, 0
612, 1.8, 0.05, 0
613, 2, 0.05, 0
614, 1.3, 0.05, 0
615, 1.5, 0.05, 0
616, 1.7, 0.05, 0
617, 1.9, 0.05, 0
618, 2.1, 0.05, 0
619, 1.2, 0.05, 0.1
620, 1.2, 0.05, 0.2
621, 1.2, 0.05, 0.3
622, 1.2, 0.05, 0.4
623, 1.2, 0.05, 0.05
624, 1.2, 0.05, 0.15
625, 1.2, 0.05, 0.25
626, 1.2, 0.05, 0.35
627, 1.2, 0.05, 0.45
628, 2.2, 0.05, 0.1
629, 2.2, 0.05, 0.2
630, 2.2, 0.05, 0.3
631, 2.2, 0.05, 0.4
632, 2.2, 0.05, 0.05
633, 2.2, 0.05, 0.15
634, 2.2, 0.05, 0.25
635, 2.2, 0.05, 0.35
636, 2.2, 0.05, 0.45
637, 1.2, 0.025, 0.5
638, 1.2, 0.0375, 0.5
639, 1.2, 0.0125, 0.5
640, 2.2, 0.025, 0.5
641, 2.2, 0.0375, 0.5
642, 2.2, 0.0125, 0.5
643, 1.4, 8.3266726846887e-17, 0.5
644, 1.6, 8.3266726846887e-17, 0.5
645, 1.8, 8.3266726846887e-17, 0.5
646, 2, 8.3266726846887e-17, 0.5
647, 1.3, 0, 0.5
648, 1.5, 0, 0.5
649, 1.7, 0, 0.5
650, 1.9, 0, 0.5
651, 2.1, 0, 0.5
652, 1.2, 0.025, 0
653, 1.2, 0.0375, 0
654, 1.2, 0.0125, 0
655, 2.2, 0.025, 0
656, 2.2, 0.0375, 0
657, 2.2, 0.0125, 0
658, 1.4, 8.3266726846887e-17, 0
659, 1.6, 8.3266726846887e-17, 0
660, 1.8, 8.3266726846887e-17, 0
661, 2, 8.3266726846887e-17, 0
662, 1.3, 0, 0
663, 1.5, 0, 0
664, 1.7, 0, 0
665, 1.9, 0, 0
666, 2.1, 0, 0
667, 1.2, 8.3266726846887e-17, 0.1
668, 1.2, 8.3266726846887e-17, 0.2
669, 1.2, 8.3266726846887e-17, 0.3
670, 1.2, 8.3266726846887e-17, 0.4
671, 1.2, -8.3266726846887e-17, 0.05
672, 1.2, -8.3266726846887e-17, 0.15
673, 1.2, -8.3266726846887e-17, 0.25
674, 1.2, -8.3266726846887e-17, 0.35
675, 1.2, -8.3266726846887e-17, 0.45
676, 2.2, 8.3266726846887e-17, 0.1
677, 2.2, 8.3266726846887e-17, 0.2
678, 2.2, 8.3266726846887e-17, 0.3
679, 2.2, 8.3266726846887e-17, 0.4
680, 2.2, -8.3266726846887e-17, 0.05
681, 2.2, -8.3266726846887e-17, 0.15
682, 2.2, -8.3266726846887e-17, 0.25
683, 2.2, -8.3266726846887e-17, 0.35
684, 2.2, -8.3266726846887e-17, 0.45
685, 2.25, 0.05, 0.5
686, 2.25, -8.3266726846887e-17, 0.5
687, 2.3, 0.025, 0.5
688, 2.3, 0.0375, 0.5
689, 2.3, 0.0125, 0.5
690, 2.25, 0.05, 0
691, 2.25, -8.3266726846887e-17, 0
692, 2.3, 0.025, 0
693, 2.3, 0.0375, 0
694, 2.3, 0.0125, 0
695, 2.3, 0.05, 0.1
696, 2.3, 0.05, 0.2
697, 2.3, 0.05, 0.3
698, 2.3, 0.05, 0.4
699, 2.3, 0.05, 0.05
700, 2.3, 0.05, 0.15
701, 2.3, 0.05, 0.25
702, 2.3, 0.05, 0.35
703, 2.3, 0.05, 0.45
704, 2.3, 8.3266726846887e-17, 0.1
705, 2.3, 8.3266726846887e-17, 0.2
706, 2.3, 8.3266726846887e-17, 0.3
707, 2.3, 8.3266726846887e-17, 0.4
708, 2.3, -8.3266726846887e-17, 0.05
709, 2.3, -8.3266726846887e-17, 0.15
710, 2.3, -8.3266726846887e-17, 0.25
711, 2.3, -8.3266726846887e-17, 0.35
712, 2.3, -8.3266726846887e-17, 0.45
713, -0.05, 0, 0.5
714, -0.05, 0, 0
715, -0.1, 0, 0.1
716, -0.1, 0, 0.2
717, -0.1, 0, 0.3
718, -0.1, 0, 0.4
719, -0.1, 0, 0.05
720, -0.1, 0, 0.15
721, -0.1, 0, 0.25
722, -0.1, 0, 0.35
723, -0.1, 0, 0.45
724, -0.05, 0.05, 0.5
725, -0.1, 0.025, 0.5
726, -0.1, 0.0125, 0.5
727, -0.1, 0.0375, 0.5
728, -0.05, 0.05, 0
729, -0.1, 0.05, 0.1
730, -0.1, 0.05, 0.2
731, -0.1, 0.05, 0.3
732, -0.1, 0.05, 0.4
733, -0.1, 0.05, 0.05
734, -0.1, 0.05, 0.15
735, -0.1, 0.05, 0.25
736, -0.1, 0.05, 0.35
737, -0.1, 0.05, 0.45
738, -0.1, 0.025, 0
739, -0.1, 0.0125, 0
740, -0.1, 0.0375, 0
741, 1.025, 0.1, 0.5
742, 1.025, 1.3, 0.5
743, 1.05, 0.34, 0.5
744, 1.05, 0.58, 0.5
745, 1.05, 0.82, 0.5
746, 1.05, 1.06, 0.5
747, 1.05, 0.22, 0.5
748, 1.05, 0.46, 0.5
749, 1.05, 0.7, 0.5
750, 1.05, 0.94, 0.5
751, 1.05, 1.18, 0.5
752, 1.025, 0.1, 0
753, 1.025, 1.3, 0
754, 1.05, 0.34, 0
755, 1.05, 0.58, 0
756, 1.05, 0.82, 0
757, 1.05, 1.06, 0
758, 1.05, 0.22, 0
759, 1.05, 0.46, 0
760, 1.05, 0.7, 0
761, 1.05, 0.94, 0
762, 1.05, 1.18, 0
763, 1.05, 0.1, 0.1
764, 1.05, 0.1, 0.2
765, 1.05, 0.1, 0.3
766, 1.05, 0.1, 0.4
767, 1.05, 0.1, 0.05
768, 1.05, 0.1, 0.15
769, 1.05, 0.1, 0.25
770, 1.05, 0.1, 0.35
771, 1.05, 0.1, 0.45
772, 1.05, 1.3, 0.1
773, 1.05, 1.3, 0.2
774, 1.05, 1.3, 0.3
775, 1.05, 1.3, 0.4
776, 1.05, 1.3, 0.05
777, 1.05, 1.3, 0.15
778, 1.05, 1.3, 0.25
779, 1.05, 1.3, 0.35
780, 1.05, 1.3, 0.45
781, 1.175, 1.3, 0.5
782, 1.175, 0.1, 0.5
783, 1.15, 1.06, 0.5
784, 1.15, 0.82, 0.5
785, 1.15, 0.58, 0.5
786, 1.15, 0.34, 0.5
787, 1.15, 1.18, 0.5
788, 1.15, 0.94, 0.5
789, 1.15, 0.7, 0.5
790, 1.15, 0.46, 0.5
791, 1.15, 0.22, 0.5
792, 1.175, 1.3, 0
793, 1.175, 0.1, 0
794, 1.15, 1.06, 0
795, 1.15, 0.82, 0
796, 1.15, 0.58, 0
797, 1.15, 0.34, 0
798, 1.15, 1.18, 0
799, 1.15, 0.94, 0
800, 1.15, 0.7, 0
801, 1.15, 0.46, 0
802, 1.15, 0.22, 0
803, 1.15, 1.3, 0.1
804, 1.15, 1.3, 0.2
805, 1.15, 1.3, 0.3
806, 1.15, 1.3, 0.4
807, 1.15, 1.3, 0.05
808, 1.15, 1.3, 0.15
809, 1.15, 1.3, 0.25
810, 1.15, 1.3, 0.35
811, 1.15, 1.3, 0.45
812, 1.15, 0.1, 0.1
813, 1.15, 0.1, 0.2
814, 1.15, 0.1, 0.3
815, 1.15, 0.1, 0.4
816, 1.15, 0.1, 0.05
817, 1.15, 0.1, 0.15
818, 1.15, 0.1, 0.25
819, 1.15, 0.1, 0.35
820, 1.15, 0.1, 0.45
821, 1, 0.1, -0.05
822, 1, 1.3, -0.05
823, 1, 0.34, -0.1
824, 1, 0.58, -0.1
825, 1, 0.82, -0.1
826, 1, 1.06, -0.1
827, 1, 0.22, -0.1
828, 1, 0.46, -0.1
829, 1, 0.7, -0.1
830, 1, 0.94, -0.1
831, 1, 1.18, -0.1
832, 0, 0.1, -0.05
833, 0, 1.3, -0.05
834, 0, 0.34, -0.1
835, 0, 0.58, -0.1
836, 0, 0.82, -0.1
837, 0, 1.06, -0.1
838, 0, 0.22, -0.1
839, 0, 0.46, -0.1
840, 0, 0.7, -0.1
841, 0, 0.94, -0.1
842, 0, 1.18, -0.1
843, 0.2, 0.1, -0.1
844, 0.4, 0.1, -0.1
845, 0.6, 0.1, -0.1
846, 0.8, 0.1, -0.1
847, 0.1, 0.1, -0.1
848, 0.3, 0.1, -0.1
849, 0.5, 0.1, -0.1
850, 0.7, 0.1, -0.1
851, 0.9, 0.1, -0.1
852, 0.2, 1.3, -0.1
853, 0.4, 1.3, -0.1
854, 0.6, 1.3, -0.1
855, 0.8, 1.3, -0.1
856, 0.1, 1.3, -0.1
857, 0.3, 1.3, -0.1
858, 0.5, 1.3, -0.1
859, 0.7, 1.3, -0.1
860, 0.9, 1.3, -0.1
861, 1.2, 1.3, -0.05
862, 1.2, 0.1, -0.05
863, 1.2, 1.06, -0.1
864, 1.2, 0.82, -0.1
865, 1.2, 0.58, -0.1
866, 1.2, 0.34, -0.1
867, 1.2, 1.18, -0.1
868, 1.2, 0.94, -0.1
869, 1.2, 0.7, -0.1
870, 1.2, 0.46, -0.1
871, 1.2, 0.22, -0.1
872, 2.2, 1.3, -0.05
873, 2.2, 0.1, -0.05
874, 2.2, 1.06, -0.1
875, 2.2, 0.82, -0.1
876, 2.2, 0.58, -0.1
877, 2.2, 0.34, -0.1
878, 2.2, 1.18, -0.1
879, 2.2, 0.94, -0.1
880, 2.2, 0.7, -0.1
881, 2.2, 0.46, -0.1
882, 2.2, 0.22, -0.1
883, 1.4, 1.3, -0.1
884, 1.6, 1.3, -0.1
885, 1.8, 1.3, -0.1
886, 2, 1.3, -0.1
887, 1.3, 1.3, -0.1
888, 1.5, 1.3, -0.1
889, 1.7, 1.3, -0.1
890, 1.9, 1.3, -0.1
891, 2.1, 1.3, -0.1
892, 1.4, 0.1, -0.1
893, 1.6, 0.1, -0.1
894, 1.8, 0.1, -0.1
895, 2, 0.1, -0.1
896, 1.3, 0.1, -0.1
897, 1.5, 0.1, -0.1
898, 1.7, 0.1, -0.1
899, 1.9, 0.1, -0.1
900, 2.1, 0.1, -0.1
901, 1.15, 1.3, -0.05
902, 1.175, 1.3, -0.1
903, 1.15, 0.1, -0.05
904, 1.175, 0.1, -0.1
905, 1.15, 1.06, -0.1
906, 1.15, 0.82, -0.1
907, 1.15, 0.58, -0.1
908, 1.15, 0.34, -0.1
909, 1.15, 1.18, -0.1
910, 1.15, 0.94, -0.1
911, 1.15, 0.7, -0.1
912, 1.15, 0.46, -0.1
913, 1.15, 0.22, -0.1
914, 1.05, 0.1, -0.05
915, 1.025, 0.1, -0.1
916, 1.05, 1.3, -0.05
917, 1.025, 1.3, -0.1
918, 1.05, 0.34, -0.1
919, 1.05, 0.58, -0.1
920, 1.05, 0.82, -0.1
921, 1.05, 1.06, -0.1
922, 1.05, 0.22, -0.1
923, 1.05, 0.46, -0.1
924, 1.05, 0.7, -0.1
925, 1.05, 0.94, -0.1
926, 1.05, 1.18, -0.1
927, 1, 1.4666666666667, 0
928, 1, 1.5333333333333, 0
929, 1, 1.4333333333333, 0
930, 1, 1.5, 0
931, 1, 1.5666666666667, 0
932, 0, 1.4666666666667, 0
933, 0, 1.5333333333333, 0
934, 0, 1.4333333333333, 0
935, 0, 1.5, 0
936, 0, 1.5666666666667, 0
937, 0.2, 1.6, 0
938, 0.4, 1.6, 0
939, 0.6, 1.6, 0
940, 0.8, 1.6, 0
941, 0.1, 1.6, 0
942, 0.3, 1.6, 0
943, 0.5, 1.6, 0
944, 0.7, 1.6, 0
945, 0.9, 1.6, 0
946, 1, 1.4666666666667, 0.5
947, 1, 1.5333333333333, 0.5
948, 1, 1.4333333333333, 0.5
949, 1, 1.5, 0.5
950, 1, 1.5666666666667, 0.5
951, 1, 1.6, 0.1
952, 1, 1.6, 0.2
953, 1, 1.6, 0.3
954, 1, 1.6, 0.4
955, 1, 1.6, 0.05
956, 1, 1.6, 0.15
957, 1, 1.6, 0.25
958, 1, 1.6, 0.35
959, 1, 1.6, 0.45
960, 0, 1.4666666666667, 0.5
961, 0, 1.5333333333333, 0.5
962, 0, 1.4333333333333, 0.5
963, 0, 1.5, 0.5
964, 0, 1.5666666666667, 0.5
965, 0.2, 1.6, 0.5
966, 0.4, 1.6, 0.5
967, 0.6, 1.6, 0.5
968, 0.8, 1.6, 0.5
969, 0.1, 1.6, 0.5
970, 0.3, 1.6, 0.5
971, 0.5, 1.6, 0.5
972, 0.7, 1.6, 0.5
973, 0.9, 1.6, 0.5
974, 0, 1.6, 0.1
975, 0, 1.6, 0.2
976, 0, 1.6, 0.3
977, 0, 1.6, 0.4
978, 0, 1.6, 0.05
979, 0, 1.6, 0.15
980, 0, 1.6, 0.25
981, 0, 1.6, 0.35
982, 0, 1.6, 0.45
983, 1.2, 1.4666666666667, 0.5
984, 1.2, 1.5333333333333, 0.5
985, 1.2, 1.4333333333333, 0.5
986, 1.2, 1.5, 0.5
987, 1.2, 1.5666666666667, 0.5
988, 1.0666666666667, 1.6, 0.5
989, 1.1333333333333, 1.6, 0.5
990, 1.0333333333333, 1.6, 0.5
991, 1.1, 1.6, 0.5
992, 1.1666666666667, 1.6, 0.5
993, 1.2, 1.4666666666667, 0
994, 1.2, 1.5333333333333, 0
995, 1.2, 1.4333333333333, 0
996, 1.2, 1.5, 0
997, 1.2, 1.5666666666667, 0
998, 1.0666666666667, 1.6, 0
999, 1.1333333333333, 1.6, 0
1000, 1.0333333333333, 1.6, 0
1001, 1.1, 1.6, 0
1002, 1.1666666666667, 1.6, 0
1003, 1.2, 1.6, 0.1
1004, 1.2, 1.6, 0.2
1005, 1.2, 1.6, 0.3
1006, 1.2, 1.6, 0.4
1007, 1.2, 1.6, 0.05
1008, 1.2, 1.6, 0.15
1009, 1.2, 1.6, 0.25
1010, 1.2, 1.6, 0.35
1011, 1.2, 1.6, 0.45
1012, 2.2, 1.4666666666667, 0.5
1013, 2.2, 1.5333333333333, 0.5
1014, 2.2, 1.4333333333333, 0.5
1015, 2.2, 1.5, 0.5
1016, 2.2, 1.5666666666667, 0.5
1017, 1.4, 1.6, 0.5
1018, 1.6, 1.6, 0.5
1019, 1.8, 1.6, 0.5
1020, 2, 1.6, 0.5
1021, 1.3, 1.6, 0.5
1022, 1.5, 1.6, 0.5
1023, 1.7, 1.6, 0.5
1024, 1.9, 1.6, 0.5
1025, 2.1, 1.6, 0.5
1026, 2.2, 1.4666666666667, 0
1027, 2.2, 1.5333333333333, 0
1028, 2.2, 1.4333333333333, 0
1029, 2.2, 1.5, 0
1030, 2.2, 1.5666666666667, 0
1031, 1.4, 1.6, 0
1032, 1.6, 1.6, 0
1033, 1.8, 1.6, 0
1034, 2, 1.6, 0
1035, 1.3, 1.6, 0
1036, 1.5, 1.6, 0
1037, 1.7, 1.6, 0
1038, 1.9, 1.6, 0
1039, 2.1, 1.6, 0
1040, 2.2, 1.6, 0.1
1041, 2.2, 1.6, 0.2
1042, 2.2, 1.6, 0.3
1043, 2.2, 1.6, 0.4
1044, 2.2, 1.6, 0.05
1045, 2.2, 1.6, 0.15
1046, 2.2, 1.6, 0.25
1047, 2.2, 1.6, 0.35
1048, 2.2, 1.6, 0.45
1049, 1, -0.066666666666667, 0
1050, 1, -0.13333333333333, 0
1051, 1, -0.033333333333333, 0
1052, 1, -0.1, 0
1053, 1, -0.16666666666667, 0
1054, 0, -0.066666666666667, 0
1055, 0, -0.13333333333333, 0
1056, 0, -0.033333333333333, 0
1057, 0, -0.1, 0
1058, 0, -0.16666666666667, 0
1059, 0.2, -0.2, 0
1060, 0.4, -0.2, 0
1061, 0.6, -0.2, 0
1062, 0.8, -0.2, 0
1063, 0.1, -0.2, 0
1064, 0.3, -0.2, 0
1065, 0.5, -0.2, 0
1066, 0.7, -0.2, 0
1067, 0.9, -0.2, 0
1068, 1, -0.066666666666667, 0.5
1069, 1, -0.13333333333333, 0.5
1070, 1, -0.033333333333333, 0.5
1071, 1, -0.1, 0.5
1072, 1, -0.16666666666667, 0.5
1073, 1, -0.2, 0.1
1074, 1, -0.2, 0.2
1075, 1, -0.2, 0.3
1076, 1, -0.2, 0.4
1077, 1, -0.2, 0.05
1078, 1, -0.2, 0.15
1079, 1, -0.2, 0.25
1080, 1, -0.2, 0.35
1081, 1, -0.2, 0.45
1082, 0, -0.066666666666667, 0.5
1083, 0, -0.13333333333333, 0.5
1084, 0, -0.033333333333333, 0.5
1085, 0, -0.1, 0.5
1086, 0, -0.16666666666667, 0.5
1087, 0.2, -0.2, 0.5
1088, 0.4, -0.2, 0.5
1089, 0.6, -0.2, 0.5
1090, 0.8, -0.2, 0.5
1091, 0.1, -0.2, 0.5
1092, 0.3, -0.2, 0.5
1093, 0.5, -0.2, 0.5
1094, 0.7, -0.2, 0.5
1095, 0.9, -0.2, 0.5
1096, 0, -0.2, 0.1
1097, 0, -0.2, 0.2
1098, 0, -0.2, 0.3
1099, 0, -0.2, 0.4
1100, 0, -0.2, 0.05
1101, 0, -0.2, 0.15
1102, 0, -0.2, 0.25
1103, 0, -0.2, 0.35
1104, 0, -0.2, 0.45
1105, -0.1, -0.066666666666667, 0.5
1106, -0.1, -0.13333333333333, 0.5
1107, -0.1, -0.033333333333333, 0.5
1108, -0.1, -0.1, 0.5
1109, -0.1, -0.16666666666667, 0.5
1110, -0.05, -0.2, 0.5
1111, -0.1, -0.066666666666667, 0
1112, -0.1, -0.13333333333333, 0
1113, -0.1, -0.033333333333333, 0
1114, -0.1, -0.1, 0
1115, -0.1, -0.16666666666667, 0
1116, -0.05, -0.2, 0
1117, -0.1, -0.2, 0.1
1118, -0.1, -0.2, 0.2
1119, -0.1, -0.2, 0.3
1120, -0.1, -0.2, 0.4
1121, -0.1, -0.2, 0.05
1122, -0.1, -0.2, 0.15
1123, -0.1, -0.2, 0.25
1124, -0.1, -0.2, 0.35
1125, -0.1, -0.2, 0.45
1126, 1.2, -0.066666666666667, 0.5
1127, 1.2, -0.13333333333333, 0.5
1128, 1.2, -0.033333333333333, 0.5
1129, 1.2, -0.1, 0.5
1130, 1.2, -0.16666666666667, 0.5
1131, 2.2, -0.066666666666667, 0.5
1132, 2.2, -0.13333333333333, 0.5
1133, 2.2, -0.033333333333333, 0.5
1134, 2.2, -0.1, 0.5
1135, 2.2, -0.16666666666667, 0.5
1136, 1.4, -0.2, 0.5
1137, 1.6, -0.2, 0.5
1138, 1.8, -0.2, 0.5
1139, 2, -0.2, 0.5
1140, 1.3, -0.2, 0.5
1141, 1.5, -0.2, 0.5
1142, 1.7, -0.2, 0.5
1143, 1.9, -0.2, 0.5
1144, 2.1, -0.2, 0.5
1145, 1.2, -0.066666666666667, 0
1146, 1.2, -0.13333333333333, 0
1147, 1.2, -0.033333333333333, 0
1148, 1.2, -0.1, 0
1149, 1.2, -0.16666666666667, 0
1150, 2.2, -0.066666666666667, 0
1151, 2.2, -0.13333333333333, 0
1152, 2.2, -0.033333333333333, 0
1153, 2.2, -0.1, 0
1154, 2.2, -0.16666666666667, 0
1155, 1.4, -0.2, 0
1156, 1.6, -0.2, 0
1157, 1.8, -0.2, 0
1158, 2, -0.2, 0
1159, 1.3, -0.2, 0
1160, 1.5, -0.2, 0
1161, 1.7, -0.2, 0
1162, 1.9, -0.2, 0
1163, 2.1, -0.2, 0
1164, 1.2, -0.2, 0.1
1165, 1.2, -0.2, 0.2
1166, 1.2, -0.2, 0.3
1167, 1.2, -0.2, 0.4
1168, 1.2, -0.2, 0.05
1169, 1.2, -0.2, 0.15
1170, 1.2, -0.2, 0.25
1171, 1.2, -0.2, 0.35
1172, 1.2, -0.2, 0.45
1173, 2.2, -0.2, 0.1
1174, 2.2, -0.2, 0.2
1175, 2.2, -0.2, 0.3
1176, 2.2, -0.2, 0.4
1177, 2.2, -0.2, 0.05
1178, 2.2, -0.2, 0.15
1179, 2.2, -0.2, 0.25
1180, 2.2, -0.2, 0.35
1181, 2.2, -0.2, 0.45
1182, 2.3, -0.066666666666667, 0.5
1183, 2.3, -0.13333333333333, 0.5
1184, 2.3, -0.033333333333333, 0.5
1185, 2.3, -0.1, 0.5
1186, 2.3, -0.16666666666667, 0.5
1187, 2.25, -0.2, 0.5
1188, 2.3, -0.066666666666667, 0
1189, 2.3, -0.13333333333333, 0
1190, 2.3, -0.033333333333333, 0
1191, 2.3, -0.1, 0
1192, 2.3, -0.16666666666667, 0
1193, 2.25, -0.2, 0
1194, 2.3, -0.2, 0.1
1195, 2.3, -0.2, 0.2
1196, 2.3, -0.2, 0.3
1197, 2.3, -0.2, 0.4
1198, 2.3, -0.2, 0.05
1199, 2.3, -0.2, 0.15
1200, 2.3, -0.2, 0.25
1201, 2.3, -0.2, 0.35
1202, 2.3, -0.2, 0.45
1203, 0, 0.025, 0.1
1204, 0, 0.025, 0.2
1205, 0, 0.025, 0.3
1206, 0, 0.025, 0.4
1207, 0, 0.0125, 0.1
1208, 0, 0.025, 0.05
1209, 0, 0.0375, 0.1
1210, 0, 0.0125, 0.2
1211, 0, 0.025, 0.15
1212, 0, 0.0375, 0.2
1213, 0, 0.0125, 0.3
1214, 0, 0.025, 0.25
1215, 0, 0.0375, 0.3
1216, 0, 0.0125, 0.4
1217, 0, 0.025, 0.35
1218, 0, 0.0375, 0.4
1219, 0, 0.025, 0.45
1220, 1, 0.025, 0.1
1221, 1, 0.025, 0.2
1222, 1, 0.025, 0.3
1223, 1, 0.025, 0.4
1224, 1, 0.025, 0.05
1225, 1, 0.0125, 0.1
1226, 1, 0.0375, 0.1
1227, 1, 0.025, 0.15
1228, 1, 0.0125, 0.2
1229, 1, 0.0375, 0.2
1230, 1, 0.025, 0.25
1231, 1, 0.0125, 0.3
1232, 1, 0.0375, 0.3
1233, 1, 0.025, 0.35
1234, 1, 0.0125, 0.4
1235, 1, 0.0375, 0.4
1236, 1, 0.025, 0.45
1237, 0.2, 0, 0.1
1238, 0.2, 0, 0.2
1239, 0.2, 0, 0.3
1240, 0.2, 0, 0.4
1241, 0.4, 0, 0.1
1242, 0.4, 0, 0.2
1243, 0.4, 0, 0.3
1244, 0.4, 0, 0.4
1245, 0.6, 0, 0.1
1246, 0.6, 0, 0.2
1247, 0.6, 0, 0.3
1248, 0.6, 0, 0.4
1249, 0.8, 0, 0.1
1250, 0.8, 0, 0.2
1251, 0.8, 0, 0.3
1252, 0.8, 0, 0.4
1253, 0.2, 0, 0.05
1254, 0.1, 0, 0.1
1255, 0.2, 0, 0.15
1256, 0.1, 0, 0.2
1257, 0.2, 0, 0.25
1258, 0.1, 0, 0.3
1259, 0.2, 0, 0.35
1260, 0.1, 0, 0.4
1261, 0.2, 0, 0.45
1262, 0.4, 0, 0.05
1263, 0.3, 0, 0.1
1264, 0.4, 0, 0.15
1265, 0.3, 0, 0.2
1266, 0.4, 0, 0.25
1267, 0.3, 0, 0.3
1268, 0.4, 0, 0.35
1269, 0.3, 0, 0.4
1270, 0.4, 0, 0.45
1271, 0.6, 0, 0.05
1272, 0.5, 0, 0.1
1273, 0.6, 0, 0.15
1274, 0.5, 0, 0.2
1275, 0.6, 0, 0.25
1276, 0.5, 0, 0.3
1277, 0.6, 0, 0.35
1278, 0.5, 0, 0.4
1279, 0.6, 0, 0.45
1280, 0.8, 0, 0.05
1281, 0.7, 0, 0.1
1282, 0.8, 0, 0.15
1283, 0.7, 0, 0.2
1284, 0.8, 0, 0.25
1285, 0.7, 0, 0.3
1286, 0.8, 0, 0.35
1287, 0.7, 0, 0.4
1288, 0.8, 0, 0.45
1289, 0.9, 0, 0.1
1290, 0.9, 0, 0.2
1291, 0.9, 0, 0.3
1292, 0.9, 0, 0.4
1293, 0.2, 0.05, 0.1
1294, 0.2, 0.05, 0.2
1295, 0.2, 0.05, 0.3
1296, 0.2, 0.05, 0.4
1297, 0.4, 0.05, 0.1
1298, 0.4, 0.05, 0.2
1299, 0.4, 0.05, 0.3
1300, 0.4, 0.05, 0.4
1301, 0.6, 0.05, 0.1
1302, 0.6, 0.05, 0.2
1303, 0.6, 0.05, 0.3
1304, 0.6, 0.05, 0.4
1305, 0.8, 0.05, 0.1
1306, 0.8, 0.05, 0.2
1307, 0.8, 0.05, 0.3
1308, 0.8, 0.05, 0.4
1309, 0.1, 0.05, 0.1
1310, 0.2, 0.05, 0.05
1311, 0.1, 0.05, 0.2
1312, 0.2, 0.05, 0.15
1313, 0.1, 0.05, 0.3
1314, 0.2, 0.05, 0.25
1315, 0.1, 0.05, 0.4
1316, 0.2, 0.05, 0.35
1317, 0.2, 0.05, 0.45
1318, 0.3, 0.05, 0.1
1319, 0.4, 0.05, 0.05
1320, 0.3, 0.05, 0.2
1321, 0.4, 0.05, 0.15
1322, 0.3, 0.05, 0.3
1323, 0.4, 0.05, 0.25
1324, 0.3, 0.05, 0.4
1325, 0.4, 0.05, 0.35
1326, 0.4, 0.05, 0.45
1327, 0.5, 0.05, 0.1
1328, 0.6, 0.05, 0.05
1329, 0.5, 0.05, 0.2
1330, 0.6, 0.05, 0.15
1331, 0.5, 0.05, 0.3
1332, 0.6, 0.05, 0.25
1333, 0.5, 0.05, 0.4
1334, 0.6, 0.05, 0.35
1335, 0.6, 0.05, 0.45
1336, 0.7, 0.05, 0.1
1337, 0.8, 0.05, 0.05
1338, 0.7, 0.05, 0.2
1339, 0.8, 0.05, 0.15
1340, 0.7, 0.05, 0.3
1341, 0.8, 0.05, 0.25
1342, 0.7, 0.05, 0.4
1343, 0.8, 0.05, 0.35
1344, 0.8, 0.05, 0.45
1345, 0.9, 0.05, 0.1
1346, 0.9, 0.05, 0.2
1347, 0.9, 0.05, 0.3
1348, 0.9, 0.05, 0.4
1349, 0.2, 0.025, 0
1350, 0.4, 0.025, 0
1351, 0.6, 0.025, 0
1352, 0.8, 0.025, 0
1353, 0.1, 0.025, 0
1354, 0.2, 0.0125, 0
1355, 0.3, 0.025, 0
1356, 0.4, 0.0125, 0
1357, 0.5, 0.025, 0
1358, 0.6, 0.0125, 0
1359, 0.7, 0.025, 0
1360, 0.8, 0.0125, 0
1361, 0.9, 0.025, 0
1362, 0.2, 0.0375, 0
1363, 0.4, 0.0375, 0
1364, 0.6, 0.0375, 0
1365, 0.8, 0.0375, 0
1366, 0.2, 0.025, 0.5
1367, 0.4, 0.025, 0.5
1368, 0.6, 0.025, 0.5
1369, 0.8, 0.025, 0.5
1370, 0.2, 0.0125, 0.5
1371, 0.1, 0.025, 0.5
1372, 0.4, 0.0125, 0.5
1373, 0.3, 0.025, 0.5
1374, 0.6, 0.0125, 0.5
1375, 0.5, 0.025, 0.5
1376, 0.8, 0.0125, 0.5
1377, 0.7, 0.025, 0.5
1378, 0.9, 0.025, 0.5
1379, 0.2, 0.0375, 0.5
1380, 0.4, 0.0375, 0.5
1381, 0.6, 0.0375, 0.5
1382, 0.8, 0.0375, 0.5
1383, 0.2, 0.075, 0
1384, 0.4, 0.075, 0
1385, 0.6, 0.075, 0
1386, 0.8, 0.075, 0
1387, 1, 0.075, 0.1
1388, 1, 0.075, 0.2
1389, 1, 0.075, 0.3
1390, 1, 0.075, 0.4
1391, 0.2, 0.075, 0.5
1392, 0.4, 0.075, 0.5
1393, 0.6, 0.075, 0.5
1394, 0.8, 0.075, 0.5
1395, 0, 0.075, 0.1
1396, 0, 0.075, 0.2
1397, 0, 0.075, 0.3
1398, 0, 0.075, 0.4
1399, 0.2, 0.1, 0.1
1400, 0.2, 0.1, 0.2
1401, 0.2, 0.1, 0.3
1402, 0.2, 0.1, 0.4
1403, 0.4, 0.1, 0.1
1404, 0.4, 0.1, 0.2
1405, 0.4, 0.1, 0.3
1406, 0.4, 0.1, 0.4
1407, 0.6, 0.1, 0.1
1408, 0.6, 0.1, 0.2
1409, 0.6, 0.1, 0.3
1410, 0.6, 0.1, 0.4
1411, 0.8, 0.1, 0.1
1412, 0.8, 0.1, 0.2
1413, 0.8, 0.1, 0.3
1414, 0.8, 0.1, 0.4
1415, 0.1, 0.1, 0.1
1416, 0.2, 0.1, 0.05
1417, 0.1, 0.1, 0.2
1418, 0.2, 0.1, 0.15
1419, 0.1, 0.1, 0.3
1420, 0.2, 0.1, 0.25
1421, 0.1, 0.1, 0.4
1422, 0.2, 0.1, 0.35
1423, 0.2, 0.1, 0.45
1424, 0.3, 0.1, 0.1
1425, 0.4, 0.1, 0.05
1426, 0.3, 0.1, 0.2
1427, 0.4, 0.1, 0.15
1428, 0.3, 0.1, 0.3
1429, 0.4, 0.1, 0.25
1430, 0.3, 0.1, 0.4
1431, 0.4, 0.1, 0.35
1432, 0.4, 0.1, 0.45
1433, 0.5, 0.1, 0.1
1434, 0.6, 0.1, 0.05
1435, 0.5, 0.1, 0.2
1436, 0.6, 0.1, 0.15
1437, 0.5, 0.1, 0.3
1438, 0.6, 0.1, 0.25
1439, 0.5, 0.1, 0.4
1440, 0.6, 0.1, 0.35
1441, 0.6, 0.1, 0.45
1442, 0.7, 0.1, 0.1
1443, 0.8, 0.1, 0.05
1444, 0.7, 0.1, 0.2
1445, 0.8, 0.1, 0.15
1446, 0.7, 0.1, 0.3
1447, 0.8, 0.1, 0.25
1448, 0.7, 0.1, 0.4
1449, 0.8, 0.1, 0.35
1450, 0.8, 0.1, 0.45
1451, 0.9, 0.1, 0.1
1452, 0.9, 0.1, 0.2
1453, 0.9, 0.1, 0.3
1454, 0.9, 0.1, 0.4
1455, 0.2, 0.34, 0
1456, 0.2, 0.58, 0
1457, 0.2, 0.82, 0
1458, 0.2, 1.06, 0
1459, 0.4, 0.34, 0
1460, 0.4, 0.58, 0
1461, 0.4, 0.82, 0
1462, 0.4, 1.06, 0
1463, 0.6, 0.34, 0
1464, 0.6, 0.58, 0
1465, 0.6, 0.82, 0
1466, 0.6, 1.06, 0
1467, 0.8, 0.34, 0
1468, 0.8, 0.58, 0
1469, 0.8, 0.82, 0
1470, 0.8, 1.06, 0
1471, 0.1, 0.34, 0
1472, 0.2, 0.22, 0
1473, 0.1, 0.58, 0
1474, 0.2, 0.46, 0
1475, 0.1, 0.82, 0
1476, 0.2, 0.7, 0
1477, 0.1, 1.06, 0
1478, 0.2, 0.94, 0
1479, 0.2, 1.18, 0
1480, 0.3, 0.34, 0
1481, 0.4, 0.22, 0
1482, 0.3, 0.58, 0
1483, 0.4, 0.46, 0
1484, 0.3, 0.82, 0
1485, 0.4, 0.7, 0
1486, 0.3, 1.06, 0
1487, 0.4, 0.94, 0
1488, 0.4, 1.18, 0
1489, 0.5, 0.34, 0
1490, 0.6, 0.22, 0
1491, 0.5, 0.58, 0
1492, 0.6, 0.46, 0
1493, 0.5, 0.82, 0
1494, 0.6, 0.7, 0
1495, 0.5, 1.06, 0
1496, 0.6, 0.94, 0
1497, 0.6, 1.18, 0
1498, 0.7, 0.34, 0
1499, 0.8, 0.22, 0
1500, 0.7, 0.58, 0
1501, 0.8, 0.46, 0
1502, 0.7, 0.82, 0
1503, 0.8, 0.7, 0
1504, 0.7, 1.06, 0
1505, 0.8, 0.94, 0
1506, 0.8, 1.18, 0
1507, 0.9, 0.34, 0
1508, 0.9, 0.58, 0
1509, 0.9, 0.82, 0
1510, 0.9, 1.06, 0
1511, 1, 0.34, 0.1
1512, 1, 0.58, 0.1
1513, 1, 0.82, 0.1
1514, 1, 1.06, 0.1
1515, 1, 0.34, 0.2
1516, 1, 0.58, 0.2
1517, 1, 0.82, 0.2
1518, 1, 1.06, 0.2
1519, 1, 0.34, 0.3
1520, 1, 0.58, 0.3
1521, 1, 0.82, 0.3
1522, 1, 1.06, 0.3
1523, 1, 0.34, 0.4
1524, 1, 0.58, 0.4
1525, 1, 0.82, 0.4
1526, 1, 1.06, 0.4
1527, 1, 0.34, 0.05
1528, 1, 0.22, 0.1
1529, 1, 0.58, 0.05
1530, 1, 0.46, 0.1
1531, 1, 0.82, 0.05
1532, 1, 0.7, 0.1
1533, 1, 1.06, 0.05
1534, 1, 0.94, 0.1
1535, 1, 1.18, 0.1
1536, 1, 0.34, 0.15
1537, 1, 0.22, 0.2
1538, 1, 0.58, 0.15
1539, 1, 0.46, 0.2
1540, 1, 0.82, 0.15
1541, 1, 0.7, 0.2
1542, 1, 1.06, 0.15
1543, 1, 0.94, 0.2
1544, 1, 1.18, 0.2
1545, 1, 0.34, 0.25
1546, 1, 0.22, 0.3
1547, 1, 0.58, 0.25
1548, 1, 0.46, 0.3
1549, 1, 0.82, 0.25
1550, 1, 0.7, 0.3
1551, 1, 1.06, 0.25
1552, 1, 0.94, 0.3
1553, 1, 1.18, 0.3
1554, 1, 0.34, 0.35
1555, 1, 0.22, 0.4
1556, 1, 0.58, 0.35
1557, 1, 0.46, 0.4
1558, 1, 0.82, 0.35
1559, 1, 0.7, 0.4
1560, 1, 1.06, 0.35
1561, 1, 0.94, 0.4
1562, 1, 1.18, 0.4
1563, 1, 0.34, 0.45
1564, 1, 0.58, 0.45
1565, 1, 0.82, 0.45
1566, 1, 1.06, 0.45
1567, 0.2, 0.34, 0.5
1568, 0.2, 0.58, 0.5
1569, 0.2, 0.82, 0.5
1570, 0.2, 1.06, 0.5
1571, 0.4, 0.34, 0.5
1572, 0.4, 0.58, 0.5
1573, 0.4, 0.82, 0.5
1574, 0.4, 1.06, 0.5
1575, 0.6, 0.34, 0.5
1576, 0.6, 0.58, 0.5
1577, 0.6, 0.82, 0.5
1578, 0.6, 1.06, 0.5
1579, 0.8, 0.34, 0.5
1580, 0.8, 0.58, 0.5
1581, 0.8, 0.82, 0.5
1582, 0.8, 1.06, 0.5
1583, 0.2, 0.22, 0.5
1584, 0.1, 0.34, 0.5
1585, 0.2, 0.46, 0.5
1586, 0.1, 0.58, 0.5
1587, 0.2, 0.7, 0.5
1588, 0.1, 0.82, 0.5
1589, 0.2, 0.94, 0.5
1590, 0.1, 1.06, 0.5
1591, 0.2, 1.18, 0.5
1592, 0.4, 0.22, 0.5
1593, 0.3, 0.34, 0.5
1594, 0.4, 0.46, 0.5
1595, 0.3, 0.58, 0.5
1596, 0.4, 0.7, 0.5
1597, 0.3, 0.82, 0.5
1598, 0.4, 0.94, 0.5
1599, 0.3, 1.06, 0.5
1600, 0.4, 1.18, 0.5
1601, 0.6, 0.22, 0.5
1602, 0.5, 0.34, 0.5
1603, 0.6, 0.46, 0.5
1604, 0.5, 0.58, 0.5
1605, 0.6, 0.7, 0.5
1606, 0.5, 0.82, 0.5
1607, 0.6, 0.94, 0.5
1608, 0.5, 1.06, 0.5
1609, 0.6, 1.18, 0.5
1610, 0.8, 0.22, 0.5
1611, 0.7, 0.34, 0.5
1612, 0.8, 0.46, 0.5
1613, 0.7, 0.58, 0.5
1614, 0.8, 0.7, 0.5
1615, 0.7, 0.82, 0.5
1616, 0.8, 0.94, 0.5
1617, 0.7, 1.06, 0.5
1618, 0.8, 1.18, 0.5
1619, 0.9, 0.34, 0.5
1620, 0.9, 0.58, 0.5
1621, 0.9, 0.82, 0.5
1622, 0.9, 1.06, 0.5
1623, 0, 0.34, 0.1
1624, 0, 0.58, 0.1
1625, 0, 0.82, 0.1
1626, 0, 1.06, 0.1
1627, 0, 0.34, 0.2
1628, 0, 0.58, 0.2
1629, 0, 0.82, 0.2
1630, 0, 1.06, 0.2
1631, 0, 0.34, 0.3
1632, 0, 0.58, 0.3
1633, 0, 0.82, 0.3
1634, 0, 1.06, 0.3
1635, 0, 0.34, 0.4
1636, 0, 0.58, 0.4
1637, 0, 0.82, 0.4
1638, 0, 1.06, 0.4
1639, 0, 0.22, 0.1
1640, 0, 0.34, 0.05
1641, 0, 0.46, 0.1
1642, 0, 0.58, 0.05
1643, 0, 0.7, 0.1
1644, 0, 0.82, 0.05
1645, 0, 0.94, 0.1
1646, 0, 1.06, 0.05
1647, 0, 1.18, 0.1
1648, 0, 0.22, 0.2
1649, 0, 0.34, 0.15
1650, 0, 0.46, 0.2
1651, 0, 0.58, 0.15
1652, 0, 0.7, 0.2
1653, 0, 0.82, 0.15
1654, 0, 0.94, 0.2
1655, 0, 1.06, 0.15
1656, 0, 1.18, 0.2
1657, 0, 0.22, 0.3
1658, 0, 0.34, 0.25
1659, 0, 0.46, 0.3
1660, 0, 0.58, 0.25
1661, 0, 0.7, 0.3
1662, 0, 0.82, 0.25
1663, 0, 0.94, 0.3
1664, 0, 1.06, 0.25
1665, 0, 1.18, 0.3
1666, 0, 0.22, 0.4
1667, 0, 0.34, 0.35
1668, 0, 0.46, 0.4
1669, 0, 0.58, 0.35
1670, 0, 0.7, 0.4
1671, 0, 0.82, 0.35
1672, 0, 0.94, 0.4
1673, 0, 1.06, 0.35
1674, 0, 1.18, 0.4
1675, 0, 0.34, 0.45
1676, 0, 0.58, 0.45
1677, 0, 0.82, 0.45
1678, 0, 1.06, 0.45
1679, 0.2, 1.3, 0.1
1680, 0.2, 1.3, 0.2
1681, 0.2, 1.3, 0.3
1682, 0.2, 1.3, 0.4
1683, 0.4, 1.3, 0.1
1684, 0.4, 1.3, 0.2
1685, 0.4, 1.3, 0.3
1686, 0.4, 1.3, 0.4
1687, 0.6, 1.3, 0.1
1688, 0.6, 1.3, 0.2
1689, 0.6, 1.3, 0.3
1690, 0.6, 1.3, 0.4
1691, 0.8, 1.3, 0.1
1692, 0.8, 1.3, 0.2
1693, 0.8, 1.3, 0.3
1694, 0.8, 1.3, 0.4
1695, 0.1, 1.3, 0.1
1696, 0.2, 1.3, 0.05
1697, 0.1, 1.3, 0.2
1698, 0.2, 1.3, 0.15
1699, 0.1, 1.3, 0.3
1700, 0.2, 1.3, 0.25
1701, 0.1, 1.3, 0.4
1702, 0.2, 1.3, 0.35
1703, 0.2, 1.3, 0.45
1704, 0.3, 1.3, 0.1
1705, 0.4, 1.3, 0.05
1706, 0.3, 1.3, 0.2
1707, 0.4, 1.3, 0.15
1708, 0.3, 1.3, 0.3
1709, 0.4, 1.3, 0.25
1710, 0.3, 1.3, 0.4
1711, 0.4, 1.3, 0.35
1712, 0.4, 1.3, 0.45
1713, 0.5, 1.3, 0.1
1714, 0.6, 1.3, 0.05
1715, 0.5, 1.3, 0.2
1716, 0.6, 1.3, 0.15
1717, 0.5, 1.3, 0.3
1718, 0.6, 1.3, 0.25
1719, 0.5, 1.3, 0.4
1720, 0.6, 1.3, 0.35
1721, 0.6, 1.3, 0.45
1722, 0.7, 1.3, 0.1
1723, 0.8, 1.3, 0.05
1724, 0.7, 1.3, 0.2
1725, 0.8, 1.3, 0.15
1726, 0.7, 1.3, 0.3
1727, 0.8, 1.3, 0.25
1728, 0.7, 1.3, 0.4
1729, 0.8, 1.3, 0.35
1730, 0.8, 1.3, 0.45
1731, 0.9, 1.3, 0.1
1732, 0.9, 1.3, 0.2
1733, 0.9, 1.3, 0.3
1734, 0.9, 1.3, 0.4
1735, 0.2, 1.325, 0
1736, 0.4, 1.325, 0
1737, 0.6, 1.325, 0
1738, 0.8, 1.325, 0
1739, 1, 1.325, 0.1
1740, 1, 1.325, 0.2
1741, 1, 1.325, 0.3
1742, 1, 1.325, 0.4
1743, 0.2, 1.325, 0.5
1744, 0.4, 1.325, 0.5
1745, 0.6, 1.325, 0.5
1746, 0.8, 1.325, 0.5
1747, 0, 1.325, 0.1
1748, 0, 1.325, 0.2
1749, 0, 1.325, 0.3
1750, 0, 1.325, 0.4
1751, 0.2, 1.35, 0.1
1752, 0.2, 1.35, 0.2
1753, 0.2, 1.35, 0.3
1754, 0.2, 1.35, 0.4
1755, 0.4, 1.35, 0.1
1756, 0.4, 1.35, 0.2
1757, 0.4, 1.35, 0.3
1758, 0.4, 1.35, 0.4
1759, 0.6, 1.35, 0.1
1760, 0.6, 1.35, 0.2
1761, 0.6, 1.35, 0.3
1762, 0.6, 1.35, 0.4
1763, 0.8, 1.35, 0.1
1764, 0.8, 1.35, 0.2
1765, 0.8, 1.35, 0.3
1766, 0.8, 1.35, 0.4
1767, 0.1, 1.35, 0.1
1768, 0.2, 1.35, 0.05
1769, 0.1, 1.35, 0.2
1770, 0.2, 1.35, 0.15
1771, 0.1, 1.35, 0.3
1772, 0.2, 1.35, 0.25
1773, 0.1, 1.35, 0.4
1774, 0.2, 1.35, 0.35
1775, 0.2, 1.35, 0.45
1776, 0.3, 1.35, 0.1
1777, 0.4, 1.35, 0.05
1778, 0.3, 1.35, 0.2
1779, 0.4, 1.35, 0.15
1780, 0.3, 1.35, 0.3
1781, 0.4, 1.35, 0.25
1782, 0.3, 1.35, 0.4
1783, 0.4, 1.35, 0.35
1784, 0.4, 1.35, 0.45
1785, 0.5, 1.35, 0.1
1786, 0.6, 1.35, 0.05
1787, 0.5, 1.35, 0.2
1788, 0.6, 1.35, 0.15
1789, 0.5, 1.35, 0.3
1790, 0.6, 1.35, 0.25
1791, 0.5, 1.35, 0.4
1792, 0.6, 1.35, 0.35
1793, 0.6, 1.35, 0.45
1794, 0.7, 1.35, 0.1
1795, 0.8, 1.35, 0.05
1796, 0.7, 1.35, 0.2
1797, 0.8, 1.35, 0.15
1798, 0.7, 1.35, 0.3
1799, 0.8, 1.35, 0.25
1800, 0.7, 1.35, 0.4
1801, 0.8, 1.35, 0.35
1802, 0.8, 1.35, 0.45
1803, 0.9, 1.35, 0.1
1804, 0.9, 1.35, 0.2
1805, 0.9, 1.35, 0.3
1806, 0.9, 1.35, 0.4
1807, 0.2, 1.375, 0
1808, 0.4, 1.375, 0
1809, 0.6, 1.375, 0
1810, 0.8, 1.375, 0
1811, 0.1, 1.375, 0
1812, 0.2, 1.3625, 0
1813, 0.2, 1.3875, 0
1814, 0.3, 1.375, 0
1815, 0.4, 1.3625, 0
1816, 0.4, 1.3875, 0
1817, 0.5, 1.375, 0
1818, 0.6, 1.3625, 0
1819, 0.6, 1.3875, 0
1820, 0.7, 1.375, 0
1821, 0.8, 1.3625, 0
1822, 0.8, 1.3875, 0
1823, 0.9, 1.375, 0
1824, 1, 1.375, 0.1
1825, 1, 1.375, 0.2
1826, 1, 1.375, 0.3
1827, 1, 1.375, 0.4
1828, 1, 1.375, 0.05
1829, 1, 1.3625, 0.1
1830, 1, 1.3875, 0.1
1831, 1, 1.375, 0.15
1832, 1, 1.3625, 0.2
1833, 1, 1.3875, 0.2
1834, 1, 1.375, 0.25
1835, 1, 1.3625, 0.3
1836, 1, 1.3875, 0.3
1837, 1, 1.375, 0.35
1838, 1, 1.3625, 0.4
1839, 1, 1.3875, 0.4
1840, 1, 1.375, 0.45
1841, 0.2, 1.375, 0.5
1842, 0.4, 1.375, 0.5
1843, 0.6, 1.375, 0.5
1844, 0.8, 1.375, 0.5
1845, 0.2, 1.3625, 0.5
1846, 0.1, 1.375, 0.5
1847, 0.2, 1.3875, 0.5
1848, 0.4, 1.3625, 0.5
1849, 0.3, 1.375, 0.5
1850, 0.4, 1.3875, 0.5
1851, 0.6, 1.3625, 0.5
1852, 0.5, 1.375, 0.5
1853, 0.6, 1.3875, 0.5
1854, 0.8, 1.3625, 0.5
1855, 0.7, 1.375, 0.5
1856, 0.8, 1.3875, 0.5
1857, 0.9, 1.375, 0.5
1858, 0, 1.375, 0.1
1859, 0, 1.375, 0.2
1860, 0, 1.375, 0.3
1861, 0, 1.375, 0.4
1862, 0, 1.3625, 0.1
1863, 0, 1.375, 0.05
1864, 0, 1.3875, 0.1
1865, 0, 1.3625, 0.2
1866, 0, 1.375, 0.15
1867, 0, 1.3875, 0.2
1868, 0, 1.3625, 0.3
1869, 0, 1.375, 0.25
1870, 0, 1.3875, 0.3
1871, 0, 1.3625, 0.4
1872, 0, 1.375, 0.35
1873, 0, 1.3875, 0.4
1874, 0, 1.375, 0.45
1875, 0.2, 1.4, 0.1
1876, 0.2, 1.4, 0.2
1877, 0.2, 1.4, 0.3
1878, 0.2, 1.4, 0.4
1879, 0.4, 1.4, 0.1
1880, 0.4, 1.4, 0.2
1881, 0.4, 1.4, 0.3
1882, 0.4, 1.4, 0.4
1883, 0.6, 1.4, 0.1
1884, 0.6, 1.4, 0.2
1885, 0.6, 1.4, 0.3
1886, 0.6, 1.4, 0.4
1887, 0.8, 1.4, 0.1
1888, 0.8, 1.4, 0.2
1889, 0.8, 1.4, 0.3
1890, 0.8, 1.4, 0.4
1891, 0.1, 1.4, 0.1
1892, 0.2, 1.4, 0.05
1893, 0.1, 1.4, 0.2
1894, 0.2, 1.4, 0.15
1895, 0.1, 1.4, 0.3
1896, 0.2, 1.4, 0.25
1897, 0.1, 1.4, 0.4
1898, 0.2, 1.4, 0.35
1899, 0.2, 1.4, 0.45
1900, 0.3, 1.4, 0.1
1901, 0.4, 1.4, 0.05
1902, 0.3, 1.4, 0.2
1903, 0.4, 1.4, 0.15
1904, 0.3, 1.4, 0.3
1905, 0.4, 1.4, 0.25
1906, 0.3, 1.4, 0.4
1907, 0.4, 1.4, 0.35
1908, 0.4, 1.4, 0.45
1909, 0.5, 1.4, 0.1
1910, 0.6, 1.4, 0.05
1911, 0.5, 1.4, 0.2
1912, 0.6, 1.4, 0.15
1913, 0.5, 1.4, 0.3
1914, 0.6, 1.4, 0.25
1915, 0.5, 1.4, 0.4
1916, 0.6, 1.4, 0.35
1917, 0.6, 1.4, 0.45
1918, 0.7, 1.4, 0.1
1919, 0.8, 1.4, 0.05
1920, 0.7, 1.4, 0.2
1921, 0.8, 1.4, 0.15
1922, 0.7, 1.4, 0.3
1923, 0.8, 1.4, 0.25
1924, 0.7, 1.4, 0.4
1925, 0.8, 1.4, 0.35
1926, 0.8, 1.4, 0.45
1927, 0.9, 1.4, 0.1
1928, 0.9, 1.4, 0.2
1929, 0.9, 1.4, 0.3
1930, 0.9, 1.4, 0.4
1931, 1.0666666666667, 1.375, 0.5
1932, 1.1333333333333, 1.375, 0.5
1933, 1.0666666666667, 1.3625, 0.5
1934, 1.0333333333333, 1.375, 0.5
1935, 1.1333333333333, 1.3625, 0.5
1936, 1.1, 1.375, 0.5
1937, 1.1666666666667, 1.375, 0.5
1938, 1.0666666666667, 1.3875, 0.5
1939, 1.1333333333333, 1.3875, 0.5
1940, 1.0666666666667, 1.375, 0
1941, 1.1333333333333, 1.375, 0
1942, 1.0333333333333, 1.375, 0
1943, 1.0666666666667, 1.3625, 0
1944, 1.1, 1.375, 0
1945, 1.1333333333333, 1.3625, 0
1946, 1.1666666666667, 1.375, 0
1947, 1.0666666666667, 1.3875, 0
1948, 1.1333333333333, 1.3875, 0
1949, 1.0666666666667, 1.35, 0.1
1950, 1.1333333333333, 1.35, 0.1
1951, 1.0666666666667, 1.35, 0.2
1952, 1.1333333333333, 1.35, 0.2
1953, 1.0666666666667, 1.35, 0.3
1954, 1.1333333333333, 1.35, 0.3
1955, 1.0666666666667, 1.35, 0.4
1956, 1.1333333333333, 1.35, 0.4
1957, 1.0666666666667, 1.35, 0.05
1958, 1.0333333333333, 1.35, 0.1
1959, 1.1333333333333, 1.35, 0.05
1960, 1.1, 1.35, 0.1
1961, 1.1666666666667, 1.35, 0.1
1962, 1.0666666666667, 1.35, 0.15
1963, 1.0333333333333, 1.35, 0.2
1964, 1.1333333333333, 1.35, 0.15
1965, 1.1, 1.35, 0.2
1966, 1.1666666666667, 1.35, 0.2
1967, 1.0666666666667, 1.35, 0.25
1968, 1.0333333333333, 1.35, 0.3
1969, 1.1333333333333, 1.35, 0.25
1970, 1.1, 1.35, 0.3
1971, 1.1666666666667, 1.35, 0.3
1972, 1.0666666666667, 1.35, 0.35
1973, 1.0333333333333, 1.35, 0.4
1974, 1.1333333333333, 1.35, 0.35
1975, 1.1, 1.35, 0.4
1976, 1.1666666666667, 1.35, 0.4
1977, 1.0666666666667, 1.35, 0.45
1978, 1.1333333333333, 1.35, 0.45
1979, 1.0666666666667, 1.4, 0.1
1980, 1.1333333333333, 1.4, 0.1
1981, 1.0666666666667, 1.4, 0.2
1982, 1.1333333333333, 1.4, 0.2
1983, 1.0666666666667, 1.4, 0.3
1984, 1.1333333333333, 1.4, 0.3
1985, 1.0666666666667, 1.4, 0.4
1986, 1.1333333333333, 1.4, 0.4
1987, 1.0333333333333, 1.4, 0.1
1988, 1.0666666666667, 1.4, 0.05
1989, 1.1, 1.4, 0.1
1990, 1.1333333333333, 1.4, 0.05
1991, 1.1666666666667, 1.4, 0.1
1992, 1.0333333333333, 1.4, 0.2
1993, 1.0666666666667, 1.4, 0.15
1994, 1.1, 1.4, 0.2
1995, 1.1333333333333, 1.4, 0.15
1996, 1.1666666666667, 1.4, 0.2
1997, 1.0333333333333, 1.4, 0.3
1998, 1.0666666666667, 1.4, 0.25
1999, 1.1, 1.4, 0.3
2000, 1.1333333333333, 1.4, 0.25
2001, 1.1666666666667, 1.4, 0.3
2002, 1.0333333333333, 1.4, 0.4
2003, 1.0666666666667, 1.4, 0.35
2004, 1.1, 1.4, 0.4
2005, 1.1333333333333, 1.4, 0.35
2006, 1.1666666666667, 1.4, 0.4
2007, 1.0666666666667, 1.4, 0.45
2008, 1.1333333333333, 1.4, 0.45
2009, 1.2, 1.375, 0.1
2010, 1.2, 1.375, 0.2
2011, 1.2, 1.375, 0.3
2012, 1.2, 1.375, 0.4
2013, 1.2, 1.375, 0.05
2014, 1.2, 1.3625, 0.1
2015, 1.2, 1.3875, 0.1
2016, 1.2, 1.375, 0.15
2017, 1.2, 1.3625, 0.2
2018, 1.2, 1.3875, 0.2
2019, 1.2, 1.375, 0.25
2020, 1.2, 1.3625, 0.3
2021, 1.2, 1.3875, 0.3
2022, 1.2, 1.375, 0.35
2023, 1.2, 1.3625, 0.4
2024, 1.2, 1.3875, 0.4
2025, 1.2, 1.375, 0.45
2026, 1.4, 1.375, 0.5
2027, 1.6, 1.375, 0.5
2028, 1.8, 1.375, 0.5
2029, 2, 1.375, 0.5
2030, 1.4, 1.3625, 0.5
2031, 1.3, 1.375, 0.5
2032, 1.6, 1.3625, 0.5
2033, 1.5, 1.375, 0.5
2034, 1.8, 1.3625, 0.5
2035, 1.7, 1.375, 0.5
2036, 2, 1.3625, 0.5
2037, 1.9, 1.375, 0.5
2038, 2.1, 1.375, 0.5
2039, 1.4, 1.3875, 0.5
2040, 1.6, 1.3875, 0.5
2041, 1.8, 1.3875, 0.5
2042, 2, 1.3875, 0.5
2043, 1.4, 1.375, 0
2044, 1.6, 1.375, 0
2045, 1.8, 1.375, 0
2046, 2, 1.375, 0
2047, 1.3, 1.375, 0
2048, 1.4, 1.3625, 0
2049, 1.5, 1.375, 0
2050, 1.6, 1.3625, 0
2051, 1.7, 1.375, 0
2052, 1.8, 1.3625, 0
2053, 1.9, 1.375, 0
2054, 2, 1.3625, 0
2055, 2.1, 1.375, 0
2056, 1.4, 1.3875, 0
2057, 1.6, 1.3875, 0
2058, 1.8, 1.3875, 0
2059, 2, 1.3875, 0
2060, 1.4, 1.35, 0.1
2061, 1.6, 1.35, 0.1
2062, 1.8, 1.35, 0.1
2063, 2, 1.35, 0.1
2064, 1.4, 1.35, 0.2
2065, 1.6, 1.35, 0.2
2066, 1.8, 1.35, 0.2
2067, 2, 1.35, 0.2
2068, 1.4, 1.35, 0.3
2069, 1.6, 1.35, 0.3
2070, 1.8, 1.35, 0.3
2071, 2, 1.35, 0.3
2072, 1.4, 1.35, 0.4
2073, 1.6, 1.35, 0.4
2074, 1.8, 1.35, 0.4
2075, 2, 1.35, 0.4
2076, 1.4, 1.35, 0.05
2077, 1.3, 1.35, 0.1
2078, 1.6, 1.35, 0.05
2079, 1.5, 1.35, 0.1
2080, 1.8, 1.35, 0.05
2081, 1.7, 1.35, 0.1
2082, 2, 1.35, 0.05
2083, 1.9, 1.35, 0.1
2084, 2.1, 1.35, 0.1
2085, 1.4, 1.35, 0.15
2086, 1.3, 1.35, 0.2
2087, 1.6, 1.35, 0.15
2088, 1.5, 1.35, 0.2
2089, 1.8, 1.35, 0.15
2090, 1.7, 1.35, 0.2
2091, 2, 1.35, 0.15
2092, 1.9, 1.35, 0.2
2093, 2.1, 1.35, 0.2
2094, 1.4, 1.35, 0.25
2095, 1.3, 1.35, 0.3
2096, 1.6, 1.35, 0.25
2097, 1.5, 1.35, 0.3
2098, 1.8, 1.35, 0.25
2099, 1.7, 1.35, 0.3
2100, 2, 1.35, 0.25
2101, 1.9, 1.35, 0.3
2102, 2.1, 1.35, 0.3
2103, 1.4, 1.35, 0.35
2104, 1.3, 1.35, 0.4
2105, 1.6, 1.35, 0.35
2106, 1.5, 1.35, 0.4
2107, 1.8, 1.35, 0.35
2108, 1.7, 1.35, 0.4
2109, 2, 1.35, 0.35
2110, 1.9, 1.35, 0.4
2111, 2.1, 1.35, 0.4
2112, 1.4, 1.35, 0.45
2113, 1.6, 1.35, 0.45
2114, 1.8, 1.35, 0.45
2115, 2, 1.35, 0.45
2116, 1.4, 1.4, 0.1
2117, 1.6, 1.4, 0.1
2118, 1.8, 1.4, 0.1
2119, 2, 1.4, 0.1
2120, 1.4, 1.4, 0.2
2121, 1.6, 1.4, 0.2
2122, 1.8, 1.4, 0.2
2123, 2, 1.4, 0.2
2124, 1.4, 1.4, 0.3
2125, 1.6, 1.4, 0.3
2126, 1.8, 1.4, 0.3
2127, 2, 1.4, 0.3
2128, 1.4, 1.4, 0.4
2129, 1.6, 1.4, 0.4
2130, 1.8, 1.4, 0.4
2131, 2, 1.4, 0.4
2132, 1.3, 1.4, 0.1
2133, 1.4, 1.4, 0.05
2134, 1.5, 1.4, 0.1
2135, 1.6, 1.4, 0.05
2136, 1.7, 1.4, 0.1
2137, 1.8, 1.4, 0.05
2138, 1.9, 1.4, 0.1
2139, 2, 1.4, 0.05
2140, 2.1, 1.4, 0.1
2141, 1.3, 1.4, 0.2
2142, 1.4, 1.4, 0.15
2143, 1.5, 1.4, 0.2
2144, 1.6, 1.4, 0.15
2145, 1.7, 1.4, 0.2
2146, 1.8, 1.4, 0.15
2147, 1.9, 1.4, 0.2
2148, 2, 1.4, 0.15
2149, 2.1, 1.4, 0.2
2150, 1.3, 1.4, 0.3
2151, 1.4, 1.4, 0.25
2152, 1.5, 1.4, 0.3
2153, 1.6, 1.4, 0.25
2154, 1.7, 1.4, 0.3
2155, 1.8, 1.4, 0.25
2156, 1.9, 1.4, 0.3
2157, 2, 1.4, 0.25
2158, 2.1, 1.4, 0.3
2159, 1.3, 1.4, 0.4
2160, 1.4, 1.4, 0.35
2161, 1.5, 1.4, 0.4
2162, 1.6, 1.4, 0.35
2163, 1.7, 1.4, 0.4
2164, 1.8, 1.4, 0.35
2165, 1.9, 1.4, 0.4
2166, 2, 1.4, 0.35
2167, 2.1, 1.4, 0.4
2168, 1.4, 1.4, 0.45
2169, 1.6, 1.4, 0.45
2170, 1.8, 1.4, 0.45
2171, 2, 1.4, 0.45
2172, 2.2, 1.375, 0.1
2173, 2.2, 1.375, 0.2
2174, 2.2, 1.375, 0.3
2175, 2.2, 1.375, 0.4
2176, 2.2, 1.375, 0.05
2177, 2.2, 1.3625, 0.1
2178, 2.2, 1.3875, 0.1
2179, 2.2, 1.375, 0.15
2180, 2.2, 1.3625, 0.2
2181, 2.2, 1.3875, 0.2
2182, 2.2, 1.375, 0.25
2183, 2.2, 1.3625, 0.3
2184, 2.2, 1.3875, 0.3
2185, 2.2, 1.375, 0.35
2186, 2.2, 1.3625, 0.4
2187, 2.2, 1.3875, 0.4
2188, 2.2, 1.375, 0.45
2189, 1.4, 1.325, 0.5
2190, 1.6, 1.325, 0.5
2191, 1.8, 1.325, 0.5
2192, 2, 1.325, 0.5
2193, 1.4, 1.325, 0
2194, 1.6, 1.325, 0
2195, 1.8, 1.325, 0
2196, 2, 1.325, 0
2197, 1.2, 1.325, 0.1
2198, 1.2, 1.325, 0.2
2199, 1.2, 1.325, 0.3
2200, 1.2, 1.325, 0.4
2201, 2.2, 1.325, 0.1
2202, 2.2, 1.325, 0.2
2203, 2.2, 1.325, 0.3
2204, 2.2, 1.325, 0.4
2205, 1.4, 1.3, 0.1
2206, 1.6, 1.3, 0.1
2207, 1.8, 1.3, 0.1
2208, 2, 1.3, 0.1
2209, 1.4, 1.3, 0.2
2210, 1.6, 1.3, 0.2
2211, 1.8, 1.3, 0.2
2212, 2, 1.3, 0.2
2213, 1.4, 1.3, 0.3
2214, 1.6, 1.3, 0.3
2215, 1.8, 1.3, 0.3
2216, 2, 1.3, 0.3
2217, 1.4, 1.3, 0.4
2218, 1.6, 1.3, 0.4
2219, 1.8, 1.3, 0.4
2220, 2, 1.3, 0.4
2221, 1.4, 1.3, 0.05
2222, 1.3, 1.3, 0.1
2223, 1.6, 1.3, 0.05
2224, 1.5, 1.3, 0.1
2225, 1.8, 1.3, 0.05
2226, 1.7, 1.3, 0.1
2227, 2, 1.3, 0.05
2228, 1.9, 1.3, 0.1
2229, 2.1, 1.3, 0.1
2230, 1.4, 1.3, 0.15
2231, 1.3, 1.3, 0.2
2232, 1.6, 1.3, 0.15
2233, 1.5, 1.3, 0.2
2234, 1.8, 1.3, 0.15
2235, 1.7, 1.3, 0.2
2236, 2, 1.3, 0.15
2237, 1.9, 1.3, 0.2
2238, 2.1, 1.3, 0.2
2239, 1.4, 1.3, 0.25
2240, 1.3, 1.3, 0.3
2241, 1.6, 1.3, 0.25
2242, 1.5, 1.3, 0.3
2243, 1.8, 1.3, 0.25
2244, 1.7, 1.3, 0.3
2245, 2, 1.3, 0.25
2246, 1.9, 1.3, 0.3
2247, 2.1, 1.3, 0.3
2248, 1.4, 1.3, 0.35
2249, 1.3, 1.3, 0.4
2250, 1.6, 1.3, 0.35
2251, 1.5, 1.3, 0.4
2252, 1.8, 1.3, 0.35
2253, 1.7, 1.3, 0.4
2254, 2, 1.3, 0.35
2255, 1.9, 1.3, 0.4
2256, 2.1, 1.3, 0.4
2257, 1.4, 1.3, 0.45
2258, 1.6, 1.3, 0.45
2259, 1.8, 1.3, 0.45
2260, 2, 1.3, 0.45
2261, 1.4, 1.06, 0.5
2262, 1.4, 0.82, 0.5
2263, 1.4, 0.58, 0.5
2264, 1.4, 0.34, 0.5
2265, 1.6, 1.06, 0.5
2266, 1.6, 0.82, 0.5
2267, 1.6, 0.58, 0.5
2268, 1.6, 0.34, 0.5
2269, 1.8, 1.06, 0.5
2270, 1.8, 0.82, 0.5
2271, 1.8, 0.58, 0.5
2272, 1.8, 0.34, 0.5
2273, 2, 1.06, 0.5
2274, 2, 0.82, 0.5
2275, 2, 0.58, 0.5
2276, 2, 0.34, 0.5
2277, 1.3, 1.06, 0.5
2278, 1.4, 1.18, 0.5
2279, 1.3, 0.82, 0.5
2280, 1.4, 0.94, 0.5
2281, 1.3, 0.58, 0.5
2282, 1.4, 0.7, 0.5
2283, 1.3, 0.34, 0.5
2284, 1.4, 0.46, 0.5
2285, 1.4, 0.22, 0.5
2286, 1.5, 1.06, 0.5
2287, 1.6, 1.18, 0.5
2288, 1.5, 0.82, 0.5
2289, 1.6, 0.94, 0.5
2290, 1.5, 0.58, 0.5
2291, 1.6, 0.7, 0.5
2292, 1.5, 0.34, 0.5
2293, 1.6, 0.46, 0.5
2294, 1.6, 0.22, 0.5
2295, 1.7, 1.06, 0.5
2296, 1.8, 1.18, 0.5
2297, 1.7, 0.82, 0.5
2298, 1.8, 0.94, 0.5
2299, 1.7, 0.58, 0.5
2300, 1.8, 0.7, 0.5
2301, 1.7, 0.34, 0.5
2302, 1.8, 0.46, 0.5
2303, 1.8, 0.22, 0.5
2304, 1.9, 1.06, 0.5
2305, 2, 1.18, 0.5
2306, 1.9, 0.82, 0.5
2307, 2, 0.94, 0.5
2308, 1.9, 0.58, 0.5
2309, 2, 0.7, 0.5
2310, 1.9, 0.34, 0.5
2311, 2, 0.46, 0.5
2312, 2, 0.22, 0.5
2313, 2.1, 1.06, 0.5
2314, 2.1, 0.82, 0.5
2315, 2.1, 0.58, 0.5
2316, 2.1, 0.34, 0.5
2317, 1.4, 1.06, 0
2318, 1.4, 0.82, 0
2319, 1.4, 0.58, 0
2320, 1.4, 0.34, 0
2321, 1.6, 1.06, 0
2322, 1.6, 0.82, 0
2323, 1.6, 0.58, 0
2324, 1.6, 0.34, 0
2325, 1.8, 1.06, 0
2326, 1.8, 0.82, 0
2327, 1.8, 0.58, 0
2328, 1.8, 0.34, 0
2329, 2, 1.06, 0
2330, 2, 0.82, 0
2331, 2, 0.58, 0
2332, 2, 0.34, 0
2333, 1.4, 1.18, 0
2334, 1.3, 1.06, 0
2335, 1.4, 0.94, 0
2336, 1.3, 0.82, 0
2337, 1.4, 0.7, 0
2338, 1.3, 0.58, 0
2339, 1.4, 0.46, 0
2340, 1.3, 0.34, 0
2341, 1.4, 0.22, 0
2342, 1.6, 1.18, 0
2343, 1.5, 1.06, 0
2344, 1.6, 0.94, 0
2345, 1.5, 0.82, 0
2346, 1.6, 0.7, 0
2347, 1.5, 0.58, 0
2348, 1.6, 0.46, 0
2349, 1.5, 0.34, 0
2350, 1.6, 0.22, 0
2351, 1.8, 1.18, 0
2352, 1.7, 1.06, 0
2353, 1.8, 0.94, 0
2354, 1.7, 0.82, 0
2355, 1.8, 0.7, 0
2356, 1.7, 0.58, 0
2357, 1.8, 0.46, 0
2358, 1.7, 0.34, 0
2359, 1.8, 0.22, 0
2360, 2, 1.18, 0
2361, 1.9, 1.06, 0
2362, 2, 0.94, 0
2363, 1.9, 0.82, 0
2364, 2, 0.7, 0
2365, 1.9, 0.58, 0
2366, 2, 0.46, 0
2367, 1.9, 0.34, 0
2368, 2, 0.22, 0
2369, 2.1, 1.06, 0
2370, 2.1, 0.82, 0
2371, 2.1, 0.58, 0
2372, 2.1, 0.34, 0
2373, 1.2, 1.06, 0.1
2374, 1.2, 0.82, 0.1
2375, 1.2, 0.58, 0.1
2376, 1.2, 0.34, 0.1
2377, 1.2, 1.06, 0.2
2378, 1.2, 0.82, 0.2
2379, 1.2, 0.58, 0.2
2380, 1.2, 0.34, 0.2
2381, 1.2, 1.06, 0.3
2382, 1.2, 0.82, 0.3
2383, 1.2, 0.58, 0.3
2384, 1.2, 0.34, 0.3
2385, 1.2, 1.06, 0.4
2386, 1.2, 0.82, 0.4
2387, 1.2, 0.58, 0.4
2388, 1.2, 0.34, 0.4
2389, 1.2, 1.06, 0.05
2390, 1.2, 1.18, 0.1
2391, 1.2, 0.82, 0.05
2392, 1.2, 0.94, 0.1
2393, 1.2, 0.58, 0.05
2394, 1.2, 0.7, 0.1
2395, 1.2, 0.34, 0.05
2396, 1.2, 0.46, 0.1
2397, 1.2, 0.22, 0.1
2398, 1.2, 1.06, 0.15
2399, 1.2, 1.18, 0.2
2400, 1.2, 0.82, 0.15
2401, 1.2, 0.94, 0.2
2402, 1.2, 0.58, 0.15
2403, 1.2, 0.7, 0.2
2404, 1.2, 0.34, 0.15
2405, 1.2, 0.46, 0.2
2406, 1.2, 0.22, 0.2
2407, 1.2, 1.06, 0.25
2408, 1.2, 1.18, 0.3
2409, 1.2, 0.82, 0.25
2410, 1.2, 0.94, 0.3
2411, 1.2, 0.58, 0.25
2412, 1.2, 0.7, 0.3
2413, 1.2, 0.34, 0.25
2414, 1.2, 0.46, 0.3
2415, 1.2, 0.22, 0.3
2416, 1.2, 1.06, 0.35
2417, 1.2, 1.18, 0.4
2418, 1.2, 0.82, 0.35
2419, 1.2, 0.94, 0.4
2420, 1.2, 0.58, 0.35
2421, 1.2, 0.7, 0.4
2422, 1.2, 0.34, 0.35
2423, 1.2, 0.46, 0.4
2424, 1.2, 0.22, 0.4
2425, 1.2, 1.06, 0.45
2426, 1.2, 0.82, 0.45
2427, 1.2, 0.58, 0.45
2428, 1.2, 0.34, 0.45
2429, 2.2, 1.06, 0.1
2430, 2.2, 0.82, 0.1
2431, 2.2, 0.58, 0.1
2432, 2.2, 0.34, 0.1
2433, 2.2, 1.06, 0.2
2434, 2.2, 0.82, 0.2
2435, 2.2, 0.58, 0.2
2436, 2.2, 0.34, 0.2
2437, 2.2, 1.06, 0.3
2438, 2.2, 0.82, 0.3
2439, 2.2, 0.58, 0.3
2440, 2.2, 0.34, 0.3
2441, 2.2, 1.06, 0.4
2442, 2.2, 0.82, 0.4
2443, 2.2, 0.58, 0.4
2444, 2.2, 0.34, 0.4
2445, 2.2, 1.18, 0.1
2446, 2.2, 1.06, 0.05
2447, 2.2, 0.94, 0.1
2448, 2.2, 0.82, 0.05
2449, 2.2, 0.7, 0.1
2450, 2.2, 0.58, 0.05
2451, 2.2, 0.46, 0.1
2452, 2.2, 0.34, 0.05
2453, 2.2, 0.22, 0.1
2454, 2.2, 1.18, 0.2
2455, 2.2, 1.06, 0.15
2456, 2.2, 0.94, 0.2
2457, 2.2, 0.82, 0.15
2458, 2.2, 0.7, 0.2
2459, 2.2, 0.58, 0.15
2460, 2.2, 0.46, 0.2
2461, 2.2, 0.34, 0.15
2462, 2.2, 0.22, 0.2
2463, 2.2, 1.18, 0.3
2464, 2.2, 1.06, 0.25
2465, 2.2, 0.94, 0.3
2466, 2.2, 0.82, 0.25
2467, 2.2, 0.7, 0.3
2468, 2.2, 0.58, 0.25
2469, 2.2, 0.46, 0.3
2470, 2.2, 0.34, 0.25
2471, 2.2, 0.22, 0.3
2472, 2.2, 1.18, 0.4
2473, 2.2, 1.06, 0.35
2474, 2.2, 0.94, 0.4
2475, 2.2, 0.82, 0.35
2476, 2.2, 0.7, 0.4
2477, 2.2, 0.58, 0.35
2478, 2.2, 0.46, 0.4
2479, 2.2, 0.34, 0.35
2480, 2.2, 0.22, 0.4
2481, 2.2, 1.06, 0.45
2482, 2.2, 0.82, 0.45
2483, 2.2, 0.58, 0.45
2484, 2.2, 0.34, 0.45
2485, 1.4, 0.1, 0.1
2486, 1.6, 0.1, 0.1
2487, 1.8, 0.1, 0.1
2488, 2, 0.1, 0.1
2489, 1.4, 0.1, 0.2
2490, 1.6, 0.1, 0.2
2491, 1.8, 0.1, 0.2
2492, 2, 0.1, 0.2
2493, 1.4, 0.1, 0.3
2494, 1.6, 0.1, 0.3
2495, 1.8, 0.1, 0.3
2496, 2, 0.1, 0.3
2497, 1.4, 0.1, 0.4
2498, 1.6, 0.1, 0.4
2499, 1.8, 0.1, 0.4
2500, 2, 0.1, 0.4
2501, 1.4, 0.1, 0.05
2502, 1.3, 0.1, 0.1
2503, 1.6, 0.1, 0.05
2504, 1.5, 0.1, 0.1
2505, 1.8, 0.1, 0.05
2506, 1.7, 0.1, 0.1
2507, 2, 0.1, 0.05
2508, 1.9, 0.1, 0.1
2509, 2.1, 0.1, 0.1
2510, 1.4, 0.1, 0.15
2511, 1.3, 0.1, 0.2
2512, 1.6, 0.1, 0.15
2513, 1.5, 0.1, 0.2
2514, 1.8, 0.1, 0.15
2515, 1.7, 0.1, 0.2
2516, 2, 0.1, 0.15
2517, 1.9, 0.1, 0.2
2518, 2.1, 0.1, 0.2
2519, 1.4, 0.1, 0.25
2520, 1.3, 0.1, 0.3
2521, 1.6, 0.1, 0.25
2522, 1.5, 0.1, 0.3
2523, 1.8, 0.1, 0.25
2524, 1.7, 0.1, 0.3
2525, 2, 0.1, 0.25
2526, 1.9, 0.1, 0.3
2527, 2.1, 0.1, 0.3
2528, 1.4, 0.1, 0.35
2529, 1.3, 0.1, 0.4
2530, 1.6, 0.1, 0.35
2531, 1.5, 0.1, 0.4
2532, 1.8, 0.1, 0.35
2533, 1.7, 0.1, 0.4
2534, 2, 0.1, 0.35
2535, 1.9, 0.1, 0.4
2536, 2.1, 0.1, 0.4
2537, 1.4, 0.1, 0.45
2538, 1.6, 0.1, 0.45
2539, 1.8, 0.1, 0.45
2540, 2, 0.1, 0.45
2541, 1.4, 0.075, 0.5
2542, 1.6, 0.075, 0.5
2543, 1.8, 0.075, 0.5
2544, 2, 0.075, 0.5
2545, 1.4, 0.075, 0
2546, 1.6, 0.075, 0
2547, 1.8, 0.075, 0
2548, 2, 0.075, 0
2549, 1.2, 0.075, 0.1
2550, 1.2, 0.075, 0.2
2551, 1.2, 0.075, 0.3
2552, 1.2, 0.075, 0.4
2553, 2.2, 0.075, 0.1
2554, 2.2, 0.075, 0.2
2555, 2.2, 0.075, 0.3
2556, 2.2, 0.075, 0.4
2557, 1.4, 0.05, 0.1
2558, 1.6, 0.05, 0.1
2559, 1.8, 0.05, 0.1
2560, 2, 0.05, 0.1
2561, 1.4, 0.05, 0.2
2562, 1.6, 0.05, 0.2
2563, 1.8, 0.05, 0.2
2564, 2, 0.05, 0.2
2565, 1.4, 0.05, 0.3
2566, 1.6, 0.05, 0.3
2567, 1.8, 0.05, 0.3
2568, 2, 0.05, 0.3
2569, 1.4, 0.05, 0.4
2570, 1.6, 0.05, 0.4
2571, 1.8, 0.05, 0.4
2572, 2, 0.05, 0.4
2573, 1.4, 0.05, 0.05
2574, 1.3, 0.05, 0.1
2575, 1.6, 0.05, 0.05
2576, 1.5, 0.05, 0.1
2577, 1.8, 0.05, 0.05
2578, 1.7, 0.05, 0.1
2579, 2, 0.05, 0.05
2580, 1.9, 0.05, 0.1
2581, 2.1, 0.05, 0.1
2582, 1.4, 0.05, 0.15
2583, 1.3, 0.05, 0.2
2584, 1.6, 0.05, 0.15
2585, 1.5, 0.05, 0.2
2586, 1.8, 0.05, 0.15
2587, 1.7, 0.05, 0.2
2588, 2, 0.05, 0.15
2589, 1.9, 0.05, 0.2
2590, 2.1, 0.05, 0.2
2591, 1.4, 0.05, 0.25
2592, 1.3, 0.05, 0.3
2593, 1.6, 0.05, 0.25
2594, 1.5, 0.05, 0.3
2595, 1.8, 0.05, 0.25
2596, 1.7, 0.05, 0.3
2597, 2, 0.05, 0.25
2598, 1.9, 0.05, 0.3
2599, 2.1, 0.05, 0.3
2600, 1.4, 0.05, 0.35
2601, 1.3, 0.05, 0.4
2602, 1.6, 0.05, 0.35
2603, 1.5, 0.05, 0.4
2604, 1.8, 0.05, 0.35
2605, 1.7, 0.05, 0.4
2606, 2, 0.05, 0.35
2607, 1.9, 0.05, 0.4
2608, 2.1, 0.05, 0.4
2609, 1.4, 0.05, 0.45
2610, 1.6, 0.05, 0.45
2611, 1.8, 0.05, 0.45
2612, 2, 0.05, 0.45
2613, 1.4, 0.025, 0.5
2614, 1.6, 0.025, 0.5
2615, 1.8, 0.025, 0.5
2616, 2, 0.025, 0.5
2617, 1.3, 0.025, 0.5
2618, 1.4, 0.0375, 0.5
2619, 1.4, 0.0125, 0.5
2620, 1.5, 0.025, 0.5
2621, 1.6, 0.0375, 0.5
2622, 1.6, 0.0125, 0.5
2623, 1.7, 0.025, 0.5
2624, 1.8, 0.0375, 0.5
2625, 1.8, 0.0125, 0.5
2626, 1.9, 0.025, 0.5
2627, 2, 0.0375, 0.5
2628, 2, 0.0125, 0.5
2629, 2.1, 0.025, 0.5
2630, 1.4, 0.025, 0
2631, 1.6, 0.025, 0
2632, 1.8, 0.025, 0
2633, 2, 0.025, 0
2634, 1.4, 0.0375, 0
2635, 1.3, 0.025, 0
2636, 1.4, 0.0125, 0
2637, 1.6, 0.0375, 0
2638, 1.5, 0.025, 0
2639, 1.6, 0.0125, 0
2640, 1.8, 0.0375, 0
2641, 1.7, 0.025, 0
2642, 1.8, 0.0125, 0
2643, 2, 0.0375, 0
2644, 1.9, 0.025, 0
2645, 2, 0.0125, 0
2646, 2.1, 0.025, 0
2647, 1.2, 0.025, 0.1
2648, 1.2, 0.025, 0.2
2649, 1.2, 0.025, 0.3
2650, 1.2, 0.025, 0.4
2651, 1.2, 0.025, 0.05
2652, 1.2, 0.0375, 0.1
2653, 1.2, 0.0125, 0.1
2654, 1.2, 0.025, 0.15
2655, 1.2, 0.0375, 0.2
2656, 1.2, 0.0125, 0.2
2657, 1.2, 0.025, 0.25
2658, 1.2, 0.0375, 0.3
2659, 1.2, 0.0125, 0.3
2660, 1.2, 0.025, 0.35
2661, 1.2, 0.0375, 0.4
2662, 1.2, 0.0125, 0.4
2663, 1.2, 0.025, 0.45
2664, 2.2, 0.025, 0.1
2665, 2.2, 0.025, 0.2
2666, 2.2, 0.025, 0.3
2667, 2.2, 0.025, 0.4
2668, 2.2, 0.0375, 0.1
2669, 2.2, 0.025, 0.05
2670, 2.2, 0.0125, 0.1
2671, 2.2, 0.0375, 0.2
2672, 2.2, 0.025, 0.15
2673, 2.2, 0.0125, 0.2
2674, 2.2, 0.0375, 0.3
2675, 2.2, 0.025, 0.25
2676, 2.2, 0.0125, 0.3
2677, 2.2, 0.0375, 0.4
2678, 2.2, 0.025, 0.35
2679, 2.2, 0.0125, 0.4
2680, 2.2, 0.025, 0.45
2681, 1.4, 8.3266726846887e-17, 0.1
2682, 1.6, 8.3266726846887e-17, 0.1
2683, 1.8, 8.3266726846887e-17, 0.1
2684, 2, 8.3266726846887e-17, 0.1
2685, 1.4, 8.3266726846887e-17, 0.2
2686, 1.6, 8.3266726846887e-17, 0.2
2687, 1.8, 8.3266726846887e-17, 0.2
2688, 2, 8.3266726846887e-17, 0.2
2689, 1.4, 8.3266726846887e-17, 0.3
2690, 1.6, 8.3266726846887e-17, 0.3
2691, 1.8, 8.3266726846887e-17, 0.3
2692, 2, 8.3266726846887e-17, 0.3
2693, 1.4, 8.3266726846887e-17, 0.4
2694, 1.6, 8.3266726846887e-17, 0.4
2695, 1.8, 8.3266726846887e-17, 0.4
2696, 2, 8.3266726846887e-17, 0.4
2697, 1.4, 0, 0.05
2698, 1.3, 0, 0.1
2699, 1.6, 0, 0.05
2700, 1.5, 0, 0.1
2701, 1.8, 0, 0.05
2702, 1.7, 0, 0.1
2703, 2, 0, 0.05
2704, 1.9, 0, 0.1
2705, 2.1, 0, 0.1
2706, 1.4, 0, 0.15
2707, 1.3, 0, 0.2
2708, 1.6, 0, 0.15
2709, 1.5, 0, 0.2
2710, 1.8, 0, 0.15
2711, 1.7, 0, 0.2
2712, 2, 0, 0.15
2713, 1.9, 0, 0.2
2714, 2.1, 0, 0.2
2715, 1.4, 0, 0.25
2716, 1.3, 0, 0.3
2717, 1.6, 0, 0.25
2718, 1.5, 0, 0.3
2719, 1.8, 0, 0.25
2720, 1.7, 0, 0.3
2721, 2, 0, 0.25
2722, 1.9, 0, 0.3
2723, 2.1, 0, 0.3
2724, 1.4, 0, 0.35
2725, 1.3, 0, 0.4
2726, 1.6, 0, 0.35
2727, 1.5, 0, 0.4
2728, 1.8, 0, 0.35
2729, 1.7, 0, 0.4
2730, 2, 0, 0.35
2731, 1.9, 0, 0.4
2732, 2.1, 0, 0.4
2733, 1.4, 0, 0.45
2734, 1.6, 0, 0.45
2735, 1.8, 0, 0.45
2736, 2, 0, 0.45
2737, 2.25, 0.025, 0.5
2738, 2.25, 0.025, 0
2739, 2.25, 0.05, 0.1
2740, 2.25, 0.05, 0.2
2741, 2.25, 0.05, 0.3
2742, 2.25, 0.05, 0.4
2743, 2.25, -8.3266726846887e-17, 0.1
2744, 2.25, -8.3266726846887e-17, 0.2
2745, 2.25, -8.3266726846887e-17, 0.3
2746, 2.25, -8.3266726846887e-17, 0.4
2747, 2.3, 0.025, 0.1
2748, 2.3, 0.025, 0.2
2749, 2.3, 0.025, 0.3
2750, 2.3, 0.025, 0.4
2751, 2.3, 0.0375, 0.1
2752, 2.3, 0.025, 0.05
2753, 2.3, 0.0125, 0.1
2754, 2.3, 0.0375, 0.2
2755, 2.3, 0.025, 0.15
2756, 2.3, 0.0125, 0.2
2757, 2.3, 0.0375, 0.3
2758, 2.3, 0.025, 0.25
2759, 2.3, 0.0125, 0.3
2760, 2.3, 0.0375, 0.4
2761, 2.3, 0.025, 0.35
2762, 2.3, 0.0125, 0.4
2763, 2.3, 0.025, 0.45
2764, -0.05, 0, 0.1
2765, -0.05, 0, 0.2
2766, -0.05, 0, 0.3
2767, -0.05, 0, 0.4
2768, -0.05, 0.025, 0.5
2769, -0.05, 0.05, 0.1
2770, -0.05, 0.05, 0.2
2771, -0.05, 0.05, 0.3
2772, -0.05, 0.05, 0.4
2773, -0.05, 0.025, 0
2774, -0.1, 0.025, 0.1
2775, -0.1, 0.025, 0.2
2776, -0.1, 0.025, 0.3
2777, -0.1, 0.025, 0.4
2778, -0.1, 0.0125, 0.1
2779, -0.1, 0.025, 0.05
2780, -0.1, 0.0375, 0.1
2781, -0.1, 0.0125, 0.2
2782, -0.1, 0.025, 0.15
2783, -0.1, 0.0375, 0.2
2784, -0.1, 0.0125, 0.3
2785, -0.1, 0.025, 0.25
2786, -0.1, 0.0375, 0.3
2787, -0.1, 0.0125, 0.4
2788, -0.1, 0.025, 0.35
2789, -0.1, 0.0375, 0.4
2790, -0.1, 0.025, 0.45
2791, 1.025, 0.34, 0.5
2792, 1.025, 0.58, 0.5
2793, 1.025, 0.82, 0.5
2794, 1.025, 1.06, 0.5
2795, 1.025, 0.34, 0
2796, 1.025, 0.58, 0
2797, 1.025, 0.82, 0
2798, 1.025, 1.06, 0
2799, 1.025, 0.1, 0.1
2800, 1.025, 0.1, 0.2
2801, 1.025, 0.1, 0.3
2802, 1.025, 0.1, 0.4
2803, 1.025, 1.3, 0.1
2804, 1.025, 1.3, 0.2
2805, 1.025, 1.3, 0.3
2806, 1.025, 1.3, 0.4
2807, 1.05, 0.34, 0.1
2808, 1.05, 0.58, 0.1
2809, 1.05, 0.82, 0.1
2810, 1.05, 1.06, 0.1
2811, 1.05, 0.34, 0.2
2812, 1.05, 0.58, 0.2
2813, 1.05, 0.82, 0.2
2814, 1.05, 1.06, 0.2
2815, 1.05, 0.34, 0.3
2816, 1.05, 0.58, 0.3
2817, 1.05, 0.82, 0.3
2818, 1.05, 1.06, 0.3
2819, 1.05, 0.34, 0.4
2820, 1.05, 0.58, 0.4
2821, 1.05, 0.82, 0.4
2822, 1.05, 1.06, 0.4
2823, 1.05, 0.34, 0.05
2824, 1.05, 0.22, 0.1
2825, 1.05, 0.58, 0.05
2826, 1.05, 0.46, 0.1
2827, 1.05, 0.82, 0.05
2828, 1.05, 0.7, 0.1
2829, 1.05, 1.06, 0.05
2830, 1.05, 0.94, 0.1
2831, 1.05, 1.18, 0.1
2832, 1.05, 0.34, 0.15
2833, 1.05, 0.22, 0.2
2834, 1.05, 0.58, 0.15
2835, 1.05, 0.46, 0.2
2836, 1.05, 0.82, 0.15
2837, 1.05, 0.7, 0.2
2838, 1.05, 1.06, 0.15
2839, 1.05, 0.94, 0.2
2840, 1.05, 1.18, 0.2
2841, 1.05, 0.34, 0.25
2842, 1.05, 0.22, 0.3
2843, 1.05, 0.58, 0.25
2844, 1.05, 0.46, 0.3
2845, 1.05, 0.82, 0.25
2846, 1.05, 0.7, 0.3
2847, 1.05, 1.06, 0.25
2848, 1.05, 0.94, 0.3
2849, 1.05, 1.18, 0.3
2850, 1.05, 0.34, 0.35
2851, 1.05, 0.22, 0.4
2852, 1.05, 0.58, 0.35
2853, 1.05, 0.46, 0.4
2854, 1.05, 0.82, 0.35
2855, 1.05, 0.7, 0.4
2856, 1.05, 1.06, 0.35
2857, 1.05, 0.94, 0.4
2858, 1.05, 1.18, 0.4
2859, 1.05, 0.34, 0.45
2860, 1.05, 0.58, 0.45
2861, 1.05, 0.82, 0.45
2862, 1.05, 1.06, 0.45
2863, 1.175, 1.06, 0.5
2864, 1.175, 0.82, 0.5
2865, 1.175, 0.58, 0.5
2866, 1.175, 0.34, 0.5
2867, 1.175, 1.06, 0
2868, 1.175, 0.82, 0
2869, 1.175, 0.58, 0
2870, 1.175, 0.34, 0
2871, 1.175, 1.3, 0.1
2872, 1.175, 1.3, 0.2
2873, 1.175, 1.3, 0.3
2874, 1.175, 1.3, 0.4
2875, 1.175, 0.1, 0.1
2876, 1.175, 0.1, 0.2
2877, 1.175, 0.1, 0.3
2878, 1.175, 0.1, 0.4
2879, 1.15, 1.06, 0.1
2880, 1.15, 0.82, 0.1
2881, 1.15, 0.58, 0.1
2882, 1.15, 0.34, 0.1
2883, 1.15, 1.06, 0.2
2884, 1.15, 0.82, 0.2
2885, 1.15, 0.58, 0.2
2886, 1.15, 0.34, 0.2
2887, 1.15, 1.06, 0.3
2888, 1.15, 0.82, 0.3
2889, 1.15, 0.58, 0.3
2890, 1.15, 0.34, 0.3
2891, 1.15, 1.06, 0.4
2892, 1.15, 0.82, 0.4
2893, 1.15, 0.58, 0.4
2894, 1.15, 0.34, 0.4
2895, 1.15, 1.06, 0.05
2896, 1.15, 1.18, 0.1
2897, 1.15, 0.82, 0.05
2898, 1.15, 0.94, 0.1
2899, 1.15, 0.58, 0.05
2900, 1.15, 0.7, 0.1
2901, 1.15, 0.34, 0.05
2902, 1.15, 0.46, 0.1
2903, 1.15, 0.22, 0.1
2904, 1.15, 1.06, 0.15
2905, 1.15, 1.18, 0.2
2906, 1.15, 0.82, 0.15
2907, 1.15, 0.94, 0.2
2908, 1.15, 0.58, 0.15
2909, 1.15, 0.7, 0.2
2910, 1.15, 0.34, 0.15
2911, 1.15, 0.46, 0.2
2912, 1.15, 0.22, 0.2
2913, 1.15, 1.06, 0.25
2914, 1.15, 1.18, 0.3
2915, 1.15, 0.82, 0.25
2916, 1.15, 0.94, 0.3
2917, 1.15, 0.58, 0.25
2918, 1.15, 0.7, 0.3
2919, 1.15, 0.34, 0.25
2920, 1.15, 0.46, 0.3
2921, 1.15, 0.22, 0.3
2922, 1.15, 1.06, 0.35
2923, 1.15, 1.18, 0.4
2924, 1.15, 0.82, 0.35
2925, 1.15, 0.94, 0.4
2926, 1.15, 0.58, 0.35
2927, 1.15, 0.7, 0.4
2928, 1.15, 0.34, 0.35
2929, 1.15, 0.46, 0.4
2930, 1.15, 0.22, 0.4
2931, 1.15, 1.06, 0.45
2932, 1.15, 0.82, 0.45
2933, 1.15, 0.58, 0.45
2934, 1.15, 0.34, 0.45
2935, 1, 0.34, -0.05
2936, 1, 0.58, -0.05
2937, 1, 0.82, -0.05
2938, 1, 1.06, -0.05
2939, 0, 0.34, -0.05
2940, 0, 0.58, -0.05
2941, 0, 0.82, -0.05
2942, 0, 1.06, -0.05
2943, 0.2, 0.1, -0.05
2944, 0.4, 0.1, -0.05
2945, 0.6, 0.1, -0.05
2946, 0.8, 0.1, -0.05
2947, 0.2, 1.3, -0.05
2948, 0.4, 1.3, -0.05
2949, 0.6, 1.3, -0.05
2950, 0.8, 1.3, -0.05
2951, 0.2, 0.34, -0.1
2952, 0.2, 0.58, -0.1
2953, 0.2, 0.82, -0.1
2954, 0.2, 1.06, -0.1
2955, 0.4, 0.34, -0.1
2956, 0.4, 0.58, -0.1
2957, 0.4, 0.82, -0.1
2958, 0.4, 1.06, -0.1
2959, 0.6, 0.34, -0.1
2960, 0.6, 0.58, -0.1
2961, 0.6, 0.82, -0.1
2962, 0.6, 1.06, -0.1
2963, 0.8, 0.34, -0.1
2964, 0.8, 0.58, -0.1
2965, 0.8, 0.82, -0.1
2966, 0.8, 1.06, -0.1
2967, 0.1, 0.34, -0.1
2968, 0.2, 0.22, -0.1
2969, 0.1, 0.58, -0.1
2970, 0.2, 0.46, -0.1
2971, 0.1, 0.82, -0.1
2972, 0.2, 0.7, -0.1
2973, 0.1, 1.06, -0.1
2974, 0.2, 0.94, -0.1
2975, 0.2, 1.18, -0.1
2976, 0.3, 0.34, -0.1
2977, 0.4, 0.22, -0.1
2978, 0.3, 0.58, -0.1
2979, 0.4, 0.46, -0.1
2980, 0.3, 0.82, -0.1
2981, 0.4, 0.7, -0.1
2982, 0.3, 1.06, -0.1
2983, 0.4, 0.94, -0.1
2984, 0.4, 1.18, -0.1
2985, 0.5, 0.34, -0.1
2986, 0.6, 0.22, -0.1
2987, 0.5, 0.58, -0.1
2988, 0.6, 0.46, -0.1
2989, 0.5, 0.82, -0.1
2990, 0.6, 0.7, -0.1
2991, 0.5, 1.06, -0.1
2992, 0.6, 0.94, -0.1
2993, 0.6, 1.18, -0.1
2994, 0.7, 0.34, -0.1
2995, 0.8, 0.22, -0.1
2996, 0.7, 0.58, -0.1
2997, 0.8, 0.46, -0.1
2998, 0.7, 0.82, -0.1
2999, 0.8, 0.7, -0.1
3000, 0.7, 1.06, -0.1
3001, 0.8, 0.94, -0.1
3002, 0.8, 1.18, -0.1
3003, 0.9, 0.34, -0.1
3004, 0.9, 0.58, -0.1
3005, 0.9, 0.82, -0.1
3006, 0.9, 1.06, -0.1
3007, 1.2, 1.06, -0.05
3008, 1.2, 0.82, -0.05
3009, 1.2, 0.58, -0.05
3010, 1.2, 0.34, -0.05
3011, 2.2, 1.06, -0.05
3012, 2.2, 0.82, -0.05
3013, 2.2, 0.58, -0.05
3014, 2.2, 0.34, -0.05
3015, 1.4, 1.3, -0.05
3016, 1.6, 1.3, -0.05
3017, 1.8, 1.3, -0.05
3018, 2, 1.3, -0.05
3019, 1.4, 0.1, -0.05
3020, 1.6, 0.1, -0.05
3021, 1.8, 0.1, -0.05
3022, 2, 0.1, -0.05
3023, 1.4, 1.06, -0.1
3024, 1.4, 0.82, -0.1
3025, 1.4, 0.58, -0.1
3026, 1.4, 0.34, -0.1
3027, 1.6, 1.06, -0.1
3028, 1.6, 0.82, -0.1
3029, 1.6, 0.58, -0.1
3030, 1.6, 0.34, -0.1
3031, 1.8, 1.06, -0.1
3032, 1.8, 0.82, -0.1
3033, 1.8, 0.58, -0.1
3034, 1.8, 0.34, -0.1
3035, 2, 1.06, -0.1
3036, 2, 0.82, -0.1
3037, 2, 0.58, -0.1
3038, 2, 0.34, -0.1
3039, 1.4, 1.18, -0.1
3040, 1.3, 1.06, -0.1
3041, 1.4, 0.94, -0.1
3042, 1.3, 0.82, -0.1
3043, 1.4, 0.7, -0.1
3044, 1.3, 0.58, -0.1
3045, 1.4, 0.46, -0.1
3046, 1.3, 0.34, -0.1
3047, 1.4, 0.22, -0.1
3048, 1.6, 1.18, -0.1
3049, 1.5, 1.06, -0.1
3050, 1.6, 0.94, -0.1
3051, 1.5, 0.82, -0.1
3052, 1.6, 0.7, -0.1
3053, 1.5, 0.58, -0.1
3054, 1.6, 0.46, -0.1
3055, 1.5, 0.34, -0.1
3056, 1.6, 0.22, -0.1
3057, 1.8, 1.18, -0.1
3058, 1.7, 1.06, -0.1
3059, 1.8, 0.94, -0.1
3060, 1.7, 0.82, -0.1
3061, 1.8, 0.7, -0.1
3062, 1.7, 0.58, -0.1
3063, 1.8, 0.46, -0.1
3064, 1.7, 0.34, -0.1
3065, 1.8, 0.22, -0.1
3066, 2, 1.18, -0.1
3067, 1.9, 1.06, -0.1
3068, 2, 0.94, -0.1
3069, 1.9, 0.82, -0.1
3070, 2, 0.7, -0.1
3071, 1.9, 0.58, -0.1
3072, 2, 0.46, -0.1
3073, 1.9, 0.34, -0.1
3074, 2, 0.22, -0.1
3075, 2.1, 1.06, -0.1
3076, 2.1, 0.82, -0.1
3077, 2.1, 0.58, -0.1
3078, 2.1, 0.34, -0.1
3079, 1.15, 1.06, -0.05
3080, 1.15, 0.82, -0.05
3081, 1.15, 0.58, -0.05
3082, 1.15, 0.34, -0.05
3083, 1.175, 1.06, -0.1
3084, 1.175, 0.82, -0.1
3085, 1.175, 0.58, -0.1
3086, 1.175, 0.34, -0.1
3087, 1.05, 0.34, -0.05
3088, 1.05, 0.58, -0.05
3089, 1.05, 0.82, -0.05
3090, 1.05, 1.06, -0.05
3091, 1.025, 0.34, -0.1
3092, 1.025, 0.58, -0.1
3093, 1.025, 0.82, -0.1
3094, 1.025, 1.06, -0.1
3095, 0.2, 1.4666666666667, 0
3096, 0.2, 1.5333333333333, 0
3097, 0.4, 1.4666666666667, 0
3098, 0.4, 1.5333333333333, 0
3099, 0.6, 1.4666666666667, 0
3100, 0.6, 1.5333333333333, 0
3101, 0.8, 1.4666666666667, 0
3102, 0.8, 1.5333333333333, 0
3103, 0.1, 1.4666666666667, 0
3104, 0.2, 1.4333333333333, 0
3105, 0.1, 1.5333333333333, 0
3106, 0.2, 1.5, 0
3107, 0.2, 1.5666666666667, 0
3108, 0.3, 1.4666666666667, 0
3109, 0.4, 1.4333333333333, 0
3110, 0.3, 1.5333333333333, 0
3111, 0.4, 1.5, 0
3112, 0.4, 1.5666666666667, 0
3113, 0.5, 1.4666666666667, 0
3114, 0.6, 1.4333333333333, 0
3115, 0.5, 1.5333333333333, 0
3116, 0.6, 1.5, 0
3117, 0.6, 1.5666666666667, 0
3118, 0.7, 1.4666666666667, 0
3119, 0.8, 1.4333333333333, 0
3120, 0.7, 1.5333333333333, 0
3121, 0.8, 1.5, 0
3122, 0.8, 1.5666666666667, 0
3123, 0.9, 1.4666666666667, 0
3124, 0.9, 1.5333333333333, 0
3125, 1, 1.4666666666667, 0.1
3126, 1, 1.5333333333333, 0.1
3127, 1, 1.4666666666667, 0.2
3128, 1, 1.5333333333333, 0.2
3129, 1, 1.4666666666667, 0.3
3130, 1, 1.5333333333333, 0.3
3131, 1, 1.4666666666667, 0.4
3132, 1, 1.5333333333333, 0.4
3133, 1, 1.4666666666667, 0.05
3134, 1, 1.4333333333333, 0.1
3135, 1, 1.5333333333333, 0.05
3136, 1, 1.5, 0.1
3137, 1, 1.5666666666667, 0.1
3138, 1, 1.4666666666667, 0.15
3139, 1, 1.4333333333333, 0.2
3140, 1, 1.5333333333333, 0.15
3141, 1, 1.5, 0.2
3142, 1, 1.5666666666667, 0.2
3143, 1, 1.4666666666667, 0.25
3144, 1, 1.4333333333333, 0.3
3145, 1, 1.5333333333333, 0.25
3146, 1, 1.5, 0.3
3147, 1, 1.5666666666667, 0.3
3148, 1, 1.4666666666667, 0.35
3149, 1, 1.4333333333333, 0.4
3150, 1, 1.5333333333333, 0.35
3151, 1, 1.5, 0.4
3152, 1, 1.5666666666667, 0.4
3153, 1, 1.4666666666667, 0.45
3154, 1, 1.5333333333333, 0.45
3155, 0.2, 1.4666666666667, 0.5
3156, 0.2, 1.5333333333333, 0.5
3157, 0.4, 1.4666666666667, 0.5
3158, 0.4, 1.5333333333333, 0.5
3159, 0.6, 1.4666666666667, 0.5
3160, 0.6, 1.5333333333333, 0.5
3161, 0.8, 1.4666666666667, 0.5
3162, 0.8, 1.5333333333333, 0.5
3163, 0.2, 1.4333333333333, 0.5
3164, 0.1, 1.4666666666667, 0.5
3165, 0.2, 1.5, 0.5
3166, 0.1, 1.5333333333333, 0.5
3167, 0.2, 1.5666666666667, 0.5
3168, 0.4, 1.4333333333333, 0.5
3169, 0.3, 1.4666666666667, 0.5
3170, 0.4, 1.5, 0.5
3171, 0.3, 1.5333333333333, 0.5
3172, 0.4, 1.5666666666667, 0.5
3173, 0.6, 1.4333333333333, 0.5
3174, 0.5, 1.4666666666667, 0.5
3175, 0.6, 1.5, 0.5
3176, 0.5, 1.5333333333333, 0.5
3177, 0.6, 1.5666666666667, 0.5
3178, 0.8, 1.4333333333333, 0.5
3179, 0.7, 1.4666666666667, 0.5
3180, 0.8, 1.5, 0.5
3181, 0.7, 1.5333333333333, 0.5
3182, 0.8, 1.5666666666667, 0.5
3183, 0.9, 1.4666666666667, 0.5
3184, 0.9, 1.5333333333333, 0.5
3185, 0, 1.4666666666667, 0.1
3186, 0, 1.5333333333333, 0.1
3187, 0, 1.4666666666667, 0.2
3188, 0, 1.5333333333333, 0.2
3189, 0, 1.4666666666667, 0.3
3190, 0, 1.5333333333333, 0.3
3191, 0, 1.4666666666667, 0.4
3192, 0, 1.5333333333333, 0.4
3193, 0, 1.4333333333333, 0.1
3194, 0, 1.4666666666667, 0.05
3195, 0, 1.5, 0.1
3196, 0, 1.5333333333333, 0.05
3197, 0, 1.5666666666667, 0.1
3198, 0, 1.4333333333333, 0.2
3199, 0, 1.4666666666667, 0.15
3200, 0, 1.5, 0.2
3201, 0, 1.5333333333333, 0.15
3202, 0, 1.5666666666667, 0.2
3203, 0, 1.4333333333333, 0.3
3204, 0, 1.4666666666667, 0.25
3205, 0, 1.5, 0.3
3206, 0, 1.5333333333333, 0.25
3207, 0, 1.5666666666667, 0.3
3208, 0, 1.4333333333333, 0.4
3209, 0, 1.4666666666667, 0.35
3210, 0, 1.5, 0.4
3211, 0, 1.5333333333333, 0.35
3212, 0, 1.5666666666667, 0.4
3213, 0, 1.4666666666667, 0.45
3214, 0, 1.5333333333333, 0.45
3215, 0.2, 1.6, 0.1
3216, 0.2, 1.6, 0.2
3217, 0.2, 1.6, 0.3
3218, 0.2, 1.6, 0.4
3219, 0.4, 1.6, 0.1
3220, 0.4, 1.6, 0.2
3221, 0.4, 1.6, 0.3
3222, 0.4, 1.6, 0.4
3223, 0.6, 1.6, 0.1
3224, 0.6, 1.6, 0.2
3225, 0.6, 1.6, 0.3
3226, 0.6, 1.6, 0.4
3227, 0.8, 1.6, 0.1
3228, 0.8, 1.6, 0.2
3229, 0.8, 1.6, 0.3
3230, 0.8, 1.6, 0.4
3231, 0.1, 1.6, 0.1
3232, 0.2, 1.6, 0.05
3233, 0.1, 1.6, 0.2
3234, 0.2, 1.6, 0.15
3235, 0.1, 1.6, 0.3
3236, 0.2, 1.6, 0.25
3237, 0.1, 1.6, 0.4
3238, 0.2, 1.6, 0.35
3239, 0.2, 1.6, 0.45
3240, 0.3, 1.6, 0.1
3241, 0.4, 1.6, 0.05
3242, 0.3, 1.6, 0.2
3243, 0.4, 1.6, 0.15
3244, 0.3, 1.6, 0.3
3245, 0.4, 1.6, 0.25
3246, 0.3, 1.6, 0.4
3247, 0.4, 1.6, 0.35
3248, 0.4, 1.6, 0.45
3249, 0.5, 1.6, 0.1
3250, 0.6, 1.6, 0.05
3251, 0.5, 1.6, 0.2
3252, 0.6, 1.6, 0.15
3253, 0.5, 1.6, 0.3
3254, 0.6, 1.6, 0.25
3255, 0.5, 1.6, 0.4
3256, 0.6, 1.6, 0.35
3257, 0.6, 1.6, 0.45
3258, 0.7, 1.6, 0.1
3259, 0.8, 1.6, 0.05
3260, 0.7, 1.6, 0.2
3261, 0.8, 1.6, 0.15
3262, 0.7, 1.6, 0.3
3263, 0.8, 1.6, 0.25
3264, 0.7, 1.6, 0.4
3265, 0.8, 1.6, 0.35
3266, 0.8, 1.6, 0.45
3267, 0.9, 1.6, 0.1
3268, 0.9, 1.6, 0.2
3269, 0.9, 1.6, 0.3
3270, 0.9, 1.6, 0.4
3271, 1.0666666666667, 1.4666666666667, 0.5
3272, 1.0666666666667, 1.5333333333333, 0.5
3273, 1.1333333333333, 1.4666666666667, 0.5
3274, 1.1333333333333, 1.5333333333333, 0.5
3275, 1.0666666666667, 1.4333333333333, 0.5
3276, 1.0333333333333, 1.4666666666667, 0.5
3277, 1.0666666666667, 1.5, 0.5
3278, 1.0333333333333, 1.5333333333333, 0.5
3279, 1.0666666666667, 1.5666666666667, 0.5
3280, 1.1333333333333, 1.4333333333333, 0.5
3281, 1.1, 1.4666666666667, 0.5
3282, 1.1333333333333, 1.5, 0.5
3283, 1.1, 1.5333333333333, 0.5
3284, 1.1333333333333, 1.5666666666667, 0.5
3285, 1.1666666666667, 1.4666666666667, 0.5
3286, 1.1666666666667, 1.5333333333333, 0.5
3287, 1.0666666666667, 1.4666666666667, 0
3288, 1.0666666666667, 1.5333333333333, 0
3289, 1.1333333333333, 1.4666666666667, 0
3290, 1.1333333333333, 1.5333333333333, 0
3291, 1.0333333333333, 1.4666666666667, 0
3292, 1.0666666666667, 1.4333333333333, 0
3293, 1.0333333333333, 1.5333333333333, 0
3294, 1.0666666666667, 1.5, 0
3295, 1.0666666666667, 1.5666666666667, 0
3296, 1.1, 1.4666666666667, 0
3297, 1.1333333333333, 1.4333333333333, 0
3298, 1.1, 1.5333333333333, 0
3299, 1.1333333333333, 1.5, 0
3300, 1.1333333333333, 1.5666666666667, 0
3301, 1.1666666666667, 1.4666666666667, 0
3302, 1.1666666666667, 1.5333333333333, 0
3303, 1.2, 1.4666666666667, 0.1
3304, 1.2, 1.5333333333333, 0.1
3305, 1.2, 1.4666666666667, 0.2
3306, 1.2, 1.5333333333333, 0.2
3307, 1.2, 1.4666666666667, 0.3
3308, 1.2, 1.5333333333333, 0.3
3309, 1.2, 1.4666666666667, 0.4
3310, 1.2, 1.5333333333333, 0.4
3311, 1.2, 1.4666666666667, 0.05
3312, 1.2, 1.4333333333333, 0.1
3313, 1.2, 1.5333333333333, 0.05
3314, 1.2, 1.5, 0.1
3315, 1.2, 1.5666666666667, 0.1
3316, 1.2, 1.4666666666667, 0.15
3317, 1.2, 1.4333333333333, 0.2
3318, 1.2, 1.5333333333333, 0.15
3319, 1.2, 1.5, 0.2
3320, 1.2, 1.5666666666667, 0.2
3321, 1.2, 1.4666666666667, 0.25
3322, 1.2, 1.4333333333333, 0.3
3323, 1.2, 1.5333333333333, 0.25
3324, 1.2, 1.5, 0.3
3325, 1.2, 1.5666666666667, 0.3
3326, 1.2, 1.4666666666667, 0.35
3327, 1.2, 1.4333333333333, 0.4
3328, 1.2, 1.5333333333333, 0.35
3329, 1.2, 1.5, 0.4
3330, 1.2, 1.5666666666667, 0.4
3331, 1.2, 1.4666666666667, 0.45
3332, 1.2, 1.5333333333333, 0.45
3333, 1.0666666666667, 1.6, 0.1
3334, 1.1333333333333, 1.6, 0.1
3335, 1.0666666666667, 1.6, 0.2
3336, 1.1333333333333, 1.6, 0.2
3337, 1.0666666666667, 1.6, 0.3
3338, 1.1333333333333, 1.6, 0.3
3339, 1.0666666666667, 1.6, 0.4
3340, 1.1333333333333, 1.6, 0.4
3341, 1.0333333333333, 1.6, 0.1
3342, 1.0666666666667, 1.6, 0.05
3343, 1.1, 1.6, 0.1
3344, 1.1333333333333, 1.6, 0.05
3345, 1.1666666666667, 1.6, 0.1
3346, 1.0333333333333, 1.6, 0.2
3347, 1.0666666666667, 1.6, 0.15
3348, 1.1, 1.6, 0.2
3349, 1.1333333333333, 1.6, 0.15
3350, 1.1666666666667, 1.6, 0.2
3351, 1.0333333333333, 1.6, 0.3
3352, 1.0666666666667, 1.6, 0.25
3353, 1.1, 1.6, 0.3
3354, 1.1333333333333, 1.6, 0.25
3355, 1.1666666666667, 1.6, 0.3
3356, 1.0333333333333, 1.6, 0.4
3357, 1.0666666666667, 1.6, 0.35
3358, 1.1, 1.6, 0.4
3359, 1.1333333333333, 1.6, 0.35
3360, 1.1666666666667, 1.6, 0.4
3361, 1.0666666666667, 1.6, 0.45
3362, 1.1333333333333, 1.6, 0.45
3363, 1.4, 1.4666666666667, 0.5
3364, 1.4, 1.5333333333333, 0.5
3365, 1.6, 1.4666666666667, 0.5
3366, 1.6, 1.5333333333333, 0.5
3367, 1.8, 1.4666666666667, 0.5
3368, 1.8, 1.5333333333333, 0.5
3369, 2, 1.4666666666667, 0.5
3370, 2, 1.5333333333333, 0.5
3371, 1.4, 1.4333333333333, 0.5
3372, 1.3, 1.4666666666667, 0.5
3373, 1.4, 1.5, 0.5
3374, 1.3, 1.5333333333333, 0.5
3375, 1.4, 1.5666666666667, 0.5
3376, 1.6, 1.4333333333333, 0.5
3377, 1.5, 1.4666666666667, 0.5
3378, 1.6, 1.5, 0.5
3379, 1.5, 1.5333333333333, 0.5
3380, 1.6, 1.5666666666667, 0.5
3381, 1.8, 1.4333333333333, 0.5
3382, 1.7, 1.4666666666667, 0.5
3383, 1.8, 1.5, 0.5
3384, 1.7, 1.5333333333333, 0.5
3385, 1.8, 1.5666666666667, 0.5
3386, 2, 1.4333333333333, 0.5
3387, 1.9, 1.4666666666667, 0.5
3388, 2, 1.5, 0.5
3389, 1.9, 1.5333333333333, 0.5
3390, 2, 1.5666666666667, 0.5
3391, 2.1, 1.4666666666667, 0.5
3392, 2.1, 1.5333333333333, 0.5
3393, 1.4, 1.4666666666667, 0
3394, 1.4, 1.5333333333333, 0
3395, 1.6, 1.4666666666667, 0
3396, 1.6, 1.5333333333333, 0
3397, 1.8, 1.4666666666667, 0
3398, 1.8, 1.5333333333333, 0
3399, 2, 1.4666666666667, 0
3400, 2, 1.5333333333333, 0
3401, 1.3, 1.4666666666667, 0
3402, 1.4, 1.4333333333333, 0
3403, 1.3, 1.5333333333333, 0
3404, 1.4, 1.5, 0
3405, 1.4, 1.5666666666667, 0
3406, 1.5, 1.4666666666667, 0
3407, 1.6, 1.4333333333333, 0
3408, 1.5, 1.5333333333333, 0
3409, 1.6, 1.5, 0
3410, 1.6, 1.5666666666667, 0
3411, 1.7, 1.4666666666667, 0
3412, 1.8, 1.4333333333333, 0
3413, 1.7, 1.5333333333333, 0
3414, 1.8, 1.5, 0
3415, 1.8, 1.5666666666667, 0
3416, 1.9, 1.4666666666667, 0
3417, 2, 1.4333333333333, 0
3418, 1.9, 1.5333333333333, 0
3419, 2, 1.5, 0
3420, 2, 1.5666666666667, 0
3421, 2.1, 1.4666666666667, 0
3422, 2.1, 1.5333333333333, 0
3423, 2.2, 1.4666666666667, 0.1
3424, 2.2, 1.5333333333333, 0.1
3425, 2.2, 1.4666666666667, 0.2
3426, 2.2, 1.5333333333333, 0.2
3427, 2.2, 1.4666666666667, 0.3
3428, 2.2, 1.5333333333333, 0.3
3429, 2.2, 1.4666666666667, 0.4
3430, 2.2, 1.5333333333333, 0.4
3431, 2.2, 1.4666666666667, 0.05
3432, 2.2, 1.4333333333333, 0.1
3433, 2.2, 1.5333333333333, 0.05
3434, 2.2, 1.5, 0.1
3435, 2.2, 1.5666666666667, 0.1
3436, 2.2, 1.4666666666667, 0.15
3437, 2.2, 1.4333333333333, 0.2
3438, 2.2, 1.5333333333333, 0.15
3439, 2.2, 1.5, 0.2
3440, 2.2, 1.5666666666667, 0.2
3441, 2.2, 1.4666666666667, 0.25
3442, 2.2, 1.4333333333333, 0.3
3443, 2.2, 1.5333333333333, 0.25
3444, 2.2, 1.5, 0.3
3445, 2.2, 1.5666666666667, 0.3
3446, 2.2, 1.4666666666667, 0.35
3447, 2.2, 1.4333333333333, 0.4
3448, 2.2, 1.5333333333333, 0.35
3449, 2.2, 1.5, 0.4
3450, 2.2, 1.5666666666667, 0.4
3451, 2.2, 1.4666666666667, 0.45
3452, 2.2, 1.5333333333333, 0.45
3453, 1.4, 1.6, 0.1
3454, 1.6, 1.6, 0.1
3455, 1.8, 1.6, 0.1
3456, 2, 1.6, 0.1
3457, 1.4, 1.6, 0.2
3458, 1.6, 1.6, 0.2
3459, 1.8, 1.6, 0.2
3460, 2, 1.6, 0.2
3461, 1.4, 1.6, 0.3
3462, 1.6, 1.6, 0.3
3463, 1.8, 1.6, 0.3
3464, 2, 1.6, 0.3
3465, 1.4, 1.6, 0.4
3466, 1.6, 1.6, 0.4
3467, 1.8, 1.6, 0.4
3468, 2, 1.6, 0.4
3469, 1.3, 1.6, 0.1
3470, 1.4, 1.6, 0.05
3471, 1.5, 1.6, 0.1
3472, 1.6, 1.6, 0.05
3473, 1.7, 1.6, 0.1
3474, 1.8, 1.6, 0.05
3475, 1.9, 1.6, 0.1
3476, 2, 1.6, 0.05
3477, 2.1, 1.6, 0.1
3478, 1.3, 1.6, 0.2
3479, 1.4, 1.6, 0.15
3480, 1.5, 1.6, 0.2
3481, 1.6, 1.6, 0.15
3482, 1.7, 1.6, 0.2
3483, 1.8, 1.6, 0.15
3484, 1.9, 1.6, 0.2
3485, 2, 1.6, 0.15
3486, 2.1, 1.6, 0.2
3487, 1.3, 1.6, 0.3
3488, 1.4, 1.6, 0.25
3489, 1.5, 1.6, 0.3
3490, 1.6, 1.6, 0.25
3491, 1.7, 1.6, 0.3
3492, 1.8, 1.6, 0.25
3493, 1.9, 1.6, 0.3
3494, 2, 1.6, 0.25
3495, 2.1, 1.6, 0.3
3496, 1.3, 1.6, 0.4
3497, 1.4, 1.6, 0.35
3498, 1.5, 1.6, 0.4
3499, 1.6, 1.6, 0.35
3500, 1.7, 1.6, 0.4
3501, 1.8, 1.6, 0.35
3502, 1.9, 1.6, 0.4
3503, 2, 1.6, 0.35
3504, 2.1, 1.6, 0.4
3505, 1.4, 1.6, 0.45
3506, 1.6, 1.6, 0.45
3507, 1.8, 1.6, 0.45
3508, 2, 1.6, 0.45
3509, 0.2, -0.066666666666667, 0
3510, 0.2, -0.13333333333333, 0
3511, 0.4, -0.066666666666667, 0
3512, 0.4, -0.13333333333333, 0
3513, 0.6, -0.066666666666667, 0
3514, 0.6, -0.13333333333333, 0
3515, 0.8, -0.066666666666667, 0
3516, 0.8, -0.13333333333333, 0
3517, 0.2, -0.033333333333333, 0
3518, 0.1, -0.066666666666667, 0
3519, 0.2, -0.1, 0
3520, 0.1, -0.13333333333333, 0
3521, 0.2, -0.16666666666667, 0
3522, 0.4, -0.033333333333333, 0
3523, 0.3, -0.066666666666667, 0
3524, 0.4, -0.1, 0
3525, 0.3, -0.13333333333333, 0
3526, 0.4, -0.16666666666667, 0
3527, 0.6, -0.033333333333333, 0
3528, 0.5, -0.066666666666667, 0
3529, 0.6, -0.1, 0
3530, 0.5, -0.13333333333333, 0
3531, 0.6, -0.16666666666667, 0
3532, 0.8, -0.033333333333333, 0
3533, 0.7, -0.066666666666667, 0
3534, 0.8, -0.1, 0
3535, 0.7, -0.13333333333333, 0
3536, 0.8, -0.16666666666667, 0
3537, 0.9, -0.066666666666667, 0
3538, 0.9, -0.13333333333333, 0
3539, 1, -0.066666666666667, 0.1
3540, 1, -0.13333333333333, 0.1
3541, 1, -0.066666666666667, 0.2
3542, 1, -0.13333333333333, 0.2
3543, 1, -0.066666666666667, 0.3
3544, 1, -0.13333333333333, 0.3
3545, 1, -0.066666666666667, 0.4
3546, 1, -0.13333333333333, 0.4
3547, 1, -0.033333333333333, 0.1
3548, 1, -0.066666666666667, 0.05
3549, 1, -0.1, 0.1
3550, 1, -0.13333333333333, 0.05
3551, 1, -0.16666666666667, 0.1
3552, 1, -0.033333333333333, 0.2
3553, 1, -0.066666666666667, 0.15
3554, 1, -0.1, 0.2
3555, 1, -0.13333333333333, 0.15
3556, 1, -0.16666666666667, 0.2
3557, 1, -0.033333333333333, 0.3
3558, 1, -0.066666666666667, 0.25
3559, 1, -0.1, 0.3
3560, 1, -0.13333333333333, 0.25
3561, 1, -0.16666666666667, 0.3
3562, 1, -0.033333333333333, 0.4
3563, 1, -0.066666666666667, 0.35
3564, 1, -0.1, 0.4
3565, 1, -0.13333333333333, 0.35
3566, 1, -0.16666666666667, 0.4
3567, 1, -0.066666666666667, 0.45
3568, 1, -0.13333333333333, 0.45
3569, 0.2, -0.066666666666667, 0.5
3570, 0.2, -0.13333333333333, 0.5
3571, 0.4, -0.066666666666667, 0.5
3572, 0.4, -0.13333333333333, 0.5
3573, 0.6, -0.066666666666667, 0.5
3574, 0.6, -0.13333333333333, 0.5
3575, 0.8, -0.066666666666667, 0.5
3576, 0.8, -0.13333333333333, 0.5
3577, 0.1, -0.066666666666667, 0.5
3578, 0.2, -0.033333333333333, 0.5
3579, 0.1, -0.13333333333333, 0.5
3580, 0.2, -0.1, 0.5
3581, 0.2, -0.16666666666667, 0.5
3582, 0.3, -0.066666666666667, 0.5
3583, 0.4, -0.033333333333333, 0.5
3584, 0.3, -0.13333333333333, 0.5
3585, 0.4, -0.1, 0.5
3586, 0.4, -0.16666666666667, 0.5
3587, 0.5, -0.066666666666667, 0.5
3588, 0.6, -0.033333333333333, 0.5
3589, 0.5, -0.13333333333333, 0.5
3590, 0.6, -0.1, 0.5
3591, 0.6, -0.16666666666667, 0.5
3592, 0.7, -0.066666666666667, 0.5
3593, 0.8, -0.033333333333333, 0.5
3594, 0.7, -0.13333333333333, 0.5
3595, 0.8, -0.1, 0.5
3596, 0.8, -0.16666666666667, 0.5
3597, 0.9, -0.066666666666667, 0.5
3598, 0.9, -0.13333333333333, 0.5
3599, 0, -0.066666666666667, 0.1
3600, 0, -0.13333333333333, 0.1
3601, 0, -0.066666666666667, 0.2
3602, 0, -0.13333333333333, 0.2
3603, 0, -0.066666666666667, 0.3
3604, 0, -0.13333333333333, 0.3
3605, 0, -0.066666666666667, 0.4
3606, 0, -0.13333333333333, 0.4
3607, 0, -0.066666666666667, 0.05
3608, 0, -0.033333333333333, 0.1
3609, 0, -0.13333333333333, 0.05
3610, 0, -0.1, 0.1
3611, 0, -0.16666666666667, 0.1
3612, 0, -0.066666666666667, 0.15
3613, 0, -0.033333333333333, 0.2
3614, 0, -0.13333333333333, 0.15
3615, 0, -0.1, 0.2
3616, 0, -0.16666666666667, 0.2
3617, 0, -0.066666666666667, 0.25
3618, 0, -0.033333333333333, 0.3
3619, 0, -0.13333333333333, 0.25
3620, 0, -0.1, 0.3
3621, 0, -0.16666666666667, 0.3
3622, 0, -0.066666666666667, 0.35
3623, 0, -0.033333333333333, 0.4
3624, 0, -0.13333333333333, 0.35
3625, 0, -0.1, 0.4
3626, 0, -0.16666666666667, 0.4
3627, 0, -0.066666666666667, 0.45
3628, 0, -0.13333333333333, 0.45
3629, 0.2, -0.2, 0.1
3630, 0.2, -0.2, 0.2
3631, 0.2, -0.2, 0.3
3632, 0.2, -0.2, 0.4
3633, 0.4, -0.2, 0.1
3634, 0.4, -0.2, 0.2
3635, 0.4, -0.2, 0.3
3636, 0.4, -0.2, 0.4
3637, 0.6, -0.2, 0.1
3638, 0.6, -0.2, 0.2
3639, 0.6, -0.2, 0.3
3640, 0.6, -0.2, 0.4
3641, 0.8, -0.2, 0.1
3642, 0.8, -0.2, 0.2
3643, 0.8, -0.2, 0.3
3644, 0.8, -0.2, 0.4
3645, 0.2, -0.2, 0.05
3646, 0.1, -0.2, 0.1
3647, 0.2, -0.2, 0.15
3648, 0.1, -0.2, 0.2
3649, 0.2, -0.2, 0.25
3650, 0.1, -0.2, 0.3
3651, 0.2, -0.2, 0.35
3652, 0.1, -0.2, 0.4
3653, 0.2, -0.2, 0.45
3654, 0.4, -0.2, 0.05
3655, 0.3, -0.2, 0.1
3656, 0.4, -0.2, 0.15
3657, 0.3, -0.2, 0.2
3658, 0.4, -0.2, 0.25
3659, 0.3, -0.2, 0.3
3660, 0.4, -0.2, 0.35
3661, 0.3, -0.2, 0.4
3662, 0.4, -0.2, 0.45
3663, 0.6, -0.2, 0.05
3664, 0.5, -0.2, 0.1
3665, 0.6, -0.2, 0.15
3666, 0.5, -0.2, 0.2
3667, 0.6, -0.2, 0.25
3668, 0.5, -0.2, 0.3
3669, 0.6, -0.2, 0.35
3670, 0.5, -0.2, 0.4
3671, 0.6, -0.2, 0.45
3672, 0.8, -0.2, 0.05
3673, 0.7, -0.2, 0.1
3674, 0.8, -0.2, 0.15
3675, 0.7, -0.2, 0.2
3676, 0.8, -0.2, 0.25
3677, 0.7, -0.2, 0.3
3678, 0.8, -0.2, 0.35
3679, 0.7, -0.2, 0.4
3680, 0.8, -0.2, 0.45
3681, 0.9, -0.2, 0.1
3682, 0.9, -0.2, 0.2
3683, 0.9, -0.2, 0.3
3684, 0.9, -0.2, 0.4
3685, -0.05, -0.066666666666667, 0.5
3686, -0.05, -0.13333333333333, 0.5
3687, -0.05, -0.066666666666667, 0
3688, -0.05, -0.13333333333333, 0
3689, -0.1, -0.066666666666667, 0.1
3690, -0.1, -0.13333333333333, 0.1
3691, -0.1, -0.066666666666667, 0.2
3692, -0.1, -0.13333333333333, 0.2
3693, -0.1, -0.066666666666667, 0.3
3694, -0.1, -0.13333333333333, 0.3
3695, -0.1, -0.066666666666667, 0.4
3696, -0.1, -0.13333333333333, 0.4
3697, -0.1, -0.066666666666667, 0.05
3698, -0.1, -0.033333333333333, 0.1
3699, -0.1, -0.13333333333333, 0.05
3700, -0.1, -0.1, 0.1
3701, -0.1, -0.16666666666667, 0.1
3702, -0.1, -0.066666666666667, 0.15
3703, -0.1, -0.033333333333333, 0.2
3704, -0.1, -0.13333333333333, 0.15
3705, -0.1, -0.1, 0.2
3706, -0.1, -0.16666666666667, 0.2
3707, -0.1, -0.066666666666667, 0.25
3708, -0.1, -0.033333333333333, 0.3
3709, -0.1, -0.13333333333333, 0.25
3710, -0.1, -0.1, 0.3
3711, -0.1, -0.16666666666667, 0.3
3712, -0.1, -0.066666666666667, 0.35
3713, -0.1, -0.033333333333333, 0.4
3714, -0.1, -0.13333333333333, 0.35
3715, -0.1, -0.1, 0.4
3716, -0.1, -0.16666666666667, 0.4
3717, -0.1, -0.066666666666667, 0.45
3718, -0.1, -0.13333333333333, 0.45
3719, -0.05, -0.2, 0.1
3720, -0.05, -0.2, 0.2
3721, -0.05, -0.2, 0.3
3722, -0.05, -0.2, 0.4
3723, 1.4, -0.066666666666667, 0.5
3724, 1.4, -0.13333333333333, 0.5
3725, 1.6, -0.066666666666667, 0.5
3726, 1.6, -0.13333333333333, 0.5
3727, 1.8, -0.066666666666667, 0.5
3728, 1.8, -0.13333333333333, 0.5
3729, 2, -0.066666666666667, 0.5
3730, 2, -0.13333333333333, 0.5
3731, 1.3, -0.066666666666667, 0.5
3732, 1.4, -0.033333333333333, 0.5
3733, 1.3, -0.13333333333333, 0.5
3734, 1.4, -0.1, 0.5
3735, 1.4, -0.16666666666667, 0.5
3736, 1.5, -0.066666666666667, 0.5
3737, 1.6, -0.033333333333333, 0.5
3738, 1.5, -0.13333333333333, 0.5
3739, 1.6, -0.1, 0.5
3740, 1.6, -0.16666666666667, 0.5
3741, 1.7, -0.066666666666667, 0.5
3742, 1.8, -0.033333333333333, 0.5
3743, 1.7, -0.13333333333333, 0.5
3744, 1.8, -0.1, 0.5
3745, 1.8, -0.16666666666667, 0.5
3746, 1.9, -0.066666666666667, 0.5
3747, 2, -0.033333333333333, 0.5
3748, 1.9, -0.13333333333333, 0.5
3749, 2, -0.1, 0.5
3750, 2, -0.16666666666667, 0.5
3751, 2.1, -0.066666666666667, 0.5
3752, 2.1, -0.13333333333333, 0.5
3753, 1.4, -0.066666666666667, 0
3754, 1.4, -0.13333333333333, 0
3755, 1.6, -0.066666666666667, 0
3756, 1.6, -0.13333333333333, 0
3757, 1.8, -0.066666666666667, 0
3758, 1.8, -0.13333333333333, 0
3759, 2, -0.066666666666667, 0
3760, 2, -0.13333333333333, 0
3761, 1.4, -0.033333333333333, 0
3762, 1.3, -0.066666666666667, 0
3763, 1.4, -0.1, 0
3764, 1.3, -0.13333333333333, 0
3765, 1.4, -0.16666666666667, 0
3766, 1.6, -0.033333333333333, 0
3767, 1.5, -0.066666666666667, 0
3768, 1.6, -0.1, 0
3769, 1.5, -0.13333333333333, 0
3770, 1.6, -0.16666666666667, 0
3771, 1.8, -0.033333333333333, 0
3772, 1.7, -0.066666666666667, 0
3773, 1.8, -0.1, 0
3774, 1.7, -0.13333333333333, 0
3775, 1.8, -0.16666666666667, 0
3776, 2, -0.033333333333333, 0
3777, 1.9, -0.066666666666667, 0
3778, 2, -0.1, 0
3779, 1.9, -0.13333333333333, 0
3780, 2, -0.16666666666667, 0
3781, 2.1, -0.066666666666667, 0
3782, 2.1, -0.13333333333333, 0
3783, 1.2, -0.066666666666667, 0.1
3784, 1.2, -0.13333333333333, 0.1
3785, 1.2, -0.066666666666667, 0.2
3786, 1.2, -0.13333333333333, 0.2
3787, 1.2, -0.066666666666667, 0.3
3788, 1.2, -0.13333333333333, 0.3
3789, 1.2, -0.066666666666667, 0.4
3790, 1.2, -0.13333333333333, 0.4
3791, 1.2, -0.066666666666667, 0.05
3792, 1.2, -0.033333333333333, 0.1
3793, 1.2, -0.13333333333333, 0.05
3794, 1.2, -0.1, 0.1
3795, 1.2, -0.16666666666667, 0.1
3796, 1.2, -0.066666666666667, 0.15
3797, 1.2, -0.033333333333333, 0.2
3798, 1.2, -0.13333333333333, 0.15
3799, 1.2, -0.1, 0.2
3800, 1.2, -0.16666666666667, 0.2
3801, 1.2, -0.066666666666667, 0.25
3802, 1.2, -0.033333333333333, 0.3
3803, 1.2, -0.13333333333333, 0.25
3804, 1.2, -0.1, 0.3
3805, 1.2, -0.16666666666667, 0.3
3806, 1.2, -0.066666666666667, 0.35
3807, 1.2, -0.033333333333333, 0.4
3808, 1.2, -0.13333333333333, 0.35
3809, 1.2, -0.1, 0.4
3810, 1.2, -0.16666666666667, 0.4
3811, 1.2, -0.066666666666667, 0.45
3812, 1.2, -0.13333333333333, 0.45
3813, 2.2, -0.066666666666667, 0.1
3814, 2.2, -0.13333333333333, 0.1
3815, 2.2, -0.066666666666667, 0.2
3816, 2.2, -0.13333333333333, 0.2
3817, 2.2, -0.066666666666667, 0.3
3818, 2.2, -0.13333333333333, 0.3
3819, 2.2, -0.066666666666667, 0.4
3820, 2.2, -0.13333333333333, 0.4
3821, 2.2, -0.033333333333333, 0.1
3822, 2.2, -0.066666666666667, 0.05
3823, 2.2, -0.1, 0.1
3824, 2.2, -0.13333333333333, 0.05
3825, 2.2, -0.16666666666667, 0.1
3826, 2.2, -0.033333333333333, 0.2
3827, 2.2, -0.066666666666667, 0.15
3828, 2.2, -0.1, 0.2
3829, 2.2, -0.13333333333333, 0.15
3830, 2.2, -0.16666666666667, 0.2
3831, 2.2, -0.033333333333333, 0.3
3832, 2.2, -0.066666666666667, 0.25
3833, 2.2, -0.1, 0.3
3834, 2.2, -0.13333333333333, 0.25
3835, 2.2, -0.16666666666667, 0.3
3836, 2.2, -0.033333333333333, 0.4
3837, 2.2, -0.066666666666667, 0.35
3838, 2.2, -0.1, 0.4
3839, 2.2, -0.13333333333333, 0.35
3840, 2.2, -0.16666666666667, 0.4
3841, 2.2, -0.066666666666667, 0.45
3842, 2.2, -0.13333333333333, 0.45
3843, 1.4, -0.2, 0.1
3844, 1.6, -0.2, 0.1
3845, 1.8, -0.2, 0.1
3846, 2, -0.2, 0.1
3847, 1.4, -0.2, 0.2
3848, 1.6, -0.2, 0.2
3849, 1.8, -0.2, 0.2
3850, 2, -0.2, 0.2
3851, 1.4, -0.2, 0.3
3852, 1.6, -0.2, 0.3
3853, 1.8, -0.2, 0.3
3854, 2, -0.2, 0.3
3855, 1.4, -0.2, 0.4
3856, 1.6, -0.2, 0.4
3857, 1.8, -0.2, 0.4
3858, 2, -0.2, 0.4
3859, 1.4, -0.2, 0.05
3860, 1.3, -0.2, 0.1
3861, 1.6, -0.2, 0.05
3862, 1.5, -0.2, 0.1
3863, 1.8, -0.2, 0.05
3864, 1.7, -0.2, 0.1
3865, 2, -0.2, 0.05
3866, 1.9, -0.2, 0.1
3867, 2.1, -0.2, 0.1
3868, 1.4, -0.2, 0.15
3869, 1.3, -0.2, 0.2
3870, 1.6, -0.2, 0.15
3871, 1.5, -0.2, 0.2
3872, 1.8, -0.2, 0.15
3873, 1.7, -0.2, 0.2
3874, 2, -0.2, 0.15
3875, 1.9, -0.2, 0.2
3876, 2.1, -0.2, 0.2
3877, 1.4, -0.2, 0.25
3878, 1.3, -0.2, 0.3
3879, 1.6, -0.2, 0.25
3880, 1.5, -0.2, 0.3
3881, 1.8, -0.2, 0.25
3882, 1.7, -0.2, 0.3
3883, 2, -0.2, 0.25
3884, 1.9, -0.2, 0.3
3885, 2.1, -0.2, 0.3
3886, 1.4, -0.2, 0.35
3887, 1.3, -0.2, 0.4
3888, 1.6, -0.2, 0.35
3889, 1.5, -0.2, 0.4
3890, 1.8, -0.2, 0.35
3891, 1.7, -0.2, 0.4
3892, 2, -0.2, 0.35
3893, 1.9, -0.2, 0.4
3894, 2.1, -0.2, 0.4
3895, 1.4, -0.2, 0.45
3896, 1.6, -0.2, 0.45
3897, 1.8, -0.2, 0.45
3898, 2, -0.2, 0.45
3899, 2.25, -0.066666666666667, 0.5
3900, 2.25, -0.13333333333333, 0.5
3901, 2.25, -0.066666666666667, 0
3902, 2.25, -0.13333333333333, 0
3903, 2.3, -0.066666666666667, 0.1
3904, 2.3, -0.13333333333333, 0.1
3905, 2.3, -0.066666666666667, 0.2
3906, 2.3, -0.13333333333333, 0.2
3907, 2.3, -0.066666666666667, 0.3
3908, 2.3, -0.13333333333333, 0.3
3909, 2.3, -0.066666666666667, 0.4
3910, 2.3, -0.13333333333333, 0.4
3911, 2.3, -0.033333333333333, 0.1
3912, 2.3, -0.066666666666667, 0.05
3913, 2.3, -0.1, 0.1
3914, 2.3, -0.13333333333333, 0.05
3915, 2.3, -0.16666666666667, 0.1
3916, 2.3, -0.033333333333333, 0.2
3917, 2.3, -0.066666666666667, 0.15
3918, 2.3, -0.1, 0.2
3919, 2.3, -0.13333333333333, 0.15
3920, 2.3, -0.16666666666667, 0.2
3921, 2.3, -0.033333333333333, 0.3
3922, 2.3, -0.066666666666667, 0.25
3923, 2.3, -0.1, 0.3
3924, 2.3, -0.13333333333333, 0.25
3925, 2.3, -0.16666666666667, 0.3
3926, 2.3, -0.033333333333333, 0.4
3927, 2.3, -0.066666666666667, 0.35
3928, 2.3, -0.1, 0.4
3929, 2.3, -0.13333333333333, 0.35
3930, 2.3, -0.16666666666667, 0.4
3931, 2.3, -0.066666666666667, 0.45
3932, 2.3, -0.13333333333333, 0.45
3933, 2.25, -0.2, 0.1
3934, 2.25, -0.2, 0.2
3935, 2.25, -0.2, 0.3
3936, 2.25, -0.2, 0.4
3937, 0.2, 0.025, 0.1
3938, 0.4, 0.025, 0.1
3939, 0.6, 0.025, 0.1
3940, 0.8, 0.025, 0.1
3941, 0.2, 0.025, 0.2
3942, 0.4, 0.025, 0.2
3943, 0.6, 0.025, 0.2
3944, 0.8, 0.025, 0.2
3945, 0.2, 0.025, 0.3
3946, 0.4, 0.025, 0.3
3947, 0.6, 0.025, 0.3
3948, 0.8, 0.025, 0.3
3949, 0.2, 0.025, 0.4
3950, 0.4, 0.025, 0.4
3951, 0.6, 0.025, 0.4
3952, 0.8, 0.025, 0.4
3953, 0.1, 0.025, 0.1
3954, 0.2, 0.0125, 0.1
3955, 0.2, 0.025, 0.05
3956, 0.3, 0.025, 0.1
3957, 0.4, 0.0125, 0.1
3958, 0.4, 0.025, 0.05
3959, 0.5, 0.025, 0.1
3960, 0.6, 0.0125, 0.1
3961, 0.6, 0.025, 0.05
3962, 0.7, 0.025, 0.1
3963, 0.8, 0.0125, 0.1
3964, 0.8, 0.025, 0.05
3965, 0.9, 0.025, 0.1
3966, 0.2, 0.0375, 0.1
3967, 0.4, 0.0375, 0.1
3968, 0.6, 0.0375, 0.1
3969, 0.8, 0.0375, 0.1
3970, 0.1, 0.025, 0.2
3971, 0.2, 0.0125, 0.2
3972, 0.2, 0.025, 0.15
3973, 0.3, 0.025, 0.2
3974, 0.4, 0.0125, 0.2
3975, 0.4, 0.025, 0.15
3976, 0.5, 0.025, 0.2
3977, 0.6, 0.0125, 0.2
3978, 0.6, 0.025, 0.15
3979, 0.7, 0.025, 0.2
3980, 0.8, 0.0125, 0.2
3981, 0.8, 0.025, 0.15
3982, 0.9, 0.025, 0.2
3983, 0.2, 0.0375, 0.2
3984, 0.4, 0.0375, 0.2
3985, 0.6, 0.0375, 0.2
3986, 0.8, 0.0375, 0.2
3987, 0.1, 0.025, 0.3
3988, 0.2, 0.0125, 0.3
3989, 0.2, 0.025, 0.25
3990, 0.3, 0.025, 0.3
3991, 0.4, 0.0125, 0.3
3992, 0.4, 0.025, 0.25
3993, 0.5, 0.025, 0.3
3994, 0.6, 0.0125, 0.3
3995, 0.6, 0.025, 0.25
3996, 0.7, 0.025, 0.3
3997, 0.8, 0.0125, 0.3
3998, 0.8, 0.025, 0.25
3999, 0.9, 0.025, 0.3
4000, 0.2, 0.0375, 0.3
4001, 0.4, 0.0375, 0.3
4002, 0.6, 0.0375, 0.3
4003, 0.8, 0.0375, 0.3
4004, 0.1, 0.025, 0.4
4005, 0.2, 0.0125, 0.4
4006, 0.2, 0.025, 0.35
4007, 0.3, 0.025, 0.4
4008, 0.4, 0.0125, 0.4
4009, 0.4, 0.025, 0.35
4010, 0.5, 0.025, 0.4
4011, 0.6, 0.0125, 0.4
4012, 0.6, 0.025, 0.35
4013, 0.7, 0.025, 0.4
4014, 0.8, 0.0125, 0.4
4015, 0.8, 0.025, 0.35
4016, 0.9, 0.025, 0.4
4017, 0.2, 0.0375, 0.4
4018, 0.4, 0.0375, 0.4
4019, 0.6, 0.0375, 0.4
4020, 0.8, 0.0375, 0.4
4021, 0.2, 0.025, 0.45
4022, 0.4, 0.025, 0.45
4023, 0.6, 0.025, 0.45
4024, 0.8, 0.025, 0.45
4025, 0.2, 0.075, 0.1
4026, 0.2, 0.075, 0.2
4027, 0.2, 0.075, 0.3
4028, 0.2, 0.075, 0.4
4029, 0.4, 0.075, 0.1
4030, 0.4, 0.075, 0.2
4031, 0.4, 0.075, 0.3
4032, 0.4, 0.075, 0.4
4033, 0.6, 0.075, 0.1
4034, 0.6, 0.075, 0.2
4035, 0.6, 0.075, 0.3
4036, 0.6, 0.075, 0.4
4037, 0.8, 0.075, 0.1
4038, 0.8, 0.075, 0.2
4039, 0.8, 0.075, 0.3
4040, 0.8, 0.075, 0.4
4041, 0.2, 0.34, 0.1
4042, 0.2, 0.58, 0.1
4043, 0.2, 0.82, 0.1
4044, 0.2, 1.06, 0.1
4045, 0.2, 0.34, 0.2
4046, 0.2, 0.58, 0.2
4047, 0.2, 0.82, 0.2
4048, 0.2, 1.06, 0.2
4049, 0.2, 0.34, 0.3
4050, 0.2, 0.58, 0.3
4051, 0.2, 0.82, 0.3
4052, 0.2, 1.06, 0.3
4053, 0.2, 0.34, 0.4
4054, 0.2, 0.58, 0.4
4055, 0.2, 0.82, 0.4
4056, 0.2, 1.06, 0.4
4057, 0.4, 0.34, 0.1
4058, 0.4, 0.58, 0.1
4059, 0.4, 0.82, 0.1
4060, 0.4, 1.06, 0.1
4061, 0.4, 0.34, 0.2
4062, 0.4, 0.58, 0.2
4063, 0.4, 0.82, 0.2
4064, 0.4, 1.06, 0.2
4065, 0.4, 0.34, 0.3
4066, 0.4, 0.58, 0.3
4067, 0.4, 0.82, 0.3
4068, 0.4, 1.06, 0.3
4069, 0.4, 0.34, 0.4
4070, 0.4, 0.58, 0.4
4071, 0.4, 0.82, 0.4
4072, 0.4, 1.06, 0.4
4073, 0.6, 0.34, 0.1
4074, 0.6, 0.58, 0.1
4075, 0.6, 0.82, 0.1
4076, 0.6, 1.06, 0.1
4077, 0.6, 0.34, 0.2
4078, 0.6, 0.58, 0.2
4079, 0.6, 0.82, 0.2
4080, 0.6, 1.06, 0.2
4081, 0.6, 0.34, 0.3
4082, 0.6, 0.58, 0.3
4083, 0.6, 0.82, 0.3
4084, 0.6, 1.06, 0.3
4085, 0.6, 0.34, 0.4
4086, 0.6, 0.58, 0.4
4087, 0.6, 0.82, 0.4
4088, 0.6, 1.06, 0.4
4089, 0.8, 0.34, 0.1
4090, 0.8, 0.58, 0.1
4091, 0.8, 0.82, 0.1
4092, 0.8, 1.06, 0.1
4093, 0.8, 0.34, 0.2
4094, 0.8, 0.58, 0.2
4095, 0.8, 0.82, 0.2
4096, 0.8, 1.06, 0.2
4097, 0.8, 0.34, 0.3
4098, 0.8, 0.58, 0.3
4099, 0.8, 0.82, 0.3
4100, 0.8, 1.06, 0.3
4101, 0.8, 0.34, 0.4
4102, 0.8, 0.58, 0.4
4103, 0.8, 0.82, 0.4
4104, 0.8, 1.06, 0.4
4105, 0.2, 0.22, 0.1
4106, 0.1, 0.34, 0.1
4107, 0.2, 0.34, 0.05
4108, 0.2, 0.46, 0.1
4109, 0.1, 0.58, 0.1
4110, 0.2, 0.58, 0.05
4111, 0.2, 0.7, 0.1
4112, 0.1, 0.82, 0.1
4113, 0.2, 0.82, 0.05
4114, 0.2, 0.94, 0.1
4115, 0.1, 1.06, 0.1
4116, 0.2, 1.06, 0.05
4117, 0.2, 1.18, 0.1
4118, 0.2, 0.22, 0.2
4119, 0.1, 0.34, 0.2
4120, 0.2, 0.34, 0.15
4121, 0.2, 0.46, 0.2
4122, 0.1, 0.58, 0.2
4123, 0.2, 0.58, 0.15
4124, 0.2, 0.7, 0.2
4125, 0.1, 0.82, 0.2
4126, 0.2, 0.82, 0.15
4127, 0.2, 0.94, 0.2
4128, 0.1, 1.06, 0.2
4129, 0.2, 1.06, 0.15
4130, 0.2, 1.18, 0.2
4131, 0.2, 0.22, 0.3
4132, 0.1, 0.34, 0.3
4133, 0.2, 0.34, 0.25
4134, 0.2, 0.46, 0.3
4135, 0.1, 0.58, 0.3
4136, 0.2, 0.58, 0.25
4137, 0.2, 0.7, 0.3
4138, 0.1, 0.82, 0.3
4139, 0.2, 0.82, 0.25
4140, 0.2, 0.94, 0.3
4141, 0.1, 1.06, 0.3
4142, 0.2, 1.06, 0.25
4143, 0.2, 1.18, 0.3
4144, 0.2, 0.22, 0.4
4145, 0.1, 0.34, 0.4
4146, 0.2, 0.34, 0.35
4147, 0.2, 0.46, 0.4
4148, 0.1, 0.58, 0.4
4149, 0.2, 0.58, 0.35
4150, 0.2, 0.7, 0.4
4151, 0.1, 0.82, 0.4
4152, 0.2, 0.82, 0.35
4153, 0.2, 0.94, 0.4
4154, 0.1, 1.06, 0.4
4155, 0.2, 1.06, 0.35
4156, 0.2, 1.18, 0.4
4157, 0.2, 0.34, 0.45
4158, 0.2, 0.58, 0.45
4159, 0.2, 0.82, 0.45
4160, 0.2, 1.06, 0.45
4161, 0.4, 0.22, 0.1
4162, 0.3, 0.34, 0.1
4163, 0.4, 0.34, 0.05
4164, 0.4, 0.46, 0.1
4165, 0.3, 0.58, 0.1
4166, 0.4, 0.58, 0.05
4167, 0.4, 0.7, 0.1
4168, 0.3, 0.82, 0.1
4169, 0.4, 0.82, 0.05
4170, 0.4, 0.94, 0.1
4171, 0.3, 1.06, 0.1
4172, 0.4, 1.06, 0.05
4173, 0.4, 1.18, 0.1
4174, 0.4, 0.22, 0.2
4175, 0.3, 0.34, 0.2
4176, 0.4, 0.34, 0.15
4177, 0.4, 0.46, 0.2
4178, 0.3, 0.58, 0.2
4179, 0.4, 0.58, 0.15
4180, 0.4, 0.7, 0.2
4181, 0.3, 0.82, 0.2
4182, 0.4, 0.82, 0.15
4183, 0.4, 0.94, 0.2
4184, 0.3, 1.06, 0.2
4185, 0.4, 1.06, 0.15
4186, 0.4, 1.18, 0.2
4187, 0.4, 0.22, 0.3
4188, 0.3, 0.34, 0.3
4189, 0.4, 0.34, 0.25
4190, 0.4, 0.46, 0.3
4191, 0.3, 0.58, 0.3
4192, 0.4, 0.58, 0.25
4193, 0.4, 0.7, 0.3
4194, 0.3, 0.82, 0.3
4195, 0.4, 0.82, 0.25
4196, 0.4, 0.94, 0.3
4197, 0.3, 1.06, 0.3
4198, 0.4, 1.06, 0.25
4199, 0.4, 1.18, 0.3
4200, 0.4, 0.22, 0.4
4201, 0.3, 0.34, 0.4
4202, 0.4, 0.34, 0.35
4203, 0.4, 0.46, 0.4
4204, 0.3, 0.58, 0.4
4205, 0.4, 0.58, 0.35
4206, 0.4, 0.7, 0.4
4207, 0.3, 0.82, 0.4
4208, 0.4, 0.82, 0.35
4209, 0.4, 0.94, 0.4
4210, 0.3, 1.06, 0.4
4211, 0.4, 1.06, 0.35
4212, 0.4, 1.18, 0.4
4213, 0.4, 0.34, 0.45
4214, 0.4, 0.58, 0.45
4215, 0.4, 0.82, 0.45
4216, 0.4, 1.06, 0.45
4217, 0.6, 0.22, 0.1
4218, 0.5, 0.34, 0.1
4219, 0.6, 0.34, 0.05
4220, 0.6, 0.46, 0.1
4221, 0.5, 0.58, 0.1
4222, 0.6, 0.58, 0.05
4223, 0.6, 0.7, 0.1
4224, 0.5, 0.82, 0.1
4225, 0.6, 0.82, 0.05
4226, 0.6, 0.94, 0.1
4227, 0.5, 1.06, 0.1
4228, 0.6, 1.06, 0.05
4229, 0.6, 1.18, 0.1
4230, 0.6, 0.22, 0.2
4231, 0.5, 0.34, 0.2
4232, 0.6, 0.34, 0.15
4233, 0.6, 0.46, 0.2
4234, 0.5, 0.58, 0.2
4235, 0.6, 0.58, 0.15
4236, 0.6, 0.7, 0.2
4237, 0.5, 0.82, 0.2
4238, 0.6, 0.82, 0.15
4239, 0.6, 0.94, 0.2
4240, 0.5, 1.06, 0.2
4241, 0.6, 1.06, 0.15
4242, 0.6, 1.18, 0.2
4243, 0.6, 0.22, 0.3
4244, 0.5, 0.34, 0.3
4245, 0.6, 0.34, 0.25
4246, 0.6, 0.46, 0.3
4247, 0.5, 0.58, 0.3
4248, 0.6, 0.58, 0.25
4249, 0.6, 0.7, 0.3
4250, 0.5, 0.82, 0.3
4251, 0.6, 0.82, 0.25
4252, 0.6, 0.94, 0.3
4253, 0.5, 1.06, 0.3
4254, 0.6, 1.06, 0.25
4255, 0.6, 1.18, 0.3
4256, 0.6, 0.22, 0.4
4257, 0.5, 0.34, 0.4
4258, 0.6, 0.34, 0.35
4259, 0.6, 0.46, 0.4
4260, 0.5, 0.58, 0.4
4261, 0.6, 0.58, 0.35
4262, 0.6, 0.7, 0.4
4263, 0.5, 0.82, 0.4
4264, 0.6, 0.82, 0.35
4265, 0.6, 0.94, 0.4
4266, 0.5, 1.06, 0.4
4267, 0.6, 1.06, 0.35
4268, 0.6, 1.18, 0.4
4269, 0.6, 0.34, 0.45
4270, 0.6, 0.58, 0.45
4271, 0.6, 0.82, 0.45
4272, 0.6, 1.06, 0.45
4273, 0.8, 0.22, 0.1
4274, 0.7, 0.34, 0.1
4275, 0.8, 0.34, 0.05
4276, 0.8, 0.46, 0.1
4277, 0.7, 0.58, 0.1
4278, 0.8, 0.58, 0.05
4279, 0.8, 0.7, 0.1
4280, 0.7, 0.82, 0.1
4281, 0.8, 0.82, 0.05
4282, 0.8, 0.94, 0.1
4283, 0.7, 1.06, 0.1
4284, 0.8, 1.06, 0.05
4285, 0.8, 1.18, 0.1
4286, 0.8, 0.22, 0.2
4287, 0.7, 0.34, 0.2
4288, 0.8, 0.34, 0.15
4289, 0.8, 0.46, 0.2
4290, 0.7, 0.58, 0.2
4291, 0.8, 0.58, 0.15
4292, 0.8, 0.7, 0.2
4293, 0.7, 0.82, 0.2
4294, 0.8, 0.82, 0.15
4295, 0.8, 0.94, 0.2
4296, 0.7, 1.06, 0.2
4297, 0.8, 1.06, 0.15
4298, 0.8, 1.18, 0.2
4299, 0.8, 0.22, 0.3
4300, 0.7, 0.34, 0.3
4301, 0.8, 0.34, 0.25
4302, 0.8, 0.46, 0.3
4303, 0.7, 0.58, 0.3
4304, 0.8, 0.58, 0.25
4305, 0.8, 0.7, 0.3
4306, 0.7, 0.82, 0.3
4307, 0.8, 0.82, 0.25
4308, 0.8, 0.94, 0.3
4309, 0.7, 1.06, 0.3
4310, 0.8, 1.06, 0.25
4311, 0.8, 1.18, 0.3
4312, 0.8, 0.22, 0.4
4313, 0.7, 0.34, 0.4
4314, 0.8, 0.34, 0.35
4315, 0.8, 0.46, 0.4
4316, 0.7, 0.58, 0.4
4317, 0.8, 0.58, 0.35
4318, 0.8, 0.7, 0.4
4319, 0.7, 0.82, 0.4
4320, 0.8, 0.82, 0.35
4321, 0.8, 0.94, 0.4
4322, 0.7, 1.06, 0.4
4323, 0.8, 1.06, 0.35
4324, 0.8, 1.18, 0.4
4325, 0.8, 0.34, 0.45
4326, 0.8, 0.58, 0.45
4327, 0.8, 0.82, 0.45
4328, 0.8, 1.06, 0.45
4329, 0.9, 0.34, 0.1
4330, 0.9, 0.58, 0.1
4331, 0.9, 0.82, 0.1
4332, 0.9, 1.06, 0.1
4333, 0.9, 0.34, 0.2
4334, 0.9, 0.58, 0.2
4335, 0.9, 0.82, 0.2
4336, 0.9, 1.06, 0.2
4337, 0.9, 0.34, 0.3
4338, 0.9, 0.58, 0.3
4339, 0.9, 0.82, 0.3
4340, 0.9, 1.06, 0.3
4341, 0.9, 0.34, 0.4
4342, 0.9, 0.58, 0.4
4343, 0.9, 0.82, 0.4
4344, 0.9, 1.06, 0.4
4345, 0.2, 1.325, 0.1
4346, 0.2, 1.325, 0.2
4347, 0.2, 1.325, 0.3
4348, 0.2, 1.325, 0.4
4349, 0.4, 1.325, 0.1
4350, 0.4, 1.325, 0.2
4351, 0.4, 1.325, 0.3
4352, 0.4, 1.325, 0.4
4353, 0.6, 1.325, 0.1
4354, 0.6, 1.325, 0.2
4355, 0.6, 1.325, 0.3
4356, 0.6, 1.325, 0.4
4357, 0.8, 1.325, 0.1
4358, 0.8, 1.325, 0.2
4359, 0.8, 1.325, 0.3
4360, 0.8, 1.325, 0.4
4361, 0.2, 1.375, 0.1
4362, 0.2, 1.375, 0.2
4363, 0.2, 1.375, 0.3
4364, 0.2, 1.375, 0.4
4365, 0.4, 1.375, 0.1
4366, 0.4, 1.375, 0.2
4367, 0.4, 1.375, 0.3
4368, 0.4, 1.375, 0.4
4369, 0.6, 1.375, 0.1
4370, 0.6, 1.375, 0.2
4371, 0.6, 1.375, 0.3
4372, 0.6, 1.375, 0.4
4373, 0.8, 1.375, 0.1
4374, 0.8, 1.375, 0.2
4375, 0.8, 1.375, 0.3
4376, 0.8, 1.375, 0.4
4377, 0.2, 1.3625, 0.1
4378, 0.1, 1.375, 0.1
4379, 0.2, 1.375, 0.05
4380, 0.2, 1.3875, 0.1
4381, 0.2, 1.3625, 0.2
4382, 0.1, 1.375, 0.2
4383, 0.2, 1.375, 0.15
4384, 0.2, 1.3875, 0.2
4385, 0.2, 1.3625, 0.3
4386, 0.1, 1.375, 0.3
4387, 0.2, 1.375, 0.25
4388, 0.2, 1.3875, 0.3
4389, 0.2, 1.3625, 0.4
4390, 0.1, 1.375, 0.4
4391, 0.2, 1.375, 0.35
4392, 0.2, 1.3875, 0.4
4393, 0.2, 1.375, 0.45
4394, 0.4, 1.3625, 0.1
4395, 0.3, 1.375, 0.1
4396, 0.4, 1.375, 0.05
4397, 0.4, 1.3875, 0.1
4398, 0.4, 1.3625, 0.2
4399, 0.3, 1.375, 0.2
4400, 0.4, 1.375, 0.15
4401, 0.4, 1.3875, 0.2
4402, 0.4, 1.3625, 0.3
4403, 0.3, 1.375, 0.3
4404, 0.4, 1.375, 0.25
4405, 0.4, 1.3875, 0.3
4406, 0.4, 1.3625, 0.4
4407, 0.3, 1.375, 0.4
4408, 0.4, 1.375, 0.35
4409, 0.4, 1.3875, 0.4
4410, 0.4, 1.375, 0.45
4411, 0.6, 1.3625, 0.1
4412, 0.5, 1.375, 0.1
4413, 0.6, 1.375, 0.05
4414, 0.6, 1.3875, 0.1
4415, 0.6, 1.3625, 0.2
4416, 0.5, 1.375, 0.2
4417, 0.6, 1.375, 0.15
4418, 0.6, 1.3875, 0.2
4419, 0.6, 1.3625, 0.3
4420, 0.5, 1.375, 0.3
4421, 0.6, 1.375, 0.25
4422, 0.6, 1.3875, 0.3
4423, 0.6, 1.3625, 0.4
4424, 0.5, 1.375, 0.4
4425, 0.6, 1.375, 0.35
4426, 0.6, 1.3875, 0.4
4427, 0.6, 1.375, 0.45
