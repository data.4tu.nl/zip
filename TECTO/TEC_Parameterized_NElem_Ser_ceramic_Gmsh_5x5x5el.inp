4428, 0.8, 1.3625, 0.1
4429, 0.7, 1.375, 0.1
4430, 0.8, 1.375, 0.05
4431, 0.8, 1.3875, 0.1
4432, 0.8, 1.3625, 0.2
4433, 0.7, 1.375, 0.2
4434, 0.8, 1.375, 0.15
4435, 0.8, 1.3875, 0.2
4436, 0.8, 1.3625, 0.3
4437, 0.7, 1.375, 0.3
4438, 0.8, 1.375, 0.25
4439, 0.8, 1.3875, 0.3
4440, 0.8, 1.3625, 0.4
4441, 0.7, 1.375, 0.4
4442, 0.8, 1.375, 0.35
4443, 0.8, 1.3875, 0.4
4444, 0.8, 1.375, 0.45
4445, 0.9, 1.375, 0.1
4446, 0.9, 1.375, 0.2
4447, 0.9, 1.375, 0.3
4448, 0.9, 1.375, 0.4
4449, 1.0666666666667, 1.375, 0.1
4450, 1.1333333333333, 1.375, 0.1
4451, 1.0666666666667, 1.375, 0.2
4452, 1.1333333333333, 1.375, 0.2
4453, 1.0666666666667, 1.375, 0.3
4454, 1.1333333333333, 1.375, 0.3
4455, 1.0666666666667, 1.375, 0.4
4456, 1.1333333333333, 1.375, 0.4
4457, 1.0333333333333, 1.375, 0.1
4458, 1.0666666666667, 1.375, 0.05
4459, 1.0666666666667, 1.3625, 0.1
4460, 1.1, 1.375, 0.1
4461, 1.1333333333333, 1.375, 0.05
4462, 1.1333333333333, 1.3625, 0.1
4463, 1.1666666666667, 1.375, 0.1
4464, 1.0666666666667, 1.3875, 0.1
4465, 1.1333333333333, 1.3875, 0.1
4466, 1.0333333333333, 1.375, 0.2
4467, 1.0666666666667, 1.375, 0.15
4468, 1.0666666666667, 1.3625, 0.2
4469, 1.1, 1.375, 0.2
4470, 1.1333333333333, 1.375, 0.15
4471, 1.1333333333333, 1.3625, 0.2
4472, 1.1666666666667, 1.375, 0.2
4473, 1.0666666666667, 1.3875, 0.2
4474, 1.1333333333333, 1.3875, 0.2
4475, 1.0333333333333, 1.375, 0.3
4476, 1.0666666666667, 1.375, 0.25
4477, 1.0666666666667, 1.3625, 0.3
4478, 1.1, 1.375, 0.3
4479, 1.1333333333333, 1.375, 0.25
4480, 1.1333333333333, 1.3625, 0.3
4481, 1.1666666666667, 1.375, 0.3
4482, 1.0666666666667, 1.3875, 0.3
4483, 1.1333333333333, 1.3875, 0.3
4484, 1.0333333333333, 1.375, 0.4
4485, 1.0666666666667, 1.375, 0.35
4486, 1.0666666666667, 1.3625, 0.4
4487, 1.1, 1.375, 0.4
4488, 1.1333333333333, 1.375, 0.35
4489, 1.1333333333333, 1.3625, 0.4
4490, 1.1666666666667, 1.375, 0.4
4491, 1.0666666666667, 1.3875, 0.4
4492, 1.1333333333333, 1.3875, 0.4
4493, 1.0666666666667, 1.375, 0.45
4494, 1.1333333333333, 1.375, 0.45
4495, 1.4, 1.375, 0.1
4496, 1.6, 1.375, 0.1
4497, 1.8, 1.375, 0.1
4498, 2, 1.375, 0.1
4499, 1.4, 1.375, 0.2
4500, 1.6, 1.375, 0.2
4501, 1.8, 1.375, 0.2
4502, 2, 1.375, 0.2
4503, 1.4, 1.375, 0.3
4504, 1.6, 1.375, 0.3
4505, 1.8, 1.375, 0.3
4506, 2, 1.375, 0.3
4507, 1.4, 1.375, 0.4
4508, 1.6, 1.375, 0.4
4509, 1.8, 1.375, 0.4
4510, 2, 1.375, 0.4
4511, 1.3, 1.375, 0.1
4512, 1.4, 1.375, 0.05
4513, 1.4, 1.3625, 0.1
4514, 1.5, 1.375, 0.1
4515, 1.6, 1.375, 0.05
4516, 1.6, 1.3625, 0.1
4517, 1.7, 1.375, 0.1
4518, 1.8, 1.375, 0.05
4519, 1.8, 1.3625, 0.1
4520, 1.9, 1.375, 0.1
4521, 2, 1.375, 0.05
4522, 2, 1.3625, 0.1
4523, 2.1, 1.375, 0.1
4524, 1.4, 1.3875, 0.1
4525, 1.6, 1.3875, 0.1
4526, 1.8, 1.3875, 0.1
4527, 2, 1.3875, 0.1
4528, 1.3, 1.375, 0.2
4529, 1.4, 1.375, 0.15
4530, 1.4, 1.3625, 0.2
4531, 1.5, 1.375, 0.2
4532, 1.6, 1.375, 0.15
4533, 1.6, 1.3625, 0.2
4534, 1.7, 1.375, 0.2
4535, 1.8, 1.375, 0.15
4536, 1.8, 1.3625, 0.2
4537, 1.9, 1.375, 0.2
4538, 2, 1.375, 0.15
4539, 2, 1.3625, 0.2
4540, 2.1, 1.375, 0.2
4541, 1.4, 1.3875, 0.2
4542, 1.6, 1.3875, 0.2
4543, 1.8, 1.3875, 0.2
4544, 2, 1.3875, 0.2
4545, 1.3, 1.375, 0.3
4546, 1.4, 1.375, 0.25
4547, 1.4, 1.3625, 0.3
4548, 1.5, 1.375, 0.3
4549, 1.6, 1.375, 0.25
4550, 1.6, 1.3625, 0.3
4551, 1.7, 1.375, 0.3
4552, 1.8, 1.375, 0.25
4553, 1.8, 1.3625, 0.3
4554, 1.9, 1.375, 0.3
4555, 2, 1.375, 0.25
4556, 2, 1.3625, 0.3
4557, 2.1, 1.375, 0.3
4558, 1.4, 1.3875, 0.3
4559, 1.6, 1.3875, 0.3
4560, 1.8, 1.3875, 0.3
4561, 2, 1.3875, 0.3
4562, 1.3, 1.375, 0.4
4563, 1.4, 1.375, 0.35
4564, 1.4, 1.3625, 0.4
4565, 1.5, 1.375, 0.4
4566, 1.6, 1.375, 0.35
4567, 1.6, 1.3625, 0.4
4568, 1.7, 1.375, 0.4
4569, 1.8, 1.375, 0.35
4570, 1.8, 1.3625, 0.4
4571, 1.9, 1.375, 0.4
4572, 2, 1.375, 0.35
4573, 2, 1.3625, 0.4
4574, 2.1, 1.375, 0.4
4575, 1.4, 1.3875, 0.4
4576, 1.6, 1.3875, 0.4
4577, 1.8, 1.3875, 0.4
4578, 2, 1.3875, 0.4
4579, 1.4, 1.375, 0.45
4580, 1.6, 1.375, 0.45
4581, 1.8, 1.375, 0.45
4582, 2, 1.375, 0.45
4583, 1.4, 1.325, 0.1
4584, 1.6, 1.325, 0.1
4585, 1.8, 1.325, 0.1
4586, 2, 1.325, 0.1
4587, 1.4, 1.325, 0.2
4588, 1.6, 1.325, 0.2
4589, 1.8, 1.325, 0.2
4590, 2, 1.325, 0.2
4591, 1.4, 1.325, 0.3
4592, 1.6, 1.325, 0.3
4593, 1.8, 1.325, 0.3
4594, 2, 1.325, 0.3
4595, 1.4, 1.325, 0.4
4596, 1.6, 1.325, 0.4
4597, 1.8, 1.325, 0.4
4598, 2, 1.325, 0.4
4599, 1.4, 1.06, 0.1
4600, 1.4, 0.82, 0.1
4601, 1.4, 0.58, 0.1
4602, 1.4, 0.34, 0.1
4603, 1.6, 1.06, 0.1
4604, 1.6, 0.82, 0.1
4605, 1.6, 0.58, 0.1
4606, 1.6, 0.34, 0.1
4607, 1.8, 1.06, 0.1
4608, 1.8, 0.82, 0.1
4609, 1.8, 0.58, 0.1
4610, 1.8, 0.34, 0.1
4611, 2, 1.06, 0.1
4612, 2, 0.82, 0.1
4613, 2, 0.58, 0.1
4614, 2, 0.34, 0.1
4615, 1.4, 1.06, 0.2
4616, 1.4, 0.82, 0.2
4617, 1.4, 0.58, 0.2
4618, 1.4, 0.34, 0.2
4619, 1.6, 1.06, 0.2
4620, 1.6, 0.82, 0.2
4621, 1.6, 0.58, 0.2
4622, 1.6, 0.34, 0.2
4623, 1.8, 1.06, 0.2
4624, 1.8, 0.82, 0.2
4625, 1.8, 0.58, 0.2
4626, 1.8, 0.34, 0.2
4627, 2, 1.06, 0.2
4628, 2, 0.82, 0.2
4629, 2, 0.58, 0.2
4630, 2, 0.34, 0.2
4631, 1.4, 1.06, 0.3
4632, 1.4, 0.82, 0.3
4633, 1.4, 0.58, 0.3
4634, 1.4, 0.34, 0.3
4635, 1.6, 1.06, 0.3
4636, 1.6, 0.82, 0.3
4637, 1.6, 0.58, 0.3
4638, 1.6, 0.34, 0.3
4639, 1.8, 1.06, 0.3
4640, 1.8, 0.82, 0.3
4641, 1.8, 0.58, 0.3
4642, 1.8, 0.34, 0.3
4643, 2, 1.06, 0.3
4644, 2, 0.82, 0.3
4645, 2, 0.58, 0.3
4646, 2, 0.34, 0.3
4647, 1.4, 1.06, 0.4
4648, 1.4, 0.82, 0.4
4649, 1.4, 0.58, 0.4
4650, 1.4, 0.34, 0.4
4651, 1.6, 1.06, 0.4
4652, 1.6, 0.82, 0.4
4653, 1.6, 0.58, 0.4
4654, 1.6, 0.34, 0.4
4655, 1.8, 1.06, 0.4
4656, 1.8, 0.82, 0.4
4657, 1.8, 0.58, 0.4
4658, 1.8, 0.34, 0.4
4659, 2, 1.06, 0.4
4660, 2, 0.82, 0.4
4661, 2, 0.58, 0.4
4662, 2, 0.34, 0.4
4663, 1.4, 1.18, 0.1
4664, 1.4, 1.06, 0.05
4665, 1.3, 1.06, 0.1
4666, 1.4, 0.94, 0.1
4667, 1.4, 0.82, 0.05
4668, 1.3, 0.82, 0.1
4669, 1.4, 0.7, 0.1
4670, 1.4, 0.58, 0.05
4671, 1.3, 0.58, 0.1
4672, 1.4, 0.46, 0.1
4673, 1.4, 0.34, 0.05
4674, 1.3, 0.34, 0.1
4675, 1.4, 0.22, 0.1
4676, 1.6, 1.18, 0.1
4677, 1.6, 1.06, 0.05
4678, 1.5, 1.06, 0.1
4679, 1.6, 0.94, 0.1
4680, 1.6, 0.82, 0.05
4681, 1.5, 0.82, 0.1
4682, 1.6, 0.7, 0.1
4683, 1.6, 0.58, 0.05
4684, 1.5, 0.58, 0.1
4685, 1.6, 0.46, 0.1
4686, 1.6, 0.34, 0.05
4687, 1.5, 0.34, 0.1
4688, 1.6, 0.22, 0.1
4689, 1.8, 1.18, 0.1
4690, 1.8, 1.06, 0.05
4691, 1.7, 1.06, 0.1
4692, 1.8, 0.94, 0.1
4693, 1.8, 0.82, 0.05
4694, 1.7, 0.82, 0.1
4695, 1.8, 0.7, 0.1
4696, 1.8, 0.58, 0.05
4697, 1.7, 0.58, 0.1
4698, 1.8, 0.46, 0.1
4699, 1.8, 0.34, 0.05
4700, 1.7, 0.34, 0.1
4701, 1.8, 0.22, 0.1
4702, 2, 1.18, 0.1
4703, 2, 1.06, 0.05
4704, 1.9, 1.06, 0.1
4705, 2, 0.94, 0.1
4706, 2, 0.82, 0.05
4707, 1.9, 0.82, 0.1
4708, 2, 0.7, 0.1
4709, 2, 0.58, 0.05
4710, 1.9, 0.58, 0.1
4711, 2, 0.46, 0.1
4712, 2, 0.34, 0.05
4713, 1.9, 0.34, 0.1
4714, 2, 0.22, 0.1
4715, 2.1, 1.06, 0.1
4716, 2.1, 0.82, 0.1
4717, 2.1, 0.58, 0.1
4718, 2.1, 0.34, 0.1
4719, 1.4, 1.18, 0.2
4720, 1.4, 1.06, 0.15
4721, 1.3, 1.06, 0.2
4722, 1.4, 0.94, 0.2
4723, 1.4, 0.82, 0.15
4724, 1.3, 0.82, 0.2
4725, 1.4, 0.7, 0.2
4726, 1.4, 0.58, 0.15
4727, 1.3, 0.58, 0.2
4728, 1.4, 0.46, 0.2
4729, 1.4, 0.34, 0.15
4730, 1.3, 0.34, 0.2
4731, 1.4, 0.22, 0.2
4732, 1.6, 1.18, 0.2
4733, 1.6, 1.06, 0.15
4734, 1.5, 1.06, 0.2
4735, 1.6, 0.94, 0.2
4736, 1.6, 0.82, 0.15
4737, 1.5, 0.82, 0.2
4738, 1.6, 0.7, 0.2
4739, 1.6, 0.58, 0.15
4740, 1.5, 0.58, 0.2
4741, 1.6, 0.46, 0.2
4742, 1.6, 0.34, 0.15
4743, 1.5, 0.34, 0.2
4744, 1.6, 0.22, 0.2
4745, 1.8, 1.18, 0.2
4746, 1.8, 1.06, 0.15
4747, 1.7, 1.06, 0.2
4748, 1.8, 0.94, 0.2
4749, 1.8, 0.82, 0.15
4750, 1.7, 0.82, 0.2
4751, 1.8, 0.7, 0.2
4752, 1.8, 0.58, 0.15
4753, 1.7, 0.58, 0.2
4754, 1.8, 0.46, 0.2
4755, 1.8, 0.34, 0.15
4756, 1.7, 0.34, 0.2
4757, 1.8, 0.22, 0.2
4758, 2, 1.18, 0.2
4759, 2, 1.06, 0.15
4760, 1.9, 1.06, 0.2
4761, 2, 0.94, 0.2
4762, 2, 0.82, 0.15
4763, 1.9, 0.82, 0.2
4764, 2, 0.7, 0.2
4765, 2, 0.58, 0.15
4766, 1.9, 0.58, 0.2
4767, 2, 0.46, 0.2
4768, 2, 0.34, 0.15
4769, 1.9, 0.34, 0.2
4770, 2, 0.22, 0.2
4771, 2.1, 1.06, 0.2
4772, 2.1, 0.82, 0.2
4773, 2.1, 0.58, 0.2
4774, 2.1, 0.34, 0.2
4775, 1.4, 1.18, 0.3
4776, 1.4, 1.06, 0.25
4777, 1.3, 1.06, 0.3
4778, 1.4, 0.94, 0.3
4779, 1.4, 0.82, 0.25
4780, 1.3, 0.82, 0.3
4781, 1.4, 0.7, 0.3
4782, 1.4, 0.58, 0.25
4783, 1.3, 0.58, 0.3
4784, 1.4, 0.46, 0.3
4785, 1.4, 0.34, 0.25
4786, 1.3, 0.34, 0.3
4787, 1.4, 0.22, 0.3
4788, 1.6, 1.18, 0.3
4789, 1.6, 1.06, 0.25
4790, 1.5, 1.06, 0.3
4791, 1.6, 0.94, 0.3
4792, 1.6, 0.82, 0.25
4793, 1.5, 0.82, 0.3
4794, 1.6, 0.7, 0.3
4795, 1.6, 0.58, 0.25
4796, 1.5, 0.58, 0.3
4797, 1.6, 0.46, 0.3
4798, 1.6, 0.34, 0.25
4799, 1.5, 0.34, 0.3
4800, 1.6, 0.22, 0.3
4801, 1.8, 1.18, 0.3
4802, 1.8, 1.06, 0.25
4803, 1.7, 1.06, 0.3
4804, 1.8, 0.94, 0.3
4805, 1.8, 0.82, 0.25
4806, 1.7, 0.82, 0.3
4807, 1.8, 0.7, 0.3
4808, 1.8, 0.58, 0.25
4809, 1.7, 0.58, 0.3
4810, 1.8, 0.46, 0.3
4811, 1.8, 0.34, 0.25
4812, 1.7, 0.34, 0.3
4813, 1.8, 0.22, 0.3
4814, 2, 1.18, 0.3
4815, 2, 1.06, 0.25
4816, 1.9, 1.06, 0.3
4817, 2, 0.94, 0.3
4818, 2, 0.82, 0.25
4819, 1.9, 0.82, 0.3
4820, 2, 0.7, 0.3
4821, 2, 0.58, 0.25
4822, 1.9, 0.58, 0.3
4823, 2, 0.46, 0.3
4824, 2, 0.34, 0.25
4825, 1.9, 0.34, 0.3
4826, 2, 0.22, 0.3
4827, 2.1, 1.06, 0.3
4828, 2.1, 0.82, 0.3
4829, 2.1, 0.58, 0.3
4830, 2.1, 0.34, 0.3
4831, 1.4, 1.18, 0.4
4832, 1.4, 1.06, 0.35
4833, 1.3, 1.06, 0.4
4834, 1.4, 0.94, 0.4
4835, 1.4, 0.82, 0.35
4836, 1.3, 0.82, 0.4
4837, 1.4, 0.7, 0.4
4838, 1.4, 0.58, 0.35
4839, 1.3, 0.58, 0.4
4840, 1.4, 0.46, 0.4
4841, 1.4, 0.34, 0.35
4842, 1.3, 0.34, 0.4
4843, 1.4, 0.22, 0.4
4844, 1.6, 1.18, 0.4
4845, 1.6, 1.06, 0.35
4846, 1.5, 1.06, 0.4
4847, 1.6, 0.94, 0.4
4848, 1.6, 0.82, 0.35
4849, 1.5, 0.82, 0.4
4850, 1.6, 0.7, 0.4
4851, 1.6, 0.58, 0.35
4852, 1.5, 0.58, 0.4
4853, 1.6, 0.46, 0.4
4854, 1.6, 0.34, 0.35
4855, 1.5, 0.34, 0.4
4856, 1.6, 0.22, 0.4
4857, 1.8, 1.18, 0.4
4858, 1.8, 1.06, 0.35
4859, 1.7, 1.06, 0.4
4860, 1.8, 0.94, 0.4
4861, 1.8, 0.82, 0.35
4862, 1.7, 0.82, 0.4
4863, 1.8, 0.7, 0.4
4864, 1.8, 0.58, 0.35
4865, 1.7, 0.58, 0.4
4866, 1.8, 0.46, 0.4
4867, 1.8, 0.34, 0.35
4868, 1.7, 0.34, 0.4
4869, 1.8, 0.22, 0.4
4870, 2, 1.18, 0.4
4871, 2, 1.06, 0.35
4872, 1.9, 1.06, 0.4
4873, 2, 0.94, 0.4
4874, 2, 0.82, 0.35
4875, 1.9, 0.82, 0.4
4876, 2, 0.7, 0.4
4877, 2, 0.58, 0.35
4878, 1.9, 0.58, 0.4
4879, 2, 0.46, 0.4
4880, 2, 0.34, 0.35
4881, 1.9, 0.34, 0.4
4882, 2, 0.22, 0.4
4883, 2.1, 1.06, 0.4
4884, 2.1, 0.82, 0.4
4885, 2.1, 0.58, 0.4
4886, 2.1, 0.34, 0.4
4887, 1.4, 1.06, 0.45
4888, 1.4, 0.82, 0.45
4889, 1.4, 0.58, 0.45
4890, 1.4, 0.34, 0.45
4891, 1.6, 1.06, 0.45
4892, 1.6, 0.82, 0.45
4893, 1.6, 0.58, 0.45
4894, 1.6, 0.34, 0.45
4895, 1.8, 1.06, 0.45
4896, 1.8, 0.82, 0.45
4897, 1.8, 0.58, 0.45
4898, 1.8, 0.34, 0.45
4899, 2, 1.06, 0.45
4900, 2, 0.82, 0.45
4901, 2, 0.58, 0.45
4902, 2, 0.34, 0.45
4903, 1.4, 0.075, 0.1
4904, 1.6, 0.075, 0.1
4905, 1.8, 0.075, 0.1
4906, 2, 0.075, 0.1
4907, 1.4, 0.075, 0.2
4908, 1.6, 0.075, 0.2
4909, 1.8, 0.075, 0.2
4910, 2, 0.075, 0.2
4911, 1.4, 0.075, 0.3
4912, 1.6, 0.075, 0.3
4913, 1.8, 0.075, 0.3
4914, 2, 0.075, 0.3
4915, 1.4, 0.075, 0.4
4916, 1.6, 0.075, 0.4
4917, 1.8, 0.075, 0.4
4918, 2, 0.075, 0.4
4919, 1.4, 0.025, 0.1
4920, 1.6, 0.025, 0.1
4921, 1.8, 0.025, 0.1
4922, 2, 0.025, 0.1
4923, 1.4, 0.025, 0.2
4924, 1.6, 0.025, 0.2
4925, 1.8, 0.025, 0.2
4926, 2, 0.025, 0.2
4927, 1.4, 0.025, 0.3
4928, 1.6, 0.025, 0.3
4929, 1.8, 0.025, 0.3
4930, 2, 0.025, 0.3
4931, 1.4, 0.025, 0.4
4932, 1.6, 0.025, 0.4
4933, 1.8, 0.025, 0.4
4934, 2, 0.025, 0.4
4935, 1.4, 0.0375, 0.1
4936, 1.4, 0.025, 0.05
4937, 1.3, 0.025, 0.1
4938, 1.4, 0.0125, 0.1
4939, 1.6, 0.0375, 0.1
4940, 1.6, 0.025, 0.05
4941, 1.5, 0.025, 0.1
4942, 1.6, 0.0125, 0.1
4943, 1.8, 0.0375, 0.1
4944, 1.8, 0.025, 0.05
4945, 1.7, 0.025, 0.1
4946, 1.8, 0.0125, 0.1
4947, 2, 0.0375, 0.1
4948, 2, 0.025, 0.05
4949, 1.9, 0.025, 0.1
4950, 2, 0.0125, 0.1
4951, 2.1, 0.025, 0.1
4952, 1.4, 0.0375, 0.2
4953, 1.4, 0.025, 0.15
4954, 1.3, 0.025, 0.2
4955, 1.4, 0.0125, 0.2
4956, 1.6, 0.0375, 0.2
4957, 1.6, 0.025, 0.15
4958, 1.5, 0.025, 0.2
4959, 1.6, 0.0125, 0.2
4960, 1.8, 0.0375, 0.2
4961, 1.8, 0.025, 0.15
4962, 1.7, 0.025, 0.2
4963, 1.8, 0.0125, 0.2
4964, 2, 0.0375, 0.2
4965, 2, 0.025, 0.15
4966, 1.9, 0.025, 0.2
4967, 2, 0.0125, 0.2
4968, 2.1, 0.025, 0.2
4969, 1.4, 0.0375, 0.3
4970, 1.4, 0.025, 0.25
4971, 1.3, 0.025, 0.3
4972, 1.4, 0.0125, 0.3
4973, 1.6, 0.0375, 0.3
4974, 1.6, 0.025, 0.25
4975, 1.5, 0.025, 0.3
4976, 1.6, 0.0125, 0.3
4977, 1.8, 0.0375, 0.3
4978, 1.8, 0.025, 0.25
4979, 1.7, 0.025, 0.3
4980, 1.8, 0.0125, 0.3
4981, 2, 0.0375, 0.3
4982, 2, 0.025, 0.25
4983, 1.9, 0.025, 0.3
4984, 2, 0.0125, 0.3
4985, 2.1, 0.025, 0.3
4986, 1.4, 0.0375, 0.4
4987, 1.4, 0.025, 0.35
4988, 1.3, 0.025, 0.4
4989, 1.4, 0.0125, 0.4
4990, 1.6, 0.0375, 0.4
4991, 1.6, 0.025, 0.35
4992, 1.5, 0.025, 0.4
4993, 1.6, 0.0125, 0.4
4994, 1.8, 0.0375, 0.4
4995, 1.8, 0.025, 0.35
4996, 1.7, 0.025, 0.4
4997, 1.8, 0.0125, 0.4
4998, 2, 0.0375, 0.4
4999, 2, 0.025, 0.35
5000, 1.9, 0.025, 0.4
5001, 2, 0.0125, 0.4
5002, 2.1, 0.025, 0.4
5003, 1.4, 0.025, 0.45
5004, 1.6, 0.025, 0.45
5005, 1.8, 0.025, 0.45
5006, 2, 0.025, 0.45
5007, 2.25, 0.025, 0.1
5008, 2.25, 0.025, 0.2
5009, 2.25, 0.025, 0.3
5010, 2.25, 0.025, 0.4
5011, -0.05, 0.025, 0.1
5012, -0.05, 0.025, 0.2
5013, -0.05, 0.025, 0.3
5014, -0.05, 0.025, 0.4
5015, 0.2, 0.34, -0.05
5016, 0.2, 0.58, -0.05
5017, 0.2, 0.82, -0.05
5018, 0.2, 1.06, -0.05
5019, 0.4, 0.34, -0.05
5020, 0.4, 0.58, -0.05
5021, 0.4, 0.82, -0.05
5022, 0.4, 1.06, -0.05
5023, 0.6, 0.34, -0.05
5024, 0.6, 0.58, -0.05
5025, 0.6, 0.82, -0.05
5026, 0.6, 1.06, -0.05
5027, 0.8, 0.34, -0.05
5028, 0.8, 0.58, -0.05
5029, 0.8, 0.82, -0.05
5030, 0.8, 1.06, -0.05
5031, 1.4, 1.06, -0.05
5032, 1.4, 0.82, -0.05
5033, 1.4, 0.58, -0.05
5034, 1.4, 0.34, -0.05
5035, 1.6, 1.06, -0.05
5036, 1.6, 0.82, -0.05
5037, 1.6, 0.58, -0.05
5038, 1.6, 0.34, -0.05
5039, 1.8, 1.06, -0.05
5040, 1.8, 0.82, -0.05
5041, 1.8, 0.58, -0.05
5042, 1.8, 0.34, -0.05
5043, 2, 1.06, -0.05
5044, 2, 0.82, -0.05
5045, 2, 0.58, -0.05
5046, 2, 0.34, -0.05
5047, 1.025, 0.34, 0.1
5048, 1.025, 0.58, 0.1
5049, 1.025, 0.82, 0.1
5050, 1.025, 1.06, 0.1
5051, 1.025, 0.34, 0.2
5052, 1.025, 0.58, 0.2
5053, 1.025, 0.82, 0.2
5054, 1.025, 1.06, 0.2
5055, 1.025, 0.34, 0.3
5056, 1.025, 0.58, 0.3
5057, 1.025, 0.82, 0.3
5058, 1.025, 1.06, 0.3
5059, 1.025, 0.34, 0.4
5060, 1.025, 0.58, 0.4
5061, 1.025, 0.82, 0.4
5062, 1.025, 1.06, 0.4
5063, 1.175, 1.06, 0.1
5064, 1.175, 0.82, 0.1
5065, 1.175, 0.58, 0.1
5066, 1.175, 0.34, 0.1
5067, 1.175, 1.06, 0.2
5068, 1.175, 0.82, 0.2
5069, 1.175, 0.58, 0.2
5070, 1.175, 0.34, 0.2
5071, 1.175, 1.06, 0.3
5072, 1.175, 0.82, 0.3
5073, 1.175, 0.58, 0.3
5074, 1.175, 0.34, 0.3
5075, 1.175, 1.06, 0.4
5076, 1.175, 0.82, 0.4
5077, 1.175, 0.58, 0.4
5078, 1.175, 0.34, 0.4
5079, 0.2, 1.4666666666667, 0.1
5080, 0.2, 1.5333333333333, 0.1
5081, 0.2, 1.4666666666667, 0.2
5082, 0.2, 1.5333333333333, 0.2
5083, 0.2, 1.4666666666667, 0.3
5084, 0.2, 1.5333333333333, 0.3
5085, 0.2, 1.4666666666667, 0.4
5086, 0.2, 1.5333333333333, 0.4
5087, 0.4, 1.4666666666667, 0.1
5088, 0.4, 1.5333333333333, 0.1
5089, 0.4, 1.4666666666667, 0.2
5090, 0.4, 1.5333333333333, 0.2
5091, 0.4, 1.4666666666667, 0.3
5092, 0.4, 1.5333333333333, 0.3
5093, 0.4, 1.4666666666667, 0.4
5094, 0.4, 1.5333333333333, 0.4
5095, 0.6, 1.4666666666667, 0.1
5096, 0.6, 1.5333333333333, 0.1
5097, 0.6, 1.4666666666667, 0.2
5098, 0.6, 1.5333333333333, 0.2
5099, 0.6, 1.4666666666667, 0.3
5100, 0.6, 1.5333333333333, 0.3
5101, 0.6, 1.4666666666667, 0.4
5102, 0.6, 1.5333333333333, 0.4
5103, 0.8, 1.4666666666667, 0.1
5104, 0.8, 1.5333333333333, 0.1
5105, 0.8, 1.4666666666667, 0.2
5106, 0.8, 1.5333333333333, 0.2
5107, 0.8, 1.4666666666667, 0.3
5108, 0.8, 1.5333333333333, 0.3
5109, 0.8, 1.4666666666667, 0.4
5110, 0.8, 1.5333333333333, 0.4
5111, 0.2, 1.4333333333333, 0.1
5112, 0.1, 1.4666666666667, 0.1
5113, 0.2, 1.4666666666667, 0.05
5114, 0.2, 1.5, 0.1
5115, 0.1, 1.5333333333333, 0.1
5116, 0.2, 1.5333333333333, 0.05
5117, 0.2, 1.5666666666667, 0.1
5118, 0.2, 1.4333333333333, 0.2
5119, 0.1, 1.4666666666667, 0.2
5120, 0.2, 1.4666666666667, 0.15
5121, 0.2, 1.5, 0.2
5122, 0.1, 1.5333333333333, 0.2
5123, 0.2, 1.5333333333333, 0.15
5124, 0.2, 1.5666666666667, 0.2
5125, 0.2, 1.4333333333333, 0.3
5126, 0.1, 1.4666666666667, 0.3
5127, 0.2, 1.4666666666667, 0.25
5128, 0.2, 1.5, 0.3
5129, 0.1, 1.5333333333333, 0.3
5130, 0.2, 1.5333333333333, 0.25
5131, 0.2, 1.5666666666667, 0.3
5132, 0.2, 1.4333333333333, 0.4
5133, 0.1, 1.4666666666667, 0.4
5134, 0.2, 1.4666666666667, 0.35
5135, 0.2, 1.5, 0.4
5136, 0.1, 1.5333333333333, 0.4
5137, 0.2, 1.5333333333333, 0.35
5138, 0.2, 1.5666666666667, 0.4
5139, 0.2, 1.4666666666667, 0.45
5140, 0.2, 1.5333333333333, 0.45
5141, 0.4, 1.4333333333333, 0.1
5142, 0.3, 1.4666666666667, 0.1
5143, 0.4, 1.4666666666667, 0.05
5144, 0.4, 1.5, 0.1
5145, 0.3, 1.5333333333333, 0.1
5146, 0.4, 1.5333333333333, 0.05
5147, 0.4, 1.5666666666667, 0.1
5148, 0.4, 1.4333333333333, 0.2
5149, 0.3, 1.4666666666667, 0.2
5150, 0.4, 1.4666666666667, 0.15
5151, 0.4, 1.5, 0.2
5152, 0.3, 1.5333333333333, 0.2
5153, 0.4, 1.5333333333333, 0.15
5154, 0.4, 1.5666666666667, 0.2
5155, 0.4, 1.4333333333333, 0.3
5156, 0.3, 1.4666666666667, 0.3
5157, 0.4, 1.4666666666667, 0.25
5158, 0.4, 1.5, 0.3
5159, 0.3, 1.5333333333333, 0.3
5160, 0.4, 1.5333333333333, 0.25
5161, 0.4, 1.5666666666667, 0.3
5162, 0.4, 1.4333333333333, 0.4
5163, 0.3, 1.4666666666667, 0.4
5164, 0.4, 1.4666666666667, 0.35
5165, 0.4, 1.5, 0.4
5166, 0.3, 1.5333333333333, 0.4
5167, 0.4, 1.5333333333333, 0.35
5168, 0.4, 1.5666666666667, 0.4
5169, 0.4, 1.4666666666667, 0.45
5170, 0.4, 1.5333333333333, 0.45
5171, 0.6, 1.4333333333333, 0.1
5172, 0.5, 1.4666666666667, 0.1
5173, 0.6, 1.4666666666667, 0.05
5174, 0.6, 1.5, 0.1
5175, 0.5, 1.5333333333333, 0.1
5176, 0.6, 1.5333333333333, 0.05
5177, 0.6, 1.5666666666667, 0.1
5178, 0.6, 1.4333333333333, 0.2
5179, 0.5, 1.4666666666667, 0.2
5180, 0.6, 1.4666666666667, 0.15
5181, 0.6, 1.5, 0.2
5182, 0.5, 1.5333333333333, 0.2
5183, 0.6, 1.5333333333333, 0.15
5184, 0.6, 1.5666666666667, 0.2
5185, 0.6, 1.4333333333333, 0.3
5186, 0.5, 1.4666666666667, 0.3
5187, 0.6, 1.4666666666667, 0.25
5188, 0.6, 1.5, 0.3
5189, 0.5, 1.5333333333333, 0.3
5190, 0.6, 1.5333333333333, 0.25
5191, 0.6, 1.5666666666667, 0.3
5192, 0.6, 1.4333333333333, 0.4
5193, 0.5, 1.4666666666667, 0.4
5194, 0.6, 1.4666666666667, 0.35
5195, 0.6, 1.5, 0.4
5196, 0.5, 1.5333333333333, 0.4
5197, 0.6, 1.5333333333333, 0.35
5198, 0.6, 1.5666666666667, 0.4
5199, 0.6, 1.4666666666667, 0.45
5200, 0.6, 1.5333333333333, 0.45
5201, 0.8, 1.4333333333333, 0.1
5202, 0.7, 1.4666666666667, 0.1
5203, 0.8, 1.4666666666667, 0.05
5204, 0.8, 1.5, 0.1
5205, 0.7, 1.5333333333333, 0.1
5206, 0.8, 1.5333333333333, 0.05
5207, 0.8, 1.5666666666667, 0.1
5208, 0.8, 1.4333333333333, 0.2
5209, 0.7, 1.4666666666667, 0.2
5210, 0.8, 1.4666666666667, 0.15
5211, 0.8, 1.5, 0.2
5212, 0.7, 1.5333333333333, 0.2
5213, 0.8, 1.5333333333333, 0.15
5214, 0.8, 1.5666666666667, 0.2
5215, 0.8, 1.4333333333333, 0.3
5216, 0.7, 1.4666666666667, 0.3
5217, 0.8, 1.4666666666667, 0.25
5218, 0.8, 1.5, 0.3
5219, 0.7, 1.5333333333333, 0.3
5220, 0.8, 1.5333333333333, 0.25
5221, 0.8, 1.5666666666667, 0.3
5222, 0.8, 1.4333333333333, 0.4
5223, 0.7, 1.4666666666667, 0.4
5224, 0.8, 1.4666666666667, 0.35
5225, 0.8, 1.5, 0.4
5226, 0.7, 1.5333333333333, 0.4
5227, 0.8, 1.5333333333333, 0.35
5228, 0.8, 1.5666666666667, 0.4
5229, 0.8, 1.4666666666667, 0.45
5230, 0.8, 1.5333333333333, 0.45
5231, 0.9, 1.4666666666667, 0.1
5232, 0.9, 1.5333333333333, 0.1
5233, 0.9, 1.4666666666667, 0.2
5234, 0.9, 1.5333333333333, 0.2
5235, 0.9, 1.4666666666667, 0.3
5236, 0.9, 1.5333333333333, 0.3
5237, 0.9, 1.4666666666667, 0.4
5238, 0.9, 1.5333333333333, 0.4
5239, 1.0666666666667, 1.4666666666667, 0.1
5240, 1.0666666666667, 1.5333333333333, 0.1
5241, 1.1333333333333, 1.4666666666667, 0.1
5242, 1.1333333333333, 1.5333333333333, 0.1
5243, 1.0666666666667, 1.4666666666667, 0.2
5244, 1.0666666666667, 1.5333333333333, 0.2
5245, 1.1333333333333, 1.4666666666667, 0.2
5246, 1.1333333333333, 1.5333333333333, 0.2
5247, 1.0666666666667, 1.4666666666667, 0.3
5248, 1.0666666666667, 1.5333333333333, 0.3
5249, 1.1333333333333, 1.4666666666667, 0.3
5250, 1.1333333333333, 1.5333333333333, 0.3
5251, 1.0666666666667, 1.4666666666667, 0.4
5252, 1.0666666666667, 1.5333333333333, 0.4
5253, 1.1333333333333, 1.4666666666667, 0.4
5254, 1.1333333333333, 1.5333333333333, 0.4
5255, 1.0666666666667, 1.4333333333333, 0.1
5256, 1.0333333333333, 1.4666666666667, 0.1
5257, 1.0666666666667, 1.4666666666667, 0.05
5258, 1.0666666666667, 1.5, 0.1
5259, 1.0333333333333, 1.5333333333333, 0.1
5260, 1.0666666666667, 1.5333333333333, 0.05
5261, 1.0666666666667, 1.5666666666667, 0.1
5262, 1.1333333333333, 1.4333333333333, 0.1
5263, 1.1, 1.4666666666667, 0.1
5264, 1.1333333333333, 1.4666666666667, 0.05
5265, 1.1333333333333, 1.5, 0.1
5266, 1.1, 1.5333333333333, 0.1
5267, 1.1333333333333, 1.5333333333333, 0.05
5268, 1.1333333333333, 1.5666666666667, 0.1
5269, 1.1666666666667, 1.4666666666667, 0.1
5270, 1.1666666666667, 1.5333333333333, 0.1
5271, 1.0666666666667, 1.4333333333333, 0.2
5272, 1.0333333333333, 1.4666666666667, 0.2
5273, 1.0666666666667, 1.4666666666667, 0.15
5274, 1.0666666666667, 1.5, 0.2
5275, 1.0333333333333, 1.5333333333333, 0.2
5276, 1.0666666666667, 1.5333333333333, 0.15
5277, 1.0666666666667, 1.5666666666667, 0.2
5278, 1.1333333333333, 1.4333333333333, 0.2
5279, 1.1, 1.4666666666667, 0.2
5280, 1.1333333333333, 1.4666666666667, 0.15
5281, 1.1333333333333, 1.5, 0.2
5282, 1.1, 1.5333333333333, 0.2
5283, 1.1333333333333, 1.5333333333333, 0.15
5284, 1.1333333333333, 1.5666666666667, 0.2
5285, 1.1666666666667, 1.4666666666667, 0.2
5286, 1.1666666666667, 1.5333333333333, 0.2
5287, 1.0666666666667, 1.4333333333333, 0.3
5288, 1.0333333333333, 1.4666666666667, 0.3
5289, 1.0666666666667, 1.4666666666667, 0.25
5290, 1.0666666666667, 1.5, 0.3
5291, 1.0333333333333, 1.5333333333333, 0.3
5292, 1.0666666666667, 1.5333333333333, 0.25
5293, 1.0666666666667, 1.5666666666667, 0.3
5294, 1.1333333333333, 1.4333333333333, 0.3
5295, 1.1, 1.4666666666667, 0.3
5296, 1.1333333333333, 1.4666666666667, 0.25
5297, 1.1333333333333, 1.5, 0.3
5298, 1.1, 1.5333333333333, 0.3
5299, 1.1333333333333, 1.5333333333333, 0.25
5300, 1.1333333333333, 1.5666666666667, 0.3
5301, 1.1666666666667, 1.4666666666667, 0.3
5302, 1.1666666666667, 1.5333333333333, 0.3
5303, 1.0666666666667, 1.4333333333333, 0.4
5304, 1.0333333333333, 1.4666666666667, 0.4
5305, 1.0666666666667, 1.4666666666667, 0.35
5306, 1.0666666666667, 1.5, 0.4
5307, 1.0333333333333, 1.5333333333333, 0.4
5308, 1.0666666666667, 1.5333333333333, 0.35
5309, 1.0666666666667, 1.5666666666667, 0.4
5310, 1.1333333333333, 1.4333333333333, 0.4
5311, 1.1, 1.4666666666667, 0.4
5312, 1.1333333333333, 1.4666666666667, 0.35
5313, 1.1333333333333, 1.5, 0.4
5314, 1.1, 1.5333333333333, 0.4
5315, 1.1333333333333, 1.5333333333333, 0.35
5316, 1.1333333333333, 1.5666666666667, 0.4
5317, 1.1666666666667, 1.4666666666667, 0.4
5318, 1.1666666666667, 1.5333333333333, 0.4
5319, 1.0666666666667, 1.4666666666667, 0.45
5320, 1.0666666666667, 1.5333333333333, 0.45
5321, 1.1333333333333, 1.4666666666667, 0.45
5322, 1.1333333333333, 1.5333333333333, 0.45
5323, 1.4, 1.4666666666667, 0.1
5324, 1.4, 1.5333333333333, 0.1
5325, 1.6, 1.4666666666667, 0.1
5326, 1.6, 1.5333333333333, 0.1
5327, 1.8, 1.4666666666667, 0.1
5328, 1.8, 1.5333333333333, 0.1
5329, 2, 1.4666666666667, 0.1
5330, 2, 1.5333333333333, 0.1
5331, 1.4, 1.4666666666667, 0.2
5332, 1.4, 1.5333333333333, 0.2
5333, 1.6, 1.4666666666667, 0.2
5334, 1.6, 1.5333333333333, 0.2
5335, 1.8, 1.4666666666667, 0.2
5336, 1.8, 1.5333333333333, 0.2
5337, 2, 1.4666666666667, 0.2
5338, 2, 1.5333333333333, 0.2
5339, 1.4, 1.4666666666667, 0.3
5340, 1.4, 1.5333333333333, 0.3
5341, 1.6, 1.4666666666667, 0.3
5342, 1.6, 1.5333333333333, 0.3
5343, 1.8, 1.4666666666667, 0.3
5344, 1.8, 1.5333333333333, 0.3
5345, 2, 1.4666666666667, 0.3
5346, 2, 1.5333333333333, 0.3
5347, 1.4, 1.4666666666667, 0.4
5348, 1.4, 1.5333333333333, 0.4
5349, 1.6, 1.4666666666667, 0.4
5350, 1.6, 1.5333333333333, 0.4
5351, 1.8, 1.4666666666667, 0.4
5352, 1.8, 1.5333333333333, 0.4
5353, 2, 1.4666666666667, 0.4
5354, 2, 1.5333333333333, 0.4
5355, 1.4, 1.4333333333333, 0.1
5356, 1.3, 1.4666666666667, 0.1
5357, 1.4, 1.4666666666667, 0.05
5358, 1.4, 1.5, 0.1
5359, 1.3, 1.5333333333333, 0.1
5360, 1.4, 1.5333333333333, 0.05
5361, 1.4, 1.5666666666667, 0.1
5362, 1.6, 1.4333333333333, 0.1
5363, 1.5, 1.4666666666667, 0.1
5364, 1.6, 1.4666666666667, 0.05
5365, 1.6, 1.5, 0.1
5366, 1.5, 1.5333333333333, 0.1
5367, 1.6, 1.5333333333333, 0.05
5368, 1.6, 1.5666666666667, 0.1
5369, 1.8, 1.4333333333333, 0.1
5370, 1.7, 1.4666666666667, 0.1
5371, 1.8, 1.4666666666667, 0.05
5372, 1.8, 1.5, 0.1
5373, 1.7, 1.5333333333333, 0.1
5374, 1.8, 1.5333333333333, 0.05
5375, 1.8, 1.5666666666667, 0.1
5376, 2, 1.4333333333333, 0.1
5377, 1.9, 1.4666666666667, 0.1
5378, 2, 1.4666666666667, 0.05
5379, 2, 1.5, 0.1
5380, 1.9, 1.5333333333333, 0.1
5381, 2, 1.5333333333333, 0.05
5382, 2, 1.5666666666667, 0.1
5383, 2.1, 1.4666666666667, 0.1
5384, 2.1, 1.5333333333333, 0.1
5385, 1.4, 1.4333333333333, 0.2
5386, 1.3, 1.4666666666667, 0.2
5387, 1.4, 1.4666666666667, 0.15
5388, 1.4, 1.5, 0.2
5389, 1.3, 1.5333333333333, 0.2
5390, 1.4, 1.5333333333333, 0.15
5391, 1.4, 1.5666666666667, 0.2
5392, 1.6, 1.4333333333333, 0.2
5393, 1.5, 1.4666666666667, 0.2
5394, 1.6, 1.4666666666667, 0.15
5395, 1.6, 1.5, 0.2
5396, 1.5, 1.5333333333333, 0.2
5397, 1.6, 1.5333333333333, 0.15
5398, 1.6, 1.5666666666667, 0.2
5399, 1.8, 1.4333333333333, 0.2
5400, 1.7, 1.4666666666667, 0.2
5401, 1.8, 1.4666666666667, 0.15
5402, 1.8, 1.5, 0.2
5403, 1.7, 1.5333333333333, 0.2
5404, 1.8, 1.5333333333333, 0.15
5405, 1.8, 1.5666666666667, 0.2
5406, 2, 1.4333333333333, 0.2
5407, 1.9, 1.4666666666667, 0.2
5408, 2, 1.4666666666667, 0.15
5409, 2, 1.5, 0.2
5410, 1.9, 1.5333333333333, 0.2
5411, 2, 1.5333333333333, 0.15
5412, 2, 1.5666666666667, 0.2
5413, 2.1, 1.4666666666667, 0.2
5414, 2.1, 1.5333333333333, 0.2
5415, 1.4, 1.4333333333333, 0.3
5416, 1.3, 1.4666666666667, 0.3
5417, 1.4, 1.4666666666667, 0.25
5418, 1.4, 1.5, 0.3
5419, 1.3, 1.5333333333333, 0.3
5420, 1.4, 1.5333333333333, 0.25
5421, 1.4, 1.5666666666667, 0.3
5422, 1.6, 1.4333333333333, 0.3
5423, 1.5, 1.4666666666667, 0.3
5424, 1.6, 1.4666666666667, 0.25
5425, 1.6, 1.5, 0.3
5426, 1.5, 1.5333333333333, 0.3
5427, 1.6, 1.5333333333333, 0.25
5428, 1.6, 1.5666666666667, 0.3
5429, 1.8, 1.4333333333333, 0.3
5430, 1.7, 1.4666666666667, 0.3
5431, 1.8, 1.4666666666667, 0.25
5432, 1.8, 1.5, 0.3
5433, 1.7, 1.5333333333333, 0.3
5434, 1.8, 1.5333333333333, 0.25
5435, 1.8, 1.5666666666667, 0.3
5436, 2, 1.4333333333333, 0.3
5437, 1.9, 1.4666666666667, 0.3
5438, 2, 1.4666666666667, 0.25
5439, 2, 1.5, 0.3
5440, 1.9, 1.5333333333333, 0.3
5441, 2, 1.5333333333333, 0.25
5442, 2, 1.5666666666667, 0.3
5443, 2.1, 1.4666666666667, 0.3
5444, 2.1, 1.5333333333333, 0.3
5445, 1.4, 1.4333333333333, 0.4
5446, 1.3, 1.4666666666667, 0.4
5447, 1.4, 1.4666666666667, 0.35
5448, 1.4, 1.5, 0.4
5449, 1.3, 1.5333333333333, 0.4
5450, 1.4, 1.5333333333333, 0.35
5451, 1.4, 1.5666666666667, 0.4
5452, 1.6, 1.4333333333333, 0.4
5453, 1.5, 1.4666666666667, 0.4
5454, 1.6, 1.4666666666667, 0.35
5455, 1.6, 1.5, 0.4
5456, 1.5, 1.5333333333333, 0.4
5457, 1.6, 1.5333333333333, 0.35
5458, 1.6, 1.5666666666667, 0.4
5459, 1.8, 1.4333333333333, 0.4
5460, 1.7, 1.4666666666667, 0.4
5461, 1.8, 1.4666666666667, 0.35
5462, 1.8, 1.5, 0.4
5463, 1.7, 1.5333333333333, 0.4
5464, 1.8, 1.5333333333333, 0.35
5465, 1.8, 1.5666666666667, 0.4
5466, 2, 1.4333333333333, 0.4
5467, 1.9, 1.4666666666667, 0.4
5468, 2, 1.4666666666667, 0.35
5469, 2, 1.5, 0.4
5470, 1.9, 1.5333333333333, 0.4
5471, 2, 1.5333333333333, 0.35
5472, 2, 1.5666666666667, 0.4
5473, 2.1, 1.4666666666667, 0.4
5474, 2.1, 1.5333333333333, 0.4
5475, 1.4, 1.4666666666667, 0.45
5476, 1.4, 1.5333333333333, 0.45
5477, 1.6, 1.4666666666667, 0.45
5478, 1.6, 1.5333333333333, 0.45
5479, 1.8, 1.4666666666667, 0.45
5480, 1.8, 1.5333333333333, 0.45
5481, 2, 1.4666666666667, 0.45
5482, 2, 1.5333333333333, 0.45
5483, 0.2, -0.066666666666667, 0.1
5484, 0.2, -0.13333333333333, 0.1
5485, 0.2, -0.066666666666667, 0.2
5486, 0.2, -0.13333333333333, 0.2
5487, 0.2, -0.066666666666667, 0.3
5488, 0.2, -0.13333333333333, 0.3
5489, 0.2, -0.066666666666667, 0.4
5490, 0.2, -0.13333333333333, 0.4
5491, 0.4, -0.066666666666667, 0.1
5492, 0.4, -0.13333333333333, 0.1
5493, 0.4, -0.066666666666667, 0.2
5494, 0.4, -0.13333333333333, 0.2
5495, 0.4, -0.066666666666667, 0.3
5496, 0.4, -0.13333333333333, 0.3
5497, 0.4, -0.066666666666667, 0.4
5498, 0.4, -0.13333333333333, 0.4
5499, 0.6, -0.066666666666667, 0.1
5500, 0.6, -0.13333333333333, 0.1
5501, 0.6, -0.066666666666667, 0.2
5502, 0.6, -0.13333333333333, 0.2
5503, 0.6, -0.066666666666667, 0.3
5504, 0.6, -0.13333333333333, 0.3
5505, 0.6, -0.066666666666667, 0.4
5506, 0.6, -0.13333333333333, 0.4
5507, 0.8, -0.066666666666667, 0.1
5508, 0.8, -0.13333333333333, 0.1
5509, 0.8, -0.066666666666667, 0.2
5510, 0.8, -0.13333333333333, 0.2
5511, 0.8, -0.066666666666667, 0.3
5512, 0.8, -0.13333333333333, 0.3
5513, 0.8, -0.066666666666667, 0.4
5514, 0.8, -0.13333333333333, 0.4
5515, 0.2, -0.033333333333333, 0.1
5516, 0.2, -0.066666666666667, 0.05
5517, 0.1, -0.066666666666667, 0.1
5518, 0.2, -0.1, 0.1
5519, 0.2, -0.13333333333333, 0.05
5520, 0.1, -0.13333333333333, 0.1
5521, 0.2, -0.16666666666667, 0.1
5522, 0.2, -0.033333333333333, 0.2
5523, 0.2, -0.066666666666667, 0.15
5524, 0.1, -0.066666666666667, 0.2
5525, 0.2, -0.1, 0.2
5526, 0.2, -0.13333333333333, 0.15
5527, 0.1, -0.13333333333333, 0.2
5528, 0.2, -0.16666666666667, 0.2
5529, 0.2, -0.033333333333333, 0.3
5530, 0.2, -0.066666666666667, 0.25
5531, 0.1, -0.066666666666667, 0.3
5532, 0.2, -0.1, 0.3
5533, 0.2, -0.13333333333333, 0.25
5534, 0.1, -0.13333333333333, 0.3
5535, 0.2, -0.16666666666667, 0.3
5536, 0.2, -0.033333333333333, 0.4
5537, 0.2, -0.066666666666667, 0.35
5538, 0.1, -0.066666666666667, 0.4
5539, 0.2, -0.1, 0.4
5540, 0.2, -0.13333333333333, 0.35
5541, 0.1, -0.13333333333333, 0.4
5542, 0.2, -0.16666666666667, 0.4
5543, 0.2, -0.066666666666667, 0.45
5544, 0.2, -0.13333333333333, 0.45
5545, 0.4, -0.033333333333333, 0.1
5546, 0.4, -0.066666666666667, 0.05
5547, 0.3, -0.066666666666667, 0.1
5548, 0.4, -0.1, 0.1
5549, 0.4, -0.13333333333333, 0.05
5550, 0.3, -0.13333333333333, 0.1
5551, 0.4, -0.16666666666667, 0.1
5552, 0.4, -0.033333333333333, 0.2
5553, 0.4, -0.066666666666667, 0.15
5554, 0.3, -0.066666666666667, 0.2
5555, 0.4, -0.1, 0.2
5556, 0.4, -0.13333333333333, 0.15
5557, 0.3, -0.13333333333333, 0.2
5558, 0.4, -0.16666666666667, 0.2
5559, 0.4, -0.033333333333333, 0.3
5560, 0.4, -0.066666666666667, 0.25
5561, 0.3, -0.066666666666667, 0.3
5562, 0.4, -0.1, 0.3
5563, 0.4, -0.13333333333333, 0.25
5564, 0.3, -0.13333333333333, 0.3
5565, 0.4, -0.16666666666667, 0.3
5566, 0.4, -0.033333333333333, 0.4
5567, 0.4, -0.066666666666667, 0.35
5568, 0.3, -0.066666666666667, 0.4
5569, 0.4, -0.1, 0.4
5570, 0.4, -0.13333333333333, 0.35
5571, 0.3, -0.13333333333333, 0.4
5572, 0.4, -0.16666666666667, 0.4
5573, 0.4, -0.066666666666667, 0.45
5574, 0.4, -0.13333333333333, 0.45
5575, 0.6, -0.033333333333333, 0.1
5576, 0.6, -0.066666666666667, 0.05
5577, 0.5, -0.066666666666667, 0.1
5578, 0.6, -0.1, 0.1
5579, 0.6, -0.13333333333333, 0.05
5580, 0.5, -0.13333333333333, 0.1
5581, 0.6, -0.16666666666667, 0.1
5582, 0.6, -0.033333333333333, 0.2
5583, 0.6, -0.066666666666667, 0.15
5584, 0.5, -0.066666666666667, 0.2
5585, 0.6, -0.1, 0.2
5586, 0.6, -0.13333333333333, 0.15
5587, 0.5, -0.13333333333333, 0.2
5588, 0.6, -0.16666666666667, 0.2
5589, 0.6, -0.033333333333333, 0.3
5590, 0.6, -0.066666666666667, 0.25
5591, 0.5, -0.066666666666667, 0.3
5592, 0.6, -0.1, 0.3
5593, 0.6, -0.13333333333333, 0.25
5594, 0.5, -0.13333333333333, 0.3
5595, 0.6, -0.16666666666667, 0.3
5596, 0.6, -0.033333333333333, 0.4
5597, 0.6, -0.066666666666667, 0.35
5598, 0.5, -0.066666666666667, 0.4
5599, 0.6, -0.1, 0.4
5600, 0.6, -0.13333333333333, 0.35
5601, 0.5, -0.13333333333333, 0.4
5602, 0.6, -0.16666666666667, 0.4
5603, 0.6, -0.066666666666667, 0.45
5604, 0.6, -0.13333333333333, 0.45
5605, 0.8, -0.033333333333333, 0.1
5606, 0.8, -0.066666666666667, 0.05
5607, 0.7, -0.066666666666667, 0.1
5608, 0.8, -0.1, 0.1
5609, 0.8, -0.13333333333333, 0.05
5610, 0.7, -0.13333333333333, 0.1
5611, 0.8, -0.16666666666667, 0.1
5612, 0.8, -0.033333333333333, 0.2
5613, 0.8, -0.066666666666667, 0.15
5614, 0.7, -0.066666666666667, 0.2
5615, 0.8, -0.1, 0.2
5616, 0.8, -0.13333333333333, 0.15
5617, 0.7, -0.13333333333333, 0.2
5618, 0.8, -0.16666666666667, 0.2
5619, 0.8, -0.033333333333333, 0.3
5620, 0.8, -0.066666666666667, 0.25
5621, 0.7, -0.066666666666667, 0.3
5622, 0.8, -0.1, 0.3
5623, 0.8, -0.13333333333333, 0.25
5624, 0.7, -0.13333333333333, 0.3
5625, 0.8, -0.16666666666667, 0.3
5626, 0.8, -0.033333333333333, 0.4
5627, 0.8, -0.066666666666667, 0.35
5628, 0.7, -0.066666666666667, 0.4
5629, 0.8, -0.1, 0.4
5630, 0.8, -0.13333333333333, 0.35
5631, 0.7, -0.13333333333333, 0.4
5632, 0.8, -0.16666666666667, 0.4
5633, 0.8, -0.066666666666667, 0.45
5634, 0.8, -0.13333333333333, 0.45
5635, 0.9, -0.066666666666667, 0.1
5636, 0.9, -0.13333333333333, 0.1
5637, 0.9, -0.066666666666667, 0.2
5638, 0.9, -0.13333333333333, 0.2
5639, 0.9, -0.066666666666667, 0.3
5640, 0.9, -0.13333333333333, 0.3
5641, 0.9, -0.066666666666667, 0.4
5642, 0.9, -0.13333333333333, 0.4
5643, -0.05, -0.066666666666667, 0.1
5644, -0.05, -0.13333333333333, 0.1
5645, -0.05, -0.066666666666667, 0.2
5646, -0.05, -0.13333333333333, 0.2
5647, -0.05, -0.066666666666667, 0.3
5648, -0.05, -0.13333333333333, 0.3
5649, -0.05, -0.066666666666667, 0.4
5650, -0.05, -0.13333333333333, 0.4
5651, 1.4, -0.066666666666667, 0.1
5652, 1.4, -0.13333333333333, 0.1
5653, 1.6, -0.066666666666667, 0.1
5654, 1.6, -0.13333333333333, 0.1
5655, 1.8, -0.066666666666667, 0.1
5656, 1.8, -0.13333333333333, 0.1
5657, 2, -0.066666666666667, 0.1
5658, 2, -0.13333333333333, 0.1
5659, 1.4, -0.066666666666667, 0.2
5660, 1.4, -0.13333333333333, 0.2
5661, 1.6, -0.066666666666667, 0.2
5662, 1.6, -0.13333333333333, 0.2
5663, 1.8, -0.066666666666667, 0.2
5664, 1.8, -0.13333333333333, 0.2
5665, 2, -0.066666666666667, 0.2
5666, 2, -0.13333333333333, 0.2
5667, 1.4, -0.066666666666667, 0.3
5668, 1.4, -0.13333333333333, 0.3
5669, 1.6, -0.066666666666667, 0.3
5670, 1.6, -0.13333333333333, 0.3
5671, 1.8, -0.066666666666667, 0.3
5672, 1.8, -0.13333333333333, 0.3
5673, 2, -0.066666666666667, 0.3
5674, 2, -0.13333333333333, 0.3
5675, 1.4, -0.066666666666667, 0.4
5676, 1.4, -0.13333333333333, 0.4
5677, 1.6, -0.066666666666667, 0.4
5678, 1.6, -0.13333333333333, 0.4
5679, 1.8, -0.066666666666667, 0.4
5680, 1.8, -0.13333333333333, 0.4
5681, 2, -0.066666666666667, 0.4
5682, 2, -0.13333333333333, 0.4
5683, 1.4, -0.033333333333333, 0.1
5684, 1.4, -0.066666666666667, 0.05
5685, 1.3, -0.066666666666667, 0.1
5686, 1.4, -0.1, 0.1
5687, 1.4, -0.13333333333333, 0.05
5688, 1.3, -0.13333333333333, 0.1
5689, 1.4, -0.16666666666667, 0.1
5690, 1.6, -0.033333333333333, 0.1
5691, 1.6, -0.066666666666667, 0.05
5692, 1.5, -0.066666666666667, 0.1
5693, 1.6, -0.1, 0.1
5694, 1.6, -0.13333333333333, 0.05
5695, 1.5, -0.13333333333333, 0.1
5696, 1.6, -0.16666666666667, 0.1
5697, 1.8, -0.033333333333333, 0.1
5698, 1.8, -0.066666666666667, 0.05
5699, 1.7, -0.066666666666667, 0.1
5700, 1.8, -0.1, 0.1
5701, 1.8, -0.13333333333333, 0.05
5702, 1.7, -0.13333333333333, 0.1
5703, 1.8, -0.16666666666667, 0.1
5704, 2, -0.033333333333333, 0.1
5705, 2, -0.066666666666667, 0.05
5706, 1.9, -0.066666666666667, 0.1
5707, 2, -0.1, 0.1
5708, 2, -0.13333333333333, 0.05
5709, 1.9, -0.13333333333333, 0.1
5710, 2, -0.16666666666667, 0.1
5711, 2.1, -0.066666666666667, 0.1
5712, 2.1, -0.13333333333333, 0.1
5713, 1.4, -0.033333333333333, 0.2
5714, 1.4, -0.066666666666667, 0.15
5715, 1.3, -0.066666666666667, 0.2
5716, 1.4, -0.1, 0.2
5717, 1.4, -0.13333333333333, 0.15
5718, 1.3, -0.13333333333333, 0.2
5719, 1.4, -0.16666666666667, 0.2
5720, 1.6, -0.033333333333333, 0.2
5721, 1.6, -0.066666666666667, 0.15
5722, 1.5, -0.066666666666667, 0.2
5723, 1.6, -0.1, 0.2
5724, 1.6, -0.13333333333333, 0.15
5725, 1.5, -0.13333333333333, 0.2
5726, 1.6, -0.16666666666667, 0.2
5727, 1.8, -0.033333333333333, 0.2
5728, 1.8, -0.066666666666667, 0.15
5729, 1.7, -0.066666666666667, 0.2
5730, 1.8, -0.1, 0.2
5731, 1.8, -0.13333333333333, 0.15
5732, 1.7, -0.13333333333333, 0.2
5733, 1.8, -0.16666666666667, 0.2
5734, 2, -0.033333333333333, 0.2
5735, 2, -0.066666666666667, 0.15
5736, 1.9, -0.066666666666667, 0.2
5737, 2, -0.1, 0.2
5738, 2, -0.13333333333333, 0.15
5739, 1.9, -0.13333333333333, 0.2
5740, 2, -0.16666666666667, 0.2
5741, 2.1, -0.066666666666667, 0.2
5742, 2.1, -0.13333333333333, 0.2
5743, 1.4, -0.033333333333333, 0.3
5744, 1.4, -0.066666666666667, 0.25
5745, 1.3, -0.066666666666667, 0.3
5746, 1.4, -0.1, 0.3
5747, 1.4, -0.13333333333333, 0.25
5748, 1.3, -0.13333333333333, 0.3
5749, 1.4, -0.16666666666667, 0.3
5750, 1.6, -0.033333333333333, 0.3
5751, 1.6, -0.066666666666667, 0.25
5752, 1.5, -0.066666666666667, 0.3
5753, 1.6, -0.1, 0.3
5754, 1.6, -0.13333333333333, 0.25
5755, 1.5, -0.13333333333333, 0.3
5756, 1.6, -0.16666666666667, 0.3
5757, 1.8, -0.033333333333333, 0.3
5758, 1.8, -0.066666666666667, 0.25
5759, 1.7, -0.066666666666667, 0.3
5760, 1.8, -0.1, 0.3
5761, 1.8, -0.13333333333333, 0.25
5762, 1.7, -0.13333333333333, 0.3
5763, 1.8, -0.16666666666667, 0.3
5764, 2, -0.033333333333333, 0.3
5765, 2, -0.066666666666667, 0.25
5766, 1.9, -0.066666666666667, 0.3
5767, 2, -0.1, 0.3
5768, 2, -0.13333333333333, 0.25
5769, 1.9, -0.13333333333333, 0.3
5770, 2, -0.16666666666667, 0.3
5771, 2.1, -0.066666666666667, 0.3
5772, 2.1, -0.13333333333333, 0.3
5773, 1.4, -0.033333333333333, 0.4
5774, 1.4, -0.066666666666667, 0.35
5775, 1.3, -0.066666666666667, 0.4
5776, 1.4, -0.1, 0.4
5777, 1.4, -0.13333333333333, 0.35
5778, 1.3, -0.13333333333333, 0.4
5779, 1.4, -0.16666666666667, 0.4
5780, 1.6, -0.033333333333333, 0.4
5781, 1.6, -0.066666666666667, 0.35
5782, 1.5, -0.066666666666667, 0.4
5783, 1.6, -0.1, 0.4
5784, 1.6, -0.13333333333333, 0.35
5785, 1.5, -0.13333333333333, 0.4
5786, 1.6, -0.16666666666667, 0.4
5787, 1.8, -0.033333333333333, 0.4
5788, 1.8, -0.066666666666667, 0.35
5789, 1.7, -0.066666666666667, 0.4
5790, 1.8, -0.1, 0.4
5791, 1.8, -0.13333333333333, 0.35
5792, 1.7, -0.13333333333333, 0.4
5793, 1.8, -0.16666666666667, 0.4
5794, 2, -0.033333333333333, 0.4
5795, 2, -0.066666666666667, 0.35
5796, 1.9, -0.066666666666667, 0.4
5797, 2, -0.1, 0.4
5798, 2, -0.13333333333333, 0.35
5799, 1.9, -0.13333333333333, 0.4
5800, 2, -0.16666666666667, 0.4
5801, 2.1, -0.066666666666667, 0.4
5802, 2.1, -0.13333333333333, 0.4
5803, 1.4, -0.066666666666667, 0.45
5804, 1.4, -0.13333333333333, 0.45
5805, 1.6, -0.066666666666667, 0.45
5806, 1.6, -0.13333333333333, 0.45
5807, 1.8, -0.066666666666667, 0.45
5808, 1.8, -0.13333333333333, 0.45
5809, 2, -0.066666666666667, 0.45
5810, 2, -0.13333333333333, 0.45
5811, 2.25, -0.066666666666667, 0.1
5812, 2.25, -0.13333333333333, 0.1
5813, 2.25, -0.066666666666667, 0.2
5814, 2.25, -0.13333333333333, 0.2
5815, 2.25, -0.066666666666667, 0.3
5816, 2.25, -0.13333333333333, 0.3
5817, 2.25, -0.066666666666667, 0.4
5818, 2.25, -0.13333333333333, 0.4
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
97, 2, 101, 97
98, 97, 102, 98
99, 98, 103, 99
100, 99, 104, 100
101, 100, 105, 1
*ELEMENT, type=T3D3, ELSET=Line2
102, 1, 107, 106
103, 106, 108, 3
*ELEMENT, type=T3D3, ELSET=Line3
104, 4, 113, 109
105, 109, 114, 110
106, 110, 115, 111
107, 111, 116, 112
108, 112, 117, 3
*ELEMENT, type=T3D3, ELSET=Line4
109, 2, 119, 118
110, 118, 120, 4
*ELEMENT, type=T3D3, ELSET=Line5
111, 6, 125, 121
112, 121, 126, 122
113, 122, 127, 123
114, 123, 128, 124
115, 124, 129, 5
*ELEMENT, type=T3D3, ELSET=Line6
116, 5, 131, 130
117, 130, 132, 7
*ELEMENT, type=T3D3, ELSET=Line7
118, 8, 137, 133
119, 133, 138, 134
120, 134, 139, 135
121, 135, 140, 136
122, 136, 141, 7
*ELEMENT, type=T3D3, ELSET=Line8
123, 6, 143, 142
124, 142, 144, 8
*ELEMENT, type=T3D3, ELSET=Line9
125, 2, 149, 145
126, 145, 150, 146
127, 146, 151, 147
128, 147, 152, 148
129, 148, 153, 6
*ELEMENT, type=T3D3, ELSET=Line10
130, 1, 158, 154
131, 154, 159, 155
132, 155, 160, 156
133, 156, 161, 157
134, 157, 162, 5
*ELEMENT, type=T3D3, ELSET=Line11
135, 4, 167, 163
136, 163, 168, 164
137, 164, 169, 165
138, 165, 170, 166
139, 166, 171, 8
*ELEMENT, type=T3D3, ELSET=Line12
140, 3, 176, 172
141, 172, 177, 173
142, 173, 178, 174
143, 174, 179, 175
144, 175, 180, 7
*ELEMENT, type=T3D3, ELSET=Line13
145, 8, 181, 9
*ELEMENT, type=T3D3, ELSET=Line14
146, 4, 182, 10
*ELEMENT, type=T3D3, ELSET=Line15
147, 10, 187, 183
148, 183, 188, 184
149, 184, 189, 185
150, 185, 190, 186
151, 186, 191, 9
*ELEMENT, type=T3D3, ELSET=Line16
152, 7, 192, 11
*ELEMENT, type=T3D3, ELSET=Line17
153, 9, 197, 193
154, 193, 198, 194
155, 194, 199, 195
156, 195, 200, 196
157, 196, 201, 11
*ELEMENT, type=T3D3, ELSET=Line18
158, 3, 202, 12
*ELEMENT, type=T3D3, ELSET=Line19
159, 12, 207, 203
160, 203, 208, 204
161, 204, 209, 205
162, 205, 210, 206
163, 206, 211, 11
*ELEMENT, type=T3D3, ELSET=Line20
164, 10, 216, 212
165, 212, 217, 213
166, 213, 218, 214
167, 214, 219, 215
168, 215, 220, 12
*ELEMENT, type=T3D3, ELSET=Line21
169, 9, 225, 221
170, 221, 226, 222
171, 222, 227, 223
172, 223, 228, 224
173, 224, 229, 13
*ELEMENT, type=T3D3, ELSET=Line22
174, 10, 234, 230
175, 230, 235, 231
176, 231, 236, 232
177, 232, 237, 233
178, 233, 238, 14
*ELEMENT, type=T3D3, ELSET=Line23
179, 14, 243, 239
180, 239, 244, 240
181, 240, 245, 241
182, 241, 246, 242
183, 242, 247, 13
*ELEMENT, type=T3D3, ELSET=Line24
184, 11, 252, 248
185, 248, 253, 249
186, 249, 254, 250
187, 250, 255, 251
188, 251, 256, 15
*ELEMENT, type=T3D3, ELSET=Line25
189, 13, 261, 257
190, 257, 262, 258
191, 258, 263, 259
192, 259, 264, 260
193, 260, 265, 15
*ELEMENT, type=T3D3, ELSET=Line26
194, 12, 270, 266
195, 266, 271, 267
196, 267, 272, 268
197, 268, 273, 269
198, 269, 274, 16
*ELEMENT, type=T3D3, ELSET=Line27
199, 16, 279, 275
200, 275, 280, 276
201, 276, 281, 277
202, 277, 282, 278
203, 278, 283, 15
*ELEMENT, type=T3D3, ELSET=Line28
204, 14, 288, 284
205, 284, 289, 285
206, 285, 290, 286
207, 286, 291, 287
208, 287, 292, 16
*ELEMENT, type=T3D3, ELSET=Line29
209, 13, 293, 17
*ELEMENT, type=T3D3, ELSET=Line30
210, 14, 294, 18
*ELEMENT, type=T3D3, ELSET=Line31
211, 18, 299, 295
212, 295, 300, 296
213, 296, 301, 297
214, 297, 302, 298
215, 298, 303, 17
*ELEMENT, type=T3D3, ELSET=Line32
216, 15, 304, 19
*ELEMENT, type=T3D3, ELSET=Line33
217, 17, 309, 305
218, 305, 310, 306
219, 306, 311, 307
220, 307, 312, 308
221, 308, 313, 19
*ELEMENT, type=T3D3, ELSET=Line34
222, 16, 314, 20
*ELEMENT, type=T3D3, ELSET=Line35
223, 20, 319, 315
224, 315, 320, 316
225, 316, 321, 317
226, 317, 322, 318
227, 318, 323, 19
*ELEMENT, type=T3D3, ELSET=Line36
228, 18, 328, 324
229, 324, 329, 325
230, 325, 330, 326
231, 326, 331, 327
232, 327, 332, 20
*ELEMENT, type=T3D3, ELSET=Line37
233, 17, 334, 333
234, 333, 335, 21
*ELEMENT, type=T3D3, ELSET=Line38
235, 18, 337, 336
236, 336, 338, 22
*ELEMENT, type=T3D3, ELSET=Line39
237, 22, 343, 339
238, 339, 344, 340
239, 340, 345, 341
240, 341, 346, 342
241, 342, 347, 21
*ELEMENT, type=T3D3, ELSET=Line40
242, 19, 349, 348
243, 348, 350, 23
*ELEMENT, type=T3D3, ELSET=Line41
244, 21, 355, 351
245, 351, 356, 352
246, 352, 357, 353
247, 353, 358, 354
248, 354, 359, 23
*ELEMENT, type=T3D3, ELSET=Line42
249, 20, 361, 360
250, 360, 362, 24
*ELEMENT, type=T3D3, ELSET=Line43
251, 24, 367, 363
252, 363, 368, 364
253, 364, 369, 365
254, 365, 370, 366
255, 366, 371, 23
*ELEMENT, type=T3D3, ELSET=Line44
256, 22, 376, 372
257, 372, 377, 373
258, 373, 378, 374
259, 374, 379, 375
260, 375, 380, 24
*ELEMENT, type=T3D3, ELSET=Line45
261, 19, 383, 381
262, 381, 384, 382
263, 382, 385, 25
*ELEMENT, type=T3D3, ELSET=Line46
264, 23, 388, 386
265, 386, 389, 387
266, 387, 390, 26
*ELEMENT, type=T3D3, ELSET=Line47
267, 25, 392, 391
268, 391, 393, 26
*ELEMENT, type=T3D3, ELSET=Line48
269, 17, 396, 394
270, 394, 397, 395
271, 395, 398, 27
*ELEMENT, type=T3D3, ELSET=Line49
272, 21, 401, 399
273, 399, 402, 400
274, 400, 403, 28
*ELEMENT, type=T3D3, ELSET=Line50
275, 27, 405, 404
276, 404, 406, 28
*ELEMENT, type=T3D3, ELSET=Line51
277, 27, 411, 407
278, 407, 412, 408
279, 408, 413, 409
280, 409, 414, 410
281, 410, 415, 25
*ELEMENT, type=T3D3, ELSET=Line52
282, 28, 420, 416
283, 416, 421, 417
284, 417, 422, 418
285, 418, 423, 419
286, 419, 424, 26
*ELEMENT, type=T3D3, ELSET=Line53
287, 25, 429, 425
288, 425, 430, 426
289, 426, 431, 427
290, 427, 432, 428
291, 428, 433, 29
*ELEMENT, type=T3D3, ELSET=Line54
292, 26, 438, 434
293, 434, 439, 435
294, 435, 440, 436
295, 436, 441, 437
296, 437, 442, 30
*ELEMENT, type=T3D3, ELSET=Line55
297, 29, 444, 443
298, 443, 445, 30
*ELEMENT, type=T3D3, ELSET=Line56
299, 27, 450, 446
300, 446, 451, 447
301, 447, 452, 448
302, 448, 453, 449
303, 449, 454, 31
*ELEMENT, type=T3D3, ELSET=Line57
304, 28, 459, 455
305, 455, 460, 456
306, 456, 461, 457
307, 457, 462, 458
308, 458, 463, 32
*ELEMENT, type=T3D3, ELSET=Line58
309, 31, 465, 464
310, 464, 466, 32
*ELEMENT, type=T3D3, ELSET=Line59
311, 31, 471, 467
312, 467, 472, 468
313, 468, 473, 469
314, 469, 474, 470
315, 470, 475, 29
*ELEMENT, type=T3D3, ELSET=Line60
316, 32, 480, 476
317, 476, 481, 477
318, 477, 482, 478
319, 478, 483, 479
320, 479, 484, 30
*ELEMENT, type=T3D3, ELSET=Line61
321, 25, 485, 33
*ELEMENT, type=T3D3, ELSET=Line62
322, 29, 486, 34
*ELEMENT, type=T3D3, ELSET=Line63
323, 33, 491, 487
324, 487, 492, 488
325, 488, 493, 489
326, 489, 494, 490
327, 490, 495, 34
*ELEMENT, type=T3D3, ELSET=Line64
328, 27, 496, 35
*ELEMENT, type=T3D3, ELSET=Line65
329, 31, 497, 36
*ELEMENT, type=T3D3, ELSET=Line66
330, 35, 502, 498
331, 498, 503, 499
332, 499, 504, 500
333, 500, 505, 501
334, 501, 506, 36
*ELEMENT, type=T3D3, ELSET=Line67
335, 35, 511, 507
336, 507, 512, 508
337, 508, 513, 509
338, 509, 514, 510
339, 510, 515, 33
*ELEMENT, type=T3D3, ELSET=Line68
340, 36, 520, 516
341, 516, 521, 517
342, 517, 522, 518
343, 518, 523, 519
344, 519, 524, 34
*ELEMENT, type=T3D3, ELSET=Line69
345, 33, 529, 525
346, 525, 530, 526
347, 526, 531, 527
348, 527, 532, 528
349, 528, 533, 37
*ELEMENT, type=T3D3, ELSET=Line70
350, 34, 538, 534
351, 534, 539, 535
352, 535, 540, 536
353, 536, 541, 537
354, 537, 542, 38
*ELEMENT, type=T3D3, ELSET=Line71
355, 37, 547, 543
356, 543, 548, 544
357, 544, 549, 545
358, 545, 550, 546
359, 546, 551, 38
*ELEMENT, type=T3D3, ELSET=Line72
360, 35, 556, 552
361, 552, 557, 553
362, 553, 558, 554
363, 554, 559, 555
364, 555, 560, 39
*ELEMENT, type=T3D3, ELSET=Line73
365, 36, 565, 561
366, 561, 566, 562
367, 562, 567, 563
368, 563, 568, 564
369, 564, 569, 40
*ELEMENT, type=T3D3, ELSET=Line74
370, 39, 574, 570
371, 570, 575, 571
372, 571, 576, 572
373, 572, 577, 573
374, 573, 578, 40
*ELEMENT, type=T3D3, ELSET=Line75
375, 39, 583, 579
376, 579, 584, 580
377, 580, 585, 581
378, 581, 586, 582
379, 582, 587, 37
*ELEMENT, type=T3D3, ELSET=Line76
380, 40, 592, 588
381, 588, 593, 589
382, 589, 594, 590
383, 590, 595, 591
384, 591, 596, 38
*ELEMENT, type=T3D3, ELSET=Line77
385, 37, 597, 41
*ELEMENT, type=T3D3, ELSET=Line78
386, 38, 598, 42
*ELEMENT, type=T3D3, ELSET=Line79
387, 41, 603, 599
388, 599, 604, 600
389, 600, 605, 601
390, 601, 606, 602
391, 602, 607, 42
*ELEMENT, type=T3D3, ELSET=Line80
392, 39, 608, 43
*ELEMENT, type=T3D3, ELSET=Line81
393, 40, 609, 44
*ELEMENT, type=T3D3, ELSET=Line82
394, 43, 614, 610
395, 610, 615, 611
396, 611, 616, 612
397, 612, 617, 613
398, 613, 618, 44
*ELEMENT, type=T3D3, ELSET=Line83
399, 43, 623, 619
400, 619, 624, 620
401, 620, 625, 621
402, 621, 626, 622
403, 622, 627, 41
*ELEMENT, type=T3D3, ELSET=Line84
404, 44, 632, 628
405, 628, 633, 629
406, 629, 634, 630
407, 630, 635, 631
408, 631, 636, 42
*ELEMENT, type=T3D3, ELSET=Line85
409, 41, 638, 637
410, 637, 639, 45
*ELEMENT, type=T3D3, ELSET=Line86
411, 42, 641, 640
412, 640, 642, 46
*ELEMENT, type=T3D3, ELSET=Line87
413, 45, 647, 643
414, 643, 648, 644
415, 644, 649, 645
416, 645, 650, 646
417, 646, 651, 46
*ELEMENT, type=T3D3, ELSET=Line88
418, 43, 653, 652
419, 652, 654, 47
*ELEMENT, type=T3D3, ELSET=Line89
420, 44, 656, 655
421, 655, 657, 48
*ELEMENT, type=T3D3, ELSET=Line90
422, 47, 662, 658
423, 658, 663, 659
424, 659, 664, 660
425, 660, 665, 661
426, 661, 666, 48
*ELEMENT, type=T3D3, ELSET=Line91
427, 47, 671, 667
428, 667, 672, 668
429, 668, 673, 669
430, 669, 674, 670
431, 670, 675, 45
*ELEMENT, type=T3D3, ELSET=Line92
432, 48, 680, 676
433, 676, 681, 677
434, 677, 682, 678
435, 678, 683, 679
436, 679, 684, 46
*ELEMENT, type=T3D3, ELSET=Line93
437, 42, 685, 49
*ELEMENT, type=T3D3, ELSET=Line94
438, 46, 686, 50
*ELEMENT, type=T3D3, ELSET=Line95
439, 49, 688, 687
440, 687, 689, 50
*ELEMENT, type=T3D3, ELSET=Line96
441, 44, 690, 51
*ELEMENT, type=T3D3, ELSET=Line97
442, 48, 691, 52
*ELEMENT, type=T3D3, ELSET=Line98
443, 51, 693, 692
444, 692, 694, 52
*ELEMENT, type=T3D3, ELSET=Line99
445, 51, 699, 695
446, 695, 700, 696
447, 696, 701, 697
448, 697, 702, 698
449, 698, 703, 49
*ELEMENT, type=T3D3, ELSET=Line100
450, 52, 708, 704
451, 704, 709, 705
452, 705, 710, 706
453, 706, 711, 707
454, 707, 712, 50
*ELEMENT, type=T3D3, ELSET=Line101
455, 1, 713, 53
*ELEMENT, type=T3D3, ELSET=Line102
456, 2, 714, 54
*ELEMENT, type=T3D3, ELSET=Line103
457, 54, 719, 715
458, 715, 720, 716
459, 716, 721, 717
460, 717, 722, 718
461, 718, 723, 53
*ELEMENT, type=T3D3, ELSET=Line104
462, 3, 724, 55
*ELEMENT, type=T3D3, ELSET=Line105
463, 53, 726, 725
464, 725, 727, 55
*ELEMENT, type=T3D3, ELSET=Line106
465, 4, 728, 56
*ELEMENT, type=T3D3, ELSET=Line107
466, 56, 733, 729
467, 729, 734, 730
468, 730, 735, 731
469, 731, 736, 732
470, 732, 737, 55
*ELEMENT, type=T3D3, ELSET=Line108
471, 54, 739, 738
472, 738, 740, 56
*ELEMENT, type=T3D3, ELSET=Line125
473, 11, 741, 57
*ELEMENT, type=T3D3, ELSET=Line126
474, 15, 742, 58
*ELEMENT, type=T3D3, ELSET=Line127
475, 57, 747, 743
476, 743, 748, 744
477, 744, 749, 745
478, 745, 750, 746
479, 746, 751, 58
*ELEMENT, type=T3D3, ELSET=Line128
480, 9, 752, 59
*ELEMENT, type=T3D3, ELSET=Line129
481, 13, 753, 60
*ELEMENT, type=T3D3, ELSET=Line130
482, 59, 758, 754
483, 754, 759, 755
484, 755, 760, 756
485, 756, 761, 757
486, 757, 762, 60
*ELEMENT, type=T3D3, ELSET=Line131
487, 59, 767, 763
488, 763, 768, 764
489, 764, 769, 765
490, 765, 770, 766
491, 766, 771, 57
*ELEMENT, type=T3D3, ELSET=Line132
492, 60, 776, 772
493, 772, 777, 773
494, 773, 778, 774
495, 774, 779, 775
496, 775, 780, 58
*ELEMENT, type=T3D3, ELSET=Line133
497, 33, 781, 61
*ELEMENT, type=T3D3, ELSET=Line134
498, 37, 782, 62
*ELEMENT, type=T3D3, ELSET=Line135
499, 61, 787, 783
500, 783, 788, 784
501, 784, 789, 785
502, 785, 790, 786
503, 786, 791, 62
*ELEMENT, type=T3D3, ELSET=Line136
504, 35, 792, 63
*ELEMENT, type=T3D3, ELSET=Line137
505, 39, 793, 64
*ELEMENT, type=T3D3, ELSET=Line138
506, 63, 798, 794
507, 794, 799, 795
508, 795, 800, 796
509, 796, 801, 797
510, 797, 802, 64
*ELEMENT, type=T3D3, ELSET=Line139
511, 63, 807, 803
512, 803, 808, 804
513, 804, 809, 805
514, 805, 810, 806
515, 806, 811, 61
*ELEMENT, type=T3D3, ELSET=Line140
516, 64, 816, 812
517, 812, 817, 813
518, 813, 818, 814
519, 814, 819, 815
520, 815, 820, 62
*ELEMENT, type=T3D3, ELSET=Line141
521, 9, 821, 65
*ELEMENT, type=T3D3, ELSET=Line142
522, 13, 822, 66
*ELEMENT, type=T3D3, ELSET=Line143
523, 65, 827, 823
524, 823, 828, 824
525, 824, 829, 825
526, 825, 830, 826
527, 826, 831, 66
*ELEMENT, type=T3D3, ELSET=Line144
528, 10, 832, 67
*ELEMENT, type=T3D3, ELSET=Line145
529, 14, 833, 68
*ELEMENT, type=T3D3, ELSET=Line146
530, 67, 838, 834
531, 834, 839, 835
532, 835, 840, 836
533, 836, 841, 837
534, 837, 842, 68
*ELEMENT, type=T3D3, ELSET=Line147
535, 67, 847, 843
536, 843, 848, 844
537, 844, 849, 845
538, 845, 850, 846
539, 846, 851, 65
*ELEMENT, type=T3D3, ELSET=Line148
540, 68, 856, 852
541, 852, 857, 853
542, 853, 858, 854
543, 854, 859, 855
544, 855, 860, 66
*ELEMENT, type=T3D3, ELSET=Line149
545, 35, 861, 69
*ELEMENT, type=T3D3, ELSET=Line150
546, 39, 862, 70
*ELEMENT, type=T3D3, ELSET=Line151
547, 69, 867, 863
548, 863, 868, 864
549, 864, 869, 865
550, 865, 870, 866
551, 866, 871, 70
*ELEMENT, type=T3D3, ELSET=Line152
552, 36, 872, 71
*ELEMENT, type=T3D3, ELSET=Line153
553, 40, 873, 72
*ELEMENT, type=T3D3, ELSET=Line154
554, 71, 878, 874
555, 874, 879, 875
556, 875, 880, 876
557, 876, 881, 877
558, 877, 882, 72
*ELEMENT, type=T3D3, ELSET=Line155
559, 69, 887, 883
560, 883, 888, 884
561, 884, 889, 885
562, 885, 890, 886
563, 886, 891, 71
*ELEMENT, type=T3D3, ELSET=Line156
564, 70, 896, 892
565, 892, 897, 893
566, 893, 898, 894
567, 894, 899, 895
568, 895, 900, 72
*ELEMENT, type=T3D3, ELSET=Line157
569, 63, 901, 73
*ELEMENT, type=T3D3, ELSET=Line158
570, 69, 902, 73
*ELEMENT, type=T3D3, ELSET=Line159
571, 64, 903, 74
*ELEMENT, type=T3D3, ELSET=Line160
572, 70, 904, 74
*ELEMENT, type=T3D3, ELSET=Line161
573, 73, 909, 905
574, 905, 910, 906
575, 906, 911, 907
576, 907, 912, 908
577, 908, 913, 74
*ELEMENT, type=T3D3, ELSET=Line162
578, 59, 914, 75
*ELEMENT, type=T3D3, ELSET=Line163
579, 65, 915, 75
*ELEMENT, type=T3D3, ELSET=Line164
580, 60, 916, 76
*ELEMENT, type=T3D3, ELSET=Line165
581, 66, 917, 76
*ELEMENT, type=T3D3, ELSET=Line166
582, 75, 922, 918
583, 918, 923, 919
584, 919, 924, 920
585, 920, 925, 921
586, 921, 926, 76
*ELEMENT, type=T3D3, ELSET=Line167
587, 21, 929, 927
588, 927, 930, 928
589, 928, 931, 77
*ELEMENT, type=T3D3, ELSET=Line168
590, 22, 934, 932
591, 932, 935, 933
592, 933, 936, 78
*ELEMENT, type=T3D3, ELSET=Line169
593, 78, 941, 937
594, 937, 942, 938
595, 938, 943, 939
596, 939, 944, 940
597, 940, 945, 77
*ELEMENT, type=T3D3, ELSET=Line170
598, 23, 948, 946
599, 946, 949, 947
600, 947, 950, 79
*ELEMENT, type=T3D3, ELSET=Line171
601, 77, 955, 951
602, 951, 956, 952
603, 952, 957, 953
604, 953, 958, 954
605, 954, 959, 79
*ELEMENT, type=T3D3, ELSET=Line172
606, 24, 962, 960
607, 960, 963, 961
608, 961, 964, 80
*ELEMENT, type=T3D3, ELSET=Line173
609, 80, 969, 965
610, 965, 970, 966
611, 966, 971, 967
612, 967, 972, 968
613, 968, 973, 79
*ELEMENT, type=T3D3, ELSET=Line174
614, 78, 978, 974
615, 974, 979, 975
616, 975, 980, 976
617, 976, 981, 977
618, 977, 982, 80
*ELEMENT, type=T3D3, ELSET=Line175
619, 26, 985, 983
620, 983, 986, 984
621, 984, 987, 81
*ELEMENT, type=T3D3, ELSET=Line176
622, 79, 990, 988
623, 988, 991, 989
624, 989, 992, 81
*ELEMENT, type=T3D3, ELSET=Line177
625, 28, 995, 993
626, 993, 996, 994
627, 994, 997, 82
*ELEMENT, type=T3D3, ELSET=Line178
628, 77, 1000, 998
629, 998, 1001, 999
630, 999, 1002, 82
*ELEMENT, type=T3D3, ELSET=Line179
631, 82, 1007, 1003
632, 1003, 1008, 1004
633, 1004, 1009, 1005
634, 1005, 1010, 1006
635, 1006, 1011, 81
*ELEMENT, type=T3D3, ELSET=Line180
636, 30, 1014, 1012
637, 1012, 1015, 1013
638, 1013, 1016, 83
*ELEMENT, type=T3D3, ELSET=Line181
639, 81, 1021, 1017
640, 1017, 1022, 1018
641, 1018, 1023, 1019
642, 1019, 1024, 1020
643, 1020, 1025, 83
*ELEMENT, type=T3D3, ELSET=Line182
644, 32, 1028, 1026
645, 1026, 1029, 1027
646, 1027, 1030, 84
*ELEMENT, type=T3D3, ELSET=Line183
647, 82, 1035, 1031
648, 1031, 1036, 1032
649, 1032, 1037, 1033
650, 1033, 1038, 1034
651, 1034, 1039, 84
*ELEMENT, type=T3D3, ELSET=Line184
652, 84, 1044, 1040
653, 1040, 1045, 1041
654, 1041, 1046, 1042
655, 1042, 1047, 1043
656, 1043, 1048, 83
*ELEMENT, type=T3D3, ELSET=Line185
657, 6, 1051, 1049
658, 1049, 1052, 1050
659, 1050, 1053, 85
*ELEMENT, type=T3D3, ELSET=Line186
660, 2, 1056, 1054
661, 1054, 1057, 1055
662, 1055, 1058, 86
*ELEMENT, type=T3D3, ELSET=Line187
663, 86, 1063, 1059
664, 1059, 1064, 1060
665, 1060, 1065, 1061
666, 1061, 1066, 1062
667, 1062, 1067, 85
*ELEMENT, type=T3D3, ELSET=Line188
668, 5, 1070, 1068
669, 1068, 1071, 1069
670, 1069, 1072, 87
*ELEMENT, type=T3D3, ELSET=Line189
671, 85, 1077, 1073
672, 1073, 1078, 1074
673, 1074, 1079, 1075
674, 1075, 1080, 1076
675, 1076, 1081, 87
*ELEMENT, type=T3D3, ELSET=Line190
676, 1, 1084, 1082
677, 1082, 1085, 1083
678, 1083, 1086, 88
*ELEMENT, type=T3D3, ELSET=Line191
679, 88, 1091, 1087
680, 1087, 1092, 1088
681, 1088, 1093, 1089
682, 1089, 1094, 1090
683, 1090, 1095, 87
*ELEMENT, type=T3D3, ELSET=Line192
684, 86, 1100, 1096
685, 1096, 1101, 1097
686, 1097, 1102, 1098
687, 1098, 1103, 1099
688, 1099, 1104, 88
*ELEMENT, type=T3D3, ELSET=Line193
689, 53, 1107, 1105
690, 1105, 1108, 1106
691, 1106, 1109, 89
*ELEMENT, type=T3D3, ELSET=Line194
692, 88, 1110, 89
*ELEMENT, type=T3D3, ELSET=Line195
693, 54, 1113, 1111
694, 1111, 1114, 1112
695, 1112, 1115, 90
*ELEMENT, type=T3D3, ELSET=Line196
696, 86, 1116, 90
*ELEMENT, type=T3D3, ELSET=Line197
697, 90, 1121, 1117
698, 1117, 1122, 1118
699, 1118, 1123, 1119
700, 1119, 1124, 1120
701, 1120, 1125, 89
*ELEMENT, type=T3D3, ELSET=Line198
702, 45, 1128, 1126
703, 1126, 1129, 1127
704, 1127, 1130, 91
*ELEMENT, type=T3D3, ELSET=Line199
705, 46, 1133, 1131
706, 1131, 1134, 1132
707, 1132, 1135, 92
*ELEMENT, type=T3D3, ELSET=Line200
708, 91, 1140, 1136
709, 1136, 1141, 1137
710, 1137, 1142, 1138
711, 1138, 1143, 1139
712, 1139, 1144, 92
*ELEMENT, type=T3D3, ELSET=Line201
713, 47, 1147, 1145
714, 1145, 1148, 1146
715, 1146, 1149, 93
*ELEMENT, type=T3D3, ELSET=Line202
716, 48, 1152, 1150
717, 1150, 1153, 1151
718, 1151, 1154, 94
*ELEMENT, type=T3D3, ELSET=Line203
719, 93, 1159, 1155
720, 1155, 1160, 1156
721, 1156, 1161, 1157
722, 1157, 1162, 1158
723, 1158, 1163, 94
*ELEMENT, type=T3D3, ELSET=Line204
724, 93, 1168, 1164
725, 1164, 1169, 1165
726, 1165, 1170, 1166
727, 1166, 1171, 1167
728, 1167, 1172, 91
*ELEMENT, type=T3D3, ELSET=Line205
729, 94, 1177, 1173
730, 1173, 1178, 1174
731, 1174, 1179, 1175
732, 1175, 1180, 1176
733, 1176, 1181, 92
*ELEMENT, type=T3D3, ELSET=Line206
734, 50, 1184, 1182
735, 1182, 1185, 1183
736, 1183, 1186, 95
*ELEMENT, type=T3D3, ELSET=Line207
737, 92, 1187, 95
*ELEMENT, type=T3D3, ELSET=Line208
738, 52, 1190, 1188
739, 1188, 1191, 1189
740, 1189, 1192, 96
*ELEMENT, type=T3D3, ELSET=Line209
741, 94, 1193, 96
*ELEMENT, type=T3D3, ELSET=Line210
742, 96, 1198, 1194
743, 1194, 1199, 1195
744, 1195, 1200, 1196
745, 1196, 1201, 1197
746, 1197, 1202, 95
*ELEMENT, type=CPS8, ELSET=Surface1
747, 2, 97, 1203, 118, 101, 1207, 1208, 119
748, 118, 1203, 109, 4, 1208, 1209, 113, 120
749, 97, 98, 1204, 1203, 102, 1210, 1211, 1207
750, 1203, 1204, 110, 109, 1211, 1212, 114, 1209
751, 98, 99, 1205, 1204, 103, 1213, 1214, 1210
752, 1204, 1205, 111, 110, 1214, 1215, 115, 1212
753, 99, 100, 1206, 1205, 104, 1216, 1217, 1213
754, 1205, 1206, 112, 111, 1217, 1218, 116, 1215
755, 100, 1, 106, 1206, 105, 107, 1219, 1216
756, 1206, 106, 3, 112, 1219, 108, 117, 1218
*ELEMENT, type=CPS8, ELSET=Surface2
757, 6, 142, 1220, 121, 143, 1224, 1225, 125
758, 142, 8, 133, 1220, 144, 137, 1226, 1224
759, 121, 1220, 1221, 122, 1225, 1227, 1228, 126
760, 1220, 133, 134, 1221, 1226, 138, 1229, 1227
761, 122, 1221, 1222, 123, 1228, 1230, 1231, 127
762, 1221, 134, 135, 1222, 1229, 139, 1232, 1230
763, 123, 1222, 1223, 124, 1231, 1233, 1234, 128
764, 1222, 135, 136, 1223, 1232, 140, 1235, 1233
765, 124, 1223, 130, 5, 1234, 1236, 131, 129
766, 1223, 136, 7, 130, 1235, 141, 132, 1236
*ELEMENT, type=CPS8, ELSET=Surface3
767, 2, 145, 1237, 97, 149, 1253, 1254, 101
768, 97, 1237, 1238, 98, 1254, 1255, 1256, 102
769, 98, 1238, 1239, 99, 1256, 1257, 1258, 103
770, 99, 1239, 1240, 100, 1258, 1259, 1260, 104
771, 100, 1240, 154, 1, 1260, 1261, 158, 105
772, 145, 146, 1241, 1237, 150, 1262, 1263, 1253
773, 1237, 1241, 1242, 1238, 1263, 1264, 1265, 1255
774, 1238, 1242, 1243, 1239, 1265, 1266, 1267, 1257
775, 1239, 1243, 1244, 1240, 1267, 1268, 1269, 1259
776, 1240, 1244, 155, 154, 1269, 1270, 159, 1261
777, 146, 147, 1245, 1241, 151, 1271, 1272, 1262
778, 1241, 1245, 1246, 1242, 1272, 1273, 1274, 1264
779, 1242, 1246, 1247, 1243, 1274, 1275, 1276, 1266
780, 1243, 1247, 1248, 1244, 1276, 1277, 1278, 1268
781, 1244, 1248, 156, 155, 1278, 1279, 160, 1270
782, 147, 148, 1249, 1245, 152, 1280, 1281, 1271
783, 1245, 1249, 1250, 1246, 1281, 1282, 1283, 1273
784, 1246, 1250, 1251, 1247, 1283, 1284, 1285, 1275
785, 1247, 1251, 1252, 1248, 1285, 1286, 1287, 1277
786, 1248, 1252, 157, 156, 1287, 1288, 161, 1279
787, 148, 6, 121, 1249, 153, 125, 1289, 1280
788, 1249, 121, 122, 1250, 1289, 126, 1290, 1282
789, 1250, 122, 123, 1251, 1290, 127, 1291, 1284
790, 1251, 123, 124, 1252, 1291, 128, 1292, 1286
791, 1252, 124, 5, 157, 1292, 129, 162, 1288
*ELEMENT, type=CPS8, ELSET=Surface4
792, 4, 109, 1293, 163, 113, 1309, 1310, 167
793, 109, 110, 1294, 1293, 114, 1311, 1312, 1309
794, 110, 111, 1295, 1294, 115, 1313, 1314, 1311
795, 111, 112, 1296, 1295, 116, 1315, 1316, 1313
796, 112, 3, 172, 1296, 117, 176, 1317, 1315
797, 163, 1293, 1297, 164, 1310, 1318, 1319, 168
798, 1293, 1294, 1298, 1297, 1312, 1320, 1321, 1318
799, 1294, 1295, 1299, 1298, 1314, 1322, 1323, 1320
800, 1295, 1296, 1300, 1299, 1316, 1324, 1325, 1322
801, 1296, 172, 173, 1300, 1317, 177, 1326, 1324
802, 164, 1297, 1301, 165, 1319, 1327, 1328, 169
803, 1297, 1298, 1302, 1301, 1321, 1329, 1330, 1327
804, 1298, 1299, 1303, 1302, 1323, 1331, 1332, 1329
805, 1299, 1300, 1304, 1303, 1325, 1333, 1334, 1331
806, 1300, 173, 174, 1304, 1326, 178, 1335, 1333
807, 165, 1301, 1305, 166, 1328, 1336, 1337, 170
808, 1301, 1302, 1306, 1305, 1330, 1338, 1339, 1336
809, 1302, 1303, 1307, 1306, 1332, 1340, 1341, 1338
810, 1303, 1304, 1308, 1307, 1334, 1342, 1343, 1340
811, 1304, 174, 175, 1308, 1335, 179, 1344, 1342
812, 166, 1305, 133, 8, 1337, 1345, 137, 171
813, 1305, 1306, 134, 133, 1339, 1346, 138, 1345
814, 1306, 1307, 135, 134, 1341, 1347, 139, 1346
815, 1307, 1308, 136, 135, 1343, 1348, 140, 1347
816, 1308, 175, 7, 136, 1344, 180, 141, 1348
*ELEMENT, type=CPS8, ELSET=Surface5
817, 2, 118, 1349, 145, 119, 1353, 1354, 149
818, 145, 1349, 1350, 146, 1354, 1355, 1356, 150
819, 146, 1350, 1351, 147, 1356, 1357, 1358, 151
820, 147, 1351, 1352, 148, 1358, 1359, 1360, 152
821, 148, 1352, 142, 6, 1360, 1361, 143, 153
822, 118, 4, 163, 1349, 120, 167, 1362, 1353
823, 1349, 163, 164, 1350, 1362, 168, 1363, 1355
824, 1350, 164, 165, 1351, 1363, 169, 1364, 1357
825, 1351, 165, 166, 1352, 1364, 170, 1365, 1359
826, 1352, 166, 8, 142, 1365, 171, 144, 1361
*ELEMENT, type=CPS8, ELSET=Surface6
827, 1, 154, 1366, 106, 158, 1370, 1371, 107
828, 154, 155, 1367, 1366, 159, 1372, 1373, 1370
829, 155, 156, 1368, 1367, 160, 1374, 1375, 1372
830, 156, 157, 1369, 1368, 161, 1376, 1377, 1374
831, 157, 5, 130, 1369, 162, 131, 1378, 1376
832, 106, 1366, 172, 3, 1371, 1379, 176, 108
833, 1366, 1367, 173, 172, 1373, 1380, 177, 1379
834, 1367, 1368, 174, 173, 1375, 1381, 178, 1380
835, 1368, 1369, 175, 174, 1377, 1382, 179, 1381
836, 1369, 130, 7, 175, 1378, 132, 180, 1382
*ELEMENT, type=CPS8, ELSET=Surface7
837, 4, 10, 183, 163, 182, 187, 1383, 167
838, 163, 183, 184, 164, 1383, 188, 1384, 168
839, 164, 184, 185, 165, 1384, 189, 1385, 169
840, 165, 185, 186, 166, 1385, 190, 1386, 170
841, 166, 186, 9, 8, 1386, 191, 181, 171
*ELEMENT, type=CPS8, ELSET=Surface8
842, 8, 9, 193, 133, 181, 197, 1387, 137
843, 133, 193, 194, 134, 1387, 198, 1388, 138
844, 134, 194, 195, 135, 1388, 199, 1389, 139
845, 135, 195, 196, 136, 1389, 200, 1390, 140
846, 136, 196, 11, 7, 1390, 201, 192, 141
*ELEMENT, type=CPS8, ELSET=Surface9
847, 3, 172, 203, 12, 176, 1391, 207, 202
848, 172, 173, 204, 203, 177, 1392, 208, 1391
849, 173, 174, 205, 204, 178, 1393, 209, 1392
850, 174, 175, 206, 205, 179, 1394, 210, 1393
851, 175, 7, 11, 206, 180, 192, 211, 1394
*ELEMENT, type=CPS8, ELSET=Surface10
852, 4, 109, 212, 10, 113, 1395, 216, 182
853, 109, 110, 213, 212, 114, 1396, 217, 1395
854, 110, 111, 214, 213, 115, 1397, 218, 1396
855, 111, 112, 215, 214, 116, 1398, 219, 1397
856, 112, 3, 12, 215, 117, 202, 220, 1398
*ELEMENT, type=CPS8, ELSET=Surface11
857, 10, 212, 1399, 183, 216, 1415, 1416, 187
858, 212, 213, 1400, 1399, 217, 1417, 1418, 1415
859, 213, 214, 1401, 1400, 218, 1419, 1420, 1417
860, 214, 215, 1402, 1401, 219, 1421, 1422, 1419
861, 215, 12, 203, 1402, 220, 207, 1423, 1421
862, 183, 1399, 1403, 184, 1416, 1424, 1425, 188
863, 1399, 1400, 1404, 1403, 1418, 1426, 1427, 1424
864, 1400, 1401, 1405, 1404, 1420, 1428, 1429, 1426
865, 1401, 1402, 1406, 1405, 1422, 1430, 1431, 1428
866, 1402, 203, 204, 1406, 1423, 208, 1432, 1430
867, 184, 1403, 1407, 185, 1425, 1433, 1434, 189
868, 1403, 1404, 1408, 1407, 1427, 1435, 1436, 1433
869, 1404, 1405, 1409, 1408, 1429, 1437, 1438, 1435
870, 1405, 1406, 1410, 1409, 1431, 1439, 1440, 1437
871, 1406, 204, 205, 1410, 1432, 209, 1441, 1439
872, 185, 1407, 1411, 186, 1434, 1442, 1443, 190
873, 1407, 1408, 1412, 1411, 1436, 1444, 1445, 1442
874, 1408, 1409, 1413, 1412, 1438, 1446, 1447, 1444
875, 1409, 1410, 1414, 1413, 1440, 1448, 1449, 1446
876, 1410, 205, 206, 1414, 1441, 210, 1450, 1448
877, 186, 1411, 193, 9, 1443, 1451, 197, 191
878, 1411, 1412, 194, 193, 1445, 1452, 198, 1451
879, 1412, 1413, 195, 194, 1447, 1453, 199, 1452
880, 1413, 1414, 196, 195, 1449, 1454, 200, 1453
881, 1414, 206, 11, 196, 1450, 211, 201, 1454
*ELEMENT, type=CPS8, ELSET=Surface12
882, 10, 230, 1455, 183, 234, 1471, 1472, 187
883, 230, 231, 1456, 1455, 235, 1473, 1474, 1471
884, 231, 232, 1457, 1456, 236, 1475, 1476, 1473
885, 232, 233, 1458, 1457, 237, 1477, 1478, 1475
886, 233, 14, 239, 1458, 238, 243, 1479, 1477
887, 183, 1455, 1459, 184, 1472, 1480, 1481, 188
888, 1455, 1456, 1460, 1459, 1474, 1482, 1483, 1480
889, 1456, 1457, 1461, 1460, 1476, 1484, 1485, 1482
890, 1457, 1458, 1462, 1461, 1478, 1486, 1487, 1484
891, 1458, 239, 240, 1462, 1479, 244, 1488, 1486
892, 184, 1459, 1463, 185, 1481, 1489, 1490, 189
893, 1459, 1460, 1464, 1463, 1483, 1491, 1492, 1489
894, 1460, 1461, 1465, 1464, 1485, 1493, 1494, 1491
895, 1461, 1462, 1466, 1465, 1487, 1495, 1496, 1493
896, 1462, 240, 241, 1466, 1488, 245, 1497, 1495
897, 185, 1463, 1467, 186, 1490, 1498, 1499, 190
898, 1463, 1464, 1468, 1467, 1492, 1500, 1501, 1498
899, 1464, 1465, 1469, 1468, 1494, 1502, 1503, 1500
900, 1465, 1466, 1470, 1469, 1496, 1504, 1505, 1502
901, 1466, 241, 242, 1470, 1497, 246, 1506, 1504
902, 186, 1467, 221, 9, 1499, 1507, 225, 191
903, 1467, 1468, 222, 221, 1501, 1508, 226, 1507
904, 1468, 1469, 223, 222, 1503, 1509, 227, 1508
905, 1469, 1470, 224, 223, 1505, 1510, 228, 1509
906, 1470, 242, 13, 224, 1506, 247, 229, 1510
*ELEMENT, type=CPS8, ELSET=Surface13
907, 9, 221, 1511, 193, 225, 1527, 1528, 197
908, 221, 222, 1512, 1511, 226, 1529, 1530, 1527
909, 222, 223, 1513, 1512, 227, 1531, 1532, 1529
910, 223, 224, 1514, 1513, 228, 1533, 1534, 1531
911, 224, 13, 257, 1514, 229, 261, 1535, 1533
912, 193, 1511, 1515, 194, 1528, 1536, 1537, 198
913, 1511, 1512, 1516, 1515, 1530, 1538, 1539, 1536
914, 1512, 1513, 1517, 1516, 1532, 1540, 1541, 1538
915, 1513, 1514, 1518, 1517, 1534, 1542, 1543, 1540
916, 1514, 257, 258, 1518, 1535, 262, 1544, 1542
917, 194, 1515, 1519, 195, 1537, 1545, 1546, 199
918, 1515, 1516, 1520, 1519, 1539, 1547, 1548, 1545
919, 1516, 1517, 1521, 1520, 1541, 1549, 1550, 1547
920, 1517, 1518, 1522, 1521, 1543, 1551, 1552, 1549
921, 1518, 258, 259, 1522, 1544, 263, 1553, 1551
922, 195, 1519, 1523, 196, 1546, 1554, 1555, 200
923, 1519, 1520, 1524, 1523, 1548, 1556, 1557, 1554
924, 1520, 1521, 1525, 1524, 1550, 1558, 1559, 1556
925, 1521, 1522, 1526, 1525, 1552, 1560, 1561, 1558
926, 1522, 259, 260, 1526, 1553, 264, 1562, 1560
927, 196, 1523, 248, 11, 1555, 1563, 252, 201
928, 1523, 1524, 249, 248, 1557, 1564, 253, 1563
929, 1524, 1525, 250, 249, 1559, 1565, 254, 1564
930, 1525, 1526, 251, 250, 1561, 1566, 255, 1565
931, 1526, 260, 15, 251, 1562, 265, 256, 1566
*ELEMENT, type=CPS8, ELSET=Surface14
932, 12, 203, 1567, 266, 207, 1583, 1584, 270
933, 266, 1567, 1568, 267, 1584, 1585, 1586, 271
934, 267, 1568, 1569, 268, 1586, 1587, 1588, 272
935, 268, 1569, 1570, 269, 1588, 1589, 1590, 273
936, 269, 1570, 275, 16, 1590, 1591, 279, 274
937, 203, 204, 1571, 1567, 208, 1592, 1593, 1583
938, 1567, 1571, 1572, 1568, 1593, 1594, 1595, 1585
939, 1568, 1572, 1573, 1569, 1595, 1596, 1597, 1587
940, 1569, 1573, 1574, 1570, 1597, 1598, 1599, 1589
941, 1570, 1574, 276, 275, 1599, 1600, 280, 1591
942, 204, 205, 1575, 1571, 209, 1601, 1602, 1592
943, 1571, 1575, 1576, 1572, 1602, 1603, 1604, 1594
944, 1572, 1576, 1577, 1573, 1604, 1605, 1606, 1596
945, 1573, 1577, 1578, 1574, 1606, 1607, 1608, 1598
946, 1574, 1578, 277, 276, 1608, 1609, 281, 1600
947, 205, 206, 1579, 1575, 210, 1610, 1611, 1601
948, 1575, 1579, 1580, 1576, 1611, 1612, 1613, 1603
949, 1576, 1580, 1581, 1577, 1613, 1614, 1615, 1605
950, 1577, 1581, 1582, 1578, 1615, 1616, 1617, 1607
951, 1578, 1582, 278, 277, 1617, 1618, 282, 1609
952, 206, 11, 248, 1579, 211, 252, 1619, 1610
953, 1579, 248, 249, 1580, 1619, 253, 1620, 1612
954, 1580, 249, 250, 1581, 1620, 254, 1621, 1614
955, 1581, 250, 251, 1582, 1621, 255, 1622, 1616
956, 1582, 251, 15, 278, 1622, 256, 283, 1618
*ELEMENT, type=CPS8, ELSET=Surface15
957, 10, 212, 1623, 230, 216, 1639, 1640, 234
958, 230, 1623, 1624, 231, 1640, 1641, 1642, 235
959, 231, 1624, 1625, 232, 1642, 1643, 1644, 236
960, 232, 1625, 1626, 233, 1644, 1645, 1646, 237
961, 233, 1626, 284, 14, 1646, 1647, 288, 238
962, 212, 213, 1627, 1623, 217, 1648, 1649, 1639
963, 1623, 1627, 1628, 1624, 1649, 1650, 1651, 1641
964, 1624, 1628, 1629, 1625, 1651, 1652, 1653, 1643
965, 1625, 1629, 1630, 1626, 1653, 1654, 1655, 1645
966, 1626, 1630, 285, 284, 1655, 1656, 289, 1647
967, 213, 214, 1631, 1627, 218, 1657, 1658, 1648
968, 1627, 1631, 1632, 1628, 1658, 1659, 1660, 1650
969, 1628, 1632, 1633, 1629, 1660, 1661, 1662, 1652
970, 1629, 1633, 1634, 1630, 1662, 1663, 1664, 1654
971, 1630, 1634, 286, 285, 1664, 1665, 290, 1656
972, 214, 215, 1635, 1631, 219, 1666, 1667, 1657
973, 1631, 1635, 1636, 1632, 1667, 1668, 1669, 1659
974, 1632, 1636, 1637, 1633, 1669, 1670, 1671, 1661
975, 1633, 1637, 1638, 1634, 1671, 1672, 1673, 1663
976, 1634, 1638, 287, 286, 1673, 1674, 291, 1665
977, 215, 12, 266, 1635, 220, 270, 1675, 1666
978, 1635, 266, 267, 1636, 1675, 271, 1676, 1668
979, 1636, 267, 268, 1637, 1676, 272, 1677, 1670
980, 1637, 268, 269, 1638, 1677, 273, 1678, 1672
981, 1638, 269, 16, 287, 1678, 274, 292, 1674
*ELEMENT, type=CPS8, ELSET=Surface16
982, 14, 284, 1679, 239, 288, 1695, 1696, 243
983, 284, 285, 1680, 1679, 289, 1697, 1698, 1695
984, 285, 286, 1681, 1680, 290, 1699, 1700, 1697
985, 286, 287, 1682, 1681, 291, 1701, 1702, 1699
986, 287, 16, 275, 1682, 292, 279, 1703, 1701
987, 239, 1679, 1683, 240, 1696, 1704, 1705, 244
988, 1679, 1680, 1684, 1683, 1698, 1706, 1707, 1704
989, 1680, 1681, 1685, 1684, 1700, 1708, 1709, 1706
990, 1681, 1682, 1686, 1685, 1702, 1710, 1711, 1708
991, 1682, 275, 276, 1686, 1703, 280, 1712, 1710
992, 240, 1683, 1687, 241, 1705, 1713, 1714, 245
993, 1683, 1684, 1688, 1687, 1707, 1715, 1716, 1713
994, 1684, 1685, 1689, 1688, 1709, 1717, 1718, 1715
995, 1685, 1686, 1690, 1689, 1711, 1719, 1720, 1717
996, 1686, 276, 277, 1690, 1712, 281, 1721, 1719
997, 241, 1687, 1691, 242, 1714, 1722, 1723, 246
998, 1687, 1688, 1692, 1691, 1716, 1724, 1725, 1722
999, 1688, 1689, 1693, 1692, 1718, 1726, 1727, 1724
1000, 1689, 1690, 1694, 1693, 1720, 1728, 1729, 1726
1001, 1690, 277, 278, 1694, 1721, 282, 1730, 1728
1002, 242, 1691, 257, 13, 1723, 1731, 261, 247
1003, 1691, 1692, 258, 257, 1725, 1732, 262, 1731
1004, 1692, 1693, 259, 258, 1727, 1733, 263, 1732
1005, 1693, 1694, 260, 259, 1729, 1734, 264, 1733
1006, 1694, 278, 15, 260, 1730, 283, 265, 1734
*ELEMENT, type=CPS8, ELSET=Surface17
1007, 14, 18, 295, 239, 294, 299, 1735, 243
1008, 239, 295, 296, 240, 1735, 300, 1736, 244
1009, 240, 296, 297, 241, 1736, 301, 1737, 245
1010, 241, 297, 298, 242, 1737, 302, 1738, 246
1011, 242, 298, 17, 13, 1738, 303, 293, 247
*ELEMENT, type=CPS8, ELSET=Surface18
1012, 13, 17, 305, 257, 293, 309, 1739, 261
1013, 257, 305, 306, 258, 1739, 310, 1740, 262
1014, 258, 306, 307, 259, 1740, 311, 1741, 263
1015, 259, 307, 308, 260, 1741, 312, 1742, 264
1016, 260, 308, 19, 15, 1742, 313, 304, 265
*ELEMENT, type=CPS8, ELSET=Surface19
1017, 16, 275, 315, 20, 279, 1743, 319, 314
1018, 275, 276, 316, 315, 280, 1744, 320, 1743
1019, 276, 277, 317, 316, 281, 1745, 321, 1744
1020, 277, 278, 318, 317, 282, 1746, 322, 1745
1021, 278, 15, 19, 318, 283, 304, 323, 1746
*ELEMENT, type=CPS8, ELSET=Surface20
1022, 14, 284, 324, 18, 288, 1747, 328, 294
1023, 284, 285, 325, 324, 289, 1748, 329, 1747
1024, 285, 286, 326, 325, 290, 1749, 330, 1748
1025, 286, 287, 327, 326, 291, 1750, 331, 1749
1026, 287, 16, 20, 327, 292, 314, 332, 1750
*ELEMENT, type=CPS8, ELSET=Surface21
1027, 18, 324, 1751, 295, 328, 1767, 1768, 299
1028, 324, 325, 1752, 1751, 329, 1769, 1770, 1767
1029, 325, 326, 1753, 1752, 330, 1771, 1772, 1769
1030, 326, 327, 1754, 1753, 331, 1773, 1774, 1771
1031, 327, 20, 315, 1754, 332, 319, 1775, 1773
1032, 295, 1751, 1755, 296, 1768, 1776, 1777, 300
1033, 1751, 1752, 1756, 1755, 1770, 1778, 1779, 1776
1034, 1752, 1753, 1757, 1756, 1772, 1780, 1781, 1778
1035, 1753, 1754, 1758, 1757, 1774, 1782, 1783, 1780
1036, 1754, 315, 316, 1758, 1775, 320, 1784, 1782
1037, 296, 1755, 1759, 297, 1777, 1785, 1786, 301
1038, 1755, 1756, 1760, 1759, 1779, 1787, 1788, 1785
1039, 1756, 1757, 1761, 1760, 1781, 1789, 1790, 1787
1040, 1757, 1758, 1762, 1761, 1783, 1791, 1792, 1789
1041, 1758, 316, 317, 1762, 1784, 321, 1793, 1791
1042, 297, 1759, 1763, 298, 1786, 1794, 1795, 302
1043, 1759, 1760, 1764, 1763, 1788, 1796, 1797, 1794
1044, 1760, 1761, 1765, 1764, 1790, 1798, 1799, 1796
1045, 1761, 1762, 1766, 1765, 1792, 1800, 1801, 1798
1046, 1762, 317, 318, 1766, 1793, 322, 1802, 1800
1047, 298, 1763, 305, 17, 1795, 1803, 309, 303
1048, 1763, 1764, 306, 305, 1797, 1804, 310, 1803
1049, 1764, 1765, 307, 306, 1799, 1805, 311, 1804
1050, 1765, 1766, 308, 307, 1801, 1806, 312, 1805
1051, 1766, 318, 19, 308, 1802, 323, 313, 1806
*ELEMENT, type=CPS8, ELSET=Surface22
1052, 18, 336, 1807, 295, 337, 1811, 1812, 299
1053, 336, 22, 339, 1807, 338, 343, 1813, 1811
1054, 295, 1807, 1808, 296, 1812, 1814, 1815, 300
1055, 1807, 339, 340, 1808, 1813, 344, 1816, 1814
1056, 296, 1808, 1809, 297, 1815, 1817, 1818, 301
1057, 1808, 340, 341, 1809, 1816, 345, 1819, 1817
1058, 297, 1809, 1810, 298, 1818, 1820, 1821, 302
1059, 1809, 341, 342, 1810, 1819, 346, 1822, 1820
1060, 298, 1810, 333, 17, 1821, 1823, 334, 303
1061, 1810, 342, 21, 333, 1822, 347, 335, 1823
*ELEMENT, type=CPS8, ELSET=Surface23
1062, 17, 333, 1824, 305, 334, 1828, 1829, 309
1063, 333, 21, 351, 1824, 335, 355, 1830, 1828
1064, 305, 1824, 1825, 306, 1829, 1831, 1832, 310
1065, 1824, 351, 352, 1825, 1830, 356, 1833, 1831
1066, 306, 1825, 1826, 307, 1832, 1834, 1835, 311
1067, 1825, 352, 353, 1826, 1833, 357, 1836, 1834
1068, 307, 1826, 1827, 308, 1835, 1837, 1838, 312
1069, 1826, 353, 354, 1827, 1836, 358, 1839, 1837
1070, 308, 1827, 348, 19, 1838, 1840, 349, 313
1071, 1827, 354, 23, 348, 1839, 359, 350, 1840
*ELEMENT, type=CPS8, ELSET=Surface24
1072, 20, 315, 1841, 360, 319, 1845, 1846, 361
1073, 360, 1841, 363, 24, 1846, 1847, 367, 362
1074, 315, 316, 1842, 1841, 320, 1848, 1849, 1845
1075, 1841, 1842, 364, 363, 1849, 1850, 368, 1847
1076, 316, 317, 1843, 1842, 321, 1851, 1852, 1848
1077, 1842, 1843, 365, 364, 1852, 1853, 369, 1850
1078, 317, 318, 1844, 1843, 322, 1854, 1855, 1851
1079, 1843, 1844, 366, 365, 1855, 1856, 370, 1853
1080, 318, 19, 348, 1844, 323, 349, 1857, 1854
1081, 1844, 348, 23, 366, 1857, 350, 371, 1856
*ELEMENT, type=CPS8, ELSET=Surface25
1082, 18, 324, 1858, 336, 328, 1862, 1863, 337
1083, 336, 1858, 372, 22, 1863, 1864, 376, 338
1084, 324, 325, 1859, 1858, 329, 1865, 1866, 1862
1085, 1858, 1859, 373, 372, 1866, 1867, 377, 1864
1086, 325, 326, 1860, 1859, 330, 1868, 1869, 1865
1087, 1859, 1860, 374, 373, 1869, 1870, 378, 1867
1088, 326, 327, 1861, 1860, 331, 1871, 1872, 1868
1089, 1860, 1861, 375, 374, 1872, 1873, 379, 1870
1090, 327, 20, 360, 1861, 332, 361, 1874, 1871
1091, 1861, 360, 24, 375, 1874, 362, 380, 1873
*ELEMENT, type=CPS8, ELSET=Surface26
1092, 22, 372, 1875, 339, 376, 1891, 1892, 343
1093, 372, 373, 1876, 1875, 377, 1893, 1894, 1891
1094, 373, 374, 1877, 1876, 378, 1895, 1896, 1893
1095, 374, 375, 1878, 1877, 379, 1897, 1898, 1895
1096, 375, 24, 363, 1878, 380, 367, 1899, 1897
1097, 339, 1875, 1879, 340, 1892, 1900, 1901, 344
1098, 1875, 1876, 1880, 1879, 1894, 1902, 1903, 1900
1099, 1876, 1877, 1881, 1880, 1896, 1904, 1905, 1902
1100, 1877, 1878, 1882, 1881, 1898, 1906, 1907, 1904
1101, 1878, 363, 364, 1882, 1899, 368, 1908, 1906
1102, 340, 1879, 1883, 341, 1901, 1909, 1910, 345
1103, 1879, 1880, 1884, 1883, 1903, 1911, 1912, 1909
1104, 1880, 1881, 1885, 1884, 1905, 1913, 1914, 1911
1105, 1881, 1882, 1886, 1885, 1907, 1915, 1916, 1913
1106, 1882, 364, 365, 1886, 1908, 369, 1917, 1915
1107, 341, 1883, 1887, 342, 1910, 1918, 1919, 346
1108, 1883, 1884, 1888, 1887, 1912, 1920, 1921, 1918
1109, 1884, 1885, 1889, 1888, 1914, 1922, 1923, 1920
1110, 1885, 1886, 1890, 1889, 1916, 1924, 1925, 1922
1111, 1886, 365, 366, 1890, 1917, 370, 1926, 1924
1112, 342, 1887, 351, 21, 1919, 1927, 355, 347
1113, 1887, 1888, 352, 351, 1921, 1928, 356, 1927
1114, 1888, 1889, 353, 352, 1923, 1929, 357, 1928
1115, 1889, 1890, 354, 353, 1925, 1930, 358, 1929
1116, 1890, 366, 23, 354, 1926, 371, 359, 1930
*ELEMENT, type=CPS8, ELSET=Surface27
1117, 19, 381, 1931, 348, 383, 1933, 1934, 349
1118, 381, 382, 1932, 1931, 384, 1935, 1936, 1933
1119, 382, 25, 391, 1932, 385, 392, 1937, 1935
1120, 348, 1931, 386, 23, 1934, 1938, 388, 350
1121, 1931, 1932, 387, 386, 1936, 1939, 389, 1938
1122, 1932, 391, 26, 387, 1937, 393, 390, 1939
*ELEMENT, type=CPS8, ELSET=Surface28
1123, 17, 333, 1940, 394, 334, 1942, 1943, 396
1124, 394, 1940, 1941, 395, 1943, 1944, 1945, 397
1125, 395, 1941, 404, 27, 1945, 1946, 405, 398
1126, 333, 21, 399, 1940, 335, 401, 1947, 1942
1127, 1940, 399, 400, 1941, 1947, 402, 1948, 1944
1128, 1941, 400, 28, 404, 1948, 403, 406, 1946
*ELEMENT, type=CPS8, ELSET=Surface29
1129, 17, 394, 1949, 305, 396, 1957, 1958, 309
1130, 394, 395, 1950, 1949, 397, 1959, 1960, 1957
1131, 395, 27, 407, 1950, 398, 411, 1961, 1959
1132, 305, 1949, 1951, 306, 1958, 1962, 1963, 310
1133, 1949, 1950, 1952, 1951, 1960, 1964, 1965, 1962
1134, 1950, 407, 408, 1952, 1961, 412, 1966, 1964
1135, 306, 1951, 1953, 307, 1963, 1967, 1968, 311
1136, 1951, 1952, 1954, 1953, 1965, 1969, 1970, 1967
1137, 1952, 408, 409, 1954, 1966, 413, 1971, 1969
1138, 307, 1953, 1955, 308, 1968, 1972, 1973, 312
1139, 1953, 1954, 1956, 1955, 1970, 1974, 1975, 1972
1140, 1954, 409, 410, 1956, 1971, 414, 1976, 1974
1141, 308, 1955, 381, 19, 1973, 1977, 383, 313
1142, 1955, 1956, 382, 381, 1975, 1978, 384, 1977
1143, 1956, 410, 25, 382, 1976, 415, 385, 1978
*ELEMENT, type=CPS8, ELSET=Surface30
1144, 21, 351, 1979, 399, 355, 1987, 1988, 401
1145, 399, 1979, 1980, 400, 1988, 1989, 1990, 402
1146, 400, 1980, 416, 28, 1990, 1991, 420, 403
1147, 351, 352, 1981, 1979, 356, 1992, 1993, 1987
1148, 1979, 1981, 1982, 1980, 1993, 1994, 1995, 1989
1149, 1980, 1982, 417, 416, 1995, 1996, 421, 1991
1150, 352, 353, 1983, 1981, 357, 1997, 1998, 1992
1151, 1981, 1983, 1984, 1982, 1998, 1999, 2000, 1994
1152, 1982, 1984, 418, 417, 2000, 2001, 422, 1996
1153, 353, 354, 1985, 1983, 358, 2002, 2003, 1997
1154, 1983, 1985, 1986, 1984, 2003, 2004, 2005, 1999
1155, 1984, 1986, 419, 418, 2005, 2006, 423, 2001
1156, 354, 23, 386, 1985, 359, 388, 2007, 2002
1157, 1985, 386, 387, 1986, 2007, 389, 2008, 2004
1158, 1986, 387, 26, 419, 2008, 390, 424, 2006
*ELEMENT, type=CPS8, ELSET=Surface31
1159, 27, 404, 2009, 407, 405, 2013, 2014, 411
1160, 404, 28, 416, 2009, 406, 420, 2015, 2013
1161, 407, 2009, 2010, 408, 2014, 2016, 2017, 412
1162, 2009, 416, 417, 2010, 2015, 421, 2018, 2016
1163, 408, 2010, 2011, 409, 2017, 2019, 2020, 413
1164, 2010, 417, 418, 2011, 2018, 422, 2021, 2019
1165, 409, 2011, 2012, 410, 2020, 2022, 2023, 414
1166, 2011, 418, 419, 2012, 2021, 423, 2024, 2022
1167, 410, 2012, 391, 25, 2023, 2025, 392, 415
1168, 2012, 419, 26, 391, 2024, 424, 393, 2025
*ELEMENT, type=CPS8, ELSET=Surface32
1169, 25, 425, 2026, 391, 429, 2030, 2031, 392
1170, 425, 426, 2027, 2026, 430, 2032, 2033, 2030
1171, 426, 427, 2028, 2027, 431, 2034, 2035, 2032
1172, 427, 428, 2029, 2028, 432, 2036, 2037, 2034
1173, 428, 29, 443, 2029, 433, 444, 2038, 2036
1174, 391, 2026, 434, 26, 2031, 2039, 438, 393
1175, 2026, 2027, 435, 434, 2033, 2040, 439, 2039
1176, 2027, 2028, 436, 435, 2035, 2041, 440, 2040
1177, 2028, 2029, 437, 436, 2037, 2042, 441, 2041
1178, 2029, 443, 30, 437, 2038, 445, 442, 2042
*ELEMENT, type=CPS8, ELSET=Surface33
1179, 27, 404, 2043, 446, 405, 2047, 2048, 450
1180, 446, 2043, 2044, 447, 2048, 2049, 2050, 451
1181, 447, 2044, 2045, 448, 2050, 2051, 2052, 452
1182, 448, 2045, 2046, 449, 2052, 2053, 2054, 453
1183, 449, 2046, 464, 31, 2054, 2055, 465, 454
1184, 404, 28, 455, 2043, 406, 459, 2056, 2047
1185, 2043, 455, 456, 2044, 2056, 460, 2057, 2049
1186, 2044, 456, 457, 2045, 2057, 461, 2058, 2051
1187, 2045, 457, 458, 2046, 2058, 462, 2059, 2053
1188, 2046, 458, 32, 464, 2059, 463, 466, 2055
*ELEMENT, type=CPS8, ELSET=Surface34
1189, 27, 446, 2060, 407, 450, 2076, 2077, 411
1190, 446, 447, 2061, 2060, 451, 2078, 2079, 2076
1191, 447, 448, 2062, 2061, 452, 2080, 2081, 2078
1192, 448, 449, 2063, 2062, 453, 2082, 2083, 2080
1193, 449, 31, 467, 2063, 454, 471, 2084, 2082
1194, 407, 2060, 2064, 408, 2077, 2085, 2086, 412
1195, 2060, 2061, 2065, 2064, 2079, 2087, 2088, 2085
1196, 2061, 2062, 2066, 2065, 2081, 2089, 2090, 2087
1197, 2062, 2063, 2067, 2066, 2083, 2091, 2092, 2089
1198, 2063, 467, 468, 2067, 2084, 472, 2093, 2091
1199, 408, 2064, 2068, 409, 2086, 2094, 2095, 413
1200, 2064, 2065, 2069, 2068, 2088, 2096, 2097, 2094
1201, 2065, 2066, 2070, 2069, 2090, 2098, 2099, 2096
1202, 2066, 2067, 2071, 2070, 2092, 2100, 2101, 2098
1203, 2067, 468, 469, 2071, 2093, 473, 2102, 2100
1204, 409, 2068, 2072, 410, 2095, 2103, 2104, 414
1205, 2068, 2069, 2073, 2072, 2097, 2105, 2106, 2103
1206, 2069, 2070, 2074, 2073, 2099, 2107, 2108, 2105
1207, 2070, 2071, 2075, 2074, 2101, 2109, 2110, 2107
1208, 2071, 469, 470, 2075, 2102, 474, 2111, 2109
1209, 410, 2072, 425, 25, 2104, 2112, 429, 415
1210, 2072, 2073, 426, 425, 2106, 2113, 430, 2112
1211, 2073, 2074, 427, 426, 2108, 2114, 431, 2113
1212, 2074, 2075, 428, 427, 2110, 2115, 432, 2114
1213, 2075, 470, 29, 428, 2111, 475, 433, 2115
*ELEMENT, type=CPS8, ELSET=Surface35
1214, 28, 416, 2116, 455, 420, 2132, 2133, 459
1215, 455, 2116, 2117, 456, 2133, 2134, 2135, 460
1216, 456, 2117, 2118, 457, 2135, 2136, 2137, 461
1217, 457, 2118, 2119, 458, 2137, 2138, 2139, 462
1218, 458, 2119, 476, 32, 2139, 2140, 480, 463
1219, 416, 417, 2120, 2116, 421, 2141, 2142, 2132
1220, 2116, 2120, 2121, 2117, 2142, 2143, 2144, 2134
1221, 2117, 2121, 2122, 2118, 2144, 2145, 2146, 2136
1222, 2118, 2122, 2123, 2119, 2146, 2147, 2148, 2138
1223, 2119, 2123, 477, 476, 2148, 2149, 481, 2140
1224, 417, 418, 2124, 2120, 422, 2150, 2151, 2141
1225, 2120, 2124, 2125, 2121, 2151, 2152, 2153, 2143
1226, 2121, 2125, 2126, 2122, 2153, 2154, 2155, 2145
1227, 2122, 2126, 2127, 2123, 2155, 2156, 2157, 2147
1228, 2123, 2127, 478, 477, 2157, 2158, 482, 2149
1229, 418, 419, 2128, 2124, 423, 2159, 2160, 2150
1230, 2124, 2128, 2129, 2125, 2160, 2161, 2162, 2152
1231, 2125, 2129, 2130, 2126, 2162, 2163, 2164, 2154
1232, 2126, 2130, 2131, 2127, 2164, 2165, 2166, 2156
1233, 2127, 2131, 479, 478, 2166, 2167, 483, 2158
1234, 419, 26, 434, 2128, 424, 438, 2168, 2159
1235, 2128, 434, 435, 2129, 2168, 439, 2169, 2161
1236, 2129, 435, 436, 2130, 2169, 440, 2170, 2163
1237, 2130, 436, 437, 2131, 2170, 441, 2171, 2165
1238, 2131, 437, 30, 479, 2171, 442, 484, 2167
*ELEMENT, type=CPS8, ELSET=Surface36
1239, 31, 464, 2172, 467, 465, 2176, 2177, 471
1240, 464, 32, 476, 2172, 466, 480, 2178, 2176
1241, 467, 2172, 2173, 468, 2177, 2179, 2180, 472
1242, 2172, 476, 477, 2173, 2178, 481, 2181, 2179
1243, 468, 2173, 2174, 469, 2180, 2182, 2183, 473
1244, 2173, 477, 478, 2174, 2181, 482, 2184, 2182
1245, 469, 2174, 2175, 470, 2183, 2185, 2186, 474
1246, 2174, 478, 479, 2175, 2184, 483, 2187, 2185
1247, 470, 2175, 443, 29, 2186, 2188, 444, 475
1248, 2175, 479, 30, 443, 2187, 484, 445, 2188
*ELEMENT, type=CPS8, ELSET=Surface37
1249, 25, 33, 487, 425, 485, 491, 2189, 429
1250, 425, 487, 488, 426, 2189, 492, 2190, 430
1251, 426, 488, 489, 427, 2190, 493, 2191, 431
1252, 427, 489, 490, 428, 2191, 494, 2192, 432
1253, 428, 490, 34, 29, 2192, 495, 486, 433
*ELEMENT, type=CPS8, ELSET=Surface38
1254, 27, 446, 498, 35, 450, 2193, 502, 496
1255, 446, 447, 499, 498, 451, 2194, 503, 2193
1256, 447, 448, 500, 499, 452, 2195, 504, 2194
1257, 448, 449, 501, 500, 453, 2196, 505, 2195
1258, 449, 31, 36, 501, 454, 497, 506, 2196
*ELEMENT, type=CPS8, ELSET=Surface39
1259, 27, 35, 507, 407, 496, 511, 2197, 411
1260, 407, 507, 508, 408, 2197, 512, 2198, 412
1261, 408, 508, 509, 409, 2198, 513, 2199, 413
1262, 409, 509, 510, 410, 2199, 514, 2200, 414
1263, 410, 510, 33, 25, 2200, 515, 485, 415
*ELEMENT, type=CPS8, ELSET=Surface40
1264, 31, 467, 516, 36, 471, 2201, 520, 497
1265, 467, 468, 517, 516, 472, 2202, 521, 2201
1266, 468, 469, 518, 517, 473, 2203, 522, 2202
1267, 469, 470, 519, 518, 474, 2204, 523, 2203
1268, 470, 29, 34, 519, 475, 486, 524, 2204
*ELEMENT, type=CPS8, ELSET=Surface41
1269, 35, 498, 2205, 507, 502, 2221, 2222, 511
1270, 498, 499, 2206, 2205, 503, 2223, 2224, 2221
1271, 499, 500, 2207, 2206, 504, 2225, 2226, 2223
1272, 500, 501, 2208, 2207, 505, 2227, 2228, 2225
1273, 501, 36, 516, 2208, 506, 520, 2229, 2227
1274, 507, 2205, 2209, 508, 2222, 2230, 2231, 512
1275, 2205, 2206, 2210, 2209, 2224, 2232, 2233, 2230
1276, 2206, 2207, 2211, 2210, 2226, 2234, 2235, 2232
1277, 2207, 2208, 2212, 2211, 2228, 2236, 2237, 2234
1278, 2208, 516, 517, 2212, 2229, 521, 2238, 2236
1279, 508, 2209, 2213, 509, 2231, 2239, 2240, 513
1280, 2209, 2210, 2214, 2213, 2233, 2241, 2242, 2239
1281, 2210, 2211, 2215, 2214, 2235, 2243, 2244, 2241
1282, 2211, 2212, 2216, 2215, 2237, 2245, 2246, 2243
1283, 2212, 517, 518, 2216, 2238, 522, 2247, 2245
1284, 509, 2213, 2217, 510, 2240, 2248, 2249, 514
1285, 2213, 2214, 2218, 2217, 2242, 2250, 2251, 2248
1286, 2214, 2215, 2219, 2218, 2244, 2252, 2253, 2250
1287, 2215, 2216, 2220, 2219, 2246, 2254, 2255, 2252
1288, 2216, 518, 519, 2220, 2247, 523, 2256, 2254
1289, 510, 2217, 487, 33, 2249, 2257, 491, 515
1290, 2217, 2218, 488, 487, 2251, 2258, 492, 2257
1291, 2218, 2219, 489, 488, 2253, 2259, 493, 2258
1292, 2219, 2220, 490, 489, 2255, 2260, 494, 2259
1293, 2220, 519, 34, 490, 2256, 524, 495, 2260
*ELEMENT, type=CPS8, ELSET=Surface42
1294, 33, 525, 2261, 487, 529, 2277, 2278, 491
1295, 525, 526, 2262, 2261, 530, 2279, 2280, 2277
1296, 526, 527, 2263, 2262, 531, 2281, 2282, 2279
1297, 527, 528, 2264, 2263, 532, 2283, 2284, 2281
1298, 528, 37, 543, 2264, 533, 547, 2285, 2283
1299, 487, 2261, 2265, 488, 2278, 2286, 2287, 492
1300, 2261, 2262, 2266, 2265, 2280, 2288, 2289, 2286
1301, 2262, 2263, 2267, 2266, 2282, 2290, 2291, 2288
1302, 2263, 2264, 2268, 2267, 2284, 2292, 2293, 2290
1303, 2264, 543, 544, 2268, 2285, 548, 2294, 2292
1304, 488, 2265, 2269, 489, 2287, 2295, 2296, 493
1305, 2265, 2266, 2270, 2269, 2289, 2297, 2298, 2295
1306, 2266, 2267, 2271, 2270, 2291, 2299, 2300, 2297
1307, 2267, 2268, 2272, 2271, 2293, 2301, 2302, 2299
1308, 2268, 544, 545, 2272, 2294, 549, 2303, 2301
1309, 489, 2269, 2273, 490, 2296, 2304, 2305, 494
1310, 2269, 2270, 2274, 2273, 2298, 2306, 2307, 2304
1311, 2270, 2271, 2275, 2274, 2300, 2308, 2309, 2306
1312, 2271, 2272, 2276, 2275, 2302, 2310, 2311, 2308
1313, 2272, 545, 546, 2276, 2303, 550, 2312, 2310
1314, 490, 2273, 534, 34, 2305, 2313, 538, 495
1315, 2273, 2274, 535, 534, 2307, 2314, 539, 2313
1316, 2274, 2275, 536, 535, 2309, 2315, 540, 2314
1317, 2275, 2276, 537, 536, 2311, 2316, 541, 2315
1318, 2276, 546, 38, 537, 2312, 551, 542, 2316
*ELEMENT, type=CPS8, ELSET=Surface43
1319, 35, 498, 2317, 552, 502, 2333, 2334, 556
1320, 552, 2317, 2318, 553, 2334, 2335, 2336, 557
1321, 553, 2318, 2319, 554, 2336, 2337, 2338, 558
1322, 554, 2319, 2320, 555, 2338, 2339, 2340, 559
1323, 555, 2320, 570, 39, 2340, 2341, 574, 560
1324, 498, 499, 2321, 2317, 503, 2342, 2343, 2333
1325, 2317, 2321, 2322, 2318, 2343, 2344, 2345, 2335
1326, 2318, 2322, 2323, 2319, 2345, 2346, 2347, 2337
1327, 2319, 2323, 2324, 2320, 2347, 2348, 2349, 2339
1328, 2320, 2324, 571, 570, 2349, 2350, 575, 2341
1329, 499, 500, 2325, 2321, 504, 2351, 2352, 2342
1330, 2321, 2325, 2326, 2322, 2352, 2353, 2354, 2344
1331, 2322, 2326, 2327, 2323, 2354, 2355, 2356, 2346
1332, 2323, 2327, 2328, 2324, 2356, 2357, 2358, 2348
1333, 2324, 2328, 572, 571, 2358, 2359, 576, 2350
1334, 500, 501, 2329, 2325, 505, 2360, 2361, 2351
1335, 2325, 2329, 2330, 2326, 2361, 2362, 2363, 2353
1336, 2326, 2330, 2331, 2327, 2363, 2364, 2365, 2355
1337, 2327, 2331, 2332, 2328, 2365, 2366, 2367, 2357
1338, 2328, 2332, 573, 572, 2367, 2368, 577, 2359
1339, 501, 36, 561, 2329, 506, 565, 2369, 2360
1340, 2329, 561, 562, 2330, 2369, 566, 2370, 2362
1341, 2330, 562, 563, 2331, 2370, 567, 2371, 2364
1342, 2331, 563, 564, 2332, 2371, 568, 2372, 2366
1343, 2332, 564, 40, 573, 2372, 569, 578, 2368
*ELEMENT, type=CPS8, ELSET=Surface44
1344, 35, 552, 2373, 507, 556, 2389, 2390, 511
1345, 552, 553, 2374, 2373, 557, 2391, 2392, 2389
1346, 553, 554, 2375, 2374, 558, 2393, 2394, 2391
1347, 554, 555, 2376, 2375, 559, 2395, 2396, 2393
1348, 555, 39, 579, 2376, 560, 583, 2397, 2395
1349, 507, 2373, 2377, 508, 2390, 2398, 2399, 512
1350, 2373, 2374, 2378, 2377, 2392, 2400, 2401, 2398
1351, 2374, 2375, 2379, 2378, 2394, 2402, 2403, 2400
1352, 2375, 2376, 2380, 2379, 2396, 2404, 2405, 2402
1353, 2376, 579, 580, 2380, 2397, 584, 2406, 2404
1354, 508, 2377, 2381, 509, 2399, 2407, 2408, 513
1355, 2377, 2378, 2382, 2381, 2401, 2409, 2410, 2407
1356, 2378, 2379, 2383, 2382, 2403, 2411, 2412, 2409
1357, 2379, 2380, 2384, 2383, 2405, 2413, 2414, 2411
1358, 2380, 580, 581, 2384, 2406, 585, 2415, 2413
1359, 509, 2381, 2385, 510, 2408, 2416, 2417, 514
1360, 2381, 2382, 2386, 2385, 2410, 2418, 2419, 2416
1361, 2382, 2383, 2387, 2386, 2412, 2420, 2421, 2418
1362, 2383, 2384, 2388, 2387, 2414, 2422, 2423, 2420
1363, 2384, 581, 582, 2388, 2415, 586, 2424, 2422
1364, 510, 2385, 525, 33, 2417, 2425, 529, 515
1365, 2385, 2386, 526, 525, 2419, 2426, 530, 2425
1366, 2386, 2387, 527, 526, 2421, 2427, 531, 2426
1367, 2387, 2388, 528, 527, 2423, 2428, 532, 2427
1368, 2388, 582, 37, 528, 2424, 587, 533, 2428
*ELEMENT, type=CPS8, ELSET=Surface45
1369, 36, 516, 2429, 561, 520, 2445, 2446, 565
1370, 561, 2429, 2430, 562, 2446, 2447, 2448, 566
1371, 562, 2430, 2431, 563, 2448, 2449, 2450, 567
1372, 563, 2431, 2432, 564, 2450, 2451, 2452, 568
1373, 564, 2432, 588, 40, 2452, 2453, 592, 569
1374, 516, 517, 2433, 2429, 521, 2454, 2455, 2445
1375, 2429, 2433, 2434, 2430, 2455, 2456, 2457, 2447
1376, 2430, 2434, 2435, 2431, 2457, 2458, 2459, 2449
1377, 2431, 2435, 2436, 2432, 2459, 2460, 2461, 2451
1378, 2432, 2436, 589, 588, 2461, 2462, 593, 2453
1379, 517, 518, 2437, 2433, 522, 2463, 2464, 2454
1380, 2433, 2437, 2438, 2434, 2464, 2465, 2466, 2456
1381, 2434, 2438, 2439, 2435, 2466, 2467, 2468, 2458
1382, 2435, 2439, 2440, 2436, 2468, 2469, 2470, 2460
1383, 2436, 2440, 590, 589, 2470, 2471, 594, 2462
1384, 518, 519, 2441, 2437, 523, 2472, 2473, 2463
1385, 2437, 2441, 2442, 2438, 2473, 2474, 2475, 2465
1386, 2438, 2442, 2443, 2439, 2475, 2476, 2477, 2467
1387, 2439, 2443, 2444, 2440, 2477, 2478, 2479, 2469
1388, 2440, 2444, 591, 590, 2479, 2480, 595, 2471
1389, 519, 34, 534, 2441, 524, 538, 2481, 2472
1390, 2441, 534, 535, 2442, 2481, 539, 2482, 2474
1391, 2442, 535, 536, 2443, 2482, 540, 2483, 2476
1392, 2443, 536, 537, 2444, 2483, 541, 2484, 2478
1393, 2444, 537, 38, 591, 2484, 542, 596, 2480
*ELEMENT, type=CPS8, ELSET=Surface46
1394, 39, 570, 2485, 579, 574, 2501, 2502, 583
1395, 570, 571, 2486, 2485, 575, 2503, 2504, 2501
1396, 571, 572, 2487, 2486, 576, 2505, 2506, 2503
1397, 572, 573, 2488, 2487, 577, 2507, 2508, 2505
1398, 573, 40, 588, 2488, 578, 592, 2509, 2507
1399, 579, 2485, 2489, 580, 2502, 2510, 2511, 584
1400, 2485, 2486, 2490, 2489, 2504, 2512, 2513, 2510
1401, 2486, 2487, 2491, 2490, 2506, 2514, 2515, 2512
1402, 2487, 2488, 2492, 2491, 2508, 2516, 2517, 2514
1403, 2488, 588, 589, 2492, 2509, 593, 2518, 2516
1404, 580, 2489, 2493, 581, 2511, 2519, 2520, 585
1405, 2489, 2490, 2494, 2493, 2513, 2521, 2522, 2519
1406, 2490, 2491, 2495, 2494, 2515, 2523, 2524, 2521
1407, 2491, 2492, 2496, 2495, 2517, 2525, 2526, 2523
1408, 2492, 589, 590, 2496, 2518, 594, 2527, 2525
1409, 581, 2493, 2497, 582, 2520, 2528, 2529, 586
1410, 2493, 2494, 2498, 2497, 2522, 2530, 2531, 2528
1411, 2494, 2495, 2499, 2498, 2524, 2532, 2533, 2530
1412, 2495, 2496, 2500, 2499, 2526, 2534, 2535, 2532
1413, 2496, 590, 591, 2500, 2527, 595, 2536, 2534
1414, 582, 2497, 543, 37, 2529, 2537, 547, 587
1415, 2497, 2498, 544, 543, 2531, 2538, 548, 2537
1416, 2498, 2499, 545, 544, 2533, 2539, 549, 2538
1417, 2499, 2500, 546, 545, 2535, 2540, 550, 2539
1418, 2500, 591, 38, 546, 2536, 596, 551, 2540
*ELEMENT, type=CPS8, ELSET=Surface47
1419, 37, 41, 599, 543, 597, 603, 2541, 547
1420, 543, 599, 600, 544, 2541, 604, 2542, 548
1421, 544, 600, 601, 545, 2542, 605, 2543, 549
1422, 545, 601, 602, 546, 2543, 606, 2544, 550
1423, 546, 602, 42, 38, 2544, 607, 598, 551
*ELEMENT, type=CPS8, ELSET=Surface48
1424, 39, 570, 610, 43, 574, 2545, 614, 608
1425, 570, 571, 611, 610, 575, 2546, 615, 2545
1426, 571, 572, 612, 611, 576, 2547, 616, 2546
1427, 572, 573, 613, 612, 577, 2548, 617, 2547
1428, 573, 40, 44, 613, 578, 609, 618, 2548
*ELEMENT, type=CPS8, ELSET=Surface49
1429, 39, 43, 619, 579, 608, 623, 2549, 583
1430, 579, 619, 620, 580, 2549, 624, 2550, 584
1431, 580, 620, 621, 581, 2550, 625, 2551, 585
1432, 581, 621, 622, 582, 2551, 626, 2552, 586
1433, 582, 622, 41, 37, 2552, 627, 597, 587
*ELEMENT, type=CPS8, ELSET=Surface50
1434, 40, 588, 628, 44, 592, 2553, 632, 609
1435, 588, 589, 629, 628, 593, 2554, 633, 2553
1436, 589, 590, 630, 629, 594, 2555, 634, 2554
1437, 590, 591, 631, 630, 595, 2556, 635, 2555
1438, 591, 38, 42, 631, 596, 598, 636, 2556
*ELEMENT, type=CPS8, ELSET=Surface51
1439, 43, 610, 2557, 619, 614, 2573, 2574, 623
1440, 610, 611, 2558, 2557, 615, 2575, 2576, 2573
1441, 611, 612, 2559, 2558, 616, 2577, 2578, 2575
1442, 612, 613, 2560, 2559, 617, 2579, 2580, 2577
1443, 613, 44, 628, 2560, 618, 632, 2581, 2579
1444, 619, 2557, 2561, 620, 2574, 2582, 2583, 624
1445, 2557, 2558, 2562, 2561, 2576, 2584, 2585, 2582
1446, 2558, 2559, 2563, 2562, 2578, 2586, 2587, 2584
1447, 2559, 2560, 2564, 2563, 2580, 2588, 2589, 2586
1448, 2560, 628, 629, 2564, 2581, 633, 2590, 2588
1449, 620, 2561, 2565, 621, 2583, 2591, 2592, 625
1450, 2561, 2562, 2566, 2565, 2585, 2593, 2594, 2591
1451, 2562, 2563, 2567, 2566, 2587, 2595, 2596, 2593
1452, 2563, 2564, 2568, 2567, 2589, 2597, 2598, 2595
1453, 2564, 629, 630, 2568, 2590, 634, 2599, 2597
1454, 621, 2565, 2569, 622, 2592, 2600, 2601, 626
1455, 2565, 2566, 2570, 2569, 2594, 2602, 2603, 2600
1456, 2566, 2567, 2571, 2570, 2596, 2604, 2605, 2602
1457, 2567, 2568, 2572, 2571, 2598, 2606, 2607, 2604
1458, 2568, 630, 631, 2572, 2599, 635, 2608, 2606
1459, 622, 2569, 599, 41, 2601, 2609, 603, 627
1460, 2569, 2570, 600, 599, 2603, 2610, 604, 2609
1461, 2570, 2571, 601, 600, 2605, 2611, 605, 2610
1462, 2571, 2572, 602, 601, 2607, 2612, 606, 2611
1463, 2572, 631, 42, 602, 2608, 636, 607, 2612
*ELEMENT, type=CPS8, ELSET=Surface52
1464, 41, 637, 2613, 599, 638, 2617, 2618, 603
1465, 637, 45, 643, 2613, 639, 647, 2619, 2617
1466, 599, 2613, 2614, 600, 2618, 2620, 2621, 604
1467, 2613, 643, 644, 2614, 2619, 648, 2622, 2620
1468, 600, 2614, 2615, 601, 2621, 2623, 2624, 605
1469, 2614, 644, 645, 2615, 2622, 649, 2625, 2623
1470, 601, 2615, 2616, 602, 2624, 2626, 2627, 606
1471, 2615, 645, 646, 2616, 2625, 650, 2628, 2626
1472, 602, 2616, 640, 42, 2627, 2629, 641, 607
1473, 2616, 646, 46, 640, 2628, 651, 642, 2629
*ELEMENT, type=CPS8, ELSET=Surface53
1474, 43, 610, 2630, 652, 614, 2634, 2635, 653
1475, 652, 2630, 658, 47, 2635, 2636, 662, 654
1476, 610, 611, 2631, 2630, 615, 2637, 2638, 2634
1477, 2630, 2631, 659, 658, 2638, 2639, 663, 2636
1478, 611, 612, 2632, 2631, 616, 2640, 2641, 2637
1479, 2631, 2632, 660, 659, 2641, 2642, 664, 2639
1480, 612, 613, 2633, 2632, 617, 2643, 2644, 2640
1481, 2632, 2633, 661, 660, 2644, 2645, 665, 2642
1482, 613, 44, 655, 2633, 618, 656, 2646, 2643
1483, 2633, 655, 48, 661, 2646, 657, 666, 2645
*ELEMENT, type=CPS8, ELSET=Surface54
1484, 43, 652, 2647, 619, 653, 2651, 2652, 623
1485, 652, 47, 667, 2647, 654, 671, 2653, 2651
1486, 619, 2647, 2648, 620, 2652, 2654, 2655, 624
1487, 2647, 667, 668, 2648, 2653, 672, 2656, 2654
1488, 620, 2648, 2649, 621, 2655, 2657, 2658, 625
1489, 2648, 668, 669, 2649, 2656, 673, 2659, 2657
1490, 621, 2649, 2650, 622, 2658, 2660, 2661, 626
1491, 2649, 669, 670, 2650, 2659, 674, 2662, 2660
1492, 622, 2650, 637, 41, 2661, 2663, 638, 627
1493, 2650, 670, 45, 637, 2662, 675, 639, 2663
*ELEMENT, type=CPS8, ELSET=Surface55
1494, 44, 628, 2664, 655, 632, 2668, 2669, 656
1495, 655, 2664, 676, 48, 2669, 2670, 680, 657
1496, 628, 629, 2665, 2664, 633, 2671, 2672, 2668
1497, 2664, 2665, 677, 676, 2672, 2673, 681, 2670
1498, 629, 630, 2666, 2665, 634, 2674, 2675, 2671
1499, 2665, 2666, 678, 677, 2675, 2676, 682, 2673
1500, 630, 631, 2667, 2666, 635, 2677, 2678, 2674
1501, 2666, 2667, 679, 678, 2678, 2679, 683, 2676
1502, 631, 42, 640, 2667, 636, 641, 2680, 2677
1503, 2667, 640, 46, 679, 2680, 642, 684, 2679
*ELEMENT, type=CPS8, ELSET=Surface56
1504, 47, 658, 2681, 667, 662, 2697, 2698, 671
1505, 658, 659, 2682, 2681, 663, 2699, 2700, 2697
1506, 659, 660, 2683, 2682, 664, 2701, 2702, 2699
1507, 660, 661, 2684, 2683, 665, 2703, 2704, 2701
1508, 661, 48, 676, 2684, 666, 680, 2705, 2703
1509, 667, 2681, 2685, 668, 2698, 2706, 2707, 672
1510, 2681, 2682, 2686, 2685, 2700, 2708, 2709, 2706
1511, 2682, 2683, 2687, 2686, 2702, 2710, 2711, 2708
1512, 2683, 2684, 2688, 2687, 2704, 2712, 2713, 2710
1513, 2684, 676, 677, 2688, 2705, 681, 2714, 2712
1514, 668, 2685, 2689, 669, 2707, 2715, 2716, 673
1515, 2685, 2686, 2690, 2689, 2709, 2717, 2718, 2715
1516, 2686, 2687, 2691, 2690, 2711, 2719, 2720, 2717
1517, 2687, 2688, 2692, 2691, 2713, 2721, 2722, 2719
1518, 2688, 677, 678, 2692, 2714, 682, 2723, 2721
1519, 669, 2689, 2693, 670, 2716, 2724, 2725, 674
1520, 2689, 2690, 2694, 2693, 2718, 2726, 2727, 2724
1521, 2690, 2691, 2695, 2694, 2720, 2728, 2729, 2726
1522, 2691, 2692, 2696, 2695, 2722, 2730, 2731, 2728
1523, 2692, 678, 679, 2696, 2723, 683, 2732, 2730
1524, 670, 2693, 643, 45, 2725, 2733, 647, 675
1525, 2693, 2694, 644, 643, 2727, 2734, 648, 2733
1526, 2694, 2695, 645, 644, 2729, 2735, 649, 2734
1527, 2695, 2696, 646, 645, 2731, 2736, 650, 2735
1528, 2696, 679, 46, 646, 2732, 684, 651, 2736
*ELEMENT, type=CPS8, ELSET=Surface57
1529, 42, 640, 687, 49, 641, 2737, 688, 685
1530, 640, 46, 50, 687, 642, 686, 689, 2737
*ELEMENT, type=CPS8, ELSET=Surface58
1531, 44, 51, 692, 655, 690, 693, 2738, 656
1532, 655, 692, 52, 48, 2738, 694, 691, 657
*ELEMENT, type=CPS8, ELSET=Surface59
1533, 44, 628, 695, 51, 632, 2739, 699, 690
1534, 628, 629, 696, 695, 633, 2740, 700, 2739
1535, 629, 630, 697, 696, 634, 2741, 701, 2740
1536, 630, 631, 698, 697, 635, 2742, 702, 2741
1537, 631, 42, 49, 698, 636, 685, 703, 2742
*ELEMENT, type=CPS8, ELSET=Surface60
1538, 48, 52, 704, 676, 691, 708, 2743, 680
1539, 676, 704, 705, 677, 2743, 709, 2744, 681
1540, 677, 705, 706, 678, 2744, 710, 2745, 682
1541, 678, 706, 707, 679, 2745, 711, 2746, 683
1542, 679, 707, 50, 46, 2746, 712, 686, 684
*ELEMENT, type=CPS8, ELSET=Surface61
1543, 51, 695, 2747, 692, 699, 2751, 2752, 693
1544, 692, 2747, 704, 52, 2752, 2753, 708, 694
1545, 695, 696, 2748, 2747, 700, 2754, 2755, 2751
1546, 2747, 2748, 705, 704, 2755, 2756, 709, 2753
1547, 696, 697, 2749, 2748, 701, 2757, 2758, 2754
1548, 2748, 2749, 706, 705, 2758, 2759, 710, 2756
1549, 697, 698, 2750, 2749, 702, 2760, 2761, 2757
1550, 2749, 2750, 707, 706, 2761, 2762, 711, 2759
1551, 698, 49, 687, 2750, 703, 688, 2763, 2760
