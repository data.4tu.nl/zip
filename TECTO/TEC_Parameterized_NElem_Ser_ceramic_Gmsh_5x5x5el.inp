1552, 2750, 687, 50, 707, 2763, 689, 712, 2762
*ELEMENT, type=CPS8, ELSET=Surface62
1553, 2, 97, 715, 54, 101, 2764, 719, 714
1554, 97, 98, 716, 715, 102, 2765, 720, 2764
1555, 98, 99, 717, 716, 103, 2766, 721, 2765
1556, 99, 100, 718, 717, 104, 2767, 722, 2766
1557, 100, 1, 53, 718, 105, 713, 723, 2767
*ELEMENT, type=CPS8, ELSET=Surface63
1558, 1, 106, 725, 53, 107, 2768, 726, 713
1559, 106, 3, 55, 725, 108, 724, 727, 2768
*ELEMENT, type=CPS8, ELSET=Surface64
1560, 4, 56, 729, 109, 728, 733, 2769, 113
1561, 109, 729, 730, 110, 2769, 734, 2770, 114
1562, 110, 730, 731, 111, 2770, 735, 2771, 115
1563, 111, 731, 732, 112, 2771, 736, 2772, 116
1564, 112, 732, 55, 3, 2772, 737, 724, 117
*ELEMENT, type=CPS8, ELSET=Surface65
1565, 2, 54, 738, 118, 714, 739, 2773, 119
1566, 118, 738, 56, 4, 2773, 740, 728, 120
*ELEMENT, type=CPS8, ELSET=Surface66
1567, 54, 715, 2774, 738, 719, 2778, 2779, 739
1568, 738, 2774, 729, 56, 2779, 2780, 733, 740
1569, 715, 716, 2775, 2774, 720, 2781, 2782, 2778
1570, 2774, 2775, 730, 729, 2782, 2783, 734, 2780
1571, 716, 717, 2776, 2775, 721, 2784, 2785, 2781
1572, 2775, 2776, 731, 730, 2785, 2786, 735, 2783
1573, 717, 718, 2777, 2776, 722, 2787, 2788, 2784
1574, 2776, 2777, 732, 731, 2788, 2789, 736, 2786
1575, 718, 53, 725, 2777, 723, 726, 2790, 2787
1576, 2777, 725, 55, 732, 2790, 727, 737, 2789
*ELEMENT, type=CPS8, ELSET=Surface77
1577, 11, 57, 743, 248, 741, 747, 2791, 252
1578, 248, 743, 744, 249, 2791, 748, 2792, 253
1579, 249, 744, 745, 250, 2792, 749, 2793, 254
1580, 250, 745, 746, 251, 2793, 750, 2794, 255
1581, 251, 746, 58, 15, 2794, 751, 742, 256
*ELEMENT, type=CPS8, ELSET=Surface78
1582, 9, 221, 754, 59, 225, 2795, 758, 752
1583, 221, 222, 755, 754, 226, 2796, 759, 2795
1584, 222, 223, 756, 755, 227, 2797, 760, 2796
1585, 223, 224, 757, 756, 228, 2798, 761, 2797
1586, 224, 13, 60, 757, 229, 753, 762, 2798
*ELEMENT, type=CPS8, ELSET=Surface79
1587, 9, 59, 763, 193, 752, 767, 2799, 197
1588, 193, 763, 764, 194, 2799, 768, 2800, 198
1589, 194, 764, 765, 195, 2800, 769, 2801, 199
1590, 195, 765, 766, 196, 2801, 770, 2802, 200
1591, 196, 766, 57, 11, 2802, 771, 741, 201
*ELEMENT, type=CPS8, ELSET=Surface80
1592, 13, 257, 772, 60, 261, 2803, 776, 753
1593, 257, 258, 773, 772, 262, 2804, 777, 2803
1594, 258, 259, 774, 773, 263, 2805, 778, 2804
1595, 259, 260, 775, 774, 264, 2806, 779, 2805
1596, 260, 15, 58, 775, 265, 742, 780, 2806
*ELEMENT, type=CPS8, ELSET=Surface81
1597, 59, 754, 2807, 763, 758, 2823, 2824, 767
1598, 754, 755, 2808, 2807, 759, 2825, 2826, 2823
1599, 755, 756, 2809, 2808, 760, 2827, 2828, 2825
1600, 756, 757, 2810, 2809, 761, 2829, 2830, 2827
1601, 757, 60, 772, 2810, 762, 776, 2831, 2829
1602, 763, 2807, 2811, 764, 2824, 2832, 2833, 768
1603, 2807, 2808, 2812, 2811, 2826, 2834, 2835, 2832
1604, 2808, 2809, 2813, 2812, 2828, 2836, 2837, 2834
1605, 2809, 2810, 2814, 2813, 2830, 2838, 2839, 2836
1606, 2810, 772, 773, 2814, 2831, 777, 2840, 2838
1607, 764, 2811, 2815, 765, 2833, 2841, 2842, 769
1608, 2811, 2812, 2816, 2815, 2835, 2843, 2844, 2841
1609, 2812, 2813, 2817, 2816, 2837, 2845, 2846, 2843
1610, 2813, 2814, 2818, 2817, 2839, 2847, 2848, 2845
1611, 2814, 773, 774, 2818, 2840, 778, 2849, 2847
1612, 765, 2815, 2819, 766, 2842, 2850, 2851, 770
1613, 2815, 2816, 2820, 2819, 2844, 2852, 2853, 2850
1614, 2816, 2817, 2821, 2820, 2846, 2854, 2855, 2852
1615, 2817, 2818, 2822, 2821, 2848, 2856, 2857, 2854
1616, 2818, 774, 775, 2822, 2849, 779, 2858, 2856
1617, 766, 2819, 743, 57, 2851, 2859, 747, 771
1618, 2819, 2820, 744, 743, 2853, 2860, 748, 2859
1619, 2820, 2821, 745, 744, 2855, 2861, 749, 2860
1620, 2821, 2822, 746, 745, 2857, 2862, 750, 2861
1621, 2822, 775, 58, 746, 2858, 780, 751, 2862
*ELEMENT, type=CPS8, ELSET=Surface82
1622, 33, 61, 783, 525, 781, 787, 2863, 529
1623, 525, 783, 784, 526, 2863, 788, 2864, 530
1624, 526, 784, 785, 527, 2864, 789, 2865, 531
1625, 527, 785, 786, 528, 2865, 790, 2866, 532
1626, 528, 786, 62, 37, 2866, 791, 782, 533
*ELEMENT, type=CPS8, ELSET=Surface83
1627, 35, 552, 794, 63, 556, 2867, 798, 792
1628, 552, 553, 795, 794, 557, 2868, 799, 2867
1629, 553, 554, 796, 795, 558, 2869, 800, 2868
1630, 554, 555, 797, 796, 559, 2870, 801, 2869
1631, 555, 39, 64, 797, 560, 793, 802, 2870
*ELEMENT, type=CPS8, ELSET=Surface84
1632, 35, 63, 803, 507, 792, 807, 2871, 511
1633, 507, 803, 804, 508, 2871, 808, 2872, 512
1634, 508, 804, 805, 509, 2872, 809, 2873, 513
1635, 509, 805, 806, 510, 2873, 810, 2874, 514
1636, 510, 806, 61, 33, 2874, 811, 781, 515
*ELEMENT, type=CPS8, ELSET=Surface85
1637, 39, 579, 812, 64, 583, 2875, 816, 793
1638, 579, 580, 813, 812, 584, 2876, 817, 2875
1639, 580, 581, 814, 813, 585, 2877, 818, 2876
1640, 581, 582, 815, 814, 586, 2878, 819, 2877
1641, 582, 37, 62, 815, 587, 782, 820, 2878
*ELEMENT, type=CPS8, ELSET=Surface86
1642, 63, 794, 2879, 803, 798, 2895, 2896, 807
1643, 794, 795, 2880, 2879, 799, 2897, 2898, 2895
1644, 795, 796, 2881, 2880, 800, 2899, 2900, 2897
1645, 796, 797, 2882, 2881, 801, 2901, 2902, 2899
1646, 797, 64, 812, 2882, 802, 816, 2903, 2901
1647, 803, 2879, 2883, 804, 2896, 2904, 2905, 808
1648, 2879, 2880, 2884, 2883, 2898, 2906, 2907, 2904
1649, 2880, 2881, 2885, 2884, 2900, 2908, 2909, 2906
1650, 2881, 2882, 2886, 2885, 2902, 2910, 2911, 2908
1651, 2882, 812, 813, 2886, 2903, 817, 2912, 2910
1652, 804, 2883, 2887, 805, 2905, 2913, 2914, 809
1653, 2883, 2884, 2888, 2887, 2907, 2915, 2916, 2913
1654, 2884, 2885, 2889, 2888, 2909, 2917, 2918, 2915
1655, 2885, 2886, 2890, 2889, 2911, 2919, 2920, 2917
1656, 2886, 813, 814, 2890, 2912, 818, 2921, 2919
1657, 805, 2887, 2891, 806, 2914, 2922, 2923, 810
1658, 2887, 2888, 2892, 2891, 2916, 2924, 2925, 2922
1659, 2888, 2889, 2893, 2892, 2918, 2926, 2927, 2924
1660, 2889, 2890, 2894, 2893, 2920, 2928, 2929, 2926
1661, 2890, 814, 815, 2894, 2921, 819, 2930, 2928
1662, 806, 2891, 783, 61, 2923, 2931, 787, 811
1663, 2891, 2892, 784, 783, 2925, 2932, 788, 2931
1664, 2892, 2893, 785, 784, 2927, 2933, 789, 2932
1665, 2893, 2894, 786, 785, 2929, 2934, 790, 2933
1666, 2894, 815, 62, 786, 2930, 820, 791, 2934
*ELEMENT, type=CPS8, ELSET=Surface87
1667, 9, 65, 823, 221, 821, 827, 2935, 225
1668, 221, 823, 824, 222, 2935, 828, 2936, 226
1669, 222, 824, 825, 223, 2936, 829, 2937, 227
1670, 223, 825, 826, 224, 2937, 830, 2938, 228
1671, 224, 826, 66, 13, 2938, 831, 822, 229
*ELEMENT, type=CPS8, ELSET=Surface88
1672, 10, 230, 834, 67, 234, 2939, 838, 832
1673, 230, 231, 835, 834, 235, 2940, 839, 2939
1674, 231, 232, 836, 835, 236, 2941, 840, 2940
1675, 232, 233, 837, 836, 237, 2942, 841, 2941
1676, 233, 14, 68, 837, 238, 833, 842, 2942
*ELEMENT, type=CPS8, ELSET=Surface89
1677, 10, 67, 843, 183, 832, 847, 2943, 187
1678, 183, 843, 844, 184, 2943, 848, 2944, 188
1679, 184, 844, 845, 185, 2944, 849, 2945, 189
1680, 185, 845, 846, 186, 2945, 850, 2946, 190
1681, 186, 846, 65, 9, 2946, 851, 821, 191
*ELEMENT, type=CPS8, ELSET=Surface90
1682, 14, 239, 852, 68, 243, 2947, 856, 833
1683, 239, 240, 853, 852, 244, 2948, 857, 2947
1684, 240, 241, 854, 853, 245, 2949, 858, 2948
1685, 241, 242, 855, 854, 246, 2950, 859, 2949
1686, 242, 13, 66, 855, 247, 822, 860, 2950
*ELEMENT, type=CPS8, ELSET=Surface91
1687, 67, 834, 2951, 843, 838, 2967, 2968, 847
1688, 834, 835, 2952, 2951, 839, 2969, 2970, 2967
1689, 835, 836, 2953, 2952, 840, 2971, 2972, 2969
1690, 836, 837, 2954, 2953, 841, 2973, 2974, 2971
1691, 837, 68, 852, 2954, 842, 856, 2975, 2973
1692, 843, 2951, 2955, 844, 2968, 2976, 2977, 848
1693, 2951, 2952, 2956, 2955, 2970, 2978, 2979, 2976
1694, 2952, 2953, 2957, 2956, 2972, 2980, 2981, 2978
1695, 2953, 2954, 2958, 2957, 2974, 2982, 2983, 2980
1696, 2954, 852, 853, 2958, 2975, 857, 2984, 2982
1697, 844, 2955, 2959, 845, 2977, 2985, 2986, 849
1698, 2955, 2956, 2960, 2959, 2979, 2987, 2988, 2985
1699, 2956, 2957, 2961, 2960, 2981, 2989, 2990, 2987
1700, 2957, 2958, 2962, 2961, 2983, 2991, 2992, 2989
1701, 2958, 853, 854, 2962, 2984, 858, 2993, 2991
1702, 845, 2959, 2963, 846, 2986, 2994, 2995, 850
1703, 2959, 2960, 2964, 2963, 2988, 2996, 2997, 2994
1704, 2960, 2961, 2965, 2964, 2990, 2998, 2999, 2996
1705, 2961, 2962, 2966, 2965, 2992, 3000, 3001, 2998
1706, 2962, 854, 855, 2966, 2993, 859, 3002, 3000
1707, 846, 2963, 823, 65, 2995, 3003, 827, 851
1708, 2963, 2964, 824, 823, 2997, 3004, 828, 3003
1709, 2964, 2965, 825, 824, 2999, 3005, 829, 3004
1710, 2965, 2966, 826, 825, 3001, 3006, 830, 3005
1711, 2966, 855, 66, 826, 3002, 860, 831, 3006
*ELEMENT, type=CPS8, ELSET=Surface92
1712, 35, 69, 863, 552, 861, 867, 3007, 556
1713, 552, 863, 864, 553, 3007, 868, 3008, 557
1714, 553, 864, 865, 554, 3008, 869, 3009, 558
1715, 554, 865, 866, 555, 3009, 870, 3010, 559
1716, 555, 866, 70, 39, 3010, 871, 862, 560
*ELEMENT, type=CPS8, ELSET=Surface93
1717, 36, 561, 874, 71, 565, 3011, 878, 872
1718, 561, 562, 875, 874, 566, 3012, 879, 3011
1719, 562, 563, 876, 875, 567, 3013, 880, 3012
1720, 563, 564, 877, 876, 568, 3014, 881, 3013
1721, 564, 40, 72, 877, 569, 873, 882, 3014
*ELEMENT, type=CPS8, ELSET=Surface94
1722, 35, 498, 883, 69, 502, 3015, 887, 861
1723, 498, 499, 884, 883, 503, 3016, 888, 3015
1724, 499, 500, 885, 884, 504, 3017, 889, 3016
1725, 500, 501, 886, 885, 505, 3018, 890, 3017
1726, 501, 36, 71, 886, 506, 872, 891, 3018
*ELEMENT, type=CPS8, ELSET=Surface95
1727, 39, 70, 892, 570, 862, 896, 3019, 574
1728, 570, 892, 893, 571, 3019, 897, 3020, 575
1729, 571, 893, 894, 572, 3020, 898, 3021, 576
1730, 572, 894, 895, 573, 3021, 899, 3022, 577
1731, 573, 895, 72, 40, 3022, 900, 873, 578
*ELEMENT, type=CPS8, ELSET=Surface96
1732, 69, 883, 3023, 863, 887, 3039, 3040, 867
1733, 863, 3023, 3024, 864, 3040, 3041, 3042, 868
1734, 864, 3024, 3025, 865, 3042, 3043, 3044, 869
1735, 865, 3025, 3026, 866, 3044, 3045, 3046, 870
1736, 866, 3026, 892, 70, 3046, 3047, 896, 871
1737, 883, 884, 3027, 3023, 888, 3048, 3049, 3039
1738, 3023, 3027, 3028, 3024, 3049, 3050, 3051, 3041
1739, 3024, 3028, 3029, 3025, 3051, 3052, 3053, 3043
1740, 3025, 3029, 3030, 3026, 3053, 3054, 3055, 3045
1741, 3026, 3030, 893, 892, 3055, 3056, 897, 3047
1742, 884, 885, 3031, 3027, 889, 3057, 3058, 3048
1743, 3027, 3031, 3032, 3028, 3058, 3059, 3060, 3050
1744, 3028, 3032, 3033, 3029, 3060, 3061, 3062, 3052
1745, 3029, 3033, 3034, 3030, 3062, 3063, 3064, 3054
1746, 3030, 3034, 894, 893, 3064, 3065, 898, 3056
1747, 885, 886, 3035, 3031, 890, 3066, 3067, 3057
1748, 3031, 3035, 3036, 3032, 3067, 3068, 3069, 3059
1749, 3032, 3036, 3037, 3033, 3069, 3070, 3071, 3061
1750, 3033, 3037, 3038, 3034, 3071, 3072, 3073, 3063
1751, 3034, 3038, 895, 894, 3073, 3074, 899, 3065
1752, 886, 71, 874, 3035, 891, 878, 3075, 3066
1753, 3035, 874, 875, 3036, 3075, 879, 3076, 3068
1754, 3036, 875, 876, 3037, 3076, 880, 3077, 3070
1755, 3037, 876, 877, 3038, 3077, 881, 3078, 3072
1756, 3038, 877, 72, 895, 3078, 882, 900, 3074
*ELEMENT, type=CPS8, ELSET=Surface97
1757, 35, 69, 73, 63, 861, 902, 901, 792
*ELEMENT, type=CPS8, ELSET=Surface98
1758, 39, 64, 74, 70, 793, 903, 904, 862
*ELEMENT, type=CPS8, ELSET=Surface99
1759, 63, 73, 905, 794, 901, 909, 3079, 798
1760, 794, 905, 906, 795, 3079, 910, 3080, 799
1761, 795, 906, 907, 796, 3080, 911, 3081, 800
1762, 796, 907, 908, 797, 3081, 912, 3082, 801
1763, 797, 908, 74, 64, 3082, 913, 903, 802
*ELEMENT, type=CPS8, ELSET=Surface100
1764, 69, 863, 905, 73, 867, 3083, 909, 902
1765, 863, 864, 906, 905, 868, 3084, 910, 3083
1766, 864, 865, 907, 906, 869, 3085, 911, 3084
1767, 865, 866, 908, 907, 870, 3086, 912, 3085
1768, 866, 70, 74, 908, 871, 904, 913, 3086
*ELEMENT, type=CPS8, ELSET=Surface101
1769, 9, 65, 75, 59, 821, 915, 914, 752
*ELEMENT, type=CPS8, ELSET=Surface102
1770, 13, 60, 76, 66, 753, 916, 917, 822
*ELEMENT, type=CPS8, ELSET=Surface103
1771, 59, 75, 918, 754, 914, 922, 3087, 758
1772, 754, 918, 919, 755, 3087, 923, 3088, 759
1773, 755, 919, 920, 756, 3088, 924, 3089, 760
1774, 756, 920, 921, 757, 3089, 925, 3090, 761
1775, 757, 921, 76, 60, 3090, 926, 916, 762
*ELEMENT, type=CPS8, ELSET=Surface104
1776, 65, 823, 918, 75, 827, 3091, 922, 915
1777, 823, 824, 919, 918, 828, 3092, 923, 3091
1778, 824, 825, 920, 919, 829, 3093, 924, 3092
1779, 825, 826, 921, 920, 830, 3094, 925, 3093
1780, 826, 66, 76, 921, 831, 917, 926, 3094
*ELEMENT, type=CPS8, ELSET=Surface105
1781, 22, 932, 3095, 339, 934, 3103, 3104, 343
1782, 932, 933, 3096, 3095, 935, 3105, 3106, 3103
1783, 933, 78, 937, 3096, 936, 941, 3107, 3105
1784, 339, 3095, 3097, 340, 3104, 3108, 3109, 344
1785, 3095, 3096, 3098, 3097, 3106, 3110, 3111, 3108
1786, 3096, 937, 938, 3098, 3107, 942, 3112, 3110
1787, 340, 3097, 3099, 341, 3109, 3113, 3114, 345
1788, 3097, 3098, 3100, 3099, 3111, 3115, 3116, 3113
1789, 3098, 938, 939, 3100, 3112, 943, 3117, 3115
1790, 341, 3099, 3101, 342, 3114, 3118, 3119, 346
1791, 3099, 3100, 3102, 3101, 3116, 3120, 3121, 3118
1792, 3100, 939, 940, 3102, 3117, 944, 3122, 3120
1793, 342, 3101, 927, 21, 3119, 3123, 929, 347
1794, 3101, 3102, 928, 927, 3121, 3124, 930, 3123
1795, 3102, 940, 77, 928, 3122, 945, 931, 3124
*ELEMENT, type=CPS8, ELSET=Surface106
1796, 21, 927, 3125, 351, 929, 3133, 3134, 355
1797, 927, 928, 3126, 3125, 930, 3135, 3136, 3133
1798, 928, 77, 951, 3126, 931, 955, 3137, 3135
1799, 351, 3125, 3127, 352, 3134, 3138, 3139, 356
1800, 3125, 3126, 3128, 3127, 3136, 3140, 3141, 3138
1801, 3126, 951, 952, 3128, 3137, 956, 3142, 3140
1802, 352, 3127, 3129, 353, 3139, 3143, 3144, 357
1803, 3127, 3128, 3130, 3129, 3141, 3145, 3146, 3143
1804, 3128, 952, 953, 3130, 3142, 957, 3147, 3145
1805, 353, 3129, 3131, 354, 3144, 3148, 3149, 358
1806, 3129, 3130, 3132, 3131, 3146, 3150, 3151, 3148
1807, 3130, 953, 954, 3132, 3147, 958, 3152, 3150
1808, 354, 3131, 946, 23, 3149, 3153, 948, 359
1809, 3131, 3132, 947, 946, 3151, 3154, 949, 3153
1810, 3132, 954, 79, 947, 3152, 959, 950, 3154
*ELEMENT, type=CPS8, ELSET=Surface107
1811, 24, 363, 3155, 960, 367, 3163, 3164, 962
1812, 960, 3155, 3156, 961, 3164, 3165, 3166, 963
1813, 961, 3156, 965, 80, 3166, 3167, 969, 964
1814, 363, 364, 3157, 3155, 368, 3168, 3169, 3163
1815, 3155, 3157, 3158, 3156, 3169, 3170, 3171, 3165
1816, 3156, 3158, 966, 965, 3171, 3172, 970, 3167
1817, 364, 365, 3159, 3157, 369, 3173, 3174, 3168
1818, 3157, 3159, 3160, 3158, 3174, 3175, 3176, 3170
1819, 3158, 3160, 967, 966, 3176, 3177, 971, 3172
1820, 365, 366, 3161, 3159, 370, 3178, 3179, 3173
1821, 3159, 3161, 3162, 3160, 3179, 3180, 3181, 3175
1822, 3160, 3162, 968, 967, 3181, 3182, 972, 3177
1823, 366, 23, 946, 3161, 371, 948, 3183, 3178
1824, 3161, 946, 947, 3162, 3183, 949, 3184, 3180
1825, 3162, 947, 79, 968, 3184, 950, 973, 3182
*ELEMENT, type=CPS8, ELSET=Surface108
1826, 22, 372, 3185, 932, 376, 3193, 3194, 934
1827, 932, 3185, 3186, 933, 3194, 3195, 3196, 935
1828, 933, 3186, 974, 78, 3196, 3197, 978, 936
1829, 372, 373, 3187, 3185, 377, 3198, 3199, 3193
1830, 3185, 3187, 3188, 3186, 3199, 3200, 3201, 3195
1831, 3186, 3188, 975, 974, 3201, 3202, 979, 3197
1832, 373, 374, 3189, 3187, 378, 3203, 3204, 3198
1833, 3187, 3189, 3190, 3188, 3204, 3205, 3206, 3200
1834, 3188, 3190, 976, 975, 3206, 3207, 980, 3202
1835, 374, 375, 3191, 3189, 379, 3208, 3209, 3203
1836, 3189, 3191, 3192, 3190, 3209, 3210, 3211, 3205
1837, 3190, 3192, 977, 976, 3211, 3212, 981, 3207
1838, 375, 24, 960, 3191, 380, 962, 3213, 3208
1839, 3191, 960, 961, 3192, 3213, 963, 3214, 3210
1840, 3192, 961, 80, 977, 3214, 964, 982, 3212
*ELEMENT, type=CPS8, ELSET=Surface109
1841, 78, 974, 3215, 937, 978, 3231, 3232, 941
1842, 974, 975, 3216, 3215, 979, 3233, 3234, 3231
1843, 975, 976, 3217, 3216, 980, 3235, 3236, 3233
1844, 976, 977, 3218, 3217, 981, 3237, 3238, 3235
1845, 977, 80, 965, 3218, 982, 969, 3239, 3237
1846, 937, 3215, 3219, 938, 3232, 3240, 3241, 942
1847, 3215, 3216, 3220, 3219, 3234, 3242, 3243, 3240
1848, 3216, 3217, 3221, 3220, 3236, 3244, 3245, 3242
1849, 3217, 3218, 3222, 3221, 3238, 3246, 3247, 3244
1850, 3218, 965, 966, 3222, 3239, 970, 3248, 3246
1851, 938, 3219, 3223, 939, 3241, 3249, 3250, 943
1852, 3219, 3220, 3224, 3223, 3243, 3251, 3252, 3249
1853, 3220, 3221, 3225, 3224, 3245, 3253, 3254, 3251
1854, 3221, 3222, 3226, 3225, 3247, 3255, 3256, 3253
1855, 3222, 966, 967, 3226, 3248, 971, 3257, 3255
1856, 939, 3223, 3227, 940, 3250, 3258, 3259, 944
1857, 3223, 3224, 3228, 3227, 3252, 3260, 3261, 3258
1858, 3224, 3225, 3229, 3228, 3254, 3262, 3263, 3260
1859, 3225, 3226, 3230, 3229, 3256, 3264, 3265, 3262
1860, 3226, 967, 968, 3230, 3257, 972, 3266, 3264
1861, 940, 3227, 951, 77, 3259, 3267, 955, 945
1862, 3227, 3228, 952, 951, 3261, 3268, 956, 3267
1863, 3228, 3229, 953, 952, 3263, 3269, 957, 3268
1864, 3229, 3230, 954, 953, 3265, 3270, 958, 3269
1865, 3230, 968, 79, 954, 3266, 973, 959, 3270
*ELEMENT, type=CPS8, ELSET=Surface110
1866, 23, 386, 3271, 946, 388, 3275, 3276, 948
1867, 946, 3271, 3272, 947, 3276, 3277, 3278, 949
1868, 947, 3272, 988, 79, 3278, 3279, 990, 950
1869, 386, 387, 3273, 3271, 389, 3280, 3281, 3275
1870, 3271, 3273, 3274, 3272, 3281, 3282, 3283, 3277
1871, 3272, 3274, 989, 988, 3283, 3284, 991, 3279
1872, 387, 26, 983, 3273, 390, 985, 3285, 3280
1873, 3273, 983, 984, 3274, 3285, 986, 3286, 3282
1874, 3274, 984, 81, 989, 3286, 987, 992, 3284
*ELEMENT, type=CPS8, ELSET=Surface111
1875, 21, 927, 3287, 399, 929, 3291, 3292, 401
1876, 927, 928, 3288, 3287, 930, 3293, 3294, 3291
1877, 928, 77, 998, 3288, 931, 1000, 3295, 3293
1878, 399, 3287, 3289, 400, 3292, 3296, 3297, 402
1879, 3287, 3288, 3290, 3289, 3294, 3298, 3299, 3296
1880, 3288, 998, 999, 3290, 3295, 1001, 3300, 3298
1881, 400, 3289, 993, 28, 3297, 3301, 995, 403
1882, 3289, 3290, 994, 993, 3299, 3302, 996, 3301
1883, 3290, 999, 82, 994, 3300, 1002, 997, 3302
*ELEMENT, type=CPS8, ELSET=Surface112
1884, 28, 993, 3303, 416, 995, 3311, 3312, 420
1885, 993, 994, 3304, 3303, 996, 3313, 3314, 3311
1886, 994, 82, 1003, 3304, 997, 1007, 3315, 3313
1887, 416, 3303, 3305, 417, 3312, 3316, 3317, 421
1888, 3303, 3304, 3306, 3305, 3314, 3318, 3319, 3316
1889, 3304, 1003, 1004, 3306, 3315, 1008, 3320, 3318
1890, 417, 3305, 3307, 418, 3317, 3321, 3322, 422
1891, 3305, 3306, 3308, 3307, 3319, 3323, 3324, 3321
1892, 3306, 1004, 1005, 3308, 3320, 1009, 3325, 3323
1893, 418, 3307, 3309, 419, 3322, 3326, 3327, 423
1894, 3307, 3308, 3310, 3309, 3324, 3328, 3329, 3326
1895, 3308, 1005, 1006, 3310, 3325, 1010, 3330, 3328
1896, 419, 3309, 983, 26, 3327, 3331, 985, 424
1897, 3309, 3310, 984, 983, 3329, 3332, 986, 3331
1898, 3310, 1006, 81, 984, 3330, 1011, 987, 3332
*ELEMENT, type=CPS8, ELSET=Surface113
1899, 77, 951, 3333, 998, 955, 3341, 3342, 1000
1900, 998, 3333, 3334, 999, 3342, 3343, 3344, 1001
1901, 999, 3334, 1003, 82, 3344, 3345, 1007, 1002
1902, 951, 952, 3335, 3333, 956, 3346, 3347, 3341
1903, 3333, 3335, 3336, 3334, 3347, 3348, 3349, 3343
1904, 3334, 3336, 1004, 1003, 3349, 3350, 1008, 3345
1905, 952, 953, 3337, 3335, 957, 3351, 3352, 3346
1906, 3335, 3337, 3338, 3336, 3352, 3353, 3354, 3348
1907, 3336, 3338, 1005, 1004, 3354, 3355, 1009, 3350
1908, 953, 954, 3339, 3337, 958, 3356, 3357, 3351
1909, 3337, 3339, 3340, 3338, 3357, 3358, 3359, 3353
1910, 3338, 3340, 1006, 1005, 3359, 3360, 1010, 3355
1911, 954, 79, 988, 3339, 959, 990, 3361, 3356
1912, 3339, 988, 989, 3340, 3361, 991, 3362, 3358
1913, 3340, 989, 81, 1006, 3362, 992, 1011, 3360
*ELEMENT, type=CPS8, ELSET=Surface114
1914, 26, 434, 3363, 983, 438, 3371, 3372, 985
1915, 983, 3363, 3364, 984, 3372, 3373, 3374, 986
1916, 984, 3364, 1017, 81, 3374, 3375, 1021, 987
1917, 434, 435, 3365, 3363, 439, 3376, 3377, 3371
1918, 3363, 3365, 3366, 3364, 3377, 3378, 3379, 3373
1919, 3364, 3366, 1018, 1017, 3379, 3380, 1022, 3375
1920, 435, 436, 3367, 3365, 440, 3381, 3382, 3376
1921, 3365, 3367, 3368, 3366, 3382, 3383, 3384, 3378
1922, 3366, 3368, 1019, 1018, 3384, 3385, 1023, 3380
1923, 436, 437, 3369, 3367, 441, 3386, 3387, 3381
1924, 3367, 3369, 3370, 3368, 3387, 3388, 3389, 3383
1925, 3368, 3370, 1020, 1019, 3389, 3390, 1024, 3385
1926, 437, 30, 1012, 3369, 442, 1014, 3391, 3386
1927, 3369, 1012, 1013, 3370, 3391, 1015, 3392, 3388
1928, 3370, 1013, 83, 1020, 3392, 1016, 1025, 3390
*ELEMENT, type=CPS8, ELSET=Surface115
1929, 28, 993, 3393, 455, 995, 3401, 3402, 459
1930, 993, 994, 3394, 3393, 996, 3403, 3404, 3401
1931, 994, 82, 1031, 3394, 997, 1035, 3405, 3403
1932, 455, 3393, 3395, 456, 3402, 3406, 3407, 460
1933, 3393, 3394, 3396, 3395, 3404, 3408, 3409, 3406
1934, 3394, 1031, 1032, 3396, 3405, 1036, 3410, 3408
1935, 456, 3395, 3397, 457, 3407, 3411, 3412, 461
1936, 3395, 3396, 3398, 3397, 3409, 3413, 3414, 3411
1937, 3396, 1032, 1033, 3398, 3410, 1037, 3415, 3413
1938, 457, 3397, 3399, 458, 3412, 3416, 3417, 462
1939, 3397, 3398, 3400, 3399, 3414, 3418, 3419, 3416
1940, 3398, 1033, 1034, 3400, 3415, 1038, 3420, 3418
1941, 458, 3399, 1026, 32, 3417, 3421, 1028, 463
1942, 3399, 3400, 1027, 1026, 3419, 3422, 1029, 3421
1943, 3400, 1034, 84, 1027, 3420, 1039, 1030, 3422
*ELEMENT, type=CPS8, ELSET=Surface116
1944, 32, 1026, 3423, 476, 1028, 3431, 3432, 480
1945, 1026, 1027, 3424, 3423, 1029, 3433, 3434, 3431
1946, 1027, 84, 1040, 3424, 1030, 1044, 3435, 3433
1947, 476, 3423, 3425, 477, 3432, 3436, 3437, 481
1948, 3423, 3424, 3426, 3425, 3434, 3438, 3439, 3436
1949, 3424, 1040, 1041, 3426, 3435, 1045, 3440, 3438
1950, 477, 3425, 3427, 478, 3437, 3441, 3442, 482
1951, 3425, 3426, 3428, 3427, 3439, 3443, 3444, 3441
1952, 3426, 1041, 1042, 3428, 3440, 1046, 3445, 3443
1953, 478, 3427, 3429, 479, 3442, 3446, 3447, 483
1954, 3427, 3428, 3430, 3429, 3444, 3448, 3449, 3446
1955, 3428, 1042, 1043, 3430, 3445, 1047, 3450, 3448
1956, 479, 3429, 1012, 30, 3447, 3451, 1014, 484
1957, 3429, 3430, 1013, 1012, 3449, 3452, 1015, 3451
1958, 3430, 1043, 83, 1013, 3450, 1048, 1016, 3452
*ELEMENT, type=CPS8, ELSET=Surface117
1959, 82, 1003, 3453, 1031, 1007, 3469, 3470, 1035
1960, 1031, 3453, 3454, 1032, 3470, 3471, 3472, 1036
1961, 1032, 3454, 3455, 1033, 3472, 3473, 3474, 1037
1962, 1033, 3455, 3456, 1034, 3474, 3475, 3476, 1038
1963, 1034, 3456, 1040, 84, 3476, 3477, 1044, 1039
1964, 1003, 1004, 3457, 3453, 1008, 3478, 3479, 3469
1965, 3453, 3457, 3458, 3454, 3479, 3480, 3481, 3471
1966, 3454, 3458, 3459, 3455, 3481, 3482, 3483, 3473
1967, 3455, 3459, 3460, 3456, 3483, 3484, 3485, 3475
1968, 3456, 3460, 1041, 1040, 3485, 3486, 1045, 3477
1969, 1004, 1005, 3461, 3457, 1009, 3487, 3488, 3478
1970, 3457, 3461, 3462, 3458, 3488, 3489, 3490, 3480
1971, 3458, 3462, 3463, 3459, 3490, 3491, 3492, 3482
1972, 3459, 3463, 3464, 3460, 3492, 3493, 3494, 3484
1973, 3460, 3464, 1042, 1041, 3494, 3495, 1046, 3486
1974, 1005, 1006, 3465, 3461, 1010, 3496, 3497, 3487
1975, 3461, 3465, 3466, 3462, 3497, 3498, 3499, 3489
1976, 3462, 3466, 3467, 3463, 3499, 3500, 3501, 3491
1977, 3463, 3467, 3468, 3464, 3501, 3502, 3503, 3493
1978, 3464, 3468, 1043, 1042, 3503, 3504, 1047, 3495
1979, 1006, 81, 1017, 3465, 1011, 1021, 3505, 3496
1980, 3465, 1017, 1018, 3466, 3505, 1022, 3506, 3498
1981, 3466, 1018, 1019, 3467, 3506, 1023, 3507, 3500
1982, 3467, 1019, 1020, 3468, 3507, 1024, 3508, 3502
1983, 3468, 1020, 83, 1043, 3508, 1025, 1048, 3504
*ELEMENT, type=CPS8, ELSET=Surface118
1984, 2, 145, 3509, 1054, 149, 3517, 3518, 1056
1985, 1054, 3509, 3510, 1055, 3518, 3519, 3520, 1057
1986, 1055, 3510, 1059, 86, 3520, 3521, 1063, 1058
1987, 145, 146, 3511, 3509, 150, 3522, 3523, 3517
1988, 3509, 3511, 3512, 3510, 3523, 3524, 3525, 3519
1989, 3510, 3512, 1060, 1059, 3525, 3526, 1064, 3521
1990, 146, 147, 3513, 3511, 151, 3527, 3528, 3522
1991, 3511, 3513, 3514, 3512, 3528, 3529, 3530, 3524
1992, 3512, 3514, 1061, 1060, 3530, 3531, 1065, 3526
1993, 147, 148, 3515, 3513, 152, 3532, 3533, 3527
1994, 3513, 3515, 3516, 3514, 3533, 3534, 3535, 3529
1995, 3514, 3516, 1062, 1061, 3535, 3536, 1066, 3531
1996, 148, 6, 1049, 3515, 153, 1051, 3537, 3532
1997, 3515, 1049, 1050, 3516, 3537, 1052, 3538, 3534
1998, 3516, 1050, 85, 1062, 3538, 1053, 1067, 3536
*ELEMENT, type=CPS8, ELSET=Surface119
1999, 6, 121, 3539, 1049, 125, 3547, 3548, 1051
2000, 1049, 3539, 3540, 1050, 3548, 3549, 3550, 1052
2001, 1050, 3540, 1073, 85, 3550, 3551, 1077, 1053
2002, 121, 122, 3541, 3539, 126, 3552, 3553, 3547
2003, 3539, 3541, 3542, 3540, 3553, 3554, 3555, 3549
2004, 3540, 3542, 1074, 1073, 3555, 3556, 1078, 3551
2005, 122, 123, 3543, 3541, 127, 3557, 3558, 3552
2006, 3541, 3543, 3544, 3542, 3558, 3559, 3560, 3554
2007, 3542, 3544, 1075, 1074, 3560, 3561, 1079, 3556
2008, 123, 124, 3545, 3543, 128, 3562, 3563, 3557
2009, 3543, 3545, 3546, 3544, 3563, 3564, 3565, 3559
2010, 3544, 3546, 1076, 1075, 3565, 3566, 1080, 3561
2011, 124, 5, 1068, 3545, 129, 1070, 3567, 3562
2012, 3545, 1068, 1069, 3546, 3567, 1071, 3568, 3564
2013, 3546, 1069, 87, 1076, 3568, 1072, 1081, 3566
*ELEMENT, type=CPS8, ELSET=Surface120
2014, 1, 1082, 3569, 154, 1084, 3577, 3578, 158
2015, 1082, 1083, 3570, 3569, 1085, 3579, 3580, 3577
2016, 1083, 88, 1087, 3570, 1086, 1091, 3581, 3579
2017, 154, 3569, 3571, 155, 3578, 3582, 3583, 159
2018, 3569, 3570, 3572, 3571, 3580, 3584, 3585, 3582
2019, 3570, 1087, 1088, 3572, 3581, 1092, 3586, 3584
2020, 155, 3571, 3573, 156, 3583, 3587, 3588, 160
2021, 3571, 3572, 3574, 3573, 3585, 3589, 3590, 3587
2022, 3572, 1088, 1089, 3574, 3586, 1093, 3591, 3589
2023, 156, 3573, 3575, 157, 3588, 3592, 3593, 161
2024, 3573, 3574, 3576, 3575, 3590, 3594, 3595, 3592
2025, 3574, 1089, 1090, 3576, 3591, 1094, 3596, 3594
2026, 157, 3575, 1068, 5, 3593, 3597, 1070, 162
2027, 3575, 3576, 1069, 1068, 3595, 3598, 1071, 3597
2028, 3576, 1090, 87, 1069, 3596, 1095, 1072, 3598
*ELEMENT, type=CPS8, ELSET=Surface121
2029, 2, 1054, 3599, 97, 1056, 3607, 3608, 101
2030, 1054, 1055, 3600, 3599, 1057, 3609, 3610, 3607
2031, 1055, 86, 1096, 3600, 1058, 1100, 3611, 3609
2032, 97, 3599, 3601, 98, 3608, 3612, 3613, 102
2033, 3599, 3600, 3602, 3601, 3610, 3614, 3615, 3612
2034, 3600, 1096, 1097, 3602, 3611, 1101, 3616, 3614
2035, 98, 3601, 3603, 99, 3613, 3617, 3618, 103
2036, 3601, 3602, 3604, 3603, 3615, 3619, 3620, 3617
2037, 3602, 1097, 1098, 3604, 3616, 1102, 3621, 3619
2038, 99, 3603, 3605, 100, 3618, 3622, 3623, 104
2039, 3603, 3604, 3606, 3605, 3620, 3624, 3625, 3622
2040, 3604, 1098, 1099, 3606, 3621, 1103, 3626, 3624
2041, 100, 3605, 1082, 1, 3623, 3627, 1084, 105
2042, 3605, 3606, 1083, 1082, 3625, 3628, 1085, 3627
2043, 3606, 1099, 88, 1083, 3626, 1104, 1086, 3628
*ELEMENT, type=CPS8, ELSET=Surface122
2044, 86, 1059, 3629, 1096, 1063, 3645, 3646, 1100
2045, 1096, 3629, 3630, 1097, 3646, 3647, 3648, 1101
2046, 1097, 3630, 3631, 1098, 3648, 3649, 3650, 1102
2047, 1098, 3631, 3632, 1099, 3650, 3651, 3652, 1103
2048, 1099, 3632, 1087, 88, 3652, 3653, 1091, 1104
2049, 1059, 1060, 3633, 3629, 1064, 3654, 3655, 3645
2050, 3629, 3633, 3634, 3630, 3655, 3656, 3657, 3647
2051, 3630, 3634, 3635, 3631, 3657, 3658, 3659, 3649
2052, 3631, 3635, 3636, 3632, 3659, 3660, 3661, 3651
2053, 3632, 3636, 1088, 1087, 3661, 3662, 1092, 3653
2054, 1060, 1061, 3637, 3633, 1065, 3663, 3664, 3654
2055, 3633, 3637, 3638, 3634, 3664, 3665, 3666, 3656
2056, 3634, 3638, 3639, 3635, 3666, 3667, 3668, 3658
2057, 3635, 3639, 3640, 3636, 3668, 3669, 3670, 3660
2058, 3636, 3640, 1089, 1088, 3670, 3671, 1093, 3662
2059, 1061, 1062, 3641, 3637, 1066, 3672, 3673, 3663
2060, 3637, 3641, 3642, 3638, 3673, 3674, 3675, 3665
2061, 3638, 3642, 3643, 3639, 3675, 3676, 3677, 3667
2062, 3639, 3643, 3644, 3640, 3677, 3678, 3679, 3669
2063, 3640, 3644, 1090, 1089, 3679, 3680, 1094, 3671
2064, 1062, 85, 1073, 3641, 1067, 1077, 3681, 3672
2065, 3641, 1073, 1074, 3642, 3681, 1078, 3682, 3674
2066, 3642, 1074, 1075, 3643, 3682, 1079, 3683, 3676
2067, 3643, 1075, 1076, 3644, 3683, 1080, 3684, 3678
2068, 3644, 1076, 87, 1090, 3684, 1081, 1095, 3680
*ELEMENT, type=CPS8, ELSET=Surface123
2069, 1, 53, 1105, 1082, 713, 1107, 3685, 1084
2070, 1082, 1105, 1106, 1083, 3685, 1108, 3686, 1085
2071, 1083, 1106, 89, 88, 3686, 1109, 1110, 1086
*ELEMENT, type=CPS8, ELSET=Surface124
2072, 2, 1054, 1111, 54, 1056, 3687, 1113, 714
2073, 1054, 1055, 1112, 1111, 1057, 3688, 1114, 3687
2074, 1055, 86, 90, 1112, 1058, 1116, 1115, 3688
*ELEMENT, type=CPS8, ELSET=Surface125
2075, 54, 1111, 3689, 715, 1113, 3697, 3698, 719
2076, 1111, 1112, 3690, 3689, 1114, 3699, 3700, 3697
2077, 1112, 90, 1117, 3690, 1115, 1121, 3701, 3699
2078, 715, 3689, 3691, 716, 3698, 3702, 3703, 720
2079, 3689, 3690, 3692, 3691, 3700, 3704, 3705, 3702
2080, 3690, 1117, 1118, 3692, 3701, 1122, 3706, 3704
2081, 716, 3691, 3693, 717, 3703, 3707, 3708, 721
2082, 3691, 3692, 3694, 3693, 3705, 3709, 3710, 3707
2083, 3692, 1118, 1119, 3694, 3706, 1123, 3711, 3709
2084, 717, 3693, 3695, 718, 3708, 3712, 3713, 722
2085, 3693, 3694, 3696, 3695, 3710, 3714, 3715, 3712
2086, 3694, 1119, 1120, 3696, 3711, 1124, 3716, 3714
2087, 718, 3695, 1105, 53, 3713, 3717, 1107, 723
2088, 3695, 3696, 1106, 1105, 3715, 3718, 1108, 3717
2089, 3696, 1120, 89, 1106, 3716, 1125, 1109, 3718
*ELEMENT, type=CPS8, ELSET=Surface126
2090, 86, 1096, 1117, 90, 1100, 3719, 1121, 1116
2091, 1096, 1097, 1118, 1117, 1101, 3720, 1122, 3719
2092, 1097, 1098, 1119, 1118, 1102, 3721, 1123, 3720
2093, 1098, 1099, 1120, 1119, 1103, 3722, 1124, 3721
2094, 1099, 88, 89, 1120, 1104, 1110, 1125, 3722
*ELEMENT, type=CPS8, ELSET=Surface127
2095, 45, 1126, 3723, 643, 1128, 3731, 3732, 647
2096, 1126, 1127, 3724, 3723, 1129, 3733, 3734, 3731
2097, 1127, 91, 1136, 3724, 1130, 1140, 3735, 3733
2098, 643, 3723, 3725, 644, 3732, 3736, 3737, 648
2099, 3723, 3724, 3726, 3725, 3734, 3738, 3739, 3736
2100, 3724, 1136, 1137, 3726, 3735, 1141, 3740, 3738
2101, 644, 3725, 3727, 645, 3737, 3741, 3742, 649
2102, 3725, 3726, 3728, 3727, 3739, 3743, 3744, 3741
2103, 3726, 1137, 1138, 3728, 3740, 1142, 3745, 3743
2104, 645, 3727, 3729, 646, 3742, 3746, 3747, 650
2105, 3727, 3728, 3730, 3729, 3744, 3748, 3749, 3746
2106, 3728, 1138, 1139, 3730, 3745, 1143, 3750, 3748
2107, 646, 3729, 1131, 46, 3747, 3751, 1133, 651
2108, 3729, 3730, 1132, 1131, 3749, 3752, 1134, 3751
2109, 3730, 1139, 92, 1132, 3750, 1144, 1135, 3752
*ELEMENT, type=CPS8, ELSET=Surface128
2110, 47, 658, 3753, 1145, 662, 3761, 3762, 1147
2111, 1145, 3753, 3754, 1146, 3762, 3763, 3764, 1148
2112, 1146, 3754, 1155, 93, 3764, 3765, 1159, 1149
2113, 658, 659, 3755, 3753, 663, 3766, 3767, 3761
2114, 3753, 3755, 3756, 3754, 3767, 3768, 3769, 3763
2115, 3754, 3756, 1156, 1155, 3769, 3770, 1160, 3765
2116, 659, 660, 3757, 3755, 664, 3771, 3772, 3766
2117, 3755, 3757, 3758, 3756, 3772, 3773, 3774, 3768
2118, 3756, 3758, 1157, 1156, 3774, 3775, 1161, 3770
2119, 660, 661, 3759, 3757, 665, 3776, 3777, 3771
2120, 3757, 3759, 3760, 3758, 3777, 3778, 3779, 3773
2121, 3758, 3760, 1158, 1157, 3779, 3780, 1162, 3775
2122, 661, 48, 1150, 3759, 666, 1152, 3781, 3776
2123, 3759, 1150, 1151, 3760, 3781, 1153, 3782, 3778
2124, 3760, 1151, 94, 1158, 3782, 1154, 1163, 3780
*ELEMENT, type=CPS8, ELSET=Surface129
2125, 47, 1145, 3783, 667, 1147, 3791, 3792, 671
2126, 1145, 1146, 3784, 3783, 1148, 3793, 3794, 3791
2127, 1146, 93, 1164, 3784, 1149, 1168, 3795, 3793
2128, 667, 3783, 3785, 668, 3792, 3796, 3797, 672
2129, 3783, 3784, 3786, 3785, 3794, 3798, 3799, 3796
2130, 3784, 1164, 1165, 3786, 3795, 1169, 3800, 3798
2131, 668, 3785, 3787, 669, 3797, 3801, 3802, 673
2132, 3785, 3786, 3788, 3787, 3799, 3803, 3804, 3801
2133, 3786, 1165, 1166, 3788, 3800, 1170, 3805, 3803
2134, 669, 3787, 3789, 670, 3802, 3806, 3807, 674
2135, 3787, 3788, 3790, 3789, 3804, 3808, 3809, 3806
2136, 3788, 1166, 1167, 3790, 3805, 1171, 3810, 3808
2137, 670, 3789, 1126, 45, 3807, 3811, 1128, 675
2138, 3789, 3790, 1127, 1126, 3809, 3812, 1129, 3811
2139, 3790, 1167, 91, 1127, 3810, 1172, 1130, 3812
*ELEMENT, type=CPS8, ELSET=Surface130
2140, 48, 676, 3813, 1150, 680, 3821, 3822, 1152
2141, 1150, 3813, 3814, 1151, 3822, 3823, 3824, 1153
2142, 1151, 3814, 1173, 94, 3824, 3825, 1177, 1154
2143, 676, 677, 3815, 3813, 681, 3826, 3827, 3821
2144, 3813, 3815, 3816, 3814, 3827, 3828, 3829, 3823
2145, 3814, 3816, 1174, 1173, 3829, 3830, 1178, 3825
2146, 677, 678, 3817, 3815, 682, 3831, 3832, 3826
2147, 3815, 3817, 3818, 3816, 3832, 3833, 3834, 3828
2148, 3816, 3818, 1175, 1174, 3834, 3835, 1179, 3830
2149, 678, 679, 3819, 3817, 683, 3836, 3837, 3831
2150, 3817, 3819, 3820, 3818, 3837, 3838, 3839, 3833
2151, 3818, 3820, 1176, 1175, 3839, 3840, 1180, 3835
2152, 679, 46, 1131, 3819, 684, 1133, 3841, 3836
2153, 3819, 1131, 1132, 3820, 3841, 1134, 3842, 3838
2154, 3820, 1132, 92, 1176, 3842, 1135, 1181, 3840
*ELEMENT, type=CPS8, ELSET=Surface131
2155, 93, 1155, 3843, 1164, 1159, 3859, 3860, 1168
2156, 1155, 1156, 3844, 3843, 1160, 3861, 3862, 3859
2157, 1156, 1157, 3845, 3844, 1161, 3863, 3864, 3861
2158, 1157, 1158, 3846, 3845, 1162, 3865, 3866, 3863
2159, 1158, 94, 1173, 3846, 1163, 1177, 3867, 3865
2160, 1164, 3843, 3847, 1165, 3860, 3868, 3869, 1169
2161, 3843, 3844, 3848, 3847, 3862, 3870, 3871, 3868
2162, 3844, 3845, 3849, 3848, 3864, 3872, 3873, 3870
2163, 3845, 3846, 3850, 3849, 3866, 3874, 3875, 3872
2164, 3846, 1173, 1174, 3850, 3867, 1178, 3876, 3874
2165, 1165, 3847, 3851, 1166, 3869, 3877, 3878, 1170
2166, 3847, 3848, 3852, 3851, 3871, 3879, 3880, 3877
2167, 3848, 3849, 3853, 3852, 3873, 3881, 3882, 3879
2168, 3849, 3850, 3854, 3853, 3875, 3883, 3884, 3881
2169, 3850, 1174, 1175, 3854, 3876, 1179, 3885, 3883
2170, 1166, 3851, 3855, 1167, 3878, 3886, 3887, 1171
2171, 3851, 3852, 3856, 3855, 3880, 3888, 3889, 3886
2172, 3852, 3853, 3857, 3856, 3882, 3890, 3891, 3888
2173, 3853, 3854, 3858, 3857, 3884, 3892, 3893, 3890
2174, 3854, 1175, 1176, 3858, 3885, 1180, 3894, 3892
2175, 1167, 3855, 1136, 91, 3887, 3895, 1140, 1172
2176, 3855, 3856, 1137, 1136, 3889, 3896, 1141, 3895
2177, 3856, 3857, 1138, 1137, 3891, 3897, 1142, 3896
2178, 3857, 3858, 1139, 1138, 3893, 3898, 1143, 3897
2179, 3858, 1176, 92, 1139, 3894, 1181, 1144, 3898
*ELEMENT, type=CPS8, ELSET=Surface132
2180, 46, 1131, 1182, 50, 1133, 3899, 1184, 686
2181, 1131, 1132, 1183, 1182, 1134, 3900, 1185, 3899
2182, 1132, 92, 95, 1183, 1135, 1187, 1186, 3900
*ELEMENT, type=CPS8, ELSET=Surface133
2183, 48, 52, 1188, 1150, 691, 1190, 3901, 1152
2184, 1150, 1188, 1189, 1151, 3901, 1191, 3902, 1153
2185, 1151, 1189, 96, 94, 3902, 1192, 1193, 1154
*ELEMENT, type=CPS8, ELSET=Surface134
2186, 52, 704, 3903, 1188, 708, 3911, 3912, 1190
2187, 1188, 3903, 3904, 1189, 3912, 3913, 3914, 1191
2188, 1189, 3904, 1194, 96, 3914, 3915, 1198, 1192
2189, 704, 705, 3905, 3903, 709, 3916, 3917, 3911
2190, 3903, 3905, 3906, 3904, 3917, 3918, 3919, 3913
2191, 3904, 3906, 1195, 1194, 3919, 3920, 1199, 3915
2192, 705, 706, 3907, 3905, 710, 3921, 3922, 3916
2193, 3905, 3907, 3908, 3906, 3922, 3923, 3924, 3918
2194, 3906, 3908, 1196, 1195, 3924, 3925, 1200, 3920
2195, 706, 707, 3909, 3907, 711, 3926, 3927, 3921
2196, 3907, 3909, 3910, 3908, 3927, 3928, 3929, 3923
2197, 3908, 3910, 1197, 1196, 3929, 3930, 1201, 3925
2198, 707, 50, 1182, 3909, 712, 1184, 3931, 3926
2199, 3909, 1182, 1183, 3910, 3931, 1185, 3932, 3928
2200, 3910, 1183, 95, 1197, 3932, 1186, 1202, 3930
*ELEMENT, type=CPS8, ELSET=Surface135
2201, 94, 96, 1194, 1173, 1193, 1198, 3933, 1177
2202, 1173, 1194, 1195, 1174, 3933, 1199, 3934, 1178
2203, 1174, 1195, 1196, 1175, 3934, 1200, 3935, 1179
2204, 1175, 1196, 1197, 1176, 3935, 1201, 3936, 1180
2205, 1176, 1197, 95, 92, 3936, 1202, 1187, 1181
*ELEMENT, type=C3D20, ELSET=Volume1
2206, 1203, 97, 2, 118, 3937, 1237, 145, 1349, 1207, 101, 119, 1208, 3954, 1253, 1354, 
3955, 3953, 1254, 149, 1353
2207, 3937, 1237, 145, 1349, 3938, 1241, 146, 1350, 3954, 1253, 1354, 3955, 3957, 1262, 1356, 
3958, 3956, 1263, 150, 1355
2208, 3938, 1241, 146, 1350, 3939, 1245, 147, 1351, 3957, 1262, 1356, 3958, 3960, 1271, 1358, 
3961, 3959, 1272, 151, 1357
2209, 3939, 1245, 147, 1351, 3940, 1249, 148, 1352, 3960, 1271, 1358, 3961, 3963, 1280, 1360, 
3964, 3962, 1281, 152, 1359
2210, 3940, 1249, 148, 1352, 1220, 121, 6, 142, 3963, 1280, 1360, 3964, 1225, 125, 143, 
1224, 3965, 1289, 153, 1361
2211, 109, 1203, 118, 4, 1293, 3937, 1349, 163, 1209, 1208, 120, 113, 3966, 3955, 1362, 
1310, 1309, 3953, 1353, 167
2212, 1293, 3937, 1349, 163, 1297, 3938, 1350, 164, 3966, 3955, 1362, 1310, 3967, 3958, 1363, 
1319, 1318, 3956, 1355, 168
2213, 1297, 3938, 1350, 164, 1301, 3939, 1351, 165, 3967, 3958, 1363, 1319, 3968, 3961, 1364, 
1328, 1327, 3959, 1357, 169
2214, 1301, 3939, 1351, 165, 1305, 3940, 1352, 166, 3968, 3961, 1364, 1328, 3969, 3964, 1365, 
1337, 1336, 3962, 1359, 170
2215, 1305, 3940, 1352, 166, 133, 1220, 142, 8, 3969, 3964, 1365, 1337, 1226, 1224, 144, 
137, 1345, 3965, 1361, 171
2216, 1204, 98, 97, 1203, 3941, 1238, 1237, 3937, 1210, 102, 1207, 1211, 3971, 1255, 3954, 
3972, 3970, 1256, 1254, 3953
2217, 3941, 1238, 1237, 3937, 3942, 1242, 1241, 3938, 3971, 1255, 3954, 3972, 3974, 1264, 3957, 
3975, 3973, 1265, 1263, 3956
2218, 3942, 1242, 1241, 3938, 3943, 1246, 1245, 3939, 3974, 1264, 3957, 3975, 3977, 1273, 3960, 
3978, 3976, 1274, 1272, 3959
2219, 3943, 1246, 1245, 3939, 3944, 1250, 1249, 3940, 3977, 1273, 3960, 3978, 3980, 1282, 3963, 
3981, 3979, 1283, 1281, 3962
2220, 3944, 1250, 1249, 3940, 1221, 122, 121, 1220, 3980, 1282, 3963, 3981, 1228, 126, 1225, 
1227, 3982, 1290, 1289, 3965
2221, 110, 1204, 1203, 109, 1294, 3941, 3937, 1293, 1212, 1211, 1209, 114, 3983, 3972, 3966, 
1312, 1311, 3970, 3953, 1309
2222, 1294, 3941, 3937, 1293, 1298, 3942, 3938, 1297, 3983, 3972, 3966, 1312, 3984, 3975, 3967, 
1321, 1320, 3973, 3956, 1318
2223, 1298, 3942, 3938, 1297, 1302, 3943, 3939, 1301, 3984, 3975, 3967, 1321, 3985, 3978, 3968, 
1330, 1329, 3976, 3959, 1327
2224, 1302, 3943, 3939, 1301, 1306, 3944, 3940, 1305, 3985, 3978, 3968, 1330, 3986, 3981, 3969, 
1339, 1338, 3979, 3962, 1336
2225, 1306, 3944, 3940, 1305, 134, 1221, 1220, 133, 3986, 3981, 3969, 1339, 1229, 1227, 1226, 
138, 1346, 3982, 3965, 1345
2226, 1205, 99, 98, 1204, 3945, 1239, 1238, 3941, 1213, 103, 1210, 1214, 3988, 1257, 3971, 
3989, 3987, 1258, 1256, 3970
2227, 3945, 1239, 1238, 3941, 3946, 1243, 1242, 3942, 3988, 1257, 3971, 3989, 3991, 1266, 3974, 
3992, 3990, 1267, 1265, 3973
2228, 3946, 1243, 1242, 3942, 3947, 1247, 1246, 3943, 3991, 1266, 3974, 3992, 3994, 1275, 3977, 
3995, 3993, 1276, 1274, 3976
2229, 3947, 1247, 1246, 3943, 3948, 1251, 1250, 3944, 3994, 1275, 3977, 3995, 3997, 1284, 3980, 
3998, 3996, 1285, 1283, 3979
2230, 3948, 1251, 1250, 3944, 1222, 123, 122, 1221, 3997, 1284, 3980, 3998, 1231, 127, 1228, 
1230, 3999, 1291, 1290, 3982
2231, 111, 1205, 1204, 110, 1295, 3945, 3941, 1294, 1215, 1214, 1212, 115, 4000, 3989, 3983, 
1314, 1313, 3987, 3970, 1311
2232, 1295, 3945, 3941, 1294, 1299, 3946, 3942, 1298, 4000, 3989, 3983, 1314, 4001, 3992, 3984, 
1323, 1322, 3990, 3973, 1320
2233, 1299, 3946, 3942, 1298, 1303, 3947, 3943, 1302, 4001, 3992, 3984, 1323, 4002, 3995, 3985, 
1332, 1331, 3993, 3976, 1329
2234, 1303, 3947, 3943, 1302, 1307, 3948, 3944, 1306, 4002, 3995, 3985, 1332, 4003, 3998, 3986, 
1341, 1340, 3996, 3979, 1338
2235, 1307, 3948, 3944, 1306, 135, 1222, 1221, 134, 4003, 3998, 3986, 1341, 1232, 1230, 1229, 
139, 1347, 3999, 3982, 1346
2236, 1206, 100, 99, 1205, 3949, 1240, 1239, 3945, 1216, 104, 1213, 1217, 4005, 1259, 3988, 
4006, 4004, 1260, 1258, 3987
2237, 3949, 1240, 1239, 3945, 3950, 1244, 1243, 3946, 4005, 1259, 3988, 4006, 4008, 1268, 3991, 
4009, 4007, 1269, 1267, 3990
2238, 3950, 1244, 1243, 3946, 3951, 1248, 1247, 3947, 4008, 1268, 3991, 4009, 4011, 1277, 3994, 
4012, 4010, 1278, 1276, 3993
2239, 3951, 1248, 1247, 3947, 3952, 1252, 1251, 3948, 4011, 1277, 3994, 4012, 4014, 1286, 3997, 
4015, 4013, 1287, 1285, 3996
2240, 3952, 1252, 1251, 3948, 1223, 124, 123, 1222, 4014, 1286, 3997, 4015, 1234, 128, 1231, 
1233, 4016, 1292, 1291, 3999
2241, 112, 1206, 1205, 111, 1296, 3949, 3945, 1295, 1218, 1217, 1215, 116, 4017, 4006, 4000, 
1316, 1315, 4004, 3987, 1313
2242, 1296, 3949, 3945, 1295, 1300, 3950, 3946, 1299, 4017, 4006, 4000, 1316, 4018, 4009, 4001, 
1325, 1324, 4007, 3990, 1322
2243, 1300, 3950, 3946, 1299, 1304, 3951, 3947, 1303, 4018, 4009, 4001, 1325, 4019, 4012, 4002, 
1334, 1333, 4010, 3993, 1331
2244, 1304, 3951, 3947, 1303, 1308, 3952, 3948, 1307, 4019, 4012, 4002, 1334, 4020, 4015, 4003, 
1343, 1342, 4013, 3996, 1340
2245, 1308, 3952, 3948, 1307, 136, 1223, 1222, 135, 4020, 4015, 4003, 1343, 1235, 1233, 1232, 
140, 1348, 4016, 3999, 1347
2246, 106, 1, 100, 1206, 1366, 154, 1240, 3949, 107, 105, 1216, 1219, 1370, 1261, 4005, 
4021, 1371, 158, 1260, 4004
2247, 1366, 154, 1240, 3949, 1367, 155, 1244, 3950, 1370, 1261, 4005, 4021, 1372, 1270, 4008, 
4022, 1373, 159, 1269, 4007
2248, 1367, 155, 1244, 3950, 1368, 156, 1248, 3951, 1372, 1270, 4008, 4022, 1374, 1279, 4011, 
4023, 1375, 160, 1278, 4010
2249, 1368, 156, 1248, 3951, 1369, 157, 1252, 3952, 1374, 1279, 4011, 4023, 1376, 1288, 4014, 
4024, 1377, 161, 1287, 4013
2250, 1369, 157, 1252, 3952, 130, 5, 124, 1223, 1376, 1288, 4014, 4024, 131, 129, 1234, 
1236, 1378, 162, 1292, 4016
2251, 3, 106, 1206, 112, 172, 1366, 3949, 1296, 108, 1219, 1218, 117, 1379, 4021, 4017, 
1317, 176, 1371, 4004, 1315
2252, 172, 1366, 3949, 1296, 173, 1367, 3950, 1300, 1379, 4021, 4017, 1317, 1380, 4022, 4018, 
1326, 177, 1373, 4007, 1324
2253, 173, 1367, 3950, 1300, 174, 1368, 3951, 1304, 1380, 4022, 4018, 1326, 1381, 4023, 4019, 
1335, 178, 1375, 4010, 1333
2254, 174, 1368, 3951, 1304, 175, 1369, 3952, 1308, 1381, 4023, 4019, 1335, 1382, 4024, 4020, 
1344, 179, 1377, 4013, 1342
2255, 175, 1369, 3952, 1308, 7, 130, 1223, 136, 1382, 4024, 4020, 1344, 132, 1236, 1235, 
141, 180, 1378, 4016, 1348
*ELEMENT, type=C3D20, ELSET=Volume2
2256, 4, 109, 1293, 163, 10, 212, 1399, 183, 113, 1309, 1310, 167, 216, 1415, 1416, 
187, 182, 1395, 4025, 1383
2257, 109, 110, 1294, 1293, 212, 213, 1400, 1399, 114, 1311, 1312, 1309, 217, 1417, 1418, 
1415, 1395, 1396, 4026, 4025
2258, 110, 111, 1295, 1294, 213, 214, 1401, 1400, 115, 1313, 1314, 1311, 218, 1419, 1420, 
1417, 1396, 1397, 4027, 4026
2259, 111, 112, 1296, 1295, 214, 215, 1402, 1401, 116, 1315, 1316, 1313, 219, 1421, 1422, 
1419, 1397, 1398, 4028, 4027
2260, 112, 3, 172, 1296, 215, 12, 203, 1402, 117, 176, 1317, 1315, 220, 207, 1423, 
1421, 1398, 202, 1391, 4028
2261, 163, 1293, 1297, 164, 183, 1399, 1403, 184, 1310, 1318, 1319, 168, 1416, 1424, 1425, 
188, 1383, 4025, 4029, 1384
2262, 1293, 1294, 1298, 1297, 1399, 1400, 1404, 1403, 1312, 1320, 1321, 1318, 1418, 1426, 1427, 
1424, 4025, 4026, 4030, 4029
2263, 1294, 1295, 1299, 1298, 1400, 1401, 1405, 1404, 1314, 1322, 1323, 1320, 1420, 1428, 1429, 
1426, 4026, 4027, 4031, 4030
2264, 1295, 1296, 1300, 1299, 1401, 1402, 1406, 1405, 1316, 1324, 1325, 1322, 1422, 1430, 1431, 
1428, 4027, 4028, 4032, 4031
2265, 1296, 172, 173, 1300, 1402, 203, 204, 1406, 1317, 177, 1326, 1324, 1423, 208, 1432, 
1430, 4028, 1391, 1392, 4032
2266, 164, 1297, 1301, 165, 184, 1403, 1407, 185, 1319, 1327, 1328, 169, 1425, 1433, 1434, 
189, 1384, 4029, 4033, 1385
2267, 1297, 1298, 1302, 1301, 1403, 1404, 1408, 1407, 1321, 1329, 1330, 1327, 1427, 1435, 1436, 
1433, 4029, 4030, 4034, 4033
2268, 1298, 1299, 1303, 1302, 1404, 1405, 1409, 1408, 1323, 1331, 1332, 1329, 1429, 1437, 1438, 
1435, 4030, 4031, 4035, 4034
2269, 1299, 1300, 1304, 1303, 1405, 1406, 1410, 1409, 1325, 1333, 1334, 1331, 1431, 1439, 1440, 
1437, 4031, 4032, 4036, 4035
2270, 1300, 173, 174, 1304, 1406, 204, 205, 1410, 1326, 178, 1335, 1333, 1432, 209, 1441, 
1439, 4032, 1392, 1393, 4036
2271, 165, 1301, 1305, 166, 185, 1407, 1411, 186, 1328, 1336, 1337, 170, 1434, 1442, 1443, 
190, 1385, 4033, 4037, 1386
2272, 1301, 1302, 1306, 1305, 1407, 1408, 1412, 1411, 1330, 1338, 1339, 1336, 1436, 1444, 1445, 
1442, 4033, 4034, 4038, 4037
2273, 1302, 1303, 1307, 1306, 1408, 1409, 1413, 1412, 1332, 1340, 1341, 1338, 1438, 1446, 1447, 
1444, 4034, 4035, 4039, 4038
2274, 1303, 1304, 1308, 1307, 1409, 1410, 1414, 1413, 1334, 1342, 1343, 1340, 1440, 1448, 1449, 
1446, 4035, 4036, 4040, 4039
2275, 1304, 174, 175, 1308, 1410, 205, 206, 1414, 1335, 179, 1344, 1342, 1441, 210, 1450, 
1448, 4036, 1393, 1394, 4040
2276, 166, 1305, 133, 8, 186, 1411, 193, 9, 1337, 1345, 137, 171, 1443, 1451, 197, 
191, 1386, 4037, 1387, 181
2277, 1305, 1306, 134, 133, 1411, 1412, 194, 193, 1339, 1346, 138, 1345, 1445, 1452, 198, 
1451, 4037, 4038, 1388, 1387
2278, 1306, 1307, 135, 134, 1412, 1413, 195, 194, 1341, 1347, 139, 1346, 1447, 1453, 199, 
1452, 4038, 4039, 1389, 1388
2279, 1307, 1308, 136, 135, 1413, 1414, 196, 195, 1343, 1348, 140, 1347, 1449, 1454, 200, 
1453, 4039, 4040, 1390, 1389
2280, 1308, 175, 7, 136, 1414, 206, 11, 196, 1344, 180, 141, 1348, 1450, 211, 201, 
1454, 4040, 1394, 192, 1390
*ELEMENT, type=C3D20, ELSET=Volume3
2281, 10, 212, 1399, 183, 230, 1623, 4041, 1455, 216, 1415, 1416, 187, 1640, 4106, 4107, 
1471, 234, 1639, 4105, 1472
2282, 230, 1623, 4041, 1455, 231, 1624, 4042, 1456, 1640, 4106, 4107, 1471, 1642, 4109, 4110, 
1473, 235, 1641, 4108, 1474
2283, 231, 1624, 4042, 1456, 232, 1625, 4043, 1457, 1642, 4109, 4110, 1473, 1644, 4112, 4113, 
1475, 236, 1643, 4111, 1476
2284, 232, 1625, 4043, 1457, 233, 1626, 4044, 1458, 1644, 4112, 4113, 1475, 1646, 4115, 4116, 
1477, 237, 1645, 4114, 1478
2285, 233, 1626, 4044, 1458, 14, 284, 1679, 239, 1646, 4115, 4116, 1477, 288, 1695, 1696, 
243, 238, 1647, 4117, 1479
2286, 212, 213, 1400, 1399, 1623, 1627, 4045, 4041, 217, 1417, 1418, 1415, 1649, 4119, 4120, 
4106, 1639, 1648, 4118, 4105
2287, 1623, 1627, 4045, 4041, 1624, 1628, 4046, 4042, 1649, 4119, 4120, 4106, 1651, 4122, 4123, 
4109, 1641, 1650, 4121, 4108
2288, 1624, 1628, 4046, 4042, 1625, 1629, 4047, 4043, 1651, 4122, 4123, 4109, 1653, 4125, 4126, 
4112, 1643, 1652, 4124, 4111
2289, 1625, 1629, 4047, 4043, 1626, 1630, 4048, 4044, 1653, 4125, 4126, 4112, 1655, 4128, 4129, 
4115, 1645, 1654, 4127, 4114
2290, 1626, 1630, 4048, 4044, 284, 285, 1680, 1679, 1655, 4128, 4129, 4115, 289, 1697, 1698, 
1695, 1647, 1656, 4130, 4117
2291, 213, 214, 1401, 1400, 1627, 1631, 4049, 4045, 218, 1419, 1420, 1417, 1658, 4132, 4133, 
4119, 1648, 1657, 4131, 4118
2292, 1627, 1631, 4049, 4045, 1628, 1632, 4050, 4046, 1658, 4132, 4133, 4119, 1660, 4135, 4136, 
4122, 1650, 1659, 4134, 4121
2293, 1628, 1632, 4050, 4046, 1629, 1633, 4051, 4047, 1660, 4135, 4136, 4122, 1662, 4138, 4139, 
4125, 1652, 1661, 4137, 4124
2294, 1629, 1633, 4051, 4047, 1630, 1634, 4052, 4048, 1662, 4138, 4139, 4125, 1664, 4141, 4142, 
4128, 1654, 1663, 4140, 4127
2295, 1630, 1634, 4052, 4048, 285, 286, 1681, 1680, 1664, 4141, 4142, 4128, 290, 1699, 1700, 
1697, 1656, 1665, 4143, 4130
2296, 214, 215, 1402, 1401, 1631, 1635, 4053, 4049, 219, 1421, 1422, 1419, 1667, 4145, 4146, 
4132, 1657, 1666, 4144, 4131
2297, 1631, 1635, 4053, 4049, 1632, 1636, 4054, 4050, 1667, 4145, 4146, 4132, 1669, 4148, 4149, 
4135, 1659, 1668, 4147, 4134
2298, 1632, 1636, 4054, 4050, 1633, 1637, 4055, 4051, 1669, 4148, 4149, 4135, 1671, 4151, 4152, 
4138, 1661, 1670, 4150, 4137
2299, 1633, 1637, 4055, 4051, 1634, 1638, 4056, 4052, 1671, 4151, 4152, 4138, 1673, 4154, 4155, 
4141, 1663, 1672, 4153, 4140
2300, 1634, 1638, 4056, 4052, 286, 287, 1682, 1681, 1673, 4154, 4155, 4141, 291, 1701, 1702, 
1699, 1665, 1674, 4156, 4143
2301, 215, 12, 203, 1402, 1635, 266, 1567, 4053, 220, 207, 1423, 1421, 1675, 1584, 4157, 
4145, 1666, 270, 1583, 4144
2302, 1635, 266, 1567, 4053, 1636, 267, 1568, 4054, 1675, 1584, 4157, 4145, 1676, 1586, 4158, 
4148, 1668, 271, 1585, 4147
2303, 1636, 267, 1568, 4054, 1637, 268, 1569, 4055, 1676, 1586, 4158, 4148, 1677, 1588, 4159, 
4151, 1670, 272, 1587, 4150
2304, 1637, 268, 1569, 4055, 1638, 269, 1570, 4056, 1677, 1588, 4159, 4151, 1678, 1590, 4160, 
4154, 1672, 273, 1589, 4153
2305, 1638, 269, 1570, 4056, 287, 16, 275, 1682, 1678, 1590, 4160, 4154, 292, 279, 1703, 
1701, 1674, 274, 1591, 4156
2306, 183, 1399, 1403, 184, 1455, 4041, 4057, 1459, 1416, 1424, 1425, 188, 4107, 4162, 4163, 
1480, 1472, 4105, 4161, 1481
2307, 1455, 4041, 4057, 1459, 1456, 4042, 4058, 1460, 4107, 4162, 4163, 1480, 4110, 4165, 4166, 
1482, 1474, 4108, 4164, 1483
2308, 1456, 4042, 4058, 1460, 1457, 4043, 4059, 1461, 4110, 4165, 4166, 1482, 4113, 4168, 4169, 
1484, 1476, 4111, 4167, 1485
2309, 1457, 4043, 4059, 1461, 1458, 4044, 4060, 1462, 4113, 4168, 4169, 1484, 4116, 4171, 4172, 
1486, 1478, 4114, 4170, 1487
2310, 1458, 4044, 4060, 1462, 239, 1679, 1683, 240, 4116, 4171, 4172, 1486, 1696, 1704, 1705, 
244, 1479, 4117, 4173, 1488
2311, 1399, 1400, 1404, 1403, 4041, 4045, 4061, 4057, 1418, 1426, 1427, 1424, 4120, 4175, 4176, 
4162, 4105, 4118, 4174, 4161
2312, 4041, 4045, 4061, 4057, 4042, 4046, 4062, 4058, 4120, 4175, 4176, 4162, 4123, 4178, 4179, 
4165, 4108, 4121, 4177, 4164
2313, 4042, 4046, 4062, 4058, 4043, 4047, 4063, 4059, 4123, 4178, 4179, 4165, 4126, 4181, 4182, 
4168, 4111, 4124, 4180, 4167
2314, 4043, 4047, 4063, 4059, 4044, 4048, 4064, 4060, 4126, 4181, 4182, 4168, 4129, 4184, 4185, 
4171, 4114, 4127, 4183, 4170
2315, 4044, 4048, 4064, 4060, 1679, 1680, 1684, 1683, 4129, 4184, 4185, 4171, 1698, 1706, 1707, 
1704, 4117, 4130, 4186, 4173
2316, 1400, 1401, 1405, 1404, 4045, 4049, 4065, 4061, 1420, 1428, 1429, 1426, 4133, 4188, 4189, 
4175, 4118, 4131, 4187, 4174
2317, 4045, 4049, 4065, 4061, 4046, 4050, 4066, 4062, 4133, 4188, 4189, 4175, 4136, 4191, 4192, 
4178, 4121, 4134, 4190, 4177
2318, 4046, 4050, 4066, 4062, 4047, 4051, 4067, 4063, 4136, 4191, 4192, 4178, 4139, 4194, 4195, 
4181, 4124, 4137, 4193, 4180
2319, 4047, 4051, 4067, 4063, 4048, 4052, 4068, 4064, 4139, 4194, 4195, 4181, 4142, 4197, 4198, 
4184, 4127, 4140, 4196, 4183
2320, 4048, 4052, 4068, 4064, 1680, 1681, 1685, 1684, 4142, 4197, 4198, 4184, 1700, 1708, 1709, 
1706, 4130, 4143, 4199, 4186
2321, 1401, 1402, 1406, 1405, 4049, 4053, 4069, 4065, 1422, 1430, 1431, 1428, 4146, 4201, 4202, 
4188, 4131, 4144, 4200, 4187
2322, 4049, 4053, 4069, 4065, 4050, 4054, 4070, 4066, 4146, 4201, 4202, 4188, 4149, 4204, 4205, 
4191, 4134, 4147, 4203, 4190
2323, 4050, 4054, 4070, 4066, 4051, 4055, 4071, 4067, 4149, 4204, 4205, 4191, 4152, 4207, 4208, 
4194, 4137, 4150, 4206, 4193
2324, 4051, 4055, 4071, 4067, 4052, 4056, 4072, 4068, 4152, 4207, 4208, 4194, 4155, 4210, 4211, 
4197, 4140, 4153, 4209, 4196
2325, 4052, 4056, 4072, 4068, 1681, 1682, 1686, 1685, 4155, 4210, 4211, 4197, 1702, 1710, 1711, 
1708, 4143, 4156, 4212, 4199
2326, 1402, 203, 204, 1406, 4053, 1567, 1571, 4069, 1423, 208, 1432, 1430, 4157, 1593, 4213, 
4201, 4144, 1583, 1592, 4200
2327, 4053, 1567, 1571, 4069, 4054, 1568, 1572, 4070, 4157, 1593, 4213, 4201, 4158, 1595, 4214, 
4204, 4147, 1585, 1594, 4203
2328, 4054, 1568, 1572, 4070, 4055, 1569, 1573, 4071, 4158, 1595, 4214, 4204, 4159, 1597, 4215, 
4207, 4150, 1587, 1596, 4206
2329, 4055, 1569, 1573, 4071, 4056, 1570, 1574, 4072, 4159, 1597, 4215, 4207, 4160, 1599, 4216, 
4210, 4153, 1589, 1598, 4209
2330, 4056, 1570, 1574, 4072, 1682, 275, 276, 1686, 4160, 1599, 4216, 4210, 1703, 280, 1712, 
1710, 4156, 1591, 1600, 4212
2331, 184, 1403, 1407, 185, 1459, 4057, 4073, 1463, 1425, 1433, 1434, 189, 4163, 4218, 4219, 
1489, 1481, 4161, 4217, 1490
2332, 1459, 4057, 4073, 1463, 1460, 4058, 4074, 1464, 4163, 4218, 4219, 1489, 4166, 4221, 4222, 
1491, 1483, 4164, 4220, 1492
2333, 1460, 4058, 4074, 1464, 1461, 4059, 4075, 1465, 4166, 4221, 4222, 1491, 4169, 4224, 4225, 
1493, 1485, 4167, 4223, 1494
2334, 1461, 4059, 4075, 1465, 1462, 4060, 4076, 1466, 4169, 4224, 4225, 1493, 4172, 4227, 4228, 
1495, 1487, 4170, 4226, 1496
2335, 1462, 4060, 4076, 1466, 240, 1683, 1687, 241, 4172, 4227, 4228, 1495, 1705, 1713, 1714, 
245, 1488, 4173, 4229, 1497
2336, 1403, 1404, 1408, 1407, 4057, 4061, 4077, 4073, 1427, 1435, 1436, 1433, 4176, 4231, 4232, 
4218, 4161, 4174, 4230, 4217
2337, 4057, 4061, 4077, 4073, 4058, 4062, 4078, 4074, 4176, 4231, 4232, 4218, 4179, 4234, 4235, 
4221, 4164, 4177, 4233, 4220
2338, 4058, 4062, 4078, 4074, 4059, 4063, 4079, 4075, 4179, 4234, 4235, 4221, 4182, 4237, 4238, 
4224, 4167, 4180, 4236, 4223
2339, 4059, 4063, 4079, 4075, 4060, 4064, 4080, 4076, 4182, 4237, 4238, 4224, 4185, 4240, 4241, 
4227, 4170, 4183, 4239, 4226
2340, 4060, 4064, 4080, 4076, 1683, 1684, 1688, 1687, 4185, 4240, 4241, 4227, 1707, 1715, 1716, 
1713, 4173, 4186, 4242, 4229
2341, 1404, 1405, 1409, 1408, 4061, 4065, 4081, 4077, 1429, 1437, 1438, 1435, 4189, 4244, 4245, 
4231, 4174, 4187, 4243, 4230
2342, 4061, 4065, 4081, 4077, 4062, 4066, 4082, 4078, 4189, 4244, 4245, 4231, 4192, 4247, 4248, 
4234, 4177, 4190, 4246, 4233
2343, 4062, 4066, 4082, 4078, 4063, 4067, 4083, 4079, 4192, 4247, 4248, 4234, 4195, 4250, 4251, 
4237, 4180, 4193, 4249, 4236
2344, 4063, 4067, 4083, 4079, 4064, 4068, 4084, 4080, 4195, 4250, 4251, 4237, 4198, 4253, 4254, 
4240, 4183, 4196, 4252, 4239
2345, 4064, 4068, 4084, 4080, 1684, 1685, 1689, 1688, 4198, 4253, 4254, 4240, 1709, 1717, 1718, 
1715, 4186, 4199, 4255, 4242
2346, 1405, 1406, 1410, 1409, 4065, 4069, 4085, 4081, 1431, 1439, 1440, 1437, 4202, 4257, 4258, 
4244, 4187, 4200, 4256, 4243
2347, 4065, 4069, 4085, 4081, 4066, 4070, 4086, 4082, 4202, 4257, 4258, 4244, 4205, 4260, 4261, 
4247, 4190, 4203, 4259, 4246
2348, 4066, 4070, 4086, 4082, 4067, 4071, 4087, 4083, 4205, 4260, 4261, 4247, 4208, 4263, 4264, 
4250, 4193, 4206, 4262, 4249
2349, 4067, 4071, 4087, 4083, 4068, 4072, 4088, 4084, 4208, 4263, 4264, 4250, 4211, 4266, 4267, 
4253, 4196, 4209, 4265, 4252
2350, 4068, 4072, 4088, 4084, 1685, 1686, 1690, 1689, 4211, 4266, 4267, 4253, 1711, 1719, 1720, 
1717, 4199, 4212, 4268, 4255
2351, 1406, 204, 205, 1410, 4069, 1571, 1575, 4085, 1432, 209, 1441, 1439, 4213, 1602, 4269, 
4257, 4200, 1592, 1601, 4256
2352, 4069, 1571, 1575, 4085, 4070, 1572, 1576, 4086, 4213, 1602, 4269, 4257, 4214, 1604, 4270, 
4260, 4203, 1594, 1603, 4259
2353, 4070, 1572, 1576, 4086, 4071, 1573, 1577, 4087, 4214, 1604, 4270, 4260, 4215, 1606, 4271, 
4263, 4206, 1596, 1605, 4262
2354, 4071, 1573, 1577, 4087, 4072, 1574, 1578, 4088, 4215, 1606, 4271, 4263, 4216, 1608, 4272, 
4266, 4209, 1598, 1607, 4265
2355, 4072, 1574, 1578, 4088, 1686, 276, 277, 1690, 4216, 1608, 4272, 4266, 1712, 281, 1721, 
1719, 4212, 1600, 1609, 4268
2356, 185, 1407, 1411, 186, 1463, 4073, 4089, 1467, 1434, 1442, 1443, 190, 4219, 4274, 4275, 
1498, 1490, 4217, 4273, 1499
2357, 1463, 4073, 4089, 1467, 1464, 4074, 4090, 1468, 4219, 4274, 4275, 1498, 4222, 4277, 4278, 
1500, 1492, 4220, 4276, 1501
2358, 1464, 4074, 4090, 1468, 1465, 4075, 4091, 1469, 4222, 4277, 4278, 1500, 4225, 4280, 4281, 
1502, 1494, 4223, 4279, 1503
2359, 1465, 4075, 4091, 1469, 1466, 4076, 4092, 1470, 4225, 4280, 4281, 1502, 4228, 4283, 4284, 
1504, 1496, 4226, 4282, 1505
2360, 1466, 4076, 4092, 1470, 241, 1687, 1691, 242, 4228, 4283, 4284, 1504, 1714, 1722, 1723, 
246, 1497, 4229, 4285, 1506
2361, 1407, 1408, 1412, 1411, 4073, 4077, 4093, 4089, 1436, 1444, 1445, 1442, 4232, 4287, 4288, 
4274, 4217, 4230, 4286, 4273
2362, 4073, 4077, 4093, 4089, 4074, 4078, 4094, 4090, 4232, 4287, 4288, 4274, 4235, 4290, 4291, 
4277, 4220, 4233, 4289, 4276
2363, 4074, 4078, 4094, 4090, 4075, 4079, 4095, 4091, 4235, 4290, 4291, 4277, 4238, 4293, 4294, 
4280, 4223, 4236, 4292, 4279
2364, 4075, 4079, 4095, 4091, 4076, 4080, 4096, 4092, 4238, 4293, 4294, 4280, 4241, 4296, 4297, 
4283, 4226, 4239, 4295, 4282
2365, 4076, 4080, 4096, 4092, 1687, 1688, 1692, 1691, 4241, 4296, 4297, 4283, 1716, 1724, 1725, 
1722, 4229, 4242, 4298, 4285
2366, 1408, 1409, 1413, 1412, 4077, 4081, 4097, 4093, 1438, 1446, 1447, 1444, 4245, 4300, 4301, 
4287, 4230, 4243, 4299, 4286
2367, 4077, 4081, 4097, 4093, 4078, 4082, 4098, 4094, 4245, 4300, 4301, 4287, 4248, 4303, 4304, 
4290, 4233, 4246, 4302, 4289
2368, 4078, 4082, 4098, 4094, 4079, 4083, 4099, 4095, 4248, 4303, 4304, 4290, 4251, 4306, 4307, 
4293, 4236, 4249, 4305, 4292
2369, 4079, 4083, 4099, 4095, 4080, 4084, 4100, 4096, 4251, 4306, 4307, 4293, 4254, 4309, 4310, 
4296, 4239, 4252, 4308, 4295
2370, 4080, 4084, 4100, 4096, 1688, 1689, 1693, 1692, 4254, 4309, 4310, 4296, 1718, 1726, 1727, 
1724, 4242, 4255, 4311, 4298
2371, 1409, 1410, 1414, 1413, 4081, 4085, 4101, 4097, 1440, 1448, 1449, 1446, 4258, 4313, 4314, 
4300, 4243, 4256, 4312, 4299
2372, 4081, 4085, 4101, 4097, 4082, 4086, 4102, 4098, 4258, 4313, 4314, 4300, 4261, 4316, 4317, 
4303, 4246, 4259, 4315, 4302
2373, 4082, 4086, 4102, 4098, 4083, 4087, 4103, 4099, 4261, 4316, 4317, 4303, 4264, 4319, 4320, 
4306, 4249, 4262, 4318, 4305
2374, 4083, 4087, 4103, 4099, 4084, 4088, 4104, 4100, 4264, 4319, 4320, 4306, 4267, 4322, 4323, 
4309, 4252, 4265, 4321, 4308
2375, 4084, 4088, 4104, 4100, 1689, 1690, 1694, 1693, 4267, 4322, 4323, 4309, 1720, 1728, 1729, 
1726, 4255, 4268, 4324, 4311
2376, 1410, 205, 206, 1414, 4085, 1575, 1579, 4101, 1441, 210, 1450, 1448, 4269, 1611, 4325, 
4313, 4256, 1601, 1610, 4312
2377, 4085, 1575, 1579, 4101, 4086, 1576, 1580, 4102, 4269, 1611, 4325, 4313, 4270, 1613, 4326, 
4316, 4259, 1603, 1612, 4315
2378, 4086, 1576, 1580, 4102, 4087, 1577, 1581, 4103, 4270, 1613, 4326, 4316, 4271, 1615, 4327, 
4319, 4262, 1605, 1614, 4318
2379, 4087, 1577, 1581, 4103, 4088, 1578, 1582, 4104, 4271, 1615, 4327, 4319, 4272, 1617, 4328, 
4322, 4265, 1607, 1616, 4321
2380, 4088, 1578, 1582, 4104, 1690, 277, 278, 1694, 4272, 1617, 4328, 4322, 1721, 282, 1730, 
1728, 4268, 1609, 1618, 4324
2381, 186, 1411, 193, 9, 1467, 4089, 1511, 221, 1443, 1451, 197, 191, 4275, 4329, 1527, 
1507, 1499, 4273, 1528, 225
2382, 1467, 4089, 1511, 221, 1468, 4090, 1512, 222, 4275, 4329, 1527, 1507, 4278, 4330, 1529, 
1508, 1501, 4276, 1530, 226
2383, 1468, 4090, 1512, 222, 1469, 4091, 1513, 223, 4278, 4330, 1529, 1508, 4281, 4331, 1531, 
1509, 1503, 4279, 1532, 227
2384, 1469, 4091, 1513, 223, 1470, 4092, 1514, 224, 4281, 4331, 1531, 1509, 4284, 4332, 1533, 
1510, 1505, 4282, 1534, 228
2385, 1470, 4092, 1514, 224, 242, 1691, 257, 13, 4284, 4332, 1533, 1510, 1723, 1731, 261, 
247, 1506, 4285, 1535, 229
2386, 1411, 1412, 194, 193, 4089, 4093, 1515, 1511, 1445, 1452, 198, 1451, 4288, 4333, 1536, 
4329, 4273, 4286, 1537, 1528
2387, 4089, 4093, 1515, 1511, 4090, 4094, 1516, 1512, 4288, 4333, 1536, 4329, 4291, 4334, 1538, 
4330, 4276, 4289, 1539, 1530
2388, 4090, 4094, 1516, 1512, 4091, 4095, 1517, 1513, 4291, 4334, 1538, 4330, 4294, 4335, 1540, 
4331, 4279, 4292, 1541, 1532
2389, 4091, 4095, 1517, 1513, 4092, 4096, 1518, 1514, 4294, 4335, 1540, 4331, 4297, 4336, 1542, 
4332, 4282, 4295, 1543, 1534
2390, 4092, 4096, 1518, 1514, 1691, 1692, 258, 257, 4297, 4336, 1542, 4332, 1725, 1732, 262, 
1731, 4285, 4298, 1544, 1535
2391, 1412, 1413, 195, 194, 4093, 4097, 1519, 1515, 1447, 1453, 199, 1452, 4301, 4337, 1545, 
4333, 4286, 4299, 1546, 1537
2392, 4093, 4097, 1519, 1515, 4094, 4098, 1520, 1516, 4301, 4337, 1545, 4333, 4304, 4338, 1547, 
4334, 4289, 4302, 1548, 1539
2393, 4094, 4098, 1520, 1516, 4095, 4099, 1521, 1517, 4304, 4338, 1547, 4334, 4307, 4339, 1549, 
4335, 4292, 4305, 1550, 1541
2394, 4095, 4099, 1521, 1517, 4096, 4100, 1522, 1518, 4307, 4339, 1549, 4335, 4310, 4340, 1551, 
4336, 4295, 4308, 1552, 1543
2395, 4096, 4100, 1522, 1518, 1692, 1693, 259, 258, 4310, 4340, 1551, 4336, 1727, 1733, 263, 
1732, 4298, 4311, 1553, 1544
2396, 1413, 1414, 196, 195, 4097, 4101, 1523, 1519, 1449, 1454, 200, 1453, 4314, 4341, 1554, 
4337, 4299, 4312, 1555, 1546
2397, 4097, 4101, 1523, 1519, 4098, 4102, 1524, 1520, 4314, 4341, 1554, 4337, 4317, 4342, 1556, 
4338, 4302, 4315, 1557, 1548
2398, 4098, 4102, 1524, 1520, 4099, 4103, 1525, 1521, 4317, 4342, 1556, 4338, 4320, 4343, 1558, 
4339, 4305, 4318, 1559, 1550
2399, 4099, 4103, 1525, 1521, 4100, 4104, 1526, 1522, 4320, 4343, 1558, 4339, 4323, 4344, 1560, 
4340, 4308, 4321, 1561, 1552
2400, 4100, 4104, 1526, 1522, 1693, 1694, 260, 259, 4323, 4344, 1560, 4340, 1729, 1734, 264, 
1733, 4311, 4324, 1562, 1553
2401, 1414, 206, 11, 196, 4101, 1579, 248, 1523, 1450, 211, 201, 1454, 4325, 1619, 1563, 
4341, 4312, 1610, 252, 1555
2402, 4101, 1579, 248, 1523, 4102, 1580, 249, 1524, 4325, 1619, 1563, 4341, 4326, 1620, 1564, 
4342, 4315, 1612, 253, 1557
2403, 4102, 1580, 249, 1524, 4103, 1581, 250, 1525, 4326, 1620, 1564, 4342, 4327, 1621, 1565, 
4343, 4318, 1614, 254, 1559
2404, 4103, 1581, 250, 1525, 4104, 1582, 251, 1526, 4327, 1621, 1565, 4343, 4328, 1622, 1566, 
4344, 4321, 1616, 255, 1561
2405, 4104, 1582, 251, 1526, 1694, 278, 15, 260, 4328, 1622, 1566, 4344, 1730, 283, 265, 
1734, 4324, 1618, 256, 1562
*ELEMENT, type=C3D20, ELSET=Volume4
2406, 14, 284, 1679, 239, 18, 324, 1751, 295, 288, 1695, 1696, 243, 328, 1767, 1768, 
299, 294, 1747, 4345, 1735
2407, 284, 285, 1680, 1679, 324, 325, 1752, 1751, 289, 1697, 1698, 1695, 329, 1769, 1770, 
1767, 1747, 1748, 4346, 4345
2408, 285, 286, 1681, 1680, 325, 326, 1753, 1752, 290, 1699, 1700, 1697, 330, 1771, 1772, 
1769, 1748, 1749, 4347, 4346
2409, 286, 287, 1682, 1681, 326, 327, 1754, 1753, 291, 1701, 1702, 1699, 331, 1773, 1774, 
1771, 1749, 1750, 4348, 4347
2410, 287, 16, 275, 1682, 327, 20, 315, 1754, 292, 279, 1703, 1701, 332, 319, 1775, 
1773, 1750, 314, 1743, 4348
2411, 239, 1679, 1683, 240, 295, 1751, 1755, 296, 1696, 1704, 1705, 244, 1768, 1776, 1777, 
300, 1735, 4345, 4349, 1736
2412, 1679, 1680, 1684, 1683, 1751, 1752, 1756, 1755, 1698, 1706, 1707, 1704, 1770, 1778, 1779, 
1776, 4345, 4346, 4350, 4349
2413, 1680, 1681, 1685, 1684, 1752, 1753, 1757, 1756, 1700, 1708, 1709, 1706, 1772, 1780, 1781, 
1778, 4346, 4347, 4351, 4350
2414, 1681, 1682, 1686, 1685, 1753, 1754, 1758, 1757, 1702, 1710, 1711, 1708, 1774, 1782, 1783, 
1780, 4347, 4348, 4352, 4351
2415, 1682, 275, 276, 1686, 1754, 315, 316, 1758, 1703, 280, 1712, 1710, 1775, 320, 1784, 
1782, 4348, 1743, 1744, 4352
2416, 240, 1683, 1687, 241, 296, 1755, 1759, 297, 1705, 1713, 1714, 245, 1777, 1785, 1786, 
301, 1736, 4349, 4353, 1737
2417, 1683, 1684, 1688, 1687, 1755, 1756, 1760, 1759, 1707, 1715, 1716, 1713, 1779, 1787, 1788, 
1785, 4349, 4350, 4354, 4353
2418, 1684, 1685, 1689, 1688, 1756, 1757, 1761, 1760, 1709, 1717, 1718, 1715, 1781, 1789, 1790, 
1787, 4350, 4351, 4355, 4354
2419, 1685, 1686, 1690, 1689, 1757, 1758, 1762, 1761, 1711, 1719, 1720, 1717, 1783, 1791, 1792, 
1789, 4351, 4352, 4356, 4355
2420, 1686, 276, 277, 1690, 1758, 316, 317, 1762, 1712, 281, 1721, 1719, 1784, 321, 1793, 
1791, 4352, 1744, 1745, 4356
2421, 241, 1687, 1691, 242, 297, 1759, 1763, 298, 1714, 1722, 1723, 246, 1786, 1794, 1795, 
302, 1737, 4353, 4357, 1738
2422, 1687, 1688, 1692, 1691, 1759, 1760, 1764, 1763, 1716, 1724, 1725, 1722, 1788, 1796, 1797, 
1794, 4353, 4354, 4358, 4357
2423, 1688, 1689, 1693, 1692, 1760, 1761, 1765, 1764, 1718, 1726, 1727, 1724, 1790, 1798, 1799, 
1796, 4354, 4355, 4359, 4358
2424, 1689, 1690, 1694, 1693, 1761, 1762, 1766, 1765, 1720, 1728, 1729, 1726, 1792, 1800, 1801, 
1798, 4355, 4356, 4360, 4359
2425, 1690, 277, 278, 1694, 1762, 317, 318, 1766, 1721, 282, 1730, 1728, 1793, 322, 1802, 
1800, 4356, 1745, 1746, 4360
2426, 242, 1691, 257, 13, 298, 1763, 305, 17, 1723, 1731, 261, 247, 1795, 1803, 309, 
303, 1738, 4357, 1739, 293
2427, 1691, 1692, 258, 257, 1763, 1764, 306, 305, 1725, 1732, 262, 1731, 1797, 1804, 310, 
1803, 4357, 4358, 1740, 1739
2428, 1692, 1693, 259, 258, 1764, 1765, 307, 306, 1727, 1733, 263, 1732, 1799, 1805, 311, 
1804, 4358, 4359, 1741, 1740
2429, 1693, 1694, 260, 259, 1765, 1766, 308, 307, 1729, 1734, 264, 1733, 1801, 1806, 312, 
1805, 4359, 4360, 1742, 1741
2430, 1694, 278, 15, 260, 1766, 318, 19, 308, 1730, 283, 265, 1734, 1802, 323, 313, 
1806, 4360, 1746, 304, 1742
*ELEMENT, type=C3D20, ELSET=Volume5
2431, 18, 324, 1751, 295, 336, 1858, 4361, 1807, 328, 1767, 1768, 299, 1863, 4378, 4379, 
1811, 337, 1862, 4377, 1812
2432, 336, 1858, 4361, 1807, 22, 372, 1875, 339, 1863, 4378, 4379, 1811, 376, 1891, 1892, 
343, 338, 1864, 4380, 1813
2433, 324, 325, 1752, 1751, 1858, 1859, 4362, 4361, 329, 1769, 1770, 1767, 1866, 4382, 4383, 
4378, 1862, 1865, 4381, 4377
2434, 1858, 1859, 4362, 4361, 372, 373, 1876, 1875, 1866, 4382, 4383, 4378, 377, 1893, 1894, 
1891, 1864, 1867, 4384, 4380
2435, 325, 326, 1753, 1752, 1859, 1860, 4363, 4362, 330, 1771, 1772, 1769, 1869, 4386, 4387, 
4382, 1865, 1868, 4385, 4381
2436, 1859, 1860, 4363, 4362, 373, 374, 1877, 1876, 1869, 4386, 4387, 4382, 378, 1895, 1896, 
1893, 1867, 1870, 4388, 4384
2437, 326, 327, 1754, 1753, 1860, 1861, 4364, 4363, 331, 1773, 1774, 1771, 1872, 4390, 4391, 
4386, 1868, 1871, 4389, 4385
2438, 1860, 1861, 4364, 4363, 374, 375, 1878, 1877, 1872, 4390, 4391, 4386, 379, 1897, 1898, 
1895, 1870, 1873, 4392, 4388
2439, 327, 20, 315, 1754, 1861, 360, 1841, 4364, 332, 319, 1775, 1773, 1874, 1846, 4393, 
4390, 1871, 361, 1845, 4389
2440, 1861, 360, 1841, 4364, 375, 24, 363, 1878, 1874, 1846, 4393, 4390, 380, 367, 1899, 
1897, 1873, 362, 1847, 4392
2441, 295, 1751, 1755, 296, 1807, 4361, 4365, 1808, 1768, 1776, 1777, 300, 4379, 4395, 4396, 
1814, 1812, 4377, 4394, 1815
2442, 1807, 4361, 4365, 1808, 339, 1875, 1879, 340, 4379, 4395, 4396, 1814, 1892, 1900, 1901, 
344, 1813, 4380, 4397, 1816
2443, 1751, 1752, 1756, 1755, 4361, 4362, 4366, 4365, 1770, 1778, 1779, 1776, 4383, 4399, 4400, 
4395, 4377, 4381, 4398, 4394
2444, 4361, 4362, 4366, 4365, 1875, 1876, 1880, 1879, 4383, 4399, 4400, 4395, 1894, 1902, 1903, 
1900, 4380, 4384, 4401, 4397
2445, 1752, 1753, 1757, 1756, 4362, 4363, 4367, 4366, 1772, 1780, 1781, 1778, 4387, 4403, 4404, 
4399, 4381, 4385, 4402, 4398
2446, 4362, 4363, 4367, 4366, 1876, 1877, 1881, 1880, 4387, 4403, 4404, 4399, 1896, 1904, 1905, 
1902, 4384, 4388, 4405, 4401
2447, 1753, 1754, 1758, 1757, 4363, 4364, 4368, 4367, 1774, 1782, 1783, 1780, 4391, 4407, 4408, 
4403, 4385, 4389, 4406, 4402
2448, 4363, 4364, 4368, 4367, 1877, 1878, 1882, 1881, 4391, 4407, 4408, 4403, 1898, 1906, 1907, 
1904, 4388, 4392, 4409, 4405
2449, 1754, 315, 316, 1758, 4364, 1841, 1842, 4368, 1775, 320, 1784, 1782, 4393, 1849, 4410, 
4407, 4389, 1845, 1848, 4406
2450, 4364, 1841, 1842, 4368, 1878, 363, 364, 1882, 4393, 1849, 4410, 4407, 1899, 368, 1908, 
1906, 4392, 1847, 1850, 4409
2451, 296, 1755, 1759, 297, 1808, 4365, 4369, 1809, 1777, 1785, 1786, 301, 4396, 4412, 4413, 
1817, 1815, 4394, 4411, 1818
2452, 1808, 4365, 4369, 1809, 340, 1879, 1883, 341, 4396, 4412, 4413, 1817, 1901, 1909, 1910, 
345, 1816, 4397, 4414, 1819
2453, 1755, 1756, 1760, 1759, 4365, 4366, 4370, 4369, 1779, 1787, 1788, 1785, 4400, 4416, 4417, 
4412, 4394, 4398, 4415, 4411
2454, 4365, 4366, 4370, 4369, 1879, 1880, 1884, 1883, 4400, 4416, 4417, 4412, 1903, 1911, 1912, 
1909, 4397, 4401, 4418, 4414
2455, 1756, 1757, 1761, 1760, 4366, 4367, 4371, 4370, 1781, 1789, 1790, 1787, 4404, 4420, 4421, 
4416, 4398, 4402, 4419, 4415
2456, 4366, 4367, 4371, 4370, 1880, 1881, 1885, 1884, 4404, 4420, 4421, 4416, 1905, 1913, 1914, 
1911, 4401, 4405, 4422, 4418
2457, 1757, 1758, 1762, 1761, 4367, 4368, 4372, 4371, 1783, 1791, 1792, 1789, 4408, 4424, 4425, 
4420, 4402, 4406, 4423, 4419
2458, 4367, 4368, 4372, 4371, 1881, 1882, 1886, 1885, 4408, 4424, 4425, 4420, 1907, 1915, 1916, 
1913, 4405, 4409, 4426, 4422
2459, 1758, 316, 317, 1762, 4368, 1842, 1843, 4372, 1784, 321, 1793, 1791, 4410, 1852, 4427, 
4424, 4406, 1848, 1851, 4423
2460, 4368, 1842, 1843, 4372, 1882, 364, 365, 1886, 4410, 1852, 4427, 4424, 1908, 369, 1917, 
1915, 4409, 1850, 1853, 4426
2461, 297, 1759, 1763, 298, 1809, 4369, 4373, 1810, 1786, 1794, 1795, 302, 4413, 4429, 4430, 
1820, 1818, 4411, 4428, 1821
2462, 1809, 4369, 4373, 1810, 341, 1883, 1887, 342, 4413, 4429, 4430, 1820, 1910, 1918, 1919, 
346, 1819, 4414, 4431, 1822
2463, 1759, 1760, 1764, 1763, 4369, 4370, 4374, 4373, 1788, 1796, 1797, 1794, 4417, 4433, 4434, 
4429, 4411, 4415, 4432, 4428
2464, 4369, 4370, 4374, 4373, 1883, 1884, 1888, 1887, 4417, 4433, 4434, 4429, 1912, 1920, 1921, 
1918, 4414, 4418, 4435, 4431
2465, 1760, 1761, 1765, 1764, 4370, 4371, 4375, 4374, 1790, 1798, 1799, 1796, 4421, 4437, 4438, 
4433, 4415, 4419, 4436, 4432
2466, 4370, 4371, 4375, 4374, 1884, 1885, 1889, 1888, 4421, 4437, 4438, 4433, 1914, 1922, 1923, 
1920, 4418, 4422, 4439, 4435
2467, 1761, 1762, 1766, 1765, 4371, 4372, 4376, 4375, 1792, 1800, 1801, 1798, 4425, 4441, 4442, 
4437, 4419, 4423, 4440, 4436
2468, 4371, 4372, 4376, 4375, 1885, 1886, 1890, 1889, 4425, 4441, 4442, 4437, 1916, 1924, 1925, 
1922, 4422, 4426, 4443, 4439
2469, 1762, 317, 318, 1766, 4372, 1843, 1844, 4376, 1793, 322, 1802, 1800, 4427, 1855, 4444, 
4441, 4423, 1851, 1854, 4440
2470, 4372, 1843, 1844, 4376, 1886, 365, 366, 1890, 4427, 1855, 4444, 4441, 1917, 370, 1926, 
1924, 4426, 1853, 1856, 4443
2471, 298, 1763, 305, 17, 1810, 4373, 1824, 333, 1795, 1803, 309, 303, 4430, 4445, 1828, 
1823, 1821, 4428, 1829, 334
2472, 1810, 4373, 1824, 333, 342, 1887, 351, 21, 4430, 4445, 1828, 1823, 1919, 1927, 355, 
347, 1822, 4431, 1830, 335
2473, 1763, 1764, 306, 305, 4373, 4374, 1825, 1824, 1797, 1804, 310, 1803, 4434, 4446, 1831, 
4445, 4428, 4432, 1832, 1829
2474, 4373, 4374, 1825, 1824, 1887, 1888, 352, 351, 4434, 4446, 1831, 4445, 1921, 1928, 356, 
1927, 4431, 4435, 1833, 1830
2475, 1764, 1765, 307, 306, 4374, 4375, 1826, 1825, 1799, 1805, 311, 1804, 4438, 4447, 1834, 
4446, 4432, 4436, 1835, 1832
2476, 4374, 4375, 1826, 1825, 1888, 1889, 353, 352, 4438, 4447, 1834, 4446, 1923, 1929, 357, 
1928, 4435, 4439, 1836, 1833
2477, 1765, 1766, 308, 307, 4375, 4376, 1827, 1826, 1801, 1806, 312, 1805, 4442, 4448, 1837, 
4447, 4436, 4440, 1838, 1835
2478, 4375, 4376, 1827, 1826, 1889, 1890, 354, 353, 4442, 4448, 1837, 4447, 1925, 1930, 358, 
1929, 4439, 4443, 1839, 1836
2479, 1766, 318, 19, 308, 4376, 1844, 348, 1827, 1802, 323, 313, 1806, 4444, 1857, 1840, 
4448, 4440, 1854, 349, 1838
2480, 4376, 1844, 348, 1827, 1890, 366, 23, 354, 4444, 1857, 1840, 4448, 1926, 371, 359, 
1930, 4443, 1856, 350, 1839
*ELEMENT, type=C3D20, ELSET=Volume6
2481, 17, 333, 1824, 305, 394, 1940, 4449, 1949, 334, 1828, 1829, 309, 1943, 4458, 4459, 
1957, 396, 1942, 4457, 1958
2482, 394, 1940, 4449, 1949, 395, 1941, 4450, 1950, 1943, 4458, 4459, 1957, 1945, 4461, 4462, 
1959, 397, 1944, 4460, 1960
2483, 395, 1941, 4450, 1950, 27, 404, 2009, 407, 1945, 4461, 4462, 1959, 405, 2013, 2014, 
411, 398, 1946, 4463, 1961
2484, 333, 21, 351, 1824, 1940, 399, 1979, 4449, 335, 355, 1830, 1828, 1947, 1988, 4464, 
4458, 1942, 401, 1987, 4457
2485, 1940, 399, 1979, 4449, 1941, 400, 1980, 4450, 1947, 1988, 4464, 4458, 1948, 1990, 4465, 
4461, 1944, 402, 1989, 4460
2486, 1941, 400, 1980, 4450, 404, 28, 416, 2009, 1948, 1990, 4465, 4461, 406, 420, 2015, 
2013, 1946, 403, 1991, 4463
2487, 305, 1824, 1825, 306, 1949, 4449, 4451, 1951, 1829, 1831, 1832, 310, 4459, 4467, 4468, 
1962, 1958, 4457, 4466, 1963
2488, 1949, 4449, 4451, 1951, 1950, 4450, 4452, 1952, 4459, 4467, 4468, 1962, 4462, 4470, 4471, 
1964, 1960, 4460, 4469, 1965
2489, 1950, 4450, 4452, 1952, 407, 2009, 2010, 408, 4462, 4470, 4471, 1964, 2014, 2016, 2017, 
412, 1961, 4463, 4472, 1966
2490, 1824, 351, 352, 1825, 4449, 1979, 1981, 4451, 1830, 356, 1833, 1831, 4464, 1993, 4473, 
4467, 4457, 1987, 1992, 4466
2491, 4449, 1979, 1981, 4451, 4450, 1980, 1982, 4452, 4464, 1993, 4473, 4467, 4465, 1995, 4474, 
4470, 4460, 1989, 1994, 4469
2492, 4450, 1980, 1982, 4452, 2009, 416, 417, 2010, 4465, 1995, 4474, 4470, 2015, 421, 2018, 
2016, 4463, 1991, 1996, 4472
2493, 306, 1825, 1826, 307, 1951, 4451, 4453, 1953, 1832, 1834, 1835, 311, 4468, 4476, 4477, 
1967, 1963, 4466, 4475, 1968
2494, 1951, 4451, 4453, 1953, 1952, 4452, 4454, 1954, 4468, 4476, 4477, 1967, 4471, 4479, 4480, 
1969, 1965, 4469, 4478, 1970
2495, 1952, 4452, 4454, 1954, 408, 2010, 2011, 409, 4471, 4479, 4480, 1969, 2017, 2019, 2020, 
413, 1966, 4472, 4481, 1971
2496, 1825, 352, 353, 1826, 4451, 1981, 1983, 4453, 1833, 357, 1836, 1834, 4473, 1998, 4482, 
4476, 4466, 1992, 1997, 4475
2497, 4451, 1981, 1983, 4453, 4452, 1982, 1984, 4454, 4473, 1998, 4482, 4476, 4474, 2000, 4483, 
4479, 4469, 1994, 1999, 4478
2498, 4452, 1982, 1984, 4454, 2010, 417, 418, 2011, 4474, 2000, 4483, 4479, 2018, 422, 2021, 
2019, 4472, 1996, 2001, 4481
2499, 307, 1826, 1827, 308, 1953, 4453, 4455, 1955, 1835, 1837, 1838, 312, 4477, 4485, 4486, 
1972, 1968, 4475, 4484, 1973
2500, 1953, 4453, 4455, 1955, 1954, 4454, 4456, 1956, 4477, 4485, 4486, 1972, 4480, 4488, 4489, 
1974, 1970, 4478, 4487, 1975
2501, 1954, 4454, 4456, 1956, 409, 2011, 2012, 410, 4480, 4488, 4489, 1974, 2020, 2022, 2023, 
414, 1971, 4481, 4490, 1976
2502, 1826, 353, 354, 1827, 4453, 1983, 1985, 4455, 1836, 358, 1839, 1837, 4482, 2003, 4491, 
4485, 4475, 1997, 2002, 4484
2503, 4453, 1983, 1985, 4455, 4454, 1984, 1986, 4456, 4482, 2003, 4491, 4485, 4483, 2005, 4492, 
4488, 4478, 1999, 2004, 4487
2504, 4454, 1984, 1986, 4456, 2011, 418, 419, 2012, 4483, 2005, 4492, 4488, 2021, 423, 2024, 
2022, 4481, 2001, 2006, 4490
2505, 308, 1827, 348, 19, 1955, 4455, 1931, 381, 1838, 1840, 349, 313, 4486, 4493, 1933, 
1977, 1973, 4484, 1934, 383
2506, 1955, 4455, 1931, 381, 1956, 4456, 1932, 382, 4486, 4493, 1933, 1977, 4489, 4494, 1935, 
1978, 1975, 4487, 1936, 384
2507, 1956, 4456, 1932, 382, 410, 2012, 391, 25, 4489, 4494, 1935, 1978, 2023, 2025, 392, 
415, 1976, 4490, 1937, 385
2508, 1827, 354, 23, 348, 4455, 1985, 386, 1931, 1839, 359, 350, 1840, 4491, 2007, 1938, 
4493, 4484, 2002, 388, 1934
2509, 4455, 1985, 386, 1931, 4456, 1986, 387, 1932, 4491, 2007, 1938, 4493, 4492, 2008, 1939, 
4494, 4487, 2004, 389, 1936
2510, 4456, 1986, 387, 1932, 2012, 419, 26, 391, 4492, 2008, 1939, 4494, 2024, 424, 393, 
2025, 4490, 2006, 390, 1937
*ELEMENT, type=C3D20, ELSET=Volume7
2511, 27, 404, 2009, 407, 446, 2043, 4495, 2060, 405, 2013, 2014, 411, 2048, 4512, 4513, 
2076, 450, 2047, 4511, 2077
2512, 446, 2043, 4495, 2060, 447, 2044, 4496, 2061, 2048, 4512, 4513, 2076, 2050, 4515, 4516, 
2078, 451, 2049, 4514, 2079
2513, 447, 2044, 4496, 2061, 448, 2045, 4497, 2062, 2050, 4515, 4516, 2078, 2052, 4518, 4519, 
2080, 452, 2051, 4517, 2081
2514, 448, 2045, 4497, 2062, 449, 2046, 4498, 2063, 2052, 4518, 4519, 2080, 2054, 4521, 4522, 
2082, 453, 2053, 4520, 2083
2515, 449, 2046, 4498, 2063, 31, 464, 2172, 467, 2054, 4521, 4522, 2082, 465, 2176, 2177, 
471, 454, 2055, 4523, 2084
2516, 404, 28, 416, 2009, 2043, 455, 2116, 4495, 406, 420, 2015, 2013, 2056, 2133, 4524, 
4512, 2047, 459, 2132, 4511
2517, 2043, 455, 2116, 4495, 2044, 456, 2117, 4496, 2056, 2133, 4524, 4512, 2057, 2135, 4525, 
4515, 2049, 460, 2134, 4514
2518, 2044, 456, 2117, 4496, 2045, 457, 2118, 4497, 2057, 2135, 4525, 4515, 2058, 2137, 4526, 
4518, 2051, 461, 2136, 4517
2519, 2045, 457, 2118, 4497, 2046, 458, 2119, 4498, 2058, 2137, 4526, 4518, 2059, 2139, 4527, 
4521, 2053, 462, 2138, 4520
2520, 2046, 458, 2119, 4498, 464, 32, 476, 2172, 2059, 2139, 4527, 4521, 466, 480, 2178, 
2176, 2055, 463, 2140, 4523
2521, 407, 2009, 2010, 408, 2060, 4495, 4499, 2064, 2014, 2016, 2017, 412, 4513, 4529, 4530, 
2085, 2077, 4511, 4528, 2086
2522, 2060, 4495, 4499, 2064, 2061, 4496, 4500, 2065, 4513, 4529, 4530, 2085, 4516, 4532, 4533, 
2087, 2079, 4514, 4531, 2088
2523, 2061, 4496, 4500, 2065, 2062, 4497, 4501, 2066, 4516, 4532, 4533, 2087, 4519, 4535, 4536, 
2089, 2081, 4517, 4534, 2090
2524, 2062, 4497, 4501, 2066, 2063, 4498, 4502, 2067, 4519, 4535, 4536, 2089, 4522, 4538, 4539, 
2091, 2083, 4520, 4537, 2092
2525, 2063, 4498, 4502, 2067, 467, 2172, 2173, 468, 4522, 4538, 4539, 2091, 2177, 2179, 2180, 
472, 2084, 4523, 4540, 2093
2526, 2009, 416, 417, 2010, 4495, 2116, 2120, 4499, 2015, 421, 2018, 2016, 4524, 2142, 4541, 
4529, 4511, 2132, 2141, 4528
2527, 4495, 2116, 2120, 4499, 4496, 2117, 2121, 4500, 4524, 2142, 4541, 4529, 4525, 2144, 4542, 
4532, 4514, 2134, 2143, 4531
2528, 4496, 2117, 2121, 4500, 4497, 2118, 2122, 4501, 4525, 2144, 4542, 4532, 4526, 2146, 4543, 
4535, 4517, 2136, 2145, 4534
2529, 4497, 2118, 2122, 4501, 4498, 2119, 2123, 4502, 4526, 2146, 4543, 4535, 4527, 2148, 4544, 
4538, 4520, 2138, 2147, 4537
2530, 4498, 2119, 2123, 4502, 2172, 476, 477, 2173, 4527, 2148, 4544, 4538, 2178, 481, 2181, 
2179, 4523, 2140, 2149, 4540
2531, 408, 2010, 2011, 409, 2064, 4499, 4503, 2068, 2017, 2019, 2020, 413, 4530, 4546, 4547, 
2094, 2086, 4528, 4545, 2095
2532, 2064, 4499, 4503, 2068, 2065, 4500, 4504, 2069, 4530, 4546, 4547, 2094, 4533, 4549, 4550, 
2096, 2088, 4531, 4548, 2097
2533, 2065, 4500, 4504, 2069, 2066, 4501, 4505, 2070, 4533, 4549, 4550, 2096, 4536, 4552, 4553, 
2098, 2090, 4534, 4551, 2099
2534, 2066, 4501, 4505, 2070, 2067, 4502, 4506, 2071, 4536, 4552, 4553, 2098, 4539, 4555, 4556, 
2100, 2092, 4537, 4554, 2101
2535, 2067, 4502, 4506, 2071, 468, 2173, 2174, 469, 4539, 4555, 4556, 2100, 2180, 2182, 2183, 
473, 2093, 4540, 4557, 2102
2536, 2010, 417, 418, 2011, 4499, 2120, 2124, 4503, 2018, 422, 2021, 2019, 4541, 2151, 4558, 
4546, 4528, 2141, 2150, 4545
2537, 4499, 2120, 2124, 4503, 4500, 2121, 2125, 4504, 4541, 2151, 4558, 4546, 4542, 2153, 4559, 
4549, 4531, 2143, 2152, 4548
2538, 4500, 2121, 2125, 4504, 4501, 2122, 2126, 4505, 4542, 2153, 4559, 4549, 4543, 2155, 4560, 
4552, 4534, 2145, 2154, 4551
2539, 4501, 2122, 2126, 4505, 4502, 2123, 2127, 4506, 4543, 2155, 4560, 4552, 4544, 2157, 4561, 
4555, 4537, 2147, 2156, 4554
2540, 4502, 2123, 2127, 4506, 2173, 477, 478, 2174, 4544, 2157, 4561, 4555, 2181, 482, 2184, 
2182, 4540, 2149, 2158, 4557
2541, 409, 2011, 2012, 410, 2068, 4503, 4507, 2072, 2020, 2022, 2023, 414, 4547, 4563, 4564, 
2103, 2095, 4545, 4562, 2104
2542, 2068, 4503, 4507, 2072, 2069, 4504, 4508, 2073, 4547, 4563, 4564, 2103, 4550, 4566, 4567, 
2105, 2097, 4548, 4565, 2106
2543, 2069, 4504, 4508, 2073, 2070, 4505, 4509, 2074, 4550, 4566, 4567, 2105, 4553, 4569, 4570, 
2107, 2099, 4551, 4568, 2108
2544, 2070, 4505, 4509, 2074, 2071, 4506, 4510, 2075, 4553, 4569, 4570, 2107, 4556, 4572, 4573, 
2109, 2101, 4554, 4571, 2110
2545, 2071, 4506, 4510, 2075, 469, 2174, 2175, 470, 4556, 4572, 4573, 2109, 2183, 2185, 2186, 
474, 2102, 4557, 4574, 2111
2546, 2011, 418, 419, 2012, 4503, 2124, 2128, 4507, 2021, 423, 2024, 2022, 4558, 2160, 4575, 
4563, 4545, 2150, 2159, 4562
2547, 4503, 2124, 2128, 4507, 4504, 2125, 2129, 4508, 4558, 2160, 4575, 4563, 4559, 2162, 4576, 
4566, 4548, 2152, 2161, 4565
2548, 4504, 2125, 2129, 4508, 4505, 2126, 2130, 4509, 4559, 2162, 4576, 4566, 4560, 2164, 4577, 
4569, 4551, 2154, 2163, 4568
2549, 4505, 2126, 2130, 4509, 4506, 2127, 2131, 4510, 4560, 2164, 4577, 4569, 4561, 2166, 4578, 
4572, 4554, 2156, 2165, 4571
2550, 4506, 2127, 2131, 4510, 2174, 478, 479, 2175, 4561, 2166, 4578, 4572, 2184, 483, 2187, 
2185, 4557, 2158, 2167, 4574
2551, 410, 2012, 391, 25, 2072, 4507, 2026, 425, 2023, 2025, 392, 415, 4564, 4579, 2030, 
2112, 2104, 4562, 2031, 429
2552, 2072, 4507, 2026, 425, 2073, 4508, 2027, 426, 4564, 4579, 2030, 2112, 4567, 4580, 2032, 
2113, 2106, 4565, 2033, 430
2553, 2073, 4508, 2027, 426, 2074, 4509, 2028, 427, 4567, 4580, 2032, 2113, 4570, 4581, 2034, 
2114, 2108, 4568, 2035, 431
2554, 2074, 4509, 2028, 427, 2075, 4510, 2029, 428, 4570, 4581, 2034, 2114, 4573, 4582, 2036, 
2115, 2110, 4571, 2037, 432
2555, 2075, 4510, 2029, 428, 470, 2175, 443, 29, 4573, 4582, 2036, 2115, 2186, 2188, 444, 
475, 2111, 4574, 2038, 433
2556, 2012, 419, 26, 391, 4507, 2128, 434, 2026, 2024, 424, 393, 2025, 4575, 2168, 2039, 
4579, 4562, 2159, 438, 2031
2557, 4507, 2128, 434, 2026, 4508, 2129, 435, 2027, 4575, 2168, 2039, 4579, 4576, 2169, 2040, 
4580, 4565, 2161, 439, 2033
2558, 4508, 2129, 435, 2027, 4509, 2130, 436, 2028, 4576, 2169, 2040, 4580, 4577, 2170, 2041, 
4581, 4568, 2163, 440, 2035
2559, 4509, 2130, 436, 2028, 4510, 2131, 437, 2029, 4577, 2170, 2041, 4581, 4578, 2171, 2042, 
4582, 4571, 2165, 441, 2037
2560, 4510, 2131, 437, 2029, 2175, 479, 30, 443, 4578, 2171, 2042, 4582, 2187, 484, 445, 
2188, 4574, 2167, 442, 2038
*ELEMENT, type=C3D20, ELSET=Volume8
2561, 27, 446, 2060, 407, 35, 498, 2205, 507, 450, 2076, 2077, 411, 502, 2221, 2222, 
511, 496, 2193, 4583, 2197
2562, 446, 447, 2061, 2060, 498, 499, 2206, 2205, 451, 2078, 2079, 2076, 503, 2223, 2224, 
2221, 2193, 2194, 4584, 4583
2563, 447, 448, 2062, 2061, 499, 500, 2207, 2206, 452, 2080, 2081, 2078, 504, 2225, 2226, 
2223, 2194, 2195, 4585, 4584
2564, 448, 449, 2063, 2062, 500, 501, 2208, 2207, 453, 2082, 2083, 2080, 505, 2227, 2228, 
2225, 2195, 2196, 4586, 4585
2565, 449, 31, 467, 2063, 501, 36, 516, 2208, 454, 471, 2084, 2082, 506, 520, 2229, 
2227, 2196, 497, 2201, 4586
2566, 407, 2060, 2064, 408, 507, 2205, 2209, 508, 2077, 2085, 2086, 412, 2222, 2230, 2231, 
512, 2197, 4583, 4587, 2198
2567, 2060, 2061, 2065, 2064, 2205, 2206, 2210, 2209, 2079, 2087, 2088, 2085, 2224, 2232, 2233, 
2230, 4583, 4584, 4588, 4587
2568, 2061, 2062, 2066, 2065, 2206, 2207, 2211, 2210, 2081, 2089, 2090, 2087, 2226, 2234, 2235, 
2232, 4584, 4585, 4589, 4588
2569, 2062, 2063, 2067, 2066, 2207, 2208, 2212, 2211, 2083, 2091, 2092, 2089, 2228, 2236, 2237, 
2234, 4585, 4586, 4590, 4589
2570, 2063, 467, 468, 2067, 2208, 516, 517, 2212, 2084, 472, 2093, 2091, 2229, 521, 2238, 
2236, 4586, 2201, 2202, 4590
2571, 408, 2064, 2068, 409, 508, 2209, 2213, 509, 2086, 2094, 2095, 413, 2231, 2239, 2240, 
513, 2198, 4587, 4591, 2199
2572, 2064, 2065, 2069, 2068, 2209, 2210, 2214, 2213, 2088, 2096, 2097, 2094, 2233, 2241, 2242, 
2239, 4587, 4588, 4592, 4591
2573, 2065, 2066, 2070, 2069, 2210, 2211, 2215, 2214, 2090, 2098, 2099, 2096, 2235, 2243, 2244, 
2241, 4588, 4589, 4593, 4592
2574, 2066, 2067, 2071, 2070, 2211, 2212, 2216, 2215, 2092, 2100, 2101, 2098, 2237, 2245, 2246, 
2243, 4589, 4590, 4594, 4593
2575, 2067, 468, 469, 2071, 2212, 517, 518, 2216, 2093, 473, 2102, 2100, 2238, 522, 2247, 
2245, 4590, 2202, 2203, 4594
2576, 409, 2068, 2072, 410, 509, 2213, 2217, 510, 2095, 2103, 2104, 414, 2240, 2248, 2249, 
514, 2199, 4591, 4595, 2200
2577, 2068, 2069, 2073, 2072, 2213, 2214, 2218, 2217, 2097, 2105, 2106, 2103, 2242, 2250, 2251, 
2248, 4591, 4592, 4596, 4595
2578, 2069, 2070, 2074, 2073, 2214, 2215, 2219, 2218, 2099, 2107, 2108, 2105, 2244, 2252, 2253, 
2250, 4592, 4593, 4597, 4596
2579, 2070, 2071, 2075, 2074, 2215, 2216, 2220, 2219, 2101, 2109, 2110, 2107, 2246, 2254, 2255, 
2252, 4593, 4594, 4598, 4597
2580, 2071, 469, 470, 2075, 2216, 518, 519, 2220, 2102, 474, 2111, 2109, 2247, 523, 2256, 
2254, 4594, 2203, 2204, 4598
2581, 410, 2072, 425, 25, 510, 2217, 487, 33, 2104, 2112, 429, 415, 2249, 2257, 491, 
515, 2200, 4595, 2189, 485
2582, 2072, 2073, 426, 425, 2217, 2218, 488, 487, 2106, 2113, 430, 2112, 2251, 2258, 492, 
2257, 4595, 4596, 2190, 2189
2583, 2073, 2074, 427, 426, 2218, 2219, 489, 488, 2108, 2114, 431, 2113, 2253, 2259, 493, 
2258, 4596, 4597, 2191, 2190
2584, 2074, 2075, 428, 427, 2219, 2220, 490, 489, 2110, 2115, 432, 2114, 2255, 2260, 494, 
2259, 4597, 4598, 2192, 2191
2585, 2075, 470, 29, 428, 2220, 519, 34, 490, 2111, 475, 433, 2115, 2256, 524, 495, 
2260, 4598, 2204, 486, 2192
*ELEMENT, type=C3D20, ELSET=Volume9
2586, 35, 498, 2205, 507, 552, 2317, 4599, 2373, 502, 2221, 2222, 511, 2334, 4664, 4665, 
2389, 556, 2333, 4663, 2390
2587, 552, 2317, 4599, 2373, 553, 2318, 4600, 2374, 2334, 4664, 4665, 2389, 2336, 4667, 4668, 
2391, 557, 2335, 4666, 2392
2588, 553, 2318, 4600, 2374, 554, 2319, 4601, 2375, 2336, 4667, 4668, 2391, 2338, 4670, 4671, 
2393, 558, 2337, 4669, 2394
2589, 554, 2319, 4601, 2375, 555, 2320, 4602, 2376, 2338, 4670, 4671, 2393, 2340, 4673, 4674, 
2395, 559, 2339, 4672, 2396
2590, 555, 2320, 4602, 2376, 39, 570, 2485, 579, 2340, 4673, 4674, 2395, 574, 2501, 2502, 
583, 560, 2341, 4675, 2397
2591, 498, 499, 2206, 2205, 2317, 2321, 4603, 4599, 503, 2223, 2224, 2221, 2343, 4677, 4678, 
4664, 2333, 2342, 4676, 4663
2592, 2317, 2321, 4603, 4599, 2318, 2322, 4604, 4600, 2343, 4677, 4678, 4664, 2345, 4680, 4681, 
4667, 2335, 2344, 4679, 4666
2593, 2318, 2322, 4604, 4600, 2319, 2323, 4605, 4601, 2345, 4680, 4681, 4667, 2347, 4683, 4684, 
4670, 2337, 2346, 4682, 4669
2594, 2319, 2323, 4605, 4601, 2320, 2324, 4606, 4602, 2347, 4683, 4684, 4670, 2349, 4686, 4687, 
4673, 2339, 2348, 4685, 4672
2595, 2320, 2324, 4606, 4602, 570, 571, 2486, 2485, 2349, 4686, 4687, 4673, 575, 2503, 2504, 
2501, 2341, 2350, 4688, 4675
2596, 499, 500, 2207, 2206, 2321, 2325, 4607, 4603, 504, 2225, 2226, 2223, 2352, 4690, 4691, 
4677, 2342, 2351, 4689, 4676
2597, 2321, 2325, 4607, 4603, 2322, 2326, 4608, 4604, 2352, 4690, 4691, 4677, 2354, 4693, 4694, 
4680, 2344, 2353, 4692, 4679
2598, 2322, 2326, 4608, 4604, 2323, 2327, 4609, 4605, 2354, 4693, 4694, 4680, 2356, 4696, 4697, 
4683, 2346, 2355, 4695, 4682
2599, 2323, 2327, 4609, 4605, 2324, 2328, 4610, 4606, 2356, 4696, 4697, 4683, 2358, 4699, 4700, 
4686, 2348, 2357, 4698, 4685
2600, 2324, 2328, 4610, 4606, 571, 572, 2487, 2486, 2358, 4699, 4700, 4686, 576, 2505, 2506, 
2503, 2350, 2359, 4701, 4688
2601, 500, 501, 2208, 2207, 2325, 2329, 4611, 4607, 505, 2227, 2228, 2225, 2361, 4703, 4704, 
4690, 2351, 2360, 4702, 4689
2602, 2325, 2329, 4611, 4607, 2326, 2330, 4612, 4608, 2361, 4703, 4704, 4690, 2363, 4706, 4707, 
4693, 2353, 2362, 4705, 4692
2603, 2326, 2330, 4612, 4608, 2327, 2331, 4613, 4609, 2363, 4706, 4707, 4693, 2365, 4709, 4710, 
4696, 2355, 2364, 4708, 4695
2604, 2327, 2331, 4613, 4609, 2328, 2332, 4614, 4610, 2365, 4709, 4710, 4696, 2367, 4712, 4713, 
4699, 2357, 2366, 4711, 4698
2605, 2328, 2332, 4614, 4610, 572, 573, 2488, 2487, 2367, 4712, 4713, 4699, 577, 2507, 2508, 
2505, 2359, 2368, 4714, 4701
2606, 501, 36, 516, 2208, 2329, 561, 2429, 4611, 506, 520, 2229, 2227, 2369, 2446, 4715, 
4703, 2360, 565, 2445, 4702
2607, 2329, 561, 2429, 4611, 2330, 562, 2430, 4612, 2369, 2446, 4715, 4703, 2370, 2448, 4716, 
4706, 2362, 566, 2447, 4705
2608, 2330, 562, 2430, 4612, 2331, 563, 2431, 4613, 2370, 2448, 4716, 4706, 2371, 2450, 4717, 
4709, 2364, 567, 2449, 4708
2609, 2331, 563, 2431, 4613, 2332, 564, 2432, 4614, 2371, 2450, 4717, 4709, 2372, 2452, 4718, 
4712, 2366, 568, 2451, 4711
2610, 2332, 564, 2432, 4614, 573, 40, 588, 2488, 2372, 2452, 4718, 4712, 578, 592, 2509, 
2507, 2368, 569, 2453, 4714
2611, 507, 2205, 2209, 508, 2373, 4599, 4615, 2377, 2222, 2230, 2231, 512, 4665, 4720, 4721, 
2398, 2390, 4663, 4719, 2399
2612, 2373, 4599, 4615, 2377, 2374, 4600, 4616, 2378, 4665, 4720, 4721, 2398, 4668, 4723, 4724, 
2400, 2392, 4666, 4722, 2401
2613, 2374, 4600, 4616, 2378, 2375, 4601, 4617, 2379, 4668, 4723, 4724, 2400, 4671, 4726, 4727, 
2402, 2394, 4669, 4725, 2403
2614, 2375, 4601, 4617, 2379, 2376, 4602, 4618, 2380, 4671, 4726, 4727, 2402, 4674, 4729, 4730, 
2404, 2396, 4672, 4728, 2405
2615, 2376, 4602, 4618, 2380, 579, 2485, 2489, 580, 4674, 4729, 4730, 2404, 2502, 2510, 2511, 
584, 2397, 4675, 4731, 2406
2616, 2205, 2206, 2210, 2209, 4599, 4603, 4619, 4615, 2224, 2232, 2233, 2230, 4678, 4733, 4734, 
4720, 4663, 4676, 4732, 4719
2617, 4599, 4603, 4619, 4615, 4600, 4604, 4620, 4616, 4678, 4733, 4734, 4720, 4681, 4736, 4737, 
4723, 4666, 4679, 4735, 4722
2618, 4600, 4604, 4620, 4616, 4601, 4605, 4621, 4617, 4681, 4736, 4737, 4723, 4684, 4739, 4740, 
4726, 4669, 4682, 4738, 4725
2619, 4601, 4605, 4621, 4617, 4602, 4606, 4622, 4618, 4684, 4739, 4740, 4726, 4687, 4742, 4743, 
4729, 4672, 4685, 4741, 4728
2620, 4602, 4606, 4622, 4618, 2485, 2486, 2490, 2489, 4687, 4742, 4743, 4729, 2504, 2512, 2513, 
2510, 4675, 4688, 4744, 4731
2621, 2206, 2207, 2211, 2210, 4603, 4607, 4623, 4619, 2226, 2234, 2235, 2232, 4691, 4746, 4747, 
4733, 4676, 4689, 4745, 4732
2622, 4603, 4607, 4623, 4619, 4604, 4608, 4624, 4620, 4691, 4746, 4747, 4733, 4694, 4749, 4750, 
4736, 4679, 4692, 4748, 4735
2623, 4604, 4608, 4624, 4620, 4605, 4609, 4625, 4621, 4694, 4749, 4750, 4736, 4697, 4752, 4753, 
4739, 4682, 4695, 4751, 4738
2624, 4605, 4609, 4625, 4621, 4606, 4610, 4626, 4622, 4697, 4752, 4753, 4739, 4700, 4755, 4756, 
4742, 4685, 4698, 4754, 4741
2625, 4606, 4610, 4626, 4622, 2486, 2487, 2491, 2490, 4700, 4755, 4756, 4742, 2506, 2514, 2515, 
2512, 4688, 4701, 4757, 4744
2626, 2207, 2208, 2212, 2211, 4607, 4611, 4627, 4623, 2228, 2236, 2237, 2234, 4704, 4759, 4760, 
4746, 4689, 4702, 4758, 4745
2627, 4607, 4611, 4627, 4623, 4608, 4612, 4628, 4624, 4704, 4759, 4760, 4746, 4707, 4762, 4763, 
4749, 4692, 4705, 4761, 4748
2628, 4608, 4612, 4628, 4624, 4609, 4613, 4629, 4625, 4707, 4762, 4763, 4749, 4710, 4765, 4766, 
4752, 4695, 4708, 4764, 4751
2629, 4609, 4613, 4629, 4625, 4610, 4614, 4630, 4626, 4710, 4765, 4766, 4752, 4713, 4768, 4769, 
4755, 4698, 4711, 4767, 4754
2630, 4610, 4614, 4630, 4626, 2487, 2488, 2492, 2491, 4713, 4768, 4769, 4755, 2508, 2516, 2517, 
2514, 4701, 4714, 4770, 4757
2631, 2208, 516, 517, 2212, 4611, 2429, 2433, 4627, 2229, 521, 2238, 2236, 4715, 2455, 4771, 
4759, 4702, 2445, 2454, 4758
2632, 4611, 2429, 2433, 4627, 4612, 2430, 2434, 4628, 4715, 2455, 4771, 4759, 4716, 2457, 4772, 
4762, 4705, 2447, 2456, 4761
2633, 4612, 2430, 2434, 4628, 4613, 2431, 2435, 4629, 4716, 2457, 4772, 4762, 4717, 2459, 4773, 
4765, 4708, 2449, 2458, 4764
2634, 4613, 2431, 2435, 4629, 4614, 2432, 2436, 4630, 4717, 2459, 4773, 4765, 4718, 2461, 4774, 
4768, 4711, 2451, 2460, 4767
2635, 4614, 2432, 2436, 4630, 2488, 588, 589, 2492, 4718, 2461, 4774, 4768, 2509, 593, 2518, 
2516, 4714, 2453, 2462, 4770
2636, 508, 2209, 2213, 509, 2377, 4615, 4631, 2381, 2231, 2239, 2240, 513, 4721, 4776, 4777, 
2407, 2399, 4719, 4775, 2408
2637, 2377, 4615, 4631, 2381, 2378, 4616, 4632, 2382, 4721, 4776, 4777, 2407, 4724, 4779, 4780, 
2409, 2401, 4722, 4778, 2410
2638, 2378, 4616, 4632, 2382, 2379, 4617, 4633, 2383, 4724, 4779, 4780, 2409, 4727, 4782, 4783, 
2411, 2403, 4725, 4781, 2412
2639, 2379, 4617, 4633, 2383, 2380, 4618, 4634, 2384, 4727, 4782, 4783, 2411, 4730, 4785, 4786, 
2413, 2405, 4728, 4784, 2414
2640, 2380, 4618, 4634, 2384, 580, 2489, 2493, 581, 4730, 4785, 4786, 2413, 2511, 2519, 2520, 
585, 2406, 4731, 4787, 2415
2641, 2209, 2210, 2214, 2213, 4615, 4619, 4635, 4631, 2233, 2241, 2242, 2239, 4734, 4789, 4790, 
4776, 4719, 4732, 4788, 4775
2642, 4615, 4619, 4635, 4631, 4616, 4620, 4636, 4632, 4734, 4789, 4790, 4776, 4737, 4792, 4793, 
4779, 4722, 4735, 4791, 4778
2643, 4616, 4620, 4636, 4632, 4617, 4621, 4637, 4633, 4737, 4792, 4793, 4779, 4740, 4795, 4796, 
4782, 4725, 4738, 4794, 4781
2644, 4617, 4621, 4637, 4633, 4618, 4622, 4638, 4634, 4740, 4795, 4796, 4782, 4743, 4798, 4799, 
4785, 4728, 4741, 4797, 4784
2645, 4618, 4622, 4638, 4634, 2489, 2490, 2494, 2493, 4743, 4798, 4799, 4785, 2513, 2521, 2522, 
2519, 4731, 4744, 4800, 4787
2646, 2210, 2211, 2215, 2214, 4619, 4623, 4639, 4635, 2235, 2243, 2244, 2241, 4747, 4802, 4803, 
4789, 4732, 4745, 4801, 4788
2647, 4619, 4623, 4639, 4635, 4620, 4624, 4640, 4636, 4747, 4802, 4803, 4789, 4750, 4805, 4806, 
4792, 4735, 4748, 4804, 4791
2648, 4620, 4624, 4640, 4636, 4621, 4625, 4641, 4637, 4750, 4805, 4806, 4792, 4753, 4808, 4809, 
4795, 4738, 4751, 4807, 4794
2649, 4621, 4625, 4641, 4637, 4622, 4626, 4642, 4638, 4753, 4808, 4809, 4795, 4756, 4811, 4812, 
4798, 4741, 4754, 4810, 4797
2650, 4622, 4626, 4642, 4638, 2490, 2491, 2495, 2494, 4756, 4811, 4812, 4798, 2515, 2523, 2524, 
2521, 4744, 4757, 4813, 4800
2651, 2211, 2212, 2216, 2215, 4623, 4627, 4643, 4639, 2237, 2245, 2246, 2243, 4760, 4815, 4816, 
4802, 4745, 4758, 4814, 4801
2652, 4623, 4627, 4643, 4639, 4624, 4628, 4644, 4640, 4760, 4815, 4816, 4802, 4763, 4818, 4819, 
4805, 4748, 4761, 4817, 4804
2653, 4624, 4628, 4644, 4640, 4625, 4629, 4645, 4641, 4763, 4818, 4819, 4805, 4766, 4821, 4822, 
4808, 4751, 4764, 4820, 4807
2654, 4625, 4629, 4645, 4641, 4626, 4630, 4646, 4642, 4766, 4821, 4822, 4808, 4769, 4824, 4825, 
4811, 4754, 4767, 4823, 4810
2655, 4626, 4630, 4646, 4642, 2491, 2492, 2496, 2495, 4769, 4824, 4825, 4811, 2517, 2525, 2526, 
2523, 4757, 4770, 4826, 4813
2656, 2212, 517, 518, 2216, 4627, 2433, 2437, 4643, 2238, 522, 2247, 2245, 4771, 2464, 4827, 
4815, 4758, 2454, 2463, 4814
2657, 4627, 2433, 2437, 4643, 4628, 2434, 2438, 4644, 4771, 2464, 4827, 4815, 4772, 2466, 4828, 
4818, 4761, 2456, 2465, 4817
2658, 4628, 2434, 2438, 4644, 4629, 2435, 2439, 4645, 4772, 2466, 4828, 4818, 4773, 2468, 4829, 
4821, 4764, 2458, 2467, 4820
2659, 4629, 2435, 2439, 4645, 4630, 2436, 2440, 4646, 4773, 2468, 4829, 4821, 4774, 2470, 4830, 
4824, 4767, 2460, 2469, 4823
2660, 4630, 2436, 2440, 4646, 2492, 589, 590, 2496, 4774, 2470, 4830, 4824, 2518, 594, 2527, 
2525, 4770, 2462, 2471, 4826
2661, 509, 2213, 2217, 510, 2381, 4631, 4647, 2385, 2240, 2248, 2249, 514, 4777, 4832, 4833, 
2416, 2408, 4775, 4831, 2417
2662, 2381, 4631, 4647, 2385, 2382, 4632, 4648, 2386, 4777, 4832, 4833, 2416, 4780, 4835, 4836, 
2418, 2410, 4778, 4834, 2419
2663, 2382, 4632, 4648, 2386, 2383, 4633, 4649, 2387, 4780, 4835, 4836, 2418, 4783, 4838, 4839, 
2420, 2412, 4781, 4837, 2421
2664, 2383, 4633, 4649, 2387, 2384, 4634, 4650, 2388, 4783, 4838, 4839, 2420, 4786, 4841, 4842, 
2422, 2414, 4784, 4840, 2423
2665, 2384, 4634, 4650, 2388, 581, 2493, 2497, 582, 4786, 4841, 4842, 2422, 2520, 2528, 2529, 
586, 2415, 4787, 4843, 2424
2666, 2213, 2214, 2218, 2217, 4631, 4635, 4651, 4647, 2242, 2250, 2251, 2248, 4790, 4845, 4846, 
4832, 4775, 4788, 4844, 4831
2667, 4631, 4635, 4651, 4647, 4632, 4636, 4652, 4648, 4790, 4845, 4846, 4832, 4793, 4848, 4849, 
4835, 4778, 4791, 4847, 4834
2668, 4632, 4636, 4652, 4648, 4633, 4637, 4653, 4649, 4793, 4848, 4849, 4835, 4796, 4851, 4852, 
4838, 4781, 4794, 4850, 4837
2669, 4633, 4637, 4653, 4649, 4634, 4638, 4654, 4650, 4796, 4851, 4852, 4838, 4799, 4854, 4855, 
4841, 4784, 4797, 4853, 4840
2670, 4634, 4638, 4654, 4650, 2493, 2494, 2498, 2497, 4799, 4854, 4855, 4841, 2522, 2530, 2531, 
2528, 4787, 4800, 4856, 4843
2671, 2214, 2215, 2219, 2218, 4635, 4639, 4655, 4651, 2244, 2252, 2253, 2250, 4803, 4858, 4859, 
4845, 4788, 4801, 4857, 4844
2672, 4635, 4639, 4655, 4651, 4636, 4640, 4656, 4652, 4803, 4858, 4859, 4845, 4806, 4861, 4862, 
4848, 4791, 4804, 4860, 4847
2673, 4636, 4640, 4656, 4652, 4637, 4641, 4657, 4653, 4806, 4861, 4862, 4848, 4809, 4864, 4865, 
4851, 4794, 4807, 4863, 4850
2674, 4637, 4641, 4657, 4653, 4638, 4642, 4658, 4654, 4809, 4864, 4865, 4851, 4812, 4867, 4868, 
4854, 4797, 4810, 4866, 4853
2675, 4638, 4642, 4658, 4654, 2494, 2495, 2499, 2498, 4812, 4867, 4868, 4854, 2524, 2532, 2533, 
2530, 4800, 4813, 4869, 4856
2676, 2215, 2216, 2220, 2219, 4639, 4643, 4659, 4655, 2246, 2254, 2255, 2252, 4816, 4871, 4872, 
4858, 4801, 4814, 4870, 4857
2677, 4639, 4643, 4659, 4655, 4640, 4644, 4660, 4656, 4816, 4871, 4872, 4858, 4819, 4874, 4875, 
4861, 4804, 4817, 4873, 4860
2678, 4640, 4644, 4660, 4656, 4641, 4645, 4661, 4657, 4819, 4874, 4875, 4861, 4822, 4877, 4878, 
4864, 4807, 4820, 4876, 4863
2679, 4641, 4645, 4661, 4657, 4642, 4646, 4662, 4658, 4822, 4877, 4878, 4864, 4825, 4880, 4881, 
4867, 4810, 4823, 4879, 4866
2680, 4642, 4646, 4662, 4658, 2495, 2496, 2500, 2499, 4825, 4880, 4881, 4867, 2526, 2534, 2535, 
2532, 4813, 4826, 4882, 4869
2681, 2216, 518, 519, 2220, 4643, 2437, 2441, 4659, 2247, 523, 2256, 2254, 4827, 2473, 4883, 
4871, 4814, 2463, 2472, 4870
2682, 4643, 2437, 2441, 4659, 4644, 2438, 2442, 4660, 4827, 2473, 4883, 4871, 4828, 2475, 4884, 
4874, 4817, 2465, 2474, 4873
2683, 4644, 2438, 2442, 4660, 4645, 2439, 2443, 4661, 4828, 2475, 4884, 4874, 4829, 2477, 4885, 
4877, 4820, 2467, 2476, 4876
2684, 4645, 2439, 2443, 4661, 4646, 2440, 2444, 4662, 4829, 2477, 4885, 4877, 4830, 2479, 4886, 
4880, 4823, 2469, 2478, 4879
2685, 4646, 2440, 2444, 4662, 2496, 590, 591, 2500, 4830, 2479, 4886, 4880, 2527, 595, 2536, 
2534, 4826, 2471, 2480, 4882
2686, 510, 2217, 487, 33, 2385, 4647, 2261, 525, 2249, 2257, 491, 515, 4833, 4887, 2277, 
2425, 2417, 4831, 2278, 529
2687, 2385, 4647, 2261, 525, 2386, 4648, 2262, 526, 4833, 4887, 2277, 2425, 4836, 4888, 2279, 
2426, 2419, 4834, 2280, 530
2688, 2386, 4648, 2262, 526, 2387, 4649, 2263, 527, 4836, 4888, 2279, 2426, 4839, 4889, 2281, 
2427, 2421, 4837, 2282, 531
2689, 2387, 4649, 2263, 527, 2388, 4650, 2264, 528, 4839, 4889, 2281, 2427, 4842, 4890, 2283, 
2428, 2423, 4840, 2284, 532
2690, 2388, 4650, 2264, 528, 582, 2497, 543, 37, 4842, 4890, 2283, 2428, 2529, 2537, 547, 
587, 2424, 4843, 2285, 533
2691, 2217, 2218, 488, 487, 4647, 4651, 2265, 2261, 2251, 2258, 492, 2257, 4846, 4891, 2286, 
4887, 4831, 4844, 2287, 2278
2692, 4647, 4651, 2265, 2261, 4648, 4652, 2266, 2262, 4846, 4891, 2286, 4887, 4849, 4892, 2288, 
4888, 4834, 4847, 2289, 2280
2693, 4648, 4652, 2266, 2262, 4649, 4653, 2267, 2263, 4849, 4892, 2288, 4888, 4852, 4893, 2290, 
4889, 4837, 4850, 2291, 2282
2694, 4649, 4653, 2267, 2263, 4650, 4654, 2268, 2264, 4852, 4893, 2290, 4889, 4855, 4894, 2292, 
4890, 4840, 4853, 2293, 2284
2695, 4650, 4654, 2268, 2264, 2497, 2498, 544, 543, 4855, 4894, 2292, 4890, 2531, 2538, 548, 
2537, 4843, 4856, 2294, 2285
2696, 2218, 2219, 489, 488, 4651, 4655, 2269, 2265, 2253, 2259, 493, 2258, 4859, 4895, 2295, 
4891, 4844, 4857, 2296, 2287
2697, 4651, 4655, 2269, 2265, 4652, 4656, 2270, 2266, 4859, 4895, 2295, 4891, 4862, 4896, 2297, 
4892, 4847, 4860, 2298, 2289
2698, 4652, 4656, 2270, 2266, 4653, 4657, 2271, 2267, 4862, 4896, 2297, 4892, 4865, 4897, 2299, 
4893, 4850, 4863, 2300, 2291
2699, 4653, 4657, 2271, 2267, 4654, 4658, 2272, 2268, 4865, 4897, 2299, 4893, 4868, 4898, 2301, 
4894, 4853, 4866, 2302, 2293
2700, 4654, 4658, 2272, 2268, 2498, 2499, 545, 544, 4868, 4898, 2301, 4894, 2533, 2539, 549, 
2538, 4856, 4869, 2303, 2294
2701, 2219, 2220, 490, 489, 4655, 4659, 2273, 2269, 2255, 2260, 494, 2259, 4872, 4899, 2304, 
4895, 4857, 4870, 2305, 2296
2702, 4655, 4659, 2273, 2269, 4656, 4660, 2274, 2270, 4872, 4899, 2304, 4895, 4875, 4900, 2306, 
4896, 4860, 4873, 2307, 2298
2703, 4656, 4660, 2274, 2270, 4657, 4661, 2275, 2271, 4875, 4900, 2306, 4896, 4878, 4901, 2308, 
4897, 4863, 4876, 2309, 2300
2704, 4657, 4661, 2275, 2271, 4658, 4662, 2276, 2272, 4878, 4901, 2308, 4897, 4881, 4902, 2310, 
4898, 4866, 4879, 2311, 2302
2705, 4658, 4662, 2276, 2272, 2499, 2500, 546, 545, 4881, 4902, 2310, 4898, 2535, 2540, 550, 
2539, 4869, 4882, 2312, 2303
2706, 2220, 519, 34, 490, 4659, 2441, 534, 2273, 2256, 524, 495, 2260, 4883, 2481, 2313, 
4899, 4870, 2472, 538, 2305
2707, 4659, 2441, 534, 2273, 4660, 2442, 535, 2274, 4883, 2481, 2313, 4899, 4884, 2482, 2314, 
4900, 4873, 2474, 539, 2307
2708, 4660, 2442, 535, 2274, 4661, 2443, 536, 2275, 4884, 2482, 2314, 4900, 4885, 2483, 2315, 
4901, 4876, 2476, 540, 2309
2709, 4661, 2443, 536, 2275, 4662, 2444, 537, 2276, 4885, 2483, 2315, 4901, 4886, 2484, 2316, 
4902, 4879, 2478, 541, 2311
2710, 4662, 2444, 537, 2276, 2500, 591, 38, 546, 4886, 2484, 2316, 4902, 2536, 596, 551, 
2540, 4882, 2480, 542, 2312
*ELEMENT, type=C3D20, ELSET=Volume10
2711, 39, 570, 2485, 579, 43, 610, 2557, 619, 574, 2501, 2502, 583, 614, 2573, 2574, 
623, 608, 2545, 4903, 2549
2712, 570, 571, 2486, 2485, 610, 611, 2558, 2557, 575, 2503, 2504, 2501, 615, 2575, 2576, 
2573, 2545, 2546, 4904, 4903
2713, 571, 572, 2487, 2486, 611, 612, 2559, 2558, 576, 2505, 2506, 2503, 616, 2577, 2578, 
2575, 2546, 2547, 4905, 4904
2714, 572, 573, 2488, 2487, 612, 613, 2560, 2559, 577, 2507, 2508, 2505, 617, 2579, 2580, 
2577, 2547, 2548, 4906, 4905
2715, 573, 40, 588, 2488, 613, 44, 628, 2560, 578, 592, 2509, 2507, 618, 632, 2581, 
2579, 2548, 609, 2553, 4906
2716, 579, 2485, 2489, 580, 619, 2557, 2561, 620, 2502, 2510, 2511, 584, 2574, 2582, 2583, 
624, 2549, 4903, 4907, 2550
2717, 2485, 2486, 2490, 2489, 2557, 2558, 2562, 2561, 2504, 2512, 2513, 2510, 2576, 2584, 2585, 
2582, 4903, 4904, 4908, 4907
2718, 2486, 2487, 2491, 2490, 2558, 2559, 2563, 2562, 2506, 2514, 2515, 2512, 2578, 2586, 2587, 
2584, 4904, 4905, 4909, 4908
2719, 2487, 2488, 2492, 2491, 2559, 2560, 2564, 2563, 2508, 2516, 2517, 2514, 2580, 2588, 2589, 
2586, 4905, 4906, 4910, 4909
2720, 2488, 588, 589, 2492, 2560, 628, 629, 2564, 2509, 593, 2518, 2516, 2581, 633, 2590, 
2588, 4906, 2553, 2554, 4910
2721, 580, 2489, 2493, 581, 620, 2561, 2565, 621, 2511, 2519, 2520, 585, 2583, 2591, 2592, 
625, 2550, 4907, 4911, 2551
2722, 2489, 2490, 2494, 2493, 2561, 2562, 2566, 2565, 2513, 2521, 2522, 2519, 2585, 2593, 2594, 
2591, 4907, 4908, 4912, 4911
2723, 2490, 2491, 2495, 2494, 2562, 2563, 2567, 2566, 2515, 2523, 2524, 2521, 2587, 2595, 2596, 
2593, 4908, 4909, 4913, 4912
2724, 2491, 2492, 2496, 2495, 2563, 2564, 2568, 2567, 2517, 2525, 2526, 2523, 2589, 2597, 2598, 
2595, 4909, 4910, 4914, 4913
2725, 2492, 589, 590, 2496, 2564, 629, 630, 2568, 2518, 594, 2527, 2525, 2590, 634, 2599, 
2597, 4910, 2554, 2555, 4914
2726, 581, 2493, 2497, 582, 621, 2565, 2569, 622, 2520, 2528, 2529, 586, 2592, 2600, 2601, 
626, 2551, 4911, 4915, 2552
2727, 2493, 2494, 2498, 2497, 2565, 2566, 2570, 2569, 2522, 2530, 2531, 2528, 2594, 2602, 2603, 
2600, 4911, 4912, 4916, 4915
