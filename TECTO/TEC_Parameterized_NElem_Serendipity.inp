*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Serendipity.inp
*NODE
1, 1, 0.1, 0
2, 0, 0.1, 0
3, 1, 0.1, 1
4, 0, 0.1, 1
5, 1, 0.9, 0
6, 0, 0.9, 0
7, 1, 0.9, 1
8, 0, 0.9, 1
9, 1.2, 0.9, 0
10, 2.2, 0.9, 0
11, 1.2, 0.9, 1
12, 2.2, 0.9, 1
13, 1.2, 0.1, 0
14, 2.2, 0.1, 0
15, 1.2, 0.1, 1
16, 2.2, 0.1, 1
17, 0, 0, 0
18, 1, 0, 0
19, 0, 0, 1
20, 1, 0, 1
21, -0.1, 0, 0
22, -0.1, 0, 1
23, 0, -0.2, 1
24, -0.1, -0.2, 1
25, 0, -0.2, 0
26, -0.1, -0.2, 0
27, 1, -0.2, 1
28, 1, -0.2, 0
29, 0, 1, 0
30, 1, 1, 0
31, 0, 1, 1
32, 1, 1, 1
33, 0, 1.2, 0
34, 1, 1.2, 0
35, 0, 1.2, 1
36, 1, 1.2, 1
37, 1.2, 1.2, 0
38, 1.2, 1, 0
39, 1.2, 1.2, 1
40, 1.2, 1, 1
41, 2.2, 1, 0
42, 2.2, 1, 1
43, 2.2, 1.2, 0
44, 2.2, 1.2, 1
45, 2.2, 9.251858538543e-18, 0
46, 1.2, 9.251858538543e-18, 0
47, 2.2, 9.251858538543e-18, 1
48, 1.2, 9.251858538543e-18, 1
49, 2.2, -0.2, 0
50, 1.2, -0.2, 0
51, 2.2, -0.2, 1
52, 1.2, -0.2, 1
53, 2.3, 9.251858538543e-18, 0
54, 2.3, -0.2, 0
55, 2.3, 9.251858538543e-18, 1
56, 2.3, -0.2, 1
57, 0.5, 0.1, 0
58, 0.75, 0.1, 0
59, 0.25, 0.1, 0
60, 0.5, 0.1, 1
61, 0.75, 0.1, 1
62, 0.25, 0.1, 1
63, 1, 0.1, 0.5
64, 1, 0.1, 0.25
65, 1, 0.1, 0.75
66, 0, 0.1, 0.5
67, 0, 0.1, 0.25
68, 0, 0.1, 0.75
69, 1, 0.5, 0
70, 1, 0.3, 0
71, 1, 0.7, 0
72, 0, 0.5, 0
73, 0, 0.3, 0
74, 0, 0.7, 0
75, 0.5, 0.9, 0
76, 0.75, 0.9, 0
77, 0.25, 0.9, 0
78, 1, 0.5, 1
79, 1, 0.3, 1
80, 1, 0.7, 1
81, 0, 0.5, 1
82, 0, 0.3, 1
83, 0, 0.7, 1
84, 0.5, 0.9, 1
85, 0.75, 0.9, 1
86, 0.25, 0.9, 1
87, 1, 0.9, 0.5
88, 1, 0.9, 0.25
89, 1, 0.9, 0.75
90, 0, 0.9, 0.5
91, 0, 0.9, 0.25
92, 0, 0.9, 0.75
93, 1.7, 0.9, 0
94, 1.45, 0.9, 0
95, 1.95, 0.9, 0
96, 1.7, 0.9, 1
97, 1.45, 0.9, 1
98, 1.95, 0.9, 1
99, 1.2, 0.9, 0.5
100, 1.2, 0.9, 0.25
101, 1.2, 0.9, 0.75
102, 2.2, 0.9, 0.5
103, 2.2, 0.9, 0.25
104, 2.2, 0.9, 0.75
105, 1.2, 0.5, 0
106, 1.2, 0.7, 0
107, 1.2, 0.3, 0
108, 2.2, 0.5, 0
109, 2.2, 0.7, 0
110, 2.2, 0.3, 0
111, 1.7, 0.1, 0
112, 1.45, 0.1, 0
113, 1.95, 0.1, 0
114, 1.2, 0.5, 1
115, 1.2, 0.7, 1
116, 1.2, 0.3, 1
117, 2.2, 0.5, 1
118, 2.2, 0.7, 1
119, 2.2, 0.3, 1
120, 1.7, 0.1, 1
121, 1.45, 0.1, 1
122, 1.95, 0.1, 1
123, 1.2, 0.1, 0.5
124, 1.2, 0.1, 0.25
125, 1.2, 0.1, 0.75
126, 2.2, 0.1, 0.5
127, 2.2, 0.1, 0.25
128, 2.2, 0.1, 0.75
129, 0, 0.05, 0
130, 1, 0.05, 0
131, 0.5, 0, 0
132, 0.75, 0, 0
133, 0.25, 0, 0
134, 0, 0.05, 1
135, 1, 0.05, 1
136, 0.5, 0, 1
137, 0.75, 0, 1
138, 0.25, 0, 1
139, 1, 0, 0.5
140, 1, 0, 0.25
141, 1, 0, 0.75
142, 0, 0, 0.5
143, 0, 0, 0.25
144, 0, 0, 0.75
145, -0.1, 0, 0.5
146, -0.1, 0, 0.25
147, -0.1, 0, 0.75
148, -0.05, 0, 1
149, -0.05, 0, 0
150, 0, -0.1, 1
151, 0, -0.05, 1
152, 0, -0.15, 1
153, -0.05, -0.2, 1
154, -0.1, -0.1, 1
155, -0.1, -0.15, 1
156, -0.1, -0.05, 1
157, -0.05, -0.2, 0
158, -0.1, -0.2, 0.5
159, -0.1, -0.2, 0.25
160, -0.1, -0.2, 0.75
161, 0, -0.2, 0.5
162, 0, -0.2, 0.25
163, 0, -0.2, 0.75
164, 0, -0.1, 0
165, 0, -0.05, 0
166, 0, -0.15, 0
167, -0.1, -0.1, 0
168, -0.1, -0.15, 0
169, -0.1, -0.05, 0
170, 1, -0.1, 1
171, 1, -0.05, 1
172, 1, -0.15, 1
173, 0.5, -0.2, 1
174, 0.75, -0.2, 1
175, 0.25, -0.2, 1
176, 0.5, -0.2, 0
177, 0.75, -0.2, 0
178, 0.25, -0.2, 0
179, 1, -0.2, 0.5
180, 1, -0.2, 0.25
181, 1, -0.2, 0.75
182, 1, -0.1, 0
183, 1, -0.05, 0
184, 1, -0.15, 0
185, 0, 0.95, 0
186, 0.5, 1, 0
187, 0.75, 1, 0
188, 0.25, 1, 0
189, 1, 0.95, 0
190, 0, 0.95, 1
191, 0.5, 1, 1
192, 0.75, 1, 1
193, 0.25, 1, 1
194, 1, 0.95, 1
195, 1, 1, 0.5
196, 1, 1, 0.25
197, 1, 1, 0.75
198, 0, 1, 0.5
199, 0, 1, 0.25
200, 0, 1, 0.75
201, 0, 1.1, 0
202, 0, 1.05, 0
203, 0, 1.15, 0
204, 0.5, 1.2, 0
205, 0.25, 1.2, 0
206, 0.75, 1.2, 0
207, 1, 1.1, 0
208, 1, 1.05, 0
209, 1, 1.15, 0
210, 0, 1.1, 1
211, 0, 1.05, 1
212, 0, 1.15, 1
213, 0.5, 1.2, 1
214, 0.25, 1.2, 1
215, 0.75, 1.2, 1
216, 1, 1.1, 1
217, 1, 1.05, 1
218, 1, 1.15, 1
219, 1, 1.2, 0.5
220, 1, 1.2, 0.25
221, 1, 1.2, 0.75
222, 0, 1.2, 0.5
223, 0, 1.2, 0.25
224, 0, 1.2, 0.75
225, 1.1, 1.2, 0
226, 1.2, 1.1, 0
227, 1.2, 1.05, 0
228, 1.2, 1.15, 0
229, 1.1, 1, 0
230, 1.1, 1.2, 1
231, 1.2, 1.1, 1
232, 1.2, 1.05, 1
233, 1.2, 1.15, 1
234, 1.1, 1, 1
235, 1.2, 1, 0.5
236, 1.2, 1, 0.25
237, 1.2, 1, 0.75
238, 1.2, 1.2, 0.5
239, 1.2, 1.2, 0.25
240, 1.2, 1.2, 0.75
241, 1.7, 1, 0
242, 1.45, 1, 0
243, 1.95, 1, 0
244, 2.2, 0.95, 0
245, 1.2, 0.95, 0
246, 1.7, 1, 1
247, 1.45, 1, 1
248, 1.95, 1, 1
249, 2.2, 0.95, 1
250, 1.2, 0.95, 1
251, 2.2, 1, 0.5
252, 2.2, 1, 0.25
253, 2.2, 1, 0.75
254, 1.7, 1.2, 0
255, 1.45, 1.2, 0
256, 1.95, 1.2, 0
257, 2.2, 1.1, 0
258, 2.2, 1.15, 0
259, 2.2, 1.05, 0
260, 1.7, 1.2, 1
261, 1.45, 1.2, 1
262, 1.95, 1.2, 1
263, 2.2, 1.1, 1
264, 2.2, 1.15, 1
265, 2.2, 1.05, 1
266, 2.2, 1.2, 0.5
267, 2.2, 1.2, 0.25
268, 2.2, 1.2, 0.75
269, 2.2, 0.05, 0
270, 1.7, -2.7755575615629e-17, 0
271, 1.45, 0, 0
272, 1.95, 0, 0
273, 1.2, 0.05, 0
274, 2.2, 0.05, 1
275, 1.7, -2.7755575615629e-17, 1
276, 1.45, 0, 1
277, 1.95, 0, 1
278, 1.2, 0.05, 1
279, 1.2, -2.7755575615629e-17, 0.5
280, 1.2, 0, 0.25
281, 1.2, 0, 0.75
282, 2.2, -2.7755575615629e-17, 0.5
283, 2.2, 0, 0.25
284, 2.2, 0, 0.75
285, 2.2, -0.1, 0
286, 2.2, -0.05, 0
287, 2.2, -0.15, 0
288, 1.7, -0.2, 0
289, 2, -0.2, 0
290, 1.5, -0.2, 0
291, 1.2, -0.1, 0
292, 1.2, -0.15, 0
293, 1.2, -0.05, 0
294, 2.2, -0.1, 1
295, 2.2, -0.05, 1
296, 2.2, -0.15, 1
297, 1.7, -0.2, 1
298, 2, -0.2, 1
299, 1.5, -0.2, 1
300, 1.2, -0.1, 1
301, 1.2, -0.15, 1
302, 1.2, -0.05, 1
303, 1.2, -0.2, 0.5
304, 1.2, -0.2, 0.25
305, 1.2, -0.2, 0.75
306, 2.2, -0.2, 0.5
307, 2.2, -0.2, 0.25
308, 2.2, -0.2, 0.75
309, 2.25, 0, 0
310, 2.3, -0.1, 0
311, 2.3, -0.05, 0
312, 2.3, -0.15, 0
313, 2.25, -0.2, 0
314, 2.25, 0, 1
315, 2.3, -0.1, 1
316, 2.3, -0.05, 1
317, 2.3, -0.15, 1
318, 2.25, -0.2, 1
319, 2.3, -2.7755575615629e-17, 0.5
320, 2.3, 0, 0.25
321, 2.3, 0, 0.75
322, 2.3, -0.2, 0.5
323, 2.3, -0.2, 0.25
324, 2.3, -0.2, 0.75
325, 0.5, 0.1, 0.5
326, 0.5, 0.1, 0.25
327, 0.75, 0.1, 0.5
328, 0.25, 0.1, 0.5
329, 0.5, 0.1, 0.75
330, 0.5, 0.5, 0
331, 0.5, 0.3, 0
332, 0.75, 0.5, 0
333, 0.5, 0.7, 0
334, 0.25, 0.5, 0
335, 0.5, 0.5, 1
336, 0.75, 0.5, 1
337, 0.5, 0.3, 1
338, 0.5, 0.7, 1
339, 0.25, 0.5, 1
340, 1, 0.5, 0.5
341, 1, 0.5, 0.25
342, 1, 0.3, 0.5
343, 1, 0.7, 0.5
344, 1, 0.5, 0.75
345, 0, 0.5, 0.5
346, 0, 0.3, 0.5
347, 0, 0.5, 0.25
348, 0, 0.7, 0.5
349, 0, 0.5, 0.75
350, 0.5, 0.9, 0.5
351, 0.5, 0.9, 0.25
352, 0.75, 0.9, 0.5
353, 0.25, 0.9, 0.5
354, 0.5, 0.9, 0.75
355, 1.7, 0.9, 0.5
356, 1.7, 0.9, 0.25
357, 1.45, 0.9, 0.5
358, 1.95, 0.9, 0.5
359, 1.7, 0.9, 0.75
360, 1.7, 0.5, 0
361, 1.7, 0.7, 0
362, 1.45, 0.5, 0
363, 1.7, 0.3, 0
364, 1.95, 0.5, 0
365, 1.7, 0.5, 1
366, 1.45, 0.5, 1
367, 1.7, 0.7, 1
368, 1.7, 0.3, 1
369, 1.95, 0.5, 1
370, 1.2, 0.5, 0.5
371, 1.2, 0.5, 0.25
372, 1.2, 0.7, 0.5
373, 1.2, 0.3, 0.5
374, 1.2, 0.5, 0.75
375, 2.2, 0.5, 0.5
376, 2.2, 0.7, 0.5
377, 2.2, 0.5, 0.25
378, 2.2, 0.3, 0.5
379, 2.2, 0.5, 0.75
380, 1.7, 0.1, 0.5
381, 1.7, 0.1, 0.25
382, 1.45, 0.1, 0.5
383, 1.95, 0.1, 0.5
384, 1.7, 0.1, 0.75
385, 0.5, 0.05, 0
386, 0.5, 0.05, 1
387, 1, 0.05, 0.5
388, 0, 0.05, 0.5
389, 0.5, 0, 0.5
390, 0.75, 0, 0.5
391, 0.5, 0, 0.25
392, 0.25, 0, 0.5
393, 0.5, 0, 0.75
394, -0.05, 0, 0.5
395, -0.05, -0.1, 1
396, -0.05, -0.2, 0.5
397, -0.05, -0.1, 0
398, 0, -0.1, 0.5
399, 0, -0.05, 0.5
400, 0, -0.1, 0.25
401, 0, -0.15, 0.5
402, 0, -0.1, 0.75
403, -0.1, -0.1, 0.5
404, -0.1, -0.15, 0.5
405, -0.1, -0.1, 0.25
406, -0.1, -0.05, 0.5
407, -0.1, -0.1, 0.75
408, 0.5, -0.1, 1
409, 0.5, -0.05, 1
410, 0.75, -0.1, 1
411, 0.25, -0.1, 1
412, 0.5, -0.15, 1
413, 0.5, -0.2, 0.5
414, 0.75, -0.2, 0.5
415, 0.5, -0.2, 0.25
416, 0.25, -0.2, 0.5
417, 0.5, -0.2, 0.75
418, 0.5, -0.1, 0
419, 0.75, -0.1, 0
420, 0.5, -0.05, 0
421, 0.25, -0.1, 0
422, 0.5, -0.15, 0
423, 1, -0.1, 0.5
424, 1, -0.05, 0.5
425, 1, -0.1, 0.25
426, 1, -0.15, 0.5
427, 1, -0.1, 0.75
428, 0.5, 0.95, 0
429, 0.5, 0.95, 1
430, 1, 0.95, 0.5
431, 0, 0.95, 0.5
432, 0.5, 1, 0.5
433, 0.5, 1, 0.25
434, 0.75, 1, 0.5
435, 0.25, 1, 0.5
436, 0.5, 1, 0.75
437, 0.5, 1.1, 0
438, 0.5, 1.05, 0
439, 0.75, 1.1, 0
440, 0.5, 1.15, 0
441, 0.25, 1.1, 0
442, 0.5, 1.1, 1
443, 0.75, 1.1, 1
444, 0.5, 1.05, 1
445, 0.5, 1.15, 1
446, 0.25, 1.1, 1
447, 1, 1.1, 0.5
448, 1, 1.1, 0.25
449, 1, 1.05, 0.5
450, 1, 1.15, 0.5
451, 1, 1.1, 0.75
452, 0, 1.1, 0.5
453, 0, 1.05, 0.5
454, 0, 1.1, 0.25
455, 0, 1.15, 0.5
456, 0, 1.1, 0.75
457, 0.5, 1.2, 0.5
458, 0.5, 1.2, 0.25
459, 0.75, 1.2, 0.5
460, 0.25, 1.2, 0.5
461, 0.5, 1.2, 0.75
462, 1.1, 1.1, 0
463, 1.1, 1.1, 1
464, 1.1, 1, 0.5
465, 1.1, 1.2, 0.5
466, 1.2, 1.1, 0.5
467, 1.2, 1.1, 0.25
468, 1.2, 1.05, 0.5
469, 1.2, 1.15, 0.5
470, 1.2, 1.1, 0.75
471, 1.7, 0.95, 0
472, 1.7, 0.95, 1
473, 1.2, 0.95, 0.5
474, 2.2, 0.95, 0.5
475, 1.7, 1, 0.5
476, 1.45, 1, 0.5
477, 1.7, 1, 0.25
478, 1.95, 1, 0.5
479, 1.7, 1, 0.75
480, 1.7, 1.1, 0
481, 1.45, 1.1, 0
482, 1.7, 1.05, 0
483, 1.95, 1.1, 0
484, 1.7, 1.15, 0
485, 1.7, 1.1, 1
486, 1.7, 1.05, 1
487, 1.45, 1.1, 1
488, 1.95, 1.1, 1
489, 1.7, 1.15, 1
490, 1.7, 1.2, 0.5
491, 1.45, 1.2, 0.5
492, 1.7, 1.2, 0.25
493, 1.95, 1.2, 0.5
494, 1.7, 1.2, 0.75
495, 2.2, 1.1, 0.5
496, 2.2, 1.1, 0.25
497, 2.2, 1.05, 0.5
498, 2.2, 1.15, 0.5
499, 2.2, 1.1, 0.75
500, 1.7, 0.05, 0
501, 1.7, 0.05, 1
502, 1.2, 0.05, 0.5
503, 2.2, 0.05, 0.5
504, 1.7, -2.7755575615629e-17, 0.5
505, 1.7, 0, 0.25
506, 1.45, 0, 0.5
507, 1.95, 0, 0.5
508, 1.7, 0, 0.75
509, 1.7, -0.1, 0
510, 1.7, -0.05, 0
511, 1.45, -0.1, 0
512, 1.75, -0.15, 0
513, 1.95, -0.1, 0
514, 1.7, -0.1, 1
515, 1.45, -0.1, 1
516, 1.7, -0.05, 1
517, 1.75, -0.15, 1
518, 1.95, -0.1, 1
519, 1.2, -0.1, 0.5
520, 1.2, -0.1, 0.25
521, 1.2, -0.05, 0.5
522, 1.2, -0.15, 0.5
523, 1.2, -0.1, 0.75
524, 2.2, -0.1, 0.5
525, 2.2, -0.05, 0.5
526, 2.2, -0.1, 0.25
527, 2.2, -0.15, 0.5
528, 2.2, -0.1, 0.75
529, 1.7, -0.2, 0.5
530, 1.75, -0.2, 0.25
531, 1.45, -0.2, 0.5
532, 1.95, -0.2, 0.5
533, 1.75, -0.2, 0.75
534, 2.25, -0.1, 0
535, 2.25, -0.1, 1
536, 2.25, 0, 0.5
537, 2.25, -0.2, 0.5
538, 2.3, -0.1, 0.5
539, 2.3, -0.05, 0.5
540, 2.3, -0.1, 0.25
541, 2.3, -0.15, 0.5
542, 2.3, -0.1, 0.75
543, 0.5, -0.1, 0.5
544, 0.75, -0.1, 0.5
545, 0.5, -0.05, 0.5
546, 0.5, -0.1, 0.25
547, 0.25, -0.1, 0.5
548, 0.5, -0.15, 0.5
549, 0.5, -0.1, 0.75
550, -0.05, -0.1, 0.5
551, 0.5, 0.05, 0.5
552, 0.5, 0.5, 0.5
553, 0.5, 0.3, 0.5
554, 0.5, 0.5, 0.25
555, 0.75, 0.5, 0.5
556, 0.5, 0.7, 0.5
557, 0.25, 0.5, 0.5
558, 0.5, 0.5, 0.75
559, 0.5, 0.95, 0.5
560, 0.5, 1.1, 0.5
561, 0.5, 1.05, 0.5
562, 0.5, 1.1, 0.25
563, 0.75, 1.1, 0.5
564, 0.5, 1.15, 0.5
565, 0.25, 1.1, 0.5
566, 0.5, 1.1, 0.75
567, 1.1, 1.1, 0.5
568, 1.7, 1.1, 0.5
569, 1.45, 1.1, 0.5
570, 1.7, 1.1, 0.25
571, 1.7, 1.05, 0.5
572, 1.95, 1.1, 0.5
573, 1.7, 1.15, 0.5
574, 1.7, 1.1, 0.75
575, 1.7, 0.95, 0.5
576, 1.7, 0.5, 0.5
577, 1.7, 0.7, 0.5
578, 1.7, 0.5, 0.25
579, 1.45, 0.5, 0.5
580, 1.7, 0.3, 0.5
581, 1.95, 0.5, 0.5
582, 1.7, 0.5, 0.75
583, 1.7, 0.05, 0.5
584, 1.7, -0.1, 0.5
585, 1.7, -0.05, 0.5
586, 1.7, -0.1, 0.25
587, 1.45, -0.1, 0.5
588, 1.7, -0.15, 0.5
589, 1.95, -0.1, 0.5
590, 1.7, -0.1, 0.75
591, 2.25, -0.1, 0.5
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line67
57, 1, 58, 57
58, 57, 59, 2
*ELEMENT, type=T3D3, ELSET=Line70
59, 3, 61, 60
60, 60, 62, 4
*ELEMENT, type=T3D3, ELSET=Line71
61, 1, 64, 63
62, 63, 65, 3
*ELEMENT, type=T3D3, ELSET=Line72
63, 2, 67, 66
64, 66, 68, 4
*ELEMENT, type=T3D3, ELSET=Line73
65, 1, 70, 69
66, 69, 71, 5
*ELEMENT, type=T3D3, ELSET=Line74
67, 2, 73, 72
68, 72, 74, 6
*ELEMENT, type=T3D3, ELSET=Line75
69, 5, 76, 75
70, 75, 77, 6
*ELEMENT, type=T3D3, ELSET=Line76
71, 3, 79, 78
72, 78, 80, 7
*ELEMENT, type=T3D3, ELSET=Line77
73, 4, 82, 81
74, 81, 83, 8
*ELEMENT, type=T3D3, ELSET=Line78
75, 7, 85, 84
76, 84, 86, 8
*ELEMENT, type=T3D3, ELSET=Line79
77, 5, 88, 87
78, 87, 89, 7
*ELEMENT, type=T3D3, ELSET=Line80
79, 6, 91, 90
80, 90, 92, 8
*ELEMENT, type=T3D3, ELSET=Line115
81, 9, 94, 93
82, 93, 95, 10
*ELEMENT, type=T3D3, ELSET=Line118
83, 11, 97, 96
84, 96, 98, 12
*ELEMENT, type=T3D3, ELSET=Line119
85, 9, 100, 99
86, 99, 101, 11
*ELEMENT, type=T3D3, ELSET=Line120
87, 10, 103, 102
88, 102, 104, 12
*ELEMENT, type=T3D3, ELSET=Line121
89, 9, 106, 105
90, 105, 107, 13
*ELEMENT, type=T3D3, ELSET=Line122
91, 10, 109, 108
92, 108, 110, 14
*ELEMENT, type=T3D3, ELSET=Line123
93, 13, 112, 111
94, 111, 113, 14
*ELEMENT, type=T3D3, ELSET=Line124
95, 11, 115, 114
96, 114, 116, 15
*ELEMENT, type=T3D3, ELSET=Line125
97, 12, 118, 117
98, 117, 119, 16
*ELEMENT, type=T3D3, ELSET=Line126
99, 15, 121, 120
100, 120, 122, 16
*ELEMENT, type=T3D3, ELSET=Line127
101, 13, 124, 123
102, 123, 125, 15
*ELEMENT, type=T3D3, ELSET=Line128
103, 14, 127, 126
104, 126, 128, 16
*ELEMENT, type=T3D3, ELSET=Line129
105, 17, 129, 2
*ELEMENT, type=T3D3, ELSET=Line130
106, 18, 130, 1
*ELEMENT, type=T3D3, ELSET=Line131
107, 18, 132, 131
108, 131, 133, 17
*ELEMENT, type=T3D3, ELSET=Line132
109, 19, 134, 4
*ELEMENT, type=T3D3, ELSET=Line133
110, 20, 135, 3
*ELEMENT, type=T3D3, ELSET=Line134
111, 20, 137, 136
112, 136, 138, 19
*ELEMENT, type=T3D3, ELSET=Line135
113, 18, 140, 139
114, 139, 141, 20
*ELEMENT, type=T3D3, ELSET=Line136
115, 17, 143, 142
116, 142, 144, 19
*ELEMENT, type=T3D3, ELSET=Line137
117, 21, 146, 145
118, 145, 147, 22
*ELEMENT, type=T3D3, ELSET=Line138
119, 22, 148, 19
*ELEMENT, type=T3D3, ELSET=Line139
120, 21, 149, 17
*ELEMENT, type=T3D3, ELSET=Line140
121, 19, 151, 150
122, 150, 152, 23
*ELEMENT, type=T3D3, ELSET=Line141
123, 23, 153, 24
*ELEMENT, type=T3D3, ELSET=Line142
124, 24, 155, 154
125, 154, 156, 22
*ELEMENT, type=T3D3, ELSET=Line143
126, 25, 157, 26
*ELEMENT, type=T3D3, ELSET=Line144
127, 26, 159, 158
128, 158, 160, 24
*ELEMENT, type=T3D3, ELSET=Line145
129, 25, 162, 161
130, 161, 163, 23
*ELEMENT, type=T3D3, ELSET=Line146
131, 17, 165, 164
132, 164, 166, 25
*ELEMENT, type=T3D3, ELSET=Line147
133, 26, 168, 167
134, 167, 169, 21
*ELEMENT, type=T3D3, ELSET=Line148
135, 20, 171, 170
136, 170, 172, 27
*ELEMENT, type=T3D3, ELSET=Line149
137, 27, 174, 173
138, 173, 175, 23
*ELEMENT, type=T3D3, ELSET=Line150
139, 28, 177, 176
140, 176, 178, 25
*ELEMENT, type=T3D3, ELSET=Line151
141, 28, 180, 179
142, 179, 181, 27
*ELEMENT, type=T3D3, ELSET=Line152
143, 18, 183, 182
144, 182, 184, 28
*ELEMENT, type=T3D3, ELSET=Line153
145, 6, 185, 29
*ELEMENT, type=T3D3, ELSET=Line154
146, 30, 187, 186
147, 186, 188, 29
*ELEMENT, type=T3D3, ELSET=Line155
148, 30, 189, 5
*ELEMENT, type=T3D3, ELSET=Line156
149, 8, 190, 31
*ELEMENT, type=T3D3, ELSET=Line157
150, 32, 192, 191
151, 191, 193, 31
*ELEMENT, type=T3D3, ELSET=Line158
152, 32, 194, 7
*ELEMENT, type=T3D3, ELSET=Line159
153, 30, 196, 195
154, 195, 197, 32
*ELEMENT, type=T3D3, ELSET=Line160
155, 29, 199, 198
156, 198, 200, 31
*ELEMENT, type=T3D3, ELSET=Line161
157, 29, 202, 201
158, 201, 203, 33
*ELEMENT, type=T3D3, ELSET=Line162
159, 33, 205, 204
160, 204, 206, 34
*ELEMENT, type=T3D3, ELSET=Line163
161, 30, 208, 207
162, 207, 209, 34
*ELEMENT, type=T3D3, ELSET=Line164
163, 31, 211, 210
164, 210, 212, 35
*ELEMENT, type=T3D3, ELSET=Line165
165, 35, 214, 213
166, 213, 215, 36
*ELEMENT, type=T3D3, ELSET=Line166
167, 32, 217, 216
168, 216, 218, 36
*ELEMENT, type=T3D3, ELSET=Line167
169, 34, 220, 219
170, 219, 221, 36
*ELEMENT, type=T3D3, ELSET=Line168
171, 33, 223, 222
172, 222, 224, 35
*ELEMENT, type=T3D3, ELSET=Line169
173, 34, 225, 37
*ELEMENT, type=T3D3, ELSET=Line170
174, 38, 227, 226
175, 226, 228, 37
*ELEMENT, type=T3D3, ELSET=Line171
176, 38, 229, 30
*ELEMENT, type=T3D3, ELSET=Line172
177, 36, 230, 39
*ELEMENT, type=T3D3, ELSET=Line173
178, 40, 232, 231
179, 231, 233, 39
*ELEMENT, type=T3D3, ELSET=Line174
180, 40, 234, 32
*ELEMENT, type=T3D3, ELSET=Line175
181, 38, 236, 235
182, 235, 237, 40
*ELEMENT, type=T3D3, ELSET=Line176
183, 37, 239, 238
184, 238, 240, 39
*ELEMENT, type=T3D3, ELSET=Line177
185, 38, 242, 241
186, 241, 243, 41
*ELEMENT, type=T3D3, ELSET=Line178
187, 41, 244, 10
*ELEMENT, type=T3D3, ELSET=Line179
188, 9, 245, 38
*ELEMENT, type=T3D3, ELSET=Line180
189, 40, 247, 246
190, 246, 248, 42
*ELEMENT, type=T3D3, ELSET=Line181
191, 42, 249, 12
*ELEMENT, type=T3D3, ELSET=Line182
192, 11, 250, 40
*ELEMENT, type=T3D3, ELSET=Line183
193, 41, 252, 251
194, 251, 253, 42
*ELEMENT, type=T3D3, ELSET=Line184
195, 37, 255, 254
196, 254, 256, 43
*ELEMENT, type=T3D3, ELSET=Line185
197, 43, 258, 257
198, 257, 259, 41
*ELEMENT, type=T3D3, ELSET=Line186
199, 39, 261, 260
200, 260, 262, 44
*ELEMENT, type=T3D3, ELSET=Line187
201, 44, 264, 263
202, 263, 265, 42
*ELEMENT, type=T3D3, ELSET=Line188
203, 43, 267, 266
204, 266, 268, 44
*ELEMENT, type=T3D3, ELSET=Line189
205, 14, 269, 45
*ELEMENT, type=T3D3, ELSET=Line190
206, 46, 271, 270
207, 270, 272, 45
*ELEMENT, type=T3D3, ELSET=Line191
208, 46, 273, 13
*ELEMENT, type=T3D3, ELSET=Line192
209, 16, 274, 47
*ELEMENT, type=T3D3, ELSET=Line193
210, 48, 276, 275
211, 275, 277, 47
*ELEMENT, type=T3D3, ELSET=Line194
212, 48, 278, 15
*ELEMENT, type=T3D3, ELSET=Line195
213, 46, 280, 279
214, 279, 281, 48
*ELEMENT, type=T3D3, ELSET=Line196
215, 45, 283, 282
216, 282, 284, 47
*ELEMENT, type=T3D3, ELSET=Line197
217, 45, 286, 285
218, 285, 287, 49
*ELEMENT, type=T3D3, ELSET=Line198
219, 49, 289, 288
220, 288, 290, 50
*ELEMENT, type=T3D3, ELSET=Line199
221, 50, 292, 291
222, 291, 293, 46
*ELEMENT, type=T3D3, ELSET=Line200
223, 47, 295, 294
224, 294, 296, 51
*ELEMENT, type=T3D3, ELSET=Line201
225, 51, 298, 297
226, 297, 299, 52
*ELEMENT, type=T3D3, ELSET=Line202
227, 52, 301, 300
228, 300, 302, 48
*ELEMENT, type=T3D3, ELSET=Line203
229, 50, 304, 303
230, 303, 305, 52
*ELEMENT, type=T3D3, ELSET=Line204
231, 49, 307, 306
232, 306, 308, 51
*ELEMENT, type=T3D3, ELSET=Line205
233, 45, 309, 53
*ELEMENT, type=T3D3, ELSET=Line206
234, 53, 311, 310
235, 310, 312, 54
*ELEMENT, type=T3D3, ELSET=Line207
236, 54, 313, 49
*ELEMENT, type=T3D3, ELSET=Line208
237, 47, 314, 55
*ELEMENT, type=T3D3, ELSET=Line209
238, 55, 316, 315
239, 315, 317, 56
*ELEMENT, type=T3D3, ELSET=Line210
240, 56, 318, 51
*ELEMENT, type=T3D3, ELSET=Line211
241, 53, 320, 319
242, 319, 321, 55
*ELEMENT, type=T3D3, ELSET=Line212
243, 54, 323, 322
244, 322, 324, 56
*ELEMENT, type=CPS8, ELSET=Surface33
245, 1, 57, 325, 63, 58, 326, 327, 64
246, 57, 2, 66, 325, 59, 67, 328, 326
247, 63, 325, 60, 3, 327, 329, 61, 65
248, 325, 66, 4, 60, 328, 68, 62, 329
*ELEMENT, type=CPS8, ELSET=Surface34
249, 1, 57, 330, 69, 58, 331, 332, 70
250, 69, 330, 75, 5, 332, 333, 76, 71
251, 57, 2, 72, 330, 59, 73, 334, 331
252, 330, 72, 6, 75, 334, 74, 77, 333
*ELEMENT, type=CPS8, ELSET=Surface35
253, 3, 78, 335, 60, 79, 336, 337, 61
254, 78, 7, 84, 335, 80, 85, 338, 336
255, 60, 335, 81, 4, 337, 339, 82, 62
256, 335, 84, 8, 81, 338, 86, 83, 339
*ELEMENT, type=CPS8, ELSET=Surface36
257, 1, 69, 340, 63, 70, 341, 342, 64
258, 69, 5, 87, 340, 71, 88, 343, 341
259, 63, 340, 78, 3, 342, 344, 79, 65
260, 340, 87, 7, 78, 343, 89, 80, 344
*ELEMENT, type=CPS8, ELSET=Surface37
261, 2, 66, 345, 72, 67, 346, 347, 73
262, 72, 345, 90, 6, 347, 348, 91, 74
263, 66, 4, 81, 345, 68, 82, 349, 346
264, 345, 81, 8, 90, 349, 83, 92, 348
*ELEMENT, type=CPS8, ELSET=Surface38
265, 5, 75, 350, 87, 76, 351, 352, 88
266, 75, 6, 90, 350, 77, 91, 353, 351
267, 87, 350, 84, 7, 352, 354, 85, 89
268, 350, 90, 8, 84, 353, 92, 86, 354
*ELEMENT, type=CPS8, ELSET=Surface63
269, 9, 93, 355, 99, 94, 356, 357, 100
270, 93, 10, 102, 355, 95, 103, 358, 356
271, 99, 355, 96, 11, 357, 359, 97, 101
272, 355, 102, 12, 96, 358, 104, 98, 359
*ELEMENT, type=CPS8, ELSET=Surface64
273, 9, 93, 360, 105, 94, 361, 362, 106
274, 105, 360, 111, 13, 362, 363, 112, 107
275, 93, 10, 108, 360, 95, 109, 364, 361
276, 360, 108, 14, 111, 364, 110, 113, 363
*ELEMENT, type=CPS8, ELSET=Surface65
277, 11, 114, 365, 96, 115, 366, 367, 97
278, 114, 15, 120, 365, 116, 121, 368, 366
279, 96, 365, 117, 12, 367, 369, 118, 98
280, 365, 120, 16, 117, 368, 122, 119, 369
*ELEMENT, type=CPS8, ELSET=Surface66
281, 9, 105, 370, 99, 106, 371, 372, 100
282, 105, 13, 123, 370, 107, 124, 373, 371
283, 99, 370, 114, 11, 372, 374, 115, 101
284, 370, 123, 15, 114, 373, 125, 116, 374
*ELEMENT, type=CPS8, ELSET=Surface67
285, 10, 102, 375, 108, 103, 376, 377, 109
286, 108, 375, 126, 14, 377, 378, 127, 110
287, 102, 12, 117, 375, 104, 118, 379, 376
288, 375, 117, 16, 126, 379, 119, 128, 378
*ELEMENT, type=CPS8, ELSET=Surface68
289, 13, 111, 380, 123, 112, 381, 382, 124
290, 111, 14, 126, 380, 113, 127, 383, 381
291, 123, 380, 120, 15, 382, 384, 121, 125
292, 380, 126, 16, 120, 383, 128, 122, 384
*ELEMENT, type=CPS8, ELSET=Surface69
293, 18, 131, 57, 1, 132, 385, 58, 130
294, 131, 17, 2, 57, 133, 129, 59, 385
*ELEMENT, type=CPS8, ELSET=Surface70
295, 20, 3, 60, 136, 135, 61, 386, 137
296, 136, 60, 4, 19, 386, 62, 134, 138
*ELEMENT, type=CPS8, ELSET=Surface71
297, 18, 1, 63, 139, 130, 64, 387, 140
298, 139, 63, 3, 20, 387, 65, 135, 141
*ELEMENT, type=CPS8, ELSET=Surface72
299, 17, 142, 66, 2, 143, 388, 67, 129
300, 142, 19, 4, 66, 144, 134, 68, 388
*ELEMENT, type=CPS8, ELSET=Surface73
301, 18, 139, 389, 131, 140, 390, 391, 132
302, 131, 389, 142, 17, 391, 392, 143, 133
303, 139, 20, 136, 389, 141, 137, 393, 390
304, 389, 136, 19, 142, 393, 138, 144, 392
*ELEMENT, type=CPS8, ELSET=Surface74
305, 17, 21, 145, 142, 149, 146, 394, 143
306, 142, 145, 22, 19, 394, 147, 148, 144
*ELEMENT, type=CPS8, ELSET=Surface75
307, 19, 22, 154, 150, 148, 156, 395, 151
308, 150, 154, 24, 23, 395, 155, 153, 152
*ELEMENT, type=CPS8, ELSET=Surface76
309, 25, 161, 158, 26, 162, 396, 159, 157
310, 161, 23, 24, 158, 163, 153, 160, 396
*ELEMENT, type=CPS8, ELSET=Surface77
311, 17, 164, 167, 21, 165, 397, 169, 149
312, 164, 25, 26, 167, 166, 157, 168, 397
*ELEMENT, type=CPS8, ELSET=Surface78
313, 17, 142, 398, 164, 143, 399, 400, 165
314, 164, 398, 161, 25, 400, 401, 162, 166
315, 142, 19, 150, 398, 144, 151, 402, 399
316, 398, 150, 23, 161, 402, 152, 163, 401
*ELEMENT, type=CPS8, ELSET=Surface79
317, 26, 158, 403, 167, 159, 404, 405, 168
318, 167, 403, 145, 21, 405, 406, 146, 169
319, 158, 24, 154, 403, 160, 155, 407, 404
320, 403, 154, 22, 145, 407, 156, 147, 406
*ELEMENT, type=CPS8, ELSET=Surface80
321, 20, 136, 408, 170, 137, 409, 410, 171
322, 136, 19, 150, 408, 138, 151, 411, 409
323, 170, 408, 173, 27, 410, 412, 174, 172
324, 408, 150, 23, 173, 411, 152, 175, 412
*ELEMENT, type=CPS8, ELSET=Surface81
325, 28, 179, 413, 176, 180, 414, 415, 177
326, 176, 413, 161, 25, 415, 416, 162, 178
327, 179, 27, 173, 413, 181, 174, 417, 414
328, 413, 173, 23, 161, 417, 175, 163, 416
*ELEMENT, type=CPS8, ELSET=Surface82
329, 18, 182, 418, 131, 183, 419, 420, 132
330, 131, 418, 164, 17, 420, 421, 165, 133
331, 182, 28, 176, 418, 184, 177, 422, 419
332, 418, 176, 25, 164, 422, 178, 166, 421
*ELEMENT, type=CPS8, ELSET=Surface83
333, 18, 139, 423, 182, 140, 424, 425, 183
334, 182, 423, 179, 28, 425, 426, 180, 184
335, 139, 20, 170, 423, 141, 171, 427, 424
336, 423, 170, 27, 179, 427, 172, 181, 426
*ELEMENT, type=CPS8, ELSET=Surface84
337, 5, 75, 186, 30, 76, 428, 187, 189
338, 75, 6, 29, 186, 77, 185, 188, 428
*ELEMENT, type=CPS8, ELSET=Surface85
339, 7, 32, 191, 84, 194, 192, 429, 85
340, 84, 191, 31, 8, 429, 193, 190, 86
*ELEMENT, type=CPS8, ELSET=Surface86
341, 5, 30, 195, 87, 189, 196, 430, 88
342, 87, 195, 32, 7, 430, 197, 194, 89
*ELEMENT, type=CPS8, ELSET=Surface87
343, 6, 90, 198, 29, 91, 431, 199, 185
344, 90, 8, 31, 198, 92, 190, 200, 431
*ELEMENT, type=CPS8, ELSET=Surface88
345, 30, 186, 432, 195, 187, 433, 434, 196
346, 186, 29, 198, 432, 188, 199, 435, 433
347, 195, 432, 191, 32, 434, 436, 192, 197
348, 432, 198, 31, 191, 435, 200, 193, 436
*ELEMENT, type=CPS8, ELSET=Surface89
349, 30, 186, 437, 207, 187, 438, 439, 208
350, 207, 437, 204, 34, 439, 440, 206, 209
351, 186, 29, 201, 437, 188, 202, 441, 438
352, 437, 201, 33, 204, 441, 203, 205, 440
*ELEMENT, type=CPS8, ELSET=Surface90
353, 32, 216, 442, 191, 217, 443, 444, 192
354, 216, 36, 213, 442, 218, 215, 445, 443
355, 191, 442, 210, 31, 444, 446, 211, 193
356, 442, 213, 35, 210, 445, 214, 212, 446
*ELEMENT, type=CPS8, ELSET=Surface91
357, 30, 207, 447, 195, 208, 448, 449, 196
358, 207, 34, 219, 447, 209, 220, 450, 448
359, 195, 447, 216, 32, 449, 451, 217, 197
360, 447, 219, 36, 216, 450, 221, 218, 451
*ELEMENT, type=CPS8, ELSET=Surface92
361, 29, 198, 452, 201, 199, 453, 454, 202
362, 201, 452, 222, 33, 454, 455, 223, 203
363, 198, 31, 210, 452, 200, 211, 456, 453
364, 452, 210, 35, 222, 456, 212, 224, 455
*ELEMENT, type=CPS8, ELSET=Surface93
365, 34, 204, 457, 219, 206, 458, 459, 220
366, 204, 33, 222, 457, 205, 223, 460, 458
367, 219, 457, 213, 36, 459, 461, 215, 221
368, 457, 222, 35, 213, 460, 224, 214, 461
*ELEMENT, type=CPS8, ELSET=Surface94
369, 30, 207, 226, 38, 208, 462, 227, 229
370, 207, 34, 37, 226, 209, 225, 228, 462
*ELEMENT, type=CPS8, ELSET=Surface95
371, 32, 40, 231, 216, 234, 232, 463, 217
372, 216, 231, 39, 36, 463, 233, 230, 218
*ELEMENT, type=CPS8, ELSET=Surface96
373, 30, 38, 235, 195, 229, 236, 464, 196
374, 195, 235, 40, 32, 464, 237, 234, 197
*ELEMENT, type=CPS8, ELSET=Surface97
375, 34, 219, 238, 37, 220, 465, 239, 225
376, 219, 36, 39, 238, 221, 230, 240, 465
*ELEMENT, type=CPS8, ELSET=Surface98
377, 38, 226, 466, 235, 227, 467, 468, 236
378, 226, 37, 238, 466, 228, 239, 469, 467
379, 235, 466, 231, 40, 468, 470, 232, 237
380, 466, 238, 39, 231, 469, 240, 233, 470
*ELEMENT, type=CPS8, ELSET=Surface99
381, 38, 241, 93, 9, 242, 471, 94, 245
382, 241, 41, 10, 93, 243, 244, 95, 471
*ELEMENT, type=CPS8, ELSET=Surface100
383, 40, 11, 96, 246, 250, 97, 472, 247
384, 246, 96, 12, 42, 472, 98, 249, 248
*ELEMENT, type=CPS8, ELSET=Surface101
385, 38, 9, 99, 235, 245, 100, 473, 236
386, 235, 99, 11, 40, 473, 101, 250, 237
*ELEMENT, type=CPS8, ELSET=Surface102
387, 41, 251, 102, 10, 252, 474, 103, 244
388, 251, 42, 12, 102, 253, 249, 104, 474
*ELEMENT, type=CPS8, ELSET=Surface103
389, 38, 235, 475, 241, 236, 476, 477, 242
390, 241, 475, 251, 41, 477, 478, 252, 243
391, 235, 40, 246, 475, 237, 247, 479, 476
392, 475, 246, 42, 251, 479, 248, 253, 478
*ELEMENT, type=CPS8, ELSET=Surface104
393, 38, 226, 480, 241, 227, 481, 482, 242
394, 241, 480, 257, 41, 482, 483, 259, 243
395, 226, 37, 254, 480, 228, 255, 484, 481
396, 480, 254, 43, 257, 484, 256, 258, 483
*ELEMENT, type=CPS8, ELSET=Surface105
397, 40, 246, 485, 231, 247, 486, 487, 232
398, 246, 42, 263, 485, 248, 265, 488, 486
399, 231, 485, 260, 39, 487, 489, 261, 233
400, 485, 263, 44, 260, 488, 264, 262, 489
*ELEMENT, type=CPS8, ELSET=Surface106
401, 37, 238, 490, 254, 239, 491, 492, 255
402, 254, 490, 266, 43, 492, 493, 267, 256
403, 238, 39, 260, 490, 240, 261, 494, 491
404, 490, 260, 44, 266, 494, 262, 268, 493
*ELEMENT, type=CPS8, ELSET=Surface107
405, 41, 257, 495, 251, 259, 496, 497, 252
406, 257, 43, 266, 495, 258, 267, 498, 496
407, 251, 495, 263, 42, 497, 499, 265, 253
408, 495, 266, 44, 263, 498, 268, 264, 499
*ELEMENT, type=CPS8, ELSET=Surface108
409, 13, 111, 270, 46, 112, 500, 271, 273
410, 111, 14, 45, 270, 113, 269, 272, 500
*ELEMENT, type=CPS8, ELSET=Surface109
411, 15, 48, 275, 120, 278, 276, 501, 121
412, 120, 275, 47, 16, 501, 277, 274, 122
*ELEMENT, type=CPS8, ELSET=Surface110
413, 13, 46, 279, 123, 273, 280, 502, 124
414, 123, 279, 48, 15, 502, 281, 278, 125
*ELEMENT, type=CPS8, ELSET=Surface111
415, 14, 126, 282, 45, 127, 503, 283, 269
416, 126, 16, 47, 282, 128, 274, 284, 503
*ELEMENT, type=CPS8, ELSET=Surface112
417, 46, 270, 504, 279, 271, 505, 506, 280
418, 270, 45, 282, 504, 272, 283, 507, 505
419, 279, 504, 275, 48, 506, 508, 276, 281
420, 504, 282, 47, 275, 507, 284, 277, 508
*ELEMENT, type=CPS8, ELSET=Surface113
421, 46, 270, 509, 291, 271, 510, 511, 293
422, 291, 509, 288, 50, 511, 512, 290, 292
423, 270, 45, 285, 509, 272, 286, 513, 510
424, 509, 285, 49, 288, 513, 287, 289, 512
*ELEMENT, type=CPS8, ELSET=Surface114
425, 48, 300, 514, 275, 302, 515, 516, 276
426, 300, 52, 297, 514, 301, 299, 517, 515
427, 275, 514, 294, 47, 516, 518, 295, 277
428, 514, 297, 51, 294, 517, 298, 296, 518
*ELEMENT, type=CPS8, ELSET=Surface115
429, 46, 291, 519, 279, 293, 520, 521, 280
430, 291, 50, 303, 519, 292, 304, 522, 520
431, 279, 519, 300, 48, 521, 523, 302, 281
432, 519, 303, 52, 300, 522, 305, 301, 523
*ELEMENT, type=CPS8, ELSET=Surface116
433, 45, 282, 524, 285, 283, 525, 526, 286
434, 285, 524, 306, 49, 526, 527, 307, 287
435, 282, 47, 294, 524, 284, 295, 528, 525
436, 524, 294, 51, 306, 528, 296, 308, 527
*ELEMENT, type=CPS8, ELSET=Surface117
437, 50, 288, 529, 303, 290, 530, 531, 304
438, 288, 49, 306, 529, 289, 307, 532, 530
439, 303, 529, 297, 52, 531, 533, 299, 305
440, 529, 306, 51, 297, 532, 308, 298, 533
*ELEMENT, type=CPS8, ELSET=Surface118
441, 45, 53, 310, 285, 309, 311, 534, 286
442, 285, 310, 54, 49, 534, 312, 313, 287
*ELEMENT, type=CPS8, ELSET=Surface119
443, 47, 294, 315, 55, 295, 535, 316, 314
444, 294, 51, 56, 315, 296, 318, 317, 535
*ELEMENT, type=CPS8, ELSET=Surface120
445, 45, 282, 319, 53, 283, 536, 320, 309
446, 282, 47, 55, 319, 284, 314, 321, 536
*ELEMENT, type=CPS8, ELSET=Surface121
447, 49, 54, 322, 306, 313, 323, 537, 307
448, 306, 322, 56, 51, 537, 324, 318, 308
*ELEMENT, type=CPS8, ELSET=Surface122
449, 53, 319, 538, 310, 320, 539, 540, 311
450, 310, 538, 322, 54, 540, 541, 323, 312
451, 319, 55, 315, 538, 321, 316, 542, 539
452, 538, 315, 56, 322, 542, 317, 324, 541
*ELEMENT, type=C3D20, ELSET=Volume2
453, 423, 139, 18, 182, 543, 389, 131, 418, 424, 140, 183, 425, 545, 391, 420, 
546, 544, 390, 132, 419
454, 543, 389, 131, 418, 398, 142, 17, 164, 545, 391, 420, 546, 399, 143, 165, 
400, 547, 392, 133, 421
455, 179, 423, 182, 28, 413, 543, 418, 176, 426, 425, 184, 180, 548, 546, 422, 
415, 414, 544, 419, 177
456, 413, 543, 418, 176, 161, 398, 164, 25, 548, 546, 422, 415, 401, 400, 166, 
162, 416, 547, 421, 178
457, 170, 20, 139, 423, 408, 136, 389, 543, 171, 141, 424, 427, 409, 393, 545, 
549, 410, 137, 390, 544
458, 408, 136, 389, 543, 150, 19, 142, 398, 409, 393, 545, 549, 151, 144, 399, 
402, 411, 138, 392, 547
459, 27, 170, 423, 179, 173, 408, 543, 413, 172, 427, 426, 181, 412, 549, 548, 
417, 174, 410, 544, 414
460, 173, 408, 543, 413, 23, 150, 398, 161, 412, 549, 548, 417, 152, 402, 401, 
163, 175, 411, 547, 416
*ELEMENT, type=C3D20, ELSET=Volume3
461, 398, 142, 17, 164, 403, 145, 21, 167, 399, 143, 165, 400, 406, 146, 169, 
405, 550, 394, 149, 397
462, 161, 398, 164, 25, 158, 403, 167, 26, 401, 400, 166, 162, 404, 405, 168, 
159, 396, 550, 397, 157
463, 150, 19, 142, 398, 154, 22, 145, 403, 151, 144, 399, 402, 156, 147, 406, 
407, 395, 148, 394, 550
464, 23, 150, 398, 161, 24, 154, 403, 158, 152, 402, 401, 163, 155, 407, 404, 
160, 153, 395, 550, 396
*ELEMENT, type=C3D20, ELSET=Volume4
465, 389, 139, 18, 131, 325, 63, 1, 57, 390, 140, 132, 391, 327, 64, 58, 
326, 551, 387, 130, 385
466, 142, 389, 131, 17, 66, 325, 57, 2, 392, 391, 133, 143, 328, 326, 59, 
67, 388, 551, 385, 129
467, 136, 20, 139, 389, 60, 3, 63, 325, 137, 141, 390, 393, 61, 65, 327, 
329, 386, 135, 387, 551
468, 19, 136, 389, 142, 4, 60, 325, 66, 138, 393, 392, 144, 62, 329, 328, 
68, 134, 386, 551, 388
*ELEMENT, type=C3D20, ELSET=Volume5
469, 1, 57, 325, 63, 69, 330, 552, 340, 58, 326, 327, 64, 332, 554, 555, 
341, 70, 331, 553, 342
470, 69, 330, 552, 340, 5, 75, 350, 87, 332, 554, 555, 341, 76, 351, 352, 
88, 71, 333, 556, 343
471, 57, 2, 66, 325, 330, 72, 345, 552, 59, 67, 328, 326, 334, 347, 557, 
554, 331, 73, 346, 553
472, 330, 72, 345, 552, 75, 6, 90, 350, 334, 347, 557, 554, 77, 91, 353, 
351, 333, 74, 348, 556
473, 63, 325, 60, 3, 340, 552, 335, 78, 327, 329, 61, 65, 555, 558, 336, 
344, 342, 553, 337, 79
474, 340, 552, 335, 78, 87, 350, 84, 7, 555, 558, 336, 344, 352, 354, 85, 
89, 343, 556, 338, 80
475, 325, 66, 4, 60, 552, 345, 81, 335, 328, 68, 62, 329, 557, 349, 339, 
558, 553, 346, 82, 337
476, 552, 345, 81, 335, 350, 90, 8, 84, 557, 349, 339, 558, 353, 92, 86, 
354, 556, 348, 83, 338
*ELEMENT, type=C3D20, ELSET=Volume6
477, 5, 75, 350, 87, 30, 186, 432, 195, 76, 351, 352, 88, 187, 433, 434, 
196, 189, 428, 559, 430
478, 75, 6, 90, 350, 186, 29, 198, 432, 77, 91, 353, 351, 188, 199, 435, 
433, 428, 185, 431, 559
479, 87, 350, 84, 7, 195, 432, 191, 32, 352, 354, 85, 89, 434, 436, 192, 
197, 430, 559, 429, 194
480, 350, 90, 8, 84, 432, 198, 31, 191, 353, 92, 86, 354, 435, 200, 193, 
436, 559, 431, 190, 429
*ELEMENT, type=C3D20, ELSET=Volume7
481, 30, 186, 432, 195, 207, 437, 560, 447, 187, 433, 434, 196, 439, 562, 563, 
448, 208, 438, 561, 449
482, 207, 437, 560, 447, 34, 204, 457, 219, 439, 562, 563, 448, 206, 458, 459, 
220, 209, 440, 564, 450
483, 186, 29, 198, 432, 437, 201, 452, 560, 188, 199, 435, 433, 441, 454, 565, 
562, 438, 202, 453, 561
484, 437, 201, 452, 560, 204, 33, 222, 457, 441, 454, 565, 562, 205, 223, 460, 
458, 440, 203, 455, 564
485, 195, 432, 191, 32, 447, 560, 442, 216, 434, 436, 192, 197, 563, 566, 443, 
451, 449, 561, 444, 217
486, 447, 560, 442, 216, 219, 457, 213, 36, 563, 566, 443, 451, 459, 461, 215, 
221, 450, 564, 445, 218
487, 432, 198, 31, 191, 560, 452, 210, 442, 435, 200, 193, 436, 565, 456, 446, 
566, 561, 453, 211, 444
488, 560, 452, 210, 442, 457, 222, 35, 213, 565, 456, 446, 566, 460, 224, 214, 
461, 564, 455, 212, 445
*ELEMENT, type=C3D20, ELSET=Volume8
489, 30, 207, 447, 195, 38, 226, 466, 235, 208, 448, 449, 196, 227, 467, 468, 
236, 229, 462, 567, 464
490, 207, 34, 219, 447, 226, 37, 238, 466, 209, 220, 450, 448, 228, 239, 469, 
467, 462, 225, 465, 567
491, 195, 447, 216, 32, 235, 466, 231, 40, 449, 451, 217, 197, 468, 470, 232, 
237, 464, 567, 463, 234
492, 447, 219, 36, 216, 466, 238, 39, 231, 450, 221, 218, 451, 469, 240, 233, 
470, 567, 465, 230, 463
*ELEMENT, type=C3D20, ELSET=Volume9
493, 38, 226, 466, 235, 241, 480, 568, 475, 227, 467, 468, 236, 482, 570, 571, 
477, 242, 481, 569, 476
494, 241, 480, 568, 475, 41, 257, 495, 251, 482, 570, 571, 477, 259, 496, 497, 
252, 243, 483, 572, 478
495, 226, 37, 238, 466, 480, 254, 490, 568, 228, 239, 469, 467, 484, 492, 573, 
570, 481, 255, 491, 569
496, 480, 254, 490, 568, 257, 43, 266, 495, 484, 492, 573, 570, 258, 267, 498, 
496, 483, 256, 493, 572
497, 235, 466, 231, 40, 475, 568, 485, 246, 468, 470, 232, 237, 571, 574, 486, 
479, 476, 569, 487, 247
498, 475, 568, 485, 246, 251, 495, 263, 42, 571, 574, 486, 479, 497, 499, 265, 
253, 478, 572, 488, 248
499, 466, 238, 39, 231, 568, 490, 260, 485, 469, 240, 233, 470, 573, 494, 489, 
574, 569, 491, 261, 487
500, 568, 490, 260, 485, 495, 266, 44, 263, 573, 494, 489, 574, 498, 268, 264, 
499, 572, 493, 262, 488
*ELEMENT, type=C3D20, ELSET=Volume10
501, 475, 235, 38, 241, 355, 99, 9, 93, 476, 236, 242, 477, 357, 100, 94, 
356, 575, 473, 245, 471
502, 251, 475, 241, 41, 102, 355, 93, 10, 478, 477, 243, 252, 358, 356, 95, 
103, 474, 575, 471, 244
503, 246, 40, 235, 475, 96, 11, 99, 355, 247, 237, 476, 479, 97, 101, 357, 
359, 472, 250, 473, 575
504, 42, 246, 475, 251, 12, 96, 355, 102, 248, 479, 478, 253, 98, 359, 358, 
104, 249, 472, 575, 474
*ELEMENT, type=C3D20, ELSET=Volume11
505, 9, 93, 355, 99, 105, 360, 576, 370, 94, 356, 357, 100, 362, 578, 579, 
371, 106, 361, 577, 372
506, 105, 360, 576, 370, 13, 111, 380, 123, 362, 578, 579, 371, 112, 381, 382, 
124, 107, 363, 580, 373
507, 93, 10, 102, 355, 360, 108, 375, 576, 95, 103, 358, 356, 364, 377, 581, 
578, 361, 109, 376, 577
508, 360, 108, 375, 576, 111, 14, 126, 380, 364, 377, 581, 578, 113, 127, 383, 
381, 363, 110, 378, 580
509, 99, 355, 96, 11, 370, 576, 365, 114, 357, 359, 97, 101, 579, 582, 366, 
374, 372, 577, 367, 115
510, 370, 576, 365, 114, 123, 380, 120, 15, 579, 582, 366, 374, 382, 384, 121, 
125, 373, 580, 368, 116
511, 355, 102, 12, 96, 576, 375, 117, 365, 358, 104, 98, 359, 581, 379, 369, 
582, 577, 376, 118, 367
512, 576, 375, 117, 365, 380, 126, 16, 120, 581, 379, 369, 582, 383, 128, 122, 
384, 580, 378, 119, 368
*ELEMENT, type=C3D20, ELSET=Volume12
513, 13, 111, 380, 123, 46, 270, 504, 279, 112, 381, 382, 124, 271, 505, 506, 
280, 273, 500, 583, 502
514, 111, 14, 126, 380, 270, 45, 282, 504, 113, 127, 383, 381, 272, 283, 507, 
505, 500, 269, 503, 583
515, 123, 380, 120, 15, 279, 504, 275, 48, 382, 384, 121, 125, 506, 508, 276, 
281, 502, 583, 501, 278
516, 380, 126, 16, 120, 504, 282, 47, 275, 383, 128, 122, 384, 507, 284, 277, 
508, 583, 503, 274, 501
*ELEMENT, type=C3D20, ELSET=Volume13
517, 46, 270, 504, 279, 291, 509, 584, 519, 271, 505, 506, 280, 511, 586, 587, 
520, 293, 510, 585, 521
518, 291, 509, 584, 519, 50, 288, 529, 303, 511, 586, 587, 520, 290, 530, 531, 
304, 292, 512, 588, 522
519, 270, 45, 282, 504, 509, 285, 524, 584, 272, 283, 507, 505, 513, 526, 589, 
586, 510, 286, 525, 585
520, 509, 285, 524, 584, 288, 49, 306, 529, 513, 526, 589, 586, 289, 307, 532, 
530, 512, 287, 527, 588
521, 279, 504, 275, 48, 519, 584, 514, 300, 506, 508, 276, 281, 587, 590, 515, 
523, 521, 585, 516, 302
522, 519, 584, 514, 300, 303, 529, 297, 52, 587, 590, 515, 523, 531, 533, 299, 
305, 522, 588, 517, 301
523, 504, 282, 47, 275, 584, 524, 294, 514, 507, 284, 277, 508, 589, 528, 518, 
590, 585, 525, 295, 516
524, 584, 524, 294, 514, 529, 306, 51, 297, 589, 528, 518, 590, 532, 308, 298, 
533, 588, 527, 296, 517
*ELEMENT, type=C3D20, ELSET=Volume14
525, 45, 282, 524, 285, 53, 319, 538, 310, 283, 525, 526, 286, 320, 539, 540, 
311, 309, 536, 591, 534
526, 285, 524, 306, 49, 310, 538, 322, 54, 526, 527, 307, 287, 540, 541, 323, 
312, 534, 591, 537, 313
527, 282, 47, 294, 524, 319, 55, 315, 538, 284, 295, 528, 525, 321, 316, 542, 
539, 536, 314, 535, 591
528, 524, 294, 51, 306, 538, 315, 56, 322, 528, 296, 308, 527, 542, 317, 324, 
541, 591, 535, 318, 537
*ELSET,ELSET=ElectrodeMinX
317, 318, 319, 320, 
*ELSET,ELSET=ElectrodeMaxX
449, 450, 451, 452, 
*ELSET,ELSET=HeatSink
325, 326, 327, 328, 437, 438, 439, 440, 
*ELSET,ELSET=Qin
365, 366, 367, 368, 375, 376, 401, 402, 403, 404, 
*ELSET,ELSET=Force
361, 362, 363, 364, 
*ELSET,ELSET=Volume
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 471, 472, 
473, 474, 475, 476, 477, 478, 479, 480, 481, 482, 
483, 484, 485, 486, 487, 488, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 527, 528, 
*ELSET,ELSET=TO
469, 470, 471, 472, 473, 474, 475, 476, 505, 506, 
507, 508, 509, 510, 511, 512, 
*ELSET,ELSET=SemiconductorN-
469, 470, 471, 472, 473, 474, 475, 476, 
*ELSET,ELSET=SemiconductorP+
505, 506, 507, 508, 509, 510, 511, 512, 
*ELSET,ELSET=Copper
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 481, 482, 483, 484, 485, 486, 487, 488, 
489, 490, 491, 492, 493, 494, 495, 496, 497, 498, 
499, 500, 517, 518, 519, 520, 521, 522, 523, 524, 
525, 526, 527, 528, 
*ELSET,ELSET=Solder
465, 466, 467, 468, 477, 478, 479, 480, 501, 502, 
503, 504, 513, 514, 515, 516, 
*NSET,NSET=ElectrodeMinX
21, 22, 24, 26, 145, 146, 147, 154, 155, 156, 
158, 159, 160, 167, 168, 169, 403, 404, 405, 406, 
407, 
*NSET,NSET=ElectrodeMaxX
53, 54, 55, 56, 310, 311, 312, 315, 316, 317, 
319, 320, 321, 322, 323, 324, 538, 539, 540, 541, 
542, 
*NSET,NSET=HeatSink
23, 25, 27, 28, 49, 50, 51, 52, 161, 162, 
163, 173, 174, 175, 176, 177, 178, 179, 180, 181, 
288, 289, 290, 297, 298, 299, 303, 304, 305, 306, 
307, 308, 413, 414, 415, 416, 417, 529, 530, 531, 
532, 533, 
*NSET,NSET=Qin
33, 34, 35, 36, 37, 39, 43, 44, 204, 205, 
206, 213, 214, 215, 219, 220, 221, 222, 223, 224, 
225, 230, 238, 239, 240, 254, 255, 256, 260, 261, 
262, 266, 267, 268, 457, 458, 459, 460, 461, 465, 
490, 491, 492, 493, 494, 
*NSET,NSET=Force
29, 31, 33, 35, 198, 199, 200, 201, 202, 203, 
210, 211, 212, 222, 223, 224, 452, 453, 454, 455, 
456, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 
*NSET,NSET=TO
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 325, 326, 
327, 328, 329, 330, 331, 332, 333, 334, 335, 336, 
337, 338, 339, 340, 341, 342, 343, 344, 345, 346, 
347, 348, 349, 350, 351, 352, 353, 354, 355, 356, 
357, 358, 359, 360, 361, 362, 363, 364, 365, 366, 
367, 368, 369, 370, 371, 372, 373, 374, 375, 376, 
377, 378, 379, 380, 381, 382, 383, 384, 552, 553, 
554, 555, 556, 557, 558, 576, 577, 578, 579, 580, 
581, 582, 
*NSET,NSET=SemiconductorN-
1, 2, 3, 4, 5, 6, 7, 8, 57, 58, 
59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 
69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 
79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 90, 91, 92, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 552, 553, 554, 555, 556, 557, 
558, 
*NSET,NSET=SemiconductorP+
9, 10, 11, 12, 13, 14, 15, 16, 93, 94, 
95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 
105, 106, 107, 108, 109, 110, 111, 112, 113, 114, 
115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 
125, 126, 127, 128, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 576, 577, 578, 579, 580, 581, 
582, 
*NSET,NSET=Copper
17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 
27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
131, 132, 133, 136, 137, 138, 139, 140, 141, 142, 
143, 144, 145, 146, 147, 148, 149, 150, 151, 152, 
153, 154, 155, 156, 157, 158, 159, 160, 161, 162, 
163, 164, 165, 166, 167, 168, 169, 170, 171, 172, 
173, 174, 175, 176, 177, 178, 179, 180, 181, 182, 
183, 184, 186, 187, 188, 191, 192, 193, 195, 196, 
197, 198, 199, 200, 201, 202, 203, 204, 205, 206, 
207, 208, 209, 210, 211, 212, 213, 214, 215, 216, 
217, 218, 219, 220, 221, 222, 223, 224, 225, 226, 
227, 228, 229, 230, 231, 232, 233, 234, 235, 236, 
237, 238, 239, 240, 241, 242, 243, 246, 247, 248, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 270, 271, 
272, 275, 276, 277, 279, 280, 281, 282, 283, 284, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
389, 390, 391, 392, 393, 394, 395, 396, 397, 398, 
399, 400, 401, 402, 403, 404, 405, 406, 407, 408, 
409, 410, 411, 412, 413, 414, 415, 416, 417, 418, 
419, 420, 421, 422, 423, 424, 425, 426, 427, 432, 
433, 434, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 475, 476, 
477, 478, 479, 480, 481, 482, 483, 484, 485, 486, 
487, 488, 489, 490, 491, 492, 493, 494, 495, 496, 
497, 498, 499, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
560, 561, 562, 563, 564, 565, 566, 567, 568, 569, 
570, 571, 572, 573, 574, 584, 585, 586, 587, 588, 
589, 590, 591, 
*NSET,NSET=Solder
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
29, 30, 31, 32, 38, 40, 41, 42, 45, 46, 
47, 48, 57, 58, 59, 60, 61, 62, 63, 64, 
65, 66, 67, 68, 75, 76, 77, 84, 85, 86, 
87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 
97, 98, 99, 100, 101, 102, 103, 104, 111, 112, 
113, 120, 121, 122, 123, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 141, 142, 143, 144, 185, 186, 187, 188, 
189, 190, 191, 192, 193, 194, 195, 196, 197, 198, 
199, 200, 235, 236, 237, 241, 242, 243, 244, 245, 
246, 247, 248, 249, 250, 251, 252, 253, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 325, 326, 327, 328, 329, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 428, 429, 430, 431, 432, 433, 434, 
435, 436, 471, 472, 473, 474, 475, 476, 477, 478, 
479, 500, 501, 502, 503, 504, 505, 506, 507, 508, 
551, 559, 575, 583, 
