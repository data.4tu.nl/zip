*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_Parameterized_NElem_Serendipity_Gmsh.inp
*NODE
1, 0, 0, 0.5
2, 0, 0, 0
3, 0, 0.2, 0.5
4, 0, 0.2, 0
5, 1, 0, 0.5
6, 1, 0, 0
7, 1, 0.2, 0.5
8, 1, 0.2, 0
9, 1, 0.3, 0
10, 0, 0.3, 0
11, 1, 0.3, 0.5
12, 0, 0.3, 0.5
13, 1, 1.1, 0
14, 0, 1.1, 0
15, 1, 1.1, 0.5
16, 0, 1.1, 0.5
17, 1, 1.2, 0
18, 0, 1.2, 0
19, 1, 1.2, 0.5
20, 0, 1.2, 0.5
21, 1, 1.4, 0
22, 0, 1.4, 0
23, 1, 1.4, 0.5
24, 0, 1.4, 0.5
25, 1.2, 1.2, 0.5
26, 1.2, 1.4, 0.5
27, 1.2, 1.2, 0
28, 1.2, 1.4, 0
29, 2.2, 1.2, 0.5
30, 2.2, 1.4, 0.5
31, 2.2, 1.2, 0
32, 2.2, 1.4, 0
33, 1.2, 1.1, 0.5
34, 2.2, 1.1, 0.5
35, 1.2, 1.1, 0
36, 2.2, 1.1, 0
37, 1.2, 0.3, 0.5
38, 2.2, 0.3, 0.5
39, 1.2, 0.3, 0
40, 2.2, 0.3, 0
41, 1.2, 0.2, 0.5
42, 2.2, 0.2, 0.5
43, 1.2, 0.2, 0
44, 2.2, 0.2, 0
45, 1.2, -2.7755575615629e-17, 0.5
46, 2.2, -2.7755575615629e-17, 0.5
47, 1.2, -2.7755575615629e-17, 0
48, 2.2, -2.7755575615629e-17, 0
49, 2.3, 0.2, 0.5
50, 2.3, -2.7755575615629e-17, 0.5
51, 2.3, 0.2, 0
52, 2.3, -2.7755575615629e-17, 0
53, -0.1, 0, 0.5
54, -0.1, 0, 0
55, -0.1, 0.2, 0.5
56, -0.1, 0.2, 0
57, 0, 0, 0.25
58, 0, 0.1, 0.5
59, 0, 0.2, 0.25
60, 0, 0.1, 0
61, 1, 0, 0.25
62, 1, 0.1, 0.5
63, 1, 0.2, 0.25
64, 1, 0.1, 0
65, 0.5, 0, 0
66, 0.5, 0, 0.5
67, 0.5, 0.2, 0
68, 0.5, 0.2, 0.5
69, 1, 0.25, 0
70, 0, 0.25, 0
71, 0.5, 0.3, 0
72, 1, 0.25, 0.5
73, 1, 0.3, 0.25
74, 0, 0.25, 0.5
75, 0.5, 0.3, 0.5
76, 0, 0.3, 0.25
77, 1, 0.7, 0
78, 0, 0.7, 0
79, 0.5, 1.1, 0
80, 1, 0.7, 0.5
81, 1, 1.1, 0.25
82, 0, 0.7, 0.5
83, 0.5, 1.1, 0.5
84, 0, 1.1, 0.25
85, 1, 1.15, 0
86, 0, 1.15, 0
87, 0.5, 1.2, 0
88, 1, 1.15, 0.5
89, 1, 1.2, 0.25
90, 0, 1.15, 0.5
91, 0.5, 1.2, 0.5
92, 0, 1.2, 0.25
93, 1, 1.3, 0
94, 0, 1.3, 0
95, 0.5, 1.4, 0
96, 1, 1.3, 0.5
97, 1, 1.4, 0.25
98, 0, 1.3, 0.5
99, 0.5, 1.4, 0.5
100, 0, 1.4, 0.25
101, 1.1, 1.2, 0.5
102, 1.1, 1.4, 0.5
103, 1.2, 1.3, 0.5
104, 1.1, 1.2, 0
105, 1.1, 1.4, 0
106, 1.2, 1.3, 0
107, 1.2, 1.2, 0.25
108, 1.2, 1.4, 0.25
109, 1.7, 1.2, 0.5
110, 1.7, 1.4, 0.5
111, 2.2, 1.3, 0.5
112, 1.7, 1.2, 0
113, 1.7, 1.4, 0
114, 2.2, 1.3, 0
115, 2.2, 1.2, 0.25
116, 2.2, 1.4, 0.25
117, 1.2, 1.15, 0.5
118, 2.2, 1.15, 0.5
119, 1.7, 1.1, 0.5
120, 1.2, 1.15, 0
121, 2.2, 1.15, 0
122, 1.7, 1.1, 0
123, 1.2, 1.1, 0.25
124, 2.2, 1.1, 0.25
125, 1.2, 0.7, 0.5
126, 2.2, 0.7, 0.5
127, 1.7, 0.3, 0.5
128, 1.2, 0.7, 0
129, 2.2, 0.7, 0
130, 1.7, 0.3, 0
131, 1.2, 0.3, 0.25
132, 2.2, 0.3, 0.25
133, 1.2, 0.25, 0.5
134, 2.2, 0.25, 0.5
135, 1.7, 0.2, 0.5
136, 1.2, 0.25, 0
137, 2.2, 0.25, 0
138, 1.7, 0.2, 0
139, 1.2, 0.2, 0.25
140, 2.2, 0.2, 0.25
141, 1.2, 0.1, 0.5
142, 2.2, 0.1, 0.5
143, 1.7, -2.2204460492503e-16, 0.5
144, 1.2, 0.1, 0
145, 2.2, 0.1, 0
146, 1.7, -2.2204460492503e-16, 0
147, 1.2, -2.7755575615629e-17, 0.25
148, 2.2, -2.7755575615629e-17, 0.25
149, 2.25, 0.2, 0.5
150, 2.25, -2.7755575615629e-17, 0.5
151, 2.3, 0.1, 0.5
152, 2.25, 0.2, 0
153, 2.25, -2.7755575615629e-17, 0
154, 2.3, 0.1, 0
155, 2.3, 0.2, 0.25
156, 2.3, -2.7755575615629e-17, 0.25
157, -0.05, 0, 0.5
158, -0.05, 0, 0
159, -0.1, 0, 0.25
160, -0.05, 0.2, 0.5
161, -0.1, 0.1, 0.5
162, -0.05, 0.2, 0
163, -0.1, 0.2, 0.25
164, -0.1, 0.1, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
57, 2, 57, 1
*ELEMENT, type=T3D3, ELSET=Line2
58, 1, 58, 3
*ELEMENT, type=T3D3, ELSET=Line3
59, 4, 59, 3
*ELEMENT, type=T3D3, ELSET=Line4
60, 2, 60, 4
*ELEMENT, type=T3D3, ELSET=Line5
61, 6, 61, 5
*ELEMENT, type=T3D3, ELSET=Line6
62, 5, 62, 7
*ELEMENT, type=T3D3, ELSET=Line7
63, 8, 63, 7
*ELEMENT, type=T3D3, ELSET=Line8
64, 6, 64, 8
*ELEMENT, type=T3D3, ELSET=Line9
65, 2, 65, 6
*ELEMENT, type=T3D3, ELSET=Line10
66, 1, 66, 5
*ELEMENT, type=T3D3, ELSET=Line11
67, 4, 67, 8
*ELEMENT, type=T3D3, ELSET=Line12
68, 3, 68, 7
*ELEMENT, type=T3D3, ELSET=Line13
69, 8, 69, 9
*ELEMENT, type=T3D3, ELSET=Line14
70, 4, 70, 10
*ELEMENT, type=T3D3, ELSET=Line15
71, 10, 71, 9
*ELEMENT, type=T3D3, ELSET=Line16
72, 7, 72, 11
*ELEMENT, type=T3D3, ELSET=Line17
73, 9, 73, 11
*ELEMENT, type=T3D3, ELSET=Line18
74, 3, 74, 12
*ELEMENT, type=T3D3, ELSET=Line19
75, 12, 75, 11
*ELEMENT, type=T3D3, ELSET=Line20
76, 10, 76, 12
*ELEMENT, type=T3D3, ELSET=Line21
77, 9, 77, 13
*ELEMENT, type=T3D3, ELSET=Line22
78, 10, 78, 14
*ELEMENT, type=T3D3, ELSET=Line23
79, 14, 79, 13
*ELEMENT, type=T3D3, ELSET=Line24
80, 11, 80, 15
*ELEMENT, type=T3D3, ELSET=Line25
81, 13, 81, 15
*ELEMENT, type=T3D3, ELSET=Line26
82, 12, 82, 16
*ELEMENT, type=T3D3, ELSET=Line27
83, 16, 83, 15
*ELEMENT, type=T3D3, ELSET=Line28
84, 14, 84, 16
*ELEMENT, type=T3D3, ELSET=Line29
85, 13, 85, 17
*ELEMENT, type=T3D3, ELSET=Line30
86, 14, 86, 18
*ELEMENT, type=T3D3, ELSET=Line31
87, 18, 87, 17
*ELEMENT, type=T3D3, ELSET=Line32
88, 15, 88, 19
*ELEMENT, type=T3D3, ELSET=Line33
89, 17, 89, 19
*ELEMENT, type=T3D3, ELSET=Line34
90, 16, 90, 20
*ELEMENT, type=T3D3, ELSET=Line35
91, 20, 91, 19
*ELEMENT, type=T3D3, ELSET=Line36
92, 18, 92, 20
*ELEMENT, type=T3D3, ELSET=Line37
93, 17, 93, 21
*ELEMENT, type=T3D3, ELSET=Line38
94, 18, 94, 22
*ELEMENT, type=T3D3, ELSET=Line39
95, 22, 95, 21
*ELEMENT, type=T3D3, ELSET=Line40
96, 19, 96, 23
*ELEMENT, type=T3D3, ELSET=Line41
97, 21, 97, 23
*ELEMENT, type=T3D3, ELSET=Line42
98, 20, 98, 24
*ELEMENT, type=T3D3, ELSET=Line43
99, 24, 99, 23
*ELEMENT, type=T3D3, ELSET=Line44
100, 22, 100, 24
*ELEMENT, type=T3D3, ELSET=Line45
101, 19, 101, 25
*ELEMENT, type=T3D3, ELSET=Line46
102, 23, 102, 26
*ELEMENT, type=T3D3, ELSET=Line47
103, 25, 103, 26
*ELEMENT, type=T3D3, ELSET=Line48
104, 17, 104, 27
*ELEMENT, type=T3D3, ELSET=Line49
105, 21, 105, 28
*ELEMENT, type=T3D3, ELSET=Line50
106, 27, 106, 28
*ELEMENT, type=T3D3, ELSET=Line51
107, 27, 107, 25
*ELEMENT, type=T3D3, ELSET=Line52
108, 28, 108, 26
*ELEMENT, type=T3D3, ELSET=Line53
109, 25, 109, 29
*ELEMENT, type=T3D3, ELSET=Line54
110, 26, 110, 30
*ELEMENT, type=T3D3, ELSET=Line55
111, 29, 111, 30
*ELEMENT, type=T3D3, ELSET=Line56
112, 27, 112, 31
*ELEMENT, type=T3D3, ELSET=Line57
113, 28, 113, 32
*ELEMENT, type=T3D3, ELSET=Line58
114, 31, 114, 32
*ELEMENT, type=T3D3, ELSET=Line59
115, 31, 115, 29
*ELEMENT, type=T3D3, ELSET=Line60
116, 32, 116, 30
*ELEMENT, type=T3D3, ELSET=Line61
117, 25, 117, 33
*ELEMENT, type=T3D3, ELSET=Line62
118, 29, 118, 34
*ELEMENT, type=T3D3, ELSET=Line63
119, 33, 119, 34
*ELEMENT, type=T3D3, ELSET=Line64
120, 27, 120, 35
*ELEMENT, type=T3D3, ELSET=Line65
121, 31, 121, 36
*ELEMENT, type=T3D3, ELSET=Line66
122, 35, 122, 36
*ELEMENT, type=T3D3, ELSET=Line67
123, 35, 123, 33
*ELEMENT, type=T3D3, ELSET=Line68
124, 36, 124, 34
*ELEMENT, type=T3D3, ELSET=Line69
125, 33, 125, 37
*ELEMENT, type=T3D3, ELSET=Line70
126, 34, 126, 38
*ELEMENT, type=T3D3, ELSET=Line71
127, 37, 127, 38
*ELEMENT, type=T3D3, ELSET=Line72
128, 35, 128, 39
*ELEMENT, type=T3D3, ELSET=Line73
129, 36, 129, 40
*ELEMENT, type=T3D3, ELSET=Line74
130, 39, 130, 40
*ELEMENT, type=T3D3, ELSET=Line75
131, 39, 131, 37
*ELEMENT, type=T3D3, ELSET=Line76
132, 40, 132, 38
*ELEMENT, type=T3D3, ELSET=Line77
133, 37, 133, 41
*ELEMENT, type=T3D3, ELSET=Line78
134, 38, 134, 42
*ELEMENT, type=T3D3, ELSET=Line79
135, 41, 135, 42
*ELEMENT, type=T3D3, ELSET=Line80
136, 39, 136, 43
*ELEMENT, type=T3D3, ELSET=Line81
137, 40, 137, 44
*ELEMENT, type=T3D3, ELSET=Line82
138, 43, 138, 44
*ELEMENT, type=T3D3, ELSET=Line83
139, 43, 139, 41
*ELEMENT, type=T3D3, ELSET=Line84
140, 44, 140, 42
*ELEMENT, type=T3D3, ELSET=Line85
141, 41, 141, 45
*ELEMENT, type=T3D3, ELSET=Line86
142, 42, 142, 46
*ELEMENT, type=T3D3, ELSET=Line87
143, 45, 143, 46
*ELEMENT, type=T3D3, ELSET=Line88
144, 43, 144, 47
*ELEMENT, type=T3D3, ELSET=Line89
145, 44, 145, 48
*ELEMENT, type=T3D3, ELSET=Line90
146, 47, 146, 48
*ELEMENT, type=T3D3, ELSET=Line91
147, 47, 147, 45
*ELEMENT, type=T3D3, ELSET=Line92
148, 48, 148, 46
*ELEMENT, type=T3D3, ELSET=Line93
149, 42, 149, 49
*ELEMENT, type=T3D3, ELSET=Line94
150, 46, 150, 50
*ELEMENT, type=T3D3, ELSET=Line95
151, 49, 151, 50
*ELEMENT, type=T3D3, ELSET=Line96
152, 44, 152, 51
*ELEMENT, type=T3D3, ELSET=Line97
153, 48, 153, 52
*ELEMENT, type=T3D3, ELSET=Line98
154, 51, 154, 52
*ELEMENT, type=T3D3, ELSET=Line99
155, 51, 155, 49
*ELEMENT, type=T3D3, ELSET=Line100
156, 52, 156, 50
*ELEMENT, type=T3D3, ELSET=Line101
157, 1, 157, 53
*ELEMENT, type=T3D3, ELSET=Line102
158, 2, 158, 54
*ELEMENT, type=T3D3, ELSET=Line103
159, 54, 159, 53
*ELEMENT, type=T3D3, ELSET=Line104
160, 3, 160, 55
*ELEMENT, type=T3D3, ELSET=Line105
161, 53, 161, 55
*ELEMENT, type=T3D3, ELSET=Line106
162, 4, 162, 56
*ELEMENT, type=T3D3, ELSET=Line107
163, 56, 163, 55
*ELEMENT, type=T3D3, ELSET=Line108
164, 54, 164, 56
*ELEMENT, type=CPS8, ELSET=Surface1
165, 2, 1, 3, 4, 57, 58, 59, 60
*ELEMENT, type=CPS8, ELSET=Surface2
166, 6, 8, 7, 5, 64, 63, 62, 61
*ELEMENT, type=CPS8, ELSET=Surface3
167, 2, 6, 5, 1, 65, 61, 66, 57
*ELEMENT, type=CPS8, ELSET=Surface4
168, 4, 3, 7, 8, 59, 68, 63, 67
*ELEMENT, type=CPS8, ELSET=Surface5
169, 2, 4, 8, 6, 60, 67, 64, 65
*ELEMENT, type=CPS8, ELSET=Surface6
170, 1, 5, 7, 3, 66, 62, 68, 58
*ELEMENT, type=CPS8, ELSET=Surface7
171, 4, 10, 9, 8, 70, 71, 69, 67
*ELEMENT, type=CPS8, ELSET=Surface8
172, 8, 9, 11, 7, 69, 73, 72, 63
*ELEMENT, type=CPS8, ELSET=Surface9
173, 3, 7, 11, 12, 68, 72, 75, 74
*ELEMENT, type=CPS8, ELSET=Surface10
174, 4, 3, 12, 10, 59, 74, 76, 70
*ELEMENT, type=CPS8, ELSET=Surface11
175, 10, 12, 11, 9, 76, 75, 73, 71
*ELEMENT, type=CPS8, ELSET=Surface12
176, 10, 14, 13, 9, 78, 79, 77, 71
*ELEMENT, type=CPS8, ELSET=Surface13
177, 9, 13, 15, 11, 77, 81, 80, 73
*ELEMENT, type=CPS8, ELSET=Surface14
178, 12, 11, 15, 16, 75, 80, 83, 82
*ELEMENT, type=CPS8, ELSET=Surface15
179, 10, 12, 16, 14, 76, 82, 84, 78
*ELEMENT, type=CPS8, ELSET=Surface16
180, 14, 16, 15, 13, 84, 83, 81, 79
*ELEMENT, type=CPS8, ELSET=Surface17
181, 14, 18, 17, 13, 86, 87, 85, 79
*ELEMENT, type=CPS8, ELSET=Surface18
182, 13, 17, 19, 15, 85, 89, 88, 81
*ELEMENT, type=CPS8, ELSET=Surface19
183, 16, 15, 19, 20, 83, 88, 91, 90
*ELEMENT, type=CPS8, ELSET=Surface20
184, 14, 16, 20, 18, 84, 90, 92, 86
*ELEMENT, type=CPS8, ELSET=Surface21
185, 18, 20, 19, 17, 92, 91, 89, 87
*ELEMENT, type=CPS8, ELSET=Surface22
186, 18, 22, 21, 17, 94, 95, 93, 87
*ELEMENT, type=CPS8, ELSET=Surface23
187, 17, 21, 23, 19, 93, 97, 96, 89
*ELEMENT, type=CPS8, ELSET=Surface24
188, 20, 19, 23, 24, 91, 96, 99, 98
*ELEMENT, type=CPS8, ELSET=Surface25
189, 18, 20, 24, 22, 92, 98, 100, 94
*ELEMENT, type=CPS8, ELSET=Surface26
190, 22, 24, 23, 21, 100, 99, 97, 95
*ELEMENT, type=CPS8, ELSET=Surface27
191, 19, 25, 26, 23, 101, 103, 102, 96
*ELEMENT, type=CPS8, ELSET=Surface28
192, 17, 21, 28, 27, 93, 105, 106, 104
*ELEMENT, type=CPS8, ELSET=Surface29
193, 17, 27, 25, 19, 104, 107, 101, 89
*ELEMENT, type=CPS8, ELSET=Surface30
194, 21, 23, 26, 28, 97, 102, 108, 105
*ELEMENT, type=CPS8, ELSET=Surface31
195, 27, 28, 26, 25, 106, 108, 103, 107
*ELEMENT, type=CPS8, ELSET=Surface32
196, 25, 29, 30, 26, 109, 111, 110, 103
*ELEMENT, type=CPS8, ELSET=Surface33
197, 27, 28, 32, 31, 106, 113, 114, 112
*ELEMENT, type=CPS8, ELSET=Surface34
198, 27, 31, 29, 25, 112, 115, 109, 107
*ELEMENT, type=CPS8, ELSET=Surface35
199, 28, 26, 30, 32, 108, 110, 116, 113
*ELEMENT, type=CPS8, ELSET=Surface36
200, 31, 32, 30, 29, 114, 116, 111, 115
*ELEMENT, type=CPS8, ELSET=Surface37
201, 25, 33, 34, 29, 117, 119, 118, 109
*ELEMENT, type=CPS8, ELSET=Surface38
202, 27, 31, 36, 35, 112, 121, 122, 120
*ELEMENT, type=CPS8, ELSET=Surface39
203, 27, 35, 33, 25, 120, 123, 117, 107
*ELEMENT, type=CPS8, ELSET=Surface40
204, 31, 29, 34, 36, 115, 118, 124, 121
*ELEMENT, type=CPS8, ELSET=Surface41
205, 35, 36, 34, 33, 122, 124, 119, 123
*ELEMENT, type=CPS8, ELSET=Surface42
206, 33, 37, 38, 34, 125, 127, 126, 119
*ELEMENT, type=CPS8, ELSET=Surface43
207, 35, 36, 40, 39, 122, 129, 130, 128
*ELEMENT, type=CPS8, ELSET=Surface44
208, 35, 39, 37, 33, 128, 131, 125, 123
*ELEMENT, type=CPS8, ELSET=Surface45
209, 36, 34, 38, 40, 124, 126, 132, 129
*ELEMENT, type=CPS8, ELSET=Surface46
210, 39, 40, 38, 37, 130, 132, 127, 131
*ELEMENT, type=CPS8, ELSET=Surface47
211, 37, 41, 42, 38, 133, 135, 134, 127
*ELEMENT, type=CPS8, ELSET=Surface48
212, 39, 40, 44, 43, 130, 137, 138, 136
*ELEMENT, type=CPS8, ELSET=Surface49
213, 39, 43, 41, 37, 136, 139, 133, 131
*ELEMENT, type=CPS8, ELSET=Surface50
214, 40, 38, 42, 44, 132, 134, 140, 137
*ELEMENT, type=CPS8, ELSET=Surface51
215, 43, 44, 42, 41, 138, 140, 135, 139
*ELEMENT, type=CPS8, ELSET=Surface52
216, 41, 45, 46, 42, 141, 143, 142, 135
*ELEMENT, type=CPS8, ELSET=Surface53
217, 43, 44, 48, 47, 138, 145, 146, 144
*ELEMENT, type=CPS8, ELSET=Surface54
218, 43, 47, 45, 41, 144, 147, 141, 139
*ELEMENT, type=CPS8, ELSET=Surface55
219, 44, 42, 46, 48, 140, 142, 148, 145
*ELEMENT, type=CPS8, ELSET=Surface56
220, 47, 48, 46, 45, 146, 148, 143, 147
*ELEMENT, type=CPS8, ELSET=Surface57
221, 42, 46, 50, 49, 142, 150, 151, 149
*ELEMENT, type=CPS8, ELSET=Surface58
222, 44, 51, 52, 48, 152, 154, 153, 145
*ELEMENT, type=CPS8, ELSET=Surface59
223, 44, 42, 49, 51, 140, 149, 155, 152
*ELEMENT, type=CPS8, ELSET=Surface60
224, 48, 52, 50, 46, 153, 156, 150, 148
*ELEMENT, type=CPS8, ELSET=Surface61
225, 51, 49, 50, 52, 155, 151, 156, 154
*ELEMENT, type=CPS8, ELSET=Surface62
226, 2, 1, 53, 54, 57, 157, 159, 158
*ELEMENT, type=CPS8, ELSET=Surface63
227, 1, 3, 55, 53, 58, 160, 161, 157
*ELEMENT, type=CPS8, ELSET=Surface64
228, 4, 56, 55, 3, 162, 163, 160, 59
*ELEMENT, type=CPS8, ELSET=Surface65
229, 2, 54, 56, 4, 158, 164, 162, 60
*ELEMENT, type=CPS8, ELSET=Surface66
230, 54, 53, 55, 56, 159, 161, 163, 164
*ELEMENT, type=C3D20, ELSET=Volume1
231, 3, 1, 2, 4, 7, 5, 6, 8, 58, 57, 60, 59, 62, 61, 64, 
63, 68, 66, 65, 67
*ELEMENT, type=C3D20, ELSET=Volume2
232, 4, 3, 7, 8, 10, 12, 11, 9, 59, 68, 63, 67, 76, 75, 73, 
71, 70, 74, 72, 69
*ELEMENT, type=C3D20, ELSET=Volume3
233, 10, 12, 11, 9, 14, 16, 15, 13, 76, 75, 73, 71, 84, 83, 81, 
79, 78, 82, 80, 77
*ELEMENT, type=C3D20, ELSET=Volume4
234, 14, 16, 15, 13, 18, 20, 19, 17, 84, 83, 81, 79, 92, 91, 89, 
87, 86, 90, 88, 85
*ELEMENT, type=C3D20, ELSET=Volume5
235, 18, 20, 19, 17, 22, 24, 23, 21, 92, 91, 89, 87, 100, 99, 97, 
95, 94, 98, 96, 93
*ELEMENT, type=C3D20, ELSET=Volume6
236, 17, 21, 23, 19, 27, 28, 26, 25, 93, 97, 96, 89, 106, 108, 103, 
107, 104, 105, 102, 101
*ELEMENT, type=C3D20, ELSET=Volume7
237, 27, 28, 26, 25, 31, 32, 30, 29, 106, 108, 103, 107, 114, 116, 111, 
115, 112, 113, 110, 109
*ELEMENT, type=C3D20, ELSET=Volume8
238, 27, 31, 29, 25, 35, 36, 34, 33, 112, 115, 109, 107, 122, 124, 119, 
123, 120, 121, 118, 117
*ELEMENT, type=C3D20, ELSET=Volume9
239, 35, 36, 34, 33, 39, 40, 38, 37, 122, 124, 119, 123, 130, 132, 127, 
131, 128, 129, 126, 125
*ELEMENT, type=C3D20, ELSET=Volume10
240, 39, 40, 38, 37, 43, 44, 42, 41, 130, 132, 127, 131, 138, 140, 135, 
139, 136, 137, 134, 133
*ELEMENT, type=C3D20, ELSET=Volume11
241, 43, 44, 42, 41, 47, 48, 46, 45, 138, 140, 135, 139, 146, 148, 143, 
147, 144, 145, 142, 141
*ELEMENT, type=C3D20, ELSET=Volume12
242, 44, 42, 46, 48, 51, 49, 50, 52, 140, 142, 148, 145, 155, 151, 156, 
154, 152, 149, 150, 153
*ELEMENT, type=C3D20, ELSET=Volume13
243, 2, 1, 3, 4, 54, 53, 55, 56, 57, 58, 59, 60, 159, 161, 163, 
164, 158, 157, 160, 162
*ELSET,ELSET=Qin
190, 194, 199, 
*ELSET,ELSET=HeatSink
167, 220, 
*ELSET,ELSET=ElectrodeMaxX
225, 
*ELSET,ELSET=ElectrodeMinX
230, 
*ELSET,ELSET=Force
189, 
*ELSET,ELSET=Copper
231, 235, 236, 237, 241, 242, 243, 
*ELSET,ELSET=SemiconductorN-
233, 
*ELSET,ELSET=SemiconductorP+
239, 
*ELSET,ELSET=Solder
232, 234, 238, 240, 
*ELSET,ELSET=Volume
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 
*ELSET,ELSET=TO
233, 239, 
*NSET,NSET=Qin
21, 22, 23, 24, 26, 28, 30, 32, 95, 97, 
99, 100, 102, 105, 108, 110, 113, 116, 
*NSET,NSET=HeatSink
1, 2, 5, 6, 45, 46, 47, 48, 57, 61, 
65, 66, 143, 146, 147, 148, 
*NSET,NSET=ElectrodeMaxX
49, 50, 51, 52, 151, 154, 155, 156, 
*NSET,NSET=ElectrodeMinX
53, 54, 55, 56, 159, 161, 163, 164, 
*NSET,NSET=Force
18, 20, 22, 24, 92, 94, 98, 100, 
*NSET,NSET=Copper
1, 2, 3, 4, 5, 6, 7, 8, 17, 18, 
19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 
29, 30, 31, 32, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 
67, 68, 87, 89, 91, 92, 93, 94, 95, 96, 
97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
135, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 
*NSET,NSET=SemiconductorN-
9, 10, 11, 12, 13, 14, 15, 16, 71, 73, 
75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 
*NSET,NSET=SemiconductorP+
33, 34, 35, 36, 37, 38, 39, 40, 119, 122, 
123, 124, 125, 126, 127, 128, 129, 130, 131, 132, 
*NSET,NSET=Solder
3, 4, 7, 8, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 25, 27, 29, 31, 
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 59, 63, 67, 68, 69, 70, 71, 72, 
73, 74, 75, 76, 79, 81, 83, 84, 85, 86, 
87, 88, 89, 90, 91, 92, 107, 109, 112, 115, 
117, 118, 119, 120, 121, 122, 123, 124, 127, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 
*NSET,NSET=TO
9, 10, 11, 12, 13, 14, 15, 16, 33, 34, 
35, 36, 37, 38, 39, 40, 71, 73, 75, 76, 
77, 78, 79, 80, 81, 82, 83, 84, 119, 122, 
123, 124, 125, 126, 127, 128, 129, 130, 131, 132, 
