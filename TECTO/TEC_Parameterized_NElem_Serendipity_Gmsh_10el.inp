52027, 0.29166666666667, 0.775, 0.16666666666667
52028, 0.27083333333333, 0.8, 0.16666666666667
52029, 0.29166666666667, 0.8, 0.14583333333333
52030, 0.29166666666667, 0.825, 0.16666666666667
52031, 0.27083333333333, 0.85, 0.16666666666667
52032, 0.29166666666667, 0.85, 0.14583333333333
52033, 0.29166666666667, 0.875, 0.16666666666667
52034, 0.27083333333333, 0.9, 0.16666666666667
52035, 0.29166666666667, 0.9, 0.14583333333333
52036, 0.29166666666667, 0.925, 0.16666666666667
52037, 0.27083333333333, 0.95, 0.16666666666667
52038, 0.29166666666667, 0.95, 0.14583333333333
52039, 0.29166666666667, 0.975, 0.16666666666667
52040, 0.27083333333333, 1, 0.16666666666667
52041, 0.29166666666667, 1, 0.14583333333333
52042, 0.29166666666667, 1.025, 0.16666666666667
52043, 0.27083333333333, 1.05, 0.16666666666667
52044, 0.29166666666667, 1.05, 0.14583333333333
52045, 0.29166666666667, 1.075, 0.16666666666667
52046, 0.27083333333333, 1.1, 0.16666666666667
52047, 0.29166666666667, 1.1, 0.14583333333333
52048, 0.29166666666667, 1.125, 0.16666666666667
52049, 0.27083333333333, 1.15, 0.16666666666667
52050, 0.29166666666667, 1.15, 0.14583333333333
52051, 0.29166666666667, 1.175, 0.16666666666667
52052, 0.27083333333333, 1.2, 0.16666666666667
52053, 0.29166666666667, 1.2, 0.14583333333333
52054, 0.29166666666667, 1.225, 0.16666666666667
52055, 0.27083333333333, 1.25, 0.16666666666667
52056, 0.29166666666667, 1.25, 0.14583333333333
52057, 0.29166666666667, 1.275, 0.16666666666667
52058, 0.27083333333333, 1.3, 0.16666666666667
52059, 0.29166666666667, 1.3, 0.14583333333333
52060, 0.29166666666667, 1.325, 0.16666666666667
52061, 0.29166666666667, 0.175, 0.20833333333333
52062, 0.27083333333333, 0.2, 0.20833333333333
52063, 0.29166666666667, 0.2, 0.1875
52064, 0.29166666666667, 0.225, 0.20833333333333
52065, 0.27083333333333, 0.25, 0.20833333333333
52066, 0.29166666666667, 0.25, 0.1875
52067, 0.29166666666667, 0.275, 0.20833333333333
52068, 0.27083333333333, 0.3, 0.20833333333333
52069, 0.29166666666667, 0.3, 0.1875
52070, 0.29166666666667, 0.325, 0.20833333333333
52071, 0.27083333333333, 0.35, 0.20833333333333
52072, 0.29166666666667, 0.35, 0.1875
52073, 0.29166666666667, 0.375, 0.20833333333333
52074, 0.27083333333333, 0.4, 0.20833333333333
52075, 0.29166666666667, 0.4, 0.1875
52076, 0.29166666666667, 0.425, 0.20833333333333
52077, 0.27083333333333, 0.45, 0.20833333333333
52078, 0.29166666666667, 0.45, 0.1875
52079, 0.29166666666667, 0.475, 0.20833333333333
52080, 0.27083333333333, 0.5, 0.20833333333333
52081, 0.29166666666667, 0.5, 0.1875
52082, 0.29166666666667, 0.525, 0.20833333333333
52083, 0.27083333333333, 0.55, 0.20833333333333
52084, 0.29166666666667, 0.55, 0.1875
52085, 0.29166666666667, 0.575, 0.20833333333333
52086, 0.27083333333333, 0.6, 0.20833333333333
52087, 0.29166666666667, 0.6, 0.1875
52088, 0.29166666666667, 0.625, 0.20833333333333
52089, 0.27083333333333, 0.65, 0.20833333333333
52090, 0.29166666666667, 0.65, 0.1875
52091, 0.29166666666667, 0.675, 0.20833333333333
52092, 0.27083333333333, 0.7, 0.20833333333333
52093, 0.29166666666667, 0.7, 0.1875
52094, 0.29166666666667, 0.725, 0.20833333333333
52095, 0.27083333333333, 0.75, 0.20833333333333
52096, 0.29166666666667, 0.75, 0.1875
52097, 0.29166666666667, 0.775, 0.20833333333333
52098, 0.27083333333333, 0.8, 0.20833333333333
52099, 0.29166666666667, 0.8, 0.1875
52100, 0.29166666666667, 0.825, 0.20833333333333
52101, 0.27083333333333, 0.85, 0.20833333333333
52102, 0.29166666666667, 0.85, 0.1875
52103, 0.29166666666667, 0.875, 0.20833333333333
52104, 0.27083333333333, 0.9, 0.20833333333333
52105, 0.29166666666667, 0.9, 0.1875
52106, 0.29166666666667, 0.925, 0.20833333333333
52107, 0.27083333333333, 0.95, 0.20833333333333
52108, 0.29166666666667, 0.95, 0.1875
52109, 0.29166666666667, 0.975, 0.20833333333333
52110, 0.27083333333333, 1, 0.20833333333333
52111, 0.29166666666667, 1, 0.1875
52112, 0.29166666666667, 1.025, 0.20833333333333
52113, 0.27083333333333, 1.05, 0.20833333333333
52114, 0.29166666666667, 1.05, 0.1875
52115, 0.29166666666667, 1.075, 0.20833333333333
52116, 0.27083333333333, 1.1, 0.20833333333333
52117, 0.29166666666667, 1.1, 0.1875
52118, 0.29166666666667, 1.125, 0.20833333333333
52119, 0.27083333333333, 1.15, 0.20833333333333
52120, 0.29166666666667, 1.15, 0.1875
52121, 0.29166666666667, 1.175, 0.20833333333333
52122, 0.27083333333333, 1.2, 0.20833333333333
52123, 0.29166666666667, 1.2, 0.1875
52124, 0.29166666666667, 1.225, 0.20833333333333
52125, 0.27083333333333, 1.25, 0.20833333333333
52126, 0.29166666666667, 1.25, 0.1875
52127, 0.29166666666667, 1.275, 0.20833333333333
52128, 0.27083333333333, 1.3, 0.20833333333333
52129, 0.29166666666667, 1.3, 0.1875
52130, 0.29166666666667, 1.325, 0.20833333333333
52131, 0.29166666666667, 0.175, 0.25
52132, 0.27083333333333, 0.2, 0.25
52133, 0.29166666666667, 0.2, 0.22916666666667
52134, 0.29166666666667, 0.225, 0.25
52135, 0.27083333333333, 0.25, 0.25
52136, 0.29166666666667, 0.25, 0.22916666666667
52137, 0.29166666666667, 0.275, 0.25
52138, 0.27083333333333, 0.3, 0.25
52139, 0.29166666666667, 0.3, 0.22916666666667
52140, 0.29166666666667, 0.325, 0.25
52141, 0.27083333333333, 0.35, 0.25
52142, 0.29166666666667, 0.35, 0.22916666666667
52143, 0.29166666666667, 0.375, 0.25
52144, 0.27083333333333, 0.4, 0.25
52145, 0.29166666666667, 0.4, 0.22916666666667
52146, 0.29166666666667, 0.425, 0.25
52147, 0.27083333333333, 0.45, 0.25
52148, 0.29166666666667, 0.45, 0.22916666666667
52149, 0.29166666666667, 0.475, 0.25
52150, 0.27083333333333, 0.5, 0.25
52151, 0.29166666666667, 0.5, 0.22916666666667
52152, 0.29166666666667, 0.525, 0.25
52153, 0.27083333333333, 0.55, 0.25
52154, 0.29166666666667, 0.55, 0.22916666666667
52155, 0.29166666666667, 0.575, 0.25
52156, 0.27083333333333, 0.6, 0.25
52157, 0.29166666666667, 0.6, 0.22916666666667
52158, 0.29166666666667, 0.625, 0.25
52159, 0.27083333333333, 0.65, 0.25
52160, 0.29166666666667, 0.65, 0.22916666666667
52161, 0.29166666666667, 0.675, 0.25
52162, 0.27083333333333, 0.7, 0.25
52163, 0.29166666666667, 0.7, 0.22916666666667
52164, 0.29166666666667, 0.725, 0.25
52165, 0.27083333333333, 0.75, 0.25
52166, 0.29166666666667, 0.75, 0.22916666666667
52167, 0.29166666666667, 0.775, 0.25
52168, 0.27083333333333, 0.8, 0.25
52169, 0.29166666666667, 0.8, 0.22916666666667
52170, 0.29166666666667, 0.825, 0.25
52171, 0.27083333333333, 0.85, 0.25
52172, 0.29166666666667, 0.85, 0.22916666666667
52173, 0.29166666666667, 0.875, 0.25
52174, 0.27083333333333, 0.9, 0.25
52175, 0.29166666666667, 0.9, 0.22916666666667
52176, 0.29166666666667, 0.925, 0.25
52177, 0.27083333333333, 0.95, 0.25
52178, 0.29166666666667, 0.95, 0.22916666666667
52179, 0.29166666666667, 0.975, 0.25
52180, 0.27083333333333, 1, 0.25
52181, 0.29166666666667, 1, 0.22916666666667
52182, 0.29166666666667, 1.025, 0.25
52183, 0.27083333333333, 1.05, 0.25
52184, 0.29166666666667, 1.05, 0.22916666666667
52185, 0.29166666666667, 1.075, 0.25
52186, 0.27083333333333, 1.1, 0.25
52187, 0.29166666666667, 1.1, 0.22916666666667
52188, 0.29166666666667, 1.125, 0.25
52189, 0.27083333333333, 1.15, 0.25
52190, 0.29166666666667, 1.15, 0.22916666666667
52191, 0.29166666666667, 1.175, 0.25
52192, 0.27083333333333, 1.2, 0.25
52193, 0.29166666666667, 1.2, 0.22916666666667
52194, 0.29166666666667, 1.225, 0.25
52195, 0.27083333333333, 1.25, 0.25
52196, 0.29166666666667, 1.25, 0.22916666666667
52197, 0.29166666666667, 1.275, 0.25
52198, 0.27083333333333, 1.3, 0.25
52199, 0.29166666666667, 1.3, 0.22916666666667
52200, 0.29166666666667, 1.325, 0.25
52201, 0.29166666666667, 0.175, 0.29166666666667
52202, 0.27083333333333, 0.2, 0.29166666666667
52203, 0.29166666666667, 0.2, 0.27083333333333
52204, 0.29166666666667, 0.225, 0.29166666666667
52205, 0.27083333333333, 0.25, 0.29166666666667
52206, 0.29166666666667, 0.25, 0.27083333333333
52207, 0.29166666666667, 0.275, 0.29166666666667
52208, 0.27083333333333, 0.3, 0.29166666666667
52209, 0.29166666666667, 0.3, 0.27083333333333
52210, 0.29166666666667, 0.325, 0.29166666666667
52211, 0.27083333333333, 0.35, 0.29166666666667
52212, 0.29166666666667, 0.35, 0.27083333333333
52213, 0.29166666666667, 0.375, 0.29166666666667
52214, 0.27083333333333, 0.4, 0.29166666666667
52215, 0.29166666666667, 0.4, 0.27083333333333
52216, 0.29166666666667, 0.425, 0.29166666666667
52217, 0.27083333333333, 0.45, 0.29166666666667
52218, 0.29166666666667, 0.45, 0.27083333333333
52219, 0.29166666666667, 0.475, 0.29166666666667
52220, 0.27083333333333, 0.5, 0.29166666666667
52221, 0.29166666666667, 0.5, 0.27083333333333
52222, 0.29166666666667, 0.525, 0.29166666666667
52223, 0.27083333333333, 0.55, 0.29166666666667
52224, 0.29166666666667, 0.55, 0.27083333333333
52225, 0.29166666666667, 0.575, 0.29166666666667
52226, 0.27083333333333, 0.6, 0.29166666666667
52227, 0.29166666666667, 0.6, 0.27083333333333
52228, 0.29166666666667, 0.625, 0.29166666666667
52229, 0.27083333333333, 0.65, 0.29166666666667
52230, 0.29166666666667, 0.65, 0.27083333333333
52231, 0.29166666666667, 0.675, 0.29166666666667
52232, 0.27083333333333, 0.7, 0.29166666666667
52233, 0.29166666666667, 0.7, 0.27083333333333
52234, 0.29166666666667, 0.725, 0.29166666666667
52235, 0.27083333333333, 0.75, 0.29166666666667
52236, 0.29166666666667, 0.75, 0.27083333333333
52237, 0.29166666666667, 0.775, 0.29166666666667
52238, 0.27083333333333, 0.8, 0.29166666666667
52239, 0.29166666666667, 0.8, 0.27083333333333
52240, 0.29166666666667, 0.825, 0.29166666666667
52241, 0.27083333333333, 0.85, 0.29166666666667
52242, 0.29166666666667, 0.85, 0.27083333333333
52243, 0.29166666666667, 0.875, 0.29166666666667
52244, 0.27083333333333, 0.9, 0.29166666666667
52245, 0.29166666666667, 0.9, 0.27083333333333
52246, 0.29166666666667, 0.925, 0.29166666666667
52247, 0.27083333333333, 0.95, 0.29166666666667
52248, 0.29166666666667, 0.95, 0.27083333333333
52249, 0.29166666666667, 0.975, 0.29166666666667
52250, 0.27083333333333, 1, 0.29166666666667
52251, 0.29166666666667, 1, 0.27083333333333
52252, 0.29166666666667, 1.025, 0.29166666666667
52253, 0.27083333333333, 1.05, 0.29166666666667
52254, 0.29166666666667, 1.05, 0.27083333333333
52255, 0.29166666666667, 1.075, 0.29166666666667
52256, 0.27083333333333, 1.1, 0.29166666666667
52257, 0.29166666666667, 1.1, 0.27083333333333
52258, 0.29166666666667, 1.125, 0.29166666666667
52259, 0.27083333333333, 1.15, 0.29166666666667
52260, 0.29166666666667, 1.15, 0.27083333333333
52261, 0.29166666666667, 1.175, 0.29166666666667
52262, 0.27083333333333, 1.2, 0.29166666666667
52263, 0.29166666666667, 1.2, 0.27083333333333
52264, 0.29166666666667, 1.225, 0.29166666666667
52265, 0.27083333333333, 1.25, 0.29166666666667
52266, 0.29166666666667, 1.25, 0.27083333333333
52267, 0.29166666666667, 1.275, 0.29166666666667
52268, 0.27083333333333, 1.3, 0.29166666666667
52269, 0.29166666666667, 1.3, 0.27083333333333
52270, 0.29166666666667, 1.325, 0.29166666666667
52271, 0.29166666666667, 0.175, 0.33333333333333
52272, 0.27083333333333, 0.2, 0.33333333333333
52273, 0.29166666666667, 0.2, 0.3125
52274, 0.29166666666667, 0.225, 0.33333333333333
52275, 0.27083333333333, 0.25, 0.33333333333333
52276, 0.29166666666667, 0.25, 0.3125
52277, 0.29166666666667, 0.275, 0.33333333333333
52278, 0.27083333333333, 0.3, 0.33333333333333
52279, 0.29166666666667, 0.3, 0.3125
52280, 0.29166666666667, 0.325, 0.33333333333333
52281, 0.27083333333333, 0.35, 0.33333333333333
52282, 0.29166666666667, 0.35, 0.3125
52283, 0.29166666666667, 0.375, 0.33333333333333
52284, 0.27083333333333, 0.4, 0.33333333333333
52285, 0.29166666666667, 0.4, 0.3125
52286, 0.29166666666667, 0.425, 0.33333333333333
52287, 0.27083333333333, 0.45, 0.33333333333333
52288, 0.29166666666667, 0.45, 0.3125
52289, 0.29166666666667, 0.475, 0.33333333333333
52290, 0.27083333333333, 0.5, 0.33333333333333
52291, 0.29166666666667, 0.5, 0.3125
52292, 0.29166666666667, 0.525, 0.33333333333333
52293, 0.27083333333333, 0.55, 0.33333333333333
52294, 0.29166666666667, 0.55, 0.3125
52295, 0.29166666666667, 0.575, 0.33333333333333
52296, 0.27083333333333, 0.6, 0.33333333333333
52297, 0.29166666666667, 0.6, 0.3125
52298, 0.29166666666667, 0.625, 0.33333333333333
52299, 0.27083333333333, 0.65, 0.33333333333333
52300, 0.29166666666667, 0.65, 0.3125
52301, 0.29166666666667, 0.675, 0.33333333333333
52302, 0.27083333333333, 0.7, 0.33333333333333
52303, 0.29166666666667, 0.7, 0.3125
52304, 0.29166666666667, 0.725, 0.33333333333333
52305, 0.27083333333333, 0.75, 0.33333333333333
52306, 0.29166666666667, 0.75, 0.3125
52307, 0.29166666666667, 0.775, 0.33333333333333
52308, 0.27083333333333, 0.8, 0.33333333333333
52309, 0.29166666666667, 0.8, 0.3125
52310, 0.29166666666667, 0.825, 0.33333333333333
52311, 0.27083333333333, 0.85, 0.33333333333333
52312, 0.29166666666667, 0.85, 0.3125
52313, 0.29166666666667, 0.875, 0.33333333333333
52314, 0.27083333333333, 0.9, 0.33333333333333
52315, 0.29166666666667, 0.9, 0.3125
52316, 0.29166666666667, 0.925, 0.33333333333333
52317, 0.27083333333333, 0.95, 0.33333333333333
52318, 0.29166666666667, 0.95, 0.3125
52319, 0.29166666666667, 0.975, 0.33333333333333
52320, 0.27083333333333, 1, 0.33333333333333
52321, 0.29166666666667, 1, 0.3125
52322, 0.29166666666667, 1.025, 0.33333333333333
52323, 0.27083333333333, 1.05, 0.33333333333333
52324, 0.29166666666667, 1.05, 0.3125
52325, 0.29166666666667, 1.075, 0.33333333333333
52326, 0.27083333333333, 1.1, 0.33333333333333
52327, 0.29166666666667, 1.1, 0.3125
52328, 0.29166666666667, 1.125, 0.33333333333333
52329, 0.27083333333333, 1.15, 0.33333333333333
52330, 0.29166666666667, 1.15, 0.3125
52331, 0.29166666666667, 1.175, 0.33333333333333
52332, 0.27083333333333, 1.2, 0.33333333333333
52333, 0.29166666666667, 1.2, 0.3125
52334, 0.29166666666667, 1.225, 0.33333333333333
52335, 0.27083333333333, 1.25, 0.33333333333333
52336, 0.29166666666667, 1.25, 0.3125
52337, 0.29166666666667, 1.275, 0.33333333333333
52338, 0.27083333333333, 1.3, 0.33333333333333
52339, 0.29166666666667, 1.3, 0.3125
52340, 0.29166666666667, 1.325, 0.33333333333333
52341, 0.29166666666667, 0.175, 0.375
52342, 0.27083333333333, 0.2, 0.375
52343, 0.29166666666667, 0.2, 0.35416666666667
52344, 0.29166666666667, 0.225, 0.375
52345, 0.27083333333333, 0.25, 0.375
52346, 0.29166666666667, 0.25, 0.35416666666667
52347, 0.29166666666667, 0.275, 0.375
52348, 0.27083333333333, 0.3, 0.375
52349, 0.29166666666667, 0.3, 0.35416666666667
52350, 0.29166666666667, 0.325, 0.375
52351, 0.27083333333333, 0.35, 0.375
52352, 0.29166666666667, 0.35, 0.35416666666667
52353, 0.29166666666667, 0.375, 0.375
52354, 0.27083333333333, 0.4, 0.375
52355, 0.29166666666667, 0.4, 0.35416666666667
52356, 0.29166666666667, 0.425, 0.375
52357, 0.27083333333333, 0.45, 0.375
52358, 0.29166666666667, 0.45, 0.35416666666667
52359, 0.29166666666667, 0.475, 0.375
52360, 0.27083333333333, 0.5, 0.375
52361, 0.29166666666667, 0.5, 0.35416666666667
52362, 0.29166666666667, 0.525, 0.375
52363, 0.27083333333333, 0.55, 0.375
52364, 0.29166666666667, 0.55, 0.35416666666667
52365, 0.29166666666667, 0.575, 0.375
52366, 0.27083333333333, 0.6, 0.375
52367, 0.29166666666667, 0.6, 0.35416666666667
52368, 0.29166666666667, 0.625, 0.375
52369, 0.27083333333333, 0.65, 0.375
52370, 0.29166666666667, 0.65, 0.35416666666667
52371, 0.29166666666667, 0.675, 0.375
52372, 0.27083333333333, 0.7, 0.375
52373, 0.29166666666667, 0.7, 0.35416666666667
52374, 0.29166666666667, 0.725, 0.375
52375, 0.27083333333333, 0.75, 0.375
52376, 0.29166666666667, 0.75, 0.35416666666667
52377, 0.29166666666667, 0.775, 0.375
52378, 0.27083333333333, 0.8, 0.375
52379, 0.29166666666667, 0.8, 0.35416666666667
52380, 0.29166666666667, 0.825, 0.375
52381, 0.27083333333333, 0.85, 0.375
52382, 0.29166666666667, 0.85, 0.35416666666667
52383, 0.29166666666667, 0.875, 0.375
52384, 0.27083333333333, 0.9, 0.375
52385, 0.29166666666667, 0.9, 0.35416666666667
52386, 0.29166666666667, 0.925, 0.375
52387, 0.27083333333333, 0.95, 0.375
52388, 0.29166666666667, 0.95, 0.35416666666667
52389, 0.29166666666667, 0.975, 0.375
52390, 0.27083333333333, 1, 0.375
52391, 0.29166666666667, 1, 0.35416666666667
52392, 0.29166666666667, 1.025, 0.375
52393, 0.27083333333333, 1.05, 0.375
52394, 0.29166666666667, 1.05, 0.35416666666667
52395, 0.29166666666667, 1.075, 0.375
52396, 0.27083333333333, 1.1, 0.375
52397, 0.29166666666667, 1.1, 0.35416666666667
52398, 0.29166666666667, 1.125, 0.375
52399, 0.27083333333333, 1.15, 0.375
52400, 0.29166666666667, 1.15, 0.35416666666667
52401, 0.29166666666667, 1.175, 0.375
52402, 0.27083333333333, 1.2, 0.375
52403, 0.29166666666667, 1.2, 0.35416666666667
52404, 0.29166666666667, 1.225, 0.375
52405, 0.27083333333333, 1.25, 0.375
52406, 0.29166666666667, 1.25, 0.35416666666667
52407, 0.29166666666667, 1.275, 0.375
52408, 0.27083333333333, 1.3, 0.375
52409, 0.29166666666667, 1.3, 0.35416666666667
52410, 0.29166666666667, 1.325, 0.375
52411, 0.29166666666667, 0.175, 0.41666666666667
52412, 0.27083333333333, 0.2, 0.41666666666667
52413, 0.29166666666667, 0.2, 0.39583333333333
52414, 0.29166666666667, 0.225, 0.41666666666667
52415, 0.27083333333333, 0.25, 0.41666666666667
52416, 0.29166666666667, 0.25, 0.39583333333333
52417, 0.29166666666667, 0.275, 0.41666666666667
52418, 0.27083333333333, 0.3, 0.41666666666667
52419, 0.29166666666667, 0.3, 0.39583333333333
52420, 0.29166666666667, 0.325, 0.41666666666667
52421, 0.27083333333333, 0.35, 0.41666666666667
52422, 0.29166666666667, 0.35, 0.39583333333333
52423, 0.29166666666667, 0.375, 0.41666666666667
52424, 0.27083333333333, 0.4, 0.41666666666667
52425, 0.29166666666667, 0.4, 0.39583333333333
52426, 0.29166666666667, 0.425, 0.41666666666667
52427, 0.27083333333333, 0.45, 0.41666666666667
52428, 0.29166666666667, 0.45, 0.39583333333333
52429, 0.29166666666667, 0.475, 0.41666666666667
52430, 0.27083333333333, 0.5, 0.41666666666667
52431, 0.29166666666667, 0.5, 0.39583333333333
52432, 0.29166666666667, 0.525, 0.41666666666667
52433, 0.27083333333333, 0.55, 0.41666666666667
52434, 0.29166666666667, 0.55, 0.39583333333333
52435, 0.29166666666667, 0.575, 0.41666666666667
52436, 0.27083333333333, 0.6, 0.41666666666667
52437, 0.29166666666667, 0.6, 0.39583333333333
52438, 0.29166666666667, 0.625, 0.41666666666667
52439, 0.27083333333333, 0.65, 0.41666666666667
52440, 0.29166666666667, 0.65, 0.39583333333333
52441, 0.29166666666667, 0.675, 0.41666666666667
52442, 0.27083333333333, 0.7, 0.41666666666667
52443, 0.29166666666667, 0.7, 0.39583333333333
52444, 0.29166666666667, 0.725, 0.41666666666667
52445, 0.27083333333333, 0.75, 0.41666666666667
52446, 0.29166666666667, 0.75, 0.39583333333333
52447, 0.29166666666667, 0.775, 0.41666666666667
52448, 0.27083333333333, 0.8, 0.41666666666667
52449, 0.29166666666667, 0.8, 0.39583333333333
52450, 0.29166666666667, 0.825, 0.41666666666667
52451, 0.27083333333333, 0.85, 0.41666666666667
52452, 0.29166666666667, 0.85, 0.39583333333333
52453, 0.29166666666667, 0.875, 0.41666666666667
52454, 0.27083333333333, 0.9, 0.41666666666667
52455, 0.29166666666667, 0.9, 0.39583333333333
52456, 0.29166666666667, 0.925, 0.41666666666667
52457, 0.27083333333333, 0.95, 0.41666666666667
52458, 0.29166666666667, 0.95, 0.39583333333333
52459, 0.29166666666667, 0.975, 0.41666666666667
52460, 0.27083333333333, 1, 0.41666666666667
52461, 0.29166666666667, 1, 0.39583333333333
52462, 0.29166666666667, 1.025, 0.41666666666667
52463, 0.27083333333333, 1.05, 0.41666666666667
52464, 0.29166666666667, 1.05, 0.39583333333333
52465, 0.29166666666667, 1.075, 0.41666666666667
52466, 0.27083333333333, 1.1, 0.41666666666667
52467, 0.29166666666667, 1.1, 0.39583333333333
52468, 0.29166666666667, 1.125, 0.41666666666667
52469, 0.27083333333333, 1.15, 0.41666666666667
52470, 0.29166666666667, 1.15, 0.39583333333333
52471, 0.29166666666667, 1.175, 0.41666666666667
52472, 0.27083333333333, 1.2, 0.41666666666667
52473, 0.29166666666667, 1.2, 0.39583333333333
52474, 0.29166666666667, 1.225, 0.41666666666667
52475, 0.27083333333333, 1.25, 0.41666666666667
52476, 0.29166666666667, 1.25, 0.39583333333333
52477, 0.29166666666667, 1.275, 0.41666666666667
52478, 0.27083333333333, 1.3, 0.41666666666667
52479, 0.29166666666667, 1.3, 0.39583333333333
52480, 0.29166666666667, 1.325, 0.41666666666667
52481, 0.29166666666667, 0.175, 0.45833333333333
52482, 0.27083333333333, 0.2, 0.45833333333333
52483, 0.29166666666667, 0.2, 0.4375
52484, 0.29166666666667, 0.225, 0.45833333333333
52485, 0.27083333333333, 0.25, 0.45833333333333
52486, 0.29166666666667, 0.25, 0.4375
52487, 0.29166666666667, 0.275, 0.45833333333333
52488, 0.27083333333333, 0.3, 0.45833333333333
52489, 0.29166666666667, 0.3, 0.4375
52490, 0.29166666666667, 0.325, 0.45833333333333
52491, 0.27083333333333, 0.35, 0.45833333333333
52492, 0.29166666666667, 0.35, 0.4375
52493, 0.29166666666667, 0.375, 0.45833333333333
52494, 0.27083333333333, 0.4, 0.45833333333333
52495, 0.29166666666667, 0.4, 0.4375
52496, 0.29166666666667, 0.425, 0.45833333333333
52497, 0.27083333333333, 0.45, 0.45833333333333
52498, 0.29166666666667, 0.45, 0.4375
52499, 0.29166666666667, 0.475, 0.45833333333333
52500, 0.27083333333333, 0.5, 0.45833333333333
52501, 0.29166666666667, 0.5, 0.4375
52502, 0.29166666666667, 0.525, 0.45833333333333
52503, 0.27083333333333, 0.55, 0.45833333333333
52504, 0.29166666666667, 0.55, 0.4375
52505, 0.29166666666667, 0.575, 0.45833333333333
52506, 0.27083333333333, 0.6, 0.45833333333333
52507, 0.29166666666667, 0.6, 0.4375
52508, 0.29166666666667, 0.625, 0.45833333333333
52509, 0.27083333333333, 0.65, 0.45833333333333
52510, 0.29166666666667, 0.65, 0.4375
52511, 0.29166666666667, 0.675, 0.45833333333333
52512, 0.27083333333333, 0.7, 0.45833333333333
52513, 0.29166666666667, 0.7, 0.4375
52514, 0.29166666666667, 0.725, 0.45833333333333
52515, 0.27083333333333, 0.75, 0.45833333333333
52516, 0.29166666666667, 0.75, 0.4375
52517, 0.29166666666667, 0.775, 0.45833333333333
52518, 0.27083333333333, 0.8, 0.45833333333333
52519, 0.29166666666667, 0.8, 0.4375
52520, 0.29166666666667, 0.825, 0.45833333333333
52521, 0.27083333333333, 0.85, 0.45833333333333
52522, 0.29166666666667, 0.85, 0.4375
52523, 0.29166666666667, 0.875, 0.45833333333333
52524, 0.27083333333333, 0.9, 0.45833333333333
52525, 0.29166666666667, 0.9, 0.4375
52526, 0.29166666666667, 0.925, 0.45833333333333
52527, 0.27083333333333, 0.95, 0.45833333333333
52528, 0.29166666666667, 0.95, 0.4375
52529, 0.29166666666667, 0.975, 0.45833333333333
52530, 0.27083333333333, 1, 0.45833333333333
52531, 0.29166666666667, 1, 0.4375
52532, 0.29166666666667, 1.025, 0.45833333333333
52533, 0.27083333333333, 1.05, 0.45833333333333
52534, 0.29166666666667, 1.05, 0.4375
52535, 0.29166666666667, 1.075, 0.45833333333333
52536, 0.27083333333333, 1.1, 0.45833333333333
52537, 0.29166666666667, 1.1, 0.4375
52538, 0.29166666666667, 1.125, 0.45833333333333
52539, 0.27083333333333, 1.15, 0.45833333333333
52540, 0.29166666666667, 1.15, 0.4375
52541, 0.29166666666667, 1.175, 0.45833333333333
52542, 0.27083333333333, 1.2, 0.45833333333333
52543, 0.29166666666667, 1.2, 0.4375
52544, 0.29166666666667, 1.225, 0.45833333333333
52545, 0.27083333333333, 1.25, 0.45833333333333
52546, 0.29166666666667, 1.25, 0.4375
52547, 0.29166666666667, 1.275, 0.45833333333333
52548, 0.27083333333333, 1.3, 0.45833333333333
52549, 0.29166666666667, 1.3, 0.4375
52550, 0.29166666666667, 1.325, 0.45833333333333
52551, 0.29166666666667, 0.2, 0.47916666666667
52552, 0.29166666666667, 0.25, 0.47916666666667
52553, 0.29166666666667, 0.3, 0.47916666666667
52554, 0.29166666666667, 0.35, 0.47916666666667
52555, 0.29166666666667, 0.4, 0.47916666666667
52556, 0.29166666666667, 0.45, 0.47916666666667
52557, 0.29166666666667, 0.5, 0.47916666666667
52558, 0.29166666666667, 0.55, 0.47916666666667
52559, 0.29166666666667, 0.6, 0.47916666666667
52560, 0.29166666666667, 0.65, 0.47916666666667
52561, 0.29166666666667, 0.7, 0.47916666666667
52562, 0.29166666666667, 0.75, 0.47916666666667
52563, 0.29166666666667, 0.8, 0.47916666666667
52564, 0.29166666666667, 0.85, 0.47916666666667
52565, 0.29166666666667, 0.9, 0.47916666666667
52566, 0.29166666666667, 0.95, 0.47916666666667
52567, 0.29166666666667, 1, 0.47916666666667
52568, 0.29166666666667, 1.05, 0.47916666666667
52569, 0.29166666666667, 1.1, 0.47916666666667
52570, 0.29166666666667, 1.15, 0.47916666666667
52571, 0.29166666666667, 1.2, 0.47916666666667
52572, 0.29166666666667, 1.25, 0.47916666666667
52573, 0.29166666666667, 1.3, 0.47916666666667
52574, 0.33333333333333, 0.175, 0.041666666666667
52575, 0.3125, 0.2, 0.041666666666667
52576, 0.33333333333333, 0.2, 0.020833333333333
52577, 0.33333333333333, 0.225, 0.041666666666667
52578, 0.3125, 0.25, 0.041666666666667
52579, 0.33333333333333, 0.25, 0.020833333333333
52580, 0.33333333333333, 0.275, 0.041666666666667
52581, 0.3125, 0.3, 0.041666666666667
52582, 0.33333333333333, 0.3, 0.020833333333333
52583, 0.33333333333333, 0.325, 0.041666666666667
52584, 0.3125, 0.35, 0.041666666666667
52585, 0.33333333333333, 0.35, 0.020833333333333
52586, 0.33333333333333, 0.375, 0.041666666666667
52587, 0.3125, 0.4, 0.041666666666667
52588, 0.33333333333333, 0.4, 0.020833333333333
52589, 0.33333333333333, 0.425, 0.041666666666667
52590, 0.3125, 0.45, 0.041666666666667
52591, 0.33333333333333, 0.45, 0.020833333333333
52592, 0.33333333333333, 0.475, 0.041666666666667
52593, 0.3125, 0.5, 0.041666666666667
52594, 0.33333333333333, 0.5, 0.020833333333333
52595, 0.33333333333333, 0.525, 0.041666666666667
52596, 0.3125, 0.55, 0.041666666666667
52597, 0.33333333333333, 0.55, 0.020833333333333
52598, 0.33333333333333, 0.575, 0.041666666666667
52599, 0.3125, 0.6, 0.041666666666667
52600, 0.33333333333333, 0.6, 0.020833333333333
52601, 0.33333333333333, 0.625, 0.041666666666667
52602, 0.3125, 0.65, 0.041666666666667
52603, 0.33333333333333, 0.65, 0.020833333333333
52604, 0.33333333333333, 0.675, 0.041666666666667
52605, 0.3125, 0.7, 0.041666666666667
52606, 0.33333333333333, 0.7, 0.020833333333333
52607, 0.33333333333333, 0.725, 0.041666666666667
52608, 0.3125, 0.75, 0.041666666666667
52609, 0.33333333333333, 0.75, 0.020833333333333
52610, 0.33333333333333, 0.775, 0.041666666666667
52611, 0.3125, 0.8, 0.041666666666667
52612, 0.33333333333333, 0.8, 0.020833333333333
52613, 0.33333333333333, 0.825, 0.041666666666667
52614, 0.3125, 0.85, 0.041666666666667
52615, 0.33333333333333, 0.85, 0.020833333333333
52616, 0.33333333333333, 0.875, 0.041666666666667
52617, 0.3125, 0.9, 0.041666666666667
52618, 0.33333333333333, 0.9, 0.020833333333333
52619, 0.33333333333333, 0.925, 0.041666666666667
52620, 0.3125, 0.95, 0.041666666666667
52621, 0.33333333333333, 0.95, 0.020833333333333
52622, 0.33333333333333, 0.975, 0.041666666666667
52623, 0.3125, 1, 0.041666666666667
52624, 0.33333333333333, 1, 0.020833333333333
52625, 0.33333333333333, 1.025, 0.041666666666667
52626, 0.3125, 1.05, 0.041666666666667
52627, 0.33333333333333, 1.05, 0.020833333333333
52628, 0.33333333333333, 1.075, 0.041666666666667
52629, 0.3125, 1.1, 0.041666666666667
52630, 0.33333333333333, 1.1, 0.020833333333333
52631, 0.33333333333333, 1.125, 0.041666666666667
52632, 0.3125, 1.15, 0.041666666666667
52633, 0.33333333333333, 1.15, 0.020833333333333
52634, 0.33333333333333, 1.175, 0.041666666666667
52635, 0.3125, 1.2, 0.041666666666667
52636, 0.33333333333333, 1.2, 0.020833333333333
52637, 0.33333333333333, 1.225, 0.041666666666667
52638, 0.3125, 1.25, 0.041666666666667
52639, 0.33333333333333, 1.25, 0.020833333333333
52640, 0.33333333333333, 1.275, 0.041666666666667
52641, 0.3125, 1.3, 0.041666666666667
52642, 0.33333333333333, 1.3, 0.020833333333333
52643, 0.33333333333333, 1.325, 0.041666666666667
52644, 0.33333333333333, 0.175, 0.083333333333333
52645, 0.3125, 0.2, 0.083333333333333
52646, 0.33333333333333, 0.2, 0.0625
52647, 0.33333333333333, 0.225, 0.083333333333333
52648, 0.3125, 0.25, 0.083333333333333
52649, 0.33333333333333, 0.25, 0.0625
52650, 0.33333333333333, 0.275, 0.083333333333333
52651, 0.3125, 0.3, 0.083333333333333
52652, 0.33333333333333, 0.3, 0.0625
52653, 0.33333333333333, 0.325, 0.083333333333333
52654, 0.3125, 0.35, 0.083333333333333
52655, 0.33333333333333, 0.35, 0.0625
52656, 0.33333333333333, 0.375, 0.083333333333333
52657, 0.3125, 0.4, 0.083333333333333
52658, 0.33333333333333, 0.4, 0.0625
52659, 0.33333333333333, 0.425, 0.083333333333333
52660, 0.3125, 0.45, 0.083333333333333
52661, 0.33333333333333, 0.45, 0.0625
52662, 0.33333333333333, 0.475, 0.083333333333333
52663, 0.3125, 0.5, 0.083333333333333
52664, 0.33333333333333, 0.5, 0.0625
52665, 0.33333333333333, 0.525, 0.083333333333333
52666, 0.3125, 0.55, 0.083333333333333
52667, 0.33333333333333, 0.55, 0.0625
52668, 0.33333333333333, 0.575, 0.083333333333333
52669, 0.3125, 0.6, 0.083333333333333
52670, 0.33333333333333, 0.6, 0.0625
52671, 0.33333333333333, 0.625, 0.083333333333333
52672, 0.3125, 0.65, 0.083333333333333
52673, 0.33333333333333, 0.65, 0.0625
52674, 0.33333333333333, 0.675, 0.083333333333333
52675, 0.3125, 0.7, 0.083333333333333
52676, 0.33333333333333, 0.7, 0.0625
52677, 0.33333333333333, 0.725, 0.083333333333333
52678, 0.3125, 0.75, 0.083333333333333
52679, 0.33333333333333, 0.75, 0.0625
52680, 0.33333333333333, 0.775, 0.083333333333333
52681, 0.3125, 0.8, 0.083333333333333
52682, 0.33333333333333, 0.8, 0.0625
52683, 0.33333333333333, 0.825, 0.083333333333333
52684, 0.3125, 0.85, 0.083333333333333
52685, 0.33333333333333, 0.85, 0.0625
52686, 0.33333333333333, 0.875, 0.083333333333333
52687, 0.3125, 0.9, 0.083333333333333
52688, 0.33333333333333, 0.9, 0.0625
52689, 0.33333333333333, 0.925, 0.083333333333333
52690, 0.3125, 0.95, 0.083333333333333
52691, 0.33333333333333, 0.95, 0.0625
52692, 0.33333333333333, 0.975, 0.083333333333333
52693, 0.3125, 1, 0.083333333333333
52694, 0.33333333333333, 1, 0.0625
52695, 0.33333333333333, 1.025, 0.083333333333333
52696, 0.3125, 1.05, 0.083333333333333
52697, 0.33333333333333, 1.05, 0.0625
52698, 0.33333333333333, 1.075, 0.083333333333333
52699, 0.3125, 1.1, 0.083333333333333
52700, 0.33333333333333, 1.1, 0.0625
52701, 0.33333333333333, 1.125, 0.083333333333333
52702, 0.3125, 1.15, 0.083333333333333
52703, 0.33333333333333, 1.15, 0.0625
52704, 0.33333333333333, 1.175, 0.083333333333333
52705, 0.3125, 1.2, 0.083333333333333
52706, 0.33333333333333, 1.2, 0.0625
52707, 0.33333333333333, 1.225, 0.083333333333333
52708, 0.3125, 1.25, 0.083333333333333
52709, 0.33333333333333, 1.25, 0.0625
52710, 0.33333333333333, 1.275, 0.083333333333333
52711, 0.3125, 1.3, 0.083333333333333
52712, 0.33333333333333, 1.3, 0.0625
52713, 0.33333333333333, 1.325, 0.083333333333333
52714, 0.33333333333333, 0.175, 0.125
52715, 0.3125, 0.2, 0.125
52716, 0.33333333333333, 0.2, 0.10416666666667
52717, 0.33333333333333, 0.225, 0.125
52718, 0.3125, 0.25, 0.125
52719, 0.33333333333333, 0.25, 0.10416666666667
52720, 0.33333333333333, 0.275, 0.125
52721, 0.3125, 0.3, 0.125
52722, 0.33333333333333, 0.3, 0.10416666666667
52723, 0.33333333333333, 0.325, 0.125
52724, 0.3125, 0.35, 0.125
52725, 0.33333333333333, 0.35, 0.10416666666667
52726, 0.33333333333333, 0.375, 0.125
52727, 0.3125, 0.4, 0.125
52728, 0.33333333333333, 0.4, 0.10416666666667
52729, 0.33333333333333, 0.425, 0.125
52730, 0.3125, 0.45, 0.125
52731, 0.33333333333333, 0.45, 0.10416666666667
52732, 0.33333333333333, 0.475, 0.125
52733, 0.3125, 0.5, 0.125
52734, 0.33333333333333, 0.5, 0.10416666666667
52735, 0.33333333333333, 0.525, 0.125
52736, 0.3125, 0.55, 0.125
52737, 0.33333333333333, 0.55, 0.10416666666667
52738, 0.33333333333333, 0.575, 0.125
52739, 0.3125, 0.6, 0.125
52740, 0.33333333333333, 0.6, 0.10416666666667
52741, 0.33333333333333, 0.625, 0.125
52742, 0.3125, 0.65, 0.125
52743, 0.33333333333333, 0.65, 0.10416666666667
52744, 0.33333333333333, 0.675, 0.125
52745, 0.3125, 0.7, 0.125
52746, 0.33333333333333, 0.7, 0.10416666666667
52747, 0.33333333333333, 0.725, 0.125
52748, 0.3125, 0.75, 0.125
52749, 0.33333333333333, 0.75, 0.10416666666667
52750, 0.33333333333333, 0.775, 0.125
52751, 0.3125, 0.8, 0.125
52752, 0.33333333333333, 0.8, 0.10416666666667
52753, 0.33333333333333, 0.825, 0.125
52754, 0.3125, 0.85, 0.125
52755, 0.33333333333333, 0.85, 0.10416666666667
52756, 0.33333333333333, 0.875, 0.125
52757, 0.3125, 0.9, 0.125
52758, 0.33333333333333, 0.9, 0.10416666666667
52759, 0.33333333333333, 0.925, 0.125
52760, 0.3125, 0.95, 0.125
52761, 0.33333333333333, 0.95, 0.10416666666667
52762, 0.33333333333333, 0.975, 0.125
52763, 0.3125, 1, 0.125
52764, 0.33333333333333, 1, 0.10416666666667
52765, 0.33333333333333, 1.025, 0.125
52766, 0.3125, 1.05, 0.125
52767, 0.33333333333333, 1.05, 0.10416666666667
52768, 0.33333333333333, 1.075, 0.125
52769, 0.3125, 1.1, 0.125
52770, 0.33333333333333, 1.1, 0.10416666666667
52771, 0.33333333333333, 1.125, 0.125
52772, 0.3125, 1.15, 0.125
52773, 0.33333333333333, 1.15, 0.10416666666667
52774, 0.33333333333333, 1.175, 0.125
52775, 0.3125, 1.2, 0.125
52776, 0.33333333333333, 1.2, 0.10416666666667
52777, 0.33333333333333, 1.225, 0.125
52778, 0.3125, 1.25, 0.125
52779, 0.33333333333333, 1.25, 0.10416666666667
52780, 0.33333333333333, 1.275, 0.125
52781, 0.3125, 1.3, 0.125
52782, 0.33333333333333, 1.3, 0.10416666666667
52783, 0.33333333333333, 1.325, 0.125
52784, 0.33333333333333, 0.175, 0.16666666666667
52785, 0.3125, 0.2, 0.16666666666667
52786, 0.33333333333333, 0.2, 0.14583333333333
52787, 0.33333333333333, 0.225, 0.16666666666667
52788, 0.3125, 0.25, 0.16666666666667
52789, 0.33333333333333, 0.25, 0.14583333333333
52790, 0.33333333333333, 0.275, 0.16666666666667
52791, 0.3125, 0.3, 0.16666666666667
52792, 0.33333333333333, 0.3, 0.14583333333333
52793, 0.33333333333333, 0.325, 0.16666666666667
52794, 0.3125, 0.35, 0.16666666666667
52795, 0.33333333333333, 0.35, 0.14583333333333
52796, 0.33333333333333, 0.375, 0.16666666666667
52797, 0.3125, 0.4, 0.16666666666667
52798, 0.33333333333333, 0.4, 0.14583333333333
52799, 0.33333333333333, 0.425, 0.16666666666667
52800, 0.3125, 0.45, 0.16666666666667
52801, 0.33333333333333, 0.45, 0.14583333333333
52802, 0.33333333333333, 0.475, 0.16666666666667
52803, 0.3125, 0.5, 0.16666666666667
52804, 0.33333333333333, 0.5, 0.14583333333333
52805, 0.33333333333333, 0.525, 0.16666666666667
52806, 0.3125, 0.55, 0.16666666666667
52807, 0.33333333333333, 0.55, 0.14583333333333
52808, 0.33333333333333, 0.575, 0.16666666666667
52809, 0.3125, 0.6, 0.16666666666667
52810, 0.33333333333333, 0.6, 0.14583333333333
52811, 0.33333333333333, 0.625, 0.16666666666667
52812, 0.3125, 0.65, 0.16666666666667
52813, 0.33333333333333, 0.65, 0.14583333333333
52814, 0.33333333333333, 0.675, 0.16666666666667
52815, 0.3125, 0.7, 0.16666666666667
52816, 0.33333333333333, 0.7, 0.14583333333333
52817, 0.33333333333333, 0.725, 0.16666666666667
52818, 0.3125, 0.75, 0.16666666666667
52819, 0.33333333333333, 0.75, 0.14583333333333
52820, 0.33333333333333, 0.775, 0.16666666666667
52821, 0.3125, 0.8, 0.16666666666667
52822, 0.33333333333333, 0.8, 0.14583333333333
52823, 0.33333333333333, 0.825, 0.16666666666667
52824, 0.3125, 0.85, 0.16666666666667
52825, 0.33333333333333, 0.85, 0.14583333333333
52826, 0.33333333333333, 0.875, 0.16666666666667
52827, 0.3125, 0.9, 0.16666666666667
52828, 0.33333333333333, 0.9, 0.14583333333333
52829, 0.33333333333333, 0.925, 0.16666666666667
52830, 0.3125, 0.95, 0.16666666666667
52831, 0.33333333333333, 0.95, 0.14583333333333
52832, 0.33333333333333, 0.975, 0.16666666666667
52833, 0.3125, 1, 0.16666666666667
52834, 0.33333333333333, 1, 0.14583333333333
52835, 0.33333333333333, 1.025, 0.16666666666667
52836, 0.3125, 1.05, 0.16666666666667
52837, 0.33333333333333, 1.05, 0.14583333333333
52838, 0.33333333333333, 1.075, 0.16666666666667
52839, 0.3125, 1.1, 0.16666666666667
52840, 0.33333333333333, 1.1, 0.14583333333333
52841, 0.33333333333333, 1.125, 0.16666666666667
52842, 0.3125, 1.15, 0.16666666666667
52843, 0.33333333333333, 1.15, 0.14583333333333
52844, 0.33333333333333, 1.175, 0.16666666666667
52845, 0.3125, 1.2, 0.16666666666667
52846, 0.33333333333333, 1.2, 0.14583333333333
52847, 0.33333333333333, 1.225, 0.16666666666667
52848, 0.3125, 1.25, 0.16666666666667
52849, 0.33333333333333, 1.25, 0.14583333333333
52850, 0.33333333333333, 1.275, 0.16666666666667
52851, 0.3125, 1.3, 0.16666666666667
52852, 0.33333333333333, 1.3, 0.14583333333333
52853, 0.33333333333333, 1.325, 0.16666666666667
52854, 0.33333333333333, 0.175, 0.20833333333333
52855, 0.3125, 0.2, 0.20833333333333
52856, 0.33333333333333, 0.2, 0.1875
52857, 0.33333333333333, 0.225, 0.20833333333333
52858, 0.3125, 0.25, 0.20833333333333
52859, 0.33333333333333, 0.25, 0.1875
52860, 0.33333333333333, 0.275, 0.20833333333333
52861, 0.3125, 0.3, 0.20833333333333
52862, 0.33333333333333, 0.3, 0.1875
52863, 0.33333333333333, 0.325, 0.20833333333333
52864, 0.3125, 0.35, 0.20833333333333
52865, 0.33333333333333, 0.35, 0.1875
52866, 0.33333333333333, 0.375, 0.20833333333333
52867, 0.3125, 0.4, 0.20833333333333
52868, 0.33333333333333, 0.4, 0.1875
52869, 0.33333333333333, 0.425, 0.20833333333333
52870, 0.3125, 0.45, 0.20833333333333
52871, 0.33333333333333, 0.45, 0.1875
52872, 0.33333333333333, 0.475, 0.20833333333333
52873, 0.3125, 0.5, 0.20833333333333
52874, 0.33333333333333, 0.5, 0.1875
52875, 0.33333333333333, 0.525, 0.20833333333333
52876, 0.3125, 0.55, 0.20833333333333
52877, 0.33333333333333, 0.55, 0.1875
52878, 0.33333333333333, 0.575, 0.20833333333333
52879, 0.3125, 0.6, 0.20833333333333
52880, 0.33333333333333, 0.6, 0.1875
52881, 0.33333333333333, 0.625, 0.20833333333333
52882, 0.3125, 0.65, 0.20833333333333
52883, 0.33333333333333, 0.65, 0.1875
52884, 0.33333333333333, 0.675, 0.20833333333333
52885, 0.3125, 0.7, 0.20833333333333
52886, 0.33333333333333, 0.7, 0.1875
52887, 0.33333333333333, 0.725, 0.20833333333333
52888, 0.3125, 0.75, 0.20833333333333
52889, 0.33333333333333, 0.75, 0.1875
52890, 0.33333333333333, 0.775, 0.20833333333333
52891, 0.3125, 0.8, 0.20833333333333
52892, 0.33333333333333, 0.8, 0.1875
52893, 0.33333333333333, 0.825, 0.20833333333333
52894, 0.3125, 0.85, 0.20833333333333
52895, 0.33333333333333, 0.85, 0.1875
52896, 0.33333333333333, 0.875, 0.20833333333333
52897, 0.3125, 0.9, 0.20833333333333
52898, 0.33333333333333, 0.9, 0.1875
52899, 0.33333333333333, 0.925, 0.20833333333333
52900, 0.3125, 0.95, 0.20833333333333
52901, 0.33333333333333, 0.95, 0.1875
52902, 0.33333333333333, 0.975, 0.20833333333333
52903, 0.3125, 1, 0.20833333333333
52904, 0.33333333333333, 1, 0.1875
52905, 0.33333333333333, 1.025, 0.20833333333333
52906, 0.3125, 1.05, 0.20833333333333
52907, 0.33333333333333, 1.05, 0.1875
52908, 0.33333333333333, 1.075, 0.20833333333333
52909, 0.3125, 1.1, 0.20833333333333
52910, 0.33333333333333, 1.1, 0.1875
52911, 0.33333333333333, 1.125, 0.20833333333333
52912, 0.3125, 1.15, 0.20833333333333
52913, 0.33333333333333, 1.15, 0.1875
52914, 0.33333333333333, 1.175, 0.20833333333333
52915, 0.3125, 1.2, 0.20833333333333
52916, 0.33333333333333, 1.2, 0.1875
52917, 0.33333333333333, 1.225, 0.20833333333333
52918, 0.3125, 1.25, 0.20833333333333
52919, 0.33333333333333, 1.25, 0.1875
52920, 0.33333333333333, 1.275, 0.20833333333333
52921, 0.3125, 1.3, 0.20833333333333
52922, 0.33333333333333, 1.3, 0.1875
52923, 0.33333333333333, 1.325, 0.20833333333333
52924, 0.33333333333333, 0.175, 0.25
52925, 0.3125, 0.2, 0.25
52926, 0.33333333333333, 0.2, 0.22916666666667
52927, 0.33333333333333, 0.225, 0.25
52928, 0.3125, 0.25, 0.25
52929, 0.33333333333333, 0.25, 0.22916666666667
52930, 0.33333333333333, 0.275, 0.25
52931, 0.3125, 0.3, 0.25
52932, 0.33333333333333, 0.3, 0.22916666666667
52933, 0.33333333333333, 0.325, 0.25
52934, 0.3125, 0.35, 0.25
52935, 0.33333333333333, 0.35, 0.22916666666667
52936, 0.33333333333333, 0.375, 0.25
52937, 0.3125, 0.4, 0.25
52938, 0.33333333333333, 0.4, 0.22916666666667
52939, 0.33333333333333, 0.425, 0.25
52940, 0.3125, 0.45, 0.25
52941, 0.33333333333333, 0.45, 0.22916666666667
52942, 0.33333333333333, 0.475, 0.25
52943, 0.3125, 0.5, 0.25
52944, 0.33333333333333, 0.5, 0.22916666666667
52945, 0.33333333333333, 0.525, 0.25
52946, 0.3125, 0.55, 0.25
52947, 0.33333333333333, 0.55, 0.22916666666667
52948, 0.33333333333333, 0.575, 0.25
52949, 0.3125, 0.6, 0.25
52950, 0.33333333333333, 0.6, 0.22916666666667
52951, 0.33333333333333, 0.625, 0.25
52952, 0.3125, 0.65, 0.25
52953, 0.33333333333333, 0.65, 0.22916666666667
52954, 0.33333333333333, 0.675, 0.25
52955, 0.3125, 0.7, 0.25
52956, 0.33333333333333, 0.7, 0.22916666666667
52957, 0.33333333333333, 0.725, 0.25
52958, 0.3125, 0.75, 0.25
52959, 0.33333333333333, 0.75, 0.22916666666667
52960, 0.33333333333333, 0.775, 0.25
52961, 0.3125, 0.8, 0.25
52962, 0.33333333333333, 0.8, 0.22916666666667
52963, 0.33333333333333, 0.825, 0.25
52964, 0.3125, 0.85, 0.25
52965, 0.33333333333333, 0.85, 0.22916666666667
52966, 0.33333333333333, 0.875, 0.25
52967, 0.3125, 0.9, 0.25
52968, 0.33333333333333, 0.9, 0.22916666666667
52969, 0.33333333333333, 0.925, 0.25
52970, 0.3125, 0.95, 0.25
52971, 0.33333333333333, 0.95, 0.22916666666667
52972, 0.33333333333333, 0.975, 0.25
52973, 0.3125, 1, 0.25
52974, 0.33333333333333, 1, 0.22916666666667
52975, 0.33333333333333, 1.025, 0.25
52976, 0.3125, 1.05, 0.25
52977, 0.33333333333333, 1.05, 0.22916666666667
52978, 0.33333333333333, 1.075, 0.25
52979, 0.3125, 1.1, 0.25
52980, 0.33333333333333, 1.1, 0.22916666666667
52981, 0.33333333333333, 1.125, 0.25
52982, 0.3125, 1.15, 0.25
52983, 0.33333333333333, 1.15, 0.22916666666667
52984, 0.33333333333333, 1.175, 0.25
52985, 0.3125, 1.2, 0.25
52986, 0.33333333333333, 1.2, 0.22916666666667
52987, 0.33333333333333, 1.225, 0.25
52988, 0.3125, 1.25, 0.25
52989, 0.33333333333333, 1.25, 0.22916666666667
52990, 0.33333333333333, 1.275, 0.25
52991, 0.3125, 1.3, 0.25
52992, 0.33333333333333, 1.3, 0.22916666666667
52993, 0.33333333333333, 1.325, 0.25
52994, 0.33333333333333, 0.175, 0.29166666666667
52995, 0.3125, 0.2, 0.29166666666667
52996, 0.33333333333333, 0.2, 0.27083333333333
52997, 0.33333333333333, 0.225, 0.29166666666667
52998, 0.3125, 0.25, 0.29166666666667
52999, 0.33333333333333, 0.25, 0.27083333333333
53000, 0.33333333333333, 0.275, 0.29166666666667
53001, 0.3125, 0.3, 0.29166666666667
53002, 0.33333333333333, 0.3, 0.27083333333333
53003, 0.33333333333333, 0.325, 0.29166666666667
53004, 0.3125, 0.35, 0.29166666666667
53005, 0.33333333333333, 0.35, 0.27083333333333
53006, 0.33333333333333, 0.375, 0.29166666666667
53007, 0.3125, 0.4, 0.29166666666667
53008, 0.33333333333333, 0.4, 0.27083333333333
53009, 0.33333333333333, 0.425, 0.29166666666667
53010, 0.3125, 0.45, 0.29166666666667
53011, 0.33333333333333, 0.45, 0.27083333333333
53012, 0.33333333333333, 0.475, 0.29166666666667
53013, 0.3125, 0.5, 0.29166666666667
53014, 0.33333333333333, 0.5, 0.27083333333333
53015, 0.33333333333333, 0.525, 0.29166666666667
53016, 0.3125, 0.55, 0.29166666666667
53017, 0.33333333333333, 0.55, 0.27083333333333
53018, 0.33333333333333, 0.575, 0.29166666666667
53019, 0.3125, 0.6, 0.29166666666667
53020, 0.33333333333333, 0.6, 0.27083333333333
53021, 0.33333333333333, 0.625, 0.29166666666667
53022, 0.3125, 0.65, 0.29166666666667
53023, 0.33333333333333, 0.65, 0.27083333333333
53024, 0.33333333333333, 0.675, 0.29166666666667
53025, 0.3125, 0.7, 0.29166666666667
53026, 0.33333333333333, 0.7, 0.27083333333333
53027, 0.33333333333333, 0.725, 0.29166666666667
53028, 0.3125, 0.75, 0.29166666666667
53029, 0.33333333333333, 0.75, 0.27083333333333
53030, 0.33333333333333, 0.775, 0.29166666666667
53031, 0.3125, 0.8, 0.29166666666667
53032, 0.33333333333333, 0.8, 0.27083333333333
53033, 0.33333333333333, 0.825, 0.29166666666667
53034, 0.3125, 0.85, 0.29166666666667
53035, 0.33333333333333, 0.85, 0.27083333333333
53036, 0.33333333333333, 0.875, 0.29166666666667
53037, 0.3125, 0.9, 0.29166666666667
53038, 0.33333333333333, 0.9, 0.27083333333333
53039, 0.33333333333333, 0.925, 0.29166666666667
53040, 0.3125, 0.95, 0.29166666666667
53041, 0.33333333333333, 0.95, 0.27083333333333
53042, 0.33333333333333, 0.975, 0.29166666666667
53043, 0.3125, 1, 0.29166666666667
53044, 0.33333333333333, 1, 0.27083333333333
53045, 0.33333333333333, 1.025, 0.29166666666667
53046, 0.3125, 1.05, 0.29166666666667
53047, 0.33333333333333, 1.05, 0.27083333333333
53048, 0.33333333333333, 1.075, 0.29166666666667
53049, 0.3125, 1.1, 0.29166666666667
53050, 0.33333333333333, 1.1, 0.27083333333333
53051, 0.33333333333333, 1.125, 0.29166666666667
53052, 0.3125, 1.15, 0.29166666666667
53053, 0.33333333333333, 1.15, 0.27083333333333
53054, 0.33333333333333, 1.175, 0.29166666666667
53055, 0.3125, 1.2, 0.29166666666667
53056, 0.33333333333333, 1.2, 0.27083333333333
53057, 0.33333333333333, 1.225, 0.29166666666667
53058, 0.3125, 1.25, 0.29166666666667
53059, 0.33333333333333, 1.25, 0.27083333333333
53060, 0.33333333333333, 1.275, 0.29166666666667
53061, 0.3125, 1.3, 0.29166666666667
53062, 0.33333333333333, 1.3, 0.27083333333333
53063, 0.33333333333333, 1.325, 0.29166666666667
53064, 0.33333333333333, 0.175, 0.33333333333333
53065, 0.3125, 0.2, 0.33333333333333
53066, 0.33333333333333, 0.2, 0.3125
53067, 0.33333333333333, 0.225, 0.33333333333333
53068, 0.3125, 0.25, 0.33333333333333
53069, 0.33333333333333, 0.25, 0.3125
53070, 0.33333333333333, 0.275, 0.33333333333333
53071, 0.3125, 0.3, 0.33333333333333
53072, 0.33333333333333, 0.3, 0.3125
53073, 0.33333333333333, 0.325, 0.33333333333333
53074, 0.3125, 0.35, 0.33333333333333
53075, 0.33333333333333, 0.35, 0.3125
53076, 0.33333333333333, 0.375, 0.33333333333333
53077, 0.3125, 0.4, 0.33333333333333
53078, 0.33333333333333, 0.4, 0.3125
53079, 0.33333333333333, 0.425, 0.33333333333333
53080, 0.3125, 0.45, 0.33333333333333
53081, 0.33333333333333, 0.45, 0.3125
53082, 0.33333333333333, 0.475, 0.33333333333333
53083, 0.3125, 0.5, 0.33333333333333
53084, 0.33333333333333, 0.5, 0.3125
53085, 0.33333333333333, 0.525, 0.33333333333333
53086, 0.3125, 0.55, 0.33333333333333
53087, 0.33333333333333, 0.55, 0.3125
53088, 0.33333333333333, 0.575, 0.33333333333333
53089, 0.3125, 0.6, 0.33333333333333
53090, 0.33333333333333, 0.6, 0.3125
53091, 0.33333333333333, 0.625, 0.33333333333333
53092, 0.3125, 0.65, 0.33333333333333
53093, 0.33333333333333, 0.65, 0.3125
53094, 0.33333333333333, 0.675, 0.33333333333333
53095, 0.3125, 0.7, 0.33333333333333
53096, 0.33333333333333, 0.7, 0.3125
53097, 0.33333333333333, 0.725, 0.33333333333333
53098, 0.3125, 0.75, 0.33333333333333
53099, 0.33333333333333, 0.75, 0.3125
53100, 0.33333333333333, 0.775, 0.33333333333333
53101, 0.3125, 0.8, 0.33333333333333
53102, 0.33333333333333, 0.8, 0.3125
53103, 0.33333333333333, 0.825, 0.33333333333333
53104, 0.3125, 0.85, 0.33333333333333
53105, 0.33333333333333, 0.85, 0.3125
53106, 0.33333333333333, 0.875, 0.33333333333333
53107, 0.3125, 0.9, 0.33333333333333
53108, 0.33333333333333, 0.9, 0.3125
53109, 0.33333333333333, 0.925, 0.33333333333333
53110, 0.3125, 0.95, 0.33333333333333
53111, 0.33333333333333, 0.95, 0.3125
53112, 0.33333333333333, 0.975, 0.33333333333333
53113, 0.3125, 1, 0.33333333333333
53114, 0.33333333333333, 1, 0.3125
53115, 0.33333333333333, 1.025, 0.33333333333333
53116, 0.3125, 1.05, 0.33333333333333
53117, 0.33333333333333, 1.05, 0.3125
53118, 0.33333333333333, 1.075, 0.33333333333333
53119, 0.3125, 1.1, 0.33333333333333
53120, 0.33333333333333, 1.1, 0.3125
53121, 0.33333333333333, 1.125, 0.33333333333333
53122, 0.3125, 1.15, 0.33333333333333
53123, 0.33333333333333, 1.15, 0.3125
53124, 0.33333333333333, 1.175, 0.33333333333333
53125, 0.3125, 1.2, 0.33333333333333
53126, 0.33333333333333, 1.2, 0.3125
53127, 0.33333333333333, 1.225, 0.33333333333333
53128, 0.3125, 1.25, 0.33333333333333
53129, 0.33333333333333, 1.25, 0.3125
53130, 0.33333333333333, 1.275, 0.33333333333333
53131, 0.3125, 1.3, 0.33333333333333
53132, 0.33333333333333, 1.3, 0.3125
53133, 0.33333333333333, 1.325, 0.33333333333333
53134, 0.33333333333333, 0.175, 0.375
53135, 0.3125, 0.2, 0.375
53136, 0.33333333333333, 0.2, 0.35416666666667
53137, 0.33333333333333, 0.225, 0.375
53138, 0.3125, 0.25, 0.375
53139, 0.33333333333333, 0.25, 0.35416666666667
53140, 0.33333333333333, 0.275, 0.375
53141, 0.3125, 0.3, 0.375
53142, 0.33333333333333, 0.3, 0.35416666666667
53143, 0.33333333333333, 0.325, 0.375
53144, 0.3125, 0.35, 0.375
53145, 0.33333333333333, 0.35, 0.35416666666667
53146, 0.33333333333333, 0.375, 0.375
53147, 0.3125, 0.4, 0.375
53148, 0.33333333333333, 0.4, 0.35416666666667
53149, 0.33333333333333, 0.425, 0.375
53150, 0.3125, 0.45, 0.375
53151, 0.33333333333333, 0.45, 0.35416666666667
53152, 0.33333333333333, 0.475, 0.375
53153, 0.3125, 0.5, 0.375
53154, 0.33333333333333, 0.5, 0.35416666666667
53155, 0.33333333333333, 0.525, 0.375
53156, 0.3125, 0.55, 0.375
53157, 0.33333333333333, 0.55, 0.35416666666667
53158, 0.33333333333333, 0.575, 0.375
53159, 0.3125, 0.6, 0.375
53160, 0.33333333333333, 0.6, 0.35416666666667
53161, 0.33333333333333, 0.625, 0.375
53162, 0.3125, 0.65, 0.375
53163, 0.33333333333333, 0.65, 0.35416666666667
53164, 0.33333333333333, 0.675, 0.375
53165, 0.3125, 0.7, 0.375
53166, 0.33333333333333, 0.7, 0.35416666666667
53167, 0.33333333333333, 0.725, 0.375
53168, 0.3125, 0.75, 0.375
53169, 0.33333333333333, 0.75, 0.35416666666667
53170, 0.33333333333333, 0.775, 0.375
53171, 0.3125, 0.8, 0.375
53172, 0.33333333333333, 0.8, 0.35416666666667
53173, 0.33333333333333, 0.825, 0.375
53174, 0.3125, 0.85, 0.375
53175, 0.33333333333333, 0.85, 0.35416666666667
53176, 0.33333333333333, 0.875, 0.375
53177, 0.3125, 0.9, 0.375
53178, 0.33333333333333, 0.9, 0.35416666666667
53179, 0.33333333333333, 0.925, 0.375
53180, 0.3125, 0.95, 0.375
53181, 0.33333333333333, 0.95, 0.35416666666667
53182, 0.33333333333333, 0.975, 0.375
53183, 0.3125, 1, 0.375
53184, 0.33333333333333, 1, 0.35416666666667
53185, 0.33333333333333, 1.025, 0.375
53186, 0.3125, 1.05, 0.375
53187, 0.33333333333333, 1.05, 0.35416666666667
53188, 0.33333333333333, 1.075, 0.375
53189, 0.3125, 1.1, 0.375
53190, 0.33333333333333, 1.1, 0.35416666666667
53191, 0.33333333333333, 1.125, 0.375
53192, 0.3125, 1.15, 0.375
53193, 0.33333333333333, 1.15, 0.35416666666667
53194, 0.33333333333333, 1.175, 0.375
53195, 0.3125, 1.2, 0.375
53196, 0.33333333333333, 1.2, 0.35416666666667
53197, 0.33333333333333, 1.225, 0.375
53198, 0.3125, 1.25, 0.375
53199, 0.33333333333333, 1.25, 0.35416666666667
53200, 0.33333333333333, 1.275, 0.375
53201, 0.3125, 1.3, 0.375
53202, 0.33333333333333, 1.3, 0.35416666666667
53203, 0.33333333333333, 1.325, 0.375
53204, 0.33333333333333, 0.175, 0.41666666666667
53205, 0.3125, 0.2, 0.41666666666667
53206, 0.33333333333333, 0.2, 0.39583333333333
53207, 0.33333333333333, 0.225, 0.41666666666667
53208, 0.3125, 0.25, 0.41666666666667
53209, 0.33333333333333, 0.25, 0.39583333333333
53210, 0.33333333333333, 0.275, 0.41666666666667
53211, 0.3125, 0.3, 0.41666666666667
53212, 0.33333333333333, 0.3, 0.39583333333333
53213, 0.33333333333333, 0.325, 0.41666666666667
53214, 0.3125, 0.35, 0.41666666666667
53215, 0.33333333333333, 0.35, 0.39583333333333
53216, 0.33333333333333, 0.375, 0.41666666666667
53217, 0.3125, 0.4, 0.41666666666667
53218, 0.33333333333333, 0.4, 0.39583333333333
53219, 0.33333333333333, 0.425, 0.41666666666667
53220, 0.3125, 0.45, 0.41666666666667
53221, 0.33333333333333, 0.45, 0.39583333333333
53222, 0.33333333333333, 0.475, 0.41666666666667
53223, 0.3125, 0.5, 0.41666666666667
53224, 0.33333333333333, 0.5, 0.39583333333333
53225, 0.33333333333333, 0.525, 0.41666666666667
53226, 0.3125, 0.55, 0.41666666666667
53227, 0.33333333333333, 0.55, 0.39583333333333
53228, 0.33333333333333, 0.575, 0.41666666666667
53229, 0.3125, 0.6, 0.41666666666667
53230, 0.33333333333333, 0.6, 0.39583333333333
53231, 0.33333333333333, 0.625, 0.41666666666667
53232, 0.3125, 0.65, 0.41666666666667
53233, 0.33333333333333, 0.65, 0.39583333333333
53234, 0.33333333333333, 0.675, 0.41666666666667
53235, 0.3125, 0.7, 0.41666666666667
53236, 0.33333333333333, 0.7, 0.39583333333333
53237, 0.33333333333333, 0.725, 0.41666666666667
53238, 0.3125, 0.75, 0.41666666666667
53239, 0.33333333333333, 0.75, 0.39583333333333
53240, 0.33333333333333, 0.775, 0.41666666666667
53241, 0.3125, 0.8, 0.41666666666667
53242, 0.33333333333333, 0.8, 0.39583333333333
53243, 0.33333333333333, 0.825, 0.41666666666667
53244, 0.3125, 0.85, 0.41666666666667
53245, 0.33333333333333, 0.85, 0.39583333333333
53246, 0.33333333333333, 0.875, 0.41666666666667
53247, 0.3125, 0.9, 0.41666666666667
53248, 0.33333333333333, 0.9, 0.39583333333333
53249, 0.33333333333333, 0.925, 0.41666666666667
53250, 0.3125, 0.95, 0.41666666666667
53251, 0.33333333333333, 0.95, 0.39583333333333
53252, 0.33333333333333, 0.975, 0.41666666666667
53253, 0.3125, 1, 0.41666666666667
53254, 0.33333333333333, 1, 0.39583333333333
53255, 0.33333333333333, 1.025, 0.41666666666667
53256, 0.3125, 1.05, 0.41666666666667
53257, 0.33333333333333, 1.05, 0.39583333333333
53258, 0.33333333333333, 1.075, 0.41666666666667
53259, 0.3125, 1.1, 0.41666666666667
53260, 0.33333333333333, 1.1, 0.39583333333333
53261, 0.33333333333333, 1.125, 0.41666666666667
53262, 0.3125, 1.15, 0.41666666666667
53263, 0.33333333333333, 1.15, 0.39583333333333
53264, 0.33333333333333, 1.175, 0.41666666666667
53265, 0.3125, 1.2, 0.41666666666667
53266, 0.33333333333333, 1.2, 0.39583333333333
53267, 0.33333333333333, 1.225, 0.41666666666667
53268, 0.3125, 1.25, 0.41666666666667
53269, 0.33333333333333, 1.25, 0.39583333333333
53270, 0.33333333333333, 1.275, 0.41666666666667
53271, 0.3125, 1.3, 0.41666666666667
53272, 0.33333333333333, 1.3, 0.39583333333333
53273, 0.33333333333333, 1.325, 0.41666666666667
53274, 0.33333333333333, 0.175, 0.45833333333333
53275, 0.3125, 0.2, 0.45833333333333
53276, 0.33333333333333, 0.2, 0.4375
53277, 0.33333333333333, 0.225, 0.45833333333333
53278, 0.3125, 0.25, 0.45833333333333
53279, 0.33333333333333, 0.25, 0.4375
53280, 0.33333333333333, 0.275, 0.45833333333333
53281, 0.3125, 0.3, 0.45833333333333
53282, 0.33333333333333, 0.3, 0.4375
53283, 0.33333333333333, 0.325, 0.45833333333333
53284, 0.3125, 0.35, 0.45833333333333
53285, 0.33333333333333, 0.35, 0.4375
53286, 0.33333333333333, 0.375, 0.45833333333333
53287, 0.3125, 0.4, 0.45833333333333
53288, 0.33333333333333, 0.4, 0.4375
53289, 0.33333333333333, 0.425, 0.45833333333333
53290, 0.3125, 0.45, 0.45833333333333
53291, 0.33333333333333, 0.45, 0.4375
53292, 0.33333333333333, 0.475, 0.45833333333333
53293, 0.3125, 0.5, 0.45833333333333
53294, 0.33333333333333, 0.5, 0.4375
53295, 0.33333333333333, 0.525, 0.45833333333333
53296, 0.3125, 0.55, 0.45833333333333
53297, 0.33333333333333, 0.55, 0.4375
53298, 0.33333333333333, 0.575, 0.45833333333333
53299, 0.3125, 0.6, 0.45833333333333
53300, 0.33333333333333, 0.6, 0.4375
53301, 0.33333333333333, 0.625, 0.45833333333333
53302, 0.3125, 0.65, 0.45833333333333
53303, 0.33333333333333, 0.65, 0.4375
53304, 0.33333333333333, 0.675, 0.45833333333333
53305, 0.3125, 0.7, 0.45833333333333
53306, 0.33333333333333, 0.7, 0.4375
53307, 0.33333333333333, 0.725, 0.45833333333333
53308, 0.3125, 0.75, 0.45833333333333
53309, 0.33333333333333, 0.75, 0.4375
53310, 0.33333333333333, 0.775, 0.45833333333333
53311, 0.3125, 0.8, 0.45833333333333
53312, 0.33333333333333, 0.8, 0.4375
53313, 0.33333333333333, 0.825, 0.45833333333333
53314, 0.3125, 0.85, 0.45833333333333
53315, 0.33333333333333, 0.85, 0.4375
53316, 0.33333333333333, 0.875, 0.45833333333333
53317, 0.3125, 0.9, 0.45833333333333
53318, 0.33333333333333, 0.9, 0.4375
53319, 0.33333333333333, 0.925, 0.45833333333333
53320, 0.3125, 0.95, 0.45833333333333
53321, 0.33333333333333, 0.95, 0.4375
53322, 0.33333333333333, 0.975, 0.45833333333333
53323, 0.3125, 1, 0.45833333333333
53324, 0.33333333333333, 1, 0.4375
53325, 0.33333333333333, 1.025, 0.45833333333333
53326, 0.3125, 1.05, 0.45833333333333
53327, 0.33333333333333, 1.05, 0.4375
53328, 0.33333333333333, 1.075, 0.45833333333333
53329, 0.3125, 1.1, 0.45833333333333
53330, 0.33333333333333, 1.1, 0.4375
53331, 0.33333333333333, 1.125, 0.45833333333333
53332, 0.3125, 1.15, 0.45833333333333
53333, 0.33333333333333, 1.15, 0.4375
53334, 0.33333333333333, 1.175, 0.45833333333333
53335, 0.3125, 1.2, 0.45833333333333
53336, 0.33333333333333, 1.2, 0.4375
53337, 0.33333333333333, 1.225, 0.45833333333333
53338, 0.3125, 1.25, 0.45833333333333
53339, 0.33333333333333, 1.25, 0.4375
53340, 0.33333333333333, 1.275, 0.45833333333333
53341, 0.3125, 1.3, 0.45833333333333
53342, 0.33333333333333, 1.3, 0.4375
53343, 0.33333333333333, 1.325, 0.45833333333333
53344, 0.33333333333333, 0.2, 0.47916666666667
53345, 0.33333333333333, 0.25, 0.47916666666667
53346, 0.33333333333333, 0.3, 0.47916666666667
53347, 0.33333333333333, 0.35, 0.47916666666667
53348, 0.33333333333333, 0.4, 0.47916666666667
53349, 0.33333333333333, 0.45, 0.47916666666667
53350, 0.33333333333333, 0.5, 0.47916666666667
53351, 0.33333333333333, 0.55, 0.47916666666667
53352, 0.33333333333333, 0.6, 0.47916666666667
53353, 0.33333333333333, 0.65, 0.47916666666667
53354, 0.33333333333333, 0.7, 0.47916666666667
53355, 0.33333333333333, 0.75, 0.47916666666667
53356, 0.33333333333333, 0.8, 0.47916666666667
53357, 0.33333333333333, 0.85, 0.47916666666667
53358, 0.33333333333333, 0.9, 0.47916666666667
53359, 0.33333333333333, 0.95, 0.47916666666667
53360, 0.33333333333333, 1, 0.47916666666667
53361, 0.33333333333333, 1.05, 0.47916666666667
53362, 0.33333333333333, 1.1, 0.47916666666667
53363, 0.33333333333333, 1.15, 0.47916666666667
53364, 0.33333333333333, 1.2, 0.47916666666667
53365, 0.33333333333333, 1.25, 0.47916666666667
53366, 0.33333333333333, 1.3, 0.47916666666667
53367, 0.375, 0.175, 0.041666666666667
53368, 0.35416666666667, 0.2, 0.041666666666667
53369, 0.375, 0.2, 0.020833333333333
53370, 0.375, 0.225, 0.041666666666667
53371, 0.35416666666667, 0.25, 0.041666666666667
53372, 0.375, 0.25, 0.020833333333333
53373, 0.375, 0.275, 0.041666666666667
53374, 0.35416666666667, 0.3, 0.041666666666667
53375, 0.375, 0.3, 0.020833333333333
53376, 0.375, 0.325, 0.041666666666667
53377, 0.35416666666667, 0.35, 0.041666666666667
53378, 0.375, 0.35, 0.020833333333333
53379, 0.375, 0.375, 0.041666666666667
53380, 0.35416666666667, 0.4, 0.041666666666667
53381, 0.375, 0.4, 0.020833333333333
53382, 0.375, 0.425, 0.041666666666667
53383, 0.35416666666667, 0.45, 0.041666666666667
53384, 0.375, 0.45, 0.020833333333333
53385, 0.375, 0.475, 0.041666666666667
53386, 0.35416666666667, 0.5, 0.041666666666667
53387, 0.375, 0.5, 0.020833333333333
53388, 0.375, 0.525, 0.041666666666667
53389, 0.35416666666667, 0.55, 0.041666666666667
53390, 0.375, 0.55, 0.020833333333333
53391, 0.375, 0.575, 0.041666666666667
53392, 0.35416666666667, 0.6, 0.041666666666667
53393, 0.375, 0.6, 0.020833333333333
53394, 0.375, 0.625, 0.041666666666667
53395, 0.35416666666667, 0.65, 0.041666666666667
53396, 0.375, 0.65, 0.020833333333333
53397, 0.375, 0.675, 0.041666666666667
53398, 0.35416666666667, 0.7, 0.041666666666667
53399, 0.375, 0.7, 0.020833333333333
53400, 0.375, 0.725, 0.041666666666667
53401, 0.35416666666667, 0.75, 0.041666666666667
53402, 0.375, 0.75, 0.020833333333333
53403, 0.375, 0.775, 0.041666666666667
53404, 0.35416666666667, 0.8, 0.041666666666667
53405, 0.375, 0.8, 0.020833333333333
53406, 0.375, 0.825, 0.041666666666667
53407, 0.35416666666667, 0.85, 0.041666666666667
53408, 0.375, 0.85, 0.020833333333333
53409, 0.375, 0.875, 0.041666666666667
53410, 0.35416666666667, 0.9, 0.041666666666667
53411, 0.375, 0.9, 0.020833333333333
53412, 0.375, 0.925, 0.041666666666667
53413, 0.35416666666667, 0.95, 0.041666666666667
53414, 0.375, 0.95, 0.020833333333333
53415, 0.375, 0.975, 0.041666666666667
53416, 0.35416666666667, 1, 0.041666666666667
53417, 0.375, 1, 0.020833333333333
53418, 0.375, 1.025, 0.041666666666667
53419, 0.35416666666667, 1.05, 0.041666666666667
53420, 0.375, 1.05, 0.020833333333333
53421, 0.375, 1.075, 0.041666666666667
53422, 0.35416666666667, 1.1, 0.041666666666667
53423, 0.375, 1.1, 0.020833333333333
53424, 0.375, 1.125, 0.041666666666667
53425, 0.35416666666667, 1.15, 0.041666666666667
53426, 0.375, 1.15, 0.020833333333333
53427, 0.375, 1.175, 0.041666666666667
53428, 0.35416666666667, 1.2, 0.041666666666667
53429, 0.375, 1.2, 0.020833333333333
53430, 0.375, 1.225, 0.041666666666667
53431, 0.35416666666667, 1.25, 0.041666666666667
53432, 0.375, 1.25, 0.020833333333333
53433, 0.375, 1.275, 0.041666666666667
53434, 0.35416666666667, 1.3, 0.041666666666667
53435, 0.375, 1.3, 0.020833333333333
53436, 0.375, 1.325, 0.041666666666667
53437, 0.375, 0.175, 0.083333333333333
53438, 0.35416666666667, 0.2, 0.083333333333333
53439, 0.375, 0.2, 0.0625
53440, 0.375, 0.225, 0.083333333333333
53441, 0.35416666666667, 0.25, 0.083333333333333
53442, 0.375, 0.25, 0.0625
53443, 0.375, 0.275, 0.083333333333333
53444, 0.35416666666667, 0.3, 0.083333333333333
53445, 0.375, 0.3, 0.0625
53446, 0.375, 0.325, 0.083333333333333
53447, 0.35416666666667, 0.35, 0.083333333333333
53448, 0.375, 0.35, 0.0625
53449, 0.375, 0.375, 0.083333333333333
53450, 0.35416666666667, 0.4, 0.083333333333333
53451, 0.375, 0.4, 0.0625
53452, 0.375, 0.425, 0.083333333333333
53453, 0.35416666666667, 0.45, 0.083333333333333
53454, 0.375, 0.45, 0.0625
53455, 0.375, 0.475, 0.083333333333333
53456, 0.35416666666667, 0.5, 0.083333333333333
53457, 0.375, 0.5, 0.0625
53458, 0.375, 0.525, 0.083333333333333
53459, 0.35416666666667, 0.55, 0.083333333333333
53460, 0.375, 0.55, 0.0625
53461, 0.375, 0.575, 0.083333333333333
53462, 0.35416666666667, 0.6, 0.083333333333333
53463, 0.375, 0.6, 0.0625
53464, 0.375, 0.625, 0.083333333333333
53465, 0.35416666666667, 0.65, 0.083333333333333
53466, 0.375, 0.65, 0.0625
53467, 0.375, 0.675, 0.083333333333333
53468, 0.35416666666667, 0.7, 0.083333333333333
53469, 0.375, 0.7, 0.0625
53470, 0.375, 0.725, 0.083333333333333
53471, 0.35416666666667, 0.75, 0.083333333333333
53472, 0.375, 0.75, 0.0625
53473, 0.375, 0.775, 0.083333333333333
53474, 0.35416666666667, 0.8, 0.083333333333333
53475, 0.375, 0.8, 0.0625
53476, 0.375, 0.825, 0.083333333333333
53477, 0.35416666666667, 0.85, 0.083333333333333
53478, 0.375, 0.85, 0.0625
53479, 0.375, 0.875, 0.083333333333333
53480, 0.35416666666667, 0.9, 0.083333333333333
53481, 0.375, 0.9, 0.0625
53482, 0.375, 0.925, 0.083333333333333
53483, 0.35416666666667, 0.95, 0.083333333333333
53484, 0.375, 0.95, 0.0625
53485, 0.375, 0.975, 0.083333333333333
53486, 0.35416666666667, 1, 0.083333333333333
53487, 0.375, 1, 0.0625
53488, 0.375, 1.025, 0.083333333333333
53489, 0.35416666666667, 1.05, 0.083333333333333
53490, 0.375, 1.05, 0.0625
53491, 0.375, 1.075, 0.083333333333333
53492, 0.35416666666667, 1.1, 0.083333333333333
53493, 0.375, 1.1, 0.0625
53494, 0.375, 1.125, 0.083333333333333
53495, 0.35416666666667, 1.15, 0.083333333333333
53496, 0.375, 1.15, 0.0625
53497, 0.375, 1.175, 0.083333333333333
53498, 0.35416666666667, 1.2, 0.083333333333333
53499, 0.375, 1.2, 0.0625
53500, 0.375, 1.225, 0.083333333333333
53501, 0.35416666666667, 1.25, 0.083333333333333
53502, 0.375, 1.25, 0.0625
53503, 0.375, 1.275, 0.083333333333333
53504, 0.35416666666667, 1.3, 0.083333333333333
53505, 0.375, 1.3, 0.0625
53506, 0.375, 1.325, 0.083333333333333
53507, 0.375, 0.175, 0.125
53508, 0.35416666666667, 0.2, 0.125
53509, 0.375, 0.2, 0.10416666666667
53510, 0.375, 0.225, 0.125
53511, 0.35416666666667, 0.25, 0.125
53512, 0.375, 0.25, 0.10416666666667
53513, 0.375, 0.275, 0.125
53514, 0.35416666666667, 0.3, 0.125
53515, 0.375, 0.3, 0.10416666666667
53516, 0.375, 0.325, 0.125
53517, 0.35416666666667, 0.35, 0.125
53518, 0.375, 0.35, 0.10416666666667
53519, 0.375, 0.375, 0.125
53520, 0.35416666666667, 0.4, 0.125
53521, 0.375, 0.4, 0.10416666666667
53522, 0.375, 0.425, 0.125
53523, 0.35416666666667, 0.45, 0.125
53524, 0.375, 0.45, 0.10416666666667
53525, 0.375, 0.475, 0.125
53526, 0.35416666666667, 0.5, 0.125
53527, 0.375, 0.5, 0.10416666666667
53528, 0.375, 0.525, 0.125
53529, 0.35416666666667, 0.55, 0.125
53530, 0.375, 0.55, 0.10416666666667
53531, 0.375, 0.575, 0.125
53532, 0.35416666666667, 0.6, 0.125
53533, 0.375, 0.6, 0.10416666666667
53534, 0.375, 0.625, 0.125
53535, 0.35416666666667, 0.65, 0.125
53536, 0.375, 0.65, 0.10416666666667
53537, 0.375, 0.675, 0.125
53538, 0.35416666666667, 0.7, 0.125
53539, 0.375, 0.7, 0.10416666666667
53540, 0.375, 0.725, 0.125
53541, 0.35416666666667, 0.75, 0.125
53542, 0.375, 0.75, 0.10416666666667
53543, 0.375, 0.775, 0.125
53544, 0.35416666666667, 0.8, 0.125
53545, 0.375, 0.8, 0.10416666666667
53546, 0.375, 0.825, 0.125
53547, 0.35416666666667, 0.85, 0.125
53548, 0.375, 0.85, 0.10416666666667
53549, 0.375, 0.875, 0.125
53550, 0.35416666666667, 0.9, 0.125
53551, 0.375, 0.9, 0.10416666666667
53552, 0.375, 0.925, 0.125
53553, 0.35416666666667, 0.95, 0.125
53554, 0.375, 0.95, 0.10416666666667
53555, 0.375, 0.975, 0.125
53556, 0.35416666666667, 1, 0.125
53557, 0.375, 1, 0.10416666666667
53558, 0.375, 1.025, 0.125
53559, 0.35416666666667, 1.05, 0.125
53560, 0.375, 1.05, 0.10416666666667
53561, 0.375, 1.075, 0.125
53562, 0.35416666666667, 1.1, 0.125
53563, 0.375, 1.1, 0.10416666666667
53564, 0.375, 1.125, 0.125
53565, 0.35416666666667, 1.15, 0.125
53566, 0.375, 1.15, 0.10416666666667
53567, 0.375, 1.175, 0.125
53568, 0.35416666666667, 1.2, 0.125
53569, 0.375, 1.2, 0.10416666666667
53570, 0.375, 1.225, 0.125
53571, 0.35416666666667, 1.25, 0.125
53572, 0.375, 1.25, 0.10416666666667
53573, 0.375, 1.275, 0.125
53574, 0.35416666666667, 1.3, 0.125
53575, 0.375, 1.3, 0.10416666666667
53576, 0.375, 1.325, 0.125
53577, 0.375, 0.175, 0.16666666666667
53578, 0.35416666666667, 0.2, 0.16666666666667
53579, 0.375, 0.2, 0.14583333333333
53580, 0.375, 0.225, 0.16666666666667
53581, 0.35416666666667, 0.25, 0.16666666666667
53582, 0.375, 0.25, 0.14583333333333
53583, 0.375, 0.275, 0.16666666666667
53584, 0.35416666666667, 0.3, 0.16666666666667
53585, 0.375, 0.3, 0.14583333333333
53586, 0.375, 0.325, 0.16666666666667
53587, 0.35416666666667, 0.35, 0.16666666666667
53588, 0.375, 0.35, 0.14583333333333
53589, 0.375, 0.375, 0.16666666666667
53590, 0.35416666666667, 0.4, 0.16666666666667
53591, 0.375, 0.4, 0.14583333333333
53592, 0.375, 0.425, 0.16666666666667
53593, 0.35416666666667, 0.45, 0.16666666666667
53594, 0.375, 0.45, 0.14583333333333
53595, 0.375, 0.475, 0.16666666666667
53596, 0.35416666666667, 0.5, 0.16666666666667
53597, 0.375, 0.5, 0.14583333333333
53598, 0.375, 0.525, 0.16666666666667
53599, 0.35416666666667, 0.55, 0.16666666666667
53600, 0.375, 0.55, 0.14583333333333
53601, 0.375, 0.575, 0.16666666666667
53602, 0.35416666666667, 0.6, 0.16666666666667
53603, 0.375, 0.6, 0.14583333333333
53604, 0.375, 0.625, 0.16666666666667
53605, 0.35416666666667, 0.65, 0.16666666666667
53606, 0.375, 0.65, 0.14583333333333
53607, 0.375, 0.675, 0.16666666666667
53608, 0.35416666666667, 0.7, 0.16666666666667
53609, 0.375, 0.7, 0.14583333333333
53610, 0.375, 0.725, 0.16666666666667
53611, 0.35416666666667, 0.75, 0.16666666666667
53612, 0.375, 0.75, 0.14583333333333
53613, 0.375, 0.775, 0.16666666666667
53614, 0.35416666666667, 0.8, 0.16666666666667
53615, 0.375, 0.8, 0.14583333333333
53616, 0.375, 0.825, 0.16666666666667
53617, 0.35416666666667, 0.85, 0.16666666666667
53618, 0.375, 0.85, 0.14583333333333
53619, 0.375, 0.875, 0.16666666666667
53620, 0.35416666666667, 0.9, 0.16666666666667
53621, 0.375, 0.9, 0.14583333333333
53622, 0.375, 0.925, 0.16666666666667
53623, 0.35416666666667, 0.95, 0.16666666666667
53624, 0.375, 0.95, 0.14583333333333
53625, 0.375, 0.975, 0.16666666666667
53626, 0.35416666666667, 1, 0.16666666666667
53627, 0.375, 1, 0.14583333333333
53628, 0.375, 1.025, 0.16666666666667
53629, 0.35416666666667, 1.05, 0.16666666666667
53630, 0.375, 1.05, 0.14583333333333
53631, 0.375, 1.075, 0.16666666666667
53632, 0.35416666666667, 1.1, 0.16666666666667
53633, 0.375, 1.1, 0.14583333333333
53634, 0.375, 1.125, 0.16666666666667
53635, 0.35416666666667, 1.15, 0.16666666666667
53636, 0.375, 1.15, 0.14583333333333
53637, 0.375, 1.175, 0.16666666666667
53638, 0.35416666666667, 1.2, 0.16666666666667
53639, 0.375, 1.2, 0.14583333333333
53640, 0.375, 1.225, 0.16666666666667
53641, 0.35416666666667, 1.25, 0.16666666666667
53642, 0.375, 1.25, 0.14583333333333
53643, 0.375, 1.275, 0.16666666666667
53644, 0.35416666666667, 1.3, 0.16666666666667
53645, 0.375, 1.3, 0.14583333333333
53646, 0.375, 1.325, 0.16666666666667
53647, 0.375, 0.175, 0.20833333333333
53648, 0.35416666666667, 0.2, 0.20833333333333
53649, 0.375, 0.2, 0.1875
53650, 0.375, 0.225, 0.20833333333333
53651, 0.35416666666667, 0.25, 0.20833333333333
53652, 0.375, 0.25, 0.1875
53653, 0.375, 0.275, 0.20833333333333
53654, 0.35416666666667, 0.3, 0.20833333333333
53655, 0.375, 0.3, 0.1875
53656, 0.375, 0.325, 0.20833333333333
53657, 0.35416666666667, 0.35, 0.20833333333333
53658, 0.375, 0.35, 0.1875
53659, 0.375, 0.375, 0.20833333333333
53660, 0.35416666666667, 0.4, 0.20833333333333
53661, 0.375, 0.4, 0.1875
53662, 0.375, 0.425, 0.20833333333333
53663, 0.35416666666667, 0.45, 0.20833333333333
53664, 0.375, 0.45, 0.1875
53665, 0.375, 0.475, 0.20833333333333
53666, 0.35416666666667, 0.5, 0.20833333333333
53667, 0.375, 0.5, 0.1875
53668, 0.375, 0.525, 0.20833333333333
53669, 0.35416666666667, 0.55, 0.20833333333333
53670, 0.375, 0.55, 0.1875
53671, 0.375, 0.575, 0.20833333333333
53672, 0.35416666666667, 0.6, 0.20833333333333
53673, 0.375, 0.6, 0.1875
53674, 0.375, 0.625, 0.20833333333333
53675, 0.35416666666667, 0.65, 0.20833333333333
53676, 0.375, 0.65, 0.1875
53677, 0.375, 0.675, 0.20833333333333
53678, 0.35416666666667, 0.7, 0.20833333333333
53679, 0.375, 0.7, 0.1875
53680, 0.375, 0.725, 0.20833333333333
53681, 0.35416666666667, 0.75, 0.20833333333333
53682, 0.375, 0.75, 0.1875
53683, 0.375, 0.775, 0.20833333333333
53684, 0.35416666666667, 0.8, 0.20833333333333
53685, 0.375, 0.8, 0.1875
53686, 0.375, 0.825, 0.20833333333333
53687, 0.35416666666667, 0.85, 0.20833333333333
53688, 0.375, 0.85, 0.1875
53689, 0.375, 0.875, 0.20833333333333
53690, 0.35416666666667, 0.9, 0.20833333333333
53691, 0.375, 0.9, 0.1875
53692, 0.375, 0.925, 0.20833333333333
53693, 0.35416666666667, 0.95, 0.20833333333333
53694, 0.375, 0.95, 0.1875
53695, 0.375, 0.975, 0.20833333333333
53696, 0.35416666666667, 1, 0.20833333333333
53697, 0.375, 1, 0.1875
53698, 0.375, 1.025, 0.20833333333333
53699, 0.35416666666667, 1.05, 0.20833333333333
53700, 0.375, 1.05, 0.1875
53701, 0.375, 1.075, 0.20833333333333
53702, 0.35416666666667, 1.1, 0.20833333333333
53703, 0.375, 1.1, 0.1875
53704, 0.375, 1.125, 0.20833333333333
53705, 0.35416666666667, 1.15, 0.20833333333333
53706, 0.375, 1.15, 0.1875
53707, 0.375, 1.175, 0.20833333333333
53708, 0.35416666666667, 1.2, 0.20833333333333
53709, 0.375, 1.2, 0.1875
53710, 0.375, 1.225, 0.20833333333333
53711, 0.35416666666667, 1.25, 0.20833333333333
53712, 0.375, 1.25, 0.1875
53713, 0.375, 1.275, 0.20833333333333
53714, 0.35416666666667, 1.3, 0.20833333333333
53715, 0.375, 1.3, 0.1875
53716, 0.375, 1.325, 0.20833333333333
53717, 0.375, 0.175, 0.25
53718, 0.35416666666667, 0.2, 0.25
53719, 0.375, 0.2, 0.22916666666667
53720, 0.375, 0.225, 0.25
53721, 0.35416666666667, 0.25, 0.25
53722, 0.375, 0.25, 0.22916666666667
53723, 0.375, 0.275, 0.25
53724, 0.35416666666667, 0.3, 0.25
53725, 0.375, 0.3, 0.22916666666667
53726, 0.375, 0.325, 0.25
53727, 0.35416666666667, 0.35, 0.25
53728, 0.375, 0.35, 0.22916666666667
53729, 0.375, 0.375, 0.25
53730, 0.35416666666667, 0.4, 0.25
53731, 0.375, 0.4, 0.22916666666667
53732, 0.375, 0.425, 0.25
53733, 0.35416666666667, 0.45, 0.25
53734, 0.375, 0.45, 0.22916666666667
53735, 0.375, 0.475, 0.25
53736, 0.35416666666667, 0.5, 0.25
53737, 0.375, 0.5, 0.22916666666667
53738, 0.375, 0.525, 0.25
53739, 0.35416666666667, 0.55, 0.25
53740, 0.375, 0.55, 0.22916666666667
53741, 0.375, 0.575, 0.25
53742, 0.35416666666667, 0.6, 0.25
53743, 0.375, 0.6, 0.22916666666667
53744, 0.375, 0.625, 0.25
53745, 0.35416666666667, 0.65, 0.25
53746, 0.375, 0.65, 0.22916666666667
53747, 0.375, 0.675, 0.25
53748, 0.35416666666667, 0.7, 0.25
53749, 0.375, 0.7, 0.22916666666667
53750, 0.375, 0.725, 0.25
53751, 0.35416666666667, 0.75, 0.25
53752, 0.375, 0.75, 0.22916666666667
53753, 0.375, 0.775, 0.25
53754, 0.35416666666667, 0.8, 0.25
53755, 0.375, 0.8, 0.22916666666667
53756, 0.375, 0.825, 0.25
53757, 0.35416666666667, 0.85, 0.25
53758, 0.375, 0.85, 0.22916666666667
53759, 0.375, 0.875, 0.25
53760, 0.35416666666667, 0.9, 0.25
53761, 0.375, 0.9, 0.22916666666667
53762, 0.375, 0.925, 0.25
53763, 0.35416666666667, 0.95, 0.25
53764, 0.375, 0.95, 0.22916666666667
53765, 0.375, 0.975, 0.25
53766, 0.35416666666667, 1, 0.25
53767, 0.375, 1, 0.22916666666667
53768, 0.375, 1.025, 0.25
53769, 0.35416666666667, 1.05, 0.25
53770, 0.375, 1.05, 0.22916666666667
53771, 0.375, 1.075, 0.25
53772, 0.35416666666667, 1.1, 0.25
53773, 0.375, 1.1, 0.22916666666667
53774, 0.375, 1.125, 0.25
53775, 0.35416666666667, 1.15, 0.25
53776, 0.375, 1.15, 0.22916666666667
53777, 0.375, 1.175, 0.25
53778, 0.35416666666667, 1.2, 0.25
53779, 0.375, 1.2, 0.22916666666667
53780, 0.375, 1.225, 0.25
53781, 0.35416666666667, 1.25, 0.25
53782, 0.375, 1.25, 0.22916666666667
53783, 0.375, 1.275, 0.25
53784, 0.35416666666667, 1.3, 0.25
53785, 0.375, 1.3, 0.22916666666667
53786, 0.375, 1.325, 0.25
53787, 0.375, 0.175, 0.29166666666667
53788, 0.35416666666667, 0.2, 0.29166666666667
53789, 0.375, 0.2, 0.27083333333333
53790, 0.375, 0.225, 0.29166666666667
53791, 0.35416666666667, 0.25, 0.29166666666667
53792, 0.375, 0.25, 0.27083333333333
53793, 0.375, 0.275, 0.29166666666667
53794, 0.35416666666667, 0.3, 0.29166666666667
53795, 0.375, 0.3, 0.27083333333333
53796, 0.375, 0.325, 0.29166666666667
53797, 0.35416666666667, 0.35, 0.29166666666667
53798, 0.375, 0.35, 0.27083333333333
53799, 0.375, 0.375, 0.29166666666667
53800, 0.35416666666667, 0.4, 0.29166666666667
53801, 0.375, 0.4, 0.27083333333333
53802, 0.375, 0.425, 0.29166666666667
53803, 0.35416666666667, 0.45, 0.29166666666667
53804, 0.375, 0.45, 0.27083333333333
53805, 0.375, 0.475, 0.29166666666667
53806, 0.35416666666667, 0.5, 0.29166666666667
53807, 0.375, 0.5, 0.27083333333333
53808, 0.375, 0.525, 0.29166666666667
53809, 0.35416666666667, 0.55, 0.29166666666667
53810, 0.375, 0.55, 0.27083333333333
53811, 0.375, 0.575, 0.29166666666667
53812, 0.35416666666667, 0.6, 0.29166666666667
53813, 0.375, 0.6, 0.27083333333333
53814, 0.375, 0.625, 0.29166666666667
53815, 0.35416666666667, 0.65, 0.29166666666667
53816, 0.375, 0.65, 0.27083333333333
53817, 0.375, 0.675, 0.29166666666667
53818, 0.35416666666667, 0.7, 0.29166666666667
53819, 0.375, 0.7, 0.27083333333333
53820, 0.375, 0.725, 0.29166666666667
53821, 0.35416666666667, 0.75, 0.29166666666667
53822, 0.375, 0.75, 0.27083333333333
53823, 0.375, 0.775, 0.29166666666667
53824, 0.35416666666667, 0.8, 0.29166666666667
53825, 0.375, 0.8, 0.27083333333333
53826, 0.375, 0.825, 0.29166666666667
53827, 0.35416666666667, 0.85, 0.29166666666667
53828, 0.375, 0.85, 0.27083333333333
53829, 0.375, 0.875, 0.29166666666667
53830, 0.35416666666667, 0.9, 0.29166666666667
53831, 0.375, 0.9, 0.27083333333333
53832, 0.375, 0.925, 0.29166666666667
53833, 0.35416666666667, 0.95, 0.29166666666667
53834, 0.375, 0.95, 0.27083333333333
53835, 0.375, 0.975, 0.29166666666667
53836, 0.35416666666667, 1, 0.29166666666667
53837, 0.375, 1, 0.27083333333333
53838, 0.375, 1.025, 0.29166666666667
53839, 0.35416666666667, 1.05, 0.29166666666667
53840, 0.375, 1.05, 0.27083333333333
53841, 0.375, 1.075, 0.29166666666667
53842, 0.35416666666667, 1.1, 0.29166666666667
53843, 0.375, 1.1, 0.27083333333333
53844, 0.375, 1.125, 0.29166666666667
53845, 0.35416666666667, 1.15, 0.29166666666667
53846, 0.375, 1.15, 0.27083333333333
53847, 0.375, 1.175, 0.29166666666667
53848, 0.35416666666667, 1.2, 0.29166666666667
53849, 0.375, 1.2, 0.27083333333333
53850, 0.375, 1.225, 0.29166666666667
53851, 0.35416666666667, 1.25, 0.29166666666667
53852, 0.375, 1.25, 0.27083333333333
53853, 0.375, 1.275, 0.29166666666667
53854, 0.35416666666667, 1.3, 0.29166666666667
53855, 0.375, 1.3, 0.27083333333333
53856, 0.375, 1.325, 0.29166666666667
53857, 0.375, 0.175, 0.33333333333333
53858, 0.35416666666667, 0.2, 0.33333333333333
53859, 0.375, 0.2, 0.3125
53860, 0.375, 0.225, 0.33333333333333
53861, 0.35416666666667, 0.25, 0.33333333333333
53862, 0.375, 0.25, 0.3125
53863, 0.375, 0.275, 0.33333333333333
53864, 0.35416666666667, 0.3, 0.33333333333333
53865, 0.375, 0.3, 0.3125
53866, 0.375, 0.325, 0.33333333333333
53867, 0.35416666666667, 0.35, 0.33333333333333
53868, 0.375, 0.35, 0.3125
53869, 0.375, 0.375, 0.33333333333333
53870, 0.35416666666667, 0.4, 0.33333333333333
53871, 0.375, 0.4, 0.3125
53872, 0.375, 0.425, 0.33333333333333
53873, 0.35416666666667, 0.45, 0.33333333333333
53874, 0.375, 0.45, 0.3125
53875, 0.375, 0.475, 0.33333333333333
53876, 0.35416666666667, 0.5, 0.33333333333333
53877, 0.375, 0.5, 0.3125
53878, 0.375, 0.525, 0.33333333333333
53879, 0.35416666666667, 0.55, 0.33333333333333
53880, 0.375, 0.55, 0.3125
53881, 0.375, 0.575, 0.33333333333333
53882, 0.35416666666667, 0.6, 0.33333333333333
53883, 0.375, 0.6, 0.3125
53884, 0.375, 0.625, 0.33333333333333
53885, 0.35416666666667, 0.65, 0.33333333333333
53886, 0.375, 0.65, 0.3125
53887, 0.375, 0.675, 0.33333333333333
53888, 0.35416666666667, 0.7, 0.33333333333333
53889, 0.375, 0.7, 0.3125
53890, 0.375, 0.725, 0.33333333333333
53891, 0.35416666666667, 0.75, 0.33333333333333
53892, 0.375, 0.75, 0.3125
53893, 0.375, 0.775, 0.33333333333333
53894, 0.35416666666667, 0.8, 0.33333333333333
53895, 0.375, 0.8, 0.3125
53896, 0.375, 0.825, 0.33333333333333
53897, 0.35416666666667, 0.85, 0.33333333333333
53898, 0.375, 0.85, 0.3125
53899, 0.375, 0.875, 0.33333333333333
53900, 0.35416666666667, 0.9, 0.33333333333333
53901, 0.375, 0.9, 0.3125
53902, 0.375, 0.925, 0.33333333333333
53903, 0.35416666666667, 0.95, 0.33333333333333
53904, 0.375, 0.95, 0.3125
53905, 0.375, 0.975, 0.33333333333333
53906, 0.35416666666667, 1, 0.33333333333333
53907, 0.375, 1, 0.3125
53908, 0.375, 1.025, 0.33333333333333
53909, 0.35416666666667, 1.05, 0.33333333333333
53910, 0.375, 1.05, 0.3125
53911, 0.375, 1.075, 0.33333333333333
53912, 0.35416666666667, 1.1, 0.33333333333333
53913, 0.375, 1.1, 0.3125
53914, 0.375, 1.125, 0.33333333333333
53915, 0.35416666666667, 1.15, 0.33333333333333
53916, 0.375, 1.15, 0.3125
53917, 0.375, 1.175, 0.33333333333333
53918, 0.35416666666667, 1.2, 0.33333333333333
53919, 0.375, 1.2, 0.3125
53920, 0.375, 1.225, 0.33333333333333
53921, 0.35416666666667, 1.25, 0.33333333333333
53922, 0.375, 1.25, 0.3125
53923, 0.375, 1.275, 0.33333333333333
53924, 0.35416666666667, 1.3, 0.33333333333333
53925, 0.375, 1.3, 0.3125
53926, 0.375, 1.325, 0.33333333333333
53927, 0.375, 0.175, 0.375
53928, 0.35416666666667, 0.2, 0.375
53929, 0.375, 0.2, 0.35416666666667
53930, 0.375, 0.225, 0.375
53931, 0.35416666666667, 0.25, 0.375
53932, 0.375, 0.25, 0.35416666666667
53933, 0.375, 0.275, 0.375
53934, 0.35416666666667, 0.3, 0.375
53935, 0.375, 0.3, 0.35416666666667
53936, 0.375, 0.325, 0.375
53937, 0.35416666666667, 0.35, 0.375
53938, 0.375, 0.35, 0.35416666666667
53939, 0.375, 0.375, 0.375
53940, 0.35416666666667, 0.4, 0.375
53941, 0.375, 0.4, 0.35416666666667
53942, 0.375, 0.425, 0.375
53943, 0.35416666666667, 0.45, 0.375
53944, 0.375, 0.45, 0.35416666666667
53945, 0.375, 0.475, 0.375
53946, 0.35416666666667, 0.5, 0.375
53947, 0.375, 0.5, 0.35416666666667
53948, 0.375, 0.525, 0.375
53949, 0.35416666666667, 0.55, 0.375
53950, 0.375, 0.55, 0.35416666666667
53951, 0.375, 0.575, 0.375
53952, 0.35416666666667, 0.6, 0.375
53953, 0.375, 0.6, 0.35416666666667
53954, 0.375, 0.625, 0.375
53955, 0.35416666666667, 0.65, 0.375
53956, 0.375, 0.65, 0.35416666666667
53957, 0.375, 0.675, 0.375
53958, 0.35416666666667, 0.7, 0.375
53959, 0.375, 0.7, 0.35416666666667
53960, 0.375, 0.725, 0.375
53961, 0.35416666666667, 0.75, 0.375
53962, 0.375, 0.75, 0.35416666666667
53963, 0.375, 0.775, 0.375
53964, 0.35416666666667, 0.8, 0.375
53965, 0.375, 0.8, 0.35416666666667
53966, 0.375, 0.825, 0.375
53967, 0.35416666666667, 0.85, 0.375
53968, 0.375, 0.85, 0.35416666666667
53969, 0.375, 0.875, 0.375
53970, 0.35416666666667, 0.9, 0.375
53971, 0.375, 0.9, 0.35416666666667
53972, 0.375, 0.925, 0.375
53973, 0.35416666666667, 0.95, 0.375
53974, 0.375, 0.95, 0.35416666666667
53975, 0.375, 0.975, 0.375
53976, 0.35416666666667, 1, 0.375
53977, 0.375, 1, 0.35416666666667
53978, 0.375, 1.025, 0.375
53979, 0.35416666666667, 1.05, 0.375
53980, 0.375, 1.05, 0.35416666666667
53981, 0.375, 1.075, 0.375
53982, 0.35416666666667, 1.1, 0.375
53983, 0.375, 1.1, 0.35416666666667
53984, 0.375, 1.125, 0.375
53985, 0.35416666666667, 1.15, 0.375
53986, 0.375, 1.15, 0.35416666666667
53987, 0.375, 1.175, 0.375
53988, 0.35416666666667, 1.2, 0.375
53989, 0.375, 1.2, 0.35416666666667
53990, 0.375, 1.225, 0.375
53991, 0.35416666666667, 1.25, 0.375
53992, 0.375, 1.25, 0.35416666666667
53993, 0.375, 1.275, 0.375
53994, 0.35416666666667, 1.3, 0.375
53995, 0.375, 1.3, 0.35416666666667
53996, 0.375, 1.325, 0.375
53997, 0.375, 0.175, 0.41666666666667
53998, 0.35416666666667, 0.2, 0.41666666666667
53999, 0.375, 0.2, 0.39583333333333
54000, 0.375, 0.225, 0.41666666666667
54001, 0.35416666666667, 0.25, 0.41666666666667
54002, 0.375, 0.25, 0.39583333333333
54003, 0.375, 0.275, 0.41666666666667
54004, 0.35416666666667, 0.3, 0.41666666666667
54005, 0.375, 0.3, 0.39583333333333
54006, 0.375, 0.325, 0.41666666666667
54007, 0.35416666666667, 0.35, 0.41666666666667
54008, 0.375, 0.35, 0.39583333333333
54009, 0.375, 0.375, 0.41666666666667
54010, 0.35416666666667, 0.4, 0.41666666666667
54011, 0.375, 0.4, 0.39583333333333
54012, 0.375, 0.425, 0.41666666666667
54013, 0.35416666666667, 0.45, 0.41666666666667
54014, 0.375, 0.45, 0.39583333333333
54015, 0.375, 0.475, 0.41666666666667
54016, 0.35416666666667, 0.5, 0.41666666666667
54017, 0.375, 0.5, 0.39583333333333
54018, 0.375, 0.525, 0.41666666666667
54019, 0.35416666666667, 0.55, 0.41666666666667
54020, 0.375, 0.55, 0.39583333333333
54021, 0.375, 0.575, 0.41666666666667
54022, 0.35416666666667, 0.6, 0.41666666666667
54023, 0.375, 0.6, 0.39583333333333
54024, 0.375, 0.625, 0.41666666666667
54025, 0.35416666666667, 0.65, 0.41666666666667
54026, 0.375, 0.65, 0.39583333333333
54027, 0.375, 0.675, 0.41666666666667
54028, 0.35416666666667, 0.7, 0.41666666666667
54029, 0.375, 0.7, 0.39583333333333
54030, 0.375, 0.725, 0.41666666666667
54031, 0.35416666666667, 0.75, 0.41666666666667
54032, 0.375, 0.75, 0.39583333333333
54033, 0.375, 0.775, 0.41666666666667
54034, 0.35416666666667, 0.8, 0.41666666666667
54035, 0.375, 0.8, 0.39583333333333
54036, 0.375, 0.825, 0.41666666666667
54037, 0.35416666666667, 0.85, 0.41666666666667
54038, 0.375, 0.85, 0.39583333333333
54039, 0.375, 0.875, 0.41666666666667
54040, 0.35416666666667, 0.9, 0.41666666666667
54041, 0.375, 0.9, 0.39583333333333
54042, 0.375, 0.925, 0.41666666666667
54043, 0.35416666666667, 0.95, 0.41666666666667
54044, 0.375, 0.95, 0.39583333333333
54045, 0.375, 0.975, 0.41666666666667
54046, 0.35416666666667, 1, 0.41666666666667
54047, 0.375, 1, 0.39583333333333
54048, 0.375, 1.025, 0.41666666666667
54049, 0.35416666666667, 1.05, 0.41666666666667
54050, 0.375, 1.05, 0.39583333333333
54051, 0.375, 1.075, 0.41666666666667
54052, 0.35416666666667, 1.1, 0.41666666666667
54053, 0.375, 1.1, 0.39583333333333
54054, 0.375, 1.125, 0.41666666666667
54055, 0.35416666666667, 1.15, 0.41666666666667
54056, 0.375, 1.15, 0.39583333333333
54057, 0.375, 1.175, 0.41666666666667
54058, 0.35416666666667, 1.2, 0.41666666666667
54059, 0.375, 1.2, 0.39583333333333
54060, 0.375, 1.225, 0.41666666666667
54061, 0.35416666666667, 1.25, 0.41666666666667
54062, 0.375, 1.25, 0.39583333333333
54063, 0.375, 1.275, 0.41666666666667
54064, 0.35416666666667, 1.3, 0.41666666666667
54065, 0.375, 1.3, 0.39583333333333
54066, 0.375, 1.325, 0.41666666666667
54067, 0.375, 0.175, 0.45833333333333
54068, 0.35416666666667, 0.2, 0.45833333333333
54069, 0.375, 0.2, 0.4375
54070, 0.375, 0.225, 0.45833333333333
54071, 0.35416666666667, 0.25, 0.45833333333333
54072, 0.375, 0.25, 0.4375
54073, 0.375, 0.275, 0.45833333333333
54074, 0.35416666666667, 0.3, 0.45833333333333
54075, 0.375, 0.3, 0.4375
54076, 0.375, 0.325, 0.45833333333333
54077, 0.35416666666667, 0.35, 0.45833333333333
54078, 0.375, 0.35, 0.4375
54079, 0.375, 0.375, 0.45833333333333
54080, 0.35416666666667, 0.4, 0.45833333333333
54081, 0.375, 0.4, 0.4375
54082, 0.375, 0.425, 0.45833333333333
54083, 0.35416666666667, 0.45, 0.45833333333333
54084, 0.375, 0.45, 0.4375
54085, 0.375, 0.475, 0.45833333333333
54086, 0.35416666666667, 0.5, 0.45833333333333
54087, 0.375, 0.5, 0.4375
54088, 0.375, 0.525, 0.45833333333333
54089, 0.35416666666667, 0.55, 0.45833333333333
54090, 0.375, 0.55, 0.4375
54091, 0.375, 0.575, 0.45833333333333
54092, 0.35416666666667, 0.6, 0.45833333333333
54093, 0.375, 0.6, 0.4375
54094, 0.375, 0.625, 0.45833333333333
54095, 0.35416666666667, 0.65, 0.45833333333333
54096, 0.375, 0.65, 0.4375
54097, 0.375, 0.675, 0.45833333333333
54098, 0.35416666666667, 0.7, 0.45833333333333
54099, 0.375, 0.7, 0.4375
54100, 0.375, 0.725, 0.45833333333333
54101, 0.35416666666667, 0.75, 0.45833333333333
54102, 0.375, 0.75, 0.4375
54103, 0.375, 0.775, 0.45833333333333
54104, 0.35416666666667, 0.8, 0.45833333333333
54105, 0.375, 0.8, 0.4375
54106, 0.375, 0.825, 0.45833333333333
54107, 0.35416666666667, 0.85, 0.45833333333333
54108, 0.375, 0.85, 0.4375
54109, 0.375, 0.875, 0.45833333333333
54110, 0.35416666666667, 0.9, 0.45833333333333
54111, 0.375, 0.9, 0.4375
54112, 0.375, 0.925, 0.45833333333333
54113, 0.35416666666667, 0.95, 0.45833333333333
54114, 0.375, 0.95, 0.4375
54115, 0.375, 0.975, 0.45833333333333
54116, 0.35416666666667, 1, 0.45833333333333
54117, 0.375, 1, 0.4375
54118, 0.375, 1.025, 0.45833333333333
54119, 0.35416666666667, 1.05, 0.45833333333333
54120, 0.375, 1.05, 0.4375
54121, 0.375, 1.075, 0.45833333333333
54122, 0.35416666666667, 1.1, 0.45833333333333
54123, 0.375, 1.1, 0.4375
54124, 0.375, 1.125, 0.45833333333333
54125, 0.35416666666667, 1.15, 0.45833333333333
54126, 0.375, 1.15, 0.4375
54127, 0.375, 1.175, 0.45833333333333
54128, 0.35416666666667, 1.2, 0.45833333333333
54129, 0.375, 1.2, 0.4375
54130, 0.375, 1.225, 0.45833333333333
54131, 0.35416666666667, 1.25, 0.45833333333333
54132, 0.375, 1.25, 0.4375
54133, 0.375, 1.275, 0.45833333333333
54134, 0.35416666666667, 1.3, 0.45833333333333
54135, 0.375, 1.3, 0.4375
54136, 0.375, 1.325, 0.45833333333333
54137, 0.375, 0.2, 0.47916666666667
54138, 0.375, 0.25, 0.47916666666667
54139, 0.375, 0.3, 0.47916666666667
54140, 0.375, 0.35, 0.47916666666667
54141, 0.375, 0.4, 0.47916666666667
54142, 0.375, 0.45, 0.47916666666667
54143, 0.375, 0.5, 0.47916666666667
54144, 0.375, 0.55, 0.47916666666667
54145, 0.375, 0.6, 0.47916666666667
54146, 0.375, 0.65, 0.47916666666667
54147, 0.375, 0.7, 0.47916666666667
54148, 0.375, 0.75, 0.47916666666667
54149, 0.375, 0.8, 0.47916666666667
54150, 0.375, 0.85, 0.47916666666667
54151, 0.375, 0.9, 0.47916666666667
54152, 0.375, 0.95, 0.47916666666667
54153, 0.375, 1, 0.47916666666667
54154, 0.375, 1.05, 0.47916666666667
54155, 0.375, 1.1, 0.47916666666667
54156, 0.375, 1.15, 0.47916666666667
54157, 0.375, 1.2, 0.47916666666667
54158, 0.375, 1.25, 0.47916666666667
54159, 0.375, 1.3, 0.47916666666667
54160, 0.41666666666667, 0.175, 0.041666666666667
54161, 0.39583333333333, 0.2, 0.041666666666667
54162, 0.41666666666667, 0.2, 0.020833333333333
54163, 0.41666666666667, 0.225, 0.041666666666667
54164, 0.39583333333333, 0.25, 0.041666666666667
54165, 0.41666666666667, 0.25, 0.020833333333333
54166, 0.41666666666667, 0.275, 0.041666666666667
54167, 0.39583333333333, 0.3, 0.041666666666667
54168, 0.41666666666667, 0.3, 0.020833333333333
54169, 0.41666666666667, 0.325, 0.041666666666667
54170, 0.39583333333333, 0.35, 0.041666666666667
54171, 0.41666666666667, 0.35, 0.020833333333333
54172, 0.41666666666667, 0.375, 0.041666666666667
54173, 0.39583333333333, 0.4, 0.041666666666667
54174, 0.41666666666667, 0.4, 0.020833333333333
54175, 0.41666666666667, 0.425, 0.041666666666667
54176, 0.39583333333333, 0.45, 0.041666666666667
54177, 0.41666666666667, 0.45, 0.020833333333333
54178, 0.41666666666667, 0.475, 0.041666666666667
54179, 0.39583333333333, 0.5, 0.041666666666667
54180, 0.41666666666667, 0.5, 0.020833333333333
54181, 0.41666666666667, 0.525, 0.041666666666667
54182, 0.39583333333333, 0.55, 0.041666666666667
54183, 0.41666666666667, 0.55, 0.020833333333333
54184, 0.41666666666667, 0.575, 0.041666666666667
54185, 0.39583333333333, 0.6, 0.041666666666667
54186, 0.41666666666667, 0.6, 0.020833333333333
54187, 0.41666666666667, 0.625, 0.041666666666667
54188, 0.39583333333333, 0.65, 0.041666666666667
54189, 0.41666666666667, 0.65, 0.020833333333333
54190, 0.41666666666667, 0.675, 0.041666666666667
54191, 0.39583333333333, 0.7, 0.041666666666667
54192, 0.41666666666667, 0.7, 0.020833333333333
54193, 0.41666666666667, 0.725, 0.041666666666667
54194, 0.39583333333333, 0.75, 0.041666666666667
54195, 0.41666666666667, 0.75, 0.020833333333333
54196, 0.41666666666667, 0.775, 0.041666666666667
54197, 0.39583333333333, 0.8, 0.041666666666667
54198, 0.41666666666667, 0.8, 0.020833333333333
54199, 0.41666666666667, 0.825, 0.041666666666667
54200, 0.39583333333333, 0.85, 0.041666666666667
54201, 0.41666666666667, 0.85, 0.020833333333333
54202, 0.41666666666667, 0.875, 0.041666666666667
54203, 0.39583333333333, 0.9, 0.041666666666667
54204, 0.41666666666667, 0.9, 0.020833333333333
54205, 0.41666666666667, 0.925, 0.041666666666667
54206, 0.39583333333333, 0.95, 0.041666666666667
54207, 0.41666666666667, 0.95, 0.020833333333333
54208, 0.41666666666667, 0.975, 0.041666666666667
54209, 0.39583333333333, 1, 0.041666666666667
54210, 0.41666666666667, 1, 0.020833333333333
54211, 0.41666666666667, 1.025, 0.041666666666667
54212, 0.39583333333333, 1.05, 0.041666666666667
54213, 0.41666666666667, 1.05, 0.020833333333333
54214, 0.41666666666667, 1.075, 0.041666666666667
54215, 0.39583333333333, 1.1, 0.041666666666667
54216, 0.41666666666667, 1.1, 0.020833333333333
54217, 0.41666666666667, 1.125, 0.041666666666667
54218, 0.39583333333333, 1.15, 0.041666666666667
54219, 0.41666666666667, 1.15, 0.020833333333333
54220, 0.41666666666667, 1.175, 0.041666666666667
54221, 0.39583333333333, 1.2, 0.041666666666667
54222, 0.41666666666667, 1.2, 0.020833333333333
54223, 0.41666666666667, 1.225, 0.041666666666667
54224, 0.39583333333333, 1.25, 0.041666666666667
54225, 0.41666666666667, 1.25, 0.020833333333333
54226, 0.41666666666667, 1.275, 0.041666666666667
54227, 0.39583333333333, 1.3, 0.041666666666667
54228, 0.41666666666667, 1.3, 0.020833333333333
54229, 0.41666666666667, 1.325, 0.041666666666667
54230, 0.41666666666667, 0.175, 0.083333333333333
54231, 0.39583333333333, 0.2, 0.083333333333333
54232, 0.41666666666667, 0.2, 0.0625
54233, 0.41666666666667, 0.225, 0.083333333333333
54234, 0.39583333333333, 0.25, 0.083333333333333
54235, 0.41666666666667, 0.25, 0.0625
54236, 0.41666666666667, 0.275, 0.083333333333333
54237, 0.39583333333333, 0.3, 0.083333333333333
54238, 0.41666666666667, 0.3, 0.0625
54239, 0.41666666666667, 0.325, 0.083333333333333
54240, 0.39583333333333, 0.35, 0.083333333333333
54241, 0.41666666666667, 0.35, 0.0625
54242, 0.41666666666667, 0.375, 0.083333333333333
54243, 0.39583333333333, 0.4, 0.083333333333333
54244, 0.41666666666667, 0.4, 0.0625
54245, 0.41666666666667, 0.425, 0.083333333333333
54246, 0.39583333333333, 0.45, 0.083333333333333
54247, 0.41666666666667, 0.45, 0.0625
54248, 0.41666666666667, 0.475, 0.083333333333333
54249, 0.39583333333333, 0.5, 0.083333333333333
54250, 0.41666666666667, 0.5, 0.0625
54251, 0.41666666666667, 0.525, 0.083333333333333
54252, 0.39583333333333, 0.55, 0.083333333333333
54253, 0.41666666666667, 0.55, 0.0625
54254, 0.41666666666667, 0.575, 0.083333333333333
54255, 0.39583333333333, 0.6, 0.083333333333333
54256, 0.41666666666667, 0.6, 0.0625
54257, 0.41666666666667, 0.625, 0.083333333333333
54258, 0.39583333333333, 0.65, 0.083333333333333
54259, 0.41666666666667, 0.65, 0.0625
54260, 0.41666666666667, 0.675, 0.083333333333333
54261, 0.39583333333333, 0.7, 0.083333333333333
54262, 0.41666666666667, 0.7, 0.0625
54263, 0.41666666666667, 0.725, 0.083333333333333
54264, 0.39583333333333, 0.75, 0.083333333333333
54265, 0.41666666666667, 0.75, 0.0625
54266, 0.41666666666667, 0.775, 0.083333333333333
54267, 0.39583333333333, 0.8, 0.083333333333333
54268, 0.41666666666667, 0.8, 0.0625
54269, 0.41666666666667, 0.825, 0.083333333333333
54270, 0.39583333333333, 0.85, 0.083333333333333
54271, 0.41666666666667, 0.85, 0.0625
54272, 0.41666666666667, 0.875, 0.083333333333333
54273, 0.39583333333333, 0.9, 0.083333333333333
54274, 0.41666666666667, 0.9, 0.0625
54275, 0.41666666666667, 0.925, 0.083333333333333
54276, 0.39583333333333, 0.95, 0.083333333333333
54277, 0.41666666666667, 0.95, 0.0625
54278, 0.41666666666667, 0.975, 0.083333333333333
54279, 0.39583333333333, 1, 0.083333333333333
54280, 0.41666666666667, 1, 0.0625
54281, 0.41666666666667, 1.025, 0.083333333333333
54282, 0.39583333333333, 1.05, 0.083333333333333
54283, 0.41666666666667, 1.05, 0.0625
54284, 0.41666666666667, 1.075, 0.083333333333333
54285, 0.39583333333333, 1.1, 0.083333333333333
54286, 0.41666666666667, 1.1, 0.0625
54287, 0.41666666666667, 1.125, 0.083333333333333
54288, 0.39583333333333, 1.15, 0.083333333333333
54289, 0.41666666666667, 1.15, 0.0625
54290, 0.41666666666667, 1.175, 0.083333333333333
54291, 0.39583333333333, 1.2, 0.083333333333333
54292, 0.41666666666667, 1.2, 0.0625
54293, 0.41666666666667, 1.225, 0.083333333333333
54294, 0.39583333333333, 1.25, 0.083333333333333
54295, 0.41666666666667, 1.25, 0.0625
54296, 0.41666666666667, 1.275, 0.083333333333333
54297, 0.39583333333333, 1.3, 0.083333333333333
54298, 0.41666666666667, 1.3, 0.0625
54299, 0.41666666666667, 1.325, 0.083333333333333
54300, 0.41666666666667, 0.175, 0.125
54301, 0.39583333333333, 0.2, 0.125
54302, 0.41666666666667, 0.2, 0.10416666666667
54303, 0.41666666666667, 0.225, 0.125
54304, 0.39583333333333, 0.25, 0.125
54305, 0.41666666666667, 0.25, 0.10416666666667
54306, 0.41666666666667, 0.275, 0.125
54307, 0.39583333333333, 0.3, 0.125
54308, 0.41666666666667, 0.3, 0.10416666666667
54309, 0.41666666666667, 0.325, 0.125
54310, 0.39583333333333, 0.35, 0.125
54311, 0.41666666666667, 0.35, 0.10416666666667
54312, 0.41666666666667, 0.375, 0.125
54313, 0.39583333333333, 0.4, 0.125
54314, 0.41666666666667, 0.4, 0.10416666666667
54315, 0.41666666666667, 0.425, 0.125
54316, 0.39583333333333, 0.45, 0.125
54317, 0.41666666666667, 0.45, 0.10416666666667
54318, 0.41666666666667, 0.475, 0.125
54319, 0.39583333333333, 0.5, 0.125
54320, 0.41666666666667, 0.5, 0.10416666666667
54321, 0.41666666666667, 0.525, 0.125
54322, 0.39583333333333, 0.55, 0.125
54323, 0.41666666666667, 0.55, 0.10416666666667
54324, 0.41666666666667, 0.575, 0.125
54325, 0.39583333333333, 0.6, 0.125
54326, 0.41666666666667, 0.6, 0.10416666666667
54327, 0.41666666666667, 0.625, 0.125
54328, 0.39583333333333, 0.65, 0.125
54329, 0.41666666666667, 0.65, 0.10416666666667
54330, 0.41666666666667, 0.675, 0.125
54331, 0.39583333333333, 0.7, 0.125
54332, 0.41666666666667, 0.7, 0.10416666666667
54333, 0.41666666666667, 0.725, 0.125
54334, 0.39583333333333, 0.75, 0.125
54335, 0.41666666666667, 0.75, 0.10416666666667
54336, 0.41666666666667, 0.775, 0.125
54337, 0.39583333333333, 0.8, 0.125
54338, 0.41666666666667, 0.8, 0.10416666666667
54339, 0.41666666666667, 0.825, 0.125
54340, 0.39583333333333, 0.85, 0.125
54341, 0.41666666666667, 0.85, 0.10416666666667
54342, 0.41666666666667, 0.875, 0.125
54343, 0.39583333333333, 0.9, 0.125
54344, 0.41666666666667, 0.9, 0.10416666666667
54345, 0.41666666666667, 0.925, 0.125
54346, 0.39583333333333, 0.95, 0.125
54347, 0.41666666666667, 0.95, 0.10416666666667
54348, 0.41666666666667, 0.975, 0.125
54349, 0.39583333333333, 1, 0.125
54350, 0.41666666666667, 1, 0.10416666666667
54351, 0.41666666666667, 1.025, 0.125
54352, 0.39583333333333, 1.05, 0.125
54353, 0.41666666666667, 1.05, 0.10416666666667
54354, 0.41666666666667, 1.075, 0.125
54355, 0.39583333333333, 1.1, 0.125
54356, 0.41666666666667, 1.1, 0.10416666666667
54357, 0.41666666666667, 1.125, 0.125
54358, 0.39583333333333, 1.15, 0.125
54359, 0.41666666666667, 1.15, 0.10416666666667
54360, 0.41666666666667, 1.175, 0.125
54361, 0.39583333333333, 1.2, 0.125
54362, 0.41666666666667, 1.2, 0.10416666666667
54363, 0.41666666666667, 1.225, 0.125
54364, 0.39583333333333, 1.25, 0.125
54365, 0.41666666666667, 1.25, 0.10416666666667
54366, 0.41666666666667, 1.275, 0.125
54367, 0.39583333333333, 1.3, 0.125
54368, 0.41666666666667, 1.3, 0.10416666666667
54369, 0.41666666666667, 1.325, 0.125
54370, 0.41666666666667, 0.175, 0.16666666666667
54371, 0.39583333333333, 0.2, 0.16666666666667
54372, 0.41666666666667, 0.2, 0.14583333333333
54373, 0.41666666666667, 0.225, 0.16666666666667
54374, 0.39583333333333, 0.25, 0.16666666666667
54375, 0.41666666666667, 0.25, 0.14583333333333
54376, 0.41666666666667, 0.275, 0.16666666666667
54377, 0.39583333333333, 0.3, 0.16666666666667
54378, 0.41666666666667, 0.3, 0.14583333333333
54379, 0.41666666666667, 0.325, 0.16666666666667
54380, 0.39583333333333, 0.35, 0.16666666666667
54381, 0.41666666666667, 0.35, 0.14583333333333
54382, 0.41666666666667, 0.375, 0.16666666666667
54383, 0.39583333333333, 0.4, 0.16666666666667
54384, 0.41666666666667, 0.4, 0.14583333333333
54385, 0.41666666666667, 0.425, 0.16666666666667
54386, 0.39583333333333, 0.45, 0.16666666666667
54387, 0.41666666666667, 0.45, 0.14583333333333
54388, 0.41666666666667, 0.475, 0.16666666666667
54389, 0.39583333333333, 0.5, 0.16666666666667
54390, 0.41666666666667, 0.5, 0.14583333333333
54391, 0.41666666666667, 0.525, 0.16666666666667
54392, 0.39583333333333, 0.55, 0.16666666666667
54393, 0.41666666666667, 0.55, 0.14583333333333
54394, 0.41666666666667, 0.575, 0.16666666666667
54395, 0.39583333333333, 0.6, 0.16666666666667
54396, 0.41666666666667, 0.6, 0.14583333333333
54397, 0.41666666666667, 0.625, 0.16666666666667
54398, 0.39583333333333, 0.65, 0.16666666666667
54399, 0.41666666666667, 0.65, 0.14583333333333
54400, 0.41666666666667, 0.675, 0.16666666666667
54401, 0.39583333333333, 0.7, 0.16666666666667
54402, 0.41666666666667, 0.7, 0.14583333333333
54403, 0.41666666666667, 0.725, 0.16666666666667
54404, 0.39583333333333, 0.75, 0.16666666666667
54405, 0.41666666666667, 0.75, 0.14583333333333
54406, 0.41666666666667, 0.775, 0.16666666666667
54407, 0.39583333333333, 0.8, 0.16666666666667
54408, 0.41666666666667, 0.8, 0.14583333333333
54409, 0.41666666666667, 0.825, 0.16666666666667
54410, 0.39583333333333, 0.85, 0.16666666666667
54411, 0.41666666666667, 0.85, 0.14583333333333
54412, 0.41666666666667, 0.875, 0.16666666666667
54413, 0.39583333333333, 0.9, 0.16666666666667
54414, 0.41666666666667, 0.9, 0.14583333333333
54415, 0.41666666666667, 0.925, 0.16666666666667
54416, 0.39583333333333, 0.95, 0.16666666666667
54417, 0.41666666666667, 0.95, 0.14583333333333
54418, 0.41666666666667, 0.975, 0.16666666666667
54419, 0.39583333333333, 1, 0.16666666666667
54420, 0.41666666666667, 1, 0.14583333333333
54421, 0.41666666666667, 1.025, 0.16666666666667
54422, 0.39583333333333, 1.05, 0.16666666666667
54423, 0.41666666666667, 1.05, 0.14583333333333
54424, 0.41666666666667, 1.075, 0.16666666666667
54425, 0.39583333333333, 1.1, 0.16666666666667
54426, 0.41666666666667, 1.1, 0.14583333333333
54427, 0.41666666666667, 1.125, 0.16666666666667
54428, 0.39583333333333, 1.15, 0.16666666666667
54429, 0.41666666666667, 1.15, 0.14583333333333
54430, 0.41666666666667, 1.175, 0.16666666666667
54431, 0.39583333333333, 1.2, 0.16666666666667
54432, 0.41666666666667, 1.2, 0.14583333333333
54433, 0.41666666666667, 1.225, 0.16666666666667
54434, 0.39583333333333, 1.25, 0.16666666666667
54435, 0.41666666666667, 1.25, 0.14583333333333
54436, 0.41666666666667, 1.275, 0.16666666666667
54437, 0.39583333333333, 1.3, 0.16666666666667
54438, 0.41666666666667, 1.3, 0.14583333333333
54439, 0.41666666666667, 1.325, 0.16666666666667
