26986, 71446, 71469, 71998, 71975, 71447, 71470, 71999, 71976, 77968, 79600, 79601, 79530, 77971, 79603, 79604, 
79533, 77899, 77969, 79602, 79532
26987, 71447, 71470, 71999, 71976, 71448, 71471, 72000, 71977, 77971, 79603, 79604, 79533, 77974, 79606, 79607, 
79536, 77902, 77972, 79605, 79535
26988, 71448, 71471, 72000, 71977, 71449, 71472, 72001, 71978, 77974, 79606, 79607, 79536, 77977, 79609, 79610, 
79539, 77905, 77975, 79608, 79538
26989, 71449, 71472, 72001, 71978, 71450, 71473, 72002, 71979, 77977, 79609, 79610, 79539, 77980, 79612, 79613, 
79542, 77908, 77978, 79611, 79541
26990, 71450, 71473, 72002, 71979, 71451, 71474, 72003, 71980, 77980, 79612, 79613, 79542, 77983, 79615, 79616, 
79545, 77911, 77981, 79614, 79544
26991, 71451, 71474, 72003, 71980, 71452, 71475, 72004, 71981, 77983, 79615, 79616, 79545, 77986, 79618, 79619, 
79548, 77914, 77984, 79617, 79547
26992, 71452, 71475, 72004, 71981, 71453, 71476, 72005, 71982, 77986, 79618, 79619, 79548, 77989, 79621, 79622, 
79551, 77917, 77987, 79620, 79550
26993, 71453, 71476, 72005, 71982, 71454, 71477, 72006, 71983, 77989, 79621, 79622, 79551, 77992, 79624, 79625, 
79554, 77920, 77990, 79623, 79553
26994, 71454, 71477, 72006, 71983, 71455, 71478, 72007, 71984, 77992, 79624, 79625, 79554, 77995, 79627, 79628, 
79557, 77923, 77993, 79626, 79556
26995, 71455, 71478, 72007, 71984, 71456, 71479, 72008, 71985, 77995, 79627, 79628, 79557, 77998, 79630, 79631, 
79560, 77926, 77996, 79629, 79559
26996, 71456, 71479, 72008, 71985, 71457, 71480, 72009, 71986, 77998, 79630, 79631, 79560, 78001, 79633, 79634, 
79563, 77929, 77999, 79632, 79562
26997, 71457, 71480, 72009, 71986, 71458, 71481, 72010, 71987, 78001, 79633, 79634, 79563, 78004, 79636, 79637, 
79566, 77932, 78002, 79635, 79565
26998, 71458, 71481, 72010, 71987, 22851, 22852, 22875, 22874, 78004, 79636, 79637, 79566, 23120, 23166, 23167, 
23164, 77935, 78005, 79638, 79568
26999, 17207, 17208, 17231, 17230, 71459, 71482, 72011, 71988, 17477, 17523, 17524, 17521, 78008, 79640, 79641, 
79570, 77936, 78006, 79639, 79569
27000, 71459, 71482, 72011, 71988, 71460, 71483, 72012, 71989, 78008, 79640, 79641, 79570, 78011, 79643, 79644, 
79573, 77939, 78009, 79642, 79572
27001, 71460, 71483, 72012, 71989, 71461, 71484, 72013, 71990, 78011, 79643, 79644, 79573, 78014, 79646, 79647, 
79576, 77942, 78012, 79645, 79575
27002, 71461, 71484, 72013, 71990, 71462, 71485, 72014, 71991, 78014, 79646, 79647, 79576, 78017, 79649, 79650, 
79579, 77945, 78015, 79648, 79578
27003, 71462, 71485, 72014, 71991, 71463, 71486, 72015, 71992, 78017, 79649, 79650, 79579, 78020, 79652, 79653, 
79582, 77948, 78018, 79651, 79581
27004, 71463, 71486, 72015, 71992, 71464, 71487, 72016, 71993, 78020, 79652, 79653, 79582, 78023, 79655, 79656, 
79585, 77951, 78021, 79654, 79584
27005, 71464, 71487, 72016, 71993, 71465, 71488, 72017, 71994, 78023, 79655, 79656, 79585, 78026, 79658, 79659, 
79588, 77954, 78024, 79657, 79587
27006, 71465, 71488, 72017, 71994, 71466, 71489, 72018, 71995, 78026, 79658, 79659, 79588, 78029, 79661, 79662, 
79591, 77957, 78027, 79660, 79590
27007, 71466, 71489, 72018, 71995, 71467, 71490, 72019, 71996, 78029, 79661, 79662, 79591, 78032, 79664, 79665, 
79594, 77960, 78030, 79663, 79593
27008, 71467, 71490, 72019, 71996, 71468, 71491, 72020, 71997, 78032, 79664, 79665, 79594, 78035, 79667, 79668, 
79597, 77963, 78033, 79666, 79596
27009, 71468, 71491, 72020, 71997, 71469, 71492, 72021, 71998, 78035, 79667, 79668, 79597, 78038, 79670, 79671, 
79600, 77966, 78036, 79669, 79599
27010, 71469, 71492, 72021, 71998, 71470, 71493, 72022, 71999, 78038, 79670, 79671, 79600, 78041, 79673, 79674, 
79603, 77969, 78039, 79672, 79602
27011, 71470, 71493, 72022, 71999, 71471, 71494, 72023, 72000, 78041, 79673, 79674, 79603, 78044, 79676, 79677, 
79606, 77972, 78042, 79675, 79605
27012, 71471, 71494, 72023, 72000, 71472, 71495, 72024, 72001, 78044, 79676, 79677, 79606, 78047, 79679, 79680, 
79609, 77975, 78045, 79678, 79608
27013, 71472, 71495, 72024, 72001, 71473, 71496, 72025, 72002, 78047, 79679, 79680, 79609, 78050, 79682, 79683, 
79612, 77978, 78048, 79681, 79611
27014, 71473, 71496, 72025, 72002, 71474, 71497, 72026, 72003, 78050, 79682, 79683, 79612, 78053, 79685, 79686, 
79615, 77981, 78051, 79684, 79614
27015, 71474, 71497, 72026, 72003, 71475, 71498, 72027, 72004, 78053, 79685, 79686, 79615, 78056, 79688, 79689, 
79618, 77984, 78054, 79687, 79617
27016, 71475, 71498, 72027, 72004, 71476, 71499, 72028, 72005, 78056, 79688, 79689, 79618, 78059, 79691, 79692, 
79621, 77987, 78057, 79690, 79620
27017, 71476, 71499, 72028, 72005, 71477, 71500, 72029, 72006, 78059, 79691, 79692, 79621, 78062, 79694, 79695, 
79624, 77990, 78060, 79693, 79623
27018, 71477, 71500, 72029, 72006, 71478, 71501, 72030, 72007, 78062, 79694, 79695, 79624, 78065, 79697, 79698, 
79627, 77993, 78063, 79696, 79626
27019, 71478, 71501, 72030, 72007, 71479, 71502, 72031, 72008, 78065, 79697, 79698, 79627, 78068, 79700, 79701, 
79630, 77996, 78066, 79699, 79629
27020, 71479, 71502, 72031, 72008, 71480, 71503, 72032, 72009, 78068, 79700, 79701, 79630, 78071, 79703, 79704, 
79633, 77999, 78069, 79702, 79632
27021, 71480, 71503, 72032, 72009, 71481, 71504, 72033, 72010, 78071, 79703, 79704, 79633, 78074, 79706, 79707, 
79636, 78002, 78072, 79705, 79635
27022, 71481, 71504, 72033, 72010, 22852, 22853, 22876, 22875, 78074, 79706, 79707, 79636, 23122, 23168, 23169, 
23166, 78005, 78075, 79708, 79638
27023, 17208, 17209, 17232, 17231, 71482, 71505, 72034, 72011, 17479, 17525, 17526, 17523, 78078, 79710, 79711, 
79640, 78006, 78076, 79709, 79639
27024, 71482, 71505, 72034, 72011, 71483, 71506, 72035, 72012, 78078, 79710, 79711, 79640, 78081, 79713, 79714, 
79643, 78009, 78079, 79712, 79642
27025, 71483, 71506, 72035, 72012, 71484, 71507, 72036, 72013, 78081, 79713, 79714, 79643, 78084, 79716, 79717, 
79646, 78012, 78082, 79715, 79645
27026, 71484, 71507, 72036, 72013, 71485, 71508, 72037, 72014, 78084, 79716, 79717, 79646, 78087, 79719, 79720, 
79649, 78015, 78085, 79718, 79648
27027, 71485, 71508, 72037, 72014, 71486, 71509, 72038, 72015, 78087, 79719, 79720, 79649, 78090, 79722, 79723, 
79652, 78018, 78088, 79721, 79651
27028, 71486, 71509, 72038, 72015, 71487, 71510, 72039, 72016, 78090, 79722, 79723, 79652, 78093, 79725, 79726, 
79655, 78021, 78091, 79724, 79654
27029, 71487, 71510, 72039, 72016, 71488, 71511, 72040, 72017, 78093, 79725, 79726, 79655, 78096, 79728, 79729, 
79658, 78024, 78094, 79727, 79657
27030, 71488, 71511, 72040, 72017, 71489, 71512, 72041, 72018, 78096, 79728, 79729, 79658, 78099, 79731, 79732, 
79661, 78027, 78097, 79730, 79660
27031, 71489, 71512, 72041, 72018, 71490, 71513, 72042, 72019, 78099, 79731, 79732, 79661, 78102, 79734, 79735, 
79664, 78030, 78100, 79733, 79663
27032, 71490, 71513, 72042, 72019, 71491, 71514, 72043, 72020, 78102, 79734, 79735, 79664, 78105, 79737, 79738, 
79667, 78033, 78103, 79736, 79666
27033, 71491, 71514, 72043, 72020, 71492, 71515, 72044, 72021, 78105, 79737, 79738, 79667, 78108, 79740, 79741, 
79670, 78036, 78106, 79739, 79669
27034, 71492, 71515, 72044, 72021, 71493, 71516, 72045, 72022, 78108, 79740, 79741, 79670, 78111, 79743, 79744, 
79673, 78039, 78109, 79742, 79672
27035, 71493, 71516, 72045, 72022, 71494, 71517, 72046, 72023, 78111, 79743, 79744, 79673, 78114, 79746, 79747, 
79676, 78042, 78112, 79745, 79675
27036, 71494, 71517, 72046, 72023, 71495, 71518, 72047, 72024, 78114, 79746, 79747, 79676, 78117, 79749, 79750, 
79679, 78045, 78115, 79748, 79678
27037, 71495, 71518, 72047, 72024, 71496, 71519, 72048, 72025, 78117, 79749, 79750, 79679, 78120, 79752, 79753, 
79682, 78048, 78118, 79751, 79681
27038, 71496, 71519, 72048, 72025, 71497, 71520, 72049, 72026, 78120, 79752, 79753, 79682, 78123, 79755, 79756, 
79685, 78051, 78121, 79754, 79684
27039, 71497, 71520, 72049, 72026, 71498, 71521, 72050, 72027, 78123, 79755, 79756, 79685, 78126, 79758, 79759, 
79688, 78054, 78124, 79757, 79687
27040, 71498, 71521, 72050, 72027, 71499, 71522, 72051, 72028, 78126, 79758, 79759, 79688, 78129, 79761, 79762, 
79691, 78057, 78127, 79760, 79690
27041, 71499, 71522, 72051, 72028, 71500, 71523, 72052, 72029, 78129, 79761, 79762, 79691, 78132, 79764, 79765, 
79694, 78060, 78130, 79763, 79693
27042, 71500, 71523, 72052, 72029, 71501, 71524, 72053, 72030, 78132, 79764, 79765, 79694, 78135, 79767, 79768, 
79697, 78063, 78133, 79766, 79696
27043, 71501, 71524, 72053, 72030, 71502, 71525, 72054, 72031, 78135, 79767, 79768, 79697, 78138, 79770, 79771, 
79700, 78066, 78136, 79769, 79699
27044, 71502, 71525, 72054, 72031, 71503, 71526, 72055, 72032, 78138, 79770, 79771, 79700, 78141, 79773, 79774, 
79703, 78069, 78139, 79772, 79702
27045, 71503, 71526, 72055, 72032, 71504, 71527, 72056, 72033, 78141, 79773, 79774, 79703, 78144, 79776, 79777, 
79706, 78072, 78142, 79775, 79705
27046, 71504, 71527, 72056, 72033, 22853, 22854, 22877, 22876, 78144, 79776, 79777, 79706, 23124, 23170, 23171, 
23168, 78075, 78145, 79778, 79708
27047, 17209, 17210, 17233, 17232, 71505, 71528, 72057, 72034, 17481, 17527, 17528, 17525, 78148, 79780, 79781, 
79710, 78076, 78146, 79779, 79709
27048, 71505, 71528, 72057, 72034, 71506, 71529, 72058, 72035, 78148, 79780, 79781, 79710, 78151, 79783, 79784, 
79713, 78079, 78149, 79782, 79712
27049, 71506, 71529, 72058, 72035, 71507, 71530, 72059, 72036, 78151, 79783, 79784, 79713, 78154, 79786, 79787, 
79716, 78082, 78152, 79785, 79715
27050, 71507, 71530, 72059, 72036, 71508, 71531, 72060, 72037, 78154, 79786, 79787, 79716, 78157, 79789, 79790, 
79719, 78085, 78155, 79788, 79718
27051, 71508, 71531, 72060, 72037, 71509, 71532, 72061, 72038, 78157, 79789, 79790, 79719, 78160, 79792, 79793, 
79722, 78088, 78158, 79791, 79721
27052, 71509, 71532, 72061, 72038, 71510, 71533, 72062, 72039, 78160, 79792, 79793, 79722, 78163, 79795, 79796, 
79725, 78091, 78161, 79794, 79724
27053, 71510, 71533, 72062, 72039, 71511, 71534, 72063, 72040, 78163, 79795, 79796, 79725, 78166, 79798, 79799, 
79728, 78094, 78164, 79797, 79727
27054, 71511, 71534, 72063, 72040, 71512, 71535, 72064, 72041, 78166, 79798, 79799, 79728, 78169, 79801, 79802, 
79731, 78097, 78167, 79800, 79730
27055, 71512, 71535, 72064, 72041, 71513, 71536, 72065, 72042, 78169, 79801, 79802, 79731, 78172, 79804, 79805, 
79734, 78100, 78170, 79803, 79733
27056, 71513, 71536, 72065, 72042, 71514, 71537, 72066, 72043, 78172, 79804, 79805, 79734, 78175, 79807, 79808, 
79737, 78103, 78173, 79806, 79736
27057, 71514, 71537, 72066, 72043, 71515, 71538, 72067, 72044, 78175, 79807, 79808, 79737, 78178, 79810, 79811, 
79740, 78106, 78176, 79809, 79739
27058, 71515, 71538, 72067, 72044, 71516, 71539, 72068, 72045, 78178, 79810, 79811, 79740, 78181, 79813, 79814, 
79743, 78109, 78179, 79812, 79742
27059, 71516, 71539, 72068, 72045, 71517, 71540, 72069, 72046, 78181, 79813, 79814, 79743, 78184, 79816, 79817, 
79746, 78112, 78182, 79815, 79745
27060, 71517, 71540, 72069, 72046, 71518, 71541, 72070, 72047, 78184, 79816, 79817, 79746, 78187, 79819, 79820, 
79749, 78115, 78185, 79818, 79748
27061, 71518, 71541, 72070, 72047, 71519, 71542, 72071, 72048, 78187, 79819, 79820, 79749, 78190, 79822, 79823, 
79752, 78118, 78188, 79821, 79751
27062, 71519, 71542, 72071, 72048, 71520, 71543, 72072, 72049, 78190, 79822, 79823, 79752, 78193, 79825, 79826, 
79755, 78121, 78191, 79824, 79754
27063, 71520, 71543, 72072, 72049, 71521, 71544, 72073, 72050, 78193, 79825, 79826, 79755, 78196, 79828, 79829, 
79758, 78124, 78194, 79827, 79757
27064, 71521, 71544, 72073, 72050, 71522, 71545, 72074, 72051, 78196, 79828, 79829, 79758, 78199, 79831, 79832, 
79761, 78127, 78197, 79830, 79760
27065, 71522, 71545, 72074, 72051, 71523, 71546, 72075, 72052, 78199, 79831, 79832, 79761, 78202, 79834, 79835, 
79764, 78130, 78200, 79833, 79763
27066, 71523, 71546, 72075, 72052, 71524, 71547, 72076, 72053, 78202, 79834, 79835, 79764, 78205, 79837, 79838, 
79767, 78133, 78203, 79836, 79766
27067, 71524, 71547, 72076, 72053, 71525, 71548, 72077, 72054, 78205, 79837, 79838, 79767, 78208, 79840, 79841, 
79770, 78136, 78206, 79839, 79769
27068, 71525, 71548, 72077, 72054, 71526, 71549, 72078, 72055, 78208, 79840, 79841, 79770, 78211, 79843, 79844, 
79773, 78139, 78209, 79842, 79772
27069, 71526, 71549, 72078, 72055, 71527, 71550, 72079, 72056, 78211, 79843, 79844, 79773, 78214, 79846, 79847, 
79776, 78142, 78212, 79845, 79775
27070, 71527, 71550, 72079, 72056, 22854, 22855, 22878, 22877, 78214, 79846, 79847, 79776, 23126, 23172, 23173, 
23170, 78145, 78215, 79848, 79778
27071, 17210, 17211, 17234, 17233, 71528, 71551, 72080, 72057, 17483, 17529, 17530, 17527, 78218, 79850, 79851, 
79780, 78146, 78216, 79849, 79779
27072, 71528, 71551, 72080, 72057, 71529, 71552, 72081, 72058, 78218, 79850, 79851, 79780, 78221, 79853, 79854, 
79783, 78149, 78219, 79852, 79782
27073, 71529, 71552, 72081, 72058, 71530, 71553, 72082, 72059, 78221, 79853, 79854, 79783, 78224, 79856, 79857, 
79786, 78152, 78222, 79855, 79785
27074, 71530, 71553, 72082, 72059, 71531, 71554, 72083, 72060, 78224, 79856, 79857, 79786, 78227, 79859, 79860, 
79789, 78155, 78225, 79858, 79788
27075, 71531, 71554, 72083, 72060, 71532, 71555, 72084, 72061, 78227, 79859, 79860, 79789, 78230, 79862, 79863, 
79792, 78158, 78228, 79861, 79791
27076, 71532, 71555, 72084, 72061, 71533, 71556, 72085, 72062, 78230, 79862, 79863, 79792, 78233, 79865, 79866, 
79795, 78161, 78231, 79864, 79794
27077, 71533, 71556, 72085, 72062, 71534, 71557, 72086, 72063, 78233, 79865, 79866, 79795, 78236, 79868, 79869, 
79798, 78164, 78234, 79867, 79797
27078, 71534, 71557, 72086, 72063, 71535, 71558, 72087, 72064, 78236, 79868, 79869, 79798, 78239, 79871, 79872, 
79801, 78167, 78237, 79870, 79800
27079, 71535, 71558, 72087, 72064, 71536, 71559, 72088, 72065, 78239, 79871, 79872, 79801, 78242, 79874, 79875, 
79804, 78170, 78240, 79873, 79803
27080, 71536, 71559, 72088, 72065, 71537, 71560, 72089, 72066, 78242, 79874, 79875, 79804, 78245, 79877, 79878, 
79807, 78173, 78243, 79876, 79806
27081, 71537, 71560, 72089, 72066, 71538, 71561, 72090, 72067, 78245, 79877, 79878, 79807, 78248, 79880, 79881, 
79810, 78176, 78246, 79879, 79809
27082, 71538, 71561, 72090, 72067, 71539, 71562, 72091, 72068, 78248, 79880, 79881, 79810, 78251, 79883, 79884, 
79813, 78179, 78249, 79882, 79812
27083, 71539, 71562, 72091, 72068, 71540, 71563, 72092, 72069, 78251, 79883, 79884, 79813, 78254, 79886, 79887, 
79816, 78182, 78252, 79885, 79815
27084, 71540, 71563, 72092, 72069, 71541, 71564, 72093, 72070, 78254, 79886, 79887, 79816, 78257, 79889, 79890, 
79819, 78185, 78255, 79888, 79818
27085, 71541, 71564, 72093, 72070, 71542, 71565, 72094, 72071, 78257, 79889, 79890, 79819, 78260, 79892, 79893, 
79822, 78188, 78258, 79891, 79821
27086, 71542, 71565, 72094, 72071, 71543, 71566, 72095, 72072, 78260, 79892, 79893, 79822, 78263, 79895, 79896, 
79825, 78191, 78261, 79894, 79824
27087, 71543, 71566, 72095, 72072, 71544, 71567, 72096, 72073, 78263, 79895, 79896, 79825, 78266, 79898, 79899, 
79828, 78194, 78264, 79897, 79827
27088, 71544, 71567, 72096, 72073, 71545, 71568, 72097, 72074, 78266, 79898, 79899, 79828, 78269, 79901, 79902, 
79831, 78197, 78267, 79900, 79830
27089, 71545, 71568, 72097, 72074, 71546, 71569, 72098, 72075, 78269, 79901, 79902, 79831, 78272, 79904, 79905, 
79834, 78200, 78270, 79903, 79833
27090, 71546, 71569, 72098, 72075, 71547, 71570, 72099, 72076, 78272, 79904, 79905, 79834, 78275, 79907, 79908, 
79837, 78203, 78273, 79906, 79836
27091, 71547, 71570, 72099, 72076, 71548, 71571, 72100, 72077, 78275, 79907, 79908, 79837, 78278, 79910, 79911, 
79840, 78206, 78276, 79909, 79839
27092, 71548, 71571, 72100, 72077, 71549, 71572, 72101, 72078, 78278, 79910, 79911, 79840, 78281, 79913, 79914, 
79843, 78209, 78279, 79912, 79842
27093, 71549, 71572, 72101, 72078, 71550, 71573, 72102, 72079, 78281, 79913, 79914, 79843, 78284, 79916, 79917, 
79846, 78212, 78282, 79915, 79845
27094, 71550, 71573, 72102, 72079, 22855, 22856, 22879, 22878, 78284, 79916, 79917, 79846, 23128, 23174, 23175, 
23172, 78215, 78285, 79918, 79848
27095, 17211, 17212, 17235, 17234, 71551, 71574, 72103, 72080, 17485, 17531, 17532, 17529, 78288, 79920, 79921, 
79850, 78216, 78286, 79919, 79849
27096, 71551, 71574, 72103, 72080, 71552, 71575, 72104, 72081, 78288, 79920, 79921, 79850, 78291, 79923, 79924, 
79853, 78219, 78289, 79922, 79852
27097, 71552, 71575, 72104, 72081, 71553, 71576, 72105, 72082, 78291, 79923, 79924, 79853, 78294, 79926, 79927, 
79856, 78222, 78292, 79925, 79855
27098, 71553, 71576, 72105, 72082, 71554, 71577, 72106, 72083, 78294, 79926, 79927, 79856, 78297, 79929, 79930, 
79859, 78225, 78295, 79928, 79858
27099, 71554, 71577, 72106, 72083, 71555, 71578, 72107, 72084, 78297, 79929, 79930, 79859, 78300, 79932, 79933, 
79862, 78228, 78298, 79931, 79861
27100, 71555, 71578, 72107, 72084, 71556, 71579, 72108, 72085, 78300, 79932, 79933, 79862, 78303, 79935, 79936, 
79865, 78231, 78301, 79934, 79864
27101, 71556, 71579, 72108, 72085, 71557, 71580, 72109, 72086, 78303, 79935, 79936, 79865, 78306, 79938, 79939, 
79868, 78234, 78304, 79937, 79867
27102, 71557, 71580, 72109, 72086, 71558, 71581, 72110, 72087, 78306, 79938, 79939, 79868, 78309, 79941, 79942, 
79871, 78237, 78307, 79940, 79870
27103, 71558, 71581, 72110, 72087, 71559, 71582, 72111, 72088, 78309, 79941, 79942, 79871, 78312, 79944, 79945, 
79874, 78240, 78310, 79943, 79873
27104, 71559, 71582, 72111, 72088, 71560, 71583, 72112, 72089, 78312, 79944, 79945, 79874, 78315, 79947, 79948, 
79877, 78243, 78313, 79946, 79876
27105, 71560, 71583, 72112, 72089, 71561, 71584, 72113, 72090, 78315, 79947, 79948, 79877, 78318, 79950, 79951, 
79880, 78246, 78316, 79949, 79879
27106, 71561, 71584, 72113, 72090, 71562, 71585, 72114, 72091, 78318, 79950, 79951, 79880, 78321, 79953, 79954, 
79883, 78249, 78319, 79952, 79882
27107, 71562, 71585, 72114, 72091, 71563, 71586, 72115, 72092, 78321, 79953, 79954, 79883, 78324, 79956, 79957, 
79886, 78252, 78322, 79955, 79885
27108, 71563, 71586, 72115, 72092, 71564, 71587, 72116, 72093, 78324, 79956, 79957, 79886, 78327, 79959, 79960, 
79889, 78255, 78325, 79958, 79888
27109, 71564, 71587, 72116, 72093, 71565, 71588, 72117, 72094, 78327, 79959, 79960, 79889, 78330, 79962, 79963, 
79892, 78258, 78328, 79961, 79891
27110, 71565, 71588, 72117, 72094, 71566, 71589, 72118, 72095, 78330, 79962, 79963, 79892, 78333, 79965, 79966, 
79895, 78261, 78331, 79964, 79894
27111, 71566, 71589, 72118, 72095, 71567, 71590, 72119, 72096, 78333, 79965, 79966, 79895, 78336, 79968, 79969, 
79898, 78264, 78334, 79967, 79897
27112, 71567, 71590, 72119, 72096, 71568, 71591, 72120, 72097, 78336, 79968, 79969, 79898, 78339, 79971, 79972, 
79901, 78267, 78337, 79970, 79900
27113, 71568, 71591, 72120, 72097, 71569, 71592, 72121, 72098, 78339, 79971, 79972, 79901, 78342, 79974, 79975, 
79904, 78270, 78340, 79973, 79903
27114, 71569, 71592, 72121, 72098, 71570, 71593, 72122, 72099, 78342, 79974, 79975, 79904, 78345, 79977, 79978, 
79907, 78273, 78343, 79976, 79906
27115, 71570, 71593, 72122, 72099, 71571, 71594, 72123, 72100, 78345, 79977, 79978, 79907, 78348, 79980, 79981, 
79910, 78276, 78346, 79979, 79909
27116, 71571, 71594, 72123, 72100, 71572, 71595, 72124, 72101, 78348, 79980, 79981, 79910, 78351, 79983, 79984, 
79913, 78279, 78349, 79982, 79912
27117, 71572, 71595, 72124, 72101, 71573, 71596, 72125, 72102, 78351, 79983, 79984, 79913, 78354, 79986, 79987, 
79916, 78282, 78352, 79985, 79915
27118, 71573, 71596, 72125, 72102, 22856, 22857, 22880, 22879, 78354, 79986, 79987, 79916, 23130, 23176, 23177, 
23174, 78285, 78355, 79988, 79918
27119, 17212, 17213, 17236, 17235, 71574, 71597, 72126, 72103, 17487, 17533, 17534, 17531, 78358, 79990, 79991, 
79920, 78286, 78356, 79989, 79919
27120, 71574, 71597, 72126, 72103, 71575, 71598, 72127, 72104, 78358, 79990, 79991, 79920, 78361, 79993, 79994, 
79923, 78289, 78359, 79992, 79922
27121, 71575, 71598, 72127, 72104, 71576, 71599, 72128, 72105, 78361, 79993, 79994, 79923, 78364, 79996, 79997, 
79926, 78292, 78362, 79995, 79925
27122, 71576, 71599, 72128, 72105, 71577, 71600, 72129, 72106, 78364, 79996, 79997, 79926, 78367, 79999, 80000, 
79929, 78295, 78365, 79998, 79928
27123, 71577, 71600, 72129, 72106, 71578, 71601, 72130, 72107, 78367, 79999, 80000, 79929, 78370, 80002, 80003, 
79932, 78298, 78368, 80001, 79931
27124, 71578, 71601, 72130, 72107, 71579, 71602, 72131, 72108, 78370, 80002, 80003, 79932, 78373, 80005, 80006, 
79935, 78301, 78371, 80004, 79934
27125, 71579, 71602, 72131, 72108, 71580, 71603, 72132, 72109, 78373, 80005, 80006, 79935, 78376, 80008, 80009, 
79938, 78304, 78374, 80007, 79937
27126, 71580, 71603, 72132, 72109, 71581, 71604, 72133, 72110, 78376, 80008, 80009, 79938, 78379, 80011, 80012, 
79941, 78307, 78377, 80010, 79940
27127, 71581, 71604, 72133, 72110, 71582, 71605, 72134, 72111, 78379, 80011, 80012, 79941, 78382, 80014, 80015, 
79944, 78310, 78380, 80013, 79943
27128, 71582, 71605, 72134, 72111, 71583, 71606, 72135, 72112, 78382, 80014, 80015, 79944, 78385, 80017, 80018, 
79947, 78313, 78383, 80016, 79946
27129, 71583, 71606, 72135, 72112, 71584, 71607, 72136, 72113, 78385, 80017, 80018, 79947, 78388, 80020, 80021, 
79950, 78316, 78386, 80019, 79949
27130, 71584, 71607, 72136, 72113, 71585, 71608, 72137, 72114, 78388, 80020, 80021, 79950, 78391, 80023, 80024, 
79953, 78319, 78389, 80022, 79952
27131, 71585, 71608, 72137, 72114, 71586, 71609, 72138, 72115, 78391, 80023, 80024, 79953, 78394, 80026, 80027, 
79956, 78322, 78392, 80025, 79955
27132, 71586, 71609, 72138, 72115, 71587, 71610, 72139, 72116, 78394, 80026, 80027, 79956, 78397, 80029, 80030, 
79959, 78325, 78395, 80028, 79958
27133, 71587, 71610, 72139, 72116, 71588, 71611, 72140, 72117, 78397, 80029, 80030, 79959, 78400, 80032, 80033, 
79962, 78328, 78398, 80031, 79961
27134, 71588, 71611, 72140, 72117, 71589, 71612, 72141, 72118, 78400, 80032, 80033, 79962, 78403, 80035, 80036, 
79965, 78331, 78401, 80034, 79964
27135, 71589, 71612, 72141, 72118, 71590, 71613, 72142, 72119, 78403, 80035, 80036, 79965, 78406, 80038, 80039, 
79968, 78334, 78404, 80037, 79967
27136, 71590, 71613, 72142, 72119, 71591, 71614, 72143, 72120, 78406, 80038, 80039, 79968, 78409, 80041, 80042, 
79971, 78337, 78407, 80040, 79970
27137, 71591, 71614, 72143, 72120, 71592, 71615, 72144, 72121, 78409, 80041, 80042, 79971, 78412, 80044, 80045, 
79974, 78340, 78410, 80043, 79973
27138, 71592, 71615, 72144, 72121, 71593, 71616, 72145, 72122, 78412, 80044, 80045, 79974, 78415, 80047, 80048, 
79977, 78343, 78413, 80046, 79976
27139, 71593, 71616, 72145, 72122, 71594, 71617, 72146, 72123, 78415, 80047, 80048, 79977, 78418, 80050, 80051, 
79980, 78346, 78416, 80049, 79979
27140, 71594, 71617, 72146, 72123, 71595, 71618, 72147, 72124, 78418, 80050, 80051, 79980, 78421, 80053, 80054, 
79983, 78349, 78419, 80052, 79982
27141, 71595, 71618, 72147, 72124, 71596, 71619, 72148, 72125, 78421, 80053, 80054, 79983, 78424, 80056, 80057, 
79986, 78352, 78422, 80055, 79985
27142, 71596, 71619, 72148, 72125, 22857, 22858, 22881, 22880, 78424, 80056, 80057, 79986, 23132, 23178, 23179, 
23176, 78355, 78425, 80058, 79988
27143, 17213, 17214, 17237, 17236, 71597, 71620, 72149, 72126, 17489, 17535, 17536, 17533, 78428, 80060, 80061, 
79990, 78356, 78426, 80059, 79989
27144, 71597, 71620, 72149, 72126, 71598, 71621, 72150, 72127, 78428, 80060, 80061, 79990, 78431, 80063, 80064, 
79993, 78359, 78429, 80062, 79992
27145, 71598, 71621, 72150, 72127, 71599, 71622, 72151, 72128, 78431, 80063, 80064, 79993, 78434, 80066, 80067, 
79996, 78362, 78432, 80065, 79995
27146, 71599, 71622, 72151, 72128, 71600, 71623, 72152, 72129, 78434, 80066, 80067, 79996, 78437, 80069, 80070, 
79999, 78365, 78435, 80068, 79998
27147, 71600, 71623, 72152, 72129, 71601, 71624, 72153, 72130, 78437, 80069, 80070, 79999, 78440, 80072, 80073, 
80002, 78368, 78438, 80071, 80001
27148, 71601, 71624, 72153, 72130, 71602, 71625, 72154, 72131, 78440, 80072, 80073, 80002, 78443, 80075, 80076, 
80005, 78371, 78441, 80074, 80004
27149, 71602, 71625, 72154, 72131, 71603, 71626, 72155, 72132, 78443, 80075, 80076, 80005, 78446, 80078, 80079, 
80008, 78374, 78444, 80077, 80007
27150, 71603, 71626, 72155, 72132, 71604, 71627, 72156, 72133, 78446, 80078, 80079, 80008, 78449, 80081, 80082, 
80011, 78377, 78447, 80080, 80010
27151, 71604, 71627, 72156, 72133, 71605, 71628, 72157, 72134, 78449, 80081, 80082, 80011, 78452, 80084, 80085, 
80014, 78380, 78450, 80083, 80013
27152, 71605, 71628, 72157, 72134, 71606, 71629, 72158, 72135, 78452, 80084, 80085, 80014, 78455, 80087, 80088, 
80017, 78383, 78453, 80086, 80016
27153, 71606, 71629, 72158, 72135, 71607, 71630, 72159, 72136, 78455, 80087, 80088, 80017, 78458, 80090, 80091, 
80020, 78386, 78456, 80089, 80019
27154, 71607, 71630, 72159, 72136, 71608, 71631, 72160, 72137, 78458, 80090, 80091, 80020, 78461, 80093, 80094, 
80023, 78389, 78459, 80092, 80022
27155, 71608, 71631, 72160, 72137, 71609, 71632, 72161, 72138, 78461, 80093, 80094, 80023, 78464, 80096, 80097, 
80026, 78392, 78462, 80095, 80025
27156, 71609, 71632, 72161, 72138, 71610, 71633, 72162, 72139, 78464, 80096, 80097, 80026, 78467, 80099, 80100, 
80029, 78395, 78465, 80098, 80028
27157, 71610, 71633, 72162, 72139, 71611, 71634, 72163, 72140, 78467, 80099, 80100, 80029, 78470, 80102, 80103, 
80032, 78398, 78468, 80101, 80031
27158, 71611, 71634, 72163, 72140, 71612, 71635, 72164, 72141, 78470, 80102, 80103, 80032, 78473, 80105, 80106, 
80035, 78401, 78471, 80104, 80034
27159, 71612, 71635, 72164, 72141, 71613, 71636, 72165, 72142, 78473, 80105, 80106, 80035, 78476, 80108, 80109, 
80038, 78404, 78474, 80107, 80037
27160, 71613, 71636, 72165, 72142, 71614, 71637, 72166, 72143, 78476, 80108, 80109, 80038, 78479, 80111, 80112, 
80041, 78407, 78477, 80110, 80040
27161, 71614, 71637, 72166, 72143, 71615, 71638, 72167, 72144, 78479, 80111, 80112, 80041, 78482, 80114, 80115, 
80044, 78410, 78480, 80113, 80043
27162, 71615, 71638, 72167, 72144, 71616, 71639, 72168, 72145, 78482, 80114, 80115, 80044, 78485, 80117, 80118, 
80047, 78413, 78483, 80116, 80046
27163, 71616, 71639, 72168, 72145, 71617, 71640, 72169, 72146, 78485, 80117, 80118, 80047, 78488, 80120, 80121, 
80050, 78416, 78486, 80119, 80049
27164, 71617, 71640, 72169, 72146, 71618, 71641, 72170, 72147, 78488, 80120, 80121, 80050, 78491, 80123, 80124, 
80053, 78419, 78489, 80122, 80052
27165, 71618, 71641, 72170, 72147, 71619, 71642, 72171, 72148, 78491, 80123, 80124, 80053, 78494, 80126, 80127, 
80056, 78422, 78492, 80125, 80055
27166, 71619, 71642, 72171, 72148, 22858, 22859, 22882, 22881, 78494, 80126, 80127, 80056, 23134, 23180, 23181, 
23178, 78425, 78495, 80128, 80058
27167, 17214, 17215, 17238, 17237, 71620, 71643, 72172, 72149, 17491, 17537, 17538, 17535, 78498, 80130, 80131, 
80060, 78426, 78496, 80129, 80059
27168, 71620, 71643, 72172, 72149, 71621, 71644, 72173, 72150, 78498, 80130, 80131, 80060, 78501, 80133, 80134, 
80063, 78429, 78499, 80132, 80062
27169, 71621, 71644, 72173, 72150, 71622, 71645, 72174, 72151, 78501, 80133, 80134, 80063, 78504, 80136, 80137, 
80066, 78432, 78502, 80135, 80065
27170, 71622, 71645, 72174, 72151, 71623, 71646, 72175, 72152, 78504, 80136, 80137, 80066, 78507, 80139, 80140, 
80069, 78435, 78505, 80138, 80068
27171, 71623, 71646, 72175, 72152, 71624, 71647, 72176, 72153, 78507, 80139, 80140, 80069, 78510, 80142, 80143, 
80072, 78438, 78508, 80141, 80071
27172, 71624, 71647, 72176, 72153, 71625, 71648, 72177, 72154, 78510, 80142, 80143, 80072, 78513, 80145, 80146, 
80075, 78441, 78511, 80144, 80074
27173, 71625, 71648, 72177, 72154, 71626, 71649, 72178, 72155, 78513, 80145, 80146, 80075, 78516, 80148, 80149, 
80078, 78444, 78514, 80147, 80077
27174, 71626, 71649, 72178, 72155, 71627, 71650, 72179, 72156, 78516, 80148, 80149, 80078, 78519, 80151, 80152, 
80081, 78447, 78517, 80150, 80080
27175, 71627, 71650, 72179, 72156, 71628, 71651, 72180, 72157, 78519, 80151, 80152, 80081, 78522, 80154, 80155, 
80084, 78450, 78520, 80153, 80083
27176, 71628, 71651, 72180, 72157, 71629, 71652, 72181, 72158, 78522, 80154, 80155, 80084, 78525, 80157, 80158, 
80087, 78453, 78523, 80156, 80086
27177, 71629, 71652, 72181, 72158, 71630, 71653, 72182, 72159, 78525, 80157, 80158, 80087, 78528, 80160, 80161, 
80090, 78456, 78526, 80159, 80089
27178, 71630, 71653, 72182, 72159, 71631, 71654, 72183, 72160, 78528, 80160, 80161, 80090, 78531, 80163, 80164, 
80093, 78459, 78529, 80162, 80092
27179, 71631, 71654, 72183, 72160, 71632, 71655, 72184, 72161, 78531, 80163, 80164, 80093, 78534, 80166, 80167, 
80096, 78462, 78532, 80165, 80095
27180, 71632, 71655, 72184, 72161, 71633, 71656, 72185, 72162, 78534, 80166, 80167, 80096, 78537, 80169, 80170, 
80099, 78465, 78535, 80168, 80098
27181, 71633, 71656, 72185, 72162, 71634, 71657, 72186, 72163, 78537, 80169, 80170, 80099, 78540, 80172, 80173, 
80102, 78468, 78538, 80171, 80101
27182, 71634, 71657, 72186, 72163, 71635, 71658, 72187, 72164, 78540, 80172, 80173, 80102, 78543, 80175, 80176, 
80105, 78471, 78541, 80174, 80104
27183, 71635, 71658, 72187, 72164, 71636, 71659, 72188, 72165, 78543, 80175, 80176, 80105, 78546, 80178, 80179, 
80108, 78474, 78544, 80177, 80107
27184, 71636, 71659, 72188, 72165, 71637, 71660, 72189, 72166, 78546, 80178, 80179, 80108, 78549, 80181, 80182, 
80111, 78477, 78547, 80180, 80110
27185, 71637, 71660, 72189, 72166, 71638, 71661, 72190, 72167, 78549, 80181, 80182, 80111, 78552, 80184, 80185, 
80114, 78480, 78550, 80183, 80113
27186, 71638, 71661, 72190, 72167, 71639, 71662, 72191, 72168, 78552, 80184, 80185, 80114, 78555, 80187, 80188, 
80117, 78483, 78553, 80186, 80116
27187, 71639, 71662, 72191, 72168, 71640, 71663, 72192, 72169, 78555, 80187, 80188, 80117, 78558, 80190, 80191, 
80120, 78486, 78556, 80189, 80119
27188, 71640, 71663, 72192, 72169, 71641, 71664, 72193, 72170, 78558, 80190, 80191, 80120, 78561, 80193, 80194, 
80123, 78489, 78559, 80192, 80122
27189, 71641, 71664, 72193, 72170, 71642, 71665, 72194, 72171, 78561, 80193, 80194, 80123, 78564, 80196, 80197, 
80126, 78492, 78562, 80195, 80125
27190, 71642, 71665, 72194, 72171, 22859, 22860, 22883, 22882, 78564, 80196, 80197, 80126, 23136, 23182, 23183, 
23180, 78495, 78565, 80198, 80128
27191, 17215, 1630, 1631, 17238, 71643, 22045, 22068, 72172, 17492, 1642, 17539, 17537, 78566, 22346, 80199, 
80130, 78496, 22298, 22345, 80129
27192, 71643, 22045, 22068, 72172, 71644, 22046, 22069, 72173, 78566, 22346, 80199, 80130, 78567, 22348, 80200, 
80133, 78499, 22300, 22347, 80132
27193, 71644, 22046, 22069, 72173, 71645, 22047, 22070, 72174, 78567, 22348, 80200, 80133, 78568, 22350, 80201, 
80136, 78502, 22302, 22349, 80135
27194, 71645, 22047, 22070, 72174, 71646, 22048, 22071, 72175, 78568, 22350, 80201, 80136, 78569, 22352, 80202, 
80139, 78505, 22304, 22351, 80138
27195, 71646, 22048, 22071, 72175, 71647, 22049, 22072, 72176, 78569, 22352, 80202, 80139, 78570, 22354, 80203, 
80142, 78508, 22306, 22353, 80141
27196, 71647, 22049, 22072, 72176, 71648, 22050, 22073, 72177, 78570, 22354, 80203, 80142, 78571, 22356, 80204, 
80145, 78511, 22308, 22355, 80144
27197, 71648, 22050, 22073, 72177, 71649, 22051, 22074, 72178, 78571, 22356, 80204, 80145, 78572, 22358, 80205, 
80148, 78514, 22310, 22357, 80147
27198, 71649, 22051, 22074, 72178, 71650, 22052, 22075, 72179, 78572, 22358, 80205, 80148, 78573, 22360, 80206, 
80151, 78517, 22312, 22359, 80150
27199, 71650, 22052, 22075, 72179, 71651, 22053, 22076, 72180, 78573, 22360, 80206, 80151, 78574, 22362, 80207, 
80154, 78520, 22314, 22361, 80153
27200, 71651, 22053, 22076, 72180, 71652, 22054, 22077, 72181, 78574, 22362, 80207, 80154, 78575, 22364, 80208, 
80157, 78523, 22316, 22363, 80156
27201, 71652, 22054, 22077, 72181, 71653, 22055, 22078, 72182, 78575, 22364, 80208, 80157, 78576, 22366, 80209, 
80160, 78526, 22318, 22365, 80159
27202, 71653, 22055, 22078, 72182, 71654, 22056, 22079, 72183, 78576, 22366, 80209, 80160, 78577, 22368, 80210, 
80163, 78529, 22320, 22367, 80162
27203, 71654, 22056, 22079, 72183, 71655, 22057, 22080, 72184, 78577, 22368, 80210, 80163, 78578, 22370, 80211, 
80166, 78532, 22322, 22369, 80165
27204, 71655, 22057, 22080, 72184, 71656, 22058, 22081, 72185, 78578, 22370, 80211, 80166, 78579, 22372, 80212, 
80169, 78535, 22324, 22371, 80168
27205, 71656, 22058, 22081, 72185, 71657, 22059, 22082, 72186, 78579, 22372, 80212, 80169, 78580, 22374, 80213, 
80172, 78538, 22326, 22373, 80171
27206, 71657, 22059, 22082, 72186, 71658, 22060, 22083, 72187, 78580, 22374, 80213, 80172, 78581, 22376, 80214, 
80175, 78541, 22328, 22375, 80174
27207, 71658, 22060, 22083, 72187, 71659, 22061, 22084, 72188, 78581, 22376, 80214, 80175, 78582, 22378, 80215, 
80178, 78544, 22330, 22377, 80177
27208, 71659, 22061, 22084, 72188, 71660, 22062, 22085, 72189, 78582, 22378, 80215, 80178, 78583, 22380, 80216, 
80181, 78547, 22332, 22379, 80180
27209, 71660, 22062, 22085, 72189, 71661, 22063, 22086, 72190, 78583, 22380, 80216, 80181, 78584, 22382, 80217, 
80184, 78550, 22334, 22381, 80183
27210, 71661, 22063, 22086, 72190, 71662, 22064, 22087, 72191, 78584, 22382, 80217, 80184, 78585, 22384, 80218, 
80187, 78553, 22336, 22383, 80186
27211, 71662, 22064, 22087, 72191, 71663, 22065, 22088, 72192, 78585, 22384, 80218, 80187, 78586, 22386, 80219, 
80190, 78556, 22338, 22385, 80189
27212, 71663, 22065, 22088, 72192, 71664, 22066, 22089, 72193, 78586, 22386, 80219, 80190, 78587, 22388, 80220, 
80193, 78559, 22340, 22387, 80192
27213, 71664, 22066, 22089, 72193, 71665, 22067, 22090, 72194, 78587, 22388, 80220, 80193, 78588, 22390, 80221, 
80196, 78562, 22342, 22389, 80195
27214, 71665, 22067, 22090, 72194, 22860, 1958, 1959, 22883, 78588, 22390, 80221, 80196, 23137, 1970, 23184, 
23182, 78565, 22344, 22391, 80198
27215, 1608, 17216, 17239, 1609, 21275, 71666, 72195, 21298, 17494, 17540, 17541, 1620, 78591, 80223, 80224, 
21599, 21553, 78589, 80222, 21600
27216, 21275, 71666, 72195, 21298, 21276, 71667, 72196, 21299, 78591, 80223, 80224, 21599, 78594, 80226, 80227, 
21601, 21555, 78592, 80225, 21602
27217, 21276, 71667, 72196, 21299, 21277, 71668, 72197, 21300, 78594, 80226, 80227, 21601, 78597, 80229, 80230, 
21603, 21557, 78595, 80228, 21604
27218, 21277, 71668, 72197, 21300, 21278, 71669, 72198, 21301, 78597, 80229, 80230, 21603, 78600, 80232, 80233, 
21605, 21559, 78598, 80231, 21606
27219, 21278, 71669, 72198, 21301, 21279, 71670, 72199, 21302, 78600, 80232, 80233, 21605, 78603, 80235, 80236, 
21607, 21561, 78601, 80234, 21608
27220, 21279, 71670, 72199, 21302, 21280, 71671, 72200, 21303, 78603, 80235, 80236, 21607, 78606, 80238, 80239, 
21609, 21563, 78604, 80237, 21610
27221, 21280, 71671, 72200, 21303, 21281, 71672, 72201, 21304, 78606, 80238, 80239, 21609, 78609, 80241, 80242, 
21611, 21565, 78607, 80240, 21612
27222, 21281, 71672, 72201, 21304, 21282, 71673, 72202, 21305, 78609, 80241, 80242, 21611, 78612, 80244, 80245, 
21613, 21567, 78610, 80243, 21614
27223, 21282, 71673, 72202, 21305, 21283, 71674, 72203, 21306, 78612, 80244, 80245, 21613, 78615, 80247, 80248, 
21615, 21569, 78613, 80246, 21616
27224, 21283, 71674, 72203, 21306, 21284, 71675, 72204, 21307, 78615, 80247, 80248, 21615, 78618, 80250, 80251, 
21617, 21571, 78616, 80249, 21618
27225, 21284, 71675, 72204, 21307, 21285, 71676, 72205, 21308, 78618, 80250, 80251, 21617, 78621, 80253, 80254, 
21619, 21573, 78619, 80252, 21620
27226, 21285, 71676, 72205, 21308, 21286, 71677, 72206, 21309, 78621, 80253, 80254, 21619, 78624, 80256, 80257, 
21621, 21575, 78622, 80255, 21622
27227, 21286, 71677, 72206, 21309, 21287, 71678, 72207, 21310, 78624, 80256, 80257, 21621, 78627, 80259, 80260, 
21623, 21577, 78625, 80258, 21624
27228, 21287, 71678, 72207, 21310, 21288, 71679, 72208, 21311, 78627, 80259, 80260, 21623, 78630, 80262, 80263, 
21625, 21579, 78628, 80261, 21626
27229, 21288, 71679, 72208, 21311, 21289, 71680, 72209, 21312, 78630, 80262, 80263, 21625, 78633, 80265, 80266, 
21627, 21581, 78631, 80264, 21628
27230, 21289, 71680, 72209, 21312, 21290, 71681, 72210, 21313, 78633, 80265, 80266, 21627, 78636, 80268, 80269, 
21629, 21583, 78634, 80267, 21630
27231, 21290, 71681, 72210, 21313, 21291, 71682, 72211, 21314, 78636, 80268, 80269, 21629, 78639, 80271, 80272, 
21631, 21585, 78637, 80270, 21632
27232, 21291, 71682, 72211, 21314, 21292, 71683, 72212, 21315, 78639, 80271, 80272, 21631, 78642, 80274, 80275, 
21633, 21587, 78640, 80273, 21634
27233, 21292, 71683, 72212, 21315, 21293, 71684, 72213, 21316, 78642, 80274, 80275, 21633, 78645, 80277, 80278, 
21635, 21589, 78643, 80276, 21636
27234, 21293, 71684, 72213, 21316, 21294, 71685, 72214, 21317, 78645, 80277, 80278, 21635, 78648, 80280, 80281, 
21637, 21591, 78646, 80279, 21638
27235, 21294, 71685, 72214, 21317, 21295, 71686, 72215, 21318, 78648, 80280, 80281, 21637, 78651, 80283, 80284, 
21639, 21593, 78649, 80282, 21640
27236, 21295, 71686, 72215, 21318, 21296, 71687, 72216, 21319, 78651, 80283, 80284, 21639, 78654, 80286, 80287, 
21641, 21595, 78652, 80285, 21642
27237, 21296, 71687, 72216, 21319, 21297, 71688, 72217, 21320, 78654, 80286, 80287, 21641, 78657, 80289, 80290, 
21643, 21597, 78655, 80288, 21644
27238, 21297, 71688, 72217, 21320, 1936, 22861, 22884, 1937, 78657, 80289, 80290, 21643, 23139, 23185, 23186, 
1948, 21598, 78658, 80291, 21645
27239, 17216, 17217, 17240, 17239, 71666, 71689, 72218, 72195, 17496, 17542, 17543, 17540, 78661, 80293, 80294, 
80223, 78589, 78659, 80292, 80222
27240, 71666, 71689, 72218, 72195, 71667, 71690, 72219, 72196, 78661, 80293, 80294, 80223, 78664, 80296, 80297, 
80226, 78592, 78662, 80295, 80225
27241, 71667, 71690, 72219, 72196, 71668, 71691, 72220, 72197, 78664, 80296, 80297, 80226, 78667, 80299, 80300, 
80229, 78595, 78665, 80298, 80228
27242, 71668, 71691, 72220, 72197, 71669, 71692, 72221, 72198, 78667, 80299, 80300, 80229, 78670, 80302, 80303, 
80232, 78598, 78668, 80301, 80231
27243, 71669, 71692, 72221, 72198, 71670, 71693, 72222, 72199, 78670, 80302, 80303, 80232, 78673, 80305, 80306, 
80235, 78601, 78671, 80304, 80234
27244, 71670, 71693, 72222, 72199, 71671, 71694, 72223, 72200, 78673, 80305, 80306, 80235, 78676, 80308, 80309, 
80238, 78604, 78674, 80307, 80237
27245, 71671, 71694, 72223, 72200, 71672, 71695, 72224, 72201, 78676, 80308, 80309, 80238, 78679, 80311, 80312, 
80241, 78607, 78677, 80310, 80240
27246, 71672, 71695, 72224, 72201, 71673, 71696, 72225, 72202, 78679, 80311, 80312, 80241, 78682, 80314, 80315, 
80244, 78610, 78680, 80313, 80243
27247, 71673, 71696, 72225, 72202, 71674, 71697, 72226, 72203, 78682, 80314, 80315, 80244, 78685, 80317, 80318, 
80247, 78613, 78683, 80316, 80246
27248, 71674, 71697, 72226, 72203, 71675, 71698, 72227, 72204, 78685, 80317, 80318, 80247, 78688, 80320, 80321, 
80250, 78616, 78686, 80319, 80249
27249, 71675, 71698, 72227, 72204, 71676, 71699, 72228, 72205, 78688, 80320, 80321, 80250, 78691, 80323, 80324, 
80253, 78619, 78689, 80322, 80252
27250, 71676, 71699, 72228, 72205, 71677, 71700, 72229, 72206, 78691, 80323, 80324, 80253, 78694, 80326, 80327, 
80256, 78622, 78692, 80325, 80255
27251, 71677, 71700, 72229, 72206, 71678, 71701, 72230, 72207, 78694, 80326, 80327, 80256, 78697, 80329, 80330, 
80259, 78625, 78695, 80328, 80258
27252, 71678, 71701, 72230, 72207, 71679, 71702, 72231, 72208, 78697, 80329, 80330, 80259, 78700, 80332, 80333, 
80262, 78628, 78698, 80331, 80261
27253, 71679, 71702, 72231, 72208, 71680, 71703, 72232, 72209, 78700, 80332, 80333, 80262, 78703, 80335, 80336, 
80265, 78631, 78701, 80334, 80264
27254, 71680, 71703, 72232, 72209, 71681, 71704, 72233, 72210, 78703, 80335, 80336, 80265, 78706, 80338, 80339, 
80268, 78634, 78704, 80337, 80267
27255, 71681, 71704, 72233, 72210, 71682, 71705, 72234, 72211, 78706, 80338, 80339, 80268, 78709, 80341, 80342, 
80271, 78637, 78707, 80340, 80270
27256, 71682, 71705, 72234, 72211, 71683, 71706, 72235, 72212, 78709, 80341, 80342, 80271, 78712, 80344, 80345, 
80274, 78640, 78710, 80343, 80273
27257, 71683, 71706, 72235, 72212, 71684, 71707, 72236, 72213, 78712, 80344, 80345, 80274, 78715, 80347, 80348, 
80277, 78643, 78713, 80346, 80276
27258, 71684, 71707, 72236, 72213, 71685, 71708, 72237, 72214, 78715, 80347, 80348, 80277, 78718, 80350, 80351, 
80280, 78646, 78716, 80349, 80279
27259, 71685, 71708, 72237, 72214, 71686, 71709, 72238, 72215, 78718, 80350, 80351, 80280, 78721, 80353, 80354, 
80283, 78649, 78719, 80352, 80282
27260, 71686, 71709, 72238, 72215, 71687, 71710, 72239, 72216, 78721, 80353, 80354, 80283, 78724, 80356, 80357, 
80286, 78652, 78722, 80355, 80285
27261, 71687, 71710, 72239, 72216, 71688, 71711, 72240, 72217, 78724, 80356, 80357, 80286, 78727, 80359, 80360, 
80289, 78655, 78725, 80358, 80288
27262, 71688, 71711, 72240, 72217, 22861, 22862, 22885, 22884, 78727, 80359, 80360, 80289, 23141, 23187, 23188, 
23185, 78658, 78728, 80361, 80291
27263, 17217, 17218, 17241, 17240, 71689, 71712, 72241, 72218, 17498, 17544, 17545, 17542, 78731, 80363, 80364, 
80293, 78659, 78729, 80362, 80292
27264, 71689, 71712, 72241, 72218, 71690, 71713, 72242, 72219, 78731, 80363, 80364, 80293, 78734, 80366, 80367, 
80296, 78662, 78732, 80365, 80295
27265, 71690, 71713, 72242, 72219, 71691, 71714, 72243, 72220, 78734, 80366, 80367, 80296, 78737, 80369, 80370, 
80299, 78665, 78735, 80368, 80298
27266, 71691, 71714, 72243, 72220, 71692, 71715, 72244, 72221, 78737, 80369, 80370, 80299, 78740, 80372, 80373, 
80302, 78668, 78738, 80371, 80301
27267, 71692, 71715, 72244, 72221, 71693, 71716, 72245, 72222, 78740, 80372, 80373, 80302, 78743, 80375, 80376, 
80305, 78671, 78741, 80374, 80304
27268, 71693, 71716, 72245, 72222, 71694, 71717, 72246, 72223, 78743, 80375, 80376, 80305, 78746, 80378, 80379, 
80308, 78674, 78744, 80377, 80307
27269, 71694, 71717, 72246, 72223, 71695, 71718, 72247, 72224, 78746, 80378, 80379, 80308, 78749, 80381, 80382, 
80311, 78677, 78747, 80380, 80310
27270, 71695, 71718, 72247, 72224, 71696, 71719, 72248, 72225, 78749, 80381, 80382, 80311, 78752, 80384, 80385, 
80314, 78680, 78750, 80383, 80313
27271, 71696, 71719, 72248, 72225, 71697, 71720, 72249, 72226, 78752, 80384, 80385, 80314, 78755, 80387, 80388, 
80317, 78683, 78753, 80386, 80316
27272, 71697, 71720, 72249, 72226, 71698, 71721, 72250, 72227, 78755, 80387, 80388, 80317, 78758, 80390, 80391, 
80320, 78686, 78756, 80389, 80319
27273, 71698, 71721, 72250, 72227, 71699, 71722, 72251, 72228, 78758, 80390, 80391, 80320, 78761, 80393, 80394, 
80323, 78689, 78759, 80392, 80322
27274, 71699, 71722, 72251, 72228, 71700, 71723, 72252, 72229, 78761, 80393, 80394, 80323, 78764, 80396, 80397, 
80326, 78692, 78762, 80395, 80325
27275, 71700, 71723, 72252, 72229, 71701, 71724, 72253, 72230, 78764, 80396, 80397, 80326, 78767, 80399, 80400, 
80329, 78695, 78765, 80398, 80328
27276, 71701, 71724, 72253, 72230, 71702, 71725, 72254, 72231, 78767, 80399, 80400, 80329, 78770, 80402, 80403, 
80332, 78698, 78768, 80401, 80331
27277, 71702, 71725, 72254, 72231, 71703, 71726, 72255, 72232, 78770, 80402, 80403, 80332, 78773, 80405, 80406, 
80335, 78701, 78771, 80404, 80334
27278, 71703, 71726, 72255, 72232, 71704, 71727, 72256, 72233, 78773, 80405, 80406, 80335, 78776, 80408, 80409, 
80338, 78704, 78774, 80407, 80337
27279, 71704, 71727, 72256, 72233, 71705, 71728, 72257, 72234, 78776, 80408, 80409, 80338, 78779, 80411, 80412, 
80341, 78707, 78777, 80410, 80340
27280, 71705, 71728, 72257, 72234, 71706, 71729, 72258, 72235, 78779, 80411, 80412, 80341, 78782, 80414, 80415, 
80344, 78710, 78780, 80413, 80343
27281, 71706, 71729, 72258, 72235, 71707, 71730, 72259, 72236, 78782, 80414, 80415, 80344, 78785, 80417, 80418, 
80347, 78713, 78783, 80416, 80346
27282, 71707, 71730, 72259, 72236, 71708, 71731, 72260, 72237, 78785, 80417, 80418, 80347, 78788, 80420, 80421, 
80350, 78716, 78786, 80419, 80349
27283, 71708, 71731, 72260, 72237, 71709, 71732, 72261, 72238, 78788, 80420, 80421, 80350, 78791, 80423, 80424, 
80353, 78719, 78789, 80422, 80352
27284, 71709, 71732, 72261, 72238, 71710, 71733, 72262, 72239, 78791, 80423, 80424, 80353, 78794, 80426, 80427, 
80356, 78722, 78792, 80425, 80355
27285, 71710, 71733, 72262, 72239, 71711, 71734, 72263, 72240, 78794, 80426, 80427, 80356, 78797, 80429, 80430, 
80359, 78725, 78795, 80428, 80358
27286, 71711, 71734, 72263, 72240, 22862, 22863, 22886, 22885, 78797, 80429, 80430, 80359, 23143, 23189, 23190, 
23187, 78728, 78798, 80431, 80361
27287, 17218, 17219, 17242, 17241, 71712, 71735, 72264, 72241, 17500, 17546, 17547, 17544, 78801, 80433, 80434, 
80363, 78729, 78799, 80432, 80362
27288, 71712, 71735, 72264, 72241, 71713, 71736, 72265, 72242, 78801, 80433, 80434, 80363, 78804, 80436, 80437, 
80366, 78732, 78802, 80435, 80365
27289, 71713, 71736, 72265, 72242, 71714, 71737, 72266, 72243, 78804, 80436, 80437, 80366, 78807, 80439, 80440, 
80369, 78735, 78805, 80438, 80368
27290, 71714, 71737, 72266, 72243, 71715, 71738, 72267, 72244, 78807, 80439, 80440, 80369, 78810, 80442, 80443, 
80372, 78738, 78808, 80441, 80371
27291, 71715, 71738, 72267, 72244, 71716, 71739, 72268, 72245, 78810, 80442, 80443, 80372, 78813, 80445, 80446, 
80375, 78741, 78811, 80444, 80374
27292, 71716, 71739, 72268, 72245, 71717, 71740, 72269, 72246, 78813, 80445, 80446, 80375, 78816, 80448, 80449, 
80378, 78744, 78814, 80447, 80377
27293, 71717, 71740, 72269, 72246, 71718, 71741, 72270, 72247, 78816, 80448, 80449, 80378, 78819, 80451, 80452, 
80381, 78747, 78817, 80450, 80380
27294, 71718, 71741, 72270, 72247, 71719, 71742, 72271, 72248, 78819, 80451, 80452, 80381, 78822, 80454, 80455, 
80384, 78750, 78820, 80453, 80383
27295, 71719, 71742, 72271, 72248, 71720, 71743, 72272, 72249, 78822, 80454, 80455, 80384, 78825, 80457, 80458, 
80387, 78753, 78823, 80456, 80386
27296, 71720, 71743, 72272, 72249, 71721, 71744, 72273, 72250, 78825, 80457, 80458, 80387, 78828, 80460, 80461, 
80390, 78756, 78826, 80459, 80389
27297, 71721, 71744, 72273, 72250, 71722, 71745, 72274, 72251, 78828, 80460, 80461, 80390, 78831, 80463, 80464, 
80393, 78759, 78829, 80462, 80392
27298, 71722, 71745, 72274, 72251, 71723, 71746, 72275, 72252, 78831, 80463, 80464, 80393, 78834, 80466, 80467, 
80396, 78762, 78832, 80465, 80395
27299, 71723, 71746, 72275, 72252, 71724, 71747, 72276, 72253, 78834, 80466, 80467, 80396, 78837, 80469, 80470, 
80399, 78765, 78835, 80468, 80398
27300, 71724, 71747, 72276, 72253, 71725, 71748, 72277, 72254, 78837, 80469, 80470, 80399, 78840, 80472, 80473, 
80402, 78768, 78838, 80471, 80401
27301, 71725, 71748, 72277, 72254, 71726, 71749, 72278, 72255, 78840, 80472, 80473, 80402, 78843, 80475, 80476, 
80405, 78771, 78841, 80474, 80404
27302, 71726, 71749, 72278, 72255, 71727, 71750, 72279, 72256, 78843, 80475, 80476, 80405, 78846, 80478, 80479, 
80408, 78774, 78844, 80477, 80407
27303, 71727, 71750, 72279, 72256, 71728, 71751, 72280, 72257, 78846, 80478, 80479, 80408, 78849, 80481, 80482, 
80411, 78777, 78847, 80480, 80410
27304, 71728, 71751, 72280, 72257, 71729, 71752, 72281, 72258, 78849, 80481, 80482, 80411, 78852, 80484, 80485, 
80414, 78780, 78850, 80483, 80413
27305, 71729, 71752, 72281, 72258, 71730, 71753, 72282, 72259, 78852, 80484, 80485, 80414, 78855, 80487, 80488, 
80417, 78783, 78853, 80486, 80416
27306, 71730, 71753, 72282, 72259, 71731, 71754, 72283, 72260, 78855, 80487, 80488, 80417, 78858, 80490, 80491, 
80420, 78786, 78856, 80489, 80419
27307, 71731, 71754, 72283, 72260, 71732, 71755, 72284, 72261, 78858, 80490, 80491, 80420, 78861, 80493, 80494, 
80423, 78789, 78859, 80492, 80422
27308, 71732, 71755, 72284, 72261, 71733, 71756, 72285, 72262, 78861, 80493, 80494, 80423, 78864, 80496, 80497, 
80426, 78792, 78862, 80495, 80425
27309, 71733, 71756, 72285, 72262, 71734, 71757, 72286, 72263, 78864, 80496, 80497, 80426, 78867, 80499, 80500, 
80429, 78795, 78865, 80498, 80428
27310, 71734, 71757, 72286, 72263, 22863, 22864, 22887, 22886, 78867, 80499, 80500, 80429, 23145, 23191, 23192, 
23189, 78798, 78868, 80501, 80431
27311, 17219, 17220, 17243, 17242, 71735, 71758, 72287, 72264, 17502, 17548, 17549, 17546, 78871, 80503, 80504, 
80433, 78799, 78869, 80502, 80432
27312, 71735, 71758, 72287, 72264, 71736, 71759, 72288, 72265, 78871, 80503, 80504, 80433, 78874, 80506, 80507, 
80436, 78802, 78872, 80505, 80435
27313, 71736, 71759, 72288, 72265, 71737, 71760, 72289, 72266, 78874, 80506, 80507, 80436, 78877, 80509, 80510, 
80439, 78805, 78875, 80508, 80438
27314, 71737, 71760, 72289, 72266, 71738, 71761, 72290, 72267, 78877, 80509, 80510, 80439, 78880, 80512, 80513, 
80442, 78808, 78878, 80511, 80441
27315, 71738, 71761, 72290, 72267, 71739, 71762, 72291, 72268, 78880, 80512, 80513, 80442, 78883, 80515, 80516, 
80445, 78811, 78881, 80514, 80444
27316, 71739, 71762, 72291, 72268, 71740, 71763, 72292, 72269, 78883, 80515, 80516, 80445, 78886, 80518, 80519, 
80448, 78814, 78884, 80517, 80447
27317, 71740, 71763, 72292, 72269, 71741, 71764, 72293, 72270, 78886, 80518, 80519, 80448, 78889, 80521, 80522, 
80451, 78817, 78887, 80520, 80450
27318, 71741, 71764, 72293, 72270, 71742, 71765, 72294, 72271, 78889, 80521, 80522, 80451, 78892, 80524, 80525, 
80454, 78820, 78890, 80523, 80453
27319, 71742, 71765, 72294, 72271, 71743, 71766, 72295, 72272, 78892, 80524, 80525, 80454, 78895, 80527, 80528, 
80457, 78823, 78893, 80526, 80456
27320, 71743, 71766, 72295, 72272, 71744, 71767, 72296, 72273, 78895, 80527, 80528, 80457, 78898, 80530, 80531, 
80460, 78826, 78896, 80529, 80459
27321, 71744, 71767, 72296, 72273, 71745, 71768, 72297, 72274, 78898, 80530, 80531, 80460, 78901, 80533, 80534, 
80463, 78829, 78899, 80532, 80462
27322, 71745, 71768, 72297, 72274, 71746, 71769, 72298, 72275, 78901, 80533, 80534, 80463, 78904, 80536, 80537, 
80466, 78832, 78902, 80535, 80465
27323, 71746, 71769, 72298, 72275, 71747, 71770, 72299, 72276, 78904, 80536, 80537, 80466, 78907, 80539, 80540, 
80469, 78835, 78905, 80538, 80468
27324, 71747, 71770, 72299, 72276, 71748, 71771, 72300, 72277, 78907, 80539, 80540, 80469, 78910, 80542, 80543, 
80472, 78838, 78908, 80541, 80471
27325, 71748, 71771, 72300, 72277, 71749, 71772, 72301, 72278, 78910, 80542, 80543, 80472, 78913, 80545, 80546, 
80475, 78841, 78911, 80544, 80474
27326, 71749, 71772, 72301, 72278, 71750, 71773, 72302, 72279, 78913, 80545, 80546, 80475, 78916, 80548, 80549, 
80478, 78844, 78914, 80547, 80477
27327, 71750, 71773, 72302, 72279, 71751, 71774, 72303, 72280, 78916, 80548, 80549, 80478, 78919, 80551, 80552, 
80481, 78847, 78917, 80550, 80480
27328, 71751, 71774, 72303, 72280, 71752, 71775, 72304, 72281, 78919, 80551, 80552, 80481, 78922, 80554, 80555, 
80484, 78850, 78920, 80553, 80483
27329, 71752, 71775, 72304, 72281, 71753, 71776, 72305, 72282, 78922, 80554, 80555, 80484, 78925, 80557, 80558, 
80487, 78853, 78923, 80556, 80486
27330, 71753, 71776, 72305, 72282, 71754, 71777, 72306, 72283, 78925, 80557, 80558, 80487, 78928, 80560, 80561, 
80490, 78856, 78926, 80559, 80489
27331, 71754, 71777, 72306, 72283, 71755, 71778, 72307, 72284, 78928, 80560, 80561, 80490, 78931, 80563, 80564, 
80493, 78859, 78929, 80562, 80492
27332, 71755, 71778, 72307, 72284, 71756, 71779, 72308, 72285, 78931, 80563, 80564, 80493, 78934, 80566, 80567, 
80496, 78862, 78932, 80565, 80495
27333, 71756, 71779, 72308, 72285, 71757, 71780, 72309, 72286, 78934, 80566, 80567, 80496, 78937, 80569, 80570, 
80499, 78865, 78935, 80568, 80498
27334, 71757, 71780, 72309, 72286, 22864, 22865, 22888, 22887, 78937, 80569, 80570, 80499, 23147, 23193, 23194, 
23191, 78868, 78938, 80571, 80501
27335, 17220, 17221, 17244, 17243, 71758, 71781, 72310, 72287, 17504, 17550, 17551, 17548, 78941, 80573, 80574, 
80503, 78869, 78939, 80572, 80502
27336, 71758, 71781, 72310, 72287, 71759, 71782, 72311, 72288, 78941, 80573, 80574, 80503, 78944, 80576, 80577, 
80506, 78872, 78942, 80575, 80505
27337, 71759, 71782, 72311, 72288, 71760, 71783, 72312, 72289, 78944, 80576, 80577, 80506, 78947, 80579, 80580, 
80509, 78875, 78945, 80578, 80508
27338, 71760, 71783, 72312, 72289, 71761, 71784, 72313, 72290, 78947, 80579, 80580, 80509, 78950, 80582, 80583, 
80512, 78878, 78948, 80581, 80511
27339, 71761, 71784, 72313, 72290, 71762, 71785, 72314, 72291, 78950, 80582, 80583, 80512, 78953, 80585, 80586, 
80515, 78881, 78951, 80584, 80514
27340, 71762, 71785, 72314, 72291, 71763, 71786, 72315, 72292, 78953, 80585, 80586, 80515, 78956, 80588, 80589, 
80518, 78884, 78954, 80587, 80517
27341, 71763, 71786, 72315, 72292, 71764, 71787, 72316, 72293, 78956, 80588, 80589, 80518, 78959, 80591, 80592, 
80521, 78887, 78957, 80590, 80520
27342, 71764, 71787, 72316, 72293, 71765, 71788, 72317, 72294, 78959, 80591, 80592, 80521, 78962, 80594, 80595, 
80524, 78890, 78960, 80593, 80523
27343, 71765, 71788, 72317, 72294, 71766, 71789, 72318, 72295, 78962, 80594, 80595, 80524, 78965, 80597, 80598, 
80527, 78893, 78963, 80596, 80526
27344, 71766, 71789, 72318, 72295, 71767, 71790, 72319, 72296, 78965, 80597, 80598, 80527, 78968, 80600, 80601, 
80530, 78896, 78966, 80599, 80529
27345, 71767, 71790, 72319, 72296, 71768, 71791, 72320, 72297, 78968, 80600, 80601, 80530, 78971, 80603, 80604, 
80533, 78899, 78969, 80602, 80532
27346, 71768, 71791, 72320, 72297, 71769, 71792, 72321, 72298, 78971, 80603, 80604, 80533, 78974, 80606, 80607, 
80536, 78902, 78972, 80605, 80535
27347, 71769, 71792, 72321, 72298, 71770, 71793, 72322, 72299, 78974, 80606, 80607, 80536, 78977, 80609, 80610, 
80539, 78905, 78975, 80608, 80538
27348, 71770, 71793, 72322, 72299, 71771, 71794, 72323, 72300, 78977, 80609, 80610, 80539, 78980, 80612, 80613, 
80542, 78908, 78978, 80611, 80541
27349, 71771, 71794, 72323, 72300, 71772, 71795, 72324, 72301, 78980, 80612, 80613, 80542, 78983, 80615, 80616, 
80545, 78911, 78981, 80614, 80544
27350, 71772, 71795, 72324, 72301, 71773, 71796, 72325, 72302, 78983, 80615, 80616, 80545, 78986, 80618, 80619, 
80548, 78914, 78984, 80617, 80547
27351, 71773, 71796, 72325, 72302, 71774, 71797, 72326, 72303, 78986, 80618, 80619, 80548, 78989, 80621, 80622, 
80551, 78917, 78987, 80620, 80550
27352, 71774, 71797, 72326, 72303, 71775, 71798, 72327, 72304, 78989, 80621, 80622, 80551, 78992, 80624, 80625, 
80554, 78920, 78990, 80623, 80553
27353, 71775, 71798, 72327, 72304, 71776, 71799, 72328, 72305, 78992, 80624, 80625, 80554, 78995, 80627, 80628, 
80557, 78923, 78993, 80626, 80556
27354, 71776, 71799, 72328, 72305, 71777, 71800, 72329, 72306, 78995, 80627, 80628, 80557, 78998, 80630, 80631, 
80560, 78926, 78996, 80629, 80559
27355, 71777, 71800, 72329, 72306, 71778, 71801, 72330, 72307, 78998, 80630, 80631, 80560, 79001, 80633, 80634, 
80563, 78929, 78999, 80632, 80562
27356, 71778, 71801, 72330, 72307, 71779, 71802, 72331, 72308, 79001, 80633, 80634, 80563, 79004, 80636, 80637, 
80566, 78932, 79002, 80635, 80565
27357, 71779, 71802, 72331, 72308, 71780, 71803, 72332, 72309, 79004, 80636, 80637, 80566, 79007, 80639, 80640, 
80569, 78935, 79005, 80638, 80568
27358, 71780, 71803, 72332, 72309, 22865, 22866, 22889, 22888, 79007, 80639, 80640, 80569, 23149, 23195, 23196, 
23193, 78938, 79008, 80641, 80571
27359, 17221, 17222, 17245, 17244, 71781, 71804, 72333, 72310, 17506, 17552, 17553, 17550, 79011, 80643, 80644, 
80573, 78939, 79009, 80642, 80572
27360, 71781, 71804, 72333, 72310, 71782, 71805, 72334, 72311, 79011, 80643, 80644, 80573, 79014, 80646, 80647, 
80576, 78942, 79012, 80645, 80575
27361, 71782, 71805, 72334, 72311, 71783, 71806, 72335, 72312, 79014, 80646, 80647, 80576, 79017, 80649, 80650, 
80579, 78945, 79015, 80648, 80578
27362, 71783, 71806, 72335, 72312, 71784, 71807, 72336, 72313, 79017, 80649, 80650, 80579, 79020, 80652, 80653, 
80582, 78948, 79018, 80651, 80581
27363, 71784, 71807, 72336, 72313, 71785, 71808, 72337, 72314, 79020, 80652, 80653, 80582, 79023, 80655, 80656, 
80585, 78951, 79021, 80654, 80584
27364, 71785, 71808, 72337, 72314, 71786, 71809, 72338, 72315, 79023, 80655, 80656, 80585, 79026, 80658, 80659, 
80588, 78954, 79024, 80657, 80587
27365, 71786, 71809, 72338, 72315, 71787, 71810, 72339, 72316, 79026, 80658, 80659, 80588, 79029, 80661, 80662, 
80591, 78957, 79027, 80660, 80590
27366, 71787, 71810, 72339, 72316, 71788, 71811, 72340, 72317, 79029, 80661, 80662, 80591, 79032, 80664, 80665, 
80594, 78960, 79030, 80663, 80593
27367, 71788, 71811, 72340, 72317, 71789, 71812, 72341, 72318, 79032, 80664, 80665, 80594, 79035, 80667, 80668, 
80597, 78963, 79033, 80666, 80596
27368, 71789, 71812, 72341, 72318, 71790, 71813, 72342, 72319, 79035, 80667, 80668, 80597, 79038, 80670, 80671, 
80600, 78966, 79036, 80669, 80599
27369, 71790, 71813, 72342, 72319, 71791, 71814, 72343, 72320, 79038, 80670, 80671, 80600, 79041, 80673, 80674, 
80603, 78969, 79039, 80672, 80602
27370, 71791, 71814, 72343, 72320, 71792, 71815, 72344, 72321, 79041, 80673, 80674, 80603, 79044, 80676, 80677, 
80606, 78972, 79042, 80675, 80605
27371, 71792, 71815, 72344, 72321, 71793, 71816, 72345, 72322, 79044, 80676, 80677, 80606, 79047, 80679, 80680, 
80609, 78975, 79045, 80678, 80608
27372, 71793, 71816, 72345, 72322, 71794, 71817, 72346, 72323, 79047, 80679, 80680, 80609, 79050, 80682, 80683, 
80612, 78978, 79048, 80681, 80611
27373, 71794, 71817, 72346, 72323, 71795, 71818, 72347, 72324, 79050, 80682, 80683, 80612, 79053, 80685, 80686, 
80615, 78981, 79051, 80684, 80614
27374, 71795, 71818, 72347, 72324, 71796, 71819, 72348, 72325, 79053, 80685, 80686, 80615, 79056, 80688, 80689, 
80618, 78984, 79054, 80687, 80617
27375, 71796, 71819, 72348, 72325, 71797, 71820, 72349, 72326, 79056, 80688, 80689, 80618, 79059, 80691, 80692, 
80621, 78987, 79057, 80690, 80620
27376, 71797, 71820, 72349, 72326, 71798, 71821, 72350, 72327, 79059, 80691, 80692, 80621, 79062, 80694, 80695, 
80624, 78990, 79060, 80693, 80623
27377, 71798, 71821, 72350, 72327, 71799, 71822, 72351, 72328, 79062, 80694, 80695, 80624, 79065, 80697, 80698, 
80627, 78993, 79063, 80696, 80626
27378, 71799, 71822, 72351, 72328, 71800, 71823, 72352, 72329, 79065, 80697, 80698, 80627, 79068, 80700, 80701, 
80630, 78996, 79066, 80699, 80629
27379, 71800, 71823, 72352, 72329, 71801, 71824, 72353, 72330, 79068, 80700, 80701, 80630, 79071, 80703, 80704, 
80633, 78999, 79069, 80702, 80632
27380, 71801, 71824, 72353, 72330, 71802, 71825, 72354, 72331, 79071, 80703, 80704, 80633, 79074, 80706, 80707, 
80636, 79002, 79072, 80705, 80635
27381, 71802, 71825, 72354, 72331, 71803, 71826, 72355, 72332, 79074, 80706, 80707, 80636, 79077, 80709, 80710, 
80639, 79005, 79075, 80708, 80638
27382, 71803, 71826, 72355, 72332, 22866, 22867, 22890, 22889, 79077, 80709, 80710, 80639, 23151, 23197, 23198, 
23195, 79008, 79078, 80711, 80641
27383, 17222, 17223, 17246, 17245, 71804, 71827, 72356, 72333, 17508, 17554, 17555, 17552, 79081, 80713, 80714, 
80643, 79009, 79079, 80712, 80642
27384, 71804, 71827, 72356, 72333, 71805, 71828, 72357, 72334, 79081, 80713, 80714, 80643, 79084, 80716, 80717, 
80646, 79012, 79082, 80715, 80645
27385, 71805, 71828, 72357, 72334, 71806, 71829, 72358, 72335, 79084, 80716, 80717, 80646, 79087, 80719, 80720, 
80649, 79015, 79085, 80718, 80648
27386, 71806, 71829, 72358, 72335, 71807, 71830, 72359, 72336, 79087, 80719, 80720, 80649, 79090, 80722, 80723, 
80652, 79018, 79088, 80721, 80651
27387, 71807, 71830, 72359, 72336, 71808, 71831, 72360, 72337, 79090, 80722, 80723, 80652, 79093, 80725, 80726, 
80655, 79021, 79091, 80724, 80654
27388, 71808, 71831, 72360, 72337, 71809, 71832, 72361, 72338, 79093, 80725, 80726, 80655, 79096, 80728, 80729, 
80658, 79024, 79094, 80727, 80657
27389, 71809, 71832, 72361, 72338, 71810, 71833, 72362, 72339, 79096, 80728, 80729, 80658, 79099, 80731, 80732, 
80661, 79027, 79097, 80730, 80660
27390, 71810, 71833, 72362, 72339, 71811, 71834, 72363, 72340, 79099, 80731, 80732, 80661, 79102, 80734, 80735, 
80664, 79030, 79100, 80733, 80663
27391, 71811, 71834, 72363, 72340, 71812, 71835, 72364, 72341, 79102, 80734, 80735, 80664, 79105, 80737, 80738, 
80667, 79033, 79103, 80736, 80666
27392, 71812, 71835, 72364, 72341, 71813, 71836, 72365, 72342, 79105, 80737, 80738, 80667, 79108, 80740, 80741, 
80670, 79036, 79106, 80739, 80669
27393, 71813, 71836, 72365, 72342, 71814, 71837, 72366, 72343, 79108, 80740, 80741, 80670, 79111, 80743, 80744, 
80673, 79039, 79109, 80742, 80672
27394, 71814, 71837, 72366, 72343, 71815, 71838, 72367, 72344, 79111, 80743, 80744, 80673, 79114, 80746, 80747, 
80676, 79042, 79112, 80745, 80675
27395, 71815, 71838, 72367, 72344, 71816, 71839, 72368, 72345, 79114, 80746, 80747, 80676, 79117, 80749, 80750, 
80679, 79045, 79115, 80748, 80678
27396, 71816, 71839, 72368, 72345, 71817, 71840, 72369, 72346, 79117, 80749, 80750, 80679, 79120, 80752, 80753, 
80682, 79048, 79118, 80751, 80681
27397, 71817, 71840, 72369, 72346, 71818, 71841, 72370, 72347, 79120, 80752, 80753, 80682, 79123, 80755, 80756, 
80685, 79051, 79121, 80754, 80684
27398, 71818, 71841, 72370, 72347, 71819, 71842, 72371, 72348, 79123, 80755, 80756, 80685, 79126, 80758, 80759, 
80688, 79054, 79124, 80757, 80687
27399, 71819, 71842, 72371, 72348, 71820, 71843, 72372, 72349, 79126, 80758, 80759, 80688, 79129, 80761, 80762, 
80691, 79057, 79127, 80760, 80690
27400, 71820, 71843, 72372, 72349, 71821, 71844, 72373, 72350, 79129, 80761, 80762, 80691, 79132, 80764, 80765, 
80694, 79060, 79130, 80763, 80693
27401, 71821, 71844, 72373, 72350, 71822, 71845, 72374, 72351, 79132, 80764, 80765, 80694, 79135, 80767, 80768, 
80697, 79063, 79133, 80766, 80696
27402, 71822, 71845, 72374, 72351, 71823, 71846, 72375, 72352, 79135, 80767, 80768, 80697, 79138, 80770, 80771, 
80700, 79066, 79136, 80769, 80699
27403, 71823, 71846, 72375, 72352, 71824, 71847, 72376, 72353, 79138, 80770, 80771, 80700, 79141, 80773, 80774, 
80703, 79069, 79139, 80772, 80702
27404, 71824, 71847, 72376, 72353, 71825, 71848, 72377, 72354, 79141, 80773, 80774, 80703, 79144, 80776, 80777, 
80706, 79072, 79142, 80775, 80705
27405, 71825, 71848, 72377, 72354, 71826, 71849, 72378, 72355, 79144, 80776, 80777, 80706, 79147, 80779, 80780, 
80709, 79075, 79145, 80778, 80708
27406, 71826, 71849, 72378, 72355, 22867, 22868, 22891, 22890, 79147, 80779, 80780, 80709, 23153, 23199, 23200, 
23197, 79078, 79148, 80781, 80711
27407, 17223, 17224, 17247, 17246, 71827, 71850, 72379, 72356, 17510, 17556, 17557, 17554, 79151, 80783, 80784, 
80713, 79079, 79149, 80782, 80712
27408, 71827, 71850, 72379, 72356, 71828, 71851, 72380, 72357, 79151, 80783, 80784, 80713, 79154, 80786, 80787, 
80716, 79082, 79152, 80785, 80715
27409, 71828, 71851, 72380, 72357, 71829, 71852, 72381, 72358, 79154, 80786, 80787, 80716, 79157, 80789, 80790, 
80719, 79085, 79155, 80788, 80718
27410, 71829, 71852, 72381, 72358, 71830, 71853, 72382, 72359, 79157, 80789, 80790, 80719, 79160, 80792, 80793, 
80722, 79088, 79158, 80791, 80721
27411, 71830, 71853, 72382, 72359, 71831, 71854, 72383, 72360, 79160, 80792, 80793, 80722, 79163, 80795, 80796, 
80725, 79091, 79161, 80794, 80724
27412, 71831, 71854, 72383, 72360, 71832, 71855, 72384, 72361, 79163, 80795, 80796, 80725, 79166, 80798, 80799, 
80728, 79094, 79164, 80797, 80727
27413, 71832, 71855, 72384, 72361, 71833, 71856, 72385, 72362, 79166, 80798, 80799, 80728, 79169, 80801, 80802, 
80731, 79097, 79167, 80800, 80730
27414, 71833, 71856, 72385, 72362, 71834, 71857, 72386, 72363, 79169, 80801, 80802, 80731, 79172, 80804, 80805, 
80734, 79100, 79170, 80803, 80733
27415, 71834, 71857, 72386, 72363, 71835, 71858, 72387, 72364, 79172, 80804, 80805, 80734, 79175, 80807, 80808, 
80737, 79103, 79173, 80806, 80736
27416, 71835, 71858, 72387, 72364, 71836, 71859, 72388, 72365, 79175, 80807, 80808, 80737, 79178, 80810, 80811, 
80740, 79106, 79176, 80809, 80739
27417, 71836, 71859, 72388, 72365, 71837, 71860, 72389, 72366, 79178, 80810, 80811, 80740, 79181, 80813, 80814, 
80743, 79109, 79179, 80812, 80742
27418, 71837, 71860, 72389, 72366, 71838, 71861, 72390, 72367, 79181, 80813, 80814, 80743, 79184, 80816, 80817, 
80746, 79112, 79182, 80815, 80745
27419, 71838, 71861, 72390, 72367, 71839, 71862, 72391, 72368, 79184, 80816, 80817, 80746, 79187, 80819, 80820, 
80749, 79115, 79185, 80818, 80748
27420, 71839, 71862, 72391, 72368, 71840, 71863, 72392, 72369, 79187, 80819, 80820, 80749, 79190, 80822, 80823, 
80752, 79118, 79188, 80821, 80751
27421, 71840, 71863, 72392, 72369, 71841, 71864, 72393, 72370, 79190, 80822, 80823, 80752, 79193, 80825, 80826, 
80755, 79121, 79191, 80824, 80754
27422, 71841, 71864, 72393, 72370, 71842, 71865, 72394, 72371, 79193, 80825, 80826, 80755, 79196, 80828, 80829, 
80758, 79124, 79194, 80827, 80757
27423, 71842, 71865, 72394, 72371, 71843, 71866, 72395, 72372, 79196, 80828, 80829, 80758, 79199, 80831, 80832, 
80761, 79127, 79197, 80830, 80760
27424, 71843, 71866, 72395, 72372, 71844, 71867, 72396, 72373, 79199, 80831, 80832, 80761, 79202, 80834, 80835, 
80764, 79130, 79200, 80833, 80763
27425, 71844, 71867, 72396, 72373, 71845, 71868, 72397, 72374, 79202, 80834, 80835, 80764, 79205, 80837, 80838, 
80767, 79133, 79203, 80836, 80766
27426, 71845, 71868, 72397, 72374, 71846, 71869, 72398, 72375, 79205, 80837, 80838, 80767, 79208, 80840, 80841, 
80770, 79136, 79206, 80839, 80769
27427, 71846, 71869, 72398, 72375, 71847, 71870, 72399, 72376, 79208, 80840, 80841, 80770, 79211, 80843, 80844, 
80773, 79139, 79209, 80842, 80772
27428, 71847, 71870, 72399, 72376, 71848, 71871, 72400, 72377, 79211, 80843, 80844, 80773, 79214, 80846, 80847, 
80776, 79142, 79212, 80845, 80775
27429, 71848, 71871, 72400, 72377, 71849, 71872, 72401, 72378, 79214, 80846, 80847, 80776, 79217, 80849, 80850, 
80779, 79145, 79215, 80848, 80778
27430, 71849, 71872, 72401, 72378, 22868, 22869, 22892, 22891, 79217, 80849, 80850, 80779, 23155, 23201, 23202, 
23199, 79148, 79218, 80851, 80781
27431, 17224, 17225, 17248, 17247, 71850, 71873, 72402, 72379, 17512, 17558, 17559, 17556, 79221, 80853, 80854, 
80783, 79149, 79219, 80852, 80782
27432, 71850, 71873, 72402, 72379, 71851, 71874, 72403, 72380, 79221, 80853, 80854, 80783, 79224, 80856, 80857, 
80786, 79152, 79222, 80855, 80785
27433, 71851, 71874, 72403, 72380, 71852, 71875, 72404, 72381, 79224, 80856, 80857, 80786, 79227, 80859, 80860, 
80789, 79155, 79225, 80858, 80788
27434, 71852, 71875, 72404, 72381, 71853, 71876, 72405, 72382, 79227, 80859, 80860, 80789, 79230, 80862, 80863, 
80792, 79158, 79228, 80861, 80791
27435, 71853, 71876, 72405, 72382, 71854, 71877, 72406, 72383, 79230, 80862, 80863, 80792, 79233, 80865, 80866, 
80795, 79161, 79231, 80864, 80794
27436, 71854, 71877, 72406, 72383, 71855, 71878, 72407, 72384, 79233, 80865, 80866, 80795, 79236, 80868, 80869, 
80798, 79164, 79234, 80867, 80797
27437, 71855, 71878, 72407, 72384, 71856, 71879, 72408, 72385, 79236, 80868, 80869, 80798, 79239, 80871, 80872, 
80801, 79167, 79237, 80870, 80800
27438, 71856, 71879, 72408, 72385, 71857, 71880, 72409, 72386, 79239, 80871, 80872, 80801, 79242, 80874, 80875, 
80804, 79170, 79240, 80873, 80803
27439, 71857, 71880, 72409, 72386, 71858, 71881, 72410, 72387, 79242, 80874, 80875, 80804, 79245, 80877, 80878, 
80807, 79173, 79243, 80876, 80806
27440, 71858, 71881, 72410, 72387, 71859, 71882, 72411, 72388, 79245, 80877, 80878, 80807, 79248, 80880, 80881, 
80810, 79176, 79246, 80879, 80809
27441, 71859, 71882, 72411, 72388, 71860, 71883, 72412, 72389, 79248, 80880, 80881, 80810, 79251, 80883, 80884, 
80813, 79179, 79249, 80882, 80812
27442, 71860, 71883, 72412, 72389, 71861, 71884, 72413, 72390, 79251, 80883, 80884, 80813, 79254, 80886, 80887, 
80816, 79182, 79252, 80885, 80815
27443, 71861, 71884, 72413, 72390, 71862, 71885, 72414, 72391, 79254, 80886, 80887, 80816, 79257, 80889, 80890, 
80819, 79185, 79255, 80888, 80818
27444, 71862, 71885, 72414, 72391, 71863, 71886, 72415, 72392, 79257, 80889, 80890, 80819, 79260, 80892, 80893, 
80822, 79188, 79258, 80891, 80821
27445, 71863, 71886, 72415, 72392, 71864, 71887, 72416, 72393, 79260, 80892, 80893, 80822, 79263, 80895, 80896, 
80825, 79191, 79261, 80894, 80824
27446, 71864, 71887, 72416, 72393, 71865, 71888, 72417, 72394, 79263, 80895, 80896, 80825, 79266, 80898, 80899, 
80828, 79194, 79264, 80897, 80827
27447, 71865, 71888, 72417, 72394, 71866, 71889, 72418, 72395, 79266, 80898, 80899, 80828, 79269, 80901, 80902, 
80831, 79197, 79267, 80900, 80830
27448, 71866, 71889, 72418, 72395, 71867, 71890, 72419, 72396, 79269, 80901, 80902, 80831, 79272, 80904, 80905, 
80834, 79200, 79270, 80903, 80833
27449, 71867, 71890, 72419, 72396, 71868, 71891, 72420, 72397, 79272, 80904, 80905, 80834, 79275, 80907, 80908, 
80837, 79203, 79273, 80906, 80836
27450, 71868, 71891, 72420, 72397, 71869, 71892, 72421, 72398, 79275, 80907, 80908, 80837, 79278, 80910, 80911, 
80840, 79206, 79276, 80909, 80839
27451, 71869, 71892, 72421, 72398, 71870, 71893, 72422, 72399, 79278, 80910, 80911, 80840, 79281, 80913, 80914, 
80843, 79209, 79279, 80912, 80842
27452, 71870, 71893, 72422, 72399, 71871, 71894, 72423, 72400, 79281, 80913, 80914, 80843, 79284, 80916, 80917, 
80846, 79212, 79282, 80915, 80845
27453, 71871, 71894, 72423, 72400, 71872, 71895, 72424, 72401, 79284, 80916, 80917, 80846, 79287, 80919, 80920, 
80849, 79215, 79285, 80918, 80848
27454, 71872, 71895, 72424, 72401, 22869, 22870, 22893, 22892, 79287, 80919, 80920, 80849, 23157, 23203, 23204, 
23201, 79218, 79288, 80921, 80851
27455, 17225, 17226, 17249, 17248, 71873, 71896, 72425, 72402, 17514, 17560, 17561, 17558, 79291, 80923, 80924, 
80853, 79219, 79289, 80922, 80852
27456, 71873, 71896, 72425, 72402, 71874, 71897, 72426, 72403, 79291, 80923, 80924, 80853, 79294, 80926, 80927, 
80856, 79222, 79292, 80925, 80855
27457, 71874, 71897, 72426, 72403, 71875, 71898, 72427, 72404, 79294, 80926, 80927, 80856, 79297, 80929, 80930, 
80859, 79225, 79295, 80928, 80858
27458, 71875, 71898, 72427, 72404, 71876, 71899, 72428, 72405, 79297, 80929, 80930, 80859, 79300, 80932, 80933, 
80862, 79228, 79298, 80931, 80861
27459, 71876, 71899, 72428, 72405, 71877, 71900, 72429, 72406, 79300, 80932, 80933, 80862, 79303, 80935, 80936, 
80865, 79231, 79301, 80934, 80864
27460, 71877, 71900, 72429, 72406, 71878, 71901, 72430, 72407, 79303, 80935, 80936, 80865, 79306, 80938, 80939, 
80868, 79234, 79304, 80937, 80867
27461, 71878, 71901, 72430, 72407, 71879, 71902, 72431, 72408, 79306, 80938, 80939, 80868, 79309, 80941, 80942, 
80871, 79237, 79307, 80940, 80870
27462, 71879, 71902, 72431, 72408, 71880, 71903, 72432, 72409, 79309, 80941, 80942, 80871, 79312, 80944, 80945, 
80874, 79240, 79310, 80943, 80873
27463, 71880, 71903, 72432, 72409, 71881, 71904, 72433, 72410, 79312, 80944, 80945, 80874, 79315, 80947, 80948, 
80877, 79243, 79313, 80946, 80876
27464, 71881, 71904, 72433, 72410, 71882, 71905, 72434, 72411, 79315, 80947, 80948, 80877, 79318, 80950, 80951, 
80880, 79246, 79316, 80949, 80879
27465, 71882, 71905, 72434, 72411, 71883, 71906, 72435, 72412, 79318, 80950, 80951, 80880, 79321, 80953, 80954, 
80883, 79249, 79319, 80952, 80882
27466, 71883, 71906, 72435, 72412, 71884, 71907, 72436, 72413, 79321, 80953, 80954, 80883, 79324, 80956, 80957, 
80886, 79252, 79322, 80955, 80885
27467, 71884, 71907, 72436, 72413, 71885, 71908, 72437, 72414, 79324, 80956, 80957, 80886, 79327, 80959, 80960, 
80889, 79255, 79325, 80958, 80888
27468, 71885, 71908, 72437, 72414, 71886, 71909, 72438, 72415, 79327, 80959, 80960, 80889, 79330, 80962, 80963, 
80892, 79258, 79328, 80961, 80891
27469, 71886, 71909, 72438, 72415, 71887, 71910, 72439, 72416, 79330, 80962, 80963, 80892, 79333, 80965, 80966, 
80895, 79261, 79331, 80964, 80894
27470, 71887, 71910, 72439, 72416, 71888, 71911, 72440, 72417, 79333, 80965, 80966, 80895, 79336, 80968, 80969, 
80898, 79264, 79334, 80967, 80897
27471, 71888, 71911, 72440, 72417, 71889, 71912, 72441, 72418, 79336, 80968, 80969, 80898, 79339, 80971, 80972, 
80901, 79267, 79337, 80970, 80900
27472, 71889, 71912, 72441, 72418, 71890, 71913, 72442, 72419, 79339, 80971, 80972, 80901, 79342, 80974, 80975, 
80904, 79270, 79340, 80973, 80903
27473, 71890, 71913, 72442, 72419, 71891, 71914, 72443, 72420, 79342, 80974, 80975, 80904, 79345, 80977, 80978, 
80907, 79273, 79343, 80976, 80906
27474, 71891, 71914, 72443, 72420, 71892, 71915, 72444, 72421, 79345, 80977, 80978, 80907, 79348, 80980, 80981, 
80910, 79276, 79346, 80979, 80909
27475, 71892, 71915, 72444, 72421, 71893, 71916, 72445, 72422, 79348, 80980, 80981, 80910, 79351, 80983, 80984, 
80913, 79279, 79349, 80982, 80912
27476, 71893, 71916, 72445, 72422, 71894, 71917, 72446, 72423, 79351, 80983, 80984, 80913, 79354, 80986, 80987, 
80916, 79282, 79352, 80985, 80915
27477, 71894, 71917, 72446, 72423, 71895, 71918, 72447, 72424, 79354, 80986, 80987, 80916, 79357, 80989, 80990, 
80919, 79285, 79355, 80988, 80918
27478, 71895, 71918, 72447, 72424, 22870, 22871, 22894, 22893, 79357, 80989, 80990, 80919, 23159, 23205, 23206, 
23203, 79288, 79358, 80991, 80921
27479, 17226, 17227, 17250, 17249, 71896, 71919, 72448, 72425, 17516, 17562, 17563, 17560, 79361, 80993, 80994, 
80923, 79289, 79359, 80992, 80922
27480, 71896, 71919, 72448, 72425, 71897, 71920, 72449, 72426, 79361, 80993, 80994, 80923, 79364, 80996, 80997, 
80926, 79292, 79362, 80995, 80925
27481, 71897, 71920, 72449, 72426, 71898, 71921, 72450, 72427, 79364, 80996, 80997, 80926, 79367, 80999, 81000, 
80929, 79295, 79365, 80998, 80928
27482, 71898, 71921, 72450, 72427, 71899, 71922, 72451, 72428, 79367, 80999, 81000, 80929, 79370, 81002, 81003, 
80932, 79298, 79368, 81001, 80931
27483, 71899, 71922, 72451, 72428, 71900, 71923, 72452, 72429, 79370, 81002, 81003, 80932, 79373, 81005, 81006, 
80935, 79301, 79371, 81004, 80934
27484, 71900, 71923, 72452, 72429, 71901, 71924, 72453, 72430, 79373, 81005, 81006, 80935, 79376, 81008, 81009, 
80938, 79304, 79374, 81007, 80937
27485, 71901, 71924, 72453, 72430, 71902, 71925, 72454, 72431, 79376, 81008, 81009, 80938, 79379, 81011, 81012, 
80941, 79307, 79377, 81010, 80940
27486, 71902, 71925, 72454, 72431, 71903, 71926, 72455, 72432, 79379, 81011, 81012, 80941, 79382, 81014, 81015, 
80944, 79310, 79380, 81013, 80943
27487, 71903, 71926, 72455, 72432, 71904, 71927, 72456, 72433, 79382, 81014, 81015, 80944, 79385, 81017, 81018, 
80947, 79313, 79383, 81016, 80946
27488, 71904, 71927, 72456, 72433, 71905, 71928, 72457, 72434, 79385, 81017, 81018, 80947, 79388, 81020, 81021, 
80950, 79316, 79386, 81019, 80949
27489, 71905, 71928, 72457, 72434, 71906, 71929, 72458, 72435, 79388, 81020, 81021, 80950, 79391, 81023, 81024, 
80953, 79319, 79389, 81022, 80952
27490, 71906, 71929, 72458, 72435, 71907, 71930, 72459, 72436, 79391, 81023, 81024, 80953, 79394, 81026, 81027, 
80956, 79322, 79392, 81025, 80955
27491, 71907, 71930, 72459, 72436, 71908, 71931, 72460, 72437, 79394, 81026, 81027, 80956, 79397, 81029, 81030, 
80959, 79325, 79395, 81028, 80958
27492, 71908, 71931, 72460, 72437, 71909, 71932, 72461, 72438, 79397, 81029, 81030, 80959, 79400, 81032, 81033, 
80962, 79328, 79398, 81031, 80961
27493, 71909, 71932, 72461, 72438, 71910, 71933, 72462, 72439, 79400, 81032, 81033, 80962, 79403, 81035, 81036, 
80965, 79331, 79401, 81034, 80964
27494, 71910, 71933, 72462, 72439, 71911, 71934, 72463, 72440, 79403, 81035, 81036, 80965, 79406, 81038, 81039, 
80968, 79334, 79404, 81037, 80967
27495, 71911, 71934, 72463, 72440, 71912, 71935, 72464, 72441, 79406, 81038, 81039, 80968, 79409, 81041, 81042, 
80971, 79337, 79407, 81040, 80970
27496, 71912, 71935, 72464, 72441, 71913, 71936, 72465, 72442, 79409, 81041, 81042, 80971, 79412, 81044, 81045, 
80974, 79340, 79410, 81043, 80973
27497, 71913, 71936, 72465, 72442, 71914, 71937, 72466, 72443, 79412, 81044, 81045, 80974, 79415, 81047, 81048, 
80977, 79343, 79413, 81046, 80976
27498, 71914, 71937, 72466, 72443, 71915, 71938, 72467, 72444, 79415, 81047, 81048, 80977, 79418, 81050, 81051, 
80980, 79346, 79416, 81049, 80979
27499, 71915, 71938, 72467, 72444, 71916, 71939, 72468, 72445, 79418, 81050, 81051, 80980, 79421, 81053, 81054, 
80983, 79349, 79419, 81052, 80982
27500, 71916, 71939, 72468, 72445, 71917, 71940, 72469, 72446, 79421, 81053, 81054, 80983, 79424, 81056, 81057, 
80986, 79352, 79422, 81055, 80985
27501, 71917, 71940, 72469, 72446, 71918, 71941, 72470, 72447, 79424, 81056, 81057, 80986, 79427, 81059, 81060, 
80989, 79355, 79425, 81058, 80988
27502, 71918, 71941, 72470, 72447, 22871, 22872, 22895, 22894, 79427, 81059, 81060, 80989, 23161, 23207, 23208, 
23205, 79358, 79428, 81061, 80991
27503, 17227, 17228, 17251, 17250, 71919, 71942, 72471, 72448, 17518, 17564, 17565, 17562, 79431, 81063, 81064, 
80993, 79359, 79429, 81062, 80992
27504, 71919, 71942, 72471, 72448, 71920, 71943, 72472, 72449, 79431, 81063, 81064, 80993, 79434, 81066, 81067, 
80996, 79362, 79432, 81065, 80995
27505, 71920, 71943, 72472, 72449, 71921, 71944, 72473, 72450, 79434, 81066, 81067, 80996, 79437, 81069, 81070, 
80999, 79365, 79435, 81068, 80998
27506, 71921, 71944, 72473, 72450, 71922, 71945, 72474, 72451, 79437, 81069, 81070, 80999, 79440, 81072, 81073, 
81002, 79368, 79438, 81071, 81001
27507, 71922, 71945, 72474, 72451, 71923, 71946, 72475, 72452, 79440, 81072, 81073, 81002, 79443, 81075, 81076, 
81005, 79371, 79441, 81074, 81004
27508, 71923, 71946, 72475, 72452, 71924, 71947, 72476, 72453, 79443, 81075, 81076, 81005, 79446, 81078, 81079, 
81008, 79374, 79444, 81077, 81007
27509, 71924, 71947, 72476, 72453, 71925, 71948, 72477, 72454, 79446, 81078, 81079, 81008, 79449, 81081, 81082, 
81011, 79377, 79447, 81080, 81010
27510, 71925, 71948, 72477, 72454, 71926, 71949, 72478, 72455, 79449, 81081, 81082, 81011, 79452, 81084, 81085, 
81014, 79380, 79450, 81083, 81013
27511, 71926, 71949, 72478, 72455, 71927, 71950, 72479, 72456, 79452, 81084, 81085, 81014, 79455, 81087, 81088, 
81017, 79383, 79453, 81086, 81016
27512, 71927, 71950, 72479, 72456, 71928, 71951, 72480, 72457, 79455, 81087, 81088, 81017, 79458, 81090, 81091, 
81020, 79386, 79456, 81089, 81019
27513, 71928, 71951, 72480, 72457, 71929, 71952, 72481, 72458, 79458, 81090, 81091, 81020, 79461, 81093, 81094, 
81023, 79389, 79459, 81092, 81022
27514, 71929, 71952, 72481, 72458, 71930, 71953, 72482, 72459, 79461, 81093, 81094, 81023, 79464, 81096, 81097, 
81026, 79392, 79462, 81095, 81025
27515, 71930, 71953, 72482, 72459, 71931, 71954, 72483, 72460, 79464, 81096, 81097, 81026, 79467, 81099, 81100, 
81029, 79395, 79465, 81098, 81028
27516, 71931, 71954, 72483, 72460, 71932, 71955, 72484, 72461, 79467, 81099, 81100, 81029, 79470, 81102, 81103, 
81032, 79398, 79468, 81101, 81031
27517, 71932, 71955, 72484, 72461, 71933, 71956, 72485, 72462, 79470, 81102, 81103, 81032, 79473, 81105, 81106, 
81035, 79401, 79471, 81104, 81034
27518, 71933, 71956, 72485, 72462, 71934, 71957, 72486, 72463, 79473, 81105, 81106, 81035, 79476, 81108, 81109, 
81038, 79404, 79474, 81107, 81037
27519, 71934, 71957, 72486, 72463, 71935, 71958, 72487, 72464, 79476, 81108, 81109, 81038, 79479, 81111, 81112, 
81041, 79407, 79477, 81110, 81040
27520, 71935, 71958, 72487, 72464, 71936, 71959, 72488, 72465, 79479, 81111, 81112, 81041, 79482, 81114, 81115, 
81044, 79410, 79480, 81113, 81043
27521, 71936, 71959, 72488, 72465, 71937, 71960, 72489, 72466, 79482, 81114, 81115, 81044, 79485, 81117, 81118, 
81047, 79413, 79483, 81116, 81046
27522, 71937, 71960, 72489, 72466, 71938, 71961, 72490, 72467, 79485, 81117, 81118, 81047, 79488, 81120, 81121, 
81050, 79416, 79486, 81119, 81049
27523, 71938, 71961, 72490, 72467, 71939, 71962, 72491, 72468, 79488, 81120, 81121, 81050, 79491, 81123, 81124, 
81053, 79419, 79489, 81122, 81052
27524, 71939, 71962, 72491, 72468, 71940, 71963, 72492, 72469, 79491, 81123, 81124, 81053, 79494, 81126, 81127, 
81056, 79422, 79492, 81125, 81055
27525, 71940, 71963, 72492, 72469, 71941, 71964, 72493, 72470, 79494, 81126, 81127, 81056, 79497, 81129, 81130, 
81059, 79425, 79495, 81128, 81058
27526, 71941, 71964, 72493, 72470, 22872, 22873, 22896, 22895, 79497, 81129, 81130, 81059, 23163, 23209, 23210, 
23207, 79428, 79498, 81131, 81061
27527, 17228, 17229, 17252, 17251, 71942, 71965, 72494, 72471, 17520, 17566, 17567, 17564, 79501, 81133, 81134, 
81063, 79429, 79499, 81132, 81062
27528, 71942, 71965, 72494, 72471, 71943, 71966, 72495, 72472, 79501, 81133, 81134, 81063, 79504, 81136, 81137, 
81066, 79432, 79502, 81135, 81065
27529, 71943, 71966, 72495, 72472, 71944, 71967, 72496, 72473, 79504, 81136, 81137, 81066, 79507, 81139, 81140, 
81069, 79435, 79505, 81138, 81068
27530, 71944, 71967, 72496, 72473, 71945, 71968, 72497, 72474, 79507, 81139, 81140, 81069, 79510, 81142, 81143, 
81072, 79438, 79508, 81141, 81071
27531, 71945, 71968, 72497, 72474, 71946, 71969, 72498, 72475, 79510, 81142, 81143, 81072, 79513, 81145, 81146, 
81075, 79441, 79511, 81144, 81074
27532, 71946, 71969, 72498, 72475, 71947, 71970, 72499, 72476, 79513, 81145, 81146, 81075, 79516, 81148, 81149, 
81078, 79444, 79514, 81147, 81077
27533, 71947, 71970, 72499, 72476, 71948, 71971, 72500, 72477, 79516, 81148, 81149, 81078, 79519, 81151, 81152, 
81081, 79447, 79517, 81150, 81080
27534, 71948, 71971, 72500, 72477, 71949, 71972, 72501, 72478, 79519, 81151, 81152, 81081, 79522, 81154, 81155, 
81084, 79450, 79520, 81153, 81083
27535, 71949, 71972, 72501, 72478, 71950, 71973, 72502, 72479, 79522, 81154, 81155, 81084, 79525, 81157, 81158, 
81087, 79453, 79523, 81156, 81086
27536, 71950, 71973, 72502, 72479, 71951, 71974, 72503, 72480, 79525, 81157, 81158, 81087, 79528, 81160, 81161, 
81090, 79456, 79526, 81159, 81089
27537, 71951, 71974, 72503, 72480, 71952, 71975, 72504, 72481, 79528, 81160, 81161, 81090, 79531, 81163, 81164, 
81093, 79459, 79529, 81162, 81092
27538, 71952, 71975, 72504, 72481, 71953, 71976, 72505, 72482, 79531, 81163, 81164, 81093, 79534, 81166, 81167, 
81096, 79462, 79532, 81165, 81095
27539, 71953, 71976, 72505, 72482, 71954, 71977, 72506, 72483, 79534, 81166, 81167, 81096, 79537, 81169, 81170, 
81099, 79465, 79535, 81168, 81098
27540, 71954, 71977, 72506, 72483, 71955, 71978, 72507, 72484, 79537, 81169, 81170, 81099, 79540, 81172, 81173, 
81102, 79468, 79538, 81171, 81101
27541, 71955, 71978, 72507, 72484, 71956, 71979, 72508, 72485, 79540, 81172, 81173, 81102, 79543, 81175, 81176, 
81105, 79471, 79541, 81174, 81104
27542, 71956, 71979, 72508, 72485, 71957, 71980, 72509, 72486, 79543, 81175, 81176, 81105, 79546, 81178, 81179, 
81108, 79474, 79544, 81177, 81107
27543, 71957, 71980, 72509, 72486, 71958, 71981, 72510, 72487, 79546, 81178, 81179, 81108, 79549, 81181, 81182, 
81111, 79477, 79547, 81180, 81110
27544, 71958, 71981, 72510, 72487, 71959, 71982, 72511, 72488, 79549, 81181, 81182, 81111, 79552, 81184, 81185, 
81114, 79480, 79550, 81183, 81113
27545, 71959, 71982, 72511, 72488, 71960, 71983, 72512, 72489, 79552, 81184, 81185, 81114, 79555, 81187, 81188, 
81117, 79483, 79553, 81186, 81116
27546, 71960, 71983, 72512, 72489, 71961, 71984, 72513, 72490, 79555, 81187, 81188, 81117, 79558, 81190, 81191, 
81120, 79486, 79556, 81189, 81119
27547, 71961, 71984, 72513, 72490, 71962, 71985, 72514, 72491, 79558, 81190, 81191, 81120, 79561, 81193, 81194, 
81123, 79489, 79559, 81192, 81122
27548, 71962, 71985, 72514, 72491, 71963, 71986, 72515, 72492, 79561, 81193, 81194, 81123, 79564, 81196, 81197, 
81126, 79492, 79562, 81195, 81125
27549, 71963, 71986, 72515, 72492, 71964, 71987, 72516, 72493, 79564, 81196, 81197, 81126, 79567, 81199, 81200, 
81129, 79495, 79565, 81198, 81128
27550, 71964, 71987, 72516, 72493, 22873, 22874, 22897, 22896, 79567, 81199, 81200, 81129, 23165, 23211, 23212, 
23209, 79498, 79568, 81201, 81131
27551, 17229, 17230, 17253, 17252, 71965, 71988, 72517, 72494, 17522, 17568, 17569, 17566, 79571, 81203, 81204, 
81133, 79499, 79569, 81202, 81132
27552, 71965, 71988, 72517, 72494, 71966, 71989, 72518, 72495, 79571, 81203, 81204, 81133, 79574, 81206, 81207, 
81136, 79502, 79572, 81205, 81135
27553, 71966, 71989, 72518, 72495, 71967, 71990, 72519, 72496, 79574, 81206, 81207, 81136, 79577, 81209, 81210, 
81139, 79505, 79575, 81208, 81138
27554, 71967, 71990, 72519, 72496, 71968, 71991, 72520, 72497, 79577, 81209, 81210, 81139, 79580, 81212, 81213, 
81142, 79508, 79578, 81211, 81141
27555, 71968, 71991, 72520, 72497, 71969, 71992, 72521, 72498, 79580, 81212, 81213, 81142, 79583, 81215, 81216, 
81145, 79511, 79581, 81214, 81144
27556, 71969, 71992, 72521, 72498, 71970, 71993, 72522, 72499, 79583, 81215, 81216, 81145, 79586, 81218, 81219, 
81148, 79514, 79584, 81217, 81147
27557, 71970, 71993, 72522, 72499, 71971, 71994, 72523, 72500, 79586, 81218, 81219, 81148, 79589, 81221, 81222, 
81151, 79517, 79587, 81220, 81150
27558, 71971, 71994, 72523, 72500, 71972, 71995, 72524, 72501, 79589, 81221, 81222, 81151, 79592, 81224, 81225, 
81154, 79520, 79590, 81223, 81153
27559, 71972, 71995, 72524, 72501, 71973, 71996, 72525, 72502, 79592, 81224, 81225, 81154, 79595, 81227, 81228, 
81157, 79523, 79593, 81226, 81156
27560, 71973, 71996, 72525, 72502, 71974, 71997, 72526, 72503, 79595, 81227, 81228, 81157, 79598, 81230, 81231, 
81160, 79526, 79596, 81229, 81159
27561, 71974, 71997, 72526, 72503, 71975, 71998, 72527, 72504, 79598, 81230, 81231, 81160, 79601, 81233, 81234, 
81163, 79529, 79599, 81232, 81162
27562, 71975, 71998, 72527, 72504, 71976, 71999, 72528, 72505, 79601, 81233, 81234, 81163, 79604, 81236, 81237, 
81166, 79532, 79602, 81235, 81165
27563, 71976, 71999, 72528, 72505, 71977, 72000, 72529, 72506, 79604, 81236, 81237, 81166, 79607, 81239, 81240, 
81169, 79535, 79605, 81238, 81168
27564, 71977, 72000, 72529, 72506, 71978, 72001, 72530, 72507, 79607, 81239, 81240, 81169, 79610, 81242, 81243, 
81172, 79538, 79608, 81241, 81171
27565, 71978, 72001, 72530, 72507, 71979, 72002, 72531, 72508, 79610, 81242, 81243, 81172, 79613, 81245, 81246, 
81175, 79541, 79611, 81244, 81174
27566, 71979, 72002, 72531, 72508, 71980, 72003, 72532, 72509, 79613, 81245, 81246, 81175, 79616, 81248, 81249, 
81178, 79544, 79614, 81247, 81177
27567, 71980, 72003, 72532, 72509, 71981, 72004, 72533, 72510, 79616, 81248, 81249, 81178, 79619, 81251, 81252, 
81181, 79547, 79617, 81250, 81180
27568, 71981, 72004, 72533, 72510, 71982, 72005, 72534, 72511, 79619, 81251, 81252, 81181, 79622, 81254, 81255, 
81184, 79550, 79620, 81253, 81183
27569, 71982, 72005, 72534, 72511, 71983, 72006, 72535, 72512, 79622, 81254, 81255, 81184, 79625, 81257, 81258, 
81187, 79553, 79623, 81256, 81186
27570, 71983, 72006, 72535, 72512, 71984, 72007, 72536, 72513, 79625, 81257, 81258, 81187, 79628, 81260, 81261, 
81190, 79556, 79626, 81259, 81189
27571, 71984, 72007, 72536, 72513, 71985, 72008, 72537, 72514, 79628, 81260, 81261, 81190, 79631, 81263, 81264, 
81193, 79559, 79629, 81262, 81192
27572, 71985, 72008, 72537, 72514, 71986, 72009, 72538, 72515, 79631, 81263, 81264, 81193, 79634, 81266, 81267, 
81196, 79562, 79632, 81265, 81195
27573, 71986, 72009, 72538, 72515, 71987, 72010, 72539, 72516, 79634, 81266, 81267, 81196, 79637, 81269, 81270, 
81199, 79565, 79635, 81268, 81198
27574, 71987, 72010, 72539, 72516, 22874, 22875, 22898, 22897, 79637, 81269, 81270, 81199, 23167, 23213, 23214, 
23211, 79568, 79638, 81271, 81201
27575, 17230, 17231, 17254, 17253, 71988, 72011, 72540, 72517, 17524, 17570, 17571, 17568, 79641, 81273, 81274, 
81203, 79569, 79639, 81272, 81202
27576, 71988, 72011, 72540, 72517, 71989, 72012, 72541, 72518, 79641, 81273, 81274, 81203, 79644, 81276, 81277, 
81206, 79572, 79642, 81275, 81205
27577, 71989, 72012, 72541, 72518, 71990, 72013, 72542, 72519, 79644, 81276, 81277, 81206, 79647, 81279, 81280, 
81209, 79575, 79645, 81278, 81208
27578, 71990, 72013, 72542, 72519, 71991, 72014, 72543, 72520, 79647, 81279, 81280, 81209, 79650, 81282, 81283, 
81212, 79578, 79648, 81281, 81211
27579, 71991, 72014, 72543, 72520, 71992, 72015, 72544, 72521, 79650, 81282, 81283, 81212, 79653, 81285, 81286, 
81215, 79581, 79651, 81284, 81214
27580, 71992, 72015, 72544, 72521, 71993, 72016, 72545, 72522, 79653, 81285, 81286, 81215, 79656, 81288, 81289, 
81218, 79584, 79654, 81287, 81217
27581, 71993, 72016, 72545, 72522, 71994, 72017, 72546, 72523, 79656, 81288, 81289, 81218, 79659, 81291, 81292, 
81221, 79587, 79657, 81290, 81220
27582, 71994, 72017, 72546, 72523, 71995, 72018, 72547, 72524, 79659, 81291, 81292, 81221, 79662, 81294, 81295, 
81224, 79590, 79660, 81293, 81223
27583, 71995, 72018, 72547, 72524, 71996, 72019, 72548, 72525, 79662, 81294, 81295, 81224, 79665, 81297, 81298, 
81227, 79593, 79663, 81296, 81226
27584, 71996, 72019, 72548, 72525, 71997, 72020, 72549, 72526, 79665, 81297, 81298, 81227, 79668, 81300, 81301, 
81230, 79596, 79666, 81299, 81229
27585, 71997, 72020, 72549, 72526, 71998, 72021, 72550, 72527, 79668, 81300, 81301, 81230, 79671, 81303, 81304, 
81233, 79599, 79669, 81302, 81232
27586, 71998, 72021, 72550, 72527, 71999, 72022, 72551, 72528, 79671, 81303, 81304, 81233, 79674, 81306, 81307, 
81236, 79602, 79672, 81305, 81235
27587, 71999, 72022, 72551, 72528, 72000, 72023, 72552, 72529, 79674, 81306, 81307, 81236, 79677, 81309, 81310, 
81239, 79605, 79675, 81308, 81238
27588, 72000, 72023, 72552, 72529, 72001, 72024, 72553, 72530, 79677, 81309, 81310, 81239, 79680, 81312, 81313, 
81242, 79608, 79678, 81311, 81241
27589, 72001, 72024, 72553, 72530, 72002, 72025, 72554, 72531, 79680, 81312, 81313, 81242, 79683, 81315, 81316, 
81245, 79611, 79681, 81314, 81244
27590, 72002, 72025, 72554, 72531, 72003, 72026, 72555, 72532, 79683, 81315, 81316, 81245, 79686, 81318, 81319, 
81248, 79614, 79684, 81317, 81247
27591, 72003, 72026, 72555, 72532, 72004, 72027, 72556, 72533, 79686, 81318, 81319, 81248, 79689, 81321, 81322, 
81251, 79617, 79687, 81320, 81250
27592, 72004, 72027, 72556, 72533, 72005, 72028, 72557, 72534, 79689, 81321, 81322, 81251, 79692, 81324, 81325, 
81254, 79620, 79690, 81323, 81253
27593, 72005, 72028, 72557, 72534, 72006, 72029, 72558, 72535, 79692, 81324, 81325, 81254, 79695, 81327, 81328, 
81257, 79623, 79693, 81326, 81256
27594, 72006, 72029, 72558, 72535, 72007, 72030, 72559, 72536, 79695, 81327, 81328, 81257, 79698, 81330, 81331, 
81260, 79626, 79696, 81329, 81259
27595, 72007, 72030, 72559, 72536, 72008, 72031, 72560, 72537, 79698, 81330, 81331, 81260, 79701, 81333, 81334, 
81263, 79629, 79699, 81332, 81262
27596, 72008, 72031, 72560, 72537, 72009, 72032, 72561, 72538, 79701, 81333, 81334, 81263, 79704, 81336, 81337, 
81266, 79632, 79702, 81335, 81265
27597, 72009, 72032, 72561, 72538, 72010, 72033, 72562, 72539, 79704, 81336, 81337, 81266, 79707, 81339, 81340, 
81269, 79635, 79705, 81338, 81268
27598, 72010, 72033, 72562, 72539, 22875, 22876, 22899, 22898, 79707, 81339, 81340, 81269, 23169, 23215, 23216, 
23213, 79638, 79708, 81341, 81271
27599, 17231, 17232, 17255, 17254, 72011, 72034, 72563, 72540, 17526, 17572, 17573, 17570, 79711, 81343, 81344, 
81273, 79639, 79709, 81342, 81272
27600, 72011, 72034, 72563, 72540, 72012, 72035, 72564, 72541, 79711, 81343, 81344, 81273, 79714, 81346, 81347, 
81276, 79642, 79712, 81345, 81275
27601, 72012, 72035, 72564, 72541, 72013, 72036, 72565, 72542, 79714, 81346, 81347, 81276, 79717, 81349, 81350, 
81279, 79645, 79715, 81348, 81278
27602, 72013, 72036, 72565, 72542, 72014, 72037, 72566, 72543, 79717, 81349, 81350, 81279, 79720, 81352, 81353, 
81282, 79648, 79718, 81351, 81281
27603, 72014, 72037, 72566, 72543, 72015, 72038, 72567, 72544, 79720, 81352, 81353, 81282, 79723, 81355, 81356, 
81285, 79651, 79721, 81354, 81284
27604, 72015, 72038, 72567, 72544, 72016, 72039, 72568, 72545, 79723, 81355, 81356, 81285, 79726, 81358, 81359, 
81288, 79654, 79724, 81357, 81287
27605, 72016, 72039, 72568, 72545, 72017, 72040, 72569, 72546, 79726, 81358, 81359, 81288, 79729, 81361, 81362, 
81291, 79657, 79727, 81360, 81290
27606, 72017, 72040, 72569, 72546, 72018, 72041, 72570, 72547, 79729, 81361, 81362, 81291, 79732, 81364, 81365, 
81294, 79660, 79730, 81363, 81293
27607, 72018, 72041, 72570, 72547, 72019, 72042, 72571, 72548, 79732, 81364, 81365, 81294, 79735, 81367, 81368, 
81297, 79663, 79733, 81366, 81296
27608, 72019, 72042, 72571, 72548, 72020, 72043, 72572, 72549, 79735, 81367, 81368, 81297, 79738, 81370, 81371, 
81300, 79666, 79736, 81369, 81299
27609, 72020, 72043, 72572, 72549, 72021, 72044, 72573, 72550, 79738, 81370, 81371, 81300, 79741, 81373, 81374, 
81303, 79669, 79739, 81372, 81302
27610, 72021, 72044, 72573, 72550, 72022, 72045, 72574, 72551, 79741, 81373, 81374, 81303, 79744, 81376, 81377, 
81306, 79672, 79742, 81375, 81305
27611, 72022, 72045, 72574, 72551, 72023, 72046, 72575, 72552, 79744, 81376, 81377, 81306, 79747, 81379, 81380, 
81309, 79675, 79745, 81378, 81308
27612, 72023, 72046, 72575, 72552, 72024, 72047, 72576, 72553, 79747, 81379, 81380, 81309, 79750, 81382, 81383, 
81312, 79678, 79748, 81381, 81311
27613, 72024, 72047, 72576, 72553, 72025, 72048, 72577, 72554, 79750, 81382, 81383, 81312, 79753, 81385, 81386, 
81315, 79681, 79751, 81384, 81314
27614, 72025, 72048, 72577, 72554, 72026, 72049, 72578, 72555, 79753, 81385, 81386, 81315, 79756, 81388, 81389, 
81318, 79684, 79754, 81387, 81317
27615, 72026, 72049, 72578, 72555, 72027, 72050, 72579, 72556, 79756, 81388, 81389, 81318, 79759, 81391, 81392, 
81321, 79687, 79757, 81390, 81320
27616, 72027, 72050, 72579, 72556, 72028, 72051, 72580, 72557, 79759, 81391, 81392, 81321, 79762, 81394, 81395, 
81324, 79690, 79760, 81393, 81323
27617, 72028, 72051, 72580, 72557, 72029, 72052, 72581, 72558, 79762, 81394, 81395, 81324, 79765, 81397, 81398, 
81327, 79693, 79763, 81396, 81326
27618, 72029, 72052, 72581, 72558, 72030, 72053, 72582, 72559, 79765, 81397, 81398, 81327, 79768, 81400, 81401, 
81330, 79696, 79766, 81399, 81329
27619, 72030, 72053, 72582, 72559, 72031, 72054, 72583, 72560, 79768, 81400, 81401, 81330, 79771, 81403, 81404, 
81333, 79699, 79769, 81402, 81332
27620, 72031, 72054, 72583, 72560, 72032, 72055, 72584, 72561, 79771, 81403, 81404, 81333, 79774, 81406, 81407, 
81336, 79702, 79772, 81405, 81335
27621, 72032, 72055, 72584, 72561, 72033, 72056, 72585, 72562, 79774, 81406, 81407, 81336, 79777, 81409, 81410, 
81339, 79705, 79775, 81408, 81338
27622, 72033, 72056, 72585, 72562, 22876, 22877, 22900, 22899, 79777, 81409, 81410, 81339, 23171, 23217, 23218, 
23215, 79708, 79778, 81411, 81341
27623, 17232, 17233, 17256, 17255, 72034, 72057, 72586, 72563, 17528, 17574, 17575, 17572, 79781, 81413, 81414, 
81343, 79709, 79779, 81412, 81342
27624, 72034, 72057, 72586, 72563, 72035, 72058, 72587, 72564, 79781, 81413, 81414, 81343, 79784, 81416, 81417, 
81346, 79712, 79782, 81415, 81345
27625, 72035, 72058, 72587, 72564, 72036, 72059, 72588, 72565, 79784, 81416, 81417, 81346, 79787, 81419, 81420, 
81349, 79715, 79785, 81418, 81348
27626, 72036, 72059, 72588, 72565, 72037, 72060, 72589, 72566, 79787, 81419, 81420, 81349, 79790, 81422, 81423, 
81352, 79718, 79788, 81421, 81351
27627, 72037, 72060, 72589, 72566, 72038, 72061, 72590, 72567, 79790, 81422, 81423, 81352, 79793, 81425, 81426, 
81355, 79721, 79791, 81424, 81354
27628, 72038, 72061, 72590, 72567, 72039, 72062, 72591, 72568, 79793, 81425, 81426, 81355, 79796, 81428, 81429, 
81358, 79724, 79794, 81427, 81357
27629, 72039, 72062, 72591, 72568, 72040, 72063, 72592, 72569, 79796, 81428, 81429, 81358, 79799, 81431, 81432, 
81361, 79727, 79797, 81430, 81360
27630, 72040, 72063, 72592, 72569, 72041, 72064, 72593, 72570, 79799, 81431, 81432, 81361, 79802, 81434, 81435, 
81364, 79730, 79800, 81433, 81363
27631, 72041, 72064, 72593, 72570, 72042, 72065, 72594, 72571, 79802, 81434, 81435, 81364, 79805, 81437, 81438, 
81367, 79733, 79803, 81436, 81366
27632, 72042, 72065, 72594, 72571, 72043, 72066, 72595, 72572, 79805, 81437, 81438, 81367, 79808, 81440, 81441, 
81370, 79736, 79806, 81439, 81369
27633, 72043, 72066, 72595, 72572, 72044, 72067, 72596, 72573, 79808, 81440, 81441, 81370, 79811, 81443, 81444, 
81373, 79739, 79809, 81442, 81372
27634, 72044, 72067, 72596, 72573, 72045, 72068, 72597, 72574, 79811, 81443, 81444, 81373, 79814, 81446, 81447, 
81376, 79742, 79812, 81445, 81375
27635, 72045, 72068, 72597, 72574, 72046, 72069, 72598, 72575, 79814, 81446, 81447, 81376, 79817, 81449, 81450, 
81379, 79745, 79815, 81448, 81378
27636, 72046, 72069, 72598, 72575, 72047, 72070, 72599, 72576, 79817, 81449, 81450, 81379, 79820, 81452, 81453, 
81382, 79748, 79818, 81451, 81381
27637, 72047, 72070, 72599, 72576, 72048, 72071, 72600, 72577, 79820, 81452, 81453, 81382, 79823, 81455, 81456, 
81385, 79751, 79821, 81454, 81384
27638, 72048, 72071, 72600, 72577, 72049, 72072, 72601, 72578, 79823, 81455, 81456, 81385, 79826, 81458, 81459, 
81388, 79754, 79824, 81457, 81387
27639, 72049, 72072, 72601, 72578, 72050, 72073, 72602, 72579, 79826, 81458, 81459, 81388, 79829, 81461, 81462, 
81391, 79757, 79827, 81460, 81390
27640, 72050, 72073, 72602, 72579, 72051, 72074, 72603, 72580, 79829, 81461, 81462, 81391, 79832, 81464, 81465, 
81394, 79760, 79830, 81463, 81393
27641, 72051, 72074, 72603, 72580, 72052, 72075, 72604, 72581, 79832, 81464, 81465, 81394, 79835, 81467, 81468, 
81397, 79763, 79833, 81466, 81396
27642, 72052, 72075, 72604, 72581, 72053, 72076, 72605, 72582, 79835, 81467, 81468, 81397, 79838, 81470, 81471, 
81400, 79766, 79836, 81469, 81399
27643, 72053, 72076, 72605, 72582, 72054, 72077, 72606, 72583, 79838, 81470, 81471, 81400, 79841, 81473, 81474, 
81403, 79769, 79839, 81472, 81402
27644, 72054, 72077, 72606, 72583, 72055, 72078, 72607, 72584, 79841, 81473, 81474, 81403, 79844, 81476, 81477, 
81406, 79772, 79842, 81475, 81405
27645, 72055, 72078, 72607, 72584, 72056, 72079, 72608, 72585, 79844, 81476, 81477, 81406, 79847, 81479, 81480, 
81409, 79775, 79845, 81478, 81408
27646, 72056, 72079, 72608, 72585, 22877, 22878, 22901, 22900, 79847, 81479, 81480, 81409, 23173, 23219, 23220, 
23217, 79778, 79848, 81481, 81411
27647, 17233, 17234, 17257, 17256, 72057, 72080, 72609, 72586, 17530, 17576, 17577, 17574, 79851, 81483, 81484, 
81413, 79779, 79849, 81482, 81412
27648, 72057, 72080, 72609, 72586, 72058, 72081, 72610, 72587, 79851, 81483, 81484, 81413, 79854, 81486, 81487, 
81416, 79782, 79852, 81485, 81415
27649, 72058, 72081, 72610, 72587, 72059, 72082, 72611, 72588, 79854, 81486, 81487, 81416, 79857, 81489, 81490, 
81419, 79785, 79855, 81488, 81418
27650, 72059, 72082, 72611, 72588, 72060, 72083, 72612, 72589, 79857, 81489, 81490, 81419, 79860, 81492, 81493, 
81422, 79788, 79858, 81491, 81421
27651, 72060, 72083, 72612, 72589, 72061, 72084, 72613, 72590, 79860, 81492, 81493, 81422, 79863, 81495, 81496, 
81425, 79791, 79861, 81494, 81424
27652, 72061, 72084, 72613, 72590, 72062, 72085, 72614, 72591, 79863, 81495, 81496, 81425, 79866, 81498, 81499, 
81428, 79794, 79864, 81497, 81427
27653, 72062, 72085, 72614, 72591, 72063, 72086, 72615, 72592, 79866, 81498, 81499, 81428, 79869, 81501, 81502, 
81431, 79797, 79867, 81500, 81430
27654, 72063, 72086, 72615, 72592, 72064, 72087, 72616, 72593, 79869, 81501, 81502, 81431, 79872, 81504, 81505, 
81434, 79800, 79870, 81503, 81433
27655, 72064, 72087, 72616, 72593, 72065, 72088, 72617, 72594, 79872, 81504, 81505, 81434, 79875, 81507, 81508, 
81437, 79803, 79873, 81506, 81436
27656, 72065, 72088, 72617, 72594, 72066, 72089, 72618, 72595, 79875, 81507, 81508, 81437, 79878, 81510, 81511, 
81440, 79806, 79876, 81509, 81439
27657, 72066, 72089, 72618, 72595, 72067, 72090, 72619, 72596, 79878, 81510, 81511, 81440, 79881, 81513, 81514, 
81443, 79809, 79879, 81512, 81442
27658, 72067, 72090, 72619, 72596, 72068, 72091, 72620, 72597, 79881, 81513, 81514, 81443, 79884, 81516, 81517, 
81446, 79812, 79882, 81515, 81445
27659, 72068, 72091, 72620, 72597, 72069, 72092, 72621, 72598, 79884, 81516, 81517, 81446, 79887, 81519, 81520, 
81449, 79815, 79885, 81518, 81448
27660, 72069, 72092, 72621, 72598, 72070, 72093, 72622, 72599, 79887, 81519, 81520, 81449, 79890, 81522, 81523, 
81452, 79818, 79888, 81521, 81451
27661, 72070, 72093, 72622, 72599, 72071, 72094, 72623, 72600, 79890, 81522, 81523, 81452, 79893, 81525, 81526, 
81455, 79821, 79891, 81524, 81454
27662, 72071, 72094, 72623, 72600, 72072, 72095, 72624, 72601, 79893, 81525, 81526, 81455, 79896, 81528, 81529, 
81458, 79824, 79894, 81527, 81457
27663, 72072, 72095, 72624, 72601, 72073, 72096, 72625, 72602, 79896, 81528, 81529, 81458, 79899, 81531, 81532, 
81461, 79827, 79897, 81530, 81460
27664, 72073, 72096, 72625, 72602, 72074, 72097, 72626, 72603, 79899, 81531, 81532, 81461, 79902, 81534, 81535, 
81464, 79830, 79900, 81533, 81463
27665, 72074, 72097, 72626, 72603, 72075, 72098, 72627, 72604, 79902, 81534, 81535, 81464, 79905, 81537, 81538, 
81467, 79833, 79903, 81536, 81466
