54440, 0.41666666666667, 0.175, 0.20833333333333
54441, 0.39583333333333, 0.2, 0.20833333333333
54442, 0.41666666666667, 0.2, 0.1875
54443, 0.41666666666667, 0.225, 0.20833333333333
54444, 0.39583333333333, 0.25, 0.20833333333333
54445, 0.41666666666667, 0.25, 0.1875
54446, 0.41666666666667, 0.275, 0.20833333333333
54447, 0.39583333333333, 0.3, 0.20833333333333
54448, 0.41666666666667, 0.3, 0.1875
54449, 0.41666666666667, 0.325, 0.20833333333333
54450, 0.39583333333333, 0.35, 0.20833333333333
54451, 0.41666666666667, 0.35, 0.1875
54452, 0.41666666666667, 0.375, 0.20833333333333
54453, 0.39583333333333, 0.4, 0.20833333333333
54454, 0.41666666666667, 0.4, 0.1875
54455, 0.41666666666667, 0.425, 0.20833333333333
54456, 0.39583333333333, 0.45, 0.20833333333333
54457, 0.41666666666667, 0.45, 0.1875
54458, 0.41666666666667, 0.475, 0.20833333333333
54459, 0.39583333333333, 0.5, 0.20833333333333
54460, 0.41666666666667, 0.5, 0.1875
54461, 0.41666666666667, 0.525, 0.20833333333333
54462, 0.39583333333333, 0.55, 0.20833333333333
54463, 0.41666666666667, 0.55, 0.1875
54464, 0.41666666666667, 0.575, 0.20833333333333
54465, 0.39583333333333, 0.6, 0.20833333333333
54466, 0.41666666666667, 0.6, 0.1875
54467, 0.41666666666667, 0.625, 0.20833333333333
54468, 0.39583333333333, 0.65, 0.20833333333333
54469, 0.41666666666667, 0.65, 0.1875
54470, 0.41666666666667, 0.675, 0.20833333333333
54471, 0.39583333333333, 0.7, 0.20833333333333
54472, 0.41666666666667, 0.7, 0.1875
54473, 0.41666666666667, 0.725, 0.20833333333333
54474, 0.39583333333333, 0.75, 0.20833333333333
54475, 0.41666666666667, 0.75, 0.1875
54476, 0.41666666666667, 0.775, 0.20833333333333
54477, 0.39583333333333, 0.8, 0.20833333333333
54478, 0.41666666666667, 0.8, 0.1875
54479, 0.41666666666667, 0.825, 0.20833333333333
54480, 0.39583333333333, 0.85, 0.20833333333333
54481, 0.41666666666667, 0.85, 0.1875
54482, 0.41666666666667, 0.875, 0.20833333333333
54483, 0.39583333333333, 0.9, 0.20833333333333
54484, 0.41666666666667, 0.9, 0.1875
54485, 0.41666666666667, 0.925, 0.20833333333333
54486, 0.39583333333333, 0.95, 0.20833333333333
54487, 0.41666666666667, 0.95, 0.1875
54488, 0.41666666666667, 0.975, 0.20833333333333
54489, 0.39583333333333, 1, 0.20833333333333
54490, 0.41666666666667, 1, 0.1875
54491, 0.41666666666667, 1.025, 0.20833333333333
54492, 0.39583333333333, 1.05, 0.20833333333333
54493, 0.41666666666667, 1.05, 0.1875
54494, 0.41666666666667, 1.075, 0.20833333333333
54495, 0.39583333333333, 1.1, 0.20833333333333
54496, 0.41666666666667, 1.1, 0.1875
54497, 0.41666666666667, 1.125, 0.20833333333333
54498, 0.39583333333333, 1.15, 0.20833333333333
54499, 0.41666666666667, 1.15, 0.1875
54500, 0.41666666666667, 1.175, 0.20833333333333
54501, 0.39583333333333, 1.2, 0.20833333333333
54502, 0.41666666666667, 1.2, 0.1875
54503, 0.41666666666667, 1.225, 0.20833333333333
54504, 0.39583333333333, 1.25, 0.20833333333333
54505, 0.41666666666667, 1.25, 0.1875
54506, 0.41666666666667, 1.275, 0.20833333333333
54507, 0.39583333333333, 1.3, 0.20833333333333
54508, 0.41666666666667, 1.3, 0.1875
54509, 0.41666666666667, 1.325, 0.20833333333333
54510, 0.41666666666667, 0.175, 0.25
54511, 0.39583333333333, 0.2, 0.25
54512, 0.41666666666667, 0.2, 0.22916666666667
54513, 0.41666666666667, 0.225, 0.25
54514, 0.39583333333333, 0.25, 0.25
54515, 0.41666666666667, 0.25, 0.22916666666667
54516, 0.41666666666667, 0.275, 0.25
54517, 0.39583333333333, 0.3, 0.25
54518, 0.41666666666667, 0.3, 0.22916666666667
54519, 0.41666666666667, 0.325, 0.25
54520, 0.39583333333333, 0.35, 0.25
54521, 0.41666666666667, 0.35, 0.22916666666667
54522, 0.41666666666667, 0.375, 0.25
54523, 0.39583333333333, 0.4, 0.25
54524, 0.41666666666667, 0.4, 0.22916666666667
54525, 0.41666666666667, 0.425, 0.25
54526, 0.39583333333333, 0.45, 0.25
54527, 0.41666666666667, 0.45, 0.22916666666667
54528, 0.41666666666667, 0.475, 0.25
54529, 0.39583333333333, 0.5, 0.25
54530, 0.41666666666667, 0.5, 0.22916666666667
54531, 0.41666666666667, 0.525, 0.25
54532, 0.39583333333333, 0.55, 0.25
54533, 0.41666666666667, 0.55, 0.22916666666667
54534, 0.41666666666667, 0.575, 0.25
54535, 0.39583333333333, 0.6, 0.25
54536, 0.41666666666667, 0.6, 0.22916666666667
54537, 0.41666666666667, 0.625, 0.25
54538, 0.39583333333333, 0.65, 0.25
54539, 0.41666666666667, 0.65, 0.22916666666667
54540, 0.41666666666667, 0.675, 0.25
54541, 0.39583333333333, 0.7, 0.25
54542, 0.41666666666667, 0.7, 0.22916666666667
54543, 0.41666666666667, 0.725, 0.25
54544, 0.39583333333333, 0.75, 0.25
54545, 0.41666666666667, 0.75, 0.22916666666667
54546, 0.41666666666667, 0.775, 0.25
54547, 0.39583333333333, 0.8, 0.25
54548, 0.41666666666667, 0.8, 0.22916666666667
54549, 0.41666666666667, 0.825, 0.25
54550, 0.39583333333333, 0.85, 0.25
54551, 0.41666666666667, 0.85, 0.22916666666667
54552, 0.41666666666667, 0.875, 0.25
54553, 0.39583333333333, 0.9, 0.25
54554, 0.41666666666667, 0.9, 0.22916666666667
54555, 0.41666666666667, 0.925, 0.25
54556, 0.39583333333333, 0.95, 0.25
54557, 0.41666666666667, 0.95, 0.22916666666667
54558, 0.41666666666667, 0.975, 0.25
54559, 0.39583333333333, 1, 0.25
54560, 0.41666666666667, 1, 0.22916666666667
54561, 0.41666666666667, 1.025, 0.25
54562, 0.39583333333333, 1.05, 0.25
54563, 0.41666666666667, 1.05, 0.22916666666667
54564, 0.41666666666667, 1.075, 0.25
54565, 0.39583333333333, 1.1, 0.25
54566, 0.41666666666667, 1.1, 0.22916666666667
54567, 0.41666666666667, 1.125, 0.25
54568, 0.39583333333333, 1.15, 0.25
54569, 0.41666666666667, 1.15, 0.22916666666667
54570, 0.41666666666667, 1.175, 0.25
54571, 0.39583333333333, 1.2, 0.25
54572, 0.41666666666667, 1.2, 0.22916666666667
54573, 0.41666666666667, 1.225, 0.25
54574, 0.39583333333333, 1.25, 0.25
54575, 0.41666666666667, 1.25, 0.22916666666667
54576, 0.41666666666667, 1.275, 0.25
54577, 0.39583333333333, 1.3, 0.25
54578, 0.41666666666667, 1.3, 0.22916666666667
54579, 0.41666666666667, 1.325, 0.25
54580, 0.41666666666667, 0.175, 0.29166666666667
54581, 0.39583333333333, 0.2, 0.29166666666667
54582, 0.41666666666667, 0.2, 0.27083333333333
54583, 0.41666666666667, 0.225, 0.29166666666667
54584, 0.39583333333333, 0.25, 0.29166666666667
54585, 0.41666666666667, 0.25, 0.27083333333333
54586, 0.41666666666667, 0.275, 0.29166666666667
54587, 0.39583333333333, 0.3, 0.29166666666667
54588, 0.41666666666667, 0.3, 0.27083333333333
54589, 0.41666666666667, 0.325, 0.29166666666667
54590, 0.39583333333333, 0.35, 0.29166666666667
54591, 0.41666666666667, 0.35, 0.27083333333333
54592, 0.41666666666667, 0.375, 0.29166666666667
54593, 0.39583333333333, 0.4, 0.29166666666667
54594, 0.41666666666667, 0.4, 0.27083333333333
54595, 0.41666666666667, 0.425, 0.29166666666667
54596, 0.39583333333333, 0.45, 0.29166666666667
54597, 0.41666666666667, 0.45, 0.27083333333333
54598, 0.41666666666667, 0.475, 0.29166666666667
54599, 0.39583333333333, 0.5, 0.29166666666667
54600, 0.41666666666667, 0.5, 0.27083333333333
54601, 0.41666666666667, 0.525, 0.29166666666667
54602, 0.39583333333333, 0.55, 0.29166666666667
54603, 0.41666666666667, 0.55, 0.27083333333333
54604, 0.41666666666667, 0.575, 0.29166666666667
54605, 0.39583333333333, 0.6, 0.29166666666667
54606, 0.41666666666667, 0.6, 0.27083333333333
54607, 0.41666666666667, 0.625, 0.29166666666667
54608, 0.39583333333333, 0.65, 0.29166666666667
54609, 0.41666666666667, 0.65, 0.27083333333333
54610, 0.41666666666667, 0.675, 0.29166666666667
54611, 0.39583333333333, 0.7, 0.29166666666667
54612, 0.41666666666667, 0.7, 0.27083333333333
54613, 0.41666666666667, 0.725, 0.29166666666667
54614, 0.39583333333333, 0.75, 0.29166666666667
54615, 0.41666666666667, 0.75, 0.27083333333333
54616, 0.41666666666667, 0.775, 0.29166666666667
54617, 0.39583333333333, 0.8, 0.29166666666667
54618, 0.41666666666667, 0.8, 0.27083333333333
54619, 0.41666666666667, 0.825, 0.29166666666667
54620, 0.39583333333333, 0.85, 0.29166666666667
54621, 0.41666666666667, 0.85, 0.27083333333333
54622, 0.41666666666667, 0.875, 0.29166666666667
54623, 0.39583333333333, 0.9, 0.29166666666667
54624, 0.41666666666667, 0.9, 0.27083333333333
54625, 0.41666666666667, 0.925, 0.29166666666667
54626, 0.39583333333333, 0.95, 0.29166666666667
54627, 0.41666666666667, 0.95, 0.27083333333333
54628, 0.41666666666667, 0.975, 0.29166666666667
54629, 0.39583333333333, 1, 0.29166666666667
54630, 0.41666666666667, 1, 0.27083333333333
54631, 0.41666666666667, 1.025, 0.29166666666667
54632, 0.39583333333333, 1.05, 0.29166666666667
54633, 0.41666666666667, 1.05, 0.27083333333333
54634, 0.41666666666667, 1.075, 0.29166666666667
54635, 0.39583333333333, 1.1, 0.29166666666667
54636, 0.41666666666667, 1.1, 0.27083333333333
54637, 0.41666666666667, 1.125, 0.29166666666667
54638, 0.39583333333333, 1.15, 0.29166666666667
54639, 0.41666666666667, 1.15, 0.27083333333333
54640, 0.41666666666667, 1.175, 0.29166666666667
54641, 0.39583333333333, 1.2, 0.29166666666667
54642, 0.41666666666667, 1.2, 0.27083333333333
54643, 0.41666666666667, 1.225, 0.29166666666667
54644, 0.39583333333333, 1.25, 0.29166666666667
54645, 0.41666666666667, 1.25, 0.27083333333333
54646, 0.41666666666667, 1.275, 0.29166666666667
54647, 0.39583333333333, 1.3, 0.29166666666667
54648, 0.41666666666667, 1.3, 0.27083333333333
54649, 0.41666666666667, 1.325, 0.29166666666667
54650, 0.41666666666667, 0.175, 0.33333333333333
54651, 0.39583333333333, 0.2, 0.33333333333333
54652, 0.41666666666667, 0.2, 0.3125
54653, 0.41666666666667, 0.225, 0.33333333333333
54654, 0.39583333333333, 0.25, 0.33333333333333
54655, 0.41666666666667, 0.25, 0.3125
54656, 0.41666666666667, 0.275, 0.33333333333333
54657, 0.39583333333333, 0.3, 0.33333333333333
54658, 0.41666666666667, 0.3, 0.3125
54659, 0.41666666666667, 0.325, 0.33333333333333
54660, 0.39583333333333, 0.35, 0.33333333333333
54661, 0.41666666666667, 0.35, 0.3125
54662, 0.41666666666667, 0.375, 0.33333333333333
54663, 0.39583333333333, 0.4, 0.33333333333333
54664, 0.41666666666667, 0.4, 0.3125
54665, 0.41666666666667, 0.425, 0.33333333333333
54666, 0.39583333333333, 0.45, 0.33333333333333
54667, 0.41666666666667, 0.45, 0.3125
54668, 0.41666666666667, 0.475, 0.33333333333333
54669, 0.39583333333333, 0.5, 0.33333333333333
54670, 0.41666666666667, 0.5, 0.3125
54671, 0.41666666666667, 0.525, 0.33333333333333
54672, 0.39583333333333, 0.55, 0.33333333333333
54673, 0.41666666666667, 0.55, 0.3125
54674, 0.41666666666667, 0.575, 0.33333333333333
54675, 0.39583333333333, 0.6, 0.33333333333333
54676, 0.41666666666667, 0.6, 0.3125
54677, 0.41666666666667, 0.625, 0.33333333333333
54678, 0.39583333333333, 0.65, 0.33333333333333
54679, 0.41666666666667, 0.65, 0.3125
54680, 0.41666666666667, 0.675, 0.33333333333333
54681, 0.39583333333333, 0.7, 0.33333333333333
54682, 0.41666666666667, 0.7, 0.3125
54683, 0.41666666666667, 0.725, 0.33333333333333
54684, 0.39583333333333, 0.75, 0.33333333333333
54685, 0.41666666666667, 0.75, 0.3125
54686, 0.41666666666667, 0.775, 0.33333333333333
54687, 0.39583333333333, 0.8, 0.33333333333333
54688, 0.41666666666667, 0.8, 0.3125
54689, 0.41666666666667, 0.825, 0.33333333333333
54690, 0.39583333333333, 0.85, 0.33333333333333
54691, 0.41666666666667, 0.85, 0.3125
54692, 0.41666666666667, 0.875, 0.33333333333333
54693, 0.39583333333333, 0.9, 0.33333333333333
54694, 0.41666666666667, 0.9, 0.3125
54695, 0.41666666666667, 0.925, 0.33333333333333
54696, 0.39583333333333, 0.95, 0.33333333333333
54697, 0.41666666666667, 0.95, 0.3125
54698, 0.41666666666667, 0.975, 0.33333333333333
54699, 0.39583333333333, 1, 0.33333333333333
54700, 0.41666666666667, 1, 0.3125
54701, 0.41666666666667, 1.025, 0.33333333333333
54702, 0.39583333333333, 1.05, 0.33333333333333
54703, 0.41666666666667, 1.05, 0.3125
54704, 0.41666666666667, 1.075, 0.33333333333333
54705, 0.39583333333333, 1.1, 0.33333333333333
54706, 0.41666666666667, 1.1, 0.3125
54707, 0.41666666666667, 1.125, 0.33333333333333
54708, 0.39583333333333, 1.15, 0.33333333333333
54709, 0.41666666666667, 1.15, 0.3125
54710, 0.41666666666667, 1.175, 0.33333333333333
54711, 0.39583333333333, 1.2, 0.33333333333333
54712, 0.41666666666667, 1.2, 0.3125
54713, 0.41666666666667, 1.225, 0.33333333333333
54714, 0.39583333333333, 1.25, 0.33333333333333
54715, 0.41666666666667, 1.25, 0.3125
54716, 0.41666666666667, 1.275, 0.33333333333333
54717, 0.39583333333333, 1.3, 0.33333333333333
54718, 0.41666666666667, 1.3, 0.3125
54719, 0.41666666666667, 1.325, 0.33333333333333
54720, 0.41666666666667, 0.175, 0.375
54721, 0.39583333333333, 0.2, 0.375
54722, 0.41666666666667, 0.2, 0.35416666666667
54723, 0.41666666666667, 0.225, 0.375
54724, 0.39583333333333, 0.25, 0.375
54725, 0.41666666666667, 0.25, 0.35416666666667
54726, 0.41666666666667, 0.275, 0.375
54727, 0.39583333333333, 0.3, 0.375
54728, 0.41666666666667, 0.3, 0.35416666666667
54729, 0.41666666666667, 0.325, 0.375
54730, 0.39583333333333, 0.35, 0.375
54731, 0.41666666666667, 0.35, 0.35416666666667
54732, 0.41666666666667, 0.375, 0.375
54733, 0.39583333333333, 0.4, 0.375
54734, 0.41666666666667, 0.4, 0.35416666666667
54735, 0.41666666666667, 0.425, 0.375
54736, 0.39583333333333, 0.45, 0.375
54737, 0.41666666666667, 0.45, 0.35416666666667
54738, 0.41666666666667, 0.475, 0.375
54739, 0.39583333333333, 0.5, 0.375
54740, 0.41666666666667, 0.5, 0.35416666666667
54741, 0.41666666666667, 0.525, 0.375
54742, 0.39583333333333, 0.55, 0.375
54743, 0.41666666666667, 0.55, 0.35416666666667
54744, 0.41666666666667, 0.575, 0.375
54745, 0.39583333333333, 0.6, 0.375
54746, 0.41666666666667, 0.6, 0.35416666666667
54747, 0.41666666666667, 0.625, 0.375
54748, 0.39583333333333, 0.65, 0.375
54749, 0.41666666666667, 0.65, 0.35416666666667
54750, 0.41666666666667, 0.675, 0.375
54751, 0.39583333333333, 0.7, 0.375
54752, 0.41666666666667, 0.7, 0.35416666666667
54753, 0.41666666666667, 0.725, 0.375
54754, 0.39583333333333, 0.75, 0.375
54755, 0.41666666666667, 0.75, 0.35416666666667
54756, 0.41666666666667, 0.775, 0.375
54757, 0.39583333333333, 0.8, 0.375
54758, 0.41666666666667, 0.8, 0.35416666666667
54759, 0.41666666666667, 0.825, 0.375
54760, 0.39583333333333, 0.85, 0.375
54761, 0.41666666666667, 0.85, 0.35416666666667
54762, 0.41666666666667, 0.875, 0.375
54763, 0.39583333333333, 0.9, 0.375
54764, 0.41666666666667, 0.9, 0.35416666666667
54765, 0.41666666666667, 0.925, 0.375
54766, 0.39583333333333, 0.95, 0.375
54767, 0.41666666666667, 0.95, 0.35416666666667
54768, 0.41666666666667, 0.975, 0.375
54769, 0.39583333333333, 1, 0.375
54770, 0.41666666666667, 1, 0.35416666666667
54771, 0.41666666666667, 1.025, 0.375
54772, 0.39583333333333, 1.05, 0.375
54773, 0.41666666666667, 1.05, 0.35416666666667
54774, 0.41666666666667, 1.075, 0.375
54775, 0.39583333333333, 1.1, 0.375
54776, 0.41666666666667, 1.1, 0.35416666666667
54777, 0.41666666666667, 1.125, 0.375
54778, 0.39583333333333, 1.15, 0.375
54779, 0.41666666666667, 1.15, 0.35416666666667
54780, 0.41666666666667, 1.175, 0.375
54781, 0.39583333333333, 1.2, 0.375
54782, 0.41666666666667, 1.2, 0.35416666666667
54783, 0.41666666666667, 1.225, 0.375
54784, 0.39583333333333, 1.25, 0.375
54785, 0.41666666666667, 1.25, 0.35416666666667
54786, 0.41666666666667, 1.275, 0.375
54787, 0.39583333333333, 1.3, 0.375
54788, 0.41666666666667, 1.3, 0.35416666666667
54789, 0.41666666666667, 1.325, 0.375
54790, 0.41666666666667, 0.175, 0.41666666666667
54791, 0.39583333333333, 0.2, 0.41666666666667
54792, 0.41666666666667, 0.2, 0.39583333333333
54793, 0.41666666666667, 0.225, 0.41666666666667
54794, 0.39583333333333, 0.25, 0.41666666666667
54795, 0.41666666666667, 0.25, 0.39583333333333
54796, 0.41666666666667, 0.275, 0.41666666666667
54797, 0.39583333333333, 0.3, 0.41666666666667
54798, 0.41666666666667, 0.3, 0.39583333333333
54799, 0.41666666666667, 0.325, 0.41666666666667
54800, 0.39583333333333, 0.35, 0.41666666666667
54801, 0.41666666666667, 0.35, 0.39583333333333
54802, 0.41666666666667, 0.375, 0.41666666666667
54803, 0.39583333333333, 0.4, 0.41666666666667
54804, 0.41666666666667, 0.4, 0.39583333333333
54805, 0.41666666666667, 0.425, 0.41666666666667
54806, 0.39583333333333, 0.45, 0.41666666666667
54807, 0.41666666666667, 0.45, 0.39583333333333
54808, 0.41666666666667, 0.475, 0.41666666666667
54809, 0.39583333333333, 0.5, 0.41666666666667
54810, 0.41666666666667, 0.5, 0.39583333333333
54811, 0.41666666666667, 0.525, 0.41666666666667
54812, 0.39583333333333, 0.55, 0.41666666666667
54813, 0.41666666666667, 0.55, 0.39583333333333
54814, 0.41666666666667, 0.575, 0.41666666666667
54815, 0.39583333333333, 0.6, 0.41666666666667
54816, 0.41666666666667, 0.6, 0.39583333333333
54817, 0.41666666666667, 0.625, 0.41666666666667
54818, 0.39583333333333, 0.65, 0.41666666666667
54819, 0.41666666666667, 0.65, 0.39583333333333
54820, 0.41666666666667, 0.675, 0.41666666666667
54821, 0.39583333333333, 0.7, 0.41666666666667
54822, 0.41666666666667, 0.7, 0.39583333333333
54823, 0.41666666666667, 0.725, 0.41666666666667
54824, 0.39583333333333, 0.75, 0.41666666666667
54825, 0.41666666666667, 0.75, 0.39583333333333
54826, 0.41666666666667, 0.775, 0.41666666666667
54827, 0.39583333333333, 0.8, 0.41666666666667
54828, 0.41666666666667, 0.8, 0.39583333333333
54829, 0.41666666666667, 0.825, 0.41666666666667
54830, 0.39583333333333, 0.85, 0.41666666666667
54831, 0.41666666666667, 0.85, 0.39583333333333
54832, 0.41666666666667, 0.875, 0.41666666666667
54833, 0.39583333333333, 0.9, 0.41666666666667
54834, 0.41666666666667, 0.9, 0.39583333333333
54835, 0.41666666666667, 0.925, 0.41666666666667
54836, 0.39583333333333, 0.95, 0.41666666666667
54837, 0.41666666666667, 0.95, 0.39583333333333
54838, 0.41666666666667, 0.975, 0.41666666666667
54839, 0.39583333333333, 1, 0.41666666666667
54840, 0.41666666666667, 1, 0.39583333333333
54841, 0.41666666666667, 1.025, 0.41666666666667
54842, 0.39583333333333, 1.05, 0.41666666666667
54843, 0.41666666666667, 1.05, 0.39583333333333
54844, 0.41666666666667, 1.075, 0.41666666666667
54845, 0.39583333333333, 1.1, 0.41666666666667
54846, 0.41666666666667, 1.1, 0.39583333333333
54847, 0.41666666666667, 1.125, 0.41666666666667
54848, 0.39583333333333, 1.15, 0.41666666666667
54849, 0.41666666666667, 1.15, 0.39583333333333
54850, 0.41666666666667, 1.175, 0.41666666666667
54851, 0.39583333333333, 1.2, 0.41666666666667
54852, 0.41666666666667, 1.2, 0.39583333333333
54853, 0.41666666666667, 1.225, 0.41666666666667
54854, 0.39583333333333, 1.25, 0.41666666666667
54855, 0.41666666666667, 1.25, 0.39583333333333
54856, 0.41666666666667, 1.275, 0.41666666666667
54857, 0.39583333333333, 1.3, 0.41666666666667
54858, 0.41666666666667, 1.3, 0.39583333333333
54859, 0.41666666666667, 1.325, 0.41666666666667
54860, 0.41666666666667, 0.175, 0.45833333333333
54861, 0.39583333333333, 0.2, 0.45833333333333
54862, 0.41666666666667, 0.2, 0.4375
54863, 0.41666666666667, 0.225, 0.45833333333333
54864, 0.39583333333333, 0.25, 0.45833333333333
54865, 0.41666666666667, 0.25, 0.4375
54866, 0.41666666666667, 0.275, 0.45833333333333
54867, 0.39583333333333, 0.3, 0.45833333333333
54868, 0.41666666666667, 0.3, 0.4375
54869, 0.41666666666667, 0.325, 0.45833333333333
54870, 0.39583333333333, 0.35, 0.45833333333333
54871, 0.41666666666667, 0.35, 0.4375
54872, 0.41666666666667, 0.375, 0.45833333333333
54873, 0.39583333333333, 0.4, 0.45833333333333
54874, 0.41666666666667, 0.4, 0.4375
54875, 0.41666666666667, 0.425, 0.45833333333333
54876, 0.39583333333333, 0.45, 0.45833333333333
54877, 0.41666666666667, 0.45, 0.4375
54878, 0.41666666666667, 0.475, 0.45833333333333
54879, 0.39583333333333, 0.5, 0.45833333333333
54880, 0.41666666666667, 0.5, 0.4375
54881, 0.41666666666667, 0.525, 0.45833333333333
54882, 0.39583333333333, 0.55, 0.45833333333333
54883, 0.41666666666667, 0.55, 0.4375
54884, 0.41666666666667, 0.575, 0.45833333333333
54885, 0.39583333333333, 0.6, 0.45833333333333
54886, 0.41666666666667, 0.6, 0.4375
54887, 0.41666666666667, 0.625, 0.45833333333333
54888, 0.39583333333333, 0.65, 0.45833333333333
54889, 0.41666666666667, 0.65, 0.4375
54890, 0.41666666666667, 0.675, 0.45833333333333
54891, 0.39583333333333, 0.7, 0.45833333333333
54892, 0.41666666666667, 0.7, 0.4375
54893, 0.41666666666667, 0.725, 0.45833333333333
54894, 0.39583333333333, 0.75, 0.45833333333333
54895, 0.41666666666667, 0.75, 0.4375
54896, 0.41666666666667, 0.775, 0.45833333333333
54897, 0.39583333333333, 0.8, 0.45833333333333
54898, 0.41666666666667, 0.8, 0.4375
54899, 0.41666666666667, 0.825, 0.45833333333333
54900, 0.39583333333333, 0.85, 0.45833333333333
54901, 0.41666666666667, 0.85, 0.4375
54902, 0.41666666666667, 0.875, 0.45833333333333
54903, 0.39583333333333, 0.9, 0.45833333333333
54904, 0.41666666666667, 0.9, 0.4375
54905, 0.41666666666667, 0.925, 0.45833333333333
54906, 0.39583333333333, 0.95, 0.45833333333333
54907, 0.41666666666667, 0.95, 0.4375
54908, 0.41666666666667, 0.975, 0.45833333333333
54909, 0.39583333333333, 1, 0.45833333333333
54910, 0.41666666666667, 1, 0.4375
54911, 0.41666666666667, 1.025, 0.45833333333333
54912, 0.39583333333333, 1.05, 0.45833333333333
54913, 0.41666666666667, 1.05, 0.4375
54914, 0.41666666666667, 1.075, 0.45833333333333
54915, 0.39583333333333, 1.1, 0.45833333333333
54916, 0.41666666666667, 1.1, 0.4375
54917, 0.41666666666667, 1.125, 0.45833333333333
54918, 0.39583333333333, 1.15, 0.45833333333333
54919, 0.41666666666667, 1.15, 0.4375
54920, 0.41666666666667, 1.175, 0.45833333333333
54921, 0.39583333333333, 1.2, 0.45833333333333
54922, 0.41666666666667, 1.2, 0.4375
54923, 0.41666666666667, 1.225, 0.45833333333333
54924, 0.39583333333333, 1.25, 0.45833333333333
54925, 0.41666666666667, 1.25, 0.4375
54926, 0.41666666666667, 1.275, 0.45833333333333
54927, 0.39583333333333, 1.3, 0.45833333333333
54928, 0.41666666666667, 1.3, 0.4375
54929, 0.41666666666667, 1.325, 0.45833333333333
54930, 0.41666666666667, 0.2, 0.47916666666667
54931, 0.41666666666667, 0.25, 0.47916666666667
54932, 0.41666666666667, 0.3, 0.47916666666667
54933, 0.41666666666667, 0.35, 0.47916666666667
54934, 0.41666666666667, 0.4, 0.47916666666667
54935, 0.41666666666667, 0.45, 0.47916666666667
54936, 0.41666666666667, 0.5, 0.47916666666667
54937, 0.41666666666667, 0.55, 0.47916666666667
54938, 0.41666666666667, 0.6, 0.47916666666667
54939, 0.41666666666667, 0.65, 0.47916666666667
54940, 0.41666666666667, 0.7, 0.47916666666667
54941, 0.41666666666667, 0.75, 0.47916666666667
54942, 0.41666666666667, 0.8, 0.47916666666667
54943, 0.41666666666667, 0.85, 0.47916666666667
54944, 0.41666666666667, 0.9, 0.47916666666667
54945, 0.41666666666667, 0.95, 0.47916666666667
54946, 0.41666666666667, 1, 0.47916666666667
54947, 0.41666666666667, 1.05, 0.47916666666667
54948, 0.41666666666667, 1.1, 0.47916666666667
54949, 0.41666666666667, 1.15, 0.47916666666667
54950, 0.41666666666667, 1.2, 0.47916666666667
54951, 0.41666666666667, 1.25, 0.47916666666667
54952, 0.41666666666667, 1.3, 0.47916666666667
54953, 0.45833333333333, 0.175, 0.041666666666667
54954, 0.4375, 0.2, 0.041666666666667
54955, 0.45833333333333, 0.2, 0.020833333333333
54956, 0.45833333333333, 0.225, 0.041666666666667
54957, 0.4375, 0.25, 0.041666666666667
54958, 0.45833333333333, 0.25, 0.020833333333333
54959, 0.45833333333333, 0.275, 0.041666666666667
54960, 0.4375, 0.3, 0.041666666666667
54961, 0.45833333333333, 0.3, 0.020833333333333
54962, 0.45833333333333, 0.325, 0.041666666666667
54963, 0.4375, 0.35, 0.041666666666667
54964, 0.45833333333333, 0.35, 0.020833333333333
54965, 0.45833333333333, 0.375, 0.041666666666667
54966, 0.4375, 0.4, 0.041666666666667
54967, 0.45833333333333, 0.4, 0.020833333333333
54968, 0.45833333333333, 0.425, 0.041666666666667
54969, 0.4375, 0.45, 0.041666666666667
54970, 0.45833333333333, 0.45, 0.020833333333333
54971, 0.45833333333333, 0.475, 0.041666666666667
54972, 0.4375, 0.5, 0.041666666666667
54973, 0.45833333333333, 0.5, 0.020833333333333
54974, 0.45833333333333, 0.525, 0.041666666666667
54975, 0.4375, 0.55, 0.041666666666667
54976, 0.45833333333333, 0.55, 0.020833333333333
54977, 0.45833333333333, 0.575, 0.041666666666667
54978, 0.4375, 0.6, 0.041666666666667
54979, 0.45833333333333, 0.6, 0.020833333333333
54980, 0.45833333333333, 0.625, 0.041666666666667
54981, 0.4375, 0.65, 0.041666666666667
54982, 0.45833333333333, 0.65, 0.020833333333333
54983, 0.45833333333333, 0.675, 0.041666666666667
54984, 0.4375, 0.7, 0.041666666666667
54985, 0.45833333333333, 0.7, 0.020833333333333
54986, 0.45833333333333, 0.725, 0.041666666666667
54987, 0.4375, 0.75, 0.041666666666667
54988, 0.45833333333333, 0.75, 0.020833333333333
54989, 0.45833333333333, 0.775, 0.041666666666667
54990, 0.4375, 0.8, 0.041666666666667
54991, 0.45833333333333, 0.8, 0.020833333333333
54992, 0.45833333333333, 0.825, 0.041666666666667
54993, 0.4375, 0.85, 0.041666666666667
54994, 0.45833333333333, 0.85, 0.020833333333333
54995, 0.45833333333333, 0.875, 0.041666666666667
54996, 0.4375, 0.9, 0.041666666666667
54997, 0.45833333333333, 0.9, 0.020833333333333
54998, 0.45833333333333, 0.925, 0.041666666666667
54999, 0.4375, 0.95, 0.041666666666667
55000, 0.45833333333333, 0.95, 0.020833333333333
55001, 0.45833333333333, 0.975, 0.041666666666667
55002, 0.4375, 1, 0.041666666666667
55003, 0.45833333333333, 1, 0.020833333333333
55004, 0.45833333333333, 1.025, 0.041666666666667
55005, 0.4375, 1.05, 0.041666666666667
55006, 0.45833333333333, 1.05, 0.020833333333333
55007, 0.45833333333333, 1.075, 0.041666666666667
55008, 0.4375, 1.1, 0.041666666666667
55009, 0.45833333333333, 1.1, 0.020833333333333
55010, 0.45833333333333, 1.125, 0.041666666666667
55011, 0.4375, 1.15, 0.041666666666667
55012, 0.45833333333333, 1.15, 0.020833333333333
55013, 0.45833333333333, 1.175, 0.041666666666667
55014, 0.4375, 1.2, 0.041666666666667
55015, 0.45833333333333, 1.2, 0.020833333333333
55016, 0.45833333333333, 1.225, 0.041666666666667
55017, 0.4375, 1.25, 0.041666666666667
55018, 0.45833333333333, 1.25, 0.020833333333333
55019, 0.45833333333333, 1.275, 0.041666666666667
55020, 0.4375, 1.3, 0.041666666666667
55021, 0.45833333333333, 1.3, 0.020833333333333
55022, 0.45833333333333, 1.325, 0.041666666666667
55023, 0.45833333333333, 0.175, 0.083333333333333
55024, 0.4375, 0.2, 0.083333333333333
55025, 0.45833333333333, 0.2, 0.0625
55026, 0.45833333333333, 0.225, 0.083333333333333
55027, 0.4375, 0.25, 0.083333333333333
55028, 0.45833333333333, 0.25, 0.0625
55029, 0.45833333333333, 0.275, 0.083333333333333
55030, 0.4375, 0.3, 0.083333333333333
55031, 0.45833333333333, 0.3, 0.0625
55032, 0.45833333333333, 0.325, 0.083333333333333
55033, 0.4375, 0.35, 0.083333333333333
55034, 0.45833333333333, 0.35, 0.0625
55035, 0.45833333333333, 0.375, 0.083333333333333
55036, 0.4375, 0.4, 0.083333333333333
55037, 0.45833333333333, 0.4, 0.0625
55038, 0.45833333333333, 0.425, 0.083333333333333
55039, 0.4375, 0.45, 0.083333333333333
55040, 0.45833333333333, 0.45, 0.0625
55041, 0.45833333333333, 0.475, 0.083333333333333
55042, 0.4375, 0.5, 0.083333333333333
55043, 0.45833333333333, 0.5, 0.0625
55044, 0.45833333333333, 0.525, 0.083333333333333
55045, 0.4375, 0.55, 0.083333333333333
55046, 0.45833333333333, 0.55, 0.0625
55047, 0.45833333333333, 0.575, 0.083333333333333
55048, 0.4375, 0.6, 0.083333333333333
55049, 0.45833333333333, 0.6, 0.0625
55050, 0.45833333333333, 0.625, 0.083333333333333
55051, 0.4375, 0.65, 0.083333333333333
55052, 0.45833333333333, 0.65, 0.0625
55053, 0.45833333333333, 0.675, 0.083333333333333
55054, 0.4375, 0.7, 0.083333333333333
55055, 0.45833333333333, 0.7, 0.0625
55056, 0.45833333333333, 0.725, 0.083333333333333
55057, 0.4375, 0.75, 0.083333333333333
55058, 0.45833333333333, 0.75, 0.0625
55059, 0.45833333333333, 0.775, 0.083333333333333
55060, 0.4375, 0.8, 0.083333333333333
55061, 0.45833333333333, 0.8, 0.0625
55062, 0.45833333333333, 0.825, 0.083333333333333
55063, 0.4375, 0.85, 0.083333333333333
55064, 0.45833333333333, 0.85, 0.0625
55065, 0.45833333333333, 0.875, 0.083333333333333
55066, 0.4375, 0.9, 0.083333333333333
55067, 0.45833333333333, 0.9, 0.0625
55068, 0.45833333333333, 0.925, 0.083333333333333
55069, 0.4375, 0.95, 0.083333333333333
55070, 0.45833333333333, 0.95, 0.0625
55071, 0.45833333333333, 0.975, 0.083333333333333
55072, 0.4375, 1, 0.083333333333333
55073, 0.45833333333333, 1, 0.0625
55074, 0.45833333333333, 1.025, 0.083333333333333
55075, 0.4375, 1.05, 0.083333333333333
55076, 0.45833333333333, 1.05, 0.0625
55077, 0.45833333333333, 1.075, 0.083333333333333
55078, 0.4375, 1.1, 0.083333333333333
55079, 0.45833333333333, 1.1, 0.0625
55080, 0.45833333333333, 1.125, 0.083333333333333
55081, 0.4375, 1.15, 0.083333333333333
55082, 0.45833333333333, 1.15, 0.0625
55083, 0.45833333333333, 1.175, 0.083333333333333
55084, 0.4375, 1.2, 0.083333333333333
55085, 0.45833333333333, 1.2, 0.0625
55086, 0.45833333333333, 1.225, 0.083333333333333
55087, 0.4375, 1.25, 0.083333333333333
55088, 0.45833333333333, 1.25, 0.0625
55089, 0.45833333333333, 1.275, 0.083333333333333
55090, 0.4375, 1.3, 0.083333333333333
55091, 0.45833333333333, 1.3, 0.0625
55092, 0.45833333333333, 1.325, 0.083333333333333
55093, 0.45833333333333, 0.175, 0.125
55094, 0.4375, 0.2, 0.125
55095, 0.45833333333333, 0.2, 0.10416666666667
55096, 0.45833333333333, 0.225, 0.125
55097, 0.4375, 0.25, 0.125
55098, 0.45833333333333, 0.25, 0.10416666666667
55099, 0.45833333333333, 0.275, 0.125
55100, 0.4375, 0.3, 0.125
55101, 0.45833333333333, 0.3, 0.10416666666667
55102, 0.45833333333333, 0.325, 0.125
55103, 0.4375, 0.35, 0.125
55104, 0.45833333333333, 0.35, 0.10416666666667
55105, 0.45833333333333, 0.375, 0.125
55106, 0.4375, 0.4, 0.125
55107, 0.45833333333333, 0.4, 0.10416666666667
55108, 0.45833333333333, 0.425, 0.125
55109, 0.4375, 0.45, 0.125
55110, 0.45833333333333, 0.45, 0.10416666666667
55111, 0.45833333333333, 0.475, 0.125
55112, 0.4375, 0.5, 0.125
55113, 0.45833333333333, 0.5, 0.10416666666667
55114, 0.45833333333333, 0.525, 0.125
55115, 0.4375, 0.55, 0.125
55116, 0.45833333333333, 0.55, 0.10416666666667
55117, 0.45833333333333, 0.575, 0.125
55118, 0.4375, 0.6, 0.125
55119, 0.45833333333333, 0.6, 0.10416666666667
55120, 0.45833333333333, 0.625, 0.125
55121, 0.4375, 0.65, 0.125
55122, 0.45833333333333, 0.65, 0.10416666666667
55123, 0.45833333333333, 0.675, 0.125
55124, 0.4375, 0.7, 0.125
55125, 0.45833333333333, 0.7, 0.10416666666667
55126, 0.45833333333333, 0.725, 0.125
55127, 0.4375, 0.75, 0.125
55128, 0.45833333333333, 0.75, 0.10416666666667
55129, 0.45833333333333, 0.775, 0.125
55130, 0.4375, 0.8, 0.125
55131, 0.45833333333333, 0.8, 0.10416666666667
55132, 0.45833333333333, 0.825, 0.125
55133, 0.4375, 0.85, 0.125
55134, 0.45833333333333, 0.85, 0.10416666666667
55135, 0.45833333333333, 0.875, 0.125
55136, 0.4375, 0.9, 0.125
55137, 0.45833333333333, 0.9, 0.10416666666667
55138, 0.45833333333333, 0.925, 0.125
55139, 0.4375, 0.95, 0.125
55140, 0.45833333333333, 0.95, 0.10416666666667
55141, 0.45833333333333, 0.975, 0.125
55142, 0.4375, 1, 0.125
55143, 0.45833333333333, 1, 0.10416666666667
55144, 0.45833333333333, 1.025, 0.125
55145, 0.4375, 1.05, 0.125
55146, 0.45833333333333, 1.05, 0.10416666666667
55147, 0.45833333333333, 1.075, 0.125
55148, 0.4375, 1.1, 0.125
55149, 0.45833333333333, 1.1, 0.10416666666667
55150, 0.45833333333333, 1.125, 0.125
55151, 0.4375, 1.15, 0.125
55152, 0.45833333333333, 1.15, 0.10416666666667
55153, 0.45833333333333, 1.175, 0.125
55154, 0.4375, 1.2, 0.125
55155, 0.45833333333333, 1.2, 0.10416666666667
55156, 0.45833333333333, 1.225, 0.125
55157, 0.4375, 1.25, 0.125
55158, 0.45833333333333, 1.25, 0.10416666666667
55159, 0.45833333333333, 1.275, 0.125
55160, 0.4375, 1.3, 0.125
55161, 0.45833333333333, 1.3, 0.10416666666667
55162, 0.45833333333333, 1.325, 0.125
55163, 0.45833333333333, 0.175, 0.16666666666667
55164, 0.4375, 0.2, 0.16666666666667
55165, 0.45833333333333, 0.2, 0.14583333333333
55166, 0.45833333333333, 0.225, 0.16666666666667
55167, 0.4375, 0.25, 0.16666666666667
55168, 0.45833333333333, 0.25, 0.14583333333333
55169, 0.45833333333333, 0.275, 0.16666666666667
55170, 0.4375, 0.3, 0.16666666666667
55171, 0.45833333333333, 0.3, 0.14583333333333
55172, 0.45833333333333, 0.325, 0.16666666666667
55173, 0.4375, 0.35, 0.16666666666667
55174, 0.45833333333333, 0.35, 0.14583333333333
55175, 0.45833333333333, 0.375, 0.16666666666667
55176, 0.4375, 0.4, 0.16666666666667
55177, 0.45833333333333, 0.4, 0.14583333333333
55178, 0.45833333333333, 0.425, 0.16666666666667
55179, 0.4375, 0.45, 0.16666666666667
55180, 0.45833333333333, 0.45, 0.14583333333333
55181, 0.45833333333333, 0.475, 0.16666666666667
55182, 0.4375, 0.5, 0.16666666666667
55183, 0.45833333333333, 0.5, 0.14583333333333
55184, 0.45833333333333, 0.525, 0.16666666666667
55185, 0.4375, 0.55, 0.16666666666667
55186, 0.45833333333333, 0.55, 0.14583333333333
55187, 0.45833333333333, 0.575, 0.16666666666667
55188, 0.4375, 0.6, 0.16666666666667
55189, 0.45833333333333, 0.6, 0.14583333333333
55190, 0.45833333333333, 0.625, 0.16666666666667
55191, 0.4375, 0.65, 0.16666666666667
55192, 0.45833333333333, 0.65, 0.14583333333333
55193, 0.45833333333333, 0.675, 0.16666666666667
55194, 0.4375, 0.7, 0.16666666666667
55195, 0.45833333333333, 0.7, 0.14583333333333
55196, 0.45833333333333, 0.725, 0.16666666666667
55197, 0.4375, 0.75, 0.16666666666667
55198, 0.45833333333333, 0.75, 0.14583333333333
55199, 0.45833333333333, 0.775, 0.16666666666667
55200, 0.4375, 0.8, 0.16666666666667
55201, 0.45833333333333, 0.8, 0.14583333333333
55202, 0.45833333333333, 0.825, 0.16666666666667
55203, 0.4375, 0.85, 0.16666666666667
55204, 0.45833333333333, 0.85, 0.14583333333333
55205, 0.45833333333333, 0.875, 0.16666666666667
55206, 0.4375, 0.9, 0.16666666666667
55207, 0.45833333333333, 0.9, 0.14583333333333
55208, 0.45833333333333, 0.925, 0.16666666666667
55209, 0.4375, 0.95, 0.16666666666667
55210, 0.45833333333333, 0.95, 0.14583333333333
55211, 0.45833333333333, 0.975, 0.16666666666667
55212, 0.4375, 1, 0.16666666666667
55213, 0.45833333333333, 1, 0.14583333333333
55214, 0.45833333333333, 1.025, 0.16666666666667
55215, 0.4375, 1.05, 0.16666666666667
55216, 0.45833333333333, 1.05, 0.14583333333333
55217, 0.45833333333333, 1.075, 0.16666666666667
55218, 0.4375, 1.1, 0.16666666666667
55219, 0.45833333333333, 1.1, 0.14583333333333
55220, 0.45833333333333, 1.125, 0.16666666666667
55221, 0.4375, 1.15, 0.16666666666667
55222, 0.45833333333333, 1.15, 0.14583333333333
55223, 0.45833333333333, 1.175, 0.16666666666667
55224, 0.4375, 1.2, 0.16666666666667
55225, 0.45833333333333, 1.2, 0.14583333333333
55226, 0.45833333333333, 1.225, 0.16666666666667
55227, 0.4375, 1.25, 0.16666666666667
55228, 0.45833333333333, 1.25, 0.14583333333333
55229, 0.45833333333333, 1.275, 0.16666666666667
55230, 0.4375, 1.3, 0.16666666666667
55231, 0.45833333333333, 1.3, 0.14583333333333
55232, 0.45833333333333, 1.325, 0.16666666666667
55233, 0.45833333333333, 0.175, 0.20833333333333
55234, 0.4375, 0.2, 0.20833333333333
55235, 0.45833333333333, 0.2, 0.1875
55236, 0.45833333333333, 0.225, 0.20833333333333
55237, 0.4375, 0.25, 0.20833333333333
55238, 0.45833333333333, 0.25, 0.1875
55239, 0.45833333333333, 0.275, 0.20833333333333
55240, 0.4375, 0.3, 0.20833333333333
55241, 0.45833333333333, 0.3, 0.1875
55242, 0.45833333333333, 0.325, 0.20833333333333
55243, 0.4375, 0.35, 0.20833333333333
55244, 0.45833333333333, 0.35, 0.1875
55245, 0.45833333333333, 0.375, 0.20833333333333
55246, 0.4375, 0.4, 0.20833333333333
55247, 0.45833333333333, 0.4, 0.1875
55248, 0.45833333333333, 0.425, 0.20833333333333
55249, 0.4375, 0.45, 0.20833333333333
55250, 0.45833333333333, 0.45, 0.1875
55251, 0.45833333333333, 0.475, 0.20833333333333
55252, 0.4375, 0.5, 0.20833333333333
55253, 0.45833333333333, 0.5, 0.1875
55254, 0.45833333333333, 0.525, 0.20833333333333
55255, 0.4375, 0.55, 0.20833333333333
55256, 0.45833333333333, 0.55, 0.1875
55257, 0.45833333333333, 0.575, 0.20833333333333
55258, 0.4375, 0.6, 0.20833333333333
55259, 0.45833333333333, 0.6, 0.1875
55260, 0.45833333333333, 0.625, 0.20833333333333
55261, 0.4375, 0.65, 0.20833333333333
55262, 0.45833333333333, 0.65, 0.1875
55263, 0.45833333333333, 0.675, 0.20833333333333
55264, 0.4375, 0.7, 0.20833333333333
55265, 0.45833333333333, 0.7, 0.1875
55266, 0.45833333333333, 0.725, 0.20833333333333
55267, 0.4375, 0.75, 0.20833333333333
55268, 0.45833333333333, 0.75, 0.1875
55269, 0.45833333333333, 0.775, 0.20833333333333
55270, 0.4375, 0.8, 0.20833333333333
55271, 0.45833333333333, 0.8, 0.1875
55272, 0.45833333333333, 0.825, 0.20833333333333
55273, 0.4375, 0.85, 0.20833333333333
55274, 0.45833333333333, 0.85, 0.1875
55275, 0.45833333333333, 0.875, 0.20833333333333
55276, 0.4375, 0.9, 0.20833333333333
55277, 0.45833333333333, 0.9, 0.1875
55278, 0.45833333333333, 0.925, 0.20833333333333
55279, 0.4375, 0.95, 0.20833333333333
55280, 0.45833333333333, 0.95, 0.1875
55281, 0.45833333333333, 0.975, 0.20833333333333
55282, 0.4375, 1, 0.20833333333333
55283, 0.45833333333333, 1, 0.1875
55284, 0.45833333333333, 1.025, 0.20833333333333
55285, 0.4375, 1.05, 0.20833333333333
55286, 0.45833333333333, 1.05, 0.1875
55287, 0.45833333333333, 1.075, 0.20833333333333
55288, 0.4375, 1.1, 0.20833333333333
55289, 0.45833333333333, 1.1, 0.1875
55290, 0.45833333333333, 1.125, 0.20833333333333
55291, 0.4375, 1.15, 0.20833333333333
55292, 0.45833333333333, 1.15, 0.1875
55293, 0.45833333333333, 1.175, 0.20833333333333
55294, 0.4375, 1.2, 0.20833333333333
55295, 0.45833333333333, 1.2, 0.1875
55296, 0.45833333333333, 1.225, 0.20833333333333
55297, 0.4375, 1.25, 0.20833333333333
55298, 0.45833333333333, 1.25, 0.1875
55299, 0.45833333333333, 1.275, 0.20833333333333
55300, 0.4375, 1.3, 0.20833333333333
55301, 0.45833333333333, 1.3, 0.1875
55302, 0.45833333333333, 1.325, 0.20833333333333
55303, 0.45833333333333, 0.175, 0.25
55304, 0.4375, 0.2, 0.25
55305, 0.45833333333333, 0.2, 0.22916666666667
55306, 0.45833333333333, 0.225, 0.25
55307, 0.4375, 0.25, 0.25
55308, 0.45833333333333, 0.25, 0.22916666666667
55309, 0.45833333333333, 0.275, 0.25
55310, 0.4375, 0.3, 0.25
55311, 0.45833333333333, 0.3, 0.22916666666667
55312, 0.45833333333333, 0.325, 0.25
55313, 0.4375, 0.35, 0.25
55314, 0.45833333333333, 0.35, 0.22916666666667
55315, 0.45833333333333, 0.375, 0.25
55316, 0.4375, 0.4, 0.25
55317, 0.45833333333333, 0.4, 0.22916666666667
55318, 0.45833333333333, 0.425, 0.25
55319, 0.4375, 0.45, 0.25
55320, 0.45833333333333, 0.45, 0.22916666666667
55321, 0.45833333333333, 0.475, 0.25
55322, 0.4375, 0.5, 0.25
55323, 0.45833333333333, 0.5, 0.22916666666667
55324, 0.45833333333333, 0.525, 0.25
55325, 0.4375, 0.55, 0.25
55326, 0.45833333333333, 0.55, 0.22916666666667
55327, 0.45833333333333, 0.575, 0.25
55328, 0.4375, 0.6, 0.25
55329, 0.45833333333333, 0.6, 0.22916666666667
55330, 0.45833333333333, 0.625, 0.25
55331, 0.4375, 0.65, 0.25
55332, 0.45833333333333, 0.65, 0.22916666666667
55333, 0.45833333333333, 0.675, 0.25
55334, 0.4375, 0.7, 0.25
55335, 0.45833333333333, 0.7, 0.22916666666667
55336, 0.45833333333333, 0.725, 0.25
55337, 0.4375, 0.75, 0.25
55338, 0.45833333333333, 0.75, 0.22916666666667
55339, 0.45833333333333, 0.775, 0.25
55340, 0.4375, 0.8, 0.25
55341, 0.45833333333333, 0.8, 0.22916666666667
55342, 0.45833333333333, 0.825, 0.25
55343, 0.4375, 0.85, 0.25
55344, 0.45833333333333, 0.85, 0.22916666666667
55345, 0.45833333333333, 0.875, 0.25
55346, 0.4375, 0.9, 0.25
55347, 0.45833333333333, 0.9, 0.22916666666667
55348, 0.45833333333333, 0.925, 0.25
55349, 0.4375, 0.95, 0.25
55350, 0.45833333333333, 0.95, 0.22916666666667
55351, 0.45833333333333, 0.975, 0.25
55352, 0.4375, 1, 0.25
55353, 0.45833333333333, 1, 0.22916666666667
55354, 0.45833333333333, 1.025, 0.25
55355, 0.4375, 1.05, 0.25
55356, 0.45833333333333, 1.05, 0.22916666666667
55357, 0.45833333333333, 1.075, 0.25
55358, 0.4375, 1.1, 0.25
55359, 0.45833333333333, 1.1, 0.22916666666667
55360, 0.45833333333333, 1.125, 0.25
55361, 0.4375, 1.15, 0.25
55362, 0.45833333333333, 1.15, 0.22916666666667
55363, 0.45833333333333, 1.175, 0.25
55364, 0.4375, 1.2, 0.25
55365, 0.45833333333333, 1.2, 0.22916666666667
55366, 0.45833333333333, 1.225, 0.25
55367, 0.4375, 1.25, 0.25
55368, 0.45833333333333, 1.25, 0.22916666666667
55369, 0.45833333333333, 1.275, 0.25
55370, 0.4375, 1.3, 0.25
55371, 0.45833333333333, 1.3, 0.22916666666667
55372, 0.45833333333333, 1.325, 0.25
55373, 0.45833333333333, 0.175, 0.29166666666667
55374, 0.4375, 0.2, 0.29166666666667
55375, 0.45833333333333, 0.2, 0.27083333333333
55376, 0.45833333333333, 0.225, 0.29166666666667
55377, 0.4375, 0.25, 0.29166666666667
55378, 0.45833333333333, 0.25, 0.27083333333333
55379, 0.45833333333333, 0.275, 0.29166666666667
55380, 0.4375, 0.3, 0.29166666666667
55381, 0.45833333333333, 0.3, 0.27083333333333
55382, 0.45833333333333, 0.325, 0.29166666666667
55383, 0.4375, 0.35, 0.29166666666667
55384, 0.45833333333333, 0.35, 0.27083333333333
55385, 0.45833333333333, 0.375, 0.29166666666667
55386, 0.4375, 0.4, 0.29166666666667
55387, 0.45833333333333, 0.4, 0.27083333333333
55388, 0.45833333333333, 0.425, 0.29166666666667
55389, 0.4375, 0.45, 0.29166666666667
55390, 0.45833333333333, 0.45, 0.27083333333333
55391, 0.45833333333333, 0.475, 0.29166666666667
55392, 0.4375, 0.5, 0.29166666666667
55393, 0.45833333333333, 0.5, 0.27083333333333
55394, 0.45833333333333, 0.525, 0.29166666666667
55395, 0.4375, 0.55, 0.29166666666667
55396, 0.45833333333333, 0.55, 0.27083333333333
55397, 0.45833333333333, 0.575, 0.29166666666667
55398, 0.4375, 0.6, 0.29166666666667
55399, 0.45833333333333, 0.6, 0.27083333333333
55400, 0.45833333333333, 0.625, 0.29166666666667
55401, 0.4375, 0.65, 0.29166666666667
55402, 0.45833333333333, 0.65, 0.27083333333333
55403, 0.45833333333333, 0.675, 0.29166666666667
55404, 0.4375, 0.7, 0.29166666666667
55405, 0.45833333333333, 0.7, 0.27083333333333
55406, 0.45833333333333, 0.725, 0.29166666666667
55407, 0.4375, 0.75, 0.29166666666667
55408, 0.45833333333333, 0.75, 0.27083333333333
55409, 0.45833333333333, 0.775, 0.29166666666667
55410, 0.4375, 0.8, 0.29166666666667
55411, 0.45833333333333, 0.8, 0.27083333333333
55412, 0.45833333333333, 0.825, 0.29166666666667
55413, 0.4375, 0.85, 0.29166666666667
55414, 0.45833333333333, 0.85, 0.27083333333333
55415, 0.45833333333333, 0.875, 0.29166666666667
55416, 0.4375, 0.9, 0.29166666666667
55417, 0.45833333333333, 0.9, 0.27083333333333
55418, 0.45833333333333, 0.925, 0.29166666666667
55419, 0.4375, 0.95, 0.29166666666667
55420, 0.45833333333333, 0.95, 0.27083333333333
55421, 0.45833333333333, 0.975, 0.29166666666667
55422, 0.4375, 1, 0.29166666666667
55423, 0.45833333333333, 1, 0.27083333333333
55424, 0.45833333333333, 1.025, 0.29166666666667
55425, 0.4375, 1.05, 0.29166666666667
55426, 0.45833333333333, 1.05, 0.27083333333333
55427, 0.45833333333333, 1.075, 0.29166666666667
55428, 0.4375, 1.1, 0.29166666666667
55429, 0.45833333333333, 1.1, 0.27083333333333
55430, 0.45833333333333, 1.125, 0.29166666666667
55431, 0.4375, 1.15, 0.29166666666667
55432, 0.45833333333333, 1.15, 0.27083333333333
55433, 0.45833333333333, 1.175, 0.29166666666667
55434, 0.4375, 1.2, 0.29166666666667
55435, 0.45833333333333, 1.2, 0.27083333333333
55436, 0.45833333333333, 1.225, 0.29166666666667
55437, 0.4375, 1.25, 0.29166666666667
55438, 0.45833333333333, 1.25, 0.27083333333333
55439, 0.45833333333333, 1.275, 0.29166666666667
55440, 0.4375, 1.3, 0.29166666666667
55441, 0.45833333333333, 1.3, 0.27083333333333
55442, 0.45833333333333, 1.325, 0.29166666666667
55443, 0.45833333333333, 0.175, 0.33333333333333
55444, 0.4375, 0.2, 0.33333333333333
55445, 0.45833333333333, 0.2, 0.3125
55446, 0.45833333333333, 0.225, 0.33333333333333
55447, 0.4375, 0.25, 0.33333333333333
55448, 0.45833333333333, 0.25, 0.3125
55449, 0.45833333333333, 0.275, 0.33333333333333
55450, 0.4375, 0.3, 0.33333333333333
55451, 0.45833333333333, 0.3, 0.3125
55452, 0.45833333333333, 0.325, 0.33333333333333
55453, 0.4375, 0.35, 0.33333333333333
55454, 0.45833333333333, 0.35, 0.3125
55455, 0.45833333333333, 0.375, 0.33333333333333
55456, 0.4375, 0.4, 0.33333333333333
55457, 0.45833333333333, 0.4, 0.3125
55458, 0.45833333333333, 0.425, 0.33333333333333
55459, 0.4375, 0.45, 0.33333333333333
55460, 0.45833333333333, 0.45, 0.3125
55461, 0.45833333333333, 0.475, 0.33333333333333
55462, 0.4375, 0.5, 0.33333333333333
55463, 0.45833333333333, 0.5, 0.3125
55464, 0.45833333333333, 0.525, 0.33333333333333
55465, 0.4375, 0.55, 0.33333333333333
55466, 0.45833333333333, 0.55, 0.3125
55467, 0.45833333333333, 0.575, 0.33333333333333
55468, 0.4375, 0.6, 0.33333333333333
55469, 0.45833333333333, 0.6, 0.3125
55470, 0.45833333333333, 0.625, 0.33333333333333
55471, 0.4375, 0.65, 0.33333333333333
55472, 0.45833333333333, 0.65, 0.3125
55473, 0.45833333333333, 0.675, 0.33333333333333
55474, 0.4375, 0.7, 0.33333333333333
55475, 0.45833333333333, 0.7, 0.3125
55476, 0.45833333333333, 0.725, 0.33333333333333
55477, 0.4375, 0.75, 0.33333333333333
55478, 0.45833333333333, 0.75, 0.3125
55479, 0.45833333333333, 0.775, 0.33333333333333
55480, 0.4375, 0.8, 0.33333333333333
55481, 0.45833333333333, 0.8, 0.3125
55482, 0.45833333333333, 0.825, 0.33333333333333
55483, 0.4375, 0.85, 0.33333333333333
55484, 0.45833333333333, 0.85, 0.3125
55485, 0.45833333333333, 0.875, 0.33333333333333
55486, 0.4375, 0.9, 0.33333333333333
55487, 0.45833333333333, 0.9, 0.3125
55488, 0.45833333333333, 0.925, 0.33333333333333
55489, 0.4375, 0.95, 0.33333333333333
55490, 0.45833333333333, 0.95, 0.3125
55491, 0.45833333333333, 0.975, 0.33333333333333
55492, 0.4375, 1, 0.33333333333333
55493, 0.45833333333333, 1, 0.3125
55494, 0.45833333333333, 1.025, 0.33333333333333
55495, 0.4375, 1.05, 0.33333333333333
55496, 0.45833333333333, 1.05, 0.3125
55497, 0.45833333333333, 1.075, 0.33333333333333
55498, 0.4375, 1.1, 0.33333333333333
55499, 0.45833333333333, 1.1, 0.3125
55500, 0.45833333333333, 1.125, 0.33333333333333
55501, 0.4375, 1.15, 0.33333333333333
55502, 0.45833333333333, 1.15, 0.3125
55503, 0.45833333333333, 1.175, 0.33333333333333
55504, 0.4375, 1.2, 0.33333333333333
55505, 0.45833333333333, 1.2, 0.3125
55506, 0.45833333333333, 1.225, 0.33333333333333
55507, 0.4375, 1.25, 0.33333333333333
55508, 0.45833333333333, 1.25, 0.3125
55509, 0.45833333333333, 1.275, 0.33333333333333
55510, 0.4375, 1.3, 0.33333333333333
55511, 0.45833333333333, 1.3, 0.3125
55512, 0.45833333333333, 1.325, 0.33333333333333
55513, 0.45833333333333, 0.175, 0.375
55514, 0.4375, 0.2, 0.375
55515, 0.45833333333333, 0.2, 0.35416666666667
55516, 0.45833333333333, 0.225, 0.375
55517, 0.4375, 0.25, 0.375
55518, 0.45833333333333, 0.25, 0.35416666666667
55519, 0.45833333333333, 0.275, 0.375
55520, 0.4375, 0.3, 0.375
55521, 0.45833333333333, 0.3, 0.35416666666667
55522, 0.45833333333333, 0.325, 0.375
55523, 0.4375, 0.35, 0.375
55524, 0.45833333333333, 0.35, 0.35416666666667
55525, 0.45833333333333, 0.375, 0.375
55526, 0.4375, 0.4, 0.375
55527, 0.45833333333333, 0.4, 0.35416666666667
55528, 0.45833333333333, 0.425, 0.375
55529, 0.4375, 0.45, 0.375
55530, 0.45833333333333, 0.45, 0.35416666666667
55531, 0.45833333333333, 0.475, 0.375
55532, 0.4375, 0.5, 0.375
55533, 0.45833333333333, 0.5, 0.35416666666667
55534, 0.45833333333333, 0.525, 0.375
55535, 0.4375, 0.55, 0.375
55536, 0.45833333333333, 0.55, 0.35416666666667
55537, 0.45833333333333, 0.575, 0.375
55538, 0.4375, 0.6, 0.375
55539, 0.45833333333333, 0.6, 0.35416666666667
55540, 0.45833333333333, 0.625, 0.375
55541, 0.4375, 0.65, 0.375
55542, 0.45833333333333, 0.65, 0.35416666666667
55543, 0.45833333333333, 0.675, 0.375
55544, 0.4375, 0.7, 0.375
55545, 0.45833333333333, 0.7, 0.35416666666667
55546, 0.45833333333333, 0.725, 0.375
55547, 0.4375, 0.75, 0.375
55548, 0.45833333333333, 0.75, 0.35416666666667
55549, 0.45833333333333, 0.775, 0.375
55550, 0.4375, 0.8, 0.375
55551, 0.45833333333333, 0.8, 0.35416666666667
55552, 0.45833333333333, 0.825, 0.375
55553, 0.4375, 0.85, 0.375
55554, 0.45833333333333, 0.85, 0.35416666666667
55555, 0.45833333333333, 0.875, 0.375
55556, 0.4375, 0.9, 0.375
55557, 0.45833333333333, 0.9, 0.35416666666667
55558, 0.45833333333333, 0.925, 0.375
55559, 0.4375, 0.95, 0.375
55560, 0.45833333333333, 0.95, 0.35416666666667
55561, 0.45833333333333, 0.975, 0.375
55562, 0.4375, 1, 0.375
55563, 0.45833333333333, 1, 0.35416666666667
55564, 0.45833333333333, 1.025, 0.375
55565, 0.4375, 1.05, 0.375
55566, 0.45833333333333, 1.05, 0.35416666666667
55567, 0.45833333333333, 1.075, 0.375
55568, 0.4375, 1.1, 0.375
55569, 0.45833333333333, 1.1, 0.35416666666667
55570, 0.45833333333333, 1.125, 0.375
55571, 0.4375, 1.15, 0.375
55572, 0.45833333333333, 1.15, 0.35416666666667
55573, 0.45833333333333, 1.175, 0.375
55574, 0.4375, 1.2, 0.375
55575, 0.45833333333333, 1.2, 0.35416666666667
55576, 0.45833333333333, 1.225, 0.375
55577, 0.4375, 1.25, 0.375
55578, 0.45833333333333, 1.25, 0.35416666666667
55579, 0.45833333333333, 1.275, 0.375
55580, 0.4375, 1.3, 0.375
55581, 0.45833333333333, 1.3, 0.35416666666667
55582, 0.45833333333333, 1.325, 0.375
55583, 0.45833333333333, 0.175, 0.41666666666667
55584, 0.4375, 0.2, 0.41666666666667
55585, 0.45833333333333, 0.2, 0.39583333333333
55586, 0.45833333333333, 0.225, 0.41666666666667
55587, 0.4375, 0.25, 0.41666666666667
55588, 0.45833333333333, 0.25, 0.39583333333333
55589, 0.45833333333333, 0.275, 0.41666666666667
55590, 0.4375, 0.3, 0.41666666666667
55591, 0.45833333333333, 0.3, 0.39583333333333
55592, 0.45833333333333, 0.325, 0.41666666666667
55593, 0.4375, 0.35, 0.41666666666667
55594, 0.45833333333333, 0.35, 0.39583333333333
55595, 0.45833333333333, 0.375, 0.41666666666667
55596, 0.4375, 0.4, 0.41666666666667
55597, 0.45833333333333, 0.4, 0.39583333333333
55598, 0.45833333333333, 0.425, 0.41666666666667
55599, 0.4375, 0.45, 0.41666666666667
55600, 0.45833333333333, 0.45, 0.39583333333333
55601, 0.45833333333333, 0.475, 0.41666666666667
55602, 0.4375, 0.5, 0.41666666666667
55603, 0.45833333333333, 0.5, 0.39583333333333
55604, 0.45833333333333, 0.525, 0.41666666666667
55605, 0.4375, 0.55, 0.41666666666667
55606, 0.45833333333333, 0.55, 0.39583333333333
55607, 0.45833333333333, 0.575, 0.41666666666667
55608, 0.4375, 0.6, 0.41666666666667
55609, 0.45833333333333, 0.6, 0.39583333333333
55610, 0.45833333333333, 0.625, 0.41666666666667
55611, 0.4375, 0.65, 0.41666666666667
55612, 0.45833333333333, 0.65, 0.39583333333333
55613, 0.45833333333333, 0.675, 0.41666666666667
55614, 0.4375, 0.7, 0.41666666666667
55615, 0.45833333333333, 0.7, 0.39583333333333
55616, 0.45833333333333, 0.725, 0.41666666666667
55617, 0.4375, 0.75, 0.41666666666667
55618, 0.45833333333333, 0.75, 0.39583333333333
55619, 0.45833333333333, 0.775, 0.41666666666667
55620, 0.4375, 0.8, 0.41666666666667
55621, 0.45833333333333, 0.8, 0.39583333333333
55622, 0.45833333333333, 0.825, 0.41666666666667
55623, 0.4375, 0.85, 0.41666666666667
55624, 0.45833333333333, 0.85, 0.39583333333333
55625, 0.45833333333333, 0.875, 0.41666666666667
55626, 0.4375, 0.9, 0.41666666666667
55627, 0.45833333333333, 0.9, 0.39583333333333
55628, 0.45833333333333, 0.925, 0.41666666666667
55629, 0.4375, 0.95, 0.41666666666667
55630, 0.45833333333333, 0.95, 0.39583333333333
55631, 0.45833333333333, 0.975, 0.41666666666667
55632, 0.4375, 1, 0.41666666666667
55633, 0.45833333333333, 1, 0.39583333333333
55634, 0.45833333333333, 1.025, 0.41666666666667
55635, 0.4375, 1.05, 0.41666666666667
55636, 0.45833333333333, 1.05, 0.39583333333333
55637, 0.45833333333333, 1.075, 0.41666666666667
55638, 0.4375, 1.1, 0.41666666666667
55639, 0.45833333333333, 1.1, 0.39583333333333
55640, 0.45833333333333, 1.125, 0.41666666666667
55641, 0.4375, 1.15, 0.41666666666667
55642, 0.45833333333333, 1.15, 0.39583333333333
55643, 0.45833333333333, 1.175, 0.41666666666667
55644, 0.4375, 1.2, 0.41666666666667
55645, 0.45833333333333, 1.2, 0.39583333333333
55646, 0.45833333333333, 1.225, 0.41666666666667
55647, 0.4375, 1.25, 0.41666666666667
55648, 0.45833333333333, 1.25, 0.39583333333333
55649, 0.45833333333333, 1.275, 0.41666666666667
55650, 0.4375, 1.3, 0.41666666666667
55651, 0.45833333333333, 1.3, 0.39583333333333
55652, 0.45833333333333, 1.325, 0.41666666666667
55653, 0.45833333333333, 0.175, 0.45833333333333
55654, 0.4375, 0.2, 0.45833333333333
55655, 0.45833333333333, 0.2, 0.4375
55656, 0.45833333333333, 0.225, 0.45833333333333
55657, 0.4375, 0.25, 0.45833333333333
55658, 0.45833333333333, 0.25, 0.4375
55659, 0.45833333333333, 0.275, 0.45833333333333
55660, 0.4375, 0.3, 0.45833333333333
55661, 0.45833333333333, 0.3, 0.4375
55662, 0.45833333333333, 0.325, 0.45833333333333
55663, 0.4375, 0.35, 0.45833333333333
55664, 0.45833333333333, 0.35, 0.4375
55665, 0.45833333333333, 0.375, 0.45833333333333
55666, 0.4375, 0.4, 0.45833333333333
55667, 0.45833333333333, 0.4, 0.4375
55668, 0.45833333333333, 0.425, 0.45833333333333
55669, 0.4375, 0.45, 0.45833333333333
55670, 0.45833333333333, 0.45, 0.4375
55671, 0.45833333333333, 0.475, 0.45833333333333
55672, 0.4375, 0.5, 0.45833333333333
55673, 0.45833333333333, 0.5, 0.4375
55674, 0.45833333333333, 0.525, 0.45833333333333
55675, 0.4375, 0.55, 0.45833333333333
55676, 0.45833333333333, 0.55, 0.4375
55677, 0.45833333333333, 0.575, 0.45833333333333
55678, 0.4375, 0.6, 0.45833333333333
55679, 0.45833333333333, 0.6, 0.4375
55680, 0.45833333333333, 0.625, 0.45833333333333
55681, 0.4375, 0.65, 0.45833333333333
55682, 0.45833333333333, 0.65, 0.4375
55683, 0.45833333333333, 0.675, 0.45833333333333
55684, 0.4375, 0.7, 0.45833333333333
55685, 0.45833333333333, 0.7, 0.4375
55686, 0.45833333333333, 0.725, 0.45833333333333
55687, 0.4375, 0.75, 0.45833333333333
55688, 0.45833333333333, 0.75, 0.4375
55689, 0.45833333333333, 0.775, 0.45833333333333
55690, 0.4375, 0.8, 0.45833333333333
55691, 0.45833333333333, 0.8, 0.4375
55692, 0.45833333333333, 0.825, 0.45833333333333
55693, 0.4375, 0.85, 0.45833333333333
55694, 0.45833333333333, 0.85, 0.4375
55695, 0.45833333333333, 0.875, 0.45833333333333
55696, 0.4375, 0.9, 0.45833333333333
55697, 0.45833333333333, 0.9, 0.4375
55698, 0.45833333333333, 0.925, 0.45833333333333
55699, 0.4375, 0.95, 0.45833333333333
55700, 0.45833333333333, 0.95, 0.4375
55701, 0.45833333333333, 0.975, 0.45833333333333
55702, 0.4375, 1, 0.45833333333333
55703, 0.45833333333333, 1, 0.4375
55704, 0.45833333333333, 1.025, 0.45833333333333
55705, 0.4375, 1.05, 0.45833333333333
55706, 0.45833333333333, 1.05, 0.4375
55707, 0.45833333333333, 1.075, 0.45833333333333
55708, 0.4375, 1.1, 0.45833333333333
55709, 0.45833333333333, 1.1, 0.4375
55710, 0.45833333333333, 1.125, 0.45833333333333
55711, 0.4375, 1.15, 0.45833333333333
55712, 0.45833333333333, 1.15, 0.4375
55713, 0.45833333333333, 1.175, 0.45833333333333
55714, 0.4375, 1.2, 0.45833333333333
55715, 0.45833333333333, 1.2, 0.4375
55716, 0.45833333333333, 1.225, 0.45833333333333
55717, 0.4375, 1.25, 0.45833333333333
55718, 0.45833333333333, 1.25, 0.4375
55719, 0.45833333333333, 1.275, 0.45833333333333
55720, 0.4375, 1.3, 0.45833333333333
55721, 0.45833333333333, 1.3, 0.4375
55722, 0.45833333333333, 1.325, 0.45833333333333
55723, 0.45833333333333, 0.2, 0.47916666666667
55724, 0.45833333333333, 0.25, 0.47916666666667
55725, 0.45833333333333, 0.3, 0.47916666666667
55726, 0.45833333333333, 0.35, 0.47916666666667
55727, 0.45833333333333, 0.4, 0.47916666666667
55728, 0.45833333333333, 0.45, 0.47916666666667
55729, 0.45833333333333, 0.5, 0.47916666666667
55730, 0.45833333333333, 0.55, 0.47916666666667
55731, 0.45833333333333, 0.6, 0.47916666666667
55732, 0.45833333333333, 0.65, 0.47916666666667
55733, 0.45833333333333, 0.7, 0.47916666666667
55734, 0.45833333333333, 0.75, 0.47916666666667
55735, 0.45833333333333, 0.8, 0.47916666666667
55736, 0.45833333333333, 0.85, 0.47916666666667
55737, 0.45833333333333, 0.9, 0.47916666666667
55738, 0.45833333333333, 0.95, 0.47916666666667
55739, 0.45833333333333, 1, 0.47916666666667
55740, 0.45833333333333, 1.05, 0.47916666666667
55741, 0.45833333333333, 1.1, 0.47916666666667
55742, 0.45833333333333, 1.15, 0.47916666666667
55743, 0.45833333333333, 1.2, 0.47916666666667
55744, 0.45833333333333, 1.25, 0.47916666666667
55745, 0.45833333333333, 1.3, 0.47916666666667
55746, 0.5, 0.175, 0.041666666666667
55747, 0.47916666666667, 0.2, 0.041666666666667
55748, 0.5, 0.2, 0.020833333333333
55749, 0.5, 0.225, 0.041666666666667
55750, 0.47916666666667, 0.25, 0.041666666666667
55751, 0.5, 0.25, 0.020833333333333
55752, 0.5, 0.275, 0.041666666666667
55753, 0.47916666666667, 0.3, 0.041666666666667
55754, 0.5, 0.3, 0.020833333333333
55755, 0.5, 0.325, 0.041666666666667
55756, 0.47916666666667, 0.35, 0.041666666666667
55757, 0.5, 0.35, 0.020833333333333
55758, 0.5, 0.375, 0.041666666666667
55759, 0.47916666666667, 0.4, 0.041666666666667
55760, 0.5, 0.4, 0.020833333333333
55761, 0.5, 0.425, 0.041666666666667
55762, 0.47916666666667, 0.45, 0.041666666666667
55763, 0.5, 0.45, 0.020833333333333
55764, 0.5, 0.475, 0.041666666666667
55765, 0.47916666666667, 0.5, 0.041666666666667
55766, 0.5, 0.5, 0.020833333333333
55767, 0.5, 0.525, 0.041666666666667
55768, 0.47916666666667, 0.55, 0.041666666666667
55769, 0.5, 0.55, 0.020833333333333
55770, 0.5, 0.575, 0.041666666666667
55771, 0.47916666666667, 0.6, 0.041666666666667
55772, 0.5, 0.6, 0.020833333333333
55773, 0.5, 0.625, 0.041666666666667
55774, 0.47916666666667, 0.65, 0.041666666666667
55775, 0.5, 0.65, 0.020833333333333
55776, 0.5, 0.675, 0.041666666666667
55777, 0.47916666666667, 0.7, 0.041666666666667
55778, 0.5, 0.7, 0.020833333333333
55779, 0.5, 0.725, 0.041666666666667
55780, 0.47916666666667, 0.75, 0.041666666666667
55781, 0.5, 0.75, 0.020833333333333
55782, 0.5, 0.775, 0.041666666666667
55783, 0.47916666666667, 0.8, 0.041666666666667
55784, 0.5, 0.8, 0.020833333333333
55785, 0.5, 0.825, 0.041666666666667
55786, 0.47916666666667, 0.85, 0.041666666666667
55787, 0.5, 0.85, 0.020833333333333
55788, 0.5, 0.875, 0.041666666666667
55789, 0.47916666666667, 0.9, 0.041666666666667
55790, 0.5, 0.9, 0.020833333333333
55791, 0.5, 0.925, 0.041666666666667
55792, 0.47916666666667, 0.95, 0.041666666666667
55793, 0.5, 0.95, 0.020833333333333
55794, 0.5, 0.975, 0.041666666666667
55795, 0.47916666666667, 1, 0.041666666666667
55796, 0.5, 1, 0.020833333333333
55797, 0.5, 1.025, 0.041666666666667
55798, 0.47916666666667, 1.05, 0.041666666666667
55799, 0.5, 1.05, 0.020833333333333
55800, 0.5, 1.075, 0.041666666666667
55801, 0.47916666666667, 1.1, 0.041666666666667
55802, 0.5, 1.1, 0.020833333333333
55803, 0.5, 1.125, 0.041666666666667
55804, 0.47916666666667, 1.15, 0.041666666666667
55805, 0.5, 1.15, 0.020833333333333
55806, 0.5, 1.175, 0.041666666666667
55807, 0.47916666666667, 1.2, 0.041666666666667
55808, 0.5, 1.2, 0.020833333333333
55809, 0.5, 1.225, 0.041666666666667
55810, 0.47916666666667, 1.25, 0.041666666666667
55811, 0.5, 1.25, 0.020833333333333
55812, 0.5, 1.275, 0.041666666666667
55813, 0.47916666666667, 1.3, 0.041666666666667
55814, 0.5, 1.3, 0.020833333333333
55815, 0.5, 1.325, 0.041666666666667
55816, 0.5, 0.175, 0.083333333333333
55817, 0.47916666666667, 0.2, 0.083333333333333
55818, 0.5, 0.2, 0.0625
55819, 0.5, 0.225, 0.083333333333333
55820, 0.47916666666667, 0.25, 0.083333333333333
55821, 0.5, 0.25, 0.0625
55822, 0.5, 0.275, 0.083333333333333
55823, 0.47916666666667, 0.3, 0.083333333333333
55824, 0.5, 0.3, 0.0625
55825, 0.5, 0.325, 0.083333333333333
55826, 0.47916666666667, 0.35, 0.083333333333333
55827, 0.5, 0.35, 0.0625
55828, 0.5, 0.375, 0.083333333333333
55829, 0.47916666666667, 0.4, 0.083333333333333
55830, 0.5, 0.4, 0.0625
55831, 0.5, 0.425, 0.083333333333333
55832, 0.47916666666667, 0.45, 0.083333333333333
55833, 0.5, 0.45, 0.0625
55834, 0.5, 0.475, 0.083333333333333
55835, 0.47916666666667, 0.5, 0.083333333333333
55836, 0.5, 0.5, 0.0625
55837, 0.5, 0.525, 0.083333333333333
55838, 0.47916666666667, 0.55, 0.083333333333333
55839, 0.5, 0.55, 0.0625
55840, 0.5, 0.575, 0.083333333333333
55841, 0.47916666666667, 0.6, 0.083333333333333
55842, 0.5, 0.6, 0.0625
55843, 0.5, 0.625, 0.083333333333333
55844, 0.47916666666667, 0.65, 0.083333333333333
55845, 0.5, 0.65, 0.0625
55846, 0.5, 0.675, 0.083333333333333
55847, 0.47916666666667, 0.7, 0.083333333333333
55848, 0.5, 0.7, 0.0625
55849, 0.5, 0.725, 0.083333333333333
55850, 0.47916666666667, 0.75, 0.083333333333333
55851, 0.5, 0.75, 0.0625
55852, 0.5, 0.775, 0.083333333333333
55853, 0.47916666666667, 0.8, 0.083333333333333
55854, 0.5, 0.8, 0.0625
55855, 0.5, 0.825, 0.083333333333333
55856, 0.47916666666667, 0.85, 0.083333333333333
55857, 0.5, 0.85, 0.0625
55858, 0.5, 0.875, 0.083333333333333
55859, 0.47916666666667, 0.9, 0.083333333333333
55860, 0.5, 0.9, 0.0625
55861, 0.5, 0.925, 0.083333333333333
55862, 0.47916666666667, 0.95, 0.083333333333333
55863, 0.5, 0.95, 0.0625
55864, 0.5, 0.975, 0.083333333333333
55865, 0.47916666666667, 1, 0.083333333333333
55866, 0.5, 1, 0.0625
55867, 0.5, 1.025, 0.083333333333333
55868, 0.47916666666667, 1.05, 0.083333333333333
55869, 0.5, 1.05, 0.0625
55870, 0.5, 1.075, 0.083333333333333
55871, 0.47916666666667, 1.1, 0.083333333333333
55872, 0.5, 1.1, 0.0625
55873, 0.5, 1.125, 0.083333333333333
55874, 0.47916666666667, 1.15, 0.083333333333333
55875, 0.5, 1.15, 0.0625
55876, 0.5, 1.175, 0.083333333333333
55877, 0.47916666666667, 1.2, 0.083333333333333
55878, 0.5, 1.2, 0.0625
55879, 0.5, 1.225, 0.083333333333333
55880, 0.47916666666667, 1.25, 0.083333333333333
55881, 0.5, 1.25, 0.0625
55882, 0.5, 1.275, 0.083333333333333
55883, 0.47916666666667, 1.3, 0.083333333333333
55884, 0.5, 1.3, 0.0625
55885, 0.5, 1.325, 0.083333333333333
55886, 0.5, 0.175, 0.125
55887, 0.47916666666667, 0.2, 0.125
55888, 0.5, 0.2, 0.10416666666667
55889, 0.5, 0.225, 0.125
55890, 0.47916666666667, 0.25, 0.125
55891, 0.5, 0.25, 0.10416666666667
55892, 0.5, 0.275, 0.125
55893, 0.47916666666667, 0.3, 0.125
55894, 0.5, 0.3, 0.10416666666667
55895, 0.5, 0.325, 0.125
55896, 0.47916666666667, 0.35, 0.125
55897, 0.5, 0.35, 0.10416666666667
55898, 0.5, 0.375, 0.125
55899, 0.47916666666667, 0.4, 0.125
55900, 0.5, 0.4, 0.10416666666667
55901, 0.5, 0.425, 0.125
55902, 0.47916666666667, 0.45, 0.125
55903, 0.5, 0.45, 0.10416666666667
55904, 0.5, 0.475, 0.125
55905, 0.47916666666667, 0.5, 0.125
55906, 0.5, 0.5, 0.10416666666667
55907, 0.5, 0.525, 0.125
55908, 0.47916666666667, 0.55, 0.125
55909, 0.5, 0.55, 0.10416666666667
55910, 0.5, 0.575, 0.125
55911, 0.47916666666667, 0.6, 0.125
55912, 0.5, 0.6, 0.10416666666667
55913, 0.5, 0.625, 0.125
55914, 0.47916666666667, 0.65, 0.125
55915, 0.5, 0.65, 0.10416666666667
55916, 0.5, 0.675, 0.125
55917, 0.47916666666667, 0.7, 0.125
55918, 0.5, 0.7, 0.10416666666667
55919, 0.5, 0.725, 0.125
55920, 0.47916666666667, 0.75, 0.125
55921, 0.5, 0.75, 0.10416666666667
55922, 0.5, 0.775, 0.125
55923, 0.47916666666667, 0.8, 0.125
55924, 0.5, 0.8, 0.10416666666667
55925, 0.5, 0.825, 0.125
55926, 0.47916666666667, 0.85, 0.125
55927, 0.5, 0.85, 0.10416666666667
55928, 0.5, 0.875, 0.125
55929, 0.47916666666667, 0.9, 0.125
55930, 0.5, 0.9, 0.10416666666667
55931, 0.5, 0.925, 0.125
55932, 0.47916666666667, 0.95, 0.125
55933, 0.5, 0.95, 0.10416666666667
55934, 0.5, 0.975, 0.125
55935, 0.47916666666667, 1, 0.125
55936, 0.5, 1, 0.10416666666667
55937, 0.5, 1.025, 0.125
55938, 0.47916666666667, 1.05, 0.125
55939, 0.5, 1.05, 0.10416666666667
55940, 0.5, 1.075, 0.125
55941, 0.47916666666667, 1.1, 0.125
55942, 0.5, 1.1, 0.10416666666667
55943, 0.5, 1.125, 0.125
55944, 0.47916666666667, 1.15, 0.125
55945, 0.5, 1.15, 0.10416666666667
55946, 0.5, 1.175, 0.125
55947, 0.47916666666667, 1.2, 0.125
55948, 0.5, 1.2, 0.10416666666667
55949, 0.5, 1.225, 0.125
55950, 0.47916666666667, 1.25, 0.125
55951, 0.5, 1.25, 0.10416666666667
55952, 0.5, 1.275, 0.125
55953, 0.47916666666667, 1.3, 0.125
55954, 0.5, 1.3, 0.10416666666667
55955, 0.5, 1.325, 0.125
55956, 0.5, 0.175, 0.16666666666667
55957, 0.47916666666667, 0.2, 0.16666666666667
55958, 0.5, 0.2, 0.14583333333333
55959, 0.5, 0.225, 0.16666666666667
55960, 0.47916666666667, 0.25, 0.16666666666667
55961, 0.5, 0.25, 0.14583333333333
55962, 0.5, 0.275, 0.16666666666667
55963, 0.47916666666667, 0.3, 0.16666666666667
55964, 0.5, 0.3, 0.14583333333333
55965, 0.5, 0.325, 0.16666666666667
55966, 0.47916666666667, 0.35, 0.16666666666667
55967, 0.5, 0.35, 0.14583333333333
55968, 0.5, 0.375, 0.16666666666667
55969, 0.47916666666667, 0.4, 0.16666666666667
55970, 0.5, 0.4, 0.14583333333333
55971, 0.5, 0.425, 0.16666666666667
55972, 0.47916666666667, 0.45, 0.16666666666667
55973, 0.5, 0.45, 0.14583333333333
55974, 0.5, 0.475, 0.16666666666667
55975, 0.47916666666667, 0.5, 0.16666666666667
55976, 0.5, 0.5, 0.14583333333333
55977, 0.5, 0.525, 0.16666666666667
55978, 0.47916666666667, 0.55, 0.16666666666667
55979, 0.5, 0.55, 0.14583333333333
55980, 0.5, 0.575, 0.16666666666667
55981, 0.47916666666667, 0.6, 0.16666666666667
55982, 0.5, 0.6, 0.14583333333333
55983, 0.5, 0.625, 0.16666666666667
55984, 0.47916666666667, 0.65, 0.16666666666667
55985, 0.5, 0.65, 0.14583333333333
55986, 0.5, 0.675, 0.16666666666667
55987, 0.47916666666667, 0.7, 0.16666666666667
55988, 0.5, 0.7, 0.14583333333333
55989, 0.5, 0.725, 0.16666666666667
55990, 0.47916666666667, 0.75, 0.16666666666667
55991, 0.5, 0.75, 0.14583333333333
55992, 0.5, 0.775, 0.16666666666667
55993, 0.47916666666667, 0.8, 0.16666666666667
55994, 0.5, 0.8, 0.14583333333333
55995, 0.5, 0.825, 0.16666666666667
55996, 0.47916666666667, 0.85, 0.16666666666667
55997, 0.5, 0.85, 0.14583333333333
55998, 0.5, 0.875, 0.16666666666667
55999, 0.47916666666667, 0.9, 0.16666666666667
56000, 0.5, 0.9, 0.14583333333333
56001, 0.5, 0.925, 0.16666666666667
56002, 0.47916666666667, 0.95, 0.16666666666667
56003, 0.5, 0.95, 0.14583333333333
56004, 0.5, 0.975, 0.16666666666667
56005, 0.47916666666667, 1, 0.16666666666667
56006, 0.5, 1, 0.14583333333333
56007, 0.5, 1.025, 0.16666666666667
56008, 0.47916666666667, 1.05, 0.16666666666667
56009, 0.5, 1.05, 0.14583333333333
56010, 0.5, 1.075, 0.16666666666667
56011, 0.47916666666667, 1.1, 0.16666666666667
56012, 0.5, 1.1, 0.14583333333333
56013, 0.5, 1.125, 0.16666666666667
56014, 0.47916666666667, 1.15, 0.16666666666667
56015, 0.5, 1.15, 0.14583333333333
56016, 0.5, 1.175, 0.16666666666667
56017, 0.47916666666667, 1.2, 0.16666666666667
56018, 0.5, 1.2, 0.14583333333333
56019, 0.5, 1.225, 0.16666666666667
56020, 0.47916666666667, 1.25, 0.16666666666667
56021, 0.5, 1.25, 0.14583333333333
56022, 0.5, 1.275, 0.16666666666667
56023, 0.47916666666667, 1.3, 0.16666666666667
56024, 0.5, 1.3, 0.14583333333333
56025, 0.5, 1.325, 0.16666666666667
56026, 0.5, 0.175, 0.20833333333333
56027, 0.47916666666667, 0.2, 0.20833333333333
56028, 0.5, 0.2, 0.1875
56029, 0.5, 0.225, 0.20833333333333
56030, 0.47916666666667, 0.25, 0.20833333333333
56031, 0.5, 0.25, 0.1875
56032, 0.5, 0.275, 0.20833333333333
56033, 0.47916666666667, 0.3, 0.20833333333333
56034, 0.5, 0.3, 0.1875
56035, 0.5, 0.325, 0.20833333333333
56036, 0.47916666666667, 0.35, 0.20833333333333
56037, 0.5, 0.35, 0.1875
56038, 0.5, 0.375, 0.20833333333333
56039, 0.47916666666667, 0.4, 0.20833333333333
56040, 0.5, 0.4, 0.1875
56041, 0.5, 0.425, 0.20833333333333
56042, 0.47916666666667, 0.45, 0.20833333333333
56043, 0.5, 0.45, 0.1875
56044, 0.5, 0.475, 0.20833333333333
56045, 0.47916666666667, 0.5, 0.20833333333333
56046, 0.5, 0.5, 0.1875
56047, 0.5, 0.525, 0.20833333333333
56048, 0.47916666666667, 0.55, 0.20833333333333
56049, 0.5, 0.55, 0.1875
56050, 0.5, 0.575, 0.20833333333333
56051, 0.47916666666667, 0.6, 0.20833333333333
56052, 0.5, 0.6, 0.1875
56053, 0.5, 0.625, 0.20833333333333
56054, 0.47916666666667, 0.65, 0.20833333333333
56055, 0.5, 0.65, 0.1875
56056, 0.5, 0.675, 0.20833333333333
56057, 0.47916666666667, 0.7, 0.20833333333333
56058, 0.5, 0.7, 0.1875
56059, 0.5, 0.725, 0.20833333333333
56060, 0.47916666666667, 0.75, 0.20833333333333
56061, 0.5, 0.75, 0.1875
56062, 0.5, 0.775, 0.20833333333333
56063, 0.47916666666667, 0.8, 0.20833333333333
56064, 0.5, 0.8, 0.1875
56065, 0.5, 0.825, 0.20833333333333
56066, 0.47916666666667, 0.85, 0.20833333333333
56067, 0.5, 0.85, 0.1875
56068, 0.5, 0.875, 0.20833333333333
56069, 0.47916666666667, 0.9, 0.20833333333333
56070, 0.5, 0.9, 0.1875
56071, 0.5, 0.925, 0.20833333333333
56072, 0.47916666666667, 0.95, 0.20833333333333
56073, 0.5, 0.95, 0.1875
56074, 0.5, 0.975, 0.20833333333333
56075, 0.47916666666667, 1, 0.20833333333333
56076, 0.5, 1, 0.1875
56077, 0.5, 1.025, 0.20833333333333
56078, 0.47916666666667, 1.05, 0.20833333333333
56079, 0.5, 1.05, 0.1875
56080, 0.5, 1.075, 0.20833333333333
56081, 0.47916666666667, 1.1, 0.20833333333333
56082, 0.5, 1.1, 0.1875
56083, 0.5, 1.125, 0.20833333333333
56084, 0.47916666666667, 1.15, 0.20833333333333
56085, 0.5, 1.15, 0.1875
56086, 0.5, 1.175, 0.20833333333333
56087, 0.47916666666667, 1.2, 0.20833333333333
56088, 0.5, 1.2, 0.1875
56089, 0.5, 1.225, 0.20833333333333
56090, 0.47916666666667, 1.25, 0.20833333333333
56091, 0.5, 1.25, 0.1875
56092, 0.5, 1.275, 0.20833333333333
56093, 0.47916666666667, 1.3, 0.20833333333333
56094, 0.5, 1.3, 0.1875
56095, 0.5, 1.325, 0.20833333333333
56096, 0.5, 0.175, 0.25
56097, 0.47916666666667, 0.2, 0.25
56098, 0.5, 0.2, 0.22916666666667
56099, 0.5, 0.225, 0.25
56100, 0.47916666666667, 0.25, 0.25
56101, 0.5, 0.25, 0.22916666666667
56102, 0.5, 0.275, 0.25
56103, 0.47916666666667, 0.3, 0.25
56104, 0.5, 0.3, 0.22916666666667
56105, 0.5, 0.325, 0.25
56106, 0.47916666666667, 0.35, 0.25
56107, 0.5, 0.35, 0.22916666666667
56108, 0.5, 0.375, 0.25
56109, 0.47916666666667, 0.4, 0.25
56110, 0.5, 0.4, 0.22916666666667
56111, 0.5, 0.425, 0.25
56112, 0.47916666666667, 0.45, 0.25
56113, 0.5, 0.45, 0.22916666666667
56114, 0.5, 0.475, 0.25
56115, 0.47916666666667, 0.5, 0.25
56116, 0.5, 0.5, 0.22916666666667
56117, 0.5, 0.525, 0.25
56118, 0.47916666666667, 0.55, 0.25
56119, 0.5, 0.55, 0.22916666666667
56120, 0.5, 0.575, 0.25
56121, 0.47916666666667, 0.6, 0.25
56122, 0.5, 0.6, 0.22916666666667
56123, 0.5, 0.625, 0.25
56124, 0.47916666666667, 0.65, 0.25
56125, 0.5, 0.65, 0.22916666666667
56126, 0.5, 0.675, 0.25
56127, 0.47916666666667, 0.7, 0.25
56128, 0.5, 0.7, 0.22916666666667
56129, 0.5, 0.725, 0.25
56130, 0.47916666666667, 0.75, 0.25
56131, 0.5, 0.75, 0.22916666666667
56132, 0.5, 0.775, 0.25
56133, 0.47916666666667, 0.8, 0.25
56134, 0.5, 0.8, 0.22916666666667
56135, 0.5, 0.825, 0.25
56136, 0.47916666666667, 0.85, 0.25
56137, 0.5, 0.85, 0.22916666666667
56138, 0.5, 0.875, 0.25
56139, 0.47916666666667, 0.9, 0.25
56140, 0.5, 0.9, 0.22916666666667
56141, 0.5, 0.925, 0.25
56142, 0.47916666666667, 0.95, 0.25
56143, 0.5, 0.95, 0.22916666666667
56144, 0.5, 0.975, 0.25
56145, 0.47916666666667, 1, 0.25
56146, 0.5, 1, 0.22916666666667
56147, 0.5, 1.025, 0.25
56148, 0.47916666666667, 1.05, 0.25
56149, 0.5, 1.05, 0.22916666666667
56150, 0.5, 1.075, 0.25
56151, 0.47916666666667, 1.1, 0.25
56152, 0.5, 1.1, 0.22916666666667
56153, 0.5, 1.125, 0.25
56154, 0.47916666666667, 1.15, 0.25
56155, 0.5, 1.15, 0.22916666666667
56156, 0.5, 1.175, 0.25
56157, 0.47916666666667, 1.2, 0.25
56158, 0.5, 1.2, 0.22916666666667
56159, 0.5, 1.225, 0.25
56160, 0.47916666666667, 1.25, 0.25
56161, 0.5, 1.25, 0.22916666666667
56162, 0.5, 1.275, 0.25
56163, 0.47916666666667, 1.3, 0.25
56164, 0.5, 1.3, 0.22916666666667
56165, 0.5, 1.325, 0.25
56166, 0.5, 0.175, 0.29166666666667
56167, 0.47916666666667, 0.2, 0.29166666666667
56168, 0.5, 0.2, 0.27083333333333
56169, 0.5, 0.225, 0.29166666666667
56170, 0.47916666666667, 0.25, 0.29166666666667
56171, 0.5, 0.25, 0.27083333333333
56172, 0.5, 0.275, 0.29166666666667
56173, 0.47916666666667, 0.3, 0.29166666666667
56174, 0.5, 0.3, 0.27083333333333
56175, 0.5, 0.325, 0.29166666666667
56176, 0.47916666666667, 0.35, 0.29166666666667
56177, 0.5, 0.35, 0.27083333333333
56178, 0.5, 0.375, 0.29166666666667
56179, 0.47916666666667, 0.4, 0.29166666666667
56180, 0.5, 0.4, 0.27083333333333
56181, 0.5, 0.425, 0.29166666666667
56182, 0.47916666666667, 0.45, 0.29166666666667
56183, 0.5, 0.45, 0.27083333333333
56184, 0.5, 0.475, 0.29166666666667
56185, 0.47916666666667, 0.5, 0.29166666666667
56186, 0.5, 0.5, 0.27083333333333
56187, 0.5, 0.525, 0.29166666666667
56188, 0.47916666666667, 0.55, 0.29166666666667
56189, 0.5, 0.55, 0.27083333333333
56190, 0.5, 0.575, 0.29166666666667
56191, 0.47916666666667, 0.6, 0.29166666666667
56192, 0.5, 0.6, 0.27083333333333
56193, 0.5, 0.625, 0.29166666666667
56194, 0.47916666666667, 0.65, 0.29166666666667
56195, 0.5, 0.65, 0.27083333333333
56196, 0.5, 0.675, 0.29166666666667
56197, 0.47916666666667, 0.7, 0.29166666666667
56198, 0.5, 0.7, 0.27083333333333
56199, 0.5, 0.725, 0.29166666666667
56200, 0.47916666666667, 0.75, 0.29166666666667
56201, 0.5, 0.75, 0.27083333333333
56202, 0.5, 0.775, 0.29166666666667
56203, 0.47916666666667, 0.8, 0.29166666666667
56204, 0.5, 0.8, 0.27083333333333
56205, 0.5, 0.825, 0.29166666666667
56206, 0.47916666666667, 0.85, 0.29166666666667
56207, 0.5, 0.85, 0.27083333333333
56208, 0.5, 0.875, 0.29166666666667
56209, 0.47916666666667, 0.9, 0.29166666666667
56210, 0.5, 0.9, 0.27083333333333
56211, 0.5, 0.925, 0.29166666666667
56212, 0.47916666666667, 0.95, 0.29166666666667
56213, 0.5, 0.95, 0.27083333333333
56214, 0.5, 0.975, 0.29166666666667
56215, 0.47916666666667, 1, 0.29166666666667
56216, 0.5, 1, 0.27083333333333
56217, 0.5, 1.025, 0.29166666666667
56218, 0.47916666666667, 1.05, 0.29166666666667
56219, 0.5, 1.05, 0.27083333333333
56220, 0.5, 1.075, 0.29166666666667
56221, 0.47916666666667, 1.1, 0.29166666666667
56222, 0.5, 1.1, 0.27083333333333
56223, 0.5, 1.125, 0.29166666666667
56224, 0.47916666666667, 1.15, 0.29166666666667
56225, 0.5, 1.15, 0.27083333333333
56226, 0.5, 1.175, 0.29166666666667
56227, 0.47916666666667, 1.2, 0.29166666666667
56228, 0.5, 1.2, 0.27083333333333
56229, 0.5, 1.225, 0.29166666666667
56230, 0.47916666666667, 1.25, 0.29166666666667
56231, 0.5, 1.25, 0.27083333333333
56232, 0.5, 1.275, 0.29166666666667
56233, 0.47916666666667, 1.3, 0.29166666666667
56234, 0.5, 1.3, 0.27083333333333
56235, 0.5, 1.325, 0.29166666666667
56236, 0.5, 0.175, 0.33333333333333
56237, 0.47916666666667, 0.2, 0.33333333333333
56238, 0.5, 0.2, 0.3125
56239, 0.5, 0.225, 0.33333333333333
56240, 0.47916666666667, 0.25, 0.33333333333333
56241, 0.5, 0.25, 0.3125
56242, 0.5, 0.275, 0.33333333333333
56243, 0.47916666666667, 0.3, 0.33333333333333
56244, 0.5, 0.3, 0.3125
56245, 0.5, 0.325, 0.33333333333333
56246, 0.47916666666667, 0.35, 0.33333333333333
56247, 0.5, 0.35, 0.3125
56248, 0.5, 0.375, 0.33333333333333
56249, 0.47916666666667, 0.4, 0.33333333333333
56250, 0.5, 0.4, 0.3125
56251, 0.5, 0.425, 0.33333333333333
56252, 0.47916666666667, 0.45, 0.33333333333333
56253, 0.5, 0.45, 0.3125
56254, 0.5, 0.475, 0.33333333333333
56255, 0.47916666666667, 0.5, 0.33333333333333
56256, 0.5, 0.5, 0.3125
56257, 0.5, 0.525, 0.33333333333333
56258, 0.47916666666667, 0.55, 0.33333333333333
56259, 0.5, 0.55, 0.3125
56260, 0.5, 0.575, 0.33333333333333
56261, 0.47916666666667, 0.6, 0.33333333333333
56262, 0.5, 0.6, 0.3125
56263, 0.5, 0.625, 0.33333333333333
56264, 0.47916666666667, 0.65, 0.33333333333333
56265, 0.5, 0.65, 0.3125
56266, 0.5, 0.675, 0.33333333333333
56267, 0.47916666666667, 0.7, 0.33333333333333
56268, 0.5, 0.7, 0.3125
56269, 0.5, 0.725, 0.33333333333333
56270, 0.47916666666667, 0.75, 0.33333333333333
56271, 0.5, 0.75, 0.3125
56272, 0.5, 0.775, 0.33333333333333
56273, 0.47916666666667, 0.8, 0.33333333333333
56274, 0.5, 0.8, 0.3125
56275, 0.5, 0.825, 0.33333333333333
56276, 0.47916666666667, 0.85, 0.33333333333333
56277, 0.5, 0.85, 0.3125
56278, 0.5, 0.875, 0.33333333333333
56279, 0.47916666666667, 0.9, 0.33333333333333
56280, 0.5, 0.9, 0.3125
56281, 0.5, 0.925, 0.33333333333333
56282, 0.47916666666667, 0.95, 0.33333333333333
56283, 0.5, 0.95, 0.3125
56284, 0.5, 0.975, 0.33333333333333
56285, 0.47916666666667, 1, 0.33333333333333
56286, 0.5, 1, 0.3125
56287, 0.5, 1.025, 0.33333333333333
56288, 0.47916666666667, 1.05, 0.33333333333333
56289, 0.5, 1.05, 0.3125
56290, 0.5, 1.075, 0.33333333333333
56291, 0.47916666666667, 1.1, 0.33333333333333
56292, 0.5, 1.1, 0.3125
56293, 0.5, 1.125, 0.33333333333333
56294, 0.47916666666667, 1.15, 0.33333333333333
56295, 0.5, 1.15, 0.3125
56296, 0.5, 1.175, 0.33333333333333
56297, 0.47916666666667, 1.2, 0.33333333333333
56298, 0.5, 1.2, 0.3125
56299, 0.5, 1.225, 0.33333333333333
56300, 0.47916666666667, 1.25, 0.33333333333333
56301, 0.5, 1.25, 0.3125
56302, 0.5, 1.275, 0.33333333333333
56303, 0.47916666666667, 1.3, 0.33333333333333
56304, 0.5, 1.3, 0.3125
56305, 0.5, 1.325, 0.33333333333333
56306, 0.5, 0.175, 0.375
56307, 0.47916666666667, 0.2, 0.375
56308, 0.5, 0.2, 0.35416666666667
56309, 0.5, 0.225, 0.375
56310, 0.47916666666667, 0.25, 0.375
56311, 0.5, 0.25, 0.35416666666667
56312, 0.5, 0.275, 0.375
56313, 0.47916666666667, 0.3, 0.375
56314, 0.5, 0.3, 0.35416666666667
56315, 0.5, 0.325, 0.375
56316, 0.47916666666667, 0.35, 0.375
56317, 0.5, 0.35, 0.35416666666667
56318, 0.5, 0.375, 0.375
56319, 0.47916666666667, 0.4, 0.375
56320, 0.5, 0.4, 0.35416666666667
56321, 0.5, 0.425, 0.375
56322, 0.47916666666667, 0.45, 0.375
56323, 0.5, 0.45, 0.35416666666667
56324, 0.5, 0.475, 0.375
56325, 0.47916666666667, 0.5, 0.375
56326, 0.5, 0.5, 0.35416666666667
56327, 0.5, 0.525, 0.375
56328, 0.47916666666667, 0.55, 0.375
56329, 0.5, 0.55, 0.35416666666667
56330, 0.5, 0.575, 0.375
56331, 0.47916666666667, 0.6, 0.375
56332, 0.5, 0.6, 0.35416666666667
56333, 0.5, 0.625, 0.375
56334, 0.47916666666667, 0.65, 0.375
56335, 0.5, 0.65, 0.35416666666667
56336, 0.5, 0.675, 0.375
56337, 0.47916666666667, 0.7, 0.375
56338, 0.5, 0.7, 0.35416666666667
56339, 0.5, 0.725, 0.375
56340, 0.47916666666667, 0.75, 0.375
56341, 0.5, 0.75, 0.35416666666667
56342, 0.5, 0.775, 0.375
56343, 0.47916666666667, 0.8, 0.375
56344, 0.5, 0.8, 0.35416666666667
56345, 0.5, 0.825, 0.375
56346, 0.47916666666667, 0.85, 0.375
56347, 0.5, 0.85, 0.35416666666667
56348, 0.5, 0.875, 0.375
56349, 0.47916666666667, 0.9, 0.375
56350, 0.5, 0.9, 0.35416666666667
56351, 0.5, 0.925, 0.375
56352, 0.47916666666667, 0.95, 0.375
56353, 0.5, 0.95, 0.35416666666667
56354, 0.5, 0.975, 0.375
56355, 0.47916666666667, 1, 0.375
56356, 0.5, 1, 0.35416666666667
56357, 0.5, 1.025, 0.375
56358, 0.47916666666667, 1.05, 0.375
56359, 0.5, 1.05, 0.35416666666667
56360, 0.5, 1.075, 0.375
56361, 0.47916666666667, 1.1, 0.375
56362, 0.5, 1.1, 0.35416666666667
56363, 0.5, 1.125, 0.375
56364, 0.47916666666667, 1.15, 0.375
56365, 0.5, 1.15, 0.35416666666667
56366, 0.5, 1.175, 0.375
56367, 0.47916666666667, 1.2, 0.375
56368, 0.5, 1.2, 0.35416666666667
56369, 0.5, 1.225, 0.375
56370, 0.47916666666667, 1.25, 0.375
56371, 0.5, 1.25, 0.35416666666667
56372, 0.5, 1.275, 0.375
56373, 0.47916666666667, 1.3, 0.375
56374, 0.5, 1.3, 0.35416666666667
56375, 0.5, 1.325, 0.375
56376, 0.5, 0.175, 0.41666666666667
56377, 0.47916666666667, 0.2, 0.41666666666667
56378, 0.5, 0.2, 0.39583333333333
56379, 0.5, 0.225, 0.41666666666667
56380, 0.47916666666667, 0.25, 0.41666666666667
56381, 0.5, 0.25, 0.39583333333333
56382, 0.5, 0.275, 0.41666666666667
56383, 0.47916666666667, 0.3, 0.41666666666667
56384, 0.5, 0.3, 0.39583333333333
56385, 0.5, 0.325, 0.41666666666667
56386, 0.47916666666667, 0.35, 0.41666666666667
56387, 0.5, 0.35, 0.39583333333333
56388, 0.5, 0.375, 0.41666666666667
56389, 0.47916666666667, 0.4, 0.41666666666667
56390, 0.5, 0.4, 0.39583333333333
56391, 0.5, 0.425, 0.41666666666667
56392, 0.47916666666667, 0.45, 0.41666666666667
56393, 0.5, 0.45, 0.39583333333333
56394, 0.5, 0.475, 0.41666666666667
56395, 0.47916666666667, 0.5, 0.41666666666667
56396, 0.5, 0.5, 0.39583333333333
56397, 0.5, 0.525, 0.41666666666667
56398, 0.47916666666667, 0.55, 0.41666666666667
56399, 0.5, 0.55, 0.39583333333333
56400, 0.5, 0.575, 0.41666666666667
56401, 0.47916666666667, 0.6, 0.41666666666667
56402, 0.5, 0.6, 0.39583333333333
56403, 0.5, 0.625, 0.41666666666667
56404, 0.47916666666667, 0.65, 0.41666666666667
56405, 0.5, 0.65, 0.39583333333333
56406, 0.5, 0.675, 0.41666666666667
56407, 0.47916666666667, 0.7, 0.41666666666667
56408, 0.5, 0.7, 0.39583333333333
56409, 0.5, 0.725, 0.41666666666667
56410, 0.47916666666667, 0.75, 0.41666666666667
56411, 0.5, 0.75, 0.39583333333333
56412, 0.5, 0.775, 0.41666666666667
56413, 0.47916666666667, 0.8, 0.41666666666667
56414, 0.5, 0.8, 0.39583333333333
56415, 0.5, 0.825, 0.41666666666667
56416, 0.47916666666667, 0.85, 0.41666666666667
56417, 0.5, 0.85, 0.39583333333333
56418, 0.5, 0.875, 0.41666666666667
56419, 0.47916666666667, 0.9, 0.41666666666667
56420, 0.5, 0.9, 0.39583333333333
56421, 0.5, 0.925, 0.41666666666667
56422, 0.47916666666667, 0.95, 0.41666666666667
56423, 0.5, 0.95, 0.39583333333333
56424, 0.5, 0.975, 0.41666666666667
56425, 0.47916666666667, 1, 0.41666666666667
56426, 0.5, 1, 0.39583333333333
56427, 0.5, 1.025, 0.41666666666667
56428, 0.47916666666667, 1.05, 0.41666666666667
56429, 0.5, 1.05, 0.39583333333333
56430, 0.5, 1.075, 0.41666666666667
56431, 0.47916666666667, 1.1, 0.41666666666667
56432, 0.5, 1.1, 0.39583333333333
56433, 0.5, 1.125, 0.41666666666667
56434, 0.47916666666667, 1.15, 0.41666666666667
56435, 0.5, 1.15, 0.39583333333333
56436, 0.5, 1.175, 0.41666666666667
56437, 0.47916666666667, 1.2, 0.41666666666667
56438, 0.5, 1.2, 0.39583333333333
56439, 0.5, 1.225, 0.41666666666667
56440, 0.47916666666667, 1.25, 0.41666666666667
56441, 0.5, 1.25, 0.39583333333333
56442, 0.5, 1.275, 0.41666666666667
56443, 0.47916666666667, 1.3, 0.41666666666667
56444, 0.5, 1.3, 0.39583333333333
56445, 0.5, 1.325, 0.41666666666667
56446, 0.5, 0.175, 0.45833333333333
56447, 0.47916666666667, 0.2, 0.45833333333333
56448, 0.5, 0.2, 0.4375
56449, 0.5, 0.225, 0.45833333333333
56450, 0.47916666666667, 0.25, 0.45833333333333
56451, 0.5, 0.25, 0.4375
56452, 0.5, 0.275, 0.45833333333333
56453, 0.47916666666667, 0.3, 0.45833333333333
56454, 0.5, 0.3, 0.4375
56455, 0.5, 0.325, 0.45833333333333
56456, 0.47916666666667, 0.35, 0.45833333333333
56457, 0.5, 0.35, 0.4375
56458, 0.5, 0.375, 0.45833333333333
56459, 0.47916666666667, 0.4, 0.45833333333333
56460, 0.5, 0.4, 0.4375
56461, 0.5, 0.425, 0.45833333333333
56462, 0.47916666666667, 0.45, 0.45833333333333
56463, 0.5, 0.45, 0.4375
56464, 0.5, 0.475, 0.45833333333333
56465, 0.47916666666667, 0.5, 0.45833333333333
56466, 0.5, 0.5, 0.4375
56467, 0.5, 0.525, 0.45833333333333
56468, 0.47916666666667, 0.55, 0.45833333333333
56469, 0.5, 0.55, 0.4375
56470, 0.5, 0.575, 0.45833333333333
56471, 0.47916666666667, 0.6, 0.45833333333333
56472, 0.5, 0.6, 0.4375
56473, 0.5, 0.625, 0.45833333333333
56474, 0.47916666666667, 0.65, 0.45833333333333
56475, 0.5, 0.65, 0.4375
56476, 0.5, 0.675, 0.45833333333333
56477, 0.47916666666667, 0.7, 0.45833333333333
56478, 0.5, 0.7, 0.4375
56479, 0.5, 0.725, 0.45833333333333
56480, 0.47916666666667, 0.75, 0.45833333333333
56481, 0.5, 0.75, 0.4375
56482, 0.5, 0.775, 0.45833333333333
56483, 0.47916666666667, 0.8, 0.45833333333333
56484, 0.5, 0.8, 0.4375
56485, 0.5, 0.825, 0.45833333333333
56486, 0.47916666666667, 0.85, 0.45833333333333
56487, 0.5, 0.85, 0.4375
56488, 0.5, 0.875, 0.45833333333333
56489, 0.47916666666667, 0.9, 0.45833333333333
56490, 0.5, 0.9, 0.4375
56491, 0.5, 0.925, 0.45833333333333
56492, 0.47916666666667, 0.95, 0.45833333333333
56493, 0.5, 0.95, 0.4375
56494, 0.5, 0.975, 0.45833333333333
56495, 0.47916666666667, 1, 0.45833333333333
56496, 0.5, 1, 0.4375
56497, 0.5, 1.025, 0.45833333333333
56498, 0.47916666666667, 1.05, 0.45833333333333
56499, 0.5, 1.05, 0.4375
56500, 0.5, 1.075, 0.45833333333333
56501, 0.47916666666667, 1.1, 0.45833333333333
56502, 0.5, 1.1, 0.4375
56503, 0.5, 1.125, 0.45833333333333
56504, 0.47916666666667, 1.15, 0.45833333333333
56505, 0.5, 1.15, 0.4375
56506, 0.5, 1.175, 0.45833333333333
56507, 0.47916666666667, 1.2, 0.45833333333333
56508, 0.5, 1.2, 0.4375
56509, 0.5, 1.225, 0.45833333333333
56510, 0.47916666666667, 1.25, 0.45833333333333
56511, 0.5, 1.25, 0.4375
56512, 0.5, 1.275, 0.45833333333333
56513, 0.47916666666667, 1.3, 0.45833333333333
56514, 0.5, 1.3, 0.4375
56515, 0.5, 1.325, 0.45833333333333
56516, 0.5, 0.2, 0.47916666666667
56517, 0.5, 0.25, 0.47916666666667
56518, 0.5, 0.3, 0.47916666666667
56519, 0.5, 0.35, 0.47916666666667
56520, 0.5, 0.4, 0.47916666666667
56521, 0.5, 0.45, 0.47916666666667
56522, 0.5, 0.5, 0.47916666666667
56523, 0.5, 0.55, 0.47916666666667
56524, 0.5, 0.6, 0.47916666666667
56525, 0.5, 0.65, 0.47916666666667
56526, 0.5, 0.7, 0.47916666666667
56527, 0.5, 0.75, 0.47916666666667
56528, 0.5, 0.8, 0.47916666666667
56529, 0.5, 0.85, 0.47916666666667
56530, 0.5, 0.9, 0.47916666666667
56531, 0.5, 0.95, 0.47916666666667
56532, 0.5, 1, 0.47916666666667
56533, 0.5, 1.05, 0.47916666666667
56534, 0.5, 1.1, 0.47916666666667
56535, 0.5, 1.15, 0.47916666666667
56536, 0.5, 1.2, 0.47916666666667
56537, 0.5, 1.25, 0.47916666666667
56538, 0.5, 1.3, 0.47916666666667
56539, 0.54166666666667, 0.175, 0.041666666666667
56540, 0.52083333333333, 0.2, 0.041666666666667
56541, 0.54166666666667, 0.2, 0.020833333333333
56542, 0.54166666666667, 0.225, 0.041666666666667
56543, 0.52083333333333, 0.25, 0.041666666666667
56544, 0.54166666666667, 0.25, 0.020833333333333
56545, 0.54166666666667, 0.275, 0.041666666666667
56546, 0.52083333333333, 0.3, 0.041666666666667
56547, 0.54166666666667, 0.3, 0.020833333333333
56548, 0.54166666666667, 0.325, 0.041666666666667
56549, 0.52083333333333, 0.35, 0.041666666666667
56550, 0.54166666666667, 0.35, 0.020833333333333
56551, 0.54166666666667, 0.375, 0.041666666666667
56552, 0.52083333333333, 0.4, 0.041666666666667
56553, 0.54166666666667, 0.4, 0.020833333333333
56554, 0.54166666666667, 0.425, 0.041666666666667
56555, 0.52083333333333, 0.45, 0.041666666666667
56556, 0.54166666666667, 0.45, 0.020833333333333
56557, 0.54166666666667, 0.475, 0.041666666666667
56558, 0.52083333333333, 0.5, 0.041666666666667
56559, 0.54166666666667, 0.5, 0.020833333333333
56560, 0.54166666666667, 0.525, 0.041666666666667
56561, 0.52083333333333, 0.55, 0.041666666666667
56562, 0.54166666666667, 0.55, 0.020833333333333
56563, 0.54166666666667, 0.575, 0.041666666666667
56564, 0.52083333333333, 0.6, 0.041666666666667
56565, 0.54166666666667, 0.6, 0.020833333333333
56566, 0.54166666666667, 0.625, 0.041666666666667
56567, 0.52083333333333, 0.65, 0.041666666666667
56568, 0.54166666666667, 0.65, 0.020833333333333
56569, 0.54166666666667, 0.675, 0.041666666666667
56570, 0.52083333333333, 0.7, 0.041666666666667
56571, 0.54166666666667, 0.7, 0.020833333333333
56572, 0.54166666666667, 0.725, 0.041666666666667
56573, 0.52083333333333, 0.75, 0.041666666666667
56574, 0.54166666666667, 0.75, 0.020833333333333
56575, 0.54166666666667, 0.775, 0.041666666666667
56576, 0.52083333333333, 0.8, 0.041666666666667
56577, 0.54166666666667, 0.8, 0.020833333333333
56578, 0.54166666666667, 0.825, 0.041666666666667
56579, 0.52083333333333, 0.85, 0.041666666666667
56580, 0.54166666666667, 0.85, 0.020833333333333
56581, 0.54166666666667, 0.875, 0.041666666666667
56582, 0.52083333333333, 0.9, 0.041666666666667
56583, 0.54166666666667, 0.9, 0.020833333333333
56584, 0.54166666666667, 0.925, 0.041666666666667
56585, 0.52083333333333, 0.95, 0.041666666666667
56586, 0.54166666666667, 0.95, 0.020833333333333
56587, 0.54166666666667, 0.975, 0.041666666666667
56588, 0.52083333333333, 1, 0.041666666666667
56589, 0.54166666666667, 1, 0.020833333333333
56590, 0.54166666666667, 1.025, 0.041666666666667
56591, 0.52083333333333, 1.05, 0.041666666666667
56592, 0.54166666666667, 1.05, 0.020833333333333
56593, 0.54166666666667, 1.075, 0.041666666666667
56594, 0.52083333333333, 1.1, 0.041666666666667
56595, 0.54166666666667, 1.1, 0.020833333333333
56596, 0.54166666666667, 1.125, 0.041666666666667
56597, 0.52083333333333, 1.15, 0.041666666666667
56598, 0.54166666666667, 1.15, 0.020833333333333
56599, 0.54166666666667, 1.175, 0.041666666666667
56600, 0.52083333333333, 1.2, 0.041666666666667
56601, 0.54166666666667, 1.2, 0.020833333333333
56602, 0.54166666666667, 1.225, 0.041666666666667
56603, 0.52083333333333, 1.25, 0.041666666666667
56604, 0.54166666666667, 1.25, 0.020833333333333
56605, 0.54166666666667, 1.275, 0.041666666666667
56606, 0.52083333333333, 1.3, 0.041666666666667
56607, 0.54166666666667, 1.3, 0.020833333333333
56608, 0.54166666666667, 1.325, 0.041666666666667
56609, 0.54166666666667, 0.175, 0.083333333333333
56610, 0.52083333333333, 0.2, 0.083333333333333
56611, 0.54166666666667, 0.2, 0.0625
56612, 0.54166666666667, 0.225, 0.083333333333333
56613, 0.52083333333333, 0.25, 0.083333333333333
56614, 0.54166666666667, 0.25, 0.0625
56615, 0.54166666666667, 0.275, 0.083333333333333
56616, 0.52083333333333, 0.3, 0.083333333333333
56617, 0.54166666666667, 0.3, 0.0625
56618, 0.54166666666667, 0.325, 0.083333333333333
56619, 0.52083333333333, 0.35, 0.083333333333333
56620, 0.54166666666667, 0.35, 0.0625
56621, 0.54166666666667, 0.375, 0.083333333333333
56622, 0.52083333333333, 0.4, 0.083333333333333
56623, 0.54166666666667, 0.4, 0.0625
56624, 0.54166666666667, 0.425, 0.083333333333333
56625, 0.52083333333333, 0.45, 0.083333333333333
56626, 0.54166666666667, 0.45, 0.0625
56627, 0.54166666666667, 0.475, 0.083333333333333
56628, 0.52083333333333, 0.5, 0.083333333333333
56629, 0.54166666666667, 0.5, 0.0625
56630, 0.54166666666667, 0.525, 0.083333333333333
56631, 0.52083333333333, 0.55, 0.083333333333333
56632, 0.54166666666667, 0.55, 0.0625
56633, 0.54166666666667, 0.575, 0.083333333333333
56634, 0.52083333333333, 0.6, 0.083333333333333
56635, 0.54166666666667, 0.6, 0.0625
56636, 0.54166666666667, 0.625, 0.083333333333333
56637, 0.52083333333333, 0.65, 0.083333333333333
56638, 0.54166666666667, 0.65, 0.0625
56639, 0.54166666666667, 0.675, 0.083333333333333
56640, 0.52083333333333, 0.7, 0.083333333333333
56641, 0.54166666666667, 0.7, 0.0625
56642, 0.54166666666667, 0.725, 0.083333333333333
56643, 0.52083333333333, 0.75, 0.083333333333333
56644, 0.54166666666667, 0.75, 0.0625
56645, 0.54166666666667, 0.775, 0.083333333333333
56646, 0.52083333333333, 0.8, 0.083333333333333
56647, 0.54166666666667, 0.8, 0.0625
56648, 0.54166666666667, 0.825, 0.083333333333333
56649, 0.52083333333333, 0.85, 0.083333333333333
56650, 0.54166666666667, 0.85, 0.0625
56651, 0.54166666666667, 0.875, 0.083333333333333
56652, 0.52083333333333, 0.9, 0.083333333333333
56653, 0.54166666666667, 0.9, 0.0625
56654, 0.54166666666667, 0.925, 0.083333333333333
56655, 0.52083333333333, 0.95, 0.083333333333333
56656, 0.54166666666667, 0.95, 0.0625
56657, 0.54166666666667, 0.975, 0.083333333333333
56658, 0.52083333333333, 1, 0.083333333333333
56659, 0.54166666666667, 1, 0.0625
56660, 0.54166666666667, 1.025, 0.083333333333333
56661, 0.52083333333333, 1.05, 0.083333333333333
56662, 0.54166666666667, 1.05, 0.0625
56663, 0.54166666666667, 1.075, 0.083333333333333
56664, 0.52083333333333, 1.1, 0.083333333333333
56665, 0.54166666666667, 1.1, 0.0625
56666, 0.54166666666667, 1.125, 0.083333333333333
56667, 0.52083333333333, 1.15, 0.083333333333333
56668, 0.54166666666667, 1.15, 0.0625
56669, 0.54166666666667, 1.175, 0.083333333333333
56670, 0.52083333333333, 1.2, 0.083333333333333
56671, 0.54166666666667, 1.2, 0.0625
56672, 0.54166666666667, 1.225, 0.083333333333333
56673, 0.52083333333333, 1.25, 0.083333333333333
56674, 0.54166666666667, 1.25, 0.0625
56675, 0.54166666666667, 1.275, 0.083333333333333
56676, 0.52083333333333, 1.3, 0.083333333333333
56677, 0.54166666666667, 1.3, 0.0625
56678, 0.54166666666667, 1.325, 0.083333333333333
56679, 0.54166666666667, 0.175, 0.125
56680, 0.52083333333333, 0.2, 0.125
56681, 0.54166666666667, 0.2, 0.10416666666667
56682, 0.54166666666667, 0.225, 0.125
56683, 0.52083333333333, 0.25, 0.125
56684, 0.54166666666667, 0.25, 0.10416666666667
56685, 0.54166666666667, 0.275, 0.125
56686, 0.52083333333333, 0.3, 0.125
56687, 0.54166666666667, 0.3, 0.10416666666667
56688, 0.54166666666667, 0.325, 0.125
56689, 0.52083333333333, 0.35, 0.125
56690, 0.54166666666667, 0.35, 0.10416666666667
56691, 0.54166666666667, 0.375, 0.125
56692, 0.52083333333333, 0.4, 0.125
56693, 0.54166666666667, 0.4, 0.10416666666667
56694, 0.54166666666667, 0.425, 0.125
56695, 0.52083333333333, 0.45, 0.125
56696, 0.54166666666667, 0.45, 0.10416666666667
56697, 0.54166666666667, 0.475, 0.125
56698, 0.52083333333333, 0.5, 0.125
56699, 0.54166666666667, 0.5, 0.10416666666667
56700, 0.54166666666667, 0.525, 0.125
56701, 0.52083333333333, 0.55, 0.125
56702, 0.54166666666667, 0.55, 0.10416666666667
56703, 0.54166666666667, 0.575, 0.125
56704, 0.52083333333333, 0.6, 0.125
56705, 0.54166666666667, 0.6, 0.10416666666667
56706, 0.54166666666667, 0.625, 0.125
56707, 0.52083333333333, 0.65, 0.125
56708, 0.54166666666667, 0.65, 0.10416666666667
56709, 0.54166666666667, 0.675, 0.125
56710, 0.52083333333333, 0.7, 0.125
56711, 0.54166666666667, 0.7, 0.10416666666667
56712, 0.54166666666667, 0.725, 0.125
56713, 0.52083333333333, 0.75, 0.125
56714, 0.54166666666667, 0.75, 0.10416666666667
56715, 0.54166666666667, 0.775, 0.125
56716, 0.52083333333333, 0.8, 0.125
56717, 0.54166666666667, 0.8, 0.10416666666667
56718, 0.54166666666667, 0.825, 0.125
56719, 0.52083333333333, 0.85, 0.125
56720, 0.54166666666667, 0.85, 0.10416666666667
56721, 0.54166666666667, 0.875, 0.125
56722, 0.52083333333333, 0.9, 0.125
56723, 0.54166666666667, 0.9, 0.10416666666667
56724, 0.54166666666667, 0.925, 0.125
56725, 0.52083333333333, 0.95, 0.125
56726, 0.54166666666667, 0.95, 0.10416666666667
56727, 0.54166666666667, 0.975, 0.125
56728, 0.52083333333333, 1, 0.125
56729, 0.54166666666667, 1, 0.10416666666667
56730, 0.54166666666667, 1.025, 0.125
56731, 0.52083333333333, 1.05, 0.125
56732, 0.54166666666667, 1.05, 0.10416666666667
56733, 0.54166666666667, 1.075, 0.125
56734, 0.52083333333333, 1.1, 0.125
56735, 0.54166666666667, 1.1, 0.10416666666667
56736, 0.54166666666667, 1.125, 0.125
56737, 0.52083333333333, 1.15, 0.125
56738, 0.54166666666667, 1.15, 0.10416666666667
56739, 0.54166666666667, 1.175, 0.125
56740, 0.52083333333333, 1.2, 0.125
56741, 0.54166666666667, 1.2, 0.10416666666667
56742, 0.54166666666667, 1.225, 0.125
56743, 0.52083333333333, 1.25, 0.125
56744, 0.54166666666667, 1.25, 0.10416666666667
56745, 0.54166666666667, 1.275, 0.125
56746, 0.52083333333333, 1.3, 0.125
56747, 0.54166666666667, 1.3, 0.10416666666667
56748, 0.54166666666667, 1.325, 0.125
56749, 0.54166666666667, 0.175, 0.16666666666667
56750, 0.52083333333333, 0.2, 0.16666666666667
56751, 0.54166666666667, 0.2, 0.14583333333333
56752, 0.54166666666667, 0.225, 0.16666666666667
56753, 0.52083333333333, 0.25, 0.16666666666667
56754, 0.54166666666667, 0.25, 0.14583333333333
56755, 0.54166666666667, 0.275, 0.16666666666667
56756, 0.52083333333333, 0.3, 0.16666666666667
56757, 0.54166666666667, 0.3, 0.14583333333333
56758, 0.54166666666667, 0.325, 0.16666666666667
56759, 0.52083333333333, 0.35, 0.16666666666667
56760, 0.54166666666667, 0.35, 0.14583333333333
56761, 0.54166666666667, 0.375, 0.16666666666667
56762, 0.52083333333333, 0.4, 0.16666666666667
56763, 0.54166666666667, 0.4, 0.14583333333333
56764, 0.54166666666667, 0.425, 0.16666666666667
56765, 0.52083333333333, 0.45, 0.16666666666667
56766, 0.54166666666667, 0.45, 0.14583333333333
56767, 0.54166666666667, 0.475, 0.16666666666667
56768, 0.52083333333333, 0.5, 0.16666666666667
56769, 0.54166666666667, 0.5, 0.14583333333333
56770, 0.54166666666667, 0.525, 0.16666666666667
56771, 0.52083333333333, 0.55, 0.16666666666667
56772, 0.54166666666667, 0.55, 0.14583333333333
56773, 0.54166666666667, 0.575, 0.16666666666667
56774, 0.52083333333333, 0.6, 0.16666666666667
56775, 0.54166666666667, 0.6, 0.14583333333333
56776, 0.54166666666667, 0.625, 0.16666666666667
56777, 0.52083333333333, 0.65, 0.16666666666667
56778, 0.54166666666667, 0.65, 0.14583333333333
56779, 0.54166666666667, 0.675, 0.16666666666667
56780, 0.52083333333333, 0.7, 0.16666666666667
56781, 0.54166666666667, 0.7, 0.14583333333333
56782, 0.54166666666667, 0.725, 0.16666666666667
56783, 0.52083333333333, 0.75, 0.16666666666667
56784, 0.54166666666667, 0.75, 0.14583333333333
56785, 0.54166666666667, 0.775, 0.16666666666667
56786, 0.52083333333333, 0.8, 0.16666666666667
56787, 0.54166666666667, 0.8, 0.14583333333333
56788, 0.54166666666667, 0.825, 0.16666666666667
56789, 0.52083333333333, 0.85, 0.16666666666667
56790, 0.54166666666667, 0.85, 0.14583333333333
56791, 0.54166666666667, 0.875, 0.16666666666667
56792, 0.52083333333333, 0.9, 0.16666666666667
56793, 0.54166666666667, 0.9, 0.14583333333333
56794, 0.54166666666667, 0.925, 0.16666666666667
56795, 0.52083333333333, 0.95, 0.16666666666667
56796, 0.54166666666667, 0.95, 0.14583333333333
56797, 0.54166666666667, 0.975, 0.16666666666667
56798, 0.52083333333333, 1, 0.16666666666667
56799, 0.54166666666667, 1, 0.14583333333333
56800, 0.54166666666667, 1.025, 0.16666666666667
56801, 0.52083333333333, 1.05, 0.16666666666667
56802, 0.54166666666667, 1.05, 0.14583333333333
56803, 0.54166666666667, 1.075, 0.16666666666667
56804, 0.52083333333333, 1.1, 0.16666666666667
56805, 0.54166666666667, 1.1, 0.14583333333333
56806, 0.54166666666667, 1.125, 0.16666666666667
56807, 0.52083333333333, 1.15, 0.16666666666667
56808, 0.54166666666667, 1.15, 0.14583333333333
56809, 0.54166666666667, 1.175, 0.16666666666667
56810, 0.52083333333333, 1.2, 0.16666666666667
56811, 0.54166666666667, 1.2, 0.14583333333333
56812, 0.54166666666667, 1.225, 0.16666666666667
56813, 0.52083333333333, 1.25, 0.16666666666667
56814, 0.54166666666667, 1.25, 0.14583333333333
56815, 0.54166666666667, 1.275, 0.16666666666667
56816, 0.52083333333333, 1.3, 0.16666666666667
56817, 0.54166666666667, 1.3, 0.14583333333333
56818, 0.54166666666667, 1.325, 0.16666666666667
56819, 0.54166666666667, 0.175, 0.20833333333333
56820, 0.52083333333333, 0.2, 0.20833333333333
56821, 0.54166666666667, 0.2, 0.1875
56822, 0.54166666666667, 0.225, 0.20833333333333
56823, 0.52083333333333, 0.25, 0.20833333333333
56824, 0.54166666666667, 0.25, 0.1875
56825, 0.54166666666667, 0.275, 0.20833333333333
56826, 0.52083333333333, 0.3, 0.20833333333333
56827, 0.54166666666667, 0.3, 0.1875
56828, 0.54166666666667, 0.325, 0.20833333333333
56829, 0.52083333333333, 0.35, 0.20833333333333
56830, 0.54166666666667, 0.35, 0.1875
56831, 0.54166666666667, 0.375, 0.20833333333333
56832, 0.52083333333333, 0.4, 0.20833333333333
56833, 0.54166666666667, 0.4, 0.1875
56834, 0.54166666666667, 0.425, 0.20833333333333
56835, 0.52083333333333, 0.45, 0.20833333333333
56836, 0.54166666666667, 0.45, 0.1875
56837, 0.54166666666667, 0.475, 0.20833333333333
56838, 0.52083333333333, 0.5, 0.20833333333333
56839, 0.54166666666667, 0.5, 0.1875
56840, 0.54166666666667, 0.525, 0.20833333333333
56841, 0.52083333333333, 0.55, 0.20833333333333
56842, 0.54166666666667, 0.55, 0.1875
56843, 0.54166666666667, 0.575, 0.20833333333333
56844, 0.52083333333333, 0.6, 0.20833333333333
56845, 0.54166666666667, 0.6, 0.1875
56846, 0.54166666666667, 0.625, 0.20833333333333
56847, 0.52083333333333, 0.65, 0.20833333333333
56848, 0.54166666666667, 0.65, 0.1875
56849, 0.54166666666667, 0.675, 0.20833333333333
56850, 0.52083333333333, 0.7, 0.20833333333333
56851, 0.54166666666667, 0.7, 0.1875
56852, 0.54166666666667, 0.725, 0.20833333333333
56853, 0.52083333333333, 0.75, 0.20833333333333
56854, 0.54166666666667, 0.75, 0.1875
56855, 0.54166666666667, 0.775, 0.20833333333333
56856, 0.52083333333333, 0.8, 0.20833333333333
56857, 0.54166666666667, 0.8, 0.1875
56858, 0.54166666666667, 0.825, 0.20833333333333
56859, 0.52083333333333, 0.85, 0.20833333333333
56860, 0.54166666666667, 0.85, 0.1875
56861, 0.54166666666667, 0.875, 0.20833333333333
56862, 0.52083333333333, 0.9, 0.20833333333333
56863, 0.54166666666667, 0.9, 0.1875
56864, 0.54166666666667, 0.925, 0.20833333333333
56865, 0.52083333333333, 0.95, 0.20833333333333
56866, 0.54166666666667, 0.95, 0.1875
56867, 0.54166666666667, 0.975, 0.20833333333333
56868, 0.52083333333333, 1, 0.20833333333333
56869, 0.54166666666667, 1, 0.1875
56870, 0.54166666666667, 1.025, 0.20833333333333
56871, 0.52083333333333, 1.05, 0.20833333333333
56872, 0.54166666666667, 1.05, 0.1875
56873, 0.54166666666667, 1.075, 0.20833333333333
56874, 0.52083333333333, 1.1, 0.20833333333333
56875, 0.54166666666667, 1.1, 0.1875
56876, 0.54166666666667, 1.125, 0.20833333333333
56877, 0.52083333333333, 1.15, 0.20833333333333
56878, 0.54166666666667, 1.15, 0.1875
56879, 0.54166666666667, 1.175, 0.20833333333333
