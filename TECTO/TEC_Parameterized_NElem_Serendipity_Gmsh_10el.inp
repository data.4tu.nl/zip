56880, 0.52083333333333, 1.2, 0.20833333333333
56881, 0.54166666666667, 1.2, 0.1875
56882, 0.54166666666667, 1.225, 0.20833333333333
56883, 0.52083333333333, 1.25, 0.20833333333333
56884, 0.54166666666667, 1.25, 0.1875
56885, 0.54166666666667, 1.275, 0.20833333333333
56886, 0.52083333333333, 1.3, 0.20833333333333
56887, 0.54166666666667, 1.3, 0.1875
56888, 0.54166666666667, 1.325, 0.20833333333333
56889, 0.54166666666667, 0.175, 0.25
56890, 0.52083333333333, 0.2, 0.25
56891, 0.54166666666667, 0.2, 0.22916666666667
56892, 0.54166666666667, 0.225, 0.25
56893, 0.52083333333333, 0.25, 0.25
56894, 0.54166666666667, 0.25, 0.22916666666667
56895, 0.54166666666667, 0.275, 0.25
56896, 0.52083333333333, 0.3, 0.25
56897, 0.54166666666667, 0.3, 0.22916666666667
56898, 0.54166666666667, 0.325, 0.25
56899, 0.52083333333333, 0.35, 0.25
56900, 0.54166666666667, 0.35, 0.22916666666667
56901, 0.54166666666667, 0.375, 0.25
56902, 0.52083333333333, 0.4, 0.25
56903, 0.54166666666667, 0.4, 0.22916666666667
56904, 0.54166666666667, 0.425, 0.25
56905, 0.52083333333333, 0.45, 0.25
56906, 0.54166666666667, 0.45, 0.22916666666667
56907, 0.54166666666667, 0.475, 0.25
56908, 0.52083333333333, 0.5, 0.25
56909, 0.54166666666667, 0.5, 0.22916666666667
56910, 0.54166666666667, 0.525, 0.25
56911, 0.52083333333333, 0.55, 0.25
56912, 0.54166666666667, 0.55, 0.22916666666667
56913, 0.54166666666667, 0.575, 0.25
56914, 0.52083333333333, 0.6, 0.25
56915, 0.54166666666667, 0.6, 0.22916666666667
56916, 0.54166666666667, 0.625, 0.25
56917, 0.52083333333333, 0.65, 0.25
56918, 0.54166666666667, 0.65, 0.22916666666667
56919, 0.54166666666667, 0.675, 0.25
56920, 0.52083333333333, 0.7, 0.25
56921, 0.54166666666667, 0.7, 0.22916666666667
56922, 0.54166666666667, 0.725, 0.25
56923, 0.52083333333333, 0.75, 0.25
56924, 0.54166666666667, 0.75, 0.22916666666667
56925, 0.54166666666667, 0.775, 0.25
56926, 0.52083333333333, 0.8, 0.25
56927, 0.54166666666667, 0.8, 0.22916666666667
56928, 0.54166666666667, 0.825, 0.25
56929, 0.52083333333333, 0.85, 0.25
56930, 0.54166666666667, 0.85, 0.22916666666667
56931, 0.54166666666667, 0.875, 0.25
56932, 0.52083333333333, 0.9, 0.25
56933, 0.54166666666667, 0.9, 0.22916666666667
56934, 0.54166666666667, 0.925, 0.25
56935, 0.52083333333333, 0.95, 0.25
56936, 0.54166666666667, 0.95, 0.22916666666667
56937, 0.54166666666667, 0.975, 0.25
56938, 0.52083333333333, 1, 0.25
56939, 0.54166666666667, 1, 0.22916666666667
56940, 0.54166666666667, 1.025, 0.25
56941, 0.52083333333333, 1.05, 0.25
56942, 0.54166666666667, 1.05, 0.22916666666667
56943, 0.54166666666667, 1.075, 0.25
56944, 0.52083333333333, 1.1, 0.25
56945, 0.54166666666667, 1.1, 0.22916666666667
56946, 0.54166666666667, 1.125, 0.25
56947, 0.52083333333333, 1.15, 0.25
56948, 0.54166666666667, 1.15, 0.22916666666667
56949, 0.54166666666667, 1.175, 0.25
56950, 0.52083333333333, 1.2, 0.25
56951, 0.54166666666667, 1.2, 0.22916666666667
56952, 0.54166666666667, 1.225, 0.25
56953, 0.52083333333333, 1.25, 0.25
56954, 0.54166666666667, 1.25, 0.22916666666667
56955, 0.54166666666667, 1.275, 0.25
56956, 0.52083333333333, 1.3, 0.25
56957, 0.54166666666667, 1.3, 0.22916666666667
56958, 0.54166666666667, 1.325, 0.25
56959, 0.54166666666667, 0.175, 0.29166666666667
56960, 0.52083333333333, 0.2, 0.29166666666667
56961, 0.54166666666667, 0.2, 0.27083333333333
56962, 0.54166666666667, 0.225, 0.29166666666667
56963, 0.52083333333333, 0.25, 0.29166666666667
56964, 0.54166666666667, 0.25, 0.27083333333333
56965, 0.54166666666667, 0.275, 0.29166666666667
56966, 0.52083333333333, 0.3, 0.29166666666667
56967, 0.54166666666667, 0.3, 0.27083333333333
56968, 0.54166666666667, 0.325, 0.29166666666667
56969, 0.52083333333333, 0.35, 0.29166666666667
56970, 0.54166666666667, 0.35, 0.27083333333333
56971, 0.54166666666667, 0.375, 0.29166666666667
56972, 0.52083333333333, 0.4, 0.29166666666667
56973, 0.54166666666667, 0.4, 0.27083333333333
56974, 0.54166666666667, 0.425, 0.29166666666667
56975, 0.52083333333333, 0.45, 0.29166666666667
56976, 0.54166666666667, 0.45, 0.27083333333333
56977, 0.54166666666667, 0.475, 0.29166666666667
56978, 0.52083333333333, 0.5, 0.29166666666667
56979, 0.54166666666667, 0.5, 0.27083333333333
56980, 0.54166666666667, 0.525, 0.29166666666667
56981, 0.52083333333333, 0.55, 0.29166666666667
56982, 0.54166666666667, 0.55, 0.27083333333333
56983, 0.54166666666667, 0.575, 0.29166666666667
56984, 0.52083333333333, 0.6, 0.29166666666667
56985, 0.54166666666667, 0.6, 0.27083333333333
56986, 0.54166666666667, 0.625, 0.29166666666667
56987, 0.52083333333333, 0.65, 0.29166666666667
56988, 0.54166666666667, 0.65, 0.27083333333333
56989, 0.54166666666667, 0.675, 0.29166666666667
56990, 0.52083333333333, 0.7, 0.29166666666667
56991, 0.54166666666667, 0.7, 0.27083333333333
56992, 0.54166666666667, 0.725, 0.29166666666667
56993, 0.52083333333333, 0.75, 0.29166666666667
56994, 0.54166666666667, 0.75, 0.27083333333333
56995, 0.54166666666667, 0.775, 0.29166666666667
56996, 0.52083333333333, 0.8, 0.29166666666667
56997, 0.54166666666667, 0.8, 0.27083333333333
56998, 0.54166666666667, 0.825, 0.29166666666667
56999, 0.52083333333333, 0.85, 0.29166666666667
57000, 0.54166666666667, 0.85, 0.27083333333333
57001, 0.54166666666667, 0.875, 0.29166666666667
57002, 0.52083333333333, 0.9, 0.29166666666667
57003, 0.54166666666667, 0.9, 0.27083333333333
57004, 0.54166666666667, 0.925, 0.29166666666667
57005, 0.52083333333333, 0.95, 0.29166666666667
57006, 0.54166666666667, 0.95, 0.27083333333333
57007, 0.54166666666667, 0.975, 0.29166666666667
57008, 0.52083333333333, 1, 0.29166666666667
57009, 0.54166666666667, 1, 0.27083333333333
57010, 0.54166666666667, 1.025, 0.29166666666667
57011, 0.52083333333333, 1.05, 0.29166666666667
57012, 0.54166666666667, 1.05, 0.27083333333333
57013, 0.54166666666667, 1.075, 0.29166666666667
57014, 0.52083333333333, 1.1, 0.29166666666667
57015, 0.54166666666667, 1.1, 0.27083333333333
57016, 0.54166666666667, 1.125, 0.29166666666667
57017, 0.52083333333333, 1.15, 0.29166666666667
57018, 0.54166666666667, 1.15, 0.27083333333333
57019, 0.54166666666667, 1.175, 0.29166666666667
57020, 0.52083333333333, 1.2, 0.29166666666667
57021, 0.54166666666667, 1.2, 0.27083333333333
57022, 0.54166666666667, 1.225, 0.29166666666667
57023, 0.52083333333333, 1.25, 0.29166666666667
57024, 0.54166666666667, 1.25, 0.27083333333333
57025, 0.54166666666667, 1.275, 0.29166666666667
57026, 0.52083333333333, 1.3, 0.29166666666667
57027, 0.54166666666667, 1.3, 0.27083333333333
57028, 0.54166666666667, 1.325, 0.29166666666667
57029, 0.54166666666667, 0.175, 0.33333333333333
57030, 0.52083333333333, 0.2, 0.33333333333333
57031, 0.54166666666667, 0.2, 0.3125
57032, 0.54166666666667, 0.225, 0.33333333333333
57033, 0.52083333333333, 0.25, 0.33333333333333
57034, 0.54166666666667, 0.25, 0.3125
57035, 0.54166666666667, 0.275, 0.33333333333333
57036, 0.52083333333333, 0.3, 0.33333333333333
57037, 0.54166666666667, 0.3, 0.3125
57038, 0.54166666666667, 0.325, 0.33333333333333
57039, 0.52083333333333, 0.35, 0.33333333333333
57040, 0.54166666666667, 0.35, 0.3125
57041, 0.54166666666667, 0.375, 0.33333333333333
57042, 0.52083333333333, 0.4, 0.33333333333333
57043, 0.54166666666667, 0.4, 0.3125
57044, 0.54166666666667, 0.425, 0.33333333333333
57045, 0.52083333333333, 0.45, 0.33333333333333
57046, 0.54166666666667, 0.45, 0.3125
57047, 0.54166666666667, 0.475, 0.33333333333333
57048, 0.52083333333333, 0.5, 0.33333333333333
57049, 0.54166666666667, 0.5, 0.3125
57050, 0.54166666666667, 0.525, 0.33333333333333
57051, 0.52083333333333, 0.55, 0.33333333333333
57052, 0.54166666666667, 0.55, 0.3125
57053, 0.54166666666667, 0.575, 0.33333333333333
57054, 0.52083333333333, 0.6, 0.33333333333333
57055, 0.54166666666667, 0.6, 0.3125
57056, 0.54166666666667, 0.625, 0.33333333333333
57057, 0.52083333333333, 0.65, 0.33333333333333
57058, 0.54166666666667, 0.65, 0.3125
57059, 0.54166666666667, 0.675, 0.33333333333333
57060, 0.52083333333333, 0.7, 0.33333333333333
57061, 0.54166666666667, 0.7, 0.3125
57062, 0.54166666666667, 0.725, 0.33333333333333
57063, 0.52083333333333, 0.75, 0.33333333333333
57064, 0.54166666666667, 0.75, 0.3125
57065, 0.54166666666667, 0.775, 0.33333333333333
57066, 0.52083333333333, 0.8, 0.33333333333333
57067, 0.54166666666667, 0.8, 0.3125
57068, 0.54166666666667, 0.825, 0.33333333333333
57069, 0.52083333333333, 0.85, 0.33333333333333
57070, 0.54166666666667, 0.85, 0.3125
57071, 0.54166666666667, 0.875, 0.33333333333333
57072, 0.52083333333333, 0.9, 0.33333333333333
57073, 0.54166666666667, 0.9, 0.3125
57074, 0.54166666666667, 0.925, 0.33333333333333
57075, 0.52083333333333, 0.95, 0.33333333333333
57076, 0.54166666666667, 0.95, 0.3125
57077, 0.54166666666667, 0.975, 0.33333333333333
57078, 0.52083333333333, 1, 0.33333333333333
57079, 0.54166666666667, 1, 0.3125
57080, 0.54166666666667, 1.025, 0.33333333333333
57081, 0.52083333333333, 1.05, 0.33333333333333
57082, 0.54166666666667, 1.05, 0.3125
57083, 0.54166666666667, 1.075, 0.33333333333333
57084, 0.52083333333333, 1.1, 0.33333333333333
57085, 0.54166666666667, 1.1, 0.3125
57086, 0.54166666666667, 1.125, 0.33333333333333
57087, 0.52083333333333, 1.15, 0.33333333333333
57088, 0.54166666666667, 1.15, 0.3125
57089, 0.54166666666667, 1.175, 0.33333333333333
57090, 0.52083333333333, 1.2, 0.33333333333333
57091, 0.54166666666667, 1.2, 0.3125
57092, 0.54166666666667, 1.225, 0.33333333333333
57093, 0.52083333333333, 1.25, 0.33333333333333
57094, 0.54166666666667, 1.25, 0.3125
57095, 0.54166666666667, 1.275, 0.33333333333333
57096, 0.52083333333333, 1.3, 0.33333333333333
57097, 0.54166666666667, 1.3, 0.3125
57098, 0.54166666666667, 1.325, 0.33333333333333
57099, 0.54166666666667, 0.175, 0.375
57100, 0.52083333333333, 0.2, 0.375
57101, 0.54166666666667, 0.2, 0.35416666666667
57102, 0.54166666666667, 0.225, 0.375
57103, 0.52083333333333, 0.25, 0.375
57104, 0.54166666666667, 0.25, 0.35416666666667
57105, 0.54166666666667, 0.275, 0.375
57106, 0.52083333333333, 0.3, 0.375
57107, 0.54166666666667, 0.3, 0.35416666666667
57108, 0.54166666666667, 0.325, 0.375
57109, 0.52083333333333, 0.35, 0.375
57110, 0.54166666666667, 0.35, 0.35416666666667
57111, 0.54166666666667, 0.375, 0.375
57112, 0.52083333333333, 0.4, 0.375
57113, 0.54166666666667, 0.4, 0.35416666666667
57114, 0.54166666666667, 0.425, 0.375
57115, 0.52083333333333, 0.45, 0.375
57116, 0.54166666666667, 0.45, 0.35416666666667
57117, 0.54166666666667, 0.475, 0.375
57118, 0.52083333333333, 0.5, 0.375
57119, 0.54166666666667, 0.5, 0.35416666666667
57120, 0.54166666666667, 0.525, 0.375
57121, 0.52083333333333, 0.55, 0.375
57122, 0.54166666666667, 0.55, 0.35416666666667
57123, 0.54166666666667, 0.575, 0.375
57124, 0.52083333333333, 0.6, 0.375
57125, 0.54166666666667, 0.6, 0.35416666666667
57126, 0.54166666666667, 0.625, 0.375
57127, 0.52083333333333, 0.65, 0.375
57128, 0.54166666666667, 0.65, 0.35416666666667
57129, 0.54166666666667, 0.675, 0.375
57130, 0.52083333333333, 0.7, 0.375
57131, 0.54166666666667, 0.7, 0.35416666666667
57132, 0.54166666666667, 0.725, 0.375
57133, 0.52083333333333, 0.75, 0.375
57134, 0.54166666666667, 0.75, 0.35416666666667
57135, 0.54166666666667, 0.775, 0.375
57136, 0.52083333333333, 0.8, 0.375
57137, 0.54166666666667, 0.8, 0.35416666666667
57138, 0.54166666666667, 0.825, 0.375
57139, 0.52083333333333, 0.85, 0.375
57140, 0.54166666666667, 0.85, 0.35416666666667
57141, 0.54166666666667, 0.875, 0.375
57142, 0.52083333333333, 0.9, 0.375
57143, 0.54166666666667, 0.9, 0.35416666666667
57144, 0.54166666666667, 0.925, 0.375
57145, 0.52083333333333, 0.95, 0.375
57146, 0.54166666666667, 0.95, 0.35416666666667
57147, 0.54166666666667, 0.975, 0.375
57148, 0.52083333333333, 1, 0.375
57149, 0.54166666666667, 1, 0.35416666666667
57150, 0.54166666666667, 1.025, 0.375
57151, 0.52083333333333, 1.05, 0.375
57152, 0.54166666666667, 1.05, 0.35416666666667
57153, 0.54166666666667, 1.075, 0.375
57154, 0.52083333333333, 1.1, 0.375
57155, 0.54166666666667, 1.1, 0.35416666666667
57156, 0.54166666666667, 1.125, 0.375
57157, 0.52083333333333, 1.15, 0.375
57158, 0.54166666666667, 1.15, 0.35416666666667
57159, 0.54166666666667, 1.175, 0.375
57160, 0.52083333333333, 1.2, 0.375
57161, 0.54166666666667, 1.2, 0.35416666666667
57162, 0.54166666666667, 1.225, 0.375
57163, 0.52083333333333, 1.25, 0.375
57164, 0.54166666666667, 1.25, 0.35416666666667
57165, 0.54166666666667, 1.275, 0.375
57166, 0.52083333333333, 1.3, 0.375
57167, 0.54166666666667, 1.3, 0.35416666666667
57168, 0.54166666666667, 1.325, 0.375
57169, 0.54166666666667, 0.175, 0.41666666666667
57170, 0.52083333333333, 0.2, 0.41666666666667
57171, 0.54166666666667, 0.2, 0.39583333333333
57172, 0.54166666666667, 0.225, 0.41666666666667
57173, 0.52083333333333, 0.25, 0.41666666666667
57174, 0.54166666666667, 0.25, 0.39583333333333
57175, 0.54166666666667, 0.275, 0.41666666666667
57176, 0.52083333333333, 0.3, 0.41666666666667
57177, 0.54166666666667, 0.3, 0.39583333333333
57178, 0.54166666666667, 0.325, 0.41666666666667
57179, 0.52083333333333, 0.35, 0.41666666666667
57180, 0.54166666666667, 0.35, 0.39583333333333
57181, 0.54166666666667, 0.375, 0.41666666666667
57182, 0.52083333333333, 0.4, 0.41666666666667
57183, 0.54166666666667, 0.4, 0.39583333333333
57184, 0.54166666666667, 0.425, 0.41666666666667
57185, 0.52083333333333, 0.45, 0.41666666666667
57186, 0.54166666666667, 0.45, 0.39583333333333
57187, 0.54166666666667, 0.475, 0.41666666666667
57188, 0.52083333333333, 0.5, 0.41666666666667
57189, 0.54166666666667, 0.5, 0.39583333333333
57190, 0.54166666666667, 0.525, 0.41666666666667
57191, 0.52083333333333, 0.55, 0.41666666666667
57192, 0.54166666666667, 0.55, 0.39583333333333
57193, 0.54166666666667, 0.575, 0.41666666666667
57194, 0.52083333333333, 0.6, 0.41666666666667
57195, 0.54166666666667, 0.6, 0.39583333333333
57196, 0.54166666666667, 0.625, 0.41666666666667
57197, 0.52083333333333, 0.65, 0.41666666666667
57198, 0.54166666666667, 0.65, 0.39583333333333
57199, 0.54166666666667, 0.675, 0.41666666666667
57200, 0.52083333333333, 0.7, 0.41666666666667
57201, 0.54166666666667, 0.7, 0.39583333333333
57202, 0.54166666666667, 0.725, 0.41666666666667
57203, 0.52083333333333, 0.75, 0.41666666666667
57204, 0.54166666666667, 0.75, 0.39583333333333
57205, 0.54166666666667, 0.775, 0.41666666666667
57206, 0.52083333333333, 0.8, 0.41666666666667
57207, 0.54166666666667, 0.8, 0.39583333333333
57208, 0.54166666666667, 0.825, 0.41666666666667
57209, 0.52083333333333, 0.85, 0.41666666666667
57210, 0.54166666666667, 0.85, 0.39583333333333
57211, 0.54166666666667, 0.875, 0.41666666666667
57212, 0.52083333333333, 0.9, 0.41666666666667
57213, 0.54166666666667, 0.9, 0.39583333333333
57214, 0.54166666666667, 0.925, 0.41666666666667
57215, 0.52083333333333, 0.95, 0.41666666666667
57216, 0.54166666666667, 0.95, 0.39583333333333
57217, 0.54166666666667, 0.975, 0.41666666666667
57218, 0.52083333333333, 1, 0.41666666666667
57219, 0.54166666666667, 1, 0.39583333333333
57220, 0.54166666666667, 1.025, 0.41666666666667
57221, 0.52083333333333, 1.05, 0.41666666666667
57222, 0.54166666666667, 1.05, 0.39583333333333
57223, 0.54166666666667, 1.075, 0.41666666666667
57224, 0.52083333333333, 1.1, 0.41666666666667
57225, 0.54166666666667, 1.1, 0.39583333333333
57226, 0.54166666666667, 1.125, 0.41666666666667
57227, 0.52083333333333, 1.15, 0.41666666666667
57228, 0.54166666666667, 1.15, 0.39583333333333
57229, 0.54166666666667, 1.175, 0.41666666666667
57230, 0.52083333333333, 1.2, 0.41666666666667
57231, 0.54166666666667, 1.2, 0.39583333333333
57232, 0.54166666666667, 1.225, 0.41666666666667
57233, 0.52083333333333, 1.25, 0.41666666666667
57234, 0.54166666666667, 1.25, 0.39583333333333
57235, 0.54166666666667, 1.275, 0.41666666666667
57236, 0.52083333333333, 1.3, 0.41666666666667
57237, 0.54166666666667, 1.3, 0.39583333333333
57238, 0.54166666666667, 1.325, 0.41666666666667
57239, 0.54166666666667, 0.175, 0.45833333333333
57240, 0.52083333333333, 0.2, 0.45833333333333
57241, 0.54166666666667, 0.2, 0.4375
57242, 0.54166666666667, 0.225, 0.45833333333333
57243, 0.52083333333333, 0.25, 0.45833333333333
57244, 0.54166666666667, 0.25, 0.4375
57245, 0.54166666666667, 0.275, 0.45833333333333
57246, 0.52083333333333, 0.3, 0.45833333333333
57247, 0.54166666666667, 0.3, 0.4375
57248, 0.54166666666667, 0.325, 0.45833333333333
57249, 0.52083333333333, 0.35, 0.45833333333333
57250, 0.54166666666667, 0.35, 0.4375
57251, 0.54166666666667, 0.375, 0.45833333333333
57252, 0.52083333333333, 0.4, 0.45833333333333
57253, 0.54166666666667, 0.4, 0.4375
57254, 0.54166666666667, 0.425, 0.45833333333333
57255, 0.52083333333333, 0.45, 0.45833333333333
57256, 0.54166666666667, 0.45, 0.4375
57257, 0.54166666666667, 0.475, 0.45833333333333
57258, 0.52083333333333, 0.5, 0.45833333333333
57259, 0.54166666666667, 0.5, 0.4375
57260, 0.54166666666667, 0.525, 0.45833333333333
57261, 0.52083333333333, 0.55, 0.45833333333333
57262, 0.54166666666667, 0.55, 0.4375
57263, 0.54166666666667, 0.575, 0.45833333333333
57264, 0.52083333333333, 0.6, 0.45833333333333
57265, 0.54166666666667, 0.6, 0.4375
57266, 0.54166666666667, 0.625, 0.45833333333333
57267, 0.52083333333333, 0.65, 0.45833333333333
57268, 0.54166666666667, 0.65, 0.4375
57269, 0.54166666666667, 0.675, 0.45833333333333
57270, 0.52083333333333, 0.7, 0.45833333333333
57271, 0.54166666666667, 0.7, 0.4375
57272, 0.54166666666667, 0.725, 0.45833333333333
57273, 0.52083333333333, 0.75, 0.45833333333333
57274, 0.54166666666667, 0.75, 0.4375
57275, 0.54166666666667, 0.775, 0.45833333333333
57276, 0.52083333333333, 0.8, 0.45833333333333
57277, 0.54166666666667, 0.8, 0.4375
57278, 0.54166666666667, 0.825, 0.45833333333333
57279, 0.52083333333333, 0.85, 0.45833333333333
57280, 0.54166666666667, 0.85, 0.4375
57281, 0.54166666666667, 0.875, 0.45833333333333
57282, 0.52083333333333, 0.9, 0.45833333333333
57283, 0.54166666666667, 0.9, 0.4375
57284, 0.54166666666667, 0.925, 0.45833333333333
57285, 0.52083333333333, 0.95, 0.45833333333333
57286, 0.54166666666667, 0.95, 0.4375
57287, 0.54166666666667, 0.975, 0.45833333333333
57288, 0.52083333333333, 1, 0.45833333333333
57289, 0.54166666666667, 1, 0.4375
57290, 0.54166666666667, 1.025, 0.45833333333333
57291, 0.52083333333333, 1.05, 0.45833333333333
57292, 0.54166666666667, 1.05, 0.4375
57293, 0.54166666666667, 1.075, 0.45833333333333
57294, 0.52083333333333, 1.1, 0.45833333333333
57295, 0.54166666666667, 1.1, 0.4375
57296, 0.54166666666667, 1.125, 0.45833333333333
57297, 0.52083333333333, 1.15, 0.45833333333333
57298, 0.54166666666667, 1.15, 0.4375
57299, 0.54166666666667, 1.175, 0.45833333333333
57300, 0.52083333333333, 1.2, 0.45833333333333
57301, 0.54166666666667, 1.2, 0.4375
57302, 0.54166666666667, 1.225, 0.45833333333333
57303, 0.52083333333333, 1.25, 0.45833333333333
57304, 0.54166666666667, 1.25, 0.4375
57305, 0.54166666666667, 1.275, 0.45833333333333
57306, 0.52083333333333, 1.3, 0.45833333333333
57307, 0.54166666666667, 1.3, 0.4375
57308, 0.54166666666667, 1.325, 0.45833333333333
57309, 0.54166666666667, 0.2, 0.47916666666667
57310, 0.54166666666667, 0.25, 0.47916666666667
57311, 0.54166666666667, 0.3, 0.47916666666667
57312, 0.54166666666667, 0.35, 0.47916666666667
57313, 0.54166666666667, 0.4, 0.47916666666667
57314, 0.54166666666667, 0.45, 0.47916666666667
57315, 0.54166666666667, 0.5, 0.47916666666667
57316, 0.54166666666667, 0.55, 0.47916666666667
57317, 0.54166666666667, 0.6, 0.47916666666667
57318, 0.54166666666667, 0.65, 0.47916666666667
57319, 0.54166666666667, 0.7, 0.47916666666667
57320, 0.54166666666667, 0.75, 0.47916666666667
57321, 0.54166666666667, 0.8, 0.47916666666667
57322, 0.54166666666667, 0.85, 0.47916666666667
57323, 0.54166666666667, 0.9, 0.47916666666667
57324, 0.54166666666667, 0.95, 0.47916666666667
57325, 0.54166666666667, 1, 0.47916666666667
57326, 0.54166666666667, 1.05, 0.47916666666667
57327, 0.54166666666667, 1.1, 0.47916666666667
57328, 0.54166666666667, 1.15, 0.47916666666667
57329, 0.54166666666667, 1.2, 0.47916666666667
57330, 0.54166666666667, 1.25, 0.47916666666667
57331, 0.54166666666667, 1.3, 0.47916666666667
57332, 0.58333333333333, 0.175, 0.041666666666667
57333, 0.5625, 0.2, 0.041666666666667
57334, 0.58333333333333, 0.2, 0.020833333333333
57335, 0.58333333333333, 0.225, 0.041666666666667
57336, 0.5625, 0.25, 0.041666666666667
57337, 0.58333333333333, 0.25, 0.020833333333333
57338, 0.58333333333333, 0.275, 0.041666666666667
57339, 0.5625, 0.3, 0.041666666666667
57340, 0.58333333333333, 0.3, 0.020833333333333
57341, 0.58333333333333, 0.325, 0.041666666666667
57342, 0.5625, 0.35, 0.041666666666667
57343, 0.58333333333333, 0.35, 0.020833333333333
57344, 0.58333333333333, 0.375, 0.041666666666667
57345, 0.5625, 0.4, 0.041666666666667
57346, 0.58333333333333, 0.4, 0.020833333333333
57347, 0.58333333333333, 0.425, 0.041666666666667
57348, 0.5625, 0.45, 0.041666666666667
57349, 0.58333333333333, 0.45, 0.020833333333333
57350, 0.58333333333333, 0.475, 0.041666666666667
57351, 0.5625, 0.5, 0.041666666666667
57352, 0.58333333333333, 0.5, 0.020833333333333
57353, 0.58333333333333, 0.525, 0.041666666666667
57354, 0.5625, 0.55, 0.041666666666667
57355, 0.58333333333333, 0.55, 0.020833333333333
57356, 0.58333333333333, 0.575, 0.041666666666667
57357, 0.5625, 0.6, 0.041666666666667
57358, 0.58333333333333, 0.6, 0.020833333333333
57359, 0.58333333333333, 0.625, 0.041666666666667
57360, 0.5625, 0.65, 0.041666666666667
57361, 0.58333333333333, 0.65, 0.020833333333333
57362, 0.58333333333333, 0.675, 0.041666666666667
57363, 0.5625, 0.7, 0.041666666666667
57364, 0.58333333333333, 0.7, 0.020833333333333
57365, 0.58333333333333, 0.725, 0.041666666666667
57366, 0.5625, 0.75, 0.041666666666667
57367, 0.58333333333333, 0.75, 0.020833333333333
57368, 0.58333333333333, 0.775, 0.041666666666667
57369, 0.5625, 0.8, 0.041666666666667
57370, 0.58333333333333, 0.8, 0.020833333333333
57371, 0.58333333333333, 0.825, 0.041666666666667
57372, 0.5625, 0.85, 0.041666666666667
57373, 0.58333333333333, 0.85, 0.020833333333333
57374, 0.58333333333333, 0.875, 0.041666666666667
57375, 0.5625, 0.9, 0.041666666666667
57376, 0.58333333333333, 0.9, 0.020833333333333
57377, 0.58333333333333, 0.925, 0.041666666666667
57378, 0.5625, 0.95, 0.041666666666667
57379, 0.58333333333333, 0.95, 0.020833333333333
57380, 0.58333333333333, 0.975, 0.041666666666667
57381, 0.5625, 1, 0.041666666666667
57382, 0.58333333333333, 1, 0.020833333333333
57383, 0.58333333333333, 1.025, 0.041666666666667
57384, 0.5625, 1.05, 0.041666666666667
57385, 0.58333333333333, 1.05, 0.020833333333333
57386, 0.58333333333333, 1.075, 0.041666666666667
57387, 0.5625, 1.1, 0.041666666666667
57388, 0.58333333333333, 1.1, 0.020833333333333
57389, 0.58333333333333, 1.125, 0.041666666666667
57390, 0.5625, 1.15, 0.041666666666667
57391, 0.58333333333333, 1.15, 0.020833333333333
57392, 0.58333333333333, 1.175, 0.041666666666667
57393, 0.5625, 1.2, 0.041666666666667
57394, 0.58333333333333, 1.2, 0.020833333333333
57395, 0.58333333333333, 1.225, 0.041666666666667
57396, 0.5625, 1.25, 0.041666666666667
57397, 0.58333333333333, 1.25, 0.020833333333333
57398, 0.58333333333333, 1.275, 0.041666666666667
57399, 0.5625, 1.3, 0.041666666666667
57400, 0.58333333333333, 1.3, 0.020833333333333
57401, 0.58333333333333, 1.325, 0.041666666666667
57402, 0.58333333333333, 0.175, 0.083333333333333
57403, 0.5625, 0.2, 0.083333333333333
57404, 0.58333333333333, 0.2, 0.0625
57405, 0.58333333333333, 0.225, 0.083333333333333
57406, 0.5625, 0.25, 0.083333333333333
57407, 0.58333333333333, 0.25, 0.0625
57408, 0.58333333333333, 0.275, 0.083333333333333
57409, 0.5625, 0.3, 0.083333333333333
57410, 0.58333333333333, 0.3, 0.0625
57411, 0.58333333333333, 0.325, 0.083333333333333
57412, 0.5625, 0.35, 0.083333333333333
57413, 0.58333333333333, 0.35, 0.0625
57414, 0.58333333333333, 0.375, 0.083333333333333
57415, 0.5625, 0.4, 0.083333333333333
57416, 0.58333333333333, 0.4, 0.0625
57417, 0.58333333333333, 0.425, 0.083333333333333
57418, 0.5625, 0.45, 0.083333333333333
57419, 0.58333333333333, 0.45, 0.0625
57420, 0.58333333333333, 0.475, 0.083333333333333
57421, 0.5625, 0.5, 0.083333333333333
57422, 0.58333333333333, 0.5, 0.0625
57423, 0.58333333333333, 0.525, 0.083333333333333
57424, 0.5625, 0.55, 0.083333333333333
57425, 0.58333333333333, 0.55, 0.0625
57426, 0.58333333333333, 0.575, 0.083333333333333
57427, 0.5625, 0.6, 0.083333333333333
57428, 0.58333333333333, 0.6, 0.0625
57429, 0.58333333333333, 0.625, 0.083333333333333
57430, 0.5625, 0.65, 0.083333333333333
57431, 0.58333333333333, 0.65, 0.0625
57432, 0.58333333333333, 0.675, 0.083333333333333
57433, 0.5625, 0.7, 0.083333333333333
57434, 0.58333333333333, 0.7, 0.0625
57435, 0.58333333333333, 0.725, 0.083333333333333
57436, 0.5625, 0.75, 0.083333333333333
57437, 0.58333333333333, 0.75, 0.0625
57438, 0.58333333333333, 0.775, 0.083333333333333
57439, 0.5625, 0.8, 0.083333333333333
57440, 0.58333333333333, 0.8, 0.0625
57441, 0.58333333333333, 0.825, 0.083333333333333
57442, 0.5625, 0.85, 0.083333333333333
57443, 0.58333333333333, 0.85, 0.0625
57444, 0.58333333333333, 0.875, 0.083333333333333
57445, 0.5625, 0.9, 0.083333333333333
57446, 0.58333333333333, 0.9, 0.0625
57447, 0.58333333333333, 0.925, 0.083333333333333
57448, 0.5625, 0.95, 0.083333333333333
57449, 0.58333333333333, 0.95, 0.0625
57450, 0.58333333333333, 0.975, 0.083333333333333
57451, 0.5625, 1, 0.083333333333333
57452, 0.58333333333333, 1, 0.0625
57453, 0.58333333333333, 1.025, 0.083333333333333
57454, 0.5625, 1.05, 0.083333333333333
57455, 0.58333333333333, 1.05, 0.0625
57456, 0.58333333333333, 1.075, 0.083333333333333
57457, 0.5625, 1.1, 0.083333333333333
57458, 0.58333333333333, 1.1, 0.0625
57459, 0.58333333333333, 1.125, 0.083333333333333
57460, 0.5625, 1.15, 0.083333333333333
57461, 0.58333333333333, 1.15, 0.0625
57462, 0.58333333333333, 1.175, 0.083333333333333
57463, 0.5625, 1.2, 0.083333333333333
57464, 0.58333333333333, 1.2, 0.0625
57465, 0.58333333333333, 1.225, 0.083333333333333
57466, 0.5625, 1.25, 0.083333333333333
57467, 0.58333333333333, 1.25, 0.0625
57468, 0.58333333333333, 1.275, 0.083333333333333
57469, 0.5625, 1.3, 0.083333333333333
57470, 0.58333333333333, 1.3, 0.0625
57471, 0.58333333333333, 1.325, 0.083333333333333
57472, 0.58333333333333, 0.175, 0.125
57473, 0.5625, 0.2, 0.125
57474, 0.58333333333333, 0.2, 0.10416666666667
57475, 0.58333333333333, 0.225, 0.125
57476, 0.5625, 0.25, 0.125
57477, 0.58333333333333, 0.25, 0.10416666666667
57478, 0.58333333333333, 0.275, 0.125
57479, 0.5625, 0.3, 0.125
57480, 0.58333333333333, 0.3, 0.10416666666667
57481, 0.58333333333333, 0.325, 0.125
57482, 0.5625, 0.35, 0.125
57483, 0.58333333333333, 0.35, 0.10416666666667
57484, 0.58333333333333, 0.375, 0.125
57485, 0.5625, 0.4, 0.125
57486, 0.58333333333333, 0.4, 0.10416666666667
57487, 0.58333333333333, 0.425, 0.125
57488, 0.5625, 0.45, 0.125
57489, 0.58333333333333, 0.45, 0.10416666666667
57490, 0.58333333333333, 0.475, 0.125
57491, 0.5625, 0.5, 0.125
57492, 0.58333333333333, 0.5, 0.10416666666667
57493, 0.58333333333333, 0.525, 0.125
57494, 0.5625, 0.55, 0.125
57495, 0.58333333333333, 0.55, 0.10416666666667
57496, 0.58333333333333, 0.575, 0.125
57497, 0.5625, 0.6, 0.125
57498, 0.58333333333333, 0.6, 0.10416666666667
57499, 0.58333333333333, 0.625, 0.125
57500, 0.5625, 0.65, 0.125
57501, 0.58333333333333, 0.65, 0.10416666666667
57502, 0.58333333333333, 0.675, 0.125
57503, 0.5625, 0.7, 0.125
57504, 0.58333333333333, 0.7, 0.10416666666667
57505, 0.58333333333333, 0.725, 0.125
57506, 0.5625, 0.75, 0.125
57507, 0.58333333333333, 0.75, 0.10416666666667
57508, 0.58333333333333, 0.775, 0.125
57509, 0.5625, 0.8, 0.125
57510, 0.58333333333333, 0.8, 0.10416666666667
57511, 0.58333333333333, 0.825, 0.125
57512, 0.5625, 0.85, 0.125
57513, 0.58333333333333, 0.85, 0.10416666666667
57514, 0.58333333333333, 0.875, 0.125
57515, 0.5625, 0.9, 0.125
57516, 0.58333333333333, 0.9, 0.10416666666667
57517, 0.58333333333333, 0.925, 0.125
57518, 0.5625, 0.95, 0.125
57519, 0.58333333333333, 0.95, 0.10416666666667
57520, 0.58333333333333, 0.975, 0.125
57521, 0.5625, 1, 0.125
57522, 0.58333333333333, 1, 0.10416666666667
57523, 0.58333333333333, 1.025, 0.125
57524, 0.5625, 1.05, 0.125
57525, 0.58333333333333, 1.05, 0.10416666666667
57526, 0.58333333333333, 1.075, 0.125
57527, 0.5625, 1.1, 0.125
57528, 0.58333333333333, 1.1, 0.10416666666667
57529, 0.58333333333333, 1.125, 0.125
57530, 0.5625, 1.15, 0.125
57531, 0.58333333333333, 1.15, 0.10416666666667
57532, 0.58333333333333, 1.175, 0.125
57533, 0.5625, 1.2, 0.125
57534, 0.58333333333333, 1.2, 0.10416666666667
57535, 0.58333333333333, 1.225, 0.125
57536, 0.5625, 1.25, 0.125
57537, 0.58333333333333, 1.25, 0.10416666666667
57538, 0.58333333333333, 1.275, 0.125
57539, 0.5625, 1.3, 0.125
57540, 0.58333333333333, 1.3, 0.10416666666667
57541, 0.58333333333333, 1.325, 0.125
57542, 0.58333333333333, 0.175, 0.16666666666667
57543, 0.5625, 0.2, 0.16666666666667
57544, 0.58333333333333, 0.2, 0.14583333333333
57545, 0.58333333333333, 0.225, 0.16666666666667
57546, 0.5625, 0.25, 0.16666666666667
57547, 0.58333333333333, 0.25, 0.14583333333333
57548, 0.58333333333333, 0.275, 0.16666666666667
57549, 0.5625, 0.3, 0.16666666666667
57550, 0.58333333333333, 0.3, 0.14583333333333
57551, 0.58333333333333, 0.325, 0.16666666666667
57552, 0.5625, 0.35, 0.16666666666667
57553, 0.58333333333333, 0.35, 0.14583333333333
57554, 0.58333333333333, 0.375, 0.16666666666667
57555, 0.5625, 0.4, 0.16666666666667
57556, 0.58333333333333, 0.4, 0.14583333333333
57557, 0.58333333333333, 0.425, 0.16666666666667
57558, 0.5625, 0.45, 0.16666666666667
57559, 0.58333333333333, 0.45, 0.14583333333333
57560, 0.58333333333333, 0.475, 0.16666666666667
57561, 0.5625, 0.5, 0.16666666666667
57562, 0.58333333333333, 0.5, 0.14583333333333
57563, 0.58333333333333, 0.525, 0.16666666666667
57564, 0.5625, 0.55, 0.16666666666667
57565, 0.58333333333333, 0.55, 0.14583333333333
57566, 0.58333333333333, 0.575, 0.16666666666667
57567, 0.5625, 0.6, 0.16666666666667
57568, 0.58333333333333, 0.6, 0.14583333333333
57569, 0.58333333333333, 0.625, 0.16666666666667
57570, 0.5625, 0.65, 0.16666666666667
57571, 0.58333333333333, 0.65, 0.14583333333333
57572, 0.58333333333333, 0.675, 0.16666666666667
57573, 0.5625, 0.7, 0.16666666666667
57574, 0.58333333333333, 0.7, 0.14583333333333
57575, 0.58333333333333, 0.725, 0.16666666666667
57576, 0.5625, 0.75, 0.16666666666667
57577, 0.58333333333333, 0.75, 0.14583333333333
57578, 0.58333333333333, 0.775, 0.16666666666667
57579, 0.5625, 0.8, 0.16666666666667
57580, 0.58333333333333, 0.8, 0.14583333333333
57581, 0.58333333333333, 0.825, 0.16666666666667
57582, 0.5625, 0.85, 0.16666666666667
57583, 0.58333333333333, 0.85, 0.14583333333333
57584, 0.58333333333333, 0.875, 0.16666666666667
57585, 0.5625, 0.9, 0.16666666666667
57586, 0.58333333333333, 0.9, 0.14583333333333
57587, 0.58333333333333, 0.925, 0.16666666666667
57588, 0.5625, 0.95, 0.16666666666667
57589, 0.58333333333333, 0.95, 0.14583333333333
57590, 0.58333333333333, 0.975, 0.16666666666667
57591, 0.5625, 1, 0.16666666666667
57592, 0.58333333333333, 1, 0.14583333333333
57593, 0.58333333333333, 1.025, 0.16666666666667
57594, 0.5625, 1.05, 0.16666666666667
57595, 0.58333333333333, 1.05, 0.14583333333333
57596, 0.58333333333333, 1.075, 0.16666666666667
57597, 0.5625, 1.1, 0.16666666666667
57598, 0.58333333333333, 1.1, 0.14583333333333
57599, 0.58333333333333, 1.125, 0.16666666666667
57600, 0.5625, 1.15, 0.16666666666667
57601, 0.58333333333333, 1.15, 0.14583333333333
57602, 0.58333333333333, 1.175, 0.16666666666667
57603, 0.5625, 1.2, 0.16666666666667
57604, 0.58333333333333, 1.2, 0.14583333333333
57605, 0.58333333333333, 1.225, 0.16666666666667
57606, 0.5625, 1.25, 0.16666666666667
57607, 0.58333333333333, 1.25, 0.14583333333333
57608, 0.58333333333333, 1.275, 0.16666666666667
57609, 0.5625, 1.3, 0.16666666666667
57610, 0.58333333333333, 1.3, 0.14583333333333
57611, 0.58333333333333, 1.325, 0.16666666666667
57612, 0.58333333333333, 0.175, 0.20833333333333
57613, 0.5625, 0.2, 0.20833333333333
57614, 0.58333333333333, 0.2, 0.1875
57615, 0.58333333333333, 0.225, 0.20833333333333
57616, 0.5625, 0.25, 0.20833333333333
57617, 0.58333333333333, 0.25, 0.1875
57618, 0.58333333333333, 0.275, 0.20833333333333
57619, 0.5625, 0.3, 0.20833333333333
57620, 0.58333333333333, 0.3, 0.1875
57621, 0.58333333333333, 0.325, 0.20833333333333
57622, 0.5625, 0.35, 0.20833333333333
57623, 0.58333333333333, 0.35, 0.1875
57624, 0.58333333333333, 0.375, 0.20833333333333
57625, 0.5625, 0.4, 0.20833333333333
57626, 0.58333333333333, 0.4, 0.1875
57627, 0.58333333333333, 0.425, 0.20833333333333
57628, 0.5625, 0.45, 0.20833333333333
57629, 0.58333333333333, 0.45, 0.1875
57630, 0.58333333333333, 0.475, 0.20833333333333
57631, 0.5625, 0.5, 0.20833333333333
57632, 0.58333333333333, 0.5, 0.1875
57633, 0.58333333333333, 0.525, 0.20833333333333
57634, 0.5625, 0.55, 0.20833333333333
57635, 0.58333333333333, 0.55, 0.1875
57636, 0.58333333333333, 0.575, 0.20833333333333
57637, 0.5625, 0.6, 0.20833333333333
57638, 0.58333333333333, 0.6, 0.1875
57639, 0.58333333333333, 0.625, 0.20833333333333
57640, 0.5625, 0.65, 0.20833333333333
57641, 0.58333333333333, 0.65, 0.1875
57642, 0.58333333333333, 0.675, 0.20833333333333
57643, 0.5625, 0.7, 0.20833333333333
57644, 0.58333333333333, 0.7, 0.1875
57645, 0.58333333333333, 0.725, 0.20833333333333
57646, 0.5625, 0.75, 0.20833333333333
57647, 0.58333333333333, 0.75, 0.1875
57648, 0.58333333333333, 0.775, 0.20833333333333
57649, 0.5625, 0.8, 0.20833333333333
57650, 0.58333333333333, 0.8, 0.1875
57651, 0.58333333333333, 0.825, 0.20833333333333
57652, 0.5625, 0.85, 0.20833333333333
57653, 0.58333333333333, 0.85, 0.1875
57654, 0.58333333333333, 0.875, 0.20833333333333
57655, 0.5625, 0.9, 0.20833333333333
57656, 0.58333333333333, 0.9, 0.1875
57657, 0.58333333333333, 0.925, 0.20833333333333
57658, 0.5625, 0.95, 0.20833333333333
57659, 0.58333333333333, 0.95, 0.1875
57660, 0.58333333333333, 0.975, 0.20833333333333
57661, 0.5625, 1, 0.20833333333333
57662, 0.58333333333333, 1, 0.1875
57663, 0.58333333333333, 1.025, 0.20833333333333
57664, 0.5625, 1.05, 0.20833333333333
57665, 0.58333333333333, 1.05, 0.1875
57666, 0.58333333333333, 1.075, 0.20833333333333
57667, 0.5625, 1.1, 0.20833333333333
57668, 0.58333333333333, 1.1, 0.1875
57669, 0.58333333333333, 1.125, 0.20833333333333
57670, 0.5625, 1.15, 0.20833333333333
57671, 0.58333333333333, 1.15, 0.1875
57672, 0.58333333333333, 1.175, 0.20833333333333
57673, 0.5625, 1.2, 0.20833333333333
57674, 0.58333333333333, 1.2, 0.1875
57675, 0.58333333333333, 1.225, 0.20833333333333
57676, 0.5625, 1.25, 0.20833333333333
57677, 0.58333333333333, 1.25, 0.1875
57678, 0.58333333333333, 1.275, 0.20833333333333
57679, 0.5625, 1.3, 0.20833333333333
57680, 0.58333333333333, 1.3, 0.1875
57681, 0.58333333333333, 1.325, 0.20833333333333
57682, 0.58333333333333, 0.175, 0.25
57683, 0.5625, 0.2, 0.25
57684, 0.58333333333333, 0.2, 0.22916666666667
57685, 0.58333333333333, 0.225, 0.25
57686, 0.5625, 0.25, 0.25
57687, 0.58333333333333, 0.25, 0.22916666666667
57688, 0.58333333333333, 0.275, 0.25
57689, 0.5625, 0.3, 0.25
57690, 0.58333333333333, 0.3, 0.22916666666667
57691, 0.58333333333333, 0.325, 0.25
57692, 0.5625, 0.35, 0.25
57693, 0.58333333333333, 0.35, 0.22916666666667
57694, 0.58333333333333, 0.375, 0.25
57695, 0.5625, 0.4, 0.25
57696, 0.58333333333333, 0.4, 0.22916666666667
57697, 0.58333333333333, 0.425, 0.25
57698, 0.5625, 0.45, 0.25
57699, 0.58333333333333, 0.45, 0.22916666666667
57700, 0.58333333333333, 0.475, 0.25
57701, 0.5625, 0.5, 0.25
57702, 0.58333333333333, 0.5, 0.22916666666667
57703, 0.58333333333333, 0.525, 0.25
57704, 0.5625, 0.55, 0.25
57705, 0.58333333333333, 0.55, 0.22916666666667
57706, 0.58333333333333, 0.575, 0.25
57707, 0.5625, 0.6, 0.25
57708, 0.58333333333333, 0.6, 0.22916666666667
57709, 0.58333333333333, 0.625, 0.25
57710, 0.5625, 0.65, 0.25
57711, 0.58333333333333, 0.65, 0.22916666666667
57712, 0.58333333333333, 0.675, 0.25
57713, 0.5625, 0.7, 0.25
57714, 0.58333333333333, 0.7, 0.22916666666667
57715, 0.58333333333333, 0.725, 0.25
57716, 0.5625, 0.75, 0.25
57717, 0.58333333333333, 0.75, 0.22916666666667
57718, 0.58333333333333, 0.775, 0.25
57719, 0.5625, 0.8, 0.25
57720, 0.58333333333333, 0.8, 0.22916666666667
57721, 0.58333333333333, 0.825, 0.25
57722, 0.5625, 0.85, 0.25
57723, 0.58333333333333, 0.85, 0.22916666666667
57724, 0.58333333333333, 0.875, 0.25
57725, 0.5625, 0.9, 0.25
57726, 0.58333333333333, 0.9, 0.22916666666667
57727, 0.58333333333333, 0.925, 0.25
57728, 0.5625, 0.95, 0.25
57729, 0.58333333333333, 0.95, 0.22916666666667
57730, 0.58333333333333, 0.975, 0.25
57731, 0.5625, 1, 0.25
57732, 0.58333333333333, 1, 0.22916666666667
57733, 0.58333333333333, 1.025, 0.25
57734, 0.5625, 1.05, 0.25
57735, 0.58333333333333, 1.05, 0.22916666666667
57736, 0.58333333333333, 1.075, 0.25
57737, 0.5625, 1.1, 0.25
57738, 0.58333333333333, 1.1, 0.22916666666667
57739, 0.58333333333333, 1.125, 0.25
57740, 0.5625, 1.15, 0.25
57741, 0.58333333333333, 1.15, 0.22916666666667
57742, 0.58333333333333, 1.175, 0.25
57743, 0.5625, 1.2, 0.25
57744, 0.58333333333333, 1.2, 0.22916666666667
57745, 0.58333333333333, 1.225, 0.25
57746, 0.5625, 1.25, 0.25
57747, 0.58333333333333, 1.25, 0.22916666666667
57748, 0.58333333333333, 1.275, 0.25
57749, 0.5625, 1.3, 0.25
57750, 0.58333333333333, 1.3, 0.22916666666667
57751, 0.58333333333333, 1.325, 0.25
57752, 0.58333333333333, 0.175, 0.29166666666667
57753, 0.5625, 0.2, 0.29166666666667
57754, 0.58333333333333, 0.2, 0.27083333333333
57755, 0.58333333333333, 0.225, 0.29166666666667
57756, 0.5625, 0.25, 0.29166666666667
57757, 0.58333333333333, 0.25, 0.27083333333333
57758, 0.58333333333333, 0.275, 0.29166666666667
57759, 0.5625, 0.3, 0.29166666666667
57760, 0.58333333333333, 0.3, 0.27083333333333
57761, 0.58333333333333, 0.325, 0.29166666666667
57762, 0.5625, 0.35, 0.29166666666667
57763, 0.58333333333333, 0.35, 0.27083333333333
57764, 0.58333333333333, 0.375, 0.29166666666667
57765, 0.5625, 0.4, 0.29166666666667
57766, 0.58333333333333, 0.4, 0.27083333333333
57767, 0.58333333333333, 0.425, 0.29166666666667
57768, 0.5625, 0.45, 0.29166666666667
57769, 0.58333333333333, 0.45, 0.27083333333333
57770, 0.58333333333333, 0.475, 0.29166666666667
57771, 0.5625, 0.5, 0.29166666666667
57772, 0.58333333333333, 0.5, 0.27083333333333
57773, 0.58333333333333, 0.525, 0.29166666666667
57774, 0.5625, 0.55, 0.29166666666667
57775, 0.58333333333333, 0.55, 0.27083333333333
57776, 0.58333333333333, 0.575, 0.29166666666667
57777, 0.5625, 0.6, 0.29166666666667
57778, 0.58333333333333, 0.6, 0.27083333333333
57779, 0.58333333333333, 0.625, 0.29166666666667
57780, 0.5625, 0.65, 0.29166666666667
57781, 0.58333333333333, 0.65, 0.27083333333333
57782, 0.58333333333333, 0.675, 0.29166666666667
57783, 0.5625, 0.7, 0.29166666666667
57784, 0.58333333333333, 0.7, 0.27083333333333
57785, 0.58333333333333, 0.725, 0.29166666666667
57786, 0.5625, 0.75, 0.29166666666667
57787, 0.58333333333333, 0.75, 0.27083333333333
57788, 0.58333333333333, 0.775, 0.29166666666667
57789, 0.5625, 0.8, 0.29166666666667
57790, 0.58333333333333, 0.8, 0.27083333333333
57791, 0.58333333333333, 0.825, 0.29166666666667
57792, 0.5625, 0.85, 0.29166666666667
57793, 0.58333333333333, 0.85, 0.27083333333333
57794, 0.58333333333333, 0.875, 0.29166666666667
57795, 0.5625, 0.9, 0.29166666666667
57796, 0.58333333333333, 0.9, 0.27083333333333
57797, 0.58333333333333, 0.925, 0.29166666666667
57798, 0.5625, 0.95, 0.29166666666667
57799, 0.58333333333333, 0.95, 0.27083333333333
57800, 0.58333333333333, 0.975, 0.29166666666667
57801, 0.5625, 1, 0.29166666666667
57802, 0.58333333333333, 1, 0.27083333333333
57803, 0.58333333333333, 1.025, 0.29166666666667
57804, 0.5625, 1.05, 0.29166666666667
57805, 0.58333333333333, 1.05, 0.27083333333333
57806, 0.58333333333333, 1.075, 0.29166666666667
57807, 0.5625, 1.1, 0.29166666666667
57808, 0.58333333333333, 1.1, 0.27083333333333
57809, 0.58333333333333, 1.125, 0.29166666666667
57810, 0.5625, 1.15, 0.29166666666667
57811, 0.58333333333333, 1.15, 0.27083333333333
57812, 0.58333333333333, 1.175, 0.29166666666667
57813, 0.5625, 1.2, 0.29166666666667
57814, 0.58333333333333, 1.2, 0.27083333333333
57815, 0.58333333333333, 1.225, 0.29166666666667
57816, 0.5625, 1.25, 0.29166666666667
57817, 0.58333333333333, 1.25, 0.27083333333333
57818, 0.58333333333333, 1.275, 0.29166666666667
57819, 0.5625, 1.3, 0.29166666666667
57820, 0.58333333333333, 1.3, 0.27083333333333
57821, 0.58333333333333, 1.325, 0.29166666666667
57822, 0.58333333333333, 0.175, 0.33333333333333
57823, 0.5625, 0.2, 0.33333333333333
57824, 0.58333333333333, 0.2, 0.3125
57825, 0.58333333333333, 0.225, 0.33333333333333
57826, 0.5625, 0.25, 0.33333333333333
57827, 0.58333333333333, 0.25, 0.3125
57828, 0.58333333333333, 0.275, 0.33333333333333
57829, 0.5625, 0.3, 0.33333333333333
57830, 0.58333333333333, 0.3, 0.3125
57831, 0.58333333333333, 0.325, 0.33333333333333
57832, 0.5625, 0.35, 0.33333333333333
57833, 0.58333333333333, 0.35, 0.3125
57834, 0.58333333333333, 0.375, 0.33333333333333
57835, 0.5625, 0.4, 0.33333333333333
57836, 0.58333333333333, 0.4, 0.3125
57837, 0.58333333333333, 0.425, 0.33333333333333
57838, 0.5625, 0.45, 0.33333333333333
57839, 0.58333333333333, 0.45, 0.3125
57840, 0.58333333333333, 0.475, 0.33333333333333
57841, 0.5625, 0.5, 0.33333333333333
57842, 0.58333333333333, 0.5, 0.3125
57843, 0.58333333333333, 0.525, 0.33333333333333
57844, 0.5625, 0.55, 0.33333333333333
57845, 0.58333333333333, 0.55, 0.3125
57846, 0.58333333333333, 0.575, 0.33333333333333
57847, 0.5625, 0.6, 0.33333333333333
57848, 0.58333333333333, 0.6, 0.3125
57849, 0.58333333333333, 0.625, 0.33333333333333
57850, 0.5625, 0.65, 0.33333333333333
57851, 0.58333333333333, 0.65, 0.3125
57852, 0.58333333333333, 0.675, 0.33333333333333
57853, 0.5625, 0.7, 0.33333333333333
57854, 0.58333333333333, 0.7, 0.3125
57855, 0.58333333333333, 0.725, 0.33333333333333
57856, 0.5625, 0.75, 0.33333333333333
57857, 0.58333333333333, 0.75, 0.3125
57858, 0.58333333333333, 0.775, 0.33333333333333
57859, 0.5625, 0.8, 0.33333333333333
57860, 0.58333333333333, 0.8, 0.3125
57861, 0.58333333333333, 0.825, 0.33333333333333
57862, 0.5625, 0.85, 0.33333333333333
57863, 0.58333333333333, 0.85, 0.3125
57864, 0.58333333333333, 0.875, 0.33333333333333
57865, 0.5625, 0.9, 0.33333333333333
57866, 0.58333333333333, 0.9, 0.3125
57867, 0.58333333333333, 0.925, 0.33333333333333
57868, 0.5625, 0.95, 0.33333333333333
57869, 0.58333333333333, 0.95, 0.3125
57870, 0.58333333333333, 0.975, 0.33333333333333
57871, 0.5625, 1, 0.33333333333333
57872, 0.58333333333333, 1, 0.3125
57873, 0.58333333333333, 1.025, 0.33333333333333
57874, 0.5625, 1.05, 0.33333333333333
57875, 0.58333333333333, 1.05, 0.3125
57876, 0.58333333333333, 1.075, 0.33333333333333
57877, 0.5625, 1.1, 0.33333333333333
57878, 0.58333333333333, 1.1, 0.3125
57879, 0.58333333333333, 1.125, 0.33333333333333
57880, 0.5625, 1.15, 0.33333333333333
57881, 0.58333333333333, 1.15, 0.3125
57882, 0.58333333333333, 1.175, 0.33333333333333
57883, 0.5625, 1.2, 0.33333333333333
57884, 0.58333333333333, 1.2, 0.3125
57885, 0.58333333333333, 1.225, 0.33333333333333
57886, 0.5625, 1.25, 0.33333333333333
57887, 0.58333333333333, 1.25, 0.3125
57888, 0.58333333333333, 1.275, 0.33333333333333
57889, 0.5625, 1.3, 0.33333333333333
57890, 0.58333333333333, 1.3, 0.3125
57891, 0.58333333333333, 1.325, 0.33333333333333
57892, 0.58333333333333, 0.175, 0.375
57893, 0.5625, 0.2, 0.375
57894, 0.58333333333333, 0.2, 0.35416666666667
57895, 0.58333333333333, 0.225, 0.375
57896, 0.5625, 0.25, 0.375
57897, 0.58333333333333, 0.25, 0.35416666666667
57898, 0.58333333333333, 0.275, 0.375
57899, 0.5625, 0.3, 0.375
57900, 0.58333333333333, 0.3, 0.35416666666667
57901, 0.58333333333333, 0.325, 0.375
57902, 0.5625, 0.35, 0.375
57903, 0.58333333333333, 0.35, 0.35416666666667
57904, 0.58333333333333, 0.375, 0.375
57905, 0.5625, 0.4, 0.375
57906, 0.58333333333333, 0.4, 0.35416666666667
57907, 0.58333333333333, 0.425, 0.375
57908, 0.5625, 0.45, 0.375
57909, 0.58333333333333, 0.45, 0.35416666666667
57910, 0.58333333333333, 0.475, 0.375
57911, 0.5625, 0.5, 0.375
57912, 0.58333333333333, 0.5, 0.35416666666667
57913, 0.58333333333333, 0.525, 0.375
57914, 0.5625, 0.55, 0.375
57915, 0.58333333333333, 0.55, 0.35416666666667
57916, 0.58333333333333, 0.575, 0.375
57917, 0.5625, 0.6, 0.375
57918, 0.58333333333333, 0.6, 0.35416666666667
57919, 0.58333333333333, 0.625, 0.375
57920, 0.5625, 0.65, 0.375
57921, 0.58333333333333, 0.65, 0.35416666666667
57922, 0.58333333333333, 0.675, 0.375
57923, 0.5625, 0.7, 0.375
57924, 0.58333333333333, 0.7, 0.35416666666667
57925, 0.58333333333333, 0.725, 0.375
57926, 0.5625, 0.75, 0.375
57927, 0.58333333333333, 0.75, 0.35416666666667
57928, 0.58333333333333, 0.775, 0.375
57929, 0.5625, 0.8, 0.375
57930, 0.58333333333333, 0.8, 0.35416666666667
57931, 0.58333333333333, 0.825, 0.375
57932, 0.5625, 0.85, 0.375
57933, 0.58333333333333, 0.85, 0.35416666666667
57934, 0.58333333333333, 0.875, 0.375
57935, 0.5625, 0.9, 0.375
57936, 0.58333333333333, 0.9, 0.35416666666667
57937, 0.58333333333333, 0.925, 0.375
57938, 0.5625, 0.95, 0.375
57939, 0.58333333333333, 0.95, 0.35416666666667
57940, 0.58333333333333, 0.975, 0.375
57941, 0.5625, 1, 0.375
57942, 0.58333333333333, 1, 0.35416666666667
57943, 0.58333333333333, 1.025, 0.375
57944, 0.5625, 1.05, 0.375
57945, 0.58333333333333, 1.05, 0.35416666666667
57946, 0.58333333333333, 1.075, 0.375
57947, 0.5625, 1.1, 0.375
57948, 0.58333333333333, 1.1, 0.35416666666667
57949, 0.58333333333333, 1.125, 0.375
57950, 0.5625, 1.15, 0.375
57951, 0.58333333333333, 1.15, 0.35416666666667
57952, 0.58333333333333, 1.175, 0.375
57953, 0.5625, 1.2, 0.375
57954, 0.58333333333333, 1.2, 0.35416666666667
57955, 0.58333333333333, 1.225, 0.375
57956, 0.5625, 1.25, 0.375
57957, 0.58333333333333, 1.25, 0.35416666666667
57958, 0.58333333333333, 1.275, 0.375
57959, 0.5625, 1.3, 0.375
57960, 0.58333333333333, 1.3, 0.35416666666667
57961, 0.58333333333333, 1.325, 0.375
57962, 0.58333333333333, 0.175, 0.41666666666667
57963, 0.5625, 0.2, 0.41666666666667
57964, 0.58333333333333, 0.2, 0.39583333333333
57965, 0.58333333333333, 0.225, 0.41666666666667
57966, 0.5625, 0.25, 0.41666666666667
57967, 0.58333333333333, 0.25, 0.39583333333333
57968, 0.58333333333333, 0.275, 0.41666666666667
57969, 0.5625, 0.3, 0.41666666666667
57970, 0.58333333333333, 0.3, 0.39583333333333
57971, 0.58333333333333, 0.325, 0.41666666666667
57972, 0.5625, 0.35, 0.41666666666667
57973, 0.58333333333333, 0.35, 0.39583333333333
57974, 0.58333333333333, 0.375, 0.41666666666667
57975, 0.5625, 0.4, 0.41666666666667
57976, 0.58333333333333, 0.4, 0.39583333333333
57977, 0.58333333333333, 0.425, 0.41666666666667
57978, 0.5625, 0.45, 0.41666666666667
57979, 0.58333333333333, 0.45, 0.39583333333333
57980, 0.58333333333333, 0.475, 0.41666666666667
57981, 0.5625, 0.5, 0.41666666666667
57982, 0.58333333333333, 0.5, 0.39583333333333
57983, 0.58333333333333, 0.525, 0.41666666666667
57984, 0.5625, 0.55, 0.41666666666667
57985, 0.58333333333333, 0.55, 0.39583333333333
57986, 0.58333333333333, 0.575, 0.41666666666667
57987, 0.5625, 0.6, 0.41666666666667
57988, 0.58333333333333, 0.6, 0.39583333333333
57989, 0.58333333333333, 0.625, 0.41666666666667
57990, 0.5625, 0.65, 0.41666666666667
57991, 0.58333333333333, 0.65, 0.39583333333333
57992, 0.58333333333333, 0.675, 0.41666666666667
57993, 0.5625, 0.7, 0.41666666666667
57994, 0.58333333333333, 0.7, 0.39583333333333
57995, 0.58333333333333, 0.725, 0.41666666666667
57996, 0.5625, 0.75, 0.41666666666667
57997, 0.58333333333333, 0.75, 0.39583333333333
57998, 0.58333333333333, 0.775, 0.41666666666667
57999, 0.5625, 0.8, 0.41666666666667
58000, 0.58333333333333, 0.8, 0.39583333333333
58001, 0.58333333333333, 0.825, 0.41666666666667
58002, 0.5625, 0.85, 0.41666666666667
58003, 0.58333333333333, 0.85, 0.39583333333333
58004, 0.58333333333333, 0.875, 0.41666666666667
58005, 0.5625, 0.9, 0.41666666666667
58006, 0.58333333333333, 0.9, 0.39583333333333
58007, 0.58333333333333, 0.925, 0.41666666666667
58008, 0.5625, 0.95, 0.41666666666667
58009, 0.58333333333333, 0.95, 0.39583333333333
58010, 0.58333333333333, 0.975, 0.41666666666667
58011, 0.5625, 1, 0.41666666666667
58012, 0.58333333333333, 1, 0.39583333333333
58013, 0.58333333333333, 1.025, 0.41666666666667
58014, 0.5625, 1.05, 0.41666666666667
58015, 0.58333333333333, 1.05, 0.39583333333333
58016, 0.58333333333333, 1.075, 0.41666666666667
58017, 0.5625, 1.1, 0.41666666666667
58018, 0.58333333333333, 1.1, 0.39583333333333
58019, 0.58333333333333, 1.125, 0.41666666666667
58020, 0.5625, 1.15, 0.41666666666667
58021, 0.58333333333333, 1.15, 0.39583333333333
58022, 0.58333333333333, 1.175, 0.41666666666667
58023, 0.5625, 1.2, 0.41666666666667
58024, 0.58333333333333, 1.2, 0.39583333333333
58025, 0.58333333333333, 1.225, 0.41666666666667
58026, 0.5625, 1.25, 0.41666666666667
58027, 0.58333333333333, 1.25, 0.39583333333333
58028, 0.58333333333333, 1.275, 0.41666666666667
58029, 0.5625, 1.3, 0.41666666666667
58030, 0.58333333333333, 1.3, 0.39583333333333
58031, 0.58333333333333, 1.325, 0.41666666666667
58032, 0.58333333333333, 0.175, 0.45833333333333
58033, 0.5625, 0.2, 0.45833333333333
58034, 0.58333333333333, 0.2, 0.4375
58035, 0.58333333333333, 0.225, 0.45833333333333
58036, 0.5625, 0.25, 0.45833333333333
58037, 0.58333333333333, 0.25, 0.4375
58038, 0.58333333333333, 0.275, 0.45833333333333
58039, 0.5625, 0.3, 0.45833333333333
58040, 0.58333333333333, 0.3, 0.4375
58041, 0.58333333333333, 0.325, 0.45833333333333
58042, 0.5625, 0.35, 0.45833333333333
58043, 0.58333333333333, 0.35, 0.4375
58044, 0.58333333333333, 0.375, 0.45833333333333
58045, 0.5625, 0.4, 0.45833333333333
58046, 0.58333333333333, 0.4, 0.4375
58047, 0.58333333333333, 0.425, 0.45833333333333
58048, 0.5625, 0.45, 0.45833333333333
58049, 0.58333333333333, 0.45, 0.4375
58050, 0.58333333333333, 0.475, 0.45833333333333
58051, 0.5625, 0.5, 0.45833333333333
58052, 0.58333333333333, 0.5, 0.4375
58053, 0.58333333333333, 0.525, 0.45833333333333
58054, 0.5625, 0.55, 0.45833333333333
58055, 0.58333333333333, 0.55, 0.4375
58056, 0.58333333333333, 0.575, 0.45833333333333
58057, 0.5625, 0.6, 0.45833333333333
58058, 0.58333333333333, 0.6, 0.4375
58059, 0.58333333333333, 0.625, 0.45833333333333
58060, 0.5625, 0.65, 0.45833333333333
58061, 0.58333333333333, 0.65, 0.4375
58062, 0.58333333333333, 0.675, 0.45833333333333
58063, 0.5625, 0.7, 0.45833333333333
58064, 0.58333333333333, 0.7, 0.4375
58065, 0.58333333333333, 0.725, 0.45833333333333
58066, 0.5625, 0.75, 0.45833333333333
58067, 0.58333333333333, 0.75, 0.4375
58068, 0.58333333333333, 0.775, 0.45833333333333
58069, 0.5625, 0.8, 0.45833333333333
58070, 0.58333333333333, 0.8, 0.4375
58071, 0.58333333333333, 0.825, 0.45833333333333
58072, 0.5625, 0.85, 0.45833333333333
58073, 0.58333333333333, 0.85, 0.4375
58074, 0.58333333333333, 0.875, 0.45833333333333
58075, 0.5625, 0.9, 0.45833333333333
58076, 0.58333333333333, 0.9, 0.4375
58077, 0.58333333333333, 0.925, 0.45833333333333
58078, 0.5625, 0.95, 0.45833333333333
58079, 0.58333333333333, 0.95, 0.4375
58080, 0.58333333333333, 0.975, 0.45833333333333
58081, 0.5625, 1, 0.45833333333333
58082, 0.58333333333333, 1, 0.4375
58083, 0.58333333333333, 1.025, 0.45833333333333
58084, 0.5625, 1.05, 0.45833333333333
58085, 0.58333333333333, 1.05, 0.4375
58086, 0.58333333333333, 1.075, 0.45833333333333
58087, 0.5625, 1.1, 0.45833333333333
58088, 0.58333333333333, 1.1, 0.4375
58089, 0.58333333333333, 1.125, 0.45833333333333
58090, 0.5625, 1.15, 0.45833333333333
58091, 0.58333333333333, 1.15, 0.4375
58092, 0.58333333333333, 1.175, 0.45833333333333
58093, 0.5625, 1.2, 0.45833333333333
58094, 0.58333333333333, 1.2, 0.4375
58095, 0.58333333333333, 1.225, 0.45833333333333
58096, 0.5625, 1.25, 0.45833333333333
58097, 0.58333333333333, 1.25, 0.4375
58098, 0.58333333333333, 1.275, 0.45833333333333
58099, 0.5625, 1.3, 0.45833333333333
58100, 0.58333333333333, 1.3, 0.4375
58101, 0.58333333333333, 1.325, 0.45833333333333
58102, 0.58333333333333, 0.2, 0.47916666666667
58103, 0.58333333333333, 0.25, 0.47916666666667
58104, 0.58333333333333, 0.3, 0.47916666666667
58105, 0.58333333333333, 0.35, 0.47916666666667
58106, 0.58333333333333, 0.4, 0.47916666666667
58107, 0.58333333333333, 0.45, 0.47916666666667
58108, 0.58333333333333, 0.5, 0.47916666666667
58109, 0.58333333333333, 0.55, 0.47916666666667
58110, 0.58333333333333, 0.6, 0.47916666666667
58111, 0.58333333333333, 0.65, 0.47916666666667
58112, 0.58333333333333, 0.7, 0.47916666666667
58113, 0.58333333333333, 0.75, 0.47916666666667
58114, 0.58333333333333, 0.8, 0.47916666666667
58115, 0.58333333333333, 0.85, 0.47916666666667
58116, 0.58333333333333, 0.9, 0.47916666666667
58117, 0.58333333333333, 0.95, 0.47916666666667
58118, 0.58333333333333, 1, 0.47916666666667
58119, 0.58333333333333, 1.05, 0.47916666666667
58120, 0.58333333333333, 1.1, 0.47916666666667
58121, 0.58333333333333, 1.15, 0.47916666666667
58122, 0.58333333333333, 1.2, 0.47916666666667
58123, 0.58333333333333, 1.25, 0.47916666666667
58124, 0.58333333333333, 1.3, 0.47916666666667
58125, 0.625, 0.175, 0.041666666666667
58126, 0.60416666666667, 0.2, 0.041666666666667
58127, 0.625, 0.2, 0.020833333333333
58128, 0.625, 0.225, 0.041666666666667
58129, 0.60416666666667, 0.25, 0.041666666666667
58130, 0.625, 0.25, 0.020833333333333
58131, 0.625, 0.275, 0.041666666666667
58132, 0.60416666666667, 0.3, 0.041666666666667
58133, 0.625, 0.3, 0.020833333333333
58134, 0.625, 0.325, 0.041666666666667
58135, 0.60416666666667, 0.35, 0.041666666666667
58136, 0.625, 0.35, 0.020833333333333
58137, 0.625, 0.375, 0.041666666666667
58138, 0.60416666666667, 0.4, 0.041666666666667
58139, 0.625, 0.4, 0.020833333333333
58140, 0.625, 0.425, 0.041666666666667
58141, 0.60416666666667, 0.45, 0.041666666666667
58142, 0.625, 0.45, 0.020833333333333
58143, 0.625, 0.475, 0.041666666666667
58144, 0.60416666666667, 0.5, 0.041666666666667
58145, 0.625, 0.5, 0.020833333333333
58146, 0.625, 0.525, 0.041666666666667
58147, 0.60416666666667, 0.55, 0.041666666666667
58148, 0.625, 0.55, 0.020833333333333
58149, 0.625, 0.575, 0.041666666666667
58150, 0.60416666666667, 0.6, 0.041666666666667
58151, 0.625, 0.6, 0.020833333333333
58152, 0.625, 0.625, 0.041666666666667
58153, 0.60416666666667, 0.65, 0.041666666666667
58154, 0.625, 0.65, 0.020833333333333
58155, 0.625, 0.675, 0.041666666666667
58156, 0.60416666666667, 0.7, 0.041666666666667
58157, 0.625, 0.7, 0.020833333333333
58158, 0.625, 0.725, 0.041666666666667
58159, 0.60416666666667, 0.75, 0.041666666666667
58160, 0.625, 0.75, 0.020833333333333
58161, 0.625, 0.775, 0.041666666666667
58162, 0.60416666666667, 0.8, 0.041666666666667
58163, 0.625, 0.8, 0.020833333333333
58164, 0.625, 0.825, 0.041666666666667
58165, 0.60416666666667, 0.85, 0.041666666666667
58166, 0.625, 0.85, 0.020833333333333
58167, 0.625, 0.875, 0.041666666666667
58168, 0.60416666666667, 0.9, 0.041666666666667
58169, 0.625, 0.9, 0.020833333333333
58170, 0.625, 0.925, 0.041666666666667
58171, 0.60416666666667, 0.95, 0.041666666666667
58172, 0.625, 0.95, 0.020833333333333
58173, 0.625, 0.975, 0.041666666666667
58174, 0.60416666666667, 1, 0.041666666666667
58175, 0.625, 1, 0.020833333333333
58176, 0.625, 1.025, 0.041666666666667
58177, 0.60416666666667, 1.05, 0.041666666666667
58178, 0.625, 1.05, 0.020833333333333
58179, 0.625, 1.075, 0.041666666666667
58180, 0.60416666666667, 1.1, 0.041666666666667
58181, 0.625, 1.1, 0.020833333333333
58182, 0.625, 1.125, 0.041666666666667
58183, 0.60416666666667, 1.15, 0.041666666666667
58184, 0.625, 1.15, 0.020833333333333
58185, 0.625, 1.175, 0.041666666666667
58186, 0.60416666666667, 1.2, 0.041666666666667
58187, 0.625, 1.2, 0.020833333333333
58188, 0.625, 1.225, 0.041666666666667
58189, 0.60416666666667, 1.25, 0.041666666666667
58190, 0.625, 1.25, 0.020833333333333
58191, 0.625, 1.275, 0.041666666666667
58192, 0.60416666666667, 1.3, 0.041666666666667
58193, 0.625, 1.3, 0.020833333333333
58194, 0.625, 1.325, 0.041666666666667
58195, 0.625, 0.175, 0.083333333333333
58196, 0.60416666666667, 0.2, 0.083333333333333
58197, 0.625, 0.2, 0.0625
58198, 0.625, 0.225, 0.083333333333333
58199, 0.60416666666667, 0.25, 0.083333333333333
58200, 0.625, 0.25, 0.0625
58201, 0.625, 0.275, 0.083333333333333
58202, 0.60416666666667, 0.3, 0.083333333333333
58203, 0.625, 0.3, 0.0625
58204, 0.625, 0.325, 0.083333333333333
58205, 0.60416666666667, 0.35, 0.083333333333333
58206, 0.625, 0.35, 0.0625
58207, 0.625, 0.375, 0.083333333333333
58208, 0.60416666666667, 0.4, 0.083333333333333
58209, 0.625, 0.4, 0.0625
58210, 0.625, 0.425, 0.083333333333333
58211, 0.60416666666667, 0.45, 0.083333333333333
58212, 0.625, 0.45, 0.0625
58213, 0.625, 0.475, 0.083333333333333
58214, 0.60416666666667, 0.5, 0.083333333333333
58215, 0.625, 0.5, 0.0625
58216, 0.625, 0.525, 0.083333333333333
58217, 0.60416666666667, 0.55, 0.083333333333333
58218, 0.625, 0.55, 0.0625
58219, 0.625, 0.575, 0.083333333333333
58220, 0.60416666666667, 0.6, 0.083333333333333
58221, 0.625, 0.6, 0.0625
58222, 0.625, 0.625, 0.083333333333333
58223, 0.60416666666667, 0.65, 0.083333333333333
58224, 0.625, 0.65, 0.0625
58225, 0.625, 0.675, 0.083333333333333
58226, 0.60416666666667, 0.7, 0.083333333333333
58227, 0.625, 0.7, 0.0625
58228, 0.625, 0.725, 0.083333333333333
58229, 0.60416666666667, 0.75, 0.083333333333333
58230, 0.625, 0.75, 0.0625
58231, 0.625, 0.775, 0.083333333333333
58232, 0.60416666666667, 0.8, 0.083333333333333
58233, 0.625, 0.8, 0.0625
58234, 0.625, 0.825, 0.083333333333333
58235, 0.60416666666667, 0.85, 0.083333333333333
58236, 0.625, 0.85, 0.0625
58237, 0.625, 0.875, 0.083333333333333
58238, 0.60416666666667, 0.9, 0.083333333333333
58239, 0.625, 0.9, 0.0625
58240, 0.625, 0.925, 0.083333333333333
58241, 0.60416666666667, 0.95, 0.083333333333333
58242, 0.625, 0.95, 0.0625
58243, 0.625, 0.975, 0.083333333333333
58244, 0.60416666666667, 1, 0.083333333333333
58245, 0.625, 1, 0.0625
58246, 0.625, 1.025, 0.083333333333333
58247, 0.60416666666667, 1.05, 0.083333333333333
58248, 0.625, 1.05, 0.0625
58249, 0.625, 1.075, 0.083333333333333
58250, 0.60416666666667, 1.1, 0.083333333333333
58251, 0.625, 1.1, 0.0625
58252, 0.625, 1.125, 0.083333333333333
58253, 0.60416666666667, 1.15, 0.083333333333333
58254, 0.625, 1.15, 0.0625
58255, 0.625, 1.175, 0.083333333333333
58256, 0.60416666666667, 1.2, 0.083333333333333
58257, 0.625, 1.2, 0.0625
58258, 0.625, 1.225, 0.083333333333333
58259, 0.60416666666667, 1.25, 0.083333333333333
58260, 0.625, 1.25, 0.0625
58261, 0.625, 1.275, 0.083333333333333
58262, 0.60416666666667, 1.3, 0.083333333333333
58263, 0.625, 1.3, 0.0625
58264, 0.625, 1.325, 0.083333333333333
58265, 0.625, 0.175, 0.125
58266, 0.60416666666667, 0.2, 0.125
58267, 0.625, 0.2, 0.10416666666667
58268, 0.625, 0.225, 0.125
58269, 0.60416666666667, 0.25, 0.125
58270, 0.625, 0.25, 0.10416666666667
58271, 0.625, 0.275, 0.125
58272, 0.60416666666667, 0.3, 0.125
58273, 0.625, 0.3, 0.10416666666667
58274, 0.625, 0.325, 0.125
58275, 0.60416666666667, 0.35, 0.125
58276, 0.625, 0.35, 0.10416666666667
58277, 0.625, 0.375, 0.125
58278, 0.60416666666667, 0.4, 0.125
58279, 0.625, 0.4, 0.10416666666667
58280, 0.625, 0.425, 0.125
58281, 0.60416666666667, 0.45, 0.125
58282, 0.625, 0.45, 0.10416666666667
58283, 0.625, 0.475, 0.125
58284, 0.60416666666667, 0.5, 0.125
58285, 0.625, 0.5, 0.10416666666667
58286, 0.625, 0.525, 0.125
58287, 0.60416666666667, 0.55, 0.125
58288, 0.625, 0.55, 0.10416666666667
58289, 0.625, 0.575, 0.125
58290, 0.60416666666667, 0.6, 0.125
58291, 0.625, 0.6, 0.10416666666667
58292, 0.625, 0.625, 0.125
58293, 0.60416666666667, 0.65, 0.125
58294, 0.625, 0.65, 0.10416666666667
58295, 0.625, 0.675, 0.125
58296, 0.60416666666667, 0.7, 0.125
58297, 0.625, 0.7, 0.10416666666667
58298, 0.625, 0.725, 0.125
58299, 0.60416666666667, 0.75, 0.125
58300, 0.625, 0.75, 0.10416666666667
58301, 0.625, 0.775, 0.125
58302, 0.60416666666667, 0.8, 0.125
58303, 0.625, 0.8, 0.10416666666667
58304, 0.625, 0.825, 0.125
58305, 0.60416666666667, 0.85, 0.125
58306, 0.625, 0.85, 0.10416666666667
58307, 0.625, 0.875, 0.125
58308, 0.60416666666667, 0.9, 0.125
58309, 0.625, 0.9, 0.10416666666667
58310, 0.625, 0.925, 0.125
58311, 0.60416666666667, 0.95, 0.125
58312, 0.625, 0.95, 0.10416666666667
58313, 0.625, 0.975, 0.125
58314, 0.60416666666667, 1, 0.125
58315, 0.625, 1, 0.10416666666667
58316, 0.625, 1.025, 0.125
58317, 0.60416666666667, 1.05, 0.125
58318, 0.625, 1.05, 0.10416666666667
58319, 0.625, 1.075, 0.125
58320, 0.60416666666667, 1.1, 0.125
58321, 0.625, 1.1, 0.10416666666667
58322, 0.625, 1.125, 0.125
58323, 0.60416666666667, 1.15, 0.125
58324, 0.625, 1.15, 0.10416666666667
58325, 0.625, 1.175, 0.125
58326, 0.60416666666667, 1.2, 0.125
58327, 0.625, 1.2, 0.10416666666667
58328, 0.625, 1.225, 0.125
58329, 0.60416666666667, 1.25, 0.125
58330, 0.625, 1.25, 0.10416666666667
58331, 0.625, 1.275, 0.125
58332, 0.60416666666667, 1.3, 0.125
58333, 0.625, 1.3, 0.10416666666667
58334, 0.625, 1.325, 0.125
58335, 0.625, 0.175, 0.16666666666667
58336, 0.60416666666667, 0.2, 0.16666666666667
58337, 0.625, 0.2, 0.14583333333333
58338, 0.625, 0.225, 0.16666666666667
58339, 0.60416666666667, 0.25, 0.16666666666667
58340, 0.625, 0.25, 0.14583333333333
58341, 0.625, 0.275, 0.16666666666667
58342, 0.60416666666667, 0.3, 0.16666666666667
58343, 0.625, 0.3, 0.14583333333333
58344, 0.625, 0.325, 0.16666666666667
58345, 0.60416666666667, 0.35, 0.16666666666667
58346, 0.625, 0.35, 0.14583333333333
58347, 0.625, 0.375, 0.16666666666667
58348, 0.60416666666667, 0.4, 0.16666666666667
58349, 0.625, 0.4, 0.14583333333333
58350, 0.625, 0.425, 0.16666666666667
58351, 0.60416666666667, 0.45, 0.16666666666667
58352, 0.625, 0.45, 0.14583333333333
58353, 0.625, 0.475, 0.16666666666667
58354, 0.60416666666667, 0.5, 0.16666666666667
58355, 0.625, 0.5, 0.14583333333333
58356, 0.625, 0.525, 0.16666666666667
58357, 0.60416666666667, 0.55, 0.16666666666667
58358, 0.625, 0.55, 0.14583333333333
58359, 0.625, 0.575, 0.16666666666667
58360, 0.60416666666667, 0.6, 0.16666666666667
58361, 0.625, 0.6, 0.14583333333333
58362, 0.625, 0.625, 0.16666666666667
58363, 0.60416666666667, 0.65, 0.16666666666667
58364, 0.625, 0.65, 0.14583333333333
58365, 0.625, 0.675, 0.16666666666667
58366, 0.60416666666667, 0.7, 0.16666666666667
58367, 0.625, 0.7, 0.14583333333333
58368, 0.625, 0.725, 0.16666666666667
58369, 0.60416666666667, 0.75, 0.16666666666667
58370, 0.625, 0.75, 0.14583333333333
58371, 0.625, 0.775, 0.16666666666667
58372, 0.60416666666667, 0.8, 0.16666666666667
58373, 0.625, 0.8, 0.14583333333333
58374, 0.625, 0.825, 0.16666666666667
58375, 0.60416666666667, 0.85, 0.16666666666667
58376, 0.625, 0.85, 0.14583333333333
58377, 0.625, 0.875, 0.16666666666667
58378, 0.60416666666667, 0.9, 0.16666666666667
58379, 0.625, 0.9, 0.14583333333333
58380, 0.625, 0.925, 0.16666666666667
58381, 0.60416666666667, 0.95, 0.16666666666667
58382, 0.625, 0.95, 0.14583333333333
58383, 0.625, 0.975, 0.16666666666667
58384, 0.60416666666667, 1, 0.16666666666667
58385, 0.625, 1, 0.14583333333333
58386, 0.625, 1.025, 0.16666666666667
58387, 0.60416666666667, 1.05, 0.16666666666667
58388, 0.625, 1.05, 0.14583333333333
58389, 0.625, 1.075, 0.16666666666667
58390, 0.60416666666667, 1.1, 0.16666666666667
58391, 0.625, 1.1, 0.14583333333333
58392, 0.625, 1.125, 0.16666666666667
58393, 0.60416666666667, 1.15, 0.16666666666667
58394, 0.625, 1.15, 0.14583333333333
58395, 0.625, 1.175, 0.16666666666667
58396, 0.60416666666667, 1.2, 0.16666666666667
58397, 0.625, 1.2, 0.14583333333333
58398, 0.625, 1.225, 0.16666666666667
58399, 0.60416666666667, 1.25, 0.16666666666667
58400, 0.625, 1.25, 0.14583333333333
58401, 0.625, 1.275, 0.16666666666667
58402, 0.60416666666667, 1.3, 0.16666666666667
58403, 0.625, 1.3, 0.14583333333333
58404, 0.625, 1.325, 0.16666666666667
58405, 0.625, 0.175, 0.20833333333333
58406, 0.60416666666667, 0.2, 0.20833333333333
58407, 0.625, 0.2, 0.1875
58408, 0.625, 0.225, 0.20833333333333
58409, 0.60416666666667, 0.25, 0.20833333333333
58410, 0.625, 0.25, 0.1875
58411, 0.625, 0.275, 0.20833333333333
58412, 0.60416666666667, 0.3, 0.20833333333333
58413, 0.625, 0.3, 0.1875
58414, 0.625, 0.325, 0.20833333333333
58415, 0.60416666666667, 0.35, 0.20833333333333
58416, 0.625, 0.35, 0.1875
58417, 0.625, 0.375, 0.20833333333333
58418, 0.60416666666667, 0.4, 0.20833333333333
58419, 0.625, 0.4, 0.1875
58420, 0.625, 0.425, 0.20833333333333
58421, 0.60416666666667, 0.45, 0.20833333333333
58422, 0.625, 0.45, 0.1875
58423, 0.625, 0.475, 0.20833333333333
58424, 0.60416666666667, 0.5, 0.20833333333333
58425, 0.625, 0.5, 0.1875
58426, 0.625, 0.525, 0.20833333333333
58427, 0.60416666666667, 0.55, 0.20833333333333
58428, 0.625, 0.55, 0.1875
58429, 0.625, 0.575, 0.20833333333333
58430, 0.60416666666667, 0.6, 0.20833333333333
58431, 0.625, 0.6, 0.1875
58432, 0.625, 0.625, 0.20833333333333
58433, 0.60416666666667, 0.65, 0.20833333333333
58434, 0.625, 0.65, 0.1875
58435, 0.625, 0.675, 0.20833333333333
58436, 0.60416666666667, 0.7, 0.20833333333333
58437, 0.625, 0.7, 0.1875
58438, 0.625, 0.725, 0.20833333333333
58439, 0.60416666666667, 0.75, 0.20833333333333
58440, 0.625, 0.75, 0.1875
58441, 0.625, 0.775, 0.20833333333333
58442, 0.60416666666667, 0.8, 0.20833333333333
58443, 0.625, 0.8, 0.1875
58444, 0.625, 0.825, 0.20833333333333
58445, 0.60416666666667, 0.85, 0.20833333333333
58446, 0.625, 0.85, 0.1875
58447, 0.625, 0.875, 0.20833333333333
58448, 0.60416666666667, 0.9, 0.20833333333333
58449, 0.625, 0.9, 0.1875
58450, 0.625, 0.925, 0.20833333333333
58451, 0.60416666666667, 0.95, 0.20833333333333
58452, 0.625, 0.95, 0.1875
58453, 0.625, 0.975, 0.20833333333333
58454, 0.60416666666667, 1, 0.20833333333333
58455, 0.625, 1, 0.1875
58456, 0.625, 1.025, 0.20833333333333
58457, 0.60416666666667, 1.05, 0.20833333333333
58458, 0.625, 1.05, 0.1875
58459, 0.625, 1.075, 0.20833333333333
58460, 0.60416666666667, 1.1, 0.20833333333333
58461, 0.625, 1.1, 0.1875
58462, 0.625, 1.125, 0.20833333333333
58463, 0.60416666666667, 1.15, 0.20833333333333
58464, 0.625, 1.15, 0.1875
58465, 0.625, 1.175, 0.20833333333333
58466, 0.60416666666667, 1.2, 0.20833333333333
58467, 0.625, 1.2, 0.1875
58468, 0.625, 1.225, 0.20833333333333
58469, 0.60416666666667, 1.25, 0.20833333333333
58470, 0.625, 1.25, 0.1875
58471, 0.625, 1.275, 0.20833333333333
58472, 0.60416666666667, 1.3, 0.20833333333333
58473, 0.625, 1.3, 0.1875
58474, 0.625, 1.325, 0.20833333333333
58475, 0.625, 0.175, 0.25
58476, 0.60416666666667, 0.2, 0.25
58477, 0.625, 0.2, 0.22916666666667
58478, 0.625, 0.225, 0.25
58479, 0.60416666666667, 0.25, 0.25
58480, 0.625, 0.25, 0.22916666666667
58481, 0.625, 0.275, 0.25
58482, 0.60416666666667, 0.3, 0.25
58483, 0.625, 0.3, 0.22916666666667
58484, 0.625, 0.325, 0.25
58485, 0.60416666666667, 0.35, 0.25
58486, 0.625, 0.35, 0.22916666666667
58487, 0.625, 0.375, 0.25
58488, 0.60416666666667, 0.4, 0.25
58489, 0.625, 0.4, 0.22916666666667
58490, 0.625, 0.425, 0.25
58491, 0.60416666666667, 0.45, 0.25
58492, 0.625, 0.45, 0.22916666666667
58493, 0.625, 0.475, 0.25
58494, 0.60416666666667, 0.5, 0.25
58495, 0.625, 0.5, 0.22916666666667
58496, 0.625, 0.525, 0.25
58497, 0.60416666666667, 0.55, 0.25
58498, 0.625, 0.55, 0.22916666666667
58499, 0.625, 0.575, 0.25
58500, 0.60416666666667, 0.6, 0.25
58501, 0.625, 0.6, 0.22916666666667
58502, 0.625, 0.625, 0.25
58503, 0.60416666666667, 0.65, 0.25
58504, 0.625, 0.65, 0.22916666666667
58505, 0.625, 0.675, 0.25
58506, 0.60416666666667, 0.7, 0.25
58507, 0.625, 0.7, 0.22916666666667
58508, 0.625, 0.725, 0.25
58509, 0.60416666666667, 0.75, 0.25
58510, 0.625, 0.75, 0.22916666666667
58511, 0.625, 0.775, 0.25
58512, 0.60416666666667, 0.8, 0.25
58513, 0.625, 0.8, 0.22916666666667
58514, 0.625, 0.825, 0.25
58515, 0.60416666666667, 0.85, 0.25
58516, 0.625, 0.85, 0.22916666666667
58517, 0.625, 0.875, 0.25
58518, 0.60416666666667, 0.9, 0.25
58519, 0.625, 0.9, 0.22916666666667
58520, 0.625, 0.925, 0.25
58521, 0.60416666666667, 0.95, 0.25
58522, 0.625, 0.95, 0.22916666666667
58523, 0.625, 0.975, 0.25
58524, 0.60416666666667, 1, 0.25
58525, 0.625, 1, 0.22916666666667
58526, 0.625, 1.025, 0.25
58527, 0.60416666666667, 1.05, 0.25
58528, 0.625, 1.05, 0.22916666666667
58529, 0.625, 1.075, 0.25
58530, 0.60416666666667, 1.1, 0.25
58531, 0.625, 1.1, 0.22916666666667
58532, 0.625, 1.125, 0.25
58533, 0.60416666666667, 1.15, 0.25
58534, 0.625, 1.15, 0.22916666666667
58535, 0.625, 1.175, 0.25
58536, 0.60416666666667, 1.2, 0.25
58537, 0.625, 1.2, 0.22916666666667
58538, 0.625, 1.225, 0.25
58539, 0.60416666666667, 1.25, 0.25
58540, 0.625, 1.25, 0.22916666666667
58541, 0.625, 1.275, 0.25
58542, 0.60416666666667, 1.3, 0.25
58543, 0.625, 1.3, 0.22916666666667
58544, 0.625, 1.325, 0.25
58545, 0.625, 0.175, 0.29166666666667
58546, 0.60416666666667, 0.2, 0.29166666666667
58547, 0.625, 0.2, 0.27083333333333
58548, 0.625, 0.225, 0.29166666666667
58549, 0.60416666666667, 0.25, 0.29166666666667
58550, 0.625, 0.25, 0.27083333333333
58551, 0.625, 0.275, 0.29166666666667
58552, 0.60416666666667, 0.3, 0.29166666666667
58553, 0.625, 0.3, 0.27083333333333
58554, 0.625, 0.325, 0.29166666666667
58555, 0.60416666666667, 0.35, 0.29166666666667
58556, 0.625, 0.35, 0.27083333333333
58557, 0.625, 0.375, 0.29166666666667
58558, 0.60416666666667, 0.4, 0.29166666666667
58559, 0.625, 0.4, 0.27083333333333
58560, 0.625, 0.425, 0.29166666666667
58561, 0.60416666666667, 0.45, 0.29166666666667
58562, 0.625, 0.45, 0.27083333333333
58563, 0.625, 0.475, 0.29166666666667
58564, 0.60416666666667, 0.5, 0.29166666666667
58565, 0.625, 0.5, 0.27083333333333
58566, 0.625, 0.525, 0.29166666666667
58567, 0.60416666666667, 0.55, 0.29166666666667
58568, 0.625, 0.55, 0.27083333333333
58569, 0.625, 0.575, 0.29166666666667
58570, 0.60416666666667, 0.6, 0.29166666666667
58571, 0.625, 0.6, 0.27083333333333
58572, 0.625, 0.625, 0.29166666666667
58573, 0.60416666666667, 0.65, 0.29166666666667
58574, 0.625, 0.65, 0.27083333333333
58575, 0.625, 0.675, 0.29166666666667
58576, 0.60416666666667, 0.7, 0.29166666666667
58577, 0.625, 0.7, 0.27083333333333
58578, 0.625, 0.725, 0.29166666666667
58579, 0.60416666666667, 0.75, 0.29166666666667
58580, 0.625, 0.75, 0.27083333333333
58581, 0.625, 0.775, 0.29166666666667
58582, 0.60416666666667, 0.8, 0.29166666666667
58583, 0.625, 0.8, 0.27083333333333
58584, 0.625, 0.825, 0.29166666666667
58585, 0.60416666666667, 0.85, 0.29166666666667
58586, 0.625, 0.85, 0.27083333333333
58587, 0.625, 0.875, 0.29166666666667
58588, 0.60416666666667, 0.9, 0.29166666666667
58589, 0.625, 0.9, 0.27083333333333
58590, 0.625, 0.925, 0.29166666666667
58591, 0.60416666666667, 0.95, 0.29166666666667
58592, 0.625, 0.95, 0.27083333333333
58593, 0.625, 0.975, 0.29166666666667
58594, 0.60416666666667, 1, 0.29166666666667
58595, 0.625, 1, 0.27083333333333
58596, 0.625, 1.025, 0.29166666666667
58597, 0.60416666666667, 1.05, 0.29166666666667
58598, 0.625, 1.05, 0.27083333333333
58599, 0.625, 1.075, 0.29166666666667
58600, 0.60416666666667, 1.1, 0.29166666666667
58601, 0.625, 1.1, 0.27083333333333
58602, 0.625, 1.125, 0.29166666666667
58603, 0.60416666666667, 1.15, 0.29166666666667
58604, 0.625, 1.15, 0.27083333333333
58605, 0.625, 1.175, 0.29166666666667
58606, 0.60416666666667, 1.2, 0.29166666666667
58607, 0.625, 1.2, 0.27083333333333
58608, 0.625, 1.225, 0.29166666666667
58609, 0.60416666666667, 1.25, 0.29166666666667
58610, 0.625, 1.25, 0.27083333333333
58611, 0.625, 1.275, 0.29166666666667
58612, 0.60416666666667, 1.3, 0.29166666666667
58613, 0.625, 1.3, 0.27083333333333
58614, 0.625, 1.325, 0.29166666666667
58615, 0.625, 0.175, 0.33333333333333
58616, 0.60416666666667, 0.2, 0.33333333333333
58617, 0.625, 0.2, 0.3125
58618, 0.625, 0.225, 0.33333333333333
58619, 0.60416666666667, 0.25, 0.33333333333333
58620, 0.625, 0.25, 0.3125
58621, 0.625, 0.275, 0.33333333333333
58622, 0.60416666666667, 0.3, 0.33333333333333
58623, 0.625, 0.3, 0.3125
58624, 0.625, 0.325, 0.33333333333333
58625, 0.60416666666667, 0.35, 0.33333333333333
58626, 0.625, 0.35, 0.3125
58627, 0.625, 0.375, 0.33333333333333
58628, 0.60416666666667, 0.4, 0.33333333333333
58629, 0.625, 0.4, 0.3125
58630, 0.625, 0.425, 0.33333333333333
58631, 0.60416666666667, 0.45, 0.33333333333333
58632, 0.625, 0.45, 0.3125
58633, 0.625, 0.475, 0.33333333333333
58634, 0.60416666666667, 0.5, 0.33333333333333
58635, 0.625, 0.5, 0.3125
58636, 0.625, 0.525, 0.33333333333333
58637, 0.60416666666667, 0.55, 0.33333333333333
58638, 0.625, 0.55, 0.3125
58639, 0.625, 0.575, 0.33333333333333
58640, 0.60416666666667, 0.6, 0.33333333333333
58641, 0.625, 0.6, 0.3125
58642, 0.625, 0.625, 0.33333333333333
58643, 0.60416666666667, 0.65, 0.33333333333333
58644, 0.625, 0.65, 0.3125
58645, 0.625, 0.675, 0.33333333333333
58646, 0.60416666666667, 0.7, 0.33333333333333
58647, 0.625, 0.7, 0.3125
58648, 0.625, 0.725, 0.33333333333333
58649, 0.60416666666667, 0.75, 0.33333333333333
58650, 0.625, 0.75, 0.3125
58651, 0.625, 0.775, 0.33333333333333
58652, 0.60416666666667, 0.8, 0.33333333333333
58653, 0.625, 0.8, 0.3125
58654, 0.625, 0.825, 0.33333333333333
58655, 0.60416666666667, 0.85, 0.33333333333333
58656, 0.625, 0.85, 0.3125
58657, 0.625, 0.875, 0.33333333333333
58658, 0.60416666666667, 0.9, 0.33333333333333
58659, 0.625, 0.9, 0.3125
58660, 0.625, 0.925, 0.33333333333333
58661, 0.60416666666667, 0.95, 0.33333333333333
58662, 0.625, 0.95, 0.3125
58663, 0.625, 0.975, 0.33333333333333
58664, 0.60416666666667, 1, 0.33333333333333
58665, 0.625, 1, 0.3125
58666, 0.625, 1.025, 0.33333333333333
58667, 0.60416666666667, 1.05, 0.33333333333333
58668, 0.625, 1.05, 0.3125
58669, 0.625, 1.075, 0.33333333333333
58670, 0.60416666666667, 1.1, 0.33333333333333
58671, 0.625, 1.1, 0.3125
58672, 0.625, 1.125, 0.33333333333333
58673, 0.60416666666667, 1.15, 0.33333333333333
58674, 0.625, 1.15, 0.3125
58675, 0.625, 1.175, 0.33333333333333
58676, 0.60416666666667, 1.2, 0.33333333333333
58677, 0.625, 1.2, 0.3125
58678, 0.625, 1.225, 0.33333333333333
58679, 0.60416666666667, 1.25, 0.33333333333333
58680, 0.625, 1.25, 0.3125
58681, 0.625, 1.275, 0.33333333333333
58682, 0.60416666666667, 1.3, 0.33333333333333
58683, 0.625, 1.3, 0.3125
58684, 0.625, 1.325, 0.33333333333333
58685, 0.625, 0.175, 0.375
58686, 0.60416666666667, 0.2, 0.375
58687, 0.625, 0.2, 0.35416666666667
58688, 0.625, 0.225, 0.375
58689, 0.60416666666667, 0.25, 0.375
58690, 0.625, 0.25, 0.35416666666667
58691, 0.625, 0.275, 0.375
58692, 0.60416666666667, 0.3, 0.375
58693, 0.625, 0.3, 0.35416666666667
58694, 0.625, 0.325, 0.375
58695, 0.60416666666667, 0.35, 0.375
58696, 0.625, 0.35, 0.35416666666667
58697, 0.625, 0.375, 0.375
58698, 0.60416666666667, 0.4, 0.375
58699, 0.625, 0.4, 0.35416666666667
58700, 0.625, 0.425, 0.375
58701, 0.60416666666667, 0.45, 0.375
58702, 0.625, 0.45, 0.35416666666667
58703, 0.625, 0.475, 0.375
58704, 0.60416666666667, 0.5, 0.375
58705, 0.625, 0.5, 0.35416666666667
58706, 0.625, 0.525, 0.375
58707, 0.60416666666667, 0.55, 0.375
58708, 0.625, 0.55, 0.35416666666667
58709, 0.625, 0.575, 0.375
58710, 0.60416666666667, 0.6, 0.375
58711, 0.625, 0.6, 0.35416666666667
58712, 0.625, 0.625, 0.375
58713, 0.60416666666667, 0.65, 0.375
58714, 0.625, 0.65, 0.35416666666667
58715, 0.625, 0.675, 0.375
58716, 0.60416666666667, 0.7, 0.375
58717, 0.625, 0.7, 0.35416666666667
58718, 0.625, 0.725, 0.375
58719, 0.60416666666667, 0.75, 0.375
58720, 0.625, 0.75, 0.35416666666667
58721, 0.625, 0.775, 0.375
58722, 0.60416666666667, 0.8, 0.375
58723, 0.625, 0.8, 0.35416666666667
58724, 0.625, 0.825, 0.375
58725, 0.60416666666667, 0.85, 0.375
58726, 0.625, 0.85, 0.35416666666667
58727, 0.625, 0.875, 0.375
58728, 0.60416666666667, 0.9, 0.375
58729, 0.625, 0.9, 0.35416666666667
58730, 0.625, 0.925, 0.375
58731, 0.60416666666667, 0.95, 0.375
58732, 0.625, 0.95, 0.35416666666667
58733, 0.625, 0.975, 0.375
58734, 0.60416666666667, 1, 0.375
58735, 0.625, 1, 0.35416666666667
58736, 0.625, 1.025, 0.375
58737, 0.60416666666667, 1.05, 0.375
58738, 0.625, 1.05, 0.35416666666667
58739, 0.625, 1.075, 0.375
58740, 0.60416666666667, 1.1, 0.375
58741, 0.625, 1.1, 0.35416666666667
58742, 0.625, 1.125, 0.375
58743, 0.60416666666667, 1.15, 0.375
58744, 0.625, 1.15, 0.35416666666667
58745, 0.625, 1.175, 0.375
58746, 0.60416666666667, 1.2, 0.375
58747, 0.625, 1.2, 0.35416666666667
58748, 0.625, 1.225, 0.375
58749, 0.60416666666667, 1.25, 0.375
58750, 0.625, 1.25, 0.35416666666667
58751, 0.625, 1.275, 0.375
58752, 0.60416666666667, 1.3, 0.375
58753, 0.625, 1.3, 0.35416666666667
58754, 0.625, 1.325, 0.375
58755, 0.625, 0.175, 0.41666666666667
58756, 0.60416666666667, 0.2, 0.41666666666667
58757, 0.625, 0.2, 0.39583333333333
58758, 0.625, 0.225, 0.41666666666667
58759, 0.60416666666667, 0.25, 0.41666666666667
58760, 0.625, 0.25, 0.39583333333333
58761, 0.625, 0.275, 0.41666666666667
58762, 0.60416666666667, 0.3, 0.41666666666667
58763, 0.625, 0.3, 0.39583333333333
58764, 0.625, 0.325, 0.41666666666667
58765, 0.60416666666667, 0.35, 0.41666666666667
58766, 0.625, 0.35, 0.39583333333333
58767, 0.625, 0.375, 0.41666666666667
58768, 0.60416666666667, 0.4, 0.41666666666667
58769, 0.625, 0.4, 0.39583333333333
58770, 0.625, 0.425, 0.41666666666667
58771, 0.60416666666667, 0.45, 0.41666666666667
58772, 0.625, 0.45, 0.39583333333333
58773, 0.625, 0.475, 0.41666666666667
58774, 0.60416666666667, 0.5, 0.41666666666667
58775, 0.625, 0.5, 0.39583333333333
58776, 0.625, 0.525, 0.41666666666667
58777, 0.60416666666667, 0.55, 0.41666666666667
58778, 0.625, 0.55, 0.39583333333333
58779, 0.625, 0.575, 0.41666666666667
58780, 0.60416666666667, 0.6, 0.41666666666667
58781, 0.625, 0.6, 0.39583333333333
58782, 0.625, 0.625, 0.41666666666667
58783, 0.60416666666667, 0.65, 0.41666666666667
58784, 0.625, 0.65, 0.39583333333333
58785, 0.625, 0.675, 0.41666666666667
58786, 0.60416666666667, 0.7, 0.41666666666667
58787, 0.625, 0.7, 0.39583333333333
58788, 0.625, 0.725, 0.41666666666667
58789, 0.60416666666667, 0.75, 0.41666666666667
58790, 0.625, 0.75, 0.39583333333333
58791, 0.625, 0.775, 0.41666666666667
58792, 0.60416666666667, 0.8, 0.41666666666667
58793, 0.625, 0.8, 0.39583333333333
58794, 0.625, 0.825, 0.41666666666667
58795, 0.60416666666667, 0.85, 0.41666666666667
58796, 0.625, 0.85, 0.39583333333333
58797, 0.625, 0.875, 0.41666666666667
58798, 0.60416666666667, 0.9, 0.41666666666667
58799, 0.625, 0.9, 0.39583333333333
58800, 0.625, 0.925, 0.41666666666667
58801, 0.60416666666667, 0.95, 0.41666666666667
58802, 0.625, 0.95, 0.39583333333333
58803, 0.625, 0.975, 0.41666666666667
58804, 0.60416666666667, 1, 0.41666666666667
58805, 0.625, 1, 0.39583333333333
58806, 0.625, 1.025, 0.41666666666667
58807, 0.60416666666667, 1.05, 0.41666666666667
58808, 0.625, 1.05, 0.39583333333333
58809, 0.625, 1.075, 0.41666666666667
58810, 0.60416666666667, 1.1, 0.41666666666667
58811, 0.625, 1.1, 0.39583333333333
58812, 0.625, 1.125, 0.41666666666667
58813, 0.60416666666667, 1.15, 0.41666666666667
58814, 0.625, 1.15, 0.39583333333333
58815, 0.625, 1.175, 0.41666666666667
58816, 0.60416666666667, 1.2, 0.41666666666667
58817, 0.625, 1.2, 0.39583333333333
58818, 0.625, 1.225, 0.41666666666667
58819, 0.60416666666667, 1.25, 0.41666666666667
58820, 0.625, 1.25, 0.39583333333333
58821, 0.625, 1.275, 0.41666666666667
58822, 0.60416666666667, 1.3, 0.41666666666667
58823, 0.625, 1.3, 0.39583333333333
58824, 0.625, 1.325, 0.41666666666667
58825, 0.625, 0.175, 0.45833333333333
58826, 0.60416666666667, 0.2, 0.45833333333333
58827, 0.625, 0.2, 0.4375
58828, 0.625, 0.225, 0.45833333333333
58829, 0.60416666666667, 0.25, 0.45833333333333
58830, 0.625, 0.25, 0.4375
58831, 0.625, 0.275, 0.45833333333333
58832, 0.60416666666667, 0.3, 0.45833333333333
58833, 0.625, 0.3, 0.4375
58834, 0.625, 0.325, 0.45833333333333
58835, 0.60416666666667, 0.35, 0.45833333333333
58836, 0.625, 0.35, 0.4375
58837, 0.625, 0.375, 0.45833333333333
58838, 0.60416666666667, 0.4, 0.45833333333333
58839, 0.625, 0.4, 0.4375
58840, 0.625, 0.425, 0.45833333333333
58841, 0.60416666666667, 0.45, 0.45833333333333
58842, 0.625, 0.45, 0.4375
58843, 0.625, 0.475, 0.45833333333333
58844, 0.60416666666667, 0.5, 0.45833333333333
58845, 0.625, 0.5, 0.4375
58846, 0.625, 0.525, 0.45833333333333
58847, 0.60416666666667, 0.55, 0.45833333333333
58848, 0.625, 0.55, 0.4375
58849, 0.625, 0.575, 0.45833333333333
58850, 0.60416666666667, 0.6, 0.45833333333333
58851, 0.625, 0.6, 0.4375
58852, 0.625, 0.625, 0.45833333333333
58853, 0.60416666666667, 0.65, 0.45833333333333
58854, 0.625, 0.65, 0.4375
58855, 0.625, 0.675, 0.45833333333333
58856, 0.60416666666667, 0.7, 0.45833333333333
58857, 0.625, 0.7, 0.4375
58858, 0.625, 0.725, 0.45833333333333
58859, 0.60416666666667, 0.75, 0.45833333333333
58860, 0.625, 0.75, 0.4375
58861, 0.625, 0.775, 0.45833333333333
58862, 0.60416666666667, 0.8, 0.45833333333333
58863, 0.625, 0.8, 0.4375
58864, 0.625, 0.825, 0.45833333333333
58865, 0.60416666666667, 0.85, 0.45833333333333
58866, 0.625, 0.85, 0.4375
58867, 0.625, 0.875, 0.45833333333333
58868, 0.60416666666667, 0.9, 0.45833333333333
58869, 0.625, 0.9, 0.4375
58870, 0.625, 0.925, 0.45833333333333
58871, 0.60416666666667, 0.95, 0.45833333333333
58872, 0.625, 0.95, 0.4375
58873, 0.625, 0.975, 0.45833333333333
58874, 0.60416666666667, 1, 0.45833333333333
58875, 0.625, 1, 0.4375
58876, 0.625, 1.025, 0.45833333333333
58877, 0.60416666666667, 1.05, 0.45833333333333
58878, 0.625, 1.05, 0.4375
58879, 0.625, 1.075, 0.45833333333333
58880, 0.60416666666667, 1.1, 0.45833333333333
58881, 0.625, 1.1, 0.4375
58882, 0.625, 1.125, 0.45833333333333
58883, 0.60416666666667, 1.15, 0.45833333333333
58884, 0.625, 1.15, 0.4375
58885, 0.625, 1.175, 0.45833333333333
58886, 0.60416666666667, 1.2, 0.45833333333333
58887, 0.625, 1.2, 0.4375
58888, 0.625, 1.225, 0.45833333333333
58889, 0.60416666666667, 1.25, 0.45833333333333
58890, 0.625, 1.25, 0.4375
58891, 0.625, 1.275, 0.45833333333333
58892, 0.60416666666667, 1.3, 0.45833333333333
58893, 0.625, 1.3, 0.4375
58894, 0.625, 1.325, 0.45833333333333
58895, 0.625, 0.2, 0.47916666666667
58896, 0.625, 0.25, 0.47916666666667
58897, 0.625, 0.3, 0.47916666666667
58898, 0.625, 0.35, 0.47916666666667
58899, 0.625, 0.4, 0.47916666666667
58900, 0.625, 0.45, 0.47916666666667
58901, 0.625, 0.5, 0.47916666666667
58902, 0.625, 0.55, 0.47916666666667
58903, 0.625, 0.6, 0.47916666666667
58904, 0.625, 0.65, 0.47916666666667
58905, 0.625, 0.7, 0.47916666666667
58906, 0.625, 0.75, 0.47916666666667
58907, 0.625, 0.8, 0.47916666666667
58908, 0.625, 0.85, 0.47916666666667
58909, 0.625, 0.9, 0.47916666666667
58910, 0.625, 0.95, 0.47916666666667
58911, 0.625, 1, 0.47916666666667
58912, 0.625, 1.05, 0.47916666666667
58913, 0.625, 1.1, 0.47916666666667
58914, 0.625, 1.15, 0.47916666666667
58915, 0.625, 1.2, 0.47916666666667
58916, 0.625, 1.25, 0.47916666666667
58917, 0.625, 1.3, 0.47916666666667
58918, 0.66666666666667, 0.175, 0.041666666666667
58919, 0.64583333333333, 0.2, 0.041666666666667
58920, 0.66666666666667, 0.2, 0.020833333333333
58921, 0.66666666666667, 0.225, 0.041666666666667
58922, 0.64583333333333, 0.25, 0.041666666666667
58923, 0.66666666666667, 0.25, 0.020833333333333
58924, 0.66666666666667, 0.275, 0.041666666666667
58925, 0.64583333333333, 0.3, 0.041666666666667
58926, 0.66666666666667, 0.3, 0.020833333333333
58927, 0.66666666666667, 0.325, 0.041666666666667
58928, 0.64583333333333, 0.35, 0.041666666666667
58929, 0.66666666666667, 0.35, 0.020833333333333
58930, 0.66666666666667, 0.375, 0.041666666666667
58931, 0.64583333333333, 0.4, 0.041666666666667
58932, 0.66666666666667, 0.4, 0.020833333333333
58933, 0.66666666666667, 0.425, 0.041666666666667
58934, 0.64583333333333, 0.45, 0.041666666666667
58935, 0.66666666666667, 0.45, 0.020833333333333
58936, 0.66666666666667, 0.475, 0.041666666666667
58937, 0.64583333333333, 0.5, 0.041666666666667
58938, 0.66666666666667, 0.5, 0.020833333333333
58939, 0.66666666666667, 0.525, 0.041666666666667
58940, 0.64583333333333, 0.55, 0.041666666666667
58941, 0.66666666666667, 0.55, 0.020833333333333
58942, 0.66666666666667, 0.575, 0.041666666666667
58943, 0.64583333333333, 0.6, 0.041666666666667
58944, 0.66666666666667, 0.6, 0.020833333333333
58945, 0.66666666666667, 0.625, 0.041666666666667
58946, 0.64583333333333, 0.65, 0.041666666666667
58947, 0.66666666666667, 0.65, 0.020833333333333
58948, 0.66666666666667, 0.675, 0.041666666666667
58949, 0.64583333333333, 0.7, 0.041666666666667
58950, 0.66666666666667, 0.7, 0.020833333333333
58951, 0.66666666666667, 0.725, 0.041666666666667
58952, 0.64583333333333, 0.75, 0.041666666666667
58953, 0.66666666666667, 0.75, 0.020833333333333
58954, 0.66666666666667, 0.775, 0.041666666666667
58955, 0.64583333333333, 0.8, 0.041666666666667
58956, 0.66666666666667, 0.8, 0.020833333333333
58957, 0.66666666666667, 0.825, 0.041666666666667
58958, 0.64583333333333, 0.85, 0.041666666666667
58959, 0.66666666666667, 0.85, 0.020833333333333
58960, 0.66666666666667, 0.875, 0.041666666666667
58961, 0.64583333333333, 0.9, 0.041666666666667
58962, 0.66666666666667, 0.9, 0.020833333333333
58963, 0.66666666666667, 0.925, 0.041666666666667
58964, 0.64583333333333, 0.95, 0.041666666666667
58965, 0.66666666666667, 0.95, 0.020833333333333
58966, 0.66666666666667, 0.975, 0.041666666666667
58967, 0.64583333333333, 1, 0.041666666666667
58968, 0.66666666666667, 1, 0.020833333333333
58969, 0.66666666666667, 1.025, 0.041666666666667
58970, 0.64583333333333, 1.05, 0.041666666666667
58971, 0.66666666666667, 1.05, 0.020833333333333
58972, 0.66666666666667, 1.075, 0.041666666666667
58973, 0.64583333333333, 1.1, 0.041666666666667
58974, 0.66666666666667, 1.1, 0.020833333333333
58975, 0.66666666666667, 1.125, 0.041666666666667
58976, 0.64583333333333, 1.15, 0.041666666666667
58977, 0.66666666666667, 1.15, 0.020833333333333
58978, 0.66666666666667, 1.175, 0.041666666666667
58979, 0.64583333333333, 1.2, 0.041666666666667
58980, 0.66666666666667, 1.2, 0.020833333333333
58981, 0.66666666666667, 1.225, 0.041666666666667
58982, 0.64583333333333, 1.25, 0.041666666666667
58983, 0.66666666666667, 1.25, 0.020833333333333
58984, 0.66666666666667, 1.275, 0.041666666666667
58985, 0.64583333333333, 1.3, 0.041666666666667
58986, 0.66666666666667, 1.3, 0.020833333333333
58987, 0.66666666666667, 1.325, 0.041666666666667
58988, 0.66666666666667, 0.175, 0.083333333333333
58989, 0.64583333333333, 0.2, 0.083333333333333
58990, 0.66666666666667, 0.2, 0.0625
58991, 0.66666666666667, 0.225, 0.083333333333333
58992, 0.64583333333333, 0.25, 0.083333333333333
58993, 0.66666666666667, 0.25, 0.0625
58994, 0.66666666666667, 0.275, 0.083333333333333
58995, 0.64583333333333, 0.3, 0.083333333333333
58996, 0.66666666666667, 0.3, 0.0625
58997, 0.66666666666667, 0.325, 0.083333333333333
58998, 0.64583333333333, 0.35, 0.083333333333333
58999, 0.66666666666667, 0.35, 0.0625
59000, 0.66666666666667, 0.375, 0.083333333333333
59001, 0.64583333333333, 0.4, 0.083333333333333
59002, 0.66666666666667, 0.4, 0.0625
59003, 0.66666666666667, 0.425, 0.083333333333333
59004, 0.64583333333333, 0.45, 0.083333333333333
59005, 0.66666666666667, 0.45, 0.0625
59006, 0.66666666666667, 0.475, 0.083333333333333
59007, 0.64583333333333, 0.5, 0.083333333333333
59008, 0.66666666666667, 0.5, 0.0625
59009, 0.66666666666667, 0.525, 0.083333333333333
59010, 0.64583333333333, 0.55, 0.083333333333333
59011, 0.66666666666667, 0.55, 0.0625
59012, 0.66666666666667, 0.575, 0.083333333333333
59013, 0.64583333333333, 0.6, 0.083333333333333
59014, 0.66666666666667, 0.6, 0.0625
59015, 0.66666666666667, 0.625, 0.083333333333333
59016, 0.64583333333333, 0.65, 0.083333333333333
59017, 0.66666666666667, 0.65, 0.0625
59018, 0.66666666666667, 0.675, 0.083333333333333
59019, 0.64583333333333, 0.7, 0.083333333333333
59020, 0.66666666666667, 0.7, 0.0625
59021, 0.66666666666667, 0.725, 0.083333333333333
59022, 0.64583333333333, 0.75, 0.083333333333333
59023, 0.66666666666667, 0.75, 0.0625
59024, 0.66666666666667, 0.775, 0.083333333333333
59025, 0.64583333333333, 0.8, 0.083333333333333
59026, 0.66666666666667, 0.8, 0.0625
59027, 0.66666666666667, 0.825, 0.083333333333333
59028, 0.64583333333333, 0.85, 0.083333333333333
59029, 0.66666666666667, 0.85, 0.0625
59030, 0.66666666666667, 0.875, 0.083333333333333
59031, 0.64583333333333, 0.9, 0.083333333333333
59032, 0.66666666666667, 0.9, 0.0625
59033, 0.66666666666667, 0.925, 0.083333333333333
59034, 0.64583333333333, 0.95, 0.083333333333333
59035, 0.66666666666667, 0.95, 0.0625
59036, 0.66666666666667, 0.975, 0.083333333333333
59037, 0.64583333333333, 1, 0.083333333333333
59038, 0.66666666666667, 1, 0.0625
59039, 0.66666666666667, 1.025, 0.083333333333333
59040, 0.64583333333333, 1.05, 0.083333333333333
59041, 0.66666666666667, 1.05, 0.0625
59042, 0.66666666666667, 1.075, 0.083333333333333
59043, 0.64583333333333, 1.1, 0.083333333333333
59044, 0.66666666666667, 1.1, 0.0625
59045, 0.66666666666667, 1.125, 0.083333333333333
59046, 0.64583333333333, 1.15, 0.083333333333333
59047, 0.66666666666667, 1.15, 0.0625
59048, 0.66666666666667, 1.175, 0.083333333333333
59049, 0.64583333333333, 1.2, 0.083333333333333
59050, 0.66666666666667, 1.2, 0.0625
59051, 0.66666666666667, 1.225, 0.083333333333333
59052, 0.64583333333333, 1.25, 0.083333333333333
59053, 0.66666666666667, 1.25, 0.0625
59054, 0.66666666666667, 1.275, 0.083333333333333
59055, 0.64583333333333, 1.3, 0.083333333333333
59056, 0.66666666666667, 1.3, 0.0625
59057, 0.66666666666667, 1.325, 0.083333333333333
59058, 0.66666666666667, 0.175, 0.125
59059, 0.64583333333333, 0.2, 0.125
59060, 0.66666666666667, 0.2, 0.10416666666667
59061, 0.66666666666667, 0.225, 0.125
59062, 0.64583333333333, 0.25, 0.125
59063, 0.66666666666667, 0.25, 0.10416666666667
59064, 0.66666666666667, 0.275, 0.125
59065, 0.64583333333333, 0.3, 0.125
59066, 0.66666666666667, 0.3, 0.10416666666667
59067, 0.66666666666667, 0.325, 0.125
59068, 0.64583333333333, 0.35, 0.125
59069, 0.66666666666667, 0.35, 0.10416666666667
59070, 0.66666666666667, 0.375, 0.125
59071, 0.64583333333333, 0.4, 0.125
59072, 0.66666666666667, 0.4, 0.10416666666667
59073, 0.66666666666667, 0.425, 0.125
59074, 0.64583333333333, 0.45, 0.125
59075, 0.66666666666667, 0.45, 0.10416666666667
59076, 0.66666666666667, 0.475, 0.125
59077, 0.64583333333333, 0.5, 0.125
59078, 0.66666666666667, 0.5, 0.10416666666667
59079, 0.66666666666667, 0.525, 0.125
59080, 0.64583333333333, 0.55, 0.125
59081, 0.66666666666667, 0.55, 0.10416666666667
59082, 0.66666666666667, 0.575, 0.125
59083, 0.64583333333333, 0.6, 0.125
59084, 0.66666666666667, 0.6, 0.10416666666667
59085, 0.66666666666667, 0.625, 0.125
59086, 0.64583333333333, 0.65, 0.125
59087, 0.66666666666667, 0.65, 0.10416666666667
59088, 0.66666666666667, 0.675, 0.125
59089, 0.64583333333333, 0.7, 0.125
59090, 0.66666666666667, 0.7, 0.10416666666667
59091, 0.66666666666667, 0.725, 0.125
59092, 0.64583333333333, 0.75, 0.125
59093, 0.66666666666667, 0.75, 0.10416666666667
59094, 0.66666666666667, 0.775, 0.125
59095, 0.64583333333333, 0.8, 0.125
59096, 0.66666666666667, 0.8, 0.10416666666667
59097, 0.66666666666667, 0.825, 0.125
59098, 0.64583333333333, 0.85, 0.125
59099, 0.66666666666667, 0.85, 0.10416666666667
59100, 0.66666666666667, 0.875, 0.125
59101, 0.64583333333333, 0.9, 0.125
59102, 0.66666666666667, 0.9, 0.10416666666667
59103, 0.66666666666667, 0.925, 0.125
59104, 0.64583333333333, 0.95, 0.125
59105, 0.66666666666667, 0.95, 0.10416666666667
59106, 0.66666666666667, 0.975, 0.125
59107, 0.64583333333333, 1, 0.125
59108, 0.66666666666667, 1, 0.10416666666667
59109, 0.66666666666667, 1.025, 0.125
59110, 0.64583333333333, 1.05, 0.125
59111, 0.66666666666667, 1.05, 0.10416666666667
59112, 0.66666666666667, 1.075, 0.125
59113, 0.64583333333333, 1.1, 0.125
59114, 0.66666666666667, 1.1, 0.10416666666667
59115, 0.66666666666667, 1.125, 0.125
59116, 0.64583333333333, 1.15, 0.125
59117, 0.66666666666667, 1.15, 0.10416666666667
59118, 0.66666666666667, 1.175, 0.125
59119, 0.64583333333333, 1.2, 0.125
59120, 0.66666666666667, 1.2, 0.10416666666667
59121, 0.66666666666667, 1.225, 0.125
59122, 0.64583333333333, 1.25, 0.125
59123, 0.66666666666667, 1.25, 0.10416666666667
59124, 0.66666666666667, 1.275, 0.125
59125, 0.64583333333333, 1.3, 0.125
59126, 0.66666666666667, 1.3, 0.10416666666667
59127, 0.66666666666667, 1.325, 0.125
59128, 0.66666666666667, 0.175, 0.16666666666667
59129, 0.64583333333333, 0.2, 0.16666666666667
59130, 0.66666666666667, 0.2, 0.14583333333333
59131, 0.66666666666667, 0.225, 0.16666666666667
59132, 0.64583333333333, 0.25, 0.16666666666667
59133, 0.66666666666667, 0.25, 0.14583333333333
59134, 0.66666666666667, 0.275, 0.16666666666667
59135, 0.64583333333333, 0.3, 0.16666666666667
59136, 0.66666666666667, 0.3, 0.14583333333333
59137, 0.66666666666667, 0.325, 0.16666666666667
59138, 0.64583333333333, 0.35, 0.16666666666667
59139, 0.66666666666667, 0.35, 0.14583333333333
59140, 0.66666666666667, 0.375, 0.16666666666667
59141, 0.64583333333333, 0.4, 0.16666666666667
59142, 0.66666666666667, 0.4, 0.14583333333333
59143, 0.66666666666667, 0.425, 0.16666666666667
59144, 0.64583333333333, 0.45, 0.16666666666667
59145, 0.66666666666667, 0.45, 0.14583333333333
59146, 0.66666666666667, 0.475, 0.16666666666667
59147, 0.64583333333333, 0.5, 0.16666666666667
59148, 0.66666666666667, 0.5, 0.14583333333333
59149, 0.66666666666667, 0.525, 0.16666666666667
59150, 0.64583333333333, 0.55, 0.16666666666667
59151, 0.66666666666667, 0.55, 0.14583333333333
59152, 0.66666666666667, 0.575, 0.16666666666667
59153, 0.64583333333333, 0.6, 0.16666666666667
59154, 0.66666666666667, 0.6, 0.14583333333333
59155, 0.66666666666667, 0.625, 0.16666666666667
59156, 0.64583333333333, 0.65, 0.16666666666667
59157, 0.66666666666667, 0.65, 0.14583333333333
59158, 0.66666666666667, 0.675, 0.16666666666667
59159, 0.64583333333333, 0.7, 0.16666666666667
59160, 0.66666666666667, 0.7, 0.14583333333333
59161, 0.66666666666667, 0.725, 0.16666666666667
59162, 0.64583333333333, 0.75, 0.16666666666667
59163, 0.66666666666667, 0.75, 0.14583333333333
59164, 0.66666666666667, 0.775, 0.16666666666667
59165, 0.64583333333333, 0.8, 0.16666666666667
59166, 0.66666666666667, 0.8, 0.14583333333333
59167, 0.66666666666667, 0.825, 0.16666666666667
59168, 0.64583333333333, 0.85, 0.16666666666667
59169, 0.66666666666667, 0.85, 0.14583333333333
59170, 0.66666666666667, 0.875, 0.16666666666667
59171, 0.64583333333333, 0.9, 0.16666666666667
59172, 0.66666666666667, 0.9, 0.14583333333333
59173, 0.66666666666667, 0.925, 0.16666666666667
59174, 0.64583333333333, 0.95, 0.16666666666667
59175, 0.66666666666667, 0.95, 0.14583333333333
59176, 0.66666666666667, 0.975, 0.16666666666667
59177, 0.64583333333333, 1, 0.16666666666667
59178, 0.66666666666667, 1, 0.14583333333333
59179, 0.66666666666667, 1.025, 0.16666666666667
59180, 0.64583333333333, 1.05, 0.16666666666667
59181, 0.66666666666667, 1.05, 0.14583333333333
59182, 0.66666666666667, 1.075, 0.16666666666667
59183, 0.64583333333333, 1.1, 0.16666666666667
59184, 0.66666666666667, 1.1, 0.14583333333333
59185, 0.66666666666667, 1.125, 0.16666666666667
59186, 0.64583333333333, 1.15, 0.16666666666667
59187, 0.66666666666667, 1.15, 0.14583333333333
59188, 0.66666666666667, 1.175, 0.16666666666667
59189, 0.64583333333333, 1.2, 0.16666666666667
59190, 0.66666666666667, 1.2, 0.14583333333333
59191, 0.66666666666667, 1.225, 0.16666666666667
59192, 0.64583333333333, 1.25, 0.16666666666667
59193, 0.66666666666667, 1.25, 0.14583333333333
59194, 0.66666666666667, 1.275, 0.16666666666667
59195, 0.64583333333333, 1.3, 0.16666666666667
59196, 0.66666666666667, 1.3, 0.14583333333333
59197, 0.66666666666667, 1.325, 0.16666666666667
59198, 0.66666666666667, 0.175, 0.20833333333333
59199, 0.64583333333333, 0.2, 0.20833333333333
59200, 0.66666666666667, 0.2, 0.1875
59201, 0.66666666666667, 0.225, 0.20833333333333
59202, 0.64583333333333, 0.25, 0.20833333333333
59203, 0.66666666666667, 0.25, 0.1875
59204, 0.66666666666667, 0.275, 0.20833333333333
59205, 0.64583333333333, 0.3, 0.20833333333333
59206, 0.66666666666667, 0.3, 0.1875
59207, 0.66666666666667, 0.325, 0.20833333333333
59208, 0.64583333333333, 0.35, 0.20833333333333
59209, 0.66666666666667, 0.35, 0.1875
59210, 0.66666666666667, 0.375, 0.20833333333333
59211, 0.64583333333333, 0.4, 0.20833333333333
59212, 0.66666666666667, 0.4, 0.1875
59213, 0.66666666666667, 0.425, 0.20833333333333
59214, 0.64583333333333, 0.45, 0.20833333333333
59215, 0.66666666666667, 0.45, 0.1875
59216, 0.66666666666667, 0.475, 0.20833333333333
59217, 0.64583333333333, 0.5, 0.20833333333333
59218, 0.66666666666667, 0.5, 0.1875
59219, 0.66666666666667, 0.525, 0.20833333333333
59220, 0.64583333333333, 0.55, 0.20833333333333
59221, 0.66666666666667, 0.55, 0.1875
59222, 0.66666666666667, 0.575, 0.20833333333333
59223, 0.64583333333333, 0.6, 0.20833333333333
59224, 0.66666666666667, 0.6, 0.1875
59225, 0.66666666666667, 0.625, 0.20833333333333
59226, 0.64583333333333, 0.65, 0.20833333333333
59227, 0.66666666666667, 0.65, 0.1875
59228, 0.66666666666667, 0.675, 0.20833333333333
59229, 0.64583333333333, 0.7, 0.20833333333333
59230, 0.66666666666667, 0.7, 0.1875
59231, 0.66666666666667, 0.725, 0.20833333333333
59232, 0.64583333333333, 0.75, 0.20833333333333
59233, 0.66666666666667, 0.75, 0.1875
59234, 0.66666666666667, 0.775, 0.20833333333333
59235, 0.64583333333333, 0.8, 0.20833333333333
59236, 0.66666666666667, 0.8, 0.1875
59237, 0.66666666666667, 0.825, 0.20833333333333
59238, 0.64583333333333, 0.85, 0.20833333333333
59239, 0.66666666666667, 0.85, 0.1875
59240, 0.66666666666667, 0.875, 0.20833333333333
59241, 0.64583333333333, 0.9, 0.20833333333333
59242, 0.66666666666667, 0.9, 0.1875
59243, 0.66666666666667, 0.925, 0.20833333333333
59244, 0.64583333333333, 0.95, 0.20833333333333
59245, 0.66666666666667, 0.95, 0.1875
59246, 0.66666666666667, 0.975, 0.20833333333333
59247, 0.64583333333333, 1, 0.20833333333333
59248, 0.66666666666667, 1, 0.1875
59249, 0.66666666666667, 1.025, 0.20833333333333
59250, 0.64583333333333, 1.05, 0.20833333333333
59251, 0.66666666666667, 1.05, 0.1875
59252, 0.66666666666667, 1.075, 0.20833333333333
59253, 0.64583333333333, 1.1, 0.20833333333333
59254, 0.66666666666667, 1.1, 0.1875
59255, 0.66666666666667, 1.125, 0.20833333333333
59256, 0.64583333333333, 1.15, 0.20833333333333
59257, 0.66666666666667, 1.15, 0.1875
59258, 0.66666666666667, 1.175, 0.20833333333333
59259, 0.64583333333333, 1.2, 0.20833333333333
59260, 0.66666666666667, 1.2, 0.1875
59261, 0.66666666666667, 1.225, 0.20833333333333
59262, 0.64583333333333, 1.25, 0.20833333333333
59263, 0.66666666666667, 1.25, 0.1875
59264, 0.66666666666667, 1.275, 0.20833333333333
59265, 0.64583333333333, 1.3, 0.20833333333333
59266, 0.66666666666667, 1.3, 0.1875
59267, 0.66666666666667, 1.325, 0.20833333333333
59268, 0.66666666666667, 0.175, 0.25
59269, 0.64583333333333, 0.2, 0.25
59270, 0.66666666666667, 0.2, 0.22916666666667
59271, 0.66666666666667, 0.225, 0.25
59272, 0.64583333333333, 0.25, 0.25
59273, 0.66666666666667, 0.25, 0.22916666666667
59274, 0.66666666666667, 0.275, 0.25
59275, 0.64583333333333, 0.3, 0.25
59276, 0.66666666666667, 0.3, 0.22916666666667
59277, 0.66666666666667, 0.325, 0.25
59278, 0.64583333333333, 0.35, 0.25
59279, 0.66666666666667, 0.35, 0.22916666666667
59280, 0.66666666666667, 0.375, 0.25
59281, 0.64583333333333, 0.4, 0.25
59282, 0.66666666666667, 0.4, 0.22916666666667
59283, 0.66666666666667, 0.425, 0.25
59284, 0.64583333333333, 0.45, 0.25
59285, 0.66666666666667, 0.45, 0.22916666666667
59286, 0.66666666666667, 0.475, 0.25
59287, 0.64583333333333, 0.5, 0.25
59288, 0.66666666666667, 0.5, 0.22916666666667
59289, 0.66666666666667, 0.525, 0.25
59290, 0.64583333333333, 0.55, 0.25
59291, 0.66666666666667, 0.55, 0.22916666666667
59292, 0.66666666666667, 0.575, 0.25
59293, 0.64583333333333, 0.6, 0.25
59294, 0.66666666666667, 0.6, 0.22916666666667
59295, 0.66666666666667, 0.625, 0.25
59296, 0.64583333333333, 0.65, 0.25
59297, 0.66666666666667, 0.65, 0.22916666666667
59298, 0.66666666666667, 0.675, 0.25
