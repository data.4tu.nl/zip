70338, 1.7416666666667, 1.4833333333333, 0.33333333333333
70339, 1.7833333333333, 1.4833333333333, 0.33333333333333
70340, 1.825, 1.4833333333333, 0.33333333333333
70341, 1.8666666666667, 1.4833333333333, 0.33333333333333
70342, 1.9083333333333, 1.4833333333333, 0.33333333333333
70343, 1.95, 1.4833333333333, 0.33333333333333
70344, 1.9916666666667, 1.4833333333333, 0.33333333333333
70345, 2.0333333333333, 1.4833333333333, 0.33333333333333
70346, 2.075, 1.4833333333333, 0.33333333333333
70347, 2.1166666666667, 1.4833333333333, 0.33333333333333
70348, 2.1583333333333, 1.4833333333333, 0.33333333333333
70349, 1.2208333333333, 1.4333333333333, 0.375
70350, 1.2416666666667, 1.4333333333333, 0.35416666666667
70351, 1.2416666666667, 1.4166666666667, 0.375
70352, 1.2625, 1.4333333333333, 0.375
70353, 1.2833333333333, 1.4333333333333, 0.35416666666667
70354, 1.2833333333333, 1.4166666666667, 0.375
70355, 1.3041666666667, 1.4333333333333, 0.375
70356, 1.325, 1.4333333333333, 0.35416666666667
70357, 1.325, 1.4166666666667, 0.375
70358, 1.3458333333333, 1.4333333333333, 0.375
70359, 1.3666666666667, 1.4333333333333, 0.35416666666667
70360, 1.3666666666667, 1.4166666666667, 0.375
70361, 1.3875, 1.4333333333333, 0.375
70362, 1.4083333333333, 1.4333333333333, 0.35416666666667
70363, 1.4083333333333, 1.4166666666667, 0.375
70364, 1.4291666666667, 1.4333333333333, 0.375
70365, 1.45, 1.4333333333333, 0.35416666666667
70366, 1.45, 1.4166666666667, 0.375
70367, 1.4708333333333, 1.4333333333333, 0.375
70368, 1.4916666666667, 1.4333333333333, 0.35416666666667
70369, 1.4916666666667, 1.4166666666667, 0.375
70370, 1.5125, 1.4333333333333, 0.375
70371, 1.5333333333333, 1.4333333333333, 0.35416666666667
70372, 1.5333333333333, 1.4166666666667, 0.375
70373, 1.5541666666667, 1.4333333333333, 0.375
70374, 1.575, 1.4333333333333, 0.35416666666667
70375, 1.575, 1.4166666666667, 0.375
70376, 1.5958333333333, 1.4333333333333, 0.375
70377, 1.6166666666667, 1.4333333333333, 0.35416666666667
70378, 1.6166666666667, 1.4166666666667, 0.375
70379, 1.6375, 1.4333333333333, 0.375
70380, 1.6583333333333, 1.4333333333333, 0.35416666666667
70381, 1.6583333333333, 1.4166666666667, 0.375
70382, 1.6791666666667, 1.4333333333333, 0.375
70383, 1.7, 1.4333333333333, 0.35416666666667
70384, 1.7, 1.4166666666667, 0.375
70385, 1.7208333333333, 1.4333333333333, 0.375
70386, 1.7416666666667, 1.4333333333333, 0.35416666666667
70387, 1.7416666666667, 1.4166666666667, 0.375
70388, 1.7625, 1.4333333333333, 0.375
70389, 1.7833333333333, 1.4333333333333, 0.35416666666667
70390, 1.7833333333333, 1.4166666666667, 0.375
70391, 1.8041666666667, 1.4333333333333, 0.375
70392, 1.825, 1.4333333333333, 0.35416666666667
70393, 1.825, 1.4166666666667, 0.375
70394, 1.8458333333333, 1.4333333333333, 0.375
70395, 1.8666666666667, 1.4333333333333, 0.35416666666667
70396, 1.8666666666667, 1.4166666666667, 0.375
70397, 1.8875, 1.4333333333333, 0.375
70398, 1.9083333333333, 1.4333333333333, 0.35416666666667
70399, 1.9083333333333, 1.4166666666667, 0.375
70400, 1.9291666666667, 1.4333333333333, 0.375
70401, 1.95, 1.4333333333333, 0.35416666666667
70402, 1.95, 1.4166666666667, 0.375
70403, 1.9708333333333, 1.4333333333333, 0.375
70404, 1.9916666666667, 1.4333333333333, 0.35416666666667
70405, 1.9916666666667, 1.4166666666667, 0.375
70406, 2.0125, 1.4333333333333, 0.375
70407, 2.0333333333333, 1.4333333333333, 0.35416666666667
70408, 2.0333333333333, 1.4166666666667, 0.375
70409, 2.0541666666667, 1.4333333333333, 0.375
70410, 2.075, 1.4333333333333, 0.35416666666667
70411, 2.075, 1.4166666666667, 0.375
70412, 2.0958333333333, 1.4333333333333, 0.375
70413, 2.1166666666667, 1.4333333333333, 0.35416666666667
70414, 2.1166666666667, 1.4166666666667, 0.375
70415, 2.1375, 1.4333333333333, 0.375
70416, 2.1583333333333, 1.4333333333333, 0.35416666666667
70417, 2.1583333333333, 1.4166666666667, 0.375
70418, 2.1791666666667, 1.4333333333333, 0.375
70419, 1.2208333333333, 1.4666666666667, 0.375
70420, 1.2416666666667, 1.4666666666667, 0.35416666666667
70421, 1.2416666666667, 1.45, 0.375
70422, 1.2625, 1.4666666666667, 0.375
70423, 1.2833333333333, 1.4666666666667, 0.35416666666667
70424, 1.2833333333333, 1.45, 0.375
70425, 1.3041666666667, 1.4666666666667, 0.375
70426, 1.325, 1.4666666666667, 0.35416666666667
70427, 1.325, 1.45, 0.375
70428, 1.3458333333333, 1.4666666666667, 0.375
70429, 1.3666666666667, 1.4666666666667, 0.35416666666667
70430, 1.3666666666667, 1.45, 0.375
70431, 1.3875, 1.4666666666667, 0.375
70432, 1.4083333333333, 1.4666666666667, 0.35416666666667
70433, 1.4083333333333, 1.45, 0.375
70434, 1.4291666666667, 1.4666666666667, 0.375
70435, 1.45, 1.4666666666667, 0.35416666666667
70436, 1.45, 1.45, 0.375
70437, 1.4708333333333, 1.4666666666667, 0.375
70438, 1.4916666666667, 1.4666666666667, 0.35416666666667
70439, 1.4916666666667, 1.45, 0.375
70440, 1.5125, 1.4666666666667, 0.375
70441, 1.5333333333333, 1.4666666666667, 0.35416666666667
70442, 1.5333333333333, 1.45, 0.375
70443, 1.5541666666667, 1.4666666666667, 0.375
70444, 1.575, 1.4666666666667, 0.35416666666667
70445, 1.575, 1.45, 0.375
70446, 1.5958333333333, 1.4666666666667, 0.375
70447, 1.6166666666667, 1.4666666666667, 0.35416666666667
70448, 1.6166666666667, 1.45, 0.375
70449, 1.6375, 1.4666666666667, 0.375
70450, 1.6583333333333, 1.4666666666667, 0.35416666666667
70451, 1.6583333333333, 1.45, 0.375
70452, 1.6791666666667, 1.4666666666667, 0.375
70453, 1.7, 1.4666666666667, 0.35416666666667
70454, 1.7, 1.45, 0.375
70455, 1.7208333333333, 1.4666666666667, 0.375
70456, 1.7416666666667, 1.4666666666667, 0.35416666666667
70457, 1.7416666666667, 1.45, 0.375
70458, 1.7625, 1.4666666666667, 0.375
70459, 1.7833333333333, 1.4666666666667, 0.35416666666667
70460, 1.7833333333333, 1.45, 0.375
70461, 1.8041666666667, 1.4666666666667, 0.375
70462, 1.825, 1.4666666666667, 0.35416666666667
70463, 1.825, 1.45, 0.375
70464, 1.8458333333333, 1.4666666666667, 0.375
70465, 1.8666666666667, 1.4666666666667, 0.35416666666667
70466, 1.8666666666667, 1.45, 0.375
70467, 1.8875, 1.4666666666667, 0.375
70468, 1.9083333333333, 1.4666666666667, 0.35416666666667
70469, 1.9083333333333, 1.45, 0.375
70470, 1.9291666666667, 1.4666666666667, 0.375
70471, 1.95, 1.4666666666667, 0.35416666666667
70472, 1.95, 1.45, 0.375
70473, 1.9708333333333, 1.4666666666667, 0.375
70474, 1.9916666666667, 1.4666666666667, 0.35416666666667
70475, 1.9916666666667, 1.45, 0.375
70476, 2.0125, 1.4666666666667, 0.375
70477, 2.0333333333333, 1.4666666666667, 0.35416666666667
70478, 2.0333333333333, 1.45, 0.375
70479, 2.0541666666667, 1.4666666666667, 0.375
70480, 2.075, 1.4666666666667, 0.35416666666667
70481, 2.075, 1.45, 0.375
70482, 2.0958333333333, 1.4666666666667, 0.375
70483, 2.1166666666667, 1.4666666666667, 0.35416666666667
70484, 2.1166666666667, 1.45, 0.375
70485, 2.1375, 1.4666666666667, 0.375
70486, 2.1583333333333, 1.4666666666667, 0.35416666666667
70487, 2.1583333333333, 1.45, 0.375
70488, 2.1791666666667, 1.4666666666667, 0.375
70489, 1.2416666666667, 1.4833333333333, 0.375
70490, 1.2833333333333, 1.4833333333333, 0.375
70491, 1.325, 1.4833333333333, 0.375
70492, 1.3666666666667, 1.4833333333333, 0.375
70493, 1.4083333333333, 1.4833333333333, 0.375
70494, 1.45, 1.4833333333333, 0.375
70495, 1.4916666666667, 1.4833333333333, 0.375
70496, 1.5333333333333, 1.4833333333333, 0.375
70497, 1.575, 1.4833333333333, 0.375
70498, 1.6166666666667, 1.4833333333333, 0.375
70499, 1.6583333333333, 1.4833333333333, 0.375
70500, 1.7, 1.4833333333333, 0.375
70501, 1.7416666666667, 1.4833333333333, 0.375
70502, 1.7833333333333, 1.4833333333333, 0.375
70503, 1.825, 1.4833333333333, 0.375
70504, 1.8666666666667, 1.4833333333333, 0.375
70505, 1.9083333333333, 1.4833333333333, 0.375
70506, 1.95, 1.4833333333333, 0.375
70507, 1.9916666666667, 1.4833333333333, 0.375
70508, 2.0333333333333, 1.4833333333333, 0.375
70509, 2.075, 1.4833333333333, 0.375
70510, 2.1166666666667, 1.4833333333333, 0.375
70511, 2.1583333333333, 1.4833333333333, 0.375
70512, 1.2208333333333, 1.4333333333333, 0.41666666666667
70513, 1.2416666666667, 1.4333333333333, 0.39583333333333
70514, 1.2416666666667, 1.4166666666667, 0.41666666666667
70515, 1.2625, 1.4333333333333, 0.41666666666667
70516, 1.2833333333333, 1.4333333333333, 0.39583333333333
70517, 1.2833333333333, 1.4166666666667, 0.41666666666667
70518, 1.3041666666667, 1.4333333333333, 0.41666666666667
70519, 1.325, 1.4333333333333, 0.39583333333333
70520, 1.325, 1.4166666666667, 0.41666666666667
70521, 1.3458333333333, 1.4333333333333, 0.41666666666667
70522, 1.3666666666667, 1.4333333333333, 0.39583333333333
70523, 1.3666666666667, 1.4166666666667, 0.41666666666667
70524, 1.3875, 1.4333333333333, 0.41666666666667
70525, 1.4083333333333, 1.4333333333333, 0.39583333333333
70526, 1.4083333333333, 1.4166666666667, 0.41666666666667
70527, 1.4291666666667, 1.4333333333333, 0.41666666666667
70528, 1.45, 1.4333333333333, 0.39583333333333
70529, 1.45, 1.4166666666667, 0.41666666666667
70530, 1.4708333333333, 1.4333333333333, 0.41666666666667
70531, 1.4916666666667, 1.4333333333333, 0.39583333333333
70532, 1.4916666666667, 1.4166666666667, 0.41666666666667
70533, 1.5125, 1.4333333333333, 0.41666666666667
70534, 1.5333333333333, 1.4333333333333, 0.39583333333333
70535, 1.5333333333333, 1.4166666666667, 0.41666666666667
70536, 1.5541666666667, 1.4333333333333, 0.41666666666667
70537, 1.575, 1.4333333333333, 0.39583333333333
70538, 1.575, 1.4166666666667, 0.41666666666667
70539, 1.5958333333333, 1.4333333333333, 0.41666666666667
70540, 1.6166666666667, 1.4333333333333, 0.39583333333333
70541, 1.6166666666667, 1.4166666666667, 0.41666666666667
70542, 1.6375, 1.4333333333333, 0.41666666666667
70543, 1.6583333333333, 1.4333333333333, 0.39583333333333
70544, 1.6583333333333, 1.4166666666667, 0.41666666666667
70545, 1.6791666666667, 1.4333333333333, 0.41666666666667
70546, 1.7, 1.4333333333333, 0.39583333333333
70547, 1.7, 1.4166666666667, 0.41666666666667
70548, 1.7208333333333, 1.4333333333333, 0.41666666666667
70549, 1.7416666666667, 1.4333333333333, 0.39583333333333
70550, 1.7416666666667, 1.4166666666667, 0.41666666666667
70551, 1.7625, 1.4333333333333, 0.41666666666667
70552, 1.7833333333333, 1.4333333333333, 0.39583333333333
70553, 1.7833333333333, 1.4166666666667, 0.41666666666667
70554, 1.8041666666667, 1.4333333333333, 0.41666666666667
70555, 1.825, 1.4333333333333, 0.39583333333333
70556, 1.825, 1.4166666666667, 0.41666666666667
70557, 1.8458333333333, 1.4333333333333, 0.41666666666667
70558, 1.8666666666667, 1.4333333333333, 0.39583333333333
70559, 1.8666666666667, 1.4166666666667, 0.41666666666667
70560, 1.8875, 1.4333333333333, 0.41666666666667
70561, 1.9083333333333, 1.4333333333333, 0.39583333333333
70562, 1.9083333333333, 1.4166666666667, 0.41666666666667
70563, 1.9291666666667, 1.4333333333333, 0.41666666666667
70564, 1.95, 1.4333333333333, 0.39583333333333
70565, 1.95, 1.4166666666667, 0.41666666666667
70566, 1.9708333333333, 1.4333333333333, 0.41666666666667
70567, 1.9916666666667, 1.4333333333333, 0.39583333333333
70568, 1.9916666666667, 1.4166666666667, 0.41666666666667
70569, 2.0125, 1.4333333333333, 0.41666666666667
70570, 2.0333333333333, 1.4333333333333, 0.39583333333333
70571, 2.0333333333333, 1.4166666666667, 0.41666666666667
70572, 2.0541666666667, 1.4333333333333, 0.41666666666667
70573, 2.075, 1.4333333333333, 0.39583333333333
70574, 2.075, 1.4166666666667, 0.41666666666667
70575, 2.0958333333333, 1.4333333333333, 0.41666666666667
70576, 2.1166666666667, 1.4333333333333, 0.39583333333333
70577, 2.1166666666667, 1.4166666666667, 0.41666666666667
70578, 2.1375, 1.4333333333333, 0.41666666666667
70579, 2.1583333333333, 1.4333333333333, 0.39583333333333
70580, 2.1583333333333, 1.4166666666667, 0.41666666666667
70581, 2.1791666666667, 1.4333333333333, 0.41666666666667
70582, 1.2208333333333, 1.4666666666667, 0.41666666666667
70583, 1.2416666666667, 1.4666666666667, 0.39583333333333
70584, 1.2416666666667, 1.45, 0.41666666666667
70585, 1.2625, 1.4666666666667, 0.41666666666667
70586, 1.2833333333333, 1.4666666666667, 0.39583333333333
70587, 1.2833333333333, 1.45, 0.41666666666667
70588, 1.3041666666667, 1.4666666666667, 0.41666666666667
70589, 1.325, 1.4666666666667, 0.39583333333333
70590, 1.325, 1.45, 0.41666666666667
70591, 1.3458333333333, 1.4666666666667, 0.41666666666667
70592, 1.3666666666667, 1.4666666666667, 0.39583333333333
70593, 1.3666666666667, 1.45, 0.41666666666667
70594, 1.3875, 1.4666666666667, 0.41666666666667
70595, 1.4083333333333, 1.4666666666667, 0.39583333333333
70596, 1.4083333333333, 1.45, 0.41666666666667
70597, 1.4291666666667, 1.4666666666667, 0.41666666666667
70598, 1.45, 1.4666666666667, 0.39583333333333
70599, 1.45, 1.45, 0.41666666666667
70600, 1.4708333333333, 1.4666666666667, 0.41666666666667
70601, 1.4916666666667, 1.4666666666667, 0.39583333333333
70602, 1.4916666666667, 1.45, 0.41666666666667
70603, 1.5125, 1.4666666666667, 0.41666666666667
70604, 1.5333333333333, 1.4666666666667, 0.39583333333333
70605, 1.5333333333333, 1.45, 0.41666666666667
70606, 1.5541666666667, 1.4666666666667, 0.41666666666667
70607, 1.575, 1.4666666666667, 0.39583333333333
70608, 1.575, 1.45, 0.41666666666667
70609, 1.5958333333333, 1.4666666666667, 0.41666666666667
70610, 1.6166666666667, 1.4666666666667, 0.39583333333333
70611, 1.6166666666667, 1.45, 0.41666666666667
70612, 1.6375, 1.4666666666667, 0.41666666666667
70613, 1.6583333333333, 1.4666666666667, 0.39583333333333
70614, 1.6583333333333, 1.45, 0.41666666666667
70615, 1.6791666666667, 1.4666666666667, 0.41666666666667
70616, 1.7, 1.4666666666667, 0.39583333333333
70617, 1.7, 1.45, 0.41666666666667
70618, 1.7208333333333, 1.4666666666667, 0.41666666666667
70619, 1.7416666666667, 1.4666666666667, 0.39583333333333
70620, 1.7416666666667, 1.45, 0.41666666666667
70621, 1.7625, 1.4666666666667, 0.41666666666667
70622, 1.7833333333333, 1.4666666666667, 0.39583333333333
70623, 1.7833333333333, 1.45, 0.41666666666667
70624, 1.8041666666667, 1.4666666666667, 0.41666666666667
70625, 1.825, 1.4666666666667, 0.39583333333333
70626, 1.825, 1.45, 0.41666666666667
70627, 1.8458333333333, 1.4666666666667, 0.41666666666667
70628, 1.8666666666667, 1.4666666666667, 0.39583333333333
70629, 1.8666666666667, 1.45, 0.41666666666667
70630, 1.8875, 1.4666666666667, 0.41666666666667
70631, 1.9083333333333, 1.4666666666667, 0.39583333333333
70632, 1.9083333333333, 1.45, 0.41666666666667
70633, 1.9291666666667, 1.4666666666667, 0.41666666666667
70634, 1.95, 1.4666666666667, 0.39583333333333
70635, 1.95, 1.45, 0.41666666666667
70636, 1.9708333333333, 1.4666666666667, 0.41666666666667
70637, 1.9916666666667, 1.4666666666667, 0.39583333333333
70638, 1.9916666666667, 1.45, 0.41666666666667
70639, 2.0125, 1.4666666666667, 0.41666666666667
70640, 2.0333333333333, 1.4666666666667, 0.39583333333333
70641, 2.0333333333333, 1.45, 0.41666666666667
70642, 2.0541666666667, 1.4666666666667, 0.41666666666667
70643, 2.075, 1.4666666666667, 0.39583333333333
70644, 2.075, 1.45, 0.41666666666667
70645, 2.0958333333333, 1.4666666666667, 0.41666666666667
70646, 2.1166666666667, 1.4666666666667, 0.39583333333333
70647, 2.1166666666667, 1.45, 0.41666666666667
70648, 2.1375, 1.4666666666667, 0.41666666666667
70649, 2.1583333333333, 1.4666666666667, 0.39583333333333
70650, 2.1583333333333, 1.45, 0.41666666666667
70651, 2.1791666666667, 1.4666666666667, 0.41666666666667
70652, 1.2416666666667, 1.4833333333333, 0.41666666666667
70653, 1.2833333333333, 1.4833333333333, 0.41666666666667
70654, 1.325, 1.4833333333333, 0.41666666666667
70655, 1.3666666666667, 1.4833333333333, 0.41666666666667
70656, 1.4083333333333, 1.4833333333333, 0.41666666666667
70657, 1.45, 1.4833333333333, 0.41666666666667
70658, 1.4916666666667, 1.4833333333333, 0.41666666666667
70659, 1.5333333333333, 1.4833333333333, 0.41666666666667
70660, 1.575, 1.4833333333333, 0.41666666666667
70661, 1.6166666666667, 1.4833333333333, 0.41666666666667
70662, 1.6583333333333, 1.4833333333333, 0.41666666666667
70663, 1.7, 1.4833333333333, 0.41666666666667
70664, 1.7416666666667, 1.4833333333333, 0.41666666666667
70665, 1.7833333333333, 1.4833333333333, 0.41666666666667
70666, 1.825, 1.4833333333333, 0.41666666666667
70667, 1.8666666666667, 1.4833333333333, 0.41666666666667
70668, 1.9083333333333, 1.4833333333333, 0.41666666666667
70669, 1.95, 1.4833333333333, 0.41666666666667
70670, 1.9916666666667, 1.4833333333333, 0.41666666666667
70671, 2.0333333333333, 1.4833333333333, 0.41666666666667
70672, 2.075, 1.4833333333333, 0.41666666666667
70673, 2.1166666666667, 1.4833333333333, 0.41666666666667
70674, 2.1583333333333, 1.4833333333333, 0.41666666666667
70675, 1.2208333333333, 1.4333333333333, 0.45833333333333
70676, 1.2416666666667, 1.4333333333333, 0.4375
70677, 1.2416666666667, 1.4166666666667, 0.45833333333333
70678, 1.2625, 1.4333333333333, 0.45833333333333
70679, 1.2833333333333, 1.4333333333333, 0.4375
70680, 1.2833333333333, 1.4166666666667, 0.45833333333333
70681, 1.3041666666667, 1.4333333333333, 0.45833333333333
70682, 1.325, 1.4333333333333, 0.4375
70683, 1.325, 1.4166666666667, 0.45833333333333
70684, 1.3458333333333, 1.4333333333333, 0.45833333333333
70685, 1.3666666666667, 1.4333333333333, 0.4375
70686, 1.3666666666667, 1.4166666666667, 0.45833333333333
70687, 1.3875, 1.4333333333333, 0.45833333333333
70688, 1.4083333333333, 1.4333333333333, 0.4375
70689, 1.4083333333333, 1.4166666666667, 0.45833333333333
70690, 1.4291666666667, 1.4333333333333, 0.45833333333333
70691, 1.45, 1.4333333333333, 0.4375
70692, 1.45, 1.4166666666667, 0.45833333333333
70693, 1.4708333333333, 1.4333333333333, 0.45833333333333
70694, 1.4916666666667, 1.4333333333333, 0.4375
70695, 1.4916666666667, 1.4166666666667, 0.45833333333333
70696, 1.5125, 1.4333333333333, 0.45833333333333
70697, 1.5333333333333, 1.4333333333333, 0.4375
70698, 1.5333333333333, 1.4166666666667, 0.45833333333333
70699, 1.5541666666667, 1.4333333333333, 0.45833333333333
70700, 1.575, 1.4333333333333, 0.4375
70701, 1.575, 1.4166666666667, 0.45833333333333
70702, 1.5958333333333, 1.4333333333333, 0.45833333333333
70703, 1.6166666666667, 1.4333333333333, 0.4375
70704, 1.6166666666667, 1.4166666666667, 0.45833333333333
70705, 1.6375, 1.4333333333333, 0.45833333333333
70706, 1.6583333333333, 1.4333333333333, 0.4375
70707, 1.6583333333333, 1.4166666666667, 0.45833333333333
70708, 1.6791666666667, 1.4333333333333, 0.45833333333333
70709, 1.7, 1.4333333333333, 0.4375
70710, 1.7, 1.4166666666667, 0.45833333333333
70711, 1.7208333333333, 1.4333333333333, 0.45833333333333
70712, 1.7416666666667, 1.4333333333333, 0.4375
70713, 1.7416666666667, 1.4166666666667, 0.45833333333333
70714, 1.7625, 1.4333333333333, 0.45833333333333
70715, 1.7833333333333, 1.4333333333333, 0.4375
70716, 1.7833333333333, 1.4166666666667, 0.45833333333333
70717, 1.8041666666667, 1.4333333333333, 0.45833333333333
70718, 1.825, 1.4333333333333, 0.4375
70719, 1.825, 1.4166666666667, 0.45833333333333
70720, 1.8458333333333, 1.4333333333333, 0.45833333333333
70721, 1.8666666666667, 1.4333333333333, 0.4375
70722, 1.8666666666667, 1.4166666666667, 0.45833333333333
70723, 1.8875, 1.4333333333333, 0.45833333333333
70724, 1.9083333333333, 1.4333333333333, 0.4375
70725, 1.9083333333333, 1.4166666666667, 0.45833333333333
70726, 1.9291666666667, 1.4333333333333, 0.45833333333333
70727, 1.95, 1.4333333333333, 0.4375
70728, 1.95, 1.4166666666667, 0.45833333333333
70729, 1.9708333333333, 1.4333333333333, 0.45833333333333
70730, 1.9916666666667, 1.4333333333333, 0.4375
70731, 1.9916666666667, 1.4166666666667, 0.45833333333333
70732, 2.0125, 1.4333333333333, 0.45833333333333
70733, 2.0333333333333, 1.4333333333333, 0.4375
70734, 2.0333333333333, 1.4166666666667, 0.45833333333333
70735, 2.0541666666667, 1.4333333333333, 0.45833333333333
70736, 2.075, 1.4333333333333, 0.4375
70737, 2.075, 1.4166666666667, 0.45833333333333
70738, 2.0958333333333, 1.4333333333333, 0.45833333333333
70739, 2.1166666666667, 1.4333333333333, 0.4375
70740, 2.1166666666667, 1.4166666666667, 0.45833333333333
70741, 2.1375, 1.4333333333333, 0.45833333333333
70742, 2.1583333333333, 1.4333333333333, 0.4375
70743, 2.1583333333333, 1.4166666666667, 0.45833333333333
70744, 2.1791666666667, 1.4333333333333, 0.45833333333333
70745, 1.2208333333333, 1.4666666666667, 0.45833333333333
70746, 1.2416666666667, 1.4666666666667, 0.4375
70747, 1.2416666666667, 1.45, 0.45833333333333
70748, 1.2625, 1.4666666666667, 0.45833333333333
70749, 1.2833333333333, 1.4666666666667, 0.4375
70750, 1.2833333333333, 1.45, 0.45833333333333
70751, 1.3041666666667, 1.4666666666667, 0.45833333333333
70752, 1.325, 1.4666666666667, 0.4375
70753, 1.325, 1.45, 0.45833333333333
70754, 1.3458333333333, 1.4666666666667, 0.45833333333333
70755, 1.3666666666667, 1.4666666666667, 0.4375
70756, 1.3666666666667, 1.45, 0.45833333333333
70757, 1.3875, 1.4666666666667, 0.45833333333333
70758, 1.4083333333333, 1.4666666666667, 0.4375
70759, 1.4083333333333, 1.45, 0.45833333333333
70760, 1.4291666666667, 1.4666666666667, 0.45833333333333
70761, 1.45, 1.4666666666667, 0.4375
70762, 1.45, 1.45, 0.45833333333333
70763, 1.4708333333333, 1.4666666666667, 0.45833333333333
70764, 1.4916666666667, 1.4666666666667, 0.4375
70765, 1.4916666666667, 1.45, 0.45833333333333
70766, 1.5125, 1.4666666666667, 0.45833333333333
70767, 1.5333333333333, 1.4666666666667, 0.4375
70768, 1.5333333333333, 1.45, 0.45833333333333
70769, 1.5541666666667, 1.4666666666667, 0.45833333333333
70770, 1.575, 1.4666666666667, 0.4375
70771, 1.575, 1.45, 0.45833333333333
70772, 1.5958333333333, 1.4666666666667, 0.45833333333333
70773, 1.6166666666667, 1.4666666666667, 0.4375
70774, 1.6166666666667, 1.45, 0.45833333333333
70775, 1.6375, 1.4666666666667, 0.45833333333333
70776, 1.6583333333333, 1.4666666666667, 0.4375
70777, 1.6583333333333, 1.45, 0.45833333333333
70778, 1.6791666666667, 1.4666666666667, 0.45833333333333
70779, 1.7, 1.4666666666667, 0.4375
70780, 1.7, 1.45, 0.45833333333333
70781, 1.7208333333333, 1.4666666666667, 0.45833333333333
70782, 1.7416666666667, 1.4666666666667, 0.4375
70783, 1.7416666666667, 1.45, 0.45833333333333
70784, 1.7625, 1.4666666666667, 0.45833333333333
70785, 1.7833333333333, 1.4666666666667, 0.4375
70786, 1.7833333333333, 1.45, 0.45833333333333
70787, 1.8041666666667, 1.4666666666667, 0.45833333333333
70788, 1.825, 1.4666666666667, 0.4375
70789, 1.825, 1.45, 0.45833333333333
70790, 1.8458333333333, 1.4666666666667, 0.45833333333333
70791, 1.8666666666667, 1.4666666666667, 0.4375
70792, 1.8666666666667, 1.45, 0.45833333333333
70793, 1.8875, 1.4666666666667, 0.45833333333333
70794, 1.9083333333333, 1.4666666666667, 0.4375
70795, 1.9083333333333, 1.45, 0.45833333333333
70796, 1.9291666666667, 1.4666666666667, 0.45833333333333
70797, 1.95, 1.4666666666667, 0.4375
70798, 1.95, 1.45, 0.45833333333333
70799, 1.9708333333333, 1.4666666666667, 0.45833333333333
70800, 1.9916666666667, 1.4666666666667, 0.4375
70801, 1.9916666666667, 1.45, 0.45833333333333
70802, 2.0125, 1.4666666666667, 0.45833333333333
70803, 2.0333333333333, 1.4666666666667, 0.4375
70804, 2.0333333333333, 1.45, 0.45833333333333
70805, 2.0541666666667, 1.4666666666667, 0.45833333333333
70806, 2.075, 1.4666666666667, 0.4375
70807, 2.075, 1.45, 0.45833333333333
70808, 2.0958333333333, 1.4666666666667, 0.45833333333333
70809, 2.1166666666667, 1.4666666666667, 0.4375
70810, 2.1166666666667, 1.45, 0.45833333333333
70811, 2.1375, 1.4666666666667, 0.45833333333333
70812, 2.1583333333333, 1.4666666666667, 0.4375
70813, 2.1583333333333, 1.45, 0.45833333333333
70814, 2.1791666666667, 1.4666666666667, 0.45833333333333
70815, 1.2416666666667, 1.4833333333333, 0.45833333333333
70816, 1.2833333333333, 1.4833333333333, 0.45833333333333
70817, 1.325, 1.4833333333333, 0.45833333333333
70818, 1.3666666666667, 1.4833333333333, 0.45833333333333
70819, 1.4083333333333, 1.4833333333333, 0.45833333333333
70820, 1.45, 1.4833333333333, 0.45833333333333
70821, 1.4916666666667, 1.4833333333333, 0.45833333333333
70822, 1.5333333333333, 1.4833333333333, 0.45833333333333
70823, 1.575, 1.4833333333333, 0.45833333333333
70824, 1.6166666666667, 1.4833333333333, 0.45833333333333
70825, 1.6583333333333, 1.4833333333333, 0.45833333333333
70826, 1.7, 1.4833333333333, 0.45833333333333
70827, 1.7416666666667, 1.4833333333333, 0.45833333333333
70828, 1.7833333333333, 1.4833333333333, 0.45833333333333
70829, 1.825, 1.4833333333333, 0.45833333333333
70830, 1.8666666666667, 1.4833333333333, 0.45833333333333
70831, 1.9083333333333, 1.4833333333333, 0.45833333333333
70832, 1.95, 1.4833333333333, 0.45833333333333
70833, 1.9916666666667, 1.4833333333333, 0.45833333333333
70834, 2.0333333333333, 1.4833333333333, 0.45833333333333
70835, 2.075, 1.4833333333333, 0.45833333333333
70836, 2.1166666666667, 1.4833333333333, 0.45833333333333
70837, 2.1583333333333, 1.4833333333333, 0.45833333333333
70838, 1.2416666666667, 1.4333333333333, 0.47916666666667
70839, 1.2833333333333, 1.4333333333333, 0.47916666666667
70840, 1.325, 1.4333333333333, 0.47916666666667
70841, 1.3666666666667, 1.4333333333333, 0.47916666666667
70842, 1.4083333333333, 1.4333333333333, 0.47916666666667
70843, 1.45, 1.4333333333333, 0.47916666666667
70844, 1.4916666666667, 1.4333333333333, 0.47916666666667
70845, 1.5333333333333, 1.4333333333333, 0.47916666666667
70846, 1.575, 1.4333333333333, 0.47916666666667
70847, 1.6166666666667, 1.4333333333333, 0.47916666666667
70848, 1.6583333333333, 1.4333333333333, 0.47916666666667
70849, 1.7, 1.4333333333333, 0.47916666666667
70850, 1.7416666666667, 1.4333333333333, 0.47916666666667
70851, 1.7833333333333, 1.4333333333333, 0.47916666666667
70852, 1.825, 1.4333333333333, 0.47916666666667
70853, 1.8666666666667, 1.4333333333333, 0.47916666666667
70854, 1.9083333333333, 1.4333333333333, 0.47916666666667
70855, 1.95, 1.4333333333333, 0.47916666666667
70856, 1.9916666666667, 1.4333333333333, 0.47916666666667
70857, 2.0333333333333, 1.4333333333333, 0.47916666666667
70858, 2.075, 1.4333333333333, 0.47916666666667
70859, 2.1166666666667, 1.4333333333333, 0.47916666666667
70860, 2.1583333333333, 1.4333333333333, 0.47916666666667
70861, 1.2416666666667, 1.4666666666667, 0.47916666666667
70862, 1.2833333333333, 1.4666666666667, 0.47916666666667
70863, 1.325, 1.4666666666667, 0.47916666666667
70864, 1.3666666666667, 1.4666666666667, 0.47916666666667
70865, 1.4083333333333, 1.4666666666667, 0.47916666666667
70866, 1.45, 1.4666666666667, 0.47916666666667
70867, 1.4916666666667, 1.4666666666667, 0.47916666666667
70868, 1.5333333333333, 1.4666666666667, 0.47916666666667
70869, 1.575, 1.4666666666667, 0.47916666666667
70870, 1.6166666666667, 1.4666666666667, 0.47916666666667
70871, 1.6583333333333, 1.4666666666667, 0.47916666666667
70872, 1.7, 1.4666666666667, 0.47916666666667
70873, 1.7416666666667, 1.4666666666667, 0.47916666666667
70874, 1.7833333333333, 1.4666666666667, 0.47916666666667
70875, 1.825, 1.4666666666667, 0.47916666666667
70876, 1.8666666666667, 1.4666666666667, 0.47916666666667
70877, 1.9083333333333, 1.4666666666667, 0.47916666666667
70878, 1.95, 1.4666666666667, 0.47916666666667
70879, 1.9916666666667, 1.4666666666667, 0.47916666666667
70880, 2.0333333333333, 1.4666666666667, 0.47916666666667
70881, 2.075, 1.4666666666667, 0.47916666666667
70882, 2.1166666666667, 1.4666666666667, 0.47916666666667
70883, 2.1583333333333, 1.4666666666667, 0.47916666666667
70884, 1.2416666666667, 1.375, 0.041666666666667
70885, 1.2833333333333, 1.375, 0.041666666666667
70886, 1.325, 1.375, 0.041666666666667
70887, 1.3666666666667, 1.375, 0.041666666666667
70888, 1.4083333333333, 1.375, 0.041666666666667
70889, 1.45, 1.375, 0.041666666666667
70890, 1.4916666666667, 1.375, 0.041666666666667
70891, 1.5333333333333, 1.375, 0.041666666666667
70892, 1.575, 1.375, 0.041666666666667
70893, 1.6166666666667, 1.375, 0.041666666666667
70894, 1.6583333333333, 1.375, 0.041666666666667
70895, 1.7, 1.375, 0.041666666666667
70896, 1.7416666666667, 1.375, 0.041666666666667
70897, 1.7833333333333, 1.375, 0.041666666666667
70898, 1.825, 1.375, 0.041666666666667
70899, 1.8666666666667, 1.375, 0.041666666666667
70900, 1.9083333333333, 1.375, 0.041666666666667
70901, 1.95, 1.375, 0.041666666666667
70902, 1.9916666666667, 1.375, 0.041666666666667
70903, 2.0333333333333, 1.375, 0.041666666666667
70904, 2.075, 1.375, 0.041666666666667
70905, 2.1166666666667, 1.375, 0.041666666666667
70906, 2.1583333333333, 1.375, 0.041666666666667
70907, 1.2416666666667, 1.375, 0.083333333333333
70908, 1.2833333333333, 1.375, 0.083333333333333
70909, 1.325, 1.375, 0.083333333333333
70910, 1.3666666666667, 1.375, 0.083333333333333
70911, 1.4083333333333, 1.375, 0.083333333333333
70912, 1.45, 1.375, 0.083333333333333
70913, 1.4916666666667, 1.375, 0.083333333333333
70914, 1.5333333333333, 1.375, 0.083333333333333
70915, 1.575, 1.375, 0.083333333333333
70916, 1.6166666666667, 1.375, 0.083333333333333
70917, 1.6583333333333, 1.375, 0.083333333333333
70918, 1.7, 1.375, 0.083333333333333
70919, 1.7416666666667, 1.375, 0.083333333333333
70920, 1.7833333333333, 1.375, 0.083333333333333
70921, 1.825, 1.375, 0.083333333333333
70922, 1.8666666666667, 1.375, 0.083333333333333
70923, 1.9083333333333, 1.375, 0.083333333333333
70924, 1.95, 1.375, 0.083333333333333
70925, 1.9916666666667, 1.375, 0.083333333333333
70926, 2.0333333333333, 1.375, 0.083333333333333
70927, 2.075, 1.375, 0.083333333333333
70928, 2.1166666666667, 1.375, 0.083333333333333
70929, 2.1583333333333, 1.375, 0.083333333333333
70930, 1.2416666666667, 1.375, 0.125
70931, 1.2833333333333, 1.375, 0.125
70932, 1.325, 1.375, 0.125
70933, 1.3666666666667, 1.375, 0.125
70934, 1.4083333333333, 1.375, 0.125
70935, 1.45, 1.375, 0.125
70936, 1.4916666666667, 1.375, 0.125
70937, 1.5333333333333, 1.375, 0.125
70938, 1.575, 1.375, 0.125
70939, 1.6166666666667, 1.375, 0.125
70940, 1.6583333333333, 1.375, 0.125
70941, 1.7, 1.375, 0.125
70942, 1.7416666666667, 1.375, 0.125
70943, 1.7833333333333, 1.375, 0.125
70944, 1.825, 1.375, 0.125
70945, 1.8666666666667, 1.375, 0.125
70946, 1.9083333333333, 1.375, 0.125
70947, 1.95, 1.375, 0.125
70948, 1.9916666666667, 1.375, 0.125
70949, 2.0333333333333, 1.375, 0.125
70950, 2.075, 1.375, 0.125
70951, 2.1166666666667, 1.375, 0.125
70952, 2.1583333333333, 1.375, 0.125
70953, 1.2416666666667, 1.375, 0.16666666666667
70954, 1.2833333333333, 1.375, 0.16666666666667
70955, 1.325, 1.375, 0.16666666666667
70956, 1.3666666666667, 1.375, 0.16666666666667
70957, 1.4083333333333, 1.375, 0.16666666666667
70958, 1.45, 1.375, 0.16666666666667
70959, 1.4916666666667, 1.375, 0.16666666666667
70960, 1.5333333333333, 1.375, 0.16666666666667
70961, 1.575, 1.375, 0.16666666666667
70962, 1.6166666666667, 1.375, 0.16666666666667
70963, 1.6583333333333, 1.375, 0.16666666666667
70964, 1.7, 1.375, 0.16666666666667
70965, 1.7416666666667, 1.375, 0.16666666666667
70966, 1.7833333333333, 1.375, 0.16666666666667
70967, 1.825, 1.375, 0.16666666666667
70968, 1.8666666666667, 1.375, 0.16666666666667
70969, 1.9083333333333, 1.375, 0.16666666666667
70970, 1.95, 1.375, 0.16666666666667
70971, 1.9916666666667, 1.375, 0.16666666666667
70972, 2.0333333333333, 1.375, 0.16666666666667
70973, 2.075, 1.375, 0.16666666666667
70974, 2.1166666666667, 1.375, 0.16666666666667
70975, 2.1583333333333, 1.375, 0.16666666666667
70976, 1.2416666666667, 1.375, 0.20833333333333
70977, 1.2833333333333, 1.375, 0.20833333333333
70978, 1.325, 1.375, 0.20833333333333
70979, 1.3666666666667, 1.375, 0.20833333333333
70980, 1.4083333333333, 1.375, 0.20833333333333
70981, 1.45, 1.375, 0.20833333333333
70982, 1.4916666666667, 1.375, 0.20833333333333
70983, 1.5333333333333, 1.375, 0.20833333333333
70984, 1.575, 1.375, 0.20833333333333
70985, 1.6166666666667, 1.375, 0.20833333333333
70986, 1.6583333333333, 1.375, 0.20833333333333
70987, 1.7, 1.375, 0.20833333333333
70988, 1.7416666666667, 1.375, 0.20833333333333
70989, 1.7833333333333, 1.375, 0.20833333333333
70990, 1.825, 1.375, 0.20833333333333
70991, 1.8666666666667, 1.375, 0.20833333333333
70992, 1.9083333333333, 1.375, 0.20833333333333
70993, 1.95, 1.375, 0.20833333333333
70994, 1.9916666666667, 1.375, 0.20833333333333
70995, 2.0333333333333, 1.375, 0.20833333333333
70996, 2.075, 1.375, 0.20833333333333
70997, 2.1166666666667, 1.375, 0.20833333333333
70998, 2.1583333333333, 1.375, 0.20833333333333
70999, 1.2416666666667, 1.375, 0.25
71000, 1.2833333333333, 1.375, 0.25
71001, 1.325, 1.375, 0.25
71002, 1.3666666666667, 1.375, 0.25
71003, 1.4083333333333, 1.375, 0.25
71004, 1.45, 1.375, 0.25
71005, 1.4916666666667, 1.375, 0.25
71006, 1.5333333333333, 1.375, 0.25
71007, 1.575, 1.375, 0.25
71008, 1.6166666666667, 1.375, 0.25
71009, 1.6583333333333, 1.375, 0.25
71010, 1.7, 1.375, 0.25
71011, 1.7416666666667, 1.375, 0.25
71012, 1.7833333333333, 1.375, 0.25
71013, 1.825, 1.375, 0.25
71014, 1.8666666666667, 1.375, 0.25
71015, 1.9083333333333, 1.375, 0.25
71016, 1.95, 1.375, 0.25
71017, 1.9916666666667, 1.375, 0.25
71018, 2.0333333333333, 1.375, 0.25
71019, 2.075, 1.375, 0.25
71020, 2.1166666666667, 1.375, 0.25
71021, 2.1583333333333, 1.375, 0.25
71022, 1.2416666666667, 1.375, 0.29166666666667
71023, 1.2833333333333, 1.375, 0.29166666666667
71024, 1.325, 1.375, 0.29166666666667
71025, 1.3666666666667, 1.375, 0.29166666666667
71026, 1.4083333333333, 1.375, 0.29166666666667
71027, 1.45, 1.375, 0.29166666666667
71028, 1.4916666666667, 1.375, 0.29166666666667
71029, 1.5333333333333, 1.375, 0.29166666666667
71030, 1.575, 1.375, 0.29166666666667
71031, 1.6166666666667, 1.375, 0.29166666666667
71032, 1.6583333333333, 1.375, 0.29166666666667
71033, 1.7, 1.375, 0.29166666666667
71034, 1.7416666666667, 1.375, 0.29166666666667
71035, 1.7833333333333, 1.375, 0.29166666666667
71036, 1.825, 1.375, 0.29166666666667
71037, 1.8666666666667, 1.375, 0.29166666666667
71038, 1.9083333333333, 1.375, 0.29166666666667
71039, 1.95, 1.375, 0.29166666666667
71040, 1.9916666666667, 1.375, 0.29166666666667
71041, 2.0333333333333, 1.375, 0.29166666666667
71042, 2.075, 1.375, 0.29166666666667
71043, 2.1166666666667, 1.375, 0.29166666666667
71044, 2.1583333333333, 1.375, 0.29166666666667
71045, 1.2416666666667, 1.375, 0.33333333333333
71046, 1.2833333333333, 1.375, 0.33333333333333
71047, 1.325, 1.375, 0.33333333333333
71048, 1.3666666666667, 1.375, 0.33333333333333
71049, 1.4083333333333, 1.375, 0.33333333333333
71050, 1.45, 1.375, 0.33333333333333
71051, 1.4916666666667, 1.375, 0.33333333333333
71052, 1.5333333333333, 1.375, 0.33333333333333
71053, 1.575, 1.375, 0.33333333333333
71054, 1.6166666666667, 1.375, 0.33333333333333
71055, 1.6583333333333, 1.375, 0.33333333333333
71056, 1.7, 1.375, 0.33333333333333
71057, 1.7416666666667, 1.375, 0.33333333333333
71058, 1.7833333333333, 1.375, 0.33333333333333
71059, 1.825, 1.375, 0.33333333333333
71060, 1.8666666666667, 1.375, 0.33333333333333
71061, 1.9083333333333, 1.375, 0.33333333333333
71062, 1.95, 1.375, 0.33333333333333
71063, 1.9916666666667, 1.375, 0.33333333333333
71064, 2.0333333333333, 1.375, 0.33333333333333
71065, 2.075, 1.375, 0.33333333333333
71066, 2.1166666666667, 1.375, 0.33333333333333
71067, 2.1583333333333, 1.375, 0.33333333333333
71068, 1.2416666666667, 1.375, 0.375
71069, 1.2833333333333, 1.375, 0.375
71070, 1.325, 1.375, 0.375
71071, 1.3666666666667, 1.375, 0.375
71072, 1.4083333333333, 1.375, 0.375
71073, 1.45, 1.375, 0.375
71074, 1.4916666666667, 1.375, 0.375
71075, 1.5333333333333, 1.375, 0.375
71076, 1.575, 1.375, 0.375
71077, 1.6166666666667, 1.375, 0.375
71078, 1.6583333333333, 1.375, 0.375
71079, 1.7, 1.375, 0.375
71080, 1.7416666666667, 1.375, 0.375
71081, 1.7833333333333, 1.375, 0.375
71082, 1.825, 1.375, 0.375
71083, 1.8666666666667, 1.375, 0.375
71084, 1.9083333333333, 1.375, 0.375
71085, 1.95, 1.375, 0.375
71086, 1.9916666666667, 1.375, 0.375
71087, 2.0333333333333, 1.375, 0.375
71088, 2.075, 1.375, 0.375
71089, 2.1166666666667, 1.375, 0.375
71090, 2.1583333333333, 1.375, 0.375
71091, 1.2416666666667, 1.375, 0.41666666666667
71092, 1.2833333333333, 1.375, 0.41666666666667
71093, 1.325, 1.375, 0.41666666666667
71094, 1.3666666666667, 1.375, 0.41666666666667
71095, 1.4083333333333, 1.375, 0.41666666666667
71096, 1.45, 1.375, 0.41666666666667
71097, 1.4916666666667, 1.375, 0.41666666666667
71098, 1.5333333333333, 1.375, 0.41666666666667
71099, 1.575, 1.375, 0.41666666666667
71100, 1.6166666666667, 1.375, 0.41666666666667
71101, 1.6583333333333, 1.375, 0.41666666666667
71102, 1.7, 1.375, 0.41666666666667
71103, 1.7416666666667, 1.375, 0.41666666666667
71104, 1.7833333333333, 1.375, 0.41666666666667
71105, 1.825, 1.375, 0.41666666666667
71106, 1.8666666666667, 1.375, 0.41666666666667
71107, 1.9083333333333, 1.375, 0.41666666666667
71108, 1.95, 1.375, 0.41666666666667
71109, 1.9916666666667, 1.375, 0.41666666666667
71110, 2.0333333333333, 1.375, 0.41666666666667
71111, 2.075, 1.375, 0.41666666666667
71112, 2.1166666666667, 1.375, 0.41666666666667
71113, 2.1583333333333, 1.375, 0.41666666666667
71114, 1.2416666666667, 1.375, 0.45833333333333
71115, 1.2833333333333, 1.375, 0.45833333333333
71116, 1.325, 1.375, 0.45833333333333
71117, 1.3666666666667, 1.375, 0.45833333333333
71118, 1.4083333333333, 1.375, 0.45833333333333
71119, 1.45, 1.375, 0.45833333333333
71120, 1.4916666666667, 1.375, 0.45833333333333
71121, 1.5333333333333, 1.375, 0.45833333333333
71122, 1.575, 1.375, 0.45833333333333
71123, 1.6166666666667, 1.375, 0.45833333333333
71124, 1.6583333333333, 1.375, 0.45833333333333
71125, 1.7, 1.375, 0.45833333333333
71126, 1.7416666666667, 1.375, 0.45833333333333
71127, 1.7833333333333, 1.375, 0.45833333333333
71128, 1.825, 1.375, 0.45833333333333
71129, 1.8666666666667, 1.375, 0.45833333333333
71130, 1.9083333333333, 1.375, 0.45833333333333
71131, 1.95, 1.375, 0.45833333333333
71132, 1.9916666666667, 1.375, 0.45833333333333
71133, 2.0333333333333, 1.375, 0.45833333333333
71134, 2.075, 1.375, 0.45833333333333
71135, 2.1166666666667, 1.375, 0.45833333333333
71136, 2.1583333333333, 1.375, 0.45833333333333
71137, 1.2416666666667, 1.3, 0.041666666666667
71138, 1.2416666666667, 1.25, 0.041666666666667
71139, 1.2416666666667, 1.2, 0.041666666666667
71140, 1.2416666666667, 1.15, 0.041666666666667
71141, 1.2416666666667, 1.1, 0.041666666666667
71142, 1.2416666666667, 1.05, 0.041666666666667
71143, 1.2416666666667, 1, 0.041666666666667
71144, 1.2416666666667, 0.95, 0.041666666666667
71145, 1.2416666666667, 0.9, 0.041666666666667
71146, 1.2416666666667, 0.85, 0.041666666666667
71147, 1.2416666666667, 0.8, 0.041666666666667
71148, 1.2416666666667, 0.75, 0.041666666666667
71149, 1.2416666666667, 0.7, 0.041666666666667
71150, 1.2416666666667, 0.65, 0.041666666666667
71151, 1.2416666666667, 0.6, 0.041666666666667
71152, 1.2416666666667, 0.55, 0.041666666666667
71153, 1.2416666666667, 0.5, 0.041666666666667
71154, 1.2416666666667, 0.45, 0.041666666666667
71155, 1.2416666666667, 0.4, 0.041666666666667
71156, 1.2416666666667, 0.35, 0.041666666666667
71157, 1.2416666666667, 0.3, 0.041666666666667
71158, 1.2416666666667, 0.25, 0.041666666666667
71159, 1.2416666666667, 0.2, 0.041666666666667
71160, 1.2833333333333, 1.3, 0.041666666666667
71161, 1.2833333333333, 1.25, 0.041666666666667
71162, 1.2833333333333, 1.2, 0.041666666666667
71163, 1.2833333333333, 1.15, 0.041666666666667
71164, 1.2833333333333, 1.1, 0.041666666666667
71165, 1.2833333333333, 1.05, 0.041666666666667
71166, 1.2833333333333, 1, 0.041666666666667
71167, 1.2833333333333, 0.95, 0.041666666666667
71168, 1.2833333333333, 0.9, 0.041666666666667
71169, 1.2833333333333, 0.85, 0.041666666666667
71170, 1.2833333333333, 0.8, 0.041666666666667
71171, 1.2833333333333, 0.75, 0.041666666666667
71172, 1.2833333333333, 0.7, 0.041666666666667
71173, 1.2833333333333, 0.65, 0.041666666666667
71174, 1.2833333333333, 0.6, 0.041666666666667
71175, 1.2833333333333, 0.55, 0.041666666666667
71176, 1.2833333333333, 0.5, 0.041666666666667
71177, 1.2833333333333, 0.45, 0.041666666666667
71178, 1.2833333333333, 0.4, 0.041666666666667
71179, 1.2833333333333, 0.35, 0.041666666666667
71180, 1.2833333333333, 0.3, 0.041666666666667
71181, 1.2833333333333, 0.25, 0.041666666666667
71182, 1.2833333333333, 0.2, 0.041666666666667
71183, 1.325, 1.3, 0.041666666666667
71184, 1.325, 1.25, 0.041666666666667
71185, 1.325, 1.2, 0.041666666666667
71186, 1.325, 1.15, 0.041666666666667
71187, 1.325, 1.1, 0.041666666666667
71188, 1.325, 1.05, 0.041666666666667
71189, 1.325, 1, 0.041666666666667
71190, 1.325, 0.95, 0.041666666666667
71191, 1.325, 0.9, 0.041666666666667
71192, 1.325, 0.85, 0.041666666666667
71193, 1.325, 0.8, 0.041666666666667
71194, 1.325, 0.75, 0.041666666666667
71195, 1.325, 0.7, 0.041666666666667
71196, 1.325, 0.65, 0.041666666666667
71197, 1.325, 0.6, 0.041666666666667
71198, 1.325, 0.55, 0.041666666666667
71199, 1.325, 0.5, 0.041666666666667
71200, 1.325, 0.45, 0.041666666666667
71201, 1.325, 0.4, 0.041666666666667
71202, 1.325, 0.35, 0.041666666666667
71203, 1.325, 0.3, 0.041666666666667
71204, 1.325, 0.25, 0.041666666666667
71205, 1.325, 0.2, 0.041666666666667
71206, 1.3666666666667, 1.3, 0.041666666666667
71207, 1.3666666666667, 1.25, 0.041666666666667
71208, 1.3666666666667, 1.2, 0.041666666666667
71209, 1.3666666666667, 1.15, 0.041666666666667
71210, 1.3666666666667, 1.1, 0.041666666666667
71211, 1.3666666666667, 1.05, 0.041666666666667
71212, 1.3666666666667, 1, 0.041666666666667
71213, 1.3666666666667, 0.95, 0.041666666666667
71214, 1.3666666666667, 0.9, 0.041666666666667
71215, 1.3666666666667, 0.85, 0.041666666666667
71216, 1.3666666666667, 0.8, 0.041666666666667
71217, 1.3666666666667, 0.75, 0.041666666666667
71218, 1.3666666666667, 0.7, 0.041666666666667
71219, 1.3666666666667, 0.65, 0.041666666666667
71220, 1.3666666666667, 0.6, 0.041666666666667
71221, 1.3666666666667, 0.55, 0.041666666666667
71222, 1.3666666666667, 0.5, 0.041666666666667
71223, 1.3666666666667, 0.45, 0.041666666666667
71224, 1.3666666666667, 0.4, 0.041666666666667
71225, 1.3666666666667, 0.35, 0.041666666666667
71226, 1.3666666666667, 0.3, 0.041666666666667
71227, 1.3666666666667, 0.25, 0.041666666666667
71228, 1.3666666666667, 0.2, 0.041666666666667
71229, 1.4083333333333, 1.3, 0.041666666666667
71230, 1.4083333333333, 1.25, 0.041666666666667
71231, 1.4083333333333, 1.2, 0.041666666666667
71232, 1.4083333333333, 1.15, 0.041666666666667
71233, 1.4083333333333, 1.1, 0.041666666666667
71234, 1.4083333333333, 1.05, 0.041666666666667
71235, 1.4083333333333, 1, 0.041666666666667
71236, 1.4083333333333, 0.95, 0.041666666666667
71237, 1.4083333333333, 0.9, 0.041666666666667
71238, 1.4083333333333, 0.85, 0.041666666666667
71239, 1.4083333333333, 0.8, 0.041666666666667
71240, 1.4083333333333, 0.75, 0.041666666666667
71241, 1.4083333333333, 0.7, 0.041666666666667
71242, 1.4083333333333, 0.65, 0.041666666666667
71243, 1.4083333333333, 0.6, 0.041666666666667
71244, 1.4083333333333, 0.55, 0.041666666666667
71245, 1.4083333333333, 0.5, 0.041666666666667
71246, 1.4083333333333, 0.45, 0.041666666666667
71247, 1.4083333333333, 0.4, 0.041666666666667
71248, 1.4083333333333, 0.35, 0.041666666666667
71249, 1.4083333333333, 0.3, 0.041666666666667
71250, 1.4083333333333, 0.25, 0.041666666666667
71251, 1.4083333333333, 0.2, 0.041666666666667
71252, 1.45, 1.3, 0.041666666666667
71253, 1.45, 1.25, 0.041666666666667
71254, 1.45, 1.2, 0.041666666666667
71255, 1.45, 1.15, 0.041666666666667
71256, 1.45, 1.1, 0.041666666666667
71257, 1.45, 1.05, 0.041666666666667
71258, 1.45, 1, 0.041666666666667
71259, 1.45, 0.95, 0.041666666666667
71260, 1.45, 0.9, 0.041666666666667
71261, 1.45, 0.85, 0.041666666666667
71262, 1.45, 0.8, 0.041666666666667
71263, 1.45, 0.75, 0.041666666666667
71264, 1.45, 0.7, 0.041666666666667
71265, 1.45, 0.65, 0.041666666666667
71266, 1.45, 0.6, 0.041666666666667
71267, 1.45, 0.55, 0.041666666666667
71268, 1.45, 0.5, 0.041666666666667
71269, 1.45, 0.45, 0.041666666666667
71270, 1.45, 0.4, 0.041666666666667
71271, 1.45, 0.35, 0.041666666666667
71272, 1.45, 0.3, 0.041666666666667
71273, 1.45, 0.25, 0.041666666666667
71274, 1.45, 0.2, 0.041666666666667
71275, 1.4916666666667, 1.3, 0.041666666666667
71276, 1.4916666666667, 1.25, 0.041666666666667
71277, 1.4916666666667, 1.2, 0.041666666666667
71278, 1.4916666666667, 1.15, 0.041666666666667
71279, 1.4916666666667, 1.1, 0.041666666666667
71280, 1.4916666666667, 1.05, 0.041666666666667
71281, 1.4916666666667, 1, 0.041666666666667
71282, 1.4916666666667, 0.95, 0.041666666666667
71283, 1.4916666666667, 0.9, 0.041666666666667
71284, 1.4916666666667, 0.85, 0.041666666666667
71285, 1.4916666666667, 0.8, 0.041666666666667
71286, 1.4916666666667, 0.75, 0.041666666666667
71287, 1.4916666666667, 0.7, 0.041666666666667
71288, 1.4916666666667, 0.65, 0.041666666666667
71289, 1.4916666666667, 0.6, 0.041666666666667
71290, 1.4916666666667, 0.55, 0.041666666666667
71291, 1.4916666666667, 0.5, 0.041666666666667
71292, 1.4916666666667, 0.45, 0.041666666666667
71293, 1.4916666666667, 0.4, 0.041666666666667
71294, 1.4916666666667, 0.35, 0.041666666666667
71295, 1.4916666666667, 0.3, 0.041666666666667
71296, 1.4916666666667, 0.25, 0.041666666666667
71297, 1.4916666666667, 0.2, 0.041666666666667
71298, 1.5333333333333, 1.3, 0.041666666666667
71299, 1.5333333333333, 1.25, 0.041666666666667
71300, 1.5333333333333, 1.2, 0.041666666666667
71301, 1.5333333333333, 1.15, 0.041666666666667
71302, 1.5333333333333, 1.1, 0.041666666666667
71303, 1.5333333333333, 1.05, 0.041666666666667
71304, 1.5333333333333, 1, 0.041666666666667
71305, 1.5333333333333, 0.95, 0.041666666666667
71306, 1.5333333333333, 0.9, 0.041666666666667
71307, 1.5333333333333, 0.85, 0.041666666666667
71308, 1.5333333333333, 0.8, 0.041666666666667
71309, 1.5333333333333, 0.75, 0.041666666666667
71310, 1.5333333333333, 0.7, 0.041666666666667
71311, 1.5333333333333, 0.65, 0.041666666666667
71312, 1.5333333333333, 0.6, 0.041666666666667
71313, 1.5333333333333, 0.55, 0.041666666666667
71314, 1.5333333333333, 0.5, 0.041666666666667
71315, 1.5333333333333, 0.45, 0.041666666666667
71316, 1.5333333333333, 0.4, 0.041666666666667
71317, 1.5333333333333, 0.35, 0.041666666666667
71318, 1.5333333333333, 0.3, 0.041666666666667
71319, 1.5333333333333, 0.25, 0.041666666666667
71320, 1.5333333333333, 0.2, 0.041666666666667
71321, 1.575, 1.3, 0.041666666666667
71322, 1.575, 1.25, 0.041666666666667
71323, 1.575, 1.2, 0.041666666666667
71324, 1.575, 1.15, 0.041666666666667
71325, 1.575, 1.1, 0.041666666666667
71326, 1.575, 1.05, 0.041666666666667
71327, 1.575, 1, 0.041666666666667
71328, 1.575, 0.95, 0.041666666666667
71329, 1.575, 0.9, 0.041666666666667
71330, 1.575, 0.85, 0.041666666666667
71331, 1.575, 0.8, 0.041666666666667
71332, 1.575, 0.75, 0.041666666666667
71333, 1.575, 0.7, 0.041666666666667
71334, 1.575, 0.65, 0.041666666666667
71335, 1.575, 0.6, 0.041666666666667
71336, 1.575, 0.55, 0.041666666666667
71337, 1.575, 0.5, 0.041666666666667
71338, 1.575, 0.45, 0.041666666666667
71339, 1.575, 0.4, 0.041666666666667
71340, 1.575, 0.35, 0.041666666666667
71341, 1.575, 0.3, 0.041666666666667
71342, 1.575, 0.25, 0.041666666666667
71343, 1.575, 0.2, 0.041666666666667
71344, 1.6166666666667, 1.3, 0.041666666666667
71345, 1.6166666666667, 1.25, 0.041666666666667
71346, 1.6166666666667, 1.2, 0.041666666666667
71347, 1.6166666666667, 1.15, 0.041666666666667
71348, 1.6166666666667, 1.1, 0.041666666666667
71349, 1.6166666666667, 1.05, 0.041666666666667
71350, 1.6166666666667, 1, 0.041666666666667
71351, 1.6166666666667, 0.95, 0.041666666666667
71352, 1.6166666666667, 0.9, 0.041666666666667
71353, 1.6166666666667, 0.85, 0.041666666666667
71354, 1.6166666666667, 0.8, 0.041666666666667
71355, 1.6166666666667, 0.75, 0.041666666666667
71356, 1.6166666666667, 0.7, 0.041666666666667
71357, 1.6166666666667, 0.65, 0.041666666666667
71358, 1.6166666666667, 0.6, 0.041666666666667
71359, 1.6166666666667, 0.55, 0.041666666666667
71360, 1.6166666666667, 0.5, 0.041666666666667
71361, 1.6166666666667, 0.45, 0.041666666666667
71362, 1.6166666666667, 0.4, 0.041666666666667
71363, 1.6166666666667, 0.35, 0.041666666666667
71364, 1.6166666666667, 0.3, 0.041666666666667
71365, 1.6166666666667, 0.25, 0.041666666666667
71366, 1.6166666666667, 0.2, 0.041666666666667
71367, 1.6583333333333, 1.3, 0.041666666666667
71368, 1.6583333333333, 1.25, 0.041666666666667
71369, 1.6583333333333, 1.2, 0.041666666666667
71370, 1.6583333333333, 1.15, 0.041666666666667
71371, 1.6583333333333, 1.1, 0.041666666666667
71372, 1.6583333333333, 1.05, 0.041666666666667
71373, 1.6583333333333, 1, 0.041666666666667
71374, 1.6583333333333, 0.95, 0.041666666666667
71375, 1.6583333333333, 0.9, 0.041666666666667
71376, 1.6583333333333, 0.85, 0.041666666666667
71377, 1.6583333333333, 0.8, 0.041666666666667
71378, 1.6583333333333, 0.75, 0.041666666666667
71379, 1.6583333333333, 0.7, 0.041666666666667
71380, 1.6583333333333, 0.65, 0.041666666666667
71381, 1.6583333333333, 0.6, 0.041666666666667
71382, 1.6583333333333, 0.55, 0.041666666666667
71383, 1.6583333333333, 0.5, 0.041666666666667
71384, 1.6583333333333, 0.45, 0.041666666666667
71385, 1.6583333333333, 0.4, 0.041666666666667
71386, 1.6583333333333, 0.35, 0.041666666666667
71387, 1.6583333333333, 0.3, 0.041666666666667
71388, 1.6583333333333, 0.25, 0.041666666666667
71389, 1.6583333333333, 0.2, 0.041666666666667
71390, 1.7, 1.3, 0.041666666666667
71391, 1.7, 1.25, 0.041666666666667
71392, 1.7, 1.2, 0.041666666666667
71393, 1.7, 1.15, 0.041666666666667
71394, 1.7, 1.1, 0.041666666666667
71395, 1.7, 1.05, 0.041666666666667
71396, 1.7, 1, 0.041666666666667
71397, 1.7, 0.95, 0.041666666666667
71398, 1.7, 0.9, 0.041666666666667
71399, 1.7, 0.85, 0.041666666666667
71400, 1.7, 0.8, 0.041666666666667
71401, 1.7, 0.75, 0.041666666666667
71402, 1.7, 0.7, 0.041666666666667
71403, 1.7, 0.65, 0.041666666666667
71404, 1.7, 0.6, 0.041666666666667
71405, 1.7, 0.55, 0.041666666666667
71406, 1.7, 0.5, 0.041666666666667
71407, 1.7, 0.45, 0.041666666666667
71408, 1.7, 0.4, 0.041666666666667
71409, 1.7, 0.35, 0.041666666666667
71410, 1.7, 0.3, 0.041666666666667
71411, 1.7, 0.25, 0.041666666666667
71412, 1.7, 0.2, 0.041666666666667
71413, 1.7416666666667, 1.3, 0.041666666666667
71414, 1.7416666666667, 1.25, 0.041666666666667
71415, 1.7416666666667, 1.2, 0.041666666666667
71416, 1.7416666666667, 1.15, 0.041666666666667
71417, 1.7416666666667, 1.1, 0.041666666666667
71418, 1.7416666666667, 1.05, 0.041666666666667
71419, 1.7416666666667, 1, 0.041666666666667
71420, 1.7416666666667, 0.95, 0.041666666666667
71421, 1.7416666666667, 0.9, 0.041666666666667
71422, 1.7416666666667, 0.85, 0.041666666666667
71423, 1.7416666666667, 0.8, 0.041666666666667
71424, 1.7416666666667, 0.75, 0.041666666666667
71425, 1.7416666666667, 0.7, 0.041666666666667
71426, 1.7416666666667, 0.65, 0.041666666666667
71427, 1.7416666666667, 0.6, 0.041666666666667
71428, 1.7416666666667, 0.55, 0.041666666666667
71429, 1.7416666666667, 0.5, 0.041666666666667
71430, 1.7416666666667, 0.45, 0.041666666666667
71431, 1.7416666666667, 0.4, 0.041666666666667
71432, 1.7416666666667, 0.35, 0.041666666666667
71433, 1.7416666666667, 0.3, 0.041666666666667
71434, 1.7416666666667, 0.25, 0.041666666666667
71435, 1.7416666666667, 0.2, 0.041666666666667
71436, 1.7833333333333, 1.3, 0.041666666666667
71437, 1.7833333333333, 1.25, 0.041666666666667
71438, 1.7833333333333, 1.2, 0.041666666666667
71439, 1.7833333333333, 1.15, 0.041666666666667
71440, 1.7833333333333, 1.1, 0.041666666666667
71441, 1.7833333333333, 1.05, 0.041666666666667
71442, 1.7833333333333, 1, 0.041666666666667
71443, 1.7833333333333, 0.95, 0.041666666666667
71444, 1.7833333333333, 0.9, 0.041666666666667
71445, 1.7833333333333, 0.85, 0.041666666666667
71446, 1.7833333333333, 0.8, 0.041666666666667
71447, 1.7833333333333, 0.75, 0.041666666666667
71448, 1.7833333333333, 0.7, 0.041666666666667
71449, 1.7833333333333, 0.65, 0.041666666666667
71450, 1.7833333333333, 0.6, 0.041666666666667
71451, 1.7833333333333, 0.55, 0.041666666666667
71452, 1.7833333333333, 0.5, 0.041666666666667
71453, 1.7833333333333, 0.45, 0.041666666666667
71454, 1.7833333333333, 0.4, 0.041666666666667
71455, 1.7833333333333, 0.35, 0.041666666666667
71456, 1.7833333333333, 0.3, 0.041666666666667
71457, 1.7833333333333, 0.25, 0.041666666666667
71458, 1.7833333333333, 0.2, 0.041666666666667
71459, 1.825, 1.3, 0.041666666666667
71460, 1.825, 1.25, 0.041666666666667
71461, 1.825, 1.2, 0.041666666666667
71462, 1.825, 1.15, 0.041666666666667
71463, 1.825, 1.1, 0.041666666666667
71464, 1.825, 1.05, 0.041666666666667
71465, 1.825, 1, 0.041666666666667
71466, 1.825, 0.95, 0.041666666666667
71467, 1.825, 0.9, 0.041666666666667
71468, 1.825, 0.85, 0.041666666666667
71469, 1.825, 0.8, 0.041666666666667
71470, 1.825, 0.75, 0.041666666666667
71471, 1.825, 0.7, 0.041666666666667
71472, 1.825, 0.65, 0.041666666666667
71473, 1.825, 0.6, 0.041666666666667
71474, 1.825, 0.55, 0.041666666666667
71475, 1.825, 0.5, 0.041666666666667
71476, 1.825, 0.45, 0.041666666666667
71477, 1.825, 0.4, 0.041666666666667
71478, 1.825, 0.35, 0.041666666666667
71479, 1.825, 0.3, 0.041666666666667
71480, 1.825, 0.25, 0.041666666666667
71481, 1.825, 0.2, 0.041666666666667
71482, 1.8666666666667, 1.3, 0.041666666666667
71483, 1.8666666666667, 1.25, 0.041666666666667
71484, 1.8666666666667, 1.2, 0.041666666666667
71485, 1.8666666666667, 1.15, 0.041666666666667
71486, 1.8666666666667, 1.1, 0.041666666666667
71487, 1.8666666666667, 1.05, 0.041666666666667
71488, 1.8666666666667, 1, 0.041666666666667
71489, 1.8666666666667, 0.95, 0.041666666666667
71490, 1.8666666666667, 0.9, 0.041666666666667
71491, 1.8666666666667, 0.85, 0.041666666666667
71492, 1.8666666666667, 0.8, 0.041666666666667
71493, 1.8666666666667, 0.75, 0.041666666666667
71494, 1.8666666666667, 0.7, 0.041666666666667
71495, 1.8666666666667, 0.65, 0.041666666666667
71496, 1.8666666666667, 0.6, 0.041666666666667
71497, 1.8666666666667, 0.55, 0.041666666666667
71498, 1.8666666666667, 0.5, 0.041666666666667
71499, 1.8666666666667, 0.45, 0.041666666666667
71500, 1.8666666666667, 0.4, 0.041666666666667
71501, 1.8666666666667, 0.35, 0.041666666666667
71502, 1.8666666666667, 0.3, 0.041666666666667
71503, 1.8666666666667, 0.25, 0.041666666666667
71504, 1.8666666666667, 0.2, 0.041666666666667
71505, 1.9083333333333, 1.3, 0.041666666666667
71506, 1.9083333333333, 1.25, 0.041666666666667
71507, 1.9083333333333, 1.2, 0.041666666666667
71508, 1.9083333333333, 1.15, 0.041666666666667
71509, 1.9083333333333, 1.1, 0.041666666666667
71510, 1.9083333333333, 1.05, 0.041666666666667
71511, 1.9083333333333, 1, 0.041666666666667
71512, 1.9083333333333, 0.95, 0.041666666666667
71513, 1.9083333333333, 0.9, 0.041666666666667
71514, 1.9083333333333, 0.85, 0.041666666666667
71515, 1.9083333333333, 0.8, 0.041666666666667
71516, 1.9083333333333, 0.75, 0.041666666666667
71517, 1.9083333333333, 0.7, 0.041666666666667
71518, 1.9083333333333, 0.65, 0.041666666666667
71519, 1.9083333333333, 0.6, 0.041666666666667
71520, 1.9083333333333, 0.55, 0.041666666666667
71521, 1.9083333333333, 0.5, 0.041666666666667
71522, 1.9083333333333, 0.45, 0.041666666666667
71523, 1.9083333333333, 0.4, 0.041666666666667
71524, 1.9083333333333, 0.35, 0.041666666666667
71525, 1.9083333333333, 0.3, 0.041666666666667
71526, 1.9083333333333, 0.25, 0.041666666666667
71527, 1.9083333333333, 0.2, 0.041666666666667
71528, 1.95, 1.3, 0.041666666666667
71529, 1.95, 1.25, 0.041666666666667
71530, 1.95, 1.2, 0.041666666666667
71531, 1.95, 1.15, 0.041666666666667
71532, 1.95, 1.1, 0.041666666666667
71533, 1.95, 1.05, 0.041666666666667
71534, 1.95, 1, 0.041666666666667
71535, 1.95, 0.95, 0.041666666666667
71536, 1.95, 0.9, 0.041666666666667
71537, 1.95, 0.85, 0.041666666666667
71538, 1.95, 0.8, 0.041666666666667
71539, 1.95, 0.75, 0.041666666666667
71540, 1.95, 0.7, 0.041666666666667
71541, 1.95, 0.65, 0.041666666666667
71542, 1.95, 0.6, 0.041666666666667
71543, 1.95, 0.55, 0.041666666666667
71544, 1.95, 0.5, 0.041666666666667
71545, 1.95, 0.45, 0.041666666666667
71546, 1.95, 0.4, 0.041666666666667
71547, 1.95, 0.35, 0.041666666666667
71548, 1.95, 0.3, 0.041666666666667
71549, 1.95, 0.25, 0.041666666666667
71550, 1.95, 0.2, 0.041666666666667
71551, 1.9916666666667, 1.3, 0.041666666666667
71552, 1.9916666666667, 1.25, 0.041666666666667
71553, 1.9916666666667, 1.2, 0.041666666666667
71554, 1.9916666666667, 1.15, 0.041666666666667
71555, 1.9916666666667, 1.1, 0.041666666666667
71556, 1.9916666666667, 1.05, 0.041666666666667
71557, 1.9916666666667, 1, 0.041666666666667
71558, 1.9916666666667, 0.95, 0.041666666666667
71559, 1.9916666666667, 0.9, 0.041666666666667
71560, 1.9916666666667, 0.85, 0.041666666666667
71561, 1.9916666666667, 0.8, 0.041666666666667
71562, 1.9916666666667, 0.75, 0.041666666666667
71563, 1.9916666666667, 0.7, 0.041666666666667
71564, 1.9916666666667, 0.65, 0.041666666666667
71565, 1.9916666666667, 0.6, 0.041666666666667
71566, 1.9916666666667, 0.55, 0.041666666666667
71567, 1.9916666666667, 0.5, 0.041666666666667
71568, 1.9916666666667, 0.45, 0.041666666666667
71569, 1.9916666666667, 0.4, 0.041666666666667
71570, 1.9916666666667, 0.35, 0.041666666666667
71571, 1.9916666666667, 0.3, 0.041666666666667
71572, 1.9916666666667, 0.25, 0.041666666666667
71573, 1.9916666666667, 0.2, 0.041666666666667
71574, 2.0333333333333, 1.3, 0.041666666666667
71575, 2.0333333333333, 1.25, 0.041666666666667
71576, 2.0333333333333, 1.2, 0.041666666666667
71577, 2.0333333333333, 1.15, 0.041666666666667
71578, 2.0333333333333, 1.1, 0.041666666666667
71579, 2.0333333333333, 1.05, 0.041666666666667
71580, 2.0333333333333, 1, 0.041666666666667
71581, 2.0333333333333, 0.95, 0.041666666666667
71582, 2.0333333333333, 0.9, 0.041666666666667
71583, 2.0333333333333, 0.85, 0.041666666666667
71584, 2.0333333333333, 0.8, 0.041666666666667
71585, 2.0333333333333, 0.75, 0.041666666666667
71586, 2.0333333333333, 0.7, 0.041666666666667
71587, 2.0333333333333, 0.65, 0.041666666666667
71588, 2.0333333333333, 0.6, 0.041666666666667
71589, 2.0333333333333, 0.55, 0.041666666666667
71590, 2.0333333333333, 0.5, 0.041666666666667
71591, 2.0333333333333, 0.45, 0.041666666666667
71592, 2.0333333333333, 0.4, 0.041666666666667
71593, 2.0333333333333, 0.35, 0.041666666666667
71594, 2.0333333333333, 0.3, 0.041666666666667
71595, 2.0333333333333, 0.25, 0.041666666666667
71596, 2.0333333333333, 0.2, 0.041666666666667
71597, 2.075, 1.3, 0.041666666666667
71598, 2.075, 1.25, 0.041666666666667
71599, 2.075, 1.2, 0.041666666666667
71600, 2.075, 1.15, 0.041666666666667
71601, 2.075, 1.1, 0.041666666666667
71602, 2.075, 1.05, 0.041666666666667
71603, 2.075, 1, 0.041666666666667
71604, 2.075, 0.95, 0.041666666666667
71605, 2.075, 0.9, 0.041666666666667
71606, 2.075, 0.85, 0.041666666666667
71607, 2.075, 0.8, 0.041666666666667
71608, 2.075, 0.75, 0.041666666666667
71609, 2.075, 0.7, 0.041666666666667
71610, 2.075, 0.65, 0.041666666666667
71611, 2.075, 0.6, 0.041666666666667
71612, 2.075, 0.55, 0.041666666666667
71613, 2.075, 0.5, 0.041666666666667
71614, 2.075, 0.45, 0.041666666666667
71615, 2.075, 0.4, 0.041666666666667
71616, 2.075, 0.35, 0.041666666666667
71617, 2.075, 0.3, 0.041666666666667
71618, 2.075, 0.25, 0.041666666666667
71619, 2.075, 0.2, 0.041666666666667
71620, 2.1166666666667, 1.3, 0.041666666666667
71621, 2.1166666666667, 1.25, 0.041666666666667
71622, 2.1166666666667, 1.2, 0.041666666666667
71623, 2.1166666666667, 1.15, 0.041666666666667
71624, 2.1166666666667, 1.1, 0.041666666666667
71625, 2.1166666666667, 1.05, 0.041666666666667
71626, 2.1166666666667, 1, 0.041666666666667
71627, 2.1166666666667, 0.95, 0.041666666666667
71628, 2.1166666666667, 0.9, 0.041666666666667
71629, 2.1166666666667, 0.85, 0.041666666666667
71630, 2.1166666666667, 0.8, 0.041666666666667
71631, 2.1166666666667, 0.75, 0.041666666666667
71632, 2.1166666666667, 0.7, 0.041666666666667
71633, 2.1166666666667, 0.65, 0.041666666666667
71634, 2.1166666666667, 0.6, 0.041666666666667
71635, 2.1166666666667, 0.55, 0.041666666666667
71636, 2.1166666666667, 0.5, 0.041666666666667
71637, 2.1166666666667, 0.45, 0.041666666666667
71638, 2.1166666666667, 0.4, 0.041666666666667
71639, 2.1166666666667, 0.35, 0.041666666666667
71640, 2.1166666666667, 0.3, 0.041666666666667
71641, 2.1166666666667, 0.25, 0.041666666666667
71642, 2.1166666666667, 0.2, 0.041666666666667
71643, 2.1583333333333, 1.3, 0.041666666666667
71644, 2.1583333333333, 1.25, 0.041666666666667
71645, 2.1583333333333, 1.2, 0.041666666666667
71646, 2.1583333333333, 1.15, 0.041666666666667
71647, 2.1583333333333, 1.1, 0.041666666666667
71648, 2.1583333333333, 1.05, 0.041666666666667
71649, 2.1583333333333, 1, 0.041666666666667
71650, 2.1583333333333, 0.95, 0.041666666666667
71651, 2.1583333333333, 0.9, 0.041666666666667
71652, 2.1583333333333, 0.85, 0.041666666666667
71653, 2.1583333333333, 0.8, 0.041666666666667
71654, 2.1583333333333, 0.75, 0.041666666666667
71655, 2.1583333333333, 0.7, 0.041666666666667
71656, 2.1583333333333, 0.65, 0.041666666666667
71657, 2.1583333333333, 0.6, 0.041666666666667
71658, 2.1583333333333, 0.55, 0.041666666666667
71659, 2.1583333333333, 0.5, 0.041666666666667
71660, 2.1583333333333, 0.45, 0.041666666666667
71661, 2.1583333333333, 0.4, 0.041666666666667
71662, 2.1583333333333, 0.35, 0.041666666666667
71663, 2.1583333333333, 0.3, 0.041666666666667
71664, 2.1583333333333, 0.25, 0.041666666666667
71665, 2.1583333333333, 0.2, 0.041666666666667
71666, 1.2416666666667, 1.3, 0.083333333333333
71667, 1.2416666666667, 1.25, 0.083333333333333
71668, 1.2416666666667, 1.2, 0.083333333333333
71669, 1.2416666666667, 1.15, 0.083333333333333
71670, 1.2416666666667, 1.1, 0.083333333333333
71671, 1.2416666666667, 1.05, 0.083333333333333
71672, 1.2416666666667, 1, 0.083333333333333
71673, 1.2416666666667, 0.95, 0.083333333333333
71674, 1.2416666666667, 0.9, 0.083333333333333
71675, 1.2416666666667, 0.85, 0.083333333333333
71676, 1.2416666666667, 0.8, 0.083333333333333
71677, 1.2416666666667, 0.75, 0.083333333333333
71678, 1.2416666666667, 0.7, 0.083333333333333
71679, 1.2416666666667, 0.65, 0.083333333333333
71680, 1.2416666666667, 0.6, 0.083333333333333
71681, 1.2416666666667, 0.55, 0.083333333333333
71682, 1.2416666666667, 0.5, 0.083333333333333
71683, 1.2416666666667, 0.45, 0.083333333333333
71684, 1.2416666666667, 0.4, 0.083333333333333
71685, 1.2416666666667, 0.35, 0.083333333333333
71686, 1.2416666666667, 0.3, 0.083333333333333
71687, 1.2416666666667, 0.25, 0.083333333333333
71688, 1.2416666666667, 0.2, 0.083333333333333
71689, 1.2833333333333, 1.3, 0.083333333333333
71690, 1.2833333333333, 1.25, 0.083333333333333
71691, 1.2833333333333, 1.2, 0.083333333333333
71692, 1.2833333333333, 1.15, 0.083333333333333
71693, 1.2833333333333, 1.1, 0.083333333333333
71694, 1.2833333333333, 1.05, 0.083333333333333
71695, 1.2833333333333, 1, 0.083333333333333
71696, 1.2833333333333, 0.95, 0.083333333333333
71697, 1.2833333333333, 0.9, 0.083333333333333
71698, 1.2833333333333, 0.85, 0.083333333333333
71699, 1.2833333333333, 0.8, 0.083333333333333
71700, 1.2833333333333, 0.75, 0.083333333333333
71701, 1.2833333333333, 0.7, 0.083333333333333
71702, 1.2833333333333, 0.65, 0.083333333333333
71703, 1.2833333333333, 0.6, 0.083333333333333
71704, 1.2833333333333, 0.55, 0.083333333333333
71705, 1.2833333333333, 0.5, 0.083333333333333
71706, 1.2833333333333, 0.45, 0.083333333333333
71707, 1.2833333333333, 0.4, 0.083333333333333
71708, 1.2833333333333, 0.35, 0.083333333333333
71709, 1.2833333333333, 0.3, 0.083333333333333
71710, 1.2833333333333, 0.25, 0.083333333333333
71711, 1.2833333333333, 0.2, 0.083333333333333
71712, 1.325, 1.3, 0.083333333333333
71713, 1.325, 1.25, 0.083333333333333
71714, 1.325, 1.2, 0.083333333333333
71715, 1.325, 1.15, 0.083333333333333
71716, 1.325, 1.1, 0.083333333333333
71717, 1.325, 1.05, 0.083333333333333
71718, 1.325, 1, 0.083333333333333
71719, 1.325, 0.95, 0.083333333333333
71720, 1.325, 0.9, 0.083333333333333
71721, 1.325, 0.85, 0.083333333333333
71722, 1.325, 0.8, 0.083333333333333
71723, 1.325, 0.75, 0.083333333333333
71724, 1.325, 0.7, 0.083333333333333
71725, 1.325, 0.65, 0.083333333333333
71726, 1.325, 0.6, 0.083333333333333
71727, 1.325, 0.55, 0.083333333333333
71728, 1.325, 0.5, 0.083333333333333
71729, 1.325, 0.45, 0.083333333333333
71730, 1.325, 0.4, 0.083333333333333
71731, 1.325, 0.35, 0.083333333333333
71732, 1.325, 0.3, 0.083333333333333
71733, 1.325, 0.25, 0.083333333333333
71734, 1.325, 0.2, 0.083333333333333
71735, 1.3666666666667, 1.3, 0.083333333333333
71736, 1.3666666666667, 1.25, 0.083333333333333
71737, 1.3666666666667, 1.2, 0.083333333333333
71738, 1.3666666666667, 1.15, 0.083333333333333
71739, 1.3666666666667, 1.1, 0.083333333333333
71740, 1.3666666666667, 1.05, 0.083333333333333
71741, 1.3666666666667, 1, 0.083333333333333
71742, 1.3666666666667, 0.95, 0.083333333333333
71743, 1.3666666666667, 0.9, 0.083333333333333
71744, 1.3666666666667, 0.85, 0.083333333333333
71745, 1.3666666666667, 0.8, 0.083333333333333
71746, 1.3666666666667, 0.75, 0.083333333333333
71747, 1.3666666666667, 0.7, 0.083333333333333
71748, 1.3666666666667, 0.65, 0.083333333333333
71749, 1.3666666666667, 0.6, 0.083333333333333
71750, 1.3666666666667, 0.55, 0.083333333333333
71751, 1.3666666666667, 0.5, 0.083333333333333
71752, 1.3666666666667, 0.45, 0.083333333333333
71753, 1.3666666666667, 0.4, 0.083333333333333
71754, 1.3666666666667, 0.35, 0.083333333333333
71755, 1.3666666666667, 0.3, 0.083333333333333
71756, 1.3666666666667, 0.25, 0.083333333333333
71757, 1.3666666666667, 0.2, 0.083333333333333
71758, 1.4083333333333, 1.3, 0.083333333333333
71759, 1.4083333333333, 1.25, 0.083333333333333
71760, 1.4083333333333, 1.2, 0.083333333333333
71761, 1.4083333333333, 1.15, 0.083333333333333
71762, 1.4083333333333, 1.1, 0.083333333333333
71763, 1.4083333333333, 1.05, 0.083333333333333
71764, 1.4083333333333, 1, 0.083333333333333
71765, 1.4083333333333, 0.95, 0.083333333333333
71766, 1.4083333333333, 0.9, 0.083333333333333
71767, 1.4083333333333, 0.85, 0.083333333333333
71768, 1.4083333333333, 0.8, 0.083333333333333
71769, 1.4083333333333, 0.75, 0.083333333333333
71770, 1.4083333333333, 0.7, 0.083333333333333
71771, 1.4083333333333, 0.65, 0.083333333333333
71772, 1.4083333333333, 0.6, 0.083333333333333
71773, 1.4083333333333, 0.55, 0.083333333333333
71774, 1.4083333333333, 0.5, 0.083333333333333
71775, 1.4083333333333, 0.45, 0.083333333333333
71776, 1.4083333333333, 0.4, 0.083333333333333
71777, 1.4083333333333, 0.35, 0.083333333333333
71778, 1.4083333333333, 0.3, 0.083333333333333
71779, 1.4083333333333, 0.25, 0.083333333333333
71780, 1.4083333333333, 0.2, 0.083333333333333
71781, 1.45, 1.3, 0.083333333333333
71782, 1.45, 1.25, 0.083333333333333
71783, 1.45, 1.2, 0.083333333333333
71784, 1.45, 1.15, 0.083333333333333
71785, 1.45, 1.1, 0.083333333333333
71786, 1.45, 1.05, 0.083333333333333
71787, 1.45, 1, 0.083333333333333
71788, 1.45, 0.95, 0.083333333333333
71789, 1.45, 0.9, 0.083333333333333
71790, 1.45, 0.85, 0.083333333333333
71791, 1.45, 0.8, 0.083333333333333
71792, 1.45, 0.75, 0.083333333333333
71793, 1.45, 0.7, 0.083333333333333
71794, 1.45, 0.65, 0.083333333333333
71795, 1.45, 0.6, 0.083333333333333
71796, 1.45, 0.55, 0.083333333333333
71797, 1.45, 0.5, 0.083333333333333
71798, 1.45, 0.45, 0.083333333333333
71799, 1.45, 0.4, 0.083333333333333
71800, 1.45, 0.35, 0.083333333333333
71801, 1.45, 0.3, 0.083333333333333
71802, 1.45, 0.25, 0.083333333333333
71803, 1.45, 0.2, 0.083333333333333
71804, 1.4916666666667, 1.3, 0.083333333333333
71805, 1.4916666666667, 1.25, 0.083333333333333
71806, 1.4916666666667, 1.2, 0.083333333333333
71807, 1.4916666666667, 1.15, 0.083333333333333
71808, 1.4916666666667, 1.1, 0.083333333333333
71809, 1.4916666666667, 1.05, 0.083333333333333
71810, 1.4916666666667, 1, 0.083333333333333
71811, 1.4916666666667, 0.95, 0.083333333333333
71812, 1.4916666666667, 0.9, 0.083333333333333
71813, 1.4916666666667, 0.85, 0.083333333333333
71814, 1.4916666666667, 0.8, 0.083333333333333
71815, 1.4916666666667, 0.75, 0.083333333333333
71816, 1.4916666666667, 0.7, 0.083333333333333
71817, 1.4916666666667, 0.65, 0.083333333333333
71818, 1.4916666666667, 0.6, 0.083333333333333
71819, 1.4916666666667, 0.55, 0.083333333333333
71820, 1.4916666666667, 0.5, 0.083333333333333
71821, 1.4916666666667, 0.45, 0.083333333333333
71822, 1.4916666666667, 0.4, 0.083333333333333
71823, 1.4916666666667, 0.35, 0.083333333333333
71824, 1.4916666666667, 0.3, 0.083333333333333
71825, 1.4916666666667, 0.25, 0.083333333333333
71826, 1.4916666666667, 0.2, 0.083333333333333
71827, 1.5333333333333, 1.3, 0.083333333333333
71828, 1.5333333333333, 1.25, 0.083333333333333
71829, 1.5333333333333, 1.2, 0.083333333333333
71830, 1.5333333333333, 1.15, 0.083333333333333
71831, 1.5333333333333, 1.1, 0.083333333333333
71832, 1.5333333333333, 1.05, 0.083333333333333
71833, 1.5333333333333, 1, 0.083333333333333
71834, 1.5333333333333, 0.95, 0.083333333333333
71835, 1.5333333333333, 0.9, 0.083333333333333
71836, 1.5333333333333, 0.85, 0.083333333333333
71837, 1.5333333333333, 0.8, 0.083333333333333
71838, 1.5333333333333, 0.75, 0.083333333333333
71839, 1.5333333333333, 0.7, 0.083333333333333
71840, 1.5333333333333, 0.65, 0.083333333333333
71841, 1.5333333333333, 0.6, 0.083333333333333
71842, 1.5333333333333, 0.55, 0.083333333333333
71843, 1.5333333333333, 0.5, 0.083333333333333
71844, 1.5333333333333, 0.45, 0.083333333333333
71845, 1.5333333333333, 0.4, 0.083333333333333
71846, 1.5333333333333, 0.35, 0.083333333333333
71847, 1.5333333333333, 0.3, 0.083333333333333
71848, 1.5333333333333, 0.25, 0.083333333333333
71849, 1.5333333333333, 0.2, 0.083333333333333
71850, 1.575, 1.3, 0.083333333333333
71851, 1.575, 1.25, 0.083333333333333
71852, 1.575, 1.2, 0.083333333333333
71853, 1.575, 1.15, 0.083333333333333
71854, 1.575, 1.1, 0.083333333333333
71855, 1.575, 1.05, 0.083333333333333
71856, 1.575, 1, 0.083333333333333
71857, 1.575, 0.95, 0.083333333333333
71858, 1.575, 0.9, 0.083333333333333
71859, 1.575, 0.85, 0.083333333333333
71860, 1.575, 0.8, 0.083333333333333
71861, 1.575, 0.75, 0.083333333333333
71862, 1.575, 0.7, 0.083333333333333
71863, 1.575, 0.65, 0.083333333333333
71864, 1.575, 0.6, 0.083333333333333
71865, 1.575, 0.55, 0.083333333333333
71866, 1.575, 0.5, 0.083333333333333
71867, 1.575, 0.45, 0.083333333333333
71868, 1.575, 0.4, 0.083333333333333
71869, 1.575, 0.35, 0.083333333333333
71870, 1.575, 0.3, 0.083333333333333
71871, 1.575, 0.25, 0.083333333333333
71872, 1.575, 0.2, 0.083333333333333
71873, 1.6166666666667, 1.3, 0.083333333333333
71874, 1.6166666666667, 1.25, 0.083333333333333
71875, 1.6166666666667, 1.2, 0.083333333333333
71876, 1.6166666666667, 1.15, 0.083333333333333
71877, 1.6166666666667, 1.1, 0.083333333333333
71878, 1.6166666666667, 1.05, 0.083333333333333
71879, 1.6166666666667, 1, 0.083333333333333
71880, 1.6166666666667, 0.95, 0.083333333333333
71881, 1.6166666666667, 0.9, 0.083333333333333
71882, 1.6166666666667, 0.85, 0.083333333333333
71883, 1.6166666666667, 0.8, 0.083333333333333
71884, 1.6166666666667, 0.75, 0.083333333333333
71885, 1.6166666666667, 0.7, 0.083333333333333
71886, 1.6166666666667, 0.65, 0.083333333333333
71887, 1.6166666666667, 0.6, 0.083333333333333
71888, 1.6166666666667, 0.55, 0.083333333333333
71889, 1.6166666666667, 0.5, 0.083333333333333
71890, 1.6166666666667, 0.45, 0.083333333333333
71891, 1.6166666666667, 0.4, 0.083333333333333
71892, 1.6166666666667, 0.35, 0.083333333333333
71893, 1.6166666666667, 0.3, 0.083333333333333
71894, 1.6166666666667, 0.25, 0.083333333333333
71895, 1.6166666666667, 0.2, 0.083333333333333
71896, 1.6583333333333, 1.3, 0.083333333333333
71897, 1.6583333333333, 1.25, 0.083333333333333
71898, 1.6583333333333, 1.2, 0.083333333333333
71899, 1.6583333333333, 1.15, 0.083333333333333
71900, 1.6583333333333, 1.1, 0.083333333333333
71901, 1.6583333333333, 1.05, 0.083333333333333
71902, 1.6583333333333, 1, 0.083333333333333
71903, 1.6583333333333, 0.95, 0.083333333333333
71904, 1.6583333333333, 0.9, 0.083333333333333
71905, 1.6583333333333, 0.85, 0.083333333333333
71906, 1.6583333333333, 0.8, 0.083333333333333
71907, 1.6583333333333, 0.75, 0.083333333333333
71908, 1.6583333333333, 0.7, 0.083333333333333
71909, 1.6583333333333, 0.65, 0.083333333333333
71910, 1.6583333333333, 0.6, 0.083333333333333
71911, 1.6583333333333, 0.55, 0.083333333333333
71912, 1.6583333333333, 0.5, 0.083333333333333
71913, 1.6583333333333, 0.45, 0.083333333333333
71914, 1.6583333333333, 0.4, 0.083333333333333
71915, 1.6583333333333, 0.35, 0.083333333333333
71916, 1.6583333333333, 0.3, 0.083333333333333
71917, 1.6583333333333, 0.25, 0.083333333333333
71918, 1.6583333333333, 0.2, 0.083333333333333
71919, 1.7, 1.3, 0.083333333333333
71920, 1.7, 1.25, 0.083333333333333
71921, 1.7, 1.2, 0.083333333333333
71922, 1.7, 1.15, 0.083333333333333
71923, 1.7, 1.1, 0.083333333333333
71924, 1.7, 1.05, 0.083333333333333
71925, 1.7, 1, 0.083333333333333
71926, 1.7, 0.95, 0.083333333333333
71927, 1.7, 0.9, 0.083333333333333
71928, 1.7, 0.85, 0.083333333333333
71929, 1.7, 0.8, 0.083333333333333
71930, 1.7, 0.75, 0.083333333333333
71931, 1.7, 0.7, 0.083333333333333
71932, 1.7, 0.65, 0.083333333333333
71933, 1.7, 0.6, 0.083333333333333
71934, 1.7, 0.55, 0.083333333333333
71935, 1.7, 0.5, 0.083333333333333
71936, 1.7, 0.45, 0.083333333333333
71937, 1.7, 0.4, 0.083333333333333
71938, 1.7, 0.35, 0.083333333333333
71939, 1.7, 0.3, 0.083333333333333
71940, 1.7, 0.25, 0.083333333333333
71941, 1.7, 0.2, 0.083333333333333
71942, 1.7416666666667, 1.3, 0.083333333333333
71943, 1.7416666666667, 1.25, 0.083333333333333
71944, 1.7416666666667, 1.2, 0.083333333333333
71945, 1.7416666666667, 1.15, 0.083333333333333
71946, 1.7416666666667, 1.1, 0.083333333333333
71947, 1.7416666666667, 1.05, 0.083333333333333
71948, 1.7416666666667, 1, 0.083333333333333
71949, 1.7416666666667, 0.95, 0.083333333333333
71950, 1.7416666666667, 0.9, 0.083333333333333
71951, 1.7416666666667, 0.85, 0.083333333333333
71952, 1.7416666666667, 0.8, 0.083333333333333
71953, 1.7416666666667, 0.75, 0.083333333333333
71954, 1.7416666666667, 0.7, 0.083333333333333
71955, 1.7416666666667, 0.65, 0.083333333333333
71956, 1.7416666666667, 0.6, 0.083333333333333
71957, 1.7416666666667, 0.55, 0.083333333333333
71958, 1.7416666666667, 0.5, 0.083333333333333
71959, 1.7416666666667, 0.45, 0.083333333333333
71960, 1.7416666666667, 0.4, 0.083333333333333
71961, 1.7416666666667, 0.35, 0.083333333333333
71962, 1.7416666666667, 0.3, 0.083333333333333
71963, 1.7416666666667, 0.25, 0.083333333333333
71964, 1.7416666666667, 0.2, 0.083333333333333
71965, 1.7833333333333, 1.3, 0.083333333333333
71966, 1.7833333333333, 1.25, 0.083333333333333
71967, 1.7833333333333, 1.2, 0.083333333333333
71968, 1.7833333333333, 1.15, 0.083333333333333
71969, 1.7833333333333, 1.1, 0.083333333333333
71970, 1.7833333333333, 1.05, 0.083333333333333
71971, 1.7833333333333, 1, 0.083333333333333
71972, 1.7833333333333, 0.95, 0.083333333333333
71973, 1.7833333333333, 0.9, 0.083333333333333
71974, 1.7833333333333, 0.85, 0.083333333333333
71975, 1.7833333333333, 0.8, 0.083333333333333
71976, 1.7833333333333, 0.75, 0.083333333333333
71977, 1.7833333333333, 0.7, 0.083333333333333
71978, 1.7833333333333, 0.65, 0.083333333333333
71979, 1.7833333333333, 0.6, 0.083333333333333
71980, 1.7833333333333, 0.55, 0.083333333333333
71981, 1.7833333333333, 0.5, 0.083333333333333
71982, 1.7833333333333, 0.45, 0.083333333333333
71983, 1.7833333333333, 0.4, 0.083333333333333
71984, 1.7833333333333, 0.35, 0.083333333333333
71985, 1.7833333333333, 0.3, 0.083333333333333
71986, 1.7833333333333, 0.25, 0.083333333333333
71987, 1.7833333333333, 0.2, 0.083333333333333
71988, 1.825, 1.3, 0.083333333333333
71989, 1.825, 1.25, 0.083333333333333
71990, 1.825, 1.2, 0.083333333333333
71991, 1.825, 1.15, 0.083333333333333
71992, 1.825, 1.1, 0.083333333333333
71993, 1.825, 1.05, 0.083333333333333
71994, 1.825, 1, 0.083333333333333
71995, 1.825, 0.95, 0.083333333333333
71996, 1.825, 0.9, 0.083333333333333
71997, 1.825, 0.85, 0.083333333333333
71998, 1.825, 0.8, 0.083333333333333
71999, 1.825, 0.75, 0.083333333333333
72000, 1.825, 0.7, 0.083333333333333
72001, 1.825, 0.65, 0.083333333333333
72002, 1.825, 0.6, 0.083333333333333
72003, 1.825, 0.55, 0.083333333333333
72004, 1.825, 0.5, 0.083333333333333
72005, 1.825, 0.45, 0.083333333333333
72006, 1.825, 0.4, 0.083333333333333
72007, 1.825, 0.35, 0.083333333333333
72008, 1.825, 0.3, 0.083333333333333
72009, 1.825, 0.25, 0.083333333333333
72010, 1.825, 0.2, 0.083333333333333
72011, 1.8666666666667, 1.3, 0.083333333333333
72012, 1.8666666666667, 1.25, 0.083333333333333
72013, 1.8666666666667, 1.2, 0.083333333333333
72014, 1.8666666666667, 1.15, 0.083333333333333
72015, 1.8666666666667, 1.1, 0.083333333333333
72016, 1.8666666666667, 1.05, 0.083333333333333
72017, 1.8666666666667, 1, 0.083333333333333
72018, 1.8666666666667, 0.95, 0.083333333333333
72019, 1.8666666666667, 0.9, 0.083333333333333
72020, 1.8666666666667, 0.85, 0.083333333333333
72021, 1.8666666666667, 0.8, 0.083333333333333
72022, 1.8666666666667, 0.75, 0.083333333333333
72023, 1.8666666666667, 0.7, 0.083333333333333
72024, 1.8666666666667, 0.65, 0.083333333333333
72025, 1.8666666666667, 0.6, 0.083333333333333
72026, 1.8666666666667, 0.55, 0.083333333333333
72027, 1.8666666666667, 0.5, 0.083333333333333
72028, 1.8666666666667, 0.45, 0.083333333333333
72029, 1.8666666666667, 0.4, 0.083333333333333
72030, 1.8666666666667, 0.35, 0.083333333333333
72031, 1.8666666666667, 0.3, 0.083333333333333
72032, 1.8666666666667, 0.25, 0.083333333333333
72033, 1.8666666666667, 0.2, 0.083333333333333
72034, 1.9083333333333, 1.3, 0.083333333333333
72035, 1.9083333333333, 1.25, 0.083333333333333
72036, 1.9083333333333, 1.2, 0.083333333333333
72037, 1.9083333333333, 1.15, 0.083333333333333
72038, 1.9083333333333, 1.1, 0.083333333333333
72039, 1.9083333333333, 1.05, 0.083333333333333
72040, 1.9083333333333, 1, 0.083333333333333
72041, 1.9083333333333, 0.95, 0.083333333333333
72042, 1.9083333333333, 0.9, 0.083333333333333
72043, 1.9083333333333, 0.85, 0.083333333333333
72044, 1.9083333333333, 0.8, 0.083333333333333
72045, 1.9083333333333, 0.75, 0.083333333333333
72046, 1.9083333333333, 0.7, 0.083333333333333
72047, 1.9083333333333, 0.65, 0.083333333333333
72048, 1.9083333333333, 0.6, 0.083333333333333
72049, 1.9083333333333, 0.55, 0.083333333333333
72050, 1.9083333333333, 0.5, 0.083333333333333
72051, 1.9083333333333, 0.45, 0.083333333333333
72052, 1.9083333333333, 0.4, 0.083333333333333
72053, 1.9083333333333, 0.35, 0.083333333333333
72054, 1.9083333333333, 0.3, 0.083333333333333
72055, 1.9083333333333, 0.25, 0.083333333333333
72056, 1.9083333333333, 0.2, 0.083333333333333
72057, 1.95, 1.3, 0.083333333333333
72058, 1.95, 1.25, 0.083333333333333
72059, 1.95, 1.2, 0.083333333333333
72060, 1.95, 1.15, 0.083333333333333
72061, 1.95, 1.1, 0.083333333333333
72062, 1.95, 1.05, 0.083333333333333
72063, 1.95, 1, 0.083333333333333
72064, 1.95, 0.95, 0.083333333333333
72065, 1.95, 0.9, 0.083333333333333
72066, 1.95, 0.85, 0.083333333333333
72067, 1.95, 0.8, 0.083333333333333
72068, 1.95, 0.75, 0.083333333333333
72069, 1.95, 0.7, 0.083333333333333
72070, 1.95, 0.65, 0.083333333333333
72071, 1.95, 0.6, 0.083333333333333
72072, 1.95, 0.55, 0.083333333333333
72073, 1.95, 0.5, 0.083333333333333
72074, 1.95, 0.45, 0.083333333333333
72075, 1.95, 0.4, 0.083333333333333
72076, 1.95, 0.35, 0.083333333333333
72077, 1.95, 0.3, 0.083333333333333
72078, 1.95, 0.25, 0.083333333333333
72079, 1.95, 0.2, 0.083333333333333
72080, 1.9916666666667, 1.3, 0.083333333333333
72081, 1.9916666666667, 1.25, 0.083333333333333
72082, 1.9916666666667, 1.2, 0.083333333333333
72083, 1.9916666666667, 1.15, 0.083333333333333
72084, 1.9916666666667, 1.1, 0.083333333333333
72085, 1.9916666666667, 1.05, 0.083333333333333
72086, 1.9916666666667, 1, 0.083333333333333
72087, 1.9916666666667, 0.95, 0.083333333333333
72088, 1.9916666666667, 0.9, 0.083333333333333
72089, 1.9916666666667, 0.85, 0.083333333333333
72090, 1.9916666666667, 0.8, 0.083333333333333
72091, 1.9916666666667, 0.75, 0.083333333333333
72092, 1.9916666666667, 0.7, 0.083333333333333
72093, 1.9916666666667, 0.65, 0.083333333333333
72094, 1.9916666666667, 0.6, 0.083333333333333
72095, 1.9916666666667, 0.55, 0.083333333333333
72096, 1.9916666666667, 0.5, 0.083333333333333
72097, 1.9916666666667, 0.45, 0.083333333333333
72098, 1.9916666666667, 0.4, 0.083333333333333
72099, 1.9916666666667, 0.35, 0.083333333333333
72100, 1.9916666666667, 0.3, 0.083333333333333
72101, 1.9916666666667, 0.25, 0.083333333333333
72102, 1.9916666666667, 0.2, 0.083333333333333
72103, 2.0333333333333, 1.3, 0.083333333333333
72104, 2.0333333333333, 1.25, 0.083333333333333
72105, 2.0333333333333, 1.2, 0.083333333333333
72106, 2.0333333333333, 1.15, 0.083333333333333
72107, 2.0333333333333, 1.1, 0.083333333333333
72108, 2.0333333333333, 1.05, 0.083333333333333
72109, 2.0333333333333, 1, 0.083333333333333
72110, 2.0333333333333, 0.95, 0.083333333333333
72111, 2.0333333333333, 0.9, 0.083333333333333
72112, 2.0333333333333, 0.85, 0.083333333333333
72113, 2.0333333333333, 0.8, 0.083333333333333
72114, 2.0333333333333, 0.75, 0.083333333333333
72115, 2.0333333333333, 0.7, 0.083333333333333
72116, 2.0333333333333, 0.65, 0.083333333333333
72117, 2.0333333333333, 0.6, 0.083333333333333
72118, 2.0333333333333, 0.55, 0.083333333333333
72119, 2.0333333333333, 0.5, 0.083333333333333
72120, 2.0333333333333, 0.45, 0.083333333333333
72121, 2.0333333333333, 0.4, 0.083333333333333
72122, 2.0333333333333, 0.35, 0.083333333333333
72123, 2.0333333333333, 0.3, 0.083333333333333
72124, 2.0333333333333, 0.25, 0.083333333333333
72125, 2.0333333333333, 0.2, 0.083333333333333
72126, 2.075, 1.3, 0.083333333333333
72127, 2.075, 1.25, 0.083333333333333
72128, 2.075, 1.2, 0.083333333333333
72129, 2.075, 1.15, 0.083333333333333
72130, 2.075, 1.1, 0.083333333333333
72131, 2.075, 1.05, 0.083333333333333
72132, 2.075, 1, 0.083333333333333
72133, 2.075, 0.95, 0.083333333333333
72134, 2.075, 0.9, 0.083333333333333
72135, 2.075, 0.85, 0.083333333333333
72136, 2.075, 0.8, 0.083333333333333
72137, 2.075, 0.75, 0.083333333333333
72138, 2.075, 0.7, 0.083333333333333
72139, 2.075, 0.65, 0.083333333333333
72140, 2.075, 0.6, 0.083333333333333
72141, 2.075, 0.55, 0.083333333333333
72142, 2.075, 0.5, 0.083333333333333
72143, 2.075, 0.45, 0.083333333333333
72144, 2.075, 0.4, 0.083333333333333
72145, 2.075, 0.35, 0.083333333333333
72146, 2.075, 0.3, 0.083333333333333
72147, 2.075, 0.25, 0.083333333333333
72148, 2.075, 0.2, 0.083333333333333
72149, 2.1166666666667, 1.3, 0.083333333333333
72150, 2.1166666666667, 1.25, 0.083333333333333
72151, 2.1166666666667, 1.2, 0.083333333333333
72152, 2.1166666666667, 1.15, 0.083333333333333
72153, 2.1166666666667, 1.1, 0.083333333333333
72154, 2.1166666666667, 1.05, 0.083333333333333
72155, 2.1166666666667, 1, 0.083333333333333
72156, 2.1166666666667, 0.95, 0.083333333333333
72157, 2.1166666666667, 0.9, 0.083333333333333
72158, 2.1166666666667, 0.85, 0.083333333333333
72159, 2.1166666666667, 0.8, 0.083333333333333
72160, 2.1166666666667, 0.75, 0.083333333333333
72161, 2.1166666666667, 0.7, 0.083333333333333
72162, 2.1166666666667, 0.65, 0.083333333333333
72163, 2.1166666666667, 0.6, 0.083333333333333
72164, 2.1166666666667, 0.55, 0.083333333333333
72165, 2.1166666666667, 0.5, 0.083333333333333
72166, 2.1166666666667, 0.45, 0.083333333333333
72167, 2.1166666666667, 0.4, 0.083333333333333
72168, 2.1166666666667, 0.35, 0.083333333333333
72169, 2.1166666666667, 0.3, 0.083333333333333
72170, 2.1166666666667, 0.25, 0.083333333333333
72171, 2.1166666666667, 0.2, 0.083333333333333
72172, 2.1583333333333, 1.3, 0.083333333333333
72173, 2.1583333333333, 1.25, 0.083333333333333
72174, 2.1583333333333, 1.2, 0.083333333333333
72175, 2.1583333333333, 1.15, 0.083333333333333
72176, 2.1583333333333, 1.1, 0.083333333333333
72177, 2.1583333333333, 1.05, 0.083333333333333
72178, 2.1583333333333, 1, 0.083333333333333
72179, 2.1583333333333, 0.95, 0.083333333333333
72180, 2.1583333333333, 0.9, 0.083333333333333
72181, 2.1583333333333, 0.85, 0.083333333333333
72182, 2.1583333333333, 0.8, 0.083333333333333
72183, 2.1583333333333, 0.75, 0.083333333333333
72184, 2.1583333333333, 0.7, 0.083333333333333
72185, 2.1583333333333, 0.65, 0.083333333333333
72186, 2.1583333333333, 0.6, 0.083333333333333
72187, 2.1583333333333, 0.55, 0.083333333333333
72188, 2.1583333333333, 0.5, 0.083333333333333
72189, 2.1583333333333, 0.45, 0.083333333333333
72190, 2.1583333333333, 0.4, 0.083333333333333
72191, 2.1583333333333, 0.35, 0.083333333333333
72192, 2.1583333333333, 0.3, 0.083333333333333
72193, 2.1583333333333, 0.25, 0.083333333333333
72194, 2.1583333333333, 0.2, 0.083333333333333
72195, 1.2416666666667, 1.3, 0.125
72196, 1.2416666666667, 1.25, 0.125
72197, 1.2416666666667, 1.2, 0.125
72198, 1.2416666666667, 1.15, 0.125
72199, 1.2416666666667, 1.1, 0.125
72200, 1.2416666666667, 1.05, 0.125
72201, 1.2416666666667, 1, 0.125
72202, 1.2416666666667, 0.95, 0.125
72203, 1.2416666666667, 0.9, 0.125
72204, 1.2416666666667, 0.85, 0.125
72205, 1.2416666666667, 0.8, 0.125
72206, 1.2416666666667, 0.75, 0.125
72207, 1.2416666666667, 0.7, 0.125
72208, 1.2416666666667, 0.65, 0.125
72209, 1.2416666666667, 0.6, 0.125
72210, 1.2416666666667, 0.55, 0.125
72211, 1.2416666666667, 0.5, 0.125
72212, 1.2416666666667, 0.45, 0.125
72213, 1.2416666666667, 0.4, 0.125
72214, 1.2416666666667, 0.35, 0.125
72215, 1.2416666666667, 0.3, 0.125
72216, 1.2416666666667, 0.25, 0.125
72217, 1.2416666666667, 0.2, 0.125
72218, 1.2833333333333, 1.3, 0.125
72219, 1.2833333333333, 1.25, 0.125
72220, 1.2833333333333, 1.2, 0.125
72221, 1.2833333333333, 1.15, 0.125
72222, 1.2833333333333, 1.1, 0.125
72223, 1.2833333333333, 1.05, 0.125
72224, 1.2833333333333, 1, 0.125
72225, 1.2833333333333, 0.95, 0.125
72226, 1.2833333333333, 0.9, 0.125
72227, 1.2833333333333, 0.85, 0.125
72228, 1.2833333333333, 0.8, 0.125
72229, 1.2833333333333, 0.75, 0.125
72230, 1.2833333333333, 0.7, 0.125
72231, 1.2833333333333, 0.65, 0.125
72232, 1.2833333333333, 0.6, 0.125
72233, 1.2833333333333, 0.55, 0.125
72234, 1.2833333333333, 0.5, 0.125
72235, 1.2833333333333, 0.45, 0.125
72236, 1.2833333333333, 0.4, 0.125
72237, 1.2833333333333, 0.35, 0.125
72238, 1.2833333333333, 0.3, 0.125
72239, 1.2833333333333, 0.25, 0.125
72240, 1.2833333333333, 0.2, 0.125
72241, 1.325, 1.3, 0.125
72242, 1.325, 1.25, 0.125
72243, 1.325, 1.2, 0.125
72244, 1.325, 1.15, 0.125
72245, 1.325, 1.1, 0.125
72246, 1.325, 1.05, 0.125
72247, 1.325, 1, 0.125
72248, 1.325, 0.95, 0.125
72249, 1.325, 0.9, 0.125
72250, 1.325, 0.85, 0.125
72251, 1.325, 0.8, 0.125
72252, 1.325, 0.75, 0.125
72253, 1.325, 0.7, 0.125
72254, 1.325, 0.65, 0.125
72255, 1.325, 0.6, 0.125
72256, 1.325, 0.55, 0.125
72257, 1.325, 0.5, 0.125
72258, 1.325, 0.45, 0.125
72259, 1.325, 0.4, 0.125
72260, 1.325, 0.35, 0.125
72261, 1.325, 0.3, 0.125
72262, 1.325, 0.25, 0.125
72263, 1.325, 0.2, 0.125
72264, 1.3666666666667, 1.3, 0.125
72265, 1.3666666666667, 1.25, 0.125
72266, 1.3666666666667, 1.2, 0.125
72267, 1.3666666666667, 1.15, 0.125
72268, 1.3666666666667, 1.1, 0.125
72269, 1.3666666666667, 1.05, 0.125
72270, 1.3666666666667, 1, 0.125
72271, 1.3666666666667, 0.95, 0.125
72272, 1.3666666666667, 0.9, 0.125
72273, 1.3666666666667, 0.85, 0.125
72274, 1.3666666666667, 0.8, 0.125
72275, 1.3666666666667, 0.75, 0.125
72276, 1.3666666666667, 0.7, 0.125
72277, 1.3666666666667, 0.65, 0.125
72278, 1.3666666666667, 0.6, 0.125
72279, 1.3666666666667, 0.55, 0.125
72280, 1.3666666666667, 0.5, 0.125
72281, 1.3666666666667, 0.45, 0.125
72282, 1.3666666666667, 0.4, 0.125
72283, 1.3666666666667, 0.35, 0.125
72284, 1.3666666666667, 0.3, 0.125
72285, 1.3666666666667, 0.25, 0.125
72286, 1.3666666666667, 0.2, 0.125
72287, 1.4083333333333, 1.3, 0.125
72288, 1.4083333333333, 1.25, 0.125
72289, 1.4083333333333, 1.2, 0.125
72290, 1.4083333333333, 1.15, 0.125
72291, 1.4083333333333, 1.1, 0.125
72292, 1.4083333333333, 1.05, 0.125
72293, 1.4083333333333, 1, 0.125
72294, 1.4083333333333, 0.95, 0.125
72295, 1.4083333333333, 0.9, 0.125
72296, 1.4083333333333, 0.85, 0.125
72297, 1.4083333333333, 0.8, 0.125
72298, 1.4083333333333, 0.75, 0.125
72299, 1.4083333333333, 0.7, 0.125
72300, 1.4083333333333, 0.65, 0.125
72301, 1.4083333333333, 0.6, 0.125
72302, 1.4083333333333, 0.55, 0.125
72303, 1.4083333333333, 0.5, 0.125
72304, 1.4083333333333, 0.45, 0.125
72305, 1.4083333333333, 0.4, 0.125
72306, 1.4083333333333, 0.35, 0.125
72307, 1.4083333333333, 0.3, 0.125
72308, 1.4083333333333, 0.25, 0.125
72309, 1.4083333333333, 0.2, 0.125
72310, 1.45, 1.3, 0.125
72311, 1.45, 1.25, 0.125
72312, 1.45, 1.2, 0.125
72313, 1.45, 1.15, 0.125
72314, 1.45, 1.1, 0.125
72315, 1.45, 1.05, 0.125
72316, 1.45, 1, 0.125
72317, 1.45, 0.95, 0.125
72318, 1.45, 0.9, 0.125
72319, 1.45, 0.85, 0.125
72320, 1.45, 0.8, 0.125
72321, 1.45, 0.75, 0.125
72322, 1.45, 0.7, 0.125
72323, 1.45, 0.65, 0.125
72324, 1.45, 0.6, 0.125
72325, 1.45, 0.55, 0.125
72326, 1.45, 0.5, 0.125
72327, 1.45, 0.45, 0.125
72328, 1.45, 0.4, 0.125
72329, 1.45, 0.35, 0.125
72330, 1.45, 0.3, 0.125
72331, 1.45, 0.25, 0.125
72332, 1.45, 0.2, 0.125
72333, 1.4916666666667, 1.3, 0.125
72334, 1.4916666666667, 1.25, 0.125
72335, 1.4916666666667, 1.2, 0.125
72336, 1.4916666666667, 1.15, 0.125
72337, 1.4916666666667, 1.1, 0.125
72338, 1.4916666666667, 1.05, 0.125
72339, 1.4916666666667, 1, 0.125
72340, 1.4916666666667, 0.95, 0.125
72341, 1.4916666666667, 0.9, 0.125
72342, 1.4916666666667, 0.85, 0.125
72343, 1.4916666666667, 0.8, 0.125
72344, 1.4916666666667, 0.75, 0.125
72345, 1.4916666666667, 0.7, 0.125
72346, 1.4916666666667, 0.65, 0.125
72347, 1.4916666666667, 0.6, 0.125
72348, 1.4916666666667, 0.55, 0.125
72349, 1.4916666666667, 0.5, 0.125
72350, 1.4916666666667, 0.45, 0.125
72351, 1.4916666666667, 0.4, 0.125
72352, 1.4916666666667, 0.35, 0.125
72353, 1.4916666666667, 0.3, 0.125
72354, 1.4916666666667, 0.25, 0.125
72355, 1.4916666666667, 0.2, 0.125
72356, 1.5333333333333, 1.3, 0.125
72357, 1.5333333333333, 1.25, 0.125
72358, 1.5333333333333, 1.2, 0.125
72359, 1.5333333333333, 1.15, 0.125
72360, 1.5333333333333, 1.1, 0.125
72361, 1.5333333333333, 1.05, 0.125
72362, 1.5333333333333, 1, 0.125
72363, 1.5333333333333, 0.95, 0.125
72364, 1.5333333333333, 0.9, 0.125
72365, 1.5333333333333, 0.85, 0.125
72366, 1.5333333333333, 0.8, 0.125
72367, 1.5333333333333, 0.75, 0.125
72368, 1.5333333333333, 0.7, 0.125
72369, 1.5333333333333, 0.65, 0.125
72370, 1.5333333333333, 0.6, 0.125
72371, 1.5333333333333, 0.55, 0.125
72372, 1.5333333333333, 0.5, 0.125
72373, 1.5333333333333, 0.45, 0.125
72374, 1.5333333333333, 0.4, 0.125
72375, 1.5333333333333, 0.35, 0.125
72376, 1.5333333333333, 0.3, 0.125
72377, 1.5333333333333, 0.25, 0.125
72378, 1.5333333333333, 0.2, 0.125
72379, 1.575, 1.3, 0.125
72380, 1.575, 1.25, 0.125
72381, 1.575, 1.2, 0.125
72382, 1.575, 1.15, 0.125
72383, 1.575, 1.1, 0.125
72384, 1.575, 1.05, 0.125
72385, 1.575, 1, 0.125
72386, 1.575, 0.95, 0.125
72387, 1.575, 0.9, 0.125
72388, 1.575, 0.85, 0.125
72389, 1.575, 0.8, 0.125
72390, 1.575, 0.75, 0.125
72391, 1.575, 0.7, 0.125
72392, 1.575, 0.65, 0.125
72393, 1.575, 0.6, 0.125
72394, 1.575, 0.55, 0.125
72395, 1.575, 0.5, 0.125
72396, 1.575, 0.45, 0.125
72397, 1.575, 0.4, 0.125
72398, 1.575, 0.35, 0.125
72399, 1.575, 0.3, 0.125
72400, 1.575, 0.25, 0.125
72401, 1.575, 0.2, 0.125
72402, 1.6166666666667, 1.3, 0.125
72403, 1.6166666666667, 1.25, 0.125
72404, 1.6166666666667, 1.2, 0.125
72405, 1.6166666666667, 1.15, 0.125
72406, 1.6166666666667, 1.1, 0.125
72407, 1.6166666666667, 1.05, 0.125
72408, 1.6166666666667, 1, 0.125
72409, 1.6166666666667, 0.95, 0.125
72410, 1.6166666666667, 0.9, 0.125
72411, 1.6166666666667, 0.85, 0.125
72412, 1.6166666666667, 0.8, 0.125
72413, 1.6166666666667, 0.75, 0.125
72414, 1.6166666666667, 0.7, 0.125
72415, 1.6166666666667, 0.65, 0.125
72416, 1.6166666666667, 0.6, 0.125
72417, 1.6166666666667, 0.55, 0.125
72418, 1.6166666666667, 0.5, 0.125
72419, 1.6166666666667, 0.45, 0.125
72420, 1.6166666666667, 0.4, 0.125
72421, 1.6166666666667, 0.35, 0.125
72422, 1.6166666666667, 0.3, 0.125
72423, 1.6166666666667, 0.25, 0.125
72424, 1.6166666666667, 0.2, 0.125
72425, 1.6583333333333, 1.3, 0.125
72426, 1.6583333333333, 1.25, 0.125
72427, 1.6583333333333, 1.2, 0.125
72428, 1.6583333333333, 1.15, 0.125
72429, 1.6583333333333, 1.1, 0.125
72430, 1.6583333333333, 1.05, 0.125
72431, 1.6583333333333, 1, 0.125
72432, 1.6583333333333, 0.95, 0.125
72433, 1.6583333333333, 0.9, 0.125
72434, 1.6583333333333, 0.85, 0.125
72435, 1.6583333333333, 0.8, 0.125
72436, 1.6583333333333, 0.75, 0.125
72437, 1.6583333333333, 0.7, 0.125
72438, 1.6583333333333, 0.65, 0.125
72439, 1.6583333333333, 0.6, 0.125
72440, 1.6583333333333, 0.55, 0.125
72441, 1.6583333333333, 0.5, 0.125
72442, 1.6583333333333, 0.45, 0.125
72443, 1.6583333333333, 0.4, 0.125
72444, 1.6583333333333, 0.35, 0.125
72445, 1.6583333333333, 0.3, 0.125
72446, 1.6583333333333, 0.25, 0.125
72447, 1.6583333333333, 0.2, 0.125
72448, 1.7, 1.3, 0.125
72449, 1.7, 1.25, 0.125
72450, 1.7, 1.2, 0.125
72451, 1.7, 1.15, 0.125
72452, 1.7, 1.1, 0.125
72453, 1.7, 1.05, 0.125
72454, 1.7, 1, 0.125
72455, 1.7, 0.95, 0.125
72456, 1.7, 0.9, 0.125
72457, 1.7, 0.85, 0.125
72458, 1.7, 0.8, 0.125
72459, 1.7, 0.75, 0.125
72460, 1.7, 0.7, 0.125
72461, 1.7, 0.65, 0.125
72462, 1.7, 0.6, 0.125
72463, 1.7, 0.55, 0.125
72464, 1.7, 0.5, 0.125
72465, 1.7, 0.45, 0.125
72466, 1.7, 0.4, 0.125
72467, 1.7, 0.35, 0.125
72468, 1.7, 0.3, 0.125
72469, 1.7, 0.25, 0.125
72470, 1.7, 0.2, 0.125
72471, 1.7416666666667, 1.3, 0.125
72472, 1.7416666666667, 1.25, 0.125
72473, 1.7416666666667, 1.2, 0.125
72474, 1.7416666666667, 1.15, 0.125
72475, 1.7416666666667, 1.1, 0.125
72476, 1.7416666666667, 1.05, 0.125
72477, 1.7416666666667, 1, 0.125
72478, 1.7416666666667, 0.95, 0.125
72479, 1.7416666666667, 0.9, 0.125
72480, 1.7416666666667, 0.85, 0.125
72481, 1.7416666666667, 0.8, 0.125
72482, 1.7416666666667, 0.75, 0.125
72483, 1.7416666666667, 0.7, 0.125
72484, 1.7416666666667, 0.65, 0.125
72485, 1.7416666666667, 0.6, 0.125
72486, 1.7416666666667, 0.55, 0.125
72487, 1.7416666666667, 0.5, 0.125
72488, 1.7416666666667, 0.45, 0.125
72489, 1.7416666666667, 0.4, 0.125
72490, 1.7416666666667, 0.35, 0.125
72491, 1.7416666666667, 0.3, 0.125
72492, 1.7416666666667, 0.25, 0.125
72493, 1.7416666666667, 0.2, 0.125
72494, 1.7833333333333, 1.3, 0.125
72495, 1.7833333333333, 1.25, 0.125
72496, 1.7833333333333, 1.2, 0.125
72497, 1.7833333333333, 1.15, 0.125
72498, 1.7833333333333, 1.1, 0.125
72499, 1.7833333333333, 1.05, 0.125
72500, 1.7833333333333, 1, 0.125
72501, 1.7833333333333, 0.95, 0.125
72502, 1.7833333333333, 0.9, 0.125
72503, 1.7833333333333, 0.85, 0.125
72504, 1.7833333333333, 0.8, 0.125
72505, 1.7833333333333, 0.75, 0.125
72506, 1.7833333333333, 0.7, 0.125
72507, 1.7833333333333, 0.65, 0.125
72508, 1.7833333333333, 0.6, 0.125
72509, 1.7833333333333, 0.55, 0.125
72510, 1.7833333333333, 0.5, 0.125
72511, 1.7833333333333, 0.45, 0.125
72512, 1.7833333333333, 0.4, 0.125
72513, 1.7833333333333, 0.35, 0.125
72514, 1.7833333333333, 0.3, 0.125
72515, 1.7833333333333, 0.25, 0.125
72516, 1.7833333333333, 0.2, 0.125
72517, 1.825, 1.3, 0.125
72518, 1.825, 1.25, 0.125
72519, 1.825, 1.2, 0.125
72520, 1.825, 1.15, 0.125
72521, 1.825, 1.1, 0.125
72522, 1.825, 1.05, 0.125
72523, 1.825, 1, 0.125
72524, 1.825, 0.95, 0.125
72525, 1.825, 0.9, 0.125
72526, 1.825, 0.85, 0.125
72527, 1.825, 0.8, 0.125
72528, 1.825, 0.75, 0.125
72529, 1.825, 0.7, 0.125
72530, 1.825, 0.65, 0.125
72531, 1.825, 0.6, 0.125
72532, 1.825, 0.55, 0.125
72533, 1.825, 0.5, 0.125
72534, 1.825, 0.45, 0.125
72535, 1.825, 0.4, 0.125
72536, 1.825, 0.35, 0.125
72537, 1.825, 0.3, 0.125
72538, 1.825, 0.25, 0.125
72539, 1.825, 0.2, 0.125
72540, 1.8666666666667, 1.3, 0.125
72541, 1.8666666666667, 1.25, 0.125
72542, 1.8666666666667, 1.2, 0.125
72543, 1.8666666666667, 1.15, 0.125
72544, 1.8666666666667, 1.1, 0.125
72545, 1.8666666666667, 1.05, 0.125
72546, 1.8666666666667, 1, 0.125
72547, 1.8666666666667, 0.95, 0.125
72548, 1.8666666666667, 0.9, 0.125
72549, 1.8666666666667, 0.85, 0.125
72550, 1.8666666666667, 0.8, 0.125
72551, 1.8666666666667, 0.75, 0.125
72552, 1.8666666666667, 0.7, 0.125
72553, 1.8666666666667, 0.65, 0.125
72554, 1.8666666666667, 0.6, 0.125
72555, 1.8666666666667, 0.55, 0.125
72556, 1.8666666666667, 0.5, 0.125
72557, 1.8666666666667, 0.45, 0.125
72558, 1.8666666666667, 0.4, 0.125
72559, 1.8666666666667, 0.35, 0.125
72560, 1.8666666666667, 0.3, 0.125
72561, 1.8666666666667, 0.25, 0.125
72562, 1.8666666666667, 0.2, 0.125
72563, 1.9083333333333, 1.3, 0.125
72564, 1.9083333333333, 1.25, 0.125
72565, 1.9083333333333, 1.2, 0.125
72566, 1.9083333333333, 1.15, 0.125
72567, 1.9083333333333, 1.1, 0.125
72568, 1.9083333333333, 1.05, 0.125
72569, 1.9083333333333, 1, 0.125
72570, 1.9083333333333, 0.95, 0.125
72571, 1.9083333333333, 0.9, 0.125
72572, 1.9083333333333, 0.85, 0.125
72573, 1.9083333333333, 0.8, 0.125
72574, 1.9083333333333, 0.75, 0.125
72575, 1.9083333333333, 0.7, 0.125
72576, 1.9083333333333, 0.65, 0.125
72577, 1.9083333333333, 0.6, 0.125
72578, 1.9083333333333, 0.55, 0.125
72579, 1.9083333333333, 0.5, 0.125
72580, 1.9083333333333, 0.45, 0.125
72581, 1.9083333333333, 0.4, 0.125
72582, 1.9083333333333, 0.35, 0.125
72583, 1.9083333333333, 0.3, 0.125
72584, 1.9083333333333, 0.25, 0.125
72585, 1.9083333333333, 0.2, 0.125
72586, 1.95, 1.3, 0.125
72587, 1.95, 1.25, 0.125
72588, 1.95, 1.2, 0.125
72589, 1.95, 1.15, 0.125
72590, 1.95, 1.1, 0.125
72591, 1.95, 1.05, 0.125
72592, 1.95, 1, 0.125
72593, 1.95, 0.95, 0.125
72594, 1.95, 0.9, 0.125
72595, 1.95, 0.85, 0.125
72596, 1.95, 0.8, 0.125
72597, 1.95, 0.75, 0.125
72598, 1.95, 0.7, 0.125
72599, 1.95, 0.65, 0.125
72600, 1.95, 0.6, 0.125
72601, 1.95, 0.55, 0.125
72602, 1.95, 0.5, 0.125
72603, 1.95, 0.45, 0.125
72604, 1.95, 0.4, 0.125
72605, 1.95, 0.35, 0.125
72606, 1.95, 0.3, 0.125
72607, 1.95, 0.25, 0.125
72608, 1.95, 0.2, 0.125
72609, 1.9916666666667, 1.3, 0.125
72610, 1.9916666666667, 1.25, 0.125
72611, 1.9916666666667, 1.2, 0.125
72612, 1.9916666666667, 1.15, 0.125
72613, 1.9916666666667, 1.1, 0.125
72614, 1.9916666666667, 1.05, 0.125
72615, 1.9916666666667, 1, 0.125
72616, 1.9916666666667, 0.95, 0.125
72617, 1.9916666666667, 0.9, 0.125
72618, 1.9916666666667, 0.85, 0.125
72619, 1.9916666666667, 0.8, 0.125
72620, 1.9916666666667, 0.75, 0.125
72621, 1.9916666666667, 0.7, 0.125
72622, 1.9916666666667, 0.65, 0.125
72623, 1.9916666666667, 0.6, 0.125
72624, 1.9916666666667, 0.55, 0.125
72625, 1.9916666666667, 0.5, 0.125
72626, 1.9916666666667, 0.45, 0.125
72627, 1.9916666666667, 0.4, 0.125
72628, 1.9916666666667, 0.35, 0.125
72629, 1.9916666666667, 0.3, 0.125
72630, 1.9916666666667, 0.25, 0.125
72631, 1.9916666666667, 0.2, 0.125
72632, 2.0333333333333, 1.3, 0.125
72633, 2.0333333333333, 1.25, 0.125
72634, 2.0333333333333, 1.2, 0.125
72635, 2.0333333333333, 1.15, 0.125
72636, 2.0333333333333, 1.1, 0.125
72637, 2.0333333333333, 1.05, 0.125
72638, 2.0333333333333, 1, 0.125
72639, 2.0333333333333, 0.95, 0.125
72640, 2.0333333333333, 0.9, 0.125
72641, 2.0333333333333, 0.85, 0.125
72642, 2.0333333333333, 0.8, 0.125
72643, 2.0333333333333, 0.75, 0.125
72644, 2.0333333333333, 0.7, 0.125
72645, 2.0333333333333, 0.65, 0.125
72646, 2.0333333333333, 0.6, 0.125
72647, 2.0333333333333, 0.55, 0.125
72648, 2.0333333333333, 0.5, 0.125
72649, 2.0333333333333, 0.45, 0.125
72650, 2.0333333333333, 0.4, 0.125
72651, 2.0333333333333, 0.35, 0.125
72652, 2.0333333333333, 0.3, 0.125
72653, 2.0333333333333, 0.25, 0.125
72654, 2.0333333333333, 0.2, 0.125
72655, 2.075, 1.3, 0.125
72656, 2.075, 1.25, 0.125
72657, 2.075, 1.2, 0.125
72658, 2.075, 1.15, 0.125
72659, 2.075, 1.1, 0.125
72660, 2.075, 1.05, 0.125
72661, 2.075, 1, 0.125
72662, 2.075, 0.95, 0.125
72663, 2.075, 0.9, 0.125
72664, 2.075, 0.85, 0.125
72665, 2.075, 0.8, 0.125
72666, 2.075, 0.75, 0.125
72667, 2.075, 0.7, 0.125
72668, 2.075, 0.65, 0.125
72669, 2.075, 0.6, 0.125
72670, 2.075, 0.55, 0.125
