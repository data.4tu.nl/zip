89878, 2.1166666666667, 0.975, 0.33333333333333
89879, 2.1166666666667, 0.95, 0.3125
89880, 2.0958333333333, 0.95, 0.33333333333333
89881, 2.1166666666667, 0.925, 0.33333333333333
89882, 2.1166666666667, 0.9, 0.3125
89883, 2.0958333333333, 0.9, 0.33333333333333
89884, 2.1166666666667, 0.875, 0.33333333333333
89885, 2.1166666666667, 0.85, 0.3125
89886, 2.0958333333333, 0.85, 0.33333333333333
89887, 2.1166666666667, 0.825, 0.33333333333333
89888, 2.1166666666667, 0.8, 0.3125
89889, 2.0958333333333, 0.8, 0.33333333333333
89890, 2.1166666666667, 0.775, 0.33333333333333
89891, 2.1166666666667, 0.75, 0.3125
89892, 2.0958333333333, 0.75, 0.33333333333333
89893, 2.1166666666667, 0.725, 0.33333333333333
89894, 2.1166666666667, 0.7, 0.3125
89895, 2.0958333333333, 0.7, 0.33333333333333
89896, 2.1166666666667, 0.675, 0.33333333333333
89897, 2.1166666666667, 0.65, 0.3125
89898, 2.0958333333333, 0.65, 0.33333333333333
89899, 2.1166666666667, 0.625, 0.33333333333333
89900, 2.1166666666667, 0.6, 0.3125
89901, 2.0958333333333, 0.6, 0.33333333333333
89902, 2.1166666666667, 0.575, 0.33333333333333
89903, 2.1166666666667, 0.55, 0.3125
89904, 2.0958333333333, 0.55, 0.33333333333333
89905, 2.1166666666667, 0.525, 0.33333333333333
89906, 2.1166666666667, 0.5, 0.3125
89907, 2.0958333333333, 0.5, 0.33333333333333
89908, 2.1166666666667, 0.475, 0.33333333333333
89909, 2.1166666666667, 0.45, 0.3125
89910, 2.0958333333333, 0.45, 0.33333333333333
89911, 2.1166666666667, 0.425, 0.33333333333333
89912, 2.1166666666667, 0.4, 0.3125
89913, 2.0958333333333, 0.4, 0.33333333333333
89914, 2.1166666666667, 0.375, 0.33333333333333
89915, 2.1166666666667, 0.35, 0.3125
89916, 2.0958333333333, 0.35, 0.33333333333333
89917, 2.1166666666667, 0.325, 0.33333333333333
89918, 2.1166666666667, 0.3, 0.3125
89919, 2.0958333333333, 0.3, 0.33333333333333
89920, 2.1166666666667, 0.275, 0.33333333333333
89921, 2.1166666666667, 0.25, 0.3125
89922, 2.0958333333333, 0.25, 0.33333333333333
89923, 2.1166666666667, 0.225, 0.33333333333333
89924, 2.1166666666667, 0.2, 0.3125
89925, 2.0958333333333, 0.2, 0.33333333333333
89926, 2.1166666666667, 0.175, 0.33333333333333
89927, 2.1583333333333, 1.325, 0.33333333333333
89928, 2.1583333333333, 1.3, 0.3125
89929, 2.1375, 1.3, 0.33333333333333
89930, 2.1583333333333, 1.275, 0.33333333333333
89931, 2.1583333333333, 1.25, 0.3125
89932, 2.1375, 1.25, 0.33333333333333
89933, 2.1583333333333, 1.225, 0.33333333333333
89934, 2.1583333333333, 1.2, 0.3125
89935, 2.1375, 1.2, 0.33333333333333
89936, 2.1583333333333, 1.175, 0.33333333333333
89937, 2.1583333333333, 1.15, 0.3125
89938, 2.1375, 1.15, 0.33333333333333
89939, 2.1583333333333, 1.125, 0.33333333333333
89940, 2.1583333333333, 1.1, 0.3125
89941, 2.1375, 1.1, 0.33333333333333
89942, 2.1583333333333, 1.075, 0.33333333333333
89943, 2.1583333333333, 1.05, 0.3125
89944, 2.1375, 1.05, 0.33333333333333
89945, 2.1583333333333, 1.025, 0.33333333333333
89946, 2.1583333333333, 1, 0.3125
89947, 2.1375, 1, 0.33333333333333
89948, 2.1583333333333, 0.975, 0.33333333333333
89949, 2.1583333333333, 0.95, 0.3125
89950, 2.1375, 0.95, 0.33333333333333
89951, 2.1583333333333, 0.925, 0.33333333333333
89952, 2.1583333333333, 0.9, 0.3125
89953, 2.1375, 0.9, 0.33333333333333
89954, 2.1583333333333, 0.875, 0.33333333333333
89955, 2.1583333333333, 0.85, 0.3125
89956, 2.1375, 0.85, 0.33333333333333
89957, 2.1583333333333, 0.825, 0.33333333333333
89958, 2.1583333333333, 0.8, 0.3125
89959, 2.1375, 0.8, 0.33333333333333
89960, 2.1583333333333, 0.775, 0.33333333333333
89961, 2.1583333333333, 0.75, 0.3125
89962, 2.1375, 0.75, 0.33333333333333
89963, 2.1583333333333, 0.725, 0.33333333333333
89964, 2.1583333333333, 0.7, 0.3125
89965, 2.1375, 0.7, 0.33333333333333
89966, 2.1583333333333, 0.675, 0.33333333333333
89967, 2.1583333333333, 0.65, 0.3125
89968, 2.1375, 0.65, 0.33333333333333
89969, 2.1583333333333, 0.625, 0.33333333333333
89970, 2.1583333333333, 0.6, 0.3125
89971, 2.1375, 0.6, 0.33333333333333
89972, 2.1583333333333, 0.575, 0.33333333333333
89973, 2.1583333333333, 0.55, 0.3125
89974, 2.1375, 0.55, 0.33333333333333
89975, 2.1583333333333, 0.525, 0.33333333333333
89976, 2.1583333333333, 0.5, 0.3125
89977, 2.1375, 0.5, 0.33333333333333
89978, 2.1583333333333, 0.475, 0.33333333333333
89979, 2.1583333333333, 0.45, 0.3125
89980, 2.1375, 0.45, 0.33333333333333
89981, 2.1583333333333, 0.425, 0.33333333333333
89982, 2.1583333333333, 0.4, 0.3125
89983, 2.1375, 0.4, 0.33333333333333
89984, 2.1583333333333, 0.375, 0.33333333333333
89985, 2.1583333333333, 0.35, 0.3125
89986, 2.1375, 0.35, 0.33333333333333
89987, 2.1583333333333, 0.325, 0.33333333333333
89988, 2.1583333333333, 0.3, 0.3125
89989, 2.1375, 0.3, 0.33333333333333
89990, 2.1583333333333, 0.275, 0.33333333333333
89991, 2.1583333333333, 0.25, 0.3125
89992, 2.1375, 0.25, 0.33333333333333
89993, 2.1583333333333, 0.225, 0.33333333333333
89994, 2.1583333333333, 0.2, 0.3125
89995, 2.1375, 0.2, 0.33333333333333
89996, 2.1583333333333, 0.175, 0.33333333333333
89997, 2.1791666666667, 1.3, 0.33333333333333
89998, 2.1791666666667, 1.25, 0.33333333333333
89999, 2.1791666666667, 1.2, 0.33333333333333
90000, 2.1791666666667, 1.15, 0.33333333333333
90001, 2.1791666666667, 1.1, 0.33333333333333
90002, 2.1791666666667, 1.05, 0.33333333333333
90003, 2.1791666666667, 1, 0.33333333333333
90004, 2.1791666666667, 0.95, 0.33333333333333
90005, 2.1791666666667, 0.9, 0.33333333333333
90006, 2.1791666666667, 0.85, 0.33333333333333
90007, 2.1791666666667, 0.8, 0.33333333333333
90008, 2.1791666666667, 0.75, 0.33333333333333
90009, 2.1791666666667, 0.7, 0.33333333333333
90010, 2.1791666666667, 0.65, 0.33333333333333
90011, 2.1791666666667, 0.6, 0.33333333333333
90012, 2.1791666666667, 0.55, 0.33333333333333
90013, 2.1791666666667, 0.5, 0.33333333333333
90014, 2.1791666666667, 0.45, 0.33333333333333
90015, 2.1791666666667, 0.4, 0.33333333333333
90016, 2.1791666666667, 0.35, 0.33333333333333
90017, 2.1791666666667, 0.3, 0.33333333333333
90018, 2.1791666666667, 0.25, 0.33333333333333
90019, 2.1791666666667, 0.2, 0.33333333333333
90020, 1.2416666666667, 1.325, 0.375
90021, 1.2416666666667, 1.3, 0.35416666666667
90022, 1.2208333333333, 1.3, 0.375
90023, 1.2416666666667, 1.275, 0.375
90024, 1.2416666666667, 1.25, 0.35416666666667
90025, 1.2208333333333, 1.25, 0.375
90026, 1.2416666666667, 1.225, 0.375
90027, 1.2416666666667, 1.2, 0.35416666666667
90028, 1.2208333333333, 1.2, 0.375
90029, 1.2416666666667, 1.175, 0.375
90030, 1.2416666666667, 1.15, 0.35416666666667
90031, 1.2208333333333, 1.15, 0.375
90032, 1.2416666666667, 1.125, 0.375
90033, 1.2416666666667, 1.1, 0.35416666666667
90034, 1.2208333333333, 1.1, 0.375
90035, 1.2416666666667, 1.075, 0.375
90036, 1.2416666666667, 1.05, 0.35416666666667
90037, 1.2208333333333, 1.05, 0.375
90038, 1.2416666666667, 1.025, 0.375
90039, 1.2416666666667, 1, 0.35416666666667
90040, 1.2208333333333, 1, 0.375
90041, 1.2416666666667, 0.975, 0.375
90042, 1.2416666666667, 0.95, 0.35416666666667
90043, 1.2208333333333, 0.95, 0.375
90044, 1.2416666666667, 0.925, 0.375
90045, 1.2416666666667, 0.9, 0.35416666666667
90046, 1.2208333333333, 0.9, 0.375
90047, 1.2416666666667, 0.875, 0.375
90048, 1.2416666666667, 0.85, 0.35416666666667
90049, 1.2208333333333, 0.85, 0.375
90050, 1.2416666666667, 0.825, 0.375
90051, 1.2416666666667, 0.8, 0.35416666666667
90052, 1.2208333333333, 0.8, 0.375
90053, 1.2416666666667, 0.775, 0.375
90054, 1.2416666666667, 0.75, 0.35416666666667
90055, 1.2208333333333, 0.75, 0.375
90056, 1.2416666666667, 0.725, 0.375
90057, 1.2416666666667, 0.7, 0.35416666666667
90058, 1.2208333333333, 0.7, 0.375
90059, 1.2416666666667, 0.675, 0.375
90060, 1.2416666666667, 0.65, 0.35416666666667
90061, 1.2208333333333, 0.65, 0.375
90062, 1.2416666666667, 0.625, 0.375
90063, 1.2416666666667, 0.6, 0.35416666666667
90064, 1.2208333333333, 0.6, 0.375
90065, 1.2416666666667, 0.575, 0.375
90066, 1.2416666666667, 0.55, 0.35416666666667
90067, 1.2208333333333, 0.55, 0.375
90068, 1.2416666666667, 0.525, 0.375
90069, 1.2416666666667, 0.5, 0.35416666666667
90070, 1.2208333333333, 0.5, 0.375
90071, 1.2416666666667, 0.475, 0.375
90072, 1.2416666666667, 0.45, 0.35416666666667
90073, 1.2208333333333, 0.45, 0.375
90074, 1.2416666666667, 0.425, 0.375
90075, 1.2416666666667, 0.4, 0.35416666666667
90076, 1.2208333333333, 0.4, 0.375
90077, 1.2416666666667, 0.375, 0.375
90078, 1.2416666666667, 0.35, 0.35416666666667
90079, 1.2208333333333, 0.35, 0.375
90080, 1.2416666666667, 0.325, 0.375
90081, 1.2416666666667, 0.3, 0.35416666666667
90082, 1.2208333333333, 0.3, 0.375
90083, 1.2416666666667, 0.275, 0.375
90084, 1.2416666666667, 0.25, 0.35416666666667
90085, 1.2208333333333, 0.25, 0.375
90086, 1.2416666666667, 0.225, 0.375
90087, 1.2416666666667, 0.2, 0.35416666666667
90088, 1.2208333333333, 0.2, 0.375
90089, 1.2416666666667, 0.175, 0.375
90090, 1.2833333333333, 1.325, 0.375
90091, 1.2833333333333, 1.3, 0.35416666666667
90092, 1.2625, 1.3, 0.375
90093, 1.2833333333333, 1.275, 0.375
90094, 1.2833333333333, 1.25, 0.35416666666667
90095, 1.2625, 1.25, 0.375
90096, 1.2833333333333, 1.225, 0.375
90097, 1.2833333333333, 1.2, 0.35416666666667
90098, 1.2625, 1.2, 0.375
90099, 1.2833333333333, 1.175, 0.375
90100, 1.2833333333333, 1.15, 0.35416666666667
90101, 1.2625, 1.15, 0.375
90102, 1.2833333333333, 1.125, 0.375
90103, 1.2833333333333, 1.1, 0.35416666666667
90104, 1.2625, 1.1, 0.375
90105, 1.2833333333333, 1.075, 0.375
90106, 1.2833333333333, 1.05, 0.35416666666667
90107, 1.2625, 1.05, 0.375
90108, 1.2833333333333, 1.025, 0.375
90109, 1.2833333333333, 1, 0.35416666666667
90110, 1.2625, 1, 0.375
90111, 1.2833333333333, 0.975, 0.375
90112, 1.2833333333333, 0.95, 0.35416666666667
90113, 1.2625, 0.95, 0.375
90114, 1.2833333333333, 0.925, 0.375
90115, 1.2833333333333, 0.9, 0.35416666666667
90116, 1.2625, 0.9, 0.375
90117, 1.2833333333333, 0.875, 0.375
90118, 1.2833333333333, 0.85, 0.35416666666667
90119, 1.2625, 0.85, 0.375
90120, 1.2833333333333, 0.825, 0.375
90121, 1.2833333333333, 0.8, 0.35416666666667
90122, 1.2625, 0.8, 0.375
90123, 1.2833333333333, 0.775, 0.375
90124, 1.2833333333333, 0.75, 0.35416666666667
90125, 1.2625, 0.75, 0.375
90126, 1.2833333333333, 0.725, 0.375
90127, 1.2833333333333, 0.7, 0.35416666666667
90128, 1.2625, 0.7, 0.375
90129, 1.2833333333333, 0.675, 0.375
90130, 1.2833333333333, 0.65, 0.35416666666667
90131, 1.2625, 0.65, 0.375
90132, 1.2833333333333, 0.625, 0.375
90133, 1.2833333333333, 0.6, 0.35416666666667
90134, 1.2625, 0.6, 0.375
90135, 1.2833333333333, 0.575, 0.375
90136, 1.2833333333333, 0.55, 0.35416666666667
90137, 1.2625, 0.55, 0.375
90138, 1.2833333333333, 0.525, 0.375
90139, 1.2833333333333, 0.5, 0.35416666666667
90140, 1.2625, 0.5, 0.375
90141, 1.2833333333333, 0.475, 0.375
90142, 1.2833333333333, 0.45, 0.35416666666667
90143, 1.2625, 0.45, 0.375
90144, 1.2833333333333, 0.425, 0.375
90145, 1.2833333333333, 0.4, 0.35416666666667
90146, 1.2625, 0.4, 0.375
90147, 1.2833333333333, 0.375, 0.375
90148, 1.2833333333333, 0.35, 0.35416666666667
90149, 1.2625, 0.35, 0.375
90150, 1.2833333333333, 0.325, 0.375
90151, 1.2833333333333, 0.3, 0.35416666666667
90152, 1.2625, 0.3, 0.375
90153, 1.2833333333333, 0.275, 0.375
90154, 1.2833333333333, 0.25, 0.35416666666667
90155, 1.2625, 0.25, 0.375
90156, 1.2833333333333, 0.225, 0.375
90157, 1.2833333333333, 0.2, 0.35416666666667
90158, 1.2625, 0.2, 0.375
90159, 1.2833333333333, 0.175, 0.375
90160, 1.325, 1.325, 0.375
90161, 1.325, 1.3, 0.35416666666667
90162, 1.3041666666667, 1.3, 0.375
90163, 1.325, 1.275, 0.375
90164, 1.325, 1.25, 0.35416666666667
90165, 1.3041666666667, 1.25, 0.375
90166, 1.325, 1.225, 0.375
90167, 1.325, 1.2, 0.35416666666667
90168, 1.3041666666667, 1.2, 0.375
90169, 1.325, 1.175, 0.375
90170, 1.325, 1.15, 0.35416666666667
90171, 1.3041666666667, 1.15, 0.375
90172, 1.325, 1.125, 0.375
90173, 1.325, 1.1, 0.35416666666667
90174, 1.3041666666667, 1.1, 0.375
90175, 1.325, 1.075, 0.375
90176, 1.325, 1.05, 0.35416666666667
90177, 1.3041666666667, 1.05, 0.375
90178, 1.325, 1.025, 0.375
90179, 1.325, 1, 0.35416666666667
90180, 1.3041666666667, 1, 0.375
90181, 1.325, 0.975, 0.375
90182, 1.325, 0.95, 0.35416666666667
90183, 1.3041666666667, 0.95, 0.375
90184, 1.325, 0.925, 0.375
90185, 1.325, 0.9, 0.35416666666667
90186, 1.3041666666667, 0.9, 0.375
90187, 1.325, 0.875, 0.375
90188, 1.325, 0.85, 0.35416666666667
90189, 1.3041666666667, 0.85, 0.375
90190, 1.325, 0.825, 0.375
90191, 1.325, 0.8, 0.35416666666667
90192, 1.3041666666667, 0.8, 0.375
90193, 1.325, 0.775, 0.375
90194, 1.325, 0.75, 0.35416666666667
90195, 1.3041666666667, 0.75, 0.375
90196, 1.325, 0.725, 0.375
90197, 1.325, 0.7, 0.35416666666667
90198, 1.3041666666667, 0.7, 0.375
90199, 1.325, 0.675, 0.375
90200, 1.325, 0.65, 0.35416666666667
90201, 1.3041666666667, 0.65, 0.375
90202, 1.325, 0.625, 0.375
90203, 1.325, 0.6, 0.35416666666667
90204, 1.3041666666667, 0.6, 0.375
90205, 1.325, 0.575, 0.375
90206, 1.325, 0.55, 0.35416666666667
90207, 1.3041666666667, 0.55, 0.375
90208, 1.325, 0.525, 0.375
90209, 1.325, 0.5, 0.35416666666667
90210, 1.3041666666667, 0.5, 0.375
90211, 1.325, 0.475, 0.375
90212, 1.325, 0.45, 0.35416666666667
90213, 1.3041666666667, 0.45, 0.375
90214, 1.325, 0.425, 0.375
90215, 1.325, 0.4, 0.35416666666667
90216, 1.3041666666667, 0.4, 0.375
90217, 1.325, 0.375, 0.375
90218, 1.325, 0.35, 0.35416666666667
90219, 1.3041666666667, 0.35, 0.375
90220, 1.325, 0.325, 0.375
90221, 1.325, 0.3, 0.35416666666667
90222, 1.3041666666667, 0.3, 0.375
90223, 1.325, 0.275, 0.375
90224, 1.325, 0.25, 0.35416666666667
90225, 1.3041666666667, 0.25, 0.375
90226, 1.325, 0.225, 0.375
90227, 1.325, 0.2, 0.35416666666667
90228, 1.3041666666667, 0.2, 0.375
90229, 1.325, 0.175, 0.375
90230, 1.3666666666667, 1.325, 0.375
90231, 1.3666666666667, 1.3, 0.35416666666667
90232, 1.3458333333333, 1.3, 0.375
90233, 1.3666666666667, 1.275, 0.375
90234, 1.3666666666667, 1.25, 0.35416666666667
90235, 1.3458333333333, 1.25, 0.375
90236, 1.3666666666667, 1.225, 0.375
90237, 1.3666666666667, 1.2, 0.35416666666667
90238, 1.3458333333333, 1.2, 0.375
90239, 1.3666666666667, 1.175, 0.375
90240, 1.3666666666667, 1.15, 0.35416666666667
90241, 1.3458333333333, 1.15, 0.375
90242, 1.3666666666667, 1.125, 0.375
90243, 1.3666666666667, 1.1, 0.35416666666667
90244, 1.3458333333333, 1.1, 0.375
90245, 1.3666666666667, 1.075, 0.375
90246, 1.3666666666667, 1.05, 0.35416666666667
90247, 1.3458333333333, 1.05, 0.375
90248, 1.3666666666667, 1.025, 0.375
90249, 1.3666666666667, 1, 0.35416666666667
90250, 1.3458333333333, 1, 0.375
90251, 1.3666666666667, 0.975, 0.375
90252, 1.3666666666667, 0.95, 0.35416666666667
90253, 1.3458333333333, 0.95, 0.375
90254, 1.3666666666667, 0.925, 0.375
90255, 1.3666666666667, 0.9, 0.35416666666667
90256, 1.3458333333333, 0.9, 0.375
90257, 1.3666666666667, 0.875, 0.375
90258, 1.3666666666667, 0.85, 0.35416666666667
90259, 1.3458333333333, 0.85, 0.375
90260, 1.3666666666667, 0.825, 0.375
90261, 1.3666666666667, 0.8, 0.35416666666667
90262, 1.3458333333333, 0.8, 0.375
90263, 1.3666666666667, 0.775, 0.375
90264, 1.3666666666667, 0.75, 0.35416666666667
90265, 1.3458333333333, 0.75, 0.375
90266, 1.3666666666667, 0.725, 0.375
90267, 1.3666666666667, 0.7, 0.35416666666667
90268, 1.3458333333333, 0.7, 0.375
90269, 1.3666666666667, 0.675, 0.375
90270, 1.3666666666667, 0.65, 0.35416666666667
90271, 1.3458333333333, 0.65, 0.375
90272, 1.3666666666667, 0.625, 0.375
90273, 1.3666666666667, 0.6, 0.35416666666667
90274, 1.3458333333333, 0.6, 0.375
90275, 1.3666666666667, 0.575, 0.375
90276, 1.3666666666667, 0.55, 0.35416666666667
90277, 1.3458333333333, 0.55, 0.375
90278, 1.3666666666667, 0.525, 0.375
90279, 1.3666666666667, 0.5, 0.35416666666667
90280, 1.3458333333333, 0.5, 0.375
90281, 1.3666666666667, 0.475, 0.375
90282, 1.3666666666667, 0.45, 0.35416666666667
90283, 1.3458333333333, 0.45, 0.375
90284, 1.3666666666667, 0.425, 0.375
90285, 1.3666666666667, 0.4, 0.35416666666667
90286, 1.3458333333333, 0.4, 0.375
90287, 1.3666666666667, 0.375, 0.375
90288, 1.3666666666667, 0.35, 0.35416666666667
90289, 1.3458333333333, 0.35, 0.375
90290, 1.3666666666667, 0.325, 0.375
90291, 1.3666666666667, 0.3, 0.35416666666667
90292, 1.3458333333333, 0.3, 0.375
90293, 1.3666666666667, 0.275, 0.375
90294, 1.3666666666667, 0.25, 0.35416666666667
90295, 1.3458333333333, 0.25, 0.375
90296, 1.3666666666667, 0.225, 0.375
90297, 1.3666666666667, 0.2, 0.35416666666667
90298, 1.3458333333333, 0.2, 0.375
90299, 1.3666666666667, 0.175, 0.375
90300, 1.4083333333333, 1.325, 0.375
90301, 1.4083333333333, 1.3, 0.35416666666667
90302, 1.3875, 1.3, 0.375
90303, 1.4083333333333, 1.275, 0.375
90304, 1.4083333333333, 1.25, 0.35416666666667
90305, 1.3875, 1.25, 0.375
90306, 1.4083333333333, 1.225, 0.375
90307, 1.4083333333333, 1.2, 0.35416666666667
90308, 1.3875, 1.2, 0.375
90309, 1.4083333333333, 1.175, 0.375
90310, 1.4083333333333, 1.15, 0.35416666666667
90311, 1.3875, 1.15, 0.375
90312, 1.4083333333333, 1.125, 0.375
90313, 1.4083333333333, 1.1, 0.35416666666667
90314, 1.3875, 1.1, 0.375
90315, 1.4083333333333, 1.075, 0.375
90316, 1.4083333333333, 1.05, 0.35416666666667
90317, 1.3875, 1.05, 0.375
90318, 1.4083333333333, 1.025, 0.375
90319, 1.4083333333333, 1, 0.35416666666667
90320, 1.3875, 1, 0.375
90321, 1.4083333333333, 0.975, 0.375
90322, 1.4083333333333, 0.95, 0.35416666666667
90323, 1.3875, 0.95, 0.375
90324, 1.4083333333333, 0.925, 0.375
90325, 1.4083333333333, 0.9, 0.35416666666667
90326, 1.3875, 0.9, 0.375
90327, 1.4083333333333, 0.875, 0.375
90328, 1.4083333333333, 0.85, 0.35416666666667
90329, 1.3875, 0.85, 0.375
90330, 1.4083333333333, 0.825, 0.375
90331, 1.4083333333333, 0.8, 0.35416666666667
90332, 1.3875, 0.8, 0.375
90333, 1.4083333333333, 0.775, 0.375
90334, 1.4083333333333, 0.75, 0.35416666666667
90335, 1.3875, 0.75, 0.375
90336, 1.4083333333333, 0.725, 0.375
90337, 1.4083333333333, 0.7, 0.35416666666667
90338, 1.3875, 0.7, 0.375
90339, 1.4083333333333, 0.675, 0.375
90340, 1.4083333333333, 0.65, 0.35416666666667
90341, 1.3875, 0.65, 0.375
90342, 1.4083333333333, 0.625, 0.375
90343, 1.4083333333333, 0.6, 0.35416666666667
90344, 1.3875, 0.6, 0.375
90345, 1.4083333333333, 0.575, 0.375
90346, 1.4083333333333, 0.55, 0.35416666666667
90347, 1.3875, 0.55, 0.375
90348, 1.4083333333333, 0.525, 0.375
90349, 1.4083333333333, 0.5, 0.35416666666667
90350, 1.3875, 0.5, 0.375
90351, 1.4083333333333, 0.475, 0.375
90352, 1.4083333333333, 0.45, 0.35416666666667
90353, 1.3875, 0.45, 0.375
90354, 1.4083333333333, 0.425, 0.375
90355, 1.4083333333333, 0.4, 0.35416666666667
90356, 1.3875, 0.4, 0.375
90357, 1.4083333333333, 0.375, 0.375
90358, 1.4083333333333, 0.35, 0.35416666666667
90359, 1.3875, 0.35, 0.375
90360, 1.4083333333333, 0.325, 0.375
90361, 1.4083333333333, 0.3, 0.35416666666667
90362, 1.3875, 0.3, 0.375
90363, 1.4083333333333, 0.275, 0.375
90364, 1.4083333333333, 0.25, 0.35416666666667
90365, 1.3875, 0.25, 0.375
90366, 1.4083333333333, 0.225, 0.375
90367, 1.4083333333333, 0.2, 0.35416666666667
90368, 1.3875, 0.2, 0.375
90369, 1.4083333333333, 0.175, 0.375
90370, 1.45, 1.325, 0.375
90371, 1.45, 1.3, 0.35416666666667
90372, 1.4291666666667, 1.3, 0.375
90373, 1.45, 1.275, 0.375
90374, 1.45, 1.25, 0.35416666666667
90375, 1.4291666666667, 1.25, 0.375
90376, 1.45, 1.225, 0.375
90377, 1.45, 1.2, 0.35416666666667
90378, 1.4291666666667, 1.2, 0.375
90379, 1.45, 1.175, 0.375
90380, 1.45, 1.15, 0.35416666666667
90381, 1.4291666666667, 1.15, 0.375
90382, 1.45, 1.125, 0.375
90383, 1.45, 1.1, 0.35416666666667
90384, 1.4291666666667, 1.1, 0.375
90385, 1.45, 1.075, 0.375
90386, 1.45, 1.05, 0.35416666666667
90387, 1.4291666666667, 1.05, 0.375
90388, 1.45, 1.025, 0.375
90389, 1.45, 1, 0.35416666666667
90390, 1.4291666666667, 1, 0.375
90391, 1.45, 0.975, 0.375
90392, 1.45, 0.95, 0.35416666666667
90393, 1.4291666666667, 0.95, 0.375
90394, 1.45, 0.925, 0.375
90395, 1.45, 0.9, 0.35416666666667
90396, 1.4291666666667, 0.9, 0.375
90397, 1.45, 0.875, 0.375
90398, 1.45, 0.85, 0.35416666666667
90399, 1.4291666666667, 0.85, 0.375
90400, 1.45, 0.825, 0.375
90401, 1.45, 0.8, 0.35416666666667
90402, 1.4291666666667, 0.8, 0.375
90403, 1.45, 0.775, 0.375
90404, 1.45, 0.75, 0.35416666666667
90405, 1.4291666666667, 0.75, 0.375
90406, 1.45, 0.725, 0.375
90407, 1.45, 0.7, 0.35416666666667
90408, 1.4291666666667, 0.7, 0.375
90409, 1.45, 0.675, 0.375
90410, 1.45, 0.65, 0.35416666666667
90411, 1.4291666666667, 0.65, 0.375
90412, 1.45, 0.625, 0.375
90413, 1.45, 0.6, 0.35416666666667
90414, 1.4291666666667, 0.6, 0.375
90415, 1.45, 0.575, 0.375
90416, 1.45, 0.55, 0.35416666666667
90417, 1.4291666666667, 0.55, 0.375
90418, 1.45, 0.525, 0.375
90419, 1.45, 0.5, 0.35416666666667
90420, 1.4291666666667, 0.5, 0.375
90421, 1.45, 0.475, 0.375
90422, 1.45, 0.45, 0.35416666666667
90423, 1.4291666666667, 0.45, 0.375
90424, 1.45, 0.425, 0.375
90425, 1.45, 0.4, 0.35416666666667
90426, 1.4291666666667, 0.4, 0.375
90427, 1.45, 0.375, 0.375
90428, 1.45, 0.35, 0.35416666666667
90429, 1.4291666666667, 0.35, 0.375
90430, 1.45, 0.325, 0.375
90431, 1.45, 0.3, 0.35416666666667
90432, 1.4291666666667, 0.3, 0.375
90433, 1.45, 0.275, 0.375
90434, 1.45, 0.25, 0.35416666666667
90435, 1.4291666666667, 0.25, 0.375
90436, 1.45, 0.225, 0.375
90437, 1.45, 0.2, 0.35416666666667
90438, 1.4291666666667, 0.2, 0.375
90439, 1.45, 0.175, 0.375
90440, 1.4916666666667, 1.325, 0.375
90441, 1.4916666666667, 1.3, 0.35416666666667
90442, 1.4708333333333, 1.3, 0.375
90443, 1.4916666666667, 1.275, 0.375
90444, 1.4916666666667, 1.25, 0.35416666666667
90445, 1.4708333333333, 1.25, 0.375
90446, 1.4916666666667, 1.225, 0.375
90447, 1.4916666666667, 1.2, 0.35416666666667
90448, 1.4708333333333, 1.2, 0.375
90449, 1.4916666666667, 1.175, 0.375
90450, 1.4916666666667, 1.15, 0.35416666666667
90451, 1.4708333333333, 1.15, 0.375
90452, 1.4916666666667, 1.125, 0.375
90453, 1.4916666666667, 1.1, 0.35416666666667
90454, 1.4708333333333, 1.1, 0.375
90455, 1.4916666666667, 1.075, 0.375
90456, 1.4916666666667, 1.05, 0.35416666666667
90457, 1.4708333333333, 1.05, 0.375
90458, 1.4916666666667, 1.025, 0.375
90459, 1.4916666666667, 1, 0.35416666666667
90460, 1.4708333333333, 1, 0.375
90461, 1.4916666666667, 0.975, 0.375
90462, 1.4916666666667, 0.95, 0.35416666666667
90463, 1.4708333333333, 0.95, 0.375
90464, 1.4916666666667, 0.925, 0.375
90465, 1.4916666666667, 0.9, 0.35416666666667
90466, 1.4708333333333, 0.9, 0.375
90467, 1.4916666666667, 0.875, 0.375
90468, 1.4916666666667, 0.85, 0.35416666666667
90469, 1.4708333333333, 0.85, 0.375
90470, 1.4916666666667, 0.825, 0.375
90471, 1.4916666666667, 0.8, 0.35416666666667
90472, 1.4708333333333, 0.8, 0.375
90473, 1.4916666666667, 0.775, 0.375
90474, 1.4916666666667, 0.75, 0.35416666666667
90475, 1.4708333333333, 0.75, 0.375
90476, 1.4916666666667, 0.725, 0.375
90477, 1.4916666666667, 0.7, 0.35416666666667
90478, 1.4708333333333, 0.7, 0.375
90479, 1.4916666666667, 0.675, 0.375
90480, 1.4916666666667, 0.65, 0.35416666666667
90481, 1.4708333333333, 0.65, 0.375
90482, 1.4916666666667, 0.625, 0.375
90483, 1.4916666666667, 0.6, 0.35416666666667
90484, 1.4708333333333, 0.6, 0.375
90485, 1.4916666666667, 0.575, 0.375
90486, 1.4916666666667, 0.55, 0.35416666666667
90487, 1.4708333333333, 0.55, 0.375
90488, 1.4916666666667, 0.525, 0.375
90489, 1.4916666666667, 0.5, 0.35416666666667
90490, 1.4708333333333, 0.5, 0.375
90491, 1.4916666666667, 0.475, 0.375
90492, 1.4916666666667, 0.45, 0.35416666666667
90493, 1.4708333333333, 0.45, 0.375
90494, 1.4916666666667, 0.425, 0.375
90495, 1.4916666666667, 0.4, 0.35416666666667
90496, 1.4708333333333, 0.4, 0.375
90497, 1.4916666666667, 0.375, 0.375
90498, 1.4916666666667, 0.35, 0.35416666666667
90499, 1.4708333333333, 0.35, 0.375
90500, 1.4916666666667, 0.325, 0.375
90501, 1.4916666666667, 0.3, 0.35416666666667
90502, 1.4708333333333, 0.3, 0.375
90503, 1.4916666666667, 0.275, 0.375
90504, 1.4916666666667, 0.25, 0.35416666666667
90505, 1.4708333333333, 0.25, 0.375
90506, 1.4916666666667, 0.225, 0.375
90507, 1.4916666666667, 0.2, 0.35416666666667
90508, 1.4708333333333, 0.2, 0.375
90509, 1.4916666666667, 0.175, 0.375
90510, 1.5333333333333, 1.325, 0.375
90511, 1.5333333333333, 1.3, 0.35416666666667
90512, 1.5125, 1.3, 0.375
90513, 1.5333333333333, 1.275, 0.375
90514, 1.5333333333333, 1.25, 0.35416666666667
90515, 1.5125, 1.25, 0.375
90516, 1.5333333333333, 1.225, 0.375
90517, 1.5333333333333, 1.2, 0.35416666666667
90518, 1.5125, 1.2, 0.375
90519, 1.5333333333333, 1.175, 0.375
90520, 1.5333333333333, 1.15, 0.35416666666667
90521, 1.5125, 1.15, 0.375
90522, 1.5333333333333, 1.125, 0.375
90523, 1.5333333333333, 1.1, 0.35416666666667
90524, 1.5125, 1.1, 0.375
90525, 1.5333333333333, 1.075, 0.375
90526, 1.5333333333333, 1.05, 0.35416666666667
90527, 1.5125, 1.05, 0.375
90528, 1.5333333333333, 1.025, 0.375
90529, 1.5333333333333, 1, 0.35416666666667
90530, 1.5125, 1, 0.375
90531, 1.5333333333333, 0.975, 0.375
90532, 1.5333333333333, 0.95, 0.35416666666667
90533, 1.5125, 0.95, 0.375
90534, 1.5333333333333, 0.925, 0.375
90535, 1.5333333333333, 0.9, 0.35416666666667
90536, 1.5125, 0.9, 0.375
90537, 1.5333333333333, 0.875, 0.375
90538, 1.5333333333333, 0.85, 0.35416666666667
90539, 1.5125, 0.85, 0.375
90540, 1.5333333333333, 0.825, 0.375
90541, 1.5333333333333, 0.8, 0.35416666666667
90542, 1.5125, 0.8, 0.375
90543, 1.5333333333333, 0.775, 0.375
90544, 1.5333333333333, 0.75, 0.35416666666667
90545, 1.5125, 0.75, 0.375
90546, 1.5333333333333, 0.725, 0.375
90547, 1.5333333333333, 0.7, 0.35416666666667
90548, 1.5125, 0.7, 0.375
90549, 1.5333333333333, 0.675, 0.375
90550, 1.5333333333333, 0.65, 0.35416666666667
90551, 1.5125, 0.65, 0.375
90552, 1.5333333333333, 0.625, 0.375
90553, 1.5333333333333, 0.6, 0.35416666666667
90554, 1.5125, 0.6, 0.375
90555, 1.5333333333333, 0.575, 0.375
90556, 1.5333333333333, 0.55, 0.35416666666667
90557, 1.5125, 0.55, 0.375
90558, 1.5333333333333, 0.525, 0.375
90559, 1.5333333333333, 0.5, 0.35416666666667
90560, 1.5125, 0.5, 0.375
90561, 1.5333333333333, 0.475, 0.375
90562, 1.5333333333333, 0.45, 0.35416666666667
90563, 1.5125, 0.45, 0.375
90564, 1.5333333333333, 0.425, 0.375
90565, 1.5333333333333, 0.4, 0.35416666666667
90566, 1.5125, 0.4, 0.375
90567, 1.5333333333333, 0.375, 0.375
90568, 1.5333333333333, 0.35, 0.35416666666667
90569, 1.5125, 0.35, 0.375
90570, 1.5333333333333, 0.325, 0.375
90571, 1.5333333333333, 0.3, 0.35416666666667
90572, 1.5125, 0.3, 0.375
90573, 1.5333333333333, 0.275, 0.375
90574, 1.5333333333333, 0.25, 0.35416666666667
90575, 1.5125, 0.25, 0.375
90576, 1.5333333333333, 0.225, 0.375
90577, 1.5333333333333, 0.2, 0.35416666666667
90578, 1.5125, 0.2, 0.375
90579, 1.5333333333333, 0.175, 0.375
90580, 1.575, 1.325, 0.375
90581, 1.575, 1.3, 0.35416666666667
90582, 1.5541666666667, 1.3, 0.375
90583, 1.575, 1.275, 0.375
90584, 1.575, 1.25, 0.35416666666667
90585, 1.5541666666667, 1.25, 0.375
90586, 1.575, 1.225, 0.375
90587, 1.575, 1.2, 0.35416666666667
90588, 1.5541666666667, 1.2, 0.375
90589, 1.575, 1.175, 0.375
90590, 1.575, 1.15, 0.35416666666667
90591, 1.5541666666667, 1.15, 0.375
90592, 1.575, 1.125, 0.375
90593, 1.575, 1.1, 0.35416666666667
90594, 1.5541666666667, 1.1, 0.375
90595, 1.575, 1.075, 0.375
90596, 1.575, 1.05, 0.35416666666667
90597, 1.5541666666667, 1.05, 0.375
90598, 1.575, 1.025, 0.375
90599, 1.575, 1, 0.35416666666667
90600, 1.5541666666667, 1, 0.375
90601, 1.575, 0.975, 0.375
90602, 1.575, 0.95, 0.35416666666667
90603, 1.5541666666667, 0.95, 0.375
90604, 1.575, 0.925, 0.375
90605, 1.575, 0.9, 0.35416666666667
90606, 1.5541666666667, 0.9, 0.375
90607, 1.575, 0.875, 0.375
90608, 1.575, 0.85, 0.35416666666667
90609, 1.5541666666667, 0.85, 0.375
90610, 1.575, 0.825, 0.375
90611, 1.575, 0.8, 0.35416666666667
90612, 1.5541666666667, 0.8, 0.375
90613, 1.575, 0.775, 0.375
90614, 1.575, 0.75, 0.35416666666667
90615, 1.5541666666667, 0.75, 0.375
90616, 1.575, 0.725, 0.375
90617, 1.575, 0.7, 0.35416666666667
90618, 1.5541666666667, 0.7, 0.375
90619, 1.575, 0.675, 0.375
90620, 1.575, 0.65, 0.35416666666667
90621, 1.5541666666667, 0.65, 0.375
90622, 1.575, 0.625, 0.375
90623, 1.575, 0.6, 0.35416666666667
90624, 1.5541666666667, 0.6, 0.375
90625, 1.575, 0.575, 0.375
90626, 1.575, 0.55, 0.35416666666667
90627, 1.5541666666667, 0.55, 0.375
90628, 1.575, 0.525, 0.375
90629, 1.575, 0.5, 0.35416666666667
90630, 1.5541666666667, 0.5, 0.375
90631, 1.575, 0.475, 0.375
90632, 1.575, 0.45, 0.35416666666667
90633, 1.5541666666667, 0.45, 0.375
90634, 1.575, 0.425, 0.375
90635, 1.575, 0.4, 0.35416666666667
90636, 1.5541666666667, 0.4, 0.375
90637, 1.575, 0.375, 0.375
90638, 1.575, 0.35, 0.35416666666667
90639, 1.5541666666667, 0.35, 0.375
90640, 1.575, 0.325, 0.375
90641, 1.575, 0.3, 0.35416666666667
90642, 1.5541666666667, 0.3, 0.375
90643, 1.575, 0.275, 0.375
90644, 1.575, 0.25, 0.35416666666667
90645, 1.5541666666667, 0.25, 0.375
90646, 1.575, 0.225, 0.375
90647, 1.575, 0.2, 0.35416666666667
90648, 1.5541666666667, 0.2, 0.375
90649, 1.575, 0.175, 0.375
90650, 1.6166666666667, 1.325, 0.375
90651, 1.6166666666667, 1.3, 0.35416666666667
90652, 1.5958333333333, 1.3, 0.375
90653, 1.6166666666667, 1.275, 0.375
90654, 1.6166666666667, 1.25, 0.35416666666667
90655, 1.5958333333333, 1.25, 0.375
90656, 1.6166666666667, 1.225, 0.375
90657, 1.6166666666667, 1.2, 0.35416666666667
90658, 1.5958333333333, 1.2, 0.375
90659, 1.6166666666667, 1.175, 0.375
90660, 1.6166666666667, 1.15, 0.35416666666667
90661, 1.5958333333333, 1.15, 0.375
90662, 1.6166666666667, 1.125, 0.375
90663, 1.6166666666667, 1.1, 0.35416666666667
90664, 1.5958333333333, 1.1, 0.375
90665, 1.6166666666667, 1.075, 0.375
90666, 1.6166666666667, 1.05, 0.35416666666667
90667, 1.5958333333333, 1.05, 0.375
90668, 1.6166666666667, 1.025, 0.375
90669, 1.6166666666667, 1, 0.35416666666667
90670, 1.5958333333333, 1, 0.375
90671, 1.6166666666667, 0.975, 0.375
90672, 1.6166666666667, 0.95, 0.35416666666667
90673, 1.5958333333333, 0.95, 0.375
90674, 1.6166666666667, 0.925, 0.375
90675, 1.6166666666667, 0.9, 0.35416666666667
90676, 1.5958333333333, 0.9, 0.375
90677, 1.6166666666667, 0.875, 0.375
90678, 1.6166666666667, 0.85, 0.35416666666667
90679, 1.5958333333333, 0.85, 0.375
90680, 1.6166666666667, 0.825, 0.375
90681, 1.6166666666667, 0.8, 0.35416666666667
90682, 1.5958333333333, 0.8, 0.375
90683, 1.6166666666667, 0.775, 0.375
90684, 1.6166666666667, 0.75, 0.35416666666667
90685, 1.5958333333333, 0.75, 0.375
90686, 1.6166666666667, 0.725, 0.375
90687, 1.6166666666667, 0.7, 0.35416666666667
90688, 1.5958333333333, 0.7, 0.375
90689, 1.6166666666667, 0.675, 0.375
90690, 1.6166666666667, 0.65, 0.35416666666667
90691, 1.5958333333333, 0.65, 0.375
90692, 1.6166666666667, 0.625, 0.375
90693, 1.6166666666667, 0.6, 0.35416666666667
90694, 1.5958333333333, 0.6, 0.375
90695, 1.6166666666667, 0.575, 0.375
90696, 1.6166666666667, 0.55, 0.35416666666667
90697, 1.5958333333333, 0.55, 0.375
90698, 1.6166666666667, 0.525, 0.375
90699, 1.6166666666667, 0.5, 0.35416666666667
90700, 1.5958333333333, 0.5, 0.375
90701, 1.6166666666667, 0.475, 0.375
90702, 1.6166666666667, 0.45, 0.35416666666667
90703, 1.5958333333333, 0.45, 0.375
90704, 1.6166666666667, 0.425, 0.375
90705, 1.6166666666667, 0.4, 0.35416666666667
90706, 1.5958333333333, 0.4, 0.375
90707, 1.6166666666667, 0.375, 0.375
90708, 1.6166666666667, 0.35, 0.35416666666667
90709, 1.5958333333333, 0.35, 0.375
90710, 1.6166666666667, 0.325, 0.375
90711, 1.6166666666667, 0.3, 0.35416666666667
90712, 1.5958333333333, 0.3, 0.375
90713, 1.6166666666667, 0.275, 0.375
90714, 1.6166666666667, 0.25, 0.35416666666667
90715, 1.5958333333333, 0.25, 0.375
90716, 1.6166666666667, 0.225, 0.375
90717, 1.6166666666667, 0.2, 0.35416666666667
90718, 1.5958333333333, 0.2, 0.375
90719, 1.6166666666667, 0.175, 0.375
90720, 1.6583333333333, 1.325, 0.375
90721, 1.6583333333333, 1.3, 0.35416666666667
90722, 1.6375, 1.3, 0.375
90723, 1.6583333333333, 1.275, 0.375
90724, 1.6583333333333, 1.25, 0.35416666666667
90725, 1.6375, 1.25, 0.375
90726, 1.6583333333333, 1.225, 0.375
90727, 1.6583333333333, 1.2, 0.35416666666667
90728, 1.6375, 1.2, 0.375
90729, 1.6583333333333, 1.175, 0.375
90730, 1.6583333333333, 1.15, 0.35416666666667
90731, 1.6375, 1.15, 0.375
90732, 1.6583333333333, 1.125, 0.375
90733, 1.6583333333333, 1.1, 0.35416666666667
90734, 1.6375, 1.1, 0.375
90735, 1.6583333333333, 1.075, 0.375
90736, 1.6583333333333, 1.05, 0.35416666666667
90737, 1.6375, 1.05, 0.375
90738, 1.6583333333333, 1.025, 0.375
90739, 1.6583333333333, 1, 0.35416666666667
90740, 1.6375, 1, 0.375
90741, 1.6583333333333, 0.975, 0.375
90742, 1.6583333333333, 0.95, 0.35416666666667
90743, 1.6375, 0.95, 0.375
90744, 1.6583333333333, 0.925, 0.375
90745, 1.6583333333333, 0.9, 0.35416666666667
90746, 1.6375, 0.9, 0.375
90747, 1.6583333333333, 0.875, 0.375
90748, 1.6583333333333, 0.85, 0.35416666666667
90749, 1.6375, 0.85, 0.375
90750, 1.6583333333333, 0.825, 0.375
90751, 1.6583333333333, 0.8, 0.35416666666667
90752, 1.6375, 0.8, 0.375
90753, 1.6583333333333, 0.775, 0.375
90754, 1.6583333333333, 0.75, 0.35416666666667
90755, 1.6375, 0.75, 0.375
90756, 1.6583333333333, 0.725, 0.375
90757, 1.6583333333333, 0.7, 0.35416666666667
90758, 1.6375, 0.7, 0.375
90759, 1.6583333333333, 0.675, 0.375
90760, 1.6583333333333, 0.65, 0.35416666666667
90761, 1.6375, 0.65, 0.375
90762, 1.6583333333333, 0.625, 0.375
90763, 1.6583333333333, 0.6, 0.35416666666667
90764, 1.6375, 0.6, 0.375
90765, 1.6583333333333, 0.575, 0.375
90766, 1.6583333333333, 0.55, 0.35416666666667
90767, 1.6375, 0.55, 0.375
90768, 1.6583333333333, 0.525, 0.375
90769, 1.6583333333333, 0.5, 0.35416666666667
90770, 1.6375, 0.5, 0.375
90771, 1.6583333333333, 0.475, 0.375
90772, 1.6583333333333, 0.45, 0.35416666666667
90773, 1.6375, 0.45, 0.375
90774, 1.6583333333333, 0.425, 0.375
90775, 1.6583333333333, 0.4, 0.35416666666667
90776, 1.6375, 0.4, 0.375
90777, 1.6583333333333, 0.375, 0.375
90778, 1.6583333333333, 0.35, 0.35416666666667
90779, 1.6375, 0.35, 0.375
90780, 1.6583333333333, 0.325, 0.375
90781, 1.6583333333333, 0.3, 0.35416666666667
90782, 1.6375, 0.3, 0.375
90783, 1.6583333333333, 0.275, 0.375
90784, 1.6583333333333, 0.25, 0.35416666666667
90785, 1.6375, 0.25, 0.375
90786, 1.6583333333333, 0.225, 0.375
90787, 1.6583333333333, 0.2, 0.35416666666667
90788, 1.6375, 0.2, 0.375
90789, 1.6583333333333, 0.175, 0.375
90790, 1.7, 1.325, 0.375
90791, 1.7, 1.3, 0.35416666666667
90792, 1.6791666666667, 1.3, 0.375
90793, 1.7, 1.275, 0.375
90794, 1.7, 1.25, 0.35416666666667
90795, 1.6791666666667, 1.25, 0.375
90796, 1.7, 1.225, 0.375
90797, 1.7, 1.2, 0.35416666666667
90798, 1.6791666666667, 1.2, 0.375
90799, 1.7, 1.175, 0.375
90800, 1.7, 1.15, 0.35416666666667
90801, 1.6791666666667, 1.15, 0.375
90802, 1.7, 1.125, 0.375
90803, 1.7, 1.1, 0.35416666666667
90804, 1.6791666666667, 1.1, 0.375
90805, 1.7, 1.075, 0.375
90806, 1.7, 1.05, 0.35416666666667
90807, 1.6791666666667, 1.05, 0.375
90808, 1.7, 1.025, 0.375
90809, 1.7, 1, 0.35416666666667
90810, 1.6791666666667, 1, 0.375
90811, 1.7, 0.975, 0.375
90812, 1.7, 0.95, 0.35416666666667
90813, 1.6791666666667, 0.95, 0.375
90814, 1.7, 0.925, 0.375
90815, 1.7, 0.9, 0.35416666666667
90816, 1.6791666666667, 0.9, 0.375
90817, 1.7, 0.875, 0.375
90818, 1.7, 0.85, 0.35416666666667
90819, 1.6791666666667, 0.85, 0.375
90820, 1.7, 0.825, 0.375
90821, 1.7, 0.8, 0.35416666666667
90822, 1.6791666666667, 0.8, 0.375
90823, 1.7, 0.775, 0.375
90824, 1.7, 0.75, 0.35416666666667
90825, 1.6791666666667, 0.75, 0.375
90826, 1.7, 0.725, 0.375
90827, 1.7, 0.7, 0.35416666666667
90828, 1.6791666666667, 0.7, 0.375
90829, 1.7, 0.675, 0.375
90830, 1.7, 0.65, 0.35416666666667
90831, 1.6791666666667, 0.65, 0.375
90832, 1.7, 0.625, 0.375
90833, 1.7, 0.6, 0.35416666666667
90834, 1.6791666666667, 0.6, 0.375
90835, 1.7, 0.575, 0.375
90836, 1.7, 0.55, 0.35416666666667
90837, 1.6791666666667, 0.55, 0.375
90838, 1.7, 0.525, 0.375
90839, 1.7, 0.5, 0.35416666666667
90840, 1.6791666666667, 0.5, 0.375
90841, 1.7, 0.475, 0.375
90842, 1.7, 0.45, 0.35416666666667
90843, 1.6791666666667, 0.45, 0.375
90844, 1.7, 0.425, 0.375
90845, 1.7, 0.4, 0.35416666666667
90846, 1.6791666666667, 0.4, 0.375
90847, 1.7, 0.375, 0.375
90848, 1.7, 0.35, 0.35416666666667
90849, 1.6791666666667, 0.35, 0.375
90850, 1.7, 0.325, 0.375
90851, 1.7, 0.3, 0.35416666666667
90852, 1.6791666666667, 0.3, 0.375
90853, 1.7, 0.275, 0.375
90854, 1.7, 0.25, 0.35416666666667
90855, 1.6791666666667, 0.25, 0.375
90856, 1.7, 0.225, 0.375
90857, 1.7, 0.2, 0.35416666666667
90858, 1.6791666666667, 0.2, 0.375
90859, 1.7, 0.175, 0.375
90860, 1.7416666666667, 1.325, 0.375
90861, 1.7416666666667, 1.3, 0.35416666666667
90862, 1.7208333333333, 1.3, 0.375
90863, 1.7416666666667, 1.275, 0.375
90864, 1.7416666666667, 1.25, 0.35416666666667
90865, 1.7208333333333, 1.25, 0.375
90866, 1.7416666666667, 1.225, 0.375
90867, 1.7416666666667, 1.2, 0.35416666666667
90868, 1.7208333333333, 1.2, 0.375
90869, 1.7416666666667, 1.175, 0.375
90870, 1.7416666666667, 1.15, 0.35416666666667
90871, 1.7208333333333, 1.15, 0.375
90872, 1.7416666666667, 1.125, 0.375
90873, 1.7416666666667, 1.1, 0.35416666666667
90874, 1.7208333333333, 1.1, 0.375
90875, 1.7416666666667, 1.075, 0.375
90876, 1.7416666666667, 1.05, 0.35416666666667
90877, 1.7208333333333, 1.05, 0.375
90878, 1.7416666666667, 1.025, 0.375
90879, 1.7416666666667, 1, 0.35416666666667
90880, 1.7208333333333, 1, 0.375
90881, 1.7416666666667, 0.975, 0.375
90882, 1.7416666666667, 0.95, 0.35416666666667
90883, 1.7208333333333, 0.95, 0.375
90884, 1.7416666666667, 0.925, 0.375
90885, 1.7416666666667, 0.9, 0.35416666666667
90886, 1.7208333333333, 0.9, 0.375
90887, 1.7416666666667, 0.875, 0.375
90888, 1.7416666666667, 0.85, 0.35416666666667
90889, 1.7208333333333, 0.85, 0.375
90890, 1.7416666666667, 0.825, 0.375
90891, 1.7416666666667, 0.8, 0.35416666666667
90892, 1.7208333333333, 0.8, 0.375
90893, 1.7416666666667, 0.775, 0.375
90894, 1.7416666666667, 0.75, 0.35416666666667
90895, 1.7208333333333, 0.75, 0.375
90896, 1.7416666666667, 0.725, 0.375
90897, 1.7416666666667, 0.7, 0.35416666666667
90898, 1.7208333333333, 0.7, 0.375
90899, 1.7416666666667, 0.675, 0.375
90900, 1.7416666666667, 0.65, 0.35416666666667
90901, 1.7208333333333, 0.65, 0.375
90902, 1.7416666666667, 0.625, 0.375
90903, 1.7416666666667, 0.6, 0.35416666666667
90904, 1.7208333333333, 0.6, 0.375
90905, 1.7416666666667, 0.575, 0.375
90906, 1.7416666666667, 0.55, 0.35416666666667
90907, 1.7208333333333, 0.55, 0.375
90908, 1.7416666666667, 0.525, 0.375
90909, 1.7416666666667, 0.5, 0.35416666666667
90910, 1.7208333333333, 0.5, 0.375
90911, 1.7416666666667, 0.475, 0.375
90912, 1.7416666666667, 0.45, 0.35416666666667
90913, 1.7208333333333, 0.45, 0.375
90914, 1.7416666666667, 0.425, 0.375
90915, 1.7416666666667, 0.4, 0.35416666666667
90916, 1.7208333333333, 0.4, 0.375
90917, 1.7416666666667, 0.375, 0.375
90918, 1.7416666666667, 0.35, 0.35416666666667
90919, 1.7208333333333, 0.35, 0.375
90920, 1.7416666666667, 0.325, 0.375
90921, 1.7416666666667, 0.3, 0.35416666666667
90922, 1.7208333333333, 0.3, 0.375
90923, 1.7416666666667, 0.275, 0.375
90924, 1.7416666666667, 0.25, 0.35416666666667
90925, 1.7208333333333, 0.25, 0.375
90926, 1.7416666666667, 0.225, 0.375
90927, 1.7416666666667, 0.2, 0.35416666666667
90928, 1.7208333333333, 0.2, 0.375
90929, 1.7416666666667, 0.175, 0.375
90930, 1.7833333333333, 1.325, 0.375
90931, 1.7833333333333, 1.3, 0.35416666666667
90932, 1.7625, 1.3, 0.375
90933, 1.7833333333333, 1.275, 0.375
90934, 1.7833333333333, 1.25, 0.35416666666667
90935, 1.7625, 1.25, 0.375
90936, 1.7833333333333, 1.225, 0.375
90937, 1.7833333333333, 1.2, 0.35416666666667
90938, 1.7625, 1.2, 0.375
90939, 1.7833333333333, 1.175, 0.375
90940, 1.7833333333333, 1.15, 0.35416666666667
90941, 1.7625, 1.15, 0.375
90942, 1.7833333333333, 1.125, 0.375
90943, 1.7833333333333, 1.1, 0.35416666666667
90944, 1.7625, 1.1, 0.375
90945, 1.7833333333333, 1.075, 0.375
90946, 1.7833333333333, 1.05, 0.35416666666667
90947, 1.7625, 1.05, 0.375
90948, 1.7833333333333, 1.025, 0.375
90949, 1.7833333333333, 1, 0.35416666666667
90950, 1.7625, 1, 0.375
90951, 1.7833333333333, 0.975, 0.375
90952, 1.7833333333333, 0.95, 0.35416666666667
90953, 1.7625, 0.95, 0.375
90954, 1.7833333333333, 0.925, 0.375
90955, 1.7833333333333, 0.9, 0.35416666666667
90956, 1.7625, 0.9, 0.375
90957, 1.7833333333333, 0.875, 0.375
90958, 1.7833333333333, 0.85, 0.35416666666667
90959, 1.7625, 0.85, 0.375
90960, 1.7833333333333, 0.825, 0.375
90961, 1.7833333333333, 0.8, 0.35416666666667
90962, 1.7625, 0.8, 0.375
90963, 1.7833333333333, 0.775, 0.375
90964, 1.7833333333333, 0.75, 0.35416666666667
90965, 1.7625, 0.75, 0.375
90966, 1.7833333333333, 0.725, 0.375
90967, 1.7833333333333, 0.7, 0.35416666666667
90968, 1.7625, 0.7, 0.375
90969, 1.7833333333333, 0.675, 0.375
90970, 1.7833333333333, 0.65, 0.35416666666667
90971, 1.7625, 0.65, 0.375
90972, 1.7833333333333, 0.625, 0.375
90973, 1.7833333333333, 0.6, 0.35416666666667
90974, 1.7625, 0.6, 0.375
90975, 1.7833333333333, 0.575, 0.375
90976, 1.7833333333333, 0.55, 0.35416666666667
90977, 1.7625, 0.55, 0.375
90978, 1.7833333333333, 0.525, 0.375
90979, 1.7833333333333, 0.5, 0.35416666666667
90980, 1.7625, 0.5, 0.375
90981, 1.7833333333333, 0.475, 0.375
90982, 1.7833333333333, 0.45, 0.35416666666667
90983, 1.7625, 0.45, 0.375
90984, 1.7833333333333, 0.425, 0.375
90985, 1.7833333333333, 0.4, 0.35416666666667
90986, 1.7625, 0.4, 0.375
90987, 1.7833333333333, 0.375, 0.375
90988, 1.7833333333333, 0.35, 0.35416666666667
90989, 1.7625, 0.35, 0.375
90990, 1.7833333333333, 0.325, 0.375
90991, 1.7833333333333, 0.3, 0.35416666666667
90992, 1.7625, 0.3, 0.375
90993, 1.7833333333333, 0.275, 0.375
90994, 1.7833333333333, 0.25, 0.35416666666667
90995, 1.7625, 0.25, 0.375
90996, 1.7833333333333, 0.225, 0.375
90997, 1.7833333333333, 0.2, 0.35416666666667
90998, 1.7625, 0.2, 0.375
90999, 1.7833333333333, 0.175, 0.375
91000, 1.825, 1.325, 0.375
91001, 1.825, 1.3, 0.35416666666667
91002, 1.8041666666667, 1.3, 0.375
91003, 1.825, 1.275, 0.375
91004, 1.825, 1.25, 0.35416666666667
91005, 1.8041666666667, 1.25, 0.375
91006, 1.825, 1.225, 0.375
91007, 1.825, 1.2, 0.35416666666667
91008, 1.8041666666667, 1.2, 0.375
91009, 1.825, 1.175, 0.375
91010, 1.825, 1.15, 0.35416666666667
91011, 1.8041666666667, 1.15, 0.375
91012, 1.825, 1.125, 0.375
91013, 1.825, 1.1, 0.35416666666667
91014, 1.8041666666667, 1.1, 0.375
91015, 1.825, 1.075, 0.375
91016, 1.825, 1.05, 0.35416666666667
91017, 1.8041666666667, 1.05, 0.375
91018, 1.825, 1.025, 0.375
91019, 1.825, 1, 0.35416666666667
91020, 1.8041666666667, 1, 0.375
91021, 1.825, 0.975, 0.375
91022, 1.825, 0.95, 0.35416666666667
91023, 1.8041666666667, 0.95, 0.375
91024, 1.825, 0.925, 0.375
91025, 1.825, 0.9, 0.35416666666667
91026, 1.8041666666667, 0.9, 0.375
91027, 1.825, 0.875, 0.375
91028, 1.825, 0.85, 0.35416666666667
91029, 1.8041666666667, 0.85, 0.375
91030, 1.825, 0.825, 0.375
91031, 1.825, 0.8, 0.35416666666667
91032, 1.8041666666667, 0.8, 0.375
91033, 1.825, 0.775, 0.375
91034, 1.825, 0.75, 0.35416666666667
91035, 1.8041666666667, 0.75, 0.375
91036, 1.825, 0.725, 0.375
91037, 1.825, 0.7, 0.35416666666667
91038, 1.8041666666667, 0.7, 0.375
91039, 1.825, 0.675, 0.375
91040, 1.825, 0.65, 0.35416666666667
91041, 1.8041666666667, 0.65, 0.375
91042, 1.825, 0.625, 0.375
91043, 1.825, 0.6, 0.35416666666667
91044, 1.8041666666667, 0.6, 0.375
91045, 1.825, 0.575, 0.375
91046, 1.825, 0.55, 0.35416666666667
91047, 1.8041666666667, 0.55, 0.375
91048, 1.825, 0.525, 0.375
91049, 1.825, 0.5, 0.35416666666667
91050, 1.8041666666667, 0.5, 0.375
91051, 1.825, 0.475, 0.375
91052, 1.825, 0.45, 0.35416666666667
91053, 1.8041666666667, 0.45, 0.375
91054, 1.825, 0.425, 0.375
91055, 1.825, 0.4, 0.35416666666667
91056, 1.8041666666667, 0.4, 0.375
91057, 1.825, 0.375, 0.375
91058, 1.825, 0.35, 0.35416666666667
91059, 1.8041666666667, 0.35, 0.375
91060, 1.825, 0.325, 0.375
91061, 1.825, 0.3, 0.35416666666667
91062, 1.8041666666667, 0.3, 0.375
91063, 1.825, 0.275, 0.375
91064, 1.825, 0.25, 0.35416666666667
91065, 1.8041666666667, 0.25, 0.375
91066, 1.825, 0.225, 0.375
91067, 1.825, 0.2, 0.35416666666667
91068, 1.8041666666667, 0.2, 0.375
91069, 1.825, 0.175, 0.375
91070, 1.8666666666667, 1.325, 0.375
91071, 1.8666666666667, 1.3, 0.35416666666667
91072, 1.8458333333333, 1.3, 0.375
91073, 1.8666666666667, 1.275, 0.375
91074, 1.8666666666667, 1.25, 0.35416666666667
91075, 1.8458333333333, 1.25, 0.375
91076, 1.8666666666667, 1.225, 0.375
91077, 1.8666666666667, 1.2, 0.35416666666667
91078, 1.8458333333333, 1.2, 0.375
91079, 1.8666666666667, 1.175, 0.375
91080, 1.8666666666667, 1.15, 0.35416666666667
91081, 1.8458333333333, 1.15, 0.375
91082, 1.8666666666667, 1.125, 0.375
91083, 1.8666666666667, 1.1, 0.35416666666667
91084, 1.8458333333333, 1.1, 0.375
91085, 1.8666666666667, 1.075, 0.375
91086, 1.8666666666667, 1.05, 0.35416666666667
91087, 1.8458333333333, 1.05, 0.375
91088, 1.8666666666667, 1.025, 0.375
91089, 1.8666666666667, 1, 0.35416666666667
91090, 1.8458333333333, 1, 0.375
91091, 1.8666666666667, 0.975, 0.375
91092, 1.8666666666667, 0.95, 0.35416666666667
91093, 1.8458333333333, 0.95, 0.375
91094, 1.8666666666667, 0.925, 0.375
91095, 1.8666666666667, 0.9, 0.35416666666667
91096, 1.8458333333333, 0.9, 0.375
91097, 1.8666666666667, 0.875, 0.375
91098, 1.8666666666667, 0.85, 0.35416666666667
91099, 1.8458333333333, 0.85, 0.375
91100, 1.8666666666667, 0.825, 0.375
91101, 1.8666666666667, 0.8, 0.35416666666667
91102, 1.8458333333333, 0.8, 0.375
91103, 1.8666666666667, 0.775, 0.375
91104, 1.8666666666667, 0.75, 0.35416666666667
91105, 1.8458333333333, 0.75, 0.375
91106, 1.8666666666667, 0.725, 0.375
91107, 1.8666666666667, 0.7, 0.35416666666667
91108, 1.8458333333333, 0.7, 0.375
91109, 1.8666666666667, 0.675, 0.375
91110, 1.8666666666667, 0.65, 0.35416666666667
91111, 1.8458333333333, 0.65, 0.375
91112, 1.8666666666667, 0.625, 0.375
91113, 1.8666666666667, 0.6, 0.35416666666667
91114, 1.8458333333333, 0.6, 0.375
91115, 1.8666666666667, 0.575, 0.375
91116, 1.8666666666667, 0.55, 0.35416666666667
91117, 1.8458333333333, 0.55, 0.375
91118, 1.8666666666667, 0.525, 0.375
91119, 1.8666666666667, 0.5, 0.35416666666667
91120, 1.8458333333333, 0.5, 0.375
91121, 1.8666666666667, 0.475, 0.375
91122, 1.8666666666667, 0.45, 0.35416666666667
91123, 1.8458333333333, 0.45, 0.375
91124, 1.8666666666667, 0.425, 0.375
91125, 1.8666666666667, 0.4, 0.35416666666667
91126, 1.8458333333333, 0.4, 0.375
91127, 1.8666666666667, 0.375, 0.375
91128, 1.8666666666667, 0.35, 0.35416666666667
91129, 1.8458333333333, 0.35, 0.375
91130, 1.8666666666667, 0.325, 0.375
91131, 1.8666666666667, 0.3, 0.35416666666667
91132, 1.8458333333333, 0.3, 0.375
91133, 1.8666666666667, 0.275, 0.375
91134, 1.8666666666667, 0.25, 0.35416666666667
91135, 1.8458333333333, 0.25, 0.375
91136, 1.8666666666667, 0.225, 0.375
91137, 1.8666666666667, 0.2, 0.35416666666667
91138, 1.8458333333333, 0.2, 0.375
91139, 1.8666666666667, 0.175, 0.375
91140, 1.9083333333333, 1.325, 0.375
91141, 1.9083333333333, 1.3, 0.35416666666667
91142, 1.8875, 1.3, 0.375
91143, 1.9083333333333, 1.275, 0.375
91144, 1.9083333333333, 1.25, 0.35416666666667
91145, 1.8875, 1.25, 0.375
91146, 1.9083333333333, 1.225, 0.375
91147, 1.9083333333333, 1.2, 0.35416666666667
91148, 1.8875, 1.2, 0.375
91149, 1.9083333333333, 1.175, 0.375
91150, 1.9083333333333, 1.15, 0.35416666666667
91151, 1.8875, 1.15, 0.375
91152, 1.9083333333333, 1.125, 0.375
91153, 1.9083333333333, 1.1, 0.35416666666667
91154, 1.8875, 1.1, 0.375
91155, 1.9083333333333, 1.075, 0.375
91156, 1.9083333333333, 1.05, 0.35416666666667
91157, 1.8875, 1.05, 0.375
91158, 1.9083333333333, 1.025, 0.375
91159, 1.9083333333333, 1, 0.35416666666667
91160, 1.8875, 1, 0.375
91161, 1.9083333333333, 0.975, 0.375
91162, 1.9083333333333, 0.95, 0.35416666666667
91163, 1.8875, 0.95, 0.375
91164, 1.9083333333333, 0.925, 0.375
91165, 1.9083333333333, 0.9, 0.35416666666667
91166, 1.8875, 0.9, 0.375
91167, 1.9083333333333, 0.875, 0.375
91168, 1.9083333333333, 0.85, 0.35416666666667
91169, 1.8875, 0.85, 0.375
91170, 1.9083333333333, 0.825, 0.375
91171, 1.9083333333333, 0.8, 0.35416666666667
91172, 1.8875, 0.8, 0.375
91173, 1.9083333333333, 0.775, 0.375
91174, 1.9083333333333, 0.75, 0.35416666666667
91175, 1.8875, 0.75, 0.375
91176, 1.9083333333333, 0.725, 0.375
91177, 1.9083333333333, 0.7, 0.35416666666667
91178, 1.8875, 0.7, 0.375
91179, 1.9083333333333, 0.675, 0.375
91180, 1.9083333333333, 0.65, 0.35416666666667
91181, 1.8875, 0.65, 0.375
91182, 1.9083333333333, 0.625, 0.375
91183, 1.9083333333333, 0.6, 0.35416666666667
91184, 1.8875, 0.6, 0.375
91185, 1.9083333333333, 0.575, 0.375
91186, 1.9083333333333, 0.55, 0.35416666666667
91187, 1.8875, 0.55, 0.375
91188, 1.9083333333333, 0.525, 0.375
91189, 1.9083333333333, 0.5, 0.35416666666667
91190, 1.8875, 0.5, 0.375
91191, 1.9083333333333, 0.475, 0.375
91192, 1.9083333333333, 0.45, 0.35416666666667
91193, 1.8875, 0.45, 0.375
91194, 1.9083333333333, 0.425, 0.375
91195, 1.9083333333333, 0.4, 0.35416666666667
91196, 1.8875, 0.4, 0.375
91197, 1.9083333333333, 0.375, 0.375
91198, 1.9083333333333, 0.35, 0.35416666666667
91199, 1.8875, 0.35, 0.375
91200, 1.9083333333333, 0.325, 0.375
91201, 1.9083333333333, 0.3, 0.35416666666667
91202, 1.8875, 0.3, 0.375
91203, 1.9083333333333, 0.275, 0.375
91204, 1.9083333333333, 0.25, 0.35416666666667
91205, 1.8875, 0.25, 0.375
91206, 1.9083333333333, 0.225, 0.375
91207, 1.9083333333333, 0.2, 0.35416666666667
91208, 1.8875, 0.2, 0.375
91209, 1.9083333333333, 0.175, 0.375
91210, 1.95, 1.325, 0.375
91211, 1.95, 1.3, 0.35416666666667
91212, 1.9291666666667, 1.3, 0.375
91213, 1.95, 1.275, 0.375
91214, 1.95, 1.25, 0.35416666666667
91215, 1.9291666666667, 1.25, 0.375
91216, 1.95, 1.225, 0.375
91217, 1.95, 1.2, 0.35416666666667
91218, 1.9291666666667, 1.2, 0.375
91219, 1.95, 1.175, 0.375
91220, 1.95, 1.15, 0.35416666666667
91221, 1.9291666666667, 1.15, 0.375
91222, 1.95, 1.125, 0.375
91223, 1.95, 1.1, 0.35416666666667
91224, 1.9291666666667, 1.1, 0.375
91225, 1.95, 1.075, 0.375
91226, 1.95, 1.05, 0.35416666666667
91227, 1.9291666666667, 1.05, 0.375
91228, 1.95, 1.025, 0.375
91229, 1.95, 1, 0.35416666666667
91230, 1.9291666666667, 1, 0.375
91231, 1.95, 0.975, 0.375
91232, 1.95, 0.95, 0.35416666666667
91233, 1.9291666666667, 0.95, 0.375
91234, 1.95, 0.925, 0.375
91235, 1.95, 0.9, 0.35416666666667
91236, 1.9291666666667, 0.9, 0.375
91237, 1.95, 0.875, 0.375
91238, 1.95, 0.85, 0.35416666666667
91239, 1.9291666666667, 0.85, 0.375
91240, 1.95, 0.825, 0.375
91241, 1.95, 0.8, 0.35416666666667
91242, 1.9291666666667, 0.8, 0.375
91243, 1.95, 0.775, 0.375
91244, 1.95, 0.75, 0.35416666666667
91245, 1.9291666666667, 0.75, 0.375
91246, 1.95, 0.725, 0.375
91247, 1.95, 0.7, 0.35416666666667
91248, 1.9291666666667, 0.7, 0.375
91249, 1.95, 0.675, 0.375
91250, 1.95, 0.65, 0.35416666666667
91251, 1.9291666666667, 0.65, 0.375
91252, 1.95, 0.625, 0.375
91253, 1.95, 0.6, 0.35416666666667
91254, 1.9291666666667, 0.6, 0.375
91255, 1.95, 0.575, 0.375
91256, 1.95, 0.55, 0.35416666666667
91257, 1.9291666666667, 0.55, 0.375
91258, 1.95, 0.525, 0.375
91259, 1.95, 0.5, 0.35416666666667
91260, 1.9291666666667, 0.5, 0.375
91261, 1.95, 0.475, 0.375
91262, 1.95, 0.45, 0.35416666666667
91263, 1.9291666666667, 0.45, 0.375
91264, 1.95, 0.425, 0.375
91265, 1.95, 0.4, 0.35416666666667
91266, 1.9291666666667, 0.4, 0.375
91267, 1.95, 0.375, 0.375
91268, 1.95, 0.35, 0.35416666666667
91269, 1.9291666666667, 0.35, 0.375
91270, 1.95, 0.325, 0.375
91271, 1.95, 0.3, 0.35416666666667
91272, 1.9291666666667, 0.3, 0.375
91273, 1.95, 0.275, 0.375
91274, 1.95, 0.25, 0.35416666666667
91275, 1.9291666666667, 0.25, 0.375
91276, 1.95, 0.225, 0.375
91277, 1.95, 0.2, 0.35416666666667
91278, 1.9291666666667, 0.2, 0.375
91279, 1.95, 0.175, 0.375
91280, 1.9916666666667, 1.325, 0.375
91281, 1.9916666666667, 1.3, 0.35416666666667
91282, 1.9708333333333, 1.3, 0.375
91283, 1.9916666666667, 1.275, 0.375
91284, 1.9916666666667, 1.25, 0.35416666666667
91285, 1.9708333333333, 1.25, 0.375
91286, 1.9916666666667, 1.225, 0.375
91287, 1.9916666666667, 1.2, 0.35416666666667
91288, 1.9708333333333, 1.2, 0.375
91289, 1.9916666666667, 1.175, 0.375
91290, 1.9916666666667, 1.15, 0.35416666666667
91291, 1.9708333333333, 1.15, 0.375
91292, 1.9916666666667, 1.125, 0.375
91293, 1.9916666666667, 1.1, 0.35416666666667
91294, 1.9708333333333, 1.1, 0.375
91295, 1.9916666666667, 1.075, 0.375
91296, 1.9916666666667, 1.05, 0.35416666666667
91297, 1.9708333333333, 1.05, 0.375
91298, 1.9916666666667, 1.025, 0.375
91299, 1.9916666666667, 1, 0.35416666666667
91300, 1.9708333333333, 1, 0.375
91301, 1.9916666666667, 0.975, 0.375
91302, 1.9916666666667, 0.95, 0.35416666666667
91303, 1.9708333333333, 0.95, 0.375
91304, 1.9916666666667, 0.925, 0.375
91305, 1.9916666666667, 0.9, 0.35416666666667
91306, 1.9708333333333, 0.9, 0.375
91307, 1.9916666666667, 0.875, 0.375
91308, 1.9916666666667, 0.85, 0.35416666666667
91309, 1.9708333333333, 0.85, 0.375
91310, 1.9916666666667, 0.825, 0.375
91311, 1.9916666666667, 0.8, 0.35416666666667
91312, 1.9708333333333, 0.8, 0.375
91313, 1.9916666666667, 0.775, 0.375
91314, 1.9916666666667, 0.75, 0.35416666666667
91315, 1.9708333333333, 0.75, 0.375
91316, 1.9916666666667, 0.725, 0.375
91317, 1.9916666666667, 0.7, 0.35416666666667
91318, 1.9708333333333, 0.7, 0.375
91319, 1.9916666666667, 0.675, 0.375
91320, 1.9916666666667, 0.65, 0.35416666666667
91321, 1.9708333333333, 0.65, 0.375
91322, 1.9916666666667, 0.625, 0.375
91323, 1.9916666666667, 0.6, 0.35416666666667
91324, 1.9708333333333, 0.6, 0.375
91325, 1.9916666666667, 0.575, 0.375
91326, 1.9916666666667, 0.55, 0.35416666666667
91327, 1.9708333333333, 0.55, 0.375
91328, 1.9916666666667, 0.525, 0.375
91329, 1.9916666666667, 0.5, 0.35416666666667
91330, 1.9708333333333, 0.5, 0.375
91331, 1.9916666666667, 0.475, 0.375
91332, 1.9916666666667, 0.45, 0.35416666666667
91333, 1.9708333333333, 0.45, 0.375
91334, 1.9916666666667, 0.425, 0.375
91335, 1.9916666666667, 0.4, 0.35416666666667
91336, 1.9708333333333, 0.4, 0.375
91337, 1.9916666666667, 0.375, 0.375
91338, 1.9916666666667, 0.35, 0.35416666666667
91339, 1.9708333333333, 0.35, 0.375
91340, 1.9916666666667, 0.325, 0.375
91341, 1.9916666666667, 0.3, 0.35416666666667
91342, 1.9708333333333, 0.3, 0.375
91343, 1.9916666666667, 0.275, 0.375
91344, 1.9916666666667, 0.25, 0.35416666666667
91345, 1.9708333333333, 0.25, 0.375
91346, 1.9916666666667, 0.225, 0.375
91347, 1.9916666666667, 0.2, 0.35416666666667
91348, 1.9708333333333, 0.2, 0.375
91349, 1.9916666666667, 0.175, 0.375
91350, 2.0333333333333, 1.325, 0.375
91351, 2.0333333333333, 1.3, 0.35416666666667
91352, 2.0125, 1.3, 0.375
91353, 2.0333333333333, 1.275, 0.375
91354, 2.0333333333333, 1.25, 0.35416666666667
91355, 2.0125, 1.25, 0.375
91356, 2.0333333333333, 1.225, 0.375
91357, 2.0333333333333, 1.2, 0.35416666666667
91358, 2.0125, 1.2, 0.375
91359, 2.0333333333333, 1.175, 0.375
91360, 2.0333333333333, 1.15, 0.35416666666667
91361, 2.0125, 1.15, 0.375
91362, 2.0333333333333, 1.125, 0.375
91363, 2.0333333333333, 1.1, 0.35416666666667
91364, 2.0125, 1.1, 0.375
91365, 2.0333333333333, 1.075, 0.375
91366, 2.0333333333333, 1.05, 0.35416666666667
91367, 2.0125, 1.05, 0.375
91368, 2.0333333333333, 1.025, 0.375
91369, 2.0333333333333, 1, 0.35416666666667
91370, 2.0125, 1, 0.375
91371, 2.0333333333333, 0.975, 0.375
91372, 2.0333333333333, 0.95, 0.35416666666667
91373, 2.0125, 0.95, 0.375
91374, 2.0333333333333, 0.925, 0.375
91375, 2.0333333333333, 0.9, 0.35416666666667
91376, 2.0125, 0.9, 0.375
91377, 2.0333333333333, 0.875, 0.375
91378, 2.0333333333333, 0.85, 0.35416666666667
91379, 2.0125, 0.85, 0.375
91380, 2.0333333333333, 0.825, 0.375
91381, 2.0333333333333, 0.8, 0.35416666666667
91382, 2.0125, 0.8, 0.375
91383, 2.0333333333333, 0.775, 0.375
91384, 2.0333333333333, 0.75, 0.35416666666667
91385, 2.0125, 0.75, 0.375
91386, 2.0333333333333, 0.725, 0.375
91387, 2.0333333333333, 0.7, 0.35416666666667
91388, 2.0125, 0.7, 0.375
91389, 2.0333333333333, 0.675, 0.375
91390, 2.0333333333333, 0.65, 0.35416666666667
91391, 2.0125, 0.65, 0.375
91392, 2.0333333333333, 0.625, 0.375
91393, 2.0333333333333, 0.6, 0.35416666666667
91394, 2.0125, 0.6, 0.375
91395, 2.0333333333333, 0.575, 0.375
91396, 2.0333333333333, 0.55, 0.35416666666667
91397, 2.0125, 0.55, 0.375
91398, 2.0333333333333, 0.525, 0.375
91399, 2.0333333333333, 0.5, 0.35416666666667
91400, 2.0125, 0.5, 0.375
91401, 2.0333333333333, 0.475, 0.375
91402, 2.0333333333333, 0.45, 0.35416666666667
91403, 2.0125, 0.45, 0.375
91404, 2.0333333333333, 0.425, 0.375
91405, 2.0333333333333, 0.4, 0.35416666666667
91406, 2.0125, 0.4, 0.375
91407, 2.0333333333333, 0.375, 0.375
91408, 2.0333333333333, 0.35, 0.35416666666667
91409, 2.0125, 0.35, 0.375
91410, 2.0333333333333, 0.325, 0.375
91411, 2.0333333333333, 0.3, 0.35416666666667
91412, 2.0125, 0.3, 0.375
91413, 2.0333333333333, 0.275, 0.375
91414, 2.0333333333333, 0.25, 0.35416666666667
91415, 2.0125, 0.25, 0.375
91416, 2.0333333333333, 0.225, 0.375
91417, 2.0333333333333, 0.2, 0.35416666666667
91418, 2.0125, 0.2, 0.375
91419, 2.0333333333333, 0.175, 0.375
91420, 2.075, 1.325, 0.375
91421, 2.075, 1.3, 0.35416666666667
91422, 2.0541666666667, 1.3, 0.375
91423, 2.075, 1.275, 0.375
91424, 2.075, 1.25, 0.35416666666667
91425, 2.0541666666667, 1.25, 0.375
91426, 2.075, 1.225, 0.375
91427, 2.075, 1.2, 0.35416666666667
91428, 2.0541666666667, 1.2, 0.375
91429, 2.075, 1.175, 0.375
91430, 2.075, 1.15, 0.35416666666667
91431, 2.0541666666667, 1.15, 0.375
91432, 2.075, 1.125, 0.375
91433, 2.075, 1.1, 0.35416666666667
91434, 2.0541666666667, 1.1, 0.375
91435, 2.075, 1.075, 0.375
91436, 2.075, 1.05, 0.35416666666667
91437, 2.0541666666667, 1.05, 0.375
91438, 2.075, 1.025, 0.375
91439, 2.075, 1, 0.35416666666667
91440, 2.0541666666667, 1, 0.375
91441, 2.075, 0.975, 0.375
91442, 2.075, 0.95, 0.35416666666667
91443, 2.0541666666667, 0.95, 0.375
91444, 2.075, 0.925, 0.375
91445, 2.075, 0.9, 0.35416666666667
91446, 2.0541666666667, 0.9, 0.375
91447, 2.075, 0.875, 0.375
91448, 2.075, 0.85, 0.35416666666667
91449, 2.0541666666667, 0.85, 0.375
91450, 2.075, 0.825, 0.375
91451, 2.075, 0.8, 0.35416666666667
91452, 2.0541666666667, 0.8, 0.375
91453, 2.075, 0.775, 0.375
91454, 2.075, 0.75, 0.35416666666667
91455, 2.0541666666667, 0.75, 0.375
91456, 2.075, 0.725, 0.375
91457, 2.075, 0.7, 0.35416666666667
91458, 2.0541666666667, 0.7, 0.375
91459, 2.075, 0.675, 0.375
91460, 2.075, 0.65, 0.35416666666667
91461, 2.0541666666667, 0.65, 0.375
91462, 2.075, 0.625, 0.375
91463, 2.075, 0.6, 0.35416666666667
91464, 2.0541666666667, 0.6, 0.375
91465, 2.075, 0.575, 0.375
91466, 2.075, 0.55, 0.35416666666667
91467, 2.0541666666667, 0.55, 0.375
91468, 2.075, 0.525, 0.375
91469, 2.075, 0.5, 0.35416666666667
91470, 2.0541666666667, 0.5, 0.375
91471, 2.075, 0.475, 0.375
91472, 2.075, 0.45, 0.35416666666667
91473, 2.0541666666667, 0.45, 0.375
91474, 2.075, 0.425, 0.375
91475, 2.075, 0.4, 0.35416666666667
91476, 2.0541666666667, 0.4, 0.375
91477, 2.075, 0.375, 0.375
91478, 2.075, 0.35, 0.35416666666667
91479, 2.0541666666667, 0.35, 0.375
91480, 2.075, 0.325, 0.375
91481, 2.075, 0.3, 0.35416666666667
91482, 2.0541666666667, 0.3, 0.375
91483, 2.075, 0.275, 0.375
91484, 2.075, 0.25, 0.35416666666667
91485, 2.0541666666667, 0.25, 0.375
91486, 2.075, 0.225, 0.375
91487, 2.075, 0.2, 0.35416666666667
91488, 2.0541666666667, 0.2, 0.375
91489, 2.075, 0.175, 0.375
91490, 2.1166666666667, 1.325, 0.375
91491, 2.1166666666667, 1.3, 0.35416666666667
91492, 2.0958333333333, 1.3, 0.375
91493, 2.1166666666667, 1.275, 0.375
91494, 2.1166666666667, 1.25, 0.35416666666667
91495, 2.0958333333333, 1.25, 0.375
91496, 2.1166666666667, 1.225, 0.375
91497, 2.1166666666667, 1.2, 0.35416666666667
91498, 2.0958333333333, 1.2, 0.375
91499, 2.1166666666667, 1.175, 0.375
91500, 2.1166666666667, 1.15, 0.35416666666667
91501, 2.0958333333333, 1.15, 0.375
91502, 2.1166666666667, 1.125, 0.375
91503, 2.1166666666667, 1.1, 0.35416666666667
91504, 2.0958333333333, 1.1, 0.375
91505, 2.1166666666667, 1.075, 0.375
91506, 2.1166666666667, 1.05, 0.35416666666667
91507, 2.0958333333333, 1.05, 0.375
91508, 2.1166666666667, 1.025, 0.375
91509, 2.1166666666667, 1, 0.35416666666667
91510, 2.0958333333333, 1, 0.375
91511, 2.1166666666667, 0.975, 0.375
91512, 2.1166666666667, 0.95, 0.35416666666667
91513, 2.0958333333333, 0.95, 0.375
91514, 2.1166666666667, 0.925, 0.375
91515, 2.1166666666667, 0.9, 0.35416666666667
91516, 2.0958333333333, 0.9, 0.375
91517, 2.1166666666667, 0.875, 0.375
91518, 2.1166666666667, 0.85, 0.35416666666667
91519, 2.0958333333333, 0.85, 0.375
91520, 2.1166666666667, 0.825, 0.375
91521, 2.1166666666667, 0.8, 0.35416666666667
91522, 2.0958333333333, 0.8, 0.375
91523, 2.1166666666667, 0.775, 0.375
91524, 2.1166666666667, 0.75, 0.35416666666667
91525, 2.0958333333333, 0.75, 0.375
91526, 2.1166666666667, 0.725, 0.375
91527, 2.1166666666667, 0.7, 0.35416666666667
91528, 2.0958333333333, 0.7, 0.375
91529, 2.1166666666667, 0.675, 0.375
91530, 2.1166666666667, 0.65, 0.35416666666667
91531, 2.0958333333333, 0.65, 0.375
91532, 2.1166666666667, 0.625, 0.375
91533, 2.1166666666667, 0.6, 0.35416666666667
91534, 2.0958333333333, 0.6, 0.375
91535, 2.1166666666667, 0.575, 0.375
91536, 2.1166666666667, 0.55, 0.35416666666667
91537, 2.0958333333333, 0.55, 0.375
91538, 2.1166666666667, 0.525, 0.375
91539, 2.1166666666667, 0.5, 0.35416666666667
91540, 2.0958333333333, 0.5, 0.375
91541, 2.1166666666667, 0.475, 0.375
91542, 2.1166666666667, 0.45, 0.35416666666667
91543, 2.0958333333333, 0.45, 0.375
91544, 2.1166666666667, 0.425, 0.375
91545, 2.1166666666667, 0.4, 0.35416666666667
91546, 2.0958333333333, 0.4, 0.375
91547, 2.1166666666667, 0.375, 0.375
91548, 2.1166666666667, 0.35, 0.35416666666667
91549, 2.0958333333333, 0.35, 0.375
91550, 2.1166666666667, 0.325, 0.375
91551, 2.1166666666667, 0.3, 0.35416666666667
91552, 2.0958333333333, 0.3, 0.375
91553, 2.1166666666667, 0.275, 0.375
91554, 2.1166666666667, 0.25, 0.35416666666667
91555, 2.0958333333333, 0.25, 0.375
91556, 2.1166666666667, 0.225, 0.375
91557, 2.1166666666667, 0.2, 0.35416666666667
91558, 2.0958333333333, 0.2, 0.375
91559, 2.1166666666667, 0.175, 0.375
91560, 2.1583333333333, 1.325, 0.375
91561, 2.1583333333333, 1.3, 0.35416666666667
91562, 2.1375, 1.3, 0.375
91563, 2.1583333333333, 1.275, 0.375
91564, 2.1583333333333, 1.25, 0.35416666666667
91565, 2.1375, 1.25, 0.375
91566, 2.1583333333333, 1.225, 0.375
91567, 2.1583333333333, 1.2, 0.35416666666667
91568, 2.1375, 1.2, 0.375
91569, 2.1583333333333, 1.175, 0.375
91570, 2.1583333333333, 1.15, 0.35416666666667
91571, 2.1375, 1.15, 0.375
91572, 2.1583333333333, 1.125, 0.375
91573, 2.1583333333333, 1.1, 0.35416666666667
91574, 2.1375, 1.1, 0.375
91575, 2.1583333333333, 1.075, 0.375
91576, 2.1583333333333, 1.05, 0.35416666666667
91577, 2.1375, 1.05, 0.375
91578, 2.1583333333333, 1.025, 0.375
91579, 2.1583333333333, 1, 0.35416666666667
91580, 2.1375, 1, 0.375
91581, 2.1583333333333, 0.975, 0.375
91582, 2.1583333333333, 0.95, 0.35416666666667
91583, 2.1375, 0.95, 0.375
91584, 2.1583333333333, 0.925, 0.375
91585, 2.1583333333333, 0.9, 0.35416666666667
91586, 2.1375, 0.9, 0.375
91587, 2.1583333333333, 0.875, 0.375
91588, 2.1583333333333, 0.85, 0.35416666666667
91589, 2.1375, 0.85, 0.375
91590, 2.1583333333333, 0.825, 0.375
91591, 2.1583333333333, 0.8, 0.35416666666667
91592, 2.1375, 0.8, 0.375
91593, 2.1583333333333, 0.775, 0.375
91594, 2.1583333333333, 0.75, 0.35416666666667
91595, 2.1375, 0.75, 0.375
91596, 2.1583333333333, 0.725, 0.375
91597, 2.1583333333333, 0.7, 0.35416666666667
91598, 2.1375, 0.7, 0.375
91599, 2.1583333333333, 0.675, 0.375
91600, 2.1583333333333, 0.65, 0.35416666666667
91601, 2.1375, 0.65, 0.375
91602, 2.1583333333333, 0.625, 0.375
91603, 2.1583333333333, 0.6, 0.35416666666667
91604, 2.1375, 0.6, 0.375
91605, 2.1583333333333, 0.575, 0.375
91606, 2.1583333333333, 0.55, 0.35416666666667
91607, 2.1375, 0.55, 0.375
91608, 2.1583333333333, 0.525, 0.375
91609, 2.1583333333333, 0.5, 0.35416666666667
91610, 2.1375, 0.5, 0.375
91611, 2.1583333333333, 0.475, 0.375
91612, 2.1583333333333, 0.45, 0.35416666666667
91613, 2.1375, 0.45, 0.375
91614, 2.1583333333333, 0.425, 0.375
91615, 2.1583333333333, 0.4, 0.35416666666667
91616, 2.1375, 0.4, 0.375
91617, 2.1583333333333, 0.375, 0.375
91618, 2.1583333333333, 0.35, 0.35416666666667
91619, 2.1375, 0.35, 0.375
91620, 2.1583333333333, 0.325, 0.375
91621, 2.1583333333333, 0.3, 0.35416666666667
91622, 2.1375, 0.3, 0.375
91623, 2.1583333333333, 0.275, 0.375
91624, 2.1583333333333, 0.25, 0.35416666666667
91625, 2.1375, 0.25, 0.375
91626, 2.1583333333333, 0.225, 0.375
91627, 2.1583333333333, 0.2, 0.35416666666667
91628, 2.1375, 0.2, 0.375
91629, 2.1583333333333, 0.175, 0.375
91630, 2.1791666666667, 1.3, 0.375
91631, 2.1791666666667, 1.25, 0.375
91632, 2.1791666666667, 1.2, 0.375
91633, 2.1791666666667, 1.15, 0.375
91634, 2.1791666666667, 1.1, 0.375
91635, 2.1791666666667, 1.05, 0.375
91636, 2.1791666666667, 1, 0.375
91637, 2.1791666666667, 0.95, 0.375
91638, 2.1791666666667, 0.9, 0.375
91639, 2.1791666666667, 0.85, 0.375
91640, 2.1791666666667, 0.8, 0.375
91641, 2.1791666666667, 0.75, 0.375
91642, 2.1791666666667, 0.7, 0.375
91643, 2.1791666666667, 0.65, 0.375
91644, 2.1791666666667, 0.6, 0.375
91645, 2.1791666666667, 0.55, 0.375
91646, 2.1791666666667, 0.5, 0.375
91647, 2.1791666666667, 0.45, 0.375
91648, 2.1791666666667, 0.4, 0.375
91649, 2.1791666666667, 0.35, 0.375
91650, 2.1791666666667, 0.3, 0.375
91651, 2.1791666666667, 0.25, 0.375
91652, 2.1791666666667, 0.2, 0.375
91653, 1.2416666666667, 1.325, 0.41666666666667
91654, 1.2416666666667, 1.3, 0.39583333333333
91655, 1.2208333333333, 1.3, 0.41666666666667
91656, 1.2416666666667, 1.275, 0.41666666666667
91657, 1.2416666666667, 1.25, 0.39583333333333
91658, 1.2208333333333, 1.25, 0.41666666666667
91659, 1.2416666666667, 1.225, 0.41666666666667
91660, 1.2416666666667, 1.2, 0.39583333333333
91661, 1.2208333333333, 1.2, 0.41666666666667
91662, 1.2416666666667, 1.175, 0.41666666666667
91663, 1.2416666666667, 1.15, 0.39583333333333
91664, 1.2208333333333, 1.15, 0.41666666666667
91665, 1.2416666666667, 1.125, 0.41666666666667
91666, 1.2416666666667, 1.1, 0.39583333333333
91667, 1.2208333333333, 1.1, 0.41666666666667
91668, 1.2416666666667, 1.075, 0.41666666666667
91669, 1.2416666666667, 1.05, 0.39583333333333
91670, 1.2208333333333, 1.05, 0.41666666666667
91671, 1.2416666666667, 1.025, 0.41666666666667
91672, 1.2416666666667, 1, 0.39583333333333
91673, 1.2208333333333, 1, 0.41666666666667
91674, 1.2416666666667, 0.975, 0.41666666666667
91675, 1.2416666666667, 0.95, 0.39583333333333
91676, 1.2208333333333, 0.95, 0.41666666666667
91677, 1.2416666666667, 0.925, 0.41666666666667
91678, 1.2416666666667, 0.9, 0.39583333333333
91679, 1.2208333333333, 0.9, 0.41666666666667
91680, 1.2416666666667, 0.875, 0.41666666666667
91681, 1.2416666666667, 0.85, 0.39583333333333
91682, 1.2208333333333, 0.85, 0.41666666666667
91683, 1.2416666666667, 0.825, 0.41666666666667
91684, 1.2416666666667, 0.8, 0.39583333333333
91685, 1.2208333333333, 0.8, 0.41666666666667
91686, 1.2416666666667, 0.775, 0.41666666666667
91687, 1.2416666666667, 0.75, 0.39583333333333
91688, 1.2208333333333, 0.75, 0.41666666666667
91689, 1.2416666666667, 0.725, 0.41666666666667
91690, 1.2416666666667, 0.7, 0.39583333333333
91691, 1.2208333333333, 0.7, 0.41666666666667
91692, 1.2416666666667, 0.675, 0.41666666666667
91693, 1.2416666666667, 0.65, 0.39583333333333
91694, 1.2208333333333, 0.65, 0.41666666666667
91695, 1.2416666666667, 0.625, 0.41666666666667
91696, 1.2416666666667, 0.6, 0.39583333333333
91697, 1.2208333333333, 0.6, 0.41666666666667
91698, 1.2416666666667, 0.575, 0.41666666666667
91699, 1.2416666666667, 0.55, 0.39583333333333
91700, 1.2208333333333, 0.55, 0.41666666666667
91701, 1.2416666666667, 0.525, 0.41666666666667
91702, 1.2416666666667, 0.5, 0.39583333333333
91703, 1.2208333333333, 0.5, 0.41666666666667
91704, 1.2416666666667, 0.475, 0.41666666666667
91705, 1.2416666666667, 0.45, 0.39583333333333
91706, 1.2208333333333, 0.45, 0.41666666666667
91707, 1.2416666666667, 0.425, 0.41666666666667
91708, 1.2416666666667, 0.4, 0.39583333333333
91709, 1.2208333333333, 0.4, 0.41666666666667
91710, 1.2416666666667, 0.375, 0.41666666666667
91711, 1.2416666666667, 0.35, 0.39583333333333
91712, 1.2208333333333, 0.35, 0.41666666666667
91713, 1.2416666666667, 0.325, 0.41666666666667
91714, 1.2416666666667, 0.3, 0.39583333333333
91715, 1.2208333333333, 0.3, 0.41666666666667
91716, 1.2416666666667, 0.275, 0.41666666666667
91717, 1.2416666666667, 0.25, 0.39583333333333
91718, 1.2208333333333, 0.25, 0.41666666666667
91719, 1.2416666666667, 0.225, 0.41666666666667
91720, 1.2416666666667, 0.2, 0.39583333333333
91721, 1.2208333333333, 0.2, 0.41666666666667
91722, 1.2416666666667, 0.175, 0.41666666666667
91723, 1.2833333333333, 1.325, 0.41666666666667
91724, 1.2833333333333, 1.3, 0.39583333333333
91725, 1.2625, 1.3, 0.41666666666667
91726, 1.2833333333333, 1.275, 0.41666666666667
91727, 1.2833333333333, 1.25, 0.39583333333333
91728, 1.2625, 1.25, 0.41666666666667
91729, 1.2833333333333, 1.225, 0.41666666666667
91730, 1.2833333333333, 1.2, 0.39583333333333
91731, 1.2625, 1.2, 0.41666666666667
91732, 1.2833333333333, 1.175, 0.41666666666667
91733, 1.2833333333333, 1.15, 0.39583333333333
91734, 1.2625, 1.15, 0.41666666666667
91735, 1.2833333333333, 1.125, 0.41666666666667
91736, 1.2833333333333, 1.1, 0.39583333333333
91737, 1.2625, 1.1, 0.41666666666667
91738, 1.2833333333333, 1.075, 0.41666666666667
91739, 1.2833333333333, 1.05, 0.39583333333333
91740, 1.2625, 1.05, 0.41666666666667
91741, 1.2833333333333, 1.025, 0.41666666666667
91742, 1.2833333333333, 1, 0.39583333333333
91743, 1.2625, 1, 0.41666666666667
91744, 1.2833333333333, 0.975, 0.41666666666667
91745, 1.2833333333333, 0.95, 0.39583333333333
91746, 1.2625, 0.95, 0.41666666666667
91747, 1.2833333333333, 0.925, 0.41666666666667
91748, 1.2833333333333, 0.9, 0.39583333333333
91749, 1.2625, 0.9, 0.41666666666667
91750, 1.2833333333333, 0.875, 0.41666666666667
91751, 1.2833333333333, 0.85, 0.39583333333333
91752, 1.2625, 0.85, 0.41666666666667
91753, 1.2833333333333, 0.825, 0.41666666666667
91754, 1.2833333333333, 0.8, 0.39583333333333
91755, 1.2625, 0.8, 0.41666666666667
91756, 1.2833333333333, 0.775, 0.41666666666667
91757, 1.2833333333333, 0.75, 0.39583333333333
91758, 1.2625, 0.75, 0.41666666666667
91759, 1.2833333333333, 0.725, 0.41666666666667
91760, 1.2833333333333, 0.7, 0.39583333333333
91761, 1.2625, 0.7, 0.41666666666667
91762, 1.2833333333333, 0.675, 0.41666666666667
91763, 1.2833333333333, 0.65, 0.39583333333333
91764, 1.2625, 0.65, 0.41666666666667
91765, 1.2833333333333, 0.625, 0.41666666666667
91766, 1.2833333333333, 0.6, 0.39583333333333
91767, 1.2625, 0.6, 0.41666666666667
91768, 1.2833333333333, 0.575, 0.41666666666667
91769, 1.2833333333333, 0.55, 0.39583333333333
91770, 1.2625, 0.55, 0.41666666666667
91771, 1.2833333333333, 0.525, 0.41666666666667
91772, 1.2833333333333, 0.5, 0.39583333333333
91773, 1.2625, 0.5, 0.41666666666667
91774, 1.2833333333333, 0.475, 0.41666666666667
91775, 1.2833333333333, 0.45, 0.39583333333333
91776, 1.2625, 0.45, 0.41666666666667
91777, 1.2833333333333, 0.425, 0.41666666666667
91778, 1.2833333333333, 0.4, 0.39583333333333
91779, 1.2625, 0.4, 0.41666666666667
91780, 1.2833333333333, 0.375, 0.41666666666667
91781, 1.2833333333333, 0.35, 0.39583333333333
91782, 1.2625, 0.35, 0.41666666666667
91783, 1.2833333333333, 0.325, 0.41666666666667
91784, 1.2833333333333, 0.3, 0.39583333333333
91785, 1.2625, 0.3, 0.41666666666667
91786, 1.2833333333333, 0.275, 0.41666666666667
91787, 1.2833333333333, 0.25, 0.39583333333333
91788, 1.2625, 0.25, 0.41666666666667
91789, 1.2833333333333, 0.225, 0.41666666666667
91790, 1.2833333333333, 0.2, 0.39583333333333
91791, 1.2625, 0.2, 0.41666666666667
91792, 1.2833333333333, 0.175, 0.41666666666667
91793, 1.325, 1.325, 0.41666666666667
91794, 1.325, 1.3, 0.39583333333333
91795, 1.3041666666667, 1.3, 0.41666666666667
91796, 1.325, 1.275, 0.41666666666667
91797, 1.325, 1.25, 0.39583333333333
91798, 1.3041666666667, 1.25, 0.41666666666667
91799, 1.325, 1.225, 0.41666666666667
91800, 1.325, 1.2, 0.39583333333333
91801, 1.3041666666667, 1.2, 0.41666666666667
91802, 1.325, 1.175, 0.41666666666667
91803, 1.325, 1.15, 0.39583333333333
91804, 1.3041666666667, 1.15, 0.41666666666667
91805, 1.325, 1.125, 0.41666666666667
91806, 1.325, 1.1, 0.39583333333333
91807, 1.3041666666667, 1.1, 0.41666666666667
91808, 1.325, 1.075, 0.41666666666667
91809, 1.325, 1.05, 0.39583333333333
91810, 1.3041666666667, 1.05, 0.41666666666667
91811, 1.325, 1.025, 0.41666666666667
91812, 1.325, 1, 0.39583333333333
91813, 1.3041666666667, 1, 0.41666666666667
91814, 1.325, 0.975, 0.41666666666667
91815, 1.325, 0.95, 0.39583333333333
91816, 1.3041666666667, 0.95, 0.41666666666667
91817, 1.325, 0.925, 0.41666666666667
91818, 1.325, 0.9, 0.39583333333333
91819, 1.3041666666667, 0.9, 0.41666666666667
91820, 1.325, 0.875, 0.41666666666667
91821, 1.325, 0.85, 0.39583333333333
91822, 1.3041666666667, 0.85, 0.41666666666667
91823, 1.325, 0.825, 0.41666666666667
91824, 1.325, 0.8, 0.39583333333333
91825, 1.3041666666667, 0.8, 0.41666666666667
91826, 1.325, 0.775, 0.41666666666667
91827, 1.325, 0.75, 0.39583333333333
91828, 1.3041666666667, 0.75, 0.41666666666667
91829, 1.325, 0.725, 0.41666666666667
91830, 1.325, 0.7, 0.39583333333333
91831, 1.3041666666667, 0.7, 0.41666666666667
91832, 1.325, 0.675, 0.41666666666667
91833, 1.325, 0.65, 0.39583333333333
91834, 1.3041666666667, 0.65, 0.41666666666667
91835, 1.325, 0.625, 0.41666666666667
91836, 1.325, 0.6, 0.39583333333333
91837, 1.3041666666667, 0.6, 0.41666666666667
91838, 1.325, 0.575, 0.41666666666667
91839, 1.325, 0.55, 0.39583333333333
91840, 1.3041666666667, 0.55, 0.41666666666667
91841, 1.325, 0.525, 0.41666666666667
91842, 1.325, 0.5, 0.39583333333333
91843, 1.3041666666667, 0.5, 0.41666666666667
91844, 1.325, 0.475, 0.41666666666667
91845, 1.325, 0.45, 0.39583333333333
91846, 1.3041666666667, 0.45, 0.41666666666667
91847, 1.325, 0.425, 0.41666666666667
91848, 1.325, 0.4, 0.39583333333333
91849, 1.3041666666667, 0.4, 0.41666666666667
91850, 1.325, 0.375, 0.41666666666667
91851, 1.325, 0.35, 0.39583333333333
91852, 1.3041666666667, 0.35, 0.41666666666667
91853, 1.325, 0.325, 0.41666666666667
91854, 1.325, 0.3, 0.39583333333333
91855, 1.3041666666667, 0.3, 0.41666666666667
91856, 1.325, 0.275, 0.41666666666667
91857, 1.325, 0.25, 0.39583333333333
91858, 1.3041666666667, 0.25, 0.41666666666667
91859, 1.325, 0.225, 0.41666666666667
91860, 1.325, 0.2, 0.39583333333333
91861, 1.3041666666667, 0.2, 0.41666666666667
91862, 1.325, 0.175, 0.41666666666667
91863, 1.3666666666667, 1.325, 0.41666666666667
91864, 1.3666666666667, 1.3, 0.39583333333333
91865, 1.3458333333333, 1.3, 0.41666666666667
91866, 1.3666666666667, 1.275, 0.41666666666667
91867, 1.3666666666667, 1.25, 0.39583333333333
91868, 1.3458333333333, 1.25, 0.41666666666667
91869, 1.3666666666667, 1.225, 0.41666666666667
91870, 1.3666666666667, 1.2, 0.39583333333333
91871, 1.3458333333333, 1.2, 0.41666666666667
91872, 1.3666666666667, 1.175, 0.41666666666667
91873, 1.3666666666667, 1.15, 0.39583333333333
91874, 1.3458333333333, 1.15, 0.41666666666667
91875, 1.3666666666667, 1.125, 0.41666666666667
91876, 1.3666666666667, 1.1, 0.39583333333333
91877, 1.3458333333333, 1.1, 0.41666666666667
91878, 1.3666666666667, 1.075, 0.41666666666667
91879, 1.3666666666667, 1.05, 0.39583333333333
91880, 1.3458333333333, 1.05, 0.41666666666667
91881, 1.3666666666667, 1.025, 0.41666666666667
91882, 1.3666666666667, 1, 0.39583333333333
91883, 1.3458333333333, 1, 0.41666666666667
91884, 1.3666666666667, 0.975, 0.41666666666667
91885, 1.3666666666667, 0.95, 0.39583333333333
91886, 1.3458333333333, 0.95, 0.41666666666667
91887, 1.3666666666667, 0.925, 0.41666666666667
91888, 1.3666666666667, 0.9, 0.39583333333333
91889, 1.3458333333333, 0.9, 0.41666666666667
91890, 1.3666666666667, 0.875, 0.41666666666667
91891, 1.3666666666667, 0.85, 0.39583333333333
91892, 1.3458333333333, 0.85, 0.41666666666667
91893, 1.3666666666667, 0.825, 0.41666666666667
91894, 1.3666666666667, 0.8, 0.39583333333333
91895, 1.3458333333333, 0.8, 0.41666666666667
91896, 1.3666666666667, 0.775, 0.41666666666667
91897, 1.3666666666667, 0.75, 0.39583333333333
91898, 1.3458333333333, 0.75, 0.41666666666667
91899, 1.3666666666667, 0.725, 0.41666666666667
91900, 1.3666666666667, 0.7, 0.39583333333333
91901, 1.3458333333333, 0.7, 0.41666666666667
91902, 1.3666666666667, 0.675, 0.41666666666667
91903, 1.3666666666667, 0.65, 0.39583333333333
91904, 1.3458333333333, 0.65, 0.41666666666667
91905, 1.3666666666667, 0.625, 0.41666666666667
91906, 1.3666666666667, 0.6, 0.39583333333333
91907, 1.3458333333333, 0.6, 0.41666666666667
91908, 1.3666666666667, 0.575, 0.41666666666667
91909, 1.3666666666667, 0.55, 0.39583333333333
91910, 1.3458333333333, 0.55, 0.41666666666667
91911, 1.3666666666667, 0.525, 0.41666666666667
91912, 1.3666666666667, 0.5, 0.39583333333333
91913, 1.3458333333333, 0.5, 0.41666666666667
91914, 1.3666666666667, 0.475, 0.41666666666667
91915, 1.3666666666667, 0.45, 0.39583333333333
91916, 1.3458333333333, 0.45, 0.41666666666667
91917, 1.3666666666667, 0.425, 0.41666666666667
91918, 1.3666666666667, 0.4, 0.39583333333333
91919, 1.3458333333333, 0.4, 0.41666666666667
91920, 1.3666666666667, 0.375, 0.41666666666667
91921, 1.3666666666667, 0.35, 0.39583333333333
91922, 1.3458333333333, 0.35, 0.41666666666667
91923, 1.3666666666667, 0.325, 0.41666666666667
91924, 1.3666666666667, 0.3, 0.39583333333333
91925, 1.3458333333333, 0.3, 0.41666666666667
91926, 1.3666666666667, 0.275, 0.41666666666667
91927, 1.3666666666667, 0.25, 0.39583333333333
91928, 1.3458333333333, 0.25, 0.41666666666667
91929, 1.3666666666667, 0.225, 0.41666666666667
91930, 1.3666666666667, 0.2, 0.39583333333333
91931, 1.3458333333333, 0.2, 0.41666666666667
91932, 1.3666666666667, 0.175, 0.41666666666667
91933, 1.4083333333333, 1.325, 0.41666666666667
91934, 1.4083333333333, 1.3, 0.39583333333333
91935, 1.3875, 1.3, 0.41666666666667
91936, 1.4083333333333, 1.275, 0.41666666666667
91937, 1.4083333333333, 1.25, 0.39583333333333
91938, 1.3875, 1.25, 0.41666666666667
91939, 1.4083333333333, 1.225, 0.41666666666667
91940, 1.4083333333333, 1.2, 0.39583333333333
91941, 1.3875, 1.2, 0.41666666666667
91942, 1.4083333333333, 1.175, 0.41666666666667
91943, 1.4083333333333, 1.15, 0.39583333333333
91944, 1.3875, 1.15, 0.41666666666667
91945, 1.4083333333333, 1.125, 0.41666666666667
91946, 1.4083333333333, 1.1, 0.39583333333333
91947, 1.3875, 1.1, 0.41666666666667
91948, 1.4083333333333, 1.075, 0.41666666666667
91949, 1.4083333333333, 1.05, 0.39583333333333
91950, 1.3875, 1.05, 0.41666666666667
91951, 1.4083333333333, 1.025, 0.41666666666667
91952, 1.4083333333333, 1, 0.39583333333333
91953, 1.3875, 1, 0.41666666666667
91954, 1.4083333333333, 0.975, 0.41666666666667
91955, 1.4083333333333, 0.95, 0.39583333333333
91956, 1.3875, 0.95, 0.41666666666667
91957, 1.4083333333333, 0.925, 0.41666666666667
91958, 1.4083333333333, 0.9, 0.39583333333333
91959, 1.3875, 0.9, 0.41666666666667
91960, 1.4083333333333, 0.875, 0.41666666666667
91961, 1.4083333333333, 0.85, 0.39583333333333
91962, 1.3875, 0.85, 0.41666666666667
91963, 1.4083333333333, 0.825, 0.41666666666667
91964, 1.4083333333333, 0.8, 0.39583333333333
91965, 1.3875, 0.8, 0.41666666666667
91966, 1.4083333333333, 0.775, 0.41666666666667
91967, 1.4083333333333, 0.75, 0.39583333333333
91968, 1.3875, 0.75, 0.41666666666667
91969, 1.4083333333333, 0.725, 0.41666666666667
91970, 1.4083333333333, 0.7, 0.39583333333333
91971, 1.3875, 0.7, 0.41666666666667
91972, 1.4083333333333, 0.675, 0.41666666666667
91973, 1.4083333333333, 0.65, 0.39583333333333
91974, 1.3875, 0.65, 0.41666666666667
91975, 1.4083333333333, 0.625, 0.41666666666667
91976, 1.4083333333333, 0.6, 0.39583333333333
91977, 1.3875, 0.6, 0.41666666666667
91978, 1.4083333333333, 0.575, 0.41666666666667
91979, 1.4083333333333, 0.55, 0.39583333333333
91980, 1.3875, 0.55, 0.41666666666667
91981, 1.4083333333333, 0.525, 0.41666666666667
91982, 1.4083333333333, 0.5, 0.39583333333333
91983, 1.3875, 0.5, 0.41666666666667
91984, 1.4083333333333, 0.475, 0.41666666666667
91985, 1.4083333333333, 0.45, 0.39583333333333
91986, 1.3875, 0.45, 0.41666666666667
91987, 1.4083333333333, 0.425, 0.41666666666667
91988, 1.4083333333333, 0.4, 0.39583333333333
91989, 1.3875, 0.4, 0.41666666666667
91990, 1.4083333333333, 0.375, 0.41666666666667
91991, 1.4083333333333, 0.35, 0.39583333333333
91992, 1.3875, 0.35, 0.41666666666667
91993, 1.4083333333333, 0.325, 0.41666666666667
91994, 1.4083333333333, 0.3, 0.39583333333333
91995, 1.3875, 0.3, 0.41666666666667
91996, 1.4083333333333, 0.275, 0.41666666666667
91997, 1.4083333333333, 0.25, 0.39583333333333
91998, 1.3875, 0.25, 0.41666666666667
91999, 1.4083333333333, 0.225, 0.41666666666667
92000, 1.4083333333333, 0.2, 0.39583333333333
92001, 1.3875, 0.2, 0.41666666666667
92002, 1.4083333333333, 0.175, 0.41666666666667
92003, 1.45, 1.325, 0.41666666666667
92004, 1.45, 1.3, 0.39583333333333
92005, 1.4291666666667, 1.3, 0.41666666666667
92006, 1.45, 1.275, 0.41666666666667
92007, 1.45, 1.25, 0.39583333333333
92008, 1.4291666666667, 1.25, 0.41666666666667
92009, 1.45, 1.225, 0.41666666666667
92010, 1.45, 1.2, 0.39583333333333
92011, 1.4291666666667, 1.2, 0.41666666666667
92012, 1.45, 1.175, 0.41666666666667
92013, 1.45, 1.15, 0.39583333333333
92014, 1.4291666666667, 1.15, 0.41666666666667
92015, 1.45, 1.125, 0.41666666666667
92016, 1.45, 1.1, 0.39583333333333
92017, 1.4291666666667, 1.1, 0.41666666666667
92018, 1.45, 1.075, 0.41666666666667
92019, 1.45, 1.05, 0.39583333333333
92020, 1.4291666666667, 1.05, 0.41666666666667
92021, 1.45, 1.025, 0.41666666666667
92022, 1.45, 1, 0.39583333333333
92023, 1.4291666666667, 1, 0.41666666666667
92024, 1.45, 0.975, 0.41666666666667
92025, 1.45, 0.95, 0.39583333333333
92026, 1.4291666666667, 0.95, 0.41666666666667
92027, 1.45, 0.925, 0.41666666666667
92028, 1.45, 0.9, 0.39583333333333
92029, 1.4291666666667, 0.9, 0.41666666666667
92030, 1.45, 0.875, 0.41666666666667
92031, 1.45, 0.85, 0.39583333333333
92032, 1.4291666666667, 0.85, 0.41666666666667
92033, 1.45, 0.825, 0.41666666666667
92034, 1.45, 0.8, 0.39583333333333
92035, 1.4291666666667, 0.8, 0.41666666666667
92036, 1.45, 0.775, 0.41666666666667
92037, 1.45, 0.75, 0.39583333333333
92038, 1.4291666666667, 0.75, 0.41666666666667
92039, 1.45, 0.725, 0.41666666666667
92040, 1.45, 0.7, 0.39583333333333
92041, 1.4291666666667, 0.7, 0.41666666666667
92042, 1.45, 0.675, 0.41666666666667
92043, 1.45, 0.65, 0.39583333333333
92044, 1.4291666666667, 0.65, 0.41666666666667
92045, 1.45, 0.625, 0.41666666666667
92046, 1.45, 0.6, 0.39583333333333
92047, 1.4291666666667, 0.6, 0.41666666666667
92048, 1.45, 0.575, 0.41666666666667
92049, 1.45, 0.55, 0.39583333333333
92050, 1.4291666666667, 0.55, 0.41666666666667
92051, 1.45, 0.525, 0.41666666666667
92052, 1.45, 0.5, 0.39583333333333
92053, 1.4291666666667, 0.5, 0.41666666666667
92054, 1.45, 0.475, 0.41666666666667
92055, 1.45, 0.45, 0.39583333333333
92056, 1.4291666666667, 0.45, 0.41666666666667
92057, 1.45, 0.425, 0.41666666666667
92058, 1.45, 0.4, 0.39583333333333
92059, 1.4291666666667, 0.4, 0.41666666666667
92060, 1.45, 0.375, 0.41666666666667
92061, 1.45, 0.35, 0.39583333333333
92062, 1.4291666666667, 0.35, 0.41666666666667
92063, 1.45, 0.325, 0.41666666666667
92064, 1.45, 0.3, 0.39583333333333
92065, 1.4291666666667, 0.3, 0.41666666666667
92066, 1.45, 0.275, 0.41666666666667
92067, 1.45, 0.25, 0.39583333333333
92068, 1.4291666666667, 0.25, 0.41666666666667
92069, 1.45, 0.225, 0.41666666666667
92070, 1.45, 0.2, 0.39583333333333
92071, 1.4291666666667, 0.2, 0.41666666666667
92072, 1.45, 0.175, 0.41666666666667
92073, 1.4916666666667, 1.325, 0.41666666666667
92074, 1.4916666666667, 1.3, 0.39583333333333
92075, 1.4708333333333, 1.3, 0.41666666666667
92076, 1.4916666666667, 1.275, 0.41666666666667
92077, 1.4916666666667, 1.25, 0.39583333333333
92078, 1.4708333333333, 1.25, 0.41666666666667
92079, 1.4916666666667, 1.225, 0.41666666666667
92080, 1.4916666666667, 1.2, 0.39583333333333
92081, 1.4708333333333, 1.2, 0.41666666666667
92082, 1.4916666666667, 1.175, 0.41666666666667
92083, 1.4916666666667, 1.15, 0.39583333333333
92084, 1.4708333333333, 1.15, 0.41666666666667
92085, 1.4916666666667, 1.125, 0.41666666666667
92086, 1.4916666666667, 1.1, 0.39583333333333
92087, 1.4708333333333, 1.1, 0.41666666666667
92088, 1.4916666666667, 1.075, 0.41666666666667
92089, 1.4916666666667, 1.05, 0.39583333333333
92090, 1.4708333333333, 1.05, 0.41666666666667
92091, 1.4916666666667, 1.025, 0.41666666666667
92092, 1.4916666666667, 1, 0.39583333333333
92093, 1.4708333333333, 1, 0.41666666666667
92094, 1.4916666666667, 0.975, 0.41666666666667
92095, 1.4916666666667, 0.95, 0.39583333333333
92096, 1.4708333333333, 0.95, 0.41666666666667
92097, 1.4916666666667, 0.925, 0.41666666666667
92098, 1.4916666666667, 0.9, 0.39583333333333
92099, 1.4708333333333, 0.9, 0.41666666666667
92100, 1.4916666666667, 0.875, 0.41666666666667
92101, 1.4916666666667, 0.85, 0.39583333333333
92102, 1.4708333333333, 0.85, 0.41666666666667
92103, 1.4916666666667, 0.825, 0.41666666666667
92104, 1.4916666666667, 0.8, 0.39583333333333
92105, 1.4708333333333, 0.8, 0.41666666666667
92106, 1.4916666666667, 0.775, 0.41666666666667
92107, 1.4916666666667, 0.75, 0.39583333333333
92108, 1.4708333333333, 0.75, 0.41666666666667
92109, 1.4916666666667, 0.725, 0.41666666666667
92110, 1.4916666666667, 0.7, 0.39583333333333
92111, 1.4708333333333, 0.7, 0.41666666666667
92112, 1.4916666666667, 0.675, 0.41666666666667
92113, 1.4916666666667, 0.65, 0.39583333333333
92114, 1.4708333333333, 0.65, 0.41666666666667
92115, 1.4916666666667, 0.625, 0.41666666666667
92116, 1.4916666666667, 0.6, 0.39583333333333
92117, 1.4708333333333, 0.6, 0.41666666666667
92118, 1.4916666666667, 0.575, 0.41666666666667
92119, 1.4916666666667, 0.55, 0.39583333333333
92120, 1.4708333333333, 0.55, 0.41666666666667
92121, 1.4916666666667, 0.525, 0.41666666666667
92122, 1.4916666666667, 0.5, 0.39583333333333
92123, 1.4708333333333, 0.5, 0.41666666666667
92124, 1.4916666666667, 0.475, 0.41666666666667
92125, 1.4916666666667, 0.45, 0.39583333333333
92126, 1.4708333333333, 0.45, 0.41666666666667
92127, 1.4916666666667, 0.425, 0.41666666666667
92128, 1.4916666666667, 0.4, 0.39583333333333
92129, 1.4708333333333, 0.4, 0.41666666666667
92130, 1.4916666666667, 0.375, 0.41666666666667
92131, 1.4916666666667, 0.35, 0.39583333333333
92132, 1.4708333333333, 0.35, 0.41666666666667
92133, 1.4916666666667, 0.325, 0.41666666666667
92134, 1.4916666666667, 0.3, 0.39583333333333
92135, 1.4708333333333, 0.3, 0.41666666666667
92136, 1.4916666666667, 0.275, 0.41666666666667
92137, 1.4916666666667, 0.25, 0.39583333333333
92138, 1.4708333333333, 0.25, 0.41666666666667
92139, 1.4916666666667, 0.225, 0.41666666666667
92140, 1.4916666666667, 0.2, 0.39583333333333
92141, 1.4708333333333, 0.2, 0.41666666666667
92142, 1.4916666666667, 0.175, 0.41666666666667
92143, 1.5333333333333, 1.325, 0.41666666666667
92144, 1.5333333333333, 1.3, 0.39583333333333
92145, 1.5125, 1.3, 0.41666666666667
92146, 1.5333333333333, 1.275, 0.41666666666667
92147, 1.5333333333333, 1.25, 0.39583333333333
92148, 1.5125, 1.25, 0.41666666666667
92149, 1.5333333333333, 1.225, 0.41666666666667
92150, 1.5333333333333, 1.2, 0.39583333333333
92151, 1.5125, 1.2, 0.41666666666667
92152, 1.5333333333333, 1.175, 0.41666666666667
92153, 1.5333333333333, 1.15, 0.39583333333333
92154, 1.5125, 1.15, 0.41666666666667
92155, 1.5333333333333, 1.125, 0.41666666666667
92156, 1.5333333333333, 1.1, 0.39583333333333
92157, 1.5125, 1.1, 0.41666666666667
92158, 1.5333333333333, 1.075, 0.41666666666667
92159, 1.5333333333333, 1.05, 0.39583333333333
92160, 1.5125, 1.05, 0.41666666666667
92161, 1.5333333333333, 1.025, 0.41666666666667
92162, 1.5333333333333, 1, 0.39583333333333
92163, 1.5125, 1, 0.41666666666667
92164, 1.5333333333333, 0.975, 0.41666666666667
92165, 1.5333333333333, 0.95, 0.39583333333333
92166, 1.5125, 0.95, 0.41666666666667
92167, 1.5333333333333, 0.925, 0.41666666666667
92168, 1.5333333333333, 0.9, 0.39583333333333
92169, 1.5125, 0.9, 0.41666666666667
92170, 1.5333333333333, 0.875, 0.41666666666667
92171, 1.5333333333333, 0.85, 0.39583333333333
92172, 1.5125, 0.85, 0.41666666666667
92173, 1.5333333333333, 0.825, 0.41666666666667
92174, 1.5333333333333, 0.8, 0.39583333333333
92175, 1.5125, 0.8, 0.41666666666667
92176, 1.5333333333333, 0.775, 0.41666666666667
92177, 1.5333333333333, 0.75, 0.39583333333333
92178, 1.5125, 0.75, 0.41666666666667
92179, 1.5333333333333, 0.725, 0.41666666666667
92180, 1.5333333333333, 0.7, 0.39583333333333
92181, 1.5125, 0.7, 0.41666666666667
92182, 1.5333333333333, 0.675, 0.41666666666667
92183, 1.5333333333333, 0.65, 0.39583333333333
92184, 1.5125, 0.65, 0.41666666666667
92185, 1.5333333333333, 0.625, 0.41666666666667
92186, 1.5333333333333, 0.6, 0.39583333333333
92187, 1.5125, 0.6, 0.41666666666667
92188, 1.5333333333333, 0.575, 0.41666666666667
92189, 1.5333333333333, 0.55, 0.39583333333333
92190, 1.5125, 0.55, 0.41666666666667
92191, 1.5333333333333, 0.525, 0.41666666666667
92192, 1.5333333333333, 0.5, 0.39583333333333
92193, 1.5125, 0.5, 0.41666666666667
92194, 1.5333333333333, 0.475, 0.41666666666667
92195, 1.5333333333333, 0.45, 0.39583333333333
92196, 1.5125, 0.45, 0.41666666666667
92197, 1.5333333333333, 0.425, 0.41666666666667
92198, 1.5333333333333, 0.4, 0.39583333333333
92199, 1.5125, 0.4, 0.41666666666667
92200, 1.5333333333333, 0.375, 0.41666666666667
92201, 1.5333333333333, 0.35, 0.39583333333333
92202, 1.5125, 0.35, 0.41666666666667
92203, 1.5333333333333, 0.325, 0.41666666666667
92204, 1.5333333333333, 0.3, 0.39583333333333
92205, 1.5125, 0.3, 0.41666666666667
92206, 1.5333333333333, 0.275, 0.41666666666667
92207, 1.5333333333333, 0.25, 0.39583333333333
92208, 1.5125, 0.25, 0.41666666666667
92209, 1.5333333333333, 0.225, 0.41666666666667
92210, 1.5333333333333, 0.2, 0.39583333333333
92211, 1.5125, 0.2, 0.41666666666667
92212, 1.5333333333333, 0.175, 0.41666666666667
92213, 1.575, 1.325, 0.41666666666667
92214, 1.575, 1.3, 0.39583333333333
92215, 1.5541666666667, 1.3, 0.41666666666667
92216, 1.575, 1.275, 0.41666666666667
92217, 1.575, 1.25, 0.39583333333333
92218, 1.5541666666667, 1.25, 0.41666666666667
92219, 1.575, 1.225, 0.41666666666667
92220, 1.575, 1.2, 0.39583333333333
92221, 1.5541666666667, 1.2, 0.41666666666667
92222, 1.575, 1.175, 0.41666666666667
92223, 1.575, 1.15, 0.39583333333333
92224, 1.5541666666667, 1.15, 0.41666666666667
92225, 1.575, 1.125, 0.41666666666667
92226, 1.575, 1.1, 0.39583333333333
92227, 1.5541666666667, 1.1, 0.41666666666667
92228, 1.575, 1.075, 0.41666666666667
92229, 1.575, 1.05, 0.39583333333333
92230, 1.5541666666667, 1.05, 0.41666666666667
92231, 1.575, 1.025, 0.41666666666667
92232, 1.575, 1, 0.39583333333333
92233, 1.5541666666667, 1, 0.41666666666667
92234, 1.575, 0.975, 0.41666666666667
92235, 1.575, 0.95, 0.39583333333333
92236, 1.5541666666667, 0.95, 0.41666666666667
92237, 1.575, 0.925, 0.41666666666667
92238, 1.575, 0.9, 0.39583333333333
92239, 1.5541666666667, 0.9, 0.41666666666667
92240, 1.575, 0.875, 0.41666666666667
92241, 1.575, 0.85, 0.39583333333333
92242, 1.5541666666667, 0.85, 0.41666666666667
92243, 1.575, 0.825, 0.41666666666667
92244, 1.575, 0.8, 0.39583333333333
92245, 1.5541666666667, 0.8, 0.41666666666667
92246, 1.575, 0.775, 0.41666666666667
92247, 1.575, 0.75, 0.39583333333333
92248, 1.5541666666667, 0.75, 0.41666666666667
92249, 1.575, 0.725, 0.41666666666667
92250, 1.575, 0.7, 0.39583333333333
92251, 1.5541666666667, 0.7, 0.41666666666667
92252, 1.575, 0.675, 0.41666666666667
92253, 1.575, 0.65, 0.39583333333333
92254, 1.5541666666667, 0.65, 0.41666666666667
92255, 1.575, 0.625, 0.41666666666667
92256, 1.575, 0.6, 0.39583333333333
92257, 1.5541666666667, 0.6, 0.41666666666667
92258, 1.575, 0.575, 0.41666666666667
92259, 1.575, 0.55, 0.39583333333333
92260, 1.5541666666667, 0.55, 0.41666666666667
92261, 1.575, 0.525, 0.41666666666667
92262, 1.575, 0.5, 0.39583333333333
92263, 1.5541666666667, 0.5, 0.41666666666667
92264, 1.575, 0.475, 0.41666666666667
92265, 1.575, 0.45, 0.39583333333333
92266, 1.5541666666667, 0.45, 0.41666666666667
92267, 1.575, 0.425, 0.41666666666667
92268, 1.575, 0.4, 0.39583333333333
92269, 1.5541666666667, 0.4, 0.41666666666667
92270, 1.575, 0.375, 0.41666666666667
92271, 1.575, 0.35, 0.39583333333333
92272, 1.5541666666667, 0.35, 0.41666666666667
92273, 1.575, 0.325, 0.41666666666667
92274, 1.575, 0.3, 0.39583333333333
92275, 1.5541666666667, 0.3, 0.41666666666667
92276, 1.575, 0.275, 0.41666666666667
92277, 1.575, 0.25, 0.39583333333333
92278, 1.5541666666667, 0.25, 0.41666666666667
92279, 1.575, 0.225, 0.41666666666667
92280, 1.575, 0.2, 0.39583333333333
92281, 1.5541666666667, 0.2, 0.41666666666667
92282, 1.575, 0.175, 0.41666666666667
92283, 1.6166666666667, 1.325, 0.41666666666667
92284, 1.6166666666667, 1.3, 0.39583333333333
92285, 1.5958333333333, 1.3, 0.41666666666667
92286, 1.6166666666667, 1.275, 0.41666666666667
92287, 1.6166666666667, 1.25, 0.39583333333333
92288, 1.5958333333333, 1.25, 0.41666666666667
92289, 1.6166666666667, 1.225, 0.41666666666667
92290, 1.6166666666667, 1.2, 0.39583333333333
92291, 1.5958333333333, 1.2, 0.41666666666667
92292, 1.6166666666667, 1.175, 0.41666666666667
92293, 1.6166666666667, 1.15, 0.39583333333333
92294, 1.5958333333333, 1.15, 0.41666666666667
92295, 1.6166666666667, 1.125, 0.41666666666667
92296, 1.6166666666667, 1.1, 0.39583333333333
92297, 1.5958333333333, 1.1, 0.41666666666667
92298, 1.6166666666667, 1.075, 0.41666666666667
92299, 1.6166666666667, 1.05, 0.39583333333333
92300, 1.5958333333333, 1.05, 0.41666666666667
92301, 1.6166666666667, 1.025, 0.41666666666667
92302, 1.6166666666667, 1, 0.39583333333333
92303, 1.5958333333333, 1, 0.41666666666667
92304, 1.6166666666667, 0.975, 0.41666666666667
92305, 1.6166666666667, 0.95, 0.39583333333333
92306, 1.5958333333333, 0.95, 0.41666666666667
92307, 1.6166666666667, 0.925, 0.41666666666667
92308, 1.6166666666667, 0.9, 0.39583333333333
92309, 1.5958333333333, 0.9, 0.41666666666667
92310, 1.6166666666667, 0.875, 0.41666666666667
92311, 1.6166666666667, 0.85, 0.39583333333333
92312, 1.5958333333333, 0.85, 0.41666666666667
92313, 1.6166666666667, 0.825, 0.41666666666667
92314, 1.6166666666667, 0.8, 0.39583333333333
92315, 1.5958333333333, 0.8, 0.41666666666667
92316, 1.6166666666667, 0.775, 0.41666666666667
92317, 1.6166666666667, 0.75, 0.39583333333333
92318, 1.5958333333333, 0.75, 0.41666666666667
92319, 1.6166666666667, 0.725, 0.41666666666667
92320, 1.6166666666667, 0.7, 0.39583333333333
92321, 1.5958333333333, 0.7, 0.41666666666667
92322, 1.6166666666667, 0.675, 0.41666666666667
92323, 1.6166666666667, 0.65, 0.39583333333333
92324, 1.5958333333333, 0.65, 0.41666666666667
92325, 1.6166666666667, 0.625, 0.41666666666667
92326, 1.6166666666667, 0.6, 0.39583333333333
92327, 1.5958333333333, 0.6, 0.41666666666667
92328, 1.6166666666667, 0.575, 0.41666666666667
92329, 1.6166666666667, 0.55, 0.39583333333333
92330, 1.5958333333333, 0.55, 0.41666666666667
92331, 1.6166666666667, 0.525, 0.41666666666667
92332, 1.6166666666667, 0.5, 0.39583333333333
92333, 1.5958333333333, 0.5, 0.41666666666667
92334, 1.6166666666667, 0.475, 0.41666666666667
92335, 1.6166666666667, 0.45, 0.39583333333333
92336, 1.5958333333333, 0.45, 0.41666666666667
92337, 1.6166666666667, 0.425, 0.41666666666667
92338, 1.6166666666667, 0.4, 0.39583333333333
92339, 1.5958333333333, 0.4, 0.41666666666667
92340, 1.6166666666667, 0.375, 0.41666666666667
92341, 1.6166666666667, 0.35, 0.39583333333333
92342, 1.5958333333333, 0.35, 0.41666666666667
92343, 1.6166666666667, 0.325, 0.41666666666667
92344, 1.6166666666667, 0.3, 0.39583333333333
92345, 1.5958333333333, 0.3, 0.41666666666667
92346, 1.6166666666667, 0.275, 0.41666666666667
92347, 1.6166666666667, 0.25, 0.39583333333333
92348, 1.5958333333333, 0.25, 0.41666666666667
92349, 1.6166666666667, 0.225, 0.41666666666667
92350, 1.6166666666667, 0.2, 0.39583333333333
92351, 1.5958333333333, 0.2, 0.41666666666667
92352, 1.6166666666667, 0.175, 0.41666666666667
92353, 1.6583333333333, 1.325, 0.41666666666667
92354, 1.6583333333333, 1.3, 0.39583333333333
92355, 1.6375, 1.3, 0.41666666666667
92356, 1.6583333333333, 1.275, 0.41666666666667
92357, 1.6583333333333, 1.25, 0.39583333333333
92358, 1.6375, 1.25, 0.41666666666667
92359, 1.6583333333333, 1.225, 0.41666666666667
92360, 1.6583333333333, 1.2, 0.39583333333333
92361, 1.6375, 1.2, 0.41666666666667
92362, 1.6583333333333, 1.175, 0.41666666666667
92363, 1.6583333333333, 1.15, 0.39583333333333
92364, 1.6375, 1.15, 0.41666666666667
92365, 1.6583333333333, 1.125, 0.41666666666667
92366, 1.6583333333333, 1.1, 0.39583333333333
92367, 1.6375, 1.1, 0.41666666666667
92368, 1.6583333333333, 1.075, 0.41666666666667
92369, 1.6583333333333, 1.05, 0.39583333333333
92370, 1.6375, 1.05, 0.41666666666667
92371, 1.6583333333333, 1.025, 0.41666666666667
92372, 1.6583333333333, 1, 0.39583333333333
92373, 1.6375, 1, 0.41666666666667
92374, 1.6583333333333, 0.975, 0.41666666666667
92375, 1.6583333333333, 0.95, 0.39583333333333
92376, 1.6375, 0.95, 0.41666666666667
92377, 1.6583333333333, 0.925, 0.41666666666667
92378, 1.6583333333333, 0.9, 0.39583333333333
92379, 1.6375, 0.9, 0.41666666666667
92380, 1.6583333333333, 0.875, 0.41666666666667
92381, 1.6583333333333, 0.85, 0.39583333333333
92382, 1.6375, 0.85, 0.41666666666667
92383, 1.6583333333333, 0.825, 0.41666666666667
92384, 1.6583333333333, 0.8, 0.39583333333333
92385, 1.6375, 0.8, 0.41666666666667
92386, 1.6583333333333, 0.775, 0.41666666666667
92387, 1.6583333333333, 0.75, 0.39583333333333
92388, 1.6375, 0.75, 0.41666666666667
92389, 1.6583333333333, 0.725, 0.41666666666667
92390, 1.6583333333333, 0.7, 0.39583333333333
92391, 1.6375, 0.7, 0.41666666666667
92392, 1.6583333333333, 0.675, 0.41666666666667
92393, 1.6583333333333, 0.65, 0.39583333333333
92394, 1.6375, 0.65, 0.41666666666667
92395, 1.6583333333333, 0.625, 0.41666666666667
92396, 1.6583333333333, 0.6, 0.39583333333333
92397, 1.6375, 0.6, 0.41666666666667
92398, 1.6583333333333, 0.575, 0.41666666666667
92399, 1.6583333333333, 0.55, 0.39583333333333
92400, 1.6375, 0.55, 0.41666666666667
92401, 1.6583333333333, 0.525, 0.41666666666667
92402, 1.6583333333333, 0.5, 0.39583333333333
92403, 1.6375, 0.5, 0.41666666666667
92404, 1.6583333333333, 0.475, 0.41666666666667
92405, 1.6583333333333, 0.45, 0.39583333333333
92406, 1.6375, 0.45, 0.41666666666667
92407, 1.6583333333333, 0.425, 0.41666666666667
92408, 1.6583333333333, 0.4, 0.39583333333333
92409, 1.6375, 0.4, 0.41666666666667
92410, 1.6583333333333, 0.375, 0.41666666666667
92411, 1.6583333333333, 0.35, 0.39583333333333
92412, 1.6375, 0.35, 0.41666666666667
92413, 1.6583333333333, 0.325, 0.41666666666667
92414, 1.6583333333333, 0.3, 0.39583333333333
92415, 1.6375, 0.3, 0.41666666666667
92416, 1.6583333333333, 0.275, 0.41666666666667
92417, 1.6583333333333, 0.25, 0.39583333333333
92418, 1.6375, 0.25, 0.41666666666667
92419, 1.6583333333333, 0.225, 0.41666666666667
92420, 1.6583333333333, 0.2, 0.39583333333333
92421, 1.6375, 0.2, 0.41666666666667
92422, 1.6583333333333, 0.175, 0.41666666666667
92423, 1.7, 1.325, 0.41666666666667
92424, 1.7, 1.3, 0.39583333333333
92425, 1.6791666666667, 1.3, 0.41666666666667
92426, 1.7, 1.275, 0.41666666666667
92427, 1.7, 1.25, 0.39583333333333
92428, 1.6791666666667, 1.25, 0.41666666666667
92429, 1.7, 1.225, 0.41666666666667
92430, 1.7, 1.2, 0.39583333333333
92431, 1.6791666666667, 1.2, 0.41666666666667
92432, 1.7, 1.175, 0.41666666666667
92433, 1.7, 1.15, 0.39583333333333
92434, 1.6791666666667, 1.15, 0.41666666666667
92435, 1.7, 1.125, 0.41666666666667
92436, 1.7, 1.1, 0.39583333333333
92437, 1.6791666666667, 1.1, 0.41666666666667
92438, 1.7, 1.075, 0.41666666666667
92439, 1.7, 1.05, 0.39583333333333
92440, 1.6791666666667, 1.05, 0.41666666666667
