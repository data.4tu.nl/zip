3764, -0.1, -0.2, 0.35416666666667
3765, -0.1, -0.2, 0.39583333333333
3766, -0.1, -0.2, 0.4375
3767, -0.1, -0.2, 0.47916666666667
3768, 1.2, -0.04, 0.5
3769, 1.2, -0.08, 0.5
3770, 1.2, -0.12, 0.5
3771, 1.2, -0.16, 0.5
3772, 1.2, -0.02, 0.5
3773, 1.2, -0.06, 0.5
3774, 1.2, -0.1, 0.5
3775, 1.2, -0.14, 0.5
3776, 1.2, -0.18, 0.5
3777, 2.2, -0.04, 0.5
3778, 2.2, -0.08, 0.5
3779, 2.2, -0.12, 0.5
3780, 2.2, -0.16, 0.5
3781, 2.2, -0.02, 0.5
3782, 2.2, -0.06, 0.5
3783, 2.2, -0.1, 0.5
3784, 2.2, -0.14, 0.5
3785, 2.2, -0.18, 0.5
3786, 1.2416666666667, -0.2, 0.5
3787, 1.2833333333333, -0.2, 0.5
3788, 1.325, -0.2, 0.5
3789, 1.3666666666667, -0.2, 0.5
3790, 1.4083333333333, -0.2, 0.5
3791, 1.45, -0.2, 0.5
3792, 1.4916666666667, -0.2, 0.5
3793, 1.5333333333333, -0.2, 0.5
3794, 1.575, -0.2, 0.5
3795, 1.6166666666667, -0.2, 0.5
3796, 1.6583333333333, -0.2, 0.5
3797, 1.7, -0.2, 0.5
3798, 1.7416666666667, -0.2, 0.5
3799, 1.7833333333333, -0.2, 0.5
3800, 1.825, -0.2, 0.5
3801, 1.8666666666667, -0.2, 0.5
3802, 1.9083333333333, -0.2, 0.5
3803, 1.95, -0.2, 0.5
3804, 1.9916666666667, -0.2, 0.5
3805, 2.0333333333333, -0.2, 0.5
3806, 2.075, -0.2, 0.5
3807, 2.1166666666667, -0.2, 0.5
3808, 2.1583333333333, -0.2, 0.5
3809, 1.2208333333333, -0.2, 0.5
3810, 1.2625, -0.2, 0.5
3811, 1.3041666666667, -0.2, 0.5
3812, 1.3458333333333, -0.2, 0.5
3813, 1.3875, -0.2, 0.5
3814, 1.4291666666667, -0.2, 0.5
3815, 1.4708333333333, -0.2, 0.5
3816, 1.5125, -0.2, 0.5
3817, 1.5541666666667, -0.2, 0.5
3818, 1.5958333333333, -0.2, 0.5
3819, 1.6375, -0.2, 0.5
3820, 1.6791666666667, -0.2, 0.5
3821, 1.7208333333333, -0.2, 0.5
3822, 1.7625, -0.2, 0.5
3823, 1.8041666666667, -0.2, 0.5
3824, 1.8458333333333, -0.2, 0.5
3825, 1.8875, -0.2, 0.5
3826, 1.9291666666667, -0.2, 0.5
3827, 1.9708333333333, -0.2, 0.5
3828, 2.0125, -0.2, 0.5
3829, 2.0541666666667, -0.2, 0.5
3830, 2.0958333333333, -0.2, 0.5
3831, 2.1375, -0.2, 0.5
3832, 2.1791666666667, -0.2, 0.5
3833, 1.2, -0.04, 0
3834, 1.2, -0.08, 0
3835, 1.2, -0.12, 0
3836, 1.2, -0.16, 0
3837, 1.2, -0.02, 0
3838, 1.2, -0.06, 0
3839, 1.2, -0.1, 0
3840, 1.2, -0.14, 0
3841, 1.2, -0.18, 0
3842, 2.2, -0.04, 0
3843, 2.2, -0.08, 0
3844, 2.2, -0.12, 0
3845, 2.2, -0.16, 0
3846, 2.2, -0.02, 0
3847, 2.2, -0.06, 0
3848, 2.2, -0.1, 0
3849, 2.2, -0.14, 0
3850, 2.2, -0.18, 0
3851, 1.2416666666667, -0.2, 0
3852, 1.2833333333333, -0.2, 0
3853, 1.325, -0.2, 0
3854, 1.3666666666667, -0.2, 0
3855, 1.4083333333333, -0.2, 0
3856, 1.45, -0.2, 0
3857, 1.4916666666667, -0.2, 0
3858, 1.5333333333333, -0.2, 0
3859, 1.575, -0.2, 0
3860, 1.6166666666667, -0.2, 0
3861, 1.6583333333333, -0.2, 0
3862, 1.7, -0.2, 0
3863, 1.7416666666667, -0.2, 0
3864, 1.7833333333333, -0.2, 0
3865, 1.825, -0.2, 0
3866, 1.8666666666667, -0.2, 0
3867, 1.9083333333333, -0.2, 0
3868, 1.95, -0.2, 0
3869, 1.9916666666667, -0.2, 0
3870, 2.0333333333333, -0.2, 0
3871, 2.075, -0.2, 0
3872, 2.1166666666667, -0.2, 0
3873, 2.1583333333333, -0.2, 0
3874, 1.2208333333333, -0.2, 0
3875, 1.2625, -0.2, 0
3876, 1.3041666666667, -0.2, 0
3877, 1.3458333333333, -0.2, 0
3878, 1.3875, -0.2, 0
3879, 1.4291666666667, -0.2, 0
3880, 1.4708333333333, -0.2, 0
3881, 1.5125, -0.2, 0
3882, 1.5541666666667, -0.2, 0
3883, 1.5958333333333, -0.2, 0
3884, 1.6375, -0.2, 0
3885, 1.6791666666667, -0.2, 0
3886, 1.7208333333333, -0.2, 0
3887, 1.7625, -0.2, 0
3888, 1.8041666666667, -0.2, 0
3889, 1.8458333333333, -0.2, 0
3890, 1.8875, -0.2, 0
3891, 1.9291666666667, -0.2, 0
3892, 1.9708333333333, -0.2, 0
3893, 2.0125, -0.2, 0
3894, 2.0541666666667, -0.2, 0
3895, 2.0958333333333, -0.2, 0
3896, 2.1375, -0.2, 0
3897, 2.1791666666667, -0.2, 0
3898, 1.2, -0.2, 0.041666666666667
3899, 1.2, -0.2, 0.083333333333333
3900, 1.2, -0.2, 0.125
3901, 1.2, -0.2, 0.16666666666667
3902, 1.2, -0.2, 0.20833333333333
3903, 1.2, -0.2, 0.25
3904, 1.2, -0.2, 0.29166666666667
3905, 1.2, -0.2, 0.33333333333333
3906, 1.2, -0.2, 0.375
3907, 1.2, -0.2, 0.41666666666667
3908, 1.2, -0.2, 0.45833333333333
3909, 1.2, -0.2, 0.020833333333333
3910, 1.2, -0.2, 0.0625
3911, 1.2, -0.2, 0.10416666666667
3912, 1.2, -0.2, 0.14583333333333
3913, 1.2, -0.2, 0.1875
3914, 1.2, -0.2, 0.22916666666667
3915, 1.2, -0.2, 0.27083333333333
3916, 1.2, -0.2, 0.3125
3917, 1.2, -0.2, 0.35416666666667
3918, 1.2, -0.2, 0.39583333333333
3919, 1.2, -0.2, 0.4375
3920, 1.2, -0.2, 0.47916666666667
3921, 2.2, -0.2, 0.041666666666667
3922, 2.2, -0.2, 0.083333333333333
3923, 2.2, -0.2, 0.125
3924, 2.2, -0.2, 0.16666666666667
3925, 2.2, -0.2, 0.20833333333333
3926, 2.2, -0.2, 0.25
3927, 2.2, -0.2, 0.29166666666667
3928, 2.2, -0.2, 0.33333333333333
3929, 2.2, -0.2, 0.375
3930, 2.2, -0.2, 0.41666666666667
3931, 2.2, -0.2, 0.45833333333333
3932, 2.2, -0.2, 0.020833333333333
3933, 2.2, -0.2, 0.0625
3934, 2.2, -0.2, 0.10416666666667
3935, 2.2, -0.2, 0.14583333333333
3936, 2.2, -0.2, 0.1875
3937, 2.2, -0.2, 0.22916666666667
3938, 2.2, -0.2, 0.27083333333333
3939, 2.2, -0.2, 0.3125
3940, 2.2, -0.2, 0.35416666666667
3941, 2.2, -0.2, 0.39583333333333
3942, 2.2, -0.2, 0.4375
3943, 2.2, -0.2, 0.47916666666667
3944, 2.3, -0.04, 0.5
3945, 2.3, -0.08, 0.5
3946, 2.3, -0.12, 0.5
3947, 2.3, -0.16, 0.5
3948, 2.3, -0.02, 0.5
3949, 2.3, -0.06, 0.5
3950, 2.3, -0.1, 0.5
3951, 2.3, -0.14, 0.5
3952, 2.3, -0.18, 0.5
3953, 2.25, -0.2, 0.5
3954, 2.3, -0.04, 0
3955, 2.3, -0.08, 0
3956, 2.3, -0.12, 0
3957, 2.3, -0.16, 0
3958, 2.3, -0.02, 0
3959, 2.3, -0.06, 0
3960, 2.3, -0.1, 0
3961, 2.3, -0.14, 0
3962, 2.3, -0.18, 0
3963, 2.25, -0.2, 0
3964, 2.3, -0.2, 0.041666666666667
3965, 2.3, -0.2, 0.083333333333333
3966, 2.3, -0.2, 0.125
3967, 2.3, -0.2, 0.16666666666667
3968, 2.3, -0.2, 0.20833333333333
3969, 2.3, -0.2, 0.25
3970, 2.3, -0.2, 0.29166666666667
3971, 2.3, -0.2, 0.33333333333333
3972, 2.3, -0.2, 0.375
3973, 2.3, -0.2, 0.41666666666667
3974, 2.3, -0.2, 0.45833333333333
3975, 2.3, -0.2, 0.020833333333333
3976, 2.3, -0.2, 0.0625
3977, 2.3, -0.2, 0.10416666666667
3978, 2.3, -0.2, 0.14583333333333
3979, 2.3, -0.2, 0.1875
3980, 2.3, -0.2, 0.22916666666667
3981, 2.3, -0.2, 0.27083333333333
3982, 2.3, -0.2, 0.3125
3983, 2.3, -0.2, 0.35416666666667
3984, 2.3, -0.2, 0.39583333333333
3985, 2.3, -0.2, 0.4375
3986, 2.3, -0.2, 0.47916666666667
3987, 0, 0.033333333333333, 0.041666666666667
3988, 0, 0.066666666666667, 0.041666666666667
3989, 0, 0.033333333333333, 0.083333333333333
3990, 0, 0.066666666666667, 0.083333333333333
3991, 0, 0.033333333333333, 0.125
3992, 0, 0.066666666666667, 0.125
3993, 0, 0.033333333333333, 0.16666666666667
3994, 0, 0.066666666666667, 0.16666666666667
3995, 0, 0.033333333333333, 0.20833333333333
3996, 0, 0.066666666666667, 0.20833333333333
3997, 0, 0.033333333333333, 0.25
3998, 0, 0.066666666666667, 0.25
3999, 0, 0.033333333333333, 0.29166666666667
4000, 0, 0.066666666666667, 0.29166666666667
4001, 0, 0.033333333333333, 0.33333333333333
4002, 0, 0.066666666666667, 0.33333333333333
4003, 0, 0.033333333333333, 0.375
4004, 0, 0.066666666666667, 0.375
4005, 0, 0.033333333333333, 0.41666666666667
4006, 0, 0.066666666666667, 0.41666666666667
4007, 0, 0.033333333333333, 0.45833333333333
4008, 0, 0.066666666666667, 0.45833333333333
4009, 0, 0.016666666666667, 0.041666666666667
4010, 0, 0.033333333333333, 0.020833333333333
4011, 0, 0.05, 0.041666666666667
4012, 0, 0.066666666666667, 0.020833333333333
4013, 0, 0.083333333333333, 0.041666666666667
4014, 0, 0.016666666666667, 0.083333333333333
4015, 0, 0.033333333333333, 0.0625
4016, 0, 0.05, 0.083333333333333
4017, 0, 0.066666666666667, 0.0625
4018, 0, 0.083333333333333, 0.083333333333333
4019, 0, 0.016666666666667, 0.125
4020, 0, 0.033333333333333, 0.10416666666667
4021, 0, 0.05, 0.125
4022, 0, 0.066666666666667, 0.10416666666667
4023, 0, 0.083333333333333, 0.125
4024, 0, 0.016666666666667, 0.16666666666667
4025, 0, 0.033333333333333, 0.14583333333333
4026, 0, 0.05, 0.16666666666667
4027, 0, 0.066666666666667, 0.14583333333333
4028, 0, 0.083333333333333, 0.16666666666667
4029, 0, 0.016666666666667, 0.20833333333333
4030, 0, 0.033333333333333, 0.1875
4031, 0, 0.05, 0.20833333333333
4032, 0, 0.066666666666667, 0.1875
4033, 0, 0.083333333333333, 0.20833333333333
4034, 0, 0.016666666666667, 0.25
4035, 0, 0.033333333333333, 0.22916666666667
4036, 0, 0.05, 0.25
4037, 0, 0.066666666666667, 0.22916666666667
4038, 0, 0.083333333333333, 0.25
4039, 0, 0.016666666666667, 0.29166666666667
4040, 0, 0.033333333333333, 0.27083333333333
4041, 0, 0.05, 0.29166666666667
4042, 0, 0.066666666666667, 0.27083333333333
4043, 0, 0.083333333333333, 0.29166666666667
4044, 0, 0.016666666666667, 0.33333333333333
4045, 0, 0.033333333333333, 0.3125
4046, 0, 0.05, 0.33333333333333
4047, 0, 0.066666666666667, 0.3125
4048, 0, 0.083333333333333, 0.33333333333333
4049, 0, 0.016666666666667, 0.375
4050, 0, 0.033333333333333, 0.35416666666667
4051, 0, 0.05, 0.375
4052, 0, 0.066666666666667, 0.35416666666667
4053, 0, 0.083333333333333, 0.375
4054, 0, 0.016666666666667, 0.41666666666667
4055, 0, 0.033333333333333, 0.39583333333333
4056, 0, 0.05, 0.41666666666667
4057, 0, 0.066666666666667, 0.39583333333333
4058, 0, 0.083333333333333, 0.41666666666667
4059, 0, 0.016666666666667, 0.45833333333333
4060, 0, 0.033333333333333, 0.4375
4061, 0, 0.05, 0.45833333333333
4062, 0, 0.066666666666667, 0.4375
4063, 0, 0.083333333333333, 0.45833333333333
4064, 0, 0.033333333333333, 0.47916666666667
4065, 0, 0.066666666666667, 0.47916666666667
4066, 1, 0.033333333333333, 0.041666666666667
4067, 1, 0.066666666666667, 0.041666666666667
4068, 1, 0.033333333333333, 0.083333333333333
4069, 1, 0.066666666666667, 0.083333333333333
4070, 1, 0.033333333333333, 0.125
4071, 1, 0.066666666666667, 0.125
4072, 1, 0.033333333333333, 0.16666666666667
4073, 1, 0.066666666666667, 0.16666666666667
4074, 1, 0.033333333333333, 0.20833333333333
4075, 1, 0.066666666666667, 0.20833333333333
4076, 1, 0.033333333333333, 0.25
4077, 1, 0.066666666666667, 0.25
4078, 1, 0.033333333333333, 0.29166666666667
4079, 1, 0.066666666666667, 0.29166666666667
4080, 1, 0.033333333333333, 0.33333333333333
4081, 1, 0.066666666666667, 0.33333333333333
4082, 1, 0.033333333333333, 0.375
4083, 1, 0.066666666666667, 0.375
4084, 1, 0.033333333333333, 0.41666666666667
4085, 1, 0.066666666666667, 0.41666666666667
4086, 1, 0.033333333333333, 0.45833333333333
4087, 1, 0.066666666666667, 0.45833333333333
4088, 1, 0.033333333333333, 0.020833333333333
4089, 1, 0.016666666666667, 0.041666666666667
4090, 1, 0.066666666666667, 0.020833333333333
4091, 1, 0.05, 0.041666666666667
4092, 1, 0.083333333333333, 0.041666666666667
4093, 1, 0.033333333333333, 0.0625
4094, 1, 0.016666666666667, 0.083333333333333
4095, 1, 0.066666666666667, 0.0625
4096, 1, 0.05, 0.083333333333333
4097, 1, 0.083333333333333, 0.083333333333333
4098, 1, 0.033333333333333, 0.10416666666667
4099, 1, 0.016666666666667, 0.125
4100, 1, 0.066666666666667, 0.10416666666667
4101, 1, 0.05, 0.125
4102, 1, 0.083333333333333, 0.125
4103, 1, 0.033333333333333, 0.14583333333333
4104, 1, 0.016666666666667, 0.16666666666667
4105, 1, 0.066666666666667, 0.14583333333333
4106, 1, 0.05, 0.16666666666667
4107, 1, 0.083333333333333, 0.16666666666667
4108, 1, 0.033333333333333, 0.1875
4109, 1, 0.016666666666667, 0.20833333333333
4110, 1, 0.066666666666667, 0.1875
4111, 1, 0.05, 0.20833333333333
4112, 1, 0.083333333333333, 0.20833333333333
4113, 1, 0.033333333333333, 0.22916666666667
4114, 1, 0.016666666666667, 0.25
4115, 1, 0.066666666666667, 0.22916666666667
4116, 1, 0.05, 0.25
4117, 1, 0.083333333333333, 0.25
4118, 1, 0.033333333333333, 0.27083333333333
4119, 1, 0.016666666666667, 0.29166666666667
4120, 1, 0.066666666666667, 0.27083333333333
4121, 1, 0.05, 0.29166666666667
4122, 1, 0.083333333333333, 0.29166666666667
4123, 1, 0.033333333333333, 0.3125
4124, 1, 0.016666666666667, 0.33333333333333
4125, 1, 0.066666666666667, 0.3125
4126, 1, 0.05, 0.33333333333333
4127, 1, 0.083333333333333, 0.33333333333333
4128, 1, 0.033333333333333, 0.35416666666667
4129, 1, 0.016666666666667, 0.375
4130, 1, 0.066666666666667, 0.35416666666667
4131, 1, 0.05, 0.375
4132, 1, 0.083333333333333, 0.375
4133, 1, 0.033333333333333, 0.39583333333333
4134, 1, 0.016666666666667, 0.41666666666667
4135, 1, 0.066666666666667, 0.39583333333333
4136, 1, 0.05, 0.41666666666667
4137, 1, 0.083333333333333, 0.41666666666667
4138, 1, 0.033333333333333, 0.4375
4139, 1, 0.016666666666667, 0.45833333333333
4140, 1, 0.066666666666667, 0.4375
4141, 1, 0.05, 0.45833333333333
4142, 1, 0.083333333333333, 0.45833333333333
4143, 1, 0.033333333333333, 0.47916666666667
4144, 1, 0.066666666666667, 0.47916666666667
4145, 0.041666666666667, 0, 0.041666666666667
4146, 0.041666666666667, 0, 0.083333333333333
4147, 0.041666666666667, 0, 0.125
4148, 0.041666666666667, 0, 0.16666666666667
4149, 0.041666666666667, 0, 0.20833333333333
4150, 0.041666666666667, 0, 0.25
4151, 0.041666666666667, 0, 0.29166666666667
4152, 0.041666666666667, 0, 0.33333333333333
4153, 0.041666666666667, 0, 0.375
4154, 0.041666666666667, 0, 0.41666666666667
4155, 0.041666666666667, 0, 0.45833333333333
4156, 0.083333333333333, 0, 0.041666666666667
4157, 0.083333333333333, 0, 0.083333333333333
4158, 0.083333333333333, 0, 0.125
4159, 0.083333333333333, 0, 0.16666666666667
4160, 0.083333333333333, 0, 0.20833333333333
4161, 0.083333333333333, 0, 0.25
4162, 0.083333333333333, 0, 0.29166666666667
4163, 0.083333333333333, 0, 0.33333333333333
4164, 0.083333333333333, 0, 0.375
4165, 0.083333333333333, 0, 0.41666666666667
4166, 0.083333333333333, 0, 0.45833333333333
4167, 0.125, 0, 0.041666666666667
4168, 0.125, 0, 0.083333333333333
4169, 0.125, 0, 0.125
4170, 0.125, 0, 0.16666666666667
4171, 0.125, 0, 0.20833333333333
4172, 0.125, 0, 0.25
4173, 0.125, 0, 0.29166666666667
4174, 0.125, 0, 0.33333333333333
4175, 0.125, 0, 0.375
4176, 0.125, 0, 0.41666666666667
4177, 0.125, 0, 0.45833333333333
4178, 0.16666666666667, 0, 0.041666666666667
4179, 0.16666666666667, 0, 0.083333333333333
4180, 0.16666666666667, 0, 0.125
4181, 0.16666666666667, 0, 0.16666666666667
4182, 0.16666666666667, 0, 0.20833333333333
4183, 0.16666666666667, 0, 0.25
4184, 0.16666666666667, 0, 0.29166666666667
4185, 0.16666666666667, 0, 0.33333333333333
4186, 0.16666666666667, 0, 0.375
4187, 0.16666666666667, 0, 0.41666666666667
4188, 0.16666666666667, 0, 0.45833333333333
4189, 0.20833333333333, 0, 0.041666666666667
4190, 0.20833333333333, 0, 0.083333333333333
4191, 0.20833333333333, 0, 0.125
4192, 0.20833333333333, 0, 0.16666666666667
4193, 0.20833333333333, 0, 0.20833333333333
4194, 0.20833333333333, 0, 0.25
4195, 0.20833333333333, 0, 0.29166666666667
4196, 0.20833333333333, 0, 0.33333333333333
4197, 0.20833333333333, 0, 0.375
4198, 0.20833333333333, 0, 0.41666666666667
4199, 0.20833333333333, 0, 0.45833333333333
4200, 0.25, 0, 0.041666666666667
4201, 0.25, 0, 0.083333333333333
4202, 0.25, 0, 0.125
4203, 0.25, 0, 0.16666666666667
4204, 0.25, 0, 0.20833333333333
4205, 0.25, 0, 0.25
4206, 0.25, 0, 0.29166666666667
4207, 0.25, 0, 0.33333333333333
4208, 0.25, 0, 0.375
4209, 0.25, 0, 0.41666666666667
4210, 0.25, 0, 0.45833333333333
4211, 0.29166666666667, 0, 0.041666666666667
4212, 0.29166666666667, 0, 0.083333333333333
4213, 0.29166666666667, 0, 0.125
4214, 0.29166666666667, 0, 0.16666666666667
4215, 0.29166666666667, 0, 0.20833333333333
4216, 0.29166666666667, 0, 0.25
4217, 0.29166666666667, 0, 0.29166666666667
4218, 0.29166666666667, 0, 0.33333333333333
4219, 0.29166666666667, 0, 0.375
4220, 0.29166666666667, 0, 0.41666666666667
4221, 0.29166666666667, 0, 0.45833333333333
4222, 0.33333333333333, 0, 0.041666666666667
4223, 0.33333333333333, 0, 0.083333333333333
4224, 0.33333333333333, 0, 0.125
4225, 0.33333333333333, 0, 0.16666666666667
4226, 0.33333333333333, 0, 0.20833333333333
4227, 0.33333333333333, 0, 0.25
4228, 0.33333333333333, 0, 0.29166666666667
4229, 0.33333333333333, 0, 0.33333333333333
4230, 0.33333333333333, 0, 0.375
4231, 0.33333333333333, 0, 0.41666666666667
4232, 0.33333333333333, 0, 0.45833333333333
4233, 0.375, 0, 0.041666666666667
4234, 0.375, 0, 0.083333333333333
4235, 0.375, 0, 0.125
4236, 0.375, 0, 0.16666666666667
4237, 0.375, 0, 0.20833333333333
4238, 0.375, 0, 0.25
4239, 0.375, 0, 0.29166666666667
4240, 0.375, 0, 0.33333333333333
4241, 0.375, 0, 0.375
4242, 0.375, 0, 0.41666666666667
4243, 0.375, 0, 0.45833333333333
4244, 0.41666666666667, 0, 0.041666666666667
4245, 0.41666666666667, 0, 0.083333333333333
4246, 0.41666666666667, 0, 0.125
4247, 0.41666666666667, 0, 0.16666666666667
4248, 0.41666666666667, 0, 0.20833333333333
4249, 0.41666666666667, 0, 0.25
4250, 0.41666666666667, 0, 0.29166666666667
4251, 0.41666666666667, 0, 0.33333333333333
4252, 0.41666666666667, 0, 0.375
4253, 0.41666666666667, 0, 0.41666666666667
4254, 0.41666666666667, 0, 0.45833333333333
4255, 0.45833333333333, 0, 0.041666666666667
4256, 0.45833333333333, 0, 0.083333333333333
4257, 0.45833333333333, 0, 0.125
4258, 0.45833333333333, 0, 0.16666666666667
4259, 0.45833333333333, 0, 0.20833333333333
4260, 0.45833333333333, 0, 0.25
4261, 0.45833333333333, 0, 0.29166666666667
4262, 0.45833333333333, 0, 0.33333333333333
4263, 0.45833333333333, 0, 0.375
4264, 0.45833333333333, 0, 0.41666666666667
4265, 0.45833333333333, 0, 0.45833333333333
4266, 0.5, 0, 0.041666666666667
4267, 0.5, 0, 0.083333333333333
4268, 0.5, 0, 0.125
4269, 0.5, 0, 0.16666666666667
4270, 0.5, 0, 0.20833333333333
4271, 0.5, 0, 0.25
4272, 0.5, 0, 0.29166666666667
4273, 0.5, 0, 0.33333333333333
4274, 0.5, 0, 0.375
4275, 0.5, 0, 0.41666666666667
4276, 0.5, 0, 0.45833333333333
4277, 0.54166666666667, 0, 0.041666666666667
4278, 0.54166666666667, 0, 0.083333333333333
4279, 0.54166666666667, 0, 0.125
4280, 0.54166666666667, 0, 0.16666666666667
4281, 0.54166666666667, 0, 0.20833333333333
4282, 0.54166666666667, 0, 0.25
4283, 0.54166666666667, 0, 0.29166666666667
4284, 0.54166666666667, 0, 0.33333333333333
4285, 0.54166666666667, 0, 0.375
4286, 0.54166666666667, 0, 0.41666666666667
4287, 0.54166666666667, 0, 0.45833333333333
4288, 0.58333333333333, 0, 0.041666666666667
4289, 0.58333333333333, 0, 0.083333333333333
4290, 0.58333333333333, 0, 0.125
4291, 0.58333333333333, 0, 0.16666666666667
4292, 0.58333333333333, 0, 0.20833333333333
4293, 0.58333333333333, 0, 0.25
4294, 0.58333333333333, 0, 0.29166666666667
4295, 0.58333333333333, 0, 0.33333333333333
4296, 0.58333333333333, 0, 0.375
4297, 0.58333333333333, 0, 0.41666666666667
4298, 0.58333333333333, 0, 0.45833333333333
4299, 0.625, 0, 0.041666666666667
4300, 0.625, 0, 0.083333333333333
4301, 0.625, 0, 0.125
4302, 0.625, 0, 0.16666666666667
4303, 0.625, 0, 0.20833333333333
4304, 0.625, 0, 0.25
4305, 0.625, 0, 0.29166666666667
4306, 0.625, 0, 0.33333333333333
4307, 0.625, 0, 0.375
4308, 0.625, 0, 0.41666666666667
4309, 0.625, 0, 0.45833333333333
4310, 0.66666666666667, 0, 0.041666666666667
4311, 0.66666666666667, 0, 0.083333333333333
4312, 0.66666666666667, 0, 0.125
4313, 0.66666666666667, 0, 0.16666666666667
4314, 0.66666666666667, 0, 0.20833333333333
4315, 0.66666666666667, 0, 0.25
4316, 0.66666666666667, 0, 0.29166666666667
4317, 0.66666666666667, 0, 0.33333333333333
4318, 0.66666666666667, 0, 0.375
4319, 0.66666666666667, 0, 0.41666666666667
4320, 0.66666666666667, 0, 0.45833333333333
4321, 0.70833333333333, 0, 0.041666666666667
4322, 0.70833333333333, 0, 0.083333333333333
4323, 0.70833333333333, 0, 0.125
4324, 0.70833333333333, 0, 0.16666666666667
4325, 0.70833333333333, 0, 0.20833333333333
4326, 0.70833333333333, 0, 0.25
4327, 0.70833333333333, 0, 0.29166666666667
4328, 0.70833333333333, 0, 0.33333333333333
4329, 0.70833333333333, 0, 0.375
4330, 0.70833333333333, 0, 0.41666666666667
4331, 0.70833333333333, 0, 0.45833333333333
4332, 0.75, 0, 0.041666666666667
4333, 0.75, 0, 0.083333333333333
4334, 0.75, 0, 0.125
4335, 0.75, 0, 0.16666666666667
4336, 0.75, 0, 0.20833333333333
4337, 0.75, 0, 0.25
4338, 0.75, 0, 0.29166666666667
4339, 0.75, 0, 0.33333333333333
4340, 0.75, 0, 0.375
4341, 0.75, 0, 0.41666666666667
4342, 0.75, 0, 0.45833333333333
4343, 0.79166666666667, 0, 0.041666666666667
4344, 0.79166666666667, 0, 0.083333333333333
4345, 0.79166666666667, 0, 0.125
4346, 0.79166666666667, 0, 0.16666666666667
4347, 0.79166666666667, 0, 0.20833333333333
4348, 0.79166666666667, 0, 0.25
4349, 0.79166666666667, 0, 0.29166666666667
4350, 0.79166666666667, 0, 0.33333333333333
4351, 0.79166666666667, 0, 0.375
4352, 0.79166666666667, 0, 0.41666666666667
4353, 0.79166666666667, 0, 0.45833333333333
4354, 0.83333333333333, 0, 0.041666666666667
4355, 0.83333333333333, 0, 0.083333333333333
4356, 0.83333333333333, 0, 0.125
4357, 0.83333333333333, 0, 0.16666666666667
4358, 0.83333333333333, 0, 0.20833333333333
4359, 0.83333333333333, 0, 0.25
4360, 0.83333333333333, 0, 0.29166666666667
4361, 0.83333333333333, 0, 0.33333333333333
4362, 0.83333333333333, 0, 0.375
4363, 0.83333333333333, 0, 0.41666666666667
4364, 0.83333333333333, 0, 0.45833333333333
4365, 0.875, 0, 0.041666666666667
4366, 0.875, 0, 0.083333333333333
4367, 0.875, 0, 0.125
4368, 0.875, 0, 0.16666666666667
4369, 0.875, 0, 0.20833333333333
4370, 0.875, 0, 0.25
4371, 0.875, 0, 0.29166666666667
4372, 0.875, 0, 0.33333333333333
4373, 0.875, 0, 0.375
4374, 0.875, 0, 0.41666666666667
4375, 0.875, 0, 0.45833333333333
4376, 0.91666666666667, 0, 0.041666666666667
4377, 0.91666666666667, 0, 0.083333333333333
4378, 0.91666666666667, 0, 0.125
4379, 0.91666666666667, 0, 0.16666666666667
4380, 0.91666666666667, 0, 0.20833333333333
4381, 0.91666666666667, 0, 0.25
4382, 0.91666666666667, 0, 0.29166666666667
4383, 0.91666666666667, 0, 0.33333333333333
4384, 0.91666666666667, 0, 0.375
4385, 0.91666666666667, 0, 0.41666666666667
4386, 0.91666666666667, 0, 0.45833333333333
4387, 0.95833333333333, 0, 0.041666666666667
4388, 0.95833333333333, 0, 0.083333333333333
4389, 0.95833333333333, 0, 0.125
4390, 0.95833333333333, 0, 0.16666666666667
4391, 0.95833333333333, 0, 0.20833333333333
4392, 0.95833333333333, 0, 0.25
4393, 0.95833333333333, 0, 0.29166666666667
4394, 0.95833333333333, 0, 0.33333333333333
4395, 0.95833333333333, 0, 0.375
4396, 0.95833333333333, 0, 0.41666666666667
4397, 0.95833333333333, 0, 0.45833333333333
4398, 0.041666666666667, 0, 0.020833333333333
4399, 0.020833333333333, 0, 0.041666666666667
4400, 0.041666666666667, 0, 0.0625
4401, 0.020833333333333, 0, 0.083333333333333
4402, 0.041666666666667, 0, 0.10416666666667
4403, 0.020833333333333, 0, 0.125
4404, 0.041666666666667, 0, 0.14583333333333
4405, 0.020833333333333, 0, 0.16666666666667
4406, 0.041666666666667, 0, 0.1875
4407, 0.020833333333333, 0, 0.20833333333333
4408, 0.041666666666667, 0, 0.22916666666667
4409, 0.020833333333333, 0, 0.25
4410, 0.041666666666667, 0, 0.27083333333333
4411, 0.020833333333333, 0, 0.29166666666667
4412, 0.041666666666667, 0, 0.3125
4413, 0.020833333333333, 0, 0.33333333333333
4414, 0.041666666666667, 0, 0.35416666666667
4415, 0.020833333333333, 0, 0.375
4416, 0.041666666666667, 0, 0.39583333333333
4417, 0.020833333333333, 0, 0.41666666666667
4418, 0.041666666666667, 0, 0.4375
4419, 0.020833333333333, 0, 0.45833333333333
4420, 0.041666666666667, 0, 0.47916666666667
4421, 0.083333333333333, 0, 0.020833333333333
4422, 0.0625, 0, 0.041666666666667
4423, 0.083333333333333, 0, 0.0625
4424, 0.0625, 0, 0.083333333333333
4425, 0.083333333333333, 0, 0.10416666666667
4426, 0.0625, 0, 0.125
4427, 0.083333333333333, 0, 0.14583333333333
4428, 0.0625, 0, 0.16666666666667
4429, 0.083333333333333, 0, 0.1875
4430, 0.0625, 0, 0.20833333333333
4431, 0.083333333333333, 0, 0.22916666666667
4432, 0.0625, 0, 0.25
4433, 0.083333333333333, 0, 0.27083333333333
4434, 0.0625, 0, 0.29166666666667
4435, 0.083333333333333, 0, 0.3125
4436, 0.0625, 0, 0.33333333333333
4437, 0.083333333333333, 0, 0.35416666666667
4438, 0.0625, 0, 0.375
4439, 0.083333333333333, 0, 0.39583333333333
4440, 0.0625, 0, 0.41666666666667
4441, 0.083333333333333, 0, 0.4375
4442, 0.0625, 0, 0.45833333333333
4443, 0.083333333333333, 0, 0.47916666666667
4444, 0.125, 0, 0.020833333333333
4445, 0.10416666666667, 0, 0.041666666666667
4446, 0.125, 0, 0.0625
4447, 0.10416666666667, 0, 0.083333333333333
4448, 0.125, 0, 0.10416666666667
4449, 0.10416666666667, 0, 0.125
4450, 0.125, 0, 0.14583333333333
4451, 0.10416666666667, 0, 0.16666666666667
4452, 0.125, 0, 0.1875
4453, 0.10416666666667, 0, 0.20833333333333
4454, 0.125, 0, 0.22916666666667
4455, 0.10416666666667, 0, 0.25
4456, 0.125, 0, 0.27083333333333
4457, 0.10416666666667, 0, 0.29166666666667
4458, 0.125, 0, 0.3125
4459, 0.10416666666667, 0, 0.33333333333333
4460, 0.125, 0, 0.35416666666667
4461, 0.10416666666667, 0, 0.375
4462, 0.125, 0, 0.39583333333333
4463, 0.10416666666667, 0, 0.41666666666667
4464, 0.125, 0, 0.4375
4465, 0.10416666666667, 0, 0.45833333333333
4466, 0.125, 0, 0.47916666666667
4467, 0.16666666666667, 0, 0.020833333333333
4468, 0.14583333333333, 0, 0.041666666666667
4469, 0.16666666666667, 0, 0.0625
4470, 0.14583333333333, 0, 0.083333333333333
4471, 0.16666666666667, 0, 0.10416666666667
4472, 0.14583333333333, 0, 0.125
4473, 0.16666666666667, 0, 0.14583333333333
4474, 0.14583333333333, 0, 0.16666666666667
4475, 0.16666666666667, 0, 0.1875
4476, 0.14583333333333, 0, 0.20833333333333
4477, 0.16666666666667, 0, 0.22916666666667
4478, 0.14583333333333, 0, 0.25
4479, 0.16666666666667, 0, 0.27083333333333
4480, 0.14583333333333, 0, 0.29166666666667
4481, 0.16666666666667, 0, 0.3125
4482, 0.14583333333333, 0, 0.33333333333333
4483, 0.16666666666667, 0, 0.35416666666667
4484, 0.14583333333333, 0, 0.375
4485, 0.16666666666667, 0, 0.39583333333333
4486, 0.14583333333333, 0, 0.41666666666667
4487, 0.16666666666667, 0, 0.4375
4488, 0.14583333333333, 0, 0.45833333333333
4489, 0.16666666666667, 0, 0.47916666666667
4490, 0.20833333333333, 0, 0.020833333333333
4491, 0.1875, 0, 0.041666666666667
4492, 0.20833333333333, 0, 0.0625
4493, 0.1875, 0, 0.083333333333333
4494, 0.20833333333333, 0, 0.10416666666667
4495, 0.1875, 0, 0.125
4496, 0.20833333333333, 0, 0.14583333333333
4497, 0.1875, 0, 0.16666666666667
4498, 0.20833333333333, 0, 0.1875
4499, 0.1875, 0, 0.20833333333333
4500, 0.20833333333333, 0, 0.22916666666667
4501, 0.1875, 0, 0.25
4502, 0.20833333333333, 0, 0.27083333333333
4503, 0.1875, 0, 0.29166666666667
4504, 0.20833333333333, 0, 0.3125
4505, 0.1875, 0, 0.33333333333333
4506, 0.20833333333333, 0, 0.35416666666667
4507, 0.1875, 0, 0.375
4508, 0.20833333333333, 0, 0.39583333333333
4509, 0.1875, 0, 0.41666666666667
4510, 0.20833333333333, 0, 0.4375
4511, 0.1875, 0, 0.45833333333333
4512, 0.20833333333333, 0, 0.47916666666667
4513, 0.25, 0, 0.020833333333333
4514, 0.22916666666667, 0, 0.041666666666667
4515, 0.25, 0, 0.0625
4516, 0.22916666666667, 0, 0.083333333333333
4517, 0.25, 0, 0.10416666666667
4518, 0.22916666666667, 0, 0.125
4519, 0.25, 0, 0.14583333333333
4520, 0.22916666666667, 0, 0.16666666666667
4521, 0.25, 0, 0.1875
4522, 0.22916666666667, 0, 0.20833333333333
4523, 0.25, 0, 0.22916666666667
4524, 0.22916666666667, 0, 0.25
4525, 0.25, 0, 0.27083333333333
4526, 0.22916666666667, 0, 0.29166666666667
4527, 0.25, 0, 0.3125
4528, 0.22916666666667, 0, 0.33333333333333
4529, 0.25, 0, 0.35416666666667
4530, 0.22916666666667, 0, 0.375
4531, 0.25, 0, 0.39583333333333
4532, 0.22916666666667, 0, 0.41666666666667
4533, 0.25, 0, 0.4375
4534, 0.22916666666667, 0, 0.45833333333333
4535, 0.25, 0, 0.47916666666667
4536, 0.29166666666667, 0, 0.020833333333333
4537, 0.27083333333333, 0, 0.041666666666667
4538, 0.29166666666667, 0, 0.0625
4539, 0.27083333333333, 0, 0.083333333333333
4540, 0.29166666666667, 0, 0.10416666666667
4541, 0.27083333333333, 0, 0.125
4542, 0.29166666666667, 0, 0.14583333333333
4543, 0.27083333333333, 0, 0.16666666666667
4544, 0.29166666666667, 0, 0.1875
4545, 0.27083333333333, 0, 0.20833333333333
4546, 0.29166666666667, 0, 0.22916666666667
4547, 0.27083333333333, 0, 0.25
4548, 0.29166666666667, 0, 0.27083333333333
4549, 0.27083333333333, 0, 0.29166666666667
4550, 0.29166666666667, 0, 0.3125
4551, 0.27083333333333, 0, 0.33333333333333
4552, 0.29166666666667, 0, 0.35416666666667
4553, 0.27083333333333, 0, 0.375
4554, 0.29166666666667, 0, 0.39583333333333
4555, 0.27083333333333, 0, 0.41666666666667
4556, 0.29166666666667, 0, 0.4375
4557, 0.27083333333333, 0, 0.45833333333333
4558, 0.29166666666667, 0, 0.47916666666667
4559, 0.33333333333333, 0, 0.020833333333333
4560, 0.3125, 0, 0.041666666666667
4561, 0.33333333333333, 0, 0.0625
4562, 0.3125, 0, 0.083333333333333
4563, 0.33333333333333, 0, 0.10416666666667
4564, 0.3125, 0, 0.125
4565, 0.33333333333333, 0, 0.14583333333333
4566, 0.3125, 0, 0.16666666666667
4567, 0.33333333333333, 0, 0.1875
4568, 0.3125, 0, 0.20833333333333
4569, 0.33333333333333, 0, 0.22916666666667
4570, 0.3125, 0, 0.25
4571, 0.33333333333333, 0, 0.27083333333333
4572, 0.3125, 0, 0.29166666666667
4573, 0.33333333333333, 0, 0.3125
4574, 0.3125, 0, 0.33333333333333
4575, 0.33333333333333, 0, 0.35416666666667
4576, 0.3125, 0, 0.375
4577, 0.33333333333333, 0, 0.39583333333333
4578, 0.3125, 0, 0.41666666666667
4579, 0.33333333333333, 0, 0.4375
4580, 0.3125, 0, 0.45833333333333
4581, 0.33333333333333, 0, 0.47916666666667
4582, 0.375, 0, 0.020833333333333
4583, 0.35416666666667, 0, 0.041666666666667
4584, 0.375, 0, 0.0625
4585, 0.35416666666667, 0, 0.083333333333333
4586, 0.375, 0, 0.10416666666667
4587, 0.35416666666667, 0, 0.125
4588, 0.375, 0, 0.14583333333333
4589, 0.35416666666667, 0, 0.16666666666667
4590, 0.375, 0, 0.1875
4591, 0.35416666666667, 0, 0.20833333333333
4592, 0.375, 0, 0.22916666666667
4593, 0.35416666666667, 0, 0.25
4594, 0.375, 0, 0.27083333333333
4595, 0.35416666666667, 0, 0.29166666666667
4596, 0.375, 0, 0.3125
4597, 0.35416666666667, 0, 0.33333333333333
4598, 0.375, 0, 0.35416666666667
4599, 0.35416666666667, 0, 0.375
4600, 0.375, 0, 0.39583333333333
4601, 0.35416666666667, 0, 0.41666666666667
4602, 0.375, 0, 0.4375
4603, 0.35416666666667, 0, 0.45833333333333
4604, 0.375, 0, 0.47916666666667
4605, 0.41666666666667, 0, 0.020833333333333
4606, 0.39583333333333, 0, 0.041666666666667
4607, 0.41666666666667, 0, 0.0625
4608, 0.39583333333333, 0, 0.083333333333333
4609, 0.41666666666667, 0, 0.10416666666667
4610, 0.39583333333333, 0, 0.125
4611, 0.41666666666667, 0, 0.14583333333333
4612, 0.39583333333333, 0, 0.16666666666667
4613, 0.41666666666667, 0, 0.1875
4614, 0.39583333333333, 0, 0.20833333333333
4615, 0.41666666666667, 0, 0.22916666666667
4616, 0.39583333333333, 0, 0.25
4617, 0.41666666666667, 0, 0.27083333333333
4618, 0.39583333333333, 0, 0.29166666666667
4619, 0.41666666666667, 0, 0.3125
4620, 0.39583333333333, 0, 0.33333333333333
4621, 0.41666666666667, 0, 0.35416666666667
4622, 0.39583333333333, 0, 0.375
4623, 0.41666666666667, 0, 0.39583333333333
4624, 0.39583333333333, 0, 0.41666666666667
4625, 0.41666666666667, 0, 0.4375
4626, 0.39583333333333, 0, 0.45833333333333
4627, 0.41666666666667, 0, 0.47916666666667
4628, 0.45833333333333, 0, 0.020833333333333
4629, 0.4375, 0, 0.041666666666667
4630, 0.45833333333333, 0, 0.0625
4631, 0.4375, 0, 0.083333333333333
4632, 0.45833333333333, 0, 0.10416666666667
4633, 0.4375, 0, 0.125
4634, 0.45833333333333, 0, 0.14583333333333
4635, 0.4375, 0, 0.16666666666667
4636, 0.45833333333333, 0, 0.1875
4637, 0.4375, 0, 0.20833333333333
4638, 0.45833333333333, 0, 0.22916666666667
4639, 0.4375, 0, 0.25
4640, 0.45833333333333, 0, 0.27083333333333
4641, 0.4375, 0, 0.29166666666667
4642, 0.45833333333333, 0, 0.3125
4643, 0.4375, 0, 0.33333333333333
4644, 0.45833333333333, 0, 0.35416666666667
4645, 0.4375, 0, 0.375
4646, 0.45833333333333, 0, 0.39583333333333
4647, 0.4375, 0, 0.41666666666667
4648, 0.45833333333333, 0, 0.4375
4649, 0.4375, 0, 0.45833333333333
4650, 0.45833333333333, 0, 0.47916666666667
4651, 0.5, 0, 0.020833333333333
4652, 0.47916666666667, 0, 0.041666666666667
4653, 0.5, 0, 0.0625
4654, 0.47916666666667, 0, 0.083333333333333
4655, 0.5, 0, 0.10416666666667
4656, 0.47916666666667, 0, 0.125
4657, 0.5, 0, 0.14583333333333
4658, 0.47916666666667, 0, 0.16666666666667
4659, 0.5, 0, 0.1875
4660, 0.47916666666667, 0, 0.20833333333333
4661, 0.5, 0, 0.22916666666667
4662, 0.47916666666667, 0, 0.25
4663, 0.5, 0, 0.27083333333333
4664, 0.47916666666667, 0, 0.29166666666667
4665, 0.5, 0, 0.3125
4666, 0.47916666666667, 0, 0.33333333333333
4667, 0.5, 0, 0.35416666666667
4668, 0.47916666666667, 0, 0.375
4669, 0.5, 0, 0.39583333333333
4670, 0.47916666666667, 0, 0.41666666666667
4671, 0.5, 0, 0.4375
4672, 0.47916666666667, 0, 0.45833333333333
4673, 0.5, 0, 0.47916666666667
4674, 0.54166666666667, 0, 0.020833333333333
4675, 0.52083333333333, 0, 0.041666666666667
4676, 0.54166666666667, 0, 0.0625
4677, 0.52083333333333, 0, 0.083333333333333
4678, 0.54166666666667, 0, 0.10416666666667
4679, 0.52083333333333, 0, 0.125
4680, 0.54166666666667, 0, 0.14583333333333
4681, 0.52083333333333, 0, 0.16666666666667
4682, 0.54166666666667, 0, 0.1875
4683, 0.52083333333333, 0, 0.20833333333333
4684, 0.54166666666667, 0, 0.22916666666667
4685, 0.52083333333333, 0, 0.25
4686, 0.54166666666667, 0, 0.27083333333333
4687, 0.52083333333333, 0, 0.29166666666667
4688, 0.54166666666667, 0, 0.3125
4689, 0.52083333333333, 0, 0.33333333333333
4690, 0.54166666666667, 0, 0.35416666666667
4691, 0.52083333333333, 0, 0.375
4692, 0.54166666666667, 0, 0.39583333333333
4693, 0.52083333333333, 0, 0.41666666666667
4694, 0.54166666666667, 0, 0.4375
4695, 0.52083333333333, 0, 0.45833333333333
4696, 0.54166666666667, 0, 0.47916666666667
4697, 0.58333333333333, 0, 0.020833333333333
4698, 0.5625, 0, 0.041666666666667
4699, 0.58333333333333, 0, 0.0625
4700, 0.5625, 0, 0.083333333333333
4701, 0.58333333333333, 0, 0.10416666666667
4702, 0.5625, 0, 0.125
4703, 0.58333333333333, 0, 0.14583333333333
4704, 0.5625, 0, 0.16666666666667
4705, 0.58333333333333, 0, 0.1875
4706, 0.5625, 0, 0.20833333333333
4707, 0.58333333333333, 0, 0.22916666666667
4708, 0.5625, 0, 0.25
4709, 0.58333333333333, 0, 0.27083333333333
4710, 0.5625, 0, 0.29166666666667
4711, 0.58333333333333, 0, 0.3125
4712, 0.5625, 0, 0.33333333333333
4713, 0.58333333333333, 0, 0.35416666666667
4714, 0.5625, 0, 0.375
4715, 0.58333333333333, 0, 0.39583333333333
4716, 0.5625, 0, 0.41666666666667
4717, 0.58333333333333, 0, 0.4375
4718, 0.5625, 0, 0.45833333333333
4719, 0.58333333333333, 0, 0.47916666666667
4720, 0.625, 0, 0.020833333333333
4721, 0.60416666666667, 0, 0.041666666666667
4722, 0.625, 0, 0.0625
4723, 0.60416666666667, 0, 0.083333333333333
4724, 0.625, 0, 0.10416666666667
4725, 0.60416666666667, 0, 0.125
4726, 0.625, 0, 0.14583333333333
4727, 0.60416666666667, 0, 0.16666666666667
4728, 0.625, 0, 0.1875
4729, 0.60416666666667, 0, 0.20833333333333
4730, 0.625, 0, 0.22916666666667
4731, 0.60416666666667, 0, 0.25
4732, 0.625, 0, 0.27083333333333
4733, 0.60416666666667, 0, 0.29166666666667
4734, 0.625, 0, 0.3125
4735, 0.60416666666667, 0, 0.33333333333333
4736, 0.625, 0, 0.35416666666667
4737, 0.60416666666667, 0, 0.375
4738, 0.625, 0, 0.39583333333333
4739, 0.60416666666667, 0, 0.41666666666667
4740, 0.625, 0, 0.4375
4741, 0.60416666666667, 0, 0.45833333333333
4742, 0.625, 0, 0.47916666666667
4743, 0.66666666666667, 0, 0.020833333333333
4744, 0.64583333333333, 0, 0.041666666666667
4745, 0.66666666666667, 0, 0.0625
4746, 0.64583333333333, 0, 0.083333333333333
4747, 0.66666666666667, 0, 0.10416666666667
4748, 0.64583333333333, 0, 0.125
4749, 0.66666666666667, 0, 0.14583333333333
4750, 0.64583333333333, 0, 0.16666666666667
4751, 0.66666666666667, 0, 0.1875
4752, 0.64583333333333, 0, 0.20833333333333
4753, 0.66666666666667, 0, 0.22916666666667
4754, 0.64583333333333, 0, 0.25
4755, 0.66666666666667, 0, 0.27083333333333
4756, 0.64583333333333, 0, 0.29166666666667
4757, 0.66666666666667, 0, 0.3125
4758, 0.64583333333333, 0, 0.33333333333333
4759, 0.66666666666667, 0, 0.35416666666667
4760, 0.64583333333333, 0, 0.375
4761, 0.66666666666667, 0, 0.39583333333333
4762, 0.64583333333333, 0, 0.41666666666667
4763, 0.66666666666667, 0, 0.4375
4764, 0.64583333333333, 0, 0.45833333333333
4765, 0.66666666666667, 0, 0.47916666666667
4766, 0.70833333333333, 0, 0.020833333333333
4767, 0.6875, 0, 0.041666666666667
4768, 0.70833333333333, 0, 0.0625
4769, 0.6875, 0, 0.083333333333333
4770, 0.70833333333333, 0, 0.10416666666667
4771, 0.6875, 0, 0.125
4772, 0.70833333333333, 0, 0.14583333333333
4773, 0.6875, 0, 0.16666666666667
4774, 0.70833333333333, 0, 0.1875
4775, 0.6875, 0, 0.20833333333333
4776, 0.70833333333333, 0, 0.22916666666667
4777, 0.6875, 0, 0.25
4778, 0.70833333333333, 0, 0.27083333333333
4779, 0.6875, 0, 0.29166666666667
4780, 0.70833333333333, 0, 0.3125
4781, 0.6875, 0, 0.33333333333333
4782, 0.70833333333333, 0, 0.35416666666667
4783, 0.6875, 0, 0.375
4784, 0.70833333333333, 0, 0.39583333333333
4785, 0.6875, 0, 0.41666666666667
4786, 0.70833333333333, 0, 0.4375
4787, 0.6875, 0, 0.45833333333333
4788, 0.70833333333333, 0, 0.47916666666667
4789, 0.75, 0, 0.020833333333333
4790, 0.72916666666667, 0, 0.041666666666667
4791, 0.75, 0, 0.0625
4792, 0.72916666666667, 0, 0.083333333333333
4793, 0.75, 0, 0.10416666666667
4794, 0.72916666666667, 0, 0.125
4795, 0.75, 0, 0.14583333333333
4796, 0.72916666666667, 0, 0.16666666666667
4797, 0.75, 0, 0.1875
4798, 0.72916666666667, 0, 0.20833333333333
4799, 0.75, 0, 0.22916666666667
4800, 0.72916666666667, 0, 0.25
4801, 0.75, 0, 0.27083333333333
4802, 0.72916666666667, 0, 0.29166666666667
4803, 0.75, 0, 0.3125
4804, 0.72916666666667, 0, 0.33333333333333
4805, 0.75, 0, 0.35416666666667
4806, 0.72916666666667, 0, 0.375
4807, 0.75, 0, 0.39583333333333
4808, 0.72916666666667, 0, 0.41666666666667
4809, 0.75, 0, 0.4375
4810, 0.72916666666667, 0, 0.45833333333333
4811, 0.75, 0, 0.47916666666667
4812, 0.79166666666667, 0, 0.020833333333333
4813, 0.77083333333333, 0, 0.041666666666667
4814, 0.79166666666667, 0, 0.0625
4815, 0.77083333333333, 0, 0.083333333333333
4816, 0.79166666666667, 0, 0.10416666666667
4817, 0.77083333333333, 0, 0.125
4818, 0.79166666666667, 0, 0.14583333333333
4819, 0.77083333333333, 0, 0.16666666666667
4820, 0.79166666666667, 0, 0.1875
4821, 0.77083333333333, 0, 0.20833333333333
4822, 0.79166666666667, 0, 0.22916666666667
4823, 0.77083333333333, 0, 0.25
4824, 0.79166666666667, 0, 0.27083333333333
4825, 0.77083333333333, 0, 0.29166666666667
4826, 0.79166666666667, 0, 0.3125
4827, 0.77083333333333, 0, 0.33333333333333
4828, 0.79166666666667, 0, 0.35416666666667
4829, 0.77083333333333, 0, 0.375
4830, 0.79166666666667, 0, 0.39583333333333
4831, 0.77083333333333, 0, 0.41666666666667
4832, 0.79166666666667, 0, 0.4375
4833, 0.77083333333333, 0, 0.45833333333333
4834, 0.79166666666667, 0, 0.47916666666667
4835, 0.83333333333333, 0, 0.020833333333333
4836, 0.8125, 0, 0.041666666666667
4837, 0.83333333333333, 0, 0.0625
4838, 0.8125, 0, 0.083333333333333
4839, 0.83333333333333, 0, 0.10416666666667
4840, 0.8125, 0, 0.125
4841, 0.83333333333333, 0, 0.14583333333333
4842, 0.8125, 0, 0.16666666666667
4843, 0.83333333333333, 0, 0.1875
4844, 0.8125, 0, 0.20833333333333
4845, 0.83333333333333, 0, 0.22916666666667
4846, 0.8125, 0, 0.25
4847, 0.83333333333333, 0, 0.27083333333333
4848, 0.8125, 0, 0.29166666666667
4849, 0.83333333333333, 0, 0.3125
4850, 0.8125, 0, 0.33333333333333
4851, 0.83333333333333, 0, 0.35416666666667
4852, 0.8125, 0, 0.375
4853, 0.83333333333333, 0, 0.39583333333333
4854, 0.8125, 0, 0.41666666666667
4855, 0.83333333333333, 0, 0.4375
4856, 0.8125, 0, 0.45833333333333
4857, 0.83333333333333, 0, 0.47916666666667
4858, 0.875, 0, 0.020833333333333
4859, 0.85416666666667, 0, 0.041666666666667
4860, 0.875, 0, 0.0625
4861, 0.85416666666667, 0, 0.083333333333333
4862, 0.875, 0, 0.10416666666667
4863, 0.85416666666667, 0, 0.125
4864, 0.875, 0, 0.14583333333333
4865, 0.85416666666667, 0, 0.16666666666667
4866, 0.875, 0, 0.1875
4867, 0.85416666666667, 0, 0.20833333333333
4868, 0.875, 0, 0.22916666666667
4869, 0.85416666666667, 0, 0.25
4870, 0.875, 0, 0.27083333333333
4871, 0.85416666666667, 0, 0.29166666666667
4872, 0.875, 0, 0.3125
4873, 0.85416666666667, 0, 0.33333333333333
4874, 0.875, 0, 0.35416666666667
4875, 0.85416666666667, 0, 0.375
4876, 0.875, 0, 0.39583333333333
4877, 0.85416666666667, 0, 0.41666666666667
4878, 0.875, 0, 0.4375
4879, 0.85416666666667, 0, 0.45833333333333
4880, 0.875, 0, 0.47916666666667
4881, 0.91666666666667, 0, 0.020833333333333
4882, 0.89583333333333, 0, 0.041666666666667
4883, 0.91666666666667, 0, 0.0625
4884, 0.89583333333333, 0, 0.083333333333333
4885, 0.91666666666667, 0, 0.10416666666667
4886, 0.89583333333333, 0, 0.125
4887, 0.91666666666667, 0, 0.14583333333333
4888, 0.89583333333333, 0, 0.16666666666667
4889, 0.91666666666667, 0, 0.1875
4890, 0.89583333333333, 0, 0.20833333333333
4891, 0.91666666666667, 0, 0.22916666666667
4892, 0.89583333333333, 0, 0.25
4893, 0.91666666666667, 0, 0.27083333333333
4894, 0.89583333333333, 0, 0.29166666666667
4895, 0.91666666666667, 0, 0.3125
4896, 0.89583333333333, 0, 0.33333333333333
4897, 0.91666666666667, 0, 0.35416666666667
4898, 0.89583333333333, 0, 0.375
4899, 0.91666666666667, 0, 0.39583333333333
4900, 0.89583333333333, 0, 0.41666666666667
4901, 0.91666666666667, 0, 0.4375
4902, 0.89583333333333, 0, 0.45833333333333
4903, 0.91666666666667, 0, 0.47916666666667
4904, 0.95833333333333, 0, 0.020833333333333
4905, 0.9375, 0, 0.041666666666667
4906, 0.95833333333333, 0, 0.0625
4907, 0.9375, 0, 0.083333333333333
4908, 0.95833333333333, 0, 0.10416666666667
4909, 0.9375, 0, 0.125
4910, 0.95833333333333, 0, 0.14583333333333
4911, 0.9375, 0, 0.16666666666667
4912, 0.95833333333333, 0, 0.1875
4913, 0.9375, 0, 0.20833333333333
4914, 0.95833333333333, 0, 0.22916666666667
4915, 0.9375, 0, 0.25
4916, 0.95833333333333, 0, 0.27083333333333
4917, 0.9375, 0, 0.29166666666667
4918, 0.95833333333333, 0, 0.3125
4919, 0.9375, 0, 0.33333333333333
4920, 0.95833333333333, 0, 0.35416666666667
4921, 0.9375, 0, 0.375
4922, 0.95833333333333, 0, 0.39583333333333
4923, 0.9375, 0, 0.41666666666667
4924, 0.95833333333333, 0, 0.4375
4925, 0.9375, 0, 0.45833333333333
4926, 0.95833333333333, 0, 0.47916666666667
4927, 0.97916666666667, 0, 0.041666666666667
4928, 0.97916666666667, 0, 0.083333333333333
4929, 0.97916666666667, 0, 0.125
4930, 0.97916666666667, 0, 0.16666666666667
4931, 0.97916666666667, 0, 0.20833333333333
4932, 0.97916666666667, 0, 0.25
4933, 0.97916666666667, 0, 0.29166666666667
4934, 0.97916666666667, 0, 0.33333333333333
4935, 0.97916666666667, 0, 0.375
4936, 0.97916666666667, 0, 0.41666666666667
4937, 0.97916666666667, 0, 0.45833333333333
4938, 0.041666666666667, 0.1, 0.041666666666667
4939, 0.041666666666667, 0.1, 0.083333333333333
4940, 0.041666666666667, 0.1, 0.125
4941, 0.041666666666667, 0.1, 0.16666666666667
4942, 0.041666666666667, 0.1, 0.20833333333333
4943, 0.041666666666667, 0.1, 0.25
4944, 0.041666666666667, 0.1, 0.29166666666667
4945, 0.041666666666667, 0.1, 0.33333333333333
4946, 0.041666666666667, 0.1, 0.375
4947, 0.041666666666667, 0.1, 0.41666666666667
4948, 0.041666666666667, 0.1, 0.45833333333333
4949, 0.083333333333333, 0.1, 0.041666666666667
4950, 0.083333333333333, 0.1, 0.083333333333333
4951, 0.083333333333333, 0.1, 0.125
4952, 0.083333333333333, 0.1, 0.16666666666667
4953, 0.083333333333333, 0.1, 0.20833333333333
4954, 0.083333333333333, 0.1, 0.25
4955, 0.083333333333333, 0.1, 0.29166666666667
4956, 0.083333333333333, 0.1, 0.33333333333333
4957, 0.083333333333333, 0.1, 0.375
4958, 0.083333333333333, 0.1, 0.41666666666667
4959, 0.083333333333333, 0.1, 0.45833333333333
4960, 0.125, 0.1, 0.041666666666667
4961, 0.125, 0.1, 0.083333333333333
4962, 0.125, 0.1, 0.125
4963, 0.125, 0.1, 0.16666666666667
4964, 0.125, 0.1, 0.20833333333333
4965, 0.125, 0.1, 0.25
4966, 0.125, 0.1, 0.29166666666667
4967, 0.125, 0.1, 0.33333333333333
4968, 0.125, 0.1, 0.375
4969, 0.125, 0.1, 0.41666666666667
4970, 0.125, 0.1, 0.45833333333333
4971, 0.16666666666667, 0.1, 0.041666666666667
4972, 0.16666666666667, 0.1, 0.083333333333333
4973, 0.16666666666667, 0.1, 0.125
4974, 0.16666666666667, 0.1, 0.16666666666667
4975, 0.16666666666667, 0.1, 0.20833333333333
4976, 0.16666666666667, 0.1, 0.25
4977, 0.16666666666667, 0.1, 0.29166666666667
4978, 0.16666666666667, 0.1, 0.33333333333333
4979, 0.16666666666667, 0.1, 0.375
4980, 0.16666666666667, 0.1, 0.41666666666667
4981, 0.16666666666667, 0.1, 0.45833333333333
4982, 0.20833333333333, 0.1, 0.041666666666667
4983, 0.20833333333333, 0.1, 0.083333333333333
4984, 0.20833333333333, 0.1, 0.125
4985, 0.20833333333333, 0.1, 0.16666666666667
4986, 0.20833333333333, 0.1, 0.20833333333333
4987, 0.20833333333333, 0.1, 0.25
4988, 0.20833333333333, 0.1, 0.29166666666667
4989, 0.20833333333333, 0.1, 0.33333333333333
4990, 0.20833333333333, 0.1, 0.375
4991, 0.20833333333333, 0.1, 0.41666666666667
4992, 0.20833333333333, 0.1, 0.45833333333333
4993, 0.25, 0.1, 0.041666666666667
4994, 0.25, 0.1, 0.083333333333333
4995, 0.25, 0.1, 0.125
4996, 0.25, 0.1, 0.16666666666667
4997, 0.25, 0.1, 0.20833333333333
4998, 0.25, 0.1, 0.25
4999, 0.25, 0.1, 0.29166666666667
5000, 0.25, 0.1, 0.33333333333333
5001, 0.25, 0.1, 0.375
5002, 0.25, 0.1, 0.41666666666667
5003, 0.25, 0.1, 0.45833333333333
5004, 0.29166666666667, 0.1, 0.041666666666667
5005, 0.29166666666667, 0.1, 0.083333333333333
5006, 0.29166666666667, 0.1, 0.125
5007, 0.29166666666667, 0.1, 0.16666666666667
5008, 0.29166666666667, 0.1, 0.20833333333333
5009, 0.29166666666667, 0.1, 0.25
5010, 0.29166666666667, 0.1, 0.29166666666667
5011, 0.29166666666667, 0.1, 0.33333333333333
5012, 0.29166666666667, 0.1, 0.375
5013, 0.29166666666667, 0.1, 0.41666666666667
5014, 0.29166666666667, 0.1, 0.45833333333333
5015, 0.33333333333333, 0.1, 0.041666666666667
5016, 0.33333333333333, 0.1, 0.083333333333333
5017, 0.33333333333333, 0.1, 0.125
5018, 0.33333333333333, 0.1, 0.16666666666667
5019, 0.33333333333333, 0.1, 0.20833333333333
5020, 0.33333333333333, 0.1, 0.25
5021, 0.33333333333333, 0.1, 0.29166666666667
5022, 0.33333333333333, 0.1, 0.33333333333333
5023, 0.33333333333333, 0.1, 0.375
5024, 0.33333333333333, 0.1, 0.41666666666667
5025, 0.33333333333333, 0.1, 0.45833333333333
5026, 0.375, 0.1, 0.041666666666667
5027, 0.375, 0.1, 0.083333333333333
5028, 0.375, 0.1, 0.125
5029, 0.375, 0.1, 0.16666666666667
5030, 0.375, 0.1, 0.20833333333333
5031, 0.375, 0.1, 0.25
5032, 0.375, 0.1, 0.29166666666667
5033, 0.375, 0.1, 0.33333333333333
5034, 0.375, 0.1, 0.375
5035, 0.375, 0.1, 0.41666666666667
5036, 0.375, 0.1, 0.45833333333333
5037, 0.41666666666667, 0.1, 0.041666666666667
5038, 0.41666666666667, 0.1, 0.083333333333333
5039, 0.41666666666667, 0.1, 0.125
5040, 0.41666666666667, 0.1, 0.16666666666667
5041, 0.41666666666667, 0.1, 0.20833333333333
5042, 0.41666666666667, 0.1, 0.25
5043, 0.41666666666667, 0.1, 0.29166666666667
5044, 0.41666666666667, 0.1, 0.33333333333333
5045, 0.41666666666667, 0.1, 0.375
5046, 0.41666666666667, 0.1, 0.41666666666667
5047, 0.41666666666667, 0.1, 0.45833333333333
5048, 0.45833333333333, 0.1, 0.041666666666667
5049, 0.45833333333333, 0.1, 0.083333333333333
5050, 0.45833333333333, 0.1, 0.125
5051, 0.45833333333333, 0.1, 0.16666666666667
5052, 0.45833333333333, 0.1, 0.20833333333333
5053, 0.45833333333333, 0.1, 0.25
5054, 0.45833333333333, 0.1, 0.29166666666667
5055, 0.45833333333333, 0.1, 0.33333333333333
5056, 0.45833333333333, 0.1, 0.375
5057, 0.45833333333333, 0.1, 0.41666666666667
5058, 0.45833333333333, 0.1, 0.45833333333333
5059, 0.5, 0.1, 0.041666666666667
5060, 0.5, 0.1, 0.083333333333333
5061, 0.5, 0.1, 0.125
5062, 0.5, 0.1, 0.16666666666667
5063, 0.5, 0.1, 0.20833333333333
5064, 0.5, 0.1, 0.25
5065, 0.5, 0.1, 0.29166666666667
5066, 0.5, 0.1, 0.33333333333333
5067, 0.5, 0.1, 0.375
5068, 0.5, 0.1, 0.41666666666667
5069, 0.5, 0.1, 0.45833333333333
5070, 0.54166666666667, 0.1, 0.041666666666667
5071, 0.54166666666667, 0.1, 0.083333333333333
5072, 0.54166666666667, 0.1, 0.125
5073, 0.54166666666667, 0.1, 0.16666666666667
5074, 0.54166666666667, 0.1, 0.20833333333333
5075, 0.54166666666667, 0.1, 0.25
5076, 0.54166666666667, 0.1, 0.29166666666667
5077, 0.54166666666667, 0.1, 0.33333333333333
5078, 0.54166666666667, 0.1, 0.375
5079, 0.54166666666667, 0.1, 0.41666666666667
5080, 0.54166666666667, 0.1, 0.45833333333333
5081, 0.58333333333333, 0.1, 0.041666666666667
5082, 0.58333333333333, 0.1, 0.083333333333333
5083, 0.58333333333333, 0.1, 0.125
5084, 0.58333333333333, 0.1, 0.16666666666667
5085, 0.58333333333333, 0.1, 0.20833333333333
5086, 0.58333333333333, 0.1, 0.25
5087, 0.58333333333333, 0.1, 0.29166666666667
5088, 0.58333333333333, 0.1, 0.33333333333333
5089, 0.58333333333333, 0.1, 0.375
5090, 0.58333333333333, 0.1, 0.41666666666667
5091, 0.58333333333333, 0.1, 0.45833333333333
5092, 0.625, 0.1, 0.041666666666667
5093, 0.625, 0.1, 0.083333333333333
5094, 0.625, 0.1, 0.125
5095, 0.625, 0.1, 0.16666666666667
5096, 0.625, 0.1, 0.20833333333333
5097, 0.625, 0.1, 0.25
5098, 0.625, 0.1, 0.29166666666667
5099, 0.625, 0.1, 0.33333333333333
5100, 0.625, 0.1, 0.375
5101, 0.625, 0.1, 0.41666666666667
5102, 0.625, 0.1, 0.45833333333333
5103, 0.66666666666667, 0.1, 0.041666666666667
5104, 0.66666666666667, 0.1, 0.083333333333333
5105, 0.66666666666667, 0.1, 0.125
5106, 0.66666666666667, 0.1, 0.16666666666667
5107, 0.66666666666667, 0.1, 0.20833333333333
5108, 0.66666666666667, 0.1, 0.25
5109, 0.66666666666667, 0.1, 0.29166666666667
5110, 0.66666666666667, 0.1, 0.33333333333333
5111, 0.66666666666667, 0.1, 0.375
5112, 0.66666666666667, 0.1, 0.41666666666667
5113, 0.66666666666667, 0.1, 0.45833333333333
5114, 0.70833333333333, 0.1, 0.041666666666667
5115, 0.70833333333333, 0.1, 0.083333333333333
5116, 0.70833333333333, 0.1, 0.125
5117, 0.70833333333333, 0.1, 0.16666666666667
5118, 0.70833333333333, 0.1, 0.20833333333333
5119, 0.70833333333333, 0.1, 0.25
5120, 0.70833333333333, 0.1, 0.29166666666667
5121, 0.70833333333333, 0.1, 0.33333333333333
5122, 0.70833333333333, 0.1, 0.375
5123, 0.70833333333333, 0.1, 0.41666666666667
5124, 0.70833333333333, 0.1, 0.45833333333333
5125, 0.75, 0.1, 0.041666666666667
5126, 0.75, 0.1, 0.083333333333333
5127, 0.75, 0.1, 0.125
5128, 0.75, 0.1, 0.16666666666667
5129, 0.75, 0.1, 0.20833333333333
5130, 0.75, 0.1, 0.25
5131, 0.75, 0.1, 0.29166666666667
5132, 0.75, 0.1, 0.33333333333333
5133, 0.75, 0.1, 0.375
5134, 0.75, 0.1, 0.41666666666667
5135, 0.75, 0.1, 0.45833333333333
5136, 0.79166666666667, 0.1, 0.041666666666667
5137, 0.79166666666667, 0.1, 0.083333333333333
5138, 0.79166666666667, 0.1, 0.125
5139, 0.79166666666667, 0.1, 0.16666666666667
5140, 0.79166666666667, 0.1, 0.20833333333333
5141, 0.79166666666667, 0.1, 0.25
5142, 0.79166666666667, 0.1, 0.29166666666667
5143, 0.79166666666667, 0.1, 0.33333333333333
5144, 0.79166666666667, 0.1, 0.375
5145, 0.79166666666667, 0.1, 0.41666666666667
5146, 0.79166666666667, 0.1, 0.45833333333333
5147, 0.83333333333333, 0.1, 0.041666666666667
5148, 0.83333333333333, 0.1, 0.083333333333333
5149, 0.83333333333333, 0.1, 0.125
5150, 0.83333333333333, 0.1, 0.16666666666667
5151, 0.83333333333333, 0.1, 0.20833333333333
5152, 0.83333333333333, 0.1, 0.25
5153, 0.83333333333333, 0.1, 0.29166666666667
5154, 0.83333333333333, 0.1, 0.33333333333333
5155, 0.83333333333333, 0.1, 0.375
5156, 0.83333333333333, 0.1, 0.41666666666667
5157, 0.83333333333333, 0.1, 0.45833333333333
5158, 0.875, 0.1, 0.041666666666667
5159, 0.875, 0.1, 0.083333333333333
5160, 0.875, 0.1, 0.125
5161, 0.875, 0.1, 0.16666666666667
5162, 0.875, 0.1, 0.20833333333333
5163, 0.875, 0.1, 0.25
5164, 0.875, 0.1, 0.29166666666667
5165, 0.875, 0.1, 0.33333333333333
5166, 0.875, 0.1, 0.375
5167, 0.875, 0.1, 0.41666666666667
5168, 0.875, 0.1, 0.45833333333333
5169, 0.91666666666667, 0.1, 0.041666666666667
5170, 0.91666666666667, 0.1, 0.083333333333333
5171, 0.91666666666667, 0.1, 0.125
5172, 0.91666666666667, 0.1, 0.16666666666667
5173, 0.91666666666667, 0.1, 0.20833333333333
5174, 0.91666666666667, 0.1, 0.25
5175, 0.91666666666667, 0.1, 0.29166666666667
5176, 0.91666666666667, 0.1, 0.33333333333333
5177, 0.91666666666667, 0.1, 0.375
5178, 0.91666666666667, 0.1, 0.41666666666667
5179, 0.91666666666667, 0.1, 0.45833333333333
5180, 0.95833333333333, 0.1, 0.041666666666667
5181, 0.95833333333333, 0.1, 0.083333333333333
5182, 0.95833333333333, 0.1, 0.125
5183, 0.95833333333333, 0.1, 0.16666666666667
5184, 0.95833333333333, 0.1, 0.20833333333333
5185, 0.95833333333333, 0.1, 0.25
5186, 0.95833333333333, 0.1, 0.29166666666667
5187, 0.95833333333333, 0.1, 0.33333333333333
5188, 0.95833333333333, 0.1, 0.375
5189, 0.95833333333333, 0.1, 0.41666666666667
5190, 0.95833333333333, 0.1, 0.45833333333333
5191, 0.020833333333333, 0.1, 0.041666666666667
5192, 0.041666666666667, 0.1, 0.020833333333333
5193, 0.020833333333333, 0.1, 0.083333333333333
5194, 0.041666666666667, 0.1, 0.0625
5195, 0.020833333333333, 0.1, 0.125
5196, 0.041666666666667, 0.1, 0.10416666666667
5197, 0.020833333333333, 0.1, 0.16666666666667
5198, 0.041666666666667, 0.1, 0.14583333333333
5199, 0.020833333333333, 0.1, 0.20833333333333
5200, 0.041666666666667, 0.1, 0.1875
5201, 0.020833333333333, 0.1, 0.25
5202, 0.041666666666667, 0.1, 0.22916666666667
5203, 0.020833333333333, 0.1, 0.29166666666667
5204, 0.041666666666667, 0.1, 0.27083333333333
5205, 0.020833333333333, 0.1, 0.33333333333333
5206, 0.041666666666667, 0.1, 0.3125
5207, 0.020833333333333, 0.1, 0.375
5208, 0.041666666666667, 0.1, 0.35416666666667
5209, 0.020833333333333, 0.1, 0.41666666666667
5210, 0.041666666666667, 0.1, 0.39583333333333
5211, 0.020833333333333, 0.1, 0.45833333333333
5212, 0.041666666666667, 0.1, 0.4375
5213, 0.041666666666667, 0.1, 0.47916666666667
5214, 0.0625, 0.1, 0.041666666666667
5215, 0.083333333333333, 0.1, 0.020833333333333
5216, 0.0625, 0.1, 0.083333333333333
5217, 0.083333333333333, 0.1, 0.0625
5218, 0.0625, 0.1, 0.125
5219, 0.083333333333333, 0.1, 0.10416666666667
5220, 0.0625, 0.1, 0.16666666666667
5221, 0.083333333333333, 0.1, 0.14583333333333
5222, 0.0625, 0.1, 0.20833333333333
5223, 0.083333333333333, 0.1, 0.1875
5224, 0.0625, 0.1, 0.25
5225, 0.083333333333333, 0.1, 0.22916666666667
5226, 0.0625, 0.1, 0.29166666666667
5227, 0.083333333333333, 0.1, 0.27083333333333
5228, 0.0625, 0.1, 0.33333333333333
5229, 0.083333333333333, 0.1, 0.3125
5230, 0.0625, 0.1, 0.375
5231, 0.083333333333333, 0.1, 0.35416666666667
5232, 0.0625, 0.1, 0.41666666666667
5233, 0.083333333333333, 0.1, 0.39583333333333
5234, 0.0625, 0.1, 0.45833333333333
5235, 0.083333333333333, 0.1, 0.4375
5236, 0.083333333333333, 0.1, 0.47916666666667
5237, 0.10416666666667, 0.1, 0.041666666666667
5238, 0.125, 0.1, 0.020833333333333
5239, 0.10416666666667, 0.1, 0.083333333333333
5240, 0.125, 0.1, 0.0625
5241, 0.10416666666667, 0.1, 0.125
5242, 0.125, 0.1, 0.10416666666667
5243, 0.10416666666667, 0.1, 0.16666666666667
5244, 0.125, 0.1, 0.14583333333333
5245, 0.10416666666667, 0.1, 0.20833333333333
5246, 0.125, 0.1, 0.1875
5247, 0.10416666666667, 0.1, 0.25
5248, 0.125, 0.1, 0.22916666666667
5249, 0.10416666666667, 0.1, 0.29166666666667
5250, 0.125, 0.1, 0.27083333333333
5251, 0.10416666666667, 0.1, 0.33333333333333
5252, 0.125, 0.1, 0.3125
5253, 0.10416666666667, 0.1, 0.375
5254, 0.125, 0.1, 0.35416666666667
5255, 0.10416666666667, 0.1, 0.41666666666667
5256, 0.125, 0.1, 0.39583333333333
5257, 0.10416666666667, 0.1, 0.45833333333333
5258, 0.125, 0.1, 0.4375
5259, 0.125, 0.1, 0.47916666666667
5260, 0.14583333333333, 0.1, 0.041666666666667
5261, 0.16666666666667, 0.1, 0.020833333333333
5262, 0.14583333333333, 0.1, 0.083333333333333
5263, 0.16666666666667, 0.1, 0.0625
5264, 0.14583333333333, 0.1, 0.125
5265, 0.16666666666667, 0.1, 0.10416666666667
5266, 0.14583333333333, 0.1, 0.16666666666667
5267, 0.16666666666667, 0.1, 0.14583333333333
5268, 0.14583333333333, 0.1, 0.20833333333333
5269, 0.16666666666667, 0.1, 0.1875
5270, 0.14583333333333, 0.1, 0.25
5271, 0.16666666666667, 0.1, 0.22916666666667
5272, 0.14583333333333, 0.1, 0.29166666666667
5273, 0.16666666666667, 0.1, 0.27083333333333
5274, 0.14583333333333, 0.1, 0.33333333333333
5275, 0.16666666666667, 0.1, 0.3125
5276, 0.14583333333333, 0.1, 0.375
5277, 0.16666666666667, 0.1, 0.35416666666667
5278, 0.14583333333333, 0.1, 0.41666666666667
5279, 0.16666666666667, 0.1, 0.39583333333333
5280, 0.14583333333333, 0.1, 0.45833333333333
5281, 0.16666666666667, 0.1, 0.4375
5282, 0.16666666666667, 0.1, 0.47916666666667
5283, 0.1875, 0.1, 0.041666666666667
5284, 0.20833333333333, 0.1, 0.020833333333333
5285, 0.1875, 0.1, 0.083333333333333
5286, 0.20833333333333, 0.1, 0.0625
5287, 0.1875, 0.1, 0.125
5288, 0.20833333333333, 0.1, 0.10416666666667
5289, 0.1875, 0.1, 0.16666666666667
5290, 0.20833333333333, 0.1, 0.14583333333333
5291, 0.1875, 0.1, 0.20833333333333
5292, 0.20833333333333, 0.1, 0.1875
5293, 0.1875, 0.1, 0.25
5294, 0.20833333333333, 0.1, 0.22916666666667
5295, 0.1875, 0.1, 0.29166666666667
5296, 0.20833333333333, 0.1, 0.27083333333333
5297, 0.1875, 0.1, 0.33333333333333
5298, 0.20833333333333, 0.1, 0.3125
5299, 0.1875, 0.1, 0.375
5300, 0.20833333333333, 0.1, 0.35416666666667
5301, 0.1875, 0.1, 0.41666666666667
5302, 0.20833333333333, 0.1, 0.39583333333333
5303, 0.1875, 0.1, 0.45833333333333
5304, 0.20833333333333, 0.1, 0.4375
5305, 0.20833333333333, 0.1, 0.47916666666667
5306, 0.22916666666667, 0.1, 0.041666666666667
5307, 0.25, 0.1, 0.020833333333333
5308, 0.22916666666667, 0.1, 0.083333333333333
5309, 0.25, 0.1, 0.0625
5310, 0.22916666666667, 0.1, 0.125
5311, 0.25, 0.1, 0.10416666666667
5312, 0.22916666666667, 0.1, 0.16666666666667
5313, 0.25, 0.1, 0.14583333333333
5314, 0.22916666666667, 0.1, 0.20833333333333
5315, 0.25, 0.1, 0.1875
5316, 0.22916666666667, 0.1, 0.25
5317, 0.25, 0.1, 0.22916666666667
5318, 0.22916666666667, 0.1, 0.29166666666667
5319, 0.25, 0.1, 0.27083333333333
5320, 0.22916666666667, 0.1, 0.33333333333333
5321, 0.25, 0.1, 0.3125
5322, 0.22916666666667, 0.1, 0.375
5323, 0.25, 0.1, 0.35416666666667
5324, 0.22916666666667, 0.1, 0.41666666666667
5325, 0.25, 0.1, 0.39583333333333
5326, 0.22916666666667, 0.1, 0.45833333333333
5327, 0.25, 0.1, 0.4375
5328, 0.25, 0.1, 0.47916666666667
5329, 0.27083333333333, 0.1, 0.041666666666667
5330, 0.29166666666667, 0.1, 0.020833333333333
5331, 0.27083333333333, 0.1, 0.083333333333333
5332, 0.29166666666667, 0.1, 0.0625
5333, 0.27083333333333, 0.1, 0.125
5334, 0.29166666666667, 0.1, 0.10416666666667
5335, 0.27083333333333, 0.1, 0.16666666666667
5336, 0.29166666666667, 0.1, 0.14583333333333
5337, 0.27083333333333, 0.1, 0.20833333333333
5338, 0.29166666666667, 0.1, 0.1875
5339, 0.27083333333333, 0.1, 0.25
5340, 0.29166666666667, 0.1, 0.22916666666667
5341, 0.27083333333333, 0.1, 0.29166666666667
5342, 0.29166666666667, 0.1, 0.27083333333333
5343, 0.27083333333333, 0.1, 0.33333333333333
5344, 0.29166666666667, 0.1, 0.3125
5345, 0.27083333333333, 0.1, 0.375
5346, 0.29166666666667, 0.1, 0.35416666666667
5347, 0.27083333333333, 0.1, 0.41666666666667
5348, 0.29166666666667, 0.1, 0.39583333333333
5349, 0.27083333333333, 0.1, 0.45833333333333
5350, 0.29166666666667, 0.1, 0.4375
5351, 0.29166666666667, 0.1, 0.47916666666667
5352, 0.3125, 0.1, 0.041666666666667
5353, 0.33333333333333, 0.1, 0.020833333333333
5354, 0.3125, 0.1, 0.083333333333333
5355, 0.33333333333333, 0.1, 0.0625
5356, 0.3125, 0.1, 0.125
5357, 0.33333333333333, 0.1, 0.10416666666667
5358, 0.3125, 0.1, 0.16666666666667
5359, 0.33333333333333, 0.1, 0.14583333333333
5360, 0.3125, 0.1, 0.20833333333333
5361, 0.33333333333333, 0.1, 0.1875
5362, 0.3125, 0.1, 0.25
5363, 0.33333333333333, 0.1, 0.22916666666667
5364, 0.3125, 0.1, 0.29166666666667
5365, 0.33333333333333, 0.1, 0.27083333333333
5366, 0.3125, 0.1, 0.33333333333333
5367, 0.33333333333333, 0.1, 0.3125
5368, 0.3125, 0.1, 0.375
5369, 0.33333333333333, 0.1, 0.35416666666667
5370, 0.3125, 0.1, 0.41666666666667
5371, 0.33333333333333, 0.1, 0.39583333333333
5372, 0.3125, 0.1, 0.45833333333333
5373, 0.33333333333333, 0.1, 0.4375
5374, 0.33333333333333, 0.1, 0.47916666666667
5375, 0.35416666666667, 0.1, 0.041666666666667
5376, 0.375, 0.1, 0.020833333333333
5377, 0.35416666666667, 0.1, 0.083333333333333
5378, 0.375, 0.1, 0.0625
5379, 0.35416666666667, 0.1, 0.125
5380, 0.375, 0.1, 0.10416666666667
5381, 0.35416666666667, 0.1, 0.16666666666667
5382, 0.375, 0.1, 0.14583333333333
5383, 0.35416666666667, 0.1, 0.20833333333333
5384, 0.375, 0.1, 0.1875
5385, 0.35416666666667, 0.1, 0.25
5386, 0.375, 0.1, 0.22916666666667
5387, 0.35416666666667, 0.1, 0.29166666666667
5388, 0.375, 0.1, 0.27083333333333
5389, 0.35416666666667, 0.1, 0.33333333333333
5390, 0.375, 0.1, 0.3125
5391, 0.35416666666667, 0.1, 0.375
5392, 0.375, 0.1, 0.35416666666667
5393, 0.35416666666667, 0.1, 0.41666666666667
5394, 0.375, 0.1, 0.39583333333333
5395, 0.35416666666667, 0.1, 0.45833333333333
5396, 0.375, 0.1, 0.4375
5397, 0.375, 0.1, 0.47916666666667
5398, 0.39583333333333, 0.1, 0.041666666666667
5399, 0.41666666666667, 0.1, 0.020833333333333
5400, 0.39583333333333, 0.1, 0.083333333333333
5401, 0.41666666666667, 0.1, 0.0625
5402, 0.39583333333333, 0.1, 0.125
5403, 0.41666666666667, 0.1, 0.10416666666667
5404, 0.39583333333333, 0.1, 0.16666666666667
5405, 0.41666666666667, 0.1, 0.14583333333333
5406, 0.39583333333333, 0.1, 0.20833333333333
5407, 0.41666666666667, 0.1, 0.1875
5408, 0.39583333333333, 0.1, 0.25
5409, 0.41666666666667, 0.1, 0.22916666666667
5410, 0.39583333333333, 0.1, 0.29166666666667
5411, 0.41666666666667, 0.1, 0.27083333333333
5412, 0.39583333333333, 0.1, 0.33333333333333
5413, 0.41666666666667, 0.1, 0.3125
5414, 0.39583333333333, 0.1, 0.375
5415, 0.41666666666667, 0.1, 0.35416666666667
5416, 0.39583333333333, 0.1, 0.41666666666667
5417, 0.41666666666667, 0.1, 0.39583333333333
5418, 0.39583333333333, 0.1, 0.45833333333333
5419, 0.41666666666667, 0.1, 0.4375
5420, 0.41666666666667, 0.1, 0.47916666666667
5421, 0.4375, 0.1, 0.041666666666667
5422, 0.45833333333333, 0.1, 0.020833333333333
5423, 0.4375, 0.1, 0.083333333333333
5424, 0.45833333333333, 0.1, 0.0625
5425, 0.4375, 0.1, 0.125
5426, 0.45833333333333, 0.1, 0.10416666666667
5427, 0.4375, 0.1, 0.16666666666667
5428, 0.45833333333333, 0.1, 0.14583333333333
5429, 0.4375, 0.1, 0.20833333333333
5430, 0.45833333333333, 0.1, 0.1875
5431, 0.4375, 0.1, 0.25
5432, 0.45833333333333, 0.1, 0.22916666666667
5433, 0.4375, 0.1, 0.29166666666667
5434, 0.45833333333333, 0.1, 0.27083333333333
5435, 0.4375, 0.1, 0.33333333333333
5436, 0.45833333333333, 0.1, 0.3125
5437, 0.4375, 0.1, 0.375
5438, 0.45833333333333, 0.1, 0.35416666666667
5439, 0.4375, 0.1, 0.41666666666667
5440, 0.45833333333333, 0.1, 0.39583333333333
5441, 0.4375, 0.1, 0.45833333333333
5442, 0.45833333333333, 0.1, 0.4375
5443, 0.45833333333333, 0.1, 0.47916666666667
5444, 0.47916666666667, 0.1, 0.041666666666667
5445, 0.5, 0.1, 0.020833333333333
5446, 0.47916666666667, 0.1, 0.083333333333333
5447, 0.5, 0.1, 0.0625
5448, 0.47916666666667, 0.1, 0.125
5449, 0.5, 0.1, 0.10416666666667
5450, 0.47916666666667, 0.1, 0.16666666666667
5451, 0.5, 0.1, 0.14583333333333
5452, 0.47916666666667, 0.1, 0.20833333333333
5453, 0.5, 0.1, 0.1875
5454, 0.47916666666667, 0.1, 0.25
5455, 0.5, 0.1, 0.22916666666667
5456, 0.47916666666667, 0.1, 0.29166666666667
5457, 0.5, 0.1, 0.27083333333333
5458, 0.47916666666667, 0.1, 0.33333333333333
5459, 0.5, 0.1, 0.3125
5460, 0.47916666666667, 0.1, 0.375
5461, 0.5, 0.1, 0.35416666666667
5462, 0.47916666666667, 0.1, 0.41666666666667
5463, 0.5, 0.1, 0.39583333333333
5464, 0.47916666666667, 0.1, 0.45833333333333
5465, 0.5, 0.1, 0.4375
5466, 0.5, 0.1, 0.47916666666667
5467, 0.52083333333333, 0.1, 0.041666666666667
5468, 0.54166666666667, 0.1, 0.020833333333333
5469, 0.52083333333333, 0.1, 0.083333333333333
5470, 0.54166666666667, 0.1, 0.0625
5471, 0.52083333333333, 0.1, 0.125
5472, 0.54166666666667, 0.1, 0.10416666666667
5473, 0.52083333333333, 0.1, 0.16666666666667
5474, 0.54166666666667, 0.1, 0.14583333333333
5475, 0.52083333333333, 0.1, 0.20833333333333
5476, 0.54166666666667, 0.1, 0.1875
5477, 0.52083333333333, 0.1, 0.25
5478, 0.54166666666667, 0.1, 0.22916666666667
5479, 0.52083333333333, 0.1, 0.29166666666667
5480, 0.54166666666667, 0.1, 0.27083333333333
5481, 0.52083333333333, 0.1, 0.33333333333333
5482, 0.54166666666667, 0.1, 0.3125
5483, 0.52083333333333, 0.1, 0.375
5484, 0.54166666666667, 0.1, 0.35416666666667
5485, 0.52083333333333, 0.1, 0.41666666666667
5486, 0.54166666666667, 0.1, 0.39583333333333
5487, 0.52083333333333, 0.1, 0.45833333333333
5488, 0.54166666666667, 0.1, 0.4375
5489, 0.54166666666667, 0.1, 0.47916666666667
5490, 0.5625, 0.1, 0.041666666666667
5491, 0.58333333333333, 0.1, 0.020833333333333
5492, 0.5625, 0.1, 0.083333333333333
5493, 0.58333333333333, 0.1, 0.0625
5494, 0.5625, 0.1, 0.125
5495, 0.58333333333333, 0.1, 0.10416666666667
5496, 0.5625, 0.1, 0.16666666666667
5497, 0.58333333333333, 0.1, 0.14583333333333
5498, 0.5625, 0.1, 0.20833333333333
5499, 0.58333333333333, 0.1, 0.1875
5500, 0.5625, 0.1, 0.25
5501, 0.58333333333333, 0.1, 0.22916666666667
5502, 0.5625, 0.1, 0.29166666666667
5503, 0.58333333333333, 0.1, 0.27083333333333
5504, 0.5625, 0.1, 0.33333333333333
5505, 0.58333333333333, 0.1, 0.3125
5506, 0.5625, 0.1, 0.375
5507, 0.58333333333333, 0.1, 0.35416666666667
5508, 0.5625, 0.1, 0.41666666666667
5509, 0.58333333333333, 0.1, 0.39583333333333
5510, 0.5625, 0.1, 0.45833333333333
5511, 0.58333333333333, 0.1, 0.4375
5512, 0.58333333333333, 0.1, 0.47916666666667
5513, 0.60416666666667, 0.1, 0.041666666666667
5514, 0.625, 0.1, 0.020833333333333
5515, 0.60416666666667, 0.1, 0.083333333333333
5516, 0.625, 0.1, 0.0625
5517, 0.60416666666667, 0.1, 0.125
5518, 0.625, 0.1, 0.10416666666667
5519, 0.60416666666667, 0.1, 0.16666666666667
5520, 0.625, 0.1, 0.14583333333333
5521, 0.60416666666667, 0.1, 0.20833333333333
5522, 0.625, 0.1, 0.1875
5523, 0.60416666666667, 0.1, 0.25
5524, 0.625, 0.1, 0.22916666666667
5525, 0.60416666666667, 0.1, 0.29166666666667
5526, 0.625, 0.1, 0.27083333333333
5527, 0.60416666666667, 0.1, 0.33333333333333
5528, 0.625, 0.1, 0.3125
5529, 0.60416666666667, 0.1, 0.375
5530, 0.625, 0.1, 0.35416666666667
5531, 0.60416666666667, 0.1, 0.41666666666667
5532, 0.625, 0.1, 0.39583333333333
5533, 0.60416666666667, 0.1, 0.45833333333333
5534, 0.625, 0.1, 0.4375
5535, 0.625, 0.1, 0.47916666666667
5536, 0.64583333333333, 0.1, 0.041666666666667
5537, 0.66666666666667, 0.1, 0.020833333333333
5538, 0.64583333333333, 0.1, 0.083333333333333
5539, 0.66666666666667, 0.1, 0.0625
5540, 0.64583333333333, 0.1, 0.125
5541, 0.66666666666667, 0.1, 0.10416666666667
5542, 0.64583333333333, 0.1, 0.16666666666667
5543, 0.66666666666667, 0.1, 0.14583333333333
5544, 0.64583333333333, 0.1, 0.20833333333333
5545, 0.66666666666667, 0.1, 0.1875
5546, 0.64583333333333, 0.1, 0.25
5547, 0.66666666666667, 0.1, 0.22916666666667
5548, 0.64583333333333, 0.1, 0.29166666666667
5549, 0.66666666666667, 0.1, 0.27083333333333
5550, 0.64583333333333, 0.1, 0.33333333333333
5551, 0.66666666666667, 0.1, 0.3125
5552, 0.64583333333333, 0.1, 0.375
5553, 0.66666666666667, 0.1, 0.35416666666667
5554, 0.64583333333333, 0.1, 0.41666666666667
5555, 0.66666666666667, 0.1, 0.39583333333333
5556, 0.64583333333333, 0.1, 0.45833333333333
5557, 0.66666666666667, 0.1, 0.4375
5558, 0.66666666666667, 0.1, 0.47916666666667
5559, 0.6875, 0.1, 0.041666666666667
5560, 0.70833333333333, 0.1, 0.020833333333333
5561, 0.6875, 0.1, 0.083333333333333
5562, 0.70833333333333, 0.1, 0.0625
5563, 0.6875, 0.1, 0.125
5564, 0.70833333333333, 0.1, 0.10416666666667
5565, 0.6875, 0.1, 0.16666666666667
5566, 0.70833333333333, 0.1, 0.14583333333333
5567, 0.6875, 0.1, 0.20833333333333
5568, 0.70833333333333, 0.1, 0.1875
5569, 0.6875, 0.1, 0.25
5570, 0.70833333333333, 0.1, 0.22916666666667
5571, 0.6875, 0.1, 0.29166666666667
5572, 0.70833333333333, 0.1, 0.27083333333333
5573, 0.6875, 0.1, 0.33333333333333
5574, 0.70833333333333, 0.1, 0.3125
5575, 0.6875, 0.1, 0.375
5576, 0.70833333333333, 0.1, 0.35416666666667
5577, 0.6875, 0.1, 0.41666666666667
5578, 0.70833333333333, 0.1, 0.39583333333333
5579, 0.6875, 0.1, 0.45833333333333
5580, 0.70833333333333, 0.1, 0.4375
5581, 0.70833333333333, 0.1, 0.47916666666667
5582, 0.72916666666667, 0.1, 0.041666666666667
5583, 0.75, 0.1, 0.020833333333333
5584, 0.72916666666667, 0.1, 0.083333333333333
5585, 0.75, 0.1, 0.0625
5586, 0.72916666666667, 0.1, 0.125
5587, 0.75, 0.1, 0.10416666666667
5588, 0.72916666666667, 0.1, 0.16666666666667
5589, 0.75, 0.1, 0.14583333333333
5590, 0.72916666666667, 0.1, 0.20833333333333
5591, 0.75, 0.1, 0.1875
5592, 0.72916666666667, 0.1, 0.25
5593, 0.75, 0.1, 0.22916666666667
5594, 0.72916666666667, 0.1, 0.29166666666667
5595, 0.75, 0.1, 0.27083333333333
5596, 0.72916666666667, 0.1, 0.33333333333333
5597, 0.75, 0.1, 0.3125
5598, 0.72916666666667, 0.1, 0.375
5599, 0.75, 0.1, 0.35416666666667
5600, 0.72916666666667, 0.1, 0.41666666666667
5601, 0.75, 0.1, 0.39583333333333
5602, 0.72916666666667, 0.1, 0.45833333333333
5603, 0.75, 0.1, 0.4375
5604, 0.75, 0.1, 0.47916666666667
5605, 0.77083333333333, 0.1, 0.041666666666667
5606, 0.79166666666667, 0.1, 0.020833333333333
5607, 0.77083333333333, 0.1, 0.083333333333333
5608, 0.79166666666667, 0.1, 0.0625
5609, 0.77083333333333, 0.1, 0.125
5610, 0.79166666666667, 0.1, 0.10416666666667
5611, 0.77083333333333, 0.1, 0.16666666666667
5612, 0.79166666666667, 0.1, 0.14583333333333
5613, 0.77083333333333, 0.1, 0.20833333333333
5614, 0.79166666666667, 0.1, 0.1875
5615, 0.77083333333333, 0.1, 0.25
5616, 0.79166666666667, 0.1, 0.22916666666667
5617, 0.77083333333333, 0.1, 0.29166666666667
5618, 0.79166666666667, 0.1, 0.27083333333333
5619, 0.77083333333333, 0.1, 0.33333333333333
5620, 0.79166666666667, 0.1, 0.3125
5621, 0.77083333333333, 0.1, 0.375
5622, 0.79166666666667, 0.1, 0.35416666666667
5623, 0.77083333333333, 0.1, 0.41666666666667
5624, 0.79166666666667, 0.1, 0.39583333333333
5625, 0.77083333333333, 0.1, 0.45833333333333
5626, 0.79166666666667, 0.1, 0.4375
5627, 0.79166666666667, 0.1, 0.47916666666667
5628, 0.8125, 0.1, 0.041666666666667
5629, 0.83333333333333, 0.1, 0.020833333333333
5630, 0.8125, 0.1, 0.083333333333333
5631, 0.83333333333333, 0.1, 0.0625
5632, 0.8125, 0.1, 0.125
5633, 0.83333333333333, 0.1, 0.10416666666667
5634, 0.8125, 0.1, 0.16666666666667
5635, 0.83333333333333, 0.1, 0.14583333333333
5636, 0.8125, 0.1, 0.20833333333333
5637, 0.83333333333333, 0.1, 0.1875
5638, 0.8125, 0.1, 0.25
5639, 0.83333333333333, 0.1, 0.22916666666667
5640, 0.8125, 0.1, 0.29166666666667
5641, 0.83333333333333, 0.1, 0.27083333333333
5642, 0.8125, 0.1, 0.33333333333333
5643, 0.83333333333333, 0.1, 0.3125
5644, 0.8125, 0.1, 0.375
5645, 0.83333333333333, 0.1, 0.35416666666667
5646, 0.8125, 0.1, 0.41666666666667
5647, 0.83333333333333, 0.1, 0.39583333333333
5648, 0.8125, 0.1, 0.45833333333333
5649, 0.83333333333333, 0.1, 0.4375
5650, 0.83333333333333, 0.1, 0.47916666666667
5651, 0.85416666666667, 0.1, 0.041666666666667
5652, 0.875, 0.1, 0.020833333333333
5653, 0.85416666666667, 0.1, 0.083333333333333
5654, 0.875, 0.1, 0.0625
5655, 0.85416666666667, 0.1, 0.125
5656, 0.875, 0.1, 0.10416666666667
5657, 0.85416666666667, 0.1, 0.16666666666667
5658, 0.875, 0.1, 0.14583333333333
5659, 0.85416666666667, 0.1, 0.20833333333333
5660, 0.875, 0.1, 0.1875
5661, 0.85416666666667, 0.1, 0.25
5662, 0.875, 0.1, 0.22916666666667
5663, 0.85416666666667, 0.1, 0.29166666666667
5664, 0.875, 0.1, 0.27083333333333
5665, 0.85416666666667, 0.1, 0.33333333333333
5666, 0.875, 0.1, 0.3125
5667, 0.85416666666667, 0.1, 0.375
5668, 0.875, 0.1, 0.35416666666667
5669, 0.85416666666667, 0.1, 0.41666666666667
5670, 0.875, 0.1, 0.39583333333333
5671, 0.85416666666667, 0.1, 0.45833333333333
5672, 0.875, 0.1, 0.4375
5673, 0.875, 0.1, 0.47916666666667
5674, 0.89583333333333, 0.1, 0.041666666666667
5675, 0.91666666666667, 0.1, 0.020833333333333
5676, 0.89583333333333, 0.1, 0.083333333333333
5677, 0.91666666666667, 0.1, 0.0625
5678, 0.89583333333333, 0.1, 0.125
5679, 0.91666666666667, 0.1, 0.10416666666667
5680, 0.89583333333333, 0.1, 0.16666666666667
5681, 0.91666666666667, 0.1, 0.14583333333333
5682, 0.89583333333333, 0.1, 0.20833333333333
5683, 0.91666666666667, 0.1, 0.1875
5684, 0.89583333333333, 0.1, 0.25
5685, 0.91666666666667, 0.1, 0.22916666666667
5686, 0.89583333333333, 0.1, 0.29166666666667
5687, 0.91666666666667, 0.1, 0.27083333333333
5688, 0.89583333333333, 0.1, 0.33333333333333
5689, 0.91666666666667, 0.1, 0.3125
5690, 0.89583333333333, 0.1, 0.375
5691, 0.91666666666667, 0.1, 0.35416666666667
5692, 0.89583333333333, 0.1, 0.41666666666667
5693, 0.91666666666667, 0.1, 0.39583333333333
5694, 0.89583333333333, 0.1, 0.45833333333333
5695, 0.91666666666667, 0.1, 0.4375
5696, 0.91666666666667, 0.1, 0.47916666666667
5697, 0.9375, 0.1, 0.041666666666667
5698, 0.95833333333333, 0.1, 0.020833333333333
5699, 0.9375, 0.1, 0.083333333333333
5700, 0.95833333333333, 0.1, 0.0625
5701, 0.9375, 0.1, 0.125
5702, 0.95833333333333, 0.1, 0.10416666666667
5703, 0.9375, 0.1, 0.16666666666667
5704, 0.95833333333333, 0.1, 0.14583333333333
5705, 0.9375, 0.1, 0.20833333333333
5706, 0.95833333333333, 0.1, 0.1875
5707, 0.9375, 0.1, 0.25
5708, 0.95833333333333, 0.1, 0.22916666666667
5709, 0.9375, 0.1, 0.29166666666667
5710, 0.95833333333333, 0.1, 0.27083333333333
5711, 0.9375, 0.1, 0.33333333333333
5712, 0.95833333333333, 0.1, 0.3125
5713, 0.9375, 0.1, 0.375
5714, 0.95833333333333, 0.1, 0.35416666666667
5715, 0.9375, 0.1, 0.41666666666667
5716, 0.95833333333333, 0.1, 0.39583333333333
5717, 0.9375, 0.1, 0.45833333333333
5718, 0.95833333333333, 0.1, 0.4375
5719, 0.95833333333333, 0.1, 0.47916666666667
5720, 0.97916666666667, 0.1, 0.041666666666667
5721, 0.97916666666667, 0.1, 0.083333333333333
5722, 0.97916666666667, 0.1, 0.125
5723, 0.97916666666667, 0.1, 0.16666666666667
5724, 0.97916666666667, 0.1, 0.20833333333333
5725, 0.97916666666667, 0.1, 0.25
5726, 0.97916666666667, 0.1, 0.29166666666667
5727, 0.97916666666667, 0.1, 0.33333333333333
5728, 0.97916666666667, 0.1, 0.375
5729, 0.97916666666667, 0.1, 0.41666666666667
5730, 0.97916666666667, 0.1, 0.45833333333333
5731, 0.041666666666667, 0.033333333333333, 0
5732, 0.083333333333333, 0.033333333333333, 0
5733, 0.125, 0.033333333333333, 0
5734, 0.16666666666667, 0.033333333333333, 0
5735, 0.20833333333333, 0.033333333333333, 0
5736, 0.25, 0.033333333333333, 0
5737, 0.29166666666667, 0.033333333333333, 0
5738, 0.33333333333333, 0.033333333333333, 0
5739, 0.375, 0.033333333333333, 0
5740, 0.41666666666667, 0.033333333333333, 0
5741, 0.45833333333333, 0.033333333333333, 0
5742, 0.5, 0.033333333333333, 0
5743, 0.54166666666667, 0.033333333333333, 0
5744, 0.58333333333333, 0.033333333333333, 0
5745, 0.625, 0.033333333333333, 0
5746, 0.66666666666667, 0.033333333333333, 0
5747, 0.70833333333333, 0.033333333333333, 0
5748, 0.75, 0.033333333333333, 0
5749, 0.79166666666667, 0.033333333333333, 0
5750, 0.83333333333333, 0.033333333333333, 0
5751, 0.875, 0.033333333333333, 0
5752, 0.91666666666667, 0.033333333333333, 0
5753, 0.95833333333333, 0.033333333333333, 0
5754, 0.041666666666667, 0.066666666666667, 0
5755, 0.083333333333333, 0.066666666666667, 0
5756, 0.125, 0.066666666666667, 0
5757, 0.16666666666667, 0.066666666666667, 0
5758, 0.20833333333333, 0.066666666666667, 0
5759, 0.25, 0.066666666666667, 0
5760, 0.29166666666667, 0.066666666666667, 0
5761, 0.33333333333333, 0.066666666666667, 0
5762, 0.375, 0.066666666666667, 0
5763, 0.41666666666667, 0.066666666666667, 0
5764, 0.45833333333333, 0.066666666666667, 0
5765, 0.5, 0.066666666666667, 0
5766, 0.54166666666667, 0.066666666666667, 0
5767, 0.58333333333333, 0.066666666666667, 0
5768, 0.625, 0.066666666666667, 0
5769, 0.66666666666667, 0.066666666666667, 0
5770, 0.70833333333333, 0.066666666666667, 0
5771, 0.75, 0.066666666666667, 0
5772, 0.79166666666667, 0.066666666666667, 0
5773, 0.83333333333333, 0.066666666666667, 0
5774, 0.875, 0.066666666666667, 0
5775, 0.91666666666667, 0.066666666666667, 0
5776, 0.95833333333333, 0.066666666666667, 0
5777, 0.020833333333333, 0.033333333333333, 0
5778, 0.041666666666667, 0.016666666666667, 0
5779, 0.0625, 0.033333333333333, 0
5780, 0.083333333333333, 0.016666666666667, 0
5781, 0.10416666666667, 0.033333333333333, 0
5782, 0.125, 0.016666666666667, 0
5783, 0.14583333333333, 0.033333333333333, 0
5784, 0.16666666666667, 0.016666666666667, 0
5785, 0.1875, 0.033333333333333, 0
5786, 0.20833333333333, 0.016666666666667, 0
5787, 0.22916666666667, 0.033333333333333, 0
5788, 0.25, 0.016666666666667, 0
5789, 0.27083333333333, 0.033333333333333, 0
5790, 0.29166666666667, 0.016666666666667, 0
5791, 0.3125, 0.033333333333333, 0
5792, 0.33333333333333, 0.016666666666667, 0
5793, 0.35416666666667, 0.033333333333333, 0
5794, 0.375, 0.016666666666667, 0
5795, 0.39583333333333, 0.033333333333333, 0
5796, 0.41666666666667, 0.016666666666667, 0
5797, 0.4375, 0.033333333333333, 0
5798, 0.45833333333333, 0.016666666666667, 0
5799, 0.47916666666667, 0.033333333333333, 0
5800, 0.5, 0.016666666666667, 0
5801, 0.52083333333333, 0.033333333333333, 0
5802, 0.54166666666667, 0.016666666666667, 0
5803, 0.5625, 0.033333333333333, 0
5804, 0.58333333333333, 0.016666666666667, 0
5805, 0.60416666666667, 0.033333333333333, 0
5806, 0.625, 0.016666666666667, 0
5807, 0.64583333333333, 0.033333333333333, 0
5808, 0.66666666666667, 0.016666666666667, 0
5809, 0.6875, 0.033333333333333, 0
5810, 0.70833333333333, 0.016666666666667, 0
5811, 0.72916666666667, 0.033333333333333, 0
5812, 0.75, 0.016666666666667, 0
5813, 0.77083333333333, 0.033333333333333, 0
5814, 0.79166666666667, 0.016666666666667, 0
5815, 0.8125, 0.033333333333333, 0
5816, 0.83333333333333, 0.016666666666667, 0
5817, 0.85416666666667, 0.033333333333333, 0
5818, 0.875, 0.016666666666667, 0
5819, 0.89583333333333, 0.033333333333333, 0
5820, 0.91666666666667, 0.016666666666667, 0
5821, 0.9375, 0.033333333333333, 0
5822, 0.95833333333333, 0.016666666666667, 0
5823, 0.97916666666667, 0.033333333333333, 0
5824, 0.020833333333333, 0.066666666666667, 0
5825, 0.041666666666667, 0.05, 0
5826, 0.0625, 0.066666666666667, 0
5827, 0.083333333333333, 0.05, 0
5828, 0.10416666666667, 0.066666666666667, 0
5829, 0.125, 0.05, 0
5830, 0.14583333333333, 0.066666666666667, 0
5831, 0.16666666666667, 0.05, 0
5832, 0.1875, 0.066666666666667, 0
5833, 0.20833333333333, 0.05, 0
5834, 0.22916666666667, 0.066666666666667, 0
5835, 0.25, 0.05, 0
5836, 0.27083333333333, 0.066666666666667, 0
5837, 0.29166666666667, 0.05, 0
5838, 0.3125, 0.066666666666667, 0
5839, 0.33333333333333, 0.05, 0
5840, 0.35416666666667, 0.066666666666667, 0
5841, 0.375, 0.05, 0
5842, 0.39583333333333, 0.066666666666667, 0
5843, 0.41666666666667, 0.05, 0
5844, 0.4375, 0.066666666666667, 0
5845, 0.45833333333333, 0.05, 0
5846, 0.47916666666667, 0.066666666666667, 0
5847, 0.5, 0.05, 0
5848, 0.52083333333333, 0.066666666666667, 0
5849, 0.54166666666667, 0.05, 0
5850, 0.5625, 0.066666666666667, 0
5851, 0.58333333333333, 0.05, 0
5852, 0.60416666666667, 0.066666666666667, 0
5853, 0.625, 0.05, 0
5854, 0.64583333333333, 0.066666666666667, 0
5855, 0.66666666666667, 0.05, 0
5856, 0.6875, 0.066666666666667, 0
5857, 0.70833333333333, 0.05, 0
5858, 0.72916666666667, 0.066666666666667, 0
5859, 0.75, 0.05, 0
5860, 0.77083333333333, 0.066666666666667, 0
5861, 0.79166666666667, 0.05, 0
5862, 0.8125, 0.066666666666667, 0
5863, 0.83333333333333, 0.05, 0
5864, 0.85416666666667, 0.066666666666667, 0
5865, 0.875, 0.05, 0
5866, 0.89583333333333, 0.066666666666667, 0
5867, 0.91666666666667, 0.05, 0
5868, 0.9375, 0.066666666666667, 0
5869, 0.95833333333333, 0.05, 0
5870, 0.97916666666667, 0.066666666666667, 0
5871, 0.041666666666667, 0.083333333333333, 0
5872, 0.083333333333333, 0.083333333333333, 0
5873, 0.125, 0.083333333333333, 0
5874, 0.16666666666667, 0.083333333333333, 0
5875, 0.20833333333333, 0.083333333333333, 0
5876, 0.25, 0.083333333333333, 0
5877, 0.29166666666667, 0.083333333333333, 0
5878, 0.33333333333333, 0.083333333333333, 0
5879, 0.375, 0.083333333333333, 0
5880, 0.41666666666667, 0.083333333333333, 0
5881, 0.45833333333333, 0.083333333333333, 0
5882, 0.5, 0.083333333333333, 0
5883, 0.54166666666667, 0.083333333333333, 0
5884, 0.58333333333333, 0.083333333333333, 0
5885, 0.625, 0.083333333333333, 0
5886, 0.66666666666667, 0.083333333333333, 0
5887, 0.70833333333333, 0.083333333333333, 0
5888, 0.75, 0.083333333333333, 0
5889, 0.79166666666667, 0.083333333333333, 0
5890, 0.83333333333333, 0.083333333333333, 0
5891, 0.875, 0.083333333333333, 0
5892, 0.91666666666667, 0.083333333333333, 0
5893, 0.95833333333333, 0.083333333333333, 0
5894, 0.041666666666667, 0.033333333333333, 0.5
5895, 0.083333333333333, 0.033333333333333, 0.5
5896, 0.125, 0.033333333333333, 0.5
5897, 0.16666666666667, 0.033333333333333, 0.5
5898, 0.20833333333333, 0.033333333333333, 0.5
5899, 0.25, 0.033333333333333, 0.5
5900, 0.29166666666667, 0.033333333333333, 0.5
5901, 0.33333333333333, 0.033333333333333, 0.5
5902, 0.375, 0.033333333333333, 0.5
5903, 0.41666666666667, 0.033333333333333, 0.5
5904, 0.45833333333333, 0.033333333333333, 0.5
5905, 0.5, 0.033333333333333, 0.5
5906, 0.54166666666667, 0.033333333333333, 0.5
5907, 0.58333333333333, 0.033333333333333, 0.5
5908, 0.625, 0.033333333333333, 0.5
5909, 0.66666666666667, 0.033333333333333, 0.5
5910, 0.70833333333333, 0.033333333333333, 0.5
5911, 0.75, 0.033333333333333, 0.5
5912, 0.79166666666667, 0.033333333333333, 0.5
5913, 0.83333333333333, 0.033333333333333, 0.5
5914, 0.875, 0.033333333333333, 0.5
5915, 0.91666666666667, 0.033333333333333, 0.5
5916, 0.95833333333333, 0.033333333333333, 0.5
5917, 0.041666666666667, 0.066666666666667, 0.5
5918, 0.083333333333333, 0.066666666666667, 0.5
5919, 0.125, 0.066666666666667, 0.5
5920, 0.16666666666667, 0.066666666666667, 0.5
5921, 0.20833333333333, 0.066666666666667, 0.5
5922, 0.25, 0.066666666666667, 0.5
5923, 0.29166666666667, 0.066666666666667, 0.5
5924, 0.33333333333333, 0.066666666666667, 0.5
5925, 0.375, 0.066666666666667, 0.5
5926, 0.41666666666667, 0.066666666666667, 0.5
5927, 0.45833333333333, 0.066666666666667, 0.5
5928, 0.5, 0.066666666666667, 0.5
5929, 0.54166666666667, 0.066666666666667, 0.5
5930, 0.58333333333333, 0.066666666666667, 0.5
5931, 0.625, 0.066666666666667, 0.5
5932, 0.66666666666667, 0.066666666666667, 0.5
5933, 0.70833333333333, 0.066666666666667, 0.5
5934, 0.75, 0.066666666666667, 0.5
5935, 0.79166666666667, 0.066666666666667, 0.5
5936, 0.83333333333333, 0.066666666666667, 0.5
5937, 0.875, 0.066666666666667, 0.5
5938, 0.91666666666667, 0.066666666666667, 0.5
5939, 0.95833333333333, 0.066666666666667, 0.5
5940, 0.041666666666667, 0.016666666666667, 0.5
5941, 0.020833333333333, 0.033333333333333, 0.5
5942, 0.083333333333333, 0.016666666666667, 0.5
5943, 0.0625, 0.033333333333333, 0.5
5944, 0.125, 0.016666666666667, 0.5
5945, 0.10416666666667, 0.033333333333333, 0.5
5946, 0.16666666666667, 0.016666666666667, 0.5
5947, 0.14583333333333, 0.033333333333333, 0.5
5948, 0.20833333333333, 0.016666666666667, 0.5
5949, 0.1875, 0.033333333333333, 0.5
5950, 0.25, 0.016666666666667, 0.5
5951, 0.22916666666667, 0.033333333333333, 0.5
5952, 0.29166666666667, 0.016666666666667, 0.5
5953, 0.27083333333333, 0.033333333333333, 0.5
5954, 0.33333333333333, 0.016666666666667, 0.5
5955, 0.3125, 0.033333333333333, 0.5
5956, 0.375, 0.016666666666667, 0.5
5957, 0.35416666666667, 0.033333333333333, 0.5
5958, 0.41666666666667, 0.016666666666667, 0.5
5959, 0.39583333333333, 0.033333333333333, 0.5
5960, 0.45833333333333, 0.016666666666667, 0.5
5961, 0.4375, 0.033333333333333, 0.5
5962, 0.5, 0.016666666666667, 0.5
5963, 0.47916666666667, 0.033333333333333, 0.5
5964, 0.54166666666667, 0.016666666666667, 0.5
5965, 0.52083333333333, 0.033333333333333, 0.5
5966, 0.58333333333333, 0.016666666666667, 0.5
5967, 0.5625, 0.033333333333333, 0.5
5968, 0.625, 0.016666666666667, 0.5
5969, 0.60416666666667, 0.033333333333333, 0.5
5970, 0.66666666666667, 0.016666666666667, 0.5
5971, 0.64583333333333, 0.033333333333333, 0.5
5972, 0.70833333333333, 0.016666666666667, 0.5
5973, 0.6875, 0.033333333333333, 0.5
5974, 0.75, 0.016666666666667, 0.5
5975, 0.72916666666667, 0.033333333333333, 0.5
5976, 0.79166666666667, 0.016666666666667, 0.5
5977, 0.77083333333333, 0.033333333333333, 0.5
5978, 0.83333333333333, 0.016666666666667, 0.5
5979, 0.8125, 0.033333333333333, 0.5
5980, 0.875, 0.016666666666667, 0.5
5981, 0.85416666666667, 0.033333333333333, 0.5
5982, 0.91666666666667, 0.016666666666667, 0.5
5983, 0.89583333333333, 0.033333333333333, 0.5
5984, 0.95833333333333, 0.016666666666667, 0.5
5985, 0.9375, 0.033333333333333, 0.5
5986, 0.97916666666667, 0.033333333333333, 0.5
5987, 0.041666666666667, 0.05, 0.5
5988, 0.020833333333333, 0.066666666666667, 0.5
5989, 0.083333333333333, 0.05, 0.5
5990, 0.0625, 0.066666666666667, 0.5
5991, 0.125, 0.05, 0.5
5992, 0.10416666666667, 0.066666666666667, 0.5
5993, 0.16666666666667, 0.05, 0.5
5994, 0.14583333333333, 0.066666666666667, 0.5
5995, 0.20833333333333, 0.05, 0.5
5996, 0.1875, 0.066666666666667, 0.5
5997, 0.25, 0.05, 0.5
5998, 0.22916666666667, 0.066666666666667, 0.5
5999, 0.29166666666667, 0.05, 0.5
6000, 0.27083333333333, 0.066666666666667, 0.5
6001, 0.33333333333333, 0.05, 0.5
6002, 0.3125, 0.066666666666667, 0.5
6003, 0.375, 0.05, 0.5
6004, 0.35416666666667, 0.066666666666667, 0.5
6005, 0.41666666666667, 0.05, 0.5
6006, 0.39583333333333, 0.066666666666667, 0.5
6007, 0.45833333333333, 0.05, 0.5
6008, 0.4375, 0.066666666666667, 0.5
6009, 0.5, 0.05, 0.5
6010, 0.47916666666667, 0.066666666666667, 0.5
6011, 0.54166666666667, 0.05, 0.5
6012, 0.52083333333333, 0.066666666666667, 0.5
6013, 0.58333333333333, 0.05, 0.5
6014, 0.5625, 0.066666666666667, 0.5
6015, 0.625, 0.05, 0.5
6016, 0.60416666666667, 0.066666666666667, 0.5
6017, 0.66666666666667, 0.05, 0.5
6018, 0.64583333333333, 0.066666666666667, 0.5
6019, 0.70833333333333, 0.05, 0.5
6020, 0.6875, 0.066666666666667, 0.5
6021, 0.75, 0.05, 0.5
6022, 0.72916666666667, 0.066666666666667, 0.5
6023, 0.79166666666667, 0.05, 0.5
6024, 0.77083333333333, 0.066666666666667, 0.5
6025, 0.83333333333333, 0.05, 0.5
6026, 0.8125, 0.066666666666667, 0.5
6027, 0.875, 0.05, 0.5
6028, 0.85416666666667, 0.066666666666667, 0.5
6029, 0.91666666666667, 0.05, 0.5
6030, 0.89583333333333, 0.066666666666667, 0.5
6031, 0.95833333333333, 0.05, 0.5
6032, 0.9375, 0.066666666666667, 0.5
6033, 0.97916666666667, 0.066666666666667, 0.5
6034, 0.041666666666667, 0.083333333333333, 0.5
6035, 0.083333333333333, 0.083333333333333, 0.5
6036, 0.125, 0.083333333333333, 0.5
6037, 0.16666666666667, 0.083333333333333, 0.5
6038, 0.20833333333333, 0.083333333333333, 0.5
6039, 0.25, 0.083333333333333, 0.5
6040, 0.29166666666667, 0.083333333333333, 0.5
6041, 0.33333333333333, 0.083333333333333, 0.5
6042, 0.375, 0.083333333333333, 0.5
6043, 0.41666666666667, 0.083333333333333, 0.5
6044, 0.45833333333333, 0.083333333333333, 0.5
6045, 0.5, 0.083333333333333, 0.5
6046, 0.54166666666667, 0.083333333333333, 0.5
6047, 0.58333333333333, 0.083333333333333, 0.5
6048, 0.625, 0.083333333333333, 0.5
6049, 0.66666666666667, 0.083333333333333, 0.5
6050, 0.70833333333333, 0.083333333333333, 0.5
6051, 0.75, 0.083333333333333, 0.5
6052, 0.79166666666667, 0.083333333333333, 0.5
6053, 0.83333333333333, 0.083333333333333, 0.5
6054, 0.875, 0.083333333333333, 0.5
6055, 0.91666666666667, 0.083333333333333, 0.5
6056, 0.95833333333333, 0.083333333333333, 0.5
6057, 0.041666666666667, 0.125, 0
6058, 0.083333333333333, 0.125, 0
6059, 0.125, 0.125, 0
6060, 0.16666666666667, 0.125, 0
6061, 0.20833333333333, 0.125, 0
6062, 0.25, 0.125, 0
6063, 0.29166666666667, 0.125, 0
6064, 0.33333333333333, 0.125, 0
6065, 0.375, 0.125, 0
6066, 0.41666666666667, 0.125, 0
6067, 0.45833333333333, 0.125, 0
6068, 0.5, 0.125, 0
6069, 0.54166666666667, 0.125, 0
6070, 0.58333333333333, 0.125, 0
6071, 0.625, 0.125, 0
6072, 0.66666666666667, 0.125, 0
6073, 0.70833333333333, 0.125, 0
6074, 0.75, 0.125, 0
6075, 0.79166666666667, 0.125, 0
6076, 0.83333333333333, 0.125, 0
6077, 0.875, 0.125, 0
6078, 0.91666666666667, 0.125, 0
6079, 0.95833333333333, 0.125, 0
6080, 1, 0.125, 0.041666666666667
6081, 1, 0.125, 0.083333333333333
6082, 1, 0.125, 0.125
6083, 1, 0.125, 0.16666666666667
6084, 1, 0.125, 0.20833333333333
6085, 1, 0.125, 0.25
6086, 1, 0.125, 0.29166666666667
6087, 1, 0.125, 0.33333333333333
6088, 1, 0.125, 0.375
6089, 1, 0.125, 0.41666666666667
6090, 1, 0.125, 0.45833333333333
6091, 0.041666666666667, 0.125, 0.5
6092, 0.083333333333333, 0.125, 0.5
6093, 0.125, 0.125, 0.5
6094, 0.16666666666667, 0.125, 0.5
6095, 0.20833333333333, 0.125, 0.5
6096, 0.25, 0.125, 0.5
6097, 0.29166666666667, 0.125, 0.5
6098, 0.33333333333333, 0.125, 0.5
6099, 0.375, 0.125, 0.5
6100, 0.41666666666667, 0.125, 0.5
6101, 0.45833333333333, 0.125, 0.5
6102, 0.5, 0.125, 0.5
6103, 0.54166666666667, 0.125, 0.5
6104, 0.58333333333333, 0.125, 0.5
6105, 0.625, 0.125, 0.5
6106, 0.66666666666667, 0.125, 0.5
6107, 0.70833333333333, 0.125, 0.5
6108, 0.75, 0.125, 0.5
6109, 0.79166666666667, 0.125, 0.5
6110, 0.83333333333333, 0.125, 0.5
6111, 0.875, 0.125, 0.5
6112, 0.91666666666667, 0.125, 0.5
6113, 0.95833333333333, 0.125, 0.5
6114, 0, 0.125, 0.041666666666667
6115, 0, 0.125, 0.083333333333333
6116, 0, 0.125, 0.125
6117, 0, 0.125, 0.16666666666667
6118, 0, 0.125, 0.20833333333333
6119, 0, 0.125, 0.25
6120, 0, 0.125, 0.29166666666667
6121, 0, 0.125, 0.33333333333333
6122, 0, 0.125, 0.375
6123, 0, 0.125, 0.41666666666667
6124, 0, 0.125, 0.45833333333333
6125, 0.041666666666667, 0.15, 0.041666666666667
6126, 0.041666666666667, 0.15, 0.083333333333333
6127, 0.041666666666667, 0.15, 0.125
6128, 0.041666666666667, 0.15, 0.16666666666667
6129, 0.041666666666667, 0.15, 0.20833333333333
6130, 0.041666666666667, 0.15, 0.25
6131, 0.041666666666667, 0.15, 0.29166666666667
6132, 0.041666666666667, 0.15, 0.33333333333333
6133, 0.041666666666667, 0.15, 0.375
6134, 0.041666666666667, 0.15, 0.41666666666667
6135, 0.041666666666667, 0.15, 0.45833333333333
6136, 0.083333333333333, 0.15, 0.041666666666667
6137, 0.083333333333333, 0.15, 0.083333333333333
6138, 0.083333333333333, 0.15, 0.125
6139, 0.083333333333333, 0.15, 0.16666666666667
6140, 0.083333333333333, 0.15, 0.20833333333333
6141, 0.083333333333333, 0.15, 0.25
6142, 0.083333333333333, 0.15, 0.29166666666667
6143, 0.083333333333333, 0.15, 0.33333333333333
6144, 0.083333333333333, 0.15, 0.375
6145, 0.083333333333333, 0.15, 0.41666666666667
6146, 0.083333333333333, 0.15, 0.45833333333333
6147, 0.125, 0.15, 0.041666666666667
6148, 0.125, 0.15, 0.083333333333333
6149, 0.125, 0.15, 0.125
6150, 0.125, 0.15, 0.16666666666667
6151, 0.125, 0.15, 0.20833333333333
6152, 0.125, 0.15, 0.25
6153, 0.125, 0.15, 0.29166666666667
6154, 0.125, 0.15, 0.33333333333333
6155, 0.125, 0.15, 0.375
6156, 0.125, 0.15, 0.41666666666667
6157, 0.125, 0.15, 0.45833333333333
6158, 0.16666666666667, 0.15, 0.041666666666667
6159, 0.16666666666667, 0.15, 0.083333333333333
6160, 0.16666666666667, 0.15, 0.125
6161, 0.16666666666667, 0.15, 0.16666666666667
6162, 0.16666666666667, 0.15, 0.20833333333333
6163, 0.16666666666667, 0.15, 0.25
6164, 0.16666666666667, 0.15, 0.29166666666667
6165, 0.16666666666667, 0.15, 0.33333333333333
6166, 0.16666666666667, 0.15, 0.375
6167, 0.16666666666667, 0.15, 0.41666666666667
6168, 0.16666666666667, 0.15, 0.45833333333333
6169, 0.20833333333333, 0.15, 0.041666666666667
6170, 0.20833333333333, 0.15, 0.083333333333333
6171, 0.20833333333333, 0.15, 0.125
6172, 0.20833333333333, 0.15, 0.16666666666667
6173, 0.20833333333333, 0.15, 0.20833333333333
6174, 0.20833333333333, 0.15, 0.25
6175, 0.20833333333333, 0.15, 0.29166666666667
6176, 0.20833333333333, 0.15, 0.33333333333333
6177, 0.20833333333333, 0.15, 0.375
6178, 0.20833333333333, 0.15, 0.41666666666667
6179, 0.20833333333333, 0.15, 0.45833333333333
6180, 0.25, 0.15, 0.041666666666667
6181, 0.25, 0.15, 0.083333333333333
6182, 0.25, 0.15, 0.125
6183, 0.25, 0.15, 0.16666666666667
6184, 0.25, 0.15, 0.20833333333333
6185, 0.25, 0.15, 0.25
6186, 0.25, 0.15, 0.29166666666667
6187, 0.25, 0.15, 0.33333333333333
6188, 0.25, 0.15, 0.375
6189, 0.25, 0.15, 0.41666666666667
6190, 0.25, 0.15, 0.45833333333333
6191, 0.29166666666667, 0.15, 0.041666666666667
6192, 0.29166666666667, 0.15, 0.083333333333333
6193, 0.29166666666667, 0.15, 0.125
6194, 0.29166666666667, 0.15, 0.16666666666667
6195, 0.29166666666667, 0.15, 0.20833333333333
6196, 0.29166666666667, 0.15, 0.25
6197, 0.29166666666667, 0.15, 0.29166666666667
6198, 0.29166666666667, 0.15, 0.33333333333333
6199, 0.29166666666667, 0.15, 0.375
6200, 0.29166666666667, 0.15, 0.41666666666667
6201, 0.29166666666667, 0.15, 0.45833333333333
6202, 0.33333333333333, 0.15, 0.041666666666667
6203, 0.33333333333333, 0.15, 0.083333333333333
6204, 0.33333333333333, 0.15, 0.125
6205, 0.33333333333333, 0.15, 0.16666666666667
6206, 0.33333333333333, 0.15, 0.20833333333333
6207, 0.33333333333333, 0.15, 0.25
6208, 0.33333333333333, 0.15, 0.29166666666667
6209, 0.33333333333333, 0.15, 0.33333333333333
6210, 0.33333333333333, 0.15, 0.375
6211, 0.33333333333333, 0.15, 0.41666666666667
6212, 0.33333333333333, 0.15, 0.45833333333333
6213, 0.375, 0.15, 0.041666666666667
6214, 0.375, 0.15, 0.083333333333333
6215, 0.375, 0.15, 0.125
6216, 0.375, 0.15, 0.16666666666667
6217, 0.375, 0.15, 0.20833333333333
6218, 0.375, 0.15, 0.25
6219, 0.375, 0.15, 0.29166666666667
6220, 0.375, 0.15, 0.33333333333333
6221, 0.375, 0.15, 0.375
6222, 0.375, 0.15, 0.41666666666667
6223, 0.375, 0.15, 0.45833333333333
6224, 0.41666666666667, 0.15, 0.041666666666667
6225, 0.41666666666667, 0.15, 0.083333333333333
6226, 0.41666666666667, 0.15, 0.125
6227, 0.41666666666667, 0.15, 0.16666666666667
6228, 0.41666666666667, 0.15, 0.20833333333333
6229, 0.41666666666667, 0.15, 0.25
6230, 0.41666666666667, 0.15, 0.29166666666667
6231, 0.41666666666667, 0.15, 0.33333333333333
6232, 0.41666666666667, 0.15, 0.375
6233, 0.41666666666667, 0.15, 0.41666666666667
6234, 0.41666666666667, 0.15, 0.45833333333333
6235, 0.45833333333333, 0.15, 0.041666666666667
6236, 0.45833333333333, 0.15, 0.083333333333333
6237, 0.45833333333333, 0.15, 0.125
6238, 0.45833333333333, 0.15, 0.16666666666667
6239, 0.45833333333333, 0.15, 0.20833333333333
6240, 0.45833333333333, 0.15, 0.25
6241, 0.45833333333333, 0.15, 0.29166666666667
6242, 0.45833333333333, 0.15, 0.33333333333333
6243, 0.45833333333333, 0.15, 0.375
6244, 0.45833333333333, 0.15, 0.41666666666667
6245, 0.45833333333333, 0.15, 0.45833333333333
6246, 0.5, 0.15, 0.041666666666667
6247, 0.5, 0.15, 0.083333333333333
6248, 0.5, 0.15, 0.125
6249, 0.5, 0.15, 0.16666666666667
6250, 0.5, 0.15, 0.20833333333333
6251, 0.5, 0.15, 0.25
6252, 0.5, 0.15, 0.29166666666667
6253, 0.5, 0.15, 0.33333333333333
6254, 0.5, 0.15, 0.375
6255, 0.5, 0.15, 0.41666666666667
6256, 0.5, 0.15, 0.45833333333333
6257, 0.54166666666667, 0.15, 0.041666666666667
6258, 0.54166666666667, 0.15, 0.083333333333333
6259, 0.54166666666667, 0.15, 0.125
6260, 0.54166666666667, 0.15, 0.16666666666667
6261, 0.54166666666667, 0.15, 0.20833333333333
6262, 0.54166666666667, 0.15, 0.25
6263, 0.54166666666667, 0.15, 0.29166666666667
6264, 0.54166666666667, 0.15, 0.33333333333333
6265, 0.54166666666667, 0.15, 0.375
6266, 0.54166666666667, 0.15, 0.41666666666667
6267, 0.54166666666667, 0.15, 0.45833333333333
6268, 0.58333333333333, 0.15, 0.041666666666667
6269, 0.58333333333333, 0.15, 0.083333333333333
6270, 0.58333333333333, 0.15, 0.125
6271, 0.58333333333333, 0.15, 0.16666666666667
6272, 0.58333333333333, 0.15, 0.20833333333333
6273, 0.58333333333333, 0.15, 0.25
6274, 0.58333333333333, 0.15, 0.29166666666667
6275, 0.58333333333333, 0.15, 0.33333333333333
6276, 0.58333333333333, 0.15, 0.375
6277, 0.58333333333333, 0.15, 0.41666666666667
6278, 0.58333333333333, 0.15, 0.45833333333333
6279, 0.625, 0.15, 0.041666666666667
6280, 0.625, 0.15, 0.083333333333333
6281, 0.625, 0.15, 0.125
6282, 0.625, 0.15, 0.16666666666667
6283, 0.625, 0.15, 0.20833333333333
6284, 0.625, 0.15, 0.25
6285, 0.625, 0.15, 0.29166666666667
6286, 0.625, 0.15, 0.33333333333333
6287, 0.625, 0.15, 0.375
6288, 0.625, 0.15, 0.41666666666667
6289, 0.625, 0.15, 0.45833333333333
6290, 0.66666666666667, 0.15, 0.041666666666667
6291, 0.66666666666667, 0.15, 0.083333333333333
6292, 0.66666666666667, 0.15, 0.125
6293, 0.66666666666667, 0.15, 0.16666666666667
6294, 0.66666666666667, 0.15, 0.20833333333333
6295, 0.66666666666667, 0.15, 0.25
6296, 0.66666666666667, 0.15, 0.29166666666667
6297, 0.66666666666667, 0.15, 0.33333333333333
6298, 0.66666666666667, 0.15, 0.375
6299, 0.66666666666667, 0.15, 0.41666666666667
6300, 0.66666666666667, 0.15, 0.45833333333333
6301, 0.70833333333333, 0.15, 0.041666666666667
6302, 0.70833333333333, 0.15, 0.083333333333333
6303, 0.70833333333333, 0.15, 0.125
6304, 0.70833333333333, 0.15, 0.16666666666667
6305, 0.70833333333333, 0.15, 0.20833333333333
6306, 0.70833333333333, 0.15, 0.25
6307, 0.70833333333333, 0.15, 0.29166666666667
6308, 0.70833333333333, 0.15, 0.33333333333333
6309, 0.70833333333333, 0.15, 0.375
6310, 0.70833333333333, 0.15, 0.41666666666667
6311, 0.70833333333333, 0.15, 0.45833333333333
6312, 0.75, 0.15, 0.041666666666667
6313, 0.75, 0.15, 0.083333333333333
6314, 0.75, 0.15, 0.125
6315, 0.75, 0.15, 0.16666666666667
6316, 0.75, 0.15, 0.20833333333333
6317, 0.75, 0.15, 0.25
6318, 0.75, 0.15, 0.29166666666667
6319, 0.75, 0.15, 0.33333333333333
6320, 0.75, 0.15, 0.375
6321, 0.75, 0.15, 0.41666666666667
6322, 0.75, 0.15, 0.45833333333333
6323, 0.79166666666667, 0.15, 0.041666666666667
6324, 0.79166666666667, 0.15, 0.083333333333333
6325, 0.79166666666667, 0.15, 0.125
6326, 0.79166666666667, 0.15, 0.16666666666667
6327, 0.79166666666667, 0.15, 0.20833333333333
6328, 0.79166666666667, 0.15, 0.25
6329, 0.79166666666667, 0.15, 0.29166666666667
6330, 0.79166666666667, 0.15, 0.33333333333333
6331, 0.79166666666667, 0.15, 0.375
6332, 0.79166666666667, 0.15, 0.41666666666667
6333, 0.79166666666667, 0.15, 0.45833333333333
6334, 0.83333333333333, 0.15, 0.041666666666667
6335, 0.83333333333333, 0.15, 0.083333333333333
6336, 0.83333333333333, 0.15, 0.125
6337, 0.83333333333333, 0.15, 0.16666666666667
6338, 0.83333333333333, 0.15, 0.20833333333333
6339, 0.83333333333333, 0.15, 0.25
6340, 0.83333333333333, 0.15, 0.29166666666667
6341, 0.83333333333333, 0.15, 0.33333333333333
6342, 0.83333333333333, 0.15, 0.375
6343, 0.83333333333333, 0.15, 0.41666666666667
6344, 0.83333333333333, 0.15, 0.45833333333333
6345, 0.875, 0.15, 0.041666666666667
6346, 0.875, 0.15, 0.083333333333333
6347, 0.875, 0.15, 0.125
6348, 0.875, 0.15, 0.16666666666667
6349, 0.875, 0.15, 0.20833333333333
6350, 0.875, 0.15, 0.25
6351, 0.875, 0.15, 0.29166666666667
6352, 0.875, 0.15, 0.33333333333333
6353, 0.875, 0.15, 0.375
6354, 0.875, 0.15, 0.41666666666667
6355, 0.875, 0.15, 0.45833333333333
6356, 0.91666666666667, 0.15, 0.041666666666667
6357, 0.91666666666667, 0.15, 0.083333333333333
6358, 0.91666666666667, 0.15, 0.125
6359, 0.91666666666667, 0.15, 0.16666666666667
6360, 0.91666666666667, 0.15, 0.20833333333333
6361, 0.91666666666667, 0.15, 0.25
6362, 0.91666666666667, 0.15, 0.29166666666667
6363, 0.91666666666667, 0.15, 0.33333333333333
6364, 0.91666666666667, 0.15, 0.375
6365, 0.91666666666667, 0.15, 0.41666666666667
6366, 0.91666666666667, 0.15, 0.45833333333333
6367, 0.95833333333333, 0.15, 0.041666666666667
6368, 0.95833333333333, 0.15, 0.083333333333333
6369, 0.95833333333333, 0.15, 0.125
6370, 0.95833333333333, 0.15, 0.16666666666667
6371, 0.95833333333333, 0.15, 0.20833333333333
6372, 0.95833333333333, 0.15, 0.25
6373, 0.95833333333333, 0.15, 0.29166666666667
6374, 0.95833333333333, 0.15, 0.33333333333333
6375, 0.95833333333333, 0.15, 0.375
6376, 0.95833333333333, 0.15, 0.41666666666667
6377, 0.95833333333333, 0.15, 0.45833333333333
6378, 0.020833333333333, 0.15, 0.041666666666667
6379, 0.041666666666667, 0.15, 0.020833333333333
6380, 0.020833333333333, 0.15, 0.083333333333333
6381, 0.041666666666667, 0.15, 0.0625
6382, 0.020833333333333, 0.15, 0.125
6383, 0.041666666666667, 0.15, 0.10416666666667
6384, 0.020833333333333, 0.15, 0.16666666666667
6385, 0.041666666666667, 0.15, 0.14583333333333
6386, 0.020833333333333, 0.15, 0.20833333333333
6387, 0.041666666666667, 0.15, 0.1875
6388, 0.020833333333333, 0.15, 0.25
6389, 0.041666666666667, 0.15, 0.22916666666667
6390, 0.020833333333333, 0.15, 0.29166666666667
6391, 0.041666666666667, 0.15, 0.27083333333333
