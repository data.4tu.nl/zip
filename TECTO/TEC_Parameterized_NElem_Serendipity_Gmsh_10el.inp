101692, 0.29166666666667, 1.58, 0.47916666666667
101693, 0.29166666666667, 1.62, 0.47916666666667
101694, 0.29166666666667, 1.66, 0.47916666666667
101695, 0.33333333333333, 1.52, 0.041666666666667
101696, 0.3125, 1.54, 0.041666666666667
101697, 0.33333333333333, 1.54, 0.020833333333333
101698, 0.33333333333333, 1.56, 0.041666666666667
101699, 0.3125, 1.58, 0.041666666666667
101700, 0.33333333333333, 1.58, 0.020833333333333
101701, 0.33333333333333, 1.6, 0.041666666666667
101702, 0.3125, 1.62, 0.041666666666667
101703, 0.33333333333333, 1.62, 0.020833333333333
101704, 0.33333333333333, 1.64, 0.041666666666667
101705, 0.3125, 1.66, 0.041666666666667
101706, 0.33333333333333, 1.66, 0.020833333333333
101707, 0.33333333333333, 1.68, 0.041666666666667
101708, 0.33333333333333, 1.52, 0.083333333333333
101709, 0.3125, 1.54, 0.083333333333333
101710, 0.33333333333333, 1.54, 0.0625
101711, 0.33333333333333, 1.56, 0.083333333333333
101712, 0.3125, 1.58, 0.083333333333333
101713, 0.33333333333333, 1.58, 0.0625
101714, 0.33333333333333, 1.6, 0.083333333333333
101715, 0.3125, 1.62, 0.083333333333333
101716, 0.33333333333333, 1.62, 0.0625
101717, 0.33333333333333, 1.64, 0.083333333333333
101718, 0.3125, 1.66, 0.083333333333333
101719, 0.33333333333333, 1.66, 0.0625
101720, 0.33333333333333, 1.68, 0.083333333333333
101721, 0.33333333333333, 1.52, 0.125
101722, 0.3125, 1.54, 0.125
101723, 0.33333333333333, 1.54, 0.10416666666667
101724, 0.33333333333333, 1.56, 0.125
101725, 0.3125, 1.58, 0.125
101726, 0.33333333333333, 1.58, 0.10416666666667
101727, 0.33333333333333, 1.6, 0.125
101728, 0.3125, 1.62, 0.125
101729, 0.33333333333333, 1.62, 0.10416666666667
101730, 0.33333333333333, 1.64, 0.125
101731, 0.3125, 1.66, 0.125
101732, 0.33333333333333, 1.66, 0.10416666666667
101733, 0.33333333333333, 1.68, 0.125
101734, 0.33333333333333, 1.52, 0.16666666666667
101735, 0.3125, 1.54, 0.16666666666667
101736, 0.33333333333333, 1.54, 0.14583333333333
101737, 0.33333333333333, 1.56, 0.16666666666667
101738, 0.3125, 1.58, 0.16666666666667
101739, 0.33333333333333, 1.58, 0.14583333333333
101740, 0.33333333333333, 1.6, 0.16666666666667
101741, 0.3125, 1.62, 0.16666666666667
101742, 0.33333333333333, 1.62, 0.14583333333333
101743, 0.33333333333333, 1.64, 0.16666666666667
101744, 0.3125, 1.66, 0.16666666666667
101745, 0.33333333333333, 1.66, 0.14583333333333
101746, 0.33333333333333, 1.68, 0.16666666666667
101747, 0.33333333333333, 1.52, 0.20833333333333
101748, 0.3125, 1.54, 0.20833333333333
101749, 0.33333333333333, 1.54, 0.1875
101750, 0.33333333333333, 1.56, 0.20833333333333
101751, 0.3125, 1.58, 0.20833333333333
101752, 0.33333333333333, 1.58, 0.1875
101753, 0.33333333333333, 1.6, 0.20833333333333
101754, 0.3125, 1.62, 0.20833333333333
101755, 0.33333333333333, 1.62, 0.1875
101756, 0.33333333333333, 1.64, 0.20833333333333
101757, 0.3125, 1.66, 0.20833333333333
101758, 0.33333333333333, 1.66, 0.1875
101759, 0.33333333333333, 1.68, 0.20833333333333
101760, 0.33333333333333, 1.52, 0.25
101761, 0.3125, 1.54, 0.25
101762, 0.33333333333333, 1.54, 0.22916666666667
101763, 0.33333333333333, 1.56, 0.25
101764, 0.3125, 1.58, 0.25
101765, 0.33333333333333, 1.58, 0.22916666666667
101766, 0.33333333333333, 1.6, 0.25
101767, 0.3125, 1.62, 0.25
101768, 0.33333333333333, 1.62, 0.22916666666667
101769, 0.33333333333333, 1.64, 0.25
101770, 0.3125, 1.66, 0.25
101771, 0.33333333333333, 1.66, 0.22916666666667
101772, 0.33333333333333, 1.68, 0.25
101773, 0.33333333333333, 1.52, 0.29166666666667
101774, 0.3125, 1.54, 0.29166666666667
101775, 0.33333333333333, 1.54, 0.27083333333333
101776, 0.33333333333333, 1.56, 0.29166666666667
101777, 0.3125, 1.58, 0.29166666666667
101778, 0.33333333333333, 1.58, 0.27083333333333
101779, 0.33333333333333, 1.6, 0.29166666666667
101780, 0.3125, 1.62, 0.29166666666667
101781, 0.33333333333333, 1.62, 0.27083333333333
101782, 0.33333333333333, 1.64, 0.29166666666667
101783, 0.3125, 1.66, 0.29166666666667
101784, 0.33333333333333, 1.66, 0.27083333333333
101785, 0.33333333333333, 1.68, 0.29166666666667
101786, 0.33333333333333, 1.52, 0.33333333333333
101787, 0.3125, 1.54, 0.33333333333333
101788, 0.33333333333333, 1.54, 0.3125
101789, 0.33333333333333, 1.56, 0.33333333333333
101790, 0.3125, 1.58, 0.33333333333333
101791, 0.33333333333333, 1.58, 0.3125
101792, 0.33333333333333, 1.6, 0.33333333333333
101793, 0.3125, 1.62, 0.33333333333333
101794, 0.33333333333333, 1.62, 0.3125
101795, 0.33333333333333, 1.64, 0.33333333333333
101796, 0.3125, 1.66, 0.33333333333333
101797, 0.33333333333333, 1.66, 0.3125
101798, 0.33333333333333, 1.68, 0.33333333333333
101799, 0.33333333333333, 1.52, 0.375
101800, 0.3125, 1.54, 0.375
101801, 0.33333333333333, 1.54, 0.35416666666667
101802, 0.33333333333333, 1.56, 0.375
101803, 0.3125, 1.58, 0.375
101804, 0.33333333333333, 1.58, 0.35416666666667
101805, 0.33333333333333, 1.6, 0.375
101806, 0.3125, 1.62, 0.375
101807, 0.33333333333333, 1.62, 0.35416666666667
101808, 0.33333333333333, 1.64, 0.375
101809, 0.3125, 1.66, 0.375
101810, 0.33333333333333, 1.66, 0.35416666666667
101811, 0.33333333333333, 1.68, 0.375
101812, 0.33333333333333, 1.52, 0.41666666666667
101813, 0.3125, 1.54, 0.41666666666667
101814, 0.33333333333333, 1.54, 0.39583333333333
101815, 0.33333333333333, 1.56, 0.41666666666667
101816, 0.3125, 1.58, 0.41666666666667
101817, 0.33333333333333, 1.58, 0.39583333333333
101818, 0.33333333333333, 1.6, 0.41666666666667
101819, 0.3125, 1.62, 0.41666666666667
101820, 0.33333333333333, 1.62, 0.39583333333333
101821, 0.33333333333333, 1.64, 0.41666666666667
101822, 0.3125, 1.66, 0.41666666666667
101823, 0.33333333333333, 1.66, 0.39583333333333
101824, 0.33333333333333, 1.68, 0.41666666666667
101825, 0.33333333333333, 1.52, 0.45833333333333
101826, 0.3125, 1.54, 0.45833333333333
101827, 0.33333333333333, 1.54, 0.4375
101828, 0.33333333333333, 1.56, 0.45833333333333
101829, 0.3125, 1.58, 0.45833333333333
101830, 0.33333333333333, 1.58, 0.4375
101831, 0.33333333333333, 1.6, 0.45833333333333
101832, 0.3125, 1.62, 0.45833333333333
101833, 0.33333333333333, 1.62, 0.4375
101834, 0.33333333333333, 1.64, 0.45833333333333
101835, 0.3125, 1.66, 0.45833333333333
101836, 0.33333333333333, 1.66, 0.4375
101837, 0.33333333333333, 1.68, 0.45833333333333
101838, 0.33333333333333, 1.54, 0.47916666666667
101839, 0.33333333333333, 1.58, 0.47916666666667
101840, 0.33333333333333, 1.62, 0.47916666666667
101841, 0.33333333333333, 1.66, 0.47916666666667
101842, 0.375, 1.52, 0.041666666666667
101843, 0.35416666666667, 1.54, 0.041666666666667
101844, 0.375, 1.54, 0.020833333333333
101845, 0.375, 1.56, 0.041666666666667
101846, 0.35416666666667, 1.58, 0.041666666666667
101847, 0.375, 1.58, 0.020833333333333
101848, 0.375, 1.6, 0.041666666666667
101849, 0.35416666666667, 1.62, 0.041666666666667
101850, 0.375, 1.62, 0.020833333333333
101851, 0.375, 1.64, 0.041666666666667
101852, 0.35416666666667, 1.66, 0.041666666666667
101853, 0.375, 1.66, 0.020833333333333
101854, 0.375, 1.68, 0.041666666666667
101855, 0.375, 1.52, 0.083333333333333
101856, 0.35416666666667, 1.54, 0.083333333333333
101857, 0.375, 1.54, 0.0625
101858, 0.375, 1.56, 0.083333333333333
101859, 0.35416666666667, 1.58, 0.083333333333333
101860, 0.375, 1.58, 0.0625
101861, 0.375, 1.6, 0.083333333333333
101862, 0.35416666666667, 1.62, 0.083333333333333
101863, 0.375, 1.62, 0.0625
101864, 0.375, 1.64, 0.083333333333333
101865, 0.35416666666667, 1.66, 0.083333333333333
101866, 0.375, 1.66, 0.0625
101867, 0.375, 1.68, 0.083333333333333
101868, 0.375, 1.52, 0.125
101869, 0.35416666666667, 1.54, 0.125
101870, 0.375, 1.54, 0.10416666666667
101871, 0.375, 1.56, 0.125
101872, 0.35416666666667, 1.58, 0.125
101873, 0.375, 1.58, 0.10416666666667
101874, 0.375, 1.6, 0.125
101875, 0.35416666666667, 1.62, 0.125
101876, 0.375, 1.62, 0.10416666666667
101877, 0.375, 1.64, 0.125
101878, 0.35416666666667, 1.66, 0.125
101879, 0.375, 1.66, 0.10416666666667
101880, 0.375, 1.68, 0.125
101881, 0.375, 1.52, 0.16666666666667
101882, 0.35416666666667, 1.54, 0.16666666666667
101883, 0.375, 1.54, 0.14583333333333
101884, 0.375, 1.56, 0.16666666666667
101885, 0.35416666666667, 1.58, 0.16666666666667
101886, 0.375, 1.58, 0.14583333333333
101887, 0.375, 1.6, 0.16666666666667
101888, 0.35416666666667, 1.62, 0.16666666666667
101889, 0.375, 1.62, 0.14583333333333
101890, 0.375, 1.64, 0.16666666666667
101891, 0.35416666666667, 1.66, 0.16666666666667
101892, 0.375, 1.66, 0.14583333333333
101893, 0.375, 1.68, 0.16666666666667
101894, 0.375, 1.52, 0.20833333333333
101895, 0.35416666666667, 1.54, 0.20833333333333
101896, 0.375, 1.54, 0.1875
101897, 0.375, 1.56, 0.20833333333333
101898, 0.35416666666667, 1.58, 0.20833333333333
101899, 0.375, 1.58, 0.1875
101900, 0.375, 1.6, 0.20833333333333
101901, 0.35416666666667, 1.62, 0.20833333333333
101902, 0.375, 1.62, 0.1875
101903, 0.375, 1.64, 0.20833333333333
101904, 0.35416666666667, 1.66, 0.20833333333333
101905, 0.375, 1.66, 0.1875
101906, 0.375, 1.68, 0.20833333333333
101907, 0.375, 1.52, 0.25
101908, 0.35416666666667, 1.54, 0.25
101909, 0.375, 1.54, 0.22916666666667
101910, 0.375, 1.56, 0.25
101911, 0.35416666666667, 1.58, 0.25
101912, 0.375, 1.58, 0.22916666666667
101913, 0.375, 1.6, 0.25
101914, 0.35416666666667, 1.62, 0.25
101915, 0.375, 1.62, 0.22916666666667
101916, 0.375, 1.64, 0.25
101917, 0.35416666666667, 1.66, 0.25
101918, 0.375, 1.66, 0.22916666666667
101919, 0.375, 1.68, 0.25
101920, 0.375, 1.52, 0.29166666666667
101921, 0.35416666666667, 1.54, 0.29166666666667
101922, 0.375, 1.54, 0.27083333333333
101923, 0.375, 1.56, 0.29166666666667
101924, 0.35416666666667, 1.58, 0.29166666666667
101925, 0.375, 1.58, 0.27083333333333
101926, 0.375, 1.6, 0.29166666666667
101927, 0.35416666666667, 1.62, 0.29166666666667
101928, 0.375, 1.62, 0.27083333333333
101929, 0.375, 1.64, 0.29166666666667
101930, 0.35416666666667, 1.66, 0.29166666666667
101931, 0.375, 1.66, 0.27083333333333
101932, 0.375, 1.68, 0.29166666666667
101933, 0.375, 1.52, 0.33333333333333
101934, 0.35416666666667, 1.54, 0.33333333333333
101935, 0.375, 1.54, 0.3125
101936, 0.375, 1.56, 0.33333333333333
101937, 0.35416666666667, 1.58, 0.33333333333333
101938, 0.375, 1.58, 0.3125
101939, 0.375, 1.6, 0.33333333333333
101940, 0.35416666666667, 1.62, 0.33333333333333
101941, 0.375, 1.62, 0.3125
101942, 0.375, 1.64, 0.33333333333333
101943, 0.35416666666667, 1.66, 0.33333333333333
101944, 0.375, 1.66, 0.3125
101945, 0.375, 1.68, 0.33333333333333
101946, 0.375, 1.52, 0.375
101947, 0.35416666666667, 1.54, 0.375
101948, 0.375, 1.54, 0.35416666666667
101949, 0.375, 1.56, 0.375
101950, 0.35416666666667, 1.58, 0.375
101951, 0.375, 1.58, 0.35416666666667
101952, 0.375, 1.6, 0.375
101953, 0.35416666666667, 1.62, 0.375
101954, 0.375, 1.62, 0.35416666666667
101955, 0.375, 1.64, 0.375
101956, 0.35416666666667, 1.66, 0.375
101957, 0.375, 1.66, 0.35416666666667
101958, 0.375, 1.68, 0.375
101959, 0.375, 1.52, 0.41666666666667
101960, 0.35416666666667, 1.54, 0.41666666666667
101961, 0.375, 1.54, 0.39583333333333
101962, 0.375, 1.56, 0.41666666666667
101963, 0.35416666666667, 1.58, 0.41666666666667
101964, 0.375, 1.58, 0.39583333333333
101965, 0.375, 1.6, 0.41666666666667
101966, 0.35416666666667, 1.62, 0.41666666666667
101967, 0.375, 1.62, 0.39583333333333
101968, 0.375, 1.64, 0.41666666666667
101969, 0.35416666666667, 1.66, 0.41666666666667
101970, 0.375, 1.66, 0.39583333333333
101971, 0.375, 1.68, 0.41666666666667
101972, 0.375, 1.52, 0.45833333333333
101973, 0.35416666666667, 1.54, 0.45833333333333
101974, 0.375, 1.54, 0.4375
101975, 0.375, 1.56, 0.45833333333333
101976, 0.35416666666667, 1.58, 0.45833333333333
101977, 0.375, 1.58, 0.4375
101978, 0.375, 1.6, 0.45833333333333
101979, 0.35416666666667, 1.62, 0.45833333333333
101980, 0.375, 1.62, 0.4375
101981, 0.375, 1.64, 0.45833333333333
101982, 0.35416666666667, 1.66, 0.45833333333333
101983, 0.375, 1.66, 0.4375
101984, 0.375, 1.68, 0.45833333333333
101985, 0.375, 1.54, 0.47916666666667
101986, 0.375, 1.58, 0.47916666666667
101987, 0.375, 1.62, 0.47916666666667
101988, 0.375, 1.66, 0.47916666666667
101989, 0.41666666666667, 1.52, 0.041666666666667
101990, 0.39583333333333, 1.54, 0.041666666666667
101991, 0.41666666666667, 1.54, 0.020833333333333
101992, 0.41666666666667, 1.56, 0.041666666666667
101993, 0.39583333333333, 1.58, 0.041666666666667
101994, 0.41666666666667, 1.58, 0.020833333333333
101995, 0.41666666666667, 1.6, 0.041666666666667
101996, 0.39583333333333, 1.62, 0.041666666666667
101997, 0.41666666666667, 1.62, 0.020833333333333
101998, 0.41666666666667, 1.64, 0.041666666666667
101999, 0.39583333333333, 1.66, 0.041666666666667
102000, 0.41666666666667, 1.66, 0.020833333333333
102001, 0.41666666666667, 1.68, 0.041666666666667
102002, 0.41666666666667, 1.52, 0.083333333333333
102003, 0.39583333333333, 1.54, 0.083333333333333
102004, 0.41666666666667, 1.54, 0.0625
102005, 0.41666666666667, 1.56, 0.083333333333333
102006, 0.39583333333333, 1.58, 0.083333333333333
102007, 0.41666666666667, 1.58, 0.0625
102008, 0.41666666666667, 1.6, 0.083333333333333
102009, 0.39583333333333, 1.62, 0.083333333333333
102010, 0.41666666666667, 1.62, 0.0625
102011, 0.41666666666667, 1.64, 0.083333333333333
102012, 0.39583333333333, 1.66, 0.083333333333333
102013, 0.41666666666667, 1.66, 0.0625
102014, 0.41666666666667, 1.68, 0.083333333333333
102015, 0.41666666666667, 1.52, 0.125
102016, 0.39583333333333, 1.54, 0.125
102017, 0.41666666666667, 1.54, 0.10416666666667
102018, 0.41666666666667, 1.56, 0.125
102019, 0.39583333333333, 1.58, 0.125
102020, 0.41666666666667, 1.58, 0.10416666666667
102021, 0.41666666666667, 1.6, 0.125
102022, 0.39583333333333, 1.62, 0.125
102023, 0.41666666666667, 1.62, 0.10416666666667
102024, 0.41666666666667, 1.64, 0.125
102025, 0.39583333333333, 1.66, 0.125
102026, 0.41666666666667, 1.66, 0.10416666666667
102027, 0.41666666666667, 1.68, 0.125
102028, 0.41666666666667, 1.52, 0.16666666666667
102029, 0.39583333333333, 1.54, 0.16666666666667
102030, 0.41666666666667, 1.54, 0.14583333333333
102031, 0.41666666666667, 1.56, 0.16666666666667
102032, 0.39583333333333, 1.58, 0.16666666666667
102033, 0.41666666666667, 1.58, 0.14583333333333
102034, 0.41666666666667, 1.6, 0.16666666666667
102035, 0.39583333333333, 1.62, 0.16666666666667
102036, 0.41666666666667, 1.62, 0.14583333333333
102037, 0.41666666666667, 1.64, 0.16666666666667
102038, 0.39583333333333, 1.66, 0.16666666666667
102039, 0.41666666666667, 1.66, 0.14583333333333
102040, 0.41666666666667, 1.68, 0.16666666666667
102041, 0.41666666666667, 1.52, 0.20833333333333
102042, 0.39583333333333, 1.54, 0.20833333333333
102043, 0.41666666666667, 1.54, 0.1875
102044, 0.41666666666667, 1.56, 0.20833333333333
102045, 0.39583333333333, 1.58, 0.20833333333333
102046, 0.41666666666667, 1.58, 0.1875
102047, 0.41666666666667, 1.6, 0.20833333333333
102048, 0.39583333333333, 1.62, 0.20833333333333
102049, 0.41666666666667, 1.62, 0.1875
102050, 0.41666666666667, 1.64, 0.20833333333333
102051, 0.39583333333333, 1.66, 0.20833333333333
102052, 0.41666666666667, 1.66, 0.1875
102053, 0.41666666666667, 1.68, 0.20833333333333
102054, 0.41666666666667, 1.52, 0.25
102055, 0.39583333333333, 1.54, 0.25
102056, 0.41666666666667, 1.54, 0.22916666666667
102057, 0.41666666666667, 1.56, 0.25
102058, 0.39583333333333, 1.58, 0.25
102059, 0.41666666666667, 1.58, 0.22916666666667
102060, 0.41666666666667, 1.6, 0.25
102061, 0.39583333333333, 1.62, 0.25
102062, 0.41666666666667, 1.62, 0.22916666666667
102063, 0.41666666666667, 1.64, 0.25
102064, 0.39583333333333, 1.66, 0.25
102065, 0.41666666666667, 1.66, 0.22916666666667
102066, 0.41666666666667, 1.68, 0.25
102067, 0.41666666666667, 1.52, 0.29166666666667
102068, 0.39583333333333, 1.54, 0.29166666666667
102069, 0.41666666666667, 1.54, 0.27083333333333
102070, 0.41666666666667, 1.56, 0.29166666666667
102071, 0.39583333333333, 1.58, 0.29166666666667
102072, 0.41666666666667, 1.58, 0.27083333333333
102073, 0.41666666666667, 1.6, 0.29166666666667
102074, 0.39583333333333, 1.62, 0.29166666666667
102075, 0.41666666666667, 1.62, 0.27083333333333
102076, 0.41666666666667, 1.64, 0.29166666666667
102077, 0.39583333333333, 1.66, 0.29166666666667
102078, 0.41666666666667, 1.66, 0.27083333333333
102079, 0.41666666666667, 1.68, 0.29166666666667
102080, 0.41666666666667, 1.52, 0.33333333333333
102081, 0.39583333333333, 1.54, 0.33333333333333
102082, 0.41666666666667, 1.54, 0.3125
102083, 0.41666666666667, 1.56, 0.33333333333333
102084, 0.39583333333333, 1.58, 0.33333333333333
102085, 0.41666666666667, 1.58, 0.3125
102086, 0.41666666666667, 1.6, 0.33333333333333
102087, 0.39583333333333, 1.62, 0.33333333333333
102088, 0.41666666666667, 1.62, 0.3125
102089, 0.41666666666667, 1.64, 0.33333333333333
102090, 0.39583333333333, 1.66, 0.33333333333333
102091, 0.41666666666667, 1.66, 0.3125
102092, 0.41666666666667, 1.68, 0.33333333333333
102093, 0.41666666666667, 1.52, 0.375
102094, 0.39583333333333, 1.54, 0.375
102095, 0.41666666666667, 1.54, 0.35416666666667
102096, 0.41666666666667, 1.56, 0.375
102097, 0.39583333333333, 1.58, 0.375
102098, 0.41666666666667, 1.58, 0.35416666666667
102099, 0.41666666666667, 1.6, 0.375
102100, 0.39583333333333, 1.62, 0.375
102101, 0.41666666666667, 1.62, 0.35416666666667
102102, 0.41666666666667, 1.64, 0.375
102103, 0.39583333333333, 1.66, 0.375
102104, 0.41666666666667, 1.66, 0.35416666666667
102105, 0.41666666666667, 1.68, 0.375
102106, 0.41666666666667, 1.52, 0.41666666666667
102107, 0.39583333333333, 1.54, 0.41666666666667
102108, 0.41666666666667, 1.54, 0.39583333333333
102109, 0.41666666666667, 1.56, 0.41666666666667
102110, 0.39583333333333, 1.58, 0.41666666666667
102111, 0.41666666666667, 1.58, 0.39583333333333
102112, 0.41666666666667, 1.6, 0.41666666666667
102113, 0.39583333333333, 1.62, 0.41666666666667
102114, 0.41666666666667, 1.62, 0.39583333333333
102115, 0.41666666666667, 1.64, 0.41666666666667
102116, 0.39583333333333, 1.66, 0.41666666666667
102117, 0.41666666666667, 1.66, 0.39583333333333
102118, 0.41666666666667, 1.68, 0.41666666666667
102119, 0.41666666666667, 1.52, 0.45833333333333
102120, 0.39583333333333, 1.54, 0.45833333333333
102121, 0.41666666666667, 1.54, 0.4375
102122, 0.41666666666667, 1.56, 0.45833333333333
102123, 0.39583333333333, 1.58, 0.45833333333333
102124, 0.41666666666667, 1.58, 0.4375
102125, 0.41666666666667, 1.6, 0.45833333333333
102126, 0.39583333333333, 1.62, 0.45833333333333
102127, 0.41666666666667, 1.62, 0.4375
102128, 0.41666666666667, 1.64, 0.45833333333333
102129, 0.39583333333333, 1.66, 0.45833333333333
102130, 0.41666666666667, 1.66, 0.4375
102131, 0.41666666666667, 1.68, 0.45833333333333
102132, 0.41666666666667, 1.54, 0.47916666666667
102133, 0.41666666666667, 1.58, 0.47916666666667
102134, 0.41666666666667, 1.62, 0.47916666666667
102135, 0.41666666666667, 1.66, 0.47916666666667
102136, 0.45833333333333, 1.52, 0.041666666666667
102137, 0.4375, 1.54, 0.041666666666667
102138, 0.45833333333333, 1.54, 0.020833333333333
102139, 0.45833333333333, 1.56, 0.041666666666667
102140, 0.4375, 1.58, 0.041666666666667
102141, 0.45833333333333, 1.58, 0.020833333333333
102142, 0.45833333333333, 1.6, 0.041666666666667
102143, 0.4375, 1.62, 0.041666666666667
102144, 0.45833333333333, 1.62, 0.020833333333333
102145, 0.45833333333333, 1.64, 0.041666666666667
102146, 0.4375, 1.66, 0.041666666666667
102147, 0.45833333333333, 1.66, 0.020833333333333
102148, 0.45833333333333, 1.68, 0.041666666666667
102149, 0.45833333333333, 1.52, 0.083333333333333
102150, 0.4375, 1.54, 0.083333333333333
102151, 0.45833333333333, 1.54, 0.0625
102152, 0.45833333333333, 1.56, 0.083333333333333
102153, 0.4375, 1.58, 0.083333333333333
102154, 0.45833333333333, 1.58, 0.0625
102155, 0.45833333333333, 1.6, 0.083333333333333
102156, 0.4375, 1.62, 0.083333333333333
102157, 0.45833333333333, 1.62, 0.0625
102158, 0.45833333333333, 1.64, 0.083333333333333
102159, 0.4375, 1.66, 0.083333333333333
102160, 0.45833333333333, 1.66, 0.0625
102161, 0.45833333333333, 1.68, 0.083333333333333
102162, 0.45833333333333, 1.52, 0.125
102163, 0.4375, 1.54, 0.125
102164, 0.45833333333333, 1.54, 0.10416666666667
102165, 0.45833333333333, 1.56, 0.125
102166, 0.4375, 1.58, 0.125
102167, 0.45833333333333, 1.58, 0.10416666666667
102168, 0.45833333333333, 1.6, 0.125
102169, 0.4375, 1.62, 0.125
102170, 0.45833333333333, 1.62, 0.10416666666667
102171, 0.45833333333333, 1.64, 0.125
102172, 0.4375, 1.66, 0.125
102173, 0.45833333333333, 1.66, 0.10416666666667
102174, 0.45833333333333, 1.68, 0.125
102175, 0.45833333333333, 1.52, 0.16666666666667
102176, 0.4375, 1.54, 0.16666666666667
102177, 0.45833333333333, 1.54, 0.14583333333333
102178, 0.45833333333333, 1.56, 0.16666666666667
102179, 0.4375, 1.58, 0.16666666666667
102180, 0.45833333333333, 1.58, 0.14583333333333
102181, 0.45833333333333, 1.6, 0.16666666666667
102182, 0.4375, 1.62, 0.16666666666667
102183, 0.45833333333333, 1.62, 0.14583333333333
102184, 0.45833333333333, 1.64, 0.16666666666667
102185, 0.4375, 1.66, 0.16666666666667
102186, 0.45833333333333, 1.66, 0.14583333333333
102187, 0.45833333333333, 1.68, 0.16666666666667
102188, 0.45833333333333, 1.52, 0.20833333333333
102189, 0.4375, 1.54, 0.20833333333333
102190, 0.45833333333333, 1.54, 0.1875
102191, 0.45833333333333, 1.56, 0.20833333333333
102192, 0.4375, 1.58, 0.20833333333333
102193, 0.45833333333333, 1.58, 0.1875
102194, 0.45833333333333, 1.6, 0.20833333333333
102195, 0.4375, 1.62, 0.20833333333333
102196, 0.45833333333333, 1.62, 0.1875
102197, 0.45833333333333, 1.64, 0.20833333333333
102198, 0.4375, 1.66, 0.20833333333333
102199, 0.45833333333333, 1.66, 0.1875
102200, 0.45833333333333, 1.68, 0.20833333333333
102201, 0.45833333333333, 1.52, 0.25
102202, 0.4375, 1.54, 0.25
102203, 0.45833333333333, 1.54, 0.22916666666667
102204, 0.45833333333333, 1.56, 0.25
102205, 0.4375, 1.58, 0.25
102206, 0.45833333333333, 1.58, 0.22916666666667
102207, 0.45833333333333, 1.6, 0.25
102208, 0.4375, 1.62, 0.25
102209, 0.45833333333333, 1.62, 0.22916666666667
102210, 0.45833333333333, 1.64, 0.25
102211, 0.4375, 1.66, 0.25
102212, 0.45833333333333, 1.66, 0.22916666666667
102213, 0.45833333333333, 1.68, 0.25
102214, 0.45833333333333, 1.52, 0.29166666666667
102215, 0.4375, 1.54, 0.29166666666667
102216, 0.45833333333333, 1.54, 0.27083333333333
102217, 0.45833333333333, 1.56, 0.29166666666667
102218, 0.4375, 1.58, 0.29166666666667
102219, 0.45833333333333, 1.58, 0.27083333333333
102220, 0.45833333333333, 1.6, 0.29166666666667
102221, 0.4375, 1.62, 0.29166666666667
102222, 0.45833333333333, 1.62, 0.27083333333333
102223, 0.45833333333333, 1.64, 0.29166666666667
102224, 0.4375, 1.66, 0.29166666666667
102225, 0.45833333333333, 1.66, 0.27083333333333
102226, 0.45833333333333, 1.68, 0.29166666666667
102227, 0.45833333333333, 1.52, 0.33333333333333
102228, 0.4375, 1.54, 0.33333333333333
102229, 0.45833333333333, 1.54, 0.3125
102230, 0.45833333333333, 1.56, 0.33333333333333
102231, 0.4375, 1.58, 0.33333333333333
102232, 0.45833333333333, 1.58, 0.3125
102233, 0.45833333333333, 1.6, 0.33333333333333
102234, 0.4375, 1.62, 0.33333333333333
102235, 0.45833333333333, 1.62, 0.3125
102236, 0.45833333333333, 1.64, 0.33333333333333
102237, 0.4375, 1.66, 0.33333333333333
102238, 0.45833333333333, 1.66, 0.3125
102239, 0.45833333333333, 1.68, 0.33333333333333
102240, 0.45833333333333, 1.52, 0.375
102241, 0.4375, 1.54, 0.375
102242, 0.45833333333333, 1.54, 0.35416666666667
102243, 0.45833333333333, 1.56, 0.375
102244, 0.4375, 1.58, 0.375
102245, 0.45833333333333, 1.58, 0.35416666666667
102246, 0.45833333333333, 1.6, 0.375
102247, 0.4375, 1.62, 0.375
102248, 0.45833333333333, 1.62, 0.35416666666667
102249, 0.45833333333333, 1.64, 0.375
102250, 0.4375, 1.66, 0.375
102251, 0.45833333333333, 1.66, 0.35416666666667
102252, 0.45833333333333, 1.68, 0.375
102253, 0.45833333333333, 1.52, 0.41666666666667
102254, 0.4375, 1.54, 0.41666666666667
102255, 0.45833333333333, 1.54, 0.39583333333333
102256, 0.45833333333333, 1.56, 0.41666666666667
102257, 0.4375, 1.58, 0.41666666666667
102258, 0.45833333333333, 1.58, 0.39583333333333
102259, 0.45833333333333, 1.6, 0.41666666666667
102260, 0.4375, 1.62, 0.41666666666667
102261, 0.45833333333333, 1.62, 0.39583333333333
102262, 0.45833333333333, 1.64, 0.41666666666667
102263, 0.4375, 1.66, 0.41666666666667
102264, 0.45833333333333, 1.66, 0.39583333333333
102265, 0.45833333333333, 1.68, 0.41666666666667
102266, 0.45833333333333, 1.52, 0.45833333333333
102267, 0.4375, 1.54, 0.45833333333333
102268, 0.45833333333333, 1.54, 0.4375
102269, 0.45833333333333, 1.56, 0.45833333333333
102270, 0.4375, 1.58, 0.45833333333333
102271, 0.45833333333333, 1.58, 0.4375
102272, 0.45833333333333, 1.6, 0.45833333333333
102273, 0.4375, 1.62, 0.45833333333333
102274, 0.45833333333333, 1.62, 0.4375
102275, 0.45833333333333, 1.64, 0.45833333333333
102276, 0.4375, 1.66, 0.45833333333333
102277, 0.45833333333333, 1.66, 0.4375
102278, 0.45833333333333, 1.68, 0.45833333333333
102279, 0.45833333333333, 1.54, 0.47916666666667
102280, 0.45833333333333, 1.58, 0.47916666666667
102281, 0.45833333333333, 1.62, 0.47916666666667
102282, 0.45833333333333, 1.66, 0.47916666666667
102283, 0.5, 1.52, 0.041666666666667
102284, 0.47916666666667, 1.54, 0.041666666666667
102285, 0.5, 1.54, 0.020833333333333
102286, 0.5, 1.56, 0.041666666666667
102287, 0.47916666666667, 1.58, 0.041666666666667
102288, 0.5, 1.58, 0.020833333333333
102289, 0.5, 1.6, 0.041666666666667
102290, 0.47916666666667, 1.62, 0.041666666666667
102291, 0.5, 1.62, 0.020833333333333
102292, 0.5, 1.64, 0.041666666666667
102293, 0.47916666666667, 1.66, 0.041666666666667
102294, 0.5, 1.66, 0.020833333333333
102295, 0.5, 1.68, 0.041666666666667
102296, 0.5, 1.52, 0.083333333333333
102297, 0.47916666666667, 1.54, 0.083333333333333
102298, 0.5, 1.54, 0.0625
102299, 0.5, 1.56, 0.083333333333333
102300, 0.47916666666667, 1.58, 0.083333333333333
102301, 0.5, 1.58, 0.0625
102302, 0.5, 1.6, 0.083333333333333
102303, 0.47916666666667, 1.62, 0.083333333333333
102304, 0.5, 1.62, 0.0625
102305, 0.5, 1.64, 0.083333333333333
102306, 0.47916666666667, 1.66, 0.083333333333333
102307, 0.5, 1.66, 0.0625
102308, 0.5, 1.68, 0.083333333333333
102309, 0.5, 1.52, 0.125
102310, 0.47916666666667, 1.54, 0.125
102311, 0.5, 1.54, 0.10416666666667
102312, 0.5, 1.56, 0.125
102313, 0.47916666666667, 1.58, 0.125
102314, 0.5, 1.58, 0.10416666666667
102315, 0.5, 1.6, 0.125
102316, 0.47916666666667, 1.62, 0.125
102317, 0.5, 1.62, 0.10416666666667
102318, 0.5, 1.64, 0.125
102319, 0.47916666666667, 1.66, 0.125
102320, 0.5, 1.66, 0.10416666666667
102321, 0.5, 1.68, 0.125
102322, 0.5, 1.52, 0.16666666666667
102323, 0.47916666666667, 1.54, 0.16666666666667
102324, 0.5, 1.54, 0.14583333333333
102325, 0.5, 1.56, 0.16666666666667
102326, 0.47916666666667, 1.58, 0.16666666666667
102327, 0.5, 1.58, 0.14583333333333
102328, 0.5, 1.6, 0.16666666666667
102329, 0.47916666666667, 1.62, 0.16666666666667
102330, 0.5, 1.62, 0.14583333333333
102331, 0.5, 1.64, 0.16666666666667
102332, 0.47916666666667, 1.66, 0.16666666666667
102333, 0.5, 1.66, 0.14583333333333
102334, 0.5, 1.68, 0.16666666666667
102335, 0.5, 1.52, 0.20833333333333
102336, 0.47916666666667, 1.54, 0.20833333333333
102337, 0.5, 1.54, 0.1875
102338, 0.5, 1.56, 0.20833333333333
102339, 0.47916666666667, 1.58, 0.20833333333333
102340, 0.5, 1.58, 0.1875
102341, 0.5, 1.6, 0.20833333333333
102342, 0.47916666666667, 1.62, 0.20833333333333
102343, 0.5, 1.62, 0.1875
102344, 0.5, 1.64, 0.20833333333333
102345, 0.47916666666667, 1.66, 0.20833333333333
102346, 0.5, 1.66, 0.1875
102347, 0.5, 1.68, 0.20833333333333
102348, 0.5, 1.52, 0.25
102349, 0.47916666666667, 1.54, 0.25
102350, 0.5, 1.54, 0.22916666666667
102351, 0.5, 1.56, 0.25
102352, 0.47916666666667, 1.58, 0.25
102353, 0.5, 1.58, 0.22916666666667
102354, 0.5, 1.6, 0.25
102355, 0.47916666666667, 1.62, 0.25
102356, 0.5, 1.62, 0.22916666666667
102357, 0.5, 1.64, 0.25
102358, 0.47916666666667, 1.66, 0.25
102359, 0.5, 1.66, 0.22916666666667
102360, 0.5, 1.68, 0.25
102361, 0.5, 1.52, 0.29166666666667
102362, 0.47916666666667, 1.54, 0.29166666666667
102363, 0.5, 1.54, 0.27083333333333
102364, 0.5, 1.56, 0.29166666666667
102365, 0.47916666666667, 1.58, 0.29166666666667
102366, 0.5, 1.58, 0.27083333333333
102367, 0.5, 1.6, 0.29166666666667
102368, 0.47916666666667, 1.62, 0.29166666666667
102369, 0.5, 1.62, 0.27083333333333
102370, 0.5, 1.64, 0.29166666666667
102371, 0.47916666666667, 1.66, 0.29166666666667
102372, 0.5, 1.66, 0.27083333333333
102373, 0.5, 1.68, 0.29166666666667
102374, 0.5, 1.52, 0.33333333333333
102375, 0.47916666666667, 1.54, 0.33333333333333
102376, 0.5, 1.54, 0.3125
102377, 0.5, 1.56, 0.33333333333333
102378, 0.47916666666667, 1.58, 0.33333333333333
102379, 0.5, 1.58, 0.3125
102380, 0.5, 1.6, 0.33333333333333
102381, 0.47916666666667, 1.62, 0.33333333333333
102382, 0.5, 1.62, 0.3125
102383, 0.5, 1.64, 0.33333333333333
102384, 0.47916666666667, 1.66, 0.33333333333333
102385, 0.5, 1.66, 0.3125
102386, 0.5, 1.68, 0.33333333333333
102387, 0.5, 1.52, 0.375
102388, 0.47916666666667, 1.54, 0.375
102389, 0.5, 1.54, 0.35416666666667
102390, 0.5, 1.56, 0.375
102391, 0.47916666666667, 1.58, 0.375
102392, 0.5, 1.58, 0.35416666666667
102393, 0.5, 1.6, 0.375
102394, 0.47916666666667, 1.62, 0.375
102395, 0.5, 1.62, 0.35416666666667
102396, 0.5, 1.64, 0.375
102397, 0.47916666666667, 1.66, 0.375
102398, 0.5, 1.66, 0.35416666666667
102399, 0.5, 1.68, 0.375
102400, 0.5, 1.52, 0.41666666666667
102401, 0.47916666666667, 1.54, 0.41666666666667
102402, 0.5, 1.54, 0.39583333333333
102403, 0.5, 1.56, 0.41666666666667
102404, 0.47916666666667, 1.58, 0.41666666666667
102405, 0.5, 1.58, 0.39583333333333
102406, 0.5, 1.6, 0.41666666666667
102407, 0.47916666666667, 1.62, 0.41666666666667
102408, 0.5, 1.62, 0.39583333333333
102409, 0.5, 1.64, 0.41666666666667
102410, 0.47916666666667, 1.66, 0.41666666666667
102411, 0.5, 1.66, 0.39583333333333
102412, 0.5, 1.68, 0.41666666666667
102413, 0.5, 1.52, 0.45833333333333
102414, 0.47916666666667, 1.54, 0.45833333333333
102415, 0.5, 1.54, 0.4375
102416, 0.5, 1.56, 0.45833333333333
102417, 0.47916666666667, 1.58, 0.45833333333333
102418, 0.5, 1.58, 0.4375
102419, 0.5, 1.6, 0.45833333333333
102420, 0.47916666666667, 1.62, 0.45833333333333
102421, 0.5, 1.62, 0.4375
102422, 0.5, 1.64, 0.45833333333333
102423, 0.47916666666667, 1.66, 0.45833333333333
102424, 0.5, 1.66, 0.4375
102425, 0.5, 1.68, 0.45833333333333
102426, 0.5, 1.54, 0.47916666666667
102427, 0.5, 1.58, 0.47916666666667
102428, 0.5, 1.62, 0.47916666666667
102429, 0.5, 1.66, 0.47916666666667
102430, 0.54166666666667, 1.52, 0.041666666666667
102431, 0.52083333333333, 1.54, 0.041666666666667
102432, 0.54166666666667, 1.54, 0.020833333333333
102433, 0.54166666666667, 1.56, 0.041666666666667
102434, 0.52083333333333, 1.58, 0.041666666666667
102435, 0.54166666666667, 1.58, 0.020833333333333
102436, 0.54166666666667, 1.6, 0.041666666666667
102437, 0.52083333333333, 1.62, 0.041666666666667
102438, 0.54166666666667, 1.62, 0.020833333333333
102439, 0.54166666666667, 1.64, 0.041666666666667
102440, 0.52083333333333, 1.66, 0.041666666666667
102441, 0.54166666666667, 1.66, 0.020833333333333
102442, 0.54166666666667, 1.68, 0.041666666666667
102443, 0.54166666666667, 1.52, 0.083333333333333
102444, 0.52083333333333, 1.54, 0.083333333333333
102445, 0.54166666666667, 1.54, 0.0625
102446, 0.54166666666667, 1.56, 0.083333333333333
102447, 0.52083333333333, 1.58, 0.083333333333333
102448, 0.54166666666667, 1.58, 0.0625
102449, 0.54166666666667, 1.6, 0.083333333333333
102450, 0.52083333333333, 1.62, 0.083333333333333
102451, 0.54166666666667, 1.62, 0.0625
102452, 0.54166666666667, 1.64, 0.083333333333333
102453, 0.52083333333333, 1.66, 0.083333333333333
102454, 0.54166666666667, 1.66, 0.0625
102455, 0.54166666666667, 1.68, 0.083333333333333
102456, 0.54166666666667, 1.52, 0.125
102457, 0.52083333333333, 1.54, 0.125
102458, 0.54166666666667, 1.54, 0.10416666666667
102459, 0.54166666666667, 1.56, 0.125
102460, 0.52083333333333, 1.58, 0.125
102461, 0.54166666666667, 1.58, 0.10416666666667
102462, 0.54166666666667, 1.6, 0.125
102463, 0.52083333333333, 1.62, 0.125
102464, 0.54166666666667, 1.62, 0.10416666666667
102465, 0.54166666666667, 1.64, 0.125
102466, 0.52083333333333, 1.66, 0.125
102467, 0.54166666666667, 1.66, 0.10416666666667
102468, 0.54166666666667, 1.68, 0.125
102469, 0.54166666666667, 1.52, 0.16666666666667
102470, 0.52083333333333, 1.54, 0.16666666666667
102471, 0.54166666666667, 1.54, 0.14583333333333
102472, 0.54166666666667, 1.56, 0.16666666666667
102473, 0.52083333333333, 1.58, 0.16666666666667
102474, 0.54166666666667, 1.58, 0.14583333333333
102475, 0.54166666666667, 1.6, 0.16666666666667
102476, 0.52083333333333, 1.62, 0.16666666666667
102477, 0.54166666666667, 1.62, 0.14583333333333
102478, 0.54166666666667, 1.64, 0.16666666666667
102479, 0.52083333333333, 1.66, 0.16666666666667
102480, 0.54166666666667, 1.66, 0.14583333333333
102481, 0.54166666666667, 1.68, 0.16666666666667
102482, 0.54166666666667, 1.52, 0.20833333333333
102483, 0.52083333333333, 1.54, 0.20833333333333
102484, 0.54166666666667, 1.54, 0.1875
102485, 0.54166666666667, 1.56, 0.20833333333333
102486, 0.52083333333333, 1.58, 0.20833333333333
102487, 0.54166666666667, 1.58, 0.1875
102488, 0.54166666666667, 1.6, 0.20833333333333
102489, 0.52083333333333, 1.62, 0.20833333333333
102490, 0.54166666666667, 1.62, 0.1875
102491, 0.54166666666667, 1.64, 0.20833333333333
102492, 0.52083333333333, 1.66, 0.20833333333333
102493, 0.54166666666667, 1.66, 0.1875
102494, 0.54166666666667, 1.68, 0.20833333333333
102495, 0.54166666666667, 1.52, 0.25
102496, 0.52083333333333, 1.54, 0.25
102497, 0.54166666666667, 1.54, 0.22916666666667
102498, 0.54166666666667, 1.56, 0.25
102499, 0.52083333333333, 1.58, 0.25
102500, 0.54166666666667, 1.58, 0.22916666666667
102501, 0.54166666666667, 1.6, 0.25
102502, 0.52083333333333, 1.62, 0.25
102503, 0.54166666666667, 1.62, 0.22916666666667
102504, 0.54166666666667, 1.64, 0.25
102505, 0.52083333333333, 1.66, 0.25
102506, 0.54166666666667, 1.66, 0.22916666666667
102507, 0.54166666666667, 1.68, 0.25
102508, 0.54166666666667, 1.52, 0.29166666666667
102509, 0.52083333333333, 1.54, 0.29166666666667
102510, 0.54166666666667, 1.54, 0.27083333333333
102511, 0.54166666666667, 1.56, 0.29166666666667
102512, 0.52083333333333, 1.58, 0.29166666666667
102513, 0.54166666666667, 1.58, 0.27083333333333
102514, 0.54166666666667, 1.6, 0.29166666666667
102515, 0.52083333333333, 1.62, 0.29166666666667
102516, 0.54166666666667, 1.62, 0.27083333333333
102517, 0.54166666666667, 1.64, 0.29166666666667
102518, 0.52083333333333, 1.66, 0.29166666666667
102519, 0.54166666666667, 1.66, 0.27083333333333
102520, 0.54166666666667, 1.68, 0.29166666666667
102521, 0.54166666666667, 1.52, 0.33333333333333
102522, 0.52083333333333, 1.54, 0.33333333333333
102523, 0.54166666666667, 1.54, 0.3125
102524, 0.54166666666667, 1.56, 0.33333333333333
102525, 0.52083333333333, 1.58, 0.33333333333333
102526, 0.54166666666667, 1.58, 0.3125
102527, 0.54166666666667, 1.6, 0.33333333333333
102528, 0.52083333333333, 1.62, 0.33333333333333
102529, 0.54166666666667, 1.62, 0.3125
102530, 0.54166666666667, 1.64, 0.33333333333333
102531, 0.52083333333333, 1.66, 0.33333333333333
102532, 0.54166666666667, 1.66, 0.3125
102533, 0.54166666666667, 1.68, 0.33333333333333
102534, 0.54166666666667, 1.52, 0.375
102535, 0.52083333333333, 1.54, 0.375
102536, 0.54166666666667, 1.54, 0.35416666666667
102537, 0.54166666666667, 1.56, 0.375
102538, 0.52083333333333, 1.58, 0.375
102539, 0.54166666666667, 1.58, 0.35416666666667
102540, 0.54166666666667, 1.6, 0.375
102541, 0.52083333333333, 1.62, 0.375
102542, 0.54166666666667, 1.62, 0.35416666666667
102543, 0.54166666666667, 1.64, 0.375
102544, 0.52083333333333, 1.66, 0.375
102545, 0.54166666666667, 1.66, 0.35416666666667
102546, 0.54166666666667, 1.68, 0.375
102547, 0.54166666666667, 1.52, 0.41666666666667
102548, 0.52083333333333, 1.54, 0.41666666666667
102549, 0.54166666666667, 1.54, 0.39583333333333
102550, 0.54166666666667, 1.56, 0.41666666666667
102551, 0.52083333333333, 1.58, 0.41666666666667
102552, 0.54166666666667, 1.58, 0.39583333333333
102553, 0.54166666666667, 1.6, 0.41666666666667
102554, 0.52083333333333, 1.62, 0.41666666666667
102555, 0.54166666666667, 1.62, 0.39583333333333
102556, 0.54166666666667, 1.64, 0.41666666666667
102557, 0.52083333333333, 1.66, 0.41666666666667
102558, 0.54166666666667, 1.66, 0.39583333333333
102559, 0.54166666666667, 1.68, 0.41666666666667
102560, 0.54166666666667, 1.52, 0.45833333333333
102561, 0.52083333333333, 1.54, 0.45833333333333
102562, 0.54166666666667, 1.54, 0.4375
102563, 0.54166666666667, 1.56, 0.45833333333333
102564, 0.52083333333333, 1.58, 0.45833333333333
102565, 0.54166666666667, 1.58, 0.4375
102566, 0.54166666666667, 1.6, 0.45833333333333
102567, 0.52083333333333, 1.62, 0.45833333333333
102568, 0.54166666666667, 1.62, 0.4375
102569, 0.54166666666667, 1.64, 0.45833333333333
102570, 0.52083333333333, 1.66, 0.45833333333333
102571, 0.54166666666667, 1.66, 0.4375
102572, 0.54166666666667, 1.68, 0.45833333333333
102573, 0.54166666666667, 1.54, 0.47916666666667
102574, 0.54166666666667, 1.58, 0.47916666666667
102575, 0.54166666666667, 1.62, 0.47916666666667
102576, 0.54166666666667, 1.66, 0.47916666666667
102577, 0.58333333333333, 1.52, 0.041666666666667
102578, 0.5625, 1.54, 0.041666666666667
102579, 0.58333333333333, 1.54, 0.020833333333333
102580, 0.58333333333333, 1.56, 0.041666666666667
102581, 0.5625, 1.58, 0.041666666666667
102582, 0.58333333333333, 1.58, 0.020833333333333
102583, 0.58333333333333, 1.6, 0.041666666666667
102584, 0.5625, 1.62, 0.041666666666667
102585, 0.58333333333333, 1.62, 0.020833333333333
102586, 0.58333333333333, 1.64, 0.041666666666667
102587, 0.5625, 1.66, 0.041666666666667
102588, 0.58333333333333, 1.66, 0.020833333333333
102589, 0.58333333333333, 1.68, 0.041666666666667
102590, 0.58333333333333, 1.52, 0.083333333333333
102591, 0.5625, 1.54, 0.083333333333333
102592, 0.58333333333333, 1.54, 0.0625
102593, 0.58333333333333, 1.56, 0.083333333333333
102594, 0.5625, 1.58, 0.083333333333333
102595, 0.58333333333333, 1.58, 0.0625
102596, 0.58333333333333, 1.6, 0.083333333333333
102597, 0.5625, 1.62, 0.083333333333333
102598, 0.58333333333333, 1.62, 0.0625
102599, 0.58333333333333, 1.64, 0.083333333333333
102600, 0.5625, 1.66, 0.083333333333333
102601, 0.58333333333333, 1.66, 0.0625
102602, 0.58333333333333, 1.68, 0.083333333333333
102603, 0.58333333333333, 1.52, 0.125
102604, 0.5625, 1.54, 0.125
102605, 0.58333333333333, 1.54, 0.10416666666667
102606, 0.58333333333333, 1.56, 0.125
102607, 0.5625, 1.58, 0.125
102608, 0.58333333333333, 1.58, 0.10416666666667
102609, 0.58333333333333, 1.6, 0.125
102610, 0.5625, 1.62, 0.125
102611, 0.58333333333333, 1.62, 0.10416666666667
102612, 0.58333333333333, 1.64, 0.125
102613, 0.5625, 1.66, 0.125
102614, 0.58333333333333, 1.66, 0.10416666666667
102615, 0.58333333333333, 1.68, 0.125
102616, 0.58333333333333, 1.52, 0.16666666666667
102617, 0.5625, 1.54, 0.16666666666667
102618, 0.58333333333333, 1.54, 0.14583333333333
102619, 0.58333333333333, 1.56, 0.16666666666667
102620, 0.5625, 1.58, 0.16666666666667
102621, 0.58333333333333, 1.58, 0.14583333333333
102622, 0.58333333333333, 1.6, 0.16666666666667
102623, 0.5625, 1.62, 0.16666666666667
102624, 0.58333333333333, 1.62, 0.14583333333333
102625, 0.58333333333333, 1.64, 0.16666666666667
102626, 0.5625, 1.66, 0.16666666666667
102627, 0.58333333333333, 1.66, 0.14583333333333
102628, 0.58333333333333, 1.68, 0.16666666666667
102629, 0.58333333333333, 1.52, 0.20833333333333
102630, 0.5625, 1.54, 0.20833333333333
102631, 0.58333333333333, 1.54, 0.1875
102632, 0.58333333333333, 1.56, 0.20833333333333
102633, 0.5625, 1.58, 0.20833333333333
102634, 0.58333333333333, 1.58, 0.1875
102635, 0.58333333333333, 1.6, 0.20833333333333
102636, 0.5625, 1.62, 0.20833333333333
102637, 0.58333333333333, 1.62, 0.1875
102638, 0.58333333333333, 1.64, 0.20833333333333
102639, 0.5625, 1.66, 0.20833333333333
102640, 0.58333333333333, 1.66, 0.1875
102641, 0.58333333333333, 1.68, 0.20833333333333
102642, 0.58333333333333, 1.52, 0.25
102643, 0.5625, 1.54, 0.25
102644, 0.58333333333333, 1.54, 0.22916666666667
102645, 0.58333333333333, 1.56, 0.25
102646, 0.5625, 1.58, 0.25
102647, 0.58333333333333, 1.58, 0.22916666666667
102648, 0.58333333333333, 1.6, 0.25
102649, 0.5625, 1.62, 0.25
102650, 0.58333333333333, 1.62, 0.22916666666667
102651, 0.58333333333333, 1.64, 0.25
102652, 0.5625, 1.66, 0.25
102653, 0.58333333333333, 1.66, 0.22916666666667
102654, 0.58333333333333, 1.68, 0.25
102655, 0.58333333333333, 1.52, 0.29166666666667
102656, 0.5625, 1.54, 0.29166666666667
102657, 0.58333333333333, 1.54, 0.27083333333333
102658, 0.58333333333333, 1.56, 0.29166666666667
102659, 0.5625, 1.58, 0.29166666666667
102660, 0.58333333333333, 1.58, 0.27083333333333
102661, 0.58333333333333, 1.6, 0.29166666666667
102662, 0.5625, 1.62, 0.29166666666667
102663, 0.58333333333333, 1.62, 0.27083333333333
102664, 0.58333333333333, 1.64, 0.29166666666667
102665, 0.5625, 1.66, 0.29166666666667
102666, 0.58333333333333, 1.66, 0.27083333333333
102667, 0.58333333333333, 1.68, 0.29166666666667
102668, 0.58333333333333, 1.52, 0.33333333333333
102669, 0.5625, 1.54, 0.33333333333333
102670, 0.58333333333333, 1.54, 0.3125
102671, 0.58333333333333, 1.56, 0.33333333333333
102672, 0.5625, 1.58, 0.33333333333333
102673, 0.58333333333333, 1.58, 0.3125
102674, 0.58333333333333, 1.6, 0.33333333333333
102675, 0.5625, 1.62, 0.33333333333333
102676, 0.58333333333333, 1.62, 0.3125
102677, 0.58333333333333, 1.64, 0.33333333333333
102678, 0.5625, 1.66, 0.33333333333333
102679, 0.58333333333333, 1.66, 0.3125
102680, 0.58333333333333, 1.68, 0.33333333333333
102681, 0.58333333333333, 1.52, 0.375
102682, 0.5625, 1.54, 0.375
102683, 0.58333333333333, 1.54, 0.35416666666667
102684, 0.58333333333333, 1.56, 0.375
102685, 0.5625, 1.58, 0.375
102686, 0.58333333333333, 1.58, 0.35416666666667
102687, 0.58333333333333, 1.6, 0.375
102688, 0.5625, 1.62, 0.375
102689, 0.58333333333333, 1.62, 0.35416666666667
102690, 0.58333333333333, 1.64, 0.375
102691, 0.5625, 1.66, 0.375
102692, 0.58333333333333, 1.66, 0.35416666666667
102693, 0.58333333333333, 1.68, 0.375
102694, 0.58333333333333, 1.52, 0.41666666666667
102695, 0.5625, 1.54, 0.41666666666667
102696, 0.58333333333333, 1.54, 0.39583333333333
102697, 0.58333333333333, 1.56, 0.41666666666667
102698, 0.5625, 1.58, 0.41666666666667
102699, 0.58333333333333, 1.58, 0.39583333333333
102700, 0.58333333333333, 1.6, 0.41666666666667
102701, 0.5625, 1.62, 0.41666666666667
102702, 0.58333333333333, 1.62, 0.39583333333333
102703, 0.58333333333333, 1.64, 0.41666666666667
102704, 0.5625, 1.66, 0.41666666666667
102705, 0.58333333333333, 1.66, 0.39583333333333
102706, 0.58333333333333, 1.68, 0.41666666666667
102707, 0.58333333333333, 1.52, 0.45833333333333
102708, 0.5625, 1.54, 0.45833333333333
102709, 0.58333333333333, 1.54, 0.4375
102710, 0.58333333333333, 1.56, 0.45833333333333
102711, 0.5625, 1.58, 0.45833333333333
102712, 0.58333333333333, 1.58, 0.4375
102713, 0.58333333333333, 1.6, 0.45833333333333
102714, 0.5625, 1.62, 0.45833333333333
102715, 0.58333333333333, 1.62, 0.4375
102716, 0.58333333333333, 1.64, 0.45833333333333
102717, 0.5625, 1.66, 0.45833333333333
102718, 0.58333333333333, 1.66, 0.4375
102719, 0.58333333333333, 1.68, 0.45833333333333
102720, 0.58333333333333, 1.54, 0.47916666666667
102721, 0.58333333333333, 1.58, 0.47916666666667
102722, 0.58333333333333, 1.62, 0.47916666666667
102723, 0.58333333333333, 1.66, 0.47916666666667
102724, 0.625, 1.52, 0.041666666666667
102725, 0.60416666666667, 1.54, 0.041666666666667
102726, 0.625, 1.54, 0.020833333333333
102727, 0.625, 1.56, 0.041666666666667
102728, 0.60416666666667, 1.58, 0.041666666666667
102729, 0.625, 1.58, 0.020833333333333
102730, 0.625, 1.6, 0.041666666666667
102731, 0.60416666666667, 1.62, 0.041666666666667
102732, 0.625, 1.62, 0.020833333333333
102733, 0.625, 1.64, 0.041666666666667
102734, 0.60416666666667, 1.66, 0.041666666666667
102735, 0.625, 1.66, 0.020833333333333
102736, 0.625, 1.68, 0.041666666666667
102737, 0.625, 1.52, 0.083333333333333
102738, 0.60416666666667, 1.54, 0.083333333333333
102739, 0.625, 1.54, 0.0625
102740, 0.625, 1.56, 0.083333333333333
102741, 0.60416666666667, 1.58, 0.083333333333333
102742, 0.625, 1.58, 0.0625
102743, 0.625, 1.6, 0.083333333333333
102744, 0.60416666666667, 1.62, 0.083333333333333
102745, 0.625, 1.62, 0.0625
102746, 0.625, 1.64, 0.083333333333333
102747, 0.60416666666667, 1.66, 0.083333333333333
102748, 0.625, 1.66, 0.0625
102749, 0.625, 1.68, 0.083333333333333
102750, 0.625, 1.52, 0.125
102751, 0.60416666666667, 1.54, 0.125
102752, 0.625, 1.54, 0.10416666666667
102753, 0.625, 1.56, 0.125
102754, 0.60416666666667, 1.58, 0.125
102755, 0.625, 1.58, 0.10416666666667
102756, 0.625, 1.6, 0.125
102757, 0.60416666666667, 1.62, 0.125
102758, 0.625, 1.62, 0.10416666666667
102759, 0.625, 1.64, 0.125
102760, 0.60416666666667, 1.66, 0.125
102761, 0.625, 1.66, 0.10416666666667
102762, 0.625, 1.68, 0.125
102763, 0.625, 1.52, 0.16666666666667
102764, 0.60416666666667, 1.54, 0.16666666666667
102765, 0.625, 1.54, 0.14583333333333
102766, 0.625, 1.56, 0.16666666666667
102767, 0.60416666666667, 1.58, 0.16666666666667
102768, 0.625, 1.58, 0.14583333333333
102769, 0.625, 1.6, 0.16666666666667
102770, 0.60416666666667, 1.62, 0.16666666666667
102771, 0.625, 1.62, 0.14583333333333
102772, 0.625, 1.64, 0.16666666666667
102773, 0.60416666666667, 1.66, 0.16666666666667
102774, 0.625, 1.66, 0.14583333333333
102775, 0.625, 1.68, 0.16666666666667
102776, 0.625, 1.52, 0.20833333333333
102777, 0.60416666666667, 1.54, 0.20833333333333
102778, 0.625, 1.54, 0.1875
102779, 0.625, 1.56, 0.20833333333333
102780, 0.60416666666667, 1.58, 0.20833333333333
102781, 0.625, 1.58, 0.1875
102782, 0.625, 1.6, 0.20833333333333
102783, 0.60416666666667, 1.62, 0.20833333333333
102784, 0.625, 1.62, 0.1875
102785, 0.625, 1.64, 0.20833333333333
102786, 0.60416666666667, 1.66, 0.20833333333333
102787, 0.625, 1.66, 0.1875
102788, 0.625, 1.68, 0.20833333333333
102789, 0.625, 1.52, 0.25
102790, 0.60416666666667, 1.54, 0.25
102791, 0.625, 1.54, 0.22916666666667
102792, 0.625, 1.56, 0.25
102793, 0.60416666666667, 1.58, 0.25
102794, 0.625, 1.58, 0.22916666666667
102795, 0.625, 1.6, 0.25
102796, 0.60416666666667, 1.62, 0.25
102797, 0.625, 1.62, 0.22916666666667
102798, 0.625, 1.64, 0.25
102799, 0.60416666666667, 1.66, 0.25
102800, 0.625, 1.66, 0.22916666666667
102801, 0.625, 1.68, 0.25
102802, 0.625, 1.52, 0.29166666666667
102803, 0.60416666666667, 1.54, 0.29166666666667
102804, 0.625, 1.54, 0.27083333333333
102805, 0.625, 1.56, 0.29166666666667
102806, 0.60416666666667, 1.58, 0.29166666666667
102807, 0.625, 1.58, 0.27083333333333
102808, 0.625, 1.6, 0.29166666666667
102809, 0.60416666666667, 1.62, 0.29166666666667
102810, 0.625, 1.62, 0.27083333333333
102811, 0.625, 1.64, 0.29166666666667
102812, 0.60416666666667, 1.66, 0.29166666666667
102813, 0.625, 1.66, 0.27083333333333
102814, 0.625, 1.68, 0.29166666666667
102815, 0.625, 1.52, 0.33333333333333
102816, 0.60416666666667, 1.54, 0.33333333333333
102817, 0.625, 1.54, 0.3125
102818, 0.625, 1.56, 0.33333333333333
102819, 0.60416666666667, 1.58, 0.33333333333333
102820, 0.625, 1.58, 0.3125
102821, 0.625, 1.6, 0.33333333333333
102822, 0.60416666666667, 1.62, 0.33333333333333
102823, 0.625, 1.62, 0.3125
102824, 0.625, 1.64, 0.33333333333333
102825, 0.60416666666667, 1.66, 0.33333333333333
102826, 0.625, 1.66, 0.3125
102827, 0.625, 1.68, 0.33333333333333
102828, 0.625, 1.52, 0.375
102829, 0.60416666666667, 1.54, 0.375
102830, 0.625, 1.54, 0.35416666666667
102831, 0.625, 1.56, 0.375
102832, 0.60416666666667, 1.58, 0.375
102833, 0.625, 1.58, 0.35416666666667
102834, 0.625, 1.6, 0.375
102835, 0.60416666666667, 1.62, 0.375
102836, 0.625, 1.62, 0.35416666666667
102837, 0.625, 1.64, 0.375
102838, 0.60416666666667, 1.66, 0.375
102839, 0.625, 1.66, 0.35416666666667
102840, 0.625, 1.68, 0.375
102841, 0.625, 1.52, 0.41666666666667
102842, 0.60416666666667, 1.54, 0.41666666666667
102843, 0.625, 1.54, 0.39583333333333
102844, 0.625, 1.56, 0.41666666666667
102845, 0.60416666666667, 1.58, 0.41666666666667
102846, 0.625, 1.58, 0.39583333333333
102847, 0.625, 1.6, 0.41666666666667
102848, 0.60416666666667, 1.62, 0.41666666666667
102849, 0.625, 1.62, 0.39583333333333
102850, 0.625, 1.64, 0.41666666666667
102851, 0.60416666666667, 1.66, 0.41666666666667
102852, 0.625, 1.66, 0.39583333333333
102853, 0.625, 1.68, 0.41666666666667
102854, 0.625, 1.52, 0.45833333333333
102855, 0.60416666666667, 1.54, 0.45833333333333
102856, 0.625, 1.54, 0.4375
102857, 0.625, 1.56, 0.45833333333333
102858, 0.60416666666667, 1.58, 0.45833333333333
102859, 0.625, 1.58, 0.4375
102860, 0.625, 1.6, 0.45833333333333
102861, 0.60416666666667, 1.62, 0.45833333333333
102862, 0.625, 1.62, 0.4375
102863, 0.625, 1.64, 0.45833333333333
102864, 0.60416666666667, 1.66, 0.45833333333333
102865, 0.625, 1.66, 0.4375
102866, 0.625, 1.68, 0.45833333333333
102867, 0.625, 1.54, 0.47916666666667
102868, 0.625, 1.58, 0.47916666666667
102869, 0.625, 1.62, 0.47916666666667
102870, 0.625, 1.66, 0.47916666666667
102871, 0.66666666666667, 1.52, 0.041666666666667
102872, 0.64583333333333, 1.54, 0.041666666666667
102873, 0.66666666666667, 1.54, 0.020833333333333
102874, 0.66666666666667, 1.56, 0.041666666666667
102875, 0.64583333333333, 1.58, 0.041666666666667
102876, 0.66666666666667, 1.58, 0.020833333333333
102877, 0.66666666666667, 1.6, 0.041666666666667
102878, 0.64583333333333, 1.62, 0.041666666666667
102879, 0.66666666666667, 1.62, 0.020833333333333
102880, 0.66666666666667, 1.64, 0.041666666666667
102881, 0.64583333333333, 1.66, 0.041666666666667
102882, 0.66666666666667, 1.66, 0.020833333333333
102883, 0.66666666666667, 1.68, 0.041666666666667
102884, 0.66666666666667, 1.52, 0.083333333333333
102885, 0.64583333333333, 1.54, 0.083333333333333
102886, 0.66666666666667, 1.54, 0.0625
102887, 0.66666666666667, 1.56, 0.083333333333333
102888, 0.64583333333333, 1.58, 0.083333333333333
102889, 0.66666666666667, 1.58, 0.0625
102890, 0.66666666666667, 1.6, 0.083333333333333
102891, 0.64583333333333, 1.62, 0.083333333333333
102892, 0.66666666666667, 1.62, 0.0625
102893, 0.66666666666667, 1.64, 0.083333333333333
102894, 0.64583333333333, 1.66, 0.083333333333333
102895, 0.66666666666667, 1.66, 0.0625
102896, 0.66666666666667, 1.68, 0.083333333333333
102897, 0.66666666666667, 1.52, 0.125
102898, 0.64583333333333, 1.54, 0.125
102899, 0.66666666666667, 1.54, 0.10416666666667
102900, 0.66666666666667, 1.56, 0.125
102901, 0.64583333333333, 1.58, 0.125
102902, 0.66666666666667, 1.58, 0.10416666666667
102903, 0.66666666666667, 1.6, 0.125
102904, 0.64583333333333, 1.62, 0.125
102905, 0.66666666666667, 1.62, 0.10416666666667
102906, 0.66666666666667, 1.64, 0.125
102907, 0.64583333333333, 1.66, 0.125
102908, 0.66666666666667, 1.66, 0.10416666666667
102909, 0.66666666666667, 1.68, 0.125
102910, 0.66666666666667, 1.52, 0.16666666666667
102911, 0.64583333333333, 1.54, 0.16666666666667
102912, 0.66666666666667, 1.54, 0.14583333333333
102913, 0.66666666666667, 1.56, 0.16666666666667
102914, 0.64583333333333, 1.58, 0.16666666666667
102915, 0.66666666666667, 1.58, 0.14583333333333
102916, 0.66666666666667, 1.6, 0.16666666666667
102917, 0.64583333333333, 1.62, 0.16666666666667
102918, 0.66666666666667, 1.62, 0.14583333333333
102919, 0.66666666666667, 1.64, 0.16666666666667
102920, 0.64583333333333, 1.66, 0.16666666666667
102921, 0.66666666666667, 1.66, 0.14583333333333
102922, 0.66666666666667, 1.68, 0.16666666666667
102923, 0.66666666666667, 1.52, 0.20833333333333
102924, 0.64583333333333, 1.54, 0.20833333333333
102925, 0.66666666666667, 1.54, 0.1875
102926, 0.66666666666667, 1.56, 0.20833333333333
102927, 0.64583333333333, 1.58, 0.20833333333333
102928, 0.66666666666667, 1.58, 0.1875
102929, 0.66666666666667, 1.6, 0.20833333333333
102930, 0.64583333333333, 1.62, 0.20833333333333
102931, 0.66666666666667, 1.62, 0.1875
102932, 0.66666666666667, 1.64, 0.20833333333333
102933, 0.64583333333333, 1.66, 0.20833333333333
102934, 0.66666666666667, 1.66, 0.1875
102935, 0.66666666666667, 1.68, 0.20833333333333
102936, 0.66666666666667, 1.52, 0.25
102937, 0.64583333333333, 1.54, 0.25
102938, 0.66666666666667, 1.54, 0.22916666666667
102939, 0.66666666666667, 1.56, 0.25
102940, 0.64583333333333, 1.58, 0.25
102941, 0.66666666666667, 1.58, 0.22916666666667
102942, 0.66666666666667, 1.6, 0.25
102943, 0.64583333333333, 1.62, 0.25
102944, 0.66666666666667, 1.62, 0.22916666666667
102945, 0.66666666666667, 1.64, 0.25
102946, 0.64583333333333, 1.66, 0.25
102947, 0.66666666666667, 1.66, 0.22916666666667
102948, 0.66666666666667, 1.68, 0.25
102949, 0.66666666666667, 1.52, 0.29166666666667
102950, 0.64583333333333, 1.54, 0.29166666666667
102951, 0.66666666666667, 1.54, 0.27083333333333
102952, 0.66666666666667, 1.56, 0.29166666666667
102953, 0.64583333333333, 1.58, 0.29166666666667
102954, 0.66666666666667, 1.58, 0.27083333333333
102955, 0.66666666666667, 1.6, 0.29166666666667
102956, 0.64583333333333, 1.62, 0.29166666666667
102957, 0.66666666666667, 1.62, 0.27083333333333
102958, 0.66666666666667, 1.64, 0.29166666666667
102959, 0.64583333333333, 1.66, 0.29166666666667
102960, 0.66666666666667, 1.66, 0.27083333333333
102961, 0.66666666666667, 1.68, 0.29166666666667
102962, 0.66666666666667, 1.52, 0.33333333333333
102963, 0.64583333333333, 1.54, 0.33333333333333
102964, 0.66666666666667, 1.54, 0.3125
102965, 0.66666666666667, 1.56, 0.33333333333333
102966, 0.64583333333333, 1.58, 0.33333333333333
102967, 0.66666666666667, 1.58, 0.3125
102968, 0.66666666666667, 1.6, 0.33333333333333
102969, 0.64583333333333, 1.62, 0.33333333333333
102970, 0.66666666666667, 1.62, 0.3125
102971, 0.66666666666667, 1.64, 0.33333333333333
102972, 0.64583333333333, 1.66, 0.33333333333333
102973, 0.66666666666667, 1.66, 0.3125
102974, 0.66666666666667, 1.68, 0.33333333333333
102975, 0.66666666666667, 1.52, 0.375
102976, 0.64583333333333, 1.54, 0.375
102977, 0.66666666666667, 1.54, 0.35416666666667
102978, 0.66666666666667, 1.56, 0.375
102979, 0.64583333333333, 1.58, 0.375
102980, 0.66666666666667, 1.58, 0.35416666666667
102981, 0.66666666666667, 1.6, 0.375
102982, 0.64583333333333, 1.62, 0.375
102983, 0.66666666666667, 1.62, 0.35416666666667
102984, 0.66666666666667, 1.64, 0.375
102985, 0.64583333333333, 1.66, 0.375
102986, 0.66666666666667, 1.66, 0.35416666666667
102987, 0.66666666666667, 1.68, 0.375
102988, 0.66666666666667, 1.52, 0.41666666666667
102989, 0.64583333333333, 1.54, 0.41666666666667
102990, 0.66666666666667, 1.54, 0.39583333333333
102991, 0.66666666666667, 1.56, 0.41666666666667
102992, 0.64583333333333, 1.58, 0.41666666666667
102993, 0.66666666666667, 1.58, 0.39583333333333
102994, 0.66666666666667, 1.6, 0.41666666666667
102995, 0.64583333333333, 1.62, 0.41666666666667
102996, 0.66666666666667, 1.62, 0.39583333333333
102997, 0.66666666666667, 1.64, 0.41666666666667
102998, 0.64583333333333, 1.66, 0.41666666666667
102999, 0.66666666666667, 1.66, 0.39583333333333
103000, 0.66666666666667, 1.68, 0.41666666666667
103001, 0.66666666666667, 1.52, 0.45833333333333
103002, 0.64583333333333, 1.54, 0.45833333333333
103003, 0.66666666666667, 1.54, 0.4375
103004, 0.66666666666667, 1.56, 0.45833333333333
103005, 0.64583333333333, 1.58, 0.45833333333333
103006, 0.66666666666667, 1.58, 0.4375
103007, 0.66666666666667, 1.6, 0.45833333333333
103008, 0.64583333333333, 1.62, 0.45833333333333
103009, 0.66666666666667, 1.62, 0.4375
103010, 0.66666666666667, 1.64, 0.45833333333333
103011, 0.64583333333333, 1.66, 0.45833333333333
103012, 0.66666666666667, 1.66, 0.4375
103013, 0.66666666666667, 1.68, 0.45833333333333
103014, 0.66666666666667, 1.54, 0.47916666666667
103015, 0.66666666666667, 1.58, 0.47916666666667
103016, 0.66666666666667, 1.62, 0.47916666666667
103017, 0.66666666666667, 1.66, 0.47916666666667
103018, 0.70833333333333, 1.52, 0.041666666666667
103019, 0.6875, 1.54, 0.041666666666667
103020, 0.70833333333333, 1.54, 0.020833333333333
103021, 0.70833333333333, 1.56, 0.041666666666667
103022, 0.6875, 1.58, 0.041666666666667
103023, 0.70833333333333, 1.58, 0.020833333333333
103024, 0.70833333333333, 1.6, 0.041666666666667
103025, 0.6875, 1.62, 0.041666666666667
103026, 0.70833333333333, 1.62, 0.020833333333333
103027, 0.70833333333333, 1.64, 0.041666666666667
103028, 0.6875, 1.66, 0.041666666666667
103029, 0.70833333333333, 1.66, 0.020833333333333
103030, 0.70833333333333, 1.68, 0.041666666666667
103031, 0.70833333333333, 1.52, 0.083333333333333
103032, 0.6875, 1.54, 0.083333333333333
103033, 0.70833333333333, 1.54, 0.0625
103034, 0.70833333333333, 1.56, 0.083333333333333
103035, 0.6875, 1.58, 0.083333333333333
103036, 0.70833333333333, 1.58, 0.0625
103037, 0.70833333333333, 1.6, 0.083333333333333
103038, 0.6875, 1.62, 0.083333333333333
103039, 0.70833333333333, 1.62, 0.0625
103040, 0.70833333333333, 1.64, 0.083333333333333
103041, 0.6875, 1.66, 0.083333333333333
103042, 0.70833333333333, 1.66, 0.0625
103043, 0.70833333333333, 1.68, 0.083333333333333
103044, 0.70833333333333, 1.52, 0.125
103045, 0.6875, 1.54, 0.125
103046, 0.70833333333333, 1.54, 0.10416666666667
103047, 0.70833333333333, 1.56, 0.125
103048, 0.6875, 1.58, 0.125
103049, 0.70833333333333, 1.58, 0.10416666666667
103050, 0.70833333333333, 1.6, 0.125
103051, 0.6875, 1.62, 0.125
103052, 0.70833333333333, 1.62, 0.10416666666667
103053, 0.70833333333333, 1.64, 0.125
103054, 0.6875, 1.66, 0.125
103055, 0.70833333333333, 1.66, 0.10416666666667
103056, 0.70833333333333, 1.68, 0.125
103057, 0.70833333333333, 1.52, 0.16666666666667
103058, 0.6875, 1.54, 0.16666666666667
103059, 0.70833333333333, 1.54, 0.14583333333333
103060, 0.70833333333333, 1.56, 0.16666666666667
103061, 0.6875, 1.58, 0.16666666666667
103062, 0.70833333333333, 1.58, 0.14583333333333
103063, 0.70833333333333, 1.6, 0.16666666666667
103064, 0.6875, 1.62, 0.16666666666667
103065, 0.70833333333333, 1.62, 0.14583333333333
103066, 0.70833333333333, 1.64, 0.16666666666667
103067, 0.6875, 1.66, 0.16666666666667
103068, 0.70833333333333, 1.66, 0.14583333333333
103069, 0.70833333333333, 1.68, 0.16666666666667
103070, 0.70833333333333, 1.52, 0.20833333333333
103071, 0.6875, 1.54, 0.20833333333333
103072, 0.70833333333333, 1.54, 0.1875
103073, 0.70833333333333, 1.56, 0.20833333333333
103074, 0.6875, 1.58, 0.20833333333333
103075, 0.70833333333333, 1.58, 0.1875
103076, 0.70833333333333, 1.6, 0.20833333333333
103077, 0.6875, 1.62, 0.20833333333333
103078, 0.70833333333333, 1.62, 0.1875
103079, 0.70833333333333, 1.64, 0.20833333333333
103080, 0.6875, 1.66, 0.20833333333333
103081, 0.70833333333333, 1.66, 0.1875
103082, 0.70833333333333, 1.68, 0.20833333333333
103083, 0.70833333333333, 1.52, 0.25
103084, 0.6875, 1.54, 0.25
103085, 0.70833333333333, 1.54, 0.22916666666667
103086, 0.70833333333333, 1.56, 0.25
103087, 0.6875, 1.58, 0.25
103088, 0.70833333333333, 1.58, 0.22916666666667
103089, 0.70833333333333, 1.6, 0.25
103090, 0.6875, 1.62, 0.25
103091, 0.70833333333333, 1.62, 0.22916666666667
103092, 0.70833333333333, 1.64, 0.25
103093, 0.6875, 1.66, 0.25
103094, 0.70833333333333, 1.66, 0.22916666666667
103095, 0.70833333333333, 1.68, 0.25
103096, 0.70833333333333, 1.52, 0.29166666666667
103097, 0.6875, 1.54, 0.29166666666667
103098, 0.70833333333333, 1.54, 0.27083333333333
103099, 0.70833333333333, 1.56, 0.29166666666667
103100, 0.6875, 1.58, 0.29166666666667
103101, 0.70833333333333, 1.58, 0.27083333333333
103102, 0.70833333333333, 1.6, 0.29166666666667
103103, 0.6875, 1.62, 0.29166666666667
103104, 0.70833333333333, 1.62, 0.27083333333333
103105, 0.70833333333333, 1.64, 0.29166666666667
103106, 0.6875, 1.66, 0.29166666666667
103107, 0.70833333333333, 1.66, 0.27083333333333
103108, 0.70833333333333, 1.68, 0.29166666666667
103109, 0.70833333333333, 1.52, 0.33333333333333
103110, 0.6875, 1.54, 0.33333333333333
103111, 0.70833333333333, 1.54, 0.3125
103112, 0.70833333333333, 1.56, 0.33333333333333
103113, 0.6875, 1.58, 0.33333333333333
103114, 0.70833333333333, 1.58, 0.3125
103115, 0.70833333333333, 1.6, 0.33333333333333
103116, 0.6875, 1.62, 0.33333333333333
103117, 0.70833333333333, 1.62, 0.3125
103118, 0.70833333333333, 1.64, 0.33333333333333
103119, 0.6875, 1.66, 0.33333333333333
103120, 0.70833333333333, 1.66, 0.3125
103121, 0.70833333333333, 1.68, 0.33333333333333
103122, 0.70833333333333, 1.52, 0.375
103123, 0.6875, 1.54, 0.375
103124, 0.70833333333333, 1.54, 0.35416666666667
103125, 0.70833333333333, 1.56, 0.375
103126, 0.6875, 1.58, 0.375
103127, 0.70833333333333, 1.58, 0.35416666666667
103128, 0.70833333333333, 1.6, 0.375
103129, 0.6875, 1.62, 0.375
103130, 0.70833333333333, 1.62, 0.35416666666667
103131, 0.70833333333333, 1.64, 0.375
103132, 0.6875, 1.66, 0.375
103133, 0.70833333333333, 1.66, 0.35416666666667
103134, 0.70833333333333, 1.68, 0.375
103135, 0.70833333333333, 1.52, 0.41666666666667
103136, 0.6875, 1.54, 0.41666666666667
103137, 0.70833333333333, 1.54, 0.39583333333333
103138, 0.70833333333333, 1.56, 0.41666666666667
103139, 0.6875, 1.58, 0.41666666666667
103140, 0.70833333333333, 1.58, 0.39583333333333
103141, 0.70833333333333, 1.6, 0.41666666666667
103142, 0.6875, 1.62, 0.41666666666667
103143, 0.70833333333333, 1.62, 0.39583333333333
103144, 0.70833333333333, 1.64, 0.41666666666667
103145, 0.6875, 1.66, 0.41666666666667
103146, 0.70833333333333, 1.66, 0.39583333333333
103147, 0.70833333333333, 1.68, 0.41666666666667
103148, 0.70833333333333, 1.52, 0.45833333333333
103149, 0.6875, 1.54, 0.45833333333333
103150, 0.70833333333333, 1.54, 0.4375
103151, 0.70833333333333, 1.56, 0.45833333333333
103152, 0.6875, 1.58, 0.45833333333333
103153, 0.70833333333333, 1.58, 0.4375
103154, 0.70833333333333, 1.6, 0.45833333333333
103155, 0.6875, 1.62, 0.45833333333333
103156, 0.70833333333333, 1.62, 0.4375
103157, 0.70833333333333, 1.64, 0.45833333333333
103158, 0.6875, 1.66, 0.45833333333333
103159, 0.70833333333333, 1.66, 0.4375
103160, 0.70833333333333, 1.68, 0.45833333333333
103161, 0.70833333333333, 1.54, 0.47916666666667
103162, 0.70833333333333, 1.58, 0.47916666666667
103163, 0.70833333333333, 1.62, 0.47916666666667
103164, 0.70833333333333, 1.66, 0.47916666666667
103165, 0.75, 1.52, 0.041666666666667
103166, 0.72916666666667, 1.54, 0.041666666666667
103167, 0.75, 1.54, 0.020833333333333
103168, 0.75, 1.56, 0.041666666666667
103169, 0.72916666666667, 1.58, 0.041666666666667
103170, 0.75, 1.58, 0.020833333333333
103171, 0.75, 1.6, 0.041666666666667
103172, 0.72916666666667, 1.62, 0.041666666666667
103173, 0.75, 1.62, 0.020833333333333
103174, 0.75, 1.64, 0.041666666666667
103175, 0.72916666666667, 1.66, 0.041666666666667
103176, 0.75, 1.66, 0.020833333333333
103177, 0.75, 1.68, 0.041666666666667
103178, 0.75, 1.52, 0.083333333333333
103179, 0.72916666666667, 1.54, 0.083333333333333
103180, 0.75, 1.54, 0.0625
103181, 0.75, 1.56, 0.083333333333333
103182, 0.72916666666667, 1.58, 0.083333333333333
103183, 0.75, 1.58, 0.0625
103184, 0.75, 1.6, 0.083333333333333
103185, 0.72916666666667, 1.62, 0.083333333333333
103186, 0.75, 1.62, 0.0625
103187, 0.75, 1.64, 0.083333333333333
103188, 0.72916666666667, 1.66, 0.083333333333333
103189, 0.75, 1.66, 0.0625
103190, 0.75, 1.68, 0.083333333333333
103191, 0.75, 1.52, 0.125
103192, 0.72916666666667, 1.54, 0.125
103193, 0.75, 1.54, 0.10416666666667
103194, 0.75, 1.56, 0.125
103195, 0.72916666666667, 1.58, 0.125
103196, 0.75, 1.58, 0.10416666666667
103197, 0.75, 1.6, 0.125
103198, 0.72916666666667, 1.62, 0.125
103199, 0.75, 1.62, 0.10416666666667
103200, 0.75, 1.64, 0.125
103201, 0.72916666666667, 1.66, 0.125
103202, 0.75, 1.66, 0.10416666666667
103203, 0.75, 1.68, 0.125
103204, 0.75, 1.52, 0.16666666666667
103205, 0.72916666666667, 1.54, 0.16666666666667
103206, 0.75, 1.54, 0.14583333333333
103207, 0.75, 1.56, 0.16666666666667
103208, 0.72916666666667, 1.58, 0.16666666666667
103209, 0.75, 1.58, 0.14583333333333
103210, 0.75, 1.6, 0.16666666666667
103211, 0.72916666666667, 1.62, 0.16666666666667
103212, 0.75, 1.62, 0.14583333333333
103213, 0.75, 1.64, 0.16666666666667
103214, 0.72916666666667, 1.66, 0.16666666666667
103215, 0.75, 1.66, 0.14583333333333
103216, 0.75, 1.68, 0.16666666666667
103217, 0.75, 1.52, 0.20833333333333
103218, 0.72916666666667, 1.54, 0.20833333333333
103219, 0.75, 1.54, 0.1875
103220, 0.75, 1.56, 0.20833333333333
103221, 0.72916666666667, 1.58, 0.20833333333333
103222, 0.75, 1.58, 0.1875
103223, 0.75, 1.6, 0.20833333333333
103224, 0.72916666666667, 1.62, 0.20833333333333
103225, 0.75, 1.62, 0.1875
103226, 0.75, 1.64, 0.20833333333333
103227, 0.72916666666667, 1.66, 0.20833333333333
103228, 0.75, 1.66, 0.1875
103229, 0.75, 1.68, 0.20833333333333
103230, 0.75, 1.52, 0.25
103231, 0.72916666666667, 1.54, 0.25
103232, 0.75, 1.54, 0.22916666666667
103233, 0.75, 1.56, 0.25
103234, 0.72916666666667, 1.58, 0.25
103235, 0.75, 1.58, 0.22916666666667
103236, 0.75, 1.6, 0.25
103237, 0.72916666666667, 1.62, 0.25
103238, 0.75, 1.62, 0.22916666666667
103239, 0.75, 1.64, 0.25
103240, 0.72916666666667, 1.66, 0.25
103241, 0.75, 1.66, 0.22916666666667
103242, 0.75, 1.68, 0.25
103243, 0.75, 1.52, 0.29166666666667
103244, 0.72916666666667, 1.54, 0.29166666666667
103245, 0.75, 1.54, 0.27083333333333
103246, 0.75, 1.56, 0.29166666666667
103247, 0.72916666666667, 1.58, 0.29166666666667
103248, 0.75, 1.58, 0.27083333333333
103249, 0.75, 1.6, 0.29166666666667
103250, 0.72916666666667, 1.62, 0.29166666666667
103251, 0.75, 1.62, 0.27083333333333
103252, 0.75, 1.64, 0.29166666666667
103253, 0.72916666666667, 1.66, 0.29166666666667
103254, 0.75, 1.66, 0.27083333333333
103255, 0.75, 1.68, 0.29166666666667
103256, 0.75, 1.52, 0.33333333333333
103257, 0.72916666666667, 1.54, 0.33333333333333
103258, 0.75, 1.54, 0.3125
103259, 0.75, 1.56, 0.33333333333333
103260, 0.72916666666667, 1.58, 0.33333333333333
103261, 0.75, 1.58, 0.3125
103262, 0.75, 1.6, 0.33333333333333
103263, 0.72916666666667, 1.62, 0.33333333333333
103264, 0.75, 1.62, 0.3125
103265, 0.75, 1.64, 0.33333333333333
103266, 0.72916666666667, 1.66, 0.33333333333333
103267, 0.75, 1.66, 0.3125
103268, 0.75, 1.68, 0.33333333333333
103269, 0.75, 1.52, 0.375
103270, 0.72916666666667, 1.54, 0.375
103271, 0.75, 1.54, 0.35416666666667
103272, 0.75, 1.56, 0.375
103273, 0.72916666666667, 1.58, 0.375
103274, 0.75, 1.58, 0.35416666666667
103275, 0.75, 1.6, 0.375
103276, 0.72916666666667, 1.62, 0.375
103277, 0.75, 1.62, 0.35416666666667
103278, 0.75, 1.64, 0.375
103279, 0.72916666666667, 1.66, 0.375
103280, 0.75, 1.66, 0.35416666666667
103281, 0.75, 1.68, 0.375
103282, 0.75, 1.52, 0.41666666666667
103283, 0.72916666666667, 1.54, 0.41666666666667
103284, 0.75, 1.54, 0.39583333333333
103285, 0.75, 1.56, 0.41666666666667
103286, 0.72916666666667, 1.58, 0.41666666666667
103287, 0.75, 1.58, 0.39583333333333
103288, 0.75, 1.6, 0.41666666666667
103289, 0.72916666666667, 1.62, 0.41666666666667
103290, 0.75, 1.62, 0.39583333333333
103291, 0.75, 1.64, 0.41666666666667
103292, 0.72916666666667, 1.66, 0.41666666666667
103293, 0.75, 1.66, 0.39583333333333
103294, 0.75, 1.68, 0.41666666666667
103295, 0.75, 1.52, 0.45833333333333
103296, 0.72916666666667, 1.54, 0.45833333333333
103297, 0.75, 1.54, 0.4375
103298, 0.75, 1.56, 0.45833333333333
103299, 0.72916666666667, 1.58, 0.45833333333333
103300, 0.75, 1.58, 0.4375
103301, 0.75, 1.6, 0.45833333333333
103302, 0.72916666666667, 1.62, 0.45833333333333
103303, 0.75, 1.62, 0.4375
103304, 0.75, 1.64, 0.45833333333333
103305, 0.72916666666667, 1.66, 0.45833333333333
103306, 0.75, 1.66, 0.4375
103307, 0.75, 1.68, 0.45833333333333
103308, 0.75, 1.54, 0.47916666666667
103309, 0.75, 1.58, 0.47916666666667
103310, 0.75, 1.62, 0.47916666666667
103311, 0.75, 1.66, 0.47916666666667
103312, 0.79166666666667, 1.52, 0.041666666666667
103313, 0.77083333333333, 1.54, 0.041666666666667
103314, 0.79166666666667, 1.54, 0.020833333333333
103315, 0.79166666666667, 1.56, 0.041666666666667
103316, 0.77083333333333, 1.58, 0.041666666666667
103317, 0.79166666666667, 1.58, 0.020833333333333
103318, 0.79166666666667, 1.6, 0.041666666666667
103319, 0.77083333333333, 1.62, 0.041666666666667
103320, 0.79166666666667, 1.62, 0.020833333333333
103321, 0.79166666666667, 1.64, 0.041666666666667
103322, 0.77083333333333, 1.66, 0.041666666666667
103323, 0.79166666666667, 1.66, 0.020833333333333
103324, 0.79166666666667, 1.68, 0.041666666666667
103325, 0.79166666666667, 1.52, 0.083333333333333
103326, 0.77083333333333, 1.54, 0.083333333333333
103327, 0.79166666666667, 1.54, 0.0625
103328, 0.79166666666667, 1.56, 0.083333333333333
103329, 0.77083333333333, 1.58, 0.083333333333333
103330, 0.79166666666667, 1.58, 0.0625
103331, 0.79166666666667, 1.6, 0.083333333333333
103332, 0.77083333333333, 1.62, 0.083333333333333
103333, 0.79166666666667, 1.62, 0.0625
103334, 0.79166666666667, 1.64, 0.083333333333333
103335, 0.77083333333333, 1.66, 0.083333333333333
103336, 0.79166666666667, 1.66, 0.0625
103337, 0.79166666666667, 1.68, 0.083333333333333
103338, 0.79166666666667, 1.52, 0.125
103339, 0.77083333333333, 1.54, 0.125
103340, 0.79166666666667, 1.54, 0.10416666666667
103341, 0.79166666666667, 1.56, 0.125
103342, 0.77083333333333, 1.58, 0.125
103343, 0.79166666666667, 1.58, 0.10416666666667
103344, 0.79166666666667, 1.6, 0.125
103345, 0.77083333333333, 1.62, 0.125
103346, 0.79166666666667, 1.62, 0.10416666666667
103347, 0.79166666666667, 1.64, 0.125
103348, 0.77083333333333, 1.66, 0.125
103349, 0.79166666666667, 1.66, 0.10416666666667
103350, 0.79166666666667, 1.68, 0.125
103351, 0.79166666666667, 1.52, 0.16666666666667
103352, 0.77083333333333, 1.54, 0.16666666666667
103353, 0.79166666666667, 1.54, 0.14583333333333
103354, 0.79166666666667, 1.56, 0.16666666666667
103355, 0.77083333333333, 1.58, 0.16666666666667
103356, 0.79166666666667, 1.58, 0.14583333333333
103357, 0.79166666666667, 1.6, 0.16666666666667
103358, 0.77083333333333, 1.62, 0.16666666666667
103359, 0.79166666666667, 1.62, 0.14583333333333
103360, 0.79166666666667, 1.64, 0.16666666666667
103361, 0.77083333333333, 1.66, 0.16666666666667
103362, 0.79166666666667, 1.66, 0.14583333333333
103363, 0.79166666666667, 1.68, 0.16666666666667
103364, 0.79166666666667, 1.52, 0.20833333333333
103365, 0.77083333333333, 1.54, 0.20833333333333
103366, 0.79166666666667, 1.54, 0.1875
103367, 0.79166666666667, 1.56, 0.20833333333333
103368, 0.77083333333333, 1.58, 0.20833333333333
103369, 0.79166666666667, 1.58, 0.1875
103370, 0.79166666666667, 1.6, 0.20833333333333
103371, 0.77083333333333, 1.62, 0.20833333333333
103372, 0.79166666666667, 1.62, 0.1875
103373, 0.79166666666667, 1.64, 0.20833333333333
103374, 0.77083333333333, 1.66, 0.20833333333333
103375, 0.79166666666667, 1.66, 0.1875
103376, 0.79166666666667, 1.68, 0.20833333333333
103377, 0.79166666666667, 1.52, 0.25
103378, 0.77083333333333, 1.54, 0.25
103379, 0.79166666666667, 1.54, 0.22916666666667
103380, 0.79166666666667, 1.56, 0.25
103381, 0.77083333333333, 1.58, 0.25
103382, 0.79166666666667, 1.58, 0.22916666666667
103383, 0.79166666666667, 1.6, 0.25
103384, 0.77083333333333, 1.62, 0.25
103385, 0.79166666666667, 1.62, 0.22916666666667
103386, 0.79166666666667, 1.64, 0.25
103387, 0.77083333333333, 1.66, 0.25
103388, 0.79166666666667, 1.66, 0.22916666666667
103389, 0.79166666666667, 1.68, 0.25
103390, 0.79166666666667, 1.52, 0.29166666666667
103391, 0.77083333333333, 1.54, 0.29166666666667
103392, 0.79166666666667, 1.54, 0.27083333333333
103393, 0.79166666666667, 1.56, 0.29166666666667
103394, 0.77083333333333, 1.58, 0.29166666666667
103395, 0.79166666666667, 1.58, 0.27083333333333
103396, 0.79166666666667, 1.6, 0.29166666666667
103397, 0.77083333333333, 1.62, 0.29166666666667
103398, 0.79166666666667, 1.62, 0.27083333333333
103399, 0.79166666666667, 1.64, 0.29166666666667
103400, 0.77083333333333, 1.66, 0.29166666666667
103401, 0.79166666666667, 1.66, 0.27083333333333
103402, 0.79166666666667, 1.68, 0.29166666666667
103403, 0.79166666666667, 1.52, 0.33333333333333
103404, 0.77083333333333, 1.54, 0.33333333333333
103405, 0.79166666666667, 1.54, 0.3125
103406, 0.79166666666667, 1.56, 0.33333333333333
103407, 0.77083333333333, 1.58, 0.33333333333333
103408, 0.79166666666667, 1.58, 0.3125
103409, 0.79166666666667, 1.6, 0.33333333333333
103410, 0.77083333333333, 1.62, 0.33333333333333
103411, 0.79166666666667, 1.62, 0.3125
103412, 0.79166666666667, 1.64, 0.33333333333333
103413, 0.77083333333333, 1.66, 0.33333333333333
103414, 0.79166666666667, 1.66, 0.3125
103415, 0.79166666666667, 1.68, 0.33333333333333
103416, 0.79166666666667, 1.52, 0.375
103417, 0.77083333333333, 1.54, 0.375
103418, 0.79166666666667, 1.54, 0.35416666666667
103419, 0.79166666666667, 1.56, 0.375
103420, 0.77083333333333, 1.58, 0.375
103421, 0.79166666666667, 1.58, 0.35416666666667
103422, 0.79166666666667, 1.6, 0.375
103423, 0.77083333333333, 1.62, 0.375
103424, 0.79166666666667, 1.62, 0.35416666666667
103425, 0.79166666666667, 1.64, 0.375
103426, 0.77083333333333, 1.66, 0.375
103427, 0.79166666666667, 1.66, 0.35416666666667
103428, 0.79166666666667, 1.68, 0.375
103429, 0.79166666666667, 1.52, 0.41666666666667
103430, 0.77083333333333, 1.54, 0.41666666666667
103431, 0.79166666666667, 1.54, 0.39583333333333
103432, 0.79166666666667, 1.56, 0.41666666666667
103433, 0.77083333333333, 1.58, 0.41666666666667
103434, 0.79166666666667, 1.58, 0.39583333333333
103435, 0.79166666666667, 1.6, 0.41666666666667
103436, 0.77083333333333, 1.62, 0.41666666666667
103437, 0.79166666666667, 1.62, 0.39583333333333
103438, 0.79166666666667, 1.64, 0.41666666666667
103439, 0.77083333333333, 1.66, 0.41666666666667
103440, 0.79166666666667, 1.66, 0.39583333333333
103441, 0.79166666666667, 1.68, 0.41666666666667
103442, 0.79166666666667, 1.52, 0.45833333333333
103443, 0.77083333333333, 1.54, 0.45833333333333
103444, 0.79166666666667, 1.54, 0.4375
103445, 0.79166666666667, 1.56, 0.45833333333333
103446, 0.77083333333333, 1.58, 0.45833333333333
103447, 0.79166666666667, 1.58, 0.4375
103448, 0.79166666666667, 1.6, 0.45833333333333
103449, 0.77083333333333, 1.62, 0.45833333333333
103450, 0.79166666666667, 1.62, 0.4375
103451, 0.79166666666667, 1.64, 0.45833333333333
103452, 0.77083333333333, 1.66, 0.45833333333333
103453, 0.79166666666667, 1.66, 0.4375
103454, 0.79166666666667, 1.68, 0.45833333333333
103455, 0.79166666666667, 1.54, 0.47916666666667
103456, 0.79166666666667, 1.58, 0.47916666666667
103457, 0.79166666666667, 1.62, 0.47916666666667
103458, 0.79166666666667, 1.66, 0.47916666666667
103459, 0.83333333333333, 1.52, 0.041666666666667
103460, 0.8125, 1.54, 0.041666666666667
103461, 0.83333333333333, 1.54, 0.020833333333333
103462, 0.83333333333333, 1.56, 0.041666666666667
103463, 0.8125, 1.58, 0.041666666666667
103464, 0.83333333333333, 1.58, 0.020833333333333
103465, 0.83333333333333, 1.6, 0.041666666666667
103466, 0.8125, 1.62, 0.041666666666667
103467, 0.83333333333333, 1.62, 0.020833333333333
103468, 0.83333333333333, 1.64, 0.041666666666667
103469, 0.8125, 1.66, 0.041666666666667
103470, 0.83333333333333, 1.66, 0.020833333333333
103471, 0.83333333333333, 1.68, 0.041666666666667
103472, 0.83333333333333, 1.52, 0.083333333333333
103473, 0.8125, 1.54, 0.083333333333333
103474, 0.83333333333333, 1.54, 0.0625
103475, 0.83333333333333, 1.56, 0.083333333333333
103476, 0.8125, 1.58, 0.083333333333333
103477, 0.83333333333333, 1.58, 0.0625
103478, 0.83333333333333, 1.6, 0.083333333333333
103479, 0.8125, 1.62, 0.083333333333333
103480, 0.83333333333333, 1.62, 0.0625
103481, 0.83333333333333, 1.64, 0.083333333333333
103482, 0.8125, 1.66, 0.083333333333333
103483, 0.83333333333333, 1.66, 0.0625
103484, 0.83333333333333, 1.68, 0.083333333333333
103485, 0.83333333333333, 1.52, 0.125
103486, 0.8125, 1.54, 0.125
103487, 0.83333333333333, 1.54, 0.10416666666667
103488, 0.83333333333333, 1.56, 0.125
103489, 0.8125, 1.58, 0.125
103490, 0.83333333333333, 1.58, 0.10416666666667
103491, 0.83333333333333, 1.6, 0.125
103492, 0.8125, 1.62, 0.125
103493, 0.83333333333333, 1.62, 0.10416666666667
103494, 0.83333333333333, 1.64, 0.125
103495, 0.8125, 1.66, 0.125
103496, 0.83333333333333, 1.66, 0.10416666666667
103497, 0.83333333333333, 1.68, 0.125
103498, 0.83333333333333, 1.52, 0.16666666666667
103499, 0.8125, 1.54, 0.16666666666667
103500, 0.83333333333333, 1.54, 0.14583333333333
103501, 0.83333333333333, 1.56, 0.16666666666667
103502, 0.8125, 1.58, 0.16666666666667
103503, 0.83333333333333, 1.58, 0.14583333333333
103504, 0.83333333333333, 1.6, 0.16666666666667
103505, 0.8125, 1.62, 0.16666666666667
103506, 0.83333333333333, 1.62, 0.14583333333333
103507, 0.83333333333333, 1.64, 0.16666666666667
103508, 0.8125, 1.66, 0.16666666666667
103509, 0.83333333333333, 1.66, 0.14583333333333
103510, 0.83333333333333, 1.68, 0.16666666666667
103511, 0.83333333333333, 1.52, 0.20833333333333
103512, 0.8125, 1.54, 0.20833333333333
103513, 0.83333333333333, 1.54, 0.1875
103514, 0.83333333333333, 1.56, 0.20833333333333
103515, 0.8125, 1.58, 0.20833333333333
103516, 0.83333333333333, 1.58, 0.1875
103517, 0.83333333333333, 1.6, 0.20833333333333
103518, 0.8125, 1.62, 0.20833333333333
103519, 0.83333333333333, 1.62, 0.1875
103520, 0.83333333333333, 1.64, 0.20833333333333
103521, 0.8125, 1.66, 0.20833333333333
103522, 0.83333333333333, 1.66, 0.1875
103523, 0.83333333333333, 1.68, 0.20833333333333
103524, 0.83333333333333, 1.52, 0.25
103525, 0.8125, 1.54, 0.25
103526, 0.83333333333333, 1.54, 0.22916666666667
103527, 0.83333333333333, 1.56, 0.25
103528, 0.8125, 1.58, 0.25
103529, 0.83333333333333, 1.58, 0.22916666666667
103530, 0.83333333333333, 1.6, 0.25
103531, 0.8125, 1.62, 0.25
103532, 0.83333333333333, 1.62, 0.22916666666667
103533, 0.83333333333333, 1.64, 0.25
103534, 0.8125, 1.66, 0.25
103535, 0.83333333333333, 1.66, 0.22916666666667
103536, 0.83333333333333, 1.68, 0.25
103537, 0.83333333333333, 1.52, 0.29166666666667
103538, 0.8125, 1.54, 0.29166666666667
103539, 0.83333333333333, 1.54, 0.27083333333333
103540, 0.83333333333333, 1.56, 0.29166666666667
103541, 0.8125, 1.58, 0.29166666666667
103542, 0.83333333333333, 1.58, 0.27083333333333
103543, 0.83333333333333, 1.6, 0.29166666666667
103544, 0.8125, 1.62, 0.29166666666667
103545, 0.83333333333333, 1.62, 0.27083333333333
103546, 0.83333333333333, 1.64, 0.29166666666667
103547, 0.8125, 1.66, 0.29166666666667
103548, 0.83333333333333, 1.66, 0.27083333333333
103549, 0.83333333333333, 1.68, 0.29166666666667
103550, 0.83333333333333, 1.52, 0.33333333333333
103551, 0.8125, 1.54, 0.33333333333333
103552, 0.83333333333333, 1.54, 0.3125
103553, 0.83333333333333, 1.56, 0.33333333333333
103554, 0.8125, 1.58, 0.33333333333333
103555, 0.83333333333333, 1.58, 0.3125
103556, 0.83333333333333, 1.6, 0.33333333333333
103557, 0.8125, 1.62, 0.33333333333333
103558, 0.83333333333333, 1.62, 0.3125
103559, 0.83333333333333, 1.64, 0.33333333333333
103560, 0.8125, 1.66, 0.33333333333333
103561, 0.83333333333333, 1.66, 0.3125
103562, 0.83333333333333, 1.68, 0.33333333333333
103563, 0.83333333333333, 1.52, 0.375
103564, 0.8125, 1.54, 0.375
103565, 0.83333333333333, 1.54, 0.35416666666667
103566, 0.83333333333333, 1.56, 0.375
103567, 0.8125, 1.58, 0.375
103568, 0.83333333333333, 1.58, 0.35416666666667
103569, 0.83333333333333, 1.6, 0.375
103570, 0.8125, 1.62, 0.375
103571, 0.83333333333333, 1.62, 0.35416666666667
103572, 0.83333333333333, 1.64, 0.375
103573, 0.8125, 1.66, 0.375
103574, 0.83333333333333, 1.66, 0.35416666666667
103575, 0.83333333333333, 1.68, 0.375
103576, 0.83333333333333, 1.52, 0.41666666666667
103577, 0.8125, 1.54, 0.41666666666667
103578, 0.83333333333333, 1.54, 0.39583333333333
103579, 0.83333333333333, 1.56, 0.41666666666667
103580, 0.8125, 1.58, 0.41666666666667
103581, 0.83333333333333, 1.58, 0.39583333333333
103582, 0.83333333333333, 1.6, 0.41666666666667
103583, 0.8125, 1.62, 0.41666666666667
103584, 0.83333333333333, 1.62, 0.39583333333333
103585, 0.83333333333333, 1.64, 0.41666666666667
103586, 0.8125, 1.66, 0.41666666666667
103587, 0.83333333333333, 1.66, 0.39583333333333
103588, 0.83333333333333, 1.68, 0.41666666666667
103589, 0.83333333333333, 1.52, 0.45833333333333
103590, 0.8125, 1.54, 0.45833333333333
103591, 0.83333333333333, 1.54, 0.4375
103592, 0.83333333333333, 1.56, 0.45833333333333
103593, 0.8125, 1.58, 0.45833333333333
103594, 0.83333333333333, 1.58, 0.4375
103595, 0.83333333333333, 1.6, 0.45833333333333
103596, 0.8125, 1.62, 0.45833333333333
103597, 0.83333333333333, 1.62, 0.4375
103598, 0.83333333333333, 1.64, 0.45833333333333
103599, 0.8125, 1.66, 0.45833333333333
103600, 0.83333333333333, 1.66, 0.4375
103601, 0.83333333333333, 1.68, 0.45833333333333
103602, 0.83333333333333, 1.54, 0.47916666666667
103603, 0.83333333333333, 1.58, 0.47916666666667
103604, 0.83333333333333, 1.62, 0.47916666666667
103605, 0.83333333333333, 1.66, 0.47916666666667
103606, 0.875, 1.52, 0.041666666666667
103607, 0.85416666666667, 1.54, 0.041666666666667
103608, 0.875, 1.54, 0.020833333333333
103609, 0.875, 1.56, 0.041666666666667
103610, 0.85416666666667, 1.58, 0.041666666666667
103611, 0.875, 1.58, 0.020833333333333
103612, 0.875, 1.6, 0.041666666666667
103613, 0.85416666666667, 1.62, 0.041666666666667
103614, 0.875, 1.62, 0.020833333333333
103615, 0.875, 1.64, 0.041666666666667
103616, 0.85416666666667, 1.66, 0.041666666666667
103617, 0.875, 1.66, 0.020833333333333
103618, 0.875, 1.68, 0.041666666666667
103619, 0.875, 1.52, 0.083333333333333
103620, 0.85416666666667, 1.54, 0.083333333333333
103621, 0.875, 1.54, 0.0625
103622, 0.875, 1.56, 0.083333333333333
103623, 0.85416666666667, 1.58, 0.083333333333333
103624, 0.875, 1.58, 0.0625
103625, 0.875, 1.6, 0.083333333333333
103626, 0.85416666666667, 1.62, 0.083333333333333
103627, 0.875, 1.62, 0.0625
103628, 0.875, 1.64, 0.083333333333333
103629, 0.85416666666667, 1.66, 0.083333333333333
103630, 0.875, 1.66, 0.0625
103631, 0.875, 1.68, 0.083333333333333
103632, 0.875, 1.52, 0.125
103633, 0.85416666666667, 1.54, 0.125
103634, 0.875, 1.54, 0.10416666666667
103635, 0.875, 1.56, 0.125
103636, 0.85416666666667, 1.58, 0.125
103637, 0.875, 1.58, 0.10416666666667
103638, 0.875, 1.6, 0.125
103639, 0.85416666666667, 1.62, 0.125
103640, 0.875, 1.62, 0.10416666666667
103641, 0.875, 1.64, 0.125
103642, 0.85416666666667, 1.66, 0.125
103643, 0.875, 1.66, 0.10416666666667
103644, 0.875, 1.68, 0.125
103645, 0.875, 1.52, 0.16666666666667
103646, 0.85416666666667, 1.54, 0.16666666666667
103647, 0.875, 1.54, 0.14583333333333
103648, 0.875, 1.56, 0.16666666666667
103649, 0.85416666666667, 1.58, 0.16666666666667
103650, 0.875, 1.58, 0.14583333333333
103651, 0.875, 1.6, 0.16666666666667
103652, 0.85416666666667, 1.62, 0.16666666666667
103653, 0.875, 1.62, 0.14583333333333
103654, 0.875, 1.64, 0.16666666666667
103655, 0.85416666666667, 1.66, 0.16666666666667
103656, 0.875, 1.66, 0.14583333333333
103657, 0.875, 1.68, 0.16666666666667
103658, 0.875, 1.52, 0.20833333333333
103659, 0.85416666666667, 1.54, 0.20833333333333
103660, 0.875, 1.54, 0.1875
103661, 0.875, 1.56, 0.20833333333333
103662, 0.85416666666667, 1.58, 0.20833333333333
103663, 0.875, 1.58, 0.1875
103664, 0.875, 1.6, 0.20833333333333
103665, 0.85416666666667, 1.62, 0.20833333333333
103666, 0.875, 1.62, 0.1875
103667, 0.875, 1.64, 0.20833333333333
103668, 0.85416666666667, 1.66, 0.20833333333333
103669, 0.875, 1.66, 0.1875
103670, 0.875, 1.68, 0.20833333333333
103671, 0.875, 1.52, 0.25
103672, 0.85416666666667, 1.54, 0.25
103673, 0.875, 1.54, 0.22916666666667
103674, 0.875, 1.56, 0.25
103675, 0.85416666666667, 1.58, 0.25
103676, 0.875, 1.58, 0.22916666666667
103677, 0.875, 1.6, 0.25
103678, 0.85416666666667, 1.62, 0.25
103679, 0.875, 1.62, 0.22916666666667
103680, 0.875, 1.64, 0.25
103681, 0.85416666666667, 1.66, 0.25
103682, 0.875, 1.66, 0.22916666666667
103683, 0.875, 1.68, 0.25
103684, 0.875, 1.52, 0.29166666666667
103685, 0.85416666666667, 1.54, 0.29166666666667
103686, 0.875, 1.54, 0.27083333333333
103687, 0.875, 1.56, 0.29166666666667
103688, 0.85416666666667, 1.58, 0.29166666666667
103689, 0.875, 1.58, 0.27083333333333
103690, 0.875, 1.6, 0.29166666666667
103691, 0.85416666666667, 1.62, 0.29166666666667
103692, 0.875, 1.62, 0.27083333333333
103693, 0.875, 1.64, 0.29166666666667
103694, 0.85416666666667, 1.66, 0.29166666666667
103695, 0.875, 1.66, 0.27083333333333
103696, 0.875, 1.68, 0.29166666666667
103697, 0.875, 1.52, 0.33333333333333
103698, 0.85416666666667, 1.54, 0.33333333333333
103699, 0.875, 1.54, 0.3125
103700, 0.875, 1.56, 0.33333333333333
103701, 0.85416666666667, 1.58, 0.33333333333333
103702, 0.875, 1.58, 0.3125
103703, 0.875, 1.6, 0.33333333333333
103704, 0.85416666666667, 1.62, 0.33333333333333
103705, 0.875, 1.62, 0.3125
103706, 0.875, 1.64, 0.33333333333333
103707, 0.85416666666667, 1.66, 0.33333333333333
103708, 0.875, 1.66, 0.3125
103709, 0.875, 1.68, 0.33333333333333
103710, 0.875, 1.52, 0.375
103711, 0.85416666666667, 1.54, 0.375
103712, 0.875, 1.54, 0.35416666666667
103713, 0.875, 1.56, 0.375
103714, 0.85416666666667, 1.58, 0.375
103715, 0.875, 1.58, 0.35416666666667
103716, 0.875, 1.6, 0.375
103717, 0.85416666666667, 1.62, 0.375
103718, 0.875, 1.62, 0.35416666666667
103719, 0.875, 1.64, 0.375
103720, 0.85416666666667, 1.66, 0.375
103721, 0.875, 1.66, 0.35416666666667
103722, 0.875, 1.68, 0.375
103723, 0.875, 1.52, 0.41666666666667
103724, 0.85416666666667, 1.54, 0.41666666666667
103725, 0.875, 1.54, 0.39583333333333
103726, 0.875, 1.56, 0.41666666666667
103727, 0.85416666666667, 1.58, 0.41666666666667
103728, 0.875, 1.58, 0.39583333333333
103729, 0.875, 1.6, 0.41666666666667
103730, 0.85416666666667, 1.62, 0.41666666666667
103731, 0.875, 1.62, 0.39583333333333
103732, 0.875, 1.64, 0.41666666666667
103733, 0.85416666666667, 1.66, 0.41666666666667
103734, 0.875, 1.66, 0.39583333333333
103735, 0.875, 1.68, 0.41666666666667
103736, 0.875, 1.52, 0.45833333333333
103737, 0.85416666666667, 1.54, 0.45833333333333
103738, 0.875, 1.54, 0.4375
103739, 0.875, 1.56, 0.45833333333333
103740, 0.85416666666667, 1.58, 0.45833333333333
103741, 0.875, 1.58, 0.4375
103742, 0.875, 1.6, 0.45833333333333
103743, 0.85416666666667, 1.62, 0.45833333333333
103744, 0.875, 1.62, 0.4375
103745, 0.875, 1.64, 0.45833333333333
103746, 0.85416666666667, 1.66, 0.45833333333333
103747, 0.875, 1.66, 0.4375
103748, 0.875, 1.68, 0.45833333333333
103749, 0.875, 1.54, 0.47916666666667
103750, 0.875, 1.58, 0.47916666666667
103751, 0.875, 1.62, 0.47916666666667
103752, 0.875, 1.66, 0.47916666666667
103753, 0.91666666666667, 1.52, 0.041666666666667
103754, 0.89583333333333, 1.54, 0.041666666666667
103755, 0.91666666666667, 1.54, 0.020833333333333
103756, 0.91666666666667, 1.56, 0.041666666666667
103757, 0.89583333333333, 1.58, 0.041666666666667
103758, 0.91666666666667, 1.58, 0.020833333333333
103759, 0.91666666666667, 1.6, 0.041666666666667
103760, 0.89583333333333, 1.62, 0.041666666666667
103761, 0.91666666666667, 1.62, 0.020833333333333
103762, 0.91666666666667, 1.64, 0.041666666666667
103763, 0.89583333333333, 1.66, 0.041666666666667
103764, 0.91666666666667, 1.66, 0.020833333333333
103765, 0.91666666666667, 1.68, 0.041666666666667
103766, 0.91666666666667, 1.52, 0.083333333333333
103767, 0.89583333333333, 1.54, 0.083333333333333
103768, 0.91666666666667, 1.54, 0.0625
103769, 0.91666666666667, 1.56, 0.083333333333333
103770, 0.89583333333333, 1.58, 0.083333333333333
103771, 0.91666666666667, 1.58, 0.0625
103772, 0.91666666666667, 1.6, 0.083333333333333
103773, 0.89583333333333, 1.62, 0.083333333333333
103774, 0.91666666666667, 1.62, 0.0625
103775, 0.91666666666667, 1.64, 0.083333333333333
103776, 0.89583333333333, 1.66, 0.083333333333333
103777, 0.91666666666667, 1.66, 0.0625
103778, 0.91666666666667, 1.68, 0.083333333333333
103779, 0.91666666666667, 1.52, 0.125
103780, 0.89583333333333, 1.54, 0.125
103781, 0.91666666666667, 1.54, 0.10416666666667
103782, 0.91666666666667, 1.56, 0.125
103783, 0.89583333333333, 1.58, 0.125
103784, 0.91666666666667, 1.58, 0.10416666666667
103785, 0.91666666666667, 1.6, 0.125
103786, 0.89583333333333, 1.62, 0.125
103787, 0.91666666666667, 1.62, 0.10416666666667
103788, 0.91666666666667, 1.64, 0.125
103789, 0.89583333333333, 1.66, 0.125
103790, 0.91666666666667, 1.66, 0.10416666666667
103791, 0.91666666666667, 1.68, 0.125
103792, 0.91666666666667, 1.52, 0.16666666666667
103793, 0.89583333333333, 1.54, 0.16666666666667
103794, 0.91666666666667, 1.54, 0.14583333333333
103795, 0.91666666666667, 1.56, 0.16666666666667
103796, 0.89583333333333, 1.58, 0.16666666666667
103797, 0.91666666666667, 1.58, 0.14583333333333
103798, 0.91666666666667, 1.6, 0.16666666666667
103799, 0.89583333333333, 1.62, 0.16666666666667
103800, 0.91666666666667, 1.62, 0.14583333333333
103801, 0.91666666666667, 1.64, 0.16666666666667
103802, 0.89583333333333, 1.66, 0.16666666666667
103803, 0.91666666666667, 1.66, 0.14583333333333
103804, 0.91666666666667, 1.68, 0.16666666666667
103805, 0.91666666666667, 1.52, 0.20833333333333
103806, 0.89583333333333, 1.54, 0.20833333333333
103807, 0.91666666666667, 1.54, 0.1875
103808, 0.91666666666667, 1.56, 0.20833333333333
103809, 0.89583333333333, 1.58, 0.20833333333333
103810, 0.91666666666667, 1.58, 0.1875
103811, 0.91666666666667, 1.6, 0.20833333333333
103812, 0.89583333333333, 1.62, 0.20833333333333
103813, 0.91666666666667, 1.62, 0.1875
103814, 0.91666666666667, 1.64, 0.20833333333333
103815, 0.89583333333333, 1.66, 0.20833333333333
103816, 0.91666666666667, 1.66, 0.1875
103817, 0.91666666666667, 1.68, 0.20833333333333
103818, 0.91666666666667, 1.52, 0.25
103819, 0.89583333333333, 1.54, 0.25
103820, 0.91666666666667, 1.54, 0.22916666666667
103821, 0.91666666666667, 1.56, 0.25
103822, 0.89583333333333, 1.58, 0.25
103823, 0.91666666666667, 1.58, 0.22916666666667
103824, 0.91666666666667, 1.6, 0.25
103825, 0.89583333333333, 1.62, 0.25
103826, 0.91666666666667, 1.62, 0.22916666666667
103827, 0.91666666666667, 1.64, 0.25
103828, 0.89583333333333, 1.66, 0.25
103829, 0.91666666666667, 1.66, 0.22916666666667
103830, 0.91666666666667, 1.68, 0.25
103831, 0.91666666666667, 1.52, 0.29166666666667
103832, 0.89583333333333, 1.54, 0.29166666666667
103833, 0.91666666666667, 1.54, 0.27083333333333
103834, 0.91666666666667, 1.56, 0.29166666666667
103835, 0.89583333333333, 1.58, 0.29166666666667
103836, 0.91666666666667, 1.58, 0.27083333333333
103837, 0.91666666666667, 1.6, 0.29166666666667
103838, 0.89583333333333, 1.62, 0.29166666666667
103839, 0.91666666666667, 1.62, 0.27083333333333
103840, 0.91666666666667, 1.64, 0.29166666666667
103841, 0.89583333333333, 1.66, 0.29166666666667
103842, 0.91666666666667, 1.66, 0.27083333333333
103843, 0.91666666666667, 1.68, 0.29166666666667
103844, 0.91666666666667, 1.52, 0.33333333333333
103845, 0.89583333333333, 1.54, 0.33333333333333
103846, 0.91666666666667, 1.54, 0.3125
103847, 0.91666666666667, 1.56, 0.33333333333333
103848, 0.89583333333333, 1.58, 0.33333333333333
103849, 0.91666666666667, 1.58, 0.3125
103850, 0.91666666666667, 1.6, 0.33333333333333
103851, 0.89583333333333, 1.62, 0.33333333333333
103852, 0.91666666666667, 1.62, 0.3125
103853, 0.91666666666667, 1.64, 0.33333333333333
103854, 0.89583333333333, 1.66, 0.33333333333333
103855, 0.91666666666667, 1.66, 0.3125
103856, 0.91666666666667, 1.68, 0.33333333333333
103857, 0.91666666666667, 1.52, 0.375
103858, 0.89583333333333, 1.54, 0.375
103859, 0.91666666666667, 1.54, 0.35416666666667
103860, 0.91666666666667, 1.56, 0.375
103861, 0.89583333333333, 1.58, 0.375
103862, 0.91666666666667, 1.58, 0.35416666666667
103863, 0.91666666666667, 1.6, 0.375
103864, 0.89583333333333, 1.62, 0.375
103865, 0.91666666666667, 1.62, 0.35416666666667
103866, 0.91666666666667, 1.64, 0.375
103867, 0.89583333333333, 1.66, 0.375
103868, 0.91666666666667, 1.66, 0.35416666666667
103869, 0.91666666666667, 1.68, 0.375
103870, 0.91666666666667, 1.52, 0.41666666666667
103871, 0.89583333333333, 1.54, 0.41666666666667
103872, 0.91666666666667, 1.54, 0.39583333333333
103873, 0.91666666666667, 1.56, 0.41666666666667
103874, 0.89583333333333, 1.58, 0.41666666666667
103875, 0.91666666666667, 1.58, 0.39583333333333
103876, 0.91666666666667, 1.6, 0.41666666666667
103877, 0.89583333333333, 1.62, 0.41666666666667
103878, 0.91666666666667, 1.62, 0.39583333333333
103879, 0.91666666666667, 1.64, 0.41666666666667
103880, 0.89583333333333, 1.66, 0.41666666666667
103881, 0.91666666666667, 1.66, 0.39583333333333
103882, 0.91666666666667, 1.68, 0.41666666666667
103883, 0.91666666666667, 1.52, 0.45833333333333
103884, 0.89583333333333, 1.54, 0.45833333333333
103885, 0.91666666666667, 1.54, 0.4375
103886, 0.91666666666667, 1.56, 0.45833333333333
103887, 0.89583333333333, 1.58, 0.45833333333333
103888, 0.91666666666667, 1.58, 0.4375
103889, 0.91666666666667, 1.6, 0.45833333333333
103890, 0.89583333333333, 1.62, 0.45833333333333
103891, 0.91666666666667, 1.62, 0.4375
103892, 0.91666666666667, 1.64, 0.45833333333333
103893, 0.89583333333333, 1.66, 0.45833333333333
103894, 0.91666666666667, 1.66, 0.4375
103895, 0.91666666666667, 1.68, 0.45833333333333
103896, 0.91666666666667, 1.54, 0.47916666666667
103897, 0.91666666666667, 1.58, 0.47916666666667
103898, 0.91666666666667, 1.62, 0.47916666666667
103899, 0.91666666666667, 1.66, 0.47916666666667
103900, 0.95833333333333, 1.52, 0.041666666666667
103901, 0.9375, 1.54, 0.041666666666667
103902, 0.95833333333333, 1.54, 0.020833333333333
103903, 0.95833333333333, 1.56, 0.041666666666667
103904, 0.9375, 1.58, 0.041666666666667
103905, 0.95833333333333, 1.58, 0.020833333333333
103906, 0.95833333333333, 1.6, 0.041666666666667
103907, 0.9375, 1.62, 0.041666666666667
103908, 0.95833333333333, 1.62, 0.020833333333333
103909, 0.95833333333333, 1.64, 0.041666666666667
103910, 0.9375, 1.66, 0.041666666666667
103911, 0.95833333333333, 1.66, 0.020833333333333
103912, 0.95833333333333, 1.68, 0.041666666666667
103913, 0.95833333333333, 1.52, 0.083333333333333
103914, 0.9375, 1.54, 0.083333333333333
103915, 0.95833333333333, 1.54, 0.0625
103916, 0.95833333333333, 1.56, 0.083333333333333
103917, 0.9375, 1.58, 0.083333333333333
103918, 0.95833333333333, 1.58, 0.0625
103919, 0.95833333333333, 1.6, 0.083333333333333
103920, 0.9375, 1.62, 0.083333333333333
103921, 0.95833333333333, 1.62, 0.0625
103922, 0.95833333333333, 1.64, 0.083333333333333
103923, 0.9375, 1.66, 0.083333333333333
103924, 0.95833333333333, 1.66, 0.0625
103925, 0.95833333333333, 1.68, 0.083333333333333
103926, 0.95833333333333, 1.52, 0.125
103927, 0.9375, 1.54, 0.125
103928, 0.95833333333333, 1.54, 0.10416666666667
103929, 0.95833333333333, 1.56, 0.125
103930, 0.9375, 1.58, 0.125
103931, 0.95833333333333, 1.58, 0.10416666666667
103932, 0.95833333333333, 1.6, 0.125
103933, 0.9375, 1.62, 0.125
103934, 0.95833333333333, 1.62, 0.10416666666667
103935, 0.95833333333333, 1.64, 0.125
103936, 0.9375, 1.66, 0.125
103937, 0.95833333333333, 1.66, 0.10416666666667
103938, 0.95833333333333, 1.68, 0.125
103939, 0.95833333333333, 1.52, 0.16666666666667
103940, 0.9375, 1.54, 0.16666666666667
103941, 0.95833333333333, 1.54, 0.14583333333333
103942, 0.95833333333333, 1.56, 0.16666666666667
103943, 0.9375, 1.58, 0.16666666666667
103944, 0.95833333333333, 1.58, 0.14583333333333
103945, 0.95833333333333, 1.6, 0.16666666666667
103946, 0.9375, 1.62, 0.16666666666667
103947, 0.95833333333333, 1.62, 0.14583333333333
103948, 0.95833333333333, 1.64, 0.16666666666667
103949, 0.9375, 1.66, 0.16666666666667
103950, 0.95833333333333, 1.66, 0.14583333333333
103951, 0.95833333333333, 1.68, 0.16666666666667
103952, 0.95833333333333, 1.52, 0.20833333333333
103953, 0.9375, 1.54, 0.20833333333333
103954, 0.95833333333333, 1.54, 0.1875
103955, 0.95833333333333, 1.56, 0.20833333333333
103956, 0.9375, 1.58, 0.20833333333333
103957, 0.95833333333333, 1.58, 0.1875
103958, 0.95833333333333, 1.6, 0.20833333333333
103959, 0.9375, 1.62, 0.20833333333333
103960, 0.95833333333333, 1.62, 0.1875
103961, 0.95833333333333, 1.64, 0.20833333333333
103962, 0.9375, 1.66, 0.20833333333333
103963, 0.95833333333333, 1.66, 0.1875
103964, 0.95833333333333, 1.68, 0.20833333333333
103965, 0.95833333333333, 1.52, 0.25
103966, 0.9375, 1.54, 0.25
103967, 0.95833333333333, 1.54, 0.22916666666667
103968, 0.95833333333333, 1.56, 0.25
103969, 0.9375, 1.58, 0.25
103970, 0.95833333333333, 1.58, 0.22916666666667
103971, 0.95833333333333, 1.6, 0.25
103972, 0.9375, 1.62, 0.25
103973, 0.95833333333333, 1.62, 0.22916666666667
103974, 0.95833333333333, 1.64, 0.25
103975, 0.9375, 1.66, 0.25
103976, 0.95833333333333, 1.66, 0.22916666666667
103977, 0.95833333333333, 1.68, 0.25
103978, 0.95833333333333, 1.52, 0.29166666666667
103979, 0.9375, 1.54, 0.29166666666667
103980, 0.95833333333333, 1.54, 0.27083333333333
103981, 0.95833333333333, 1.56, 0.29166666666667
103982, 0.9375, 1.58, 0.29166666666667
103983, 0.95833333333333, 1.58, 0.27083333333333
103984, 0.95833333333333, 1.6, 0.29166666666667
103985, 0.9375, 1.62, 0.29166666666667
103986, 0.95833333333333, 1.62, 0.27083333333333
103987, 0.95833333333333, 1.64, 0.29166666666667
103988, 0.9375, 1.66, 0.29166666666667
103989, 0.95833333333333, 1.66, 0.27083333333333
103990, 0.95833333333333, 1.68, 0.29166666666667
103991, 0.95833333333333, 1.52, 0.33333333333333
103992, 0.9375, 1.54, 0.33333333333333
103993, 0.95833333333333, 1.54, 0.3125
103994, 0.95833333333333, 1.56, 0.33333333333333
103995, 0.9375, 1.58, 0.33333333333333
103996, 0.95833333333333, 1.58, 0.3125
103997, 0.95833333333333, 1.6, 0.33333333333333
103998, 0.9375, 1.62, 0.33333333333333
103999, 0.95833333333333, 1.62, 0.3125
104000, 0.95833333333333, 1.64, 0.33333333333333
104001, 0.9375, 1.66, 0.33333333333333
104002, 0.95833333333333, 1.66, 0.3125
104003, 0.95833333333333, 1.68, 0.33333333333333
104004, 0.95833333333333, 1.52, 0.375
104005, 0.9375, 1.54, 0.375
104006, 0.95833333333333, 1.54, 0.35416666666667
104007, 0.95833333333333, 1.56, 0.375
104008, 0.9375, 1.58, 0.375
104009, 0.95833333333333, 1.58, 0.35416666666667
104010, 0.95833333333333, 1.6, 0.375
104011, 0.9375, 1.62, 0.375
104012, 0.95833333333333, 1.62, 0.35416666666667
104013, 0.95833333333333, 1.64, 0.375
104014, 0.9375, 1.66, 0.375
104015, 0.95833333333333, 1.66, 0.35416666666667
104016, 0.95833333333333, 1.68, 0.375
104017, 0.95833333333333, 1.52, 0.41666666666667
104018, 0.9375, 1.54, 0.41666666666667
104019, 0.95833333333333, 1.54, 0.39583333333333
104020, 0.95833333333333, 1.56, 0.41666666666667
104021, 0.9375, 1.58, 0.41666666666667
104022, 0.95833333333333, 1.58, 0.39583333333333
104023, 0.95833333333333, 1.6, 0.41666666666667
104024, 0.9375, 1.62, 0.41666666666667
104025, 0.95833333333333, 1.62, 0.39583333333333
104026, 0.95833333333333, 1.64, 0.41666666666667
104027, 0.9375, 1.66, 0.41666666666667
104028, 0.95833333333333, 1.66, 0.39583333333333
104029, 0.95833333333333, 1.68, 0.41666666666667
104030, 0.95833333333333, 1.52, 0.45833333333333
104031, 0.9375, 1.54, 0.45833333333333
104032, 0.95833333333333, 1.54, 0.4375
104033, 0.95833333333333, 1.56, 0.45833333333333
104034, 0.9375, 1.58, 0.45833333333333
104035, 0.95833333333333, 1.58, 0.4375
104036, 0.95833333333333, 1.6, 0.45833333333333
104037, 0.9375, 1.62, 0.45833333333333
104038, 0.95833333333333, 1.62, 0.4375
104039, 0.95833333333333, 1.64, 0.45833333333333
104040, 0.9375, 1.66, 0.45833333333333
104041, 0.95833333333333, 1.66, 0.4375
104042, 0.95833333333333, 1.68, 0.45833333333333
104043, 0.95833333333333, 1.54, 0.47916666666667
104044, 0.95833333333333, 1.58, 0.47916666666667
104045, 0.95833333333333, 1.62, 0.47916666666667
104046, 0.95833333333333, 1.66, 0.47916666666667
104047, 0.97916666666667, 1.54, 0.041666666666667
104048, 0.97916666666667, 1.58, 0.041666666666667
104049, 0.97916666666667, 1.62, 0.041666666666667
104050, 0.97916666666667, 1.66, 0.041666666666667
104051, 0.97916666666667, 1.54, 0.083333333333333
104052, 0.97916666666667, 1.58, 0.083333333333333
104053, 0.97916666666667, 1.62, 0.083333333333333
104054, 0.97916666666667, 1.66, 0.083333333333333
104055, 0.97916666666667, 1.54, 0.125
104056, 0.97916666666667, 1.58, 0.125
