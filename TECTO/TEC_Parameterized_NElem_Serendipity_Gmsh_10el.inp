17677, 2.0958333333333, 1.35, 0.20833333333333
17678, 2.1583333333333, 1.35, 0.1875
17679, 2.1375, 1.35, 0.20833333333333
17680, 2.1791666666667, 1.35, 0.20833333333333
17681, 1.2416666666667, 1.35, 0.22916666666667
17682, 1.2208333333333, 1.35, 0.25
17683, 1.2833333333333, 1.35, 0.22916666666667
17684, 1.2625, 1.35, 0.25
17685, 1.325, 1.35, 0.22916666666667
17686, 1.3041666666667, 1.35, 0.25
17687, 1.3666666666667, 1.35, 0.22916666666667
17688, 1.3458333333333, 1.35, 0.25
17689, 1.4083333333333, 1.35, 0.22916666666667
17690, 1.3875, 1.35, 0.25
17691, 1.45, 1.35, 0.22916666666667
17692, 1.4291666666667, 1.35, 0.25
17693, 1.4916666666667, 1.35, 0.22916666666667
17694, 1.4708333333333, 1.35, 0.25
17695, 1.5333333333333, 1.35, 0.22916666666667
17696, 1.5125, 1.35, 0.25
17697, 1.575, 1.35, 0.22916666666667
17698, 1.5541666666667, 1.35, 0.25
17699, 1.6166666666667, 1.35, 0.22916666666667
17700, 1.5958333333333, 1.35, 0.25
17701, 1.6583333333333, 1.35, 0.22916666666667
17702, 1.6375, 1.35, 0.25
17703, 1.7, 1.35, 0.22916666666667
17704, 1.6791666666667, 1.35, 0.25
17705, 1.7416666666667, 1.35, 0.22916666666667
17706, 1.7208333333333, 1.35, 0.25
17707, 1.7833333333333, 1.35, 0.22916666666667
17708, 1.7625, 1.35, 0.25
17709, 1.825, 1.35, 0.22916666666667
17710, 1.8041666666667, 1.35, 0.25
17711, 1.8666666666667, 1.35, 0.22916666666667
17712, 1.8458333333333, 1.35, 0.25
17713, 1.9083333333333, 1.35, 0.22916666666667
17714, 1.8875, 1.35, 0.25
17715, 1.95, 1.35, 0.22916666666667
17716, 1.9291666666667, 1.35, 0.25
17717, 1.9916666666667, 1.35, 0.22916666666667
17718, 1.9708333333333, 1.35, 0.25
17719, 2.0333333333333, 1.35, 0.22916666666667
17720, 2.0125, 1.35, 0.25
17721, 2.075, 1.35, 0.22916666666667
17722, 2.0541666666667, 1.35, 0.25
17723, 2.1166666666667, 1.35, 0.22916666666667
17724, 2.0958333333333, 1.35, 0.25
17725, 2.1583333333333, 1.35, 0.22916666666667
17726, 2.1375, 1.35, 0.25
17727, 2.1791666666667, 1.35, 0.25
17728, 1.2416666666667, 1.35, 0.27083333333333
17729, 1.2208333333333, 1.35, 0.29166666666667
17730, 1.2833333333333, 1.35, 0.27083333333333
17731, 1.2625, 1.35, 0.29166666666667
17732, 1.325, 1.35, 0.27083333333333
17733, 1.3041666666667, 1.35, 0.29166666666667
17734, 1.3666666666667, 1.35, 0.27083333333333
17735, 1.3458333333333, 1.35, 0.29166666666667
17736, 1.4083333333333, 1.35, 0.27083333333333
17737, 1.3875, 1.35, 0.29166666666667
17738, 1.45, 1.35, 0.27083333333333
17739, 1.4291666666667, 1.35, 0.29166666666667
17740, 1.4916666666667, 1.35, 0.27083333333333
17741, 1.4708333333333, 1.35, 0.29166666666667
17742, 1.5333333333333, 1.35, 0.27083333333333
17743, 1.5125, 1.35, 0.29166666666667
17744, 1.575, 1.35, 0.27083333333333
17745, 1.5541666666667, 1.35, 0.29166666666667
17746, 1.6166666666667, 1.35, 0.27083333333333
17747, 1.5958333333333, 1.35, 0.29166666666667
17748, 1.6583333333333, 1.35, 0.27083333333333
17749, 1.6375, 1.35, 0.29166666666667
17750, 1.7, 1.35, 0.27083333333333
17751, 1.6791666666667, 1.35, 0.29166666666667
17752, 1.7416666666667, 1.35, 0.27083333333333
17753, 1.7208333333333, 1.35, 0.29166666666667
17754, 1.7833333333333, 1.35, 0.27083333333333
17755, 1.7625, 1.35, 0.29166666666667
17756, 1.825, 1.35, 0.27083333333333
17757, 1.8041666666667, 1.35, 0.29166666666667
17758, 1.8666666666667, 1.35, 0.27083333333333
17759, 1.8458333333333, 1.35, 0.29166666666667
17760, 1.9083333333333, 1.35, 0.27083333333333
17761, 1.8875, 1.35, 0.29166666666667
17762, 1.95, 1.35, 0.27083333333333
17763, 1.9291666666667, 1.35, 0.29166666666667
17764, 1.9916666666667, 1.35, 0.27083333333333
17765, 1.9708333333333, 1.35, 0.29166666666667
17766, 2.0333333333333, 1.35, 0.27083333333333
17767, 2.0125, 1.35, 0.29166666666667
17768, 2.075, 1.35, 0.27083333333333
17769, 2.0541666666667, 1.35, 0.29166666666667
17770, 2.1166666666667, 1.35, 0.27083333333333
17771, 2.0958333333333, 1.35, 0.29166666666667
17772, 2.1583333333333, 1.35, 0.27083333333333
17773, 2.1375, 1.35, 0.29166666666667
17774, 2.1791666666667, 1.35, 0.29166666666667
17775, 1.2416666666667, 1.35, 0.3125
17776, 1.2208333333333, 1.35, 0.33333333333333
17777, 1.2833333333333, 1.35, 0.3125
17778, 1.2625, 1.35, 0.33333333333333
17779, 1.325, 1.35, 0.3125
17780, 1.3041666666667, 1.35, 0.33333333333333
17781, 1.3666666666667, 1.35, 0.3125
17782, 1.3458333333333, 1.35, 0.33333333333333
17783, 1.4083333333333, 1.35, 0.3125
17784, 1.3875, 1.35, 0.33333333333333
17785, 1.45, 1.35, 0.3125
17786, 1.4291666666667, 1.35, 0.33333333333333
17787, 1.4916666666667, 1.35, 0.3125
17788, 1.4708333333333, 1.35, 0.33333333333333
17789, 1.5333333333333, 1.35, 0.3125
17790, 1.5125, 1.35, 0.33333333333333
17791, 1.575, 1.35, 0.3125
17792, 1.5541666666667, 1.35, 0.33333333333333
17793, 1.6166666666667, 1.35, 0.3125
17794, 1.5958333333333, 1.35, 0.33333333333333
17795, 1.6583333333333, 1.35, 0.3125
17796, 1.6375, 1.35, 0.33333333333333
17797, 1.7, 1.35, 0.3125
17798, 1.6791666666667, 1.35, 0.33333333333333
17799, 1.7416666666667, 1.35, 0.3125
17800, 1.7208333333333, 1.35, 0.33333333333333
17801, 1.7833333333333, 1.35, 0.3125
17802, 1.7625, 1.35, 0.33333333333333
17803, 1.825, 1.35, 0.3125
17804, 1.8041666666667, 1.35, 0.33333333333333
17805, 1.8666666666667, 1.35, 0.3125
17806, 1.8458333333333, 1.35, 0.33333333333333
17807, 1.9083333333333, 1.35, 0.3125
17808, 1.8875, 1.35, 0.33333333333333
17809, 1.95, 1.35, 0.3125
17810, 1.9291666666667, 1.35, 0.33333333333333
17811, 1.9916666666667, 1.35, 0.3125
17812, 1.9708333333333, 1.35, 0.33333333333333
17813, 2.0333333333333, 1.35, 0.3125
17814, 2.0125, 1.35, 0.33333333333333
17815, 2.075, 1.35, 0.3125
17816, 2.0541666666667, 1.35, 0.33333333333333
17817, 2.1166666666667, 1.35, 0.3125
17818, 2.0958333333333, 1.35, 0.33333333333333
17819, 2.1583333333333, 1.35, 0.3125
17820, 2.1375, 1.35, 0.33333333333333
17821, 2.1791666666667, 1.35, 0.33333333333333
17822, 1.2416666666667, 1.35, 0.35416666666667
17823, 1.2208333333333, 1.35, 0.375
17824, 1.2833333333333, 1.35, 0.35416666666667
17825, 1.2625, 1.35, 0.375
17826, 1.325, 1.35, 0.35416666666667
17827, 1.3041666666667, 1.35, 0.375
17828, 1.3666666666667, 1.35, 0.35416666666667
17829, 1.3458333333333, 1.35, 0.375
17830, 1.4083333333333, 1.35, 0.35416666666667
17831, 1.3875, 1.35, 0.375
17832, 1.45, 1.35, 0.35416666666667
17833, 1.4291666666667, 1.35, 0.375
17834, 1.4916666666667, 1.35, 0.35416666666667
17835, 1.4708333333333, 1.35, 0.375
17836, 1.5333333333333, 1.35, 0.35416666666667
17837, 1.5125, 1.35, 0.375
17838, 1.575, 1.35, 0.35416666666667
17839, 1.5541666666667, 1.35, 0.375
17840, 1.6166666666667, 1.35, 0.35416666666667
17841, 1.5958333333333, 1.35, 0.375
17842, 1.6583333333333, 1.35, 0.35416666666667
17843, 1.6375, 1.35, 0.375
17844, 1.7, 1.35, 0.35416666666667
17845, 1.6791666666667, 1.35, 0.375
17846, 1.7416666666667, 1.35, 0.35416666666667
17847, 1.7208333333333, 1.35, 0.375
17848, 1.7833333333333, 1.35, 0.35416666666667
17849, 1.7625, 1.35, 0.375
17850, 1.825, 1.35, 0.35416666666667
17851, 1.8041666666667, 1.35, 0.375
17852, 1.8666666666667, 1.35, 0.35416666666667
17853, 1.8458333333333, 1.35, 0.375
17854, 1.9083333333333, 1.35, 0.35416666666667
17855, 1.8875, 1.35, 0.375
17856, 1.95, 1.35, 0.35416666666667
17857, 1.9291666666667, 1.35, 0.375
17858, 1.9916666666667, 1.35, 0.35416666666667
17859, 1.9708333333333, 1.35, 0.375
17860, 2.0333333333333, 1.35, 0.35416666666667
17861, 2.0125, 1.35, 0.375
17862, 2.075, 1.35, 0.35416666666667
17863, 2.0541666666667, 1.35, 0.375
17864, 2.1166666666667, 1.35, 0.35416666666667
17865, 2.0958333333333, 1.35, 0.375
17866, 2.1583333333333, 1.35, 0.35416666666667
17867, 2.1375, 1.35, 0.375
17868, 2.1791666666667, 1.35, 0.375
17869, 1.2416666666667, 1.35, 0.39583333333333
17870, 1.2208333333333, 1.35, 0.41666666666667
17871, 1.2833333333333, 1.35, 0.39583333333333
17872, 1.2625, 1.35, 0.41666666666667
17873, 1.325, 1.35, 0.39583333333333
17874, 1.3041666666667, 1.35, 0.41666666666667
17875, 1.3666666666667, 1.35, 0.39583333333333
17876, 1.3458333333333, 1.35, 0.41666666666667
17877, 1.4083333333333, 1.35, 0.39583333333333
17878, 1.3875, 1.35, 0.41666666666667
17879, 1.45, 1.35, 0.39583333333333
17880, 1.4291666666667, 1.35, 0.41666666666667
17881, 1.4916666666667, 1.35, 0.39583333333333
17882, 1.4708333333333, 1.35, 0.41666666666667
17883, 1.5333333333333, 1.35, 0.39583333333333
17884, 1.5125, 1.35, 0.41666666666667
17885, 1.575, 1.35, 0.39583333333333
17886, 1.5541666666667, 1.35, 0.41666666666667
17887, 1.6166666666667, 1.35, 0.39583333333333
17888, 1.5958333333333, 1.35, 0.41666666666667
17889, 1.6583333333333, 1.35, 0.39583333333333
17890, 1.6375, 1.35, 0.41666666666667
17891, 1.7, 1.35, 0.39583333333333
17892, 1.6791666666667, 1.35, 0.41666666666667
17893, 1.7416666666667, 1.35, 0.39583333333333
17894, 1.7208333333333, 1.35, 0.41666666666667
17895, 1.7833333333333, 1.35, 0.39583333333333
17896, 1.7625, 1.35, 0.41666666666667
17897, 1.825, 1.35, 0.39583333333333
17898, 1.8041666666667, 1.35, 0.41666666666667
17899, 1.8666666666667, 1.35, 0.39583333333333
17900, 1.8458333333333, 1.35, 0.41666666666667
17901, 1.9083333333333, 1.35, 0.39583333333333
17902, 1.8875, 1.35, 0.41666666666667
17903, 1.95, 1.35, 0.39583333333333
17904, 1.9291666666667, 1.35, 0.41666666666667
17905, 1.9916666666667, 1.35, 0.39583333333333
17906, 1.9708333333333, 1.35, 0.41666666666667
17907, 2.0333333333333, 1.35, 0.39583333333333
17908, 2.0125, 1.35, 0.41666666666667
17909, 2.075, 1.35, 0.39583333333333
17910, 2.0541666666667, 1.35, 0.41666666666667
17911, 2.1166666666667, 1.35, 0.39583333333333
17912, 2.0958333333333, 1.35, 0.41666666666667
17913, 2.1583333333333, 1.35, 0.39583333333333
17914, 2.1375, 1.35, 0.41666666666667
17915, 2.1791666666667, 1.35, 0.41666666666667
17916, 1.2416666666667, 1.35, 0.4375
17917, 1.2208333333333, 1.35, 0.45833333333333
17918, 1.2833333333333, 1.35, 0.4375
17919, 1.2625, 1.35, 0.45833333333333
17920, 1.325, 1.35, 0.4375
17921, 1.3041666666667, 1.35, 0.45833333333333
17922, 1.3666666666667, 1.35, 0.4375
17923, 1.3458333333333, 1.35, 0.45833333333333
17924, 1.4083333333333, 1.35, 0.4375
17925, 1.3875, 1.35, 0.45833333333333
17926, 1.45, 1.35, 0.4375
17927, 1.4291666666667, 1.35, 0.45833333333333
17928, 1.4916666666667, 1.35, 0.4375
17929, 1.4708333333333, 1.35, 0.45833333333333
17930, 1.5333333333333, 1.35, 0.4375
17931, 1.5125, 1.35, 0.45833333333333
17932, 1.575, 1.35, 0.4375
17933, 1.5541666666667, 1.35, 0.45833333333333
17934, 1.6166666666667, 1.35, 0.4375
17935, 1.5958333333333, 1.35, 0.45833333333333
17936, 1.6583333333333, 1.35, 0.4375
17937, 1.6375, 1.35, 0.45833333333333
17938, 1.7, 1.35, 0.4375
17939, 1.6791666666667, 1.35, 0.45833333333333
17940, 1.7416666666667, 1.35, 0.4375
17941, 1.7208333333333, 1.35, 0.45833333333333
17942, 1.7833333333333, 1.35, 0.4375
17943, 1.7625, 1.35, 0.45833333333333
17944, 1.825, 1.35, 0.4375
17945, 1.8041666666667, 1.35, 0.45833333333333
17946, 1.8666666666667, 1.35, 0.4375
17947, 1.8458333333333, 1.35, 0.45833333333333
17948, 1.9083333333333, 1.35, 0.4375
17949, 1.8875, 1.35, 0.45833333333333
17950, 1.95, 1.35, 0.4375
17951, 1.9291666666667, 1.35, 0.45833333333333
17952, 1.9916666666667, 1.35, 0.4375
17953, 1.9708333333333, 1.35, 0.45833333333333
17954, 2.0333333333333, 1.35, 0.4375
17955, 2.0125, 1.35, 0.45833333333333
17956, 2.075, 1.35, 0.4375
17957, 2.0541666666667, 1.35, 0.45833333333333
17958, 2.1166666666667, 1.35, 0.4375
17959, 2.0958333333333, 1.35, 0.45833333333333
17960, 2.1583333333333, 1.35, 0.4375
17961, 2.1375, 1.35, 0.45833333333333
17962, 2.1791666666667, 1.35, 0.45833333333333
17963, 1.2416666666667, 1.35, 0.47916666666667
17964, 1.2833333333333, 1.35, 0.47916666666667
17965, 1.325, 1.35, 0.47916666666667
17966, 1.3666666666667, 1.35, 0.47916666666667
17967, 1.4083333333333, 1.35, 0.47916666666667
17968, 1.45, 1.35, 0.47916666666667
17969, 1.4916666666667, 1.35, 0.47916666666667
17970, 1.5333333333333, 1.35, 0.47916666666667
17971, 1.575, 1.35, 0.47916666666667
17972, 1.6166666666667, 1.35, 0.47916666666667
17973, 1.6583333333333, 1.35, 0.47916666666667
17974, 1.7, 1.35, 0.47916666666667
17975, 1.7416666666667, 1.35, 0.47916666666667
17976, 1.7833333333333, 1.35, 0.47916666666667
17977, 1.825, 1.35, 0.47916666666667
17978, 1.8666666666667, 1.35, 0.47916666666667
17979, 1.9083333333333, 1.35, 0.47916666666667
17980, 1.95, 1.35, 0.47916666666667
17981, 1.9916666666667, 1.35, 0.47916666666667
17982, 2.0333333333333, 1.35, 0.47916666666667
17983, 2.075, 1.35, 0.47916666666667
17984, 2.1166666666667, 1.35, 0.47916666666667
17985, 2.1583333333333, 1.35, 0.47916666666667
17986, 1.2416666666667, 1.3, 0.5
17987, 1.2416666666667, 1.25, 0.5
17988, 1.2416666666667, 1.2, 0.5
17989, 1.2416666666667, 1.15, 0.5
17990, 1.2416666666667, 1.1, 0.5
17991, 1.2416666666667, 1.05, 0.5
17992, 1.2416666666667, 1, 0.5
17993, 1.2416666666667, 0.95, 0.5
17994, 1.2416666666667, 0.9, 0.5
17995, 1.2416666666667, 0.85, 0.5
17996, 1.2416666666667, 0.8, 0.5
17997, 1.2416666666667, 0.75, 0.5
17998, 1.2416666666667, 0.7, 0.5
17999, 1.2416666666667, 0.65, 0.5
18000, 1.2416666666667, 0.6, 0.5
18001, 1.2416666666667, 0.55, 0.5
18002, 1.2416666666667, 0.5, 0.5
18003, 1.2416666666667, 0.45, 0.5
18004, 1.2416666666667, 0.4, 0.5
18005, 1.2416666666667, 0.35, 0.5
18006, 1.2416666666667, 0.3, 0.5
18007, 1.2416666666667, 0.25, 0.5
18008, 1.2416666666667, 0.2, 0.5
18009, 1.2833333333333, 1.3, 0.5
18010, 1.2833333333333, 1.25, 0.5
18011, 1.2833333333333, 1.2, 0.5
18012, 1.2833333333333, 1.15, 0.5
18013, 1.2833333333333, 1.1, 0.5
18014, 1.2833333333333, 1.05, 0.5
18015, 1.2833333333333, 1, 0.5
18016, 1.2833333333333, 0.95, 0.5
18017, 1.2833333333333, 0.9, 0.5
18018, 1.2833333333333, 0.85, 0.5
18019, 1.2833333333333, 0.8, 0.5
18020, 1.2833333333333, 0.75, 0.5
18021, 1.2833333333333, 0.7, 0.5
18022, 1.2833333333333, 0.65, 0.5
18023, 1.2833333333333, 0.6, 0.5
18024, 1.2833333333333, 0.55, 0.5
18025, 1.2833333333333, 0.5, 0.5
18026, 1.2833333333333, 0.45, 0.5
18027, 1.2833333333333, 0.4, 0.5
18028, 1.2833333333333, 0.35, 0.5
18029, 1.2833333333333, 0.3, 0.5
18030, 1.2833333333333, 0.25, 0.5
18031, 1.2833333333333, 0.2, 0.5
18032, 1.325, 1.3, 0.5
18033, 1.325, 1.25, 0.5
18034, 1.325, 1.2, 0.5
18035, 1.325, 1.15, 0.5
18036, 1.325, 1.1, 0.5
18037, 1.325, 1.05, 0.5
18038, 1.325, 1, 0.5
18039, 1.325, 0.95, 0.5
18040, 1.325, 0.9, 0.5
18041, 1.325, 0.85, 0.5
18042, 1.325, 0.8, 0.5
18043, 1.325, 0.75, 0.5
18044, 1.325, 0.7, 0.5
18045, 1.325, 0.65, 0.5
18046, 1.325, 0.6, 0.5
18047, 1.325, 0.55, 0.5
18048, 1.325, 0.5, 0.5
18049, 1.325, 0.45, 0.5
18050, 1.325, 0.4, 0.5
18051, 1.325, 0.35, 0.5
18052, 1.325, 0.3, 0.5
18053, 1.325, 0.25, 0.5
18054, 1.325, 0.2, 0.5
18055, 1.3666666666667, 1.3, 0.5
18056, 1.3666666666667, 1.25, 0.5
18057, 1.3666666666667, 1.2, 0.5
18058, 1.3666666666667, 1.15, 0.5
18059, 1.3666666666667, 1.1, 0.5
18060, 1.3666666666667, 1.05, 0.5
18061, 1.3666666666667, 1, 0.5
18062, 1.3666666666667, 0.95, 0.5
18063, 1.3666666666667, 0.9, 0.5
18064, 1.3666666666667, 0.85, 0.5
18065, 1.3666666666667, 0.8, 0.5
18066, 1.3666666666667, 0.75, 0.5
18067, 1.3666666666667, 0.7, 0.5
18068, 1.3666666666667, 0.65, 0.5
18069, 1.3666666666667, 0.6, 0.5
18070, 1.3666666666667, 0.55, 0.5
18071, 1.3666666666667, 0.5, 0.5
18072, 1.3666666666667, 0.45, 0.5
18073, 1.3666666666667, 0.4, 0.5
18074, 1.3666666666667, 0.35, 0.5
18075, 1.3666666666667, 0.3, 0.5
18076, 1.3666666666667, 0.25, 0.5
18077, 1.3666666666667, 0.2, 0.5
18078, 1.4083333333333, 1.3, 0.5
18079, 1.4083333333333, 1.25, 0.5
18080, 1.4083333333333, 1.2, 0.5
18081, 1.4083333333333, 1.15, 0.5
18082, 1.4083333333333, 1.1, 0.5
18083, 1.4083333333333, 1.05, 0.5
18084, 1.4083333333333, 1, 0.5
18085, 1.4083333333333, 0.95, 0.5
18086, 1.4083333333333, 0.9, 0.5
18087, 1.4083333333333, 0.85, 0.5
18088, 1.4083333333333, 0.8, 0.5
18089, 1.4083333333333, 0.75, 0.5
18090, 1.4083333333333, 0.7, 0.5
18091, 1.4083333333333, 0.65, 0.5
18092, 1.4083333333333, 0.6, 0.5
18093, 1.4083333333333, 0.55, 0.5
18094, 1.4083333333333, 0.5, 0.5
18095, 1.4083333333333, 0.45, 0.5
18096, 1.4083333333333, 0.4, 0.5
18097, 1.4083333333333, 0.35, 0.5
18098, 1.4083333333333, 0.3, 0.5
18099, 1.4083333333333, 0.25, 0.5
18100, 1.4083333333333, 0.2, 0.5
18101, 1.45, 1.3, 0.5
18102, 1.45, 1.25, 0.5
18103, 1.45, 1.2, 0.5
18104, 1.45, 1.15, 0.5
18105, 1.45, 1.1, 0.5
18106, 1.45, 1.05, 0.5
18107, 1.45, 1, 0.5
18108, 1.45, 0.95, 0.5
18109, 1.45, 0.9, 0.5
18110, 1.45, 0.85, 0.5
18111, 1.45, 0.8, 0.5
18112, 1.45, 0.75, 0.5
18113, 1.45, 0.7, 0.5
18114, 1.45, 0.65, 0.5
18115, 1.45, 0.6, 0.5
18116, 1.45, 0.55, 0.5
18117, 1.45, 0.5, 0.5
18118, 1.45, 0.45, 0.5
18119, 1.45, 0.4, 0.5
18120, 1.45, 0.35, 0.5
18121, 1.45, 0.3, 0.5
18122, 1.45, 0.25, 0.5
18123, 1.45, 0.2, 0.5
18124, 1.4916666666667, 1.3, 0.5
18125, 1.4916666666667, 1.25, 0.5
18126, 1.4916666666667, 1.2, 0.5
18127, 1.4916666666667, 1.15, 0.5
18128, 1.4916666666667, 1.1, 0.5
18129, 1.4916666666667, 1.05, 0.5
18130, 1.4916666666667, 1, 0.5
18131, 1.4916666666667, 0.95, 0.5
18132, 1.4916666666667, 0.9, 0.5
18133, 1.4916666666667, 0.85, 0.5
18134, 1.4916666666667, 0.8, 0.5
18135, 1.4916666666667, 0.75, 0.5
18136, 1.4916666666667, 0.7, 0.5
18137, 1.4916666666667, 0.65, 0.5
18138, 1.4916666666667, 0.6, 0.5
18139, 1.4916666666667, 0.55, 0.5
18140, 1.4916666666667, 0.5, 0.5
18141, 1.4916666666667, 0.45, 0.5
18142, 1.4916666666667, 0.4, 0.5
18143, 1.4916666666667, 0.35, 0.5
18144, 1.4916666666667, 0.3, 0.5
18145, 1.4916666666667, 0.25, 0.5
18146, 1.4916666666667, 0.2, 0.5
18147, 1.5333333333333, 1.3, 0.5
18148, 1.5333333333333, 1.25, 0.5
18149, 1.5333333333333, 1.2, 0.5
18150, 1.5333333333333, 1.15, 0.5
18151, 1.5333333333333, 1.1, 0.5
18152, 1.5333333333333, 1.05, 0.5
18153, 1.5333333333333, 1, 0.5
18154, 1.5333333333333, 0.95, 0.5
18155, 1.5333333333333, 0.9, 0.5
18156, 1.5333333333333, 0.85, 0.5
18157, 1.5333333333333, 0.8, 0.5
18158, 1.5333333333333, 0.75, 0.5
18159, 1.5333333333333, 0.7, 0.5
18160, 1.5333333333333, 0.65, 0.5
18161, 1.5333333333333, 0.6, 0.5
18162, 1.5333333333333, 0.55, 0.5
18163, 1.5333333333333, 0.5, 0.5
18164, 1.5333333333333, 0.45, 0.5
18165, 1.5333333333333, 0.4, 0.5
18166, 1.5333333333333, 0.35, 0.5
18167, 1.5333333333333, 0.3, 0.5
18168, 1.5333333333333, 0.25, 0.5
18169, 1.5333333333333, 0.2, 0.5
18170, 1.575, 1.3, 0.5
18171, 1.575, 1.25, 0.5
18172, 1.575, 1.2, 0.5
18173, 1.575, 1.15, 0.5
18174, 1.575, 1.1, 0.5
18175, 1.575, 1.05, 0.5
18176, 1.575, 1, 0.5
18177, 1.575, 0.95, 0.5
18178, 1.575, 0.9, 0.5
18179, 1.575, 0.85, 0.5
18180, 1.575, 0.8, 0.5
18181, 1.575, 0.75, 0.5
18182, 1.575, 0.7, 0.5
18183, 1.575, 0.65, 0.5
18184, 1.575, 0.6, 0.5
18185, 1.575, 0.55, 0.5
18186, 1.575, 0.5, 0.5
18187, 1.575, 0.45, 0.5
18188, 1.575, 0.4, 0.5
18189, 1.575, 0.35, 0.5
18190, 1.575, 0.3, 0.5
18191, 1.575, 0.25, 0.5
18192, 1.575, 0.2, 0.5
18193, 1.6166666666667, 1.3, 0.5
18194, 1.6166666666667, 1.25, 0.5
18195, 1.6166666666667, 1.2, 0.5
18196, 1.6166666666667, 1.15, 0.5
18197, 1.6166666666667, 1.1, 0.5
18198, 1.6166666666667, 1.05, 0.5
18199, 1.6166666666667, 1, 0.5
18200, 1.6166666666667, 0.95, 0.5
18201, 1.6166666666667, 0.9, 0.5
18202, 1.6166666666667, 0.85, 0.5
18203, 1.6166666666667, 0.8, 0.5
18204, 1.6166666666667, 0.75, 0.5
18205, 1.6166666666667, 0.7, 0.5
18206, 1.6166666666667, 0.65, 0.5
18207, 1.6166666666667, 0.6, 0.5
18208, 1.6166666666667, 0.55, 0.5
18209, 1.6166666666667, 0.5, 0.5
18210, 1.6166666666667, 0.45, 0.5
18211, 1.6166666666667, 0.4, 0.5
18212, 1.6166666666667, 0.35, 0.5
18213, 1.6166666666667, 0.3, 0.5
18214, 1.6166666666667, 0.25, 0.5
18215, 1.6166666666667, 0.2, 0.5
18216, 1.6583333333333, 1.3, 0.5
18217, 1.6583333333333, 1.25, 0.5
18218, 1.6583333333333, 1.2, 0.5
18219, 1.6583333333333, 1.15, 0.5
18220, 1.6583333333333, 1.1, 0.5
18221, 1.6583333333333, 1.05, 0.5
18222, 1.6583333333333, 1, 0.5
18223, 1.6583333333333, 0.95, 0.5
18224, 1.6583333333333, 0.9, 0.5
18225, 1.6583333333333, 0.85, 0.5
18226, 1.6583333333333, 0.8, 0.5
18227, 1.6583333333333, 0.75, 0.5
18228, 1.6583333333333, 0.7, 0.5
18229, 1.6583333333333, 0.65, 0.5
18230, 1.6583333333333, 0.6, 0.5
18231, 1.6583333333333, 0.55, 0.5
18232, 1.6583333333333, 0.5, 0.5
18233, 1.6583333333333, 0.45, 0.5
18234, 1.6583333333333, 0.4, 0.5
18235, 1.6583333333333, 0.35, 0.5
18236, 1.6583333333333, 0.3, 0.5
18237, 1.6583333333333, 0.25, 0.5
18238, 1.6583333333333, 0.2, 0.5
18239, 1.7, 1.3, 0.5
18240, 1.7, 1.25, 0.5
18241, 1.7, 1.2, 0.5
18242, 1.7, 1.15, 0.5
18243, 1.7, 1.1, 0.5
18244, 1.7, 1.05, 0.5
18245, 1.7, 1, 0.5
18246, 1.7, 0.95, 0.5
18247, 1.7, 0.9, 0.5
18248, 1.7, 0.85, 0.5
18249, 1.7, 0.8, 0.5
18250, 1.7, 0.75, 0.5
18251, 1.7, 0.7, 0.5
18252, 1.7, 0.65, 0.5
18253, 1.7, 0.6, 0.5
18254, 1.7, 0.55, 0.5
18255, 1.7, 0.5, 0.5
18256, 1.7, 0.45, 0.5
18257, 1.7, 0.4, 0.5
18258, 1.7, 0.35, 0.5
18259, 1.7, 0.3, 0.5
18260, 1.7, 0.25, 0.5
18261, 1.7, 0.2, 0.5
18262, 1.7416666666667, 1.3, 0.5
18263, 1.7416666666667, 1.25, 0.5
18264, 1.7416666666667, 1.2, 0.5
18265, 1.7416666666667, 1.15, 0.5
18266, 1.7416666666667, 1.1, 0.5
18267, 1.7416666666667, 1.05, 0.5
18268, 1.7416666666667, 1, 0.5
18269, 1.7416666666667, 0.95, 0.5
18270, 1.7416666666667, 0.9, 0.5
18271, 1.7416666666667, 0.85, 0.5
18272, 1.7416666666667, 0.8, 0.5
18273, 1.7416666666667, 0.75, 0.5
18274, 1.7416666666667, 0.7, 0.5
18275, 1.7416666666667, 0.65, 0.5
18276, 1.7416666666667, 0.6, 0.5
18277, 1.7416666666667, 0.55, 0.5
18278, 1.7416666666667, 0.5, 0.5
18279, 1.7416666666667, 0.45, 0.5
18280, 1.7416666666667, 0.4, 0.5
18281, 1.7416666666667, 0.35, 0.5
18282, 1.7416666666667, 0.3, 0.5
18283, 1.7416666666667, 0.25, 0.5
18284, 1.7416666666667, 0.2, 0.5
18285, 1.7833333333333, 1.3, 0.5
18286, 1.7833333333333, 1.25, 0.5
18287, 1.7833333333333, 1.2, 0.5
18288, 1.7833333333333, 1.15, 0.5
18289, 1.7833333333333, 1.1, 0.5
18290, 1.7833333333333, 1.05, 0.5
18291, 1.7833333333333, 1, 0.5
18292, 1.7833333333333, 0.95, 0.5
18293, 1.7833333333333, 0.9, 0.5
18294, 1.7833333333333, 0.85, 0.5
18295, 1.7833333333333, 0.8, 0.5
18296, 1.7833333333333, 0.75, 0.5
18297, 1.7833333333333, 0.7, 0.5
18298, 1.7833333333333, 0.65, 0.5
18299, 1.7833333333333, 0.6, 0.5
18300, 1.7833333333333, 0.55, 0.5
18301, 1.7833333333333, 0.5, 0.5
18302, 1.7833333333333, 0.45, 0.5
18303, 1.7833333333333, 0.4, 0.5
18304, 1.7833333333333, 0.35, 0.5
18305, 1.7833333333333, 0.3, 0.5
18306, 1.7833333333333, 0.25, 0.5
18307, 1.7833333333333, 0.2, 0.5
18308, 1.825, 1.3, 0.5
18309, 1.825, 1.25, 0.5
18310, 1.825, 1.2, 0.5
18311, 1.825, 1.15, 0.5
18312, 1.825, 1.1, 0.5
18313, 1.825, 1.05, 0.5
18314, 1.825, 1, 0.5
18315, 1.825, 0.95, 0.5
18316, 1.825, 0.9, 0.5
18317, 1.825, 0.85, 0.5
18318, 1.825, 0.8, 0.5
18319, 1.825, 0.75, 0.5
18320, 1.825, 0.7, 0.5
18321, 1.825, 0.65, 0.5
18322, 1.825, 0.6, 0.5
18323, 1.825, 0.55, 0.5
18324, 1.825, 0.5, 0.5
18325, 1.825, 0.45, 0.5
18326, 1.825, 0.4, 0.5
18327, 1.825, 0.35, 0.5
18328, 1.825, 0.3, 0.5
18329, 1.825, 0.25, 0.5
18330, 1.825, 0.2, 0.5
18331, 1.8666666666667, 1.3, 0.5
18332, 1.8666666666667, 1.25, 0.5
18333, 1.8666666666667, 1.2, 0.5
18334, 1.8666666666667, 1.15, 0.5
18335, 1.8666666666667, 1.1, 0.5
18336, 1.8666666666667, 1.05, 0.5
18337, 1.8666666666667, 1, 0.5
18338, 1.8666666666667, 0.95, 0.5
18339, 1.8666666666667, 0.9, 0.5
18340, 1.8666666666667, 0.85, 0.5
18341, 1.8666666666667, 0.8, 0.5
18342, 1.8666666666667, 0.75, 0.5
18343, 1.8666666666667, 0.7, 0.5
18344, 1.8666666666667, 0.65, 0.5
18345, 1.8666666666667, 0.6, 0.5
18346, 1.8666666666667, 0.55, 0.5
18347, 1.8666666666667, 0.5, 0.5
18348, 1.8666666666667, 0.45, 0.5
18349, 1.8666666666667, 0.4, 0.5
18350, 1.8666666666667, 0.35, 0.5
18351, 1.8666666666667, 0.3, 0.5
18352, 1.8666666666667, 0.25, 0.5
18353, 1.8666666666667, 0.2, 0.5
18354, 1.9083333333333, 1.3, 0.5
18355, 1.9083333333333, 1.25, 0.5
18356, 1.9083333333333, 1.2, 0.5
18357, 1.9083333333333, 1.15, 0.5
18358, 1.9083333333333, 1.1, 0.5
18359, 1.9083333333333, 1.05, 0.5
18360, 1.9083333333333, 1, 0.5
18361, 1.9083333333333, 0.95, 0.5
18362, 1.9083333333333, 0.9, 0.5
18363, 1.9083333333333, 0.85, 0.5
18364, 1.9083333333333, 0.8, 0.5
18365, 1.9083333333333, 0.75, 0.5
18366, 1.9083333333333, 0.7, 0.5
18367, 1.9083333333333, 0.65, 0.5
18368, 1.9083333333333, 0.6, 0.5
18369, 1.9083333333333, 0.55, 0.5
18370, 1.9083333333333, 0.5, 0.5
18371, 1.9083333333333, 0.45, 0.5
18372, 1.9083333333333, 0.4, 0.5
18373, 1.9083333333333, 0.35, 0.5
18374, 1.9083333333333, 0.3, 0.5
18375, 1.9083333333333, 0.25, 0.5
18376, 1.9083333333333, 0.2, 0.5
18377, 1.95, 1.3, 0.5
18378, 1.95, 1.25, 0.5
18379, 1.95, 1.2, 0.5
18380, 1.95, 1.15, 0.5
18381, 1.95, 1.1, 0.5
18382, 1.95, 1.05, 0.5
18383, 1.95, 1, 0.5
18384, 1.95, 0.95, 0.5
18385, 1.95, 0.9, 0.5
18386, 1.95, 0.85, 0.5
18387, 1.95, 0.8, 0.5
18388, 1.95, 0.75, 0.5
18389, 1.95, 0.7, 0.5
18390, 1.95, 0.65, 0.5
18391, 1.95, 0.6, 0.5
18392, 1.95, 0.55, 0.5
18393, 1.95, 0.5, 0.5
18394, 1.95, 0.45, 0.5
18395, 1.95, 0.4, 0.5
18396, 1.95, 0.35, 0.5
18397, 1.95, 0.3, 0.5
18398, 1.95, 0.25, 0.5
18399, 1.95, 0.2, 0.5
18400, 1.9916666666667, 1.3, 0.5
18401, 1.9916666666667, 1.25, 0.5
18402, 1.9916666666667, 1.2, 0.5
18403, 1.9916666666667, 1.15, 0.5
18404, 1.9916666666667, 1.1, 0.5
18405, 1.9916666666667, 1.05, 0.5
18406, 1.9916666666667, 1, 0.5
18407, 1.9916666666667, 0.95, 0.5
18408, 1.9916666666667, 0.9, 0.5
18409, 1.9916666666667, 0.85, 0.5
18410, 1.9916666666667, 0.8, 0.5
18411, 1.9916666666667, 0.75, 0.5
18412, 1.9916666666667, 0.7, 0.5
18413, 1.9916666666667, 0.65, 0.5
18414, 1.9916666666667, 0.6, 0.5
18415, 1.9916666666667, 0.55, 0.5
18416, 1.9916666666667, 0.5, 0.5
18417, 1.9916666666667, 0.45, 0.5
18418, 1.9916666666667, 0.4, 0.5
18419, 1.9916666666667, 0.35, 0.5
18420, 1.9916666666667, 0.3, 0.5
18421, 1.9916666666667, 0.25, 0.5
18422, 1.9916666666667, 0.2, 0.5
18423, 2.0333333333333, 1.3, 0.5
18424, 2.0333333333333, 1.25, 0.5
18425, 2.0333333333333, 1.2, 0.5
18426, 2.0333333333333, 1.15, 0.5
18427, 2.0333333333333, 1.1, 0.5
18428, 2.0333333333333, 1.05, 0.5
18429, 2.0333333333333, 1, 0.5
18430, 2.0333333333333, 0.95, 0.5
18431, 2.0333333333333, 0.9, 0.5
18432, 2.0333333333333, 0.85, 0.5
18433, 2.0333333333333, 0.8, 0.5
18434, 2.0333333333333, 0.75, 0.5
18435, 2.0333333333333, 0.7, 0.5
18436, 2.0333333333333, 0.65, 0.5
18437, 2.0333333333333, 0.6, 0.5
18438, 2.0333333333333, 0.55, 0.5
18439, 2.0333333333333, 0.5, 0.5
18440, 2.0333333333333, 0.45, 0.5
18441, 2.0333333333333, 0.4, 0.5
18442, 2.0333333333333, 0.35, 0.5
18443, 2.0333333333333, 0.3, 0.5
18444, 2.0333333333333, 0.25, 0.5
18445, 2.0333333333333, 0.2, 0.5
18446, 2.075, 1.3, 0.5
18447, 2.075, 1.25, 0.5
18448, 2.075, 1.2, 0.5
18449, 2.075, 1.15, 0.5
18450, 2.075, 1.1, 0.5
18451, 2.075, 1.05, 0.5
18452, 2.075, 1, 0.5
18453, 2.075, 0.95, 0.5
18454, 2.075, 0.9, 0.5
18455, 2.075, 0.85, 0.5
18456, 2.075, 0.8, 0.5
18457, 2.075, 0.75, 0.5
18458, 2.075, 0.7, 0.5
18459, 2.075, 0.65, 0.5
18460, 2.075, 0.6, 0.5
18461, 2.075, 0.55, 0.5
18462, 2.075, 0.5, 0.5
18463, 2.075, 0.45, 0.5
18464, 2.075, 0.4, 0.5
18465, 2.075, 0.35, 0.5
18466, 2.075, 0.3, 0.5
18467, 2.075, 0.25, 0.5
18468, 2.075, 0.2, 0.5
18469, 2.1166666666667, 1.3, 0.5
18470, 2.1166666666667, 1.25, 0.5
18471, 2.1166666666667, 1.2, 0.5
18472, 2.1166666666667, 1.15, 0.5
18473, 2.1166666666667, 1.1, 0.5
18474, 2.1166666666667, 1.05, 0.5
18475, 2.1166666666667, 1, 0.5
18476, 2.1166666666667, 0.95, 0.5
18477, 2.1166666666667, 0.9, 0.5
18478, 2.1166666666667, 0.85, 0.5
18479, 2.1166666666667, 0.8, 0.5
18480, 2.1166666666667, 0.75, 0.5
18481, 2.1166666666667, 0.7, 0.5
18482, 2.1166666666667, 0.65, 0.5
18483, 2.1166666666667, 0.6, 0.5
18484, 2.1166666666667, 0.55, 0.5
18485, 2.1166666666667, 0.5, 0.5
18486, 2.1166666666667, 0.45, 0.5
18487, 2.1166666666667, 0.4, 0.5
18488, 2.1166666666667, 0.35, 0.5
18489, 2.1166666666667, 0.3, 0.5
18490, 2.1166666666667, 0.25, 0.5
18491, 2.1166666666667, 0.2, 0.5
18492, 2.1583333333333, 1.3, 0.5
18493, 2.1583333333333, 1.25, 0.5
18494, 2.1583333333333, 1.2, 0.5
18495, 2.1583333333333, 1.15, 0.5
18496, 2.1583333333333, 1.1, 0.5
18497, 2.1583333333333, 1.05, 0.5
18498, 2.1583333333333, 1, 0.5
18499, 2.1583333333333, 0.95, 0.5
18500, 2.1583333333333, 0.9, 0.5
18501, 2.1583333333333, 0.85, 0.5
18502, 2.1583333333333, 0.8, 0.5
18503, 2.1583333333333, 0.75, 0.5
18504, 2.1583333333333, 0.7, 0.5
18505, 2.1583333333333, 0.65, 0.5
18506, 2.1583333333333, 0.6, 0.5
18507, 2.1583333333333, 0.55, 0.5
18508, 2.1583333333333, 0.5, 0.5
18509, 2.1583333333333, 0.45, 0.5
18510, 2.1583333333333, 0.4, 0.5
18511, 2.1583333333333, 0.35, 0.5
18512, 2.1583333333333, 0.3, 0.5
18513, 2.1583333333333, 0.25, 0.5
18514, 2.1583333333333, 0.2, 0.5
18515, 1.2208333333333, 1.3, 0.5
18516, 1.2416666666667, 1.325, 0.5
18517, 1.2208333333333, 1.25, 0.5
18518, 1.2416666666667, 1.275, 0.5
18519, 1.2208333333333, 1.2, 0.5
18520, 1.2416666666667, 1.225, 0.5
18521, 1.2208333333333, 1.15, 0.5
18522, 1.2416666666667, 1.175, 0.5
18523, 1.2208333333333, 1.1, 0.5
18524, 1.2416666666667, 1.125, 0.5
18525, 1.2208333333333, 1.05, 0.5
18526, 1.2416666666667, 1.075, 0.5
18527, 1.2208333333333, 1, 0.5
18528, 1.2416666666667, 1.025, 0.5
18529, 1.2208333333333, 0.95, 0.5
18530, 1.2416666666667, 0.975, 0.5
18531, 1.2208333333333, 0.9, 0.5
18532, 1.2416666666667, 0.925, 0.5
18533, 1.2208333333333, 0.85, 0.5
18534, 1.2416666666667, 0.875, 0.5
18535, 1.2208333333333, 0.8, 0.5
18536, 1.2416666666667, 0.825, 0.5
18537, 1.2208333333333, 0.75, 0.5
18538, 1.2416666666667, 0.775, 0.5
18539, 1.2208333333333, 0.7, 0.5
18540, 1.2416666666667, 0.725, 0.5
18541, 1.2208333333333, 0.65, 0.5
18542, 1.2416666666667, 0.675, 0.5
18543, 1.2208333333333, 0.6, 0.5
18544, 1.2416666666667, 0.625, 0.5
18545, 1.2208333333333, 0.55, 0.5
18546, 1.2416666666667, 0.575, 0.5
18547, 1.2208333333333, 0.5, 0.5
18548, 1.2416666666667, 0.525, 0.5
18549, 1.2208333333333, 0.45, 0.5
18550, 1.2416666666667, 0.475, 0.5
18551, 1.2208333333333, 0.4, 0.5
18552, 1.2416666666667, 0.425, 0.5
18553, 1.2208333333333, 0.35, 0.5
18554, 1.2416666666667, 0.375, 0.5
18555, 1.2208333333333, 0.3, 0.5
18556, 1.2416666666667, 0.325, 0.5
18557, 1.2208333333333, 0.25, 0.5
18558, 1.2416666666667, 0.275, 0.5
18559, 1.2208333333333, 0.2, 0.5
18560, 1.2416666666667, 0.225, 0.5
18561, 1.2416666666667, 0.175, 0.5
18562, 1.2625, 1.3, 0.5
18563, 1.2833333333333, 1.325, 0.5
18564, 1.2625, 1.25, 0.5
18565, 1.2833333333333, 1.275, 0.5
18566, 1.2625, 1.2, 0.5
18567, 1.2833333333333, 1.225, 0.5
18568, 1.2625, 1.15, 0.5
18569, 1.2833333333333, 1.175, 0.5
18570, 1.2625, 1.1, 0.5
18571, 1.2833333333333, 1.125, 0.5
18572, 1.2625, 1.05, 0.5
18573, 1.2833333333333, 1.075, 0.5
18574, 1.2625, 1, 0.5
18575, 1.2833333333333, 1.025, 0.5
18576, 1.2625, 0.95, 0.5
18577, 1.2833333333333, 0.975, 0.5
18578, 1.2625, 0.9, 0.5
18579, 1.2833333333333, 0.925, 0.5
18580, 1.2625, 0.85, 0.5
18581, 1.2833333333333, 0.875, 0.5
18582, 1.2625, 0.8, 0.5
18583, 1.2833333333333, 0.825, 0.5
18584, 1.2625, 0.75, 0.5
18585, 1.2833333333333, 0.775, 0.5
18586, 1.2625, 0.7, 0.5
18587, 1.2833333333333, 0.725, 0.5
18588, 1.2625, 0.65, 0.5
18589, 1.2833333333333, 0.675, 0.5
18590, 1.2625, 0.6, 0.5
18591, 1.2833333333333, 0.625, 0.5
18592, 1.2625, 0.55, 0.5
18593, 1.2833333333333, 0.575, 0.5
18594, 1.2625, 0.5, 0.5
18595, 1.2833333333333, 0.525, 0.5
18596, 1.2625, 0.45, 0.5
18597, 1.2833333333333, 0.475, 0.5
18598, 1.2625, 0.4, 0.5
18599, 1.2833333333333, 0.425, 0.5
18600, 1.2625, 0.35, 0.5
18601, 1.2833333333333, 0.375, 0.5
18602, 1.2625, 0.3, 0.5
18603, 1.2833333333333, 0.325, 0.5
18604, 1.2625, 0.25, 0.5
18605, 1.2833333333333, 0.275, 0.5
18606, 1.2625, 0.2, 0.5
18607, 1.2833333333333, 0.225, 0.5
18608, 1.2833333333333, 0.175, 0.5
18609, 1.3041666666667, 1.3, 0.5
18610, 1.325, 1.325, 0.5
18611, 1.3041666666667, 1.25, 0.5
18612, 1.325, 1.275, 0.5
18613, 1.3041666666667, 1.2, 0.5
18614, 1.325, 1.225, 0.5
18615, 1.3041666666667, 1.15, 0.5
18616, 1.325, 1.175, 0.5
18617, 1.3041666666667, 1.1, 0.5
18618, 1.325, 1.125, 0.5
18619, 1.3041666666667, 1.05, 0.5
18620, 1.325, 1.075, 0.5
18621, 1.3041666666667, 1, 0.5
18622, 1.325, 1.025, 0.5
18623, 1.3041666666667, 0.95, 0.5
18624, 1.325, 0.975, 0.5
18625, 1.3041666666667, 0.9, 0.5
18626, 1.325, 0.925, 0.5
18627, 1.3041666666667, 0.85, 0.5
18628, 1.325, 0.875, 0.5
18629, 1.3041666666667, 0.8, 0.5
18630, 1.325, 0.825, 0.5
18631, 1.3041666666667, 0.75, 0.5
18632, 1.325, 0.775, 0.5
18633, 1.3041666666667, 0.7, 0.5
18634, 1.325, 0.725, 0.5
18635, 1.3041666666667, 0.65, 0.5
18636, 1.325, 0.675, 0.5
18637, 1.3041666666667, 0.6, 0.5
18638, 1.325, 0.625, 0.5
18639, 1.3041666666667, 0.55, 0.5
18640, 1.325, 0.575, 0.5
18641, 1.3041666666667, 0.5, 0.5
18642, 1.325, 0.525, 0.5
18643, 1.3041666666667, 0.45, 0.5
18644, 1.325, 0.475, 0.5
18645, 1.3041666666667, 0.4, 0.5
18646, 1.325, 0.425, 0.5
18647, 1.3041666666667, 0.35, 0.5
18648, 1.325, 0.375, 0.5
18649, 1.3041666666667, 0.3, 0.5
18650, 1.325, 0.325, 0.5
18651, 1.3041666666667, 0.25, 0.5
18652, 1.325, 0.275, 0.5
18653, 1.3041666666667, 0.2, 0.5
18654, 1.325, 0.225, 0.5
18655, 1.325, 0.175, 0.5
18656, 1.3458333333333, 1.3, 0.5
18657, 1.3666666666667, 1.325, 0.5
18658, 1.3458333333333, 1.25, 0.5
18659, 1.3666666666667, 1.275, 0.5
18660, 1.3458333333333, 1.2, 0.5
18661, 1.3666666666667, 1.225, 0.5
18662, 1.3458333333333, 1.15, 0.5
18663, 1.3666666666667, 1.175, 0.5
18664, 1.3458333333333, 1.1, 0.5
18665, 1.3666666666667, 1.125, 0.5
18666, 1.3458333333333, 1.05, 0.5
18667, 1.3666666666667, 1.075, 0.5
18668, 1.3458333333333, 1, 0.5
18669, 1.3666666666667, 1.025, 0.5
18670, 1.3458333333333, 0.95, 0.5
18671, 1.3666666666667, 0.975, 0.5
18672, 1.3458333333333, 0.9, 0.5
18673, 1.3666666666667, 0.925, 0.5
18674, 1.3458333333333, 0.85, 0.5
18675, 1.3666666666667, 0.875, 0.5
18676, 1.3458333333333, 0.8, 0.5
18677, 1.3666666666667, 0.825, 0.5
18678, 1.3458333333333, 0.75, 0.5
18679, 1.3666666666667, 0.775, 0.5
18680, 1.3458333333333, 0.7, 0.5
18681, 1.3666666666667, 0.725, 0.5
18682, 1.3458333333333, 0.65, 0.5
18683, 1.3666666666667, 0.675, 0.5
18684, 1.3458333333333, 0.6, 0.5
18685, 1.3666666666667, 0.625, 0.5
18686, 1.3458333333333, 0.55, 0.5
18687, 1.3666666666667, 0.575, 0.5
18688, 1.3458333333333, 0.5, 0.5
18689, 1.3666666666667, 0.525, 0.5
18690, 1.3458333333333, 0.45, 0.5
18691, 1.3666666666667, 0.475, 0.5
18692, 1.3458333333333, 0.4, 0.5
18693, 1.3666666666667, 0.425, 0.5
18694, 1.3458333333333, 0.35, 0.5
18695, 1.3666666666667, 0.375, 0.5
18696, 1.3458333333333, 0.3, 0.5
18697, 1.3666666666667, 0.325, 0.5
18698, 1.3458333333333, 0.25, 0.5
18699, 1.3666666666667, 0.275, 0.5
18700, 1.3458333333333, 0.2, 0.5
18701, 1.3666666666667, 0.225, 0.5
18702, 1.3666666666667, 0.175, 0.5
18703, 1.3875, 1.3, 0.5
18704, 1.4083333333333, 1.325, 0.5
18705, 1.3875, 1.25, 0.5
18706, 1.4083333333333, 1.275, 0.5
18707, 1.3875, 1.2, 0.5
18708, 1.4083333333333, 1.225, 0.5
18709, 1.3875, 1.15, 0.5
18710, 1.4083333333333, 1.175, 0.5
18711, 1.3875, 1.1, 0.5
18712, 1.4083333333333, 1.125, 0.5
18713, 1.3875, 1.05, 0.5
18714, 1.4083333333333, 1.075, 0.5
18715, 1.3875, 1, 0.5
18716, 1.4083333333333, 1.025, 0.5
18717, 1.3875, 0.95, 0.5
18718, 1.4083333333333, 0.975, 0.5
18719, 1.3875, 0.9, 0.5
18720, 1.4083333333333, 0.925, 0.5
18721, 1.3875, 0.85, 0.5
18722, 1.4083333333333, 0.875, 0.5
18723, 1.3875, 0.8, 0.5
18724, 1.4083333333333, 0.825, 0.5
18725, 1.3875, 0.75, 0.5
18726, 1.4083333333333, 0.775, 0.5
18727, 1.3875, 0.7, 0.5
18728, 1.4083333333333, 0.725, 0.5
18729, 1.3875, 0.65, 0.5
18730, 1.4083333333333, 0.675, 0.5
18731, 1.3875, 0.6, 0.5
18732, 1.4083333333333, 0.625, 0.5
18733, 1.3875, 0.55, 0.5
18734, 1.4083333333333, 0.575, 0.5
18735, 1.3875, 0.5, 0.5
18736, 1.4083333333333, 0.525, 0.5
18737, 1.3875, 0.45, 0.5
18738, 1.4083333333333, 0.475, 0.5
18739, 1.3875, 0.4, 0.5
18740, 1.4083333333333, 0.425, 0.5
18741, 1.3875, 0.35, 0.5
18742, 1.4083333333333, 0.375, 0.5
18743, 1.3875, 0.3, 0.5
18744, 1.4083333333333, 0.325, 0.5
18745, 1.3875, 0.25, 0.5
18746, 1.4083333333333, 0.275, 0.5
18747, 1.3875, 0.2, 0.5
18748, 1.4083333333333, 0.225, 0.5
18749, 1.4083333333333, 0.175, 0.5
18750, 1.4291666666667, 1.3, 0.5
18751, 1.45, 1.325, 0.5
18752, 1.4291666666667, 1.25, 0.5
18753, 1.45, 1.275, 0.5
18754, 1.4291666666667, 1.2, 0.5
18755, 1.45, 1.225, 0.5
18756, 1.4291666666667, 1.15, 0.5
18757, 1.45, 1.175, 0.5
18758, 1.4291666666667, 1.1, 0.5
18759, 1.45, 1.125, 0.5
18760, 1.4291666666667, 1.05, 0.5
18761, 1.45, 1.075, 0.5
18762, 1.4291666666667, 1, 0.5
18763, 1.45, 1.025, 0.5
18764, 1.4291666666667, 0.95, 0.5
18765, 1.45, 0.975, 0.5
18766, 1.4291666666667, 0.9, 0.5
18767, 1.45, 0.925, 0.5
18768, 1.4291666666667, 0.85, 0.5
18769, 1.45, 0.875, 0.5
18770, 1.4291666666667, 0.8, 0.5
18771, 1.45, 0.825, 0.5
18772, 1.4291666666667, 0.75, 0.5
18773, 1.45, 0.775, 0.5
18774, 1.4291666666667, 0.7, 0.5
18775, 1.45, 0.725, 0.5
18776, 1.4291666666667, 0.65, 0.5
18777, 1.45, 0.675, 0.5
18778, 1.4291666666667, 0.6, 0.5
18779, 1.45, 0.625, 0.5
18780, 1.4291666666667, 0.55, 0.5
18781, 1.45, 0.575, 0.5
18782, 1.4291666666667, 0.5, 0.5
18783, 1.45, 0.525, 0.5
18784, 1.4291666666667, 0.45, 0.5
18785, 1.45, 0.475, 0.5
18786, 1.4291666666667, 0.4, 0.5
18787, 1.45, 0.425, 0.5
18788, 1.4291666666667, 0.35, 0.5
18789, 1.45, 0.375, 0.5
18790, 1.4291666666667, 0.3, 0.5
18791, 1.45, 0.325, 0.5
18792, 1.4291666666667, 0.25, 0.5
18793, 1.45, 0.275, 0.5
18794, 1.4291666666667, 0.2, 0.5
18795, 1.45, 0.225, 0.5
18796, 1.45, 0.175, 0.5
18797, 1.4708333333333, 1.3, 0.5
18798, 1.4916666666667, 1.325, 0.5
18799, 1.4708333333333, 1.25, 0.5
18800, 1.4916666666667, 1.275, 0.5
18801, 1.4708333333333, 1.2, 0.5
18802, 1.4916666666667, 1.225, 0.5
18803, 1.4708333333333, 1.15, 0.5
18804, 1.4916666666667, 1.175, 0.5
18805, 1.4708333333333, 1.1, 0.5
18806, 1.4916666666667, 1.125, 0.5
18807, 1.4708333333333, 1.05, 0.5
18808, 1.4916666666667, 1.075, 0.5
18809, 1.4708333333333, 1, 0.5
18810, 1.4916666666667, 1.025, 0.5
18811, 1.4708333333333, 0.95, 0.5
18812, 1.4916666666667, 0.975, 0.5
18813, 1.4708333333333, 0.9, 0.5
18814, 1.4916666666667, 0.925, 0.5
18815, 1.4708333333333, 0.85, 0.5
18816, 1.4916666666667, 0.875, 0.5
18817, 1.4708333333333, 0.8, 0.5
18818, 1.4916666666667, 0.825, 0.5
18819, 1.4708333333333, 0.75, 0.5
18820, 1.4916666666667, 0.775, 0.5
18821, 1.4708333333333, 0.7, 0.5
18822, 1.4916666666667, 0.725, 0.5
18823, 1.4708333333333, 0.65, 0.5
18824, 1.4916666666667, 0.675, 0.5
18825, 1.4708333333333, 0.6, 0.5
18826, 1.4916666666667, 0.625, 0.5
18827, 1.4708333333333, 0.55, 0.5
18828, 1.4916666666667, 0.575, 0.5
18829, 1.4708333333333, 0.5, 0.5
18830, 1.4916666666667, 0.525, 0.5
18831, 1.4708333333333, 0.45, 0.5
18832, 1.4916666666667, 0.475, 0.5
18833, 1.4708333333333, 0.4, 0.5
18834, 1.4916666666667, 0.425, 0.5
18835, 1.4708333333333, 0.35, 0.5
18836, 1.4916666666667, 0.375, 0.5
18837, 1.4708333333333, 0.3, 0.5
18838, 1.4916666666667, 0.325, 0.5
18839, 1.4708333333333, 0.25, 0.5
18840, 1.4916666666667, 0.275, 0.5
18841, 1.4708333333333, 0.2, 0.5
18842, 1.4916666666667, 0.225, 0.5
18843, 1.4916666666667, 0.175, 0.5
18844, 1.5125, 1.3, 0.5
18845, 1.5333333333333, 1.325, 0.5
18846, 1.5125, 1.25, 0.5
18847, 1.5333333333333, 1.275, 0.5
18848, 1.5125, 1.2, 0.5
18849, 1.5333333333333, 1.225, 0.5
18850, 1.5125, 1.15, 0.5
18851, 1.5333333333333, 1.175, 0.5
18852, 1.5125, 1.1, 0.5
18853, 1.5333333333333, 1.125, 0.5
18854, 1.5125, 1.05, 0.5
18855, 1.5333333333333, 1.075, 0.5
18856, 1.5125, 1, 0.5
18857, 1.5333333333333, 1.025, 0.5
18858, 1.5125, 0.95, 0.5
18859, 1.5333333333333, 0.975, 0.5
18860, 1.5125, 0.9, 0.5
18861, 1.5333333333333, 0.925, 0.5
18862, 1.5125, 0.85, 0.5
18863, 1.5333333333333, 0.875, 0.5
18864, 1.5125, 0.8, 0.5
18865, 1.5333333333333, 0.825, 0.5
18866, 1.5125, 0.75, 0.5
18867, 1.5333333333333, 0.775, 0.5
18868, 1.5125, 0.7, 0.5
18869, 1.5333333333333, 0.725, 0.5
18870, 1.5125, 0.65, 0.5
18871, 1.5333333333333, 0.675, 0.5
18872, 1.5125, 0.6, 0.5
18873, 1.5333333333333, 0.625, 0.5
18874, 1.5125, 0.55, 0.5
18875, 1.5333333333333, 0.575, 0.5
18876, 1.5125, 0.5, 0.5
18877, 1.5333333333333, 0.525, 0.5
18878, 1.5125, 0.45, 0.5
18879, 1.5333333333333, 0.475, 0.5
18880, 1.5125, 0.4, 0.5
18881, 1.5333333333333, 0.425, 0.5
18882, 1.5125, 0.35, 0.5
18883, 1.5333333333333, 0.375, 0.5
18884, 1.5125, 0.3, 0.5
18885, 1.5333333333333, 0.325, 0.5
18886, 1.5125, 0.25, 0.5
18887, 1.5333333333333, 0.275, 0.5
18888, 1.5125, 0.2, 0.5
18889, 1.5333333333333, 0.225, 0.5
18890, 1.5333333333333, 0.175, 0.5
18891, 1.5541666666667, 1.3, 0.5
18892, 1.575, 1.325, 0.5
18893, 1.5541666666667, 1.25, 0.5
18894, 1.575, 1.275, 0.5
18895, 1.5541666666667, 1.2, 0.5
18896, 1.575, 1.225, 0.5
18897, 1.5541666666667, 1.15, 0.5
18898, 1.575, 1.175, 0.5
18899, 1.5541666666667, 1.1, 0.5
18900, 1.575, 1.125, 0.5
18901, 1.5541666666667, 1.05, 0.5
18902, 1.575, 1.075, 0.5
18903, 1.5541666666667, 1, 0.5
18904, 1.575, 1.025, 0.5
18905, 1.5541666666667, 0.95, 0.5
18906, 1.575, 0.975, 0.5
18907, 1.5541666666667, 0.9, 0.5
18908, 1.575, 0.925, 0.5
18909, 1.5541666666667, 0.85, 0.5
18910, 1.575, 0.875, 0.5
18911, 1.5541666666667, 0.8, 0.5
18912, 1.575, 0.825, 0.5
18913, 1.5541666666667, 0.75, 0.5
18914, 1.575, 0.775, 0.5
18915, 1.5541666666667, 0.7, 0.5
18916, 1.575, 0.725, 0.5
18917, 1.5541666666667, 0.65, 0.5
18918, 1.575, 0.675, 0.5
18919, 1.5541666666667, 0.6, 0.5
18920, 1.575, 0.625, 0.5
18921, 1.5541666666667, 0.55, 0.5
18922, 1.575, 0.575, 0.5
18923, 1.5541666666667, 0.5, 0.5
18924, 1.575, 0.525, 0.5
18925, 1.5541666666667, 0.45, 0.5
18926, 1.575, 0.475, 0.5
18927, 1.5541666666667, 0.4, 0.5
18928, 1.575, 0.425, 0.5
18929, 1.5541666666667, 0.35, 0.5
18930, 1.575, 0.375, 0.5
18931, 1.5541666666667, 0.3, 0.5
18932, 1.575, 0.325, 0.5
18933, 1.5541666666667, 0.25, 0.5
18934, 1.575, 0.275, 0.5
18935, 1.5541666666667, 0.2, 0.5
18936, 1.575, 0.225, 0.5
18937, 1.575, 0.175, 0.5
18938, 1.5958333333333, 1.3, 0.5
18939, 1.6166666666667, 1.325, 0.5
18940, 1.5958333333333, 1.25, 0.5
18941, 1.6166666666667, 1.275, 0.5
18942, 1.5958333333333, 1.2, 0.5
18943, 1.6166666666667, 1.225, 0.5
18944, 1.5958333333333, 1.15, 0.5
18945, 1.6166666666667, 1.175, 0.5
18946, 1.5958333333333, 1.1, 0.5
18947, 1.6166666666667, 1.125, 0.5
18948, 1.5958333333333, 1.05, 0.5
18949, 1.6166666666667, 1.075, 0.5
18950, 1.5958333333333, 1, 0.5
18951, 1.6166666666667, 1.025, 0.5
18952, 1.5958333333333, 0.95, 0.5
18953, 1.6166666666667, 0.975, 0.5
18954, 1.5958333333333, 0.9, 0.5
18955, 1.6166666666667, 0.925, 0.5
18956, 1.5958333333333, 0.85, 0.5
18957, 1.6166666666667, 0.875, 0.5
18958, 1.5958333333333, 0.8, 0.5
18959, 1.6166666666667, 0.825, 0.5
18960, 1.5958333333333, 0.75, 0.5
18961, 1.6166666666667, 0.775, 0.5
18962, 1.5958333333333, 0.7, 0.5
18963, 1.6166666666667, 0.725, 0.5
18964, 1.5958333333333, 0.65, 0.5
18965, 1.6166666666667, 0.675, 0.5
18966, 1.5958333333333, 0.6, 0.5
18967, 1.6166666666667, 0.625, 0.5
18968, 1.5958333333333, 0.55, 0.5
18969, 1.6166666666667, 0.575, 0.5
18970, 1.5958333333333, 0.5, 0.5
18971, 1.6166666666667, 0.525, 0.5
18972, 1.5958333333333, 0.45, 0.5
18973, 1.6166666666667, 0.475, 0.5
18974, 1.5958333333333, 0.4, 0.5
18975, 1.6166666666667, 0.425, 0.5
18976, 1.5958333333333, 0.35, 0.5
18977, 1.6166666666667, 0.375, 0.5
18978, 1.5958333333333, 0.3, 0.5
18979, 1.6166666666667, 0.325, 0.5
18980, 1.5958333333333, 0.25, 0.5
18981, 1.6166666666667, 0.275, 0.5
18982, 1.5958333333333, 0.2, 0.5
18983, 1.6166666666667, 0.225, 0.5
18984, 1.6166666666667, 0.175, 0.5
18985, 1.6375, 1.3, 0.5
18986, 1.6583333333333, 1.325, 0.5
18987, 1.6375, 1.25, 0.5
18988, 1.6583333333333, 1.275, 0.5
18989, 1.6375, 1.2, 0.5
18990, 1.6583333333333, 1.225, 0.5
18991, 1.6375, 1.15, 0.5
18992, 1.6583333333333, 1.175, 0.5
18993, 1.6375, 1.1, 0.5
18994, 1.6583333333333, 1.125, 0.5
18995, 1.6375, 1.05, 0.5
18996, 1.6583333333333, 1.075, 0.5
18997, 1.6375, 1, 0.5
18998, 1.6583333333333, 1.025, 0.5
18999, 1.6375, 0.95, 0.5
19000, 1.6583333333333, 0.975, 0.5
19001, 1.6375, 0.9, 0.5
19002, 1.6583333333333, 0.925, 0.5
19003, 1.6375, 0.85, 0.5
19004, 1.6583333333333, 0.875, 0.5
19005, 1.6375, 0.8, 0.5
19006, 1.6583333333333, 0.825, 0.5
19007, 1.6375, 0.75, 0.5
19008, 1.6583333333333, 0.775, 0.5
19009, 1.6375, 0.7, 0.5
19010, 1.6583333333333, 0.725, 0.5
19011, 1.6375, 0.65, 0.5
19012, 1.6583333333333, 0.675, 0.5
19013, 1.6375, 0.6, 0.5
19014, 1.6583333333333, 0.625, 0.5
19015, 1.6375, 0.55, 0.5
19016, 1.6583333333333, 0.575, 0.5
19017, 1.6375, 0.5, 0.5
19018, 1.6583333333333, 0.525, 0.5
19019, 1.6375, 0.45, 0.5
19020, 1.6583333333333, 0.475, 0.5
19021, 1.6375, 0.4, 0.5
19022, 1.6583333333333, 0.425, 0.5
19023, 1.6375, 0.35, 0.5
19024, 1.6583333333333, 0.375, 0.5
19025, 1.6375, 0.3, 0.5
19026, 1.6583333333333, 0.325, 0.5
19027, 1.6375, 0.25, 0.5
19028, 1.6583333333333, 0.275, 0.5
19029, 1.6375, 0.2, 0.5
19030, 1.6583333333333, 0.225, 0.5
19031, 1.6583333333333, 0.175, 0.5
19032, 1.6791666666667, 1.3, 0.5
19033, 1.7, 1.325, 0.5
19034, 1.6791666666667, 1.25, 0.5
19035, 1.7, 1.275, 0.5
19036, 1.6791666666667, 1.2, 0.5
19037, 1.7, 1.225, 0.5
19038, 1.6791666666667, 1.15, 0.5
19039, 1.7, 1.175, 0.5
19040, 1.6791666666667, 1.1, 0.5
19041, 1.7, 1.125, 0.5
19042, 1.6791666666667, 1.05, 0.5
19043, 1.7, 1.075, 0.5
19044, 1.6791666666667, 1, 0.5
19045, 1.7, 1.025, 0.5
19046, 1.6791666666667, 0.95, 0.5
19047, 1.7, 0.975, 0.5
19048, 1.6791666666667, 0.9, 0.5
19049, 1.7, 0.925, 0.5
19050, 1.6791666666667, 0.85, 0.5
19051, 1.7, 0.875, 0.5
19052, 1.6791666666667, 0.8, 0.5
19053, 1.7, 0.825, 0.5
19054, 1.6791666666667, 0.75, 0.5
19055, 1.7, 0.775, 0.5
19056, 1.6791666666667, 0.7, 0.5
19057, 1.7, 0.725, 0.5
19058, 1.6791666666667, 0.65, 0.5
19059, 1.7, 0.675, 0.5
19060, 1.6791666666667, 0.6, 0.5
19061, 1.7, 0.625, 0.5
19062, 1.6791666666667, 0.55, 0.5
19063, 1.7, 0.575, 0.5
19064, 1.6791666666667, 0.5, 0.5
19065, 1.7, 0.525, 0.5
19066, 1.6791666666667, 0.45, 0.5
19067, 1.7, 0.475, 0.5
19068, 1.6791666666667, 0.4, 0.5
19069, 1.7, 0.425, 0.5
19070, 1.6791666666667, 0.35, 0.5
19071, 1.7, 0.375, 0.5
19072, 1.6791666666667, 0.3, 0.5
19073, 1.7, 0.325, 0.5
19074, 1.6791666666667, 0.25, 0.5
19075, 1.7, 0.275, 0.5
19076, 1.6791666666667, 0.2, 0.5
19077, 1.7, 0.225, 0.5
19078, 1.7, 0.175, 0.5
19079, 1.7208333333333, 1.3, 0.5
19080, 1.7416666666667, 1.325, 0.5
19081, 1.7208333333333, 1.25, 0.5
19082, 1.7416666666667, 1.275, 0.5
19083, 1.7208333333333, 1.2, 0.5
19084, 1.7416666666667, 1.225, 0.5
19085, 1.7208333333333, 1.15, 0.5
19086, 1.7416666666667, 1.175, 0.5
19087, 1.7208333333333, 1.1, 0.5
19088, 1.7416666666667, 1.125, 0.5
19089, 1.7208333333333, 1.05, 0.5
19090, 1.7416666666667, 1.075, 0.5
19091, 1.7208333333333, 1, 0.5
19092, 1.7416666666667, 1.025, 0.5
19093, 1.7208333333333, 0.95, 0.5
19094, 1.7416666666667, 0.975, 0.5
19095, 1.7208333333333, 0.9, 0.5
19096, 1.7416666666667, 0.925, 0.5
19097, 1.7208333333333, 0.85, 0.5
19098, 1.7416666666667, 0.875, 0.5
19099, 1.7208333333333, 0.8, 0.5
19100, 1.7416666666667, 0.825, 0.5
19101, 1.7208333333333, 0.75, 0.5
19102, 1.7416666666667, 0.775, 0.5
19103, 1.7208333333333, 0.7, 0.5
19104, 1.7416666666667, 0.725, 0.5
19105, 1.7208333333333, 0.65, 0.5
19106, 1.7416666666667, 0.675, 0.5
19107, 1.7208333333333, 0.6, 0.5
19108, 1.7416666666667, 0.625, 0.5
19109, 1.7208333333333, 0.55, 0.5
19110, 1.7416666666667, 0.575, 0.5
19111, 1.7208333333333, 0.5, 0.5
19112, 1.7416666666667, 0.525, 0.5
19113, 1.7208333333333, 0.45, 0.5
19114, 1.7416666666667, 0.475, 0.5
19115, 1.7208333333333, 0.4, 0.5
19116, 1.7416666666667, 0.425, 0.5
19117, 1.7208333333333, 0.35, 0.5
19118, 1.7416666666667, 0.375, 0.5
19119, 1.7208333333333, 0.3, 0.5
19120, 1.7416666666667, 0.325, 0.5
19121, 1.7208333333333, 0.25, 0.5
19122, 1.7416666666667, 0.275, 0.5
19123, 1.7208333333333, 0.2, 0.5
19124, 1.7416666666667, 0.225, 0.5
19125, 1.7416666666667, 0.175, 0.5
19126, 1.7625, 1.3, 0.5
19127, 1.7833333333333, 1.325, 0.5
19128, 1.7625, 1.25, 0.5
19129, 1.7833333333333, 1.275, 0.5
19130, 1.7625, 1.2, 0.5
19131, 1.7833333333333, 1.225, 0.5
19132, 1.7625, 1.15, 0.5
19133, 1.7833333333333, 1.175, 0.5
19134, 1.7625, 1.1, 0.5
19135, 1.7833333333333, 1.125, 0.5
19136, 1.7625, 1.05, 0.5
19137, 1.7833333333333, 1.075, 0.5
19138, 1.7625, 1, 0.5
19139, 1.7833333333333, 1.025, 0.5
19140, 1.7625, 0.95, 0.5
19141, 1.7833333333333, 0.975, 0.5
19142, 1.7625, 0.9, 0.5
19143, 1.7833333333333, 0.925, 0.5
19144, 1.7625, 0.85, 0.5
19145, 1.7833333333333, 0.875, 0.5
19146, 1.7625, 0.8, 0.5
19147, 1.7833333333333, 0.825, 0.5
19148, 1.7625, 0.75, 0.5
19149, 1.7833333333333, 0.775, 0.5
19150, 1.7625, 0.7, 0.5
19151, 1.7833333333333, 0.725, 0.5
19152, 1.7625, 0.65, 0.5
19153, 1.7833333333333, 0.675, 0.5
19154, 1.7625, 0.6, 0.5
19155, 1.7833333333333, 0.625, 0.5
19156, 1.7625, 0.55, 0.5
19157, 1.7833333333333, 0.575, 0.5
19158, 1.7625, 0.5, 0.5
19159, 1.7833333333333, 0.525, 0.5
19160, 1.7625, 0.45, 0.5
19161, 1.7833333333333, 0.475, 0.5
19162, 1.7625, 0.4, 0.5
19163, 1.7833333333333, 0.425, 0.5
19164, 1.7625, 0.35, 0.5
19165, 1.7833333333333, 0.375, 0.5
19166, 1.7625, 0.3, 0.5
19167, 1.7833333333333, 0.325, 0.5
19168, 1.7625, 0.25, 0.5
19169, 1.7833333333333, 0.275, 0.5
19170, 1.7625, 0.2, 0.5
19171, 1.7833333333333, 0.225, 0.5
19172, 1.7833333333333, 0.175, 0.5
19173, 1.8041666666667, 1.3, 0.5
19174, 1.825, 1.325, 0.5
19175, 1.8041666666667, 1.25, 0.5
19176, 1.825, 1.275, 0.5
19177, 1.8041666666667, 1.2, 0.5
19178, 1.825, 1.225, 0.5
19179, 1.8041666666667, 1.15, 0.5
19180, 1.825, 1.175, 0.5
19181, 1.8041666666667, 1.1, 0.5
19182, 1.825, 1.125, 0.5
19183, 1.8041666666667, 1.05, 0.5
19184, 1.825, 1.075, 0.5
19185, 1.8041666666667, 1, 0.5
19186, 1.825, 1.025, 0.5
19187, 1.8041666666667, 0.95, 0.5
19188, 1.825, 0.975, 0.5
19189, 1.8041666666667, 0.9, 0.5
19190, 1.825, 0.925, 0.5
19191, 1.8041666666667, 0.85, 0.5
19192, 1.825, 0.875, 0.5
19193, 1.8041666666667, 0.8, 0.5
19194, 1.825, 0.825, 0.5
19195, 1.8041666666667, 0.75, 0.5
19196, 1.825, 0.775, 0.5
19197, 1.8041666666667, 0.7, 0.5
19198, 1.825, 0.725, 0.5
19199, 1.8041666666667, 0.65, 0.5
19200, 1.825, 0.675, 0.5
19201, 1.8041666666667, 0.6, 0.5
19202, 1.825, 0.625, 0.5
19203, 1.8041666666667, 0.55, 0.5
19204, 1.825, 0.575, 0.5
19205, 1.8041666666667, 0.5, 0.5
19206, 1.825, 0.525, 0.5
19207, 1.8041666666667, 0.45, 0.5
19208, 1.825, 0.475, 0.5
19209, 1.8041666666667, 0.4, 0.5
19210, 1.825, 0.425, 0.5
19211, 1.8041666666667, 0.35, 0.5
19212, 1.825, 0.375, 0.5
19213, 1.8041666666667, 0.3, 0.5
19214, 1.825, 0.325, 0.5
19215, 1.8041666666667, 0.25, 0.5
19216, 1.825, 0.275, 0.5
19217, 1.8041666666667, 0.2, 0.5
19218, 1.825, 0.225, 0.5
19219, 1.825, 0.175, 0.5
19220, 1.8458333333333, 1.3, 0.5
19221, 1.8666666666667, 1.325, 0.5
19222, 1.8458333333333, 1.25, 0.5
19223, 1.8666666666667, 1.275, 0.5
19224, 1.8458333333333, 1.2, 0.5
19225, 1.8666666666667, 1.225, 0.5
19226, 1.8458333333333, 1.15, 0.5
19227, 1.8666666666667, 1.175, 0.5
19228, 1.8458333333333, 1.1, 0.5
19229, 1.8666666666667, 1.125, 0.5
19230, 1.8458333333333, 1.05, 0.5
19231, 1.8666666666667, 1.075, 0.5
19232, 1.8458333333333, 1, 0.5
19233, 1.8666666666667, 1.025, 0.5
19234, 1.8458333333333, 0.95, 0.5
19235, 1.8666666666667, 0.975, 0.5
19236, 1.8458333333333, 0.9, 0.5
19237, 1.8666666666667, 0.925, 0.5
19238, 1.8458333333333, 0.85, 0.5
19239, 1.8666666666667, 0.875, 0.5
19240, 1.8458333333333, 0.8, 0.5
19241, 1.8666666666667, 0.825, 0.5
19242, 1.8458333333333, 0.75, 0.5
19243, 1.8666666666667, 0.775, 0.5
19244, 1.8458333333333, 0.7, 0.5
19245, 1.8666666666667, 0.725, 0.5
19246, 1.8458333333333, 0.65, 0.5
19247, 1.8666666666667, 0.675, 0.5
19248, 1.8458333333333, 0.6, 0.5
19249, 1.8666666666667, 0.625, 0.5
19250, 1.8458333333333, 0.55, 0.5
19251, 1.8666666666667, 0.575, 0.5
19252, 1.8458333333333, 0.5, 0.5
19253, 1.8666666666667, 0.525, 0.5
19254, 1.8458333333333, 0.45, 0.5
19255, 1.8666666666667, 0.475, 0.5
19256, 1.8458333333333, 0.4, 0.5
19257, 1.8666666666667, 0.425, 0.5
19258, 1.8458333333333, 0.35, 0.5
19259, 1.8666666666667, 0.375, 0.5
19260, 1.8458333333333, 0.3, 0.5
19261, 1.8666666666667, 0.325, 0.5
19262, 1.8458333333333, 0.25, 0.5
19263, 1.8666666666667, 0.275, 0.5
19264, 1.8458333333333, 0.2, 0.5
19265, 1.8666666666667, 0.225, 0.5
19266, 1.8666666666667, 0.175, 0.5
19267, 1.8875, 1.3, 0.5
19268, 1.9083333333333, 1.325, 0.5
19269, 1.8875, 1.25, 0.5
19270, 1.9083333333333, 1.275, 0.5
19271, 1.8875, 1.2, 0.5
19272, 1.9083333333333, 1.225, 0.5
19273, 1.8875, 1.15, 0.5
19274, 1.9083333333333, 1.175, 0.5
19275, 1.8875, 1.1, 0.5
19276, 1.9083333333333, 1.125, 0.5
19277, 1.8875, 1.05, 0.5
19278, 1.9083333333333, 1.075, 0.5
19279, 1.8875, 1, 0.5
19280, 1.9083333333333, 1.025, 0.5
19281, 1.8875, 0.95, 0.5
19282, 1.9083333333333, 0.975, 0.5
19283, 1.8875, 0.9, 0.5
19284, 1.9083333333333, 0.925, 0.5
19285, 1.8875, 0.85, 0.5
19286, 1.9083333333333, 0.875, 0.5
19287, 1.8875, 0.8, 0.5
19288, 1.9083333333333, 0.825, 0.5
19289, 1.8875, 0.75, 0.5
19290, 1.9083333333333, 0.775, 0.5
19291, 1.8875, 0.7, 0.5
19292, 1.9083333333333, 0.725, 0.5
19293, 1.8875, 0.65, 0.5
19294, 1.9083333333333, 0.675, 0.5
19295, 1.8875, 0.6, 0.5
19296, 1.9083333333333, 0.625, 0.5
19297, 1.8875, 0.55, 0.5
19298, 1.9083333333333, 0.575, 0.5
19299, 1.8875, 0.5, 0.5
19300, 1.9083333333333, 0.525, 0.5
19301, 1.8875, 0.45, 0.5
19302, 1.9083333333333, 0.475, 0.5
19303, 1.8875, 0.4, 0.5
19304, 1.9083333333333, 0.425, 0.5
19305, 1.8875, 0.35, 0.5
19306, 1.9083333333333, 0.375, 0.5
19307, 1.8875, 0.3, 0.5
19308, 1.9083333333333, 0.325, 0.5
19309, 1.8875, 0.25, 0.5
19310, 1.9083333333333, 0.275, 0.5
19311, 1.8875, 0.2, 0.5
19312, 1.9083333333333, 0.225, 0.5
19313, 1.9083333333333, 0.175, 0.5
19314, 1.9291666666667, 1.3, 0.5
19315, 1.95, 1.325, 0.5
19316, 1.9291666666667, 1.25, 0.5
19317, 1.95, 1.275, 0.5
19318, 1.9291666666667, 1.2, 0.5
19319, 1.95, 1.225, 0.5
19320, 1.9291666666667, 1.15, 0.5
19321, 1.95, 1.175, 0.5
19322, 1.9291666666667, 1.1, 0.5
19323, 1.95, 1.125, 0.5
19324, 1.9291666666667, 1.05, 0.5
19325, 1.95, 1.075, 0.5
19326, 1.9291666666667, 1, 0.5
19327, 1.95, 1.025, 0.5
19328, 1.9291666666667, 0.95, 0.5
19329, 1.95, 0.975, 0.5
19330, 1.9291666666667, 0.9, 0.5
19331, 1.95, 0.925, 0.5
19332, 1.9291666666667, 0.85, 0.5
19333, 1.95, 0.875, 0.5
19334, 1.9291666666667, 0.8, 0.5
19335, 1.95, 0.825, 0.5
19336, 1.9291666666667, 0.75, 0.5
19337, 1.95, 0.775, 0.5
19338, 1.9291666666667, 0.7, 0.5
19339, 1.95, 0.725, 0.5
19340, 1.9291666666667, 0.65, 0.5
19341, 1.95, 0.675, 0.5
19342, 1.9291666666667, 0.6, 0.5
19343, 1.95, 0.625, 0.5
19344, 1.9291666666667, 0.55, 0.5
19345, 1.95, 0.575, 0.5
19346, 1.9291666666667, 0.5, 0.5
19347, 1.95, 0.525, 0.5
19348, 1.9291666666667, 0.45, 0.5
19349, 1.95, 0.475, 0.5
19350, 1.9291666666667, 0.4, 0.5
19351, 1.95, 0.425, 0.5
19352, 1.9291666666667, 0.35, 0.5
19353, 1.95, 0.375, 0.5
19354, 1.9291666666667, 0.3, 0.5
19355, 1.95, 0.325, 0.5
19356, 1.9291666666667, 0.25, 0.5
19357, 1.95, 0.275, 0.5
19358, 1.9291666666667, 0.2, 0.5
19359, 1.95, 0.225, 0.5
19360, 1.95, 0.175, 0.5
19361, 1.9708333333333, 1.3, 0.5
19362, 1.9916666666667, 1.325, 0.5
19363, 1.9708333333333, 1.25, 0.5
19364, 1.9916666666667, 1.275, 0.5
19365, 1.9708333333333, 1.2, 0.5
19366, 1.9916666666667, 1.225, 0.5
19367, 1.9708333333333, 1.15, 0.5
19368, 1.9916666666667, 1.175, 0.5
19369, 1.9708333333333, 1.1, 0.5
19370, 1.9916666666667, 1.125, 0.5
19371, 1.9708333333333, 1.05, 0.5
19372, 1.9916666666667, 1.075, 0.5
19373, 1.9708333333333, 1, 0.5
19374, 1.9916666666667, 1.025, 0.5
19375, 1.9708333333333, 0.95, 0.5
19376, 1.9916666666667, 0.975, 0.5
19377, 1.9708333333333, 0.9, 0.5
19378, 1.9916666666667, 0.925, 0.5
19379, 1.9708333333333, 0.85, 0.5
19380, 1.9916666666667, 0.875, 0.5
19381, 1.9708333333333, 0.8, 0.5
19382, 1.9916666666667, 0.825, 0.5
19383, 1.9708333333333, 0.75, 0.5
19384, 1.9916666666667, 0.775, 0.5
19385, 1.9708333333333, 0.7, 0.5
19386, 1.9916666666667, 0.725, 0.5
19387, 1.9708333333333, 0.65, 0.5
19388, 1.9916666666667, 0.675, 0.5
19389, 1.9708333333333, 0.6, 0.5
19390, 1.9916666666667, 0.625, 0.5
19391, 1.9708333333333, 0.55, 0.5
19392, 1.9916666666667, 0.575, 0.5
19393, 1.9708333333333, 0.5, 0.5
19394, 1.9916666666667, 0.525, 0.5
19395, 1.9708333333333, 0.45, 0.5
19396, 1.9916666666667, 0.475, 0.5
19397, 1.9708333333333, 0.4, 0.5
19398, 1.9916666666667, 0.425, 0.5
19399, 1.9708333333333, 0.35, 0.5
19400, 1.9916666666667, 0.375, 0.5
19401, 1.9708333333333, 0.3, 0.5
19402, 1.9916666666667, 0.325, 0.5
19403, 1.9708333333333, 0.25, 0.5
19404, 1.9916666666667, 0.275, 0.5
19405, 1.9708333333333, 0.2, 0.5
19406, 1.9916666666667, 0.225, 0.5
19407, 1.9916666666667, 0.175, 0.5
19408, 2.0125, 1.3, 0.5
19409, 2.0333333333333, 1.325, 0.5
19410, 2.0125, 1.25, 0.5
19411, 2.0333333333333, 1.275, 0.5
19412, 2.0125, 1.2, 0.5
19413, 2.0333333333333, 1.225, 0.5
19414, 2.0125, 1.15, 0.5
19415, 2.0333333333333, 1.175, 0.5
19416, 2.0125, 1.1, 0.5
19417, 2.0333333333333, 1.125, 0.5
19418, 2.0125, 1.05, 0.5
19419, 2.0333333333333, 1.075, 0.5
19420, 2.0125, 1, 0.5
19421, 2.0333333333333, 1.025, 0.5
19422, 2.0125, 0.95, 0.5
19423, 2.0333333333333, 0.975, 0.5
19424, 2.0125, 0.9, 0.5
19425, 2.0333333333333, 0.925, 0.5
19426, 2.0125, 0.85, 0.5
19427, 2.0333333333333, 0.875, 0.5
19428, 2.0125, 0.8, 0.5
19429, 2.0333333333333, 0.825, 0.5
19430, 2.0125, 0.75, 0.5
19431, 2.0333333333333, 0.775, 0.5
19432, 2.0125, 0.7, 0.5
19433, 2.0333333333333, 0.725, 0.5
19434, 2.0125, 0.65, 0.5
19435, 2.0333333333333, 0.675, 0.5
19436, 2.0125, 0.6, 0.5
19437, 2.0333333333333, 0.625, 0.5
19438, 2.0125, 0.55, 0.5
19439, 2.0333333333333, 0.575, 0.5
19440, 2.0125, 0.5, 0.5
19441, 2.0333333333333, 0.525, 0.5
19442, 2.0125, 0.45, 0.5
19443, 2.0333333333333, 0.475, 0.5
19444, 2.0125, 0.4, 0.5
19445, 2.0333333333333, 0.425, 0.5
19446, 2.0125, 0.35, 0.5
19447, 2.0333333333333, 0.375, 0.5
19448, 2.0125, 0.3, 0.5
19449, 2.0333333333333, 0.325, 0.5
19450, 2.0125, 0.25, 0.5
19451, 2.0333333333333, 0.275, 0.5
19452, 2.0125, 0.2, 0.5
19453, 2.0333333333333, 0.225, 0.5
19454, 2.0333333333333, 0.175, 0.5
19455, 2.0541666666667, 1.3, 0.5
19456, 2.075, 1.325, 0.5
19457, 2.0541666666667, 1.25, 0.5
19458, 2.075, 1.275, 0.5
19459, 2.0541666666667, 1.2, 0.5
19460, 2.075, 1.225, 0.5
19461, 2.0541666666667, 1.15, 0.5
19462, 2.075, 1.175, 0.5
19463, 2.0541666666667, 1.1, 0.5
19464, 2.075, 1.125, 0.5
19465, 2.0541666666667, 1.05, 0.5
19466, 2.075, 1.075, 0.5
19467, 2.0541666666667, 1, 0.5
19468, 2.075, 1.025, 0.5
19469, 2.0541666666667, 0.95, 0.5
19470, 2.075, 0.975, 0.5
19471, 2.0541666666667, 0.9, 0.5
19472, 2.075, 0.925, 0.5
19473, 2.0541666666667, 0.85, 0.5
19474, 2.075, 0.875, 0.5
19475, 2.0541666666667, 0.8, 0.5
19476, 2.075, 0.825, 0.5
19477, 2.0541666666667, 0.75, 0.5
19478, 2.075, 0.775, 0.5
19479, 2.0541666666667, 0.7, 0.5
19480, 2.075, 0.725, 0.5
19481, 2.0541666666667, 0.65, 0.5
19482, 2.075, 0.675, 0.5
19483, 2.0541666666667, 0.6, 0.5
19484, 2.075, 0.625, 0.5
19485, 2.0541666666667, 0.55, 0.5
19486, 2.075, 0.575, 0.5
19487, 2.0541666666667, 0.5, 0.5
19488, 2.075, 0.525, 0.5
19489, 2.0541666666667, 0.45, 0.5
19490, 2.075, 0.475, 0.5
19491, 2.0541666666667, 0.4, 0.5
19492, 2.075, 0.425, 0.5
19493, 2.0541666666667, 0.35, 0.5
19494, 2.075, 0.375, 0.5
19495, 2.0541666666667, 0.3, 0.5
19496, 2.075, 0.325, 0.5
19497, 2.0541666666667, 0.25, 0.5
19498, 2.075, 0.275, 0.5
19499, 2.0541666666667, 0.2, 0.5
19500, 2.075, 0.225, 0.5
19501, 2.075, 0.175, 0.5
19502, 2.0958333333333, 1.3, 0.5
19503, 2.1166666666667, 1.325, 0.5
19504, 2.0958333333333, 1.25, 0.5
19505, 2.1166666666667, 1.275, 0.5
19506, 2.0958333333333, 1.2, 0.5
19507, 2.1166666666667, 1.225, 0.5
19508, 2.0958333333333, 1.15, 0.5
19509, 2.1166666666667, 1.175, 0.5
19510, 2.0958333333333, 1.1, 0.5
19511, 2.1166666666667, 1.125, 0.5
19512, 2.0958333333333, 1.05, 0.5
19513, 2.1166666666667, 1.075, 0.5
19514, 2.0958333333333, 1, 0.5
19515, 2.1166666666667, 1.025, 0.5
19516, 2.0958333333333, 0.95, 0.5
19517, 2.1166666666667, 0.975, 0.5
19518, 2.0958333333333, 0.9, 0.5
19519, 2.1166666666667, 0.925, 0.5
19520, 2.0958333333333, 0.85, 0.5
19521, 2.1166666666667, 0.875, 0.5
19522, 2.0958333333333, 0.8, 0.5
19523, 2.1166666666667, 0.825, 0.5
19524, 2.0958333333333, 0.75, 0.5
19525, 2.1166666666667, 0.775, 0.5
19526, 2.0958333333333, 0.7, 0.5
19527, 2.1166666666667, 0.725, 0.5
19528, 2.0958333333333, 0.65, 0.5
19529, 2.1166666666667, 0.675, 0.5
19530, 2.0958333333333, 0.6, 0.5
19531, 2.1166666666667, 0.625, 0.5
19532, 2.0958333333333, 0.55, 0.5
19533, 2.1166666666667, 0.575, 0.5
19534, 2.0958333333333, 0.5, 0.5
19535, 2.1166666666667, 0.525, 0.5
19536, 2.0958333333333, 0.45, 0.5
19537, 2.1166666666667, 0.475, 0.5
19538, 2.0958333333333, 0.4, 0.5
19539, 2.1166666666667, 0.425, 0.5
19540, 2.0958333333333, 0.35, 0.5
19541, 2.1166666666667, 0.375, 0.5
19542, 2.0958333333333, 0.3, 0.5
19543, 2.1166666666667, 0.325, 0.5
19544, 2.0958333333333, 0.25, 0.5
19545, 2.1166666666667, 0.275, 0.5
19546, 2.0958333333333, 0.2, 0.5
19547, 2.1166666666667, 0.225, 0.5
19548, 2.1166666666667, 0.175, 0.5
19549, 2.1375, 1.3, 0.5
19550, 2.1583333333333, 1.325, 0.5
19551, 2.1375, 1.25, 0.5
19552, 2.1583333333333, 1.275, 0.5
19553, 2.1375, 1.2, 0.5
19554, 2.1583333333333, 1.225, 0.5
19555, 2.1375, 1.15, 0.5
19556, 2.1583333333333, 1.175, 0.5
19557, 2.1375, 1.1, 0.5
19558, 2.1583333333333, 1.125, 0.5
19559, 2.1375, 1.05, 0.5
19560, 2.1583333333333, 1.075, 0.5
19561, 2.1375, 1, 0.5
19562, 2.1583333333333, 1.025, 0.5
19563, 2.1375, 0.95, 0.5
19564, 2.1583333333333, 0.975, 0.5
19565, 2.1375, 0.9, 0.5
19566, 2.1583333333333, 0.925, 0.5
19567, 2.1375, 0.85, 0.5
19568, 2.1583333333333, 0.875, 0.5
19569, 2.1375, 0.8, 0.5
19570, 2.1583333333333, 0.825, 0.5
19571, 2.1375, 0.75, 0.5
19572, 2.1583333333333, 0.775, 0.5
19573, 2.1375, 0.7, 0.5
19574, 2.1583333333333, 0.725, 0.5
19575, 2.1375, 0.65, 0.5
19576, 2.1583333333333, 0.675, 0.5
19577, 2.1375, 0.6, 0.5
19578, 2.1583333333333, 0.625, 0.5
19579, 2.1375, 0.55, 0.5
19580, 2.1583333333333, 0.575, 0.5
19581, 2.1375, 0.5, 0.5
19582, 2.1583333333333, 0.525, 0.5
19583, 2.1375, 0.45, 0.5
19584, 2.1583333333333, 0.475, 0.5
19585, 2.1375, 0.4, 0.5
19586, 2.1583333333333, 0.425, 0.5
19587, 2.1375, 0.35, 0.5
19588, 2.1583333333333, 0.375, 0.5
19589, 2.1375, 0.3, 0.5
19590, 2.1583333333333, 0.325, 0.5
19591, 2.1375, 0.25, 0.5
19592, 2.1583333333333, 0.275, 0.5
19593, 2.1375, 0.2, 0.5
19594, 2.1583333333333, 0.225, 0.5
19595, 2.1583333333333, 0.175, 0.5
19596, 2.1791666666667, 1.3, 0.5
19597, 2.1791666666667, 1.25, 0.5
19598, 2.1791666666667, 1.2, 0.5
19599, 2.1791666666667, 1.15, 0.5
19600, 2.1791666666667, 1.1, 0.5
19601, 2.1791666666667, 1.05, 0.5
19602, 2.1791666666667, 1, 0.5
19603, 2.1791666666667, 0.95, 0.5
19604, 2.1791666666667, 0.9, 0.5
19605, 2.1791666666667, 0.85, 0.5
19606, 2.1791666666667, 0.8, 0.5
19607, 2.1791666666667, 0.75, 0.5
19608, 2.1791666666667, 0.7, 0.5
19609, 2.1791666666667, 0.65, 0.5
19610, 2.1791666666667, 0.6, 0.5
19611, 2.1791666666667, 0.55, 0.5
19612, 2.1791666666667, 0.5, 0.5
19613, 2.1791666666667, 0.45, 0.5
19614, 2.1791666666667, 0.4, 0.5
19615, 2.1791666666667, 0.35, 0.5
19616, 2.1791666666667, 0.3, 0.5
19617, 2.1791666666667, 0.25, 0.5
19618, 2.1791666666667, 0.2, 0.5
19619, 1.2416666666667, 1.3, 0
19620, 1.2416666666667, 1.25, 0
19621, 1.2416666666667, 1.2, 0
19622, 1.2416666666667, 1.15, 0
19623, 1.2416666666667, 1.1, 0
19624, 1.2416666666667, 1.05, 0
19625, 1.2416666666667, 1, 0
19626, 1.2416666666667, 0.95, 0
19627, 1.2416666666667, 0.9, 0
19628, 1.2416666666667, 0.85, 0
19629, 1.2416666666667, 0.8, 0
19630, 1.2416666666667, 0.75, 0
19631, 1.2416666666667, 0.7, 0
19632, 1.2416666666667, 0.65, 0
19633, 1.2416666666667, 0.6, 0
19634, 1.2416666666667, 0.55, 0
19635, 1.2416666666667, 0.5, 0
19636, 1.2416666666667, 0.45, 0
19637, 1.2416666666667, 0.4, 0
19638, 1.2416666666667, 0.35, 0
19639, 1.2416666666667, 0.3, 0
19640, 1.2416666666667, 0.25, 0
19641, 1.2416666666667, 0.2, 0
19642, 1.2833333333333, 1.3, 0
19643, 1.2833333333333, 1.25, 0
19644, 1.2833333333333, 1.2, 0
19645, 1.2833333333333, 1.15, 0
19646, 1.2833333333333, 1.1, 0
19647, 1.2833333333333, 1.05, 0
19648, 1.2833333333333, 1, 0
19649, 1.2833333333333, 0.95, 0
19650, 1.2833333333333, 0.9, 0
19651, 1.2833333333333, 0.85, 0
19652, 1.2833333333333, 0.8, 0
19653, 1.2833333333333, 0.75, 0
19654, 1.2833333333333, 0.7, 0
19655, 1.2833333333333, 0.65, 0
19656, 1.2833333333333, 0.6, 0
19657, 1.2833333333333, 0.55, 0
19658, 1.2833333333333, 0.5, 0
19659, 1.2833333333333, 0.45, 0
19660, 1.2833333333333, 0.4, 0
19661, 1.2833333333333, 0.35, 0
19662, 1.2833333333333, 0.3, 0
19663, 1.2833333333333, 0.25, 0
19664, 1.2833333333333, 0.2, 0
19665, 1.325, 1.3, 0
19666, 1.325, 1.25, 0
19667, 1.325, 1.2, 0
19668, 1.325, 1.15, 0
19669, 1.325, 1.1, 0
19670, 1.325, 1.05, 0
19671, 1.325, 1, 0
19672, 1.325, 0.95, 0
19673, 1.325, 0.9, 0
19674, 1.325, 0.85, 0
19675, 1.325, 0.8, 0
19676, 1.325, 0.75, 0
19677, 1.325, 0.7, 0
19678, 1.325, 0.65, 0
19679, 1.325, 0.6, 0
19680, 1.325, 0.55, 0
19681, 1.325, 0.5, 0
19682, 1.325, 0.45, 0
19683, 1.325, 0.4, 0
19684, 1.325, 0.35, 0
19685, 1.325, 0.3, 0
19686, 1.325, 0.25, 0
19687, 1.325, 0.2, 0
19688, 1.3666666666667, 1.3, 0
19689, 1.3666666666667, 1.25, 0
19690, 1.3666666666667, 1.2, 0
19691, 1.3666666666667, 1.15, 0
19692, 1.3666666666667, 1.1, 0
19693, 1.3666666666667, 1.05, 0
19694, 1.3666666666667, 1, 0
19695, 1.3666666666667, 0.95, 0
19696, 1.3666666666667, 0.9, 0
19697, 1.3666666666667, 0.85, 0
19698, 1.3666666666667, 0.8, 0
19699, 1.3666666666667, 0.75, 0
19700, 1.3666666666667, 0.7, 0
19701, 1.3666666666667, 0.65, 0
19702, 1.3666666666667, 0.6, 0
19703, 1.3666666666667, 0.55, 0
19704, 1.3666666666667, 0.5, 0
19705, 1.3666666666667, 0.45, 0
19706, 1.3666666666667, 0.4, 0
19707, 1.3666666666667, 0.35, 0
19708, 1.3666666666667, 0.3, 0
19709, 1.3666666666667, 0.25, 0
19710, 1.3666666666667, 0.2, 0
19711, 1.4083333333333, 1.3, 0
19712, 1.4083333333333, 1.25, 0
19713, 1.4083333333333, 1.2, 0
19714, 1.4083333333333, 1.15, 0
19715, 1.4083333333333, 1.1, 0
19716, 1.4083333333333, 1.05, 0
19717, 1.4083333333333, 1, 0
19718, 1.4083333333333, 0.95, 0
19719, 1.4083333333333, 0.9, 0
19720, 1.4083333333333, 0.85, 0
19721, 1.4083333333333, 0.8, 0
19722, 1.4083333333333, 0.75, 0
19723, 1.4083333333333, 0.7, 0
19724, 1.4083333333333, 0.65, 0
19725, 1.4083333333333, 0.6, 0
19726, 1.4083333333333, 0.55, 0
19727, 1.4083333333333, 0.5, 0
19728, 1.4083333333333, 0.45, 0
19729, 1.4083333333333, 0.4, 0
19730, 1.4083333333333, 0.35, 0
19731, 1.4083333333333, 0.3, 0
19732, 1.4083333333333, 0.25, 0
19733, 1.4083333333333, 0.2, 0
19734, 1.45, 1.3, 0
19735, 1.45, 1.25, 0
19736, 1.45, 1.2, 0
19737, 1.45, 1.15, 0
19738, 1.45, 1.1, 0
19739, 1.45, 1.05, 0
19740, 1.45, 1, 0
19741, 1.45, 0.95, 0
19742, 1.45, 0.9, 0
19743, 1.45, 0.85, 0
19744, 1.45, 0.8, 0
19745, 1.45, 0.75, 0
19746, 1.45, 0.7, 0
19747, 1.45, 0.65, 0
19748, 1.45, 0.6, 0
19749, 1.45, 0.55, 0
19750, 1.45, 0.5, 0
19751, 1.45, 0.45, 0
19752, 1.45, 0.4, 0
19753, 1.45, 0.35, 0
19754, 1.45, 0.3, 0
19755, 1.45, 0.25, 0
19756, 1.45, 0.2, 0
19757, 1.4916666666667, 1.3, 0
19758, 1.4916666666667, 1.25, 0
19759, 1.4916666666667, 1.2, 0
19760, 1.4916666666667, 1.15, 0
19761, 1.4916666666667, 1.1, 0
19762, 1.4916666666667, 1.05, 0
19763, 1.4916666666667, 1, 0
19764, 1.4916666666667, 0.95, 0
19765, 1.4916666666667, 0.9, 0
19766, 1.4916666666667, 0.85, 0
19767, 1.4916666666667, 0.8, 0
19768, 1.4916666666667, 0.75, 0
19769, 1.4916666666667, 0.7, 0
19770, 1.4916666666667, 0.65, 0
19771, 1.4916666666667, 0.6, 0
19772, 1.4916666666667, 0.55, 0
19773, 1.4916666666667, 0.5, 0
19774, 1.4916666666667, 0.45, 0
19775, 1.4916666666667, 0.4, 0
19776, 1.4916666666667, 0.35, 0
19777, 1.4916666666667, 0.3, 0
19778, 1.4916666666667, 0.25, 0
19779, 1.4916666666667, 0.2, 0
19780, 1.5333333333333, 1.3, 0
19781, 1.5333333333333, 1.25, 0
19782, 1.5333333333333, 1.2, 0
19783, 1.5333333333333, 1.15, 0
19784, 1.5333333333333, 1.1, 0
19785, 1.5333333333333, 1.05, 0
19786, 1.5333333333333, 1, 0
19787, 1.5333333333333, 0.95, 0
19788, 1.5333333333333, 0.9, 0
19789, 1.5333333333333, 0.85, 0
19790, 1.5333333333333, 0.8, 0
19791, 1.5333333333333, 0.75, 0
19792, 1.5333333333333, 0.7, 0
19793, 1.5333333333333, 0.65, 0
19794, 1.5333333333333, 0.6, 0
19795, 1.5333333333333, 0.55, 0
19796, 1.5333333333333, 0.5, 0
19797, 1.5333333333333, 0.45, 0
19798, 1.5333333333333, 0.4, 0
19799, 1.5333333333333, 0.35, 0
19800, 1.5333333333333, 0.3, 0
19801, 1.5333333333333, 0.25, 0
19802, 1.5333333333333, 0.2, 0
19803, 1.575, 1.3, 0
19804, 1.575, 1.25, 0
19805, 1.575, 1.2, 0
19806, 1.575, 1.15, 0
19807, 1.575, 1.1, 0
19808, 1.575, 1.05, 0
19809, 1.575, 1, 0
19810, 1.575, 0.95, 0
19811, 1.575, 0.9, 0
19812, 1.575, 0.85, 0
19813, 1.575, 0.8, 0
19814, 1.575, 0.75, 0
19815, 1.575, 0.7, 0
19816, 1.575, 0.65, 0
19817, 1.575, 0.6, 0
19818, 1.575, 0.55, 0
19819, 1.575, 0.5, 0
19820, 1.575, 0.45, 0
19821, 1.575, 0.4, 0
19822, 1.575, 0.35, 0
19823, 1.575, 0.3, 0
19824, 1.575, 0.25, 0
19825, 1.575, 0.2, 0
19826, 1.6166666666667, 1.3, 0
19827, 1.6166666666667, 1.25, 0
19828, 1.6166666666667, 1.2, 0
19829, 1.6166666666667, 1.15, 0
19830, 1.6166666666667, 1.1, 0
19831, 1.6166666666667, 1.05, 0
19832, 1.6166666666667, 1, 0
19833, 1.6166666666667, 0.95, 0
19834, 1.6166666666667, 0.9, 0
19835, 1.6166666666667, 0.85, 0
19836, 1.6166666666667, 0.8, 0
19837, 1.6166666666667, 0.75, 0
19838, 1.6166666666667, 0.7, 0
19839, 1.6166666666667, 0.65, 0
19840, 1.6166666666667, 0.6, 0
19841, 1.6166666666667, 0.55, 0
19842, 1.6166666666667, 0.5, 0
19843, 1.6166666666667, 0.45, 0
19844, 1.6166666666667, 0.4, 0
19845, 1.6166666666667, 0.35, 0
19846, 1.6166666666667, 0.3, 0
19847, 1.6166666666667, 0.25, 0
19848, 1.6166666666667, 0.2, 0
19849, 1.6583333333333, 1.3, 0
19850, 1.6583333333333, 1.25, 0
19851, 1.6583333333333, 1.2, 0
19852, 1.6583333333333, 1.15, 0
19853, 1.6583333333333, 1.1, 0
19854, 1.6583333333333, 1.05, 0
19855, 1.6583333333333, 1, 0
19856, 1.6583333333333, 0.95, 0
19857, 1.6583333333333, 0.9, 0
19858, 1.6583333333333, 0.85, 0
19859, 1.6583333333333, 0.8, 0
19860, 1.6583333333333, 0.75, 0
19861, 1.6583333333333, 0.7, 0
19862, 1.6583333333333, 0.65, 0
19863, 1.6583333333333, 0.6, 0
19864, 1.6583333333333, 0.55, 0
19865, 1.6583333333333, 0.5, 0
19866, 1.6583333333333, 0.45, 0
19867, 1.6583333333333, 0.4, 0
19868, 1.6583333333333, 0.35, 0
19869, 1.6583333333333, 0.3, 0
19870, 1.6583333333333, 0.25, 0
19871, 1.6583333333333, 0.2, 0
19872, 1.7, 1.3, 0
19873, 1.7, 1.25, 0
19874, 1.7, 1.2, 0
19875, 1.7, 1.15, 0
19876, 1.7, 1.1, 0
19877, 1.7, 1.05, 0
19878, 1.7, 1, 0
19879, 1.7, 0.95, 0
19880, 1.7, 0.9, 0
19881, 1.7, 0.85, 0
19882, 1.7, 0.8, 0
19883, 1.7, 0.75, 0
19884, 1.7, 0.7, 0
19885, 1.7, 0.65, 0
19886, 1.7, 0.6, 0
19887, 1.7, 0.55, 0
19888, 1.7, 0.5, 0
19889, 1.7, 0.45, 0
19890, 1.7, 0.4, 0
19891, 1.7, 0.35, 0
19892, 1.7, 0.3, 0
19893, 1.7, 0.25, 0
19894, 1.7, 0.2, 0
19895, 1.7416666666667, 1.3, 0
19896, 1.7416666666667, 1.25, 0
19897, 1.7416666666667, 1.2, 0
19898, 1.7416666666667, 1.15, 0
19899, 1.7416666666667, 1.1, 0
19900, 1.7416666666667, 1.05, 0
19901, 1.7416666666667, 1, 0
19902, 1.7416666666667, 0.95, 0
19903, 1.7416666666667, 0.9, 0
19904, 1.7416666666667, 0.85, 0
19905, 1.7416666666667, 0.8, 0
19906, 1.7416666666667, 0.75, 0
19907, 1.7416666666667, 0.7, 0
19908, 1.7416666666667, 0.65, 0
19909, 1.7416666666667, 0.6, 0
19910, 1.7416666666667, 0.55, 0
19911, 1.7416666666667, 0.5, 0
19912, 1.7416666666667, 0.45, 0
19913, 1.7416666666667, 0.4, 0
19914, 1.7416666666667, 0.35, 0
19915, 1.7416666666667, 0.3, 0
19916, 1.7416666666667, 0.25, 0
19917, 1.7416666666667, 0.2, 0
19918, 1.7833333333333, 1.3, 0
19919, 1.7833333333333, 1.25, 0
19920, 1.7833333333333, 1.2, 0
19921, 1.7833333333333, 1.15, 0
19922, 1.7833333333333, 1.1, 0
19923, 1.7833333333333, 1.05, 0
19924, 1.7833333333333, 1, 0
19925, 1.7833333333333, 0.95, 0
19926, 1.7833333333333, 0.9, 0
19927, 1.7833333333333, 0.85, 0
19928, 1.7833333333333, 0.8, 0
19929, 1.7833333333333, 0.75, 0
19930, 1.7833333333333, 0.7, 0
19931, 1.7833333333333, 0.65, 0
19932, 1.7833333333333, 0.6, 0
19933, 1.7833333333333, 0.55, 0
19934, 1.7833333333333, 0.5, 0
19935, 1.7833333333333, 0.45, 0
19936, 1.7833333333333, 0.4, 0
19937, 1.7833333333333, 0.35, 0
19938, 1.7833333333333, 0.3, 0
19939, 1.7833333333333, 0.25, 0
19940, 1.7833333333333, 0.2, 0
19941, 1.825, 1.3, 0
19942, 1.825, 1.25, 0
19943, 1.825, 1.2, 0
19944, 1.825, 1.15, 0
19945, 1.825, 1.1, 0
19946, 1.825, 1.05, 0
19947, 1.825, 1, 0
19948, 1.825, 0.95, 0
19949, 1.825, 0.9, 0
19950, 1.825, 0.85, 0
19951, 1.825, 0.8, 0
19952, 1.825, 0.75, 0
19953, 1.825, 0.7, 0
19954, 1.825, 0.65, 0
19955, 1.825, 0.6, 0
19956, 1.825, 0.55, 0
19957, 1.825, 0.5, 0
19958, 1.825, 0.45, 0
19959, 1.825, 0.4, 0
19960, 1.825, 0.35, 0
19961, 1.825, 0.3, 0
19962, 1.825, 0.25, 0
19963, 1.825, 0.2, 0
19964, 1.8666666666667, 1.3, 0
19965, 1.8666666666667, 1.25, 0
19966, 1.8666666666667, 1.2, 0
19967, 1.8666666666667, 1.15, 0
19968, 1.8666666666667, 1.1, 0
19969, 1.8666666666667, 1.05, 0
19970, 1.8666666666667, 1, 0
19971, 1.8666666666667, 0.95, 0
19972, 1.8666666666667, 0.9, 0
19973, 1.8666666666667, 0.85, 0
19974, 1.8666666666667, 0.8, 0
19975, 1.8666666666667, 0.75, 0
19976, 1.8666666666667, 0.7, 0
19977, 1.8666666666667, 0.65, 0
19978, 1.8666666666667, 0.6, 0
19979, 1.8666666666667, 0.55, 0
19980, 1.8666666666667, 0.5, 0
19981, 1.8666666666667, 0.45, 0
19982, 1.8666666666667, 0.4, 0
19983, 1.8666666666667, 0.35, 0
19984, 1.8666666666667, 0.3, 0
19985, 1.8666666666667, 0.25, 0
19986, 1.8666666666667, 0.2, 0
19987, 1.9083333333333, 1.3, 0
19988, 1.9083333333333, 1.25, 0
19989, 1.9083333333333, 1.2, 0
19990, 1.9083333333333, 1.15, 0
19991, 1.9083333333333, 1.1, 0
19992, 1.9083333333333, 1.05, 0
19993, 1.9083333333333, 1, 0
19994, 1.9083333333333, 0.95, 0
19995, 1.9083333333333, 0.9, 0
19996, 1.9083333333333, 0.85, 0
19997, 1.9083333333333, 0.8, 0
19998, 1.9083333333333, 0.75, 0
19999, 1.9083333333333, 0.7, 0
20000, 1.9083333333333, 0.65, 0
20001, 1.9083333333333, 0.6, 0
20002, 1.9083333333333, 0.55, 0
20003, 1.9083333333333, 0.5, 0
20004, 1.9083333333333, 0.45, 0
20005, 1.9083333333333, 0.4, 0
20006, 1.9083333333333, 0.35, 0
20007, 1.9083333333333, 0.3, 0
20008, 1.9083333333333, 0.25, 0
20009, 1.9083333333333, 0.2, 0
20010, 1.95, 1.3, 0
20011, 1.95, 1.25, 0
20012, 1.95, 1.2, 0
20013, 1.95, 1.15, 0
20014, 1.95, 1.1, 0
20015, 1.95, 1.05, 0
20016, 1.95, 1, 0
20017, 1.95, 0.95, 0
20018, 1.95, 0.9, 0
20019, 1.95, 0.85, 0
20020, 1.95, 0.8, 0
20021, 1.95, 0.75, 0
20022, 1.95, 0.7, 0
20023, 1.95, 0.65, 0
20024, 1.95, 0.6, 0
20025, 1.95, 0.55, 0
20026, 1.95, 0.5, 0
20027, 1.95, 0.45, 0
20028, 1.95, 0.4, 0
20029, 1.95, 0.35, 0
20030, 1.95, 0.3, 0
20031, 1.95, 0.25, 0
20032, 1.95, 0.2, 0
20033, 1.9916666666667, 1.3, 0
20034, 1.9916666666667, 1.25, 0
20035, 1.9916666666667, 1.2, 0
20036, 1.9916666666667, 1.15, 0
20037, 1.9916666666667, 1.1, 0
20038, 1.9916666666667, 1.05, 0
20039, 1.9916666666667, 1, 0
20040, 1.9916666666667, 0.95, 0
20041, 1.9916666666667, 0.9, 0
20042, 1.9916666666667, 0.85, 0
20043, 1.9916666666667, 0.8, 0
20044, 1.9916666666667, 0.75, 0
20045, 1.9916666666667, 0.7, 0
20046, 1.9916666666667, 0.65, 0
20047, 1.9916666666667, 0.6, 0
20048, 1.9916666666667, 0.55, 0
20049, 1.9916666666667, 0.5, 0
20050, 1.9916666666667, 0.45, 0
20051, 1.9916666666667, 0.4, 0
20052, 1.9916666666667, 0.35, 0
20053, 1.9916666666667, 0.3, 0
20054, 1.9916666666667, 0.25, 0
20055, 1.9916666666667, 0.2, 0
20056, 2.0333333333333, 1.3, 0
20057, 2.0333333333333, 1.25, 0
20058, 2.0333333333333, 1.2, 0
20059, 2.0333333333333, 1.15, 0
20060, 2.0333333333333, 1.1, 0
20061, 2.0333333333333, 1.05, 0
20062, 2.0333333333333, 1, 0
20063, 2.0333333333333, 0.95, 0
20064, 2.0333333333333, 0.9, 0
20065, 2.0333333333333, 0.85, 0
20066, 2.0333333333333, 0.8, 0
20067, 2.0333333333333, 0.75, 0
20068, 2.0333333333333, 0.7, 0
20069, 2.0333333333333, 0.65, 0
20070, 2.0333333333333, 0.6, 0
20071, 2.0333333333333, 0.55, 0
20072, 2.0333333333333, 0.5, 0
20073, 2.0333333333333, 0.45, 0
20074, 2.0333333333333, 0.4, 0
20075, 2.0333333333333, 0.35, 0
20076, 2.0333333333333, 0.3, 0
20077, 2.0333333333333, 0.25, 0
20078, 2.0333333333333, 0.2, 0
20079, 2.075, 1.3, 0
20080, 2.075, 1.25, 0
20081, 2.075, 1.2, 0
20082, 2.075, 1.15, 0
20083, 2.075, 1.1, 0
20084, 2.075, 1.05, 0
20085, 2.075, 1, 0
20086, 2.075, 0.95, 0
20087, 2.075, 0.9, 0
20088, 2.075, 0.85, 0
20089, 2.075, 0.8, 0
20090, 2.075, 0.75, 0
20091, 2.075, 0.7, 0
20092, 2.075, 0.65, 0
20093, 2.075, 0.6, 0
20094, 2.075, 0.55, 0
20095, 2.075, 0.5, 0
20096, 2.075, 0.45, 0
20097, 2.075, 0.4, 0
20098, 2.075, 0.35, 0
20099, 2.075, 0.3, 0
20100, 2.075, 0.25, 0
20101, 2.075, 0.2, 0
20102, 2.1166666666667, 1.3, 0
20103, 2.1166666666667, 1.25, 0
20104, 2.1166666666667, 1.2, 0
20105, 2.1166666666667, 1.15, 0
20106, 2.1166666666667, 1.1, 0
20107, 2.1166666666667, 1.05, 0
20108, 2.1166666666667, 1, 0
20109, 2.1166666666667, 0.95, 0
20110, 2.1166666666667, 0.9, 0
20111, 2.1166666666667, 0.85, 0
20112, 2.1166666666667, 0.8, 0
20113, 2.1166666666667, 0.75, 0
20114, 2.1166666666667, 0.7, 0
20115, 2.1166666666667, 0.65, 0
20116, 2.1166666666667, 0.6, 0
20117, 2.1166666666667, 0.55, 0
20118, 2.1166666666667, 0.5, 0
20119, 2.1166666666667, 0.45, 0
20120, 2.1166666666667, 0.4, 0
20121, 2.1166666666667, 0.35, 0
20122, 2.1166666666667, 0.3, 0
20123, 2.1166666666667, 0.25, 0
20124, 2.1166666666667, 0.2, 0
20125, 2.1583333333333, 1.3, 0
20126, 2.1583333333333, 1.25, 0
20127, 2.1583333333333, 1.2, 0
20128, 2.1583333333333, 1.15, 0
20129, 2.1583333333333, 1.1, 0
20130, 2.1583333333333, 1.05, 0
20131, 2.1583333333333, 1, 0
20132, 2.1583333333333, 0.95, 0
20133, 2.1583333333333, 0.9, 0
20134, 2.1583333333333, 0.85, 0
20135, 2.1583333333333, 0.8, 0
20136, 2.1583333333333, 0.75, 0
20137, 2.1583333333333, 0.7, 0
20138, 2.1583333333333, 0.65, 0
20139, 2.1583333333333, 0.6, 0
20140, 2.1583333333333, 0.55, 0
20141, 2.1583333333333, 0.5, 0
20142, 2.1583333333333, 0.45, 0
20143, 2.1583333333333, 0.4, 0
20144, 2.1583333333333, 0.35, 0
20145, 2.1583333333333, 0.3, 0
20146, 2.1583333333333, 0.25, 0
20147, 2.1583333333333, 0.2, 0
20148, 1.2416666666667, 1.325, 0
20149, 1.2208333333333, 1.3, 0
20150, 1.2416666666667, 1.275, 0
20151, 1.2208333333333, 1.25, 0
20152, 1.2416666666667, 1.225, 0
20153, 1.2208333333333, 1.2, 0
20154, 1.2416666666667, 1.175, 0
20155, 1.2208333333333, 1.15, 0
20156, 1.2416666666667, 1.125, 0
20157, 1.2208333333333, 1.1, 0
20158, 1.2416666666667, 1.075, 0
20159, 1.2208333333333, 1.05, 0
20160, 1.2416666666667, 1.025, 0
20161, 1.2208333333333, 1, 0
20162, 1.2416666666667, 0.975, 0
20163, 1.2208333333333, 0.95, 0
20164, 1.2416666666667, 0.925, 0
20165, 1.2208333333333, 0.9, 0
20166, 1.2416666666667, 0.875, 0
20167, 1.2208333333333, 0.85, 0
20168, 1.2416666666667, 0.825, 0
20169, 1.2208333333333, 0.8, 0
20170, 1.2416666666667, 0.775, 0
20171, 1.2208333333333, 0.75, 0
20172, 1.2416666666667, 0.725, 0
20173, 1.2208333333333, 0.7, 0
20174, 1.2416666666667, 0.675, 0
20175, 1.2208333333333, 0.65, 0
20176, 1.2416666666667, 0.625, 0
20177, 1.2208333333333, 0.6, 0
20178, 1.2416666666667, 0.575, 0
20179, 1.2208333333333, 0.55, 0
20180, 1.2416666666667, 0.525, 0
20181, 1.2208333333333, 0.5, 0
20182, 1.2416666666667, 0.475, 0
20183, 1.2208333333333, 0.45, 0
20184, 1.2416666666667, 0.425, 0
20185, 1.2208333333333, 0.4, 0
20186, 1.2416666666667, 0.375, 0
20187, 1.2208333333333, 0.35, 0
20188, 1.2416666666667, 0.325, 0
20189, 1.2208333333333, 0.3, 0
20190, 1.2416666666667, 0.275, 0
20191, 1.2208333333333, 0.25, 0
20192, 1.2416666666667, 0.225, 0
20193, 1.2208333333333, 0.2, 0
20194, 1.2416666666667, 0.175, 0
20195, 1.2833333333333, 1.325, 0
20196, 1.2625, 1.3, 0
20197, 1.2833333333333, 1.275, 0
20198, 1.2625, 1.25, 0
20199, 1.2833333333333, 1.225, 0
20200, 1.2625, 1.2, 0
20201, 1.2833333333333, 1.175, 0
20202, 1.2625, 1.15, 0
20203, 1.2833333333333, 1.125, 0
20204, 1.2625, 1.1, 0
20205, 1.2833333333333, 1.075, 0
20206, 1.2625, 1.05, 0
20207, 1.2833333333333, 1.025, 0
20208, 1.2625, 1, 0
20209, 1.2833333333333, 0.975, 0
20210, 1.2625, 0.95, 0
20211, 1.2833333333333, 0.925, 0
20212, 1.2625, 0.9, 0
20213, 1.2833333333333, 0.875, 0
20214, 1.2625, 0.85, 0
20215, 1.2833333333333, 0.825, 0
20216, 1.2625, 0.8, 0
20217, 1.2833333333333, 0.775, 0
20218, 1.2625, 0.75, 0
20219, 1.2833333333333, 0.725, 0
20220, 1.2625, 0.7, 0
20221, 1.2833333333333, 0.675, 0
20222, 1.2625, 0.65, 0
20223, 1.2833333333333, 0.625, 0
20224, 1.2625, 0.6, 0
20225, 1.2833333333333, 0.575, 0
20226, 1.2625, 0.55, 0
20227, 1.2833333333333, 0.525, 0
20228, 1.2625, 0.5, 0
20229, 1.2833333333333, 0.475, 0
20230, 1.2625, 0.45, 0
20231, 1.2833333333333, 0.425, 0
20232, 1.2625, 0.4, 0
20233, 1.2833333333333, 0.375, 0
20234, 1.2625, 0.35, 0
20235, 1.2833333333333, 0.325, 0
20236, 1.2625, 0.3, 0
20237, 1.2833333333333, 0.275, 0
20238, 1.2625, 0.25, 0
20239, 1.2833333333333, 0.225, 0
20240, 1.2625, 0.2, 0
20241, 1.2833333333333, 0.175, 0
20242, 1.325, 1.325, 0
20243, 1.3041666666667, 1.3, 0
20244, 1.325, 1.275, 0
20245, 1.3041666666667, 1.25, 0
20246, 1.325, 1.225, 0
20247, 1.3041666666667, 1.2, 0
20248, 1.325, 1.175, 0
20249, 1.3041666666667, 1.15, 0
20250, 1.325, 1.125, 0
20251, 1.3041666666667, 1.1, 0
20252, 1.325, 1.075, 0
20253, 1.3041666666667, 1.05, 0
20254, 1.325, 1.025, 0
20255, 1.3041666666667, 1, 0
20256, 1.325, 0.975, 0
20257, 1.3041666666667, 0.95, 0
20258, 1.325, 0.925, 0
20259, 1.3041666666667, 0.9, 0
20260, 1.325, 0.875, 0
20261, 1.3041666666667, 0.85, 0
20262, 1.325, 0.825, 0
20263, 1.3041666666667, 0.8, 0
20264, 1.325, 0.775, 0
20265, 1.3041666666667, 0.75, 0
20266, 1.325, 0.725, 0
20267, 1.3041666666667, 0.7, 0
20268, 1.325, 0.675, 0
20269, 1.3041666666667, 0.65, 0
20270, 1.325, 0.625, 0
20271, 1.3041666666667, 0.6, 0
20272, 1.325, 0.575, 0
20273, 1.3041666666667, 0.55, 0
20274, 1.325, 0.525, 0
20275, 1.3041666666667, 0.5, 0
20276, 1.325, 0.475, 0
20277, 1.3041666666667, 0.45, 0
20278, 1.325, 0.425, 0
20279, 1.3041666666667, 0.4, 0
20280, 1.325, 0.375, 0
20281, 1.3041666666667, 0.35, 0
20282, 1.325, 0.325, 0
20283, 1.3041666666667, 0.3, 0
20284, 1.325, 0.275, 0
20285, 1.3041666666667, 0.25, 0
20286, 1.325, 0.225, 0
20287, 1.3041666666667, 0.2, 0
20288, 1.325, 0.175, 0
20289, 1.3666666666667, 1.325, 0
20290, 1.3458333333333, 1.3, 0
20291, 1.3666666666667, 1.275, 0
20292, 1.3458333333333, 1.25, 0
20293, 1.3666666666667, 1.225, 0
20294, 1.3458333333333, 1.2, 0
20295, 1.3666666666667, 1.175, 0
20296, 1.3458333333333, 1.15, 0
20297, 1.3666666666667, 1.125, 0
20298, 1.3458333333333, 1.1, 0
20299, 1.3666666666667, 1.075, 0
20300, 1.3458333333333, 1.05, 0
20301, 1.3666666666667, 1.025, 0
20302, 1.3458333333333, 1, 0
20303, 1.3666666666667, 0.975, 0
20304, 1.3458333333333, 0.95, 0
20305, 1.3666666666667, 0.925, 0
20306, 1.3458333333333, 0.9, 0
20307, 1.3666666666667, 0.875, 0
20308, 1.3458333333333, 0.85, 0
20309, 1.3666666666667, 0.825, 0
20310, 1.3458333333333, 0.8, 0
20311, 1.3666666666667, 0.775, 0
20312, 1.3458333333333, 0.75, 0
20313, 1.3666666666667, 0.725, 0
20314, 1.3458333333333, 0.7, 0
20315, 1.3666666666667, 0.675, 0
20316, 1.3458333333333, 0.65, 0
20317, 1.3666666666667, 0.625, 0
20318, 1.3458333333333, 0.6, 0
20319, 1.3666666666667, 0.575, 0
20320, 1.3458333333333, 0.55, 0
20321, 1.3666666666667, 0.525, 0
20322, 1.3458333333333, 0.5, 0
20323, 1.3666666666667, 0.475, 0
20324, 1.3458333333333, 0.45, 0
20325, 1.3666666666667, 0.425, 0
20326, 1.3458333333333, 0.4, 0
20327, 1.3666666666667, 0.375, 0
20328, 1.3458333333333, 0.35, 0
20329, 1.3666666666667, 0.325, 0
20330, 1.3458333333333, 0.3, 0
20331, 1.3666666666667, 0.275, 0
20332, 1.3458333333333, 0.25, 0
20333, 1.3666666666667, 0.225, 0
20334, 1.3458333333333, 0.2, 0
20335, 1.3666666666667, 0.175, 0
20336, 1.4083333333333, 1.325, 0
20337, 1.3875, 1.3, 0
20338, 1.4083333333333, 1.275, 0
20339, 1.3875, 1.25, 0
20340, 1.4083333333333, 1.225, 0
20341, 1.3875, 1.2, 0
20342, 1.4083333333333, 1.175, 0
20343, 1.3875, 1.15, 0
20344, 1.4083333333333, 1.125, 0
20345, 1.3875, 1.1, 0
20346, 1.4083333333333, 1.075, 0
20347, 1.3875, 1.05, 0
20348, 1.4083333333333, 1.025, 0
20349, 1.3875, 1, 0
20350, 1.4083333333333, 0.975, 0
20351, 1.3875, 0.95, 0
20352, 1.4083333333333, 0.925, 0
20353, 1.3875, 0.9, 0
20354, 1.4083333333333, 0.875, 0
20355, 1.3875, 0.85, 0
20356, 1.4083333333333, 0.825, 0
20357, 1.3875, 0.8, 0
20358, 1.4083333333333, 0.775, 0
20359, 1.3875, 0.75, 0
20360, 1.4083333333333, 0.725, 0
20361, 1.3875, 0.7, 0
20362, 1.4083333333333, 0.675, 0
20363, 1.3875, 0.65, 0
20364, 1.4083333333333, 0.625, 0
20365, 1.3875, 0.6, 0
20366, 1.4083333333333, 0.575, 0
20367, 1.3875, 0.55, 0
20368, 1.4083333333333, 0.525, 0
20369, 1.3875, 0.5, 0
20370, 1.4083333333333, 0.475, 0
20371, 1.3875, 0.45, 0
20372, 1.4083333333333, 0.425, 0
20373, 1.3875, 0.4, 0
20374, 1.4083333333333, 0.375, 0
20375, 1.3875, 0.35, 0
20376, 1.4083333333333, 0.325, 0
20377, 1.3875, 0.3, 0
20378, 1.4083333333333, 0.275, 0
20379, 1.3875, 0.25, 0
20380, 1.4083333333333, 0.225, 0
20381, 1.3875, 0.2, 0
20382, 1.4083333333333, 0.175, 0
20383, 1.45, 1.325, 0
20384, 1.4291666666667, 1.3, 0
20385, 1.45, 1.275, 0
20386, 1.4291666666667, 1.25, 0
20387, 1.45, 1.225, 0
20388, 1.4291666666667, 1.2, 0
20389, 1.45, 1.175, 0
20390, 1.4291666666667, 1.15, 0
20391, 1.45, 1.125, 0
20392, 1.4291666666667, 1.1, 0
20393, 1.45, 1.075, 0
20394, 1.4291666666667, 1.05, 0
20395, 1.45, 1.025, 0
20396, 1.4291666666667, 1, 0
20397, 1.45, 0.975, 0
20398, 1.4291666666667, 0.95, 0
20399, 1.45, 0.925, 0
20400, 1.4291666666667, 0.9, 0
20401, 1.45, 0.875, 0
20402, 1.4291666666667, 0.85, 0
20403, 1.45, 0.825, 0
20404, 1.4291666666667, 0.8, 0
20405, 1.45, 0.775, 0
20406, 1.4291666666667, 0.75, 0
20407, 1.45, 0.725, 0
20408, 1.4291666666667, 0.7, 0
20409, 1.45, 0.675, 0
20410, 1.4291666666667, 0.65, 0
20411, 1.45, 0.625, 0
20412, 1.4291666666667, 0.6, 0
20413, 1.45, 0.575, 0
20414, 1.4291666666667, 0.55, 0
20415, 1.45, 0.525, 0
20416, 1.4291666666667, 0.5, 0
20417, 1.45, 0.475, 0
20418, 1.4291666666667, 0.45, 0
20419, 1.45, 0.425, 0
20420, 1.4291666666667, 0.4, 0
20421, 1.45, 0.375, 0
20422, 1.4291666666667, 0.35, 0
20423, 1.45, 0.325, 0
20424, 1.4291666666667, 0.3, 0
20425, 1.45, 0.275, 0
20426, 1.4291666666667, 0.25, 0
20427, 1.45, 0.225, 0
20428, 1.4291666666667, 0.2, 0
20429, 1.45, 0.175, 0
20430, 1.4916666666667, 1.325, 0
20431, 1.4708333333333, 1.3, 0
20432, 1.4916666666667, 1.275, 0
20433, 1.4708333333333, 1.25, 0
20434, 1.4916666666667, 1.225, 0
20435, 1.4708333333333, 1.2, 0
20436, 1.4916666666667, 1.175, 0
20437, 1.4708333333333, 1.15, 0
20438, 1.4916666666667, 1.125, 0
20439, 1.4708333333333, 1.1, 0
20440, 1.4916666666667, 1.075, 0
20441, 1.4708333333333, 1.05, 0
20442, 1.4916666666667, 1.025, 0
20443, 1.4708333333333, 1, 0
20444, 1.4916666666667, 0.975, 0
20445, 1.4708333333333, 0.95, 0
20446, 1.4916666666667, 0.925, 0
20447, 1.4708333333333, 0.9, 0
20448, 1.4916666666667, 0.875, 0
20449, 1.4708333333333, 0.85, 0
20450, 1.4916666666667, 0.825, 0
20451, 1.4708333333333, 0.8, 0
20452, 1.4916666666667, 0.775, 0
20453, 1.4708333333333, 0.75, 0
20454, 1.4916666666667, 0.725, 0
20455, 1.4708333333333, 0.7, 0
20456, 1.4916666666667, 0.675, 0
20457, 1.4708333333333, 0.65, 0
20458, 1.4916666666667, 0.625, 0
20459, 1.4708333333333, 0.6, 0
20460, 1.4916666666667, 0.575, 0
20461, 1.4708333333333, 0.55, 0
20462, 1.4916666666667, 0.525, 0
20463, 1.4708333333333, 0.5, 0
20464, 1.4916666666667, 0.475, 0
20465, 1.4708333333333, 0.45, 0
20466, 1.4916666666667, 0.425, 0
20467, 1.4708333333333, 0.4, 0
20468, 1.4916666666667, 0.375, 0
20469, 1.4708333333333, 0.35, 0
20470, 1.4916666666667, 0.325, 0
20471, 1.4708333333333, 0.3, 0
20472, 1.4916666666667, 0.275, 0
20473, 1.4708333333333, 0.25, 0
20474, 1.4916666666667, 0.225, 0
20475, 1.4708333333333, 0.2, 0
20476, 1.4916666666667, 0.175, 0
20477, 1.5333333333333, 1.325, 0
20478, 1.5125, 1.3, 0
20479, 1.5333333333333, 1.275, 0
20480, 1.5125, 1.25, 0
20481, 1.5333333333333, 1.225, 0
20482, 1.5125, 1.2, 0
20483, 1.5333333333333, 1.175, 0
20484, 1.5125, 1.15, 0
20485, 1.5333333333333, 1.125, 0
20486, 1.5125, 1.1, 0
20487, 1.5333333333333, 1.075, 0
20488, 1.5125, 1.05, 0
20489, 1.5333333333333, 1.025, 0
20490, 1.5125, 1, 0
20491, 1.5333333333333, 0.975, 0
20492, 1.5125, 0.95, 0
20493, 1.5333333333333, 0.925, 0
20494, 1.5125, 0.9, 0
20495, 1.5333333333333, 0.875, 0
20496, 1.5125, 0.85, 0
20497, 1.5333333333333, 0.825, 0
20498, 1.5125, 0.8, 0
20499, 1.5333333333333, 0.775, 0
20500, 1.5125, 0.75, 0
20501, 1.5333333333333, 0.725, 0
20502, 1.5125, 0.7, 0
20503, 1.5333333333333, 0.675, 0
20504, 1.5125, 0.65, 0
20505, 1.5333333333333, 0.625, 0
20506, 1.5125, 0.6, 0
20507, 1.5333333333333, 0.575, 0
20508, 1.5125, 0.55, 0
20509, 1.5333333333333, 0.525, 0
20510, 1.5125, 0.5, 0
20511, 1.5333333333333, 0.475, 0
20512, 1.5125, 0.45, 0
20513, 1.5333333333333, 0.425, 0
20514, 1.5125, 0.4, 0
20515, 1.5333333333333, 0.375, 0
20516, 1.5125, 0.35, 0
20517, 1.5333333333333, 0.325, 0
20518, 1.5125, 0.3, 0
20519, 1.5333333333333, 0.275, 0
20520, 1.5125, 0.25, 0
20521, 1.5333333333333, 0.225, 0
20522, 1.5125, 0.2, 0
20523, 1.5333333333333, 0.175, 0
20524, 1.575, 1.325, 0
20525, 1.5541666666667, 1.3, 0
20526, 1.575, 1.275, 0
20527, 1.5541666666667, 1.25, 0
20528, 1.575, 1.225, 0
20529, 1.5541666666667, 1.2, 0
20530, 1.575, 1.175, 0
20531, 1.5541666666667, 1.15, 0
20532, 1.575, 1.125, 0
20533, 1.5541666666667, 1.1, 0
20534, 1.575, 1.075, 0
20535, 1.5541666666667, 1.05, 0
20536, 1.575, 1.025, 0
20537, 1.5541666666667, 1, 0
20538, 1.575, 0.975, 0
20539, 1.5541666666667, 0.95, 0
20540, 1.575, 0.925, 0
20541, 1.5541666666667, 0.9, 0
20542, 1.575, 0.875, 0
20543, 1.5541666666667, 0.85, 0
20544, 1.575, 0.825, 0
20545, 1.5541666666667, 0.8, 0
20546, 1.575, 0.775, 0
20547, 1.5541666666667, 0.75, 0
20548, 1.575, 0.725, 0
20549, 1.5541666666667, 0.7, 0
20550, 1.575, 0.675, 0
20551, 1.5541666666667, 0.65, 0
20552, 1.575, 0.625, 0
20553, 1.5541666666667, 0.6, 0
20554, 1.575, 0.575, 0
20555, 1.5541666666667, 0.55, 0
20556, 1.575, 0.525, 0
20557, 1.5541666666667, 0.5, 0
20558, 1.575, 0.475, 0
20559, 1.5541666666667, 0.45, 0
20560, 1.575, 0.425, 0
20561, 1.5541666666667, 0.4, 0
20562, 1.575, 0.375, 0
20563, 1.5541666666667, 0.35, 0
20564, 1.575, 0.325, 0
20565, 1.5541666666667, 0.3, 0
20566, 1.575, 0.275, 0
20567, 1.5541666666667, 0.25, 0
20568, 1.575, 0.225, 0
20569, 1.5541666666667, 0.2, 0
20570, 1.575, 0.175, 0
20571, 1.6166666666667, 1.325, 0
20572, 1.5958333333333, 1.3, 0
20573, 1.6166666666667, 1.275, 0
20574, 1.5958333333333, 1.25, 0
20575, 1.6166666666667, 1.225, 0
20576, 1.5958333333333, 1.2, 0
20577, 1.6166666666667, 1.175, 0
20578, 1.5958333333333, 1.15, 0
20579, 1.6166666666667, 1.125, 0
20580, 1.5958333333333, 1.1, 0
20581, 1.6166666666667, 1.075, 0
20582, 1.5958333333333, 1.05, 0
20583, 1.6166666666667, 1.025, 0
20584, 1.5958333333333, 1, 0
20585, 1.6166666666667, 0.975, 0
20586, 1.5958333333333, 0.95, 0
20587, 1.6166666666667, 0.925, 0
20588, 1.5958333333333, 0.9, 0
20589, 1.6166666666667, 0.875, 0
20590, 1.5958333333333, 0.85, 0
20591, 1.6166666666667, 0.825, 0
20592, 1.5958333333333, 0.8, 0
20593, 1.6166666666667, 0.775, 0
20594, 1.5958333333333, 0.75, 0
20595, 1.6166666666667, 0.725, 0
20596, 1.5958333333333, 0.7, 0
20597, 1.6166666666667, 0.675, 0
20598, 1.5958333333333, 0.65, 0
20599, 1.6166666666667, 0.625, 0
20600, 1.5958333333333, 0.6, 0
20601, 1.6166666666667, 0.575, 0
20602, 1.5958333333333, 0.55, 0
20603, 1.6166666666667, 0.525, 0
20604, 1.5958333333333, 0.5, 0
20605, 1.6166666666667, 0.475, 0
20606, 1.5958333333333, 0.45, 0
20607, 1.6166666666667, 0.425, 0
20608, 1.5958333333333, 0.4, 0
20609, 1.6166666666667, 0.375, 0
20610, 1.5958333333333, 0.35, 0
20611, 1.6166666666667, 0.325, 0
20612, 1.5958333333333, 0.3, 0
20613, 1.6166666666667, 0.275, 0
20614, 1.5958333333333, 0.25, 0
20615, 1.6166666666667, 0.225, 0
20616, 1.5958333333333, 0.2, 0
20617, 1.6166666666667, 0.175, 0
20618, 1.6583333333333, 1.325, 0
20619, 1.6375, 1.3, 0
20620, 1.6583333333333, 1.275, 0
20621, 1.6375, 1.25, 0
20622, 1.6583333333333, 1.225, 0
20623, 1.6375, 1.2, 0
20624, 1.6583333333333, 1.175, 0
20625, 1.6375, 1.15, 0
20626, 1.6583333333333, 1.125, 0
20627, 1.6375, 1.1, 0
20628, 1.6583333333333, 1.075, 0
20629, 1.6375, 1.05, 0
20630, 1.6583333333333, 1.025, 0
20631, 1.6375, 1, 0
20632, 1.6583333333333, 0.975, 0
20633, 1.6375, 0.95, 0
20634, 1.6583333333333, 0.925, 0
20635, 1.6375, 0.9, 0
20636, 1.6583333333333, 0.875, 0
20637, 1.6375, 0.85, 0
20638, 1.6583333333333, 0.825, 0
20639, 1.6375, 0.8, 0
20640, 1.6583333333333, 0.775, 0
20641, 1.6375, 0.75, 0
20642, 1.6583333333333, 0.725, 0
20643, 1.6375, 0.7, 0
20644, 1.6583333333333, 0.675, 0
20645, 1.6375, 0.65, 0
20646, 1.6583333333333, 0.625, 0
20647, 1.6375, 0.6, 0
20648, 1.6583333333333, 0.575, 0
20649, 1.6375, 0.55, 0
20650, 1.6583333333333, 0.525, 0
20651, 1.6375, 0.5, 0
20652, 1.6583333333333, 0.475, 0
20653, 1.6375, 0.45, 0
20654, 1.6583333333333, 0.425, 0
20655, 1.6375, 0.4, 0
20656, 1.6583333333333, 0.375, 0
20657, 1.6375, 0.35, 0
20658, 1.6583333333333, 0.325, 0
20659, 1.6375, 0.3, 0
20660, 1.6583333333333, 0.275, 0
20661, 1.6375, 0.25, 0
20662, 1.6583333333333, 0.225, 0
20663, 1.6375, 0.2, 0
20664, 1.6583333333333, 0.175, 0
20665, 1.7, 1.325, 0
20666, 1.6791666666667, 1.3, 0
20667, 1.7, 1.275, 0
20668, 1.6791666666667, 1.25, 0
20669, 1.7, 1.225, 0
20670, 1.6791666666667, 1.2, 0
20671, 1.7, 1.175, 0
20672, 1.6791666666667, 1.15, 0
20673, 1.7, 1.125, 0
20674, 1.6791666666667, 1.1, 0
20675, 1.7, 1.075, 0
20676, 1.6791666666667, 1.05, 0
20677, 1.7, 1.025, 0
20678, 1.6791666666667, 1, 0
20679, 1.7, 0.975, 0
20680, 1.6791666666667, 0.95, 0
20681, 1.7, 0.925, 0
20682, 1.6791666666667, 0.9, 0
20683, 1.7, 0.875, 0
20684, 1.6791666666667, 0.85, 0
20685, 1.7, 0.825, 0
20686, 1.6791666666667, 0.8, 0
20687, 1.7, 0.775, 0
20688, 1.6791666666667, 0.75, 0
20689, 1.7, 0.725, 0
20690, 1.6791666666667, 0.7, 0
20691, 1.7, 0.675, 0
20692, 1.6791666666667, 0.65, 0
20693, 1.7, 0.625, 0
20694, 1.6791666666667, 0.6, 0
20695, 1.7, 0.575, 0
20696, 1.6791666666667, 0.55, 0
20697, 1.7, 0.525, 0
20698, 1.6791666666667, 0.5, 0
20699, 1.7, 0.475, 0
20700, 1.6791666666667, 0.45, 0
20701, 1.7, 0.425, 0
20702, 1.6791666666667, 0.4, 0
20703, 1.7, 0.375, 0
20704, 1.6791666666667, 0.35, 0
20705, 1.7, 0.325, 0
20706, 1.6791666666667, 0.3, 0
20707, 1.7, 0.275, 0
20708, 1.6791666666667, 0.25, 0
20709, 1.7, 0.225, 0
20710, 1.6791666666667, 0.2, 0
20711, 1.7, 0.175, 0
20712, 1.7416666666667, 1.325, 0
20713, 1.7208333333333, 1.3, 0
20714, 1.7416666666667, 1.275, 0
20715, 1.7208333333333, 1.25, 0
20716, 1.7416666666667, 1.225, 0
20717, 1.7208333333333, 1.2, 0
20718, 1.7416666666667, 1.175, 0
20719, 1.7208333333333, 1.15, 0
20720, 1.7416666666667, 1.125, 0
20721, 1.7208333333333, 1.1, 0
20722, 1.7416666666667, 1.075, 0
20723, 1.7208333333333, 1.05, 0
20724, 1.7416666666667, 1.025, 0
20725, 1.7208333333333, 1, 0
20726, 1.7416666666667, 0.975, 0
20727, 1.7208333333333, 0.95, 0
20728, 1.7416666666667, 0.925, 0
20729, 1.7208333333333, 0.9, 0
20730, 1.7416666666667, 0.875, 0
20731, 1.7208333333333, 0.85, 0
20732, 1.7416666666667, 0.825, 0
20733, 1.7208333333333, 0.8, 0
20734, 1.7416666666667, 0.775, 0
20735, 1.7208333333333, 0.75, 0
20736, 1.7416666666667, 0.725, 0
20737, 1.7208333333333, 0.7, 0
20738, 1.7416666666667, 0.675, 0
20739, 1.7208333333333, 0.65, 0
20740, 1.7416666666667, 0.625, 0
20741, 1.7208333333333, 0.6, 0
20742, 1.7416666666667, 0.575, 0
20743, 1.7208333333333, 0.55, 0
20744, 1.7416666666667, 0.525, 0
20745, 1.7208333333333, 0.5, 0
20746, 1.7416666666667, 0.475, 0
20747, 1.7208333333333, 0.45, 0
20748, 1.7416666666667, 0.425, 0
20749, 1.7208333333333, 0.4, 0
20750, 1.7416666666667, 0.375, 0
20751, 1.7208333333333, 0.35, 0
20752, 1.7416666666667, 0.325, 0
20753, 1.7208333333333, 0.3, 0
20754, 1.7416666666667, 0.275, 0
20755, 1.7208333333333, 0.25, 0
20756, 1.7416666666667, 0.225, 0
20757, 1.7208333333333, 0.2, 0
20758, 1.7416666666667, 0.175, 0
20759, 1.7833333333333, 1.325, 0
20760, 1.7625, 1.3, 0
20761, 1.7833333333333, 1.275, 0
20762, 1.7625, 1.25, 0
20763, 1.7833333333333, 1.225, 0
20764, 1.7625, 1.2, 0
20765, 1.7833333333333, 1.175, 0
20766, 1.7625, 1.15, 0
20767, 1.7833333333333, 1.125, 0
20768, 1.7625, 1.1, 0
20769, 1.7833333333333, 1.075, 0
20770, 1.7625, 1.05, 0
20771, 1.7833333333333, 1.025, 0
20772, 1.7625, 1, 0
20773, 1.7833333333333, 0.975, 0
20774, 1.7625, 0.95, 0
20775, 1.7833333333333, 0.925, 0
20776, 1.7625, 0.9, 0
20777, 1.7833333333333, 0.875, 0
20778, 1.7625, 0.85, 0
20779, 1.7833333333333, 0.825, 0
20780, 1.7625, 0.8, 0
20781, 1.7833333333333, 0.775, 0
20782, 1.7625, 0.75, 0
20783, 1.7833333333333, 0.725, 0
20784, 1.7625, 0.7, 0
20785, 1.7833333333333, 0.675, 0
20786, 1.7625, 0.65, 0
20787, 1.7833333333333, 0.625, 0
20788, 1.7625, 0.6, 0
20789, 1.7833333333333, 0.575, 0
20790, 1.7625, 0.55, 0
20791, 1.7833333333333, 0.525, 0
20792, 1.7625, 0.5, 0
20793, 1.7833333333333, 0.475, 0
20794, 1.7625, 0.45, 0
20795, 1.7833333333333, 0.425, 0
20796, 1.7625, 0.4, 0
20797, 1.7833333333333, 0.375, 0
20798, 1.7625, 0.35, 0
20799, 1.7833333333333, 0.325, 0
20800, 1.7625, 0.3, 0
20801, 1.7833333333333, 0.275, 0
20802, 1.7625, 0.25, 0
20803, 1.7833333333333, 0.225, 0
20804, 1.7625, 0.2, 0
20805, 1.7833333333333, 0.175, 0
20806, 1.825, 1.325, 0
20807, 1.8041666666667, 1.3, 0
20808, 1.825, 1.275, 0
20809, 1.8041666666667, 1.25, 0
20810, 1.825, 1.225, 0
20811, 1.8041666666667, 1.2, 0
20812, 1.825, 1.175, 0
20813, 1.8041666666667, 1.15, 0
20814, 1.825, 1.125, 0
20815, 1.8041666666667, 1.1, 0
20816, 1.825, 1.075, 0
20817, 1.8041666666667, 1.05, 0
20818, 1.825, 1.025, 0
20819, 1.8041666666667, 1, 0
20820, 1.825, 0.975, 0
20821, 1.8041666666667, 0.95, 0
20822, 1.825, 0.925, 0
20823, 1.8041666666667, 0.9, 0
20824, 1.825, 0.875, 0
20825, 1.8041666666667, 0.85, 0
20826, 1.825, 0.825, 0
20827, 1.8041666666667, 0.8, 0
20828, 1.825, 0.775, 0
20829, 1.8041666666667, 0.75, 0
20830, 1.825, 0.725, 0
20831, 1.8041666666667, 0.7, 0
20832, 1.825, 0.675, 0
20833, 1.8041666666667, 0.65, 0
20834, 1.825, 0.625, 0
20835, 1.8041666666667, 0.6, 0
20836, 1.825, 0.575, 0
20837, 1.8041666666667, 0.55, 0
20838, 1.825, 0.525, 0
20839, 1.8041666666667, 0.5, 0
20840, 1.825, 0.475, 0
20841, 1.8041666666667, 0.45, 0
20842, 1.825, 0.425, 0
20843, 1.8041666666667, 0.4, 0
20844, 1.825, 0.375, 0
20845, 1.8041666666667, 0.35, 0
20846, 1.825, 0.325, 0
20847, 1.8041666666667, 0.3, 0
20848, 1.825, 0.275, 0
20849, 1.8041666666667, 0.25, 0
20850, 1.825, 0.225, 0
20851, 1.8041666666667, 0.2, 0
20852, 1.825, 0.175, 0
20853, 1.8666666666667, 1.325, 0
20854, 1.8458333333333, 1.3, 0
20855, 1.8666666666667, 1.275, 0
20856, 1.8458333333333, 1.25, 0
20857, 1.8666666666667, 1.225, 0
20858, 1.8458333333333, 1.2, 0
20859, 1.8666666666667, 1.175, 0
20860, 1.8458333333333, 1.15, 0
20861, 1.8666666666667, 1.125, 0
20862, 1.8458333333333, 1.1, 0
20863, 1.8666666666667, 1.075, 0
20864, 1.8458333333333, 1.05, 0
20865, 1.8666666666667, 1.025, 0
20866, 1.8458333333333, 1, 0
20867, 1.8666666666667, 0.975, 0
20868, 1.8458333333333, 0.95, 0
20869, 1.8666666666667, 0.925, 0
20870, 1.8458333333333, 0.9, 0
20871, 1.8666666666667, 0.875, 0
20872, 1.8458333333333, 0.85, 0
20873, 1.8666666666667, 0.825, 0
20874, 1.8458333333333, 0.8, 0
20875, 1.8666666666667, 0.775, 0
20876, 1.8458333333333, 0.75, 0
20877, 1.8666666666667, 0.725, 0
20878, 1.8458333333333, 0.7, 0
20879, 1.8666666666667, 0.675, 0
20880, 1.8458333333333, 0.65, 0
20881, 1.8666666666667, 0.625, 0
20882, 1.8458333333333, 0.6, 0
20883, 1.8666666666667, 0.575, 0
20884, 1.8458333333333, 0.55, 0
20885, 1.8666666666667, 0.525, 0
20886, 1.8458333333333, 0.5, 0
20887, 1.8666666666667, 0.475, 0
20888, 1.8458333333333, 0.45, 0
20889, 1.8666666666667, 0.425, 0
20890, 1.8458333333333, 0.4, 0
20891, 1.8666666666667, 0.375, 0
20892, 1.8458333333333, 0.35, 0
20893, 1.8666666666667, 0.325, 0
20894, 1.8458333333333, 0.3, 0
20895, 1.8666666666667, 0.275, 0
20896, 1.8458333333333, 0.25, 0
20897, 1.8666666666667, 0.225, 0
20898, 1.8458333333333, 0.2, 0
20899, 1.8666666666667, 0.175, 0
20900, 1.9083333333333, 1.325, 0
20901, 1.8875, 1.3, 0
20902, 1.9083333333333, 1.275, 0
20903, 1.8875, 1.25, 0
20904, 1.9083333333333, 1.225, 0
20905, 1.8875, 1.2, 0
20906, 1.9083333333333, 1.175, 0
20907, 1.8875, 1.15, 0
20908, 1.9083333333333, 1.125, 0
20909, 1.8875, 1.1, 0
20910, 1.9083333333333, 1.075, 0
20911, 1.8875, 1.05, 0
