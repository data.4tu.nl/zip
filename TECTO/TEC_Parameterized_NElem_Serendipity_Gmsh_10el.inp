113601, 0.95833333333333, -0.1, 0.083333333333333
113602, 0.95833333333333, -0.12, 0.0625
113603, 0.9375, -0.12, 0.083333333333333
113604, 0.95833333333333, -0.14, 0.083333333333333
113605, 0.95833333333333, -0.16, 0.0625
113606, 0.9375, -0.16, 0.083333333333333
113607, 0.95833333333333, -0.18, 0.083333333333333
113608, 0.95833333333333, -0.02, 0.125
113609, 0.95833333333333, -0.04, 0.10416666666667
113610, 0.9375, -0.04, 0.125
113611, 0.95833333333333, -0.06, 0.125
113612, 0.95833333333333, -0.08, 0.10416666666667
113613, 0.9375, -0.08, 0.125
113614, 0.95833333333333, -0.1, 0.125
113615, 0.95833333333333, -0.12, 0.10416666666667
113616, 0.9375, -0.12, 0.125
113617, 0.95833333333333, -0.14, 0.125
113618, 0.95833333333333, -0.16, 0.10416666666667
113619, 0.9375, -0.16, 0.125
113620, 0.95833333333333, -0.18, 0.125
113621, 0.95833333333333, -0.02, 0.16666666666667
113622, 0.95833333333333, -0.04, 0.14583333333333
113623, 0.9375, -0.04, 0.16666666666667
113624, 0.95833333333333, -0.06, 0.16666666666667
113625, 0.95833333333333, -0.08, 0.14583333333333
113626, 0.9375, -0.08, 0.16666666666667
113627, 0.95833333333333, -0.1, 0.16666666666667
113628, 0.95833333333333, -0.12, 0.14583333333333
113629, 0.9375, -0.12, 0.16666666666667
113630, 0.95833333333333, -0.14, 0.16666666666667
113631, 0.95833333333333, -0.16, 0.14583333333333
113632, 0.9375, -0.16, 0.16666666666667
113633, 0.95833333333333, -0.18, 0.16666666666667
113634, 0.95833333333333, -0.02, 0.20833333333333
113635, 0.95833333333333, -0.04, 0.1875
113636, 0.9375, -0.04, 0.20833333333333
113637, 0.95833333333333, -0.06, 0.20833333333333
113638, 0.95833333333333, -0.08, 0.1875
113639, 0.9375, -0.08, 0.20833333333333
113640, 0.95833333333333, -0.1, 0.20833333333333
113641, 0.95833333333333, -0.12, 0.1875
113642, 0.9375, -0.12, 0.20833333333333
113643, 0.95833333333333, -0.14, 0.20833333333333
113644, 0.95833333333333, -0.16, 0.1875
113645, 0.9375, -0.16, 0.20833333333333
113646, 0.95833333333333, -0.18, 0.20833333333333
113647, 0.95833333333333, -0.02, 0.25
113648, 0.95833333333333, -0.04, 0.22916666666667
113649, 0.9375, -0.04, 0.25
113650, 0.95833333333333, -0.06, 0.25
113651, 0.95833333333333, -0.08, 0.22916666666667
113652, 0.9375, -0.08, 0.25
113653, 0.95833333333333, -0.1, 0.25
113654, 0.95833333333333, -0.12, 0.22916666666667
113655, 0.9375, -0.12, 0.25
113656, 0.95833333333333, -0.14, 0.25
113657, 0.95833333333333, -0.16, 0.22916666666667
113658, 0.9375, -0.16, 0.25
113659, 0.95833333333333, -0.18, 0.25
113660, 0.95833333333333, -0.02, 0.29166666666667
113661, 0.95833333333333, -0.04, 0.27083333333333
113662, 0.9375, -0.04, 0.29166666666667
113663, 0.95833333333333, -0.06, 0.29166666666667
113664, 0.95833333333333, -0.08, 0.27083333333333
113665, 0.9375, -0.08, 0.29166666666667
113666, 0.95833333333333, -0.1, 0.29166666666667
113667, 0.95833333333333, -0.12, 0.27083333333333
113668, 0.9375, -0.12, 0.29166666666667
113669, 0.95833333333333, -0.14, 0.29166666666667
113670, 0.95833333333333, -0.16, 0.27083333333333
113671, 0.9375, -0.16, 0.29166666666667
113672, 0.95833333333333, -0.18, 0.29166666666667
113673, 0.95833333333333, -0.02, 0.33333333333333
113674, 0.95833333333333, -0.04, 0.3125
113675, 0.9375, -0.04, 0.33333333333333
113676, 0.95833333333333, -0.06, 0.33333333333333
113677, 0.95833333333333, -0.08, 0.3125
113678, 0.9375, -0.08, 0.33333333333333
113679, 0.95833333333333, -0.1, 0.33333333333333
113680, 0.95833333333333, -0.12, 0.3125
113681, 0.9375, -0.12, 0.33333333333333
113682, 0.95833333333333, -0.14, 0.33333333333333
113683, 0.95833333333333, -0.16, 0.3125
113684, 0.9375, -0.16, 0.33333333333333
113685, 0.95833333333333, -0.18, 0.33333333333333
113686, 0.95833333333333, -0.02, 0.375
113687, 0.95833333333333, -0.04, 0.35416666666667
113688, 0.9375, -0.04, 0.375
113689, 0.95833333333333, -0.06, 0.375
113690, 0.95833333333333, -0.08, 0.35416666666667
113691, 0.9375, -0.08, 0.375
113692, 0.95833333333333, -0.1, 0.375
113693, 0.95833333333333, -0.12, 0.35416666666667
113694, 0.9375, -0.12, 0.375
113695, 0.95833333333333, -0.14, 0.375
113696, 0.95833333333333, -0.16, 0.35416666666667
113697, 0.9375, -0.16, 0.375
113698, 0.95833333333333, -0.18, 0.375
113699, 0.95833333333333, -0.02, 0.41666666666667
113700, 0.95833333333333, -0.04, 0.39583333333333
113701, 0.9375, -0.04, 0.41666666666667
113702, 0.95833333333333, -0.06, 0.41666666666667
113703, 0.95833333333333, -0.08, 0.39583333333333
113704, 0.9375, -0.08, 0.41666666666667
113705, 0.95833333333333, -0.1, 0.41666666666667
113706, 0.95833333333333, -0.12, 0.39583333333333
113707, 0.9375, -0.12, 0.41666666666667
113708, 0.95833333333333, -0.14, 0.41666666666667
113709, 0.95833333333333, -0.16, 0.39583333333333
113710, 0.9375, -0.16, 0.41666666666667
113711, 0.95833333333333, -0.18, 0.41666666666667
113712, 0.95833333333333, -0.02, 0.45833333333333
113713, 0.95833333333333, -0.04, 0.4375
113714, 0.9375, -0.04, 0.45833333333333
113715, 0.95833333333333, -0.06, 0.45833333333333
113716, 0.95833333333333, -0.08, 0.4375
113717, 0.9375, -0.08, 0.45833333333333
113718, 0.95833333333333, -0.1, 0.45833333333333
113719, 0.95833333333333, -0.12, 0.4375
113720, 0.9375, -0.12, 0.45833333333333
113721, 0.95833333333333, -0.14, 0.45833333333333
113722, 0.95833333333333, -0.16, 0.4375
113723, 0.9375, -0.16, 0.45833333333333
113724, 0.95833333333333, -0.18, 0.45833333333333
113725, 0.95833333333333, -0.04, 0.47916666666667
113726, 0.95833333333333, -0.08, 0.47916666666667
113727, 0.95833333333333, -0.12, 0.47916666666667
113728, 0.95833333333333, -0.16, 0.47916666666667
113729, 0.97916666666667, -0.04, 0.041666666666667
113730, 0.97916666666667, -0.08, 0.041666666666667
113731, 0.97916666666667, -0.12, 0.041666666666667
113732, 0.97916666666667, -0.16, 0.041666666666667
113733, 0.97916666666667, -0.04, 0.083333333333333
113734, 0.97916666666667, -0.08, 0.083333333333333
113735, 0.97916666666667, -0.12, 0.083333333333333
113736, 0.97916666666667, -0.16, 0.083333333333333
113737, 0.97916666666667, -0.04, 0.125
113738, 0.97916666666667, -0.08, 0.125
113739, 0.97916666666667, -0.12, 0.125
113740, 0.97916666666667, -0.16, 0.125
113741, 0.97916666666667, -0.04, 0.16666666666667
113742, 0.97916666666667, -0.08, 0.16666666666667
113743, 0.97916666666667, -0.12, 0.16666666666667
113744, 0.97916666666667, -0.16, 0.16666666666667
113745, 0.97916666666667, -0.04, 0.20833333333333
113746, 0.97916666666667, -0.08, 0.20833333333333
113747, 0.97916666666667, -0.12, 0.20833333333333
113748, 0.97916666666667, -0.16, 0.20833333333333
113749, 0.97916666666667, -0.04, 0.25
113750, 0.97916666666667, -0.08, 0.25
113751, 0.97916666666667, -0.12, 0.25
113752, 0.97916666666667, -0.16, 0.25
113753, 0.97916666666667, -0.04, 0.29166666666667
113754, 0.97916666666667, -0.08, 0.29166666666667
113755, 0.97916666666667, -0.12, 0.29166666666667
113756, 0.97916666666667, -0.16, 0.29166666666667
113757, 0.97916666666667, -0.04, 0.33333333333333
113758, 0.97916666666667, -0.08, 0.33333333333333
113759, 0.97916666666667, -0.12, 0.33333333333333
113760, 0.97916666666667, -0.16, 0.33333333333333
113761, 0.97916666666667, -0.04, 0.375
113762, 0.97916666666667, -0.08, 0.375
113763, 0.97916666666667, -0.12, 0.375
113764, 0.97916666666667, -0.16, 0.375
113765, 0.97916666666667, -0.04, 0.41666666666667
113766, 0.97916666666667, -0.08, 0.41666666666667
113767, 0.97916666666667, -0.12, 0.41666666666667
113768, 0.97916666666667, -0.16, 0.41666666666667
113769, 0.97916666666667, -0.04, 0.45833333333333
113770, 0.97916666666667, -0.08, 0.45833333333333
113771, 0.97916666666667, -0.12, 0.45833333333333
113772, 0.97916666666667, -0.16, 0.45833333333333
113773, -0.05, -0.04, 0.041666666666667
113774, -0.05, -0.08, 0.041666666666667
113775, -0.05, -0.12, 0.041666666666667
113776, -0.05, -0.16, 0.041666666666667
113777, -0.05, -0.04, 0.083333333333333
113778, -0.05, -0.08, 0.083333333333333
113779, -0.05, -0.12, 0.083333333333333
113780, -0.05, -0.16, 0.083333333333333
113781, -0.05, -0.04, 0.125
113782, -0.05, -0.08, 0.125
113783, -0.05, -0.12, 0.125
113784, -0.05, -0.16, 0.125
113785, -0.05, -0.04, 0.16666666666667
113786, -0.05, -0.08, 0.16666666666667
113787, -0.05, -0.12, 0.16666666666667
113788, -0.05, -0.16, 0.16666666666667
113789, -0.05, -0.04, 0.20833333333333
113790, -0.05, -0.08, 0.20833333333333
113791, -0.05, -0.12, 0.20833333333333
113792, -0.05, -0.16, 0.20833333333333
113793, -0.05, -0.04, 0.25
113794, -0.05, -0.08, 0.25
113795, -0.05, -0.12, 0.25
113796, -0.05, -0.16, 0.25
113797, -0.05, -0.04, 0.29166666666667
113798, -0.05, -0.08, 0.29166666666667
113799, -0.05, -0.12, 0.29166666666667
113800, -0.05, -0.16, 0.29166666666667
113801, -0.05, -0.04, 0.33333333333333
113802, -0.05, -0.08, 0.33333333333333
113803, -0.05, -0.12, 0.33333333333333
113804, -0.05, -0.16, 0.33333333333333
113805, -0.05, -0.04, 0.375
113806, -0.05, -0.08, 0.375
113807, -0.05, -0.12, 0.375
113808, -0.05, -0.16, 0.375
113809, -0.05, -0.04, 0.41666666666667
113810, -0.05, -0.08, 0.41666666666667
113811, -0.05, -0.12, 0.41666666666667
113812, -0.05, -0.16, 0.41666666666667
113813, -0.05, -0.04, 0.45833333333333
113814, -0.05, -0.08, 0.45833333333333
113815, -0.05, -0.12, 0.45833333333333
113816, -0.05, -0.16, 0.45833333333333
113817, 1.2416666666667, -0.04, 0.041666666666667
113818, 1.2416666666667, -0.08, 0.041666666666667
113819, 1.2416666666667, -0.12, 0.041666666666667
113820, 1.2416666666667, -0.16, 0.041666666666667
113821, 1.2833333333333, -0.04, 0.041666666666667
113822, 1.2833333333333, -0.08, 0.041666666666667
113823, 1.2833333333333, -0.12, 0.041666666666667
113824, 1.2833333333333, -0.16, 0.041666666666667
113825, 1.325, -0.04, 0.041666666666667
113826, 1.325, -0.08, 0.041666666666667
113827, 1.325, -0.12, 0.041666666666667
113828, 1.325, -0.16, 0.041666666666667
113829, 1.3666666666667, -0.04, 0.041666666666667
113830, 1.3666666666667, -0.08, 0.041666666666667
113831, 1.3666666666667, -0.12, 0.041666666666667
113832, 1.3666666666667, -0.16, 0.041666666666667
113833, 1.4083333333333, -0.04, 0.041666666666667
113834, 1.4083333333333, -0.08, 0.041666666666667
113835, 1.4083333333333, -0.12, 0.041666666666667
113836, 1.4083333333333, -0.16, 0.041666666666667
113837, 1.45, -0.04, 0.041666666666667
113838, 1.45, -0.08, 0.041666666666667
113839, 1.45, -0.12, 0.041666666666667
113840, 1.45, -0.16, 0.041666666666667
113841, 1.4916666666667, -0.04, 0.041666666666667
113842, 1.4916666666667, -0.08, 0.041666666666667
113843, 1.4916666666667, -0.12, 0.041666666666667
113844, 1.4916666666667, -0.16, 0.041666666666667
113845, 1.5333333333333, -0.04, 0.041666666666667
113846, 1.5333333333333, -0.08, 0.041666666666667
113847, 1.5333333333333, -0.12, 0.041666666666667
113848, 1.5333333333333, -0.16, 0.041666666666667
113849, 1.575, -0.04, 0.041666666666667
113850, 1.575, -0.08, 0.041666666666667
113851, 1.575, -0.12, 0.041666666666667
113852, 1.575, -0.16, 0.041666666666667
113853, 1.6166666666667, -0.04, 0.041666666666667
113854, 1.6166666666667, -0.08, 0.041666666666667
113855, 1.6166666666667, -0.12, 0.041666666666667
113856, 1.6166666666667, -0.16, 0.041666666666667
113857, 1.6583333333333, -0.04, 0.041666666666667
113858, 1.6583333333333, -0.08, 0.041666666666667
113859, 1.6583333333333, -0.12, 0.041666666666667
113860, 1.6583333333333, -0.16, 0.041666666666667
113861, 1.7, -0.04, 0.041666666666667
113862, 1.7, -0.08, 0.041666666666667
113863, 1.7, -0.12, 0.041666666666667
113864, 1.7, -0.16, 0.041666666666667
113865, 1.7416666666667, -0.04, 0.041666666666667
113866, 1.7416666666667, -0.08, 0.041666666666667
113867, 1.7416666666667, -0.12, 0.041666666666667
113868, 1.7416666666667, -0.16, 0.041666666666667
113869, 1.7833333333333, -0.04, 0.041666666666667
113870, 1.7833333333333, -0.08, 0.041666666666667
113871, 1.7833333333333, -0.12, 0.041666666666667
113872, 1.7833333333333, -0.16, 0.041666666666667
113873, 1.825, -0.04, 0.041666666666667
113874, 1.825, -0.08, 0.041666666666667
113875, 1.825, -0.12, 0.041666666666667
113876, 1.825, -0.16, 0.041666666666667
113877, 1.8666666666667, -0.04, 0.041666666666667
113878, 1.8666666666667, -0.08, 0.041666666666667
113879, 1.8666666666667, -0.12, 0.041666666666667
113880, 1.8666666666667, -0.16, 0.041666666666667
113881, 1.9083333333333, -0.04, 0.041666666666667
113882, 1.9083333333333, -0.08, 0.041666666666667
113883, 1.9083333333333, -0.12, 0.041666666666667
113884, 1.9083333333333, -0.16, 0.041666666666667
113885, 1.95, -0.04, 0.041666666666667
113886, 1.95, -0.08, 0.041666666666667
113887, 1.95, -0.12, 0.041666666666667
113888, 1.95, -0.16, 0.041666666666667
113889, 1.9916666666667, -0.04, 0.041666666666667
113890, 1.9916666666667, -0.08, 0.041666666666667
113891, 1.9916666666667, -0.12, 0.041666666666667
113892, 1.9916666666667, -0.16, 0.041666666666667
113893, 2.0333333333333, -0.04, 0.041666666666667
113894, 2.0333333333333, -0.08, 0.041666666666667
113895, 2.0333333333333, -0.12, 0.041666666666667
113896, 2.0333333333333, -0.16, 0.041666666666667
113897, 2.075, -0.04, 0.041666666666667
113898, 2.075, -0.08, 0.041666666666667
113899, 2.075, -0.12, 0.041666666666667
113900, 2.075, -0.16, 0.041666666666667
113901, 2.1166666666667, -0.04, 0.041666666666667
113902, 2.1166666666667, -0.08, 0.041666666666667
113903, 2.1166666666667, -0.12, 0.041666666666667
113904, 2.1166666666667, -0.16, 0.041666666666667
113905, 2.1583333333333, -0.04, 0.041666666666667
113906, 2.1583333333333, -0.08, 0.041666666666667
113907, 2.1583333333333, -0.12, 0.041666666666667
113908, 2.1583333333333, -0.16, 0.041666666666667
113909, 1.2416666666667, -0.04, 0.083333333333333
113910, 1.2416666666667, -0.08, 0.083333333333333
113911, 1.2416666666667, -0.12, 0.083333333333333
113912, 1.2416666666667, -0.16, 0.083333333333333
113913, 1.2833333333333, -0.04, 0.083333333333333
113914, 1.2833333333333, -0.08, 0.083333333333333
113915, 1.2833333333333, -0.12, 0.083333333333333
113916, 1.2833333333333, -0.16, 0.083333333333333
113917, 1.325, -0.04, 0.083333333333333
113918, 1.325, -0.08, 0.083333333333333
113919, 1.325, -0.12, 0.083333333333333
113920, 1.325, -0.16, 0.083333333333333
113921, 1.3666666666667, -0.04, 0.083333333333333
113922, 1.3666666666667, -0.08, 0.083333333333333
113923, 1.3666666666667, -0.12, 0.083333333333333
113924, 1.3666666666667, -0.16, 0.083333333333333
113925, 1.4083333333333, -0.04, 0.083333333333333
113926, 1.4083333333333, -0.08, 0.083333333333333
113927, 1.4083333333333, -0.12, 0.083333333333333
113928, 1.4083333333333, -0.16, 0.083333333333333
113929, 1.45, -0.04, 0.083333333333333
113930, 1.45, -0.08, 0.083333333333333
113931, 1.45, -0.12, 0.083333333333333
113932, 1.45, -0.16, 0.083333333333333
113933, 1.4916666666667, -0.04, 0.083333333333333
113934, 1.4916666666667, -0.08, 0.083333333333333
113935, 1.4916666666667, -0.12, 0.083333333333333
113936, 1.4916666666667, -0.16, 0.083333333333333
113937, 1.5333333333333, -0.04, 0.083333333333333
113938, 1.5333333333333, -0.08, 0.083333333333333
113939, 1.5333333333333, -0.12, 0.083333333333333
113940, 1.5333333333333, -0.16, 0.083333333333333
113941, 1.575, -0.04, 0.083333333333333
113942, 1.575, -0.08, 0.083333333333333
113943, 1.575, -0.12, 0.083333333333333
113944, 1.575, -0.16, 0.083333333333333
113945, 1.6166666666667, -0.04, 0.083333333333333
113946, 1.6166666666667, -0.08, 0.083333333333333
113947, 1.6166666666667, -0.12, 0.083333333333333
113948, 1.6166666666667, -0.16, 0.083333333333333
113949, 1.6583333333333, -0.04, 0.083333333333333
113950, 1.6583333333333, -0.08, 0.083333333333333
113951, 1.6583333333333, -0.12, 0.083333333333333
113952, 1.6583333333333, -0.16, 0.083333333333333
113953, 1.7, -0.04, 0.083333333333333
113954, 1.7, -0.08, 0.083333333333333
113955, 1.7, -0.12, 0.083333333333333
113956, 1.7, -0.16, 0.083333333333333
113957, 1.7416666666667, -0.04, 0.083333333333333
113958, 1.7416666666667, -0.08, 0.083333333333333
113959, 1.7416666666667, -0.12, 0.083333333333333
113960, 1.7416666666667, -0.16, 0.083333333333333
113961, 1.7833333333333, -0.04, 0.083333333333333
113962, 1.7833333333333, -0.08, 0.083333333333333
113963, 1.7833333333333, -0.12, 0.083333333333333
113964, 1.7833333333333, -0.16, 0.083333333333333
113965, 1.825, -0.04, 0.083333333333333
113966, 1.825, -0.08, 0.083333333333333
113967, 1.825, -0.12, 0.083333333333333
113968, 1.825, -0.16, 0.083333333333333
113969, 1.8666666666667, -0.04, 0.083333333333333
113970, 1.8666666666667, -0.08, 0.083333333333333
113971, 1.8666666666667, -0.12, 0.083333333333333
113972, 1.8666666666667, -0.16, 0.083333333333333
113973, 1.9083333333333, -0.04, 0.083333333333333
113974, 1.9083333333333, -0.08, 0.083333333333333
113975, 1.9083333333333, -0.12, 0.083333333333333
113976, 1.9083333333333, -0.16, 0.083333333333333
113977, 1.95, -0.04, 0.083333333333333
113978, 1.95, -0.08, 0.083333333333333
113979, 1.95, -0.12, 0.083333333333333
113980, 1.95, -0.16, 0.083333333333333
113981, 1.9916666666667, -0.04, 0.083333333333333
113982, 1.9916666666667, -0.08, 0.083333333333333
113983, 1.9916666666667, -0.12, 0.083333333333333
113984, 1.9916666666667, -0.16, 0.083333333333333
113985, 2.0333333333333, -0.04, 0.083333333333333
113986, 2.0333333333333, -0.08, 0.083333333333333
113987, 2.0333333333333, -0.12, 0.083333333333333
113988, 2.0333333333333, -0.16, 0.083333333333333
113989, 2.075, -0.04, 0.083333333333333
113990, 2.075, -0.08, 0.083333333333333
113991, 2.075, -0.12, 0.083333333333333
113992, 2.075, -0.16, 0.083333333333333
113993, 2.1166666666667, -0.04, 0.083333333333333
113994, 2.1166666666667, -0.08, 0.083333333333333
113995, 2.1166666666667, -0.12, 0.083333333333333
113996, 2.1166666666667, -0.16, 0.083333333333333
113997, 2.1583333333333, -0.04, 0.083333333333333
113998, 2.1583333333333, -0.08, 0.083333333333333
113999, 2.1583333333333, -0.12, 0.083333333333333
114000, 2.1583333333333, -0.16, 0.083333333333333
114001, 1.2416666666667, -0.04, 0.125
114002, 1.2416666666667, -0.08, 0.125
114003, 1.2416666666667, -0.12, 0.125
114004, 1.2416666666667, -0.16, 0.125
114005, 1.2833333333333, -0.04, 0.125
114006, 1.2833333333333, -0.08, 0.125
114007, 1.2833333333333, -0.12, 0.125
114008, 1.2833333333333, -0.16, 0.125
114009, 1.325, -0.04, 0.125
114010, 1.325, -0.08, 0.125
114011, 1.325, -0.12, 0.125
114012, 1.325, -0.16, 0.125
114013, 1.3666666666667, -0.04, 0.125
114014, 1.3666666666667, -0.08, 0.125
114015, 1.3666666666667, -0.12, 0.125
114016, 1.3666666666667, -0.16, 0.125
114017, 1.4083333333333, -0.04, 0.125
114018, 1.4083333333333, -0.08, 0.125
114019, 1.4083333333333, -0.12, 0.125
114020, 1.4083333333333, -0.16, 0.125
114021, 1.45, -0.04, 0.125
114022, 1.45, -0.08, 0.125
114023, 1.45, -0.12, 0.125
114024, 1.45, -0.16, 0.125
114025, 1.4916666666667, -0.04, 0.125
114026, 1.4916666666667, -0.08, 0.125
114027, 1.4916666666667, -0.12, 0.125
114028, 1.4916666666667, -0.16, 0.125
114029, 1.5333333333333, -0.04, 0.125
114030, 1.5333333333333, -0.08, 0.125
114031, 1.5333333333333, -0.12, 0.125
114032, 1.5333333333333, -0.16, 0.125
114033, 1.575, -0.04, 0.125
114034, 1.575, -0.08, 0.125
114035, 1.575, -0.12, 0.125
114036, 1.575, -0.16, 0.125
114037, 1.6166666666667, -0.04, 0.125
114038, 1.6166666666667, -0.08, 0.125
114039, 1.6166666666667, -0.12, 0.125
114040, 1.6166666666667, -0.16, 0.125
114041, 1.6583333333333, -0.04, 0.125
114042, 1.6583333333333, -0.08, 0.125
114043, 1.6583333333333, -0.12, 0.125
114044, 1.6583333333333, -0.16, 0.125
114045, 1.7, -0.04, 0.125
114046, 1.7, -0.08, 0.125
114047, 1.7, -0.12, 0.125
114048, 1.7, -0.16, 0.125
114049, 1.7416666666667, -0.04, 0.125
114050, 1.7416666666667, -0.08, 0.125
114051, 1.7416666666667, -0.12, 0.125
114052, 1.7416666666667, -0.16, 0.125
114053, 1.7833333333333, -0.04, 0.125
114054, 1.7833333333333, -0.08, 0.125
114055, 1.7833333333333, -0.12, 0.125
114056, 1.7833333333333, -0.16, 0.125
114057, 1.825, -0.04, 0.125
114058, 1.825, -0.08, 0.125
114059, 1.825, -0.12, 0.125
114060, 1.825, -0.16, 0.125
114061, 1.8666666666667, -0.04, 0.125
114062, 1.8666666666667, -0.08, 0.125
114063, 1.8666666666667, -0.12, 0.125
114064, 1.8666666666667, -0.16, 0.125
114065, 1.9083333333333, -0.04, 0.125
114066, 1.9083333333333, -0.08, 0.125
114067, 1.9083333333333, -0.12, 0.125
114068, 1.9083333333333, -0.16, 0.125
114069, 1.95, -0.04, 0.125
114070, 1.95, -0.08, 0.125
114071, 1.95, -0.12, 0.125
114072, 1.95, -0.16, 0.125
114073, 1.9916666666667, -0.04, 0.125
114074, 1.9916666666667, -0.08, 0.125
114075, 1.9916666666667, -0.12, 0.125
114076, 1.9916666666667, -0.16, 0.125
114077, 2.0333333333333, -0.04, 0.125
114078, 2.0333333333333, -0.08, 0.125
114079, 2.0333333333333, -0.12, 0.125
114080, 2.0333333333333, -0.16, 0.125
114081, 2.075, -0.04, 0.125
114082, 2.075, -0.08, 0.125
114083, 2.075, -0.12, 0.125
114084, 2.075, -0.16, 0.125
114085, 2.1166666666667, -0.04, 0.125
114086, 2.1166666666667, -0.08, 0.125
114087, 2.1166666666667, -0.12, 0.125
114088, 2.1166666666667, -0.16, 0.125
114089, 2.1583333333333, -0.04, 0.125
114090, 2.1583333333333, -0.08, 0.125
114091, 2.1583333333333, -0.12, 0.125
114092, 2.1583333333333, -0.16, 0.125
114093, 1.2416666666667, -0.04, 0.16666666666667
114094, 1.2416666666667, -0.08, 0.16666666666667
114095, 1.2416666666667, -0.12, 0.16666666666667
114096, 1.2416666666667, -0.16, 0.16666666666667
114097, 1.2833333333333, -0.04, 0.16666666666667
114098, 1.2833333333333, -0.08, 0.16666666666667
114099, 1.2833333333333, -0.12, 0.16666666666667
114100, 1.2833333333333, -0.16, 0.16666666666667
114101, 1.325, -0.04, 0.16666666666667
114102, 1.325, -0.08, 0.16666666666667
114103, 1.325, -0.12, 0.16666666666667
114104, 1.325, -0.16, 0.16666666666667
114105, 1.3666666666667, -0.04, 0.16666666666667
114106, 1.3666666666667, -0.08, 0.16666666666667
114107, 1.3666666666667, -0.12, 0.16666666666667
114108, 1.3666666666667, -0.16, 0.16666666666667
114109, 1.4083333333333, -0.04, 0.16666666666667
114110, 1.4083333333333, -0.08, 0.16666666666667
114111, 1.4083333333333, -0.12, 0.16666666666667
114112, 1.4083333333333, -0.16, 0.16666666666667
114113, 1.45, -0.04, 0.16666666666667
114114, 1.45, -0.08, 0.16666666666667
114115, 1.45, -0.12, 0.16666666666667
114116, 1.45, -0.16, 0.16666666666667
114117, 1.4916666666667, -0.04, 0.16666666666667
114118, 1.4916666666667, -0.08, 0.16666666666667
114119, 1.4916666666667, -0.12, 0.16666666666667
114120, 1.4916666666667, -0.16, 0.16666666666667
114121, 1.5333333333333, -0.04, 0.16666666666667
114122, 1.5333333333333, -0.08, 0.16666666666667
114123, 1.5333333333333, -0.12, 0.16666666666667
114124, 1.5333333333333, -0.16, 0.16666666666667
114125, 1.575, -0.04, 0.16666666666667
114126, 1.575, -0.08, 0.16666666666667
114127, 1.575, -0.12, 0.16666666666667
114128, 1.575, -0.16, 0.16666666666667
114129, 1.6166666666667, -0.04, 0.16666666666667
114130, 1.6166666666667, -0.08, 0.16666666666667
114131, 1.6166666666667, -0.12, 0.16666666666667
114132, 1.6166666666667, -0.16, 0.16666666666667
114133, 1.6583333333333, -0.04, 0.16666666666667
114134, 1.6583333333333, -0.08, 0.16666666666667
114135, 1.6583333333333, -0.12, 0.16666666666667
114136, 1.6583333333333, -0.16, 0.16666666666667
114137, 1.7, -0.04, 0.16666666666667
114138, 1.7, -0.08, 0.16666666666667
114139, 1.7, -0.12, 0.16666666666667
114140, 1.7, -0.16, 0.16666666666667
114141, 1.7416666666667, -0.04, 0.16666666666667
114142, 1.7416666666667, -0.08, 0.16666666666667
114143, 1.7416666666667, -0.12, 0.16666666666667
114144, 1.7416666666667, -0.16, 0.16666666666667
114145, 1.7833333333333, -0.04, 0.16666666666667
114146, 1.7833333333333, -0.08, 0.16666666666667
114147, 1.7833333333333, -0.12, 0.16666666666667
114148, 1.7833333333333, -0.16, 0.16666666666667
114149, 1.825, -0.04, 0.16666666666667
114150, 1.825, -0.08, 0.16666666666667
114151, 1.825, -0.12, 0.16666666666667
114152, 1.825, -0.16, 0.16666666666667
114153, 1.8666666666667, -0.04, 0.16666666666667
114154, 1.8666666666667, -0.08, 0.16666666666667
114155, 1.8666666666667, -0.12, 0.16666666666667
114156, 1.8666666666667, -0.16, 0.16666666666667
114157, 1.9083333333333, -0.04, 0.16666666666667
114158, 1.9083333333333, -0.08, 0.16666666666667
114159, 1.9083333333333, -0.12, 0.16666666666667
114160, 1.9083333333333, -0.16, 0.16666666666667
114161, 1.95, -0.04, 0.16666666666667
114162, 1.95, -0.08, 0.16666666666667
114163, 1.95, -0.12, 0.16666666666667
114164, 1.95, -0.16, 0.16666666666667
114165, 1.9916666666667, -0.04, 0.16666666666667
114166, 1.9916666666667, -0.08, 0.16666666666667
114167, 1.9916666666667, -0.12, 0.16666666666667
114168, 1.9916666666667, -0.16, 0.16666666666667
114169, 2.0333333333333, -0.04, 0.16666666666667
114170, 2.0333333333333, -0.08, 0.16666666666667
114171, 2.0333333333333, -0.12, 0.16666666666667
114172, 2.0333333333333, -0.16, 0.16666666666667
114173, 2.075, -0.04, 0.16666666666667
114174, 2.075, -0.08, 0.16666666666667
114175, 2.075, -0.12, 0.16666666666667
114176, 2.075, -0.16, 0.16666666666667
114177, 2.1166666666667, -0.04, 0.16666666666667
114178, 2.1166666666667, -0.08, 0.16666666666667
114179, 2.1166666666667, -0.12, 0.16666666666667
114180, 2.1166666666667, -0.16, 0.16666666666667
114181, 2.1583333333333, -0.04, 0.16666666666667
114182, 2.1583333333333, -0.08, 0.16666666666667
114183, 2.1583333333333, -0.12, 0.16666666666667
114184, 2.1583333333333, -0.16, 0.16666666666667
114185, 1.2416666666667, -0.04, 0.20833333333333
114186, 1.2416666666667, -0.08, 0.20833333333333
114187, 1.2416666666667, -0.12, 0.20833333333333
114188, 1.2416666666667, -0.16, 0.20833333333333
114189, 1.2833333333333, -0.04, 0.20833333333333
114190, 1.2833333333333, -0.08, 0.20833333333333
114191, 1.2833333333333, -0.12, 0.20833333333333
114192, 1.2833333333333, -0.16, 0.20833333333333
114193, 1.325, -0.04, 0.20833333333333
114194, 1.325, -0.08, 0.20833333333333
114195, 1.325, -0.12, 0.20833333333333
114196, 1.325, -0.16, 0.20833333333333
114197, 1.3666666666667, -0.04, 0.20833333333333
114198, 1.3666666666667, -0.08, 0.20833333333333
114199, 1.3666666666667, -0.12, 0.20833333333333
114200, 1.3666666666667, -0.16, 0.20833333333333
114201, 1.4083333333333, -0.04, 0.20833333333333
114202, 1.4083333333333, -0.08, 0.20833333333333
114203, 1.4083333333333, -0.12, 0.20833333333333
114204, 1.4083333333333, -0.16, 0.20833333333333
114205, 1.45, -0.04, 0.20833333333333
114206, 1.45, -0.08, 0.20833333333333
114207, 1.45, -0.12, 0.20833333333333
114208, 1.45, -0.16, 0.20833333333333
114209, 1.4916666666667, -0.04, 0.20833333333333
114210, 1.4916666666667, -0.08, 0.20833333333333
114211, 1.4916666666667, -0.12, 0.20833333333333
114212, 1.4916666666667, -0.16, 0.20833333333333
114213, 1.5333333333333, -0.04, 0.20833333333333
114214, 1.5333333333333, -0.08, 0.20833333333333
114215, 1.5333333333333, -0.12, 0.20833333333333
114216, 1.5333333333333, -0.16, 0.20833333333333
114217, 1.575, -0.04, 0.20833333333333
114218, 1.575, -0.08, 0.20833333333333
114219, 1.575, -0.12, 0.20833333333333
114220, 1.575, -0.16, 0.20833333333333
114221, 1.6166666666667, -0.04, 0.20833333333333
114222, 1.6166666666667, -0.08, 0.20833333333333
114223, 1.6166666666667, -0.12, 0.20833333333333
114224, 1.6166666666667, -0.16, 0.20833333333333
114225, 1.6583333333333, -0.04, 0.20833333333333
114226, 1.6583333333333, -0.08, 0.20833333333333
114227, 1.6583333333333, -0.12, 0.20833333333333
114228, 1.6583333333333, -0.16, 0.20833333333333
114229, 1.7, -0.04, 0.20833333333333
114230, 1.7, -0.08, 0.20833333333333
114231, 1.7, -0.12, 0.20833333333333
114232, 1.7, -0.16, 0.20833333333333
114233, 1.7416666666667, -0.04, 0.20833333333333
114234, 1.7416666666667, -0.08, 0.20833333333333
114235, 1.7416666666667, -0.12, 0.20833333333333
114236, 1.7416666666667, -0.16, 0.20833333333333
114237, 1.7833333333333, -0.04, 0.20833333333333
114238, 1.7833333333333, -0.08, 0.20833333333333
114239, 1.7833333333333, -0.12, 0.20833333333333
114240, 1.7833333333333, -0.16, 0.20833333333333
114241, 1.825, -0.04, 0.20833333333333
114242, 1.825, -0.08, 0.20833333333333
114243, 1.825, -0.12, 0.20833333333333
114244, 1.825, -0.16, 0.20833333333333
114245, 1.8666666666667, -0.04, 0.20833333333333
114246, 1.8666666666667, -0.08, 0.20833333333333
114247, 1.8666666666667, -0.12, 0.20833333333333
114248, 1.8666666666667, -0.16, 0.20833333333333
114249, 1.9083333333333, -0.04, 0.20833333333333
114250, 1.9083333333333, -0.08, 0.20833333333333
114251, 1.9083333333333, -0.12, 0.20833333333333
114252, 1.9083333333333, -0.16, 0.20833333333333
114253, 1.95, -0.04, 0.20833333333333
114254, 1.95, -0.08, 0.20833333333333
114255, 1.95, -0.12, 0.20833333333333
114256, 1.95, -0.16, 0.20833333333333
114257, 1.9916666666667, -0.04, 0.20833333333333
114258, 1.9916666666667, -0.08, 0.20833333333333
114259, 1.9916666666667, -0.12, 0.20833333333333
114260, 1.9916666666667, -0.16, 0.20833333333333
114261, 2.0333333333333, -0.04, 0.20833333333333
114262, 2.0333333333333, -0.08, 0.20833333333333
114263, 2.0333333333333, -0.12, 0.20833333333333
114264, 2.0333333333333, -0.16, 0.20833333333333
114265, 2.075, -0.04, 0.20833333333333
114266, 2.075, -0.08, 0.20833333333333
114267, 2.075, -0.12, 0.20833333333333
114268, 2.075, -0.16, 0.20833333333333
114269, 2.1166666666667, -0.04, 0.20833333333333
114270, 2.1166666666667, -0.08, 0.20833333333333
114271, 2.1166666666667, -0.12, 0.20833333333333
114272, 2.1166666666667, -0.16, 0.20833333333333
114273, 2.1583333333333, -0.04, 0.20833333333333
114274, 2.1583333333333, -0.08, 0.20833333333333
114275, 2.1583333333333, -0.12, 0.20833333333333
114276, 2.1583333333333, -0.16, 0.20833333333333
114277, 1.2416666666667, -0.04, 0.25
114278, 1.2416666666667, -0.08, 0.25
114279, 1.2416666666667, -0.12, 0.25
114280, 1.2416666666667, -0.16, 0.25
114281, 1.2833333333333, -0.04, 0.25
114282, 1.2833333333333, -0.08, 0.25
114283, 1.2833333333333, -0.12, 0.25
114284, 1.2833333333333, -0.16, 0.25
114285, 1.325, -0.04, 0.25
114286, 1.325, -0.08, 0.25
114287, 1.325, -0.12, 0.25
114288, 1.325, -0.16, 0.25
114289, 1.3666666666667, -0.04, 0.25
114290, 1.3666666666667, -0.08, 0.25
114291, 1.3666666666667, -0.12, 0.25
114292, 1.3666666666667, -0.16, 0.25
114293, 1.4083333333333, -0.04, 0.25
114294, 1.4083333333333, -0.08, 0.25
114295, 1.4083333333333, -0.12, 0.25
114296, 1.4083333333333, -0.16, 0.25
114297, 1.45, -0.04, 0.25
114298, 1.45, -0.08, 0.25
114299, 1.45, -0.12, 0.25
114300, 1.45, -0.16, 0.25
114301, 1.4916666666667, -0.04, 0.25
114302, 1.4916666666667, -0.08, 0.25
114303, 1.4916666666667, -0.12, 0.25
114304, 1.4916666666667, -0.16, 0.25
114305, 1.5333333333333, -0.04, 0.25
114306, 1.5333333333333, -0.08, 0.25
114307, 1.5333333333333, -0.12, 0.25
114308, 1.5333333333333, -0.16, 0.25
114309, 1.575, -0.04, 0.25
114310, 1.575, -0.08, 0.25
114311, 1.575, -0.12, 0.25
114312, 1.575, -0.16, 0.25
114313, 1.6166666666667, -0.04, 0.25
114314, 1.6166666666667, -0.08, 0.25
114315, 1.6166666666667, -0.12, 0.25
114316, 1.6166666666667, -0.16, 0.25
114317, 1.6583333333333, -0.04, 0.25
114318, 1.6583333333333, -0.08, 0.25
114319, 1.6583333333333, -0.12, 0.25
114320, 1.6583333333333, -0.16, 0.25
114321, 1.7, -0.04, 0.25
114322, 1.7, -0.08, 0.25
114323, 1.7, -0.12, 0.25
114324, 1.7, -0.16, 0.25
114325, 1.7416666666667, -0.04, 0.25
114326, 1.7416666666667, -0.08, 0.25
114327, 1.7416666666667, -0.12, 0.25
114328, 1.7416666666667, -0.16, 0.25
114329, 1.7833333333333, -0.04, 0.25
114330, 1.7833333333333, -0.08, 0.25
114331, 1.7833333333333, -0.12, 0.25
114332, 1.7833333333333, -0.16, 0.25
114333, 1.825, -0.04, 0.25
114334, 1.825, -0.08, 0.25
114335, 1.825, -0.12, 0.25
114336, 1.825, -0.16, 0.25
114337, 1.8666666666667, -0.04, 0.25
114338, 1.8666666666667, -0.08, 0.25
114339, 1.8666666666667, -0.12, 0.25
114340, 1.8666666666667, -0.16, 0.25
114341, 1.9083333333333, -0.04, 0.25
114342, 1.9083333333333, -0.08, 0.25
114343, 1.9083333333333, -0.12, 0.25
114344, 1.9083333333333, -0.16, 0.25
114345, 1.95, -0.04, 0.25
114346, 1.95, -0.08, 0.25
114347, 1.95, -0.12, 0.25
114348, 1.95, -0.16, 0.25
114349, 1.9916666666667, -0.04, 0.25
114350, 1.9916666666667, -0.08, 0.25
114351, 1.9916666666667, -0.12, 0.25
114352, 1.9916666666667, -0.16, 0.25
114353, 2.0333333333333, -0.04, 0.25
114354, 2.0333333333333, -0.08, 0.25
114355, 2.0333333333333, -0.12, 0.25
114356, 2.0333333333333, -0.16, 0.25
114357, 2.075, -0.04, 0.25
114358, 2.075, -0.08, 0.25
114359, 2.075, -0.12, 0.25
114360, 2.075, -0.16, 0.25
114361, 2.1166666666667, -0.04, 0.25
114362, 2.1166666666667, -0.08, 0.25
114363, 2.1166666666667, -0.12, 0.25
114364, 2.1166666666667, -0.16, 0.25
114365, 2.1583333333333, -0.04, 0.25
114366, 2.1583333333333, -0.08, 0.25
114367, 2.1583333333333, -0.12, 0.25
114368, 2.1583333333333, -0.16, 0.25
114369, 1.2416666666667, -0.04, 0.29166666666667
114370, 1.2416666666667, -0.08, 0.29166666666667
114371, 1.2416666666667, -0.12, 0.29166666666667
114372, 1.2416666666667, -0.16, 0.29166666666667
114373, 1.2833333333333, -0.04, 0.29166666666667
114374, 1.2833333333333, -0.08, 0.29166666666667
114375, 1.2833333333333, -0.12, 0.29166666666667
114376, 1.2833333333333, -0.16, 0.29166666666667
114377, 1.325, -0.04, 0.29166666666667
114378, 1.325, -0.08, 0.29166666666667
114379, 1.325, -0.12, 0.29166666666667
114380, 1.325, -0.16, 0.29166666666667
114381, 1.3666666666667, -0.04, 0.29166666666667
114382, 1.3666666666667, -0.08, 0.29166666666667
114383, 1.3666666666667, -0.12, 0.29166666666667
114384, 1.3666666666667, -0.16, 0.29166666666667
114385, 1.4083333333333, -0.04, 0.29166666666667
114386, 1.4083333333333, -0.08, 0.29166666666667
114387, 1.4083333333333, -0.12, 0.29166666666667
114388, 1.4083333333333, -0.16, 0.29166666666667
114389, 1.45, -0.04, 0.29166666666667
114390, 1.45, -0.08, 0.29166666666667
114391, 1.45, -0.12, 0.29166666666667
114392, 1.45, -0.16, 0.29166666666667
114393, 1.4916666666667, -0.04, 0.29166666666667
114394, 1.4916666666667, -0.08, 0.29166666666667
114395, 1.4916666666667, -0.12, 0.29166666666667
114396, 1.4916666666667, -0.16, 0.29166666666667
114397, 1.5333333333333, -0.04, 0.29166666666667
114398, 1.5333333333333, -0.08, 0.29166666666667
114399, 1.5333333333333, -0.12, 0.29166666666667
114400, 1.5333333333333, -0.16, 0.29166666666667
114401, 1.575, -0.04, 0.29166666666667
114402, 1.575, -0.08, 0.29166666666667
114403, 1.575, -0.12, 0.29166666666667
114404, 1.575, -0.16, 0.29166666666667
114405, 1.6166666666667, -0.04, 0.29166666666667
114406, 1.6166666666667, -0.08, 0.29166666666667
114407, 1.6166666666667, -0.12, 0.29166666666667
114408, 1.6166666666667, -0.16, 0.29166666666667
114409, 1.6583333333333, -0.04, 0.29166666666667
114410, 1.6583333333333, -0.08, 0.29166666666667
114411, 1.6583333333333, -0.12, 0.29166666666667
114412, 1.6583333333333, -0.16, 0.29166666666667
114413, 1.7, -0.04, 0.29166666666667
114414, 1.7, -0.08, 0.29166666666667
114415, 1.7, -0.12, 0.29166666666667
114416, 1.7, -0.16, 0.29166666666667
114417, 1.7416666666667, -0.04, 0.29166666666667
114418, 1.7416666666667, -0.08, 0.29166666666667
114419, 1.7416666666667, -0.12, 0.29166666666667
114420, 1.7416666666667, -0.16, 0.29166666666667
114421, 1.7833333333333, -0.04, 0.29166666666667
114422, 1.7833333333333, -0.08, 0.29166666666667
114423, 1.7833333333333, -0.12, 0.29166666666667
114424, 1.7833333333333, -0.16, 0.29166666666667
114425, 1.825, -0.04, 0.29166666666667
114426, 1.825, -0.08, 0.29166666666667
114427, 1.825, -0.12, 0.29166666666667
114428, 1.825, -0.16, 0.29166666666667
114429, 1.8666666666667, -0.04, 0.29166666666667
114430, 1.8666666666667, -0.08, 0.29166666666667
114431, 1.8666666666667, -0.12, 0.29166666666667
114432, 1.8666666666667, -0.16, 0.29166666666667
114433, 1.9083333333333, -0.04, 0.29166666666667
114434, 1.9083333333333, -0.08, 0.29166666666667
114435, 1.9083333333333, -0.12, 0.29166666666667
114436, 1.9083333333333, -0.16, 0.29166666666667
114437, 1.95, -0.04, 0.29166666666667
114438, 1.95, -0.08, 0.29166666666667
114439, 1.95, -0.12, 0.29166666666667
114440, 1.95, -0.16, 0.29166666666667
114441, 1.9916666666667, -0.04, 0.29166666666667
114442, 1.9916666666667, -0.08, 0.29166666666667
114443, 1.9916666666667, -0.12, 0.29166666666667
114444, 1.9916666666667, -0.16, 0.29166666666667
114445, 2.0333333333333, -0.04, 0.29166666666667
114446, 2.0333333333333, -0.08, 0.29166666666667
114447, 2.0333333333333, -0.12, 0.29166666666667
114448, 2.0333333333333, -0.16, 0.29166666666667
114449, 2.075, -0.04, 0.29166666666667
114450, 2.075, -0.08, 0.29166666666667
114451, 2.075, -0.12, 0.29166666666667
114452, 2.075, -0.16, 0.29166666666667
114453, 2.1166666666667, -0.04, 0.29166666666667
114454, 2.1166666666667, -0.08, 0.29166666666667
114455, 2.1166666666667, -0.12, 0.29166666666667
114456, 2.1166666666667, -0.16, 0.29166666666667
114457, 2.1583333333333, -0.04, 0.29166666666667
114458, 2.1583333333333, -0.08, 0.29166666666667
114459, 2.1583333333333, -0.12, 0.29166666666667
114460, 2.1583333333333, -0.16, 0.29166666666667
114461, 1.2416666666667, -0.04, 0.33333333333333
114462, 1.2416666666667, -0.08, 0.33333333333333
114463, 1.2416666666667, -0.12, 0.33333333333333
114464, 1.2416666666667, -0.16, 0.33333333333333
114465, 1.2833333333333, -0.04, 0.33333333333333
114466, 1.2833333333333, -0.08, 0.33333333333333
114467, 1.2833333333333, -0.12, 0.33333333333333
114468, 1.2833333333333, -0.16, 0.33333333333333
114469, 1.325, -0.04, 0.33333333333333
114470, 1.325, -0.08, 0.33333333333333
114471, 1.325, -0.12, 0.33333333333333
114472, 1.325, -0.16, 0.33333333333333
114473, 1.3666666666667, -0.04, 0.33333333333333
114474, 1.3666666666667, -0.08, 0.33333333333333
114475, 1.3666666666667, -0.12, 0.33333333333333
114476, 1.3666666666667, -0.16, 0.33333333333333
114477, 1.4083333333333, -0.04, 0.33333333333333
114478, 1.4083333333333, -0.08, 0.33333333333333
114479, 1.4083333333333, -0.12, 0.33333333333333
114480, 1.4083333333333, -0.16, 0.33333333333333
114481, 1.45, -0.04, 0.33333333333333
114482, 1.45, -0.08, 0.33333333333333
114483, 1.45, -0.12, 0.33333333333333
114484, 1.45, -0.16, 0.33333333333333
114485, 1.4916666666667, -0.04, 0.33333333333333
114486, 1.4916666666667, -0.08, 0.33333333333333
114487, 1.4916666666667, -0.12, 0.33333333333333
114488, 1.4916666666667, -0.16, 0.33333333333333
114489, 1.5333333333333, -0.04, 0.33333333333333
114490, 1.5333333333333, -0.08, 0.33333333333333
114491, 1.5333333333333, -0.12, 0.33333333333333
114492, 1.5333333333333, -0.16, 0.33333333333333
114493, 1.575, -0.04, 0.33333333333333
114494, 1.575, -0.08, 0.33333333333333
114495, 1.575, -0.12, 0.33333333333333
114496, 1.575, -0.16, 0.33333333333333
114497, 1.6166666666667, -0.04, 0.33333333333333
114498, 1.6166666666667, -0.08, 0.33333333333333
114499, 1.6166666666667, -0.12, 0.33333333333333
114500, 1.6166666666667, -0.16, 0.33333333333333
114501, 1.6583333333333, -0.04, 0.33333333333333
114502, 1.6583333333333, -0.08, 0.33333333333333
114503, 1.6583333333333, -0.12, 0.33333333333333
114504, 1.6583333333333, -0.16, 0.33333333333333
114505, 1.7, -0.04, 0.33333333333333
114506, 1.7, -0.08, 0.33333333333333
114507, 1.7, -0.12, 0.33333333333333
114508, 1.7, -0.16, 0.33333333333333
114509, 1.7416666666667, -0.04, 0.33333333333333
114510, 1.7416666666667, -0.08, 0.33333333333333
114511, 1.7416666666667, -0.12, 0.33333333333333
114512, 1.7416666666667, -0.16, 0.33333333333333
114513, 1.7833333333333, -0.04, 0.33333333333333
114514, 1.7833333333333, -0.08, 0.33333333333333
114515, 1.7833333333333, -0.12, 0.33333333333333
114516, 1.7833333333333, -0.16, 0.33333333333333
114517, 1.825, -0.04, 0.33333333333333
114518, 1.825, -0.08, 0.33333333333333
114519, 1.825, -0.12, 0.33333333333333
114520, 1.825, -0.16, 0.33333333333333
114521, 1.8666666666667, -0.04, 0.33333333333333
114522, 1.8666666666667, -0.08, 0.33333333333333
114523, 1.8666666666667, -0.12, 0.33333333333333
114524, 1.8666666666667, -0.16, 0.33333333333333
114525, 1.9083333333333, -0.04, 0.33333333333333
114526, 1.9083333333333, -0.08, 0.33333333333333
114527, 1.9083333333333, -0.12, 0.33333333333333
114528, 1.9083333333333, -0.16, 0.33333333333333
114529, 1.95, -0.04, 0.33333333333333
114530, 1.95, -0.08, 0.33333333333333
114531, 1.95, -0.12, 0.33333333333333
114532, 1.95, -0.16, 0.33333333333333
114533, 1.9916666666667, -0.04, 0.33333333333333
114534, 1.9916666666667, -0.08, 0.33333333333333
114535, 1.9916666666667, -0.12, 0.33333333333333
114536, 1.9916666666667, -0.16, 0.33333333333333
114537, 2.0333333333333, -0.04, 0.33333333333333
114538, 2.0333333333333, -0.08, 0.33333333333333
114539, 2.0333333333333, -0.12, 0.33333333333333
114540, 2.0333333333333, -0.16, 0.33333333333333
114541, 2.075, -0.04, 0.33333333333333
114542, 2.075, -0.08, 0.33333333333333
114543, 2.075, -0.12, 0.33333333333333
114544, 2.075, -0.16, 0.33333333333333
114545, 2.1166666666667, -0.04, 0.33333333333333
114546, 2.1166666666667, -0.08, 0.33333333333333
114547, 2.1166666666667, -0.12, 0.33333333333333
114548, 2.1166666666667, -0.16, 0.33333333333333
114549, 2.1583333333333, -0.04, 0.33333333333333
114550, 2.1583333333333, -0.08, 0.33333333333333
114551, 2.1583333333333, -0.12, 0.33333333333333
114552, 2.1583333333333, -0.16, 0.33333333333333
114553, 1.2416666666667, -0.04, 0.375
114554, 1.2416666666667, -0.08, 0.375
114555, 1.2416666666667, -0.12, 0.375
114556, 1.2416666666667, -0.16, 0.375
114557, 1.2833333333333, -0.04, 0.375
114558, 1.2833333333333, -0.08, 0.375
114559, 1.2833333333333, -0.12, 0.375
114560, 1.2833333333333, -0.16, 0.375
114561, 1.325, -0.04, 0.375
114562, 1.325, -0.08, 0.375
114563, 1.325, -0.12, 0.375
114564, 1.325, -0.16, 0.375
114565, 1.3666666666667, -0.04, 0.375
114566, 1.3666666666667, -0.08, 0.375
114567, 1.3666666666667, -0.12, 0.375
114568, 1.3666666666667, -0.16, 0.375
114569, 1.4083333333333, -0.04, 0.375
114570, 1.4083333333333, -0.08, 0.375
114571, 1.4083333333333, -0.12, 0.375
114572, 1.4083333333333, -0.16, 0.375
114573, 1.45, -0.04, 0.375
114574, 1.45, -0.08, 0.375
114575, 1.45, -0.12, 0.375
114576, 1.45, -0.16, 0.375
114577, 1.4916666666667, -0.04, 0.375
114578, 1.4916666666667, -0.08, 0.375
114579, 1.4916666666667, -0.12, 0.375
114580, 1.4916666666667, -0.16, 0.375
114581, 1.5333333333333, -0.04, 0.375
114582, 1.5333333333333, -0.08, 0.375
114583, 1.5333333333333, -0.12, 0.375
114584, 1.5333333333333, -0.16, 0.375
114585, 1.575, -0.04, 0.375
114586, 1.575, -0.08, 0.375
114587, 1.575, -0.12, 0.375
114588, 1.575, -0.16, 0.375
114589, 1.6166666666667, -0.04, 0.375
114590, 1.6166666666667, -0.08, 0.375
114591, 1.6166666666667, -0.12, 0.375
114592, 1.6166666666667, -0.16, 0.375
114593, 1.6583333333333, -0.04, 0.375
114594, 1.6583333333333, -0.08, 0.375
114595, 1.6583333333333, -0.12, 0.375
114596, 1.6583333333333, -0.16, 0.375
114597, 1.7, -0.04, 0.375
114598, 1.7, -0.08, 0.375
114599, 1.7, -0.12, 0.375
114600, 1.7, -0.16, 0.375
114601, 1.7416666666667, -0.04, 0.375
114602, 1.7416666666667, -0.08, 0.375
114603, 1.7416666666667, -0.12, 0.375
114604, 1.7416666666667, -0.16, 0.375
114605, 1.7833333333333, -0.04, 0.375
114606, 1.7833333333333, -0.08, 0.375
114607, 1.7833333333333, -0.12, 0.375
114608, 1.7833333333333, -0.16, 0.375
114609, 1.825, -0.04, 0.375
114610, 1.825, -0.08, 0.375
114611, 1.825, -0.12, 0.375
114612, 1.825, -0.16, 0.375
114613, 1.8666666666667, -0.04, 0.375
114614, 1.8666666666667, -0.08, 0.375
114615, 1.8666666666667, -0.12, 0.375
114616, 1.8666666666667, -0.16, 0.375
114617, 1.9083333333333, -0.04, 0.375
114618, 1.9083333333333, -0.08, 0.375
114619, 1.9083333333333, -0.12, 0.375
114620, 1.9083333333333, -0.16, 0.375
114621, 1.95, -0.04, 0.375
114622, 1.95, -0.08, 0.375
114623, 1.95, -0.12, 0.375
114624, 1.95, -0.16, 0.375
114625, 1.9916666666667, -0.04, 0.375
114626, 1.9916666666667, -0.08, 0.375
114627, 1.9916666666667, -0.12, 0.375
114628, 1.9916666666667, -0.16, 0.375
114629, 2.0333333333333, -0.04, 0.375
114630, 2.0333333333333, -0.08, 0.375
114631, 2.0333333333333, -0.12, 0.375
114632, 2.0333333333333, -0.16, 0.375
114633, 2.075, -0.04, 0.375
114634, 2.075, -0.08, 0.375
114635, 2.075, -0.12, 0.375
114636, 2.075, -0.16, 0.375
114637, 2.1166666666667, -0.04, 0.375
114638, 2.1166666666667, -0.08, 0.375
114639, 2.1166666666667, -0.12, 0.375
114640, 2.1166666666667, -0.16, 0.375
114641, 2.1583333333333, -0.04, 0.375
114642, 2.1583333333333, -0.08, 0.375
114643, 2.1583333333333, -0.12, 0.375
114644, 2.1583333333333, -0.16, 0.375
114645, 1.2416666666667, -0.04, 0.41666666666667
114646, 1.2416666666667, -0.08, 0.41666666666667
114647, 1.2416666666667, -0.12, 0.41666666666667
114648, 1.2416666666667, -0.16, 0.41666666666667
114649, 1.2833333333333, -0.04, 0.41666666666667
114650, 1.2833333333333, -0.08, 0.41666666666667
114651, 1.2833333333333, -0.12, 0.41666666666667
114652, 1.2833333333333, -0.16, 0.41666666666667
114653, 1.325, -0.04, 0.41666666666667
114654, 1.325, -0.08, 0.41666666666667
114655, 1.325, -0.12, 0.41666666666667
114656, 1.325, -0.16, 0.41666666666667
114657, 1.3666666666667, -0.04, 0.41666666666667
114658, 1.3666666666667, -0.08, 0.41666666666667
114659, 1.3666666666667, -0.12, 0.41666666666667
114660, 1.3666666666667, -0.16, 0.41666666666667
114661, 1.4083333333333, -0.04, 0.41666666666667
114662, 1.4083333333333, -0.08, 0.41666666666667
114663, 1.4083333333333, -0.12, 0.41666666666667
114664, 1.4083333333333, -0.16, 0.41666666666667
114665, 1.45, -0.04, 0.41666666666667
114666, 1.45, -0.08, 0.41666666666667
114667, 1.45, -0.12, 0.41666666666667
114668, 1.45, -0.16, 0.41666666666667
114669, 1.4916666666667, -0.04, 0.41666666666667
114670, 1.4916666666667, -0.08, 0.41666666666667
114671, 1.4916666666667, -0.12, 0.41666666666667
114672, 1.4916666666667, -0.16, 0.41666666666667
114673, 1.5333333333333, -0.04, 0.41666666666667
114674, 1.5333333333333, -0.08, 0.41666666666667
114675, 1.5333333333333, -0.12, 0.41666666666667
114676, 1.5333333333333, -0.16, 0.41666666666667
114677, 1.575, -0.04, 0.41666666666667
114678, 1.575, -0.08, 0.41666666666667
114679, 1.575, -0.12, 0.41666666666667
114680, 1.575, -0.16, 0.41666666666667
114681, 1.6166666666667, -0.04, 0.41666666666667
114682, 1.6166666666667, -0.08, 0.41666666666667
114683, 1.6166666666667, -0.12, 0.41666666666667
114684, 1.6166666666667, -0.16, 0.41666666666667
114685, 1.6583333333333, -0.04, 0.41666666666667
114686, 1.6583333333333, -0.08, 0.41666666666667
114687, 1.6583333333333, -0.12, 0.41666666666667
114688, 1.6583333333333, -0.16, 0.41666666666667
114689, 1.7, -0.04, 0.41666666666667
114690, 1.7, -0.08, 0.41666666666667
114691, 1.7, -0.12, 0.41666666666667
114692, 1.7, -0.16, 0.41666666666667
114693, 1.7416666666667, -0.04, 0.41666666666667
114694, 1.7416666666667, -0.08, 0.41666666666667
114695, 1.7416666666667, -0.12, 0.41666666666667
114696, 1.7416666666667, -0.16, 0.41666666666667
114697, 1.7833333333333, -0.04, 0.41666666666667
114698, 1.7833333333333, -0.08, 0.41666666666667
114699, 1.7833333333333, -0.12, 0.41666666666667
114700, 1.7833333333333, -0.16, 0.41666666666667
114701, 1.825, -0.04, 0.41666666666667
114702, 1.825, -0.08, 0.41666666666667
114703, 1.825, -0.12, 0.41666666666667
114704, 1.825, -0.16, 0.41666666666667
114705, 1.8666666666667, -0.04, 0.41666666666667
114706, 1.8666666666667, -0.08, 0.41666666666667
114707, 1.8666666666667, -0.12, 0.41666666666667
114708, 1.8666666666667, -0.16, 0.41666666666667
114709, 1.9083333333333, -0.04, 0.41666666666667
114710, 1.9083333333333, -0.08, 0.41666666666667
114711, 1.9083333333333, -0.12, 0.41666666666667
114712, 1.9083333333333, -0.16, 0.41666666666667
114713, 1.95, -0.04, 0.41666666666667
114714, 1.95, -0.08, 0.41666666666667
114715, 1.95, -0.12, 0.41666666666667
114716, 1.95, -0.16, 0.41666666666667
114717, 1.9916666666667, -0.04, 0.41666666666667
114718, 1.9916666666667, -0.08, 0.41666666666667
114719, 1.9916666666667, -0.12, 0.41666666666667
114720, 1.9916666666667, -0.16, 0.41666666666667
114721, 2.0333333333333, -0.04, 0.41666666666667
114722, 2.0333333333333, -0.08, 0.41666666666667
114723, 2.0333333333333, -0.12, 0.41666666666667
114724, 2.0333333333333, -0.16, 0.41666666666667
114725, 2.075, -0.04, 0.41666666666667
114726, 2.075, -0.08, 0.41666666666667
114727, 2.075, -0.12, 0.41666666666667
114728, 2.075, -0.16, 0.41666666666667
114729, 2.1166666666667, -0.04, 0.41666666666667
114730, 2.1166666666667, -0.08, 0.41666666666667
114731, 2.1166666666667, -0.12, 0.41666666666667
114732, 2.1166666666667, -0.16, 0.41666666666667
114733, 2.1583333333333, -0.04, 0.41666666666667
114734, 2.1583333333333, -0.08, 0.41666666666667
114735, 2.1583333333333, -0.12, 0.41666666666667
114736, 2.1583333333333, -0.16, 0.41666666666667
114737, 1.2416666666667, -0.04, 0.45833333333333
114738, 1.2416666666667, -0.08, 0.45833333333333
114739, 1.2416666666667, -0.12, 0.45833333333333
114740, 1.2416666666667, -0.16, 0.45833333333333
114741, 1.2833333333333, -0.04, 0.45833333333333
114742, 1.2833333333333, -0.08, 0.45833333333333
114743, 1.2833333333333, -0.12, 0.45833333333333
114744, 1.2833333333333, -0.16, 0.45833333333333
114745, 1.325, -0.04, 0.45833333333333
114746, 1.325, -0.08, 0.45833333333333
114747, 1.325, -0.12, 0.45833333333333
114748, 1.325, -0.16, 0.45833333333333
114749, 1.3666666666667, -0.04, 0.45833333333333
114750, 1.3666666666667, -0.08, 0.45833333333333
114751, 1.3666666666667, -0.12, 0.45833333333333
114752, 1.3666666666667, -0.16, 0.45833333333333
114753, 1.4083333333333, -0.04, 0.45833333333333
114754, 1.4083333333333, -0.08, 0.45833333333333
114755, 1.4083333333333, -0.12, 0.45833333333333
114756, 1.4083333333333, -0.16, 0.45833333333333
114757, 1.45, -0.04, 0.45833333333333
114758, 1.45, -0.08, 0.45833333333333
114759, 1.45, -0.12, 0.45833333333333
114760, 1.45, -0.16, 0.45833333333333
114761, 1.4916666666667, -0.04, 0.45833333333333
114762, 1.4916666666667, -0.08, 0.45833333333333
114763, 1.4916666666667, -0.12, 0.45833333333333
114764, 1.4916666666667, -0.16, 0.45833333333333
114765, 1.5333333333333, -0.04, 0.45833333333333
114766, 1.5333333333333, -0.08, 0.45833333333333
114767, 1.5333333333333, -0.12, 0.45833333333333
114768, 1.5333333333333, -0.16, 0.45833333333333
114769, 1.575, -0.04, 0.45833333333333
114770, 1.575, -0.08, 0.45833333333333
114771, 1.575, -0.12, 0.45833333333333
114772, 1.575, -0.16, 0.45833333333333
114773, 1.6166666666667, -0.04, 0.45833333333333
114774, 1.6166666666667, -0.08, 0.45833333333333
114775, 1.6166666666667, -0.12, 0.45833333333333
114776, 1.6166666666667, -0.16, 0.45833333333333
114777, 1.6583333333333, -0.04, 0.45833333333333
114778, 1.6583333333333, -0.08, 0.45833333333333
114779, 1.6583333333333, -0.12, 0.45833333333333
114780, 1.6583333333333, -0.16, 0.45833333333333
114781, 1.7, -0.04, 0.45833333333333
114782, 1.7, -0.08, 0.45833333333333
114783, 1.7, -0.12, 0.45833333333333
114784, 1.7, -0.16, 0.45833333333333
114785, 1.7416666666667, -0.04, 0.45833333333333
114786, 1.7416666666667, -0.08, 0.45833333333333
114787, 1.7416666666667, -0.12, 0.45833333333333
114788, 1.7416666666667, -0.16, 0.45833333333333
114789, 1.7833333333333, -0.04, 0.45833333333333
114790, 1.7833333333333, -0.08, 0.45833333333333
114791, 1.7833333333333, -0.12, 0.45833333333333
114792, 1.7833333333333, -0.16, 0.45833333333333
114793, 1.825, -0.04, 0.45833333333333
114794, 1.825, -0.08, 0.45833333333333
114795, 1.825, -0.12, 0.45833333333333
114796, 1.825, -0.16, 0.45833333333333
114797, 1.8666666666667, -0.04, 0.45833333333333
114798, 1.8666666666667, -0.08, 0.45833333333333
114799, 1.8666666666667, -0.12, 0.45833333333333
114800, 1.8666666666667, -0.16, 0.45833333333333
114801, 1.9083333333333, -0.04, 0.45833333333333
114802, 1.9083333333333, -0.08, 0.45833333333333
114803, 1.9083333333333, -0.12, 0.45833333333333
114804, 1.9083333333333, -0.16, 0.45833333333333
114805, 1.95, -0.04, 0.45833333333333
114806, 1.95, -0.08, 0.45833333333333
114807, 1.95, -0.12, 0.45833333333333
114808, 1.95, -0.16, 0.45833333333333
114809, 1.9916666666667, -0.04, 0.45833333333333
114810, 1.9916666666667, -0.08, 0.45833333333333
114811, 1.9916666666667, -0.12, 0.45833333333333
114812, 1.9916666666667, -0.16, 0.45833333333333
114813, 2.0333333333333, -0.04, 0.45833333333333
114814, 2.0333333333333, -0.08, 0.45833333333333
114815, 2.0333333333333, -0.12, 0.45833333333333
114816, 2.0333333333333, -0.16, 0.45833333333333
114817, 2.075, -0.04, 0.45833333333333
114818, 2.075, -0.08, 0.45833333333333
114819, 2.075, -0.12, 0.45833333333333
114820, 2.075, -0.16, 0.45833333333333
114821, 2.1166666666667, -0.04, 0.45833333333333
114822, 2.1166666666667, -0.08, 0.45833333333333
114823, 2.1166666666667, -0.12, 0.45833333333333
114824, 2.1166666666667, -0.16, 0.45833333333333
114825, 2.1583333333333, -0.04, 0.45833333333333
114826, 2.1583333333333, -0.08, 0.45833333333333
114827, 2.1583333333333, -0.12, 0.45833333333333
114828, 2.1583333333333, -0.16, 0.45833333333333
114829, 1.2416666666667, -0.02, 0.041666666666667
114830, 1.2416666666667, -0.04, 0.020833333333333
114831, 1.2208333333333, -0.04, 0.041666666666667
114832, 1.2416666666667, -0.06, 0.041666666666667
114833, 1.2416666666667, -0.08, 0.020833333333333
114834, 1.2208333333333, -0.08, 0.041666666666667
114835, 1.2416666666667, -0.1, 0.041666666666667
114836, 1.2416666666667, -0.12, 0.020833333333333
114837, 1.2208333333333, -0.12, 0.041666666666667
114838, 1.2416666666667, -0.14, 0.041666666666667
114839, 1.2416666666667, -0.16, 0.020833333333333
114840, 1.2208333333333, -0.16, 0.041666666666667
114841, 1.2416666666667, -0.18, 0.041666666666667
114842, 1.2833333333333, -0.02, 0.041666666666667
114843, 1.2833333333333, -0.04, 0.020833333333333
114844, 1.2625, -0.04, 0.041666666666667
114845, 1.2833333333333, -0.06, 0.041666666666667
114846, 1.2833333333333, -0.08, 0.020833333333333
114847, 1.2625, -0.08, 0.041666666666667
114848, 1.2833333333333, -0.1, 0.041666666666667
114849, 1.2833333333333, -0.12, 0.020833333333333
114850, 1.2625, -0.12, 0.041666666666667
114851, 1.2833333333333, -0.14, 0.041666666666667
114852, 1.2833333333333, -0.16, 0.020833333333333
114853, 1.2625, -0.16, 0.041666666666667
114854, 1.2833333333333, -0.18, 0.041666666666667
114855, 1.325, -0.02, 0.041666666666667
114856, 1.325, -0.04, 0.020833333333333
114857, 1.3041666666667, -0.04, 0.041666666666667
114858, 1.325, -0.06, 0.041666666666667
114859, 1.325, -0.08, 0.020833333333333
114860, 1.3041666666667, -0.08, 0.041666666666667
114861, 1.325, -0.1, 0.041666666666667
114862, 1.325, -0.12, 0.020833333333333
114863, 1.3041666666667, -0.12, 0.041666666666667
114864, 1.325, -0.14, 0.041666666666667
114865, 1.325, -0.16, 0.020833333333333
114866, 1.3041666666667, -0.16, 0.041666666666667
114867, 1.325, -0.18, 0.041666666666667
114868, 1.3666666666667, -0.02, 0.041666666666667
114869, 1.3666666666667, -0.04, 0.020833333333333
114870, 1.3458333333333, -0.04, 0.041666666666667
114871, 1.3666666666667, -0.06, 0.041666666666667
114872, 1.3666666666667, -0.08, 0.020833333333333
114873, 1.3458333333333, -0.08, 0.041666666666667
114874, 1.3666666666667, -0.1, 0.041666666666667
114875, 1.3666666666667, -0.12, 0.020833333333333
114876, 1.3458333333333, -0.12, 0.041666666666667
114877, 1.3666666666667, -0.14, 0.041666666666667
114878, 1.3666666666667, -0.16, 0.020833333333333
114879, 1.3458333333333, -0.16, 0.041666666666667
114880, 1.3666666666667, -0.18, 0.041666666666667
114881, 1.4083333333333, -0.02, 0.041666666666667
114882, 1.4083333333333, -0.04, 0.020833333333333
114883, 1.3875, -0.04, 0.041666666666667
114884, 1.4083333333333, -0.06, 0.041666666666667
114885, 1.4083333333333, -0.08, 0.020833333333333
114886, 1.3875, -0.08, 0.041666666666667
114887, 1.4083333333333, -0.1, 0.041666666666667
114888, 1.4083333333333, -0.12, 0.020833333333333
114889, 1.3875, -0.12, 0.041666666666667
114890, 1.4083333333333, -0.14, 0.041666666666667
114891, 1.4083333333333, -0.16, 0.020833333333333
114892, 1.3875, -0.16, 0.041666666666667
114893, 1.4083333333333, -0.18, 0.041666666666667
114894, 1.45, -0.02, 0.041666666666667
114895, 1.45, -0.04, 0.020833333333333
114896, 1.4291666666667, -0.04, 0.041666666666667
114897, 1.45, -0.06, 0.041666666666667
114898, 1.45, -0.08, 0.020833333333333
114899, 1.4291666666667, -0.08, 0.041666666666667
114900, 1.45, -0.1, 0.041666666666667
114901, 1.45, -0.12, 0.020833333333333
114902, 1.4291666666667, -0.12, 0.041666666666667
114903, 1.45, -0.14, 0.041666666666667
114904, 1.45, -0.16, 0.020833333333333
114905, 1.4291666666667, -0.16, 0.041666666666667
114906, 1.45, -0.18, 0.041666666666667
114907, 1.4916666666667, -0.02, 0.041666666666667
114908, 1.4916666666667, -0.04, 0.020833333333333
114909, 1.4708333333333, -0.04, 0.041666666666667
114910, 1.4916666666667, -0.06, 0.041666666666667
114911, 1.4916666666667, -0.08, 0.020833333333333
114912, 1.4708333333333, -0.08, 0.041666666666667
114913, 1.4916666666667, -0.1, 0.041666666666667
114914, 1.4916666666667, -0.12, 0.020833333333333
114915, 1.4708333333333, -0.12, 0.041666666666667
114916, 1.4916666666667, -0.14, 0.041666666666667
114917, 1.4916666666667, -0.16, 0.020833333333333
114918, 1.4708333333333, -0.16, 0.041666666666667
114919, 1.4916666666667, -0.18, 0.041666666666667
114920, 1.5333333333333, -0.02, 0.041666666666667
114921, 1.5333333333333, -0.04, 0.020833333333333
114922, 1.5125, -0.04, 0.041666666666667
114923, 1.5333333333333, -0.06, 0.041666666666667
114924, 1.5333333333333, -0.08, 0.020833333333333
114925, 1.5125, -0.08, 0.041666666666667
114926, 1.5333333333333, -0.1, 0.041666666666667
114927, 1.5333333333333, -0.12, 0.020833333333333
114928, 1.5125, -0.12, 0.041666666666667
114929, 1.5333333333333, -0.14, 0.041666666666667
114930, 1.5333333333333, -0.16, 0.020833333333333
114931, 1.5125, -0.16, 0.041666666666667
114932, 1.5333333333333, -0.18, 0.041666666666667
114933, 1.575, -0.02, 0.041666666666667
114934, 1.575, -0.04, 0.020833333333333
114935, 1.5541666666667, -0.04, 0.041666666666667
114936, 1.575, -0.06, 0.041666666666667
114937, 1.575, -0.08, 0.020833333333333
114938, 1.5541666666667, -0.08, 0.041666666666667
114939, 1.575, -0.1, 0.041666666666667
114940, 1.575, -0.12, 0.020833333333333
114941, 1.5541666666667, -0.12, 0.041666666666667
114942, 1.575, -0.14, 0.041666666666667
114943, 1.575, -0.16, 0.020833333333333
114944, 1.5541666666667, -0.16, 0.041666666666667
114945, 1.575, -0.18, 0.041666666666667
114946, 1.6166666666667, -0.02, 0.041666666666667
114947, 1.6166666666667, -0.04, 0.020833333333333
114948, 1.5958333333333, -0.04, 0.041666666666667
114949, 1.6166666666667, -0.06, 0.041666666666667
114950, 1.6166666666667, -0.08, 0.020833333333333
114951, 1.5958333333333, -0.08, 0.041666666666667
114952, 1.6166666666667, -0.1, 0.041666666666667
114953, 1.6166666666667, -0.12, 0.020833333333333
114954, 1.5958333333333, -0.12, 0.041666666666667
114955, 1.6166666666667, -0.14, 0.041666666666667
114956, 1.6166666666667, -0.16, 0.020833333333333
114957, 1.5958333333333, -0.16, 0.041666666666667
114958, 1.6166666666667, -0.18, 0.041666666666667
114959, 1.6583333333333, -0.02, 0.041666666666667
114960, 1.6583333333333, -0.04, 0.020833333333333
114961, 1.6375, -0.04, 0.041666666666667
114962, 1.6583333333333, -0.06, 0.041666666666667
114963, 1.6583333333333, -0.08, 0.020833333333333
114964, 1.6375, -0.08, 0.041666666666667
114965, 1.6583333333333, -0.1, 0.041666666666667
114966, 1.6583333333333, -0.12, 0.020833333333333
114967, 1.6375, -0.12, 0.041666666666667
114968, 1.6583333333333, -0.14, 0.041666666666667
114969, 1.6583333333333, -0.16, 0.020833333333333
114970, 1.6375, -0.16, 0.041666666666667
114971, 1.6583333333333, -0.18, 0.041666666666667
114972, 1.7, -0.02, 0.041666666666667
114973, 1.7, -0.04, 0.020833333333333
114974, 1.6791666666667, -0.04, 0.041666666666667
114975, 1.7, -0.06, 0.041666666666667
114976, 1.7, -0.08, 0.020833333333333
114977, 1.6791666666667, -0.08, 0.041666666666667
114978, 1.7, -0.1, 0.041666666666667
114979, 1.7, -0.12, 0.020833333333333
114980, 1.6791666666667, -0.12, 0.041666666666667
114981, 1.7, -0.14, 0.041666666666667
114982, 1.7, -0.16, 0.020833333333333
114983, 1.6791666666667, -0.16, 0.041666666666667
114984, 1.7, -0.18, 0.041666666666667
114985, 1.7416666666667, -0.02, 0.041666666666667
114986, 1.7416666666667, -0.04, 0.020833333333333
114987, 1.7208333333333, -0.04, 0.041666666666667
114988, 1.7416666666667, -0.06, 0.041666666666667
114989, 1.7416666666667, -0.08, 0.020833333333333
114990, 1.7208333333333, -0.08, 0.041666666666667
114991, 1.7416666666667, -0.1, 0.041666666666667
114992, 1.7416666666667, -0.12, 0.020833333333333
114993, 1.7208333333333, -0.12, 0.041666666666667
114994, 1.7416666666667, -0.14, 0.041666666666667
114995, 1.7416666666667, -0.16, 0.020833333333333
114996, 1.7208333333333, -0.16, 0.041666666666667
114997, 1.7416666666667, -0.18, 0.041666666666667
114998, 1.7833333333333, -0.02, 0.041666666666667
114999, 1.7833333333333, -0.04, 0.020833333333333
115000, 1.7625, -0.04, 0.041666666666667
115001, 1.7833333333333, -0.06, 0.041666666666667
115002, 1.7833333333333, -0.08, 0.020833333333333
115003, 1.7625, -0.08, 0.041666666666667
115004, 1.7833333333333, -0.1, 0.041666666666667
115005, 1.7833333333333, -0.12, 0.020833333333333
115006, 1.7625, -0.12, 0.041666666666667
115007, 1.7833333333333, -0.14, 0.041666666666667
115008, 1.7833333333333, -0.16, 0.020833333333333
115009, 1.7625, -0.16, 0.041666666666667
115010, 1.7833333333333, -0.18, 0.041666666666667
115011, 1.825, -0.02, 0.041666666666667
115012, 1.825, -0.04, 0.020833333333333
115013, 1.8041666666667, -0.04, 0.041666666666667
115014, 1.825, -0.06, 0.041666666666667
115015, 1.825, -0.08, 0.020833333333333
115016, 1.8041666666667, -0.08, 0.041666666666667
115017, 1.825, -0.1, 0.041666666666667
115018, 1.825, -0.12, 0.020833333333333
115019, 1.8041666666667, -0.12, 0.041666666666667
115020, 1.825, -0.14, 0.041666666666667
115021, 1.825, -0.16, 0.020833333333333
115022, 1.8041666666667, -0.16, 0.041666666666667
115023, 1.825, -0.18, 0.041666666666667
115024, 1.8666666666667, -0.02, 0.041666666666667
115025, 1.8666666666667, -0.04, 0.020833333333333
115026, 1.8458333333333, -0.04, 0.041666666666667
115027, 1.8666666666667, -0.06, 0.041666666666667
115028, 1.8666666666667, -0.08, 0.020833333333333
115029, 1.8458333333333, -0.08, 0.041666666666667
115030, 1.8666666666667, -0.1, 0.041666666666667
115031, 1.8666666666667, -0.12, 0.020833333333333
115032, 1.8458333333333, -0.12, 0.041666666666667
115033, 1.8666666666667, -0.14, 0.041666666666667
115034, 1.8666666666667, -0.16, 0.020833333333333
115035, 1.8458333333333, -0.16, 0.041666666666667
115036, 1.8666666666667, -0.18, 0.041666666666667
115037, 1.9083333333333, -0.02, 0.041666666666667
115038, 1.9083333333333, -0.04, 0.020833333333333
115039, 1.8875, -0.04, 0.041666666666667
115040, 1.9083333333333, -0.06, 0.041666666666667
115041, 1.9083333333333, -0.08, 0.020833333333333
115042, 1.8875, -0.08, 0.041666666666667
115043, 1.9083333333333, -0.1, 0.041666666666667
115044, 1.9083333333333, -0.12, 0.020833333333333
115045, 1.8875, -0.12, 0.041666666666667
115046, 1.9083333333333, -0.14, 0.041666666666667
115047, 1.9083333333333, -0.16, 0.020833333333333
115048, 1.8875, -0.16, 0.041666666666667
115049, 1.9083333333333, -0.18, 0.041666666666667
115050, 1.95, -0.02, 0.041666666666667
115051, 1.95, -0.04, 0.020833333333333
115052, 1.9291666666667, -0.04, 0.041666666666667
115053, 1.95, -0.06, 0.041666666666667
115054, 1.95, -0.08, 0.020833333333333
115055, 1.9291666666667, -0.08, 0.041666666666667
115056, 1.95, -0.1, 0.041666666666667
115057, 1.95, -0.12, 0.020833333333333
115058, 1.9291666666667, -0.12, 0.041666666666667
115059, 1.95, -0.14, 0.041666666666667
115060, 1.95, -0.16, 0.020833333333333
115061, 1.9291666666667, -0.16, 0.041666666666667
115062, 1.95, -0.18, 0.041666666666667
115063, 1.9916666666667, -0.02, 0.041666666666667
115064, 1.9916666666667, -0.04, 0.020833333333333
115065, 1.9708333333333, -0.04, 0.041666666666667
115066, 1.9916666666667, -0.06, 0.041666666666667
115067, 1.9916666666667, -0.08, 0.020833333333333
115068, 1.9708333333333, -0.08, 0.041666666666667
115069, 1.9916666666667, -0.1, 0.041666666666667
115070, 1.9916666666667, -0.12, 0.020833333333333
115071, 1.9708333333333, -0.12, 0.041666666666667
115072, 1.9916666666667, -0.14, 0.041666666666667
115073, 1.9916666666667, -0.16, 0.020833333333333
115074, 1.9708333333333, -0.16, 0.041666666666667
115075, 1.9916666666667, -0.18, 0.041666666666667
115076, 2.0333333333333, -0.02, 0.041666666666667
115077, 2.0333333333333, -0.04, 0.020833333333333
115078, 2.0125, -0.04, 0.041666666666667
115079, 2.0333333333333, -0.06, 0.041666666666667
115080, 2.0333333333333, -0.08, 0.020833333333333
115081, 2.0125, -0.08, 0.041666666666667
115082, 2.0333333333333, -0.1, 0.041666666666667
115083, 2.0333333333333, -0.12, 0.020833333333333
115084, 2.0125, -0.12, 0.041666666666667
115085, 2.0333333333333, -0.14, 0.041666666666667
115086, 2.0333333333333, -0.16, 0.020833333333333
115087, 2.0125, -0.16, 0.041666666666667
115088, 2.0333333333333, -0.18, 0.041666666666667
115089, 2.075, -0.02, 0.041666666666667
115090, 2.075, -0.04, 0.020833333333333
115091, 2.0541666666667, -0.04, 0.041666666666667
115092, 2.075, -0.06, 0.041666666666667
115093, 2.075, -0.08, 0.020833333333333
115094, 2.0541666666667, -0.08, 0.041666666666667
115095, 2.075, -0.1, 0.041666666666667
115096, 2.075, -0.12, 0.020833333333333
115097, 2.0541666666667, -0.12, 0.041666666666667
115098, 2.075, -0.14, 0.041666666666667
115099, 2.075, -0.16, 0.020833333333333
115100, 2.0541666666667, -0.16, 0.041666666666667
115101, 2.075, -0.18, 0.041666666666667
115102, 2.1166666666667, -0.02, 0.041666666666667
115103, 2.1166666666667, -0.04, 0.020833333333333
115104, 2.0958333333333, -0.04, 0.041666666666667
115105, 2.1166666666667, -0.06, 0.041666666666667
115106, 2.1166666666667, -0.08, 0.020833333333333
115107, 2.0958333333333, -0.08, 0.041666666666667
115108, 2.1166666666667, -0.1, 0.041666666666667
115109, 2.1166666666667, -0.12, 0.020833333333333
115110, 2.0958333333333, -0.12, 0.041666666666667
115111, 2.1166666666667, -0.14, 0.041666666666667
115112, 2.1166666666667, -0.16, 0.020833333333333
115113, 2.0958333333333, -0.16, 0.041666666666667
115114, 2.1166666666667, -0.18, 0.041666666666667
115115, 2.1583333333333, -0.02, 0.041666666666667
115116, 2.1583333333333, -0.04, 0.020833333333333
115117, 2.1375, -0.04, 0.041666666666667
115118, 2.1583333333333, -0.06, 0.041666666666667
115119, 2.1583333333333, -0.08, 0.020833333333333
115120, 2.1375, -0.08, 0.041666666666667
115121, 2.1583333333333, -0.1, 0.041666666666667
115122, 2.1583333333333, -0.12, 0.020833333333333
115123, 2.1375, -0.12, 0.041666666666667
115124, 2.1583333333333, -0.14, 0.041666666666667
115125, 2.1583333333333, -0.16, 0.020833333333333
115126, 2.1375, -0.16, 0.041666666666667
115127, 2.1583333333333, -0.18, 0.041666666666667
115128, 2.1791666666667, -0.04, 0.041666666666667
115129, 2.1791666666667, -0.08, 0.041666666666667
115130, 2.1791666666667, -0.12, 0.041666666666667
115131, 2.1791666666667, -0.16, 0.041666666666667
115132, 1.2416666666667, -0.02, 0.083333333333333
115133, 1.2416666666667, -0.04, 0.0625
115134, 1.2208333333333, -0.04, 0.083333333333333
115135, 1.2416666666667, -0.06, 0.083333333333333
115136, 1.2416666666667, -0.08, 0.0625
115137, 1.2208333333333, -0.08, 0.083333333333333
115138, 1.2416666666667, -0.1, 0.083333333333333
115139, 1.2416666666667, -0.12, 0.0625
115140, 1.2208333333333, -0.12, 0.083333333333333
115141, 1.2416666666667, -0.14, 0.083333333333333
115142, 1.2416666666667, -0.16, 0.0625
115143, 1.2208333333333, -0.16, 0.083333333333333
115144, 1.2416666666667, -0.18, 0.083333333333333
115145, 1.2833333333333, -0.02, 0.083333333333333
115146, 1.2833333333333, -0.04, 0.0625
115147, 1.2625, -0.04, 0.083333333333333
115148, 1.2833333333333, -0.06, 0.083333333333333
115149, 1.2833333333333, -0.08, 0.0625
115150, 1.2625, -0.08, 0.083333333333333
115151, 1.2833333333333, -0.1, 0.083333333333333
115152, 1.2833333333333, -0.12, 0.0625
115153, 1.2625, -0.12, 0.083333333333333
115154, 1.2833333333333, -0.14, 0.083333333333333
115155, 1.2833333333333, -0.16, 0.0625
115156, 1.2625, -0.16, 0.083333333333333
115157, 1.2833333333333, -0.18, 0.083333333333333
115158, 1.325, -0.02, 0.083333333333333
115159, 1.325, -0.04, 0.0625
115160, 1.3041666666667, -0.04, 0.083333333333333
115161, 1.325, -0.06, 0.083333333333333
115162, 1.325, -0.08, 0.0625
115163, 1.3041666666667, -0.08, 0.083333333333333
115164, 1.325, -0.1, 0.083333333333333
115165, 1.325, -0.12, 0.0625
115166, 1.3041666666667, -0.12, 0.083333333333333
115167, 1.325, -0.14, 0.083333333333333
115168, 1.325, -0.16, 0.0625
115169, 1.3041666666667, -0.16, 0.083333333333333
115170, 1.325, -0.18, 0.083333333333333
115171, 1.3666666666667, -0.02, 0.083333333333333
115172, 1.3666666666667, -0.04, 0.0625
115173, 1.3458333333333, -0.04, 0.083333333333333
115174, 1.3666666666667, -0.06, 0.083333333333333
115175, 1.3666666666667, -0.08, 0.0625
115176, 1.3458333333333, -0.08, 0.083333333333333
115177, 1.3666666666667, -0.1, 0.083333333333333
115178, 1.3666666666667, -0.12, 0.0625
115179, 1.3458333333333, -0.12, 0.083333333333333
115180, 1.3666666666667, -0.14, 0.083333333333333
115181, 1.3666666666667, -0.16, 0.0625
115182, 1.3458333333333, -0.16, 0.083333333333333
115183, 1.3666666666667, -0.18, 0.083333333333333
115184, 1.4083333333333, -0.02, 0.083333333333333
115185, 1.4083333333333, -0.04, 0.0625
115186, 1.3875, -0.04, 0.083333333333333
115187, 1.4083333333333, -0.06, 0.083333333333333
115188, 1.4083333333333, -0.08, 0.0625
115189, 1.3875, -0.08, 0.083333333333333
115190, 1.4083333333333, -0.1, 0.083333333333333
115191, 1.4083333333333, -0.12, 0.0625
115192, 1.3875, -0.12, 0.083333333333333
115193, 1.4083333333333, -0.14, 0.083333333333333
115194, 1.4083333333333, -0.16, 0.0625
115195, 1.3875, -0.16, 0.083333333333333
115196, 1.4083333333333, -0.18, 0.083333333333333
115197, 1.45, -0.02, 0.083333333333333
115198, 1.45, -0.04, 0.0625
115199, 1.4291666666667, -0.04, 0.083333333333333
115200, 1.45, -0.06, 0.083333333333333
115201, 1.45, -0.08, 0.0625
115202, 1.4291666666667, -0.08, 0.083333333333333
115203, 1.45, -0.1, 0.083333333333333
115204, 1.45, -0.12, 0.0625
115205, 1.4291666666667, -0.12, 0.083333333333333
115206, 1.45, -0.14, 0.083333333333333
115207, 1.45, -0.16, 0.0625
115208, 1.4291666666667, -0.16, 0.083333333333333
115209, 1.45, -0.18, 0.083333333333333
115210, 1.4916666666667, -0.02, 0.083333333333333
115211, 1.4916666666667, -0.04, 0.0625
115212, 1.4708333333333, -0.04, 0.083333333333333
115213, 1.4916666666667, -0.06, 0.083333333333333
115214, 1.4916666666667, -0.08, 0.0625
115215, 1.4708333333333, -0.08, 0.083333333333333
115216, 1.4916666666667, -0.1, 0.083333333333333
115217, 1.4916666666667, -0.12, 0.0625
115218, 1.4708333333333, -0.12, 0.083333333333333
115219, 1.4916666666667, -0.14, 0.083333333333333
115220, 1.4916666666667, -0.16, 0.0625
115221, 1.4708333333333, -0.16, 0.083333333333333
115222, 1.4916666666667, -0.18, 0.083333333333333
115223, 1.5333333333333, -0.02, 0.083333333333333
115224, 1.5333333333333, -0.04, 0.0625
115225, 1.5125, -0.04, 0.083333333333333
115226, 1.5333333333333, -0.06, 0.083333333333333
115227, 1.5333333333333, -0.08, 0.0625
115228, 1.5125, -0.08, 0.083333333333333
115229, 1.5333333333333, -0.1, 0.083333333333333
115230, 1.5333333333333, -0.12, 0.0625
115231, 1.5125, -0.12, 0.083333333333333
115232, 1.5333333333333, -0.14, 0.083333333333333
115233, 1.5333333333333, -0.16, 0.0625
115234, 1.5125, -0.16, 0.083333333333333
115235, 1.5333333333333, -0.18, 0.083333333333333
115236, 1.575, -0.02, 0.083333333333333
115237, 1.575, -0.04, 0.0625
115238, 1.5541666666667, -0.04, 0.083333333333333
115239, 1.575, -0.06, 0.083333333333333
115240, 1.575, -0.08, 0.0625
115241, 1.5541666666667, -0.08, 0.083333333333333
115242, 1.575, -0.1, 0.083333333333333
115243, 1.575, -0.12, 0.0625
115244, 1.5541666666667, -0.12, 0.083333333333333
115245, 1.575, -0.14, 0.083333333333333
115246, 1.575, -0.16, 0.0625
115247, 1.5541666666667, -0.16, 0.083333333333333
115248, 1.575, -0.18, 0.083333333333333
115249, 1.6166666666667, -0.02, 0.083333333333333
115250, 1.6166666666667, -0.04, 0.0625
115251, 1.5958333333333, -0.04, 0.083333333333333
115252, 1.6166666666667, -0.06, 0.083333333333333
115253, 1.6166666666667, -0.08, 0.0625
115254, 1.5958333333333, -0.08, 0.083333333333333
115255, 1.6166666666667, -0.1, 0.083333333333333
115256, 1.6166666666667, -0.12, 0.0625
115257, 1.5958333333333, -0.12, 0.083333333333333
115258, 1.6166666666667, -0.14, 0.083333333333333
115259, 1.6166666666667, -0.16, 0.0625
115260, 1.5958333333333, -0.16, 0.083333333333333
115261, 1.6166666666667, -0.18, 0.083333333333333
115262, 1.6583333333333, -0.02, 0.083333333333333
115263, 1.6583333333333, -0.04, 0.0625
115264, 1.6375, -0.04, 0.083333333333333
115265, 1.6583333333333, -0.06, 0.083333333333333
115266, 1.6583333333333, -0.08, 0.0625
115267, 1.6375, -0.08, 0.083333333333333
115268, 1.6583333333333, -0.1, 0.083333333333333
115269, 1.6583333333333, -0.12, 0.0625
115270, 1.6375, -0.12, 0.083333333333333
115271, 1.6583333333333, -0.14, 0.083333333333333
115272, 1.6583333333333, -0.16, 0.0625
115273, 1.6375, -0.16, 0.083333333333333
115274, 1.6583333333333, -0.18, 0.083333333333333
115275, 1.7, -0.02, 0.083333333333333
115276, 1.7, -0.04, 0.0625
115277, 1.6791666666667, -0.04, 0.083333333333333
115278, 1.7, -0.06, 0.083333333333333
115279, 1.7, -0.08, 0.0625
115280, 1.6791666666667, -0.08, 0.083333333333333
115281, 1.7, -0.1, 0.083333333333333
115282, 1.7, -0.12, 0.0625
115283, 1.6791666666667, -0.12, 0.083333333333333
115284, 1.7, -0.14, 0.083333333333333
115285, 1.7, -0.16, 0.0625
115286, 1.6791666666667, -0.16, 0.083333333333333
115287, 1.7, -0.18, 0.083333333333333
115288, 1.7416666666667, -0.02, 0.083333333333333
115289, 1.7416666666667, -0.04, 0.0625
115290, 1.7208333333333, -0.04, 0.083333333333333
115291, 1.7416666666667, -0.06, 0.083333333333333
115292, 1.7416666666667, -0.08, 0.0625
115293, 1.7208333333333, -0.08, 0.083333333333333
115294, 1.7416666666667, -0.1, 0.083333333333333
115295, 1.7416666666667, -0.12, 0.0625
115296, 1.7208333333333, -0.12, 0.083333333333333
115297, 1.7416666666667, -0.14, 0.083333333333333
115298, 1.7416666666667, -0.16, 0.0625
115299, 1.7208333333333, -0.16, 0.083333333333333
115300, 1.7416666666667, -0.18, 0.083333333333333
115301, 1.7833333333333, -0.02, 0.083333333333333
115302, 1.7833333333333, -0.04, 0.0625
115303, 1.7625, -0.04, 0.083333333333333
115304, 1.7833333333333, -0.06, 0.083333333333333
115305, 1.7833333333333, -0.08, 0.0625
115306, 1.7625, -0.08, 0.083333333333333
115307, 1.7833333333333, -0.1, 0.083333333333333
115308, 1.7833333333333, -0.12, 0.0625
115309, 1.7625, -0.12, 0.083333333333333
115310, 1.7833333333333, -0.14, 0.083333333333333
115311, 1.7833333333333, -0.16, 0.0625
115312, 1.7625, -0.16, 0.083333333333333
115313, 1.7833333333333, -0.18, 0.083333333333333
115314, 1.825, -0.02, 0.083333333333333
115315, 1.825, -0.04, 0.0625
115316, 1.8041666666667, -0.04, 0.083333333333333
115317, 1.825, -0.06, 0.083333333333333
115318, 1.825, -0.08, 0.0625
115319, 1.8041666666667, -0.08, 0.083333333333333
115320, 1.825, -0.1, 0.083333333333333
115321, 1.825, -0.12, 0.0625
115322, 1.8041666666667, -0.12, 0.083333333333333
115323, 1.825, -0.14, 0.083333333333333
115324, 1.825, -0.16, 0.0625
115325, 1.8041666666667, -0.16, 0.083333333333333
115326, 1.825, -0.18, 0.083333333333333
115327, 1.8666666666667, -0.02, 0.083333333333333
115328, 1.8666666666667, -0.04, 0.0625
115329, 1.8458333333333, -0.04, 0.083333333333333
115330, 1.8666666666667, -0.06, 0.083333333333333
115331, 1.8666666666667, -0.08, 0.0625
115332, 1.8458333333333, -0.08, 0.083333333333333
115333, 1.8666666666667, -0.1, 0.083333333333333
115334, 1.8666666666667, -0.12, 0.0625
115335, 1.8458333333333, -0.12, 0.083333333333333
115336, 1.8666666666667, -0.14, 0.083333333333333
115337, 1.8666666666667, -0.16, 0.0625
115338, 1.8458333333333, -0.16, 0.083333333333333
115339, 1.8666666666667, -0.18, 0.083333333333333
115340, 1.9083333333333, -0.02, 0.083333333333333
115341, 1.9083333333333, -0.04, 0.0625
115342, 1.8875, -0.04, 0.083333333333333
115343, 1.9083333333333, -0.06, 0.083333333333333
115344, 1.9083333333333, -0.08, 0.0625
115345, 1.8875, -0.08, 0.083333333333333
115346, 1.9083333333333, -0.1, 0.083333333333333
115347, 1.9083333333333, -0.12, 0.0625
115348, 1.8875, -0.12, 0.083333333333333
115349, 1.9083333333333, -0.14, 0.083333333333333
115350, 1.9083333333333, -0.16, 0.0625
115351, 1.8875, -0.16, 0.083333333333333
115352, 1.9083333333333, -0.18, 0.083333333333333
115353, 1.95, -0.02, 0.083333333333333
115354, 1.95, -0.04, 0.0625
115355, 1.9291666666667, -0.04, 0.083333333333333
115356, 1.95, -0.06, 0.083333333333333
115357, 1.95, -0.08, 0.0625
115358, 1.9291666666667, -0.08, 0.083333333333333
115359, 1.95, -0.1, 0.083333333333333
115360, 1.95, -0.12, 0.0625
115361, 1.9291666666667, -0.12, 0.083333333333333
115362, 1.95, -0.14, 0.083333333333333
115363, 1.95, -0.16, 0.0625
115364, 1.9291666666667, -0.16, 0.083333333333333
115365, 1.95, -0.18, 0.083333333333333
115366, 1.9916666666667, -0.02, 0.083333333333333
115367, 1.9916666666667, -0.04, 0.0625
115368, 1.9708333333333, -0.04, 0.083333333333333
115369, 1.9916666666667, -0.06, 0.083333333333333
115370, 1.9916666666667, -0.08, 0.0625
115371, 1.9708333333333, -0.08, 0.083333333333333
115372, 1.9916666666667, -0.1, 0.083333333333333
115373, 1.9916666666667, -0.12, 0.0625
115374, 1.9708333333333, -0.12, 0.083333333333333
115375, 1.9916666666667, -0.14, 0.083333333333333
115376, 1.9916666666667, -0.16, 0.0625
115377, 1.9708333333333, -0.16, 0.083333333333333
115378, 1.9916666666667, -0.18, 0.083333333333333
115379, 2.0333333333333, -0.02, 0.083333333333333
115380, 2.0333333333333, -0.04, 0.0625
115381, 2.0125, -0.04, 0.083333333333333
115382, 2.0333333333333, -0.06, 0.083333333333333
115383, 2.0333333333333, -0.08, 0.0625
115384, 2.0125, -0.08, 0.083333333333333
115385, 2.0333333333333, -0.1, 0.083333333333333
115386, 2.0333333333333, -0.12, 0.0625
115387, 2.0125, -0.12, 0.083333333333333
115388, 2.0333333333333, -0.14, 0.083333333333333
115389, 2.0333333333333, -0.16, 0.0625
115390, 2.0125, -0.16, 0.083333333333333
115391, 2.0333333333333, -0.18, 0.083333333333333
115392, 2.075, -0.02, 0.083333333333333
115393, 2.075, -0.04, 0.0625
115394, 2.0541666666667, -0.04, 0.083333333333333
115395, 2.075, -0.06, 0.083333333333333
115396, 2.075, -0.08, 0.0625
115397, 2.0541666666667, -0.08, 0.083333333333333
115398, 2.075, -0.1, 0.083333333333333
115399, 2.075, -0.12, 0.0625
115400, 2.0541666666667, -0.12, 0.083333333333333
115401, 2.075, -0.14, 0.083333333333333
115402, 2.075, -0.16, 0.0625
115403, 2.0541666666667, -0.16, 0.083333333333333
115404, 2.075, -0.18, 0.083333333333333
115405, 2.1166666666667, -0.02, 0.083333333333333
115406, 2.1166666666667, -0.04, 0.0625
115407, 2.0958333333333, -0.04, 0.083333333333333
115408, 2.1166666666667, -0.06, 0.083333333333333
115409, 2.1166666666667, -0.08, 0.0625
115410, 2.0958333333333, -0.08, 0.083333333333333
115411, 2.1166666666667, -0.1, 0.083333333333333
115412, 2.1166666666667, -0.12, 0.0625
115413, 2.0958333333333, -0.12, 0.083333333333333
115414, 2.1166666666667, -0.14, 0.083333333333333
115415, 2.1166666666667, -0.16, 0.0625
115416, 2.0958333333333, -0.16, 0.083333333333333
115417, 2.1166666666667, -0.18, 0.083333333333333
115418, 2.1583333333333, -0.02, 0.083333333333333
115419, 2.1583333333333, -0.04, 0.0625
115420, 2.1375, -0.04, 0.083333333333333
115421, 2.1583333333333, -0.06, 0.083333333333333
115422, 2.1583333333333, -0.08, 0.0625
115423, 2.1375, -0.08, 0.083333333333333
115424, 2.1583333333333, -0.1, 0.083333333333333
115425, 2.1583333333333, -0.12, 0.0625
115426, 2.1375, -0.12, 0.083333333333333
115427, 2.1583333333333, -0.14, 0.083333333333333
115428, 2.1583333333333, -0.16, 0.0625
115429, 2.1375, -0.16, 0.083333333333333
115430, 2.1583333333333, -0.18, 0.083333333333333
115431, 2.1791666666667, -0.04, 0.083333333333333
115432, 2.1791666666667, -0.08, 0.083333333333333
115433, 2.1791666666667, -0.12, 0.083333333333333
115434, 2.1791666666667, -0.16, 0.083333333333333
115435, 1.2416666666667, -0.02, 0.125
115436, 1.2416666666667, -0.04, 0.10416666666667
115437, 1.2208333333333, -0.04, 0.125
115438, 1.2416666666667, -0.06, 0.125
115439, 1.2416666666667, -0.08, 0.10416666666667
115440, 1.2208333333333, -0.08, 0.125
115441, 1.2416666666667, -0.1, 0.125
115442, 1.2416666666667, -0.12, 0.10416666666667
115443, 1.2208333333333, -0.12, 0.125
115444, 1.2416666666667, -0.14, 0.125
115445, 1.2416666666667, -0.16, 0.10416666666667
115446, 1.2208333333333, -0.16, 0.125
115447, 1.2416666666667, -0.18, 0.125
115448, 1.2833333333333, -0.02, 0.125
115449, 1.2833333333333, -0.04, 0.10416666666667
115450, 1.2625, -0.04, 0.125
115451, 1.2833333333333, -0.06, 0.125
115452, 1.2833333333333, -0.08, 0.10416666666667
115453, 1.2625, -0.08, 0.125
115454, 1.2833333333333, -0.1, 0.125
115455, 1.2833333333333, -0.12, 0.10416666666667
115456, 1.2625, -0.12, 0.125
115457, 1.2833333333333, -0.14, 0.125
115458, 1.2833333333333, -0.16, 0.10416666666667
115459, 1.2625, -0.16, 0.125
115460, 1.2833333333333, -0.18, 0.125
115461, 1.325, -0.02, 0.125
115462, 1.325, -0.04, 0.10416666666667
115463, 1.3041666666667, -0.04, 0.125
115464, 1.325, -0.06, 0.125
115465, 1.325, -0.08, 0.10416666666667
115466, 1.3041666666667, -0.08, 0.125
115467, 1.325, -0.1, 0.125
115468, 1.325, -0.12, 0.10416666666667
115469, 1.3041666666667, -0.12, 0.125
115470, 1.325, -0.14, 0.125
115471, 1.325, -0.16, 0.10416666666667
115472, 1.3041666666667, -0.16, 0.125
115473, 1.325, -0.18, 0.125
115474, 1.3666666666667, -0.02, 0.125
115475, 1.3666666666667, -0.04, 0.10416666666667
115476, 1.3458333333333, -0.04, 0.125
115477, 1.3666666666667, -0.06, 0.125
115478, 1.3666666666667, -0.08, 0.10416666666667
115479, 1.3458333333333, -0.08, 0.125
115480, 1.3666666666667, -0.1, 0.125
115481, 1.3666666666667, -0.12, 0.10416666666667
115482, 1.3458333333333, -0.12, 0.125
115483, 1.3666666666667, -0.14, 0.125
115484, 1.3666666666667, -0.16, 0.10416666666667
115485, 1.3458333333333, -0.16, 0.125
115486, 1.3666666666667, -0.18, 0.125
115487, 1.4083333333333, -0.02, 0.125
115488, 1.4083333333333, -0.04, 0.10416666666667
115489, 1.3875, -0.04, 0.125
115490, 1.4083333333333, -0.06, 0.125
115491, 1.4083333333333, -0.08, 0.10416666666667
115492, 1.3875, -0.08, 0.125
115493, 1.4083333333333, -0.1, 0.125
115494, 1.4083333333333, -0.12, 0.10416666666667
115495, 1.3875, -0.12, 0.125
115496, 1.4083333333333, -0.14, 0.125
115497, 1.4083333333333, -0.16, 0.10416666666667
115498, 1.3875, -0.16, 0.125
115499, 1.4083333333333, -0.18, 0.125
115500, 1.45, -0.02, 0.125
115501, 1.45, -0.04, 0.10416666666667
115502, 1.4291666666667, -0.04, 0.125
115503, 1.45, -0.06, 0.125
115504, 1.45, -0.08, 0.10416666666667
115505, 1.4291666666667, -0.08, 0.125
115506, 1.45, -0.1, 0.125
115507, 1.45, -0.12, 0.10416666666667
115508, 1.4291666666667, -0.12, 0.125
115509, 1.45, -0.14, 0.125
115510, 1.45, -0.16, 0.10416666666667
115511, 1.4291666666667, -0.16, 0.125
115512, 1.45, -0.18, 0.125
115513, 1.4916666666667, -0.02, 0.125
115514, 1.4916666666667, -0.04, 0.10416666666667
115515, 1.4708333333333, -0.04, 0.125
115516, 1.4916666666667, -0.06, 0.125
115517, 1.4916666666667, -0.08, 0.10416666666667
115518, 1.4708333333333, -0.08, 0.125
115519, 1.4916666666667, -0.1, 0.125
115520, 1.4916666666667, -0.12, 0.10416666666667
115521, 1.4708333333333, -0.12, 0.125
115522, 1.4916666666667, -0.14, 0.125
115523, 1.4916666666667, -0.16, 0.10416666666667
115524, 1.4708333333333, -0.16, 0.125
115525, 1.4916666666667, -0.18, 0.125
115526, 1.5333333333333, -0.02, 0.125
115527, 1.5333333333333, -0.04, 0.10416666666667
115528, 1.5125, -0.04, 0.125
115529, 1.5333333333333, -0.06, 0.125
115530, 1.5333333333333, -0.08, 0.10416666666667
115531, 1.5125, -0.08, 0.125
115532, 1.5333333333333, -0.1, 0.125
115533, 1.5333333333333, -0.12, 0.10416666666667
115534, 1.5125, -0.12, 0.125
115535, 1.5333333333333, -0.14, 0.125
115536, 1.5333333333333, -0.16, 0.10416666666667
115537, 1.5125, -0.16, 0.125
115538, 1.5333333333333, -0.18, 0.125
115539, 1.575, -0.02, 0.125
115540, 1.575, -0.04, 0.10416666666667
115541, 1.5541666666667, -0.04, 0.125
115542, 1.575, -0.06, 0.125
115543, 1.575, -0.08, 0.10416666666667
115544, 1.5541666666667, -0.08, 0.125
115545, 1.575, -0.1, 0.125
115546, 1.575, -0.12, 0.10416666666667
115547, 1.5541666666667, -0.12, 0.125
115548, 1.575, -0.14, 0.125
115549, 1.575, -0.16, 0.10416666666667
115550, 1.5541666666667, -0.16, 0.125
115551, 1.575, -0.18, 0.125
115552, 1.6166666666667, -0.02, 0.125
115553, 1.6166666666667, -0.04, 0.10416666666667
115554, 1.5958333333333, -0.04, 0.125
115555, 1.6166666666667, -0.06, 0.125
115556, 1.6166666666667, -0.08, 0.10416666666667
115557, 1.5958333333333, -0.08, 0.125
115558, 1.6166666666667, -0.1, 0.125
115559, 1.6166666666667, -0.12, 0.10416666666667
115560, 1.5958333333333, -0.12, 0.125
115561, 1.6166666666667, -0.14, 0.125
115562, 1.6166666666667, -0.16, 0.10416666666667
115563, 1.5958333333333, -0.16, 0.125
115564, 1.6166666666667, -0.18, 0.125
115565, 1.6583333333333, -0.02, 0.125
115566, 1.6583333333333, -0.04, 0.10416666666667
115567, 1.6375, -0.04, 0.125
115568, 1.6583333333333, -0.06, 0.125
115569, 1.6583333333333, -0.08, 0.10416666666667
115570, 1.6375, -0.08, 0.125
115571, 1.6583333333333, -0.1, 0.125
115572, 1.6583333333333, -0.12, 0.10416666666667
115573, 1.6375, -0.12, 0.125
115574, 1.6583333333333, -0.14, 0.125
115575, 1.6583333333333, -0.16, 0.10416666666667
115576, 1.6375, -0.16, 0.125
115577, 1.6583333333333, -0.18, 0.125
115578, 1.7, -0.02, 0.125
115579, 1.7, -0.04, 0.10416666666667
115580, 1.6791666666667, -0.04, 0.125
115581, 1.7, -0.06, 0.125
115582, 1.7, -0.08, 0.10416666666667
115583, 1.6791666666667, -0.08, 0.125
115584, 1.7, -0.1, 0.125
115585, 1.7, -0.12, 0.10416666666667
115586, 1.6791666666667, -0.12, 0.125
115587, 1.7, -0.14, 0.125
115588, 1.7, -0.16, 0.10416666666667
115589, 1.6791666666667, -0.16, 0.125
115590, 1.7, -0.18, 0.125
115591, 1.7416666666667, -0.02, 0.125
115592, 1.7416666666667, -0.04, 0.10416666666667
115593, 1.7208333333333, -0.04, 0.125
115594, 1.7416666666667, -0.06, 0.125
115595, 1.7416666666667, -0.08, 0.10416666666667
115596, 1.7208333333333, -0.08, 0.125
115597, 1.7416666666667, -0.1, 0.125
115598, 1.7416666666667, -0.12, 0.10416666666667
115599, 1.7208333333333, -0.12, 0.125
115600, 1.7416666666667, -0.14, 0.125
115601, 1.7416666666667, -0.16, 0.10416666666667
115602, 1.7208333333333, -0.16, 0.125
115603, 1.7416666666667, -0.18, 0.125
115604, 1.7833333333333, -0.02, 0.125
115605, 1.7833333333333, -0.04, 0.10416666666667
115606, 1.7625, -0.04, 0.125
115607, 1.7833333333333, -0.06, 0.125
115608, 1.7833333333333, -0.08, 0.10416666666667
115609, 1.7625, -0.08, 0.125
115610, 1.7833333333333, -0.1, 0.125
115611, 1.7833333333333, -0.12, 0.10416666666667
115612, 1.7625, -0.12, 0.125
115613, 1.7833333333333, -0.14, 0.125
115614, 1.7833333333333, -0.16, 0.10416666666667
115615, 1.7625, -0.16, 0.125
115616, 1.7833333333333, -0.18, 0.125
115617, 1.825, -0.02, 0.125
115618, 1.825, -0.04, 0.10416666666667
115619, 1.8041666666667, -0.04, 0.125
115620, 1.825, -0.06, 0.125
115621, 1.825, -0.08, 0.10416666666667
115622, 1.8041666666667, -0.08, 0.125
115623, 1.825, -0.1, 0.125
115624, 1.825, -0.12, 0.10416666666667
115625, 1.8041666666667, -0.12, 0.125
115626, 1.825, -0.14, 0.125
115627, 1.825, -0.16, 0.10416666666667
115628, 1.8041666666667, -0.16, 0.125
115629, 1.825, -0.18, 0.125
115630, 1.8666666666667, -0.02, 0.125
115631, 1.8666666666667, -0.04, 0.10416666666667
115632, 1.8458333333333, -0.04, 0.125
115633, 1.8666666666667, -0.06, 0.125
115634, 1.8666666666667, -0.08, 0.10416666666667
115635, 1.8458333333333, -0.08, 0.125
115636, 1.8666666666667, -0.1, 0.125
115637, 1.8666666666667, -0.12, 0.10416666666667
115638, 1.8458333333333, -0.12, 0.125
115639, 1.8666666666667, -0.14, 0.125
115640, 1.8666666666667, -0.16, 0.10416666666667
115641, 1.8458333333333, -0.16, 0.125
115642, 1.8666666666667, -0.18, 0.125
115643, 1.9083333333333, -0.02, 0.125
115644, 1.9083333333333, -0.04, 0.10416666666667
115645, 1.8875, -0.04, 0.125
115646, 1.9083333333333, -0.06, 0.125
115647, 1.9083333333333, -0.08, 0.10416666666667
115648, 1.8875, -0.08, 0.125
115649, 1.9083333333333, -0.1, 0.125
115650, 1.9083333333333, -0.12, 0.10416666666667
115651, 1.8875, -0.12, 0.125
115652, 1.9083333333333, -0.14, 0.125
115653, 1.9083333333333, -0.16, 0.10416666666667
115654, 1.8875, -0.16, 0.125
115655, 1.9083333333333, -0.18, 0.125
115656, 1.95, -0.02, 0.125
115657, 1.95, -0.04, 0.10416666666667
115658, 1.9291666666667, -0.04, 0.125
115659, 1.95, -0.06, 0.125
115660, 1.95, -0.08, 0.10416666666667
115661, 1.9291666666667, -0.08, 0.125
115662, 1.95, -0.1, 0.125
115663, 1.95, -0.12, 0.10416666666667
115664, 1.9291666666667, -0.12, 0.125
115665, 1.95, -0.14, 0.125
115666, 1.95, -0.16, 0.10416666666667
115667, 1.9291666666667, -0.16, 0.125
115668, 1.95, -0.18, 0.125
115669, 1.9916666666667, -0.02, 0.125
115670, 1.9916666666667, -0.04, 0.10416666666667
115671, 1.9708333333333, -0.04, 0.125
115672, 1.9916666666667, -0.06, 0.125
115673, 1.9916666666667, -0.08, 0.10416666666667
115674, 1.9708333333333, -0.08, 0.125
115675, 1.9916666666667, -0.1, 0.125
115676, 1.9916666666667, -0.12, 0.10416666666667
115677, 1.9708333333333, -0.12, 0.125
115678, 1.9916666666667, -0.14, 0.125
115679, 1.9916666666667, -0.16, 0.10416666666667
115680, 1.9708333333333, -0.16, 0.125
115681, 1.9916666666667, -0.18, 0.125
115682, 2.0333333333333, -0.02, 0.125
115683, 2.0333333333333, -0.04, 0.10416666666667
115684, 2.0125, -0.04, 0.125
115685, 2.0333333333333, -0.06, 0.125
115686, 2.0333333333333, -0.08, 0.10416666666667
115687, 2.0125, -0.08, 0.125
115688, 2.0333333333333, -0.1, 0.125
115689, 2.0333333333333, -0.12, 0.10416666666667
115690, 2.0125, -0.12, 0.125
115691, 2.0333333333333, -0.14, 0.125
115692, 2.0333333333333, -0.16, 0.10416666666667
115693, 2.0125, -0.16, 0.125
115694, 2.0333333333333, -0.18, 0.125
115695, 2.075, -0.02, 0.125
115696, 2.075, -0.04, 0.10416666666667
115697, 2.0541666666667, -0.04, 0.125
115698, 2.075, -0.06, 0.125
115699, 2.075, -0.08, 0.10416666666667
115700, 2.0541666666667, -0.08, 0.125
115701, 2.075, -0.1, 0.125
115702, 2.075, -0.12, 0.10416666666667
115703, 2.0541666666667, -0.12, 0.125
115704, 2.075, -0.14, 0.125
115705, 2.075, -0.16, 0.10416666666667
115706, 2.0541666666667, -0.16, 0.125
115707, 2.075, -0.18, 0.125
115708, 2.1166666666667, -0.02, 0.125
115709, 2.1166666666667, -0.04, 0.10416666666667
115710, 2.0958333333333, -0.04, 0.125
115711, 2.1166666666667, -0.06, 0.125
115712, 2.1166666666667, -0.08, 0.10416666666667
115713, 2.0958333333333, -0.08, 0.125
115714, 2.1166666666667, -0.1, 0.125
115715, 2.1166666666667, -0.12, 0.10416666666667
115716, 2.0958333333333, -0.12, 0.125
115717, 2.1166666666667, -0.14, 0.125
115718, 2.1166666666667, -0.16, 0.10416666666667
115719, 2.0958333333333, -0.16, 0.125
115720, 2.1166666666667, -0.18, 0.125
115721, 2.1583333333333, -0.02, 0.125
115722, 2.1583333333333, -0.04, 0.10416666666667
115723, 2.1375, -0.04, 0.125
115724, 2.1583333333333, -0.06, 0.125
115725, 2.1583333333333, -0.08, 0.10416666666667
115726, 2.1375, -0.08, 0.125
115727, 2.1583333333333, -0.1, 0.125
115728, 2.1583333333333, -0.12, 0.10416666666667
115729, 2.1375, -0.12, 0.125
115730, 2.1583333333333, -0.14, 0.125
115731, 2.1583333333333, -0.16, 0.10416666666667
115732, 2.1375, -0.16, 0.125
115733, 2.1583333333333, -0.18, 0.125
115734, 2.1791666666667, -0.04, 0.125
115735, 2.1791666666667, -0.08, 0.125
115736, 2.1791666666667, -0.12, 0.125
115737, 2.1791666666667, -0.16, 0.125
115738, 1.2416666666667, -0.02, 0.16666666666667
115739, 1.2416666666667, -0.04, 0.14583333333333
115740, 1.2208333333333, -0.04, 0.16666666666667
115741, 1.2416666666667, -0.06, 0.16666666666667
115742, 1.2416666666667, -0.08, 0.14583333333333
115743, 1.2208333333333, -0.08, 0.16666666666667
115744, 1.2416666666667, -0.1, 0.16666666666667
115745, 1.2416666666667, -0.12, 0.14583333333333
115746, 1.2208333333333, -0.12, 0.16666666666667
115747, 1.2416666666667, -0.14, 0.16666666666667
115748, 1.2416666666667, -0.16, 0.14583333333333
115749, 1.2208333333333, -0.16, 0.16666666666667
115750, 1.2416666666667, -0.18, 0.16666666666667
115751, 1.2833333333333, -0.02, 0.16666666666667
115752, 1.2833333333333, -0.04, 0.14583333333333
115753, 1.2625, -0.04, 0.16666666666667
115754, 1.2833333333333, -0.06, 0.16666666666667
115755, 1.2833333333333, -0.08, 0.14583333333333
115756, 1.2625, -0.08, 0.16666666666667
115757, 1.2833333333333, -0.1, 0.16666666666667
115758, 1.2833333333333, -0.12, 0.14583333333333
115759, 1.2625, -0.12, 0.16666666666667
115760, 1.2833333333333, -0.14, 0.16666666666667
115761, 1.2833333333333, -0.16, 0.14583333333333
115762, 1.2625, -0.16, 0.16666666666667
115763, 1.2833333333333, -0.18, 0.16666666666667
115764, 1.325, -0.02, 0.16666666666667
115765, 1.325, -0.04, 0.14583333333333
115766, 1.3041666666667, -0.04, 0.16666666666667
115767, 1.325, -0.06, 0.16666666666667
115768, 1.325, -0.08, 0.14583333333333
115769, 1.3041666666667, -0.08, 0.16666666666667
115770, 1.325, -0.1, 0.16666666666667
115771, 1.325, -0.12, 0.14583333333333
115772, 1.3041666666667, -0.12, 0.16666666666667
115773, 1.325, -0.14, 0.16666666666667
115774, 1.325, -0.16, 0.14583333333333
115775, 1.3041666666667, -0.16, 0.16666666666667
115776, 1.325, -0.18, 0.16666666666667
115777, 1.3666666666667, -0.02, 0.16666666666667
115778, 1.3666666666667, -0.04, 0.14583333333333
115779, 1.3458333333333, -0.04, 0.16666666666667
115780, 1.3666666666667, -0.06, 0.16666666666667
115781, 1.3666666666667, -0.08, 0.14583333333333
115782, 1.3458333333333, -0.08, 0.16666666666667
115783, 1.3666666666667, -0.1, 0.16666666666667
115784, 1.3666666666667, -0.12, 0.14583333333333
115785, 1.3458333333333, -0.12, 0.16666666666667
115786, 1.3666666666667, -0.14, 0.16666666666667
115787, 1.3666666666667, -0.16, 0.14583333333333
115788, 1.3458333333333, -0.16, 0.16666666666667
115789, 1.3666666666667, -0.18, 0.16666666666667
115790, 1.4083333333333, -0.02, 0.16666666666667
115791, 1.4083333333333, -0.04, 0.14583333333333
115792, 1.3875, -0.04, 0.16666666666667
115793, 1.4083333333333, -0.06, 0.16666666666667
115794, 1.4083333333333, -0.08, 0.14583333333333
115795, 1.3875, -0.08, 0.16666666666667
115796, 1.4083333333333, -0.1, 0.16666666666667
115797, 1.4083333333333, -0.12, 0.14583333333333
115798, 1.3875, -0.12, 0.16666666666667
115799, 1.4083333333333, -0.14, 0.16666666666667
115800, 1.4083333333333, -0.16, 0.14583333333333
115801, 1.3875, -0.16, 0.16666666666667
115802, 1.4083333333333, -0.18, 0.16666666666667
115803, 1.45, -0.02, 0.16666666666667
115804, 1.45, -0.04, 0.14583333333333
115805, 1.4291666666667, -0.04, 0.16666666666667
115806, 1.45, -0.06, 0.16666666666667
115807, 1.45, -0.08, 0.14583333333333
115808, 1.4291666666667, -0.08, 0.16666666666667
115809, 1.45, -0.1, 0.16666666666667
115810, 1.45, -0.12, 0.14583333333333
115811, 1.4291666666667, -0.12, 0.16666666666667
115812, 1.45, -0.14, 0.16666666666667
115813, 1.45, -0.16, 0.14583333333333
115814, 1.4291666666667, -0.16, 0.16666666666667
115815, 1.45, -0.18, 0.16666666666667
115816, 1.4916666666667, -0.02, 0.16666666666667
115817, 1.4916666666667, -0.04, 0.14583333333333
115818, 1.4708333333333, -0.04, 0.16666666666667
115819, 1.4916666666667, -0.06, 0.16666666666667
115820, 1.4916666666667, -0.08, 0.14583333333333
115821, 1.4708333333333, -0.08, 0.16666666666667
115822, 1.4916666666667, -0.1, 0.16666666666667
115823, 1.4916666666667, -0.12, 0.14583333333333
115824, 1.4708333333333, -0.12, 0.16666666666667
115825, 1.4916666666667, -0.14, 0.16666666666667
115826, 1.4916666666667, -0.16, 0.14583333333333
115827, 1.4708333333333, -0.16, 0.16666666666667
115828, 1.4916666666667, -0.18, 0.16666666666667
115829, 1.5333333333333, -0.02, 0.16666666666667
115830, 1.5333333333333, -0.04, 0.14583333333333
115831, 1.5125, -0.04, 0.16666666666667
115832, 1.5333333333333, -0.06, 0.16666666666667
115833, 1.5333333333333, -0.08, 0.14583333333333
115834, 1.5125, -0.08, 0.16666666666667
115835, 1.5333333333333, -0.1, 0.16666666666667
115836, 1.5333333333333, -0.12, 0.14583333333333
115837, 1.5125, -0.12, 0.16666666666667
115838, 1.5333333333333, -0.14, 0.16666666666667
115839, 1.5333333333333, -0.16, 0.14583333333333
115840, 1.5125, -0.16, 0.16666666666667
115841, 1.5333333333333, -0.18, 0.16666666666667
115842, 1.575, -0.02, 0.16666666666667
115843, 1.575, -0.04, 0.14583333333333
115844, 1.5541666666667, -0.04, 0.16666666666667
115845, 1.575, -0.06, 0.16666666666667
115846, 1.575, -0.08, 0.14583333333333
115847, 1.5541666666667, -0.08, 0.16666666666667
115848, 1.575, -0.1, 0.16666666666667
115849, 1.575, -0.12, 0.14583333333333
115850, 1.5541666666667, -0.12, 0.16666666666667
115851, 1.575, -0.14, 0.16666666666667
115852, 1.575, -0.16, 0.14583333333333
115853, 1.5541666666667, -0.16, 0.16666666666667
115854, 1.575, -0.18, 0.16666666666667
115855, 1.6166666666667, -0.02, 0.16666666666667
115856, 1.6166666666667, -0.04, 0.14583333333333
115857, 1.5958333333333, -0.04, 0.16666666666667
115858, 1.6166666666667, -0.06, 0.16666666666667
115859, 1.6166666666667, -0.08, 0.14583333333333
115860, 1.5958333333333, -0.08, 0.16666666666667
115861, 1.6166666666667, -0.1, 0.16666666666667
115862, 1.6166666666667, -0.12, 0.14583333333333
115863, 1.5958333333333, -0.12, 0.16666666666667
115864, 1.6166666666667, -0.14, 0.16666666666667
115865, 1.6166666666667, -0.16, 0.14583333333333
115866, 1.5958333333333, -0.16, 0.16666666666667
115867, 1.6166666666667, -0.18, 0.16666666666667
115868, 1.6583333333333, -0.02, 0.16666666666667
115869, 1.6583333333333, -0.04, 0.14583333333333
115870, 1.6375, -0.04, 0.16666666666667
115871, 1.6583333333333, -0.06, 0.16666666666667
115872, 1.6583333333333, -0.08, 0.14583333333333
115873, 1.6375, -0.08, 0.16666666666667
115874, 1.6583333333333, -0.1, 0.16666666666667
115875, 1.6583333333333, -0.12, 0.14583333333333
115876, 1.6375, -0.12, 0.16666666666667
115877, 1.6583333333333, -0.14, 0.16666666666667
115878, 1.6583333333333, -0.16, 0.14583333333333
115879, 1.6375, -0.16, 0.16666666666667
115880, 1.6583333333333, -0.18, 0.16666666666667
115881, 1.7, -0.02, 0.16666666666667
115882, 1.7, -0.04, 0.14583333333333
115883, 1.6791666666667, -0.04, 0.16666666666667
115884, 1.7, -0.06, 0.16666666666667
115885, 1.7, -0.08, 0.14583333333333
115886, 1.6791666666667, -0.08, 0.16666666666667
115887, 1.7, -0.1, 0.16666666666667
115888, 1.7, -0.12, 0.14583333333333
115889, 1.6791666666667, -0.12, 0.16666666666667
115890, 1.7, -0.14, 0.16666666666667
115891, 1.7, -0.16, 0.14583333333333
115892, 1.6791666666667, -0.16, 0.16666666666667
115893, 1.7, -0.18, 0.16666666666667
115894, 1.7416666666667, -0.02, 0.16666666666667
115895, 1.7416666666667, -0.04, 0.14583333333333
115896, 1.7208333333333, -0.04, 0.16666666666667
115897, 1.7416666666667, -0.06, 0.16666666666667
115898, 1.7416666666667, -0.08, 0.14583333333333
115899, 1.7208333333333, -0.08, 0.16666666666667
115900, 1.7416666666667, -0.1, 0.16666666666667
115901, 1.7416666666667, -0.12, 0.14583333333333
115902, 1.7208333333333, -0.12, 0.16666666666667
115903, 1.7416666666667, -0.14, 0.16666666666667
115904, 1.7416666666667, -0.16, 0.14583333333333
115905, 1.7208333333333, -0.16, 0.16666666666667
115906, 1.7416666666667, -0.18, 0.16666666666667
115907, 1.7833333333333, -0.02, 0.16666666666667
115908, 1.7833333333333, -0.04, 0.14583333333333
115909, 1.7625, -0.04, 0.16666666666667
115910, 1.7833333333333, -0.06, 0.16666666666667
115911, 1.7833333333333, -0.08, 0.14583333333333
115912, 1.7625, -0.08, 0.16666666666667
115913, 1.7833333333333, -0.1, 0.16666666666667
115914, 1.7833333333333, -0.12, 0.14583333333333
115915, 1.7625, -0.12, 0.16666666666667
115916, 1.7833333333333, -0.14, 0.16666666666667
115917, 1.7833333333333, -0.16, 0.14583333333333
115918, 1.7625, -0.16, 0.16666666666667
115919, 1.7833333333333, -0.18, 0.16666666666667
115920, 1.825, -0.02, 0.16666666666667
115921, 1.825, -0.04, 0.14583333333333
115922, 1.8041666666667, -0.04, 0.16666666666667
