20912, 1.9083333333333, 1.025, 0
20913, 1.8875, 1, 0
20914, 1.9083333333333, 0.975, 0
20915, 1.8875, 0.95, 0
20916, 1.9083333333333, 0.925, 0
20917, 1.8875, 0.9, 0
20918, 1.9083333333333, 0.875, 0
20919, 1.8875, 0.85, 0
20920, 1.9083333333333, 0.825, 0
20921, 1.8875, 0.8, 0
20922, 1.9083333333333, 0.775, 0
20923, 1.8875, 0.75, 0
20924, 1.9083333333333, 0.725, 0
20925, 1.8875, 0.7, 0
20926, 1.9083333333333, 0.675, 0
20927, 1.8875, 0.65, 0
20928, 1.9083333333333, 0.625, 0
20929, 1.8875, 0.6, 0
20930, 1.9083333333333, 0.575, 0
20931, 1.8875, 0.55, 0
20932, 1.9083333333333, 0.525, 0
20933, 1.8875, 0.5, 0
20934, 1.9083333333333, 0.475, 0
20935, 1.8875, 0.45, 0
20936, 1.9083333333333, 0.425, 0
20937, 1.8875, 0.4, 0
20938, 1.9083333333333, 0.375, 0
20939, 1.8875, 0.35, 0
20940, 1.9083333333333, 0.325, 0
20941, 1.8875, 0.3, 0
20942, 1.9083333333333, 0.275, 0
20943, 1.8875, 0.25, 0
20944, 1.9083333333333, 0.225, 0
20945, 1.8875, 0.2, 0
20946, 1.9083333333333, 0.175, 0
20947, 1.95, 1.325, 0
20948, 1.9291666666667, 1.3, 0
20949, 1.95, 1.275, 0
20950, 1.9291666666667, 1.25, 0
20951, 1.95, 1.225, 0
20952, 1.9291666666667, 1.2, 0
20953, 1.95, 1.175, 0
20954, 1.9291666666667, 1.15, 0
20955, 1.95, 1.125, 0
20956, 1.9291666666667, 1.1, 0
20957, 1.95, 1.075, 0
20958, 1.9291666666667, 1.05, 0
20959, 1.95, 1.025, 0
20960, 1.9291666666667, 1, 0
20961, 1.95, 0.975, 0
20962, 1.9291666666667, 0.95, 0
20963, 1.95, 0.925, 0
20964, 1.9291666666667, 0.9, 0
20965, 1.95, 0.875, 0
20966, 1.9291666666667, 0.85, 0
20967, 1.95, 0.825, 0
20968, 1.9291666666667, 0.8, 0
20969, 1.95, 0.775, 0
20970, 1.9291666666667, 0.75, 0
20971, 1.95, 0.725, 0
20972, 1.9291666666667, 0.7, 0
20973, 1.95, 0.675, 0
20974, 1.9291666666667, 0.65, 0
20975, 1.95, 0.625, 0
20976, 1.9291666666667, 0.6, 0
20977, 1.95, 0.575, 0
20978, 1.9291666666667, 0.55, 0
20979, 1.95, 0.525, 0
20980, 1.9291666666667, 0.5, 0
20981, 1.95, 0.475, 0
20982, 1.9291666666667, 0.45, 0
20983, 1.95, 0.425, 0
20984, 1.9291666666667, 0.4, 0
20985, 1.95, 0.375, 0
20986, 1.9291666666667, 0.35, 0
20987, 1.95, 0.325, 0
20988, 1.9291666666667, 0.3, 0
20989, 1.95, 0.275, 0
20990, 1.9291666666667, 0.25, 0
20991, 1.95, 0.225, 0
20992, 1.9291666666667, 0.2, 0
20993, 1.95, 0.175, 0
20994, 1.9916666666667, 1.325, 0
20995, 1.9708333333333, 1.3, 0
20996, 1.9916666666667, 1.275, 0
20997, 1.9708333333333, 1.25, 0
20998, 1.9916666666667, 1.225, 0
20999, 1.9708333333333, 1.2, 0
21000, 1.9916666666667, 1.175, 0
21001, 1.9708333333333, 1.15, 0
21002, 1.9916666666667, 1.125, 0
21003, 1.9708333333333, 1.1, 0
21004, 1.9916666666667, 1.075, 0
21005, 1.9708333333333, 1.05, 0
21006, 1.9916666666667, 1.025, 0
21007, 1.9708333333333, 1, 0
21008, 1.9916666666667, 0.975, 0
21009, 1.9708333333333, 0.95, 0
21010, 1.9916666666667, 0.925, 0
21011, 1.9708333333333, 0.9, 0
21012, 1.9916666666667, 0.875, 0
21013, 1.9708333333333, 0.85, 0
21014, 1.9916666666667, 0.825, 0
21015, 1.9708333333333, 0.8, 0
21016, 1.9916666666667, 0.775, 0
21017, 1.9708333333333, 0.75, 0
21018, 1.9916666666667, 0.725, 0
21019, 1.9708333333333, 0.7, 0
21020, 1.9916666666667, 0.675, 0
21021, 1.9708333333333, 0.65, 0
21022, 1.9916666666667, 0.625, 0
21023, 1.9708333333333, 0.6, 0
21024, 1.9916666666667, 0.575, 0
21025, 1.9708333333333, 0.55, 0
21026, 1.9916666666667, 0.525, 0
21027, 1.9708333333333, 0.5, 0
21028, 1.9916666666667, 0.475, 0
21029, 1.9708333333333, 0.45, 0
21030, 1.9916666666667, 0.425, 0
21031, 1.9708333333333, 0.4, 0
21032, 1.9916666666667, 0.375, 0
21033, 1.9708333333333, 0.35, 0
21034, 1.9916666666667, 0.325, 0
21035, 1.9708333333333, 0.3, 0
21036, 1.9916666666667, 0.275, 0
21037, 1.9708333333333, 0.25, 0
21038, 1.9916666666667, 0.225, 0
21039, 1.9708333333333, 0.2, 0
21040, 1.9916666666667, 0.175, 0
21041, 2.0333333333333, 1.325, 0
21042, 2.0125, 1.3, 0
21043, 2.0333333333333, 1.275, 0
21044, 2.0125, 1.25, 0
21045, 2.0333333333333, 1.225, 0
21046, 2.0125, 1.2, 0
21047, 2.0333333333333, 1.175, 0
21048, 2.0125, 1.15, 0
21049, 2.0333333333333, 1.125, 0
21050, 2.0125, 1.1, 0
21051, 2.0333333333333, 1.075, 0
21052, 2.0125, 1.05, 0
21053, 2.0333333333333, 1.025, 0
21054, 2.0125, 1, 0
21055, 2.0333333333333, 0.975, 0
21056, 2.0125, 0.95, 0
21057, 2.0333333333333, 0.925, 0
21058, 2.0125, 0.9, 0
21059, 2.0333333333333, 0.875, 0
21060, 2.0125, 0.85, 0
21061, 2.0333333333333, 0.825, 0
21062, 2.0125, 0.8, 0
21063, 2.0333333333333, 0.775, 0
21064, 2.0125, 0.75, 0
21065, 2.0333333333333, 0.725, 0
21066, 2.0125, 0.7, 0
21067, 2.0333333333333, 0.675, 0
21068, 2.0125, 0.65, 0
21069, 2.0333333333333, 0.625, 0
21070, 2.0125, 0.6, 0
21071, 2.0333333333333, 0.575, 0
21072, 2.0125, 0.55, 0
21073, 2.0333333333333, 0.525, 0
21074, 2.0125, 0.5, 0
21075, 2.0333333333333, 0.475, 0
21076, 2.0125, 0.45, 0
21077, 2.0333333333333, 0.425, 0
21078, 2.0125, 0.4, 0
21079, 2.0333333333333, 0.375, 0
21080, 2.0125, 0.35, 0
21081, 2.0333333333333, 0.325, 0
21082, 2.0125, 0.3, 0
21083, 2.0333333333333, 0.275, 0
21084, 2.0125, 0.25, 0
21085, 2.0333333333333, 0.225, 0
21086, 2.0125, 0.2, 0
21087, 2.0333333333333, 0.175, 0
21088, 2.075, 1.325, 0
21089, 2.0541666666667, 1.3, 0
21090, 2.075, 1.275, 0
21091, 2.0541666666667, 1.25, 0
21092, 2.075, 1.225, 0
21093, 2.0541666666667, 1.2, 0
21094, 2.075, 1.175, 0
21095, 2.0541666666667, 1.15, 0
21096, 2.075, 1.125, 0
21097, 2.0541666666667, 1.1, 0
21098, 2.075, 1.075, 0
21099, 2.0541666666667, 1.05, 0
21100, 2.075, 1.025, 0
21101, 2.0541666666667, 1, 0
21102, 2.075, 0.975, 0
21103, 2.0541666666667, 0.95, 0
21104, 2.075, 0.925, 0
21105, 2.0541666666667, 0.9, 0
21106, 2.075, 0.875, 0
21107, 2.0541666666667, 0.85, 0
21108, 2.075, 0.825, 0
21109, 2.0541666666667, 0.8, 0
21110, 2.075, 0.775, 0
21111, 2.0541666666667, 0.75, 0
21112, 2.075, 0.725, 0
21113, 2.0541666666667, 0.7, 0
21114, 2.075, 0.675, 0
21115, 2.0541666666667, 0.65, 0
21116, 2.075, 0.625, 0
21117, 2.0541666666667, 0.6, 0
21118, 2.075, 0.575, 0
21119, 2.0541666666667, 0.55, 0
21120, 2.075, 0.525, 0
21121, 2.0541666666667, 0.5, 0
21122, 2.075, 0.475, 0
21123, 2.0541666666667, 0.45, 0
21124, 2.075, 0.425, 0
21125, 2.0541666666667, 0.4, 0
21126, 2.075, 0.375, 0
21127, 2.0541666666667, 0.35, 0
21128, 2.075, 0.325, 0
21129, 2.0541666666667, 0.3, 0
21130, 2.075, 0.275, 0
21131, 2.0541666666667, 0.25, 0
21132, 2.075, 0.225, 0
21133, 2.0541666666667, 0.2, 0
21134, 2.075, 0.175, 0
21135, 2.1166666666667, 1.325, 0
21136, 2.0958333333333, 1.3, 0
21137, 2.1166666666667, 1.275, 0
21138, 2.0958333333333, 1.25, 0
21139, 2.1166666666667, 1.225, 0
21140, 2.0958333333333, 1.2, 0
21141, 2.1166666666667, 1.175, 0
21142, 2.0958333333333, 1.15, 0
21143, 2.1166666666667, 1.125, 0
21144, 2.0958333333333, 1.1, 0
21145, 2.1166666666667, 1.075, 0
21146, 2.0958333333333, 1.05, 0
21147, 2.1166666666667, 1.025, 0
21148, 2.0958333333333, 1, 0
21149, 2.1166666666667, 0.975, 0
21150, 2.0958333333333, 0.95, 0
21151, 2.1166666666667, 0.925, 0
21152, 2.0958333333333, 0.9, 0
21153, 2.1166666666667, 0.875, 0
21154, 2.0958333333333, 0.85, 0
21155, 2.1166666666667, 0.825, 0
21156, 2.0958333333333, 0.8, 0
21157, 2.1166666666667, 0.775, 0
21158, 2.0958333333333, 0.75, 0
21159, 2.1166666666667, 0.725, 0
21160, 2.0958333333333, 0.7, 0
21161, 2.1166666666667, 0.675, 0
21162, 2.0958333333333, 0.65, 0
21163, 2.1166666666667, 0.625, 0
21164, 2.0958333333333, 0.6, 0
21165, 2.1166666666667, 0.575, 0
21166, 2.0958333333333, 0.55, 0
21167, 2.1166666666667, 0.525, 0
21168, 2.0958333333333, 0.5, 0
21169, 2.1166666666667, 0.475, 0
21170, 2.0958333333333, 0.45, 0
21171, 2.1166666666667, 0.425, 0
21172, 2.0958333333333, 0.4, 0
21173, 2.1166666666667, 0.375, 0
21174, 2.0958333333333, 0.35, 0
21175, 2.1166666666667, 0.325, 0
21176, 2.0958333333333, 0.3, 0
21177, 2.1166666666667, 0.275, 0
21178, 2.0958333333333, 0.25, 0
21179, 2.1166666666667, 0.225, 0
21180, 2.0958333333333, 0.2, 0
21181, 2.1166666666667, 0.175, 0
21182, 2.1583333333333, 1.325, 0
21183, 2.1375, 1.3, 0
21184, 2.1583333333333, 1.275, 0
21185, 2.1375, 1.25, 0
21186, 2.1583333333333, 1.225, 0
21187, 2.1375, 1.2, 0
21188, 2.1583333333333, 1.175, 0
21189, 2.1375, 1.15, 0
21190, 2.1583333333333, 1.125, 0
21191, 2.1375, 1.1, 0
21192, 2.1583333333333, 1.075, 0
21193, 2.1375, 1.05, 0
21194, 2.1583333333333, 1.025, 0
21195, 2.1375, 1, 0
21196, 2.1583333333333, 0.975, 0
21197, 2.1375, 0.95, 0
21198, 2.1583333333333, 0.925, 0
21199, 2.1375, 0.9, 0
21200, 2.1583333333333, 0.875, 0
21201, 2.1375, 0.85, 0
21202, 2.1583333333333, 0.825, 0
21203, 2.1375, 0.8, 0
21204, 2.1583333333333, 0.775, 0
21205, 2.1375, 0.75, 0
21206, 2.1583333333333, 0.725, 0
21207, 2.1375, 0.7, 0
21208, 2.1583333333333, 0.675, 0
21209, 2.1375, 0.65, 0
21210, 2.1583333333333, 0.625, 0
21211, 2.1375, 0.6, 0
21212, 2.1583333333333, 0.575, 0
21213, 2.1375, 0.55, 0
21214, 2.1583333333333, 0.525, 0
21215, 2.1375, 0.5, 0
21216, 2.1583333333333, 0.475, 0
21217, 2.1375, 0.45, 0
21218, 2.1583333333333, 0.425, 0
21219, 2.1375, 0.4, 0
21220, 2.1583333333333, 0.375, 0
21221, 2.1375, 0.35, 0
21222, 2.1583333333333, 0.325, 0
21223, 2.1375, 0.3, 0
21224, 2.1583333333333, 0.275, 0
21225, 2.1375, 0.25, 0
21226, 2.1583333333333, 0.225, 0
21227, 2.1375, 0.2, 0
21228, 2.1583333333333, 0.175, 0
21229, 2.1791666666667, 1.3, 0
21230, 2.1791666666667, 1.25, 0
21231, 2.1791666666667, 1.2, 0
21232, 2.1791666666667, 1.15, 0
21233, 2.1791666666667, 1.1, 0
21234, 2.1791666666667, 1.05, 0
21235, 2.1791666666667, 1, 0
21236, 2.1791666666667, 0.95, 0
21237, 2.1791666666667, 0.9, 0
21238, 2.1791666666667, 0.85, 0
21239, 2.1791666666667, 0.8, 0
21240, 2.1791666666667, 0.75, 0
21241, 2.1791666666667, 0.7, 0
21242, 2.1791666666667, 0.65, 0
21243, 2.1791666666667, 0.6, 0
21244, 2.1791666666667, 0.55, 0
21245, 2.1791666666667, 0.5, 0
21246, 2.1791666666667, 0.45, 0
21247, 2.1791666666667, 0.4, 0
21248, 2.1791666666667, 0.35, 0
21249, 2.1791666666667, 0.3, 0
21250, 2.1791666666667, 0.25, 0
21251, 2.1791666666667, 0.2, 0
21252, 1.2, 1.3, 0.041666666666667
21253, 1.2, 1.25, 0.041666666666667
21254, 1.2, 1.2, 0.041666666666667
21255, 1.2, 1.15, 0.041666666666667
21256, 1.2, 1.1, 0.041666666666667
21257, 1.2, 1.05, 0.041666666666667
21258, 1.2, 1, 0.041666666666667
21259, 1.2, 0.95, 0.041666666666667
21260, 1.2, 0.9, 0.041666666666667
21261, 1.2, 0.85, 0.041666666666667
21262, 1.2, 0.8, 0.041666666666667
21263, 1.2, 0.75, 0.041666666666667
21264, 1.2, 0.7, 0.041666666666667
21265, 1.2, 0.65, 0.041666666666667
21266, 1.2, 0.6, 0.041666666666667
21267, 1.2, 0.55, 0.041666666666667
21268, 1.2, 0.5, 0.041666666666667
21269, 1.2, 0.45, 0.041666666666667
21270, 1.2, 0.4, 0.041666666666667
21271, 1.2, 0.35, 0.041666666666667
21272, 1.2, 0.3, 0.041666666666667
21273, 1.2, 0.25, 0.041666666666667
21274, 1.2, 0.2, 0.041666666666667
21275, 1.2, 1.3, 0.083333333333333
21276, 1.2, 1.25, 0.083333333333333
21277, 1.2, 1.2, 0.083333333333333
21278, 1.2, 1.15, 0.083333333333333
21279, 1.2, 1.1, 0.083333333333333
21280, 1.2, 1.05, 0.083333333333333
21281, 1.2, 1, 0.083333333333333
21282, 1.2, 0.95, 0.083333333333333
21283, 1.2, 0.9, 0.083333333333333
21284, 1.2, 0.85, 0.083333333333333
21285, 1.2, 0.8, 0.083333333333333
21286, 1.2, 0.75, 0.083333333333333
21287, 1.2, 0.7, 0.083333333333333
21288, 1.2, 0.65, 0.083333333333333
21289, 1.2, 0.6, 0.083333333333333
21290, 1.2, 0.55, 0.083333333333333
21291, 1.2, 0.5, 0.083333333333333
21292, 1.2, 0.45, 0.083333333333333
21293, 1.2, 0.4, 0.083333333333333
21294, 1.2, 0.35, 0.083333333333333
21295, 1.2, 0.3, 0.083333333333333
21296, 1.2, 0.25, 0.083333333333333
21297, 1.2, 0.2, 0.083333333333333
21298, 1.2, 1.3, 0.125
21299, 1.2, 1.25, 0.125
21300, 1.2, 1.2, 0.125
21301, 1.2, 1.15, 0.125
21302, 1.2, 1.1, 0.125
21303, 1.2, 1.05, 0.125
21304, 1.2, 1, 0.125
21305, 1.2, 0.95, 0.125
21306, 1.2, 0.9, 0.125
21307, 1.2, 0.85, 0.125
21308, 1.2, 0.8, 0.125
21309, 1.2, 0.75, 0.125
21310, 1.2, 0.7, 0.125
21311, 1.2, 0.65, 0.125
21312, 1.2, 0.6, 0.125
21313, 1.2, 0.55, 0.125
21314, 1.2, 0.5, 0.125
21315, 1.2, 0.45, 0.125
21316, 1.2, 0.4, 0.125
21317, 1.2, 0.35, 0.125
21318, 1.2, 0.3, 0.125
21319, 1.2, 0.25, 0.125
21320, 1.2, 0.2, 0.125
21321, 1.2, 1.3, 0.16666666666667
21322, 1.2, 1.25, 0.16666666666667
21323, 1.2, 1.2, 0.16666666666667
21324, 1.2, 1.15, 0.16666666666667
21325, 1.2, 1.1, 0.16666666666667
21326, 1.2, 1.05, 0.16666666666667
21327, 1.2, 1, 0.16666666666667
21328, 1.2, 0.95, 0.16666666666667
21329, 1.2, 0.9, 0.16666666666667
21330, 1.2, 0.85, 0.16666666666667
21331, 1.2, 0.8, 0.16666666666667
21332, 1.2, 0.75, 0.16666666666667
21333, 1.2, 0.7, 0.16666666666667
21334, 1.2, 0.65, 0.16666666666667
21335, 1.2, 0.6, 0.16666666666667
21336, 1.2, 0.55, 0.16666666666667
21337, 1.2, 0.5, 0.16666666666667
21338, 1.2, 0.45, 0.16666666666667
21339, 1.2, 0.4, 0.16666666666667
21340, 1.2, 0.35, 0.16666666666667
21341, 1.2, 0.3, 0.16666666666667
21342, 1.2, 0.25, 0.16666666666667
21343, 1.2, 0.2, 0.16666666666667
21344, 1.2, 1.3, 0.20833333333333
21345, 1.2, 1.25, 0.20833333333333
21346, 1.2, 1.2, 0.20833333333333
21347, 1.2, 1.15, 0.20833333333333
21348, 1.2, 1.1, 0.20833333333333
21349, 1.2, 1.05, 0.20833333333333
21350, 1.2, 1, 0.20833333333333
21351, 1.2, 0.95, 0.20833333333333
21352, 1.2, 0.9, 0.20833333333333
21353, 1.2, 0.85, 0.20833333333333
21354, 1.2, 0.8, 0.20833333333333
21355, 1.2, 0.75, 0.20833333333333
21356, 1.2, 0.7, 0.20833333333333
21357, 1.2, 0.65, 0.20833333333333
21358, 1.2, 0.6, 0.20833333333333
21359, 1.2, 0.55, 0.20833333333333
21360, 1.2, 0.5, 0.20833333333333
21361, 1.2, 0.45, 0.20833333333333
21362, 1.2, 0.4, 0.20833333333333
21363, 1.2, 0.35, 0.20833333333333
21364, 1.2, 0.3, 0.20833333333333
21365, 1.2, 0.25, 0.20833333333333
21366, 1.2, 0.2, 0.20833333333333
21367, 1.2, 1.3, 0.25
21368, 1.2, 1.25, 0.25
21369, 1.2, 1.2, 0.25
21370, 1.2, 1.15, 0.25
21371, 1.2, 1.1, 0.25
21372, 1.2, 1.05, 0.25
21373, 1.2, 1, 0.25
21374, 1.2, 0.95, 0.25
21375, 1.2, 0.9, 0.25
21376, 1.2, 0.85, 0.25
21377, 1.2, 0.8, 0.25
21378, 1.2, 0.75, 0.25
21379, 1.2, 0.7, 0.25
21380, 1.2, 0.65, 0.25
21381, 1.2, 0.6, 0.25
21382, 1.2, 0.55, 0.25
21383, 1.2, 0.5, 0.25
21384, 1.2, 0.45, 0.25
21385, 1.2, 0.4, 0.25
21386, 1.2, 0.35, 0.25
21387, 1.2, 0.3, 0.25
21388, 1.2, 0.25, 0.25
21389, 1.2, 0.2, 0.25
21390, 1.2, 1.3, 0.29166666666667
21391, 1.2, 1.25, 0.29166666666667
21392, 1.2, 1.2, 0.29166666666667
21393, 1.2, 1.15, 0.29166666666667
21394, 1.2, 1.1, 0.29166666666667
21395, 1.2, 1.05, 0.29166666666667
21396, 1.2, 1, 0.29166666666667
21397, 1.2, 0.95, 0.29166666666667
21398, 1.2, 0.9, 0.29166666666667
21399, 1.2, 0.85, 0.29166666666667
21400, 1.2, 0.8, 0.29166666666667
21401, 1.2, 0.75, 0.29166666666667
21402, 1.2, 0.7, 0.29166666666667
21403, 1.2, 0.65, 0.29166666666667
21404, 1.2, 0.6, 0.29166666666667
21405, 1.2, 0.55, 0.29166666666667
21406, 1.2, 0.5, 0.29166666666667
21407, 1.2, 0.45, 0.29166666666667
21408, 1.2, 0.4, 0.29166666666667
21409, 1.2, 0.35, 0.29166666666667
21410, 1.2, 0.3, 0.29166666666667
21411, 1.2, 0.25, 0.29166666666667
21412, 1.2, 0.2, 0.29166666666667
21413, 1.2, 1.3, 0.33333333333333
21414, 1.2, 1.25, 0.33333333333333
21415, 1.2, 1.2, 0.33333333333333
21416, 1.2, 1.15, 0.33333333333333
21417, 1.2, 1.1, 0.33333333333333
21418, 1.2, 1.05, 0.33333333333333
21419, 1.2, 1, 0.33333333333333
21420, 1.2, 0.95, 0.33333333333333
21421, 1.2, 0.9, 0.33333333333333
21422, 1.2, 0.85, 0.33333333333333
21423, 1.2, 0.8, 0.33333333333333
21424, 1.2, 0.75, 0.33333333333333
21425, 1.2, 0.7, 0.33333333333333
21426, 1.2, 0.65, 0.33333333333333
21427, 1.2, 0.6, 0.33333333333333
21428, 1.2, 0.55, 0.33333333333333
21429, 1.2, 0.5, 0.33333333333333
21430, 1.2, 0.45, 0.33333333333333
21431, 1.2, 0.4, 0.33333333333333
21432, 1.2, 0.35, 0.33333333333333
21433, 1.2, 0.3, 0.33333333333333
21434, 1.2, 0.25, 0.33333333333333
21435, 1.2, 0.2, 0.33333333333333
21436, 1.2, 1.3, 0.375
21437, 1.2, 1.25, 0.375
21438, 1.2, 1.2, 0.375
21439, 1.2, 1.15, 0.375
21440, 1.2, 1.1, 0.375
21441, 1.2, 1.05, 0.375
21442, 1.2, 1, 0.375
21443, 1.2, 0.95, 0.375
21444, 1.2, 0.9, 0.375
21445, 1.2, 0.85, 0.375
21446, 1.2, 0.8, 0.375
21447, 1.2, 0.75, 0.375
21448, 1.2, 0.7, 0.375
21449, 1.2, 0.65, 0.375
21450, 1.2, 0.6, 0.375
21451, 1.2, 0.55, 0.375
21452, 1.2, 0.5, 0.375
21453, 1.2, 0.45, 0.375
21454, 1.2, 0.4, 0.375
21455, 1.2, 0.35, 0.375
21456, 1.2, 0.3, 0.375
21457, 1.2, 0.25, 0.375
21458, 1.2, 0.2, 0.375
21459, 1.2, 1.3, 0.41666666666667
21460, 1.2, 1.25, 0.41666666666667
21461, 1.2, 1.2, 0.41666666666667
21462, 1.2, 1.15, 0.41666666666667
21463, 1.2, 1.1, 0.41666666666667
21464, 1.2, 1.05, 0.41666666666667
21465, 1.2, 1, 0.41666666666667
21466, 1.2, 0.95, 0.41666666666667
21467, 1.2, 0.9, 0.41666666666667
21468, 1.2, 0.85, 0.41666666666667
21469, 1.2, 0.8, 0.41666666666667
21470, 1.2, 0.75, 0.41666666666667
21471, 1.2, 0.7, 0.41666666666667
21472, 1.2, 0.65, 0.41666666666667
21473, 1.2, 0.6, 0.41666666666667
21474, 1.2, 0.55, 0.41666666666667
21475, 1.2, 0.5, 0.41666666666667
21476, 1.2, 0.45, 0.41666666666667
21477, 1.2, 0.4, 0.41666666666667
21478, 1.2, 0.35, 0.41666666666667
21479, 1.2, 0.3, 0.41666666666667
21480, 1.2, 0.25, 0.41666666666667
21481, 1.2, 0.2, 0.41666666666667
21482, 1.2, 1.3, 0.45833333333333
21483, 1.2, 1.25, 0.45833333333333
21484, 1.2, 1.2, 0.45833333333333
21485, 1.2, 1.15, 0.45833333333333
21486, 1.2, 1.1, 0.45833333333333
21487, 1.2, 1.05, 0.45833333333333
21488, 1.2, 1, 0.45833333333333
21489, 1.2, 0.95, 0.45833333333333
21490, 1.2, 0.9, 0.45833333333333
21491, 1.2, 0.85, 0.45833333333333
21492, 1.2, 0.8, 0.45833333333333
21493, 1.2, 0.75, 0.45833333333333
21494, 1.2, 0.7, 0.45833333333333
21495, 1.2, 0.65, 0.45833333333333
21496, 1.2, 0.6, 0.45833333333333
21497, 1.2, 0.55, 0.45833333333333
21498, 1.2, 0.5, 0.45833333333333
21499, 1.2, 0.45, 0.45833333333333
21500, 1.2, 0.4, 0.45833333333333
21501, 1.2, 0.35, 0.45833333333333
21502, 1.2, 0.3, 0.45833333333333
21503, 1.2, 0.25, 0.45833333333333
21504, 1.2, 0.2, 0.45833333333333
21505, 1.2, 1.3, 0.020833333333333
21506, 1.2, 1.325, 0.041666666666667
21507, 1.2, 1.25, 0.020833333333333
21508, 1.2, 1.275, 0.041666666666667
21509, 1.2, 1.2, 0.020833333333333
21510, 1.2, 1.225, 0.041666666666667
21511, 1.2, 1.15, 0.020833333333333
21512, 1.2, 1.175, 0.041666666666667
21513, 1.2, 1.1, 0.020833333333333
21514, 1.2, 1.125, 0.041666666666667
21515, 1.2, 1.05, 0.020833333333333
21516, 1.2, 1.075, 0.041666666666667
21517, 1.2, 1, 0.020833333333333
21518, 1.2, 1.025, 0.041666666666667
21519, 1.2, 0.95, 0.020833333333333
21520, 1.2, 0.975, 0.041666666666667
21521, 1.2, 0.9, 0.020833333333333
21522, 1.2, 0.925, 0.041666666666667
21523, 1.2, 0.85, 0.020833333333333
21524, 1.2, 0.875, 0.041666666666667
21525, 1.2, 0.8, 0.020833333333333
21526, 1.2, 0.825, 0.041666666666667
21527, 1.2, 0.75, 0.020833333333333
21528, 1.2, 0.775, 0.041666666666667
21529, 1.2, 0.7, 0.020833333333333
21530, 1.2, 0.725, 0.041666666666667
21531, 1.2, 0.65, 0.020833333333333
21532, 1.2, 0.675, 0.041666666666667
21533, 1.2, 0.6, 0.020833333333333
21534, 1.2, 0.625, 0.041666666666667
21535, 1.2, 0.55, 0.020833333333333
21536, 1.2, 0.575, 0.041666666666667
21537, 1.2, 0.5, 0.020833333333333
21538, 1.2, 0.525, 0.041666666666667
21539, 1.2, 0.45, 0.020833333333333
21540, 1.2, 0.475, 0.041666666666667
21541, 1.2, 0.4, 0.020833333333333
21542, 1.2, 0.425, 0.041666666666667
21543, 1.2, 0.35, 0.020833333333333
21544, 1.2, 0.375, 0.041666666666667
21545, 1.2, 0.3, 0.020833333333333
21546, 1.2, 0.325, 0.041666666666667
21547, 1.2, 0.25, 0.020833333333333
21548, 1.2, 0.275, 0.041666666666667
21549, 1.2, 0.2, 0.020833333333333
21550, 1.2, 0.225, 0.041666666666667
21551, 1.2, 0.175, 0.041666666666667
21552, 1.2, 1.3, 0.0625
21553, 1.2, 1.325, 0.083333333333333
21554, 1.2, 1.25, 0.0625
21555, 1.2, 1.275, 0.083333333333333
21556, 1.2, 1.2, 0.0625
21557, 1.2, 1.225, 0.083333333333333
21558, 1.2, 1.15, 0.0625
21559, 1.2, 1.175, 0.083333333333333
21560, 1.2, 1.1, 0.0625
21561, 1.2, 1.125, 0.083333333333333
21562, 1.2, 1.05, 0.0625
21563, 1.2, 1.075, 0.083333333333333
21564, 1.2, 1, 0.0625
21565, 1.2, 1.025, 0.083333333333333
21566, 1.2, 0.95, 0.0625
21567, 1.2, 0.975, 0.083333333333333
21568, 1.2, 0.9, 0.0625
21569, 1.2, 0.925, 0.083333333333333
21570, 1.2, 0.85, 0.0625
21571, 1.2, 0.875, 0.083333333333333
21572, 1.2, 0.8, 0.0625
21573, 1.2, 0.825, 0.083333333333333
21574, 1.2, 0.75, 0.0625
21575, 1.2, 0.775, 0.083333333333333
21576, 1.2, 0.7, 0.0625
21577, 1.2, 0.725, 0.083333333333333
21578, 1.2, 0.65, 0.0625
21579, 1.2, 0.675, 0.083333333333333
21580, 1.2, 0.6, 0.0625
21581, 1.2, 0.625, 0.083333333333333
21582, 1.2, 0.55, 0.0625
21583, 1.2, 0.575, 0.083333333333333
21584, 1.2, 0.5, 0.0625
21585, 1.2, 0.525, 0.083333333333333
21586, 1.2, 0.45, 0.0625
21587, 1.2, 0.475, 0.083333333333333
21588, 1.2, 0.4, 0.0625
21589, 1.2, 0.425, 0.083333333333333
21590, 1.2, 0.35, 0.0625
21591, 1.2, 0.375, 0.083333333333333
21592, 1.2, 0.3, 0.0625
21593, 1.2, 0.325, 0.083333333333333
21594, 1.2, 0.25, 0.0625
21595, 1.2, 0.275, 0.083333333333333
21596, 1.2, 0.2, 0.0625
21597, 1.2, 0.225, 0.083333333333333
21598, 1.2, 0.175, 0.083333333333333
21599, 1.2, 1.3, 0.10416666666667
21600, 1.2, 1.325, 0.125
21601, 1.2, 1.25, 0.10416666666667
21602, 1.2, 1.275, 0.125
21603, 1.2, 1.2, 0.10416666666667
21604, 1.2, 1.225, 0.125
21605, 1.2, 1.15, 0.10416666666667
21606, 1.2, 1.175, 0.125
21607, 1.2, 1.1, 0.10416666666667
21608, 1.2, 1.125, 0.125
21609, 1.2, 1.05, 0.10416666666667
21610, 1.2, 1.075, 0.125
21611, 1.2, 1, 0.10416666666667
21612, 1.2, 1.025, 0.125
21613, 1.2, 0.95, 0.10416666666667
21614, 1.2, 0.975, 0.125
21615, 1.2, 0.9, 0.10416666666667
21616, 1.2, 0.925, 0.125
21617, 1.2, 0.85, 0.10416666666667
21618, 1.2, 0.875, 0.125
21619, 1.2, 0.8, 0.10416666666667
21620, 1.2, 0.825, 0.125
21621, 1.2, 0.75, 0.10416666666667
21622, 1.2, 0.775, 0.125
21623, 1.2, 0.7, 0.10416666666667
21624, 1.2, 0.725, 0.125
21625, 1.2, 0.65, 0.10416666666667
21626, 1.2, 0.675, 0.125
21627, 1.2, 0.6, 0.10416666666667
21628, 1.2, 0.625, 0.125
21629, 1.2, 0.55, 0.10416666666667
21630, 1.2, 0.575, 0.125
21631, 1.2, 0.5, 0.10416666666667
21632, 1.2, 0.525, 0.125
21633, 1.2, 0.45, 0.10416666666667
21634, 1.2, 0.475, 0.125
21635, 1.2, 0.4, 0.10416666666667
21636, 1.2, 0.425, 0.125
21637, 1.2, 0.35, 0.10416666666667
21638, 1.2, 0.375, 0.125
21639, 1.2, 0.3, 0.10416666666667
21640, 1.2, 0.325, 0.125
21641, 1.2, 0.25, 0.10416666666667
21642, 1.2, 0.275, 0.125
21643, 1.2, 0.2, 0.10416666666667
21644, 1.2, 0.225, 0.125
21645, 1.2, 0.175, 0.125
21646, 1.2, 1.3, 0.14583333333333
21647, 1.2, 1.325, 0.16666666666667
21648, 1.2, 1.25, 0.14583333333333
21649, 1.2, 1.275, 0.16666666666667
21650, 1.2, 1.2, 0.14583333333333
21651, 1.2, 1.225, 0.16666666666667
21652, 1.2, 1.15, 0.14583333333333
21653, 1.2, 1.175, 0.16666666666667
21654, 1.2, 1.1, 0.14583333333333
21655, 1.2, 1.125, 0.16666666666667
21656, 1.2, 1.05, 0.14583333333333
21657, 1.2, 1.075, 0.16666666666667
21658, 1.2, 1, 0.14583333333333
21659, 1.2, 1.025, 0.16666666666667
21660, 1.2, 0.95, 0.14583333333333
21661, 1.2, 0.975, 0.16666666666667
21662, 1.2, 0.9, 0.14583333333333
21663, 1.2, 0.925, 0.16666666666667
21664, 1.2, 0.85, 0.14583333333333
21665, 1.2, 0.875, 0.16666666666667
21666, 1.2, 0.8, 0.14583333333333
21667, 1.2, 0.825, 0.16666666666667
21668, 1.2, 0.75, 0.14583333333333
21669, 1.2, 0.775, 0.16666666666667
21670, 1.2, 0.7, 0.14583333333333
21671, 1.2, 0.725, 0.16666666666667
21672, 1.2, 0.65, 0.14583333333333
21673, 1.2, 0.675, 0.16666666666667
21674, 1.2, 0.6, 0.14583333333333
21675, 1.2, 0.625, 0.16666666666667
21676, 1.2, 0.55, 0.14583333333333
21677, 1.2, 0.575, 0.16666666666667
21678, 1.2, 0.5, 0.14583333333333
21679, 1.2, 0.525, 0.16666666666667
21680, 1.2, 0.45, 0.14583333333333
21681, 1.2, 0.475, 0.16666666666667
21682, 1.2, 0.4, 0.14583333333333
21683, 1.2, 0.425, 0.16666666666667
21684, 1.2, 0.35, 0.14583333333333
21685, 1.2, 0.375, 0.16666666666667
21686, 1.2, 0.3, 0.14583333333333
21687, 1.2, 0.325, 0.16666666666667
21688, 1.2, 0.25, 0.14583333333333
21689, 1.2, 0.275, 0.16666666666667
21690, 1.2, 0.2, 0.14583333333333
21691, 1.2, 0.225, 0.16666666666667
21692, 1.2, 0.175, 0.16666666666667
21693, 1.2, 1.3, 0.1875
21694, 1.2, 1.325, 0.20833333333333
21695, 1.2, 1.25, 0.1875
21696, 1.2, 1.275, 0.20833333333333
21697, 1.2, 1.2, 0.1875
21698, 1.2, 1.225, 0.20833333333333
21699, 1.2, 1.15, 0.1875
21700, 1.2, 1.175, 0.20833333333333
21701, 1.2, 1.1, 0.1875
21702, 1.2, 1.125, 0.20833333333333
21703, 1.2, 1.05, 0.1875
21704, 1.2, 1.075, 0.20833333333333
21705, 1.2, 1, 0.1875
21706, 1.2, 1.025, 0.20833333333333
21707, 1.2, 0.95, 0.1875
21708, 1.2, 0.975, 0.20833333333333
21709, 1.2, 0.9, 0.1875
21710, 1.2, 0.925, 0.20833333333333
21711, 1.2, 0.85, 0.1875
21712, 1.2, 0.875, 0.20833333333333
21713, 1.2, 0.8, 0.1875
21714, 1.2, 0.825, 0.20833333333333
21715, 1.2, 0.75, 0.1875
21716, 1.2, 0.775, 0.20833333333333
21717, 1.2, 0.7, 0.1875
21718, 1.2, 0.725, 0.20833333333333
21719, 1.2, 0.65, 0.1875
21720, 1.2, 0.675, 0.20833333333333
21721, 1.2, 0.6, 0.1875
21722, 1.2, 0.625, 0.20833333333333
21723, 1.2, 0.55, 0.1875
21724, 1.2, 0.575, 0.20833333333333
21725, 1.2, 0.5, 0.1875
21726, 1.2, 0.525, 0.20833333333333
21727, 1.2, 0.45, 0.1875
21728, 1.2, 0.475, 0.20833333333333
21729, 1.2, 0.4, 0.1875
21730, 1.2, 0.425, 0.20833333333333
21731, 1.2, 0.35, 0.1875
21732, 1.2, 0.375, 0.20833333333333
21733, 1.2, 0.3, 0.1875
21734, 1.2, 0.325, 0.20833333333333
21735, 1.2, 0.25, 0.1875
21736, 1.2, 0.275, 0.20833333333333
21737, 1.2, 0.2, 0.1875
21738, 1.2, 0.225, 0.20833333333333
21739, 1.2, 0.175, 0.20833333333333
21740, 1.2, 1.3, 0.22916666666667
21741, 1.2, 1.325, 0.25
21742, 1.2, 1.25, 0.22916666666667
21743, 1.2, 1.275, 0.25
21744, 1.2, 1.2, 0.22916666666667
21745, 1.2, 1.225, 0.25
21746, 1.2, 1.15, 0.22916666666667
21747, 1.2, 1.175, 0.25
21748, 1.2, 1.1, 0.22916666666667
21749, 1.2, 1.125, 0.25
21750, 1.2, 1.05, 0.22916666666667
21751, 1.2, 1.075, 0.25
21752, 1.2, 1, 0.22916666666667
21753, 1.2, 1.025, 0.25
21754, 1.2, 0.95, 0.22916666666667
21755, 1.2, 0.975, 0.25
21756, 1.2, 0.9, 0.22916666666667
21757, 1.2, 0.925, 0.25
21758, 1.2, 0.85, 0.22916666666667
21759, 1.2, 0.875, 0.25
21760, 1.2, 0.8, 0.22916666666667
21761, 1.2, 0.825, 0.25
21762, 1.2, 0.75, 0.22916666666667
21763, 1.2, 0.775, 0.25
21764, 1.2, 0.7, 0.22916666666667
21765, 1.2, 0.725, 0.25
21766, 1.2, 0.65, 0.22916666666667
21767, 1.2, 0.675, 0.25
21768, 1.2, 0.6, 0.22916666666667
21769, 1.2, 0.625, 0.25
21770, 1.2, 0.55, 0.22916666666667
21771, 1.2, 0.575, 0.25
21772, 1.2, 0.5, 0.22916666666667
21773, 1.2, 0.525, 0.25
21774, 1.2, 0.45, 0.22916666666667
21775, 1.2, 0.475, 0.25
21776, 1.2, 0.4, 0.22916666666667
21777, 1.2, 0.425, 0.25
21778, 1.2, 0.35, 0.22916666666667
21779, 1.2, 0.375, 0.25
21780, 1.2, 0.3, 0.22916666666667
21781, 1.2, 0.325, 0.25
21782, 1.2, 0.25, 0.22916666666667
21783, 1.2, 0.275, 0.25
21784, 1.2, 0.2, 0.22916666666667
21785, 1.2, 0.225, 0.25
21786, 1.2, 0.175, 0.25
21787, 1.2, 1.3, 0.27083333333333
21788, 1.2, 1.325, 0.29166666666667
21789, 1.2, 1.25, 0.27083333333333
21790, 1.2, 1.275, 0.29166666666667
21791, 1.2, 1.2, 0.27083333333333
21792, 1.2, 1.225, 0.29166666666667
21793, 1.2, 1.15, 0.27083333333333
21794, 1.2, 1.175, 0.29166666666667
21795, 1.2, 1.1, 0.27083333333333
21796, 1.2, 1.125, 0.29166666666667
21797, 1.2, 1.05, 0.27083333333333
21798, 1.2, 1.075, 0.29166666666667
21799, 1.2, 1, 0.27083333333333
21800, 1.2, 1.025, 0.29166666666667
21801, 1.2, 0.95, 0.27083333333333
21802, 1.2, 0.975, 0.29166666666667
21803, 1.2, 0.9, 0.27083333333333
21804, 1.2, 0.925, 0.29166666666667
21805, 1.2, 0.85, 0.27083333333333
21806, 1.2, 0.875, 0.29166666666667
21807, 1.2, 0.8, 0.27083333333333
21808, 1.2, 0.825, 0.29166666666667
21809, 1.2, 0.75, 0.27083333333333
21810, 1.2, 0.775, 0.29166666666667
21811, 1.2, 0.7, 0.27083333333333
21812, 1.2, 0.725, 0.29166666666667
21813, 1.2, 0.65, 0.27083333333333
21814, 1.2, 0.675, 0.29166666666667
21815, 1.2, 0.6, 0.27083333333333
21816, 1.2, 0.625, 0.29166666666667
21817, 1.2, 0.55, 0.27083333333333
21818, 1.2, 0.575, 0.29166666666667
21819, 1.2, 0.5, 0.27083333333333
21820, 1.2, 0.525, 0.29166666666667
21821, 1.2, 0.45, 0.27083333333333
21822, 1.2, 0.475, 0.29166666666667
21823, 1.2, 0.4, 0.27083333333333
21824, 1.2, 0.425, 0.29166666666667
21825, 1.2, 0.35, 0.27083333333333
21826, 1.2, 0.375, 0.29166666666667
21827, 1.2, 0.3, 0.27083333333333
21828, 1.2, 0.325, 0.29166666666667
21829, 1.2, 0.25, 0.27083333333333
21830, 1.2, 0.275, 0.29166666666667
21831, 1.2, 0.2, 0.27083333333333
21832, 1.2, 0.225, 0.29166666666667
21833, 1.2, 0.175, 0.29166666666667
21834, 1.2, 1.3, 0.3125
21835, 1.2, 1.325, 0.33333333333333
21836, 1.2, 1.25, 0.3125
21837, 1.2, 1.275, 0.33333333333333
21838, 1.2, 1.2, 0.3125
21839, 1.2, 1.225, 0.33333333333333
21840, 1.2, 1.15, 0.3125
21841, 1.2, 1.175, 0.33333333333333
21842, 1.2, 1.1, 0.3125
21843, 1.2, 1.125, 0.33333333333333
21844, 1.2, 1.05, 0.3125
21845, 1.2, 1.075, 0.33333333333333
21846, 1.2, 1, 0.3125
21847, 1.2, 1.025, 0.33333333333333
21848, 1.2, 0.95, 0.3125
21849, 1.2, 0.975, 0.33333333333333
21850, 1.2, 0.9, 0.3125
21851, 1.2, 0.925, 0.33333333333333
21852, 1.2, 0.85, 0.3125
21853, 1.2, 0.875, 0.33333333333333
21854, 1.2, 0.8, 0.3125
21855, 1.2, 0.825, 0.33333333333333
21856, 1.2, 0.75, 0.3125
21857, 1.2, 0.775, 0.33333333333333
21858, 1.2, 0.7, 0.3125
21859, 1.2, 0.725, 0.33333333333333
21860, 1.2, 0.65, 0.3125
21861, 1.2, 0.675, 0.33333333333333
21862, 1.2, 0.6, 0.3125
21863, 1.2, 0.625, 0.33333333333333
21864, 1.2, 0.55, 0.3125
21865, 1.2, 0.575, 0.33333333333333
21866, 1.2, 0.5, 0.3125
21867, 1.2, 0.525, 0.33333333333333
21868, 1.2, 0.45, 0.3125
21869, 1.2, 0.475, 0.33333333333333
21870, 1.2, 0.4, 0.3125
21871, 1.2, 0.425, 0.33333333333333
21872, 1.2, 0.35, 0.3125
21873, 1.2, 0.375, 0.33333333333333
21874, 1.2, 0.3, 0.3125
21875, 1.2, 0.325, 0.33333333333333
21876, 1.2, 0.25, 0.3125
21877, 1.2, 0.275, 0.33333333333333
21878, 1.2, 0.2, 0.3125
21879, 1.2, 0.225, 0.33333333333333
21880, 1.2, 0.175, 0.33333333333333
21881, 1.2, 1.3, 0.35416666666667
21882, 1.2, 1.325, 0.375
21883, 1.2, 1.25, 0.35416666666667
21884, 1.2, 1.275, 0.375
21885, 1.2, 1.2, 0.35416666666667
21886, 1.2, 1.225, 0.375
21887, 1.2, 1.15, 0.35416666666667
21888, 1.2, 1.175, 0.375
21889, 1.2, 1.1, 0.35416666666667
21890, 1.2, 1.125, 0.375
21891, 1.2, 1.05, 0.35416666666667
21892, 1.2, 1.075, 0.375
21893, 1.2, 1, 0.35416666666667
21894, 1.2, 1.025, 0.375
21895, 1.2, 0.95, 0.35416666666667
21896, 1.2, 0.975, 0.375
21897, 1.2, 0.9, 0.35416666666667
21898, 1.2, 0.925, 0.375
21899, 1.2, 0.85, 0.35416666666667
21900, 1.2, 0.875, 0.375
21901, 1.2, 0.8, 0.35416666666667
21902, 1.2, 0.825, 0.375
21903, 1.2, 0.75, 0.35416666666667
21904, 1.2, 0.775, 0.375
21905, 1.2, 0.7, 0.35416666666667
21906, 1.2, 0.725, 0.375
21907, 1.2, 0.65, 0.35416666666667
21908, 1.2, 0.675, 0.375
21909, 1.2, 0.6, 0.35416666666667
21910, 1.2, 0.625, 0.375
21911, 1.2, 0.55, 0.35416666666667
21912, 1.2, 0.575, 0.375
21913, 1.2, 0.5, 0.35416666666667
21914, 1.2, 0.525, 0.375
21915, 1.2, 0.45, 0.35416666666667
21916, 1.2, 0.475, 0.375
21917, 1.2, 0.4, 0.35416666666667
21918, 1.2, 0.425, 0.375
21919, 1.2, 0.35, 0.35416666666667
21920, 1.2, 0.375, 0.375
21921, 1.2, 0.3, 0.35416666666667
21922, 1.2, 0.325, 0.375
21923, 1.2, 0.25, 0.35416666666667
21924, 1.2, 0.275, 0.375
21925, 1.2, 0.2, 0.35416666666667
21926, 1.2, 0.225, 0.375
21927, 1.2, 0.175, 0.375
21928, 1.2, 1.3, 0.39583333333333
21929, 1.2, 1.325, 0.41666666666667
21930, 1.2, 1.25, 0.39583333333333
21931, 1.2, 1.275, 0.41666666666667
21932, 1.2, 1.2, 0.39583333333333
21933, 1.2, 1.225, 0.41666666666667
21934, 1.2, 1.15, 0.39583333333333
21935, 1.2, 1.175, 0.41666666666667
21936, 1.2, 1.1, 0.39583333333333
21937, 1.2, 1.125, 0.41666666666667
21938, 1.2, 1.05, 0.39583333333333
21939, 1.2, 1.075, 0.41666666666667
21940, 1.2, 1, 0.39583333333333
21941, 1.2, 1.025, 0.41666666666667
21942, 1.2, 0.95, 0.39583333333333
21943, 1.2, 0.975, 0.41666666666667
21944, 1.2, 0.9, 0.39583333333333
21945, 1.2, 0.925, 0.41666666666667
21946, 1.2, 0.85, 0.39583333333333
21947, 1.2, 0.875, 0.41666666666667
21948, 1.2, 0.8, 0.39583333333333
21949, 1.2, 0.825, 0.41666666666667
21950, 1.2, 0.75, 0.39583333333333
21951, 1.2, 0.775, 0.41666666666667
21952, 1.2, 0.7, 0.39583333333333
21953, 1.2, 0.725, 0.41666666666667
21954, 1.2, 0.65, 0.39583333333333
21955, 1.2, 0.675, 0.41666666666667
21956, 1.2, 0.6, 0.39583333333333
21957, 1.2, 0.625, 0.41666666666667
21958, 1.2, 0.55, 0.39583333333333
21959, 1.2, 0.575, 0.41666666666667
21960, 1.2, 0.5, 0.39583333333333
21961, 1.2, 0.525, 0.41666666666667
21962, 1.2, 0.45, 0.39583333333333
21963, 1.2, 0.475, 0.41666666666667
21964, 1.2, 0.4, 0.39583333333333
21965, 1.2, 0.425, 0.41666666666667
21966, 1.2, 0.35, 0.39583333333333
21967, 1.2, 0.375, 0.41666666666667
21968, 1.2, 0.3, 0.39583333333333
21969, 1.2, 0.325, 0.41666666666667
21970, 1.2, 0.25, 0.39583333333333
21971, 1.2, 0.275, 0.41666666666667
21972, 1.2, 0.2, 0.39583333333333
21973, 1.2, 0.225, 0.41666666666667
21974, 1.2, 0.175, 0.41666666666667
21975, 1.2, 1.3, 0.4375
21976, 1.2, 1.325, 0.45833333333333
21977, 1.2, 1.25, 0.4375
21978, 1.2, 1.275, 0.45833333333333
21979, 1.2, 1.2, 0.4375
21980, 1.2, 1.225, 0.45833333333333
21981, 1.2, 1.15, 0.4375
21982, 1.2, 1.175, 0.45833333333333
21983, 1.2, 1.1, 0.4375
21984, 1.2, 1.125, 0.45833333333333
21985, 1.2, 1.05, 0.4375
21986, 1.2, 1.075, 0.45833333333333
21987, 1.2, 1, 0.4375
21988, 1.2, 1.025, 0.45833333333333
21989, 1.2, 0.95, 0.4375
21990, 1.2, 0.975, 0.45833333333333
21991, 1.2, 0.9, 0.4375
21992, 1.2, 0.925, 0.45833333333333
21993, 1.2, 0.85, 0.4375
21994, 1.2, 0.875, 0.45833333333333
21995, 1.2, 0.8, 0.4375
21996, 1.2, 0.825, 0.45833333333333
21997, 1.2, 0.75, 0.4375
21998, 1.2, 0.775, 0.45833333333333
21999, 1.2, 0.7, 0.4375
22000, 1.2, 0.725, 0.45833333333333
22001, 1.2, 0.65, 0.4375
22002, 1.2, 0.675, 0.45833333333333
22003, 1.2, 0.6, 0.4375
22004, 1.2, 0.625, 0.45833333333333
22005, 1.2, 0.55, 0.4375
22006, 1.2, 0.575, 0.45833333333333
22007, 1.2, 0.5, 0.4375
22008, 1.2, 0.525, 0.45833333333333
22009, 1.2, 0.45, 0.4375
22010, 1.2, 0.475, 0.45833333333333
22011, 1.2, 0.4, 0.4375
22012, 1.2, 0.425, 0.45833333333333
22013, 1.2, 0.35, 0.4375
22014, 1.2, 0.375, 0.45833333333333
22015, 1.2, 0.3, 0.4375
22016, 1.2, 0.325, 0.45833333333333
22017, 1.2, 0.25, 0.4375
22018, 1.2, 0.275, 0.45833333333333
22019, 1.2, 0.2, 0.4375
22020, 1.2, 0.225, 0.45833333333333
22021, 1.2, 0.175, 0.45833333333333
22022, 1.2, 1.3, 0.47916666666667
22023, 1.2, 1.25, 0.47916666666667
22024, 1.2, 1.2, 0.47916666666667
22025, 1.2, 1.15, 0.47916666666667
22026, 1.2, 1.1, 0.47916666666667
22027, 1.2, 1.05, 0.47916666666667
22028, 1.2, 1, 0.47916666666667
22029, 1.2, 0.95, 0.47916666666667
22030, 1.2, 0.9, 0.47916666666667
22031, 1.2, 0.85, 0.47916666666667
22032, 1.2, 0.8, 0.47916666666667
22033, 1.2, 0.75, 0.47916666666667
22034, 1.2, 0.7, 0.47916666666667
22035, 1.2, 0.65, 0.47916666666667
22036, 1.2, 0.6, 0.47916666666667
22037, 1.2, 0.55, 0.47916666666667
22038, 1.2, 0.5, 0.47916666666667
22039, 1.2, 0.45, 0.47916666666667
22040, 1.2, 0.4, 0.47916666666667
22041, 1.2, 0.35, 0.47916666666667
22042, 1.2, 0.3, 0.47916666666667
22043, 1.2, 0.25, 0.47916666666667
22044, 1.2, 0.2, 0.47916666666667
22045, 2.2, 1.3, 0.041666666666667
22046, 2.2, 1.25, 0.041666666666667
22047, 2.2, 1.2, 0.041666666666667
22048, 2.2, 1.15, 0.041666666666667
22049, 2.2, 1.1, 0.041666666666667
22050, 2.2, 1.05, 0.041666666666667
22051, 2.2, 1, 0.041666666666667
22052, 2.2, 0.95, 0.041666666666667
22053, 2.2, 0.9, 0.041666666666667
22054, 2.2, 0.85, 0.041666666666667
22055, 2.2, 0.8, 0.041666666666667
22056, 2.2, 0.75, 0.041666666666667
22057, 2.2, 0.7, 0.041666666666667
22058, 2.2, 0.65, 0.041666666666667
22059, 2.2, 0.6, 0.041666666666667
22060, 2.2, 0.55, 0.041666666666667
22061, 2.2, 0.5, 0.041666666666667
22062, 2.2, 0.45, 0.041666666666667
22063, 2.2, 0.4, 0.041666666666667
22064, 2.2, 0.35, 0.041666666666667
22065, 2.2, 0.3, 0.041666666666667
22066, 2.2, 0.25, 0.041666666666667
22067, 2.2, 0.2, 0.041666666666667
22068, 2.2, 1.3, 0.083333333333333
22069, 2.2, 1.25, 0.083333333333333
22070, 2.2, 1.2, 0.083333333333333
22071, 2.2, 1.15, 0.083333333333333
22072, 2.2, 1.1, 0.083333333333333
22073, 2.2, 1.05, 0.083333333333333
22074, 2.2, 1, 0.083333333333333
22075, 2.2, 0.95, 0.083333333333333
22076, 2.2, 0.9, 0.083333333333333
22077, 2.2, 0.85, 0.083333333333333
22078, 2.2, 0.8, 0.083333333333333
22079, 2.2, 0.75, 0.083333333333333
22080, 2.2, 0.7, 0.083333333333333
22081, 2.2, 0.65, 0.083333333333333
22082, 2.2, 0.6, 0.083333333333333
22083, 2.2, 0.55, 0.083333333333333
22084, 2.2, 0.5, 0.083333333333333
22085, 2.2, 0.45, 0.083333333333333
22086, 2.2, 0.4, 0.083333333333333
22087, 2.2, 0.35, 0.083333333333333
22088, 2.2, 0.3, 0.083333333333333
22089, 2.2, 0.25, 0.083333333333333
22090, 2.2, 0.2, 0.083333333333333
22091, 2.2, 1.3, 0.125
22092, 2.2, 1.25, 0.125
22093, 2.2, 1.2, 0.125
22094, 2.2, 1.15, 0.125
22095, 2.2, 1.1, 0.125
22096, 2.2, 1.05, 0.125
22097, 2.2, 1, 0.125
22098, 2.2, 0.95, 0.125
22099, 2.2, 0.9, 0.125
22100, 2.2, 0.85, 0.125
22101, 2.2, 0.8, 0.125
22102, 2.2, 0.75, 0.125
22103, 2.2, 0.7, 0.125
22104, 2.2, 0.65, 0.125
22105, 2.2, 0.6, 0.125
22106, 2.2, 0.55, 0.125
22107, 2.2, 0.5, 0.125
22108, 2.2, 0.45, 0.125
22109, 2.2, 0.4, 0.125
22110, 2.2, 0.35, 0.125
22111, 2.2, 0.3, 0.125
22112, 2.2, 0.25, 0.125
22113, 2.2, 0.2, 0.125
22114, 2.2, 1.3, 0.16666666666667
22115, 2.2, 1.25, 0.16666666666667
22116, 2.2, 1.2, 0.16666666666667
22117, 2.2, 1.15, 0.16666666666667
22118, 2.2, 1.1, 0.16666666666667
22119, 2.2, 1.05, 0.16666666666667
22120, 2.2, 1, 0.16666666666667
22121, 2.2, 0.95, 0.16666666666667
22122, 2.2, 0.9, 0.16666666666667
22123, 2.2, 0.85, 0.16666666666667
22124, 2.2, 0.8, 0.16666666666667
22125, 2.2, 0.75, 0.16666666666667
22126, 2.2, 0.7, 0.16666666666667
22127, 2.2, 0.65, 0.16666666666667
22128, 2.2, 0.6, 0.16666666666667
22129, 2.2, 0.55, 0.16666666666667
22130, 2.2, 0.5, 0.16666666666667
22131, 2.2, 0.45, 0.16666666666667
22132, 2.2, 0.4, 0.16666666666667
22133, 2.2, 0.35, 0.16666666666667
22134, 2.2, 0.3, 0.16666666666667
22135, 2.2, 0.25, 0.16666666666667
22136, 2.2, 0.2, 0.16666666666667
22137, 2.2, 1.3, 0.20833333333333
22138, 2.2, 1.25, 0.20833333333333
22139, 2.2, 1.2, 0.20833333333333
22140, 2.2, 1.15, 0.20833333333333
22141, 2.2, 1.1, 0.20833333333333
22142, 2.2, 1.05, 0.20833333333333
22143, 2.2, 1, 0.20833333333333
22144, 2.2, 0.95, 0.20833333333333
22145, 2.2, 0.9, 0.20833333333333
22146, 2.2, 0.85, 0.20833333333333
22147, 2.2, 0.8, 0.20833333333333
22148, 2.2, 0.75, 0.20833333333333
22149, 2.2, 0.7, 0.20833333333333
22150, 2.2, 0.65, 0.20833333333333
22151, 2.2, 0.6, 0.20833333333333
22152, 2.2, 0.55, 0.20833333333333
22153, 2.2, 0.5, 0.20833333333333
22154, 2.2, 0.45, 0.20833333333333
22155, 2.2, 0.4, 0.20833333333333
22156, 2.2, 0.35, 0.20833333333333
22157, 2.2, 0.3, 0.20833333333333
22158, 2.2, 0.25, 0.20833333333333
22159, 2.2, 0.2, 0.20833333333333
22160, 2.2, 1.3, 0.25
22161, 2.2, 1.25, 0.25
22162, 2.2, 1.2, 0.25
22163, 2.2, 1.15, 0.25
22164, 2.2, 1.1, 0.25
22165, 2.2, 1.05, 0.25
22166, 2.2, 1, 0.25
22167, 2.2, 0.95, 0.25
22168, 2.2, 0.9, 0.25
22169, 2.2, 0.85, 0.25
22170, 2.2, 0.8, 0.25
22171, 2.2, 0.75, 0.25
22172, 2.2, 0.7, 0.25
22173, 2.2, 0.65, 0.25
22174, 2.2, 0.6, 0.25
22175, 2.2, 0.55, 0.25
22176, 2.2, 0.5, 0.25
22177, 2.2, 0.45, 0.25
22178, 2.2, 0.4, 0.25
22179, 2.2, 0.35, 0.25
22180, 2.2, 0.3, 0.25
22181, 2.2, 0.25, 0.25
22182, 2.2, 0.2, 0.25
22183, 2.2, 1.3, 0.29166666666667
22184, 2.2, 1.25, 0.29166666666667
22185, 2.2, 1.2, 0.29166666666667
22186, 2.2, 1.15, 0.29166666666667
22187, 2.2, 1.1, 0.29166666666667
22188, 2.2, 1.05, 0.29166666666667
22189, 2.2, 1, 0.29166666666667
22190, 2.2, 0.95, 0.29166666666667
22191, 2.2, 0.9, 0.29166666666667
22192, 2.2, 0.85, 0.29166666666667
22193, 2.2, 0.8, 0.29166666666667
22194, 2.2, 0.75, 0.29166666666667
22195, 2.2, 0.7, 0.29166666666667
22196, 2.2, 0.65, 0.29166666666667
22197, 2.2, 0.6, 0.29166666666667
22198, 2.2, 0.55, 0.29166666666667
22199, 2.2, 0.5, 0.29166666666667
22200, 2.2, 0.45, 0.29166666666667
22201, 2.2, 0.4, 0.29166666666667
22202, 2.2, 0.35, 0.29166666666667
22203, 2.2, 0.3, 0.29166666666667
22204, 2.2, 0.25, 0.29166666666667
22205, 2.2, 0.2, 0.29166666666667
22206, 2.2, 1.3, 0.33333333333333
22207, 2.2, 1.25, 0.33333333333333
22208, 2.2, 1.2, 0.33333333333333
22209, 2.2, 1.15, 0.33333333333333
22210, 2.2, 1.1, 0.33333333333333
22211, 2.2, 1.05, 0.33333333333333
22212, 2.2, 1, 0.33333333333333
22213, 2.2, 0.95, 0.33333333333333
22214, 2.2, 0.9, 0.33333333333333
22215, 2.2, 0.85, 0.33333333333333
22216, 2.2, 0.8, 0.33333333333333
22217, 2.2, 0.75, 0.33333333333333
22218, 2.2, 0.7, 0.33333333333333
22219, 2.2, 0.65, 0.33333333333333
22220, 2.2, 0.6, 0.33333333333333
22221, 2.2, 0.55, 0.33333333333333
22222, 2.2, 0.5, 0.33333333333333
22223, 2.2, 0.45, 0.33333333333333
22224, 2.2, 0.4, 0.33333333333333
22225, 2.2, 0.35, 0.33333333333333
22226, 2.2, 0.3, 0.33333333333333
22227, 2.2, 0.25, 0.33333333333333
22228, 2.2, 0.2, 0.33333333333333
22229, 2.2, 1.3, 0.375
22230, 2.2, 1.25, 0.375
22231, 2.2, 1.2, 0.375
22232, 2.2, 1.15, 0.375
22233, 2.2, 1.1, 0.375
22234, 2.2, 1.05, 0.375
22235, 2.2, 1, 0.375
22236, 2.2, 0.95, 0.375
22237, 2.2, 0.9, 0.375
22238, 2.2, 0.85, 0.375
22239, 2.2, 0.8, 0.375
22240, 2.2, 0.75, 0.375
22241, 2.2, 0.7, 0.375
22242, 2.2, 0.65, 0.375
22243, 2.2, 0.6, 0.375
22244, 2.2, 0.55, 0.375
22245, 2.2, 0.5, 0.375
22246, 2.2, 0.45, 0.375
22247, 2.2, 0.4, 0.375
22248, 2.2, 0.35, 0.375
22249, 2.2, 0.3, 0.375
22250, 2.2, 0.25, 0.375
22251, 2.2, 0.2, 0.375
22252, 2.2, 1.3, 0.41666666666667
22253, 2.2, 1.25, 0.41666666666667
22254, 2.2, 1.2, 0.41666666666667
22255, 2.2, 1.15, 0.41666666666667
22256, 2.2, 1.1, 0.41666666666667
22257, 2.2, 1.05, 0.41666666666667
22258, 2.2, 1, 0.41666666666667
22259, 2.2, 0.95, 0.41666666666667
22260, 2.2, 0.9, 0.41666666666667
22261, 2.2, 0.85, 0.41666666666667
22262, 2.2, 0.8, 0.41666666666667
22263, 2.2, 0.75, 0.41666666666667
22264, 2.2, 0.7, 0.41666666666667
22265, 2.2, 0.65, 0.41666666666667
22266, 2.2, 0.6, 0.41666666666667
22267, 2.2, 0.55, 0.41666666666667
22268, 2.2, 0.5, 0.41666666666667
22269, 2.2, 0.45, 0.41666666666667
22270, 2.2, 0.4, 0.41666666666667
22271, 2.2, 0.35, 0.41666666666667
22272, 2.2, 0.3, 0.41666666666667
22273, 2.2, 0.25, 0.41666666666667
22274, 2.2, 0.2, 0.41666666666667
22275, 2.2, 1.3, 0.45833333333333
22276, 2.2, 1.25, 0.45833333333333
22277, 2.2, 1.2, 0.45833333333333
22278, 2.2, 1.15, 0.45833333333333
22279, 2.2, 1.1, 0.45833333333333
22280, 2.2, 1.05, 0.45833333333333
22281, 2.2, 1, 0.45833333333333
22282, 2.2, 0.95, 0.45833333333333
22283, 2.2, 0.9, 0.45833333333333
22284, 2.2, 0.85, 0.45833333333333
22285, 2.2, 0.8, 0.45833333333333
22286, 2.2, 0.75, 0.45833333333333
22287, 2.2, 0.7, 0.45833333333333
22288, 2.2, 0.65, 0.45833333333333
22289, 2.2, 0.6, 0.45833333333333
22290, 2.2, 0.55, 0.45833333333333
22291, 2.2, 0.5, 0.45833333333333
22292, 2.2, 0.45, 0.45833333333333
22293, 2.2, 0.4, 0.45833333333333
22294, 2.2, 0.35, 0.45833333333333
22295, 2.2, 0.3, 0.45833333333333
22296, 2.2, 0.25, 0.45833333333333
22297, 2.2, 0.2, 0.45833333333333
22298, 2.2, 1.325, 0.041666666666667
22299, 2.2, 1.3, 0.020833333333333
22300, 2.2, 1.275, 0.041666666666667
22301, 2.2, 1.25, 0.020833333333333
22302, 2.2, 1.225, 0.041666666666667
22303, 2.2, 1.2, 0.020833333333333
22304, 2.2, 1.175, 0.041666666666667
22305, 2.2, 1.15, 0.020833333333333
22306, 2.2, 1.125, 0.041666666666667
22307, 2.2, 1.1, 0.020833333333333
22308, 2.2, 1.075, 0.041666666666667
22309, 2.2, 1.05, 0.020833333333333
22310, 2.2, 1.025, 0.041666666666667
22311, 2.2, 1, 0.020833333333333
22312, 2.2, 0.975, 0.041666666666667
22313, 2.2, 0.95, 0.020833333333333
22314, 2.2, 0.925, 0.041666666666667
22315, 2.2, 0.9, 0.020833333333333
22316, 2.2, 0.875, 0.041666666666667
22317, 2.2, 0.85, 0.020833333333333
22318, 2.2, 0.825, 0.041666666666667
22319, 2.2, 0.8, 0.020833333333333
22320, 2.2, 0.775, 0.041666666666667
22321, 2.2, 0.75, 0.020833333333333
22322, 2.2, 0.725, 0.041666666666667
22323, 2.2, 0.7, 0.020833333333333
22324, 2.2, 0.675, 0.041666666666667
22325, 2.2, 0.65, 0.020833333333333
22326, 2.2, 0.625, 0.041666666666667
22327, 2.2, 0.6, 0.020833333333333
22328, 2.2, 0.575, 0.041666666666667
22329, 2.2, 0.55, 0.020833333333333
22330, 2.2, 0.525, 0.041666666666667
22331, 2.2, 0.5, 0.020833333333333
22332, 2.2, 0.475, 0.041666666666667
22333, 2.2, 0.45, 0.020833333333333
22334, 2.2, 0.425, 0.041666666666667
22335, 2.2, 0.4, 0.020833333333333
22336, 2.2, 0.375, 0.041666666666667
22337, 2.2, 0.35, 0.020833333333333
22338, 2.2, 0.325, 0.041666666666667
22339, 2.2, 0.3, 0.020833333333333
22340, 2.2, 0.275, 0.041666666666667
22341, 2.2, 0.25, 0.020833333333333
22342, 2.2, 0.225, 0.041666666666667
22343, 2.2, 0.2, 0.020833333333333
22344, 2.2, 0.175, 0.041666666666667
22345, 2.2, 1.325, 0.083333333333333
22346, 2.2, 1.3, 0.0625
22347, 2.2, 1.275, 0.083333333333333
22348, 2.2, 1.25, 0.0625
22349, 2.2, 1.225, 0.083333333333333
22350, 2.2, 1.2, 0.0625
22351, 2.2, 1.175, 0.083333333333333
22352, 2.2, 1.15, 0.0625
22353, 2.2, 1.125, 0.083333333333333
22354, 2.2, 1.1, 0.0625
22355, 2.2, 1.075, 0.083333333333333
22356, 2.2, 1.05, 0.0625
22357, 2.2, 1.025, 0.083333333333333
22358, 2.2, 1, 0.0625
22359, 2.2, 0.975, 0.083333333333333
22360, 2.2, 0.95, 0.0625
22361, 2.2, 0.925, 0.083333333333333
22362, 2.2, 0.9, 0.0625
22363, 2.2, 0.875, 0.083333333333333
22364, 2.2, 0.85, 0.0625
22365, 2.2, 0.825, 0.083333333333333
22366, 2.2, 0.8, 0.0625
22367, 2.2, 0.775, 0.083333333333333
22368, 2.2, 0.75, 0.0625
22369, 2.2, 0.725, 0.083333333333333
22370, 2.2, 0.7, 0.0625
22371, 2.2, 0.675, 0.083333333333333
22372, 2.2, 0.65, 0.0625
22373, 2.2, 0.625, 0.083333333333333
22374, 2.2, 0.6, 0.0625
22375, 2.2, 0.575, 0.083333333333333
22376, 2.2, 0.55, 0.0625
22377, 2.2, 0.525, 0.083333333333333
22378, 2.2, 0.5, 0.0625
22379, 2.2, 0.475, 0.083333333333333
22380, 2.2, 0.45, 0.0625
22381, 2.2, 0.425, 0.083333333333333
22382, 2.2, 0.4, 0.0625
22383, 2.2, 0.375, 0.083333333333333
22384, 2.2, 0.35, 0.0625
22385, 2.2, 0.325, 0.083333333333333
22386, 2.2, 0.3, 0.0625
22387, 2.2, 0.275, 0.083333333333333
22388, 2.2, 0.25, 0.0625
22389, 2.2, 0.225, 0.083333333333333
22390, 2.2, 0.2, 0.0625
22391, 2.2, 0.175, 0.083333333333333
22392, 2.2, 1.325, 0.125
22393, 2.2, 1.3, 0.10416666666667
22394, 2.2, 1.275, 0.125
22395, 2.2, 1.25, 0.10416666666667
22396, 2.2, 1.225, 0.125
22397, 2.2, 1.2, 0.10416666666667
22398, 2.2, 1.175, 0.125
22399, 2.2, 1.15, 0.10416666666667
22400, 2.2, 1.125, 0.125
22401, 2.2, 1.1, 0.10416666666667
22402, 2.2, 1.075, 0.125
22403, 2.2, 1.05, 0.10416666666667
22404, 2.2, 1.025, 0.125
22405, 2.2, 1, 0.10416666666667
22406, 2.2, 0.975, 0.125
22407, 2.2, 0.95, 0.10416666666667
22408, 2.2, 0.925, 0.125
22409, 2.2, 0.9, 0.10416666666667
22410, 2.2, 0.875, 0.125
22411, 2.2, 0.85, 0.10416666666667
22412, 2.2, 0.825, 0.125
22413, 2.2, 0.8, 0.10416666666667
22414, 2.2, 0.775, 0.125
22415, 2.2, 0.75, 0.10416666666667
22416, 2.2, 0.725, 0.125
22417, 2.2, 0.7, 0.10416666666667
22418, 2.2, 0.675, 0.125
22419, 2.2, 0.65, 0.10416666666667
22420, 2.2, 0.625, 0.125
22421, 2.2, 0.6, 0.10416666666667
22422, 2.2, 0.575, 0.125
22423, 2.2, 0.55, 0.10416666666667
22424, 2.2, 0.525, 0.125
22425, 2.2, 0.5, 0.10416666666667
22426, 2.2, 0.475, 0.125
22427, 2.2, 0.45, 0.10416666666667
22428, 2.2, 0.425, 0.125
22429, 2.2, 0.4, 0.10416666666667
22430, 2.2, 0.375, 0.125
22431, 2.2, 0.35, 0.10416666666667
22432, 2.2, 0.325, 0.125
22433, 2.2, 0.3, 0.10416666666667
22434, 2.2, 0.275, 0.125
22435, 2.2, 0.25, 0.10416666666667
22436, 2.2, 0.225, 0.125
22437, 2.2, 0.2, 0.10416666666667
22438, 2.2, 0.175, 0.125
22439, 2.2, 1.325, 0.16666666666667
22440, 2.2, 1.3, 0.14583333333333
22441, 2.2, 1.275, 0.16666666666667
22442, 2.2, 1.25, 0.14583333333333
22443, 2.2, 1.225, 0.16666666666667
22444, 2.2, 1.2, 0.14583333333333
22445, 2.2, 1.175, 0.16666666666667
22446, 2.2, 1.15, 0.14583333333333
22447, 2.2, 1.125, 0.16666666666667
22448, 2.2, 1.1, 0.14583333333333
22449, 2.2, 1.075, 0.16666666666667
22450, 2.2, 1.05, 0.14583333333333
22451, 2.2, 1.025, 0.16666666666667
22452, 2.2, 1, 0.14583333333333
22453, 2.2, 0.975, 0.16666666666667
22454, 2.2, 0.95, 0.14583333333333
22455, 2.2, 0.925, 0.16666666666667
22456, 2.2, 0.9, 0.14583333333333
22457, 2.2, 0.875, 0.16666666666667
22458, 2.2, 0.85, 0.14583333333333
22459, 2.2, 0.825, 0.16666666666667
22460, 2.2, 0.8, 0.14583333333333
22461, 2.2, 0.775, 0.16666666666667
22462, 2.2, 0.75, 0.14583333333333
22463, 2.2, 0.725, 0.16666666666667
22464, 2.2, 0.7, 0.14583333333333
22465, 2.2, 0.675, 0.16666666666667
22466, 2.2, 0.65, 0.14583333333333
22467, 2.2, 0.625, 0.16666666666667
22468, 2.2, 0.6, 0.14583333333333
22469, 2.2, 0.575, 0.16666666666667
22470, 2.2, 0.55, 0.14583333333333
22471, 2.2, 0.525, 0.16666666666667
22472, 2.2, 0.5, 0.14583333333333
22473, 2.2, 0.475, 0.16666666666667
22474, 2.2, 0.45, 0.14583333333333
22475, 2.2, 0.425, 0.16666666666667
22476, 2.2, 0.4, 0.14583333333333
22477, 2.2, 0.375, 0.16666666666667
22478, 2.2, 0.35, 0.14583333333333
22479, 2.2, 0.325, 0.16666666666667
22480, 2.2, 0.3, 0.14583333333333
22481, 2.2, 0.275, 0.16666666666667
22482, 2.2, 0.25, 0.14583333333333
22483, 2.2, 0.225, 0.16666666666667
22484, 2.2, 0.2, 0.14583333333333
22485, 2.2, 0.175, 0.16666666666667
22486, 2.2, 1.325, 0.20833333333333
22487, 2.2, 1.3, 0.1875
22488, 2.2, 1.275, 0.20833333333333
22489, 2.2, 1.25, 0.1875
22490, 2.2, 1.225, 0.20833333333333
22491, 2.2, 1.2, 0.1875
22492, 2.2, 1.175, 0.20833333333333
22493, 2.2, 1.15, 0.1875
22494, 2.2, 1.125, 0.20833333333333
22495, 2.2, 1.1, 0.1875
22496, 2.2, 1.075, 0.20833333333333
22497, 2.2, 1.05, 0.1875
22498, 2.2, 1.025, 0.20833333333333
22499, 2.2, 1, 0.1875
22500, 2.2, 0.975, 0.20833333333333
22501, 2.2, 0.95, 0.1875
22502, 2.2, 0.925, 0.20833333333333
22503, 2.2, 0.9, 0.1875
22504, 2.2, 0.875, 0.20833333333333
22505, 2.2, 0.85, 0.1875
22506, 2.2, 0.825, 0.20833333333333
22507, 2.2, 0.8, 0.1875
22508, 2.2, 0.775, 0.20833333333333
22509, 2.2, 0.75, 0.1875
22510, 2.2, 0.725, 0.20833333333333
22511, 2.2, 0.7, 0.1875
22512, 2.2, 0.675, 0.20833333333333
22513, 2.2, 0.65, 0.1875
22514, 2.2, 0.625, 0.20833333333333
22515, 2.2, 0.6, 0.1875
22516, 2.2, 0.575, 0.20833333333333
22517, 2.2, 0.55, 0.1875
22518, 2.2, 0.525, 0.20833333333333
22519, 2.2, 0.5, 0.1875
22520, 2.2, 0.475, 0.20833333333333
22521, 2.2, 0.45, 0.1875
22522, 2.2, 0.425, 0.20833333333333
22523, 2.2, 0.4, 0.1875
22524, 2.2, 0.375, 0.20833333333333
22525, 2.2, 0.35, 0.1875
22526, 2.2, 0.325, 0.20833333333333
22527, 2.2, 0.3, 0.1875
22528, 2.2, 0.275, 0.20833333333333
22529, 2.2, 0.25, 0.1875
22530, 2.2, 0.225, 0.20833333333333
22531, 2.2, 0.2, 0.1875
22532, 2.2, 0.175, 0.20833333333333
22533, 2.2, 1.325, 0.25
22534, 2.2, 1.3, 0.22916666666667
22535, 2.2, 1.275, 0.25
22536, 2.2, 1.25, 0.22916666666667
22537, 2.2, 1.225, 0.25
22538, 2.2, 1.2, 0.22916666666667
22539, 2.2, 1.175, 0.25
22540, 2.2, 1.15, 0.22916666666667
22541, 2.2, 1.125, 0.25
22542, 2.2, 1.1, 0.22916666666667
22543, 2.2, 1.075, 0.25
22544, 2.2, 1.05, 0.22916666666667
22545, 2.2, 1.025, 0.25
22546, 2.2, 1, 0.22916666666667
22547, 2.2, 0.975, 0.25
22548, 2.2, 0.95, 0.22916666666667
22549, 2.2, 0.925, 0.25
22550, 2.2, 0.9, 0.22916666666667
22551, 2.2, 0.875, 0.25
22552, 2.2, 0.85, 0.22916666666667
22553, 2.2, 0.825, 0.25
22554, 2.2, 0.8, 0.22916666666667
22555, 2.2, 0.775, 0.25
22556, 2.2, 0.75, 0.22916666666667
22557, 2.2, 0.725, 0.25
22558, 2.2, 0.7, 0.22916666666667
22559, 2.2, 0.675, 0.25
22560, 2.2, 0.65, 0.22916666666667
22561, 2.2, 0.625, 0.25
22562, 2.2, 0.6, 0.22916666666667
22563, 2.2, 0.575, 0.25
22564, 2.2, 0.55, 0.22916666666667
22565, 2.2, 0.525, 0.25
22566, 2.2, 0.5, 0.22916666666667
22567, 2.2, 0.475, 0.25
22568, 2.2, 0.45, 0.22916666666667
22569, 2.2, 0.425, 0.25
22570, 2.2, 0.4, 0.22916666666667
22571, 2.2, 0.375, 0.25
22572, 2.2, 0.35, 0.22916666666667
22573, 2.2, 0.325, 0.25
22574, 2.2, 0.3, 0.22916666666667
22575, 2.2, 0.275, 0.25
22576, 2.2, 0.25, 0.22916666666667
22577, 2.2, 0.225, 0.25
22578, 2.2, 0.2, 0.22916666666667
22579, 2.2, 0.175, 0.25
22580, 2.2, 1.325, 0.29166666666667
22581, 2.2, 1.3, 0.27083333333333
22582, 2.2, 1.275, 0.29166666666667
22583, 2.2, 1.25, 0.27083333333333
22584, 2.2, 1.225, 0.29166666666667
22585, 2.2, 1.2, 0.27083333333333
22586, 2.2, 1.175, 0.29166666666667
22587, 2.2, 1.15, 0.27083333333333
22588, 2.2, 1.125, 0.29166666666667
22589, 2.2, 1.1, 0.27083333333333
22590, 2.2, 1.075, 0.29166666666667
22591, 2.2, 1.05, 0.27083333333333
22592, 2.2, 1.025, 0.29166666666667
22593, 2.2, 1, 0.27083333333333
22594, 2.2, 0.975, 0.29166666666667
22595, 2.2, 0.95, 0.27083333333333
22596, 2.2, 0.925, 0.29166666666667
22597, 2.2, 0.9, 0.27083333333333
22598, 2.2, 0.875, 0.29166666666667
22599, 2.2, 0.85, 0.27083333333333
22600, 2.2, 0.825, 0.29166666666667
22601, 2.2, 0.8, 0.27083333333333
22602, 2.2, 0.775, 0.29166666666667
22603, 2.2, 0.75, 0.27083333333333
22604, 2.2, 0.725, 0.29166666666667
22605, 2.2, 0.7, 0.27083333333333
22606, 2.2, 0.675, 0.29166666666667
22607, 2.2, 0.65, 0.27083333333333
22608, 2.2, 0.625, 0.29166666666667
22609, 2.2, 0.6, 0.27083333333333
22610, 2.2, 0.575, 0.29166666666667
22611, 2.2, 0.55, 0.27083333333333
22612, 2.2, 0.525, 0.29166666666667
22613, 2.2, 0.5, 0.27083333333333
22614, 2.2, 0.475, 0.29166666666667
22615, 2.2, 0.45, 0.27083333333333
22616, 2.2, 0.425, 0.29166666666667
22617, 2.2, 0.4, 0.27083333333333
22618, 2.2, 0.375, 0.29166666666667
22619, 2.2, 0.35, 0.27083333333333
22620, 2.2, 0.325, 0.29166666666667
22621, 2.2, 0.3, 0.27083333333333
22622, 2.2, 0.275, 0.29166666666667
22623, 2.2, 0.25, 0.27083333333333
22624, 2.2, 0.225, 0.29166666666667
22625, 2.2, 0.2, 0.27083333333333
22626, 2.2, 0.175, 0.29166666666667
22627, 2.2, 1.325, 0.33333333333333
22628, 2.2, 1.3, 0.3125
22629, 2.2, 1.275, 0.33333333333333
22630, 2.2, 1.25, 0.3125
22631, 2.2, 1.225, 0.33333333333333
22632, 2.2, 1.2, 0.3125
22633, 2.2, 1.175, 0.33333333333333
22634, 2.2, 1.15, 0.3125
22635, 2.2, 1.125, 0.33333333333333
22636, 2.2, 1.1, 0.3125
22637, 2.2, 1.075, 0.33333333333333
22638, 2.2, 1.05, 0.3125
22639, 2.2, 1.025, 0.33333333333333
22640, 2.2, 1, 0.3125
22641, 2.2, 0.975, 0.33333333333333
22642, 2.2, 0.95, 0.3125
22643, 2.2, 0.925, 0.33333333333333
22644, 2.2, 0.9, 0.3125
22645, 2.2, 0.875, 0.33333333333333
22646, 2.2, 0.85, 0.3125
22647, 2.2, 0.825, 0.33333333333333
22648, 2.2, 0.8, 0.3125
22649, 2.2, 0.775, 0.33333333333333
22650, 2.2, 0.75, 0.3125
22651, 2.2, 0.725, 0.33333333333333
22652, 2.2, 0.7, 0.3125
22653, 2.2, 0.675, 0.33333333333333
22654, 2.2, 0.65, 0.3125
22655, 2.2, 0.625, 0.33333333333333
22656, 2.2, 0.6, 0.3125
22657, 2.2, 0.575, 0.33333333333333
22658, 2.2, 0.55, 0.3125
22659, 2.2, 0.525, 0.33333333333333
22660, 2.2, 0.5, 0.3125
22661, 2.2, 0.475, 0.33333333333333
22662, 2.2, 0.45, 0.3125
22663, 2.2, 0.425, 0.33333333333333
22664, 2.2, 0.4, 0.3125
22665, 2.2, 0.375, 0.33333333333333
22666, 2.2, 0.35, 0.3125
22667, 2.2, 0.325, 0.33333333333333
22668, 2.2, 0.3, 0.3125
22669, 2.2, 0.275, 0.33333333333333
22670, 2.2, 0.25, 0.3125
22671, 2.2, 0.225, 0.33333333333333
22672, 2.2, 0.2, 0.3125
22673, 2.2, 0.175, 0.33333333333333
22674, 2.2, 1.325, 0.375
22675, 2.2, 1.3, 0.35416666666667
22676, 2.2, 1.275, 0.375
22677, 2.2, 1.25, 0.35416666666667
22678, 2.2, 1.225, 0.375
22679, 2.2, 1.2, 0.35416666666667
22680, 2.2, 1.175, 0.375
22681, 2.2, 1.15, 0.35416666666667
22682, 2.2, 1.125, 0.375
22683, 2.2, 1.1, 0.35416666666667
22684, 2.2, 1.075, 0.375
22685, 2.2, 1.05, 0.35416666666667
22686, 2.2, 1.025, 0.375
22687, 2.2, 1, 0.35416666666667
22688, 2.2, 0.975, 0.375
22689, 2.2, 0.95, 0.35416666666667
22690, 2.2, 0.925, 0.375
22691, 2.2, 0.9, 0.35416666666667
22692, 2.2, 0.875, 0.375
22693, 2.2, 0.85, 0.35416666666667
22694, 2.2, 0.825, 0.375
22695, 2.2, 0.8, 0.35416666666667
22696, 2.2, 0.775, 0.375
22697, 2.2, 0.75, 0.35416666666667
22698, 2.2, 0.725, 0.375
22699, 2.2, 0.7, 0.35416666666667
22700, 2.2, 0.675, 0.375
22701, 2.2, 0.65, 0.35416666666667
22702, 2.2, 0.625, 0.375
22703, 2.2, 0.6, 0.35416666666667
22704, 2.2, 0.575, 0.375
22705, 2.2, 0.55, 0.35416666666667
22706, 2.2, 0.525, 0.375
22707, 2.2, 0.5, 0.35416666666667
22708, 2.2, 0.475, 0.375
22709, 2.2, 0.45, 0.35416666666667
22710, 2.2, 0.425, 0.375
22711, 2.2, 0.4, 0.35416666666667
22712, 2.2, 0.375, 0.375
22713, 2.2, 0.35, 0.35416666666667
22714, 2.2, 0.325, 0.375
22715, 2.2, 0.3, 0.35416666666667
22716, 2.2, 0.275, 0.375
22717, 2.2, 0.25, 0.35416666666667
22718, 2.2, 0.225, 0.375
22719, 2.2, 0.2, 0.35416666666667
22720, 2.2, 0.175, 0.375
22721, 2.2, 1.325, 0.41666666666667
22722, 2.2, 1.3, 0.39583333333333
22723, 2.2, 1.275, 0.41666666666667
22724, 2.2, 1.25, 0.39583333333333
22725, 2.2, 1.225, 0.41666666666667
22726, 2.2, 1.2, 0.39583333333333
22727, 2.2, 1.175, 0.41666666666667
22728, 2.2, 1.15, 0.39583333333333
22729, 2.2, 1.125, 0.41666666666667
22730, 2.2, 1.1, 0.39583333333333
22731, 2.2, 1.075, 0.41666666666667
22732, 2.2, 1.05, 0.39583333333333
22733, 2.2, 1.025, 0.41666666666667
22734, 2.2, 1, 0.39583333333333
22735, 2.2, 0.975, 0.41666666666667
22736, 2.2, 0.95, 0.39583333333333
22737, 2.2, 0.925, 0.41666666666667
22738, 2.2, 0.9, 0.39583333333333
22739, 2.2, 0.875, 0.41666666666667
22740, 2.2, 0.85, 0.39583333333333
22741, 2.2, 0.825, 0.41666666666667
22742, 2.2, 0.8, 0.39583333333333
22743, 2.2, 0.775, 0.41666666666667
22744, 2.2, 0.75, 0.39583333333333
22745, 2.2, 0.725, 0.41666666666667
22746, 2.2, 0.7, 0.39583333333333
22747, 2.2, 0.675, 0.41666666666667
22748, 2.2, 0.65, 0.39583333333333
22749, 2.2, 0.625, 0.41666666666667
22750, 2.2, 0.6, 0.39583333333333
22751, 2.2, 0.575, 0.41666666666667
22752, 2.2, 0.55, 0.39583333333333
22753, 2.2, 0.525, 0.41666666666667
22754, 2.2, 0.5, 0.39583333333333
22755, 2.2, 0.475, 0.41666666666667
22756, 2.2, 0.45, 0.39583333333333
22757, 2.2, 0.425, 0.41666666666667
22758, 2.2, 0.4, 0.39583333333333
22759, 2.2, 0.375, 0.41666666666667
22760, 2.2, 0.35, 0.39583333333333
22761, 2.2, 0.325, 0.41666666666667
22762, 2.2, 0.3, 0.39583333333333
22763, 2.2, 0.275, 0.41666666666667
22764, 2.2, 0.25, 0.39583333333333
22765, 2.2, 0.225, 0.41666666666667
22766, 2.2, 0.2, 0.39583333333333
22767, 2.2, 0.175, 0.41666666666667
22768, 2.2, 1.325, 0.45833333333333
22769, 2.2, 1.3, 0.4375
22770, 2.2, 1.275, 0.45833333333333
22771, 2.2, 1.25, 0.4375
22772, 2.2, 1.225, 0.45833333333333
22773, 2.2, 1.2, 0.4375
22774, 2.2, 1.175, 0.45833333333333
22775, 2.2, 1.15, 0.4375
22776, 2.2, 1.125, 0.45833333333333
22777, 2.2, 1.1, 0.4375
22778, 2.2, 1.075, 0.45833333333333
22779, 2.2, 1.05, 0.4375
22780, 2.2, 1.025, 0.45833333333333
22781, 2.2, 1, 0.4375
22782, 2.2, 0.975, 0.45833333333333
22783, 2.2, 0.95, 0.4375
22784, 2.2, 0.925, 0.45833333333333
22785, 2.2, 0.9, 0.4375
22786, 2.2, 0.875, 0.45833333333333
22787, 2.2, 0.85, 0.4375
22788, 2.2, 0.825, 0.45833333333333
22789, 2.2, 0.8, 0.4375
22790, 2.2, 0.775, 0.45833333333333
22791, 2.2, 0.75, 0.4375
22792, 2.2, 0.725, 0.45833333333333
22793, 2.2, 0.7, 0.4375
22794, 2.2, 0.675, 0.45833333333333
22795, 2.2, 0.65, 0.4375
22796, 2.2, 0.625, 0.45833333333333
22797, 2.2, 0.6, 0.4375
22798, 2.2, 0.575, 0.45833333333333
22799, 2.2, 0.55, 0.4375
22800, 2.2, 0.525, 0.45833333333333
22801, 2.2, 0.5, 0.4375
22802, 2.2, 0.475, 0.45833333333333
22803, 2.2, 0.45, 0.4375
22804, 2.2, 0.425, 0.45833333333333
22805, 2.2, 0.4, 0.4375
22806, 2.2, 0.375, 0.45833333333333
22807, 2.2, 0.35, 0.4375
22808, 2.2, 0.325, 0.45833333333333
22809, 2.2, 0.3, 0.4375
22810, 2.2, 0.275, 0.45833333333333
22811, 2.2, 0.25, 0.4375
22812, 2.2, 0.225, 0.45833333333333
22813, 2.2, 0.2, 0.4375
22814, 2.2, 0.175, 0.45833333333333
22815, 2.2, 1.3, 0.47916666666667
22816, 2.2, 1.25, 0.47916666666667
22817, 2.2, 1.2, 0.47916666666667
22818, 2.2, 1.15, 0.47916666666667
22819, 2.2, 1.1, 0.47916666666667
22820, 2.2, 1.05, 0.47916666666667
22821, 2.2, 1, 0.47916666666667
22822, 2.2, 0.95, 0.47916666666667
22823, 2.2, 0.9, 0.47916666666667
22824, 2.2, 0.85, 0.47916666666667
22825, 2.2, 0.8, 0.47916666666667
22826, 2.2, 0.75, 0.47916666666667
22827, 2.2, 0.7, 0.47916666666667
22828, 2.2, 0.65, 0.47916666666667
22829, 2.2, 0.6, 0.47916666666667
22830, 2.2, 0.55, 0.47916666666667
22831, 2.2, 0.5, 0.47916666666667
22832, 2.2, 0.45, 0.47916666666667
22833, 2.2, 0.4, 0.47916666666667
22834, 2.2, 0.35, 0.47916666666667
22835, 2.2, 0.3, 0.47916666666667
22836, 2.2, 0.25, 0.47916666666667
22837, 2.2, 0.2, 0.47916666666667
22838, 1.2416666666667, 0.15, 0.041666666666667
22839, 1.2833333333333, 0.15, 0.041666666666667
22840, 1.325, 0.15, 0.041666666666667
22841, 1.3666666666667, 0.15, 0.041666666666667
22842, 1.4083333333333, 0.15, 0.041666666666667
22843, 1.45, 0.15, 0.041666666666667
22844, 1.4916666666667, 0.15, 0.041666666666667
22845, 1.5333333333333, 0.15, 0.041666666666667
22846, 1.575, 0.15, 0.041666666666667
22847, 1.6166666666667, 0.15, 0.041666666666667
22848, 1.6583333333333, 0.15, 0.041666666666667
22849, 1.7, 0.15, 0.041666666666667
22850, 1.7416666666667, 0.15, 0.041666666666667
22851, 1.7833333333333, 0.15, 0.041666666666667
22852, 1.825, 0.15, 0.041666666666667
22853, 1.8666666666667, 0.15, 0.041666666666667
22854, 1.9083333333333, 0.15, 0.041666666666667
22855, 1.95, 0.15, 0.041666666666667
22856, 1.9916666666667, 0.15, 0.041666666666667
22857, 2.0333333333333, 0.15, 0.041666666666667
22858, 2.075, 0.15, 0.041666666666667
22859, 2.1166666666667, 0.15, 0.041666666666667
22860, 2.1583333333333, 0.15, 0.041666666666667
22861, 1.2416666666667, 0.15, 0.083333333333333
22862, 1.2833333333333, 0.15, 0.083333333333333
22863, 1.325, 0.15, 0.083333333333333
22864, 1.3666666666667, 0.15, 0.083333333333333
22865, 1.4083333333333, 0.15, 0.083333333333333
22866, 1.45, 0.15, 0.083333333333333
22867, 1.4916666666667, 0.15, 0.083333333333333
22868, 1.5333333333333, 0.15, 0.083333333333333
22869, 1.575, 0.15, 0.083333333333333
22870, 1.6166666666667, 0.15, 0.083333333333333
22871, 1.6583333333333, 0.15, 0.083333333333333
22872, 1.7, 0.15, 0.083333333333333
22873, 1.7416666666667, 0.15, 0.083333333333333
22874, 1.7833333333333, 0.15, 0.083333333333333
22875, 1.825, 0.15, 0.083333333333333
22876, 1.8666666666667, 0.15, 0.083333333333333
22877, 1.9083333333333, 0.15, 0.083333333333333
22878, 1.95, 0.15, 0.083333333333333
22879, 1.9916666666667, 0.15, 0.083333333333333
22880, 2.0333333333333, 0.15, 0.083333333333333
22881, 2.075, 0.15, 0.083333333333333
22882, 2.1166666666667, 0.15, 0.083333333333333
22883, 2.1583333333333, 0.15, 0.083333333333333
22884, 1.2416666666667, 0.15, 0.125
22885, 1.2833333333333, 0.15, 0.125
22886, 1.325, 0.15, 0.125
22887, 1.3666666666667, 0.15, 0.125
22888, 1.4083333333333, 0.15, 0.125
22889, 1.45, 0.15, 0.125
22890, 1.4916666666667, 0.15, 0.125
22891, 1.5333333333333, 0.15, 0.125
22892, 1.575, 0.15, 0.125
22893, 1.6166666666667, 0.15, 0.125
22894, 1.6583333333333, 0.15, 0.125
22895, 1.7, 0.15, 0.125
22896, 1.7416666666667, 0.15, 0.125
22897, 1.7833333333333, 0.15, 0.125
22898, 1.825, 0.15, 0.125
22899, 1.8666666666667, 0.15, 0.125
22900, 1.9083333333333, 0.15, 0.125
22901, 1.95, 0.15, 0.125
22902, 1.9916666666667, 0.15, 0.125
22903, 2.0333333333333, 0.15, 0.125
22904, 2.075, 0.15, 0.125
22905, 2.1166666666667, 0.15, 0.125
22906, 2.1583333333333, 0.15, 0.125
22907, 1.2416666666667, 0.15, 0.16666666666667
22908, 1.2833333333333, 0.15, 0.16666666666667
22909, 1.325, 0.15, 0.16666666666667
22910, 1.3666666666667, 0.15, 0.16666666666667
22911, 1.4083333333333, 0.15, 0.16666666666667
22912, 1.45, 0.15, 0.16666666666667
22913, 1.4916666666667, 0.15, 0.16666666666667
22914, 1.5333333333333, 0.15, 0.16666666666667
22915, 1.575, 0.15, 0.16666666666667
22916, 1.6166666666667, 0.15, 0.16666666666667
22917, 1.6583333333333, 0.15, 0.16666666666667
22918, 1.7, 0.15, 0.16666666666667
22919, 1.7416666666667, 0.15, 0.16666666666667
22920, 1.7833333333333, 0.15, 0.16666666666667
22921, 1.825, 0.15, 0.16666666666667
22922, 1.8666666666667, 0.15, 0.16666666666667
22923, 1.9083333333333, 0.15, 0.16666666666667
22924, 1.95, 0.15, 0.16666666666667
22925, 1.9916666666667, 0.15, 0.16666666666667
22926, 2.0333333333333, 0.15, 0.16666666666667
22927, 2.075, 0.15, 0.16666666666667
22928, 2.1166666666667, 0.15, 0.16666666666667
22929, 2.1583333333333, 0.15, 0.16666666666667
22930, 1.2416666666667, 0.15, 0.20833333333333
22931, 1.2833333333333, 0.15, 0.20833333333333
22932, 1.325, 0.15, 0.20833333333333
22933, 1.3666666666667, 0.15, 0.20833333333333
22934, 1.4083333333333, 0.15, 0.20833333333333
22935, 1.45, 0.15, 0.20833333333333
22936, 1.4916666666667, 0.15, 0.20833333333333
22937, 1.5333333333333, 0.15, 0.20833333333333
22938, 1.575, 0.15, 0.20833333333333
22939, 1.6166666666667, 0.15, 0.20833333333333
22940, 1.6583333333333, 0.15, 0.20833333333333
22941, 1.7, 0.15, 0.20833333333333
22942, 1.7416666666667, 0.15, 0.20833333333333
22943, 1.7833333333333, 0.15, 0.20833333333333
22944, 1.825, 0.15, 0.20833333333333
22945, 1.8666666666667, 0.15, 0.20833333333333
22946, 1.9083333333333, 0.15, 0.20833333333333
22947, 1.95, 0.15, 0.20833333333333
22948, 1.9916666666667, 0.15, 0.20833333333333
22949, 2.0333333333333, 0.15, 0.20833333333333
22950, 2.075, 0.15, 0.20833333333333
22951, 2.1166666666667, 0.15, 0.20833333333333
22952, 2.1583333333333, 0.15, 0.20833333333333
22953, 1.2416666666667, 0.15, 0.25
22954, 1.2833333333333, 0.15, 0.25
22955, 1.325, 0.15, 0.25
22956, 1.3666666666667, 0.15, 0.25
22957, 1.4083333333333, 0.15, 0.25
22958, 1.45, 0.15, 0.25
22959, 1.4916666666667, 0.15, 0.25
22960, 1.5333333333333, 0.15, 0.25
22961, 1.575, 0.15, 0.25
22962, 1.6166666666667, 0.15, 0.25
22963, 1.6583333333333, 0.15, 0.25
22964, 1.7, 0.15, 0.25
22965, 1.7416666666667, 0.15, 0.25
22966, 1.7833333333333, 0.15, 0.25
22967, 1.825, 0.15, 0.25
22968, 1.8666666666667, 0.15, 0.25
22969, 1.9083333333333, 0.15, 0.25
22970, 1.95, 0.15, 0.25
22971, 1.9916666666667, 0.15, 0.25
22972, 2.0333333333333, 0.15, 0.25
22973, 2.075, 0.15, 0.25
22974, 2.1166666666667, 0.15, 0.25
22975, 2.1583333333333, 0.15, 0.25
22976, 1.2416666666667, 0.15, 0.29166666666667
22977, 1.2833333333333, 0.15, 0.29166666666667
22978, 1.325, 0.15, 0.29166666666667
22979, 1.3666666666667, 0.15, 0.29166666666667
22980, 1.4083333333333, 0.15, 0.29166666666667
22981, 1.45, 0.15, 0.29166666666667
22982, 1.4916666666667, 0.15, 0.29166666666667
22983, 1.5333333333333, 0.15, 0.29166666666667
22984, 1.575, 0.15, 0.29166666666667
22985, 1.6166666666667, 0.15, 0.29166666666667
22986, 1.6583333333333, 0.15, 0.29166666666667
22987, 1.7, 0.15, 0.29166666666667
22988, 1.7416666666667, 0.15, 0.29166666666667
22989, 1.7833333333333, 0.15, 0.29166666666667
22990, 1.825, 0.15, 0.29166666666667
22991, 1.8666666666667, 0.15, 0.29166666666667
22992, 1.9083333333333, 0.15, 0.29166666666667
22993, 1.95, 0.15, 0.29166666666667
22994, 1.9916666666667, 0.15, 0.29166666666667
22995, 2.0333333333333, 0.15, 0.29166666666667
22996, 2.075, 0.15, 0.29166666666667
22997, 2.1166666666667, 0.15, 0.29166666666667
22998, 2.1583333333333, 0.15, 0.29166666666667
22999, 1.2416666666667, 0.15, 0.33333333333333
23000, 1.2833333333333, 0.15, 0.33333333333333
23001, 1.325, 0.15, 0.33333333333333
23002, 1.3666666666667, 0.15, 0.33333333333333
23003, 1.4083333333333, 0.15, 0.33333333333333
23004, 1.45, 0.15, 0.33333333333333
23005, 1.4916666666667, 0.15, 0.33333333333333
23006, 1.5333333333333, 0.15, 0.33333333333333
23007, 1.575, 0.15, 0.33333333333333
23008, 1.6166666666667, 0.15, 0.33333333333333
23009, 1.6583333333333, 0.15, 0.33333333333333
23010, 1.7, 0.15, 0.33333333333333
23011, 1.7416666666667, 0.15, 0.33333333333333
23012, 1.7833333333333, 0.15, 0.33333333333333
23013, 1.825, 0.15, 0.33333333333333
23014, 1.8666666666667, 0.15, 0.33333333333333
23015, 1.9083333333333, 0.15, 0.33333333333333
23016, 1.95, 0.15, 0.33333333333333
23017, 1.9916666666667, 0.15, 0.33333333333333
23018, 2.0333333333333, 0.15, 0.33333333333333
23019, 2.075, 0.15, 0.33333333333333
23020, 2.1166666666667, 0.15, 0.33333333333333
23021, 2.1583333333333, 0.15, 0.33333333333333
23022, 1.2416666666667, 0.15, 0.375
23023, 1.2833333333333, 0.15, 0.375
23024, 1.325, 0.15, 0.375
23025, 1.3666666666667, 0.15, 0.375
23026, 1.4083333333333, 0.15, 0.375
23027, 1.45, 0.15, 0.375
23028, 1.4916666666667, 0.15, 0.375
23029, 1.5333333333333, 0.15, 0.375
23030, 1.575, 0.15, 0.375
23031, 1.6166666666667, 0.15, 0.375
23032, 1.6583333333333, 0.15, 0.375
23033, 1.7, 0.15, 0.375
23034, 1.7416666666667, 0.15, 0.375
23035, 1.7833333333333, 0.15, 0.375
23036, 1.825, 0.15, 0.375
23037, 1.8666666666667, 0.15, 0.375
23038, 1.9083333333333, 0.15, 0.375
23039, 1.95, 0.15, 0.375
23040, 1.9916666666667, 0.15, 0.375
23041, 2.0333333333333, 0.15, 0.375
23042, 2.075, 0.15, 0.375
23043, 2.1166666666667, 0.15, 0.375
23044, 2.1583333333333, 0.15, 0.375
23045, 1.2416666666667, 0.15, 0.41666666666667
23046, 1.2833333333333, 0.15, 0.41666666666667
23047, 1.325, 0.15, 0.41666666666667
23048, 1.3666666666667, 0.15, 0.41666666666667
23049, 1.4083333333333, 0.15, 0.41666666666667
23050, 1.45, 0.15, 0.41666666666667
23051, 1.4916666666667, 0.15, 0.41666666666667
23052, 1.5333333333333, 0.15, 0.41666666666667
23053, 1.575, 0.15, 0.41666666666667
23054, 1.6166666666667, 0.15, 0.41666666666667
23055, 1.6583333333333, 0.15, 0.41666666666667
23056, 1.7, 0.15, 0.41666666666667
23057, 1.7416666666667, 0.15, 0.41666666666667
23058, 1.7833333333333, 0.15, 0.41666666666667
23059, 1.825, 0.15, 0.41666666666667
23060, 1.8666666666667, 0.15, 0.41666666666667
23061, 1.9083333333333, 0.15, 0.41666666666667
23062, 1.95, 0.15, 0.41666666666667
23063, 1.9916666666667, 0.15, 0.41666666666667
23064, 2.0333333333333, 0.15, 0.41666666666667
23065, 2.075, 0.15, 0.41666666666667
23066, 2.1166666666667, 0.15, 0.41666666666667
23067, 2.1583333333333, 0.15, 0.41666666666667
23068, 1.2416666666667, 0.15, 0.45833333333333
23069, 1.2833333333333, 0.15, 0.45833333333333
23070, 1.325, 0.15, 0.45833333333333
23071, 1.3666666666667, 0.15, 0.45833333333333
23072, 1.4083333333333, 0.15, 0.45833333333333
23073, 1.45, 0.15, 0.45833333333333
23074, 1.4916666666667, 0.15, 0.45833333333333
23075, 1.5333333333333, 0.15, 0.45833333333333
23076, 1.575, 0.15, 0.45833333333333
23077, 1.6166666666667, 0.15, 0.45833333333333
23078, 1.6583333333333, 0.15, 0.45833333333333
23079, 1.7, 0.15, 0.45833333333333
23080, 1.7416666666667, 0.15, 0.45833333333333
23081, 1.7833333333333, 0.15, 0.45833333333333
23082, 1.825, 0.15, 0.45833333333333
23083, 1.8666666666667, 0.15, 0.45833333333333
23084, 1.9083333333333, 0.15, 0.45833333333333
23085, 1.95, 0.15, 0.45833333333333
23086, 1.9916666666667, 0.15, 0.45833333333333
23087, 2.0333333333333, 0.15, 0.45833333333333
23088, 2.075, 0.15, 0.45833333333333
23089, 2.1166666666667, 0.15, 0.45833333333333
23090, 2.1583333333333, 0.15, 0.45833333333333
23091, 1.2416666666667, 0.15, 0.020833333333333
23092, 1.2208333333333, 0.15, 0.041666666666667
23093, 1.2833333333333, 0.15, 0.020833333333333
23094, 1.2625, 0.15, 0.041666666666667
23095, 1.325, 0.15, 0.020833333333333
23096, 1.3041666666667, 0.15, 0.041666666666667
23097, 1.3666666666667, 0.15, 0.020833333333333
23098, 1.3458333333333, 0.15, 0.041666666666667
23099, 1.4083333333333, 0.15, 0.020833333333333
23100, 1.3875, 0.15, 0.041666666666667
23101, 1.45, 0.15, 0.020833333333333
23102, 1.4291666666667, 0.15, 0.041666666666667
23103, 1.4916666666667, 0.15, 0.020833333333333
23104, 1.4708333333333, 0.15, 0.041666666666667
23105, 1.5333333333333, 0.15, 0.020833333333333
23106, 1.5125, 0.15, 0.041666666666667
23107, 1.575, 0.15, 0.020833333333333
23108, 1.5541666666667, 0.15, 0.041666666666667
23109, 1.6166666666667, 0.15, 0.020833333333333
23110, 1.5958333333333, 0.15, 0.041666666666667
23111, 1.6583333333333, 0.15, 0.020833333333333
23112, 1.6375, 0.15, 0.041666666666667
23113, 1.7, 0.15, 0.020833333333333
23114, 1.6791666666667, 0.15, 0.041666666666667
23115, 1.7416666666667, 0.15, 0.020833333333333
23116, 1.7208333333333, 0.15, 0.041666666666667
23117, 1.7833333333333, 0.15, 0.020833333333333
23118, 1.7625, 0.15, 0.041666666666667
23119, 1.825, 0.15, 0.020833333333333
23120, 1.8041666666667, 0.15, 0.041666666666667
23121, 1.8666666666667, 0.15, 0.020833333333333
23122, 1.8458333333333, 0.15, 0.041666666666667
23123, 1.9083333333333, 0.15, 0.020833333333333
23124, 1.8875, 0.15, 0.041666666666667
23125, 1.95, 0.15, 0.020833333333333
23126, 1.9291666666667, 0.15, 0.041666666666667
23127, 1.9916666666667, 0.15, 0.020833333333333
23128, 1.9708333333333, 0.15, 0.041666666666667
23129, 2.0333333333333, 0.15, 0.020833333333333
23130, 2.0125, 0.15, 0.041666666666667
23131, 2.075, 0.15, 0.020833333333333
23132, 2.0541666666667, 0.15, 0.041666666666667
23133, 2.1166666666667, 0.15, 0.020833333333333
23134, 2.0958333333333, 0.15, 0.041666666666667
23135, 2.1583333333333, 0.15, 0.020833333333333
23136, 2.1375, 0.15, 0.041666666666667
23137, 2.1791666666667, 0.15, 0.041666666666667
23138, 1.2416666666667, 0.15, 0.0625
23139, 1.2208333333333, 0.15, 0.083333333333333
23140, 1.2833333333333, 0.15, 0.0625
23141, 1.2625, 0.15, 0.083333333333333
23142, 1.325, 0.15, 0.0625
23143, 1.3041666666667, 0.15, 0.083333333333333
23144, 1.3666666666667, 0.15, 0.0625
23145, 1.3458333333333, 0.15, 0.083333333333333
23146, 1.4083333333333, 0.15, 0.0625
23147, 1.3875, 0.15, 0.083333333333333
23148, 1.45, 0.15, 0.0625
23149, 1.4291666666667, 0.15, 0.083333333333333
23150, 1.4916666666667, 0.15, 0.0625
23151, 1.4708333333333, 0.15, 0.083333333333333
23152, 1.5333333333333, 0.15, 0.0625
23153, 1.5125, 0.15, 0.083333333333333
23154, 1.575, 0.15, 0.0625
23155, 1.5541666666667, 0.15, 0.083333333333333
23156, 1.6166666666667, 0.15, 0.0625
23157, 1.5958333333333, 0.15, 0.083333333333333
23158, 1.6583333333333, 0.15, 0.0625
23159, 1.6375, 0.15, 0.083333333333333
23160, 1.7, 0.15, 0.0625
23161, 1.6791666666667, 0.15, 0.083333333333333
23162, 1.7416666666667, 0.15, 0.0625
23163, 1.7208333333333, 0.15, 0.083333333333333
23164, 1.7833333333333, 0.15, 0.0625
23165, 1.7625, 0.15, 0.083333333333333
23166, 1.825, 0.15, 0.0625
23167, 1.8041666666667, 0.15, 0.083333333333333
23168, 1.8666666666667, 0.15, 0.0625
23169, 1.8458333333333, 0.15, 0.083333333333333
23170, 1.9083333333333, 0.15, 0.0625
23171, 1.8875, 0.15, 0.083333333333333
23172, 1.95, 0.15, 0.0625
23173, 1.9291666666667, 0.15, 0.083333333333333
23174, 1.9916666666667, 0.15, 0.0625
23175, 1.9708333333333, 0.15, 0.083333333333333
23176, 2.0333333333333, 0.15, 0.0625
23177, 2.0125, 0.15, 0.083333333333333
23178, 2.075, 0.15, 0.0625
23179, 2.0541666666667, 0.15, 0.083333333333333
23180, 2.1166666666667, 0.15, 0.0625
23181, 2.0958333333333, 0.15, 0.083333333333333
23182, 2.1583333333333, 0.15, 0.0625
23183, 2.1375, 0.15, 0.083333333333333
23184, 2.1791666666667, 0.15, 0.083333333333333
23185, 1.2416666666667, 0.15, 0.10416666666667
23186, 1.2208333333333, 0.15, 0.125
23187, 1.2833333333333, 0.15, 0.10416666666667
23188, 1.2625, 0.15, 0.125
23189, 1.325, 0.15, 0.10416666666667
23190, 1.3041666666667, 0.15, 0.125
23191, 1.3666666666667, 0.15, 0.10416666666667
23192, 1.3458333333333, 0.15, 0.125
23193, 1.4083333333333, 0.15, 0.10416666666667
23194, 1.3875, 0.15, 0.125
23195, 1.45, 0.15, 0.10416666666667
23196, 1.4291666666667, 0.15, 0.125
23197, 1.4916666666667, 0.15, 0.10416666666667
23198, 1.4708333333333, 0.15, 0.125
23199, 1.5333333333333, 0.15, 0.10416666666667
23200, 1.5125, 0.15, 0.125
23201, 1.575, 0.15, 0.10416666666667
23202, 1.5541666666667, 0.15, 0.125
23203, 1.6166666666667, 0.15, 0.10416666666667
23204, 1.5958333333333, 0.15, 0.125
23205, 1.6583333333333, 0.15, 0.10416666666667
23206, 1.6375, 0.15, 0.125
23207, 1.7, 0.15, 0.10416666666667
23208, 1.6791666666667, 0.15, 0.125
23209, 1.7416666666667, 0.15, 0.10416666666667
23210, 1.7208333333333, 0.15, 0.125
23211, 1.7833333333333, 0.15, 0.10416666666667
23212, 1.7625, 0.15, 0.125
23213, 1.825, 0.15, 0.10416666666667
23214, 1.8041666666667, 0.15, 0.125
23215, 1.8666666666667, 0.15, 0.10416666666667
23216, 1.8458333333333, 0.15, 0.125
23217, 1.9083333333333, 0.15, 0.10416666666667
23218, 1.8875, 0.15, 0.125
23219, 1.95, 0.15, 0.10416666666667
23220, 1.9291666666667, 0.15, 0.125
23221, 1.9916666666667, 0.15, 0.10416666666667
23222, 1.9708333333333, 0.15, 0.125
23223, 2.0333333333333, 0.15, 0.10416666666667
23224, 2.0125, 0.15, 0.125
23225, 2.075, 0.15, 0.10416666666667
23226, 2.0541666666667, 0.15, 0.125
23227, 2.1166666666667, 0.15, 0.10416666666667
23228, 2.0958333333333, 0.15, 0.125
23229, 2.1583333333333, 0.15, 0.10416666666667
23230, 2.1375, 0.15, 0.125
23231, 2.1791666666667, 0.15, 0.125
23232, 1.2416666666667, 0.15, 0.14583333333333
23233, 1.2208333333333, 0.15, 0.16666666666667
23234, 1.2833333333333, 0.15, 0.14583333333333
23235, 1.2625, 0.15, 0.16666666666667
23236, 1.325, 0.15, 0.14583333333333
23237, 1.3041666666667, 0.15, 0.16666666666667
23238, 1.3666666666667, 0.15, 0.14583333333333
23239, 1.3458333333333, 0.15, 0.16666666666667
23240, 1.4083333333333, 0.15, 0.14583333333333
23241, 1.3875, 0.15, 0.16666666666667
23242, 1.45, 0.15, 0.14583333333333
23243, 1.4291666666667, 0.15, 0.16666666666667
23244, 1.4916666666667, 0.15, 0.14583333333333
23245, 1.4708333333333, 0.15, 0.16666666666667
23246, 1.5333333333333, 0.15, 0.14583333333333
23247, 1.5125, 0.15, 0.16666666666667
23248, 1.575, 0.15, 0.14583333333333
23249, 1.5541666666667, 0.15, 0.16666666666667
23250, 1.6166666666667, 0.15, 0.14583333333333
23251, 1.5958333333333, 0.15, 0.16666666666667
23252, 1.6583333333333, 0.15, 0.14583333333333
23253, 1.6375, 0.15, 0.16666666666667
23254, 1.7, 0.15, 0.14583333333333
23255, 1.6791666666667, 0.15, 0.16666666666667
23256, 1.7416666666667, 0.15, 0.14583333333333
23257, 1.7208333333333, 0.15, 0.16666666666667
23258, 1.7833333333333, 0.15, 0.14583333333333
23259, 1.7625, 0.15, 0.16666666666667
23260, 1.825, 0.15, 0.14583333333333
23261, 1.8041666666667, 0.15, 0.16666666666667
23262, 1.8666666666667, 0.15, 0.14583333333333
23263, 1.8458333333333, 0.15, 0.16666666666667
23264, 1.9083333333333, 0.15, 0.14583333333333
23265, 1.8875, 0.15, 0.16666666666667
23266, 1.95, 0.15, 0.14583333333333
23267, 1.9291666666667, 0.15, 0.16666666666667
23268, 1.9916666666667, 0.15, 0.14583333333333
23269, 1.9708333333333, 0.15, 0.16666666666667
23270, 2.0333333333333, 0.15, 0.14583333333333
23271, 2.0125, 0.15, 0.16666666666667
23272, 2.075, 0.15, 0.14583333333333
23273, 2.0541666666667, 0.15, 0.16666666666667
23274, 2.1166666666667, 0.15, 0.14583333333333
23275, 2.0958333333333, 0.15, 0.16666666666667
23276, 2.1583333333333, 0.15, 0.14583333333333
23277, 2.1375, 0.15, 0.16666666666667
23278, 2.1791666666667, 0.15, 0.16666666666667
23279, 1.2416666666667, 0.15, 0.1875
23280, 1.2208333333333, 0.15, 0.20833333333333
23281, 1.2833333333333, 0.15, 0.1875
23282, 1.2625, 0.15, 0.20833333333333
23283, 1.325, 0.15, 0.1875
23284, 1.3041666666667, 0.15, 0.20833333333333
23285, 1.3666666666667, 0.15, 0.1875
23286, 1.3458333333333, 0.15, 0.20833333333333
23287, 1.4083333333333, 0.15, 0.1875
23288, 1.3875, 0.15, 0.20833333333333
23289, 1.45, 0.15, 0.1875
23290, 1.4291666666667, 0.15, 0.20833333333333
23291, 1.4916666666667, 0.15, 0.1875
23292, 1.4708333333333, 0.15, 0.20833333333333
23293, 1.5333333333333, 0.15, 0.1875
23294, 1.5125, 0.15, 0.20833333333333
23295, 1.575, 0.15, 0.1875
23296, 1.5541666666667, 0.15, 0.20833333333333
23297, 1.6166666666667, 0.15, 0.1875
23298, 1.5958333333333, 0.15, 0.20833333333333
23299, 1.6583333333333, 0.15, 0.1875
23300, 1.6375, 0.15, 0.20833333333333
23301, 1.7, 0.15, 0.1875
23302, 1.6791666666667, 0.15, 0.20833333333333
23303, 1.7416666666667, 0.15, 0.1875
23304, 1.7208333333333, 0.15, 0.20833333333333
23305, 1.7833333333333, 0.15, 0.1875
23306, 1.7625, 0.15, 0.20833333333333
23307, 1.825, 0.15, 0.1875
23308, 1.8041666666667, 0.15, 0.20833333333333
23309, 1.8666666666667, 0.15, 0.1875
23310, 1.8458333333333, 0.15, 0.20833333333333
23311, 1.9083333333333, 0.15, 0.1875
23312, 1.8875, 0.15, 0.20833333333333
23313, 1.95, 0.15, 0.1875
23314, 1.9291666666667, 0.15, 0.20833333333333
23315, 1.9916666666667, 0.15, 0.1875
23316, 1.9708333333333, 0.15, 0.20833333333333
23317, 2.0333333333333, 0.15, 0.1875
23318, 2.0125, 0.15, 0.20833333333333
23319, 2.075, 0.15, 0.1875
23320, 2.0541666666667, 0.15, 0.20833333333333
23321, 2.1166666666667, 0.15, 0.1875
23322, 2.0958333333333, 0.15, 0.20833333333333
23323, 2.1583333333333, 0.15, 0.1875
23324, 2.1375, 0.15, 0.20833333333333
23325, 2.1791666666667, 0.15, 0.20833333333333
23326, 1.2416666666667, 0.15, 0.22916666666667
23327, 1.2208333333333, 0.15, 0.25
23328, 1.2833333333333, 0.15, 0.22916666666667
23329, 1.2625, 0.15, 0.25
23330, 1.325, 0.15, 0.22916666666667
23331, 1.3041666666667, 0.15, 0.25
23332, 1.3666666666667, 0.15, 0.22916666666667
23333, 1.3458333333333, 0.15, 0.25
23334, 1.4083333333333, 0.15, 0.22916666666667
23335, 1.3875, 0.15, 0.25
23336, 1.45, 0.15, 0.22916666666667
23337, 1.4291666666667, 0.15, 0.25
23338, 1.4916666666667, 0.15, 0.22916666666667
23339, 1.4708333333333, 0.15, 0.25
23340, 1.5333333333333, 0.15, 0.22916666666667
23341, 1.5125, 0.15, 0.25
23342, 1.575, 0.15, 0.22916666666667
23343, 1.5541666666667, 0.15, 0.25
23344, 1.6166666666667, 0.15, 0.22916666666667
23345, 1.5958333333333, 0.15, 0.25
23346, 1.6583333333333, 0.15, 0.22916666666667
23347, 1.6375, 0.15, 0.25
23348, 1.7, 0.15, 0.22916666666667
23349, 1.6791666666667, 0.15, 0.25
23350, 1.7416666666667, 0.15, 0.22916666666667
23351, 1.7208333333333, 0.15, 0.25
23352, 1.7833333333333, 0.15, 0.22916666666667
23353, 1.7625, 0.15, 0.25
23354, 1.825, 0.15, 0.22916666666667
23355, 1.8041666666667, 0.15, 0.25
23356, 1.8666666666667, 0.15, 0.22916666666667
23357, 1.8458333333333, 0.15, 0.25
23358, 1.9083333333333, 0.15, 0.22916666666667
23359, 1.8875, 0.15, 0.25
23360, 1.95, 0.15, 0.22916666666667
23361, 1.9291666666667, 0.15, 0.25
23362, 1.9916666666667, 0.15, 0.22916666666667
23363, 1.9708333333333, 0.15, 0.25
23364, 2.0333333333333, 0.15, 0.22916666666667
23365, 2.0125, 0.15, 0.25
23366, 2.075, 0.15, 0.22916666666667
23367, 2.0541666666667, 0.15, 0.25
23368, 2.1166666666667, 0.15, 0.22916666666667
23369, 2.0958333333333, 0.15, 0.25
23370, 2.1583333333333, 0.15, 0.22916666666667
23371, 2.1375, 0.15, 0.25
23372, 2.1791666666667, 0.15, 0.25
23373, 1.2416666666667, 0.15, 0.27083333333333
23374, 1.2208333333333, 0.15, 0.29166666666667
23375, 1.2833333333333, 0.15, 0.27083333333333
23376, 1.2625, 0.15, 0.29166666666667
23377, 1.325, 0.15, 0.27083333333333
23378, 1.3041666666667, 0.15, 0.29166666666667
23379, 1.3666666666667, 0.15, 0.27083333333333
23380, 1.3458333333333, 0.15, 0.29166666666667
23381, 1.4083333333333, 0.15, 0.27083333333333
23382, 1.3875, 0.15, 0.29166666666667
23383, 1.45, 0.15, 0.27083333333333
23384, 1.4291666666667, 0.15, 0.29166666666667
23385, 1.4916666666667, 0.15, 0.27083333333333
23386, 1.4708333333333, 0.15, 0.29166666666667
23387, 1.5333333333333, 0.15, 0.27083333333333
23388, 1.5125, 0.15, 0.29166666666667
23389, 1.575, 0.15, 0.27083333333333
23390, 1.5541666666667, 0.15, 0.29166666666667
23391, 1.6166666666667, 0.15, 0.27083333333333
23392, 1.5958333333333, 0.15, 0.29166666666667
23393, 1.6583333333333, 0.15, 0.27083333333333
23394, 1.6375, 0.15, 0.29166666666667
23395, 1.7, 0.15, 0.27083333333333
23396, 1.6791666666667, 0.15, 0.29166666666667
23397, 1.7416666666667, 0.15, 0.27083333333333
23398, 1.7208333333333, 0.15, 0.29166666666667
23399, 1.7833333333333, 0.15, 0.27083333333333
23400, 1.7625, 0.15, 0.29166666666667
23401, 1.825, 0.15, 0.27083333333333
23402, 1.8041666666667, 0.15, 0.29166666666667
23403, 1.8666666666667, 0.15, 0.27083333333333
23404, 1.8458333333333, 0.15, 0.29166666666667
23405, 1.9083333333333, 0.15, 0.27083333333333
23406, 1.8875, 0.15, 0.29166666666667
23407, 1.95, 0.15, 0.27083333333333
23408, 1.9291666666667, 0.15, 0.29166666666667
23409, 1.9916666666667, 0.15, 0.27083333333333
23410, 1.9708333333333, 0.15, 0.29166666666667
23411, 2.0333333333333, 0.15, 0.27083333333333
23412, 2.0125, 0.15, 0.29166666666667
23413, 2.075, 0.15, 0.27083333333333
23414, 2.0541666666667, 0.15, 0.29166666666667
23415, 2.1166666666667, 0.15, 0.27083333333333
23416, 2.0958333333333, 0.15, 0.29166666666667
23417, 2.1583333333333, 0.15, 0.27083333333333
23418, 2.1375, 0.15, 0.29166666666667
23419, 2.1791666666667, 0.15, 0.29166666666667
23420, 1.2416666666667, 0.15, 0.3125
23421, 1.2208333333333, 0.15, 0.33333333333333
23422, 1.2833333333333, 0.15, 0.3125
23423, 1.2625, 0.15, 0.33333333333333
23424, 1.325, 0.15, 0.3125
23425, 1.3041666666667, 0.15, 0.33333333333333
23426, 1.3666666666667, 0.15, 0.3125
23427, 1.3458333333333, 0.15, 0.33333333333333
23428, 1.4083333333333, 0.15, 0.3125
23429, 1.3875, 0.15, 0.33333333333333
23430, 1.45, 0.15, 0.3125
23431, 1.4291666666667, 0.15, 0.33333333333333
23432, 1.4916666666667, 0.15, 0.3125
23433, 1.4708333333333, 0.15, 0.33333333333333
23434, 1.5333333333333, 0.15, 0.3125
23435, 1.5125, 0.15, 0.33333333333333
23436, 1.575, 0.15, 0.3125
23437, 1.5541666666667, 0.15, 0.33333333333333
23438, 1.6166666666667, 0.15, 0.3125
23439, 1.5958333333333, 0.15, 0.33333333333333
23440, 1.6583333333333, 0.15, 0.3125
23441, 1.6375, 0.15, 0.33333333333333
23442, 1.7, 0.15, 0.3125
23443, 1.6791666666667, 0.15, 0.33333333333333
23444, 1.7416666666667, 0.15, 0.3125
23445, 1.7208333333333, 0.15, 0.33333333333333
23446, 1.7833333333333, 0.15, 0.3125
23447, 1.7625, 0.15, 0.33333333333333
23448, 1.825, 0.15, 0.3125
23449, 1.8041666666667, 0.15, 0.33333333333333
23450, 1.8666666666667, 0.15, 0.3125
23451, 1.8458333333333, 0.15, 0.33333333333333
23452, 1.9083333333333, 0.15, 0.3125
23453, 1.8875, 0.15, 0.33333333333333
23454, 1.95, 0.15, 0.3125
23455, 1.9291666666667, 0.15, 0.33333333333333
23456, 1.9916666666667, 0.15, 0.3125
23457, 1.9708333333333, 0.15, 0.33333333333333
23458, 2.0333333333333, 0.15, 0.3125
23459, 2.0125, 0.15, 0.33333333333333
23460, 2.075, 0.15, 0.3125
23461, 2.0541666666667, 0.15, 0.33333333333333
23462, 2.1166666666667, 0.15, 0.3125
23463, 2.0958333333333, 0.15, 0.33333333333333
23464, 2.1583333333333, 0.15, 0.3125
23465, 2.1375, 0.15, 0.33333333333333
23466, 2.1791666666667, 0.15, 0.33333333333333
23467, 1.2416666666667, 0.15, 0.35416666666667
23468, 1.2208333333333, 0.15, 0.375
23469, 1.2833333333333, 0.15, 0.35416666666667
23470, 1.2625, 0.15, 0.375
23471, 1.325, 0.15, 0.35416666666667
23472, 1.3041666666667, 0.15, 0.375
23473, 1.3666666666667, 0.15, 0.35416666666667
23474, 1.3458333333333, 0.15, 0.375
23475, 1.4083333333333, 0.15, 0.35416666666667
23476, 1.3875, 0.15, 0.375
23477, 1.45, 0.15, 0.35416666666667
23478, 1.4291666666667, 0.15, 0.375
23479, 1.4916666666667, 0.15, 0.35416666666667
23480, 1.4708333333333, 0.15, 0.375
23481, 1.5333333333333, 0.15, 0.35416666666667
23482, 1.5125, 0.15, 0.375
23483, 1.575, 0.15, 0.35416666666667
23484, 1.5541666666667, 0.15, 0.375
23485, 1.6166666666667, 0.15, 0.35416666666667
23486, 1.5958333333333, 0.15, 0.375
23487, 1.6583333333333, 0.15, 0.35416666666667
23488, 1.6375, 0.15, 0.375
23489, 1.7, 0.15, 0.35416666666667
23490, 1.6791666666667, 0.15, 0.375
23491, 1.7416666666667, 0.15, 0.35416666666667
23492, 1.7208333333333, 0.15, 0.375
23493, 1.7833333333333, 0.15, 0.35416666666667
23494, 1.7625, 0.15, 0.375
23495, 1.825, 0.15, 0.35416666666667
23496, 1.8041666666667, 0.15, 0.375
23497, 1.8666666666667, 0.15, 0.35416666666667
23498, 1.8458333333333, 0.15, 0.375
23499, 1.9083333333333, 0.15, 0.35416666666667
23500, 1.8875, 0.15, 0.375
23501, 1.95, 0.15, 0.35416666666667
23502, 1.9291666666667, 0.15, 0.375
23503, 1.9916666666667, 0.15, 0.35416666666667
23504, 1.9708333333333, 0.15, 0.375
23505, 2.0333333333333, 0.15, 0.35416666666667
23506, 2.0125, 0.15, 0.375
23507, 2.075, 0.15, 0.35416666666667
23508, 2.0541666666667, 0.15, 0.375
23509, 2.1166666666667, 0.15, 0.35416666666667
23510, 2.0958333333333, 0.15, 0.375
23511, 2.1583333333333, 0.15, 0.35416666666667
23512, 2.1375, 0.15, 0.375
23513, 2.1791666666667, 0.15, 0.375
23514, 1.2416666666667, 0.15, 0.39583333333333
23515, 1.2208333333333, 0.15, 0.41666666666667
23516, 1.2833333333333, 0.15, 0.39583333333333
23517, 1.2625, 0.15, 0.41666666666667
23518, 1.325, 0.15, 0.39583333333333
23519, 1.3041666666667, 0.15, 0.41666666666667
23520, 1.3666666666667, 0.15, 0.39583333333333
23521, 1.3458333333333, 0.15, 0.41666666666667
23522, 1.4083333333333, 0.15, 0.39583333333333
23523, 1.3875, 0.15, 0.41666666666667
23524, 1.45, 0.15, 0.39583333333333
23525, 1.4291666666667, 0.15, 0.41666666666667
23526, 1.4916666666667, 0.15, 0.39583333333333
23527, 1.4708333333333, 0.15, 0.41666666666667
23528, 1.5333333333333, 0.15, 0.39583333333333
23529, 1.5125, 0.15, 0.41666666666667
23530, 1.575, 0.15, 0.39583333333333
23531, 1.5541666666667, 0.15, 0.41666666666667
23532, 1.6166666666667, 0.15, 0.39583333333333
23533, 1.5958333333333, 0.15, 0.41666666666667
23534, 1.6583333333333, 0.15, 0.39583333333333
23535, 1.6375, 0.15, 0.41666666666667
23536, 1.7, 0.15, 0.39583333333333
23537, 1.6791666666667, 0.15, 0.41666666666667
23538, 1.7416666666667, 0.15, 0.39583333333333
23539, 1.7208333333333, 0.15, 0.41666666666667
23540, 1.7833333333333, 0.15, 0.39583333333333
23541, 1.7625, 0.15, 0.41666666666667
23542, 1.825, 0.15, 0.39583333333333
23543, 1.8041666666667, 0.15, 0.41666666666667
23544, 1.8666666666667, 0.15, 0.39583333333333
23545, 1.8458333333333, 0.15, 0.41666666666667
23546, 1.9083333333333, 0.15, 0.39583333333333
23547, 1.8875, 0.15, 0.41666666666667
23548, 1.95, 0.15, 0.39583333333333
23549, 1.9291666666667, 0.15, 0.41666666666667
23550, 1.9916666666667, 0.15, 0.39583333333333
23551, 1.9708333333333, 0.15, 0.41666666666667
23552, 2.0333333333333, 0.15, 0.39583333333333
23553, 2.0125, 0.15, 0.41666666666667
23554, 2.075, 0.15, 0.39583333333333
23555, 2.0541666666667, 0.15, 0.41666666666667
23556, 2.1166666666667, 0.15, 0.39583333333333
23557, 2.0958333333333, 0.15, 0.41666666666667
23558, 2.1583333333333, 0.15, 0.39583333333333
23559, 2.1375, 0.15, 0.41666666666667
23560, 2.1791666666667, 0.15, 0.41666666666667
23561, 1.2416666666667, 0.15, 0.4375
23562, 1.2208333333333, 0.15, 0.45833333333333
23563, 1.2833333333333, 0.15, 0.4375
23564, 1.2625, 0.15, 0.45833333333333
23565, 1.325, 0.15, 0.4375
23566, 1.3041666666667, 0.15, 0.45833333333333
23567, 1.3666666666667, 0.15, 0.4375
23568, 1.3458333333333, 0.15, 0.45833333333333
23569, 1.4083333333333, 0.15, 0.4375
23570, 1.3875, 0.15, 0.45833333333333
23571, 1.45, 0.15, 0.4375
23572, 1.4291666666667, 0.15, 0.45833333333333
23573, 1.4916666666667, 0.15, 0.4375
23574, 1.4708333333333, 0.15, 0.45833333333333
23575, 1.5333333333333, 0.15, 0.4375
23576, 1.5125, 0.15, 0.45833333333333
23577, 1.575, 0.15, 0.4375
23578, 1.5541666666667, 0.15, 0.45833333333333
23579, 1.6166666666667, 0.15, 0.4375
23580, 1.5958333333333, 0.15, 0.45833333333333
23581, 1.6583333333333, 0.15, 0.4375
23582, 1.6375, 0.15, 0.45833333333333
23583, 1.7, 0.15, 0.4375
23584, 1.6791666666667, 0.15, 0.45833333333333
23585, 1.7416666666667, 0.15, 0.4375
23586, 1.7208333333333, 0.15, 0.45833333333333
23587, 1.7833333333333, 0.15, 0.4375
23588, 1.7625, 0.15, 0.45833333333333
23589, 1.825, 0.15, 0.4375
23590, 1.8041666666667, 0.15, 0.45833333333333
23591, 1.8666666666667, 0.15, 0.4375
23592, 1.8458333333333, 0.15, 0.45833333333333
23593, 1.9083333333333, 0.15, 0.4375
23594, 1.8875, 0.15, 0.45833333333333
23595, 1.95, 0.15, 0.4375
23596, 1.9291666666667, 0.15, 0.45833333333333
23597, 1.9916666666667, 0.15, 0.4375
23598, 1.9708333333333, 0.15, 0.45833333333333
23599, 2.0333333333333, 0.15, 0.4375
23600, 2.0125, 0.15, 0.45833333333333
23601, 2.075, 0.15, 0.4375
23602, 2.0541666666667, 0.15, 0.45833333333333
23603, 2.1166666666667, 0.15, 0.4375
23604, 2.0958333333333, 0.15, 0.45833333333333
23605, 2.1583333333333, 0.15, 0.4375
23606, 2.1375, 0.15, 0.45833333333333
23607, 2.1791666666667, 0.15, 0.45833333333333
23608, 1.2416666666667, 0.15, 0.47916666666667
23609, 1.2833333333333, 0.15, 0.47916666666667
23610, 1.325, 0.15, 0.47916666666667
23611, 1.3666666666667, 0.15, 0.47916666666667
23612, 1.4083333333333, 0.15, 0.47916666666667
23613, 1.45, 0.15, 0.47916666666667
23614, 1.4916666666667, 0.15, 0.47916666666667
23615, 1.5333333333333, 0.15, 0.47916666666667
23616, 1.575, 0.15, 0.47916666666667
23617, 1.6166666666667, 0.15, 0.47916666666667
23618, 1.6583333333333, 0.15, 0.47916666666667
23619, 1.7, 0.15, 0.47916666666667
23620, 1.7416666666667, 0.15, 0.47916666666667
23621, 1.7833333333333, 0.15, 0.47916666666667
23622, 1.825, 0.15, 0.47916666666667
23623, 1.8666666666667, 0.15, 0.47916666666667
23624, 1.9083333333333, 0.15, 0.47916666666667
23625, 1.95, 0.15, 0.47916666666667
23626, 1.9916666666667, 0.15, 0.47916666666667
23627, 2.0333333333333, 0.15, 0.47916666666667
23628, 2.075, 0.15, 0.47916666666667
23629, 2.1166666666667, 0.15, 0.47916666666667
23630, 2.1583333333333, 0.15, 0.47916666666667
23631, 1.2416666666667, 0.125, 0.5
23632, 1.2833333333333, 0.125, 0.5
23633, 1.325, 0.125, 0.5
23634, 1.3666666666667, 0.125, 0.5
23635, 1.4083333333333, 0.125, 0.5
23636, 1.45, 0.125, 0.5
23637, 1.4916666666667, 0.125, 0.5
23638, 1.5333333333333, 0.125, 0.5
23639, 1.575, 0.125, 0.5
23640, 1.6166666666667, 0.125, 0.5
23641, 1.6583333333333, 0.125, 0.5
23642, 1.7, 0.125, 0.5
23643, 1.7416666666667, 0.125, 0.5
23644, 1.7833333333333, 0.125, 0.5
23645, 1.825, 0.125, 0.5
23646, 1.8666666666667, 0.125, 0.5
23647, 1.9083333333333, 0.125, 0.5
23648, 1.95, 0.125, 0.5
23649, 1.9916666666667, 0.125, 0.5
23650, 2.0333333333333, 0.125, 0.5
23651, 2.075, 0.125, 0.5
23652, 2.1166666666667, 0.125, 0.5
23653, 2.1583333333333, 0.125, 0.5
23654, 1.2416666666667, 0.125, 0
23655, 1.2833333333333, 0.125, 0
23656, 1.325, 0.125, 0
23657, 1.3666666666667, 0.125, 0
23658, 1.4083333333333, 0.125, 0
23659, 1.45, 0.125, 0
23660, 1.4916666666667, 0.125, 0
23661, 1.5333333333333, 0.125, 0
23662, 1.575, 0.125, 0
23663, 1.6166666666667, 0.125, 0
23664, 1.6583333333333, 0.125, 0
23665, 1.7, 0.125, 0
23666, 1.7416666666667, 0.125, 0
23667, 1.7833333333333, 0.125, 0
23668, 1.825, 0.125, 0
23669, 1.8666666666667, 0.125, 0
23670, 1.9083333333333, 0.125, 0
23671, 1.95, 0.125, 0
23672, 1.9916666666667, 0.125, 0
23673, 2.0333333333333, 0.125, 0
23674, 2.075, 0.125, 0
23675, 2.1166666666667, 0.125, 0
23676, 2.1583333333333, 0.125, 0
23677, 1.2, 0.125, 0.041666666666667
23678, 1.2, 0.125, 0.083333333333333
23679, 1.2, 0.125, 0.125
23680, 1.2, 0.125, 0.16666666666667
23681, 1.2, 0.125, 0.20833333333333
23682, 1.2, 0.125, 0.25
23683, 1.2, 0.125, 0.29166666666667
23684, 1.2, 0.125, 0.33333333333333
23685, 1.2, 0.125, 0.375
23686, 1.2, 0.125, 0.41666666666667
23687, 1.2, 0.125, 0.45833333333333
23688, 2.2, 0.125, 0.041666666666667
23689, 2.2, 0.125, 0.083333333333333
23690, 2.2, 0.125, 0.125
23691, 2.2, 0.125, 0.16666666666667
23692, 2.2, 0.125, 0.20833333333333
23693, 2.2, 0.125, 0.25
23694, 2.2, 0.125, 0.29166666666667
23695, 2.2, 0.125, 0.33333333333333
23696, 2.2, 0.125, 0.375
23697, 2.2, 0.125, 0.41666666666667
23698, 2.2, 0.125, 0.45833333333333
23699, 1.2416666666667, 0.1, 0.041666666666667
23700, 1.2833333333333, 0.1, 0.041666666666667
23701, 1.325, 0.1, 0.041666666666667
23702, 1.3666666666667, 0.1, 0.041666666666667
23703, 1.4083333333333, 0.1, 0.041666666666667
23704, 1.45, 0.1, 0.041666666666667
23705, 1.4916666666667, 0.1, 0.041666666666667
23706, 1.5333333333333, 0.1, 0.041666666666667
23707, 1.575, 0.1, 0.041666666666667
23708, 1.6166666666667, 0.1, 0.041666666666667
23709, 1.6583333333333, 0.1, 0.041666666666667
23710, 1.7, 0.1, 0.041666666666667
23711, 1.7416666666667, 0.1, 0.041666666666667
23712, 1.7833333333333, 0.1, 0.041666666666667
23713, 1.825, 0.1, 0.041666666666667
23714, 1.8666666666667, 0.1, 0.041666666666667
23715, 1.9083333333333, 0.1, 0.041666666666667
23716, 1.95, 0.1, 0.041666666666667
23717, 1.9916666666667, 0.1, 0.041666666666667
23718, 2.0333333333333, 0.1, 0.041666666666667
23719, 2.075, 0.1, 0.041666666666667
23720, 2.1166666666667, 0.1, 0.041666666666667
23721, 2.1583333333333, 0.1, 0.041666666666667
23722, 1.2416666666667, 0.1, 0.083333333333333
23723, 1.2833333333333, 0.1, 0.083333333333333
23724, 1.325, 0.1, 0.083333333333333
23725, 1.3666666666667, 0.1, 0.083333333333333
23726, 1.4083333333333, 0.1, 0.083333333333333
23727, 1.45, 0.1, 0.083333333333333
23728, 1.4916666666667, 0.1, 0.083333333333333
23729, 1.5333333333333, 0.1, 0.083333333333333
23730, 1.575, 0.1, 0.083333333333333
23731, 1.6166666666667, 0.1, 0.083333333333333
23732, 1.6583333333333, 0.1, 0.083333333333333
23733, 1.7, 0.1, 0.083333333333333
23734, 1.7416666666667, 0.1, 0.083333333333333
23735, 1.7833333333333, 0.1, 0.083333333333333
23736, 1.825, 0.1, 0.083333333333333
23737, 1.8666666666667, 0.1, 0.083333333333333
23738, 1.9083333333333, 0.1, 0.083333333333333
23739, 1.95, 0.1, 0.083333333333333
23740, 1.9916666666667, 0.1, 0.083333333333333
23741, 2.0333333333333, 0.1, 0.083333333333333
23742, 2.075, 0.1, 0.083333333333333
23743, 2.1166666666667, 0.1, 0.083333333333333
23744, 2.1583333333333, 0.1, 0.083333333333333
23745, 1.2416666666667, 0.1, 0.125
23746, 1.2833333333333, 0.1, 0.125
23747, 1.325, 0.1, 0.125
23748, 1.3666666666667, 0.1, 0.125
23749, 1.4083333333333, 0.1, 0.125
23750, 1.45, 0.1, 0.125
23751, 1.4916666666667, 0.1, 0.125
23752, 1.5333333333333, 0.1, 0.125
23753, 1.575, 0.1, 0.125
23754, 1.6166666666667, 0.1, 0.125
23755, 1.6583333333333, 0.1, 0.125
23756, 1.7, 0.1, 0.125
23757, 1.7416666666667, 0.1, 0.125
23758, 1.7833333333333, 0.1, 0.125
23759, 1.825, 0.1, 0.125
23760, 1.8666666666667, 0.1, 0.125
23761, 1.9083333333333, 0.1, 0.125
23762, 1.95, 0.1, 0.125
23763, 1.9916666666667, 0.1, 0.125
23764, 2.0333333333333, 0.1, 0.125
23765, 2.075, 0.1, 0.125
23766, 2.1166666666667, 0.1, 0.125
23767, 2.1583333333333, 0.1, 0.125
23768, 1.2416666666667, 0.1, 0.16666666666667
23769, 1.2833333333333, 0.1, 0.16666666666667
23770, 1.325, 0.1, 0.16666666666667
23771, 1.3666666666667, 0.1, 0.16666666666667
23772, 1.4083333333333, 0.1, 0.16666666666667
23773, 1.45, 0.1, 0.16666666666667
23774, 1.4916666666667, 0.1, 0.16666666666667
23775, 1.5333333333333, 0.1, 0.16666666666667
23776, 1.575, 0.1, 0.16666666666667
23777, 1.6166666666667, 0.1, 0.16666666666667
23778, 1.6583333333333, 0.1, 0.16666666666667
23779, 1.7, 0.1, 0.16666666666667
23780, 1.7416666666667, 0.1, 0.16666666666667
23781, 1.7833333333333, 0.1, 0.16666666666667
23782, 1.825, 0.1, 0.16666666666667
23783, 1.8666666666667, 0.1, 0.16666666666667
23784, 1.9083333333333, 0.1, 0.16666666666667
23785, 1.95, 0.1, 0.16666666666667
23786, 1.9916666666667, 0.1, 0.16666666666667
23787, 2.0333333333333, 0.1, 0.16666666666667
23788, 2.075, 0.1, 0.16666666666667
23789, 2.1166666666667, 0.1, 0.16666666666667
23790, 2.1583333333333, 0.1, 0.16666666666667
23791, 1.2416666666667, 0.1, 0.20833333333333
23792, 1.2833333333333, 0.1, 0.20833333333333
23793, 1.325, 0.1, 0.20833333333333
23794, 1.3666666666667, 0.1, 0.20833333333333
23795, 1.4083333333333, 0.1, 0.20833333333333
23796, 1.45, 0.1, 0.20833333333333
23797, 1.4916666666667, 0.1, 0.20833333333333
23798, 1.5333333333333, 0.1, 0.20833333333333
23799, 1.575, 0.1, 0.20833333333333
23800, 1.6166666666667, 0.1, 0.20833333333333
23801, 1.6583333333333, 0.1, 0.20833333333333
23802, 1.7, 0.1, 0.20833333333333
23803, 1.7416666666667, 0.1, 0.20833333333333
23804, 1.7833333333333, 0.1, 0.20833333333333
23805, 1.825, 0.1, 0.20833333333333
23806, 1.8666666666667, 0.1, 0.20833333333333
23807, 1.9083333333333, 0.1, 0.20833333333333
23808, 1.95, 0.1, 0.20833333333333
23809, 1.9916666666667, 0.1, 0.20833333333333
23810, 2.0333333333333, 0.1, 0.20833333333333
23811, 2.075, 0.1, 0.20833333333333
23812, 2.1166666666667, 0.1, 0.20833333333333
23813, 2.1583333333333, 0.1, 0.20833333333333
23814, 1.2416666666667, 0.1, 0.25
23815, 1.2833333333333, 0.1, 0.25
23816, 1.325, 0.1, 0.25
23817, 1.3666666666667, 0.1, 0.25
23818, 1.4083333333333, 0.1, 0.25
23819, 1.45, 0.1, 0.25
23820, 1.4916666666667, 0.1, 0.25
23821, 1.5333333333333, 0.1, 0.25
23822, 1.575, 0.1, 0.25
23823, 1.6166666666667, 0.1, 0.25
