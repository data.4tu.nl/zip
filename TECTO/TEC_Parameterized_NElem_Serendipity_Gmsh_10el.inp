23567, 47011, 9861, 693, 8792, 47012, 9862, 694, 8793, 65250, 10965, 9332, 65503, 65251, 10966, 9333, 
65504, 65205, 10931, 717, 9299
23568, 47012, 9862, 694, 8793, 47013, 9863, 695, 8794, 65251, 10966, 9333, 65504, 65252, 10967, 9334, 
65505, 65208, 10933, 718, 9301
23569, 47013, 9863, 695, 8794, 47014, 9864, 696, 8795, 65252, 10967, 9334, 65505, 65253, 10968, 9335, 
65506, 65211, 10935, 719, 9303
23570, 47014, 9864, 696, 8795, 47015, 9865, 697, 8796, 65253, 10968, 9335, 65506, 65254, 10969, 9336, 
65507, 65214, 10937, 720, 9305
23571, 47015, 9865, 697, 8796, 47016, 9866, 698, 8797, 65254, 10969, 9336, 65507, 65255, 10970, 9337, 
65508, 65217, 10939, 721, 9307
23572, 47016, 9866, 698, 8797, 47017, 9867, 699, 8798, 65255, 10970, 9337, 65508, 65256, 10971, 9338, 
65509, 65220, 10941, 722, 9309
23573, 47017, 9867, 699, 8798, 47018, 9868, 700, 8799, 65256, 10971, 9338, 65509, 65257, 10972, 9339, 
65510, 65223, 10943, 723, 9311
23574, 47018, 9868, 700, 8799, 47019, 9869, 701, 8800, 65257, 10972, 9339, 65510, 65258, 10973, 9340, 
65511, 65226, 10945, 724, 9313
23575, 47019, 9869, 701, 8800, 47020, 9870, 702, 8801, 65258, 10973, 9340, 65511, 65259, 10974, 9341, 
65512, 65229, 10947, 725, 9315
23576, 47020, 9870, 702, 8801, 47021, 9871, 703, 8802, 65259, 10974, 9341, 65512, 65260, 10975, 9342, 
65513, 65232, 10949, 726, 9317
23577, 47021, 9871, 703, 8802, 47022, 9872, 704, 8803, 65260, 10975, 9342, 65513, 65261, 10976, 9343, 
65514, 65235, 10951, 727, 9319
23578, 47022, 9872, 704, 8803, 12022, 821, 15, 739, 65261, 10976, 9343, 65514, 12551, 845, 751, 
12562, 65238, 10953, 728, 9320
*ELEMENT, type=C3D20, ELSET=Volume4
23579, 14, 846, 11770, 635, 18, 990, 12631, 871, 857, 12023, 12024, 658, 1001, 12884, 12885, 
894, 870, 12620, 65515, 12563
23580, 846, 847, 11771, 11770, 990, 991, 12632, 12631, 858, 12025, 12026, 12023, 1002, 12886, 12887, 
12884, 12620, 12621, 65516, 65515
23581, 847, 848, 11772, 11771, 991, 992, 12633, 12632, 859, 12027, 12028, 12025, 1003, 12888, 12889, 
12886, 12621, 12622, 65517, 65516
23582, 848, 849, 11773, 11772, 992, 993, 12634, 12633, 860, 12029, 12030, 12027, 1004, 12890, 12891, 
12888, 12622, 12623, 65518, 65517
23583, 849, 850, 11774, 11773, 993, 994, 12635, 12634, 861, 12031, 12032, 12029, 1005, 12892, 12893, 
12890, 12623, 12624, 65519, 65518
23584, 850, 851, 11775, 11774, 994, 995, 12636, 12635, 862, 12033, 12034, 12031, 1006, 12894, 12895, 
12892, 12624, 12625, 65520, 65519
23585, 851, 852, 11776, 11775, 995, 996, 12637, 12636, 863, 12035, 12036, 12033, 1007, 12896, 12897, 
12894, 12625, 12626, 65521, 65520
23586, 852, 853, 11777, 11776, 996, 997, 12638, 12637, 864, 12037, 12038, 12035, 1008, 12898, 12899, 
12896, 12626, 12627, 65522, 65521
23587, 853, 854, 11778, 11777, 997, 998, 12639, 12638, 865, 12039, 12040, 12037, 1009, 12900, 12901, 
12898, 12627, 12628, 65523, 65522
23588, 854, 855, 11779, 11778, 998, 999, 12640, 12639, 866, 12041, 12042, 12039, 1010, 12902, 12903, 
12900, 12628, 12629, 65524, 65523
23589, 855, 856, 11780, 11779, 999, 1000, 12641, 12640, 867, 12043, 12044, 12041, 1011, 12904, 12905, 
12902, 12629, 12630, 65525, 65524
23590, 856, 16, 799, 11780, 1000, 20, 943, 12641, 868, 822, 12045, 12043, 1012, 966, 12906, 
12904, 12630, 942, 12597, 65525
23591, 635, 11770, 11781, 636, 871, 12631, 12642, 872, 12024, 12046, 12047, 659, 12885, 12907, 12908, 
895, 12563, 65515, 65526, 12564
23592, 11770, 11771, 11782, 11781, 12631, 12632, 12643, 12642, 12026, 12048, 12049, 12046, 12887, 12909, 12910, 
12907, 65515, 65516, 65527, 65526
23593, 11771, 11772, 11783, 11782, 12632, 12633, 12644, 12643, 12028, 12050, 12051, 12048, 12889, 12911, 12912, 
12909, 65516, 65517, 65528, 65527
23594, 11772, 11773, 11784, 11783, 12633, 12634, 12645, 12644, 12030, 12052, 12053, 12050, 12891, 12913, 12914, 
12911, 65517, 65518, 65529, 65528
23595, 11773, 11774, 11785, 11784, 12634, 12635, 12646, 12645, 12032, 12054, 12055, 12052, 12893, 12915, 12916, 
12913, 65518, 65519, 65530, 65529
23596, 11774, 11775, 11786, 11785, 12635, 12636, 12647, 12646, 12034, 12056, 12057, 12054, 12895, 12917, 12918, 
12915, 65519, 65520, 65531, 65530
23597, 11775, 11776, 11787, 11786, 12636, 12637, 12648, 12647, 12036, 12058, 12059, 12056, 12897, 12919, 12920, 
12917, 65520, 65521, 65532, 65531
23598, 11776, 11777, 11788, 11787, 12637, 12638, 12649, 12648, 12038, 12060, 12061, 12058, 12899, 12921, 12922, 
12919, 65521, 65522, 65533, 65532
23599, 11777, 11778, 11789, 11788, 12638, 12639, 12650, 12649, 12040, 12062, 12063, 12060, 12901, 12923, 12924, 
12921, 65522, 65523, 65534, 65533
23600, 11778, 11779, 11790, 11789, 12639, 12640, 12651, 12650, 12042, 12064, 12065, 12062, 12903, 12925, 12926, 
12923, 65523, 65524, 65535, 65534
23601, 11779, 11780, 11791, 11790, 12640, 12641, 12652, 12651, 12044, 12066, 12067, 12064, 12905, 12927, 12928, 
12925, 65524, 65525, 65536, 65535
23602, 11780, 799, 800, 11791, 12641, 943, 944, 12652, 12045, 823, 12068, 12066, 12906, 967, 12929, 
12927, 65525, 12597, 12598, 65536
23603, 636, 11781, 11792, 637, 872, 12642, 12653, 873, 12047, 12069, 12070, 660, 12908, 12930, 12931, 
896, 12564, 65526, 65537, 12565
23604, 11781, 11782, 11793, 11792, 12642, 12643, 12654, 12653, 12049, 12071, 12072, 12069, 12910, 12932, 12933, 
12930, 65526, 65527, 65538, 65537
23605, 11782, 11783, 11794, 11793, 12643, 12644, 12655, 12654, 12051, 12073, 12074, 12071, 12912, 12934, 12935, 
12932, 65527, 65528, 65539, 65538
23606, 11783, 11784, 11795, 11794, 12644, 12645, 12656, 12655, 12053, 12075, 12076, 12073, 12914, 12936, 12937, 
12934, 65528, 65529, 65540, 65539
23607, 11784, 11785, 11796, 11795, 12645, 12646, 12657, 12656, 12055, 12077, 12078, 12075, 12916, 12938, 12939, 
12936, 65529, 65530, 65541, 65540
23608, 11785, 11786, 11797, 11796, 12646, 12647, 12658, 12657, 12057, 12079, 12080, 12077, 12918, 12940, 12941, 
12938, 65530, 65531, 65542, 65541
23609, 11786, 11787, 11798, 11797, 12647, 12648, 12659, 12658, 12059, 12081, 12082, 12079, 12920, 12942, 12943, 
12940, 65531, 65532, 65543, 65542
23610, 11787, 11788, 11799, 11798, 12648, 12649, 12660, 12659, 12061, 12083, 12084, 12081, 12922, 12944, 12945, 
12942, 65532, 65533, 65544, 65543
23611, 11788, 11789, 11800, 11799, 12649, 12650, 12661, 12660, 12063, 12085, 12086, 12083, 12924, 12946, 12947, 
12944, 65533, 65534, 65545, 65544
23612, 11789, 11790, 11801, 11800, 12650, 12651, 12662, 12661, 12065, 12087, 12088, 12085, 12926, 12948, 12949, 
12946, 65534, 65535, 65546, 65545
23613, 11790, 11791, 11802, 11801, 12651, 12652, 12663, 12662, 12067, 12089, 12090, 12087, 12928, 12950, 12951, 
12948, 65535, 65536, 65547, 65546
23614, 11791, 800, 801, 11802, 12652, 944, 945, 12663, 12068, 824, 12091, 12089, 12929, 968, 12952, 
12950, 65536, 12598, 12599, 65547
23615, 637, 11792, 11803, 638, 873, 12653, 12664, 874, 12070, 12092, 12093, 661, 12931, 12953, 12954, 
897, 12565, 65537, 65548, 12566
23616, 11792, 11793, 11804, 11803, 12653, 12654, 12665, 12664, 12072, 12094, 12095, 12092, 12933, 12955, 12956, 
12953, 65537, 65538, 65549, 65548
23617, 11793, 11794, 11805, 11804, 12654, 12655, 12666, 12665, 12074, 12096, 12097, 12094, 12935, 12957, 12958, 
12955, 65538, 65539, 65550, 65549
23618, 11794, 11795, 11806, 11805, 12655, 12656, 12667, 12666, 12076, 12098, 12099, 12096, 12937, 12959, 12960, 
12957, 65539, 65540, 65551, 65550
23619, 11795, 11796, 11807, 11806, 12656, 12657, 12668, 12667, 12078, 12100, 12101, 12098, 12939, 12961, 12962, 
12959, 65540, 65541, 65552, 65551
23620, 11796, 11797, 11808, 11807, 12657, 12658, 12669, 12668, 12080, 12102, 12103, 12100, 12941, 12963, 12964, 
12961, 65541, 65542, 65553, 65552
23621, 11797, 11798, 11809, 11808, 12658, 12659, 12670, 12669, 12082, 12104, 12105, 12102, 12943, 12965, 12966, 
12963, 65542, 65543, 65554, 65553
23622, 11798, 11799, 11810, 11809, 12659, 12660, 12671, 12670, 12084, 12106, 12107, 12104, 12945, 12967, 12968, 
12965, 65543, 65544, 65555, 65554
23623, 11799, 11800, 11811, 11810, 12660, 12661, 12672, 12671, 12086, 12108, 12109, 12106, 12947, 12969, 12970, 
12967, 65544, 65545, 65556, 65555
23624, 11800, 11801, 11812, 11811, 12661, 12662, 12673, 12672, 12088, 12110, 12111, 12108, 12949, 12971, 12972, 
12969, 65545, 65546, 65557, 65556
23625, 11801, 11802, 11813, 11812, 12662, 12663, 12674, 12673, 12090, 12112, 12113, 12110, 12951, 12973, 12974, 
12971, 65546, 65547, 65558, 65557
23626, 11802, 801, 802, 11813, 12663, 945, 946, 12674, 12091, 825, 12114, 12112, 12952, 969, 12975, 
12973, 65547, 12599, 12600, 65558
23627, 638, 11803, 11814, 639, 874, 12664, 12675, 875, 12093, 12115, 12116, 662, 12954, 12976, 12977, 
898, 12566, 65548, 65559, 12567
23628, 11803, 11804, 11815, 11814, 12664, 12665, 12676, 12675, 12095, 12117, 12118, 12115, 12956, 12978, 12979, 
12976, 65548, 65549, 65560, 65559
23629, 11804, 11805, 11816, 11815, 12665, 12666, 12677, 12676, 12097, 12119, 12120, 12117, 12958, 12980, 12981, 
12978, 65549, 65550, 65561, 65560
23630, 11805, 11806, 11817, 11816, 12666, 12667, 12678, 12677, 12099, 12121, 12122, 12119, 12960, 12982, 12983, 
12980, 65550, 65551, 65562, 65561
23631, 11806, 11807, 11818, 11817, 12667, 12668, 12679, 12678, 12101, 12123, 12124, 12121, 12962, 12984, 12985, 
12982, 65551, 65552, 65563, 65562
23632, 11807, 11808, 11819, 11818, 12668, 12669, 12680, 12679, 12103, 12125, 12126, 12123, 12964, 12986, 12987, 
12984, 65552, 65553, 65564, 65563
23633, 11808, 11809, 11820, 11819, 12669, 12670, 12681, 12680, 12105, 12127, 12128, 12125, 12966, 12988, 12989, 
12986, 65553, 65554, 65565, 65564
23634, 11809, 11810, 11821, 11820, 12670, 12671, 12682, 12681, 12107, 12129, 12130, 12127, 12968, 12990, 12991, 
12988, 65554, 65555, 65566, 65565
23635, 11810, 11811, 11822, 11821, 12671, 12672, 12683, 12682, 12109, 12131, 12132, 12129, 12970, 12992, 12993, 
12990, 65555, 65556, 65567, 65566
23636, 11811, 11812, 11823, 11822, 12672, 12673, 12684, 12683, 12111, 12133, 12134, 12131, 12972, 12994, 12995, 
12992, 65556, 65557, 65568, 65567
23637, 11812, 11813, 11824, 11823, 12673, 12674, 12685, 12684, 12113, 12135, 12136, 12133, 12974, 12996, 12997, 
12994, 65557, 65558, 65569, 65568
23638, 11813, 802, 803, 11824, 12674, 946, 947, 12685, 12114, 826, 12137, 12135, 12975, 970, 12998, 
12996, 65558, 12600, 12601, 65569
23639, 639, 11814, 11825, 640, 875, 12675, 12686, 876, 12116, 12138, 12139, 663, 12977, 12999, 13000, 
899, 12567, 65559, 65570, 12568
23640, 11814, 11815, 11826, 11825, 12675, 12676, 12687, 12686, 12118, 12140, 12141, 12138, 12979, 13001, 13002, 
12999, 65559, 65560, 65571, 65570
23641, 11815, 11816, 11827, 11826, 12676, 12677, 12688, 12687, 12120, 12142, 12143, 12140, 12981, 13003, 13004, 
13001, 65560, 65561, 65572, 65571
23642, 11816, 11817, 11828, 11827, 12677, 12678, 12689, 12688, 12122, 12144, 12145, 12142, 12983, 13005, 13006, 
13003, 65561, 65562, 65573, 65572
23643, 11817, 11818, 11829, 11828, 12678, 12679, 12690, 12689, 12124, 12146, 12147, 12144, 12985, 13007, 13008, 
13005, 65562, 65563, 65574, 65573
23644, 11818, 11819, 11830, 11829, 12679, 12680, 12691, 12690, 12126, 12148, 12149, 12146, 12987, 13009, 13010, 
13007, 65563, 65564, 65575, 65574
23645, 11819, 11820, 11831, 11830, 12680, 12681, 12692, 12691, 12128, 12150, 12151, 12148, 12989, 13011, 13012, 
13009, 65564, 65565, 65576, 65575
23646, 11820, 11821, 11832, 11831, 12681, 12682, 12693, 12692, 12130, 12152, 12153, 12150, 12991, 13013, 13014, 
13011, 65565, 65566, 65577, 65576
23647, 11821, 11822, 11833, 11832, 12682, 12683, 12694, 12693, 12132, 12154, 12155, 12152, 12993, 13015, 13016, 
13013, 65566, 65567, 65578, 65577
23648, 11822, 11823, 11834, 11833, 12683, 12684, 12695, 12694, 12134, 12156, 12157, 12154, 12995, 13017, 13018, 
13015, 65567, 65568, 65579, 65578
23649, 11823, 11824, 11835, 11834, 12684, 12685, 12696, 12695, 12136, 12158, 12159, 12156, 12997, 13019, 13020, 
13017, 65568, 65569, 65580, 65579
23650, 11824, 803, 804, 11835, 12685, 947, 948, 12696, 12137, 827, 12160, 12158, 12998, 971, 13021, 
13019, 65569, 12601, 12602, 65580
23651, 640, 11825, 11836, 641, 876, 12686, 12697, 877, 12139, 12161, 12162, 664, 13000, 13022, 13023, 
900, 12568, 65570, 65581, 12569
23652, 11825, 11826, 11837, 11836, 12686, 12687, 12698, 12697, 12141, 12163, 12164, 12161, 13002, 13024, 13025, 
13022, 65570, 65571, 65582, 65581
23653, 11826, 11827, 11838, 11837, 12687, 12688, 12699, 12698, 12143, 12165, 12166, 12163, 13004, 13026, 13027, 
13024, 65571, 65572, 65583, 65582
23654, 11827, 11828, 11839, 11838, 12688, 12689, 12700, 12699, 12145, 12167, 12168, 12165, 13006, 13028, 13029, 
13026, 65572, 65573, 65584, 65583
23655, 11828, 11829, 11840, 11839, 12689, 12690, 12701, 12700, 12147, 12169, 12170, 12167, 13008, 13030, 13031, 
13028, 65573, 65574, 65585, 65584
23656, 11829, 11830, 11841, 11840, 12690, 12691, 12702, 12701, 12149, 12171, 12172, 12169, 13010, 13032, 13033, 
13030, 65574, 65575, 65586, 65585
23657, 11830, 11831, 11842, 11841, 12691, 12692, 12703, 12702, 12151, 12173, 12174, 12171, 13012, 13034, 13035, 
13032, 65575, 65576, 65587, 65586
23658, 11831, 11832, 11843, 11842, 12692, 12693, 12704, 12703, 12153, 12175, 12176, 12173, 13014, 13036, 13037, 
13034, 65576, 65577, 65588, 65587
23659, 11832, 11833, 11844, 11843, 12693, 12694, 12705, 12704, 12155, 12177, 12178, 12175, 13016, 13038, 13039, 
13036, 65577, 65578, 65589, 65588
23660, 11833, 11834, 11845, 11844, 12694, 12695, 12706, 12705, 12157, 12179, 12180, 12177, 13018, 13040, 13041, 
13038, 65578, 65579, 65590, 65589
23661, 11834, 11835, 11846, 11845, 12695, 12696, 12707, 12706, 12159, 12181, 12182, 12179, 13020, 13042, 13043, 
13040, 65579, 65580, 65591, 65590
23662, 11835, 804, 805, 11846, 12696, 948, 949, 12707, 12160, 828, 12183, 12181, 13021, 972, 13044, 
13042, 65580, 12602, 12603, 65591
23663, 641, 11836, 11847, 642, 877, 12697, 12708, 878, 12162, 12184, 12185, 665, 13023, 13045, 13046, 
901, 12569, 65581, 65592, 12570
23664, 11836, 11837, 11848, 11847, 12697, 12698, 12709, 12708, 12164, 12186, 12187, 12184, 13025, 13047, 13048, 
13045, 65581, 65582, 65593, 65592
23665, 11837, 11838, 11849, 11848, 12698, 12699, 12710, 12709, 12166, 12188, 12189, 12186, 13027, 13049, 13050, 
13047, 65582, 65583, 65594, 65593
23666, 11838, 11839, 11850, 11849, 12699, 12700, 12711, 12710, 12168, 12190, 12191, 12188, 13029, 13051, 13052, 
13049, 65583, 65584, 65595, 65594
23667, 11839, 11840, 11851, 11850, 12700, 12701, 12712, 12711, 12170, 12192, 12193, 12190, 13031, 13053, 13054, 
13051, 65584, 65585, 65596, 65595
23668, 11840, 11841, 11852, 11851, 12701, 12702, 12713, 12712, 12172, 12194, 12195, 12192, 13033, 13055, 13056, 
13053, 65585, 65586, 65597, 65596
23669, 11841, 11842, 11853, 11852, 12702, 12703, 12714, 12713, 12174, 12196, 12197, 12194, 13035, 13057, 13058, 
13055, 65586, 65587, 65598, 65597
23670, 11842, 11843, 11854, 11853, 12703, 12704, 12715, 12714, 12176, 12198, 12199, 12196, 13037, 13059, 13060, 
13057, 65587, 65588, 65599, 65598
23671, 11843, 11844, 11855, 11854, 12704, 12705, 12716, 12715, 12178, 12200, 12201, 12198, 13039, 13061, 13062, 
13059, 65588, 65589, 65600, 65599
23672, 11844, 11845, 11856, 11855, 12705, 12706, 12717, 12716, 12180, 12202, 12203, 12200, 13041, 13063, 13064, 
13061, 65589, 65590, 65601, 65600
23673, 11845, 11846, 11857, 11856, 12706, 12707, 12718, 12717, 12182, 12204, 12205, 12202, 13043, 13065, 13066, 
13063, 65590, 65591, 65602, 65601
23674, 11846, 805, 806, 11857, 12707, 949, 950, 12718, 12183, 829, 12206, 12204, 13044, 973, 13067, 
13065, 65591, 12603, 12604, 65602
23675, 642, 11847, 11858, 643, 878, 12708, 12719, 879, 12185, 12207, 12208, 666, 13046, 13068, 13069, 
902, 12570, 65592, 65603, 12571
23676, 11847, 11848, 11859, 11858, 12708, 12709, 12720, 12719, 12187, 12209, 12210, 12207, 13048, 13070, 13071, 
13068, 65592, 65593, 65604, 65603
23677, 11848, 11849, 11860, 11859, 12709, 12710, 12721, 12720, 12189, 12211, 12212, 12209, 13050, 13072, 13073, 
13070, 65593, 65594, 65605, 65604
23678, 11849, 11850, 11861, 11860, 12710, 12711, 12722, 12721, 12191, 12213, 12214, 12211, 13052, 13074, 13075, 
13072, 65594, 65595, 65606, 65605
23679, 11850, 11851, 11862, 11861, 12711, 12712, 12723, 12722, 12193, 12215, 12216, 12213, 13054, 13076, 13077, 
13074, 65595, 65596, 65607, 65606
23680, 11851, 11852, 11863, 11862, 12712, 12713, 12724, 12723, 12195, 12217, 12218, 12215, 13056, 13078, 13079, 
13076, 65596, 65597, 65608, 65607
23681, 11852, 11853, 11864, 11863, 12713, 12714, 12725, 12724, 12197, 12219, 12220, 12217, 13058, 13080, 13081, 
13078, 65597, 65598, 65609, 65608
23682, 11853, 11854, 11865, 11864, 12714, 12715, 12726, 12725, 12199, 12221, 12222, 12219, 13060, 13082, 13083, 
13080, 65598, 65599, 65610, 65609
23683, 11854, 11855, 11866, 11865, 12715, 12716, 12727, 12726, 12201, 12223, 12224, 12221, 13062, 13084, 13085, 
13082, 65599, 65600, 65611, 65610
23684, 11855, 11856, 11867, 11866, 12716, 12717, 12728, 12727, 12203, 12225, 12226, 12223, 13064, 13086, 13087, 
13084, 65600, 65601, 65612, 65611
23685, 11856, 11857, 11868, 11867, 12717, 12718, 12729, 12728, 12205, 12227, 12228, 12225, 13066, 13088, 13089, 
13086, 65601, 65602, 65613, 65612
23686, 11857, 806, 807, 11868, 12718, 950, 951, 12729, 12206, 830, 12229, 12227, 13067, 974, 13090, 
13088, 65602, 12604, 12605, 65613
23687, 643, 11858, 11869, 644, 879, 12719, 12730, 880, 12208, 12230, 12231, 667, 13069, 13091, 13092, 
903, 12571, 65603, 65614, 12572
23688, 11858, 11859, 11870, 11869, 12719, 12720, 12731, 12730, 12210, 12232, 12233, 12230, 13071, 13093, 13094, 
13091, 65603, 65604, 65615, 65614
23689, 11859, 11860, 11871, 11870, 12720, 12721, 12732, 12731, 12212, 12234, 12235, 12232, 13073, 13095, 13096, 
13093, 65604, 65605, 65616, 65615
23690, 11860, 11861, 11872, 11871, 12721, 12722, 12733, 12732, 12214, 12236, 12237, 12234, 13075, 13097, 13098, 
13095, 65605, 65606, 65617, 65616
23691, 11861, 11862, 11873, 11872, 12722, 12723, 12734, 12733, 12216, 12238, 12239, 12236, 13077, 13099, 13100, 
13097, 65606, 65607, 65618, 65617
23692, 11862, 11863, 11874, 11873, 12723, 12724, 12735, 12734, 12218, 12240, 12241, 12238, 13079, 13101, 13102, 
13099, 65607, 65608, 65619, 65618
23693, 11863, 11864, 11875, 11874, 12724, 12725, 12736, 12735, 12220, 12242, 12243, 12240, 13081, 13103, 13104, 
13101, 65608, 65609, 65620, 65619
23694, 11864, 11865, 11876, 11875, 12725, 12726, 12737, 12736, 12222, 12244, 12245, 12242, 13083, 13105, 13106, 
13103, 65609, 65610, 65621, 65620
23695, 11865, 11866, 11877, 11876, 12726, 12727, 12738, 12737, 12224, 12246, 12247, 12244, 13085, 13107, 13108, 
13105, 65610, 65611, 65622, 65621
23696, 11866, 11867, 11878, 11877, 12727, 12728, 12739, 12738, 12226, 12248, 12249, 12246, 13087, 13109, 13110, 
13107, 65611, 65612, 65623, 65622
23697, 11867, 11868, 11879, 11878, 12728, 12729, 12740, 12739, 12228, 12250, 12251, 12248, 13089, 13111, 13112, 
13109, 65612, 65613, 65624, 65623
23698, 11868, 807, 808, 11879, 12729, 951, 952, 12740, 12229, 831, 12252, 12250, 13090, 975, 13113, 
13111, 65613, 12605, 12606, 65624
23699, 644, 11869, 11880, 645, 880, 12730, 12741, 881, 12231, 12253, 12254, 668, 13092, 13114, 13115, 
904, 12572, 65614, 65625, 12573
23700, 11869, 11870, 11881, 11880, 12730, 12731, 12742, 12741, 12233, 12255, 12256, 12253, 13094, 13116, 13117, 
13114, 65614, 65615, 65626, 65625
23701, 11870, 11871, 11882, 11881, 12731, 12732, 12743, 12742, 12235, 12257, 12258, 12255, 13096, 13118, 13119, 
13116, 65615, 65616, 65627, 65626
23702, 11871, 11872, 11883, 11882, 12732, 12733, 12744, 12743, 12237, 12259, 12260, 12257, 13098, 13120, 13121, 
13118, 65616, 65617, 65628, 65627
23703, 11872, 11873, 11884, 11883, 12733, 12734, 12745, 12744, 12239, 12261, 12262, 12259, 13100, 13122, 13123, 
13120, 65617, 65618, 65629, 65628
23704, 11873, 11874, 11885, 11884, 12734, 12735, 12746, 12745, 12241, 12263, 12264, 12261, 13102, 13124, 13125, 
13122, 65618, 65619, 65630, 65629
23705, 11874, 11875, 11886, 11885, 12735, 12736, 12747, 12746, 12243, 12265, 12266, 12263, 13104, 13126, 13127, 
13124, 65619, 65620, 65631, 65630
23706, 11875, 11876, 11887, 11886, 12736, 12737, 12748, 12747, 12245, 12267, 12268, 12265, 13106, 13128, 13129, 
13126, 65620, 65621, 65632, 65631
23707, 11876, 11877, 11888, 11887, 12737, 12738, 12749, 12748, 12247, 12269, 12270, 12267, 13108, 13130, 13131, 
13128, 65621, 65622, 65633, 65632
23708, 11877, 11878, 11889, 11888, 12738, 12739, 12750, 12749, 12249, 12271, 12272, 12269, 13110, 13132, 13133, 
13130, 65622, 65623, 65634, 65633
23709, 11878, 11879, 11890, 11889, 12739, 12740, 12751, 12750, 12251, 12273, 12274, 12271, 13112, 13134, 13135, 
13132, 65623, 65624, 65635, 65634
23710, 11879, 808, 809, 11890, 12740, 952, 953, 12751, 12252, 832, 12275, 12273, 13113, 976, 13136, 
13134, 65624, 12606, 12607, 65635
23711, 645, 11880, 11891, 646, 881, 12741, 12752, 882, 12254, 12276, 12277, 669, 13115, 13137, 13138, 
905, 12573, 65625, 65636, 12574
23712, 11880, 11881, 11892, 11891, 12741, 12742, 12753, 12752, 12256, 12278, 12279, 12276, 13117, 13139, 13140, 
13137, 65625, 65626, 65637, 65636
23713, 11881, 11882, 11893, 11892, 12742, 12743, 12754, 12753, 12258, 12280, 12281, 12278, 13119, 13141, 13142, 
13139, 65626, 65627, 65638, 65637
23714, 11882, 11883, 11894, 11893, 12743, 12744, 12755, 12754, 12260, 12282, 12283, 12280, 13121, 13143, 13144, 
13141, 65627, 65628, 65639, 65638
23715, 11883, 11884, 11895, 11894, 12744, 12745, 12756, 12755, 12262, 12284, 12285, 12282, 13123, 13145, 13146, 
13143, 65628, 65629, 65640, 65639
23716, 11884, 11885, 11896, 11895, 12745, 12746, 12757, 12756, 12264, 12286, 12287, 12284, 13125, 13147, 13148, 
13145, 65629, 65630, 65641, 65640
23717, 11885, 11886, 11897, 11896, 12746, 12747, 12758, 12757, 12266, 12288, 12289, 12286, 13127, 13149, 13150, 
13147, 65630, 65631, 65642, 65641
23718, 11886, 11887, 11898, 11897, 12747, 12748, 12759, 12758, 12268, 12290, 12291, 12288, 13129, 13151, 13152, 
13149, 65631, 65632, 65643, 65642
23719, 11887, 11888, 11899, 11898, 12748, 12749, 12760, 12759, 12270, 12292, 12293, 12290, 13131, 13153, 13154, 
13151, 65632, 65633, 65644, 65643
23720, 11888, 11889, 11900, 11899, 12749, 12750, 12761, 12760, 12272, 12294, 12295, 12292, 13133, 13155, 13156, 
13153, 65633, 65634, 65645, 65644
23721, 11889, 11890, 11901, 11900, 12750, 12751, 12762, 12761, 12274, 12296, 12297, 12294, 13135, 13157, 13158, 
13155, 65634, 65635, 65646, 65645
23722, 11890, 809, 810, 11901, 12751, 953, 954, 12762, 12275, 833, 12298, 12296, 13136, 977, 13159, 
13157, 65635, 12607, 12608, 65646
23723, 646, 11891, 11902, 647, 882, 12752, 12763, 883, 12277, 12299, 12300, 670, 13138, 13160, 13161, 
906, 12574, 65636, 65647, 12575
23724, 11891, 11892, 11903, 11902, 12752, 12753, 12764, 12763, 12279, 12301, 12302, 12299, 13140, 13162, 13163, 
13160, 65636, 65637, 65648, 65647
23725, 11892, 11893, 11904, 11903, 12753, 12754, 12765, 12764, 12281, 12303, 12304, 12301, 13142, 13164, 13165, 
13162, 65637, 65638, 65649, 65648
23726, 11893, 11894, 11905, 11904, 12754, 12755, 12766, 12765, 12283, 12305, 12306, 12303, 13144, 13166, 13167, 
13164, 65638, 65639, 65650, 65649
23727, 11894, 11895, 11906, 11905, 12755, 12756, 12767, 12766, 12285, 12307, 12308, 12305, 13146, 13168, 13169, 
13166, 65639, 65640, 65651, 65650
23728, 11895, 11896, 11907, 11906, 12756, 12757, 12768, 12767, 12287, 12309, 12310, 12307, 13148, 13170, 13171, 
13168, 65640, 65641, 65652, 65651
23729, 11896, 11897, 11908, 11907, 12757, 12758, 12769, 12768, 12289, 12311, 12312, 12309, 13150, 13172, 13173, 
13170, 65641, 65642, 65653, 65652
23730, 11897, 11898, 11909, 11908, 12758, 12759, 12770, 12769, 12291, 12313, 12314, 12311, 13152, 13174, 13175, 
13172, 65642, 65643, 65654, 65653
23731, 11898, 11899, 11910, 11909, 12759, 12760, 12771, 12770, 12293, 12315, 12316, 12313, 13154, 13176, 13177, 
13174, 65643, 65644, 65655, 65654
23732, 11899, 11900, 11911, 11910, 12760, 12761, 12772, 12771, 12295, 12317, 12318, 12315, 13156, 13178, 13179, 
13176, 65644, 65645, 65656, 65655
23733, 11900, 11901, 11912, 11911, 12761, 12762, 12773, 12772, 12297, 12319, 12320, 12317, 13158, 13180, 13181, 
13178, 65645, 65646, 65657, 65656
23734, 11901, 810, 811, 11912, 12762, 954, 955, 12773, 12298, 834, 12321, 12319, 13159, 978, 13182, 
13180, 65646, 12608, 12609, 65657
23735, 647, 11902, 11913, 648, 883, 12763, 12774, 884, 12300, 12322, 12323, 671, 13161, 13183, 13184, 
907, 12575, 65647, 65658, 12576
23736, 11902, 11903, 11914, 11913, 12763, 12764, 12775, 12774, 12302, 12324, 12325, 12322, 13163, 13185, 13186, 
13183, 65647, 65648, 65659, 65658
23737, 11903, 11904, 11915, 11914, 12764, 12765, 12776, 12775, 12304, 12326, 12327, 12324, 13165, 13187, 13188, 
13185, 65648, 65649, 65660, 65659
23738, 11904, 11905, 11916, 11915, 12765, 12766, 12777, 12776, 12306, 12328, 12329, 12326, 13167, 13189, 13190, 
13187, 65649, 65650, 65661, 65660
23739, 11905, 11906, 11917, 11916, 12766, 12767, 12778, 12777, 12308, 12330, 12331, 12328, 13169, 13191, 13192, 
13189, 65650, 65651, 65662, 65661
23740, 11906, 11907, 11918, 11917, 12767, 12768, 12779, 12778, 12310, 12332, 12333, 12330, 13171, 13193, 13194, 
13191, 65651, 65652, 65663, 65662
23741, 11907, 11908, 11919, 11918, 12768, 12769, 12780, 12779, 12312, 12334, 12335, 12332, 13173, 13195, 13196, 
13193, 65652, 65653, 65664, 65663
23742, 11908, 11909, 11920, 11919, 12769, 12770, 12781, 12780, 12314, 12336, 12337, 12334, 13175, 13197, 13198, 
13195, 65653, 65654, 65665, 65664
23743, 11909, 11910, 11921, 11920, 12770, 12771, 12782, 12781, 12316, 12338, 12339, 12336, 13177, 13199, 13200, 
13197, 65654, 65655, 65666, 65665
23744, 11910, 11911, 11922, 11921, 12771, 12772, 12783, 12782, 12318, 12340, 12341, 12338, 13179, 13201, 13202, 
13199, 65655, 65656, 65667, 65666
23745, 11911, 11912, 11923, 11922, 12772, 12773, 12784, 12783, 12320, 12342, 12343, 12340, 13181, 13203, 13204, 
13201, 65656, 65657, 65668, 65667
23746, 11912, 811, 812, 11923, 12773, 955, 956, 12784, 12321, 835, 12344, 12342, 13182, 979, 13205, 
13203, 65657, 12609, 12610, 65668
23747, 648, 11913, 11924, 649, 884, 12774, 12785, 885, 12323, 12345, 12346, 672, 13184, 13206, 13207, 
908, 12576, 65658, 65669, 12577
23748, 11913, 11914, 11925, 11924, 12774, 12775, 12786, 12785, 12325, 12347, 12348, 12345, 13186, 13208, 13209, 
13206, 65658, 65659, 65670, 65669
23749, 11914, 11915, 11926, 11925, 12775, 12776, 12787, 12786, 12327, 12349, 12350, 12347, 13188, 13210, 13211, 
13208, 65659, 65660, 65671, 65670
23750, 11915, 11916, 11927, 11926, 12776, 12777, 12788, 12787, 12329, 12351, 12352, 12349, 13190, 13212, 13213, 
13210, 65660, 65661, 65672, 65671
23751, 11916, 11917, 11928, 11927, 12777, 12778, 12789, 12788, 12331, 12353, 12354, 12351, 13192, 13214, 13215, 
13212, 65661, 65662, 65673, 65672
23752, 11917, 11918, 11929, 11928, 12778, 12779, 12790, 12789, 12333, 12355, 12356, 12353, 13194, 13216, 13217, 
13214, 65662, 65663, 65674, 65673
23753, 11918, 11919, 11930, 11929, 12779, 12780, 12791, 12790, 12335, 12357, 12358, 12355, 13196, 13218, 13219, 
13216, 65663, 65664, 65675, 65674
23754, 11919, 11920, 11931, 11930, 12780, 12781, 12792, 12791, 12337, 12359, 12360, 12357, 13198, 13220, 13221, 
13218, 65664, 65665, 65676, 65675
23755, 11920, 11921, 11932, 11931, 12781, 12782, 12793, 12792, 12339, 12361, 12362, 12359, 13200, 13222, 13223, 
13220, 65665, 65666, 65677, 65676
23756, 11921, 11922, 11933, 11932, 12782, 12783, 12794, 12793, 12341, 12363, 12364, 12361, 13202, 13224, 13225, 
13222, 65666, 65667, 65678, 65677
23757, 11922, 11923, 11934, 11933, 12783, 12784, 12795, 12794, 12343, 12365, 12366, 12363, 13204, 13226, 13227, 
13224, 65667, 65668, 65679, 65678
23758, 11923, 812, 813, 11934, 12784, 956, 957, 12795, 12344, 836, 12367, 12365, 13205, 980, 13228, 
13226, 65668, 12610, 12611, 65679
23759, 649, 11924, 11935, 650, 885, 12785, 12796, 886, 12346, 12368, 12369, 673, 13207, 13229, 13230, 
909, 12577, 65669, 65680, 12578
23760, 11924, 11925, 11936, 11935, 12785, 12786, 12797, 12796, 12348, 12370, 12371, 12368, 13209, 13231, 13232, 
13229, 65669, 65670, 65681, 65680
23761, 11925, 11926, 11937, 11936, 12786, 12787, 12798, 12797, 12350, 12372, 12373, 12370, 13211, 13233, 13234, 
13231, 65670, 65671, 65682, 65681
23762, 11926, 11927, 11938, 11937, 12787, 12788, 12799, 12798, 12352, 12374, 12375, 12372, 13213, 13235, 13236, 
13233, 65671, 65672, 65683, 65682
23763, 11927, 11928, 11939, 11938, 12788, 12789, 12800, 12799, 12354, 12376, 12377, 12374, 13215, 13237, 13238, 
13235, 65672, 65673, 65684, 65683
23764, 11928, 11929, 11940, 11939, 12789, 12790, 12801, 12800, 12356, 12378, 12379, 12376, 13217, 13239, 13240, 
13237, 65673, 65674, 65685, 65684
23765, 11929, 11930, 11941, 11940, 12790, 12791, 12802, 12801, 12358, 12380, 12381, 12378, 13219, 13241, 13242, 
13239, 65674, 65675, 65686, 65685
23766, 11930, 11931, 11942, 11941, 12791, 12792, 12803, 12802, 12360, 12382, 12383, 12380, 13221, 13243, 13244, 
13241, 65675, 65676, 65687, 65686
23767, 11931, 11932, 11943, 11942, 12792, 12793, 12804, 12803, 12362, 12384, 12385, 12382, 13223, 13245, 13246, 
13243, 65676, 65677, 65688, 65687
23768, 11932, 11933, 11944, 11943, 12793, 12794, 12805, 12804, 12364, 12386, 12387, 12384, 13225, 13247, 13248, 
13245, 65677, 65678, 65689, 65688
23769, 11933, 11934, 11945, 11944, 12794, 12795, 12806, 12805, 12366, 12388, 12389, 12386, 13227, 13249, 13250, 
13247, 65678, 65679, 65690, 65689
23770, 11934, 813, 814, 11945, 12795, 957, 958, 12806, 12367, 837, 12390, 12388, 13228, 981, 13251, 
13249, 65679, 12611, 12612, 65690
23771, 650, 11935, 11946, 651, 886, 12796, 12807, 887, 12369, 12391, 12392, 674, 13230, 13252, 13253, 
910, 12578, 65680, 65691, 12579
23772, 11935, 11936, 11947, 11946, 12796, 12797, 12808, 12807, 12371, 12393, 12394, 12391, 13232, 13254, 13255, 
13252, 65680, 65681, 65692, 65691
23773, 11936, 11937, 11948, 11947, 12797, 12798, 12809, 12808, 12373, 12395, 12396, 12393, 13234, 13256, 13257, 
13254, 65681, 65682, 65693, 65692
23774, 11937, 11938, 11949, 11948, 12798, 12799, 12810, 12809, 12375, 12397, 12398, 12395, 13236, 13258, 13259, 
13256, 65682, 65683, 65694, 65693
23775, 11938, 11939, 11950, 11949, 12799, 12800, 12811, 12810, 12377, 12399, 12400, 12397, 13238, 13260, 13261, 
13258, 65683, 65684, 65695, 65694
23776, 11939, 11940, 11951, 11950, 12800, 12801, 12812, 12811, 12379, 12401, 12402, 12399, 13240, 13262, 13263, 
13260, 65684, 65685, 65696, 65695
23777, 11940, 11941, 11952, 11951, 12801, 12802, 12813, 12812, 12381, 12403, 12404, 12401, 13242, 13264, 13265, 
13262, 65685, 65686, 65697, 65696
23778, 11941, 11942, 11953, 11952, 12802, 12803, 12814, 12813, 12383, 12405, 12406, 12403, 13244, 13266, 13267, 
13264, 65686, 65687, 65698, 65697
23779, 11942, 11943, 11954, 11953, 12803, 12804, 12815, 12814, 12385, 12407, 12408, 12405, 13246, 13268, 13269, 
13266, 65687, 65688, 65699, 65698
23780, 11943, 11944, 11955, 11954, 12804, 12805, 12816, 12815, 12387, 12409, 12410, 12407, 13248, 13270, 13271, 
13268, 65688, 65689, 65700, 65699
23781, 11944, 11945, 11956, 11955, 12805, 12806, 12817, 12816, 12389, 12411, 12412, 12409, 13250, 13272, 13273, 
13270, 65689, 65690, 65701, 65700
23782, 11945, 814, 815, 11956, 12806, 958, 959, 12817, 12390, 838, 12413, 12411, 13251, 982, 13274, 
13272, 65690, 12612, 12613, 65701
23783, 651, 11946, 11957, 652, 887, 12807, 12818, 888, 12392, 12414, 12415, 675, 13253, 13275, 13276, 
911, 12579, 65691, 65702, 12580
23784, 11946, 11947, 11958, 11957, 12807, 12808, 12819, 12818, 12394, 12416, 12417, 12414, 13255, 13277, 13278, 
13275, 65691, 65692, 65703, 65702
23785, 11947, 11948, 11959, 11958, 12808, 12809, 12820, 12819, 12396, 12418, 12419, 12416, 13257, 13279, 13280, 
13277, 65692, 65693, 65704, 65703
23786, 11948, 11949, 11960, 11959, 12809, 12810, 12821, 12820, 12398, 12420, 12421, 12418, 13259, 13281, 13282, 
13279, 65693, 65694, 65705, 65704
23787, 11949, 11950, 11961, 11960, 12810, 12811, 12822, 12821, 12400, 12422, 12423, 12420, 13261, 13283, 13284, 
13281, 65694, 65695, 65706, 65705
23788, 11950, 11951, 11962, 11961, 12811, 12812, 12823, 12822, 12402, 12424, 12425, 12422, 13263, 13285, 13286, 
13283, 65695, 65696, 65707, 65706
23789, 11951, 11952, 11963, 11962, 12812, 12813, 12824, 12823, 12404, 12426, 12427, 12424, 13265, 13287, 13288, 
13285, 65696, 65697, 65708, 65707
23790, 11952, 11953, 11964, 11963, 12813, 12814, 12825, 12824, 12406, 12428, 12429, 12426, 13267, 13289, 13290, 
13287, 65697, 65698, 65709, 65708
23791, 11953, 11954, 11965, 11964, 12814, 12815, 12826, 12825, 12408, 12430, 12431, 12428, 13269, 13291, 13292, 
13289, 65698, 65699, 65710, 65709
23792, 11954, 11955, 11966, 11965, 12815, 12816, 12827, 12826, 12410, 12432, 12433, 12430, 13271, 13293, 13294, 
13291, 65699, 65700, 65711, 65710
23793, 11955, 11956, 11967, 11966, 12816, 12817, 12828, 12827, 12412, 12434, 12435, 12432, 13273, 13295, 13296, 
13293, 65700, 65701, 65712, 65711
23794, 11956, 815, 816, 11967, 12817, 959, 960, 12828, 12413, 839, 12436, 12434, 13274, 983, 13297, 
13295, 65701, 12613, 12614, 65712
23795, 652, 11957, 11968, 653, 888, 12818, 12829, 889, 12415, 12437, 12438, 676, 13276, 13298, 13299, 
912, 12580, 65702, 65713, 12581
23796, 11957, 11958, 11969, 11968, 12818, 12819, 12830, 12829, 12417, 12439, 12440, 12437, 13278, 13300, 13301, 
13298, 65702, 65703, 65714, 65713
23797, 11958, 11959, 11970, 11969, 12819, 12820, 12831, 12830, 12419, 12441, 12442, 12439, 13280, 13302, 13303, 
13300, 65703, 65704, 65715, 65714
23798, 11959, 11960, 11971, 11970, 12820, 12821, 12832, 12831, 12421, 12443, 12444, 12441, 13282, 13304, 13305, 
13302, 65704, 65705, 65716, 65715
23799, 11960, 11961, 11972, 11971, 12821, 12822, 12833, 12832, 12423, 12445, 12446, 12443, 13284, 13306, 13307, 
13304, 65705, 65706, 65717, 65716
23800, 11961, 11962, 11973, 11972, 12822, 12823, 12834, 12833, 12425, 12447, 12448, 12445, 13286, 13308, 13309, 
13306, 65706, 65707, 65718, 65717
23801, 11962, 11963, 11974, 11973, 12823, 12824, 12835, 12834, 12427, 12449, 12450, 12447, 13288, 13310, 13311, 
13308, 65707, 65708, 65719, 65718
23802, 11963, 11964, 11975, 11974, 12824, 12825, 12836, 12835, 12429, 12451, 12452, 12449, 13290, 13312, 13313, 
13310, 65708, 65709, 65720, 65719
23803, 11964, 11965, 11976, 11975, 12825, 12826, 12837, 12836, 12431, 12453, 12454, 12451, 13292, 13314, 13315, 
13312, 65709, 65710, 65721, 65720
23804, 11965, 11966, 11977, 11976, 12826, 12827, 12838, 12837, 12433, 12455, 12456, 12453, 13294, 13316, 13317, 
13314, 65710, 65711, 65722, 65721
23805, 11966, 11967, 11978, 11977, 12827, 12828, 12839, 12838, 12435, 12457, 12458, 12455, 13296, 13318, 13319, 
13316, 65711, 65712, 65723, 65722
23806, 11967, 816, 817, 11978, 12828, 960, 961, 12839, 12436, 840, 12459, 12457, 13297, 984, 13320, 
13318, 65712, 12614, 12615, 65723
23807, 653, 11968, 11979, 654, 889, 12829, 12840, 890, 12438, 12460, 12461, 677, 13299, 13321, 13322, 
913, 12581, 65713, 65724, 12582
23808, 11968, 11969, 11980, 11979, 12829, 12830, 12841, 12840, 12440, 12462, 12463, 12460, 13301, 13323, 13324, 
13321, 65713, 65714, 65725, 65724
23809, 11969, 11970, 11981, 11980, 12830, 12831, 12842, 12841, 12442, 12464, 12465, 12462, 13303, 13325, 13326, 
13323, 65714, 65715, 65726, 65725
23810, 11970, 11971, 11982, 11981, 12831, 12832, 12843, 12842, 12444, 12466, 12467, 12464, 13305, 13327, 13328, 
13325, 65715, 65716, 65727, 65726
23811, 11971, 11972, 11983, 11982, 12832, 12833, 12844, 12843, 12446, 12468, 12469, 12466, 13307, 13329, 13330, 
13327, 65716, 65717, 65728, 65727
23812, 11972, 11973, 11984, 11983, 12833, 12834, 12845, 12844, 12448, 12470, 12471, 12468, 13309, 13331, 13332, 
13329, 65717, 65718, 65729, 65728
23813, 11973, 11974, 11985, 11984, 12834, 12835, 12846, 12845, 12450, 12472, 12473, 12470, 13311, 13333, 13334, 
13331, 65718, 65719, 65730, 65729
23814, 11974, 11975, 11986, 11985, 12835, 12836, 12847, 12846, 12452, 12474, 12475, 12472, 13313, 13335, 13336, 
13333, 65719, 65720, 65731, 65730
23815, 11975, 11976, 11987, 11986, 12836, 12837, 12848, 12847, 12454, 12476, 12477, 12474, 13315, 13337, 13338, 
13335, 65720, 65721, 65732, 65731
23816, 11976, 11977, 11988, 11987, 12837, 12838, 12849, 12848, 12456, 12478, 12479, 12476, 13317, 13339, 13340, 
13337, 65721, 65722, 65733, 65732
23817, 11977, 11978, 11989, 11988, 12838, 12839, 12850, 12849, 12458, 12480, 12481, 12478, 13319, 13341, 13342, 
13339, 65722, 65723, 65734, 65733
23818, 11978, 817, 818, 11989, 12839, 961, 962, 12850, 12459, 841, 12482, 12480, 13320, 985, 13343, 
13341, 65723, 12615, 12616, 65734
23819, 654, 11979, 11990, 655, 890, 12840, 12851, 891, 12461, 12483, 12484, 678, 13322, 13344, 13345, 
914, 12582, 65724, 65735, 12583
23820, 11979, 11980, 11991, 11990, 12840, 12841, 12852, 12851, 12463, 12485, 12486, 12483, 13324, 13346, 13347, 
13344, 65724, 65725, 65736, 65735
23821, 11980, 11981, 11992, 11991, 12841, 12842, 12853, 12852, 12465, 12487, 12488, 12485, 13326, 13348, 13349, 
13346, 65725, 65726, 65737, 65736
23822, 11981, 11982, 11993, 11992, 12842, 12843, 12854, 12853, 12467, 12489, 12490, 12487, 13328, 13350, 13351, 
13348, 65726, 65727, 65738, 65737
23823, 11982, 11983, 11994, 11993, 12843, 12844, 12855, 12854, 12469, 12491, 12492, 12489, 13330, 13352, 13353, 
13350, 65727, 65728, 65739, 65738
23824, 11983, 11984, 11995, 11994, 12844, 12845, 12856, 12855, 12471, 12493, 12494, 12491, 13332, 13354, 13355, 
13352, 65728, 65729, 65740, 65739
23825, 11984, 11985, 11996, 11995, 12845, 12846, 12857, 12856, 12473, 12495, 12496, 12493, 13334, 13356, 13357, 
13354, 65729, 65730, 65741, 65740
23826, 11985, 11986, 11997, 11996, 12846, 12847, 12858, 12857, 12475, 12497, 12498, 12495, 13336, 13358, 13359, 
13356, 65730, 65731, 65742, 65741
23827, 11986, 11987, 11998, 11997, 12847, 12848, 12859, 12858, 12477, 12499, 12500, 12497, 13338, 13360, 13361, 
13358, 65731, 65732, 65743, 65742
23828, 11987, 11988, 11999, 11998, 12848, 12849, 12860, 12859, 12479, 12501, 12502, 12499, 13340, 13362, 13363, 
13360, 65732, 65733, 65744, 65743
23829, 11988, 11989, 12000, 11999, 12849, 12850, 12861, 12860, 12481, 12503, 12504, 12501, 13342, 13364, 13365, 
13362, 65733, 65734, 65745, 65744
23830, 11989, 818, 819, 12000, 12850, 962, 963, 12861, 12482, 842, 12505, 12503, 13343, 986, 13366, 
13364, 65734, 12616, 12617, 65745
23831, 655, 11990, 12001, 656, 891, 12851, 12862, 892, 12484, 12506, 12507, 679, 13345, 13367, 13368, 
915, 12583, 65735, 65746, 12584
23832, 11990, 11991, 12002, 12001, 12851, 12852, 12863, 12862, 12486, 12508, 12509, 12506, 13347, 13369, 13370, 
13367, 65735, 65736, 65747, 65746
23833, 11991, 11992, 12003, 12002, 12852, 12853, 12864, 12863, 12488, 12510, 12511, 12508, 13349, 13371, 13372, 
13369, 65736, 65737, 65748, 65747
23834, 11992, 11993, 12004, 12003, 12853, 12854, 12865, 12864, 12490, 12512, 12513, 12510, 13351, 13373, 13374, 
13371, 65737, 65738, 65749, 65748
23835, 11993, 11994, 12005, 12004, 12854, 12855, 12866, 12865, 12492, 12514, 12515, 12512, 13353, 13375, 13376, 
13373, 65738, 65739, 65750, 65749
23836, 11994, 11995, 12006, 12005, 12855, 12856, 12867, 12866, 12494, 12516, 12517, 12514, 13355, 13377, 13378, 
13375, 65739, 65740, 65751, 65750
23837, 11995, 11996, 12007, 12006, 12856, 12857, 12868, 12867, 12496, 12518, 12519, 12516, 13357, 13379, 13380, 
13377, 65740, 65741, 65752, 65751
23838, 11996, 11997, 12008, 12007, 12857, 12858, 12869, 12868, 12498, 12520, 12521, 12518, 13359, 13381, 13382, 
13379, 65741, 65742, 65753, 65752
23839, 11997, 11998, 12009, 12008, 12858, 12859, 12870, 12869, 12500, 12522, 12523, 12520, 13361, 13383, 13384, 
13381, 65742, 65743, 65754, 65753
23840, 11998, 11999, 12010, 12009, 12859, 12860, 12871, 12870, 12502, 12524, 12525, 12522, 13363, 13385, 13386, 
13383, 65743, 65744, 65755, 65754
23841, 11999, 12000, 12011, 12010, 12860, 12861, 12872, 12871, 12504, 12526, 12527, 12524, 13365, 13387, 13388, 
13385, 65744, 65745, 65756, 65755
23842, 12000, 819, 820, 12011, 12861, 963, 964, 12872, 12505, 843, 12528, 12526, 13366, 987, 13389, 
13387, 65745, 12617, 12618, 65756
23843, 656, 12001, 12012, 657, 892, 12862, 12873, 893, 12507, 12529, 12530, 680, 13368, 13390, 13391, 
916, 12584, 65746, 65757, 12585
23844, 12001, 12002, 12013, 12012, 12862, 12863, 12874, 12873, 12509, 12531, 12532, 12529, 13370, 13392, 13393, 
13390, 65746, 65747, 65758, 65757
23845, 12002, 12003, 12014, 12013, 12863, 12864, 12875, 12874, 12511, 12533, 12534, 12531, 13372, 13394, 13395, 
13392, 65747, 65748, 65759, 65758
23846, 12003, 12004, 12015, 12014, 12864, 12865, 12876, 12875, 12513, 12535, 12536, 12533, 13374, 13396, 13397, 
13394, 65748, 65749, 65760, 65759
23847, 12004, 12005, 12016, 12015, 12865, 12866, 12877, 12876, 12515, 12537, 12538, 12535, 13376, 13398, 13399, 
13396, 65749, 65750, 65761, 65760
23848, 12005, 12006, 12017, 12016, 12866, 12867, 12878, 12877, 12517, 12539, 12540, 12537, 13378, 13400, 13401, 
13398, 65750, 65751, 65762, 65761
23849, 12006, 12007, 12018, 12017, 12867, 12868, 12879, 12878, 12519, 12541, 12542, 12539, 13380, 13402, 13403, 
13400, 65751, 65752, 65763, 65762
23850, 12007, 12008, 12019, 12018, 12868, 12869, 12880, 12879, 12521, 12543, 12544, 12541, 13382, 13404, 13405, 
13402, 65752, 65753, 65764, 65763
23851, 12008, 12009, 12020, 12019, 12869, 12870, 12881, 12880, 12523, 12545, 12546, 12543, 13384, 13406, 13407, 
13404, 65753, 65754, 65765, 65764
23852, 12009, 12010, 12021, 12020, 12870, 12871, 12882, 12881, 12525, 12547, 12548, 12545, 13386, 13408, 13409, 
13406, 65754, 65755, 65766, 65765
23853, 12010, 12011, 12022, 12021, 12871, 12872, 12883, 12882, 12527, 12549, 12550, 12547, 13388, 13410, 13411, 
13408, 65755, 65756, 65767, 65766
23854, 12011, 820, 821, 12022, 12872, 964, 965, 12883, 12528, 844, 12551, 12549, 13389, 988, 13412, 
13410, 65756, 12618, 12619, 65767
23855, 657, 12012, 729, 13, 893, 12873, 919, 17, 12530, 12552, 740, 681, 13391, 13413, 930, 
917, 12585, 65757, 12586, 869
23856, 12012, 12013, 730, 729, 12873, 12874, 920, 919, 12532, 12553, 741, 12552, 13393, 13414, 931, 
13413, 65757, 65758, 12587, 12586
23857, 12013, 12014, 731, 730, 12874, 12875, 921, 920, 12534, 12554, 742, 12553, 13395, 13415, 932, 
13414, 65758, 65759, 12588, 12587
23858, 12014, 12015, 732, 731, 12875, 12876, 922, 921, 12536, 12555, 743, 12554, 13397, 13416, 933, 
13415, 65759, 65760, 12589, 12588
23859, 12015, 12016, 733, 732, 12876, 12877, 923, 922, 12538, 12556, 744, 12555, 13399, 13417, 934, 
13416, 65760, 65761, 12590, 12589
23860, 12016, 12017, 734, 733, 12877, 12878, 924, 923, 12540, 12557, 745, 12556, 13401, 13418, 935, 
13417, 65761, 65762, 12591, 12590
23861, 12017, 12018, 735, 734, 12878, 12879, 925, 924, 12542, 12558, 746, 12557, 13403, 13419, 936, 
13418, 65762, 65763, 12592, 12591
23862, 12018, 12019, 736, 735, 12879, 12880, 926, 925, 12544, 12559, 747, 12558, 13405, 13420, 937, 
13419, 65763, 65764, 12593, 12592
23863, 12019, 12020, 737, 736, 12880, 12881, 927, 926, 12546, 12560, 748, 12559, 13407, 13421, 938, 
13420, 65764, 65765, 12594, 12593
23864, 12020, 12021, 738, 737, 12881, 12882, 928, 927, 12548, 12561, 749, 12560, 13409, 13422, 939, 
13421, 65765, 65766, 12595, 12594
23865, 12021, 12022, 739, 738, 12882, 12883, 929, 928, 12550, 12562, 750, 12561, 13411, 13423, 940, 
13422, 65766, 65767, 12596, 12595
23866, 12022, 821, 15, 739, 12883, 965, 19, 929, 12551, 845, 751, 12562, 13412, 989, 941, 
13423, 65767, 12619, 918, 12596
*ELEMENT, type=C3D20, ELSET=Volume5
23867, 18, 990, 12631, 871, 1018, 13829, 65768, 13424, 1001, 12884, 12885, 894, 13852, 66275, 66276, 
13470, 1020, 13851, 66274, 13471
23868, 1018, 13829, 65768, 13424, 1019, 13830, 65769, 13425, 13852, 66275, 66276, 13470, 13854, 66278, 66279, 
13472, 1021, 13853, 66277, 13473
23869, 1019, 13830, 65769, 13425, 22, 1150, 13908, 1023, 13854, 66278, 66279, 13472, 1161, 14161, 14162, 
1046, 1022, 13855, 66280, 13474
23870, 990, 991, 12632, 12631, 13829, 13831, 65770, 65768, 1002, 12886, 12887, 12884, 13857, 66282, 66283, 
66275, 13851, 13856, 66281, 66274
23871, 13829, 13831, 65770, 65768, 13830, 13832, 65771, 65769, 13857, 66282, 66283, 66275, 13859, 66285, 66286, 
66278, 13853, 13858, 66284, 66277
23872, 13830, 13832, 65771, 65769, 1150, 1151, 13909, 13908, 13859, 66285, 66286, 66278, 1162, 14163, 14164, 
14161, 13855, 13860, 66287, 66280
23873, 991, 992, 12633, 12632, 13831, 13833, 65772, 65770, 1003, 12888, 12889, 12886, 13862, 66289, 66290, 
66282, 13856, 13861, 66288, 66281
23874, 13831, 13833, 65772, 65770, 13832, 13834, 65773, 65771, 13862, 66289, 66290, 66282, 13864, 66292, 66293, 
66285, 13858, 13863, 66291, 66284
23875, 13832, 13834, 65773, 65771, 1151, 1152, 13910, 13909, 13864, 66292, 66293, 66285, 1163, 14165, 14166, 
14163, 13860, 13865, 66294, 66287
23876, 992, 993, 12634, 12633, 13833, 13835, 65774, 65772, 1004, 12890, 12891, 12888, 13867, 66296, 66297, 
66289, 13861, 13866, 66295, 66288
23877, 13833, 13835, 65774, 65772, 13834, 13836, 65775, 65773, 13867, 66296, 66297, 66289, 13869, 66299, 66300, 
66292, 13863, 13868, 66298, 66291
23878, 13834, 13836, 65775, 65773, 1152, 1153, 13911, 13910, 13869, 66299, 66300, 66292, 1164, 14167, 14168, 
14165, 13865, 13870, 66301, 66294
23879, 993, 994, 12635, 12634, 13835, 13837, 65776, 65774, 1005, 12892, 12893, 12890, 13872, 66303, 66304, 
66296, 13866, 13871, 66302, 66295
23880, 13835, 13837, 65776, 65774, 13836, 13838, 65777, 65775, 13872, 66303, 66304, 66296, 13874, 66306, 66307, 
66299, 13868, 13873, 66305, 66298
23881, 13836, 13838, 65777, 65775, 1153, 1154, 13912, 13911, 13874, 66306, 66307, 66299, 1165, 14169, 14170, 
14167, 13870, 13875, 66308, 66301
23882, 994, 995, 12636, 12635, 13837, 13839, 65778, 65776, 1006, 12894, 12895, 12892, 13877, 66310, 66311, 
66303, 13871, 13876, 66309, 66302
23883, 13837, 13839, 65778, 65776, 13838, 13840, 65779, 65777, 13877, 66310, 66311, 66303, 13879, 66313, 66314, 
66306, 13873, 13878, 66312, 66305
23884, 13838, 13840, 65779, 65777, 1154, 1155, 13913, 13912, 13879, 66313, 66314, 66306, 1166, 14171, 14172, 
14169, 13875, 13880, 66315, 66308
23885, 995, 996, 12637, 12636, 13839, 13841, 65780, 65778, 1007, 12896, 12897, 12894, 13882, 66317, 66318, 
66310, 13876, 13881, 66316, 66309
23886, 13839, 13841, 65780, 65778, 13840, 13842, 65781, 65779, 13882, 66317, 66318, 66310, 13884, 66320, 66321, 
66313, 13878, 13883, 66319, 66312
23887, 13840, 13842, 65781, 65779, 1155, 1156, 13914, 13913, 13884, 66320, 66321, 66313, 1167, 14173, 14174, 
14171, 13880, 13885, 66322, 66315
23888, 996, 997, 12638, 12637, 13841, 13843, 65782, 65780, 1008, 12898, 12899, 12896, 13887, 66324, 66325, 
66317, 13881, 13886, 66323, 66316
23889, 13841, 13843, 65782, 65780, 13842, 13844, 65783, 65781, 13887, 66324, 66325, 66317, 13889, 66327, 66328, 
66320, 13883, 13888, 66326, 66319
23890, 13842, 13844, 65783, 65781, 1156, 1157, 13915, 13914, 13889, 66327, 66328, 66320, 1168, 14175, 14176, 
14173, 13885, 13890, 66329, 66322
23891, 997, 998, 12639, 12638, 13843, 13845, 65784, 65782, 1009, 12900, 12901, 12898, 13892, 66331, 66332, 
66324, 13886, 13891, 66330, 66323
23892, 13843, 13845, 65784, 65782, 13844, 13846, 65785, 65783, 13892, 66331, 66332, 66324, 13894, 66334, 66335, 
66327, 13888, 13893, 66333, 66326
23893, 13844, 13846, 65785, 65783, 1157, 1158, 13916, 13915, 13894, 66334, 66335, 66327, 1169, 14177, 14178, 
14175, 13890, 13895, 66336, 66329
23894, 998, 999, 12640, 12639, 13845, 13847, 65786, 65784, 1010, 12902, 12903, 12900, 13897, 66338, 66339, 
66331, 13891, 13896, 66337, 66330
23895, 13845, 13847, 65786, 65784, 13846, 13848, 65787, 65785, 13897, 66338, 66339, 66331, 13899, 66341, 66342, 
66334, 13893, 13898, 66340, 66333
23896, 13846, 13848, 65787, 65785, 1158, 1159, 13917, 13916, 13899, 66341, 66342, 66334, 1170, 14179, 14180, 
14177, 13895, 13900, 66343, 66336
23897, 999, 1000, 12641, 12640, 13847, 13849, 65788, 65786, 1011, 12904, 12905, 12902, 13902, 66345, 66346, 
66338, 13896, 13901, 66344, 66337
23898, 13847, 13849, 65788, 65786, 13848, 13850, 65789, 65787, 13902, 66345, 66346, 66338, 13904, 66348, 66349, 
66341, 13898, 13903, 66347, 66340
23899, 13848, 13850, 65789, 65787, 1159, 1160, 13918, 13917, 13904, 66348, 66349, 66341, 1171, 14181, 14182, 
14179, 13900, 13905, 66350, 66343
23900, 1000, 20, 943, 12641, 13849, 1098, 13666, 65788, 1012, 966, 12906, 12904, 13906, 13713, 66351, 
66345, 13901, 1100, 13712, 66344
23901, 13849, 1098, 13666, 65788, 13850, 1099, 13667, 65789, 13906, 13713, 66351, 66345, 13907, 13715, 66352, 
66348, 13903, 1101, 13714, 66347
23902, 13850, 1099, 13667, 65789, 1160, 24, 1103, 13918, 13907, 13715, 66352, 66348, 1172, 1126, 14183, 
14181, 13905, 1102, 13716, 66350
23903, 871, 12631, 12642, 872, 13424, 65768, 65790, 13426, 12885, 12907, 12908, 895, 66276, 66354, 66355, 
13475, 13471, 66274, 66353, 13476
23904, 13424, 65768, 65790, 13426, 13425, 65769, 65791, 13427, 66276, 66354, 66355, 13475, 66279, 66357, 66358, 
13477, 13473, 66277, 66356, 13478
23905, 13425, 65769, 65791, 13427, 1023, 13908, 13919, 1024, 66279, 66357, 66358, 13477, 14162, 14184, 14185, 
1047, 13474, 66280, 66359, 13479
23906, 12631, 12632, 12643, 12642, 65768, 65770, 65792, 65790, 12887, 12909, 12910, 12907, 66283, 66361, 66362, 
66354, 66274, 66281, 66360, 66353
23907, 65768, 65770, 65792, 65790, 65769, 65771, 65793, 65791, 66283, 66361, 66362, 66354, 66286, 66364, 66365, 
66357, 66277, 66284, 66363, 66356
23908, 65769, 65771, 65793, 65791, 13908, 13909, 13920, 13919, 66286, 66364, 66365, 66357, 14164, 14186, 14187, 
14184, 66280, 66287, 66366, 66359
23909, 12632, 12633, 12644, 12643, 65770, 65772, 65794, 65792, 12889, 12911, 12912, 12909, 66290, 66368, 66369, 
66361, 66281, 66288, 66367, 66360
23910, 65770, 65772, 65794, 65792, 65771, 65773, 65795, 65793, 66290, 66368, 66369, 66361, 66293, 66371, 66372, 
66364, 66284, 66291, 66370, 66363
23911, 65771, 65773, 65795, 65793, 13909, 13910, 13921, 13920, 66293, 66371, 66372, 66364, 14166, 14188, 14189, 
14186, 66287, 66294, 66373, 66366
23912, 12633, 12634, 12645, 12644, 65772, 65774, 65796, 65794, 12891, 12913, 12914, 12911, 66297, 66375, 66376, 
66368, 66288, 66295, 66374, 66367
23913, 65772, 65774, 65796, 65794, 65773, 65775, 65797, 65795, 66297, 66375, 66376, 66368, 66300, 66378, 66379, 
66371, 66291, 66298, 66377, 66370
23914, 65773, 65775, 65797, 65795, 13910, 13911, 13922, 13921, 66300, 66378, 66379, 66371, 14168, 14190, 14191, 
14188, 66294, 66301, 66380, 66373
23915, 12634, 12635, 12646, 12645, 65774, 65776, 65798, 65796, 12893, 12915, 12916, 12913, 66304, 66382, 66383, 
66375, 66295, 66302, 66381, 66374
23916, 65774, 65776, 65798, 65796, 65775, 65777, 65799, 65797, 66304, 66382, 66383, 66375, 66307, 66385, 66386, 
66378, 66298, 66305, 66384, 66377
23917, 65775, 65777, 65799, 65797, 13911, 13912, 13923, 13922, 66307, 66385, 66386, 66378, 14170, 14192, 14193, 
14190, 66301, 66308, 66387, 66380
23918, 12635, 12636, 12647, 12646, 65776, 65778, 65800, 65798, 12895, 12917, 12918, 12915, 66311, 66389, 66390, 
66382, 66302, 66309, 66388, 66381
23919, 65776, 65778, 65800, 65798, 65777, 65779, 65801, 65799, 66311, 66389, 66390, 66382, 66314, 66392, 66393, 
66385, 66305, 66312, 66391, 66384
23920, 65777, 65779, 65801, 65799, 13912, 13913, 13924, 13923, 66314, 66392, 66393, 66385, 14172, 14194, 14195, 
14192, 66308, 66315, 66394, 66387
23921, 12636, 12637, 12648, 12647, 65778, 65780, 65802, 65800, 12897, 12919, 12920, 12917, 66318, 66396, 66397, 
66389, 66309, 66316, 66395, 66388
23922, 65778, 65780, 65802, 65800, 65779, 65781, 65803, 65801, 66318, 66396, 66397, 66389, 66321, 66399, 66400, 
66392, 66312, 66319, 66398, 66391
23923, 65779, 65781, 65803, 65801, 13913, 13914, 13925, 13924, 66321, 66399, 66400, 66392, 14174, 14196, 14197, 
14194, 66315, 66322, 66401, 66394
23924, 12637, 12638, 12649, 12648, 65780, 65782, 65804, 65802, 12899, 12921, 12922, 12919, 66325, 66403, 66404, 
66396, 66316, 66323, 66402, 66395
23925, 65780, 65782, 65804, 65802, 65781, 65783, 65805, 65803, 66325, 66403, 66404, 66396, 66328, 66406, 66407, 
66399, 66319, 66326, 66405, 66398
23926, 65781, 65783, 65805, 65803, 13914, 13915, 13926, 13925, 66328, 66406, 66407, 66399, 14176, 14198, 14199, 
14196, 66322, 66329, 66408, 66401
23927, 12638, 12639, 12650, 12649, 65782, 65784, 65806, 65804, 12901, 12923, 12924, 12921, 66332, 66410, 66411, 
66403, 66323, 66330, 66409, 66402
23928, 65782, 65784, 65806, 65804, 65783, 65785, 65807, 65805, 66332, 66410, 66411, 66403, 66335, 66413, 66414, 
66406, 66326, 66333, 66412, 66405
23929, 65783, 65785, 65807, 65805, 13915, 13916, 13927, 13926, 66335, 66413, 66414, 66406, 14178, 14200, 14201, 
14198, 66329, 66336, 66415, 66408
23930, 12639, 12640, 12651, 12650, 65784, 65786, 65808, 65806, 12903, 12925, 12926, 12923, 66339, 66417, 66418, 
66410, 66330, 66337, 66416, 66409
23931, 65784, 65786, 65808, 65806, 65785, 65787, 65809, 65807, 66339, 66417, 66418, 66410, 66342, 66420, 66421, 
66413, 66333, 66340, 66419, 66412
23932, 65785, 65787, 65809, 65807, 13916, 13917, 13928, 13927, 66342, 66420, 66421, 66413, 14180, 14202, 14203, 
14200, 66336, 66343, 66422, 66415
23933, 12640, 12641, 12652, 12651, 65786, 65788, 65810, 65808, 12905, 12927, 12928, 12925, 66346, 66424, 66425, 
66417, 66337, 66344, 66423, 66416
23934, 65786, 65788, 65810, 65808, 65787, 65789, 65811, 65809, 66346, 66424, 66425, 66417, 66349, 66427, 66428, 
66420, 66340, 66347, 66426, 66419
23935, 65787, 65789, 65811, 65809, 13917, 13918, 13929, 13928, 66349, 66427, 66428, 66420, 14182, 14204, 14205, 
14202, 66343, 66350, 66429, 66422
23936, 12641, 943, 944, 12652, 65788, 13666, 13668, 65810, 12906, 967, 12929, 12927, 66351, 13718, 66430, 
66424, 66344, 13712, 13717, 66423
23937, 65788, 13666, 13668, 65810, 65789, 13667, 13669, 65811, 66351, 13718, 66430, 66424, 66352, 13720, 66431, 
66427, 66347, 13714, 13719, 66426
23938, 65789, 13667, 13669, 65811, 13918, 1103, 1104, 13929, 66352, 13720, 66431, 66427, 14183, 1127, 14206, 
14204, 66350, 13716, 13721, 66429
23939, 872, 12642, 12653, 873, 13426, 65790, 65812, 13428, 12908, 12930, 12931, 896, 66355, 66433, 66434, 
13480, 13476, 66353, 66432, 13481
23940, 13426, 65790, 65812, 13428, 13427, 65791, 65813, 13429, 66355, 66433, 66434, 13480, 66358, 66436, 66437, 
13482, 13478, 66356, 66435, 13483
23941, 13427, 65791, 65813, 13429, 1024, 13919, 13930, 1025, 66358, 66436, 66437, 13482, 14185, 14207, 14208, 
1048, 13479, 66359, 66438, 13484
23942, 12642, 12643, 12654, 12653, 65790, 65792, 65814, 65812, 12910, 12932, 12933, 12930, 66362, 66440, 66441, 
66433, 66353, 66360, 66439, 66432
23943, 65790, 65792, 65814, 65812, 65791, 65793, 65815, 65813, 66362, 66440, 66441, 66433, 66365, 66443, 66444, 
66436, 66356, 66363, 66442, 66435
23944, 65791, 65793, 65815, 65813, 13919, 13920, 13931, 13930, 66365, 66443, 66444, 66436, 14187, 14209, 14210, 
14207, 66359, 66366, 66445, 66438
23945, 12643, 12644, 12655, 12654, 65792, 65794, 65816, 65814, 12912, 12934, 12935, 12932, 66369, 66447, 66448, 
66440, 66360, 66367, 66446, 66439
23946, 65792, 65794, 65816, 65814, 65793, 65795, 65817, 65815, 66369, 66447, 66448, 66440, 66372, 66450, 66451, 
66443, 66363, 66370, 66449, 66442
23947, 65793, 65795, 65817, 65815, 13920, 13921, 13932, 13931, 66372, 66450, 66451, 66443, 14189, 14211, 14212, 
14209, 66366, 66373, 66452, 66445
23948, 12644, 12645, 12656, 12655, 65794, 65796, 65818, 65816, 12914, 12936, 12937, 12934, 66376, 66454, 66455, 
66447, 66367, 66374, 66453, 66446
23949, 65794, 65796, 65818, 65816, 65795, 65797, 65819, 65817, 66376, 66454, 66455, 66447, 66379, 66457, 66458, 
66450, 66370, 66377, 66456, 66449
23950, 65795, 65797, 65819, 65817, 13921, 13922, 13933, 13932, 66379, 66457, 66458, 66450, 14191, 14213, 14214, 
14211, 66373, 66380, 66459, 66452
23951, 12645, 12646, 12657, 12656, 65796, 65798, 65820, 65818, 12916, 12938, 12939, 12936, 66383, 66461, 66462, 
66454, 66374, 66381, 66460, 66453
23952, 65796, 65798, 65820, 65818, 65797, 65799, 65821, 65819, 66383, 66461, 66462, 66454, 66386, 66464, 66465, 
66457, 66377, 66384, 66463, 66456
23953, 65797, 65799, 65821, 65819, 13922, 13923, 13934, 13933, 66386, 66464, 66465, 66457, 14193, 14215, 14216, 
14213, 66380, 66387, 66466, 66459
23954, 12646, 12647, 12658, 12657, 65798, 65800, 65822, 65820, 12918, 12940, 12941, 12938, 66390, 66468, 66469, 
66461, 66381, 66388, 66467, 66460
23955, 65798, 65800, 65822, 65820, 65799, 65801, 65823, 65821, 66390, 66468, 66469, 66461, 66393, 66471, 66472, 
66464, 66384, 66391, 66470, 66463
23956, 65799, 65801, 65823, 65821, 13923, 13924, 13935, 13934, 66393, 66471, 66472, 66464, 14195, 14217, 14218, 
14215, 66387, 66394, 66473, 66466
23957, 12647, 12648, 12659, 12658, 65800, 65802, 65824, 65822, 12920, 12942, 12943, 12940, 66397, 66475, 66476, 
66468, 66388, 66395, 66474, 66467
23958, 65800, 65802, 65824, 65822, 65801, 65803, 65825, 65823, 66397, 66475, 66476, 66468, 66400, 66478, 66479, 
66471, 66391, 66398, 66477, 66470
23959, 65801, 65803, 65825, 65823, 13924, 13925, 13936, 13935, 66400, 66478, 66479, 66471, 14197, 14219, 14220, 
14217, 66394, 66401, 66480, 66473
23960, 12648, 12649, 12660, 12659, 65802, 65804, 65826, 65824, 12922, 12944, 12945, 12942, 66404, 66482, 66483, 
66475, 66395, 66402, 66481, 66474
23961, 65802, 65804, 65826, 65824, 65803, 65805, 65827, 65825, 66404, 66482, 66483, 66475, 66407, 66485, 66486, 
66478, 66398, 66405, 66484, 66477
23962, 65803, 65805, 65827, 65825, 13925, 13926, 13937, 13936, 66407, 66485, 66486, 66478, 14199, 14221, 14222, 
14219, 66401, 66408, 66487, 66480
23963, 12649, 12650, 12661, 12660, 65804, 65806, 65828, 65826, 12924, 12946, 12947, 12944, 66411, 66489, 66490, 
66482, 66402, 66409, 66488, 66481
23964, 65804, 65806, 65828, 65826, 65805, 65807, 65829, 65827, 66411, 66489, 66490, 66482, 66414, 66492, 66493, 
66485, 66405, 66412, 66491, 66484
23965, 65805, 65807, 65829, 65827, 13926, 13927, 13938, 13937, 66414, 66492, 66493, 66485, 14201, 14223, 14224, 
14221, 66408, 66415, 66494, 66487
23966, 12650, 12651, 12662, 12661, 65806, 65808, 65830, 65828, 12926, 12948, 12949, 12946, 66418, 66496, 66497, 
66489, 66409, 66416, 66495, 66488
23967, 65806, 65808, 65830, 65828, 65807, 65809, 65831, 65829, 66418, 66496, 66497, 66489, 66421, 66499, 66500, 
66492, 66412, 66419, 66498, 66491
23968, 65807, 65809, 65831, 65829, 13927, 13928, 13939, 13938, 66421, 66499, 66500, 66492, 14203, 14225, 14226, 
14223, 66415, 66422, 66501, 66494
23969, 12651, 12652, 12663, 12662, 65808, 65810, 65832, 65830, 12928, 12950, 12951, 12948, 66425, 66503, 66504, 
66496, 66416, 66423, 66502, 66495
23970, 65808, 65810, 65832, 65830, 65809, 65811, 65833, 65831, 66425, 66503, 66504, 66496, 66428, 66506, 66507, 
66499, 66419, 66426, 66505, 66498
23971, 65809, 65811, 65833, 65831, 13928, 13929, 13940, 13939, 66428, 66506, 66507, 66499, 14205, 14227, 14228, 
14225, 66422, 66429, 66508, 66501
23972, 12652, 944, 945, 12663, 65810, 13668, 13670, 65832, 12929, 968, 12952, 12950, 66430, 13723, 66509, 
66503, 66423, 13717, 13722, 66502
23973, 65810, 13668, 13670, 65832, 65811, 13669, 13671, 65833, 66430, 13723, 66509, 66503, 66431, 13725, 66510, 
66506, 66426, 13719, 13724, 66505
23974, 65811, 13669, 13671, 65833, 13929, 1104, 1105, 13940, 66431, 13725, 66510, 66506, 14206, 1128, 14229, 
14227, 66429, 13721, 13726, 66508
23975, 873, 12653, 12664, 874, 13428, 65812, 65834, 13430, 12931, 12953, 12954, 897, 66434, 66512, 66513, 
13485, 13481, 66432, 66511, 13486
23976, 13428, 65812, 65834, 13430, 13429, 65813, 65835, 13431, 66434, 66512, 66513, 13485, 66437, 66515, 66516, 
13487, 13483, 66435, 66514, 13488
23977, 13429, 65813, 65835, 13431, 1025, 13930, 13941, 1026, 66437, 66515, 66516, 13487, 14208, 14230, 14231, 
1049, 13484, 66438, 66517, 13489
23978, 12653, 12654, 12665, 12664, 65812, 65814, 65836, 65834, 12933, 12955, 12956, 12953, 66441, 66519, 66520, 
66512, 66432, 66439, 66518, 66511
23979, 65812, 65814, 65836, 65834, 65813, 65815, 65837, 65835, 66441, 66519, 66520, 66512, 66444, 66522, 66523, 
66515, 66435, 66442, 66521, 66514
23980, 65813, 65815, 65837, 65835, 13930, 13931, 13942, 13941, 66444, 66522, 66523, 66515, 14210, 14232, 14233, 
14230, 66438, 66445, 66524, 66517
23981, 12654, 12655, 12666, 12665, 65814, 65816, 65838, 65836, 12935, 12957, 12958, 12955, 66448, 66526, 66527, 
66519, 66439, 66446, 66525, 66518
23982, 65814, 65816, 65838, 65836, 65815, 65817, 65839, 65837, 66448, 66526, 66527, 66519, 66451, 66529, 66530, 
66522, 66442, 66449, 66528, 66521
23983, 65815, 65817, 65839, 65837, 13931, 13932, 13943, 13942, 66451, 66529, 66530, 66522, 14212, 14234, 14235, 
14232, 66445, 66452, 66531, 66524
23984, 12655, 12656, 12667, 12666, 65816, 65818, 65840, 65838, 12937, 12959, 12960, 12957, 66455, 66533, 66534, 
66526, 66446, 66453, 66532, 66525
23985, 65816, 65818, 65840, 65838, 65817, 65819, 65841, 65839, 66455, 66533, 66534, 66526, 66458, 66536, 66537, 
66529, 66449, 66456, 66535, 66528
23986, 65817, 65819, 65841, 65839, 13932, 13933, 13944, 13943, 66458, 66536, 66537, 66529, 14214, 14236, 14237, 
14234, 66452, 66459, 66538, 66531
23987, 12656, 12657, 12668, 12667, 65818, 65820, 65842, 65840, 12939, 12961, 12962, 12959, 66462, 66540, 66541, 
66533, 66453, 66460, 66539, 66532
23988, 65818, 65820, 65842, 65840, 65819, 65821, 65843, 65841, 66462, 66540, 66541, 66533, 66465, 66543, 66544, 
66536, 66456, 66463, 66542, 66535
23989, 65819, 65821, 65843, 65841, 13933, 13934, 13945, 13944, 66465, 66543, 66544, 66536, 14216, 14238, 14239, 
14236, 66459, 66466, 66545, 66538
23990, 12657, 12658, 12669, 12668, 65820, 65822, 65844, 65842, 12941, 12963, 12964, 12961, 66469, 66547, 66548, 
66540, 66460, 66467, 66546, 66539
23991, 65820, 65822, 65844, 65842, 65821, 65823, 65845, 65843, 66469, 66547, 66548, 66540, 66472, 66550, 66551, 
66543, 66463, 66470, 66549, 66542
23992, 65821, 65823, 65845, 65843, 13934, 13935, 13946, 13945, 66472, 66550, 66551, 66543, 14218, 14240, 14241, 
14238, 66466, 66473, 66552, 66545
23993, 12658, 12659, 12670, 12669, 65822, 65824, 65846, 65844, 12943, 12965, 12966, 12963, 66476, 66554, 66555, 
66547, 66467, 66474, 66553, 66546
23994, 65822, 65824, 65846, 65844, 65823, 65825, 65847, 65845, 66476, 66554, 66555, 66547, 66479, 66557, 66558, 
66550, 66470, 66477, 66556, 66549
23995, 65823, 65825, 65847, 65845, 13935, 13936, 13947, 13946, 66479, 66557, 66558, 66550, 14220, 14242, 14243, 
14240, 66473, 66480, 66559, 66552
23996, 12659, 12660, 12671, 12670, 65824, 65826, 65848, 65846, 12945, 12967, 12968, 12965, 66483, 66561, 66562, 
66554, 66474, 66481, 66560, 66553
23997, 65824, 65826, 65848, 65846, 65825, 65827, 65849, 65847, 66483, 66561, 66562, 66554, 66486, 66564, 66565, 
66557, 66477, 66484, 66563, 66556
23998, 65825, 65827, 65849, 65847, 13936, 13937, 13948, 13947, 66486, 66564, 66565, 66557, 14222, 14244, 14245, 
14242, 66480, 66487, 66566, 66559
23999, 12660, 12661, 12672, 12671, 65826, 65828, 65850, 65848, 12947, 12969, 12970, 12967, 66490, 66568, 66569, 
66561, 66481, 66488, 66567, 66560
24000, 65826, 65828, 65850, 65848, 65827, 65829, 65851, 65849, 66490, 66568, 66569, 66561, 66493, 66571, 66572, 
66564, 66484, 66491, 66570, 66563
24001, 65827, 65829, 65851, 65849, 13937, 13938, 13949, 13948, 66493, 66571, 66572, 66564, 14224, 14246, 14247, 
14244, 66487, 66494, 66573, 66566
24002, 12661, 12662, 12673, 12672, 65828, 65830, 65852, 65850, 12949, 12971, 12972, 12969, 66497, 66575, 66576, 
66568, 66488, 66495, 66574, 66567
24003, 65828, 65830, 65852, 65850, 65829, 65831, 65853, 65851, 66497, 66575, 66576, 66568, 66500, 66578, 66579, 
66571, 66491, 66498, 66577, 66570
24004, 65829, 65831, 65853, 65851, 13938, 13939, 13950, 13949, 66500, 66578, 66579, 66571, 14226, 14248, 14249, 
14246, 66494, 66501, 66580, 66573
24005, 12662, 12663, 12674, 12673, 65830, 65832, 65854, 65852, 12951, 12973, 12974, 12971, 66504, 66582, 66583, 
66575, 66495, 66502, 66581, 66574
24006, 65830, 65832, 65854, 65852, 65831, 65833, 65855, 65853, 66504, 66582, 66583, 66575, 66507, 66585, 66586, 
66578, 66498, 66505, 66584, 66577
24007, 65831, 65833, 65855, 65853, 13939, 13940, 13951, 13950, 66507, 66585, 66586, 66578, 14228, 14250, 14251, 
14248, 66501, 66508, 66587, 66580
24008, 12663, 945, 946, 12674, 65832, 13670, 13672, 65854, 12952, 969, 12975, 12973, 66509, 13728, 66588, 
66582, 66502, 13722, 13727, 66581
24009, 65832, 13670, 13672, 65854, 65833, 13671, 13673, 65855, 66509, 13728, 66588, 66582, 66510, 13730, 66589, 
66585, 66505, 13724, 13729, 66584
24010, 65833, 13671, 13673, 65855, 13940, 1105, 1106, 13951, 66510, 13730, 66589, 66585, 14229, 1129, 14252, 
14250, 66508, 13726, 13731, 66587
24011, 874, 12664, 12675, 875, 13430, 65834, 65856, 13432, 12954, 12976, 12977, 898, 66513, 66591, 66592, 
13490, 13486, 66511, 66590, 13491
24012, 13430, 65834, 65856, 13432, 13431, 65835, 65857, 13433, 66513, 66591, 66592, 13490, 66516, 66594, 66595, 
13492, 13488, 66514, 66593, 13493
24013, 13431, 65835, 65857, 13433, 1026, 13941, 13952, 1027, 66516, 66594, 66595, 13492, 14231, 14253, 14254, 
1050, 13489, 66517, 66596, 13494
24014, 12664, 12665, 12676, 12675, 65834, 65836, 65858, 65856, 12956, 12978, 12979, 12976, 66520, 66598, 66599, 
66591, 66511, 66518, 66597, 66590
24015, 65834, 65836, 65858, 65856, 65835, 65837, 65859, 65857, 66520, 66598, 66599, 66591, 66523, 66601, 66602, 
66594, 66514, 66521, 66600, 66593
24016, 65835, 65837, 65859, 65857, 13941, 13942, 13953, 13952, 66523, 66601, 66602, 66594, 14233, 14255, 14256, 
14253, 66517, 66524, 66603, 66596
24017, 12665, 12666, 12677, 12676, 65836, 65838, 65860, 65858, 12958, 12980, 12981, 12978, 66527, 66605, 66606, 
66598, 66518, 66525, 66604, 66597
24018, 65836, 65838, 65860, 65858, 65837, 65839, 65861, 65859, 66527, 66605, 66606, 66598, 66530, 66608, 66609, 
66601, 66521, 66528, 66607, 66600
24019, 65837, 65839, 65861, 65859, 13942, 13943, 13954, 13953, 66530, 66608, 66609, 66601, 14235, 14257, 14258, 
14255, 66524, 66531, 66610, 66603
24020, 12666, 12667, 12678, 12677, 65838, 65840, 65862, 65860, 12960, 12982, 12983, 12980, 66534, 66612, 66613, 
66605, 66525, 66532, 66611, 66604
24021, 65838, 65840, 65862, 65860, 65839, 65841, 65863, 65861, 66534, 66612, 66613, 66605, 66537, 66615, 66616, 
66608, 66528, 66535, 66614, 66607
24022, 65839, 65841, 65863, 65861, 13943, 13944, 13955, 13954, 66537, 66615, 66616, 66608, 14237, 14259, 14260, 
14257, 66531, 66538, 66617, 66610
24023, 12667, 12668, 12679, 12678, 65840, 65842, 65864, 65862, 12962, 12984, 12985, 12982, 66541, 66619, 66620, 
66612, 66532, 66539, 66618, 66611
24024, 65840, 65842, 65864, 65862, 65841, 65843, 65865, 65863, 66541, 66619, 66620, 66612, 66544, 66622, 66623, 
66615, 66535, 66542, 66621, 66614
24025, 65841, 65843, 65865, 65863, 13944, 13945, 13956, 13955, 66544, 66622, 66623, 66615, 14239, 14261, 14262, 
14259, 66538, 66545, 66624, 66617
24026, 12668, 12669, 12680, 12679, 65842, 65844, 65866, 65864, 12964, 12986, 12987, 12984, 66548, 66626, 66627, 
66619, 66539, 66546, 66625, 66618
24027, 65842, 65844, 65866, 65864, 65843, 65845, 65867, 65865, 66548, 66626, 66627, 66619, 66551, 66629, 66630, 
66622, 66542, 66549, 66628, 66621
24028, 65843, 65845, 65867, 65865, 13945, 13946, 13957, 13956, 66551, 66629, 66630, 66622, 14241, 14263, 14264, 
14261, 66545, 66552, 66631, 66624
24029, 12669, 12670, 12681, 12680, 65844, 65846, 65868, 65866, 12966, 12988, 12989, 12986, 66555, 66633, 66634, 
66626, 66546, 66553, 66632, 66625
24030, 65844, 65846, 65868, 65866, 65845, 65847, 65869, 65867, 66555, 66633, 66634, 66626, 66558, 66636, 66637, 
66629, 66549, 66556, 66635, 66628
24031, 65845, 65847, 65869, 65867, 13946, 13947, 13958, 13957, 66558, 66636, 66637, 66629, 14243, 14265, 14266, 
14263, 66552, 66559, 66638, 66631
24032, 12670, 12671, 12682, 12681, 65846, 65848, 65870, 65868, 12968, 12990, 12991, 12988, 66562, 66640, 66641, 
66633, 66553, 66560, 66639, 66632
24033, 65846, 65848, 65870, 65868, 65847, 65849, 65871, 65869, 66562, 66640, 66641, 66633, 66565, 66643, 66644, 
66636, 66556, 66563, 66642, 66635
24034, 65847, 65849, 65871, 65869, 13947, 13948, 13959, 13958, 66565, 66643, 66644, 66636, 14245, 14267, 14268, 
14265, 66559, 66566, 66645, 66638
24035, 12671, 12672, 12683, 12682, 65848, 65850, 65872, 65870, 12970, 12992, 12993, 12990, 66569, 66647, 66648, 
66640, 66560, 66567, 66646, 66639
24036, 65848, 65850, 65872, 65870, 65849, 65851, 65873, 65871, 66569, 66647, 66648, 66640, 66572, 66650, 66651, 
66643, 66563, 66570, 66649, 66642
24037, 65849, 65851, 65873, 65871, 13948, 13949, 13960, 13959, 66572, 66650, 66651, 66643, 14247, 14269, 14270, 
14267, 66566, 66573, 66652, 66645
24038, 12672, 12673, 12684, 12683, 65850, 65852, 65874, 65872, 12972, 12994, 12995, 12992, 66576, 66654, 66655, 
66647, 66567, 66574, 66653, 66646
24039, 65850, 65852, 65874, 65872, 65851, 65853, 65875, 65873, 66576, 66654, 66655, 66647, 66579, 66657, 66658, 
66650, 66570, 66577, 66656, 66649
24040, 65851, 65853, 65875, 65873, 13949, 13950, 13961, 13960, 66579, 66657, 66658, 66650, 14249, 14271, 14272, 
14269, 66573, 66580, 66659, 66652
24041, 12673, 12674, 12685, 12684, 65852, 65854, 65876, 65874, 12974, 12996, 12997, 12994, 66583, 66661, 66662, 
66654, 66574, 66581, 66660, 66653
24042, 65852, 65854, 65876, 65874, 65853, 65855, 65877, 65875, 66583, 66661, 66662, 66654, 66586, 66664, 66665, 
66657, 66577, 66584, 66663, 66656
24043, 65853, 65855, 65877, 65875, 13950, 13951, 13962, 13961, 66586, 66664, 66665, 66657, 14251, 14273, 14274, 
14271, 66580, 66587, 66666, 66659
24044, 12674, 946, 947, 12685, 65854, 13672, 13674, 65876, 12975, 970, 12998, 12996, 66588, 13733, 66667, 
66661, 66581, 13727, 13732, 66660
24045, 65854, 13672, 13674, 65876, 65855, 13673, 13675, 65877, 66588, 13733, 66667, 66661, 66589, 13735, 66668, 
66664, 66584, 13729, 13734, 66663
24046, 65855, 13673, 13675, 65877, 13951, 1106, 1107, 13962, 66589, 13735, 66668, 66664, 14252, 1130, 14275, 
14273, 66587, 13731, 13736, 66666
24047, 875, 12675, 12686, 876, 13432, 65856, 65878, 13434, 12977, 12999, 13000, 899, 66592, 66670, 66671, 
13495, 13491, 66590, 66669, 13496
24048, 13432, 65856, 65878, 13434, 13433, 65857, 65879, 13435, 66592, 66670, 66671, 13495, 66595, 66673, 66674, 
13497, 13493, 66593, 66672, 13498
24049, 13433, 65857, 65879, 13435, 1027, 13952, 13963, 1028, 66595, 66673, 66674, 13497, 14254, 14276, 14277, 
1051, 13494, 66596, 66675, 13499
24050, 12675, 12676, 12687, 12686, 65856, 65858, 65880, 65878, 12979, 13001, 13002, 12999, 66599, 66677, 66678, 
66670, 66590, 66597, 66676, 66669
24051, 65856, 65858, 65880, 65878, 65857, 65859, 65881, 65879, 66599, 66677, 66678, 66670, 66602, 66680, 66681, 
66673, 66593, 66600, 66679, 66672
24052, 65857, 65859, 65881, 65879, 13952, 13953, 13964, 13963, 66602, 66680, 66681, 66673, 14256, 14278, 14279, 
14276, 66596, 66603, 66682, 66675
24053, 12676, 12677, 12688, 12687, 65858, 65860, 65882, 65880, 12981, 13003, 13004, 13001, 66606, 66684, 66685, 
66677, 66597, 66604, 66683, 66676
24054, 65858, 65860, 65882, 65880, 65859, 65861, 65883, 65881, 66606, 66684, 66685, 66677, 66609, 66687, 66688, 
66680, 66600, 66607, 66686, 66679
24055, 65859, 65861, 65883, 65881, 13953, 13954, 13965, 13964, 66609, 66687, 66688, 66680, 14258, 14280, 14281, 
14278, 66603, 66610, 66689, 66682
24056, 12677, 12678, 12689, 12688, 65860, 65862, 65884, 65882, 12983, 13005, 13006, 13003, 66613, 66691, 66692, 
66684, 66604, 66611, 66690, 66683
24057, 65860, 65862, 65884, 65882, 65861, 65863, 65885, 65883, 66613, 66691, 66692, 66684, 66616, 66694, 66695, 
66687, 66607, 66614, 66693, 66686
24058, 65861, 65863, 65885, 65883, 13954, 13955, 13966, 13965, 66616, 66694, 66695, 66687, 14260, 14282, 14283, 
14280, 66610, 66617, 66696, 66689
24059, 12678, 12679, 12690, 12689, 65862, 65864, 65886, 65884, 12985, 13007, 13008, 13005, 66620, 66698, 66699, 
66691, 66611, 66618, 66697, 66690
24060, 65862, 65864, 65886, 65884, 65863, 65865, 65887, 65885, 66620, 66698, 66699, 66691, 66623, 66701, 66702, 
66694, 66614, 66621, 66700, 66693
24061, 65863, 65865, 65887, 65885, 13955, 13956, 13967, 13966, 66623, 66701, 66702, 66694, 14262, 14284, 14285, 
14282, 66617, 66624, 66703, 66696
24062, 12679, 12680, 12691, 12690, 65864, 65866, 65888, 65886, 12987, 13009, 13010, 13007, 66627, 66705, 66706, 
66698, 66618, 66625, 66704, 66697
24063, 65864, 65866, 65888, 65886, 65865, 65867, 65889, 65887, 66627, 66705, 66706, 66698, 66630, 66708, 66709, 
66701, 66621, 66628, 66707, 66700
24064, 65865, 65867, 65889, 65887, 13956, 13957, 13968, 13967, 66630, 66708, 66709, 66701, 14264, 14286, 14287, 
14284, 66624, 66631, 66710, 66703
24065, 12680, 12681, 12692, 12691, 65866, 65868, 65890, 65888, 12989, 13011, 13012, 13009, 66634, 66712, 66713, 
66705, 66625, 66632, 66711, 66704
24066, 65866, 65868, 65890, 65888, 65867, 65869, 65891, 65889, 66634, 66712, 66713, 66705, 66637, 66715, 66716, 
66708, 66628, 66635, 66714, 66707
24067, 65867, 65869, 65891, 65889, 13957, 13958, 13969, 13968, 66637, 66715, 66716, 66708, 14266, 14288, 14289, 
14286, 66631, 66638, 66717, 66710
24068, 12681, 12682, 12693, 12692, 65868, 65870, 65892, 65890, 12991, 13013, 13014, 13011, 66641, 66719, 66720, 
66712, 66632, 66639, 66718, 66711
24069, 65868, 65870, 65892, 65890, 65869, 65871, 65893, 65891, 66641, 66719, 66720, 66712, 66644, 66722, 66723, 
66715, 66635, 66642, 66721, 66714
24070, 65869, 65871, 65893, 65891, 13958, 13959, 13970, 13969, 66644, 66722, 66723, 66715, 14268, 14290, 14291, 
14288, 66638, 66645, 66724, 66717
24071, 12682, 12683, 12694, 12693, 65870, 65872, 65894, 65892, 12993, 13015, 13016, 13013, 66648, 66726, 66727, 
66719, 66639, 66646, 66725, 66718
24072, 65870, 65872, 65894, 65892, 65871, 65873, 65895, 65893, 66648, 66726, 66727, 66719, 66651, 66729, 66730, 
66722, 66642, 66649, 66728, 66721
24073, 65871, 65873, 65895, 65893, 13959, 13960, 13971, 13970, 66651, 66729, 66730, 66722, 14270, 14292, 14293, 
14290, 66645, 66652, 66731, 66724
24074, 12683, 12684, 12695, 12694, 65872, 65874, 65896, 65894, 12995, 13017, 13018, 13015, 66655, 66733, 66734, 
66726, 66646, 66653, 66732, 66725
24075, 65872, 65874, 65896, 65894, 65873, 65875, 65897, 65895, 66655, 66733, 66734, 66726, 66658, 66736, 66737, 
66729, 66649, 66656, 66735, 66728
24076, 65873, 65875, 65897, 65895, 13960, 13961, 13972, 13971, 66658, 66736, 66737, 66729, 14272, 14294, 14295, 
14292, 66652, 66659, 66738, 66731
24077, 12684, 12685, 12696, 12695, 65874, 65876, 65898, 65896, 12997, 13019, 13020, 13017, 66662, 66740, 66741, 
66733, 66653, 66660, 66739, 66732
24078, 65874, 65876, 65898, 65896, 65875, 65877, 65899, 65897, 66662, 66740, 66741, 66733, 66665, 66743, 66744, 
66736, 66656, 66663, 66742, 66735
24079, 65875, 65877, 65899, 65897, 13961, 13962, 13973, 13972, 66665, 66743, 66744, 66736, 14274, 14296, 14297, 
14294, 66659, 66666, 66745, 66738
24080, 12685, 947, 948, 12696, 65876, 13674, 13676, 65898, 12998, 971, 13021, 13019, 66667, 13738, 66746, 
66740, 66660, 13732, 13737, 66739
24081, 65876, 13674, 13676, 65898, 65877, 13675, 13677, 65899, 66667, 13738, 66746, 66740, 66668, 13740, 66747, 
66743, 66663, 13734, 13739, 66742
24082, 65877, 13675, 13677, 65899, 13962, 1107, 1108, 13973, 66668, 13740, 66747, 66743, 14275, 1131, 14298, 
14296, 66666, 13736, 13741, 66745
24083, 876, 12686, 12697, 877, 13434, 65878, 65900, 13436, 13000, 13022, 13023, 900, 66671, 66749, 66750, 
13500, 13496, 66669, 66748, 13501
24084, 13434, 65878, 65900, 13436, 13435, 65879, 65901, 13437, 66671, 66749, 66750, 13500, 66674, 66752, 66753, 
13502, 13498, 66672, 66751, 13503
24085, 13435, 65879, 65901, 13437, 1028, 13963, 13974, 1029, 66674, 66752, 66753, 13502, 14277, 14299, 14300, 
1052, 13499, 66675, 66754, 13504
24086, 12686, 12687, 12698, 12697, 65878, 65880, 65902, 65900, 13002, 13024, 13025, 13022, 66678, 66756, 66757, 
66749, 66669, 66676, 66755, 66748
24087, 65878, 65880, 65902, 65900, 65879, 65881, 65903, 65901, 66678, 66756, 66757, 66749, 66681, 66759, 66760, 
66752, 66672, 66679, 66758, 66751
24088, 65879, 65881, 65903, 65901, 13963, 13964, 13975, 13974, 66681, 66759, 66760, 66752, 14279, 14301, 14302, 
14299, 66675, 66682, 66761, 66754
24089, 12687, 12688, 12699, 12698, 65880, 65882, 65904, 65902, 13004, 13026, 13027, 13024, 66685, 66763, 66764, 
66756, 66676, 66683, 66762, 66755
24090, 65880, 65882, 65904, 65902, 65881, 65883, 65905, 65903, 66685, 66763, 66764, 66756, 66688, 66766, 66767, 
66759, 66679, 66686, 66765, 66758
24091, 65881, 65883, 65905, 65903, 13964, 13965, 13976, 13975, 66688, 66766, 66767, 66759, 14281, 14303, 14304, 
14301, 66682, 66689, 66768, 66761
24092, 12688, 12689, 12700, 12699, 65882, 65884, 65906, 65904, 13006, 13028, 13029, 13026, 66692, 66770, 66771, 
66763, 66683, 66690, 66769, 66762
24093, 65882, 65884, 65906, 65904, 65883, 65885, 65907, 65905, 66692, 66770, 66771, 66763, 66695, 66773, 66774, 
66766, 66686, 66693, 66772, 66765
24094, 65883, 65885, 65907, 65905, 13965, 13966, 13977, 13976, 66695, 66773, 66774, 66766, 14283, 14305, 14306, 
14303, 66689, 66696, 66775, 66768
24095, 12689, 12690, 12701, 12700, 65884, 65886, 65908, 65906, 13008, 13030, 13031, 13028, 66699, 66777, 66778, 
66770, 66690, 66697, 66776, 66769
24096, 65884, 65886, 65908, 65906, 65885, 65887, 65909, 65907, 66699, 66777, 66778, 66770, 66702, 66780, 66781, 
66773, 66693, 66700, 66779, 66772
24097, 65885, 65887, 65909, 65907, 13966, 13967, 13978, 13977, 66702, 66780, 66781, 66773, 14285, 14307, 14308, 
14305, 66696, 66703, 66782, 66775
24098, 12690, 12691, 12702, 12701, 65886, 65888, 65910, 65908, 13010, 13032, 13033, 13030, 66706, 66784, 66785, 
66777, 66697, 66704, 66783, 66776
24099, 65886, 65888, 65910, 65908, 65887, 65889, 65911, 65909, 66706, 66784, 66785, 66777, 66709, 66787, 66788, 
66780, 66700, 66707, 66786, 66779
24100, 65887, 65889, 65911, 65909, 13967, 13968, 13979, 13978, 66709, 66787, 66788, 66780, 14287, 14309, 14310, 
14307, 66703, 66710, 66789, 66782
24101, 12691, 12692, 12703, 12702, 65888, 65890, 65912, 65910, 13012, 13034, 13035, 13032, 66713, 66791, 66792, 
66784, 66704, 66711, 66790, 66783
24102, 65888, 65890, 65912, 65910, 65889, 65891, 65913, 65911, 66713, 66791, 66792, 66784, 66716, 66794, 66795, 
66787, 66707, 66714, 66793, 66786
24103, 65889, 65891, 65913, 65911, 13968, 13969, 13980, 13979, 66716, 66794, 66795, 66787, 14289, 14311, 14312, 
14309, 66710, 66717, 66796, 66789
24104, 12692, 12693, 12704, 12703, 65890, 65892, 65914, 65912, 13014, 13036, 13037, 13034, 66720, 66798, 66799, 
66791, 66711, 66718, 66797, 66790
24105, 65890, 65892, 65914, 65912, 65891, 65893, 65915, 65913, 66720, 66798, 66799, 66791, 66723, 66801, 66802, 
66794, 66714, 66721, 66800, 66793
24106, 65891, 65893, 65915, 65913, 13969, 13970, 13981, 13980, 66723, 66801, 66802, 66794, 14291, 14313, 14314, 
14311, 66717, 66724, 66803, 66796
24107, 12693, 12694, 12705, 12704, 65892, 65894, 65916, 65914, 13016, 13038, 13039, 13036, 66727, 66805, 66806, 
66798, 66718, 66725, 66804, 66797
24108, 65892, 65894, 65916, 65914, 65893, 65895, 65917, 65915, 66727, 66805, 66806, 66798, 66730, 66808, 66809, 
66801, 66721, 66728, 66807, 66800
24109, 65893, 65895, 65917, 65915, 13970, 13971, 13982, 13981, 66730, 66808, 66809, 66801, 14293, 14315, 14316, 
14313, 66724, 66731, 66810, 66803
24110, 12694, 12695, 12706, 12705, 65894, 65896, 65918, 65916, 13018, 13040, 13041, 13038, 66734, 66812, 66813, 
66805, 66725, 66732, 66811, 66804
24111, 65894, 65896, 65918, 65916, 65895, 65897, 65919, 65917, 66734, 66812, 66813, 66805, 66737, 66815, 66816, 
66808, 66728, 66735, 66814, 66807
24112, 65895, 65897, 65919, 65917, 13971, 13972, 13983, 13982, 66737, 66815, 66816, 66808, 14295, 14317, 14318, 
14315, 66731, 66738, 66817, 66810
24113, 12695, 12696, 12707, 12706, 65896, 65898, 65920, 65918, 13020, 13042, 13043, 13040, 66741, 66819, 66820, 
66812, 66732, 66739, 66818, 66811
24114, 65896, 65898, 65920, 65918, 65897, 65899, 65921, 65919, 66741, 66819, 66820, 66812, 66744, 66822, 66823, 
66815, 66735, 66742, 66821, 66814
24115, 65897, 65899, 65921, 65919, 13972, 13973, 13984, 13983, 66744, 66822, 66823, 66815, 14297, 14319, 14320, 
14317, 66738, 66745, 66824, 66817
24116, 12696, 948, 949, 12707, 65898, 13676, 13678, 65920, 13021, 972, 13044, 13042, 66746, 13743, 66825, 
66819, 66739, 13737, 13742, 66818
24117, 65898, 13676, 13678, 65920, 65899, 13677, 13679, 65921, 66746, 13743, 66825, 66819, 66747, 13745, 66826, 
66822, 66742, 13739, 13744, 66821
24118, 65899, 13677, 13679, 65921, 13973, 1108, 1109, 13984, 66747, 13745, 66826, 66822, 14298, 1132, 14321, 
14319, 66745, 13741, 13746, 66824
24119, 877, 12697, 12708, 878, 13436, 65900, 65922, 13438, 13023, 13045, 13046, 901, 66750, 66828, 66829, 
13505, 13501, 66748, 66827, 13506
24120, 13436, 65900, 65922, 13438, 13437, 65901, 65923, 13439, 66750, 66828, 66829, 13505, 66753, 66831, 66832, 
13507, 13503, 66751, 66830, 13508
24121, 13437, 65901, 65923, 13439, 1029, 13974, 13985, 1030, 66753, 66831, 66832, 13507, 14300, 14322, 14323, 
1053, 13504, 66754, 66833, 13509
24122, 12697, 12698, 12709, 12708, 65900, 65902, 65924, 65922, 13025, 13047, 13048, 13045, 66757, 66835, 66836, 
66828, 66748, 66755, 66834, 66827
24123, 65900, 65902, 65924, 65922, 65901, 65903, 65925, 65923, 66757, 66835, 66836, 66828, 66760, 66838, 66839, 
66831, 66751, 66758, 66837, 66830
24124, 65901, 65903, 65925, 65923, 13974, 13975, 13986, 13985, 66760, 66838, 66839, 66831, 14302, 14324, 14325, 
14322, 66754, 66761, 66840, 66833
24125, 12698, 12699, 12710, 12709, 65902, 65904, 65926, 65924, 13027, 13049, 13050, 13047, 66764, 66842, 66843, 
66835, 66755, 66762, 66841, 66834
24126, 65902, 65904, 65926, 65924, 65903, 65905, 65927, 65925, 66764, 66842, 66843, 66835, 66767, 66845, 66846, 
66838, 66758, 66765, 66844, 66837
24127, 65903, 65905, 65927, 65925, 13975, 13976, 13987, 13986, 66767, 66845, 66846, 66838, 14304, 14326, 14327, 
14324, 66761, 66768, 66847, 66840
24128, 12699, 12700, 12711, 12710, 65904, 65906, 65928, 65926, 13029, 13051, 13052, 13049, 66771, 66849, 66850, 
66842, 66762, 66769, 66848, 66841
24129, 65904, 65906, 65928, 65926, 65905, 65907, 65929, 65927, 66771, 66849, 66850, 66842, 66774, 66852, 66853, 
66845, 66765, 66772, 66851, 66844
24130, 65905, 65907, 65929, 65927, 13976, 13977, 13988, 13987, 66774, 66852, 66853, 66845, 14306, 14328, 14329, 
14326, 66768, 66775, 66854, 66847
24131, 12700, 12701, 12712, 12711, 65906, 65908, 65930, 65928, 13031, 13053, 13054, 13051, 66778, 66856, 66857, 
66849, 66769, 66776, 66855, 66848
24132, 65906, 65908, 65930, 65928, 65907, 65909, 65931, 65929, 66778, 66856, 66857, 66849, 66781, 66859, 66860, 
66852, 66772, 66779, 66858, 66851
24133, 65907, 65909, 65931, 65929, 13977, 13978, 13989, 13988, 66781, 66859, 66860, 66852, 14308, 14330, 14331, 
14328, 66775, 66782, 66861, 66854
24134, 12701, 12702, 12713, 12712, 65908, 65910, 65932, 65930, 13033, 13055, 13056, 13053, 66785, 66863, 66864, 
66856, 66776, 66783, 66862, 66855
24135, 65908, 65910, 65932, 65930, 65909, 65911, 65933, 65931, 66785, 66863, 66864, 66856, 66788, 66866, 66867, 
66859, 66779, 66786, 66865, 66858
24136, 65909, 65911, 65933, 65931, 13978, 13979, 13990, 13989, 66788, 66866, 66867, 66859, 14310, 14332, 14333, 
14330, 66782, 66789, 66868, 66861
24137, 12702, 12703, 12714, 12713, 65910, 65912, 65934, 65932, 13035, 13057, 13058, 13055, 66792, 66870, 66871, 
66863, 66783, 66790, 66869, 66862
24138, 65910, 65912, 65934, 65932, 65911, 65913, 65935, 65933, 66792, 66870, 66871, 66863, 66795, 66873, 66874, 
66866, 66786, 66793, 66872, 66865
24139, 65911, 65913, 65935, 65933, 13979, 13980, 13991, 13990, 66795, 66873, 66874, 66866, 14312, 14334, 14335, 
14332, 66789, 66796, 66875, 66868
24140, 12703, 12704, 12715, 12714, 65912, 65914, 65936, 65934, 13037, 13059, 13060, 13057, 66799, 66877, 66878, 
66870, 66790, 66797, 66876, 66869
24141, 65912, 65914, 65936, 65934, 65913, 65915, 65937, 65935, 66799, 66877, 66878, 66870, 66802, 66880, 66881, 
66873, 66793, 66800, 66879, 66872
24142, 65913, 65915, 65937, 65935, 13980, 13981, 13992, 13991, 66802, 66880, 66881, 66873, 14314, 14336, 14337, 
14334, 66796, 66803, 66882, 66875
24143, 12704, 12705, 12716, 12715, 65914, 65916, 65938, 65936, 13039, 13061, 13062, 13059, 66806, 66884, 66885, 
66877, 66797, 66804, 66883, 66876
24144, 65914, 65916, 65938, 65936, 65915, 65917, 65939, 65937, 66806, 66884, 66885, 66877, 66809, 66887, 66888, 
66880, 66800, 66807, 66886, 66879
24145, 65915, 65917, 65939, 65937, 13981, 13982, 13993, 13992, 66809, 66887, 66888, 66880, 14316, 14338, 14339, 
14336, 66803, 66810, 66889, 66882
24146, 12705, 12706, 12717, 12716, 65916, 65918, 65940, 65938, 13041, 13063, 13064, 13061, 66813, 66891, 66892, 
66884, 66804, 66811, 66890, 66883
24147, 65916, 65918, 65940, 65938, 65917, 65919, 65941, 65939, 66813, 66891, 66892, 66884, 66816, 66894, 66895, 
66887, 66807, 66814, 66893, 66886
24148, 65917, 65919, 65941, 65939, 13982, 13983, 13994, 13993, 66816, 66894, 66895, 66887, 14318, 14340, 14341, 
14338, 66810, 66817, 66896, 66889
24149, 12706, 12707, 12718, 12717, 65918, 65920, 65942, 65940, 13043, 13065, 13066, 13063, 66820, 66898, 66899, 
66891, 66811, 66818, 66897, 66890
24150, 65918, 65920, 65942, 65940, 65919, 65921, 65943, 65941, 66820, 66898, 66899, 66891, 66823, 66901, 66902, 
66894, 66814, 66821, 66900, 66893
24151, 65919, 65921, 65943, 65941, 13983, 13984, 13995, 13994, 66823, 66901, 66902, 66894, 14320, 14342, 14343, 
14340, 66817, 66824, 66903, 66896
24152, 12707, 949, 950, 12718, 65920, 13678, 13680, 65942, 13044, 973, 13067, 13065, 66825, 13748, 66904, 
66898, 66818, 13742, 13747, 66897
24153, 65920, 13678, 13680, 65942, 65921, 13679, 13681, 65943, 66825, 13748, 66904, 66898, 66826, 13750, 66905, 
66901, 66821, 13744, 13749, 66900
24154, 65921, 13679, 13681, 65943, 13984, 1109, 1110, 13995, 66826, 13750, 66905, 66901, 14321, 1133, 14344, 
14342, 66824, 13746, 13751, 66903
24155, 878, 12708, 12719, 879, 13438, 65922, 65944, 13440, 13046, 13068, 13069, 902, 66829, 66907, 66908, 
13510, 13506, 66827, 66906, 13511
24156, 13438, 65922, 65944, 13440, 13439, 65923, 65945, 13441, 66829, 66907, 66908, 13510, 66832, 66910, 66911, 
13512, 13508, 66830, 66909, 13513
24157, 13439, 65923, 65945, 13441, 1030, 13985, 13996, 1031, 66832, 66910, 66911, 13512, 14323, 14345, 14346, 
1054, 13509, 66833, 66912, 13514
24158, 12708, 12709, 12720, 12719, 65922, 65924, 65946, 65944, 13048, 13070, 13071, 13068, 66836, 66914, 66915, 
66907, 66827, 66834, 66913, 66906
24159, 65922, 65924, 65946, 65944, 65923, 65925, 65947, 65945, 66836, 66914, 66915, 66907, 66839, 66917, 66918, 
66910, 66830, 66837, 66916, 66909
24160, 65923, 65925, 65947, 65945, 13985, 13986, 13997, 13996, 66839, 66917, 66918, 66910, 14325, 14347, 14348, 
14345, 66833, 66840, 66919, 66912
24161, 12709, 12710, 12721, 12720, 65924, 65926, 65948, 65946, 13050, 13072, 13073, 13070, 66843, 66921, 66922, 
66914, 66834, 66841, 66920, 66913
24162, 65924, 65926, 65948, 65946, 65925, 65927, 65949, 65947, 66843, 66921, 66922, 66914, 66846, 66924, 66925, 
66917, 66837, 66844, 66923, 66916
24163, 65925, 65927, 65949, 65947, 13986, 13987, 13998, 13997, 66846, 66924, 66925, 66917, 14327, 14349, 14350, 
14347, 66840, 66847, 66926, 66919
24164, 12710, 12711, 12722, 12721, 65926, 65928, 65950, 65948, 13052, 13074, 13075, 13072, 66850, 66928, 66929, 
66921, 66841, 66848, 66927, 66920
24165, 65926, 65928, 65950, 65948, 65927, 65929, 65951, 65949, 66850, 66928, 66929, 66921, 66853, 66931, 66932, 
66924, 66844, 66851, 66930, 66923
24166, 65927, 65929, 65951, 65949, 13987, 13988, 13999, 13998, 66853, 66931, 66932, 66924, 14329, 14351, 14352, 
14349, 66847, 66854, 66933, 66926
24167, 12711, 12712, 12723, 12722, 65928, 65930, 65952, 65950, 13054, 13076, 13077, 13074, 66857, 66935, 66936, 
66928, 66848, 66855, 66934, 66927
24168, 65928, 65930, 65952, 65950, 65929, 65931, 65953, 65951, 66857, 66935, 66936, 66928, 66860, 66938, 66939, 
66931, 66851, 66858, 66937, 66930
24169, 65929, 65931, 65953, 65951, 13988, 13989, 14000, 13999, 66860, 66938, 66939, 66931, 14331, 14353, 14354, 
14351, 66854, 66861, 66940, 66933
24170, 12712, 12713, 12724, 12723, 65930, 65932, 65954, 65952, 13056, 13078, 13079, 13076, 66864, 66942, 66943, 
66935, 66855, 66862, 66941, 66934
24171, 65930, 65932, 65954, 65952, 65931, 65933, 65955, 65953, 66864, 66942, 66943, 66935, 66867, 66945, 66946, 
66938, 66858, 66865, 66944, 66937
24172, 65931, 65933, 65955, 65953, 13989, 13990, 14001, 14000, 66867, 66945, 66946, 66938, 14333, 14355, 14356, 
14353, 66861, 66868, 66947, 66940
24173, 12713, 12714, 12725, 12724, 65932, 65934, 65956, 65954, 13058, 13080, 13081, 13078, 66871, 66949, 66950, 
66942, 66862, 66869, 66948, 66941
24174, 65932, 65934, 65956, 65954, 65933, 65935, 65957, 65955, 66871, 66949, 66950, 66942, 66874, 66952, 66953, 
66945, 66865, 66872, 66951, 66944
24175, 65933, 65935, 65957, 65955, 13990, 13991, 14002, 14001, 66874, 66952, 66953, 66945, 14335, 14357, 14358, 
14355, 66868, 66875, 66954, 66947
24176, 12714, 12715, 12726, 12725, 65934, 65936, 65958, 65956, 13060, 13082, 13083, 13080, 66878, 66956, 66957, 
66949, 66869, 66876, 66955, 66948
24177, 65934, 65936, 65958, 65956, 65935, 65937, 65959, 65957, 66878, 66956, 66957, 66949, 66881, 66959, 66960, 
66952, 66872, 66879, 66958, 66951
24178, 65935, 65937, 65959, 65957, 13991, 13992, 14003, 14002, 66881, 66959, 66960, 66952, 14337, 14359, 14360, 
14357, 66875, 66882, 66961, 66954
24179, 12715, 12716, 12727, 12726, 65936, 65938, 65960, 65958, 13062, 13084, 13085, 13082, 66885, 66963, 66964, 
66956, 66876, 66883, 66962, 66955
24180, 65936, 65938, 65960, 65958, 65937, 65939, 65961, 65959, 66885, 66963, 66964, 66956, 66888, 66966, 66967, 
66959, 66879, 66886, 66965, 66958
24181, 65937, 65939, 65961, 65959, 13992, 13993, 14004, 14003, 66888, 66966, 66967, 66959, 14339, 14361, 14362, 
14359, 66882, 66889, 66968, 66961
24182, 12716, 12717, 12728, 12727, 65938, 65940, 65962, 65960, 13064, 13086, 13087, 13084, 66892, 66970, 66971, 
66963, 66883, 66890, 66969, 66962
24183, 65938, 65940, 65962, 65960, 65939, 65941, 65963, 65961, 66892, 66970, 66971, 66963, 66895, 66973, 66974, 
66966, 66886, 66893, 66972, 66965
24184, 65939, 65941, 65963, 65961, 13993, 13994, 14005, 14004, 66895, 66973, 66974, 66966, 14341, 14363, 14364, 
14361, 66889, 66896, 66975, 66968
24185, 12717, 12718, 12729, 12728, 65940, 65942, 65964, 65962, 13066, 13088, 13089, 13086, 66899, 66977, 66978, 
66970, 66890, 66897, 66976, 66969
24186, 65940, 65942, 65964, 65962, 65941, 65943, 65965, 65963, 66899, 66977, 66978, 66970, 66902, 66980, 66981, 
66973, 66893, 66900, 66979, 66972
24187, 65941, 65943, 65965, 65963, 13994, 13995, 14006, 14005, 66902, 66980, 66981, 66973, 14343, 14365, 14366, 
14363, 66896, 66903, 66982, 66975
24188, 12718, 950, 951, 12729, 65942, 13680, 13682, 65964, 13067, 974, 13090, 13088, 66904, 13753, 66983, 
66977, 66897, 13747, 13752, 66976
24189, 65942, 13680, 13682, 65964, 65943, 13681, 13683, 65965, 66904, 13753, 66983, 66977, 66905, 13755, 66984, 
66980, 66900, 13749, 13754, 66979
24190, 65943, 13681, 13683, 65965, 13995, 1110, 1111, 14006, 66905, 13755, 66984, 66980, 14344, 1134, 14367, 
14365, 66903, 13751, 13756, 66982
24191, 879, 12719, 12730, 880, 13440, 65944, 65966, 13442, 13069, 13091, 13092, 903, 66908, 66986, 66987, 
13515, 13511, 66906, 66985, 13516
24192, 13440, 65944, 65966, 13442, 13441, 65945, 65967, 13443, 66908, 66986, 66987, 13515, 66911, 66989, 66990, 
13517, 13513, 66909, 66988, 13518
24193, 13441, 65945, 65967, 13443, 1031, 13996, 14007, 1032, 66911, 66989, 66990, 13517, 14346, 14368, 14369, 
1055, 13514, 66912, 66991, 13519
24194, 12719, 12720, 12731, 12730, 65944, 65946, 65968, 65966, 13071, 13093, 13094, 13091, 66915, 66993, 66994, 
66986, 66906, 66913, 66992, 66985
24195, 65944, 65946, 65968, 65966, 65945, 65947, 65969, 65967, 66915, 66993, 66994, 66986, 66918, 66996, 66997, 
66989, 66909, 66916, 66995, 66988
24196, 65945, 65947, 65969, 65967, 13996, 13997, 14008, 14007, 66918, 66996, 66997, 66989, 14348, 14370, 14371, 
14368, 66912, 66919, 66998, 66991
24197, 12720, 12721, 12732, 12731, 65946, 65948, 65970, 65968, 13073, 13095, 13096, 13093, 66922, 67000, 67001, 
66993, 66913, 66920, 66999, 66992
24198, 65946, 65948, 65970, 65968, 65947, 65949, 65971, 65969, 66922, 67000, 67001, 66993, 66925, 67003, 67004, 
66996, 66916, 66923, 67002, 66995
24199, 65947, 65949, 65971, 65969, 13997, 13998, 14009, 14008, 66925, 67003, 67004, 66996, 14350, 14372, 14373, 
14370, 66919, 66926, 67005, 66998
24200, 12721, 12722, 12733, 12732, 65948, 65950, 65972, 65970, 13075, 13097, 13098, 13095, 66929, 67007, 67008, 
67000, 66920, 66927, 67006, 66999
24201, 65948, 65950, 65972, 65970, 65949, 65951, 65973, 65971, 66929, 67007, 67008, 67000, 66932, 67010, 67011, 
67003, 66923, 66930, 67009, 67002
24202, 65949, 65951, 65973, 65971, 13998, 13999, 14010, 14009, 66932, 67010, 67011, 67003, 14352, 14374, 14375, 
14372, 66926, 66933, 67012, 67005
24203, 12722, 12723, 12734, 12733, 65950, 65952, 65974, 65972, 13077, 13099, 13100, 13097, 66936, 67014, 67015, 
67007, 66927, 66934, 67013, 67006
24204, 65950, 65952, 65974, 65972, 65951, 65953, 65975, 65973, 66936, 67014, 67015, 67007, 66939, 67017, 67018, 
67010, 66930, 66937, 67016, 67009
24205, 65951, 65953, 65975, 65973, 13999, 14000, 14011, 14010, 66939, 67017, 67018, 67010, 14354, 14376, 14377, 
14374, 66933, 66940, 67019, 67012
24206, 12723, 12724, 12735, 12734, 65952, 65954, 65976, 65974, 13079, 13101, 13102, 13099, 66943, 67021, 67022, 
67014, 66934, 66941, 67020, 67013
24207, 65952, 65954, 65976, 65974, 65953, 65955, 65977, 65975, 66943, 67021, 67022, 67014, 66946, 67024, 67025, 
67017, 66937, 66944, 67023, 67016
24208, 65953, 65955, 65977, 65975, 14000, 14001, 14012, 14011, 66946, 67024, 67025, 67017, 14356, 14378, 14379, 
14376, 66940, 66947, 67026, 67019
24209, 12724, 12725, 12736, 12735, 65954, 65956, 65978, 65976, 13081, 13103, 13104, 13101, 66950, 67028, 67029, 
67021, 66941, 66948, 67027, 67020
24210, 65954, 65956, 65978, 65976, 65955, 65957, 65979, 65977, 66950, 67028, 67029, 67021, 66953, 67031, 67032, 
67024, 66944, 66951, 67030, 67023
24211, 65955, 65957, 65979, 65977, 14001, 14002, 14013, 14012, 66953, 67031, 67032, 67024, 14358, 14380, 14381, 
14378, 66947, 66954, 67033, 67026
24212, 12725, 12726, 12737, 12736, 65956, 65958, 65980, 65978, 13083, 13105, 13106, 13103, 66957, 67035, 67036, 
67028, 66948, 66955, 67034, 67027
24213, 65956, 65958, 65980, 65978, 65957, 65959, 65981, 65979, 66957, 67035, 67036, 67028, 66960, 67038, 67039, 
67031, 66951, 66958, 67037, 67030
24214, 65957, 65959, 65981, 65979, 14002, 14003, 14014, 14013, 66960, 67038, 67039, 67031, 14360, 14382, 14383, 
14380, 66954, 66961, 67040, 67033
24215, 12726, 12727, 12738, 12737, 65958, 65960, 65982, 65980, 13085, 13107, 13108, 13105, 66964, 67042, 67043, 
67035, 66955, 66962, 67041, 67034
24216, 65958, 65960, 65982, 65980, 65959, 65961, 65983, 65981, 66964, 67042, 67043, 67035, 66967, 67045, 67046, 
67038, 66958, 66965, 67044, 67037
24217, 65959, 65961, 65983, 65981, 14003, 14004, 14015, 14014, 66967, 67045, 67046, 67038, 14362, 14384, 14385, 
14382, 66961, 66968, 67047, 67040
24218, 12727, 12728, 12739, 12738, 65960, 65962, 65984, 65982, 13087, 13109, 13110, 13107, 66971, 67049, 67050, 
67042, 66962, 66969, 67048, 67041
24219, 65960, 65962, 65984, 65982, 65961, 65963, 65985, 65983, 66971, 67049, 67050, 67042, 66974, 67052, 67053, 
67045, 66965, 66972, 67051, 67044
24220, 65961, 65963, 65985, 65983, 14004, 14005, 14016, 14015, 66974, 67052, 67053, 67045, 14364, 14386, 14387, 
14384, 66968, 66975, 67054, 67047
24221, 12728, 12729, 12740, 12739, 65962, 65964, 65986, 65984, 13089, 13111, 13112, 13109, 66978, 67056, 67057, 
67049, 66969, 66976, 67055, 67048
24222, 65962, 65964, 65986, 65984, 65963, 65965, 65987, 65985, 66978, 67056, 67057, 67049, 66981, 67059, 67060, 
67052, 66972, 66979, 67058, 67051
24223, 65963, 65965, 65987, 65985, 14005, 14006, 14017, 14016, 66981, 67059, 67060, 67052, 14366, 14388, 14389, 
14386, 66975, 66982, 67061, 67054
24224, 12729, 951, 952, 12740, 65964, 13682, 13684, 65986, 13090, 975, 13113, 13111, 66983, 13758, 67062, 
67056, 66976, 13752, 13757, 67055
24225, 65964, 13682, 13684, 65986, 65965, 13683, 13685, 65987, 66983, 13758, 67062, 67056, 66984, 13760, 67063, 
67059, 66979, 13754, 13759, 67058
24226, 65965, 13683, 13685, 65987, 14006, 1111, 1112, 14017, 66984, 13760, 67063, 67059, 14367, 1135, 14390, 
14388, 66982, 13756, 13761, 67061
24227, 880, 12730, 12741, 881, 13442, 65966, 65988, 13444, 13092, 13114, 13115, 904, 66987, 67065, 67066, 
13520, 13516, 66985, 67064, 13521
24228, 13442, 65966, 65988, 13444, 13443, 65967, 65989, 13445, 66987, 67065, 67066, 13520, 66990, 67068, 67069, 
13522, 13518, 66988, 67067, 13523
24229, 13443, 65967, 65989, 13445, 1032, 14007, 14018, 1033, 66990, 67068, 67069, 13522, 14369, 14391, 14392, 
1056, 13519, 66991, 67070, 13524
24230, 12730, 12731, 12742, 12741, 65966, 65968, 65990, 65988, 13094, 13116, 13117, 13114, 66994, 67072, 67073, 
67065, 66985, 66992, 67071, 67064
24231, 65966, 65968, 65990, 65988, 65967, 65969, 65991, 65989, 66994, 67072, 67073, 67065, 66997, 67075, 67076, 
67068, 66988, 66995, 67074, 67067
24232, 65967, 65969, 65991, 65989, 14007, 14008, 14019, 14018, 66997, 67075, 67076, 67068, 14371, 14393, 14394, 
14391, 66991, 66998, 67077, 67070
24233, 12731, 12732, 12743, 12742, 65968, 65970, 65992, 65990, 13096, 13118, 13119, 13116, 67001, 67079, 67080, 
67072, 66992, 66999, 67078, 67071
24234, 65968, 65970, 65992, 65990, 65969, 65971, 65993, 65991, 67001, 67079, 67080, 67072, 67004, 67082, 67083, 
67075, 66995, 67002, 67081, 67074
24235, 65969, 65971, 65993, 65991, 14008, 14009, 14020, 14019, 67004, 67082, 67083, 67075, 14373, 14395, 14396, 
14393, 66998, 67005, 67084, 67077
24236, 12732, 12733, 12744, 12743, 65970, 65972, 65994, 65992, 13098, 13120, 13121, 13118, 67008, 67086, 67087, 
67079, 66999, 67006, 67085, 67078
24237, 65970, 65972, 65994, 65992, 65971, 65973, 65995, 65993, 67008, 67086, 67087, 67079, 67011, 67089, 67090, 
67082, 67002, 67009, 67088, 67081
24238, 65971, 65973, 65995, 65993, 14009, 14010, 14021, 14020, 67011, 67089, 67090, 67082, 14375, 14397, 14398, 
14395, 67005, 67012, 67091, 67084
24239, 12733, 12734, 12745, 12744, 65972, 65974, 65996, 65994, 13100, 13122, 13123, 13120, 67015, 67093, 67094, 
67086, 67006, 67013, 67092, 67085
24240, 65972, 65974, 65996, 65994, 65973, 65975, 65997, 65995, 67015, 67093, 67094, 67086, 67018, 67096, 67097, 
67089, 67009, 67016, 67095, 67088
24241, 65973, 65975, 65997, 65995, 14010, 14011, 14022, 14021, 67018, 67096, 67097, 67089, 14377, 14399, 14400, 
14397, 67012, 67019, 67098, 67091
24242, 12734, 12735, 12746, 12745, 65974, 65976, 65998, 65996, 13102, 13124, 13125, 13122, 67022, 67100, 67101, 
67093, 67013, 67020, 67099, 67092
24243, 65974, 65976, 65998, 65996, 65975, 65977, 65999, 65997, 67022, 67100, 67101, 67093, 67025, 67103, 67104, 
67096, 67016, 67023, 67102, 67095
24244, 65975, 65977, 65999, 65997, 14011, 14012, 14023, 14022, 67025, 67103, 67104, 67096, 14379, 14401, 14402, 
14399, 67019, 67026, 67105, 67098
24245, 12735, 12736, 12747, 12746, 65976, 65978, 66000, 65998, 13104, 13126, 13127, 13124, 67029, 67107, 67108, 
67100, 67020, 67027, 67106, 67099
24246, 65976, 65978, 66000, 65998, 65977, 65979, 66001, 65999, 67029, 67107, 67108, 67100, 67032, 67110, 67111, 
67103, 67023, 67030, 67109, 67102
24247, 65977, 65979, 66001, 65999, 14012, 14013, 14024, 14023, 67032, 67110, 67111, 67103, 14381, 14403, 14404, 
14401, 67026, 67033, 67112, 67105
24248, 12736, 12737, 12748, 12747, 65978, 65980, 66002, 66000, 13106, 13128, 13129, 13126, 67036, 67114, 67115, 
67107, 67027, 67034, 67113, 67106
24249, 65978, 65980, 66002, 66000, 65979, 65981, 66003, 66001, 67036, 67114, 67115, 67107, 67039, 67117, 67118, 
67110, 67030, 67037, 67116, 67109
24250, 65979, 65981, 66003, 66001, 14013, 14014, 14025, 14024, 67039, 67117, 67118, 67110, 14383, 14405, 14406, 
14403, 67033, 67040, 67119, 67112
24251, 12737, 12738, 12749, 12748, 65980, 65982, 66004, 66002, 13108, 13130, 13131, 13128, 67043, 67121, 67122, 
67114, 67034, 67041, 67120, 67113
24252, 65980, 65982, 66004, 66002, 65981, 65983, 66005, 66003, 67043, 67121, 67122, 67114, 67046, 67124, 67125, 
67117, 67037, 67044, 67123, 67116
24253, 65981, 65983, 66005, 66003, 14014, 14015, 14026, 14025, 67046, 67124, 67125, 67117, 14385, 14407, 14408, 
14405, 67040, 67047, 67126, 67119
24254, 12738, 12739, 12750, 12749, 65982, 65984, 66006, 66004, 13110, 13132, 13133, 13130, 67050, 67128, 67129, 
67121, 67041, 67048, 67127, 67120
