23824, 1.6583333333333, 0.1, 0.25
23825, 1.7, 0.1, 0.25
23826, 1.7416666666667, 0.1, 0.25
23827, 1.7833333333333, 0.1, 0.25
23828, 1.825, 0.1, 0.25
23829, 1.8666666666667, 0.1, 0.25
23830, 1.9083333333333, 0.1, 0.25
23831, 1.95, 0.1, 0.25
23832, 1.9916666666667, 0.1, 0.25
23833, 2.0333333333333, 0.1, 0.25
23834, 2.075, 0.1, 0.25
23835, 2.1166666666667, 0.1, 0.25
23836, 2.1583333333333, 0.1, 0.25
23837, 1.2416666666667, 0.1, 0.29166666666667
23838, 1.2833333333333, 0.1, 0.29166666666667
23839, 1.325, 0.1, 0.29166666666667
23840, 1.3666666666667, 0.1, 0.29166666666667
23841, 1.4083333333333, 0.1, 0.29166666666667
23842, 1.45, 0.1, 0.29166666666667
23843, 1.4916666666667, 0.1, 0.29166666666667
23844, 1.5333333333333, 0.1, 0.29166666666667
23845, 1.575, 0.1, 0.29166666666667
23846, 1.6166666666667, 0.1, 0.29166666666667
23847, 1.6583333333333, 0.1, 0.29166666666667
23848, 1.7, 0.1, 0.29166666666667
23849, 1.7416666666667, 0.1, 0.29166666666667
23850, 1.7833333333333, 0.1, 0.29166666666667
23851, 1.825, 0.1, 0.29166666666667
23852, 1.8666666666667, 0.1, 0.29166666666667
23853, 1.9083333333333, 0.1, 0.29166666666667
23854, 1.95, 0.1, 0.29166666666667
23855, 1.9916666666667, 0.1, 0.29166666666667
23856, 2.0333333333333, 0.1, 0.29166666666667
23857, 2.075, 0.1, 0.29166666666667
23858, 2.1166666666667, 0.1, 0.29166666666667
23859, 2.1583333333333, 0.1, 0.29166666666667
23860, 1.2416666666667, 0.1, 0.33333333333333
23861, 1.2833333333333, 0.1, 0.33333333333333
23862, 1.325, 0.1, 0.33333333333333
23863, 1.3666666666667, 0.1, 0.33333333333333
23864, 1.4083333333333, 0.1, 0.33333333333333
23865, 1.45, 0.1, 0.33333333333333
23866, 1.4916666666667, 0.1, 0.33333333333333
23867, 1.5333333333333, 0.1, 0.33333333333333
23868, 1.575, 0.1, 0.33333333333333
23869, 1.6166666666667, 0.1, 0.33333333333333
23870, 1.6583333333333, 0.1, 0.33333333333333
23871, 1.7, 0.1, 0.33333333333333
23872, 1.7416666666667, 0.1, 0.33333333333333
23873, 1.7833333333333, 0.1, 0.33333333333333
23874, 1.825, 0.1, 0.33333333333333
23875, 1.8666666666667, 0.1, 0.33333333333333
23876, 1.9083333333333, 0.1, 0.33333333333333
23877, 1.95, 0.1, 0.33333333333333
23878, 1.9916666666667, 0.1, 0.33333333333333
23879, 2.0333333333333, 0.1, 0.33333333333333
23880, 2.075, 0.1, 0.33333333333333
23881, 2.1166666666667, 0.1, 0.33333333333333
23882, 2.1583333333333, 0.1, 0.33333333333333
23883, 1.2416666666667, 0.1, 0.375
23884, 1.2833333333333, 0.1, 0.375
23885, 1.325, 0.1, 0.375
23886, 1.3666666666667, 0.1, 0.375
23887, 1.4083333333333, 0.1, 0.375
23888, 1.45, 0.1, 0.375
23889, 1.4916666666667, 0.1, 0.375
23890, 1.5333333333333, 0.1, 0.375
23891, 1.575, 0.1, 0.375
23892, 1.6166666666667, 0.1, 0.375
23893, 1.6583333333333, 0.1, 0.375
23894, 1.7, 0.1, 0.375
23895, 1.7416666666667, 0.1, 0.375
23896, 1.7833333333333, 0.1, 0.375
23897, 1.825, 0.1, 0.375
23898, 1.8666666666667, 0.1, 0.375
23899, 1.9083333333333, 0.1, 0.375
23900, 1.95, 0.1, 0.375
23901, 1.9916666666667, 0.1, 0.375
23902, 2.0333333333333, 0.1, 0.375
23903, 2.075, 0.1, 0.375
23904, 2.1166666666667, 0.1, 0.375
23905, 2.1583333333333, 0.1, 0.375
23906, 1.2416666666667, 0.1, 0.41666666666667
23907, 1.2833333333333, 0.1, 0.41666666666667
23908, 1.325, 0.1, 0.41666666666667
23909, 1.3666666666667, 0.1, 0.41666666666667
23910, 1.4083333333333, 0.1, 0.41666666666667
23911, 1.45, 0.1, 0.41666666666667
23912, 1.4916666666667, 0.1, 0.41666666666667
23913, 1.5333333333333, 0.1, 0.41666666666667
23914, 1.575, 0.1, 0.41666666666667
23915, 1.6166666666667, 0.1, 0.41666666666667
23916, 1.6583333333333, 0.1, 0.41666666666667
23917, 1.7, 0.1, 0.41666666666667
23918, 1.7416666666667, 0.1, 0.41666666666667
23919, 1.7833333333333, 0.1, 0.41666666666667
23920, 1.825, 0.1, 0.41666666666667
23921, 1.8666666666667, 0.1, 0.41666666666667
23922, 1.9083333333333, 0.1, 0.41666666666667
23923, 1.95, 0.1, 0.41666666666667
23924, 1.9916666666667, 0.1, 0.41666666666667
23925, 2.0333333333333, 0.1, 0.41666666666667
23926, 2.075, 0.1, 0.41666666666667
23927, 2.1166666666667, 0.1, 0.41666666666667
23928, 2.1583333333333, 0.1, 0.41666666666667
23929, 1.2416666666667, 0.1, 0.45833333333333
23930, 1.2833333333333, 0.1, 0.45833333333333
23931, 1.325, 0.1, 0.45833333333333
23932, 1.3666666666667, 0.1, 0.45833333333333
23933, 1.4083333333333, 0.1, 0.45833333333333
23934, 1.45, 0.1, 0.45833333333333
23935, 1.4916666666667, 0.1, 0.45833333333333
23936, 1.5333333333333, 0.1, 0.45833333333333
23937, 1.575, 0.1, 0.45833333333333
23938, 1.6166666666667, 0.1, 0.45833333333333
23939, 1.6583333333333, 0.1, 0.45833333333333
23940, 1.7, 0.1, 0.45833333333333
23941, 1.7416666666667, 0.1, 0.45833333333333
23942, 1.7833333333333, 0.1, 0.45833333333333
23943, 1.825, 0.1, 0.45833333333333
23944, 1.8666666666667, 0.1, 0.45833333333333
23945, 1.9083333333333, 0.1, 0.45833333333333
23946, 1.95, 0.1, 0.45833333333333
23947, 1.9916666666667, 0.1, 0.45833333333333
23948, 2.0333333333333, 0.1, 0.45833333333333
23949, 2.075, 0.1, 0.45833333333333
23950, 2.1166666666667, 0.1, 0.45833333333333
23951, 2.1583333333333, 0.1, 0.45833333333333
23952, 1.2416666666667, 0.1, 0.020833333333333
23953, 1.2208333333333, 0.1, 0.041666666666667
23954, 1.2833333333333, 0.1, 0.020833333333333
23955, 1.2625, 0.1, 0.041666666666667
23956, 1.325, 0.1, 0.020833333333333
23957, 1.3041666666667, 0.1, 0.041666666666667
23958, 1.3666666666667, 0.1, 0.020833333333333
23959, 1.3458333333333, 0.1, 0.041666666666667
23960, 1.4083333333333, 0.1, 0.020833333333333
23961, 1.3875, 0.1, 0.041666666666667
23962, 1.45, 0.1, 0.020833333333333
23963, 1.4291666666667, 0.1, 0.041666666666667
23964, 1.4916666666667, 0.1, 0.020833333333333
23965, 1.4708333333333, 0.1, 0.041666666666667
23966, 1.5333333333333, 0.1, 0.020833333333333
23967, 1.5125, 0.1, 0.041666666666667
23968, 1.575, 0.1, 0.020833333333333
23969, 1.5541666666667, 0.1, 0.041666666666667
23970, 1.6166666666667, 0.1, 0.020833333333333
23971, 1.5958333333333, 0.1, 0.041666666666667
23972, 1.6583333333333, 0.1, 0.020833333333333
23973, 1.6375, 0.1, 0.041666666666667
23974, 1.7, 0.1, 0.020833333333333
23975, 1.6791666666667, 0.1, 0.041666666666667
23976, 1.7416666666667, 0.1, 0.020833333333333
23977, 1.7208333333333, 0.1, 0.041666666666667
23978, 1.7833333333333, 0.1, 0.020833333333333
23979, 1.7625, 0.1, 0.041666666666667
23980, 1.825, 0.1, 0.020833333333333
23981, 1.8041666666667, 0.1, 0.041666666666667
23982, 1.8666666666667, 0.1, 0.020833333333333
23983, 1.8458333333333, 0.1, 0.041666666666667
23984, 1.9083333333333, 0.1, 0.020833333333333
23985, 1.8875, 0.1, 0.041666666666667
23986, 1.95, 0.1, 0.020833333333333
23987, 1.9291666666667, 0.1, 0.041666666666667
23988, 1.9916666666667, 0.1, 0.020833333333333
23989, 1.9708333333333, 0.1, 0.041666666666667
23990, 2.0333333333333, 0.1, 0.020833333333333
23991, 2.0125, 0.1, 0.041666666666667
23992, 2.075, 0.1, 0.020833333333333
23993, 2.0541666666667, 0.1, 0.041666666666667
23994, 2.1166666666667, 0.1, 0.020833333333333
23995, 2.0958333333333, 0.1, 0.041666666666667
23996, 2.1583333333333, 0.1, 0.020833333333333
23997, 2.1375, 0.1, 0.041666666666667
23998, 2.1791666666667, 0.1, 0.041666666666667
23999, 1.2416666666667, 0.1, 0.0625
24000, 1.2208333333333, 0.1, 0.083333333333333
24001, 1.2833333333333, 0.1, 0.0625
24002, 1.2625, 0.1, 0.083333333333333
24003, 1.325, 0.1, 0.0625
24004, 1.3041666666667, 0.1, 0.083333333333333
24005, 1.3666666666667, 0.1, 0.0625
24006, 1.3458333333333, 0.1, 0.083333333333333
24007, 1.4083333333333, 0.1, 0.0625
24008, 1.3875, 0.1, 0.083333333333333
24009, 1.45, 0.1, 0.0625
24010, 1.4291666666667, 0.1, 0.083333333333333
24011, 1.4916666666667, 0.1, 0.0625
24012, 1.4708333333333, 0.1, 0.083333333333333
24013, 1.5333333333333, 0.1, 0.0625
24014, 1.5125, 0.1, 0.083333333333333
24015, 1.575, 0.1, 0.0625
24016, 1.5541666666667, 0.1, 0.083333333333333
24017, 1.6166666666667, 0.1, 0.0625
24018, 1.5958333333333, 0.1, 0.083333333333333
24019, 1.6583333333333, 0.1, 0.0625
24020, 1.6375, 0.1, 0.083333333333333
24021, 1.7, 0.1, 0.0625
24022, 1.6791666666667, 0.1, 0.083333333333333
24023, 1.7416666666667, 0.1, 0.0625
24024, 1.7208333333333, 0.1, 0.083333333333333
24025, 1.7833333333333, 0.1, 0.0625
24026, 1.7625, 0.1, 0.083333333333333
24027, 1.825, 0.1, 0.0625
24028, 1.8041666666667, 0.1, 0.083333333333333
24029, 1.8666666666667, 0.1, 0.0625
24030, 1.8458333333333, 0.1, 0.083333333333333
24031, 1.9083333333333, 0.1, 0.0625
24032, 1.8875, 0.1, 0.083333333333333
24033, 1.95, 0.1, 0.0625
24034, 1.9291666666667, 0.1, 0.083333333333333
24035, 1.9916666666667, 0.1, 0.0625
24036, 1.9708333333333, 0.1, 0.083333333333333
24037, 2.0333333333333, 0.1, 0.0625
24038, 2.0125, 0.1, 0.083333333333333
24039, 2.075, 0.1, 0.0625
24040, 2.0541666666667, 0.1, 0.083333333333333
24041, 2.1166666666667, 0.1, 0.0625
24042, 2.0958333333333, 0.1, 0.083333333333333
24043, 2.1583333333333, 0.1, 0.0625
24044, 2.1375, 0.1, 0.083333333333333
24045, 2.1791666666667, 0.1, 0.083333333333333
24046, 1.2416666666667, 0.1, 0.10416666666667
24047, 1.2208333333333, 0.1, 0.125
24048, 1.2833333333333, 0.1, 0.10416666666667
24049, 1.2625, 0.1, 0.125
24050, 1.325, 0.1, 0.10416666666667
24051, 1.3041666666667, 0.1, 0.125
24052, 1.3666666666667, 0.1, 0.10416666666667
24053, 1.3458333333333, 0.1, 0.125
24054, 1.4083333333333, 0.1, 0.10416666666667
24055, 1.3875, 0.1, 0.125
24056, 1.45, 0.1, 0.10416666666667
24057, 1.4291666666667, 0.1, 0.125
24058, 1.4916666666667, 0.1, 0.10416666666667
24059, 1.4708333333333, 0.1, 0.125
24060, 1.5333333333333, 0.1, 0.10416666666667
24061, 1.5125, 0.1, 0.125
24062, 1.575, 0.1, 0.10416666666667
24063, 1.5541666666667, 0.1, 0.125
24064, 1.6166666666667, 0.1, 0.10416666666667
24065, 1.5958333333333, 0.1, 0.125
24066, 1.6583333333333, 0.1, 0.10416666666667
24067, 1.6375, 0.1, 0.125
24068, 1.7, 0.1, 0.10416666666667
24069, 1.6791666666667, 0.1, 0.125
24070, 1.7416666666667, 0.1, 0.10416666666667
24071, 1.7208333333333, 0.1, 0.125
24072, 1.7833333333333, 0.1, 0.10416666666667
24073, 1.7625, 0.1, 0.125
24074, 1.825, 0.1, 0.10416666666667
24075, 1.8041666666667, 0.1, 0.125
24076, 1.8666666666667, 0.1, 0.10416666666667
24077, 1.8458333333333, 0.1, 0.125
24078, 1.9083333333333, 0.1, 0.10416666666667
24079, 1.8875, 0.1, 0.125
24080, 1.95, 0.1, 0.10416666666667
24081, 1.9291666666667, 0.1, 0.125
24082, 1.9916666666667, 0.1, 0.10416666666667
24083, 1.9708333333333, 0.1, 0.125
24084, 2.0333333333333, 0.1, 0.10416666666667
24085, 2.0125, 0.1, 0.125
24086, 2.075, 0.1, 0.10416666666667
24087, 2.0541666666667, 0.1, 0.125
24088, 2.1166666666667, 0.1, 0.10416666666667
24089, 2.0958333333333, 0.1, 0.125
24090, 2.1583333333333, 0.1, 0.10416666666667
24091, 2.1375, 0.1, 0.125
24092, 2.1791666666667, 0.1, 0.125
24093, 1.2416666666667, 0.1, 0.14583333333333
24094, 1.2208333333333, 0.1, 0.16666666666667
24095, 1.2833333333333, 0.1, 0.14583333333333
24096, 1.2625, 0.1, 0.16666666666667
24097, 1.325, 0.1, 0.14583333333333
24098, 1.3041666666667, 0.1, 0.16666666666667
24099, 1.3666666666667, 0.1, 0.14583333333333
24100, 1.3458333333333, 0.1, 0.16666666666667
24101, 1.4083333333333, 0.1, 0.14583333333333
24102, 1.3875, 0.1, 0.16666666666667
24103, 1.45, 0.1, 0.14583333333333
24104, 1.4291666666667, 0.1, 0.16666666666667
24105, 1.4916666666667, 0.1, 0.14583333333333
24106, 1.4708333333333, 0.1, 0.16666666666667
24107, 1.5333333333333, 0.1, 0.14583333333333
24108, 1.5125, 0.1, 0.16666666666667
24109, 1.575, 0.1, 0.14583333333333
24110, 1.5541666666667, 0.1, 0.16666666666667
24111, 1.6166666666667, 0.1, 0.14583333333333
24112, 1.5958333333333, 0.1, 0.16666666666667
24113, 1.6583333333333, 0.1, 0.14583333333333
24114, 1.6375, 0.1, 0.16666666666667
24115, 1.7, 0.1, 0.14583333333333
24116, 1.6791666666667, 0.1, 0.16666666666667
24117, 1.7416666666667, 0.1, 0.14583333333333
24118, 1.7208333333333, 0.1, 0.16666666666667
24119, 1.7833333333333, 0.1, 0.14583333333333
24120, 1.7625, 0.1, 0.16666666666667
24121, 1.825, 0.1, 0.14583333333333
24122, 1.8041666666667, 0.1, 0.16666666666667
24123, 1.8666666666667, 0.1, 0.14583333333333
24124, 1.8458333333333, 0.1, 0.16666666666667
24125, 1.9083333333333, 0.1, 0.14583333333333
24126, 1.8875, 0.1, 0.16666666666667
24127, 1.95, 0.1, 0.14583333333333
24128, 1.9291666666667, 0.1, 0.16666666666667
24129, 1.9916666666667, 0.1, 0.14583333333333
24130, 1.9708333333333, 0.1, 0.16666666666667
24131, 2.0333333333333, 0.1, 0.14583333333333
24132, 2.0125, 0.1, 0.16666666666667
24133, 2.075, 0.1, 0.14583333333333
24134, 2.0541666666667, 0.1, 0.16666666666667
24135, 2.1166666666667, 0.1, 0.14583333333333
24136, 2.0958333333333, 0.1, 0.16666666666667
24137, 2.1583333333333, 0.1, 0.14583333333333
24138, 2.1375, 0.1, 0.16666666666667
24139, 2.1791666666667, 0.1, 0.16666666666667
24140, 1.2416666666667, 0.1, 0.1875
24141, 1.2208333333333, 0.1, 0.20833333333333
24142, 1.2833333333333, 0.1, 0.1875
24143, 1.2625, 0.1, 0.20833333333333
24144, 1.325, 0.1, 0.1875
24145, 1.3041666666667, 0.1, 0.20833333333333
24146, 1.3666666666667, 0.1, 0.1875
24147, 1.3458333333333, 0.1, 0.20833333333333
24148, 1.4083333333333, 0.1, 0.1875
24149, 1.3875, 0.1, 0.20833333333333
24150, 1.45, 0.1, 0.1875
24151, 1.4291666666667, 0.1, 0.20833333333333
24152, 1.4916666666667, 0.1, 0.1875
24153, 1.4708333333333, 0.1, 0.20833333333333
24154, 1.5333333333333, 0.1, 0.1875
24155, 1.5125, 0.1, 0.20833333333333
24156, 1.575, 0.1, 0.1875
24157, 1.5541666666667, 0.1, 0.20833333333333
24158, 1.6166666666667, 0.1, 0.1875
24159, 1.5958333333333, 0.1, 0.20833333333333
24160, 1.6583333333333, 0.1, 0.1875
24161, 1.6375, 0.1, 0.20833333333333
24162, 1.7, 0.1, 0.1875
24163, 1.6791666666667, 0.1, 0.20833333333333
24164, 1.7416666666667, 0.1, 0.1875
24165, 1.7208333333333, 0.1, 0.20833333333333
24166, 1.7833333333333, 0.1, 0.1875
24167, 1.7625, 0.1, 0.20833333333333
24168, 1.825, 0.1, 0.1875
24169, 1.8041666666667, 0.1, 0.20833333333333
24170, 1.8666666666667, 0.1, 0.1875
24171, 1.8458333333333, 0.1, 0.20833333333333
24172, 1.9083333333333, 0.1, 0.1875
24173, 1.8875, 0.1, 0.20833333333333
24174, 1.95, 0.1, 0.1875
24175, 1.9291666666667, 0.1, 0.20833333333333
24176, 1.9916666666667, 0.1, 0.1875
24177, 1.9708333333333, 0.1, 0.20833333333333
24178, 2.0333333333333, 0.1, 0.1875
24179, 2.0125, 0.1, 0.20833333333333
24180, 2.075, 0.1, 0.1875
24181, 2.0541666666667, 0.1, 0.20833333333333
24182, 2.1166666666667, 0.1, 0.1875
24183, 2.0958333333333, 0.1, 0.20833333333333
24184, 2.1583333333333, 0.1, 0.1875
24185, 2.1375, 0.1, 0.20833333333333
24186, 2.1791666666667, 0.1, 0.20833333333333
24187, 1.2416666666667, 0.1, 0.22916666666667
24188, 1.2208333333333, 0.1, 0.25
24189, 1.2833333333333, 0.1, 0.22916666666667
24190, 1.2625, 0.1, 0.25
24191, 1.325, 0.1, 0.22916666666667
24192, 1.3041666666667, 0.1, 0.25
24193, 1.3666666666667, 0.1, 0.22916666666667
24194, 1.3458333333333, 0.1, 0.25
24195, 1.4083333333333, 0.1, 0.22916666666667
24196, 1.3875, 0.1, 0.25
24197, 1.45, 0.1, 0.22916666666667
24198, 1.4291666666667, 0.1, 0.25
24199, 1.4916666666667, 0.1, 0.22916666666667
24200, 1.4708333333333, 0.1, 0.25
24201, 1.5333333333333, 0.1, 0.22916666666667
24202, 1.5125, 0.1, 0.25
24203, 1.575, 0.1, 0.22916666666667
24204, 1.5541666666667, 0.1, 0.25
24205, 1.6166666666667, 0.1, 0.22916666666667
24206, 1.5958333333333, 0.1, 0.25
24207, 1.6583333333333, 0.1, 0.22916666666667
24208, 1.6375, 0.1, 0.25
24209, 1.7, 0.1, 0.22916666666667
24210, 1.6791666666667, 0.1, 0.25
24211, 1.7416666666667, 0.1, 0.22916666666667
24212, 1.7208333333333, 0.1, 0.25
24213, 1.7833333333333, 0.1, 0.22916666666667
24214, 1.7625, 0.1, 0.25
24215, 1.825, 0.1, 0.22916666666667
24216, 1.8041666666667, 0.1, 0.25
24217, 1.8666666666667, 0.1, 0.22916666666667
24218, 1.8458333333333, 0.1, 0.25
24219, 1.9083333333333, 0.1, 0.22916666666667
24220, 1.8875, 0.1, 0.25
24221, 1.95, 0.1, 0.22916666666667
24222, 1.9291666666667, 0.1, 0.25
24223, 1.9916666666667, 0.1, 0.22916666666667
24224, 1.9708333333333, 0.1, 0.25
24225, 2.0333333333333, 0.1, 0.22916666666667
24226, 2.0125, 0.1, 0.25
24227, 2.075, 0.1, 0.22916666666667
24228, 2.0541666666667, 0.1, 0.25
24229, 2.1166666666667, 0.1, 0.22916666666667
24230, 2.0958333333333, 0.1, 0.25
24231, 2.1583333333333, 0.1, 0.22916666666667
24232, 2.1375, 0.1, 0.25
24233, 2.1791666666667, 0.1, 0.25
24234, 1.2416666666667, 0.1, 0.27083333333333
24235, 1.2208333333333, 0.1, 0.29166666666667
24236, 1.2833333333333, 0.1, 0.27083333333333
24237, 1.2625, 0.1, 0.29166666666667
24238, 1.325, 0.1, 0.27083333333333
24239, 1.3041666666667, 0.1, 0.29166666666667
24240, 1.3666666666667, 0.1, 0.27083333333333
24241, 1.3458333333333, 0.1, 0.29166666666667
24242, 1.4083333333333, 0.1, 0.27083333333333
24243, 1.3875, 0.1, 0.29166666666667
24244, 1.45, 0.1, 0.27083333333333
24245, 1.4291666666667, 0.1, 0.29166666666667
24246, 1.4916666666667, 0.1, 0.27083333333333
24247, 1.4708333333333, 0.1, 0.29166666666667
24248, 1.5333333333333, 0.1, 0.27083333333333
24249, 1.5125, 0.1, 0.29166666666667
24250, 1.575, 0.1, 0.27083333333333
24251, 1.5541666666667, 0.1, 0.29166666666667
24252, 1.6166666666667, 0.1, 0.27083333333333
24253, 1.5958333333333, 0.1, 0.29166666666667
24254, 1.6583333333333, 0.1, 0.27083333333333
24255, 1.6375, 0.1, 0.29166666666667
24256, 1.7, 0.1, 0.27083333333333
24257, 1.6791666666667, 0.1, 0.29166666666667
24258, 1.7416666666667, 0.1, 0.27083333333333
24259, 1.7208333333333, 0.1, 0.29166666666667
24260, 1.7833333333333, 0.1, 0.27083333333333
24261, 1.7625, 0.1, 0.29166666666667
24262, 1.825, 0.1, 0.27083333333333
24263, 1.8041666666667, 0.1, 0.29166666666667
24264, 1.8666666666667, 0.1, 0.27083333333333
24265, 1.8458333333333, 0.1, 0.29166666666667
24266, 1.9083333333333, 0.1, 0.27083333333333
24267, 1.8875, 0.1, 0.29166666666667
24268, 1.95, 0.1, 0.27083333333333
24269, 1.9291666666667, 0.1, 0.29166666666667
24270, 1.9916666666667, 0.1, 0.27083333333333
24271, 1.9708333333333, 0.1, 0.29166666666667
24272, 2.0333333333333, 0.1, 0.27083333333333
24273, 2.0125, 0.1, 0.29166666666667
24274, 2.075, 0.1, 0.27083333333333
24275, 2.0541666666667, 0.1, 0.29166666666667
24276, 2.1166666666667, 0.1, 0.27083333333333
24277, 2.0958333333333, 0.1, 0.29166666666667
24278, 2.1583333333333, 0.1, 0.27083333333333
24279, 2.1375, 0.1, 0.29166666666667
24280, 2.1791666666667, 0.1, 0.29166666666667
24281, 1.2416666666667, 0.1, 0.3125
24282, 1.2208333333333, 0.1, 0.33333333333333
24283, 1.2833333333333, 0.1, 0.3125
24284, 1.2625, 0.1, 0.33333333333333
24285, 1.325, 0.1, 0.3125
24286, 1.3041666666667, 0.1, 0.33333333333333
24287, 1.3666666666667, 0.1, 0.3125
24288, 1.3458333333333, 0.1, 0.33333333333333
24289, 1.4083333333333, 0.1, 0.3125
24290, 1.3875, 0.1, 0.33333333333333
24291, 1.45, 0.1, 0.3125
24292, 1.4291666666667, 0.1, 0.33333333333333
24293, 1.4916666666667, 0.1, 0.3125
24294, 1.4708333333333, 0.1, 0.33333333333333
24295, 1.5333333333333, 0.1, 0.3125
24296, 1.5125, 0.1, 0.33333333333333
24297, 1.575, 0.1, 0.3125
24298, 1.5541666666667, 0.1, 0.33333333333333
24299, 1.6166666666667, 0.1, 0.3125
24300, 1.5958333333333, 0.1, 0.33333333333333
24301, 1.6583333333333, 0.1, 0.3125
24302, 1.6375, 0.1, 0.33333333333333
24303, 1.7, 0.1, 0.3125
24304, 1.6791666666667, 0.1, 0.33333333333333
24305, 1.7416666666667, 0.1, 0.3125
24306, 1.7208333333333, 0.1, 0.33333333333333
24307, 1.7833333333333, 0.1, 0.3125
24308, 1.7625, 0.1, 0.33333333333333
24309, 1.825, 0.1, 0.3125
24310, 1.8041666666667, 0.1, 0.33333333333333
24311, 1.8666666666667, 0.1, 0.3125
24312, 1.8458333333333, 0.1, 0.33333333333333
24313, 1.9083333333333, 0.1, 0.3125
24314, 1.8875, 0.1, 0.33333333333333
24315, 1.95, 0.1, 0.3125
24316, 1.9291666666667, 0.1, 0.33333333333333
24317, 1.9916666666667, 0.1, 0.3125
24318, 1.9708333333333, 0.1, 0.33333333333333
24319, 2.0333333333333, 0.1, 0.3125
24320, 2.0125, 0.1, 0.33333333333333
24321, 2.075, 0.1, 0.3125
24322, 2.0541666666667, 0.1, 0.33333333333333
24323, 2.1166666666667, 0.1, 0.3125
24324, 2.0958333333333, 0.1, 0.33333333333333
24325, 2.1583333333333, 0.1, 0.3125
24326, 2.1375, 0.1, 0.33333333333333
24327, 2.1791666666667, 0.1, 0.33333333333333
24328, 1.2416666666667, 0.1, 0.35416666666667
24329, 1.2208333333333, 0.1, 0.375
24330, 1.2833333333333, 0.1, 0.35416666666667
24331, 1.2625, 0.1, 0.375
24332, 1.325, 0.1, 0.35416666666667
24333, 1.3041666666667, 0.1, 0.375
24334, 1.3666666666667, 0.1, 0.35416666666667
24335, 1.3458333333333, 0.1, 0.375
24336, 1.4083333333333, 0.1, 0.35416666666667
24337, 1.3875, 0.1, 0.375
24338, 1.45, 0.1, 0.35416666666667
24339, 1.4291666666667, 0.1, 0.375
24340, 1.4916666666667, 0.1, 0.35416666666667
24341, 1.4708333333333, 0.1, 0.375
24342, 1.5333333333333, 0.1, 0.35416666666667
24343, 1.5125, 0.1, 0.375
24344, 1.575, 0.1, 0.35416666666667
24345, 1.5541666666667, 0.1, 0.375
24346, 1.6166666666667, 0.1, 0.35416666666667
24347, 1.5958333333333, 0.1, 0.375
24348, 1.6583333333333, 0.1, 0.35416666666667
24349, 1.6375, 0.1, 0.375
24350, 1.7, 0.1, 0.35416666666667
24351, 1.6791666666667, 0.1, 0.375
24352, 1.7416666666667, 0.1, 0.35416666666667
24353, 1.7208333333333, 0.1, 0.375
24354, 1.7833333333333, 0.1, 0.35416666666667
24355, 1.7625, 0.1, 0.375
24356, 1.825, 0.1, 0.35416666666667
24357, 1.8041666666667, 0.1, 0.375
24358, 1.8666666666667, 0.1, 0.35416666666667
24359, 1.8458333333333, 0.1, 0.375
24360, 1.9083333333333, 0.1, 0.35416666666667
24361, 1.8875, 0.1, 0.375
24362, 1.95, 0.1, 0.35416666666667
24363, 1.9291666666667, 0.1, 0.375
24364, 1.9916666666667, 0.1, 0.35416666666667
24365, 1.9708333333333, 0.1, 0.375
24366, 2.0333333333333, 0.1, 0.35416666666667
24367, 2.0125, 0.1, 0.375
24368, 2.075, 0.1, 0.35416666666667
24369, 2.0541666666667, 0.1, 0.375
24370, 2.1166666666667, 0.1, 0.35416666666667
24371, 2.0958333333333, 0.1, 0.375
24372, 2.1583333333333, 0.1, 0.35416666666667
24373, 2.1375, 0.1, 0.375
24374, 2.1791666666667, 0.1, 0.375
24375, 1.2416666666667, 0.1, 0.39583333333333
24376, 1.2208333333333, 0.1, 0.41666666666667
24377, 1.2833333333333, 0.1, 0.39583333333333
24378, 1.2625, 0.1, 0.41666666666667
24379, 1.325, 0.1, 0.39583333333333
24380, 1.3041666666667, 0.1, 0.41666666666667
24381, 1.3666666666667, 0.1, 0.39583333333333
24382, 1.3458333333333, 0.1, 0.41666666666667
24383, 1.4083333333333, 0.1, 0.39583333333333
24384, 1.3875, 0.1, 0.41666666666667
24385, 1.45, 0.1, 0.39583333333333
24386, 1.4291666666667, 0.1, 0.41666666666667
24387, 1.4916666666667, 0.1, 0.39583333333333
24388, 1.4708333333333, 0.1, 0.41666666666667
24389, 1.5333333333333, 0.1, 0.39583333333333
24390, 1.5125, 0.1, 0.41666666666667
24391, 1.575, 0.1, 0.39583333333333
24392, 1.5541666666667, 0.1, 0.41666666666667
24393, 1.6166666666667, 0.1, 0.39583333333333
24394, 1.5958333333333, 0.1, 0.41666666666667
24395, 1.6583333333333, 0.1, 0.39583333333333
24396, 1.6375, 0.1, 0.41666666666667
24397, 1.7, 0.1, 0.39583333333333
24398, 1.6791666666667, 0.1, 0.41666666666667
24399, 1.7416666666667, 0.1, 0.39583333333333
24400, 1.7208333333333, 0.1, 0.41666666666667
24401, 1.7833333333333, 0.1, 0.39583333333333
24402, 1.7625, 0.1, 0.41666666666667
24403, 1.825, 0.1, 0.39583333333333
24404, 1.8041666666667, 0.1, 0.41666666666667
24405, 1.8666666666667, 0.1, 0.39583333333333
24406, 1.8458333333333, 0.1, 0.41666666666667
24407, 1.9083333333333, 0.1, 0.39583333333333
24408, 1.8875, 0.1, 0.41666666666667
24409, 1.95, 0.1, 0.39583333333333
24410, 1.9291666666667, 0.1, 0.41666666666667
24411, 1.9916666666667, 0.1, 0.39583333333333
24412, 1.9708333333333, 0.1, 0.41666666666667
24413, 2.0333333333333, 0.1, 0.39583333333333
24414, 2.0125, 0.1, 0.41666666666667
24415, 2.075, 0.1, 0.39583333333333
24416, 2.0541666666667, 0.1, 0.41666666666667
24417, 2.1166666666667, 0.1, 0.39583333333333
24418, 2.0958333333333, 0.1, 0.41666666666667
24419, 2.1583333333333, 0.1, 0.39583333333333
24420, 2.1375, 0.1, 0.41666666666667
24421, 2.1791666666667, 0.1, 0.41666666666667
24422, 1.2416666666667, 0.1, 0.4375
24423, 1.2208333333333, 0.1, 0.45833333333333
24424, 1.2833333333333, 0.1, 0.4375
24425, 1.2625, 0.1, 0.45833333333333
24426, 1.325, 0.1, 0.4375
24427, 1.3041666666667, 0.1, 0.45833333333333
24428, 1.3666666666667, 0.1, 0.4375
24429, 1.3458333333333, 0.1, 0.45833333333333
24430, 1.4083333333333, 0.1, 0.4375
24431, 1.3875, 0.1, 0.45833333333333
24432, 1.45, 0.1, 0.4375
24433, 1.4291666666667, 0.1, 0.45833333333333
24434, 1.4916666666667, 0.1, 0.4375
24435, 1.4708333333333, 0.1, 0.45833333333333
24436, 1.5333333333333, 0.1, 0.4375
24437, 1.5125, 0.1, 0.45833333333333
24438, 1.575, 0.1, 0.4375
24439, 1.5541666666667, 0.1, 0.45833333333333
24440, 1.6166666666667, 0.1, 0.4375
24441, 1.5958333333333, 0.1, 0.45833333333333
24442, 1.6583333333333, 0.1, 0.4375
24443, 1.6375, 0.1, 0.45833333333333
24444, 1.7, 0.1, 0.4375
24445, 1.6791666666667, 0.1, 0.45833333333333
24446, 1.7416666666667, 0.1, 0.4375
24447, 1.7208333333333, 0.1, 0.45833333333333
24448, 1.7833333333333, 0.1, 0.4375
24449, 1.7625, 0.1, 0.45833333333333
24450, 1.825, 0.1, 0.4375
24451, 1.8041666666667, 0.1, 0.45833333333333
24452, 1.8666666666667, 0.1, 0.4375
24453, 1.8458333333333, 0.1, 0.45833333333333
24454, 1.9083333333333, 0.1, 0.4375
24455, 1.8875, 0.1, 0.45833333333333
24456, 1.95, 0.1, 0.4375
24457, 1.9291666666667, 0.1, 0.45833333333333
24458, 1.9916666666667, 0.1, 0.4375
24459, 1.9708333333333, 0.1, 0.45833333333333
24460, 2.0333333333333, 0.1, 0.4375
24461, 2.0125, 0.1, 0.45833333333333
24462, 2.075, 0.1, 0.4375
24463, 2.0541666666667, 0.1, 0.45833333333333
24464, 2.1166666666667, 0.1, 0.4375
24465, 2.0958333333333, 0.1, 0.45833333333333
24466, 2.1583333333333, 0.1, 0.4375
24467, 2.1375, 0.1, 0.45833333333333
24468, 2.1791666666667, 0.1, 0.45833333333333
24469, 1.2416666666667, 0.1, 0.47916666666667
24470, 1.2833333333333, 0.1, 0.47916666666667
24471, 1.325, 0.1, 0.47916666666667
24472, 1.3666666666667, 0.1, 0.47916666666667
24473, 1.4083333333333, 0.1, 0.47916666666667
24474, 1.45, 0.1, 0.47916666666667
24475, 1.4916666666667, 0.1, 0.47916666666667
24476, 1.5333333333333, 0.1, 0.47916666666667
24477, 1.575, 0.1, 0.47916666666667
24478, 1.6166666666667, 0.1, 0.47916666666667
24479, 1.6583333333333, 0.1, 0.47916666666667
24480, 1.7, 0.1, 0.47916666666667
24481, 1.7416666666667, 0.1, 0.47916666666667
24482, 1.7833333333333, 0.1, 0.47916666666667
24483, 1.825, 0.1, 0.47916666666667
24484, 1.8666666666667, 0.1, 0.47916666666667
24485, 1.9083333333333, 0.1, 0.47916666666667
24486, 1.95, 0.1, 0.47916666666667
24487, 1.9916666666667, 0.1, 0.47916666666667
24488, 2.0333333333333, 0.1, 0.47916666666667
24489, 2.075, 0.1, 0.47916666666667
24490, 2.1166666666667, 0.1, 0.47916666666667
24491, 2.1583333333333, 0.1, 0.47916666666667
24492, 1.2416666666667, 0.066666666666667, 0.5
24493, 1.2416666666667, 0.033333333333333, 0.5
24494, 1.2833333333333, 0.066666666666667, 0.5
24495, 1.2833333333333, 0.033333333333333, 0.5
24496, 1.325, 0.066666666666667, 0.5
24497, 1.325, 0.033333333333333, 0.5
24498, 1.3666666666667, 0.066666666666667, 0.5
24499, 1.3666666666667, 0.033333333333333, 0.5
24500, 1.4083333333333, 0.066666666666667, 0.5
24501, 1.4083333333333, 0.033333333333333, 0.5
24502, 1.45, 0.066666666666667, 0.5
24503, 1.45, 0.033333333333333, 0.5
24504, 1.4916666666667, 0.066666666666667, 0.5
24505, 1.4916666666667, 0.033333333333333, 0.5
24506, 1.5333333333333, 0.066666666666667, 0.5
24507, 1.5333333333333, 0.033333333333333, 0.5
24508, 1.575, 0.066666666666667, 0.5
24509, 1.575, 0.033333333333333, 0.5
24510, 1.6166666666667, 0.066666666666667, 0.5
24511, 1.6166666666667, 0.033333333333333, 0.5
24512, 1.6583333333333, 0.066666666666667, 0.5
24513, 1.6583333333333, 0.033333333333333, 0.5
24514, 1.7, 0.066666666666667, 0.5
24515, 1.7, 0.033333333333333, 0.5
24516, 1.7416666666667, 0.066666666666667, 0.5
24517, 1.7416666666667, 0.033333333333333, 0.5
24518, 1.7833333333333, 0.066666666666667, 0.5
24519, 1.7833333333333, 0.033333333333333, 0.5
24520, 1.825, 0.066666666666667, 0.5
24521, 1.825, 0.033333333333333, 0.5
24522, 1.8666666666667, 0.066666666666667, 0.5
24523, 1.8666666666667, 0.033333333333333, 0.5
24524, 1.9083333333333, 0.066666666666667, 0.5
24525, 1.9083333333333, 0.033333333333333, 0.5
24526, 1.95, 0.066666666666667, 0.5
24527, 1.95, 0.033333333333333, 0.5
24528, 1.9916666666667, 0.066666666666667, 0.5
24529, 1.9916666666667, 0.033333333333333, 0.5
24530, 2.0333333333333, 0.066666666666667, 0.5
24531, 2.0333333333333, 0.033333333333333, 0.5
24532, 2.075, 0.066666666666667, 0.5
24533, 2.075, 0.033333333333333, 0.5
24534, 2.1166666666667, 0.066666666666667, 0.5
24535, 2.1166666666667, 0.033333333333333, 0.5
24536, 2.1583333333333, 0.066666666666667, 0.5
24537, 2.1583333333333, 0.033333333333333, 0.5
24538, 1.2208333333333, 0.066666666666667, 0.5
24539, 1.2416666666667, 0.083333333333333, 0.5
24540, 1.2208333333333, 0.033333333333333, 0.5
24541, 1.2416666666667, 0.05, 0.5
24542, 1.2416666666667, 0.016666666666667, 0.5
24543, 1.2625, 0.066666666666667, 0.5
24544, 1.2833333333333, 0.083333333333333, 0.5
24545, 1.2625, 0.033333333333333, 0.5
24546, 1.2833333333333, 0.05, 0.5
24547, 1.2833333333333, 0.016666666666667, 0.5
24548, 1.3041666666667, 0.066666666666667, 0.5
24549, 1.325, 0.083333333333333, 0.5
24550, 1.3041666666667, 0.033333333333333, 0.5
24551, 1.325, 0.05, 0.5
24552, 1.325, 0.016666666666667, 0.5
24553, 1.3458333333333, 0.066666666666667, 0.5
24554, 1.3666666666667, 0.083333333333333, 0.5
24555, 1.3458333333333, 0.033333333333333, 0.5
24556, 1.3666666666667, 0.05, 0.5
24557, 1.3666666666667, 0.016666666666667, 0.5
24558, 1.3875, 0.066666666666667, 0.5
24559, 1.4083333333333, 0.083333333333333, 0.5
24560, 1.3875, 0.033333333333333, 0.5
24561, 1.4083333333333, 0.05, 0.5
24562, 1.4083333333333, 0.016666666666667, 0.5
24563, 1.4291666666667, 0.066666666666667, 0.5
24564, 1.45, 0.083333333333333, 0.5
24565, 1.4291666666667, 0.033333333333333, 0.5
24566, 1.45, 0.05, 0.5
24567, 1.45, 0.016666666666667, 0.5
24568, 1.4708333333333, 0.066666666666667, 0.5
24569, 1.4916666666667, 0.083333333333333, 0.5
24570, 1.4708333333333, 0.033333333333333, 0.5
24571, 1.4916666666667, 0.05, 0.5
24572, 1.4916666666667, 0.016666666666667, 0.5
24573, 1.5125, 0.066666666666667, 0.5
24574, 1.5333333333333, 0.083333333333333, 0.5
24575, 1.5125, 0.033333333333333, 0.5
24576, 1.5333333333333, 0.05, 0.5
24577, 1.5333333333333, 0.016666666666667, 0.5
24578, 1.5541666666667, 0.066666666666667, 0.5
24579, 1.575, 0.083333333333333, 0.5
24580, 1.5541666666667, 0.033333333333333, 0.5
24581, 1.575, 0.05, 0.5
24582, 1.575, 0.016666666666667, 0.5
24583, 1.5958333333333, 0.066666666666667, 0.5
24584, 1.6166666666667, 0.083333333333333, 0.5
24585, 1.5958333333333, 0.033333333333333, 0.5
24586, 1.6166666666667, 0.05, 0.5
24587, 1.6166666666667, 0.016666666666667, 0.5
24588, 1.6375, 0.066666666666667, 0.5
24589, 1.6583333333333, 0.083333333333333, 0.5
24590, 1.6375, 0.033333333333333, 0.5
24591, 1.6583333333333, 0.05, 0.5
24592, 1.6583333333333, 0.016666666666667, 0.5
24593, 1.6791666666667, 0.066666666666667, 0.5
24594, 1.7, 0.083333333333333, 0.5
24595, 1.6791666666667, 0.033333333333333, 0.5
24596, 1.7, 0.05, 0.5
24597, 1.7, 0.016666666666667, 0.5
24598, 1.7208333333333, 0.066666666666667, 0.5
24599, 1.7416666666667, 0.083333333333333, 0.5
24600, 1.7208333333333, 0.033333333333333, 0.5
24601, 1.7416666666667, 0.05, 0.5
24602, 1.7416666666667, 0.016666666666667, 0.5
24603, 1.7625, 0.066666666666667, 0.5
24604, 1.7833333333333, 0.083333333333333, 0.5
24605, 1.7625, 0.033333333333333, 0.5
24606, 1.7833333333333, 0.05, 0.5
24607, 1.7833333333333, 0.016666666666667, 0.5
24608, 1.8041666666667, 0.066666666666667, 0.5
24609, 1.825, 0.083333333333333, 0.5
24610, 1.8041666666667, 0.033333333333333, 0.5
24611, 1.825, 0.05, 0.5
24612, 1.825, 0.016666666666667, 0.5
24613, 1.8458333333333, 0.066666666666667, 0.5
24614, 1.8666666666667, 0.083333333333333, 0.5
24615, 1.8458333333333, 0.033333333333333, 0.5
24616, 1.8666666666667, 0.05, 0.5
24617, 1.8666666666667, 0.016666666666667, 0.5
24618, 1.8875, 0.066666666666667, 0.5
24619, 1.9083333333333, 0.083333333333333, 0.5
24620, 1.8875, 0.033333333333333, 0.5
24621, 1.9083333333333, 0.05, 0.5
24622, 1.9083333333333, 0.016666666666667, 0.5
24623, 1.9291666666667, 0.066666666666667, 0.5
24624, 1.95, 0.083333333333333, 0.5
24625, 1.9291666666667, 0.033333333333333, 0.5
24626, 1.95, 0.05, 0.5
24627, 1.95, 0.016666666666667, 0.5
24628, 1.9708333333333, 0.066666666666667, 0.5
24629, 1.9916666666667, 0.083333333333333, 0.5
24630, 1.9708333333333, 0.033333333333333, 0.5
24631, 1.9916666666667, 0.05, 0.5
24632, 1.9916666666667, 0.016666666666667, 0.5
24633, 2.0125, 0.066666666666667, 0.5
24634, 2.0333333333333, 0.083333333333333, 0.5
24635, 2.0125, 0.033333333333333, 0.5
24636, 2.0333333333333, 0.05, 0.5
24637, 2.0333333333333, 0.016666666666667, 0.5
24638, 2.0541666666667, 0.066666666666667, 0.5
24639, 2.075, 0.083333333333333, 0.5
24640, 2.0541666666667, 0.033333333333333, 0.5
24641, 2.075, 0.05, 0.5
24642, 2.075, 0.016666666666667, 0.5
24643, 2.0958333333333, 0.066666666666667, 0.5
24644, 2.1166666666667, 0.083333333333333, 0.5
24645, 2.0958333333333, 0.033333333333333, 0.5
24646, 2.1166666666667, 0.05, 0.5
24647, 2.1166666666667, 0.016666666666667, 0.5
24648, 2.1375, 0.066666666666667, 0.5
24649, 2.1583333333333, 0.083333333333333, 0.5
24650, 2.1375, 0.033333333333333, 0.5
24651, 2.1583333333333, 0.05, 0.5
24652, 2.1583333333333, 0.016666666666667, 0.5
24653, 2.1791666666667, 0.066666666666667, 0.5
24654, 2.1791666666667, 0.033333333333333, 0.5
24655, 1.2416666666667, 0.066666666666667, 0
24656, 1.2416666666667, 0.033333333333333, 0
24657, 1.2833333333333, 0.066666666666667, 0
24658, 1.2833333333333, 0.033333333333333, 0
24659, 1.325, 0.066666666666667, 0
24660, 1.325, 0.033333333333333, 0
24661, 1.3666666666667, 0.066666666666667, 0
24662, 1.3666666666667, 0.033333333333333, 0
24663, 1.4083333333333, 0.066666666666667, 0
24664, 1.4083333333333, 0.033333333333333, 0
24665, 1.45, 0.066666666666667, 0
24666, 1.45, 0.033333333333333, 0
24667, 1.4916666666667, 0.066666666666667, 0
24668, 1.4916666666667, 0.033333333333333, 0
24669, 1.5333333333333, 0.066666666666667, 0
24670, 1.5333333333333, 0.033333333333333, 0
24671, 1.575, 0.066666666666667, 0
24672, 1.575, 0.033333333333333, 0
24673, 1.6166666666667, 0.066666666666667, 0
24674, 1.6166666666667, 0.033333333333333, 0
24675, 1.6583333333333, 0.066666666666667, 0
24676, 1.6583333333333, 0.033333333333333, 0
24677, 1.7, 0.066666666666667, 0
24678, 1.7, 0.033333333333333, 0
24679, 1.7416666666667, 0.066666666666667, 0
24680, 1.7416666666667, 0.033333333333333, 0
24681, 1.7833333333333, 0.066666666666667, 0
24682, 1.7833333333333, 0.033333333333333, 0
24683, 1.825, 0.066666666666667, 0
24684, 1.825, 0.033333333333333, 0
24685, 1.8666666666667, 0.066666666666667, 0
24686, 1.8666666666667, 0.033333333333333, 0
24687, 1.9083333333333, 0.066666666666667, 0
24688, 1.9083333333333, 0.033333333333333, 0
24689, 1.95, 0.066666666666667, 0
24690, 1.95, 0.033333333333333, 0
24691, 1.9916666666667, 0.066666666666667, 0
24692, 1.9916666666667, 0.033333333333333, 0
24693, 2.0333333333333, 0.066666666666667, 0
24694, 2.0333333333333, 0.033333333333333, 0
24695, 2.075, 0.066666666666667, 0
24696, 2.075, 0.033333333333333, 0
24697, 2.1166666666667, 0.066666666666667, 0
24698, 2.1166666666667, 0.033333333333333, 0
24699, 2.1583333333333, 0.066666666666667, 0
24700, 2.1583333333333, 0.033333333333333, 0
24701, 1.2416666666667, 0.083333333333333, 0
24702, 1.2208333333333, 0.066666666666667, 0
24703, 1.2416666666667, 0.05, 0
24704, 1.2208333333333, 0.033333333333333, 0
24705, 1.2416666666667, 0.016666666666667, 0
24706, 1.2833333333333, 0.083333333333333, 0
24707, 1.2625, 0.066666666666667, 0
24708, 1.2833333333333, 0.05, 0
24709, 1.2625, 0.033333333333333, 0
24710, 1.2833333333333, 0.016666666666667, 0
24711, 1.325, 0.083333333333333, 0
24712, 1.3041666666667, 0.066666666666667, 0
24713, 1.325, 0.05, 0
24714, 1.3041666666667, 0.033333333333333, 0
24715, 1.325, 0.016666666666667, 0
24716, 1.3666666666667, 0.083333333333333, 0
24717, 1.3458333333333, 0.066666666666667, 0
24718, 1.3666666666667, 0.05, 0
24719, 1.3458333333333, 0.033333333333333, 0
24720, 1.3666666666667, 0.016666666666667, 0
24721, 1.4083333333333, 0.083333333333333, 0
24722, 1.3875, 0.066666666666667, 0
24723, 1.4083333333333, 0.05, 0
24724, 1.3875, 0.033333333333333, 0
24725, 1.4083333333333, 0.016666666666667, 0
24726, 1.45, 0.083333333333333, 0
24727, 1.4291666666667, 0.066666666666667, 0
24728, 1.45, 0.05, 0
24729, 1.4291666666667, 0.033333333333333, 0
24730, 1.45, 0.016666666666667, 0
24731, 1.4916666666667, 0.083333333333333, 0
24732, 1.4708333333333, 0.066666666666667, 0
24733, 1.4916666666667, 0.05, 0
24734, 1.4708333333333, 0.033333333333333, 0
24735, 1.4916666666667, 0.016666666666667, 0
24736, 1.5333333333333, 0.083333333333333, 0
24737, 1.5125, 0.066666666666667, 0
24738, 1.5333333333333, 0.05, 0
24739, 1.5125, 0.033333333333333, 0
24740, 1.5333333333333, 0.016666666666667, 0
24741, 1.575, 0.083333333333333, 0
24742, 1.5541666666667, 0.066666666666667, 0
24743, 1.575, 0.05, 0
24744, 1.5541666666667, 0.033333333333333, 0
24745, 1.575, 0.016666666666667, 0
24746, 1.6166666666667, 0.083333333333333, 0
24747, 1.5958333333333, 0.066666666666667, 0
24748, 1.6166666666667, 0.05, 0
24749, 1.5958333333333, 0.033333333333333, 0
24750, 1.6166666666667, 0.016666666666667, 0
24751, 1.6583333333333, 0.083333333333333, 0
24752, 1.6375, 0.066666666666667, 0
24753, 1.6583333333333, 0.05, 0
24754, 1.6375, 0.033333333333333, 0
24755, 1.6583333333333, 0.016666666666667, 0
24756, 1.7, 0.083333333333333, 0
24757, 1.6791666666667, 0.066666666666667, 0
24758, 1.7, 0.05, 0
24759, 1.6791666666667, 0.033333333333333, 0
24760, 1.7, 0.016666666666667, 0
24761, 1.7416666666667, 0.083333333333333, 0
24762, 1.7208333333333, 0.066666666666667, 0
24763, 1.7416666666667, 0.05, 0
24764, 1.7208333333333, 0.033333333333333, 0
24765, 1.7416666666667, 0.016666666666667, 0
24766, 1.7833333333333, 0.083333333333333, 0
24767, 1.7625, 0.066666666666667, 0
24768, 1.7833333333333, 0.05, 0
24769, 1.7625, 0.033333333333333, 0
24770, 1.7833333333333, 0.016666666666667, 0
24771, 1.825, 0.083333333333333, 0
24772, 1.8041666666667, 0.066666666666667, 0
24773, 1.825, 0.05, 0
24774, 1.8041666666667, 0.033333333333333, 0
24775, 1.825, 0.016666666666667, 0
24776, 1.8666666666667, 0.083333333333333, 0
24777, 1.8458333333333, 0.066666666666667, 0
24778, 1.8666666666667, 0.05, 0
24779, 1.8458333333333, 0.033333333333333, 0
24780, 1.8666666666667, 0.016666666666667, 0
24781, 1.9083333333333, 0.083333333333333, 0
24782, 1.8875, 0.066666666666667, 0
24783, 1.9083333333333, 0.05, 0
24784, 1.8875, 0.033333333333333, 0
24785, 1.9083333333333, 0.016666666666667, 0
24786, 1.95, 0.083333333333333, 0
24787, 1.9291666666667, 0.066666666666667, 0
24788, 1.95, 0.05, 0
24789, 1.9291666666667, 0.033333333333333, 0
24790, 1.95, 0.016666666666667, 0
24791, 1.9916666666667, 0.083333333333333, 0
24792, 1.9708333333333, 0.066666666666667, 0
24793, 1.9916666666667, 0.05, 0
24794, 1.9708333333333, 0.033333333333333, 0
24795, 1.9916666666667, 0.016666666666667, 0
24796, 2.0333333333333, 0.083333333333333, 0
24797, 2.0125, 0.066666666666667, 0
24798, 2.0333333333333, 0.05, 0
24799, 2.0125, 0.033333333333333, 0
24800, 2.0333333333333, 0.016666666666667, 0
24801, 2.075, 0.083333333333333, 0
24802, 2.0541666666667, 0.066666666666667, 0
24803, 2.075, 0.05, 0
24804, 2.0541666666667, 0.033333333333333, 0
24805, 2.075, 0.016666666666667, 0
24806, 2.1166666666667, 0.083333333333333, 0
24807, 2.0958333333333, 0.066666666666667, 0
24808, 2.1166666666667, 0.05, 0
24809, 2.0958333333333, 0.033333333333333, 0
24810, 2.1166666666667, 0.016666666666667, 0
24811, 2.1583333333333, 0.083333333333333, 0
24812, 2.1375, 0.066666666666667, 0
24813, 2.1583333333333, 0.05, 0
24814, 2.1375, 0.033333333333333, 0
24815, 2.1583333333333, 0.016666666666667, 0
24816, 2.1791666666667, 0.066666666666667, 0
24817, 2.1791666666667, 0.033333333333333, 0
24818, 1.2, 0.066666666666667, 0.041666666666667
24819, 1.2, 0.033333333333333, 0.041666666666667
24820, 1.2, 0.066666666666667, 0.083333333333333
24821, 1.2, 0.033333333333333, 0.083333333333333
24822, 1.2, 0.066666666666667, 0.125
24823, 1.2, 0.033333333333333, 0.125
24824, 1.2, 0.066666666666667, 0.16666666666667
24825, 1.2, 0.033333333333333, 0.16666666666667
24826, 1.2, 0.066666666666667, 0.20833333333333
24827, 1.2, 0.033333333333333, 0.20833333333333
24828, 1.2, 0.066666666666667, 0.25
24829, 1.2, 0.033333333333333, 0.25
24830, 1.2, 0.066666666666667, 0.29166666666667
24831, 1.2, 0.033333333333333, 0.29166666666667
24832, 1.2, 0.066666666666667, 0.33333333333333
24833, 1.2, 0.033333333333333, 0.33333333333333
24834, 1.2, 0.066666666666667, 0.375
24835, 1.2, 0.033333333333333, 0.375
24836, 1.2, 0.066666666666667, 0.41666666666667
24837, 1.2, 0.033333333333333, 0.41666666666667
24838, 1.2, 0.066666666666667, 0.45833333333333
24839, 1.2, 0.033333333333333, 0.45833333333333
24840, 1.2, 0.066666666666667, 0.020833333333333
24841, 1.2, 0.083333333333333, 0.041666666666667
24842, 1.2, 0.033333333333333, 0.020833333333333
24843, 1.2, 0.05, 0.041666666666667
24844, 1.2, 0.016666666666667, 0.041666666666667
24845, 1.2, 0.066666666666667, 0.0625
24846, 1.2, 0.083333333333333, 0.083333333333333
24847, 1.2, 0.033333333333333, 0.0625
24848, 1.2, 0.05, 0.083333333333333
24849, 1.2, 0.016666666666667, 0.083333333333333
24850, 1.2, 0.066666666666667, 0.10416666666667
24851, 1.2, 0.083333333333333, 0.125
24852, 1.2, 0.033333333333333, 0.10416666666667
24853, 1.2, 0.05, 0.125
24854, 1.2, 0.016666666666667, 0.125
24855, 1.2, 0.066666666666667, 0.14583333333333
24856, 1.2, 0.083333333333333, 0.16666666666667
24857, 1.2, 0.033333333333333, 0.14583333333333
24858, 1.2, 0.05, 0.16666666666667
24859, 1.2, 0.016666666666667, 0.16666666666667
24860, 1.2, 0.066666666666667, 0.1875
24861, 1.2, 0.083333333333333, 0.20833333333333
24862, 1.2, 0.033333333333333, 0.1875
24863, 1.2, 0.05, 0.20833333333333
24864, 1.2, 0.016666666666667, 0.20833333333333
24865, 1.2, 0.066666666666667, 0.22916666666667
24866, 1.2, 0.083333333333333, 0.25
24867, 1.2, 0.033333333333333, 0.22916666666667
24868, 1.2, 0.05, 0.25
24869, 1.2, 0.016666666666667, 0.25
24870, 1.2, 0.066666666666667, 0.27083333333333
24871, 1.2, 0.083333333333333, 0.29166666666667
24872, 1.2, 0.033333333333333, 0.27083333333333
24873, 1.2, 0.05, 0.29166666666667
24874, 1.2, 0.016666666666667, 0.29166666666667
24875, 1.2, 0.066666666666667, 0.3125
24876, 1.2, 0.083333333333333, 0.33333333333333
24877, 1.2, 0.033333333333333, 0.3125
24878, 1.2, 0.05, 0.33333333333333
24879, 1.2, 0.016666666666667, 0.33333333333333
24880, 1.2, 0.066666666666667, 0.35416666666667
24881, 1.2, 0.083333333333333, 0.375
24882, 1.2, 0.033333333333333, 0.35416666666667
24883, 1.2, 0.05, 0.375
24884, 1.2, 0.016666666666667, 0.375
24885, 1.2, 0.066666666666667, 0.39583333333333
24886, 1.2, 0.083333333333333, 0.41666666666667
24887, 1.2, 0.033333333333333, 0.39583333333333
24888, 1.2, 0.05, 0.41666666666667
24889, 1.2, 0.016666666666667, 0.41666666666667
24890, 1.2, 0.066666666666667, 0.4375
24891, 1.2, 0.083333333333333, 0.45833333333333
24892, 1.2, 0.033333333333333, 0.4375
24893, 1.2, 0.05, 0.45833333333333
24894, 1.2, 0.016666666666667, 0.45833333333333
24895, 1.2, 0.066666666666667, 0.47916666666667
24896, 1.2, 0.033333333333333, 0.47916666666667
24897, 2.2, 0.066666666666667, 0.041666666666667
24898, 2.2, 0.033333333333333, 0.041666666666667
24899, 2.2, 0.066666666666667, 0.083333333333333
24900, 2.2, 0.033333333333333, 0.083333333333333
24901, 2.2, 0.066666666666667, 0.125
24902, 2.2, 0.033333333333333, 0.125
24903, 2.2, 0.066666666666667, 0.16666666666667
24904, 2.2, 0.033333333333333, 0.16666666666667
24905, 2.2, 0.066666666666667, 0.20833333333333
24906, 2.2, 0.033333333333333, 0.20833333333333
24907, 2.2, 0.066666666666667, 0.25
24908, 2.2, 0.033333333333333, 0.25
24909, 2.2, 0.066666666666667, 0.29166666666667
24910, 2.2, 0.033333333333333, 0.29166666666667
24911, 2.2, 0.066666666666667, 0.33333333333333
24912, 2.2, 0.033333333333333, 0.33333333333333
24913, 2.2, 0.066666666666667, 0.375
24914, 2.2, 0.033333333333333, 0.375
24915, 2.2, 0.066666666666667, 0.41666666666667
24916, 2.2, 0.033333333333333, 0.41666666666667
24917, 2.2, 0.066666666666667, 0.45833333333333
24918, 2.2, 0.033333333333333, 0.45833333333333
24919, 2.2, 0.083333333333333, 0.041666666666667
24920, 2.2, 0.066666666666667, 0.020833333333333
24921, 2.2, 0.05, 0.041666666666667
24922, 2.2, 0.033333333333333, 0.020833333333333
24923, 2.2, 0.016666666666667, 0.041666666666667
24924, 2.2, 0.083333333333333, 0.083333333333333
24925, 2.2, 0.066666666666667, 0.0625
24926, 2.2, 0.05, 0.083333333333333
24927, 2.2, 0.033333333333333, 0.0625
24928, 2.2, 0.016666666666667, 0.083333333333333
24929, 2.2, 0.083333333333333, 0.125
24930, 2.2, 0.066666666666667, 0.10416666666667
24931, 2.2, 0.05, 0.125
24932, 2.2, 0.033333333333333, 0.10416666666667
24933, 2.2, 0.016666666666667, 0.125
24934, 2.2, 0.083333333333333, 0.16666666666667
24935, 2.2, 0.066666666666667, 0.14583333333333
24936, 2.2, 0.05, 0.16666666666667
24937, 2.2, 0.033333333333333, 0.14583333333333
24938, 2.2, 0.016666666666667, 0.16666666666667
24939, 2.2, 0.083333333333333, 0.20833333333333
24940, 2.2, 0.066666666666667, 0.1875
24941, 2.2, 0.05, 0.20833333333333
24942, 2.2, 0.033333333333333, 0.1875
24943, 2.2, 0.016666666666667, 0.20833333333333
24944, 2.2, 0.083333333333333, 0.25
24945, 2.2, 0.066666666666667, 0.22916666666667
24946, 2.2, 0.05, 0.25
24947, 2.2, 0.033333333333333, 0.22916666666667
24948, 2.2, 0.016666666666667, 0.25
24949, 2.2, 0.083333333333333, 0.29166666666667
24950, 2.2, 0.066666666666667, 0.27083333333333
24951, 2.2, 0.05, 0.29166666666667
24952, 2.2, 0.033333333333333, 0.27083333333333
24953, 2.2, 0.016666666666667, 0.29166666666667
24954, 2.2, 0.083333333333333, 0.33333333333333
24955, 2.2, 0.066666666666667, 0.3125
24956, 2.2, 0.05, 0.33333333333333
24957, 2.2, 0.033333333333333, 0.3125
24958, 2.2, 0.016666666666667, 0.33333333333333
24959, 2.2, 0.083333333333333, 0.375
24960, 2.2, 0.066666666666667, 0.35416666666667
24961, 2.2, 0.05, 0.375
24962, 2.2, 0.033333333333333, 0.35416666666667
24963, 2.2, 0.016666666666667, 0.375
24964, 2.2, 0.083333333333333, 0.41666666666667
24965, 2.2, 0.066666666666667, 0.39583333333333
24966, 2.2, 0.05, 0.41666666666667
24967, 2.2, 0.033333333333333, 0.39583333333333
24968, 2.2, 0.016666666666667, 0.41666666666667
24969, 2.2, 0.083333333333333, 0.45833333333333
24970, 2.2, 0.066666666666667, 0.4375
24971, 2.2, 0.05, 0.45833333333333
24972, 2.2, 0.033333333333333, 0.4375
24973, 2.2, 0.016666666666667, 0.45833333333333
24974, 2.2, 0.066666666666667, 0.47916666666667
24975, 2.2, 0.033333333333333, 0.47916666666667
24976, 1.2416666666667, 1.2490009027033e-16, 0.041666666666667
24977, 1.2833333333333, 1.2490009027033e-16, 0.041666666666667
24978, 1.325, 1.2490009027033e-16, 0.041666666666667
24979, 1.3666666666667, 1.2490009027033e-16, 0.041666666666667
24980, 1.4083333333333, 1.2490009027033e-16, 0.041666666666667
24981, 1.45, 1.2490009027033e-16, 0.041666666666667
24982, 1.4916666666667, 1.2490009027033e-16, 0.041666666666667
24983, 1.5333333333333, 1.2490009027033e-16, 0.041666666666667
24984, 1.575, 1.2490009027033e-16, 0.041666666666667
24985, 1.6166666666667, 1.2490009027033e-16, 0.041666666666667
24986, 1.6583333333333, 1.2490009027033e-16, 0.041666666666667
24987, 1.7, 1.2490009027033e-16, 0.041666666666667
24988, 1.7416666666667, 1.2490009027033e-16, 0.041666666666667
24989, 1.7833333333333, 1.2490009027033e-16, 0.041666666666667
24990, 1.825, 1.2490009027033e-16, 0.041666666666667
24991, 1.8666666666667, 1.2490009027033e-16, 0.041666666666667
24992, 1.9083333333333, 1.2490009027033e-16, 0.041666666666667
24993, 1.95, 1.2490009027033e-16, 0.041666666666667
24994, 1.9916666666667, 1.2490009027033e-16, 0.041666666666667
24995, 2.0333333333333, 1.2490009027033e-16, 0.041666666666667
24996, 2.075, 1.2490009027033e-16, 0.041666666666667
24997, 2.1166666666667, 1.2490009027033e-16, 0.041666666666667
24998, 2.1583333333333, 1.2490009027033e-16, 0.041666666666667
24999, 1.2416666666667, 1.2490009027033e-16, 0.083333333333333
25000, 1.2833333333333, 1.2490009027033e-16, 0.083333333333333
25001, 1.325, 1.2490009027033e-16, 0.083333333333333
25002, 1.3666666666667, 1.2490009027033e-16, 0.083333333333333
25003, 1.4083333333333, 1.2490009027033e-16, 0.083333333333333
25004, 1.45, 1.2490009027033e-16, 0.083333333333333
25005, 1.4916666666667, 1.2490009027033e-16, 0.083333333333333
25006, 1.5333333333333, 1.2490009027033e-16, 0.083333333333333
25007, 1.575, 1.2490009027033e-16, 0.083333333333333
25008, 1.6166666666667, 1.2490009027033e-16, 0.083333333333333
25009, 1.6583333333333, 1.2490009027033e-16, 0.083333333333333
25010, 1.7, 1.2490009027033e-16, 0.083333333333333
25011, 1.7416666666667, 1.2490009027033e-16, 0.083333333333333
25012, 1.7833333333333, 1.2490009027033e-16, 0.083333333333333
25013, 1.825, 1.2490009027033e-16, 0.083333333333333
25014, 1.8666666666667, 1.2490009027033e-16, 0.083333333333333
25015, 1.9083333333333, 1.2490009027033e-16, 0.083333333333333
25016, 1.95, 1.2490009027033e-16, 0.083333333333333
25017, 1.9916666666667, 1.2490009027033e-16, 0.083333333333333
25018, 2.0333333333333, 1.2490009027033e-16, 0.083333333333333
25019, 2.075, 1.2490009027033e-16, 0.083333333333333
25020, 2.1166666666667, 1.2490009027033e-16, 0.083333333333333
25021, 2.1583333333333, 1.2490009027033e-16, 0.083333333333333
25022, 1.2416666666667, 1.2490009027033e-16, 0.125
25023, 1.2833333333333, 1.2490009027033e-16, 0.125
25024, 1.325, 1.2490009027033e-16, 0.125
25025, 1.3666666666667, 1.2490009027033e-16, 0.125
25026, 1.4083333333333, 1.2490009027033e-16, 0.125
25027, 1.45, 1.2490009027033e-16, 0.125
25028, 1.4916666666667, 1.2490009027033e-16, 0.125
25029, 1.5333333333333, 1.2490009027033e-16, 0.125
25030, 1.575, 1.2490009027033e-16, 0.125
25031, 1.6166666666667, 1.2490009027033e-16, 0.125
25032, 1.6583333333333, 1.2490009027033e-16, 0.125
25033, 1.7, 1.2490009027033e-16, 0.125
25034, 1.7416666666667, 1.2490009027033e-16, 0.125
25035, 1.7833333333333, 1.2490009027033e-16, 0.125
25036, 1.825, 1.2490009027033e-16, 0.125
25037, 1.8666666666667, 1.2490009027033e-16, 0.125
25038, 1.9083333333333, 1.2490009027033e-16, 0.125
25039, 1.95, 1.2490009027033e-16, 0.125
25040, 1.9916666666667, 1.2490009027033e-16, 0.125
25041, 2.0333333333333, 1.2490009027033e-16, 0.125
25042, 2.075, 1.2490009027033e-16, 0.125
25043, 2.1166666666667, 1.2490009027033e-16, 0.125
25044, 2.1583333333333, 1.2490009027033e-16, 0.125
25045, 1.2416666666667, 1.2490009027033e-16, 0.16666666666667
25046, 1.2833333333333, 1.2490009027033e-16, 0.16666666666667
25047, 1.325, 1.2490009027033e-16, 0.16666666666667
25048, 1.3666666666667, 1.2490009027033e-16, 0.16666666666667
25049, 1.4083333333333, 1.2490009027033e-16, 0.16666666666667
25050, 1.45, 1.2490009027033e-16, 0.16666666666667
25051, 1.4916666666667, 1.2490009027033e-16, 0.16666666666667
25052, 1.5333333333333, 1.2490009027033e-16, 0.16666666666667
25053, 1.575, 1.2490009027033e-16, 0.16666666666667
25054, 1.6166666666667, 1.2490009027033e-16, 0.16666666666667
25055, 1.6583333333333, 1.2490009027033e-16, 0.16666666666667
25056, 1.7, 1.2490009027033e-16, 0.16666666666667
25057, 1.7416666666667, 1.2490009027033e-16, 0.16666666666667
25058, 1.7833333333333, 1.2490009027033e-16, 0.16666666666667
25059, 1.825, 1.2490009027033e-16, 0.16666666666667
25060, 1.8666666666667, 1.2490009027033e-16, 0.16666666666667
25061, 1.9083333333333, 1.2490009027033e-16, 0.16666666666667
25062, 1.95, 1.2490009027033e-16, 0.16666666666667
25063, 1.9916666666667, 1.2490009027033e-16, 0.16666666666667
25064, 2.0333333333333, 1.2490009027033e-16, 0.16666666666667
25065, 2.075, 1.2490009027033e-16, 0.16666666666667
25066, 2.1166666666667, 1.2490009027033e-16, 0.16666666666667
25067, 2.1583333333333, 1.2490009027033e-16, 0.16666666666667
25068, 1.2416666666667, 1.2490009027033e-16, 0.20833333333333
25069, 1.2833333333333, 1.2490009027033e-16, 0.20833333333333
25070, 1.325, 1.2490009027033e-16, 0.20833333333333
25071, 1.3666666666667, 1.2490009027033e-16, 0.20833333333333
25072, 1.4083333333333, 1.2490009027033e-16, 0.20833333333333
25073, 1.45, 1.2490009027033e-16, 0.20833333333333
25074, 1.4916666666667, 1.2490009027033e-16, 0.20833333333333
25075, 1.5333333333333, 1.2490009027033e-16, 0.20833333333333
25076, 1.575, 1.2490009027033e-16, 0.20833333333333
25077, 1.6166666666667, 1.2490009027033e-16, 0.20833333333333
25078, 1.6583333333333, 1.2490009027033e-16, 0.20833333333333
25079, 1.7, 1.2490009027033e-16, 0.20833333333333
25080, 1.7416666666667, 1.2490009027033e-16, 0.20833333333333
25081, 1.7833333333333, 1.2490009027033e-16, 0.20833333333333
25082, 1.825, 1.2490009027033e-16, 0.20833333333333
25083, 1.8666666666667, 1.2490009027033e-16, 0.20833333333333
25084, 1.9083333333333, 1.2490009027033e-16, 0.20833333333333
25085, 1.95, 1.2490009027033e-16, 0.20833333333333
25086, 1.9916666666667, 1.2490009027033e-16, 0.20833333333333
25087, 2.0333333333333, 1.2490009027033e-16, 0.20833333333333
25088, 2.075, 1.2490009027033e-16, 0.20833333333333
25089, 2.1166666666667, 1.2490009027033e-16, 0.20833333333333
25090, 2.1583333333333, 1.2490009027033e-16, 0.20833333333333
25091, 1.2416666666667, 1.2490009027033e-16, 0.25
25092, 1.2833333333333, 1.2490009027033e-16, 0.25
25093, 1.325, 1.2490009027033e-16, 0.25
25094, 1.3666666666667, 1.2490009027033e-16, 0.25
25095, 1.4083333333333, 1.2490009027033e-16, 0.25
25096, 1.45, 1.2490009027033e-16, 0.25
25097, 1.4916666666667, 1.2490009027033e-16, 0.25
25098, 1.5333333333333, 1.2490009027033e-16, 0.25
25099, 1.575, 1.2490009027033e-16, 0.25
25100, 1.6166666666667, 1.2490009027033e-16, 0.25
25101, 1.6583333333333, 1.2490009027033e-16, 0.25
25102, 1.7, 1.2490009027033e-16, 0.25
25103, 1.7416666666667, 1.2490009027033e-16, 0.25
25104, 1.7833333333333, 1.2490009027033e-16, 0.25
25105, 1.825, 1.2490009027033e-16, 0.25
25106, 1.8666666666667, 1.2490009027033e-16, 0.25
25107, 1.9083333333333, 1.2490009027033e-16, 0.25
25108, 1.95, 1.2490009027033e-16, 0.25
25109, 1.9916666666667, 1.2490009027033e-16, 0.25
25110, 2.0333333333333, 1.2490009027033e-16, 0.25
25111, 2.075, 1.2490009027033e-16, 0.25
25112, 2.1166666666667, 1.2490009027033e-16, 0.25
25113, 2.1583333333333, 1.2490009027033e-16, 0.25
25114, 1.2416666666667, 1.2490009027033e-16, 0.29166666666667
25115, 1.2833333333333, 1.2490009027033e-16, 0.29166666666667
25116, 1.325, 1.2490009027033e-16, 0.29166666666667
25117, 1.3666666666667, 1.2490009027033e-16, 0.29166666666667
25118, 1.4083333333333, 1.2490009027033e-16, 0.29166666666667
25119, 1.45, 1.2490009027033e-16, 0.29166666666667
25120, 1.4916666666667, 1.2490009027033e-16, 0.29166666666667
25121, 1.5333333333333, 1.2490009027033e-16, 0.29166666666667
25122, 1.575, 1.2490009027033e-16, 0.29166666666667
25123, 1.6166666666667, 1.2490009027033e-16, 0.29166666666667
25124, 1.6583333333333, 1.2490009027033e-16, 0.29166666666667
25125, 1.7, 1.2490009027033e-16, 0.29166666666667
25126, 1.7416666666667, 1.2490009027033e-16, 0.29166666666667
25127, 1.7833333333333, 1.2490009027033e-16, 0.29166666666667
25128, 1.825, 1.2490009027033e-16, 0.29166666666667
25129, 1.8666666666667, 1.2490009027033e-16, 0.29166666666667
25130, 1.9083333333333, 1.2490009027033e-16, 0.29166666666667
25131, 1.95, 1.2490009027033e-16, 0.29166666666667
25132, 1.9916666666667, 1.2490009027033e-16, 0.29166666666667
25133, 2.0333333333333, 1.2490009027033e-16, 0.29166666666667
25134, 2.075, 1.2490009027033e-16, 0.29166666666667
25135, 2.1166666666667, 1.2490009027033e-16, 0.29166666666667
25136, 2.1583333333333, 1.2490009027033e-16, 0.29166666666667
25137, 1.2416666666667, 1.2490009027033e-16, 0.33333333333333
25138, 1.2833333333333, 1.2490009027033e-16, 0.33333333333333
25139, 1.325, 1.2490009027033e-16, 0.33333333333333
25140, 1.3666666666667, 1.2490009027033e-16, 0.33333333333333
25141, 1.4083333333333, 1.2490009027033e-16, 0.33333333333333
25142, 1.45, 1.2490009027033e-16, 0.33333333333333
25143, 1.4916666666667, 1.2490009027033e-16, 0.33333333333333
25144, 1.5333333333333, 1.2490009027033e-16, 0.33333333333333
25145, 1.575, 1.2490009027033e-16, 0.33333333333333
25146, 1.6166666666667, 1.2490009027033e-16, 0.33333333333333
25147, 1.6583333333333, 1.2490009027033e-16, 0.33333333333333
25148, 1.7, 1.2490009027033e-16, 0.33333333333333
25149, 1.7416666666667, 1.2490009027033e-16, 0.33333333333333
25150, 1.7833333333333, 1.2490009027033e-16, 0.33333333333333
25151, 1.825, 1.2490009027033e-16, 0.33333333333333
25152, 1.8666666666667, 1.2490009027033e-16, 0.33333333333333
25153, 1.9083333333333, 1.2490009027033e-16, 0.33333333333333
25154, 1.95, 1.2490009027033e-16, 0.33333333333333
25155, 1.9916666666667, 1.2490009027033e-16, 0.33333333333333
25156, 2.0333333333333, 1.2490009027033e-16, 0.33333333333333
25157, 2.075, 1.2490009027033e-16, 0.33333333333333
25158, 2.1166666666667, 1.2490009027033e-16, 0.33333333333333
25159, 2.1583333333333, 1.2490009027033e-16, 0.33333333333333
25160, 1.2416666666667, 1.2490009027033e-16, 0.375
25161, 1.2833333333333, 1.2490009027033e-16, 0.375
25162, 1.325, 1.2490009027033e-16, 0.375
25163, 1.3666666666667, 1.2490009027033e-16, 0.375
25164, 1.4083333333333, 1.2490009027033e-16, 0.375
25165, 1.45, 1.2490009027033e-16, 0.375
25166, 1.4916666666667, 1.2490009027033e-16, 0.375
25167, 1.5333333333333, 1.2490009027033e-16, 0.375
25168, 1.575, 1.2490009027033e-16, 0.375
25169, 1.6166666666667, 1.2490009027033e-16, 0.375
25170, 1.6583333333333, 1.2490009027033e-16, 0.375
25171, 1.7, 1.2490009027033e-16, 0.375
25172, 1.7416666666667, 1.2490009027033e-16, 0.375
25173, 1.7833333333333, 1.2490009027033e-16, 0.375
25174, 1.825, 1.2490009027033e-16, 0.375
25175, 1.8666666666667, 1.2490009027033e-16, 0.375
25176, 1.9083333333333, 1.2490009027033e-16, 0.375
25177, 1.95, 1.2490009027033e-16, 0.375
25178, 1.9916666666667, 1.2490009027033e-16, 0.375
25179, 2.0333333333333, 1.2490009027033e-16, 0.375
25180, 2.075, 1.2490009027033e-16, 0.375
25181, 2.1166666666667, 1.2490009027033e-16, 0.375
25182, 2.1583333333333, 1.2490009027033e-16, 0.375
25183, 1.2416666666667, 1.2490009027033e-16, 0.41666666666667
25184, 1.2833333333333, 1.2490009027033e-16, 0.41666666666667
25185, 1.325, 1.2490009027033e-16, 0.41666666666667
25186, 1.3666666666667, 1.2490009027033e-16, 0.41666666666667
25187, 1.4083333333333, 1.2490009027033e-16, 0.41666666666667
25188, 1.45, 1.2490009027033e-16, 0.41666666666667
25189, 1.4916666666667, 1.2490009027033e-16, 0.41666666666667
25190, 1.5333333333333, 1.2490009027033e-16, 0.41666666666667
25191, 1.575, 1.2490009027033e-16, 0.41666666666667
25192, 1.6166666666667, 1.2490009027033e-16, 0.41666666666667
25193, 1.6583333333333, 1.2490009027033e-16, 0.41666666666667
25194, 1.7, 1.2490009027033e-16, 0.41666666666667
25195, 1.7416666666667, 1.2490009027033e-16, 0.41666666666667
25196, 1.7833333333333, 1.2490009027033e-16, 0.41666666666667
25197, 1.825, 1.2490009027033e-16, 0.41666666666667
25198, 1.8666666666667, 1.2490009027033e-16, 0.41666666666667
25199, 1.9083333333333, 1.2490009027033e-16, 0.41666666666667
25200, 1.95, 1.2490009027033e-16, 0.41666666666667
25201, 1.9916666666667, 1.2490009027033e-16, 0.41666666666667
25202, 2.0333333333333, 1.2490009027033e-16, 0.41666666666667
25203, 2.075, 1.2490009027033e-16, 0.41666666666667
25204, 2.1166666666667, 1.2490009027033e-16, 0.41666666666667
25205, 2.1583333333333, 1.2490009027033e-16, 0.41666666666667
25206, 1.2416666666667, 1.2490009027033e-16, 0.45833333333333
25207, 1.2833333333333, 1.2490009027033e-16, 0.45833333333333
25208, 1.325, 1.2490009027033e-16, 0.45833333333333
25209, 1.3666666666667, 1.2490009027033e-16, 0.45833333333333
25210, 1.4083333333333, 1.2490009027033e-16, 0.45833333333333
25211, 1.45, 1.2490009027033e-16, 0.45833333333333
25212, 1.4916666666667, 1.2490009027033e-16, 0.45833333333333
25213, 1.5333333333333, 1.2490009027033e-16, 0.45833333333333
25214, 1.575, 1.2490009027033e-16, 0.45833333333333
25215, 1.6166666666667, 1.2490009027033e-16, 0.45833333333333
25216, 1.6583333333333, 1.2490009027033e-16, 0.45833333333333
25217, 1.7, 1.2490009027033e-16, 0.45833333333333
25218, 1.7416666666667, 1.2490009027033e-16, 0.45833333333333
25219, 1.7833333333333, 1.2490009027033e-16, 0.45833333333333
25220, 1.825, 1.2490009027033e-16, 0.45833333333333
25221, 1.8666666666667, 1.2490009027033e-16, 0.45833333333333
25222, 1.9083333333333, 1.2490009027033e-16, 0.45833333333333
25223, 1.95, 1.2490009027033e-16, 0.45833333333333
25224, 1.9916666666667, 1.2490009027033e-16, 0.45833333333333
25225, 2.0333333333333, 1.2490009027033e-16, 0.45833333333333
25226, 2.075, 1.2490009027033e-16, 0.45833333333333
25227, 2.1166666666667, 1.2490009027033e-16, 0.45833333333333
25228, 2.1583333333333, 1.2490009027033e-16, 0.45833333333333
25229, 1.2416666666667, 0, 0.020833333333333
25230, 1.2208333333333, 0, 0.041666666666667
25231, 1.2833333333333, 0, 0.020833333333333
25232, 1.2625, 0, 0.041666666666667
25233, 1.325, 0, 0.020833333333333
25234, 1.3041666666667, 0, 0.041666666666667
25235, 1.3666666666667, 0, 0.020833333333333
25236, 1.3458333333333, 0, 0.041666666666667
25237, 1.4083333333333, 0, 0.020833333333333
25238, 1.3875, 0, 0.041666666666667
25239, 1.45, 0, 0.020833333333333
25240, 1.4291666666667, 0, 0.041666666666667
25241, 1.4916666666667, 0, 0.020833333333333
25242, 1.4708333333333, 0, 0.041666666666667
25243, 1.5333333333333, 0, 0.020833333333333
25244, 1.5125, 0, 0.041666666666667
25245, 1.575, 0, 0.020833333333333
25246, 1.5541666666667, 0, 0.041666666666667
25247, 1.6166666666667, 0, 0.020833333333333
25248, 1.5958333333333, 0, 0.041666666666667
25249, 1.6583333333333, 0, 0.020833333333333
25250, 1.6375, 0, 0.041666666666667
25251, 1.7, 0, 0.020833333333333
25252, 1.6791666666667, 0, 0.041666666666667
25253, 1.7416666666667, 0, 0.020833333333333
25254, 1.7208333333333, 0, 0.041666666666667
25255, 1.7833333333333, 0, 0.020833333333333
25256, 1.7625, 0, 0.041666666666667
25257, 1.825, 0, 0.020833333333333
25258, 1.8041666666667, 0, 0.041666666666667
25259, 1.8666666666667, 0, 0.020833333333333
25260, 1.8458333333333, 0, 0.041666666666667
25261, 1.9083333333333, 0, 0.020833333333333
25262, 1.8875, 0, 0.041666666666667
25263, 1.95, 0, 0.020833333333333
25264, 1.9291666666667, 0, 0.041666666666667
25265, 1.9916666666667, 0, 0.020833333333333
25266, 1.9708333333333, 0, 0.041666666666667
25267, 2.0333333333333, 0, 0.020833333333333
25268, 2.0125, 0, 0.041666666666667
25269, 2.075, 0, 0.020833333333333
25270, 2.0541666666667, 0, 0.041666666666667
25271, 2.1166666666667, 0, 0.020833333333333
25272, 2.0958333333333, 0, 0.041666666666667
25273, 2.1583333333333, 0, 0.020833333333333
25274, 2.1375, 0, 0.041666666666667
25275, 2.1791666666667, 0, 0.041666666666667
25276, 1.2416666666667, 0, 0.0625
25277, 1.2208333333333, 0, 0.083333333333333
25278, 1.2833333333333, 0, 0.0625
25279, 1.2625, 0, 0.083333333333333
25280, 1.325, 0, 0.0625
25281, 1.3041666666667, 0, 0.083333333333333
25282, 1.3666666666667, 0, 0.0625
25283, 1.3458333333333, 0, 0.083333333333333
25284, 1.4083333333333, 0, 0.0625
25285, 1.3875, 0, 0.083333333333333
25286, 1.45, 0, 0.0625
25287, 1.4291666666667, 0, 0.083333333333333
25288, 1.4916666666667, 0, 0.0625
25289, 1.4708333333333, 0, 0.083333333333333
25290, 1.5333333333333, 0, 0.0625
25291, 1.5125, 0, 0.083333333333333
25292, 1.575, 0, 0.0625
25293, 1.5541666666667, 0, 0.083333333333333
25294, 1.6166666666667, 0, 0.0625
25295, 1.5958333333333, 0, 0.083333333333333
25296, 1.6583333333333, 0, 0.0625
25297, 1.6375, 0, 0.083333333333333
25298, 1.7, 0, 0.0625
25299, 1.6791666666667, 0, 0.083333333333333
25300, 1.7416666666667, 0, 0.0625
25301, 1.7208333333333, 0, 0.083333333333333
25302, 1.7833333333333, 0, 0.0625
25303, 1.7625, 0, 0.083333333333333
25304, 1.825, 0, 0.0625
25305, 1.8041666666667, 0, 0.083333333333333
25306, 1.8666666666667, 0, 0.0625
25307, 1.8458333333333, 0, 0.083333333333333
25308, 1.9083333333333, 0, 0.0625
25309, 1.8875, 0, 0.083333333333333
25310, 1.95, 0, 0.0625
25311, 1.9291666666667, 0, 0.083333333333333
25312, 1.9916666666667, 0, 0.0625
25313, 1.9708333333333, 0, 0.083333333333333
25314, 2.0333333333333, 0, 0.0625
25315, 2.0125, 0, 0.083333333333333
25316, 2.075, 0, 0.0625
25317, 2.0541666666667, 0, 0.083333333333333
25318, 2.1166666666667, 0, 0.0625
25319, 2.0958333333333, 0, 0.083333333333333
25320, 2.1583333333333, 0, 0.0625
25321, 2.1375, 0, 0.083333333333333
25322, 2.1791666666667, 0, 0.083333333333333
25323, 1.2416666666667, 0, 0.10416666666667
25324, 1.2208333333333, 0, 0.125
25325, 1.2833333333333, 0, 0.10416666666667
25326, 1.2625, 0, 0.125
25327, 1.325, 0, 0.10416666666667
25328, 1.3041666666667, 0, 0.125
25329, 1.3666666666667, 0, 0.10416666666667
25330, 1.3458333333333, 0, 0.125
25331, 1.4083333333333, 0, 0.10416666666667
25332, 1.3875, 0, 0.125
25333, 1.45, 0, 0.10416666666667
25334, 1.4291666666667, 0, 0.125
25335, 1.4916666666667, 0, 0.10416666666667
25336, 1.4708333333333, 0, 0.125
25337, 1.5333333333333, 0, 0.10416666666667
25338, 1.5125, 0, 0.125
25339, 1.575, 0, 0.10416666666667
25340, 1.5541666666667, 0, 0.125
25341, 1.6166666666667, 0, 0.10416666666667
25342, 1.5958333333333, 0, 0.125
25343, 1.6583333333333, 0, 0.10416666666667
25344, 1.6375, 0, 0.125
25345, 1.7, 0, 0.10416666666667
25346, 1.6791666666667, 0, 0.125
25347, 1.7416666666667, 0, 0.10416666666667
25348, 1.7208333333333, 0, 0.125
25349, 1.7833333333333, 0, 0.10416666666667
25350, 1.7625, 0, 0.125
25351, 1.825, 0, 0.10416666666667
25352, 1.8041666666667, 0, 0.125
25353, 1.8666666666667, 0, 0.10416666666667
25354, 1.8458333333333, 0, 0.125
25355, 1.9083333333333, 0, 0.10416666666667
25356, 1.8875, 0, 0.125
25357, 1.95, 0, 0.10416666666667
25358, 1.9291666666667, 0, 0.125
25359, 1.9916666666667, 0, 0.10416666666667
25360, 1.9708333333333, 0, 0.125
25361, 2.0333333333333, 0, 0.10416666666667
25362, 2.0125, 0, 0.125
25363, 2.075, 0, 0.10416666666667
25364, 2.0541666666667, 0, 0.125
25365, 2.1166666666667, 0, 0.10416666666667
25366, 2.0958333333333, 0, 0.125
25367, 2.1583333333333, 0, 0.10416666666667
25368, 2.1375, 0, 0.125
25369, 2.1791666666667, 0, 0.125
25370, 1.2416666666667, 0, 0.14583333333333
25371, 1.2208333333333, 0, 0.16666666666667
25372, 1.2833333333333, 0, 0.14583333333333
25373, 1.2625, 0, 0.16666666666667
25374, 1.325, 0, 0.14583333333333
25375, 1.3041666666667, 0, 0.16666666666667
25376, 1.3666666666667, 0, 0.14583333333333
25377, 1.3458333333333, 0, 0.16666666666667
25378, 1.4083333333333, 0, 0.14583333333333
25379, 1.3875, 0, 0.16666666666667
25380, 1.45, 0, 0.14583333333333
25381, 1.4291666666667, 0, 0.16666666666667
25382, 1.4916666666667, 0, 0.14583333333333
25383, 1.4708333333333, 0, 0.16666666666667
25384, 1.5333333333333, 0, 0.14583333333333
25385, 1.5125, 0, 0.16666666666667
25386, 1.575, 0, 0.14583333333333
25387, 1.5541666666667, 0, 0.16666666666667
25388, 1.6166666666667, 0, 0.14583333333333
25389, 1.5958333333333, 0, 0.16666666666667
25390, 1.6583333333333, 0, 0.14583333333333
25391, 1.6375, 0, 0.16666666666667
25392, 1.7, 0, 0.14583333333333
25393, 1.6791666666667, 0, 0.16666666666667
25394, 1.7416666666667, 0, 0.14583333333333
25395, 1.7208333333333, 0, 0.16666666666667
25396, 1.7833333333333, 0, 0.14583333333333
25397, 1.7625, 0, 0.16666666666667
25398, 1.825, 0, 0.14583333333333
25399, 1.8041666666667, 0, 0.16666666666667
25400, 1.8666666666667, 0, 0.14583333333333
25401, 1.8458333333333, 0, 0.16666666666667
25402, 1.9083333333333, 0, 0.14583333333333
25403, 1.8875, 0, 0.16666666666667
25404, 1.95, 0, 0.14583333333333
25405, 1.9291666666667, 0, 0.16666666666667
25406, 1.9916666666667, 0, 0.14583333333333
25407, 1.9708333333333, 0, 0.16666666666667
25408, 2.0333333333333, 0, 0.14583333333333
25409, 2.0125, 0, 0.16666666666667
25410, 2.075, 0, 0.14583333333333
25411, 2.0541666666667, 0, 0.16666666666667
25412, 2.1166666666667, 0, 0.14583333333333
25413, 2.0958333333333, 0, 0.16666666666667
25414, 2.1583333333333, 0, 0.14583333333333
25415, 2.1375, 0, 0.16666666666667
25416, 2.1791666666667, 0, 0.16666666666667
25417, 1.2416666666667, 0, 0.1875
25418, 1.2208333333333, 0, 0.20833333333333
25419, 1.2833333333333, 0, 0.1875
25420, 1.2625, 0, 0.20833333333333
25421, 1.325, 0, 0.1875
25422, 1.3041666666667, 0, 0.20833333333333
25423, 1.3666666666667, 0, 0.1875
25424, 1.3458333333333, 0, 0.20833333333333
25425, 1.4083333333333, 0, 0.1875
25426, 1.3875, 0, 0.20833333333333
25427, 1.45, 0, 0.1875
25428, 1.4291666666667, 0, 0.20833333333333
25429, 1.4916666666667, 0, 0.1875
25430, 1.4708333333333, 0, 0.20833333333333
25431, 1.5333333333333, 0, 0.1875
25432, 1.5125, 0, 0.20833333333333
25433, 1.575, 0, 0.1875
25434, 1.5541666666667, 0, 0.20833333333333
25435, 1.6166666666667, 0, 0.1875
25436, 1.5958333333333, 0, 0.20833333333333
25437, 1.6583333333333, 0, 0.1875
25438, 1.6375, 0, 0.20833333333333
25439, 1.7, 0, 0.1875
25440, 1.6791666666667, 0, 0.20833333333333
25441, 1.7416666666667, 0, 0.1875
25442, 1.7208333333333, 0, 0.20833333333333
25443, 1.7833333333333, 0, 0.1875
25444, 1.7625, 0, 0.20833333333333
25445, 1.825, 0, 0.1875
25446, 1.8041666666667, 0, 0.20833333333333
25447, 1.8666666666667, 0, 0.1875
25448, 1.8458333333333, 0, 0.20833333333333
25449, 1.9083333333333, 0, 0.1875
25450, 1.8875, 0, 0.20833333333333
25451, 1.95, 0, 0.1875
25452, 1.9291666666667, 0, 0.20833333333333
25453, 1.9916666666667, 0, 0.1875
25454, 1.9708333333333, 0, 0.20833333333333
25455, 2.0333333333333, 0, 0.1875
25456, 2.0125, 0, 0.20833333333333
25457, 2.075, 0, 0.1875
25458, 2.0541666666667, 0, 0.20833333333333
25459, 2.1166666666667, 0, 0.1875
25460, 2.0958333333333, 0, 0.20833333333333
25461, 2.1583333333333, 0, 0.1875
25462, 2.1375, 0, 0.20833333333333
25463, 2.1791666666667, 0, 0.20833333333333
25464, 1.2416666666667, 0, 0.22916666666667
25465, 1.2208333333333, 0, 0.25
25466, 1.2833333333333, 0, 0.22916666666667
25467, 1.2625, 0, 0.25
25468, 1.325, 0, 0.22916666666667
25469, 1.3041666666667, 0, 0.25
25470, 1.3666666666667, 0, 0.22916666666667
25471, 1.3458333333333, 0, 0.25
25472, 1.4083333333333, 0, 0.22916666666667
25473, 1.3875, 0, 0.25
25474, 1.45, 0, 0.22916666666667
25475, 1.4291666666667, 0, 0.25
25476, 1.4916666666667, 0, 0.22916666666667
25477, 1.4708333333333, 0, 0.25
25478, 1.5333333333333, 0, 0.22916666666667
25479, 1.5125, 0, 0.25
25480, 1.575, 0, 0.22916666666667
25481, 1.5541666666667, 0, 0.25
25482, 1.6166666666667, 0, 0.22916666666667
25483, 1.5958333333333, 0, 0.25
25484, 1.6583333333333, 0, 0.22916666666667
25485, 1.6375, 0, 0.25
25486, 1.7, 0, 0.22916666666667
25487, 1.6791666666667, 0, 0.25
25488, 1.7416666666667, 0, 0.22916666666667
25489, 1.7208333333333, 0, 0.25
25490, 1.7833333333333, 0, 0.22916666666667
25491, 1.7625, 0, 0.25
25492, 1.825, 0, 0.22916666666667
25493, 1.8041666666667, 0, 0.25
25494, 1.8666666666667, 0, 0.22916666666667
25495, 1.8458333333333, 0, 0.25
25496, 1.9083333333333, 0, 0.22916666666667
25497, 1.8875, 0, 0.25
25498, 1.95, 0, 0.22916666666667
25499, 1.9291666666667, 0, 0.25
25500, 1.9916666666667, 0, 0.22916666666667
25501, 1.9708333333333, 0, 0.25
25502, 2.0333333333333, 0, 0.22916666666667
25503, 2.0125, 0, 0.25
25504, 2.075, 0, 0.22916666666667
25505, 2.0541666666667, 0, 0.25
25506, 2.1166666666667, 0, 0.22916666666667
25507, 2.0958333333333, 0, 0.25
25508, 2.1583333333333, 0, 0.22916666666667
25509, 2.1375, 0, 0.25
25510, 2.1791666666667, 0, 0.25
25511, 1.2416666666667, 0, 0.27083333333333
25512, 1.2208333333333, 0, 0.29166666666667
25513, 1.2833333333333, 0, 0.27083333333333
25514, 1.2625, 0, 0.29166666666667
25515, 1.325, 0, 0.27083333333333
25516, 1.3041666666667, 0, 0.29166666666667
25517, 1.3666666666667, 0, 0.27083333333333
25518, 1.3458333333333, 0, 0.29166666666667
25519, 1.4083333333333, 0, 0.27083333333333
25520, 1.3875, 0, 0.29166666666667
25521, 1.45, 0, 0.27083333333333
25522, 1.4291666666667, 0, 0.29166666666667
25523, 1.4916666666667, 0, 0.27083333333333
25524, 1.4708333333333, 0, 0.29166666666667
25525, 1.5333333333333, 0, 0.27083333333333
25526, 1.5125, 0, 0.29166666666667
25527, 1.575, 0, 0.27083333333333
25528, 1.5541666666667, 0, 0.29166666666667
25529, 1.6166666666667, 0, 0.27083333333333
25530, 1.5958333333333, 0, 0.29166666666667
25531, 1.6583333333333, 0, 0.27083333333333
25532, 1.6375, 0, 0.29166666666667
25533, 1.7, 0, 0.27083333333333
25534, 1.6791666666667, 0, 0.29166666666667
25535, 1.7416666666667, 0, 0.27083333333333
25536, 1.7208333333333, 0, 0.29166666666667
25537, 1.7833333333333, 0, 0.27083333333333
25538, 1.7625, 0, 0.29166666666667
25539, 1.825, 0, 0.27083333333333
25540, 1.8041666666667, 0, 0.29166666666667
25541, 1.8666666666667, 0, 0.27083333333333
25542, 1.8458333333333, 0, 0.29166666666667
25543, 1.9083333333333, 0, 0.27083333333333
25544, 1.8875, 0, 0.29166666666667
25545, 1.95, 0, 0.27083333333333
25546, 1.9291666666667, 0, 0.29166666666667
25547, 1.9916666666667, 0, 0.27083333333333
25548, 1.9708333333333, 0, 0.29166666666667
25549, 2.0333333333333, 0, 0.27083333333333
25550, 2.0125, 0, 0.29166666666667
25551, 2.075, 0, 0.27083333333333
25552, 2.0541666666667, 0, 0.29166666666667
25553, 2.1166666666667, 0, 0.27083333333333
25554, 2.0958333333333, 0, 0.29166666666667
25555, 2.1583333333333, 0, 0.27083333333333
25556, 2.1375, 0, 0.29166666666667
25557, 2.1791666666667, 0, 0.29166666666667
25558, 1.2416666666667, 0, 0.3125
25559, 1.2208333333333, 0, 0.33333333333333
25560, 1.2833333333333, 0, 0.3125
25561, 1.2625, 0, 0.33333333333333
25562, 1.325, 0, 0.3125
25563, 1.3041666666667, 0, 0.33333333333333
25564, 1.3666666666667, 0, 0.3125
25565, 1.3458333333333, 0, 0.33333333333333
25566, 1.4083333333333, 0, 0.3125
25567, 1.3875, 0, 0.33333333333333
25568, 1.45, 0, 0.3125
25569, 1.4291666666667, 0, 0.33333333333333
25570, 1.4916666666667, 0, 0.3125
25571, 1.4708333333333, 0, 0.33333333333333
25572, 1.5333333333333, 0, 0.3125
25573, 1.5125, 0, 0.33333333333333
25574, 1.575, 0, 0.3125
25575, 1.5541666666667, 0, 0.33333333333333
25576, 1.6166666666667, 0, 0.3125
25577, 1.5958333333333, 0, 0.33333333333333
25578, 1.6583333333333, 0, 0.3125
25579, 1.6375, 0, 0.33333333333333
25580, 1.7, 0, 0.3125
25581, 1.6791666666667, 0, 0.33333333333333
25582, 1.7416666666667, 0, 0.3125
25583, 1.7208333333333, 0, 0.33333333333333
25584, 1.7833333333333, 0, 0.3125
25585, 1.7625, 0, 0.33333333333333
25586, 1.825, 0, 0.3125
25587, 1.8041666666667, 0, 0.33333333333333
25588, 1.8666666666667, 0, 0.3125
25589, 1.8458333333333, 0, 0.33333333333333
25590, 1.9083333333333, 0, 0.3125
25591, 1.8875, 0, 0.33333333333333
25592, 1.95, 0, 0.3125
25593, 1.9291666666667, 0, 0.33333333333333
25594, 1.9916666666667, 0, 0.3125
25595, 1.9708333333333, 0, 0.33333333333333
25596, 2.0333333333333, 0, 0.3125
25597, 2.0125, 0, 0.33333333333333
25598, 2.075, 0, 0.3125
25599, 2.0541666666667, 0, 0.33333333333333
25600, 2.1166666666667, 0, 0.3125
25601, 2.0958333333333, 0, 0.33333333333333
25602, 2.1583333333333, 0, 0.3125
25603, 2.1375, 0, 0.33333333333333
25604, 2.1791666666667, 0, 0.33333333333333
25605, 1.2416666666667, 0, 0.35416666666667
25606, 1.2208333333333, 0, 0.375
25607, 1.2833333333333, 0, 0.35416666666667
25608, 1.2625, 0, 0.375
25609, 1.325, 0, 0.35416666666667
25610, 1.3041666666667, 0, 0.375
25611, 1.3666666666667, 0, 0.35416666666667
25612, 1.3458333333333, 0, 0.375
25613, 1.4083333333333, 0, 0.35416666666667
25614, 1.3875, 0, 0.375
25615, 1.45, 0, 0.35416666666667
25616, 1.4291666666667, 0, 0.375
25617, 1.4916666666667, 0, 0.35416666666667
25618, 1.4708333333333, 0, 0.375
25619, 1.5333333333333, 0, 0.35416666666667
25620, 1.5125, 0, 0.375
25621, 1.575, 0, 0.35416666666667
25622, 1.5541666666667, 0, 0.375
25623, 1.6166666666667, 0, 0.35416666666667
25624, 1.5958333333333, 0, 0.375
25625, 1.6583333333333, 0, 0.35416666666667
25626, 1.6375, 0, 0.375
25627, 1.7, 0, 0.35416666666667
25628, 1.6791666666667, 0, 0.375
25629, 1.7416666666667, 0, 0.35416666666667
25630, 1.7208333333333, 0, 0.375
25631, 1.7833333333333, 0, 0.35416666666667
25632, 1.7625, 0, 0.375
25633, 1.825, 0, 0.35416666666667
25634, 1.8041666666667, 0, 0.375
25635, 1.8666666666667, 0, 0.35416666666667
25636, 1.8458333333333, 0, 0.375
25637, 1.9083333333333, 0, 0.35416666666667
25638, 1.8875, 0, 0.375
25639, 1.95, 0, 0.35416666666667
25640, 1.9291666666667, 0, 0.375
25641, 1.9916666666667, 0, 0.35416666666667
25642, 1.9708333333333, 0, 0.375
25643, 2.0333333333333, 0, 0.35416666666667
25644, 2.0125, 0, 0.375
25645, 2.075, 0, 0.35416666666667
25646, 2.0541666666667, 0, 0.375
25647, 2.1166666666667, 0, 0.35416666666667
25648, 2.0958333333333, 0, 0.375
25649, 2.1583333333333, 0, 0.35416666666667
25650, 2.1375, 0, 0.375
25651, 2.1791666666667, 0, 0.375
25652, 1.2416666666667, 0, 0.39583333333333
25653, 1.2208333333333, 0, 0.41666666666667
25654, 1.2833333333333, 0, 0.39583333333333
25655, 1.2625, 0, 0.41666666666667
25656, 1.325, 0, 0.39583333333333
25657, 1.3041666666667, 0, 0.41666666666667
25658, 1.3666666666667, 0, 0.39583333333333
25659, 1.3458333333333, 0, 0.41666666666667
25660, 1.4083333333333, 0, 0.39583333333333
25661, 1.3875, 0, 0.41666666666667
25662, 1.45, 0, 0.39583333333333
25663, 1.4291666666667, 0, 0.41666666666667
25664, 1.4916666666667, 0, 0.39583333333333
25665, 1.4708333333333, 0, 0.41666666666667
25666, 1.5333333333333, 0, 0.39583333333333
25667, 1.5125, 0, 0.41666666666667
25668, 1.575, 0, 0.39583333333333
25669, 1.5541666666667, 0, 0.41666666666667
25670, 1.6166666666667, 0, 0.39583333333333
25671, 1.5958333333333, 0, 0.41666666666667
25672, 1.6583333333333, 0, 0.39583333333333
25673, 1.6375, 0, 0.41666666666667
25674, 1.7, 0, 0.39583333333333
25675, 1.6791666666667, 0, 0.41666666666667
25676, 1.7416666666667, 0, 0.39583333333333
25677, 1.7208333333333, 0, 0.41666666666667
25678, 1.7833333333333, 0, 0.39583333333333
25679, 1.7625, 0, 0.41666666666667
25680, 1.825, 0, 0.39583333333333
25681, 1.8041666666667, 0, 0.41666666666667
25682, 1.8666666666667, 0, 0.39583333333333
25683, 1.8458333333333, 0, 0.41666666666667
25684, 1.9083333333333, 0, 0.39583333333333
25685, 1.8875, 0, 0.41666666666667
25686, 1.95, 0, 0.39583333333333
25687, 1.9291666666667, 0, 0.41666666666667
25688, 1.9916666666667, 0, 0.39583333333333
25689, 1.9708333333333, 0, 0.41666666666667
25690, 2.0333333333333, 0, 0.39583333333333
25691, 2.0125, 0, 0.41666666666667
25692, 2.075, 0, 0.39583333333333
25693, 2.0541666666667, 0, 0.41666666666667
25694, 2.1166666666667, 0, 0.39583333333333
25695, 2.0958333333333, 0, 0.41666666666667
25696, 2.1583333333333, 0, 0.39583333333333
25697, 2.1375, 0, 0.41666666666667
25698, 2.1791666666667, 0, 0.41666666666667
25699, 1.2416666666667, 0, 0.4375
25700, 1.2208333333333, 0, 0.45833333333333
25701, 1.2833333333333, 0, 0.4375
25702, 1.2625, 0, 0.45833333333333
25703, 1.325, 0, 0.4375
25704, 1.3041666666667, 0, 0.45833333333333
25705, 1.3666666666667, 0, 0.4375
25706, 1.3458333333333, 0, 0.45833333333333
25707, 1.4083333333333, 0, 0.4375
25708, 1.3875, 0, 0.45833333333333
25709, 1.45, 0, 0.4375
25710, 1.4291666666667, 0, 0.45833333333333
25711, 1.4916666666667, 0, 0.4375
25712, 1.4708333333333, 0, 0.45833333333333
25713, 1.5333333333333, 0, 0.4375
25714, 1.5125, 0, 0.45833333333333
25715, 1.575, 0, 0.4375
25716, 1.5541666666667, 0, 0.45833333333333
25717, 1.6166666666667, 0, 0.4375
25718, 1.5958333333333, 0, 0.45833333333333
25719, 1.6583333333333, 0, 0.4375
25720, 1.6375, 0, 0.45833333333333
25721, 1.7, 0, 0.4375
25722, 1.6791666666667, 0, 0.45833333333333
25723, 1.7416666666667, 0, 0.4375
25724, 1.7208333333333, 0, 0.45833333333333
25725, 1.7833333333333, 0, 0.4375
25726, 1.7625, 0, 0.45833333333333
25727, 1.825, 0, 0.4375
25728, 1.8041666666667, 0, 0.45833333333333
25729, 1.8666666666667, 0, 0.4375
25730, 1.8458333333333, 0, 0.45833333333333
25731, 1.9083333333333, 0, 0.4375
25732, 1.8875, 0, 0.45833333333333
25733, 1.95, 0, 0.4375
25734, 1.9291666666667, 0, 0.45833333333333
25735, 1.9916666666667, 0, 0.4375
25736, 1.9708333333333, 0, 0.45833333333333
25737, 2.0333333333333, 0, 0.4375
25738, 2.0125, 0, 0.45833333333333
25739, 2.075, 0, 0.4375
25740, 2.0541666666667, 0, 0.45833333333333
25741, 2.1166666666667, 0, 0.4375
25742, 2.0958333333333, 0, 0.45833333333333
25743, 2.1583333333333, 0, 0.4375
25744, 2.1375, 0, 0.45833333333333
25745, 2.1791666666667, 0, 0.45833333333333
25746, 1.2416666666667, 0, 0.47916666666667
25747, 1.2833333333333, 0, 0.47916666666667
25748, 1.325, 0, 0.47916666666667
25749, 1.3666666666667, 0, 0.47916666666667
25750, 1.4083333333333, 0, 0.47916666666667
25751, 1.45, 0, 0.47916666666667
25752, 1.4916666666667, 0, 0.47916666666667
25753, 1.5333333333333, 0, 0.47916666666667
25754, 1.575, 0, 0.47916666666667
25755, 1.6166666666667, 0, 0.47916666666667
25756, 1.6583333333333, 0, 0.47916666666667
25757, 1.7, 0, 0.47916666666667
25758, 1.7416666666667, 0, 0.47916666666667
25759, 1.7833333333333, 0, 0.47916666666667
25760, 1.825, 0, 0.47916666666667
25761, 1.8666666666667, 0, 0.47916666666667
25762, 1.9083333333333, 0, 0.47916666666667
25763, 1.95, 0, 0.47916666666667
25764, 1.9916666666667, 0, 0.47916666666667
25765, 2.0333333333333, 0, 0.47916666666667
25766, 2.075, 0, 0.47916666666667
25767, 2.1166666666667, 0, 0.47916666666667
25768, 2.1583333333333, 0, 0.47916666666667
25769, 2.25, 0.066666666666667, 0.5
25770, 2.25, 0.033333333333333, 0.5
25771, 2.25, 0.066666666666667, 0
25772, 2.25, 0.033333333333333, 0
25773, 2.25, 0.1, 0.041666666666667
25774, 2.25, 0.1, 0.083333333333333
25775, 2.25, 0.1, 0.125
25776, 2.25, 0.1, 0.16666666666667
25777, 2.25, 0.1, 0.20833333333333
25778, 2.25, 0.1, 0.25
25779, 2.25, 0.1, 0.29166666666667
25780, 2.25, 0.1, 0.33333333333333
25781, 2.25, 0.1, 0.375
25782, 2.25, 0.1, 0.41666666666667
25783, 2.25, 0.1, 0.45833333333333
25784, 2.25, -1.2490009027033e-16, 0.041666666666667
25785, 2.25, -1.2490009027033e-16, 0.083333333333333
25786, 2.25, -1.2490009027033e-16, 0.125
25787, 2.25, -1.2490009027033e-16, 0.16666666666667
25788, 2.25, -1.2490009027033e-16, 0.20833333333333
25789, 2.25, -1.2490009027033e-16, 0.25
25790, 2.25, -1.2490009027033e-16, 0.29166666666667
25791, 2.25, -1.2490009027033e-16, 0.33333333333333
25792, 2.25, -1.2490009027033e-16, 0.375
25793, 2.25, -1.2490009027033e-16, 0.41666666666667
25794, 2.25, -1.2490009027033e-16, 0.45833333333333
25795, 2.3, 0.066666666666667, 0.041666666666667
25796, 2.3, 0.033333333333333, 0.041666666666667
25797, 2.3, 0.066666666666667, 0.083333333333333
25798, 2.3, 0.033333333333333, 0.083333333333333
25799, 2.3, 0.066666666666667, 0.125
25800, 2.3, 0.033333333333333, 0.125
25801, 2.3, 0.066666666666667, 0.16666666666667
25802, 2.3, 0.033333333333333, 0.16666666666667
25803, 2.3, 0.066666666666667, 0.20833333333333
25804, 2.3, 0.033333333333333, 0.20833333333333
25805, 2.3, 0.066666666666667, 0.25
25806, 2.3, 0.033333333333333, 0.25
25807, 2.3, 0.066666666666667, 0.29166666666667
25808, 2.3, 0.033333333333333, 0.29166666666667
25809, 2.3, 0.066666666666667, 0.33333333333333
25810, 2.3, 0.033333333333333, 0.33333333333333
25811, 2.3, 0.066666666666667, 0.375
25812, 2.3, 0.033333333333333, 0.375
25813, 2.3, 0.066666666666667, 0.41666666666667
25814, 2.3, 0.033333333333333, 0.41666666666667
25815, 2.3, 0.066666666666667, 0.45833333333333
25816, 2.3, 0.033333333333333, 0.45833333333333
25817, 2.3, 0.083333333333333, 0.041666666666667
25818, 2.3, 0.066666666666667, 0.020833333333333
25819, 2.3, 0.05, 0.041666666666667
25820, 2.3, 0.033333333333333, 0.020833333333333
25821, 2.3, 0.016666666666667, 0.041666666666667
25822, 2.3, 0.083333333333333, 0.083333333333333
25823, 2.3, 0.066666666666667, 0.0625
25824, 2.3, 0.05, 0.083333333333333
25825, 2.3, 0.033333333333333, 0.0625
25826, 2.3, 0.016666666666667, 0.083333333333333
25827, 2.3, 0.083333333333333, 0.125
25828, 2.3, 0.066666666666667, 0.10416666666667
25829, 2.3, 0.05, 0.125
25830, 2.3, 0.033333333333333, 0.10416666666667
25831, 2.3, 0.016666666666667, 0.125
25832, 2.3, 0.083333333333333, 0.16666666666667
25833, 2.3, 0.066666666666667, 0.14583333333333
25834, 2.3, 0.05, 0.16666666666667
25835, 2.3, 0.033333333333333, 0.14583333333333
25836, 2.3, 0.016666666666667, 0.16666666666667
25837, 2.3, 0.083333333333333, 0.20833333333333
25838, 2.3, 0.066666666666667, 0.1875
25839, 2.3, 0.05, 0.20833333333333
25840, 2.3, 0.033333333333333, 0.1875
25841, 2.3, 0.016666666666667, 0.20833333333333
25842, 2.3, 0.083333333333333, 0.25
25843, 2.3, 0.066666666666667, 0.22916666666667
25844, 2.3, 0.05, 0.25
25845, 2.3, 0.033333333333333, 0.22916666666667
25846, 2.3, 0.016666666666667, 0.25
25847, 2.3, 0.083333333333333, 0.29166666666667
25848, 2.3, 0.066666666666667, 0.27083333333333
25849, 2.3, 0.05, 0.29166666666667
25850, 2.3, 0.033333333333333, 0.27083333333333
25851, 2.3, 0.016666666666667, 0.29166666666667
25852, 2.3, 0.083333333333333, 0.33333333333333
25853, 2.3, 0.066666666666667, 0.3125
25854, 2.3, 0.05, 0.33333333333333
25855, 2.3, 0.033333333333333, 0.3125
25856, 2.3, 0.016666666666667, 0.33333333333333
25857, 2.3, 0.083333333333333, 0.375
25858, 2.3, 0.066666666666667, 0.35416666666667
25859, 2.3, 0.05, 0.375
25860, 2.3, 0.033333333333333, 0.35416666666667
25861, 2.3, 0.016666666666667, 0.375
25862, 2.3, 0.083333333333333, 0.41666666666667
25863, 2.3, 0.066666666666667, 0.39583333333333
25864, 2.3, 0.05, 0.41666666666667
25865, 2.3, 0.033333333333333, 0.39583333333333
25866, 2.3, 0.016666666666667, 0.41666666666667
25867, 2.3, 0.083333333333333, 0.45833333333333
25868, 2.3, 0.066666666666667, 0.4375
25869, 2.3, 0.05, 0.45833333333333
25870, 2.3, 0.033333333333333, 0.4375
25871, 2.3, 0.016666666666667, 0.45833333333333
25872, 2.3, 0.066666666666667, 0.47916666666667
25873, 2.3, 0.033333333333333, 0.47916666666667
25874, -0.05, 0, 0.041666666666667
25875, -0.05, 0, 0.083333333333333
25876, -0.05, 0, 0.125
25877, -0.05, 0, 0.16666666666667
25878, -0.05, 0, 0.20833333333333
25879, -0.05, 0, 0.25
25880, -0.05, 0, 0.29166666666667
25881, -0.05, 0, 0.33333333333333
25882, -0.05, 0, 0.375
25883, -0.05, 0, 0.41666666666667
25884, -0.05, 0, 0.45833333333333
25885, -0.05, 0.033333333333333, 0.5
25886, -0.05, 0.066666666666667, 0.5
25887, -0.05, 0.1, 0.041666666666667
25888, -0.05, 0.1, 0.083333333333333
25889, -0.05, 0.1, 0.125
25890, -0.05, 0.1, 0.16666666666667
25891, -0.05, 0.1, 0.20833333333333
25892, -0.05, 0.1, 0.25
25893, -0.05, 0.1, 0.29166666666667
25894, -0.05, 0.1, 0.33333333333333
25895, -0.05, 0.1, 0.375
25896, -0.05, 0.1, 0.41666666666667
25897, -0.05, 0.1, 0.45833333333333
25898, -0.05, 0.033333333333333, 0
25899, -0.05, 0.066666666666667, 0
25900, -0.1, 0.033333333333333, 0.041666666666667
25901, -0.1, 0.066666666666667, 0.041666666666667
25902, -0.1, 0.033333333333333, 0.083333333333333
25903, -0.1, 0.066666666666667, 0.083333333333333
25904, -0.1, 0.033333333333333, 0.125
25905, -0.1, 0.066666666666667, 0.125
25906, -0.1, 0.033333333333333, 0.16666666666667
25907, -0.1, 0.066666666666667, 0.16666666666667
25908, -0.1, 0.033333333333333, 0.20833333333333
25909, -0.1, 0.066666666666667, 0.20833333333333
25910, -0.1, 0.033333333333333, 0.25
25911, -0.1, 0.066666666666667, 0.25
25912, -0.1, 0.033333333333333, 0.29166666666667
25913, -0.1, 0.066666666666667, 0.29166666666667
25914, -0.1, 0.033333333333333, 0.33333333333333
25915, -0.1, 0.066666666666667, 0.33333333333333
25916, -0.1, 0.033333333333333, 0.375
25917, -0.1, 0.066666666666667, 0.375
25918, -0.1, 0.033333333333333, 0.41666666666667
25919, -0.1, 0.066666666666667, 0.41666666666667
25920, -0.1, 0.033333333333333, 0.45833333333333
25921, -0.1, 0.066666666666667, 0.45833333333333
25922, -0.1, 0.016666666666667, 0.041666666666667
25923, -0.1, 0.033333333333333, 0.020833333333333
25924, -0.1, 0.05, 0.041666666666667
25925, -0.1, 0.066666666666667, 0.020833333333333
25926, -0.1, 0.083333333333333, 0.041666666666667
25927, -0.1, 0.016666666666667, 0.083333333333333
25928, -0.1, 0.033333333333333, 0.0625
25929, -0.1, 0.05, 0.083333333333333
25930, -0.1, 0.066666666666667, 0.0625
25931, -0.1, 0.083333333333333, 0.083333333333333
25932, -0.1, 0.016666666666667, 0.125
25933, -0.1, 0.033333333333333, 0.10416666666667
25934, -0.1, 0.05, 0.125
25935, -0.1, 0.066666666666667, 0.10416666666667
25936, -0.1, 0.083333333333333, 0.125
25937, -0.1, 0.016666666666667, 0.16666666666667
25938, -0.1, 0.033333333333333, 0.14583333333333
25939, -0.1, 0.05, 0.16666666666667
25940, -0.1, 0.066666666666667, 0.14583333333333
25941, -0.1, 0.083333333333333, 0.16666666666667
25942, -0.1, 0.016666666666667, 0.20833333333333
25943, -0.1, 0.033333333333333, 0.1875
25944, -0.1, 0.05, 0.20833333333333
25945, -0.1, 0.066666666666667, 0.1875
25946, -0.1, 0.083333333333333, 0.20833333333333
25947, -0.1, 0.016666666666667, 0.25
25948, -0.1, 0.033333333333333, 0.22916666666667
25949, -0.1, 0.05, 0.25
25950, -0.1, 0.066666666666667, 0.22916666666667
25951, -0.1, 0.083333333333333, 0.25
25952, -0.1, 0.016666666666667, 0.29166666666667
25953, -0.1, 0.033333333333333, 0.27083333333333
25954, -0.1, 0.05, 0.29166666666667
25955, -0.1, 0.066666666666667, 0.27083333333333
25956, -0.1, 0.083333333333333, 0.29166666666667
25957, -0.1, 0.016666666666667, 0.33333333333333
25958, -0.1, 0.033333333333333, 0.3125
25959, -0.1, 0.05, 0.33333333333333
25960, -0.1, 0.066666666666667, 0.3125
25961, -0.1, 0.083333333333333, 0.33333333333333
25962, -0.1, 0.016666666666667, 0.375
25963, -0.1, 0.033333333333333, 0.35416666666667
25964, -0.1, 0.05, 0.375
25965, -0.1, 0.066666666666667, 0.35416666666667
25966, -0.1, 0.083333333333333, 0.375
25967, -0.1, 0.016666666666667, 0.41666666666667
25968, -0.1, 0.033333333333333, 0.39583333333333
25969, -0.1, 0.05, 0.41666666666667
25970, -0.1, 0.066666666666667, 0.39583333333333
25971, -0.1, 0.083333333333333, 0.41666666666667
25972, -0.1, 0.016666666666667, 0.45833333333333
25973, -0.1, 0.033333333333333, 0.4375
25974, -0.1, 0.05, 0.45833333333333
25975, -0.1, 0.066666666666667, 0.4375
25976, -0.1, 0.083333333333333, 0.45833333333333
25977, -0.1, 0.033333333333333, 0.47916666666667
25978, -0.1, 0.066666666666667, 0.47916666666667
25979, 1.025, 0.2, 0.5
25980, 1.025, 0.25, 0.5
25981, 1.025, 0.3, 0.5
25982, 1.025, 0.35, 0.5
25983, 1.025, 0.4, 0.5
25984, 1.025, 0.45, 0.5
25985, 1.025, 0.5, 0.5
25986, 1.025, 0.55, 0.5
25987, 1.025, 0.6, 0.5
25988, 1.025, 0.65, 0.5
25989, 1.025, 0.7, 0.5
25990, 1.025, 0.75, 0.5
25991, 1.025, 0.8, 0.5
25992, 1.025, 0.85, 0.5
25993, 1.025, 0.9, 0.5
25994, 1.025, 0.95, 0.5
25995, 1.025, 1, 0.5
25996, 1.025, 1.05, 0.5
25997, 1.025, 1.1, 0.5
25998, 1.025, 1.15, 0.5
25999, 1.025, 1.2, 0.5
26000, 1.025, 1.25, 0.5
26001, 1.025, 1.3, 0.5
26002, 1.025, 0.2, 0
26003, 1.025, 0.25, 0
26004, 1.025, 0.3, 0
26005, 1.025, 0.35, 0
26006, 1.025, 0.4, 0
26007, 1.025, 0.45, 0
26008, 1.025, 0.5, 0
26009, 1.025, 0.55, 0
26010, 1.025, 0.6, 0
26011, 1.025, 0.65, 0
26012, 1.025, 0.7, 0
26013, 1.025, 0.75, 0
26014, 1.025, 0.8, 0
26015, 1.025, 0.85, 0
26016, 1.025, 0.9, 0
26017, 1.025, 0.95, 0
26018, 1.025, 1, 0
26019, 1.025, 1.05, 0
26020, 1.025, 1.1, 0
26021, 1.025, 1.15, 0
26022, 1.025, 1.2, 0
26023, 1.025, 1.25, 0
26024, 1.025, 1.3, 0
26025, 1.025, 0.15, 0.041666666666667
26026, 1.025, 0.15, 0.083333333333333
26027, 1.025, 0.15, 0.125
26028, 1.025, 0.15, 0.16666666666667
26029, 1.025, 0.15, 0.20833333333333
26030, 1.025, 0.15, 0.25
26031, 1.025, 0.15, 0.29166666666667
26032, 1.025, 0.15, 0.33333333333333
26033, 1.025, 0.15, 0.375
26034, 1.025, 0.15, 0.41666666666667
26035, 1.025, 0.15, 0.45833333333333
26036, 1.025, 1.35, 0.041666666666667
26037, 1.025, 1.35, 0.083333333333333
26038, 1.025, 1.35, 0.125
26039, 1.025, 1.35, 0.16666666666667
26040, 1.025, 1.35, 0.20833333333333
26041, 1.025, 1.35, 0.25
26042, 1.025, 1.35, 0.29166666666667
26043, 1.025, 1.35, 0.33333333333333
26044, 1.025, 1.35, 0.375
26045, 1.025, 1.35, 0.41666666666667
26046, 1.025, 1.35, 0.45833333333333
26047, 1.05, 0.2, 0.041666666666667
26048, 1.05, 0.25, 0.041666666666667
26049, 1.05, 0.3, 0.041666666666667
26050, 1.05, 0.35, 0.041666666666667
26051, 1.05, 0.4, 0.041666666666667
26052, 1.05, 0.45, 0.041666666666667
26053, 1.05, 0.5, 0.041666666666667
26054, 1.05, 0.55, 0.041666666666667
26055, 1.05, 0.6, 0.041666666666667
26056, 1.05, 0.65, 0.041666666666667
26057, 1.05, 0.7, 0.041666666666667
26058, 1.05, 0.75, 0.041666666666667
26059, 1.05, 0.8, 0.041666666666667
26060, 1.05, 0.85, 0.041666666666667
26061, 1.05, 0.9, 0.041666666666667
26062, 1.05, 0.95, 0.041666666666667
26063, 1.05, 1, 0.041666666666667
26064, 1.05, 1.05, 0.041666666666667
26065, 1.05, 1.1, 0.041666666666667
26066, 1.05, 1.15, 0.041666666666667
26067, 1.05, 1.2, 0.041666666666667
26068, 1.05, 1.25, 0.041666666666667
26069, 1.05, 1.3, 0.041666666666667
26070, 1.05, 0.2, 0.083333333333333
26071, 1.05, 0.25, 0.083333333333333
26072, 1.05, 0.3, 0.083333333333333
26073, 1.05, 0.35, 0.083333333333333
26074, 1.05, 0.4, 0.083333333333333
26075, 1.05, 0.45, 0.083333333333333
26076, 1.05, 0.5, 0.083333333333333
26077, 1.05, 0.55, 0.083333333333333
26078, 1.05, 0.6, 0.083333333333333
26079, 1.05, 0.65, 0.083333333333333
26080, 1.05, 0.7, 0.083333333333333
26081, 1.05, 0.75, 0.083333333333333
26082, 1.05, 0.8, 0.083333333333333
26083, 1.05, 0.85, 0.083333333333333
26084, 1.05, 0.9, 0.083333333333333
26085, 1.05, 0.95, 0.083333333333333
26086, 1.05, 1, 0.083333333333333
26087, 1.05, 1.05, 0.083333333333333
26088, 1.05, 1.1, 0.083333333333333
26089, 1.05, 1.15, 0.083333333333333
26090, 1.05, 1.2, 0.083333333333333
26091, 1.05, 1.25, 0.083333333333333
26092, 1.05, 1.3, 0.083333333333333
26093, 1.05, 0.2, 0.125
26094, 1.05, 0.25, 0.125
26095, 1.05, 0.3, 0.125
26096, 1.05, 0.35, 0.125
26097, 1.05, 0.4, 0.125
26098, 1.05, 0.45, 0.125
26099, 1.05, 0.5, 0.125
26100, 1.05, 0.55, 0.125
26101, 1.05, 0.6, 0.125
26102, 1.05, 0.65, 0.125
26103, 1.05, 0.7, 0.125
26104, 1.05, 0.75, 0.125
26105, 1.05, 0.8, 0.125
26106, 1.05, 0.85, 0.125
26107, 1.05, 0.9, 0.125
26108, 1.05, 0.95, 0.125
26109, 1.05, 1, 0.125
26110, 1.05, 1.05, 0.125
26111, 1.05, 1.1, 0.125
26112, 1.05, 1.15, 0.125
26113, 1.05, 1.2, 0.125
26114, 1.05, 1.25, 0.125
26115, 1.05, 1.3, 0.125
26116, 1.05, 0.2, 0.16666666666667
26117, 1.05, 0.25, 0.16666666666667
26118, 1.05, 0.3, 0.16666666666667
26119, 1.05, 0.35, 0.16666666666667
26120, 1.05, 0.4, 0.16666666666667
26121, 1.05, 0.45, 0.16666666666667
26122, 1.05, 0.5, 0.16666666666667
26123, 1.05, 0.55, 0.16666666666667
26124, 1.05, 0.6, 0.16666666666667
26125, 1.05, 0.65, 0.16666666666667
26126, 1.05, 0.7, 0.16666666666667
26127, 1.05, 0.75, 0.16666666666667
26128, 1.05, 0.8, 0.16666666666667
26129, 1.05, 0.85, 0.16666666666667
26130, 1.05, 0.9, 0.16666666666667
26131, 1.05, 0.95, 0.16666666666667
26132, 1.05, 1, 0.16666666666667
26133, 1.05, 1.05, 0.16666666666667
26134, 1.05, 1.1, 0.16666666666667
26135, 1.05, 1.15, 0.16666666666667
26136, 1.05, 1.2, 0.16666666666667
26137, 1.05, 1.25, 0.16666666666667
26138, 1.05, 1.3, 0.16666666666667
26139, 1.05, 0.2, 0.20833333333333
26140, 1.05, 0.25, 0.20833333333333
26141, 1.05, 0.3, 0.20833333333333
26142, 1.05, 0.35, 0.20833333333333
26143, 1.05, 0.4, 0.20833333333333
26144, 1.05, 0.45, 0.20833333333333
26145, 1.05, 0.5, 0.20833333333333
26146, 1.05, 0.55, 0.20833333333333
26147, 1.05, 0.6, 0.20833333333333
26148, 1.05, 0.65, 0.20833333333333
26149, 1.05, 0.7, 0.20833333333333
26150, 1.05, 0.75, 0.20833333333333
26151, 1.05, 0.8, 0.20833333333333
26152, 1.05, 0.85, 0.20833333333333
26153, 1.05, 0.9, 0.20833333333333
26154, 1.05, 0.95, 0.20833333333333
26155, 1.05, 1, 0.20833333333333
26156, 1.05, 1.05, 0.20833333333333
26157, 1.05, 1.1, 0.20833333333333
26158, 1.05, 1.15, 0.20833333333333
26159, 1.05, 1.2, 0.20833333333333
26160, 1.05, 1.25, 0.20833333333333
26161, 1.05, 1.3, 0.20833333333333
26162, 1.05, 0.2, 0.25
26163, 1.05, 0.25, 0.25
26164, 1.05, 0.3, 0.25
26165, 1.05, 0.35, 0.25
26166, 1.05, 0.4, 0.25
26167, 1.05, 0.45, 0.25
26168, 1.05, 0.5, 0.25
26169, 1.05, 0.55, 0.25
26170, 1.05, 0.6, 0.25
26171, 1.05, 0.65, 0.25
26172, 1.05, 0.7, 0.25
26173, 1.05, 0.75, 0.25
26174, 1.05, 0.8, 0.25
26175, 1.05, 0.85, 0.25
26176, 1.05, 0.9, 0.25
26177, 1.05, 0.95, 0.25
26178, 1.05, 1, 0.25
26179, 1.05, 1.05, 0.25
26180, 1.05, 1.1, 0.25
26181, 1.05, 1.15, 0.25
26182, 1.05, 1.2, 0.25
26183, 1.05, 1.25, 0.25
26184, 1.05, 1.3, 0.25
26185, 1.05, 0.2, 0.29166666666667
26186, 1.05, 0.25, 0.29166666666667
26187, 1.05, 0.3, 0.29166666666667
26188, 1.05, 0.35, 0.29166666666667
26189, 1.05, 0.4, 0.29166666666667
26190, 1.05, 0.45, 0.29166666666667
26191, 1.05, 0.5, 0.29166666666667
26192, 1.05, 0.55, 0.29166666666667
26193, 1.05, 0.6, 0.29166666666667
26194, 1.05, 0.65, 0.29166666666667
26195, 1.05, 0.7, 0.29166666666667
26196, 1.05, 0.75, 0.29166666666667
26197, 1.05, 0.8, 0.29166666666667
26198, 1.05, 0.85, 0.29166666666667
26199, 1.05, 0.9, 0.29166666666667
26200, 1.05, 0.95, 0.29166666666667
26201, 1.05, 1, 0.29166666666667
26202, 1.05, 1.05, 0.29166666666667
26203, 1.05, 1.1, 0.29166666666667
26204, 1.05, 1.15, 0.29166666666667
26205, 1.05, 1.2, 0.29166666666667
26206, 1.05, 1.25, 0.29166666666667
26207, 1.05, 1.3, 0.29166666666667
26208, 1.05, 0.2, 0.33333333333333
26209, 1.05, 0.25, 0.33333333333333
26210, 1.05, 0.3, 0.33333333333333
26211, 1.05, 0.35, 0.33333333333333
26212, 1.05, 0.4, 0.33333333333333
26213, 1.05, 0.45, 0.33333333333333
26214, 1.05, 0.5, 0.33333333333333
26215, 1.05, 0.55, 0.33333333333333
26216, 1.05, 0.6, 0.33333333333333
26217, 1.05, 0.65, 0.33333333333333
26218, 1.05, 0.7, 0.33333333333333
26219, 1.05, 0.75, 0.33333333333333
26220, 1.05, 0.8, 0.33333333333333
26221, 1.05, 0.85, 0.33333333333333
26222, 1.05, 0.9, 0.33333333333333
26223, 1.05, 0.95, 0.33333333333333
26224, 1.05, 1, 0.33333333333333
26225, 1.05, 1.05, 0.33333333333333
26226, 1.05, 1.1, 0.33333333333333
26227, 1.05, 1.15, 0.33333333333333
26228, 1.05, 1.2, 0.33333333333333
26229, 1.05, 1.25, 0.33333333333333
26230, 1.05, 1.3, 0.33333333333333
26231, 1.05, 0.2, 0.375
26232, 1.05, 0.25, 0.375
26233, 1.05, 0.3, 0.375
26234, 1.05, 0.35, 0.375
26235, 1.05, 0.4, 0.375
26236, 1.05, 0.45, 0.375
26237, 1.05, 0.5, 0.375
26238, 1.05, 0.55, 0.375
26239, 1.05, 0.6, 0.375
26240, 1.05, 0.65, 0.375
26241, 1.05, 0.7, 0.375
26242, 1.05, 0.75, 0.375
26243, 1.05, 0.8, 0.375
26244, 1.05, 0.85, 0.375
26245, 1.05, 0.9, 0.375
26246, 1.05, 0.95, 0.375
26247, 1.05, 1, 0.375
26248, 1.05, 1.05, 0.375
26249, 1.05, 1.1, 0.375
26250, 1.05, 1.15, 0.375
26251, 1.05, 1.2, 0.375
26252, 1.05, 1.25, 0.375
26253, 1.05, 1.3, 0.375
26254, 1.05, 0.2, 0.41666666666667
26255, 1.05, 0.25, 0.41666666666667
26256, 1.05, 0.3, 0.41666666666667
26257, 1.05, 0.35, 0.41666666666667
26258, 1.05, 0.4, 0.41666666666667
26259, 1.05, 0.45, 0.41666666666667
26260, 1.05, 0.5, 0.41666666666667
26261, 1.05, 0.55, 0.41666666666667
26262, 1.05, 0.6, 0.41666666666667
26263, 1.05, 0.65, 0.41666666666667
26264, 1.05, 0.7, 0.41666666666667
26265, 1.05, 0.75, 0.41666666666667
26266, 1.05, 0.8, 0.41666666666667
26267, 1.05, 0.85, 0.41666666666667
26268, 1.05, 0.9, 0.41666666666667
26269, 1.05, 0.95, 0.41666666666667
26270, 1.05, 1, 0.41666666666667
26271, 1.05, 1.05, 0.41666666666667
26272, 1.05, 1.1, 0.41666666666667
26273, 1.05, 1.15, 0.41666666666667
26274, 1.05, 1.2, 0.41666666666667
26275, 1.05, 1.25, 0.41666666666667
26276, 1.05, 1.3, 0.41666666666667
26277, 1.05, 0.2, 0.45833333333333
26278, 1.05, 0.25, 0.45833333333333
26279, 1.05, 0.3, 0.45833333333333
26280, 1.05, 0.35, 0.45833333333333
26281, 1.05, 0.4, 0.45833333333333
26282, 1.05, 0.45, 0.45833333333333
26283, 1.05, 0.5, 0.45833333333333
26284, 1.05, 0.55, 0.45833333333333
26285, 1.05, 0.6, 0.45833333333333
26286, 1.05, 0.65, 0.45833333333333
26287, 1.05, 0.7, 0.45833333333333
26288, 1.05, 0.75, 0.45833333333333
26289, 1.05, 0.8, 0.45833333333333
26290, 1.05, 0.85, 0.45833333333333
26291, 1.05, 0.9, 0.45833333333333
26292, 1.05, 0.95, 0.45833333333333
26293, 1.05, 1, 0.45833333333333
26294, 1.05, 1.05, 0.45833333333333
26295, 1.05, 1.1, 0.45833333333333
26296, 1.05, 1.15, 0.45833333333333
