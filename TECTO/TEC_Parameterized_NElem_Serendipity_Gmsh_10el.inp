27666, 72075, 72098, 72627, 72604, 72076, 72099, 72628, 72605, 79905, 81537, 81538, 81467, 79908, 81540, 81541, 
81470, 79836, 79906, 81539, 81469
27667, 72076, 72099, 72628, 72605, 72077, 72100, 72629, 72606, 79908, 81540, 81541, 81470, 79911, 81543, 81544, 
81473, 79839, 79909, 81542, 81472
27668, 72077, 72100, 72629, 72606, 72078, 72101, 72630, 72607, 79911, 81543, 81544, 81473, 79914, 81546, 81547, 
81476, 79842, 79912, 81545, 81475
27669, 72078, 72101, 72630, 72607, 72079, 72102, 72631, 72608, 79914, 81546, 81547, 81476, 79917, 81549, 81550, 
81479, 79845, 79915, 81548, 81478
27670, 72079, 72102, 72631, 72608, 22878, 22879, 22902, 22901, 79917, 81549, 81550, 81479, 23175, 23221, 23222, 
23219, 79848, 79918, 81551, 81481
27671, 17234, 17235, 17258, 17257, 72080, 72103, 72632, 72609, 17532, 17578, 17579, 17576, 79921, 81553, 81554, 
81483, 79849, 79919, 81552, 81482
27672, 72080, 72103, 72632, 72609, 72081, 72104, 72633, 72610, 79921, 81553, 81554, 81483, 79924, 81556, 81557, 
81486, 79852, 79922, 81555, 81485
27673, 72081, 72104, 72633, 72610, 72082, 72105, 72634, 72611, 79924, 81556, 81557, 81486, 79927, 81559, 81560, 
81489, 79855, 79925, 81558, 81488
27674, 72082, 72105, 72634, 72611, 72083, 72106, 72635, 72612, 79927, 81559, 81560, 81489, 79930, 81562, 81563, 
81492, 79858, 79928, 81561, 81491
27675, 72083, 72106, 72635, 72612, 72084, 72107, 72636, 72613, 79930, 81562, 81563, 81492, 79933, 81565, 81566, 
81495, 79861, 79931, 81564, 81494
27676, 72084, 72107, 72636, 72613, 72085, 72108, 72637, 72614, 79933, 81565, 81566, 81495, 79936, 81568, 81569, 
81498, 79864, 79934, 81567, 81497
27677, 72085, 72108, 72637, 72614, 72086, 72109, 72638, 72615, 79936, 81568, 81569, 81498, 79939, 81571, 81572, 
81501, 79867, 79937, 81570, 81500
27678, 72086, 72109, 72638, 72615, 72087, 72110, 72639, 72616, 79939, 81571, 81572, 81501, 79942, 81574, 81575, 
81504, 79870, 79940, 81573, 81503
27679, 72087, 72110, 72639, 72616, 72088, 72111, 72640, 72617, 79942, 81574, 81575, 81504, 79945, 81577, 81578, 
81507, 79873, 79943, 81576, 81506
27680, 72088, 72111, 72640, 72617, 72089, 72112, 72641, 72618, 79945, 81577, 81578, 81507, 79948, 81580, 81581, 
81510, 79876, 79946, 81579, 81509
27681, 72089, 72112, 72641, 72618, 72090, 72113, 72642, 72619, 79948, 81580, 81581, 81510, 79951, 81583, 81584, 
81513, 79879, 79949, 81582, 81512
27682, 72090, 72113, 72642, 72619, 72091, 72114, 72643, 72620, 79951, 81583, 81584, 81513, 79954, 81586, 81587, 
81516, 79882, 79952, 81585, 81515
27683, 72091, 72114, 72643, 72620, 72092, 72115, 72644, 72621, 79954, 81586, 81587, 81516, 79957, 81589, 81590, 
81519, 79885, 79955, 81588, 81518
27684, 72092, 72115, 72644, 72621, 72093, 72116, 72645, 72622, 79957, 81589, 81590, 81519, 79960, 81592, 81593, 
81522, 79888, 79958, 81591, 81521
27685, 72093, 72116, 72645, 72622, 72094, 72117, 72646, 72623, 79960, 81592, 81593, 81522, 79963, 81595, 81596, 
81525, 79891, 79961, 81594, 81524
27686, 72094, 72117, 72646, 72623, 72095, 72118, 72647, 72624, 79963, 81595, 81596, 81525, 79966, 81598, 81599, 
81528, 79894, 79964, 81597, 81527
27687, 72095, 72118, 72647, 72624, 72096, 72119, 72648, 72625, 79966, 81598, 81599, 81528, 79969, 81601, 81602, 
81531, 79897, 79967, 81600, 81530
27688, 72096, 72119, 72648, 72625, 72097, 72120, 72649, 72626, 79969, 81601, 81602, 81531, 79972, 81604, 81605, 
81534, 79900, 79970, 81603, 81533
27689, 72097, 72120, 72649, 72626, 72098, 72121, 72650, 72627, 79972, 81604, 81605, 81534, 79975, 81607, 81608, 
81537, 79903, 79973, 81606, 81536
27690, 72098, 72121, 72650, 72627, 72099, 72122, 72651, 72628, 79975, 81607, 81608, 81537, 79978, 81610, 81611, 
81540, 79906, 79976, 81609, 81539
27691, 72099, 72122, 72651, 72628, 72100, 72123, 72652, 72629, 79978, 81610, 81611, 81540, 79981, 81613, 81614, 
81543, 79909, 79979, 81612, 81542
27692, 72100, 72123, 72652, 72629, 72101, 72124, 72653, 72630, 79981, 81613, 81614, 81543, 79984, 81616, 81617, 
81546, 79912, 79982, 81615, 81545
27693, 72101, 72124, 72653, 72630, 72102, 72125, 72654, 72631, 79984, 81616, 81617, 81546, 79987, 81619, 81620, 
81549, 79915, 79985, 81618, 81548
27694, 72102, 72125, 72654, 72631, 22879, 22880, 22903, 22902, 79987, 81619, 81620, 81549, 23177, 23223, 23224, 
23221, 79918, 79988, 81621, 81551
27695, 17235, 17236, 17259, 17258, 72103, 72126, 72655, 72632, 17534, 17580, 17581, 17578, 79991, 81623, 81624, 
81553, 79919, 79989, 81622, 81552
27696, 72103, 72126, 72655, 72632, 72104, 72127, 72656, 72633, 79991, 81623, 81624, 81553, 79994, 81626, 81627, 
81556, 79922, 79992, 81625, 81555
27697, 72104, 72127, 72656, 72633, 72105, 72128, 72657, 72634, 79994, 81626, 81627, 81556, 79997, 81629, 81630, 
81559, 79925, 79995, 81628, 81558
27698, 72105, 72128, 72657, 72634, 72106, 72129, 72658, 72635, 79997, 81629, 81630, 81559, 80000, 81632, 81633, 
81562, 79928, 79998, 81631, 81561
27699, 72106, 72129, 72658, 72635, 72107, 72130, 72659, 72636, 80000, 81632, 81633, 81562, 80003, 81635, 81636, 
81565, 79931, 80001, 81634, 81564
27700, 72107, 72130, 72659, 72636, 72108, 72131, 72660, 72637, 80003, 81635, 81636, 81565, 80006, 81638, 81639, 
81568, 79934, 80004, 81637, 81567
27701, 72108, 72131, 72660, 72637, 72109, 72132, 72661, 72638, 80006, 81638, 81639, 81568, 80009, 81641, 81642, 
81571, 79937, 80007, 81640, 81570
27702, 72109, 72132, 72661, 72638, 72110, 72133, 72662, 72639, 80009, 81641, 81642, 81571, 80012, 81644, 81645, 
81574, 79940, 80010, 81643, 81573
27703, 72110, 72133, 72662, 72639, 72111, 72134, 72663, 72640, 80012, 81644, 81645, 81574, 80015, 81647, 81648, 
81577, 79943, 80013, 81646, 81576
27704, 72111, 72134, 72663, 72640, 72112, 72135, 72664, 72641, 80015, 81647, 81648, 81577, 80018, 81650, 81651, 
81580, 79946, 80016, 81649, 81579
27705, 72112, 72135, 72664, 72641, 72113, 72136, 72665, 72642, 80018, 81650, 81651, 81580, 80021, 81653, 81654, 
81583, 79949, 80019, 81652, 81582
27706, 72113, 72136, 72665, 72642, 72114, 72137, 72666, 72643, 80021, 81653, 81654, 81583, 80024, 81656, 81657, 
81586, 79952, 80022, 81655, 81585
27707, 72114, 72137, 72666, 72643, 72115, 72138, 72667, 72644, 80024, 81656, 81657, 81586, 80027, 81659, 81660, 
81589, 79955, 80025, 81658, 81588
27708, 72115, 72138, 72667, 72644, 72116, 72139, 72668, 72645, 80027, 81659, 81660, 81589, 80030, 81662, 81663, 
81592, 79958, 80028, 81661, 81591
27709, 72116, 72139, 72668, 72645, 72117, 72140, 72669, 72646, 80030, 81662, 81663, 81592, 80033, 81665, 81666, 
81595, 79961, 80031, 81664, 81594
27710, 72117, 72140, 72669, 72646, 72118, 72141, 72670, 72647, 80033, 81665, 81666, 81595, 80036, 81668, 81669, 
81598, 79964, 80034, 81667, 81597
27711, 72118, 72141, 72670, 72647, 72119, 72142, 72671, 72648, 80036, 81668, 81669, 81598, 80039, 81671, 81672, 
81601, 79967, 80037, 81670, 81600
27712, 72119, 72142, 72671, 72648, 72120, 72143, 72672, 72649, 80039, 81671, 81672, 81601, 80042, 81674, 81675, 
81604, 79970, 80040, 81673, 81603
27713, 72120, 72143, 72672, 72649, 72121, 72144, 72673, 72650, 80042, 81674, 81675, 81604, 80045, 81677, 81678, 
81607, 79973, 80043, 81676, 81606
27714, 72121, 72144, 72673, 72650, 72122, 72145, 72674, 72651, 80045, 81677, 81678, 81607, 80048, 81680, 81681, 
81610, 79976, 80046, 81679, 81609
27715, 72122, 72145, 72674, 72651, 72123, 72146, 72675, 72652, 80048, 81680, 81681, 81610, 80051, 81683, 81684, 
81613, 79979, 80049, 81682, 81612
27716, 72123, 72146, 72675, 72652, 72124, 72147, 72676, 72653, 80051, 81683, 81684, 81613, 80054, 81686, 81687, 
81616, 79982, 80052, 81685, 81615
27717, 72124, 72147, 72676, 72653, 72125, 72148, 72677, 72654, 80054, 81686, 81687, 81616, 80057, 81689, 81690, 
81619, 79985, 80055, 81688, 81618
27718, 72125, 72148, 72677, 72654, 22880, 22881, 22904, 22903, 80057, 81689, 81690, 81619, 23179, 23225, 23226, 
23223, 79988, 80058, 81691, 81621
27719, 17236, 17237, 17260, 17259, 72126, 72149, 72678, 72655, 17536, 17582, 17583, 17580, 80061, 81693, 81694, 
81623, 79989, 80059, 81692, 81622
27720, 72126, 72149, 72678, 72655, 72127, 72150, 72679, 72656, 80061, 81693, 81694, 81623, 80064, 81696, 81697, 
81626, 79992, 80062, 81695, 81625
27721, 72127, 72150, 72679, 72656, 72128, 72151, 72680, 72657, 80064, 81696, 81697, 81626, 80067, 81699, 81700, 
81629, 79995, 80065, 81698, 81628
27722, 72128, 72151, 72680, 72657, 72129, 72152, 72681, 72658, 80067, 81699, 81700, 81629, 80070, 81702, 81703, 
81632, 79998, 80068, 81701, 81631
27723, 72129, 72152, 72681, 72658, 72130, 72153, 72682, 72659, 80070, 81702, 81703, 81632, 80073, 81705, 81706, 
81635, 80001, 80071, 81704, 81634
27724, 72130, 72153, 72682, 72659, 72131, 72154, 72683, 72660, 80073, 81705, 81706, 81635, 80076, 81708, 81709, 
81638, 80004, 80074, 81707, 81637
27725, 72131, 72154, 72683, 72660, 72132, 72155, 72684, 72661, 80076, 81708, 81709, 81638, 80079, 81711, 81712, 
81641, 80007, 80077, 81710, 81640
27726, 72132, 72155, 72684, 72661, 72133, 72156, 72685, 72662, 80079, 81711, 81712, 81641, 80082, 81714, 81715, 
81644, 80010, 80080, 81713, 81643
27727, 72133, 72156, 72685, 72662, 72134, 72157, 72686, 72663, 80082, 81714, 81715, 81644, 80085, 81717, 81718, 
81647, 80013, 80083, 81716, 81646
27728, 72134, 72157, 72686, 72663, 72135, 72158, 72687, 72664, 80085, 81717, 81718, 81647, 80088, 81720, 81721, 
81650, 80016, 80086, 81719, 81649
27729, 72135, 72158, 72687, 72664, 72136, 72159, 72688, 72665, 80088, 81720, 81721, 81650, 80091, 81723, 81724, 
81653, 80019, 80089, 81722, 81652
27730, 72136, 72159, 72688, 72665, 72137, 72160, 72689, 72666, 80091, 81723, 81724, 81653, 80094, 81726, 81727, 
81656, 80022, 80092, 81725, 81655
27731, 72137, 72160, 72689, 72666, 72138, 72161, 72690, 72667, 80094, 81726, 81727, 81656, 80097, 81729, 81730, 
81659, 80025, 80095, 81728, 81658
27732, 72138, 72161, 72690, 72667, 72139, 72162, 72691, 72668, 80097, 81729, 81730, 81659, 80100, 81732, 81733, 
81662, 80028, 80098, 81731, 81661
27733, 72139, 72162, 72691, 72668, 72140, 72163, 72692, 72669, 80100, 81732, 81733, 81662, 80103, 81735, 81736, 
81665, 80031, 80101, 81734, 81664
27734, 72140, 72163, 72692, 72669, 72141, 72164, 72693, 72670, 80103, 81735, 81736, 81665, 80106, 81738, 81739, 
81668, 80034, 80104, 81737, 81667
27735, 72141, 72164, 72693, 72670, 72142, 72165, 72694, 72671, 80106, 81738, 81739, 81668, 80109, 81741, 81742, 
81671, 80037, 80107, 81740, 81670
27736, 72142, 72165, 72694, 72671, 72143, 72166, 72695, 72672, 80109, 81741, 81742, 81671, 80112, 81744, 81745, 
81674, 80040, 80110, 81743, 81673
27737, 72143, 72166, 72695, 72672, 72144, 72167, 72696, 72673, 80112, 81744, 81745, 81674, 80115, 81747, 81748, 
81677, 80043, 80113, 81746, 81676
27738, 72144, 72167, 72696, 72673, 72145, 72168, 72697, 72674, 80115, 81747, 81748, 81677, 80118, 81750, 81751, 
81680, 80046, 80116, 81749, 81679
27739, 72145, 72168, 72697, 72674, 72146, 72169, 72698, 72675, 80118, 81750, 81751, 81680, 80121, 81753, 81754, 
81683, 80049, 80119, 81752, 81682
27740, 72146, 72169, 72698, 72675, 72147, 72170, 72699, 72676, 80121, 81753, 81754, 81683, 80124, 81756, 81757, 
81686, 80052, 80122, 81755, 81685
27741, 72147, 72170, 72699, 72676, 72148, 72171, 72700, 72677, 80124, 81756, 81757, 81686, 80127, 81759, 81760, 
81689, 80055, 80125, 81758, 81688
27742, 72148, 72171, 72700, 72677, 22881, 22882, 22905, 22904, 80127, 81759, 81760, 81689, 23181, 23227, 23228, 
23225, 80058, 80128, 81761, 81691
27743, 17237, 17238, 17261, 17260, 72149, 72172, 72701, 72678, 17538, 17584, 17585, 17582, 80131, 81763, 81764, 
81693, 80059, 80129, 81762, 81692
27744, 72149, 72172, 72701, 72678, 72150, 72173, 72702, 72679, 80131, 81763, 81764, 81693, 80134, 81766, 81767, 
81696, 80062, 80132, 81765, 81695
27745, 72150, 72173, 72702, 72679, 72151, 72174, 72703, 72680, 80134, 81766, 81767, 81696, 80137, 81769, 81770, 
81699, 80065, 80135, 81768, 81698
27746, 72151, 72174, 72703, 72680, 72152, 72175, 72704, 72681, 80137, 81769, 81770, 81699, 80140, 81772, 81773, 
81702, 80068, 80138, 81771, 81701
27747, 72152, 72175, 72704, 72681, 72153, 72176, 72705, 72682, 80140, 81772, 81773, 81702, 80143, 81775, 81776, 
81705, 80071, 80141, 81774, 81704
27748, 72153, 72176, 72705, 72682, 72154, 72177, 72706, 72683, 80143, 81775, 81776, 81705, 80146, 81778, 81779, 
81708, 80074, 80144, 81777, 81707
27749, 72154, 72177, 72706, 72683, 72155, 72178, 72707, 72684, 80146, 81778, 81779, 81708, 80149, 81781, 81782, 
81711, 80077, 80147, 81780, 81710
27750, 72155, 72178, 72707, 72684, 72156, 72179, 72708, 72685, 80149, 81781, 81782, 81711, 80152, 81784, 81785, 
81714, 80080, 80150, 81783, 81713
27751, 72156, 72179, 72708, 72685, 72157, 72180, 72709, 72686, 80152, 81784, 81785, 81714, 80155, 81787, 81788, 
81717, 80083, 80153, 81786, 81716
27752, 72157, 72180, 72709, 72686, 72158, 72181, 72710, 72687, 80155, 81787, 81788, 81717, 80158, 81790, 81791, 
81720, 80086, 80156, 81789, 81719
27753, 72158, 72181, 72710, 72687, 72159, 72182, 72711, 72688, 80158, 81790, 81791, 81720, 80161, 81793, 81794, 
81723, 80089, 80159, 81792, 81722
27754, 72159, 72182, 72711, 72688, 72160, 72183, 72712, 72689, 80161, 81793, 81794, 81723, 80164, 81796, 81797, 
81726, 80092, 80162, 81795, 81725
27755, 72160, 72183, 72712, 72689, 72161, 72184, 72713, 72690, 80164, 81796, 81797, 81726, 80167, 81799, 81800, 
81729, 80095, 80165, 81798, 81728
27756, 72161, 72184, 72713, 72690, 72162, 72185, 72714, 72691, 80167, 81799, 81800, 81729, 80170, 81802, 81803, 
81732, 80098, 80168, 81801, 81731
27757, 72162, 72185, 72714, 72691, 72163, 72186, 72715, 72692, 80170, 81802, 81803, 81732, 80173, 81805, 81806, 
81735, 80101, 80171, 81804, 81734
27758, 72163, 72186, 72715, 72692, 72164, 72187, 72716, 72693, 80173, 81805, 81806, 81735, 80176, 81808, 81809, 
81738, 80104, 80174, 81807, 81737
27759, 72164, 72187, 72716, 72693, 72165, 72188, 72717, 72694, 80176, 81808, 81809, 81738, 80179, 81811, 81812, 
81741, 80107, 80177, 81810, 81740
27760, 72165, 72188, 72717, 72694, 72166, 72189, 72718, 72695, 80179, 81811, 81812, 81741, 80182, 81814, 81815, 
81744, 80110, 80180, 81813, 81743
27761, 72166, 72189, 72718, 72695, 72167, 72190, 72719, 72696, 80182, 81814, 81815, 81744, 80185, 81817, 81818, 
81747, 80113, 80183, 81816, 81746
27762, 72167, 72190, 72719, 72696, 72168, 72191, 72720, 72697, 80185, 81817, 81818, 81747, 80188, 81820, 81821, 
81750, 80116, 80186, 81819, 81749
27763, 72168, 72191, 72720, 72697, 72169, 72192, 72721, 72698, 80188, 81820, 81821, 81750, 80191, 81823, 81824, 
81753, 80119, 80189, 81822, 81752
27764, 72169, 72192, 72721, 72698, 72170, 72193, 72722, 72699, 80191, 81823, 81824, 81753, 80194, 81826, 81827, 
81756, 80122, 80192, 81825, 81755
27765, 72170, 72193, 72722, 72699, 72171, 72194, 72723, 72700, 80194, 81826, 81827, 81756, 80197, 81829, 81830, 
81759, 80125, 80195, 81828, 81758
27766, 72171, 72194, 72723, 72700, 22882, 22883, 22906, 22905, 80197, 81829, 81830, 81759, 23183, 23229, 23230, 
23227, 80128, 80198, 81831, 81761
27767, 17238, 1631, 1632, 17261, 72172, 22068, 22091, 72701, 17539, 1643, 17586, 17584, 80199, 22393, 81832, 
81763, 80129, 22345, 22392, 81762
27768, 72172, 22068, 22091, 72701, 72173, 22069, 22092, 72702, 80199, 22393, 81832, 81763, 80200, 22395, 81833, 
81766, 80132, 22347, 22394, 81765
27769, 72173, 22069, 22092, 72702, 72174, 22070, 22093, 72703, 80200, 22395, 81833, 81766, 80201, 22397, 81834, 
81769, 80135, 22349, 22396, 81768
27770, 72174, 22070, 22093, 72703, 72175, 22071, 22094, 72704, 80201, 22397, 81834, 81769, 80202, 22399, 81835, 
81772, 80138, 22351, 22398, 81771
27771, 72175, 22071, 22094, 72704, 72176, 22072, 22095, 72705, 80202, 22399, 81835, 81772, 80203, 22401, 81836, 
81775, 80141, 22353, 22400, 81774
27772, 72176, 22072, 22095, 72705, 72177, 22073, 22096, 72706, 80203, 22401, 81836, 81775, 80204, 22403, 81837, 
81778, 80144, 22355, 22402, 81777
27773, 72177, 22073, 22096, 72706, 72178, 22074, 22097, 72707, 80204, 22403, 81837, 81778, 80205, 22405, 81838, 
81781, 80147, 22357, 22404, 81780
27774, 72178, 22074, 22097, 72707, 72179, 22075, 22098, 72708, 80205, 22405, 81838, 81781, 80206, 22407, 81839, 
81784, 80150, 22359, 22406, 81783
27775, 72179, 22075, 22098, 72708, 72180, 22076, 22099, 72709, 80206, 22407, 81839, 81784, 80207, 22409, 81840, 
81787, 80153, 22361, 22408, 81786
27776, 72180, 22076, 22099, 72709, 72181, 22077, 22100, 72710, 80207, 22409, 81840, 81787, 80208, 22411, 81841, 
81790, 80156, 22363, 22410, 81789
27777, 72181, 22077, 22100, 72710, 72182, 22078, 22101, 72711, 80208, 22411, 81841, 81790, 80209, 22413, 81842, 
81793, 80159, 22365, 22412, 81792
27778, 72182, 22078, 22101, 72711, 72183, 22079, 22102, 72712, 80209, 22413, 81842, 81793, 80210, 22415, 81843, 
81796, 80162, 22367, 22414, 81795
27779, 72183, 22079, 22102, 72712, 72184, 22080, 22103, 72713, 80210, 22415, 81843, 81796, 80211, 22417, 81844, 
81799, 80165, 22369, 22416, 81798
27780, 72184, 22080, 22103, 72713, 72185, 22081, 22104, 72714, 80211, 22417, 81844, 81799, 80212, 22419, 81845, 
81802, 80168, 22371, 22418, 81801
27781, 72185, 22081, 22104, 72714, 72186, 22082, 22105, 72715, 80212, 22419, 81845, 81802, 80213, 22421, 81846, 
81805, 80171, 22373, 22420, 81804
27782, 72186, 22082, 22105, 72715, 72187, 22083, 22106, 72716, 80213, 22421, 81846, 81805, 80214, 22423, 81847, 
81808, 80174, 22375, 22422, 81807
27783, 72187, 22083, 22106, 72716, 72188, 22084, 22107, 72717, 80214, 22423, 81847, 81808, 80215, 22425, 81848, 
81811, 80177, 22377, 22424, 81810
27784, 72188, 22084, 22107, 72717, 72189, 22085, 22108, 72718, 80215, 22425, 81848, 81811, 80216, 22427, 81849, 
81814, 80180, 22379, 22426, 81813
27785, 72189, 22085, 22108, 72718, 72190, 22086, 22109, 72719, 80216, 22427, 81849, 81814, 80217, 22429, 81850, 
81817, 80183, 22381, 22428, 81816
27786, 72190, 22086, 22109, 72719, 72191, 22087, 22110, 72720, 80217, 22429, 81850, 81817, 80218, 22431, 81851, 
81820, 80186, 22383, 22430, 81819
27787, 72191, 22087, 22110, 72720, 72192, 22088, 22111, 72721, 80218, 22431, 81851, 81820, 80219, 22433, 81852, 
81823, 80189, 22385, 22432, 81822
27788, 72192, 22088, 22111, 72721, 72193, 22089, 22112, 72722, 80219, 22433, 81852, 81823, 80220, 22435, 81853, 
81826, 80192, 22387, 22434, 81825
27789, 72193, 22089, 22112, 72722, 72194, 22090, 22113, 72723, 80220, 22435, 81853, 81826, 80221, 22437, 81854, 
81829, 80195, 22389, 22436, 81828
27790, 72194, 22090, 22113, 72723, 22883, 1959, 1960, 22906, 80221, 22437, 81854, 81829, 23184, 1971, 23231, 
23229, 80198, 22391, 22438, 81831
27791, 1609, 17239, 17262, 1610, 21298, 72195, 72724, 21321, 17541, 17587, 17588, 1621, 80224, 81856, 81857, 
21646, 21600, 80222, 81855, 21647
27792, 21298, 72195, 72724, 21321, 21299, 72196, 72725, 21322, 80224, 81856, 81857, 21646, 80227, 81859, 81860, 
21648, 21602, 80225, 81858, 21649
27793, 21299, 72196, 72725, 21322, 21300, 72197, 72726, 21323, 80227, 81859, 81860, 21648, 80230, 81862, 81863, 
21650, 21604, 80228, 81861, 21651
27794, 21300, 72197, 72726, 21323, 21301, 72198, 72727, 21324, 80230, 81862, 81863, 21650, 80233, 81865, 81866, 
21652, 21606, 80231, 81864, 21653
27795, 21301, 72198, 72727, 21324, 21302, 72199, 72728, 21325, 80233, 81865, 81866, 21652, 80236, 81868, 81869, 
21654, 21608, 80234, 81867, 21655
27796, 21302, 72199, 72728, 21325, 21303, 72200, 72729, 21326, 80236, 81868, 81869, 21654, 80239, 81871, 81872, 
21656, 21610, 80237, 81870, 21657
27797, 21303, 72200, 72729, 21326, 21304, 72201, 72730, 21327, 80239, 81871, 81872, 21656, 80242, 81874, 81875, 
21658, 21612, 80240, 81873, 21659
27798, 21304, 72201, 72730, 21327, 21305, 72202, 72731, 21328, 80242, 81874, 81875, 21658, 80245, 81877, 81878, 
21660, 21614, 80243, 81876, 21661
27799, 21305, 72202, 72731, 21328, 21306, 72203, 72732, 21329, 80245, 81877, 81878, 21660, 80248, 81880, 81881, 
21662, 21616, 80246, 81879, 21663
27800, 21306, 72203, 72732, 21329, 21307, 72204, 72733, 21330, 80248, 81880, 81881, 21662, 80251, 81883, 81884, 
21664, 21618, 80249, 81882, 21665
27801, 21307, 72204, 72733, 21330, 21308, 72205, 72734, 21331, 80251, 81883, 81884, 21664, 80254, 81886, 81887, 
21666, 21620, 80252, 81885, 21667
27802, 21308, 72205, 72734, 21331, 21309, 72206, 72735, 21332, 80254, 81886, 81887, 21666, 80257, 81889, 81890, 
21668, 21622, 80255, 81888, 21669
27803, 21309, 72206, 72735, 21332, 21310, 72207, 72736, 21333, 80257, 81889, 81890, 21668, 80260, 81892, 81893, 
21670, 21624, 80258, 81891, 21671
27804, 21310, 72207, 72736, 21333, 21311, 72208, 72737, 21334, 80260, 81892, 81893, 21670, 80263, 81895, 81896, 
21672, 21626, 80261, 81894, 21673
27805, 21311, 72208, 72737, 21334, 21312, 72209, 72738, 21335, 80263, 81895, 81896, 21672, 80266, 81898, 81899, 
21674, 21628, 80264, 81897, 21675
27806, 21312, 72209, 72738, 21335, 21313, 72210, 72739, 21336, 80266, 81898, 81899, 21674, 80269, 81901, 81902, 
21676, 21630, 80267, 81900, 21677
27807, 21313, 72210, 72739, 21336, 21314, 72211, 72740, 21337, 80269, 81901, 81902, 21676, 80272, 81904, 81905, 
21678, 21632, 80270, 81903, 21679
27808, 21314, 72211, 72740, 21337, 21315, 72212, 72741, 21338, 80272, 81904, 81905, 21678, 80275, 81907, 81908, 
21680, 21634, 80273, 81906, 21681
27809, 21315, 72212, 72741, 21338, 21316, 72213, 72742, 21339, 80275, 81907, 81908, 21680, 80278, 81910, 81911, 
21682, 21636, 80276, 81909, 21683
27810, 21316, 72213, 72742, 21339, 21317, 72214, 72743, 21340, 80278, 81910, 81911, 21682, 80281, 81913, 81914, 
21684, 21638, 80279, 81912, 21685
27811, 21317, 72214, 72743, 21340, 21318, 72215, 72744, 21341, 80281, 81913, 81914, 21684, 80284, 81916, 81917, 
21686, 21640, 80282, 81915, 21687
27812, 21318, 72215, 72744, 21341, 21319, 72216, 72745, 21342, 80284, 81916, 81917, 21686, 80287, 81919, 81920, 
21688, 21642, 80285, 81918, 21689
27813, 21319, 72216, 72745, 21342, 21320, 72217, 72746, 21343, 80287, 81919, 81920, 21688, 80290, 81922, 81923, 
21690, 21644, 80288, 81921, 21691
27814, 21320, 72217, 72746, 21343, 1937, 22884, 22907, 1938, 80290, 81922, 81923, 21690, 23186, 23232, 23233, 
1949, 21645, 80291, 81924, 21692
27815, 17239, 17240, 17263, 17262, 72195, 72218, 72747, 72724, 17543, 17589, 17590, 17587, 80294, 81926, 81927, 
81856, 80222, 80292, 81925, 81855
27816, 72195, 72218, 72747, 72724, 72196, 72219, 72748, 72725, 80294, 81926, 81927, 81856, 80297, 81929, 81930, 
81859, 80225, 80295, 81928, 81858
27817, 72196, 72219, 72748, 72725, 72197, 72220, 72749, 72726, 80297, 81929, 81930, 81859, 80300, 81932, 81933, 
81862, 80228, 80298, 81931, 81861
27818, 72197, 72220, 72749, 72726, 72198, 72221, 72750, 72727, 80300, 81932, 81933, 81862, 80303, 81935, 81936, 
81865, 80231, 80301, 81934, 81864
27819, 72198, 72221, 72750, 72727, 72199, 72222, 72751, 72728, 80303, 81935, 81936, 81865, 80306, 81938, 81939, 
81868, 80234, 80304, 81937, 81867
27820, 72199, 72222, 72751, 72728, 72200, 72223, 72752, 72729, 80306, 81938, 81939, 81868, 80309, 81941, 81942, 
81871, 80237, 80307, 81940, 81870
27821, 72200, 72223, 72752, 72729, 72201, 72224, 72753, 72730, 80309, 81941, 81942, 81871, 80312, 81944, 81945, 
81874, 80240, 80310, 81943, 81873
27822, 72201, 72224, 72753, 72730, 72202, 72225, 72754, 72731, 80312, 81944, 81945, 81874, 80315, 81947, 81948, 
81877, 80243, 80313, 81946, 81876
27823, 72202, 72225, 72754, 72731, 72203, 72226, 72755, 72732, 80315, 81947, 81948, 81877, 80318, 81950, 81951, 
81880, 80246, 80316, 81949, 81879
27824, 72203, 72226, 72755, 72732, 72204, 72227, 72756, 72733, 80318, 81950, 81951, 81880, 80321, 81953, 81954, 
81883, 80249, 80319, 81952, 81882
27825, 72204, 72227, 72756, 72733, 72205, 72228, 72757, 72734, 80321, 81953, 81954, 81883, 80324, 81956, 81957, 
81886, 80252, 80322, 81955, 81885
27826, 72205, 72228, 72757, 72734, 72206, 72229, 72758, 72735, 80324, 81956, 81957, 81886, 80327, 81959, 81960, 
81889, 80255, 80325, 81958, 81888
27827, 72206, 72229, 72758, 72735, 72207, 72230, 72759, 72736, 80327, 81959, 81960, 81889, 80330, 81962, 81963, 
81892, 80258, 80328, 81961, 81891
27828, 72207, 72230, 72759, 72736, 72208, 72231, 72760, 72737, 80330, 81962, 81963, 81892, 80333, 81965, 81966, 
81895, 80261, 80331, 81964, 81894
27829, 72208, 72231, 72760, 72737, 72209, 72232, 72761, 72738, 80333, 81965, 81966, 81895, 80336, 81968, 81969, 
81898, 80264, 80334, 81967, 81897
27830, 72209, 72232, 72761, 72738, 72210, 72233, 72762, 72739, 80336, 81968, 81969, 81898, 80339, 81971, 81972, 
81901, 80267, 80337, 81970, 81900
27831, 72210, 72233, 72762, 72739, 72211, 72234, 72763, 72740, 80339, 81971, 81972, 81901, 80342, 81974, 81975, 
81904, 80270, 80340, 81973, 81903
27832, 72211, 72234, 72763, 72740, 72212, 72235, 72764, 72741, 80342, 81974, 81975, 81904, 80345, 81977, 81978, 
81907, 80273, 80343, 81976, 81906
27833, 72212, 72235, 72764, 72741, 72213, 72236, 72765, 72742, 80345, 81977, 81978, 81907, 80348, 81980, 81981, 
81910, 80276, 80346, 81979, 81909
27834, 72213, 72236, 72765, 72742, 72214, 72237, 72766, 72743, 80348, 81980, 81981, 81910, 80351, 81983, 81984, 
81913, 80279, 80349, 81982, 81912
27835, 72214, 72237, 72766, 72743, 72215, 72238, 72767, 72744, 80351, 81983, 81984, 81913, 80354, 81986, 81987, 
81916, 80282, 80352, 81985, 81915
27836, 72215, 72238, 72767, 72744, 72216, 72239, 72768, 72745, 80354, 81986, 81987, 81916, 80357, 81989, 81990, 
81919, 80285, 80355, 81988, 81918
27837, 72216, 72239, 72768, 72745, 72217, 72240, 72769, 72746, 80357, 81989, 81990, 81919, 80360, 81992, 81993, 
81922, 80288, 80358, 81991, 81921
27838, 72217, 72240, 72769, 72746, 22884, 22885, 22908, 22907, 80360, 81992, 81993, 81922, 23188, 23234, 23235, 
23232, 80291, 80361, 81994, 81924
27839, 17240, 17241, 17264, 17263, 72218, 72241, 72770, 72747, 17545, 17591, 17592, 17589, 80364, 81996, 81997, 
81926, 80292, 80362, 81995, 81925
27840, 72218, 72241, 72770, 72747, 72219, 72242, 72771, 72748, 80364, 81996, 81997, 81926, 80367, 81999, 82000, 
81929, 80295, 80365, 81998, 81928
27841, 72219, 72242, 72771, 72748, 72220, 72243, 72772, 72749, 80367, 81999, 82000, 81929, 80370, 82002, 82003, 
81932, 80298, 80368, 82001, 81931
27842, 72220, 72243, 72772, 72749, 72221, 72244, 72773, 72750, 80370, 82002, 82003, 81932, 80373, 82005, 82006, 
81935, 80301, 80371, 82004, 81934
27843, 72221, 72244, 72773, 72750, 72222, 72245, 72774, 72751, 80373, 82005, 82006, 81935, 80376, 82008, 82009, 
81938, 80304, 80374, 82007, 81937
27844, 72222, 72245, 72774, 72751, 72223, 72246, 72775, 72752, 80376, 82008, 82009, 81938, 80379, 82011, 82012, 
81941, 80307, 80377, 82010, 81940
27845, 72223, 72246, 72775, 72752, 72224, 72247, 72776, 72753, 80379, 82011, 82012, 81941, 80382, 82014, 82015, 
81944, 80310, 80380, 82013, 81943
27846, 72224, 72247, 72776, 72753, 72225, 72248, 72777, 72754, 80382, 82014, 82015, 81944, 80385, 82017, 82018, 
81947, 80313, 80383, 82016, 81946
27847, 72225, 72248, 72777, 72754, 72226, 72249, 72778, 72755, 80385, 82017, 82018, 81947, 80388, 82020, 82021, 
81950, 80316, 80386, 82019, 81949
27848, 72226, 72249, 72778, 72755, 72227, 72250, 72779, 72756, 80388, 82020, 82021, 81950, 80391, 82023, 82024, 
81953, 80319, 80389, 82022, 81952
27849, 72227, 72250, 72779, 72756, 72228, 72251, 72780, 72757, 80391, 82023, 82024, 81953, 80394, 82026, 82027, 
81956, 80322, 80392, 82025, 81955
27850, 72228, 72251, 72780, 72757, 72229, 72252, 72781, 72758, 80394, 82026, 82027, 81956, 80397, 82029, 82030, 
81959, 80325, 80395, 82028, 81958
27851, 72229, 72252, 72781, 72758, 72230, 72253, 72782, 72759, 80397, 82029, 82030, 81959, 80400, 82032, 82033, 
81962, 80328, 80398, 82031, 81961
27852, 72230, 72253, 72782, 72759, 72231, 72254, 72783, 72760, 80400, 82032, 82033, 81962, 80403, 82035, 82036, 
81965, 80331, 80401, 82034, 81964
27853, 72231, 72254, 72783, 72760, 72232, 72255, 72784, 72761, 80403, 82035, 82036, 81965, 80406, 82038, 82039, 
81968, 80334, 80404, 82037, 81967
27854, 72232, 72255, 72784, 72761, 72233, 72256, 72785, 72762, 80406, 82038, 82039, 81968, 80409, 82041, 82042, 
81971, 80337, 80407, 82040, 81970
27855, 72233, 72256, 72785, 72762, 72234, 72257, 72786, 72763, 80409, 82041, 82042, 81971, 80412, 82044, 82045, 
81974, 80340, 80410, 82043, 81973
27856, 72234, 72257, 72786, 72763, 72235, 72258, 72787, 72764, 80412, 82044, 82045, 81974, 80415, 82047, 82048, 
81977, 80343, 80413, 82046, 81976
27857, 72235, 72258, 72787, 72764, 72236, 72259, 72788, 72765, 80415, 82047, 82048, 81977, 80418, 82050, 82051, 
81980, 80346, 80416, 82049, 81979
27858, 72236, 72259, 72788, 72765, 72237, 72260, 72789, 72766, 80418, 82050, 82051, 81980, 80421, 82053, 82054, 
81983, 80349, 80419, 82052, 81982
27859, 72237, 72260, 72789, 72766, 72238, 72261, 72790, 72767, 80421, 82053, 82054, 81983, 80424, 82056, 82057, 
81986, 80352, 80422, 82055, 81985
27860, 72238, 72261, 72790, 72767, 72239, 72262, 72791, 72768, 80424, 82056, 82057, 81986, 80427, 82059, 82060, 
81989, 80355, 80425, 82058, 81988
27861, 72239, 72262, 72791, 72768, 72240, 72263, 72792, 72769, 80427, 82059, 82060, 81989, 80430, 82062, 82063, 
81992, 80358, 80428, 82061, 81991
27862, 72240, 72263, 72792, 72769, 22885, 22886, 22909, 22908, 80430, 82062, 82063, 81992, 23190, 23236, 23237, 
23234, 80361, 80431, 82064, 81994
27863, 17241, 17242, 17265, 17264, 72241, 72264, 72793, 72770, 17547, 17593, 17594, 17591, 80434, 82066, 82067, 
81996, 80362, 80432, 82065, 81995
27864, 72241, 72264, 72793, 72770, 72242, 72265, 72794, 72771, 80434, 82066, 82067, 81996, 80437, 82069, 82070, 
81999, 80365, 80435, 82068, 81998
27865, 72242, 72265, 72794, 72771, 72243, 72266, 72795, 72772, 80437, 82069, 82070, 81999, 80440, 82072, 82073, 
82002, 80368, 80438, 82071, 82001
27866, 72243, 72266, 72795, 72772, 72244, 72267, 72796, 72773, 80440, 82072, 82073, 82002, 80443, 82075, 82076, 
82005, 80371, 80441, 82074, 82004
27867, 72244, 72267, 72796, 72773, 72245, 72268, 72797, 72774, 80443, 82075, 82076, 82005, 80446, 82078, 82079, 
82008, 80374, 80444, 82077, 82007
27868, 72245, 72268, 72797, 72774, 72246, 72269, 72798, 72775, 80446, 82078, 82079, 82008, 80449, 82081, 82082, 
82011, 80377, 80447, 82080, 82010
27869, 72246, 72269, 72798, 72775, 72247, 72270, 72799, 72776, 80449, 82081, 82082, 82011, 80452, 82084, 82085, 
82014, 80380, 80450, 82083, 82013
27870, 72247, 72270, 72799, 72776, 72248, 72271, 72800, 72777, 80452, 82084, 82085, 82014, 80455, 82087, 82088, 
82017, 80383, 80453, 82086, 82016
27871, 72248, 72271, 72800, 72777, 72249, 72272, 72801, 72778, 80455, 82087, 82088, 82017, 80458, 82090, 82091, 
82020, 80386, 80456, 82089, 82019
27872, 72249, 72272, 72801, 72778, 72250, 72273, 72802, 72779, 80458, 82090, 82091, 82020, 80461, 82093, 82094, 
82023, 80389, 80459, 82092, 82022
27873, 72250, 72273, 72802, 72779, 72251, 72274, 72803, 72780, 80461, 82093, 82094, 82023, 80464, 82096, 82097, 
82026, 80392, 80462, 82095, 82025
27874, 72251, 72274, 72803, 72780, 72252, 72275, 72804, 72781, 80464, 82096, 82097, 82026, 80467, 82099, 82100, 
82029, 80395, 80465, 82098, 82028
27875, 72252, 72275, 72804, 72781, 72253, 72276, 72805, 72782, 80467, 82099, 82100, 82029, 80470, 82102, 82103, 
82032, 80398, 80468, 82101, 82031
27876, 72253, 72276, 72805, 72782, 72254, 72277, 72806, 72783, 80470, 82102, 82103, 82032, 80473, 82105, 82106, 
82035, 80401, 80471, 82104, 82034
27877, 72254, 72277, 72806, 72783, 72255, 72278, 72807, 72784, 80473, 82105, 82106, 82035, 80476, 82108, 82109, 
82038, 80404, 80474, 82107, 82037
27878, 72255, 72278, 72807, 72784, 72256, 72279, 72808, 72785, 80476, 82108, 82109, 82038, 80479, 82111, 82112, 
82041, 80407, 80477, 82110, 82040
27879, 72256, 72279, 72808, 72785, 72257, 72280, 72809, 72786, 80479, 82111, 82112, 82041, 80482, 82114, 82115, 
82044, 80410, 80480, 82113, 82043
27880, 72257, 72280, 72809, 72786, 72258, 72281, 72810, 72787, 80482, 82114, 82115, 82044, 80485, 82117, 82118, 
82047, 80413, 80483, 82116, 82046
27881, 72258, 72281, 72810, 72787, 72259, 72282, 72811, 72788, 80485, 82117, 82118, 82047, 80488, 82120, 82121, 
82050, 80416, 80486, 82119, 82049
27882, 72259, 72282, 72811, 72788, 72260, 72283, 72812, 72789, 80488, 82120, 82121, 82050, 80491, 82123, 82124, 
82053, 80419, 80489, 82122, 82052
27883, 72260, 72283, 72812, 72789, 72261, 72284, 72813, 72790, 80491, 82123, 82124, 82053, 80494, 82126, 82127, 
82056, 80422, 80492, 82125, 82055
27884, 72261, 72284, 72813, 72790, 72262, 72285, 72814, 72791, 80494, 82126, 82127, 82056, 80497, 82129, 82130, 
82059, 80425, 80495, 82128, 82058
27885, 72262, 72285, 72814, 72791, 72263, 72286, 72815, 72792, 80497, 82129, 82130, 82059, 80500, 82132, 82133, 
82062, 80428, 80498, 82131, 82061
27886, 72263, 72286, 72815, 72792, 22886, 22887, 22910, 22909, 80500, 82132, 82133, 82062, 23192, 23238, 23239, 
23236, 80431, 80501, 82134, 82064
27887, 17242, 17243, 17266, 17265, 72264, 72287, 72816, 72793, 17549, 17595, 17596, 17593, 80504, 82136, 82137, 
82066, 80432, 80502, 82135, 82065
27888, 72264, 72287, 72816, 72793, 72265, 72288, 72817, 72794, 80504, 82136, 82137, 82066, 80507, 82139, 82140, 
82069, 80435, 80505, 82138, 82068
27889, 72265, 72288, 72817, 72794, 72266, 72289, 72818, 72795, 80507, 82139, 82140, 82069, 80510, 82142, 82143, 
82072, 80438, 80508, 82141, 82071
27890, 72266, 72289, 72818, 72795, 72267, 72290, 72819, 72796, 80510, 82142, 82143, 82072, 80513, 82145, 82146, 
82075, 80441, 80511, 82144, 82074
27891, 72267, 72290, 72819, 72796, 72268, 72291, 72820, 72797, 80513, 82145, 82146, 82075, 80516, 82148, 82149, 
82078, 80444, 80514, 82147, 82077
27892, 72268, 72291, 72820, 72797, 72269, 72292, 72821, 72798, 80516, 82148, 82149, 82078, 80519, 82151, 82152, 
82081, 80447, 80517, 82150, 82080
27893, 72269, 72292, 72821, 72798, 72270, 72293, 72822, 72799, 80519, 82151, 82152, 82081, 80522, 82154, 82155, 
82084, 80450, 80520, 82153, 82083
27894, 72270, 72293, 72822, 72799, 72271, 72294, 72823, 72800, 80522, 82154, 82155, 82084, 80525, 82157, 82158, 
82087, 80453, 80523, 82156, 82086
27895, 72271, 72294, 72823, 72800, 72272, 72295, 72824, 72801, 80525, 82157, 82158, 82087, 80528, 82160, 82161, 
82090, 80456, 80526, 82159, 82089
27896, 72272, 72295, 72824, 72801, 72273, 72296, 72825, 72802, 80528, 82160, 82161, 82090, 80531, 82163, 82164, 
82093, 80459, 80529, 82162, 82092
27897, 72273, 72296, 72825, 72802, 72274, 72297, 72826, 72803, 80531, 82163, 82164, 82093, 80534, 82166, 82167, 
82096, 80462, 80532, 82165, 82095
27898, 72274, 72297, 72826, 72803, 72275, 72298, 72827, 72804, 80534, 82166, 82167, 82096, 80537, 82169, 82170, 
82099, 80465, 80535, 82168, 82098
27899, 72275, 72298, 72827, 72804, 72276, 72299, 72828, 72805, 80537, 82169, 82170, 82099, 80540, 82172, 82173, 
82102, 80468, 80538, 82171, 82101
27900, 72276, 72299, 72828, 72805, 72277, 72300, 72829, 72806, 80540, 82172, 82173, 82102, 80543, 82175, 82176, 
82105, 80471, 80541, 82174, 82104
27901, 72277, 72300, 72829, 72806, 72278, 72301, 72830, 72807, 80543, 82175, 82176, 82105, 80546, 82178, 82179, 
82108, 80474, 80544, 82177, 82107
27902, 72278, 72301, 72830, 72807, 72279, 72302, 72831, 72808, 80546, 82178, 82179, 82108, 80549, 82181, 82182, 
82111, 80477, 80547, 82180, 82110
27903, 72279, 72302, 72831, 72808, 72280, 72303, 72832, 72809, 80549, 82181, 82182, 82111, 80552, 82184, 82185, 
82114, 80480, 80550, 82183, 82113
27904, 72280, 72303, 72832, 72809, 72281, 72304, 72833, 72810, 80552, 82184, 82185, 82114, 80555, 82187, 82188, 
82117, 80483, 80553, 82186, 82116
27905, 72281, 72304, 72833, 72810, 72282, 72305, 72834, 72811, 80555, 82187, 82188, 82117, 80558, 82190, 82191, 
82120, 80486, 80556, 82189, 82119
27906, 72282, 72305, 72834, 72811, 72283, 72306, 72835, 72812, 80558, 82190, 82191, 82120, 80561, 82193, 82194, 
82123, 80489, 80559, 82192, 82122
27907, 72283, 72306, 72835, 72812, 72284, 72307, 72836, 72813, 80561, 82193, 82194, 82123, 80564, 82196, 82197, 
82126, 80492, 80562, 82195, 82125
27908, 72284, 72307, 72836, 72813, 72285, 72308, 72837, 72814, 80564, 82196, 82197, 82126, 80567, 82199, 82200, 
82129, 80495, 80565, 82198, 82128
27909, 72285, 72308, 72837, 72814, 72286, 72309, 72838, 72815, 80567, 82199, 82200, 82129, 80570, 82202, 82203, 
82132, 80498, 80568, 82201, 82131
27910, 72286, 72309, 72838, 72815, 22887, 22888, 22911, 22910, 80570, 82202, 82203, 82132, 23194, 23240, 23241, 
23238, 80501, 80571, 82204, 82134
27911, 17243, 17244, 17267, 17266, 72287, 72310, 72839, 72816, 17551, 17597, 17598, 17595, 80574, 82206, 82207, 
82136, 80502, 80572, 82205, 82135
27912, 72287, 72310, 72839, 72816, 72288, 72311, 72840, 72817, 80574, 82206, 82207, 82136, 80577, 82209, 82210, 
82139, 80505, 80575, 82208, 82138
27913, 72288, 72311, 72840, 72817, 72289, 72312, 72841, 72818, 80577, 82209, 82210, 82139, 80580, 82212, 82213, 
82142, 80508, 80578, 82211, 82141
27914, 72289, 72312, 72841, 72818, 72290, 72313, 72842, 72819, 80580, 82212, 82213, 82142, 80583, 82215, 82216, 
82145, 80511, 80581, 82214, 82144
27915, 72290, 72313, 72842, 72819, 72291, 72314, 72843, 72820, 80583, 82215, 82216, 82145, 80586, 82218, 82219, 
82148, 80514, 80584, 82217, 82147
27916, 72291, 72314, 72843, 72820, 72292, 72315, 72844, 72821, 80586, 82218, 82219, 82148, 80589, 82221, 82222, 
82151, 80517, 80587, 82220, 82150
27917, 72292, 72315, 72844, 72821, 72293, 72316, 72845, 72822, 80589, 82221, 82222, 82151, 80592, 82224, 82225, 
82154, 80520, 80590, 82223, 82153
27918, 72293, 72316, 72845, 72822, 72294, 72317, 72846, 72823, 80592, 82224, 82225, 82154, 80595, 82227, 82228, 
82157, 80523, 80593, 82226, 82156
27919, 72294, 72317, 72846, 72823, 72295, 72318, 72847, 72824, 80595, 82227, 82228, 82157, 80598, 82230, 82231, 
82160, 80526, 80596, 82229, 82159
27920, 72295, 72318, 72847, 72824, 72296, 72319, 72848, 72825, 80598, 82230, 82231, 82160, 80601, 82233, 82234, 
82163, 80529, 80599, 82232, 82162
27921, 72296, 72319, 72848, 72825, 72297, 72320, 72849, 72826, 80601, 82233, 82234, 82163, 80604, 82236, 82237, 
82166, 80532, 80602, 82235, 82165
27922, 72297, 72320, 72849, 72826, 72298, 72321, 72850, 72827, 80604, 82236, 82237, 82166, 80607, 82239, 82240, 
82169, 80535, 80605, 82238, 82168
27923, 72298, 72321, 72850, 72827, 72299, 72322, 72851, 72828, 80607, 82239, 82240, 82169, 80610, 82242, 82243, 
82172, 80538, 80608, 82241, 82171
27924, 72299, 72322, 72851, 72828, 72300, 72323, 72852, 72829, 80610, 82242, 82243, 82172, 80613, 82245, 82246, 
82175, 80541, 80611, 82244, 82174
27925, 72300, 72323, 72852, 72829, 72301, 72324, 72853, 72830, 80613, 82245, 82246, 82175, 80616, 82248, 82249, 
82178, 80544, 80614, 82247, 82177
27926, 72301, 72324, 72853, 72830, 72302, 72325, 72854, 72831, 80616, 82248, 82249, 82178, 80619, 82251, 82252, 
82181, 80547, 80617, 82250, 82180
27927, 72302, 72325, 72854, 72831, 72303, 72326, 72855, 72832, 80619, 82251, 82252, 82181, 80622, 82254, 82255, 
82184, 80550, 80620, 82253, 82183
27928, 72303, 72326, 72855, 72832, 72304, 72327, 72856, 72833, 80622, 82254, 82255, 82184, 80625, 82257, 82258, 
82187, 80553, 80623, 82256, 82186
27929, 72304, 72327, 72856, 72833, 72305, 72328, 72857, 72834, 80625, 82257, 82258, 82187, 80628, 82260, 82261, 
82190, 80556, 80626, 82259, 82189
27930, 72305, 72328, 72857, 72834, 72306, 72329, 72858, 72835, 80628, 82260, 82261, 82190, 80631, 82263, 82264, 
82193, 80559, 80629, 82262, 82192
27931, 72306, 72329, 72858, 72835, 72307, 72330, 72859, 72836, 80631, 82263, 82264, 82193, 80634, 82266, 82267, 
82196, 80562, 80632, 82265, 82195
27932, 72307, 72330, 72859, 72836, 72308, 72331, 72860, 72837, 80634, 82266, 82267, 82196, 80637, 82269, 82270, 
82199, 80565, 80635, 82268, 82198
27933, 72308, 72331, 72860, 72837, 72309, 72332, 72861, 72838, 80637, 82269, 82270, 82199, 80640, 82272, 82273, 
82202, 80568, 80638, 82271, 82201
27934, 72309, 72332, 72861, 72838, 22888, 22889, 22912, 22911, 80640, 82272, 82273, 82202, 23196, 23242, 23243, 
23240, 80571, 80641, 82274, 82204
27935, 17244, 17245, 17268, 17267, 72310, 72333, 72862, 72839, 17553, 17599, 17600, 17597, 80644, 82276, 82277, 
82206, 80572, 80642, 82275, 82205
27936, 72310, 72333, 72862, 72839, 72311, 72334, 72863, 72840, 80644, 82276, 82277, 82206, 80647, 82279, 82280, 
82209, 80575, 80645, 82278, 82208
27937, 72311, 72334, 72863, 72840, 72312, 72335, 72864, 72841, 80647, 82279, 82280, 82209, 80650, 82282, 82283, 
82212, 80578, 80648, 82281, 82211
27938, 72312, 72335, 72864, 72841, 72313, 72336, 72865, 72842, 80650, 82282, 82283, 82212, 80653, 82285, 82286, 
82215, 80581, 80651, 82284, 82214
27939, 72313, 72336, 72865, 72842, 72314, 72337, 72866, 72843, 80653, 82285, 82286, 82215, 80656, 82288, 82289, 
82218, 80584, 80654, 82287, 82217
27940, 72314, 72337, 72866, 72843, 72315, 72338, 72867, 72844, 80656, 82288, 82289, 82218, 80659, 82291, 82292, 
82221, 80587, 80657, 82290, 82220
27941, 72315, 72338, 72867, 72844, 72316, 72339, 72868, 72845, 80659, 82291, 82292, 82221, 80662, 82294, 82295, 
82224, 80590, 80660, 82293, 82223
27942, 72316, 72339, 72868, 72845, 72317, 72340, 72869, 72846, 80662, 82294, 82295, 82224, 80665, 82297, 82298, 
82227, 80593, 80663, 82296, 82226
27943, 72317, 72340, 72869, 72846, 72318, 72341, 72870, 72847, 80665, 82297, 82298, 82227, 80668, 82300, 82301, 
82230, 80596, 80666, 82299, 82229
27944, 72318, 72341, 72870, 72847, 72319, 72342, 72871, 72848, 80668, 82300, 82301, 82230, 80671, 82303, 82304, 
82233, 80599, 80669, 82302, 82232
27945, 72319, 72342, 72871, 72848, 72320, 72343, 72872, 72849, 80671, 82303, 82304, 82233, 80674, 82306, 82307, 
82236, 80602, 80672, 82305, 82235
27946, 72320, 72343, 72872, 72849, 72321, 72344, 72873, 72850, 80674, 82306, 82307, 82236, 80677, 82309, 82310, 
82239, 80605, 80675, 82308, 82238
27947, 72321, 72344, 72873, 72850, 72322, 72345, 72874, 72851, 80677, 82309, 82310, 82239, 80680, 82312, 82313, 
82242, 80608, 80678, 82311, 82241
27948, 72322, 72345, 72874, 72851, 72323, 72346, 72875, 72852, 80680, 82312, 82313, 82242, 80683, 82315, 82316, 
82245, 80611, 80681, 82314, 82244
27949, 72323, 72346, 72875, 72852, 72324, 72347, 72876, 72853, 80683, 82315, 82316, 82245, 80686, 82318, 82319, 
82248, 80614, 80684, 82317, 82247
27950, 72324, 72347, 72876, 72853, 72325, 72348, 72877, 72854, 80686, 82318, 82319, 82248, 80689, 82321, 82322, 
82251, 80617, 80687, 82320, 82250
27951, 72325, 72348, 72877, 72854, 72326, 72349, 72878, 72855, 80689, 82321, 82322, 82251, 80692, 82324, 82325, 
82254, 80620, 80690, 82323, 82253
27952, 72326, 72349, 72878, 72855, 72327, 72350, 72879, 72856, 80692, 82324, 82325, 82254, 80695, 82327, 82328, 
82257, 80623, 80693, 82326, 82256
27953, 72327, 72350, 72879, 72856, 72328, 72351, 72880, 72857, 80695, 82327, 82328, 82257, 80698, 82330, 82331, 
82260, 80626, 80696, 82329, 82259
27954, 72328, 72351, 72880, 72857, 72329, 72352, 72881, 72858, 80698, 82330, 82331, 82260, 80701, 82333, 82334, 
82263, 80629, 80699, 82332, 82262
27955, 72329, 72352, 72881, 72858, 72330, 72353, 72882, 72859, 80701, 82333, 82334, 82263, 80704, 82336, 82337, 
82266, 80632, 80702, 82335, 82265
27956, 72330, 72353, 72882, 72859, 72331, 72354, 72883, 72860, 80704, 82336, 82337, 82266, 80707, 82339, 82340, 
82269, 80635, 80705, 82338, 82268
27957, 72331, 72354, 72883, 72860, 72332, 72355, 72884, 72861, 80707, 82339, 82340, 82269, 80710, 82342, 82343, 
82272, 80638, 80708, 82341, 82271
27958, 72332, 72355, 72884, 72861, 22889, 22890, 22913, 22912, 80710, 82342, 82343, 82272, 23198, 23244, 23245, 
23242, 80641, 80711, 82344, 82274
27959, 17245, 17246, 17269, 17268, 72333, 72356, 72885, 72862, 17555, 17601, 17602, 17599, 80714, 82346, 82347, 
82276, 80642, 80712, 82345, 82275
27960, 72333, 72356, 72885, 72862, 72334, 72357, 72886, 72863, 80714, 82346, 82347, 82276, 80717, 82349, 82350, 
82279, 80645, 80715, 82348, 82278
27961, 72334, 72357, 72886, 72863, 72335, 72358, 72887, 72864, 80717, 82349, 82350, 82279, 80720, 82352, 82353, 
82282, 80648, 80718, 82351, 82281
27962, 72335, 72358, 72887, 72864, 72336, 72359, 72888, 72865, 80720, 82352, 82353, 82282, 80723, 82355, 82356, 
82285, 80651, 80721, 82354, 82284
27963, 72336, 72359, 72888, 72865, 72337, 72360, 72889, 72866, 80723, 82355, 82356, 82285, 80726, 82358, 82359, 
82288, 80654, 80724, 82357, 82287
27964, 72337, 72360, 72889, 72866, 72338, 72361, 72890, 72867, 80726, 82358, 82359, 82288, 80729, 82361, 82362, 
82291, 80657, 80727, 82360, 82290
27965, 72338, 72361, 72890, 72867, 72339, 72362, 72891, 72868, 80729, 82361, 82362, 82291, 80732, 82364, 82365, 
82294, 80660, 80730, 82363, 82293
27966, 72339, 72362, 72891, 72868, 72340, 72363, 72892, 72869, 80732, 82364, 82365, 82294, 80735, 82367, 82368, 
82297, 80663, 80733, 82366, 82296
27967, 72340, 72363, 72892, 72869, 72341, 72364, 72893, 72870, 80735, 82367, 82368, 82297, 80738, 82370, 82371, 
82300, 80666, 80736, 82369, 82299
27968, 72341, 72364, 72893, 72870, 72342, 72365, 72894, 72871, 80738, 82370, 82371, 82300, 80741, 82373, 82374, 
82303, 80669, 80739, 82372, 82302
27969, 72342, 72365, 72894, 72871, 72343, 72366, 72895, 72872, 80741, 82373, 82374, 82303, 80744, 82376, 82377, 
82306, 80672, 80742, 82375, 82305
27970, 72343, 72366, 72895, 72872, 72344, 72367, 72896, 72873, 80744, 82376, 82377, 82306, 80747, 82379, 82380, 
82309, 80675, 80745, 82378, 82308
27971, 72344, 72367, 72896, 72873, 72345, 72368, 72897, 72874, 80747, 82379, 82380, 82309, 80750, 82382, 82383, 
82312, 80678, 80748, 82381, 82311
27972, 72345, 72368, 72897, 72874, 72346, 72369, 72898, 72875, 80750, 82382, 82383, 82312, 80753, 82385, 82386, 
82315, 80681, 80751, 82384, 82314
27973, 72346, 72369, 72898, 72875, 72347, 72370, 72899, 72876, 80753, 82385, 82386, 82315, 80756, 82388, 82389, 
82318, 80684, 80754, 82387, 82317
27974, 72347, 72370, 72899, 72876, 72348, 72371, 72900, 72877, 80756, 82388, 82389, 82318, 80759, 82391, 82392, 
82321, 80687, 80757, 82390, 82320
27975, 72348, 72371, 72900, 72877, 72349, 72372, 72901, 72878, 80759, 82391, 82392, 82321, 80762, 82394, 82395, 
82324, 80690, 80760, 82393, 82323
27976, 72349, 72372, 72901, 72878, 72350, 72373, 72902, 72879, 80762, 82394, 82395, 82324, 80765, 82397, 82398, 
82327, 80693, 80763, 82396, 82326
27977, 72350, 72373, 72902, 72879, 72351, 72374, 72903, 72880, 80765, 82397, 82398, 82327, 80768, 82400, 82401, 
82330, 80696, 80766, 82399, 82329
27978, 72351, 72374, 72903, 72880, 72352, 72375, 72904, 72881, 80768, 82400, 82401, 82330, 80771, 82403, 82404, 
82333, 80699, 80769, 82402, 82332
27979, 72352, 72375, 72904, 72881, 72353, 72376, 72905, 72882, 80771, 82403, 82404, 82333, 80774, 82406, 82407, 
82336, 80702, 80772, 82405, 82335
27980, 72353, 72376, 72905, 72882, 72354, 72377, 72906, 72883, 80774, 82406, 82407, 82336, 80777, 82409, 82410, 
82339, 80705, 80775, 82408, 82338
27981, 72354, 72377, 72906, 72883, 72355, 72378, 72907, 72884, 80777, 82409, 82410, 82339, 80780, 82412, 82413, 
82342, 80708, 80778, 82411, 82341
27982, 72355, 72378, 72907, 72884, 22890, 22891, 22914, 22913, 80780, 82412, 82413, 82342, 23200, 23246, 23247, 
23244, 80711, 80781, 82414, 82344
27983, 17246, 17247, 17270, 17269, 72356, 72379, 72908, 72885, 17557, 17603, 17604, 17601, 80784, 82416, 82417, 
82346, 80712, 80782, 82415, 82345
27984, 72356, 72379, 72908, 72885, 72357, 72380, 72909, 72886, 80784, 82416, 82417, 82346, 80787, 82419, 82420, 
82349, 80715, 80785, 82418, 82348
27985, 72357, 72380, 72909, 72886, 72358, 72381, 72910, 72887, 80787, 82419, 82420, 82349, 80790, 82422, 82423, 
82352, 80718, 80788, 82421, 82351
27986, 72358, 72381, 72910, 72887, 72359, 72382, 72911, 72888, 80790, 82422, 82423, 82352, 80793, 82425, 82426, 
82355, 80721, 80791, 82424, 82354
27987, 72359, 72382, 72911, 72888, 72360, 72383, 72912, 72889, 80793, 82425, 82426, 82355, 80796, 82428, 82429, 
82358, 80724, 80794, 82427, 82357
27988, 72360, 72383, 72912, 72889, 72361, 72384, 72913, 72890, 80796, 82428, 82429, 82358, 80799, 82431, 82432, 
82361, 80727, 80797, 82430, 82360
27989, 72361, 72384, 72913, 72890, 72362, 72385, 72914, 72891, 80799, 82431, 82432, 82361, 80802, 82434, 82435, 
82364, 80730, 80800, 82433, 82363
27990, 72362, 72385, 72914, 72891, 72363, 72386, 72915, 72892, 80802, 82434, 82435, 82364, 80805, 82437, 82438, 
82367, 80733, 80803, 82436, 82366
27991, 72363, 72386, 72915, 72892, 72364, 72387, 72916, 72893, 80805, 82437, 82438, 82367, 80808, 82440, 82441, 
82370, 80736, 80806, 82439, 82369
27992, 72364, 72387, 72916, 72893, 72365, 72388, 72917, 72894, 80808, 82440, 82441, 82370, 80811, 82443, 82444, 
82373, 80739, 80809, 82442, 82372
27993, 72365, 72388, 72917, 72894, 72366, 72389, 72918, 72895, 80811, 82443, 82444, 82373, 80814, 82446, 82447, 
82376, 80742, 80812, 82445, 82375
27994, 72366, 72389, 72918, 72895, 72367, 72390, 72919, 72896, 80814, 82446, 82447, 82376, 80817, 82449, 82450, 
82379, 80745, 80815, 82448, 82378
27995, 72367, 72390, 72919, 72896, 72368, 72391, 72920, 72897, 80817, 82449, 82450, 82379, 80820, 82452, 82453, 
82382, 80748, 80818, 82451, 82381
27996, 72368, 72391, 72920, 72897, 72369, 72392, 72921, 72898, 80820, 82452, 82453, 82382, 80823, 82455, 82456, 
82385, 80751, 80821, 82454, 82384
27997, 72369, 72392, 72921, 72898, 72370, 72393, 72922, 72899, 80823, 82455, 82456, 82385, 80826, 82458, 82459, 
82388, 80754, 80824, 82457, 82387
27998, 72370, 72393, 72922, 72899, 72371, 72394, 72923, 72900, 80826, 82458, 82459, 82388, 80829, 82461, 82462, 
82391, 80757, 80827, 82460, 82390
27999, 72371, 72394, 72923, 72900, 72372, 72395, 72924, 72901, 80829, 82461, 82462, 82391, 80832, 82464, 82465, 
82394, 80760, 80830, 82463, 82393
28000, 72372, 72395, 72924, 72901, 72373, 72396, 72925, 72902, 80832, 82464, 82465, 82394, 80835, 82467, 82468, 
82397, 80763, 80833, 82466, 82396
28001, 72373, 72396, 72925, 72902, 72374, 72397, 72926, 72903, 80835, 82467, 82468, 82397, 80838, 82470, 82471, 
82400, 80766, 80836, 82469, 82399
28002, 72374, 72397, 72926, 72903, 72375, 72398, 72927, 72904, 80838, 82470, 82471, 82400, 80841, 82473, 82474, 
82403, 80769, 80839, 82472, 82402
28003, 72375, 72398, 72927, 72904, 72376, 72399, 72928, 72905, 80841, 82473, 82474, 82403, 80844, 82476, 82477, 
82406, 80772, 80842, 82475, 82405
28004, 72376, 72399, 72928, 72905, 72377, 72400, 72929, 72906, 80844, 82476, 82477, 82406, 80847, 82479, 82480, 
82409, 80775, 80845, 82478, 82408
28005, 72377, 72400, 72929, 72906, 72378, 72401, 72930, 72907, 80847, 82479, 82480, 82409, 80850, 82482, 82483, 
82412, 80778, 80848, 82481, 82411
28006, 72378, 72401, 72930, 72907, 22891, 22892, 22915, 22914, 80850, 82482, 82483, 82412, 23202, 23248, 23249, 
23246, 80781, 80851, 82484, 82414
28007, 17247, 17248, 17271, 17270, 72379, 72402, 72931, 72908, 17559, 17605, 17606, 17603, 80854, 82486, 82487, 
82416, 80782, 80852, 82485, 82415
28008, 72379, 72402, 72931, 72908, 72380, 72403, 72932, 72909, 80854, 82486, 82487, 82416, 80857, 82489, 82490, 
82419, 80785, 80855, 82488, 82418
28009, 72380, 72403, 72932, 72909, 72381, 72404, 72933, 72910, 80857, 82489, 82490, 82419, 80860, 82492, 82493, 
82422, 80788, 80858, 82491, 82421
28010, 72381, 72404, 72933, 72910, 72382, 72405, 72934, 72911, 80860, 82492, 82493, 82422, 80863, 82495, 82496, 
82425, 80791, 80861, 82494, 82424
28011, 72382, 72405, 72934, 72911, 72383, 72406, 72935, 72912, 80863, 82495, 82496, 82425, 80866, 82498, 82499, 
82428, 80794, 80864, 82497, 82427
28012, 72383, 72406, 72935, 72912, 72384, 72407, 72936, 72913, 80866, 82498, 82499, 82428, 80869, 82501, 82502, 
82431, 80797, 80867, 82500, 82430
28013, 72384, 72407, 72936, 72913, 72385, 72408, 72937, 72914, 80869, 82501, 82502, 82431, 80872, 82504, 82505, 
82434, 80800, 80870, 82503, 82433
28014, 72385, 72408, 72937, 72914, 72386, 72409, 72938, 72915, 80872, 82504, 82505, 82434, 80875, 82507, 82508, 
82437, 80803, 80873, 82506, 82436
28015, 72386, 72409, 72938, 72915, 72387, 72410, 72939, 72916, 80875, 82507, 82508, 82437, 80878, 82510, 82511, 
82440, 80806, 80876, 82509, 82439
28016, 72387, 72410, 72939, 72916, 72388, 72411, 72940, 72917, 80878, 82510, 82511, 82440, 80881, 82513, 82514, 
82443, 80809, 80879, 82512, 82442
28017, 72388, 72411, 72940, 72917, 72389, 72412, 72941, 72918, 80881, 82513, 82514, 82443, 80884, 82516, 82517, 
82446, 80812, 80882, 82515, 82445
28018, 72389, 72412, 72941, 72918, 72390, 72413, 72942, 72919, 80884, 82516, 82517, 82446, 80887, 82519, 82520, 
82449, 80815, 80885, 82518, 82448
28019, 72390, 72413, 72942, 72919, 72391, 72414, 72943, 72920, 80887, 82519, 82520, 82449, 80890, 82522, 82523, 
82452, 80818, 80888, 82521, 82451
28020, 72391, 72414, 72943, 72920, 72392, 72415, 72944, 72921, 80890, 82522, 82523, 82452, 80893, 82525, 82526, 
82455, 80821, 80891, 82524, 82454
28021, 72392, 72415, 72944, 72921, 72393, 72416, 72945, 72922, 80893, 82525, 82526, 82455, 80896, 82528, 82529, 
82458, 80824, 80894, 82527, 82457
28022, 72393, 72416, 72945, 72922, 72394, 72417, 72946, 72923, 80896, 82528, 82529, 82458, 80899, 82531, 82532, 
82461, 80827, 80897, 82530, 82460
28023, 72394, 72417, 72946, 72923, 72395, 72418, 72947, 72924, 80899, 82531, 82532, 82461, 80902, 82534, 82535, 
82464, 80830, 80900, 82533, 82463
28024, 72395, 72418, 72947, 72924, 72396, 72419, 72948, 72925, 80902, 82534, 82535, 82464, 80905, 82537, 82538, 
82467, 80833, 80903, 82536, 82466
28025, 72396, 72419, 72948, 72925, 72397, 72420, 72949, 72926, 80905, 82537, 82538, 82467, 80908, 82540, 82541, 
82470, 80836, 80906, 82539, 82469
28026, 72397, 72420, 72949, 72926, 72398, 72421, 72950, 72927, 80908, 82540, 82541, 82470, 80911, 82543, 82544, 
82473, 80839, 80909, 82542, 82472
28027, 72398, 72421, 72950, 72927, 72399, 72422, 72951, 72928, 80911, 82543, 82544, 82473, 80914, 82546, 82547, 
82476, 80842, 80912, 82545, 82475
28028, 72399, 72422, 72951, 72928, 72400, 72423, 72952, 72929, 80914, 82546, 82547, 82476, 80917, 82549, 82550, 
82479, 80845, 80915, 82548, 82478
28029, 72400, 72423, 72952, 72929, 72401, 72424, 72953, 72930, 80917, 82549, 82550, 82479, 80920, 82552, 82553, 
82482, 80848, 80918, 82551, 82481
28030, 72401, 72424, 72953, 72930, 22892, 22893, 22916, 22915, 80920, 82552, 82553, 82482, 23204, 23250, 23251, 
23248, 80851, 80921, 82554, 82484
28031, 17248, 17249, 17272, 17271, 72402, 72425, 72954, 72931, 17561, 17607, 17608, 17605, 80924, 82556, 82557, 
82486, 80852, 80922, 82555, 82485
28032, 72402, 72425, 72954, 72931, 72403, 72426, 72955, 72932, 80924, 82556, 82557, 82486, 80927, 82559, 82560, 
82489, 80855, 80925, 82558, 82488
28033, 72403, 72426, 72955, 72932, 72404, 72427, 72956, 72933, 80927, 82559, 82560, 82489, 80930, 82562, 82563, 
82492, 80858, 80928, 82561, 82491
28034, 72404, 72427, 72956, 72933, 72405, 72428, 72957, 72934, 80930, 82562, 82563, 82492, 80933, 82565, 82566, 
82495, 80861, 80931, 82564, 82494
28035, 72405, 72428, 72957, 72934, 72406, 72429, 72958, 72935, 80933, 82565, 82566, 82495, 80936, 82568, 82569, 
82498, 80864, 80934, 82567, 82497
28036, 72406, 72429, 72958, 72935, 72407, 72430, 72959, 72936, 80936, 82568, 82569, 82498, 80939, 82571, 82572, 
82501, 80867, 80937, 82570, 82500
28037, 72407, 72430, 72959, 72936, 72408, 72431, 72960, 72937, 80939, 82571, 82572, 82501, 80942, 82574, 82575, 
82504, 80870, 80940, 82573, 82503
28038, 72408, 72431, 72960, 72937, 72409, 72432, 72961, 72938, 80942, 82574, 82575, 82504, 80945, 82577, 82578, 
82507, 80873, 80943, 82576, 82506
28039, 72409, 72432, 72961, 72938, 72410, 72433, 72962, 72939, 80945, 82577, 82578, 82507, 80948, 82580, 82581, 
82510, 80876, 80946, 82579, 82509
28040, 72410, 72433, 72962, 72939, 72411, 72434, 72963, 72940, 80948, 82580, 82581, 82510, 80951, 82583, 82584, 
82513, 80879, 80949, 82582, 82512
28041, 72411, 72434, 72963, 72940, 72412, 72435, 72964, 72941, 80951, 82583, 82584, 82513, 80954, 82586, 82587, 
82516, 80882, 80952, 82585, 82515
28042, 72412, 72435, 72964, 72941, 72413, 72436, 72965, 72942, 80954, 82586, 82587, 82516, 80957, 82589, 82590, 
82519, 80885, 80955, 82588, 82518
28043, 72413, 72436, 72965, 72942, 72414, 72437, 72966, 72943, 80957, 82589, 82590, 82519, 80960, 82592, 82593, 
82522, 80888, 80958, 82591, 82521
28044, 72414, 72437, 72966, 72943, 72415, 72438, 72967, 72944, 80960, 82592, 82593, 82522, 80963, 82595, 82596, 
82525, 80891, 80961, 82594, 82524
28045, 72415, 72438, 72967, 72944, 72416, 72439, 72968, 72945, 80963, 82595, 82596, 82525, 80966, 82598, 82599, 
82528, 80894, 80964, 82597, 82527
28046, 72416, 72439, 72968, 72945, 72417, 72440, 72969, 72946, 80966, 82598, 82599, 82528, 80969, 82601, 82602, 
82531, 80897, 80967, 82600, 82530
28047, 72417, 72440, 72969, 72946, 72418, 72441, 72970, 72947, 80969, 82601, 82602, 82531, 80972, 82604, 82605, 
82534, 80900, 80970, 82603, 82533
28048, 72418, 72441, 72970, 72947, 72419, 72442, 72971, 72948, 80972, 82604, 82605, 82534, 80975, 82607, 82608, 
82537, 80903, 80973, 82606, 82536
28049, 72419, 72442, 72971, 72948, 72420, 72443, 72972, 72949, 80975, 82607, 82608, 82537, 80978, 82610, 82611, 
82540, 80906, 80976, 82609, 82539
28050, 72420, 72443, 72972, 72949, 72421, 72444, 72973, 72950, 80978, 82610, 82611, 82540, 80981, 82613, 82614, 
82543, 80909, 80979, 82612, 82542
28051, 72421, 72444, 72973, 72950, 72422, 72445, 72974, 72951, 80981, 82613, 82614, 82543, 80984, 82616, 82617, 
82546, 80912, 80982, 82615, 82545
28052, 72422, 72445, 72974, 72951, 72423, 72446, 72975, 72952, 80984, 82616, 82617, 82546, 80987, 82619, 82620, 
82549, 80915, 80985, 82618, 82548
28053, 72423, 72446, 72975, 72952, 72424, 72447, 72976, 72953, 80987, 82619, 82620, 82549, 80990, 82622, 82623, 
82552, 80918, 80988, 82621, 82551
28054, 72424, 72447, 72976, 72953, 22893, 22894, 22917, 22916, 80990, 82622, 82623, 82552, 23206, 23252, 23253, 
23250, 80921, 80991, 82624, 82554
28055, 17249, 17250, 17273, 17272, 72425, 72448, 72977, 72954, 17563, 17609, 17610, 17607, 80994, 82626, 82627, 
82556, 80922, 80992, 82625, 82555
28056, 72425, 72448, 72977, 72954, 72426, 72449, 72978, 72955, 80994, 82626, 82627, 82556, 80997, 82629, 82630, 
82559, 80925, 80995, 82628, 82558
28057, 72426, 72449, 72978, 72955, 72427, 72450, 72979, 72956, 80997, 82629, 82630, 82559, 81000, 82632, 82633, 
82562, 80928, 80998, 82631, 82561
28058, 72427, 72450, 72979, 72956, 72428, 72451, 72980, 72957, 81000, 82632, 82633, 82562, 81003, 82635, 82636, 
82565, 80931, 81001, 82634, 82564
28059, 72428, 72451, 72980, 72957, 72429, 72452, 72981, 72958, 81003, 82635, 82636, 82565, 81006, 82638, 82639, 
82568, 80934, 81004, 82637, 82567
28060, 72429, 72452, 72981, 72958, 72430, 72453, 72982, 72959, 81006, 82638, 82639, 82568, 81009, 82641, 82642, 
82571, 80937, 81007, 82640, 82570
28061, 72430, 72453, 72982, 72959, 72431, 72454, 72983, 72960, 81009, 82641, 82642, 82571, 81012, 82644, 82645, 
82574, 80940, 81010, 82643, 82573
28062, 72431, 72454, 72983, 72960, 72432, 72455, 72984, 72961, 81012, 82644, 82645, 82574, 81015, 82647, 82648, 
82577, 80943, 81013, 82646, 82576
28063, 72432, 72455, 72984, 72961, 72433, 72456, 72985, 72962, 81015, 82647, 82648, 82577, 81018, 82650, 82651, 
82580, 80946, 81016, 82649, 82579
28064, 72433, 72456, 72985, 72962, 72434, 72457, 72986, 72963, 81018, 82650, 82651, 82580, 81021, 82653, 82654, 
82583, 80949, 81019, 82652, 82582
28065, 72434, 72457, 72986, 72963, 72435, 72458, 72987, 72964, 81021, 82653, 82654, 82583, 81024, 82656, 82657, 
82586, 80952, 81022, 82655, 82585
28066, 72435, 72458, 72987, 72964, 72436, 72459, 72988, 72965, 81024, 82656, 82657, 82586, 81027, 82659, 82660, 
82589, 80955, 81025, 82658, 82588
28067, 72436, 72459, 72988, 72965, 72437, 72460, 72989, 72966, 81027, 82659, 82660, 82589, 81030, 82662, 82663, 
82592, 80958, 81028, 82661, 82591
28068, 72437, 72460, 72989, 72966, 72438, 72461, 72990, 72967, 81030, 82662, 82663, 82592, 81033, 82665, 82666, 
82595, 80961, 81031, 82664, 82594
28069, 72438, 72461, 72990, 72967, 72439, 72462, 72991, 72968, 81033, 82665, 82666, 82595, 81036, 82668, 82669, 
82598, 80964, 81034, 82667, 82597
28070, 72439, 72462, 72991, 72968, 72440, 72463, 72992, 72969, 81036, 82668, 82669, 82598, 81039, 82671, 82672, 
82601, 80967, 81037, 82670, 82600
28071, 72440, 72463, 72992, 72969, 72441, 72464, 72993, 72970, 81039, 82671, 82672, 82601, 81042, 82674, 82675, 
82604, 80970, 81040, 82673, 82603
28072, 72441, 72464, 72993, 72970, 72442, 72465, 72994, 72971, 81042, 82674, 82675, 82604, 81045, 82677, 82678, 
82607, 80973, 81043, 82676, 82606
28073, 72442, 72465, 72994, 72971, 72443, 72466, 72995, 72972, 81045, 82677, 82678, 82607, 81048, 82680, 82681, 
82610, 80976, 81046, 82679, 82609
28074, 72443, 72466, 72995, 72972, 72444, 72467, 72996, 72973, 81048, 82680, 82681, 82610, 81051, 82683, 82684, 
82613, 80979, 81049, 82682, 82612
28075, 72444, 72467, 72996, 72973, 72445, 72468, 72997, 72974, 81051, 82683, 82684, 82613, 81054, 82686, 82687, 
82616, 80982, 81052, 82685, 82615
28076, 72445, 72468, 72997, 72974, 72446, 72469, 72998, 72975, 81054, 82686, 82687, 82616, 81057, 82689, 82690, 
82619, 80985, 81055, 82688, 82618
28077, 72446, 72469, 72998, 72975, 72447, 72470, 72999, 72976, 81057, 82689, 82690, 82619, 81060, 82692, 82693, 
82622, 80988, 81058, 82691, 82621
28078, 72447, 72470, 72999, 72976, 22894, 22895, 22918, 22917, 81060, 82692, 82693, 82622, 23208, 23254, 23255, 
23252, 80991, 81061, 82694, 82624
28079, 17250, 17251, 17274, 17273, 72448, 72471, 73000, 72977, 17565, 17611, 17612, 17609, 81064, 82696, 82697, 
82626, 80992, 81062, 82695, 82625
28080, 72448, 72471, 73000, 72977, 72449, 72472, 73001, 72978, 81064, 82696, 82697, 82626, 81067, 82699, 82700, 
82629, 80995, 81065, 82698, 82628
28081, 72449, 72472, 73001, 72978, 72450, 72473, 73002, 72979, 81067, 82699, 82700, 82629, 81070, 82702, 82703, 
82632, 80998, 81068, 82701, 82631
28082, 72450, 72473, 73002, 72979, 72451, 72474, 73003, 72980, 81070, 82702, 82703, 82632, 81073, 82705, 82706, 
82635, 81001, 81071, 82704, 82634
28083, 72451, 72474, 73003, 72980, 72452, 72475, 73004, 72981, 81073, 82705, 82706, 82635, 81076, 82708, 82709, 
82638, 81004, 81074, 82707, 82637
28084, 72452, 72475, 73004, 72981, 72453, 72476, 73005, 72982, 81076, 82708, 82709, 82638, 81079, 82711, 82712, 
82641, 81007, 81077, 82710, 82640
28085, 72453, 72476, 73005, 72982, 72454, 72477, 73006, 72983, 81079, 82711, 82712, 82641, 81082, 82714, 82715, 
82644, 81010, 81080, 82713, 82643
28086, 72454, 72477, 73006, 72983, 72455, 72478, 73007, 72984, 81082, 82714, 82715, 82644, 81085, 82717, 82718, 
82647, 81013, 81083, 82716, 82646
28087, 72455, 72478, 73007, 72984, 72456, 72479, 73008, 72985, 81085, 82717, 82718, 82647, 81088, 82720, 82721, 
82650, 81016, 81086, 82719, 82649
28088, 72456, 72479, 73008, 72985, 72457, 72480, 73009, 72986, 81088, 82720, 82721, 82650, 81091, 82723, 82724, 
82653, 81019, 81089, 82722, 82652
28089, 72457, 72480, 73009, 72986, 72458, 72481, 73010, 72987, 81091, 82723, 82724, 82653, 81094, 82726, 82727, 
82656, 81022, 81092, 82725, 82655
28090, 72458, 72481, 73010, 72987, 72459, 72482, 73011, 72988, 81094, 82726, 82727, 82656, 81097, 82729, 82730, 
82659, 81025, 81095, 82728, 82658
28091, 72459, 72482, 73011, 72988, 72460, 72483, 73012, 72989, 81097, 82729, 82730, 82659, 81100, 82732, 82733, 
82662, 81028, 81098, 82731, 82661
28092, 72460, 72483, 73012, 72989, 72461, 72484, 73013, 72990, 81100, 82732, 82733, 82662, 81103, 82735, 82736, 
82665, 81031, 81101, 82734, 82664
28093, 72461, 72484, 73013, 72990, 72462, 72485, 73014, 72991, 81103, 82735, 82736, 82665, 81106, 82738, 82739, 
82668, 81034, 81104, 82737, 82667
28094, 72462, 72485, 73014, 72991, 72463, 72486, 73015, 72992, 81106, 82738, 82739, 82668, 81109, 82741, 82742, 
82671, 81037, 81107, 82740, 82670
28095, 72463, 72486, 73015, 72992, 72464, 72487, 73016, 72993, 81109, 82741, 82742, 82671, 81112, 82744, 82745, 
82674, 81040, 81110, 82743, 82673
28096, 72464, 72487, 73016, 72993, 72465, 72488, 73017, 72994, 81112, 82744, 82745, 82674, 81115, 82747, 82748, 
82677, 81043, 81113, 82746, 82676
28097, 72465, 72488, 73017, 72994, 72466, 72489, 73018, 72995, 81115, 82747, 82748, 82677, 81118, 82750, 82751, 
82680, 81046, 81116, 82749, 82679
28098, 72466, 72489, 73018, 72995, 72467, 72490, 73019, 72996, 81118, 82750, 82751, 82680, 81121, 82753, 82754, 
82683, 81049, 81119, 82752, 82682
28099, 72467, 72490, 73019, 72996, 72468, 72491, 73020, 72997, 81121, 82753, 82754, 82683, 81124, 82756, 82757, 
82686, 81052, 81122, 82755, 82685
28100, 72468, 72491, 73020, 72997, 72469, 72492, 73021, 72998, 81124, 82756, 82757, 82686, 81127, 82759, 82760, 
82689, 81055, 81125, 82758, 82688
28101, 72469, 72492, 73021, 72998, 72470, 72493, 73022, 72999, 81127, 82759, 82760, 82689, 81130, 82762, 82763, 
82692, 81058, 81128, 82761, 82691
28102, 72470, 72493, 73022, 72999, 22895, 22896, 22919, 22918, 81130, 82762, 82763, 82692, 23210, 23256, 23257, 
23254, 81061, 81131, 82764, 82694
28103, 17251, 17252, 17275, 17274, 72471, 72494, 73023, 73000, 17567, 17613, 17614, 17611, 81134, 82766, 82767, 
82696, 81062, 81132, 82765, 82695
28104, 72471, 72494, 73023, 73000, 72472, 72495, 73024, 73001, 81134, 82766, 82767, 82696, 81137, 82769, 82770, 
82699, 81065, 81135, 82768, 82698
28105, 72472, 72495, 73024, 73001, 72473, 72496, 73025, 73002, 81137, 82769, 82770, 82699, 81140, 82772, 82773, 
82702, 81068, 81138, 82771, 82701
28106, 72473, 72496, 73025, 73002, 72474, 72497, 73026, 73003, 81140, 82772, 82773, 82702, 81143, 82775, 82776, 
82705, 81071, 81141, 82774, 82704
28107, 72474, 72497, 73026, 73003, 72475, 72498, 73027, 73004, 81143, 82775, 82776, 82705, 81146, 82778, 82779, 
82708, 81074, 81144, 82777, 82707
28108, 72475, 72498, 73027, 73004, 72476, 72499, 73028, 73005, 81146, 82778, 82779, 82708, 81149, 82781, 82782, 
82711, 81077, 81147, 82780, 82710
28109, 72476, 72499, 73028, 73005, 72477, 72500, 73029, 73006, 81149, 82781, 82782, 82711, 81152, 82784, 82785, 
82714, 81080, 81150, 82783, 82713
28110, 72477, 72500, 73029, 73006, 72478, 72501, 73030, 73007, 81152, 82784, 82785, 82714, 81155, 82787, 82788, 
82717, 81083, 81153, 82786, 82716
28111, 72478, 72501, 73030, 73007, 72479, 72502, 73031, 73008, 81155, 82787, 82788, 82717, 81158, 82790, 82791, 
82720, 81086, 81156, 82789, 82719
28112, 72479, 72502, 73031, 73008, 72480, 72503, 73032, 73009, 81158, 82790, 82791, 82720, 81161, 82793, 82794, 
82723, 81089, 81159, 82792, 82722
28113, 72480, 72503, 73032, 73009, 72481, 72504, 73033, 73010, 81161, 82793, 82794, 82723, 81164, 82796, 82797, 
82726, 81092, 81162, 82795, 82725
28114, 72481, 72504, 73033, 73010, 72482, 72505, 73034, 73011, 81164, 82796, 82797, 82726, 81167, 82799, 82800, 
82729, 81095, 81165, 82798, 82728
28115, 72482, 72505, 73034, 73011, 72483, 72506, 73035, 73012, 81167, 82799, 82800, 82729, 81170, 82802, 82803, 
82732, 81098, 81168, 82801, 82731
28116, 72483, 72506, 73035, 73012, 72484, 72507, 73036, 73013, 81170, 82802, 82803, 82732, 81173, 82805, 82806, 
82735, 81101, 81171, 82804, 82734
28117, 72484, 72507, 73036, 73013, 72485, 72508, 73037, 73014, 81173, 82805, 82806, 82735, 81176, 82808, 82809, 
82738, 81104, 81174, 82807, 82737
28118, 72485, 72508, 73037, 73014, 72486, 72509, 73038, 73015, 81176, 82808, 82809, 82738, 81179, 82811, 82812, 
82741, 81107, 81177, 82810, 82740
28119, 72486, 72509, 73038, 73015, 72487, 72510, 73039, 73016, 81179, 82811, 82812, 82741, 81182, 82814, 82815, 
82744, 81110, 81180, 82813, 82743
28120, 72487, 72510, 73039, 73016, 72488, 72511, 73040, 73017, 81182, 82814, 82815, 82744, 81185, 82817, 82818, 
82747, 81113, 81183, 82816, 82746
28121, 72488, 72511, 73040, 73017, 72489, 72512, 73041, 73018, 81185, 82817, 82818, 82747, 81188, 82820, 82821, 
82750, 81116, 81186, 82819, 82749
28122, 72489, 72512, 73041, 73018, 72490, 72513, 73042, 73019, 81188, 82820, 82821, 82750, 81191, 82823, 82824, 
82753, 81119, 81189, 82822, 82752
28123, 72490, 72513, 73042, 73019, 72491, 72514, 73043, 73020, 81191, 82823, 82824, 82753, 81194, 82826, 82827, 
82756, 81122, 81192, 82825, 82755
28124, 72491, 72514, 73043, 73020, 72492, 72515, 73044, 73021, 81194, 82826, 82827, 82756, 81197, 82829, 82830, 
82759, 81125, 81195, 82828, 82758
28125, 72492, 72515, 73044, 73021, 72493, 72516, 73045, 73022, 81197, 82829, 82830, 82759, 81200, 82832, 82833, 
82762, 81128, 81198, 82831, 82761
28126, 72493, 72516, 73045, 73022, 22896, 22897, 22920, 22919, 81200, 82832, 82833, 82762, 23212, 23258, 23259, 
23256, 81131, 81201, 82834, 82764
28127, 17252, 17253, 17276, 17275, 72494, 72517, 73046, 73023, 17569, 17615, 17616, 17613, 81204, 82836, 82837, 
82766, 81132, 81202, 82835, 82765
28128, 72494, 72517, 73046, 73023, 72495, 72518, 73047, 73024, 81204, 82836, 82837, 82766, 81207, 82839, 82840, 
82769, 81135, 81205, 82838, 82768
28129, 72495, 72518, 73047, 73024, 72496, 72519, 73048, 73025, 81207, 82839, 82840, 82769, 81210, 82842, 82843, 
82772, 81138, 81208, 82841, 82771
28130, 72496, 72519, 73048, 73025, 72497, 72520, 73049, 73026, 81210, 82842, 82843, 82772, 81213, 82845, 82846, 
82775, 81141, 81211, 82844, 82774
28131, 72497, 72520, 73049, 73026, 72498, 72521, 73050, 73027, 81213, 82845, 82846, 82775, 81216, 82848, 82849, 
82778, 81144, 81214, 82847, 82777
28132, 72498, 72521, 73050, 73027, 72499, 72522, 73051, 73028, 81216, 82848, 82849, 82778, 81219, 82851, 82852, 
82781, 81147, 81217, 82850, 82780
28133, 72499, 72522, 73051, 73028, 72500, 72523, 73052, 73029, 81219, 82851, 82852, 82781, 81222, 82854, 82855, 
82784, 81150, 81220, 82853, 82783
28134, 72500, 72523, 73052, 73029, 72501, 72524, 73053, 73030, 81222, 82854, 82855, 82784, 81225, 82857, 82858, 
82787, 81153, 81223, 82856, 82786
28135, 72501, 72524, 73053, 73030, 72502, 72525, 73054, 73031, 81225, 82857, 82858, 82787, 81228, 82860, 82861, 
82790, 81156, 81226, 82859, 82789
28136, 72502, 72525, 73054, 73031, 72503, 72526, 73055, 73032, 81228, 82860, 82861, 82790, 81231, 82863, 82864, 
82793, 81159, 81229, 82862, 82792
28137, 72503, 72526, 73055, 73032, 72504, 72527, 73056, 73033, 81231, 82863, 82864, 82793, 81234, 82866, 82867, 
82796, 81162, 81232, 82865, 82795
28138, 72504, 72527, 73056, 73033, 72505, 72528, 73057, 73034, 81234, 82866, 82867, 82796, 81237, 82869, 82870, 
82799, 81165, 81235, 82868, 82798
28139, 72505, 72528, 73057, 73034, 72506, 72529, 73058, 73035, 81237, 82869, 82870, 82799, 81240, 82872, 82873, 
82802, 81168, 81238, 82871, 82801
28140, 72506, 72529, 73058, 73035, 72507, 72530, 73059, 73036, 81240, 82872, 82873, 82802, 81243, 82875, 82876, 
82805, 81171, 81241, 82874, 82804
28141, 72507, 72530, 73059, 73036, 72508, 72531, 73060, 73037, 81243, 82875, 82876, 82805, 81246, 82878, 82879, 
82808, 81174, 81244, 82877, 82807
28142, 72508, 72531, 73060, 73037, 72509, 72532, 73061, 73038, 81246, 82878, 82879, 82808, 81249, 82881, 82882, 
82811, 81177, 81247, 82880, 82810
28143, 72509, 72532, 73061, 73038, 72510, 72533, 73062, 73039, 81249, 82881, 82882, 82811, 81252, 82884, 82885, 
82814, 81180, 81250, 82883, 82813
28144, 72510, 72533, 73062, 73039, 72511, 72534, 73063, 73040, 81252, 82884, 82885, 82814, 81255, 82887, 82888, 
82817, 81183, 81253, 82886, 82816
28145, 72511, 72534, 73063, 73040, 72512, 72535, 73064, 73041, 81255, 82887, 82888, 82817, 81258, 82890, 82891, 
82820, 81186, 81256, 82889, 82819
28146, 72512, 72535, 73064, 73041, 72513, 72536, 73065, 73042, 81258, 82890, 82891, 82820, 81261, 82893, 82894, 
82823, 81189, 81259, 82892, 82822
28147, 72513, 72536, 73065, 73042, 72514, 72537, 73066, 73043, 81261, 82893, 82894, 82823, 81264, 82896, 82897, 
82826, 81192, 81262, 82895, 82825
28148, 72514, 72537, 73066, 73043, 72515, 72538, 73067, 73044, 81264, 82896, 82897, 82826, 81267, 82899, 82900, 
82829, 81195, 81265, 82898, 82828
28149, 72515, 72538, 73067, 73044, 72516, 72539, 73068, 73045, 81267, 82899, 82900, 82829, 81270, 82902, 82903, 
82832, 81198, 81268, 82901, 82831
28150, 72516, 72539, 73068, 73045, 22897, 22898, 22921, 22920, 81270, 82902, 82903, 82832, 23214, 23260, 23261, 
23258, 81201, 81271, 82904, 82834
28151, 17253, 17254, 17277, 17276, 72517, 72540, 73069, 73046, 17571, 17617, 17618, 17615, 81274, 82906, 82907, 
82836, 81202, 81272, 82905, 82835
28152, 72517, 72540, 73069, 73046, 72518, 72541, 73070, 73047, 81274, 82906, 82907, 82836, 81277, 82909, 82910, 
82839, 81205, 81275, 82908, 82838
28153, 72518, 72541, 73070, 73047, 72519, 72542, 73071, 73048, 81277, 82909, 82910, 82839, 81280, 82912, 82913, 
82842, 81208, 81278, 82911, 82841
28154, 72519, 72542, 73071, 73048, 72520, 72543, 73072, 73049, 81280, 82912, 82913, 82842, 81283, 82915, 82916, 
82845, 81211, 81281, 82914, 82844
28155, 72520, 72543, 73072, 73049, 72521, 72544, 73073, 73050, 81283, 82915, 82916, 82845, 81286, 82918, 82919, 
82848, 81214, 81284, 82917, 82847
28156, 72521, 72544, 73073, 73050, 72522, 72545, 73074, 73051, 81286, 82918, 82919, 82848, 81289, 82921, 82922, 
82851, 81217, 81287, 82920, 82850
28157, 72522, 72545, 73074, 73051, 72523, 72546, 73075, 73052, 81289, 82921, 82922, 82851, 81292, 82924, 82925, 
82854, 81220, 81290, 82923, 82853
28158, 72523, 72546, 73075, 73052, 72524, 72547, 73076, 73053, 81292, 82924, 82925, 82854, 81295, 82927, 82928, 
82857, 81223, 81293, 82926, 82856
28159, 72524, 72547, 73076, 73053, 72525, 72548, 73077, 73054, 81295, 82927, 82928, 82857, 81298, 82930, 82931, 
82860, 81226, 81296, 82929, 82859
28160, 72525, 72548, 73077, 73054, 72526, 72549, 73078, 73055, 81298, 82930, 82931, 82860, 81301, 82933, 82934, 
82863, 81229, 81299, 82932, 82862
28161, 72526, 72549, 73078, 73055, 72527, 72550, 73079, 73056, 81301, 82933, 82934, 82863, 81304, 82936, 82937, 
82866, 81232, 81302, 82935, 82865
28162, 72527, 72550, 73079, 73056, 72528, 72551, 73080, 73057, 81304, 82936, 82937, 82866, 81307, 82939, 82940, 
82869, 81235, 81305, 82938, 82868
28163, 72528, 72551, 73080, 73057, 72529, 72552, 73081, 73058, 81307, 82939, 82940, 82869, 81310, 82942, 82943, 
82872, 81238, 81308, 82941, 82871
28164, 72529, 72552, 73081, 73058, 72530, 72553, 73082, 73059, 81310, 82942, 82943, 82872, 81313, 82945, 82946, 
82875, 81241, 81311, 82944, 82874
28165, 72530, 72553, 73082, 73059, 72531, 72554, 73083, 73060, 81313, 82945, 82946, 82875, 81316, 82948, 82949, 
82878, 81244, 81314, 82947, 82877
28166, 72531, 72554, 73083, 73060, 72532, 72555, 73084, 73061, 81316, 82948, 82949, 82878, 81319, 82951, 82952, 
82881, 81247, 81317, 82950, 82880
28167, 72532, 72555, 73084, 73061, 72533, 72556, 73085, 73062, 81319, 82951, 82952, 82881, 81322, 82954, 82955, 
82884, 81250, 81320, 82953, 82883
28168, 72533, 72556, 73085, 73062, 72534, 72557, 73086, 73063, 81322, 82954, 82955, 82884, 81325, 82957, 82958, 
82887, 81253, 81323, 82956, 82886
28169, 72534, 72557, 73086, 73063, 72535, 72558, 73087, 73064, 81325, 82957, 82958, 82887, 81328, 82960, 82961, 
82890, 81256, 81326, 82959, 82889
28170, 72535, 72558, 73087, 73064, 72536, 72559, 73088, 73065, 81328, 82960, 82961, 82890, 81331, 82963, 82964, 
82893, 81259, 81329, 82962, 82892
28171, 72536, 72559, 73088, 73065, 72537, 72560, 73089, 73066, 81331, 82963, 82964, 82893, 81334, 82966, 82967, 
82896, 81262, 81332, 82965, 82895
28172, 72537, 72560, 73089, 73066, 72538, 72561, 73090, 73067, 81334, 82966, 82967, 82896, 81337, 82969, 82970, 
82899, 81265, 81335, 82968, 82898
28173, 72538, 72561, 73090, 73067, 72539, 72562, 73091, 73068, 81337, 82969, 82970, 82899, 81340, 82972, 82973, 
82902, 81268, 81338, 82971, 82901
28174, 72539, 72562, 73091, 73068, 22898, 22899, 22922, 22921, 81340, 82972, 82973, 82902, 23216, 23262, 23263, 
23260, 81271, 81341, 82974, 82904
28175, 17254, 17255, 17278, 17277, 72540, 72563, 73092, 73069, 17573, 17619, 17620, 17617, 81344, 82976, 82977, 
82906, 81272, 81342, 82975, 82905
28176, 72540, 72563, 73092, 73069, 72541, 72564, 73093, 73070, 81344, 82976, 82977, 82906, 81347, 82979, 82980, 
82909, 81275, 81345, 82978, 82908
28177, 72541, 72564, 73093, 73070, 72542, 72565, 73094, 73071, 81347, 82979, 82980, 82909, 81350, 82982, 82983, 
82912, 81278, 81348, 82981, 82911
28178, 72542, 72565, 73094, 73071, 72543, 72566, 73095, 73072, 81350, 82982, 82983, 82912, 81353, 82985, 82986, 
82915, 81281, 81351, 82984, 82914
28179, 72543, 72566, 73095, 73072, 72544, 72567, 73096, 73073, 81353, 82985, 82986, 82915, 81356, 82988, 82989, 
82918, 81284, 81354, 82987, 82917
28180, 72544, 72567, 73096, 73073, 72545, 72568, 73097, 73074, 81356, 82988, 82989, 82918, 81359, 82991, 82992, 
82921, 81287, 81357, 82990, 82920
28181, 72545, 72568, 73097, 73074, 72546, 72569, 73098, 73075, 81359, 82991, 82992, 82921, 81362, 82994, 82995, 
82924, 81290, 81360, 82993, 82923
28182, 72546, 72569, 73098, 73075, 72547, 72570, 73099, 73076, 81362, 82994, 82995, 82924, 81365, 82997, 82998, 
82927, 81293, 81363, 82996, 82926
28183, 72547, 72570, 73099, 73076, 72548, 72571, 73100, 73077, 81365, 82997, 82998, 82927, 81368, 83000, 83001, 
82930, 81296, 81366, 82999, 82929
28184, 72548, 72571, 73100, 73077, 72549, 72572, 73101, 73078, 81368, 83000, 83001, 82930, 81371, 83003, 83004, 
82933, 81299, 81369, 83002, 82932
28185, 72549, 72572, 73101, 73078, 72550, 72573, 73102, 73079, 81371, 83003, 83004, 82933, 81374, 83006, 83007, 
82936, 81302, 81372, 83005, 82935
28186, 72550, 72573, 73102, 73079, 72551, 72574, 73103, 73080, 81374, 83006, 83007, 82936, 81377, 83009, 83010, 
82939, 81305, 81375, 83008, 82938
28187, 72551, 72574, 73103, 73080, 72552, 72575, 73104, 73081, 81377, 83009, 83010, 82939, 81380, 83012, 83013, 
82942, 81308, 81378, 83011, 82941
28188, 72552, 72575, 73104, 73081, 72553, 72576, 73105, 73082, 81380, 83012, 83013, 82942, 81383, 83015, 83016, 
82945, 81311, 81381, 83014, 82944
28189, 72553, 72576, 73105, 73082, 72554, 72577, 73106, 73083, 81383, 83015, 83016, 82945, 81386, 83018, 83019, 
82948, 81314, 81384, 83017, 82947
28190, 72554, 72577, 73106, 73083, 72555, 72578, 73107, 73084, 81386, 83018, 83019, 82948, 81389, 83021, 83022, 
82951, 81317, 81387, 83020, 82950
28191, 72555, 72578, 73107, 73084, 72556, 72579, 73108, 73085, 81389, 83021, 83022, 82951, 81392, 83024, 83025, 
82954, 81320, 81390, 83023, 82953
28192, 72556, 72579, 73108, 73085, 72557, 72580, 73109, 73086, 81392, 83024, 83025, 82954, 81395, 83027, 83028, 
82957, 81323, 81393, 83026, 82956
28193, 72557, 72580, 73109, 73086, 72558, 72581, 73110, 73087, 81395, 83027, 83028, 82957, 81398, 83030, 83031, 
82960, 81326, 81396, 83029, 82959
28194, 72558, 72581, 73110, 73087, 72559, 72582, 73111, 73088, 81398, 83030, 83031, 82960, 81401, 83033, 83034, 
82963, 81329, 81399, 83032, 82962
28195, 72559, 72582, 73111, 73088, 72560, 72583, 73112, 73089, 81401, 83033, 83034, 82963, 81404, 83036, 83037, 
82966, 81332, 81402, 83035, 82965
28196, 72560, 72583, 73112, 73089, 72561, 72584, 73113, 73090, 81404, 83036, 83037, 82966, 81407, 83039, 83040, 
82969, 81335, 81405, 83038, 82968
28197, 72561, 72584, 73113, 73090, 72562, 72585, 73114, 73091, 81407, 83039, 83040, 82969, 81410, 83042, 83043, 
82972, 81338, 81408, 83041, 82971
28198, 72562, 72585, 73114, 73091, 22899, 22900, 22923, 22922, 81410, 83042, 83043, 82972, 23218, 23264, 23265, 
23262, 81341, 81411, 83044, 82974
28199, 17255, 17256, 17279, 17278, 72563, 72586, 73115, 73092, 17575, 17621, 17622, 17619, 81414, 83046, 83047, 
82976, 81342, 81412, 83045, 82975
28200, 72563, 72586, 73115, 73092, 72564, 72587, 73116, 73093, 81414, 83046, 83047, 82976, 81417, 83049, 83050, 
82979, 81345, 81415, 83048, 82978
28201, 72564, 72587, 73116, 73093, 72565, 72588, 73117, 73094, 81417, 83049, 83050, 82979, 81420, 83052, 83053, 
82982, 81348, 81418, 83051, 82981
28202, 72565, 72588, 73117, 73094, 72566, 72589, 73118, 73095, 81420, 83052, 83053, 82982, 81423, 83055, 83056, 
82985, 81351, 81421, 83054, 82984
28203, 72566, 72589, 73118, 73095, 72567, 72590, 73119, 73096, 81423, 83055, 83056, 82985, 81426, 83058, 83059, 
82988, 81354, 81424, 83057, 82987
28204, 72567, 72590, 73119, 73096, 72568, 72591, 73120, 73097, 81426, 83058, 83059, 82988, 81429, 83061, 83062, 
82991, 81357, 81427, 83060, 82990
28205, 72568, 72591, 73120, 73097, 72569, 72592, 73121, 73098, 81429, 83061, 83062, 82991, 81432, 83064, 83065, 
82994, 81360, 81430, 83063, 82993
28206, 72569, 72592, 73121, 73098, 72570, 72593, 73122, 73099, 81432, 83064, 83065, 82994, 81435, 83067, 83068, 
82997, 81363, 81433, 83066, 82996
28207, 72570, 72593, 73122, 73099, 72571, 72594, 73123, 73100, 81435, 83067, 83068, 82997, 81438, 83070, 83071, 
83000, 81366, 81436, 83069, 82999
28208, 72571, 72594, 73123, 73100, 72572, 72595, 73124, 73101, 81438, 83070, 83071, 83000, 81441, 83073, 83074, 
83003, 81369, 81439, 83072, 83002
28209, 72572, 72595, 73124, 73101, 72573, 72596, 73125, 73102, 81441, 83073, 83074, 83003, 81444, 83076, 83077, 
83006, 81372, 81442, 83075, 83005
28210, 72573, 72596, 73125, 73102, 72574, 72597, 73126, 73103, 81444, 83076, 83077, 83006, 81447, 83079, 83080, 
83009, 81375, 81445, 83078, 83008
28211, 72574, 72597, 73126, 73103, 72575, 72598, 73127, 73104, 81447, 83079, 83080, 83009, 81450, 83082, 83083, 
83012, 81378, 81448, 83081, 83011
28212, 72575, 72598, 73127, 73104, 72576, 72599, 73128, 73105, 81450, 83082, 83083, 83012, 81453, 83085, 83086, 
83015, 81381, 81451, 83084, 83014
28213, 72576, 72599, 73128, 73105, 72577, 72600, 73129, 73106, 81453, 83085, 83086, 83015, 81456, 83088, 83089, 
83018, 81384, 81454, 83087, 83017
28214, 72577, 72600, 73129, 73106, 72578, 72601, 73130, 73107, 81456, 83088, 83089, 83018, 81459, 83091, 83092, 
83021, 81387, 81457, 83090, 83020
28215, 72578, 72601, 73130, 73107, 72579, 72602, 73131, 73108, 81459, 83091, 83092, 83021, 81462, 83094, 83095, 
83024, 81390, 81460, 83093, 83023
28216, 72579, 72602, 73131, 73108, 72580, 72603, 73132, 73109, 81462, 83094, 83095, 83024, 81465, 83097, 83098, 
83027, 81393, 81463, 83096, 83026
28217, 72580, 72603, 73132, 73109, 72581, 72604, 73133, 73110, 81465, 83097, 83098, 83027, 81468, 83100, 83101, 
83030, 81396, 81466, 83099, 83029
28218, 72581, 72604, 73133, 73110, 72582, 72605, 73134, 73111, 81468, 83100, 83101, 83030, 81471, 83103, 83104, 
83033, 81399, 81469, 83102, 83032
28219, 72582, 72605, 73134, 73111, 72583, 72606, 73135, 73112, 81471, 83103, 83104, 83033, 81474, 83106, 83107, 
83036, 81402, 81472, 83105, 83035
28220, 72583, 72606, 73135, 73112, 72584, 72607, 73136, 73113, 81474, 83106, 83107, 83036, 81477, 83109, 83110, 
83039, 81405, 81475, 83108, 83038
28221, 72584, 72607, 73136, 73113, 72585, 72608, 73137, 73114, 81477, 83109, 83110, 83039, 81480, 83112, 83113, 
83042, 81408, 81478, 83111, 83041
28222, 72585, 72608, 73137, 73114, 22900, 22901, 22924, 22923, 81480, 83112, 83113, 83042, 23220, 23266, 23267, 
23264, 81411, 81481, 83114, 83044
28223, 17256, 17257, 17280, 17279, 72586, 72609, 73138, 73115, 17577, 17623, 17624, 17621, 81484, 83116, 83117, 
83046, 81412, 81482, 83115, 83045
28224, 72586, 72609, 73138, 73115, 72587, 72610, 73139, 73116, 81484, 83116, 83117, 83046, 81487, 83119, 83120, 
83049, 81415, 81485, 83118, 83048
28225, 72587, 72610, 73139, 73116, 72588, 72611, 73140, 73117, 81487, 83119, 83120, 83049, 81490, 83122, 83123, 
83052, 81418, 81488, 83121, 83051
28226, 72588, 72611, 73140, 73117, 72589, 72612, 73141, 73118, 81490, 83122, 83123, 83052, 81493, 83125, 83126, 
83055, 81421, 81491, 83124, 83054
28227, 72589, 72612, 73141, 73118, 72590, 72613, 73142, 73119, 81493, 83125, 83126, 83055, 81496, 83128, 83129, 
83058, 81424, 81494, 83127, 83057
28228, 72590, 72613, 73142, 73119, 72591, 72614, 73143, 73120, 81496, 83128, 83129, 83058, 81499, 83131, 83132, 
83061, 81427, 81497, 83130, 83060
28229, 72591, 72614, 73143, 73120, 72592, 72615, 73144, 73121, 81499, 83131, 83132, 83061, 81502, 83134, 83135, 
83064, 81430, 81500, 83133, 83063
28230, 72592, 72615, 73144, 73121, 72593, 72616, 73145, 73122, 81502, 83134, 83135, 83064, 81505, 83137, 83138, 
83067, 81433, 81503, 83136, 83066
28231, 72593, 72616, 73145, 73122, 72594, 72617, 73146, 73123, 81505, 83137, 83138, 83067, 81508, 83140, 83141, 
83070, 81436, 81506, 83139, 83069
28232, 72594, 72617, 73146, 73123, 72595, 72618, 73147, 73124, 81508, 83140, 83141, 83070, 81511, 83143, 83144, 
83073, 81439, 81509, 83142, 83072
28233, 72595, 72618, 73147, 73124, 72596, 72619, 73148, 73125, 81511, 83143, 83144, 83073, 81514, 83146, 83147, 
83076, 81442, 81512, 83145, 83075
28234, 72596, 72619, 73148, 73125, 72597, 72620, 73149, 73126, 81514, 83146, 83147, 83076, 81517, 83149, 83150, 
83079, 81445, 81515, 83148, 83078
28235, 72597, 72620, 73149, 73126, 72598, 72621, 73150, 73127, 81517, 83149, 83150, 83079, 81520, 83152, 83153, 
83082, 81448, 81518, 83151, 83081
28236, 72598, 72621, 73150, 73127, 72599, 72622, 73151, 73128, 81520, 83152, 83153, 83082, 81523, 83155, 83156, 
83085, 81451, 81521, 83154, 83084
28237, 72599, 72622, 73151, 73128, 72600, 72623, 73152, 73129, 81523, 83155, 83156, 83085, 81526, 83158, 83159, 
83088, 81454, 81524, 83157, 83087
28238, 72600, 72623, 73152, 73129, 72601, 72624, 73153, 73130, 81526, 83158, 83159, 83088, 81529, 83161, 83162, 
83091, 81457, 81527, 83160, 83090
28239, 72601, 72624, 73153, 73130, 72602, 72625, 73154, 73131, 81529, 83161, 83162, 83091, 81532, 83164, 83165, 
83094, 81460, 81530, 83163, 83093
28240, 72602, 72625, 73154, 73131, 72603, 72626, 73155, 73132, 81532, 83164, 83165, 83094, 81535, 83167, 83168, 
83097, 81463, 81533, 83166, 83096
28241, 72603, 72626, 73155, 73132, 72604, 72627, 73156, 73133, 81535, 83167, 83168, 83097, 81538, 83170, 83171, 
83100, 81466, 81536, 83169, 83099
28242, 72604, 72627, 73156, 73133, 72605, 72628, 73157, 73134, 81538, 83170, 83171, 83100, 81541, 83173, 83174, 
83103, 81469, 81539, 83172, 83102
28243, 72605, 72628, 73157, 73134, 72606, 72629, 73158, 73135, 81541, 83173, 83174, 83103, 81544, 83176, 83177, 
83106, 81472, 81542, 83175, 83105
28244, 72606, 72629, 73158, 73135, 72607, 72630, 73159, 73136, 81544, 83176, 83177, 83106, 81547, 83179, 83180, 
83109, 81475, 81545, 83178, 83108
28245, 72607, 72630, 73159, 73136, 72608, 72631, 73160, 73137, 81547, 83179, 83180, 83109, 81550, 83182, 83183, 
83112, 81478, 81548, 83181, 83111
28246, 72608, 72631, 73160, 73137, 22901, 22902, 22925, 22924, 81550, 83182, 83183, 83112, 23222, 23268, 23269, 
23266, 81481, 81551, 83184, 83114
28247, 17257, 17258, 17281, 17280, 72609, 72632, 73161, 73138, 17579, 17625, 17626, 17623, 81554, 83186, 83187, 
83116, 81482, 81552, 83185, 83115
28248, 72609, 72632, 73161, 73138, 72610, 72633, 73162, 73139, 81554, 83186, 83187, 83116, 81557, 83189, 83190, 
83119, 81485, 81555, 83188, 83118
28249, 72610, 72633, 73162, 73139, 72611, 72634, 73163, 73140, 81557, 83189, 83190, 83119, 81560, 83192, 83193, 
83122, 81488, 81558, 83191, 83121
28250, 72611, 72634, 73163, 73140, 72612, 72635, 73164, 73141, 81560, 83192, 83193, 83122, 81563, 83195, 83196, 
83125, 81491, 81561, 83194, 83124
28251, 72612, 72635, 73164, 73141, 72613, 72636, 73165, 73142, 81563, 83195, 83196, 83125, 81566, 83198, 83199, 
83128, 81494, 81564, 83197, 83127
28252, 72613, 72636, 73165, 73142, 72614, 72637, 73166, 73143, 81566, 83198, 83199, 83128, 81569, 83201, 83202, 
83131, 81497, 81567, 83200, 83130
28253, 72614, 72637, 73166, 73143, 72615, 72638, 73167, 73144, 81569, 83201, 83202, 83131, 81572, 83204, 83205, 
83134, 81500, 81570, 83203, 83133
28254, 72615, 72638, 73167, 73144, 72616, 72639, 73168, 73145, 81572, 83204, 83205, 83134, 81575, 83207, 83208, 
83137, 81503, 81573, 83206, 83136
28255, 72616, 72639, 73168, 73145, 72617, 72640, 73169, 73146, 81575, 83207, 83208, 83137, 81578, 83210, 83211, 
83140, 81506, 81576, 83209, 83139
28256, 72617, 72640, 73169, 73146, 72618, 72641, 73170, 73147, 81578, 83210, 83211, 83140, 81581, 83213, 83214, 
83143, 81509, 81579, 83212, 83142
28257, 72618, 72641, 73170, 73147, 72619, 72642, 73171, 73148, 81581, 83213, 83214, 83143, 81584, 83216, 83217, 
83146, 81512, 81582, 83215, 83145
28258, 72619, 72642, 73171, 73148, 72620, 72643, 73172, 73149, 81584, 83216, 83217, 83146, 81587, 83219, 83220, 
83149, 81515, 81585, 83218, 83148
28259, 72620, 72643, 73172, 73149, 72621, 72644, 73173, 73150, 81587, 83219, 83220, 83149, 81590, 83222, 83223, 
83152, 81518, 81588, 83221, 83151
28260, 72621, 72644, 73173, 73150, 72622, 72645, 73174, 73151, 81590, 83222, 83223, 83152, 81593, 83225, 83226, 
83155, 81521, 81591, 83224, 83154
28261, 72622, 72645, 73174, 73151, 72623, 72646, 73175, 73152, 81593, 83225, 83226, 83155, 81596, 83228, 83229, 
83158, 81524, 81594, 83227, 83157
28262, 72623, 72646, 73175, 73152, 72624, 72647, 73176, 73153, 81596, 83228, 83229, 83158, 81599, 83231, 83232, 
83161, 81527, 81597, 83230, 83160
28263, 72624, 72647, 73176, 73153, 72625, 72648, 73177, 73154, 81599, 83231, 83232, 83161, 81602, 83234, 83235, 
83164, 81530, 81600, 83233, 83163
28264, 72625, 72648, 73177, 73154, 72626, 72649, 73178, 73155, 81602, 83234, 83235, 83164, 81605, 83237, 83238, 
83167, 81533, 81603, 83236, 83166
28265, 72626, 72649, 73178, 73155, 72627, 72650, 73179, 73156, 81605, 83237, 83238, 83167, 81608, 83240, 83241, 
83170, 81536, 81606, 83239, 83169
28266, 72627, 72650, 73179, 73156, 72628, 72651, 73180, 73157, 81608, 83240, 83241, 83170, 81611, 83243, 83244, 
83173, 81539, 81609, 83242, 83172
28267, 72628, 72651, 73180, 73157, 72629, 72652, 73181, 73158, 81611, 83243, 83244, 83173, 81614, 83246, 83247, 
83176, 81542, 81612, 83245, 83175
28268, 72629, 72652, 73181, 73158, 72630, 72653, 73182, 73159, 81614, 83246, 83247, 83176, 81617, 83249, 83250, 
83179, 81545, 81615, 83248, 83178
28269, 72630, 72653, 73182, 73159, 72631, 72654, 73183, 73160, 81617, 83249, 83250, 83179, 81620, 83252, 83253, 
83182, 81548, 81618, 83251, 83181
28270, 72631, 72654, 73183, 73160, 22902, 22903, 22926, 22925, 81620, 83252, 83253, 83182, 23224, 23270, 23271, 
23268, 81551, 81621, 83254, 83184
28271, 17258, 17259, 17282, 17281, 72632, 72655, 73184, 73161, 17581, 17627, 17628, 17625, 81624, 83256, 83257, 
83186, 81552, 81622, 83255, 83185
28272, 72632, 72655, 73184, 73161, 72633, 72656, 73185, 73162, 81624, 83256, 83257, 83186, 81627, 83259, 83260, 
83189, 81555, 81625, 83258, 83188
28273, 72633, 72656, 73185, 73162, 72634, 72657, 73186, 73163, 81627, 83259, 83260, 83189, 81630, 83262, 83263, 
83192, 81558, 81628, 83261, 83191
28274, 72634, 72657, 73186, 73163, 72635, 72658, 73187, 73164, 81630, 83262, 83263, 83192, 81633, 83265, 83266, 
83195, 81561, 81631, 83264, 83194
28275, 72635, 72658, 73187, 73164, 72636, 72659, 73188, 73165, 81633, 83265, 83266, 83195, 81636, 83268, 83269, 
83198, 81564, 81634, 83267, 83197
28276, 72636, 72659, 73188, 73165, 72637, 72660, 73189, 73166, 81636, 83268, 83269, 83198, 81639, 83271, 83272, 
83201, 81567, 81637, 83270, 83200
28277, 72637, 72660, 73189, 73166, 72638, 72661, 73190, 73167, 81639, 83271, 83272, 83201, 81642, 83274, 83275, 
83204, 81570, 81640, 83273, 83203
28278, 72638, 72661, 73190, 73167, 72639, 72662, 73191, 73168, 81642, 83274, 83275, 83204, 81645, 83277, 83278, 
83207, 81573, 81643, 83276, 83206
28279, 72639, 72662, 73191, 73168, 72640, 72663, 73192, 73169, 81645, 83277, 83278, 83207, 81648, 83280, 83281, 
83210, 81576, 81646, 83279, 83209
28280, 72640, 72663, 73192, 73169, 72641, 72664, 73193, 73170, 81648, 83280, 83281, 83210, 81651, 83283, 83284, 
83213, 81579, 81649, 83282, 83212
28281, 72641, 72664, 73193, 73170, 72642, 72665, 73194, 73171, 81651, 83283, 83284, 83213, 81654, 83286, 83287, 
83216, 81582, 81652, 83285, 83215
28282, 72642, 72665, 73194, 73171, 72643, 72666, 73195, 73172, 81654, 83286, 83287, 83216, 81657, 83289, 83290, 
83219, 81585, 81655, 83288, 83218
28283, 72643, 72666, 73195, 73172, 72644, 72667, 73196, 73173, 81657, 83289, 83290, 83219, 81660, 83292, 83293, 
83222, 81588, 81658, 83291, 83221
28284, 72644, 72667, 73196, 73173, 72645, 72668, 73197, 73174, 81660, 83292, 83293, 83222, 81663, 83295, 83296, 
83225, 81591, 81661, 83294, 83224
28285, 72645, 72668, 73197, 73174, 72646, 72669, 73198, 73175, 81663, 83295, 83296, 83225, 81666, 83298, 83299, 
83228, 81594, 81664, 83297, 83227
28286, 72646, 72669, 73198, 73175, 72647, 72670, 73199, 73176, 81666, 83298, 83299, 83228, 81669, 83301, 83302, 
83231, 81597, 81667, 83300, 83230
28287, 72647, 72670, 73199, 73176, 72648, 72671, 73200, 73177, 81669, 83301, 83302, 83231, 81672, 83304, 83305, 
83234, 81600, 81670, 83303, 83233
28288, 72648, 72671, 73200, 73177, 72649, 72672, 73201, 73178, 81672, 83304, 83305, 83234, 81675, 83307, 83308, 
83237, 81603, 81673, 83306, 83236
28289, 72649, 72672, 73201, 73178, 72650, 72673, 73202, 73179, 81675, 83307, 83308, 83237, 81678, 83310, 83311, 
83240, 81606, 81676, 83309, 83239
28290, 72650, 72673, 73202, 73179, 72651, 72674, 73203, 73180, 81678, 83310, 83311, 83240, 81681, 83313, 83314, 
83243, 81609, 81679, 83312, 83242
28291, 72651, 72674, 73203, 73180, 72652, 72675, 73204, 73181, 81681, 83313, 83314, 83243, 81684, 83316, 83317, 
83246, 81612, 81682, 83315, 83245
28292, 72652, 72675, 73204, 73181, 72653, 72676, 73205, 73182, 81684, 83316, 83317, 83246, 81687, 83319, 83320, 
83249, 81615, 81685, 83318, 83248
28293, 72653, 72676, 73205, 73182, 72654, 72677, 73206, 73183, 81687, 83319, 83320, 83249, 81690, 83322, 83323, 
83252, 81618, 81688, 83321, 83251
28294, 72654, 72677, 73206, 73183, 22903, 22904, 22927, 22926, 81690, 83322, 83323, 83252, 23226, 23272, 23273, 
23270, 81621, 81691, 83324, 83254
28295, 17259, 17260, 17283, 17282, 72655, 72678, 73207, 73184, 17583, 17629, 17630, 17627, 81694, 83326, 83327, 
83256, 81622, 81692, 83325, 83255
28296, 72655, 72678, 73207, 73184, 72656, 72679, 73208, 73185, 81694, 83326, 83327, 83256, 81697, 83329, 83330, 
83259, 81625, 81695, 83328, 83258
28297, 72656, 72679, 73208, 73185, 72657, 72680, 73209, 73186, 81697, 83329, 83330, 83259, 81700, 83332, 83333, 
83262, 81628, 81698, 83331, 83261
28298, 72657, 72680, 73209, 73186, 72658, 72681, 73210, 73187, 81700, 83332, 83333, 83262, 81703, 83335, 83336, 
83265, 81631, 81701, 83334, 83264
28299, 72658, 72681, 73210, 73187, 72659, 72682, 73211, 73188, 81703, 83335, 83336, 83265, 81706, 83338, 83339, 
83268, 81634, 81704, 83337, 83267
28300, 72659, 72682, 73211, 73188, 72660, 72683, 73212, 73189, 81706, 83338, 83339, 83268, 81709, 83341, 83342, 
83271, 81637, 81707, 83340, 83270
28301, 72660, 72683, 73212, 73189, 72661, 72684, 73213, 73190, 81709, 83341, 83342, 83271, 81712, 83344, 83345, 
83274, 81640, 81710, 83343, 83273
28302, 72661, 72684, 73213, 73190, 72662, 72685, 73214, 73191, 81712, 83344, 83345, 83274, 81715, 83347, 83348, 
83277, 81643, 81713, 83346, 83276
28303, 72662, 72685, 73214, 73191, 72663, 72686, 73215, 73192, 81715, 83347, 83348, 83277, 81718, 83350, 83351, 
83280, 81646, 81716, 83349, 83279
28304, 72663, 72686, 73215, 73192, 72664, 72687, 73216, 73193, 81718, 83350, 83351, 83280, 81721, 83353, 83354, 
83283, 81649, 81719, 83352, 83282
28305, 72664, 72687, 73216, 73193, 72665, 72688, 73217, 73194, 81721, 83353, 83354, 83283, 81724, 83356, 83357, 
83286, 81652, 81722, 83355, 83285
28306, 72665, 72688, 73217, 73194, 72666, 72689, 73218, 73195, 81724, 83356, 83357, 83286, 81727, 83359, 83360, 
83289, 81655, 81725, 83358, 83288
28307, 72666, 72689, 73218, 73195, 72667, 72690, 73219, 73196, 81727, 83359, 83360, 83289, 81730, 83362, 83363, 
83292, 81658, 81728, 83361, 83291
28308, 72667, 72690, 73219, 73196, 72668, 72691, 73220, 73197, 81730, 83362, 83363, 83292, 81733, 83365, 83366, 
83295, 81661, 81731, 83364, 83294
28309, 72668, 72691, 73220, 73197, 72669, 72692, 73221, 73198, 81733, 83365, 83366, 83295, 81736, 83368, 83369, 
83298, 81664, 81734, 83367, 83297
28310, 72669, 72692, 73221, 73198, 72670, 72693, 73222, 73199, 81736, 83368, 83369, 83298, 81739, 83371, 83372, 
83301, 81667, 81737, 83370, 83300
28311, 72670, 72693, 73222, 73199, 72671, 72694, 73223, 73200, 81739, 83371, 83372, 83301, 81742, 83374, 83375, 
83304, 81670, 81740, 83373, 83303
28312, 72671, 72694, 73223, 73200, 72672, 72695, 73224, 73201, 81742, 83374, 83375, 83304, 81745, 83377, 83378, 
83307, 81673, 81743, 83376, 83306
28313, 72672, 72695, 73224, 73201, 72673, 72696, 73225, 73202, 81745, 83377, 83378, 83307, 81748, 83380, 83381, 
83310, 81676, 81746, 83379, 83309
28314, 72673, 72696, 73225, 73202, 72674, 72697, 73226, 73203, 81748, 83380, 83381, 83310, 81751, 83383, 83384, 
83313, 81679, 81749, 83382, 83312
28315, 72674, 72697, 73226, 73203, 72675, 72698, 73227, 73204, 81751, 83383, 83384, 83313, 81754, 83386, 83387, 
83316, 81682, 81752, 83385, 83315
28316, 72675, 72698, 73227, 73204, 72676, 72699, 73228, 73205, 81754, 83386, 83387, 83316, 81757, 83389, 83390, 
83319, 81685, 81755, 83388, 83318
28317, 72676, 72699, 73228, 73205, 72677, 72700, 73229, 73206, 81757, 83389, 83390, 83319, 81760, 83392, 83393, 
83322, 81688, 81758, 83391, 83321
28318, 72677, 72700, 73229, 73206, 22904, 22905, 22928, 22927, 81760, 83392, 83393, 83322, 23228, 23274, 23275, 
23272, 81691, 81761, 83394, 83324
28319, 17260, 17261, 17284, 17283, 72678, 72701, 73230, 73207, 17585, 17631, 17632, 17629, 81764, 83396, 83397, 
83326, 81692, 81762, 83395, 83325
28320, 72678, 72701, 73230, 73207, 72679, 72702, 73231, 73208, 81764, 83396, 83397, 83326, 81767, 83399, 83400, 
83329, 81695, 81765, 83398, 83328
28321, 72679, 72702, 73231, 73208, 72680, 72703, 73232, 73209, 81767, 83399, 83400, 83329, 81770, 83402, 83403, 
83332, 81698, 81768, 83401, 83331
28322, 72680, 72703, 73232, 73209, 72681, 72704, 73233, 73210, 81770, 83402, 83403, 83332, 81773, 83405, 83406, 
83335, 81701, 81771, 83404, 83334
28323, 72681, 72704, 73233, 73210, 72682, 72705, 73234, 73211, 81773, 83405, 83406, 83335, 81776, 83408, 83409, 
83338, 81704, 81774, 83407, 83337
28324, 72682, 72705, 73234, 73211, 72683, 72706, 73235, 73212, 81776, 83408, 83409, 83338, 81779, 83411, 83412, 
83341, 81707, 81777, 83410, 83340
28325, 72683, 72706, 73235, 73212, 72684, 72707, 73236, 73213, 81779, 83411, 83412, 83341, 81782, 83414, 83415, 
83344, 81710, 81780, 83413, 83343
28326, 72684, 72707, 73236, 73213, 72685, 72708, 73237, 73214, 81782, 83414, 83415, 83344, 81785, 83417, 83418, 
83347, 81713, 81783, 83416, 83346
28327, 72685, 72708, 73237, 73214, 72686, 72709, 73238, 73215, 81785, 83417, 83418, 83347, 81788, 83420, 83421, 
83350, 81716, 81786, 83419, 83349
28328, 72686, 72709, 73238, 73215, 72687, 72710, 73239, 73216, 81788, 83420, 83421, 83350, 81791, 83423, 83424, 
83353, 81719, 81789, 83422, 83352
28329, 72687, 72710, 73239, 73216, 72688, 72711, 73240, 73217, 81791, 83423, 83424, 83353, 81794, 83426, 83427, 
83356, 81722, 81792, 83425, 83355
28330, 72688, 72711, 73240, 73217, 72689, 72712, 73241, 73218, 81794, 83426, 83427, 83356, 81797, 83429, 83430, 
83359, 81725, 81795, 83428, 83358
28331, 72689, 72712, 73241, 73218, 72690, 72713, 73242, 73219, 81797, 83429, 83430, 83359, 81800, 83432, 83433, 
83362, 81728, 81798, 83431, 83361
28332, 72690, 72713, 73242, 73219, 72691, 72714, 73243, 73220, 81800, 83432, 83433, 83362, 81803, 83435, 83436, 
83365, 81731, 81801, 83434, 83364
28333, 72691, 72714, 73243, 73220, 72692, 72715, 73244, 73221, 81803, 83435, 83436, 83365, 81806, 83438, 83439, 
83368, 81734, 81804, 83437, 83367
28334, 72692, 72715, 73244, 73221, 72693, 72716, 73245, 73222, 81806, 83438, 83439, 83368, 81809, 83441, 83442, 
83371, 81737, 81807, 83440, 83370
28335, 72693, 72716, 73245, 73222, 72694, 72717, 73246, 73223, 81809, 83441, 83442, 83371, 81812, 83444, 83445, 
83374, 81740, 81810, 83443, 83373
28336, 72694, 72717, 73246, 73223, 72695, 72718, 73247, 73224, 81812, 83444, 83445, 83374, 81815, 83447, 83448, 
83377, 81743, 81813, 83446, 83376
28337, 72695, 72718, 73247, 73224, 72696, 72719, 73248, 73225, 81815, 83447, 83448, 83377, 81818, 83450, 83451, 
83380, 81746, 81816, 83449, 83379
28338, 72696, 72719, 73248, 73225, 72697, 72720, 73249, 73226, 81818, 83450, 83451, 83380, 81821, 83453, 83454, 
83383, 81749, 81819, 83452, 83382
28339, 72697, 72720, 73249, 73226, 72698, 72721, 73250, 73227, 81821, 83453, 83454, 83383, 81824, 83456, 83457, 
83386, 81752, 81822, 83455, 83385
28340, 72698, 72721, 73250, 73227, 72699, 72722, 73251, 73228, 81824, 83456, 83457, 83386, 81827, 83459, 83460, 
83389, 81755, 81825, 83458, 83388
28341, 72699, 72722, 73251, 73228, 72700, 72723, 73252, 73229, 81827, 83459, 83460, 83389, 81830, 83462, 83463, 
83392, 81758, 81828, 83461, 83391
28342, 72700, 72723, 73252, 73229, 22905, 22906, 22929, 22928, 81830, 83462, 83463, 83392, 23230, 23276, 23277, 
23274, 81761, 81831, 83464, 83394
28343, 17261, 1632, 1633, 17284, 72701, 22091, 22114, 73230, 17586, 1644, 17633, 17631, 81832, 22440, 83465, 
83396, 81762, 22392, 22439, 83395
28344, 72701, 22091, 22114, 73230, 72702, 22092, 22115, 73231, 81832, 22440, 83465, 83396, 81833, 22442, 83466, 
83399, 81765, 22394, 22441, 83398
28345, 72702, 22092, 22115, 73231, 72703, 22093, 22116, 73232, 81833, 22442, 83466, 83399, 81834, 22444, 83467, 
83402, 81768, 22396, 22443, 83401
