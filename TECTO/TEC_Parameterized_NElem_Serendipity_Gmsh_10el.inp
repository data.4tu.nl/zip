26297, 1.05, 1.2, 0.45833333333333
26298, 1.05, 1.25, 0.45833333333333
26299, 1.05, 1.3, 0.45833333333333
26300, 1.05, 0.2, 0.020833333333333
26301, 1.05, 0.175, 0.041666666666667
26302, 1.05, 0.25, 0.020833333333333
26303, 1.05, 0.225, 0.041666666666667
26304, 1.05, 0.3, 0.020833333333333
26305, 1.05, 0.275, 0.041666666666667
26306, 1.05, 0.35, 0.020833333333333
26307, 1.05, 0.325, 0.041666666666667
26308, 1.05, 0.4, 0.020833333333333
26309, 1.05, 0.375, 0.041666666666667
26310, 1.05, 0.45, 0.020833333333333
26311, 1.05, 0.425, 0.041666666666667
26312, 1.05, 0.5, 0.020833333333333
26313, 1.05, 0.475, 0.041666666666667
26314, 1.05, 0.55, 0.020833333333333
26315, 1.05, 0.525, 0.041666666666667
26316, 1.05, 0.6, 0.020833333333333
26317, 1.05, 0.575, 0.041666666666667
26318, 1.05, 0.65, 0.020833333333333
26319, 1.05, 0.625, 0.041666666666667
26320, 1.05, 0.7, 0.020833333333333
26321, 1.05, 0.675, 0.041666666666667
26322, 1.05, 0.75, 0.020833333333333
26323, 1.05, 0.725, 0.041666666666667
26324, 1.05, 0.8, 0.020833333333333
26325, 1.05, 0.775, 0.041666666666667
26326, 1.05, 0.85, 0.020833333333333
26327, 1.05, 0.825, 0.041666666666667
26328, 1.05, 0.9, 0.020833333333333
26329, 1.05, 0.875, 0.041666666666667
26330, 1.05, 0.95, 0.020833333333333
26331, 1.05, 0.925, 0.041666666666667
26332, 1.05, 1, 0.020833333333333
26333, 1.05, 0.975, 0.041666666666667
26334, 1.05, 1.05, 0.020833333333333
26335, 1.05, 1.025, 0.041666666666667
26336, 1.05, 1.1, 0.020833333333333
26337, 1.05, 1.075, 0.041666666666667
26338, 1.05, 1.15, 0.020833333333333
26339, 1.05, 1.125, 0.041666666666667
26340, 1.05, 1.2, 0.020833333333333
26341, 1.05, 1.175, 0.041666666666667
26342, 1.05, 1.25, 0.020833333333333
26343, 1.05, 1.225, 0.041666666666667
26344, 1.05, 1.3, 0.020833333333333
26345, 1.05, 1.275, 0.041666666666667
26346, 1.05, 1.325, 0.041666666666667
26347, 1.05, 0.2, 0.0625
26348, 1.05, 0.175, 0.083333333333333
26349, 1.05, 0.25, 0.0625
26350, 1.05, 0.225, 0.083333333333333
26351, 1.05, 0.3, 0.0625
26352, 1.05, 0.275, 0.083333333333333
26353, 1.05, 0.35, 0.0625
26354, 1.05, 0.325, 0.083333333333333
26355, 1.05, 0.4, 0.0625
26356, 1.05, 0.375, 0.083333333333333
26357, 1.05, 0.45, 0.0625
26358, 1.05, 0.425, 0.083333333333333
26359, 1.05, 0.5, 0.0625
26360, 1.05, 0.475, 0.083333333333333
26361, 1.05, 0.55, 0.0625
26362, 1.05, 0.525, 0.083333333333333
26363, 1.05, 0.6, 0.0625
26364, 1.05, 0.575, 0.083333333333333
26365, 1.05, 0.65, 0.0625
26366, 1.05, 0.625, 0.083333333333333
26367, 1.05, 0.7, 0.0625
26368, 1.05, 0.675, 0.083333333333333
26369, 1.05, 0.75, 0.0625
26370, 1.05, 0.725, 0.083333333333333
26371, 1.05, 0.8, 0.0625
26372, 1.05, 0.775, 0.083333333333333
26373, 1.05, 0.85, 0.0625
26374, 1.05, 0.825, 0.083333333333333
26375, 1.05, 0.9, 0.0625
26376, 1.05, 0.875, 0.083333333333333
26377, 1.05, 0.95, 0.0625
26378, 1.05, 0.925, 0.083333333333333
26379, 1.05, 1, 0.0625
26380, 1.05, 0.975, 0.083333333333333
26381, 1.05, 1.05, 0.0625
26382, 1.05, 1.025, 0.083333333333333
26383, 1.05, 1.1, 0.0625
26384, 1.05, 1.075, 0.083333333333333
26385, 1.05, 1.15, 0.0625
26386, 1.05, 1.125, 0.083333333333333
26387, 1.05, 1.2, 0.0625
26388, 1.05, 1.175, 0.083333333333333
26389, 1.05, 1.25, 0.0625
26390, 1.05, 1.225, 0.083333333333333
26391, 1.05, 1.3, 0.0625
26392, 1.05, 1.275, 0.083333333333333
26393, 1.05, 1.325, 0.083333333333333
26394, 1.05, 0.2, 0.10416666666667
26395, 1.05, 0.175, 0.125
26396, 1.05, 0.25, 0.10416666666667
26397, 1.05, 0.225, 0.125
26398, 1.05, 0.3, 0.10416666666667
26399, 1.05, 0.275, 0.125
26400, 1.05, 0.35, 0.10416666666667
26401, 1.05, 0.325, 0.125
26402, 1.05, 0.4, 0.10416666666667
26403, 1.05, 0.375, 0.125
26404, 1.05, 0.45, 0.10416666666667
26405, 1.05, 0.425, 0.125
26406, 1.05, 0.5, 0.10416666666667
26407, 1.05, 0.475, 0.125
26408, 1.05, 0.55, 0.10416666666667
26409, 1.05, 0.525, 0.125
26410, 1.05, 0.6, 0.10416666666667
26411, 1.05, 0.575, 0.125
26412, 1.05, 0.65, 0.10416666666667
26413, 1.05, 0.625, 0.125
26414, 1.05, 0.7, 0.10416666666667
26415, 1.05, 0.675, 0.125
26416, 1.05, 0.75, 0.10416666666667
26417, 1.05, 0.725, 0.125
26418, 1.05, 0.8, 0.10416666666667
26419, 1.05, 0.775, 0.125
26420, 1.05, 0.85, 0.10416666666667
26421, 1.05, 0.825, 0.125
26422, 1.05, 0.9, 0.10416666666667
26423, 1.05, 0.875, 0.125
26424, 1.05, 0.95, 0.10416666666667
26425, 1.05, 0.925, 0.125
26426, 1.05, 1, 0.10416666666667
26427, 1.05, 0.975, 0.125
26428, 1.05, 1.05, 0.10416666666667
26429, 1.05, 1.025, 0.125
26430, 1.05, 1.1, 0.10416666666667
26431, 1.05, 1.075, 0.125
26432, 1.05, 1.15, 0.10416666666667
26433, 1.05, 1.125, 0.125
26434, 1.05, 1.2, 0.10416666666667
26435, 1.05, 1.175, 0.125
26436, 1.05, 1.25, 0.10416666666667
26437, 1.05, 1.225, 0.125
26438, 1.05, 1.3, 0.10416666666667
26439, 1.05, 1.275, 0.125
26440, 1.05, 1.325, 0.125
26441, 1.05, 0.2, 0.14583333333333
26442, 1.05, 0.175, 0.16666666666667
26443, 1.05, 0.25, 0.14583333333333
26444, 1.05, 0.225, 0.16666666666667
26445, 1.05, 0.3, 0.14583333333333
26446, 1.05, 0.275, 0.16666666666667
26447, 1.05, 0.35, 0.14583333333333
26448, 1.05, 0.325, 0.16666666666667
26449, 1.05, 0.4, 0.14583333333333
26450, 1.05, 0.375, 0.16666666666667
26451, 1.05, 0.45, 0.14583333333333
26452, 1.05, 0.425, 0.16666666666667
26453, 1.05, 0.5, 0.14583333333333
26454, 1.05, 0.475, 0.16666666666667
26455, 1.05, 0.55, 0.14583333333333
26456, 1.05, 0.525, 0.16666666666667
26457, 1.05, 0.6, 0.14583333333333
26458, 1.05, 0.575, 0.16666666666667
26459, 1.05, 0.65, 0.14583333333333
26460, 1.05, 0.625, 0.16666666666667
26461, 1.05, 0.7, 0.14583333333333
26462, 1.05, 0.675, 0.16666666666667
26463, 1.05, 0.75, 0.14583333333333
26464, 1.05, 0.725, 0.16666666666667
26465, 1.05, 0.8, 0.14583333333333
26466, 1.05, 0.775, 0.16666666666667
26467, 1.05, 0.85, 0.14583333333333
26468, 1.05, 0.825, 0.16666666666667
26469, 1.05, 0.9, 0.14583333333333
26470, 1.05, 0.875, 0.16666666666667
26471, 1.05, 0.95, 0.14583333333333
26472, 1.05, 0.925, 0.16666666666667
26473, 1.05, 1, 0.14583333333333
26474, 1.05, 0.975, 0.16666666666667
26475, 1.05, 1.05, 0.14583333333333
26476, 1.05, 1.025, 0.16666666666667
26477, 1.05, 1.1, 0.14583333333333
26478, 1.05, 1.075, 0.16666666666667
26479, 1.05, 1.15, 0.14583333333333
26480, 1.05, 1.125, 0.16666666666667
26481, 1.05, 1.2, 0.14583333333333
26482, 1.05, 1.175, 0.16666666666667
26483, 1.05, 1.25, 0.14583333333333
26484, 1.05, 1.225, 0.16666666666667
26485, 1.05, 1.3, 0.14583333333333
26486, 1.05, 1.275, 0.16666666666667
26487, 1.05, 1.325, 0.16666666666667
26488, 1.05, 0.2, 0.1875
26489, 1.05, 0.175, 0.20833333333333
26490, 1.05, 0.25, 0.1875
26491, 1.05, 0.225, 0.20833333333333
26492, 1.05, 0.3, 0.1875
26493, 1.05, 0.275, 0.20833333333333
26494, 1.05, 0.35, 0.1875
26495, 1.05, 0.325, 0.20833333333333
26496, 1.05, 0.4, 0.1875
26497, 1.05, 0.375, 0.20833333333333
26498, 1.05, 0.45, 0.1875
26499, 1.05, 0.425, 0.20833333333333
26500, 1.05, 0.5, 0.1875
26501, 1.05, 0.475, 0.20833333333333
26502, 1.05, 0.55, 0.1875
26503, 1.05, 0.525, 0.20833333333333
26504, 1.05, 0.6, 0.1875
26505, 1.05, 0.575, 0.20833333333333
26506, 1.05, 0.65, 0.1875
26507, 1.05, 0.625, 0.20833333333333
26508, 1.05, 0.7, 0.1875
26509, 1.05, 0.675, 0.20833333333333
26510, 1.05, 0.75, 0.1875
26511, 1.05, 0.725, 0.20833333333333
26512, 1.05, 0.8, 0.1875
26513, 1.05, 0.775, 0.20833333333333
26514, 1.05, 0.85, 0.1875
26515, 1.05, 0.825, 0.20833333333333
26516, 1.05, 0.9, 0.1875
26517, 1.05, 0.875, 0.20833333333333
26518, 1.05, 0.95, 0.1875
26519, 1.05, 0.925, 0.20833333333333
26520, 1.05, 1, 0.1875
26521, 1.05, 0.975, 0.20833333333333
26522, 1.05, 1.05, 0.1875
26523, 1.05, 1.025, 0.20833333333333
26524, 1.05, 1.1, 0.1875
26525, 1.05, 1.075, 0.20833333333333
26526, 1.05, 1.15, 0.1875
26527, 1.05, 1.125, 0.20833333333333
26528, 1.05, 1.2, 0.1875
26529, 1.05, 1.175, 0.20833333333333
26530, 1.05, 1.25, 0.1875
26531, 1.05, 1.225, 0.20833333333333
26532, 1.05, 1.3, 0.1875
26533, 1.05, 1.275, 0.20833333333333
26534, 1.05, 1.325, 0.20833333333333
26535, 1.05, 0.2, 0.22916666666667
26536, 1.05, 0.175, 0.25
26537, 1.05, 0.25, 0.22916666666667
26538, 1.05, 0.225, 0.25
26539, 1.05, 0.3, 0.22916666666667
26540, 1.05, 0.275, 0.25
26541, 1.05, 0.35, 0.22916666666667
26542, 1.05, 0.325, 0.25
26543, 1.05, 0.4, 0.22916666666667
26544, 1.05, 0.375, 0.25
26545, 1.05, 0.45, 0.22916666666667
26546, 1.05, 0.425, 0.25
26547, 1.05, 0.5, 0.22916666666667
26548, 1.05, 0.475, 0.25
26549, 1.05, 0.55, 0.22916666666667
26550, 1.05, 0.525, 0.25
26551, 1.05, 0.6, 0.22916666666667
26552, 1.05, 0.575, 0.25
26553, 1.05, 0.65, 0.22916666666667
26554, 1.05, 0.625, 0.25
26555, 1.05, 0.7, 0.22916666666667
26556, 1.05, 0.675, 0.25
26557, 1.05, 0.75, 0.22916666666667
26558, 1.05, 0.725, 0.25
26559, 1.05, 0.8, 0.22916666666667
26560, 1.05, 0.775, 0.25
26561, 1.05, 0.85, 0.22916666666667
26562, 1.05, 0.825, 0.25
26563, 1.05, 0.9, 0.22916666666667
26564, 1.05, 0.875, 0.25
26565, 1.05, 0.95, 0.22916666666667
26566, 1.05, 0.925, 0.25
26567, 1.05, 1, 0.22916666666667
26568, 1.05, 0.975, 0.25
26569, 1.05, 1.05, 0.22916666666667
26570, 1.05, 1.025, 0.25
26571, 1.05, 1.1, 0.22916666666667
26572, 1.05, 1.075, 0.25
26573, 1.05, 1.15, 0.22916666666667
26574, 1.05, 1.125, 0.25
26575, 1.05, 1.2, 0.22916666666667
26576, 1.05, 1.175, 0.25
26577, 1.05, 1.25, 0.22916666666667
26578, 1.05, 1.225, 0.25
26579, 1.05, 1.3, 0.22916666666667
26580, 1.05, 1.275, 0.25
26581, 1.05, 1.325, 0.25
26582, 1.05, 0.2, 0.27083333333333
26583, 1.05, 0.175, 0.29166666666667
26584, 1.05, 0.25, 0.27083333333333
26585, 1.05, 0.225, 0.29166666666667
26586, 1.05, 0.3, 0.27083333333333
26587, 1.05, 0.275, 0.29166666666667
26588, 1.05, 0.35, 0.27083333333333
26589, 1.05, 0.325, 0.29166666666667
26590, 1.05, 0.4, 0.27083333333333
26591, 1.05, 0.375, 0.29166666666667
26592, 1.05, 0.45, 0.27083333333333
26593, 1.05, 0.425, 0.29166666666667
26594, 1.05, 0.5, 0.27083333333333
26595, 1.05, 0.475, 0.29166666666667
26596, 1.05, 0.55, 0.27083333333333
26597, 1.05, 0.525, 0.29166666666667
26598, 1.05, 0.6, 0.27083333333333
26599, 1.05, 0.575, 0.29166666666667
26600, 1.05, 0.65, 0.27083333333333
26601, 1.05, 0.625, 0.29166666666667
26602, 1.05, 0.7, 0.27083333333333
26603, 1.05, 0.675, 0.29166666666667
26604, 1.05, 0.75, 0.27083333333333
26605, 1.05, 0.725, 0.29166666666667
26606, 1.05, 0.8, 0.27083333333333
26607, 1.05, 0.775, 0.29166666666667
26608, 1.05, 0.85, 0.27083333333333
26609, 1.05, 0.825, 0.29166666666667
26610, 1.05, 0.9, 0.27083333333333
26611, 1.05, 0.875, 0.29166666666667
26612, 1.05, 0.95, 0.27083333333333
26613, 1.05, 0.925, 0.29166666666667
26614, 1.05, 1, 0.27083333333333
26615, 1.05, 0.975, 0.29166666666667
26616, 1.05, 1.05, 0.27083333333333
26617, 1.05, 1.025, 0.29166666666667
26618, 1.05, 1.1, 0.27083333333333
26619, 1.05, 1.075, 0.29166666666667
26620, 1.05, 1.15, 0.27083333333333
26621, 1.05, 1.125, 0.29166666666667
26622, 1.05, 1.2, 0.27083333333333
26623, 1.05, 1.175, 0.29166666666667
26624, 1.05, 1.25, 0.27083333333333
26625, 1.05, 1.225, 0.29166666666667
26626, 1.05, 1.3, 0.27083333333333
26627, 1.05, 1.275, 0.29166666666667
26628, 1.05, 1.325, 0.29166666666667
26629, 1.05, 0.2, 0.3125
26630, 1.05, 0.175, 0.33333333333333
26631, 1.05, 0.25, 0.3125
26632, 1.05, 0.225, 0.33333333333333
26633, 1.05, 0.3, 0.3125
26634, 1.05, 0.275, 0.33333333333333
26635, 1.05, 0.35, 0.3125
26636, 1.05, 0.325, 0.33333333333333
26637, 1.05, 0.4, 0.3125
26638, 1.05, 0.375, 0.33333333333333
26639, 1.05, 0.45, 0.3125
26640, 1.05, 0.425, 0.33333333333333
26641, 1.05, 0.5, 0.3125
26642, 1.05, 0.475, 0.33333333333333
26643, 1.05, 0.55, 0.3125
26644, 1.05, 0.525, 0.33333333333333
26645, 1.05, 0.6, 0.3125
26646, 1.05, 0.575, 0.33333333333333
26647, 1.05, 0.65, 0.3125
26648, 1.05, 0.625, 0.33333333333333
26649, 1.05, 0.7, 0.3125
26650, 1.05, 0.675, 0.33333333333333
26651, 1.05, 0.75, 0.3125
26652, 1.05, 0.725, 0.33333333333333
26653, 1.05, 0.8, 0.3125
26654, 1.05, 0.775, 0.33333333333333
26655, 1.05, 0.85, 0.3125
26656, 1.05, 0.825, 0.33333333333333
26657, 1.05, 0.9, 0.3125
26658, 1.05, 0.875, 0.33333333333333
26659, 1.05, 0.95, 0.3125
26660, 1.05, 0.925, 0.33333333333333
26661, 1.05, 1, 0.3125
26662, 1.05, 0.975, 0.33333333333333
26663, 1.05, 1.05, 0.3125
26664, 1.05, 1.025, 0.33333333333333
26665, 1.05, 1.1, 0.3125
26666, 1.05, 1.075, 0.33333333333333
26667, 1.05, 1.15, 0.3125
26668, 1.05, 1.125, 0.33333333333333
26669, 1.05, 1.2, 0.3125
26670, 1.05, 1.175, 0.33333333333333
26671, 1.05, 1.25, 0.3125
26672, 1.05, 1.225, 0.33333333333333
26673, 1.05, 1.3, 0.3125
26674, 1.05, 1.275, 0.33333333333333
26675, 1.05, 1.325, 0.33333333333333
26676, 1.05, 0.2, 0.35416666666667
26677, 1.05, 0.175, 0.375
26678, 1.05, 0.25, 0.35416666666667
26679, 1.05, 0.225, 0.375
26680, 1.05, 0.3, 0.35416666666667
26681, 1.05, 0.275, 0.375
26682, 1.05, 0.35, 0.35416666666667
26683, 1.05, 0.325, 0.375
26684, 1.05, 0.4, 0.35416666666667
26685, 1.05, 0.375, 0.375
26686, 1.05, 0.45, 0.35416666666667
26687, 1.05, 0.425, 0.375
26688, 1.05, 0.5, 0.35416666666667
26689, 1.05, 0.475, 0.375
26690, 1.05, 0.55, 0.35416666666667
26691, 1.05, 0.525, 0.375
26692, 1.05, 0.6, 0.35416666666667
26693, 1.05, 0.575, 0.375
26694, 1.05, 0.65, 0.35416666666667
26695, 1.05, 0.625, 0.375
26696, 1.05, 0.7, 0.35416666666667
26697, 1.05, 0.675, 0.375
26698, 1.05, 0.75, 0.35416666666667
26699, 1.05, 0.725, 0.375
26700, 1.05, 0.8, 0.35416666666667
26701, 1.05, 0.775, 0.375
26702, 1.05, 0.85, 0.35416666666667
26703, 1.05, 0.825, 0.375
26704, 1.05, 0.9, 0.35416666666667
26705, 1.05, 0.875, 0.375
26706, 1.05, 0.95, 0.35416666666667
26707, 1.05, 0.925, 0.375
26708, 1.05, 1, 0.35416666666667
26709, 1.05, 0.975, 0.375
26710, 1.05, 1.05, 0.35416666666667
26711, 1.05, 1.025, 0.375
26712, 1.05, 1.1, 0.35416666666667
26713, 1.05, 1.075, 0.375
26714, 1.05, 1.15, 0.35416666666667
26715, 1.05, 1.125, 0.375
26716, 1.05, 1.2, 0.35416666666667
26717, 1.05, 1.175, 0.375
26718, 1.05, 1.25, 0.35416666666667
26719, 1.05, 1.225, 0.375
26720, 1.05, 1.3, 0.35416666666667
26721, 1.05, 1.275, 0.375
26722, 1.05, 1.325, 0.375
26723, 1.05, 0.2, 0.39583333333333
26724, 1.05, 0.175, 0.41666666666667
26725, 1.05, 0.25, 0.39583333333333
26726, 1.05, 0.225, 0.41666666666667
26727, 1.05, 0.3, 0.39583333333333
26728, 1.05, 0.275, 0.41666666666667
26729, 1.05, 0.35, 0.39583333333333
26730, 1.05, 0.325, 0.41666666666667
26731, 1.05, 0.4, 0.39583333333333
26732, 1.05, 0.375, 0.41666666666667
26733, 1.05, 0.45, 0.39583333333333
26734, 1.05, 0.425, 0.41666666666667
26735, 1.05, 0.5, 0.39583333333333
26736, 1.05, 0.475, 0.41666666666667
26737, 1.05, 0.55, 0.39583333333333
26738, 1.05, 0.525, 0.41666666666667
26739, 1.05, 0.6, 0.39583333333333
26740, 1.05, 0.575, 0.41666666666667
26741, 1.05, 0.65, 0.39583333333333
26742, 1.05, 0.625, 0.41666666666667
26743, 1.05, 0.7, 0.39583333333333
26744, 1.05, 0.675, 0.41666666666667
26745, 1.05, 0.75, 0.39583333333333
26746, 1.05, 0.725, 0.41666666666667
26747, 1.05, 0.8, 0.39583333333333
26748, 1.05, 0.775, 0.41666666666667
26749, 1.05, 0.85, 0.39583333333333
26750, 1.05, 0.825, 0.41666666666667
26751, 1.05, 0.9, 0.39583333333333
26752, 1.05, 0.875, 0.41666666666667
26753, 1.05, 0.95, 0.39583333333333
26754, 1.05, 0.925, 0.41666666666667
26755, 1.05, 1, 0.39583333333333
26756, 1.05, 0.975, 0.41666666666667
26757, 1.05, 1.05, 0.39583333333333
26758, 1.05, 1.025, 0.41666666666667
26759, 1.05, 1.1, 0.39583333333333
26760, 1.05, 1.075, 0.41666666666667
26761, 1.05, 1.15, 0.39583333333333
26762, 1.05, 1.125, 0.41666666666667
26763, 1.05, 1.2, 0.39583333333333
26764, 1.05, 1.175, 0.41666666666667
26765, 1.05, 1.25, 0.39583333333333
26766, 1.05, 1.225, 0.41666666666667
26767, 1.05, 1.3, 0.39583333333333
26768, 1.05, 1.275, 0.41666666666667
26769, 1.05, 1.325, 0.41666666666667
26770, 1.05, 0.2, 0.4375
26771, 1.05, 0.175, 0.45833333333333
26772, 1.05, 0.25, 0.4375
26773, 1.05, 0.225, 0.45833333333333
26774, 1.05, 0.3, 0.4375
26775, 1.05, 0.275, 0.45833333333333
26776, 1.05, 0.35, 0.4375
26777, 1.05, 0.325, 0.45833333333333
26778, 1.05, 0.4, 0.4375
26779, 1.05, 0.375, 0.45833333333333
26780, 1.05, 0.45, 0.4375
26781, 1.05, 0.425, 0.45833333333333
26782, 1.05, 0.5, 0.4375
26783, 1.05, 0.475, 0.45833333333333
26784, 1.05, 0.55, 0.4375
26785, 1.05, 0.525, 0.45833333333333
26786, 1.05, 0.6, 0.4375
26787, 1.05, 0.575, 0.45833333333333
26788, 1.05, 0.65, 0.4375
26789, 1.05, 0.625, 0.45833333333333
26790, 1.05, 0.7, 0.4375
26791, 1.05, 0.675, 0.45833333333333
26792, 1.05, 0.75, 0.4375
26793, 1.05, 0.725, 0.45833333333333
26794, 1.05, 0.8, 0.4375
26795, 1.05, 0.775, 0.45833333333333
26796, 1.05, 0.85, 0.4375
26797, 1.05, 0.825, 0.45833333333333
26798, 1.05, 0.9, 0.4375
26799, 1.05, 0.875, 0.45833333333333
26800, 1.05, 0.95, 0.4375
26801, 1.05, 0.925, 0.45833333333333
26802, 1.05, 1, 0.4375
26803, 1.05, 0.975, 0.45833333333333
26804, 1.05, 1.05, 0.4375
26805, 1.05, 1.025, 0.45833333333333
26806, 1.05, 1.1, 0.4375
26807, 1.05, 1.075, 0.45833333333333
26808, 1.05, 1.15, 0.4375
26809, 1.05, 1.125, 0.45833333333333
26810, 1.05, 1.2, 0.4375
26811, 1.05, 1.175, 0.45833333333333
26812, 1.05, 1.25, 0.4375
26813, 1.05, 1.225, 0.45833333333333
26814, 1.05, 1.3, 0.4375
26815, 1.05, 1.275, 0.45833333333333
26816, 1.05, 1.325, 0.45833333333333
26817, 1.05, 0.2, 0.47916666666667
26818, 1.05, 0.25, 0.47916666666667
26819, 1.05, 0.3, 0.47916666666667
26820, 1.05, 0.35, 0.47916666666667
26821, 1.05, 0.4, 0.47916666666667
26822, 1.05, 0.45, 0.47916666666667
26823, 1.05, 0.5, 0.47916666666667
26824, 1.05, 0.55, 0.47916666666667
26825, 1.05, 0.6, 0.47916666666667
26826, 1.05, 0.65, 0.47916666666667
26827, 1.05, 0.7, 0.47916666666667
26828, 1.05, 0.75, 0.47916666666667
26829, 1.05, 0.8, 0.47916666666667
26830, 1.05, 0.85, 0.47916666666667
26831, 1.05, 0.9, 0.47916666666667
26832, 1.05, 0.95, 0.47916666666667
26833, 1.05, 1, 0.47916666666667
26834, 1.05, 1.05, 0.47916666666667
26835, 1.05, 1.1, 0.47916666666667
26836, 1.05, 1.15, 0.47916666666667
26837, 1.05, 1.2, 0.47916666666667
26838, 1.05, 1.25, 0.47916666666667
26839, 1.05, 1.3, 0.47916666666667
26840, 1.175, 1.3, 0.5
26841, 1.175, 1.25, 0.5
26842, 1.175, 1.2, 0.5
26843, 1.175, 1.15, 0.5
26844, 1.175, 1.1, 0.5
26845, 1.175, 1.05, 0.5
26846, 1.175, 1, 0.5
26847, 1.175, 0.95, 0.5
26848, 1.175, 0.9, 0.5
26849, 1.175, 0.85, 0.5
26850, 1.175, 0.8, 0.5
26851, 1.175, 0.75, 0.5
26852, 1.175, 0.7, 0.5
26853, 1.175, 0.65, 0.5
26854, 1.175, 0.6, 0.5
26855, 1.175, 0.55, 0.5
26856, 1.175, 0.5, 0.5
26857, 1.175, 0.45, 0.5
26858, 1.175, 0.4, 0.5
26859, 1.175, 0.35, 0.5
26860, 1.175, 0.3, 0.5
26861, 1.175, 0.25, 0.5
26862, 1.175, 0.2, 0.5
26863, 1.175, 1.3, 0
26864, 1.175, 1.25, 0
26865, 1.175, 1.2, 0
26866, 1.175, 1.15, 0
26867, 1.175, 1.1, 0
26868, 1.175, 1.05, 0
26869, 1.175, 1, 0
26870, 1.175, 0.95, 0
26871, 1.175, 0.9, 0
26872, 1.175, 0.85, 0
26873, 1.175, 0.8, 0
26874, 1.175, 0.75, 0
26875, 1.175, 0.7, 0
26876, 1.175, 0.65, 0
26877, 1.175, 0.6, 0
26878, 1.175, 0.55, 0
26879, 1.175, 0.5, 0
26880, 1.175, 0.45, 0
26881, 1.175, 0.4, 0
26882, 1.175, 0.35, 0
26883, 1.175, 0.3, 0
26884, 1.175, 0.25, 0
26885, 1.175, 0.2, 0
26886, 1.175, 1.35, 0.041666666666667
26887, 1.175, 1.35, 0.083333333333333
26888, 1.175, 1.35, 0.125
26889, 1.175, 1.35, 0.16666666666667
26890, 1.175, 1.35, 0.20833333333333
26891, 1.175, 1.35, 0.25
26892, 1.175, 1.35, 0.29166666666667
26893, 1.175, 1.35, 0.33333333333333
26894, 1.175, 1.35, 0.375
26895, 1.175, 1.35, 0.41666666666667
26896, 1.175, 1.35, 0.45833333333333
26897, 1.175, 0.15, 0.041666666666667
26898, 1.175, 0.15, 0.083333333333333
26899, 1.175, 0.15, 0.125
26900, 1.175, 0.15, 0.16666666666667
26901, 1.175, 0.15, 0.20833333333333
26902, 1.175, 0.15, 0.25
26903, 1.175, 0.15, 0.29166666666667
26904, 1.175, 0.15, 0.33333333333333
26905, 1.175, 0.15, 0.375
26906, 1.175, 0.15, 0.41666666666667
26907, 1.175, 0.15, 0.45833333333333
26908, 1.15, 1.3, 0.041666666666667
26909, 1.15, 1.25, 0.041666666666667
26910, 1.15, 1.2, 0.041666666666667
26911, 1.15, 1.15, 0.041666666666667
26912, 1.15, 1.1, 0.041666666666667
26913, 1.15, 1.05, 0.041666666666667
26914, 1.15, 1, 0.041666666666667
26915, 1.15, 0.95, 0.041666666666667
26916, 1.15, 0.9, 0.041666666666667
26917, 1.15, 0.85, 0.041666666666667
26918, 1.15, 0.8, 0.041666666666667
26919, 1.15, 0.75, 0.041666666666667
26920, 1.15, 0.7, 0.041666666666667
26921, 1.15, 0.65, 0.041666666666667
26922, 1.15, 0.6, 0.041666666666667
26923, 1.15, 0.55, 0.041666666666667
26924, 1.15, 0.5, 0.041666666666667
26925, 1.15, 0.45, 0.041666666666667
26926, 1.15, 0.4, 0.041666666666667
26927, 1.15, 0.35, 0.041666666666667
26928, 1.15, 0.3, 0.041666666666667
26929, 1.15, 0.25, 0.041666666666667
26930, 1.15, 0.2, 0.041666666666667
26931, 1.15, 1.3, 0.083333333333333
26932, 1.15, 1.25, 0.083333333333333
26933, 1.15, 1.2, 0.083333333333333
26934, 1.15, 1.15, 0.083333333333333
26935, 1.15, 1.1, 0.083333333333333
26936, 1.15, 1.05, 0.083333333333333
26937, 1.15, 1, 0.083333333333333
26938, 1.15, 0.95, 0.083333333333333
26939, 1.15, 0.9, 0.083333333333333
26940, 1.15, 0.85, 0.083333333333333
26941, 1.15, 0.8, 0.083333333333333
26942, 1.15, 0.75, 0.083333333333333
26943, 1.15, 0.7, 0.083333333333333
26944, 1.15, 0.65, 0.083333333333333
26945, 1.15, 0.6, 0.083333333333333
26946, 1.15, 0.55, 0.083333333333333
26947, 1.15, 0.5, 0.083333333333333
26948, 1.15, 0.45, 0.083333333333333
26949, 1.15, 0.4, 0.083333333333333
26950, 1.15, 0.35, 0.083333333333333
26951, 1.15, 0.3, 0.083333333333333
26952, 1.15, 0.25, 0.083333333333333
26953, 1.15, 0.2, 0.083333333333333
26954, 1.15, 1.3, 0.125
26955, 1.15, 1.25, 0.125
26956, 1.15, 1.2, 0.125
26957, 1.15, 1.15, 0.125
26958, 1.15, 1.1, 0.125
26959, 1.15, 1.05, 0.125
26960, 1.15, 1, 0.125
26961, 1.15, 0.95, 0.125
26962, 1.15, 0.9, 0.125
26963, 1.15, 0.85, 0.125
26964, 1.15, 0.8, 0.125
26965, 1.15, 0.75, 0.125
26966, 1.15, 0.7, 0.125
26967, 1.15, 0.65, 0.125
26968, 1.15, 0.6, 0.125
26969, 1.15, 0.55, 0.125
26970, 1.15, 0.5, 0.125
26971, 1.15, 0.45, 0.125
26972, 1.15, 0.4, 0.125
26973, 1.15, 0.35, 0.125
26974, 1.15, 0.3, 0.125
26975, 1.15, 0.25, 0.125
26976, 1.15, 0.2, 0.125
26977, 1.15, 1.3, 0.16666666666667
26978, 1.15, 1.25, 0.16666666666667
26979, 1.15, 1.2, 0.16666666666667
26980, 1.15, 1.15, 0.16666666666667
26981, 1.15, 1.1, 0.16666666666667
26982, 1.15, 1.05, 0.16666666666667
26983, 1.15, 1, 0.16666666666667
26984, 1.15, 0.95, 0.16666666666667
26985, 1.15, 0.9, 0.16666666666667
26986, 1.15, 0.85, 0.16666666666667
26987, 1.15, 0.8, 0.16666666666667
26988, 1.15, 0.75, 0.16666666666667
26989, 1.15, 0.7, 0.16666666666667
26990, 1.15, 0.65, 0.16666666666667
26991, 1.15, 0.6, 0.16666666666667
26992, 1.15, 0.55, 0.16666666666667
26993, 1.15, 0.5, 0.16666666666667
26994, 1.15, 0.45, 0.16666666666667
26995, 1.15, 0.4, 0.16666666666667
26996, 1.15, 0.35, 0.16666666666667
26997, 1.15, 0.3, 0.16666666666667
26998, 1.15, 0.25, 0.16666666666667
26999, 1.15, 0.2, 0.16666666666667
27000, 1.15, 1.3, 0.20833333333333
27001, 1.15, 1.25, 0.20833333333333
27002, 1.15, 1.2, 0.20833333333333
27003, 1.15, 1.15, 0.20833333333333
27004, 1.15, 1.1, 0.20833333333333
27005, 1.15, 1.05, 0.20833333333333
27006, 1.15, 1, 0.20833333333333
27007, 1.15, 0.95, 0.20833333333333
27008, 1.15, 0.9, 0.20833333333333
27009, 1.15, 0.85, 0.20833333333333
27010, 1.15, 0.8, 0.20833333333333
27011, 1.15, 0.75, 0.20833333333333
27012, 1.15, 0.7, 0.20833333333333
27013, 1.15, 0.65, 0.20833333333333
27014, 1.15, 0.6, 0.20833333333333
27015, 1.15, 0.55, 0.20833333333333
27016, 1.15, 0.5, 0.20833333333333
27017, 1.15, 0.45, 0.20833333333333
27018, 1.15, 0.4, 0.20833333333333
27019, 1.15, 0.35, 0.20833333333333
27020, 1.15, 0.3, 0.20833333333333
27021, 1.15, 0.25, 0.20833333333333
27022, 1.15, 0.2, 0.20833333333333
27023, 1.15, 1.3, 0.25
27024, 1.15, 1.25, 0.25
27025, 1.15, 1.2, 0.25
27026, 1.15, 1.15, 0.25
27027, 1.15, 1.1, 0.25
27028, 1.15, 1.05, 0.25
27029, 1.15, 1, 0.25
27030, 1.15, 0.95, 0.25
27031, 1.15, 0.9, 0.25
27032, 1.15, 0.85, 0.25
27033, 1.15, 0.8, 0.25
27034, 1.15, 0.75, 0.25
27035, 1.15, 0.7, 0.25
27036, 1.15, 0.65, 0.25
27037, 1.15, 0.6, 0.25
27038, 1.15, 0.55, 0.25
27039, 1.15, 0.5, 0.25
27040, 1.15, 0.45, 0.25
27041, 1.15, 0.4, 0.25
27042, 1.15, 0.35, 0.25
27043, 1.15, 0.3, 0.25
27044, 1.15, 0.25, 0.25
27045, 1.15, 0.2, 0.25
27046, 1.15, 1.3, 0.29166666666667
27047, 1.15, 1.25, 0.29166666666667
27048, 1.15, 1.2, 0.29166666666667
27049, 1.15, 1.15, 0.29166666666667
27050, 1.15, 1.1, 0.29166666666667
27051, 1.15, 1.05, 0.29166666666667
27052, 1.15, 1, 0.29166666666667
27053, 1.15, 0.95, 0.29166666666667
27054, 1.15, 0.9, 0.29166666666667
27055, 1.15, 0.85, 0.29166666666667
27056, 1.15, 0.8, 0.29166666666667
27057, 1.15, 0.75, 0.29166666666667
27058, 1.15, 0.7, 0.29166666666667
27059, 1.15, 0.65, 0.29166666666667
27060, 1.15, 0.6, 0.29166666666667
27061, 1.15, 0.55, 0.29166666666667
27062, 1.15, 0.5, 0.29166666666667
27063, 1.15, 0.45, 0.29166666666667
27064, 1.15, 0.4, 0.29166666666667
27065, 1.15, 0.35, 0.29166666666667
27066, 1.15, 0.3, 0.29166666666667
27067, 1.15, 0.25, 0.29166666666667
27068, 1.15, 0.2, 0.29166666666667
27069, 1.15, 1.3, 0.33333333333333
27070, 1.15, 1.25, 0.33333333333333
27071, 1.15, 1.2, 0.33333333333333
27072, 1.15, 1.15, 0.33333333333333
27073, 1.15, 1.1, 0.33333333333333
27074, 1.15, 1.05, 0.33333333333333
27075, 1.15, 1, 0.33333333333333
27076, 1.15, 0.95, 0.33333333333333
27077, 1.15, 0.9, 0.33333333333333
27078, 1.15, 0.85, 0.33333333333333
27079, 1.15, 0.8, 0.33333333333333
27080, 1.15, 0.75, 0.33333333333333
27081, 1.15, 0.7, 0.33333333333333
27082, 1.15, 0.65, 0.33333333333333
27083, 1.15, 0.6, 0.33333333333333
27084, 1.15, 0.55, 0.33333333333333
27085, 1.15, 0.5, 0.33333333333333
27086, 1.15, 0.45, 0.33333333333333
27087, 1.15, 0.4, 0.33333333333333
27088, 1.15, 0.35, 0.33333333333333
27089, 1.15, 0.3, 0.33333333333333
27090, 1.15, 0.25, 0.33333333333333
27091, 1.15, 0.2, 0.33333333333333
27092, 1.15, 1.3, 0.375
27093, 1.15, 1.25, 0.375
27094, 1.15, 1.2, 0.375
27095, 1.15, 1.15, 0.375
27096, 1.15, 1.1, 0.375
27097, 1.15, 1.05, 0.375
27098, 1.15, 1, 0.375
27099, 1.15, 0.95, 0.375
27100, 1.15, 0.9, 0.375
27101, 1.15, 0.85, 0.375
27102, 1.15, 0.8, 0.375
27103, 1.15, 0.75, 0.375
27104, 1.15, 0.7, 0.375
27105, 1.15, 0.65, 0.375
27106, 1.15, 0.6, 0.375
27107, 1.15, 0.55, 0.375
27108, 1.15, 0.5, 0.375
27109, 1.15, 0.45, 0.375
27110, 1.15, 0.4, 0.375
27111, 1.15, 0.35, 0.375
27112, 1.15, 0.3, 0.375
27113, 1.15, 0.25, 0.375
27114, 1.15, 0.2, 0.375
27115, 1.15, 1.3, 0.41666666666667
27116, 1.15, 1.25, 0.41666666666667
27117, 1.15, 1.2, 0.41666666666667
27118, 1.15, 1.15, 0.41666666666667
27119, 1.15, 1.1, 0.41666666666667
27120, 1.15, 1.05, 0.41666666666667
27121, 1.15, 1, 0.41666666666667
27122, 1.15, 0.95, 0.41666666666667
27123, 1.15, 0.9, 0.41666666666667
27124, 1.15, 0.85, 0.41666666666667
27125, 1.15, 0.8, 0.41666666666667
27126, 1.15, 0.75, 0.41666666666667
27127, 1.15, 0.7, 0.41666666666667
27128, 1.15, 0.65, 0.41666666666667
27129, 1.15, 0.6, 0.41666666666667
27130, 1.15, 0.55, 0.41666666666667
27131, 1.15, 0.5, 0.41666666666667
27132, 1.15, 0.45, 0.41666666666667
27133, 1.15, 0.4, 0.41666666666667
27134, 1.15, 0.35, 0.41666666666667
27135, 1.15, 0.3, 0.41666666666667
27136, 1.15, 0.25, 0.41666666666667
27137, 1.15, 0.2, 0.41666666666667
27138, 1.15, 1.3, 0.45833333333333
27139, 1.15, 1.25, 0.45833333333333
27140, 1.15, 1.2, 0.45833333333333
27141, 1.15, 1.15, 0.45833333333333
27142, 1.15, 1.1, 0.45833333333333
27143, 1.15, 1.05, 0.45833333333333
27144, 1.15, 1, 0.45833333333333
27145, 1.15, 0.95, 0.45833333333333
27146, 1.15, 0.9, 0.45833333333333
27147, 1.15, 0.85, 0.45833333333333
27148, 1.15, 0.8, 0.45833333333333
27149, 1.15, 0.75, 0.45833333333333
27150, 1.15, 0.7, 0.45833333333333
27151, 1.15, 0.65, 0.45833333333333
27152, 1.15, 0.6, 0.45833333333333
27153, 1.15, 0.55, 0.45833333333333
27154, 1.15, 0.5, 0.45833333333333
27155, 1.15, 0.45, 0.45833333333333
27156, 1.15, 0.4, 0.45833333333333
27157, 1.15, 0.35, 0.45833333333333
27158, 1.15, 0.3, 0.45833333333333
27159, 1.15, 0.25, 0.45833333333333
27160, 1.15, 0.2, 0.45833333333333
27161, 1.15, 1.3, 0.020833333333333
27162, 1.15, 1.325, 0.041666666666667
27163, 1.15, 1.25, 0.020833333333333
27164, 1.15, 1.275, 0.041666666666667
27165, 1.15, 1.2, 0.020833333333333
27166, 1.15, 1.225, 0.041666666666667
27167, 1.15, 1.15, 0.020833333333333
27168, 1.15, 1.175, 0.041666666666667
27169, 1.15, 1.1, 0.020833333333333
27170, 1.15, 1.125, 0.041666666666667
27171, 1.15, 1.05, 0.020833333333333
27172, 1.15, 1.075, 0.041666666666667
27173, 1.15, 1, 0.020833333333333
27174, 1.15, 1.025, 0.041666666666667
27175, 1.15, 0.95, 0.020833333333333
27176, 1.15, 0.975, 0.041666666666667
27177, 1.15, 0.9, 0.020833333333333
27178, 1.15, 0.925, 0.041666666666667
27179, 1.15, 0.85, 0.020833333333333
27180, 1.15, 0.875, 0.041666666666667
27181, 1.15, 0.8, 0.020833333333333
27182, 1.15, 0.825, 0.041666666666667
27183, 1.15, 0.75, 0.020833333333333
27184, 1.15, 0.775, 0.041666666666667
27185, 1.15, 0.7, 0.020833333333333
27186, 1.15, 0.725, 0.041666666666667
27187, 1.15, 0.65, 0.020833333333333
27188, 1.15, 0.675, 0.041666666666667
27189, 1.15, 0.6, 0.020833333333333
27190, 1.15, 0.625, 0.041666666666667
27191, 1.15, 0.55, 0.020833333333333
27192, 1.15, 0.575, 0.041666666666667
27193, 1.15, 0.5, 0.020833333333333
27194, 1.15, 0.525, 0.041666666666667
27195, 1.15, 0.45, 0.020833333333333
27196, 1.15, 0.475, 0.041666666666667
27197, 1.15, 0.4, 0.020833333333333
27198, 1.15, 0.425, 0.041666666666667
27199, 1.15, 0.35, 0.020833333333333
27200, 1.15, 0.375, 0.041666666666667
27201, 1.15, 0.3, 0.020833333333333
27202, 1.15, 0.325, 0.041666666666667
27203, 1.15, 0.25, 0.020833333333333
27204, 1.15, 0.275, 0.041666666666667
27205, 1.15, 0.2, 0.020833333333333
27206, 1.15, 0.225, 0.041666666666667
27207, 1.15, 0.175, 0.041666666666667
27208, 1.15, 1.3, 0.0625
27209, 1.15, 1.325, 0.083333333333333
27210, 1.15, 1.25, 0.0625
27211, 1.15, 1.275, 0.083333333333333
27212, 1.15, 1.2, 0.0625
27213, 1.15, 1.225, 0.083333333333333
27214, 1.15, 1.15, 0.0625
27215, 1.15, 1.175, 0.083333333333333
27216, 1.15, 1.1, 0.0625
27217, 1.15, 1.125, 0.083333333333333
27218, 1.15, 1.05, 0.0625
27219, 1.15, 1.075, 0.083333333333333
27220, 1.15, 1, 0.0625
27221, 1.15, 1.025, 0.083333333333333
27222, 1.15, 0.95, 0.0625
27223, 1.15, 0.975, 0.083333333333333
27224, 1.15, 0.9, 0.0625
27225, 1.15, 0.925, 0.083333333333333
27226, 1.15, 0.85, 0.0625
27227, 1.15, 0.875, 0.083333333333333
27228, 1.15, 0.8, 0.0625
27229, 1.15, 0.825, 0.083333333333333
27230, 1.15, 0.75, 0.0625
27231, 1.15, 0.775, 0.083333333333333
27232, 1.15, 0.7, 0.0625
27233, 1.15, 0.725, 0.083333333333333
27234, 1.15, 0.65, 0.0625
27235, 1.15, 0.675, 0.083333333333333
27236, 1.15, 0.6, 0.0625
27237, 1.15, 0.625, 0.083333333333333
27238, 1.15, 0.55, 0.0625
27239, 1.15, 0.575, 0.083333333333333
27240, 1.15, 0.5, 0.0625
27241, 1.15, 0.525, 0.083333333333333
27242, 1.15, 0.45, 0.0625
27243, 1.15, 0.475, 0.083333333333333
27244, 1.15, 0.4, 0.0625
27245, 1.15, 0.425, 0.083333333333333
27246, 1.15, 0.35, 0.0625
27247, 1.15, 0.375, 0.083333333333333
27248, 1.15, 0.3, 0.0625
27249, 1.15, 0.325, 0.083333333333333
27250, 1.15, 0.25, 0.0625
27251, 1.15, 0.275, 0.083333333333333
27252, 1.15, 0.2, 0.0625
27253, 1.15, 0.225, 0.083333333333333
27254, 1.15, 0.175, 0.083333333333333
27255, 1.15, 1.3, 0.10416666666667
27256, 1.15, 1.325, 0.125
27257, 1.15, 1.25, 0.10416666666667
27258, 1.15, 1.275, 0.125
27259, 1.15, 1.2, 0.10416666666667
27260, 1.15, 1.225, 0.125
27261, 1.15, 1.15, 0.10416666666667
27262, 1.15, 1.175, 0.125
27263, 1.15, 1.1, 0.10416666666667
27264, 1.15, 1.125, 0.125
27265, 1.15, 1.05, 0.10416666666667
27266, 1.15, 1.075, 0.125
27267, 1.15, 1, 0.10416666666667
27268, 1.15, 1.025, 0.125
27269, 1.15, 0.95, 0.10416666666667
27270, 1.15, 0.975, 0.125
27271, 1.15, 0.9, 0.10416666666667
27272, 1.15, 0.925, 0.125
27273, 1.15, 0.85, 0.10416666666667
27274, 1.15, 0.875, 0.125
27275, 1.15, 0.8, 0.10416666666667
27276, 1.15, 0.825, 0.125
27277, 1.15, 0.75, 0.10416666666667
27278, 1.15, 0.775, 0.125
27279, 1.15, 0.7, 0.10416666666667
27280, 1.15, 0.725, 0.125
27281, 1.15, 0.65, 0.10416666666667
27282, 1.15, 0.675, 0.125
27283, 1.15, 0.6, 0.10416666666667
27284, 1.15, 0.625, 0.125
27285, 1.15, 0.55, 0.10416666666667
27286, 1.15, 0.575, 0.125
27287, 1.15, 0.5, 0.10416666666667
27288, 1.15, 0.525, 0.125
27289, 1.15, 0.45, 0.10416666666667
27290, 1.15, 0.475, 0.125
27291, 1.15, 0.4, 0.10416666666667
27292, 1.15, 0.425, 0.125
27293, 1.15, 0.35, 0.10416666666667
27294, 1.15, 0.375, 0.125
27295, 1.15, 0.3, 0.10416666666667
27296, 1.15, 0.325, 0.125
27297, 1.15, 0.25, 0.10416666666667
27298, 1.15, 0.275, 0.125
27299, 1.15, 0.2, 0.10416666666667
27300, 1.15, 0.225, 0.125
27301, 1.15, 0.175, 0.125
27302, 1.15, 1.3, 0.14583333333333
27303, 1.15, 1.325, 0.16666666666667
27304, 1.15, 1.25, 0.14583333333333
27305, 1.15, 1.275, 0.16666666666667
27306, 1.15, 1.2, 0.14583333333333
27307, 1.15, 1.225, 0.16666666666667
27308, 1.15, 1.15, 0.14583333333333
27309, 1.15, 1.175, 0.16666666666667
27310, 1.15, 1.1, 0.14583333333333
27311, 1.15, 1.125, 0.16666666666667
27312, 1.15, 1.05, 0.14583333333333
27313, 1.15, 1.075, 0.16666666666667
27314, 1.15, 1, 0.14583333333333
27315, 1.15, 1.025, 0.16666666666667
27316, 1.15, 0.95, 0.14583333333333
27317, 1.15, 0.975, 0.16666666666667
27318, 1.15, 0.9, 0.14583333333333
27319, 1.15, 0.925, 0.16666666666667
27320, 1.15, 0.85, 0.14583333333333
27321, 1.15, 0.875, 0.16666666666667
27322, 1.15, 0.8, 0.14583333333333
27323, 1.15, 0.825, 0.16666666666667
27324, 1.15, 0.75, 0.14583333333333
27325, 1.15, 0.775, 0.16666666666667
27326, 1.15, 0.7, 0.14583333333333
27327, 1.15, 0.725, 0.16666666666667
27328, 1.15, 0.65, 0.14583333333333
27329, 1.15, 0.675, 0.16666666666667
27330, 1.15, 0.6, 0.14583333333333
27331, 1.15, 0.625, 0.16666666666667
27332, 1.15, 0.55, 0.14583333333333
27333, 1.15, 0.575, 0.16666666666667
27334, 1.15, 0.5, 0.14583333333333
27335, 1.15, 0.525, 0.16666666666667
27336, 1.15, 0.45, 0.14583333333333
27337, 1.15, 0.475, 0.16666666666667
27338, 1.15, 0.4, 0.14583333333333
27339, 1.15, 0.425, 0.16666666666667
27340, 1.15, 0.35, 0.14583333333333
27341, 1.15, 0.375, 0.16666666666667
27342, 1.15, 0.3, 0.14583333333333
27343, 1.15, 0.325, 0.16666666666667
27344, 1.15, 0.25, 0.14583333333333
27345, 1.15, 0.275, 0.16666666666667
27346, 1.15, 0.2, 0.14583333333333
27347, 1.15, 0.225, 0.16666666666667
27348, 1.15, 0.175, 0.16666666666667
27349, 1.15, 1.3, 0.1875
27350, 1.15, 1.325, 0.20833333333333
27351, 1.15, 1.25, 0.1875
27352, 1.15, 1.275, 0.20833333333333
27353, 1.15, 1.2, 0.1875
27354, 1.15, 1.225, 0.20833333333333
27355, 1.15, 1.15, 0.1875
27356, 1.15, 1.175, 0.20833333333333
27357, 1.15, 1.1, 0.1875
27358, 1.15, 1.125, 0.20833333333333
27359, 1.15, 1.05, 0.1875
27360, 1.15, 1.075, 0.20833333333333
27361, 1.15, 1, 0.1875
27362, 1.15, 1.025, 0.20833333333333
27363, 1.15, 0.95, 0.1875
27364, 1.15, 0.975, 0.20833333333333
27365, 1.15, 0.9, 0.1875
27366, 1.15, 0.925, 0.20833333333333
27367, 1.15, 0.85, 0.1875
27368, 1.15, 0.875, 0.20833333333333
27369, 1.15, 0.8, 0.1875
27370, 1.15, 0.825, 0.20833333333333
27371, 1.15, 0.75, 0.1875
27372, 1.15, 0.775, 0.20833333333333
27373, 1.15, 0.7, 0.1875
27374, 1.15, 0.725, 0.20833333333333
27375, 1.15, 0.65, 0.1875
27376, 1.15, 0.675, 0.20833333333333
27377, 1.15, 0.6, 0.1875
27378, 1.15, 0.625, 0.20833333333333
27379, 1.15, 0.55, 0.1875
27380, 1.15, 0.575, 0.20833333333333
27381, 1.15, 0.5, 0.1875
27382, 1.15, 0.525, 0.20833333333333
27383, 1.15, 0.45, 0.1875
27384, 1.15, 0.475, 0.20833333333333
27385, 1.15, 0.4, 0.1875
27386, 1.15, 0.425, 0.20833333333333
27387, 1.15, 0.35, 0.1875
27388, 1.15, 0.375, 0.20833333333333
27389, 1.15, 0.3, 0.1875
27390, 1.15, 0.325, 0.20833333333333
27391, 1.15, 0.25, 0.1875
27392, 1.15, 0.275, 0.20833333333333
27393, 1.15, 0.2, 0.1875
27394, 1.15, 0.225, 0.20833333333333
27395, 1.15, 0.175, 0.20833333333333
27396, 1.15, 1.3, 0.22916666666667
27397, 1.15, 1.325, 0.25
27398, 1.15, 1.25, 0.22916666666667
27399, 1.15, 1.275, 0.25
27400, 1.15, 1.2, 0.22916666666667
27401, 1.15, 1.225, 0.25
27402, 1.15, 1.15, 0.22916666666667
27403, 1.15, 1.175, 0.25
27404, 1.15, 1.1, 0.22916666666667
27405, 1.15, 1.125, 0.25
27406, 1.15, 1.05, 0.22916666666667
27407, 1.15, 1.075, 0.25
27408, 1.15, 1, 0.22916666666667
27409, 1.15, 1.025, 0.25
27410, 1.15, 0.95, 0.22916666666667
27411, 1.15, 0.975, 0.25
27412, 1.15, 0.9, 0.22916666666667
27413, 1.15, 0.925, 0.25
27414, 1.15, 0.85, 0.22916666666667
27415, 1.15, 0.875, 0.25
27416, 1.15, 0.8, 0.22916666666667
27417, 1.15, 0.825, 0.25
27418, 1.15, 0.75, 0.22916666666667
27419, 1.15, 0.775, 0.25
27420, 1.15, 0.7, 0.22916666666667
27421, 1.15, 0.725, 0.25
27422, 1.15, 0.65, 0.22916666666667
27423, 1.15, 0.675, 0.25
27424, 1.15, 0.6, 0.22916666666667
27425, 1.15, 0.625, 0.25
27426, 1.15, 0.55, 0.22916666666667
27427, 1.15, 0.575, 0.25
27428, 1.15, 0.5, 0.22916666666667
27429, 1.15, 0.525, 0.25
27430, 1.15, 0.45, 0.22916666666667
27431, 1.15, 0.475, 0.25
27432, 1.15, 0.4, 0.22916666666667
27433, 1.15, 0.425, 0.25
27434, 1.15, 0.35, 0.22916666666667
27435, 1.15, 0.375, 0.25
27436, 1.15, 0.3, 0.22916666666667
27437, 1.15, 0.325, 0.25
27438, 1.15, 0.25, 0.22916666666667
27439, 1.15, 0.275, 0.25
27440, 1.15, 0.2, 0.22916666666667
27441, 1.15, 0.225, 0.25
27442, 1.15, 0.175, 0.25
27443, 1.15, 1.3, 0.27083333333333
27444, 1.15, 1.325, 0.29166666666667
27445, 1.15, 1.25, 0.27083333333333
27446, 1.15, 1.275, 0.29166666666667
27447, 1.15, 1.2, 0.27083333333333
27448, 1.15, 1.225, 0.29166666666667
27449, 1.15, 1.15, 0.27083333333333
27450, 1.15, 1.175, 0.29166666666667
27451, 1.15, 1.1, 0.27083333333333
27452, 1.15, 1.125, 0.29166666666667
27453, 1.15, 1.05, 0.27083333333333
27454, 1.15, 1.075, 0.29166666666667
27455, 1.15, 1, 0.27083333333333
27456, 1.15, 1.025, 0.29166666666667
27457, 1.15, 0.95, 0.27083333333333
27458, 1.15, 0.975, 0.29166666666667
27459, 1.15, 0.9, 0.27083333333333
27460, 1.15, 0.925, 0.29166666666667
27461, 1.15, 0.85, 0.27083333333333
27462, 1.15, 0.875, 0.29166666666667
27463, 1.15, 0.8, 0.27083333333333
27464, 1.15, 0.825, 0.29166666666667
27465, 1.15, 0.75, 0.27083333333333
27466, 1.15, 0.775, 0.29166666666667
27467, 1.15, 0.7, 0.27083333333333
27468, 1.15, 0.725, 0.29166666666667
27469, 1.15, 0.65, 0.27083333333333
27470, 1.15, 0.675, 0.29166666666667
27471, 1.15, 0.6, 0.27083333333333
27472, 1.15, 0.625, 0.29166666666667
27473, 1.15, 0.55, 0.27083333333333
27474, 1.15, 0.575, 0.29166666666667
27475, 1.15, 0.5, 0.27083333333333
27476, 1.15, 0.525, 0.29166666666667
27477, 1.15, 0.45, 0.27083333333333
27478, 1.15, 0.475, 0.29166666666667
27479, 1.15, 0.4, 0.27083333333333
27480, 1.15, 0.425, 0.29166666666667
27481, 1.15, 0.35, 0.27083333333333
27482, 1.15, 0.375, 0.29166666666667
27483, 1.15, 0.3, 0.27083333333333
27484, 1.15, 0.325, 0.29166666666667
27485, 1.15, 0.25, 0.27083333333333
27486, 1.15, 0.275, 0.29166666666667
27487, 1.15, 0.2, 0.27083333333333
27488, 1.15, 0.225, 0.29166666666667
27489, 1.15, 0.175, 0.29166666666667
27490, 1.15, 1.3, 0.3125
27491, 1.15, 1.325, 0.33333333333333
27492, 1.15, 1.25, 0.3125
27493, 1.15, 1.275, 0.33333333333333
27494, 1.15, 1.2, 0.3125
27495, 1.15, 1.225, 0.33333333333333
27496, 1.15, 1.15, 0.3125
27497, 1.15, 1.175, 0.33333333333333
27498, 1.15, 1.1, 0.3125
27499, 1.15, 1.125, 0.33333333333333
27500, 1.15, 1.05, 0.3125
27501, 1.15, 1.075, 0.33333333333333
27502, 1.15, 1, 0.3125
27503, 1.15, 1.025, 0.33333333333333
27504, 1.15, 0.95, 0.3125
27505, 1.15, 0.975, 0.33333333333333
27506, 1.15, 0.9, 0.3125
27507, 1.15, 0.925, 0.33333333333333
27508, 1.15, 0.85, 0.3125
27509, 1.15, 0.875, 0.33333333333333
27510, 1.15, 0.8, 0.3125
27511, 1.15, 0.825, 0.33333333333333
27512, 1.15, 0.75, 0.3125
27513, 1.15, 0.775, 0.33333333333333
27514, 1.15, 0.7, 0.3125
27515, 1.15, 0.725, 0.33333333333333
27516, 1.15, 0.65, 0.3125
27517, 1.15, 0.675, 0.33333333333333
27518, 1.15, 0.6, 0.3125
27519, 1.15, 0.625, 0.33333333333333
27520, 1.15, 0.55, 0.3125
27521, 1.15, 0.575, 0.33333333333333
27522, 1.15, 0.5, 0.3125
27523, 1.15, 0.525, 0.33333333333333
27524, 1.15, 0.45, 0.3125
27525, 1.15, 0.475, 0.33333333333333
27526, 1.15, 0.4, 0.3125
27527, 1.15, 0.425, 0.33333333333333
27528, 1.15, 0.35, 0.3125
27529, 1.15, 0.375, 0.33333333333333
27530, 1.15, 0.3, 0.3125
27531, 1.15, 0.325, 0.33333333333333
27532, 1.15, 0.25, 0.3125
27533, 1.15, 0.275, 0.33333333333333
27534, 1.15, 0.2, 0.3125
27535, 1.15, 0.225, 0.33333333333333
27536, 1.15, 0.175, 0.33333333333333
27537, 1.15, 1.3, 0.35416666666667
27538, 1.15, 1.325, 0.375
27539, 1.15, 1.25, 0.35416666666667
27540, 1.15, 1.275, 0.375
27541, 1.15, 1.2, 0.35416666666667
27542, 1.15, 1.225, 0.375
27543, 1.15, 1.15, 0.35416666666667
27544, 1.15, 1.175, 0.375
27545, 1.15, 1.1, 0.35416666666667
27546, 1.15, 1.125, 0.375
27547, 1.15, 1.05, 0.35416666666667
27548, 1.15, 1.075, 0.375
27549, 1.15, 1, 0.35416666666667
27550, 1.15, 1.025, 0.375
27551, 1.15, 0.95, 0.35416666666667
27552, 1.15, 0.975, 0.375
27553, 1.15, 0.9, 0.35416666666667
27554, 1.15, 0.925, 0.375
27555, 1.15, 0.85, 0.35416666666667
27556, 1.15, 0.875, 0.375
27557, 1.15, 0.8, 0.35416666666667
27558, 1.15, 0.825, 0.375
27559, 1.15, 0.75, 0.35416666666667
27560, 1.15, 0.775, 0.375
27561, 1.15, 0.7, 0.35416666666667
27562, 1.15, 0.725, 0.375
27563, 1.15, 0.65, 0.35416666666667
27564, 1.15, 0.675, 0.375
27565, 1.15, 0.6, 0.35416666666667
27566, 1.15, 0.625, 0.375
27567, 1.15, 0.55, 0.35416666666667
27568, 1.15, 0.575, 0.375
27569, 1.15, 0.5, 0.35416666666667
27570, 1.15, 0.525, 0.375
27571, 1.15, 0.45, 0.35416666666667
27572, 1.15, 0.475, 0.375
27573, 1.15, 0.4, 0.35416666666667
27574, 1.15, 0.425, 0.375
27575, 1.15, 0.35, 0.35416666666667
27576, 1.15, 0.375, 0.375
27577, 1.15, 0.3, 0.35416666666667
27578, 1.15, 0.325, 0.375
27579, 1.15, 0.25, 0.35416666666667
27580, 1.15, 0.275, 0.375
27581, 1.15, 0.2, 0.35416666666667
27582, 1.15, 0.225, 0.375
27583, 1.15, 0.175, 0.375
27584, 1.15, 1.3, 0.39583333333333
27585, 1.15, 1.325, 0.41666666666667
27586, 1.15, 1.25, 0.39583333333333
27587, 1.15, 1.275, 0.41666666666667
27588, 1.15, 1.2, 0.39583333333333
27589, 1.15, 1.225, 0.41666666666667
27590, 1.15, 1.15, 0.39583333333333
27591, 1.15, 1.175, 0.41666666666667
27592, 1.15, 1.1, 0.39583333333333
27593, 1.15, 1.125, 0.41666666666667
27594, 1.15, 1.05, 0.39583333333333
27595, 1.15, 1.075, 0.41666666666667
27596, 1.15, 1, 0.39583333333333
27597, 1.15, 1.025, 0.41666666666667
27598, 1.15, 0.95, 0.39583333333333
27599, 1.15, 0.975, 0.41666666666667
27600, 1.15, 0.9, 0.39583333333333
27601, 1.15, 0.925, 0.41666666666667
27602, 1.15, 0.85, 0.39583333333333
27603, 1.15, 0.875, 0.41666666666667
27604, 1.15, 0.8, 0.39583333333333
27605, 1.15, 0.825, 0.41666666666667
27606, 1.15, 0.75, 0.39583333333333
27607, 1.15, 0.775, 0.41666666666667
27608, 1.15, 0.7, 0.39583333333333
27609, 1.15, 0.725, 0.41666666666667
27610, 1.15, 0.65, 0.39583333333333
27611, 1.15, 0.675, 0.41666666666667
27612, 1.15, 0.6, 0.39583333333333
27613, 1.15, 0.625, 0.41666666666667
27614, 1.15, 0.55, 0.39583333333333
27615, 1.15, 0.575, 0.41666666666667
27616, 1.15, 0.5, 0.39583333333333
27617, 1.15, 0.525, 0.41666666666667
27618, 1.15, 0.45, 0.39583333333333
27619, 1.15, 0.475, 0.41666666666667
27620, 1.15, 0.4, 0.39583333333333
27621, 1.15, 0.425, 0.41666666666667
27622, 1.15, 0.35, 0.39583333333333
27623, 1.15, 0.375, 0.41666666666667
27624, 1.15, 0.3, 0.39583333333333
27625, 1.15, 0.325, 0.41666666666667
27626, 1.15, 0.25, 0.39583333333333
27627, 1.15, 0.275, 0.41666666666667
27628, 1.15, 0.2, 0.39583333333333
27629, 1.15, 0.225, 0.41666666666667
27630, 1.15, 0.175, 0.41666666666667
27631, 1.15, 1.3, 0.4375
27632, 1.15, 1.325, 0.45833333333333
27633, 1.15, 1.25, 0.4375
27634, 1.15, 1.275, 0.45833333333333
27635, 1.15, 1.2, 0.4375
27636, 1.15, 1.225, 0.45833333333333
27637, 1.15, 1.15, 0.4375
27638, 1.15, 1.175, 0.45833333333333
27639, 1.15, 1.1, 0.4375
27640, 1.15, 1.125, 0.45833333333333
27641, 1.15, 1.05, 0.4375
27642, 1.15, 1.075, 0.45833333333333
27643, 1.15, 1, 0.4375
27644, 1.15, 1.025, 0.45833333333333
27645, 1.15, 0.95, 0.4375
27646, 1.15, 0.975, 0.45833333333333
27647, 1.15, 0.9, 0.4375
27648, 1.15, 0.925, 0.45833333333333
27649, 1.15, 0.85, 0.4375
27650, 1.15, 0.875, 0.45833333333333
27651, 1.15, 0.8, 0.4375
27652, 1.15, 0.825, 0.45833333333333
27653, 1.15, 0.75, 0.4375
27654, 1.15, 0.775, 0.45833333333333
27655, 1.15, 0.7, 0.4375
27656, 1.15, 0.725, 0.45833333333333
27657, 1.15, 0.65, 0.4375
27658, 1.15, 0.675, 0.45833333333333
27659, 1.15, 0.6, 0.4375
27660, 1.15, 0.625, 0.45833333333333
27661, 1.15, 0.55, 0.4375
27662, 1.15, 0.575, 0.45833333333333
27663, 1.15, 0.5, 0.4375
27664, 1.15, 0.525, 0.45833333333333
27665, 1.15, 0.45, 0.4375
27666, 1.15, 0.475, 0.45833333333333
27667, 1.15, 0.4, 0.4375
27668, 1.15, 0.425, 0.45833333333333
27669, 1.15, 0.35, 0.4375
27670, 1.15, 0.375, 0.45833333333333
27671, 1.15, 0.3, 0.4375
27672, 1.15, 0.325, 0.45833333333333
27673, 1.15, 0.25, 0.4375
27674, 1.15, 0.275, 0.45833333333333
27675, 1.15, 0.2, 0.4375
27676, 1.15, 0.225, 0.45833333333333
27677, 1.15, 0.175, 0.45833333333333
27678, 1.15, 1.3, 0.47916666666667
27679, 1.15, 1.25, 0.47916666666667
27680, 1.15, 1.2, 0.47916666666667
27681, 1.15, 1.15, 0.47916666666667
27682, 1.15, 1.1, 0.47916666666667
27683, 1.15, 1.05, 0.47916666666667
27684, 1.15, 1, 0.47916666666667
27685, 1.15, 0.95, 0.47916666666667
27686, 1.15, 0.9, 0.47916666666667
27687, 1.15, 0.85, 0.47916666666667
27688, 1.15, 0.8, 0.47916666666667
27689, 1.15, 0.75, 0.47916666666667
27690, 1.15, 0.7, 0.47916666666667
27691, 1.15, 0.65, 0.47916666666667
27692, 1.15, 0.6, 0.47916666666667
27693, 1.15, 0.55, 0.47916666666667
27694, 1.15, 0.5, 0.47916666666667
27695, 1.15, 0.45, 0.47916666666667
27696, 1.15, 0.4, 0.47916666666667
27697, 1.15, 0.35, 0.47916666666667
27698, 1.15, 0.3, 0.47916666666667
27699, 1.15, 0.25, 0.47916666666667
27700, 1.15, 0.2, 0.47916666666667
27701, 1, 0.2, -0.05
27702, 1, 0.25, -0.05
27703, 1, 0.3, -0.05
27704, 1, 0.35, -0.05
27705, 1, 0.4, -0.05
27706, 1, 0.45, -0.05
27707, 1, 0.5, -0.05
27708, 1, 0.55, -0.05
27709, 1, 0.6, -0.05
27710, 1, 0.65, -0.05
27711, 1, 0.7, -0.05
27712, 1, 0.75, -0.05
27713, 1, 0.8, -0.05
27714, 1, 0.85, -0.05
27715, 1, 0.9, -0.05
27716, 1, 0.95, -0.05
27717, 1, 1, -0.05
27718, 1, 1.05, -0.05
27719, 1, 1.1, -0.05
27720, 1, 1.15, -0.05
27721, 1, 1.2, -0.05
27722, 1, 1.25, -0.05
27723, 1, 1.3, -0.05
27724, 0, 0.2, -0.05
27725, 0, 0.25, -0.05
27726, 0, 0.3, -0.05
27727, 0, 0.35, -0.05
27728, 0, 0.4, -0.05
27729, 0, 0.45, -0.05
27730, 0, 0.5, -0.05
27731, 0, 0.55, -0.05
27732, 0, 0.6, -0.05
27733, 0, 0.65, -0.05
27734, 0, 0.7, -0.05
27735, 0, 0.75, -0.05
27736, 0, 0.8, -0.05
27737, 0, 0.85, -0.05
27738, 0, 0.9, -0.05
27739, 0, 0.95, -0.05
27740, 0, 1, -0.05
27741, 0, 1.05, -0.05
27742, 0, 1.1, -0.05
27743, 0, 1.15, -0.05
27744, 0, 1.2, -0.05
27745, 0, 1.25, -0.05
27746, 0, 1.3, -0.05
27747, 0.041666666666667, 0.15, -0.05
27748, 0.083333333333333, 0.15, -0.05
27749, 0.125, 0.15, -0.05
27750, 0.16666666666667, 0.15, -0.05
27751, 0.20833333333333, 0.15, -0.05
27752, 0.25, 0.15, -0.05
27753, 0.29166666666667, 0.15, -0.05
27754, 0.33333333333333, 0.15, -0.05
27755, 0.375, 0.15, -0.05
27756, 0.41666666666667, 0.15, -0.05
27757, 0.45833333333333, 0.15, -0.05
27758, 0.5, 0.15, -0.05
27759, 0.54166666666667, 0.15, -0.05
27760, 0.58333333333333, 0.15, -0.05
27761, 0.625, 0.15, -0.05
27762, 0.66666666666667, 0.15, -0.05
27763, 0.70833333333333, 0.15, -0.05
27764, 0.75, 0.15, -0.05
27765, 0.79166666666667, 0.15, -0.05
27766, 0.83333333333333, 0.15, -0.05
27767, 0.875, 0.15, -0.05
27768, 0.91666666666667, 0.15, -0.05
27769, 0.95833333333333, 0.15, -0.05
27770, 0.041666666666667, 1.35, -0.05
27771, 0.083333333333333, 1.35, -0.05
27772, 0.125, 1.35, -0.05
27773, 0.16666666666667, 1.35, -0.05
27774, 0.20833333333333, 1.35, -0.05
27775, 0.25, 1.35, -0.05
27776, 0.29166666666667, 1.35, -0.05
27777, 0.33333333333333, 1.35, -0.05
27778, 0.375, 1.35, -0.05
27779, 0.41666666666667, 1.35, -0.05
27780, 0.45833333333333, 1.35, -0.05
27781, 0.5, 1.35, -0.05
27782, 0.54166666666667, 1.35, -0.05
27783, 0.58333333333333, 1.35, -0.05
27784, 0.625, 1.35, -0.05
27785, 0.66666666666667, 1.35, -0.05
27786, 0.70833333333333, 1.35, -0.05
27787, 0.75, 1.35, -0.05
27788, 0.79166666666667, 1.35, -0.05
27789, 0.83333333333333, 1.35, -0.05
27790, 0.875, 1.35, -0.05
27791, 0.91666666666667, 1.35, -0.05
27792, 0.95833333333333, 1.35, -0.05
27793, 0.041666666666667, 0.2, -0.1
27794, 0.041666666666667, 0.25, -0.1
27795, 0.041666666666667, 0.3, -0.1
27796, 0.041666666666667, 0.35, -0.1
27797, 0.041666666666667, 0.4, -0.1
27798, 0.041666666666667, 0.45, -0.1
27799, 0.041666666666667, 0.5, -0.1
27800, 0.041666666666667, 0.55, -0.1
27801, 0.041666666666667, 0.6, -0.1
27802, 0.041666666666667, 0.65, -0.1
27803, 0.041666666666667, 0.7, -0.1
27804, 0.041666666666667, 0.75, -0.1
27805, 0.041666666666667, 0.8, -0.1
27806, 0.041666666666667, 0.85, -0.1
27807, 0.041666666666667, 0.9, -0.1
27808, 0.041666666666667, 0.95, -0.1
27809, 0.041666666666667, 1, -0.1
27810, 0.041666666666667, 1.05, -0.1
27811, 0.041666666666667, 1.1, -0.1
27812, 0.041666666666667, 1.15, -0.1
27813, 0.041666666666667, 1.2, -0.1
27814, 0.041666666666667, 1.25, -0.1
27815, 0.041666666666667, 1.3, -0.1
27816, 0.083333333333333, 0.2, -0.1
27817, 0.083333333333333, 0.25, -0.1
27818, 0.083333333333333, 0.3, -0.1
27819, 0.083333333333333, 0.35, -0.1
27820, 0.083333333333333, 0.4, -0.1
27821, 0.083333333333333, 0.45, -0.1
27822, 0.083333333333333, 0.5, -0.1
27823, 0.083333333333333, 0.55, -0.1
27824, 0.083333333333333, 0.6, -0.1
27825, 0.083333333333333, 0.65, -0.1
27826, 0.083333333333333, 0.7, -0.1
27827, 0.083333333333333, 0.75, -0.1
27828, 0.083333333333333, 0.8, -0.1
27829, 0.083333333333333, 0.85, -0.1
27830, 0.083333333333333, 0.9, -0.1
27831, 0.083333333333333, 0.95, -0.1
27832, 0.083333333333333, 1, -0.1
27833, 0.083333333333333, 1.05, -0.1
27834, 0.083333333333333, 1.1, -0.1
27835, 0.083333333333333, 1.15, -0.1
27836, 0.083333333333333, 1.2, -0.1
27837, 0.083333333333333, 1.25, -0.1
27838, 0.083333333333333, 1.3, -0.1
27839, 0.125, 0.2, -0.1
27840, 0.125, 0.25, -0.1
27841, 0.125, 0.3, -0.1
27842, 0.125, 0.35, -0.1
27843, 0.125, 0.4, -0.1
27844, 0.125, 0.45, -0.1
27845, 0.125, 0.5, -0.1
27846, 0.125, 0.55, -0.1
27847, 0.125, 0.6, -0.1
27848, 0.125, 0.65, -0.1
27849, 0.125, 0.7, -0.1
27850, 0.125, 0.75, -0.1
27851, 0.125, 0.8, -0.1
27852, 0.125, 0.85, -0.1
27853, 0.125, 0.9, -0.1
27854, 0.125, 0.95, -0.1
27855, 0.125, 1, -0.1
27856, 0.125, 1.05, -0.1
27857, 0.125, 1.1, -0.1
27858, 0.125, 1.15, -0.1
27859, 0.125, 1.2, -0.1
27860, 0.125, 1.25, -0.1
27861, 0.125, 1.3, -0.1
27862, 0.16666666666667, 0.2, -0.1
27863, 0.16666666666667, 0.25, -0.1
27864, 0.16666666666667, 0.3, -0.1
27865, 0.16666666666667, 0.35, -0.1
27866, 0.16666666666667, 0.4, -0.1
27867, 0.16666666666667, 0.45, -0.1
27868, 0.16666666666667, 0.5, -0.1
27869, 0.16666666666667, 0.55, -0.1
27870, 0.16666666666667, 0.6, -0.1
27871, 0.16666666666667, 0.65, -0.1
27872, 0.16666666666667, 0.7, -0.1
27873, 0.16666666666667, 0.75, -0.1
27874, 0.16666666666667, 0.8, -0.1
27875, 0.16666666666667, 0.85, -0.1
27876, 0.16666666666667, 0.9, -0.1
27877, 0.16666666666667, 0.95, -0.1
27878, 0.16666666666667, 1, -0.1
27879, 0.16666666666667, 1.05, -0.1
27880, 0.16666666666667, 1.1, -0.1
27881, 0.16666666666667, 1.15, -0.1
27882, 0.16666666666667, 1.2, -0.1
27883, 0.16666666666667, 1.25, -0.1
27884, 0.16666666666667, 1.3, -0.1
27885, 0.20833333333333, 0.2, -0.1
27886, 0.20833333333333, 0.25, -0.1
27887, 0.20833333333333, 0.3, -0.1
27888, 0.20833333333333, 0.35, -0.1
27889, 0.20833333333333, 0.4, -0.1
27890, 0.20833333333333, 0.45, -0.1
27891, 0.20833333333333, 0.5, -0.1
27892, 0.20833333333333, 0.55, -0.1
27893, 0.20833333333333, 0.6, -0.1
27894, 0.20833333333333, 0.65, -0.1
27895, 0.20833333333333, 0.7, -0.1
27896, 0.20833333333333, 0.75, -0.1
27897, 0.20833333333333, 0.8, -0.1
27898, 0.20833333333333, 0.85, -0.1
27899, 0.20833333333333, 0.9, -0.1
27900, 0.20833333333333, 0.95, -0.1
27901, 0.20833333333333, 1, -0.1
27902, 0.20833333333333, 1.05, -0.1
27903, 0.20833333333333, 1.1, -0.1
27904, 0.20833333333333, 1.15, -0.1
27905, 0.20833333333333, 1.2, -0.1
27906, 0.20833333333333, 1.25, -0.1
27907, 0.20833333333333, 1.3, -0.1
27908, 0.25, 0.2, -0.1
27909, 0.25, 0.25, -0.1
27910, 0.25, 0.3, -0.1
27911, 0.25, 0.35, -0.1
27912, 0.25, 0.4, -0.1
27913, 0.25, 0.45, -0.1
27914, 0.25, 0.5, -0.1
27915, 0.25, 0.55, -0.1
27916, 0.25, 0.6, -0.1
27917, 0.25, 0.65, -0.1
27918, 0.25, 0.7, -0.1
27919, 0.25, 0.75, -0.1
27920, 0.25, 0.8, -0.1
27921, 0.25, 0.85, -0.1
27922, 0.25, 0.9, -0.1
27923, 0.25, 0.95, -0.1
27924, 0.25, 1, -0.1
27925, 0.25, 1.05, -0.1
27926, 0.25, 1.1, -0.1
27927, 0.25, 1.15, -0.1
27928, 0.25, 1.2, -0.1
27929, 0.25, 1.25, -0.1
27930, 0.25, 1.3, -0.1
27931, 0.29166666666667, 0.2, -0.1
27932, 0.29166666666667, 0.25, -0.1
27933, 0.29166666666667, 0.3, -0.1
27934, 0.29166666666667, 0.35, -0.1
27935, 0.29166666666667, 0.4, -0.1
27936, 0.29166666666667, 0.45, -0.1
27937, 0.29166666666667, 0.5, -0.1
27938, 0.29166666666667, 0.55, -0.1
27939, 0.29166666666667, 0.6, -0.1
27940, 0.29166666666667, 0.65, -0.1
27941, 0.29166666666667, 0.7, -0.1
27942, 0.29166666666667, 0.75, -0.1
27943, 0.29166666666667, 0.8, -0.1
27944, 0.29166666666667, 0.85, -0.1
27945, 0.29166666666667, 0.9, -0.1
27946, 0.29166666666667, 0.95, -0.1
27947, 0.29166666666667, 1, -0.1
27948, 0.29166666666667, 1.05, -0.1
27949, 0.29166666666667, 1.1, -0.1
27950, 0.29166666666667, 1.15, -0.1
27951, 0.29166666666667, 1.2, -0.1
27952, 0.29166666666667, 1.25, -0.1
27953, 0.29166666666667, 1.3, -0.1
27954, 0.33333333333333, 0.2, -0.1
27955, 0.33333333333333, 0.25, -0.1
27956, 0.33333333333333, 0.3, -0.1
27957, 0.33333333333333, 0.35, -0.1
27958, 0.33333333333333, 0.4, -0.1
27959, 0.33333333333333, 0.45, -0.1
27960, 0.33333333333333, 0.5, -0.1
27961, 0.33333333333333, 0.55, -0.1
27962, 0.33333333333333, 0.6, -0.1
27963, 0.33333333333333, 0.65, -0.1
27964, 0.33333333333333, 0.7, -0.1
27965, 0.33333333333333, 0.75, -0.1
27966, 0.33333333333333, 0.8, -0.1
27967, 0.33333333333333, 0.85, -0.1
27968, 0.33333333333333, 0.9, -0.1
27969, 0.33333333333333, 0.95, -0.1
27970, 0.33333333333333, 1, -0.1
27971, 0.33333333333333, 1.05, -0.1
27972, 0.33333333333333, 1.1, -0.1
27973, 0.33333333333333, 1.15, -0.1
27974, 0.33333333333333, 1.2, -0.1
27975, 0.33333333333333, 1.25, -0.1
27976, 0.33333333333333, 1.3, -0.1
27977, 0.375, 0.2, -0.1
27978, 0.375, 0.25, -0.1
27979, 0.375, 0.3, -0.1
27980, 0.375, 0.35, -0.1
27981, 0.375, 0.4, -0.1
27982, 0.375, 0.45, -0.1
27983, 0.375, 0.5, -0.1
27984, 0.375, 0.55, -0.1
27985, 0.375, 0.6, -0.1
27986, 0.375, 0.65, -0.1
27987, 0.375, 0.7, -0.1
27988, 0.375, 0.75, -0.1
27989, 0.375, 0.8, -0.1
27990, 0.375, 0.85, -0.1
27991, 0.375, 0.9, -0.1
27992, 0.375, 0.95, -0.1
27993, 0.375, 1, -0.1
27994, 0.375, 1.05, -0.1
27995, 0.375, 1.1, -0.1
27996, 0.375, 1.15, -0.1
27997, 0.375, 1.2, -0.1
27998, 0.375, 1.25, -0.1
27999, 0.375, 1.3, -0.1
28000, 0.41666666666667, 0.2, -0.1
28001, 0.41666666666667, 0.25, -0.1
28002, 0.41666666666667, 0.3, -0.1
28003, 0.41666666666667, 0.35, -0.1
28004, 0.41666666666667, 0.4, -0.1
28005, 0.41666666666667, 0.45, -0.1
28006, 0.41666666666667, 0.5, -0.1
28007, 0.41666666666667, 0.55, -0.1
28008, 0.41666666666667, 0.6, -0.1
28009, 0.41666666666667, 0.65, -0.1
28010, 0.41666666666667, 0.7, -0.1
28011, 0.41666666666667, 0.75, -0.1
28012, 0.41666666666667, 0.8, -0.1
28013, 0.41666666666667, 0.85, -0.1
28014, 0.41666666666667, 0.9, -0.1
28015, 0.41666666666667, 0.95, -0.1
28016, 0.41666666666667, 1, -0.1
28017, 0.41666666666667, 1.05, -0.1
28018, 0.41666666666667, 1.1, -0.1
28019, 0.41666666666667, 1.15, -0.1
28020, 0.41666666666667, 1.2, -0.1
28021, 0.41666666666667, 1.25, -0.1
28022, 0.41666666666667, 1.3, -0.1
28023, 0.45833333333333, 0.2, -0.1
28024, 0.45833333333333, 0.25, -0.1
28025, 0.45833333333333, 0.3, -0.1
28026, 0.45833333333333, 0.35, -0.1
28027, 0.45833333333333, 0.4, -0.1
28028, 0.45833333333333, 0.45, -0.1
28029, 0.45833333333333, 0.5, -0.1
28030, 0.45833333333333, 0.55, -0.1
28031, 0.45833333333333, 0.6, -0.1
28032, 0.45833333333333, 0.65, -0.1
28033, 0.45833333333333, 0.7, -0.1
28034, 0.45833333333333, 0.75, -0.1
28035, 0.45833333333333, 0.8, -0.1
28036, 0.45833333333333, 0.85, -0.1
28037, 0.45833333333333, 0.9, -0.1
28038, 0.45833333333333, 0.95, -0.1
28039, 0.45833333333333, 1, -0.1
28040, 0.45833333333333, 1.05, -0.1
28041, 0.45833333333333, 1.1, -0.1
28042, 0.45833333333333, 1.15, -0.1
28043, 0.45833333333333, 1.2, -0.1
28044, 0.45833333333333, 1.25, -0.1
28045, 0.45833333333333, 1.3, -0.1
28046, 0.5, 0.2, -0.1
28047, 0.5, 0.25, -0.1
28048, 0.5, 0.3, -0.1
28049, 0.5, 0.35, -0.1
28050, 0.5, 0.4, -0.1
28051, 0.5, 0.45, -0.1
28052, 0.5, 0.5, -0.1
28053, 0.5, 0.55, -0.1
28054, 0.5, 0.6, -0.1
28055, 0.5, 0.65, -0.1
28056, 0.5, 0.7, -0.1
28057, 0.5, 0.75, -0.1
28058, 0.5, 0.8, -0.1
28059, 0.5, 0.85, -0.1
28060, 0.5, 0.9, -0.1
28061, 0.5, 0.95, -0.1
28062, 0.5, 1, -0.1
28063, 0.5, 1.05, -0.1
28064, 0.5, 1.1, -0.1
28065, 0.5, 1.15, -0.1
28066, 0.5, 1.2, -0.1
28067, 0.5, 1.25, -0.1
28068, 0.5, 1.3, -0.1
28069, 0.54166666666667, 0.2, -0.1
28070, 0.54166666666667, 0.25, -0.1
28071, 0.54166666666667, 0.3, -0.1
28072, 0.54166666666667, 0.35, -0.1
28073, 0.54166666666667, 0.4, -0.1
28074, 0.54166666666667, 0.45, -0.1
28075, 0.54166666666667, 0.5, -0.1
28076, 0.54166666666667, 0.55, -0.1
28077, 0.54166666666667, 0.6, -0.1
28078, 0.54166666666667, 0.65, -0.1
28079, 0.54166666666667, 0.7, -0.1
28080, 0.54166666666667, 0.75, -0.1
28081, 0.54166666666667, 0.8, -0.1
28082, 0.54166666666667, 0.85, -0.1
28083, 0.54166666666667, 0.9, -0.1
28084, 0.54166666666667, 0.95, -0.1
28085, 0.54166666666667, 1, -0.1
28086, 0.54166666666667, 1.05, -0.1
28087, 0.54166666666667, 1.1, -0.1
28088, 0.54166666666667, 1.15, -0.1
28089, 0.54166666666667, 1.2, -0.1
28090, 0.54166666666667, 1.25, -0.1
28091, 0.54166666666667, 1.3, -0.1
28092, 0.58333333333333, 0.2, -0.1
28093, 0.58333333333333, 0.25, -0.1
28094, 0.58333333333333, 0.3, -0.1
28095, 0.58333333333333, 0.35, -0.1
28096, 0.58333333333333, 0.4, -0.1
28097, 0.58333333333333, 0.45, -0.1
28098, 0.58333333333333, 0.5, -0.1
28099, 0.58333333333333, 0.55, -0.1
28100, 0.58333333333333, 0.6, -0.1
28101, 0.58333333333333, 0.65, -0.1
28102, 0.58333333333333, 0.7, -0.1
28103, 0.58333333333333, 0.75, -0.1
28104, 0.58333333333333, 0.8, -0.1
28105, 0.58333333333333, 0.85, -0.1
28106, 0.58333333333333, 0.9, -0.1
28107, 0.58333333333333, 0.95, -0.1
28108, 0.58333333333333, 1, -0.1
28109, 0.58333333333333, 1.05, -0.1
28110, 0.58333333333333, 1.1, -0.1
28111, 0.58333333333333, 1.15, -0.1
28112, 0.58333333333333, 1.2, -0.1
28113, 0.58333333333333, 1.25, -0.1
28114, 0.58333333333333, 1.3, -0.1
28115, 0.625, 0.2, -0.1
28116, 0.625, 0.25, -0.1
28117, 0.625, 0.3, -0.1
28118, 0.625, 0.35, -0.1
28119, 0.625, 0.4, -0.1
28120, 0.625, 0.45, -0.1
28121, 0.625, 0.5, -0.1
28122, 0.625, 0.55, -0.1
28123, 0.625, 0.6, -0.1
28124, 0.625, 0.65, -0.1
28125, 0.625, 0.7, -0.1
28126, 0.625, 0.75, -0.1
28127, 0.625, 0.8, -0.1
28128, 0.625, 0.85, -0.1
28129, 0.625, 0.9, -0.1
28130, 0.625, 0.95, -0.1
28131, 0.625, 1, -0.1
28132, 0.625, 1.05, -0.1
28133, 0.625, 1.1, -0.1
28134, 0.625, 1.15, -0.1
28135, 0.625, 1.2, -0.1
28136, 0.625, 1.25, -0.1
28137, 0.625, 1.3, -0.1
28138, 0.66666666666667, 0.2, -0.1
28139, 0.66666666666667, 0.25, -0.1
28140, 0.66666666666667, 0.3, -0.1
28141, 0.66666666666667, 0.35, -0.1
28142, 0.66666666666667, 0.4, -0.1
28143, 0.66666666666667, 0.45, -0.1
28144, 0.66666666666667, 0.5, -0.1
28145, 0.66666666666667, 0.55, -0.1
28146, 0.66666666666667, 0.6, -0.1
28147, 0.66666666666667, 0.65, -0.1
28148, 0.66666666666667, 0.7, -0.1
28149, 0.66666666666667, 0.75, -0.1
28150, 0.66666666666667, 0.8, -0.1
28151, 0.66666666666667, 0.85, -0.1
28152, 0.66666666666667, 0.9, -0.1
28153, 0.66666666666667, 0.95, -0.1
28154, 0.66666666666667, 1, -0.1
28155, 0.66666666666667, 1.05, -0.1
28156, 0.66666666666667, 1.1, -0.1
28157, 0.66666666666667, 1.15, -0.1
28158, 0.66666666666667, 1.2, -0.1
28159, 0.66666666666667, 1.25, -0.1
28160, 0.66666666666667, 1.3, -0.1
28161, 0.70833333333333, 0.2, -0.1
28162, 0.70833333333333, 0.25, -0.1
28163, 0.70833333333333, 0.3, -0.1
28164, 0.70833333333333, 0.35, -0.1
28165, 0.70833333333333, 0.4, -0.1
28166, 0.70833333333333, 0.45, -0.1
28167, 0.70833333333333, 0.5, -0.1
28168, 0.70833333333333, 0.55, -0.1
28169, 0.70833333333333, 0.6, -0.1
28170, 0.70833333333333, 0.65, -0.1
28171, 0.70833333333333, 0.7, -0.1
28172, 0.70833333333333, 0.75, -0.1
28173, 0.70833333333333, 0.8, -0.1
28174, 0.70833333333333, 0.85, -0.1
28175, 0.70833333333333, 0.9, -0.1
28176, 0.70833333333333, 0.95, -0.1
28177, 0.70833333333333, 1, -0.1
28178, 0.70833333333333, 1.05, -0.1
28179, 0.70833333333333, 1.1, -0.1
28180, 0.70833333333333, 1.15, -0.1
28181, 0.70833333333333, 1.2, -0.1
28182, 0.70833333333333, 1.25, -0.1
28183, 0.70833333333333, 1.3, -0.1
28184, 0.75, 0.2, -0.1
28185, 0.75, 0.25, -0.1
28186, 0.75, 0.3, -0.1
28187, 0.75, 0.35, -0.1
28188, 0.75, 0.4, -0.1
28189, 0.75, 0.45, -0.1
28190, 0.75, 0.5, -0.1
28191, 0.75, 0.55, -0.1
28192, 0.75, 0.6, -0.1
28193, 0.75, 0.65, -0.1
28194, 0.75, 0.7, -0.1
28195, 0.75, 0.75, -0.1
28196, 0.75, 0.8, -0.1
28197, 0.75, 0.85, -0.1
28198, 0.75, 0.9, -0.1
28199, 0.75, 0.95, -0.1
28200, 0.75, 1, -0.1
28201, 0.75, 1.05, -0.1
28202, 0.75, 1.1, -0.1
28203, 0.75, 1.15, -0.1
28204, 0.75, 1.2, -0.1
28205, 0.75, 1.25, -0.1
28206, 0.75, 1.3, -0.1
28207, 0.79166666666667, 0.2, -0.1
28208, 0.79166666666667, 0.25, -0.1
28209, 0.79166666666667, 0.3, -0.1
28210, 0.79166666666667, 0.35, -0.1
28211, 0.79166666666667, 0.4, -0.1
28212, 0.79166666666667, 0.45, -0.1
28213, 0.79166666666667, 0.5, -0.1
28214, 0.79166666666667, 0.55, -0.1
28215, 0.79166666666667, 0.6, -0.1
28216, 0.79166666666667, 0.65, -0.1
28217, 0.79166666666667, 0.7, -0.1
28218, 0.79166666666667, 0.75, -0.1
28219, 0.79166666666667, 0.8, -0.1
28220, 0.79166666666667, 0.85, -0.1
28221, 0.79166666666667, 0.9, -0.1
28222, 0.79166666666667, 0.95, -0.1
28223, 0.79166666666667, 1, -0.1
28224, 0.79166666666667, 1.05, -0.1
28225, 0.79166666666667, 1.1, -0.1
28226, 0.79166666666667, 1.15, -0.1
28227, 0.79166666666667, 1.2, -0.1
28228, 0.79166666666667, 1.25, -0.1
28229, 0.79166666666667, 1.3, -0.1
28230, 0.83333333333333, 0.2, -0.1
28231, 0.83333333333333, 0.25, -0.1
28232, 0.83333333333333, 0.3, -0.1
28233, 0.83333333333333, 0.35, -0.1
28234, 0.83333333333333, 0.4, -0.1
28235, 0.83333333333333, 0.45, -0.1
28236, 0.83333333333333, 0.5, -0.1
28237, 0.83333333333333, 0.55, -0.1
28238, 0.83333333333333, 0.6, -0.1
28239, 0.83333333333333, 0.65, -0.1
28240, 0.83333333333333, 0.7, -0.1
28241, 0.83333333333333, 0.75, -0.1
28242, 0.83333333333333, 0.8, -0.1
28243, 0.83333333333333, 0.85, -0.1
28244, 0.83333333333333, 0.9, -0.1
28245, 0.83333333333333, 0.95, -0.1
28246, 0.83333333333333, 1, -0.1
28247, 0.83333333333333, 1.05, -0.1
28248, 0.83333333333333, 1.1, -0.1
28249, 0.83333333333333, 1.15, -0.1
28250, 0.83333333333333, 1.2, -0.1
28251, 0.83333333333333, 1.25, -0.1
28252, 0.83333333333333, 1.3, -0.1
28253, 0.875, 0.2, -0.1
28254, 0.875, 0.25, -0.1
28255, 0.875, 0.3, -0.1
28256, 0.875, 0.35, -0.1
28257, 0.875, 0.4, -0.1
28258, 0.875, 0.45, -0.1
28259, 0.875, 0.5, -0.1
28260, 0.875, 0.55, -0.1
28261, 0.875, 0.6, -0.1
28262, 0.875, 0.65, -0.1
28263, 0.875, 0.7, -0.1
28264, 0.875, 0.75, -0.1
28265, 0.875, 0.8, -0.1
28266, 0.875, 0.85, -0.1
28267, 0.875, 0.9, -0.1
28268, 0.875, 0.95, -0.1
28269, 0.875, 1, -0.1
28270, 0.875, 1.05, -0.1
28271, 0.875, 1.1, -0.1
28272, 0.875, 1.15, -0.1
28273, 0.875, 1.2, -0.1
28274, 0.875, 1.25, -0.1
28275, 0.875, 1.3, -0.1
28276, 0.91666666666667, 0.2, -0.1
28277, 0.91666666666667, 0.25, -0.1
28278, 0.91666666666667, 0.3, -0.1
28279, 0.91666666666667, 0.35, -0.1
28280, 0.91666666666667, 0.4, -0.1
28281, 0.91666666666667, 0.45, -0.1
28282, 0.91666666666667, 0.5, -0.1
28283, 0.91666666666667, 0.55, -0.1
28284, 0.91666666666667, 0.6, -0.1
28285, 0.91666666666667, 0.65, -0.1
28286, 0.91666666666667, 0.7, -0.1
28287, 0.91666666666667, 0.75, -0.1
28288, 0.91666666666667, 0.8, -0.1
28289, 0.91666666666667, 0.85, -0.1
28290, 0.91666666666667, 0.9, -0.1
28291, 0.91666666666667, 0.95, -0.1
28292, 0.91666666666667, 1, -0.1
28293, 0.91666666666667, 1.05, -0.1
28294, 0.91666666666667, 1.1, -0.1
28295, 0.91666666666667, 1.15, -0.1
28296, 0.91666666666667, 1.2, -0.1
28297, 0.91666666666667, 1.25, -0.1
28298, 0.91666666666667, 1.3, -0.1
28299, 0.95833333333333, 0.2, -0.1
28300, 0.95833333333333, 0.25, -0.1
28301, 0.95833333333333, 0.3, -0.1
28302, 0.95833333333333, 0.35, -0.1
28303, 0.95833333333333, 0.4, -0.1
28304, 0.95833333333333, 0.45, -0.1
28305, 0.95833333333333, 0.5, -0.1
28306, 0.95833333333333, 0.55, -0.1
28307, 0.95833333333333, 0.6, -0.1
28308, 0.95833333333333, 0.65, -0.1
28309, 0.95833333333333, 0.7, -0.1
28310, 0.95833333333333, 0.75, -0.1
28311, 0.95833333333333, 0.8, -0.1
28312, 0.95833333333333, 0.85, -0.1
28313, 0.95833333333333, 0.9, -0.1
28314, 0.95833333333333, 0.95, -0.1
28315, 0.95833333333333, 1, -0.1
28316, 0.95833333333333, 1.05, -0.1
28317, 0.95833333333333, 1.1, -0.1
28318, 0.95833333333333, 1.15, -0.1
28319, 0.95833333333333, 1.2, -0.1
28320, 0.95833333333333, 1.25, -0.1
28321, 0.95833333333333, 1.3, -0.1
28322, 0.020833333333333, 0.2, -0.1
28323, 0.041666666666667, 0.175, -0.1
28324, 0.020833333333333, 0.25, -0.1
28325, 0.041666666666667, 0.225, -0.1
28326, 0.020833333333333, 0.3, -0.1
28327, 0.041666666666667, 0.275, -0.1
28328, 0.020833333333333, 0.35, -0.1
28329, 0.041666666666667, 0.325, -0.1
28330, 0.020833333333333, 0.4, -0.1
28331, 0.041666666666667, 0.375, -0.1
28332, 0.020833333333333, 0.45, -0.1
28333, 0.041666666666667, 0.425, -0.1
28334, 0.020833333333333, 0.5, -0.1
28335, 0.041666666666667, 0.475, -0.1
28336, 0.020833333333333, 0.55, -0.1
28337, 0.041666666666667, 0.525, -0.1
28338, 0.020833333333333, 0.6, -0.1
28339, 0.041666666666667, 0.575, -0.1
28340, 0.020833333333333, 0.65, -0.1
28341, 0.041666666666667, 0.625, -0.1
28342, 0.020833333333333, 0.7, -0.1
28343, 0.041666666666667, 0.675, -0.1
28344, 0.020833333333333, 0.75, -0.1
28345, 0.041666666666667, 0.725, -0.1
28346, 0.020833333333333, 0.8, -0.1
28347, 0.041666666666667, 0.775, -0.1
28348, 0.020833333333333, 0.85, -0.1
28349, 0.041666666666667, 0.825, -0.1
28350, 0.020833333333333, 0.9, -0.1
28351, 0.041666666666667, 0.875, -0.1
28352, 0.020833333333333, 0.95, -0.1
28353, 0.041666666666667, 0.925, -0.1
28354, 0.020833333333333, 1, -0.1
28355, 0.041666666666667, 0.975, -0.1
28356, 0.020833333333333, 1.05, -0.1
28357, 0.041666666666667, 1.025, -0.1
28358, 0.020833333333333, 1.1, -0.1
28359, 0.041666666666667, 1.075, -0.1
28360, 0.020833333333333, 1.15, -0.1
28361, 0.041666666666667, 1.125, -0.1
28362, 0.020833333333333, 1.2, -0.1
28363, 0.041666666666667, 1.175, -0.1
28364, 0.020833333333333, 1.25, -0.1
28365, 0.041666666666667, 1.225, -0.1
28366, 0.020833333333333, 1.3, -0.1
28367, 0.041666666666667, 1.275, -0.1
28368, 0.041666666666667, 1.325, -0.1
28369, 0.0625, 0.2, -0.1
28370, 0.083333333333333, 0.175, -0.1
28371, 0.0625, 0.25, -0.1
28372, 0.083333333333333, 0.225, -0.1
28373, 0.0625, 0.3, -0.1
28374, 0.083333333333333, 0.275, -0.1
28375, 0.0625, 0.35, -0.1
28376, 0.083333333333333, 0.325, -0.1
28377, 0.0625, 0.4, -0.1
28378, 0.083333333333333, 0.375, -0.1
28379, 0.0625, 0.45, -0.1
28380, 0.083333333333333, 0.425, -0.1
28381, 0.0625, 0.5, -0.1
28382, 0.083333333333333, 0.475, -0.1
28383, 0.0625, 0.55, -0.1
28384, 0.083333333333333, 0.525, -0.1
28385, 0.0625, 0.6, -0.1
28386, 0.083333333333333, 0.575, -0.1
28387, 0.0625, 0.65, -0.1
28388, 0.083333333333333, 0.625, -0.1
28389, 0.0625, 0.7, -0.1
28390, 0.083333333333333, 0.675, -0.1
28391, 0.0625, 0.75, -0.1
28392, 0.083333333333333, 0.725, -0.1
28393, 0.0625, 0.8, -0.1
28394, 0.083333333333333, 0.775, -0.1
28395, 0.0625, 0.85, -0.1
28396, 0.083333333333333, 0.825, -0.1
28397, 0.0625, 0.9, -0.1
28398, 0.083333333333333, 0.875, -0.1
28399, 0.0625, 0.95, -0.1
28400, 0.083333333333333, 0.925, -0.1
28401, 0.0625, 1, -0.1
28402, 0.083333333333333, 0.975, -0.1
28403, 0.0625, 1.05, -0.1
28404, 0.083333333333333, 1.025, -0.1
28405, 0.0625, 1.1, -0.1
28406, 0.083333333333333, 1.075, -0.1
28407, 0.0625, 1.15, -0.1
28408, 0.083333333333333, 1.125, -0.1
28409, 0.0625, 1.2, -0.1
28410, 0.083333333333333, 1.175, -0.1
28411, 0.0625, 1.25, -0.1
28412, 0.083333333333333, 1.225, -0.1
28413, 0.0625, 1.3, -0.1
28414, 0.083333333333333, 1.275, -0.1
28415, 0.083333333333333, 1.325, -0.1
28416, 0.10416666666667, 0.2, -0.1
28417, 0.125, 0.175, -0.1
28418, 0.10416666666667, 0.25, -0.1
28419, 0.125, 0.225, -0.1
28420, 0.10416666666667, 0.3, -0.1
28421, 0.125, 0.275, -0.1
28422, 0.10416666666667, 0.35, -0.1
28423, 0.125, 0.325, -0.1
28424, 0.10416666666667, 0.4, -0.1
28425, 0.125, 0.375, -0.1
28426, 0.10416666666667, 0.45, -0.1
28427, 0.125, 0.425, -0.1
28428, 0.10416666666667, 0.5, -0.1
28429, 0.125, 0.475, -0.1
28430, 0.10416666666667, 0.55, -0.1
28431, 0.125, 0.525, -0.1
28432, 0.10416666666667, 0.6, -0.1
28433, 0.125, 0.575, -0.1
28434, 0.10416666666667, 0.65, -0.1
28435, 0.125, 0.625, -0.1
28436, 0.10416666666667, 0.7, -0.1
28437, 0.125, 0.675, -0.1
28438, 0.10416666666667, 0.75, -0.1
28439, 0.125, 0.725, -0.1
28440, 0.10416666666667, 0.8, -0.1
28441, 0.125, 0.775, -0.1
28442, 0.10416666666667, 0.85, -0.1
28443, 0.125, 0.825, -0.1
28444, 0.10416666666667, 0.9, -0.1
28445, 0.125, 0.875, -0.1
28446, 0.10416666666667, 0.95, -0.1
28447, 0.125, 0.925, -0.1
28448, 0.10416666666667, 1, -0.1
28449, 0.125, 0.975, -0.1
28450, 0.10416666666667, 1.05, -0.1
28451, 0.125, 1.025, -0.1
28452, 0.10416666666667, 1.1, -0.1
28453, 0.125, 1.075, -0.1
28454, 0.10416666666667, 1.15, -0.1
28455, 0.125, 1.125, -0.1
28456, 0.10416666666667, 1.2, -0.1
28457, 0.125, 1.175, -0.1
28458, 0.10416666666667, 1.25, -0.1
28459, 0.125, 1.225, -0.1
28460, 0.10416666666667, 1.3, -0.1
28461, 0.125, 1.275, -0.1
28462, 0.125, 1.325, -0.1
28463, 0.14583333333333, 0.2, -0.1
28464, 0.16666666666667, 0.175, -0.1
28465, 0.14583333333333, 0.25, -0.1
28466, 0.16666666666667, 0.225, -0.1
28467, 0.14583333333333, 0.3, -0.1
28468, 0.16666666666667, 0.275, -0.1
28469, 0.14583333333333, 0.35, -0.1
28470, 0.16666666666667, 0.325, -0.1
28471, 0.14583333333333, 0.4, -0.1
28472, 0.16666666666667, 0.375, -0.1
28473, 0.14583333333333, 0.45, -0.1
28474, 0.16666666666667, 0.425, -0.1
28475, 0.14583333333333, 0.5, -0.1
28476, 0.16666666666667, 0.475, -0.1
28477, 0.14583333333333, 0.55, -0.1
28478, 0.16666666666667, 0.525, -0.1
28479, 0.14583333333333, 0.6, -0.1
28480, 0.16666666666667, 0.575, -0.1
28481, 0.14583333333333, 0.65, -0.1
28482, 0.16666666666667, 0.625, -0.1
28483, 0.14583333333333, 0.7, -0.1
28484, 0.16666666666667, 0.675, -0.1
28485, 0.14583333333333, 0.75, -0.1
28486, 0.16666666666667, 0.725, -0.1
28487, 0.14583333333333, 0.8, -0.1
28488, 0.16666666666667, 0.775, -0.1
28489, 0.14583333333333, 0.85, -0.1
28490, 0.16666666666667, 0.825, -0.1
28491, 0.14583333333333, 0.9, -0.1
28492, 0.16666666666667, 0.875, -0.1
28493, 0.14583333333333, 0.95, -0.1
28494, 0.16666666666667, 0.925, -0.1
28495, 0.14583333333333, 1, -0.1
28496, 0.16666666666667, 0.975, -0.1
28497, 0.14583333333333, 1.05, -0.1
28498, 0.16666666666667, 1.025, -0.1
28499, 0.14583333333333, 1.1, -0.1
28500, 0.16666666666667, 1.075, -0.1
28501, 0.14583333333333, 1.15, -0.1
28502, 0.16666666666667, 1.125, -0.1
28503, 0.14583333333333, 1.2, -0.1
28504, 0.16666666666667, 1.175, -0.1
28505, 0.14583333333333, 1.25, -0.1
28506, 0.16666666666667, 1.225, -0.1
28507, 0.14583333333333, 1.3, -0.1
28508, 0.16666666666667, 1.275, -0.1
28509, 0.16666666666667, 1.325, -0.1
28510, 0.1875, 0.2, -0.1
28511, 0.20833333333333, 0.175, -0.1
28512, 0.1875, 0.25, -0.1
28513, 0.20833333333333, 0.225, -0.1
28514, 0.1875, 0.3, -0.1
28515, 0.20833333333333, 0.275, -0.1
28516, 0.1875, 0.35, -0.1
28517, 0.20833333333333, 0.325, -0.1
28518, 0.1875, 0.4, -0.1
28519, 0.20833333333333, 0.375, -0.1
28520, 0.1875, 0.45, -0.1
28521, 0.20833333333333, 0.425, -0.1
28522, 0.1875, 0.5, -0.1
28523, 0.20833333333333, 0.475, -0.1
28524, 0.1875, 0.55, -0.1
28525, 0.20833333333333, 0.525, -0.1
28526, 0.1875, 0.6, -0.1
28527, 0.20833333333333, 0.575, -0.1
28528, 0.1875, 0.65, -0.1
28529, 0.20833333333333, 0.625, -0.1
28530, 0.1875, 0.7, -0.1
28531, 0.20833333333333, 0.675, -0.1
28532, 0.1875, 0.75, -0.1
28533, 0.20833333333333, 0.725, -0.1
28534, 0.1875, 0.8, -0.1
28535, 0.20833333333333, 0.775, -0.1
28536, 0.1875, 0.85, -0.1
28537, 0.20833333333333, 0.825, -0.1
28538, 0.1875, 0.9, -0.1
28539, 0.20833333333333, 0.875, -0.1
28540, 0.1875, 0.95, -0.1
28541, 0.20833333333333, 0.925, -0.1
28542, 0.1875, 1, -0.1
28543, 0.20833333333333, 0.975, -0.1
28544, 0.1875, 1.05, -0.1
28545, 0.20833333333333, 1.025, -0.1
28546, 0.1875, 1.1, -0.1
28547, 0.20833333333333, 1.075, -0.1
28548, 0.1875, 1.15, -0.1
28549, 0.20833333333333, 1.125, -0.1
28550, 0.1875, 1.2, -0.1
28551, 0.20833333333333, 1.175, -0.1
28552, 0.1875, 1.25, -0.1
28553, 0.20833333333333, 1.225, -0.1
28554, 0.1875, 1.3, -0.1
28555, 0.20833333333333, 1.275, -0.1
28556, 0.20833333333333, 1.325, -0.1
28557, 0.22916666666667, 0.2, -0.1
28558, 0.25, 0.175, -0.1
28559, 0.22916666666667, 0.25, -0.1
28560, 0.25, 0.225, -0.1
28561, 0.22916666666667, 0.3, -0.1
28562, 0.25, 0.275, -0.1
28563, 0.22916666666667, 0.35, -0.1
28564, 0.25, 0.325, -0.1
28565, 0.22916666666667, 0.4, -0.1
28566, 0.25, 0.375, -0.1
28567, 0.22916666666667, 0.45, -0.1
28568, 0.25, 0.425, -0.1
28569, 0.22916666666667, 0.5, -0.1
28570, 0.25, 0.475, -0.1
28571, 0.22916666666667, 0.55, -0.1
28572, 0.25, 0.525, -0.1
28573, 0.22916666666667, 0.6, -0.1
28574, 0.25, 0.575, -0.1
28575, 0.22916666666667, 0.65, -0.1
28576, 0.25, 0.625, -0.1
28577, 0.22916666666667, 0.7, -0.1
28578, 0.25, 0.675, -0.1
28579, 0.22916666666667, 0.75, -0.1
28580, 0.25, 0.725, -0.1
28581, 0.22916666666667, 0.8, -0.1
28582, 0.25, 0.775, -0.1
28583, 0.22916666666667, 0.85, -0.1
28584, 0.25, 0.825, -0.1
28585, 0.22916666666667, 0.9, -0.1
28586, 0.25, 0.875, -0.1
28587, 0.22916666666667, 0.95, -0.1
28588, 0.25, 0.925, -0.1
28589, 0.22916666666667, 1, -0.1
28590, 0.25, 0.975, -0.1
28591, 0.22916666666667, 1.05, -0.1
28592, 0.25, 1.025, -0.1
28593, 0.22916666666667, 1.1, -0.1
28594, 0.25, 1.075, -0.1
28595, 0.22916666666667, 1.15, -0.1
28596, 0.25, 1.125, -0.1
28597, 0.22916666666667, 1.2, -0.1
28598, 0.25, 1.175, -0.1
28599, 0.22916666666667, 1.25, -0.1
28600, 0.25, 1.225, -0.1
28601, 0.22916666666667, 1.3, -0.1
28602, 0.25, 1.275, -0.1
28603, 0.25, 1.325, -0.1
28604, 0.27083333333333, 0.2, -0.1
28605, 0.29166666666667, 0.175, -0.1
28606, 0.27083333333333, 0.25, -0.1
28607, 0.29166666666667, 0.225, -0.1
28608, 0.27083333333333, 0.3, -0.1
28609, 0.29166666666667, 0.275, -0.1
28610, 0.27083333333333, 0.35, -0.1
28611, 0.29166666666667, 0.325, -0.1
28612, 0.27083333333333, 0.4, -0.1
28613, 0.29166666666667, 0.375, -0.1
28614, 0.27083333333333, 0.45, -0.1
28615, 0.29166666666667, 0.425, -0.1
28616, 0.27083333333333, 0.5, -0.1
28617, 0.29166666666667, 0.475, -0.1
28618, 0.27083333333333, 0.55, -0.1
28619, 0.29166666666667, 0.525, -0.1
28620, 0.27083333333333, 0.6, -0.1
28621, 0.29166666666667, 0.575, -0.1
28622, 0.27083333333333, 0.65, -0.1
28623, 0.29166666666667, 0.625, -0.1
28624, 0.27083333333333, 0.7, -0.1
28625, 0.29166666666667, 0.675, -0.1
28626, 0.27083333333333, 0.75, -0.1
28627, 0.29166666666667, 0.725, -0.1
28628, 0.27083333333333, 0.8, -0.1
28629, 0.29166666666667, 0.775, -0.1
28630, 0.27083333333333, 0.85, -0.1
28631, 0.29166666666667, 0.825, -0.1
28632, 0.27083333333333, 0.9, -0.1
28633, 0.29166666666667, 0.875, -0.1
28634, 0.27083333333333, 0.95, -0.1
28635, 0.29166666666667, 0.925, -0.1
28636, 0.27083333333333, 1, -0.1
28637, 0.29166666666667, 0.975, -0.1
28638, 0.27083333333333, 1.05, -0.1
28639, 0.29166666666667, 1.025, -0.1
28640, 0.27083333333333, 1.1, -0.1
28641, 0.29166666666667, 1.075, -0.1
28642, 0.27083333333333, 1.15, -0.1
28643, 0.29166666666667, 1.125, -0.1
28644, 0.27083333333333, 1.2, -0.1
28645, 0.29166666666667, 1.175, -0.1
28646, 0.27083333333333, 1.25, -0.1
28647, 0.29166666666667, 1.225, -0.1
28648, 0.27083333333333, 1.3, -0.1
28649, 0.29166666666667, 1.275, -0.1
28650, 0.29166666666667, 1.325, -0.1
28651, 0.3125, 0.2, -0.1
28652, 0.33333333333333, 0.175, -0.1
28653, 0.3125, 0.25, -0.1
28654, 0.33333333333333, 0.225, -0.1
28655, 0.3125, 0.3, -0.1
28656, 0.33333333333333, 0.275, -0.1
28657, 0.3125, 0.35, -0.1
28658, 0.33333333333333, 0.325, -0.1
28659, 0.3125, 0.4, -0.1
28660, 0.33333333333333, 0.375, -0.1
28661, 0.3125, 0.45, -0.1
28662, 0.33333333333333, 0.425, -0.1
28663, 0.3125, 0.5, -0.1
28664, 0.33333333333333, 0.475, -0.1
28665, 0.3125, 0.55, -0.1
28666, 0.33333333333333, 0.525, -0.1
28667, 0.3125, 0.6, -0.1
28668, 0.33333333333333, 0.575, -0.1
28669, 0.3125, 0.65, -0.1
28670, 0.33333333333333, 0.625, -0.1
28671, 0.3125, 0.7, -0.1
28672, 0.33333333333333, 0.675, -0.1
28673, 0.3125, 0.75, -0.1
28674, 0.33333333333333, 0.725, -0.1
28675, 0.3125, 0.8, -0.1
28676, 0.33333333333333, 0.775, -0.1
28677, 0.3125, 0.85, -0.1
28678, 0.33333333333333, 0.825, -0.1
28679, 0.3125, 0.9, -0.1
28680, 0.33333333333333, 0.875, -0.1
28681, 0.3125, 0.95, -0.1
28682, 0.33333333333333, 0.925, -0.1
28683, 0.3125, 1, -0.1
28684, 0.33333333333333, 0.975, -0.1
28685, 0.3125, 1.05, -0.1
28686, 0.33333333333333, 1.025, -0.1
28687, 0.3125, 1.1, -0.1
28688, 0.33333333333333, 1.075, -0.1
28689, 0.3125, 1.15, -0.1
28690, 0.33333333333333, 1.125, -0.1
28691, 0.3125, 1.2, -0.1
28692, 0.33333333333333, 1.175, -0.1
28693, 0.3125, 1.25, -0.1
28694, 0.33333333333333, 1.225, -0.1
28695, 0.3125, 1.3, -0.1
28696, 0.33333333333333, 1.275, -0.1
28697, 0.33333333333333, 1.325, -0.1
28698, 0.35416666666667, 0.2, -0.1
28699, 0.375, 0.175, -0.1
28700, 0.35416666666667, 0.25, -0.1
28701, 0.375, 0.225, -0.1
28702, 0.35416666666667, 0.3, -0.1
28703, 0.375, 0.275, -0.1
28704, 0.35416666666667, 0.35, -0.1
28705, 0.375, 0.325, -0.1
28706, 0.35416666666667, 0.4, -0.1
28707, 0.375, 0.375, -0.1
28708, 0.35416666666667, 0.45, -0.1
28709, 0.375, 0.425, -0.1
28710, 0.35416666666667, 0.5, -0.1
28711, 0.375, 0.475, -0.1
28712, 0.35416666666667, 0.55, -0.1
28713, 0.375, 0.525, -0.1
28714, 0.35416666666667, 0.6, -0.1
28715, 0.375, 0.575, -0.1
28716, 0.35416666666667, 0.65, -0.1
28717, 0.375, 0.625, -0.1
28718, 0.35416666666667, 0.7, -0.1
28719, 0.375, 0.675, -0.1
28720, 0.35416666666667, 0.75, -0.1
28721, 0.375, 0.725, -0.1
28722, 0.35416666666667, 0.8, -0.1
28723, 0.375, 0.775, -0.1
28724, 0.35416666666667, 0.85, -0.1
28725, 0.375, 0.825, -0.1
28726, 0.35416666666667, 0.9, -0.1
28727, 0.375, 0.875, -0.1
28728, 0.35416666666667, 0.95, -0.1
28729, 0.375, 0.925, -0.1
28730, 0.35416666666667, 1, -0.1
28731, 0.375, 0.975, -0.1
28732, 0.35416666666667, 1.05, -0.1
28733, 0.375, 1.025, -0.1
28734, 0.35416666666667, 1.1, -0.1
28735, 0.375, 1.075, -0.1
28736, 0.35416666666667, 1.15, -0.1
28737, 0.375, 1.125, -0.1
28738, 0.35416666666667, 1.2, -0.1
28739, 0.375, 1.175, -0.1
28740, 0.35416666666667, 1.25, -0.1
28741, 0.375, 1.225, -0.1
28742, 0.35416666666667, 1.3, -0.1
28743, 0.375, 1.275, -0.1
28744, 0.375, 1.325, -0.1
28745, 0.39583333333333, 0.2, -0.1
28746, 0.41666666666667, 0.175, -0.1
28747, 0.39583333333333, 0.25, -0.1
28748, 0.41666666666667, 0.225, -0.1
28749, 0.39583333333333, 0.3, -0.1
28750, 0.41666666666667, 0.275, -0.1
28751, 0.39583333333333, 0.35, -0.1
28752, 0.41666666666667, 0.325, -0.1
28753, 0.39583333333333, 0.4, -0.1
28754, 0.41666666666667, 0.375, -0.1
28755, 0.39583333333333, 0.45, -0.1
28756, 0.41666666666667, 0.425, -0.1
28757, 0.39583333333333, 0.5, -0.1
28758, 0.41666666666667, 0.475, -0.1
28759, 0.39583333333333, 0.55, -0.1
28760, 0.41666666666667, 0.525, -0.1
28761, 0.39583333333333, 0.6, -0.1
28762, 0.41666666666667, 0.575, -0.1
28763, 0.39583333333333, 0.65, -0.1
28764, 0.41666666666667, 0.625, -0.1
28765, 0.39583333333333, 0.7, -0.1
28766, 0.41666666666667, 0.675, -0.1
28767, 0.39583333333333, 0.75, -0.1
28768, 0.41666666666667, 0.725, -0.1
28769, 0.39583333333333, 0.8, -0.1
28770, 0.41666666666667, 0.775, -0.1
28771, 0.39583333333333, 0.85, -0.1
28772, 0.41666666666667, 0.825, -0.1
28773, 0.39583333333333, 0.9, -0.1
28774, 0.41666666666667, 0.875, -0.1
28775, 0.39583333333333, 0.95, -0.1
28776, 0.41666666666667, 0.925, -0.1
28777, 0.39583333333333, 1, -0.1
28778, 0.41666666666667, 0.975, -0.1
28779, 0.39583333333333, 1.05, -0.1
28780, 0.41666666666667, 1.025, -0.1
28781, 0.39583333333333, 1.1, -0.1
28782, 0.41666666666667, 1.075, -0.1
28783, 0.39583333333333, 1.15, -0.1
28784, 0.41666666666667, 1.125, -0.1
28785, 0.39583333333333, 1.2, -0.1
28786, 0.41666666666667, 1.175, -0.1
28787, 0.39583333333333, 1.25, -0.1
28788, 0.41666666666667, 1.225, -0.1
28789, 0.39583333333333, 1.3, -0.1
28790, 0.41666666666667, 1.275, -0.1
28791, 0.41666666666667, 1.325, -0.1
28792, 0.4375, 0.2, -0.1
28793, 0.45833333333333, 0.175, -0.1
28794, 0.4375, 0.25, -0.1
28795, 0.45833333333333, 0.225, -0.1
28796, 0.4375, 0.3, -0.1
28797, 0.45833333333333, 0.275, -0.1
28798, 0.4375, 0.35, -0.1
28799, 0.45833333333333, 0.325, -0.1
28800, 0.4375, 0.4, -0.1
28801, 0.45833333333333, 0.375, -0.1
28802, 0.4375, 0.45, -0.1
28803, 0.45833333333333, 0.425, -0.1
28804, 0.4375, 0.5, -0.1
28805, 0.45833333333333, 0.475, -0.1
28806, 0.4375, 0.55, -0.1
28807, 0.45833333333333, 0.525, -0.1
28808, 0.4375, 0.6, -0.1
28809, 0.45833333333333, 0.575, -0.1
28810, 0.4375, 0.65, -0.1
28811, 0.45833333333333, 0.625, -0.1
28812, 0.4375, 0.7, -0.1
28813, 0.45833333333333, 0.675, -0.1
28814, 0.4375, 0.75, -0.1
28815, 0.45833333333333, 0.725, -0.1
28816, 0.4375, 0.8, -0.1
28817, 0.45833333333333, 0.775, -0.1
28818, 0.4375, 0.85, -0.1
28819, 0.45833333333333, 0.825, -0.1
28820, 0.4375, 0.9, -0.1
28821, 0.45833333333333, 0.875, -0.1
28822, 0.4375, 0.95, -0.1
28823, 0.45833333333333, 0.925, -0.1
28824, 0.4375, 1, -0.1
28825, 0.45833333333333, 0.975, -0.1
28826, 0.4375, 1.05, -0.1
28827, 0.45833333333333, 1.025, -0.1
28828, 0.4375, 1.1, -0.1
28829, 0.45833333333333, 1.075, -0.1
28830, 0.4375, 1.15, -0.1
28831, 0.45833333333333, 1.125, -0.1
28832, 0.4375, 1.2, -0.1
28833, 0.45833333333333, 1.175, -0.1
28834, 0.4375, 1.25, -0.1
28835, 0.45833333333333, 1.225, -0.1
28836, 0.4375, 1.3, -0.1
28837, 0.45833333333333, 1.275, -0.1
28838, 0.45833333333333, 1.325, -0.1
28839, 0.47916666666667, 0.2, -0.1
28840, 0.5, 0.175, -0.1
28841, 0.47916666666667, 0.25, -0.1
28842, 0.5, 0.225, -0.1
28843, 0.47916666666667, 0.3, -0.1
28844, 0.5, 0.275, -0.1
28845, 0.47916666666667, 0.35, -0.1
28846, 0.5, 0.325, -0.1
28847, 0.47916666666667, 0.4, -0.1
28848, 0.5, 0.375, -0.1
28849, 0.47916666666667, 0.45, -0.1
28850, 0.5, 0.425, -0.1
28851, 0.47916666666667, 0.5, -0.1
28852, 0.5, 0.475, -0.1
28853, 0.47916666666667, 0.55, -0.1
28854, 0.5, 0.525, -0.1
28855, 0.47916666666667, 0.6, -0.1
28856, 0.5, 0.575, -0.1
28857, 0.47916666666667, 0.65, -0.1
28858, 0.5, 0.625, -0.1
28859, 0.47916666666667, 0.7, -0.1
28860, 0.5, 0.675, -0.1
28861, 0.47916666666667, 0.75, -0.1
28862, 0.5, 0.725, -0.1
28863, 0.47916666666667, 0.8, -0.1
28864, 0.5, 0.775, -0.1
28865, 0.47916666666667, 0.85, -0.1
28866, 0.5, 0.825, -0.1
28867, 0.47916666666667, 0.9, -0.1
28868, 0.5, 0.875, -0.1
28869, 0.47916666666667, 0.95, -0.1
28870, 0.5, 0.925, -0.1
28871, 0.47916666666667, 1, -0.1
28872, 0.5, 0.975, -0.1
28873, 0.47916666666667, 1.05, -0.1
28874, 0.5, 1.025, -0.1
28875, 0.47916666666667, 1.1, -0.1
28876, 0.5, 1.075, -0.1
28877, 0.47916666666667, 1.15, -0.1
28878, 0.5, 1.125, -0.1
28879, 0.47916666666667, 1.2, -0.1
28880, 0.5, 1.175, -0.1
28881, 0.47916666666667, 1.25, -0.1
28882, 0.5, 1.225, -0.1
28883, 0.47916666666667, 1.3, -0.1
28884, 0.5, 1.275, -0.1
28885, 0.5, 1.325, -0.1
28886, 0.52083333333333, 0.2, -0.1
28887, 0.54166666666667, 0.175, -0.1
28888, 0.52083333333333, 0.25, -0.1
28889, 0.54166666666667, 0.225, -0.1
28890, 0.52083333333333, 0.3, -0.1
28891, 0.54166666666667, 0.275, -0.1
28892, 0.52083333333333, 0.35, -0.1
28893, 0.54166666666667, 0.325, -0.1
28894, 0.52083333333333, 0.4, -0.1
28895, 0.54166666666667, 0.375, -0.1
28896, 0.52083333333333, 0.45, -0.1
28897, 0.54166666666667, 0.425, -0.1
28898, 0.52083333333333, 0.5, -0.1
28899, 0.54166666666667, 0.475, -0.1
28900, 0.52083333333333, 0.55, -0.1
28901, 0.54166666666667, 0.525, -0.1
28902, 0.52083333333333, 0.6, -0.1
28903, 0.54166666666667, 0.575, -0.1
28904, 0.52083333333333, 0.65, -0.1
28905, 0.54166666666667, 0.625, -0.1
28906, 0.52083333333333, 0.7, -0.1
28907, 0.54166666666667, 0.675, -0.1
28908, 0.52083333333333, 0.75, -0.1
28909, 0.54166666666667, 0.725, -0.1
28910, 0.52083333333333, 0.8, -0.1
28911, 0.54166666666667, 0.775, -0.1
28912, 0.52083333333333, 0.85, -0.1
28913, 0.54166666666667, 0.825, -0.1
28914, 0.52083333333333, 0.9, -0.1
28915, 0.54166666666667, 0.875, -0.1
28916, 0.52083333333333, 0.95, -0.1
28917, 0.54166666666667, 0.925, -0.1
28918, 0.52083333333333, 1, -0.1
28919, 0.54166666666667, 0.975, -0.1
28920, 0.52083333333333, 1.05, -0.1
28921, 0.54166666666667, 1.025, -0.1
28922, 0.52083333333333, 1.1, -0.1
28923, 0.54166666666667, 1.075, -0.1
28924, 0.52083333333333, 1.15, -0.1
28925, 0.54166666666667, 1.125, -0.1
28926, 0.52083333333333, 1.2, -0.1
28927, 0.54166666666667, 1.175, -0.1
28928, 0.52083333333333, 1.25, -0.1
28929, 0.54166666666667, 1.225, -0.1
28930, 0.52083333333333, 1.3, -0.1
28931, 0.54166666666667, 1.275, -0.1
28932, 0.54166666666667, 1.325, -0.1
28933, 0.5625, 0.2, -0.1
28934, 0.58333333333333, 0.175, -0.1
28935, 0.5625, 0.25, -0.1
28936, 0.58333333333333, 0.225, -0.1
28937, 0.5625, 0.3, -0.1
28938, 0.58333333333333, 0.275, -0.1
28939, 0.5625, 0.35, -0.1
28940, 0.58333333333333, 0.325, -0.1
28941, 0.5625, 0.4, -0.1
28942, 0.58333333333333, 0.375, -0.1
28943, 0.5625, 0.45, -0.1
28944, 0.58333333333333, 0.425, -0.1
28945, 0.5625, 0.5, -0.1
28946, 0.58333333333333, 0.475, -0.1
28947, 0.5625, 0.55, -0.1
28948, 0.58333333333333, 0.525, -0.1
28949, 0.5625, 0.6, -0.1
28950, 0.58333333333333, 0.575, -0.1
28951, 0.5625, 0.65, -0.1
28952, 0.58333333333333, 0.625, -0.1
28953, 0.5625, 0.7, -0.1
28954, 0.58333333333333, 0.675, -0.1
28955, 0.5625, 0.75, -0.1
28956, 0.58333333333333, 0.725, -0.1
28957, 0.5625, 0.8, -0.1
28958, 0.58333333333333, 0.775, -0.1
28959, 0.5625, 0.85, -0.1
28960, 0.58333333333333, 0.825, -0.1
28961, 0.5625, 0.9, -0.1
28962, 0.58333333333333, 0.875, -0.1
28963, 0.5625, 0.95, -0.1
28964, 0.58333333333333, 0.925, -0.1
28965, 0.5625, 1, -0.1
28966, 0.58333333333333, 0.975, -0.1
28967, 0.5625, 1.05, -0.1
28968, 0.58333333333333, 1.025, -0.1
28969, 0.5625, 1.1, -0.1
28970, 0.58333333333333, 1.075, -0.1
28971, 0.5625, 1.15, -0.1
28972, 0.58333333333333, 1.125, -0.1
28973, 0.5625, 1.2, -0.1
28974, 0.58333333333333, 1.175, -0.1
28975, 0.5625, 1.25, -0.1
28976, 0.58333333333333, 1.225, -0.1
28977, 0.5625, 1.3, -0.1
28978, 0.58333333333333, 1.275, -0.1
28979, 0.58333333333333, 1.325, -0.1
28980, 0.60416666666667, 0.2, -0.1
28981, 0.625, 0.175, -0.1
28982, 0.60416666666667, 0.25, -0.1
28983, 0.625, 0.225, -0.1
28984, 0.60416666666667, 0.3, -0.1
28985, 0.625, 0.275, -0.1
28986, 0.60416666666667, 0.35, -0.1
28987, 0.625, 0.325, -0.1
28988, 0.60416666666667, 0.4, -0.1
28989, 0.625, 0.375, -0.1
28990, 0.60416666666667, 0.45, -0.1
28991, 0.625, 0.425, -0.1
28992, 0.60416666666667, 0.5, -0.1
28993, 0.625, 0.475, -0.1
28994, 0.60416666666667, 0.55, -0.1
28995, 0.625, 0.525, -0.1
28996, 0.60416666666667, 0.6, -0.1
28997, 0.625, 0.575, -0.1
28998, 0.60416666666667, 0.65, -0.1
28999, 0.625, 0.625, -0.1
29000, 0.60416666666667, 0.7, -0.1
29001, 0.625, 0.675, -0.1
29002, 0.60416666666667, 0.75, -0.1
29003, 0.625, 0.725, -0.1
29004, 0.60416666666667, 0.8, -0.1
29005, 0.625, 0.775, -0.1
29006, 0.60416666666667, 0.85, -0.1
29007, 0.625, 0.825, -0.1
29008, 0.60416666666667, 0.9, -0.1
29009, 0.625, 0.875, -0.1
29010, 0.60416666666667, 0.95, -0.1
29011, 0.625, 0.925, -0.1
29012, 0.60416666666667, 1, -0.1
29013, 0.625, 0.975, -0.1
29014, 0.60416666666667, 1.05, -0.1
29015, 0.625, 1.025, -0.1
29016, 0.60416666666667, 1.1, -0.1
29017, 0.625, 1.075, -0.1
29018, 0.60416666666667, 1.15, -0.1
29019, 0.625, 1.125, -0.1
29020, 0.60416666666667, 1.2, -0.1
29021, 0.625, 1.175, -0.1
29022, 0.60416666666667, 1.25, -0.1
29023, 0.625, 1.225, -0.1
29024, 0.60416666666667, 1.3, -0.1
29025, 0.625, 1.275, -0.1
29026, 0.625, 1.325, -0.1
29027, 0.64583333333333, 0.2, -0.1
29028, 0.66666666666667, 0.175, -0.1
29029, 0.64583333333333, 0.25, -0.1
29030, 0.66666666666667, 0.225, -0.1
29031, 0.64583333333333, 0.3, -0.1
29032, 0.66666666666667, 0.275, -0.1
29033, 0.64583333333333, 0.35, -0.1
29034, 0.66666666666667, 0.325, -0.1
29035, 0.64583333333333, 0.4, -0.1
29036, 0.66666666666667, 0.375, -0.1
29037, 0.64583333333333, 0.45, -0.1
29038, 0.66666666666667, 0.425, -0.1
29039, 0.64583333333333, 0.5, -0.1
29040, 0.66666666666667, 0.475, -0.1
29041, 0.64583333333333, 0.55, -0.1
29042, 0.66666666666667, 0.525, -0.1
29043, 0.64583333333333, 0.6, -0.1
29044, 0.66666666666667, 0.575, -0.1
29045, 0.64583333333333, 0.65, -0.1
29046, 0.66666666666667, 0.625, -0.1
29047, 0.64583333333333, 0.7, -0.1
29048, 0.66666666666667, 0.675, -0.1
29049, 0.64583333333333, 0.75, -0.1
29050, 0.66666666666667, 0.725, -0.1
29051, 0.64583333333333, 0.8, -0.1
29052, 0.66666666666667, 0.775, -0.1
29053, 0.64583333333333, 0.85, -0.1
29054, 0.66666666666667, 0.825, -0.1
29055, 0.64583333333333, 0.9, -0.1
29056, 0.66666666666667, 0.875, -0.1
29057, 0.64583333333333, 0.95, -0.1
29058, 0.66666666666667, 0.925, -0.1
29059, 0.64583333333333, 1, -0.1
29060, 0.66666666666667, 0.975, -0.1
29061, 0.64583333333333, 1.05, -0.1
29062, 0.66666666666667, 1.025, -0.1
29063, 0.64583333333333, 1.1, -0.1
29064, 0.66666666666667, 1.075, -0.1
29065, 0.64583333333333, 1.15, -0.1
29066, 0.66666666666667, 1.125, -0.1
29067, 0.64583333333333, 1.2, -0.1
29068, 0.66666666666667, 1.175, -0.1
29069, 0.64583333333333, 1.25, -0.1
29070, 0.66666666666667, 1.225, -0.1
29071, 0.64583333333333, 1.3, -0.1
29072, 0.66666666666667, 1.275, -0.1
29073, 0.66666666666667, 1.325, -0.1
29074, 0.6875, 0.2, -0.1
29075, 0.70833333333333, 0.175, -0.1
29076, 0.6875, 0.25, -0.1
29077, 0.70833333333333, 0.225, -0.1
29078, 0.6875, 0.3, -0.1
29079, 0.70833333333333, 0.275, -0.1
29080, 0.6875, 0.35, -0.1
29081, 0.70833333333333, 0.325, -0.1
29082, 0.6875, 0.4, -0.1
29083, 0.70833333333333, 0.375, -0.1
29084, 0.6875, 0.45, -0.1
29085, 0.70833333333333, 0.425, -0.1
29086, 0.6875, 0.5, -0.1
29087, 0.70833333333333, 0.475, -0.1
29088, 0.6875, 0.55, -0.1
29089, 0.70833333333333, 0.525, -0.1
29090, 0.6875, 0.6, -0.1
29091, 0.70833333333333, 0.575, -0.1
29092, 0.6875, 0.65, -0.1
29093, 0.70833333333333, 0.625, -0.1
29094, 0.6875, 0.7, -0.1
29095, 0.70833333333333, 0.675, -0.1
29096, 0.6875, 0.75, -0.1
29097, 0.70833333333333, 0.725, -0.1
29098, 0.6875, 0.8, -0.1
29099, 0.70833333333333, 0.775, -0.1
29100, 0.6875, 0.85, -0.1
29101, 0.70833333333333, 0.825, -0.1
29102, 0.6875, 0.9, -0.1
29103, 0.70833333333333, 0.875, -0.1
29104, 0.6875, 0.95, -0.1
29105, 0.70833333333333, 0.925, -0.1
29106, 0.6875, 1, -0.1
29107, 0.70833333333333, 0.975, -0.1
29108, 0.6875, 1.05, -0.1
29109, 0.70833333333333, 1.025, -0.1
29110, 0.6875, 1.1, -0.1
29111, 0.70833333333333, 1.075, -0.1
29112, 0.6875, 1.15, -0.1
29113, 0.70833333333333, 1.125, -0.1
29114, 0.6875, 1.2, -0.1
29115, 0.70833333333333, 1.175, -0.1
29116, 0.6875, 1.25, -0.1
29117, 0.70833333333333, 1.225, -0.1
29118, 0.6875, 1.3, -0.1
29119, 0.70833333333333, 1.275, -0.1
29120, 0.70833333333333, 1.325, -0.1
29121, 0.72916666666667, 0.2, -0.1
29122, 0.75, 0.175, -0.1
29123, 0.72916666666667, 0.25, -0.1
29124, 0.75, 0.225, -0.1
29125, 0.72916666666667, 0.3, -0.1
29126, 0.75, 0.275, -0.1
29127, 0.72916666666667, 0.35, -0.1
29128, 0.75, 0.325, -0.1
29129, 0.72916666666667, 0.4, -0.1
29130, 0.75, 0.375, -0.1
29131, 0.72916666666667, 0.45, -0.1
29132, 0.75, 0.425, -0.1
29133, 0.72916666666667, 0.5, -0.1
29134, 0.75, 0.475, -0.1
29135, 0.72916666666667, 0.55, -0.1
29136, 0.75, 0.525, -0.1
29137, 0.72916666666667, 0.6, -0.1
29138, 0.75, 0.575, -0.1
29139, 0.72916666666667, 0.65, -0.1
29140, 0.75, 0.625, -0.1
29141, 0.72916666666667, 0.7, -0.1
29142, 0.75, 0.675, -0.1
29143, 0.72916666666667, 0.75, -0.1
29144, 0.75, 0.725, -0.1
29145, 0.72916666666667, 0.8, -0.1
29146, 0.75, 0.775, -0.1
29147, 0.72916666666667, 0.85, -0.1
29148, 0.75, 0.825, -0.1
29149, 0.72916666666667, 0.9, -0.1
29150, 0.75, 0.875, -0.1
29151, 0.72916666666667, 0.95, -0.1
29152, 0.75, 0.925, -0.1
29153, 0.72916666666667, 1, -0.1
29154, 0.75, 0.975, -0.1
29155, 0.72916666666667, 1.05, -0.1
29156, 0.75, 1.025, -0.1
29157, 0.72916666666667, 1.1, -0.1
29158, 0.75, 1.075, -0.1
29159, 0.72916666666667, 1.15, -0.1
29160, 0.75, 1.125, -0.1
29161, 0.72916666666667, 1.2, -0.1
29162, 0.75, 1.175, -0.1
29163, 0.72916666666667, 1.25, -0.1
29164, 0.75, 1.225, -0.1
29165, 0.72916666666667, 1.3, -0.1
29166, 0.75, 1.275, -0.1
29167, 0.75, 1.325, -0.1
29168, 0.77083333333333, 0.2, -0.1
29169, 0.79166666666667, 0.175, -0.1
29170, 0.77083333333333, 0.25, -0.1
29171, 0.79166666666667, 0.225, -0.1
29172, 0.77083333333333, 0.3, -0.1
29173, 0.79166666666667, 0.275, -0.1
29174, 0.77083333333333, 0.35, -0.1
29175, 0.79166666666667, 0.325, -0.1
29176, 0.77083333333333, 0.4, -0.1
29177, 0.79166666666667, 0.375, -0.1
29178, 0.77083333333333, 0.45, -0.1
29179, 0.79166666666667, 0.425, -0.1
29180, 0.77083333333333, 0.5, -0.1
29181, 0.79166666666667, 0.475, -0.1
29182, 0.77083333333333, 0.55, -0.1
29183, 0.79166666666667, 0.525, -0.1
29184, 0.77083333333333, 0.6, -0.1
29185, 0.79166666666667, 0.575, -0.1
29186, 0.77083333333333, 0.65, -0.1
29187, 0.79166666666667, 0.625, -0.1
29188, 0.77083333333333, 0.7, -0.1
29189, 0.79166666666667, 0.675, -0.1
29190, 0.77083333333333, 0.75, -0.1
29191, 0.79166666666667, 0.725, -0.1
29192, 0.77083333333333, 0.8, -0.1
29193, 0.79166666666667, 0.775, -0.1
29194, 0.77083333333333, 0.85, -0.1
29195, 0.79166666666667, 0.825, -0.1
29196, 0.77083333333333, 0.9, -0.1
29197, 0.79166666666667, 0.875, -0.1
29198, 0.77083333333333, 0.95, -0.1
29199, 0.79166666666667, 0.925, -0.1
29200, 0.77083333333333, 1, -0.1
29201, 0.79166666666667, 0.975, -0.1
29202, 0.77083333333333, 1.05, -0.1
29203, 0.79166666666667, 1.025, -0.1
29204, 0.77083333333333, 1.1, -0.1
29205, 0.79166666666667, 1.075, -0.1
29206, 0.77083333333333, 1.15, -0.1
29207, 0.79166666666667, 1.125, -0.1
29208, 0.77083333333333, 1.2, -0.1
29209, 0.79166666666667, 1.175, -0.1
29210, 0.77083333333333, 1.25, -0.1
29211, 0.79166666666667, 1.225, -0.1
29212, 0.77083333333333, 1.3, -0.1
29213, 0.79166666666667, 1.275, -0.1
29214, 0.79166666666667, 1.325, -0.1
29215, 0.8125, 0.2, -0.1
29216, 0.83333333333333, 0.175, -0.1
29217, 0.8125, 0.25, -0.1
29218, 0.83333333333333, 0.225, -0.1
29219, 0.8125, 0.3, -0.1
29220, 0.83333333333333, 0.275, -0.1
29221, 0.8125, 0.35, -0.1
29222, 0.83333333333333, 0.325, -0.1
29223, 0.8125, 0.4, -0.1
29224, 0.83333333333333, 0.375, -0.1
29225, 0.8125, 0.45, -0.1
29226, 0.83333333333333, 0.425, -0.1
29227, 0.8125, 0.5, -0.1
29228, 0.83333333333333, 0.475, -0.1
29229, 0.8125, 0.55, -0.1
29230, 0.83333333333333, 0.525, -0.1
29231, 0.8125, 0.6, -0.1
29232, 0.83333333333333, 0.575, -0.1
29233, 0.8125, 0.65, -0.1
29234, 0.83333333333333, 0.625, -0.1
29235, 0.8125, 0.7, -0.1
29236, 0.83333333333333, 0.675, -0.1
29237, 0.8125, 0.75, -0.1
29238, 0.83333333333333, 0.725, -0.1
29239, 0.8125, 0.8, -0.1
29240, 0.83333333333333, 0.775, -0.1
29241, 0.8125, 0.85, -0.1
29242, 0.83333333333333, 0.825, -0.1
29243, 0.8125, 0.9, -0.1
29244, 0.83333333333333, 0.875, -0.1
29245, 0.8125, 0.95, -0.1
29246, 0.83333333333333, 0.925, -0.1
29247, 0.8125, 1, -0.1
29248, 0.83333333333333, 0.975, -0.1
29249, 0.8125, 1.05, -0.1
29250, 0.83333333333333, 1.025, -0.1
29251, 0.8125, 1.1, -0.1
29252, 0.83333333333333, 1.075, -0.1
29253, 0.8125, 1.15, -0.1
29254, 0.83333333333333, 1.125, -0.1
29255, 0.8125, 1.2, -0.1
29256, 0.83333333333333, 1.175, -0.1
29257, 0.8125, 1.25, -0.1
29258, 0.83333333333333, 1.225, -0.1
29259, 0.8125, 1.3, -0.1
29260, 0.83333333333333, 1.275, -0.1
29261, 0.83333333333333, 1.325, -0.1
29262, 0.85416666666667, 0.2, -0.1
29263, 0.875, 0.175, -0.1
29264, 0.85416666666667, 0.25, -0.1
29265, 0.875, 0.225, -0.1
29266, 0.85416666666667, 0.3, -0.1
29267, 0.875, 0.275, -0.1
29268, 0.85416666666667, 0.35, -0.1
29269, 0.875, 0.325, -0.1
29270, 0.85416666666667, 0.4, -0.1
29271, 0.875, 0.375, -0.1
29272, 0.85416666666667, 0.45, -0.1
29273, 0.875, 0.425, -0.1
29274, 0.85416666666667, 0.5, -0.1
29275, 0.875, 0.475, -0.1
29276, 0.85416666666667, 0.55, -0.1
29277, 0.875, 0.525, -0.1
29278, 0.85416666666667, 0.6, -0.1
29279, 0.875, 0.575, -0.1
29280, 0.85416666666667, 0.65, -0.1
29281, 0.875, 0.625, -0.1
29282, 0.85416666666667, 0.7, -0.1
29283, 0.875, 0.675, -0.1
29284, 0.85416666666667, 0.75, -0.1
29285, 0.875, 0.725, -0.1
29286, 0.85416666666667, 0.8, -0.1
29287, 0.875, 0.775, -0.1
29288, 0.85416666666667, 0.85, -0.1
29289, 0.875, 0.825, -0.1
29290, 0.85416666666667, 0.9, -0.1
29291, 0.875, 0.875, -0.1
29292, 0.85416666666667, 0.95, -0.1
29293, 0.875, 0.925, -0.1
29294, 0.85416666666667, 1, -0.1
29295, 0.875, 0.975, -0.1
29296, 0.85416666666667, 1.05, -0.1
29297, 0.875, 1.025, -0.1
29298, 0.85416666666667, 1.1, -0.1
29299, 0.875, 1.075, -0.1
29300, 0.85416666666667, 1.15, -0.1
29301, 0.875, 1.125, -0.1
29302, 0.85416666666667, 1.2, -0.1
29303, 0.875, 1.175, -0.1
29304, 0.85416666666667, 1.25, -0.1
29305, 0.875, 1.225, -0.1
29306, 0.85416666666667, 1.3, -0.1
29307, 0.875, 1.275, -0.1
29308, 0.875, 1.325, -0.1
29309, 0.89583333333333, 0.2, -0.1
29310, 0.91666666666667, 0.175, -0.1
29311, 0.89583333333333, 0.25, -0.1
29312, 0.91666666666667, 0.225, -0.1
29313, 0.89583333333333, 0.3, -0.1
29314, 0.91666666666667, 0.275, -0.1
29315, 0.89583333333333, 0.35, -0.1
29316, 0.91666666666667, 0.325, -0.1
29317, 0.89583333333333, 0.4, -0.1
29318, 0.91666666666667, 0.375, -0.1
29319, 0.89583333333333, 0.45, -0.1
29320, 0.91666666666667, 0.425, -0.1
29321, 0.89583333333333, 0.5, -0.1
29322, 0.91666666666667, 0.475, -0.1
29323, 0.89583333333333, 0.55, -0.1
29324, 0.91666666666667, 0.525, -0.1
29325, 0.89583333333333, 0.6, -0.1
29326, 0.91666666666667, 0.575, -0.1
29327, 0.89583333333333, 0.65, -0.1
29328, 0.91666666666667, 0.625, -0.1
29329, 0.89583333333333, 0.7, -0.1
29330, 0.91666666666667, 0.675, -0.1
29331, 0.89583333333333, 0.75, -0.1
29332, 0.91666666666667, 0.725, -0.1
29333, 0.89583333333333, 0.8, -0.1
29334, 0.91666666666667, 0.775, -0.1
29335, 0.89583333333333, 0.85, -0.1
29336, 0.91666666666667, 0.825, -0.1
29337, 0.89583333333333, 0.9, -0.1
29338, 0.91666666666667, 0.875, -0.1
29339, 0.89583333333333, 0.95, -0.1
29340, 0.91666666666667, 0.925, -0.1
29341, 0.89583333333333, 1, -0.1
29342, 0.91666666666667, 0.975, -0.1
29343, 0.89583333333333, 1.05, -0.1
29344, 0.91666666666667, 1.025, -0.1
29345, 0.89583333333333, 1.1, -0.1
29346, 0.91666666666667, 1.075, -0.1
29347, 0.89583333333333, 1.15, -0.1
29348, 0.91666666666667, 1.125, -0.1
29349, 0.89583333333333, 1.2, -0.1
29350, 0.91666666666667, 1.175, -0.1
29351, 0.89583333333333, 1.25, -0.1
29352, 0.91666666666667, 1.225, -0.1
29353, 0.89583333333333, 1.3, -0.1
29354, 0.91666666666667, 1.275, -0.1
29355, 0.91666666666667, 1.325, -0.1
29356, 0.9375, 0.2, -0.1
29357, 0.95833333333333, 0.175, -0.1
29358, 0.9375, 0.25, -0.1
29359, 0.95833333333333, 0.225, -0.1
29360, 0.9375, 0.3, -0.1
29361, 0.95833333333333, 0.275, -0.1
29362, 0.9375, 0.35, -0.1
29363, 0.95833333333333, 0.325, -0.1
29364, 0.9375, 0.4, -0.1
29365, 0.95833333333333, 0.375, -0.1
29366, 0.9375, 0.45, -0.1
29367, 0.95833333333333, 0.425, -0.1
29368, 0.9375, 0.5, -0.1
29369, 0.95833333333333, 0.475, -0.1
29370, 0.9375, 0.55, -0.1
29371, 0.95833333333333, 0.525, -0.1
29372, 0.9375, 0.6, -0.1
29373, 0.95833333333333, 0.575, -0.1
29374, 0.9375, 0.65, -0.1
29375, 0.95833333333333, 0.625, -0.1
29376, 0.9375, 0.7, -0.1
29377, 0.95833333333333, 0.675, -0.1
29378, 0.9375, 0.75, -0.1
29379, 0.95833333333333, 0.725, -0.1
