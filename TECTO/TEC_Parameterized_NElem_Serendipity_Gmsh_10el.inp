47210, 0.041666666666667, 0.95, 0.10416666666667
47211, 0.041666666666667, 0.975, 0.125
47212, 0.020833333333333, 1, 0.125
47213, 0.041666666666667, 1, 0.10416666666667
47214, 0.041666666666667, 1.025, 0.125
47215, 0.020833333333333, 1.05, 0.125
47216, 0.041666666666667, 1.05, 0.10416666666667
47217, 0.041666666666667, 1.075, 0.125
47218, 0.020833333333333, 1.1, 0.125
47219, 0.041666666666667, 1.1, 0.10416666666667
47220, 0.041666666666667, 1.125, 0.125
47221, 0.020833333333333, 1.15, 0.125
47222, 0.041666666666667, 1.15, 0.10416666666667
47223, 0.041666666666667, 1.175, 0.125
47224, 0.020833333333333, 1.2, 0.125
47225, 0.041666666666667, 1.2, 0.10416666666667
47226, 0.041666666666667, 1.225, 0.125
47227, 0.020833333333333, 1.25, 0.125
47228, 0.041666666666667, 1.25, 0.10416666666667
47229, 0.041666666666667, 1.275, 0.125
47230, 0.020833333333333, 1.3, 0.125
47231, 0.041666666666667, 1.3, 0.10416666666667
47232, 0.041666666666667, 1.325, 0.125
47233, 0.041666666666667, 0.175, 0.16666666666667
47234, 0.020833333333333, 0.2, 0.16666666666667
47235, 0.041666666666667, 0.2, 0.14583333333333
47236, 0.041666666666667, 0.225, 0.16666666666667
47237, 0.020833333333333, 0.25, 0.16666666666667
47238, 0.041666666666667, 0.25, 0.14583333333333
47239, 0.041666666666667, 0.275, 0.16666666666667
47240, 0.020833333333333, 0.3, 0.16666666666667
47241, 0.041666666666667, 0.3, 0.14583333333333
47242, 0.041666666666667, 0.325, 0.16666666666667
47243, 0.020833333333333, 0.35, 0.16666666666667
47244, 0.041666666666667, 0.35, 0.14583333333333
47245, 0.041666666666667, 0.375, 0.16666666666667
47246, 0.020833333333333, 0.4, 0.16666666666667
47247, 0.041666666666667, 0.4, 0.14583333333333
47248, 0.041666666666667, 0.425, 0.16666666666667
47249, 0.020833333333333, 0.45, 0.16666666666667
47250, 0.041666666666667, 0.45, 0.14583333333333
47251, 0.041666666666667, 0.475, 0.16666666666667
47252, 0.020833333333333, 0.5, 0.16666666666667
47253, 0.041666666666667, 0.5, 0.14583333333333
47254, 0.041666666666667, 0.525, 0.16666666666667
47255, 0.020833333333333, 0.55, 0.16666666666667
47256, 0.041666666666667, 0.55, 0.14583333333333
47257, 0.041666666666667, 0.575, 0.16666666666667
47258, 0.020833333333333, 0.6, 0.16666666666667
47259, 0.041666666666667, 0.6, 0.14583333333333
47260, 0.041666666666667, 0.625, 0.16666666666667
47261, 0.020833333333333, 0.65, 0.16666666666667
47262, 0.041666666666667, 0.65, 0.14583333333333
47263, 0.041666666666667, 0.675, 0.16666666666667
47264, 0.020833333333333, 0.7, 0.16666666666667
47265, 0.041666666666667, 0.7, 0.14583333333333
47266, 0.041666666666667, 0.725, 0.16666666666667
47267, 0.020833333333333, 0.75, 0.16666666666667
47268, 0.041666666666667, 0.75, 0.14583333333333
47269, 0.041666666666667, 0.775, 0.16666666666667
47270, 0.020833333333333, 0.8, 0.16666666666667
47271, 0.041666666666667, 0.8, 0.14583333333333
47272, 0.041666666666667, 0.825, 0.16666666666667
47273, 0.020833333333333, 0.85, 0.16666666666667
47274, 0.041666666666667, 0.85, 0.14583333333333
47275, 0.041666666666667, 0.875, 0.16666666666667
47276, 0.020833333333333, 0.9, 0.16666666666667
47277, 0.041666666666667, 0.9, 0.14583333333333
47278, 0.041666666666667, 0.925, 0.16666666666667
47279, 0.020833333333333, 0.95, 0.16666666666667
47280, 0.041666666666667, 0.95, 0.14583333333333
47281, 0.041666666666667, 0.975, 0.16666666666667
47282, 0.020833333333333, 1, 0.16666666666667
47283, 0.041666666666667, 1, 0.14583333333333
47284, 0.041666666666667, 1.025, 0.16666666666667
47285, 0.020833333333333, 1.05, 0.16666666666667
47286, 0.041666666666667, 1.05, 0.14583333333333
47287, 0.041666666666667, 1.075, 0.16666666666667
47288, 0.020833333333333, 1.1, 0.16666666666667
47289, 0.041666666666667, 1.1, 0.14583333333333
47290, 0.041666666666667, 1.125, 0.16666666666667
47291, 0.020833333333333, 1.15, 0.16666666666667
47292, 0.041666666666667, 1.15, 0.14583333333333
47293, 0.041666666666667, 1.175, 0.16666666666667
47294, 0.020833333333333, 1.2, 0.16666666666667
47295, 0.041666666666667, 1.2, 0.14583333333333
47296, 0.041666666666667, 1.225, 0.16666666666667
47297, 0.020833333333333, 1.25, 0.16666666666667
47298, 0.041666666666667, 1.25, 0.14583333333333
47299, 0.041666666666667, 1.275, 0.16666666666667
47300, 0.020833333333333, 1.3, 0.16666666666667
47301, 0.041666666666667, 1.3, 0.14583333333333
47302, 0.041666666666667, 1.325, 0.16666666666667
47303, 0.041666666666667, 0.175, 0.20833333333333
47304, 0.020833333333333, 0.2, 0.20833333333333
47305, 0.041666666666667, 0.2, 0.1875
47306, 0.041666666666667, 0.225, 0.20833333333333
47307, 0.020833333333333, 0.25, 0.20833333333333
47308, 0.041666666666667, 0.25, 0.1875
47309, 0.041666666666667, 0.275, 0.20833333333333
47310, 0.020833333333333, 0.3, 0.20833333333333
47311, 0.041666666666667, 0.3, 0.1875
47312, 0.041666666666667, 0.325, 0.20833333333333
47313, 0.020833333333333, 0.35, 0.20833333333333
47314, 0.041666666666667, 0.35, 0.1875
47315, 0.041666666666667, 0.375, 0.20833333333333
47316, 0.020833333333333, 0.4, 0.20833333333333
47317, 0.041666666666667, 0.4, 0.1875
47318, 0.041666666666667, 0.425, 0.20833333333333
47319, 0.020833333333333, 0.45, 0.20833333333333
47320, 0.041666666666667, 0.45, 0.1875
47321, 0.041666666666667, 0.475, 0.20833333333333
47322, 0.020833333333333, 0.5, 0.20833333333333
47323, 0.041666666666667, 0.5, 0.1875
47324, 0.041666666666667, 0.525, 0.20833333333333
47325, 0.020833333333333, 0.55, 0.20833333333333
47326, 0.041666666666667, 0.55, 0.1875
47327, 0.041666666666667, 0.575, 0.20833333333333
47328, 0.020833333333333, 0.6, 0.20833333333333
47329, 0.041666666666667, 0.6, 0.1875
47330, 0.041666666666667, 0.625, 0.20833333333333
47331, 0.020833333333333, 0.65, 0.20833333333333
47332, 0.041666666666667, 0.65, 0.1875
47333, 0.041666666666667, 0.675, 0.20833333333333
47334, 0.020833333333333, 0.7, 0.20833333333333
47335, 0.041666666666667, 0.7, 0.1875
47336, 0.041666666666667, 0.725, 0.20833333333333
47337, 0.020833333333333, 0.75, 0.20833333333333
47338, 0.041666666666667, 0.75, 0.1875
47339, 0.041666666666667, 0.775, 0.20833333333333
47340, 0.020833333333333, 0.8, 0.20833333333333
47341, 0.041666666666667, 0.8, 0.1875
47342, 0.041666666666667, 0.825, 0.20833333333333
47343, 0.020833333333333, 0.85, 0.20833333333333
47344, 0.041666666666667, 0.85, 0.1875
47345, 0.041666666666667, 0.875, 0.20833333333333
47346, 0.020833333333333, 0.9, 0.20833333333333
47347, 0.041666666666667, 0.9, 0.1875
47348, 0.041666666666667, 0.925, 0.20833333333333
47349, 0.020833333333333, 0.95, 0.20833333333333
47350, 0.041666666666667, 0.95, 0.1875
47351, 0.041666666666667, 0.975, 0.20833333333333
47352, 0.020833333333333, 1, 0.20833333333333
47353, 0.041666666666667, 1, 0.1875
47354, 0.041666666666667, 1.025, 0.20833333333333
47355, 0.020833333333333, 1.05, 0.20833333333333
47356, 0.041666666666667, 1.05, 0.1875
47357, 0.041666666666667, 1.075, 0.20833333333333
47358, 0.020833333333333, 1.1, 0.20833333333333
47359, 0.041666666666667, 1.1, 0.1875
47360, 0.041666666666667, 1.125, 0.20833333333333
47361, 0.020833333333333, 1.15, 0.20833333333333
47362, 0.041666666666667, 1.15, 0.1875
47363, 0.041666666666667, 1.175, 0.20833333333333
47364, 0.020833333333333, 1.2, 0.20833333333333
47365, 0.041666666666667, 1.2, 0.1875
47366, 0.041666666666667, 1.225, 0.20833333333333
47367, 0.020833333333333, 1.25, 0.20833333333333
47368, 0.041666666666667, 1.25, 0.1875
47369, 0.041666666666667, 1.275, 0.20833333333333
47370, 0.020833333333333, 1.3, 0.20833333333333
47371, 0.041666666666667, 1.3, 0.1875
47372, 0.041666666666667, 1.325, 0.20833333333333
47373, 0.041666666666667, 0.175, 0.25
47374, 0.020833333333333, 0.2, 0.25
47375, 0.041666666666667, 0.2, 0.22916666666667
47376, 0.041666666666667, 0.225, 0.25
47377, 0.020833333333333, 0.25, 0.25
47378, 0.041666666666667, 0.25, 0.22916666666667
47379, 0.041666666666667, 0.275, 0.25
47380, 0.020833333333333, 0.3, 0.25
47381, 0.041666666666667, 0.3, 0.22916666666667
47382, 0.041666666666667, 0.325, 0.25
47383, 0.020833333333333, 0.35, 0.25
47384, 0.041666666666667, 0.35, 0.22916666666667
47385, 0.041666666666667, 0.375, 0.25
47386, 0.020833333333333, 0.4, 0.25
47387, 0.041666666666667, 0.4, 0.22916666666667
47388, 0.041666666666667, 0.425, 0.25
47389, 0.020833333333333, 0.45, 0.25
47390, 0.041666666666667, 0.45, 0.22916666666667
47391, 0.041666666666667, 0.475, 0.25
47392, 0.020833333333333, 0.5, 0.25
47393, 0.041666666666667, 0.5, 0.22916666666667
47394, 0.041666666666667, 0.525, 0.25
47395, 0.020833333333333, 0.55, 0.25
47396, 0.041666666666667, 0.55, 0.22916666666667
47397, 0.041666666666667, 0.575, 0.25
47398, 0.020833333333333, 0.6, 0.25
47399, 0.041666666666667, 0.6, 0.22916666666667
47400, 0.041666666666667, 0.625, 0.25
47401, 0.020833333333333, 0.65, 0.25
47402, 0.041666666666667, 0.65, 0.22916666666667
47403, 0.041666666666667, 0.675, 0.25
47404, 0.020833333333333, 0.7, 0.25
47405, 0.041666666666667, 0.7, 0.22916666666667
47406, 0.041666666666667, 0.725, 0.25
47407, 0.020833333333333, 0.75, 0.25
47408, 0.041666666666667, 0.75, 0.22916666666667
47409, 0.041666666666667, 0.775, 0.25
47410, 0.020833333333333, 0.8, 0.25
47411, 0.041666666666667, 0.8, 0.22916666666667
47412, 0.041666666666667, 0.825, 0.25
47413, 0.020833333333333, 0.85, 0.25
47414, 0.041666666666667, 0.85, 0.22916666666667
47415, 0.041666666666667, 0.875, 0.25
47416, 0.020833333333333, 0.9, 0.25
47417, 0.041666666666667, 0.9, 0.22916666666667
47418, 0.041666666666667, 0.925, 0.25
47419, 0.020833333333333, 0.95, 0.25
47420, 0.041666666666667, 0.95, 0.22916666666667
47421, 0.041666666666667, 0.975, 0.25
47422, 0.020833333333333, 1, 0.25
47423, 0.041666666666667, 1, 0.22916666666667
47424, 0.041666666666667, 1.025, 0.25
47425, 0.020833333333333, 1.05, 0.25
47426, 0.041666666666667, 1.05, 0.22916666666667
47427, 0.041666666666667, 1.075, 0.25
47428, 0.020833333333333, 1.1, 0.25
47429, 0.041666666666667, 1.1, 0.22916666666667
47430, 0.041666666666667, 1.125, 0.25
47431, 0.020833333333333, 1.15, 0.25
47432, 0.041666666666667, 1.15, 0.22916666666667
47433, 0.041666666666667, 1.175, 0.25
47434, 0.020833333333333, 1.2, 0.25
47435, 0.041666666666667, 1.2, 0.22916666666667
47436, 0.041666666666667, 1.225, 0.25
47437, 0.020833333333333, 1.25, 0.25
47438, 0.041666666666667, 1.25, 0.22916666666667
47439, 0.041666666666667, 1.275, 0.25
47440, 0.020833333333333, 1.3, 0.25
47441, 0.041666666666667, 1.3, 0.22916666666667
47442, 0.041666666666667, 1.325, 0.25
47443, 0.041666666666667, 0.175, 0.29166666666667
47444, 0.020833333333333, 0.2, 0.29166666666667
47445, 0.041666666666667, 0.2, 0.27083333333333
47446, 0.041666666666667, 0.225, 0.29166666666667
47447, 0.020833333333333, 0.25, 0.29166666666667
47448, 0.041666666666667, 0.25, 0.27083333333333
47449, 0.041666666666667, 0.275, 0.29166666666667
47450, 0.020833333333333, 0.3, 0.29166666666667
47451, 0.041666666666667, 0.3, 0.27083333333333
47452, 0.041666666666667, 0.325, 0.29166666666667
47453, 0.020833333333333, 0.35, 0.29166666666667
47454, 0.041666666666667, 0.35, 0.27083333333333
47455, 0.041666666666667, 0.375, 0.29166666666667
47456, 0.020833333333333, 0.4, 0.29166666666667
47457, 0.041666666666667, 0.4, 0.27083333333333
47458, 0.041666666666667, 0.425, 0.29166666666667
47459, 0.020833333333333, 0.45, 0.29166666666667
47460, 0.041666666666667, 0.45, 0.27083333333333
47461, 0.041666666666667, 0.475, 0.29166666666667
47462, 0.020833333333333, 0.5, 0.29166666666667
47463, 0.041666666666667, 0.5, 0.27083333333333
47464, 0.041666666666667, 0.525, 0.29166666666667
47465, 0.020833333333333, 0.55, 0.29166666666667
47466, 0.041666666666667, 0.55, 0.27083333333333
47467, 0.041666666666667, 0.575, 0.29166666666667
47468, 0.020833333333333, 0.6, 0.29166666666667
47469, 0.041666666666667, 0.6, 0.27083333333333
47470, 0.041666666666667, 0.625, 0.29166666666667
47471, 0.020833333333333, 0.65, 0.29166666666667
47472, 0.041666666666667, 0.65, 0.27083333333333
47473, 0.041666666666667, 0.675, 0.29166666666667
47474, 0.020833333333333, 0.7, 0.29166666666667
47475, 0.041666666666667, 0.7, 0.27083333333333
47476, 0.041666666666667, 0.725, 0.29166666666667
47477, 0.020833333333333, 0.75, 0.29166666666667
47478, 0.041666666666667, 0.75, 0.27083333333333
47479, 0.041666666666667, 0.775, 0.29166666666667
47480, 0.020833333333333, 0.8, 0.29166666666667
47481, 0.041666666666667, 0.8, 0.27083333333333
47482, 0.041666666666667, 0.825, 0.29166666666667
47483, 0.020833333333333, 0.85, 0.29166666666667
47484, 0.041666666666667, 0.85, 0.27083333333333
47485, 0.041666666666667, 0.875, 0.29166666666667
47486, 0.020833333333333, 0.9, 0.29166666666667
47487, 0.041666666666667, 0.9, 0.27083333333333
47488, 0.041666666666667, 0.925, 0.29166666666667
47489, 0.020833333333333, 0.95, 0.29166666666667
47490, 0.041666666666667, 0.95, 0.27083333333333
47491, 0.041666666666667, 0.975, 0.29166666666667
47492, 0.020833333333333, 1, 0.29166666666667
47493, 0.041666666666667, 1, 0.27083333333333
47494, 0.041666666666667, 1.025, 0.29166666666667
47495, 0.020833333333333, 1.05, 0.29166666666667
47496, 0.041666666666667, 1.05, 0.27083333333333
47497, 0.041666666666667, 1.075, 0.29166666666667
47498, 0.020833333333333, 1.1, 0.29166666666667
47499, 0.041666666666667, 1.1, 0.27083333333333
47500, 0.041666666666667, 1.125, 0.29166666666667
47501, 0.020833333333333, 1.15, 0.29166666666667
47502, 0.041666666666667, 1.15, 0.27083333333333
47503, 0.041666666666667, 1.175, 0.29166666666667
47504, 0.020833333333333, 1.2, 0.29166666666667
47505, 0.041666666666667, 1.2, 0.27083333333333
47506, 0.041666666666667, 1.225, 0.29166666666667
47507, 0.020833333333333, 1.25, 0.29166666666667
47508, 0.041666666666667, 1.25, 0.27083333333333
47509, 0.041666666666667, 1.275, 0.29166666666667
47510, 0.020833333333333, 1.3, 0.29166666666667
47511, 0.041666666666667, 1.3, 0.27083333333333
47512, 0.041666666666667, 1.325, 0.29166666666667
47513, 0.041666666666667, 0.175, 0.33333333333333
47514, 0.020833333333333, 0.2, 0.33333333333333
47515, 0.041666666666667, 0.2, 0.3125
47516, 0.041666666666667, 0.225, 0.33333333333333
47517, 0.020833333333333, 0.25, 0.33333333333333
47518, 0.041666666666667, 0.25, 0.3125
47519, 0.041666666666667, 0.275, 0.33333333333333
47520, 0.020833333333333, 0.3, 0.33333333333333
47521, 0.041666666666667, 0.3, 0.3125
47522, 0.041666666666667, 0.325, 0.33333333333333
47523, 0.020833333333333, 0.35, 0.33333333333333
47524, 0.041666666666667, 0.35, 0.3125
47525, 0.041666666666667, 0.375, 0.33333333333333
47526, 0.020833333333333, 0.4, 0.33333333333333
47527, 0.041666666666667, 0.4, 0.3125
47528, 0.041666666666667, 0.425, 0.33333333333333
47529, 0.020833333333333, 0.45, 0.33333333333333
47530, 0.041666666666667, 0.45, 0.3125
47531, 0.041666666666667, 0.475, 0.33333333333333
47532, 0.020833333333333, 0.5, 0.33333333333333
47533, 0.041666666666667, 0.5, 0.3125
47534, 0.041666666666667, 0.525, 0.33333333333333
47535, 0.020833333333333, 0.55, 0.33333333333333
47536, 0.041666666666667, 0.55, 0.3125
47537, 0.041666666666667, 0.575, 0.33333333333333
47538, 0.020833333333333, 0.6, 0.33333333333333
47539, 0.041666666666667, 0.6, 0.3125
47540, 0.041666666666667, 0.625, 0.33333333333333
47541, 0.020833333333333, 0.65, 0.33333333333333
47542, 0.041666666666667, 0.65, 0.3125
47543, 0.041666666666667, 0.675, 0.33333333333333
47544, 0.020833333333333, 0.7, 0.33333333333333
47545, 0.041666666666667, 0.7, 0.3125
47546, 0.041666666666667, 0.725, 0.33333333333333
47547, 0.020833333333333, 0.75, 0.33333333333333
47548, 0.041666666666667, 0.75, 0.3125
47549, 0.041666666666667, 0.775, 0.33333333333333
47550, 0.020833333333333, 0.8, 0.33333333333333
47551, 0.041666666666667, 0.8, 0.3125
47552, 0.041666666666667, 0.825, 0.33333333333333
47553, 0.020833333333333, 0.85, 0.33333333333333
47554, 0.041666666666667, 0.85, 0.3125
47555, 0.041666666666667, 0.875, 0.33333333333333
47556, 0.020833333333333, 0.9, 0.33333333333333
47557, 0.041666666666667, 0.9, 0.3125
47558, 0.041666666666667, 0.925, 0.33333333333333
47559, 0.020833333333333, 0.95, 0.33333333333333
47560, 0.041666666666667, 0.95, 0.3125
47561, 0.041666666666667, 0.975, 0.33333333333333
47562, 0.020833333333333, 1, 0.33333333333333
47563, 0.041666666666667, 1, 0.3125
47564, 0.041666666666667, 1.025, 0.33333333333333
47565, 0.020833333333333, 1.05, 0.33333333333333
47566, 0.041666666666667, 1.05, 0.3125
47567, 0.041666666666667, 1.075, 0.33333333333333
47568, 0.020833333333333, 1.1, 0.33333333333333
47569, 0.041666666666667, 1.1, 0.3125
47570, 0.041666666666667, 1.125, 0.33333333333333
47571, 0.020833333333333, 1.15, 0.33333333333333
47572, 0.041666666666667, 1.15, 0.3125
47573, 0.041666666666667, 1.175, 0.33333333333333
47574, 0.020833333333333, 1.2, 0.33333333333333
47575, 0.041666666666667, 1.2, 0.3125
47576, 0.041666666666667, 1.225, 0.33333333333333
47577, 0.020833333333333, 1.25, 0.33333333333333
47578, 0.041666666666667, 1.25, 0.3125
47579, 0.041666666666667, 1.275, 0.33333333333333
47580, 0.020833333333333, 1.3, 0.33333333333333
47581, 0.041666666666667, 1.3, 0.3125
47582, 0.041666666666667, 1.325, 0.33333333333333
47583, 0.041666666666667, 0.175, 0.375
47584, 0.020833333333333, 0.2, 0.375
47585, 0.041666666666667, 0.2, 0.35416666666667
47586, 0.041666666666667, 0.225, 0.375
47587, 0.020833333333333, 0.25, 0.375
47588, 0.041666666666667, 0.25, 0.35416666666667
47589, 0.041666666666667, 0.275, 0.375
47590, 0.020833333333333, 0.3, 0.375
47591, 0.041666666666667, 0.3, 0.35416666666667
47592, 0.041666666666667, 0.325, 0.375
47593, 0.020833333333333, 0.35, 0.375
47594, 0.041666666666667, 0.35, 0.35416666666667
47595, 0.041666666666667, 0.375, 0.375
47596, 0.020833333333333, 0.4, 0.375
47597, 0.041666666666667, 0.4, 0.35416666666667
47598, 0.041666666666667, 0.425, 0.375
47599, 0.020833333333333, 0.45, 0.375
47600, 0.041666666666667, 0.45, 0.35416666666667
47601, 0.041666666666667, 0.475, 0.375
47602, 0.020833333333333, 0.5, 0.375
47603, 0.041666666666667, 0.5, 0.35416666666667
47604, 0.041666666666667, 0.525, 0.375
47605, 0.020833333333333, 0.55, 0.375
47606, 0.041666666666667, 0.55, 0.35416666666667
47607, 0.041666666666667, 0.575, 0.375
47608, 0.020833333333333, 0.6, 0.375
47609, 0.041666666666667, 0.6, 0.35416666666667
47610, 0.041666666666667, 0.625, 0.375
47611, 0.020833333333333, 0.65, 0.375
47612, 0.041666666666667, 0.65, 0.35416666666667
47613, 0.041666666666667, 0.675, 0.375
47614, 0.020833333333333, 0.7, 0.375
47615, 0.041666666666667, 0.7, 0.35416666666667
47616, 0.041666666666667, 0.725, 0.375
47617, 0.020833333333333, 0.75, 0.375
47618, 0.041666666666667, 0.75, 0.35416666666667
47619, 0.041666666666667, 0.775, 0.375
47620, 0.020833333333333, 0.8, 0.375
47621, 0.041666666666667, 0.8, 0.35416666666667
47622, 0.041666666666667, 0.825, 0.375
47623, 0.020833333333333, 0.85, 0.375
47624, 0.041666666666667, 0.85, 0.35416666666667
47625, 0.041666666666667, 0.875, 0.375
47626, 0.020833333333333, 0.9, 0.375
47627, 0.041666666666667, 0.9, 0.35416666666667
47628, 0.041666666666667, 0.925, 0.375
47629, 0.020833333333333, 0.95, 0.375
47630, 0.041666666666667, 0.95, 0.35416666666667
47631, 0.041666666666667, 0.975, 0.375
47632, 0.020833333333333, 1, 0.375
47633, 0.041666666666667, 1, 0.35416666666667
47634, 0.041666666666667, 1.025, 0.375
47635, 0.020833333333333, 1.05, 0.375
47636, 0.041666666666667, 1.05, 0.35416666666667
47637, 0.041666666666667, 1.075, 0.375
47638, 0.020833333333333, 1.1, 0.375
47639, 0.041666666666667, 1.1, 0.35416666666667
47640, 0.041666666666667, 1.125, 0.375
47641, 0.020833333333333, 1.15, 0.375
47642, 0.041666666666667, 1.15, 0.35416666666667
47643, 0.041666666666667, 1.175, 0.375
47644, 0.020833333333333, 1.2, 0.375
47645, 0.041666666666667, 1.2, 0.35416666666667
47646, 0.041666666666667, 1.225, 0.375
47647, 0.020833333333333, 1.25, 0.375
47648, 0.041666666666667, 1.25, 0.35416666666667
47649, 0.041666666666667, 1.275, 0.375
47650, 0.020833333333333, 1.3, 0.375
47651, 0.041666666666667, 1.3, 0.35416666666667
47652, 0.041666666666667, 1.325, 0.375
47653, 0.041666666666667, 0.175, 0.41666666666667
47654, 0.020833333333333, 0.2, 0.41666666666667
47655, 0.041666666666667, 0.2, 0.39583333333333
47656, 0.041666666666667, 0.225, 0.41666666666667
47657, 0.020833333333333, 0.25, 0.41666666666667
47658, 0.041666666666667, 0.25, 0.39583333333333
47659, 0.041666666666667, 0.275, 0.41666666666667
47660, 0.020833333333333, 0.3, 0.41666666666667
47661, 0.041666666666667, 0.3, 0.39583333333333
47662, 0.041666666666667, 0.325, 0.41666666666667
47663, 0.020833333333333, 0.35, 0.41666666666667
47664, 0.041666666666667, 0.35, 0.39583333333333
47665, 0.041666666666667, 0.375, 0.41666666666667
47666, 0.020833333333333, 0.4, 0.41666666666667
47667, 0.041666666666667, 0.4, 0.39583333333333
47668, 0.041666666666667, 0.425, 0.41666666666667
47669, 0.020833333333333, 0.45, 0.41666666666667
47670, 0.041666666666667, 0.45, 0.39583333333333
47671, 0.041666666666667, 0.475, 0.41666666666667
47672, 0.020833333333333, 0.5, 0.41666666666667
47673, 0.041666666666667, 0.5, 0.39583333333333
47674, 0.041666666666667, 0.525, 0.41666666666667
47675, 0.020833333333333, 0.55, 0.41666666666667
47676, 0.041666666666667, 0.55, 0.39583333333333
47677, 0.041666666666667, 0.575, 0.41666666666667
47678, 0.020833333333333, 0.6, 0.41666666666667
47679, 0.041666666666667, 0.6, 0.39583333333333
47680, 0.041666666666667, 0.625, 0.41666666666667
47681, 0.020833333333333, 0.65, 0.41666666666667
47682, 0.041666666666667, 0.65, 0.39583333333333
47683, 0.041666666666667, 0.675, 0.41666666666667
47684, 0.020833333333333, 0.7, 0.41666666666667
47685, 0.041666666666667, 0.7, 0.39583333333333
47686, 0.041666666666667, 0.725, 0.41666666666667
47687, 0.020833333333333, 0.75, 0.41666666666667
47688, 0.041666666666667, 0.75, 0.39583333333333
47689, 0.041666666666667, 0.775, 0.41666666666667
47690, 0.020833333333333, 0.8, 0.41666666666667
47691, 0.041666666666667, 0.8, 0.39583333333333
47692, 0.041666666666667, 0.825, 0.41666666666667
47693, 0.020833333333333, 0.85, 0.41666666666667
47694, 0.041666666666667, 0.85, 0.39583333333333
47695, 0.041666666666667, 0.875, 0.41666666666667
47696, 0.020833333333333, 0.9, 0.41666666666667
47697, 0.041666666666667, 0.9, 0.39583333333333
47698, 0.041666666666667, 0.925, 0.41666666666667
47699, 0.020833333333333, 0.95, 0.41666666666667
47700, 0.041666666666667, 0.95, 0.39583333333333
47701, 0.041666666666667, 0.975, 0.41666666666667
47702, 0.020833333333333, 1, 0.41666666666667
47703, 0.041666666666667, 1, 0.39583333333333
47704, 0.041666666666667, 1.025, 0.41666666666667
47705, 0.020833333333333, 1.05, 0.41666666666667
47706, 0.041666666666667, 1.05, 0.39583333333333
47707, 0.041666666666667, 1.075, 0.41666666666667
47708, 0.020833333333333, 1.1, 0.41666666666667
47709, 0.041666666666667, 1.1, 0.39583333333333
47710, 0.041666666666667, 1.125, 0.41666666666667
47711, 0.020833333333333, 1.15, 0.41666666666667
47712, 0.041666666666667, 1.15, 0.39583333333333
47713, 0.041666666666667, 1.175, 0.41666666666667
47714, 0.020833333333333, 1.2, 0.41666666666667
47715, 0.041666666666667, 1.2, 0.39583333333333
47716, 0.041666666666667, 1.225, 0.41666666666667
47717, 0.020833333333333, 1.25, 0.41666666666667
47718, 0.041666666666667, 1.25, 0.39583333333333
47719, 0.041666666666667, 1.275, 0.41666666666667
47720, 0.020833333333333, 1.3, 0.41666666666667
47721, 0.041666666666667, 1.3, 0.39583333333333
47722, 0.041666666666667, 1.325, 0.41666666666667
47723, 0.041666666666667, 0.175, 0.45833333333333
47724, 0.020833333333333, 0.2, 0.45833333333333
47725, 0.041666666666667, 0.2, 0.4375
47726, 0.041666666666667, 0.225, 0.45833333333333
47727, 0.020833333333333, 0.25, 0.45833333333333
47728, 0.041666666666667, 0.25, 0.4375
47729, 0.041666666666667, 0.275, 0.45833333333333
47730, 0.020833333333333, 0.3, 0.45833333333333
47731, 0.041666666666667, 0.3, 0.4375
47732, 0.041666666666667, 0.325, 0.45833333333333
47733, 0.020833333333333, 0.35, 0.45833333333333
47734, 0.041666666666667, 0.35, 0.4375
47735, 0.041666666666667, 0.375, 0.45833333333333
47736, 0.020833333333333, 0.4, 0.45833333333333
47737, 0.041666666666667, 0.4, 0.4375
47738, 0.041666666666667, 0.425, 0.45833333333333
47739, 0.020833333333333, 0.45, 0.45833333333333
47740, 0.041666666666667, 0.45, 0.4375
47741, 0.041666666666667, 0.475, 0.45833333333333
47742, 0.020833333333333, 0.5, 0.45833333333333
47743, 0.041666666666667, 0.5, 0.4375
47744, 0.041666666666667, 0.525, 0.45833333333333
47745, 0.020833333333333, 0.55, 0.45833333333333
47746, 0.041666666666667, 0.55, 0.4375
47747, 0.041666666666667, 0.575, 0.45833333333333
47748, 0.020833333333333, 0.6, 0.45833333333333
47749, 0.041666666666667, 0.6, 0.4375
47750, 0.041666666666667, 0.625, 0.45833333333333
47751, 0.020833333333333, 0.65, 0.45833333333333
47752, 0.041666666666667, 0.65, 0.4375
47753, 0.041666666666667, 0.675, 0.45833333333333
47754, 0.020833333333333, 0.7, 0.45833333333333
47755, 0.041666666666667, 0.7, 0.4375
47756, 0.041666666666667, 0.725, 0.45833333333333
47757, 0.020833333333333, 0.75, 0.45833333333333
47758, 0.041666666666667, 0.75, 0.4375
47759, 0.041666666666667, 0.775, 0.45833333333333
47760, 0.020833333333333, 0.8, 0.45833333333333
47761, 0.041666666666667, 0.8, 0.4375
47762, 0.041666666666667, 0.825, 0.45833333333333
47763, 0.020833333333333, 0.85, 0.45833333333333
47764, 0.041666666666667, 0.85, 0.4375
47765, 0.041666666666667, 0.875, 0.45833333333333
47766, 0.020833333333333, 0.9, 0.45833333333333
47767, 0.041666666666667, 0.9, 0.4375
47768, 0.041666666666667, 0.925, 0.45833333333333
47769, 0.020833333333333, 0.95, 0.45833333333333
47770, 0.041666666666667, 0.95, 0.4375
47771, 0.041666666666667, 0.975, 0.45833333333333
47772, 0.020833333333333, 1, 0.45833333333333
47773, 0.041666666666667, 1, 0.4375
47774, 0.041666666666667, 1.025, 0.45833333333333
47775, 0.020833333333333, 1.05, 0.45833333333333
47776, 0.041666666666667, 1.05, 0.4375
47777, 0.041666666666667, 1.075, 0.45833333333333
47778, 0.020833333333333, 1.1, 0.45833333333333
47779, 0.041666666666667, 1.1, 0.4375
47780, 0.041666666666667, 1.125, 0.45833333333333
47781, 0.020833333333333, 1.15, 0.45833333333333
47782, 0.041666666666667, 1.15, 0.4375
47783, 0.041666666666667, 1.175, 0.45833333333333
47784, 0.020833333333333, 1.2, 0.45833333333333
47785, 0.041666666666667, 1.2, 0.4375
47786, 0.041666666666667, 1.225, 0.45833333333333
47787, 0.020833333333333, 1.25, 0.45833333333333
47788, 0.041666666666667, 1.25, 0.4375
47789, 0.041666666666667, 1.275, 0.45833333333333
47790, 0.020833333333333, 1.3, 0.45833333333333
47791, 0.041666666666667, 1.3, 0.4375
47792, 0.041666666666667, 1.325, 0.45833333333333
47793, 0.041666666666667, 0.2, 0.47916666666667
47794, 0.041666666666667, 0.25, 0.47916666666667
47795, 0.041666666666667, 0.3, 0.47916666666667
47796, 0.041666666666667, 0.35, 0.47916666666667
47797, 0.041666666666667, 0.4, 0.47916666666667
47798, 0.041666666666667, 0.45, 0.47916666666667
47799, 0.041666666666667, 0.5, 0.47916666666667
47800, 0.041666666666667, 0.55, 0.47916666666667
47801, 0.041666666666667, 0.6, 0.47916666666667
47802, 0.041666666666667, 0.65, 0.47916666666667
47803, 0.041666666666667, 0.7, 0.47916666666667
47804, 0.041666666666667, 0.75, 0.47916666666667
47805, 0.041666666666667, 0.8, 0.47916666666667
47806, 0.041666666666667, 0.85, 0.47916666666667
47807, 0.041666666666667, 0.9, 0.47916666666667
47808, 0.041666666666667, 0.95, 0.47916666666667
47809, 0.041666666666667, 1, 0.47916666666667
47810, 0.041666666666667, 1.05, 0.47916666666667
47811, 0.041666666666667, 1.1, 0.47916666666667
47812, 0.041666666666667, 1.15, 0.47916666666667
47813, 0.041666666666667, 1.2, 0.47916666666667
47814, 0.041666666666667, 1.25, 0.47916666666667
47815, 0.041666666666667, 1.3, 0.47916666666667
47816, 0.083333333333333, 0.175, 0.041666666666667
47817, 0.0625, 0.2, 0.041666666666667
47818, 0.083333333333333, 0.2, 0.020833333333333
47819, 0.083333333333333, 0.225, 0.041666666666667
47820, 0.0625, 0.25, 0.041666666666667
47821, 0.083333333333333, 0.25, 0.020833333333333
47822, 0.083333333333333, 0.275, 0.041666666666667
47823, 0.0625, 0.3, 0.041666666666667
47824, 0.083333333333333, 0.3, 0.020833333333333
47825, 0.083333333333333, 0.325, 0.041666666666667
47826, 0.0625, 0.35, 0.041666666666667
47827, 0.083333333333333, 0.35, 0.020833333333333
47828, 0.083333333333333, 0.375, 0.041666666666667
47829, 0.0625, 0.4, 0.041666666666667
47830, 0.083333333333333, 0.4, 0.020833333333333
47831, 0.083333333333333, 0.425, 0.041666666666667
47832, 0.0625, 0.45, 0.041666666666667
47833, 0.083333333333333, 0.45, 0.020833333333333
47834, 0.083333333333333, 0.475, 0.041666666666667
47835, 0.0625, 0.5, 0.041666666666667
47836, 0.083333333333333, 0.5, 0.020833333333333
47837, 0.083333333333333, 0.525, 0.041666666666667
47838, 0.0625, 0.55, 0.041666666666667
47839, 0.083333333333333, 0.55, 0.020833333333333
47840, 0.083333333333333, 0.575, 0.041666666666667
47841, 0.0625, 0.6, 0.041666666666667
47842, 0.083333333333333, 0.6, 0.020833333333333
47843, 0.083333333333333, 0.625, 0.041666666666667
47844, 0.0625, 0.65, 0.041666666666667
47845, 0.083333333333333, 0.65, 0.020833333333333
47846, 0.083333333333333, 0.675, 0.041666666666667
47847, 0.0625, 0.7, 0.041666666666667
47848, 0.083333333333333, 0.7, 0.020833333333333
47849, 0.083333333333333, 0.725, 0.041666666666667
47850, 0.0625, 0.75, 0.041666666666667
47851, 0.083333333333333, 0.75, 0.020833333333333
47852, 0.083333333333333, 0.775, 0.041666666666667
47853, 0.0625, 0.8, 0.041666666666667
47854, 0.083333333333333, 0.8, 0.020833333333333
47855, 0.083333333333333, 0.825, 0.041666666666667
47856, 0.0625, 0.85, 0.041666666666667
47857, 0.083333333333333, 0.85, 0.020833333333333
47858, 0.083333333333333, 0.875, 0.041666666666667
47859, 0.0625, 0.9, 0.041666666666667
47860, 0.083333333333333, 0.9, 0.020833333333333
47861, 0.083333333333333, 0.925, 0.041666666666667
47862, 0.0625, 0.95, 0.041666666666667
47863, 0.083333333333333, 0.95, 0.020833333333333
47864, 0.083333333333333, 0.975, 0.041666666666667
47865, 0.0625, 1, 0.041666666666667
47866, 0.083333333333333, 1, 0.020833333333333
47867, 0.083333333333333, 1.025, 0.041666666666667
47868, 0.0625, 1.05, 0.041666666666667
47869, 0.083333333333333, 1.05, 0.020833333333333
47870, 0.083333333333333, 1.075, 0.041666666666667
47871, 0.0625, 1.1, 0.041666666666667
47872, 0.083333333333333, 1.1, 0.020833333333333
47873, 0.083333333333333, 1.125, 0.041666666666667
47874, 0.0625, 1.15, 0.041666666666667
47875, 0.083333333333333, 1.15, 0.020833333333333
47876, 0.083333333333333, 1.175, 0.041666666666667
47877, 0.0625, 1.2, 0.041666666666667
47878, 0.083333333333333, 1.2, 0.020833333333333
47879, 0.083333333333333, 1.225, 0.041666666666667
47880, 0.0625, 1.25, 0.041666666666667
47881, 0.083333333333333, 1.25, 0.020833333333333
47882, 0.083333333333333, 1.275, 0.041666666666667
47883, 0.0625, 1.3, 0.041666666666667
47884, 0.083333333333333, 1.3, 0.020833333333333
47885, 0.083333333333333, 1.325, 0.041666666666667
47886, 0.083333333333333, 0.175, 0.083333333333333
47887, 0.0625, 0.2, 0.083333333333333
47888, 0.083333333333333, 0.2, 0.0625
47889, 0.083333333333333, 0.225, 0.083333333333333
47890, 0.0625, 0.25, 0.083333333333333
47891, 0.083333333333333, 0.25, 0.0625
47892, 0.083333333333333, 0.275, 0.083333333333333
47893, 0.0625, 0.3, 0.083333333333333
47894, 0.083333333333333, 0.3, 0.0625
47895, 0.083333333333333, 0.325, 0.083333333333333
47896, 0.0625, 0.35, 0.083333333333333
47897, 0.083333333333333, 0.35, 0.0625
47898, 0.083333333333333, 0.375, 0.083333333333333
47899, 0.0625, 0.4, 0.083333333333333
47900, 0.083333333333333, 0.4, 0.0625
47901, 0.083333333333333, 0.425, 0.083333333333333
47902, 0.0625, 0.45, 0.083333333333333
47903, 0.083333333333333, 0.45, 0.0625
47904, 0.083333333333333, 0.475, 0.083333333333333
47905, 0.0625, 0.5, 0.083333333333333
47906, 0.083333333333333, 0.5, 0.0625
47907, 0.083333333333333, 0.525, 0.083333333333333
47908, 0.0625, 0.55, 0.083333333333333
47909, 0.083333333333333, 0.55, 0.0625
47910, 0.083333333333333, 0.575, 0.083333333333333
47911, 0.0625, 0.6, 0.083333333333333
47912, 0.083333333333333, 0.6, 0.0625
47913, 0.083333333333333, 0.625, 0.083333333333333
47914, 0.0625, 0.65, 0.083333333333333
47915, 0.083333333333333, 0.65, 0.0625
47916, 0.083333333333333, 0.675, 0.083333333333333
47917, 0.0625, 0.7, 0.083333333333333
47918, 0.083333333333333, 0.7, 0.0625
47919, 0.083333333333333, 0.725, 0.083333333333333
47920, 0.0625, 0.75, 0.083333333333333
47921, 0.083333333333333, 0.75, 0.0625
47922, 0.083333333333333, 0.775, 0.083333333333333
47923, 0.0625, 0.8, 0.083333333333333
47924, 0.083333333333333, 0.8, 0.0625
47925, 0.083333333333333, 0.825, 0.083333333333333
47926, 0.0625, 0.85, 0.083333333333333
47927, 0.083333333333333, 0.85, 0.0625
47928, 0.083333333333333, 0.875, 0.083333333333333
47929, 0.0625, 0.9, 0.083333333333333
47930, 0.083333333333333, 0.9, 0.0625
47931, 0.083333333333333, 0.925, 0.083333333333333
47932, 0.0625, 0.95, 0.083333333333333
47933, 0.083333333333333, 0.95, 0.0625
47934, 0.083333333333333, 0.975, 0.083333333333333
47935, 0.0625, 1, 0.083333333333333
47936, 0.083333333333333, 1, 0.0625
47937, 0.083333333333333, 1.025, 0.083333333333333
47938, 0.0625, 1.05, 0.083333333333333
47939, 0.083333333333333, 1.05, 0.0625
47940, 0.083333333333333, 1.075, 0.083333333333333
47941, 0.0625, 1.1, 0.083333333333333
47942, 0.083333333333333, 1.1, 0.0625
47943, 0.083333333333333, 1.125, 0.083333333333333
47944, 0.0625, 1.15, 0.083333333333333
47945, 0.083333333333333, 1.15, 0.0625
47946, 0.083333333333333, 1.175, 0.083333333333333
47947, 0.0625, 1.2, 0.083333333333333
47948, 0.083333333333333, 1.2, 0.0625
47949, 0.083333333333333, 1.225, 0.083333333333333
47950, 0.0625, 1.25, 0.083333333333333
47951, 0.083333333333333, 1.25, 0.0625
47952, 0.083333333333333, 1.275, 0.083333333333333
47953, 0.0625, 1.3, 0.083333333333333
47954, 0.083333333333333, 1.3, 0.0625
47955, 0.083333333333333, 1.325, 0.083333333333333
47956, 0.083333333333333, 0.175, 0.125
47957, 0.0625, 0.2, 0.125
47958, 0.083333333333333, 0.2, 0.10416666666667
47959, 0.083333333333333, 0.225, 0.125
47960, 0.0625, 0.25, 0.125
47961, 0.083333333333333, 0.25, 0.10416666666667
47962, 0.083333333333333, 0.275, 0.125
47963, 0.0625, 0.3, 0.125
47964, 0.083333333333333, 0.3, 0.10416666666667
47965, 0.083333333333333, 0.325, 0.125
47966, 0.0625, 0.35, 0.125
47967, 0.083333333333333, 0.35, 0.10416666666667
47968, 0.083333333333333, 0.375, 0.125
47969, 0.0625, 0.4, 0.125
47970, 0.083333333333333, 0.4, 0.10416666666667
47971, 0.083333333333333, 0.425, 0.125
47972, 0.0625, 0.45, 0.125
47973, 0.083333333333333, 0.45, 0.10416666666667
47974, 0.083333333333333, 0.475, 0.125
47975, 0.0625, 0.5, 0.125
47976, 0.083333333333333, 0.5, 0.10416666666667
47977, 0.083333333333333, 0.525, 0.125
47978, 0.0625, 0.55, 0.125
47979, 0.083333333333333, 0.55, 0.10416666666667
47980, 0.083333333333333, 0.575, 0.125
47981, 0.0625, 0.6, 0.125
47982, 0.083333333333333, 0.6, 0.10416666666667
47983, 0.083333333333333, 0.625, 0.125
47984, 0.0625, 0.65, 0.125
47985, 0.083333333333333, 0.65, 0.10416666666667
47986, 0.083333333333333, 0.675, 0.125
47987, 0.0625, 0.7, 0.125
47988, 0.083333333333333, 0.7, 0.10416666666667
47989, 0.083333333333333, 0.725, 0.125
47990, 0.0625, 0.75, 0.125
47991, 0.083333333333333, 0.75, 0.10416666666667
47992, 0.083333333333333, 0.775, 0.125
47993, 0.0625, 0.8, 0.125
47994, 0.083333333333333, 0.8, 0.10416666666667
47995, 0.083333333333333, 0.825, 0.125
47996, 0.0625, 0.85, 0.125
47997, 0.083333333333333, 0.85, 0.10416666666667
47998, 0.083333333333333, 0.875, 0.125
47999, 0.0625, 0.9, 0.125
48000, 0.083333333333333, 0.9, 0.10416666666667
48001, 0.083333333333333, 0.925, 0.125
48002, 0.0625, 0.95, 0.125
48003, 0.083333333333333, 0.95, 0.10416666666667
48004, 0.083333333333333, 0.975, 0.125
48005, 0.0625, 1, 0.125
48006, 0.083333333333333, 1, 0.10416666666667
48007, 0.083333333333333, 1.025, 0.125
48008, 0.0625, 1.05, 0.125
48009, 0.083333333333333, 1.05, 0.10416666666667
48010, 0.083333333333333, 1.075, 0.125
48011, 0.0625, 1.1, 0.125
48012, 0.083333333333333, 1.1, 0.10416666666667
48013, 0.083333333333333, 1.125, 0.125
48014, 0.0625, 1.15, 0.125
48015, 0.083333333333333, 1.15, 0.10416666666667
48016, 0.083333333333333, 1.175, 0.125
48017, 0.0625, 1.2, 0.125
48018, 0.083333333333333, 1.2, 0.10416666666667
48019, 0.083333333333333, 1.225, 0.125
48020, 0.0625, 1.25, 0.125
48021, 0.083333333333333, 1.25, 0.10416666666667
48022, 0.083333333333333, 1.275, 0.125
48023, 0.0625, 1.3, 0.125
48024, 0.083333333333333, 1.3, 0.10416666666667
48025, 0.083333333333333, 1.325, 0.125
48026, 0.083333333333333, 0.175, 0.16666666666667
48027, 0.0625, 0.2, 0.16666666666667
48028, 0.083333333333333, 0.2, 0.14583333333333
48029, 0.083333333333333, 0.225, 0.16666666666667
48030, 0.0625, 0.25, 0.16666666666667
48031, 0.083333333333333, 0.25, 0.14583333333333
48032, 0.083333333333333, 0.275, 0.16666666666667
48033, 0.0625, 0.3, 0.16666666666667
48034, 0.083333333333333, 0.3, 0.14583333333333
48035, 0.083333333333333, 0.325, 0.16666666666667
48036, 0.0625, 0.35, 0.16666666666667
48037, 0.083333333333333, 0.35, 0.14583333333333
48038, 0.083333333333333, 0.375, 0.16666666666667
48039, 0.0625, 0.4, 0.16666666666667
48040, 0.083333333333333, 0.4, 0.14583333333333
48041, 0.083333333333333, 0.425, 0.16666666666667
48042, 0.0625, 0.45, 0.16666666666667
48043, 0.083333333333333, 0.45, 0.14583333333333
48044, 0.083333333333333, 0.475, 0.16666666666667
48045, 0.0625, 0.5, 0.16666666666667
48046, 0.083333333333333, 0.5, 0.14583333333333
48047, 0.083333333333333, 0.525, 0.16666666666667
48048, 0.0625, 0.55, 0.16666666666667
48049, 0.083333333333333, 0.55, 0.14583333333333
48050, 0.083333333333333, 0.575, 0.16666666666667
48051, 0.0625, 0.6, 0.16666666666667
48052, 0.083333333333333, 0.6, 0.14583333333333
48053, 0.083333333333333, 0.625, 0.16666666666667
48054, 0.0625, 0.65, 0.16666666666667
48055, 0.083333333333333, 0.65, 0.14583333333333
48056, 0.083333333333333, 0.675, 0.16666666666667
48057, 0.0625, 0.7, 0.16666666666667
48058, 0.083333333333333, 0.7, 0.14583333333333
48059, 0.083333333333333, 0.725, 0.16666666666667
48060, 0.0625, 0.75, 0.16666666666667
48061, 0.083333333333333, 0.75, 0.14583333333333
48062, 0.083333333333333, 0.775, 0.16666666666667
48063, 0.0625, 0.8, 0.16666666666667
48064, 0.083333333333333, 0.8, 0.14583333333333
48065, 0.083333333333333, 0.825, 0.16666666666667
48066, 0.0625, 0.85, 0.16666666666667
48067, 0.083333333333333, 0.85, 0.14583333333333
48068, 0.083333333333333, 0.875, 0.16666666666667
48069, 0.0625, 0.9, 0.16666666666667
48070, 0.083333333333333, 0.9, 0.14583333333333
48071, 0.083333333333333, 0.925, 0.16666666666667
48072, 0.0625, 0.95, 0.16666666666667
48073, 0.083333333333333, 0.95, 0.14583333333333
48074, 0.083333333333333, 0.975, 0.16666666666667
48075, 0.0625, 1, 0.16666666666667
48076, 0.083333333333333, 1, 0.14583333333333
48077, 0.083333333333333, 1.025, 0.16666666666667
48078, 0.0625, 1.05, 0.16666666666667
48079, 0.083333333333333, 1.05, 0.14583333333333
48080, 0.083333333333333, 1.075, 0.16666666666667
48081, 0.0625, 1.1, 0.16666666666667
48082, 0.083333333333333, 1.1, 0.14583333333333
48083, 0.083333333333333, 1.125, 0.16666666666667
48084, 0.0625, 1.15, 0.16666666666667
48085, 0.083333333333333, 1.15, 0.14583333333333
48086, 0.083333333333333, 1.175, 0.16666666666667
48087, 0.0625, 1.2, 0.16666666666667
48088, 0.083333333333333, 1.2, 0.14583333333333
48089, 0.083333333333333, 1.225, 0.16666666666667
48090, 0.0625, 1.25, 0.16666666666667
48091, 0.083333333333333, 1.25, 0.14583333333333
48092, 0.083333333333333, 1.275, 0.16666666666667
48093, 0.0625, 1.3, 0.16666666666667
48094, 0.083333333333333, 1.3, 0.14583333333333
48095, 0.083333333333333, 1.325, 0.16666666666667
48096, 0.083333333333333, 0.175, 0.20833333333333
48097, 0.0625, 0.2, 0.20833333333333
48098, 0.083333333333333, 0.2, 0.1875
48099, 0.083333333333333, 0.225, 0.20833333333333
48100, 0.0625, 0.25, 0.20833333333333
48101, 0.083333333333333, 0.25, 0.1875
48102, 0.083333333333333, 0.275, 0.20833333333333
48103, 0.0625, 0.3, 0.20833333333333
48104, 0.083333333333333, 0.3, 0.1875
48105, 0.083333333333333, 0.325, 0.20833333333333
48106, 0.0625, 0.35, 0.20833333333333
48107, 0.083333333333333, 0.35, 0.1875
48108, 0.083333333333333, 0.375, 0.20833333333333
48109, 0.0625, 0.4, 0.20833333333333
48110, 0.083333333333333, 0.4, 0.1875
48111, 0.083333333333333, 0.425, 0.20833333333333
48112, 0.0625, 0.45, 0.20833333333333
48113, 0.083333333333333, 0.45, 0.1875
48114, 0.083333333333333, 0.475, 0.20833333333333
48115, 0.0625, 0.5, 0.20833333333333
48116, 0.083333333333333, 0.5, 0.1875
48117, 0.083333333333333, 0.525, 0.20833333333333
48118, 0.0625, 0.55, 0.20833333333333
48119, 0.083333333333333, 0.55, 0.1875
48120, 0.083333333333333, 0.575, 0.20833333333333
48121, 0.0625, 0.6, 0.20833333333333
48122, 0.083333333333333, 0.6, 0.1875
48123, 0.083333333333333, 0.625, 0.20833333333333
48124, 0.0625, 0.65, 0.20833333333333
48125, 0.083333333333333, 0.65, 0.1875
48126, 0.083333333333333, 0.675, 0.20833333333333
48127, 0.0625, 0.7, 0.20833333333333
48128, 0.083333333333333, 0.7, 0.1875
48129, 0.083333333333333, 0.725, 0.20833333333333
48130, 0.0625, 0.75, 0.20833333333333
48131, 0.083333333333333, 0.75, 0.1875
48132, 0.083333333333333, 0.775, 0.20833333333333
48133, 0.0625, 0.8, 0.20833333333333
48134, 0.083333333333333, 0.8, 0.1875
48135, 0.083333333333333, 0.825, 0.20833333333333
48136, 0.0625, 0.85, 0.20833333333333
48137, 0.083333333333333, 0.85, 0.1875
48138, 0.083333333333333, 0.875, 0.20833333333333
48139, 0.0625, 0.9, 0.20833333333333
48140, 0.083333333333333, 0.9, 0.1875
48141, 0.083333333333333, 0.925, 0.20833333333333
48142, 0.0625, 0.95, 0.20833333333333
48143, 0.083333333333333, 0.95, 0.1875
48144, 0.083333333333333, 0.975, 0.20833333333333
48145, 0.0625, 1, 0.20833333333333
48146, 0.083333333333333, 1, 0.1875
48147, 0.083333333333333, 1.025, 0.20833333333333
48148, 0.0625, 1.05, 0.20833333333333
48149, 0.083333333333333, 1.05, 0.1875
48150, 0.083333333333333, 1.075, 0.20833333333333
48151, 0.0625, 1.1, 0.20833333333333
48152, 0.083333333333333, 1.1, 0.1875
48153, 0.083333333333333, 1.125, 0.20833333333333
48154, 0.0625, 1.15, 0.20833333333333
48155, 0.083333333333333, 1.15, 0.1875
48156, 0.083333333333333, 1.175, 0.20833333333333
48157, 0.0625, 1.2, 0.20833333333333
48158, 0.083333333333333, 1.2, 0.1875
48159, 0.083333333333333, 1.225, 0.20833333333333
48160, 0.0625, 1.25, 0.20833333333333
48161, 0.083333333333333, 1.25, 0.1875
48162, 0.083333333333333, 1.275, 0.20833333333333
48163, 0.0625, 1.3, 0.20833333333333
48164, 0.083333333333333, 1.3, 0.1875
48165, 0.083333333333333, 1.325, 0.20833333333333
48166, 0.083333333333333, 0.175, 0.25
48167, 0.0625, 0.2, 0.25
48168, 0.083333333333333, 0.2, 0.22916666666667
48169, 0.083333333333333, 0.225, 0.25
48170, 0.0625, 0.25, 0.25
48171, 0.083333333333333, 0.25, 0.22916666666667
48172, 0.083333333333333, 0.275, 0.25
48173, 0.0625, 0.3, 0.25
48174, 0.083333333333333, 0.3, 0.22916666666667
48175, 0.083333333333333, 0.325, 0.25
48176, 0.0625, 0.35, 0.25
48177, 0.083333333333333, 0.35, 0.22916666666667
48178, 0.083333333333333, 0.375, 0.25
48179, 0.0625, 0.4, 0.25
48180, 0.083333333333333, 0.4, 0.22916666666667
48181, 0.083333333333333, 0.425, 0.25
48182, 0.0625, 0.45, 0.25
48183, 0.083333333333333, 0.45, 0.22916666666667
48184, 0.083333333333333, 0.475, 0.25
48185, 0.0625, 0.5, 0.25
48186, 0.083333333333333, 0.5, 0.22916666666667
48187, 0.083333333333333, 0.525, 0.25
48188, 0.0625, 0.55, 0.25
48189, 0.083333333333333, 0.55, 0.22916666666667
48190, 0.083333333333333, 0.575, 0.25
48191, 0.0625, 0.6, 0.25
48192, 0.083333333333333, 0.6, 0.22916666666667
48193, 0.083333333333333, 0.625, 0.25
48194, 0.0625, 0.65, 0.25
48195, 0.083333333333333, 0.65, 0.22916666666667
48196, 0.083333333333333, 0.675, 0.25
48197, 0.0625, 0.7, 0.25
48198, 0.083333333333333, 0.7, 0.22916666666667
48199, 0.083333333333333, 0.725, 0.25
48200, 0.0625, 0.75, 0.25
48201, 0.083333333333333, 0.75, 0.22916666666667
48202, 0.083333333333333, 0.775, 0.25
48203, 0.0625, 0.8, 0.25
48204, 0.083333333333333, 0.8, 0.22916666666667
48205, 0.083333333333333, 0.825, 0.25
48206, 0.0625, 0.85, 0.25
48207, 0.083333333333333, 0.85, 0.22916666666667
48208, 0.083333333333333, 0.875, 0.25
48209, 0.0625, 0.9, 0.25
48210, 0.083333333333333, 0.9, 0.22916666666667
48211, 0.083333333333333, 0.925, 0.25
48212, 0.0625, 0.95, 0.25
48213, 0.083333333333333, 0.95, 0.22916666666667
48214, 0.083333333333333, 0.975, 0.25
48215, 0.0625, 1, 0.25
48216, 0.083333333333333, 1, 0.22916666666667
48217, 0.083333333333333, 1.025, 0.25
48218, 0.0625, 1.05, 0.25
48219, 0.083333333333333, 1.05, 0.22916666666667
48220, 0.083333333333333, 1.075, 0.25
48221, 0.0625, 1.1, 0.25
48222, 0.083333333333333, 1.1, 0.22916666666667
48223, 0.083333333333333, 1.125, 0.25
48224, 0.0625, 1.15, 0.25
48225, 0.083333333333333, 1.15, 0.22916666666667
48226, 0.083333333333333, 1.175, 0.25
48227, 0.0625, 1.2, 0.25
48228, 0.083333333333333, 1.2, 0.22916666666667
48229, 0.083333333333333, 1.225, 0.25
48230, 0.0625, 1.25, 0.25
48231, 0.083333333333333, 1.25, 0.22916666666667
48232, 0.083333333333333, 1.275, 0.25
48233, 0.0625, 1.3, 0.25
48234, 0.083333333333333, 1.3, 0.22916666666667
48235, 0.083333333333333, 1.325, 0.25
48236, 0.083333333333333, 0.175, 0.29166666666667
48237, 0.0625, 0.2, 0.29166666666667
48238, 0.083333333333333, 0.2, 0.27083333333333
48239, 0.083333333333333, 0.225, 0.29166666666667
48240, 0.0625, 0.25, 0.29166666666667
48241, 0.083333333333333, 0.25, 0.27083333333333
48242, 0.083333333333333, 0.275, 0.29166666666667
48243, 0.0625, 0.3, 0.29166666666667
48244, 0.083333333333333, 0.3, 0.27083333333333
48245, 0.083333333333333, 0.325, 0.29166666666667
48246, 0.0625, 0.35, 0.29166666666667
48247, 0.083333333333333, 0.35, 0.27083333333333
48248, 0.083333333333333, 0.375, 0.29166666666667
48249, 0.0625, 0.4, 0.29166666666667
48250, 0.083333333333333, 0.4, 0.27083333333333
48251, 0.083333333333333, 0.425, 0.29166666666667
48252, 0.0625, 0.45, 0.29166666666667
48253, 0.083333333333333, 0.45, 0.27083333333333
48254, 0.083333333333333, 0.475, 0.29166666666667
48255, 0.0625, 0.5, 0.29166666666667
48256, 0.083333333333333, 0.5, 0.27083333333333
48257, 0.083333333333333, 0.525, 0.29166666666667
48258, 0.0625, 0.55, 0.29166666666667
48259, 0.083333333333333, 0.55, 0.27083333333333
48260, 0.083333333333333, 0.575, 0.29166666666667
48261, 0.0625, 0.6, 0.29166666666667
48262, 0.083333333333333, 0.6, 0.27083333333333
48263, 0.083333333333333, 0.625, 0.29166666666667
48264, 0.0625, 0.65, 0.29166666666667
48265, 0.083333333333333, 0.65, 0.27083333333333
48266, 0.083333333333333, 0.675, 0.29166666666667
48267, 0.0625, 0.7, 0.29166666666667
48268, 0.083333333333333, 0.7, 0.27083333333333
48269, 0.083333333333333, 0.725, 0.29166666666667
48270, 0.0625, 0.75, 0.29166666666667
48271, 0.083333333333333, 0.75, 0.27083333333333
48272, 0.083333333333333, 0.775, 0.29166666666667
48273, 0.0625, 0.8, 0.29166666666667
48274, 0.083333333333333, 0.8, 0.27083333333333
48275, 0.083333333333333, 0.825, 0.29166666666667
48276, 0.0625, 0.85, 0.29166666666667
48277, 0.083333333333333, 0.85, 0.27083333333333
48278, 0.083333333333333, 0.875, 0.29166666666667
48279, 0.0625, 0.9, 0.29166666666667
48280, 0.083333333333333, 0.9, 0.27083333333333
48281, 0.083333333333333, 0.925, 0.29166666666667
48282, 0.0625, 0.95, 0.29166666666667
48283, 0.083333333333333, 0.95, 0.27083333333333
48284, 0.083333333333333, 0.975, 0.29166666666667
48285, 0.0625, 1, 0.29166666666667
48286, 0.083333333333333, 1, 0.27083333333333
48287, 0.083333333333333, 1.025, 0.29166666666667
48288, 0.0625, 1.05, 0.29166666666667
48289, 0.083333333333333, 1.05, 0.27083333333333
48290, 0.083333333333333, 1.075, 0.29166666666667
48291, 0.0625, 1.1, 0.29166666666667
48292, 0.083333333333333, 1.1, 0.27083333333333
48293, 0.083333333333333, 1.125, 0.29166666666667
48294, 0.0625, 1.15, 0.29166666666667
48295, 0.083333333333333, 1.15, 0.27083333333333
48296, 0.083333333333333, 1.175, 0.29166666666667
48297, 0.0625, 1.2, 0.29166666666667
48298, 0.083333333333333, 1.2, 0.27083333333333
48299, 0.083333333333333, 1.225, 0.29166666666667
48300, 0.0625, 1.25, 0.29166666666667
48301, 0.083333333333333, 1.25, 0.27083333333333
48302, 0.083333333333333, 1.275, 0.29166666666667
48303, 0.0625, 1.3, 0.29166666666667
48304, 0.083333333333333, 1.3, 0.27083333333333
48305, 0.083333333333333, 1.325, 0.29166666666667
48306, 0.083333333333333, 0.175, 0.33333333333333
48307, 0.0625, 0.2, 0.33333333333333
48308, 0.083333333333333, 0.2, 0.3125
48309, 0.083333333333333, 0.225, 0.33333333333333
48310, 0.0625, 0.25, 0.33333333333333
48311, 0.083333333333333, 0.25, 0.3125
48312, 0.083333333333333, 0.275, 0.33333333333333
48313, 0.0625, 0.3, 0.33333333333333
48314, 0.083333333333333, 0.3, 0.3125
48315, 0.083333333333333, 0.325, 0.33333333333333
48316, 0.0625, 0.35, 0.33333333333333
48317, 0.083333333333333, 0.35, 0.3125
48318, 0.083333333333333, 0.375, 0.33333333333333
48319, 0.0625, 0.4, 0.33333333333333
48320, 0.083333333333333, 0.4, 0.3125
48321, 0.083333333333333, 0.425, 0.33333333333333
48322, 0.0625, 0.45, 0.33333333333333
48323, 0.083333333333333, 0.45, 0.3125
48324, 0.083333333333333, 0.475, 0.33333333333333
48325, 0.0625, 0.5, 0.33333333333333
48326, 0.083333333333333, 0.5, 0.3125
48327, 0.083333333333333, 0.525, 0.33333333333333
48328, 0.0625, 0.55, 0.33333333333333
48329, 0.083333333333333, 0.55, 0.3125
48330, 0.083333333333333, 0.575, 0.33333333333333
48331, 0.0625, 0.6, 0.33333333333333
48332, 0.083333333333333, 0.6, 0.3125
48333, 0.083333333333333, 0.625, 0.33333333333333
48334, 0.0625, 0.65, 0.33333333333333
48335, 0.083333333333333, 0.65, 0.3125
48336, 0.083333333333333, 0.675, 0.33333333333333
48337, 0.0625, 0.7, 0.33333333333333
48338, 0.083333333333333, 0.7, 0.3125
48339, 0.083333333333333, 0.725, 0.33333333333333
48340, 0.0625, 0.75, 0.33333333333333
48341, 0.083333333333333, 0.75, 0.3125
48342, 0.083333333333333, 0.775, 0.33333333333333
48343, 0.0625, 0.8, 0.33333333333333
48344, 0.083333333333333, 0.8, 0.3125
48345, 0.083333333333333, 0.825, 0.33333333333333
48346, 0.0625, 0.85, 0.33333333333333
48347, 0.083333333333333, 0.85, 0.3125
48348, 0.083333333333333, 0.875, 0.33333333333333
48349, 0.0625, 0.9, 0.33333333333333
48350, 0.083333333333333, 0.9, 0.3125
48351, 0.083333333333333, 0.925, 0.33333333333333
48352, 0.0625, 0.95, 0.33333333333333
48353, 0.083333333333333, 0.95, 0.3125
48354, 0.083333333333333, 0.975, 0.33333333333333
48355, 0.0625, 1, 0.33333333333333
48356, 0.083333333333333, 1, 0.3125
48357, 0.083333333333333, 1.025, 0.33333333333333
48358, 0.0625, 1.05, 0.33333333333333
48359, 0.083333333333333, 1.05, 0.3125
48360, 0.083333333333333, 1.075, 0.33333333333333
48361, 0.0625, 1.1, 0.33333333333333
48362, 0.083333333333333, 1.1, 0.3125
48363, 0.083333333333333, 1.125, 0.33333333333333
48364, 0.0625, 1.15, 0.33333333333333
48365, 0.083333333333333, 1.15, 0.3125
48366, 0.083333333333333, 1.175, 0.33333333333333
48367, 0.0625, 1.2, 0.33333333333333
48368, 0.083333333333333, 1.2, 0.3125
48369, 0.083333333333333, 1.225, 0.33333333333333
48370, 0.0625, 1.25, 0.33333333333333
48371, 0.083333333333333, 1.25, 0.3125
48372, 0.083333333333333, 1.275, 0.33333333333333
48373, 0.0625, 1.3, 0.33333333333333
48374, 0.083333333333333, 1.3, 0.3125
48375, 0.083333333333333, 1.325, 0.33333333333333
48376, 0.083333333333333, 0.175, 0.375
48377, 0.0625, 0.2, 0.375
48378, 0.083333333333333, 0.2, 0.35416666666667
48379, 0.083333333333333, 0.225, 0.375
48380, 0.0625, 0.25, 0.375
48381, 0.083333333333333, 0.25, 0.35416666666667
48382, 0.083333333333333, 0.275, 0.375
48383, 0.0625, 0.3, 0.375
48384, 0.083333333333333, 0.3, 0.35416666666667
48385, 0.083333333333333, 0.325, 0.375
48386, 0.0625, 0.35, 0.375
48387, 0.083333333333333, 0.35, 0.35416666666667
48388, 0.083333333333333, 0.375, 0.375
48389, 0.0625, 0.4, 0.375
48390, 0.083333333333333, 0.4, 0.35416666666667
48391, 0.083333333333333, 0.425, 0.375
48392, 0.0625, 0.45, 0.375
48393, 0.083333333333333, 0.45, 0.35416666666667
48394, 0.083333333333333, 0.475, 0.375
48395, 0.0625, 0.5, 0.375
48396, 0.083333333333333, 0.5, 0.35416666666667
48397, 0.083333333333333, 0.525, 0.375
48398, 0.0625, 0.55, 0.375
48399, 0.083333333333333, 0.55, 0.35416666666667
48400, 0.083333333333333, 0.575, 0.375
48401, 0.0625, 0.6, 0.375
48402, 0.083333333333333, 0.6, 0.35416666666667
48403, 0.083333333333333, 0.625, 0.375
48404, 0.0625, 0.65, 0.375
48405, 0.083333333333333, 0.65, 0.35416666666667
48406, 0.083333333333333, 0.675, 0.375
48407, 0.0625, 0.7, 0.375
48408, 0.083333333333333, 0.7, 0.35416666666667
48409, 0.083333333333333, 0.725, 0.375
48410, 0.0625, 0.75, 0.375
48411, 0.083333333333333, 0.75, 0.35416666666667
48412, 0.083333333333333, 0.775, 0.375
48413, 0.0625, 0.8, 0.375
48414, 0.083333333333333, 0.8, 0.35416666666667
48415, 0.083333333333333, 0.825, 0.375
48416, 0.0625, 0.85, 0.375
48417, 0.083333333333333, 0.85, 0.35416666666667
48418, 0.083333333333333, 0.875, 0.375
48419, 0.0625, 0.9, 0.375
48420, 0.083333333333333, 0.9, 0.35416666666667
48421, 0.083333333333333, 0.925, 0.375
48422, 0.0625, 0.95, 0.375
48423, 0.083333333333333, 0.95, 0.35416666666667
48424, 0.083333333333333, 0.975, 0.375
48425, 0.0625, 1, 0.375
48426, 0.083333333333333, 1, 0.35416666666667
48427, 0.083333333333333, 1.025, 0.375
48428, 0.0625, 1.05, 0.375
48429, 0.083333333333333, 1.05, 0.35416666666667
48430, 0.083333333333333, 1.075, 0.375
48431, 0.0625, 1.1, 0.375
48432, 0.083333333333333, 1.1, 0.35416666666667
48433, 0.083333333333333, 1.125, 0.375
48434, 0.0625, 1.15, 0.375
48435, 0.083333333333333, 1.15, 0.35416666666667
48436, 0.083333333333333, 1.175, 0.375
48437, 0.0625, 1.2, 0.375
48438, 0.083333333333333, 1.2, 0.35416666666667
48439, 0.083333333333333, 1.225, 0.375
48440, 0.0625, 1.25, 0.375
48441, 0.083333333333333, 1.25, 0.35416666666667
48442, 0.083333333333333, 1.275, 0.375
48443, 0.0625, 1.3, 0.375
48444, 0.083333333333333, 1.3, 0.35416666666667
48445, 0.083333333333333, 1.325, 0.375
48446, 0.083333333333333, 0.175, 0.41666666666667
48447, 0.0625, 0.2, 0.41666666666667
48448, 0.083333333333333, 0.2, 0.39583333333333
48449, 0.083333333333333, 0.225, 0.41666666666667
48450, 0.0625, 0.25, 0.41666666666667
48451, 0.083333333333333, 0.25, 0.39583333333333
48452, 0.083333333333333, 0.275, 0.41666666666667
48453, 0.0625, 0.3, 0.41666666666667
48454, 0.083333333333333, 0.3, 0.39583333333333
48455, 0.083333333333333, 0.325, 0.41666666666667
48456, 0.0625, 0.35, 0.41666666666667
48457, 0.083333333333333, 0.35, 0.39583333333333
48458, 0.083333333333333, 0.375, 0.41666666666667
48459, 0.0625, 0.4, 0.41666666666667
48460, 0.083333333333333, 0.4, 0.39583333333333
48461, 0.083333333333333, 0.425, 0.41666666666667
48462, 0.0625, 0.45, 0.41666666666667
48463, 0.083333333333333, 0.45, 0.39583333333333
48464, 0.083333333333333, 0.475, 0.41666666666667
48465, 0.0625, 0.5, 0.41666666666667
48466, 0.083333333333333, 0.5, 0.39583333333333
48467, 0.083333333333333, 0.525, 0.41666666666667
48468, 0.0625, 0.55, 0.41666666666667
48469, 0.083333333333333, 0.55, 0.39583333333333
48470, 0.083333333333333, 0.575, 0.41666666666667
48471, 0.0625, 0.6, 0.41666666666667
48472, 0.083333333333333, 0.6, 0.39583333333333
48473, 0.083333333333333, 0.625, 0.41666666666667
48474, 0.0625, 0.65, 0.41666666666667
48475, 0.083333333333333, 0.65, 0.39583333333333
48476, 0.083333333333333, 0.675, 0.41666666666667
48477, 0.0625, 0.7, 0.41666666666667
48478, 0.083333333333333, 0.7, 0.39583333333333
48479, 0.083333333333333, 0.725, 0.41666666666667
48480, 0.0625, 0.75, 0.41666666666667
48481, 0.083333333333333, 0.75, 0.39583333333333
48482, 0.083333333333333, 0.775, 0.41666666666667
48483, 0.0625, 0.8, 0.41666666666667
48484, 0.083333333333333, 0.8, 0.39583333333333
48485, 0.083333333333333, 0.825, 0.41666666666667
48486, 0.0625, 0.85, 0.41666666666667
48487, 0.083333333333333, 0.85, 0.39583333333333
48488, 0.083333333333333, 0.875, 0.41666666666667
48489, 0.0625, 0.9, 0.41666666666667
48490, 0.083333333333333, 0.9, 0.39583333333333
48491, 0.083333333333333, 0.925, 0.41666666666667
48492, 0.0625, 0.95, 0.41666666666667
48493, 0.083333333333333, 0.95, 0.39583333333333
48494, 0.083333333333333, 0.975, 0.41666666666667
48495, 0.0625, 1, 0.41666666666667
48496, 0.083333333333333, 1, 0.39583333333333
48497, 0.083333333333333, 1.025, 0.41666666666667
48498, 0.0625, 1.05, 0.41666666666667
48499, 0.083333333333333, 1.05, 0.39583333333333
48500, 0.083333333333333, 1.075, 0.41666666666667
48501, 0.0625, 1.1, 0.41666666666667
48502, 0.083333333333333, 1.1, 0.39583333333333
48503, 0.083333333333333, 1.125, 0.41666666666667
48504, 0.0625, 1.15, 0.41666666666667
48505, 0.083333333333333, 1.15, 0.39583333333333
48506, 0.083333333333333, 1.175, 0.41666666666667
48507, 0.0625, 1.2, 0.41666666666667
48508, 0.083333333333333, 1.2, 0.39583333333333
48509, 0.083333333333333, 1.225, 0.41666666666667
48510, 0.0625, 1.25, 0.41666666666667
48511, 0.083333333333333, 1.25, 0.39583333333333
48512, 0.083333333333333, 1.275, 0.41666666666667
48513, 0.0625, 1.3, 0.41666666666667
48514, 0.083333333333333, 1.3, 0.39583333333333
48515, 0.083333333333333, 1.325, 0.41666666666667
48516, 0.083333333333333, 0.175, 0.45833333333333
48517, 0.0625, 0.2, 0.45833333333333
48518, 0.083333333333333, 0.2, 0.4375
48519, 0.083333333333333, 0.225, 0.45833333333333
48520, 0.0625, 0.25, 0.45833333333333
48521, 0.083333333333333, 0.25, 0.4375
48522, 0.083333333333333, 0.275, 0.45833333333333
48523, 0.0625, 0.3, 0.45833333333333
48524, 0.083333333333333, 0.3, 0.4375
48525, 0.083333333333333, 0.325, 0.45833333333333
48526, 0.0625, 0.35, 0.45833333333333
48527, 0.083333333333333, 0.35, 0.4375
48528, 0.083333333333333, 0.375, 0.45833333333333
48529, 0.0625, 0.4, 0.45833333333333
48530, 0.083333333333333, 0.4, 0.4375
48531, 0.083333333333333, 0.425, 0.45833333333333
48532, 0.0625, 0.45, 0.45833333333333
48533, 0.083333333333333, 0.45, 0.4375
48534, 0.083333333333333, 0.475, 0.45833333333333
48535, 0.0625, 0.5, 0.45833333333333
48536, 0.083333333333333, 0.5, 0.4375
48537, 0.083333333333333, 0.525, 0.45833333333333
48538, 0.0625, 0.55, 0.45833333333333
48539, 0.083333333333333, 0.55, 0.4375
48540, 0.083333333333333, 0.575, 0.45833333333333
48541, 0.0625, 0.6, 0.45833333333333
48542, 0.083333333333333, 0.6, 0.4375
48543, 0.083333333333333, 0.625, 0.45833333333333
48544, 0.0625, 0.65, 0.45833333333333
48545, 0.083333333333333, 0.65, 0.4375
48546, 0.083333333333333, 0.675, 0.45833333333333
48547, 0.0625, 0.7, 0.45833333333333
48548, 0.083333333333333, 0.7, 0.4375
48549, 0.083333333333333, 0.725, 0.45833333333333
48550, 0.0625, 0.75, 0.45833333333333
48551, 0.083333333333333, 0.75, 0.4375
48552, 0.083333333333333, 0.775, 0.45833333333333
48553, 0.0625, 0.8, 0.45833333333333
48554, 0.083333333333333, 0.8, 0.4375
48555, 0.083333333333333, 0.825, 0.45833333333333
48556, 0.0625, 0.85, 0.45833333333333
48557, 0.083333333333333, 0.85, 0.4375
48558, 0.083333333333333, 0.875, 0.45833333333333
48559, 0.0625, 0.9, 0.45833333333333
48560, 0.083333333333333, 0.9, 0.4375
48561, 0.083333333333333, 0.925, 0.45833333333333
48562, 0.0625, 0.95, 0.45833333333333
48563, 0.083333333333333, 0.95, 0.4375
48564, 0.083333333333333, 0.975, 0.45833333333333
48565, 0.0625, 1, 0.45833333333333
48566, 0.083333333333333, 1, 0.4375
48567, 0.083333333333333, 1.025, 0.45833333333333
48568, 0.0625, 1.05, 0.45833333333333
48569, 0.083333333333333, 1.05, 0.4375
48570, 0.083333333333333, 1.075, 0.45833333333333
48571, 0.0625, 1.1, 0.45833333333333
48572, 0.083333333333333, 1.1, 0.4375
48573, 0.083333333333333, 1.125, 0.45833333333333
48574, 0.0625, 1.15, 0.45833333333333
48575, 0.083333333333333, 1.15, 0.4375
48576, 0.083333333333333, 1.175, 0.45833333333333
48577, 0.0625, 1.2, 0.45833333333333
48578, 0.083333333333333, 1.2, 0.4375
48579, 0.083333333333333, 1.225, 0.45833333333333
48580, 0.0625, 1.25, 0.45833333333333
48581, 0.083333333333333, 1.25, 0.4375
48582, 0.083333333333333, 1.275, 0.45833333333333
48583, 0.0625, 1.3, 0.45833333333333
48584, 0.083333333333333, 1.3, 0.4375
48585, 0.083333333333333, 1.325, 0.45833333333333
48586, 0.083333333333333, 0.2, 0.47916666666667
48587, 0.083333333333333, 0.25, 0.47916666666667
48588, 0.083333333333333, 0.3, 0.47916666666667
48589, 0.083333333333333, 0.35, 0.47916666666667
48590, 0.083333333333333, 0.4, 0.47916666666667
48591, 0.083333333333333, 0.45, 0.47916666666667
48592, 0.083333333333333, 0.5, 0.47916666666667
48593, 0.083333333333333, 0.55, 0.47916666666667
48594, 0.083333333333333, 0.6, 0.47916666666667
48595, 0.083333333333333, 0.65, 0.47916666666667
48596, 0.083333333333333, 0.7, 0.47916666666667
48597, 0.083333333333333, 0.75, 0.47916666666667
48598, 0.083333333333333, 0.8, 0.47916666666667
48599, 0.083333333333333, 0.85, 0.47916666666667
48600, 0.083333333333333, 0.9, 0.47916666666667
48601, 0.083333333333333, 0.95, 0.47916666666667
48602, 0.083333333333333, 1, 0.47916666666667
48603, 0.083333333333333, 1.05, 0.47916666666667
48604, 0.083333333333333, 1.1, 0.47916666666667
48605, 0.083333333333333, 1.15, 0.47916666666667
48606, 0.083333333333333, 1.2, 0.47916666666667
48607, 0.083333333333333, 1.25, 0.47916666666667
48608, 0.083333333333333, 1.3, 0.47916666666667
48609, 0.125, 0.175, 0.041666666666667
48610, 0.10416666666667, 0.2, 0.041666666666667
48611, 0.125, 0.2, 0.020833333333333
48612, 0.125, 0.225, 0.041666666666667
48613, 0.10416666666667, 0.25, 0.041666666666667
48614, 0.125, 0.25, 0.020833333333333
48615, 0.125, 0.275, 0.041666666666667
48616, 0.10416666666667, 0.3, 0.041666666666667
48617, 0.125, 0.3, 0.020833333333333
48618, 0.125, 0.325, 0.041666666666667
48619, 0.10416666666667, 0.35, 0.041666666666667
48620, 0.125, 0.35, 0.020833333333333
48621, 0.125, 0.375, 0.041666666666667
48622, 0.10416666666667, 0.4, 0.041666666666667
48623, 0.125, 0.4, 0.020833333333333
48624, 0.125, 0.425, 0.041666666666667
48625, 0.10416666666667, 0.45, 0.041666666666667
48626, 0.125, 0.45, 0.020833333333333
48627, 0.125, 0.475, 0.041666666666667
48628, 0.10416666666667, 0.5, 0.041666666666667
48629, 0.125, 0.5, 0.020833333333333
48630, 0.125, 0.525, 0.041666666666667
48631, 0.10416666666667, 0.55, 0.041666666666667
48632, 0.125, 0.55, 0.020833333333333
48633, 0.125, 0.575, 0.041666666666667
48634, 0.10416666666667, 0.6, 0.041666666666667
48635, 0.125, 0.6, 0.020833333333333
48636, 0.125, 0.625, 0.041666666666667
48637, 0.10416666666667, 0.65, 0.041666666666667
48638, 0.125, 0.65, 0.020833333333333
48639, 0.125, 0.675, 0.041666666666667
48640, 0.10416666666667, 0.7, 0.041666666666667
48641, 0.125, 0.7, 0.020833333333333
48642, 0.125, 0.725, 0.041666666666667
48643, 0.10416666666667, 0.75, 0.041666666666667
48644, 0.125, 0.75, 0.020833333333333
48645, 0.125, 0.775, 0.041666666666667
48646, 0.10416666666667, 0.8, 0.041666666666667
48647, 0.125, 0.8, 0.020833333333333
48648, 0.125, 0.825, 0.041666666666667
48649, 0.10416666666667, 0.85, 0.041666666666667
48650, 0.125, 0.85, 0.020833333333333
48651, 0.125, 0.875, 0.041666666666667
48652, 0.10416666666667, 0.9, 0.041666666666667
48653, 0.125, 0.9, 0.020833333333333
48654, 0.125, 0.925, 0.041666666666667
48655, 0.10416666666667, 0.95, 0.041666666666667
48656, 0.125, 0.95, 0.020833333333333
48657, 0.125, 0.975, 0.041666666666667
48658, 0.10416666666667, 1, 0.041666666666667
48659, 0.125, 1, 0.020833333333333
48660, 0.125, 1.025, 0.041666666666667
48661, 0.10416666666667, 1.05, 0.041666666666667
48662, 0.125, 1.05, 0.020833333333333
48663, 0.125, 1.075, 0.041666666666667
48664, 0.10416666666667, 1.1, 0.041666666666667
48665, 0.125, 1.1, 0.020833333333333
48666, 0.125, 1.125, 0.041666666666667
48667, 0.10416666666667, 1.15, 0.041666666666667
48668, 0.125, 1.15, 0.020833333333333
48669, 0.125, 1.175, 0.041666666666667
48670, 0.10416666666667, 1.2, 0.041666666666667
48671, 0.125, 1.2, 0.020833333333333
48672, 0.125, 1.225, 0.041666666666667
48673, 0.10416666666667, 1.25, 0.041666666666667
48674, 0.125, 1.25, 0.020833333333333
48675, 0.125, 1.275, 0.041666666666667
48676, 0.10416666666667, 1.3, 0.041666666666667
48677, 0.125, 1.3, 0.020833333333333
48678, 0.125, 1.325, 0.041666666666667
48679, 0.125, 0.175, 0.083333333333333
48680, 0.10416666666667, 0.2, 0.083333333333333
48681, 0.125, 0.2, 0.0625
48682, 0.125, 0.225, 0.083333333333333
48683, 0.10416666666667, 0.25, 0.083333333333333
48684, 0.125, 0.25, 0.0625
48685, 0.125, 0.275, 0.083333333333333
48686, 0.10416666666667, 0.3, 0.083333333333333
48687, 0.125, 0.3, 0.0625
48688, 0.125, 0.325, 0.083333333333333
48689, 0.10416666666667, 0.35, 0.083333333333333
48690, 0.125, 0.35, 0.0625
48691, 0.125, 0.375, 0.083333333333333
48692, 0.10416666666667, 0.4, 0.083333333333333
48693, 0.125, 0.4, 0.0625
48694, 0.125, 0.425, 0.083333333333333
48695, 0.10416666666667, 0.45, 0.083333333333333
48696, 0.125, 0.45, 0.0625
48697, 0.125, 0.475, 0.083333333333333
48698, 0.10416666666667, 0.5, 0.083333333333333
48699, 0.125, 0.5, 0.0625
48700, 0.125, 0.525, 0.083333333333333
48701, 0.10416666666667, 0.55, 0.083333333333333
48702, 0.125, 0.55, 0.0625
48703, 0.125, 0.575, 0.083333333333333
48704, 0.10416666666667, 0.6, 0.083333333333333
48705, 0.125, 0.6, 0.0625
48706, 0.125, 0.625, 0.083333333333333
48707, 0.10416666666667, 0.65, 0.083333333333333
48708, 0.125, 0.65, 0.0625
48709, 0.125, 0.675, 0.083333333333333
48710, 0.10416666666667, 0.7, 0.083333333333333
48711, 0.125, 0.7, 0.0625
48712, 0.125, 0.725, 0.083333333333333
48713, 0.10416666666667, 0.75, 0.083333333333333
48714, 0.125, 0.75, 0.0625
48715, 0.125, 0.775, 0.083333333333333
48716, 0.10416666666667, 0.8, 0.083333333333333
48717, 0.125, 0.8, 0.0625
48718, 0.125, 0.825, 0.083333333333333
48719, 0.10416666666667, 0.85, 0.083333333333333
48720, 0.125, 0.85, 0.0625
48721, 0.125, 0.875, 0.083333333333333
48722, 0.10416666666667, 0.9, 0.083333333333333
48723, 0.125, 0.9, 0.0625
48724, 0.125, 0.925, 0.083333333333333
48725, 0.10416666666667, 0.95, 0.083333333333333
48726, 0.125, 0.95, 0.0625
48727, 0.125, 0.975, 0.083333333333333
48728, 0.10416666666667, 1, 0.083333333333333
48729, 0.125, 1, 0.0625
48730, 0.125, 1.025, 0.083333333333333
48731, 0.10416666666667, 1.05, 0.083333333333333
48732, 0.125, 1.05, 0.0625
48733, 0.125, 1.075, 0.083333333333333
48734, 0.10416666666667, 1.1, 0.083333333333333
48735, 0.125, 1.1, 0.0625
48736, 0.125, 1.125, 0.083333333333333
48737, 0.10416666666667, 1.15, 0.083333333333333
48738, 0.125, 1.15, 0.0625
48739, 0.125, 1.175, 0.083333333333333
48740, 0.10416666666667, 1.2, 0.083333333333333
48741, 0.125, 1.2, 0.0625
48742, 0.125, 1.225, 0.083333333333333
48743, 0.10416666666667, 1.25, 0.083333333333333
48744, 0.125, 1.25, 0.0625
48745, 0.125, 1.275, 0.083333333333333
48746, 0.10416666666667, 1.3, 0.083333333333333
48747, 0.125, 1.3, 0.0625
48748, 0.125, 1.325, 0.083333333333333
48749, 0.125, 0.175, 0.125
48750, 0.10416666666667, 0.2, 0.125
48751, 0.125, 0.2, 0.10416666666667
48752, 0.125, 0.225, 0.125
48753, 0.10416666666667, 0.25, 0.125
48754, 0.125, 0.25, 0.10416666666667
48755, 0.125, 0.275, 0.125
48756, 0.10416666666667, 0.3, 0.125
48757, 0.125, 0.3, 0.10416666666667
48758, 0.125, 0.325, 0.125
48759, 0.10416666666667, 0.35, 0.125
48760, 0.125, 0.35, 0.10416666666667
48761, 0.125, 0.375, 0.125
48762, 0.10416666666667, 0.4, 0.125
48763, 0.125, 0.4, 0.10416666666667
48764, 0.125, 0.425, 0.125
48765, 0.10416666666667, 0.45, 0.125
48766, 0.125, 0.45, 0.10416666666667
48767, 0.125, 0.475, 0.125
48768, 0.10416666666667, 0.5, 0.125
48769, 0.125, 0.5, 0.10416666666667
48770, 0.125, 0.525, 0.125
48771, 0.10416666666667, 0.55, 0.125
48772, 0.125, 0.55, 0.10416666666667
48773, 0.125, 0.575, 0.125
48774, 0.10416666666667, 0.6, 0.125
48775, 0.125, 0.6, 0.10416666666667
48776, 0.125, 0.625, 0.125
48777, 0.10416666666667, 0.65, 0.125
48778, 0.125, 0.65, 0.10416666666667
48779, 0.125, 0.675, 0.125
48780, 0.10416666666667, 0.7, 0.125
48781, 0.125, 0.7, 0.10416666666667
48782, 0.125, 0.725, 0.125
48783, 0.10416666666667, 0.75, 0.125
48784, 0.125, 0.75, 0.10416666666667
48785, 0.125, 0.775, 0.125
48786, 0.10416666666667, 0.8, 0.125
48787, 0.125, 0.8, 0.10416666666667
48788, 0.125, 0.825, 0.125
48789, 0.10416666666667, 0.85, 0.125
48790, 0.125, 0.85, 0.10416666666667
48791, 0.125, 0.875, 0.125
48792, 0.10416666666667, 0.9, 0.125
48793, 0.125, 0.9, 0.10416666666667
48794, 0.125, 0.925, 0.125
48795, 0.10416666666667, 0.95, 0.125
48796, 0.125, 0.95, 0.10416666666667
48797, 0.125, 0.975, 0.125
48798, 0.10416666666667, 1, 0.125
48799, 0.125, 1, 0.10416666666667
48800, 0.125, 1.025, 0.125
48801, 0.10416666666667, 1.05, 0.125
48802, 0.125, 1.05, 0.10416666666667
48803, 0.125, 1.075, 0.125
48804, 0.10416666666667, 1.1, 0.125
48805, 0.125, 1.1, 0.10416666666667
48806, 0.125, 1.125, 0.125
48807, 0.10416666666667, 1.15, 0.125
48808, 0.125, 1.15, 0.10416666666667
48809, 0.125, 1.175, 0.125
48810, 0.10416666666667, 1.2, 0.125
48811, 0.125, 1.2, 0.10416666666667
48812, 0.125, 1.225, 0.125
48813, 0.10416666666667, 1.25, 0.125
48814, 0.125, 1.25, 0.10416666666667
48815, 0.125, 1.275, 0.125
48816, 0.10416666666667, 1.3, 0.125
48817, 0.125, 1.3, 0.10416666666667
48818, 0.125, 1.325, 0.125
48819, 0.125, 0.175, 0.16666666666667
48820, 0.10416666666667, 0.2, 0.16666666666667
48821, 0.125, 0.2, 0.14583333333333
48822, 0.125, 0.225, 0.16666666666667
48823, 0.10416666666667, 0.25, 0.16666666666667
48824, 0.125, 0.25, 0.14583333333333
48825, 0.125, 0.275, 0.16666666666667
48826, 0.10416666666667, 0.3, 0.16666666666667
48827, 0.125, 0.3, 0.14583333333333
48828, 0.125, 0.325, 0.16666666666667
48829, 0.10416666666667, 0.35, 0.16666666666667
48830, 0.125, 0.35, 0.14583333333333
48831, 0.125, 0.375, 0.16666666666667
48832, 0.10416666666667, 0.4, 0.16666666666667
48833, 0.125, 0.4, 0.14583333333333
48834, 0.125, 0.425, 0.16666666666667
48835, 0.10416666666667, 0.45, 0.16666666666667
48836, 0.125, 0.45, 0.14583333333333
48837, 0.125, 0.475, 0.16666666666667
48838, 0.10416666666667, 0.5, 0.16666666666667
48839, 0.125, 0.5, 0.14583333333333
48840, 0.125, 0.525, 0.16666666666667
48841, 0.10416666666667, 0.55, 0.16666666666667
48842, 0.125, 0.55, 0.14583333333333
48843, 0.125, 0.575, 0.16666666666667
48844, 0.10416666666667, 0.6, 0.16666666666667
48845, 0.125, 0.6, 0.14583333333333
48846, 0.125, 0.625, 0.16666666666667
48847, 0.10416666666667, 0.65, 0.16666666666667
48848, 0.125, 0.65, 0.14583333333333
48849, 0.125, 0.675, 0.16666666666667
48850, 0.10416666666667, 0.7, 0.16666666666667
48851, 0.125, 0.7, 0.14583333333333
48852, 0.125, 0.725, 0.16666666666667
48853, 0.10416666666667, 0.75, 0.16666666666667
48854, 0.125, 0.75, 0.14583333333333
48855, 0.125, 0.775, 0.16666666666667
48856, 0.10416666666667, 0.8, 0.16666666666667
48857, 0.125, 0.8, 0.14583333333333
48858, 0.125, 0.825, 0.16666666666667
48859, 0.10416666666667, 0.85, 0.16666666666667
48860, 0.125, 0.85, 0.14583333333333
48861, 0.125, 0.875, 0.16666666666667
48862, 0.10416666666667, 0.9, 0.16666666666667
48863, 0.125, 0.9, 0.14583333333333
48864, 0.125, 0.925, 0.16666666666667
48865, 0.10416666666667, 0.95, 0.16666666666667
48866, 0.125, 0.95, 0.14583333333333
48867, 0.125, 0.975, 0.16666666666667
48868, 0.10416666666667, 1, 0.16666666666667
48869, 0.125, 1, 0.14583333333333
48870, 0.125, 1.025, 0.16666666666667
48871, 0.10416666666667, 1.05, 0.16666666666667
48872, 0.125, 1.05, 0.14583333333333
48873, 0.125, 1.075, 0.16666666666667
48874, 0.10416666666667, 1.1, 0.16666666666667
48875, 0.125, 1.1, 0.14583333333333
48876, 0.125, 1.125, 0.16666666666667
48877, 0.10416666666667, 1.15, 0.16666666666667
48878, 0.125, 1.15, 0.14583333333333
48879, 0.125, 1.175, 0.16666666666667
48880, 0.10416666666667, 1.2, 0.16666666666667
48881, 0.125, 1.2, 0.14583333333333
48882, 0.125, 1.225, 0.16666666666667
48883, 0.10416666666667, 1.25, 0.16666666666667
48884, 0.125, 1.25, 0.14583333333333
48885, 0.125, 1.275, 0.16666666666667
48886, 0.10416666666667, 1.3, 0.16666666666667
48887, 0.125, 1.3, 0.14583333333333
48888, 0.125, 1.325, 0.16666666666667
48889, 0.125, 0.175, 0.20833333333333
48890, 0.10416666666667, 0.2, 0.20833333333333
48891, 0.125, 0.2, 0.1875
48892, 0.125, 0.225, 0.20833333333333
48893, 0.10416666666667, 0.25, 0.20833333333333
48894, 0.125, 0.25, 0.1875
48895, 0.125, 0.275, 0.20833333333333
48896, 0.10416666666667, 0.3, 0.20833333333333
48897, 0.125, 0.3, 0.1875
48898, 0.125, 0.325, 0.20833333333333
48899, 0.10416666666667, 0.35, 0.20833333333333
48900, 0.125, 0.35, 0.1875
48901, 0.125, 0.375, 0.20833333333333
48902, 0.10416666666667, 0.4, 0.20833333333333
48903, 0.125, 0.4, 0.1875
48904, 0.125, 0.425, 0.20833333333333
48905, 0.10416666666667, 0.45, 0.20833333333333
48906, 0.125, 0.45, 0.1875
48907, 0.125, 0.475, 0.20833333333333
48908, 0.10416666666667, 0.5, 0.20833333333333
48909, 0.125, 0.5, 0.1875
48910, 0.125, 0.525, 0.20833333333333
48911, 0.10416666666667, 0.55, 0.20833333333333
48912, 0.125, 0.55, 0.1875
48913, 0.125, 0.575, 0.20833333333333
48914, 0.10416666666667, 0.6, 0.20833333333333
48915, 0.125, 0.6, 0.1875
48916, 0.125, 0.625, 0.20833333333333
48917, 0.10416666666667, 0.65, 0.20833333333333
48918, 0.125, 0.65, 0.1875
48919, 0.125, 0.675, 0.20833333333333
48920, 0.10416666666667, 0.7, 0.20833333333333
48921, 0.125, 0.7, 0.1875
48922, 0.125, 0.725, 0.20833333333333
48923, 0.10416666666667, 0.75, 0.20833333333333
48924, 0.125, 0.75, 0.1875
48925, 0.125, 0.775, 0.20833333333333
48926, 0.10416666666667, 0.8, 0.20833333333333
48927, 0.125, 0.8, 0.1875
48928, 0.125, 0.825, 0.20833333333333
48929, 0.10416666666667, 0.85, 0.20833333333333
48930, 0.125, 0.85, 0.1875
48931, 0.125, 0.875, 0.20833333333333
48932, 0.10416666666667, 0.9, 0.20833333333333
48933, 0.125, 0.9, 0.1875
48934, 0.125, 0.925, 0.20833333333333
48935, 0.10416666666667, 0.95, 0.20833333333333
48936, 0.125, 0.95, 0.1875
48937, 0.125, 0.975, 0.20833333333333
48938, 0.10416666666667, 1, 0.20833333333333
48939, 0.125, 1, 0.1875
48940, 0.125, 1.025, 0.20833333333333
48941, 0.10416666666667, 1.05, 0.20833333333333
48942, 0.125, 1.05, 0.1875
48943, 0.125, 1.075, 0.20833333333333
48944, 0.10416666666667, 1.1, 0.20833333333333
48945, 0.125, 1.1, 0.1875
48946, 0.125, 1.125, 0.20833333333333
48947, 0.10416666666667, 1.15, 0.20833333333333
48948, 0.125, 1.15, 0.1875
48949, 0.125, 1.175, 0.20833333333333
48950, 0.10416666666667, 1.2, 0.20833333333333
48951, 0.125, 1.2, 0.1875
48952, 0.125, 1.225, 0.20833333333333
48953, 0.10416666666667, 1.25, 0.20833333333333
48954, 0.125, 1.25, 0.1875
48955, 0.125, 1.275, 0.20833333333333
48956, 0.10416666666667, 1.3, 0.20833333333333
48957, 0.125, 1.3, 0.1875
48958, 0.125, 1.325, 0.20833333333333
48959, 0.125, 0.175, 0.25
48960, 0.10416666666667, 0.2, 0.25
48961, 0.125, 0.2, 0.22916666666667
48962, 0.125, 0.225, 0.25
48963, 0.10416666666667, 0.25, 0.25
48964, 0.125, 0.25, 0.22916666666667
48965, 0.125, 0.275, 0.25
48966, 0.10416666666667, 0.3, 0.25
48967, 0.125, 0.3, 0.22916666666667
48968, 0.125, 0.325, 0.25
48969, 0.10416666666667, 0.35, 0.25
48970, 0.125, 0.35, 0.22916666666667
48971, 0.125, 0.375, 0.25
48972, 0.10416666666667, 0.4, 0.25
48973, 0.125, 0.4, 0.22916666666667
48974, 0.125, 0.425, 0.25
48975, 0.10416666666667, 0.45, 0.25
48976, 0.125, 0.45, 0.22916666666667
48977, 0.125, 0.475, 0.25
48978, 0.10416666666667, 0.5, 0.25
48979, 0.125, 0.5, 0.22916666666667
48980, 0.125, 0.525, 0.25
48981, 0.10416666666667, 0.55, 0.25
48982, 0.125, 0.55, 0.22916666666667
48983, 0.125, 0.575, 0.25
48984, 0.10416666666667, 0.6, 0.25
48985, 0.125, 0.6, 0.22916666666667
48986, 0.125, 0.625, 0.25
48987, 0.10416666666667, 0.65, 0.25
48988, 0.125, 0.65, 0.22916666666667
48989, 0.125, 0.675, 0.25
48990, 0.10416666666667, 0.7, 0.25
48991, 0.125, 0.7, 0.22916666666667
48992, 0.125, 0.725, 0.25
48993, 0.10416666666667, 0.75, 0.25
48994, 0.125, 0.75, 0.22916666666667
48995, 0.125, 0.775, 0.25
48996, 0.10416666666667, 0.8, 0.25
48997, 0.125, 0.8, 0.22916666666667
48998, 0.125, 0.825, 0.25
48999, 0.10416666666667, 0.85, 0.25
49000, 0.125, 0.85, 0.22916666666667
49001, 0.125, 0.875, 0.25
49002, 0.10416666666667, 0.9, 0.25
49003, 0.125, 0.9, 0.22916666666667
49004, 0.125, 0.925, 0.25
49005, 0.10416666666667, 0.95, 0.25
49006, 0.125, 0.95, 0.22916666666667
49007, 0.125, 0.975, 0.25
49008, 0.10416666666667, 1, 0.25
49009, 0.125, 1, 0.22916666666667
49010, 0.125, 1.025, 0.25
49011, 0.10416666666667, 1.05, 0.25
49012, 0.125, 1.05, 0.22916666666667
49013, 0.125, 1.075, 0.25
49014, 0.10416666666667, 1.1, 0.25
49015, 0.125, 1.1, 0.22916666666667
49016, 0.125, 1.125, 0.25
49017, 0.10416666666667, 1.15, 0.25
49018, 0.125, 1.15, 0.22916666666667
49019, 0.125, 1.175, 0.25
49020, 0.10416666666667, 1.2, 0.25
49021, 0.125, 1.2, 0.22916666666667
49022, 0.125, 1.225, 0.25
49023, 0.10416666666667, 1.25, 0.25
49024, 0.125, 1.25, 0.22916666666667
49025, 0.125, 1.275, 0.25
49026, 0.10416666666667, 1.3, 0.25
49027, 0.125, 1.3, 0.22916666666667
49028, 0.125, 1.325, 0.25
49029, 0.125, 0.175, 0.29166666666667
49030, 0.10416666666667, 0.2, 0.29166666666667
49031, 0.125, 0.2, 0.27083333333333
49032, 0.125, 0.225, 0.29166666666667
49033, 0.10416666666667, 0.25, 0.29166666666667
49034, 0.125, 0.25, 0.27083333333333
49035, 0.125, 0.275, 0.29166666666667
49036, 0.10416666666667, 0.3, 0.29166666666667
49037, 0.125, 0.3, 0.27083333333333
49038, 0.125, 0.325, 0.29166666666667
49039, 0.10416666666667, 0.35, 0.29166666666667
49040, 0.125, 0.35, 0.27083333333333
49041, 0.125, 0.375, 0.29166666666667
49042, 0.10416666666667, 0.4, 0.29166666666667
49043, 0.125, 0.4, 0.27083333333333
49044, 0.125, 0.425, 0.29166666666667
49045, 0.10416666666667, 0.45, 0.29166666666667
49046, 0.125, 0.45, 0.27083333333333
49047, 0.125, 0.475, 0.29166666666667
49048, 0.10416666666667, 0.5, 0.29166666666667
49049, 0.125, 0.5, 0.27083333333333
49050, 0.125, 0.525, 0.29166666666667
49051, 0.10416666666667, 0.55, 0.29166666666667
49052, 0.125, 0.55, 0.27083333333333
49053, 0.125, 0.575, 0.29166666666667
49054, 0.10416666666667, 0.6, 0.29166666666667
49055, 0.125, 0.6, 0.27083333333333
49056, 0.125, 0.625, 0.29166666666667
49057, 0.10416666666667, 0.65, 0.29166666666667
49058, 0.125, 0.65, 0.27083333333333
49059, 0.125, 0.675, 0.29166666666667
49060, 0.10416666666667, 0.7, 0.29166666666667
49061, 0.125, 0.7, 0.27083333333333
49062, 0.125, 0.725, 0.29166666666667
49063, 0.10416666666667, 0.75, 0.29166666666667
49064, 0.125, 0.75, 0.27083333333333
49065, 0.125, 0.775, 0.29166666666667
49066, 0.10416666666667, 0.8, 0.29166666666667
49067, 0.125, 0.8, 0.27083333333333
49068, 0.125, 0.825, 0.29166666666667
49069, 0.10416666666667, 0.85, 0.29166666666667
49070, 0.125, 0.85, 0.27083333333333
49071, 0.125, 0.875, 0.29166666666667
49072, 0.10416666666667, 0.9, 0.29166666666667
49073, 0.125, 0.9, 0.27083333333333
49074, 0.125, 0.925, 0.29166666666667
49075, 0.10416666666667, 0.95, 0.29166666666667
49076, 0.125, 0.95, 0.27083333333333
49077, 0.125, 0.975, 0.29166666666667
49078, 0.10416666666667, 1, 0.29166666666667
49079, 0.125, 1, 0.27083333333333
49080, 0.125, 1.025, 0.29166666666667
49081, 0.10416666666667, 1.05, 0.29166666666667
49082, 0.125, 1.05, 0.27083333333333
49083, 0.125, 1.075, 0.29166666666667
49084, 0.10416666666667, 1.1, 0.29166666666667
49085, 0.125, 1.1, 0.27083333333333
49086, 0.125, 1.125, 0.29166666666667
49087, 0.10416666666667, 1.15, 0.29166666666667
49088, 0.125, 1.15, 0.27083333333333
49089, 0.125, 1.175, 0.29166666666667
49090, 0.10416666666667, 1.2, 0.29166666666667
49091, 0.125, 1.2, 0.27083333333333
49092, 0.125, 1.225, 0.29166666666667
49093, 0.10416666666667, 1.25, 0.29166666666667
49094, 0.125, 1.25, 0.27083333333333
49095, 0.125, 1.275, 0.29166666666667
49096, 0.10416666666667, 1.3, 0.29166666666667
49097, 0.125, 1.3, 0.27083333333333
49098, 0.125, 1.325, 0.29166666666667
49099, 0.125, 0.175, 0.33333333333333
49100, 0.10416666666667, 0.2, 0.33333333333333
49101, 0.125, 0.2, 0.3125
49102, 0.125, 0.225, 0.33333333333333
49103, 0.10416666666667, 0.25, 0.33333333333333
49104, 0.125, 0.25, 0.3125
49105, 0.125, 0.275, 0.33333333333333
49106, 0.10416666666667, 0.3, 0.33333333333333
49107, 0.125, 0.3, 0.3125
49108, 0.125, 0.325, 0.33333333333333
49109, 0.10416666666667, 0.35, 0.33333333333333
49110, 0.125, 0.35, 0.3125
49111, 0.125, 0.375, 0.33333333333333
49112, 0.10416666666667, 0.4, 0.33333333333333
49113, 0.125, 0.4, 0.3125
49114, 0.125, 0.425, 0.33333333333333
49115, 0.10416666666667, 0.45, 0.33333333333333
49116, 0.125, 0.45, 0.3125
49117, 0.125, 0.475, 0.33333333333333
49118, 0.10416666666667, 0.5, 0.33333333333333
49119, 0.125, 0.5, 0.3125
49120, 0.125, 0.525, 0.33333333333333
49121, 0.10416666666667, 0.55, 0.33333333333333
49122, 0.125, 0.55, 0.3125
49123, 0.125, 0.575, 0.33333333333333
49124, 0.10416666666667, 0.6, 0.33333333333333
49125, 0.125, 0.6, 0.3125
49126, 0.125, 0.625, 0.33333333333333
49127, 0.10416666666667, 0.65, 0.33333333333333
49128, 0.125, 0.65, 0.3125
49129, 0.125, 0.675, 0.33333333333333
49130, 0.10416666666667, 0.7, 0.33333333333333
49131, 0.125, 0.7, 0.3125
49132, 0.125, 0.725, 0.33333333333333
49133, 0.10416666666667, 0.75, 0.33333333333333
49134, 0.125, 0.75, 0.3125
49135, 0.125, 0.775, 0.33333333333333
49136, 0.10416666666667, 0.8, 0.33333333333333
49137, 0.125, 0.8, 0.3125
49138, 0.125, 0.825, 0.33333333333333
49139, 0.10416666666667, 0.85, 0.33333333333333
49140, 0.125, 0.85, 0.3125
49141, 0.125, 0.875, 0.33333333333333
49142, 0.10416666666667, 0.9, 0.33333333333333
49143, 0.125, 0.9, 0.3125
49144, 0.125, 0.925, 0.33333333333333
49145, 0.10416666666667, 0.95, 0.33333333333333
49146, 0.125, 0.95, 0.3125
49147, 0.125, 0.975, 0.33333333333333
49148, 0.10416666666667, 1, 0.33333333333333
49149, 0.125, 1, 0.3125
49150, 0.125, 1.025, 0.33333333333333
49151, 0.10416666666667, 1.05, 0.33333333333333
49152, 0.125, 1.05, 0.3125
49153, 0.125, 1.075, 0.33333333333333
49154, 0.10416666666667, 1.1, 0.33333333333333
49155, 0.125, 1.1, 0.3125
49156, 0.125, 1.125, 0.33333333333333
49157, 0.10416666666667, 1.15, 0.33333333333333
49158, 0.125, 1.15, 0.3125
49159, 0.125, 1.175, 0.33333333333333
49160, 0.10416666666667, 1.2, 0.33333333333333
49161, 0.125, 1.2, 0.3125
49162, 0.125, 1.225, 0.33333333333333
49163, 0.10416666666667, 1.25, 0.33333333333333
49164, 0.125, 1.25, 0.3125
49165, 0.125, 1.275, 0.33333333333333
49166, 0.10416666666667, 1.3, 0.33333333333333
49167, 0.125, 1.3, 0.3125
49168, 0.125, 1.325, 0.33333333333333
49169, 0.125, 0.175, 0.375
49170, 0.10416666666667, 0.2, 0.375
49171, 0.125, 0.2, 0.35416666666667
49172, 0.125, 0.225, 0.375
49173, 0.10416666666667, 0.25, 0.375
49174, 0.125, 0.25, 0.35416666666667
49175, 0.125, 0.275, 0.375
49176, 0.10416666666667, 0.3, 0.375
49177, 0.125, 0.3, 0.35416666666667
49178, 0.125, 0.325, 0.375
49179, 0.10416666666667, 0.35, 0.375
49180, 0.125, 0.35, 0.35416666666667
49181, 0.125, 0.375, 0.375
49182, 0.10416666666667, 0.4, 0.375
49183, 0.125, 0.4, 0.35416666666667
49184, 0.125, 0.425, 0.375
49185, 0.10416666666667, 0.45, 0.375
49186, 0.125, 0.45, 0.35416666666667
49187, 0.125, 0.475, 0.375
49188, 0.10416666666667, 0.5, 0.375
49189, 0.125, 0.5, 0.35416666666667
49190, 0.125, 0.525, 0.375
49191, 0.10416666666667, 0.55, 0.375
49192, 0.125, 0.55, 0.35416666666667
49193, 0.125, 0.575, 0.375
49194, 0.10416666666667, 0.6, 0.375
49195, 0.125, 0.6, 0.35416666666667
49196, 0.125, 0.625, 0.375
49197, 0.10416666666667, 0.65, 0.375
49198, 0.125, 0.65, 0.35416666666667
49199, 0.125, 0.675, 0.375
49200, 0.10416666666667, 0.7, 0.375
49201, 0.125, 0.7, 0.35416666666667
49202, 0.125, 0.725, 0.375
49203, 0.10416666666667, 0.75, 0.375
49204, 0.125, 0.75, 0.35416666666667
49205, 0.125, 0.775, 0.375
49206, 0.10416666666667, 0.8, 0.375
49207, 0.125, 0.8, 0.35416666666667
49208, 0.125, 0.825, 0.375
49209, 0.10416666666667, 0.85, 0.375
49210, 0.125, 0.85, 0.35416666666667
49211, 0.125, 0.875, 0.375
49212, 0.10416666666667, 0.9, 0.375
49213, 0.125, 0.9, 0.35416666666667
49214, 0.125, 0.925, 0.375
49215, 0.10416666666667, 0.95, 0.375
49216, 0.125, 0.95, 0.35416666666667
49217, 0.125, 0.975, 0.375
49218, 0.10416666666667, 1, 0.375
49219, 0.125, 1, 0.35416666666667
49220, 0.125, 1.025, 0.375
49221, 0.10416666666667, 1.05, 0.375
49222, 0.125, 1.05, 0.35416666666667
49223, 0.125, 1.075, 0.375
49224, 0.10416666666667, 1.1, 0.375
49225, 0.125, 1.1, 0.35416666666667
49226, 0.125, 1.125, 0.375
49227, 0.10416666666667, 1.15, 0.375
49228, 0.125, 1.15, 0.35416666666667
49229, 0.125, 1.175, 0.375
49230, 0.10416666666667, 1.2, 0.375
49231, 0.125, 1.2, 0.35416666666667
49232, 0.125, 1.225, 0.375
49233, 0.10416666666667, 1.25, 0.375
49234, 0.125, 1.25, 0.35416666666667
49235, 0.125, 1.275, 0.375
49236, 0.10416666666667, 1.3, 0.375
49237, 0.125, 1.3, 0.35416666666667
49238, 0.125, 1.325, 0.375
49239, 0.125, 0.175, 0.41666666666667
49240, 0.10416666666667, 0.2, 0.41666666666667
49241, 0.125, 0.2, 0.39583333333333
49242, 0.125, 0.225, 0.41666666666667
49243, 0.10416666666667, 0.25, 0.41666666666667
49244, 0.125, 0.25, 0.39583333333333
49245, 0.125, 0.275, 0.41666666666667
49246, 0.10416666666667, 0.3, 0.41666666666667
49247, 0.125, 0.3, 0.39583333333333
49248, 0.125, 0.325, 0.41666666666667
49249, 0.10416666666667, 0.35, 0.41666666666667
49250, 0.125, 0.35, 0.39583333333333
49251, 0.125, 0.375, 0.41666666666667
49252, 0.10416666666667, 0.4, 0.41666666666667
49253, 0.125, 0.4, 0.39583333333333
49254, 0.125, 0.425, 0.41666666666667
49255, 0.10416666666667, 0.45, 0.41666666666667
49256, 0.125, 0.45, 0.39583333333333
49257, 0.125, 0.475, 0.41666666666667
49258, 0.10416666666667, 0.5, 0.41666666666667
49259, 0.125, 0.5, 0.39583333333333
49260, 0.125, 0.525, 0.41666666666667
49261, 0.10416666666667, 0.55, 0.41666666666667
49262, 0.125, 0.55, 0.39583333333333
49263, 0.125, 0.575, 0.41666666666667
49264, 0.10416666666667, 0.6, 0.41666666666667
49265, 0.125, 0.6, 0.39583333333333
49266, 0.125, 0.625, 0.41666666666667
49267, 0.10416666666667, 0.65, 0.41666666666667
49268, 0.125, 0.65, 0.39583333333333
49269, 0.125, 0.675, 0.41666666666667
49270, 0.10416666666667, 0.7, 0.41666666666667
49271, 0.125, 0.7, 0.39583333333333
49272, 0.125, 0.725, 0.41666666666667
49273, 0.10416666666667, 0.75, 0.41666666666667
49274, 0.125, 0.75, 0.39583333333333
49275, 0.125, 0.775, 0.41666666666667
49276, 0.10416666666667, 0.8, 0.41666666666667
49277, 0.125, 0.8, 0.39583333333333
49278, 0.125, 0.825, 0.41666666666667
49279, 0.10416666666667, 0.85, 0.41666666666667
49280, 0.125, 0.85, 0.39583333333333
49281, 0.125, 0.875, 0.41666666666667
49282, 0.10416666666667, 0.9, 0.41666666666667
49283, 0.125, 0.9, 0.39583333333333
49284, 0.125, 0.925, 0.41666666666667
49285, 0.10416666666667, 0.95, 0.41666666666667
49286, 0.125, 0.95, 0.39583333333333
49287, 0.125, 0.975, 0.41666666666667
49288, 0.10416666666667, 1, 0.41666666666667
49289, 0.125, 1, 0.39583333333333
49290, 0.125, 1.025, 0.41666666666667
49291, 0.10416666666667, 1.05, 0.41666666666667
49292, 0.125, 1.05, 0.39583333333333
49293, 0.125, 1.075, 0.41666666666667
49294, 0.10416666666667, 1.1, 0.41666666666667
49295, 0.125, 1.1, 0.39583333333333
49296, 0.125, 1.125, 0.41666666666667
49297, 0.10416666666667, 1.15, 0.41666666666667
49298, 0.125, 1.15, 0.39583333333333
49299, 0.125, 1.175, 0.41666666666667
49300, 0.10416666666667, 1.2, 0.41666666666667
49301, 0.125, 1.2, 0.39583333333333
49302, 0.125, 1.225, 0.41666666666667
49303, 0.10416666666667, 1.25, 0.41666666666667
49304, 0.125, 1.25, 0.39583333333333
49305, 0.125, 1.275, 0.41666666666667
49306, 0.10416666666667, 1.3, 0.41666666666667
49307, 0.125, 1.3, 0.39583333333333
49308, 0.125, 1.325, 0.41666666666667
49309, 0.125, 0.175, 0.45833333333333
49310, 0.10416666666667, 0.2, 0.45833333333333
49311, 0.125, 0.2, 0.4375
49312, 0.125, 0.225, 0.45833333333333
49313, 0.10416666666667, 0.25, 0.45833333333333
49314, 0.125, 0.25, 0.4375
49315, 0.125, 0.275, 0.45833333333333
49316, 0.10416666666667, 0.3, 0.45833333333333
49317, 0.125, 0.3, 0.4375
49318, 0.125, 0.325, 0.45833333333333
49319, 0.10416666666667, 0.35, 0.45833333333333
49320, 0.125, 0.35, 0.4375
49321, 0.125, 0.375, 0.45833333333333
49322, 0.10416666666667, 0.4, 0.45833333333333
49323, 0.125, 0.4, 0.4375
49324, 0.125, 0.425, 0.45833333333333
49325, 0.10416666666667, 0.45, 0.45833333333333
49326, 0.125, 0.45, 0.4375
49327, 0.125, 0.475, 0.45833333333333
49328, 0.10416666666667, 0.5, 0.45833333333333
49329, 0.125, 0.5, 0.4375
49330, 0.125, 0.525, 0.45833333333333
49331, 0.10416666666667, 0.55, 0.45833333333333
49332, 0.125, 0.55, 0.4375
49333, 0.125, 0.575, 0.45833333333333
49334, 0.10416666666667, 0.6, 0.45833333333333
49335, 0.125, 0.6, 0.4375
49336, 0.125, 0.625, 0.45833333333333
49337, 0.10416666666667, 0.65, 0.45833333333333
49338, 0.125, 0.65, 0.4375
49339, 0.125, 0.675, 0.45833333333333
49340, 0.10416666666667, 0.7, 0.45833333333333
49341, 0.125, 0.7, 0.4375
49342, 0.125, 0.725, 0.45833333333333
49343, 0.10416666666667, 0.75, 0.45833333333333
49344, 0.125, 0.75, 0.4375
49345, 0.125, 0.775, 0.45833333333333
49346, 0.10416666666667, 0.8, 0.45833333333333
49347, 0.125, 0.8, 0.4375
49348, 0.125, 0.825, 0.45833333333333
49349, 0.10416666666667, 0.85, 0.45833333333333
49350, 0.125, 0.85, 0.4375
49351, 0.125, 0.875, 0.45833333333333
49352, 0.10416666666667, 0.9, 0.45833333333333
49353, 0.125, 0.9, 0.4375
49354, 0.125, 0.925, 0.45833333333333
49355, 0.10416666666667, 0.95, 0.45833333333333
49356, 0.125, 0.95, 0.4375
49357, 0.125, 0.975, 0.45833333333333
49358, 0.10416666666667, 1, 0.45833333333333
49359, 0.125, 1, 0.4375
49360, 0.125, 1.025, 0.45833333333333
49361, 0.10416666666667, 1.05, 0.45833333333333
49362, 0.125, 1.05, 0.4375
49363, 0.125, 1.075, 0.45833333333333
49364, 0.10416666666667, 1.1, 0.45833333333333
49365, 0.125, 1.1, 0.4375
49366, 0.125, 1.125, 0.45833333333333
49367, 0.10416666666667, 1.15, 0.45833333333333
49368, 0.125, 1.15, 0.4375
49369, 0.125, 1.175, 0.45833333333333
49370, 0.10416666666667, 1.2, 0.45833333333333
49371, 0.125, 1.2, 0.4375
49372, 0.125, 1.225, 0.45833333333333
49373, 0.10416666666667, 1.25, 0.45833333333333
49374, 0.125, 1.25, 0.4375
49375, 0.125, 1.275, 0.45833333333333
49376, 0.10416666666667, 1.3, 0.45833333333333
49377, 0.125, 1.3, 0.4375
49378, 0.125, 1.325, 0.45833333333333
49379, 0.125, 0.2, 0.47916666666667
49380, 0.125, 0.25, 0.47916666666667
49381, 0.125, 0.3, 0.47916666666667
49382, 0.125, 0.35, 0.47916666666667
49383, 0.125, 0.4, 0.47916666666667
49384, 0.125, 0.45, 0.47916666666667
49385, 0.125, 0.5, 0.47916666666667
49386, 0.125, 0.55, 0.47916666666667
49387, 0.125, 0.6, 0.47916666666667
49388, 0.125, 0.65, 0.47916666666667
49389, 0.125, 0.7, 0.47916666666667
49390, 0.125, 0.75, 0.47916666666667
49391, 0.125, 0.8, 0.47916666666667
49392, 0.125, 0.85, 0.47916666666667
49393, 0.125, 0.9, 0.47916666666667
49394, 0.125, 0.95, 0.47916666666667
49395, 0.125, 1, 0.47916666666667
49396, 0.125, 1.05, 0.47916666666667
49397, 0.125, 1.1, 0.47916666666667
49398, 0.125, 1.15, 0.47916666666667
49399, 0.125, 1.2, 0.47916666666667
49400, 0.125, 1.25, 0.47916666666667
49401, 0.125, 1.3, 0.47916666666667
49402, 0.16666666666667, 0.175, 0.041666666666667
49403, 0.14583333333333, 0.2, 0.041666666666667
49404, 0.16666666666667, 0.2, 0.020833333333333
49405, 0.16666666666667, 0.225, 0.041666666666667
49406, 0.14583333333333, 0.25, 0.041666666666667
49407, 0.16666666666667, 0.25, 0.020833333333333
49408, 0.16666666666667, 0.275, 0.041666666666667
49409, 0.14583333333333, 0.3, 0.041666666666667
49410, 0.16666666666667, 0.3, 0.020833333333333
49411, 0.16666666666667, 0.325, 0.041666666666667
49412, 0.14583333333333, 0.35, 0.041666666666667
49413, 0.16666666666667, 0.35, 0.020833333333333
49414, 0.16666666666667, 0.375, 0.041666666666667
49415, 0.14583333333333, 0.4, 0.041666666666667
49416, 0.16666666666667, 0.4, 0.020833333333333
49417, 0.16666666666667, 0.425, 0.041666666666667
49418, 0.14583333333333, 0.45, 0.041666666666667
49419, 0.16666666666667, 0.45, 0.020833333333333
49420, 0.16666666666667, 0.475, 0.041666666666667
49421, 0.14583333333333, 0.5, 0.041666666666667
49422, 0.16666666666667, 0.5, 0.020833333333333
49423, 0.16666666666667, 0.525, 0.041666666666667
49424, 0.14583333333333, 0.55, 0.041666666666667
49425, 0.16666666666667, 0.55, 0.020833333333333
49426, 0.16666666666667, 0.575, 0.041666666666667
49427, 0.14583333333333, 0.6, 0.041666666666667
49428, 0.16666666666667, 0.6, 0.020833333333333
49429, 0.16666666666667, 0.625, 0.041666666666667
49430, 0.14583333333333, 0.65, 0.041666666666667
49431, 0.16666666666667, 0.65, 0.020833333333333
49432, 0.16666666666667, 0.675, 0.041666666666667
49433, 0.14583333333333, 0.7, 0.041666666666667
49434, 0.16666666666667, 0.7, 0.020833333333333
49435, 0.16666666666667, 0.725, 0.041666666666667
49436, 0.14583333333333, 0.75, 0.041666666666667
49437, 0.16666666666667, 0.75, 0.020833333333333
49438, 0.16666666666667, 0.775, 0.041666666666667
49439, 0.14583333333333, 0.8, 0.041666666666667
49440, 0.16666666666667, 0.8, 0.020833333333333
49441, 0.16666666666667, 0.825, 0.041666666666667
49442, 0.14583333333333, 0.85, 0.041666666666667
49443, 0.16666666666667, 0.85, 0.020833333333333
49444, 0.16666666666667, 0.875, 0.041666666666667
49445, 0.14583333333333, 0.9, 0.041666666666667
49446, 0.16666666666667, 0.9, 0.020833333333333
49447, 0.16666666666667, 0.925, 0.041666666666667
49448, 0.14583333333333, 0.95, 0.041666666666667
49449, 0.16666666666667, 0.95, 0.020833333333333
49450, 0.16666666666667, 0.975, 0.041666666666667
49451, 0.14583333333333, 1, 0.041666666666667
49452, 0.16666666666667, 1, 0.020833333333333
49453, 0.16666666666667, 1.025, 0.041666666666667
49454, 0.14583333333333, 1.05, 0.041666666666667
49455, 0.16666666666667, 1.05, 0.020833333333333
49456, 0.16666666666667, 1.075, 0.041666666666667
49457, 0.14583333333333, 1.1, 0.041666666666667
49458, 0.16666666666667, 1.1, 0.020833333333333
49459, 0.16666666666667, 1.125, 0.041666666666667
49460, 0.14583333333333, 1.15, 0.041666666666667
49461, 0.16666666666667, 1.15, 0.020833333333333
49462, 0.16666666666667, 1.175, 0.041666666666667
49463, 0.14583333333333, 1.2, 0.041666666666667
49464, 0.16666666666667, 1.2, 0.020833333333333
49465, 0.16666666666667, 1.225, 0.041666666666667
49466, 0.14583333333333, 1.25, 0.041666666666667
49467, 0.16666666666667, 1.25, 0.020833333333333
49468, 0.16666666666667, 1.275, 0.041666666666667
49469, 0.14583333333333, 1.3, 0.041666666666667
49470, 0.16666666666667, 1.3, 0.020833333333333
49471, 0.16666666666667, 1.325, 0.041666666666667
49472, 0.16666666666667, 0.175, 0.083333333333333
49473, 0.14583333333333, 0.2, 0.083333333333333
49474, 0.16666666666667, 0.2, 0.0625
49475, 0.16666666666667, 0.225, 0.083333333333333
49476, 0.14583333333333, 0.25, 0.083333333333333
49477, 0.16666666666667, 0.25, 0.0625
49478, 0.16666666666667, 0.275, 0.083333333333333
49479, 0.14583333333333, 0.3, 0.083333333333333
49480, 0.16666666666667, 0.3, 0.0625
49481, 0.16666666666667, 0.325, 0.083333333333333
49482, 0.14583333333333, 0.35, 0.083333333333333
49483, 0.16666666666667, 0.35, 0.0625
49484, 0.16666666666667, 0.375, 0.083333333333333
49485, 0.14583333333333, 0.4, 0.083333333333333
49486, 0.16666666666667, 0.4, 0.0625
49487, 0.16666666666667, 0.425, 0.083333333333333
49488, 0.14583333333333, 0.45, 0.083333333333333
49489, 0.16666666666667, 0.45, 0.0625
49490, 0.16666666666667, 0.475, 0.083333333333333
49491, 0.14583333333333, 0.5, 0.083333333333333
49492, 0.16666666666667, 0.5, 0.0625
49493, 0.16666666666667, 0.525, 0.083333333333333
49494, 0.14583333333333, 0.55, 0.083333333333333
49495, 0.16666666666667, 0.55, 0.0625
49496, 0.16666666666667, 0.575, 0.083333333333333
49497, 0.14583333333333, 0.6, 0.083333333333333
49498, 0.16666666666667, 0.6, 0.0625
49499, 0.16666666666667, 0.625, 0.083333333333333
49500, 0.14583333333333, 0.65, 0.083333333333333
49501, 0.16666666666667, 0.65, 0.0625
49502, 0.16666666666667, 0.675, 0.083333333333333
49503, 0.14583333333333, 0.7, 0.083333333333333
49504, 0.16666666666667, 0.7, 0.0625
49505, 0.16666666666667, 0.725, 0.083333333333333
49506, 0.14583333333333, 0.75, 0.083333333333333
49507, 0.16666666666667, 0.75, 0.0625
49508, 0.16666666666667, 0.775, 0.083333333333333
49509, 0.14583333333333, 0.8, 0.083333333333333
49510, 0.16666666666667, 0.8, 0.0625
49511, 0.16666666666667, 0.825, 0.083333333333333
49512, 0.14583333333333, 0.85, 0.083333333333333
49513, 0.16666666666667, 0.85, 0.0625
49514, 0.16666666666667, 0.875, 0.083333333333333
49515, 0.14583333333333, 0.9, 0.083333333333333
49516, 0.16666666666667, 0.9, 0.0625
49517, 0.16666666666667, 0.925, 0.083333333333333
49518, 0.14583333333333, 0.95, 0.083333333333333
49519, 0.16666666666667, 0.95, 0.0625
49520, 0.16666666666667, 0.975, 0.083333333333333
49521, 0.14583333333333, 1, 0.083333333333333
49522, 0.16666666666667, 1, 0.0625
49523, 0.16666666666667, 1.025, 0.083333333333333
49524, 0.14583333333333, 1.05, 0.083333333333333
49525, 0.16666666666667, 1.05, 0.0625
49526, 0.16666666666667, 1.075, 0.083333333333333
49527, 0.14583333333333, 1.1, 0.083333333333333
49528, 0.16666666666667, 1.1, 0.0625
49529, 0.16666666666667, 1.125, 0.083333333333333
49530, 0.14583333333333, 1.15, 0.083333333333333
49531, 0.16666666666667, 1.15, 0.0625
49532, 0.16666666666667, 1.175, 0.083333333333333
49533, 0.14583333333333, 1.2, 0.083333333333333
49534, 0.16666666666667, 1.2, 0.0625
49535, 0.16666666666667, 1.225, 0.083333333333333
49536, 0.14583333333333, 1.25, 0.083333333333333
49537, 0.16666666666667, 1.25, 0.0625
49538, 0.16666666666667, 1.275, 0.083333333333333
49539, 0.14583333333333, 1.3, 0.083333333333333
49540, 0.16666666666667, 1.3, 0.0625
49541, 0.16666666666667, 1.325, 0.083333333333333
49542, 0.16666666666667, 0.175, 0.125
49543, 0.14583333333333, 0.2, 0.125
49544, 0.16666666666667, 0.2, 0.10416666666667
49545, 0.16666666666667, 0.225, 0.125
49546, 0.14583333333333, 0.25, 0.125
49547, 0.16666666666667, 0.25, 0.10416666666667
49548, 0.16666666666667, 0.275, 0.125
49549, 0.14583333333333, 0.3, 0.125
49550, 0.16666666666667, 0.3, 0.10416666666667
49551, 0.16666666666667, 0.325, 0.125
49552, 0.14583333333333, 0.35, 0.125
49553, 0.16666666666667, 0.35, 0.10416666666667
49554, 0.16666666666667, 0.375, 0.125
49555, 0.14583333333333, 0.4, 0.125
49556, 0.16666666666667, 0.4, 0.10416666666667
49557, 0.16666666666667, 0.425, 0.125
49558, 0.14583333333333, 0.45, 0.125
49559, 0.16666666666667, 0.45, 0.10416666666667
49560, 0.16666666666667, 0.475, 0.125
49561, 0.14583333333333, 0.5, 0.125
49562, 0.16666666666667, 0.5, 0.10416666666667
49563, 0.16666666666667, 0.525, 0.125
49564, 0.14583333333333, 0.55, 0.125
49565, 0.16666666666667, 0.55, 0.10416666666667
49566, 0.16666666666667, 0.575, 0.125
49567, 0.14583333333333, 0.6, 0.125
49568, 0.16666666666667, 0.6, 0.10416666666667
49569, 0.16666666666667, 0.625, 0.125
49570, 0.14583333333333, 0.65, 0.125
49571, 0.16666666666667, 0.65, 0.10416666666667
49572, 0.16666666666667, 0.675, 0.125
49573, 0.14583333333333, 0.7, 0.125
49574, 0.16666666666667, 0.7, 0.10416666666667
49575, 0.16666666666667, 0.725, 0.125
49576, 0.14583333333333, 0.75, 0.125
49577, 0.16666666666667, 0.75, 0.10416666666667
49578, 0.16666666666667, 0.775, 0.125
49579, 0.14583333333333, 0.8, 0.125
49580, 0.16666666666667, 0.8, 0.10416666666667
49581, 0.16666666666667, 0.825, 0.125
49582, 0.14583333333333, 0.85, 0.125
49583, 0.16666666666667, 0.85, 0.10416666666667
49584, 0.16666666666667, 0.875, 0.125
49585, 0.14583333333333, 0.9, 0.125
49586, 0.16666666666667, 0.9, 0.10416666666667
49587, 0.16666666666667, 0.925, 0.125
49588, 0.14583333333333, 0.95, 0.125
49589, 0.16666666666667, 0.95, 0.10416666666667
49590, 0.16666666666667, 0.975, 0.125
49591, 0.14583333333333, 1, 0.125
49592, 0.16666666666667, 1, 0.10416666666667
49593, 0.16666666666667, 1.025, 0.125
49594, 0.14583333333333, 1.05, 0.125
49595, 0.16666666666667, 1.05, 0.10416666666667
49596, 0.16666666666667, 1.075, 0.125
49597, 0.14583333333333, 1.1, 0.125
49598, 0.16666666666667, 1.1, 0.10416666666667
49599, 0.16666666666667, 1.125, 0.125
49600, 0.14583333333333, 1.15, 0.125
