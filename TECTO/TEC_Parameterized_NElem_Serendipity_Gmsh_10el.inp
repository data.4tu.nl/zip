38161, 1.7833333333333, -0.2, 0.22916666666667
38162, 1.7625, -0.2, 0.25
38163, 1.825, -0.2, 0.22916666666667
38164, 1.8041666666667, -0.2, 0.25
38165, 1.8666666666667, -0.2, 0.22916666666667
38166, 1.8458333333333, -0.2, 0.25
38167, 1.9083333333333, -0.2, 0.22916666666667
38168, 1.8875, -0.2, 0.25
38169, 1.95, -0.2, 0.22916666666667
38170, 1.9291666666667, -0.2, 0.25
38171, 1.9916666666667, -0.2, 0.22916666666667
38172, 1.9708333333333, -0.2, 0.25
38173, 2.0333333333333, -0.2, 0.22916666666667
38174, 2.0125, -0.2, 0.25
38175, 2.075, -0.2, 0.22916666666667
38176, 2.0541666666667, -0.2, 0.25
38177, 2.1166666666667, -0.2, 0.22916666666667
38178, 2.0958333333333, -0.2, 0.25
38179, 2.1583333333333, -0.2, 0.22916666666667
38180, 2.1375, -0.2, 0.25
38181, 2.1791666666667, -0.2, 0.25
38182, 1.2416666666667, -0.2, 0.27083333333333
38183, 1.2208333333333, -0.2, 0.29166666666667
38184, 1.2833333333333, -0.2, 0.27083333333333
38185, 1.2625, -0.2, 0.29166666666667
38186, 1.325, -0.2, 0.27083333333333
38187, 1.3041666666667, -0.2, 0.29166666666667
38188, 1.3666666666667, -0.2, 0.27083333333333
38189, 1.3458333333333, -0.2, 0.29166666666667
38190, 1.4083333333333, -0.2, 0.27083333333333
38191, 1.3875, -0.2, 0.29166666666667
38192, 1.45, -0.2, 0.27083333333333
38193, 1.4291666666667, -0.2, 0.29166666666667
38194, 1.4916666666667, -0.2, 0.27083333333333
38195, 1.4708333333333, -0.2, 0.29166666666667
38196, 1.5333333333333, -0.2, 0.27083333333333
38197, 1.5125, -0.2, 0.29166666666667
38198, 1.575, -0.2, 0.27083333333333
38199, 1.5541666666667, -0.2, 0.29166666666667
38200, 1.6166666666667, -0.2, 0.27083333333333
38201, 1.5958333333333, -0.2, 0.29166666666667
38202, 1.6583333333333, -0.2, 0.27083333333333
38203, 1.6375, -0.2, 0.29166666666667
38204, 1.7, -0.2, 0.27083333333333
38205, 1.6791666666667, -0.2, 0.29166666666667
38206, 1.7416666666667, -0.2, 0.27083333333333
38207, 1.7208333333333, -0.2, 0.29166666666667
38208, 1.7833333333333, -0.2, 0.27083333333333
38209, 1.7625, -0.2, 0.29166666666667
38210, 1.825, -0.2, 0.27083333333333
38211, 1.8041666666667, -0.2, 0.29166666666667
38212, 1.8666666666667, -0.2, 0.27083333333333
38213, 1.8458333333333, -0.2, 0.29166666666667
38214, 1.9083333333333, -0.2, 0.27083333333333
38215, 1.8875, -0.2, 0.29166666666667
38216, 1.95, -0.2, 0.27083333333333
38217, 1.9291666666667, -0.2, 0.29166666666667
38218, 1.9916666666667, -0.2, 0.27083333333333
38219, 1.9708333333333, -0.2, 0.29166666666667
38220, 2.0333333333333, -0.2, 0.27083333333333
38221, 2.0125, -0.2, 0.29166666666667
38222, 2.075, -0.2, 0.27083333333333
38223, 2.0541666666667, -0.2, 0.29166666666667
38224, 2.1166666666667, -0.2, 0.27083333333333
38225, 2.0958333333333, -0.2, 0.29166666666667
38226, 2.1583333333333, -0.2, 0.27083333333333
38227, 2.1375, -0.2, 0.29166666666667
38228, 2.1791666666667, -0.2, 0.29166666666667
38229, 1.2416666666667, -0.2, 0.3125
38230, 1.2208333333333, -0.2, 0.33333333333333
38231, 1.2833333333333, -0.2, 0.3125
38232, 1.2625, -0.2, 0.33333333333333
38233, 1.325, -0.2, 0.3125
38234, 1.3041666666667, -0.2, 0.33333333333333
38235, 1.3666666666667, -0.2, 0.3125
38236, 1.3458333333333, -0.2, 0.33333333333333
38237, 1.4083333333333, -0.2, 0.3125
38238, 1.3875, -0.2, 0.33333333333333
38239, 1.45, -0.2, 0.3125
38240, 1.4291666666667, -0.2, 0.33333333333333
38241, 1.4916666666667, -0.2, 0.3125
38242, 1.4708333333333, -0.2, 0.33333333333333
38243, 1.5333333333333, -0.2, 0.3125
38244, 1.5125, -0.2, 0.33333333333333
38245, 1.575, -0.2, 0.3125
38246, 1.5541666666667, -0.2, 0.33333333333333
38247, 1.6166666666667, -0.2, 0.3125
38248, 1.5958333333333, -0.2, 0.33333333333333
38249, 1.6583333333333, -0.2, 0.3125
38250, 1.6375, -0.2, 0.33333333333333
38251, 1.7, -0.2, 0.3125
38252, 1.6791666666667, -0.2, 0.33333333333333
38253, 1.7416666666667, -0.2, 0.3125
38254, 1.7208333333333, -0.2, 0.33333333333333
38255, 1.7833333333333, -0.2, 0.3125
38256, 1.7625, -0.2, 0.33333333333333
38257, 1.825, -0.2, 0.3125
38258, 1.8041666666667, -0.2, 0.33333333333333
38259, 1.8666666666667, -0.2, 0.3125
38260, 1.8458333333333, -0.2, 0.33333333333333
38261, 1.9083333333333, -0.2, 0.3125
38262, 1.8875, -0.2, 0.33333333333333
38263, 1.95, -0.2, 0.3125
38264, 1.9291666666667, -0.2, 0.33333333333333
38265, 1.9916666666667, -0.2, 0.3125
38266, 1.9708333333333, -0.2, 0.33333333333333
38267, 2.0333333333333, -0.2, 0.3125
38268, 2.0125, -0.2, 0.33333333333333
38269, 2.075, -0.2, 0.3125
38270, 2.0541666666667, -0.2, 0.33333333333333
38271, 2.1166666666667, -0.2, 0.3125
38272, 2.0958333333333, -0.2, 0.33333333333333
38273, 2.1583333333333, -0.2, 0.3125
38274, 2.1375, -0.2, 0.33333333333333
38275, 2.1791666666667, -0.2, 0.33333333333333
38276, 1.2416666666667, -0.2, 0.35416666666667
38277, 1.2208333333333, -0.2, 0.375
38278, 1.2833333333333, -0.2, 0.35416666666667
38279, 1.2625, -0.2, 0.375
38280, 1.325, -0.2, 0.35416666666667
38281, 1.3041666666667, -0.2, 0.375
38282, 1.3666666666667, -0.2, 0.35416666666667
38283, 1.3458333333333, -0.2, 0.375
38284, 1.4083333333333, -0.2, 0.35416666666667
38285, 1.3875, -0.2, 0.375
38286, 1.45, -0.2, 0.35416666666667
38287, 1.4291666666667, -0.2, 0.375
38288, 1.4916666666667, -0.2, 0.35416666666667
38289, 1.4708333333333, -0.2, 0.375
38290, 1.5333333333333, -0.2, 0.35416666666667
38291, 1.5125, -0.2, 0.375
38292, 1.575, -0.2, 0.35416666666667
38293, 1.5541666666667, -0.2, 0.375
38294, 1.6166666666667, -0.2, 0.35416666666667
38295, 1.5958333333333, -0.2, 0.375
38296, 1.6583333333333, -0.2, 0.35416666666667
38297, 1.6375, -0.2, 0.375
38298, 1.7, -0.2, 0.35416666666667
38299, 1.6791666666667, -0.2, 0.375
38300, 1.7416666666667, -0.2, 0.35416666666667
38301, 1.7208333333333, -0.2, 0.375
38302, 1.7833333333333, -0.2, 0.35416666666667
38303, 1.7625, -0.2, 0.375
38304, 1.825, -0.2, 0.35416666666667
38305, 1.8041666666667, -0.2, 0.375
38306, 1.8666666666667, -0.2, 0.35416666666667
38307, 1.8458333333333, -0.2, 0.375
38308, 1.9083333333333, -0.2, 0.35416666666667
38309, 1.8875, -0.2, 0.375
38310, 1.95, -0.2, 0.35416666666667
38311, 1.9291666666667, -0.2, 0.375
38312, 1.9916666666667, -0.2, 0.35416666666667
38313, 1.9708333333333, -0.2, 0.375
38314, 2.0333333333333, -0.2, 0.35416666666667
38315, 2.0125, -0.2, 0.375
38316, 2.075, -0.2, 0.35416666666667
38317, 2.0541666666667, -0.2, 0.375
38318, 2.1166666666667, -0.2, 0.35416666666667
38319, 2.0958333333333, -0.2, 0.375
38320, 2.1583333333333, -0.2, 0.35416666666667
38321, 2.1375, -0.2, 0.375
38322, 2.1791666666667, -0.2, 0.375
38323, 1.2416666666667, -0.2, 0.39583333333333
38324, 1.2208333333333, -0.2, 0.41666666666667
38325, 1.2833333333333, -0.2, 0.39583333333333
38326, 1.2625, -0.2, 0.41666666666667
38327, 1.325, -0.2, 0.39583333333333
38328, 1.3041666666667, -0.2, 0.41666666666667
38329, 1.3666666666667, -0.2, 0.39583333333333
38330, 1.3458333333333, -0.2, 0.41666666666667
38331, 1.4083333333333, -0.2, 0.39583333333333
38332, 1.3875, -0.2, 0.41666666666667
38333, 1.45, -0.2, 0.39583333333333
38334, 1.4291666666667, -0.2, 0.41666666666667
38335, 1.4916666666667, -0.2, 0.39583333333333
38336, 1.4708333333333, -0.2, 0.41666666666667
38337, 1.5333333333333, -0.2, 0.39583333333333
38338, 1.5125, -0.2, 0.41666666666667
38339, 1.575, -0.2, 0.39583333333333
38340, 1.5541666666667, -0.2, 0.41666666666667
38341, 1.6166666666667, -0.2, 0.39583333333333
38342, 1.5958333333333, -0.2, 0.41666666666667
38343, 1.6583333333333, -0.2, 0.39583333333333
38344, 1.6375, -0.2, 0.41666666666667
38345, 1.7, -0.2, 0.39583333333333
38346, 1.6791666666667, -0.2, 0.41666666666667
38347, 1.7416666666667, -0.2, 0.39583333333333
38348, 1.7208333333333, -0.2, 0.41666666666667
38349, 1.7833333333333, -0.2, 0.39583333333333
38350, 1.7625, -0.2, 0.41666666666667
38351, 1.825, -0.2, 0.39583333333333
38352, 1.8041666666667, -0.2, 0.41666666666667
38353, 1.8666666666667, -0.2, 0.39583333333333
38354, 1.8458333333333, -0.2, 0.41666666666667
38355, 1.9083333333333, -0.2, 0.39583333333333
38356, 1.8875, -0.2, 0.41666666666667
38357, 1.95, -0.2, 0.39583333333333
38358, 1.9291666666667, -0.2, 0.41666666666667
38359, 1.9916666666667, -0.2, 0.39583333333333
38360, 1.9708333333333, -0.2, 0.41666666666667
38361, 2.0333333333333, -0.2, 0.39583333333333
38362, 2.0125, -0.2, 0.41666666666667
38363, 2.075, -0.2, 0.39583333333333
38364, 2.0541666666667, -0.2, 0.41666666666667
38365, 2.1166666666667, -0.2, 0.39583333333333
38366, 2.0958333333333, -0.2, 0.41666666666667
38367, 2.1583333333333, -0.2, 0.39583333333333
38368, 2.1375, -0.2, 0.41666666666667
38369, 2.1791666666667, -0.2, 0.41666666666667
38370, 1.2416666666667, -0.2, 0.4375
38371, 1.2208333333333, -0.2, 0.45833333333333
38372, 1.2833333333333, -0.2, 0.4375
38373, 1.2625, -0.2, 0.45833333333333
38374, 1.325, -0.2, 0.4375
38375, 1.3041666666667, -0.2, 0.45833333333333
38376, 1.3666666666667, -0.2, 0.4375
38377, 1.3458333333333, -0.2, 0.45833333333333
38378, 1.4083333333333, -0.2, 0.4375
38379, 1.3875, -0.2, 0.45833333333333
38380, 1.45, -0.2, 0.4375
38381, 1.4291666666667, -0.2, 0.45833333333333
38382, 1.4916666666667, -0.2, 0.4375
38383, 1.4708333333333, -0.2, 0.45833333333333
38384, 1.5333333333333, -0.2, 0.4375
38385, 1.5125, -0.2, 0.45833333333333
38386, 1.575, -0.2, 0.4375
38387, 1.5541666666667, -0.2, 0.45833333333333
38388, 1.6166666666667, -0.2, 0.4375
38389, 1.5958333333333, -0.2, 0.45833333333333
38390, 1.6583333333333, -0.2, 0.4375
38391, 1.6375, -0.2, 0.45833333333333
38392, 1.7, -0.2, 0.4375
38393, 1.6791666666667, -0.2, 0.45833333333333
38394, 1.7416666666667, -0.2, 0.4375
38395, 1.7208333333333, -0.2, 0.45833333333333
38396, 1.7833333333333, -0.2, 0.4375
38397, 1.7625, -0.2, 0.45833333333333
38398, 1.825, -0.2, 0.4375
38399, 1.8041666666667, -0.2, 0.45833333333333
38400, 1.8666666666667, -0.2, 0.4375
38401, 1.8458333333333, -0.2, 0.45833333333333
38402, 1.9083333333333, -0.2, 0.4375
38403, 1.8875, -0.2, 0.45833333333333
38404, 1.95, -0.2, 0.4375
38405, 1.9291666666667, -0.2, 0.45833333333333
38406, 1.9916666666667, -0.2, 0.4375
38407, 1.9708333333333, -0.2, 0.45833333333333
38408, 2.0333333333333, -0.2, 0.4375
38409, 2.0125, -0.2, 0.45833333333333
38410, 2.075, -0.2, 0.4375
38411, 2.0541666666667, -0.2, 0.45833333333333
38412, 2.1166666666667, -0.2, 0.4375
38413, 2.0958333333333, -0.2, 0.45833333333333
38414, 2.1583333333333, -0.2, 0.4375
38415, 2.1375, -0.2, 0.45833333333333
38416, 2.1791666666667, -0.2, 0.45833333333333
38417, 1.2416666666667, -0.2, 0.47916666666667
38418, 1.2833333333333, -0.2, 0.47916666666667
38419, 1.325, -0.2, 0.47916666666667
38420, 1.3666666666667, -0.2, 0.47916666666667
38421, 1.4083333333333, -0.2, 0.47916666666667
38422, 1.45, -0.2, 0.47916666666667
38423, 1.4916666666667, -0.2, 0.47916666666667
38424, 1.5333333333333, -0.2, 0.47916666666667
38425, 1.575, -0.2, 0.47916666666667
38426, 1.6166666666667, -0.2, 0.47916666666667
38427, 1.6583333333333, -0.2, 0.47916666666667
38428, 1.7, -0.2, 0.47916666666667
38429, 1.7416666666667, -0.2, 0.47916666666667
38430, 1.7833333333333, -0.2, 0.47916666666667
38431, 1.825, -0.2, 0.47916666666667
38432, 1.8666666666667, -0.2, 0.47916666666667
38433, 1.9083333333333, -0.2, 0.47916666666667
38434, 1.95, -0.2, 0.47916666666667
38435, 1.9916666666667, -0.2, 0.47916666666667
38436, 2.0333333333333, -0.2, 0.47916666666667
38437, 2.075, -0.2, 0.47916666666667
38438, 2.1166666666667, -0.2, 0.47916666666667
38439, 2.1583333333333, -0.2, 0.47916666666667
38440, 2.25, -0.04, 0.5
38441, 2.25, -0.08, 0.5
38442, 2.25, -0.12, 0.5
38443, 2.25, -0.16, 0.5
38444, 2.25, -0.04, 0
38445, 2.25, -0.08, 0
38446, 2.25, -0.12, 0
38447, 2.25, -0.16, 0
38448, 2.3, -0.04, 0.041666666666667
38449, 2.3, -0.08, 0.041666666666667
38450, 2.3, -0.12, 0.041666666666667
38451, 2.3, -0.16, 0.041666666666667
38452, 2.3, -0.04, 0.083333333333333
38453, 2.3, -0.08, 0.083333333333333
38454, 2.3, -0.12, 0.083333333333333
38455, 2.3, -0.16, 0.083333333333333
38456, 2.3, -0.04, 0.125
38457, 2.3, -0.08, 0.125
38458, 2.3, -0.12, 0.125
38459, 2.3, -0.16, 0.125
38460, 2.3, -0.04, 0.16666666666667
38461, 2.3, -0.08, 0.16666666666667
38462, 2.3, -0.12, 0.16666666666667
38463, 2.3, -0.16, 0.16666666666667
38464, 2.3, -0.04, 0.20833333333333
38465, 2.3, -0.08, 0.20833333333333
38466, 2.3, -0.12, 0.20833333333333
38467, 2.3, -0.16, 0.20833333333333
38468, 2.3, -0.04, 0.25
38469, 2.3, -0.08, 0.25
38470, 2.3, -0.12, 0.25
38471, 2.3, -0.16, 0.25
38472, 2.3, -0.04, 0.29166666666667
38473, 2.3, -0.08, 0.29166666666667
38474, 2.3, -0.12, 0.29166666666667
38475, 2.3, -0.16, 0.29166666666667
38476, 2.3, -0.04, 0.33333333333333
38477, 2.3, -0.08, 0.33333333333333
38478, 2.3, -0.12, 0.33333333333333
38479, 2.3, -0.16, 0.33333333333333
38480, 2.3, -0.04, 0.375
38481, 2.3, -0.08, 0.375
38482, 2.3, -0.12, 0.375
38483, 2.3, -0.16, 0.375
38484, 2.3, -0.04, 0.41666666666667
38485, 2.3, -0.08, 0.41666666666667
38486, 2.3, -0.12, 0.41666666666667
38487, 2.3, -0.16, 0.41666666666667
38488, 2.3, -0.04, 0.45833333333333
38489, 2.3, -0.08, 0.45833333333333
38490, 2.3, -0.12, 0.45833333333333
38491, 2.3, -0.16, 0.45833333333333
38492, 2.3, -0.02, 0.041666666666667
38493, 2.3, -0.04, 0.020833333333333
38494, 2.3, -0.06, 0.041666666666667
38495, 2.3, -0.08, 0.020833333333333
38496, 2.3, -0.1, 0.041666666666667
38497, 2.3, -0.12, 0.020833333333333
38498, 2.3, -0.14, 0.041666666666667
38499, 2.3, -0.16, 0.020833333333333
38500, 2.3, -0.18, 0.041666666666667
38501, 2.3, -0.02, 0.083333333333333
38502, 2.3, -0.04, 0.0625
38503, 2.3, -0.06, 0.083333333333333
38504, 2.3, -0.08, 0.0625
38505, 2.3, -0.1, 0.083333333333333
38506, 2.3, -0.12, 0.0625
38507, 2.3, -0.14, 0.083333333333333
38508, 2.3, -0.16, 0.0625
38509, 2.3, -0.18, 0.083333333333333
38510, 2.3, -0.02, 0.125
38511, 2.3, -0.04, 0.10416666666667
38512, 2.3, -0.06, 0.125
38513, 2.3, -0.08, 0.10416666666667
38514, 2.3, -0.1, 0.125
38515, 2.3, -0.12, 0.10416666666667
38516, 2.3, -0.14, 0.125
38517, 2.3, -0.16, 0.10416666666667
38518, 2.3, -0.18, 0.125
38519, 2.3, -0.02, 0.16666666666667
38520, 2.3, -0.04, 0.14583333333333
38521, 2.3, -0.06, 0.16666666666667
38522, 2.3, -0.08, 0.14583333333333
38523, 2.3, -0.1, 0.16666666666667
38524, 2.3, -0.12, 0.14583333333333
38525, 2.3, -0.14, 0.16666666666667
38526, 2.3, -0.16, 0.14583333333333
38527, 2.3, -0.18, 0.16666666666667
38528, 2.3, -0.02, 0.20833333333333
38529, 2.3, -0.04, 0.1875
38530, 2.3, -0.06, 0.20833333333333
38531, 2.3, -0.08, 0.1875
38532, 2.3, -0.1, 0.20833333333333
38533, 2.3, -0.12, 0.1875
38534, 2.3, -0.14, 0.20833333333333
38535, 2.3, -0.16, 0.1875
38536, 2.3, -0.18, 0.20833333333333
38537, 2.3, -0.02, 0.25
38538, 2.3, -0.04, 0.22916666666667
38539, 2.3, -0.06, 0.25
38540, 2.3, -0.08, 0.22916666666667
38541, 2.3, -0.1, 0.25
38542, 2.3, -0.12, 0.22916666666667
38543, 2.3, -0.14, 0.25
38544, 2.3, -0.16, 0.22916666666667
38545, 2.3, -0.18, 0.25
38546, 2.3, -0.02, 0.29166666666667
38547, 2.3, -0.04, 0.27083333333333
38548, 2.3, -0.06, 0.29166666666667
38549, 2.3, -0.08, 0.27083333333333
38550, 2.3, -0.1, 0.29166666666667
38551, 2.3, -0.12, 0.27083333333333
38552, 2.3, -0.14, 0.29166666666667
38553, 2.3, -0.16, 0.27083333333333
38554, 2.3, -0.18, 0.29166666666667
38555, 2.3, -0.02, 0.33333333333333
38556, 2.3, -0.04, 0.3125
38557, 2.3, -0.06, 0.33333333333333
38558, 2.3, -0.08, 0.3125
38559, 2.3, -0.1, 0.33333333333333
38560, 2.3, -0.12, 0.3125
38561, 2.3, -0.14, 0.33333333333333
38562, 2.3, -0.16, 0.3125
38563, 2.3, -0.18, 0.33333333333333
38564, 2.3, -0.02, 0.375
38565, 2.3, -0.04, 0.35416666666667
38566, 2.3, -0.06, 0.375
38567, 2.3, -0.08, 0.35416666666667
38568, 2.3, -0.1, 0.375
38569, 2.3, -0.12, 0.35416666666667
38570, 2.3, -0.14, 0.375
38571, 2.3, -0.16, 0.35416666666667
38572, 2.3, -0.18, 0.375
38573, 2.3, -0.02, 0.41666666666667
38574, 2.3, -0.04, 0.39583333333333
38575, 2.3, -0.06, 0.41666666666667
38576, 2.3, -0.08, 0.39583333333333
38577, 2.3, -0.1, 0.41666666666667
38578, 2.3, -0.12, 0.39583333333333
38579, 2.3, -0.14, 0.41666666666667
38580, 2.3, -0.16, 0.39583333333333
38581, 2.3, -0.18, 0.41666666666667
38582, 2.3, -0.02, 0.45833333333333
38583, 2.3, -0.04, 0.4375
38584, 2.3, -0.06, 0.45833333333333
38585, 2.3, -0.08, 0.4375
38586, 2.3, -0.1, 0.45833333333333
38587, 2.3, -0.12, 0.4375
38588, 2.3, -0.14, 0.45833333333333
38589, 2.3, -0.16, 0.4375
38590, 2.3, -0.18, 0.45833333333333
38591, 2.3, -0.04, 0.47916666666667
38592, 2.3, -0.08, 0.47916666666667
38593, 2.3, -0.12, 0.47916666666667
38594, 2.3, -0.16, 0.47916666666667
38595, 2.25, -0.2, 0.041666666666667
38596, 2.25, -0.2, 0.083333333333333
38597, 2.25, -0.2, 0.125
38598, 2.25, -0.2, 0.16666666666667
38599, 2.25, -0.2, 0.20833333333333
38600, 2.25, -0.2, 0.25
38601, 2.25, -0.2, 0.29166666666667
38602, 2.25, -0.2, 0.33333333333333
38603, 2.25, -0.2, 0.375
38604, 2.25, -0.2, 0.41666666666667
38605, 2.25, -0.2, 0.45833333333333
38606, 0.041666666666667, 0.033333333333333, 0.041666666666667
38607, 0.083333333333333, 0.033333333333333, 0.041666666666667
38608, 0.125, 0.033333333333333, 0.041666666666667
38609, 0.16666666666667, 0.033333333333333, 0.041666666666667
38610, 0.20833333333333, 0.033333333333333, 0.041666666666667
38611, 0.25, 0.033333333333333, 0.041666666666667
38612, 0.29166666666667, 0.033333333333333, 0.041666666666667
38613, 0.33333333333333, 0.033333333333333, 0.041666666666667
38614, 0.375, 0.033333333333333, 0.041666666666667
38615, 0.41666666666667, 0.033333333333333, 0.041666666666667
38616, 0.45833333333333, 0.033333333333333, 0.041666666666667
38617, 0.5, 0.033333333333333, 0.041666666666667
38618, 0.54166666666667, 0.033333333333333, 0.041666666666667
38619, 0.58333333333333, 0.033333333333333, 0.041666666666667
38620, 0.625, 0.033333333333333, 0.041666666666667
38621, 0.66666666666667, 0.033333333333333, 0.041666666666667
38622, 0.70833333333333, 0.033333333333333, 0.041666666666667
38623, 0.75, 0.033333333333333, 0.041666666666667
38624, 0.79166666666667, 0.033333333333333, 0.041666666666667
38625, 0.83333333333333, 0.033333333333333, 0.041666666666667
38626, 0.875, 0.033333333333333, 0.041666666666667
38627, 0.91666666666667, 0.033333333333333, 0.041666666666667
38628, 0.95833333333333, 0.033333333333333, 0.041666666666667
38629, 0.041666666666667, 0.066666666666667, 0.041666666666667
38630, 0.083333333333333, 0.066666666666667, 0.041666666666667
38631, 0.125, 0.066666666666667, 0.041666666666667
38632, 0.16666666666667, 0.066666666666667, 0.041666666666667
38633, 0.20833333333333, 0.066666666666667, 0.041666666666667
38634, 0.25, 0.066666666666667, 0.041666666666667
38635, 0.29166666666667, 0.066666666666667, 0.041666666666667
38636, 0.33333333333333, 0.066666666666667, 0.041666666666667
38637, 0.375, 0.066666666666667, 0.041666666666667
38638, 0.41666666666667, 0.066666666666667, 0.041666666666667
38639, 0.45833333333333, 0.066666666666667, 0.041666666666667
38640, 0.5, 0.066666666666667, 0.041666666666667
38641, 0.54166666666667, 0.066666666666667, 0.041666666666667
38642, 0.58333333333333, 0.066666666666667, 0.041666666666667
38643, 0.625, 0.066666666666667, 0.041666666666667
38644, 0.66666666666667, 0.066666666666667, 0.041666666666667
38645, 0.70833333333333, 0.066666666666667, 0.041666666666667
38646, 0.75, 0.066666666666667, 0.041666666666667
38647, 0.79166666666667, 0.066666666666667, 0.041666666666667
38648, 0.83333333333333, 0.066666666666667, 0.041666666666667
38649, 0.875, 0.066666666666667, 0.041666666666667
38650, 0.91666666666667, 0.066666666666667, 0.041666666666667
38651, 0.95833333333333, 0.066666666666667, 0.041666666666667
38652, 0.041666666666667, 0.033333333333333, 0.083333333333333
38653, 0.083333333333333, 0.033333333333333, 0.083333333333333
38654, 0.125, 0.033333333333333, 0.083333333333333
38655, 0.16666666666667, 0.033333333333333, 0.083333333333333
38656, 0.20833333333333, 0.033333333333333, 0.083333333333333
38657, 0.25, 0.033333333333333, 0.083333333333333
38658, 0.29166666666667, 0.033333333333333, 0.083333333333333
38659, 0.33333333333333, 0.033333333333333, 0.083333333333333
38660, 0.375, 0.033333333333333, 0.083333333333333
38661, 0.41666666666667, 0.033333333333333, 0.083333333333333
38662, 0.45833333333333, 0.033333333333333, 0.083333333333333
38663, 0.5, 0.033333333333333, 0.083333333333333
38664, 0.54166666666667, 0.033333333333333, 0.083333333333333
38665, 0.58333333333333, 0.033333333333333, 0.083333333333333
38666, 0.625, 0.033333333333333, 0.083333333333333
38667, 0.66666666666667, 0.033333333333333, 0.083333333333333
38668, 0.70833333333333, 0.033333333333333, 0.083333333333333
38669, 0.75, 0.033333333333333, 0.083333333333333
38670, 0.79166666666667, 0.033333333333333, 0.083333333333333
38671, 0.83333333333333, 0.033333333333333, 0.083333333333333
38672, 0.875, 0.033333333333333, 0.083333333333333
38673, 0.91666666666667, 0.033333333333333, 0.083333333333333
38674, 0.95833333333333, 0.033333333333333, 0.083333333333333
38675, 0.041666666666667, 0.066666666666667, 0.083333333333333
38676, 0.083333333333333, 0.066666666666667, 0.083333333333333
38677, 0.125, 0.066666666666667, 0.083333333333333
38678, 0.16666666666667, 0.066666666666667, 0.083333333333333
38679, 0.20833333333333, 0.066666666666667, 0.083333333333333
38680, 0.25, 0.066666666666667, 0.083333333333333
38681, 0.29166666666667, 0.066666666666667, 0.083333333333333
38682, 0.33333333333333, 0.066666666666667, 0.083333333333333
38683, 0.375, 0.066666666666667, 0.083333333333333
38684, 0.41666666666667, 0.066666666666667, 0.083333333333333
38685, 0.45833333333333, 0.066666666666667, 0.083333333333333
38686, 0.5, 0.066666666666667, 0.083333333333333
38687, 0.54166666666667, 0.066666666666667, 0.083333333333333
38688, 0.58333333333333, 0.066666666666667, 0.083333333333333
38689, 0.625, 0.066666666666667, 0.083333333333333
38690, 0.66666666666667, 0.066666666666667, 0.083333333333333
38691, 0.70833333333333, 0.066666666666667, 0.083333333333333
38692, 0.75, 0.066666666666667, 0.083333333333333
38693, 0.79166666666667, 0.066666666666667, 0.083333333333333
38694, 0.83333333333333, 0.066666666666667, 0.083333333333333
38695, 0.875, 0.066666666666667, 0.083333333333333
38696, 0.91666666666667, 0.066666666666667, 0.083333333333333
38697, 0.95833333333333, 0.066666666666667, 0.083333333333333
38698, 0.041666666666667, 0.033333333333333, 0.125
38699, 0.083333333333333, 0.033333333333333, 0.125
38700, 0.125, 0.033333333333333, 0.125
38701, 0.16666666666667, 0.033333333333333, 0.125
38702, 0.20833333333333, 0.033333333333333, 0.125
38703, 0.25, 0.033333333333333, 0.125
38704, 0.29166666666667, 0.033333333333333, 0.125
38705, 0.33333333333333, 0.033333333333333, 0.125
38706, 0.375, 0.033333333333333, 0.125
38707, 0.41666666666667, 0.033333333333333, 0.125
38708, 0.45833333333333, 0.033333333333333, 0.125
38709, 0.5, 0.033333333333333, 0.125
38710, 0.54166666666667, 0.033333333333333, 0.125
38711, 0.58333333333333, 0.033333333333333, 0.125
38712, 0.625, 0.033333333333333, 0.125
38713, 0.66666666666667, 0.033333333333333, 0.125
38714, 0.70833333333333, 0.033333333333333, 0.125
38715, 0.75, 0.033333333333333, 0.125
38716, 0.79166666666667, 0.033333333333333, 0.125
38717, 0.83333333333333, 0.033333333333333, 0.125
38718, 0.875, 0.033333333333333, 0.125
38719, 0.91666666666667, 0.033333333333333, 0.125
38720, 0.95833333333333, 0.033333333333333, 0.125
38721, 0.041666666666667, 0.066666666666667, 0.125
38722, 0.083333333333333, 0.066666666666667, 0.125
38723, 0.125, 0.066666666666667, 0.125
38724, 0.16666666666667, 0.066666666666667, 0.125
38725, 0.20833333333333, 0.066666666666667, 0.125
38726, 0.25, 0.066666666666667, 0.125
38727, 0.29166666666667, 0.066666666666667, 0.125
38728, 0.33333333333333, 0.066666666666667, 0.125
38729, 0.375, 0.066666666666667, 0.125
38730, 0.41666666666667, 0.066666666666667, 0.125
38731, 0.45833333333333, 0.066666666666667, 0.125
38732, 0.5, 0.066666666666667, 0.125
38733, 0.54166666666667, 0.066666666666667, 0.125
38734, 0.58333333333333, 0.066666666666667, 0.125
38735, 0.625, 0.066666666666667, 0.125
38736, 0.66666666666667, 0.066666666666667, 0.125
38737, 0.70833333333333, 0.066666666666667, 0.125
38738, 0.75, 0.066666666666667, 0.125
38739, 0.79166666666667, 0.066666666666667, 0.125
38740, 0.83333333333333, 0.066666666666667, 0.125
38741, 0.875, 0.066666666666667, 0.125
38742, 0.91666666666667, 0.066666666666667, 0.125
38743, 0.95833333333333, 0.066666666666667, 0.125
38744, 0.041666666666667, 0.033333333333333, 0.16666666666667
38745, 0.083333333333333, 0.033333333333333, 0.16666666666667
38746, 0.125, 0.033333333333333, 0.16666666666667
38747, 0.16666666666667, 0.033333333333333, 0.16666666666667
38748, 0.20833333333333, 0.033333333333333, 0.16666666666667
38749, 0.25, 0.033333333333333, 0.16666666666667
38750, 0.29166666666667, 0.033333333333333, 0.16666666666667
38751, 0.33333333333333, 0.033333333333333, 0.16666666666667
38752, 0.375, 0.033333333333333, 0.16666666666667
38753, 0.41666666666667, 0.033333333333333, 0.16666666666667
38754, 0.45833333333333, 0.033333333333333, 0.16666666666667
38755, 0.5, 0.033333333333333, 0.16666666666667
38756, 0.54166666666667, 0.033333333333333, 0.16666666666667
38757, 0.58333333333333, 0.033333333333333, 0.16666666666667
38758, 0.625, 0.033333333333333, 0.16666666666667
38759, 0.66666666666667, 0.033333333333333, 0.16666666666667
38760, 0.70833333333333, 0.033333333333333, 0.16666666666667
38761, 0.75, 0.033333333333333, 0.16666666666667
38762, 0.79166666666667, 0.033333333333333, 0.16666666666667
38763, 0.83333333333333, 0.033333333333333, 0.16666666666667
38764, 0.875, 0.033333333333333, 0.16666666666667
38765, 0.91666666666667, 0.033333333333333, 0.16666666666667
38766, 0.95833333333333, 0.033333333333333, 0.16666666666667
38767, 0.041666666666667, 0.066666666666667, 0.16666666666667
38768, 0.083333333333333, 0.066666666666667, 0.16666666666667
38769, 0.125, 0.066666666666667, 0.16666666666667
38770, 0.16666666666667, 0.066666666666667, 0.16666666666667
38771, 0.20833333333333, 0.066666666666667, 0.16666666666667
38772, 0.25, 0.066666666666667, 0.16666666666667
38773, 0.29166666666667, 0.066666666666667, 0.16666666666667
38774, 0.33333333333333, 0.066666666666667, 0.16666666666667
38775, 0.375, 0.066666666666667, 0.16666666666667
38776, 0.41666666666667, 0.066666666666667, 0.16666666666667
38777, 0.45833333333333, 0.066666666666667, 0.16666666666667
38778, 0.5, 0.066666666666667, 0.16666666666667
38779, 0.54166666666667, 0.066666666666667, 0.16666666666667
38780, 0.58333333333333, 0.066666666666667, 0.16666666666667
38781, 0.625, 0.066666666666667, 0.16666666666667
38782, 0.66666666666667, 0.066666666666667, 0.16666666666667
38783, 0.70833333333333, 0.066666666666667, 0.16666666666667
38784, 0.75, 0.066666666666667, 0.16666666666667
38785, 0.79166666666667, 0.066666666666667, 0.16666666666667
38786, 0.83333333333333, 0.066666666666667, 0.16666666666667
38787, 0.875, 0.066666666666667, 0.16666666666667
38788, 0.91666666666667, 0.066666666666667, 0.16666666666667
38789, 0.95833333333333, 0.066666666666667, 0.16666666666667
38790, 0.041666666666667, 0.033333333333333, 0.20833333333333
38791, 0.083333333333333, 0.033333333333333, 0.20833333333333
38792, 0.125, 0.033333333333333, 0.20833333333333
38793, 0.16666666666667, 0.033333333333333, 0.20833333333333
38794, 0.20833333333333, 0.033333333333333, 0.20833333333333
38795, 0.25, 0.033333333333333, 0.20833333333333
38796, 0.29166666666667, 0.033333333333333, 0.20833333333333
38797, 0.33333333333333, 0.033333333333333, 0.20833333333333
38798, 0.375, 0.033333333333333, 0.20833333333333
38799, 0.41666666666667, 0.033333333333333, 0.20833333333333
38800, 0.45833333333333, 0.033333333333333, 0.20833333333333
38801, 0.5, 0.033333333333333, 0.20833333333333
38802, 0.54166666666667, 0.033333333333333, 0.20833333333333
38803, 0.58333333333333, 0.033333333333333, 0.20833333333333
38804, 0.625, 0.033333333333333, 0.20833333333333
38805, 0.66666666666667, 0.033333333333333, 0.20833333333333
38806, 0.70833333333333, 0.033333333333333, 0.20833333333333
38807, 0.75, 0.033333333333333, 0.20833333333333
38808, 0.79166666666667, 0.033333333333333, 0.20833333333333
38809, 0.83333333333333, 0.033333333333333, 0.20833333333333
38810, 0.875, 0.033333333333333, 0.20833333333333
38811, 0.91666666666667, 0.033333333333333, 0.20833333333333
38812, 0.95833333333333, 0.033333333333333, 0.20833333333333
38813, 0.041666666666667, 0.066666666666667, 0.20833333333333
38814, 0.083333333333333, 0.066666666666667, 0.20833333333333
38815, 0.125, 0.066666666666667, 0.20833333333333
38816, 0.16666666666667, 0.066666666666667, 0.20833333333333
38817, 0.20833333333333, 0.066666666666667, 0.20833333333333
38818, 0.25, 0.066666666666667, 0.20833333333333
38819, 0.29166666666667, 0.066666666666667, 0.20833333333333
38820, 0.33333333333333, 0.066666666666667, 0.20833333333333
38821, 0.375, 0.066666666666667, 0.20833333333333
38822, 0.41666666666667, 0.066666666666667, 0.20833333333333
38823, 0.45833333333333, 0.066666666666667, 0.20833333333333
38824, 0.5, 0.066666666666667, 0.20833333333333
38825, 0.54166666666667, 0.066666666666667, 0.20833333333333
38826, 0.58333333333333, 0.066666666666667, 0.20833333333333
38827, 0.625, 0.066666666666667, 0.20833333333333
38828, 0.66666666666667, 0.066666666666667, 0.20833333333333
38829, 0.70833333333333, 0.066666666666667, 0.20833333333333
38830, 0.75, 0.066666666666667, 0.20833333333333
38831, 0.79166666666667, 0.066666666666667, 0.20833333333333
38832, 0.83333333333333, 0.066666666666667, 0.20833333333333
38833, 0.875, 0.066666666666667, 0.20833333333333
38834, 0.91666666666667, 0.066666666666667, 0.20833333333333
38835, 0.95833333333333, 0.066666666666667, 0.20833333333333
38836, 0.041666666666667, 0.033333333333333, 0.25
38837, 0.083333333333333, 0.033333333333333, 0.25
38838, 0.125, 0.033333333333333, 0.25
38839, 0.16666666666667, 0.033333333333333, 0.25
38840, 0.20833333333333, 0.033333333333333, 0.25
38841, 0.25, 0.033333333333333, 0.25
38842, 0.29166666666667, 0.033333333333333, 0.25
38843, 0.33333333333333, 0.033333333333333, 0.25
38844, 0.375, 0.033333333333333, 0.25
38845, 0.41666666666667, 0.033333333333333, 0.25
38846, 0.45833333333333, 0.033333333333333, 0.25
38847, 0.5, 0.033333333333333, 0.25
38848, 0.54166666666667, 0.033333333333333, 0.25
38849, 0.58333333333333, 0.033333333333333, 0.25
38850, 0.625, 0.033333333333333, 0.25
38851, 0.66666666666667, 0.033333333333333, 0.25
38852, 0.70833333333333, 0.033333333333333, 0.25
38853, 0.75, 0.033333333333333, 0.25
38854, 0.79166666666667, 0.033333333333333, 0.25
38855, 0.83333333333333, 0.033333333333333, 0.25
38856, 0.875, 0.033333333333333, 0.25
38857, 0.91666666666667, 0.033333333333333, 0.25
38858, 0.95833333333333, 0.033333333333333, 0.25
38859, 0.041666666666667, 0.066666666666667, 0.25
38860, 0.083333333333333, 0.066666666666667, 0.25
38861, 0.125, 0.066666666666667, 0.25
38862, 0.16666666666667, 0.066666666666667, 0.25
38863, 0.20833333333333, 0.066666666666667, 0.25
38864, 0.25, 0.066666666666667, 0.25
38865, 0.29166666666667, 0.066666666666667, 0.25
38866, 0.33333333333333, 0.066666666666667, 0.25
38867, 0.375, 0.066666666666667, 0.25
38868, 0.41666666666667, 0.066666666666667, 0.25
38869, 0.45833333333333, 0.066666666666667, 0.25
38870, 0.5, 0.066666666666667, 0.25
38871, 0.54166666666667, 0.066666666666667, 0.25
38872, 0.58333333333333, 0.066666666666667, 0.25
38873, 0.625, 0.066666666666667, 0.25
38874, 0.66666666666667, 0.066666666666667, 0.25
38875, 0.70833333333333, 0.066666666666667, 0.25
38876, 0.75, 0.066666666666667, 0.25
38877, 0.79166666666667, 0.066666666666667, 0.25
38878, 0.83333333333333, 0.066666666666667, 0.25
38879, 0.875, 0.066666666666667, 0.25
38880, 0.91666666666667, 0.066666666666667, 0.25
38881, 0.95833333333333, 0.066666666666667, 0.25
38882, 0.041666666666667, 0.033333333333333, 0.29166666666667
38883, 0.083333333333333, 0.033333333333333, 0.29166666666667
38884, 0.125, 0.033333333333333, 0.29166666666667
38885, 0.16666666666667, 0.033333333333333, 0.29166666666667
38886, 0.20833333333333, 0.033333333333333, 0.29166666666667
38887, 0.25, 0.033333333333333, 0.29166666666667
38888, 0.29166666666667, 0.033333333333333, 0.29166666666667
38889, 0.33333333333333, 0.033333333333333, 0.29166666666667
38890, 0.375, 0.033333333333333, 0.29166666666667
38891, 0.41666666666667, 0.033333333333333, 0.29166666666667
38892, 0.45833333333333, 0.033333333333333, 0.29166666666667
38893, 0.5, 0.033333333333333, 0.29166666666667
38894, 0.54166666666667, 0.033333333333333, 0.29166666666667
38895, 0.58333333333333, 0.033333333333333, 0.29166666666667
38896, 0.625, 0.033333333333333, 0.29166666666667
38897, 0.66666666666667, 0.033333333333333, 0.29166666666667
38898, 0.70833333333333, 0.033333333333333, 0.29166666666667
38899, 0.75, 0.033333333333333, 0.29166666666667
38900, 0.79166666666667, 0.033333333333333, 0.29166666666667
38901, 0.83333333333333, 0.033333333333333, 0.29166666666667
38902, 0.875, 0.033333333333333, 0.29166666666667
38903, 0.91666666666667, 0.033333333333333, 0.29166666666667
38904, 0.95833333333333, 0.033333333333333, 0.29166666666667
38905, 0.041666666666667, 0.066666666666667, 0.29166666666667
38906, 0.083333333333333, 0.066666666666667, 0.29166666666667
38907, 0.125, 0.066666666666667, 0.29166666666667
38908, 0.16666666666667, 0.066666666666667, 0.29166666666667
38909, 0.20833333333333, 0.066666666666667, 0.29166666666667
38910, 0.25, 0.066666666666667, 0.29166666666667
38911, 0.29166666666667, 0.066666666666667, 0.29166666666667
38912, 0.33333333333333, 0.066666666666667, 0.29166666666667
38913, 0.375, 0.066666666666667, 0.29166666666667
38914, 0.41666666666667, 0.066666666666667, 0.29166666666667
38915, 0.45833333333333, 0.066666666666667, 0.29166666666667
38916, 0.5, 0.066666666666667, 0.29166666666667
38917, 0.54166666666667, 0.066666666666667, 0.29166666666667
38918, 0.58333333333333, 0.066666666666667, 0.29166666666667
38919, 0.625, 0.066666666666667, 0.29166666666667
38920, 0.66666666666667, 0.066666666666667, 0.29166666666667
38921, 0.70833333333333, 0.066666666666667, 0.29166666666667
38922, 0.75, 0.066666666666667, 0.29166666666667
38923, 0.79166666666667, 0.066666666666667, 0.29166666666667
38924, 0.83333333333333, 0.066666666666667, 0.29166666666667
38925, 0.875, 0.066666666666667, 0.29166666666667
38926, 0.91666666666667, 0.066666666666667, 0.29166666666667
38927, 0.95833333333333, 0.066666666666667, 0.29166666666667
38928, 0.041666666666667, 0.033333333333333, 0.33333333333333
38929, 0.083333333333333, 0.033333333333333, 0.33333333333333
38930, 0.125, 0.033333333333333, 0.33333333333333
38931, 0.16666666666667, 0.033333333333333, 0.33333333333333
38932, 0.20833333333333, 0.033333333333333, 0.33333333333333
38933, 0.25, 0.033333333333333, 0.33333333333333
38934, 0.29166666666667, 0.033333333333333, 0.33333333333333
38935, 0.33333333333333, 0.033333333333333, 0.33333333333333
38936, 0.375, 0.033333333333333, 0.33333333333333
38937, 0.41666666666667, 0.033333333333333, 0.33333333333333
38938, 0.45833333333333, 0.033333333333333, 0.33333333333333
38939, 0.5, 0.033333333333333, 0.33333333333333
38940, 0.54166666666667, 0.033333333333333, 0.33333333333333
38941, 0.58333333333333, 0.033333333333333, 0.33333333333333
38942, 0.625, 0.033333333333333, 0.33333333333333
38943, 0.66666666666667, 0.033333333333333, 0.33333333333333
38944, 0.70833333333333, 0.033333333333333, 0.33333333333333
38945, 0.75, 0.033333333333333, 0.33333333333333
38946, 0.79166666666667, 0.033333333333333, 0.33333333333333
38947, 0.83333333333333, 0.033333333333333, 0.33333333333333
38948, 0.875, 0.033333333333333, 0.33333333333333
38949, 0.91666666666667, 0.033333333333333, 0.33333333333333
38950, 0.95833333333333, 0.033333333333333, 0.33333333333333
38951, 0.041666666666667, 0.066666666666667, 0.33333333333333
38952, 0.083333333333333, 0.066666666666667, 0.33333333333333
38953, 0.125, 0.066666666666667, 0.33333333333333
38954, 0.16666666666667, 0.066666666666667, 0.33333333333333
38955, 0.20833333333333, 0.066666666666667, 0.33333333333333
38956, 0.25, 0.066666666666667, 0.33333333333333
38957, 0.29166666666667, 0.066666666666667, 0.33333333333333
38958, 0.33333333333333, 0.066666666666667, 0.33333333333333
38959, 0.375, 0.066666666666667, 0.33333333333333
38960, 0.41666666666667, 0.066666666666667, 0.33333333333333
38961, 0.45833333333333, 0.066666666666667, 0.33333333333333
38962, 0.5, 0.066666666666667, 0.33333333333333
38963, 0.54166666666667, 0.066666666666667, 0.33333333333333
38964, 0.58333333333333, 0.066666666666667, 0.33333333333333
38965, 0.625, 0.066666666666667, 0.33333333333333
38966, 0.66666666666667, 0.066666666666667, 0.33333333333333
38967, 0.70833333333333, 0.066666666666667, 0.33333333333333
38968, 0.75, 0.066666666666667, 0.33333333333333
38969, 0.79166666666667, 0.066666666666667, 0.33333333333333
38970, 0.83333333333333, 0.066666666666667, 0.33333333333333
38971, 0.875, 0.066666666666667, 0.33333333333333
38972, 0.91666666666667, 0.066666666666667, 0.33333333333333
38973, 0.95833333333333, 0.066666666666667, 0.33333333333333
38974, 0.041666666666667, 0.033333333333333, 0.375
38975, 0.083333333333333, 0.033333333333333, 0.375
38976, 0.125, 0.033333333333333, 0.375
38977, 0.16666666666667, 0.033333333333333, 0.375
38978, 0.20833333333333, 0.033333333333333, 0.375
38979, 0.25, 0.033333333333333, 0.375
38980, 0.29166666666667, 0.033333333333333, 0.375
38981, 0.33333333333333, 0.033333333333333, 0.375
38982, 0.375, 0.033333333333333, 0.375
38983, 0.41666666666667, 0.033333333333333, 0.375
38984, 0.45833333333333, 0.033333333333333, 0.375
38985, 0.5, 0.033333333333333, 0.375
38986, 0.54166666666667, 0.033333333333333, 0.375
38987, 0.58333333333333, 0.033333333333333, 0.375
38988, 0.625, 0.033333333333333, 0.375
38989, 0.66666666666667, 0.033333333333333, 0.375
38990, 0.70833333333333, 0.033333333333333, 0.375
38991, 0.75, 0.033333333333333, 0.375
38992, 0.79166666666667, 0.033333333333333, 0.375
38993, 0.83333333333333, 0.033333333333333, 0.375
38994, 0.875, 0.033333333333333, 0.375
38995, 0.91666666666667, 0.033333333333333, 0.375
38996, 0.95833333333333, 0.033333333333333, 0.375
38997, 0.041666666666667, 0.066666666666667, 0.375
38998, 0.083333333333333, 0.066666666666667, 0.375
38999, 0.125, 0.066666666666667, 0.375
39000, 0.16666666666667, 0.066666666666667, 0.375
39001, 0.20833333333333, 0.066666666666667, 0.375
39002, 0.25, 0.066666666666667, 0.375
39003, 0.29166666666667, 0.066666666666667, 0.375
39004, 0.33333333333333, 0.066666666666667, 0.375
39005, 0.375, 0.066666666666667, 0.375
39006, 0.41666666666667, 0.066666666666667, 0.375
39007, 0.45833333333333, 0.066666666666667, 0.375
39008, 0.5, 0.066666666666667, 0.375
39009, 0.54166666666667, 0.066666666666667, 0.375
39010, 0.58333333333333, 0.066666666666667, 0.375
39011, 0.625, 0.066666666666667, 0.375
39012, 0.66666666666667, 0.066666666666667, 0.375
39013, 0.70833333333333, 0.066666666666667, 0.375
39014, 0.75, 0.066666666666667, 0.375
39015, 0.79166666666667, 0.066666666666667, 0.375
39016, 0.83333333333333, 0.066666666666667, 0.375
39017, 0.875, 0.066666666666667, 0.375
39018, 0.91666666666667, 0.066666666666667, 0.375
39019, 0.95833333333333, 0.066666666666667, 0.375
39020, 0.041666666666667, 0.033333333333333, 0.41666666666667
39021, 0.083333333333333, 0.033333333333333, 0.41666666666667
39022, 0.125, 0.033333333333333, 0.41666666666667
39023, 0.16666666666667, 0.033333333333333, 0.41666666666667
39024, 0.20833333333333, 0.033333333333333, 0.41666666666667
39025, 0.25, 0.033333333333333, 0.41666666666667
39026, 0.29166666666667, 0.033333333333333, 0.41666666666667
39027, 0.33333333333333, 0.033333333333333, 0.41666666666667
39028, 0.375, 0.033333333333333, 0.41666666666667
39029, 0.41666666666667, 0.033333333333333, 0.41666666666667
39030, 0.45833333333333, 0.033333333333333, 0.41666666666667
39031, 0.5, 0.033333333333333, 0.41666666666667
39032, 0.54166666666667, 0.033333333333333, 0.41666666666667
39033, 0.58333333333333, 0.033333333333333, 0.41666666666667
39034, 0.625, 0.033333333333333, 0.41666666666667
39035, 0.66666666666667, 0.033333333333333, 0.41666666666667
39036, 0.70833333333333, 0.033333333333333, 0.41666666666667
39037, 0.75, 0.033333333333333, 0.41666666666667
39038, 0.79166666666667, 0.033333333333333, 0.41666666666667
39039, 0.83333333333333, 0.033333333333333, 0.41666666666667
39040, 0.875, 0.033333333333333, 0.41666666666667
39041, 0.91666666666667, 0.033333333333333, 0.41666666666667
39042, 0.95833333333333, 0.033333333333333, 0.41666666666667
39043, 0.041666666666667, 0.066666666666667, 0.41666666666667
39044, 0.083333333333333, 0.066666666666667, 0.41666666666667
39045, 0.125, 0.066666666666667, 0.41666666666667
39046, 0.16666666666667, 0.066666666666667, 0.41666666666667
39047, 0.20833333333333, 0.066666666666667, 0.41666666666667
39048, 0.25, 0.066666666666667, 0.41666666666667
39049, 0.29166666666667, 0.066666666666667, 0.41666666666667
39050, 0.33333333333333, 0.066666666666667, 0.41666666666667
39051, 0.375, 0.066666666666667, 0.41666666666667
39052, 0.41666666666667, 0.066666666666667, 0.41666666666667
39053, 0.45833333333333, 0.066666666666667, 0.41666666666667
39054, 0.5, 0.066666666666667, 0.41666666666667
39055, 0.54166666666667, 0.066666666666667, 0.41666666666667
39056, 0.58333333333333, 0.066666666666667, 0.41666666666667
39057, 0.625, 0.066666666666667, 0.41666666666667
39058, 0.66666666666667, 0.066666666666667, 0.41666666666667
39059, 0.70833333333333, 0.066666666666667, 0.41666666666667
39060, 0.75, 0.066666666666667, 0.41666666666667
39061, 0.79166666666667, 0.066666666666667, 0.41666666666667
39062, 0.83333333333333, 0.066666666666667, 0.41666666666667
39063, 0.875, 0.066666666666667, 0.41666666666667
39064, 0.91666666666667, 0.066666666666667, 0.41666666666667
39065, 0.95833333333333, 0.066666666666667, 0.41666666666667
39066, 0.041666666666667, 0.033333333333333, 0.45833333333333
39067, 0.083333333333333, 0.033333333333333, 0.45833333333333
39068, 0.125, 0.033333333333333, 0.45833333333333
39069, 0.16666666666667, 0.033333333333333, 0.45833333333333
39070, 0.20833333333333, 0.033333333333333, 0.45833333333333
39071, 0.25, 0.033333333333333, 0.45833333333333
39072, 0.29166666666667, 0.033333333333333, 0.45833333333333
39073, 0.33333333333333, 0.033333333333333, 0.45833333333333
39074, 0.375, 0.033333333333333, 0.45833333333333
39075, 0.41666666666667, 0.033333333333333, 0.45833333333333
39076, 0.45833333333333, 0.033333333333333, 0.45833333333333
39077, 0.5, 0.033333333333333, 0.45833333333333
39078, 0.54166666666667, 0.033333333333333, 0.45833333333333
39079, 0.58333333333333, 0.033333333333333, 0.45833333333333
39080, 0.625, 0.033333333333333, 0.45833333333333
39081, 0.66666666666667, 0.033333333333333, 0.45833333333333
39082, 0.70833333333333, 0.033333333333333, 0.45833333333333
39083, 0.75, 0.033333333333333, 0.45833333333333
39084, 0.79166666666667, 0.033333333333333, 0.45833333333333
39085, 0.83333333333333, 0.033333333333333, 0.45833333333333
39086, 0.875, 0.033333333333333, 0.45833333333333
39087, 0.91666666666667, 0.033333333333333, 0.45833333333333
39088, 0.95833333333333, 0.033333333333333, 0.45833333333333
39089, 0.041666666666667, 0.066666666666667, 0.45833333333333
39090, 0.083333333333333, 0.066666666666667, 0.45833333333333
39091, 0.125, 0.066666666666667, 0.45833333333333
39092, 0.16666666666667, 0.066666666666667, 0.45833333333333
39093, 0.20833333333333, 0.066666666666667, 0.45833333333333
39094, 0.25, 0.066666666666667, 0.45833333333333
39095, 0.29166666666667, 0.066666666666667, 0.45833333333333
39096, 0.33333333333333, 0.066666666666667, 0.45833333333333
39097, 0.375, 0.066666666666667, 0.45833333333333
39098, 0.41666666666667, 0.066666666666667, 0.45833333333333
39099, 0.45833333333333, 0.066666666666667, 0.45833333333333
39100, 0.5, 0.066666666666667, 0.45833333333333
39101, 0.54166666666667, 0.066666666666667, 0.45833333333333
39102, 0.58333333333333, 0.066666666666667, 0.45833333333333
39103, 0.625, 0.066666666666667, 0.45833333333333
39104, 0.66666666666667, 0.066666666666667, 0.45833333333333
39105, 0.70833333333333, 0.066666666666667, 0.45833333333333
39106, 0.75, 0.066666666666667, 0.45833333333333
39107, 0.79166666666667, 0.066666666666667, 0.45833333333333
39108, 0.83333333333333, 0.066666666666667, 0.45833333333333
39109, 0.875, 0.066666666666667, 0.45833333333333
39110, 0.91666666666667, 0.066666666666667, 0.45833333333333
39111, 0.95833333333333, 0.066666666666667, 0.45833333333333
39112, 0.020833333333333, 0.033333333333333, 0.041666666666667
39113, 0.041666666666667, 0.016666666666667, 0.041666666666667
39114, 0.041666666666667, 0.033333333333333, 0.020833333333333
39115, 0.0625, 0.033333333333333, 0.041666666666667
39116, 0.083333333333333, 0.016666666666667, 0.041666666666667
39117, 0.083333333333333, 0.033333333333333, 0.020833333333333
39118, 0.10416666666667, 0.033333333333333, 0.041666666666667
39119, 0.125, 0.016666666666667, 0.041666666666667
39120, 0.125, 0.033333333333333, 0.020833333333333
39121, 0.14583333333333, 0.033333333333333, 0.041666666666667
39122, 0.16666666666667, 0.016666666666667, 0.041666666666667
39123, 0.16666666666667, 0.033333333333333, 0.020833333333333
39124, 0.1875, 0.033333333333333, 0.041666666666667
39125, 0.20833333333333, 0.016666666666667, 0.041666666666667
39126, 0.20833333333333, 0.033333333333333, 0.020833333333333
39127, 0.22916666666667, 0.033333333333333, 0.041666666666667
39128, 0.25, 0.016666666666667, 0.041666666666667
39129, 0.25, 0.033333333333333, 0.020833333333333
39130, 0.27083333333333, 0.033333333333333, 0.041666666666667
39131, 0.29166666666667, 0.016666666666667, 0.041666666666667
39132, 0.29166666666667, 0.033333333333333, 0.020833333333333
39133, 0.3125, 0.033333333333333, 0.041666666666667
39134, 0.33333333333333, 0.016666666666667, 0.041666666666667
39135, 0.33333333333333, 0.033333333333333, 0.020833333333333
39136, 0.35416666666667, 0.033333333333333, 0.041666666666667
39137, 0.375, 0.016666666666667, 0.041666666666667
39138, 0.375, 0.033333333333333, 0.020833333333333
39139, 0.39583333333333, 0.033333333333333, 0.041666666666667
39140, 0.41666666666667, 0.016666666666667, 0.041666666666667
39141, 0.41666666666667, 0.033333333333333, 0.020833333333333
39142, 0.4375, 0.033333333333333, 0.041666666666667
39143, 0.45833333333333, 0.016666666666667, 0.041666666666667
39144, 0.45833333333333, 0.033333333333333, 0.020833333333333
39145, 0.47916666666667, 0.033333333333333, 0.041666666666667
39146, 0.5, 0.016666666666667, 0.041666666666667
39147, 0.5, 0.033333333333333, 0.020833333333333
39148, 0.52083333333333, 0.033333333333333, 0.041666666666667
39149, 0.54166666666667, 0.016666666666667, 0.041666666666667
39150, 0.54166666666667, 0.033333333333333, 0.020833333333333
39151, 0.5625, 0.033333333333333, 0.041666666666667
39152, 0.58333333333333, 0.016666666666667, 0.041666666666667
39153, 0.58333333333333, 0.033333333333333, 0.020833333333333
39154, 0.60416666666667, 0.033333333333333, 0.041666666666667
39155, 0.625, 0.016666666666667, 0.041666666666667
39156, 0.625, 0.033333333333333, 0.020833333333333
39157, 0.64583333333333, 0.033333333333333, 0.041666666666667
39158, 0.66666666666667, 0.016666666666667, 0.041666666666667
39159, 0.66666666666667, 0.033333333333333, 0.020833333333333
39160, 0.6875, 0.033333333333333, 0.041666666666667
39161, 0.70833333333333, 0.016666666666667, 0.041666666666667
39162, 0.70833333333333, 0.033333333333333, 0.020833333333333
39163, 0.72916666666667, 0.033333333333333, 0.041666666666667
39164, 0.75, 0.016666666666667, 0.041666666666667
39165, 0.75, 0.033333333333333, 0.020833333333333
39166, 0.77083333333333, 0.033333333333333, 0.041666666666667
39167, 0.79166666666667, 0.016666666666667, 0.041666666666667
39168, 0.79166666666667, 0.033333333333333, 0.020833333333333
39169, 0.8125, 0.033333333333333, 0.041666666666667
39170, 0.83333333333333, 0.016666666666667, 0.041666666666667
39171, 0.83333333333333, 0.033333333333333, 0.020833333333333
39172, 0.85416666666667, 0.033333333333333, 0.041666666666667
39173, 0.875, 0.016666666666667, 0.041666666666667
39174, 0.875, 0.033333333333333, 0.020833333333333
39175, 0.89583333333333, 0.033333333333333, 0.041666666666667
39176, 0.91666666666667, 0.016666666666667, 0.041666666666667
39177, 0.91666666666667, 0.033333333333333, 0.020833333333333
39178, 0.9375, 0.033333333333333, 0.041666666666667
39179, 0.95833333333333, 0.016666666666667, 0.041666666666667
39180, 0.95833333333333, 0.033333333333333, 0.020833333333333
39181, 0.97916666666667, 0.033333333333333, 0.041666666666667
39182, 0.020833333333333, 0.066666666666667, 0.041666666666667
39183, 0.041666666666667, 0.05, 0.041666666666667
39184, 0.041666666666667, 0.066666666666667, 0.020833333333333
39185, 0.0625, 0.066666666666667, 0.041666666666667
39186, 0.083333333333333, 0.05, 0.041666666666667
39187, 0.083333333333333, 0.066666666666667, 0.020833333333333
39188, 0.10416666666667, 0.066666666666667, 0.041666666666667
39189, 0.125, 0.05, 0.041666666666667
39190, 0.125, 0.066666666666667, 0.020833333333333
39191, 0.14583333333333, 0.066666666666667, 0.041666666666667
39192, 0.16666666666667, 0.05, 0.041666666666667
39193, 0.16666666666667, 0.066666666666667, 0.020833333333333
39194, 0.1875, 0.066666666666667, 0.041666666666667
39195, 0.20833333333333, 0.05, 0.041666666666667
39196, 0.20833333333333, 0.066666666666667, 0.020833333333333
39197, 0.22916666666667, 0.066666666666667, 0.041666666666667
39198, 0.25, 0.05, 0.041666666666667
39199, 0.25, 0.066666666666667, 0.020833333333333
39200, 0.27083333333333, 0.066666666666667, 0.041666666666667
39201, 0.29166666666667, 0.05, 0.041666666666667
39202, 0.29166666666667, 0.066666666666667, 0.020833333333333
39203, 0.3125, 0.066666666666667, 0.041666666666667
39204, 0.33333333333333, 0.05, 0.041666666666667
39205, 0.33333333333333, 0.066666666666667, 0.020833333333333
39206, 0.35416666666667, 0.066666666666667, 0.041666666666667
39207, 0.375, 0.05, 0.041666666666667
39208, 0.375, 0.066666666666667, 0.020833333333333
39209, 0.39583333333333, 0.066666666666667, 0.041666666666667
39210, 0.41666666666667, 0.05, 0.041666666666667
39211, 0.41666666666667, 0.066666666666667, 0.020833333333333
39212, 0.4375, 0.066666666666667, 0.041666666666667
39213, 0.45833333333333, 0.05, 0.041666666666667
39214, 0.45833333333333, 0.066666666666667, 0.020833333333333
39215, 0.47916666666667, 0.066666666666667, 0.041666666666667
39216, 0.5, 0.05, 0.041666666666667
39217, 0.5, 0.066666666666667, 0.020833333333333
39218, 0.52083333333333, 0.066666666666667, 0.041666666666667
39219, 0.54166666666667, 0.05, 0.041666666666667
39220, 0.54166666666667, 0.066666666666667, 0.020833333333333
39221, 0.5625, 0.066666666666667, 0.041666666666667
39222, 0.58333333333333, 0.05, 0.041666666666667
39223, 0.58333333333333, 0.066666666666667, 0.020833333333333
39224, 0.60416666666667, 0.066666666666667, 0.041666666666667
39225, 0.625, 0.05, 0.041666666666667
39226, 0.625, 0.066666666666667, 0.020833333333333
39227, 0.64583333333333, 0.066666666666667, 0.041666666666667
39228, 0.66666666666667, 0.05, 0.041666666666667
39229, 0.66666666666667, 0.066666666666667, 0.020833333333333
39230, 0.6875, 0.066666666666667, 0.041666666666667
39231, 0.70833333333333, 0.05, 0.041666666666667
39232, 0.70833333333333, 0.066666666666667, 0.020833333333333
39233, 0.72916666666667, 0.066666666666667, 0.041666666666667
39234, 0.75, 0.05, 0.041666666666667
39235, 0.75, 0.066666666666667, 0.020833333333333
39236, 0.77083333333333, 0.066666666666667, 0.041666666666667
39237, 0.79166666666667, 0.05, 0.041666666666667
39238, 0.79166666666667, 0.066666666666667, 0.020833333333333
39239, 0.8125, 0.066666666666667, 0.041666666666667
39240, 0.83333333333333, 0.05, 0.041666666666667
39241, 0.83333333333333, 0.066666666666667, 0.020833333333333
39242, 0.85416666666667, 0.066666666666667, 0.041666666666667
39243, 0.875, 0.05, 0.041666666666667
39244, 0.875, 0.066666666666667, 0.020833333333333
39245, 0.89583333333333, 0.066666666666667, 0.041666666666667
39246, 0.91666666666667, 0.05, 0.041666666666667
39247, 0.91666666666667, 0.066666666666667, 0.020833333333333
39248, 0.9375, 0.066666666666667, 0.041666666666667
39249, 0.95833333333333, 0.05, 0.041666666666667
39250, 0.95833333333333, 0.066666666666667, 0.020833333333333
39251, 0.97916666666667, 0.066666666666667, 0.041666666666667
39252, 0.041666666666667, 0.083333333333333, 0.041666666666667
39253, 0.083333333333333, 0.083333333333333, 0.041666666666667
39254, 0.125, 0.083333333333333, 0.041666666666667
39255, 0.16666666666667, 0.083333333333333, 0.041666666666667
39256, 0.20833333333333, 0.083333333333333, 0.041666666666667
39257, 0.25, 0.083333333333333, 0.041666666666667
39258, 0.29166666666667, 0.083333333333333, 0.041666666666667
39259, 0.33333333333333, 0.083333333333333, 0.041666666666667
39260, 0.375, 0.083333333333333, 0.041666666666667
39261, 0.41666666666667, 0.083333333333333, 0.041666666666667
39262, 0.45833333333333, 0.083333333333333, 0.041666666666667
39263, 0.5, 0.083333333333333, 0.041666666666667
39264, 0.54166666666667, 0.083333333333333, 0.041666666666667
39265, 0.58333333333333, 0.083333333333333, 0.041666666666667
39266, 0.625, 0.083333333333333, 0.041666666666667
39267, 0.66666666666667, 0.083333333333333, 0.041666666666667
39268, 0.70833333333333, 0.083333333333333, 0.041666666666667
39269, 0.75, 0.083333333333333, 0.041666666666667
39270, 0.79166666666667, 0.083333333333333, 0.041666666666667
39271, 0.83333333333333, 0.083333333333333, 0.041666666666667
39272, 0.875, 0.083333333333333, 0.041666666666667
39273, 0.91666666666667, 0.083333333333333, 0.041666666666667
39274, 0.95833333333333, 0.083333333333333, 0.041666666666667
39275, 0.020833333333333, 0.033333333333333, 0.083333333333333
39276, 0.041666666666667, 0.016666666666667, 0.083333333333333
39277, 0.041666666666667, 0.033333333333333, 0.0625
39278, 0.0625, 0.033333333333333, 0.083333333333333
39279, 0.083333333333333, 0.016666666666667, 0.083333333333333
39280, 0.083333333333333, 0.033333333333333, 0.0625
39281, 0.10416666666667, 0.033333333333333, 0.083333333333333
39282, 0.125, 0.016666666666667, 0.083333333333333
39283, 0.125, 0.033333333333333, 0.0625
39284, 0.14583333333333, 0.033333333333333, 0.083333333333333
39285, 0.16666666666667, 0.016666666666667, 0.083333333333333
39286, 0.16666666666667, 0.033333333333333, 0.0625
39287, 0.1875, 0.033333333333333, 0.083333333333333
39288, 0.20833333333333, 0.016666666666667, 0.083333333333333
39289, 0.20833333333333, 0.033333333333333, 0.0625
39290, 0.22916666666667, 0.033333333333333, 0.083333333333333
39291, 0.25, 0.016666666666667, 0.083333333333333
39292, 0.25, 0.033333333333333, 0.0625
39293, 0.27083333333333, 0.033333333333333, 0.083333333333333
39294, 0.29166666666667, 0.016666666666667, 0.083333333333333
39295, 0.29166666666667, 0.033333333333333, 0.0625
39296, 0.3125, 0.033333333333333, 0.083333333333333
39297, 0.33333333333333, 0.016666666666667, 0.083333333333333
39298, 0.33333333333333, 0.033333333333333, 0.0625
39299, 0.35416666666667, 0.033333333333333, 0.083333333333333
39300, 0.375, 0.016666666666667, 0.083333333333333
39301, 0.375, 0.033333333333333, 0.0625
39302, 0.39583333333333, 0.033333333333333, 0.083333333333333
39303, 0.41666666666667, 0.016666666666667, 0.083333333333333
39304, 0.41666666666667, 0.033333333333333, 0.0625
39305, 0.4375, 0.033333333333333, 0.083333333333333
39306, 0.45833333333333, 0.016666666666667, 0.083333333333333
39307, 0.45833333333333, 0.033333333333333, 0.0625
39308, 0.47916666666667, 0.033333333333333, 0.083333333333333
39309, 0.5, 0.016666666666667, 0.083333333333333
39310, 0.5, 0.033333333333333, 0.0625
39311, 0.52083333333333, 0.033333333333333, 0.083333333333333
39312, 0.54166666666667, 0.016666666666667, 0.083333333333333
39313, 0.54166666666667, 0.033333333333333, 0.0625
39314, 0.5625, 0.033333333333333, 0.083333333333333
39315, 0.58333333333333, 0.016666666666667, 0.083333333333333
39316, 0.58333333333333, 0.033333333333333, 0.0625
39317, 0.60416666666667, 0.033333333333333, 0.083333333333333
39318, 0.625, 0.016666666666667, 0.083333333333333
39319, 0.625, 0.033333333333333, 0.0625
39320, 0.64583333333333, 0.033333333333333, 0.083333333333333
39321, 0.66666666666667, 0.016666666666667, 0.083333333333333
39322, 0.66666666666667, 0.033333333333333, 0.0625
39323, 0.6875, 0.033333333333333, 0.083333333333333
39324, 0.70833333333333, 0.016666666666667, 0.083333333333333
39325, 0.70833333333333, 0.033333333333333, 0.0625
39326, 0.72916666666667, 0.033333333333333, 0.083333333333333
39327, 0.75, 0.016666666666667, 0.083333333333333
39328, 0.75, 0.033333333333333, 0.0625
39329, 0.77083333333333, 0.033333333333333, 0.083333333333333
39330, 0.79166666666667, 0.016666666666667, 0.083333333333333
39331, 0.79166666666667, 0.033333333333333, 0.0625
39332, 0.8125, 0.033333333333333, 0.083333333333333
39333, 0.83333333333333, 0.016666666666667, 0.083333333333333
39334, 0.83333333333333, 0.033333333333333, 0.0625
39335, 0.85416666666667, 0.033333333333333, 0.083333333333333
39336, 0.875, 0.016666666666667, 0.083333333333333
39337, 0.875, 0.033333333333333, 0.0625
39338, 0.89583333333333, 0.033333333333333, 0.083333333333333
39339, 0.91666666666667, 0.016666666666667, 0.083333333333333
39340, 0.91666666666667, 0.033333333333333, 0.0625
39341, 0.9375, 0.033333333333333, 0.083333333333333
39342, 0.95833333333333, 0.016666666666667, 0.083333333333333
39343, 0.95833333333333, 0.033333333333333, 0.0625
39344, 0.97916666666667, 0.033333333333333, 0.083333333333333
39345, 0.020833333333333, 0.066666666666667, 0.083333333333333
39346, 0.041666666666667, 0.05, 0.083333333333333
39347, 0.041666666666667, 0.066666666666667, 0.0625
39348, 0.0625, 0.066666666666667, 0.083333333333333
39349, 0.083333333333333, 0.05, 0.083333333333333
39350, 0.083333333333333, 0.066666666666667, 0.0625
39351, 0.10416666666667, 0.066666666666667, 0.083333333333333
39352, 0.125, 0.05, 0.083333333333333
39353, 0.125, 0.066666666666667, 0.0625
39354, 0.14583333333333, 0.066666666666667, 0.083333333333333
39355, 0.16666666666667, 0.05, 0.083333333333333
39356, 0.16666666666667, 0.066666666666667, 0.0625
39357, 0.1875, 0.066666666666667, 0.083333333333333
39358, 0.20833333333333, 0.05, 0.083333333333333
39359, 0.20833333333333, 0.066666666666667, 0.0625
39360, 0.22916666666667, 0.066666666666667, 0.083333333333333
39361, 0.25, 0.05, 0.083333333333333
39362, 0.25, 0.066666666666667, 0.0625
39363, 0.27083333333333, 0.066666666666667, 0.083333333333333
39364, 0.29166666666667, 0.05, 0.083333333333333
39365, 0.29166666666667, 0.066666666666667, 0.0625
39366, 0.3125, 0.066666666666667, 0.083333333333333
39367, 0.33333333333333, 0.05, 0.083333333333333
39368, 0.33333333333333, 0.066666666666667, 0.0625
39369, 0.35416666666667, 0.066666666666667, 0.083333333333333
39370, 0.375, 0.05, 0.083333333333333
39371, 0.375, 0.066666666666667, 0.0625
39372, 0.39583333333333, 0.066666666666667, 0.083333333333333
39373, 0.41666666666667, 0.05, 0.083333333333333
39374, 0.41666666666667, 0.066666666666667, 0.0625
39375, 0.4375, 0.066666666666667, 0.083333333333333
39376, 0.45833333333333, 0.05, 0.083333333333333
39377, 0.45833333333333, 0.066666666666667, 0.0625
39378, 0.47916666666667, 0.066666666666667, 0.083333333333333
39379, 0.5, 0.05, 0.083333333333333
39380, 0.5, 0.066666666666667, 0.0625
39381, 0.52083333333333, 0.066666666666667, 0.083333333333333
39382, 0.54166666666667, 0.05, 0.083333333333333
39383, 0.54166666666667, 0.066666666666667, 0.0625
39384, 0.5625, 0.066666666666667, 0.083333333333333
39385, 0.58333333333333, 0.05, 0.083333333333333
39386, 0.58333333333333, 0.066666666666667, 0.0625
39387, 0.60416666666667, 0.066666666666667, 0.083333333333333
39388, 0.625, 0.05, 0.083333333333333
39389, 0.625, 0.066666666666667, 0.0625
39390, 0.64583333333333, 0.066666666666667, 0.083333333333333
39391, 0.66666666666667, 0.05, 0.083333333333333
39392, 0.66666666666667, 0.066666666666667, 0.0625
39393, 0.6875, 0.066666666666667, 0.083333333333333
39394, 0.70833333333333, 0.05, 0.083333333333333
39395, 0.70833333333333, 0.066666666666667, 0.0625
39396, 0.72916666666667, 0.066666666666667, 0.083333333333333
39397, 0.75, 0.05, 0.083333333333333
39398, 0.75, 0.066666666666667, 0.0625
39399, 0.77083333333333, 0.066666666666667, 0.083333333333333
39400, 0.79166666666667, 0.05, 0.083333333333333
39401, 0.79166666666667, 0.066666666666667, 0.0625
39402, 0.8125, 0.066666666666667, 0.083333333333333
39403, 0.83333333333333, 0.05, 0.083333333333333
39404, 0.83333333333333, 0.066666666666667, 0.0625
39405, 0.85416666666667, 0.066666666666667, 0.083333333333333
39406, 0.875, 0.05, 0.083333333333333
39407, 0.875, 0.066666666666667, 0.0625
39408, 0.89583333333333, 0.066666666666667, 0.083333333333333
39409, 0.91666666666667, 0.05, 0.083333333333333
39410, 0.91666666666667, 0.066666666666667, 0.0625
39411, 0.9375, 0.066666666666667, 0.083333333333333
39412, 0.95833333333333, 0.05, 0.083333333333333
39413, 0.95833333333333, 0.066666666666667, 0.0625
39414, 0.97916666666667, 0.066666666666667, 0.083333333333333
39415, 0.041666666666667, 0.083333333333333, 0.083333333333333
39416, 0.083333333333333, 0.083333333333333, 0.083333333333333
39417, 0.125, 0.083333333333333, 0.083333333333333
39418, 0.16666666666667, 0.083333333333333, 0.083333333333333
39419, 0.20833333333333, 0.083333333333333, 0.083333333333333
39420, 0.25, 0.083333333333333, 0.083333333333333
39421, 0.29166666666667, 0.083333333333333, 0.083333333333333
39422, 0.33333333333333, 0.083333333333333, 0.083333333333333
39423, 0.375, 0.083333333333333, 0.083333333333333
39424, 0.41666666666667, 0.083333333333333, 0.083333333333333
39425, 0.45833333333333, 0.083333333333333, 0.083333333333333
39426, 0.5, 0.083333333333333, 0.083333333333333
39427, 0.54166666666667, 0.083333333333333, 0.083333333333333
39428, 0.58333333333333, 0.083333333333333, 0.083333333333333
39429, 0.625, 0.083333333333333, 0.083333333333333
39430, 0.66666666666667, 0.083333333333333, 0.083333333333333
39431, 0.70833333333333, 0.083333333333333, 0.083333333333333
39432, 0.75, 0.083333333333333, 0.083333333333333
39433, 0.79166666666667, 0.083333333333333, 0.083333333333333
39434, 0.83333333333333, 0.083333333333333, 0.083333333333333
39435, 0.875, 0.083333333333333, 0.083333333333333
39436, 0.91666666666667, 0.083333333333333, 0.083333333333333
39437, 0.95833333333333, 0.083333333333333, 0.083333333333333
39438, 0.020833333333333, 0.033333333333333, 0.125
39439, 0.041666666666667, 0.016666666666667, 0.125
39440, 0.041666666666667, 0.033333333333333, 0.10416666666667
39441, 0.0625, 0.033333333333333, 0.125
39442, 0.083333333333333, 0.016666666666667, 0.125
39443, 0.083333333333333, 0.033333333333333, 0.10416666666667
39444, 0.10416666666667, 0.033333333333333, 0.125
39445, 0.125, 0.016666666666667, 0.125
39446, 0.125, 0.033333333333333, 0.10416666666667
39447, 0.14583333333333, 0.033333333333333, 0.125
39448, 0.16666666666667, 0.016666666666667, 0.125
39449, 0.16666666666667, 0.033333333333333, 0.10416666666667
39450, 0.1875, 0.033333333333333, 0.125
39451, 0.20833333333333, 0.016666666666667, 0.125
39452, 0.20833333333333, 0.033333333333333, 0.10416666666667
39453, 0.22916666666667, 0.033333333333333, 0.125
39454, 0.25, 0.016666666666667, 0.125
39455, 0.25, 0.033333333333333, 0.10416666666667
39456, 0.27083333333333, 0.033333333333333, 0.125
39457, 0.29166666666667, 0.016666666666667, 0.125
39458, 0.29166666666667, 0.033333333333333, 0.10416666666667
39459, 0.3125, 0.033333333333333, 0.125
39460, 0.33333333333333, 0.016666666666667, 0.125
39461, 0.33333333333333, 0.033333333333333, 0.10416666666667
39462, 0.35416666666667, 0.033333333333333, 0.125
39463, 0.375, 0.016666666666667, 0.125
39464, 0.375, 0.033333333333333, 0.10416666666667
39465, 0.39583333333333, 0.033333333333333, 0.125
39466, 0.41666666666667, 0.016666666666667, 0.125
39467, 0.41666666666667, 0.033333333333333, 0.10416666666667
39468, 0.4375, 0.033333333333333, 0.125
39469, 0.45833333333333, 0.016666666666667, 0.125
39470, 0.45833333333333, 0.033333333333333, 0.10416666666667
39471, 0.47916666666667, 0.033333333333333, 0.125
39472, 0.5, 0.016666666666667, 0.125
39473, 0.5, 0.033333333333333, 0.10416666666667
39474, 0.52083333333333, 0.033333333333333, 0.125
39475, 0.54166666666667, 0.016666666666667, 0.125
39476, 0.54166666666667, 0.033333333333333, 0.10416666666667
39477, 0.5625, 0.033333333333333, 0.125
39478, 0.58333333333333, 0.016666666666667, 0.125
39479, 0.58333333333333, 0.033333333333333, 0.10416666666667
39480, 0.60416666666667, 0.033333333333333, 0.125
39481, 0.625, 0.016666666666667, 0.125
39482, 0.625, 0.033333333333333, 0.10416666666667
39483, 0.64583333333333, 0.033333333333333, 0.125
39484, 0.66666666666667, 0.016666666666667, 0.125
39485, 0.66666666666667, 0.033333333333333, 0.10416666666667
39486, 0.6875, 0.033333333333333, 0.125
39487, 0.70833333333333, 0.016666666666667, 0.125
39488, 0.70833333333333, 0.033333333333333, 0.10416666666667
39489, 0.72916666666667, 0.033333333333333, 0.125
39490, 0.75, 0.016666666666667, 0.125
39491, 0.75, 0.033333333333333, 0.10416666666667
39492, 0.77083333333333, 0.033333333333333, 0.125
39493, 0.79166666666667, 0.016666666666667, 0.125
39494, 0.79166666666667, 0.033333333333333, 0.10416666666667
39495, 0.8125, 0.033333333333333, 0.125
39496, 0.83333333333333, 0.016666666666667, 0.125
39497, 0.83333333333333, 0.033333333333333, 0.10416666666667
39498, 0.85416666666667, 0.033333333333333, 0.125
39499, 0.875, 0.016666666666667, 0.125
39500, 0.875, 0.033333333333333, 0.10416666666667
39501, 0.89583333333333, 0.033333333333333, 0.125
39502, 0.91666666666667, 0.016666666666667, 0.125
39503, 0.91666666666667, 0.033333333333333, 0.10416666666667
39504, 0.9375, 0.033333333333333, 0.125
39505, 0.95833333333333, 0.016666666666667, 0.125
39506, 0.95833333333333, 0.033333333333333, 0.10416666666667
39507, 0.97916666666667, 0.033333333333333, 0.125
39508, 0.020833333333333, 0.066666666666667, 0.125
39509, 0.041666666666667, 0.05, 0.125
39510, 0.041666666666667, 0.066666666666667, 0.10416666666667
39511, 0.0625, 0.066666666666667, 0.125
39512, 0.083333333333333, 0.05, 0.125
39513, 0.083333333333333, 0.066666666666667, 0.10416666666667
39514, 0.10416666666667, 0.066666666666667, 0.125
39515, 0.125, 0.05, 0.125
39516, 0.125, 0.066666666666667, 0.10416666666667
39517, 0.14583333333333, 0.066666666666667, 0.125
39518, 0.16666666666667, 0.05, 0.125
39519, 0.16666666666667, 0.066666666666667, 0.10416666666667
39520, 0.1875, 0.066666666666667, 0.125
39521, 0.20833333333333, 0.05, 0.125
39522, 0.20833333333333, 0.066666666666667, 0.10416666666667
39523, 0.22916666666667, 0.066666666666667, 0.125
39524, 0.25, 0.05, 0.125
39525, 0.25, 0.066666666666667, 0.10416666666667
39526, 0.27083333333333, 0.066666666666667, 0.125
39527, 0.29166666666667, 0.05, 0.125
39528, 0.29166666666667, 0.066666666666667, 0.10416666666667
39529, 0.3125, 0.066666666666667, 0.125
39530, 0.33333333333333, 0.05, 0.125
39531, 0.33333333333333, 0.066666666666667, 0.10416666666667
39532, 0.35416666666667, 0.066666666666667, 0.125
39533, 0.375, 0.05, 0.125
39534, 0.375, 0.066666666666667, 0.10416666666667
39535, 0.39583333333333, 0.066666666666667, 0.125
39536, 0.41666666666667, 0.05, 0.125
39537, 0.41666666666667, 0.066666666666667, 0.10416666666667
39538, 0.4375, 0.066666666666667, 0.125
39539, 0.45833333333333, 0.05, 0.125
39540, 0.45833333333333, 0.066666666666667, 0.10416666666667
39541, 0.47916666666667, 0.066666666666667, 0.125
39542, 0.5, 0.05, 0.125
39543, 0.5, 0.066666666666667, 0.10416666666667
39544, 0.52083333333333, 0.066666666666667, 0.125
39545, 0.54166666666667, 0.05, 0.125
39546, 0.54166666666667, 0.066666666666667, 0.10416666666667
39547, 0.5625, 0.066666666666667, 0.125
39548, 0.58333333333333, 0.05, 0.125
39549, 0.58333333333333, 0.066666666666667, 0.10416666666667
39550, 0.60416666666667, 0.066666666666667, 0.125
39551, 0.625, 0.05, 0.125
39552, 0.625, 0.066666666666667, 0.10416666666667
39553, 0.64583333333333, 0.066666666666667, 0.125
39554, 0.66666666666667, 0.05, 0.125
39555, 0.66666666666667, 0.066666666666667, 0.10416666666667
39556, 0.6875, 0.066666666666667, 0.125
39557, 0.70833333333333, 0.05, 0.125
39558, 0.70833333333333, 0.066666666666667, 0.10416666666667
39559, 0.72916666666667, 0.066666666666667, 0.125
39560, 0.75, 0.05, 0.125
39561, 0.75, 0.066666666666667, 0.10416666666667
39562, 0.77083333333333, 0.066666666666667, 0.125
39563, 0.79166666666667, 0.05, 0.125
39564, 0.79166666666667, 0.066666666666667, 0.10416666666667
39565, 0.8125, 0.066666666666667, 0.125
39566, 0.83333333333333, 0.05, 0.125
39567, 0.83333333333333, 0.066666666666667, 0.10416666666667
39568, 0.85416666666667, 0.066666666666667, 0.125
39569, 0.875, 0.05, 0.125
39570, 0.875, 0.066666666666667, 0.10416666666667
39571, 0.89583333333333, 0.066666666666667, 0.125
39572, 0.91666666666667, 0.05, 0.125
39573, 0.91666666666667, 0.066666666666667, 0.10416666666667
39574, 0.9375, 0.066666666666667, 0.125
39575, 0.95833333333333, 0.05, 0.125
39576, 0.95833333333333, 0.066666666666667, 0.10416666666667
39577, 0.97916666666667, 0.066666666666667, 0.125
39578, 0.041666666666667, 0.083333333333333, 0.125
39579, 0.083333333333333, 0.083333333333333, 0.125
39580, 0.125, 0.083333333333333, 0.125
39581, 0.16666666666667, 0.083333333333333, 0.125
39582, 0.20833333333333, 0.083333333333333, 0.125
39583, 0.25, 0.083333333333333, 0.125
39584, 0.29166666666667, 0.083333333333333, 0.125
39585, 0.33333333333333, 0.083333333333333, 0.125
39586, 0.375, 0.083333333333333, 0.125
39587, 0.41666666666667, 0.083333333333333, 0.125
39588, 0.45833333333333, 0.083333333333333, 0.125
39589, 0.5, 0.083333333333333, 0.125
39590, 0.54166666666667, 0.083333333333333, 0.125
39591, 0.58333333333333, 0.083333333333333, 0.125
39592, 0.625, 0.083333333333333, 0.125
39593, 0.66666666666667, 0.083333333333333, 0.125
39594, 0.70833333333333, 0.083333333333333, 0.125
39595, 0.75, 0.083333333333333, 0.125
39596, 0.79166666666667, 0.083333333333333, 0.125
39597, 0.83333333333333, 0.083333333333333, 0.125
39598, 0.875, 0.083333333333333, 0.125
39599, 0.91666666666667, 0.083333333333333, 0.125
39600, 0.95833333333333, 0.083333333333333, 0.125
39601, 0.020833333333333, 0.033333333333333, 0.16666666666667
39602, 0.041666666666667, 0.016666666666667, 0.16666666666667
39603, 0.041666666666667, 0.033333333333333, 0.14583333333333
39604, 0.0625, 0.033333333333333, 0.16666666666667
39605, 0.083333333333333, 0.016666666666667, 0.16666666666667
39606, 0.083333333333333, 0.033333333333333, 0.14583333333333
39607, 0.10416666666667, 0.033333333333333, 0.16666666666667
39608, 0.125, 0.016666666666667, 0.16666666666667
39609, 0.125, 0.033333333333333, 0.14583333333333
39610, 0.14583333333333, 0.033333333333333, 0.16666666666667
39611, 0.16666666666667, 0.016666666666667, 0.16666666666667
39612, 0.16666666666667, 0.033333333333333, 0.14583333333333
39613, 0.1875, 0.033333333333333, 0.16666666666667
39614, 0.20833333333333, 0.016666666666667, 0.16666666666667
39615, 0.20833333333333, 0.033333333333333, 0.14583333333333
39616, 0.22916666666667, 0.033333333333333, 0.16666666666667
39617, 0.25, 0.016666666666667, 0.16666666666667
39618, 0.25, 0.033333333333333, 0.14583333333333
39619, 0.27083333333333, 0.033333333333333, 0.16666666666667
39620, 0.29166666666667, 0.016666666666667, 0.16666666666667
39621, 0.29166666666667, 0.033333333333333, 0.14583333333333
39622, 0.3125, 0.033333333333333, 0.16666666666667
39623, 0.33333333333333, 0.016666666666667, 0.16666666666667
39624, 0.33333333333333, 0.033333333333333, 0.14583333333333
39625, 0.35416666666667, 0.033333333333333, 0.16666666666667
39626, 0.375, 0.016666666666667, 0.16666666666667
39627, 0.375, 0.033333333333333, 0.14583333333333
39628, 0.39583333333333, 0.033333333333333, 0.16666666666667
39629, 0.41666666666667, 0.016666666666667, 0.16666666666667
39630, 0.41666666666667, 0.033333333333333, 0.14583333333333
39631, 0.4375, 0.033333333333333, 0.16666666666667
39632, 0.45833333333333, 0.016666666666667, 0.16666666666667
39633, 0.45833333333333, 0.033333333333333, 0.14583333333333
39634, 0.47916666666667, 0.033333333333333, 0.16666666666667
39635, 0.5, 0.016666666666667, 0.16666666666667
39636, 0.5, 0.033333333333333, 0.14583333333333
39637, 0.52083333333333, 0.033333333333333, 0.16666666666667
39638, 0.54166666666667, 0.016666666666667, 0.16666666666667
39639, 0.54166666666667, 0.033333333333333, 0.14583333333333
39640, 0.5625, 0.033333333333333, 0.16666666666667
39641, 0.58333333333333, 0.016666666666667, 0.16666666666667
39642, 0.58333333333333, 0.033333333333333, 0.14583333333333
39643, 0.60416666666667, 0.033333333333333, 0.16666666666667
39644, 0.625, 0.016666666666667, 0.16666666666667
39645, 0.625, 0.033333333333333, 0.14583333333333
39646, 0.64583333333333, 0.033333333333333, 0.16666666666667
39647, 0.66666666666667, 0.016666666666667, 0.16666666666667
39648, 0.66666666666667, 0.033333333333333, 0.14583333333333
39649, 0.6875, 0.033333333333333, 0.16666666666667
39650, 0.70833333333333, 0.016666666666667, 0.16666666666667
39651, 0.70833333333333, 0.033333333333333, 0.14583333333333
39652, 0.72916666666667, 0.033333333333333, 0.16666666666667
39653, 0.75, 0.016666666666667, 0.16666666666667
39654, 0.75, 0.033333333333333, 0.14583333333333
39655, 0.77083333333333, 0.033333333333333, 0.16666666666667
39656, 0.79166666666667, 0.016666666666667, 0.16666666666667
39657, 0.79166666666667, 0.033333333333333, 0.14583333333333
39658, 0.8125, 0.033333333333333, 0.16666666666667
39659, 0.83333333333333, 0.016666666666667, 0.16666666666667
39660, 0.83333333333333, 0.033333333333333, 0.14583333333333
39661, 0.85416666666667, 0.033333333333333, 0.16666666666667
39662, 0.875, 0.016666666666667, 0.16666666666667
39663, 0.875, 0.033333333333333, 0.14583333333333
39664, 0.89583333333333, 0.033333333333333, 0.16666666666667
39665, 0.91666666666667, 0.016666666666667, 0.16666666666667
39666, 0.91666666666667, 0.033333333333333, 0.14583333333333
39667, 0.9375, 0.033333333333333, 0.16666666666667
39668, 0.95833333333333, 0.016666666666667, 0.16666666666667
39669, 0.95833333333333, 0.033333333333333, 0.14583333333333
39670, 0.97916666666667, 0.033333333333333, 0.16666666666667
39671, 0.020833333333333, 0.066666666666667, 0.16666666666667
39672, 0.041666666666667, 0.05, 0.16666666666667
39673, 0.041666666666667, 0.066666666666667, 0.14583333333333
39674, 0.0625, 0.066666666666667, 0.16666666666667
39675, 0.083333333333333, 0.05, 0.16666666666667
39676, 0.083333333333333, 0.066666666666667, 0.14583333333333
39677, 0.10416666666667, 0.066666666666667, 0.16666666666667
39678, 0.125, 0.05, 0.16666666666667
39679, 0.125, 0.066666666666667, 0.14583333333333
39680, 0.14583333333333, 0.066666666666667, 0.16666666666667
39681, 0.16666666666667, 0.05, 0.16666666666667
39682, 0.16666666666667, 0.066666666666667, 0.14583333333333
39683, 0.1875, 0.066666666666667, 0.16666666666667
39684, 0.20833333333333, 0.05, 0.16666666666667
39685, 0.20833333333333, 0.066666666666667, 0.14583333333333
39686, 0.22916666666667, 0.066666666666667, 0.16666666666667
39687, 0.25, 0.05, 0.16666666666667
39688, 0.25, 0.066666666666667, 0.14583333333333
39689, 0.27083333333333, 0.066666666666667, 0.16666666666667
39690, 0.29166666666667, 0.05, 0.16666666666667
39691, 0.29166666666667, 0.066666666666667, 0.14583333333333
39692, 0.3125, 0.066666666666667, 0.16666666666667
39693, 0.33333333333333, 0.05, 0.16666666666667
39694, 0.33333333333333, 0.066666666666667, 0.14583333333333
39695, 0.35416666666667, 0.066666666666667, 0.16666666666667
39696, 0.375, 0.05, 0.16666666666667
39697, 0.375, 0.066666666666667, 0.14583333333333
39698, 0.39583333333333, 0.066666666666667, 0.16666666666667
39699, 0.41666666666667, 0.05, 0.16666666666667
39700, 0.41666666666667, 0.066666666666667, 0.14583333333333
39701, 0.4375, 0.066666666666667, 0.16666666666667
39702, 0.45833333333333, 0.05, 0.16666666666667
39703, 0.45833333333333, 0.066666666666667, 0.14583333333333
39704, 0.47916666666667, 0.066666666666667, 0.16666666666667
39705, 0.5, 0.05, 0.16666666666667
39706, 0.5, 0.066666666666667, 0.14583333333333
39707, 0.52083333333333, 0.066666666666667, 0.16666666666667
39708, 0.54166666666667, 0.05, 0.16666666666667
39709, 0.54166666666667, 0.066666666666667, 0.14583333333333
39710, 0.5625, 0.066666666666667, 0.16666666666667
39711, 0.58333333333333, 0.05, 0.16666666666667
39712, 0.58333333333333, 0.066666666666667, 0.14583333333333
39713, 0.60416666666667, 0.066666666666667, 0.16666666666667
39714, 0.625, 0.05, 0.16666666666667
39715, 0.625, 0.066666666666667, 0.14583333333333
39716, 0.64583333333333, 0.066666666666667, 0.16666666666667
39717, 0.66666666666667, 0.05, 0.16666666666667
39718, 0.66666666666667, 0.066666666666667, 0.14583333333333
39719, 0.6875, 0.066666666666667, 0.16666666666667
39720, 0.70833333333333, 0.05, 0.16666666666667
39721, 0.70833333333333, 0.066666666666667, 0.14583333333333
39722, 0.72916666666667, 0.066666666666667, 0.16666666666667
39723, 0.75, 0.05, 0.16666666666667
39724, 0.75, 0.066666666666667, 0.14583333333333
39725, 0.77083333333333, 0.066666666666667, 0.16666666666667
39726, 0.79166666666667, 0.05, 0.16666666666667
39727, 0.79166666666667, 0.066666666666667, 0.14583333333333
39728, 0.8125, 0.066666666666667, 0.16666666666667
39729, 0.83333333333333, 0.05, 0.16666666666667
39730, 0.83333333333333, 0.066666666666667, 0.14583333333333
39731, 0.85416666666667, 0.066666666666667, 0.16666666666667
39732, 0.875, 0.05, 0.16666666666667
39733, 0.875, 0.066666666666667, 0.14583333333333
39734, 0.89583333333333, 0.066666666666667, 0.16666666666667
39735, 0.91666666666667, 0.05, 0.16666666666667
39736, 0.91666666666667, 0.066666666666667, 0.14583333333333
39737, 0.9375, 0.066666666666667, 0.16666666666667
39738, 0.95833333333333, 0.05, 0.16666666666667
39739, 0.95833333333333, 0.066666666666667, 0.14583333333333
39740, 0.97916666666667, 0.066666666666667, 0.16666666666667
39741, 0.041666666666667, 0.083333333333333, 0.16666666666667
39742, 0.083333333333333, 0.083333333333333, 0.16666666666667
39743, 0.125, 0.083333333333333, 0.16666666666667
39744, 0.16666666666667, 0.083333333333333, 0.16666666666667
39745, 0.20833333333333, 0.083333333333333, 0.16666666666667
39746, 0.25, 0.083333333333333, 0.16666666666667
39747, 0.29166666666667, 0.083333333333333, 0.16666666666667
39748, 0.33333333333333, 0.083333333333333, 0.16666666666667
39749, 0.375, 0.083333333333333, 0.16666666666667
39750, 0.41666666666667, 0.083333333333333, 0.16666666666667
39751, 0.45833333333333, 0.083333333333333, 0.16666666666667
39752, 0.5, 0.083333333333333, 0.16666666666667
39753, 0.54166666666667, 0.083333333333333, 0.16666666666667
39754, 0.58333333333333, 0.083333333333333, 0.16666666666667
39755, 0.625, 0.083333333333333, 0.16666666666667
39756, 0.66666666666667, 0.083333333333333, 0.16666666666667
39757, 0.70833333333333, 0.083333333333333, 0.16666666666667
39758, 0.75, 0.083333333333333, 0.16666666666667
39759, 0.79166666666667, 0.083333333333333, 0.16666666666667
39760, 0.83333333333333, 0.083333333333333, 0.16666666666667
39761, 0.875, 0.083333333333333, 0.16666666666667
39762, 0.91666666666667, 0.083333333333333, 0.16666666666667
39763, 0.95833333333333, 0.083333333333333, 0.16666666666667
39764, 0.020833333333333, 0.033333333333333, 0.20833333333333
39765, 0.041666666666667, 0.016666666666667, 0.20833333333333
39766, 0.041666666666667, 0.033333333333333, 0.1875
39767, 0.0625, 0.033333333333333, 0.20833333333333
39768, 0.083333333333333, 0.016666666666667, 0.20833333333333
39769, 0.083333333333333, 0.033333333333333, 0.1875
39770, 0.10416666666667, 0.033333333333333, 0.20833333333333
39771, 0.125, 0.016666666666667, 0.20833333333333
39772, 0.125, 0.033333333333333, 0.1875
39773, 0.14583333333333, 0.033333333333333, 0.20833333333333
39774, 0.16666666666667, 0.016666666666667, 0.20833333333333
39775, 0.16666666666667, 0.033333333333333, 0.1875
39776, 0.1875, 0.033333333333333, 0.20833333333333
39777, 0.20833333333333, 0.016666666666667, 0.20833333333333
39778, 0.20833333333333, 0.033333333333333, 0.1875
39779, 0.22916666666667, 0.033333333333333, 0.20833333333333
39780, 0.25, 0.016666666666667, 0.20833333333333
39781, 0.25, 0.033333333333333, 0.1875
39782, 0.27083333333333, 0.033333333333333, 0.20833333333333
39783, 0.29166666666667, 0.016666666666667, 0.20833333333333
39784, 0.29166666666667, 0.033333333333333, 0.1875
39785, 0.3125, 0.033333333333333, 0.20833333333333
39786, 0.33333333333333, 0.016666666666667, 0.20833333333333
39787, 0.33333333333333, 0.033333333333333, 0.1875
39788, 0.35416666666667, 0.033333333333333, 0.20833333333333
39789, 0.375, 0.016666666666667, 0.20833333333333
39790, 0.375, 0.033333333333333, 0.1875
39791, 0.39583333333333, 0.033333333333333, 0.20833333333333
39792, 0.41666666666667, 0.016666666666667, 0.20833333333333
39793, 0.41666666666667, 0.033333333333333, 0.1875
39794, 0.4375, 0.033333333333333, 0.20833333333333
39795, 0.45833333333333, 0.016666666666667, 0.20833333333333
39796, 0.45833333333333, 0.033333333333333, 0.1875
39797, 0.47916666666667, 0.033333333333333, 0.20833333333333
39798, 0.5, 0.016666666666667, 0.20833333333333
39799, 0.5, 0.033333333333333, 0.1875
39800, 0.52083333333333, 0.033333333333333, 0.20833333333333
39801, 0.54166666666667, 0.016666666666667, 0.20833333333333
39802, 0.54166666666667, 0.033333333333333, 0.1875
39803, 0.5625, 0.033333333333333, 0.20833333333333
39804, 0.58333333333333, 0.016666666666667, 0.20833333333333
39805, 0.58333333333333, 0.033333333333333, 0.1875
39806, 0.60416666666667, 0.033333333333333, 0.20833333333333
39807, 0.625, 0.016666666666667, 0.20833333333333
39808, 0.625, 0.033333333333333, 0.1875
39809, 0.64583333333333, 0.033333333333333, 0.20833333333333
39810, 0.66666666666667, 0.016666666666667, 0.20833333333333
39811, 0.66666666666667, 0.033333333333333, 0.1875
39812, 0.6875, 0.033333333333333, 0.20833333333333
39813, 0.70833333333333, 0.016666666666667, 0.20833333333333
39814, 0.70833333333333, 0.033333333333333, 0.1875
39815, 0.72916666666667, 0.033333333333333, 0.20833333333333
39816, 0.75, 0.016666666666667, 0.20833333333333
39817, 0.75, 0.033333333333333, 0.1875
39818, 0.77083333333333, 0.033333333333333, 0.20833333333333
39819, 0.79166666666667, 0.016666666666667, 0.20833333333333
39820, 0.79166666666667, 0.033333333333333, 0.1875
39821, 0.8125, 0.033333333333333, 0.20833333333333
39822, 0.83333333333333, 0.016666666666667, 0.20833333333333
39823, 0.83333333333333, 0.033333333333333, 0.1875
39824, 0.85416666666667, 0.033333333333333, 0.20833333333333
39825, 0.875, 0.016666666666667, 0.20833333333333
39826, 0.875, 0.033333333333333, 0.1875
39827, 0.89583333333333, 0.033333333333333, 0.20833333333333
39828, 0.91666666666667, 0.016666666666667, 0.20833333333333
39829, 0.91666666666667, 0.033333333333333, 0.1875
39830, 0.9375, 0.033333333333333, 0.20833333333333
39831, 0.95833333333333, 0.016666666666667, 0.20833333333333
39832, 0.95833333333333, 0.033333333333333, 0.1875
39833, 0.97916666666667, 0.033333333333333, 0.20833333333333
39834, 0.020833333333333, 0.066666666666667, 0.20833333333333
39835, 0.041666666666667, 0.05, 0.20833333333333
39836, 0.041666666666667, 0.066666666666667, 0.1875
39837, 0.0625, 0.066666666666667, 0.20833333333333
39838, 0.083333333333333, 0.05, 0.20833333333333
39839, 0.083333333333333, 0.066666666666667, 0.1875
39840, 0.10416666666667, 0.066666666666667, 0.20833333333333
39841, 0.125, 0.05, 0.20833333333333
39842, 0.125, 0.066666666666667, 0.1875
39843, 0.14583333333333, 0.066666666666667, 0.20833333333333
39844, 0.16666666666667, 0.05, 0.20833333333333
39845, 0.16666666666667, 0.066666666666667, 0.1875
39846, 0.1875, 0.066666666666667, 0.20833333333333
39847, 0.20833333333333, 0.05, 0.20833333333333
39848, 0.20833333333333, 0.066666666666667, 0.1875
39849, 0.22916666666667, 0.066666666666667, 0.20833333333333
39850, 0.25, 0.05, 0.20833333333333
39851, 0.25, 0.066666666666667, 0.1875
39852, 0.27083333333333, 0.066666666666667, 0.20833333333333
39853, 0.29166666666667, 0.05, 0.20833333333333
39854, 0.29166666666667, 0.066666666666667, 0.1875
39855, 0.3125, 0.066666666666667, 0.20833333333333
39856, 0.33333333333333, 0.05, 0.20833333333333
39857, 0.33333333333333, 0.066666666666667, 0.1875
39858, 0.35416666666667, 0.066666666666667, 0.20833333333333
39859, 0.375, 0.05, 0.20833333333333
39860, 0.375, 0.066666666666667, 0.1875
39861, 0.39583333333333, 0.066666666666667, 0.20833333333333
39862, 0.41666666666667, 0.05, 0.20833333333333
39863, 0.41666666666667, 0.066666666666667, 0.1875
39864, 0.4375, 0.066666666666667, 0.20833333333333
39865, 0.45833333333333, 0.05, 0.20833333333333
39866, 0.45833333333333, 0.066666666666667, 0.1875
39867, 0.47916666666667, 0.066666666666667, 0.20833333333333
39868, 0.5, 0.05, 0.20833333333333
39869, 0.5, 0.066666666666667, 0.1875
39870, 0.52083333333333, 0.066666666666667, 0.20833333333333
39871, 0.54166666666667, 0.05, 0.20833333333333
39872, 0.54166666666667, 0.066666666666667, 0.1875
39873, 0.5625, 0.066666666666667, 0.20833333333333
39874, 0.58333333333333, 0.05, 0.20833333333333
39875, 0.58333333333333, 0.066666666666667, 0.1875
39876, 0.60416666666667, 0.066666666666667, 0.20833333333333
39877, 0.625, 0.05, 0.20833333333333
39878, 0.625, 0.066666666666667, 0.1875
39879, 0.64583333333333, 0.066666666666667, 0.20833333333333
39880, 0.66666666666667, 0.05, 0.20833333333333
39881, 0.66666666666667, 0.066666666666667, 0.1875
39882, 0.6875, 0.066666666666667, 0.20833333333333
39883, 0.70833333333333, 0.05, 0.20833333333333
39884, 0.70833333333333, 0.066666666666667, 0.1875
39885, 0.72916666666667, 0.066666666666667, 0.20833333333333
39886, 0.75, 0.05, 0.20833333333333
39887, 0.75, 0.066666666666667, 0.1875
39888, 0.77083333333333, 0.066666666666667, 0.20833333333333
39889, 0.79166666666667, 0.05, 0.20833333333333
39890, 0.79166666666667, 0.066666666666667, 0.1875
39891, 0.8125, 0.066666666666667, 0.20833333333333
39892, 0.83333333333333, 0.05, 0.20833333333333
39893, 0.83333333333333, 0.066666666666667, 0.1875
39894, 0.85416666666667, 0.066666666666667, 0.20833333333333
39895, 0.875, 0.05, 0.20833333333333
39896, 0.875, 0.066666666666667, 0.1875
39897, 0.89583333333333, 0.066666666666667, 0.20833333333333
39898, 0.91666666666667, 0.05, 0.20833333333333
39899, 0.91666666666667, 0.066666666666667, 0.1875
39900, 0.9375, 0.066666666666667, 0.20833333333333
39901, 0.95833333333333, 0.05, 0.20833333333333
39902, 0.95833333333333, 0.066666666666667, 0.1875
39903, 0.97916666666667, 0.066666666666667, 0.20833333333333
39904, 0.041666666666667, 0.083333333333333, 0.20833333333333
39905, 0.083333333333333, 0.083333333333333, 0.20833333333333
39906, 0.125, 0.083333333333333, 0.20833333333333
39907, 0.16666666666667, 0.083333333333333, 0.20833333333333
39908, 0.20833333333333, 0.083333333333333, 0.20833333333333
39909, 0.25, 0.083333333333333, 0.20833333333333
39910, 0.29166666666667, 0.083333333333333, 0.20833333333333
39911, 0.33333333333333, 0.083333333333333, 0.20833333333333
39912, 0.375, 0.083333333333333, 0.20833333333333
39913, 0.41666666666667, 0.083333333333333, 0.20833333333333
39914, 0.45833333333333, 0.083333333333333, 0.20833333333333
39915, 0.5, 0.083333333333333, 0.20833333333333
39916, 0.54166666666667, 0.083333333333333, 0.20833333333333
39917, 0.58333333333333, 0.083333333333333, 0.20833333333333
39918, 0.625, 0.083333333333333, 0.20833333333333
39919, 0.66666666666667, 0.083333333333333, 0.20833333333333
39920, 0.70833333333333, 0.083333333333333, 0.20833333333333
39921, 0.75, 0.083333333333333, 0.20833333333333
39922, 0.79166666666667, 0.083333333333333, 0.20833333333333
39923, 0.83333333333333, 0.083333333333333, 0.20833333333333
39924, 0.875, 0.083333333333333, 0.20833333333333
39925, 0.91666666666667, 0.083333333333333, 0.20833333333333
39926, 0.95833333333333, 0.083333333333333, 0.20833333333333
39927, 0.020833333333333, 0.033333333333333, 0.25
39928, 0.041666666666667, 0.016666666666667, 0.25
39929, 0.041666666666667, 0.033333333333333, 0.22916666666667
39930, 0.0625, 0.033333333333333, 0.25
39931, 0.083333333333333, 0.016666666666667, 0.25
39932, 0.083333333333333, 0.033333333333333, 0.22916666666667
39933, 0.10416666666667, 0.033333333333333, 0.25
39934, 0.125, 0.016666666666667, 0.25
39935, 0.125, 0.033333333333333, 0.22916666666667
39936, 0.14583333333333, 0.033333333333333, 0.25
39937, 0.16666666666667, 0.016666666666667, 0.25
39938, 0.16666666666667, 0.033333333333333, 0.22916666666667
39939, 0.1875, 0.033333333333333, 0.25
39940, 0.20833333333333, 0.016666666666667, 0.25
39941, 0.20833333333333, 0.033333333333333, 0.22916666666667
39942, 0.22916666666667, 0.033333333333333, 0.25
39943, 0.25, 0.016666666666667, 0.25
39944, 0.25, 0.033333333333333, 0.22916666666667
39945, 0.27083333333333, 0.033333333333333, 0.25
39946, 0.29166666666667, 0.016666666666667, 0.25
39947, 0.29166666666667, 0.033333333333333, 0.22916666666667
39948, 0.3125, 0.033333333333333, 0.25
39949, 0.33333333333333, 0.016666666666667, 0.25
39950, 0.33333333333333, 0.033333333333333, 0.22916666666667
39951, 0.35416666666667, 0.033333333333333, 0.25
39952, 0.375, 0.016666666666667, 0.25
39953, 0.375, 0.033333333333333, 0.22916666666667
39954, 0.39583333333333, 0.033333333333333, 0.25
39955, 0.41666666666667, 0.016666666666667, 0.25
39956, 0.41666666666667, 0.033333333333333, 0.22916666666667
39957, 0.4375, 0.033333333333333, 0.25
39958, 0.45833333333333, 0.016666666666667, 0.25
39959, 0.45833333333333, 0.033333333333333, 0.22916666666667
39960, 0.47916666666667, 0.033333333333333, 0.25
39961, 0.5, 0.016666666666667, 0.25
39962, 0.5, 0.033333333333333, 0.22916666666667
39963, 0.52083333333333, 0.033333333333333, 0.25
39964, 0.54166666666667, 0.016666666666667, 0.25
39965, 0.54166666666667, 0.033333333333333, 0.22916666666667
39966, 0.5625, 0.033333333333333, 0.25
39967, 0.58333333333333, 0.016666666666667, 0.25
39968, 0.58333333333333, 0.033333333333333, 0.22916666666667
39969, 0.60416666666667, 0.033333333333333, 0.25
39970, 0.625, 0.016666666666667, 0.25
39971, 0.625, 0.033333333333333, 0.22916666666667
39972, 0.64583333333333, 0.033333333333333, 0.25
39973, 0.66666666666667, 0.016666666666667, 0.25
39974, 0.66666666666667, 0.033333333333333, 0.22916666666667
39975, 0.6875, 0.033333333333333, 0.25
39976, 0.70833333333333, 0.016666666666667, 0.25
39977, 0.70833333333333, 0.033333333333333, 0.22916666666667
39978, 0.72916666666667, 0.033333333333333, 0.25
39979, 0.75, 0.016666666666667, 0.25
39980, 0.75, 0.033333333333333, 0.22916666666667
39981, 0.77083333333333, 0.033333333333333, 0.25
39982, 0.79166666666667, 0.016666666666667, 0.25
39983, 0.79166666666667, 0.033333333333333, 0.22916666666667
39984, 0.8125, 0.033333333333333, 0.25
39985, 0.83333333333333, 0.016666666666667, 0.25
39986, 0.83333333333333, 0.033333333333333, 0.22916666666667
39987, 0.85416666666667, 0.033333333333333, 0.25
39988, 0.875, 0.016666666666667, 0.25
39989, 0.875, 0.033333333333333, 0.22916666666667
39990, 0.89583333333333, 0.033333333333333, 0.25
39991, 0.91666666666667, 0.016666666666667, 0.25
39992, 0.91666666666667, 0.033333333333333, 0.22916666666667
39993, 0.9375, 0.033333333333333, 0.25
39994, 0.95833333333333, 0.016666666666667, 0.25
39995, 0.95833333333333, 0.033333333333333, 0.22916666666667
39996, 0.97916666666667, 0.033333333333333, 0.25
39997, 0.020833333333333, 0.066666666666667, 0.25
39998, 0.041666666666667, 0.05, 0.25
39999, 0.041666666666667, 0.066666666666667, 0.22916666666667
40000, 0.0625, 0.066666666666667, 0.25
40001, 0.083333333333333, 0.05, 0.25
40002, 0.083333333333333, 0.066666666666667, 0.22916666666667
40003, 0.10416666666667, 0.066666666666667, 0.25
40004, 0.125, 0.05, 0.25
40005, 0.125, 0.066666666666667, 0.22916666666667
40006, 0.14583333333333, 0.066666666666667, 0.25
40007, 0.16666666666667, 0.05, 0.25
40008, 0.16666666666667, 0.066666666666667, 0.22916666666667
40009, 0.1875, 0.066666666666667, 0.25
40010, 0.20833333333333, 0.05, 0.25
40011, 0.20833333333333, 0.066666666666667, 0.22916666666667
40012, 0.22916666666667, 0.066666666666667, 0.25
40013, 0.25, 0.05, 0.25
40014, 0.25, 0.066666666666667, 0.22916666666667
40015, 0.27083333333333, 0.066666666666667, 0.25
40016, 0.29166666666667, 0.05, 0.25
40017, 0.29166666666667, 0.066666666666667, 0.22916666666667
40018, 0.3125, 0.066666666666667, 0.25
40019, 0.33333333333333, 0.05, 0.25
40020, 0.33333333333333, 0.066666666666667, 0.22916666666667
40021, 0.35416666666667, 0.066666666666667, 0.25
40022, 0.375, 0.05, 0.25
40023, 0.375, 0.066666666666667, 0.22916666666667
40024, 0.39583333333333, 0.066666666666667, 0.25
40025, 0.41666666666667, 0.05, 0.25
40026, 0.41666666666667, 0.066666666666667, 0.22916666666667
40027, 0.4375, 0.066666666666667, 0.25
40028, 0.45833333333333, 0.05, 0.25
40029, 0.45833333333333, 0.066666666666667, 0.22916666666667
40030, 0.47916666666667, 0.066666666666667, 0.25
40031, 0.5, 0.05, 0.25
40032, 0.5, 0.066666666666667, 0.22916666666667
40033, 0.52083333333333, 0.066666666666667, 0.25
40034, 0.54166666666667, 0.05, 0.25
40035, 0.54166666666667, 0.066666666666667, 0.22916666666667
40036, 0.5625, 0.066666666666667, 0.25
40037, 0.58333333333333, 0.05, 0.25
40038, 0.58333333333333, 0.066666666666667, 0.22916666666667
40039, 0.60416666666667, 0.066666666666667, 0.25
40040, 0.625, 0.05, 0.25
40041, 0.625, 0.066666666666667, 0.22916666666667
40042, 0.64583333333333, 0.066666666666667, 0.25
40043, 0.66666666666667, 0.05, 0.25
40044, 0.66666666666667, 0.066666666666667, 0.22916666666667
40045, 0.6875, 0.066666666666667, 0.25
40046, 0.70833333333333, 0.05, 0.25
40047, 0.70833333333333, 0.066666666666667, 0.22916666666667
40048, 0.72916666666667, 0.066666666666667, 0.25
40049, 0.75, 0.05, 0.25
40050, 0.75, 0.066666666666667, 0.22916666666667
40051, 0.77083333333333, 0.066666666666667, 0.25
40052, 0.79166666666667, 0.05, 0.25
40053, 0.79166666666667, 0.066666666666667, 0.22916666666667
40054, 0.8125, 0.066666666666667, 0.25
40055, 0.83333333333333, 0.05, 0.25
40056, 0.83333333333333, 0.066666666666667, 0.22916666666667
40057, 0.85416666666667, 0.066666666666667, 0.25
40058, 0.875, 0.05, 0.25
40059, 0.875, 0.066666666666667, 0.22916666666667
40060, 0.89583333333333, 0.066666666666667, 0.25
40061, 0.91666666666667, 0.05, 0.25
40062, 0.91666666666667, 0.066666666666667, 0.22916666666667
40063, 0.9375, 0.066666666666667, 0.25
40064, 0.95833333333333, 0.05, 0.25
40065, 0.95833333333333, 0.066666666666667, 0.22916666666667
40066, 0.97916666666667, 0.066666666666667, 0.25
40067, 0.041666666666667, 0.083333333333333, 0.25
40068, 0.083333333333333, 0.083333333333333, 0.25
40069, 0.125, 0.083333333333333, 0.25
40070, 0.16666666666667, 0.083333333333333, 0.25
40071, 0.20833333333333, 0.083333333333333, 0.25
40072, 0.25, 0.083333333333333, 0.25
40073, 0.29166666666667, 0.083333333333333, 0.25
40074, 0.33333333333333, 0.083333333333333, 0.25
40075, 0.375, 0.083333333333333, 0.25
40076, 0.41666666666667, 0.083333333333333, 0.25
40077, 0.45833333333333, 0.083333333333333, 0.25
40078, 0.5, 0.083333333333333, 0.25
40079, 0.54166666666667, 0.083333333333333, 0.25
40080, 0.58333333333333, 0.083333333333333, 0.25
40081, 0.625, 0.083333333333333, 0.25
40082, 0.66666666666667, 0.083333333333333, 0.25
40083, 0.70833333333333, 0.083333333333333, 0.25
40084, 0.75, 0.083333333333333, 0.25
40085, 0.79166666666667, 0.083333333333333, 0.25
40086, 0.83333333333333, 0.083333333333333, 0.25
40087, 0.875, 0.083333333333333, 0.25
40088, 0.91666666666667, 0.083333333333333, 0.25
40089, 0.95833333333333, 0.083333333333333, 0.25
40090, 0.020833333333333, 0.033333333333333, 0.29166666666667
40091, 0.041666666666667, 0.016666666666667, 0.29166666666667
40092, 0.041666666666667, 0.033333333333333, 0.27083333333333
40093, 0.0625, 0.033333333333333, 0.29166666666667
40094, 0.083333333333333, 0.016666666666667, 0.29166666666667
40095, 0.083333333333333, 0.033333333333333, 0.27083333333333
40096, 0.10416666666667, 0.033333333333333, 0.29166666666667
40097, 0.125, 0.016666666666667, 0.29166666666667
40098, 0.125, 0.033333333333333, 0.27083333333333
40099, 0.14583333333333, 0.033333333333333, 0.29166666666667
40100, 0.16666666666667, 0.016666666666667, 0.29166666666667
40101, 0.16666666666667, 0.033333333333333, 0.27083333333333
40102, 0.1875, 0.033333333333333, 0.29166666666667
40103, 0.20833333333333, 0.016666666666667, 0.29166666666667
40104, 0.20833333333333, 0.033333333333333, 0.27083333333333
40105, 0.22916666666667, 0.033333333333333, 0.29166666666667
40106, 0.25, 0.016666666666667, 0.29166666666667
40107, 0.25, 0.033333333333333, 0.27083333333333
40108, 0.27083333333333, 0.033333333333333, 0.29166666666667
40109, 0.29166666666667, 0.016666666666667, 0.29166666666667
40110, 0.29166666666667, 0.033333333333333, 0.27083333333333
40111, 0.3125, 0.033333333333333, 0.29166666666667
40112, 0.33333333333333, 0.016666666666667, 0.29166666666667
40113, 0.33333333333333, 0.033333333333333, 0.27083333333333
40114, 0.35416666666667, 0.033333333333333, 0.29166666666667
40115, 0.375, 0.016666666666667, 0.29166666666667
40116, 0.375, 0.033333333333333, 0.27083333333333
40117, 0.39583333333333, 0.033333333333333, 0.29166666666667
40118, 0.41666666666667, 0.016666666666667, 0.29166666666667
40119, 0.41666666666667, 0.033333333333333, 0.27083333333333
40120, 0.4375, 0.033333333333333, 0.29166666666667
40121, 0.45833333333333, 0.016666666666667, 0.29166666666667
40122, 0.45833333333333, 0.033333333333333, 0.27083333333333
40123, 0.47916666666667, 0.033333333333333, 0.29166666666667
40124, 0.5, 0.016666666666667, 0.29166666666667
40125, 0.5, 0.033333333333333, 0.27083333333333
40126, 0.52083333333333, 0.033333333333333, 0.29166666666667
40127, 0.54166666666667, 0.016666666666667, 0.29166666666667
40128, 0.54166666666667, 0.033333333333333, 0.27083333333333
40129, 0.5625, 0.033333333333333, 0.29166666666667
40130, 0.58333333333333, 0.016666666666667, 0.29166666666667
40131, 0.58333333333333, 0.033333333333333, 0.27083333333333
40132, 0.60416666666667, 0.033333333333333, 0.29166666666667
40133, 0.625, 0.016666666666667, 0.29166666666667
40134, 0.625, 0.033333333333333, 0.27083333333333
40135, 0.64583333333333, 0.033333333333333, 0.29166666666667
40136, 0.66666666666667, 0.016666666666667, 0.29166666666667
40137, 0.66666666666667, 0.033333333333333, 0.27083333333333
40138, 0.6875, 0.033333333333333, 0.29166666666667
40139, 0.70833333333333, 0.016666666666667, 0.29166666666667
40140, 0.70833333333333, 0.033333333333333, 0.27083333333333
40141, 0.72916666666667, 0.033333333333333, 0.29166666666667
40142, 0.75, 0.016666666666667, 0.29166666666667
40143, 0.75, 0.033333333333333, 0.27083333333333
40144, 0.77083333333333, 0.033333333333333, 0.29166666666667
40145, 0.79166666666667, 0.016666666666667, 0.29166666666667
40146, 0.79166666666667, 0.033333333333333, 0.27083333333333
40147, 0.8125, 0.033333333333333, 0.29166666666667
40148, 0.83333333333333, 0.016666666666667, 0.29166666666667
40149, 0.83333333333333, 0.033333333333333, 0.27083333333333
40150, 0.85416666666667, 0.033333333333333, 0.29166666666667
40151, 0.875, 0.016666666666667, 0.29166666666667
40152, 0.875, 0.033333333333333, 0.27083333333333
40153, 0.89583333333333, 0.033333333333333, 0.29166666666667
40154, 0.91666666666667, 0.016666666666667, 0.29166666666667
40155, 0.91666666666667, 0.033333333333333, 0.27083333333333
40156, 0.9375, 0.033333333333333, 0.29166666666667
40157, 0.95833333333333, 0.016666666666667, 0.29166666666667
40158, 0.95833333333333, 0.033333333333333, 0.27083333333333
40159, 0.97916666666667, 0.033333333333333, 0.29166666666667
40160, 0.020833333333333, 0.066666666666667, 0.29166666666667
40161, 0.041666666666667, 0.05, 0.29166666666667
40162, 0.041666666666667, 0.066666666666667, 0.27083333333333
40163, 0.0625, 0.066666666666667, 0.29166666666667
40164, 0.083333333333333, 0.05, 0.29166666666667
