40165, 0.083333333333333, 0.066666666666667, 0.27083333333333
40166, 0.10416666666667, 0.066666666666667, 0.29166666666667
40167, 0.125, 0.05, 0.29166666666667
40168, 0.125, 0.066666666666667, 0.27083333333333
40169, 0.14583333333333, 0.066666666666667, 0.29166666666667
40170, 0.16666666666667, 0.05, 0.29166666666667
40171, 0.16666666666667, 0.066666666666667, 0.27083333333333
40172, 0.1875, 0.066666666666667, 0.29166666666667
40173, 0.20833333333333, 0.05, 0.29166666666667
40174, 0.20833333333333, 0.066666666666667, 0.27083333333333
40175, 0.22916666666667, 0.066666666666667, 0.29166666666667
40176, 0.25, 0.05, 0.29166666666667
40177, 0.25, 0.066666666666667, 0.27083333333333
40178, 0.27083333333333, 0.066666666666667, 0.29166666666667
40179, 0.29166666666667, 0.05, 0.29166666666667
40180, 0.29166666666667, 0.066666666666667, 0.27083333333333
40181, 0.3125, 0.066666666666667, 0.29166666666667
40182, 0.33333333333333, 0.05, 0.29166666666667
40183, 0.33333333333333, 0.066666666666667, 0.27083333333333
40184, 0.35416666666667, 0.066666666666667, 0.29166666666667
40185, 0.375, 0.05, 0.29166666666667
40186, 0.375, 0.066666666666667, 0.27083333333333
40187, 0.39583333333333, 0.066666666666667, 0.29166666666667
40188, 0.41666666666667, 0.05, 0.29166666666667
40189, 0.41666666666667, 0.066666666666667, 0.27083333333333
40190, 0.4375, 0.066666666666667, 0.29166666666667
40191, 0.45833333333333, 0.05, 0.29166666666667
40192, 0.45833333333333, 0.066666666666667, 0.27083333333333
40193, 0.47916666666667, 0.066666666666667, 0.29166666666667
40194, 0.5, 0.05, 0.29166666666667
40195, 0.5, 0.066666666666667, 0.27083333333333
40196, 0.52083333333333, 0.066666666666667, 0.29166666666667
40197, 0.54166666666667, 0.05, 0.29166666666667
40198, 0.54166666666667, 0.066666666666667, 0.27083333333333
40199, 0.5625, 0.066666666666667, 0.29166666666667
40200, 0.58333333333333, 0.05, 0.29166666666667
40201, 0.58333333333333, 0.066666666666667, 0.27083333333333
40202, 0.60416666666667, 0.066666666666667, 0.29166666666667
40203, 0.625, 0.05, 0.29166666666667
40204, 0.625, 0.066666666666667, 0.27083333333333
40205, 0.64583333333333, 0.066666666666667, 0.29166666666667
40206, 0.66666666666667, 0.05, 0.29166666666667
40207, 0.66666666666667, 0.066666666666667, 0.27083333333333
40208, 0.6875, 0.066666666666667, 0.29166666666667
40209, 0.70833333333333, 0.05, 0.29166666666667
40210, 0.70833333333333, 0.066666666666667, 0.27083333333333
40211, 0.72916666666667, 0.066666666666667, 0.29166666666667
40212, 0.75, 0.05, 0.29166666666667
40213, 0.75, 0.066666666666667, 0.27083333333333
40214, 0.77083333333333, 0.066666666666667, 0.29166666666667
40215, 0.79166666666667, 0.05, 0.29166666666667
40216, 0.79166666666667, 0.066666666666667, 0.27083333333333
40217, 0.8125, 0.066666666666667, 0.29166666666667
40218, 0.83333333333333, 0.05, 0.29166666666667
40219, 0.83333333333333, 0.066666666666667, 0.27083333333333
40220, 0.85416666666667, 0.066666666666667, 0.29166666666667
40221, 0.875, 0.05, 0.29166666666667
40222, 0.875, 0.066666666666667, 0.27083333333333
40223, 0.89583333333333, 0.066666666666667, 0.29166666666667
40224, 0.91666666666667, 0.05, 0.29166666666667
40225, 0.91666666666667, 0.066666666666667, 0.27083333333333
40226, 0.9375, 0.066666666666667, 0.29166666666667
40227, 0.95833333333333, 0.05, 0.29166666666667
40228, 0.95833333333333, 0.066666666666667, 0.27083333333333
40229, 0.97916666666667, 0.066666666666667, 0.29166666666667
40230, 0.041666666666667, 0.083333333333333, 0.29166666666667
40231, 0.083333333333333, 0.083333333333333, 0.29166666666667
40232, 0.125, 0.083333333333333, 0.29166666666667
40233, 0.16666666666667, 0.083333333333333, 0.29166666666667
40234, 0.20833333333333, 0.083333333333333, 0.29166666666667
40235, 0.25, 0.083333333333333, 0.29166666666667
40236, 0.29166666666667, 0.083333333333333, 0.29166666666667
40237, 0.33333333333333, 0.083333333333333, 0.29166666666667
40238, 0.375, 0.083333333333333, 0.29166666666667
40239, 0.41666666666667, 0.083333333333333, 0.29166666666667
40240, 0.45833333333333, 0.083333333333333, 0.29166666666667
40241, 0.5, 0.083333333333333, 0.29166666666667
40242, 0.54166666666667, 0.083333333333333, 0.29166666666667
40243, 0.58333333333333, 0.083333333333333, 0.29166666666667
40244, 0.625, 0.083333333333333, 0.29166666666667
40245, 0.66666666666667, 0.083333333333333, 0.29166666666667
40246, 0.70833333333333, 0.083333333333333, 0.29166666666667
40247, 0.75, 0.083333333333333, 0.29166666666667
40248, 0.79166666666667, 0.083333333333333, 0.29166666666667
40249, 0.83333333333333, 0.083333333333333, 0.29166666666667
40250, 0.875, 0.083333333333333, 0.29166666666667
40251, 0.91666666666667, 0.083333333333333, 0.29166666666667
40252, 0.95833333333333, 0.083333333333333, 0.29166666666667
40253, 0.020833333333333, 0.033333333333333, 0.33333333333333
40254, 0.041666666666667, 0.016666666666667, 0.33333333333333
40255, 0.041666666666667, 0.033333333333333, 0.3125
40256, 0.0625, 0.033333333333333, 0.33333333333333
40257, 0.083333333333333, 0.016666666666667, 0.33333333333333
40258, 0.083333333333333, 0.033333333333333, 0.3125
40259, 0.10416666666667, 0.033333333333333, 0.33333333333333
40260, 0.125, 0.016666666666667, 0.33333333333333
40261, 0.125, 0.033333333333333, 0.3125
40262, 0.14583333333333, 0.033333333333333, 0.33333333333333
40263, 0.16666666666667, 0.016666666666667, 0.33333333333333
40264, 0.16666666666667, 0.033333333333333, 0.3125
40265, 0.1875, 0.033333333333333, 0.33333333333333
40266, 0.20833333333333, 0.016666666666667, 0.33333333333333
40267, 0.20833333333333, 0.033333333333333, 0.3125
40268, 0.22916666666667, 0.033333333333333, 0.33333333333333
40269, 0.25, 0.016666666666667, 0.33333333333333
40270, 0.25, 0.033333333333333, 0.3125
40271, 0.27083333333333, 0.033333333333333, 0.33333333333333
40272, 0.29166666666667, 0.016666666666667, 0.33333333333333
40273, 0.29166666666667, 0.033333333333333, 0.3125
40274, 0.3125, 0.033333333333333, 0.33333333333333
40275, 0.33333333333333, 0.016666666666667, 0.33333333333333
40276, 0.33333333333333, 0.033333333333333, 0.3125
40277, 0.35416666666667, 0.033333333333333, 0.33333333333333
40278, 0.375, 0.016666666666667, 0.33333333333333
40279, 0.375, 0.033333333333333, 0.3125
40280, 0.39583333333333, 0.033333333333333, 0.33333333333333
40281, 0.41666666666667, 0.016666666666667, 0.33333333333333
40282, 0.41666666666667, 0.033333333333333, 0.3125
40283, 0.4375, 0.033333333333333, 0.33333333333333
40284, 0.45833333333333, 0.016666666666667, 0.33333333333333
40285, 0.45833333333333, 0.033333333333333, 0.3125
40286, 0.47916666666667, 0.033333333333333, 0.33333333333333
40287, 0.5, 0.016666666666667, 0.33333333333333
40288, 0.5, 0.033333333333333, 0.3125
40289, 0.52083333333333, 0.033333333333333, 0.33333333333333
40290, 0.54166666666667, 0.016666666666667, 0.33333333333333
40291, 0.54166666666667, 0.033333333333333, 0.3125
40292, 0.5625, 0.033333333333333, 0.33333333333333
40293, 0.58333333333333, 0.016666666666667, 0.33333333333333
40294, 0.58333333333333, 0.033333333333333, 0.3125
40295, 0.60416666666667, 0.033333333333333, 0.33333333333333
40296, 0.625, 0.016666666666667, 0.33333333333333
40297, 0.625, 0.033333333333333, 0.3125
40298, 0.64583333333333, 0.033333333333333, 0.33333333333333
40299, 0.66666666666667, 0.016666666666667, 0.33333333333333
40300, 0.66666666666667, 0.033333333333333, 0.3125
40301, 0.6875, 0.033333333333333, 0.33333333333333
40302, 0.70833333333333, 0.016666666666667, 0.33333333333333
40303, 0.70833333333333, 0.033333333333333, 0.3125
40304, 0.72916666666667, 0.033333333333333, 0.33333333333333
40305, 0.75, 0.016666666666667, 0.33333333333333
40306, 0.75, 0.033333333333333, 0.3125
40307, 0.77083333333333, 0.033333333333333, 0.33333333333333
40308, 0.79166666666667, 0.016666666666667, 0.33333333333333
40309, 0.79166666666667, 0.033333333333333, 0.3125
40310, 0.8125, 0.033333333333333, 0.33333333333333
40311, 0.83333333333333, 0.016666666666667, 0.33333333333333
40312, 0.83333333333333, 0.033333333333333, 0.3125
40313, 0.85416666666667, 0.033333333333333, 0.33333333333333
40314, 0.875, 0.016666666666667, 0.33333333333333
40315, 0.875, 0.033333333333333, 0.3125
40316, 0.89583333333333, 0.033333333333333, 0.33333333333333
40317, 0.91666666666667, 0.016666666666667, 0.33333333333333
40318, 0.91666666666667, 0.033333333333333, 0.3125
40319, 0.9375, 0.033333333333333, 0.33333333333333
40320, 0.95833333333333, 0.016666666666667, 0.33333333333333
40321, 0.95833333333333, 0.033333333333333, 0.3125
40322, 0.97916666666667, 0.033333333333333, 0.33333333333333
40323, 0.020833333333333, 0.066666666666667, 0.33333333333333
40324, 0.041666666666667, 0.05, 0.33333333333333
40325, 0.041666666666667, 0.066666666666667, 0.3125
40326, 0.0625, 0.066666666666667, 0.33333333333333
40327, 0.083333333333333, 0.05, 0.33333333333333
40328, 0.083333333333333, 0.066666666666667, 0.3125
40329, 0.10416666666667, 0.066666666666667, 0.33333333333333
40330, 0.125, 0.05, 0.33333333333333
40331, 0.125, 0.066666666666667, 0.3125
40332, 0.14583333333333, 0.066666666666667, 0.33333333333333
40333, 0.16666666666667, 0.05, 0.33333333333333
40334, 0.16666666666667, 0.066666666666667, 0.3125
40335, 0.1875, 0.066666666666667, 0.33333333333333
40336, 0.20833333333333, 0.05, 0.33333333333333
40337, 0.20833333333333, 0.066666666666667, 0.3125
40338, 0.22916666666667, 0.066666666666667, 0.33333333333333
40339, 0.25, 0.05, 0.33333333333333
40340, 0.25, 0.066666666666667, 0.3125
40341, 0.27083333333333, 0.066666666666667, 0.33333333333333
40342, 0.29166666666667, 0.05, 0.33333333333333
40343, 0.29166666666667, 0.066666666666667, 0.3125
40344, 0.3125, 0.066666666666667, 0.33333333333333
40345, 0.33333333333333, 0.05, 0.33333333333333
40346, 0.33333333333333, 0.066666666666667, 0.3125
40347, 0.35416666666667, 0.066666666666667, 0.33333333333333
40348, 0.375, 0.05, 0.33333333333333
40349, 0.375, 0.066666666666667, 0.3125
40350, 0.39583333333333, 0.066666666666667, 0.33333333333333
40351, 0.41666666666667, 0.05, 0.33333333333333
40352, 0.41666666666667, 0.066666666666667, 0.3125
40353, 0.4375, 0.066666666666667, 0.33333333333333
40354, 0.45833333333333, 0.05, 0.33333333333333
40355, 0.45833333333333, 0.066666666666667, 0.3125
40356, 0.47916666666667, 0.066666666666667, 0.33333333333333
40357, 0.5, 0.05, 0.33333333333333
40358, 0.5, 0.066666666666667, 0.3125
40359, 0.52083333333333, 0.066666666666667, 0.33333333333333
40360, 0.54166666666667, 0.05, 0.33333333333333
40361, 0.54166666666667, 0.066666666666667, 0.3125
40362, 0.5625, 0.066666666666667, 0.33333333333333
40363, 0.58333333333333, 0.05, 0.33333333333333
40364, 0.58333333333333, 0.066666666666667, 0.3125
40365, 0.60416666666667, 0.066666666666667, 0.33333333333333
40366, 0.625, 0.05, 0.33333333333333
40367, 0.625, 0.066666666666667, 0.3125
40368, 0.64583333333333, 0.066666666666667, 0.33333333333333
40369, 0.66666666666667, 0.05, 0.33333333333333
40370, 0.66666666666667, 0.066666666666667, 0.3125
40371, 0.6875, 0.066666666666667, 0.33333333333333
40372, 0.70833333333333, 0.05, 0.33333333333333
40373, 0.70833333333333, 0.066666666666667, 0.3125
40374, 0.72916666666667, 0.066666666666667, 0.33333333333333
40375, 0.75, 0.05, 0.33333333333333
40376, 0.75, 0.066666666666667, 0.3125
40377, 0.77083333333333, 0.066666666666667, 0.33333333333333
40378, 0.79166666666667, 0.05, 0.33333333333333
40379, 0.79166666666667, 0.066666666666667, 0.3125
40380, 0.8125, 0.066666666666667, 0.33333333333333
40381, 0.83333333333333, 0.05, 0.33333333333333
40382, 0.83333333333333, 0.066666666666667, 0.3125
40383, 0.85416666666667, 0.066666666666667, 0.33333333333333
40384, 0.875, 0.05, 0.33333333333333
40385, 0.875, 0.066666666666667, 0.3125
40386, 0.89583333333333, 0.066666666666667, 0.33333333333333
40387, 0.91666666666667, 0.05, 0.33333333333333
40388, 0.91666666666667, 0.066666666666667, 0.3125
40389, 0.9375, 0.066666666666667, 0.33333333333333
40390, 0.95833333333333, 0.05, 0.33333333333333
40391, 0.95833333333333, 0.066666666666667, 0.3125
40392, 0.97916666666667, 0.066666666666667, 0.33333333333333
40393, 0.041666666666667, 0.083333333333333, 0.33333333333333
40394, 0.083333333333333, 0.083333333333333, 0.33333333333333
40395, 0.125, 0.083333333333333, 0.33333333333333
40396, 0.16666666666667, 0.083333333333333, 0.33333333333333
40397, 0.20833333333333, 0.083333333333333, 0.33333333333333
40398, 0.25, 0.083333333333333, 0.33333333333333
40399, 0.29166666666667, 0.083333333333333, 0.33333333333333
40400, 0.33333333333333, 0.083333333333333, 0.33333333333333
40401, 0.375, 0.083333333333333, 0.33333333333333
40402, 0.41666666666667, 0.083333333333333, 0.33333333333333
40403, 0.45833333333333, 0.083333333333333, 0.33333333333333
40404, 0.5, 0.083333333333333, 0.33333333333333
40405, 0.54166666666667, 0.083333333333333, 0.33333333333333
40406, 0.58333333333333, 0.083333333333333, 0.33333333333333
40407, 0.625, 0.083333333333333, 0.33333333333333
40408, 0.66666666666667, 0.083333333333333, 0.33333333333333
40409, 0.70833333333333, 0.083333333333333, 0.33333333333333
40410, 0.75, 0.083333333333333, 0.33333333333333
40411, 0.79166666666667, 0.083333333333333, 0.33333333333333
40412, 0.83333333333333, 0.083333333333333, 0.33333333333333
40413, 0.875, 0.083333333333333, 0.33333333333333
40414, 0.91666666666667, 0.083333333333333, 0.33333333333333
40415, 0.95833333333333, 0.083333333333333, 0.33333333333333
40416, 0.020833333333333, 0.033333333333333, 0.375
40417, 0.041666666666667, 0.016666666666667, 0.375
40418, 0.041666666666667, 0.033333333333333, 0.35416666666667
40419, 0.0625, 0.033333333333333, 0.375
40420, 0.083333333333333, 0.016666666666667, 0.375
40421, 0.083333333333333, 0.033333333333333, 0.35416666666667
40422, 0.10416666666667, 0.033333333333333, 0.375
40423, 0.125, 0.016666666666667, 0.375
40424, 0.125, 0.033333333333333, 0.35416666666667
40425, 0.14583333333333, 0.033333333333333, 0.375
40426, 0.16666666666667, 0.016666666666667, 0.375
40427, 0.16666666666667, 0.033333333333333, 0.35416666666667
40428, 0.1875, 0.033333333333333, 0.375
40429, 0.20833333333333, 0.016666666666667, 0.375
40430, 0.20833333333333, 0.033333333333333, 0.35416666666667
40431, 0.22916666666667, 0.033333333333333, 0.375
40432, 0.25, 0.016666666666667, 0.375
40433, 0.25, 0.033333333333333, 0.35416666666667
40434, 0.27083333333333, 0.033333333333333, 0.375
40435, 0.29166666666667, 0.016666666666667, 0.375
40436, 0.29166666666667, 0.033333333333333, 0.35416666666667
40437, 0.3125, 0.033333333333333, 0.375
40438, 0.33333333333333, 0.016666666666667, 0.375
40439, 0.33333333333333, 0.033333333333333, 0.35416666666667
40440, 0.35416666666667, 0.033333333333333, 0.375
40441, 0.375, 0.016666666666667, 0.375
40442, 0.375, 0.033333333333333, 0.35416666666667
40443, 0.39583333333333, 0.033333333333333, 0.375
40444, 0.41666666666667, 0.016666666666667, 0.375
40445, 0.41666666666667, 0.033333333333333, 0.35416666666667
40446, 0.4375, 0.033333333333333, 0.375
40447, 0.45833333333333, 0.016666666666667, 0.375
40448, 0.45833333333333, 0.033333333333333, 0.35416666666667
40449, 0.47916666666667, 0.033333333333333, 0.375
40450, 0.5, 0.016666666666667, 0.375
40451, 0.5, 0.033333333333333, 0.35416666666667
40452, 0.52083333333333, 0.033333333333333, 0.375
40453, 0.54166666666667, 0.016666666666667, 0.375
40454, 0.54166666666667, 0.033333333333333, 0.35416666666667
40455, 0.5625, 0.033333333333333, 0.375
40456, 0.58333333333333, 0.016666666666667, 0.375
40457, 0.58333333333333, 0.033333333333333, 0.35416666666667
40458, 0.60416666666667, 0.033333333333333, 0.375
40459, 0.625, 0.016666666666667, 0.375
40460, 0.625, 0.033333333333333, 0.35416666666667
40461, 0.64583333333333, 0.033333333333333, 0.375
40462, 0.66666666666667, 0.016666666666667, 0.375
40463, 0.66666666666667, 0.033333333333333, 0.35416666666667
40464, 0.6875, 0.033333333333333, 0.375
40465, 0.70833333333333, 0.016666666666667, 0.375
40466, 0.70833333333333, 0.033333333333333, 0.35416666666667
40467, 0.72916666666667, 0.033333333333333, 0.375
40468, 0.75, 0.016666666666667, 0.375
40469, 0.75, 0.033333333333333, 0.35416666666667
40470, 0.77083333333333, 0.033333333333333, 0.375
40471, 0.79166666666667, 0.016666666666667, 0.375
40472, 0.79166666666667, 0.033333333333333, 0.35416666666667
40473, 0.8125, 0.033333333333333, 0.375
40474, 0.83333333333333, 0.016666666666667, 0.375
40475, 0.83333333333333, 0.033333333333333, 0.35416666666667
40476, 0.85416666666667, 0.033333333333333, 0.375
40477, 0.875, 0.016666666666667, 0.375
40478, 0.875, 0.033333333333333, 0.35416666666667
40479, 0.89583333333333, 0.033333333333333, 0.375
40480, 0.91666666666667, 0.016666666666667, 0.375
40481, 0.91666666666667, 0.033333333333333, 0.35416666666667
40482, 0.9375, 0.033333333333333, 0.375
40483, 0.95833333333333, 0.016666666666667, 0.375
40484, 0.95833333333333, 0.033333333333333, 0.35416666666667
40485, 0.97916666666667, 0.033333333333333, 0.375
40486, 0.020833333333333, 0.066666666666667, 0.375
40487, 0.041666666666667, 0.05, 0.375
40488, 0.041666666666667, 0.066666666666667, 0.35416666666667
40489, 0.0625, 0.066666666666667, 0.375
40490, 0.083333333333333, 0.05, 0.375
40491, 0.083333333333333, 0.066666666666667, 0.35416666666667
40492, 0.10416666666667, 0.066666666666667, 0.375
40493, 0.125, 0.05, 0.375
40494, 0.125, 0.066666666666667, 0.35416666666667
40495, 0.14583333333333, 0.066666666666667, 0.375
40496, 0.16666666666667, 0.05, 0.375
40497, 0.16666666666667, 0.066666666666667, 0.35416666666667
40498, 0.1875, 0.066666666666667, 0.375
40499, 0.20833333333333, 0.05, 0.375
40500, 0.20833333333333, 0.066666666666667, 0.35416666666667
40501, 0.22916666666667, 0.066666666666667, 0.375
40502, 0.25, 0.05, 0.375
40503, 0.25, 0.066666666666667, 0.35416666666667
40504, 0.27083333333333, 0.066666666666667, 0.375
40505, 0.29166666666667, 0.05, 0.375
40506, 0.29166666666667, 0.066666666666667, 0.35416666666667
40507, 0.3125, 0.066666666666667, 0.375
40508, 0.33333333333333, 0.05, 0.375
40509, 0.33333333333333, 0.066666666666667, 0.35416666666667
40510, 0.35416666666667, 0.066666666666667, 0.375
40511, 0.375, 0.05, 0.375
40512, 0.375, 0.066666666666667, 0.35416666666667
40513, 0.39583333333333, 0.066666666666667, 0.375
40514, 0.41666666666667, 0.05, 0.375
40515, 0.41666666666667, 0.066666666666667, 0.35416666666667
40516, 0.4375, 0.066666666666667, 0.375
40517, 0.45833333333333, 0.05, 0.375
40518, 0.45833333333333, 0.066666666666667, 0.35416666666667
40519, 0.47916666666667, 0.066666666666667, 0.375
40520, 0.5, 0.05, 0.375
40521, 0.5, 0.066666666666667, 0.35416666666667
40522, 0.52083333333333, 0.066666666666667, 0.375
40523, 0.54166666666667, 0.05, 0.375
40524, 0.54166666666667, 0.066666666666667, 0.35416666666667
40525, 0.5625, 0.066666666666667, 0.375
40526, 0.58333333333333, 0.05, 0.375
40527, 0.58333333333333, 0.066666666666667, 0.35416666666667
40528, 0.60416666666667, 0.066666666666667, 0.375
40529, 0.625, 0.05, 0.375
40530, 0.625, 0.066666666666667, 0.35416666666667
40531, 0.64583333333333, 0.066666666666667, 0.375
40532, 0.66666666666667, 0.05, 0.375
40533, 0.66666666666667, 0.066666666666667, 0.35416666666667
40534, 0.6875, 0.066666666666667, 0.375
40535, 0.70833333333333, 0.05, 0.375
40536, 0.70833333333333, 0.066666666666667, 0.35416666666667
40537, 0.72916666666667, 0.066666666666667, 0.375
40538, 0.75, 0.05, 0.375
40539, 0.75, 0.066666666666667, 0.35416666666667
40540, 0.77083333333333, 0.066666666666667, 0.375
40541, 0.79166666666667, 0.05, 0.375
40542, 0.79166666666667, 0.066666666666667, 0.35416666666667
40543, 0.8125, 0.066666666666667, 0.375
40544, 0.83333333333333, 0.05, 0.375
40545, 0.83333333333333, 0.066666666666667, 0.35416666666667
40546, 0.85416666666667, 0.066666666666667, 0.375
40547, 0.875, 0.05, 0.375
40548, 0.875, 0.066666666666667, 0.35416666666667
40549, 0.89583333333333, 0.066666666666667, 0.375
40550, 0.91666666666667, 0.05, 0.375
40551, 0.91666666666667, 0.066666666666667, 0.35416666666667
40552, 0.9375, 0.066666666666667, 0.375
40553, 0.95833333333333, 0.05, 0.375
40554, 0.95833333333333, 0.066666666666667, 0.35416666666667
40555, 0.97916666666667, 0.066666666666667, 0.375
40556, 0.041666666666667, 0.083333333333333, 0.375
40557, 0.083333333333333, 0.083333333333333, 0.375
40558, 0.125, 0.083333333333333, 0.375
40559, 0.16666666666667, 0.083333333333333, 0.375
40560, 0.20833333333333, 0.083333333333333, 0.375
40561, 0.25, 0.083333333333333, 0.375
40562, 0.29166666666667, 0.083333333333333, 0.375
40563, 0.33333333333333, 0.083333333333333, 0.375
40564, 0.375, 0.083333333333333, 0.375
40565, 0.41666666666667, 0.083333333333333, 0.375
40566, 0.45833333333333, 0.083333333333333, 0.375
40567, 0.5, 0.083333333333333, 0.375
40568, 0.54166666666667, 0.083333333333333, 0.375
40569, 0.58333333333333, 0.083333333333333, 0.375
40570, 0.625, 0.083333333333333, 0.375
40571, 0.66666666666667, 0.083333333333333, 0.375
40572, 0.70833333333333, 0.083333333333333, 0.375
40573, 0.75, 0.083333333333333, 0.375
40574, 0.79166666666667, 0.083333333333333, 0.375
40575, 0.83333333333333, 0.083333333333333, 0.375
40576, 0.875, 0.083333333333333, 0.375
40577, 0.91666666666667, 0.083333333333333, 0.375
40578, 0.95833333333333, 0.083333333333333, 0.375
40579, 0.020833333333333, 0.033333333333333, 0.41666666666667
40580, 0.041666666666667, 0.016666666666667, 0.41666666666667
40581, 0.041666666666667, 0.033333333333333, 0.39583333333333
40582, 0.0625, 0.033333333333333, 0.41666666666667
40583, 0.083333333333333, 0.016666666666667, 0.41666666666667
40584, 0.083333333333333, 0.033333333333333, 0.39583333333333
40585, 0.10416666666667, 0.033333333333333, 0.41666666666667
40586, 0.125, 0.016666666666667, 0.41666666666667
40587, 0.125, 0.033333333333333, 0.39583333333333
40588, 0.14583333333333, 0.033333333333333, 0.41666666666667
40589, 0.16666666666667, 0.016666666666667, 0.41666666666667
40590, 0.16666666666667, 0.033333333333333, 0.39583333333333
40591, 0.1875, 0.033333333333333, 0.41666666666667
40592, 0.20833333333333, 0.016666666666667, 0.41666666666667
40593, 0.20833333333333, 0.033333333333333, 0.39583333333333
40594, 0.22916666666667, 0.033333333333333, 0.41666666666667
40595, 0.25, 0.016666666666667, 0.41666666666667
40596, 0.25, 0.033333333333333, 0.39583333333333
40597, 0.27083333333333, 0.033333333333333, 0.41666666666667
40598, 0.29166666666667, 0.016666666666667, 0.41666666666667
40599, 0.29166666666667, 0.033333333333333, 0.39583333333333
40600, 0.3125, 0.033333333333333, 0.41666666666667
40601, 0.33333333333333, 0.016666666666667, 0.41666666666667
40602, 0.33333333333333, 0.033333333333333, 0.39583333333333
40603, 0.35416666666667, 0.033333333333333, 0.41666666666667
40604, 0.375, 0.016666666666667, 0.41666666666667
40605, 0.375, 0.033333333333333, 0.39583333333333
40606, 0.39583333333333, 0.033333333333333, 0.41666666666667
40607, 0.41666666666667, 0.016666666666667, 0.41666666666667
40608, 0.41666666666667, 0.033333333333333, 0.39583333333333
40609, 0.4375, 0.033333333333333, 0.41666666666667
40610, 0.45833333333333, 0.016666666666667, 0.41666666666667
40611, 0.45833333333333, 0.033333333333333, 0.39583333333333
40612, 0.47916666666667, 0.033333333333333, 0.41666666666667
40613, 0.5, 0.016666666666667, 0.41666666666667
40614, 0.5, 0.033333333333333, 0.39583333333333
40615, 0.52083333333333, 0.033333333333333, 0.41666666666667
40616, 0.54166666666667, 0.016666666666667, 0.41666666666667
40617, 0.54166666666667, 0.033333333333333, 0.39583333333333
40618, 0.5625, 0.033333333333333, 0.41666666666667
40619, 0.58333333333333, 0.016666666666667, 0.41666666666667
40620, 0.58333333333333, 0.033333333333333, 0.39583333333333
40621, 0.60416666666667, 0.033333333333333, 0.41666666666667
40622, 0.625, 0.016666666666667, 0.41666666666667
40623, 0.625, 0.033333333333333, 0.39583333333333
40624, 0.64583333333333, 0.033333333333333, 0.41666666666667
40625, 0.66666666666667, 0.016666666666667, 0.41666666666667
40626, 0.66666666666667, 0.033333333333333, 0.39583333333333
40627, 0.6875, 0.033333333333333, 0.41666666666667
40628, 0.70833333333333, 0.016666666666667, 0.41666666666667
40629, 0.70833333333333, 0.033333333333333, 0.39583333333333
40630, 0.72916666666667, 0.033333333333333, 0.41666666666667
40631, 0.75, 0.016666666666667, 0.41666666666667
40632, 0.75, 0.033333333333333, 0.39583333333333
40633, 0.77083333333333, 0.033333333333333, 0.41666666666667
40634, 0.79166666666667, 0.016666666666667, 0.41666666666667
40635, 0.79166666666667, 0.033333333333333, 0.39583333333333
40636, 0.8125, 0.033333333333333, 0.41666666666667
40637, 0.83333333333333, 0.016666666666667, 0.41666666666667
40638, 0.83333333333333, 0.033333333333333, 0.39583333333333
40639, 0.85416666666667, 0.033333333333333, 0.41666666666667
40640, 0.875, 0.016666666666667, 0.41666666666667
40641, 0.875, 0.033333333333333, 0.39583333333333
40642, 0.89583333333333, 0.033333333333333, 0.41666666666667
40643, 0.91666666666667, 0.016666666666667, 0.41666666666667
40644, 0.91666666666667, 0.033333333333333, 0.39583333333333
40645, 0.9375, 0.033333333333333, 0.41666666666667
40646, 0.95833333333333, 0.016666666666667, 0.41666666666667
40647, 0.95833333333333, 0.033333333333333, 0.39583333333333
40648, 0.97916666666667, 0.033333333333333, 0.41666666666667
40649, 0.020833333333333, 0.066666666666667, 0.41666666666667
40650, 0.041666666666667, 0.05, 0.41666666666667
40651, 0.041666666666667, 0.066666666666667, 0.39583333333333
40652, 0.0625, 0.066666666666667, 0.41666666666667
40653, 0.083333333333333, 0.05, 0.41666666666667
40654, 0.083333333333333, 0.066666666666667, 0.39583333333333
40655, 0.10416666666667, 0.066666666666667, 0.41666666666667
40656, 0.125, 0.05, 0.41666666666667
40657, 0.125, 0.066666666666667, 0.39583333333333
40658, 0.14583333333333, 0.066666666666667, 0.41666666666667
40659, 0.16666666666667, 0.05, 0.41666666666667
40660, 0.16666666666667, 0.066666666666667, 0.39583333333333
40661, 0.1875, 0.066666666666667, 0.41666666666667
40662, 0.20833333333333, 0.05, 0.41666666666667
40663, 0.20833333333333, 0.066666666666667, 0.39583333333333
40664, 0.22916666666667, 0.066666666666667, 0.41666666666667
40665, 0.25, 0.05, 0.41666666666667
40666, 0.25, 0.066666666666667, 0.39583333333333
40667, 0.27083333333333, 0.066666666666667, 0.41666666666667
40668, 0.29166666666667, 0.05, 0.41666666666667
40669, 0.29166666666667, 0.066666666666667, 0.39583333333333
40670, 0.3125, 0.066666666666667, 0.41666666666667
40671, 0.33333333333333, 0.05, 0.41666666666667
40672, 0.33333333333333, 0.066666666666667, 0.39583333333333
40673, 0.35416666666667, 0.066666666666667, 0.41666666666667
40674, 0.375, 0.05, 0.41666666666667
40675, 0.375, 0.066666666666667, 0.39583333333333
40676, 0.39583333333333, 0.066666666666667, 0.41666666666667
40677, 0.41666666666667, 0.05, 0.41666666666667
40678, 0.41666666666667, 0.066666666666667, 0.39583333333333
40679, 0.4375, 0.066666666666667, 0.41666666666667
40680, 0.45833333333333, 0.05, 0.41666666666667
40681, 0.45833333333333, 0.066666666666667, 0.39583333333333
40682, 0.47916666666667, 0.066666666666667, 0.41666666666667
40683, 0.5, 0.05, 0.41666666666667
40684, 0.5, 0.066666666666667, 0.39583333333333
40685, 0.52083333333333, 0.066666666666667, 0.41666666666667
40686, 0.54166666666667, 0.05, 0.41666666666667
40687, 0.54166666666667, 0.066666666666667, 0.39583333333333
40688, 0.5625, 0.066666666666667, 0.41666666666667
40689, 0.58333333333333, 0.05, 0.41666666666667
40690, 0.58333333333333, 0.066666666666667, 0.39583333333333
40691, 0.60416666666667, 0.066666666666667, 0.41666666666667
40692, 0.625, 0.05, 0.41666666666667
40693, 0.625, 0.066666666666667, 0.39583333333333
40694, 0.64583333333333, 0.066666666666667, 0.41666666666667
40695, 0.66666666666667, 0.05, 0.41666666666667
40696, 0.66666666666667, 0.066666666666667, 0.39583333333333
40697, 0.6875, 0.066666666666667, 0.41666666666667
40698, 0.70833333333333, 0.05, 0.41666666666667
40699, 0.70833333333333, 0.066666666666667, 0.39583333333333
40700, 0.72916666666667, 0.066666666666667, 0.41666666666667
40701, 0.75, 0.05, 0.41666666666667
40702, 0.75, 0.066666666666667, 0.39583333333333
40703, 0.77083333333333, 0.066666666666667, 0.41666666666667
40704, 0.79166666666667, 0.05, 0.41666666666667
40705, 0.79166666666667, 0.066666666666667, 0.39583333333333
40706, 0.8125, 0.066666666666667, 0.41666666666667
40707, 0.83333333333333, 0.05, 0.41666666666667
40708, 0.83333333333333, 0.066666666666667, 0.39583333333333
40709, 0.85416666666667, 0.066666666666667, 0.41666666666667
40710, 0.875, 0.05, 0.41666666666667
40711, 0.875, 0.066666666666667, 0.39583333333333
40712, 0.89583333333333, 0.066666666666667, 0.41666666666667
40713, 0.91666666666667, 0.05, 0.41666666666667
40714, 0.91666666666667, 0.066666666666667, 0.39583333333333
40715, 0.9375, 0.066666666666667, 0.41666666666667
40716, 0.95833333333333, 0.05, 0.41666666666667
40717, 0.95833333333333, 0.066666666666667, 0.39583333333333
40718, 0.97916666666667, 0.066666666666667, 0.41666666666667
40719, 0.041666666666667, 0.083333333333333, 0.41666666666667
40720, 0.083333333333333, 0.083333333333333, 0.41666666666667
40721, 0.125, 0.083333333333333, 0.41666666666667
40722, 0.16666666666667, 0.083333333333333, 0.41666666666667
40723, 0.20833333333333, 0.083333333333333, 0.41666666666667
40724, 0.25, 0.083333333333333, 0.41666666666667
40725, 0.29166666666667, 0.083333333333333, 0.41666666666667
40726, 0.33333333333333, 0.083333333333333, 0.41666666666667
40727, 0.375, 0.083333333333333, 0.41666666666667
40728, 0.41666666666667, 0.083333333333333, 0.41666666666667
40729, 0.45833333333333, 0.083333333333333, 0.41666666666667
40730, 0.5, 0.083333333333333, 0.41666666666667
40731, 0.54166666666667, 0.083333333333333, 0.41666666666667
40732, 0.58333333333333, 0.083333333333333, 0.41666666666667
40733, 0.625, 0.083333333333333, 0.41666666666667
40734, 0.66666666666667, 0.083333333333333, 0.41666666666667
40735, 0.70833333333333, 0.083333333333333, 0.41666666666667
40736, 0.75, 0.083333333333333, 0.41666666666667
40737, 0.79166666666667, 0.083333333333333, 0.41666666666667
40738, 0.83333333333333, 0.083333333333333, 0.41666666666667
40739, 0.875, 0.083333333333333, 0.41666666666667
40740, 0.91666666666667, 0.083333333333333, 0.41666666666667
40741, 0.95833333333333, 0.083333333333333, 0.41666666666667
40742, 0.020833333333333, 0.033333333333333, 0.45833333333333
40743, 0.041666666666667, 0.016666666666667, 0.45833333333333
40744, 0.041666666666667, 0.033333333333333, 0.4375
40745, 0.0625, 0.033333333333333, 0.45833333333333
40746, 0.083333333333333, 0.016666666666667, 0.45833333333333
40747, 0.083333333333333, 0.033333333333333, 0.4375
40748, 0.10416666666667, 0.033333333333333, 0.45833333333333
40749, 0.125, 0.016666666666667, 0.45833333333333
40750, 0.125, 0.033333333333333, 0.4375
40751, 0.14583333333333, 0.033333333333333, 0.45833333333333
40752, 0.16666666666667, 0.016666666666667, 0.45833333333333
40753, 0.16666666666667, 0.033333333333333, 0.4375
40754, 0.1875, 0.033333333333333, 0.45833333333333
40755, 0.20833333333333, 0.016666666666667, 0.45833333333333
40756, 0.20833333333333, 0.033333333333333, 0.4375
40757, 0.22916666666667, 0.033333333333333, 0.45833333333333
40758, 0.25, 0.016666666666667, 0.45833333333333
40759, 0.25, 0.033333333333333, 0.4375
40760, 0.27083333333333, 0.033333333333333, 0.45833333333333
40761, 0.29166666666667, 0.016666666666667, 0.45833333333333
40762, 0.29166666666667, 0.033333333333333, 0.4375
40763, 0.3125, 0.033333333333333, 0.45833333333333
40764, 0.33333333333333, 0.016666666666667, 0.45833333333333
40765, 0.33333333333333, 0.033333333333333, 0.4375
40766, 0.35416666666667, 0.033333333333333, 0.45833333333333
40767, 0.375, 0.016666666666667, 0.45833333333333
40768, 0.375, 0.033333333333333, 0.4375
40769, 0.39583333333333, 0.033333333333333, 0.45833333333333
40770, 0.41666666666667, 0.016666666666667, 0.45833333333333
40771, 0.41666666666667, 0.033333333333333, 0.4375
40772, 0.4375, 0.033333333333333, 0.45833333333333
40773, 0.45833333333333, 0.016666666666667, 0.45833333333333
40774, 0.45833333333333, 0.033333333333333, 0.4375
40775, 0.47916666666667, 0.033333333333333, 0.45833333333333
40776, 0.5, 0.016666666666667, 0.45833333333333
40777, 0.5, 0.033333333333333, 0.4375
40778, 0.52083333333333, 0.033333333333333, 0.45833333333333
40779, 0.54166666666667, 0.016666666666667, 0.45833333333333
40780, 0.54166666666667, 0.033333333333333, 0.4375
40781, 0.5625, 0.033333333333333, 0.45833333333333
40782, 0.58333333333333, 0.016666666666667, 0.45833333333333
40783, 0.58333333333333, 0.033333333333333, 0.4375
40784, 0.60416666666667, 0.033333333333333, 0.45833333333333
40785, 0.625, 0.016666666666667, 0.45833333333333
40786, 0.625, 0.033333333333333, 0.4375
40787, 0.64583333333333, 0.033333333333333, 0.45833333333333
40788, 0.66666666666667, 0.016666666666667, 0.45833333333333
40789, 0.66666666666667, 0.033333333333333, 0.4375
40790, 0.6875, 0.033333333333333, 0.45833333333333
40791, 0.70833333333333, 0.016666666666667, 0.45833333333333
40792, 0.70833333333333, 0.033333333333333, 0.4375
40793, 0.72916666666667, 0.033333333333333, 0.45833333333333
40794, 0.75, 0.016666666666667, 0.45833333333333
40795, 0.75, 0.033333333333333, 0.4375
40796, 0.77083333333333, 0.033333333333333, 0.45833333333333
40797, 0.79166666666667, 0.016666666666667, 0.45833333333333
40798, 0.79166666666667, 0.033333333333333, 0.4375
40799, 0.8125, 0.033333333333333, 0.45833333333333
40800, 0.83333333333333, 0.016666666666667, 0.45833333333333
40801, 0.83333333333333, 0.033333333333333, 0.4375
40802, 0.85416666666667, 0.033333333333333, 0.45833333333333
40803, 0.875, 0.016666666666667, 0.45833333333333
40804, 0.875, 0.033333333333333, 0.4375
40805, 0.89583333333333, 0.033333333333333, 0.45833333333333
40806, 0.91666666666667, 0.016666666666667, 0.45833333333333
40807, 0.91666666666667, 0.033333333333333, 0.4375
40808, 0.9375, 0.033333333333333, 0.45833333333333
40809, 0.95833333333333, 0.016666666666667, 0.45833333333333
40810, 0.95833333333333, 0.033333333333333, 0.4375
40811, 0.97916666666667, 0.033333333333333, 0.45833333333333
40812, 0.020833333333333, 0.066666666666667, 0.45833333333333
40813, 0.041666666666667, 0.05, 0.45833333333333
40814, 0.041666666666667, 0.066666666666667, 0.4375
40815, 0.0625, 0.066666666666667, 0.45833333333333
40816, 0.083333333333333, 0.05, 0.45833333333333
40817, 0.083333333333333, 0.066666666666667, 0.4375
40818, 0.10416666666667, 0.066666666666667, 0.45833333333333
40819, 0.125, 0.05, 0.45833333333333
40820, 0.125, 0.066666666666667, 0.4375
40821, 0.14583333333333, 0.066666666666667, 0.45833333333333
40822, 0.16666666666667, 0.05, 0.45833333333333
40823, 0.16666666666667, 0.066666666666667, 0.4375
40824, 0.1875, 0.066666666666667, 0.45833333333333
40825, 0.20833333333333, 0.05, 0.45833333333333
40826, 0.20833333333333, 0.066666666666667, 0.4375
40827, 0.22916666666667, 0.066666666666667, 0.45833333333333
40828, 0.25, 0.05, 0.45833333333333
40829, 0.25, 0.066666666666667, 0.4375
40830, 0.27083333333333, 0.066666666666667, 0.45833333333333
40831, 0.29166666666667, 0.05, 0.45833333333333
40832, 0.29166666666667, 0.066666666666667, 0.4375
40833, 0.3125, 0.066666666666667, 0.45833333333333
40834, 0.33333333333333, 0.05, 0.45833333333333
40835, 0.33333333333333, 0.066666666666667, 0.4375
40836, 0.35416666666667, 0.066666666666667, 0.45833333333333
40837, 0.375, 0.05, 0.45833333333333
40838, 0.375, 0.066666666666667, 0.4375
40839, 0.39583333333333, 0.066666666666667, 0.45833333333333
40840, 0.41666666666667, 0.05, 0.45833333333333
40841, 0.41666666666667, 0.066666666666667, 0.4375
40842, 0.4375, 0.066666666666667, 0.45833333333333
40843, 0.45833333333333, 0.05, 0.45833333333333
40844, 0.45833333333333, 0.066666666666667, 0.4375
40845, 0.47916666666667, 0.066666666666667, 0.45833333333333
40846, 0.5, 0.05, 0.45833333333333
40847, 0.5, 0.066666666666667, 0.4375
40848, 0.52083333333333, 0.066666666666667, 0.45833333333333
40849, 0.54166666666667, 0.05, 0.45833333333333
40850, 0.54166666666667, 0.066666666666667, 0.4375
40851, 0.5625, 0.066666666666667, 0.45833333333333
40852, 0.58333333333333, 0.05, 0.45833333333333
40853, 0.58333333333333, 0.066666666666667, 0.4375
40854, 0.60416666666667, 0.066666666666667, 0.45833333333333
40855, 0.625, 0.05, 0.45833333333333
40856, 0.625, 0.066666666666667, 0.4375
40857, 0.64583333333333, 0.066666666666667, 0.45833333333333
40858, 0.66666666666667, 0.05, 0.45833333333333
40859, 0.66666666666667, 0.066666666666667, 0.4375
40860, 0.6875, 0.066666666666667, 0.45833333333333
40861, 0.70833333333333, 0.05, 0.45833333333333
40862, 0.70833333333333, 0.066666666666667, 0.4375
40863, 0.72916666666667, 0.066666666666667, 0.45833333333333
40864, 0.75, 0.05, 0.45833333333333
40865, 0.75, 0.066666666666667, 0.4375
40866, 0.77083333333333, 0.066666666666667, 0.45833333333333
40867, 0.79166666666667, 0.05, 0.45833333333333
40868, 0.79166666666667, 0.066666666666667, 0.4375
40869, 0.8125, 0.066666666666667, 0.45833333333333
40870, 0.83333333333333, 0.05, 0.45833333333333
40871, 0.83333333333333, 0.066666666666667, 0.4375
40872, 0.85416666666667, 0.066666666666667, 0.45833333333333
40873, 0.875, 0.05, 0.45833333333333
40874, 0.875, 0.066666666666667, 0.4375
40875, 0.89583333333333, 0.066666666666667, 0.45833333333333
40876, 0.91666666666667, 0.05, 0.45833333333333
40877, 0.91666666666667, 0.066666666666667, 0.4375
40878, 0.9375, 0.066666666666667, 0.45833333333333
40879, 0.95833333333333, 0.05, 0.45833333333333
40880, 0.95833333333333, 0.066666666666667, 0.4375
40881, 0.97916666666667, 0.066666666666667, 0.45833333333333
40882, 0.041666666666667, 0.083333333333333, 0.45833333333333
40883, 0.083333333333333, 0.083333333333333, 0.45833333333333
40884, 0.125, 0.083333333333333, 0.45833333333333
40885, 0.16666666666667, 0.083333333333333, 0.45833333333333
40886, 0.20833333333333, 0.083333333333333, 0.45833333333333
40887, 0.25, 0.083333333333333, 0.45833333333333
40888, 0.29166666666667, 0.083333333333333, 0.45833333333333
40889, 0.33333333333333, 0.083333333333333, 0.45833333333333
40890, 0.375, 0.083333333333333, 0.45833333333333
40891, 0.41666666666667, 0.083333333333333, 0.45833333333333
40892, 0.45833333333333, 0.083333333333333, 0.45833333333333
40893, 0.5, 0.083333333333333, 0.45833333333333
40894, 0.54166666666667, 0.083333333333333, 0.45833333333333
40895, 0.58333333333333, 0.083333333333333, 0.45833333333333
40896, 0.625, 0.083333333333333, 0.45833333333333
40897, 0.66666666666667, 0.083333333333333, 0.45833333333333
40898, 0.70833333333333, 0.083333333333333, 0.45833333333333
40899, 0.75, 0.083333333333333, 0.45833333333333
40900, 0.79166666666667, 0.083333333333333, 0.45833333333333
40901, 0.83333333333333, 0.083333333333333, 0.45833333333333
40902, 0.875, 0.083333333333333, 0.45833333333333
40903, 0.91666666666667, 0.083333333333333, 0.45833333333333
40904, 0.95833333333333, 0.083333333333333, 0.45833333333333
40905, 0.041666666666667, 0.033333333333333, 0.47916666666667
40906, 0.083333333333333, 0.033333333333333, 0.47916666666667
40907, 0.125, 0.033333333333333, 0.47916666666667
40908, 0.16666666666667, 0.033333333333333, 0.47916666666667
40909, 0.20833333333333, 0.033333333333333, 0.47916666666667
40910, 0.25, 0.033333333333333, 0.47916666666667
40911, 0.29166666666667, 0.033333333333333, 0.47916666666667
40912, 0.33333333333333, 0.033333333333333, 0.47916666666667
40913, 0.375, 0.033333333333333, 0.47916666666667
40914, 0.41666666666667, 0.033333333333333, 0.47916666666667
40915, 0.45833333333333, 0.033333333333333, 0.47916666666667
40916, 0.5, 0.033333333333333, 0.47916666666667
40917, 0.54166666666667, 0.033333333333333, 0.47916666666667
40918, 0.58333333333333, 0.033333333333333, 0.47916666666667
40919, 0.625, 0.033333333333333, 0.47916666666667
40920, 0.66666666666667, 0.033333333333333, 0.47916666666667
40921, 0.70833333333333, 0.033333333333333, 0.47916666666667
40922, 0.75, 0.033333333333333, 0.47916666666667
40923, 0.79166666666667, 0.033333333333333, 0.47916666666667
40924, 0.83333333333333, 0.033333333333333, 0.47916666666667
40925, 0.875, 0.033333333333333, 0.47916666666667
40926, 0.91666666666667, 0.033333333333333, 0.47916666666667
40927, 0.95833333333333, 0.033333333333333, 0.47916666666667
40928, 0.041666666666667, 0.066666666666667, 0.47916666666667
40929, 0.083333333333333, 0.066666666666667, 0.47916666666667
40930, 0.125, 0.066666666666667, 0.47916666666667
40931, 0.16666666666667, 0.066666666666667, 0.47916666666667
40932, 0.20833333333333, 0.066666666666667, 0.47916666666667
40933, 0.25, 0.066666666666667, 0.47916666666667
40934, 0.29166666666667, 0.066666666666667, 0.47916666666667
40935, 0.33333333333333, 0.066666666666667, 0.47916666666667
40936, 0.375, 0.066666666666667, 0.47916666666667
40937, 0.41666666666667, 0.066666666666667, 0.47916666666667
40938, 0.45833333333333, 0.066666666666667, 0.47916666666667
40939, 0.5, 0.066666666666667, 0.47916666666667
40940, 0.54166666666667, 0.066666666666667, 0.47916666666667
40941, 0.58333333333333, 0.066666666666667, 0.47916666666667
40942, 0.625, 0.066666666666667, 0.47916666666667
40943, 0.66666666666667, 0.066666666666667, 0.47916666666667
40944, 0.70833333333333, 0.066666666666667, 0.47916666666667
40945, 0.75, 0.066666666666667, 0.47916666666667
40946, 0.79166666666667, 0.066666666666667, 0.47916666666667
40947, 0.83333333333333, 0.066666666666667, 0.47916666666667
40948, 0.875, 0.066666666666667, 0.47916666666667
40949, 0.91666666666667, 0.066666666666667, 0.47916666666667
40950, 0.95833333333333, 0.066666666666667, 0.47916666666667
40951, 0.041666666666667, 0.125, 0.041666666666667
40952, 0.041666666666667, 0.125, 0.083333333333333
40953, 0.041666666666667, 0.125, 0.125
40954, 0.041666666666667, 0.125, 0.16666666666667
40955, 0.041666666666667, 0.125, 0.20833333333333
40956, 0.041666666666667, 0.125, 0.25
40957, 0.041666666666667, 0.125, 0.29166666666667
40958, 0.041666666666667, 0.125, 0.33333333333333
40959, 0.041666666666667, 0.125, 0.375
40960, 0.041666666666667, 0.125, 0.41666666666667
40961, 0.041666666666667, 0.125, 0.45833333333333
40962, 0.083333333333333, 0.125, 0.041666666666667
40963, 0.083333333333333, 0.125, 0.083333333333333
40964, 0.083333333333333, 0.125, 0.125
40965, 0.083333333333333, 0.125, 0.16666666666667
40966, 0.083333333333333, 0.125, 0.20833333333333
40967, 0.083333333333333, 0.125, 0.25
40968, 0.083333333333333, 0.125, 0.29166666666667
40969, 0.083333333333333, 0.125, 0.33333333333333
40970, 0.083333333333333, 0.125, 0.375
40971, 0.083333333333333, 0.125, 0.41666666666667
40972, 0.083333333333333, 0.125, 0.45833333333333
40973, 0.125, 0.125, 0.041666666666667
40974, 0.125, 0.125, 0.083333333333333
40975, 0.125, 0.125, 0.125
40976, 0.125, 0.125, 0.16666666666667
40977, 0.125, 0.125, 0.20833333333333
40978, 0.125, 0.125, 0.25
40979, 0.125, 0.125, 0.29166666666667
40980, 0.125, 0.125, 0.33333333333333
40981, 0.125, 0.125, 0.375
40982, 0.125, 0.125, 0.41666666666667
40983, 0.125, 0.125, 0.45833333333333
40984, 0.16666666666667, 0.125, 0.041666666666667
40985, 0.16666666666667, 0.125, 0.083333333333333
40986, 0.16666666666667, 0.125, 0.125
40987, 0.16666666666667, 0.125, 0.16666666666667
40988, 0.16666666666667, 0.125, 0.20833333333333
40989, 0.16666666666667, 0.125, 0.25
40990, 0.16666666666667, 0.125, 0.29166666666667
40991, 0.16666666666667, 0.125, 0.33333333333333
40992, 0.16666666666667, 0.125, 0.375
40993, 0.16666666666667, 0.125, 0.41666666666667
40994, 0.16666666666667, 0.125, 0.45833333333333
40995, 0.20833333333333, 0.125, 0.041666666666667
40996, 0.20833333333333, 0.125, 0.083333333333333
40997, 0.20833333333333, 0.125, 0.125
40998, 0.20833333333333, 0.125, 0.16666666666667
40999, 0.20833333333333, 0.125, 0.20833333333333
41000, 0.20833333333333, 0.125, 0.25
41001, 0.20833333333333, 0.125, 0.29166666666667
41002, 0.20833333333333, 0.125, 0.33333333333333
41003, 0.20833333333333, 0.125, 0.375
41004, 0.20833333333333, 0.125, 0.41666666666667
41005, 0.20833333333333, 0.125, 0.45833333333333
41006, 0.25, 0.125, 0.041666666666667
41007, 0.25, 0.125, 0.083333333333333
41008, 0.25, 0.125, 0.125
41009, 0.25, 0.125, 0.16666666666667
41010, 0.25, 0.125, 0.20833333333333
41011, 0.25, 0.125, 0.25
41012, 0.25, 0.125, 0.29166666666667
41013, 0.25, 0.125, 0.33333333333333
41014, 0.25, 0.125, 0.375
41015, 0.25, 0.125, 0.41666666666667
41016, 0.25, 0.125, 0.45833333333333
41017, 0.29166666666667, 0.125, 0.041666666666667
41018, 0.29166666666667, 0.125, 0.083333333333333
41019, 0.29166666666667, 0.125, 0.125
41020, 0.29166666666667, 0.125, 0.16666666666667
41021, 0.29166666666667, 0.125, 0.20833333333333
41022, 0.29166666666667, 0.125, 0.25
41023, 0.29166666666667, 0.125, 0.29166666666667
41024, 0.29166666666667, 0.125, 0.33333333333333
41025, 0.29166666666667, 0.125, 0.375
41026, 0.29166666666667, 0.125, 0.41666666666667
41027, 0.29166666666667, 0.125, 0.45833333333333
41028, 0.33333333333333, 0.125, 0.041666666666667
41029, 0.33333333333333, 0.125, 0.083333333333333
41030, 0.33333333333333, 0.125, 0.125
41031, 0.33333333333333, 0.125, 0.16666666666667
41032, 0.33333333333333, 0.125, 0.20833333333333
41033, 0.33333333333333, 0.125, 0.25
41034, 0.33333333333333, 0.125, 0.29166666666667
41035, 0.33333333333333, 0.125, 0.33333333333333
41036, 0.33333333333333, 0.125, 0.375
41037, 0.33333333333333, 0.125, 0.41666666666667
41038, 0.33333333333333, 0.125, 0.45833333333333
41039, 0.375, 0.125, 0.041666666666667
41040, 0.375, 0.125, 0.083333333333333
41041, 0.375, 0.125, 0.125
41042, 0.375, 0.125, 0.16666666666667
41043, 0.375, 0.125, 0.20833333333333
41044, 0.375, 0.125, 0.25
41045, 0.375, 0.125, 0.29166666666667
41046, 0.375, 0.125, 0.33333333333333
41047, 0.375, 0.125, 0.375
41048, 0.375, 0.125, 0.41666666666667
41049, 0.375, 0.125, 0.45833333333333
41050, 0.41666666666667, 0.125, 0.041666666666667
41051, 0.41666666666667, 0.125, 0.083333333333333
41052, 0.41666666666667, 0.125, 0.125
41053, 0.41666666666667, 0.125, 0.16666666666667
41054, 0.41666666666667, 0.125, 0.20833333333333
41055, 0.41666666666667, 0.125, 0.25
41056, 0.41666666666667, 0.125, 0.29166666666667
41057, 0.41666666666667, 0.125, 0.33333333333333
41058, 0.41666666666667, 0.125, 0.375
41059, 0.41666666666667, 0.125, 0.41666666666667
41060, 0.41666666666667, 0.125, 0.45833333333333
41061, 0.45833333333333, 0.125, 0.041666666666667
41062, 0.45833333333333, 0.125, 0.083333333333333
41063, 0.45833333333333, 0.125, 0.125
41064, 0.45833333333333, 0.125, 0.16666666666667
41065, 0.45833333333333, 0.125, 0.20833333333333
41066, 0.45833333333333, 0.125, 0.25
41067, 0.45833333333333, 0.125, 0.29166666666667
41068, 0.45833333333333, 0.125, 0.33333333333333
41069, 0.45833333333333, 0.125, 0.375
41070, 0.45833333333333, 0.125, 0.41666666666667
41071, 0.45833333333333, 0.125, 0.45833333333333
41072, 0.5, 0.125, 0.041666666666667
41073, 0.5, 0.125, 0.083333333333333
41074, 0.5, 0.125, 0.125
41075, 0.5, 0.125, 0.16666666666667
41076, 0.5, 0.125, 0.20833333333333
41077, 0.5, 0.125, 0.25
41078, 0.5, 0.125, 0.29166666666667
41079, 0.5, 0.125, 0.33333333333333
41080, 0.5, 0.125, 0.375
41081, 0.5, 0.125, 0.41666666666667
41082, 0.5, 0.125, 0.45833333333333
41083, 0.54166666666667, 0.125, 0.041666666666667
41084, 0.54166666666667, 0.125, 0.083333333333333
41085, 0.54166666666667, 0.125, 0.125
41086, 0.54166666666667, 0.125, 0.16666666666667
41087, 0.54166666666667, 0.125, 0.20833333333333
41088, 0.54166666666667, 0.125, 0.25
41089, 0.54166666666667, 0.125, 0.29166666666667
41090, 0.54166666666667, 0.125, 0.33333333333333
41091, 0.54166666666667, 0.125, 0.375
41092, 0.54166666666667, 0.125, 0.41666666666667
41093, 0.54166666666667, 0.125, 0.45833333333333
41094, 0.58333333333333, 0.125, 0.041666666666667
41095, 0.58333333333333, 0.125, 0.083333333333333
41096, 0.58333333333333, 0.125, 0.125
41097, 0.58333333333333, 0.125, 0.16666666666667
41098, 0.58333333333333, 0.125, 0.20833333333333
41099, 0.58333333333333, 0.125, 0.25
41100, 0.58333333333333, 0.125, 0.29166666666667
41101, 0.58333333333333, 0.125, 0.33333333333333
41102, 0.58333333333333, 0.125, 0.375
41103, 0.58333333333333, 0.125, 0.41666666666667
41104, 0.58333333333333, 0.125, 0.45833333333333
41105, 0.625, 0.125, 0.041666666666667
41106, 0.625, 0.125, 0.083333333333333
41107, 0.625, 0.125, 0.125
41108, 0.625, 0.125, 0.16666666666667
41109, 0.625, 0.125, 0.20833333333333
41110, 0.625, 0.125, 0.25
41111, 0.625, 0.125, 0.29166666666667
41112, 0.625, 0.125, 0.33333333333333
41113, 0.625, 0.125, 0.375
41114, 0.625, 0.125, 0.41666666666667
41115, 0.625, 0.125, 0.45833333333333
41116, 0.66666666666667, 0.125, 0.041666666666667
41117, 0.66666666666667, 0.125, 0.083333333333333
41118, 0.66666666666667, 0.125, 0.125
41119, 0.66666666666667, 0.125, 0.16666666666667
41120, 0.66666666666667, 0.125, 0.20833333333333
41121, 0.66666666666667, 0.125, 0.25
41122, 0.66666666666667, 0.125, 0.29166666666667
41123, 0.66666666666667, 0.125, 0.33333333333333
41124, 0.66666666666667, 0.125, 0.375
41125, 0.66666666666667, 0.125, 0.41666666666667
41126, 0.66666666666667, 0.125, 0.45833333333333
41127, 0.70833333333333, 0.125, 0.041666666666667
41128, 0.70833333333333, 0.125, 0.083333333333333
41129, 0.70833333333333, 0.125, 0.125
41130, 0.70833333333333, 0.125, 0.16666666666667
41131, 0.70833333333333, 0.125, 0.20833333333333
41132, 0.70833333333333, 0.125, 0.25
41133, 0.70833333333333, 0.125, 0.29166666666667
41134, 0.70833333333333, 0.125, 0.33333333333333
41135, 0.70833333333333, 0.125, 0.375
41136, 0.70833333333333, 0.125, 0.41666666666667
41137, 0.70833333333333, 0.125, 0.45833333333333
41138, 0.75, 0.125, 0.041666666666667
41139, 0.75, 0.125, 0.083333333333333
41140, 0.75, 0.125, 0.125
41141, 0.75, 0.125, 0.16666666666667
41142, 0.75, 0.125, 0.20833333333333
41143, 0.75, 0.125, 0.25
41144, 0.75, 0.125, 0.29166666666667
41145, 0.75, 0.125, 0.33333333333333
41146, 0.75, 0.125, 0.375
41147, 0.75, 0.125, 0.41666666666667
41148, 0.75, 0.125, 0.45833333333333
41149, 0.79166666666667, 0.125, 0.041666666666667
41150, 0.79166666666667, 0.125, 0.083333333333333
41151, 0.79166666666667, 0.125, 0.125
41152, 0.79166666666667, 0.125, 0.16666666666667
41153, 0.79166666666667, 0.125, 0.20833333333333
41154, 0.79166666666667, 0.125, 0.25
41155, 0.79166666666667, 0.125, 0.29166666666667
41156, 0.79166666666667, 0.125, 0.33333333333333
41157, 0.79166666666667, 0.125, 0.375
41158, 0.79166666666667, 0.125, 0.41666666666667
41159, 0.79166666666667, 0.125, 0.45833333333333
41160, 0.83333333333333, 0.125, 0.041666666666667
41161, 0.83333333333333, 0.125, 0.083333333333333
41162, 0.83333333333333, 0.125, 0.125
41163, 0.83333333333333, 0.125, 0.16666666666667
41164, 0.83333333333333, 0.125, 0.20833333333333
41165, 0.83333333333333, 0.125, 0.25
41166, 0.83333333333333, 0.125, 0.29166666666667
41167, 0.83333333333333, 0.125, 0.33333333333333
41168, 0.83333333333333, 0.125, 0.375
41169, 0.83333333333333, 0.125, 0.41666666666667
41170, 0.83333333333333, 0.125, 0.45833333333333
41171, 0.875, 0.125, 0.041666666666667
41172, 0.875, 0.125, 0.083333333333333
41173, 0.875, 0.125, 0.125
41174, 0.875, 0.125, 0.16666666666667
41175, 0.875, 0.125, 0.20833333333333
41176, 0.875, 0.125, 0.25
41177, 0.875, 0.125, 0.29166666666667
41178, 0.875, 0.125, 0.33333333333333
41179, 0.875, 0.125, 0.375
41180, 0.875, 0.125, 0.41666666666667
41181, 0.875, 0.125, 0.45833333333333
41182, 0.91666666666667, 0.125, 0.041666666666667
41183, 0.91666666666667, 0.125, 0.083333333333333
41184, 0.91666666666667, 0.125, 0.125
41185, 0.91666666666667, 0.125, 0.16666666666667
41186, 0.91666666666667, 0.125, 0.20833333333333
41187, 0.91666666666667, 0.125, 0.25
41188, 0.91666666666667, 0.125, 0.29166666666667
41189, 0.91666666666667, 0.125, 0.33333333333333
41190, 0.91666666666667, 0.125, 0.375
41191, 0.91666666666667, 0.125, 0.41666666666667
41192, 0.91666666666667, 0.125, 0.45833333333333
41193, 0.95833333333333, 0.125, 0.041666666666667
41194, 0.95833333333333, 0.125, 0.083333333333333
41195, 0.95833333333333, 0.125, 0.125
41196, 0.95833333333333, 0.125, 0.16666666666667
41197, 0.95833333333333, 0.125, 0.20833333333333
41198, 0.95833333333333, 0.125, 0.25
41199, 0.95833333333333, 0.125, 0.29166666666667
41200, 0.95833333333333, 0.125, 0.33333333333333
41201, 0.95833333333333, 0.125, 0.375
41202, 0.95833333333333, 0.125, 0.41666666666667
41203, 0.95833333333333, 0.125, 0.45833333333333
41204, 0.041666666666667, 0.2, 0.041666666666667
41205, 0.041666666666667, 0.25, 0.041666666666667
41206, 0.041666666666667, 0.3, 0.041666666666667
41207, 0.041666666666667, 0.35, 0.041666666666667
41208, 0.041666666666667, 0.4, 0.041666666666667
41209, 0.041666666666667, 0.45, 0.041666666666667
41210, 0.041666666666667, 0.5, 0.041666666666667
41211, 0.041666666666667, 0.55, 0.041666666666667
41212, 0.041666666666667, 0.6, 0.041666666666667
41213, 0.041666666666667, 0.65, 0.041666666666667
41214, 0.041666666666667, 0.7, 0.041666666666667
41215, 0.041666666666667, 0.75, 0.041666666666667
41216, 0.041666666666667, 0.8, 0.041666666666667
41217, 0.041666666666667, 0.85, 0.041666666666667
41218, 0.041666666666667, 0.9, 0.041666666666667
41219, 0.041666666666667, 0.95, 0.041666666666667
41220, 0.041666666666667, 1, 0.041666666666667
41221, 0.041666666666667, 1.05, 0.041666666666667
41222, 0.041666666666667, 1.1, 0.041666666666667
41223, 0.041666666666667, 1.15, 0.041666666666667
41224, 0.041666666666667, 1.2, 0.041666666666667
41225, 0.041666666666667, 1.25, 0.041666666666667
41226, 0.041666666666667, 1.3, 0.041666666666667
41227, 0.041666666666667, 0.2, 0.083333333333333
41228, 0.041666666666667, 0.25, 0.083333333333333
41229, 0.041666666666667, 0.3, 0.083333333333333
41230, 0.041666666666667, 0.35, 0.083333333333333
41231, 0.041666666666667, 0.4, 0.083333333333333
41232, 0.041666666666667, 0.45, 0.083333333333333
41233, 0.041666666666667, 0.5, 0.083333333333333
41234, 0.041666666666667, 0.55, 0.083333333333333
41235, 0.041666666666667, 0.6, 0.083333333333333
41236, 0.041666666666667, 0.65, 0.083333333333333
41237, 0.041666666666667, 0.7, 0.083333333333333
41238, 0.041666666666667, 0.75, 0.083333333333333
41239, 0.041666666666667, 0.8, 0.083333333333333
41240, 0.041666666666667, 0.85, 0.083333333333333
41241, 0.041666666666667, 0.9, 0.083333333333333
41242, 0.041666666666667, 0.95, 0.083333333333333
41243, 0.041666666666667, 1, 0.083333333333333
41244, 0.041666666666667, 1.05, 0.083333333333333
41245, 0.041666666666667, 1.1, 0.083333333333333
41246, 0.041666666666667, 1.15, 0.083333333333333
41247, 0.041666666666667, 1.2, 0.083333333333333
41248, 0.041666666666667, 1.25, 0.083333333333333
41249, 0.041666666666667, 1.3, 0.083333333333333
41250, 0.041666666666667, 0.2, 0.125
41251, 0.041666666666667, 0.25, 0.125
41252, 0.041666666666667, 0.3, 0.125
41253, 0.041666666666667, 0.35, 0.125
41254, 0.041666666666667, 0.4, 0.125
41255, 0.041666666666667, 0.45, 0.125
41256, 0.041666666666667, 0.5, 0.125
41257, 0.041666666666667, 0.55, 0.125
41258, 0.041666666666667, 0.6, 0.125
41259, 0.041666666666667, 0.65, 0.125
41260, 0.041666666666667, 0.7, 0.125
41261, 0.041666666666667, 0.75, 0.125
41262, 0.041666666666667, 0.8, 0.125
41263, 0.041666666666667, 0.85, 0.125
41264, 0.041666666666667, 0.9, 0.125
41265, 0.041666666666667, 0.95, 0.125
41266, 0.041666666666667, 1, 0.125
41267, 0.041666666666667, 1.05, 0.125
41268, 0.041666666666667, 1.1, 0.125
41269, 0.041666666666667, 1.15, 0.125
41270, 0.041666666666667, 1.2, 0.125
41271, 0.041666666666667, 1.25, 0.125
41272, 0.041666666666667, 1.3, 0.125
41273, 0.041666666666667, 0.2, 0.16666666666667
41274, 0.041666666666667, 0.25, 0.16666666666667
41275, 0.041666666666667, 0.3, 0.16666666666667
41276, 0.041666666666667, 0.35, 0.16666666666667
41277, 0.041666666666667, 0.4, 0.16666666666667
41278, 0.041666666666667, 0.45, 0.16666666666667
41279, 0.041666666666667, 0.5, 0.16666666666667
41280, 0.041666666666667, 0.55, 0.16666666666667
41281, 0.041666666666667, 0.6, 0.16666666666667
41282, 0.041666666666667, 0.65, 0.16666666666667
41283, 0.041666666666667, 0.7, 0.16666666666667
41284, 0.041666666666667, 0.75, 0.16666666666667
41285, 0.041666666666667, 0.8, 0.16666666666667
41286, 0.041666666666667, 0.85, 0.16666666666667
41287, 0.041666666666667, 0.9, 0.16666666666667
41288, 0.041666666666667, 0.95, 0.16666666666667
41289, 0.041666666666667, 1, 0.16666666666667
41290, 0.041666666666667, 1.05, 0.16666666666667
41291, 0.041666666666667, 1.1, 0.16666666666667
41292, 0.041666666666667, 1.15, 0.16666666666667
41293, 0.041666666666667, 1.2, 0.16666666666667
41294, 0.041666666666667, 1.25, 0.16666666666667
41295, 0.041666666666667, 1.3, 0.16666666666667
41296, 0.041666666666667, 0.2, 0.20833333333333
41297, 0.041666666666667, 0.25, 0.20833333333333
41298, 0.041666666666667, 0.3, 0.20833333333333
41299, 0.041666666666667, 0.35, 0.20833333333333
41300, 0.041666666666667, 0.4, 0.20833333333333
41301, 0.041666666666667, 0.45, 0.20833333333333
41302, 0.041666666666667, 0.5, 0.20833333333333
41303, 0.041666666666667, 0.55, 0.20833333333333
41304, 0.041666666666667, 0.6, 0.20833333333333
41305, 0.041666666666667, 0.65, 0.20833333333333
41306, 0.041666666666667, 0.7, 0.20833333333333
41307, 0.041666666666667, 0.75, 0.20833333333333
41308, 0.041666666666667, 0.8, 0.20833333333333
41309, 0.041666666666667, 0.85, 0.20833333333333
41310, 0.041666666666667, 0.9, 0.20833333333333
41311, 0.041666666666667, 0.95, 0.20833333333333
41312, 0.041666666666667, 1, 0.20833333333333
41313, 0.041666666666667, 1.05, 0.20833333333333
41314, 0.041666666666667, 1.1, 0.20833333333333
41315, 0.041666666666667, 1.15, 0.20833333333333
41316, 0.041666666666667, 1.2, 0.20833333333333
41317, 0.041666666666667, 1.25, 0.20833333333333
41318, 0.041666666666667, 1.3, 0.20833333333333
41319, 0.041666666666667, 0.2, 0.25
41320, 0.041666666666667, 0.25, 0.25
41321, 0.041666666666667, 0.3, 0.25
41322, 0.041666666666667, 0.35, 0.25
41323, 0.041666666666667, 0.4, 0.25
41324, 0.041666666666667, 0.45, 0.25
41325, 0.041666666666667, 0.5, 0.25
41326, 0.041666666666667, 0.55, 0.25
41327, 0.041666666666667, 0.6, 0.25
41328, 0.041666666666667, 0.65, 0.25
41329, 0.041666666666667, 0.7, 0.25
41330, 0.041666666666667, 0.75, 0.25
41331, 0.041666666666667, 0.8, 0.25
41332, 0.041666666666667, 0.85, 0.25
41333, 0.041666666666667, 0.9, 0.25
41334, 0.041666666666667, 0.95, 0.25
41335, 0.041666666666667, 1, 0.25
41336, 0.041666666666667, 1.05, 0.25
41337, 0.041666666666667, 1.1, 0.25
41338, 0.041666666666667, 1.15, 0.25
41339, 0.041666666666667, 1.2, 0.25
41340, 0.041666666666667, 1.25, 0.25
41341, 0.041666666666667, 1.3, 0.25
41342, 0.041666666666667, 0.2, 0.29166666666667
41343, 0.041666666666667, 0.25, 0.29166666666667
41344, 0.041666666666667, 0.3, 0.29166666666667
41345, 0.041666666666667, 0.35, 0.29166666666667
41346, 0.041666666666667, 0.4, 0.29166666666667
41347, 0.041666666666667, 0.45, 0.29166666666667
41348, 0.041666666666667, 0.5, 0.29166666666667
41349, 0.041666666666667, 0.55, 0.29166666666667
41350, 0.041666666666667, 0.6, 0.29166666666667
41351, 0.041666666666667, 0.65, 0.29166666666667
41352, 0.041666666666667, 0.7, 0.29166666666667
41353, 0.041666666666667, 0.75, 0.29166666666667
41354, 0.041666666666667, 0.8, 0.29166666666667
41355, 0.041666666666667, 0.85, 0.29166666666667
41356, 0.041666666666667, 0.9, 0.29166666666667
41357, 0.041666666666667, 0.95, 0.29166666666667
41358, 0.041666666666667, 1, 0.29166666666667
41359, 0.041666666666667, 1.05, 0.29166666666667
41360, 0.041666666666667, 1.1, 0.29166666666667
41361, 0.041666666666667, 1.15, 0.29166666666667
41362, 0.041666666666667, 1.2, 0.29166666666667
41363, 0.041666666666667, 1.25, 0.29166666666667
41364, 0.041666666666667, 1.3, 0.29166666666667
41365, 0.041666666666667, 0.2, 0.33333333333333
41366, 0.041666666666667, 0.25, 0.33333333333333
41367, 0.041666666666667, 0.3, 0.33333333333333
41368, 0.041666666666667, 0.35, 0.33333333333333
41369, 0.041666666666667, 0.4, 0.33333333333333
41370, 0.041666666666667, 0.45, 0.33333333333333
41371, 0.041666666666667, 0.5, 0.33333333333333
41372, 0.041666666666667, 0.55, 0.33333333333333
41373, 0.041666666666667, 0.6, 0.33333333333333
41374, 0.041666666666667, 0.65, 0.33333333333333
41375, 0.041666666666667, 0.7, 0.33333333333333
41376, 0.041666666666667, 0.75, 0.33333333333333
41377, 0.041666666666667, 0.8, 0.33333333333333
41378, 0.041666666666667, 0.85, 0.33333333333333
41379, 0.041666666666667, 0.9, 0.33333333333333
41380, 0.041666666666667, 0.95, 0.33333333333333
41381, 0.041666666666667, 1, 0.33333333333333
41382, 0.041666666666667, 1.05, 0.33333333333333
41383, 0.041666666666667, 1.1, 0.33333333333333
41384, 0.041666666666667, 1.15, 0.33333333333333
41385, 0.041666666666667, 1.2, 0.33333333333333
41386, 0.041666666666667, 1.25, 0.33333333333333
41387, 0.041666666666667, 1.3, 0.33333333333333
41388, 0.041666666666667, 0.2, 0.375
41389, 0.041666666666667, 0.25, 0.375
41390, 0.041666666666667, 0.3, 0.375
41391, 0.041666666666667, 0.35, 0.375
41392, 0.041666666666667, 0.4, 0.375
41393, 0.041666666666667, 0.45, 0.375
41394, 0.041666666666667, 0.5, 0.375
41395, 0.041666666666667, 0.55, 0.375
41396, 0.041666666666667, 0.6, 0.375
41397, 0.041666666666667, 0.65, 0.375
41398, 0.041666666666667, 0.7, 0.375
41399, 0.041666666666667, 0.75, 0.375
41400, 0.041666666666667, 0.8, 0.375
41401, 0.041666666666667, 0.85, 0.375
41402, 0.041666666666667, 0.9, 0.375
41403, 0.041666666666667, 0.95, 0.375
41404, 0.041666666666667, 1, 0.375
41405, 0.041666666666667, 1.05, 0.375
41406, 0.041666666666667, 1.1, 0.375
41407, 0.041666666666667, 1.15, 0.375
41408, 0.041666666666667, 1.2, 0.375
41409, 0.041666666666667, 1.25, 0.375
41410, 0.041666666666667, 1.3, 0.375
41411, 0.041666666666667, 0.2, 0.41666666666667
41412, 0.041666666666667, 0.25, 0.41666666666667
41413, 0.041666666666667, 0.3, 0.41666666666667
41414, 0.041666666666667, 0.35, 0.41666666666667
41415, 0.041666666666667, 0.4, 0.41666666666667
41416, 0.041666666666667, 0.45, 0.41666666666667
41417, 0.041666666666667, 0.5, 0.41666666666667
41418, 0.041666666666667, 0.55, 0.41666666666667
41419, 0.041666666666667, 0.6, 0.41666666666667
41420, 0.041666666666667, 0.65, 0.41666666666667
41421, 0.041666666666667, 0.7, 0.41666666666667
41422, 0.041666666666667, 0.75, 0.41666666666667
41423, 0.041666666666667, 0.8, 0.41666666666667
41424, 0.041666666666667, 0.85, 0.41666666666667
41425, 0.041666666666667, 0.9, 0.41666666666667
41426, 0.041666666666667, 0.95, 0.41666666666667
41427, 0.041666666666667, 1, 0.41666666666667
41428, 0.041666666666667, 1.05, 0.41666666666667
41429, 0.041666666666667, 1.1, 0.41666666666667
41430, 0.041666666666667, 1.15, 0.41666666666667
41431, 0.041666666666667, 1.2, 0.41666666666667
41432, 0.041666666666667, 1.25, 0.41666666666667
41433, 0.041666666666667, 1.3, 0.41666666666667
41434, 0.041666666666667, 0.2, 0.45833333333333
41435, 0.041666666666667, 0.25, 0.45833333333333
41436, 0.041666666666667, 0.3, 0.45833333333333
41437, 0.041666666666667, 0.35, 0.45833333333333
41438, 0.041666666666667, 0.4, 0.45833333333333
41439, 0.041666666666667, 0.45, 0.45833333333333
41440, 0.041666666666667, 0.5, 0.45833333333333
41441, 0.041666666666667, 0.55, 0.45833333333333
41442, 0.041666666666667, 0.6, 0.45833333333333
41443, 0.041666666666667, 0.65, 0.45833333333333
41444, 0.041666666666667, 0.7, 0.45833333333333
41445, 0.041666666666667, 0.75, 0.45833333333333
41446, 0.041666666666667, 0.8, 0.45833333333333
41447, 0.041666666666667, 0.85, 0.45833333333333
41448, 0.041666666666667, 0.9, 0.45833333333333
41449, 0.041666666666667, 0.95, 0.45833333333333
41450, 0.041666666666667, 1, 0.45833333333333
41451, 0.041666666666667, 1.05, 0.45833333333333
41452, 0.041666666666667, 1.1, 0.45833333333333
41453, 0.041666666666667, 1.15, 0.45833333333333
41454, 0.041666666666667, 1.2, 0.45833333333333
41455, 0.041666666666667, 1.25, 0.45833333333333
41456, 0.041666666666667, 1.3, 0.45833333333333
41457, 0.083333333333333, 0.2, 0.041666666666667
41458, 0.083333333333333, 0.25, 0.041666666666667
41459, 0.083333333333333, 0.3, 0.041666666666667
41460, 0.083333333333333, 0.35, 0.041666666666667
41461, 0.083333333333333, 0.4, 0.041666666666667
41462, 0.083333333333333, 0.45, 0.041666666666667
41463, 0.083333333333333, 0.5, 0.041666666666667
41464, 0.083333333333333, 0.55, 0.041666666666667
41465, 0.083333333333333, 0.6, 0.041666666666667
41466, 0.083333333333333, 0.65, 0.041666666666667
41467, 0.083333333333333, 0.7, 0.041666666666667
41468, 0.083333333333333, 0.75, 0.041666666666667
41469, 0.083333333333333, 0.8, 0.041666666666667
41470, 0.083333333333333, 0.85, 0.041666666666667
41471, 0.083333333333333, 0.9, 0.041666666666667
41472, 0.083333333333333, 0.95, 0.041666666666667
41473, 0.083333333333333, 1, 0.041666666666667
41474, 0.083333333333333, 1.05, 0.041666666666667
41475, 0.083333333333333, 1.1, 0.041666666666667
41476, 0.083333333333333, 1.15, 0.041666666666667
41477, 0.083333333333333, 1.2, 0.041666666666667
41478, 0.083333333333333, 1.25, 0.041666666666667
41479, 0.083333333333333, 1.3, 0.041666666666667
41480, 0.083333333333333, 0.2, 0.083333333333333
41481, 0.083333333333333, 0.25, 0.083333333333333
41482, 0.083333333333333, 0.3, 0.083333333333333
41483, 0.083333333333333, 0.35, 0.083333333333333
41484, 0.083333333333333, 0.4, 0.083333333333333
41485, 0.083333333333333, 0.45, 0.083333333333333
41486, 0.083333333333333, 0.5, 0.083333333333333
41487, 0.083333333333333, 0.55, 0.083333333333333
41488, 0.083333333333333, 0.6, 0.083333333333333
41489, 0.083333333333333, 0.65, 0.083333333333333
41490, 0.083333333333333, 0.7, 0.083333333333333
41491, 0.083333333333333, 0.75, 0.083333333333333
41492, 0.083333333333333, 0.8, 0.083333333333333
41493, 0.083333333333333, 0.85, 0.083333333333333
41494, 0.083333333333333, 0.9, 0.083333333333333
41495, 0.083333333333333, 0.95, 0.083333333333333
41496, 0.083333333333333, 1, 0.083333333333333
41497, 0.083333333333333, 1.05, 0.083333333333333
41498, 0.083333333333333, 1.1, 0.083333333333333
41499, 0.083333333333333, 1.15, 0.083333333333333
41500, 0.083333333333333, 1.2, 0.083333333333333
41501, 0.083333333333333, 1.25, 0.083333333333333
41502, 0.083333333333333, 1.3, 0.083333333333333
41503, 0.083333333333333, 0.2, 0.125
41504, 0.083333333333333, 0.25, 0.125
41505, 0.083333333333333, 0.3, 0.125
41506, 0.083333333333333, 0.35, 0.125
41507, 0.083333333333333, 0.4, 0.125
41508, 0.083333333333333, 0.45, 0.125
41509, 0.083333333333333, 0.5, 0.125
41510, 0.083333333333333, 0.55, 0.125
41511, 0.083333333333333, 0.6, 0.125
41512, 0.083333333333333, 0.65, 0.125
41513, 0.083333333333333, 0.7, 0.125
41514, 0.083333333333333, 0.75, 0.125
41515, 0.083333333333333, 0.8, 0.125
41516, 0.083333333333333, 0.85, 0.125
41517, 0.083333333333333, 0.9, 0.125
41518, 0.083333333333333, 0.95, 0.125
41519, 0.083333333333333, 1, 0.125
41520, 0.083333333333333, 1.05, 0.125
41521, 0.083333333333333, 1.1, 0.125
41522, 0.083333333333333, 1.15, 0.125
41523, 0.083333333333333, 1.2, 0.125
41524, 0.083333333333333, 1.25, 0.125
41525, 0.083333333333333, 1.3, 0.125
41526, 0.083333333333333, 0.2, 0.16666666666667
41527, 0.083333333333333, 0.25, 0.16666666666667
41528, 0.083333333333333, 0.3, 0.16666666666667
41529, 0.083333333333333, 0.35, 0.16666666666667
41530, 0.083333333333333, 0.4, 0.16666666666667
41531, 0.083333333333333, 0.45, 0.16666666666667
41532, 0.083333333333333, 0.5, 0.16666666666667
41533, 0.083333333333333, 0.55, 0.16666666666667
41534, 0.083333333333333, 0.6, 0.16666666666667
41535, 0.083333333333333, 0.65, 0.16666666666667
41536, 0.083333333333333, 0.7, 0.16666666666667
41537, 0.083333333333333, 0.75, 0.16666666666667
41538, 0.083333333333333, 0.8, 0.16666666666667
41539, 0.083333333333333, 0.85, 0.16666666666667
41540, 0.083333333333333, 0.9, 0.16666666666667
41541, 0.083333333333333, 0.95, 0.16666666666667
41542, 0.083333333333333, 1, 0.16666666666667
41543, 0.083333333333333, 1.05, 0.16666666666667
41544, 0.083333333333333, 1.1, 0.16666666666667
41545, 0.083333333333333, 1.15, 0.16666666666667
41546, 0.083333333333333, 1.2, 0.16666666666667
41547, 0.083333333333333, 1.25, 0.16666666666667
41548, 0.083333333333333, 1.3, 0.16666666666667
41549, 0.083333333333333, 0.2, 0.20833333333333
41550, 0.083333333333333, 0.25, 0.20833333333333
41551, 0.083333333333333, 0.3, 0.20833333333333
41552, 0.083333333333333, 0.35, 0.20833333333333
41553, 0.083333333333333, 0.4, 0.20833333333333
41554, 0.083333333333333, 0.45, 0.20833333333333
41555, 0.083333333333333, 0.5, 0.20833333333333
41556, 0.083333333333333, 0.55, 0.20833333333333
41557, 0.083333333333333, 0.6, 0.20833333333333
41558, 0.083333333333333, 0.65, 0.20833333333333
41559, 0.083333333333333, 0.7, 0.20833333333333
41560, 0.083333333333333, 0.75, 0.20833333333333
41561, 0.083333333333333, 0.8, 0.20833333333333
41562, 0.083333333333333, 0.85, 0.20833333333333
41563, 0.083333333333333, 0.9, 0.20833333333333
41564, 0.083333333333333, 0.95, 0.20833333333333
41565, 0.083333333333333, 1, 0.20833333333333
41566, 0.083333333333333, 1.05, 0.20833333333333
41567, 0.083333333333333, 1.1, 0.20833333333333
41568, 0.083333333333333, 1.15, 0.20833333333333
41569, 0.083333333333333, 1.2, 0.20833333333333
41570, 0.083333333333333, 1.25, 0.20833333333333
41571, 0.083333333333333, 1.3, 0.20833333333333
41572, 0.083333333333333, 0.2, 0.25
41573, 0.083333333333333, 0.25, 0.25
41574, 0.083333333333333, 0.3, 0.25
41575, 0.083333333333333, 0.35, 0.25
41576, 0.083333333333333, 0.4, 0.25
41577, 0.083333333333333, 0.45, 0.25
41578, 0.083333333333333, 0.5, 0.25
41579, 0.083333333333333, 0.55, 0.25
41580, 0.083333333333333, 0.6, 0.25
41581, 0.083333333333333, 0.65, 0.25
41582, 0.083333333333333, 0.7, 0.25
41583, 0.083333333333333, 0.75, 0.25
41584, 0.083333333333333, 0.8, 0.25
41585, 0.083333333333333, 0.85, 0.25
41586, 0.083333333333333, 0.9, 0.25
41587, 0.083333333333333, 0.95, 0.25
41588, 0.083333333333333, 1, 0.25
41589, 0.083333333333333, 1.05, 0.25
41590, 0.083333333333333, 1.1, 0.25
41591, 0.083333333333333, 1.15, 0.25
41592, 0.083333333333333, 1.2, 0.25
41593, 0.083333333333333, 1.25, 0.25
41594, 0.083333333333333, 1.3, 0.25
41595, 0.083333333333333, 0.2, 0.29166666666667
41596, 0.083333333333333, 0.25, 0.29166666666667
41597, 0.083333333333333, 0.3, 0.29166666666667
41598, 0.083333333333333, 0.35, 0.29166666666667
41599, 0.083333333333333, 0.4, 0.29166666666667
41600, 0.083333333333333, 0.45, 0.29166666666667
41601, 0.083333333333333, 0.5, 0.29166666666667
41602, 0.083333333333333, 0.55, 0.29166666666667
41603, 0.083333333333333, 0.6, 0.29166666666667
41604, 0.083333333333333, 0.65, 0.29166666666667
41605, 0.083333333333333, 0.7, 0.29166666666667
41606, 0.083333333333333, 0.75, 0.29166666666667
41607, 0.083333333333333, 0.8, 0.29166666666667
41608, 0.083333333333333, 0.85, 0.29166666666667
41609, 0.083333333333333, 0.9, 0.29166666666667
41610, 0.083333333333333, 0.95, 0.29166666666667
41611, 0.083333333333333, 1, 0.29166666666667
41612, 0.083333333333333, 1.05, 0.29166666666667
41613, 0.083333333333333, 1.1, 0.29166666666667
41614, 0.083333333333333, 1.15, 0.29166666666667
41615, 0.083333333333333, 1.2, 0.29166666666667
41616, 0.083333333333333, 1.25, 0.29166666666667
41617, 0.083333333333333, 1.3, 0.29166666666667
41618, 0.083333333333333, 0.2, 0.33333333333333
41619, 0.083333333333333, 0.25, 0.33333333333333
41620, 0.083333333333333, 0.3, 0.33333333333333
41621, 0.083333333333333, 0.35, 0.33333333333333
41622, 0.083333333333333, 0.4, 0.33333333333333
41623, 0.083333333333333, 0.45, 0.33333333333333
41624, 0.083333333333333, 0.5, 0.33333333333333
41625, 0.083333333333333, 0.55, 0.33333333333333
41626, 0.083333333333333, 0.6, 0.33333333333333
41627, 0.083333333333333, 0.65, 0.33333333333333
41628, 0.083333333333333, 0.7, 0.33333333333333
41629, 0.083333333333333, 0.75, 0.33333333333333
41630, 0.083333333333333, 0.8, 0.33333333333333
41631, 0.083333333333333, 0.85, 0.33333333333333
41632, 0.083333333333333, 0.9, 0.33333333333333
41633, 0.083333333333333, 0.95, 0.33333333333333
41634, 0.083333333333333, 1, 0.33333333333333
41635, 0.083333333333333, 1.05, 0.33333333333333
41636, 0.083333333333333, 1.1, 0.33333333333333
41637, 0.083333333333333, 1.15, 0.33333333333333
41638, 0.083333333333333, 1.2, 0.33333333333333
41639, 0.083333333333333, 1.25, 0.33333333333333
41640, 0.083333333333333, 1.3, 0.33333333333333
41641, 0.083333333333333, 0.2, 0.375
41642, 0.083333333333333, 0.25, 0.375
41643, 0.083333333333333, 0.3, 0.375
41644, 0.083333333333333, 0.35, 0.375
41645, 0.083333333333333, 0.4, 0.375
41646, 0.083333333333333, 0.45, 0.375
41647, 0.083333333333333, 0.5, 0.375
41648, 0.083333333333333, 0.55, 0.375
41649, 0.083333333333333, 0.6, 0.375
41650, 0.083333333333333, 0.65, 0.375
41651, 0.083333333333333, 0.7, 0.375
41652, 0.083333333333333, 0.75, 0.375
41653, 0.083333333333333, 0.8, 0.375
41654, 0.083333333333333, 0.85, 0.375
41655, 0.083333333333333, 0.9, 0.375
41656, 0.083333333333333, 0.95, 0.375
41657, 0.083333333333333, 1, 0.375
41658, 0.083333333333333, 1.05, 0.375
41659, 0.083333333333333, 1.1, 0.375
41660, 0.083333333333333, 1.15, 0.375
41661, 0.083333333333333, 1.2, 0.375
41662, 0.083333333333333, 1.25, 0.375
41663, 0.083333333333333, 1.3, 0.375
41664, 0.083333333333333, 0.2, 0.41666666666667
41665, 0.083333333333333, 0.25, 0.41666666666667
41666, 0.083333333333333, 0.3, 0.41666666666667
41667, 0.083333333333333, 0.35, 0.41666666666667
41668, 0.083333333333333, 0.4, 0.41666666666667
41669, 0.083333333333333, 0.45, 0.41666666666667
41670, 0.083333333333333, 0.5, 0.41666666666667
41671, 0.083333333333333, 0.55, 0.41666666666667
41672, 0.083333333333333, 0.6, 0.41666666666667
41673, 0.083333333333333, 0.65, 0.41666666666667
41674, 0.083333333333333, 0.7, 0.41666666666667
41675, 0.083333333333333, 0.75, 0.41666666666667
41676, 0.083333333333333, 0.8, 0.41666666666667
41677, 0.083333333333333, 0.85, 0.41666666666667
41678, 0.083333333333333, 0.9, 0.41666666666667
41679, 0.083333333333333, 0.95, 0.41666666666667
41680, 0.083333333333333, 1, 0.41666666666667
41681, 0.083333333333333, 1.05, 0.41666666666667
41682, 0.083333333333333, 1.1, 0.41666666666667
41683, 0.083333333333333, 1.15, 0.41666666666667
41684, 0.083333333333333, 1.2, 0.41666666666667
41685, 0.083333333333333, 1.25, 0.41666666666667
41686, 0.083333333333333, 1.3, 0.41666666666667
41687, 0.083333333333333, 0.2, 0.45833333333333
41688, 0.083333333333333, 0.25, 0.45833333333333
41689, 0.083333333333333, 0.3, 0.45833333333333
41690, 0.083333333333333, 0.35, 0.45833333333333
41691, 0.083333333333333, 0.4, 0.45833333333333
41692, 0.083333333333333, 0.45, 0.45833333333333
41693, 0.083333333333333, 0.5, 0.45833333333333
41694, 0.083333333333333, 0.55, 0.45833333333333
41695, 0.083333333333333, 0.6, 0.45833333333333
41696, 0.083333333333333, 0.65, 0.45833333333333
41697, 0.083333333333333, 0.7, 0.45833333333333
41698, 0.083333333333333, 0.75, 0.45833333333333
41699, 0.083333333333333, 0.8, 0.45833333333333
41700, 0.083333333333333, 0.85, 0.45833333333333
41701, 0.083333333333333, 0.9, 0.45833333333333
41702, 0.083333333333333, 0.95, 0.45833333333333
41703, 0.083333333333333, 1, 0.45833333333333
41704, 0.083333333333333, 1.05, 0.45833333333333
41705, 0.083333333333333, 1.1, 0.45833333333333
41706, 0.083333333333333, 1.15, 0.45833333333333
41707, 0.083333333333333, 1.2, 0.45833333333333
41708, 0.083333333333333, 1.25, 0.45833333333333
41709, 0.083333333333333, 1.3, 0.45833333333333
41710, 0.125, 0.2, 0.041666666666667
41711, 0.125, 0.25, 0.041666666666667
41712, 0.125, 0.3, 0.041666666666667
41713, 0.125, 0.35, 0.041666666666667
41714, 0.125, 0.4, 0.041666666666667
41715, 0.125, 0.45, 0.041666666666667
41716, 0.125, 0.5, 0.041666666666667
41717, 0.125, 0.55, 0.041666666666667
41718, 0.125, 0.6, 0.041666666666667
41719, 0.125, 0.65, 0.041666666666667
41720, 0.125, 0.7, 0.041666666666667
41721, 0.125, 0.75, 0.041666666666667
41722, 0.125, 0.8, 0.041666666666667
41723, 0.125, 0.85, 0.041666666666667
41724, 0.125, 0.9, 0.041666666666667
41725, 0.125, 0.95, 0.041666666666667
41726, 0.125, 1, 0.041666666666667
41727, 0.125, 1.05, 0.041666666666667
41728, 0.125, 1.1, 0.041666666666667
41729, 0.125, 1.15, 0.041666666666667
41730, 0.125, 1.2, 0.041666666666667
41731, 0.125, 1.25, 0.041666666666667
41732, 0.125, 1.3, 0.041666666666667
41733, 0.125, 0.2, 0.083333333333333
41734, 0.125, 0.25, 0.083333333333333
41735, 0.125, 0.3, 0.083333333333333
41736, 0.125, 0.35, 0.083333333333333
41737, 0.125, 0.4, 0.083333333333333
41738, 0.125, 0.45, 0.083333333333333
41739, 0.125, 0.5, 0.083333333333333
41740, 0.125, 0.55, 0.083333333333333
41741, 0.125, 0.6, 0.083333333333333
41742, 0.125, 0.65, 0.083333333333333
41743, 0.125, 0.7, 0.083333333333333
41744, 0.125, 0.75, 0.083333333333333
41745, 0.125, 0.8, 0.083333333333333
41746, 0.125, 0.85, 0.083333333333333
41747, 0.125, 0.9, 0.083333333333333
41748, 0.125, 0.95, 0.083333333333333
41749, 0.125, 1, 0.083333333333333
41750, 0.125, 1.05, 0.083333333333333
41751, 0.125, 1.1, 0.083333333333333
41752, 0.125, 1.15, 0.083333333333333
41753, 0.125, 1.2, 0.083333333333333
41754, 0.125, 1.25, 0.083333333333333
41755, 0.125, 1.3, 0.083333333333333
41756, 0.125, 0.2, 0.125
41757, 0.125, 0.25, 0.125
41758, 0.125, 0.3, 0.125
41759, 0.125, 0.35, 0.125
41760, 0.125, 0.4, 0.125
41761, 0.125, 0.45, 0.125
41762, 0.125, 0.5, 0.125
41763, 0.125, 0.55, 0.125
41764, 0.125, 0.6, 0.125
41765, 0.125, 0.65, 0.125
41766, 0.125, 0.7, 0.125
41767, 0.125, 0.75, 0.125
41768, 0.125, 0.8, 0.125
41769, 0.125, 0.85, 0.125
41770, 0.125, 0.9, 0.125
41771, 0.125, 0.95, 0.125
41772, 0.125, 1, 0.125
41773, 0.125, 1.05, 0.125
41774, 0.125, 1.1, 0.125
41775, 0.125, 1.15, 0.125
41776, 0.125, 1.2, 0.125
41777, 0.125, 1.25, 0.125
41778, 0.125, 1.3, 0.125
41779, 0.125, 0.2, 0.16666666666667
41780, 0.125, 0.25, 0.16666666666667
41781, 0.125, 0.3, 0.16666666666667
41782, 0.125, 0.35, 0.16666666666667
41783, 0.125, 0.4, 0.16666666666667
41784, 0.125, 0.45, 0.16666666666667
41785, 0.125, 0.5, 0.16666666666667
41786, 0.125, 0.55, 0.16666666666667
41787, 0.125, 0.6, 0.16666666666667
41788, 0.125, 0.65, 0.16666666666667
41789, 0.125, 0.7, 0.16666666666667
41790, 0.125, 0.75, 0.16666666666667
41791, 0.125, 0.8, 0.16666666666667
41792, 0.125, 0.85, 0.16666666666667
41793, 0.125, 0.9, 0.16666666666667
41794, 0.125, 0.95, 0.16666666666667
41795, 0.125, 1, 0.16666666666667
41796, 0.125, 1.05, 0.16666666666667
41797, 0.125, 1.1, 0.16666666666667
41798, 0.125, 1.15, 0.16666666666667
41799, 0.125, 1.2, 0.16666666666667
41800, 0.125, 1.25, 0.16666666666667
41801, 0.125, 1.3, 0.16666666666667
41802, 0.125, 0.2, 0.20833333333333
41803, 0.125, 0.25, 0.20833333333333
41804, 0.125, 0.3, 0.20833333333333
41805, 0.125, 0.35, 0.20833333333333
41806, 0.125, 0.4, 0.20833333333333
41807, 0.125, 0.45, 0.20833333333333
41808, 0.125, 0.5, 0.20833333333333
41809, 0.125, 0.55, 0.20833333333333
41810, 0.125, 0.6, 0.20833333333333
41811, 0.125, 0.65, 0.20833333333333
41812, 0.125, 0.7, 0.20833333333333
41813, 0.125, 0.75, 0.20833333333333
41814, 0.125, 0.8, 0.20833333333333
41815, 0.125, 0.85, 0.20833333333333
41816, 0.125, 0.9, 0.20833333333333
41817, 0.125, 0.95, 0.20833333333333
41818, 0.125, 1, 0.20833333333333
41819, 0.125, 1.05, 0.20833333333333
41820, 0.125, 1.1, 0.20833333333333
41821, 0.125, 1.15, 0.20833333333333
41822, 0.125, 1.2, 0.20833333333333
41823, 0.125, 1.25, 0.20833333333333
41824, 0.125, 1.3, 0.20833333333333
41825, 0.125, 0.2, 0.25
41826, 0.125, 0.25, 0.25
41827, 0.125, 0.3, 0.25
41828, 0.125, 0.35, 0.25
41829, 0.125, 0.4, 0.25
41830, 0.125, 0.45, 0.25
41831, 0.125, 0.5, 0.25
41832, 0.125, 0.55, 0.25
41833, 0.125, 0.6, 0.25
41834, 0.125, 0.65, 0.25
41835, 0.125, 0.7, 0.25
41836, 0.125, 0.75, 0.25
41837, 0.125, 0.8, 0.25
41838, 0.125, 0.85, 0.25
41839, 0.125, 0.9, 0.25
41840, 0.125, 0.95, 0.25
41841, 0.125, 1, 0.25
41842, 0.125, 1.05, 0.25
41843, 0.125, 1.1, 0.25
41844, 0.125, 1.15, 0.25
41845, 0.125, 1.2, 0.25
41846, 0.125, 1.25, 0.25
41847, 0.125, 1.3, 0.25
41848, 0.125, 0.2, 0.29166666666667
41849, 0.125, 0.25, 0.29166666666667
41850, 0.125, 0.3, 0.29166666666667
41851, 0.125, 0.35, 0.29166666666667
41852, 0.125, 0.4, 0.29166666666667
41853, 0.125, 0.45, 0.29166666666667
41854, 0.125, 0.5, 0.29166666666667
41855, 0.125, 0.55, 0.29166666666667
41856, 0.125, 0.6, 0.29166666666667
41857, 0.125, 0.65, 0.29166666666667
41858, 0.125, 0.7, 0.29166666666667
41859, 0.125, 0.75, 0.29166666666667
41860, 0.125, 0.8, 0.29166666666667
41861, 0.125, 0.85, 0.29166666666667
41862, 0.125, 0.9, 0.29166666666667
41863, 0.125, 0.95, 0.29166666666667
41864, 0.125, 1, 0.29166666666667
41865, 0.125, 1.05, 0.29166666666667
41866, 0.125, 1.1, 0.29166666666667
41867, 0.125, 1.15, 0.29166666666667
41868, 0.125, 1.2, 0.29166666666667
41869, 0.125, 1.25, 0.29166666666667
41870, 0.125, 1.3, 0.29166666666667
41871, 0.125, 0.2, 0.33333333333333
41872, 0.125, 0.25, 0.33333333333333
41873, 0.125, 0.3, 0.33333333333333
41874, 0.125, 0.35, 0.33333333333333
41875, 0.125, 0.4, 0.33333333333333
41876, 0.125, 0.45, 0.33333333333333
41877, 0.125, 0.5, 0.33333333333333
41878, 0.125, 0.55, 0.33333333333333
41879, 0.125, 0.6, 0.33333333333333
41880, 0.125, 0.65, 0.33333333333333
41881, 0.125, 0.7, 0.33333333333333
41882, 0.125, 0.75, 0.33333333333333
41883, 0.125, 0.8, 0.33333333333333
41884, 0.125, 0.85, 0.33333333333333
41885, 0.125, 0.9, 0.33333333333333
41886, 0.125, 0.95, 0.33333333333333
41887, 0.125, 1, 0.33333333333333
41888, 0.125, 1.05, 0.33333333333333
41889, 0.125, 1.1, 0.33333333333333
41890, 0.125, 1.15, 0.33333333333333
41891, 0.125, 1.2, 0.33333333333333
41892, 0.125, 1.25, 0.33333333333333
41893, 0.125, 1.3, 0.33333333333333
41894, 0.125, 0.2, 0.375
41895, 0.125, 0.25, 0.375
41896, 0.125, 0.3, 0.375
41897, 0.125, 0.35, 0.375
41898, 0.125, 0.4, 0.375
41899, 0.125, 0.45, 0.375
41900, 0.125, 0.5, 0.375
41901, 0.125, 0.55, 0.375
41902, 0.125, 0.6, 0.375
41903, 0.125, 0.65, 0.375
41904, 0.125, 0.7, 0.375
41905, 0.125, 0.75, 0.375
41906, 0.125, 0.8, 0.375
41907, 0.125, 0.85, 0.375
41908, 0.125, 0.9, 0.375
41909, 0.125, 0.95, 0.375
41910, 0.125, 1, 0.375
41911, 0.125, 1.05, 0.375
41912, 0.125, 1.1, 0.375
41913, 0.125, 1.15, 0.375
41914, 0.125, 1.2, 0.375
41915, 0.125, 1.25, 0.375
41916, 0.125, 1.3, 0.375
41917, 0.125, 0.2, 0.41666666666667
41918, 0.125, 0.25, 0.41666666666667
41919, 0.125, 0.3, 0.41666666666667
41920, 0.125, 0.35, 0.41666666666667
41921, 0.125, 0.4, 0.41666666666667
41922, 0.125, 0.45, 0.41666666666667
41923, 0.125, 0.5, 0.41666666666667
41924, 0.125, 0.55, 0.41666666666667
41925, 0.125, 0.6, 0.41666666666667
41926, 0.125, 0.65, 0.41666666666667
41927, 0.125, 0.7, 0.41666666666667
41928, 0.125, 0.75, 0.41666666666667
41929, 0.125, 0.8, 0.41666666666667
41930, 0.125, 0.85, 0.41666666666667
41931, 0.125, 0.9, 0.41666666666667
41932, 0.125, 0.95, 0.41666666666667
41933, 0.125, 1, 0.41666666666667
41934, 0.125, 1.05, 0.41666666666667
41935, 0.125, 1.1, 0.41666666666667
41936, 0.125, 1.15, 0.41666666666667
41937, 0.125, 1.2, 0.41666666666667
41938, 0.125, 1.25, 0.41666666666667
41939, 0.125, 1.3, 0.41666666666667
41940, 0.125, 0.2, 0.45833333333333
41941, 0.125, 0.25, 0.45833333333333
41942, 0.125, 0.3, 0.45833333333333
41943, 0.125, 0.35, 0.45833333333333
41944, 0.125, 0.4, 0.45833333333333
41945, 0.125, 0.45, 0.45833333333333
41946, 0.125, 0.5, 0.45833333333333
41947, 0.125, 0.55, 0.45833333333333
41948, 0.125, 0.6, 0.45833333333333
41949, 0.125, 0.65, 0.45833333333333
41950, 0.125, 0.7, 0.45833333333333
41951, 0.125, 0.75, 0.45833333333333
41952, 0.125, 0.8, 0.45833333333333
41953, 0.125, 0.85, 0.45833333333333
41954, 0.125, 0.9, 0.45833333333333
41955, 0.125, 0.95, 0.45833333333333
41956, 0.125, 1, 0.45833333333333
41957, 0.125, 1.05, 0.45833333333333
41958, 0.125, 1.1, 0.45833333333333
41959, 0.125, 1.15, 0.45833333333333
41960, 0.125, 1.2, 0.45833333333333
41961, 0.125, 1.25, 0.45833333333333
41962, 0.125, 1.3, 0.45833333333333
41963, 0.16666666666667, 0.2, 0.041666666666667
41964, 0.16666666666667, 0.25, 0.041666666666667
41965, 0.16666666666667, 0.3, 0.041666666666667
41966, 0.16666666666667, 0.35, 0.041666666666667
41967, 0.16666666666667, 0.4, 0.041666666666667
41968, 0.16666666666667, 0.45, 0.041666666666667
41969, 0.16666666666667, 0.5, 0.041666666666667
41970, 0.16666666666667, 0.55, 0.041666666666667
41971, 0.16666666666667, 0.6, 0.041666666666667
41972, 0.16666666666667, 0.65, 0.041666666666667
41973, 0.16666666666667, 0.7, 0.041666666666667
41974, 0.16666666666667, 0.75, 0.041666666666667
41975, 0.16666666666667, 0.8, 0.041666666666667
41976, 0.16666666666667, 0.85, 0.041666666666667
41977, 0.16666666666667, 0.9, 0.041666666666667
41978, 0.16666666666667, 0.95, 0.041666666666667
41979, 0.16666666666667, 1, 0.041666666666667
41980, 0.16666666666667, 1.05, 0.041666666666667
41981, 0.16666666666667, 1.1, 0.041666666666667
41982, 0.16666666666667, 1.15, 0.041666666666667
41983, 0.16666666666667, 1.2, 0.041666666666667
41984, 0.16666666666667, 1.25, 0.041666666666667
41985, 0.16666666666667, 1.3, 0.041666666666667
41986, 0.16666666666667, 0.2, 0.083333333333333
41987, 0.16666666666667, 0.25, 0.083333333333333
41988, 0.16666666666667, 0.3, 0.083333333333333
41989, 0.16666666666667, 0.35, 0.083333333333333
41990, 0.16666666666667, 0.4, 0.083333333333333
41991, 0.16666666666667, 0.45, 0.083333333333333
41992, 0.16666666666667, 0.5, 0.083333333333333
41993, 0.16666666666667, 0.55, 0.083333333333333
41994, 0.16666666666667, 0.6, 0.083333333333333
41995, 0.16666666666667, 0.65, 0.083333333333333
41996, 0.16666666666667, 0.7, 0.083333333333333
41997, 0.16666666666667, 0.75, 0.083333333333333
41998, 0.16666666666667, 0.8, 0.083333333333333
41999, 0.16666666666667, 0.85, 0.083333333333333
42000, 0.16666666666667, 0.9, 0.083333333333333
42001, 0.16666666666667, 0.95, 0.083333333333333
42002, 0.16666666666667, 1, 0.083333333333333
42003, 0.16666666666667, 1.05, 0.083333333333333
42004, 0.16666666666667, 1.1, 0.083333333333333
42005, 0.16666666666667, 1.15, 0.083333333333333
42006, 0.16666666666667, 1.2, 0.083333333333333
42007, 0.16666666666667, 1.25, 0.083333333333333
42008, 0.16666666666667, 1.3, 0.083333333333333
42009, 0.16666666666667, 0.2, 0.125
42010, 0.16666666666667, 0.25, 0.125
42011, 0.16666666666667, 0.3, 0.125
42012, 0.16666666666667, 0.35, 0.125
42013, 0.16666666666667, 0.4, 0.125
42014, 0.16666666666667, 0.45, 0.125
42015, 0.16666666666667, 0.5, 0.125
42016, 0.16666666666667, 0.55, 0.125
42017, 0.16666666666667, 0.6, 0.125
42018, 0.16666666666667, 0.65, 0.125
42019, 0.16666666666667, 0.7, 0.125
42020, 0.16666666666667, 0.75, 0.125
42021, 0.16666666666667, 0.8, 0.125
42022, 0.16666666666667, 0.85, 0.125
42023, 0.16666666666667, 0.9, 0.125
42024, 0.16666666666667, 0.95, 0.125
42025, 0.16666666666667, 1, 0.125
42026, 0.16666666666667, 1.05, 0.125
42027, 0.16666666666667, 1.1, 0.125
42028, 0.16666666666667, 1.15, 0.125
42029, 0.16666666666667, 1.2, 0.125
42030, 0.16666666666667, 1.25, 0.125
42031, 0.16666666666667, 1.3, 0.125
42032, 0.16666666666667, 0.2, 0.16666666666667
42033, 0.16666666666667, 0.25, 0.16666666666667
42034, 0.16666666666667, 0.3, 0.16666666666667
42035, 0.16666666666667, 0.35, 0.16666666666667
42036, 0.16666666666667, 0.4, 0.16666666666667
42037, 0.16666666666667, 0.45, 0.16666666666667
42038, 0.16666666666667, 0.5, 0.16666666666667
42039, 0.16666666666667, 0.55, 0.16666666666667
42040, 0.16666666666667, 0.6, 0.16666666666667
42041, 0.16666666666667, 0.65, 0.16666666666667
42042, 0.16666666666667, 0.7, 0.16666666666667
42043, 0.16666666666667, 0.75, 0.16666666666667
42044, 0.16666666666667, 0.8, 0.16666666666667
42045, 0.16666666666667, 0.85, 0.16666666666667
42046, 0.16666666666667, 0.9, 0.16666666666667
42047, 0.16666666666667, 0.95, 0.16666666666667
42048, 0.16666666666667, 1, 0.16666666666667
42049, 0.16666666666667, 1.05, 0.16666666666667
42050, 0.16666666666667, 1.1, 0.16666666666667
42051, 0.16666666666667, 1.15, 0.16666666666667
42052, 0.16666666666667, 1.2, 0.16666666666667
42053, 0.16666666666667, 1.25, 0.16666666666667
42054, 0.16666666666667, 1.3, 0.16666666666667
42055, 0.16666666666667, 0.2, 0.20833333333333
42056, 0.16666666666667, 0.25, 0.20833333333333
42057, 0.16666666666667, 0.3, 0.20833333333333
42058, 0.16666666666667, 0.35, 0.20833333333333
42059, 0.16666666666667, 0.4, 0.20833333333333
42060, 0.16666666666667, 0.45, 0.20833333333333
42061, 0.16666666666667, 0.5, 0.20833333333333
42062, 0.16666666666667, 0.55, 0.20833333333333
42063, 0.16666666666667, 0.6, 0.20833333333333
42064, 0.16666666666667, 0.65, 0.20833333333333
42065, 0.16666666666667, 0.7, 0.20833333333333
42066, 0.16666666666667, 0.75, 0.20833333333333
42067, 0.16666666666667, 0.8, 0.20833333333333
42068, 0.16666666666667, 0.85, 0.20833333333333
42069, 0.16666666666667, 0.9, 0.20833333333333
42070, 0.16666666666667, 0.95, 0.20833333333333
42071, 0.16666666666667, 1, 0.20833333333333
42072, 0.16666666666667, 1.05, 0.20833333333333
42073, 0.16666666666667, 1.1, 0.20833333333333
42074, 0.16666666666667, 1.15, 0.20833333333333
42075, 0.16666666666667, 1.2, 0.20833333333333
42076, 0.16666666666667, 1.25, 0.20833333333333
42077, 0.16666666666667, 1.3, 0.20833333333333
42078, 0.16666666666667, 0.2, 0.25
42079, 0.16666666666667, 0.25, 0.25
42080, 0.16666666666667, 0.3, 0.25
42081, 0.16666666666667, 0.35, 0.25
42082, 0.16666666666667, 0.4, 0.25
42083, 0.16666666666667, 0.45, 0.25
42084, 0.16666666666667, 0.5, 0.25
42085, 0.16666666666667, 0.55, 0.25
42086, 0.16666666666667, 0.6, 0.25
42087, 0.16666666666667, 0.65, 0.25
42088, 0.16666666666667, 0.7, 0.25
42089, 0.16666666666667, 0.75, 0.25
42090, 0.16666666666667, 0.8, 0.25
42091, 0.16666666666667, 0.85, 0.25
42092, 0.16666666666667, 0.9, 0.25
42093, 0.16666666666667, 0.95, 0.25
42094, 0.16666666666667, 1, 0.25
42095, 0.16666666666667, 1.05, 0.25
42096, 0.16666666666667, 1.1, 0.25
42097, 0.16666666666667, 1.15, 0.25
42098, 0.16666666666667, 1.2, 0.25
42099, 0.16666666666667, 1.25, 0.25
42100, 0.16666666666667, 1.3, 0.25
42101, 0.16666666666667, 0.2, 0.29166666666667
42102, 0.16666666666667, 0.25, 0.29166666666667
42103, 0.16666666666667, 0.3, 0.29166666666667
42104, 0.16666666666667, 0.35, 0.29166666666667
42105, 0.16666666666667, 0.4, 0.29166666666667
42106, 0.16666666666667, 0.45, 0.29166666666667
42107, 0.16666666666667, 0.5, 0.29166666666667
42108, 0.16666666666667, 0.55, 0.29166666666667
42109, 0.16666666666667, 0.6, 0.29166666666667
42110, 0.16666666666667, 0.65, 0.29166666666667
42111, 0.16666666666667, 0.7, 0.29166666666667
42112, 0.16666666666667, 0.75, 0.29166666666667
42113, 0.16666666666667, 0.8, 0.29166666666667
42114, 0.16666666666667, 0.85, 0.29166666666667
42115, 0.16666666666667, 0.9, 0.29166666666667
42116, 0.16666666666667, 0.95, 0.29166666666667
42117, 0.16666666666667, 1, 0.29166666666667
42118, 0.16666666666667, 1.05, 0.29166666666667
42119, 0.16666666666667, 1.1, 0.29166666666667
42120, 0.16666666666667, 1.15, 0.29166666666667
42121, 0.16666666666667, 1.2, 0.29166666666667
42122, 0.16666666666667, 1.25, 0.29166666666667
42123, 0.16666666666667, 1.3, 0.29166666666667
42124, 0.16666666666667, 0.2, 0.33333333333333
42125, 0.16666666666667, 0.25, 0.33333333333333
42126, 0.16666666666667, 0.3, 0.33333333333333
42127, 0.16666666666667, 0.35, 0.33333333333333
42128, 0.16666666666667, 0.4, 0.33333333333333
42129, 0.16666666666667, 0.45, 0.33333333333333
42130, 0.16666666666667, 0.5, 0.33333333333333
42131, 0.16666666666667, 0.55, 0.33333333333333
42132, 0.16666666666667, 0.6, 0.33333333333333
42133, 0.16666666666667, 0.65, 0.33333333333333
42134, 0.16666666666667, 0.7, 0.33333333333333
42135, 0.16666666666667, 0.75, 0.33333333333333
42136, 0.16666666666667, 0.8, 0.33333333333333
42137, 0.16666666666667, 0.85, 0.33333333333333
42138, 0.16666666666667, 0.9, 0.33333333333333
42139, 0.16666666666667, 0.95, 0.33333333333333
42140, 0.16666666666667, 1, 0.33333333333333
42141, 0.16666666666667, 1.05, 0.33333333333333
42142, 0.16666666666667, 1.1, 0.33333333333333
42143, 0.16666666666667, 1.15, 0.33333333333333
42144, 0.16666666666667, 1.2, 0.33333333333333
42145, 0.16666666666667, 1.25, 0.33333333333333
42146, 0.16666666666667, 1.3, 0.33333333333333
42147, 0.16666666666667, 0.2, 0.375
42148, 0.16666666666667, 0.25, 0.375
42149, 0.16666666666667, 0.3, 0.375
42150, 0.16666666666667, 0.35, 0.375
42151, 0.16666666666667, 0.4, 0.375
42152, 0.16666666666667, 0.45, 0.375
42153, 0.16666666666667, 0.5, 0.375
42154, 0.16666666666667, 0.55, 0.375
42155, 0.16666666666667, 0.6, 0.375
42156, 0.16666666666667, 0.65, 0.375
42157, 0.16666666666667, 0.7, 0.375
42158, 0.16666666666667, 0.75, 0.375
42159, 0.16666666666667, 0.8, 0.375
42160, 0.16666666666667, 0.85, 0.375
42161, 0.16666666666667, 0.9, 0.375
42162, 0.16666666666667, 0.95, 0.375
42163, 0.16666666666667, 1, 0.375
42164, 0.16666666666667, 1.05, 0.375
42165, 0.16666666666667, 1.1, 0.375
42166, 0.16666666666667, 1.15, 0.375
42167, 0.16666666666667, 1.2, 0.375
42168, 0.16666666666667, 1.25, 0.375
42169, 0.16666666666667, 1.3, 0.375
42170, 0.16666666666667, 0.2, 0.41666666666667
42171, 0.16666666666667, 0.25, 0.41666666666667
42172, 0.16666666666667, 0.3, 0.41666666666667
42173, 0.16666666666667, 0.35, 0.41666666666667
42174, 0.16666666666667, 0.4, 0.41666666666667
42175, 0.16666666666667, 0.45, 0.41666666666667
42176, 0.16666666666667, 0.5, 0.41666666666667
42177, 0.16666666666667, 0.55, 0.41666666666667
42178, 0.16666666666667, 0.6, 0.41666666666667
42179, 0.16666666666667, 0.65, 0.41666666666667
42180, 0.16666666666667, 0.7, 0.41666666666667
42181, 0.16666666666667, 0.75, 0.41666666666667
42182, 0.16666666666667, 0.8, 0.41666666666667
42183, 0.16666666666667, 0.85, 0.41666666666667
42184, 0.16666666666667, 0.9, 0.41666666666667
42185, 0.16666666666667, 0.95, 0.41666666666667
42186, 0.16666666666667, 1, 0.41666666666667
42187, 0.16666666666667, 1.05, 0.41666666666667
42188, 0.16666666666667, 1.1, 0.41666666666667
42189, 0.16666666666667, 1.15, 0.41666666666667
42190, 0.16666666666667, 1.2, 0.41666666666667
42191, 0.16666666666667, 1.25, 0.41666666666667
42192, 0.16666666666667, 1.3, 0.41666666666667
42193, 0.16666666666667, 0.2, 0.45833333333333
42194, 0.16666666666667, 0.25, 0.45833333333333
42195, 0.16666666666667, 0.3, 0.45833333333333
42196, 0.16666666666667, 0.35, 0.45833333333333
42197, 0.16666666666667, 0.4, 0.45833333333333
42198, 0.16666666666667, 0.45, 0.45833333333333
42199, 0.16666666666667, 0.5, 0.45833333333333
42200, 0.16666666666667, 0.55, 0.45833333333333
42201, 0.16666666666667, 0.6, 0.45833333333333
42202, 0.16666666666667, 0.65, 0.45833333333333
42203, 0.16666666666667, 0.7, 0.45833333333333
42204, 0.16666666666667, 0.75, 0.45833333333333
42205, 0.16666666666667, 0.8, 0.45833333333333
42206, 0.16666666666667, 0.85, 0.45833333333333
42207, 0.16666666666667, 0.9, 0.45833333333333
42208, 0.16666666666667, 0.95, 0.45833333333333
42209, 0.16666666666667, 1, 0.45833333333333
42210, 0.16666666666667, 1.05, 0.45833333333333
42211, 0.16666666666667, 1.1, 0.45833333333333
42212, 0.16666666666667, 1.15, 0.45833333333333
42213, 0.16666666666667, 1.2, 0.45833333333333
42214, 0.16666666666667, 1.25, 0.45833333333333
42215, 0.16666666666667, 1.3, 0.45833333333333
42216, 0.20833333333333, 0.2, 0.041666666666667
42217, 0.20833333333333, 0.25, 0.041666666666667
42218, 0.20833333333333, 0.3, 0.041666666666667
42219, 0.20833333333333, 0.35, 0.041666666666667
42220, 0.20833333333333, 0.4, 0.041666666666667
42221, 0.20833333333333, 0.45, 0.041666666666667
42222, 0.20833333333333, 0.5, 0.041666666666667
42223, 0.20833333333333, 0.55, 0.041666666666667
42224, 0.20833333333333, 0.6, 0.041666666666667
42225, 0.20833333333333, 0.65, 0.041666666666667
42226, 0.20833333333333, 0.7, 0.041666666666667
42227, 0.20833333333333, 0.75, 0.041666666666667
42228, 0.20833333333333, 0.8, 0.041666666666667
42229, 0.20833333333333, 0.85, 0.041666666666667
42230, 0.20833333333333, 0.9, 0.041666666666667
42231, 0.20833333333333, 0.95, 0.041666666666667
42232, 0.20833333333333, 1, 0.041666666666667
42233, 0.20833333333333, 1.05, 0.041666666666667
42234, 0.20833333333333, 1.1, 0.041666666666667
42235, 0.20833333333333, 1.15, 0.041666666666667
42236, 0.20833333333333, 1.2, 0.041666666666667
42237, 0.20833333333333, 1.25, 0.041666666666667
42238, 0.20833333333333, 1.3, 0.041666666666667
42239, 0.20833333333333, 0.2, 0.083333333333333
42240, 0.20833333333333, 0.25, 0.083333333333333
42241, 0.20833333333333, 0.3, 0.083333333333333
42242, 0.20833333333333, 0.35, 0.083333333333333
42243, 0.20833333333333, 0.4, 0.083333333333333
42244, 0.20833333333333, 0.45, 0.083333333333333
42245, 0.20833333333333, 0.5, 0.083333333333333
42246, 0.20833333333333, 0.55, 0.083333333333333
42247, 0.20833333333333, 0.6, 0.083333333333333
42248, 0.20833333333333, 0.65, 0.083333333333333
42249, 0.20833333333333, 0.7, 0.083333333333333
42250, 0.20833333333333, 0.75, 0.083333333333333
42251, 0.20833333333333, 0.8, 0.083333333333333
42252, 0.20833333333333, 0.85, 0.083333333333333
42253, 0.20833333333333, 0.9, 0.083333333333333
42254, 0.20833333333333, 0.95, 0.083333333333333
42255, 0.20833333333333, 1, 0.083333333333333
42256, 0.20833333333333, 1.05, 0.083333333333333
42257, 0.20833333333333, 1.1, 0.083333333333333
42258, 0.20833333333333, 1.15, 0.083333333333333
42259, 0.20833333333333, 1.2, 0.083333333333333
42260, 0.20833333333333, 1.25, 0.083333333333333
42261, 0.20833333333333, 1.3, 0.083333333333333
42262, 0.20833333333333, 0.2, 0.125
42263, 0.20833333333333, 0.25, 0.125
42264, 0.20833333333333, 0.3, 0.125
42265, 0.20833333333333, 0.35, 0.125
42266, 0.20833333333333, 0.4, 0.125
42267, 0.20833333333333, 0.45, 0.125
42268, 0.20833333333333, 0.5, 0.125
42269, 0.20833333333333, 0.55, 0.125
42270, 0.20833333333333, 0.6, 0.125
42271, 0.20833333333333, 0.65, 0.125
42272, 0.20833333333333, 0.7, 0.125
42273, 0.20833333333333, 0.75, 0.125
42274, 0.20833333333333, 0.8, 0.125
42275, 0.20833333333333, 0.85, 0.125
42276, 0.20833333333333, 0.9, 0.125
42277, 0.20833333333333, 0.95, 0.125
42278, 0.20833333333333, 1, 0.125
42279, 0.20833333333333, 1.05, 0.125
42280, 0.20833333333333, 1.1, 0.125
42281, 0.20833333333333, 1.15, 0.125
42282, 0.20833333333333, 1.2, 0.125
42283, 0.20833333333333, 1.25, 0.125
42284, 0.20833333333333, 1.3, 0.125
42285, 0.20833333333333, 0.2, 0.16666666666667
42286, 0.20833333333333, 0.25, 0.16666666666667
42287, 0.20833333333333, 0.3, 0.16666666666667
42288, 0.20833333333333, 0.35, 0.16666666666667
42289, 0.20833333333333, 0.4, 0.16666666666667
42290, 0.20833333333333, 0.45, 0.16666666666667
42291, 0.20833333333333, 0.5, 0.16666666666667
42292, 0.20833333333333, 0.55, 0.16666666666667
42293, 0.20833333333333, 0.6, 0.16666666666667
42294, 0.20833333333333, 0.65, 0.16666666666667
42295, 0.20833333333333, 0.7, 0.16666666666667
42296, 0.20833333333333, 0.75, 0.16666666666667
42297, 0.20833333333333, 0.8, 0.16666666666667
42298, 0.20833333333333, 0.85, 0.16666666666667
42299, 0.20833333333333, 0.9, 0.16666666666667
42300, 0.20833333333333, 0.95, 0.16666666666667
42301, 0.20833333333333, 1, 0.16666666666667
42302, 0.20833333333333, 1.05, 0.16666666666667
42303, 0.20833333333333, 1.1, 0.16666666666667
42304, 0.20833333333333, 1.15, 0.16666666666667
42305, 0.20833333333333, 1.2, 0.16666666666667
42306, 0.20833333333333, 1.25, 0.16666666666667
42307, 0.20833333333333, 1.3, 0.16666666666667
42308, 0.20833333333333, 0.2, 0.20833333333333
42309, 0.20833333333333, 0.25, 0.20833333333333
42310, 0.20833333333333, 0.3, 0.20833333333333
42311, 0.20833333333333, 0.35, 0.20833333333333
42312, 0.20833333333333, 0.4, 0.20833333333333
42313, 0.20833333333333, 0.45, 0.20833333333333
42314, 0.20833333333333, 0.5, 0.20833333333333
42315, 0.20833333333333, 0.55, 0.20833333333333
42316, 0.20833333333333, 0.6, 0.20833333333333
42317, 0.20833333333333, 0.65, 0.20833333333333
42318, 0.20833333333333, 0.7, 0.20833333333333
42319, 0.20833333333333, 0.75, 0.20833333333333
42320, 0.20833333333333, 0.8, 0.20833333333333
42321, 0.20833333333333, 0.85, 0.20833333333333
42322, 0.20833333333333, 0.9, 0.20833333333333
