96891, 1.4083333333333, 0.033333333333333, 0.1875
96892, 1.3875, 0.033333333333333, 0.20833333333333
96893, 1.4083333333333, 0.016666666666667, 0.20833333333333
96894, 1.45, 0.083333333333333, 0.20833333333333
96895, 1.45, 0.066666666666667, 0.1875
96896, 1.4291666666667, 0.066666666666667, 0.20833333333333
96897, 1.45, 0.05, 0.20833333333333
96898, 1.45, 0.033333333333333, 0.1875
96899, 1.4291666666667, 0.033333333333333, 0.20833333333333
96900, 1.45, 0.016666666666667, 0.20833333333333
96901, 1.4916666666667, 0.083333333333333, 0.20833333333333
96902, 1.4916666666667, 0.066666666666667, 0.1875
96903, 1.4708333333333, 0.066666666666667, 0.20833333333333
96904, 1.4916666666667, 0.05, 0.20833333333333
96905, 1.4916666666667, 0.033333333333333, 0.1875
96906, 1.4708333333333, 0.033333333333333, 0.20833333333333
96907, 1.4916666666667, 0.016666666666667, 0.20833333333333
96908, 1.5333333333333, 0.083333333333333, 0.20833333333333
96909, 1.5333333333333, 0.066666666666667, 0.1875
96910, 1.5125, 0.066666666666667, 0.20833333333333
96911, 1.5333333333333, 0.05, 0.20833333333333
96912, 1.5333333333333, 0.033333333333333, 0.1875
96913, 1.5125, 0.033333333333333, 0.20833333333333
96914, 1.5333333333333, 0.016666666666667, 0.20833333333333
96915, 1.575, 0.083333333333333, 0.20833333333333
96916, 1.575, 0.066666666666667, 0.1875
96917, 1.5541666666667, 0.066666666666667, 0.20833333333333
96918, 1.575, 0.05, 0.20833333333333
96919, 1.575, 0.033333333333333, 0.1875
96920, 1.5541666666667, 0.033333333333333, 0.20833333333333
96921, 1.575, 0.016666666666667, 0.20833333333333
96922, 1.6166666666667, 0.083333333333333, 0.20833333333333
96923, 1.6166666666667, 0.066666666666667, 0.1875
96924, 1.5958333333333, 0.066666666666667, 0.20833333333333
96925, 1.6166666666667, 0.05, 0.20833333333333
96926, 1.6166666666667, 0.033333333333333, 0.1875
96927, 1.5958333333333, 0.033333333333333, 0.20833333333333
96928, 1.6166666666667, 0.016666666666667, 0.20833333333333
96929, 1.6583333333333, 0.083333333333333, 0.20833333333333
96930, 1.6583333333333, 0.066666666666667, 0.1875
96931, 1.6375, 0.066666666666667, 0.20833333333333
96932, 1.6583333333333, 0.05, 0.20833333333333
96933, 1.6583333333333, 0.033333333333333, 0.1875
96934, 1.6375, 0.033333333333333, 0.20833333333333
96935, 1.6583333333333, 0.016666666666667, 0.20833333333333
96936, 1.7, 0.083333333333333, 0.20833333333333
96937, 1.7, 0.066666666666667, 0.1875
96938, 1.6791666666667, 0.066666666666667, 0.20833333333333
96939, 1.7, 0.05, 0.20833333333333
96940, 1.7, 0.033333333333333, 0.1875
96941, 1.6791666666667, 0.033333333333333, 0.20833333333333
96942, 1.7, 0.016666666666667, 0.20833333333333
96943, 1.7416666666667, 0.083333333333333, 0.20833333333333
96944, 1.7416666666667, 0.066666666666667, 0.1875
96945, 1.7208333333333, 0.066666666666667, 0.20833333333333
96946, 1.7416666666667, 0.05, 0.20833333333333
96947, 1.7416666666667, 0.033333333333333, 0.1875
96948, 1.7208333333333, 0.033333333333333, 0.20833333333333
96949, 1.7416666666667, 0.016666666666667, 0.20833333333333
96950, 1.7833333333333, 0.083333333333333, 0.20833333333333
96951, 1.7833333333333, 0.066666666666667, 0.1875
96952, 1.7625, 0.066666666666667, 0.20833333333333
96953, 1.7833333333333, 0.05, 0.20833333333333
96954, 1.7833333333333, 0.033333333333333, 0.1875
96955, 1.7625, 0.033333333333333, 0.20833333333333
96956, 1.7833333333333, 0.016666666666667, 0.20833333333333
96957, 1.825, 0.083333333333333, 0.20833333333333
96958, 1.825, 0.066666666666667, 0.1875
96959, 1.8041666666667, 0.066666666666667, 0.20833333333333
96960, 1.825, 0.05, 0.20833333333333
96961, 1.825, 0.033333333333333, 0.1875
96962, 1.8041666666667, 0.033333333333333, 0.20833333333333
96963, 1.825, 0.016666666666667, 0.20833333333333
96964, 1.8666666666667, 0.083333333333333, 0.20833333333333
96965, 1.8666666666667, 0.066666666666667, 0.1875
96966, 1.8458333333333, 0.066666666666667, 0.20833333333333
96967, 1.8666666666667, 0.05, 0.20833333333333
96968, 1.8666666666667, 0.033333333333333, 0.1875
96969, 1.8458333333333, 0.033333333333333, 0.20833333333333
96970, 1.8666666666667, 0.016666666666667, 0.20833333333333
96971, 1.9083333333333, 0.083333333333333, 0.20833333333333
96972, 1.9083333333333, 0.066666666666667, 0.1875
96973, 1.8875, 0.066666666666667, 0.20833333333333
96974, 1.9083333333333, 0.05, 0.20833333333333
96975, 1.9083333333333, 0.033333333333333, 0.1875
96976, 1.8875, 0.033333333333333, 0.20833333333333
96977, 1.9083333333333, 0.016666666666667, 0.20833333333333
96978, 1.95, 0.083333333333333, 0.20833333333333
96979, 1.95, 0.066666666666667, 0.1875
96980, 1.9291666666667, 0.066666666666667, 0.20833333333333
96981, 1.95, 0.05, 0.20833333333333
96982, 1.95, 0.033333333333333, 0.1875
96983, 1.9291666666667, 0.033333333333333, 0.20833333333333
96984, 1.95, 0.016666666666667, 0.20833333333333
96985, 1.9916666666667, 0.083333333333333, 0.20833333333333
96986, 1.9916666666667, 0.066666666666667, 0.1875
96987, 1.9708333333333, 0.066666666666667, 0.20833333333333
96988, 1.9916666666667, 0.05, 0.20833333333333
96989, 1.9916666666667, 0.033333333333333, 0.1875
96990, 1.9708333333333, 0.033333333333333, 0.20833333333333
96991, 1.9916666666667, 0.016666666666667, 0.20833333333333
96992, 2.0333333333333, 0.083333333333333, 0.20833333333333
96993, 2.0333333333333, 0.066666666666667, 0.1875
96994, 2.0125, 0.066666666666667, 0.20833333333333
96995, 2.0333333333333, 0.05, 0.20833333333333
96996, 2.0333333333333, 0.033333333333333, 0.1875
96997, 2.0125, 0.033333333333333, 0.20833333333333
96998, 2.0333333333333, 0.016666666666667, 0.20833333333333
96999, 2.075, 0.083333333333333, 0.20833333333333
97000, 2.075, 0.066666666666667, 0.1875
97001, 2.0541666666667, 0.066666666666667, 0.20833333333333
97002, 2.075, 0.05, 0.20833333333333
97003, 2.075, 0.033333333333333, 0.1875
97004, 2.0541666666667, 0.033333333333333, 0.20833333333333
97005, 2.075, 0.016666666666667, 0.20833333333333
97006, 2.1166666666667, 0.083333333333333, 0.20833333333333
97007, 2.1166666666667, 0.066666666666667, 0.1875
97008, 2.0958333333333, 0.066666666666667, 0.20833333333333
97009, 2.1166666666667, 0.05, 0.20833333333333
97010, 2.1166666666667, 0.033333333333333, 0.1875
97011, 2.0958333333333, 0.033333333333333, 0.20833333333333
97012, 2.1166666666667, 0.016666666666667, 0.20833333333333
97013, 2.1583333333333, 0.083333333333333, 0.20833333333333
97014, 2.1583333333333, 0.066666666666667, 0.1875
97015, 2.1375, 0.066666666666667, 0.20833333333333
97016, 2.1583333333333, 0.05, 0.20833333333333
97017, 2.1583333333333, 0.033333333333333, 0.1875
97018, 2.1375, 0.033333333333333, 0.20833333333333
97019, 2.1583333333333, 0.016666666666667, 0.20833333333333
97020, 2.1791666666667, 0.066666666666667, 0.20833333333333
97021, 2.1791666666667, 0.033333333333333, 0.20833333333333
97022, 1.2416666666667, 0.083333333333333, 0.25
97023, 1.2416666666667, 0.066666666666667, 0.22916666666667
97024, 1.2208333333333, 0.066666666666667, 0.25
97025, 1.2416666666667, 0.05, 0.25
97026, 1.2416666666667, 0.033333333333333, 0.22916666666667
97027, 1.2208333333333, 0.033333333333333, 0.25
97028, 1.2416666666667, 0.016666666666667, 0.25
97029, 1.2833333333333, 0.083333333333333, 0.25
97030, 1.2833333333333, 0.066666666666667, 0.22916666666667
97031, 1.2625, 0.066666666666667, 0.25
97032, 1.2833333333333, 0.05, 0.25
97033, 1.2833333333333, 0.033333333333333, 0.22916666666667
97034, 1.2625, 0.033333333333333, 0.25
97035, 1.2833333333333, 0.016666666666667, 0.25
97036, 1.325, 0.083333333333333, 0.25
97037, 1.325, 0.066666666666667, 0.22916666666667
97038, 1.3041666666667, 0.066666666666667, 0.25
97039, 1.325, 0.05, 0.25
97040, 1.325, 0.033333333333333, 0.22916666666667
97041, 1.3041666666667, 0.033333333333333, 0.25
97042, 1.325, 0.016666666666667, 0.25
97043, 1.3666666666667, 0.083333333333333, 0.25
97044, 1.3666666666667, 0.066666666666667, 0.22916666666667
97045, 1.3458333333333, 0.066666666666667, 0.25
97046, 1.3666666666667, 0.05, 0.25
97047, 1.3666666666667, 0.033333333333333, 0.22916666666667
97048, 1.3458333333333, 0.033333333333333, 0.25
97049, 1.3666666666667, 0.016666666666667, 0.25
97050, 1.4083333333333, 0.083333333333333, 0.25
97051, 1.4083333333333, 0.066666666666667, 0.22916666666667
97052, 1.3875, 0.066666666666667, 0.25
97053, 1.4083333333333, 0.05, 0.25
97054, 1.4083333333333, 0.033333333333333, 0.22916666666667
97055, 1.3875, 0.033333333333333, 0.25
97056, 1.4083333333333, 0.016666666666667, 0.25
97057, 1.45, 0.083333333333333, 0.25
97058, 1.45, 0.066666666666667, 0.22916666666667
97059, 1.4291666666667, 0.066666666666667, 0.25
97060, 1.45, 0.05, 0.25
97061, 1.45, 0.033333333333333, 0.22916666666667
97062, 1.4291666666667, 0.033333333333333, 0.25
97063, 1.45, 0.016666666666667, 0.25
97064, 1.4916666666667, 0.083333333333333, 0.25
97065, 1.4916666666667, 0.066666666666667, 0.22916666666667
97066, 1.4708333333333, 0.066666666666667, 0.25
97067, 1.4916666666667, 0.05, 0.25
97068, 1.4916666666667, 0.033333333333333, 0.22916666666667
97069, 1.4708333333333, 0.033333333333333, 0.25
97070, 1.4916666666667, 0.016666666666667, 0.25
97071, 1.5333333333333, 0.083333333333333, 0.25
97072, 1.5333333333333, 0.066666666666667, 0.22916666666667
97073, 1.5125, 0.066666666666667, 0.25
97074, 1.5333333333333, 0.05, 0.25
97075, 1.5333333333333, 0.033333333333333, 0.22916666666667
97076, 1.5125, 0.033333333333333, 0.25
97077, 1.5333333333333, 0.016666666666667, 0.25
97078, 1.575, 0.083333333333333, 0.25
97079, 1.575, 0.066666666666667, 0.22916666666667
97080, 1.5541666666667, 0.066666666666667, 0.25
97081, 1.575, 0.05, 0.25
97082, 1.575, 0.033333333333333, 0.22916666666667
97083, 1.5541666666667, 0.033333333333333, 0.25
97084, 1.575, 0.016666666666667, 0.25
97085, 1.6166666666667, 0.083333333333333, 0.25
97086, 1.6166666666667, 0.066666666666667, 0.22916666666667
97087, 1.5958333333333, 0.066666666666667, 0.25
97088, 1.6166666666667, 0.05, 0.25
97089, 1.6166666666667, 0.033333333333333, 0.22916666666667
97090, 1.5958333333333, 0.033333333333333, 0.25
97091, 1.6166666666667, 0.016666666666667, 0.25
97092, 1.6583333333333, 0.083333333333333, 0.25
97093, 1.6583333333333, 0.066666666666667, 0.22916666666667
97094, 1.6375, 0.066666666666667, 0.25
97095, 1.6583333333333, 0.05, 0.25
97096, 1.6583333333333, 0.033333333333333, 0.22916666666667
97097, 1.6375, 0.033333333333333, 0.25
97098, 1.6583333333333, 0.016666666666667, 0.25
97099, 1.7, 0.083333333333333, 0.25
97100, 1.7, 0.066666666666667, 0.22916666666667
97101, 1.6791666666667, 0.066666666666667, 0.25
97102, 1.7, 0.05, 0.25
97103, 1.7, 0.033333333333333, 0.22916666666667
97104, 1.6791666666667, 0.033333333333333, 0.25
97105, 1.7, 0.016666666666667, 0.25
97106, 1.7416666666667, 0.083333333333333, 0.25
97107, 1.7416666666667, 0.066666666666667, 0.22916666666667
97108, 1.7208333333333, 0.066666666666667, 0.25
97109, 1.7416666666667, 0.05, 0.25
97110, 1.7416666666667, 0.033333333333333, 0.22916666666667
97111, 1.7208333333333, 0.033333333333333, 0.25
97112, 1.7416666666667, 0.016666666666667, 0.25
97113, 1.7833333333333, 0.083333333333333, 0.25
97114, 1.7833333333333, 0.066666666666667, 0.22916666666667
97115, 1.7625, 0.066666666666667, 0.25
97116, 1.7833333333333, 0.05, 0.25
97117, 1.7833333333333, 0.033333333333333, 0.22916666666667
97118, 1.7625, 0.033333333333333, 0.25
97119, 1.7833333333333, 0.016666666666667, 0.25
97120, 1.825, 0.083333333333333, 0.25
97121, 1.825, 0.066666666666667, 0.22916666666667
97122, 1.8041666666667, 0.066666666666667, 0.25
97123, 1.825, 0.05, 0.25
97124, 1.825, 0.033333333333333, 0.22916666666667
97125, 1.8041666666667, 0.033333333333333, 0.25
97126, 1.825, 0.016666666666667, 0.25
97127, 1.8666666666667, 0.083333333333333, 0.25
97128, 1.8666666666667, 0.066666666666667, 0.22916666666667
97129, 1.8458333333333, 0.066666666666667, 0.25
97130, 1.8666666666667, 0.05, 0.25
97131, 1.8666666666667, 0.033333333333333, 0.22916666666667
97132, 1.8458333333333, 0.033333333333333, 0.25
97133, 1.8666666666667, 0.016666666666667, 0.25
97134, 1.9083333333333, 0.083333333333333, 0.25
97135, 1.9083333333333, 0.066666666666667, 0.22916666666667
97136, 1.8875, 0.066666666666667, 0.25
97137, 1.9083333333333, 0.05, 0.25
97138, 1.9083333333333, 0.033333333333333, 0.22916666666667
97139, 1.8875, 0.033333333333333, 0.25
97140, 1.9083333333333, 0.016666666666667, 0.25
97141, 1.95, 0.083333333333333, 0.25
97142, 1.95, 0.066666666666667, 0.22916666666667
97143, 1.9291666666667, 0.066666666666667, 0.25
97144, 1.95, 0.05, 0.25
97145, 1.95, 0.033333333333333, 0.22916666666667
97146, 1.9291666666667, 0.033333333333333, 0.25
97147, 1.95, 0.016666666666667, 0.25
97148, 1.9916666666667, 0.083333333333333, 0.25
97149, 1.9916666666667, 0.066666666666667, 0.22916666666667
97150, 1.9708333333333, 0.066666666666667, 0.25
97151, 1.9916666666667, 0.05, 0.25
97152, 1.9916666666667, 0.033333333333333, 0.22916666666667
97153, 1.9708333333333, 0.033333333333333, 0.25
97154, 1.9916666666667, 0.016666666666667, 0.25
97155, 2.0333333333333, 0.083333333333333, 0.25
97156, 2.0333333333333, 0.066666666666667, 0.22916666666667
97157, 2.0125, 0.066666666666667, 0.25
97158, 2.0333333333333, 0.05, 0.25
97159, 2.0333333333333, 0.033333333333333, 0.22916666666667
97160, 2.0125, 0.033333333333333, 0.25
97161, 2.0333333333333, 0.016666666666667, 0.25
97162, 2.075, 0.083333333333333, 0.25
97163, 2.075, 0.066666666666667, 0.22916666666667
97164, 2.0541666666667, 0.066666666666667, 0.25
97165, 2.075, 0.05, 0.25
97166, 2.075, 0.033333333333333, 0.22916666666667
97167, 2.0541666666667, 0.033333333333333, 0.25
97168, 2.075, 0.016666666666667, 0.25
97169, 2.1166666666667, 0.083333333333333, 0.25
97170, 2.1166666666667, 0.066666666666667, 0.22916666666667
97171, 2.0958333333333, 0.066666666666667, 0.25
97172, 2.1166666666667, 0.05, 0.25
97173, 2.1166666666667, 0.033333333333333, 0.22916666666667
97174, 2.0958333333333, 0.033333333333333, 0.25
97175, 2.1166666666667, 0.016666666666667, 0.25
97176, 2.1583333333333, 0.083333333333333, 0.25
97177, 2.1583333333333, 0.066666666666667, 0.22916666666667
97178, 2.1375, 0.066666666666667, 0.25
97179, 2.1583333333333, 0.05, 0.25
97180, 2.1583333333333, 0.033333333333333, 0.22916666666667
97181, 2.1375, 0.033333333333333, 0.25
97182, 2.1583333333333, 0.016666666666667, 0.25
97183, 2.1791666666667, 0.066666666666667, 0.25
97184, 2.1791666666667, 0.033333333333333, 0.25
97185, 1.2416666666667, 0.083333333333333, 0.29166666666667
97186, 1.2416666666667, 0.066666666666667, 0.27083333333333
97187, 1.2208333333333, 0.066666666666667, 0.29166666666667
97188, 1.2416666666667, 0.05, 0.29166666666667
97189, 1.2416666666667, 0.033333333333333, 0.27083333333333
97190, 1.2208333333333, 0.033333333333333, 0.29166666666667
97191, 1.2416666666667, 0.016666666666667, 0.29166666666667
97192, 1.2833333333333, 0.083333333333333, 0.29166666666667
97193, 1.2833333333333, 0.066666666666667, 0.27083333333333
97194, 1.2625, 0.066666666666667, 0.29166666666667
97195, 1.2833333333333, 0.05, 0.29166666666667
97196, 1.2833333333333, 0.033333333333333, 0.27083333333333
97197, 1.2625, 0.033333333333333, 0.29166666666667
97198, 1.2833333333333, 0.016666666666667, 0.29166666666667
97199, 1.325, 0.083333333333333, 0.29166666666667
97200, 1.325, 0.066666666666667, 0.27083333333333
97201, 1.3041666666667, 0.066666666666667, 0.29166666666667
97202, 1.325, 0.05, 0.29166666666667
97203, 1.325, 0.033333333333333, 0.27083333333333
97204, 1.3041666666667, 0.033333333333333, 0.29166666666667
97205, 1.325, 0.016666666666667, 0.29166666666667
97206, 1.3666666666667, 0.083333333333333, 0.29166666666667
97207, 1.3666666666667, 0.066666666666667, 0.27083333333333
97208, 1.3458333333333, 0.066666666666667, 0.29166666666667
97209, 1.3666666666667, 0.05, 0.29166666666667
97210, 1.3666666666667, 0.033333333333333, 0.27083333333333
97211, 1.3458333333333, 0.033333333333333, 0.29166666666667
97212, 1.3666666666667, 0.016666666666667, 0.29166666666667
97213, 1.4083333333333, 0.083333333333333, 0.29166666666667
97214, 1.4083333333333, 0.066666666666667, 0.27083333333333
97215, 1.3875, 0.066666666666667, 0.29166666666667
97216, 1.4083333333333, 0.05, 0.29166666666667
97217, 1.4083333333333, 0.033333333333333, 0.27083333333333
97218, 1.3875, 0.033333333333333, 0.29166666666667
97219, 1.4083333333333, 0.016666666666667, 0.29166666666667
97220, 1.45, 0.083333333333333, 0.29166666666667
97221, 1.45, 0.066666666666667, 0.27083333333333
97222, 1.4291666666667, 0.066666666666667, 0.29166666666667
97223, 1.45, 0.05, 0.29166666666667
97224, 1.45, 0.033333333333333, 0.27083333333333
97225, 1.4291666666667, 0.033333333333333, 0.29166666666667
97226, 1.45, 0.016666666666667, 0.29166666666667
97227, 1.4916666666667, 0.083333333333333, 0.29166666666667
97228, 1.4916666666667, 0.066666666666667, 0.27083333333333
97229, 1.4708333333333, 0.066666666666667, 0.29166666666667
97230, 1.4916666666667, 0.05, 0.29166666666667
97231, 1.4916666666667, 0.033333333333333, 0.27083333333333
97232, 1.4708333333333, 0.033333333333333, 0.29166666666667
97233, 1.4916666666667, 0.016666666666667, 0.29166666666667
97234, 1.5333333333333, 0.083333333333333, 0.29166666666667
97235, 1.5333333333333, 0.066666666666667, 0.27083333333333
97236, 1.5125, 0.066666666666667, 0.29166666666667
97237, 1.5333333333333, 0.05, 0.29166666666667
97238, 1.5333333333333, 0.033333333333333, 0.27083333333333
97239, 1.5125, 0.033333333333333, 0.29166666666667
97240, 1.5333333333333, 0.016666666666667, 0.29166666666667
97241, 1.575, 0.083333333333333, 0.29166666666667
97242, 1.575, 0.066666666666667, 0.27083333333333
97243, 1.5541666666667, 0.066666666666667, 0.29166666666667
97244, 1.575, 0.05, 0.29166666666667
97245, 1.575, 0.033333333333333, 0.27083333333333
97246, 1.5541666666667, 0.033333333333333, 0.29166666666667
97247, 1.575, 0.016666666666667, 0.29166666666667
97248, 1.6166666666667, 0.083333333333333, 0.29166666666667
97249, 1.6166666666667, 0.066666666666667, 0.27083333333333
97250, 1.5958333333333, 0.066666666666667, 0.29166666666667
97251, 1.6166666666667, 0.05, 0.29166666666667
97252, 1.6166666666667, 0.033333333333333, 0.27083333333333
97253, 1.5958333333333, 0.033333333333333, 0.29166666666667
97254, 1.6166666666667, 0.016666666666667, 0.29166666666667
97255, 1.6583333333333, 0.083333333333333, 0.29166666666667
97256, 1.6583333333333, 0.066666666666667, 0.27083333333333
97257, 1.6375, 0.066666666666667, 0.29166666666667
97258, 1.6583333333333, 0.05, 0.29166666666667
97259, 1.6583333333333, 0.033333333333333, 0.27083333333333
97260, 1.6375, 0.033333333333333, 0.29166666666667
97261, 1.6583333333333, 0.016666666666667, 0.29166666666667
97262, 1.7, 0.083333333333333, 0.29166666666667
97263, 1.7, 0.066666666666667, 0.27083333333333
97264, 1.6791666666667, 0.066666666666667, 0.29166666666667
97265, 1.7, 0.05, 0.29166666666667
97266, 1.7, 0.033333333333333, 0.27083333333333
97267, 1.6791666666667, 0.033333333333333, 0.29166666666667
97268, 1.7, 0.016666666666667, 0.29166666666667
97269, 1.7416666666667, 0.083333333333333, 0.29166666666667
97270, 1.7416666666667, 0.066666666666667, 0.27083333333333
97271, 1.7208333333333, 0.066666666666667, 0.29166666666667
97272, 1.7416666666667, 0.05, 0.29166666666667
97273, 1.7416666666667, 0.033333333333333, 0.27083333333333
97274, 1.7208333333333, 0.033333333333333, 0.29166666666667
97275, 1.7416666666667, 0.016666666666667, 0.29166666666667
97276, 1.7833333333333, 0.083333333333333, 0.29166666666667
97277, 1.7833333333333, 0.066666666666667, 0.27083333333333
97278, 1.7625, 0.066666666666667, 0.29166666666667
97279, 1.7833333333333, 0.05, 0.29166666666667
97280, 1.7833333333333, 0.033333333333333, 0.27083333333333
97281, 1.7625, 0.033333333333333, 0.29166666666667
97282, 1.7833333333333, 0.016666666666667, 0.29166666666667
97283, 1.825, 0.083333333333333, 0.29166666666667
97284, 1.825, 0.066666666666667, 0.27083333333333
97285, 1.8041666666667, 0.066666666666667, 0.29166666666667
97286, 1.825, 0.05, 0.29166666666667
97287, 1.825, 0.033333333333333, 0.27083333333333
97288, 1.8041666666667, 0.033333333333333, 0.29166666666667
97289, 1.825, 0.016666666666667, 0.29166666666667
97290, 1.8666666666667, 0.083333333333333, 0.29166666666667
97291, 1.8666666666667, 0.066666666666667, 0.27083333333333
97292, 1.8458333333333, 0.066666666666667, 0.29166666666667
97293, 1.8666666666667, 0.05, 0.29166666666667
97294, 1.8666666666667, 0.033333333333333, 0.27083333333333
97295, 1.8458333333333, 0.033333333333333, 0.29166666666667
97296, 1.8666666666667, 0.016666666666667, 0.29166666666667
97297, 1.9083333333333, 0.083333333333333, 0.29166666666667
97298, 1.9083333333333, 0.066666666666667, 0.27083333333333
97299, 1.8875, 0.066666666666667, 0.29166666666667
97300, 1.9083333333333, 0.05, 0.29166666666667
97301, 1.9083333333333, 0.033333333333333, 0.27083333333333
97302, 1.8875, 0.033333333333333, 0.29166666666667
97303, 1.9083333333333, 0.016666666666667, 0.29166666666667
97304, 1.95, 0.083333333333333, 0.29166666666667
97305, 1.95, 0.066666666666667, 0.27083333333333
97306, 1.9291666666667, 0.066666666666667, 0.29166666666667
97307, 1.95, 0.05, 0.29166666666667
97308, 1.95, 0.033333333333333, 0.27083333333333
97309, 1.9291666666667, 0.033333333333333, 0.29166666666667
97310, 1.95, 0.016666666666667, 0.29166666666667
97311, 1.9916666666667, 0.083333333333333, 0.29166666666667
97312, 1.9916666666667, 0.066666666666667, 0.27083333333333
97313, 1.9708333333333, 0.066666666666667, 0.29166666666667
97314, 1.9916666666667, 0.05, 0.29166666666667
97315, 1.9916666666667, 0.033333333333333, 0.27083333333333
97316, 1.9708333333333, 0.033333333333333, 0.29166666666667
97317, 1.9916666666667, 0.016666666666667, 0.29166666666667
97318, 2.0333333333333, 0.083333333333333, 0.29166666666667
97319, 2.0333333333333, 0.066666666666667, 0.27083333333333
97320, 2.0125, 0.066666666666667, 0.29166666666667
97321, 2.0333333333333, 0.05, 0.29166666666667
97322, 2.0333333333333, 0.033333333333333, 0.27083333333333
97323, 2.0125, 0.033333333333333, 0.29166666666667
97324, 2.0333333333333, 0.016666666666667, 0.29166666666667
97325, 2.075, 0.083333333333333, 0.29166666666667
97326, 2.075, 0.066666666666667, 0.27083333333333
97327, 2.0541666666667, 0.066666666666667, 0.29166666666667
97328, 2.075, 0.05, 0.29166666666667
97329, 2.075, 0.033333333333333, 0.27083333333333
97330, 2.0541666666667, 0.033333333333333, 0.29166666666667
97331, 2.075, 0.016666666666667, 0.29166666666667
97332, 2.1166666666667, 0.083333333333333, 0.29166666666667
97333, 2.1166666666667, 0.066666666666667, 0.27083333333333
97334, 2.0958333333333, 0.066666666666667, 0.29166666666667
97335, 2.1166666666667, 0.05, 0.29166666666667
97336, 2.1166666666667, 0.033333333333333, 0.27083333333333
97337, 2.0958333333333, 0.033333333333333, 0.29166666666667
97338, 2.1166666666667, 0.016666666666667, 0.29166666666667
97339, 2.1583333333333, 0.083333333333333, 0.29166666666667
97340, 2.1583333333333, 0.066666666666667, 0.27083333333333
97341, 2.1375, 0.066666666666667, 0.29166666666667
97342, 2.1583333333333, 0.05, 0.29166666666667
97343, 2.1583333333333, 0.033333333333333, 0.27083333333333
97344, 2.1375, 0.033333333333333, 0.29166666666667
97345, 2.1583333333333, 0.016666666666667, 0.29166666666667
97346, 2.1791666666667, 0.066666666666667, 0.29166666666667
97347, 2.1791666666667, 0.033333333333333, 0.29166666666667
97348, 1.2416666666667, 0.083333333333333, 0.33333333333333
97349, 1.2416666666667, 0.066666666666667, 0.3125
97350, 1.2208333333333, 0.066666666666667, 0.33333333333333
97351, 1.2416666666667, 0.05, 0.33333333333333
97352, 1.2416666666667, 0.033333333333333, 0.3125
97353, 1.2208333333333, 0.033333333333333, 0.33333333333333
97354, 1.2416666666667, 0.016666666666667, 0.33333333333333
97355, 1.2833333333333, 0.083333333333333, 0.33333333333333
97356, 1.2833333333333, 0.066666666666667, 0.3125
97357, 1.2625, 0.066666666666667, 0.33333333333333
97358, 1.2833333333333, 0.05, 0.33333333333333
97359, 1.2833333333333, 0.033333333333333, 0.3125
97360, 1.2625, 0.033333333333333, 0.33333333333333
97361, 1.2833333333333, 0.016666666666667, 0.33333333333333
97362, 1.325, 0.083333333333333, 0.33333333333333
97363, 1.325, 0.066666666666667, 0.3125
97364, 1.3041666666667, 0.066666666666667, 0.33333333333333
97365, 1.325, 0.05, 0.33333333333333
97366, 1.325, 0.033333333333333, 0.3125
97367, 1.3041666666667, 0.033333333333333, 0.33333333333333
97368, 1.325, 0.016666666666667, 0.33333333333333
97369, 1.3666666666667, 0.083333333333333, 0.33333333333333
97370, 1.3666666666667, 0.066666666666667, 0.3125
97371, 1.3458333333333, 0.066666666666667, 0.33333333333333
97372, 1.3666666666667, 0.05, 0.33333333333333
97373, 1.3666666666667, 0.033333333333333, 0.3125
97374, 1.3458333333333, 0.033333333333333, 0.33333333333333
97375, 1.3666666666667, 0.016666666666667, 0.33333333333333
97376, 1.4083333333333, 0.083333333333333, 0.33333333333333
97377, 1.4083333333333, 0.066666666666667, 0.3125
97378, 1.3875, 0.066666666666667, 0.33333333333333
97379, 1.4083333333333, 0.05, 0.33333333333333
97380, 1.4083333333333, 0.033333333333333, 0.3125
97381, 1.3875, 0.033333333333333, 0.33333333333333
97382, 1.4083333333333, 0.016666666666667, 0.33333333333333
97383, 1.45, 0.083333333333333, 0.33333333333333
97384, 1.45, 0.066666666666667, 0.3125
97385, 1.4291666666667, 0.066666666666667, 0.33333333333333
97386, 1.45, 0.05, 0.33333333333333
97387, 1.45, 0.033333333333333, 0.3125
97388, 1.4291666666667, 0.033333333333333, 0.33333333333333
97389, 1.45, 0.016666666666667, 0.33333333333333
97390, 1.4916666666667, 0.083333333333333, 0.33333333333333
97391, 1.4916666666667, 0.066666666666667, 0.3125
97392, 1.4708333333333, 0.066666666666667, 0.33333333333333
97393, 1.4916666666667, 0.05, 0.33333333333333
97394, 1.4916666666667, 0.033333333333333, 0.3125
97395, 1.4708333333333, 0.033333333333333, 0.33333333333333
97396, 1.4916666666667, 0.016666666666667, 0.33333333333333
97397, 1.5333333333333, 0.083333333333333, 0.33333333333333
97398, 1.5333333333333, 0.066666666666667, 0.3125
97399, 1.5125, 0.066666666666667, 0.33333333333333
97400, 1.5333333333333, 0.05, 0.33333333333333
97401, 1.5333333333333, 0.033333333333333, 0.3125
97402, 1.5125, 0.033333333333333, 0.33333333333333
97403, 1.5333333333333, 0.016666666666667, 0.33333333333333
97404, 1.575, 0.083333333333333, 0.33333333333333
97405, 1.575, 0.066666666666667, 0.3125
97406, 1.5541666666667, 0.066666666666667, 0.33333333333333
97407, 1.575, 0.05, 0.33333333333333
97408, 1.575, 0.033333333333333, 0.3125
97409, 1.5541666666667, 0.033333333333333, 0.33333333333333
97410, 1.575, 0.016666666666667, 0.33333333333333
97411, 1.6166666666667, 0.083333333333333, 0.33333333333333
97412, 1.6166666666667, 0.066666666666667, 0.3125
97413, 1.5958333333333, 0.066666666666667, 0.33333333333333
97414, 1.6166666666667, 0.05, 0.33333333333333
97415, 1.6166666666667, 0.033333333333333, 0.3125
97416, 1.5958333333333, 0.033333333333333, 0.33333333333333
97417, 1.6166666666667, 0.016666666666667, 0.33333333333333
97418, 1.6583333333333, 0.083333333333333, 0.33333333333333
97419, 1.6583333333333, 0.066666666666667, 0.3125
97420, 1.6375, 0.066666666666667, 0.33333333333333
97421, 1.6583333333333, 0.05, 0.33333333333333
97422, 1.6583333333333, 0.033333333333333, 0.3125
97423, 1.6375, 0.033333333333333, 0.33333333333333
97424, 1.6583333333333, 0.016666666666667, 0.33333333333333
97425, 1.7, 0.083333333333333, 0.33333333333333
97426, 1.7, 0.066666666666667, 0.3125
97427, 1.6791666666667, 0.066666666666667, 0.33333333333333
97428, 1.7, 0.05, 0.33333333333333
97429, 1.7, 0.033333333333333, 0.3125
97430, 1.6791666666667, 0.033333333333333, 0.33333333333333
97431, 1.7, 0.016666666666667, 0.33333333333333
97432, 1.7416666666667, 0.083333333333333, 0.33333333333333
97433, 1.7416666666667, 0.066666666666667, 0.3125
97434, 1.7208333333333, 0.066666666666667, 0.33333333333333
97435, 1.7416666666667, 0.05, 0.33333333333333
97436, 1.7416666666667, 0.033333333333333, 0.3125
97437, 1.7208333333333, 0.033333333333333, 0.33333333333333
97438, 1.7416666666667, 0.016666666666667, 0.33333333333333
97439, 1.7833333333333, 0.083333333333333, 0.33333333333333
97440, 1.7833333333333, 0.066666666666667, 0.3125
97441, 1.7625, 0.066666666666667, 0.33333333333333
97442, 1.7833333333333, 0.05, 0.33333333333333
97443, 1.7833333333333, 0.033333333333333, 0.3125
97444, 1.7625, 0.033333333333333, 0.33333333333333
97445, 1.7833333333333, 0.016666666666667, 0.33333333333333
97446, 1.825, 0.083333333333333, 0.33333333333333
97447, 1.825, 0.066666666666667, 0.3125
97448, 1.8041666666667, 0.066666666666667, 0.33333333333333
97449, 1.825, 0.05, 0.33333333333333
97450, 1.825, 0.033333333333333, 0.3125
97451, 1.8041666666667, 0.033333333333333, 0.33333333333333
97452, 1.825, 0.016666666666667, 0.33333333333333
97453, 1.8666666666667, 0.083333333333333, 0.33333333333333
97454, 1.8666666666667, 0.066666666666667, 0.3125
97455, 1.8458333333333, 0.066666666666667, 0.33333333333333
97456, 1.8666666666667, 0.05, 0.33333333333333
97457, 1.8666666666667, 0.033333333333333, 0.3125
97458, 1.8458333333333, 0.033333333333333, 0.33333333333333
97459, 1.8666666666667, 0.016666666666667, 0.33333333333333
97460, 1.9083333333333, 0.083333333333333, 0.33333333333333
97461, 1.9083333333333, 0.066666666666667, 0.3125
97462, 1.8875, 0.066666666666667, 0.33333333333333
97463, 1.9083333333333, 0.05, 0.33333333333333
97464, 1.9083333333333, 0.033333333333333, 0.3125
97465, 1.8875, 0.033333333333333, 0.33333333333333
97466, 1.9083333333333, 0.016666666666667, 0.33333333333333
97467, 1.95, 0.083333333333333, 0.33333333333333
97468, 1.95, 0.066666666666667, 0.3125
97469, 1.9291666666667, 0.066666666666667, 0.33333333333333
97470, 1.95, 0.05, 0.33333333333333
97471, 1.95, 0.033333333333333, 0.3125
97472, 1.9291666666667, 0.033333333333333, 0.33333333333333
97473, 1.95, 0.016666666666667, 0.33333333333333
97474, 1.9916666666667, 0.083333333333333, 0.33333333333333
97475, 1.9916666666667, 0.066666666666667, 0.3125
97476, 1.9708333333333, 0.066666666666667, 0.33333333333333
97477, 1.9916666666667, 0.05, 0.33333333333333
97478, 1.9916666666667, 0.033333333333333, 0.3125
97479, 1.9708333333333, 0.033333333333333, 0.33333333333333
97480, 1.9916666666667, 0.016666666666667, 0.33333333333333
97481, 2.0333333333333, 0.083333333333333, 0.33333333333333
97482, 2.0333333333333, 0.066666666666667, 0.3125
97483, 2.0125, 0.066666666666667, 0.33333333333333
97484, 2.0333333333333, 0.05, 0.33333333333333
97485, 2.0333333333333, 0.033333333333333, 0.3125
97486, 2.0125, 0.033333333333333, 0.33333333333333
97487, 2.0333333333333, 0.016666666666667, 0.33333333333333
97488, 2.075, 0.083333333333333, 0.33333333333333
97489, 2.075, 0.066666666666667, 0.3125
97490, 2.0541666666667, 0.066666666666667, 0.33333333333333
97491, 2.075, 0.05, 0.33333333333333
97492, 2.075, 0.033333333333333, 0.3125
97493, 2.0541666666667, 0.033333333333333, 0.33333333333333
97494, 2.075, 0.016666666666667, 0.33333333333333
97495, 2.1166666666667, 0.083333333333333, 0.33333333333333
97496, 2.1166666666667, 0.066666666666667, 0.3125
97497, 2.0958333333333, 0.066666666666667, 0.33333333333333
97498, 2.1166666666667, 0.05, 0.33333333333333
97499, 2.1166666666667, 0.033333333333333, 0.3125
97500, 2.0958333333333, 0.033333333333333, 0.33333333333333
97501, 2.1166666666667, 0.016666666666667, 0.33333333333333
97502, 2.1583333333333, 0.083333333333333, 0.33333333333333
97503, 2.1583333333333, 0.066666666666667, 0.3125
97504, 2.1375, 0.066666666666667, 0.33333333333333
97505, 2.1583333333333, 0.05, 0.33333333333333
97506, 2.1583333333333, 0.033333333333333, 0.3125
97507, 2.1375, 0.033333333333333, 0.33333333333333
97508, 2.1583333333333, 0.016666666666667, 0.33333333333333
97509, 2.1791666666667, 0.066666666666667, 0.33333333333333
97510, 2.1791666666667, 0.033333333333333, 0.33333333333333
97511, 1.2416666666667, 0.083333333333333, 0.375
97512, 1.2416666666667, 0.066666666666667, 0.35416666666667
97513, 1.2208333333333, 0.066666666666667, 0.375
97514, 1.2416666666667, 0.05, 0.375
97515, 1.2416666666667, 0.033333333333333, 0.35416666666667
97516, 1.2208333333333, 0.033333333333333, 0.375
97517, 1.2416666666667, 0.016666666666667, 0.375
97518, 1.2833333333333, 0.083333333333333, 0.375
97519, 1.2833333333333, 0.066666666666667, 0.35416666666667
97520, 1.2625, 0.066666666666667, 0.375
97521, 1.2833333333333, 0.05, 0.375
97522, 1.2833333333333, 0.033333333333333, 0.35416666666667
97523, 1.2625, 0.033333333333333, 0.375
97524, 1.2833333333333, 0.016666666666667, 0.375
97525, 1.325, 0.083333333333333, 0.375
97526, 1.325, 0.066666666666667, 0.35416666666667
97527, 1.3041666666667, 0.066666666666667, 0.375
97528, 1.325, 0.05, 0.375
97529, 1.325, 0.033333333333333, 0.35416666666667
97530, 1.3041666666667, 0.033333333333333, 0.375
97531, 1.325, 0.016666666666667, 0.375
97532, 1.3666666666667, 0.083333333333333, 0.375
97533, 1.3666666666667, 0.066666666666667, 0.35416666666667
97534, 1.3458333333333, 0.066666666666667, 0.375
97535, 1.3666666666667, 0.05, 0.375
97536, 1.3666666666667, 0.033333333333333, 0.35416666666667
97537, 1.3458333333333, 0.033333333333333, 0.375
97538, 1.3666666666667, 0.016666666666667, 0.375
97539, 1.4083333333333, 0.083333333333333, 0.375
97540, 1.4083333333333, 0.066666666666667, 0.35416666666667
97541, 1.3875, 0.066666666666667, 0.375
97542, 1.4083333333333, 0.05, 0.375
97543, 1.4083333333333, 0.033333333333333, 0.35416666666667
97544, 1.3875, 0.033333333333333, 0.375
97545, 1.4083333333333, 0.016666666666667, 0.375
97546, 1.45, 0.083333333333333, 0.375
97547, 1.45, 0.066666666666667, 0.35416666666667
97548, 1.4291666666667, 0.066666666666667, 0.375
97549, 1.45, 0.05, 0.375
97550, 1.45, 0.033333333333333, 0.35416666666667
97551, 1.4291666666667, 0.033333333333333, 0.375
97552, 1.45, 0.016666666666667, 0.375
97553, 1.4916666666667, 0.083333333333333, 0.375
97554, 1.4916666666667, 0.066666666666667, 0.35416666666667
97555, 1.4708333333333, 0.066666666666667, 0.375
97556, 1.4916666666667, 0.05, 0.375
97557, 1.4916666666667, 0.033333333333333, 0.35416666666667
97558, 1.4708333333333, 0.033333333333333, 0.375
97559, 1.4916666666667, 0.016666666666667, 0.375
97560, 1.5333333333333, 0.083333333333333, 0.375
97561, 1.5333333333333, 0.066666666666667, 0.35416666666667
97562, 1.5125, 0.066666666666667, 0.375
97563, 1.5333333333333, 0.05, 0.375
97564, 1.5333333333333, 0.033333333333333, 0.35416666666667
97565, 1.5125, 0.033333333333333, 0.375
97566, 1.5333333333333, 0.016666666666667, 0.375
97567, 1.575, 0.083333333333333, 0.375
97568, 1.575, 0.066666666666667, 0.35416666666667
97569, 1.5541666666667, 0.066666666666667, 0.375
97570, 1.575, 0.05, 0.375
97571, 1.575, 0.033333333333333, 0.35416666666667
97572, 1.5541666666667, 0.033333333333333, 0.375
97573, 1.575, 0.016666666666667, 0.375
97574, 1.6166666666667, 0.083333333333333, 0.375
97575, 1.6166666666667, 0.066666666666667, 0.35416666666667
97576, 1.5958333333333, 0.066666666666667, 0.375
97577, 1.6166666666667, 0.05, 0.375
97578, 1.6166666666667, 0.033333333333333, 0.35416666666667
97579, 1.5958333333333, 0.033333333333333, 0.375
97580, 1.6166666666667, 0.016666666666667, 0.375
97581, 1.6583333333333, 0.083333333333333, 0.375
97582, 1.6583333333333, 0.066666666666667, 0.35416666666667
97583, 1.6375, 0.066666666666667, 0.375
97584, 1.6583333333333, 0.05, 0.375
97585, 1.6583333333333, 0.033333333333333, 0.35416666666667
97586, 1.6375, 0.033333333333333, 0.375
97587, 1.6583333333333, 0.016666666666667, 0.375
97588, 1.7, 0.083333333333333, 0.375
97589, 1.7, 0.066666666666667, 0.35416666666667
97590, 1.6791666666667, 0.066666666666667, 0.375
97591, 1.7, 0.05, 0.375
97592, 1.7, 0.033333333333333, 0.35416666666667
97593, 1.6791666666667, 0.033333333333333, 0.375
97594, 1.7, 0.016666666666667, 0.375
97595, 1.7416666666667, 0.083333333333333, 0.375
97596, 1.7416666666667, 0.066666666666667, 0.35416666666667
97597, 1.7208333333333, 0.066666666666667, 0.375
97598, 1.7416666666667, 0.05, 0.375
97599, 1.7416666666667, 0.033333333333333, 0.35416666666667
97600, 1.7208333333333, 0.033333333333333, 0.375
97601, 1.7416666666667, 0.016666666666667, 0.375
97602, 1.7833333333333, 0.083333333333333, 0.375
97603, 1.7833333333333, 0.066666666666667, 0.35416666666667
97604, 1.7625, 0.066666666666667, 0.375
97605, 1.7833333333333, 0.05, 0.375
97606, 1.7833333333333, 0.033333333333333, 0.35416666666667
97607, 1.7625, 0.033333333333333, 0.375
97608, 1.7833333333333, 0.016666666666667, 0.375
97609, 1.825, 0.083333333333333, 0.375
97610, 1.825, 0.066666666666667, 0.35416666666667
97611, 1.8041666666667, 0.066666666666667, 0.375
97612, 1.825, 0.05, 0.375
97613, 1.825, 0.033333333333333, 0.35416666666667
97614, 1.8041666666667, 0.033333333333333, 0.375
97615, 1.825, 0.016666666666667, 0.375
97616, 1.8666666666667, 0.083333333333333, 0.375
97617, 1.8666666666667, 0.066666666666667, 0.35416666666667
97618, 1.8458333333333, 0.066666666666667, 0.375
97619, 1.8666666666667, 0.05, 0.375
97620, 1.8666666666667, 0.033333333333333, 0.35416666666667
97621, 1.8458333333333, 0.033333333333333, 0.375
97622, 1.8666666666667, 0.016666666666667, 0.375
97623, 1.9083333333333, 0.083333333333333, 0.375
97624, 1.9083333333333, 0.066666666666667, 0.35416666666667
97625, 1.8875, 0.066666666666667, 0.375
97626, 1.9083333333333, 0.05, 0.375
97627, 1.9083333333333, 0.033333333333333, 0.35416666666667
97628, 1.8875, 0.033333333333333, 0.375
97629, 1.9083333333333, 0.016666666666667, 0.375
97630, 1.95, 0.083333333333333, 0.375
97631, 1.95, 0.066666666666667, 0.35416666666667
97632, 1.9291666666667, 0.066666666666667, 0.375
97633, 1.95, 0.05, 0.375
97634, 1.95, 0.033333333333333, 0.35416666666667
97635, 1.9291666666667, 0.033333333333333, 0.375
97636, 1.95, 0.016666666666667, 0.375
97637, 1.9916666666667, 0.083333333333333, 0.375
97638, 1.9916666666667, 0.066666666666667, 0.35416666666667
97639, 1.9708333333333, 0.066666666666667, 0.375
97640, 1.9916666666667, 0.05, 0.375
97641, 1.9916666666667, 0.033333333333333, 0.35416666666667
97642, 1.9708333333333, 0.033333333333333, 0.375
97643, 1.9916666666667, 0.016666666666667, 0.375
97644, 2.0333333333333, 0.083333333333333, 0.375
97645, 2.0333333333333, 0.066666666666667, 0.35416666666667
97646, 2.0125, 0.066666666666667, 0.375
97647, 2.0333333333333, 0.05, 0.375
97648, 2.0333333333333, 0.033333333333333, 0.35416666666667
97649, 2.0125, 0.033333333333333, 0.375
97650, 2.0333333333333, 0.016666666666667, 0.375
97651, 2.075, 0.083333333333333, 0.375
97652, 2.075, 0.066666666666667, 0.35416666666667
97653, 2.0541666666667, 0.066666666666667, 0.375
97654, 2.075, 0.05, 0.375
97655, 2.075, 0.033333333333333, 0.35416666666667
97656, 2.0541666666667, 0.033333333333333, 0.375
97657, 2.075, 0.016666666666667, 0.375
97658, 2.1166666666667, 0.083333333333333, 0.375
97659, 2.1166666666667, 0.066666666666667, 0.35416666666667
97660, 2.0958333333333, 0.066666666666667, 0.375
97661, 2.1166666666667, 0.05, 0.375
97662, 2.1166666666667, 0.033333333333333, 0.35416666666667
97663, 2.0958333333333, 0.033333333333333, 0.375
97664, 2.1166666666667, 0.016666666666667, 0.375
97665, 2.1583333333333, 0.083333333333333, 0.375
97666, 2.1583333333333, 0.066666666666667, 0.35416666666667
97667, 2.1375, 0.066666666666667, 0.375
97668, 2.1583333333333, 0.05, 0.375
97669, 2.1583333333333, 0.033333333333333, 0.35416666666667
97670, 2.1375, 0.033333333333333, 0.375
97671, 2.1583333333333, 0.016666666666667, 0.375
97672, 2.1791666666667, 0.066666666666667, 0.375
97673, 2.1791666666667, 0.033333333333333, 0.375
97674, 1.2416666666667, 0.083333333333333, 0.41666666666667
97675, 1.2416666666667, 0.066666666666667, 0.39583333333333
97676, 1.2208333333333, 0.066666666666667, 0.41666666666667
97677, 1.2416666666667, 0.05, 0.41666666666667
97678, 1.2416666666667, 0.033333333333333, 0.39583333333333
97679, 1.2208333333333, 0.033333333333333, 0.41666666666667
97680, 1.2416666666667, 0.016666666666667, 0.41666666666667
97681, 1.2833333333333, 0.083333333333333, 0.41666666666667
97682, 1.2833333333333, 0.066666666666667, 0.39583333333333
97683, 1.2625, 0.066666666666667, 0.41666666666667
97684, 1.2833333333333, 0.05, 0.41666666666667
97685, 1.2833333333333, 0.033333333333333, 0.39583333333333
97686, 1.2625, 0.033333333333333, 0.41666666666667
97687, 1.2833333333333, 0.016666666666667, 0.41666666666667
97688, 1.325, 0.083333333333333, 0.41666666666667
97689, 1.325, 0.066666666666667, 0.39583333333333
97690, 1.3041666666667, 0.066666666666667, 0.41666666666667
97691, 1.325, 0.05, 0.41666666666667
97692, 1.325, 0.033333333333333, 0.39583333333333
97693, 1.3041666666667, 0.033333333333333, 0.41666666666667
97694, 1.325, 0.016666666666667, 0.41666666666667
97695, 1.3666666666667, 0.083333333333333, 0.41666666666667
97696, 1.3666666666667, 0.066666666666667, 0.39583333333333
97697, 1.3458333333333, 0.066666666666667, 0.41666666666667
97698, 1.3666666666667, 0.05, 0.41666666666667
97699, 1.3666666666667, 0.033333333333333, 0.39583333333333
97700, 1.3458333333333, 0.033333333333333, 0.41666666666667
97701, 1.3666666666667, 0.016666666666667, 0.41666666666667
97702, 1.4083333333333, 0.083333333333333, 0.41666666666667
97703, 1.4083333333333, 0.066666666666667, 0.39583333333333
97704, 1.3875, 0.066666666666667, 0.41666666666667
97705, 1.4083333333333, 0.05, 0.41666666666667
97706, 1.4083333333333, 0.033333333333333, 0.39583333333333
97707, 1.3875, 0.033333333333333, 0.41666666666667
97708, 1.4083333333333, 0.016666666666667, 0.41666666666667
97709, 1.45, 0.083333333333333, 0.41666666666667
97710, 1.45, 0.066666666666667, 0.39583333333333
97711, 1.4291666666667, 0.066666666666667, 0.41666666666667
97712, 1.45, 0.05, 0.41666666666667
97713, 1.45, 0.033333333333333, 0.39583333333333
97714, 1.4291666666667, 0.033333333333333, 0.41666666666667
97715, 1.45, 0.016666666666667, 0.41666666666667
97716, 1.4916666666667, 0.083333333333333, 0.41666666666667
97717, 1.4916666666667, 0.066666666666667, 0.39583333333333
97718, 1.4708333333333, 0.066666666666667, 0.41666666666667
97719, 1.4916666666667, 0.05, 0.41666666666667
97720, 1.4916666666667, 0.033333333333333, 0.39583333333333
97721, 1.4708333333333, 0.033333333333333, 0.41666666666667
97722, 1.4916666666667, 0.016666666666667, 0.41666666666667
97723, 1.5333333333333, 0.083333333333333, 0.41666666666667
97724, 1.5333333333333, 0.066666666666667, 0.39583333333333
97725, 1.5125, 0.066666666666667, 0.41666666666667
97726, 1.5333333333333, 0.05, 0.41666666666667
97727, 1.5333333333333, 0.033333333333333, 0.39583333333333
97728, 1.5125, 0.033333333333333, 0.41666666666667
97729, 1.5333333333333, 0.016666666666667, 0.41666666666667
97730, 1.575, 0.083333333333333, 0.41666666666667
97731, 1.575, 0.066666666666667, 0.39583333333333
97732, 1.5541666666667, 0.066666666666667, 0.41666666666667
97733, 1.575, 0.05, 0.41666666666667
97734, 1.575, 0.033333333333333, 0.39583333333333
97735, 1.5541666666667, 0.033333333333333, 0.41666666666667
97736, 1.575, 0.016666666666667, 0.41666666666667
97737, 1.6166666666667, 0.083333333333333, 0.41666666666667
97738, 1.6166666666667, 0.066666666666667, 0.39583333333333
97739, 1.5958333333333, 0.066666666666667, 0.41666666666667
97740, 1.6166666666667, 0.05, 0.41666666666667
97741, 1.6166666666667, 0.033333333333333, 0.39583333333333
97742, 1.5958333333333, 0.033333333333333, 0.41666666666667
97743, 1.6166666666667, 0.016666666666667, 0.41666666666667
97744, 1.6583333333333, 0.083333333333333, 0.41666666666667
97745, 1.6583333333333, 0.066666666666667, 0.39583333333333
97746, 1.6375, 0.066666666666667, 0.41666666666667
97747, 1.6583333333333, 0.05, 0.41666666666667
97748, 1.6583333333333, 0.033333333333333, 0.39583333333333
97749, 1.6375, 0.033333333333333, 0.41666666666667
97750, 1.6583333333333, 0.016666666666667, 0.41666666666667
97751, 1.7, 0.083333333333333, 0.41666666666667
97752, 1.7, 0.066666666666667, 0.39583333333333
97753, 1.6791666666667, 0.066666666666667, 0.41666666666667
97754, 1.7, 0.05, 0.41666666666667
97755, 1.7, 0.033333333333333, 0.39583333333333
97756, 1.6791666666667, 0.033333333333333, 0.41666666666667
97757, 1.7, 0.016666666666667, 0.41666666666667
97758, 1.7416666666667, 0.083333333333333, 0.41666666666667
97759, 1.7416666666667, 0.066666666666667, 0.39583333333333
97760, 1.7208333333333, 0.066666666666667, 0.41666666666667
97761, 1.7416666666667, 0.05, 0.41666666666667
97762, 1.7416666666667, 0.033333333333333, 0.39583333333333
97763, 1.7208333333333, 0.033333333333333, 0.41666666666667
97764, 1.7416666666667, 0.016666666666667, 0.41666666666667
97765, 1.7833333333333, 0.083333333333333, 0.41666666666667
97766, 1.7833333333333, 0.066666666666667, 0.39583333333333
97767, 1.7625, 0.066666666666667, 0.41666666666667
97768, 1.7833333333333, 0.05, 0.41666666666667
97769, 1.7833333333333, 0.033333333333333, 0.39583333333333
97770, 1.7625, 0.033333333333333, 0.41666666666667
97771, 1.7833333333333, 0.016666666666667, 0.41666666666667
97772, 1.825, 0.083333333333333, 0.41666666666667
97773, 1.825, 0.066666666666667, 0.39583333333333
97774, 1.8041666666667, 0.066666666666667, 0.41666666666667
97775, 1.825, 0.05, 0.41666666666667
97776, 1.825, 0.033333333333333, 0.39583333333333
97777, 1.8041666666667, 0.033333333333333, 0.41666666666667
97778, 1.825, 0.016666666666667, 0.41666666666667
97779, 1.8666666666667, 0.083333333333333, 0.41666666666667
97780, 1.8666666666667, 0.066666666666667, 0.39583333333333
97781, 1.8458333333333, 0.066666666666667, 0.41666666666667
97782, 1.8666666666667, 0.05, 0.41666666666667
97783, 1.8666666666667, 0.033333333333333, 0.39583333333333
97784, 1.8458333333333, 0.033333333333333, 0.41666666666667
97785, 1.8666666666667, 0.016666666666667, 0.41666666666667
97786, 1.9083333333333, 0.083333333333333, 0.41666666666667
97787, 1.9083333333333, 0.066666666666667, 0.39583333333333
97788, 1.8875, 0.066666666666667, 0.41666666666667
97789, 1.9083333333333, 0.05, 0.41666666666667
97790, 1.9083333333333, 0.033333333333333, 0.39583333333333
97791, 1.8875, 0.033333333333333, 0.41666666666667
97792, 1.9083333333333, 0.016666666666667, 0.41666666666667
97793, 1.95, 0.083333333333333, 0.41666666666667
97794, 1.95, 0.066666666666667, 0.39583333333333
97795, 1.9291666666667, 0.066666666666667, 0.41666666666667
97796, 1.95, 0.05, 0.41666666666667
97797, 1.95, 0.033333333333333, 0.39583333333333
97798, 1.9291666666667, 0.033333333333333, 0.41666666666667
97799, 1.95, 0.016666666666667, 0.41666666666667
97800, 1.9916666666667, 0.083333333333333, 0.41666666666667
97801, 1.9916666666667, 0.066666666666667, 0.39583333333333
97802, 1.9708333333333, 0.066666666666667, 0.41666666666667
97803, 1.9916666666667, 0.05, 0.41666666666667
97804, 1.9916666666667, 0.033333333333333, 0.39583333333333
97805, 1.9708333333333, 0.033333333333333, 0.41666666666667
97806, 1.9916666666667, 0.016666666666667, 0.41666666666667
97807, 2.0333333333333, 0.083333333333333, 0.41666666666667
97808, 2.0333333333333, 0.066666666666667, 0.39583333333333
97809, 2.0125, 0.066666666666667, 0.41666666666667
97810, 2.0333333333333, 0.05, 0.41666666666667
97811, 2.0333333333333, 0.033333333333333, 0.39583333333333
97812, 2.0125, 0.033333333333333, 0.41666666666667
97813, 2.0333333333333, 0.016666666666667, 0.41666666666667
97814, 2.075, 0.083333333333333, 0.41666666666667
97815, 2.075, 0.066666666666667, 0.39583333333333
97816, 2.0541666666667, 0.066666666666667, 0.41666666666667
97817, 2.075, 0.05, 0.41666666666667
97818, 2.075, 0.033333333333333, 0.39583333333333
97819, 2.0541666666667, 0.033333333333333, 0.41666666666667
97820, 2.075, 0.016666666666667, 0.41666666666667
97821, 2.1166666666667, 0.083333333333333, 0.41666666666667
97822, 2.1166666666667, 0.066666666666667, 0.39583333333333
97823, 2.0958333333333, 0.066666666666667, 0.41666666666667
97824, 2.1166666666667, 0.05, 0.41666666666667
97825, 2.1166666666667, 0.033333333333333, 0.39583333333333
97826, 2.0958333333333, 0.033333333333333, 0.41666666666667
97827, 2.1166666666667, 0.016666666666667, 0.41666666666667
97828, 2.1583333333333, 0.083333333333333, 0.41666666666667
97829, 2.1583333333333, 0.066666666666667, 0.39583333333333
97830, 2.1375, 0.066666666666667, 0.41666666666667
97831, 2.1583333333333, 0.05, 0.41666666666667
97832, 2.1583333333333, 0.033333333333333, 0.39583333333333
97833, 2.1375, 0.033333333333333, 0.41666666666667
97834, 2.1583333333333, 0.016666666666667, 0.41666666666667
97835, 2.1791666666667, 0.066666666666667, 0.41666666666667
97836, 2.1791666666667, 0.033333333333333, 0.41666666666667
97837, 1.2416666666667, 0.083333333333333, 0.45833333333333
97838, 1.2416666666667, 0.066666666666667, 0.4375
97839, 1.2208333333333, 0.066666666666667, 0.45833333333333
97840, 1.2416666666667, 0.05, 0.45833333333333
97841, 1.2416666666667, 0.033333333333333, 0.4375
97842, 1.2208333333333, 0.033333333333333, 0.45833333333333
97843, 1.2416666666667, 0.016666666666667, 0.45833333333333
97844, 1.2833333333333, 0.083333333333333, 0.45833333333333
97845, 1.2833333333333, 0.066666666666667, 0.4375
97846, 1.2625, 0.066666666666667, 0.45833333333333
97847, 1.2833333333333, 0.05, 0.45833333333333
97848, 1.2833333333333, 0.033333333333333, 0.4375
97849, 1.2625, 0.033333333333333, 0.45833333333333
97850, 1.2833333333333, 0.016666666666667, 0.45833333333333
97851, 1.325, 0.083333333333333, 0.45833333333333
97852, 1.325, 0.066666666666667, 0.4375
97853, 1.3041666666667, 0.066666666666667, 0.45833333333333
97854, 1.325, 0.05, 0.45833333333333
97855, 1.325, 0.033333333333333, 0.4375
97856, 1.3041666666667, 0.033333333333333, 0.45833333333333
97857, 1.325, 0.016666666666667, 0.45833333333333
97858, 1.3666666666667, 0.083333333333333, 0.45833333333333
97859, 1.3666666666667, 0.066666666666667, 0.4375
97860, 1.3458333333333, 0.066666666666667, 0.45833333333333
97861, 1.3666666666667, 0.05, 0.45833333333333
97862, 1.3666666666667, 0.033333333333333, 0.4375
97863, 1.3458333333333, 0.033333333333333, 0.45833333333333
97864, 1.3666666666667, 0.016666666666667, 0.45833333333333
97865, 1.4083333333333, 0.083333333333333, 0.45833333333333
97866, 1.4083333333333, 0.066666666666667, 0.4375
97867, 1.3875, 0.066666666666667, 0.45833333333333
97868, 1.4083333333333, 0.05, 0.45833333333333
97869, 1.4083333333333, 0.033333333333333, 0.4375
97870, 1.3875, 0.033333333333333, 0.45833333333333
97871, 1.4083333333333, 0.016666666666667, 0.45833333333333
97872, 1.45, 0.083333333333333, 0.45833333333333
97873, 1.45, 0.066666666666667, 0.4375
97874, 1.4291666666667, 0.066666666666667, 0.45833333333333
97875, 1.45, 0.05, 0.45833333333333
97876, 1.45, 0.033333333333333, 0.4375
97877, 1.4291666666667, 0.033333333333333, 0.45833333333333
97878, 1.45, 0.016666666666667, 0.45833333333333
97879, 1.4916666666667, 0.083333333333333, 0.45833333333333
97880, 1.4916666666667, 0.066666666666667, 0.4375
97881, 1.4708333333333, 0.066666666666667, 0.45833333333333
97882, 1.4916666666667, 0.05, 0.45833333333333
97883, 1.4916666666667, 0.033333333333333, 0.4375
97884, 1.4708333333333, 0.033333333333333, 0.45833333333333
97885, 1.4916666666667, 0.016666666666667, 0.45833333333333
97886, 1.5333333333333, 0.083333333333333, 0.45833333333333
97887, 1.5333333333333, 0.066666666666667, 0.4375
97888, 1.5125, 0.066666666666667, 0.45833333333333
97889, 1.5333333333333, 0.05, 0.45833333333333
97890, 1.5333333333333, 0.033333333333333, 0.4375
97891, 1.5125, 0.033333333333333, 0.45833333333333
97892, 1.5333333333333, 0.016666666666667, 0.45833333333333
97893, 1.575, 0.083333333333333, 0.45833333333333
97894, 1.575, 0.066666666666667, 0.4375
97895, 1.5541666666667, 0.066666666666667, 0.45833333333333
97896, 1.575, 0.05, 0.45833333333333
97897, 1.575, 0.033333333333333, 0.4375
97898, 1.5541666666667, 0.033333333333333, 0.45833333333333
97899, 1.575, 0.016666666666667, 0.45833333333333
97900, 1.6166666666667, 0.083333333333333, 0.45833333333333
97901, 1.6166666666667, 0.066666666666667, 0.4375
97902, 1.5958333333333, 0.066666666666667, 0.45833333333333
97903, 1.6166666666667, 0.05, 0.45833333333333
97904, 1.6166666666667, 0.033333333333333, 0.4375
97905, 1.5958333333333, 0.033333333333333, 0.45833333333333
97906, 1.6166666666667, 0.016666666666667, 0.45833333333333
97907, 1.6583333333333, 0.083333333333333, 0.45833333333333
97908, 1.6583333333333, 0.066666666666667, 0.4375
97909, 1.6375, 0.066666666666667, 0.45833333333333
97910, 1.6583333333333, 0.05, 0.45833333333333
97911, 1.6583333333333, 0.033333333333333, 0.4375
97912, 1.6375, 0.033333333333333, 0.45833333333333
97913, 1.6583333333333, 0.016666666666667, 0.45833333333333
97914, 1.7, 0.083333333333333, 0.45833333333333
97915, 1.7, 0.066666666666667, 0.4375
97916, 1.6791666666667, 0.066666666666667, 0.45833333333333
97917, 1.7, 0.05, 0.45833333333333
97918, 1.7, 0.033333333333333, 0.4375
97919, 1.6791666666667, 0.033333333333333, 0.45833333333333
97920, 1.7, 0.016666666666667, 0.45833333333333
97921, 1.7416666666667, 0.083333333333333, 0.45833333333333
97922, 1.7416666666667, 0.066666666666667, 0.4375
97923, 1.7208333333333, 0.066666666666667, 0.45833333333333
97924, 1.7416666666667, 0.05, 0.45833333333333
97925, 1.7416666666667, 0.033333333333333, 0.4375
97926, 1.7208333333333, 0.033333333333333, 0.45833333333333
97927, 1.7416666666667, 0.016666666666667, 0.45833333333333
97928, 1.7833333333333, 0.083333333333333, 0.45833333333333
97929, 1.7833333333333, 0.066666666666667, 0.4375
97930, 1.7625, 0.066666666666667, 0.45833333333333
97931, 1.7833333333333, 0.05, 0.45833333333333
97932, 1.7833333333333, 0.033333333333333, 0.4375
97933, 1.7625, 0.033333333333333, 0.45833333333333
97934, 1.7833333333333, 0.016666666666667, 0.45833333333333
97935, 1.825, 0.083333333333333, 0.45833333333333
97936, 1.825, 0.066666666666667, 0.4375
97937, 1.8041666666667, 0.066666666666667, 0.45833333333333
97938, 1.825, 0.05, 0.45833333333333
97939, 1.825, 0.033333333333333, 0.4375
97940, 1.8041666666667, 0.033333333333333, 0.45833333333333
97941, 1.825, 0.016666666666667, 0.45833333333333
97942, 1.8666666666667, 0.083333333333333, 0.45833333333333
97943, 1.8666666666667, 0.066666666666667, 0.4375
97944, 1.8458333333333, 0.066666666666667, 0.45833333333333
97945, 1.8666666666667, 0.05, 0.45833333333333
97946, 1.8666666666667, 0.033333333333333, 0.4375
97947, 1.8458333333333, 0.033333333333333, 0.45833333333333
97948, 1.8666666666667, 0.016666666666667, 0.45833333333333
97949, 1.9083333333333, 0.083333333333333, 0.45833333333333
97950, 1.9083333333333, 0.066666666666667, 0.4375
97951, 1.8875, 0.066666666666667, 0.45833333333333
97952, 1.9083333333333, 0.05, 0.45833333333333
97953, 1.9083333333333, 0.033333333333333, 0.4375
97954, 1.8875, 0.033333333333333, 0.45833333333333
97955, 1.9083333333333, 0.016666666666667, 0.45833333333333
97956, 1.95, 0.083333333333333, 0.45833333333333
97957, 1.95, 0.066666666666667, 0.4375
97958, 1.9291666666667, 0.066666666666667, 0.45833333333333
97959, 1.95, 0.05, 0.45833333333333
97960, 1.95, 0.033333333333333, 0.4375
97961, 1.9291666666667, 0.033333333333333, 0.45833333333333
97962, 1.95, 0.016666666666667, 0.45833333333333
97963, 1.9916666666667, 0.083333333333333, 0.45833333333333
97964, 1.9916666666667, 0.066666666666667, 0.4375
97965, 1.9708333333333, 0.066666666666667, 0.45833333333333
97966, 1.9916666666667, 0.05, 0.45833333333333
97967, 1.9916666666667, 0.033333333333333, 0.4375
97968, 1.9708333333333, 0.033333333333333, 0.45833333333333
97969, 1.9916666666667, 0.016666666666667, 0.45833333333333
97970, 2.0333333333333, 0.083333333333333, 0.45833333333333
97971, 2.0333333333333, 0.066666666666667, 0.4375
97972, 2.0125, 0.066666666666667, 0.45833333333333
97973, 2.0333333333333, 0.05, 0.45833333333333
97974, 2.0333333333333, 0.033333333333333, 0.4375
97975, 2.0125, 0.033333333333333, 0.45833333333333
97976, 2.0333333333333, 0.016666666666667, 0.45833333333333
97977, 2.075, 0.083333333333333, 0.45833333333333
97978, 2.075, 0.066666666666667, 0.4375
97979, 2.0541666666667, 0.066666666666667, 0.45833333333333
97980, 2.075, 0.05, 0.45833333333333
97981, 2.075, 0.033333333333333, 0.4375
97982, 2.0541666666667, 0.033333333333333, 0.45833333333333
97983, 2.075, 0.016666666666667, 0.45833333333333
97984, 2.1166666666667, 0.083333333333333, 0.45833333333333
97985, 2.1166666666667, 0.066666666666667, 0.4375
97986, 2.0958333333333, 0.066666666666667, 0.45833333333333
97987, 2.1166666666667, 0.05, 0.45833333333333
97988, 2.1166666666667, 0.033333333333333, 0.4375
97989, 2.0958333333333, 0.033333333333333, 0.45833333333333
97990, 2.1166666666667, 0.016666666666667, 0.45833333333333
97991, 2.1583333333333, 0.083333333333333, 0.45833333333333
97992, 2.1583333333333, 0.066666666666667, 0.4375
97993, 2.1375, 0.066666666666667, 0.45833333333333
97994, 2.1583333333333, 0.05, 0.45833333333333
97995, 2.1583333333333, 0.033333333333333, 0.4375
97996, 2.1375, 0.033333333333333, 0.45833333333333
97997, 2.1583333333333, 0.016666666666667, 0.45833333333333
97998, 2.1791666666667, 0.066666666666667, 0.45833333333333
97999, 2.1791666666667, 0.033333333333333, 0.45833333333333
98000, 1.2416666666667, 0.066666666666667, 0.47916666666667
98001, 1.2416666666667, 0.033333333333333, 0.47916666666667
98002, 1.2833333333333, 0.066666666666667, 0.47916666666667
98003, 1.2833333333333, 0.033333333333333, 0.47916666666667
98004, 1.325, 0.066666666666667, 0.47916666666667
98005, 1.325, 0.033333333333333, 0.47916666666667
98006, 1.3666666666667, 0.066666666666667, 0.47916666666667
98007, 1.3666666666667, 0.033333333333333, 0.47916666666667
98008, 1.4083333333333, 0.066666666666667, 0.47916666666667
98009, 1.4083333333333, 0.033333333333333, 0.47916666666667
98010, 1.45, 0.066666666666667, 0.47916666666667
98011, 1.45, 0.033333333333333, 0.47916666666667
98012, 1.4916666666667, 0.066666666666667, 0.47916666666667
98013, 1.4916666666667, 0.033333333333333, 0.47916666666667
98014, 1.5333333333333, 0.066666666666667, 0.47916666666667
98015, 1.5333333333333, 0.033333333333333, 0.47916666666667
98016, 1.575, 0.066666666666667, 0.47916666666667
98017, 1.575, 0.033333333333333, 0.47916666666667
98018, 1.6166666666667, 0.066666666666667, 0.47916666666667
98019, 1.6166666666667, 0.033333333333333, 0.47916666666667
98020, 1.6583333333333, 0.066666666666667, 0.47916666666667
98021, 1.6583333333333, 0.033333333333333, 0.47916666666667
98022, 1.7, 0.066666666666667, 0.47916666666667
98023, 1.7, 0.033333333333333, 0.47916666666667
98024, 1.7416666666667, 0.066666666666667, 0.47916666666667
98025, 1.7416666666667, 0.033333333333333, 0.47916666666667
98026, 1.7833333333333, 0.066666666666667, 0.47916666666667
98027, 1.7833333333333, 0.033333333333333, 0.47916666666667
98028, 1.825, 0.066666666666667, 0.47916666666667
98029, 1.825, 0.033333333333333, 0.47916666666667
98030, 1.8666666666667, 0.066666666666667, 0.47916666666667
98031, 1.8666666666667, 0.033333333333333, 0.47916666666667
98032, 1.9083333333333, 0.066666666666667, 0.47916666666667
98033, 1.9083333333333, 0.033333333333333, 0.47916666666667
98034, 1.95, 0.066666666666667, 0.47916666666667
98035, 1.95, 0.033333333333333, 0.47916666666667
98036, 1.9916666666667, 0.066666666666667, 0.47916666666667
98037, 1.9916666666667, 0.033333333333333, 0.47916666666667
98038, 2.0333333333333, 0.066666666666667, 0.47916666666667
98039, 2.0333333333333, 0.033333333333333, 0.47916666666667
98040, 2.075, 0.066666666666667, 0.47916666666667
98041, 2.075, 0.033333333333333, 0.47916666666667
98042, 2.1166666666667, 0.066666666666667, 0.47916666666667
98043, 2.1166666666667, 0.033333333333333, 0.47916666666667
98044, 2.1583333333333, 0.066666666666667, 0.47916666666667
98045, 2.1583333333333, 0.033333333333333, 0.47916666666667
98046, 2.25, 0.066666666666667, 0.041666666666667
98047, 2.25, 0.033333333333333, 0.041666666666667
98048, 2.25, 0.066666666666667, 0.083333333333333
98049, 2.25, 0.033333333333333, 0.083333333333333
98050, 2.25, 0.066666666666667, 0.125
98051, 2.25, 0.033333333333333, 0.125
98052, 2.25, 0.066666666666667, 0.16666666666667
98053, 2.25, 0.033333333333333, 0.16666666666667
98054, 2.25, 0.066666666666667, 0.20833333333333
98055, 2.25, 0.033333333333333, 0.20833333333333
98056, 2.25, 0.066666666666667, 0.25
98057, 2.25, 0.033333333333333, 0.25
98058, 2.25, 0.066666666666667, 0.29166666666667
98059, 2.25, 0.033333333333333, 0.29166666666667
98060, 2.25, 0.066666666666667, 0.33333333333333
98061, 2.25, 0.033333333333333, 0.33333333333333
98062, 2.25, 0.066666666666667, 0.375
98063, 2.25, 0.033333333333333, 0.375
98064, 2.25, 0.066666666666667, 0.41666666666667
98065, 2.25, 0.033333333333333, 0.41666666666667
98066, 2.25, 0.066666666666667, 0.45833333333333
98067, 2.25, 0.033333333333333, 0.45833333333333
98068, -0.05, 0.033333333333333, 0.041666666666667
98069, -0.05, 0.066666666666667, 0.041666666666667
98070, -0.05, 0.033333333333333, 0.083333333333333
98071, -0.05, 0.066666666666667, 0.083333333333333
98072, -0.05, 0.033333333333333, 0.125
98073, -0.05, 0.066666666666667, 0.125
98074, -0.05, 0.033333333333333, 0.16666666666667
98075, -0.05, 0.066666666666667, 0.16666666666667
98076, -0.05, 0.033333333333333, 0.20833333333333
98077, -0.05, 0.066666666666667, 0.20833333333333
98078, -0.05, 0.033333333333333, 0.25
98079, -0.05, 0.066666666666667, 0.25
98080, -0.05, 0.033333333333333, 0.29166666666667
98081, -0.05, 0.066666666666667, 0.29166666666667
98082, -0.05, 0.033333333333333, 0.33333333333333
98083, -0.05, 0.066666666666667, 0.33333333333333
98084, -0.05, 0.033333333333333, 0.375
98085, -0.05, 0.066666666666667, 0.375
98086, -0.05, 0.033333333333333, 0.41666666666667
98087, -0.05, 0.066666666666667, 0.41666666666667
98088, -0.05, 0.033333333333333, 0.45833333333333
98089, -0.05, 0.066666666666667, 0.45833333333333
98090, 0.041666666666667, 0.2, -0.05
98091, 0.041666666666667, 0.25, -0.05
98092, 0.041666666666667, 0.3, -0.05
98093, 0.041666666666667, 0.35, -0.05
98094, 0.041666666666667, 0.4, -0.05
98095, 0.041666666666667, 0.45, -0.05
98096, 0.041666666666667, 0.5, -0.05
98097, 0.041666666666667, 0.55, -0.05
98098, 0.041666666666667, 0.6, -0.05
98099, 0.041666666666667, 0.65, -0.05
98100, 0.041666666666667, 0.7, -0.05
98101, 0.041666666666667, 0.75, -0.05
98102, 0.041666666666667, 0.8, -0.05
98103, 0.041666666666667, 0.85, -0.05
98104, 0.041666666666667, 0.9, -0.05
98105, 0.041666666666667, 0.95, -0.05
98106, 0.041666666666667, 1, -0.05
98107, 0.041666666666667, 1.05, -0.05
98108, 0.041666666666667, 1.1, -0.05
98109, 0.041666666666667, 1.15, -0.05
98110, 0.041666666666667, 1.2, -0.05
98111, 0.041666666666667, 1.25, -0.05
98112, 0.041666666666667, 1.3, -0.05
98113, 0.083333333333333, 0.2, -0.05
98114, 0.083333333333333, 0.25, -0.05
98115, 0.083333333333333, 0.3, -0.05
98116, 0.083333333333333, 0.35, -0.05
98117, 0.083333333333333, 0.4, -0.05
98118, 0.083333333333333, 0.45, -0.05
98119, 0.083333333333333, 0.5, -0.05
98120, 0.083333333333333, 0.55, -0.05
98121, 0.083333333333333, 0.6, -0.05
98122, 0.083333333333333, 0.65, -0.05
98123, 0.083333333333333, 0.7, -0.05
98124, 0.083333333333333, 0.75, -0.05
98125, 0.083333333333333, 0.8, -0.05
98126, 0.083333333333333, 0.85, -0.05
98127, 0.083333333333333, 0.9, -0.05
98128, 0.083333333333333, 0.95, -0.05
98129, 0.083333333333333, 1, -0.05
98130, 0.083333333333333, 1.05, -0.05
98131, 0.083333333333333, 1.1, -0.05
98132, 0.083333333333333, 1.15, -0.05
98133, 0.083333333333333, 1.2, -0.05
98134, 0.083333333333333, 1.25, -0.05
98135, 0.083333333333333, 1.3, -0.05
98136, 0.125, 0.2, -0.05
98137, 0.125, 0.25, -0.05
98138, 0.125, 0.3, -0.05
98139, 0.125, 0.35, -0.05
98140, 0.125, 0.4, -0.05
98141, 0.125, 0.45, -0.05
98142, 0.125, 0.5, -0.05
98143, 0.125, 0.55, -0.05
98144, 0.125, 0.6, -0.05
98145, 0.125, 0.65, -0.05
98146, 0.125, 0.7, -0.05
98147, 0.125, 0.75, -0.05
98148, 0.125, 0.8, -0.05
98149, 0.125, 0.85, -0.05
98150, 0.125, 0.9, -0.05
98151, 0.125, 0.95, -0.05
98152, 0.125, 1, -0.05
98153, 0.125, 1.05, -0.05
98154, 0.125, 1.1, -0.05
98155, 0.125, 1.15, -0.05
98156, 0.125, 1.2, -0.05
98157, 0.125, 1.25, -0.05
98158, 0.125, 1.3, -0.05
98159, 0.16666666666667, 0.2, -0.05
98160, 0.16666666666667, 0.25, -0.05
98161, 0.16666666666667, 0.3, -0.05
98162, 0.16666666666667, 0.35, -0.05
98163, 0.16666666666667, 0.4, -0.05
98164, 0.16666666666667, 0.45, -0.05
98165, 0.16666666666667, 0.5, -0.05
98166, 0.16666666666667, 0.55, -0.05
98167, 0.16666666666667, 0.6, -0.05
98168, 0.16666666666667, 0.65, -0.05
98169, 0.16666666666667, 0.7, -0.05
98170, 0.16666666666667, 0.75, -0.05
98171, 0.16666666666667, 0.8, -0.05
98172, 0.16666666666667, 0.85, -0.05
98173, 0.16666666666667, 0.9, -0.05
98174, 0.16666666666667, 0.95, -0.05
98175, 0.16666666666667, 1, -0.05
98176, 0.16666666666667, 1.05, -0.05
98177, 0.16666666666667, 1.1, -0.05
98178, 0.16666666666667, 1.15, -0.05
98179, 0.16666666666667, 1.2, -0.05
98180, 0.16666666666667, 1.25, -0.05
98181, 0.16666666666667, 1.3, -0.05
98182, 0.20833333333333, 0.2, -0.05
98183, 0.20833333333333, 0.25, -0.05
98184, 0.20833333333333, 0.3, -0.05
98185, 0.20833333333333, 0.35, -0.05
98186, 0.20833333333333, 0.4, -0.05
98187, 0.20833333333333, 0.45, -0.05
98188, 0.20833333333333, 0.5, -0.05
98189, 0.20833333333333, 0.55, -0.05
98190, 0.20833333333333, 0.6, -0.05
98191, 0.20833333333333, 0.65, -0.05
98192, 0.20833333333333, 0.7, -0.05
98193, 0.20833333333333, 0.75, -0.05
98194, 0.20833333333333, 0.8, -0.05
98195, 0.20833333333333, 0.85, -0.05
98196, 0.20833333333333, 0.9, -0.05
98197, 0.20833333333333, 0.95, -0.05
98198, 0.20833333333333, 1, -0.05
98199, 0.20833333333333, 1.05, -0.05
98200, 0.20833333333333, 1.1, -0.05
98201, 0.20833333333333, 1.15, -0.05
98202, 0.20833333333333, 1.2, -0.05
98203, 0.20833333333333, 1.25, -0.05
98204, 0.20833333333333, 1.3, -0.05
98205, 0.25, 0.2, -0.05
98206, 0.25, 0.25, -0.05
98207, 0.25, 0.3, -0.05
98208, 0.25, 0.35, -0.05
98209, 0.25, 0.4, -0.05
98210, 0.25, 0.45, -0.05
98211, 0.25, 0.5, -0.05
98212, 0.25, 0.55, -0.05
98213, 0.25, 0.6, -0.05
98214, 0.25, 0.65, -0.05
98215, 0.25, 0.7, -0.05
98216, 0.25, 0.75, -0.05
98217, 0.25, 0.8, -0.05
98218, 0.25, 0.85, -0.05
98219, 0.25, 0.9, -0.05
98220, 0.25, 0.95, -0.05
98221, 0.25, 1, -0.05
98222, 0.25, 1.05, -0.05
98223, 0.25, 1.1, -0.05
98224, 0.25, 1.15, -0.05
98225, 0.25, 1.2, -0.05
98226, 0.25, 1.25, -0.05
98227, 0.25, 1.3, -0.05
98228, 0.29166666666667, 0.2, -0.05
98229, 0.29166666666667, 0.25, -0.05
98230, 0.29166666666667, 0.3, -0.05
98231, 0.29166666666667, 0.35, -0.05
98232, 0.29166666666667, 0.4, -0.05
98233, 0.29166666666667, 0.45, -0.05
98234, 0.29166666666667, 0.5, -0.05
98235, 0.29166666666667, 0.55, -0.05
98236, 0.29166666666667, 0.6, -0.05
98237, 0.29166666666667, 0.65, -0.05
98238, 0.29166666666667, 0.7, -0.05
98239, 0.29166666666667, 0.75, -0.05
98240, 0.29166666666667, 0.8, -0.05
98241, 0.29166666666667, 0.85, -0.05
98242, 0.29166666666667, 0.9, -0.05
98243, 0.29166666666667, 0.95, -0.05
98244, 0.29166666666667, 1, -0.05
98245, 0.29166666666667, 1.05, -0.05
98246, 0.29166666666667, 1.1, -0.05
98247, 0.29166666666667, 1.15, -0.05
98248, 0.29166666666667, 1.2, -0.05
98249, 0.29166666666667, 1.25, -0.05
98250, 0.29166666666667, 1.3, -0.05
98251, 0.33333333333333, 0.2, -0.05
98252, 0.33333333333333, 0.25, -0.05
98253, 0.33333333333333, 0.3, -0.05
98254, 0.33333333333333, 0.35, -0.05
98255, 0.33333333333333, 0.4, -0.05
98256, 0.33333333333333, 0.45, -0.05
98257, 0.33333333333333, 0.5, -0.05
98258, 0.33333333333333, 0.55, -0.05
98259, 0.33333333333333, 0.6, -0.05
98260, 0.33333333333333, 0.65, -0.05
98261, 0.33333333333333, 0.7, -0.05
98262, 0.33333333333333, 0.75, -0.05
98263, 0.33333333333333, 0.8, -0.05
98264, 0.33333333333333, 0.85, -0.05
98265, 0.33333333333333, 0.9, -0.05
98266, 0.33333333333333, 0.95, -0.05
98267, 0.33333333333333, 1, -0.05
98268, 0.33333333333333, 1.05, -0.05
98269, 0.33333333333333, 1.1, -0.05
98270, 0.33333333333333, 1.15, -0.05
98271, 0.33333333333333, 1.2, -0.05
98272, 0.33333333333333, 1.25, -0.05
98273, 0.33333333333333, 1.3, -0.05
98274, 0.375, 0.2, -0.05
98275, 0.375, 0.25, -0.05
98276, 0.375, 0.3, -0.05
98277, 0.375, 0.35, -0.05
98278, 0.375, 0.4, -0.05
98279, 0.375, 0.45, -0.05
98280, 0.375, 0.5, -0.05
98281, 0.375, 0.55, -0.05
98282, 0.375, 0.6, -0.05
98283, 0.375, 0.65, -0.05
98284, 0.375, 0.7, -0.05
98285, 0.375, 0.75, -0.05
98286, 0.375, 0.8, -0.05
98287, 0.375, 0.85, -0.05
98288, 0.375, 0.9, -0.05
98289, 0.375, 0.95, -0.05
98290, 0.375, 1, -0.05
98291, 0.375, 1.05, -0.05
98292, 0.375, 1.1, -0.05
98293, 0.375, 1.15, -0.05
98294, 0.375, 1.2, -0.05
98295, 0.375, 1.25, -0.05
98296, 0.375, 1.3, -0.05
98297, 0.41666666666667, 0.2, -0.05
98298, 0.41666666666667, 0.25, -0.05
98299, 0.41666666666667, 0.3, -0.05
98300, 0.41666666666667, 0.35, -0.05
98301, 0.41666666666667, 0.4, -0.05
98302, 0.41666666666667, 0.45, -0.05
98303, 0.41666666666667, 0.5, -0.05
98304, 0.41666666666667, 0.55, -0.05
98305, 0.41666666666667, 0.6, -0.05
98306, 0.41666666666667, 0.65, -0.05
98307, 0.41666666666667, 0.7, -0.05
98308, 0.41666666666667, 0.75, -0.05
98309, 0.41666666666667, 0.8, -0.05
98310, 0.41666666666667, 0.85, -0.05
98311, 0.41666666666667, 0.9, -0.05
98312, 0.41666666666667, 0.95, -0.05
98313, 0.41666666666667, 1, -0.05
98314, 0.41666666666667, 1.05, -0.05
98315, 0.41666666666667, 1.1, -0.05
98316, 0.41666666666667, 1.15, -0.05
98317, 0.41666666666667, 1.2, -0.05
98318, 0.41666666666667, 1.25, -0.05
98319, 0.41666666666667, 1.3, -0.05
98320, 0.45833333333333, 0.2, -0.05
98321, 0.45833333333333, 0.25, -0.05
98322, 0.45833333333333, 0.3, -0.05
98323, 0.45833333333333, 0.35, -0.05
98324, 0.45833333333333, 0.4, -0.05
98325, 0.45833333333333, 0.45, -0.05
98326, 0.45833333333333, 0.5, -0.05
98327, 0.45833333333333, 0.55, -0.05
98328, 0.45833333333333, 0.6, -0.05
98329, 0.45833333333333, 0.65, -0.05
98330, 0.45833333333333, 0.7, -0.05
98331, 0.45833333333333, 0.75, -0.05
98332, 0.45833333333333, 0.8, -0.05
98333, 0.45833333333333, 0.85, -0.05
98334, 0.45833333333333, 0.9, -0.05
98335, 0.45833333333333, 0.95, -0.05
98336, 0.45833333333333, 1, -0.05
98337, 0.45833333333333, 1.05, -0.05
98338, 0.45833333333333, 1.1, -0.05
98339, 0.45833333333333, 1.15, -0.05
98340, 0.45833333333333, 1.2, -0.05
98341, 0.45833333333333, 1.25, -0.05
98342, 0.45833333333333, 1.3, -0.05
98343, 0.5, 0.2, -0.05
98344, 0.5, 0.25, -0.05
98345, 0.5, 0.3, -0.05
98346, 0.5, 0.35, -0.05
98347, 0.5, 0.4, -0.05
98348, 0.5, 0.45, -0.05
98349, 0.5, 0.5, -0.05
98350, 0.5, 0.55, -0.05
98351, 0.5, 0.6, -0.05
98352, 0.5, 0.65, -0.05
98353, 0.5, 0.7, -0.05
98354, 0.5, 0.75, -0.05
98355, 0.5, 0.8, -0.05
98356, 0.5, 0.85, -0.05
98357, 0.5, 0.9, -0.05
98358, 0.5, 0.95, -0.05
98359, 0.5, 1, -0.05
98360, 0.5, 1.05, -0.05
98361, 0.5, 1.1, -0.05
98362, 0.5, 1.15, -0.05
98363, 0.5, 1.2, -0.05
98364, 0.5, 1.25, -0.05
98365, 0.5, 1.3, -0.05
98366, 0.54166666666667, 0.2, -0.05
98367, 0.54166666666667, 0.25, -0.05
98368, 0.54166666666667, 0.3, -0.05
98369, 0.54166666666667, 0.35, -0.05
98370, 0.54166666666667, 0.4, -0.05
98371, 0.54166666666667, 0.45, -0.05
98372, 0.54166666666667, 0.5, -0.05
98373, 0.54166666666667, 0.55, -0.05
98374, 0.54166666666667, 0.6, -0.05
98375, 0.54166666666667, 0.65, -0.05
98376, 0.54166666666667, 0.7, -0.05
98377, 0.54166666666667, 0.75, -0.05
98378, 0.54166666666667, 0.8, -0.05
98379, 0.54166666666667, 0.85, -0.05
98380, 0.54166666666667, 0.9, -0.05
98381, 0.54166666666667, 0.95, -0.05
98382, 0.54166666666667, 1, -0.05
98383, 0.54166666666667, 1.05, -0.05
98384, 0.54166666666667, 1.1, -0.05
98385, 0.54166666666667, 1.15, -0.05
98386, 0.54166666666667, 1.2, -0.05
98387, 0.54166666666667, 1.25, -0.05
98388, 0.54166666666667, 1.3, -0.05
98389, 0.58333333333333, 0.2, -0.05
98390, 0.58333333333333, 0.25, -0.05
98391, 0.58333333333333, 0.3, -0.05
98392, 0.58333333333333, 0.35, -0.05
98393, 0.58333333333333, 0.4, -0.05
98394, 0.58333333333333, 0.45, -0.05
98395, 0.58333333333333, 0.5, -0.05
98396, 0.58333333333333, 0.55, -0.05
98397, 0.58333333333333, 0.6, -0.05
98398, 0.58333333333333, 0.65, -0.05
98399, 0.58333333333333, 0.7, -0.05
98400, 0.58333333333333, 0.75, -0.05
98401, 0.58333333333333, 0.8, -0.05
98402, 0.58333333333333, 0.85, -0.05
98403, 0.58333333333333, 0.9, -0.05
98404, 0.58333333333333, 0.95, -0.05
98405, 0.58333333333333, 1, -0.05
98406, 0.58333333333333, 1.05, -0.05
98407, 0.58333333333333, 1.1, -0.05
98408, 0.58333333333333, 1.15, -0.05
98409, 0.58333333333333, 1.2, -0.05
98410, 0.58333333333333, 1.25, -0.05
98411, 0.58333333333333, 1.3, -0.05
98412, 0.625, 0.2, -0.05
98413, 0.625, 0.25, -0.05
98414, 0.625, 0.3, -0.05
98415, 0.625, 0.35, -0.05
98416, 0.625, 0.4, -0.05
98417, 0.625, 0.45, -0.05
98418, 0.625, 0.5, -0.05
98419, 0.625, 0.55, -0.05
98420, 0.625, 0.6, -0.05
98421, 0.625, 0.65, -0.05
98422, 0.625, 0.7, -0.05
98423, 0.625, 0.75, -0.05
98424, 0.625, 0.8, -0.05
98425, 0.625, 0.85, -0.05
98426, 0.625, 0.9, -0.05
98427, 0.625, 0.95, -0.05
98428, 0.625, 1, -0.05
98429, 0.625, 1.05, -0.05
98430, 0.625, 1.1, -0.05
98431, 0.625, 1.15, -0.05
98432, 0.625, 1.2, -0.05
98433, 0.625, 1.25, -0.05
98434, 0.625, 1.3, -0.05
98435, 0.66666666666667, 0.2, -0.05
98436, 0.66666666666667, 0.25, -0.05
98437, 0.66666666666667, 0.3, -0.05
98438, 0.66666666666667, 0.35, -0.05
98439, 0.66666666666667, 0.4, -0.05
98440, 0.66666666666667, 0.45, -0.05
98441, 0.66666666666667, 0.5, -0.05
98442, 0.66666666666667, 0.55, -0.05
98443, 0.66666666666667, 0.6, -0.05
98444, 0.66666666666667, 0.65, -0.05
98445, 0.66666666666667, 0.7, -0.05
98446, 0.66666666666667, 0.75, -0.05
98447, 0.66666666666667, 0.8, -0.05
98448, 0.66666666666667, 0.85, -0.05
98449, 0.66666666666667, 0.9, -0.05
98450, 0.66666666666667, 0.95, -0.05
98451, 0.66666666666667, 1, -0.05
98452, 0.66666666666667, 1.05, -0.05
98453, 0.66666666666667, 1.1, -0.05
98454, 0.66666666666667, 1.15, -0.05
98455, 0.66666666666667, 1.2, -0.05
98456, 0.66666666666667, 1.25, -0.05
98457, 0.66666666666667, 1.3, -0.05
98458, 0.70833333333333, 0.2, -0.05
98459, 0.70833333333333, 0.25, -0.05
98460, 0.70833333333333, 0.3, -0.05
98461, 0.70833333333333, 0.35, -0.05
98462, 0.70833333333333, 0.4, -0.05
98463, 0.70833333333333, 0.45, -0.05
98464, 0.70833333333333, 0.5, -0.05
98465, 0.70833333333333, 0.55, -0.05
98466, 0.70833333333333, 0.6, -0.05
98467, 0.70833333333333, 0.65, -0.05
98468, 0.70833333333333, 0.7, -0.05
98469, 0.70833333333333, 0.75, -0.05
98470, 0.70833333333333, 0.8, -0.05
98471, 0.70833333333333, 0.85, -0.05
98472, 0.70833333333333, 0.9, -0.05
98473, 0.70833333333333, 0.95, -0.05
98474, 0.70833333333333, 1, -0.05
98475, 0.70833333333333, 1.05, -0.05
98476, 0.70833333333333, 1.1, -0.05
98477, 0.70833333333333, 1.15, -0.05
98478, 0.70833333333333, 1.2, -0.05
98479, 0.70833333333333, 1.25, -0.05
98480, 0.70833333333333, 1.3, -0.05
98481, 0.75, 0.2, -0.05
98482, 0.75, 0.25, -0.05
98483, 0.75, 0.3, -0.05
98484, 0.75, 0.35, -0.05
98485, 0.75, 0.4, -0.05
98486, 0.75, 0.45, -0.05
98487, 0.75, 0.5, -0.05
98488, 0.75, 0.55, -0.05
98489, 0.75, 0.6, -0.05
98490, 0.75, 0.65, -0.05
98491, 0.75, 0.7, -0.05
98492, 0.75, 0.75, -0.05
98493, 0.75, 0.8, -0.05
98494, 0.75, 0.85, -0.05
98495, 0.75, 0.9, -0.05
98496, 0.75, 0.95, -0.05
98497, 0.75, 1, -0.05
98498, 0.75, 1.05, -0.05
98499, 0.75, 1.1, -0.05
98500, 0.75, 1.15, -0.05
98501, 0.75, 1.2, -0.05
98502, 0.75, 1.25, -0.05
98503, 0.75, 1.3, -0.05
98504, 0.79166666666667, 0.2, -0.05
98505, 0.79166666666667, 0.25, -0.05
98506, 0.79166666666667, 0.3, -0.05
98507, 0.79166666666667, 0.35, -0.05
98508, 0.79166666666667, 0.4, -0.05
98509, 0.79166666666667, 0.45, -0.05
98510, 0.79166666666667, 0.5, -0.05
98511, 0.79166666666667, 0.55, -0.05
98512, 0.79166666666667, 0.6, -0.05
98513, 0.79166666666667, 0.65, -0.05
98514, 0.79166666666667, 0.7, -0.05
98515, 0.79166666666667, 0.75, -0.05
98516, 0.79166666666667, 0.8, -0.05
98517, 0.79166666666667, 0.85, -0.05
98518, 0.79166666666667, 0.9, -0.05
98519, 0.79166666666667, 0.95, -0.05
98520, 0.79166666666667, 1, -0.05
98521, 0.79166666666667, 1.05, -0.05
98522, 0.79166666666667, 1.1, -0.05
98523, 0.79166666666667, 1.15, -0.05
98524, 0.79166666666667, 1.2, -0.05
98525, 0.79166666666667, 1.25, -0.05
98526, 0.79166666666667, 1.3, -0.05
98527, 0.83333333333333, 0.2, -0.05
98528, 0.83333333333333, 0.25, -0.05
98529, 0.83333333333333, 0.3, -0.05
98530, 0.83333333333333, 0.35, -0.05
98531, 0.83333333333333, 0.4, -0.05
98532, 0.83333333333333, 0.45, -0.05
98533, 0.83333333333333, 0.5, -0.05
98534, 0.83333333333333, 0.55, -0.05
98535, 0.83333333333333, 0.6, -0.05
98536, 0.83333333333333, 0.65, -0.05
98537, 0.83333333333333, 0.7, -0.05
98538, 0.83333333333333, 0.75, -0.05
98539, 0.83333333333333, 0.8, -0.05
98540, 0.83333333333333, 0.85, -0.05
98541, 0.83333333333333, 0.9, -0.05
98542, 0.83333333333333, 0.95, -0.05
98543, 0.83333333333333, 1, -0.05
98544, 0.83333333333333, 1.05, -0.05
98545, 0.83333333333333, 1.1, -0.05
98546, 0.83333333333333, 1.15, -0.05
98547, 0.83333333333333, 1.2, -0.05
98548, 0.83333333333333, 1.25, -0.05
98549, 0.83333333333333, 1.3, -0.05
98550, 0.875, 0.2, -0.05
98551, 0.875, 0.25, -0.05
98552, 0.875, 0.3, -0.05
98553, 0.875, 0.35, -0.05
98554, 0.875, 0.4, -0.05
98555, 0.875, 0.45, -0.05
98556, 0.875, 0.5, -0.05
98557, 0.875, 0.55, -0.05
98558, 0.875, 0.6, -0.05
98559, 0.875, 0.65, -0.05
98560, 0.875, 0.7, -0.05
98561, 0.875, 0.75, -0.05
98562, 0.875, 0.8, -0.05
98563, 0.875, 0.85, -0.05
98564, 0.875, 0.9, -0.05
98565, 0.875, 0.95, -0.05
98566, 0.875, 1, -0.05
98567, 0.875, 1.05, -0.05
98568, 0.875, 1.1, -0.05
98569, 0.875, 1.15, -0.05
98570, 0.875, 1.2, -0.05
98571, 0.875, 1.25, -0.05
98572, 0.875, 1.3, -0.05
98573, 0.91666666666667, 0.2, -0.05
98574, 0.91666666666667, 0.25, -0.05
98575, 0.91666666666667, 0.3, -0.05
98576, 0.91666666666667, 0.35, -0.05
98577, 0.91666666666667, 0.4, -0.05
98578, 0.91666666666667, 0.45, -0.05
98579, 0.91666666666667, 0.5, -0.05
98580, 0.91666666666667, 0.55, -0.05
98581, 0.91666666666667, 0.6, -0.05
98582, 0.91666666666667, 0.65, -0.05
98583, 0.91666666666667, 0.7, -0.05
98584, 0.91666666666667, 0.75, -0.05
98585, 0.91666666666667, 0.8, -0.05
98586, 0.91666666666667, 0.85, -0.05
98587, 0.91666666666667, 0.9, -0.05
98588, 0.91666666666667, 0.95, -0.05
98589, 0.91666666666667, 1, -0.05
98590, 0.91666666666667, 1.05, -0.05
98591, 0.91666666666667, 1.1, -0.05
98592, 0.91666666666667, 1.15, -0.05
98593, 0.91666666666667, 1.2, -0.05
98594, 0.91666666666667, 1.25, -0.05
98595, 0.91666666666667, 1.3, -0.05
98596, 0.95833333333333, 0.2, -0.05
98597, 0.95833333333333, 0.25, -0.05
98598, 0.95833333333333, 0.3, -0.05
98599, 0.95833333333333, 0.35, -0.05
98600, 0.95833333333333, 0.4, -0.05
98601, 0.95833333333333, 0.45, -0.05
98602, 0.95833333333333, 0.5, -0.05
98603, 0.95833333333333, 0.55, -0.05
98604, 0.95833333333333, 0.6, -0.05
98605, 0.95833333333333, 0.65, -0.05
98606, 0.95833333333333, 0.7, -0.05
98607, 0.95833333333333, 0.75, -0.05
98608, 0.95833333333333, 0.8, -0.05
98609, 0.95833333333333, 0.85, -0.05
98610, 0.95833333333333, 0.9, -0.05
98611, 0.95833333333333, 0.95, -0.05
98612, 0.95833333333333, 1, -0.05
98613, 0.95833333333333, 1.05, -0.05
98614, 0.95833333333333, 1.1, -0.05
98615, 0.95833333333333, 1.15, -0.05
98616, 0.95833333333333, 1.2, -0.05
98617, 0.95833333333333, 1.25, -0.05
98618, 0.95833333333333, 1.3, -0.05
98619, 1.2416666666667, 1.3, -0.05
98620, 1.2416666666667, 1.25, -0.05
98621, 1.2416666666667, 1.2, -0.05
98622, 1.2416666666667, 1.15, -0.05
98623, 1.2416666666667, 1.1, -0.05
98624, 1.2416666666667, 1.05, -0.05
98625, 1.2416666666667, 1, -0.05
98626, 1.2416666666667, 0.95, -0.05
98627, 1.2416666666667, 0.9, -0.05
98628, 1.2416666666667, 0.85, -0.05
98629, 1.2416666666667, 0.8, -0.05
98630, 1.2416666666667, 0.75, -0.05
98631, 1.2416666666667, 0.7, -0.05
98632, 1.2416666666667, 0.65, -0.05
98633, 1.2416666666667, 0.6, -0.05
98634, 1.2416666666667, 0.55, -0.05
98635, 1.2416666666667, 0.5, -0.05
98636, 1.2416666666667, 0.45, -0.05
98637, 1.2416666666667, 0.4, -0.05
98638, 1.2416666666667, 0.35, -0.05
98639, 1.2416666666667, 0.3, -0.05
98640, 1.2416666666667, 0.25, -0.05
98641, 1.2416666666667, 0.2, -0.05
98642, 1.2833333333333, 1.3, -0.05
98643, 1.2833333333333, 1.25, -0.05
98644, 1.2833333333333, 1.2, -0.05
98645, 1.2833333333333, 1.15, -0.05
98646, 1.2833333333333, 1.1, -0.05
98647, 1.2833333333333, 1.05, -0.05
98648, 1.2833333333333, 1, -0.05
98649, 1.2833333333333, 0.95, -0.05
98650, 1.2833333333333, 0.9, -0.05
98651, 1.2833333333333, 0.85, -0.05
98652, 1.2833333333333, 0.8, -0.05
98653, 1.2833333333333, 0.75, -0.05
98654, 1.2833333333333, 0.7, -0.05
98655, 1.2833333333333, 0.65, -0.05
98656, 1.2833333333333, 0.6, -0.05
98657, 1.2833333333333, 0.55, -0.05
98658, 1.2833333333333, 0.5, -0.05
98659, 1.2833333333333, 0.45, -0.05
98660, 1.2833333333333, 0.4, -0.05
98661, 1.2833333333333, 0.35, -0.05
98662, 1.2833333333333, 0.3, -0.05
98663, 1.2833333333333, 0.25, -0.05
98664, 1.2833333333333, 0.2, -0.05
98665, 1.325, 1.3, -0.05
98666, 1.325, 1.25, -0.05
98667, 1.325, 1.2, -0.05
98668, 1.325, 1.15, -0.05
98669, 1.325, 1.1, -0.05
98670, 1.325, 1.05, -0.05
98671, 1.325, 1, -0.05
98672, 1.325, 0.95, -0.05
98673, 1.325, 0.9, -0.05
98674, 1.325, 0.85, -0.05
98675, 1.325, 0.8, -0.05
98676, 1.325, 0.75, -0.05
98677, 1.325, 0.7, -0.05
98678, 1.325, 0.65, -0.05
98679, 1.325, 0.6, -0.05
98680, 1.325, 0.55, -0.05
98681, 1.325, 0.5, -0.05
98682, 1.325, 0.45, -0.05
98683, 1.325, 0.4, -0.05
98684, 1.325, 0.35, -0.05
98685, 1.325, 0.3, -0.05
98686, 1.325, 0.25, -0.05
98687, 1.325, 0.2, -0.05
98688, 1.3666666666667, 1.3, -0.05
98689, 1.3666666666667, 1.25, -0.05
98690, 1.3666666666667, 1.2, -0.05
98691, 1.3666666666667, 1.15, -0.05
98692, 1.3666666666667, 1.1, -0.05
98693, 1.3666666666667, 1.05, -0.05
98694, 1.3666666666667, 1, -0.05
98695, 1.3666666666667, 0.95, -0.05
98696, 1.3666666666667, 0.9, -0.05
98697, 1.3666666666667, 0.85, -0.05
98698, 1.3666666666667, 0.8, -0.05
98699, 1.3666666666667, 0.75, -0.05
98700, 1.3666666666667, 0.7, -0.05
98701, 1.3666666666667, 0.65, -0.05
98702, 1.3666666666667, 0.6, -0.05
98703, 1.3666666666667, 0.55, -0.05
98704, 1.3666666666667, 0.5, -0.05
98705, 1.3666666666667, 0.45, -0.05
98706, 1.3666666666667, 0.4, -0.05
98707, 1.3666666666667, 0.35, -0.05
98708, 1.3666666666667, 0.3, -0.05
98709, 1.3666666666667, 0.25, -0.05
98710, 1.3666666666667, 0.2, -0.05
98711, 1.4083333333333, 1.3, -0.05
98712, 1.4083333333333, 1.25, -0.05
98713, 1.4083333333333, 1.2, -0.05
98714, 1.4083333333333, 1.15, -0.05
98715, 1.4083333333333, 1.1, -0.05
98716, 1.4083333333333, 1.05, -0.05
98717, 1.4083333333333, 1, -0.05
98718, 1.4083333333333, 0.95, -0.05
98719, 1.4083333333333, 0.9, -0.05
98720, 1.4083333333333, 0.85, -0.05
98721, 1.4083333333333, 0.8, -0.05
98722, 1.4083333333333, 0.75, -0.05
98723, 1.4083333333333, 0.7, -0.05
98724, 1.4083333333333, 0.65, -0.05
98725, 1.4083333333333, 0.6, -0.05
98726, 1.4083333333333, 0.55, -0.05
98727, 1.4083333333333, 0.5, -0.05
98728, 1.4083333333333, 0.45, -0.05
98729, 1.4083333333333, 0.4, -0.05
98730, 1.4083333333333, 0.35, -0.05
98731, 1.4083333333333, 0.3, -0.05
98732, 1.4083333333333, 0.25, -0.05
98733, 1.4083333333333, 0.2, -0.05
98734, 1.45, 1.3, -0.05
98735, 1.45, 1.25, -0.05
98736, 1.45, 1.2, -0.05
98737, 1.45, 1.15, -0.05
98738, 1.45, 1.1, -0.05
98739, 1.45, 1.05, -0.05
98740, 1.45, 1, -0.05
98741, 1.45, 0.95, -0.05
98742, 1.45, 0.9, -0.05
98743, 1.45, 0.85, -0.05
98744, 1.45, 0.8, -0.05
98745, 1.45, 0.75, -0.05
98746, 1.45, 0.7, -0.05
98747, 1.45, 0.65, -0.05
98748, 1.45, 0.6, -0.05
98749, 1.45, 0.55, -0.05
98750, 1.45, 0.5, -0.05
98751, 1.45, 0.45, -0.05
98752, 1.45, 0.4, -0.05
98753, 1.45, 0.35, -0.05
98754, 1.45, 0.3, -0.05
98755, 1.45, 0.25, -0.05
98756, 1.45, 0.2, -0.05
98757, 1.4916666666667, 1.3, -0.05
98758, 1.4916666666667, 1.25, -0.05
98759, 1.4916666666667, 1.2, -0.05
98760, 1.4916666666667, 1.15, -0.05
98761, 1.4916666666667, 1.1, -0.05
98762, 1.4916666666667, 1.05, -0.05
98763, 1.4916666666667, 1, -0.05
98764, 1.4916666666667, 0.95, -0.05
98765, 1.4916666666667, 0.9, -0.05
98766, 1.4916666666667, 0.85, -0.05
98767, 1.4916666666667, 0.8, -0.05
98768, 1.4916666666667, 0.75, -0.05
98769, 1.4916666666667, 0.7, -0.05
98770, 1.4916666666667, 0.65, -0.05
98771, 1.4916666666667, 0.6, -0.05
98772, 1.4916666666667, 0.55, -0.05
98773, 1.4916666666667, 0.5, -0.05
98774, 1.4916666666667, 0.45, -0.05
98775, 1.4916666666667, 0.4, -0.05
98776, 1.4916666666667, 0.35, -0.05
98777, 1.4916666666667, 0.3, -0.05
98778, 1.4916666666667, 0.25, -0.05
98779, 1.4916666666667, 0.2, -0.05
98780, 1.5333333333333, 1.3, -0.05
98781, 1.5333333333333, 1.25, -0.05
98782, 1.5333333333333, 1.2, -0.05
98783, 1.5333333333333, 1.15, -0.05
98784, 1.5333333333333, 1.1, -0.05
98785, 1.5333333333333, 1.05, -0.05
98786, 1.5333333333333, 1, -0.05
98787, 1.5333333333333, 0.95, -0.05
98788, 1.5333333333333, 0.9, -0.05
98789, 1.5333333333333, 0.85, -0.05
98790, 1.5333333333333, 0.8, -0.05
98791, 1.5333333333333, 0.75, -0.05
98792, 1.5333333333333, 0.7, -0.05
98793, 1.5333333333333, 0.65, -0.05
98794, 1.5333333333333, 0.6, -0.05
98795, 1.5333333333333, 0.55, -0.05
98796, 1.5333333333333, 0.5, -0.05
98797, 1.5333333333333, 0.45, -0.05
98798, 1.5333333333333, 0.4, -0.05
98799, 1.5333333333333, 0.35, -0.05
98800, 1.5333333333333, 0.3, -0.05
98801, 1.5333333333333, 0.25, -0.05
98802, 1.5333333333333, 0.2, -0.05
98803, 1.575, 1.3, -0.05
98804, 1.575, 1.25, -0.05
98805, 1.575, 1.2, -0.05
98806, 1.575, 1.15, -0.05
98807, 1.575, 1.1, -0.05
98808, 1.575, 1.05, -0.05
98809, 1.575, 1, -0.05
98810, 1.575, 0.95, -0.05
98811, 1.575, 0.9, -0.05
98812, 1.575, 0.85, -0.05
98813, 1.575, 0.8, -0.05
98814, 1.575, 0.75, -0.05
98815, 1.575, 0.7, -0.05
98816, 1.575, 0.65, -0.05
98817, 1.575, 0.6, -0.05
98818, 1.575, 0.55, -0.05
98819, 1.575, 0.5, -0.05
98820, 1.575, 0.45, -0.05
98821, 1.575, 0.4, -0.05
98822, 1.575, 0.35, -0.05
98823, 1.575, 0.3, -0.05
98824, 1.575, 0.25, -0.05
98825, 1.575, 0.2, -0.05
98826, 1.6166666666667, 1.3, -0.05
98827, 1.6166666666667, 1.25, -0.05
98828, 1.6166666666667, 1.2, -0.05
98829, 1.6166666666667, 1.15, -0.05
98830, 1.6166666666667, 1.1, -0.05
98831, 1.6166666666667, 1.05, -0.05
98832, 1.6166666666667, 1, -0.05
98833, 1.6166666666667, 0.95, -0.05
98834, 1.6166666666667, 0.9, -0.05
98835, 1.6166666666667, 0.85, -0.05
98836, 1.6166666666667, 0.8, -0.05
98837, 1.6166666666667, 0.75, -0.05
98838, 1.6166666666667, 0.7, -0.05
98839, 1.6166666666667, 0.65, -0.05
98840, 1.6166666666667, 0.6, -0.05
98841, 1.6166666666667, 0.55, -0.05
98842, 1.6166666666667, 0.5, -0.05
98843, 1.6166666666667, 0.45, -0.05
98844, 1.6166666666667, 0.4, -0.05
98845, 1.6166666666667, 0.35, -0.05
98846, 1.6166666666667, 0.3, -0.05
98847, 1.6166666666667, 0.25, -0.05
98848, 1.6166666666667, 0.2, -0.05
98849, 1.6583333333333, 1.3, -0.05
98850, 1.6583333333333, 1.25, -0.05
98851, 1.6583333333333, 1.2, -0.05
98852, 1.6583333333333, 1.15, -0.05
98853, 1.6583333333333, 1.1, -0.05
98854, 1.6583333333333, 1.05, -0.05
98855, 1.6583333333333, 1, -0.05
98856, 1.6583333333333, 0.95, -0.05
98857, 1.6583333333333, 0.9, -0.05
98858, 1.6583333333333, 0.85, -0.05
98859, 1.6583333333333, 0.8, -0.05
98860, 1.6583333333333, 0.75, -0.05
98861, 1.6583333333333, 0.7, -0.05
98862, 1.6583333333333, 0.65, -0.05
98863, 1.6583333333333, 0.6, -0.05
98864, 1.6583333333333, 0.55, -0.05
98865, 1.6583333333333, 0.5, -0.05
98866, 1.6583333333333, 0.45, -0.05
98867, 1.6583333333333, 0.4, -0.05
98868, 1.6583333333333, 0.35, -0.05
98869, 1.6583333333333, 0.3, -0.05
98870, 1.6583333333333, 0.25, -0.05
98871, 1.6583333333333, 0.2, -0.05
98872, 1.7, 1.3, -0.05
98873, 1.7, 1.25, -0.05
98874, 1.7, 1.2, -0.05
98875, 1.7, 1.15, -0.05
98876, 1.7, 1.1, -0.05
98877, 1.7, 1.05, -0.05
98878, 1.7, 1, -0.05
98879, 1.7, 0.95, -0.05
98880, 1.7, 0.9, -0.05
98881, 1.7, 0.85, -0.05
98882, 1.7, 0.8, -0.05
98883, 1.7, 0.75, -0.05
98884, 1.7, 0.7, -0.05
98885, 1.7, 0.65, -0.05
98886, 1.7, 0.6, -0.05
98887, 1.7, 0.55, -0.05
98888, 1.7, 0.5, -0.05
98889, 1.7, 0.45, -0.05
98890, 1.7, 0.4, -0.05
98891, 1.7, 0.35, -0.05
98892, 1.7, 0.3, -0.05
98893, 1.7, 0.25, -0.05
98894, 1.7, 0.2, -0.05
98895, 1.7416666666667, 1.3, -0.05
98896, 1.7416666666667, 1.25, -0.05
98897, 1.7416666666667, 1.2, -0.05
98898, 1.7416666666667, 1.15, -0.05
98899, 1.7416666666667, 1.1, -0.05
98900, 1.7416666666667, 1.05, -0.05
98901, 1.7416666666667, 1, -0.05
98902, 1.7416666666667, 0.95, -0.05
98903, 1.7416666666667, 0.9, -0.05
98904, 1.7416666666667, 0.85, -0.05
98905, 1.7416666666667, 0.8, -0.05
98906, 1.7416666666667, 0.75, -0.05
98907, 1.7416666666667, 0.7, -0.05
98908, 1.7416666666667, 0.65, -0.05
98909, 1.7416666666667, 0.6, -0.05
98910, 1.7416666666667, 0.55, -0.05
98911, 1.7416666666667, 0.5, -0.05
98912, 1.7416666666667, 0.45, -0.05
98913, 1.7416666666667, 0.4, -0.05
98914, 1.7416666666667, 0.35, -0.05
98915, 1.7416666666667, 0.3, -0.05
98916, 1.7416666666667, 0.25, -0.05
98917, 1.7416666666667, 0.2, -0.05
98918, 1.7833333333333, 1.3, -0.05
98919, 1.7833333333333, 1.25, -0.05
98920, 1.7833333333333, 1.2, -0.05
98921, 1.7833333333333, 1.15, -0.05
98922, 1.7833333333333, 1.1, -0.05
98923, 1.7833333333333, 1.05, -0.05
98924, 1.7833333333333, 1, -0.05
98925, 1.7833333333333, 0.95, -0.05
98926, 1.7833333333333, 0.9, -0.05
98927, 1.7833333333333, 0.85, -0.05
98928, 1.7833333333333, 0.8, -0.05
98929, 1.7833333333333, 0.75, -0.05
98930, 1.7833333333333, 0.7, -0.05
98931, 1.7833333333333, 0.65, -0.05
98932, 1.7833333333333, 0.6, -0.05
98933, 1.7833333333333, 0.55, -0.05
98934, 1.7833333333333, 0.5, -0.05
98935, 1.7833333333333, 0.45, -0.05
98936, 1.7833333333333, 0.4, -0.05
98937, 1.7833333333333, 0.35, -0.05
98938, 1.7833333333333, 0.3, -0.05
98939, 1.7833333333333, 0.25, -0.05
98940, 1.7833333333333, 0.2, -0.05
98941, 1.825, 1.3, -0.05
98942, 1.825, 1.25, -0.05
98943, 1.825, 1.2, -0.05
98944, 1.825, 1.15, -0.05
98945, 1.825, 1.1, -0.05
98946, 1.825, 1.05, -0.05
98947, 1.825, 1, -0.05
98948, 1.825, 0.95, -0.05
98949, 1.825, 0.9, -0.05
98950, 1.825, 0.85, -0.05
98951, 1.825, 0.8, -0.05
98952, 1.825, 0.75, -0.05
98953, 1.825, 0.7, -0.05
98954, 1.825, 0.65, -0.05
98955, 1.825, 0.6, -0.05
98956, 1.825, 0.55, -0.05
98957, 1.825, 0.5, -0.05
98958, 1.825, 0.45, -0.05
98959, 1.825, 0.4, -0.05
98960, 1.825, 0.35, -0.05
98961, 1.825, 0.3, -0.05
98962, 1.825, 0.25, -0.05
98963, 1.825, 0.2, -0.05
98964, 1.8666666666667, 1.3, -0.05
98965, 1.8666666666667, 1.25, -0.05
98966, 1.8666666666667, 1.2, -0.05
98967, 1.8666666666667, 1.15, -0.05
98968, 1.8666666666667, 1.1, -0.05
98969, 1.8666666666667, 1.05, -0.05
98970, 1.8666666666667, 1, -0.05
98971, 1.8666666666667, 0.95, -0.05
98972, 1.8666666666667, 0.9, -0.05
98973, 1.8666666666667, 0.85, -0.05
98974, 1.8666666666667, 0.8, -0.05
98975, 1.8666666666667, 0.75, -0.05
98976, 1.8666666666667, 0.7, -0.05
98977, 1.8666666666667, 0.65, -0.05
98978, 1.8666666666667, 0.6, -0.05
98979, 1.8666666666667, 0.55, -0.05
98980, 1.8666666666667, 0.5, -0.05
98981, 1.8666666666667, 0.45, -0.05
98982, 1.8666666666667, 0.4, -0.05
98983, 1.8666666666667, 0.35, -0.05
98984, 1.8666666666667, 0.3, -0.05
98985, 1.8666666666667, 0.25, -0.05
98986, 1.8666666666667, 0.2, -0.05
98987, 1.9083333333333, 1.3, -0.05
98988, 1.9083333333333, 1.25, -0.05
98989, 1.9083333333333, 1.2, -0.05
98990, 1.9083333333333, 1.15, -0.05
98991, 1.9083333333333, 1.1, -0.05
98992, 1.9083333333333, 1.05, -0.05
98993, 1.9083333333333, 1, -0.05
98994, 1.9083333333333, 0.95, -0.05
98995, 1.9083333333333, 0.9, -0.05
98996, 1.9083333333333, 0.85, -0.05
98997, 1.9083333333333, 0.8, -0.05
98998, 1.9083333333333, 0.75, -0.05
98999, 1.9083333333333, 0.7, -0.05
99000, 1.9083333333333, 0.65, -0.05
99001, 1.9083333333333, 0.6, -0.05
99002, 1.9083333333333, 0.55, -0.05
99003, 1.9083333333333, 0.5, -0.05
99004, 1.9083333333333, 0.45, -0.05
99005, 1.9083333333333, 0.4, -0.05
99006, 1.9083333333333, 0.35, -0.05
99007, 1.9083333333333, 0.3, -0.05
99008, 1.9083333333333, 0.25, -0.05
99009, 1.9083333333333, 0.2, -0.05
99010, 1.95, 1.3, -0.05
99011, 1.95, 1.25, -0.05
99012, 1.95, 1.2, -0.05
99013, 1.95, 1.15, -0.05
99014, 1.95, 1.1, -0.05
99015, 1.95, 1.05, -0.05
99016, 1.95, 1, -0.05
99017, 1.95, 0.95, -0.05
99018, 1.95, 0.9, -0.05
99019, 1.95, 0.85, -0.05
99020, 1.95, 0.8, -0.05
99021, 1.95, 0.75, -0.05
99022, 1.95, 0.7, -0.05
99023, 1.95, 0.65, -0.05
99024, 1.95, 0.6, -0.05
99025, 1.95, 0.55, -0.05
99026, 1.95, 0.5, -0.05
99027, 1.95, 0.45, -0.05
99028, 1.95, 0.4, -0.05
99029, 1.95, 0.35, -0.05
99030, 1.95, 0.3, -0.05
99031, 1.95, 0.25, -0.05
99032, 1.95, 0.2, -0.05
99033, 1.9916666666667, 1.3, -0.05
99034, 1.9916666666667, 1.25, -0.05
99035, 1.9916666666667, 1.2, -0.05
99036, 1.9916666666667, 1.15, -0.05
99037, 1.9916666666667, 1.1, -0.05
99038, 1.9916666666667, 1.05, -0.05
99039, 1.9916666666667, 1, -0.05
99040, 1.9916666666667, 0.95, -0.05
99041, 1.9916666666667, 0.9, -0.05
99042, 1.9916666666667, 0.85, -0.05
99043, 1.9916666666667, 0.8, -0.05
99044, 1.9916666666667, 0.75, -0.05
99045, 1.9916666666667, 0.7, -0.05
99046, 1.9916666666667, 0.65, -0.05
99047, 1.9916666666667, 0.6, -0.05
99048, 1.9916666666667, 0.55, -0.05
99049, 1.9916666666667, 0.5, -0.05
99050, 1.9916666666667, 0.45, -0.05
99051, 1.9916666666667, 0.4, -0.05
99052, 1.9916666666667, 0.35, -0.05
99053, 1.9916666666667, 0.3, -0.05
99054, 1.9916666666667, 0.25, -0.05
99055, 1.9916666666667, 0.2, -0.05
99056, 2.0333333333333, 1.3, -0.05
99057, 2.0333333333333, 1.25, -0.05
99058, 2.0333333333333, 1.2, -0.05
99059, 2.0333333333333, 1.15, -0.05
99060, 2.0333333333333, 1.1, -0.05
99061, 2.0333333333333, 1.05, -0.05
99062, 2.0333333333333, 1, -0.05
99063, 2.0333333333333, 0.95, -0.05
99064, 2.0333333333333, 0.9, -0.05
99065, 2.0333333333333, 0.85, -0.05
99066, 2.0333333333333, 0.8, -0.05
99067, 2.0333333333333, 0.75, -0.05
99068, 2.0333333333333, 0.7, -0.05
99069, 2.0333333333333, 0.65, -0.05
99070, 2.0333333333333, 0.6, -0.05
99071, 2.0333333333333, 0.55, -0.05
99072, 2.0333333333333, 0.5, -0.05
99073, 2.0333333333333, 0.45, -0.05
99074, 2.0333333333333, 0.4, -0.05
99075, 2.0333333333333, 0.35, -0.05
99076, 2.0333333333333, 0.3, -0.05
99077, 2.0333333333333, 0.25, -0.05
99078, 2.0333333333333, 0.2, -0.05
99079, 2.075, 1.3, -0.05
99080, 2.075, 1.25, -0.05
99081, 2.075, 1.2, -0.05
99082, 2.075, 1.15, -0.05
99083, 2.075, 1.1, -0.05
99084, 2.075, 1.05, -0.05
99085, 2.075, 1, -0.05
99086, 2.075, 0.95, -0.05
99087, 2.075, 0.9, -0.05
99088, 2.075, 0.85, -0.05
99089, 2.075, 0.8, -0.05
99090, 2.075, 0.75, -0.05
99091, 2.075, 0.7, -0.05
99092, 2.075, 0.65, -0.05
99093, 2.075, 0.6, -0.05
99094, 2.075, 0.55, -0.05
99095, 2.075, 0.5, -0.05
99096, 2.075, 0.45, -0.05
99097, 2.075, 0.4, -0.05
99098, 2.075, 0.35, -0.05
99099, 2.075, 0.3, -0.05
99100, 2.075, 0.25, -0.05
99101, 2.075, 0.2, -0.05
99102, 2.1166666666667, 1.3, -0.05
99103, 2.1166666666667, 1.25, -0.05
99104, 2.1166666666667, 1.2, -0.05
99105, 2.1166666666667, 1.15, -0.05
99106, 2.1166666666667, 1.1, -0.05
99107, 2.1166666666667, 1.05, -0.05
99108, 2.1166666666667, 1, -0.05
99109, 2.1166666666667, 0.95, -0.05
99110, 2.1166666666667, 0.9, -0.05
99111, 2.1166666666667, 0.85, -0.05
99112, 2.1166666666667, 0.8, -0.05
99113, 2.1166666666667, 0.75, -0.05
99114, 2.1166666666667, 0.7, -0.05
99115, 2.1166666666667, 0.65, -0.05
99116, 2.1166666666667, 0.6, -0.05
99117, 2.1166666666667, 0.55, -0.05
99118, 2.1166666666667, 0.5, -0.05
99119, 2.1166666666667, 0.45, -0.05
99120, 2.1166666666667, 0.4, -0.05
99121, 2.1166666666667, 0.35, -0.05
99122, 2.1166666666667, 0.3, -0.05
99123, 2.1166666666667, 0.25, -0.05
99124, 2.1166666666667, 0.2, -0.05
99125, 2.1583333333333, 1.3, -0.05
99126, 2.1583333333333, 1.25, -0.05
99127, 2.1583333333333, 1.2, -0.05
99128, 2.1583333333333, 1.15, -0.05
99129, 2.1583333333333, 1.1, -0.05
99130, 2.1583333333333, 1.05, -0.05
99131, 2.1583333333333, 1, -0.05
99132, 2.1583333333333, 0.95, -0.05
99133, 2.1583333333333, 0.9, -0.05
99134, 2.1583333333333, 0.85, -0.05
99135, 2.1583333333333, 0.8, -0.05
99136, 2.1583333333333, 0.75, -0.05
99137, 2.1583333333333, 0.7, -0.05
99138, 2.1583333333333, 0.65, -0.05
99139, 2.1583333333333, 0.6, -0.05
99140, 2.1583333333333, 0.55, -0.05
99141, 2.1583333333333, 0.5, -0.05
99142, 2.1583333333333, 0.45, -0.05
99143, 2.1583333333333, 0.4, -0.05
99144, 2.1583333333333, 0.35, -0.05
99145, 2.1583333333333, 0.3, -0.05
99146, 2.1583333333333, 0.25, -0.05
99147, 2.1583333333333, 0.2, -0.05
99148, 1.025, 0.2, 0.041666666666667
99149, 1.025, 0.25, 0.041666666666667
99150, 1.025, 0.3, 0.041666666666667
99151, 1.025, 0.35, 0.041666666666667
99152, 1.025, 0.4, 0.041666666666667
99153, 1.025, 0.45, 0.041666666666667
99154, 1.025, 0.5, 0.041666666666667
99155, 1.025, 0.55, 0.041666666666667
99156, 1.025, 0.6, 0.041666666666667
99157, 1.025, 0.65, 0.041666666666667
99158, 1.025, 0.7, 0.041666666666667
99159, 1.025, 0.75, 0.041666666666667
99160, 1.025, 0.8, 0.041666666666667
99161, 1.025, 0.85, 0.041666666666667
99162, 1.025, 0.9, 0.041666666666667
99163, 1.025, 0.95, 0.041666666666667
99164, 1.025, 1, 0.041666666666667
99165, 1.025, 1.05, 0.041666666666667
99166, 1.025, 1.1, 0.041666666666667
99167, 1.025, 1.15, 0.041666666666667
99168, 1.025, 1.2, 0.041666666666667
99169, 1.025, 1.25, 0.041666666666667
99170, 1.025, 1.3, 0.041666666666667
99171, 1.025, 0.2, 0.083333333333333
99172, 1.025, 0.25, 0.083333333333333
99173, 1.025, 0.3, 0.083333333333333
99174, 1.025, 0.35, 0.083333333333333
99175, 1.025, 0.4, 0.083333333333333
99176, 1.025, 0.45, 0.083333333333333
99177, 1.025, 0.5, 0.083333333333333
99178, 1.025, 0.55, 0.083333333333333
99179, 1.025, 0.6, 0.083333333333333
99180, 1.025, 0.65, 0.083333333333333
99181, 1.025, 0.7, 0.083333333333333
99182, 1.025, 0.75, 0.083333333333333
99183, 1.025, 0.8, 0.083333333333333
99184, 1.025, 0.85, 0.083333333333333
99185, 1.025, 0.9, 0.083333333333333
99186, 1.025, 0.95, 0.083333333333333
99187, 1.025, 1, 0.083333333333333
99188, 1.025, 1.05, 0.083333333333333
99189, 1.025, 1.1, 0.083333333333333
99190, 1.025, 1.15, 0.083333333333333
99191, 1.025, 1.2, 0.083333333333333
99192, 1.025, 1.25, 0.083333333333333
99193, 1.025, 1.3, 0.083333333333333
99194, 1.025, 0.2, 0.125
99195, 1.025, 0.25, 0.125
99196, 1.025, 0.3, 0.125
99197, 1.025, 0.35, 0.125
99198, 1.025, 0.4, 0.125
99199, 1.025, 0.45, 0.125
99200, 1.025, 0.5, 0.125
99201, 1.025, 0.55, 0.125
99202, 1.025, 0.6, 0.125
99203, 1.025, 0.65, 0.125
99204, 1.025, 0.7, 0.125
99205, 1.025, 0.75, 0.125
99206, 1.025, 0.8, 0.125
99207, 1.025, 0.85, 0.125
99208, 1.025, 0.9, 0.125
99209, 1.025, 0.95, 0.125
99210, 1.025, 1, 0.125
99211, 1.025, 1.05, 0.125
99212, 1.025, 1.1, 0.125
99213, 1.025, 1.15, 0.125
99214, 1.025, 1.2, 0.125
99215, 1.025, 1.25, 0.125
99216, 1.025, 1.3, 0.125
99217, 1.025, 0.2, 0.16666666666667
99218, 1.025, 0.25, 0.16666666666667
99219, 1.025, 0.3, 0.16666666666667
99220, 1.025, 0.35, 0.16666666666667
99221, 1.025, 0.4, 0.16666666666667
99222, 1.025, 0.45, 0.16666666666667
99223, 1.025, 0.5, 0.16666666666667
99224, 1.025, 0.55, 0.16666666666667
99225, 1.025, 0.6, 0.16666666666667
99226, 1.025, 0.65, 0.16666666666667
99227, 1.025, 0.7, 0.16666666666667
99228, 1.025, 0.75, 0.16666666666667
99229, 1.025, 0.8, 0.16666666666667
99230, 1.025, 0.85, 0.16666666666667
99231, 1.025, 0.9, 0.16666666666667
99232, 1.025, 0.95, 0.16666666666667
99233, 1.025, 1, 0.16666666666667
99234, 1.025, 1.05, 0.16666666666667
99235, 1.025, 1.1, 0.16666666666667
99236, 1.025, 1.15, 0.16666666666667
99237, 1.025, 1.2, 0.16666666666667
99238, 1.025, 1.25, 0.16666666666667
99239, 1.025, 1.3, 0.16666666666667
99240, 1.025, 0.2, 0.20833333333333
99241, 1.025, 0.25, 0.20833333333333
99242, 1.025, 0.3, 0.20833333333333
99243, 1.025, 0.35, 0.20833333333333
99244, 1.025, 0.4, 0.20833333333333
99245, 1.025, 0.45, 0.20833333333333
99246, 1.025, 0.5, 0.20833333333333
99247, 1.025, 0.55, 0.20833333333333
99248, 1.025, 0.6, 0.20833333333333
99249, 1.025, 0.65, 0.20833333333333
99250, 1.025, 0.7, 0.20833333333333
99251, 1.025, 0.75, 0.20833333333333
99252, 1.025, 0.8, 0.20833333333333
99253, 1.025, 0.85, 0.20833333333333
99254, 1.025, 0.9, 0.20833333333333
99255, 1.025, 0.95, 0.20833333333333
99256, 1.025, 1, 0.20833333333333
99257, 1.025, 1.05, 0.20833333333333
99258, 1.025, 1.1, 0.20833333333333
99259, 1.025, 1.15, 0.20833333333333
