36544, 100025, 100029, 100073, 100069, 32235, 32236, 32247, 32246, 101918, 102064, 102065, 102051, 32591, 32613, 32614, 
32611, 101906, 101919, 102066, 102053
36545, 14001, 14002, 14013, 14012, 100026, 100030, 100074, 100070, 14358, 14380, 14381, 14378, 101922, 102068, 102069, 
102055, 101907, 101920, 102067, 102054
36546, 100026, 100030, 100074, 100070, 100027, 100031, 100075, 100071, 101922, 102068, 102069, 102055, 101925, 102071, 102072, 
102058, 101910, 101923, 102070, 102057
36547, 100027, 100031, 100075, 100071, 100028, 100032, 100076, 100072, 101925, 102071, 102072, 102058, 101928, 102074, 102075, 
102061, 101913, 101926, 102073, 102060
36548, 100028, 100032, 100076, 100072, 100029, 100033, 100077, 100073, 101928, 102074, 102075, 102061, 101931, 102077, 102078, 
102064, 101916, 101929, 102076, 102063
36549, 100029, 100033, 100077, 100073, 32236, 32237, 32248, 32247, 101931, 102077, 102078, 102064, 32593, 32615, 32616, 
32613, 101919, 101932, 102079, 102066
36550, 14002, 14003, 14014, 14013, 100030, 100034, 100078, 100074, 14360, 14382, 14383, 14380, 101935, 102081, 102082, 
102068, 101920, 101933, 102080, 102067
36551, 100030, 100034, 100078, 100074, 100031, 100035, 100079, 100075, 101935, 102081, 102082, 102068, 101938, 102084, 102085, 
102071, 101923, 101936, 102083, 102070
36552, 100031, 100035, 100079, 100075, 100032, 100036, 100080, 100076, 101938, 102084, 102085, 102071, 101941, 102087, 102088, 
102074, 101926, 101939, 102086, 102073
36553, 100032, 100036, 100080, 100076, 100033, 100037, 100081, 100077, 101941, 102087, 102088, 102074, 101944, 102090, 102091, 
102077, 101929, 101942, 102089, 102076
36554, 100033, 100037, 100081, 100077, 32237, 32238, 32249, 32248, 101944, 102090, 102091, 102077, 32595, 32617, 32618, 
32615, 101932, 101945, 102092, 102079
36555, 14003, 14004, 14015, 14014, 100034, 100038, 100082, 100078, 14362, 14384, 14385, 14382, 101948, 102094, 102095, 
102081, 101933, 101946, 102093, 102080
36556, 100034, 100038, 100082, 100078, 100035, 100039, 100083, 100079, 101948, 102094, 102095, 102081, 101951, 102097, 102098, 
102084, 101936, 101949, 102096, 102083
36557, 100035, 100039, 100083, 100079, 100036, 100040, 100084, 100080, 101951, 102097, 102098, 102084, 101954, 102100, 102101, 
102087, 101939, 101952, 102099, 102086
36558, 100036, 100040, 100084, 100080, 100037, 100041, 100085, 100081, 101954, 102100, 102101, 102087, 101957, 102103, 102104, 
102090, 101942, 101955, 102102, 102089
36559, 100037, 100041, 100085, 100081, 32238, 32239, 32250, 32249, 101957, 102103, 102104, 102090, 32597, 32619, 32620, 
32617, 101945, 101958, 102105, 102092
36560, 14004, 14005, 14016, 14015, 100038, 100042, 100086, 100082, 14364, 14386, 14387, 14384, 101961, 102107, 102108, 
102094, 101946, 101959, 102106, 102093
36561, 100038, 100042, 100086, 100082, 100039, 100043, 100087, 100083, 101961, 102107, 102108, 102094, 101964, 102110, 102111, 
102097, 101949, 101962, 102109, 102096
36562, 100039, 100043, 100087, 100083, 100040, 100044, 100088, 100084, 101964, 102110, 102111, 102097, 101967, 102113, 102114, 
102100, 101952, 101965, 102112, 102099
36563, 100040, 100044, 100088, 100084, 100041, 100045, 100089, 100085, 101967, 102113, 102114, 102100, 101970, 102116, 102117, 
102103, 101955, 101968, 102115, 102102
36564, 100041, 100045, 100089, 100085, 32239, 32240, 32251, 32250, 101970, 102116, 102117, 102103, 32599, 32621, 32622, 
32619, 101958, 101971, 102118, 102105
36565, 14005, 14006, 14017, 14016, 100042, 100046, 100090, 100086, 14366, 14388, 14389, 14386, 101974, 102120, 102121, 
102107, 101959, 101972, 102119, 102106
36566, 100042, 100046, 100090, 100086, 100043, 100047, 100091, 100087, 101974, 102120, 102121, 102107, 101977, 102123, 102124, 
102110, 101962, 101975, 102122, 102109
36567, 100043, 100047, 100091, 100087, 100044, 100048, 100092, 100088, 101977, 102123, 102124, 102110, 101980, 102126, 102127, 
102113, 101965, 101978, 102125, 102112
36568, 100044, 100048, 100092, 100088, 100045, 100049, 100093, 100089, 101980, 102126, 102127, 102113, 101983, 102129, 102130, 
102116, 101968, 101981, 102128, 102115
36569, 100045, 100049, 100093, 100089, 32240, 32241, 32252, 32251, 101983, 102129, 102130, 102116, 32601, 32623, 32624, 
32621, 101971, 101984, 102131, 102118
36570, 14006, 1111, 1112, 14017, 100046, 31725, 31729, 100090, 14367, 1135, 14390, 14388, 101985, 31867, 102132, 
102120, 101972, 31857, 31866, 102119
36571, 100046, 31725, 31729, 100090, 100047, 31726, 31730, 100091, 101985, 31867, 102132, 102120, 101986, 31869, 102133, 
102123, 101975, 31859, 31868, 102122
36572, 100047, 31726, 31730, 100091, 100048, 31727, 31731, 100092, 101986, 31869, 102133, 102123, 101987, 31871, 102134, 
102126, 101978, 31861, 31870, 102125
36573, 100048, 31727, 31731, 100092, 100049, 31728, 31732, 100093, 101987, 31871, 102134, 102126, 101988, 31873, 102135, 
102129, 101981, 31863, 31872, 102128
36574, 100049, 31728, 31732, 100093, 32241, 3293, 3294, 32252, 101988, 31873, 102135, 102129, 32602, 3317, 32625, 
32623, 101984, 31865, 31874, 102131
36575, 1032, 14007, 14018, 1033, 31279, 100050, 100094, 31283, 14369, 14391, 14392, 1056, 101991, 102137, 102138, 
31425, 31417, 101989, 102136, 31426
36576, 31279, 100050, 100094, 31283, 31280, 100051, 100095, 31284, 101991, 102137, 102138, 31425, 101994, 102140, 102141, 
31427, 31419, 101992, 102139, 31428
36577, 31280, 100051, 100095, 31284, 31281, 100052, 100096, 31285, 101994, 102140, 102141, 31427, 101997, 102143, 102144, 
31429, 31421, 101995, 102142, 31430
36578, 31281, 100052, 100096, 31285, 31282, 100053, 100097, 31286, 101997, 102143, 102144, 31429, 102000, 102146, 102147, 
31431, 31423, 101998, 102145, 31432
36579, 31282, 100053, 100097, 31286, 3206, 32242, 32253, 3207, 102000, 102146, 102147, 31431, 32604, 32626, 32627, 
3230, 31424, 102001, 102148, 31433
36580, 14007, 14008, 14019, 14018, 100050, 100054, 100098, 100094, 14371, 14393, 14394, 14391, 102004, 102150, 102151, 
102137, 101989, 102002, 102149, 102136
36581, 100050, 100054, 100098, 100094, 100051, 100055, 100099, 100095, 102004, 102150, 102151, 102137, 102007, 102153, 102154, 
102140, 101992, 102005, 102152, 102139
36582, 100051, 100055, 100099, 100095, 100052, 100056, 100100, 100096, 102007, 102153, 102154, 102140, 102010, 102156, 102157, 
102143, 101995, 102008, 102155, 102142
36583, 100052, 100056, 100100, 100096, 100053, 100057, 100101, 100097, 102010, 102156, 102157, 102143, 102013, 102159, 102160, 
102146, 101998, 102011, 102158, 102145
36584, 100053, 100057, 100101, 100097, 32242, 32243, 32254, 32253, 102013, 102159, 102160, 102146, 32606, 32628, 32629, 
32626, 102001, 102014, 102161, 102148
36585, 14008, 14009, 14020, 14019, 100054, 100058, 100102, 100098, 14373, 14395, 14396, 14393, 102017, 102163, 102164, 
102150, 102002, 102015, 102162, 102149
36586, 100054, 100058, 100102, 100098, 100055, 100059, 100103, 100099, 102017, 102163, 102164, 102150, 102020, 102166, 102167, 
102153, 102005, 102018, 102165, 102152
36587, 100055, 100059, 100103, 100099, 100056, 100060, 100104, 100100, 102020, 102166, 102167, 102153, 102023, 102169, 102170, 
102156, 102008, 102021, 102168, 102155
36588, 100056, 100060, 100104, 100100, 100057, 100061, 100105, 100101, 102023, 102169, 102170, 102156, 102026, 102172, 102173, 
102159, 102011, 102024, 102171, 102158
36589, 100057, 100061, 100105, 100101, 32243, 32244, 32255, 32254, 102026, 102172, 102173, 102159, 32608, 32630, 32631, 
32628, 102014, 102027, 102174, 102161
36590, 14009, 14010, 14021, 14020, 100058, 100062, 100106, 100102, 14375, 14397, 14398, 14395, 102030, 102176, 102177, 
102163, 102015, 102028, 102175, 102162
36591, 100058, 100062, 100106, 100102, 100059, 100063, 100107, 100103, 102030, 102176, 102177, 102163, 102033, 102179, 102180, 
102166, 102018, 102031, 102178, 102165
36592, 100059, 100063, 100107, 100103, 100060, 100064, 100108, 100104, 102033, 102179, 102180, 102166, 102036, 102182, 102183, 
102169, 102021, 102034, 102181, 102168
36593, 100060, 100064, 100108, 100104, 100061, 100065, 100109, 100105, 102036, 102182, 102183, 102169, 102039, 102185, 102186, 
102172, 102024, 102037, 102184, 102171
36594, 100061, 100065, 100109, 100105, 32244, 32245, 32256, 32255, 102039, 102185, 102186, 102172, 32610, 32632, 32633, 
32630, 102027, 102040, 102187, 102174
36595, 14010, 14011, 14022, 14021, 100062, 100066, 100110, 100106, 14377, 14399, 14400, 14397, 102043, 102189, 102190, 
102176, 102028, 102041, 102188, 102175
36596, 100062, 100066, 100110, 100106, 100063, 100067, 100111, 100107, 102043, 102189, 102190, 102176, 102046, 102192, 102193, 
102179, 102031, 102044, 102191, 102178
36597, 100063, 100067, 100111, 100107, 100064, 100068, 100112, 100108, 102046, 102192, 102193, 102179, 102049, 102195, 102196, 
102182, 102034, 102047, 102194, 102181
36598, 100064, 100068, 100112, 100108, 100065, 100069, 100113, 100109, 102049, 102195, 102196, 102182, 102052, 102198, 102199, 
102185, 102037, 102050, 102197, 102184
36599, 100065, 100069, 100113, 100109, 32245, 32246, 32257, 32256, 102052, 102198, 102199, 102185, 32612, 32634, 32635, 
32632, 102040, 102053, 102200, 102187
36600, 14011, 14012, 14023, 14022, 100066, 100070, 100114, 100110, 14379, 14401, 14402, 14399, 102056, 102202, 102203, 
102189, 102041, 102054, 102201, 102188
36601, 100066, 100070, 100114, 100110, 100067, 100071, 100115, 100111, 102056, 102202, 102203, 102189, 102059, 102205, 102206, 
102192, 102044, 102057, 102204, 102191
36602, 100067, 100071, 100115, 100111, 100068, 100072, 100116, 100112, 102059, 102205, 102206, 102192, 102062, 102208, 102209, 
102195, 102047, 102060, 102207, 102194
36603, 100068, 100072, 100116, 100112, 100069, 100073, 100117, 100113, 102062, 102208, 102209, 102195, 102065, 102211, 102212, 
102198, 102050, 102063, 102210, 102197
36604, 100069, 100073, 100117, 100113, 32246, 32247, 32258, 32257, 102065, 102211, 102212, 102198, 32614, 32636, 32637, 
32634, 102053, 102066, 102213, 102200
36605, 14012, 14013, 14024, 14023, 100070, 100074, 100118, 100114, 14381, 14403, 14404, 14401, 102069, 102215, 102216, 
102202, 102054, 102067, 102214, 102201
36606, 100070, 100074, 100118, 100114, 100071, 100075, 100119, 100115, 102069, 102215, 102216, 102202, 102072, 102218, 102219, 
102205, 102057, 102070, 102217, 102204
36607, 100071, 100075, 100119, 100115, 100072, 100076, 100120, 100116, 102072, 102218, 102219, 102205, 102075, 102221, 102222, 
102208, 102060, 102073, 102220, 102207
36608, 100072, 100076, 100120, 100116, 100073, 100077, 100121, 100117, 102075, 102221, 102222, 102208, 102078, 102224, 102225, 
102211, 102063, 102076, 102223, 102210
36609, 100073, 100077, 100121, 100117, 32247, 32248, 32259, 32258, 102078, 102224, 102225, 102211, 32616, 32638, 32639, 
32636, 102066, 102079, 102226, 102213
36610, 14013, 14014, 14025, 14024, 100074, 100078, 100122, 100118, 14383, 14405, 14406, 14403, 102082, 102228, 102229, 
102215, 102067, 102080, 102227, 102214
36611, 100074, 100078, 100122, 100118, 100075, 100079, 100123, 100119, 102082, 102228, 102229, 102215, 102085, 102231, 102232, 
102218, 102070, 102083, 102230, 102217
36612, 100075, 100079, 100123, 100119, 100076, 100080, 100124, 100120, 102085, 102231, 102232, 102218, 102088, 102234, 102235, 
102221, 102073, 102086, 102233, 102220
36613, 100076, 100080, 100124, 100120, 100077, 100081, 100125, 100121, 102088, 102234, 102235, 102221, 102091, 102237, 102238, 
102224, 102076, 102089, 102236, 102223
36614, 100077, 100081, 100125, 100121, 32248, 32249, 32260, 32259, 102091, 102237, 102238, 102224, 32618, 32640, 32641, 
32638, 102079, 102092, 102239, 102226
36615, 14014, 14015, 14026, 14025, 100078, 100082, 100126, 100122, 14385, 14407, 14408, 14405, 102095, 102241, 102242, 
102228, 102080, 102093, 102240, 102227
36616, 100078, 100082, 100126, 100122, 100079, 100083, 100127, 100123, 102095, 102241, 102242, 102228, 102098, 102244, 102245, 
102231, 102083, 102096, 102243, 102230
36617, 100079, 100083, 100127, 100123, 100080, 100084, 100128, 100124, 102098, 102244, 102245, 102231, 102101, 102247, 102248, 
102234, 102086, 102099, 102246, 102233
36618, 100080, 100084, 100128, 100124, 100081, 100085, 100129, 100125, 102101, 102247, 102248, 102234, 102104, 102250, 102251, 
102237, 102089, 102102, 102249, 102236
36619, 100081, 100085, 100129, 100125, 32249, 32250, 32261, 32260, 102104, 102250, 102251, 102237, 32620, 32642, 32643, 
32640, 102092, 102105, 102252, 102239
36620, 14015, 14016, 14027, 14026, 100082, 100086, 100130, 100126, 14387, 14409, 14410, 14407, 102108, 102254, 102255, 
102241, 102093, 102106, 102253, 102240
36621, 100082, 100086, 100130, 100126, 100083, 100087, 100131, 100127, 102108, 102254, 102255, 102241, 102111, 102257, 102258, 
102244, 102096, 102109, 102256, 102243
36622, 100083, 100087, 100131, 100127, 100084, 100088, 100132, 100128, 102111, 102257, 102258, 102244, 102114, 102260, 102261, 
102247, 102099, 102112, 102259, 102246
36623, 100084, 100088, 100132, 100128, 100085, 100089, 100133, 100129, 102114, 102260, 102261, 102247, 102117, 102263, 102264, 
102250, 102102, 102115, 102262, 102249
36624, 100085, 100089, 100133, 100129, 32250, 32251, 32262, 32261, 102117, 102263, 102264, 102250, 32622, 32644, 32645, 
32642, 102105, 102118, 102265, 102252
36625, 14016, 14017, 14028, 14027, 100086, 100090, 100134, 100130, 14389, 14411, 14412, 14409, 102121, 102267, 102268, 
102254, 102106, 102119, 102266, 102253
36626, 100086, 100090, 100134, 100130, 100087, 100091, 100135, 100131, 102121, 102267, 102268, 102254, 102124, 102270, 102271, 
102257, 102109, 102122, 102269, 102256
36627, 100087, 100091, 100135, 100131, 100088, 100092, 100136, 100132, 102124, 102270, 102271, 102257, 102127, 102273, 102274, 
102260, 102112, 102125, 102272, 102259
36628, 100088, 100092, 100136, 100132, 100089, 100093, 100137, 100133, 102127, 102273, 102274, 102260, 102130, 102276, 102277, 
102263, 102115, 102128, 102275, 102262
36629, 100089, 100093, 100137, 100133, 32251, 32252, 32263, 32262, 102130, 102276, 102277, 102263, 32624, 32646, 32647, 
32644, 102118, 102131, 102278, 102265
36630, 14017, 1112, 1113, 14028, 100090, 31729, 31733, 100134, 14390, 1136, 14413, 14411, 102132, 31876, 102279, 
102267, 102119, 31866, 31875, 102266
36631, 100090, 31729, 31733, 100134, 100091, 31730, 31734, 100135, 102132, 31876, 102279, 102267, 102133, 31878, 102280, 
102270, 102122, 31868, 31877, 102269
36632, 100091, 31730, 31734, 100135, 100092, 31731, 31735, 100136, 102133, 31878, 102280, 102270, 102134, 31880, 102281, 
102273, 102125, 31870, 31879, 102272
36633, 100092, 31731, 31735, 100136, 100093, 31732, 31736, 100137, 102134, 31880, 102281, 102273, 102135, 31882, 102282, 
102276, 102128, 31872, 31881, 102275
36634, 100093, 31732, 31736, 100137, 32252, 3294, 3295, 32263, 102135, 31882, 102282, 102276, 32625, 3318, 32648, 
32646, 102131, 31874, 31883, 102278
36635, 1033, 14018, 14029, 1034, 31283, 100094, 100138, 31287, 14392, 14414, 14415, 1057, 102138, 102284, 102285, 
31434, 31426, 102136, 102283, 31435
36636, 31283, 100094, 100138, 31287, 31284, 100095, 100139, 31288, 102138, 102284, 102285, 31434, 102141, 102287, 102288, 
31436, 31428, 102139, 102286, 31437
36637, 31284, 100095, 100139, 31288, 31285, 100096, 100140, 31289, 102141, 102287, 102288, 31436, 102144, 102290, 102291, 
31438, 31430, 102142, 102289, 31439
36638, 31285, 100096, 100140, 31289, 31286, 100097, 100141, 31290, 102144, 102290, 102291, 31438, 102147, 102293, 102294, 
31440, 31432, 102145, 102292, 31441
36639, 31286, 100097, 100141, 31290, 3207, 32253, 32264, 3208, 102147, 102293, 102294, 31440, 32627, 32649, 32650, 
3231, 31433, 102148, 102295, 31442
36640, 14018, 14019, 14030, 14029, 100094, 100098, 100142, 100138, 14394, 14416, 14417, 14414, 102151, 102297, 102298, 
102284, 102136, 102149, 102296, 102283
36641, 100094, 100098, 100142, 100138, 100095, 100099, 100143, 100139, 102151, 102297, 102298, 102284, 102154, 102300, 102301, 
102287, 102139, 102152, 102299, 102286
36642, 100095, 100099, 100143, 100139, 100096, 100100, 100144, 100140, 102154, 102300, 102301, 102287, 102157, 102303, 102304, 
102290, 102142, 102155, 102302, 102289
36643, 100096, 100100, 100144, 100140, 100097, 100101, 100145, 100141, 102157, 102303, 102304, 102290, 102160, 102306, 102307, 
102293, 102145, 102158, 102305, 102292
36644, 100097, 100101, 100145, 100141, 32253, 32254, 32265, 32264, 102160, 102306, 102307, 102293, 32629, 32651, 32652, 
32649, 102148, 102161, 102308, 102295
36645, 14019, 14020, 14031, 14030, 100098, 100102, 100146, 100142, 14396, 14418, 14419, 14416, 102164, 102310, 102311, 
102297, 102149, 102162, 102309, 102296
36646, 100098, 100102, 100146, 100142, 100099, 100103, 100147, 100143, 102164, 102310, 102311, 102297, 102167, 102313, 102314, 
102300, 102152, 102165, 102312, 102299
36647, 100099, 100103, 100147, 100143, 100100, 100104, 100148, 100144, 102167, 102313, 102314, 102300, 102170, 102316, 102317, 
102303, 102155, 102168, 102315, 102302
36648, 100100, 100104, 100148, 100144, 100101, 100105, 100149, 100145, 102170, 102316, 102317, 102303, 102173, 102319, 102320, 
102306, 102158, 102171, 102318, 102305
36649, 100101, 100105, 100149, 100145, 32254, 32255, 32266, 32265, 102173, 102319, 102320, 102306, 32631, 32653, 32654, 
32651, 102161, 102174, 102321, 102308
36650, 14020, 14021, 14032, 14031, 100102, 100106, 100150, 100146, 14398, 14420, 14421, 14418, 102177, 102323, 102324, 
102310, 102162, 102175, 102322, 102309
36651, 100102, 100106, 100150, 100146, 100103, 100107, 100151, 100147, 102177, 102323, 102324, 102310, 102180, 102326, 102327, 
102313, 102165, 102178, 102325, 102312
36652, 100103, 100107, 100151, 100147, 100104, 100108, 100152, 100148, 102180, 102326, 102327, 102313, 102183, 102329, 102330, 
102316, 102168, 102181, 102328, 102315
36653, 100104, 100108, 100152, 100148, 100105, 100109, 100153, 100149, 102183, 102329, 102330, 102316, 102186, 102332, 102333, 
102319, 102171, 102184, 102331, 102318
36654, 100105, 100109, 100153, 100149, 32255, 32256, 32267, 32266, 102186, 102332, 102333, 102319, 32633, 32655, 32656, 
32653, 102174, 102187, 102334, 102321
36655, 14021, 14022, 14033, 14032, 100106, 100110, 100154, 100150, 14400, 14422, 14423, 14420, 102190, 102336, 102337, 
102323, 102175, 102188, 102335, 102322
36656, 100106, 100110, 100154, 100150, 100107, 100111, 100155, 100151, 102190, 102336, 102337, 102323, 102193, 102339, 102340, 
102326, 102178, 102191, 102338, 102325
36657, 100107, 100111, 100155, 100151, 100108, 100112, 100156, 100152, 102193, 102339, 102340, 102326, 102196, 102342, 102343, 
102329, 102181, 102194, 102341, 102328
36658, 100108, 100112, 100156, 100152, 100109, 100113, 100157, 100153, 102196, 102342, 102343, 102329, 102199, 102345, 102346, 
102332, 102184, 102197, 102344, 102331
36659, 100109, 100113, 100157, 100153, 32256, 32257, 32268, 32267, 102199, 102345, 102346, 102332, 32635, 32657, 32658, 
32655, 102187, 102200, 102347, 102334
36660, 14022, 14023, 14034, 14033, 100110, 100114, 100158, 100154, 14402, 14424, 14425, 14422, 102203, 102349, 102350, 
102336, 102188, 102201, 102348, 102335
36661, 100110, 100114, 100158, 100154, 100111, 100115, 100159, 100155, 102203, 102349, 102350, 102336, 102206, 102352, 102353, 
102339, 102191, 102204, 102351, 102338
36662, 100111, 100115, 100159, 100155, 100112, 100116, 100160, 100156, 102206, 102352, 102353, 102339, 102209, 102355, 102356, 
102342, 102194, 102207, 102354, 102341
36663, 100112, 100116, 100160, 100156, 100113, 100117, 100161, 100157, 102209, 102355, 102356, 102342, 102212, 102358, 102359, 
102345, 102197, 102210, 102357, 102344
36664, 100113, 100117, 100161, 100157, 32257, 32258, 32269, 32268, 102212, 102358, 102359, 102345, 32637, 32659, 32660, 
32657, 102200, 102213, 102360, 102347
36665, 14023, 14024, 14035, 14034, 100114, 100118, 100162, 100158, 14404, 14426, 14427, 14424, 102216, 102362, 102363, 
102349, 102201, 102214, 102361, 102348
36666, 100114, 100118, 100162, 100158, 100115, 100119, 100163, 100159, 102216, 102362, 102363, 102349, 102219, 102365, 102366, 
102352, 102204, 102217, 102364, 102351
36667, 100115, 100119, 100163, 100159, 100116, 100120, 100164, 100160, 102219, 102365, 102366, 102352, 102222, 102368, 102369, 
102355, 102207, 102220, 102367, 102354
36668, 100116, 100120, 100164, 100160, 100117, 100121, 100165, 100161, 102222, 102368, 102369, 102355, 102225, 102371, 102372, 
102358, 102210, 102223, 102370, 102357
36669, 100117, 100121, 100165, 100161, 32258, 32259, 32270, 32269, 102225, 102371, 102372, 102358, 32639, 32661, 32662, 
32659, 102213, 102226, 102373, 102360
36670, 14024, 14025, 14036, 14035, 100118, 100122, 100166, 100162, 14406, 14428, 14429, 14426, 102229, 102375, 102376, 
102362, 102214, 102227, 102374, 102361
36671, 100118, 100122, 100166, 100162, 100119, 100123, 100167, 100163, 102229, 102375, 102376, 102362, 102232, 102378, 102379, 
102365, 102217, 102230, 102377, 102364
36672, 100119, 100123, 100167, 100163, 100120, 100124, 100168, 100164, 102232, 102378, 102379, 102365, 102235, 102381, 102382, 
102368, 102220, 102233, 102380, 102367
36673, 100120, 100124, 100168, 100164, 100121, 100125, 100169, 100165, 102235, 102381, 102382, 102368, 102238, 102384, 102385, 
102371, 102223, 102236, 102383, 102370
36674, 100121, 100125, 100169, 100165, 32259, 32260, 32271, 32270, 102238, 102384, 102385, 102371, 32641, 32663, 32664, 
32661, 102226, 102239, 102386, 102373
36675, 14025, 14026, 14037, 14036, 100122, 100126, 100170, 100166, 14408, 14430, 14431, 14428, 102242, 102388, 102389, 
102375, 102227, 102240, 102387, 102374
36676, 100122, 100126, 100170, 100166, 100123, 100127, 100171, 100167, 102242, 102388, 102389, 102375, 102245, 102391, 102392, 
102378, 102230, 102243, 102390, 102377
36677, 100123, 100127, 100171, 100167, 100124, 100128, 100172, 100168, 102245, 102391, 102392, 102378, 102248, 102394, 102395, 
102381, 102233, 102246, 102393, 102380
36678, 100124, 100128, 100172, 100168, 100125, 100129, 100173, 100169, 102248, 102394, 102395, 102381, 102251, 102397, 102398, 
102384, 102236, 102249, 102396, 102383
36679, 100125, 100129, 100173, 100169, 32260, 32261, 32272, 32271, 102251, 102397, 102398, 102384, 32643, 32665, 32666, 
32663, 102239, 102252, 102399, 102386
36680, 14026, 14027, 14038, 14037, 100126, 100130, 100174, 100170, 14410, 14432, 14433, 14430, 102255, 102401, 102402, 
102388, 102240, 102253, 102400, 102387
36681, 100126, 100130, 100174, 100170, 100127, 100131, 100175, 100171, 102255, 102401, 102402, 102388, 102258, 102404, 102405, 
102391, 102243, 102256, 102403, 102390
36682, 100127, 100131, 100175, 100171, 100128, 100132, 100176, 100172, 102258, 102404, 102405, 102391, 102261, 102407, 102408, 
102394, 102246, 102259, 102406, 102393
36683, 100128, 100132, 100176, 100172, 100129, 100133, 100177, 100173, 102261, 102407, 102408, 102394, 102264, 102410, 102411, 
102397, 102249, 102262, 102409, 102396
36684, 100129, 100133, 100177, 100173, 32261, 32262, 32273, 32272, 102264, 102410, 102411, 102397, 32645, 32667, 32668, 
32665, 102252, 102265, 102412, 102399
36685, 14027, 14028, 14039, 14038, 100130, 100134, 100178, 100174, 14412, 14434, 14435, 14432, 102268, 102414, 102415, 
102401, 102253, 102266, 102413, 102400
36686, 100130, 100134, 100178, 100174, 100131, 100135, 100179, 100175, 102268, 102414, 102415, 102401, 102271, 102417, 102418, 
102404, 102256, 102269, 102416, 102403
36687, 100131, 100135, 100179, 100175, 100132, 100136, 100180, 100176, 102271, 102417, 102418, 102404, 102274, 102420, 102421, 
102407, 102259, 102272, 102419, 102406
36688, 100132, 100136, 100180, 100176, 100133, 100137, 100181, 100177, 102274, 102420, 102421, 102407, 102277, 102423, 102424, 
102410, 102262, 102275, 102422, 102409
36689, 100133, 100137, 100181, 100177, 32262, 32263, 32274, 32273, 102277, 102423, 102424, 102410, 32647, 32669, 32670, 
32667, 102265, 102278, 102425, 102412
36690, 14028, 1113, 1114, 14039, 100134, 31733, 31737, 100178, 14413, 1137, 14436, 14434, 102279, 31885, 102426, 
102414, 102266, 31875, 31884, 102413
36691, 100134, 31733, 31737, 100178, 100135, 31734, 31738, 100179, 102279, 31885, 102426, 102414, 102280, 31887, 102427, 
102417, 102269, 31877, 31886, 102416
36692, 100135, 31734, 31738, 100179, 100136, 31735, 31739, 100180, 102280, 31887, 102427, 102417, 102281, 31889, 102428, 
102420, 102272, 31879, 31888, 102419
36693, 100136, 31735, 31739, 100180, 100137, 31736, 31740, 100181, 102281, 31889, 102428, 102420, 102282, 31891, 102429, 
102423, 102275, 31881, 31890, 102422
36694, 100137, 31736, 31740, 100181, 32263, 3295, 3296, 32274, 102282, 31891, 102429, 102423, 32648, 3319, 32671, 
32669, 102278, 31883, 31892, 102425
36695, 1034, 14029, 14040, 1035, 31287, 100138, 100182, 31291, 14415, 14437, 14438, 1058, 102285, 102431, 102432, 
31443, 31435, 102283, 102430, 31444
36696, 31287, 100138, 100182, 31291, 31288, 100139, 100183, 31292, 102285, 102431, 102432, 31443, 102288, 102434, 102435, 
31445, 31437, 102286, 102433, 31446
36697, 31288, 100139, 100183, 31292, 31289, 100140, 100184, 31293, 102288, 102434, 102435, 31445, 102291, 102437, 102438, 
31447, 31439, 102289, 102436, 31448
36698, 31289, 100140, 100184, 31293, 31290, 100141, 100185, 31294, 102291, 102437, 102438, 31447, 102294, 102440, 102441, 
31449, 31441, 102292, 102439, 31450
36699, 31290, 100141, 100185, 31294, 3208, 32264, 32275, 3209, 102294, 102440, 102441, 31449, 32650, 32672, 32673, 
3232, 31442, 102295, 102442, 31451
36700, 14029, 14030, 14041, 14040, 100138, 100142, 100186, 100182, 14417, 14439, 14440, 14437, 102298, 102444, 102445, 
102431, 102283, 102296, 102443, 102430
36701, 100138, 100142, 100186, 100182, 100139, 100143, 100187, 100183, 102298, 102444, 102445, 102431, 102301, 102447, 102448, 
102434, 102286, 102299, 102446, 102433
36702, 100139, 100143, 100187, 100183, 100140, 100144, 100188, 100184, 102301, 102447, 102448, 102434, 102304, 102450, 102451, 
102437, 102289, 102302, 102449, 102436
36703, 100140, 100144, 100188, 100184, 100141, 100145, 100189, 100185, 102304, 102450, 102451, 102437, 102307, 102453, 102454, 
102440, 102292, 102305, 102452, 102439
36704, 100141, 100145, 100189, 100185, 32264, 32265, 32276, 32275, 102307, 102453, 102454, 102440, 32652, 32674, 32675, 
32672, 102295, 102308, 102455, 102442
36705, 14030, 14031, 14042, 14041, 100142, 100146, 100190, 100186, 14419, 14441, 14442, 14439, 102311, 102457, 102458, 
102444, 102296, 102309, 102456, 102443
36706, 100142, 100146, 100190, 100186, 100143, 100147, 100191, 100187, 102311, 102457, 102458, 102444, 102314, 102460, 102461, 
102447, 102299, 102312, 102459, 102446
36707, 100143, 100147, 100191, 100187, 100144, 100148, 100192, 100188, 102314, 102460, 102461, 102447, 102317, 102463, 102464, 
102450, 102302, 102315, 102462, 102449
36708, 100144, 100148, 100192, 100188, 100145, 100149, 100193, 100189, 102317, 102463, 102464, 102450, 102320, 102466, 102467, 
102453, 102305, 102318, 102465, 102452
36709, 100145, 100149, 100193, 100189, 32265, 32266, 32277, 32276, 102320, 102466, 102467, 102453, 32654, 32676, 32677, 
32674, 102308, 102321, 102468, 102455
36710, 14031, 14032, 14043, 14042, 100146, 100150, 100194, 100190, 14421, 14443, 14444, 14441, 102324, 102470, 102471, 
102457, 102309, 102322, 102469, 102456
36711, 100146, 100150, 100194, 100190, 100147, 100151, 100195, 100191, 102324, 102470, 102471, 102457, 102327, 102473, 102474, 
102460, 102312, 102325, 102472, 102459
36712, 100147, 100151, 100195, 100191, 100148, 100152, 100196, 100192, 102327, 102473, 102474, 102460, 102330, 102476, 102477, 
102463, 102315, 102328, 102475, 102462
36713, 100148, 100152, 100196, 100192, 100149, 100153, 100197, 100193, 102330, 102476, 102477, 102463, 102333, 102479, 102480, 
102466, 102318, 102331, 102478, 102465
36714, 100149, 100153, 100197, 100193, 32266, 32267, 32278, 32277, 102333, 102479, 102480, 102466, 32656, 32678, 32679, 
32676, 102321, 102334, 102481, 102468
36715, 14032, 14033, 14044, 14043, 100150, 100154, 100198, 100194, 14423, 14445, 14446, 14443, 102337, 102483, 102484, 
102470, 102322, 102335, 102482, 102469
36716, 100150, 100154, 100198, 100194, 100151, 100155, 100199, 100195, 102337, 102483, 102484, 102470, 102340, 102486, 102487, 
102473, 102325, 102338, 102485, 102472
36717, 100151, 100155, 100199, 100195, 100152, 100156, 100200, 100196, 102340, 102486, 102487, 102473, 102343, 102489, 102490, 
102476, 102328, 102341, 102488, 102475
36718, 100152, 100156, 100200, 100196, 100153, 100157, 100201, 100197, 102343, 102489, 102490, 102476, 102346, 102492, 102493, 
102479, 102331, 102344, 102491, 102478
36719, 100153, 100157, 100201, 100197, 32267, 32268, 32279, 32278, 102346, 102492, 102493, 102479, 32658, 32680, 32681, 
32678, 102334, 102347, 102494, 102481
36720, 14033, 14034, 14045, 14044, 100154, 100158, 100202, 100198, 14425, 14447, 14448, 14445, 102350, 102496, 102497, 
102483, 102335, 102348, 102495, 102482
36721, 100154, 100158, 100202, 100198, 100155, 100159, 100203, 100199, 102350, 102496, 102497, 102483, 102353, 102499, 102500, 
102486, 102338, 102351, 102498, 102485
36722, 100155, 100159, 100203, 100199, 100156, 100160, 100204, 100200, 102353, 102499, 102500, 102486, 102356, 102502, 102503, 
102489, 102341, 102354, 102501, 102488
36723, 100156, 100160, 100204, 100200, 100157, 100161, 100205, 100201, 102356, 102502, 102503, 102489, 102359, 102505, 102506, 
102492, 102344, 102357, 102504, 102491
36724, 100157, 100161, 100205, 100201, 32268, 32269, 32280, 32279, 102359, 102505, 102506, 102492, 32660, 32682, 32683, 
32680, 102347, 102360, 102507, 102494
36725, 14034, 14035, 14046, 14045, 100158, 100162, 100206, 100202, 14427, 14449, 14450, 14447, 102363, 102509, 102510, 
102496, 102348, 102361, 102508, 102495
36726, 100158, 100162, 100206, 100202, 100159, 100163, 100207, 100203, 102363, 102509, 102510, 102496, 102366, 102512, 102513, 
102499, 102351, 102364, 102511, 102498
36727, 100159, 100163, 100207, 100203, 100160, 100164, 100208, 100204, 102366, 102512, 102513, 102499, 102369, 102515, 102516, 
102502, 102354, 102367, 102514, 102501
36728, 100160, 100164, 100208, 100204, 100161, 100165, 100209, 100205, 102369, 102515, 102516, 102502, 102372, 102518, 102519, 
102505, 102357, 102370, 102517, 102504
36729, 100161, 100165, 100209, 100205, 32269, 32270, 32281, 32280, 102372, 102518, 102519, 102505, 32662, 32684, 32685, 
32682, 102360, 102373, 102520, 102507
36730, 14035, 14036, 14047, 14046, 100162, 100166, 100210, 100206, 14429, 14451, 14452, 14449, 102376, 102522, 102523, 
102509, 102361, 102374, 102521, 102508
36731, 100162, 100166, 100210, 100206, 100163, 100167, 100211, 100207, 102376, 102522, 102523, 102509, 102379, 102525, 102526, 
102512, 102364, 102377, 102524, 102511
36732, 100163, 100167, 100211, 100207, 100164, 100168, 100212, 100208, 102379, 102525, 102526, 102512, 102382, 102528, 102529, 
102515, 102367, 102380, 102527, 102514
36733, 100164, 100168, 100212, 100208, 100165, 100169, 100213, 100209, 102382, 102528, 102529, 102515, 102385, 102531, 102532, 
102518, 102370, 102383, 102530, 102517
36734, 100165, 100169, 100213, 100209, 32270, 32271, 32282, 32281, 102385, 102531, 102532, 102518, 32664, 32686, 32687, 
32684, 102373, 102386, 102533, 102520
36735, 14036, 14037, 14048, 14047, 100166, 100170, 100214, 100210, 14431, 14453, 14454, 14451, 102389, 102535, 102536, 
102522, 102374, 102387, 102534, 102521
36736, 100166, 100170, 100214, 100210, 100167, 100171, 100215, 100211, 102389, 102535, 102536, 102522, 102392, 102538, 102539, 
102525, 102377, 102390, 102537, 102524
36737, 100167, 100171, 100215, 100211, 100168, 100172, 100216, 100212, 102392, 102538, 102539, 102525, 102395, 102541, 102542, 
102528, 102380, 102393, 102540, 102527
36738, 100168, 100172, 100216, 100212, 100169, 100173, 100217, 100213, 102395, 102541, 102542, 102528, 102398, 102544, 102545, 
102531, 102383, 102396, 102543, 102530
36739, 100169, 100173, 100217, 100213, 32271, 32272, 32283, 32282, 102398, 102544, 102545, 102531, 32666, 32688, 32689, 
32686, 102386, 102399, 102546, 102533
36740, 14037, 14038, 14049, 14048, 100170, 100174, 100218, 100214, 14433, 14455, 14456, 14453, 102402, 102548, 102549, 
102535, 102387, 102400, 102547, 102534
36741, 100170, 100174, 100218, 100214, 100171, 100175, 100219, 100215, 102402, 102548, 102549, 102535, 102405, 102551, 102552, 
102538, 102390, 102403, 102550, 102537
36742, 100171, 100175, 100219, 100215, 100172, 100176, 100220, 100216, 102405, 102551, 102552, 102538, 102408, 102554, 102555, 
102541, 102393, 102406, 102553, 102540
36743, 100172, 100176, 100220, 100216, 100173, 100177, 100221, 100217, 102408, 102554, 102555, 102541, 102411, 102557, 102558, 
102544, 102396, 102409, 102556, 102543
36744, 100173, 100177, 100221, 100217, 32272, 32273, 32284, 32283, 102411, 102557, 102558, 102544, 32668, 32690, 32691, 
32688, 102399, 102412, 102559, 102546
36745, 14038, 14039, 14050, 14049, 100174, 100178, 100222, 100218, 14435, 14457, 14458, 14455, 102415, 102561, 102562, 
102548, 102400, 102413, 102560, 102547
36746, 100174, 100178, 100222, 100218, 100175, 100179, 100223, 100219, 102415, 102561, 102562, 102548, 102418, 102564, 102565, 
102551, 102403, 102416, 102563, 102550
36747, 100175, 100179, 100223, 100219, 100176, 100180, 100224, 100220, 102418, 102564, 102565, 102551, 102421, 102567, 102568, 
102554, 102406, 102419, 102566, 102553
36748, 100176, 100180, 100224, 100220, 100177, 100181, 100225, 100221, 102421, 102567, 102568, 102554, 102424, 102570, 102571, 
102557, 102409, 102422, 102569, 102556
36749, 100177, 100181, 100225, 100221, 32273, 32274, 32285, 32284, 102424, 102570, 102571, 102557, 32670, 32692, 32693, 
32690, 102412, 102425, 102572, 102559
36750, 14039, 1114, 1115, 14050, 100178, 31737, 31741, 100222, 14436, 1138, 14459, 14457, 102426, 31894, 102573, 
102561, 102413, 31884, 31893, 102560
36751, 100178, 31737, 31741, 100222, 100179, 31738, 31742, 100223, 102426, 31894, 102573, 102561, 102427, 31896, 102574, 
102564, 102416, 31886, 31895, 102563
36752, 100179, 31738, 31742, 100223, 100180, 31739, 31743, 100224, 102427, 31896, 102574, 102564, 102428, 31898, 102575, 
102567, 102419, 31888, 31897, 102566
36753, 100180, 31739, 31743, 100224, 100181, 31740, 31744, 100225, 102428, 31898, 102575, 102567, 102429, 31900, 102576, 
102570, 102422, 31890, 31899, 102569
36754, 100181, 31740, 31744, 100225, 32274, 3296, 3297, 32285, 102429, 31900, 102576, 102570, 32671, 3320, 32694, 
32692, 102425, 31892, 31901, 102572
36755, 1035, 14040, 14051, 1036, 31291, 100182, 100226, 31295, 14438, 14460, 14461, 1059, 102432, 102578, 102579, 
31452, 31444, 102430, 102577, 31453
36756, 31291, 100182, 100226, 31295, 31292, 100183, 100227, 31296, 102432, 102578, 102579, 31452, 102435, 102581, 102582, 
31454, 31446, 102433, 102580, 31455
36757, 31292, 100183, 100227, 31296, 31293, 100184, 100228, 31297, 102435, 102581, 102582, 31454, 102438, 102584, 102585, 
31456, 31448, 102436, 102583, 31457
36758, 31293, 100184, 100228, 31297, 31294, 100185, 100229, 31298, 102438, 102584, 102585, 31456, 102441, 102587, 102588, 
31458, 31450, 102439, 102586, 31459
36759, 31294, 100185, 100229, 31298, 3209, 32275, 32286, 3210, 102441, 102587, 102588, 31458, 32673, 32695, 32696, 
3233, 31451, 102442, 102589, 31460
36760, 14040, 14041, 14052, 14051, 100182, 100186, 100230, 100226, 14440, 14462, 14463, 14460, 102445, 102591, 102592, 
102578, 102430, 102443, 102590, 102577
36761, 100182, 100186, 100230, 100226, 100183, 100187, 100231, 100227, 102445, 102591, 102592, 102578, 102448, 102594, 102595, 
102581, 102433, 102446, 102593, 102580
36762, 100183, 100187, 100231, 100227, 100184, 100188, 100232, 100228, 102448, 102594, 102595, 102581, 102451, 102597, 102598, 
102584, 102436, 102449, 102596, 102583
36763, 100184, 100188, 100232, 100228, 100185, 100189, 100233, 100229, 102451, 102597, 102598, 102584, 102454, 102600, 102601, 
102587, 102439, 102452, 102599, 102586
36764, 100185, 100189, 100233, 100229, 32275, 32276, 32287, 32286, 102454, 102600, 102601, 102587, 32675, 32697, 32698, 
32695, 102442, 102455, 102602, 102589
36765, 14041, 14042, 14053, 14052, 100186, 100190, 100234, 100230, 14442, 14464, 14465, 14462, 102458, 102604, 102605, 
102591, 102443, 102456, 102603, 102590
36766, 100186, 100190, 100234, 100230, 100187, 100191, 100235, 100231, 102458, 102604, 102605, 102591, 102461, 102607, 102608, 
102594, 102446, 102459, 102606, 102593
36767, 100187, 100191, 100235, 100231, 100188, 100192, 100236, 100232, 102461, 102607, 102608, 102594, 102464, 102610, 102611, 
102597, 102449, 102462, 102609, 102596
36768, 100188, 100192, 100236, 100232, 100189, 100193, 100237, 100233, 102464, 102610, 102611, 102597, 102467, 102613, 102614, 
102600, 102452, 102465, 102612, 102599
36769, 100189, 100193, 100237, 100233, 32276, 32277, 32288, 32287, 102467, 102613, 102614, 102600, 32677, 32699, 32700, 
32697, 102455, 102468, 102615, 102602
36770, 14042, 14043, 14054, 14053, 100190, 100194, 100238, 100234, 14444, 14466, 14467, 14464, 102471, 102617, 102618, 
102604, 102456, 102469, 102616, 102603
36771, 100190, 100194, 100238, 100234, 100191, 100195, 100239, 100235, 102471, 102617, 102618, 102604, 102474, 102620, 102621, 
102607, 102459, 102472, 102619, 102606
36772, 100191, 100195, 100239, 100235, 100192, 100196, 100240, 100236, 102474, 102620, 102621, 102607, 102477, 102623, 102624, 
102610, 102462, 102475, 102622, 102609
36773, 100192, 100196, 100240, 100236, 100193, 100197, 100241, 100237, 102477, 102623, 102624, 102610, 102480, 102626, 102627, 
102613, 102465, 102478, 102625, 102612
36774, 100193, 100197, 100241, 100237, 32277, 32278, 32289, 32288, 102480, 102626, 102627, 102613, 32679, 32701, 32702, 
32699, 102468, 102481, 102628, 102615
36775, 14043, 14044, 14055, 14054, 100194, 100198, 100242, 100238, 14446, 14468, 14469, 14466, 102484, 102630, 102631, 
102617, 102469, 102482, 102629, 102616
36776, 100194, 100198, 100242, 100238, 100195, 100199, 100243, 100239, 102484, 102630, 102631, 102617, 102487, 102633, 102634, 
102620, 102472, 102485, 102632, 102619
36777, 100195, 100199, 100243, 100239, 100196, 100200, 100244, 100240, 102487, 102633, 102634, 102620, 102490, 102636, 102637, 
102623, 102475, 102488, 102635, 102622
36778, 100196, 100200, 100244, 100240, 100197, 100201, 100245, 100241, 102490, 102636, 102637, 102623, 102493, 102639, 102640, 
102626, 102478, 102491, 102638, 102625
36779, 100197, 100201, 100245, 100241, 32278, 32279, 32290, 32289, 102493, 102639, 102640, 102626, 32681, 32703, 32704, 
32701, 102481, 102494, 102641, 102628
36780, 14044, 14045, 14056, 14055, 100198, 100202, 100246, 100242, 14448, 14470, 14471, 14468, 102497, 102643, 102644, 
102630, 102482, 102495, 102642, 102629
36781, 100198, 100202, 100246, 100242, 100199, 100203, 100247, 100243, 102497, 102643, 102644, 102630, 102500, 102646, 102647, 
102633, 102485, 102498, 102645, 102632
36782, 100199, 100203, 100247, 100243, 100200, 100204, 100248, 100244, 102500, 102646, 102647, 102633, 102503, 102649, 102650, 
102636, 102488, 102501, 102648, 102635
36783, 100200, 100204, 100248, 100244, 100201, 100205, 100249, 100245, 102503, 102649, 102650, 102636, 102506, 102652, 102653, 
102639, 102491, 102504, 102651, 102638
36784, 100201, 100205, 100249, 100245, 32279, 32280, 32291, 32290, 102506, 102652, 102653, 102639, 32683, 32705, 32706, 
32703, 102494, 102507, 102654, 102641
36785, 14045, 14046, 14057, 14056, 100202, 100206, 100250, 100246, 14450, 14472, 14473, 14470, 102510, 102656, 102657, 
102643, 102495, 102508, 102655, 102642
36786, 100202, 100206, 100250, 100246, 100203, 100207, 100251, 100247, 102510, 102656, 102657, 102643, 102513, 102659, 102660, 
102646, 102498, 102511, 102658, 102645
36787, 100203, 100207, 100251, 100247, 100204, 100208, 100252, 100248, 102513, 102659, 102660, 102646, 102516, 102662, 102663, 
102649, 102501, 102514, 102661, 102648
36788, 100204, 100208, 100252, 100248, 100205, 100209, 100253, 100249, 102516, 102662, 102663, 102649, 102519, 102665, 102666, 
102652, 102504, 102517, 102664, 102651
36789, 100205, 100209, 100253, 100249, 32280, 32281, 32292, 32291, 102519, 102665, 102666, 102652, 32685, 32707, 32708, 
32705, 102507, 102520, 102667, 102654
36790, 14046, 14047, 14058, 14057, 100206, 100210, 100254, 100250, 14452, 14474, 14475, 14472, 102523, 102669, 102670, 
102656, 102508, 102521, 102668, 102655
36791, 100206, 100210, 100254, 100250, 100207, 100211, 100255, 100251, 102523, 102669, 102670, 102656, 102526, 102672, 102673, 
102659, 102511, 102524, 102671, 102658
36792, 100207, 100211, 100255, 100251, 100208, 100212, 100256, 100252, 102526, 102672, 102673, 102659, 102529, 102675, 102676, 
102662, 102514, 102527, 102674, 102661
36793, 100208, 100212, 100256, 100252, 100209, 100213, 100257, 100253, 102529, 102675, 102676, 102662, 102532, 102678, 102679, 
102665, 102517, 102530, 102677, 102664
36794, 100209, 100213, 100257, 100253, 32281, 32282, 32293, 32292, 102532, 102678, 102679, 102665, 32687, 32709, 32710, 
32707, 102520, 102533, 102680, 102667
36795, 14047, 14048, 14059, 14058, 100210, 100214, 100258, 100254, 14454, 14476, 14477, 14474, 102536, 102682, 102683, 
102669, 102521, 102534, 102681, 102668
36796, 100210, 100214, 100258, 100254, 100211, 100215, 100259, 100255, 102536, 102682, 102683, 102669, 102539, 102685, 102686, 
102672, 102524, 102537, 102684, 102671
36797, 100211, 100215, 100259, 100255, 100212, 100216, 100260, 100256, 102539, 102685, 102686, 102672, 102542, 102688, 102689, 
102675, 102527, 102540, 102687, 102674
36798, 100212, 100216, 100260, 100256, 100213, 100217, 100261, 100257, 102542, 102688, 102689, 102675, 102545, 102691, 102692, 
102678, 102530, 102543, 102690, 102677
36799, 100213, 100217, 100261, 100257, 32282, 32283, 32294, 32293, 102545, 102691, 102692, 102678, 32689, 32711, 32712, 
32709, 102533, 102546, 102693, 102680
36800, 14048, 14049, 14060, 14059, 100214, 100218, 100262, 100258, 14456, 14478, 14479, 14476, 102549, 102695, 102696, 
102682, 102534, 102547, 102694, 102681
36801, 100214, 100218, 100262, 100258, 100215, 100219, 100263, 100259, 102549, 102695, 102696, 102682, 102552, 102698, 102699, 
102685, 102537, 102550, 102697, 102684
36802, 100215, 100219, 100263, 100259, 100216, 100220, 100264, 100260, 102552, 102698, 102699, 102685, 102555, 102701, 102702, 
102688, 102540, 102553, 102700, 102687
36803, 100216, 100220, 100264, 100260, 100217, 100221, 100265, 100261, 102555, 102701, 102702, 102688, 102558, 102704, 102705, 
102691, 102543, 102556, 102703, 102690
36804, 100217, 100221, 100265, 100261, 32283, 32284, 32295, 32294, 102558, 102704, 102705, 102691, 32691, 32713, 32714, 
32711, 102546, 102559, 102706, 102693
36805, 14049, 14050, 14061, 14060, 100218, 100222, 100266, 100262, 14458, 14480, 14481, 14478, 102562, 102708, 102709, 
102695, 102547, 102560, 102707, 102694
36806, 100218, 100222, 100266, 100262, 100219, 100223, 100267, 100263, 102562, 102708, 102709, 102695, 102565, 102711, 102712, 
102698, 102550, 102563, 102710, 102697
36807, 100219, 100223, 100267, 100263, 100220, 100224, 100268, 100264, 102565, 102711, 102712, 102698, 102568, 102714, 102715, 
102701, 102553, 102566, 102713, 102700
36808, 100220, 100224, 100268, 100264, 100221, 100225, 100269, 100265, 102568, 102714, 102715, 102701, 102571, 102717, 102718, 
102704, 102556, 102569, 102716, 102703
36809, 100221, 100225, 100269, 100265, 32284, 32285, 32296, 32295, 102571, 102717, 102718, 102704, 32693, 32715, 32716, 
32713, 102559, 102572, 102719, 102706
36810, 14050, 1115, 1116, 14061, 100222, 31741, 31745, 100266, 14459, 1139, 14482, 14480, 102573, 31903, 102720, 
102708, 102560, 31893, 31902, 102707
36811, 100222, 31741, 31745, 100266, 100223, 31742, 31746, 100267, 102573, 31903, 102720, 102708, 102574, 31905, 102721, 
102711, 102563, 31895, 31904, 102710
36812, 100223, 31742, 31746, 100267, 100224, 31743, 31747, 100268, 102574, 31905, 102721, 102711, 102575, 31907, 102722, 
102714, 102566, 31897, 31906, 102713
36813, 100224, 31743, 31747, 100268, 100225, 31744, 31748, 100269, 102575, 31907, 102722, 102714, 102576, 31909, 102723, 
102717, 102569, 31899, 31908, 102716
36814, 100225, 31744, 31748, 100269, 32285, 3297, 3298, 32296, 102576, 31909, 102723, 102717, 32694, 3321, 32717, 
32715, 102572, 31901, 31910, 102719
36815, 1036, 14051, 14062, 1037, 31295, 100226, 100270, 31299, 14461, 14483, 14484, 1060, 102579, 102725, 102726, 
31461, 31453, 102577, 102724, 31462
36816, 31295, 100226, 100270, 31299, 31296, 100227, 100271, 31300, 102579, 102725, 102726, 31461, 102582, 102728, 102729, 
31463, 31455, 102580, 102727, 31464
36817, 31296, 100227, 100271, 31300, 31297, 100228, 100272, 31301, 102582, 102728, 102729, 31463, 102585, 102731, 102732, 
31465, 31457, 102583, 102730, 31466
36818, 31297, 100228, 100272, 31301, 31298, 100229, 100273, 31302, 102585, 102731, 102732, 31465, 102588, 102734, 102735, 
31467, 31459, 102586, 102733, 31468
36819, 31298, 100229, 100273, 31302, 3210, 32286, 32297, 3211, 102588, 102734, 102735, 31467, 32696, 32718, 32719, 
3234, 31460, 102589, 102736, 31469
36820, 14051, 14052, 14063, 14062, 100226, 100230, 100274, 100270, 14463, 14485, 14486, 14483, 102592, 102738, 102739, 
102725, 102577, 102590, 102737, 102724
36821, 100226, 100230, 100274, 100270, 100227, 100231, 100275, 100271, 102592, 102738, 102739, 102725, 102595, 102741, 102742, 
102728, 102580, 102593, 102740, 102727
36822, 100227, 100231, 100275, 100271, 100228, 100232, 100276, 100272, 102595, 102741, 102742, 102728, 102598, 102744, 102745, 
102731, 102583, 102596, 102743, 102730
36823, 100228, 100232, 100276, 100272, 100229, 100233, 100277, 100273, 102598, 102744, 102745, 102731, 102601, 102747, 102748, 
102734, 102586, 102599, 102746, 102733
36824, 100229, 100233, 100277, 100273, 32286, 32287, 32298, 32297, 102601, 102747, 102748, 102734, 32698, 32720, 32721, 
32718, 102589, 102602, 102749, 102736
36825, 14052, 14053, 14064, 14063, 100230, 100234, 100278, 100274, 14465, 14487, 14488, 14485, 102605, 102751, 102752, 
102738, 102590, 102603, 102750, 102737
36826, 100230, 100234, 100278, 100274, 100231, 100235, 100279, 100275, 102605, 102751, 102752, 102738, 102608, 102754, 102755, 
102741, 102593, 102606, 102753, 102740
36827, 100231, 100235, 100279, 100275, 100232, 100236, 100280, 100276, 102608, 102754, 102755, 102741, 102611, 102757, 102758, 
102744, 102596, 102609, 102756, 102743
36828, 100232, 100236, 100280, 100276, 100233, 100237, 100281, 100277, 102611, 102757, 102758, 102744, 102614, 102760, 102761, 
102747, 102599, 102612, 102759, 102746
36829, 100233, 100237, 100281, 100277, 32287, 32288, 32299, 32298, 102614, 102760, 102761, 102747, 32700, 32722, 32723, 
32720, 102602, 102615, 102762, 102749
36830, 14053, 14054, 14065, 14064, 100234, 100238, 100282, 100278, 14467, 14489, 14490, 14487, 102618, 102764, 102765, 
102751, 102603, 102616, 102763, 102750
36831, 100234, 100238, 100282, 100278, 100235, 100239, 100283, 100279, 102618, 102764, 102765, 102751, 102621, 102767, 102768, 
102754, 102606, 102619, 102766, 102753
36832, 100235, 100239, 100283, 100279, 100236, 100240, 100284, 100280, 102621, 102767, 102768, 102754, 102624, 102770, 102771, 
102757, 102609, 102622, 102769, 102756
36833, 100236, 100240, 100284, 100280, 100237, 100241, 100285, 100281, 102624, 102770, 102771, 102757, 102627, 102773, 102774, 
102760, 102612, 102625, 102772, 102759
36834, 100237, 100241, 100285, 100281, 32288, 32289, 32300, 32299, 102627, 102773, 102774, 102760, 32702, 32724, 32725, 
32722, 102615, 102628, 102775, 102762
36835, 14054, 14055, 14066, 14065, 100238, 100242, 100286, 100282, 14469, 14491, 14492, 14489, 102631, 102777, 102778, 
102764, 102616, 102629, 102776, 102763
36836, 100238, 100242, 100286, 100282, 100239, 100243, 100287, 100283, 102631, 102777, 102778, 102764, 102634, 102780, 102781, 
102767, 102619, 102632, 102779, 102766
36837, 100239, 100243, 100287, 100283, 100240, 100244, 100288, 100284, 102634, 102780, 102781, 102767, 102637, 102783, 102784, 
102770, 102622, 102635, 102782, 102769
36838, 100240, 100244, 100288, 100284, 100241, 100245, 100289, 100285, 102637, 102783, 102784, 102770, 102640, 102786, 102787, 
102773, 102625, 102638, 102785, 102772
36839, 100241, 100245, 100289, 100285, 32289, 32290, 32301, 32300, 102640, 102786, 102787, 102773, 32704, 32726, 32727, 
32724, 102628, 102641, 102788, 102775
36840, 14055, 14056, 14067, 14066, 100242, 100246, 100290, 100286, 14471, 14493, 14494, 14491, 102644, 102790, 102791, 
102777, 102629, 102642, 102789, 102776
36841, 100242, 100246, 100290, 100286, 100243, 100247, 100291, 100287, 102644, 102790, 102791, 102777, 102647, 102793, 102794, 
102780, 102632, 102645, 102792, 102779
36842, 100243, 100247, 100291, 100287, 100244, 100248, 100292, 100288, 102647, 102793, 102794, 102780, 102650, 102796, 102797, 
102783, 102635, 102648, 102795, 102782
36843, 100244, 100248, 100292, 100288, 100245, 100249, 100293, 100289, 102650, 102796, 102797, 102783, 102653, 102799, 102800, 
102786, 102638, 102651, 102798, 102785
36844, 100245, 100249, 100293, 100289, 32290, 32291, 32302, 32301, 102653, 102799, 102800, 102786, 32706, 32728, 32729, 
32726, 102641, 102654, 102801, 102788
36845, 14056, 14057, 14068, 14067, 100246, 100250, 100294, 100290, 14473, 14495, 14496, 14493, 102657, 102803, 102804, 
102790, 102642, 102655, 102802, 102789
36846, 100246, 100250, 100294, 100290, 100247, 100251, 100295, 100291, 102657, 102803, 102804, 102790, 102660, 102806, 102807, 
102793, 102645, 102658, 102805, 102792
36847, 100247, 100251, 100295, 100291, 100248, 100252, 100296, 100292, 102660, 102806, 102807, 102793, 102663, 102809, 102810, 
102796, 102648, 102661, 102808, 102795
36848, 100248, 100252, 100296, 100292, 100249, 100253, 100297, 100293, 102663, 102809, 102810, 102796, 102666, 102812, 102813, 
102799, 102651, 102664, 102811, 102798
36849, 100249, 100253, 100297, 100293, 32291, 32292, 32303, 32302, 102666, 102812, 102813, 102799, 32708, 32730, 32731, 
32728, 102654, 102667, 102814, 102801
36850, 14057, 14058, 14069, 14068, 100250, 100254, 100298, 100294, 14475, 14497, 14498, 14495, 102670, 102816, 102817, 
102803, 102655, 102668, 102815, 102802
36851, 100250, 100254, 100298, 100294, 100251, 100255, 100299, 100295, 102670, 102816, 102817, 102803, 102673, 102819, 102820, 
102806, 102658, 102671, 102818, 102805
36852, 100251, 100255, 100299, 100295, 100252, 100256, 100300, 100296, 102673, 102819, 102820, 102806, 102676, 102822, 102823, 
102809, 102661, 102674, 102821, 102808
36853, 100252, 100256, 100300, 100296, 100253, 100257, 100301, 100297, 102676, 102822, 102823, 102809, 102679, 102825, 102826, 
102812, 102664, 102677, 102824, 102811
36854, 100253, 100257, 100301, 100297, 32292, 32293, 32304, 32303, 102679, 102825, 102826, 102812, 32710, 32732, 32733, 
32730, 102667, 102680, 102827, 102814
36855, 14058, 14059, 14070, 14069, 100254, 100258, 100302, 100298, 14477, 14499, 14500, 14497, 102683, 102829, 102830, 
102816, 102668, 102681, 102828, 102815
36856, 100254, 100258, 100302, 100298, 100255, 100259, 100303, 100299, 102683, 102829, 102830, 102816, 102686, 102832, 102833, 
102819, 102671, 102684, 102831, 102818
36857, 100255, 100259, 100303, 100299, 100256, 100260, 100304, 100300, 102686, 102832, 102833, 102819, 102689, 102835, 102836, 
102822, 102674, 102687, 102834, 102821
36858, 100256, 100260, 100304, 100300, 100257, 100261, 100305, 100301, 102689, 102835, 102836, 102822, 102692, 102838, 102839, 
102825, 102677, 102690, 102837, 102824
36859, 100257, 100261, 100305, 100301, 32293, 32294, 32305, 32304, 102692, 102838, 102839, 102825, 32712, 32734, 32735, 
32732, 102680, 102693, 102840, 102827
36860, 14059, 14060, 14071, 14070, 100258, 100262, 100306, 100302, 14479, 14501, 14502, 14499, 102696, 102842, 102843, 
102829, 102681, 102694, 102841, 102828
36861, 100258, 100262, 100306, 100302, 100259, 100263, 100307, 100303, 102696, 102842, 102843, 102829, 102699, 102845, 102846, 
102832, 102684, 102697, 102844, 102831
36862, 100259, 100263, 100307, 100303, 100260, 100264, 100308, 100304, 102699, 102845, 102846, 102832, 102702, 102848, 102849, 
102835, 102687, 102700, 102847, 102834
36863, 100260, 100264, 100308, 100304, 100261, 100265, 100309, 100305, 102702, 102848, 102849, 102835, 102705, 102851, 102852, 
102838, 102690, 102703, 102850, 102837
36864, 100261, 100265, 100309, 100305, 32294, 32295, 32306, 32305, 102705, 102851, 102852, 102838, 32714, 32736, 32737, 
32734, 102693, 102706, 102853, 102840
36865, 14060, 14061, 14072, 14071, 100262, 100266, 100310, 100306, 14481, 14503, 14504, 14501, 102709, 102855, 102856, 
102842, 102694, 102707, 102854, 102841
36866, 100262, 100266, 100310, 100306, 100263, 100267, 100311, 100307, 102709, 102855, 102856, 102842, 102712, 102858, 102859, 
102845, 102697, 102710, 102857, 102844
36867, 100263, 100267, 100311, 100307, 100264, 100268, 100312, 100308, 102712, 102858, 102859, 102845, 102715, 102861, 102862, 
102848, 102700, 102713, 102860, 102847
36868, 100264, 100268, 100312, 100308, 100265, 100269, 100313, 100309, 102715, 102861, 102862, 102848, 102718, 102864, 102865, 
102851, 102703, 102716, 102863, 102850
36869, 100265, 100269, 100313, 100309, 32295, 32296, 32307, 32306, 102718, 102864, 102865, 102851, 32716, 32738, 32739, 
32736, 102706, 102719, 102866, 102853
36870, 14061, 1116, 1117, 14072, 100266, 31745, 31749, 100310, 14482, 1140, 14505, 14503, 102720, 31912, 102867, 
102855, 102707, 31902, 31911, 102854
36871, 100266, 31745, 31749, 100310, 100267, 31746, 31750, 100311, 102720, 31912, 102867, 102855, 102721, 31914, 102868, 
102858, 102710, 31904, 31913, 102857
36872, 100267, 31746, 31750, 100311, 100268, 31747, 31751, 100312, 102721, 31914, 102868, 102858, 102722, 31916, 102869, 
102861, 102713, 31906, 31915, 102860
36873, 100268, 31747, 31751, 100312, 100269, 31748, 31752, 100313, 102722, 31916, 102869, 102861, 102723, 31918, 102870, 
102864, 102716, 31908, 31917, 102863
36874, 100269, 31748, 31752, 100313, 32296, 3298, 3299, 32307, 102723, 31918, 102870, 102864, 32717, 3322, 32740, 
32738, 102719, 31910, 31919, 102866
36875, 1037, 14062, 14073, 1038, 31299, 100270, 100314, 31303, 14484, 14506, 14507, 1061, 102726, 102872, 102873, 
31470, 31462, 102724, 102871, 31471
36876, 31299, 100270, 100314, 31303, 31300, 100271, 100315, 31304, 102726, 102872, 102873, 31470, 102729, 102875, 102876, 
31472, 31464, 102727, 102874, 31473
36877, 31300, 100271, 100315, 31304, 31301, 100272, 100316, 31305, 102729, 102875, 102876, 31472, 102732, 102878, 102879, 
31474, 31466, 102730, 102877, 31475
36878, 31301, 100272, 100316, 31305, 31302, 100273, 100317, 31306, 102732, 102878, 102879, 31474, 102735, 102881, 102882, 
31476, 31468, 102733, 102880, 31477
36879, 31302, 100273, 100317, 31306, 3211, 32297, 32308, 3212, 102735, 102881, 102882, 31476, 32719, 32741, 32742, 
3235, 31469, 102736, 102883, 31478
36880, 14062, 14063, 14074, 14073, 100270, 100274, 100318, 100314, 14486, 14508, 14509, 14506, 102739, 102885, 102886, 
102872, 102724, 102737, 102884, 102871
36881, 100270, 100274, 100318, 100314, 100271, 100275, 100319, 100315, 102739, 102885, 102886, 102872, 102742, 102888, 102889, 
102875, 102727, 102740, 102887, 102874
36882, 100271, 100275, 100319, 100315, 100272, 100276, 100320, 100316, 102742, 102888, 102889, 102875, 102745, 102891, 102892, 
102878, 102730, 102743, 102890, 102877
36883, 100272, 100276, 100320, 100316, 100273, 100277, 100321, 100317, 102745, 102891, 102892, 102878, 102748, 102894, 102895, 
102881, 102733, 102746, 102893, 102880
36884, 100273, 100277, 100321, 100317, 32297, 32298, 32309, 32308, 102748, 102894, 102895, 102881, 32721, 32743, 32744, 
32741, 102736, 102749, 102896, 102883
36885, 14063, 14064, 14075, 14074, 100274, 100278, 100322, 100318, 14488, 14510, 14511, 14508, 102752, 102898, 102899, 
102885, 102737, 102750, 102897, 102884
36886, 100274, 100278, 100322, 100318, 100275, 100279, 100323, 100319, 102752, 102898, 102899, 102885, 102755, 102901, 102902, 
102888, 102740, 102753, 102900, 102887
36887, 100275, 100279, 100323, 100319, 100276, 100280, 100324, 100320, 102755, 102901, 102902, 102888, 102758, 102904, 102905, 
102891, 102743, 102756, 102903, 102890
36888, 100276, 100280, 100324, 100320, 100277, 100281, 100325, 100321, 102758, 102904, 102905, 102891, 102761, 102907, 102908, 
102894, 102746, 102759, 102906, 102893
36889, 100277, 100281, 100325, 100321, 32298, 32299, 32310, 32309, 102761, 102907, 102908, 102894, 32723, 32745, 32746, 
32743, 102749, 102762, 102909, 102896
36890, 14064, 14065, 14076, 14075, 100278, 100282, 100326, 100322, 14490, 14512, 14513, 14510, 102765, 102911, 102912, 
102898, 102750, 102763, 102910, 102897
36891, 100278, 100282, 100326, 100322, 100279, 100283, 100327, 100323, 102765, 102911, 102912, 102898, 102768, 102914, 102915, 
102901, 102753, 102766, 102913, 102900
36892, 100279, 100283, 100327, 100323, 100280, 100284, 100328, 100324, 102768, 102914, 102915, 102901, 102771, 102917, 102918, 
102904, 102756, 102769, 102916, 102903
36893, 100280, 100284, 100328, 100324, 100281, 100285, 100329, 100325, 102771, 102917, 102918, 102904, 102774, 102920, 102921, 
102907, 102759, 102772, 102919, 102906
36894, 100281, 100285, 100329, 100325, 32299, 32300, 32311, 32310, 102774, 102920, 102921, 102907, 32725, 32747, 32748, 
32745, 102762, 102775, 102922, 102909
36895, 14065, 14066, 14077, 14076, 100282, 100286, 100330, 100326, 14492, 14514, 14515, 14512, 102778, 102924, 102925, 
102911, 102763, 102776, 102923, 102910
36896, 100282, 100286, 100330, 100326, 100283, 100287, 100331, 100327, 102778, 102924, 102925, 102911, 102781, 102927, 102928, 
102914, 102766, 102779, 102926, 102913
36897, 100283, 100287, 100331, 100327, 100284, 100288, 100332, 100328, 102781, 102927, 102928, 102914, 102784, 102930, 102931, 
102917, 102769, 102782, 102929, 102916
36898, 100284, 100288, 100332, 100328, 100285, 100289, 100333, 100329, 102784, 102930, 102931, 102917, 102787, 102933, 102934, 
102920, 102772, 102785, 102932, 102919
36899, 100285, 100289, 100333, 100329, 32300, 32301, 32312, 32311, 102787, 102933, 102934, 102920, 32727, 32749, 32750, 
32747, 102775, 102788, 102935, 102922
36900, 14066, 14067, 14078, 14077, 100286, 100290, 100334, 100330, 14494, 14516, 14517, 14514, 102791, 102937, 102938, 
102924, 102776, 102789, 102936, 102923
36901, 100286, 100290, 100334, 100330, 100287, 100291, 100335, 100331, 102791, 102937, 102938, 102924, 102794, 102940, 102941, 
102927, 102779, 102792, 102939, 102926
36902, 100287, 100291, 100335, 100331, 100288, 100292, 100336, 100332, 102794, 102940, 102941, 102927, 102797, 102943, 102944, 
102930, 102782, 102795, 102942, 102929
36903, 100288, 100292, 100336, 100332, 100289, 100293, 100337, 100333, 102797, 102943, 102944, 102930, 102800, 102946, 102947, 
102933, 102785, 102798, 102945, 102932
36904, 100289, 100293, 100337, 100333, 32301, 32302, 32313, 32312, 102800, 102946, 102947, 102933, 32729, 32751, 32752, 
32749, 102788, 102801, 102948, 102935
36905, 14067, 14068, 14079, 14078, 100290, 100294, 100338, 100334, 14496, 14518, 14519, 14516, 102804, 102950, 102951, 
102937, 102789, 102802, 102949, 102936
36906, 100290, 100294, 100338, 100334, 100291, 100295, 100339, 100335, 102804, 102950, 102951, 102937, 102807, 102953, 102954, 
102940, 102792, 102805, 102952, 102939
36907, 100291, 100295, 100339, 100335, 100292, 100296, 100340, 100336, 102807, 102953, 102954, 102940, 102810, 102956, 102957, 
102943, 102795, 102808, 102955, 102942
36908, 100292, 100296, 100340, 100336, 100293, 100297, 100341, 100337, 102810, 102956, 102957, 102943, 102813, 102959, 102960, 
102946, 102798, 102811, 102958, 102945
36909, 100293, 100297, 100341, 100337, 32302, 32303, 32314, 32313, 102813, 102959, 102960, 102946, 32731, 32753, 32754, 
32751, 102801, 102814, 102961, 102948
36910, 14068, 14069, 14080, 14079, 100294, 100298, 100342, 100338, 14498, 14520, 14521, 14518, 102817, 102963, 102964, 
102950, 102802, 102815, 102962, 102949
36911, 100294, 100298, 100342, 100338, 100295, 100299, 100343, 100339, 102817, 102963, 102964, 102950, 102820, 102966, 102967, 
102953, 102805, 102818, 102965, 102952
36912, 100295, 100299, 100343, 100339, 100296, 100300, 100344, 100340, 102820, 102966, 102967, 102953, 102823, 102969, 102970, 
102956, 102808, 102821, 102968, 102955
36913, 100296, 100300, 100344, 100340, 100297, 100301, 100345, 100341, 102823, 102969, 102970, 102956, 102826, 102972, 102973, 
102959, 102811, 102824, 102971, 102958
36914, 100297, 100301, 100345, 100341, 32303, 32304, 32315, 32314, 102826, 102972, 102973, 102959, 32733, 32755, 32756, 
32753, 102814, 102827, 102974, 102961
36915, 14069, 14070, 14081, 14080, 100298, 100302, 100346, 100342, 14500, 14522, 14523, 14520, 102830, 102976, 102977, 
102963, 102815, 102828, 102975, 102962
36916, 100298, 100302, 100346, 100342, 100299, 100303, 100347, 100343, 102830, 102976, 102977, 102963, 102833, 102979, 102980, 
102966, 102818, 102831, 102978, 102965
36917, 100299, 100303, 100347, 100343, 100300, 100304, 100348, 100344, 102833, 102979, 102980, 102966, 102836, 102982, 102983, 
102969, 102821, 102834, 102981, 102968
36918, 100300, 100304, 100348, 100344, 100301, 100305, 100349, 100345, 102836, 102982, 102983, 102969, 102839, 102985, 102986, 
102972, 102824, 102837, 102984, 102971
36919, 100301, 100305, 100349, 100345, 32304, 32305, 32316, 32315, 102839, 102985, 102986, 102972, 32735, 32757, 32758, 
32755, 102827, 102840, 102987, 102974
36920, 14070, 14071, 14082, 14081, 100302, 100306, 100350, 100346, 14502, 14524, 14525, 14522, 102843, 102989, 102990, 
102976, 102828, 102841, 102988, 102975
36921, 100302, 100306, 100350, 100346, 100303, 100307, 100351, 100347, 102843, 102989, 102990, 102976, 102846, 102992, 102993, 
102979, 102831, 102844, 102991, 102978
36922, 100303, 100307, 100351, 100347, 100304, 100308, 100352, 100348, 102846, 102992, 102993, 102979, 102849, 102995, 102996, 
102982, 102834, 102847, 102994, 102981
36923, 100304, 100308, 100352, 100348, 100305, 100309, 100353, 100349, 102849, 102995, 102996, 102982, 102852, 102998, 102999, 
102985, 102837, 102850, 102997, 102984
36924, 100305, 100309, 100353, 100349, 32305, 32306, 32317, 32316, 102852, 102998, 102999, 102985, 32737, 32759, 32760, 
32757, 102840, 102853, 103000, 102987
36925, 14071, 14072, 14083, 14082, 100306, 100310, 100354, 100350, 14504, 14526, 14527, 14524, 102856, 103002, 103003, 
102989, 102841, 102854, 103001, 102988
36926, 100306, 100310, 100354, 100350, 100307, 100311, 100355, 100351, 102856, 103002, 103003, 102989, 102859, 103005, 103006, 
102992, 102844, 102857, 103004, 102991
36927, 100307, 100311, 100355, 100351, 100308, 100312, 100356, 100352, 102859, 103005, 103006, 102992, 102862, 103008, 103009, 
102995, 102847, 102860, 103007, 102994
36928, 100308, 100312, 100356, 100352, 100309, 100313, 100357, 100353, 102862, 103008, 103009, 102995, 102865, 103011, 103012, 
102998, 102850, 102863, 103010, 102997
36929, 100309, 100313, 100357, 100353, 32306, 32307, 32318, 32317, 102865, 103011, 103012, 102998, 32739, 32761, 32762, 
32759, 102853, 102866, 103013, 103000
36930, 14072, 1117, 1118, 14083, 100310, 31749, 31753, 100354, 14505, 1141, 14528, 14526, 102867, 31921, 103014, 
103002, 102854, 31911, 31920, 103001
36931, 100310, 31749, 31753, 100354, 100311, 31750, 31754, 100355, 102867, 31921, 103014, 103002, 102868, 31923, 103015, 
103005, 102857, 31913, 31922, 103004
36932, 100311, 31750, 31754, 100355, 100312, 31751, 31755, 100356, 102868, 31923, 103015, 103005, 102869, 31925, 103016, 
103008, 102860, 31915, 31924, 103007
36933, 100312, 31751, 31755, 100356, 100313, 31752, 31756, 100357, 102869, 31925, 103016, 103008, 102870, 31927, 103017, 
103011, 102863, 31917, 31926, 103010
36934, 100313, 31752, 31756, 100357, 32307, 3299, 3300, 32318, 102870, 31927, 103017, 103011, 32740, 3323, 32763, 
32761, 102866, 31919, 31928, 103013
36935, 1038, 14073, 14084, 1039, 31303, 100314, 100358, 31307, 14507, 14529, 14530, 1062, 102873, 103019, 103020, 
31479, 31471, 102871, 103018, 31480
36936, 31303, 100314, 100358, 31307, 31304, 100315, 100359, 31308, 102873, 103019, 103020, 31479, 102876, 103022, 103023, 
31481, 31473, 102874, 103021, 31482
36937, 31304, 100315, 100359, 31308, 31305, 100316, 100360, 31309, 102876, 103022, 103023, 31481, 102879, 103025, 103026, 
31483, 31475, 102877, 103024, 31484
36938, 31305, 100316, 100360, 31309, 31306, 100317, 100361, 31310, 102879, 103025, 103026, 31483, 102882, 103028, 103029, 
31485, 31477, 102880, 103027, 31486
36939, 31306, 100317, 100361, 31310, 3212, 32308, 32319, 3213, 102882, 103028, 103029, 31485, 32742, 32764, 32765, 
3236, 31478, 102883, 103030, 31487
36940, 14073, 14074, 14085, 14084, 100314, 100318, 100362, 100358, 14509, 14531, 14532, 14529, 102886, 103032, 103033, 
103019, 102871, 102884, 103031, 103018
36941, 100314, 100318, 100362, 100358, 100315, 100319, 100363, 100359, 102886, 103032, 103033, 103019, 102889, 103035, 103036, 
103022, 102874, 102887, 103034, 103021
36942, 100315, 100319, 100363, 100359, 100316, 100320, 100364, 100360, 102889, 103035, 103036, 103022, 102892, 103038, 103039, 
103025, 102877, 102890, 103037, 103024
36943, 100316, 100320, 100364, 100360, 100317, 100321, 100365, 100361, 102892, 103038, 103039, 103025, 102895, 103041, 103042, 
103028, 102880, 102893, 103040, 103027
36944, 100317, 100321, 100365, 100361, 32308, 32309, 32320, 32319, 102895, 103041, 103042, 103028, 32744, 32766, 32767, 
32764, 102883, 102896, 103043, 103030
36945, 14074, 14075, 14086, 14085, 100318, 100322, 100366, 100362, 14511, 14533, 14534, 14531, 102899, 103045, 103046, 
103032, 102884, 102897, 103044, 103031
36946, 100318, 100322, 100366, 100362, 100319, 100323, 100367, 100363, 102899, 103045, 103046, 103032, 102902, 103048, 103049, 
103035, 102887, 102900, 103047, 103034
36947, 100319, 100323, 100367, 100363, 100320, 100324, 100368, 100364, 102902, 103048, 103049, 103035, 102905, 103051, 103052, 
103038, 102890, 102903, 103050, 103037
36948, 100320, 100324, 100368, 100364, 100321, 100325, 100369, 100365, 102905, 103051, 103052, 103038, 102908, 103054, 103055, 
103041, 102893, 102906, 103053, 103040
36949, 100321, 100325, 100369, 100365, 32309, 32310, 32321, 32320, 102908, 103054, 103055, 103041, 32746, 32768, 32769, 
32766, 102896, 102909, 103056, 103043
36950, 14075, 14076, 14087, 14086, 100322, 100326, 100370, 100366, 14513, 14535, 14536, 14533, 102912, 103058, 103059, 
103045, 102897, 102910, 103057, 103044
36951, 100322, 100326, 100370, 100366, 100323, 100327, 100371, 100367, 102912, 103058, 103059, 103045, 102915, 103061, 103062, 
103048, 102900, 102913, 103060, 103047
36952, 100323, 100327, 100371, 100367, 100324, 100328, 100372, 100368, 102915, 103061, 103062, 103048, 102918, 103064, 103065, 
103051, 102903, 102916, 103063, 103050
36953, 100324, 100328, 100372, 100368, 100325, 100329, 100373, 100369, 102918, 103064, 103065, 103051, 102921, 103067, 103068, 
103054, 102906, 102919, 103066, 103053
36954, 100325, 100329, 100373, 100369, 32310, 32311, 32322, 32321, 102921, 103067, 103068, 103054, 32748, 32770, 32771, 
32768, 102909, 102922, 103069, 103056
36955, 14076, 14077, 14088, 14087, 100326, 100330, 100374, 100370, 14515, 14537, 14538, 14535, 102925, 103071, 103072, 
103058, 102910, 102923, 103070, 103057
36956, 100326, 100330, 100374, 100370, 100327, 100331, 100375, 100371, 102925, 103071, 103072, 103058, 102928, 103074, 103075, 
103061, 102913, 102926, 103073, 103060
36957, 100327, 100331, 100375, 100371, 100328, 100332, 100376, 100372, 102928, 103074, 103075, 103061, 102931, 103077, 103078, 
103064, 102916, 102929, 103076, 103063
36958, 100328, 100332, 100376, 100372, 100329, 100333, 100377, 100373, 102931, 103077, 103078, 103064, 102934, 103080, 103081, 
103067, 102919, 102932, 103079, 103066
36959, 100329, 100333, 100377, 100373, 32311, 32312, 32323, 32322, 102934, 103080, 103081, 103067, 32750, 32772, 32773, 
32770, 102922, 102935, 103082, 103069
36960, 14077, 14078, 14089, 14088, 100330, 100334, 100378, 100374, 14517, 14539, 14540, 14537, 102938, 103084, 103085, 
103071, 102923, 102936, 103083, 103070
36961, 100330, 100334, 100378, 100374, 100331, 100335, 100379, 100375, 102938, 103084, 103085, 103071, 102941, 103087, 103088, 
103074, 102926, 102939, 103086, 103073
36962, 100331, 100335, 100379, 100375, 100332, 100336, 100380, 100376, 102941, 103087, 103088, 103074, 102944, 103090, 103091, 
103077, 102929, 102942, 103089, 103076
36963, 100332, 100336, 100380, 100376, 100333, 100337, 100381, 100377, 102944, 103090, 103091, 103077, 102947, 103093, 103094, 
103080, 102932, 102945, 103092, 103079
36964, 100333, 100337, 100381, 100377, 32312, 32313, 32324, 32323, 102947, 103093, 103094, 103080, 32752, 32774, 32775, 
32772, 102935, 102948, 103095, 103082
36965, 14078, 14079, 14090, 14089, 100334, 100338, 100382, 100378, 14519, 14541, 14542, 14539, 102951, 103097, 103098, 
103084, 102936, 102949, 103096, 103083
36966, 100334, 100338, 100382, 100378, 100335, 100339, 100383, 100379, 102951, 103097, 103098, 103084, 102954, 103100, 103101, 
103087, 102939, 102952, 103099, 103086
36967, 100335, 100339, 100383, 100379, 100336, 100340, 100384, 100380, 102954, 103100, 103101, 103087, 102957, 103103, 103104, 
103090, 102942, 102955, 103102, 103089
36968, 100336, 100340, 100384, 100380, 100337, 100341, 100385, 100381, 102957, 103103, 103104, 103090, 102960, 103106, 103107, 
103093, 102945, 102958, 103105, 103092
36969, 100337, 100341, 100385, 100381, 32313, 32314, 32325, 32324, 102960, 103106, 103107, 103093, 32754, 32776, 32777, 
32774, 102948, 102961, 103108, 103095
36970, 14079, 14080, 14091, 14090, 100338, 100342, 100386, 100382, 14521, 14543, 14544, 14541, 102964, 103110, 103111, 
103097, 102949, 102962, 103109, 103096
36971, 100338, 100342, 100386, 100382, 100339, 100343, 100387, 100383, 102964, 103110, 103111, 103097, 102967, 103113, 103114, 
103100, 102952, 102965, 103112, 103099
36972, 100339, 100343, 100387, 100383, 100340, 100344, 100388, 100384, 102967, 103113, 103114, 103100, 102970, 103116, 103117, 
103103, 102955, 102968, 103115, 103102
36973, 100340, 100344, 100388, 100384, 100341, 100345, 100389, 100385, 102970, 103116, 103117, 103103, 102973, 103119, 103120, 
103106, 102958, 102971, 103118, 103105
36974, 100341, 100345, 100389, 100385, 32314, 32315, 32326, 32325, 102973, 103119, 103120, 103106, 32756, 32778, 32779, 
32776, 102961, 102974, 103121, 103108
36975, 14080, 14081, 14092, 14091, 100342, 100346, 100390, 100386, 14523, 14545, 14546, 14543, 102977, 103123, 103124, 
103110, 102962, 102975, 103122, 103109
36976, 100342, 100346, 100390, 100386, 100343, 100347, 100391, 100387, 102977, 103123, 103124, 103110, 102980, 103126, 103127, 
103113, 102965, 102978, 103125, 103112
36977, 100343, 100347, 100391, 100387, 100344, 100348, 100392, 100388, 102980, 103126, 103127, 103113, 102983, 103129, 103130, 
103116, 102968, 102981, 103128, 103115
36978, 100344, 100348, 100392, 100388, 100345, 100349, 100393, 100389, 102983, 103129, 103130, 103116, 102986, 103132, 103133, 
103119, 102971, 102984, 103131, 103118
36979, 100345, 100349, 100393, 100389, 32315, 32316, 32327, 32326, 102986, 103132, 103133, 103119, 32758, 32780, 32781, 
32778, 102974, 102987, 103134, 103121
36980, 14081, 14082, 14093, 14092, 100346, 100350, 100394, 100390, 14525, 14547, 14548, 14545, 102990, 103136, 103137, 
103123, 102975, 102988, 103135, 103122
36981, 100346, 100350, 100394, 100390, 100347, 100351, 100395, 100391, 102990, 103136, 103137, 103123, 102993, 103139, 103140, 
103126, 102978, 102991, 103138, 103125
36982, 100347, 100351, 100395, 100391, 100348, 100352, 100396, 100392, 102993, 103139, 103140, 103126, 102996, 103142, 103143, 
103129, 102981, 102994, 103141, 103128
36983, 100348, 100352, 100396, 100392, 100349, 100353, 100397, 100393, 102996, 103142, 103143, 103129, 102999, 103145, 103146, 
103132, 102984, 102997, 103144, 103131
36984, 100349, 100353, 100397, 100393, 32316, 32317, 32328, 32327, 102999, 103145, 103146, 103132, 32760, 32782, 32783, 
32780, 102987, 103000, 103147, 103134
36985, 14082, 14083, 14094, 14093, 100350, 100354, 100398, 100394, 14527, 14549, 14550, 14547, 103003, 103149, 103150, 
103136, 102988, 103001, 103148, 103135
36986, 100350, 100354, 100398, 100394, 100351, 100355, 100399, 100395, 103003, 103149, 103150, 103136, 103006, 103152, 103153, 
103139, 102991, 103004, 103151, 103138
36987, 100351, 100355, 100399, 100395, 100352, 100356, 100400, 100396, 103006, 103152, 103153, 103139, 103009, 103155, 103156, 
103142, 102994, 103007, 103154, 103141
36988, 100352, 100356, 100400, 100396, 100353, 100357, 100401, 100397, 103009, 103155, 103156, 103142, 103012, 103158, 103159, 
103145, 102997, 103010, 103157, 103144
36989, 100353, 100357, 100401, 100397, 32317, 32318, 32329, 32328, 103012, 103158, 103159, 103145, 32762, 32784, 32785, 
32782, 103000, 103013, 103160, 103147
36990, 14083, 1118, 1119, 14094, 100354, 31753, 31757, 100398, 14528, 1142, 14551, 14549, 103014, 31930, 103161, 
103149, 103001, 31920, 31929, 103148
36991, 100354, 31753, 31757, 100398, 100355, 31754, 31758, 100399, 103014, 31930, 103161, 103149, 103015, 31932, 103162, 
103152, 103004, 31922, 31931, 103151
36992, 100355, 31754, 31758, 100399, 100356, 31755, 31759, 100400, 103015, 31932, 103162, 103152, 103016, 31934, 103163, 
103155, 103007, 31924, 31933, 103154
36993, 100356, 31755, 31759, 100400, 100357, 31756, 31760, 100401, 103016, 31934, 103163, 103155, 103017, 31936, 103164, 
103158, 103010, 31926, 31935, 103157
36994, 100357, 31756, 31760, 100401, 32318, 3300, 3301, 32329, 103017, 31936, 103164, 103158, 32763, 3324, 32786, 
32784, 103013, 31928, 31937, 103160
36995, 1039, 14084, 14095, 1040, 31307, 100358, 100402, 31311, 14530, 14552, 14553, 1063, 103020, 103166, 103167, 
31488, 31480, 103018, 103165, 31489
36996, 31307, 100358, 100402, 31311, 31308, 100359, 100403, 31312, 103020, 103166, 103167, 31488, 103023, 103169, 103170, 
31490, 31482, 103021, 103168, 31491
36997, 31308, 100359, 100403, 31312, 31309, 100360, 100404, 31313, 103023, 103169, 103170, 31490, 103026, 103172, 103173, 
31492, 31484, 103024, 103171, 31493
36998, 31309, 100360, 100404, 31313, 31310, 100361, 100405, 31314, 103026, 103172, 103173, 31492, 103029, 103175, 103176, 
31494, 31486, 103027, 103174, 31495
36999, 31310, 100361, 100405, 31314, 3213, 32319, 32330, 3214, 103029, 103175, 103176, 31494, 32765, 32787, 32788, 
3237, 31487, 103030, 103177, 31496
37000, 14084, 14085, 14096, 14095, 100358, 100362, 100406, 100402, 14532, 14554, 14555, 14552, 103033, 103179, 103180, 
103166, 103018, 103031, 103178, 103165
37001, 100358, 100362, 100406, 100402, 100359, 100363, 100407, 100403, 103033, 103179, 103180, 103166, 103036, 103182, 103183, 
103169, 103021, 103034, 103181, 103168
37002, 100359, 100363, 100407, 100403, 100360, 100364, 100408, 100404, 103036, 103182, 103183, 103169, 103039, 103185, 103186, 
103172, 103024, 103037, 103184, 103171
37003, 100360, 100364, 100408, 100404, 100361, 100365, 100409, 100405, 103039, 103185, 103186, 103172, 103042, 103188, 103189, 
103175, 103027, 103040, 103187, 103174
37004, 100361, 100365, 100409, 100405, 32319, 32320, 32331, 32330, 103042, 103188, 103189, 103175, 32767, 32789, 32790, 
32787, 103030, 103043, 103190, 103177
37005, 14085, 14086, 14097, 14096, 100362, 100366, 100410, 100406, 14534, 14556, 14557, 14554, 103046, 103192, 103193, 
103179, 103031, 103044, 103191, 103178
37006, 100362, 100366, 100410, 100406, 100363, 100367, 100411, 100407, 103046, 103192, 103193, 103179, 103049, 103195, 103196, 
103182, 103034, 103047, 103194, 103181
37007, 100363, 100367, 100411, 100407, 100364, 100368, 100412, 100408, 103049, 103195, 103196, 103182, 103052, 103198, 103199, 
103185, 103037, 103050, 103197, 103184
37008, 100364, 100368, 100412, 100408, 100365, 100369, 100413, 100409, 103052, 103198, 103199, 103185, 103055, 103201, 103202, 
103188, 103040, 103053, 103200, 103187
37009, 100365, 100369, 100413, 100409, 32320, 32321, 32332, 32331, 103055, 103201, 103202, 103188, 32769, 32791, 32792, 
32789, 103043, 103056, 103203, 103190
37010, 14086, 14087, 14098, 14097, 100366, 100370, 100414, 100410, 14536, 14558, 14559, 14556, 103059, 103205, 103206, 
103192, 103044, 103057, 103204, 103191
37011, 100366, 100370, 100414, 100410, 100367, 100371, 100415, 100411, 103059, 103205, 103206, 103192, 103062, 103208, 103209, 
103195, 103047, 103060, 103207, 103194
37012, 100367, 100371, 100415, 100411, 100368, 100372, 100416, 100412, 103062, 103208, 103209, 103195, 103065, 103211, 103212, 
103198, 103050, 103063, 103210, 103197
37013, 100368, 100372, 100416, 100412, 100369, 100373, 100417, 100413, 103065, 103211, 103212, 103198, 103068, 103214, 103215, 
103201, 103053, 103066, 103213, 103200
37014, 100369, 100373, 100417, 100413, 32321, 32322, 32333, 32332, 103068, 103214, 103215, 103201, 32771, 32793, 32794, 
32791, 103056, 103069, 103216, 103203
37015, 14087, 14088, 14099, 14098, 100370, 100374, 100418, 100414, 14538, 14560, 14561, 14558, 103072, 103218, 103219, 
103205, 103057, 103070, 103217, 103204
37016, 100370, 100374, 100418, 100414, 100371, 100375, 100419, 100415, 103072, 103218, 103219, 103205, 103075, 103221, 103222, 
103208, 103060, 103073, 103220, 103207
37017, 100371, 100375, 100419, 100415, 100372, 100376, 100420, 100416, 103075, 103221, 103222, 103208, 103078, 103224, 103225, 
103211, 103063, 103076, 103223, 103210
37018, 100372, 100376, 100420, 100416, 100373, 100377, 100421, 100417, 103078, 103224, 103225, 103211, 103081, 103227, 103228, 
103214, 103066, 103079, 103226, 103213
37019, 100373, 100377, 100421, 100417, 32322, 32323, 32334, 32333, 103081, 103227, 103228, 103214, 32773, 32795, 32796, 
32793, 103069, 103082, 103229, 103216
37020, 14088, 14089, 14100, 14099, 100374, 100378, 100422, 100418, 14540, 14562, 14563, 14560, 103085, 103231, 103232, 
103218, 103070, 103083, 103230, 103217
37021, 100374, 100378, 100422, 100418, 100375, 100379, 100423, 100419, 103085, 103231, 103232, 103218, 103088, 103234, 103235, 
103221, 103073, 103086, 103233, 103220
37022, 100375, 100379, 100423, 100419, 100376, 100380, 100424, 100420, 103088, 103234, 103235, 103221, 103091, 103237, 103238, 
103224, 103076, 103089, 103236, 103223
37023, 100376, 100380, 100424, 100420, 100377, 100381, 100425, 100421, 103091, 103237, 103238, 103224, 103094, 103240, 103241, 
103227, 103079, 103092, 103239, 103226
37024, 100377, 100381, 100425, 100421, 32323, 32324, 32335, 32334, 103094, 103240, 103241, 103227, 32775, 32797, 32798, 
32795, 103082, 103095, 103242, 103229
37025, 14089, 14090, 14101, 14100, 100378, 100382, 100426, 100422, 14542, 14564, 14565, 14562, 103098, 103244, 103245, 
103231, 103083, 103096, 103243, 103230
37026, 100378, 100382, 100426, 100422, 100379, 100383, 100427, 100423, 103098, 103244, 103245, 103231, 103101, 103247, 103248, 
103234, 103086, 103099, 103246, 103233
37027, 100379, 100383, 100427, 100423, 100380, 100384, 100428, 100424, 103101, 103247, 103248, 103234, 103104, 103250, 103251, 
103237, 103089, 103102, 103249, 103236
37028, 100380, 100384, 100428, 100424, 100381, 100385, 100429, 100425, 103104, 103250, 103251, 103237, 103107, 103253, 103254, 
103240, 103092, 103105, 103252, 103239
37029, 100381, 100385, 100429, 100425, 32324, 32325, 32336, 32335, 103107, 103253, 103254, 103240, 32777, 32799, 32800, 
32797, 103095, 103108, 103255, 103242
37030, 14090, 14091, 14102, 14101, 100382, 100386, 100430, 100426, 14544, 14566, 14567, 14564, 103111, 103257, 103258, 
103244, 103096, 103109, 103256, 103243
37031, 100382, 100386, 100430, 100426, 100383, 100387, 100431, 100427, 103111, 103257, 103258, 103244, 103114, 103260, 103261, 
103247, 103099, 103112, 103259, 103246
37032, 100383, 100387, 100431, 100427, 100384, 100388, 100432, 100428, 103114, 103260, 103261, 103247, 103117, 103263, 103264, 
103250, 103102, 103115, 103262, 103249
37033, 100384, 100388, 100432, 100428, 100385, 100389, 100433, 100429, 103117, 103263, 103264, 103250, 103120, 103266, 103267, 
103253, 103105, 103118, 103265, 103252
37034, 100385, 100389, 100433, 100429, 32325, 32326, 32337, 32336, 103120, 103266, 103267, 103253, 32779, 32801, 32802, 
32799, 103108, 103121, 103268, 103255
37035, 14091, 14092, 14103, 14102, 100386, 100390, 100434, 100430, 14546, 14568, 14569, 14566, 103124, 103270, 103271, 
103257, 103109, 103122, 103269, 103256
37036, 100386, 100390, 100434, 100430, 100387, 100391, 100435, 100431, 103124, 103270, 103271, 103257, 103127, 103273, 103274, 
103260, 103112, 103125, 103272, 103259
37037, 100387, 100391, 100435, 100431, 100388, 100392, 100436, 100432, 103127, 103273, 103274, 103260, 103130, 103276, 103277, 
103263, 103115, 103128, 103275, 103262
37038, 100388, 100392, 100436, 100432, 100389, 100393, 100437, 100433, 103130, 103276, 103277, 103263, 103133, 103279, 103280, 
103266, 103118, 103131, 103278, 103265
37039, 100389, 100393, 100437, 100433, 32326, 32327, 32338, 32337, 103133, 103279, 103280, 103266, 32781, 32803, 32804, 
32801, 103121, 103134, 103281, 103268
37040, 14092, 14093, 14104, 14103, 100390, 100394, 100438, 100434, 14548, 14570, 14571, 14568, 103137, 103283, 103284, 
103270, 103122, 103135, 103282, 103269
37041, 100390, 100394, 100438, 100434, 100391, 100395, 100439, 100435, 103137, 103283, 103284, 103270, 103140, 103286, 103287, 
103273, 103125, 103138, 103285, 103272
37042, 100391, 100395, 100439, 100435, 100392, 100396, 100440, 100436, 103140, 103286, 103287, 103273, 103143, 103289, 103290, 
103276, 103128, 103141, 103288, 103275
37043, 100392, 100396, 100440, 100436, 100393, 100397, 100441, 100437, 103143, 103289, 103290, 103276, 103146, 103292, 103293, 
103279, 103131, 103144, 103291, 103278
37044, 100393, 100397, 100441, 100437, 32327, 32328, 32339, 32338, 103146, 103292, 103293, 103279, 32783, 32805, 32806, 
32803, 103134, 103147, 103294, 103281
37045, 14093, 14094, 14105, 14104, 100394, 100398, 100442, 100438, 14550, 14572, 14573, 14570, 103150, 103296, 103297, 
103283, 103135, 103148, 103295, 103282
37046, 100394, 100398, 100442, 100438, 100395, 100399, 100443, 100439, 103150, 103296, 103297, 103283, 103153, 103299, 103300, 
103286, 103138, 103151, 103298, 103285
37047, 100395, 100399, 100443, 100439, 100396, 100400, 100444, 100440, 103153, 103299, 103300, 103286, 103156, 103302, 103303, 
103289, 103141, 103154, 103301, 103288
37048, 100396, 100400, 100444, 100440, 100397, 100401, 100445, 100441, 103156, 103302, 103303, 103289, 103159, 103305, 103306, 
103292, 103144, 103157, 103304, 103291
37049, 100397, 100401, 100445, 100441, 32328, 32329, 32340, 32339, 103159, 103305, 103306, 103292, 32785, 32807, 32808, 
32805, 103147, 103160, 103307, 103294
37050, 14094, 1119, 1120, 14105, 100398, 31757, 31761, 100442, 14551, 1143, 14574, 14572, 103161, 31939, 103308, 
103296, 103148, 31929, 31938, 103295
37051, 100398, 31757, 31761, 100442, 100399, 31758, 31762, 100443, 103161, 31939, 103308, 103296, 103162, 31941, 103309, 
103299, 103151, 31931, 31940, 103298
37052, 100399, 31758, 31762, 100443, 100400, 31759, 31763, 100444, 103162, 31941, 103309, 103299, 103163, 31943, 103310, 
103302, 103154, 31933, 31942, 103301
37053, 100400, 31759, 31763, 100444, 100401, 31760, 31764, 100445, 103163, 31943, 103310, 103302, 103164, 31945, 103311, 
103305, 103157, 31935, 31944, 103304
37054, 100401, 31760, 31764, 100445, 32329, 3301, 3302, 32340, 103164, 31945, 103311, 103305, 32786, 3325, 32809, 
32807, 103160, 31937, 31946, 103307
37055, 1040, 14095, 14106, 1041, 31311, 100402, 100446, 31315, 14553, 14575, 14576, 1064, 103167, 103313, 103314, 
31497, 31489, 103165, 103312, 31498
37056, 31311, 100402, 100446, 31315, 31312, 100403, 100447, 31316, 103167, 103313, 103314, 31497, 103170, 103316, 103317, 
31499, 31491, 103168, 103315, 31500
37057, 31312, 100403, 100447, 31316, 31313, 100404, 100448, 31317, 103170, 103316, 103317, 31499, 103173, 103319, 103320, 
31501, 31493, 103171, 103318, 31502
37058, 31313, 100404, 100448, 31317, 31314, 100405, 100449, 31318, 103173, 103319, 103320, 31501, 103176, 103322, 103323, 
31503, 31495, 103174, 103321, 31504
37059, 31314, 100405, 100449, 31318, 3214, 32330, 32341, 3215, 103176, 103322, 103323, 31503, 32788, 32810, 32811, 
3238, 31496, 103177, 103324, 31505
37060, 14095, 14096, 14107, 14106, 100402, 100406, 100450, 100446, 14555, 14577, 14578, 14575, 103180, 103326, 103327, 
103313, 103165, 103178, 103325, 103312
37061, 100402, 100406, 100450, 100446, 100403, 100407, 100451, 100447, 103180, 103326, 103327, 103313, 103183, 103329, 103330, 
103316, 103168, 103181, 103328, 103315
37062, 100403, 100407, 100451, 100447, 100404, 100408, 100452, 100448, 103183, 103329, 103330, 103316, 103186, 103332, 103333, 
103319, 103171, 103184, 103331, 103318
37063, 100404, 100408, 100452, 100448, 100405, 100409, 100453, 100449, 103186, 103332, 103333, 103319, 103189, 103335, 103336, 
103322, 103174, 103187, 103334, 103321
37064, 100405, 100409, 100453, 100449, 32330, 32331, 32342, 32341, 103189, 103335, 103336, 103322, 32790, 32812, 32813, 
32810, 103177, 103190, 103337, 103324
37065, 14096, 14097, 14108, 14107, 100406, 100410, 100454, 100450, 14557, 14579, 14580, 14577, 103193, 103339, 103340, 
103326, 103178, 103191, 103338, 103325
37066, 100406, 100410, 100454, 100450, 100407, 100411, 100455, 100451, 103193, 103339, 103340, 103326, 103196, 103342, 103343, 
103329, 103181, 103194, 103341, 103328
37067, 100407, 100411, 100455, 100451, 100408, 100412, 100456, 100452, 103196, 103342, 103343, 103329, 103199, 103345, 103346, 
103332, 103184, 103197, 103344, 103331
37068, 100408, 100412, 100456, 100452, 100409, 100413, 100457, 100453, 103199, 103345, 103346, 103332, 103202, 103348, 103349, 
103335, 103187, 103200, 103347, 103334
37069, 100409, 100413, 100457, 100453, 32331, 32332, 32343, 32342, 103202, 103348, 103349, 103335, 32792, 32814, 32815, 
32812, 103190, 103203, 103350, 103337
37070, 14097, 14098, 14109, 14108, 100410, 100414, 100458, 100454, 14559, 14581, 14582, 14579, 103206, 103352, 103353, 
103339, 103191, 103204, 103351, 103338
37071, 100410, 100414, 100458, 100454, 100411, 100415, 100459, 100455, 103206, 103352, 103353, 103339, 103209, 103355, 103356, 
103342, 103194, 103207, 103354, 103341
37072, 100411, 100415, 100459, 100455, 100412, 100416, 100460, 100456, 103209, 103355, 103356, 103342, 103212, 103358, 103359, 
103345, 103197, 103210, 103357, 103344
37073, 100412, 100416, 100460, 100456, 100413, 100417, 100461, 100457, 103212, 103358, 103359, 103345, 103215, 103361, 103362, 
103348, 103200, 103213, 103360, 103347
37074, 100413, 100417, 100461, 100457, 32332, 32333, 32344, 32343, 103215, 103361, 103362, 103348, 32794, 32816, 32817, 
32814, 103203, 103216, 103363, 103350
37075, 14098, 14099, 14110, 14109, 100414, 100418, 100462, 100458, 14561, 14583, 14584, 14581, 103219, 103365, 103366, 
103352, 103204, 103217, 103364, 103351
37076, 100414, 100418, 100462, 100458, 100415, 100419, 100463, 100459, 103219, 103365, 103366, 103352, 103222, 103368, 103369, 
103355, 103207, 103220, 103367, 103354
37077, 100415, 100419, 100463, 100459, 100416, 100420, 100464, 100460, 103222, 103368, 103369, 103355, 103225, 103371, 103372, 
103358, 103210, 103223, 103370, 103357
37078, 100416, 100420, 100464, 100460, 100417, 100421, 100465, 100461, 103225, 103371, 103372, 103358, 103228, 103374, 103375, 
103361, 103213, 103226, 103373, 103360
37079, 100417, 100421, 100465, 100461, 32333, 32334, 32345, 32344, 103228, 103374, 103375, 103361, 32796, 32818, 32819, 
32816, 103216, 103229, 103376, 103363
37080, 14099, 14100, 14111, 14110, 100418, 100422, 100466, 100462, 14563, 14585, 14586, 14583, 103232, 103378, 103379, 
103365, 103217, 103230, 103377, 103364
37081, 100418, 100422, 100466, 100462, 100419, 100423, 100467, 100463, 103232, 103378, 103379, 103365, 103235, 103381, 103382, 
103368, 103220, 103233, 103380, 103367
37082, 100419, 100423, 100467, 100463, 100420, 100424, 100468, 100464, 103235, 103381, 103382, 103368, 103238, 103384, 103385, 
103371, 103223, 103236, 103383, 103370
37083, 100420, 100424, 100468, 100464, 100421, 100425, 100469, 100465, 103238, 103384, 103385, 103371, 103241, 103387, 103388, 
103374, 103226, 103239, 103386, 103373
37084, 100421, 100425, 100469, 100465, 32334, 32335, 32346, 32345, 103241, 103387, 103388, 103374, 32798, 32820, 32821, 
32818, 103229, 103242, 103389, 103376
37085, 14100, 14101, 14112, 14111, 100422, 100426, 100470, 100466, 14565, 14587, 14588, 14585, 103245, 103391, 103392, 
103378, 103230, 103243, 103390, 103377
37086, 100422, 100426, 100470, 100466, 100423, 100427, 100471, 100467, 103245, 103391, 103392, 103378, 103248, 103394, 103395, 
103381, 103233, 103246, 103393, 103380
37087, 100423, 100427, 100471, 100467, 100424, 100428, 100472, 100468, 103248, 103394, 103395, 103381, 103251, 103397, 103398, 
103384, 103236, 103249, 103396, 103383
37088, 100424, 100428, 100472, 100468, 100425, 100429, 100473, 100469, 103251, 103397, 103398, 103384, 103254, 103400, 103401, 
103387, 103239, 103252, 103399, 103386
37089, 100425, 100429, 100473, 100469, 32335, 32336, 32347, 32346, 103254, 103400, 103401, 103387, 32800, 32822, 32823, 
32820, 103242, 103255, 103402, 103389
37090, 14101, 14102, 14113, 14112, 100426, 100430, 100474, 100470, 14567, 14589, 14590, 14587, 103258, 103404, 103405, 
103391, 103243, 103256, 103403, 103390
37091, 100426, 100430, 100474, 100470, 100427, 100431, 100475, 100471, 103258, 103404, 103405, 103391, 103261, 103407, 103408, 
103394, 103246, 103259, 103406, 103393
37092, 100427, 100431, 100475, 100471, 100428, 100432, 100476, 100472, 103261, 103407, 103408, 103394, 103264, 103410, 103411, 
103397, 103249, 103262, 103409, 103396
37093, 100428, 100432, 100476, 100472, 100429, 100433, 100477, 100473, 103264, 103410, 103411, 103397, 103267, 103413, 103414, 
103400, 103252, 103265, 103412, 103399
37094, 100429, 100433, 100477, 100473, 32336, 32337, 32348, 32347, 103267, 103413, 103414, 103400, 32802, 32824, 32825, 
32822, 103255, 103268, 103415, 103402
37095, 14102, 14103, 14114, 14113, 100430, 100434, 100478, 100474, 14569, 14591, 14592, 14589, 103271, 103417, 103418, 
103404, 103256, 103269, 103416, 103403
37096, 100430, 100434, 100478, 100474, 100431, 100435, 100479, 100475, 103271, 103417, 103418, 103404, 103274, 103420, 103421, 
103407, 103259, 103272, 103419, 103406
37097, 100431, 100435, 100479, 100475, 100432, 100436, 100480, 100476, 103274, 103420, 103421, 103407, 103277, 103423, 103424, 
103410, 103262, 103275, 103422, 103409
37098, 100432, 100436, 100480, 100476, 100433, 100437, 100481, 100477, 103277, 103423, 103424, 103410, 103280, 103426, 103427, 
103413, 103265, 103278, 103425, 103412
37099, 100433, 100437, 100481, 100477, 32337, 32338, 32349, 32348, 103280, 103426, 103427, 103413, 32804, 32826, 32827, 
32824, 103268, 103281, 103428, 103415
37100, 14103, 14104, 14115, 14114, 100434, 100438, 100482, 100478, 14571, 14593, 14594, 14591, 103284, 103430, 103431, 
103417, 103269, 103282, 103429, 103416
37101, 100434, 100438, 100482, 100478, 100435, 100439, 100483, 100479, 103284, 103430, 103431, 103417, 103287, 103433, 103434, 
103420, 103272, 103285, 103432, 103419
37102, 100435, 100439, 100483, 100479, 100436, 100440, 100484, 100480, 103287, 103433, 103434, 103420, 103290, 103436, 103437, 
103423, 103275, 103288, 103435, 103422
37103, 100436, 100440, 100484, 100480, 100437, 100441, 100485, 100481, 103290, 103436, 103437, 103423, 103293, 103439, 103440, 
103426, 103278, 103291, 103438, 103425
37104, 100437, 100441, 100485, 100481, 32338, 32339, 32350, 32349, 103293, 103439, 103440, 103426, 32806, 32828, 32829, 
32826, 103281, 103294, 103441, 103428
37105, 14104, 14105, 14116, 14115, 100438, 100442, 100486, 100482, 14573, 14595, 14596, 14593, 103297, 103443, 103444, 
103430, 103282, 103295, 103442, 103429
37106, 100438, 100442, 100486, 100482, 100439, 100443, 100487, 100483, 103297, 103443, 103444, 103430, 103300, 103446, 103447, 
103433, 103285, 103298, 103445, 103432
37107, 100439, 100443, 100487, 100483, 100440, 100444, 100488, 100484, 103300, 103446, 103447, 103433, 103303, 103449, 103450, 
103436, 103288, 103301, 103448, 103435
37108, 100440, 100444, 100488, 100484, 100441, 100445, 100489, 100485, 103303, 103449, 103450, 103436, 103306, 103452, 103453, 
103439, 103291, 103304, 103451, 103438
37109, 100441, 100445, 100489, 100485, 32339, 32340, 32351, 32350, 103306, 103452, 103453, 103439, 32808, 32830, 32831, 
32828, 103294, 103307, 103454, 103441
37110, 14105, 1120, 1121, 14116, 100442, 31761, 31765, 100486, 14574, 1144, 14597, 14595, 103308, 31948, 103455, 
103443, 103295, 31938, 31947, 103442
37111, 100442, 31761, 31765, 100486, 100443, 31762, 31766, 100487, 103308, 31948, 103455, 103443, 103309, 31950, 103456, 
103446, 103298, 31940, 31949, 103445
37112, 100443, 31762, 31766, 100487, 100444, 31763, 31767, 100488, 103309, 31950, 103456, 103446, 103310, 31952, 103457, 
103449, 103301, 31942, 31951, 103448
37113, 100444, 31763, 31767, 100488, 100445, 31764, 31768, 100489, 103310, 31952, 103457, 103449, 103311, 31954, 103458, 
103452, 103304, 31944, 31953, 103451
37114, 100445, 31764, 31768, 100489, 32340, 3302, 3303, 32351, 103311, 31954, 103458, 103452, 32809, 3326, 32832, 
32830, 103307, 31946, 31955, 103454
37115, 1041, 14106, 14117, 1042, 31315, 100446, 100490, 31319, 14576, 14598, 14599, 1065, 103314, 103460, 103461, 
31506, 31498, 103312, 103459, 31507
37116, 31315, 100446, 100490, 31319, 31316, 100447, 100491, 31320, 103314, 103460, 103461, 31506, 103317, 103463, 103464, 
31508, 31500, 103315, 103462, 31509
37117, 31316, 100447, 100491, 31320, 31317, 100448, 100492, 31321, 103317, 103463, 103464, 31508, 103320, 103466, 103467, 
31510, 31502, 103318, 103465, 31511
37118, 31317, 100448, 100492, 31321, 31318, 100449, 100493, 31322, 103320, 103466, 103467, 31510, 103323, 103469, 103470, 
31512, 31504, 103321, 103468, 31513
37119, 31318, 100449, 100493, 31322, 3215, 32341, 32352, 3216, 103323, 103469, 103470, 31512, 32811, 32833, 32834, 
3239, 31505, 103324, 103471, 31514
37120, 14106, 14107, 14118, 14117, 100446, 100450, 100494, 100490, 14578, 14600, 14601, 14598, 103327, 103473, 103474, 
103460, 103312, 103325, 103472, 103459
37121, 100446, 100450, 100494, 100490, 100447, 100451, 100495, 100491, 103327, 103473, 103474, 103460, 103330, 103476, 103477, 
103463, 103315, 103328, 103475, 103462
37122, 100447, 100451, 100495, 100491, 100448, 100452, 100496, 100492, 103330, 103476, 103477, 103463, 103333, 103479, 103480, 
103466, 103318, 103331, 103478, 103465
37123, 100448, 100452, 100496, 100492, 100449, 100453, 100497, 100493, 103333, 103479, 103480, 103466, 103336, 103482, 103483, 
103469, 103321, 103334, 103481, 103468
37124, 100449, 100453, 100497, 100493, 32341, 32342, 32353, 32352, 103336, 103482, 103483, 103469, 32813, 32835, 32836, 
32833, 103324, 103337, 103484, 103471
37125, 14107, 14108, 14119, 14118, 100450, 100454, 100498, 100494, 14580, 14602, 14603, 14600, 103340, 103486, 103487, 
103473, 103325, 103338, 103485, 103472
37126, 100450, 100454, 100498, 100494, 100451, 100455, 100499, 100495, 103340, 103486, 103487, 103473, 103343, 103489, 103490, 
103476, 103328, 103341, 103488, 103475
37127, 100451, 100455, 100499, 100495, 100452, 100456, 100500, 100496, 103343, 103489, 103490, 103476, 103346, 103492, 103493, 
103479, 103331, 103344, 103491, 103478
37128, 100452, 100456, 100500, 100496, 100453, 100457, 100501, 100497, 103346, 103492, 103493, 103479, 103349, 103495, 103496, 
103482, 103334, 103347, 103494, 103481
37129, 100453, 100457, 100501, 100497, 32342, 32343, 32354, 32353, 103349, 103495, 103496, 103482, 32815, 32837, 32838, 
32835, 103337, 103350, 103497, 103484
37130, 14108, 14109, 14120, 14119, 100454, 100458, 100502, 100498, 14582, 14604, 14605, 14602, 103353, 103499, 103500, 
103486, 103338, 103351, 103498, 103485
37131, 100454, 100458, 100502, 100498, 100455, 100459, 100503, 100499, 103353, 103499, 103500, 103486, 103356, 103502, 103503, 
103489, 103341, 103354, 103501, 103488
37132, 100455, 100459, 100503, 100499, 100456, 100460, 100504, 100500, 103356, 103502, 103503, 103489, 103359, 103505, 103506, 
103492, 103344, 103357, 103504, 103491
37133, 100456, 100460, 100504, 100500, 100457, 100461, 100505, 100501, 103359, 103505, 103506, 103492, 103362, 103508, 103509, 
103495, 103347, 103360, 103507, 103494
37134, 100457, 100461, 100505, 100501, 32343, 32344, 32355, 32354, 103362, 103508, 103509, 103495, 32817, 32839, 32840, 
32837, 103350, 103363, 103510, 103497
37135, 14109, 14110, 14121, 14120, 100458, 100462, 100506, 100502, 14584, 14606, 14607, 14604, 103366, 103512, 103513, 
103499, 103351, 103364, 103511, 103498
37136, 100458, 100462, 100506, 100502, 100459, 100463, 100507, 100503, 103366, 103512, 103513, 103499, 103369, 103515, 103516, 
103502, 103354, 103367, 103514, 103501
37137, 100459, 100463, 100507, 100503, 100460, 100464, 100508, 100504, 103369, 103515, 103516, 103502, 103372, 103518, 103519, 
103505, 103357, 103370, 103517, 103504
37138, 100460, 100464, 100508, 100504, 100461, 100465, 100509, 100505, 103372, 103518, 103519, 103505, 103375, 103521, 103522, 
103508, 103360, 103373, 103520, 103507
37139, 100461, 100465, 100509, 100505, 32344, 32345, 32356, 32355, 103375, 103521, 103522, 103508, 32819, 32841, 32842, 
32839, 103363, 103376, 103523, 103510
37140, 14110, 14111, 14122, 14121, 100462, 100466, 100510, 100506, 14586, 14608, 14609, 14606, 103379, 103525, 103526, 
103512, 103364, 103377, 103524, 103511
37141, 100462, 100466, 100510, 100506, 100463, 100467, 100511, 100507, 103379, 103525, 103526, 103512, 103382, 103528, 103529, 
103515, 103367, 103380, 103527, 103514
37142, 100463, 100467, 100511, 100507, 100464, 100468, 100512, 100508, 103382, 103528, 103529, 103515, 103385, 103531, 103532, 
103518, 103370, 103383, 103530, 103517
37143, 100464, 100468, 100512, 100508, 100465, 100469, 100513, 100509, 103385, 103531, 103532, 103518, 103388, 103534, 103535, 
103521, 103373, 103386, 103533, 103520
37144, 100465, 100469, 100513, 100509, 32345, 32346, 32357, 32356, 103388, 103534, 103535, 103521, 32821, 32843, 32844, 
32841, 103376, 103389, 103536, 103523
37145, 14111, 14112, 14123, 14122, 100466, 100470, 100514, 100510, 14588, 14610, 14611, 14608, 103392, 103538, 103539, 
103525, 103377, 103390, 103537, 103524
37146, 100466, 100470, 100514, 100510, 100467, 100471, 100515, 100511, 103392, 103538, 103539, 103525, 103395, 103541, 103542, 
103528, 103380, 103393, 103540, 103527
37147, 100467, 100471, 100515, 100511, 100468, 100472, 100516, 100512, 103395, 103541, 103542, 103528, 103398, 103544, 103545, 
103531, 103383, 103396, 103543, 103530
37148, 100468, 100472, 100516, 100512, 100469, 100473, 100517, 100513, 103398, 103544, 103545, 103531, 103401, 103547, 103548, 
103534, 103386, 103399, 103546, 103533
37149, 100469, 100473, 100517, 100513, 32346, 32347, 32358, 32357, 103401, 103547, 103548, 103534, 32823, 32845, 32846, 
32843, 103389, 103402, 103549, 103536
37150, 14112, 14113, 14124, 14123, 100470, 100474, 100518, 100514, 14590, 14612, 14613, 14610, 103405, 103551, 103552, 
103538, 103390, 103403, 103550, 103537
37151, 100470, 100474, 100518, 100514, 100471, 100475, 100519, 100515, 103405, 103551, 103552, 103538, 103408, 103554, 103555, 
103541, 103393, 103406, 103553, 103540
37152, 100471, 100475, 100519, 100515, 100472, 100476, 100520, 100516, 103408, 103554, 103555, 103541, 103411, 103557, 103558, 
103544, 103396, 103409, 103556, 103543
37153, 100472, 100476, 100520, 100516, 100473, 100477, 100521, 100517, 103411, 103557, 103558, 103544, 103414, 103560, 103561, 
103547, 103399, 103412, 103559, 103546
37154, 100473, 100477, 100521, 100517, 32347, 32348, 32359, 32358, 103414, 103560, 103561, 103547, 32825, 32847, 32848, 
32845, 103402, 103415, 103562, 103549
37155, 14113, 14114, 14125, 14124, 100474, 100478, 100522, 100518, 14592, 14614, 14615, 14612, 103418, 103564, 103565, 
103551, 103403, 103416, 103563, 103550
37156, 100474, 100478, 100522, 100518, 100475, 100479, 100523, 100519, 103418, 103564, 103565, 103551, 103421, 103567, 103568, 
103554, 103406, 103419, 103566, 103553
37157, 100475, 100479, 100523, 100519, 100476, 100480, 100524, 100520, 103421, 103567, 103568, 103554, 103424, 103570, 103571, 
103557, 103409, 103422, 103569, 103556
37158, 100476, 100480, 100524, 100520, 100477, 100481, 100525, 100521, 103424, 103570, 103571, 103557, 103427, 103573, 103574, 
103560, 103412, 103425, 103572, 103559
